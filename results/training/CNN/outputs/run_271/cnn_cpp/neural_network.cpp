#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16765261f, 0.34148175f, 0.78693438f, 0.65847838f, 0.27338848f, -0.17282405f, 0.30429754f, -0.64086139f, 
    0.05840737f, -0.21896221f, -0.09966323f, 0.29344413f, 0.25401092f, 0.29213160f, 0.11076295f, 0.36565843f, 
    0.43692744f, -0.13907829f, 0.19428393f, -0.14034705f, 0.05184389f, 0.27811107f, 0.37112018f, -0.08760758f, 
    0.28340417f, -1.41729975f, -0.03856074f, 0.04153543f, 0.78219187f, -1.05484867f, 0.42297831f, 1.16155624f, 
    -0.27952313f, 0.31466398f, 0.12682503f, -0.15105462f, -0.13066180f, -0.10319091f, -0.21337853f, -0.31938201f, 
    0.14283828f, 0.27597868f, 0.00577392f, -0.15162668f, -0.15311036f, 0.15353335f, 0.02121438f, -0.04545917f, 
    0.03287509f, 0.05255558f, 0.98329413f, 0.34161615f, 0.77664971f, 0.16163942f, -0.31980494f, 0.67524201f, 
    -0.45603579f, 0.55221349f, 0.61031860f, -0.05913411f, -0.16176869f, 0.08790796f, -0.15875724f, -0.59119529f, 
    -0.07074203f, -0.18069297f, -0.06825456f, -0.13612945f, -0.07262490f, 0.13938777f, -0.32634762f, -0.30625150f, 
    0.25216538f, 0.27550665f, -0.51973951f, 1.51230490f, 0.62999201f, -0.87710959f, 0.76559222f, -0.51008403f, 
    -0.40796793f, 0.14104219f, 0.23992264f, 0.63261163f, -0.10410794f, -0.26552573f, -0.39218080f, 0.16160604f, 
    -0.25307539f, -0.15690911f, 0.03503022f, -0.16854404f, -0.41260165f, -0.33017707f, 0.04239801f, -0.12671153f, 
    -0.20571463f, -0.29848167f, -0.05344837f, -0.12303319f, -0.39817530f, 0.73601168f, -0.07694552f, -0.19055183f, 
    0.44270632f, -0.21840484f, -0.81757206f, 0.64287639f, 0.40611890f, -0.37673888f, -0.51330537f, -0.13004906f, 
    -0.36038962f, -0.08845314f, -0.15499474f, -0.11842959f, 0.36382970f, -0.52740169f, 0.01226768f, 0.01983313f, 
    -0.38030708f, 0.59737396f, 0.14358689f, 0.69692492f, -0.34638384f, 1.00798285f, 0.10148796f, -0.16147988f, 
    1.20300114f, -0.00611342f, 0.71920037f, 0.67832357f, 0.34963086f, 0.45524934f, 0.72308952f, -0.57165909f, 
    0.11802752f, 0.06164246f, 0.17563002f, -0.15916853f, -0.17584462f, -0.30959883f, -0.02593735f, -0.08390085f, 
    -0.10876936f, -0.02854685f, -0.31227580f, -0.09759728f, -0.03434757f, -0.17771403f, 1.17621791f, 0.61847663f, 
    0.81898743f, 1.23598242f, 1.04037392f, 0.00359692f, 0.32445815f, -0.11334320f, -0.04539287f, 0.19464161f, 
    -0.23576854f, -0.40345189f, -0.34635574f, -0.25870332f, -0.04406283f, -0.32747877f, 0.11024545f, 0.16008282f, 
    0.18451613f, 0.30763718f, 0.31162229f, 0.18021601f, 0.10047112f, -0.05573434f, 0.01046978f, -1.03777397f, 
    0.82389832f, -0.44151512f, -0.87282747f, -0.90203190f, 1.22747850f, 0.06655678f, -0.62803179f, 0.61070752f, 
    0.45343885f, 0.24397624f, -0.29154521f, -0.07991632f, 0.10883014f, -0.11255231f, 0.18723950f, 0.00757143f, 
    0.10495505f, 0.07746021f, 0.25992808f, -0.15423930f, -0.27458730f, 0.08006688f, -0.17010996f, 0.31256956f, 
    0.41104186f, -0.92233872f, -1.19935691f, -0.85761011f, -0.23463066f, -0.66592258f, 0.33023775f, 0.24591152f, 
    0.09666507f, 0.53736973f, 0.38067564f, -0.21617311f, -0.03140977f, 0.04330454f, 0.07525895f, -0.01090936f, 
    0.20724380f, -0.12192778f, -0.06902023f, -0.07164687f, 0.08556453f, 0.07734483f, 0.36493802f, 0.14478570f, 
    0.45583689f, -0.54107094f, -0.59314501f, -1.18266547f, -0.10797776f, -0.58403778f, 0.52755696f, 0.25503543f, 
    -0.77837986f, 0.39534989f, -0.15450126f, -0.37338769f, 0.55431843f, 0.04008646f, 0.42473763f, 0.11667240f, 
    0.18981791f, 0.05042977f, -0.10138729f, 0.30006078f, -0.37799922f, -0.04807367f, 0.00378205f, 0.02586433f, 
    -0.19087027f, -0.03042291f, -1.16428638f, -1.44952226f, 0.51281112f, 0.19814137f, -0.53421456f, 0.64551890f, 
    0.43542963f, 0.41105926f, -0.27940974f, 0.10624939f, -0.27663666f, -0.10646596f, 0.15594862f, 0.39222068f, 
    0.42290348f, -0.25052062f, 0.10981554f, -0.19327684f, -0.22944264f, 0.08978021f, 0.03235769f, -0.06347334f, 
    -0.18659915f, -0.03166720f, -0.16506481f, -1.06028426f, 1.09590507f, 0.82974035f, -1.06364036f, 0.72423440f, 
    0.05121442f, -0.26553470f, -0.42091849f, -1.11286294f, -0.38233483f, 0.06986187f, 0.06301288f, 0.36602047f, 
    0.33365300f, -0.26701638f, 0.23303878f, 0.21110711f, 0.18190961f, -0.12017526f, -0.06111410f, -0.00125251f, 
    -0.04782951f, 0.07678023f, 0.18378423f, 0.21802452f, -0.03895932f, 1.12246108f, 0.80435222f, -0.28346691f, 
    -0.07616849f, -0.66694003f, 0.80627245f, 0.17839332f, 0.15699305f, 0.50803077f, -0.27560851f, 0.54258043f, 
    0.32227969f, 0.26976404f, 0.40768465f, 0.11443614f, -0.43230313f, 0.11972852f, 0.39352387f, 0.24636358f, 
    0.00177002f, 0.13044009f, 0.26261353f, 0.08594627f, 0.09260821f, 0.29425523f, -0.15219572f, 0.14482068f, 
    -0.89889014f, -0.49459764f, 0.74152172f, 0.52935934f, -0.17637703f, 0.65373766f, 0.51329333f, 0.40573511f, 
    -0.38547570f, -0.33703077f, -0.24396753f, -0.64043850f, 0.12632780f, 0.10404521f, 0.16324349f, 0.09775937f, 
    -0.35119304f, -0.02686108f, 0.08929018f, -0.25179213f, -0.35285261f, 0.04379288f, -0.67613411f, 0.77780926f, 
    -0.48791426f, 0.32487878f, 0.23261467f, 0.94825244f, -0.53918862f, 0.20892175f, -0.62355518f, -0.47152761f, 
    -0.23242375f, 0.25315064f, 0.19414666f, 0.29339349f, 0.17489240f, -0.16209994f, -0.35486642f, -0.39289606f, 
    -0.18725216f, 0.27023742f, 0.40815961f, -0.04312790f, 0.14172536f, -0.24611096f, -0.35733387f, 1.03774035f, 
    0.52957618f, 0.19214214f, 1.04916024f, 0.82826519f, -0.19606766f, -0.63866222f, 0.17864195f, -0.67703694f, 
    -0.28462073f, -0.00424988f, 0.51268512f, -0.04258100f, 0.31150955f, -0.18128635f, 0.17796469f, -0.14796755f, 
    0.11109512f, 0.10705412f, 0.23153770f, -0.26545435f, -0.16204000f, -0.20989494f, 0.17994322f, 0.05630933f, 
    0.09867499f, 0.73270851f, 0.80260026f, -0.26087880f, -0.82632065f, -1.00972116f, -0.14435740f, 0.26471305f, 
    -0.28270549f, -0.56877875f, -0.32635576f, 0.35965997f, -0.64663577f, -0.46439531f, -0.57275122f, -0.60072768f, 
    -0.42577401f, -0.25048399f, -0.16643259f, 0.00807984f, 0.17429316f, -0.26729563f, -0.36920181f, -0.19124739f, 
    -0.03021416f, 0.96630931f, 1.03395343f, 0.42501491f, -0.04480972f, 0.14091210f, -0.16309258f, -0.76586986f, 
    0.09678489f, -0.00056377f, 0.56545961f, 0.57576656f, 0.10313945f, 0.19600160f, -0.22310521f, -0.43315652f, 
    -0.19631210f, -0.25118688f, 0.24190003f, -0.00448968f, -0.25331715f, 0.11663146f, 0.22447324f, 0.32784519f, 
    0.45308796f, -0.12105545f, -0.15454100f, -1.64770126f, 0.23824345f, 0.85160315f, 0.58309847f, -0.00183967f, 
    0.71301764f, 0.29275522f, 0.03410825f, 0.28866825f, 0.24111769f, -0.02476573f, -0.34105659f, 0.20618777f, 
    -0.16383019f, -0.45486555f, -0.13476633f, 0.19015864f, 0.43617767f, -0.27557501f, -0.34072760f, -0.00980516f, 
    0.01225101f, 0.04443469f, -0.35712638f, 1.25399542f, 0.84568131f, -0.47592878f, -0.84715801f, -0.43559700f, 
    0.70199680f, 0.12738055f, -0.54039168f, -0.18451135f, 0.28710893f, 0.49831513f, 0.00062857f, 0.08885643f, 
    0.45452198f, -0.30537513f, 0.33595172f, 0.38793993f, -0.18861344f, 0.17554586f, 0.38246384f, 0.13855423f, 
    0.16377516f, -0.23485211f, -0.17087971f, 0.38792992f, -0.35006425f, -0.65467715f, -0.72479761f, -0.42586422f, 
    -0.43275768f, 0.29222757f, 0.99141085f, 0.65154761f, 0.03968574f, 0.49327174f, -0.79563552f, -0.13643482f, 
    -0.51136976f, -0.26657450f, 0.05005395f, -0.61778712f, 0.17176862f, -0.32448179f, -0.13200065f, -0.20105971f, 
    -0.24872372f, -0.20532584f, -0.32434198f, -0.25848204f, 0.17427464f, 0.58034611f, -0.44252264f, -0.86644316f, 
    -0.62135941f, 0.61104411f, -0.24095437f, -0.54241508f, -0.92547703f, -0.51464570f, -0.01165640f, -0.39467245f, 
    0.30851233f, 0.54495424f, 0.18231699f, 0.15079127f, -0.41885850f, -0.12265478f, -0.16488457f, -0.03179023f, 
    0.07145383f, 0.06503015f, 0.17713693f, 0.56944823f, -0.24756067f, -0.13068847f, 1.10338628f, 0.77568889f, 
    -0.11351710f, 0.07431921f, 0.66822916f, -0.60458428f, -0.65072095f, -0.36051467f, 0.73114669f, -0.45066190f, 
    -0.19827910f, -0.39916083f, 0.24983312f, 0.02110599f, 0.22414628f, 0.21235789f, -0.48217526f, -0.14083798f, 
    0.17992698f, -0.10076971f, 0.57407892f, -0.00497774f, 0.10318706f, -0.27103254f, 0.23904653f, 0.13575773f, 
    1.11283183f, -0.07765660f, 0.26594755f, -0.11849324f, -0.93551701f, 0.06913875f, -0.51379979f, -0.21587656f, 
    -0.70315659f, 0.21817778f, -0.35307050f, -0.37952349f, 0.16413598f, 0.59590346f, 0.22369587f, -0.24099040f, 
    -0.12219454f, 0.20498335f, 0.16676229f, -0.21264313f, -0.14259672f, -0.04913557f, -0.16806537f, 0.42011872f, 
    -0.37017235f, 0.19134992f, 0.46231920f, 0.04836707f, 0.46953604f, 0.28509691f, -0.66613132f, -1.22307730f, 
    -0.40412632f, -0.65643197f, 0.27018681f, 0.04064649f, 0.33890653f, 0.54272002f, -0.18356438f, -0.24039558f, 
    0.02639374f, 0.00035982f, 0.20055450f, 0.45221958f, 0.19910158f, 0.30170718f, 0.04758026f, 0.17603929f, 
    0.18111451f, 0.85207975f, 0.86687416f, 0.58129686f, -0.70102125f, -0.43741429f, 0.15803440f, -0.87518698f, 
    -0.13547826f, -0.49457711f, 0.65108818f, -0.00008927f, 0.09183566f, -0.16003145f, 0.10710097f, 0.51081777f, 
    -0.36956859f, -0.25041169f, -0.03498286f, -0.10689767f, -0.17750774f, -0.35641059f, 0.29706475f, -0.15617575f, 
    -0.07571452f, 0.06795755f, -0.33436292f, -0.61326128f, -0.60409665f, -0.83267444f, -0.28787792f, -0.48542604f, 
    -0.09138541f, -0.34271258f, -0.08724389f, -0.55195802f, -0.58570784f, 0.31108752f, -0.02872539f, -0.18657273f, 
    -0.16171557f, 0.45917806f, -0.39081553f, -0.01827890f, 0.41135719f, 0.12950185f, 0.10296384f, -0.03624393f, 
    -0.26516461f, -0.32148474f, 0.39393851f, -0.40575716f, -0.79338014f, -0.22604187f, -0.59689552f, -0.37263012f, 
    0.45984575f, 0.06370780f, -0.32661080f, -0.13929942f, -0.12812205f, -0.04265847f, -0.17719379f, -0.47441125f, 
    -0.20015427f, 0.04037793f, 0.02500464f, 0.49320969f, -0.38435352f, 0.13306926f, 0.22886872f, -0.04195459f, 
    -0.11462890f, 0.68265253f, 0.78036314f, -0.30397213f, -0.78073537f, 0.09904254f, 0.27751797f, 0.71010762f, 
    0.27755362f, -1.47842562f, 0.01330176f, 0.52235311f, -0.60071874f, -0.38003564f, 0.52823395f, 0.05893956f, 
    0.21341157f, 0.33077639f, 0.39624780f, -0.10108537f, 0.48284805f, 0.17490345f, -0.08159934f, 0.20557062f, 
    0.15109949f, -0.04318610f, -0.08394077f, 0.48431984f, -0.36945412f, -1.84114611f, 1.29373538f, 1.09376884f, 
    -0.99456382f, -0.32770243f, 0.03515313f, 0.75982416f, 0.14524147f, 0.18042275f, -0.32105643f, -0.23857202f, 
    0.26428267f, -0.21088983f, 0.01223776f, 0.09912226f, -0.18206835f, -0.19594343f, -0.13154274f, -0.11702403f, 
    -0.24986877f, 0.29391244f, 0.26799050f, 0.12590745f, 0.34649414f, 0.04190346f, 0.74961555f, 0.16782185f, 
    -0.96683151f, -0.17388475f, -0.68136901f, 0.20457171f, 0.85884649f, 0.60297483f, 0.46061543f, 0.66514969f, 
    0.09240796f, -0.14435606f, -0.09191483f, -0.13460791f, 0.14895013f, 0.13518788f, -0.11281896f, 0.08827650f, 
    0.22974309f, 0.20403504f, 0.45971751f, -0.16647212f, -0.20830676f, 0.17246798f, -0.26304042f, 0.97289890f, 
    0.71148491f, 0.92814797f, 0.35828191f, 0.54167211f, 0.36992574f, 0.06089637f, -0.07874681f, 0.14781062f, 
    -0.07164704f, 0.32968602f, 0.54444194f, -0.30360937f, 0.05232796f, 0.41000199f, 0.43249890f, -0.18369122f, 
    -0.25191149f, -0.35567716f, 0.26084244f, -0.57610244f, -0.20967117f, -0.01957200f, -0.11169190f, 0.28784242f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13727449f, 0.05578811f, 0.11623367f, 0.26825547f, 0.23373711f, 0.26843280f, 0.29638240f, 0.20370013f, 
    0.44704196f, 0.44096053f, 0.17468920f, 0.15625741f, 0.08828538f, 0.03575732f, 0.20079041f, -0.06332455f, 
    0.05946326f, 0.14931594f, 0.31711024f, 0.14515689f, 0.02255006f, 0.59751672f, 0.06345851f, 0.16751081f, 
    0.05733267f, 0.05927917f, 0.30603403f, 0.20623302f, 0.12113914f, 0.13687047f, 0.14903891f, 0.14610589f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08520149f, -0.13255826f, -0.19976152f, 0.03722337f, -0.12659357f, -0.14375050f, 0.00265020f, 0.09067558f, 
    -0.08781601f, 0.05555646f, -0.05236150f, -0.04611748f, 0.76123625f, 0.42444199f, 0.20983818f, 0.08541545f, 
    -0.02278210f, 0.05149472f, -0.07834487f, -0.01340459f, 0.01723634f, -0.12888810f, -0.08597470f, -0.04844882f, 
    0.10242971f, -0.05027616f, -0.10816614f, 0.17417671f, -0.26166224f, -0.03812718f, 0.05807951f, -0.04157043f, 
    -0.21982267f, -0.19545569f, -0.08308107f, 0.11325903f, -0.16733778f, -0.04398553f, -0.14870261f, 0.22103529f, 
    -0.11248041f, -0.04757866f, -0.03215102f, 0.03952513f, 0.06835562f, 0.02124166f, 0.19483031f, -0.03096275f, 
    -0.06086006f, 0.08240894f, 0.09208416f, 0.05624421f, 0.03263015f, 0.04264986f, -0.09221759f, -0.22129837f, 
    -0.06618441f, -0.14412697f, -0.01834013f, 0.00845148f, 0.12585613f, 0.02756006f, -0.25045061f, 0.37657136f, 
    -0.11085452f, 0.04819618f, -0.06967464f, -0.01339073f, -0.16100010f, 0.04136017f, 0.05067112f, -0.02468470f, 
    0.23425542f, -0.01972971f, 0.03694129f, 0.43149224f, -0.36760840f, 0.00476245f, 0.02123616f, 0.02915052f, 
    -0.04447262f, 0.00904101f, -0.04447808f, -0.02551683f, 0.74560434f, -0.18349895f, -0.24541028f, -0.20928252f, 
    -0.05612292f, -0.13505925f, 0.02988877f, 0.02510587f, 0.05594191f, -0.01061571f, 0.03150103f, 0.01243467f, 
    -0.24678360f, -0.06979662f, 0.05223722f, -0.37200138f, 0.02487239f, -0.01505816f, 0.09527203f, -0.06840733f, 
    -0.02627663f, -0.02304126f, -0.04244096f, 0.03117733f, 0.06707890f, -0.10356008f, 0.04932803f, -0.23522629f, 
    -0.10623787f, -0.18834625f, 0.04697588f, -0.09228361f, 0.03277337f, -0.10122404f, 0.09664031f, -0.02376378f, 
    -0.42266688f, 0.12630257f, 0.00698734f, 0.10663515f, 0.07568109f, -0.06451685f, -0.01630438f, 0.07721655f, 
    0.06462964f, -0.08514195f, 0.04887129f, -0.12392172f, -0.79162467f, 0.08254745f, 0.05913815f, -0.35995084f, 
    0.04710606f, 0.05215256f, 0.00687102f, 0.01961049f, 0.11070213f, -0.17606057f, -0.05801657f, 0.04142907f, 
    -0.25077894f, 0.00192020f, -0.05035308f, -0.14579396f, 0.10711182f, 0.16969769f, 0.02282052f, -0.08663057f, 
    0.00517636f, -0.03002472f, 0.03466725f, 0.02003407f, 0.12311512f, 0.01917420f, 0.12024571f, -0.18747367f, 
    0.06809041f, 0.10669490f, -0.10295083f, -0.13462779f, -0.04231820f, 0.17630520f, -0.03528776f, -0.05188968f, 
    -0.00038381f, 0.01429232f, 0.20926574f, -0.11393121f, -0.04849621f, 0.08952311f, 0.08689130f, -0.10975263f, 
    0.10699065f, -0.08135267f, 0.04077252f, 0.01961421f, 0.43499699f, 0.03805596f, 0.06233061f, 0.20254947f, 
    -0.15400109f, -0.08403481f, -0.09348156f, 0.17903276f, 0.05107981f, 0.03726650f, 0.04692728f, -0.04987716f, 
    -0.30524838f, 0.27020037f, -0.03651151f, 0.33256409f, 0.00896939f, 0.06732626f, -0.09887572f, -0.07204431f, 
    -0.03471670f, -0.02811368f, -0.11082237f, 0.01290507f, 0.21092376f, -0.05239360f, 0.23334387f, -0.36128426f, 
    -0.09666058f, 0.04507034f, -0.07809859f, 0.04929223f, 0.07059243f, -0.04953739f, 0.07798678f, -0.09542084f, 
    -0.09446096f, -0.01790296f, -0.07546270f, 0.18199670f, 0.06967112f, 0.01158856f, 0.06654486f, 0.05136860f, 
    0.03907557f, -0.08028739f, -0.07662887f, 0.01874174f, -0.30579627f, 0.03343581f, 0.07785583f, -0.32463747f, 
    -0.04569108f, -0.06706443f, 0.05432348f, 0.12505352f, 0.01769153f, 0.06742253f, 0.07371624f, 0.14850013f, 
    0.18087707f, 0.00796928f, -0.00571799f, -0.32871655f, 0.19501767f, 0.07754583f, 0.04494407f, 0.16505794f, 
    0.04271864f, -0.10548900f, -0.05986050f, 0.16203125f, -0.04413266f, -0.41792002f, 0.09785400f, -0.22927316f, 
    -0.01990021f, -0.01730225f, 0.11394399f, -0.03837820f, -0.19333458f, 0.01868814f, -0.12103432f, -0.14190400f, 
    0.16155930f, 0.11486942f, 0.03874763f, -0.16685793f, -0.07219227f, -0.06153765f, -0.01351878f, 0.14824280f, 
    0.02855971f, -0.10345419f, 0.12017042f, -0.03415493f, -0.00134093f, 0.36481556f, 0.09081443f, -0.11227184f, 
    -0.21734740f, -0.02650553f, 0.13426273f, 0.02803768f, -0.05521660f, -0.02415774f, -0.01673179f, -0.16075747f, 
    -0.30798906f, -0.01045347f, 0.26042330f, -0.09878322f, -0.10429742f, -0.05237881f, -0.08730491f, -0.09897518f, 
    0.09580266f, -0.09418312f, -0.04234143f, 0.07798384f, -0.06599242f, 0.17798021f, 0.12077482f, -0.34097382f, 
    -0.13942921f, -0.08421333f, 0.02185856f, -0.02683469f, -0.11722930f, -0.02775046f, -0.03772726f, 0.07785833f, 
    -0.40442297f, -0.24620251f, 0.16018333f, -0.20551933f, -0.06857241f, -0.03998339f, 0.12563711f, 0.11384942f, 
    0.05190189f, -0.02340903f, -0.00398024f, 0.01425001f, -0.14214581f, 0.06215590f, 0.13167097f, -0.38262996f, 
    0.11360884f, 0.15466209f, -0.01147648f, -0.00462235f, -0.07521292f, 0.01128830f, 0.10029068f, 0.01911121f, 
    -0.21338871f, 0.16852374f, -0.21922629f, 0.24191886f, 0.16602217f, -0.00028733f, 0.03041373f, -0.25434124f, 
    -0.10148881f, 0.00686677f, 0.02878247f, -0.00420393f, -0.01538642f, 0.16355219f, 0.29411462f, -0.06998619f, 
    -0.06918627f, 0.12609945f, 0.07377275f, -0.04132179f, -0.02045861f, 0.09343361f, -0.01876253f, 0.02803588f, 
    -0.07076754f, 0.14064282f, -0.13120297f, -0.40541732f, 0.11647467f, -0.05449667f, -0.01693572f, -0.10042347f, 
    -0.22631633f, -0.05606252f, 0.08655873f, 0.12885894f, 0.26136255f, -0.26800242f, 0.02851889f, -0.16974919f, 
    -0.15915537f, -0.05413033f, 0.03276230f, 0.17757891f, 0.23154688f, 0.01853850f, 0.08459245f, -0.09195320f, 
    0.37105671f, 0.00415169f, 0.18621716f, 0.22153792f, -0.06107704f, -0.11057027f, -0.01543436f, -0.03052654f, 
    0.25415403f, -0.05114285f, 0.10518573f, -0.00487828f, -0.73219103f, -0.12596184f, -0.31410205f, 0.13708866f, 
    0.01347555f, -0.15052502f, 0.05864106f, 0.01012975f, 0.06828338f, 0.03073040f, -0.03053303f, -0.03834676f, 
    0.01887542f, 0.16185555f, 0.14307603f, 0.24349461f, -0.07779473f, -0.04587531f, 0.03302773f, -0.00234650f, 
    0.01076187f, 0.03975853f, 0.00431938f, -0.14741674f, 0.44319850f, -0.23960675f, 0.00808652f, 0.02755978f, 
    0.05416018f, -0.09735766f, -0.24869566f, 0.13894829f, -0.14546739f, -0.05080875f, -0.23173818f, -0.03127989f, 
    -0.13100421f, 0.03870350f, -0.08249629f, -0.13233019f, 0.10508918f, -0.08956121f, 0.13469605f, 0.00968937f, 
    0.15461816f, 0.08122478f, -0.05013813f, 0.05319754f, 0.48693097f, 0.09368166f, 0.18550506f, 0.23424566f, 
    -0.02774286f, 0.02028996f, -0.10457131f, 0.00678180f, 0.06358975f, 0.11223114f, 0.11714689f, 0.06700215f, 
    0.38798878f, -0.02293559f, 0.03297101f, 0.33351594f, -0.16369168f, 0.06607563f, 0.10272610f, 0.00167665f, 
    -0.06209690f, -0.06739400f, 0.07892814f, -0.00717359f, -0.79122573f, -0.26025379f, 0.11073799f, -0.23789975f, 
    -0.00528599f, -0.08778237f, 0.08564735f, 0.08954971f, 0.05454090f, 0.08994184f, -0.06164395f, -0.09368689f, 
    0.46910334f, -0.36535028f, -0.27391675f, -0.29698601f, 0.00834468f, 0.15411894f, -0.04328255f, 0.14563231f, 
    0.01851160f, 0.04635141f, 0.12072754f, 0.00114688f, 0.06065102f, 0.02260728f, -0.06529938f, -0.10810135f, 
    0.01277124f, -0.04639604f, 0.05198502f, 0.27424628f, -0.06707004f, 0.00794104f, -0.00162428f, 0.03988323f, 
    0.10057479f, 0.22367160f, -0.04292009f, 0.39084762f, -0.08294310f, 0.03972183f, -0.11239739f, -0.12574184f, 
    -0.15389949f, 0.02303666f, -0.17974921f, 0.08190049f, 0.33579549f, 0.10056952f, -0.21690665f, -0.34887856f, 
    -0.00679808f, 0.06986826f, 0.13627899f, -0.12754092f, 0.04300981f, 0.18514761f, 0.05818958f, 0.04898782f, 
    -0.17456107f, 0.25327000f, -0.11330407f, -0.21872814f, -0.03405632f, -0.15577115f, 0.01685842f, -0.06154365f, 
    0.04336997f, 0.03619292f, 0.00805991f, 0.11638670f, -0.11194213f, -0.08005641f, -0.01319805f, -0.09626067f, 
    0.07966483f, -0.07437824f, -0.13452081f, 0.09669562f, 0.05700414f, -0.05027522f, -0.00572493f, -0.12328627f, 
    0.15515994f, -0.03574144f, -0.13768043f, 0.02128725f, -0.06498367f, -0.25843945f, -0.11699267f, -0.22916088f, 
    0.07032321f, 0.13441083f, -0.07143535f, -0.15084481f, 0.02197219f, -0.01365452f, 0.11921330f, 0.26564354f, 
    0.13045374f, -0.03222630f, -0.04167103f, -0.02899103f, 0.15745117f, -0.00495683f, -0.17784908f, 0.15450218f, 
    -0.30592281f, 0.09164380f, -0.45669937f, -0.19491793f, 0.17164281f, -0.13218066f, 0.00910409f, 0.05004796f, 
    -0.02981316f, -0.10323688f, -0.06290433f, -0.16461064f, 0.17566235f, 0.05182839f, 0.21926711f, 0.08030313f, 
    -0.07283401f, -0.19476157f, 0.15922683f, -0.02045365f, 0.00782654f, 0.05627535f, 0.07841048f, 0.11728629f, 
    0.10656948f, -0.02638802f, -0.16534263f, 0.22011277f, -0.16507398f, 0.03423635f, 0.07979781f, -0.01137638f, 
    0.01563112f, -0.13264085f, 0.06388126f, 0.00170135f, 0.37521592f, -0.14148706f, 0.14429578f, -0.32771650f, 
    -0.21156034f, -0.08186249f, -0.07098693f, -0.11797143f, -0.34537211f, 0.06818400f, -0.04558388f, -0.05275689f, 
    0.04707619f, -0.11105261f, -0.07400782f, -0.10666084f, 0.13337265f, -0.03476446f, -0.12904015f, -0.20671473f, 
    0.01311234f, 0.09197585f, -0.11163957f, -0.27060640f, 0.11208169f, -0.22448127f, 0.08245888f, -0.21904567f, 
    -0.01074539f, -0.11299286f, 0.04580125f, 0.11187628f, -0.07653055f, 0.05555051f, 0.05943502f, -0.03282565f, 
    0.10207095f, -0.31403410f, 0.13650477f, 0.30803996f, -0.06017949f, -0.13103621f, 0.04708167f, 0.18799219f, 
    -0.11851002f, -0.07421547f, -0.32101154f, 0.05033604f, 0.02887550f, -0.16979335f, -0.34576499f, -0.24137849f, 
    0.06437551f, 0.06621455f, -0.08318291f, 0.09661238f, -0.14413662f, 0.02884440f, -0.02221922f, 0.14885639f, 
    -0.25615919f, 0.01561624f, -0.01267148f, -0.05054263f, -0.04519344f, 0.02116940f, 0.07357928f, 0.07006223f, 
    -0.05648794f, 0.09568083f, 0.10824451f, -0.14859915f, 0.00823732f, 0.06331178f, -0.09210777f, -0.02902467f, 
    0.07825403f, -0.08765585f, 0.05907676f, -0.00409966f, -0.06617251f, -0.05435175f, -0.00009059f, 0.03160080f, 
    -0.11730035f, -0.09433703f, 0.04458267f, -0.21765654f, 0.09974021f, 0.01052889f, -0.07214833f, 0.15108165f, 
    -0.05281598f, 0.04113465f, -0.01424458f, 0.07183547f, 0.04760106f, -0.06588194f, -0.02148911f, -0.08588916f, 
    0.06600545f, -0.08019350f, -0.04245169f, -0.13876495f, 0.17398129f, 0.04047645f, -0.15903029f, 0.12444855f, 
    -0.32722646f, -0.06938529f, 0.00098358f, 0.17662741f, 0.02606480f, 0.00646028f, -0.28197801f, -0.04508437f, 
    -0.02623042f, -0.03852814f, 0.14132358f, 0.06910528f, -0.68561268f, 0.08780771f, -0.33403164f, -0.29033047f, 
    0.02533487f, 0.03566859f, 0.07966893f, 0.06423589f, 0.05810311f, 0.00554927f, -0.02221139f, -0.06348000f, 
    0.43418464f, -0.28477827f, 0.04200543f, -0.20858207f, 0.04382180f, -0.08353721f, 0.11849897f, 0.17445660f, 
    0.11714488f, 0.11971816f, -0.09048751f, 0.15717845f, 0.12891541f, 0.10088999f, 0.25053254f, 0.12260690f, 
    -0.09499010f, -0.13422184f, -0.07002052f, -0.06329906f, -0.01740243f, 0.05621912f, -0.11597920f, 0.11099578f, 
    -0.07306666f, 0.11938052f, -0.10025039f, -0.15402699f, -0.05307309f, 0.05900502f, -0.04687006f, -0.00953990f, 
    -0.13647586f, -0.06659653f, -0.12947886f, -0.16297671f, 0.54326642f, -0.15122291f, 0.04689436f, -0.23604071f, 
    -0.04950707f, -0.07373320f, 0.05487645f, 0.13663495f, 0.08194841f, -0.01461648f, -0.05707071f, -0.14519475f, 
    -0.17384772f, 0.18296669f, 0.01787741f, -0.07153749f, 0.04700999f, -0.02162313f, 0.03496271f, 0.15028599f, 
    -0.09824779f, -0.01119606f, 0.05510091f, -0.07324504f, 0.08716738f, -0.01309263f, -0.25338209f, -0.02965318f, 
    -0.07559026f, -0.13907664f, 0.01635501f, 0.09696474f, -0.08876827f, 0.04888757f, 0.07162706f, -0.17294234f, 
    -0.30366015f, 0.11725628f, -0.30975103f, 0.10388904f, 0.04088575f, 0.05461646f, 0.06611509f, -0.12750728f, 
    -0.10740821f, -0.15221861f, 0.18390329f, -0.10332119f, 0.04307733f, -0.16121203f, -0.01968722f, -0.14371482f, 
    -0.03391804f, 0.07445659f, -0.04725448f, 0.07325802f, -0.08520751f, 0.14643526f, 0.05986210f, -0.06850322f, 
    -0.05057652f, -0.00468810f, 0.09872779f, 0.08156084f, 0.17497091f, -0.04902083f, -0.05694861f, -0.04281018f, 
    0.05029592f, 0.04349608f, 0.01195361f, 0.03521148f, 0.34462687f, 0.25944218f, 0.17003243f, 0.13414767f, 
    0.19120093f, -0.12720209f, -0.03205314f, 0.06226439f, -0.19715758f, 0.09931618f, -0.01750774f, -0.05245472f, 
    0.20314938f, -0.09177339f, 0.25076115f, 0.19262813f, -0.24211353f, -0.05821055f, -0.07621297f, -0.19519781f, 
    -0.14709426f, -0.09910641f, -0.02487031f, 0.06054342f, 0.14478377f, -0.17076081f, 0.06922393f, -0.13461550f, 
    -0.13141286f, -0.09702256f, 0.00917545f, 0.08328963f, -0.01323816f, -0.09804234f, -0.11465435f, 0.02239940f, 
    0.41050386f, -0.01028955f, -0.07670091f, -0.28925031f, -0.29060572f, -0.14778168f, -0.14270984f, 0.15802982f, 
    0.23920555f, -0.04050375f, -0.08173808f, -0.13018475f, 0.23037447f, -0.05344100f, -0.47658831f, -0.04068649f, 
    0.24272808f, 0.02573527f, 0.04750668f, -0.08584541f, -0.04599432f, 0.10912232f, -0.11144437f, -0.01964674f, 
    0.13325815f, 0.08676519f, -0.14384750f, -0.10715948f, -0.23759322f, 0.09241991f, -0.03418588f, 0.00649988f, 
    -0.05502147f, -0.13402393f, 0.05001106f, -0.05044698f, -0.03783344f, -0.11670349f, 0.23195384f, 0.06690752f, 
    -0.03662509f, -0.08304062f, 0.15573490f, 0.00324174f, 0.03011459f, 0.10842786f, 0.00830759f, 0.03237818f, 
    -0.10175581f, 0.05285157f, 0.05232337f, -0.16282539f, 0.05277843f, 0.00712643f, 0.02631458f, -0.00842524f, 
    -0.05297099f, -0.00971492f, -0.17163643f, -0.12167195f, -0.14064881f, 0.04987825f, 0.02158251f, 0.05648034f, 
    0.10978837f, 0.08381799f, -0.01057289f, -0.04428288f, -0.15912665f, -0.02734101f, -0.04002922f, -0.19680314f, 
    -0.04890785f, 0.15520374f, -0.19787927f, -0.25174162f, 0.02956469f, 0.03215970f, 0.01597608f, -0.08746575f, 
    -0.08631468f, 0.00899501f, 0.03528206f, -0.00240366f, 0.00644245f, 0.12465013f, 0.10957943f, 0.03759420f, 
    -0.01174439f, 0.00526592f, 0.12844768f, -0.09928448f, -0.11315711f, -0.06963117f, 0.07288051f, -0.01847565f, 
    0.21775466f, -0.24682437f, 0.10793418f, 0.08230359f, -0.12746651f, 0.07692295f, -0.10513468f, 0.07170238f, 
    0.07559705f, -0.02415713f, -0.04493406f, 0.11279806f, -0.08524024f, -0.05266451f, 0.12003895f, -0.16726249f, 
    0.09239572f, -0.16095366f, 0.18385352f, -0.18609260f, 0.02095808f, -0.04069096f, 0.07460888f, -0.00358771f, 
    0.39978433f, 0.19818717f, 0.18563911f, 0.32472309f, -0.17908914f, -0.19786659f, 0.03060236f, 0.18861018f, 
    0.08142240f, 0.04813591f, 0.02310722f, -0.09798282f, -0.46610355f, -0.41262797f, -0.02052004f, -0.46267080f, 
    0.07534294f, 0.01199846f, 0.07870428f, -0.12211271f, -0.04642967f, 0.02707525f, -0.12258007f, -0.16192287f, 
    -0.15130681f, 0.20496488f, -0.26862544f, -0.16763505f, 0.13173129f, -0.15769973f, 0.13341779f, -0.10720507f, 
    0.01964880f, 0.14427230f, 0.17573111f, -0.12125199f, -0.03482148f, 0.00877901f, -0.35223022f, -0.22582102f, 
    0.01955037f, 0.00609497f, -0.00902023f, -0.14115277f, -0.14637142f, 0.15829593f, -0.14131121f, -0.04332696f, 
    0.02420533f, 0.20007776f, -0.24084184f, 0.08888405f, 0.12913452f, 0.06419125f, -0.01969503f, 0.01983644f, 
    -0.09487907f, -0.12477927f, -0.01275375f, -0.07670869f, -0.32953244f, 0.00854700f, 0.17809419f, -0.41414553f, 
    -0.07222944f, 0.03837717f, 0.06421728f, 0.02581439f, -0.08718467f, 0.16782521f, 0.02442901f, 0.04538307f, 
    -0.24845910f, -0.08741073f, -0.19130148f, -0.00093247f, -0.16750592f, -0.09200510f, -0.13224246f, -0.01016902f, 
    -0.04016697f, 0.07437817f, -0.13433205f, -0.00345764f, 0.05866621f, -0.25431517f, 0.28953472f, -0.01917146f, 
    -0.05163315f, 0.04583389f, -0.13518305f, -0.13670976f, 0.01167590f, -0.04135367f, 0.12007546f, -0.07523873f, 
    0.50670421f, 0.18672445f, -0.59137702f, 0.14725322f, -0.06242875f, 0.14668548f, -0.18349908f, 0.01568085f, 
    -0.08253366f, -0.05975906f, 0.02295626f, 0.10607396f, 0.50003070f, 0.02442595f, -0.54188770f, -0.37880102f, 
    0.02816319f, 0.07280289f, 0.01354583f, -0.02374075f, 0.07203113f, -0.04953551f, 0.06129542f, -0.02135672f, 
    0.18591170f, 0.01462437f, 0.18478654f, 0.22465585f, -0.03275323f, -0.26316765f, 0.06275941f, -0.00171313f, 
    -0.11166640f, -0.15576491f, -0.01695068f, -0.05504601f, 0.15165402f, 0.03316319f, -0.06283530f, 0.06188189f, 
    0.10873588f, 0.04206904f, 0.08974970f, -0.02808027f, 0.07367192f, -0.01087267f, 0.12329020f, -0.00917945f, 
    -0.53032887f, -0.41555178f, -0.23596816f, 0.12508953f, -0.08946650f, 0.08729655f, 0.03880651f, -0.07655368f, 
    -0.06788035f, -0.09474733f, -0.08680014f, 0.09202069f, -0.47010407f, 0.20376900f, 0.01016792f, -0.09021256f, 
    0.07885005f, -0.00244363f, 0.08688466f, 0.16945861f, -0.04789318f, -0.07733350f, 0.07375793f, -0.09213703f, 
    -0.12925209f, -0.50564277f, -0.13435578f, -0.01940019f, -0.05227929f, 0.01030271f, 0.05311267f, 0.04594128f, 
    -0.06152952f, 0.04123976f, -0.09240025f, 0.06603825f, 0.40691802f, -0.42894453f, -0.03320777f, -0.12400175f, 
    -0.01047224f, -0.05139086f, -0.00545821f, 0.02739176f, 0.08806343f, -0.02500127f, 0.03981756f, 0.09197105f, 
    -0.13298009f, -0.00623653f, -0.00516292f, 0.06280023f, -0.05678136f, 0.03005545f, -0.01801650f, 0.00153746f, 
    -0.04768390f, -0.02037481f, -0.03453350f, 0.07650788f, -0.28904957f, -0.22550175f, -0.43208140f, -0.03803587f, 
    -0.03330092f, -0.10126305f, -0.03461057f, -0.21187907f, 0.05048538f, 0.05469013f, -0.01036770f, 0.04410315f, 
    -0.58619571f, -0.67342949f, -0.09674033f, 0.08129580f, -0.12833479f, -0.05462216f, -0.07978724f, -0.19197187f, 
    -0.05779657f, -0.10158341f, 0.16224536f, -0.04134347f, 0.09189554f, 0.33916309f, -0.03486310f, -0.22423889f, 
    0.02898942f, 0.06100129f, -0.02529359f, 0.05693315f, -0.03897770f, -0.16571984f, -0.06762174f, 0.00116007f, 
    0.10454530f, 0.00646461f, -0.11300738f, 0.05421456f, -0.23146415f, -0.02958229f, -0.07635257f, -0.07203639f, 
    -0.02966068f, 0.05416496f, -0.12530653f, -0.00309888f, 0.26643485f, -0.10681796f, -0.16548160f, -0.02318612f, 
    -0.06930888f, 0.05288149f, -0.03957367f, 0.02311960f, -0.06492643f, -0.14724468f, 0.10196539f, 0.06747929f, 
    0.41292450f, -0.18558857f, 0.07572892f, -0.31136122f, -0.01304433f, -0.00981308f, -0.06129030f, 0.10494638f, 
    -0.06645317f, -0.09332275f, -0.04229984f, 0.16478433f, 0.34624639f, 0.03631187f, 0.30908677f, 0.02574288f, 
    0.14123654f, 0.02589387f, 0.07166251f, 0.08255220f, 0.09666829f, -0.01156355f, -0.08496132f, -0.03400742f, 
    -0.57084411f, -0.00720211f, 0.06384324f, -0.15415590f, 0.06845010f, -0.04607322f, 0.10222209f, 0.14659332f, 
    -0.03292142f, -0.16454579f, -0.08710971f, 0.16648617f, -0.33862951f, -0.04431152f, 0.00664470f, -0.15989430f, 
    -0.07393500f, 0.00992286f, -0.13362974f, 0.09087542f, 0.01870753f, -0.01498784f, -0.07878387f, 0.03125564f, 
    0.42905095f, 0.24522372f, -0.12559207f, 0.28972790f, -0.09336469f, -0.03208041f, -0.06918214f, 0.15339819f, 
    0.05666552f, -0.05891725f, -0.08238591f, -0.04131075f, 0.18739587f, -0.51188385f, 0.13444883f, 0.30722740f, 
    0.05721808f, 0.02048442f, 0.05572540f, 0.00577084f, 0.04551718f, -0.11629902f, 0.00670754f, -0.08151449f, 
    -0.16248043f, 0.40487808f, -0.00947036f, 0.07781274f, 0.07007556f, 0.09980071f, -0.00970258f, 0.13429923f, 
    -0.05599436f, 0.19995785f, 0.04668657f, 0.11353873f, -0.29095423f, -0.38835377f, -0.51791185f, 0.26794240f, 
    0.06913469f, 0.12670256f, -0.00316465f, -0.04024383f, -0.08723938f, -0.10627710f, -0.12943713f, -0.04603262f, 
    -0.12300896f, 0.05321506f, 0.09251176f, 0.05012600f, -0.16612948f, 0.11259467f, -0.00570918f, 0.04308310f, 
    -0.02932928f, -0.00524124f, 0.05990431f, 0.02714494f, -0.13881867f, 0.07682069f, -0.14817156f, 0.07606643f, 
    -0.09245307f, 0.00531743f, -0.09544414f, 0.10908773f, 0.09065674f, 0.03296921f, -0.06156632f, 0.06054690f, 
    -0.14372805f, -0.10012124f, 0.03639542f, 0.03189930f, -0.14115812f, -0.01608292f, 0.08399742f, 0.03639396f, 
    -0.16534176f, 0.00281942f, 0.05654430f, 0.18483965f, 0.16918577f, 0.21859226f, 0.13499089f, 0.09046774f, 
    -0.00365537f, 0.12191192f, -0.12036577f, -0.01001659f, -0.00115342f, 0.05454240f, -0.00875509f, -0.06595156f, 
    0.28862792f, 0.09589197f, -0.09431882f, -0.18142962f, -0.01333856f, -0.00557846f, 0.04834762f, -0.17952558f, 
    0.11664698f, 0.10654592f, 0.13154233f, -0.11943365f, -0.05197080f, 0.27160943f, 0.04388333f, -0.22113810f, 
    0.08919195f, 0.01162407f, 0.12387701f, 0.17990509f, -0.02849116f, -0.02719010f, 0.10488513f, -0.17938437f, 
    0.41958153f, 0.01013753f, 0.17200439f, 0.30957907f, 0.21226907f, 0.02821918f, -0.06439342f, -0.12685764f, 
    -0.00821256f, -0.05722746f, -0.17131545f, -0.10210884f, 0.02643078f, -0.06660934f, -0.12672132f, 0.16526969f, 
    -0.04736568f, 0.00657369f, -0.11500930f, 0.01334552f, -0.01435520f, -0.01585108f, 0.01226372f, 0.07570390f, 
    0.05637644f, 0.10584232f, 0.00882227f, -0.00507267f, -0.16176054f, -0.14755259f, 0.03920140f, 0.00065688f, 
    -0.01884963f, 0.04537925f, 0.08115821f, 0.08731476f, 0.18108307f, -0.17218392f, -0.06850764f, -0.02183896f, 
    -0.17191170f, -0.04417204f, 0.02958056f, 0.13455845f, -0.00982246f, -0.17841299f, 0.09753466f, 0.00698962f, 
    -0.57565278f, 0.06759629f, 0.37189895f, 0.13045385f, -0.07794892f, 0.00215709f, 0.07523344f, -0.01157786f, 
    -0.06988273f, -0.06682776f, -0.06753393f, -0.02828867f, 0.01186078f, 0.36016977f, 0.42470762f, -0.26352888f, 
    0.01540136f, 0.10021791f, -0.01676173f, 0.07071479f, 0.09356423f, 0.00169295f, 0.03774557f, 0.00689073f, 
    -0.04661658f, -0.16320017f, -0.09219677f, -0.04387100f, -0.18404679f, 0.05460984f, -0.15984115f, -0.10555518f, 
    -0.09793250f, -0.03049499f, 0.07973755f, 0.05277434f, -0.53946465f, -0.47176680f, -0.27429852f, -0.06829090f, 
    -0.11981806f, -0.07208359f, 0.11279859f, 0.13765047f, -0.02433949f, -0.03171687f, 0.00990666f, -0.30194479f, 
    -0.17769410f, 0.20590903f, 0.18834113f, 0.17266572f, -0.03253460f, -0.00971855f, -0.07003932f, 0.12709494f, 
    0.12256440f, 0.07845447f, -0.04626355f, 0.03441404f, -0.46470624f, -0.20669895f, -0.08495799f, -0.19290191f, 
    0.08932617f, 0.05161484f, -0.07547792f, -0.00914193f, -0.10565281f, 0.06571023f, 0.11593521f, 0.00825024f, 
    -0.16119584f, 0.06218277f, 0.07543111f, -0.14390190f, 0.00750278f, -0.05299954f, -0.10894734f, 0.00505055f, 
    0.13652419f, 0.00677008f, 0.10367227f, 0.09532873f, 0.29356158f, 0.01534503f, -0.09302755f, -0.06563330f, 
    -0.02025499f, 0.15326387f, 0.12731889f, -0.21854441f, -0.07627206f, 0.04091784f, 0.11778573f, -0.04786225f, 
    0.58480686f, -0.24597588f, -0.08407701f, 0.12592100f, -0.12286652f, 0.19750035f, -0.04727948f, -0.14295842f, 
    -0.08198135f, 0.03121801f, -0.01155994f, -0.09196211f, -0.03474378f, 0.20357926f, -0.05345456f, 0.14372854f, 
    0.13683045f, -0.08829650f, 0.07936688f, 0.13073376f, -0.24981929f, -0.02859775f, 0.11493521f, 0.00599653f, 
    0.18337271f, 0.16304822f, 0.01131869f, 0.07641441f, 0.04439913f, 0.08555305f, 0.00924055f, 0.05660101f, 
    0.04878891f, 0.00344546f, 0.00964355f, -0.02373772f, 0.16767387f, 0.16751030f, 0.04828611f, 0.13291478f, 
    0.07005405f, 0.03293935f, -0.04070611f, 0.08150164f, -0.00426466f, 0.08303582f, 0.14005445f, 0.08567745f, 
    -0.21259019f, 0.15403023f, -0.05075989f, 0.15002652f, 0.01903792f, -0.03902529f, 0.14341260f, 0.12342110f, 
    -0.03988004f, 0.02156583f, 0.00629622f, -0.02142546f, 0.01114642f, 0.27213576f, 0.11470032f, 0.18673177f, 
    0.13159524f, -0.05801120f, -0.09851993f, 0.12044843f, 0.04741247f, 0.06332640f, -0.13341719f, 0.00329613f, 
    -0.49883229f, 0.07077826f, -0.04078504f, -0.36727339f, 0.00074105f, 0.07796679f, -0.02456342f, 0.17041045f, 
    0.04349321f, -0.04922193f, -0.09549323f, 0.12113795f, -0.10849506f, 0.29247454f, 0.00283038f, -0.04773917f, 
    -0.16909774f, -0.08754617f, 0.01182318f, 0.11558846f, -0.00371724f, 0.04080066f, -0.07829826f, -0.00778388f, 
    -0.42560068f, 0.06540488f, 0.00368898f, 0.15604210f, -0.04796466f, -0.05776029f, -0.05611356f, -0.03715292f, 
    -0.02596434f, 0.04083766f, -0.03886335f, 0.04473195f, -0.16374466f, 0.22880703f, 0.30504531f, 0.08586995f, 
    -0.20157102f, 0.06831450f, 0.07315628f, 0.06585981f, -0.03824007f, 0.04981184f, 0.11350645f, 0.14263970f, 
    -0.13653655f, -0.06536654f, -0.27438161f, -0.25694102f, 0.14322667f, 0.18664561f, 0.13414757f, 0.06261013f, 
    -0.12152991f, -0.16787909f, 0.15239695f, -0.02819334f, -0.07753272f, -0.05283226f, 0.02367618f, 0.07929265f, 
    -0.03780621f, -0.00859521f, 0.11664357f, -0.02582690f, -0.01539482f, 0.00106183f, 0.08326138f, -0.21767755f, 
    0.06088373f, -0.49918807f, 0.27379212f, -0.17948027f, -0.02048338f, 0.12426941f, 0.10802045f, 0.03246207f, 
    0.02111071f, -0.06809009f, 0.12516294f, -0.02266843f, -0.37909800f, -0.29595673f, -0.07042575f, 0.06957503f, 
    -0.31155705f, 0.04368877f, 0.04258520f, -0.05081844f, 0.12908338f, 0.00545691f, -0.25970200f, -0.01327860f, 
    -0.54204988f, 0.27426648f, -0.20878227f, -0.23782930f, 0.05251499f, 0.06200099f, -0.02364262f, 0.09579015f, 
    0.16050948f, 0.08266444f, -0.05527649f, -0.03101011f, -0.19197375f, -0.18328218f, -0.00428095f, 0.02198099f, 
    0.07505252f, 0.00902134f, -0.06358900f, 0.05713403f, 0.06920463f, -0.14598735f, -0.04818511f, -0.22012910f, 
    -0.68936050f, -0.13775738f, 0.16531591f, 0.17856060f, 0.02183877f, -0.11854415f, 0.19255511f, 0.06473348f, 
    -0.08451373f, -0.08689419f, 0.11887755f, 0.17081146f, 0.00663327f, -0.20258795f, 0.01921918f, 0.16248530f, 
    -0.04375886f, 0.02303599f, 0.09915127f, 0.06518249f, -0.03814435f, -0.11043987f, -0.06327040f, 0.13889790f, 
    0.23297302f, -0.13942032f, -0.06665643f, 0.27515566f, -0.24862675f, -0.07296406f, -0.00928191f, -0.16813178f, 
    -0.01107285f, -0.05723464f, -0.02134402f, -0.08306009f, -0.32143033f, -0.00213850f, 0.31838584f, 0.02133096f, 
    0.03817895f, 0.14313667f, 0.12553063f, -0.27710354f, 0.15852770f, 0.02101453f, -0.02182279f, -0.14958222f, 
    -0.27116838f, 0.10827527f, 0.18151914f, -0.06061416f, 0.04011631f, 0.06399966f, -0.20226158f, -0.05301499f, 
    0.05762999f, -0.12332068f, 0.07354623f, -0.00636203f, -0.16015238f, -0.48426503f, 0.08076872f, -0.14851981f, 
    -0.02611611f, -0.02819712f, -0.05200580f, -0.17974247f, 0.08494805f, 0.03707298f, 0.08314205f, 0.06334098f, 
    0.14239180f, 0.06782814f, 0.21095139f, 0.16226517f, 0.00661832f, -0.13978070f, -0.00765811f, 0.20727243f, 
    0.04815064f, -0.04078682f, 0.05777669f, 0.01012038f, -0.01795400f, -0.12071720f, -0.01298744f, 0.14480257f, 
    0.12682098f, -0.06007526f, -0.02627059f, 0.01708991f, -0.10591289f, -0.13894770f, -0.00937211f, 0.14476712f, 
    -0.29967073f, -0.29716742f, 0.00891234f, 0.25761545f, -0.12828049f, -0.15263836f, 0.05121864f, -0.04260573f, 
    -0.03825311f, 0.03113335f, -0.24534054f, -0.00915882f, 0.48466638f, 0.37612283f, -0.22360563f, -0.20658638f, 
    -0.07097659f, -0.16048078f, 0.05689490f, -0.11845163f, 0.06673570f, -0.10722360f, -0.09626234f, -0.08954088f, 
    -0.27508461f, -0.20513652f, 0.04111217f, 0.20246339f, -0.03937869f, 0.15539362f, -0.08878664f, -0.32345524f, 
    0.04597169f, -0.10335883f, -0.00768501f, -0.13771991f, -0.12987249f, 0.04225657f, -0.11964921f, -0.03542357f, 
    -0.10645772f, 0.01504587f, -0.11947167f, 0.10954227f, -0.07328697f, -0.03822584f, 0.10431118f, -0.14258514f, 
    0.08822391f, 0.10621262f, 0.09790722f, 0.19140792f, -0.01492081f, 0.10874701f, 0.15300189f, 0.09594887f, 
    0.02578691f, -0.00030079f, -0.04615648f, 0.15721685f, -0.49073556f, 0.00021910f, 0.04216369f, -0.06902567f, 
    0.14034463f, 0.07981348f, 0.00704724f, -0.04687010f, 0.04671637f, -0.16520931f, -0.03316361f, 0.03595986f, 
    0.22859076f, 0.01056317f, 0.00278105f, 0.13943203f, 0.02497340f, -0.14332865f, -0.08228681f, -0.09444045f, 
    -0.15460780f, -0.09790975f, 0.01024892f, -0.15652190f, 0.15465246f, 0.06500845f, 0.03413672f, -0.00245409f, 
    -0.12415797f, 0.04144416f, -0.03074930f, -0.20727961f, -0.15091640f, -0.01761042f, -0.24591893f, -0.05575762f, 
    0.07992655f, 0.08007008f, 0.12031992f, 0.21569738f, -0.08537189f, 0.03651959f, -0.01106938f, -0.07377277f, 
    0.00814185f, -0.09106405f, -0.31003672f, -0.07222375f, 0.12439567f, 0.11506776f, 0.20682549f, -0.33691794f, 
    -0.01707651f, -0.15943667f, -0.04081075f, -0.05507382f, -0.11143755f, -0.07770900f, -0.01785604f, -0.03950180f, 
    -0.10298518f, 0.00302522f, 0.24691118f, -0.26188016f, -0.08186588f, -0.00609623f, 0.02310515f, -0.04418171f, 
    0.20300555f, 0.20219173f, 0.10119314f, 0.08011726f, -0.08126476f, -0.15317695f, -0.16435306f, -0.09913627f, 
    0.01557149f, 0.05213754f, -0.07407048f, -0.28258872f, -0.02766806f, -0.03835727f, 0.07167631f, 0.04265064f, 
    -0.41900682f, -0.39933351f, -0.18030860f, -0.02184088f, 0.21163262f, 0.15585312f, -0.11581863f, 0.09994514f, 
    0.02910114f, -0.00380283f, -0.07861197f, 0.13055098f, -0.81284016f, -0.17317963f, -0.21147747f, -0.05005193f, 
    0.09389892f, 0.11394077f, -0.07298634f, -0.19209059f, 0.01108188f, 0.14825714f, 0.17550746f, -0.03288471f, 
    -0.97598797f, -0.12645315f, -0.22797270f, -0.02057229f, 0.04490051f, 0.04015044f, -0.00354735f, -0.06098815f, 
    -0.05150861f, 0.09227360f, 0.01813669f, -0.11375999f, -0.36639345f, -0.13597505f, 0.38968471f, 0.44855970f, 
    -0.04688140f, -0.10859829f, 0.08157174f, -0.04590285f, -0.05624817f, 0.00972770f, 0.20827535f, 0.01332780f, 
    0.18805376f, -0.01071364f, 0.01615835f, -0.19832818f, -0.05906390f, 0.06980131f, 0.07130592f, -0.05175503f, 
    0.13214134f, 0.11729021f, 0.17918527f, 0.04795422f, 0.27593577f, -0.36263403f, -0.39492846f, 0.06189119f, 
    0.00596550f, 0.03513941f, 0.04342498f, -0.13330352f, 0.10440516f, -0.36365974f, -0.19039172f, 0.06332479f, 
    -0.41193852f, -0.16345799f, 0.40288588f, 0.01063552f, 0.01923779f, 0.07766016f, 0.09852220f, 0.05455238f, 
    -0.11524971f, 0.13956688f, -0.05789832f, 0.15146434f, 0.10428386f, 0.02825311f, -0.07791640f, -0.08703005f, 
    -0.27762699f, 0.16322960f, 0.14050627f, -0.07877828f, -0.09930131f, -0.03796254f, 0.11253218f, 0.22554711f, 
    0.12497130f, 0.12198635f, -0.09595660f, 0.26214752f, -0.22587565f, -0.09248067f, 0.00396944f, 0.24453931f, 
    -0.03428858f, 0.14734966f, -0.07429687f, -0.06351598f, -0.05913831f, -0.10199402f, -0.11200345f, 0.08425617f, 
    -0.06068073f, 0.06025735f, -0.04203930f, 0.02014706f, 0.20791274f, -0.35210052f, 0.07621107f, -0.03724331f, 
    -0.33642760f, 0.37656781f, 0.07929642f, -0.24978735f, 0.18723397f, -0.04992443f, -0.01313639f, -0.28750899f, 
    -0.06506671f, -0.02196652f, 0.08333098f, -0.13729550f, -0.01930895f, 0.10107197f, -0.07840928f, 0.02660197f, 
    -0.01626063f, 0.02890638f, -0.02187409f, -0.01485437f, 0.06207004f, 0.03067712f, 0.04838739f, 0.13609156f, 
    0.00593693f, 0.19786680f, -0.38800588f, -0.12288822f, 0.08176082f, 0.10177102f, -0.15296756f, -0.08137040f, 
    -0.00879068f, -0.14077331f, -0.06407884f, -0.11925969f, 0.00805625f, -0.06953526f, 0.08258323f, 0.15172105f, 
    -0.01503355f, -0.08218989f, -0.05605233f, 0.06280795f, 0.11433146f, -0.05818537f, 0.20180787f, -0.09071027f, 
    0.09477237f, -0.01812775f, 0.02841608f, -0.06782848f, 0.14918917f, 0.01319369f, 0.07261786f, -0.09697671f, 
    -0.05651278f, -0.00279086f, 0.04906609f, 0.08224847f, 0.21286887f, -0.00427966f, 0.04716825f, 0.23772559f, 
    -0.15044478f, -0.03132832f, -0.16347227f, 0.14596331f, -0.03539850f, 0.03862835f, 0.14018650f, 0.16809803f, 
    0.12916608f, -0.15393467f, 0.01979698f, 0.07578512f, -0.14588842f, 0.03767388f, 0.10282899f, -0.04587186f, 
    -0.22567423f, 0.13742994f, -0.02037544f, 0.42423993f, -0.10081650f, 0.06396828f, 0.07216305f, 0.06575294f, 
    0.07942931f, -0.11598211f, 0.08886245f, -0.03460481f, -0.07184847f, -0.13548656f, 0.07687615f, -0.22598802f, 
    0.05433030f, -0.17082098f, -0.14993882f, 0.07532713f, 0.16256565f, 0.14619212f, -0.10427906f, 0.01288425f, 
    -0.13736726f, 0.02070124f, 0.19661210f, 0.05818234f, -0.29246873f, -0.03960359f, -0.20933621f, 0.16473493f, 
    0.04460981f, -0.08147860f, 0.26940817f, 0.10542955f, 0.06733231f, 0.30229598f, -0.20449802f, -0.08930122f, 
    0.20326065f, -0.07205141f, -0.01139209f, -0.17127597f, 0.11851942f, -0.25002053f, 0.07621435f, 0.15999423f, 
    0.13212740f, 0.06599311f, 0.04096849f, 0.09991489f, -0.58567584f, -0.41349661f, 0.24318802f, 0.26602775f, 
    -0.00794922f, -0.16095573f, -0.01479899f, 0.10080156f, 0.15556924f, 0.06199405f, -0.01708204f, -0.08889952f, 
    0.21178661f, 0.13450190f, -0.11298997f, -0.19229189f, -0.01836472f, -0.11204300f, -0.18131626f, -0.06283878f, 
    0.11468076f, 0.04281516f, 0.02342540f, -0.03020278f, -0.01455750f, 0.07585144f, 0.06198495f, 0.24477501f, 
    0.00932817f, 0.22904621f, 0.08807904f, -0.05042774f, -0.11735199f, 0.01570897f, -0.26159149f, 0.08989625f, 
    -0.05407622f, 0.10065658f, 0.06241308f, -0.37535721f, -0.01519919f, 0.02527885f, -0.08917093f, -0.12287781f, 
    -0.10939471f, 0.01027436f, 0.16203617f, -0.14802064f, 0.59261668f, -0.37564051f, 0.24879856f, -0.02973420f, 
    0.01173682f, 0.15931553f, 0.10465691f, 0.08094944f, -0.06479257f, -0.03439948f, 0.09055312f, -0.01515060f, 
    -0.41739121f, 0.05196825f, 0.04102268f, 0.13181631f, -0.03367417f, 0.01845429f, 0.26547512f, 0.03562966f, 
    0.14244483f, 0.17144205f, -0.10536202f, 0.19696036f, -0.32176980f, 0.18742195f, 0.15727626f, 0.27156430f, 
    0.09178980f, 0.07212038f, 0.09307840f, 0.10943355f, 0.05647080f, 0.05734720f, 0.04850026f, 0.09855744f, 
    -0.40019053f, 0.22392443f, -0.05212595f, -0.33890527f, -0.14677215f, -0.04013963f, 0.07973866f, 0.08844648f, 
    0.08253538f, 0.14472745f, 0.15409914f, 0.19114186f, -0.23682354f, -0.04440165f, 0.19634968f, -0.18347797f, 
    -0.29867437f, 0.06447792f, 0.02632610f, 0.02499284f, 0.01712815f, 0.02592601f, -0.12804320f, 0.08008955f, 
    0.04368362f, 0.27339068f, 0.17291568f, -0.67042059f, -0.08946367f, -0.05568593f, 0.02194563f, 0.10321613f, 
    -0.10994867f, -0.06464070f, -0.01574882f, 0.06349949f, 0.15235879f, -0.21057770f, -0.30931070f, 0.29674923f, 
    -0.19407862f, 0.17463975f, 0.02164660f, -0.04829217f, -0.10263778f, 0.03452522f, -0.13635878f, 0.03667994f, 
    -0.13278054f, -0.03091248f, -0.01932021f, -0.22079095f, 0.02730917f, -0.06940880f, -0.05753613f, -0.27970764f, 
    0.11793292f, -0.19540475f, 0.09559362f, -0.18017349f, 0.00508820f, -0.04461062f, 0.12690133f, -0.07446138f, 
    -0.02989895f, 0.07179264f, -0.10023602f, 0.00878419f, 0.02024451f, 0.12492302f, -0.11197697f, -0.03010198f, 
    0.08363758f, -0.52412874f, 0.01713568f, -0.10477400f, -0.02482393f, 0.10852022f, 0.07182986f, 0.07443190f, 
    0.09847400f, 0.08804341f, 0.12389281f, 0.01108150f, -0.01348677f, -0.10886817f, -0.09918603f, 0.02481778f, 
    0.01034376f, 0.02357499f, 0.04504545f, 0.11919949f, -0.04832331f, -0.06777233f, -0.23277269f, -0.11382834f, 
    -0.16152358f, 0.05928025f, 0.16872215f, 0.18243252f, -0.03647060f, -0.00457130f, 0.06230328f, 0.05255143f, 
    -0.06371669f, -0.11833555f, -0.15005238f, -0.26330599f, -0.40124685f, 0.07909100f, -0.45872214f, 0.19570120f, 
    -0.07264367f, 0.05138497f, -0.06951216f, -0.15472390f, -0.06695948f, 0.20541520f, 0.16180182f, -0.00062177f, 
    0.23361139f, 0.09374169f, -0.06387918f, 0.03893371f, -0.07871311f, 0.10364926f, -0.07026985f, -0.00033308f, 
    0.06381726f, -0.09680912f, 0.17778294f, 0.04216816f, 0.13919553f, 0.23835480f, 0.11264051f, -0.63390064f, 
    -0.06534773f, -0.03959198f, -0.05167678f, -0.02249574f, 0.05077930f, 0.00155187f, -0.04646261f, -0.17994188f, 
    -0.27805501f, -0.10896391f, -0.06580509f, -0.03003507f, 0.16491197f, 0.00567628f, -0.02704259f, -0.05195959f, 
    0.02039248f, -0.14603424f, 0.05566852f, 0.02234033f, -0.16660884f, 0.24035011f, -0.06834161f, 0.00536044f, 
    0.01438662f, 0.01623796f, -0.04739504f, 0.02517396f, -0.10594995f, 0.22230443f, -0.07178622f, 0.01407795f, 
    0.56108713f, -0.52396017f, 0.07805115f, -0.03060861f, -0.10204890f, -0.09024350f, 0.06541106f, 0.16681962f, 
    0.04226588f, 0.09321946f, 0.08598289f, 0.06940672f, 0.17186406f, -0.07142803f, -0.32384053f, 0.30541459f, 
    0.04560375f, 0.10570832f, -0.04450506f, 0.03132556f, 0.07743669f, -0.09599820f, -0.11407979f, -0.17917354f, 
    -0.04711681f, -0.31545877f, -0.15894713f, -0.02030175f, -0.03246420f, 0.10166346f, -0.00289449f, -0.11967513f, 
    -0.02177273f, 0.00401607f, 0.13688864f, 0.31998104f, 0.11285388f, -0.04192584f, -0.13756789f, -0.19321352f, 
    0.05926447f, -0.10759688f, -0.09650609f, -0.08358677f, -0.01809923f, -0.10894772f, -0.09509268f, 0.12024457f, 
    -0.18772089f, 0.31500241f, 0.01983559f, -0.24150395f, 0.01451308f, 0.12246123f, -0.02244645f, -0.01255353f, 
    -0.02270761f, -0.11692508f, 0.09749984f, 0.00104441f, -0.11181405f, 0.22500952f, 0.00676924f, 0.09566124f, 
    0.16483265f, -0.13857065f, 0.09573960f, -0.02264541f, 0.10070896f, -0.02133990f, -0.13175224f, -0.01748890f, 
    0.12321411f, -0.06520154f, 0.01831791f, -0.09613141f, 0.00977046f, -0.01013033f, -0.00800968f, 0.00178453f, 
    0.08268873f, -0.20256898f, 0.00114161f, -0.12708554f, -0.34428239f, 0.39639661f, -0.24214441f, 0.45600325f, 
    0.01875442f, 0.07274167f, -0.11678068f, 0.17317767f, -0.07809584f, 0.15990944f, -0.01887943f, 0.00221564f, 
    -0.07208287f, -0.23983596f, -0.38991344f, -0.06018033f, -0.08381014f, 0.09911378f, 0.12164933f, -0.23541553f, 
    0.05324442f, 0.00107373f, 0.03995920f, -0.06168938f, 0.08842278f, 0.01896921f, -0.17260586f, -0.30874431f, 
    -0.22898142f, 0.19720343f, -0.19418928f, 0.08309253f, -0.07098226f, 0.04740706f, 0.06934767f, 0.04521489f, 
    0.03944952f, 0.02528798f, 0.07130477f, -0.22822411f, -0.11343251f, 0.12473913f, 0.27565557f, 0.08684057f, 
    0.11518946f, -0.03550099f, -0.10312284f, -0.16433567f, 0.17018028f, -0.31858757f, -0.12747706f, 0.28230104f, 
    -0.04574003f, -0.00484005f, -0.11994098f, -0.08739169f, -0.18606496f, 0.04251814f, -0.11066256f, 0.03532460f, 
    -0.45460653f, -0.06582563f, -0.07553383f, 0.17830560f, 0.02847821f, -0.02205433f, 0.09192816f, 0.14768669f, 
    0.04193394f, -0.04441468f, -0.00053044f, -0.06009295f, -0.19870891f, 0.31389025f, 0.07813660f, -0.06811669f, 
    -0.15308443f, -0.11183600f, 0.02043511f, 0.01982773f, 0.17058162f, 0.05256813f, 0.10435427f, -0.06780516f, 
    0.07369883f, -0.17369458f, -0.33726040f, -0.09828049f, 0.00578883f, 0.03916008f, 0.07379720f, -0.05777323f, 
    -0.04132725f, 0.04153466f, 0.06137206f, -0.08370209f, 0.15413512f, 0.22052401f, 0.22826129f, 0.16596991f, 
    0.16236222f, 0.06228526f, 0.08284478f, 0.06878173f, -0.06000034f, 0.00121683f, 0.08439020f, 0.02055470f, 
    0.24526356f, -0.16732584f, -0.12276626f, -0.25171080f, -0.08088824f, -0.01209809f, -0.09619772f, -0.04537611f, 
    -0.01325640f, -0.03850369f, -0.09302949f, -0.12055627f, -0.05642165f, 0.22680232f, -0.18636476f, -0.17212084f, 
    -0.14642702f, 0.08826423f, -0.03932594f, -0.05198519f, -0.04190054f, -0.01812210f, 0.04572248f, -0.13033193f, 
    0.21570159f, 0.07185381f, -0.01616366f, -0.07261673f, 0.03651688f, 0.08918858f, -0.19549394f, -0.04871225f, 
    -0.07936607f, 0.03768905f, -0.03817226f, -0.06044556f, -0.29154149f, 0.06107108f, -0.05455415f, -0.23777218f, 
    -0.12529217f, 0.01283814f, 0.03542202f, -0.10601350f, -0.04230839f, -0.06875940f, -0.21668120f, -0.09286388f, 
    -0.33679408f, 0.08475403f, -0.16332027f, -0.23918834f, -0.05954215f, 0.02943860f, -0.02949199f, -0.04581323f, 
    -0.07794489f, -0.04433142f, -0.02785757f, -0.05519489f, -0.19995712f, 0.20934165f, -0.09962423f, 0.22584203f, 
    0.17169356f, -0.15449677f, 0.03362449f, 0.08664241f, 0.04300800f, 0.00900745f, -0.00853602f, -0.12396711f, 
    0.03205400f, 0.27137238f, 0.15895005f, 0.04191983f, -0.02809456f, -0.02613624f, -0.06522187f, -0.08181428f, 
    0.00749816f, 0.10854597f, 0.02853863f, -0.17297967f, -0.03812608f, 0.27170584f, 0.04718602f, 0.09907034f, 
    -0.01078343f, -0.03949850f, -0.02207541f, -0.07246605f, -0.13809253f, 0.03281548f, -0.02760698f, -0.04104838f, 
    0.25438187f, 0.08534153f, 0.13025855f, 0.26025993f, 0.20003867f, 0.10501450f, -0.01064993f, -0.06728319f, 
    -0.02904127f, -0.01193863f, -0.07030454f, 0.01109963f, 0.46097988f, -0.20926015f, 0.26123765f, 0.41674688f, 
    -0.01761411f, -0.04813550f, -0.05734712f, -0.03655700f, 0.00190194f, 0.02610832f, -0.16568866f, -0.11047584f, 
    0.22392115f, -0.30023304f, 0.01932515f, -0.09776594f, -0.00440035f, 0.12329876f, -0.04369005f, 0.02263259f, 
    0.02989699f, -0.13609828f, 0.01430085f, -0.01830754f, -0.07755288f, 0.37614578f, -0.27487659f, 0.10194789f, 
    0.05860097f, -0.00455698f, 0.09113341f, -0.01118235f, 0.08106364f, 0.02156891f, 0.05815532f, -0.04110417f, 
    -0.21245214f, 0.20501500f, -0.00466941f, -0.01952889f, -0.07258652f, -0.09844811f, 0.07928763f, 0.02025567f, 
    -0.14262429f, -0.02379595f, -0.04692514f, 0.02154939f, -0.38856167f, 0.11838754f, -0.07170925f, -0.00360804f, 
    0.05326613f, 0.01310579f, -0.02681560f, -0.08782033f, -0.11804122f, -0.05307746f, 0.01386544f, -0.14644355f, 
    0.19798149f, -0.38837808f, 0.10325304f, 0.13457540f, 0.04354449f, -0.12857820f, -0.05074720f, -0.06475877f, 
    -0.11759995f, -0.08410900f, -0.11366447f, -0.06728816f, -0.48578888f, -0.01231563f, -0.20413962f, -0.30593351f, 
    0.04523246f, -0.12542062f, -0.02311504f, -0.01222274f, -0.13948986f, 0.06712796f, 0.05622046f, -0.09610754f, 
    0.01900049f, 0.02545541f, 0.02582740f, -0.29444548f, -0.05254391f, 0.08287068f, -0.03635996f, -0.11648326f, 
    -0.08916665f, 0.05070599f, -0.03922602f, -0.03746908f, -0.45420772f, 0.11796100f, -0.10663579f, -0.00730014f, 
    -0.08648173f, 0.01407078f, -0.00400849f, -0.02880167f, 0.03878316f, 0.03979725f, -0.06130474f, -0.06870920f, 
    0.17579329f, 0.13095345f, 0.11413429f, 0.15459672f, 0.04050553f, 0.03982458f, 0.05061223f, -0.01713494f, 
    0.04111284f, 0.00021837f, -0.07419045f, 0.02287767f, 0.01409935f, 0.05775815f, 0.00085361f, 0.13782345f, 
    -0.03271454f, -0.05901267f, -0.12442447f, -0.02952701f, -0.18376811f, -0.04953746f, -0.16360021f, 0.00473469f, 
    -0.18672660f, 0.08952220f, -0.13937858f, 0.03047227f, 0.03822175f, -0.14044076f, -0.07081988f, -0.04447910f, 
    -0.03542866f, -0.09945127f, 0.16127321f, 0.03291073f, 0.00522170f, -0.21775798f, 0.11208390f, 0.13866420f, 
    -0.20390177f, -0.15532170f, 0.03836404f, 0.13107327f, 0.03640011f, -0.13570103f, 0.05880987f, -0.03458204f, 
    -0.20159413f, 0.02080301f, -0.09184822f, 0.17715973f, -0.22586466f, -0.12399981f, 0.00698931f, -0.01897378f, 
    -0.07137161f, 0.00376747f, 0.01964920f, -0.02864936f, -0.23514168f, -0.29819408f, -0.24201761f, -0.15720703f, 
    0.00669772f, -0.21774304f, 0.02226317f, 0.00907751f, -0.13705257f, 0.06908301f, -0.01899681f, -0.09540644f, 
    0.19927594f, 0.15798347f, 0.14892536f, 0.23540142f, 0.13334239f, 0.10916317f, -0.03500738f, -0.05174835f, 
    0.02295263f, -0.06071395f, -0.09962358f, -0.16478294f, 0.07211538f, 0.25044763f, 0.16288969f, 0.28981590f, 
    0.19771291f, 0.05426507f, 0.03860407f, 0.06068672f, -0.01129821f, -0.03519047f, 0.00221659f, -0.00816531f, 
    0.33068675f, -0.49795818f, 0.00272579f, -0.21448156f, -0.04440870f, 0.11144577f, 0.00613593f, -0.12590525f, 
    0.06337176f, 0.01563795f, -0.04658056f, -0.11931095f, 0.45057473f, -0.02128417f, 0.11681656f, 0.21066716f, 
    0.22095211f, 0.06673643f, 0.05597430f, -0.07380567f, -0.09726959f, -0.12929747f, -0.07842860f, -0.08468319f, 
    -0.32497430f, 0.09757118f, -0.05705573f, -0.01751654f, -0.10817990f, 0.08042065f, -0.02652741f, -0.07313851f, 
    0.08804838f, 0.04781685f, 0.02804440f, -0.07925956f, -0.25093681f, -0.08117227f, -0.11311880f, -0.13684885f, 
    -0.03801249f, 0.05873047f, 0.00411198f, -0.01062253f, -0.12584417f, -0.07550829f, 0.01874435f, -0.06541175f, 
    0.05098623f, -0.23755138f, -0.03369877f, 0.13206366f, 0.02484888f, 0.02810780f, 0.01583354f, -0.10661296f, 
    -0.01153734f, -0.12999626f, 0.11196828f, 0.15391752f, 0.09034258f, -0.36578423f, 0.10291330f, 0.00827274f, 
    -0.17648518f, -0.16214955f, -0.05260449f, -0.02843887f, 0.05761703f, -0.14596389f, -0.28348738f, 0.00657350f, 
    0.25947341f, 0.09262276f, -0.08139508f, -0.03754416f, 0.11605730f, 0.02852568f, -0.02945288f, -0.11467192f, 
    0.04162355f, 0.08361972f, -0.08200561f, 0.03851433f, -0.02610824f, -0.17056596f, 0.02134954f, -0.01777659f, 
    0.01249664f, -0.16551380f, -0.07065209f, -0.00835109f, 0.03764705f, -0.06342702f, -0.13136685f, 0.00708949f, 
    -0.13794634f, -0.13154329f, -0.10041875f, -0.24433233f, 0.18094149f, -0.10352437f, 0.07688665f, 0.09933750f, 
    -0.00275332f, 0.02057276f, -0.12041921f, 0.06262563f, 0.41419891f, 0.03497614f, 0.08885198f, 0.13391279f, 
    0.00916065f, -0.06425777f, -0.10968531f, -0.10483955f, -0.05391610f, -0.06877063f, 0.04438290f, -0.18917495f, 
    0.14666073f, -0.03052971f, -0.03769280f, 0.44340131f, 0.20025511f, -0.08060706f, -0.04334068f, -0.11676662f, 
    0.00690805f, 0.07188208f, 0.08841261f, -0.21812366f, -0.18579088f, 0.25270432f, -0.00983308f, -0.02021730f, 
    0.09064282f, 0.02571117f, -0.14308608f, 0.00012827f, 0.02065603f, -0.06248911f, 0.09982098f, 0.20002402f, 
    -0.34195149f, 0.35370061f, 0.21841954f, 0.02490461f, -0.04692691f, 0.07766698f, -0.04157262f, 0.08135781f, 
    0.07669012f, -0.00049883f, -0.09729784f, 0.07681947f, 0.06890126f, -0.06585780f, 0.15787834f, -0.10290296f, 
    0.05162499f, -0.19873087f, -0.07470554f, -0.15739824f, -0.05502806f, -0.17327192f, 0.15455535f, -0.07397915f, 
    -0.23102760f, -0.28872699f, 0.27708927f, -0.22810850f, -0.05544476f, -0.16812052f, 0.16642480f, -0.05829908f, 
    -0.06456802f, 0.10341219f, 0.07728238f, -0.13177288f, -0.13169806f, 0.02118300f, -0.24000469f, -0.14795731f, 
    -0.02908315f, -0.04934159f, -0.10065719f, 0.03853904f, 0.08576728f, 0.03045354f, 0.06016316f, -0.13872945f, 
    0.35599446f, 0.02479113f, -0.20154262f, 0.18775871f, 0.11289069f, -0.07963618f, -0.01720331f, -0.10203069f, 
    -0.02846998f, 0.09632716f, 0.07194486f, 0.01291503f, 0.33298457f, 0.19409803f, 0.02215856f, 0.14818729f, 
    -0.03850814f, 0.16089158f, -0.08067051f, -0.06482487f, -0.05838996f, -0.01427044f, 0.02174976f, -0.03049238f, 
    0.02650457f, -0.04204097f, -0.13082384f, -0.07373937f, 0.06251246f, -0.05299996f, -0.22591402f, -0.07400826f, 
    0.17891273f, 0.15528733f, -0.05527082f, -0.15268221f, -0.23374380f, -0.18687740f, -0.04610220f, 0.25434548f, 
    0.06578635f, -0.06833355f, -0.02950787f, -0.05631668f, -0.02518774f, 0.15178213f, 0.07181687f, 0.07197389f, 
    0.05920240f, -0.36353180f, 0.06620168f, -0.15674528f, -0.01125756f, 0.02996792f, 0.00793305f, -0.10202721f, 
    0.04513739f, 0.06758012f, -0.16250952f, -0.00027248f, 0.14168662f, 0.04611709f, -0.07232356f, 0.00967690f, 
    0.12669492f, 0.04616288f, -0.07906774f, 0.06451757f, 0.08611734f, -0.01963519f, -0.01069763f, -0.03112410f, 
    -0.05843313f, -0.28997627f, 0.10338917f, 0.20071468f, -0.12192260f, -0.12963225f, 0.02220307f, -0.12254892f, 
    0.04778863f, -0.03938005f, 0.01565138f, 0.04123087f, 0.16215698f, 0.24882953f, -0.29045337f, 0.04896810f, 
    -0.04127199f, -0.00452616f, -0.04560940f, -0.07333391f, 0.10158166f, -0.07135568f, 0.14650996f, 0.21222094f, 
    -0.00062266f, 0.03758705f, 0.05974480f, 0.02156135f, -0.13601816f, 0.02073467f, 0.00416596f, 0.11900213f, 
    -0.04486606f, -0.02265551f, -0.17523772f, -0.24094674f, -0.31757197f, 0.33634591f, -0.14570282f, -0.35244536f, 
    -0.12039596f, -0.01349304f, -0.03586476f, -0.07472268f, 0.03450903f, 0.01182945f, 0.05659170f, -0.03848734f, 
    -0.26667094f, -0.40318713f, -0.16161714f, -0.05237076f, -0.02746675f, 0.07447023f, -0.08916765f, 0.02708455f, 
    0.07605350f, -0.00255901f, 0.07981230f, -0.11275183f, -0.04348290f, -0.33989382f, -0.36792988f, 0.04404737f, 
    -0.03749774f, 0.01174029f, -0.21499762f, -0.10356534f, 0.01299122f, 0.10779164f, 0.13550520f, 0.17833553f, 
    -0.29729834f, -0.31091464f, -0.24127661f, -0.14941867f, 0.06421362f, -0.06153216f, 0.03452445f, -0.07301592f, 
    0.10202830f, 0.14250503f, -0.01709222f, 0.01641283f, 0.11914784f, 0.13929720f, -0.45907888f, -0.16944410f, 
    0.07911859f, -0.09126948f, -0.09961074f, 0.03443776f, 0.14391376f, 0.02142537f, -0.06921670f, 0.15915041f, 
    -0.20005526f, -0.03508373f, -0.09101661f, -0.40293321f, 0.06569128f, 0.11001033f, -0.24132811f, -0.05515271f, 
    -0.01069748f, -0.13172588f, 0.08491920f, 0.07114593f, -0.24153127f, -0.01478068f, 0.13710265f, -0.30168235f, 
    -0.00590992f, -0.06286138f, 0.28546596f, -0.14498186f, 0.02333874f, -0.15097311f, -0.01837948f, 0.04280678f, 
    0.03917380f, -0.15683322f, 0.20684493f, -0.00745854f, 0.11867689f, -0.10627184f, 0.15773812f, -0.03975933f, 
    0.11049153f, 0.08601493f, 0.12438256f, 0.07251114f, 0.14288835f, 0.15780778f, -0.14414692f, -0.10860580f, 
    0.02405386f, 0.03824420f, 0.08626457f, 0.05853024f, -0.00930227f, -0.04779649f, -0.09366635f, -0.00863472f, 
    0.04871454f, 0.34938583f, -0.11786513f, 0.12595446f, -0.18322641f, 0.10110524f, -0.11388133f, 0.07054321f, 
    -0.05289722f, 0.08286035f, -0.02496356f, -0.09288812f, 0.07367279f, 0.05143481f, -0.03108634f, 0.26217109f, 
    0.13020438f, 0.06915379f, -0.05395802f, -0.09705283f, -0.24819043f, 0.08612651f, -0.18593962f, 0.02715753f, 
    -0.15247716f, 0.12967321f, -0.01400313f, -0.36591297f, 0.18341619f, 0.13897802f, -0.19495815f, 0.00601262f, 
    -0.17561620f, -0.03207237f, 0.01383807f, -0.18607473f, -0.00087628f, 0.01905051f, -0.19528146f, 0.26424816f, 
    0.03850792f, -0.03161198f, 0.03187615f, -0.20717569f, 0.01400662f, 0.16125110f, -0.05868177f, 0.09618923f, 
    0.39932957f, 0.08234155f, 0.00547969f, -0.05705047f, -0.05913268f, 0.21067710f, -0.00495446f, 0.22151114f, 
    0.05101947f, 0.04158143f, 0.02092111f, 0.04558088f, -0.53889674f, 0.24939685f, 0.21954142f, 0.07502792f, 
    -0.01244832f, -0.11279125f, 0.05336618f, -0.02577585f, 0.15148331f, 0.01682250f, 0.14287108f, 0.06418962f, 
    0.08403584f, -0.30705631f, -0.07307175f, 0.13687642f, -0.01093639f, -0.19311614f, -0.13032998f, 0.07402793f, 
    -0.01485926f, -0.03681633f, 0.23275103f, 0.10346493f, -0.55749601f, 0.22585128f, -0.05790199f, -0.18527769f, 
    0.22587496f, 0.12161784f, 0.11636068f, 0.02186969f, 0.16818196f, 0.08124945f, 0.06976824f, 0.10750733f, 
    -0.42302790f, 0.04770089f, -0.23147786f, -0.17052853f, 0.14097799f, -0.05679701f, -0.02636579f, -0.05871977f, 
    -0.17814465f, -0.19397929f, -0.24526086f, -0.06957632f, -0.71403903f, -0.26847166f, 0.37952280f, -0.18341568f, 
    -0.03822432f, -0.01197812f, 0.13471514f, 0.08997700f, 0.10909048f, -0.20675044f, 0.03432620f, -0.14728802f, 
    -0.11468600f, -0.03708248f, 0.07333236f, 0.38815641f, -0.04924009f, -0.05721287f, -0.13443658f, 0.10385778f, 
    -0.06035236f, 0.12199330f, 0.02769210f, -0.02550195f, -0.68819308f, -0.23425689f, 0.10830495f, 0.32705480f, 
    0.14921492f, -0.02361309f, 0.13763079f, -0.06651690f, 0.11390030f, 0.00239274f, -0.17603746f, -0.08713707f, 
    0.59234464f, 0.29796204f, -0.10197680f, -0.05849199f, 0.15661940f, -0.06539949f, 0.09901489f, -0.23062247f, 
    -0.12427213f, -0.01721600f, -0.04527454f, 0.14030170f, 0.07374053f, -0.35210681f, -0.19065318f, -0.53685719f, 
    -0.12980275f, -0.06447388f, -0.19929548f, -0.05090528f, -0.04860439f, -0.15167812f, -0.09275176f, -0.01537067f, 
    0.46643692f, -0.71028477f, 0.29465410f, 0.10098873f, 0.02519960f, 0.05742715f, -0.03789767f, -0.10868350f, 
    -0.03641226f, -0.03723039f, -0.17296243f, 0.03787065f, 0.14186609f, -0.17223118f, 0.15610808f, -0.19310677f, 
    0.23282069f, -0.05952441f, 0.03715868f, 0.18451422f, 0.09053583f, 0.12026627f, 0.09090132f, 0.07527861f, 
    0.05556259f, -0.11228263f, -0.15405270f, 0.07332984f, -0.02981563f, -0.03281984f, -0.10433381f, 0.15613869f, 
    -0.08591253f, 0.12929992f, 0.06494052f, 0.02162265f, -0.31874564f, 0.19635417f, -0.22386508f, -0.24222359f, 
    0.03120745f, -0.10442478f, 0.00931421f, 0.00525046f, 0.01821008f, 0.03664795f, -0.02480579f, 0.00515496f, 
    0.36811206f, -0.19046856f, 0.08130804f, 0.12718754f, -0.13570775f, -0.20888889f, 0.03853462f, -0.07143313f, 
    -0.09205341f, 0.18558745f, 0.08655118f, 0.14386351f, 0.16072749f, 0.03816425f, 0.15394355f, -0.16551475f, 
    0.02075408f, 0.01391605f, -0.10288338f, -0.09038564f, -0.20190793f, -0.01496614f, 0.09329247f, -0.21360098f, 
    0.25665873f, -0.24147448f, 0.02895345f, 0.01641664f, 0.19438562f, -0.05287357f, -0.00542611f, 0.05603451f, 
    0.04730068f, 0.03061871f, 0.10505977f, 0.17203447f, -0.01981555f, 0.35961321f, 0.31436273f, -0.04735696f, 
    0.13836406f, 0.12683357f, -0.01696229f, 0.03381699f, 0.03419888f, -0.07433309f, 0.06401464f, -0.15985759f, 
    -0.16029510f, -0.10977418f, -0.00840249f, 0.06803040f, -0.02732220f, 0.01806126f, 0.08375699f, 0.17038462f, 
    0.08436518f, 0.13512041f, 0.07028107f, -0.01788703f, -0.57001263f, 0.20451963f, -0.00441312f, 0.14854649f, 
    0.06567682f, 0.19354838f, -0.06010747f, -0.07577511f, -0.01540441f, -0.10381731f, -0.12410291f, 0.03581549f, 
    -0.30749264f, -0.14240432f, 0.07823155f, -0.13766642f, -0.16923606f, 0.14138134f, -0.05579557f, -0.09675423f, 
    -0.04699146f, -0.03395127f, -0.03116436f, -0.12366863f, 0.04174018f, -0.36159545f, 0.20397481f, -0.06968287f, 
    -0.15271974f, 0.08406022f, -0.03123839f, 0.01120369f, 0.11012758f, -0.22325575f, 0.06665348f, -0.05678619f, 
    -0.08300089f, 0.18398285f, -0.43549752f, -0.38988319f, -0.05880193f, -0.17667206f, 0.04078661f, 0.04907018f, 
    0.04892338f, -0.01156724f, -0.17520337f, -0.11367616f, 0.22856465f, -0.09723237f, 0.34038684f, -0.07945777f, 
    0.01628212f, 0.12843923f, 0.09286273f, -0.03896381f, 0.00628905f, -0.19278406f, -0.08211369f, 0.04111696f, 
    -0.23825160f, -0.08646950f, -0.00723400f, 0.14786848f, 0.03437028f, -0.05457640f, 0.10752852f, -0.08096358f, 
    0.03708862f, 0.00478966f, -0.10104614f, 0.04791888f, -0.11228056f, -0.07089984f, -0.15811945f, 0.08520555f, 
    0.12884672f, 0.09185496f, -0.29395860f, 0.03969863f, -0.12249752f, -0.13963941f, 0.16779517f, -0.10500297f, 
    0.41025344f, -0.09948227f, 0.00161743f, -0.25718766f, -0.24429630f, 0.10321568f, -0.00742062f, -0.03208713f, 
    -0.03044941f, -0.03257873f, 0.14503945f, -0.22066134f, 0.15621881f, -0.58927935f, 0.33938360f, 0.09537587f, 
    0.17283843f, -0.00932919f, -0.07851506f, 0.01882805f, -0.10307268f, -0.07688101f, 0.17472424f, 0.20540293f, 
    -0.27818736f, 0.07126067f, 0.28365076f, 0.03928020f, 0.21715418f, 0.17818436f, 0.14768395f, 0.04116954f, 
    -0.00357723f, 0.00469653f, 0.08945987f, 0.09081016f, -0.11041375f, 0.10744856f, 0.01898018f, -0.31201228f, 
    0.15303053f, -0.01550434f, -0.21337140f, -0.05083047f, 0.02180027f, -0.07712123f, 0.12290154f, -0.12718998f, 
    -0.60870844f, -0.39234844f, -0.02899826f, -0.17216711f, 0.01253059f, -0.04931769f, 0.04442755f, 0.09899592f, 
    0.13902414f, 0.12498392f, 0.16859934f, 0.10949815f, 0.32734546f, 0.16607414f, -0.09887553f, 0.02416345f, 
    -0.27022624f, -0.17075205f, -0.12267239f, 0.02308365f, -0.06094434f, -0.01757810f, 0.10248578f, 0.06558269f, 
    -0.55954581f, -0.21850999f, -0.11998600f, -0.29758421f, 0.08624141f, 0.04739000f, -0.04394621f, -0.15821685f, 
    0.12149634f, 0.01950877f, -0.07519965f, -0.02695421f, -0.97554237f, -0.53667676f, 0.15814269f, -0.00231957f, 
    0.10710699f, 0.15031675f, 0.00271564f, -0.04492362f, 0.15254237f, -0.16974482f, -0.16899739f, 0.08691759f, 
    -0.26601207f, -0.00865133f, 0.07192026f, -0.10721262f, 0.18103684f, 0.01382081f, 0.08422377f, 0.10295952f, 
    0.09695476f, 0.12537499f, 0.13462421f, -0.03748570f, -0.38574746f, -0.21156052f, -0.15817356f, -0.15483387f, 
    0.13091180f, -0.05384530f, -0.08520955f, -0.01576483f, 0.12200730f, -0.16479829f, -0.02581952f, 0.01219344f, 
    -0.58169723f, -0.20945567f, -0.27378380f, -0.32627600f, 0.06468653f, -0.06856972f, -0.11517707f, 0.06108801f, 
    -0.03109566f, 0.11692933f, 0.03449279f, 0.02155473f, -0.04366895f, 0.00896151f, -0.07366736f, -0.02893092f, 
    -0.14755350f, -0.12265476f, 0.07520972f, 0.11616652f, 0.03320548f, 0.08230680f, 0.07092766f, 0.03632471f, 
    0.06767648f, -0.18367063f, 0.10400299f, -0.03347592f, -0.04831295f, 0.03158892f, 0.04399711f, -0.00463245f, 
    0.11841934f, -0.03378290f, 0.05675373f, -0.02426279f, 0.12643489f, 0.12478594f, -0.05810318f, 0.15504928f, 
    -0.04923798f, -0.17683308f, 0.15410893f, 0.05177586f, 0.03881229f, -0.12922214f, 0.19679227f, 0.02305183f, 
    0.12543163f, 0.20222844f, -0.20499623f, 0.31732008f, -0.18765087f, -0.02323799f, 0.05022453f, -0.14167809f, 
    -0.08894321f, 0.03645732f, -0.02581577f, -0.21616465f, 0.03825661f, 0.28468588f, -0.19120280f, -0.35812673f, 
    0.10111587f, 0.12140346f, 0.02261432f, -0.00860126f, 0.10617600f, 0.11037654f, 0.17108835f, 0.08782659f, 
    -0.30459461f, 0.03069215f, -0.16504194f, 0.01365934f, -0.07364564f, -0.10748025f, -0.09472973f, -0.00746400f, 
    0.08830927f, 0.19497348f, 0.01320442f, 0.04864399f, -0.04343290f, -0.16536914f, -0.07439835f, 0.02806848f, 
    -0.05765681f, -0.03231633f, 0.14286867f, -0.09906495f, 0.01664888f, -0.20298280f, -0.07147259f, 0.06419898f, 
    0.02109223f, -0.18004446f, 0.08890048f, -0.05498425f, 0.02419969f, -0.00923899f, 0.08090346f, 0.10883050f, 
    0.06607448f, 0.17637679f, -0.00833322f, 0.01331508f, -0.17058444f, -0.33300328f, -0.18487154f, -0.33309302f, 
    0.00465352f, -0.02426927f, -0.07410903f, -0.09784336f, 0.03165989f, 0.11235361f, 0.09011410f, 0.09280986f, 
    -0.17381254f, 0.07086286f, 0.09061030f, -0.10863201f, 0.03059163f, -0.04204847f, -0.15018865f, -0.16278619f, 
    -0.00110927f, -0.19397196f, -0.28408319f, -0.11657815f, -0.36926535f, -0.09687698f, 0.05933607f, -0.03645689f, 
    0.15075344f, 0.09811464f, 0.05694871f, 0.00122942f, 0.08769164f, 0.08544356f, 0.12226189f, 0.05248790f, 
    0.33006901f, 0.05384725f, -0.07225598f, 0.08298842f, 0.10813513f, -0.29333317f, -0.14990267f, -0.00533487f, 
    0.02993862f, -0.07658071f, -0.13529745f, -0.09889025f, -0.47361350f, -0.37611330f, -0.07964687f, 0.20025417f, 
    0.22196454f, -0.03562720f, 0.02126333f, 0.03030667f, 0.03912012f, 0.01501480f, 0.02458018f, 0.13713422f, 
    0.44744775f, 0.19378014f, 0.05697670f, -0.11488919f, -0.30543330f, -0.10751592f, -0.19113207f, 0.03744371f, 
    0.17035253f, -0.08896750f, -0.21434270f, -0.40541941f, 0.37450507f, 0.02234023f, -0.05709298f, 0.02126840f, 
    0.12734345f, 0.14670026f, 0.09427710f, 0.08605025f, 0.09653611f, 0.10150363f, 0.05911375f, -0.00150326f, 
    -0.33309239f, -0.20395036f, 0.22208197f, 0.09289718f, 0.19820797f, 0.07171363f, -0.03619177f, 0.21768621f, 
    -0.11132903f, 0.08740290f, -0.13816036f, 0.20825161f, -0.04591609f, -0.01137123f, 0.27540487f, 0.17504971f, 
    -0.08626405f, -0.00438622f, -0.15105091f, -0.07021984f, 0.01828561f, 0.09731204f, -0.03282611f, 0.20851651f, 
    0.23787443f, 0.25167891f, -0.02000692f, -0.11203251f, 0.13382761f, 0.10218593f, 0.12919781f, 0.16745104f, 
    0.01975226f, 0.13224183f, 0.10967571f, -0.04738918f, -0.47294173f, 0.02725757f, 0.11411415f, 0.24338645f, 
    0.06382017f, 0.08550262f, 0.03999174f, 0.02105647f, 0.04816666f, -0.00018029f, -0.18023813f, -0.05163473f, 
    0.17012031f, -0.00780017f, 0.05523103f, -0.14718056f, 0.15493943f, 0.18407576f, -0.04271118f, -0.06498525f, 
    -0.06934419f, 0.03625825f, 0.04833414f, -0.04162069f, 0.03328580f, 0.12085933f, 0.07867891f, 0.10714880f, 
    -0.11531251f, -0.08756198f, 0.03627222f, -0.20566681f, 0.16383833f, 0.22393768f, -0.09881074f, 0.04586438f, 
    -0.09545933f, 0.26403227f, -0.13891436f, -0.07567351f, 0.09297611f, 0.13260284f, 0.03304435f, 0.04730932f, 
    -0.01349256f, 0.02335800f, 0.11472543f, 0.14896674f, -0.63909686f, 0.14297843f, -0.30181253f, -0.17267387f, 
    -0.04634041f, -0.02782769f, -0.01862234f, 0.02553975f, 0.02637652f, 0.12324163f, -0.12318096f, -0.02320091f, 
    0.13463281f, 0.00010124f, -0.08405320f, -0.07480748f, -0.01217021f, -0.00083109f, 0.08658557f, 0.01240659f, 
    0.04102717f, 0.05452348f, 0.01249769f, 0.05323416f, -0.55241841f, -0.30347323f, -0.10895010f, -0.14770710f, 
    0.06283515f, 0.03852750f, -0.16463745f, -0.14027715f, 0.15208554f, -0.04659820f, -0.06813592f, 0.26064578f, 
    0.31092447f, -0.06649216f, -0.25844243f, -0.06030434f, 0.09301818f, -0.08133765f, -0.00884486f, -0.07151093f, 
    -0.00637617f, 0.03328206f, -0.12762962f, -0.04298211f, -0.30381399f, -0.01343665f, -0.03108085f, -0.23358709f, 
    -0.16476400f, 0.05093765f, 0.00030263f, -0.00676848f, -0.19359210f, 0.13364407f, -0.09178463f, -0.01978038f, 
    -0.23841827f, -0.26897582f, -0.10084645f, -0.45129576f, 0.15498435f, 0.06602502f, -0.12074106f, 0.08445295f, 
    -0.02619909f, -0.14331834f, 0.14366207f, 0.01052680f, -0.34264791f, 0.30870089f, -0.04044118f, -0.18277836f, 
    0.09690002f, 0.10635932f, 0.02749312f, 0.18296757f, 0.08977881f, 0.07282807f, 0.11298742f, 0.01758010f, 
    -0.08494750f, 0.23201919f, 0.02799944f, -0.00169066f, 0.09823094f, 0.00584824f, -0.12198362f, 0.15266725f, 
    0.00140667f, -0.15569787f, -0.01607385f, -0.09894869f, -0.45108101f, -0.55777228f, -0.16852137f, -0.19591145f, 
    -0.01700124f, 0.04008277f, 0.06986196f, 0.03280521f, 0.10651078f, -0.04725776f, -0.10187704f, -0.07203101f, 
    0.14702180f, -0.04677996f, -0.37958044f, -0.15886736f, 0.03946324f, 0.04736570f, -0.01475041f, -0.00076339f, 
    0.00654854f, -0.08763468f, -0.04760779f, 0.06444664f, 0.05060934f, -0.32237554f, -0.18279679f, 0.15804724f, 
    -0.09590820f, 0.11590094f, -0.20161383f, -0.07606518f, -0.01891245f, -0.04749104f, -0.13937683f, 0.04006808f, 
    0.20521834f, 0.33204797f, -0.08004021f, -0.04225453f, 0.08331348f, -0.15700890f, 0.10284509f, -0.01885256f, 
    -0.10794481f, 0.07445271f, -0.01892945f, -0.09325904f, 0.43978310f, -0.07846963f, -0.08415668f, 0.03227817f, 
    -0.02129870f, 0.10267663f, -0.02505265f, -0.18833204f, 0.12742986f, -0.09316211f, -0.15414979f, 0.05118529f, 
    -0.32576156f, -0.12513074f, 0.07458257f, 0.02496408f, -0.00710433f, 0.00308427f, -0.00796984f, -0.03901839f, 
    0.15891637f, -0.01026831f, 0.24215306f, 0.14845739f, -0.20823550f, -0.17545751f, -0.10084034f, 0.50521058f, 
    -0.20810071f, 0.10061906f, 0.03926374f, 0.10756055f, -0.02267383f, -0.22576846f, 0.10241815f, 0.09326533f, 
    0.13960345f, 0.14862163f, 0.03833877f, 0.08792467f, -0.05194004f, -0.09417558f, -0.09093956f, 0.22828612f, 
    -0.06196582f, -0.08430496f, -0.09162735f, -0.10006329f, 0.05675333f, -0.37004760f, 0.00877350f, -0.10603348f, 
    -0.05916137f, -0.07266343f, 0.07429200f, 0.06557762f, -0.11894941f, 0.10415193f, 0.06412696f, -0.19495389f, 
    -0.18996559f, -0.05578940f, 0.16686916f, 0.19291209f, 0.02561868f, 0.02229684f, -0.03721227f, -0.03631353f, 
    0.00757958f, -0.15016362f, 0.05767754f, 0.15042193f, -0.06034195f, -0.01001314f, -0.11732718f, -0.02986168f, 
    0.19753575f, -0.00541766f, -0.01740372f, 0.06374290f, 0.11343545f, 0.03749321f, -0.06873561f, -0.00894775f, 
    0.32041991f, 0.23221090f, -0.03516123f, -0.11878462f, -0.06139553f, 0.04171926f, -0.08923008f, 0.08031028f, 
    0.27851358f, 0.00868768f, 0.07012695f, 0.08152961f, 0.61779559f, 0.21884313f, -0.10180821f, -0.07124793f, 
    0.14955977f, -0.03636781f, -0.20546542f, 0.16253586f, 0.03064720f, 0.12516749f, 0.01730640f, 0.09586985f, 
    -0.27389556f, 0.04859370f, -0.10126863f, -0.15010427f, 0.09128196f, 0.01745844f, 0.11330599f, -0.01887892f, 
    -0.09676938f, 0.01513817f, 0.07002420f, 0.13534537f, 0.31848451f, -0.37591332f, -0.10112598f, 0.19481109f, 
    0.04928655f, 0.01220477f, 0.01276616f, -0.02053403f, -0.05017050f, 0.15818551f, 0.01812133f, -0.08744008f, 
    -0.18020833f, -0.10292020f, 0.05141506f, 0.10309224f, -0.09356730f, -0.05121185f, 0.02816476f, -0.10015199f, 
    0.09664559f, 0.10538393f, 0.17287925f, -0.03338784f, 0.08178842f, 0.10807948f, -0.35323662f, 0.14554045f, 
    0.09778653f, -0.06743480f, 0.05041065f, 0.03244023f, 0.11169297f, 0.02313063f, -0.05692200f, 0.06295525f, 
    0.24784310f, 0.37540457f, -0.15554863f, 0.16772576f, 0.09694745f, 0.12330556f, -0.11931508f, -0.03293065f, 
    0.15038992f, 0.01713360f, -0.19487917f, 0.06629480f, 0.26649609f, -0.07059273f, -0.34931177f, 0.04237887f, 
    0.08543686f, -0.12060583f, 0.09320680f, -0.04562353f, -0.04795728f, -0.07726887f, -0.10206036f, 0.08049040f, 
    0.14085655f, -0.34414208f, 0.03005444f, 0.34770283f, -0.17180215f, -0.04281123f, 0.13019249f, -0.02667804f, 
    0.05474388f, -0.03827391f, -0.03897895f, -0.08872680f, 0.52991593f, -0.09923731f, 0.04173310f, -0.00224961f, 
    -0.15332662f, 0.01067624f, -0.07523034f, 0.03966875f, 0.22537012f, 0.15723966f, 0.08113613f, 0.13453639f, 
    0.06017919f, 0.28326610f, -0.16242452f, 0.02991187f, -0.28173080f, -0.14957064f, -0.16459915f, -0.15390405f, 
    0.08052348f, -0.07049877f, -0.14163858f, -0.18031321f, 0.06893764f, -0.00928483f, 0.02615745f, 0.09167697f, 
    -0.21025433f, -0.07911868f, -0.08960317f, -0.08556238f, -0.18036933f, -0.03422026f, 0.00581475f, -0.12824094f, 
    -0.36665782f, 0.26543236f, -0.13364206f, -0.11329905f, 0.00033288f, -0.00458751f, -0.13889359f, -0.04572351f, 
    -0.12429470f, -0.06335131f, -0.16211304f, -0.06833348f, -0.43714759f, 0.04163758f, 0.05111616f, 0.21397540f, 
    -0.14027196f, 0.04331804f, -0.32165673f, 0.11949562f, -0.01376673f, 0.07210483f, 0.23794533f, 0.08948825f, 
    -0.22429848f, 0.04321200f, -0.16115279f, 0.16087085f, 0.16119201f, -0.03855459f, 0.02181747f, 0.13428821f, 
    -0.02429517f, -0.06315430f, -0.20080054f, -0.04032464f, 0.36873505f, -0.25280401f, -0.23984066f, 0.00225366f, 
    -0.07046980f, -0.16626631f, 0.02345032f, -0.08830863f, 0.00969634f, -0.08119531f, -0.09805572f, 0.00967923f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02615164f, 0.00898896f, -0.06558330f, -0.00183942f, -0.03381460f, 0.03289869f, -0.03864188f, -0.07276876f, 
    -0.00673042f, 0.04836076f, 0.13761139f, -0.02043160f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
