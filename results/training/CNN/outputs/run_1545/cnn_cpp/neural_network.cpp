#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84118396f, -0.42478392f, -0.43864608f, -0.54547793f, -0.40707442f, 0.44785270f, 0.09822989f, -0.39662391f, 
    0.17210521f, 0.45858034f, -0.02240249f, 0.06837329f, -0.43076995f, -0.11417084f, -0.04862673f, 0.14049448f, 
    0.14127506f, -0.24557108f, 0.08549149f, -0.07547908f, 0.00314968f, -0.23353532f, -0.08912767f, 0.03820353f, 
    0.14599502f, -0.53127491f, -0.32125157f, -0.11832242f, -0.05977250f, -0.25382012f, -0.10757806f, -0.08554314f, 
    -0.31929672f, 0.00315527f, -0.19406494f, -0.31650570f, -0.27153686f, -0.14342320f, -0.26426601f, -0.27207536f, 
    0.01966530f, 0.20205946f, 0.04546382f, -0.25514504f, -0.05192403f, -0.06594513f, 0.04519691f, 0.30489051f, 
    -0.04078417f, 0.12588820f, -0.18232529f, 0.30979186f, -0.32093149f, 0.25102577f, 0.02927544f, -0.49585932f, 
    -0.40658921f, 0.11293852f, 0.46767607f, 0.51336700f, -0.17877728f, -0.00869649f, 0.06007731f, -0.32307675f, 
    0.26195192f, 0.03781061f, 0.19243415f, -0.24358012f, -0.25501823f, 0.05867362f, 0.02448275f, -0.22490194f, 
    -0.00306805f, -0.21070670f, 0.00874501f, -0.36649066f, -0.10237128f, -0.20192820f, -0.50543612f, -0.58554232f, 
    0.66526401f, 0.09177683f, 0.12812938f, 0.37470400f, 0.53897506f, 0.15320201f, 0.04401726f, 0.10112437f, 
    -0.01909675f, 0.10132591f, 0.04427956f, -0.18474740f, -0.13098131f, -0.12332043f, -0.02093920f, -0.18997385f, 
    0.34710968f, -0.11241297f, -0.18882707f, 0.07959574f, -0.25683814f, 0.02998901f, 0.08576506f, 0.07447295f, 
    0.32032365f, -0.27157602f, -0.03813498f, 0.49946848f, -0.59622890f, -0.13774845f, -0.11864290f, -0.00766961f, 
    0.15522616f, -0.03818200f, -0.20032734f, 0.17361738f, 0.33102638f, -0.18232885f, -0.04626973f, -0.37606436f, 
    -0.21355569f, 0.12653349f, 0.34565747f, 0.25997898f, 0.11285130f, -0.40479180f, 0.51016122f, -0.12246405f, 
    -0.41445312f, -0.36128438f, 0.13687886f, 0.41098770f, 0.13272227f, 0.03760517f, -0.62383097f, 0.00408473f, 
    0.51050895f, -0.07160571f, 0.25449246f, -0.33014160f, -0.00477420f, -0.19735447f, -0.45124945f, -0.12981044f, 
    -0.11790650f, 0.17444795f, 0.19841458f, -0.23131385f, 0.25492159f, 0.38369146f, -0.01040226f, 0.07474964f, 
    0.35406017f, -0.26604551f, -0.66464478f, -0.23255391f, -0.16243394f, -0.02753418f, 0.28310052f, 0.23323274f, 
    0.28988728f, 0.03872345f, -0.37644079f, -0.30703866f, -0.29777429f, 0.07062954f, 0.12734745f, 0.01634711f, 
    -0.05830716f, 0.01167468f, -0.14754872f, -0.11500640f, -0.37967125f, -0.36494166f, -0.58582824f, -0.16107553f, 
    -0.16297193f, -0.19501975f, 0.09368283f, 0.12929259f, -0.66912025f, -0.55227864f, -0.55926925f, -0.29211736f, 
    0.01794695f, 0.08387135f, -0.10819960f, 0.07819264f, 0.62524951f, 0.05146670f, 0.24199127f, -0.34240791f, 
    -0.11179926f, -0.31253302f, -0.23441570f, -0.22834013f, 0.06897753f, 0.04325779f, -0.09910751f, -0.29668117f, 
    0.33836848f, -0.12281876f, -0.36144617f, 0.29072186f, 0.84478629f, 0.11199880f, 0.47074515f, 0.07598315f, 
    -0.39465892f, -0.46717525f, -0.28366286f, -0.18470658f, 0.09739022f, -0.10373954f, 0.01536727f, -0.09146697f, 
    -0.09831439f, -0.09689141f, 0.02039533f, -0.06143023f, 0.13777696f, 0.05403392f, -0.13732971f, -0.04710357f, 
    0.19897565f, 0.39937174f, -0.52082837f, -0.22891021f, -0.06419472f, 0.49643025f, -0.13741414f, 0.33709311f, 
    0.09472012f, 0.47419065f, -0.21166959f, -0.25223398f, 0.05347923f, -0.04990767f, 0.15853824f, 0.22463487f, 
    -0.33613029f, 0.15759943f, -0.14245084f, 0.24593574f, 0.01077782f, 0.48397666f, 0.39177772f, 0.02379114f, 
    -0.01911881f, 0.24165066f, -0.79666406f, -0.99354130f, -0.39109969f, 0.27769980f, 0.66922104f, 0.33389342f, 
    0.25966907f, 0.37145212f, 0.25165030f, 0.02604704f, 0.18577282f, 0.13113625f, 0.16684406f, -0.20771872f, 
    -0.06617839f, -0.00944368f, 0.06679568f, -0.07653996f, 0.11677382f, -0.00732005f, -0.07378758f, -0.28000554f, 
    0.02833719f, -0.09009513f, 0.19376990f, 0.26447293f, -0.42228094f, -0.14515209f, -0.42851228f, -0.33553395f, 
    0.08223490f, 0.03651761f, 0.41737917f, 0.34114316f, 0.19953735f, 0.24176846f, 0.05072809f, 0.00559895f, 
    0.18011223f, 0.05212411f, -0.06389817f, 0.14422029f, 0.19267641f, 0.11994249f, -0.09901010f, -0.09933410f, 
    -0.02146130f, 0.14264268f, -0.20471530f, -0.09425255f, 0.32617012f, -0.30636469f, -0.44543076f, -0.39406696f, 
    0.42753628f, -0.54771602f, -0.48290199f, 0.15934695f, -0.05806438f, -0.13423328f, 0.14327878f, 0.09165826f, 
    0.59869790f, -0.20080598f, -0.05336575f, -0.08070605f, -0.04109385f, -0.19329070f, 0.20976177f, 0.16775982f, 
    -0.05095976f, 0.09261329f, -0.33107039f, 0.08335745f, 0.46727744f, -0.35202208f, 0.58519506f, -0.17249396f, 
    0.21078755f, 0.14150319f, -0.39838082f, -0.47454870f, 0.29952699f, 0.21635573f, 0.37143418f, 0.27980945f, 
    -0.39352834f, 0.51197308f, -0.39772597f, -0.25542217f, 0.29061139f, -0.25962093f, 0.19961773f, 0.11101101f, 
    -0.24775440f, 0.02883605f, -0.13306794f, 0.15489383f, 0.09523422f, -0.03607205f, -1.26856673f, 0.53549236f, 
    0.39945012f, 0.05211731f, 0.09628629f, -0.44643304f, -0.00309911f, 0.52653515f, 0.24122837f, 0.01228691f, 
    -0.23158869f, 0.11733783f, -0.24744669f, 0.49471435f, -0.19637501f, 0.02207683f, -0.12440275f, -0.04190459f, 
    -0.20755963f, -0.17294292f, 0.00757259f, -0.12296439f, 0.08765288f, 0.05852782f, -0.11870115f, 0.22359087f, 
    0.73348659f, 0.69728428f, -0.49047866f, 0.15389140f, -0.59720701f, -0.12481163f, 0.14109074f, -0.06428245f, 
    0.12748614f, 0.26117423f, -0.13287236f, -0.00051963f, 0.36284173f, -0.23112124f, 0.01048187f, -0.14142589f, 
    -0.11800337f, 0.11546768f, -0.09344742f, 0.07839009f, 0.06888277f, -0.13505468f, 0.14127837f, -0.02694226f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18243177f, -0.30780497f, 0.33514974f, -0.12377159f, 0.21757920f, -0.06630398f, 0.04053721f, -0.14376238f, 
    0.08899803f, 0.02823276f, -0.02925106f, -0.03006240f, 0.02178337f, 0.25237298f, 0.12565835f, 0.33192623f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05919046f, 0.09214693f, 0.04376141f, -0.14029838f, -0.10523428f, -0.00796087f, -0.12236255f, 0.10091411f, 
    0.10425308f, -0.01644176f, 0.01289751f, -0.02565873f, -0.25756922f, 0.10655469f, 0.01110205f, -0.20865147f, 
    0.02547959f, -0.10033450f, -0.06906068f, -0.11643622f, -0.00002931f, -0.03156501f, -0.17686982f, -0.19607890f, 
    0.17560226f, 0.25826573f, 0.09994872f, 0.12576808f, 0.08550180f, 0.00984548f, -0.00319055f, 0.02310803f, 
    0.04905553f, 0.13371401f, 0.07273925f, -0.01488250f, -0.02750125f, 0.18007129f, 0.15660430f, -0.06103404f, 
    -0.14372298f, -0.00860105f, -0.12160867f, -0.20046033f, -0.03657085f, 0.03921116f, -0.02761525f, -0.00766079f, 
    -0.08497195f, -0.09721535f, -0.01809830f, -0.09930713f, -0.10706432f, -0.00022907f, 0.05307385f, 0.13111199f, 
    -0.06986140f, 0.09578523f, -0.09222490f, 0.04411213f, -0.50329703f, -0.18504891f, 0.21752056f, -0.26155713f, 
    -0.02128014f, -0.08615615f, 0.01853246f, 0.28682232f, 0.13430029f, 0.16310221f, 0.10711139f, 0.21585679f, 
    -0.11650329f, 0.03935301f, 0.04915930f, 0.04075086f, 0.01555738f, -0.07588712f, -0.02209734f, 0.08549038f, 
    -0.05345171f, -0.02338248f, -0.01649421f, -0.00044768f, -0.22423668f, -0.28211811f, -0.23404010f, -0.01489843f, 
    0.13885941f, -0.13595892f, -0.00278188f, -0.04366122f, 0.04255176f, -0.03842536f, 0.01721757f, -0.00047108f, 
    0.05944633f, -0.09348708f, 0.08500513f, -0.11105086f, -0.00389833f, 0.01453345f, -0.03823144f, -0.04870076f, 
    0.02927802f, -0.02975298f, 0.00285680f, -0.00186610f, -0.08340782f, 0.00165786f, -0.04116394f, 0.00989337f, 
    0.18365131f, 0.20394856f, -0.02966693f, 0.05504661f, 0.05492726f, 0.03209044f, 0.07834503f, -0.02288138f, 
    0.01237666f, -0.05043880f, 0.19053380f, 0.24899699f, -0.09102140f, -0.06944607f, 0.01549015f, -0.10740200f, 
    0.11071590f, -0.01721918f, 0.08611185f, 0.07013571f, -0.08171376f, 0.12924501f, 0.04704289f, -0.03731377f, 
    -0.04762979f, 0.02167007f, -0.03195971f, -0.13448948f, 0.04579709f, 0.03533854f, 0.14894237f, 0.00751201f, 
    -0.01498073f, -0.09260805f, 0.07702050f, 0.01579992f, 0.10880122f, -0.01869684f, -0.10076949f, 0.11589998f, 
    -0.03918055f, -0.01339414f, 0.03902789f, -0.05667280f, 0.15979770f, -0.06919665f, 0.11663046f, 0.16925789f, 
    0.18768865f, 0.12620328f, 0.11508334f, -0.07340062f, -0.11995858f, 0.04814794f, -0.09582443f, -0.00948957f, 
    -0.31588006f, -0.29470876f, 0.09455609f, 0.06664854f, -0.00741597f, 0.07136795f, 0.08832569f, -0.01698844f, 
    0.07025546f, 0.08689552f, 0.18340653f, -0.05310228f, 0.43344450f, 0.14691840f, 0.20964968f, -0.08903733f, 
    0.00479835f, 0.07307567f, 0.18159291f, 0.20212524f, -0.05273021f, -0.05888689f, 0.13497750f, -0.05092184f, 
    0.08319640f, 0.17033921f, 0.27591303f, 0.42503056f, 0.09065814f, -0.00874989f, -0.01288435f, -0.03583241f, 
    -0.09576554f, 0.04402277f, -0.00265473f, 0.16779260f, -0.13181405f, -0.21855897f, -0.08156351f, 0.27179268f, 
    -0.04669650f, 0.09893683f, 0.08623657f, 0.06263797f, -0.07296830f, -0.12879489f, -0.12506415f, -0.09635995f, 
    0.05826836f, 0.00276785f, -0.12151514f, -0.09373592f, 0.03497083f, -0.09414663f, 0.05039714f, -0.19446395f, 
    0.11922029f, 0.19007224f, 0.01049923f, 0.08422922f, 0.16665044f, 0.33601189f, 0.26682889f, 0.14402762f, 
    -0.01934828f, -0.10658561f, -0.13564387f, -0.03396909f, -0.11171959f, -0.15149249f, 0.01467308f, 0.05685260f, 
    0.17343232f, -0.18019356f, 0.07954825f, -0.08234522f, 0.03250921f, 0.06680825f, -0.05257484f, -0.10967964f, 
    -0.01005038f, -0.11633205f, 0.02190739f, -0.01089241f, 0.43860260f, -0.04229406f, 0.16905153f, -0.02382374f, 
    0.04153620f, -0.16180888f, 0.07797424f, 0.04352244f, 0.00552728f, -0.13440230f, -0.11940869f, -0.10654867f, 
    0.24389206f, 0.21190758f, -0.09560937f, -0.05265361f, -0.04601828f, -0.16672535f, -0.01429773f, 0.10154869f, 
    0.14216095f, 0.09504896f, 0.04497438f, 0.21291240f, -0.09314272f, 0.00154727f, -0.01290484f, 0.28328782f, 
    -0.12384706f, 0.06636910f, -0.11383303f, 0.04064023f, -0.04715974f, 0.13950086f, 0.07089680f, 0.08275213f, 
    0.11564257f, 0.16859552f, -0.05319097f, 0.00348256f, -0.09631190f, 0.11613117f, -0.10612470f, 0.01630538f, 
    -0.05035802f, -0.09911710f, -0.09754003f, -0.08486118f, 0.03981813f, -0.00885615f, -0.04969005f, -0.06510536f, 
    -0.10051298f, 0.15854910f, -0.01822930f, -0.01892298f, 0.13751525f, -0.06950735f, 0.06049310f, -0.12157489f, 
    -0.39375022f, 0.06117829f, 0.13633505f, 0.27414036f, 0.14523391f, 0.04918167f, -0.12277190f, -0.02836464f, 
    0.02444368f, 0.03538052f, 0.05279417f, 0.06784260f, -0.09638911f, 0.27297640f, 0.14223433f, 0.06734414f, 
    0.00442832f, -0.02148826f, 0.09208440f, 0.05840157f, 0.05375808f, 0.03694452f, 0.14697020f, 0.07006267f, 
    -0.18752620f, 0.03669342f, 0.25215939f, 0.12897725f, -0.01457623f, 0.06602056f, 0.04251565f, 0.09330021f, 
    0.03392626f, -0.25506186f, -0.06243746f, -0.28930333f, 0.20275633f, -0.07178602f, 0.01761461f, -0.09953222f, 
    -0.14076501f, 0.02687400f, 0.05317250f, 0.04643921f, 0.06254555f, 0.07356785f, 0.25103351f, -0.03293144f, 
    0.34554252f, 0.26657653f, -0.14695551f, 0.04959106f, 0.07643168f, -0.09666061f, -0.01662070f, -0.08546043f, 
    -0.07355857f, -0.16131571f, 0.10555851f, -0.02040643f, 0.05392002f, 0.01289428f, 0.06789217f, -0.21288197f, 
    -0.00289976f, 0.07439027f, -0.03474379f, -0.08313371f, -0.01388474f, 0.01391104f, -0.02816381f, -0.13108982f, 
    0.14232486f, -0.06895560f, -0.15767653f, 0.15306669f, 0.04658942f, -0.08137176f, 0.21071565f, -0.04440238f, 
    -0.26429504f, -0.02325393f, -0.00310016f, -0.01213722f, 0.14155589f, -0.02298885f, -0.01593683f, 0.18913685f, 
    -0.02506123f, -0.04531979f, -0.02542341f, 0.02040958f, -0.09141853f, -0.00891879f, -0.16310214f, 0.08417154f, 
    -0.42328057f, -0.06222136f, -0.25554857f, -0.40482053f, -0.08018731f, 0.02865988f, 0.11097400f, -0.02378764f, 
    0.00112923f, -0.23525633f, 0.11272328f, -0.02331418f, 0.36088061f, -0.03337897f, 0.07735905f, 0.10346118f, 
    -0.02179556f, 0.05706310f, 0.15113422f, 0.22117992f, -0.15198246f, 0.07109624f, 0.05640081f, -0.17194329f, 
    0.03431721f, 0.09315329f, 0.17094211f, 0.08045091f, -0.24253669f, 0.10929447f, -0.31984335f, -0.01213374f, 
    -0.02476793f, -0.07958450f, 0.09991981f, 0.07463743f, 0.49435949f, -0.08200527f, 0.22916922f, 0.22876684f, 
    0.08649407f, 0.09036373f, 0.34752300f, -0.17735825f, -0.23491879f, 0.02187544f, 0.38683864f, 0.05188232f, 
    0.14973232f, -0.11154280f, 0.02461371f, -0.15086198f, 0.02150956f, 0.14000943f, 0.15918700f, -0.02435945f, 
    0.14498071f, -0.16875008f, -0.06732318f, -0.03347611f, -0.11834031f, 0.08046463f, -0.15694310f, 0.12122189f, 
    0.00722838f, 0.03647747f, 0.13830228f, 0.22099803f, 0.02574307f, 0.18283358f, 0.15336247f, 0.07092911f, 
    0.05272664f, 0.19150206f, 0.14150105f, 0.44375670f, -0.12646903f, -0.05260135f, -0.00242952f, 0.07091800f, 
    0.11922851f, -0.09658883f, 0.02374759f, 0.00602772f, 0.01643819f, 0.21266524f, 0.03694505f, 0.03103185f, 
    -0.04466343f, 0.03523143f, 0.08203676f, -0.00461533f, -0.00460735f, -0.12214249f, -0.07623232f, 0.02241671f, 
    -0.16478686f, 0.14501162f, -0.34988078f, -0.31841749f, -0.01816545f, 0.06174678f, 0.03949174f, 0.01217599f, 
    -0.12758398f, 0.07712009f, -0.21675405f, -0.10838064f, -0.02160771f, -0.13532393f, 0.00177055f, 0.15515338f, 
    0.08450273f, 0.13641237f, 0.09250208f, 0.28006917f, -0.14603522f, -0.04556792f, -0.15714473f, 0.00928198f, 
    0.03709882f, -0.05452127f, -0.10020468f, 0.22619747f, 0.08636676f, -0.12140955f, 0.14048757f, 0.03281076f, 
    0.08828948f, 0.00487692f, 0.16167687f, -0.00871183f, 0.05167487f, 0.08899355f, 0.22760898f, -0.40608981f, 
    -0.23000705f, -0.11925212f, -0.07093595f, 0.05057575f, 0.21148188f, -0.05585399f, 0.09211732f, 0.02471764f, 
    0.54908019f, 0.44988096f, -0.06418466f, -0.62726986f, -0.01848260f, -0.07368670f, -0.02669017f, 0.10153998f, 
    0.07208294f, -0.00714584f, 0.15389296f, 0.23503529f, -0.05188283f, -0.18166524f, -0.10370842f, -0.11699700f, 
    -0.18929398f, 0.08044207f, -0.11033886f, -0.12445419f, 0.19694740f, 0.02459639f, 0.06166137f, 0.08311529f, 
    0.04998892f, 0.03410193f, 0.04543534f, -0.03259382f, -0.08902039f, -0.06114277f, 0.04006640f, -0.04136477f, 
    -0.06922209f, -0.01787226f, -0.05912023f, -0.05665581f, 0.03061038f, 0.05794528f, 0.02939257f, -0.04030026f, 
    0.01307275f, -0.02831821f, -0.00034780f, 0.02738279f, 0.02448374f, 0.08570075f, 0.03150733f, -0.04096526f, 
    -0.10754699f, -0.03385019f, 0.01493102f, -0.03362726f, -0.06393240f, -0.08335713f, -0.01887816f, 0.02346471f, 
    -0.08747550f, -0.08119597f, -0.01170653f, -0.09135903f, -0.02785429f, -0.01992740f, -0.06194494f, -0.01750851f, 
    0.05586946f, -0.01300673f, -0.06617526f, 0.01490979f, -0.00661851f, -0.00609050f, -0.06201760f, -0.09037770f, 
    0.01796996f, -0.03845426f, 0.03527044f, -0.07308186f, -0.08859780f, -0.03909695f, -0.05294103f, -0.00405058f, 
    0.03901170f, 0.02535617f, 0.04945061f, -0.04551303f, 0.05155129f, -0.08851928f, 0.00346042f, 0.00921474f, 
    -0.09849755f, -0.06152816f, -0.03708629f, 0.01050885f, -0.10675013f, -0.10561685f, 0.03831598f, -0.09832057f, 
    -0.02350757f, -0.01333727f, -0.01970627f, 0.00363851f, -0.03136573f, 0.00844950f, -0.04870032f, 0.05515023f, 
    0.04757589f, 0.01719597f, -0.08140168f, -0.07736331f, -0.04619044f, -0.03461774f, -0.03496911f, -0.02709091f, 
    0.01949501f, -0.00925894f, -0.03213401f, 0.02022968f, 0.02310588f, 0.03481671f, 0.05450569f, 0.02156335f, 
    -0.08955662f, -0.09573200f, -0.02365335f, -0.06980761f, 0.05348772f, 0.04341964f, 0.02717787f, -0.06925279f, 
    -0.06630575f, -0.07211392f, -0.07005259f, -0.08927264f, -0.00311173f, 0.05578424f, -0.08356526f, 0.00377711f, 
    0.00140715f, 0.04846223f, 0.01562073f, 0.01319112f, 0.06962381f, 0.04985656f, -0.02174600f, -0.00683018f, 
    -0.03298988f, 0.01967888f, -0.05449970f, 0.01426014f, -0.00656007f, 0.04729097f, -0.04777968f, 0.00085548f, 
    -0.07141088f, -0.04890392f, -0.02744651f, 0.01685531f, 0.06289342f, -0.03101838f, -0.05452639f, 0.02310318f, 
    -0.06937473f, -0.01679594f, 0.04717791f, 0.05665107f, -0.00945017f, -0.02610057f, 0.00839200f, -0.02537283f, 
    0.04490880f, 0.01385300f, -0.00175495f, 0.05146667f, -0.06409466f, -0.01984631f, 0.01554042f, -0.03199387f, 
    -0.04957719f, -0.00531316f, -0.04655788f, -0.02590889f, -0.06988474f, -0.03330016f, -0.01310557f, -0.06420162f, 
    0.03142659f, -0.08801821f, 0.03828878f, 0.01235496f, -0.02162611f, -0.08622361f, -0.08330393f, 0.01519556f, 
    -0.08345513f, -0.00152952f, 0.00247013f, -0.00686718f, 0.01721277f, -0.04610544f, -0.05453674f, -0.06348094f, 
    0.03698502f, 0.06480008f, 0.00695478f, -0.03614293f, -0.05730068f, -0.01193532f, 0.03737997f, -0.06189570f, 
    -0.00170749f, 0.03192556f, -0.00761576f, 0.03726647f, 0.00250112f, 0.02878669f, -0.02978094f, -0.02142491f, 
    0.02579169f, 0.02937770f, 0.01055661f, 0.02515708f, -0.02006612f, -0.00613202f, -0.01305715f, 0.05566297f, 
    -0.05327175f, 0.01759219f, -0.03622467f, -0.06568184f, -0.05404227f, 0.01375076f, 0.02096988f, 0.04622881f, 
    0.01250859f, -0.01660660f, -0.02154199f, 0.00468618f, -0.00461880f, -0.04422729f, -0.06356417f, -0.03080148f, 
    -0.05137758f, -0.04600211f, -0.00050621f, -0.02012840f, -0.03869055f, 0.02679249f, -0.01251881f, 0.03039441f, 
    0.00013034f, -0.04678364f, -0.07116842f, -0.00883692f, -0.06701474f, -0.06020404f, -0.08083878f, -0.00485633f, 
    -0.04559455f, 0.01452180f, -0.05820996f, -0.06289937f, 0.03854825f, 0.00755890f, -0.04875953f, -0.01705004f, 
    -0.07667259f, 0.00611516f, 0.00405203f, -0.05254237f, 0.03790114f, -0.03168091f, 0.00981390f, 0.00033497f, 
    -0.02566868f, 0.07534859f, -0.03262673f, 0.00531842f, 0.01390880f, -0.00797511f, 0.04527996f, 0.01999373f, 
    0.03502442f, -0.02134798f, -0.00507609f, 0.01098399f, 0.00239568f, 0.01443779f, -0.03434512f, 0.04112240f, 
    -0.00756532f, 0.02551946f, -0.07299960f, 0.03238470f, -0.05331349f, -0.03835624f, -0.05308914f, 0.05533674f, 
    0.01541086f, 0.02089522f, 0.01408514f, -0.00252573f, 0.03605497f, -0.06143487f, -0.07636824f, 0.00872941f, 
    -0.04194840f, -0.01799880f, 0.02533478f, 0.00018423f, 0.03230224f, 0.04552749f, 0.00452250f, -0.01177630f, 
    0.01319381f, -0.00052395f, 0.04529215f, -0.04164022f, -0.03526955f, 0.02722796f, 0.01118870f, -0.05512115f, 
    -0.06196818f, -0.00691605f, 0.01137585f, 0.02745995f, 0.05228165f, 0.04995021f, -0.05079532f, -0.07113394f, 
    0.02808294f, -0.01650714f, 0.06651358f, 0.01237422f, -0.04655394f, -0.06957193f, 0.03652726f, -0.00886545f, 
    0.00705382f, -0.01702501f, -0.02454223f, 0.05079525f, -0.07226826f, 0.04590649f, 0.00894770f, -0.01857996f, 
    0.03355872f, 0.05106788f, -0.05776906f, 0.00190528f, -0.07438286f, -0.04580626f, 0.00463848f, 0.01405022f, 
    0.03505599f, -0.02944573f, -0.05364647f, -0.05809947f, -0.06482635f, -0.07237896f, 0.01343489f, -0.04599973f, 
    0.05156466f, 0.03594407f, -0.01821225f, -0.02992229f, -0.06910654f, 0.01939143f, -0.02284360f, 0.04691748f, 
    -0.04750719f, 0.02768302f, -0.06169367f, -0.00534333f, 0.02833221f, -0.04016864f, -0.02749499f, -0.08257984f, 
    -0.01129755f, 0.03177178f, 0.00058205f, -0.04322557f, -0.07703106f, 0.03782776f, 0.05135279f, -0.06201109f, 
    -0.01066526f, -0.01950335f, -0.07411695f, -0.06452764f, 0.04115844f, 0.03906043f, -0.02245180f, 0.05198374f, 
    0.06420089f, 0.00272103f, 0.03822474f, -0.00419308f, -0.00229134f, 0.01230305f, -0.04675771f, 0.03979806f, 
    0.00393472f, 0.01710631f, -0.00608169f, -0.06373686f, -0.06074435f, 0.02366850f, 0.05592790f, -0.03909539f, 
    0.11986864f, 0.20718858f, 0.01788747f, -0.14987339f, 0.14956379f, 0.22150816f, 0.07265183f, 0.09980424f, 
    0.01610816f, -0.10793400f, 0.02254792f, -0.12526645f, 0.13578512f, 0.25143319f, 0.19467500f, -0.10272402f, 
    0.04162277f, 0.01826624f, 0.06692971f, 0.00455079f, 0.02095635f, -0.06750982f, -0.03232156f, -0.09759969f, 
    -0.02057248f, 0.01048013f, 0.10903680f, 0.15689740f, -0.02365875f, 0.00738234f, -0.03197591f, 0.05387288f, 
    0.04442567f, -0.10654064f, 0.06985512f, 0.02690325f, -0.21601850f, -0.05077471f, -0.23342139f, -0.12033530f, 
    0.00246816f, 0.02830720f, -0.07477210f, -0.17514166f, -0.09796987f, -0.08011972f, -0.03993529f, -0.00947101f, 
    0.04314880f, -0.08361116f, 0.19308881f, -0.01603529f, 0.02278754f, 0.02736235f, 0.22979701f, -0.01740599f, 
    0.09552420f, 0.13226838f, 0.10758365f, 0.18932615f, -0.08020805f, -0.08268210f, -0.05132491f, -0.15183690f, 
    -0.00349605f, 0.12810107f, -0.02783978f, 0.25831029f, 0.06424605f, -0.00821885f, 0.00383959f, 0.23138823f, 
    0.01292875f, 0.07777584f, 0.00381923f, -0.11327577f, 0.04694402f, -0.00250468f, -0.11011105f, 0.00006636f, 
    -0.02886276f, -0.12705004f, -0.03275276f, -0.11549476f, 0.03018839f, 0.08326966f, 0.11698121f, -0.15836722f, 
    0.00842660f, 0.05488316f, -0.02805410f, 0.07449922f, -0.06813628f, -0.10618933f, -0.10331599f, 0.05301469f, 
    0.07638296f, 0.04848174f, -0.02660226f, -0.00854412f, -0.14843920f, -0.04646585f, -0.05126613f, -0.04973445f, 
    -0.06048833f, -0.05990035f, 0.00217191f, 0.01824471f, -0.12772532f, -0.02747296f, -0.28588521f, -0.04993315f, 
    -0.02834691f, -0.03147447f, -0.04356521f, 0.11247097f, -0.01224568f, 0.03736646f, 0.01700635f, -0.01211609f, 
    0.16600747f, -0.29036349f, -0.16336210f, 0.08785129f, -0.03357701f, 0.03465581f, -0.04531136f, -0.13957605f, 
    0.02421426f, 0.01331909f, 0.20610866f, 0.05079149f, -0.18998583f, -0.31849530f, -0.20781609f, -0.16839901f, 
    -0.14442292f, 0.00593591f, -0.09178045f, -0.10282373f, -0.00284462f, 0.05075770f, -0.05018821f, -0.06193517f, 
    0.26662996f, -0.14093722f, 0.07083595f, -0.03200434f, -0.02273866f, 0.24330212f, -0.03738765f, 0.08161812f, 
    -0.07717926f, 0.07406887f, -0.01952521f, 0.11779469f, -0.17384377f, -0.00617606f, 0.21897288f, -0.05344895f, 
    0.12690191f, 0.03942861f, -0.03110878f, 0.01732448f, -0.03192080f, -0.07045198f, 0.03560173f, 0.10404238f, 
    -0.23019794f, -0.47005647f, 0.23374853f, 0.06196215f, -0.06602842f, 0.07563019f, 0.02321587f, 0.09514015f, 
    0.12405082f, 0.00732203f, -0.15744558f, -0.01474354f, 0.10558293f, -0.00397546f, 0.21216290f, 0.06101408f, 
    0.04955736f, -0.18711907f, 0.05360423f, 0.17400631f, -0.04278513f, 0.05729069f, -0.00105876f, 0.09406437f, 
    0.25370347f, 0.39091840f, 0.06293672f, 0.16494632f, 0.17719209f, 0.10567174f, -0.09753072f, 0.01862461f, 
    -0.02632400f, -0.02564438f, -0.05518688f, 0.09081686f, -0.04376904f, -0.02386943f, 0.19627957f, 0.09820285f, 
    -0.04912478f, 0.02835309f, -0.08072527f, -0.18616517f, 0.03156591f, -0.04988744f, -0.13184789f, -0.05357839f, 
    0.04070762f, 0.01022548f, -0.10655254f, 0.05341344f, 0.11540194f, 0.06595573f, -0.07271034f, -0.17421418f, 
    0.08817602f, 0.01576550f, -0.02420334f, 0.20664263f, -0.07084125f, 0.18636826f, -0.05658013f, 0.13594936f, 
    -0.02556608f, 0.06375824f, -0.19796301f, -0.18853177f, 0.01268796f, -0.09852204f, 0.03198951f, 0.03975697f, 
    0.09801597f, -0.05998690f, 0.16049169f, 0.08125118f, -0.14395152f, 0.13891740f, 0.08509157f, 0.07714234f, 
    0.22345531f, -0.03196416f, 0.15510127f, 0.12795924f, -0.04866736f, -0.33699521f, -0.19018567f, -0.10375753f, 
    -0.06440970f, 0.01327128f, 0.04060936f, 0.30441406f, 0.06946933f, 0.01636858f, -0.04640632f, 0.08807483f, 
    0.12575772f, 0.03029420f, 0.11067468f, 0.00983191f, -0.01628209f, -0.09220870f, 0.03476401f, 0.06236659f, 
    -0.01345143f, -0.12178225f, -0.06597023f, 0.00578121f, -0.09651729f, -0.38176534f, 0.03993015f, 0.05865972f, 
    -0.01231550f, -0.07005601f, -0.03413517f, 0.23101960f, -0.07087770f, -0.01983750f, 0.05275958f, -0.00306642f, 
    0.40216258f, 0.35710454f, -0.05861953f, 0.08905046f, -0.20911589f, -0.01773001f, -0.11740069f, -0.09617041f, 
    0.01964143f, -0.10211350f, -0.07576963f, -0.25513822f, 0.04962417f, -0.04195064f, -0.22737105f, 0.09177153f, 
    -0.02806243f, 0.10032521f, -0.05926187f, 0.02516438f, 0.07213731f, 0.12779309f, 0.07445437f, -0.04715429f, 
    -0.01747767f, -0.26602525f, -0.33862919f, -0.05262595f, 0.09518135f, 0.03115705f, -0.07701638f, 0.01824911f, 
    0.03632896f, -0.04521822f, 0.15331675f, 0.09841462f, -0.20080929f, -0.10540605f, -0.12584312f, -0.06594810f, 
    -0.20023757f, -0.04990902f, -0.03989109f, -0.14929491f, 0.03674294f, 0.09050477f, 0.09065831f, 0.13610780f, 
    0.07255706f, -0.14964692f, 0.02881496f, 0.11270810f, 0.00987067f, 0.38274974f, -0.11565565f, -0.07613182f, 
    0.06764483f, -0.01103706f, -0.06948884f, 0.06766823f, 0.14598243f, 0.13986577f, 0.27960300f, -0.18250580f, 
    0.20570819f, 0.07021956f, -0.08519287f, -0.04568577f, 0.01702050f, 0.01374002f, 0.05037249f, 0.05454949f, 
    0.11798761f, -0.41641754f, -0.12158793f, -0.00799269f, 0.04003584f, -0.05059269f, 0.06187451f, -0.02651629f, 
    -0.04710437f, -0.09003834f, -0.05780358f, -0.06676237f, 0.24343516f, -0.02865344f, 0.47794631f, -0.01991252f, 
    0.12716492f, -0.15321982f, -0.06635740f, 0.07423747f, 0.00634819f, -0.12074552f, 0.01183072f, 0.03949481f, 
    -0.14865457f, -0.11512607f, -0.03175097f, 0.03146127f, 0.13961981f, 0.05969546f, 0.02332160f, -0.01157116f, 
    0.09813207f, -0.11595574f, 0.05876857f, 0.10556683f, 0.03741429f, -0.03397176f, -0.01828887f, -0.15175000f, 
    0.00502779f, -0.01425608f, 0.01507996f, -0.15124570f, -0.05150395f, 0.08602133f, -0.01307125f, -0.01471274f, 
    0.47230726f, -0.22078587f, 0.00356183f, 0.12720692f, 0.07239047f, -0.15945223f, -0.05697096f, 0.22954218f, 
    -0.01797021f, 0.13024049f, -0.06883006f, 0.11472825f, -0.22055301f, -0.36589131f, -0.13557914f, 0.14527912f, 
    -0.01456216f, 0.09991754f, 0.05349700f, 0.01872191f, 0.12283588f, 0.07629505f, 0.06839968f, 0.03524645f, 
    0.16862988f, 0.29064652f, -0.12430856f, -0.01655462f, -0.04369100f, 0.08575065f, -0.07772143f, 0.09983567f, 
    0.10588644f, -0.05042421f, -0.03755919f, 0.19249524f, -0.09876896f, -0.03765421f, -0.26745158f, 0.15405327f, 
    0.14182648f, 0.12022005f, 0.02310890f, -0.02324934f, 0.02081144f, -0.01901328f, 0.00688099f, 0.11073056f, 
    0.00913989f, -0.16542065f, 0.03235711f, 0.04781317f, 0.12812921f, 0.05025675f, -0.07134122f, -0.02292906f, 
    -0.03849986f, -0.02042994f, -0.15513775f, -0.19735551f, -0.06691786f, -0.37559113f, -0.00405111f, -0.02331303f, 
    0.00299766f, 0.12221272f, -0.05200065f, 0.00862055f, 0.03761229f, -0.06984172f, 0.00505772f, 0.03730744f, 
    0.06516857f, 0.34677202f, -0.07906061f, 0.20060423f, -0.09897630f, 0.03388054f, 0.08961385f, -0.09638103f, 
    -0.09580420f, -0.04363912f, 0.08255071f, 0.00436748f, -0.02228868f, -0.13847046f, -0.03305513f, -0.04418757f, 
    -0.15440702f, -0.07805371f, 0.14027517f, -0.13342744f, 0.04141224f, -0.04838014f, 0.12310512f, 0.10335746f, 
    -0.04613727f, 0.11231937f, -0.18182051f, -0.41373110f, -0.10751872f, -0.06245104f, 0.14914681f, 0.02064673f, 
    0.06225971f, 0.03151245f, 0.20193782f, 0.05539462f, 0.04039016f, -0.02790051f, -0.17909122f, -0.02652511f, 
    -0.03778096f, 0.07611489f, -0.01280939f, -0.05966682f, 0.06326371f, 0.04879472f, 0.13686527f, 0.03503276f, 
    0.18490979f, -0.19268572f, -0.17538115f, 0.09453262f, 0.01049157f, 0.25953335f, -0.16276613f, -0.06204701f, 
    0.06677310f, 0.15838560f, -0.03712548f, 0.04870513f, 0.48011735f, 0.09520846f, -0.03397531f, -0.15379079f, 
    -0.01338539f, -0.02085132f, -0.07615474f, 0.16793676f, -0.09025513f, 0.13318342f, -0.08809621f, -0.01700543f, 
    0.33551058f, 0.02420383f, 0.17099942f, -0.10162173f, 0.03096919f, -0.12200654f, -0.06168625f, 0.05098132f, 
    -0.05994551f, 0.21103624f, 0.04645221f, 0.10420662f, 0.01013861f, -0.13097817f, 0.11064236f, -0.02408311f, 
    0.08052533f, -0.13095801f, -0.06356725f, 0.06086643f, -0.07110329f, 0.13444383f, 0.17369083f, 0.12181907f, 
    -0.36833295f, -0.04251900f, 0.07013134f, 0.19474490f, 0.02290312f, -0.11527026f, 0.16303714f, 0.09799436f, 
    0.09521592f, -0.08529856f, 0.06878511f, 0.28880250f, -0.17352334f, -0.14541736f, 0.17335086f, 0.28490806f, 
    -0.10519570f, 0.00115138f, -0.00119099f, 0.04420642f, 0.10018975f, -0.00494051f, 0.19825037f, -0.10748915f, 
    0.51189286f, -0.16862671f, 0.04260593f, 0.06971132f, 0.11155052f, -0.14249508f, -0.02136791f, 0.12085818f, 
    0.06710190f, 0.23446779f, 0.10307436f, -0.04347240f, -0.19161125f, -0.28358728f, -0.09488116f, -0.13303913f, 
    -0.08875822f, -0.12769628f, 0.03577530f, 0.20747742f, 0.24000677f, -0.13295892f, -0.04753340f, 0.16394731f, 
    0.17875969f, 0.07134611f, -0.00628482f, -0.18763615f, 0.10479014f, -0.13735145f, -0.25034806f, -0.12483591f, 
    0.06871404f, -0.23596366f, 0.03807817f, -0.22018662f, -0.05023242f, 0.17147556f, -0.19482505f, 0.15544932f, 
    0.01202828f, 0.01345250f, -0.11361800f, -0.25021443f, 0.04328297f, 0.04534311f, -0.08185609f, -0.17541264f, 
    0.01263526f, -0.05225369f, -0.03318564f, 0.17990430f, -0.06305918f, -0.04637666f, 0.24277695f, 0.04293673f, 
    0.05996498f, 0.04057891f, 0.11395705f, 0.29092792f, -0.14485304f, -0.00457869f, 0.29527524f, 0.33709678f, 
    -0.05836697f, 0.15844713f, -0.00040797f, -0.02654983f, 0.10666008f, -0.10155624f, 0.00780735f, -0.02139783f, 
    -0.04552343f, 0.42933363f, 0.05173358f, -0.16535896f, -0.00729878f, 0.12729901f, 0.09526917f, 0.00090585f, 
    -0.11361612f, 0.10271081f, -0.17849955f, -0.06991009f, 0.02932863f, -0.46134618f, 0.30530319f, -0.17386962f, 
    0.07275497f, -0.06129974f, -0.02664207f, -0.23828527f, 0.14949761f, -0.03139665f, 0.10598896f, -0.09415856f, 
    -0.26052332f, -0.04377089f, -0.00696207f, -0.05237537f, 0.08888102f, 0.10992797f, -0.14263974f, 0.09623078f, 
    -0.12093945f, 0.00832745f, -0.03259179f, 0.04087774f, 0.08207706f, 0.08732133f, -0.00866582f, -0.06262518f, 
    -0.03094119f, 0.03942301f, -0.01859993f, -0.06627115f, -0.01162096f, -0.07937747f, 0.13317920f, -0.07083154f, 
    -0.11581084f, -0.01277768f, 0.46900862f, 0.07097272f, 0.10229533f, 0.13144010f, -0.03392553f, 0.06755944f, 
    -0.05875117f, 0.05806197f, -0.14810029f, -0.03023457f, 0.48250896f, -0.01122618f, -0.20545308f, -0.07578804f, 
    -0.05996601f, 0.05573382f, -0.12128491f, 0.06537217f, 0.03077980f, -0.01596223f, 0.21033248f, 0.00090594f, 
    0.09781802f, 0.14894722f, -0.11770795f, 0.24339238f, 0.04658873f, 0.05705739f, 0.01717413f, -0.26656827f, 
    -0.07898697f, 0.06646882f, -0.01657148f, 0.04982037f, -0.07551593f, 0.11992298f, 0.04531093f, 0.00907941f, 
    0.07148792f, -0.00136187f, -0.11246385f, -0.23346967f, -0.03233134f, -0.08555961f, -0.07281094f, -0.05495401f, 
    -0.05831736f, 0.07170062f, 0.11156873f, -0.00410860f, 0.06373813f, -0.10743356f, -0.04939948f, -0.02055393f, 
    -0.03625546f, 0.01631727f, 0.01797247f, 0.14062463f, 0.12041941f, -0.02473390f, -0.08665883f, 0.20678873f, 
    0.12097162f, -0.09462733f, 0.01961895f, 0.11305180f, 0.07646792f, 0.02257021f, 0.08557747f, -0.01822202f, 
    -0.01178261f, 0.00561797f, 0.08002470f, -0.04636243f, 0.05813926f, -0.11570419f, 0.01247256f, -0.13735703f, 
    0.18410422f, 0.04774979f, 0.05413117f, 0.00482916f, 0.03648816f, 0.08412167f, 0.16993135f, -0.16627081f, 
    -0.18606228f, -0.16241179f, 0.03667710f, -0.02983614f, -0.03274188f, 0.04684737f, 0.10508808f, -0.06607063f, 
    0.01721057f, -0.01363916f, 0.11842217f, -0.07724428f, 0.11686814f, 0.00771464f, -0.17531310f, 0.06562623f, 
    -0.00013505f, -0.02531761f, -0.04070071f, -0.31008953f, 0.06396696f, 0.15623122f, 0.06831916f, 0.11416879f, 
    -0.16269405f, 0.04229199f, 0.01302080f, 0.15650073f, -0.06147880f, 0.05351985f, -0.07929778f, -0.05319104f, 
    0.00160732f, -0.04812885f, 0.03838108f, 0.13260028f, -0.05916495f, -0.03295241f, 0.16990258f, 0.09703092f, 
    0.03940472f, 0.16389506f, 0.31961372f, 0.17798211f, 0.24309835f, 0.21778572f, 0.24612223f, 0.23896065f, 
    0.05816000f, -0.03792115f, 0.00125782f, 0.12651752f, 0.06770574f, 0.01097094f, 0.18282025f, 0.10378108f, 
    -0.03354729f, 0.01884751f, 0.07247438f, -0.17862310f, -0.00127413f, 0.07094637f, -0.05169290f, -0.05723057f, 
    -0.10251048f, -0.14536983f, -0.12062553f, 0.11738188f, -0.02857796f, -0.25237775f, 0.03419170f, -0.12937437f, 
    0.20072830f, 0.08236297f, -0.01669052f, -0.05784326f, 0.10944751f, -0.03371914f, 0.15938008f, 0.03501260f, 
    -0.18844019f, 0.00786181f, 0.01631536f, 0.28894433f, 0.42775676f, 0.02911323f, -0.12089828f, -0.05808117f, 
    0.07694241f, 0.13417436f, -0.02225652f, 0.01535544f, -0.11092658f, -0.05255108f, 0.20594023f, 0.17144030f, 
    0.10262324f, -0.06211186f, -0.03784445f, 0.06186750f, -0.01460672f, 0.08490655f, 0.07354850f, 0.02485567f, 
    -0.02792928f, 0.11090380f, 0.62031424f, -0.14042933f, 0.04545990f, -0.22770202f, 0.14467867f, 0.02574734f, 
    -0.17242011f, -0.18067907f, -0.03780646f, -0.32510930f, -0.04580073f, -0.13395040f, 0.04269884f, -0.06932016f, 
    -0.12770142f, 0.07796451f, 0.01508429f, 0.02457570f, 0.14034545f, 0.11523322f, 0.20208445f, -0.04714563f, 
    0.01001605f, 0.08978561f, -0.03460148f, 0.18360670f, 0.16481134f, -0.05899066f, -0.01204351f, -0.09747966f, 
    0.07301307f, -0.09162185f, 0.15828103f, -0.01836211f, 0.00589214f, 0.18054608f, 0.02440746f, -0.11438034f, 
    -0.02473647f, 0.23996747f, 0.09859796f, -0.15709244f, 0.05893758f, -0.06506846f, 0.01973458f, 0.01128244f, 
    -0.00264456f, 0.03251062f, -0.22780520f, -0.22140889f, -0.00906261f, -0.09686666f, 0.06098770f, -0.03003628f, 
    -0.00439899f, 0.16758165f, 0.16981706f, 0.02527042f, 0.20175578f, 0.03020141f, -0.20761138f, -0.25158072f, 
    0.10830908f, -0.16290371f, -0.05734682f, 0.11592261f, 0.00399061f, -0.03458313f, -0.05644742f, 0.04695224f, 
    -0.22666895f, 0.21852739f, -0.08952000f, -0.19590768f, 0.11277518f, 0.03180450f, 0.06629468f, -0.07355727f, 
    -0.04399340f, 0.07102439f, 0.20394713f, -0.00267366f, 0.06406764f, 0.18563722f, 0.05382251f, -0.27195042f, 
    -0.14390309f, -0.10673387f, -0.15347615f, -0.16945890f, -0.07396614f, 0.08263274f, 0.14932656f, -0.09997848f, 
    -0.06066085f, -0.04834162f, 0.21185790f, -0.27934346f, -0.04799565f, 0.01211609f, -0.25651258f, 0.15599331f, 
    -0.17039660f, 0.05778531f, -0.25728565f, -0.24371234f, -0.27991888f, -0.20406425f, 0.42361784f, -0.05483923f, 
    -0.18390952f, -0.07145417f, 0.08375936f, 0.13553315f, -0.06098866f, 0.01255407f, 0.09600645f, 0.05762738f, 
    0.07735089f, -0.22184375f, 0.14961569f, 0.05153774f, 0.12213275f, 0.07821853f, 0.05662075f, 0.04534618f, 
    0.03570458f, 0.20520645f, 0.31766224f, 0.09438176f, 0.19020130f, 0.15765439f, -0.26636213f, -0.17567699f, 
    0.01231050f, 0.00846812f, -0.00717748f, 0.18648225f, 0.20568310f, 0.01204961f, 0.29304364f, 0.19383113f, 
    0.10689662f, -0.24419521f, 0.33823347f, 0.18575311f, 0.17437604f, 0.04451285f, -0.00525538f, -0.11054857f, 
    0.03031179f, -0.02192855f, 0.08436228f, 0.22835344f, 0.08262178f, 0.17781170f, -0.04103840f, 0.01759094f, 
    0.16946156f, 0.09993557f, -0.18401663f, 0.07150291f, -0.06772852f, -0.13309722f, -0.01091224f, -0.13919695f, 
    0.08185271f, 0.23033281f, 0.07781618f, -0.00698876f, 0.06278263f, -0.14827609f, -0.14694628f, -0.14871548f, 
    -0.05900347f, 0.02203007f, -0.01721936f, 0.09279612f, 0.07981777f, -0.11367589f, -0.05448016f, -0.02663886f, 
    -0.04206399f, 0.03257126f, -0.07765355f, 0.05386512f, -0.14247318f, 0.05364754f, -0.11333076f, -0.07207333f, 
    0.02994956f, 0.05284503f, 0.04318224f, -0.27357396f, 0.05728351f, -0.35087398f, -0.00644269f, 0.15810622f, 
    -0.03360148f, -0.26553953f, 0.02600312f, -0.25751048f, 0.07399765f, 0.05460926f, 0.29118150f, 0.09806585f, 
    -0.04816099f, 0.04339379f, 0.01659274f, 0.12213991f, 0.04674465f, 0.11616711f, -0.25651488f, -0.10205360f, 
    -0.27991533f, -0.16373199f, 0.41899374f, -0.29116079f, 0.01653846f, 0.05149658f, 0.00677309f, 0.05938335f, 
    0.17045738f, -0.10030905f, 0.15739572f, 0.18782881f, 0.63708562f, 0.15417291f, 0.19019867f, 0.02831925f, 
    -0.04815827f, 0.25320679f, 0.14210947f, -0.00044043f, 0.10346358f, -0.01790456f, -0.00307274f, -0.01691417f, 
    0.03312061f, -0.02571008f, -0.06490190f, -0.00022975f, -0.06974639f, -0.06591086f, 0.04093843f, 0.02969528f, 
    0.00042155f, -0.00936353f, -0.04123758f, -0.03854748f, -0.01195046f, -0.00689546f, -0.06239785f, 0.04028255f, 
    0.00973423f, 0.01693126f, 0.00647958f, 0.02011713f, 0.00756980f, 0.01204761f, 0.05154931f, -0.01839651f, 
    -0.07128160f, -0.07672635f, 0.05896186f, 0.01047016f, -0.03581966f, 0.04128737f, -0.04899200f, 0.02012285f, 
    -0.01580117f, 0.00444521f, 0.02837241f, 0.03724664f, -0.00683916f, -0.00452552f, 0.04156376f, -0.05323930f, 
    0.05176500f, 0.03360197f, 0.02715412f, -0.01123854f, 0.00009443f, -0.05414375f, -0.00517442f, -0.03698502f, 
    -0.00463867f, 0.03477112f, 0.00862813f, 0.06055902f, -0.01292851f, -0.07237844f, -0.07211556f, 0.06218923f, 
    0.02205129f, -0.07057524f, -0.00120409f, 0.03043080f, 0.06032153f, 0.00393806f, -0.02803905f, 0.05693192f, 
    -0.03981042f, -0.05720018f, -0.05452917f, -0.04992711f, 0.06040499f, 0.06789296f, 0.05005069f, -0.03180888f, 
    0.00116537f, -0.02651222f, -0.02183831f, 0.05894513f, 0.03451511f, 0.03193028f, -0.03630856f, -0.04329841f, 
    0.06353071f, 0.03152455f, -0.04699754f, -0.02766670f, -0.04529402f, -0.06124382f, -0.00502888f, 0.04094780f, 
    -0.01832032f, -0.05962906f, 0.04112708f, -0.01719432f, 0.00295560f, 0.02731738f, -0.02239735f, 0.01510271f, 
    0.01718058f, 0.02907745f, 0.02100784f, -0.04427719f, -0.06365551f, 0.03027374f, 0.06477049f, -0.06124540f, 
    -0.04141179f, -0.06239622f, -0.02003084f, -0.04970438f, 0.00410548f, 0.06430049f, 0.04689868f, 0.01203714f, 
    -0.06362996f, -0.01594953f, -0.01760734f, -0.05977390f, -0.07009087f, -0.05808007f, 0.07815266f, 0.05091271f, 
    0.04757950f, -0.06696479f, 0.05266200f, 0.05242744f, -0.00044882f, 0.02817980f, -0.06303133f, 0.05643471f, 
    0.05584241f, 0.05197530f, -0.04011456f, -0.04565766f, -0.07551319f, -0.01137594f, -0.00672972f, -0.02250038f, 
    0.03524818f, -0.02859372f, -0.02639948f, -0.06596053f, 0.02144335f, 0.04968946f, 0.01373331f, 0.02706911f, 
    0.00477897f, 0.02617954f, -0.04888108f, 0.03201622f, 0.06697676f, 0.03036819f, 0.01161433f, -0.00210585f, 
    0.06627204f, 0.01477304f, 0.06746871f, 0.00886330f, 0.00452040f, -0.03452229f, -0.04631076f, -0.06734203f, 
    -0.03092075f, -0.00653566f, -0.02995335f, -0.05707301f, 0.02323748f, 0.02410429f, -0.01833054f, -0.04197560f, 
    -0.05054691f, -0.03167767f, -0.07289322f, -0.05197045f, -0.01143473f, -0.02851838f, 0.03526966f, 0.00215534f, 
    -0.02348551f, 0.01059778f, -0.05830783f, -0.01411759f, -0.02474482f, -0.03776313f, -0.00745758f, 0.01708600f, 
    0.05057262f, -0.04716248f, 0.05156096f, -0.06393246f, -0.00139513f, -0.03258125f, -0.05023257f, -0.04146417f, 
    0.23857209f, 0.30816156f, -0.04550323f, 0.08296566f, -0.02421745f, -0.02505912f, 0.05840396f, 0.07734792f, 
    0.04766291f, 0.02647285f, -0.10243694f, 0.00503550f, -0.10095417f, 0.08349846f, 0.13848799f, -0.10224466f, 
    0.03553855f, 0.07823151f, 0.01038523f, -0.05917348f, -0.01663741f, -0.04675643f, -0.16157030f, -0.13104370f, 
    -0.14160308f, -0.04214923f, -0.12974952f, 0.10569929f, 0.01504501f, 0.05271865f, 0.10033603f, 0.07858279f, 
    0.13628566f, 0.05020271f, 0.01060282f, 0.20032059f, -0.05634685f, 0.27372032f, -0.14038521f, 0.20505778f, 
    -0.07068459f, 0.00625693f, 0.00203922f, 0.07314257f, -0.11663534f, -0.06801662f, 0.02492160f, -0.01388138f, 
    0.10193369f, -0.08087156f, 0.02765764f, -0.08570279f, -0.14078885f, -0.00655794f, 0.14529942f, 0.12203388f, 
    -0.08451017f, 0.16236351f, -0.06715141f, 0.10986356f, -0.18761937f, -0.41285899f, 0.06314235f, -0.20832665f, 
    -0.13134494f, -0.20619054f, 0.07112597f, 0.12039482f, -0.05116919f, -0.03673010f, -0.05726833f, 0.01476593f, 
    0.13814612f, 0.16692822f, 0.06463341f, -0.13390860f, -0.00233125f, 0.13434197f, -0.06217405f, -0.04107223f, 
    0.09596809f, 0.02354569f, 0.09145583f, 0.05285285f, -0.15015823f, -0.36488602f, -0.22535466f, -0.09148277f, 
    0.04383972f, -0.05515972f, 0.05915472f, 0.10865421f, 0.10012984f, 0.02715789f, 0.16821156f, 0.05266484f, 
    0.29369500f, 0.03819552f, -0.13009371f, 0.14923336f, -0.08202896f, -0.06183513f, -0.01084920f, -0.06561999f, 
    0.04020654f, 0.11100902f, -0.04444508f, -0.03999605f, -0.08260449f, 0.15784985f, -0.16832617f, 0.26575524f, 
    -0.04649613f, 0.12783650f, 0.02691164f, 0.12696442f, -0.14722203f, -0.02848167f, -0.12387200f, -0.15917748f, 
    -0.09646251f, -0.21447144f, -0.30182520f, 0.02437887f, -0.25640228f, 0.01516739f, 0.20843787f, 0.12733106f, 
    0.04383647f, 0.05076285f, 0.08320706f, -0.00686738f, -0.05675790f, 0.03299361f, -0.12309480f, 0.07300519f, 
    -0.18957932f, 0.14279744f, 0.15334675f, -0.00563846f, 0.06697710f, -0.04197991f, 0.01157734f, 0.08048521f, 
    0.16240293f, -0.03675313f, -0.14816135f, 0.17398094f, -0.02057200f, 0.17440698f, -0.11106019f, -0.03535041f, 
    0.02937669f, -0.00601958f, -0.08751369f, -0.02754643f, -0.05444686f, 0.02050142f, 0.26766172f, -0.12224977f, 
    0.16722547f, 0.02448099f, 0.04412937f, 0.08075409f, 0.04509800f, -0.02305015f, -0.00156881f, 0.03961322f, 
    -0.28513354f, -0.50357693f, -0.05264887f, -0.33872044f, -0.14223137f, 0.11026383f, -0.03631330f, 0.14816463f, 
    0.14450242f, 0.01667782f, 0.03077803f, 0.26066378f, 0.43136099f, -0.22298463f, 0.32785150f, -0.06204443f, 
    -0.06564190f, -0.04572138f, -0.00530489f, 0.12437370f, -0.06348748f, -0.16368409f, 0.13291070f, -0.03222781f, 
    0.28208515f, 0.03394064f, -0.12778738f, -0.27995911f, 0.04729473f, 0.07603432f, 0.09549224f, -0.01271939f, 
    -0.02316286f, 0.16377315f, 0.08909400f, 0.05636780f, 0.36431268f, 0.21148971f, -0.03632322f, -0.29128218f, 
    0.06121300f, 0.07764037f, 0.05923146f, 0.12163464f, -0.09237805f, -0.04716794f, -0.07385509f, 0.12375383f, 
    -0.20116548f, 0.17153442f, 0.20365220f, -0.15386426f, -0.03236740f, -0.06875703f, -0.07630166f, -0.19462094f, 
    0.13046624f, 0.09822452f, 0.02241343f, 0.07643795f, 0.18072437f, -0.28334996f, 0.09355707f, -0.04332452f, 
    -0.25734004f, 0.07730652f, -0.27796340f, -0.50227183f, 0.01741039f, 0.19292209f, 0.06169125f, 0.11296263f, 
    -0.04563496f, 0.24164462f, -0.12496144f, 0.05671959f, 0.03479136f, -0.00634235f, 0.13352190f, -0.02988158f, 
    -0.24384816f, -0.05665477f, -0.26308775f, -0.32942563f, 0.05616326f, -0.04400927f, 0.00743999f, -0.00130510f, 
    -0.13097881f, 0.02691033f, 0.00974769f, 0.03527396f, -0.09688658f, -0.08790557f, -0.17983392f, -0.02811825f, 
    -0.15833057f, -0.08133909f, 0.08680555f, -0.12930641f, -0.10578090f, 0.13540760f, -0.02487130f, -0.07752681f, 
    0.19848904f, 0.28919497f, 0.16323932f, 0.27459961f, 0.31192911f, 0.20004459f, 0.05763147f, -0.15222786f, 
    0.02473030f, 0.04370613f, 0.07348290f, -0.07772305f, 0.05095466f, -0.06357908f, 0.10339952f, 0.09251514f, 
    0.21546060f, -0.15232208f, 0.21553685f, 0.16397762f, 0.11590782f, -0.05322799f, -0.04817892f, 0.01724621f, 
    -0.23439296f, -0.02868081f, 0.03212341f, 0.03711333f, -0.25008109f, 0.17146091f, -0.21246931f, -0.07935602f, 
    0.05957726f, -0.04923021f, -0.07790842f, -0.05754272f, -0.37263390f, -0.28658611f, -0.28317782f, -0.07303288f, 
    0.55064851f, 0.49198937f, 0.10731414f, -0.11036732f, 0.28457782f, -0.12011614f, 0.08408294f, 0.00548682f, 
    -0.00995224f, -0.04389631f, 0.07644583f, -0.02420818f, 0.19190073f, -0.35065347f, 0.10128464f, 0.01653372f, 
    -0.05564105f, -0.17177488f, -0.13543621f, -0.09721802f, 0.03248407f, 0.05903188f, 0.07508755f, 0.17609885f, 
    0.10660573f, 0.27571282f, -0.17268965f, -0.19883919f, 0.03766994f, -0.30266571f, -0.01719800f, 0.13544863f, 
    -0.13526252f, -0.10470548f, 0.04741825f, -0.32596126f, -0.35531005f, 0.18593729f, 0.07882874f, 0.16131395f, 
    -0.06827231f, -0.03430049f, 0.07373556f, -0.12644909f, 0.04333188f, 0.05633489f, 0.12708446f, -0.02719297f, 
    -0.00320544f, 0.38149509f, 0.29466262f, 0.13717093f, -0.14543208f, 0.01241646f, 0.06844023f, -0.07231832f, 
    0.02500381f, 0.01674661f, 0.07127839f, 0.14657336f, -0.20847033f, 0.08803950f, 0.21046679f, 0.13072734f, 
    -0.18090728f, -0.00983823f, 0.07848424f, -0.23208401f, 0.02227106f, -0.03548642f, -0.04337788f, 0.04979726f, 
    0.18959126f, -0.14856572f, 0.09918310f, 0.25481299f, -0.07408180f, 0.15179066f, 0.17263837f, 0.03827129f, 
    0.07948303f, 0.13735175f, -0.09112464f, 0.14800176f, 0.03910647f, -0.20962386f, -0.06286285f, -0.16547354f, 
    -0.04380129f, 0.05964319f, 0.09246103f, 0.00997822f, -0.10278571f, -0.25255394f, -0.10176507f, 0.07035109f, 
    0.08063327f, 0.01884760f, -0.12753341f, -0.20804292f, -0.18356511f, -0.03256217f, 0.00221344f, -0.03464385f, 
    0.14508061f, 0.16166089f, 0.15619718f, 0.11489320f, 0.36313257f, 0.32092243f, 0.31440046f, 0.43450049f, 
    -0.18547235f, 0.01110368f, -0.10784815f, 0.07682099f, 0.27544597f, 0.08279727f, 0.08957294f, 0.10456228f, 
    -0.09365968f, 0.05980473f, -0.13876855f, -0.04770420f, 0.04032837f, -0.01654713f, 0.05306435f, -0.08449023f, 
    -0.22983210f, -0.18662360f, -0.16253997f, -0.33695704f, 0.27956346f, -0.03357268f, 0.10423186f, 0.19256158f, 
    -0.06458969f, -0.11513266f, -0.08701885f, -0.11906935f, -0.09608586f, -0.02755585f, -0.09289570f, -0.16699526f, 
    0.12181572f, 0.00724456f, -0.04101061f, 0.02685871f, -0.03574919f, 0.07052448f, 0.21465118f, 0.14358935f, 
    0.25419909f, 0.29628894f, 0.21580781f, 0.40175849f, 0.15558617f, 0.00515746f, 0.08794555f, 0.08339899f, 
    -0.16978179f, 0.03029195f, -0.00362927f, -0.02966008f, 0.08632220f, 0.10076562f, 0.14949939f, 0.04786329f, 
    0.16356421f, -0.17858011f, 0.05562366f, 0.17724046f, 0.09588576f, -0.13338836f, -0.23248594f, -0.04557643f, 
    -0.26614100f, -0.07218655f, -0.05117381f, -0.06939878f, -0.15315676f, 0.02111749f, -0.15642270f, -0.02397440f, 
    -0.14994377f, 0.00947225f, 0.01439155f, -0.07220978f, -0.12409195f, -0.30507559f, -0.43477684f, -0.27170253f, 
    0.15374470f, 0.24743980f, 0.23523989f, -0.02510809f, -0.25105900f, -0.09432027f, 0.12425940f, 0.07366170f, 
    0.04948537f, 0.16218735f, 0.05435019f, -0.02155203f, -0.00188252f, 0.20974790f, 0.08920996f, 0.08300982f, 
    -0.05481783f, 0.00029498f, -0.03581964f, 0.01275120f, 0.10649184f, -0.00423183f, 0.17554682f, 0.24238002f, 
    -0.02769071f, 0.28420749f, -0.18880707f, -0.11407733f, -0.11576454f, -0.13635476f, -0.07395943f, 0.03866186f, 
    -0.13938960f, -0.04855767f, -0.08026403f, -0.20387113f, -0.01304815f, 0.05900436f, -0.09824551f, 0.02778946f, 
    -0.20268640f, 0.09200294f, 0.11926117f, 0.13448392f, 0.00056745f, -0.01233289f, 0.13079654f, -0.03382600f, 
    0.18201831f, 0.32728422f, -0.01527665f, -0.12707964f, -0.15273671f, -0.08054051f, 0.03691600f, -0.11451200f, 
    -0.05939844f, 0.17516531f, 0.07906251f, 0.09795000f, -0.12848152f, -0.20302007f, -0.10758839f, -0.01088735f, 
    0.04514353f, 0.04606891f, -0.10953243f, -0.09133538f, -0.13530682f, -0.09725942f, -0.03969187f, -0.12101009f, 
    0.02067980f, -0.00979988f, -0.01744694f, -0.02032921f, 0.05389768f, 0.01809374f, -0.04265676f, 0.02042402f, 
    -0.03623014f, -0.06105362f, -0.03838465f, 0.05352856f, -0.03899239f, 0.04977765f, 0.02499335f, -0.04412606f, 
    0.02075094f, -0.01768852f, 0.02081547f, 0.05691625f, 0.03310557f, -0.03375452f, -0.07847522f, 0.02122979f, 
    -0.01783293f, -0.05964156f, 0.03652456f, 0.03568549f, -0.02641065f, -0.01542930f, -0.07555981f, 0.04881296f, 
    0.01468201f, -0.06441949f, -0.07721925f, -0.07798452f, 0.04061363f, 0.00351506f, 0.00561158f, -0.04172862f, 
    0.03961708f, -0.04329178f, 0.00404525f, 0.04507807f, 0.04333367f, 0.04617124f, 0.05635456f, -0.07144588f, 
    -0.04187901f, -0.03967616f, -0.01335883f, -0.02511394f, 0.05763053f, -0.02608948f, -0.05972738f, -0.04660749f, 
    -0.00136131f, 0.00554599f, -0.08009169f, -0.07370877f, -0.00442464f, -0.07000221f, 0.00014828f, -0.06805495f, 
    -0.04107121f, -0.00916823f, -0.06103097f, -0.06587387f, -0.03480234f, -0.03829327f, -0.04622222f, -0.02636926f, 
    -0.06112305f, -0.07613450f, -0.07092000f, -0.03654454f, 0.00537401f, 0.05934355f, 0.01096139f, 0.02092757f, 
    0.05482517f, 0.01452842f, 0.01379060f, 0.02524244f, -0.05099314f, 0.05124998f, -0.01925035f, -0.02834903f, 
    -0.06795695f, 0.05536920f, 0.00823962f, 0.03539398f, 0.02835863f, 0.05508415f, 0.05962415f, 0.03745564f, 
    0.05176068f, -0.04054494f, 0.01195606f, -0.08372628f, -0.02976357f, -0.06737732f, 0.05171686f, 0.01111753f, 
    -0.06048827f, -0.06678843f, 0.00148060f, -0.02859430f, -0.02715220f, -0.04759999f, -0.08601151f, 0.00959225f, 
    -0.08143494f, 0.03386054f, -0.08243205f, -0.01205617f, -0.04370017f, 0.05687774f, -0.04434752f, 0.03483287f, 
    -0.01185574f, 0.01348427f, -0.03284660f, 0.00060094f, 0.03083179f, -0.05653907f, 0.03296160f, -0.03792955f, 
    0.04220524f, 0.02884288f, 0.05233032f, 0.04297791f, 0.02785476f, -0.07910327f, 0.01849858f, 0.04862140f, 
    0.00218662f, -0.01868732f, -0.02769566f, -0.01624617f, 0.01797086f, -0.04596433f, 0.02864994f, -0.00190249f, 
    0.01278192f, -0.01713994f, 0.00479162f, 0.05391498f, -0.06674469f, 0.01471991f, -0.05483982f, 0.02808395f, 
    -0.08301960f, 0.02750526f, -0.05061193f, -0.05729303f, -0.07257868f, -0.03170532f, 0.05746914f, 0.04474181f, 
    -0.01403469f, -0.04743437f, 0.02210347f, -0.04792125f, -0.06884900f, -0.06277607f, -0.01115335f, -0.02151555f, 
    0.01122663f, -0.01303873f, -0.05665832f, -0.07844774f, 0.00117384f, -0.07173233f, 0.04242786f, 0.06079837f, 
    -0.06126976f, 0.02157654f, 0.04917968f, 0.00269754f, 0.03833260f, -0.07393834f, 0.03849221f, 0.01119038f, 
    -0.06450909f, -0.00152265f, -0.08165221f, 0.04651700f, -0.02246308f, 0.01313017f, -0.03302259f, -0.04318643f, 
    -0.12245707f, 0.10040689f, 0.02806327f, 0.08251331f, -0.20195988f, -0.01234637f, 0.08450084f, 0.04733246f, 
    -0.03096388f, 0.06915724f, 0.13373210f, -0.05091181f, -0.17110680f, -0.00936665f, -0.00284208f, -0.02823582f, 
    -0.10402562f, -0.00402782f, 0.02245202f, 0.00199995f, -0.00712857f, -0.05800628f, 0.14932127f, -0.05285037f, 
    -0.14940512f, 0.11037647f, -0.15128912f, 0.24373463f, -0.13544130f, 0.04163552f, 0.18367374f, 0.12598567f, 
    0.05719155f, -0.09614697f, 0.18705514f, 0.09547929f, 0.28564724f, 0.45780778f, 0.11795320f, 0.00900113f, 
    0.00581578f, -0.09887362f, 0.08553050f, 0.11711055f, 0.06711289f, -0.06233823f, 0.04346559f, 0.19340168f, 
    -0.05313368f, -0.23483005f, 0.00331056f, -0.03967576f, 0.16013096f, 0.17559092f, -0.11125506f, 0.17574207f, 
    -0.03027414f, -0.00196906f, -0.00587118f, -0.10135191f, 0.11224666f, 0.16384333f, 0.34398046f, -0.01469464f, 
    0.15865242f, -0.02111904f, 0.04849875f, -0.03896353f, -0.08483098f, -0.21166410f, 0.00477172f, -0.17813322f, 
    0.14179170f, 0.15421800f, -0.22726291f, -0.02450464f, 0.03954785f, 0.09098694f, 0.03488009f, 0.05839377f, 
    0.25489271f, 0.13662648f, 0.22810303f, 0.13601694f, -0.09407963f, 0.12476094f, 0.10814924f, 0.04051534f, 
    -0.04476497f, 0.09802446f, 0.02938362f, -0.11035447f, 0.07350750f, 0.07434259f, -0.00296474f, 0.08151244f, 
    -0.23268190f, -0.44160172f, 0.16958287f, -0.08036630f, 0.23460972f, -0.00329546f, -0.00755046f, -0.00570923f, 
    0.17435077f, 0.08642387f, -0.06229767f, 0.07887404f, -0.01099725f, 0.02111717f, 0.00494126f, 0.14595675f, 
    -0.11769843f, -0.03347501f, -0.06859673f, 0.16455863f, -0.02183171f, -0.13244158f, -0.07017411f, -0.19170162f, 
    -0.09748846f, -0.10416043f, 0.30407938f, 0.27666274f, -0.18119752f, 0.05581981f, 0.01912724f, 0.02522626f, 
    0.00271353f, 0.14990631f, -0.00972094f, -0.02707862f, 0.12785049f, 0.16571106f, 0.14862393f, 0.04839956f, 
    0.00770479f, -0.10888842f, -0.01172520f, 0.08499441f, 0.02708970f, -0.06574725f, 0.07191835f, 0.12253838f, 
    -0.07528856f, 0.26114696f, 0.06088812f, -0.10269722f, -0.11750204f, 0.09360486f, 0.01053580f, -0.01013520f, 
    0.18284854f, -0.00176389f, 0.04131788f, 0.04076264f, -0.23694988f, -0.13815646f, 0.07338817f, 0.20101148f, 
    -0.07795868f, 0.01040148f, 0.11411026f, 0.21555568f, -0.08153066f, 0.06630641f, -0.07844235f, -0.08332701f, 
    -0.45936459f, -0.32813069f, 0.04123475f, -0.11389253f, -0.09344385f, 0.09438935f, -0.01836218f, 0.08597111f, 
    -0.00480687f, 0.04361370f, -0.04414400f, 0.20552270f, 0.02629595f, -0.14416596f, -0.20203461f, 0.14426878f, 
    -0.03922289f, 0.06937847f, -0.03790189f, 0.03187918f, 0.00747684f, -0.02364280f, -0.15764005f, -0.11666739f, 
    0.32744968f, -0.00109105f, 0.18148948f, -0.03521746f, 0.05024621f, 0.09871559f, 0.06286789f, 0.05574308f, 
    0.00993195f, 0.00243769f, -0.17023741f, 0.06654643f, 0.12981990f, 0.09562049f, 0.06817877f, -0.18992975f, 
    0.04258003f, 0.10934755f, 0.09227174f, 0.11172927f, -0.03058004f, -0.07868484f, -0.01254144f, 0.04760492f, 
    -0.23856260f, 0.03684927f, -0.00691448f, 0.07494976f, 0.03924517f, 0.14091964f, 0.11200617f, -0.02935833f, 
    0.15459317f, 0.09251460f, -0.08037750f, 0.05327280f, 0.36070687f, 0.14956772f, -0.06876618f, 0.28135574f, 
    -0.16295981f, 0.16811024f, 0.03672956f, -0.10233605f, 0.01595592f, 0.03562729f, -0.11947274f, 0.24747737f, 
    -0.03756841f, -0.02444830f, -0.18101960f, 0.27513966f, 0.12592298f, -0.08138116f, 0.31050426f, -0.25470191f, 
    -0.07601748f, 0.05454557f, -0.03622697f, 0.01174038f, 0.31669444f, -0.06533442f, -0.23585594f, 0.18435419f, 
    -0.01388606f, 0.03689527f, 0.04429886f, 0.00342599f, -0.05562605f, -0.11836006f, -0.27384272f, 0.10474783f, 
    -0.07931416f, 0.01452864f, 0.06076347f, -0.10583430f, 0.03979632f, 0.16265559f, 0.10441215f, 0.06366146f, 
    0.13280208f, 0.21266416f, -0.04359956f, 0.25730616f, 0.26099059f, 0.02994215f, 0.08148560f, -0.15727392f, 
    0.13437960f, 0.01858055f, 0.06122883f, 0.02274428f, 0.10131172f, 0.08425615f, -0.06946443f, 0.01271661f, 
    0.26675019f, -0.04262057f, 0.01879291f, 0.10153592f, -0.01607223f, -0.31609413f, -0.05089723f, 0.06027194f, 
    -0.04201840f, 0.10004385f, -0.02358676f, -0.20844980f, 0.06597034f, -0.05460811f, -0.34767693f, 0.20178744f, 
    -0.16237065f, 0.03824187f, 0.04183561f, 0.05858927f, -0.14614195f, -0.19972873f, -0.25397012f, -0.13756767f, 
    0.39008471f, 0.00447969f, -0.00986705f, 0.02401389f, -0.11932858f, -0.16718771f, 0.05335817f, 0.27667770f, 
    0.19342785f, 0.06456795f, 0.04871358f, -0.07930087f, 0.07364520f, 0.06623614f, -0.08008881f, -0.01922874f, 
    -0.15389784f, -0.13485180f, -0.06795028f, -0.08492967f, 0.06883857f, -0.04624151f, 0.06987644f, 0.11336563f, 
    0.01089082f, 0.24772328f, -0.28758335f, -0.11874445f, -0.00594778f, 0.21926658f, 0.01672134f, -0.04673119f, 
    -0.04160142f, 0.06930599f, -0.00867647f, 0.13821232f, -0.49211356f, 0.14814807f, -0.09542591f, 0.07237007f, 
    -0.06830163f, 0.12943169f, 0.01580936f, -0.24882108f, 0.09527761f, -0.01241328f, 0.19055134f, -0.00420940f, 
    -0.05821109f, -0.03826490f, 0.00421792f, 0.13176447f, -0.12346032f, 0.00701547f, -0.05838534f, 0.07472685f, 
    0.16006964f, 0.15648721f, -0.03752797f, -0.03567094f, -0.41644284f, -0.09250439f, 0.07565715f, 0.27565640f, 
    0.00688459f, -0.23624362f, -0.15239649f, -0.05698870f, 0.07016596f, -0.01573910f, -0.05767146f, 0.00194944f, 
    -0.43333980f, -0.09860730f, -0.08173815f, -0.35204887f, 0.10507022f, 0.09478414f, 0.07234162f, -0.00479403f, 
    0.11594974f, 0.00822536f, -0.00584484f, -0.01501233f, -0.00555505f, 0.09600798f, -0.01783567f, -0.11757950f, 
    -0.02536066f, -0.03673213f, -0.07045884f, -0.18209127f, 0.02539740f, 0.08783828f, 0.21450795f, 0.17980191f, 
    0.39561045f, -0.07731918f, 0.26360095f, 0.26223940f, 0.09029929f, -0.05313748f, 0.02524205f, 0.31682876f, 
    0.01096678f, 0.10741576f, 0.08197777f, -0.02078637f, -0.07308252f, -0.65357035f, -0.00154429f, -0.37684280f, 
    -0.02008080f, -0.09824663f, -0.10948659f, -0.10939533f, 0.06751233f, -0.09661157f, -0.26088119f, -0.11835632f, 
    -0.03138310f, 0.24615365f, -0.08798258f, -0.01037722f, 0.17342782f, 0.14305836f, -0.06341126f, 0.12856781f, 
    0.08613901f, -0.05373667f, 0.12864400f, 0.08885453f, -0.38722277f, 0.11206046f, -0.16711372f, -0.04637052f, 
    -0.14117230f, 0.21320060f, 0.01993541f, -0.05292196f, 0.35361215f, 0.02058446f, 0.05256868f, 0.03937954f, 
    -0.23815648f, -0.06097217f, -0.18070242f, -0.02718723f, 0.12557295f, 0.02140965f, 0.00728524f, -0.04493916f, 
    -0.12391925f, 0.08417565f, 0.04407077f, -0.03321602f, -0.03676581f, -0.04149571f, 0.25617045f, -0.13015147f, 
    0.11804877f, 0.10756171f, 0.03744480f, -0.16025534f, 0.01527056f, 0.03721586f, -0.08716349f, 0.11796702f, 
    0.01151435f, 0.36933446f, 0.04893728f, 0.06743997f, -0.01080178f, 0.09162743f, 0.02914713f, -0.04757118f, 
    -0.06110823f, -0.11724835f, -0.02428935f, 0.05514269f, 0.04937528f, -0.11558705f, 0.10909370f, -0.04861309f, 
    -0.21726201f, -0.26240271f, -0.03775067f, -0.17200401f, 0.02875953f, -0.09537182f, 0.14428079f, 0.17221642f, 
    -0.17287394f, 0.26708516f, 0.09138590f, -0.13334590f, 0.07282846f, -0.16516498f, -0.08630372f, -0.09312052f, 
    0.01514004f, -0.14624949f, 0.02361860f, 0.02622614f, 0.08415503f, -0.10191940f, -0.15021130f, -0.14108424f, 
    0.02121071f, -0.07160289f, -0.08205590f, -0.13469067f, -0.14489129f, -0.02291471f, 0.12605526f, -0.17412685f, 
    -0.00173890f, -0.21729052f, 0.12094400f, -0.04412956f, 0.22164795f, 0.05685081f, -0.17408678f, -0.05485152f, 
    0.06929319f, 0.02837892f, 0.01142580f, 0.17401907f, 0.31522036f, 0.08005380f, 0.16124737f, 0.23884305f, 
    0.11574232f, 0.02931054f, -0.07223742f, 0.09848242f, -0.17112152f, 0.01050398f, 0.10586970f, 0.17995915f, 
    -0.17889640f, 0.12310806f, 0.46392021f, 0.36841157f, 0.20636672f, 0.05626536f, 0.09297068f, -0.03684987f, 
    0.20473142f, 0.19405416f, 0.02088497f, -0.00072047f, 0.19067703f, 0.12504724f, 0.19176532f, 0.17909499f, 
    0.03055976f, 0.05716895f, -0.03415324f, 0.08609551f, -0.19421016f, 0.08764320f, -0.02239888f, 0.05279398f, 
    0.10169150f, 0.07958080f, -0.23512763f, -0.12484568f, 0.09810266f, 0.14201467f, 0.01451657f, -0.00774466f, 
    -0.09552319f, -0.01204814f, -0.06809095f, -0.24986976f, 0.20537865f, 0.04674848f, -0.13837439f, -0.05212496f, 
    0.08258370f, -0.04553686f, 0.08671158f, 0.09589320f, 0.00527132f, 0.07573103f, -0.10906409f, -0.06215452f, 
    -0.01377873f, 0.17578335f, 0.07611240f, -0.06370203f, 0.03663822f, 0.02658508f, -0.00376027f, 0.01384499f, 
    0.10881434f, -0.04521542f, -0.02185871f, 0.03534047f, -0.35431474f, -0.11785187f, -0.02543250f, 0.09544301f, 
    -0.01308129f, 0.09013131f, 0.00167938f, 0.04459121f, -0.09647660f, 0.05892867f, -0.01630651f, -0.15702131f, 
    -0.04382031f, 0.16207778f, 0.11959362f, 0.02203398f, 0.18029374f, -0.16958140f, 0.03019130f, 0.01258431f, 
    0.14483190f, 0.15109102f, 0.10108774f, 0.12182032f, -0.13371691f, -0.12291118f, 0.10033803f, -0.09125102f, 
    -0.07951140f, 0.16617639f, -0.03626943f, -0.11567304f, -0.17029203f, -0.10377552f, 0.07080799f, 0.11607677f, 
    -0.17002316f, 0.06912906f, 0.04621602f, -0.04651580f, 0.15218322f, 0.07417344f, -0.05752711f, 0.07334850f, 
    0.00537960f, -0.12435073f, -0.11830947f, -0.46529374f, 0.12050024f, 0.02882034f, -0.25208217f, -0.25850660f, 
    0.17927125f, -0.00330784f, -0.03634540f, 0.05770449f, 0.07194609f, 0.07260472f, -0.10388103f, -0.08113746f, 
    -0.15986109f, -0.03454374f, 0.07980457f, 0.04218521f, -0.21206053f, -0.03157133f, 0.05230448f, -0.04883731f, 
    -0.06390708f, -0.11796594f, 0.04384537f, 0.06612270f, -0.19800545f, 0.10023328f, -0.06688365f, -0.14780948f, 
    -0.05231953f, 0.07958792f, 0.06899691f, -0.06764281f, -0.21562915f, 0.05621915f, 0.13196872f, 0.14744540f, 
    0.16166034f, -0.07521540f, -0.11821106f, -0.03320804f, -0.07859542f, 0.01494767f, 0.10812925f, -0.11317645f, 
    0.15240206f, -0.00085120f, 0.10404392f, -0.10130633f, -0.24836598f, -0.08282178f, -0.06382444f, 0.00014307f, 
    0.09827471f, 0.01890787f, -0.05200198f, 0.18229610f, 0.06397931f, 0.08013236f, -0.11911998f, -0.16458106f, 
    0.48561463f, -0.16714971f, -0.17055264f, 0.36573139f, -0.09926368f, -0.04552561f, 0.02915071f, 0.05240427f, 
    0.05608601f, 0.18122461f, 0.10653292f, 0.13420022f, 0.11283020f, -0.02841160f, 0.06731036f, -0.10310409f, 
    0.11445723f, -0.12854178f, -0.08243665f, 0.11170742f, 0.00061455f, 0.02249886f, 0.00484503f, 0.14183125f, 
    0.30283490f, -0.00488740f, 0.18371916f, -0.18959780f, 0.13672177f, -0.02486129f, 0.07981069f, 0.15421775f, 
    0.20787780f, -0.02107648f, -0.04685747f, -0.00366362f, -0.12808006f, -0.06313135f, 0.01254595f, 0.02549275f, 
    -0.04054969f, -0.03374896f, -0.01981297f, -0.01298989f, 0.00268673f, 0.16046917f, 0.16853505f, 0.13840489f, 
    0.00086213f, -0.01302428f, 0.00391209f, -0.02065056f, -0.03838834f, -0.04932047f, -0.03859129f, -0.04576997f, 
    0.03654087f, 0.03280128f, 0.00204320f, -0.01498888f, -0.03690671f, 0.00500631f, -0.03367804f, -0.00227479f, 
    0.01141683f, -0.01265201f, -0.00099756f, -0.05663520f, 0.01613409f, 0.00087635f, 0.02110192f, -0.06757814f, 
    -0.03600427f, -0.05376586f, -0.02373161f, -0.08166178f, -0.03296364f, 0.00055636f, -0.07862714f, -0.01101551f, 
    0.00286752f, -0.07947420f, 0.03073112f, -0.08410691f, -0.07227822f, -0.01551522f, 0.05488452f, 0.00945192f, 
    -0.00565080f, -0.03441050f, 0.05528364f, -0.03890014f, -0.02880311f, -0.07148127f, 0.00527966f, -0.01713432f, 
    0.03839686f, -0.02238514f, -0.05328506f, -0.04879535f, -0.05682362f, 0.04498031f, -0.01149403f, -0.03547503f, 
    -0.04685221f, 0.04049476f, 0.02008069f, 0.03660683f, 0.03516329f, 0.00789697f, 0.00892708f, -0.01630477f, 
    -0.00003635f, -0.05676870f, 0.03707999f, -0.01404551f, 0.00418367f, 0.00589224f, -0.02024554f, -0.00148419f, 
    -0.06970628f, 0.04875278f, 0.00966855f, 0.02645869f, 0.03274683f, 0.02691874f, -0.02764441f, -0.01706347f, 
    -0.02230569f, 0.00851292f, -0.01168948f, -0.07334547f, -0.03231842f, 0.01916903f, -0.02069104f, -0.04214933f, 
    0.02766079f, 0.00370906f, -0.05799252f, -0.04873720f, 0.02711739f, -0.03208246f, -0.05972013f, 0.03796501f, 
    -0.03357435f, -0.04400162f, -0.04433575f, 0.04869423f, -0.00080061f, 0.05816559f, -0.04228164f, 0.00103309f, 
    -0.02817646f, 0.03495868f, 0.03506973f, -0.01164155f, -0.02963751f, -0.06682882f, -0.03079503f, -0.05328292f, 
    -0.00334604f, -0.02386553f, -0.07134788f, -0.03895114f, 0.03219422f, 0.06145839f, 0.03921557f, 0.00330850f, 
    0.02294758f, -0.04606779f, 0.02000635f, -0.07302944f, -0.06203373f, 0.03421993f, -0.00247206f, 0.01275009f, 
    -0.03749102f, 0.02656754f, -0.03093529f, 0.04194950f, 0.04767705f, 0.00504698f, 0.00705214f, 0.02065132f, 
    0.02969256f, -0.01931663f, -0.06453235f, 0.05981391f, 0.02061678f, -0.05909418f, 0.00314455f, 0.01370515f, 
    -0.05815269f, -0.06967950f, 0.05670607f, 0.03147028f, 0.05827877f, -0.06080901f, -0.06017103f, -0.06941499f, 
    0.05166820f, 0.01442285f, -0.04993848f, 0.04883278f, -0.07730610f, -0.07844447f, -0.05439290f, 0.06378619f, 
    0.00522225f, 0.00289105f, -0.01806823f, -0.05136877f, 0.04341990f, 0.05002747f, -0.07201079f, -0.06157226f, 
    0.02324205f, 0.03079596f, 0.05547011f, -0.01950382f, -0.02076430f, 0.03857014f, 0.05467916f, 0.04384390f, 
    0.03741619f, -0.04765519f, 0.04785534f, 0.05208591f, -0.07037753f, -0.01809128f, 0.01997758f, -0.04946480f, 
    0.04031025f, -0.05241897f, -0.05333421f, -0.06417745f, 0.06269260f, -0.06664833f, 0.01786818f, -0.00318900f, 
    0.01143794f, 0.01395874f, 0.03560549f, 0.02996554f, -0.01537992f, -0.02951867f, -0.04365025f, 0.01271699f, 
    -0.06892874f, 0.01024360f, 0.00515299f, 0.04969591f, 0.03577591f, -0.04808728f, -0.00831581f, -0.04412476f, 
    0.00101915f, -0.04450906f, 0.04323700f, 0.00044649f, -0.00257428f, 0.00360271f, -0.06041127f, 0.02573841f, 
    -0.06746833f, 0.03891253f, -0.01034769f, 0.04039223f, 0.05495139f, 0.03053334f, 0.05711564f, 0.01715142f, 
    -0.02050867f, -0.02440655f, -0.01587491f, -0.00797571f, -0.04075998f, 0.03021789f, 0.03732831f, -0.05966336f, 
    0.03920390f, 0.04469176f, -0.04476227f, -0.04095912f, -0.07934821f, -0.05465729f, -0.03466737f, 0.06323434f, 
    0.01964633f, -0.02417416f, -0.06039906f, 0.03917637f, 0.02460726f, 0.01302957f, 0.03793791f, 0.06080474f, 
    -0.04513666f, -0.06235898f, -0.02740682f, 0.02829374f, -0.03421510f, 0.02400003f, -0.04344839f, -0.05743812f, 
    -0.04231965f, -0.06193332f, 0.06124966f, 0.02950002f, 0.05830337f, -0.03846839f, 0.03503836f, 0.01452820f, 
    -0.03009835f, 0.03729913f, -0.05332382f, -0.00708165f, -0.01071476f, 0.01552685f, 0.00660109f, 0.02791663f, 
    -0.08515553f, -0.08093361f, -0.06764472f, -0.08084605f, -0.07869083f, -0.03542623f, 0.04725045f, 0.04552694f, 
    0.03545455f, 0.04645153f, -0.02548438f, -0.01443807f, -0.07373689f, 0.01634859f, -0.03109811f, -0.06023346f, 
    0.04801509f, -0.06390309f, -0.02838169f, -0.08214324f, -0.00448007f, -0.02616277f, 0.00895984f, 0.05270909f, 
    0.01230760f, -0.04489349f, -0.02564974f, 0.00119133f, -0.03210687f, 0.06022828f, 0.05939254f, -0.02452103f, 
    0.03757773f, -0.00182019f, 0.04026552f, 0.01751166f, -0.02029631f, 0.03838601f, -0.04118587f, -0.06403509f, 
    -0.01422829f, -0.00741198f, 0.05488325f, 0.00161511f, -0.07075655f, 0.05230102f, 0.05686611f, -0.06807662f, 
    0.03046354f, -0.02196871f, -0.04138444f, -0.03426963f, -0.02743569f, -0.04287950f, -0.03694378f, 0.00790699f, 
    -0.02450479f, 0.03609863f, -0.04713485f, -0.07645966f, 0.05647686f, -0.00012494f, -0.03603625f, 0.01359009f, 
    0.02632150f, -0.07499050f, -0.02664444f, -0.05861034f, -0.03717802f, -0.02880247f, -0.03866337f, 0.05749562f, 
    0.03850617f, 0.03560842f, -0.04045165f, -0.01226356f, -0.03943925f, 0.00894776f, -0.02554934f, -0.07407095f, 
    0.04473536f, 0.00883040f, 0.01828610f, 0.05774700f, 0.03992499f, -0.01054695f, -0.04598997f, 0.01536408f, 
    0.02414171f, -0.04879617f, -0.02220185f, 0.05420604f, -0.02674003f, 0.04792449f, -0.05209037f, -0.03658032f, 
    -0.02678986f, -0.02190294f, -0.06995336f, 0.01360533f, -0.01126326f, 0.04753353f, 0.00146993f, -0.03792524f, 
    -0.05847324f, -0.02961835f, 0.04071284f, -0.06982005f, 0.04720091f, 0.05566100f, -0.05082788f, -0.03194899f, 
    -0.06562576f, -0.02730710f, -0.04770703f, -0.00442415f, 0.01889175f, -0.00856306f, -0.01939986f, 0.01959429f, 
    0.06588367f, -0.04942045f, 0.02341396f, 0.03706096f, 0.05942307f, 0.01758186f, -0.03011417f, -0.05668946f, 
    0.05915598f, -0.06871443f, 0.06518427f, 0.00072719f, -0.01233427f, -0.07112994f, -0.01761167f, -0.02797191f, 
    -0.01986335f, 0.06173804f, -0.07323910f, -0.02090097f, -0.08146662f, 0.03901826f, 0.01136928f, 0.04360110f, 
    0.00682441f, -0.06113910f, 0.02207447f, 0.00341958f, 0.02169690f, 0.00215631f, -0.02287447f, 0.03620730f, 
    -0.04279814f, 0.00981289f, -0.05962559f, -0.02275217f, 0.04822512f, 0.01557821f, 0.01159031f, 0.03960608f, 
    -0.00560056f, -0.04838776f, -0.05321895f, 0.04601026f, -0.03569176f, 0.05285896f, -0.06457891f, 0.03590755f, 
    -0.05964769f, 0.00654993f, 0.00132201f, -0.03030614f, 0.03095358f, -0.06008208f, -0.07492650f, -0.00762276f, 
    -0.02024223f, -0.02675794f, 0.01386324f, 0.03983608f, 0.03205414f, -0.05614908f, 0.02374459f, -0.07819798f, 
    0.04474323f, 0.01331161f, -0.06687608f, -0.02410623f, -0.05767930f, 0.04635873f, -0.03304254f, -0.03941169f, 
    -0.06797442f, 0.01556720f, -0.07097287f, 0.05641048f, -0.04144841f, -0.01694419f, 0.04636637f, -0.06407595f, 
    -0.01803818f, 0.01407084f, 0.06242358f, -0.05974511f, 0.03024020f, 0.01407616f, -0.03510110f, -0.04757050f, 
    0.01294753f, 0.02014862f, -0.07594752f, -0.06339625f, -0.02487386f, -0.02151581f, 0.02175680f, 0.05265142f, 
    -0.06520369f, -0.06839076f, 0.02340364f, -0.00428036f, -0.01281150f, -0.06198299f, 0.05609871f, 0.00918746f, 
    -0.02009243f, 0.05845940f, 0.03613825f, -0.06724022f, 0.03786321f, -0.05139193f, 0.02130287f, -0.06938861f, 
    -0.03224347f, -0.02124535f, 0.03078166f, -0.06348599f, 0.03010421f, 0.03225970f, 0.03833103f, 0.00863786f, 
    0.00299167f, 0.05672010f, -0.03778545f, -0.00023522f, 0.02849806f, -0.00298393f, 0.06001476f, -0.06812371f, 
    -0.00551817f, -0.06927753f, 0.00173320f, -0.00074982f, -0.04668728f, -0.03007625f, -0.03437562f, 0.01509306f, 
    -0.05953076f, 0.00368455f, -0.05427223f, -0.07466439f, -0.06947120f, 0.06284203f, 0.00498290f, 0.02593742f, 
    -0.05176656f, 0.02403214f, -0.02833481f, -0.05502065f, -0.02537684f, 0.04036901f, 0.03301182f, -0.05120028f, 
    -0.07961717f, -0.05134975f, 0.00703199f, 0.01709185f, -0.04617497f, -0.01547197f, -0.01534075f, 0.01384101f, 
    0.04207836f, -0.02306482f, 0.05721858f, 0.00027654f, -0.02603103f, -0.05286012f, -0.01477161f, -0.00936010f, 
    -0.03720661f, -0.05868782f, 0.00374474f, 0.01380742f, -0.05031394f, 0.03409554f, 0.05880491f, -0.07740747f, 
    0.00137340f, 0.00972677f, 0.05638140f, -0.07717361f, -0.06049919f, -0.05430007f, -0.06459989f, -0.02001688f, 
    0.24261579f, 0.18551749f, -0.08864089f, 0.27349079f, 0.13744645f, 0.06976087f, -0.05570008f, 0.13768865f, 
    0.00046592f, 0.09336302f, -0.08508653f, -0.11844149f, -0.07604474f, 0.07092065f, 0.09517207f, 0.36037573f, 
    0.16854323f, -0.01724690f, 0.15020613f, 0.09956959f, 0.12076870f, -0.04908110f, 0.01355618f, -0.04631023f, 
    -0.22017252f, -0.05627776f, -0.03132328f, -0.11561587f, -0.00857058f, -0.06524371f, -0.06370036f, -0.06011485f, 
    0.10843674f, -0.20925827f, -0.07757227f, -0.08658430f, 0.07491644f, 0.08006357f, -0.07368410f, -0.20233572f, 
    0.07012630f, 0.08624246f, -0.08700021f, -0.07882644f, -0.05983431f, 0.02838211f, 0.05021666f, 0.09113819f, 
    -0.12352554f, -0.20947048f, 0.21765767f, 0.01508177f, 0.02383459f, 0.03412101f, 0.03262732f, 0.07400728f, 
    0.13192603f, 0.15248209f, 0.07570340f, 0.06175913f, 0.41247118f, 0.11553793f, 0.39184883f, 0.10483539f, 
    0.09557426f, 0.07081882f, 0.22083300f, 0.11561194f, -0.02982589f, -0.11353936f, 0.25900441f, 0.28907242f, 
    0.29486001f, -0.00425569f, -0.09827068f, -0.10144310f, 0.08031831f, -0.04866658f, -0.11672011f, 0.04295242f, 
    -0.09806147f, -0.17598431f, -0.16411881f, -0.23329863f, -0.06680074f, 0.22467136f, -0.01833647f, 0.33548242f, 
    0.01415579f, -0.08780166f, 0.06464040f, 0.34418556f, -0.03492037f, 0.09946597f, -0.09711851f, -0.09290692f, 
    -0.15777452f, -0.20135872f, 0.07930847f, -0.13065669f, -0.10200522f, -0.02444957f, -0.00114056f, -0.11364073f, 
    0.16293883f, -0.16094427f, 0.00667091f, 0.04770298f, -0.07504321f, 0.11409881f, -0.23653911f, -0.04459219f, 
    -0.09707212f, 0.21219091f, 0.09026209f, 0.01899295f, 0.15221475f, 0.14214827f, 0.19330978f, -0.04769547f, 
    -0.31476808f, -0.14674002f, -0.29788557f, 0.07845426f, -0.12922877f, 0.16855890f, -0.07051912f, 0.00530409f, 
    0.13315430f, 0.21544798f, -0.00434778f, -0.00706411f, -0.15758447f, -0.27630326f, -0.06831159f, -0.13776511f, 
    0.00150669f, -0.07280831f, -0.08199059f, 0.09714988f, 0.18697974f, 0.12779234f, -0.07004046f, 0.03729973f, 
    0.16815953f, -0.10158999f, 0.01491733f, 0.32354522f, -0.07818202f, 0.22836138f, 0.05576164f, 0.07379252f, 
    0.02634329f, -0.11473188f, 0.08074281f, 0.04872219f, -0.28694770f, 0.02549819f, 0.09877727f, -0.13221824f, 
    0.04829604f, -0.13219838f, -0.23113437f, -0.07007865f, 0.21445121f, 0.04070600f, 0.10266796f, -0.08861321f, 
    -0.02914531f, -0.07761694f, 0.12616031f, -0.22995444f, 0.07300430f, -0.10260131f, -0.11188319f, 0.16162723f, 
    0.02776739f, 0.02277643f, -0.04664781f, 0.05605631f, -0.07562317f, -0.23445003f, -0.11095995f, -0.10720915f, 
    -0.25723153f, -0.01981494f, -0.02522888f, -0.02537886f, -0.06213389f, 0.06102702f, -0.05145732f, 0.01359368f, 
    0.16347383f, 0.08486886f, 0.10423116f, -0.05086186f, 0.00590475f, 0.08054309f, 0.01997686f, -0.07560705f, 
    0.10870318f, -0.10784022f, -0.10121138f, 0.02766973f, 0.24794436f, 0.18485409f, 0.26798108f, -0.10104756f, 
    0.03535255f, -0.06064245f, -0.10086685f, 0.11161996f, 0.07514839f, 0.10858124f, -0.00208819f, 0.10497170f, 
    0.04915928f, -0.27388513f, 0.11338328f, 0.17186582f, 0.05479067f, 0.06239902f, -0.08606293f, 0.01249023f, 
    0.12327345f, 0.02672957f, -0.08317479f, 0.07551172f, -0.21954574f, -0.17122659f, -0.15192191f, 0.01111246f, 
    0.13428450f, 0.12890206f, -0.10610031f, -0.07742885f, 0.03547389f, 0.10731408f, 0.02282494f, 0.07465025f, 
    0.00733669f, 0.36062092f, -0.23702602f, 0.22792299f, 0.19889283f, -0.10721471f, 0.12738141f, 0.00460995f, 
    0.07229964f, 0.01854482f, 0.06732482f, 0.07782044f, -0.10011347f, -0.04128559f, -0.38536307f, 0.25532177f, 
    0.07881930f, 0.05547347f, -0.06374274f, -0.04163927f, -0.20976484f, 0.03314278f, 0.07477376f, 0.15915322f, 
    -0.07809532f, 0.11811369f, 0.20533237f, -0.08153911f, 0.10128526f, 0.18160345f, -0.08419568f, 0.01364581f, 
    -0.17242487f, -0.09948041f, -0.02679220f, 0.00483459f, 0.27372402f, -0.10765936f, 0.04216559f, -0.22241218f, 
    -0.00719980f, -0.12620755f, 0.21850613f, 0.19286247f, 0.07346359f, -0.07703094f, -0.00796526f, -0.13123733f, 
    0.08164779f, 0.15712862f, -0.05283692f, 0.09250481f, -0.04021806f, -0.07225532f, 0.05471193f, 0.01560752f, 
    -0.05029053f, 0.10915449f, 0.12391187f, -0.06302502f, -0.02139509f, -0.21969444f, -0.21052025f, -0.08555381f, 
    0.02179599f, -0.23500712f, -0.01318215f, -0.08121347f, -0.13028796f, 0.05085402f, -0.05153196f, 0.10070480f, 
    0.23404923f, -0.07687488f, -0.20497271f, 0.01719956f, -0.00920479f, 0.00989139f, 0.21084937f, 0.02178080f, 
    0.04275720f, -0.05430765f, 0.06567277f, 0.10720529f, -0.00331710f, -0.23688334f, -0.07601830f, -0.05710837f, 
    0.04762381f, 0.12234744f, -0.00698886f, -0.16194125f, 0.04585438f, 0.06240777f, -0.08316641f, -0.08107179f, 
    0.32927632f, 0.14590588f, -0.08565654f, 0.04934841f, 0.02912460f, -0.07728380f, 0.07356462f, -0.09687980f, 
    -0.04725229f, 0.13522199f, 0.00890715f, 0.14588119f, -0.11466100f, 0.15250351f, -0.04496774f, -0.12732582f, 
    0.13059783f, 0.00942040f, -0.13103053f, -0.05888225f, 0.22408198f, -0.00022591f, -0.05250284f, 0.11584029f, 
    -0.18072762f, -0.26291269f, -0.18210348f, 0.36762047f, 0.11112803f, -0.06102934f, 0.02747876f, -0.06912801f, 
    0.10447276f, 0.03736188f, 0.00934870f, 0.11008563f, -0.34197357f, -0.01143930f, -0.09042309f, 0.09731277f, 
    0.15367790f, -0.25830582f, -0.17871226f, 0.01975696f, 0.07965712f, 0.03549616f, 0.03752133f, 0.04446989f, 
    0.00212921f, 0.13145284f, 0.11577235f, 0.19388504f, 0.03408619f, 0.02695454f, 0.02928842f, 0.09495281f, 
    -0.07946628f, -0.04924537f, 0.05552749f, -0.08573598f, -0.33468416f, -0.08781689f, 0.05547851f, -0.15131018f, 
    -0.09105441f, -0.09046701f, 0.05746984f, -0.18493193f, -0.02405531f, -0.07177187f, -0.07588651f, -0.10505959f, 
    0.24462847f, 0.11743702f, -0.13858125f, 0.15473969f, 0.11748453f, 0.04086544f, 0.09140266f, 0.10063263f, 
    0.19368216f, 0.19331841f, 0.15530552f, 0.19491014f, -0.24918273f, 0.43592498f, 0.06112415f, 0.07543983f, 
    -0.11048836f, -0.00115478f, -0.05748688f, -0.05434510f, -0.03822544f, -0.00290911f, -0.00971491f, -0.03862322f, 
    -0.02485287f, -0.12331540f, 0.07037643f, -0.14550233f, 0.09350608f, 0.01533037f, -0.00621972f, 0.16492811f, 
    -0.04045065f, 0.16060762f, -0.05422716f, 0.06594096f, -0.47941238f, -0.30720600f, 0.03070440f, -0.31956139f, 
    -0.00535488f, -0.24153921f, -0.07354724f, 0.06997564f, 0.18989575f, 0.13211085f, -0.15443598f, -0.05020309f, 
    0.03123973f, 0.15347059f, -0.01255895f, 0.01096615f, 0.00870884f, 0.00448701f, 0.09174746f, 0.03261061f, 
    0.13066152f, 0.06022587f, 0.09184197f, -0.13271819f, -0.27668092f, -0.48177952f, -0.15630984f, -0.10485033f, 
    0.05326533f, -0.02002772f, 0.02053285f, -0.02189199f, 0.08215783f, -0.12337127f, 0.23536250f, 0.10545838f, 
    0.15851317f, -0.00889901f, 0.02644214f, -0.02171225f, -0.03990378f, -0.04558291f, 0.03640498f, -0.06650141f, 
    -0.03923349f, 0.02822827f, -0.01132061f, -0.00626230f, -0.04777222f, -0.05774176f, 0.01846029f, 0.15286839f, 
    0.09187298f, 0.16434385f, -0.07153781f, 0.09165214f, 0.01178242f, 0.02723174f, -0.00785544f, -0.08650187f, 
    -0.29393473f, -0.25809017f, 0.00803113f, 0.22394139f, -0.17187856f, -0.13195914f, 0.03434220f, 0.07561588f, 
    0.20744066f, 0.14897691f, 0.15735200f, -0.00810269f, -0.07968269f, 0.11487799f, -0.08618312f, 0.08143665f, 
    -0.06141768f, 0.04220331f, 0.00306755f, 0.06644381f, 0.02487865f, 0.06801448f, 0.01089928f, -0.01479562f, 
    0.17169785f, -0.05607231f, -0.08416712f, -0.11679556f, 0.04896147f, 0.09402465f, 0.03253084f, -0.04208361f, 
    -0.11198503f, -0.05162194f, -0.00401246f, 0.00601854f, 0.30445015f, -0.05945470f, 0.03476102f, 0.14109944f, 
    0.08115117f, 0.05745093f, 0.10190507f, 0.07199416f, -0.12845965f, 0.08464014f, -0.04260484f, 0.00312808f, 
    -0.21582389f, -0.57975394f, -0.12760322f, -0.06317449f, -0.06389043f, 0.13136883f, -0.04683925f, -0.04932149f, 
    0.23579237f, 0.07084363f, 0.08114706f, 0.09014089f, 0.46429855f, -0.05588104f, 0.09437685f, 0.04397264f, 
    0.08356064f, -0.03369618f, 0.15213384f, 0.18033926f, 0.01047262f, -0.09528693f, 0.09486540f, 0.03401833f, 
    0.16848214f, -0.18491209f, -0.01137343f, 0.02972856f, 0.14773442f, 0.03851323f, -0.02316083f, 0.03613093f, 
    -0.01074162f, -0.00436591f, -0.04043271f, -0.01473614f, 0.08387639f, 0.05769810f, -0.03874025f, 0.04616363f, 
    -0.01975873f, 0.10667924f, -0.10827206f, 0.13601351f, -0.07352559f, -0.01593545f, -0.19179851f, 0.00070763f, 
    -0.05783982f, 0.01623313f, 0.00418542f, -0.17481585f, 0.05919831f, 0.17478502f, -0.15750112f, -0.03816818f, 
    -0.02461415f, -0.05689938f, -0.15002039f, -0.04853562f, 0.21609516f, -0.14544401f, -0.03884198f, 0.07186975f, 
    0.01792486f, 0.02881296f, -0.01517112f, -0.01581647f, -0.03182018f, 0.07806303f, 0.08786748f, -0.00491092f, 
    -0.05366956f, 0.14300638f, -0.15761039f, 0.06465254f, -0.09658373f, -0.01780791f, 0.23392092f, -0.01997436f, 
    0.07174916f, 0.11029427f, -0.03750676f, 0.21254723f, 0.04759288f, 0.00131161f, 0.07359593f, 0.18151721f, 
    -0.05156837f, 0.14687674f, 0.33412170f, -0.02297604f, 0.10679062f, 0.11451991f, 0.25478923f, 0.22903243f, 
    -0.03761894f, -0.07272115f, 0.11861722f, 0.08248256f, -0.05369310f, 0.05102267f, -0.10890440f, -0.02057149f, 
    -0.11375874f, -0.20621958f, -0.23550434f, -0.19898121f, -0.06633960f, -0.15359205f, -0.22439462f, 0.22994635f, 
    0.08640370f, 0.03914649f, 0.15776724f, 0.08087137f, -0.12676997f, 0.12102588f, -0.00283365f, -0.05152498f, 
    0.22570565f, 0.15314576f, -0.08386972f, 0.25173384f, -0.05727573f, -0.06990739f, -0.02846210f, 0.02393119f, 
    0.01622509f, 0.04644414f, 0.03893295f, -0.14119795f, 0.08703167f, 0.09521759f, -0.03176413f, 0.00190886f, 
    0.01198369f, -0.08479749f, 0.12674347f, -0.05449998f, -0.17344320f, 0.16304542f, 0.09296440f, 0.13095306f, 
    0.25484648f, 0.11317027f, -0.08870848f, -0.43504959f, -0.11054728f, 0.06365343f, 0.05189418f, -0.02797525f, 
    -0.02016548f, -0.01557475f, -0.06985480f, -0.01395851f, 0.07505799f, 0.03708630f, -0.03936964f, -0.14901015f, 
    -0.08799590f, -0.04486129f, 0.02257905f, -0.03923223f, -0.01499890f, 0.04814404f, 0.08612224f, -0.01412704f, 
    -0.19712554f, -0.05201830f, -0.43334964f, 0.35680434f, 0.05989239f, -0.00038993f, 0.22784647f, 0.08289168f, 
    0.07831543f, 0.10376570f, 0.11744002f, 0.16055092f, 0.05347973f, 0.14764036f, -0.05216522f, -0.11055498f, 
    0.03806400f, -0.01301809f, -0.09722976f, -0.20516387f, 0.12364911f, 0.03524922f, -0.07345600f, 0.08164670f, 
    0.44940779f, 0.56017339f, -0.07657269f, -0.23285207f, -0.14285478f, 0.00378923f, -0.02291318f, -0.07487277f, 
    -0.11307209f, -0.12332608f, 0.11120778f, -0.09310935f, -0.12149888f, 0.02933714f, -0.09367621f, -0.16633569f, 
    -0.08286838f, -0.18218876f, 0.04105756f, 0.06619159f, 0.05485184f, 0.10713711f, 0.19906797f, -0.05337436f, 
    -0.17525616f, 0.08424243f, 0.13219811f, 0.07660641f, 0.16945125f, 0.01189329f, 0.03274210f, -0.00105110f, 
    -0.06331935f, -0.05563154f, -0.00388969f, -0.08455352f, -0.15154821f, 0.00861681f, -0.08317638f, 0.19321589f, 
    -0.05188855f, 0.08300374f, 0.16476040f, -0.10432816f, -0.09520037f, -0.01811569f, 0.02459100f, -0.01698966f, 
    0.18314081f, 0.13848276f, 0.02867917f, 0.15521736f, -0.00641460f, 0.03411258f, 0.03812770f, 0.19958822f, 
    -0.02238554f, 0.06570327f, 0.00419321f, 0.07545608f, -0.18866685f, 0.11706749f, -0.00683033f, 0.00525105f, 
    -0.00488043f, -0.16732617f, 0.03326272f, -0.03800077f, -0.16084680f, -0.01969269f, -0.04623302f, -0.04607338f, 
    -0.00105483f, -0.23111054f, 0.23542759f, 0.04012437f, 0.00658914f, 0.10839407f, 0.14792427f, 0.06158837f, 
    0.11236537f, 0.11791731f, 0.17734912f, 0.33418614f, 0.05696546f, -0.01268710f, 0.22266538f, -0.22148982f, 
    -0.01180053f, 0.01883295f, 0.05804014f, 0.07671328f, 0.10822267f, 0.09819184f, 0.07182696f, 0.10967270f, 
    0.11273988f, -0.00776994f, -0.20377085f, 0.02032954f, 0.02405788f, -0.05770851f, -0.06264115f, 0.08118600f, 
    -0.13672887f, -0.13486911f, -0.17959026f, -0.36773604f, -0.27781603f, -0.05927367f, -0.05569807f, -0.04782082f, 
    0.11321142f, -0.03195616f, -0.04838887f, -0.04343804f, -0.03669677f, 0.02945019f, -0.07207653f, 0.06864076f, 
    -0.14349300f, 0.25225905f, 0.00457984f, 0.08129515f, -0.27430871f, 0.09908857f, 0.00780396f, 0.01494943f, 
    -0.13132045f, -0.12387732f, 0.05580727f, 0.01329094f, -0.15947418f, -0.04617603f, 0.00299087f, -0.06788417f, 
    -0.11971669f, 0.06884661f, -0.13039610f, -0.17414068f, 0.10722605f, 0.19889915f, 0.23783354f, 0.01812091f, 
    -0.28871304f, -0.02526001f, 0.13698064f, -0.00856041f, -0.18695447f, -0.01570932f, -0.13036360f, -0.12962967f, 
    0.08519498f, -0.07487131f, 0.09542600f, -0.03060956f, -0.11488310f, 0.06162949f, -0.18436286f, -0.13478124f, 
    -0.25864562f, -0.10526777f, 0.05763974f, 0.15235133f, 0.09186119f, 0.09380335f, 0.04160663f, -0.15895900f, 
    -0.00838714f, -0.20360285f, -0.01884064f, 0.13649352f, -0.00558844f, 0.41316882f, -0.09616799f, 0.04913197f, 
    -0.01064406f, 0.04783246f, 0.01997989f, 0.05994602f, 0.28924799f, 0.04203187f, 0.14684121f, 0.11484889f, 
    0.00436876f, 0.01352535f, -0.05605325f, 0.11623672f, -0.00961560f, 0.02949774f, 0.09592477f, 0.18810780f, 
    0.11218122f, 0.01322215f, 0.26747814f, -0.03411773f, -0.05933313f, -0.16099137f, -0.01734275f, 0.19284311f, 
    0.10921624f, 0.02693769f, -0.11384062f, -0.15634854f, 0.11650799f, -0.10524902f, 0.06932399f, -0.05494407f, 
    0.00574921f, -0.18396108f, 0.00948124f, 0.05485268f, -0.05341661f, 0.04550594f, -0.10829426f, 0.04949033f, 
    0.02874253f, 0.06538615f, 0.04108147f, -0.04741528f, 0.00096985f, 0.04084440f, 0.00570061f, -0.05109908f, 
    -0.03071720f, 0.04067363f, -0.02723354f, -0.02582339f, 0.02492695f, -0.07661782f, -0.01491790f, -0.05029484f, 
    -0.05203420f, -0.06882735f, -0.03583600f, -0.05550927f, 0.02569610f, -0.03556252f, 0.02277407f, -0.03453410f, 
    0.00959086f, 0.01569901f, -0.05270576f, 0.01951128f, 0.00819461f, -0.01079320f, 0.05647089f, 0.03798725f, 
    -0.04689345f, -0.05667264f, 0.02398208f, 0.05066806f, 0.03306351f, 0.01512888f, 0.03025791f, 0.00363183f, 
    -0.00196849f, 0.05311540f, 0.05643603f, -0.01593453f, 0.01939075f, -0.01036904f, 0.03634281f, -0.00929754f, 
    0.02743499f, -0.02268297f, -0.06918333f, 0.05908741f, 0.02490629f, -0.05291634f, 0.02602532f, 0.03301555f, 
    -0.01368046f, -0.07420853f, -0.00987108f, -0.07090770f, 0.00865943f, -0.00516727f, 0.00175342f, -0.03488980f, 
    0.01724798f, 0.01482811f, 0.01433068f, -0.00125116f, -0.03281179f, 0.04625003f, 0.02929651f, -0.01869598f, 
    0.03531345f, -0.02173147f, -0.00731200f, -0.06063087f, -0.00430934f, -0.06634247f, -0.05537165f, -0.00722702f, 
    -0.03967877f, -0.01677342f, -0.02076431f, 0.00169447f, -0.01446886f, 0.05621842f, -0.04567520f, 0.05730022f, 
    -0.01919329f, -0.02814237f, 0.01510529f, 0.00939924f, 0.01062420f, 0.01293683f, -0.00036081f, 0.01533925f, 
    0.03567607f, -0.02918771f, -0.04334415f, 0.01478258f, 0.06329437f, -0.06667161f, -0.03440366f, -0.02367289f, 
    -0.05257721f, -0.00353356f, 0.02903873f, -0.03382237f, -0.05522666f, 0.04963880f, -0.04717000f, -0.07615092f, 
    -0.00312051f, 0.02453870f, 0.05496481f, -0.04762955f, -0.03219640f, -0.03399353f, 0.01573844f, 0.02028974f, 
    0.04524674f, 0.03467742f, 0.02192068f, 0.05291953f, 0.01218667f, -0.02348969f, -0.07215904f, 0.00451166f, 
    -0.02703058f, -0.05851023f, 0.03591030f, -0.02583940f, -0.06899353f, -0.00335460f, -0.05763472f, -0.01716605f, 
    0.04371449f, 0.03368692f, -0.05059385f, -0.03057258f, -0.01331106f, 0.01546221f, 0.00154709f, 0.02712712f, 
    -0.01639659f, -0.02294812f, 0.00918437f, -0.07766663f, -0.03391170f, -0.01196411f, 0.04145244f, 0.05864805f, 
    -0.05561852f, -0.07497008f, -0.04616260f, 0.00534884f, 0.02628921f, 0.03785322f, -0.03864498f, -0.03642623f, 
    -0.05118340f, -0.07643969f, -0.00879783f, -0.03701078f, -0.07483257f, 0.01118633f, 0.03577926f, 0.05087155f, 
    0.04945379f, 0.00612942f, 0.05782274f, 0.02176620f, 0.02860514f, -0.02099660f, 0.01275781f, -0.07498912f, 
    -0.04543779f, 0.02254693f, -0.07729436f, 0.04233405f, 0.02162084f, -0.04818619f, -0.08163175f, -0.06788298f, 
    -0.07931869f, 0.05363383f, -0.06372320f, -0.08260302f, 0.01884350f, 0.05683834f, 0.04383211f, -0.00122492f, 
    -0.12608202f, -0.11115320f, 0.02320636f, 0.10791466f, 0.01405387f, -0.02057359f, -0.07152072f, 0.01959249f, 
    0.05226336f, 0.00513896f, -0.01885521f, 0.07546633f, -0.33300531f, -0.26730767f, -0.19848347f, -0.03997948f, 
    0.01070341f, -0.00283338f, 0.00277828f, -0.02661217f, -0.10660628f, -0.00142930f, 0.04686974f, -0.03771653f, 
    0.24617597f, 0.08670327f, -0.08541629f, 0.08055925f, 0.05648175f, -0.04454402f, 0.07722510f, -0.12168352f, 
    0.02072803f, 0.21917059f, 0.18435870f, 0.03997705f, 0.03833777f, 0.33172399f, 0.19524372f, -0.00205694f, 
    -0.07160444f, -0.03359549f, -0.03864552f, -0.04386997f, 0.08912423f, -0.13656940f, 0.03038655f, -0.07129657f, 
    0.04640155f, -0.07575316f, -0.02449286f, 0.01740746f, 0.05646954f, -0.03993677f, -0.09296200f, 0.00448159f, 
    -0.00313285f, 0.01919511f, -0.10082139f, -0.04242372f, -0.27338016f, -0.14747992f, -0.00080522f, -0.09012419f, 
    0.06613670f, -0.13268419f, -0.13147369f, -0.06551381f, 0.14869353f, -0.00092774f, -0.05861490f, -0.07536666f, 
    -0.03184146f, 0.01823833f, -0.04584857f, 0.07534618f, 0.05020967f, -0.00033903f, 0.19290832f, -0.03798157f, 
    0.18649161f, 0.12048604f, 0.04999670f, 0.26818985f, -0.20703372f, -0.18950941f, -0.07139364f, 0.05252502f, 
    -0.01720351f, 0.07173827f, 0.02076029f, -0.06782012f, 0.16256878f, 0.04947235f, 0.17464058f, 0.14089939f, 
    0.31455883f, 0.10950851f, 0.27907607f, 0.13433443f, 0.06468191f, 0.02575373f, -0.07404809f, 0.00350173f, 
    -0.01106231f, -0.06987651f, -0.05618886f, -0.06427329f, 0.02076603f, -0.05042757f, 0.13980933f, 0.15215752f, 
    0.03304271f, -0.02870459f, -0.02528272f, 0.00477647f, 0.01960512f, -0.04280182f, -0.03521645f, -0.05127842f, 
    -0.11764810f, 0.13628168f, 0.22275056f, -0.01389700f, -0.06663484f, -0.03945573f, -0.02094520f, 0.11119397f, 
    0.10510331f, 0.03173204f, -0.02424258f, 0.07976866f, 0.06804644f, 0.11962809f, 0.05081839f, 0.04671732f, 
    -0.01342257f, -0.07598089f, 0.02674599f, -0.12022913f, -0.12511189f, -0.04237339f, 0.12257218f, 0.10714494f, 
    -0.37224612f, -0.08381907f, 0.07705731f, -0.12765108f, 0.02682372f, -0.03361390f, 0.05808724f, 0.05740919f, 
    -0.09240633f, 0.05309276f, -0.06427762f, -0.16469634f, 0.24647675f, 0.08184048f, -0.06625924f, 0.14503811f, 
    -0.03929492f, 0.05246077f, 0.03726157f, 0.00493896f, -0.09240491f, 0.07307819f, 0.08720828f, -0.16281715f, 
    0.05040676f, 0.19687405f, -0.15422857f, 0.17001793f, 0.00235644f, -0.03605356f, 0.02007962f, -0.11215068f, 
    0.03549121f, 0.02283326f, 0.11203320f, -0.02788460f, 0.46649829f, 0.23748322f, 0.13672175f, -0.02087763f, 
    -0.03059957f, 0.13967241f, 0.06534106f, 0.02781511f, -0.01391004f, -0.17234966f, 0.05417047f, -0.01183202f, 
    -0.16247141f, -0.36778489f, -0.23669940f, -0.39750493f, -0.10447509f, -0.08038440f, -0.14539100f, 0.07074853f, 
    0.26934993f, -0.03962798f, 0.05975178f, 0.07766987f, -0.32024750f, -0.28995979f, -0.16355905f, -0.00263206f, 
    0.16008933f, 0.13439363f, -0.04559658f, 0.20462044f, 0.18945019f, 0.04995125f, 0.16822124f, 0.04776044f, 
    -0.00130301f, 0.07112165f, 0.15358108f, 0.00438140f, 0.04214116f, 0.09435833f, -0.20638275f, -0.26335481f, 
    -0.01683770f, 0.02845228f, -0.02548342f, -0.04755772f, 0.23842365f, -0.27728000f, -0.17959557f, -0.33039689f, 
    -0.15755120f, 0.14747138f, -0.03571955f, -0.26716766f, 0.19729312f, -0.11991673f, -0.07851822f, 0.08567106f, 
    0.03339210f, 0.14195551f, 0.16054255f, 0.37983280f, 0.01548359f, 0.01319700f, 0.22390078f, -0.21905151f, 
    -0.00305966f, -0.09886068f, 0.06137639f, -0.20909104f, 0.03325434f, 0.25590810f, -0.46274602f, 0.29279542f, 
    -0.04094039f, 0.22457342f, 0.10510869f, 0.08209682f, -0.04589790f, -0.00493249f, -0.20849034f, 0.12525190f, 
    -0.24067374f, 0.03166443f, 0.10752050f, 0.01192431f, -0.18853715f, -0.04434180f, -0.05595632f, -0.04390968f, 
    -0.00198119f, 0.02268292f, -0.11113647f, 0.07230978f, 0.12333800f, 0.23539716f, 0.14169262f, 0.26158801f, 
    0.09028372f, 0.10908586f, 0.29160362f, 0.26673064f, 0.07882674f, 0.04489409f, -0.18590219f, -0.07929751f, 
    0.38148886f, 0.11792419f, 0.20976773f, 0.02539478f, -0.07795247f, -0.08107467f, 0.12890084f, -0.01324843f, 
    0.01669391f, -0.13594161f, 0.08899888f, -0.16629590f, 0.23807225f, -0.10118284f, 0.10006682f, -0.20805813f, 
    0.04602453f, -0.00140055f, 0.16671216f, -0.05406399f, -0.23610498f, 0.09356335f, 0.00570831f, -0.00381339f, 
    0.32351112f, 0.02582718f, -0.24041550f, -0.04422012f, -0.33809620f, 0.05884292f, -0.33045802f, -0.14038859f, 
    0.24797881f, 0.09207966f, 0.00658751f, -0.13436039f, 0.30434427f, -0.29211238f, 0.04986100f, -0.32832524f, 
    -0.23796213f, -0.33181861f, -0.08516276f, -0.56055838f, 0.01348854f, -0.00772413f, -0.00881869f, 0.09467939f, 
    -0.38385534f, -0.37117672f, -0.08079416f, -0.00491430f, 0.08324850f, 0.20525421f, 0.19735555f, 0.01101277f, 
    0.07454485f, 0.20191295f, -0.06597172f, 0.09194455f, -0.11823861f, 0.29064894f, -0.02652473f, -0.04089084f, 
    0.00758797f, 0.01833336f, -0.17908774f, -0.43611187f, 0.19804387f, -0.09096503f, 0.19722337f, 0.03430029f, 
    0.19453931f, 0.33904076f, 0.05952136f, 0.31938231f, -0.05747430f, 0.01390642f, 0.14248954f, -0.19048865f, 
    -0.00363211f, 0.06071414f, 0.11854392f, 0.20764896f, -0.01928624f, 0.20865242f, 0.03548488f, 0.23589225f, 
    -0.03578120f, -0.23273663f, -0.01575735f, -0.14537089f, 0.14137115f, 0.00372842f, 0.04741607f, 0.11004363f, 
    -0.34256822f, -0.38280052f, 0.23279546f, 0.06983168f, 0.07589627f, 0.06715047f, 0.02264781f, -0.00537353f, 
    0.03728891f, -0.01814174f, -0.05820540f, 0.01227223f, 0.00066840f, 0.00753015f, -0.03545216f, 0.07228059f, 
    -0.15823096f, 0.10774485f, -0.07793806f, 0.03115987f, 0.03925535f, 0.00619151f, 0.02786488f, 0.12011668f, 
    0.25570464f, -0.01146851f, 0.25616914f, 0.14883319f, -0.04399410f, -0.07595075f, -0.01404770f, 0.04681034f, 
    0.02955708f, 0.04037409f, -0.05382314f, -0.01071369f, 0.02451431f, -0.47272173f, -0.06112195f, 0.29367769f, 
    0.05132880f, 0.05826208f, 0.01945877f, -0.03895992f, 0.14201491f, 0.09962083f, -0.07652400f, 0.19197886f, 
    -0.02888599f, 0.05610118f, -0.08796570f, 0.32485041f, 0.12201146f, -0.03805392f, 0.20839041f, -0.10607193f, 
    -0.03390660f, -0.12228496f, 0.04051523f, 0.26819256f, 0.23918852f, 0.39752173f, -0.44723430f, 0.25101516f, 
    0.13482970f, 0.13885556f, 0.09734637f, -0.24945216f, 0.06877378f, 0.07010796f, -0.00734616f, 0.04673839f, 
    -0.14545748f, -0.03933927f, -0.07936651f, 0.05229644f, -0.03235161f, 0.18682297f, -0.02242701f, 0.05015978f, 
    0.02806340f, 0.01719653f, -0.16841520f, -0.01939774f, -0.02056126f, 0.04741501f, 0.19127370f, 0.13129717f, 
    0.11766815f, 0.13453661f, 0.12425201f, -0.05206732f, -0.12597948f, 0.08105008f, -0.21211033f, -0.12833722f, 
    0.02553605f, 0.21596380f, 0.10565534f, 0.01880661f, -0.12238065f, -0.21977741f, 0.10534589f, 0.00602475f, 
    -0.05266363f, 0.09143477f, -0.04238132f, -0.17308621f, -0.01491828f, -0.28536648f, -0.04268965f, -0.21575809f, 
    -0.18834291f, -0.14739276f, 0.31471536f, -0.17787990f, -0.03799405f, 0.16476378f, -0.06648105f, 0.22605172f, 
    0.17816792f, 0.08486880f, 0.27442545f, -0.24731615f, -0.16929583f, -0.01700960f, -0.00933119f, -0.01102618f, 
    0.08058458f, 0.00056609f, 0.09816669f, 0.03664982f, 0.00313328f, -0.00938335f, 0.06146431f, -0.15054832f, 
    -0.06781471f, -0.04154266f, -0.06770270f, -0.14173402f, 0.05119475f, -0.09477708f, 0.04086483f, 0.01201510f, 
    -0.22548658f, -0.04894933f, -0.31697276f, 0.14618342f, -0.01085357f, 0.18989886f, 0.06696633f, -0.06047024f, 
    0.03062673f, 0.25044638f, 0.11520508f, 0.29116511f, -0.02888074f, 0.19336127f, -0.29018542f, 0.10006800f, 
    -0.00680131f, -0.05849427f, 0.02122663f, -0.04635328f, 0.15290010f, -0.09619046f, 0.24183412f, 0.22470202f, 
    0.37044787f, 0.56002760f, -0.05086761f, 0.38819042f, -0.09090250f, 0.06471191f, 0.00122665f, -0.07008325f, 
    -0.06824530f, 0.13729483f, -0.10123127f, -0.15325513f, -0.51304495f, 0.02522385f, -0.25017518f, 0.13703091f, 
    -0.00090892f, -0.32779047f, -0.16879888f, -0.09666368f, -0.03884407f, 0.09011224f, 0.09940749f, 0.02840360f, 
    -0.10888455f, -0.14108659f, 0.12462300f, 0.26582354f, 0.00667446f, -0.19032975f, -0.01648796f, -0.03846918f, 
    -0.05896614f, -0.01098463f, 0.07756268f, -0.00828366f, -0.37907657f, -0.22810613f, -0.25432467f, 0.21171393f, 
    -0.06050872f, -0.03761691f, 0.05266574f, 0.02048445f, 0.03447384f, 0.07737968f, -0.02335098f, 0.04830831f, 
    0.19685343f, 0.05220789f, -0.17634949f, 0.05235633f, 0.08998384f, 0.01270539f, 0.07915079f, -0.02748497f, 
    0.06048935f, 0.17183642f, 0.10735276f, -0.00971666f, 0.10154865f, 0.19141838f, 0.22397314f, 0.00957404f, 
    -0.13032065f, -0.28773502f, -0.08174240f, -0.03664755f, 0.04699090f, 0.01114645f, -0.02073891f, 0.04330975f, 
    0.05992397f, -0.12127795f, -0.15466426f, -0.12897313f, -0.13826883f, 0.01410314f, -0.11967716f, -0.01228997f, 
    -0.07788125f, -0.10467231f, -0.04549313f, -0.05382786f, 0.14598274f, 0.20821553f, 0.26399854f, 0.03836562f, 
    0.00331102f, -0.12170761f, 0.04597427f, -0.09561583f, 0.05451009f, 0.01916649f, -0.00433107f, -0.06769434f, 
    0.09213518f, 0.11296350f, -0.08673982f, 0.08493552f, -0.03150534f, 0.01437399f, 0.15608171f, -0.01231793f, 
    0.16515481f, 0.14355218f, 0.06625134f, 0.16870341f, -0.17489234f, -0.00034657f, -0.06239886f, 0.19899918f, 
    -0.09384824f, 0.02212206f, -0.01253987f, -0.09550127f, 0.11172756f, 0.02088863f, 0.08704007f, 0.08052966f, 
    -0.21027102f, 0.10253984f, 0.13245448f, -0.03374434f, -0.11631726f, 0.06149672f, 0.02701322f, -0.09481513f, 
    0.04259309f, -0.05884413f, -0.01408507f, 0.04077525f, -0.13959289f, -0.04363581f, 0.08961624f, -0.06558413f, 
    -0.01405294f, -0.03230706f, -0.04282821f, -0.21625398f, 0.05806584f, -0.07642697f, 0.05521847f, 0.04095508f, 
    -0.29918572f, 0.09067965f, 0.14781456f, 0.08818915f, 0.04799513f, -0.10905027f, -0.16988944f, 0.08699873f, 
    0.05878147f, 0.14548381f, 0.00776047f, -0.04173883f, -0.21978247f, 0.24010079f, 0.09879587f, 0.07984333f, 
    -0.04100451f, -0.05913381f, -0.03361401f, 0.11181685f, 0.04513352f, 0.04613516f, 0.05133040f, 0.05382104f, 
    -0.17931207f, -0.09040686f, 0.19498380f, 0.19195616f, 0.05371959f, -0.05261460f, 0.05573523f, 0.10806181f, 
    0.01370333f, -0.01856419f, -0.03846023f, -0.16060162f, 0.25658369f, -0.15481949f, -0.07385423f, 0.01376469f, 
    -0.05473096f, -0.08441440f, 0.01494621f, 0.11838760f, 0.08783782f, -0.03007898f, 0.10080533f, -0.05226769f, 
    0.33101940f, 0.41272143f, -0.16122366f, 0.02737010f, 0.08613785f, -0.02526068f, -0.12750630f, -0.03220157f, 
    -0.08330099f, 0.04535902f, 0.05419591f, -0.00960069f, 0.12205857f, -0.05434781f, -0.17110780f, -0.29533446f, 
    -0.09275178f, 0.08929285f, 0.05684437f, -0.17033435f, -0.05864295f, -0.01386129f, -0.06275433f, -0.12361197f, 
    0.20442039f, 0.24074459f, -0.07606354f, 0.09374754f, 0.00998282f, 0.04140948f, -0.08721999f, 0.02061966f, 
    0.07070547f, 0.07320175f, 0.02069768f, 0.00374094f, 0.05198372f, 0.14140573f, 0.00425621f, 0.04356965f, 
    0.17416362f, 0.05586832f, 0.02035212f, -0.01136443f, 0.02152514f, -0.02012978f, -0.12779345f, 0.00915024f, 
    -0.14561020f, 0.09246362f, -0.10757183f, -0.08793797f, 0.06520645f, 0.02594206f, 0.03582489f, -0.20525593f, 
    -0.04888941f, -0.02655485f, 0.07145758f, -0.03341435f, -0.14209971f, 0.01056665f, -0.09144242f, -0.12156063f, 
    -0.10688581f, 0.05559456f, 0.01352879f, -0.14398958f, -0.03694501f, -0.01533974f, 0.02948470f, -0.09141836f, 
    0.02596128f, -0.04106415f, 0.30369341f, -0.08880301f, -0.10997932f, -0.00221151f, -0.08770173f, -0.08736973f, 
    0.09332481f, 0.10069228f, 0.14863282f, -0.01555822f, -0.09564887f, -0.27138793f, 0.16121697f, -0.20154795f, 
    -0.15722635f, 0.03101521f, 0.13218430f, 0.14398460f, 0.01907655f, -0.13561633f, 0.02521989f, 0.22216000f, 
    0.14552620f, 0.12402324f, 0.05634988f, -0.00900253f, 0.12698421f, -0.14796308f, -0.15634087f, 0.03855066f, 
    0.01499318f, -0.17179812f, -0.09448731f, -0.23610784f, -0.00009355f, -0.02820527f, -0.10430866f, -0.03577226f, 
    0.06058008f, -0.01860273f, -0.11916442f, 0.07476985f, 0.07618570f, 0.10004617f, 0.06650177f, 0.10172562f, 
    0.15652592f, -0.03615543f, 0.06667278f, -0.00739838f, -0.25293252f, 0.06606174f, 0.05994146f, -0.08816989f, 
    -0.01011416f, -0.14801089f, -0.10273499f, 0.00308505f, 0.00007697f, 0.12410129f, -0.13325945f, 0.05425899f, 
    0.10741039f, 0.23802482f, 0.02360992f, 0.02616132f, 0.03446452f, 0.04591993f, 0.09648091f, -0.04008526f, 
    0.21388404f, -0.33489224f, -0.40744057f, 0.01425246f, -0.13681154f, 0.06844384f, -0.06596410f, 0.04653726f, 
    0.12117653f, 0.03992189f, 0.14166017f, -0.05720410f, -0.27424836f, -0.12267984f, -0.19891649f, 0.01331391f, 
    -0.09535926f, 0.00073277f, 0.09523714f, 0.00647476f, 0.10374510f, 0.12238806f, -0.03036287f, -0.00976683f, 
    0.25138140f, -0.27751338f, 0.08625831f, 0.20203042f, -0.07912011f, 0.14103509f, -0.12124309f, 0.11964864f, 
    0.02454948f, 0.05750888f, -0.04729179f, -0.04503263f, 0.09381802f, 0.09103455f, 0.36481869f, -0.12338526f, 
    0.16696589f, -0.01598968f, -0.04060870f, -0.14091845f, -0.01167268f, 0.04881065f, -0.00508915f, 0.07141198f, 
    0.18980563f, -0.24108753f, 0.04241797f, -0.29780394f, 0.05811023f, 0.06519924f, 0.11370613f, 0.01789971f, 
    0.08880153f, -0.11157107f, -0.06392407f, -0.02093722f, 0.38020343f, 0.07115368f, 0.28549892f, 0.05120438f, 
    -0.02369510f, 0.07576351f, 0.18339989f, 0.08529751f, -0.12509753f, -0.01130653f, 0.05530355f, 0.00162277f, 
    0.00788929f, 0.08921456f, 0.02043623f, -0.16349502f, -0.04559610f, 0.04380625f, -0.00697513f, -0.01858489f, 
    0.01033024f, -0.00318029f, 0.00886003f, -0.10735951f, 0.00331588f, 0.23329236f, 0.07362387f, 0.04490015f, 
    0.06042000f, 0.12781431f, 0.09813174f, 0.10728770f, 0.03309904f, 0.01811575f, 0.05589621f, -0.06763694f, 
    -0.47882611f, 0.06925358f, 0.11918653f, 0.25779027f, -0.06296877f, 0.15234673f, -0.02109095f, 0.08871363f, 
    -0.02605805f, -0.14134291f, -0.05145215f, -0.10222025f, 0.19919083f, 0.04526030f, 0.00145533f, -0.15727356f, 
    0.10347529f, 0.06698968f, -0.00662924f, -0.04660567f, -0.12691565f, -0.03677707f, -0.04123032f, -0.00046595f, 
    -0.18116252f, -0.08610838f, 0.06352140f, 0.24012466f, 0.07713643f, -0.05283694f, 0.26378429f, 0.02434177f, 
    0.07619520f, 0.11062098f, 0.13519229f, 0.21621257f, 0.11934390f, 0.20617430f, 0.10818651f, -0.28647465f, 
    0.02071498f, 0.12310448f, 0.07452947f, -0.04865460f, -0.18915941f, -0.16080326f, 0.27194127f, 0.14154606f, 
    -0.12733920f, 0.14219874f, -0.03514460f, -0.21127240f, 0.00543044f, -0.07722700f, -0.15585655f, 0.02503607f, 
    -0.05389984f, -0.10948773f, -0.14748080f, -0.04987836f, -0.07237931f, 0.23139785f, -0.00405064f, -0.10425362f, 
    0.07817701f, -0.01951700f, -0.02286675f, 0.01514259f, -0.16397120f, 0.03133596f, -0.24094732f, -0.06368167f, 
    -0.04643170f, -0.26567659f, 0.07147836f, 0.05975236f, 0.07448736f, -0.03891024f, 0.07334669f, 0.09200748f, 
    0.08815265f, 0.07882119f, 0.06571709f, 0.11266932f, 0.08445847f, 0.11612821f, 0.01818726f, 0.14883333f, 
    -0.09317122f, -0.17458910f, 0.02773063f, 0.06730521f, 0.00864068f, 0.17824805f, -0.07280286f, 0.03470246f, 
    0.18753904f, -0.03396187f, 0.13269451f, 0.16613433f, -0.01981854f, 0.07064850f, 0.01007901f, -0.05992521f, 
    0.01395554f, -0.10987997f, 0.01656020f, -0.02780374f, 0.13245684f, 0.08648477f, 0.06792445f, -0.12300423f, 
    0.01390500f, -0.04301163f, 0.07199633f, 0.14075704f, -0.03661682f, -0.02493070f, -0.05692811f, -0.04371608f, 
    -0.04456765f, 0.06705502f, -0.03873766f, 0.01279967f, -0.06292152f, 0.14504711f, 0.02120301f, 0.00598729f, 
    0.04721166f, -0.05241738f, 0.06866766f, 0.28983697f, -0.50521868f, 0.14860319f, 0.11474031f, 0.27023619f, 
    0.05413974f, 0.05746472f, 0.00463541f, -0.08108189f, 0.05352594f, -0.09991545f, -0.07722796f, 0.19565886f, 
    -0.42074224f, 0.03263766f, 0.16202559f, 0.16209720f, -0.05293569f, -0.04164843f, 0.08219066f, 0.07399675f, 
    -0.14083853f, -0.02169149f, -0.12403224f, -0.26667804f, -0.06238203f, -0.01944794f, -0.08804759f, 0.17374736f, 
    -0.00811282f, 0.00640290f, 0.06979961f, 0.13128190f, 0.04926892f, 0.17456365f, -0.06685174f, 0.06022875f, 
    -0.32334110f, -0.24483980f, 0.08204652f, -0.09799359f, -0.06742962f, -0.07789825f, 0.13126047f, 0.06693432f, 
    0.05317197f, -0.05138677f, 0.10903161f, -0.00476905f, -0.26843330f, -0.08471465f, -0.14405844f, 0.15447317f, 
    -0.06670797f, -0.16920891f, 0.04497214f, 0.12474389f, 0.06898850f, -0.06621258f, 0.08047256f, 0.11633797f, 
    0.24783939f, 0.18338819f, 0.03523961f, 0.10414486f, -0.08400863f, -0.11401525f, 0.04444661f, 0.01626142f, 
    0.11452732f, 0.05930461f, 0.06403705f, -0.16305180f, 0.12450805f, 0.15518935f, 0.28314486f, -0.10335240f, 
    -0.16612045f, -0.25769502f, 0.01293675f, 0.05293762f, 0.08035214f, -0.02233571f, -0.08668131f, 0.15077291f, 
    -0.07778018f, -0.20470333f, 0.02589434f, 0.04668580f, 0.24186744f, 0.12600823f, -0.05466867f, -0.03763402f, 
    0.12280299f, 0.01959930f, 0.02959533f, -0.04832059f, -0.02016795f, 0.48474705f, 0.03284508f, 0.09649988f, 
    -0.05984345f, 0.09291195f, -0.08450709f, -0.11135355f, 0.04006919f, 0.00129491f, 0.19199428f, -0.10125292f, 
    -0.16120501f, 0.01241768f, -0.20831291f, 0.03666479f, 0.00437356f, 0.05802780f, 0.09593634f, 0.03697108f, 
    0.00358883f, 0.06846521f, 0.11879794f, -0.04664150f, -0.01804119f, 0.16368361f, 0.11689834f, 0.12038133f, 
    0.11040284f, 0.11461363f, 0.07580575f, 0.03984425f, -0.05041944f, 0.02041259f, -0.23152947f, -0.01230280f, 
    -0.39197275f, -0.43898958f, 0.18985206f, -0.18449455f, 0.13317083f, 0.04451180f, 0.04080110f, 0.03927791f, 
    0.03147608f, -0.09899576f, -0.00567234f, 0.15575862f, 0.05725140f, -0.08439264f, 0.04202338f, -0.06418436f, 
    0.15179957f, -0.11076251f, 0.08718669f, 0.01831336f, 0.19091822f, 0.10379726f, -0.01789467f, 0.14081706f, 
    0.10691508f, -0.01720187f, 0.41149908f, 0.21961559f, 0.02506860f, -0.00797507f, -0.27365455f, -0.10559054f, 
    -0.01586491f, -0.02796389f, -0.05648220f, -0.03224802f, 0.07960775f, 0.20129012f, 0.13808481f, -0.13134301f, 
    0.07602853f, -0.18616003f, -0.00448196f, -0.03260309f, 0.05005652f, -0.08968147f, 0.15782559f, 0.10079250f, 
    -0.26715451f, 0.10508659f, 0.04230669f, -0.17339706f, -0.04527306f, -0.12686273f, 0.17998555f, 0.02918395f, 
    -0.04547584f, -0.15198241f, -0.00934106f, 0.13113995f, 0.12043142f, -0.03476297f, -0.30346110f, 0.23216213f, 
    -0.06861645f, 0.08890502f, 0.14073224f, 0.06943580f, 0.06056707f, 0.11790645f, -0.07299905f, -0.04894180f, 
    0.08026771f, 0.38606691f, 0.07860712f, 0.42924929f, 0.03849920f, 0.12651634f, -0.04566026f, -0.08257682f, 
    0.02459409f, 0.17633830f, 0.09934461f, -0.09320176f, -0.24781625f, 0.09653746f, -0.45457077f, 0.07832014f, 
    -0.05212841f, 0.13801633f, 0.13316531f, -0.11535289f, 0.08373456f, 0.10180367f, -0.09604865f, 0.08633012f, 
    0.06430365f, -0.13905813f, -0.05440578f, 0.10544297f, 0.19196004f, 0.06642198f, 0.09259080f, -0.06449465f, 
    -0.03354032f, 0.00512955f, -0.06585146f, 0.14336956f, 0.29059291f, -0.01213912f, 0.09354793f, -0.03266952f, 
    0.07885408f, 0.03092398f, -0.10448436f, -0.03239989f, -0.03404461f, 0.12910402f, -0.23354523f, 0.11003499f, 
    0.07710756f, -0.11944071f, 0.06191460f, -0.35799110f, 0.12724842f, -0.00708597f, -0.08932309f, -0.16968744f, 
    -0.01574111f, 0.09714308f, -0.07572695f, 0.03173457f, -0.03821532f, -0.41789034f, 0.06273930f, 0.15833333f, 
    0.14679168f, 0.15578547f, -0.00321002f, 0.03358231f, -0.04720947f, 0.20828368f, -0.01142269f, -0.03738290f, 
    0.06498598f, 0.36594346f, -0.20230927f, 0.01708094f, -0.02255261f, -0.06402587f, -0.03707468f, -0.02847239f, 
    0.03198266f, -0.04304411f, -0.10307728f, 0.10697591f, 0.06252401f, -0.05094094f, -0.09825319f, 0.34857461f, 
    -0.02890505f, -0.01953712f, -0.06376313f, 0.04265193f, 0.00553444f, 0.09959304f, -0.02569849f, 0.00199541f, 
    -0.08451146f, -0.19321027f, 0.24119036f, 0.11907695f, 0.00276521f, 0.13650706f, 0.04268435f, -0.06660102f, 
    -0.08059898f, 0.05312398f, 0.05775242f, 0.11287019f, 0.27021292f, -0.07720023f, -0.07902078f, 0.03083486f, 
    -0.02108700f, -0.08679886f, 0.03063624f, 0.07266573f, 0.04118686f, -0.15728399f, 0.10662366f, -0.04690686f, 
    0.20037791f, 0.43264207f, -0.05830218f, 0.28106815f, 0.02912571f, -0.07206332f, -0.06662948f, -0.10048816f, 
    -0.14847571f, -0.05780394f, 0.04292109f, -0.09617596f, -0.16339624f, -0.01384469f, -0.00780976f, -0.33320445f, 
    0.10740634f, -0.04417085f, 0.02661316f, -0.19990234f, -0.10325271f, -0.00572033f, -0.03038933f, 0.23271063f, 
    0.01140921f, 0.48878953f, -0.25693226f, -0.28193161f, 0.26725841f, 0.05298026f, 0.00770869f, -0.05924713f, 
    -0.06926230f, -0.02178511f, 0.06205437f, -0.06218546f, 0.02154488f, -0.22836310f, 0.07415720f, 0.20448188f, 
    0.14445472f, 0.05100978f, -0.00092701f, 0.10018164f, -0.14673245f, 0.07340179f, -0.06245777f, 0.04879406f, 
    0.03287632f, 0.15510356f, -0.10844997f, 0.14254574f, 0.09779789f, -0.26379347f, 0.02649672f, -0.00280329f, 
    -0.01629977f, 0.10941084f, 0.11624940f, -0.14233144f, 0.05973197f, 0.03744848f, -0.15377344f, -0.42657664f, 
    -0.11470630f, -0.06716161f, -0.08550166f, -0.12176357f, 0.06358783f, -0.01472685f, 0.06549352f, -0.03093614f, 
    0.48049799f, 0.40002602f, -0.07682362f, -0.08557016f, 0.06954791f, -0.07292987f, 0.06942520f, -0.07405428f, 
    -0.13830169f, -0.15086153f, 0.09531408f, 0.02317140f, -0.34485736f, 0.13154384f, 0.07287873f, -0.22097190f, 
    0.03245395f, 0.04374595f, -0.03463726f, -0.11435018f, 0.03441220f, -0.08911961f, 0.12236635f, -0.02561995f, 
    -0.10266469f, 0.06505872f, 0.10923307f, 0.19596073f, -0.21045585f, -0.06863192f, 0.20704350f, 0.14964563f, 
    -0.07834244f, -0.13131975f, -0.03608354f, 0.03983896f, -0.26920551f, -0.17720342f, 0.09662092f, -0.03029427f, 
    -0.07805308f, -0.07025421f, 0.00696766f, -0.01118884f, 0.05666167f, -0.14063698f, 0.07182226f, -0.16834442f, 
    0.46477482f, -0.14701140f, -0.32424366f, -0.07872293f, 0.06763589f, -0.03510958f, -0.01650670f, 0.07370750f, 
    0.22361143f, 0.02167203f, 0.07939018f, 0.20518109f, -0.04497928f, 0.36977518f, -0.02750045f, 0.08555160f, 
    -0.27868906f, -0.08061035f, 0.05294773f, 0.28697604f, 0.17031659f, 0.07275969f, -0.01308503f, 0.11690367f, 
    0.24432315f, 0.08041573f, -0.08671626f, -0.08336177f, 0.11182685f, -0.08149387f, -0.24332474f, -0.10002013f, 
    0.13294366f, -0.15818140f, -0.08356972f, -0.13406168f, -0.08107066f, 0.01406736f, -0.09259716f, 0.14804229f, 
    0.00794561f, -0.09613688f, -0.08570666f, -0.30164221f, -0.07998146f, 0.01749517f, -0.05881877f, -0.14084698f, 
    0.08225044f, 0.12248474f, -0.07496377f, 0.06712867f, 0.11131579f, 0.08027074f, 0.29004705f, 0.09194759f, 
    0.06274071f, 0.17593950f, 0.17680264f, 0.20709364f, 0.00796895f, -0.16195783f, 0.17144810f, 0.17327651f, 
    -0.07391899f, 0.13831775f, 0.05461672f, 0.00670536f, 0.15402253f, -0.02312624f, 0.08191125f, 0.03828310f, 
    -0.16057798f, -0.06843025f, -0.00765843f, -0.17172632f, -0.00196601f, -0.02010159f, -0.09091949f, -0.10085138f, 
    -0.09012724f, 0.09061003f, -0.08466769f, -0.02318663f, 0.16118491f, -0.20050809f, 0.07504216f, 0.08220176f, 
    0.04866766f, 0.17850202f, -0.00310249f, 0.07120046f, 0.17891432f, -0.11622382f, -0.05257844f, -0.07360524f, 
    0.06803077f, -0.50143051f, 0.01325654f, 0.08166755f, -0.28408247f, -0.09876061f, 0.04122592f, 0.02633159f, 
    0.11466819f, 0.10634550f, -0.05783965f, 0.02477096f, -0.14752604f, 0.28655019f, -0.05787995f, -0.14411616f, 
    0.00823672f, 0.11434603f, 0.09609992f, -0.01186263f, 0.08300398f, -0.07919956f, 0.04647038f, -0.01719002f, 
    0.26445544f, -0.01759817f, 0.19565170f, -0.08086333f, -0.13435966f, 0.08988041f, -0.07608552f, 0.05587126f, 
    -0.06031977f, 0.00369519f, -0.17402199f, -0.14560430f, 0.60443801f, -0.05131590f, -0.13141252f, -0.20468055f, 
    0.12670602f, 0.02635505f, 0.09481259f, 0.28628963f, 0.05447780f, 0.04985701f, 0.08841674f, -0.10187408f, 
    0.09309514f, -0.47070584f, -0.28834072f, -0.08857754f, 0.06006097f, 0.09719244f, 0.00382938f, -0.13311498f, 
    0.19717562f, 0.14025043f, 0.01218726f, 0.22202314f, 0.13024071f, -0.00485348f, -0.16455486f, 0.02484871f, 
    0.22368336f, 0.09322511f, -0.17247552f, 0.02422081f, -0.01971658f, -0.07335276f, 0.02790109f, 0.01806142f, 
    0.10722152f, 0.28400490f, 0.11016778f, -0.10691463f, -0.03091291f, 0.18762590f, 0.00135022f, 0.11199199f, 
    -0.02264917f, -0.03062352f, 0.03324758f, -0.04969722f, 0.20224661f, 0.27659824f, 0.16994964f, 0.02262603f, 
    0.07491776f, -0.01073034f, 0.09863158f, 0.04807894f, 0.09035810f, -0.12276620f, 0.12379409f, -0.02235635f, 
    -0.11349317f, 0.02636772f, 0.05048017f, 0.24173266f, -0.04506421f, 0.10210528f, -0.03642872f, -0.00346113f, 
    0.18131281f, -0.01377406f, -0.03215472f, 0.03063808f, 0.08096891f, -0.03859757f, -0.28855091f, -0.33611014f, 
    -0.18984935f, -0.02886045f, 0.06690487f, 0.07720815f, 0.05502384f, 0.02567297f, 0.00519356f, 0.06067729f, 
    -0.28282213f, -0.10077697f, 0.17688364f, -0.00748374f, 0.16928042f, -0.03722689f, 0.07552224f, 0.01053783f, 
    0.12132216f, 0.10331661f, 0.03232641f, -0.17014188f, -0.06515690f, 0.26715139f, -0.05492833f, -0.06917171f, 
    0.04421592f, 0.11911803f, 0.10757157f, 0.14450385f, -0.02174534f, -0.10007399f, -0.10634725f, 0.07089224f, 
    -0.09826896f, 0.14165653f, -0.03155063f, -0.09357861f, 0.10882004f, 0.07057703f, 0.01814149f, 0.01202593f, 
    -0.06840824f, -0.08559227f, 0.00737745f, -0.03620349f, 0.03936081f, 0.19765010f, 0.20778719f, -0.11049623f, 
    0.12542021f, 0.06143527f, 0.11573078f, 0.03058741f, 0.05581031f, -0.05092202f, -0.20818549f, -0.05023069f, 
    -0.30187130f, -0.49855822f, 0.13047811f, -0.31510851f, 0.02023770f, -0.07983007f, 0.09203508f, -0.01088293f, 
    -0.00569162f, 0.10103205f, -0.09841945f, 0.03052754f, -0.03485909f, -0.21125938f, -0.25923681f, -0.16931804f, 
    0.00551923f, -0.06005108f, 0.04282571f, 0.14022881f, 0.01931711f, 0.05575453f, 0.01285145f, -0.11937634f, 
    0.27587137f, -0.07179693f, 0.11923676f, 0.28217444f, 0.01694520f, -0.00221418f, -0.00054384f, -0.06637041f, 
    0.09461669f, -0.02012776f, 0.11107101f, 0.09721287f, 0.09272394f, -0.31402674f, -0.02327200f, -0.27772665f, 
    -0.05767490f, -0.06664804f, -0.09598541f, 0.04975883f, 0.04987770f, 0.01834594f, -0.06452450f, -0.07616992f, 
    0.26477167f, 0.04731119f, 0.20461164f, -0.22555777f, 0.03756118f, 0.11890976f, 0.04208767f, 0.05912842f, 
    -0.17701441f, -0.04434011f, -0.11983638f, 0.13557450f, -0.41130203f, -0.01324002f, 0.10986510f, 0.07403658f, 
    0.12289602f, 0.02395432f, -0.05778445f, -0.09393222f, 0.06998149f, -0.08000455f, -0.08573967f, 0.06290359f, 
    -0.54488766f, -0.44586709f, 0.14581923f, 0.35349888f, 0.08005578f, 0.13803235f, 0.03166346f, 0.06004741f, 
    0.18265814f, 0.15074025f, -0.15186538f, 0.04941633f, -0.30658191f, 0.08662334f, -0.27752218f, 0.25252295f, 
    0.03823211f, -0.01218196f, 0.07687656f, 0.13291323f, -0.00747348f, 0.00115077f, -0.00762405f, 0.13779065f, 
    0.05521826f, -0.01156594f, 0.01206887f, -0.06653512f, 0.00414185f, -0.05281255f, -0.03167436f, 0.00062364f, 
    0.00934865f, 0.05651303f, 0.00059529f, 0.03478202f, -0.05131713f, -0.02894853f, 0.05535031f, 0.05594945f, 
    0.01712674f, -0.00030787f, 0.00660202f, -0.07405914f, 0.03614805f, 0.02374596f, 0.00119023f, -0.05373985f, 
    -0.02849620f, -0.04180608f, 0.02671449f, -0.01992683f, -0.03803398f, -0.00945294f, 0.05012210f, -0.06443793f, 
    0.02829261f, 0.04363296f, -0.04181422f, -0.02372546f, -0.00310299f, -0.01069434f, 0.03213648f, 0.03404028f, 
    0.03291416f, -0.02577085f, -0.04852849f, -0.02539910f, -0.06992554f, 0.05646562f, -0.02545904f, -0.03667527f, 
    -0.07367891f, 0.04254798f, -0.07430732f, 0.01044878f, 0.05197434f, 0.04999285f, 0.03826311f, 0.05155478f, 
    -0.04518843f, -0.03899725f, -0.02236488f, 0.04805301f, 0.02925440f, 0.02745657f, -0.02625701f, 0.05043584f, 
    0.04762389f, 0.00054265f, -0.01138723f, -0.03425063f, 0.01091281f, -0.01991593f, 0.00954063f, -0.05174499f, 
    0.00483626f, -0.03992041f, 0.00700260f, -0.00393010f, 0.00280417f, -0.03375825f, 0.02750860f, 0.05655768f, 
    0.04155400f, -0.00836051f, 0.00558091f, 0.03164846f, 0.05385422f, -0.02393612f, 0.05801994f, -0.04091310f, 
    -0.04438056f, -0.00440341f, -0.05530858f, -0.04437366f, -0.07968577f, 0.03600224f, -0.03271575f, -0.06714779f, 
    -0.00131176f, -0.03274898f, -0.03902401f, -0.01365096f, -0.06649103f, -0.05854571f, -0.04888034f, -0.06336050f, 
    0.01342869f, -0.03368335f, -0.00480404f, 0.00189378f, -0.04195778f, 0.03036097f, -0.00703141f, 0.01318572f, 
    -0.04658900f, 0.02527163f, -0.01064391f, -0.04574353f, -0.00141330f, -0.03319969f, 0.04941357f, 0.04515144f, 
    0.04890703f, -0.05344298f, 0.03373892f, 0.02264428f, -0.01831846f, 0.03629185f, -0.02547703f, -0.04021214f, 
    0.01448155f, -0.05044327f, 0.02739830f, 0.01384045f, 0.05711336f, -0.03850865f, -0.04094516f, -0.04824981f, 
    -0.03289905f, -0.05378160f, -0.07644052f, -0.03331339f, -0.01189899f, 0.02057373f, -0.05173304f, 0.02676369f, 
    -0.06441198f, -0.06133009f, 0.00238225f, -0.04614060f, -0.06085692f, -0.02186407f, -0.07834295f, -0.03322962f, 
    0.02917164f, 0.03071942f, -0.00258852f, 0.05149164f, -0.06631938f, 0.00508392f, -0.01115090f, -0.06116790f, 
    -0.04606290f, -0.02987633f, 0.03450707f, -0.05090416f, -0.02891037f, -0.00864453f, -0.01595275f, -0.03602310f, 
    0.00998917f, -0.06300312f, -0.05385076f, 0.00472495f, -0.01802196f, 0.02093558f, -0.02693989f, -0.05987957f, 
    -0.04664778f, 0.06133643f, -0.04268732f, -0.03242997f, -0.00361220f, -0.00082317f, -0.01482000f, -0.02276300f, 
    -0.00980408f, 0.04796356f, -0.03593469f, -0.03024496f, 0.05859334f, -0.00396827f, 0.01404793f, -0.05211768f, 
    -0.12262288f, 0.00766336f, -0.02853114f, -0.13623096f, 0.07327575f, -0.05772684f, -0.23422030f, -0.04804640f, 
    -0.22648562f, -0.02962302f, -0.07466577f, -0.01004565f, -0.13332047f, 0.20205075f, -0.06365044f, -0.08063211f, 
    -0.00779122f, -0.11516198f, -0.22538123f, 0.00230165f, -0.32668141f, -0.16024469f, -0.08486695f, -0.10316860f, 
    -0.31151080f, 0.00769196f, 0.04735660f, 0.09045760f, -0.13919078f, 0.07263593f, -0.09559575f, -0.16217038f, 
    0.03357298f, 0.17353138f, 0.01046275f, 0.01632895f, 0.19707407f, 0.22702688f, -0.13406803f, -0.19270150f, 
    -0.03894575f, -0.09498686f, -0.01548987f, 0.01859602f, -0.08522815f, 0.12240872f, 0.08266823f, 0.21712448f, 
    -0.02274525f, -0.30251652f, 0.23838522f, 0.10976362f, 0.06787498f, 0.10805685f, 0.01071480f, 0.04170528f, 
    -0.02070856f, 0.02820803f, -0.12047231f, -0.00740713f, -0.08296617f, 0.07256700f, 0.27615100f, -0.06202406f, 
    -0.07099397f, -0.07225806f, -0.15287767f, 0.15378739f, 0.00607185f, 0.11629256f, -0.20730224f, -0.06932283f, 
    -0.19193439f, -0.04532977f, -0.36088428f, -0.37017542f, -0.22392505f, -0.05583686f, -0.31294021f, -0.04465562f, 
    -0.01571452f, 0.01757302f, -0.06195026f, -0.11799179f, -0.04021994f, 0.47178066f, 0.08964635f, 0.05211801f, 
    0.04631108f, -0.24761415f, 0.07537512f, 0.21095398f, -0.13170753f, -0.10365931f, 0.02233429f, -0.34934738f, 
    -0.13107593f, -0.00036272f, 0.40072900f, 0.07383691f, 0.02216082f, 0.09325305f, -0.07585286f, 0.11184046f, 
    0.02208702f, -0.00723158f, -0.02067100f, 0.09771904f, 0.12545377f, 0.12198099f, 0.15262583f, 0.10897280f, 
    0.05897444f, -0.04104959f, -0.07591813f, -0.01992032f, 0.06247590f, -0.07538811f, -0.03786645f, -0.02944940f, 
    -0.04298330f, 0.09017599f, 0.36566758f, 0.39785314f, -0.18082991f, 0.00267406f, -0.02734413f, -0.08226378f, 
    -0.06527546f, -0.01374900f, 0.15415657f, 0.30490822f, 0.05286150f, -0.01206333f, 0.11635221f, -0.07810339f, 
    0.04872254f, -0.01299495f, 0.04707718f, 0.02757434f, 0.01012765f, 0.10607056f, 0.25549927f, -0.11855254f, 
    -0.24556975f, 0.19433239f, -0.09195318f, -0.19078282f, 0.18047333f, 0.25098461f, 0.10014156f, 0.06547506f, 
    -0.21689291f, -0.06165604f, -0.09339842f, -0.15564856f, -0.24031469f, 0.13599411f, -0.08978065f, 0.31280807f, 
    -0.02273062f, 0.08021077f, 0.24983808f, -0.14548711f, -0.03325013f, 0.10101773f, 0.07245821f, 0.11448483f, 
    -0.43923968f, -0.01041757f, 0.05794888f, 0.32402071f, -0.22227821f, 0.09724075f, -0.03680435f, 0.00455555f, 
    0.09649946f, -0.11849812f, 0.03907173f, -0.31078729f, 0.04383969f, 0.08269010f, -0.05723311f, 0.20967630f, 
    0.00254134f, -0.10980073f, 0.16340262f, -0.01258185f, 0.14241028f, 0.02643083f, 0.06907937f, 0.05493328f, 
    0.03624317f, 0.03248481f, 0.00625971f, -0.04794300f, 0.03531221f, -0.06475019f, 0.00871572f, -0.00029771f, 
    -0.01890908f, 0.03820847f, -0.05703281f, -0.07338136f, 0.01035454f, -0.03148993f, 0.03402711f, -0.01997709f, 
    0.04607181f, -0.06576620f, -0.02970670f, 0.04377747f, -0.01728894f, 0.03098760f, -0.02025296f, -0.04964313f, 
    0.01100760f, -0.03294317f, -0.01518855f, 0.03633853f, -0.00390900f, -0.01860219f, -0.02113628f, -0.04380527f, 
    0.01010764f, 0.01209745f, -0.06213551f, -0.03092044f, -0.07503616f, 0.04236401f, 0.01553880f, -0.01338772f, 
    0.03799562f, -0.00981912f, -0.02922747f, 0.03042699f, -0.05162027f, -0.07947998f, 0.05673494f, -0.02780097f, 
    0.05190932f, -0.05410613f, 0.02829942f, 0.05908921f, -0.05910592f, 0.02435318f, -0.00502062f, 0.00221422f, 
    -0.00527342f, -0.06274317f, 0.00768947f, 0.04595806f, 0.03727316f, -0.07752005f, -0.07267947f, 0.01348746f, 
    0.02327824f, 0.03989417f, 0.03513829f, 0.05684635f, -0.03878769f, 0.01642303f, 0.00941609f, 0.05872372f, 
    -0.05004327f, -0.02707323f, 0.04896635f, 0.00528385f, -0.00064741f, 0.00567477f, -0.05816141f, -0.00159256f, 
    -0.06847939f, 0.00676659f, -0.07585746f, 0.01139049f, 0.01656101f, 0.04745943f, 0.01629116f, -0.02231294f, 
    -0.03162767f, -0.06006920f, 0.04192360f, -0.00799630f, 0.06301557f, 0.04499101f, 0.05304690f, -0.04816173f, 
    -0.04421097f, -0.02689382f, -0.02314955f, -0.00612402f, -0.04886213f, -0.07781322f, -0.03402636f, 0.04805514f, 
    0.05483850f, 0.00901286f, -0.02236949f, -0.05973644f, -0.07385521f, -0.01945543f, -0.01131650f, -0.00183669f, 
    -0.05868325f, 0.06079603f, -0.05318369f, -0.03130827f, -0.03512393f, 0.02656489f, -0.07062198f, 0.03214829f, 
    0.05972587f, -0.02147248f, -0.04791798f, 0.06440754f, -0.07666147f, 0.05803302f, 0.03187155f, -0.01985878f, 
    -0.07800672f, -0.05217705f, 0.01442095f, 0.04657801f, 0.05954582f, -0.03863242f, 0.05379755f, -0.00718941f, 
    -0.03552864f, 0.02567385f, -0.07619245f, -0.05483857f, -0.04909192f, -0.05216903f, 0.00509359f, 0.05220112f, 
    -0.04597014f, -0.05965113f, -0.07434513f, -0.06967399f, -0.04189778f, -0.04854684f, -0.03266150f, -0.03902789f, 
    -0.00395600f, 0.01949825f, 0.01250419f, -0.05135227f, 0.04544508f, -0.01586562f, -0.04991959f, 0.01952349f, 
    0.05707029f, 0.05623400f, 0.05141840f, 0.00631209f, -0.04926442f, 0.02011059f, -0.06460048f, -0.01257764f, 
    -0.00151438f, 0.02351958f, 0.01112060f, 0.01136184f, 0.01236796f, -0.07254187f, -0.07780350f, 0.04736457f, 
    0.03451568f, -0.04720892f, 0.03448598f, 0.00042472f, -0.04300923f, 0.01913059f, -0.00873022f, -0.00315639f, 
    -0.04192402f, -0.00046077f, 0.02513808f, -0.04229278f, -0.02808972f, -0.05884453f, 0.00956480f, -0.02013983f, 
    0.09992608f, 0.13508840f, -0.12019881f, -0.17486323f, 0.10981979f, 0.11389434f, 0.02689651f, 0.15248071f, 
    0.06458519f, -0.04457942f, 0.02785517f, -0.02569604f, 0.18543276f, 0.26769137f, 0.01148303f, -0.14169009f, 
    0.20853473f, 0.09694151f, -0.01402340f, -0.07326110f, -0.02860162f, -0.02524889f, 0.05953816f, 0.02902191f, 
    -0.04617133f, 0.02649280f, 0.20512074f, 0.18012607f, -0.04905998f, 0.08476003f, 0.06995809f, 0.08964480f, 
    0.01798795f, -0.08592755f, -0.00935124f, 0.06395890f, -0.19388209f, -0.20353784f, -0.31340471f, -0.26538709f, 
    -0.08794559f, -0.04962563f, -0.00933676f, -0.03562477f, -0.07681900f, 0.05355078f, -0.02074463f, 0.05419397f, 
    0.07387324f, 0.02457391f, 0.34366563f, 0.05315231f, 0.14627995f, 0.03118075f, 0.07755909f, -0.06614823f, 
    -0.06934977f, 0.09178744f, -0.04268782f, 0.03907949f, -0.07357626f, -0.07361074f, -0.09272925f, -0.09751789f, 
    -0.06167698f, 0.13028201f, -0.03491953f, 0.19868723f, 0.04237396f, -0.01518590f, 0.02911025f, 0.15095405f, 
    -0.09753973f, -0.07814426f, 0.04113859f, -0.07608366f, 0.10605894f, -0.11697903f, -0.08780177f, -0.02680840f, 
    -0.08055753f, -0.04749091f, -0.05652093f, -0.15898454f, 0.08808649f, 0.01323420f, 0.04708731f, -0.15143926f, 
    0.11022479f, 0.01491779f, 0.00468574f, 0.04933110f, -0.05743259f, -0.07774633f, -0.12978238f, 0.06162165f, 
    0.07814243f, 0.04689522f, 0.12725188f, 0.08196173f, -0.15172128f, 0.10083344f, 0.06409482f, -0.02081827f, 
    -0.04906382f, -0.02841624f, -0.05422862f, 0.16885118f, 0.04404900f, 0.05112658f, -0.05121683f, -0.05289937f, 
    -0.01429520f, 0.09070728f, -0.05628557f, 0.05333384f, 0.00085839f, 0.01332183f, -0.00170089f, -0.05575321f, 
    0.15457779f, -0.10883934f, -0.17086825f, 0.10231332f, 0.00542575f, -0.13153465f, 0.00828356f, -0.13534214f, 
    0.05145598f, -0.10050742f, 0.12830776f, 0.05433423f, -0.04886899f, -0.27081409f, -0.04763519f, -0.09187104f, 
    -0.06037198f, -0.02007866f, -0.01415049f, -0.01623592f, 0.06906059f, -0.02524753f, 0.01893399f, -0.11234844f, 
    0.20260610f, -0.14669633f, 0.09624445f, -0.14445905f, 0.06631747f, 0.12975319f, -0.13556534f, 0.03796492f, 
    -0.15872659f, 0.06713823f, -0.13466822f, -0.02898118f, -0.11072976f, 0.16447376f, 0.24429743f, 0.08749289f, 
    0.17762479f, 0.01600040f, -0.03046257f, -0.04404966f, -0.12891313f, -0.05130688f, -0.01799158f, 0.11817917f, 
    -0.23359592f, -0.32341999f, 0.35055831f, -0.02585407f, -0.03727787f, -0.00804009f, 0.09397234f, 0.09404068f, 
    0.11078767f, 0.06646898f, -0.12316538f, -0.09688101f, 0.28229836f, 0.16850349f, 0.24772355f, 0.21459557f, 
    0.05063290f, -0.02113484f, 0.16467854f, 0.02922253f, 0.03000908f, 0.10888876f, 0.06513614f, 0.03642720f, 
    -0.09596006f, -0.06328262f, 0.08963175f, 0.28207079f, -0.04878861f, 0.04735396f, 0.14379257f, -0.06897657f, 
    0.02841001f, -0.06885951f, 0.08505597f, 0.23736046f, -0.03505828f, -0.11480343f, 0.07450030f, 0.13837232f, 
    -0.00802762f, 0.05929123f, 0.11259612f, -0.09545259f, 0.13308269f, -0.06651957f, 0.11048256f, 0.11273444f, 
    0.16369148f, -0.16738880f, -0.18738891f, 0.20558247f, -0.06898732f, -0.21257475f, 0.10200398f, 0.11211359f, 
    0.07859883f, 0.00823287f, 0.04177158f, 0.15232503f, -0.17430398f, 0.11942258f, 0.08290221f, 0.18474226f, 
    0.04194290f, 0.00882261f, 0.12241396f, 0.09375373f, 0.12554871f, -0.05158072f, 0.02240777f, 0.12075871f, 
    0.24359177f, -0.05791207f, -0.01179020f, 0.01138094f, 0.13456291f, 0.08923592f, -0.22539100f, -0.10482243f, 
    0.10374517f, -0.16765405f, 0.01591169f, -0.18229741f, 0.13889822f, 0.11252537f, -0.16574563f, 0.08727618f, 
    0.15873143f, 0.06912722f, -0.19494052f, -0.10307845f, -0.07830095f, -0.16334538f, -0.13463561f, -0.16420475f, 
    0.09179106f, 0.07148100f, -0.23883243f, 0.04580841f, -0.00669043f, 0.06630649f, 0.18892835f, 0.09027618f, 
    0.15086994f, 0.18280783f, 0.20624731f, 0.33002135f, 0.09390160f, 0.00851360f, 0.37129545f, 0.10602977f, 
    -0.09140238f, -0.00658922f, -0.05441992f, -0.10614432f, 0.04835250f, 0.02422977f, 0.06431091f, 0.01557307f, 
    0.10596764f, 0.06308315f, 0.03909996f, 0.01529975f, 0.20367524f, 0.00895150f, 0.02462448f, -0.01995837f, 
    -0.00580149f, -0.13194299f, -0.03893186f, -0.09106589f, 0.06060240f, -0.21328476f, 0.04320155f, 0.00530260f, 
    0.01850362f, 0.05135597f, -0.03302864f, 0.03001499f, 0.15864907f, -0.11082201f, -0.14495650f, -0.04272635f, 
    -0.39276540f, -0.25356156f, -0.04981863f, 0.23009981f, 0.08381007f, 0.05732360f, 0.07447221f, 0.19006419f, 
    -0.07723140f, 0.05243566f, -0.01866380f, 0.08214109f, 0.14088748f, 0.17184341f, 0.10104991f, 0.10050677f, 
    0.13728058f, 0.09221824f, 0.08194236f, -0.06308214f, 0.08369852f, -0.02233682f, 0.06274243f, 0.06734979f, 
    0.02778992f, 0.10864283f, 0.17744762f, -0.23820119f, 0.00945441f, 0.14560048f, -0.04650445f, -0.04990305f, 
    0.06838815f, -0.13630135f, -0.19586311f, -0.13054766f, 0.10318224f, -0.14789356f, -0.14115368f, 0.02992428f, 
    -0.10721266f, -0.06617886f, 0.03890114f, 0.15441465f, -0.03520869f, 0.16594851f, 0.24304384f, -0.22375330f, 
    -0.19121654f, -0.28060508f, -0.30924949f, 0.14464924f, 0.17778319f, -0.00547921f, -0.04131156f, -0.00233101f, 
    -0.17955925f, 0.06712578f, -0.01773190f, 0.01982304f, -0.21228068f, -0.02480075f, -0.11901192f, 0.17135137f, 
    0.22014812f, 0.05265198f, -0.04207443f, -0.06614163f, 0.09711270f, 0.01083132f, -0.09436633f, 0.01414564f, 
    0.30861229f, 0.05903954f, 0.06637631f, -0.03735606f, -0.00169366f, 0.11068946f, -0.10677598f, -0.07618389f, 
    0.05887914f, -0.03503078f, -0.05940491f, 0.12428555f, 0.27253348f, 0.13618588f, 0.03879988f, -0.13059542f, 
    0.05571998f, -0.09030272f, -0.08995385f, 0.07903854f, 0.26937059f, 0.09898643f, 0.12112155f, 0.15974045f, 
    -0.14719625f, -0.11531144f, 0.15053760f, -0.07417661f, 0.00044310f, 0.09789235f, -0.14497046f, -0.21763450f, 
    0.24702092f, 0.08279172f, -0.02165011f, 0.13565719f, 0.07235376f, -0.12766281f, -0.10798443f, 0.11011761f, 
    0.00313351f, 0.12185388f, -0.16991933f, -0.25826681f, -0.01083547f, 0.19556215f, 0.07889402f, 0.11969011f, 
    0.10153186f, 0.18677904f, -0.23666084f, 0.12890694f, 0.08479425f, -0.13370201f, 0.19112633f, -0.00396758f, 
    -0.00795971f, -0.02601633f, -0.06778091f, -0.06673835f, 0.06926865f, -0.13319999f, -0.45452464f, 0.11151306f, 
    0.07045273f, 0.15493645f, -0.02135149f, 0.03088029f, 0.06573626f, 0.18043074f, -0.16896898f, 0.15310082f, 
    -0.11723365f, 0.16847295f, 0.20785086f, -0.07834631f, -0.04233215f, 0.18298146f, 0.01774680f, 0.02198711f, 
    -0.06258841f, 0.05072987f, 0.08139168f, 0.26844060f, 0.37756544f, 0.09754382f, 0.10930526f, -0.21454619f, 
    -0.00799941f, -0.25013885f, 0.16107428f, 0.14140438f, 0.06174406f, 0.02723701f, 0.13889702f, -0.07595730f, 
    0.29532474f, -0.01411502f, 0.09517975f, 0.03034557f, 0.06693887f, -0.08765651f, -0.00131969f, 0.05424406f, 
    -0.09764562f, 0.11479052f, 0.02373750f, -0.23690632f, 0.13623247f, -0.25305942f, -0.19088139f, 0.07778665f, 
    0.11443879f, -0.22840290f, 0.01051504f, -0.05815893f, 0.10548357f, 0.07110401f, -0.00264901f, 0.00330915f, 
    0.26785105f, -0.08868393f, -0.08480279f, 0.19231719f, 0.19824426f, -0.03910906f, -0.03305170f, 0.09412567f, 
    0.02674374f, -0.02810134f, -0.00254968f, -0.00671444f, 0.11257783f, -0.21417272f, 0.10614445f, 0.00679615f, 
    0.08132942f, -0.02659537f, -0.07304867f, -0.21443094f, -0.00505140f, 0.04579309f, 0.01020814f, 0.10183784f, 
    0.15448640f, 0.09594638f, -0.19417465f, -0.14043465f, 0.01613411f, -0.12407299f, 0.20825335f, -0.10910022f, 
    -0.09341937f, -0.00246441f, -0.04538804f, -0.02087890f, -0.38853407f, 0.12877855f, -0.23162133f, -0.01062665f, 
    0.12223278f, -0.08502872f, -0.09308912f, -0.18748224f, 0.27999020f, 0.02747416f, 0.07708927f, 0.04480722f, 
    -0.07497610f, -0.09193136f, -0.23474474f, 0.41182691f, 0.10989368f, -0.05788402f, -0.10966545f, -0.25160095f, 
    0.10991240f, -0.05758645f, -0.04168253f, -0.03682488f, -0.41183883f, 0.10213596f, -0.02716460f, 0.19231293f, 
    0.15111837f, -0.19042036f, -0.15332823f, -0.17953624f, 0.12921979f, -0.00731131f, 0.09292165f, 0.01576760f, 
    -0.33415455f, -0.27233604f, -0.44659221f, -0.25456923f, -0.02825579f, -0.08619128f, -0.30204472f, -0.04192905f, 
    0.03784862f, -0.03686812f, -0.01932515f, -0.03447516f, -0.27601078f, 0.03089015f, -0.10846677f, -0.03562929f, 
    0.21443368f, 0.21177323f, -0.05515363f, 0.06028668f, -0.07840125f, 0.06782096f, 0.05015979f, 0.13342099f, 
    -0.26924017f, 0.18139915f, 0.08571229f, 0.00930393f, -0.05637259f, 0.09883370f, 0.00748055f, 0.04862008f, 
    -0.23427495f, -0.11620693f, -0.12429774f, -0.00425852f, 0.23421237f, 0.07892389f, -0.22112215f, -0.16213696f, 
    -0.06279733f, -0.03763553f, -0.01524821f, -0.06771656f, -0.12309611f, -0.17882128f, -0.03788219f, 0.07935055f, 
    0.02350779f, -0.10346562f, 0.18449415f, 0.41097674f, -0.04358829f, 0.06342520f, 0.16280435f, -0.16858859f, 
    -0.09418140f, -0.01898173f, 0.06663993f, -0.00295150f, 0.19015951f, -0.10944365f, -0.25534043f, 0.38612235f, 
    0.04647943f, 0.12516445f, 0.18320401f, -0.00392733f, 0.04994129f, 0.06940215f, 0.08957808f, 0.17503650f, 
    -0.15806119f, -0.18094823f, -0.18862243f, -0.10644803f, 0.14334126f, -0.09720534f, -0.01103827f, 0.01453627f, 
    0.05034307f, -0.31361204f, -0.09919694f, 0.09029176f, 0.17288499f, 0.43396941f, 0.18506612f, -0.13253056f, 
    0.06892291f, 0.14854923f, 0.23161338f, 0.41217715f, -0.02004023f, -0.00462135f, -0.05989397f, -0.03008320f, 
    0.45794055f, 0.30348822f, 0.29387414f, 0.25752804f, -0.02220166f, 0.08169834f, -0.06341109f, 0.02072890f, 
    0.07628956f, -0.00629757f, 0.05730486f, -0.02882518f, 0.29317778f, 0.13072076f, 0.20302975f, 0.19067498f, 
    -0.05633374f, -0.13759597f, -0.02255927f, 0.09427779f, -0.03941200f, 0.07046446f, -0.15756525f, -0.04774119f, 
    0.30810463f, -0.14207649f, 0.07876284f, -0.18863244f, -0.19525684f, -0.09252205f, -0.10119238f, -0.10351777f, 
    -0.02210684f, -0.14696683f, 0.08230028f, 0.13427447f, 0.14654708f, -0.00766058f, 0.03131904f, -0.13242166f, 
    -0.08970560f, -0.07928390f, -0.10291284f, -0.03183827f, -0.04292225f, -0.12953912f, 0.10014630f, -0.08678094f, 
    -0.59551424f, -0.25718844f, -0.45564151f, -0.34270015f, 0.00627881f, 0.19159770f, -0.01428880f, -0.05856119f, 
    0.18787515f, 0.00559126f, -0.04241302f, 0.10551684f, -0.16114910f, 0.33610803f, -0.01896240f, 0.16510269f, 
    0.04545338f, 0.12363034f, -0.00728527f, -0.28200099f, 0.07229374f, -0.01309002f, 0.21629035f, 0.10400655f, 
    -0.14602074f, 0.21777676f, 0.31690833f, 0.12594871f, -0.18053497f, -0.01759930f, 0.02857207f, -0.14146264f, 
    -0.07130682f, -0.17621586f, -0.11045209f, -0.14431636f, 0.20974736f, 0.30016842f, -0.01723789f, 0.27954087f, 
    0.02093618f, -0.07670273f, -0.05367243f, -0.04149710f, 0.09015845f, 0.07419025f, 0.04743569f, -0.00455149f, 
    -0.25738868f, -0.27827018f, -0.02376976f, 0.15509368f, 0.04737705f, -0.09270697f, 0.03842461f, -0.05124300f, 
    0.03478437f, 0.04329472f, 0.03162111f, 0.05698097f, -0.00708571f, -0.11360420f, -0.12640570f, 0.26639867f, 
    -0.08433168f, -0.01150726f, -0.01066038f, 0.09815945f, 0.01892378f, 0.10949270f, -0.05936845f, 0.13130216f, 
    0.07501834f, 0.10366659f, -0.09264866f, -0.15492773f, -0.08003292f, 0.03584754f, -0.01706088f, -0.04596861f, 
    -0.05457248f, -0.04466492f, 0.03566611f, -0.16873203f, 0.35842684f, -0.23319736f, 0.10806862f, -0.14748114f, 
    -0.15970606f, -0.09002924f, 0.11271907f, 0.07547778f, -0.06069615f, 0.01498955f, -0.08395199f, -0.09244828f, 
    0.05892511f, -0.02159136f, 0.12621757f, -0.12919882f, -0.12254540f, 0.13970616f, -0.21522565f, -0.02036064f, 
    -0.08268732f, -0.04711340f, 0.01454427f, -0.07826591f, 0.33934036f, 0.32201347f, 0.23250024f, 0.24931669f, 
    -0.01238925f, -0.00238857f, 0.19534452f, -0.01434357f, -0.04167882f, 0.07362248f, 0.12525307f, -0.02202489f, 
    0.12457548f, -0.09797373f, -0.05530967f, 0.08651377f, -0.08906540f, -0.00437481f, 0.12624833f, 0.02824560f, 
    -0.06832718f, 0.01876267f, 0.04437832f, 0.03933858f, 0.00231535f, 0.18482348f, -0.05262231f, 0.25717521f, 
    0.05084106f, 0.04780959f, 0.01287937f, 0.06918571f, 0.00216138f, 0.04473153f, -0.03392214f, 0.02705657f, 
    -0.07145447f, 0.14735623f, 0.03252537f, -0.07401159f, 0.00183598f, 0.12404034f, 0.04038618f, 0.06562568f, 
    0.01467167f, -0.05329045f, 0.03747954f, 0.08429538f, 0.10679186f, 0.02235138f, 0.06085052f, -0.22701479f, 
    0.05705538f, -0.02949188f, 0.10852193f, 0.01111946f, 0.14058301f, 0.11616717f, 0.14063530f, 0.16604719f, 
    -0.12032803f, 0.24269229f, 0.19645187f, -0.19172032f, 0.14391828f, 0.09946976f, -0.18093155f, -0.03187761f, 
    -0.08954565f, -0.03637985f, -0.19318846f, 0.02609974f, -0.01363848f, -0.02830547f, 0.07350156f, -0.12572336f, 
    -0.05082183f, -0.18431631f, -0.01292715f, 0.19716212f, -0.04518404f, -0.01949657f, 0.03922383f, 0.09079395f, 
    -0.32638028f, 0.02853089f, 0.30095100f, 0.20532735f, 0.13918224f, -0.02037308f, 0.04182639f, 0.09434781f, 
    0.05849916f, -0.13479395f, 0.09639803f, -0.02122703f, 0.13871919f, -0.01194900f, -0.11798988f, -0.04084637f, 
    -0.31130421f, -0.01477497f, -0.07391462f, 0.00693440f, 0.07542171f, 0.07950418f, 0.08985941f, -0.04466942f, 
    0.46094686f, 0.66886890f, 0.08278025f, 0.02877607f, -0.06185132f, -0.12166256f, 0.05565713f, -0.14642541f, 
    -0.06844036f, -0.03774923f, 0.13620752f, -0.15075912f, -0.08709319f, 0.00075470f, -0.21552926f, -0.24811037f, 
    -0.18004158f, 0.10567139f, 0.07262804f, -0.16427262f, 0.08115122f, 0.09615560f, -0.04475604f, -0.06996454f, 
    -0.02638837f, 0.21817549f, 0.01956240f, -0.08370592f, -0.10969474f, -0.04551950f, 0.02073089f, 0.19417602f, 
    0.05623507f, 0.01733921f, 0.07463022f, -0.00240639f, -0.10638653f, 0.20814009f, 0.06193075f, 0.09323529f, 
    0.05116752f, -0.03612209f, 0.16554704f, 0.11346843f, 0.00324563f, 0.02976117f, 0.28412718f, 0.08657584f, 
    -0.12770736f, 0.10814340f, 0.03452264f, 0.25469872f, 0.00808014f, 0.07917788f, 0.00661473f, -0.02964856f, 
    -0.08031756f, -0.06329440f, 0.08712938f, 0.09831531f, -0.02766654f, 0.24548788f, -0.17872877f, -0.37350303f, 
    -0.07908645f, -0.08548399f, -0.08811092f, -0.05480888f, 0.00796703f, -0.11839233f, -0.05760074f, 0.01137193f, 
    -0.02943233f, -0.29160595f, 0.21984151f, -0.14312187f, 0.06381491f, 0.13201399f, -0.11820102f, 0.01197465f, 
    -0.09701450f, -0.02457557f, -0.01136845f, -0.14941722f, -0.19312836f, 0.14988890f, 0.18691613f, -0.20729649f, 
    -0.02467590f, 0.07128925f, -0.02686362f, 0.18272801f, 0.08115139f, -0.12787241f, 0.01086324f, 0.07278761f, 
    0.07937386f, 0.08828406f, -0.19757032f, -0.02143268f, -0.04016163f, -0.04449246f, 0.02756978f, 0.00377935f, 
    -0.04433611f, -0.10790271f, 0.02840666f, 0.05007641f, -0.11503029f, 0.16208044f, 0.05608976f, 0.07095207f, 
    0.04255784f, -0.03344724f, 0.06057220f, 0.08631095f, 0.10167858f, 0.06375886f, -0.10711507f, 0.08657096f, 
    -0.16005434f, -0.37673429f, 0.18553941f, -0.33627596f, 0.04008443f, 0.09048912f, 0.04990960f, -0.03030722f, 
    0.14636269f, -0.00055967f, -0.13826980f, 0.08046427f, 0.06244642f, -0.06522823f, -0.00980943f, 0.08906435f, 
    -0.08119213f, 0.02742669f, -0.14232433f, 0.06647627f, 0.03400837f, 0.01921382f, -0.10358862f, -0.18968409f, 
    -0.00023237f, -0.50655663f, -0.02911414f, 0.42997590f, 0.00755990f, -0.05775620f, -0.14121774f, 0.01899267f, 
    0.08568780f, 0.00995126f, 0.03469722f, -0.01721361f, -0.02370738f, -0.10841791f, 0.00007293f, -0.13466455f, 
    -0.05148740f, -0.18699135f, -0.06637323f, -0.12231892f, -0.00019258f, -0.02245904f, -0.00726481f, -0.08855148f, 
    0.07539874f, -0.16909781f, 0.24064869f, -0.26162657f, -0.02035929f, 0.17788188f, -0.08597651f, 0.10491184f, 
    -0.02634052f, -0.08091170f, -0.07383440f, -0.04087806f, -0.18907708f, -0.02567581f, 0.28957731f, 0.19018525f, 
    0.15629262f, 0.00065679f, -0.01595107f, -0.12217165f, -0.10577998f, 0.07636975f, 0.06444097f, -0.09753194f, 
    -0.49242097f, -0.42372078f, 0.09772921f, 0.12410618f, 0.05580046f, -0.00485100f, -0.00380377f, 0.00883660f, 
    0.08217727f, -0.03213965f, 0.00854001f, -0.01736565f, 0.25947940f, 0.15765913f, 0.10678481f, 0.20891312f, 
    -0.09052014f, 0.06274526f, 0.04539357f, 0.03919721f, -0.08080135f, -0.00764380f, -0.07554682f, -0.04494884f, 
    0.43965217f, 0.28184649f, 0.22335362f, 0.36434892f, 0.07086802f, 0.00782961f, -0.10699997f, -0.16505274f, 
    -0.07775192f, -0.01244324f, -0.02666164f, 0.06054808f, 0.04258714f, -0.04960723f, 0.08525394f, 0.11839925f, 
    -0.05215403f, 0.05031988f, -0.01420684f, 0.01594147f, 0.06867610f, 0.02263214f, -0.20527726f, 0.05974248f, 
    -0.12880607f, -0.16603009f, -0.10543198f, -0.05444479f, 0.14985299f, 0.03297357f, -0.00798586f, -0.21280582f, 
    0.22325823f, -0.01114832f, -0.09947684f, 0.00925672f, 0.14815986f, 0.34145260f, 0.16364203f, 0.39466733f, 
    -0.02626393f, 0.08811086f, -0.26799271f, -0.26144588f, -0.02878776f, -0.00973963f, 0.16622683f, -0.04899101f, 
    0.13631885f, 0.06786159f, -0.18233132f, 0.13219896f, -0.16541632f, -0.00161867f, 0.16439196f, 0.02572718f, 
    0.10331330f, -0.10191443f, -0.02616387f, 0.01313852f, 0.20443514f, -0.24230537f, -0.16606231f, 0.07964284f, 
    0.02957083f, 0.05658969f, -0.04420055f, 0.08682553f, -0.10100714f, -0.03920237f, -0.03954492f, 0.20817658f, 
    0.18177189f, 0.15480372f, 0.15689261f, -0.06358769f, 0.05364447f, -0.05402492f, -0.01470923f, 0.15138090f, 
    0.03181755f, 0.03079907f, 0.00496714f, 0.17274632f, 0.14644939f, -0.27581435f, 0.03699603f, 0.18132439f, 
    0.00913478f, -0.17809872f, 0.14690457f, 0.15779588f, -0.04215054f, 0.01825054f, 0.22152524f, -0.08180071f, 
    0.47128746f, 0.20472224f, -0.16526173f, 0.07008958f, -0.16208389f, -0.17655829f, -0.15591674f, -0.13374723f, 
    0.11201905f, -0.02196849f, -0.02915489f, -0.29181272f, 0.09857798f, -0.14056408f, -0.34398735f, 0.05286598f, 
    0.01005184f, -0.06894730f, 0.03307976f, -0.13364363f, -0.03392418f, -0.07236593f, -0.14375155f, -0.24828225f, 
    -0.14522626f, -0.12093818f, -0.09877730f, 0.11458691f, 0.14047611f, -0.16844615f, 0.08003302f, 0.09422415f, 
    0.04805848f, 0.05112164f, -0.01387894f, -0.02764763f, -0.22442462f, 0.10805988f, 0.05593178f, 0.20986629f, 
    -0.05938811f, 0.09293145f, -0.10864627f, -0.10375512f, -0.01227208f, 0.08605617f, -0.07600448f, 0.14032529f, 
    0.06050861f, 0.17551179f, -0.23288730f, 0.13894793f, -0.14813997f, -0.01176158f, 0.09798809f, -0.09707168f, 
    0.03892984f, 0.02002234f, -0.05074673f, -0.03736719f, -0.04851714f, 0.01587872f, 0.08245888f, -0.25593695f, 
    0.12580779f, 0.02139229f, -0.05263187f, 0.03482409f, 0.14358771f, -0.02606011f, 0.00467105f, -0.01804797f, 
    0.01897518f, -0.27426094f, -0.39946279f, 0.12061352f, -0.03117547f, -0.03060756f, -0.10853155f, 0.06088511f, 
    -0.03541939f, -0.04758997f, -0.00313837f, -0.04351078f, -0.16053991f, -0.26105088f, 0.30997398f, -0.11272532f, 
    0.15399773f, -0.08610554f, -0.19065654f, 0.07739986f, 0.09934904f, -0.12534608f, 0.06159536f, -0.16985275f, 
    -0.32363209f, -0.05391773f, 0.19041355f, 0.02323847f, -0.04292671f, -0.03450700f, 0.13208702f, 0.18793829f, 
    -0.06107908f, -0.19552319f, -0.05029038f, 0.14088060f, -0.21340472f, -0.11694575f, 0.11058077f, 0.19128802f, 
    -0.07865266f, -0.02615723f, 0.00598627f, -0.10203891f, 0.04811439f, -0.17312171f, 0.17784639f, -0.06150384f, 
    0.37061092f, -0.10577578f, -0.02721175f, 0.19196425f, 0.06419371f, -0.09867034f, -0.00834920f, 0.18056329f, 
    0.16385129f, 0.24100946f, 0.05094232f, 0.04022365f, -0.13850950f, -0.12761861f, 0.10073341f, -0.00035789f, 
    -0.10497429f, -0.17590016f, 0.08183751f, 0.26269764f, 0.22978833f, -0.01727761f, 0.08975752f, 0.13319352f, 
    0.19236906f, 0.11884854f, -0.04533783f, -0.02831411f, 0.15102573f, 0.02347020f, -0.06508402f, 0.01012699f, 
    -0.01679568f, -0.13567494f, -0.04919936f, -0.20771301f, -0.12118594f, 0.17200804f, -0.22160159f, 0.16150706f, 
    -0.00501557f, 0.03446698f, -0.19925785f, -0.14970540f, 0.02691627f, 0.10883046f, -0.08566842f, -0.13662502f, 
    -0.09728871f, -0.06963618f, -0.03542165f, 0.12175177f, -0.06276479f, -0.06840721f, 0.27293584f, 0.08272132f, 
    0.12144790f, 0.16144857f, 0.21224283f, 0.39374593f, 0.02121644f, -0.06797329f, 0.23290938f, 0.16358288f, 
    -0.04710728f, 0.03928340f, 0.02731533f, -0.09565598f, 0.06453938f, -0.12292147f, 0.01304667f, 0.02533836f, 
    0.16723406f, 0.19912462f, 0.00843457f, -0.15334301f, 0.04173524f, -0.05838228f, -0.05970401f, -0.03568470f, 
    -0.12001965f, -0.02756458f, -0.03592394f, -0.02879271f, 0.16693553f, -0.38818851f, 0.18678562f, -0.12977397f, 
    0.18993625f, -0.05919440f, 0.04620043f, -0.11091802f, 0.23393215f, 0.01626977f, 0.04937333f, -0.10568120f, 
    -0.22249587f, 0.00924977f, 0.24395187f, 0.27225271f, 0.27669856f, 0.00172402f, -0.10905714f, 0.12146132f, 
    -0.08763913f, 0.04507700f, 0.11546185f, 0.08794774f, -0.01222536f, 0.09460751f, 0.03537612f, 0.06715965f, 
    0.01869334f, 0.01725069f, 0.08724181f, -0.10552970f, 0.01423268f, -0.01460332f, 0.09537608f, -0.02242362f, 
    -0.05424092f, 0.11572661f, 0.32823116f, -0.01529224f, 0.06680697f, 0.06835956f, -0.10947920f, 0.02534666f, 
    -0.21302369f, -0.08753686f, -0.18751192f, -0.13698645f, 0.32920346f, -0.05612438f, -0.17268805f, -0.03686747f, 
    -0.02121879f, -0.07612538f, 0.04619509f, 0.15148938f, 0.09760021f, -0.00563683f, 0.12042710f, -0.01867893f, 
    -0.12269818f, -0.09317558f, -0.21648590f, 0.37869382f, 0.12048794f, -0.06793489f, -0.05444447f, -0.29220766f, 
    0.07128170f, 0.14796542f, 0.09140301f, 0.02558369f, -0.11186847f, 0.20843598f, -0.01779688f, 0.00984193f, 
    0.17953090f, 0.05962826f, -0.06888003f, -0.14443778f, 0.05929825f, -0.07457896f, 0.00528088f, -0.10036897f, 
    -0.19648249f, -0.16374376f, -0.11682761f, 0.14155948f, 0.17378326f, 0.06383230f, 0.04795560f, -0.05198755f, 
    0.02040874f, -0.05864683f, -0.01565748f, 0.15983728f, 0.03639572f, -0.13281877f, -0.06993346f, 0.00789185f, 
    0.00823248f, -0.04365208f, -0.03497751f, -0.06384052f, -0.06396036f, 0.03186616f, -0.08943620f, 0.12042585f, 
    0.46170086f, -0.12629975f, -0.09460147f, -0.11434350f, 0.13586660f, -0.08463008f, 0.00598792f, 0.03660920f, 
    0.03066413f, 0.17756586f, 0.02251061f, 0.04895281f, -0.39000019f, -0.33140630f, 0.02415062f, 0.01656777f, 
    0.02795196f, 0.00665284f, 0.09043089f, 0.04508720f, 0.07951041f, 0.12122297f, 0.04234028f, -0.13870773f, 
    0.14390850f, 0.21787982f, -0.11060480f, -0.11435964f, -0.04472616f, 0.16575682f, -0.15215185f, 0.08342668f, 
    0.05345593f, 0.00880504f, 0.06996445f, 0.14667618f, -0.14225350f, -0.03841086f, -0.14504631f, 0.17757018f, 
    0.04366471f, -0.04090672f, -0.06829390f, 0.00541440f, 0.02289701f, 0.12352750f, 0.04493753f, 0.06416123f, 
    0.03518018f, -0.10952796f, 0.14296657f, 0.14149465f, -0.05630981f, 0.02660812f, 0.15034419f, 0.03949484f, 
    -0.15777037f, 0.03866171f, 0.00198937f, -0.18418652f, 0.16227441f, -0.19694588f, -0.03007150f, 0.07362396f, 
    0.00287606f, -0.02149157f, 0.08186367f, 0.05685153f, -0.09992880f, -0.09917617f, 0.16220668f, 0.04995125f, 
    -0.01652083f, 0.60719693f, -0.13750818f, 0.07695797f, -0.10148427f, 0.00909594f, -0.04611365f, -0.11736739f, 
    -0.07709256f, -0.00688079f, 0.07395331f, 0.07233548f, -0.07570432f, -0.14149712f, 0.05592699f, -0.24298309f, 
    0.05826215f, 0.05848789f, 0.08356765f, -0.05748079f, 0.12005516f, 0.02049649f, 0.15150295f, 0.29104644f, 
    -0.10471952f, 0.26845059f, -0.22411922f, -0.41053295f, 0.11869361f, -0.07357534f, 0.01230408f, -0.10235587f, 
    0.03041857f, 0.03312555f, 0.07697114f, 0.12634376f, -0.06437549f, -0.03896052f, -0.13912742f, 0.04222983f, 
    -0.02689356f, 0.07791780f, 0.05773288f, 0.00520530f, -0.02628934f, 0.01211314f, 0.05593580f, 0.06963643f, 
    0.02372429f, -0.24326670f, -0.06610021f, 0.07941400f, 0.13985680f, -0.09318630f, -0.00117331f, -0.01442041f, 
    0.04578625f, 0.03837812f, 0.02739107f, 0.01374072f, 0.71416003f, -0.04685122f, -0.21139096f, -0.28104895f, 
    -0.07838144f, 0.00572389f, 0.03139933f, 0.12863328f, -0.02006602f, 0.07536350f, -0.01076891f, -0.01143872f, 
    0.53173298f, 0.22011922f, -0.05896667f, -0.12889726f, -0.04569590f, -0.08058670f, 0.02418735f, -0.08215095f, 
    -0.13055000f, 0.04016020f, 0.01946289f, 0.03842038f, 0.04921058f, 0.15573467f, 0.15495415f, -0.06334399f, 
    0.06054766f, -0.05052002f, -0.08462465f, -0.00614503f, -0.06426162f, 0.04177269f, 0.08826404f, 0.05306890f, 
    0.03225866f, 0.00620341f, -0.10262758f, 0.20050673f, -0.04066038f, -0.02921514f, 0.05477771f, -0.03860201f, 
    -0.02403977f, 0.01176873f, 0.05007751f, 0.06043699f, -0.00689132f, -0.15678544f, 0.01559287f, -0.02670609f, 
    -0.07838351f, -0.06056436f, -0.11526097f, -0.05595205f, -0.07222222f, -0.04798109f, -0.15702611f, -0.01987509f, 
    0.23381808f, -0.15971839f, -0.07568678f, -0.24778004f, 0.14746037f, -0.10387822f, -0.15417069f, -0.05146111f, 
    0.00827812f, 0.04836481f, -0.04002347f, 0.00656282f, -0.13220236f, -0.04748039f, 0.06235101f, 0.16279794f, 
    0.11373134f, 0.15510723f, 0.01612617f, 0.10370394f, -0.04627615f, -0.00728494f, 0.02780176f, -0.12095103f, 
    0.09060634f, 0.29614088f, -0.15950710f, -0.16068047f, -0.17526160f, 0.04732122f, -0.04985092f, 0.02064428f, 
    0.11665913f, -0.06283286f, 0.01849474f, -0.03961463f, -0.13288079f, -0.22883721f, -0.16351210f, 0.27184677f, 
    0.00982388f, -0.01834494f, 0.13733508f, -0.07970274f, -0.07363421f, 0.04445545f, 0.04409921f, 0.11966168f, 
    0.10920433f, -0.06320981f, 0.23704956f, 0.10245557f, -0.03109185f, -0.07854956f, 0.04167538f, -0.04272386f, 
    -0.01204278f, 0.05168046f, -0.07531098f, -0.05236720f, 0.05447673f, -0.33115724f, -0.11910625f, 0.21314038f, 
    0.00529773f, 0.02537227f, 0.06631203f, 0.08906212f, -0.04428321f, -0.05162111f, 0.09331273f, 0.00230303f, 
    0.30584642f, 0.43704787f, -0.26602662f, 0.19387048f, -0.06634970f, 0.04609918f, 0.02540965f, 0.00082309f, 
    0.07982052f, -0.02906723f, -0.03777355f, -0.15805982f, 0.07506265f, 0.15041491f, 0.02252893f, 0.02218328f, 
    0.16889413f, 0.31610885f, 0.05923142f, 0.00889242f, 0.07247745f, -0.06997200f, 0.08323985f, 0.04663171f, 
    -0.05443485f, 0.05976006f, -0.24162407f, -0.32308236f, 0.04955563f, 0.06938776f, 0.10986514f, -0.00763119f, 
    -0.04997323f, 0.02031280f, -0.07542542f, 0.09251085f, -0.07490074f, 0.05970405f, -0.02495151f, 0.08255323f, 
    -0.02825831f, 0.18931268f, -0.01161049f, -0.12382766f, -0.08829644f, 0.08535592f, 0.02637708f, -0.01049446f, 
    0.15337528f, -0.13004968f, -0.14406037f, 0.22783221f, 0.05850794f, -0.08981840f, -0.05964177f, -0.08174883f, 
    0.02454809f, 0.07266515f, -0.02408381f, -0.02857378f, 0.43744367f, -0.04002602f, 0.05746223f, -0.34334090f, 
    -0.01042833f, -0.01491161f, -0.07848729f, -0.01155307f, -0.01269665f, -0.02170342f, -0.04009422f, -0.07073580f, 
    0.21003325f, -0.09241657f, -0.24938142f, -0.37947538f, 0.02667173f, -0.05594757f, 0.01916001f, -0.05558154f, 
    -0.05943878f, 0.02326751f, 0.14060387f, 0.14755446f, 0.34437886f, 0.02869901f, 0.24580498f, -0.12215162f, 
    0.03968691f, 0.01966101f, -0.01816733f, 0.07838107f, -0.02067335f, -0.02201434f, 0.16013679f, -0.01590414f, 
    0.37924242f, 0.34436631f, 0.19001129f, -0.10783064f, 0.10567703f, -0.00145963f, -0.09090993f, -0.11708407f, 
    -0.04871492f, 0.03841805f, -0.03146041f, 0.05096484f, 0.38032687f, 0.27861750f, 0.08965699f, 0.07099744f, 
    0.11429211f, 0.04068822f, 0.08843739f, 0.16361049f, -0.01693641f, -0.07936306f, -0.02281136f, 0.04399098f, 
    -0.48770574f, -0.08619980f, 0.28394315f, -0.05823826f, -0.09457740f, 0.12072727f, 0.00913389f, -0.15202950f, 
    0.10362408f, -0.03247922f, -0.10479134f, 0.15720989f, 0.09599630f, -0.22599711f, -0.11369283f, -0.13248652f, 
    -0.03175735f, 0.03613310f, -0.06594813f, -0.09083051f, -0.10149497f, 0.10770832f, 0.11869965f, -0.06718574f, 
    -0.16137624f, -0.00644325f, 0.11077688f, 0.11522029f, 0.09000722f, -0.01444613f, 0.25068134f, -0.06898226f, 
    -0.01294082f, 0.04257357f, 0.02279549f, 0.14807981f, 0.37508178f, 0.06010055f, 0.11413476f, -0.08556021f, 
    0.01420118f, 0.04617951f, 0.16010311f, 0.28133821f, -0.05735282f, -0.01342797f, 0.03960682f, 0.17463693f, 
    0.00199915f, 0.09015191f, 0.20654175f, -0.09094885f, -0.00741831f, 0.08507448f, 0.03769156f, 0.05118942f, 
    -0.02867470f, 0.03828929f, 0.12940124f, 0.19653016f, 0.25780654f, 0.32731849f, 0.16986005f, 0.03014624f, 
    0.02281325f, 0.02343441f, -0.05547340f, 0.05151313f, -0.02150695f, -0.08716789f, 0.02774198f, 0.02395121f, 
    0.14788073f, -0.05352572f, -0.17163999f, -0.00189416f, -0.05881320f, -0.12726100f, 0.03117010f, 0.05725177f, 
    -0.07601499f, -0.03070753f, 0.00568687f, -0.09596673f, -0.15396123f, 0.01671044f, -0.31464446f, -0.02938331f, 
    -0.01415150f, 0.02290727f, 0.04936786f, 0.00297181f, 0.09815218f, 0.08051853f, 0.03594701f, -0.13330281f, 
    -0.06272548f, 0.23948744f, -0.09695031f, 0.14636083f, 0.26155463f, -0.07545686f, 0.01247803f, -0.06398856f, 
    0.06562164f, -0.01632812f, -0.03969463f, 0.02038650f, -0.11443104f, -0.43049952f, 0.02804976f, -0.11238313f, 
    -0.01343737f, 0.08810338f, -0.00815279f, 0.05074212f, 0.07455494f, 0.12202762f, -0.07713098f, 0.08275921f, 
    -0.00421503f, 0.33586556f, 0.06184770f, 0.06740867f, -0.00886384f, 0.00183533f, 0.04456157f, -0.13964723f, 
    -0.06070365f, -0.11799654f, 0.04770312f, -0.05049044f, -0.66871887f, 0.02409076f, 0.36723503f, -0.12315331f, 
    -0.09615442f, 0.02451274f, -0.01926190f, -0.04563097f, 0.23375429f, 0.09103038f, 0.11270212f, 0.06141603f, 
    -0.21359745f, -0.15154418f, 0.16099733f, 0.12835647f, -0.03089149f, -0.20344436f, 0.00225706f, 0.07516669f, 
    0.04383166f, -0.07042863f, -0.03028325f, -0.03827505f, -0.31859288f, -0.14738373f, 0.01131707f, 0.00057964f, 
    -0.09536432f, -0.05365827f, 0.07959995f, 0.05067696f, 0.26111528f, -0.05947448f, 0.00237473f, 0.06487957f, 
    -0.05747509f, 0.08065643f, 0.04347696f, -0.15310505f, 0.20546737f, 0.24242577f, 0.17630433f, 0.16457120f, 
    0.09390128f, -0.16565545f, 0.01190177f, -0.03583944f, 0.18446569f, 0.26086238f, 0.23282491f, 0.14657612f, 
    0.27987206f, 0.02859807f, 0.19464399f, 0.00374217f, 0.02870118f, 0.05622445f, 0.15733361f, -0.04608713f, 
    0.07630993f, -0.12322191f, 0.00277919f, -0.01286175f, -0.15327926f, -0.06395477f, -0.01511008f, 0.11594363f, 
    0.00067857f, -0.06711885f, 0.01077827f, -0.08783640f, -0.23347110f, -0.44827357f, -0.49287629f, -0.49324900f, 
    0.00580815f, -0.04093181f, 0.14484781f, 0.09725980f, 0.15659814f, 0.00308858f, -0.01703283f, 0.11223224f, 
    -0.14871272f, 0.00092571f, -0.04623519f, -0.10076598f, 0.27053028f, -0.05433232f, 0.09383361f, -0.01300955f, 
    0.24978949f, 0.10003142f, 0.15048602f, 0.17142609f, -0.04770289f, 0.15820600f, 0.14172842f, 0.01207620f, 
    0.11343751f, 0.19827046f, 0.04207958f, 0.04988404f, 0.06799974f, 0.03158817f, 0.04810981f, 0.06777119f, 
    -0.01678794f, -0.01164462f, -0.18710016f, -0.02485611f, 0.13453729f, -0.05370922f, -0.03001151f, -0.00880975f, 
    -0.20257753f, -0.11428300f, -0.10824396f, -0.45351163f, 0.07353568f, 0.08301239f, 0.13512522f, -0.11520500f, 
    0.08871403f, 0.09089627f, 0.08288286f, -0.06758235f, -0.08191817f, -0.04870611f, -0.21645619f, -0.02258941f, 
    -0.21925063f, -0.43756095f, -0.00456124f, -0.23742519f, -0.20846099f, -0.09754781f, -0.03379271f, 0.03379573f, 
    -0.08069105f, 0.08754297f, -0.08020678f, 0.13423805f, 0.02135338f, -0.19641568f, -0.02888042f, -0.04209615f, 
    0.08749315f, -0.01882846f, 0.19713476f, 0.10147231f, 0.10929234f, 0.25484049f, 0.17593478f, 0.34103271f, 
    0.23576172f, 0.06242872f, -0.05141786f, -0.34835878f, -0.04660391f, -0.09021722f, -0.03885438f, -0.07681122f, 
    0.06259762f, -0.08947414f, 0.08724763f, 0.04568172f, -0.04543386f, -0.32129291f, -0.42879668f, -0.36607215f, 
    -0.06490879f, -0.02162886f, -0.01361628f, 0.18502055f, 0.16537207f, 0.00376749f, -0.01685975f, -0.01646347f, 
    0.13835689f, -0.14879456f, 0.17227505f, 0.03528368f, 0.00460837f, 0.12856422f, -0.10443459f, 0.12934966f, 
    0.00121022f, 0.11194988f, 0.05984590f, 0.25484502f, -0.08901229f, -0.03680443f, -0.06840076f, -0.02923114f, 
    0.10879078f, -0.02907353f, -0.12121268f, 0.02744778f, -0.05668389f, -0.02164559f, -0.12674007f, 0.09197900f, 
    -0.24881774f, -0.20184164f, 0.18317536f, 0.12698665f, 0.11341871f, 0.03688139f, -0.02372096f, 0.08185472f, 
    -0.01016351f, 0.10947072f, -0.10495353f, -0.09999953f, -0.34115589f, 0.10081377f, -0.18376823f, -0.05981405f, 
    -0.00003778f, -0.23735234f, 0.00803438f, 0.08829689f, -0.10674272f, 0.14152318f, 0.09690513f, 0.21557905f, 
    0.12719484f, 0.09002207f, 0.23500827f, 0.17480679f, 0.01021066f, 0.03750759f, 0.01457458f, 0.08555828f, 
    -0.02522894f, 0.03080994f, -0.02086736f, -0.05952355f, -0.18758500f, -0.09726407f, -0.03452095f, 0.19511731f, 
    0.01320714f, 0.03188279f, 0.12703705f, 0.15619761f, 0.09538527f, 0.05659197f, 0.25200000f, -0.06158923f, 
    -0.04880089f, 0.22400011f, 0.06607737f, 0.07942034f, -0.03532027f, 0.10677230f, 0.11723653f, -0.23711668f, 
    0.07055626f, 0.06178662f, 0.12842733f, -0.02931791f, 0.19053021f, 0.30427825f, 0.06347957f, 0.00542992f, 
    -0.34564114f, -0.31215063f, -0.04817641f, -0.14903019f, -0.00316391f, 0.02406464f, -0.17556714f, 0.01737986f, 
    -0.07981984f, -0.13043857f, 0.23502415f, 0.02365110f, 0.06898605f, -0.04260704f, -0.06189638f, -0.20506459f, 
    -0.10200878f, -0.04903203f, -0.07187518f, -0.20666112f, 0.32398152f, 0.21069019f, 0.15009473f, -0.00607254f, 
    0.04080227f, 0.00668024f, 0.07685928f, 0.07566863f, 0.00016264f, -0.11712708f, -0.01597665f, -0.03071767f, 
    0.03428158f, 0.24904893f, -0.22720955f, -0.00967820f, 0.09331565f, -0.04884917f, 0.01565349f, 0.15796643f, 
    0.04435649f, 0.02903803f, 0.10110413f, 0.17061093f, -0.00381155f, 0.22907335f, 0.22307387f, -0.00948644f, 
    0.06123527f, 0.04382962f, -0.04363071f, 0.07208721f, 0.17222100f, 0.09968711f, -0.08577540f, -0.05996168f, 
    -0.08677369f, -0.35058096f, 0.16664401f, -0.28334978f, -0.18550983f, 0.00530552f, -0.02283254f, 0.07839260f, 
    0.11621743f, -0.00975824f, -0.20733018f, -0.10831388f, 0.02889096f, -0.19216338f, 0.03331806f, -0.13276114f, 
    -0.09236905f, 0.06276403f, -0.01468921f, -0.11228764f, 0.11817319f, -0.05432871f, -0.15841213f, -0.09295961f, 
    0.14684209f, -0.33807340f, 0.21016610f, 0.40089247f, -0.10713186f, -0.18637484f, -0.25970376f, -0.13349606f, 
    0.13996479f, -0.00823153f, 0.05060557f, -0.12601981f, -0.26207897f, 0.17042075f, 0.23061638f, -0.14818162f, 
    -0.04958232f, -0.36834037f, -0.06357200f, 0.00969646f, -0.01351372f, -0.03545403f, -0.04225750f, 0.02479438f, 
    0.04361755f, -0.11067376f, 0.07633436f, -0.13580447f, -0.09948722f, 0.09313027f, 0.12143408f, 0.07401738f, 
    -0.02811317f, 0.04969572f, -0.15914570f, -0.13630211f, -0.02027071f, -0.00391236f, -0.15215924f, 0.24389184f, 
    -0.01714498f, 0.13898230f, 0.02152493f, -0.10643997f, -0.01518557f, -0.05178186f, 0.22663720f, 0.01623088f, 
    0.21131654f, 0.05609667f, -0.06608978f, 0.30413267f, 0.04041963f, -0.01654351f, -0.06070258f, -0.09648129f, 
    0.05480438f, 0.07248893f, -0.07036959f, -0.07443512f, -0.34560519f, -0.02121463f, -0.21750957f, 0.13392401f, 
    -0.10095355f, -0.02718764f, 0.06130883f, -0.21234179f, 0.03826930f, 0.09327836f, -0.09615029f, -0.03474961f, 
    0.25224990f, 0.13009964f, 0.18282540f, 0.23675568f, 0.02603382f, 0.10256432f, -0.04048169f, 0.09640910f, 
    0.12197074f, 0.13490468f, -0.05718003f, -0.03736695f, -0.23961715f, 0.05648032f, -0.10760093f, -0.01952086f, 
    -0.07378747f, 0.13268378f, -0.02460349f, -0.08718219f, -0.00955704f, 0.10704929f, -0.11065757f, -0.09666860f, 
    -0.10890278f, 0.01603840f, -0.03479362f, 0.11121956f, 0.09286825f, 0.13694979f, -0.02070306f, -0.01083077f, 
    0.06631264f, -0.03112385f, -0.08837888f, 0.15806949f, -0.14017029f, 0.29862908f, -0.03260431f, 0.23928522f, 
    0.03211532f, -0.02141050f, -0.09004249f, -0.19101797f, -0.13655201f, 0.05142210f, 0.03778170f, 0.03983366f, 
    0.04700696f, -0.26306209f, -0.07719714f, 0.08192090f, -0.19709590f, -0.07781538f, 0.28464258f, 0.02056441f, 
    -0.06540137f, 0.21105497f, -0.05664681f, 0.30060157f, 0.15990932f, -0.22212870f, 0.30268034f, -0.16024825f, 
    -0.07372673f, -0.06430449f, 0.22997265f, 0.29944041f, 0.32654431f, 0.11750218f, 0.13905227f, 0.15289859f, 
    0.17638262f, 0.23235215f, 0.09809041f, 0.06852779f, -0.02349634f, 0.07137471f, -0.15442076f, -0.05648876f, 
    0.10860248f, -0.05620407f, -0.27627790f, -0.01404008f, -0.40307254f, -0.43287969f, -0.49613935f, 0.00312425f, 
    0.01355007f, -0.06254245f, 0.11004668f, 0.01728145f, -0.06895225f, 0.08353018f, 0.16583541f, 0.00103501f, 
    0.36752832f, 0.21466254f, -0.14371082f, 0.32033035f, -0.18959223f, -0.09793662f, -0.05497498f, -0.07093002f, 
    0.04946834f, 0.06424160f, 0.11433385f, -0.15481637f, -0.12701106f, 0.17543334f, -0.25451088f, 0.10720123f, 
    -0.22347282f, -0.06939755f, -0.04696893f, 0.00248068f, -0.10889333f, 0.13505173f, -0.01067309f, 0.04617655f, 
    -0.04434600f, -0.01561277f, -0.17248598f, -0.08689810f, -0.17464942f, 0.02605180f, 0.02277720f, 0.06975584f, 
    0.11015228f, 0.02234202f, -0.00668615f, -0.17245485f, -0.18566409f, 0.11804811f, -0.09856632f, -0.09071407f, 
    -0.15824713f, -0.00911456f, 0.08752566f, -0.12412783f, 0.07264696f, 0.10293762f, -0.09032273f, 0.09057192f, 
    -0.16426773f, -0.07024393f, -0.50818294f, 0.35361689f, -0.00652037f, 0.34153262f, 0.04522772f, 0.04568319f, 
    0.15793306f, 0.05170044f, 0.11165833f, 0.02533416f, -0.04769124f, -0.00396760f, 0.15643109f, -0.04070834f, 
    0.02481332f, 0.06880802f, 0.08198300f, -0.17304014f, 0.01524572f, 0.09269974f, 0.05754424f, -0.02134922f, 
    0.28356844f, 0.18410382f, -0.16630843f, -0.23179975f, -0.16801699f, 0.04646637f, -0.00626918f, 0.06326359f, 
    -0.09252167f, -0.10430185f, 0.14395009f, 0.00380250f, 0.34970587f, -0.18454777f, 0.02670392f, -0.31859708f, 
    -0.17593442f, -0.19226974f, -0.11711474f, 0.00948146f, 0.05951009f, -0.14864336f, 0.01700594f, -0.09001646f, 
    -0.29770643f, -0.05173157f, 0.07567146f, 0.05872013f, 0.16158628f, 0.03165133f, 0.03006923f, 0.10559955f, 
    0.05787570f, -0.12882006f, 0.04288268f, -0.10436837f, -0.21526617f, 0.00597575f, -0.09930499f, 0.07505085f, 
    -0.14757301f, 0.11335686f, -0.07901872f, -0.15033512f, -0.09513688f, 0.00697789f, -0.00814377f, -0.03766032f, 
    0.31114066f, 0.13453966f, 0.08737213f, 0.20162790f, 0.05499413f, 0.07150503f, 0.06168027f, 0.15748718f, 
    0.06089573f, 0.11748967f, 0.09068020f, -0.01819162f, -0.15334749f, -0.21078652f, -0.15692402f, -0.00067772f, 
    -0.02013960f, -0.09334522f, -0.06782409f, 0.10769484f, -0.03369010f, -0.05584580f, -0.15022595f, -0.02782980f, 
    0.13204691f, -0.02250392f, 0.21774301f, 0.07285084f, -0.01441041f, 0.08667643f, 0.12242635f, 0.02392816f, 
    0.07976241f, 0.11227757f, 0.16201894f, 0.27223033f, 0.07423175f, 0.12073581f, -0.01350632f, -0.17010400f, 
    -0.05063077f, -0.00798411f, 0.00823723f, 0.02063576f, 0.33001801f, 0.06448457f, -0.01361781f, -0.05652090f, 
    0.04136517f, -0.13523661f, -0.18009937f, 0.01577565f, 0.16176830f, 0.04772696f, -0.01462260f, -0.03643475f, 
    -0.01029568f, -0.02711162f, -0.19282499f, -0.35461313f, -0.26750973f, -0.13226457f, -0.00311465f, 0.03451336f, 
    0.12368300f, 0.05367032f, -0.13494307f, -0.15827312f, -0.09913518f, -0.02932109f, -0.17215879f, -0.04106741f, 
    -0.00545646f, 0.49873075f, 0.00844428f, 0.09312385f, -0.27174628f, 0.08512569f, 0.05473911f, 0.00689447f, 
    0.03484594f, 0.04677675f, 0.11968748f, 0.07483383f, -0.25451079f, -0.09819627f, 0.00785505f, -0.25130859f, 
    -0.27607933f, -0.02312667f, -0.09528217f, -0.18632546f, -0.07427939f, 0.15609886f, 0.19791859f, 0.17628369f, 
    -0.05891445f, 0.24511451f, 0.06992238f, -0.36493427f, -0.12860255f, 0.13205664f, -0.06201169f, -0.08168875f, 
    0.02257582f, -0.03832286f, 0.10326505f, 0.01851723f, -0.06975795f, 0.04300263f, -0.30693534f, -0.05896616f, 
    -0.15712745f, 0.02270526f, 0.11329912f, 0.06907471f, 0.10114176f, 0.01124165f, 0.11842982f, -0.10224301f, 
    -0.05185185f, -0.19427256f, 0.02352614f, 0.27079242f, 0.00163764f, 0.42994574f, -0.06014970f, 0.22544682f, 
    -0.09556940f, -0.00225361f, 0.02169914f, 0.17463626f, 0.34987360f, 0.08267898f, 0.01502943f, 0.01540667f, 
    -0.01251173f, 0.08143010f, 0.06341999f, 0.06540781f, -0.11072334f, 0.09851423f, 0.18924849f, 0.14131188f, 
    0.33412507f, 0.43896982f, 0.33197024f, 0.07124621f, 0.03696537f, 0.01973009f, 0.14465186f, 0.13927016f, 
    0.11475296f, 0.10368388f, -0.04233734f, -0.04057976f, 0.10673616f, -0.05040747f, 0.08542115f, -0.15544432f, 
    -0.08045790f, -0.23055871f, 0.01995007f, -0.01396132f, -0.19098471f, 0.04255012f, 0.02465922f, 0.05522958f, 
    -0.09470113f, -0.21276875f, -0.13442373f, 0.08026355f, 0.06412893f, 0.00279532f, 0.09365753f, 0.07853550f, 
    0.05333954f, 0.14403322f, 0.14260809f, 0.02170586f, -0.19861414f, -0.18394560f, -0.09870225f, -0.00735659f, 
    0.01177525f, -0.14962111f, -0.14105310f, 0.02877806f, 0.08525787f, 0.12101417f, -0.01262644f, 0.00957068f, 
    0.40829301f, 0.02628836f, -0.00859459f, -0.17140791f, 0.19574542f, -0.04367324f, 0.00311752f, 0.00711039f, 
    -0.03641455f, 0.03091617f, 0.11135670f, -0.05375895f, -0.06989571f, -0.04324978f, 0.08909398f, 0.01322831f, 
    0.02850659f, -0.00689410f, -0.04868314f, -0.03379069f, 0.01606281f, 0.10914920f, 0.12594384f, 0.00416525f, 
    -0.01453879f, -0.02231396f, -0.04277863f, -0.15335658f, -0.02127020f, 0.08277156f, 0.03200369f, 0.17676336f, 
    0.12556112f, 0.03222481f, 0.00292928f, 0.02103310f, -0.26552811f, -0.03435520f, 0.15488808f, 0.11321717f, 
    -0.12515604f, -0.16356848f, 0.15144937f, 0.16441052f, 0.27776214f, 0.30272105f, 0.07564013f, 0.16150847f, 
    0.03578820f, -0.09088245f, 0.15812987f, 0.20341004f, 0.05447799f, -0.02330352f, 0.13197272f, 0.02726840f, 
    -0.08699168f, 0.03092185f, 0.05557527f, -0.19479558f, 0.00879750f, -0.16104512f, -0.16412470f, 0.10270388f, 
    0.05828542f, 0.00479538f, 0.10287208f, 0.02725726f, 0.06550061f, -0.07132882f, 0.21842401f, 0.06737722f, 
    -0.09905019f, 0.22136694f, 0.04050241f, 0.03708355f, -0.01276091f, -0.04205323f, -0.06564063f, -0.06995472f, 
    -0.08175996f, 0.02376450f, 0.07693924f, 0.09202804f, -0.15727401f, -0.06975681f, -0.03688330f, -0.08940014f, 
    -0.08575965f, -0.05058058f, -0.11960523f, -0.06817538f, -0.07947209f, 0.14960651f, 0.15879087f, 0.11374737f, 
    -0.10594171f, 0.37088904f, -0.08282258f, -0.35708144f, -0.12232469f, 0.03567566f, -0.07415743f, -0.05291055f, 
    0.11830916f, 0.08717418f, 0.05882793f, 0.00358602f, -0.02747693f, 0.00523905f, -0.03462243f, 0.04403691f, 
    -0.10512474f, 0.00132400f, 0.04624231f, -0.03625425f, -0.01370088f, -0.04495351f, 0.02721497f, 0.05559095f, 
    -0.11905921f, -0.16149795f, -0.19979323f, 0.12391643f, 0.07647108f, -0.02508171f, 0.19221424f, 0.08514989f, 
    -0.10209183f, -0.00223762f, 0.14328985f, 0.02575181f, 0.43902308f, 0.00325593f, -0.17175995f, -0.14187081f, 
    -0.02573084f, 0.01725124f, 0.04603866f, -0.04066027f, 0.06990645f, 0.12023539f, -0.09643257f, -0.04157222f, 
    0.36190343f, 0.43508184f, -0.08735342f, -0.17197941f, 0.01381540f, 0.07607639f, -0.07622577f, 0.00779174f, 
    0.03133711f, 0.09137102f, 0.22840752f, 0.11787730f, 0.18692963f, 0.09152952f, 0.01068269f, -0.25082049f, 
    -0.01686000f, -0.01802372f, -0.02321323f, -0.04023075f, -0.01425001f, -0.03703629f, 0.02249568f, -0.06677877f, 
    0.21067721f, 0.35415402f, 0.20258236f, 0.12667929f, 0.14649242f, 0.13619947f, -0.04460591f, -0.03319523f, 
    -0.06456590f, -0.10938936f, -0.06243441f, 0.10569449f, 0.20742089f, 0.05596468f, 0.26271105f, 0.36988080f, 
    0.10950803f, 0.24023153f, 0.11705539f, 0.10917653f, 0.10213871f, -0.06238737f, -0.01328026f, -0.05649158f, 
    -0.03894093f, -0.13201030f, 0.14716542f, 0.07475710f, 0.06038497f, -0.00602000f, -0.09690543f, -0.02673297f, 
    0.14398484f, 0.09294125f, -0.11604846f, 0.10222540f, 0.02123570f, -0.06535541f, -0.06276622f, 0.11471465f, 
    -0.01312861f, 0.13624500f, -0.10291632f, 0.03767494f, -0.02011553f, -0.04298143f, 0.12376680f, 0.06635412f, 
    0.07342958f, 0.03377088f, -0.08108408f, 0.01548836f, 0.10784005f, -0.10294536f, 0.05488696f, 0.00107315f, 
    0.03106001f, -0.15438433f, 0.05210798f, -0.01061040f, 0.41988811f, 0.23066556f, -0.19571172f, 0.03442630f, 
    0.00173414f, 0.04839921f, -0.02247206f, 0.08112793f, 0.01703362f, -0.08813085f, -0.12197603f, 0.14816995f, 
    0.12741879f, 0.10990151f, 0.10979410f, -0.00621685f, 0.01565471f, -0.02784413f, -0.05617141f, 0.02756083f, 
    -0.00869758f, -0.04150819f, -0.01759308f, 0.23985088f, 0.26338327f, 0.09829524f, 0.40856442f, 0.14584215f, 
    -0.01460401f, -0.08012921f, -0.01683816f, -0.00518871f, -0.05011304f, -0.00995985f, 0.03442863f, 0.01947936f, 
    0.34113681f, 0.31386104f, -0.19632307f, -0.09508742f, -0.11251696f, -0.04969468f, -0.06222864f, 0.01488598f, 
    -0.00814814f, -0.07496323f, -0.04674403f, -0.16082518f, 0.05420315f, -0.30096459f, -0.22353850f, -0.01265973f, 
    0.02431779f, 0.08801552f, 0.06292289f, -0.09760867f, 0.06813614f, 0.03299774f, 0.07361726f, 0.00205990f, 
    -0.05343441f, -0.08049581f, -0.19813824f, 0.17057082f, 0.24490668f, 0.09115878f, -0.00788872f, 0.04169196f, 
    -0.00377829f, 0.01342480f, 0.13714868f, 0.07394713f, -0.07747550f, -0.10037566f, 0.07575620f, 0.05714239f, 
    0.04109536f, 0.08349394f, 0.08102603f, -0.08663378f, 0.04469640f, 0.10659063f, 0.05020117f, -0.08260500f, 
    0.16353808f, 0.08287631f, 0.35134143f, 0.11258663f, -0.01607849f, 0.20440549f, -0.02147689f, 0.06488053f, 
    0.01698836f, 0.01849854f, -0.02966084f, -0.11771050f, -0.18388039f, 0.07542051f, 0.18756260f, -0.18251787f, 
    0.03677565f, -0.01405299f, -0.08481674f, -0.00200377f, 0.14390467f, -0.02775435f, 0.19467311f, -0.02551575f, 
    0.04360827f, -0.12956458f, -0.18076578f, 0.30160317f, 0.02371994f, -0.12610972f, -0.01093065f, -0.04121200f, 
    -0.02441869f, -0.02076266f, -0.00699770f, 0.05236848f, -0.18888028f, 0.07082954f, 0.18076558f, 0.03856659f, 
    0.17200767f, -0.12425572f, -0.10756274f, -0.00037658f, -0.01242796f, 0.00037678f, -0.03073114f, -0.00032859f, 
    0.00513326f, 0.26033998f, -0.15272559f, -0.19289386f, 0.03141157f, -0.06969108f, 0.10002958f, 0.07666038f, 
    -0.02077843f, -0.12579833f, -0.01004312f, 0.06339293f, 0.25119445f, 0.13543493f, 0.07424247f, 0.03047603f, 
    0.02197725f, 0.03587463f, 0.07901541f, -0.08908556f, -0.01805733f, -0.08761215f, -0.03602018f, 0.04790926f, 
    0.06561649f, 0.04892776f, 0.17225383f, -0.00935758f, 0.03743065f, -0.07264452f, 0.03314179f, 0.20100984f, 
    0.08059788f, -0.08794641f, -0.03060648f, 0.05092994f, -0.12777445f, -0.36905712f, -0.18278056f, -0.14456700f, 
    0.01173615f, -0.04211022f, -0.05716410f, 0.02060434f, 0.00540314f, -0.08982792f, -0.05918439f, -0.07000993f, 
    0.14175762f, 0.14240304f, 0.34839708f, -0.14747843f, -0.07725014f, 0.06390698f, -0.04517956f, 0.06374446f, 
    -0.03509051f, 0.02930170f, 0.15530151f, 0.05230362f, 0.13330413f, 0.08936198f, 0.03529058f, -0.24122025f, 
    -0.04815022f, 0.11510430f, 0.02086495f, 0.05802797f, -0.03130200f, -0.02300732f, 0.18701941f, -0.01401765f, 
    -0.03661662f, -0.15281937f, -0.02961888f, -0.02062348f, 0.01187237f, -0.05495112f, 0.06726101f, 0.04870216f, 
    -0.06254956f, -0.07318065f, 0.10011882f, -0.15621723f, -0.08203877f, -0.03903132f, -0.05003490f, -0.09699803f, 
    0.09815218f, 0.09433678f, -0.08818775f, -0.03488234f, -0.01295085f, 0.01536336f, -0.12583014f, 0.08075877f, 
    0.07617620f, 0.37636563f, -0.04295867f, 0.02381522f, -0.21244159f, 0.03076321f, -0.00225978f, -0.07383294f, 
    0.00501963f, -0.17596127f, -0.01125364f, 0.12429276f, -0.26386791f, 0.01582491f, -0.07606833f, -0.25900900f, 
    -0.10855342f, 0.03476181f, -0.03987244f, -0.13712619f, 0.03705126f, -0.00280264f, 0.03668081f, -0.07945844f, 
    -0.15054786f, 0.06331497f, -0.23118693f, -0.04711667f, 0.10958812f, 0.05023433f, -0.01819929f, -0.06667753f, 
    -0.00063990f, -0.06558293f, 0.10328667f, 0.07399023f, -0.18872969f, -0.30518228f, -0.27274570f, 0.05258129f, 
    -0.03353024f, 0.07799385f, -0.04274600f, 0.16528523f, 0.06197662f, 0.03466263f, 0.00307593f, -0.09463439f, 
    0.19473436f, -0.12533164f, 0.29983971f, 0.03630601f, 0.06887814f, 0.23433146f, -0.20770682f, 0.15178291f, 
    -0.04030933f, -0.08677351f, 0.14025709f, 0.07832267f, -0.01034079f, 0.00830679f, 0.37567931f, -0.15374853f, 
    0.07681777f, -0.01686648f, -0.13566962f, 0.13411403f, -0.06383409f, -0.08510043f, -0.08352102f, 0.06825041f, 
    0.00235588f, -0.05114613f, 0.45360580f, -0.18277210f, 0.04868520f, -0.16764903f, 0.13759986f, 0.17635384f, 
    0.12468691f, 0.02862192f, -0.14265636f, 0.04860619f, 0.08209341f, -0.12122348f, 0.44466215f, -0.15167317f, 
    -0.12659113f, 0.04170158f, 0.13484387f, 0.03922293f, -0.07413208f, 0.02559134f, -0.16176030f, 0.13581122f, 
    -0.04104453f, -0.06699359f, 0.11350659f, -0.10052793f, -0.10210829f, -0.06004511f, 0.10642127f, 0.13031399f, 
    -0.04260480f, -0.02894202f, -0.05205844f, 0.11009763f, -0.29093078f, -0.18187511f, -0.11243473f, -0.38237286f, 
    -0.08095836f, -0.11575514f, -0.16436253f, -0.13657527f, -0.22637166f, -0.11681946f, -0.13521215f, -0.13352725f, 
    0.02440585f, -0.00114755f, 0.00021117f, 0.02394385f, 0.03433435f, 0.13130972f, 0.10365779f, 0.12456785f, 
    0.12711090f, 0.25932696f, 0.20947206f, -0.03914541f, 0.05301659f, 0.18949334f, 0.03093738f, -0.04735026f, 
    -0.13232657f, -0.05256577f, 0.00290958f, 0.12300620f, 0.06290209f, 0.03037807f, 0.16908000f, 0.03332200f, 
    0.05512165f, 0.02544317f, -0.12260430f, -0.09459036f, 0.08816589f, -0.03527372f, -0.03921867f, 0.06240724f, 
    -0.20807040f, 0.04905969f, -0.12145940f, -0.06390996f, -0.25758877f, -0.13668008f, 0.08533633f, -0.03849217f, 
    -0.02255699f, -0.21714100f, 0.09300267f, -0.00791786f, 0.19097385f, 0.18583725f, -0.03318906f, -0.16033192f, 
    0.01411506f, -0.01304317f, 0.12572657f, 0.10329659f, -0.14434583f, 0.14178200f, 0.29013890f, -0.01213665f, 
    0.17421119f, 0.18480623f, 0.19290769f, 0.18747914f, -0.24302331f, -0.38121414f, -0.32194269f, -0.08302977f, 
    -0.00834726f, 0.05175888f, -0.04876586f, -0.13272877f, 0.04477764f, -0.02623959f, 0.20853168f, 0.13339236f, 
    0.29182073f, 0.05355452f, 0.10055988f, 0.25499561f, 0.11577420f, -0.04083064f, 0.03304646f, -0.03411193f, 
    -0.08538867f, 0.21373083f, 0.03153930f, -0.00670962f, 0.10315116f, 0.07666075f, -0.01850516f, 0.14232410f, 
    0.13173495f, -0.00356485f, -0.07252303f, 0.00193458f, -0.02281022f, -0.06818995f, -0.15497892f, -0.11037796f, 
    0.02396479f, 0.32286376f, 0.24510904f, -0.15702738f, 0.01865176f, -0.01671945f, 0.10188087f, 0.19276585f, 
    0.00409994f, 0.01055422f, -0.04335842f, 0.08068899f, 0.14601687f, 0.11914872f, -0.04800551f, -0.00087887f, 
    -0.03029479f, 0.08840792f, 0.11419833f, -0.00976236f, -0.00823067f, 0.07083832f, 0.07463685f, -0.06467848f, 
    -0.32040098f, 0.50178492f, -0.20412579f, -0.22911553f, 0.19373685f, -0.06286137f, 0.13814272f, -0.05631030f, 
    -0.13875315f, -0.03613562f, -0.06777421f, -0.13929573f, 0.11137285f, 0.06138555f, 0.02796522f, 0.12896886f, 
    -0.02986327f, 0.08534955f, 0.05327479f, 0.06182670f, 0.00635312f, 0.02181760f, -0.04042910f, -0.05005275f, 
    -0.17815600f, 0.07624271f, -0.01294191f, -0.15705027f, -0.12577915f, 0.03107985f, -0.01702161f, -0.14035295f, 
    0.03904297f, 0.11660977f, 0.25588295f, 0.09267132f, 0.34150413f, 0.07371429f, 0.07591797f, -0.04309938f, 
    -0.01518588f, 0.07961231f, -0.05808277f, 0.00138159f, -0.05830239f, -0.11179350f, 0.08821419f, -0.02468040f, 
    0.27404305f, 0.12008704f, 0.04501907f, 0.27184811f, 0.20426661f, 0.16725543f, 0.04980966f, -0.02006693f, 
    -0.01245158f, 0.03773746f, 0.00553172f, -0.05938544f, 0.08831135f, 0.01260581f, -0.03051687f, 0.12537736f, 
    0.03069440f, -0.00531894f, 0.15380539f, -0.03088658f, 0.07672767f, 0.04453431f, 0.02837023f, 0.18145925f, 
    -0.08599444f, 0.10550143f, 0.05112596f, -0.04481091f, -0.01281122f, 0.06662375f, -0.00046256f, -0.03789698f, 
    0.05403357f, -0.26047981f, -0.03316331f, 0.02432442f, -0.06532589f, 0.02692762f, -0.13540669f, 0.19918332f, 
    0.03002706f, 0.00287195f, 0.08320674f, 0.03895013f, 0.03079235f, -0.01005348f, 0.02083560f, -0.01025989f, 
    -0.02338003f, -0.14309375f, 0.13080005f, 0.10135223f, -0.00848818f, -0.04727643f, 0.04908315f, -0.09296288f, 
    0.15255553f, 0.17951602f, 0.12090851f, 0.17435491f, 0.52959186f, 0.02386769f, 0.15770538f, -0.12958384f, 
    -0.05655504f, 0.09948005f, 0.01345231f, 0.05593904f, -0.03290689f, -0.00195108f, 0.01860901f, -0.01590943f, 
    0.21241748f, 0.08916702f, -0.09083829f, -0.10234062f, 0.15046285f, 0.00541230f, -0.08132381f, -0.05554571f, 
    -0.03946086f, -0.13838002f, -0.09303514f, -0.25764853f, 0.15991953f, 0.41070768f, 0.05517539f, 0.02262457f, 
    -0.13124089f, -0.00929963f, -0.01031516f, 0.00507702f, -0.07624044f, 0.14796883f, -0.12455449f, -0.01820774f, 
    -0.17052002f, -0.02993144f, -0.06466754f, -0.12714569f, -0.04765487f, -0.07963818f, 0.08103995f, 0.02447817f, 
    -0.03496538f, -0.03780966f, -0.04641010f, 0.09627122f, -0.17927180f, -0.05714969f, -0.21013045f, -0.15630974f, 
    -0.32047516f, 0.00912172f, 0.00262030f, -0.10136167f, -0.01899252f, 0.09695502f, 0.00102112f, 0.14542237f, 
    -0.03372810f, -0.07359731f, -0.18711539f, -0.03858235f, -0.12606768f, 0.09750969f, -0.00149459f, 0.02220785f, 
    0.06526880f, 0.02839972f, 0.01598800f, -0.06767428f, -0.09082317f, -0.08079669f, 0.01286725f, -0.04416303f, 
    -0.00763076f, -0.07930721f, -0.07253990f, 0.16296124f, 0.20498388f, 0.01533729f, -0.16838014f, -0.08082023f, 
    0.25659785f, 0.03894266f, -0.12370247f, 0.17506157f, -0.13948651f, 0.11748905f, 0.03130001f, -0.01607858f, 
    0.19604285f, 0.01875895f, 0.03768724f, 0.05522251f, -0.23804829f, 0.00047307f, -0.03049306f, -0.09391400f, 
    -0.01339279f, 0.10055432f, 0.02886444f, 0.04677029f, 0.05112208f, -0.13513425f, 0.19363767f, 0.17957388f, 
    0.20127118f, 0.02497042f, 0.12865992f, -0.11167694f, 0.12710059f, -0.05823503f, -0.01330770f, 0.14480716f, 
    0.00429451f, -0.00529272f, -0.27903494f, -0.07772196f, -0.31537116f, -0.18506630f, -0.13446607f, -0.00987015f, 
    0.03527445f, -0.10017924f, -0.02093900f, 0.01340170f, -0.00696762f, 0.05355852f, -0.12236412f, 0.10197628f, 
    -0.33601028f, -0.11443064f, 0.13884833f, 0.11752862f, 0.07617974f, 0.00007987f, 0.01551769f, 0.07513469f, 
    0.04752205f, -0.00456164f, 0.05551728f, 0.11773860f, -0.18845308f, -0.15388241f, -0.10926417f, 0.12716050f, 
    -0.07441544f, -0.07929803f, -0.04787341f, -0.02859979f, 0.05820328f, 0.10707130f, 0.00725612f, -0.04965360f, 
    0.61456573f, 0.07319817f, 0.12871455f, 0.19131182f, 0.06183795f, -0.06185346f, 0.05002542f, 0.09537448f, 
    0.03737782f, 0.26732931f, 0.09279368f, -0.11642760f, -0.12341242f, -0.10989243f, 0.25623846f, 0.00278403f, 
    -0.11407899f, -0.16165651f, -0.10113482f, -0.10555824f, -0.05194294f, 0.13616367f, -0.08002761f, -0.01825482f, 
    -0.01967784f, 0.03296571f, -0.10354493f, -0.04912941f, 0.13340980f, 0.05271000f, -0.08441777f, 0.18053488f, 
    0.09635147f, -0.02101407f, 0.00175808f, 0.13541505f, -0.18751946f, 0.09788541f, 0.05440225f, 0.14346860f, 
    -0.01663960f, 0.00832444f, 0.04595908f, 0.03362826f, 0.30573973f, 0.16329005f, 0.14798605f, 0.03084346f, 
    -0.08318981f, 0.01910565f, 0.08115174f, 0.15231629f, -0.03134929f, 0.08998761f, 0.10437810f, -0.00721354f, 
    0.00886276f, 0.06427433f, -0.02606425f, -0.10559432f, -0.01282435f, -0.09644680f, -0.03838472f, 0.08117967f, 
    0.07398959f, 0.04265711f, 0.07633391f, -0.04881914f, -0.03664199f, -0.09761357f, 0.15140066f, 0.12928794f, 
    -0.23342495f, 0.45172581f, -0.02129243f, -0.09653036f, -0.10591893f, 0.07275347f, -0.07737197f, -0.05139107f, 
    -0.02496813f, -0.08978748f, 0.08858402f, -0.04320587f, -0.10483851f, -0.28259832f, 0.07187614f, -0.23542821f, 
    -0.00945774f, -0.07521924f, -0.05062448f, -0.02572939f, -0.02294121f, 0.05794138f, 0.23750673f, 0.16528974f, 
    -0.30166188f, 0.21649706f, 0.30513853f, -0.06181141f, 0.10505044f, -0.06770830f, -0.07702725f, -0.15621617f, 
    0.06349342f, 0.04980395f, 0.05524624f, 0.05378270f, -0.01315506f, 0.12007406f, 0.03243511f, -0.00847081f, 
    -0.04179883f, -0.19467530f, -0.05221219f, -0.08968596f, -0.05516003f, 0.01568149f, 0.15076278f, -0.03151128f, 
    -0.25675815f, -0.14342628f, -0.02682728f, 0.03484346f, 0.10602623f, -0.02979763f, 0.11127058f, -0.02875344f, 
    -0.06010989f, -0.02111132f, 0.09080504f, 0.10216544f, 0.52445871f, -0.17136616f, -0.20287135f, 0.07048230f, 
    -0.11928601f, -0.07209516f, 0.12495057f, 0.01494733f, -0.05795368f, 0.05663591f, -0.00184180f, 0.04836743f, 
    0.35824582f, 0.43488556f, -0.00675159f, 0.31297377f, 0.08024672f, 0.01766310f, -0.07550520f, -0.04003422f, 
    0.04241087f, 0.08295435f, 0.12997127f, -0.09669308f, -0.02090014f, 0.12891468f, -0.13565639f, -0.14101252f, 
    -0.03874320f, -0.06137707f, -0.03343459f, 0.04990687f, -0.07857267f, 0.04699987f, 0.01861091f, 0.02505529f, 
    -0.09562194f, 0.21017200f, 0.09805910f, -0.23571117f, 0.06666014f, 0.03833265f, 0.05639344f, 0.19375007f, 
    0.09211503f, -0.02661758f, -0.08976069f, -0.18299282f, -0.02580255f, 0.24519226f, 0.04073934f, -0.09794144f, 
    0.04263784f, 0.08844683f, 0.05103080f, -0.04605290f, 0.01442033f, -0.05849827f, -0.02569526f, 0.03152523f, 
    -0.01420806f, 0.02710354f, 0.27441433f, 0.38997263f, -0.00166977f, -0.01108004f, 0.01278045f, 0.25881696f, 
    0.04441440f, 0.05337925f, 0.01225582f, 0.10320987f, -0.26752359f, -0.14456826f, -0.19204392f, -0.20780079f, 
    0.00104364f, -0.03740467f, -0.12980673f, -0.10054027f, -0.01485541f, 0.00816133f, -0.06353774f, 0.04565194f, 
    -0.10356099f, -0.16151305f, 0.09032749f, 0.07380082f, 0.04379739f, -0.07477479f, 0.14181210f, 0.13851982f, 
    -0.10006259f, 0.12432455f, -0.08472972f, 0.20335042f, -0.26795113f, -0.02179311f, 0.01296731f, -0.30156446f, 
    -0.00896766f, -0.11231197f, -0.01772040f, 0.17384231f, 0.22794448f, 0.08199957f, -0.01444760f, 0.03349155f, 
    -0.17405973f, 0.04970212f, -0.00688274f, -0.14402106f, 0.09945282f, -0.00785124f, -0.06432085f, 0.09224312f, 
    -0.12190884f, 0.01857822f, -0.04695708f, -0.07416612f, -0.05550981f, -0.06252424f, 0.04867522f, -0.18986782f, 
    0.15100585f, 0.02227550f, 0.06612996f, 0.01211399f, 0.04449415f, -0.04095282f, -0.10495631f, 0.05827062f, 
    -0.03146848f, -0.07179394f, 0.05092699f, -0.11357746f, -0.13462035f, -0.02307102f, -0.04594381f, -0.05165954f, 
    -0.05559476f, 0.11212831f, 0.02432993f, 0.08213867f, -0.13188694f, -0.02875555f, -0.05266911f, 0.12573913f, 
    -0.02412293f, -0.17582682f, -0.08238835f, 0.13100177f, 0.03420863f, 0.09316233f, 0.04919123f, -0.00396106f, 
    -0.11182008f, -0.17438333f, 0.06431611f, 0.20467336f, -0.01301307f, -0.00973535f, 0.00226164f, 0.03976898f, 
    0.11071666f, -0.07394054f, 0.10460362f, 0.16991633f, 0.04857943f, -0.11331103f, -0.11958491f, -0.07183426f, 
    -0.13020666f, 0.05093049f, -0.00698339f, 0.02847710f, 0.02095248f, 0.08274684f, 0.02514905f, -0.09854963f, 
    0.15900497f, 0.05028431f, -0.09251491f, -0.00875034f, 0.08568904f, 0.28663671f, -0.08776902f, 0.07861493f, 
    -0.02984720f, -0.05999675f, -0.06845532f, 0.15682787f, -0.15699033f, 0.08409101f, 0.02952825f, 0.25470465f, 
    0.12795308f, 0.01181591f, -0.05535802f, 0.03631873f, -0.04932543f, -0.01274291f, -0.12000771f, 0.13108335f, 
    -0.56078482f, -0.32204434f, 0.12969738f, 0.28178635f, -0.07358559f, -0.00835531f, -0.00879212f, 0.08073755f, 
    0.21713649f, 0.17325206f, -0.12944239f, -0.05511362f, 0.02316480f, -0.02510288f, 0.09266670f, 0.11286155f, 
    -0.07060511f, -0.16865149f, 0.03134020f, 0.02667847f, -0.04583919f, 0.06492446f, -0.02847593f, 0.08049097f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17111254f, 0.13331252f, -0.20560381f, -0.08708581f, 0.04981275f, 0.17830375f, 0.16343205f, 0.02443953f, 
    0.10038849f, 0.04003234f, -0.07033964f, 0.01209932f, -0.00126259f, -0.16199255f, -0.12329954f, 0.02429008f, 
    0.03843974f, -0.00624741f, 0.14332817f, 0.02250653f, -0.05877829f, -0.00848021f, 0.01133272f, 0.04628698f, 
    -0.05733945f, 0.22168881f, -0.01415598f, 0.25283962f, 0.01254264f, 0.08798836f, -0.05977398f, 0.07306577f, 
    0.11663355f, 0.10307682f, -0.00221929f, 0.19288416f, -0.19329175f, 0.04087093f, 0.11402012f, 0.03889412f, 
    0.29261133f, 0.02602191f, 0.04853771f, 0.02326252f, -0.04354013f, 0.17104536f, -0.00268726f, 0.07248433f, 
    0.05144534f, 0.09000959f, 0.03737595f, -0.09101862f, -0.07168715f, 0.05810834f, 0.20380674f, 0.14336011f, 
    0.28238401f, 0.01773433f, -0.03195775f, 0.00718281f, 0.08252309f, -0.02572052f, 0.20925801f, 0.18050075f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02907354f, 0.08999673f, -0.00001017f, 0.07540185f, -0.01598613f, 0.00690758f, -0.02073450f, -0.12177507f, 
    -0.23485161f, 0.02861809f, 0.04804577f, 0.11686117f, 0.22049962f, 0.15716554f, 0.10250557f, 0.07237925f, 
    -0.01577952f, 0.30560780f, -0.12940346f, 0.15470725f, -0.09556612f, 0.08478704f, 0.01249330f, 0.10554769f, 
    -0.01670172f, 0.23018298f, -0.00826404f, 0.22902566f, -0.03366999f, 0.08389678f, -0.10704353f, 0.00909549f, 
    0.18097496f, -0.13139535f, 0.06091607f, -0.14064169f, -0.19870803f, -0.28084940f, -0.12153717f, -0.02917484f, 
    0.30055103f, 0.11920429f, -0.07096990f, -0.13124783f, -0.07667410f, 0.01192454f, -0.14454789f, -0.03869064f, 
    0.22867809f, -0.08931616f, -0.17706622f, -0.21953824f, 0.19045712f, -0.19412023f, -0.03235414f, 0.43637428f, 
    0.14739519f, 0.07128499f, -0.12261124f, -0.07649355f, 0.21965863f, 0.26092544f, 0.00584992f, 0.15073238f, 
    0.11146239f, 0.03398720f, -0.20516604f, -0.15121731f, 0.08418765f, -0.27573669f, -0.16834815f, -0.15034522f, 
    -0.00989463f, 0.11201155f, 0.04399006f, 0.05477621f, -0.30300531f, -0.07935173f, 0.18451390f, 0.01201108f, 
    0.06405477f, 0.03325229f, 0.01519189f, -0.05463131f, -0.06998927f, 0.11604052f, -0.00491223f, 0.00886184f, 
    0.11158093f, 0.07411356f, 0.08485461f, -0.05098470f, -0.09296054f, 0.15088689f, -0.35767198f, 0.24240154f, 
    0.02565350f, -0.30907187f, 0.00363408f, 0.38089409f, 0.33171684f, 0.21520597f, 0.01134038f, -0.01151654f, 
    0.25717148f, -0.09267083f, -0.32318664f, 0.03117634f, 0.23644942f, -0.07915361f, -0.02384277f, -0.14729664f, 
    0.13325749f, 0.13435389f, 0.10773294f, -0.07117006f, -0.06505813f, -0.25197926f, 0.17152107f, -0.07542682f, 
    -0.09148242f, 0.19488476f, -0.05810670f, -0.43051490f, 0.07361083f, -0.01405836f, 0.33764669f, -0.11541240f, 
    -0.03438668f, -0.04743113f, 0.11869760f, 0.02566500f, 0.00434591f, 0.25365555f, 0.35938677f, 0.22805840f, 
    0.00606343f, 0.11250371f, 0.13346697f, -0.09839050f, 0.39388764f, -0.07897826f, 0.14257458f, -0.00471719f, 
    -0.07893193f, -0.08515535f, -0.12012580f, 0.17038684f, -0.11919080f, -0.09063838f, 0.09915893f, 0.15874518f, 
    -0.17261416f, 0.17447203f, 0.03757883f, 0.09668162f, -0.02830678f, 0.11514394f, -0.03788203f, -0.13514270f, 
    -0.02509084f, 0.13993824f, -0.24594861f, -0.27504230f, -0.02637303f, 0.20575091f, -0.17108582f, 0.02505380f, 
    -0.25771368f, 0.12165649f, 0.11476307f, 0.09667030f, -0.21182087f, -0.22775398f, -0.13917376f, -0.08561730f, 
    0.17984234f, -0.06425887f, 0.19897126f, 0.16614735f, -0.14231694f, -0.04441453f, 0.03448059f, 0.08453244f, 
    0.14934203f, 0.16380312f, 0.06765017f, 0.24183466f, 0.03457113f, -0.02130152f, 0.09934600f, -0.02812537f, 
    -0.03439559f, 0.06370329f, -0.20863193f, -0.06782489f, -0.00145895f, 0.23032479f, 0.16846643f, 0.08563719f, 
    0.09558298f, -0.01391554f, -0.03004580f, 0.01796260f, 0.21170978f, 0.02414908f, 0.11655353f, 0.05126788f, 
    0.20580882f, 0.15649030f, 0.24510700f, -0.09701870f, -0.01309779f, 0.11050452f, -0.04005560f, -0.10182217f, 
    -0.01458850f, 0.27169985f, -0.29588711f, 0.17297374f, -0.08340783f, 0.15751122f, -0.41857651f, -0.21051341f, 
    -0.11793391f, -0.09856877f, -0.09857285f, 0.02191581f, -0.37548736f, 0.25625485f, 0.23912948f, -0.05554003f, 
    0.07224600f, 0.02063720f, 0.14255808f, 0.30570087f, 0.15271436f, -0.06486972f, -0.34937677f, 0.14069428f, 
    0.04191007f, 0.22402066f, -0.02098941f, -0.16967940f, 0.01876983f, -0.12757996f, 0.10150114f, 0.17066078f, 
    0.02983294f, -0.05894540f, 0.09534146f, 0.05126752f, 0.18626739f, 0.04268811f, -0.11236081f, 0.26454157f, 
    -0.13335989f, -0.03701740f, 0.17443787f, 0.03728950f, 0.08916089f, -0.09778428f, -0.18237236f, 0.10457683f, 
    -0.05604246f, -0.04802689f, -0.07815326f, 0.03625711f, -0.39134496f, 0.14795820f, 0.19343899f, 0.08378324f, 
    0.06060450f, 0.22466438f, 0.16686873f, 0.10266054f, 0.04417521f, -0.07836833f, 0.09838681f, 0.14696912f, 
    0.05896907f, -0.14361280f, 0.28900468f, 0.21367989f, -0.08827250f, 0.03169774f, 0.41457763f, 0.50816298f, 
    0.08848884f, -0.10235165f, 0.13882250f, 0.34034401f, -0.02025707f, -0.18140699f, -0.08569890f, -0.03367458f, 
    0.19974418f, -0.08943383f, 0.05803687f, 0.13709860f, -0.00811529f, 0.27185372f, 0.30594954f, 0.03124134f, 
    -0.15569957f, 0.02788436f, 0.02521562f, -0.17653328f, -0.00950486f, 0.23682000f, 0.18147363f, 0.07078712f, 
    0.03441621f, -0.02582019f, 0.08666376f, -0.09493554f, -0.15773474f, 0.21449415f, 0.12319484f, 0.04050779f, 
    -0.08923974f, 0.00044468f, 0.01040956f, -0.05176593f, 0.04390435f, 0.02895627f, -0.22036247f, -0.18696117f, 
    0.22931534f, 0.12586877f, -0.10610545f, 0.01124035f, -0.46206430f, 0.47009504f, 0.10468166f, 0.10592258f, 
    -0.20475988f, 0.13452804f, 0.11737323f, -0.21267456f, -0.06848447f, 0.07783280f, -0.00238408f, -0.09362100f, 
    0.12533262f, -0.19301808f, 0.14156508f, -0.22961020f, 0.00080435f, 0.04316278f, 0.34158123f, 0.23454809f, 
    0.07678238f, -0.06772901f, 0.01534928f, 0.05108838f, 0.36527976f, -0.17846209f, 0.02620501f, -0.10520827f, 
    -0.16534369f, 0.06704854f, -0.10417725f, -0.10143497f, 0.21779373f, -0.13101704f, 0.13406758f, 0.05392708f, 
    0.06118035f, 0.15813811f, -0.06765927f, -0.19155766f, 0.19477710f, -0.15371236f, 0.19176702f, 0.00942180f, 
    -0.05090715f, 0.08704499f, 0.09876734f, -0.16225323f, 0.05127317f, -0.11815319f, -0.02567271f, -0.12622041f, 
    0.00073848f, 0.20832856f, -0.39414570f, -0.05133193f, -0.06803719f, 0.04869826f, 0.30183148f, -0.16534461f, 
    -0.07914389f, 0.18062916f, -0.15275443f, 0.08939879f, -0.18622398f, -0.17457445f, -0.30417919f, 0.03956235f, 
    -0.35200968f, -0.04082073f, -0.07839005f, -0.04647515f, -0.02883914f, -0.08293235f, 0.03552898f, 0.27390242f, 
    0.16132425f, 0.10426737f, 0.09483585f, 0.22186497f, -0.10103916f, 0.00688294f, 0.38461727f, 0.23630431f, 
    -0.04422661f, 0.12046102f, -0.13280195f, 0.04376638f, -0.04000373f, -0.18382300f, 0.09627730f, -0.10367159f, 
    0.16263802f, 0.06946020f, 0.01278756f, 0.01560611f, 0.24217300f, 0.13230684f, 0.11750069f, -0.04696416f, 
    0.22038275f, 0.10340818f, 0.07119564f, -0.15209152f, 0.20784880f, 0.15755066f, 0.10274309f, 0.14471801f, 
    0.09542713f, -0.06139404f, 0.21924326f, -0.12224729f, -0.14408061f, -0.00033106f, 0.14163415f, 0.07033048f, 
    -0.01044766f, -0.13844405f, -0.02212596f, -0.05864290f, -0.02208190f, -0.14355306f, -0.00414059f, 0.02646228f, 
    -0.07316432f, 0.07722113f, -0.11869278f, -0.11082092f, -0.02306009f, -0.02747302f, 0.06029489f, -0.08336976f, 
    -0.03432231f, 0.07776100f, -0.06446382f, 0.04119987f, -0.08144449f, -0.10838044f, -0.08067155f, -0.10113493f, 
    -0.15568674f, -0.09790202f, -0.03012122f, 0.06070631f, 0.07806633f, 0.03712308f, -0.00748918f, -0.10271266f, 
    -0.05661507f, -0.05402729f, -0.12343156f, -0.06999753f, -0.08766451f, -0.00509773f, -0.10520023f, 0.10115533f, 
    -0.03976405f, -0.11861029f, -0.08923481f, -0.09085318f, -0.08330798f, -0.08730048f, -0.01822146f, 0.08259886f, 
    0.03393576f, 0.09197077f, -0.04465270f, 0.03061436f, -0.08598616f, 0.04844008f, -0.06471868f, -0.08033235f, 
    -0.15238306f, 0.04094366f, 0.07773644f, -0.04701669f, -0.14221089f, 0.05618921f, -0.09117357f, 0.01664774f, 
    -0.03220550f, -0.06657094f, -0.02994402f, -0.02717020f, -0.06529938f, -0.02611865f, -0.07341810f, -0.05775620f, 
    -0.12918773f, -0.08505565f, -0.06485958f, 0.07946509f, 0.13952968f, 0.09415434f, -0.02144344f, 0.03790279f, 
    -0.09514092f, 0.04383432f, 0.18736632f, -0.13680212f, 0.09719391f, 0.06539136f, 0.11029378f, -0.08808363f, 
    0.05463519f, -0.12540139f, -0.14561172f, -0.15049134f, 0.11842984f, 0.00712134f, -0.03772166f, -0.04319704f, 
    -0.13559288f, -0.07439379f, -0.14867520f, -0.07581566f, 0.03776340f, -0.03865446f, 0.03219481f, 0.01378460f, 
    0.05599465f, -0.04643393f, 0.08761858f, -0.10222096f, 0.11950465f, -0.12417232f, -0.05330333f, 0.06135701f, 
    0.07318054f, -0.08666164f, -0.16065916f, 0.04079389f, 0.14755119f, 0.02916265f, 0.00024216f, -0.04927446f, 
    -0.12944601f, -0.07739802f, 0.01402967f, 0.02173907f, -0.16907141f, -0.03320190f, -0.18423888f, 0.04206786f, 
    -0.05739488f, -0.12906708f, 0.26001868f, -0.10519984f, 0.09671953f, -0.19933102f, 0.04002018f, 0.02263502f, 
    0.16594106f, -0.11977238f, 0.19844574f, 0.08601715f, 0.00405941f, 0.30012292f, -0.03897196f, -0.06321087f, 
    -0.17440894f, -0.10417940f, -0.01657809f, -0.04596143f, 0.11061587f, 0.05036325f, -0.05607657f, 0.09457313f, 
    -0.11775324f, -0.14090885f, 0.22029197f, -0.12001631f, 0.05349033f, 0.12620336f, 0.64681190f, 0.06480733f, 
    -0.07013414f, -0.05098569f, 0.01444012f, 0.12222496f, 0.08578569f, -0.24784292f, -0.21947856f, -0.00986925f, 
    0.32882249f, 0.01361553f, 0.14518173f, -0.28950951f, -0.08874431f, 0.47990790f, 0.29587862f, 0.03924970f, 
    -0.56356031f, 0.07635266f, 0.19279383f, 0.08203131f, -0.26315585f, 0.16067597f, -0.20869577f, -0.02990825f, 
    0.12774777f, 0.04993739f, -0.22231716f, -0.02443483f, 0.18995611f, -0.24005316f, -0.11949465f, 0.05323719f, 
    -0.03331297f, -0.09445760f, -0.01269211f, -0.05861102f, -0.11005194f, -0.15893111f, -0.24266608f, 0.15676610f, 
    0.09462431f, -0.01530941f, 0.10778865f, -0.11562226f, 0.05178000f, 0.11103718f, 0.35564804f, -0.04430624f, 
    0.11630589f, 0.23680612f, 0.00336623f, -0.19678691f, -0.00429186f, -0.06077568f, 0.12120336f, -0.10022123f, 
    -0.18085161f, -0.08088555f, 0.12520790f, 0.00095005f, -0.05823970f, 0.06889865f, 0.34678015f, 0.29748866f, 
    0.08157325f, -0.24673866f, -0.25934017f, 0.15941879f, -0.05263051f, -0.00277198f, -0.39923194f, -0.02872007f, 
    0.03089928f, -0.08232208f, -0.11789145f, -0.18025962f, -0.16759090f, 0.05744509f, 0.24237424f, -0.17911194f, 
    -0.52310294f, 0.05699785f, -0.06629890f, -0.17737907f, -0.24624926f, -0.47959086f, -0.13934943f, 0.03199247f, 
    0.20342600f, 0.05540277f, -0.49545941f, -0.14294264f, 0.30461448f, -0.24217193f, 0.07921509f, 0.04489277f, 
    -0.30887055f, 0.01122504f, 0.36284962f, -0.01669297f, 0.04658613f, 0.18463334f, 0.07268503f, -0.00631478f, 
    -0.13918990f, 0.16329408f, 0.26439199f, 0.10722274f, 0.24885954f, 0.54472959f, 0.29779369f, 0.00247232f, 
    0.12599747f, 0.23498772f, -0.62231898f, 0.04431946f, 0.05741265f, -0.08538376f, 0.02096800f, 0.27302429f, 
    0.30048475f, -0.26737827f, 0.07534974f, -0.28397721f, -0.07283656f, -0.30135894f, -0.13779119f, 0.10092525f, 
    -0.04660998f, 0.19924124f, -0.18714170f, -0.23451732f, 0.34115243f, 0.13038914f, 0.11901598f, -0.11224186f, 
    -0.38733837f, -0.06855068f, -0.05159809f, 0.02324210f, 0.18642785f, -0.51327610f, -0.13469233f, -0.16846383f, 
    0.21825281f, -0.02812405f, -0.06087416f, 0.01731319f, 0.28917205f, 0.08106060f, -0.01589829f, -0.09267330f, 
    -0.32946396f, 0.03955156f, 0.05824012f, 0.03156251f, -0.07624418f, 0.24737015f, -0.32239532f, -0.28002325f, 
    -0.09974863f, 0.01381769f, 0.21045087f, 0.04426709f, -0.11315851f, 0.00283555f, -0.11275493f, -0.32159248f, 
    -0.18757018f, 0.14783143f, 0.15192956f, 0.11438341f, -0.28582531f, 0.52968311f, 0.05139551f, 0.08938868f, 
    -0.07939480f, 0.13770506f, -0.01739478f, 0.10500663f, 0.06058835f, 0.03640409f, -0.01849684f, 0.15924001f, 
    -0.07066002f, -0.16354917f, 0.14447075f, -0.04237964f, -0.04621631f, 0.09295157f, 0.32923302f, -0.10209502f, 
    0.07609847f, -0.04653849f, 0.04904499f, 0.07337860f, 0.29022381f, -0.38637385f, 0.07112149f, 0.08546026f, 
    0.21245517f, 0.05040007f, -0.12244860f, -0.12403996f, 0.10090043f, 0.14747737f, 0.23007925f, -0.14998965f, 
    -0.08280125f, -0.11980426f, -0.06141864f, -0.32669789f, 0.28458548f, 0.15158309f, 0.06577679f, 0.04080831f, 
    0.16023739f, 0.01391439f, 0.10595435f, 0.05230070f, -0.06499366f, 0.14408709f, 0.05297140f, -0.08790840f, 
    0.04595719f, 0.05507043f, -0.35340542f, 0.03857114f, 0.03911430f, 0.01633248f, -0.06983925f, -0.46631253f, 
    0.07511380f, 0.10618000f, 0.08187283f, 0.12004671f, -0.21139076f, 0.21015234f, 0.04284610f, 0.08250967f, 
    -0.02415835f, 0.19759840f, 0.04552975f, -0.19391428f, 0.08633203f, 0.06545684f, -0.07743141f, -0.05536977f, 
    0.00821565f, 0.17157915f, -0.37893161f, -0.14836611f, -0.05796891f, 0.12952213f, 0.16054331f, 0.03158827f, 
    -0.00583481f, -0.00684462f, -0.13505253f, 0.15238391f, -0.11837090f, 0.10684667f, 0.16960038f, -0.02501062f, 
    0.18453251f, -0.04413883f, 0.15230551f, -0.00506397f, 0.13879907f, 0.02162746f, -0.16839927f, 0.26826790f, 
    -0.12682296f, 0.01611387f, -0.36065316f, -0.44618231f, 0.07073147f, 0.04519908f, 0.27407840f, -0.15747765f, 
    -0.28434479f, -0.13603009f, 0.01292663f, -0.35451633f, -0.00915782f, -0.15791734f, 0.04009625f, -0.05525383f, 
    -0.21350536f, 0.17301451f, 0.03472713f, 0.08046545f, 0.01934576f, -0.07730716f, 0.05237094f, -0.23703341f, 
    0.17412025f, 0.19448034f, 0.25516230f, 0.02079993f, -0.31121385f, 0.88527495f, 0.53669411f, 0.06200027f, 
    -0.03491677f, 0.31863105f, -0.10974591f, -0.09560911f, -0.09403596f, 0.02153112f, 0.01360969f, -0.07945754f, 
    -0.07074974f, -0.20675239f, -0.23639944f, -0.23967654f, -0.04783386f, 0.13982792f, 0.27916747f, 0.10439146f, 
    0.01530075f, -0.05992160f, -0.34011704f, -0.19828795f, 0.58305162f, -0.05032175f, -0.01474652f, -0.07435877f, 
    -0.13626839f, 0.07345483f, 0.03489855f, 0.15243545f, 0.22417198f, -0.01391949f, 0.09682565f, -0.36108577f, 
    0.23282558f, 0.06009004f, 0.05418832f, -0.06816752f, 0.24108042f, -0.26232877f, 0.16491330f, -0.33791623f, 
    -0.24371369f, -0.05846197f, 0.09730627f, -0.12587671f, 0.08832105f, 0.14504403f, -0.12771368f, -0.34992829f, 
    0.12934102f, -0.07459135f, -0.11373857f, -0.09774092f, 0.00066534f, 0.10307419f, -0.04786381f, -0.33175585f, 
    -0.03440746f, -0.00233426f, -0.09166189f, -0.01143353f, -0.13403963f, -0.13165699f, 0.02077558f, -0.09654781f, 
    0.18378620f, 0.13934945f, 0.02801255f, -0.20290636f, -0.10541874f, 0.05826632f, 0.04958765f, 0.01831783f, 
    -0.03227104f, 0.05798817f, 0.11077592f, 0.14034046f, -0.11788157f, 0.06556413f, -0.19668652f, 0.08277187f, 
    0.04131643f, -0.13018174f, 0.12956721f, 0.37490854f, -0.39214256f, 0.04565562f, 0.11544316f, -0.02966516f, 
    0.38241664f, 0.07720890f, 0.07687281f, -0.01142037f, -0.14927548f, 0.37396306f, 0.12594146f, 0.15447818f, 
    -0.08939863f, 0.16285069f, -0.19909757f, -0.23380037f, 0.03823513f, 0.05375464f, 0.25148234f, -0.07330380f, 
    0.09336277f, -0.17429349f, -0.01772101f, -0.12898116f, -0.00489822f, 0.09339347f, 0.00488739f, 0.06664170f, 
    0.10372966f, 0.02921643f, 0.06182182f, -0.01590837f, -0.09847999f, 0.01084172f, -0.09654263f, 0.28901106f, 
    0.10175927f, 0.12704390f, 0.09964079f, 0.02120553f, 0.02218135f, -0.31260952f, -0.23612529f, 0.02029309f, 
    0.11844297f, -0.38509113f, 0.10282857f, 0.03936359f, 0.05440896f, 0.01590096f, 0.05615947f, -0.09934228f, 
    0.06540313f, 0.18531984f, -0.26967254f, -0.04468370f, 0.01172538f, 0.08426806f, -0.23339039f, -0.29938802f, 
    0.14308478f, 0.22141269f, 0.02152991f, -0.04083118f, -0.02133746f, 0.25339666f, -0.07426927f, -0.07369947f, 
    -0.01425626f, 0.01375856f, -0.05676975f, 0.30790636f, -0.20119569f, -0.12009312f, -0.14294475f, 0.09958501f, 
    -0.05467450f, 0.03563567f, 0.05965725f, 0.06207033f, -0.03540861f, 0.04946888f, -0.13396715f, -0.19960730f, 
    0.20169079f, 0.09984467f, 0.10957992f, 0.11085647f, -0.03861118f, -0.04428208f, -0.09049857f, -0.07992724f, 
    0.02919901f, 0.28897390f, 0.17831674f, -0.09169743f, -0.00195369f, 0.11703332f, 0.29393092f, -0.24797656f, 
    -0.09483258f, 0.08197676f, -0.04994918f, 0.03858843f, 0.24510685f, 0.07452004f, 0.06484658f, 0.03627054f, 
    0.23762578f, 0.15537299f, -0.47133991f, 0.17272708f, -0.12663385f, 0.01493667f, 0.01485226f, 0.22202362f, 
    -0.10258999f, -0.12410976f, 0.01970797f, 0.23164706f, -0.01400748f, -0.09905379f, -0.06296741f, 0.05693085f, 
    -0.01774340f, 0.10584622f, 0.12440389f, -0.05558944f, -0.27208456f, -0.08279313f, 0.04807491f, -0.08289947f, 
    0.24919939f, 0.02957011f, 0.02592010f, -0.03888654f, -0.06853625f, -0.23473336f, 0.01002118f, -0.03232181f, 
    0.23237424f, -0.16845925f, -0.37518996f, -0.17332317f, 0.27207345f, -0.21163051f, 0.26621145f, 0.26966059f, 
    0.17911305f, -0.02690621f, 0.08690010f, 0.04064526f, -0.09290737f, 0.24281883f, -0.16760796f, -0.11625939f, 
    -0.13395365f, -0.09990171f, -0.05779396f, 0.06695665f, -0.08829152f, -0.00419971f, -0.04734936f, 0.06351054f, 
    0.07049552f, -0.13402945f, -0.02829731f, -0.01330830f, -0.01276610f, -0.12938483f, -0.01915769f, 0.05286922f, 
    0.03639570f, 0.05507784f, -0.13742381f, 0.06095434f, 0.10873134f, 0.00533398f, 0.02076388f, 0.07468987f, 
    -0.03805255f, -0.00601386f, 0.00792900f, 0.04954063f, -0.01730447f, -0.04573771f, -0.02482648f, 0.00130811f, 
    -0.07294576f, -0.00801378f, -0.05021935f, 0.05483995f, -0.00712359f, -0.14145508f, 0.04214061f, -0.10361437f, 
    -0.01833045f, 0.03431819f, -0.01050826f, -0.09386399f, 0.08856662f, 0.08073921f, -0.12960841f, -0.10119277f, 
    -0.14366028f, 0.09633236f, -0.01518357f, 0.02350285f, -0.14417201f, -0.13293281f, -0.02111253f, -0.01808359f, 
    0.06191910f, -0.14522541f, -0.03251852f, -0.14229974f, -0.10600785f, 0.08513612f, 0.06319052f, -0.09225140f, 
    0.05016685f, -0.04732454f, 0.04189220f, -0.12326574f, 0.08075151f, -0.04050863f, 0.04897451f, -0.07620669f, 
    -0.10729741f, 0.11540987f, -0.09557286f, 0.01670875f, -0.12430316f, -0.11098713f, -0.09481560f, -0.03144950f, 
    0.03931224f, 0.09556721f, 0.06770839f, -0.08854769f, 0.05759771f, -0.06857024f, 0.07528132f, 0.04899098f, 
    0.07193901f, -0.10031654f, -0.16453171f, 0.01179496f, -0.03462258f, 0.00991370f, -0.11822456f, -0.07446265f, 
    -0.07923778f, -0.08206435f, -0.15185381f, -0.12851156f, 0.00992951f, 0.04215159f, -0.11114484f, 0.09500106f, 
    0.03021136f, -0.10189140f, -0.02894577f, -0.11762296f, -0.03238337f, 0.01530216f, -0.07204891f, -0.14421245f, 
    0.04223631f, -0.06814949f, -0.14246474f, 0.03065291f, -0.11900993f, 0.10094100f, -0.10806721f, 0.06038111f, 
    -0.12726039f, -0.12714529f, 0.05981192f, -0.02066338f, -0.03124055f, -0.04767478f, 0.07258794f, -0.13401878f, 
    -0.16342494f, 0.29932496f, 0.16084890f, -0.05459731f, 0.10160843f, -0.13847718f, 0.19244105f, -0.02503087f, 
    0.23578438f, -0.06461132f, 0.00611597f, -0.09016871f, 0.12242185f, -0.35073581f, 0.05937944f, 0.10894123f, 
    -0.04516181f, 0.00677224f, -0.01974209f, -0.16231036f, -0.00483270f, 0.05127129f, -0.11082225f, 0.19342571f, 
    -0.14498268f, -0.00686183f, 0.26451364f, 0.35864419f, 0.08976884f, 0.14317429f, -0.37049663f, 0.16731603f, 
    0.27604803f, 0.02906400f, -0.18260516f, -0.17590570f, 0.03959946f, -0.00631803f, -0.35793108f, 0.06134222f, 
    -0.17524493f, 0.07266092f, -0.17810510f, -0.06747544f, -0.22206539f, -0.43334121f, 0.30490777f, -0.26195291f, 
    0.22456509f, 0.13261625f, 0.06194119f, 0.01630059f, -0.09529281f, -0.34017307f, -0.00535362f, 0.43508101f, 
    0.43918845f, 0.06411264f, 0.12846652f, 0.07677510f, 0.10992955f, -0.01327176f, 0.18942936f, -0.15674376f, 
    -0.11445367f, 0.03899356f, -0.05098543f, 0.09152062f, 0.00453656f, -0.09842821f, 0.09259830f, 0.12589478f, 
    -0.02118266f, -0.01294666f, -0.09705370f, -0.02942164f, -0.10190994f, 0.00580770f, 0.07083345f, 0.06902476f, 
    -0.17752051f, 0.09661325f, 0.02233689f, 0.12499102f, 0.00291508f, -0.03059573f, -0.05995337f, 0.08113547f, 
    -0.06428497f, -0.18945380f, 0.19200765f, 0.00360234f, -0.04572892f, -0.08518689f, -0.14582951f, -0.05619293f, 
    -0.25745288f, -0.04267414f, -0.13570943f, -0.22375350f, 0.11780433f, -0.08969922f, 0.01318193f, 0.09225369f, 
    -0.02674526f, 0.08341355f, 0.07926638f, -0.06218438f, -0.12768085f, -0.06307744f, -0.07558296f, -0.21832870f, 
    -0.11121162f, -0.13365528f, -0.07629811f, -0.03798743f, -0.08806907f, 0.00159823f, 0.03634014f, -0.10814486f, 
    -0.09910744f, -0.18701226f, 0.09865023f, 0.01178458f, -0.17873858f, 0.04346172f, -0.10603154f, -0.01184470f, 
    -0.08975396f, 0.28427061f, 0.22541669f, -0.02715181f, -0.11160627f, -0.03395843f, 0.05301135f, -0.04443999f, 
    0.20874047f, 0.20122334f, 0.26727131f, 0.05405948f, -0.11982603f, -0.27470800f, 0.10696111f, -0.06869516f, 
    0.07045354f, -0.29979357f, 0.11689093f, 0.05728478f, -0.04233167f, -0.03925275f, -0.00888636f, 0.16320819f, 
    -0.35148716f, 0.14320832f, -0.36504945f, 0.29488415f, 0.12806258f, 0.15025672f, -0.62701708f, -0.17399172f, 
    0.30095178f, 0.22763555f, -0.16798225f, 0.08969685f, -0.24181367f, 0.07174855f, -0.09656702f, -0.03041886f, 
    -0.01627364f, 0.05008367f, -0.08885763f, 0.13476159f, -0.34350961f, -0.24327365f, 0.32852054f, 0.11151928f, 
    -0.08166731f, 0.08357592f, 0.04826232f, -0.00670950f, 0.03974534f, -0.17137180f, 0.21813028f, -0.15094872f, 
    0.14561994f, 0.05783077f, -0.01851343f, 0.33403677f, 0.00755260f, 0.02168013f, 0.17264239f, -0.20035498f, 
    0.04332657f, -0.07990590f, 0.45090315f, 0.02226231f, 0.09319809f, -0.05022423f, -0.15268594f, -0.02689259f, 
    -0.22845581f, 0.03426222f, 0.10703401f, 0.11785112f, 0.05551358f, 0.01395843f, -0.04996059f, -0.08258624f, 
    -0.04947397f, -0.06666363f, -0.33707747f, 0.14659360f, -0.07675713f, 0.01540516f, 0.12399387f, 0.07487754f, 
    0.00151356f, -0.04403489f, 0.03193756f, -0.08001115f, 0.07938916f, -0.05755900f, -0.08394811f, -0.07585602f, 
    -0.09611813f, -0.14888990f, -0.02338202f, 0.09116821f, 0.11605275f, 0.01231532f, 0.02844485f, 0.11051574f, 
    0.06962740f, -0.04124996f, -0.13614626f, -0.06027596f, -0.23289888f, -0.07389340f, 0.17480758f, -0.18643799f, 
    0.07852223f, -0.23146614f, 0.08895297f, 0.16030818f, 0.06926425f, 0.22344871f, -0.09210388f, -0.10124263f, 
    -0.33963105f, -0.10424221f, 0.02751146f, 0.20728646f, 0.28464183f, -0.01947732f, -0.27246493f, -0.02319233f, 
    0.12415626f, -0.17194240f, 0.01742562f, 0.08056372f, 0.04975711f, -0.19035493f, -0.12841901f, -0.23301682f, 
    0.08533558f, -0.29992217f, -0.10733451f, -0.09935510f, -0.07541645f, 0.07305387f, -0.00243920f, -0.11611558f, 
    0.17941219f, 0.14377744f, -0.28951356f, 0.15407677f, 0.06178457f, -0.03843260f, 0.04978867f, -0.03180213f, 
    -0.08455984f, 0.06027434f, -0.05561119f, -0.11750522f, 0.11507342f, -0.08269268f, 0.10045534f, -0.05466550f, 
    0.07317331f, -0.08116311f, 0.04526563f, 0.19232604f, -0.16640820f, -0.05123236f, -0.09212063f, 0.11576690f, 
    0.18420172f, 0.02484192f, -0.13224223f, 0.14007014f, -0.31170931f, -0.29867774f, -0.00854002f, 0.10711108f, 
    -0.20503415f, -0.09357411f, -0.05629713f, 0.17078325f, -0.29041556f, -0.16418858f, -0.10916103f, -0.38231325f, 
    0.13864861f, -0.35167971f, -0.11390804f, -0.01560412f, -0.09127539f, -0.06271408f, -0.37397057f, -0.16432905f, 
    -0.03350824f, 0.11605646f, -0.21977443f, -0.03998754f, 0.02674061f, -0.07735449f, 0.01455194f, 0.03399009f, 
    0.21075659f, 0.09228584f, -0.03959082f, -0.04052567f, 0.09732795f, 0.04213296f, 0.27314764f, -0.00541488f, 
    0.05881915f, 0.17016277f, -0.10791451f, -0.24560055f, -0.00220965f, -0.05395003f, 0.11089773f, -0.14014000f, 
    -0.01848803f, 0.00872943f, -0.15127897f, -0.12064613f, 0.06344334f, 0.13565296f, 0.08403707f, 0.03792356f, 
    0.01342125f, -0.12932563f, -0.27723178f, 0.08828420f, -0.20676579f, 0.42167154f, 0.10267954f, 0.09666783f, 
    -0.12414592f, -0.12820937f, -0.04614088f, 0.14038995f, -0.01897013f, -0.29397300f, -0.08518144f, 0.07697661f, 
    -0.08197323f, 0.25889799f, -0.05186338f, -0.15248583f, -0.01304762f, -0.03173116f, 0.13693410f, -0.09889752f, 
    0.00334114f, 0.06045887f, 0.06495975f, -0.05712296f, 0.28991690f, -0.12726617f, 0.06783339f, 0.15902174f, 
    0.04845413f, -0.06829650f, 0.04696950f, 0.05141259f, -0.10117203f, 0.00473791f, -0.06619003f, 0.12802741f, 
    0.17968018f, -0.11979327f, -0.09718260f, 0.06123046f, -0.06978833f, -0.13263144f, -0.10267685f, -0.06019129f, 
    -0.09590166f, 0.09568989f, 0.10135540f, 0.12454405f, 0.11102308f, -0.04428514f, 0.03042771f, -0.01998847f, 
    0.28992000f, -0.23602946f, 0.11176410f, 0.06514613f, -0.07512167f, -0.14546539f, 0.26574716f, 0.37144190f, 
    -0.21197146f, 0.03996648f, 0.10690881f, -0.10412184f, 0.14992954f, -0.07743345f, 0.15156226f, -0.05646189f, 
    -0.09520449f, -0.03016540f, 0.02687893f, 0.11317412f, 0.17808232f, 0.27307415f, -0.02990261f, 0.06029127f, 
    0.06810537f, -0.05850001f, 0.23954347f, 0.13374239f, -0.03577992f, 0.37260178f, -0.06741483f, -0.09068026f, 
    -0.08208485f, -0.20483568f, 0.14134902f, -0.05471589f, -0.12020167f, -0.08710738f, -0.07182756f, -0.13980442f, 
    0.10979640f, 0.08402494f, -0.12106420f, 0.04934443f, -0.06358296f, 0.08466589f, 0.28121090f, 0.19974901f, 
    0.00464380f, -0.09715687f, 0.04370560f, 0.02570158f, 0.21613540f, -0.23508953f, -0.04665389f, 0.03426597f, 
    -0.11560888f, -0.06636909f, -0.05128992f, 0.18474044f, 0.06766527f, -0.00099762f, 0.10433767f, -0.40023112f, 
    0.03996439f, 0.16119145f, -0.00668285f, -0.03195891f, -0.08646882f, -0.02466071f, -0.17474785f, -0.04240645f, 
    0.08146188f, 0.21055087f, -0.26893377f, 0.04307139f, 0.15226127f, 0.34705797f, -0.33673742f, -0.03666428f, 
    -0.16726576f, 0.11837785f, 0.03223071f, -0.07220805f, -0.08684365f, -0.32183424f, -0.00214234f, -0.12257195f, 
    0.02260104f, 0.12566487f, 0.21626535f, 0.20050855f, -0.34946895f, -0.07494290f, -0.27133688f, 0.01568074f, 
    0.18154185f, 0.07293676f, -0.03156181f, -0.08702632f, 0.08590525f, -0.11544829f, 0.14536983f, -0.06998480f, 
    0.10152981f, 0.05842444f, 0.07719626f, -0.09870332f, -0.10489045f, -0.04635806f, 0.02791581f, -0.04252749f, 
    -0.10215279f, -0.13546896f, -0.01239879f, -0.10580800f, 0.03507073f, -0.03104530f, -0.03513674f, -0.10270778f, 
    -0.08373658f, 0.03970102f, -0.11662753f, -0.11840611f, -0.00009415f, -0.05139294f, -0.07737499f, -0.05124324f, 
    -0.05687679f, 0.05462100f, -0.08717830f, -0.02290776f, 0.08179554f, -0.12619092f, -0.08018786f, 0.10117185f, 
    -0.05079716f, -0.06744925f, -0.08035608f, -0.12478778f, -0.08486374f, 0.09654444f, -0.04450173f, -0.06780730f, 
    0.05939280f, 0.00708946f, -0.12622084f, -0.00477721f, 0.09333859f, -0.00499661f, 0.04381914f, -0.02899682f, 
    -0.02411862f, -0.12553722f, 0.07391676f, -0.11741245f, -0.07261270f, 0.05882469f, 0.10903887f, 0.10292014f, 
    -0.11867578f, 0.02756460f, 0.02265669f, 0.05793753f, -0.05740895f, -0.11474729f, 0.10630141f, 0.02091064f, 
    -0.12501131f, -0.06123435f, 0.10280222f, -0.04766514f, -0.10437598f, -0.01245308f, -0.15926674f, -0.04466756f, 
    -0.16653892f, -0.17954345f, -0.10344458f, 0.07495126f, 0.13172342f, -0.10655535f, -0.02577769f, 0.11324728f, 
    0.10642544f, -0.01222632f, -0.30274019f, 0.09394802f, 0.09810207f, -0.07864733f, 0.01165127f, -0.12781101f, 
    -0.12036429f, 0.06730979f, -0.05243953f, -0.01906205f, 0.07054181f, -0.10760356f, -0.09210720f, -0.13886094f, 
    0.01868608f, -0.33669004f, 0.02282203f, 0.04154997f, -0.05978242f, -0.22008692f, -0.10757982f, -0.10738337f, 
    0.03165809f, 0.00602621f, -0.16382816f, 0.03332368f, -0.45646492f, -0.11746869f, -0.08738313f, -0.06152675f, 
    -0.12833323f, -0.37878436f, 0.04921449f, 0.14103024f, -0.12049520f, -0.30800363f, -0.06515671f, -0.15277824f, 
    0.06423626f, -0.34727550f, -0.00474939f, 0.03941854f, -0.04838178f, -0.03210029f, -0.28122923f, 0.07093081f, 
    -0.16080576f, 0.21041083f, 0.12470587f, -0.04197727f, 0.04515398f, 0.05686278f, 0.29375795f, -0.10535326f, 
    -0.13195968f, 0.08588400f, -0.11967129f, -0.10825731f, 0.47332585f, 0.20261647f, 0.28069583f, 0.04906471f, 
    -0.05796947f, 0.06547283f, -0.53244936f, -0.14631638f, -0.07252359f, -0.07871857f, 0.11801697f, 0.13180737f, 
    0.21391760f, 0.09008133f, -0.06491417f, -0.16390862f, 0.11463510f, 0.04605345f, -0.42066580f, 0.01848565f, 
    0.13223208f, 0.00503029f, -0.12840001f, -0.25931230f, 0.25136828f, 0.10268152f, -0.06599283f, -0.02076319f, 
    -0.32992119f, 0.04863232f, -0.16483606f, 0.03650219f, 0.27860135f, -0.50073510f, -0.03352835f, -0.04074797f, 
    0.51566654f, 0.06752615f, 0.01456334f, 0.03829161f, 0.15872374f, -0.20936927f, 0.18846984f, 0.33157492f, 
    -0.32621264f, -0.00847480f, 0.20485382f, -0.04328337f, -0.03965632f, 0.14538360f, -0.04713131f, -0.24995002f, 
    0.08983360f, 0.05092170f, -0.41055566f, -0.11863995f, -0.03483668f, -0.06485628f, -0.08142618f, -0.08894689f, 
    -0.18481307f, 0.02922052f, -0.04727017f, 0.09918831f, 0.18754233f, 0.06893311f, 0.01572665f, 0.11598665f, 
    0.17429064f, 0.28650066f, -0.16707928f, -0.07006351f, 0.07572062f, 0.09706416f, 0.00473203f, -0.10018463f, 
    -0.07860662f, 0.22861315f, 0.02152752f, 0.04765645f, 0.04224515f, 0.01122812f, -0.49628559f, 0.01086493f, 
    0.13575056f, 0.03598241f, -0.04202116f, 0.04117802f, -0.34609124f, 0.09113415f, 0.18200794f, -0.08948080f, 
    0.20978449f, 0.00597675f, 0.00650430f, -0.04700040f, 0.10169668f, -0.14871207f, -0.33528492f, 0.16893969f, 
    0.20787126f, -0.03262137f, -0.25918776f, -0.09012267f, -0.08198214f, -0.05168579f, -0.01664862f, 0.10365871f, 
    0.10693745f, -0.00450539f, -0.03558625f, 0.00204880f, 0.20534208f, -0.07068969f, -0.04056088f, 0.30474225f, 
    0.06855567f, 0.18125205f, 0.01388979f, 0.00748034f, 0.03592368f, -0.12588643f, 0.10012786f, -0.00966174f, 
    0.28993511f, 0.21457735f, 0.12803945f, -0.03667680f, 0.16237138f, -0.43384326f, -0.09651344f, -0.00828901f, 
    0.14945820f, -0.06691615f, 0.12670417f, -0.19175905f, 0.04597422f, 0.07728604f, 0.04829288f, -0.03690623f, 
    0.02983510f, 0.21431626f, -0.26294535f, -0.05167642f, -0.02571646f, 0.27601039f, -0.29656145f, -0.18464048f, 
    0.12482257f, -0.09022676f, -0.06264080f, 0.05584646f, -0.00909466f, 0.28305987f, -0.11587658f, 0.09983147f, 
    0.30217460f, 0.05779726f, -0.06448915f, 0.30543596f, -0.02560302f, 0.11595091f, -0.04926853f, 0.22889830f, 
    0.25660560f, 0.15959816f, 0.11630756f, 0.00298788f, -0.01508145f, -0.13164647f, -0.01767315f, -0.06053092f, 
    -0.06002855f, 0.17908987f, 0.12039257f, -0.08951698f, 0.00462524f, -0.03248468f, 0.17716974f, -0.02016391f, 
    0.04574405f, -0.15065964f, 0.02570201f, 0.11526858f, -0.11471505f, -0.21275012f, -0.04606995f, 0.14485295f, 
    0.08652784f, 0.03204352f, 0.29284009f, 0.10772841f, 0.13961691f, 0.11779667f, 0.09527025f, -0.07762904f, 
    0.19499116f, -0.13598521f, 0.23410472f, 0.04079630f, -0.04480210f, -0.07796794f, -0.04092775f, -0.24403755f, 
    -0.10492562f, 0.12146221f, 0.13489403f, -0.04541299f, -0.03421358f, 0.09699150f, 0.10046928f, 0.10063604f, 
    -0.07848606f, -0.09717115f, -0.11098535f, -0.12357835f, 0.16815422f, -0.04312794f, -0.34142563f, -0.11301670f, 
    -0.14144939f, 0.03546791f, 0.03668389f, -0.18923461f, -0.38678443f, 0.25452712f, 0.05224827f, 0.05544502f, 
    -0.49370238f, -0.00281586f, 0.06842176f, 0.05809978f, -0.49441552f, -0.45752612f, -0.19387536f, 0.15592214f, 
    0.09485695f, 0.08282138f, -0.27281040f, 0.10085697f, 0.12509604f, -0.13704506f, 0.10327666f, -0.00697112f, 
    -0.00737830f, 0.01903949f, 0.03988772f, 0.11110854f, 0.02519077f, -0.05495856f, -0.07958919f, -0.07104213f, 
    -0.02887402f, -0.11715831f, -0.08457986f, 0.10329638f, -0.06809404f, -0.12845457f, 0.08108743f, 0.11530238f, 
    -0.12765199f, 0.01092419f, -0.04894670f, -0.08798224f, 0.05357976f, -0.09706092f, 0.10805163f, 0.08799792f, 
    0.04065258f, -0.02942146f, 0.00587392f, -0.03471392f, -0.07214271f, -0.04644855f, 0.07223275f, -0.10322941f, 
    0.05144230f, 0.01200301f, 0.02467134f, -0.12909111f, -0.02529366f, 0.04450794f, -0.05547105f, 0.09675270f, 
    0.09811237f, 0.10895710f, -0.07344405f, -0.12609200f, 0.06554941f, -0.09791535f, -0.15279680f, -0.09258930f, 
    -0.08404534f, -0.05773877f, -0.02347289f, -0.03148765f, -0.13650323f, -0.02630318f, -0.01741041f, 0.03700937f, 
    -0.03774786f, -0.08742728f, 0.03684777f, -0.17283286f, -0.08606779f, -0.02993927f, -0.03720534f, -0.05375380f, 
    -0.25173983f, 0.22505160f, 0.23067483f, 0.09841961f, -0.09328239f, -0.08027378f, 0.13109982f, 0.12530896f, 
    0.11225018f, 0.04195720f, -0.37454498f, 0.01783178f, -0.02170380f, -0.23589860f, 0.28359324f, -0.03210476f, 
    -0.15094705f, 0.16492160f, -0.37514520f, -0.07412253f, 0.09556898f, 0.10397197f, 0.01433219f, -0.00468151f, 
    0.11169142f, 0.02449498f, 0.42395109f, -0.03228145f, -0.04584956f, 0.03425769f, 0.07327030f, 0.31965458f, 
    0.19276001f, 0.04461898f, -0.20243865f, -0.08336813f, 0.17346926f, 0.22154890f, -0.35156479f, -0.11201693f, 
    -0.35388234f, -0.01223966f, -0.48996153f, 0.08752313f, 0.08249351f, -0.13057300f, 0.04570429f, -0.37766320f, 
    0.08992431f, 0.08375905f, 0.25398737f, 0.15207721f, -0.09896887f, -0.23531361f, 0.05944128f, 0.36686400f, 
    0.20274110f, 0.19205377f, 0.14138803f, -0.29600927f, -0.01710791f, 0.04125904f, 0.09260054f, -0.37468758f, 
    0.05399851f, 0.17106463f, 0.11739056f, -0.03930838f, 0.07104285f, 0.31001878f, 0.45270357f, 0.04951066f, 
    -0.00807858f, 0.09575268f, 0.21989819f, -0.02058315f, 0.20437144f, 0.01301982f, -0.15677728f, 0.10761568f, 
    -0.28450292f, 0.15788464f, 0.04686873f, -0.00411095f, 0.01058130f, 0.04082864f, -0.10876280f, 0.15248244f, 
    0.11415628f, 0.05700178f, -0.02343571f, 0.17751749f, -0.11142308f, 0.04183427f, 0.26458195f, -0.08955419f, 
    -0.05030835f, 0.14877133f, -0.18356811f, -0.37658870f, 0.19565119f, -0.25421610f, 0.07625768f, 0.02156786f, 
    0.05433957f, -0.11435829f, 0.21630181f, -0.26015544f, -0.01225293f, 0.19556729f, -0.05277098f, -0.08861443f, 
    0.10531408f, -0.04431085f, 0.16892213f, -0.07493485f, 0.29071978f, -0.06361400f, 0.02646301f, 0.17951654f, 
    0.22557996f, 0.01319514f, 0.14359157f, 0.14382832f, 0.03011257f, 0.04229971f, 0.03433216f, 0.02377131f, 
    0.05550066f, -0.15579557f, -0.21465226f, 0.04184503f, -0.04825530f, 0.08765929f, 0.21759614f, 0.09908007f, 
    -0.18285671f, -0.00336093f, 0.03546362f, -0.05020440f, 0.08439322f, -0.44284481f, -0.17360321f, 0.06500476f, 
    -0.03663811f, 0.18144159f, 0.11010344f, 0.06511074f, -0.05588475f, -0.05717317f, 0.04257381f, 0.03818470f, 
    0.41090962f, 0.27671415f, 0.08114266f, 0.04379979f, 0.08833428f, 0.09115595f, 0.19206469f, 0.19700371f, 
    0.03703513f, -0.12356404f, -0.03103043f, -0.06735826f, -0.23039782f, 0.21161896f, 0.34267658f, -0.00617562f, 
    0.16280326f, 0.03668870f, 0.04268071f, -0.13841753f, 0.40523905f, -0.03328953f, -0.38677165f, -0.07762825f, 
    0.16866705f, 0.03879900f, -0.05464810f, -0.09901797f, -0.03319868f, 0.34261823f, -0.01271564f, 0.23218839f, 
    -0.13423993f, 0.24880280f, 0.01741172f, -0.30129656f, 0.15959772f, -0.01705649f, 0.12296011f, 0.16528276f, 
    0.08397284f, 0.12296838f, 0.08744891f, 0.04543307f, -0.04264430f, -0.12497360f, 0.17499769f, -0.08394669f, 
    0.06891768f, 0.07620794f, 0.15706961f, -0.03128456f, 0.20099290f, 0.23201072f, -0.01894793f, -0.08290031f, 
    -0.07424565f, 0.01594780f, 0.03913285f, -0.25911695f, 0.04539118f, 0.04985607f, -0.06118833f, -0.19831471f, 
    0.00401646f, 0.01090212f, 0.01242002f, -0.16890393f, -0.02337825f, 0.04799594f, 0.16506141f, -0.25994125f, 
    0.14319301f, -0.08211431f, -0.24442828f, -0.10743628f, 0.26527694f, -0.03926568f, -0.27748719f, -0.12122999f, 
    -0.07448635f, 0.02660518f, -0.00629647f, 0.06015056f, 0.07182664f, 0.07551657f, 0.18166219f, -0.11449703f, 
    0.11597785f, 0.20404844f, 0.13423139f, 0.14621386f, 0.06862596f, -0.35669294f, -0.18475126f, 0.10663371f, 
    -0.18963224f, -0.03143144f, 0.12752920f, 0.01028820f, 0.41176268f, -0.20310250f, 0.08629496f, -0.06491370f, 
    -0.20318685f, 0.20904385f, 0.20587845f, 0.02730577f, -0.07200584f, -0.02835558f, 0.04440635f, 0.28801277f, 
    -0.11789668f, -0.02369243f, -0.15907003f, -0.07863489f, -0.16665649f, 0.18405327f, 0.41357344f, -0.01467545f, 
    -0.08875276f, 0.24653102f, -0.06160146f, 0.17284901f, -0.11702874f, 0.03226949f, 0.10814308f, -0.01600440f, 
    0.05551049f, -0.13377623f, 0.10423611f, 0.31575862f, -0.08576960f, 0.04150863f, -0.16022274f, 0.35894901f, 
    0.01565299f, -0.02109199f, -0.11622266f, 0.15197967f, 0.06815460f, 0.09189996f, -0.24528119f, -0.11192844f, 
    0.01850640f, 0.12836118f, -0.14653856f, 0.00610870f, -0.18555512f, -0.13022763f, 0.18957518f, -0.41737133f, 
    -0.07106994f, 0.00196636f, 0.12401184f, -0.17498837f, -0.05675195f, 0.10168851f, 0.19988012f, -0.00686273f, 
    0.26511526f, 0.00088971f, 0.00258146f, -0.02294165f, -0.02891298f, 0.24885687f, -0.01562391f, -0.14921919f, 
    -0.05139235f, -0.12058776f, -0.18442184f, -0.00258346f, -0.04510283f, -0.12703449f, 0.22406039f, 0.10283239f, 
    0.03006094f, -0.12527953f, -0.07564588f, 0.05158760f, 0.19622549f, -0.02923412f, 0.10923727f, -0.05271815f, 
    -0.16323151f, 0.23910980f, 0.06619697f, -0.05620848f, 0.08553584f, -0.01469892f, -0.10221346f, -0.35397369f, 
    0.05119655f, -0.06864438f, 0.03974571f, 0.05162677f, 0.01715729f, 0.11418784f, 0.31734216f, 0.26772127f, 
    0.03442869f, -0.11985177f, -0.16042310f, -0.10971183f, 0.08947999f, -0.02316426f, -0.03492697f, -0.04906609f, 
    -0.09105378f, -0.03580166f, -0.13796709f, -0.21852712f, 0.09279512f, 0.13569359f, -0.12041792f, -0.03207329f, 
    0.20364310f, 0.13436143f, -0.07707126f, 0.09304553f, -0.04375063f, -0.52815092f, 0.10159574f, 0.15938376f, 
    0.06829585f, 0.02456422f, -0.05113072f, 0.02448722f, 0.18332519f, -0.04588048f, 0.14243874f, 0.10332187f, 
    -0.08126292f, 0.00848634f, -0.10232690f, 0.08458493f, -0.06957147f, 0.27746257f, 0.14259851f, 0.04198376f, 
    0.31604788f, 0.07771317f, -0.11724498f, -0.05255654f, 0.22092739f, 0.10199936f, 0.05273260f, 0.00925142f, 
    0.10549934f, 0.16642582f, -0.07070739f, 0.05255476f, 0.07586014f, -0.03608832f, 0.04443065f, -0.03201214f, 
    0.27417251f, 0.08823631f, -0.32848501f, -0.13258238f, 0.02096687f, -0.17705242f, 0.23050174f, 0.21732017f, 
    -0.12566516f, -0.29857203f, -0.02245070f, -0.05176510f, -0.07007610f, 0.19533859f, 0.38380086f, -0.10474456f, 
    -0.08770300f, -0.11502255f, 0.08228627f, 0.20898768f, 0.32104889f, 0.00935871f, -0.13941070f, -0.09775981f, 
    0.12732489f, 0.23264809f, -0.09636113f, -0.10638988f, 0.11516987f, 0.34147865f, 0.18485230f, -0.40993768f, 
    -0.03632861f, -0.28936431f, 0.26873788f, -0.00535467f, -0.18057917f, -0.01736678f, -0.22833683f, 0.16471554f, 
    0.00125698f, 0.07691672f, 0.22360240f, 0.05269313f, -0.00253163f, 0.00753951f, -0.16638632f, 0.15157598f, 
    0.27706817f, 0.20730413f, -0.14981203f, -0.09284799f, -0.47473034f, 0.12655233f, -0.17871265f, -0.09326059f, 
    -0.15584858f, -0.21680017f, 0.10109871f, 0.10425296f, 0.03186012f, 0.05367571f, 0.10199517f, -0.05031229f, 
    0.05676724f, -0.14623071f, 0.06978861f, 0.20608367f, 0.08847663f, 0.03641665f, 0.38036159f, 0.14039032f, 
    0.11394358f, -0.09531767f, -0.16731639f, 0.05881285f, 0.21088861f, 0.03208117f, -0.06191073f, -0.07327528f, 
    -0.13819477f, 0.08755268f, -0.00573963f, -0.25139573f, -0.01179979f, -0.32355335f, 0.27386039f, -0.04371319f, 
    -0.15273526f, -0.05470946f, 0.22049786f, -0.06558653f, -0.03280945f, 0.09005967f, 0.07543137f, -0.15962924f, 
    0.32828230f, 0.20141847f, 0.07619385f, 0.27891421f, -0.16179761f, 0.12571721f, 0.30655950f, -0.06623229f, 
    0.07236630f, -0.15393654f, 0.08751429f, 0.07079574f, 0.08062255f, -0.01810632f, -0.09964775f, -0.08741960f, 
    -0.05446976f, -0.11618491f, 0.14499800f, 0.04628624f, -0.15745275f, 0.01516395f, -0.06379007f, 0.03545763f, 
    -0.08917989f, -0.12819920f, -0.02499445f, 0.09997690f, 0.12565364f, 0.05825859f, 0.03764889f, -0.16874579f, 
    0.12670481f, 0.11782598f, 0.19372876f, -0.09746031f, 0.08360825f, 0.10817678f, 0.51974732f, 0.25504595f, 
    0.05163867f, 0.09516861f, -0.13434874f, 0.31617257f, 0.31845185f, 0.18229765f, -0.00368178f, -0.04511866f, 
    0.37885725f, -0.01488644f, -0.03154046f, -0.28064984f, -0.02055797f, 0.15095219f, 0.08855994f, -0.04802088f, 
    -0.40327963f, -0.11638452f, 0.05943223f, -0.07393692f, -0.60255897f, 0.20063725f, -0.04680568f, -0.09858768f, 
    0.21460472f, 0.10942901f, -0.30728969f, -0.23331173f, 0.06296823f, 0.08510159f, 0.24664800f, 0.00112004f, 
    0.02546011f, 0.03757229f, -0.55697018f, -0.02169602f, -0.01516606f, 0.27929470f, 0.14973578f, 0.12220270f, 
    0.06930092f, -0.00778711f, -0.06987868f, -0.00131639f, -0.26629215f, -0.49150714f, -0.25200316f, -0.07365189f, 
    -0.17009395f, -0.17238599f, 0.29503173f, -0.10463153f, 0.09212837f, 0.05204471f, 0.01176479f, 0.22310267f, 
    -0.00661707f, 0.09503385f, -0.11539814f, 0.35569146f, -0.02828546f, -0.00366885f, -0.23563300f, 0.11741148f, 
    0.01576981f, 0.01641979f, -0.12952961f, 0.07485419f, 0.01411053f, -0.06687658f, 0.08177572f, -0.02565250f, 
    0.17196415f, 0.01086732f, 0.17549442f, -0.16192433f, -0.09028310f, -0.04580806f, -0.09018646f, -0.18969975f, 
    -0.06510112f, 0.20560403f, 0.12761617f, -0.25062308f, -0.00749849f, 0.37186918f, 0.13005398f, -0.00610086f, 
    0.19262004f, 0.03232500f, -0.01266072f, 0.15323445f, -0.10113955f, 0.11316789f, 0.32468513f, 0.20097664f, 
    0.09851442f, -0.12113282f, 0.05800523f, -0.04576463f, 0.10543370f, 0.17832124f, 0.36573142f, -0.01622675f, 
    0.12704581f, 0.00221521f, 0.28593606f, 0.02414955f, 0.35908678f, -0.44073066f, -0.41360092f, -0.03917865f, 
    -0.24405847f, -0.24421066f, -0.06782843f, -0.04863816f, -0.11846264f, -0.04167773f, -0.06301796f, 0.17021732f, 
    0.18038470f, 0.23346372f, -0.08620356f, 0.10055604f, 0.03469431f, 0.16810022f, 0.08483858f, -0.30545133f, 
    -0.19477119f, 0.33976144f, -0.23761559f, -0.28609192f, -0.03722456f, 0.24302894f, 0.09666744f, -0.08429410f, 
    0.13179177f, 0.00619842f, 0.28442618f, -0.05820792f, 0.04539714f, 0.04133283f, -0.22147261f, 0.15381014f, 
    0.28094843f, 0.07506694f, 0.10916652f, 0.12464477f, -0.12596190f, -0.02406305f, -0.10904786f, -0.10005774f, 
    0.04670597f, 0.13991004f, 0.06754051f, 0.18797378f, 0.19057389f, -0.08805929f, -0.15892535f, 0.00524138f, 
    0.19557492f, 0.18186381f, 0.00039174f, 0.10783166f, -0.00375555f, -0.06916344f, 0.02139018f, -0.26633218f, 
    0.30319822f, 0.22739534f, 0.14799583f, 0.12158568f, -0.17368931f, -0.31801739f, -0.12477244f, 0.08718443f, 
    0.16009940f, -0.10288781f, 0.20888261f, -0.15330727f, -0.10953856f, -0.09052136f, 0.01698172f, 0.17495471f, 
    -0.25324678f, 0.18238482f, -0.25627258f, 0.04677458f, -0.05002850f, 0.15210420f, -0.45178440f, -0.18682319f, 
    0.30492276f, 0.22502384f, -0.13201068f, 0.27493435f, -0.52590030f, 0.23709795f, 0.11034841f, -0.04457457f, 
    0.26516727f, 0.09700468f, 0.04212119f, 0.00484625f, -0.17590362f, -0.23153202f, 0.16045694f, 0.32339761f, 
    -0.12863100f, 0.26829442f, -0.15377650f, -0.18866089f, -0.06553569f, 0.11483756f, 0.29352888f, 0.07920524f, 
    -0.05012609f, 0.09654848f, -0.07645456f, -0.04469521f, 0.04371649f, -0.03961613f, 0.15170893f, 0.15971255f, 
    0.14792301f, -0.11496988f, -0.07418779f, -0.06001536f, -0.07146462f, 0.06002399f, -0.17508765f, -0.20416771f, 
    -0.33491504f, 0.05872107f, 0.30797371f, 0.06914758f, 0.15747942f, 0.30138779f, 0.17987217f, 0.08151115f, 
    0.09620074f, 0.16045457f, -0.24859093f, 0.14679565f, -0.07728885f, -0.07311355f, -0.12224329f, 0.08365623f, 
    0.08495360f, 0.12389065f, -0.07446489f, -0.20798996f, -0.00966186f, -0.08781958f, -0.42440358f, -0.17935871f, 
    -0.06456538f, 0.09005762f, 0.14167395f, 0.07876192f, -0.00081453f, 0.08773068f, 0.11196019f, -0.06458905f, 
    -0.05355302f, 0.00265252f, 0.07752953f, -0.02994531f, 0.16710921f, -0.04533504f, -0.07004315f, 0.07967929f, 
    0.12326234f, -0.03605194f, -0.26212436f, -0.13253704f, 0.13973993f, 0.10561155f, 0.11634202f, -0.06087948f, 
    -0.39847058f, -0.28321007f, 0.06470399f, -0.01894092f, 0.04079795f, 0.03678319f, -0.03125297f, 0.10036366f, 
    0.03226837f, 0.17140089f, -0.24428123f, -0.06036812f, -0.02181569f, 0.31011212f, 0.38289988f, -0.26043630f, 
    -0.07806373f, 0.18494086f, 0.08308718f, -0.08762819f, 0.12486655f, 0.06638089f, -0.35463938f, -0.01723718f, 
    -0.10736164f, 0.04261718f, 0.04047327f, -0.18675530f, -0.01795124f, -0.01340414f, 0.10024054f, -0.01173670f, 
    0.02613778f, -0.02946345f, -0.06524705f, 0.21682657f, -0.12303416f, 0.04640033f, 0.26323688f, 0.03831959f, 
    -0.00915318f, 0.20099084f, 0.05867570f, -0.10309663f, -0.29586551f, -0.03170092f, 0.27887097f, 0.08507960f, 
    0.19134466f, 0.06597456f, 0.21779487f, -0.18169188f, -0.03490474f, 0.20069730f, -0.09404140f, 0.05624550f, 
    0.09822320f, -0.01363167f, -0.28637755f, -0.18193185f, 0.27956194f, 0.07735964f, 0.14786386f, 0.02911212f, 
    0.13481469f, -0.08623081f, 0.24422035f, 0.25126347f, -0.00869658f, 0.11843815f, -0.02742809f, 0.17499563f, 
    0.21928012f, -0.03729323f, -0.21908429f, 0.03504045f, 0.10436900f, -0.13441479f, -0.26219159f, -0.03231262f, 
    0.06665538f, 0.13924165f, 0.13025932f, 0.04595725f, -0.22676328f, -0.02049359f, 0.04727301f, -0.12363815f, 
    0.16451620f, -0.01022068f, -0.09658027f, -0.19399460f, -0.02925988f, -0.01924535f, -0.09745982f, -0.37265679f, 
    -0.00990947f, 0.17174417f, 0.07939350f, -0.06158390f, -0.04450619f, 0.21309793f, -0.07268561f, 0.07440088f, 
    0.06850389f, -0.28912205f, 0.06291934f, 0.38527429f, -0.14662957f, 0.04412491f, 0.07249470f, -0.11566307f, 
    0.17533056f, -0.04412157f, -0.19588149f, 0.00897610f, 0.16153596f, -0.16251813f, 0.06211055f, -0.05572248f, 
    -0.01996591f, 0.10299657f, -0.06398242f, 0.00808509f, -0.08994026f, -0.17018220f, 0.05371382f, 0.05928323f, 
    0.02776152f, 0.09309391f, -0.34875178f, -0.18562599f, 0.39308071f, -0.36039764f, 0.19547758f, 0.05462163f, 
    0.03923330f, 0.01243017f, -0.14034550f, 0.01775435f, 0.01311634f, 0.10505835f, 0.27389976f, 0.08923872f, 
    0.20762914f, 0.02796665f, -0.19260742f, 0.09348205f, -0.03585630f, -0.23574100f, -0.28527457f, -0.04882751f, 
    -0.20176788f, 0.06176746f, 0.19526328f, -0.16115244f, -0.02145430f, 0.07990555f, -0.12340153f, -0.02714684f, 
    0.09810288f, 0.05394822f, 0.20704858f, 0.10382125f, -0.02506341f, 0.05144698f, 0.54985183f, -0.02341137f, 
    -0.07546967f, 0.08880382f, -0.08178119f, -0.26968101f, 0.30287558f, -0.02797826f, 0.03644868f, -0.01187675f, 
    -0.05635928f, 0.06479725f, 0.06498966f, -0.18571614f, -0.07200801f, 0.22088547f, 0.08892169f, -0.02703068f, 
    0.12889466f, 0.02924607f, 0.12731956f, 0.07336824f, 0.13439094f, 0.15249367f, -0.10471340f, 0.23283608f, 
    0.09049369f, 0.14922038f, 0.10722309f, 0.10035120f, 0.12108435f, -0.18800630f, 0.19128683f, -0.02588111f, 
    -0.14896321f, 0.00208721f, -0.08207782f, 0.12848659f, 0.10848981f, 0.19494303f, -0.15392891f, 0.02880944f, 
    -0.09955698f, 0.19788501f, 0.14537786f, 0.03817479f, -0.28862581f, 0.18602021f, -0.03104064f, -0.11233565f, 
    -0.03233635f, 0.12536222f, 0.11170787f, -0.01601410f, 0.04792006f, -0.01602446f, 0.03068026f, 0.12176187f, 
    0.21485697f, -0.03725410f, -0.26886904f, -0.12090403f, 0.05181043f, -0.16792452f, 0.39371610f, 0.11224452f, 
    -0.04707491f, -0.11047875f, 0.02910904f, 0.05480805f, 0.17721289f, -0.01283477f, 0.34246287f, -0.08624002f, 
    0.23018995f, -0.01360606f, 0.22701250f, -0.02942220f, 0.05679772f, -0.00831966f, -0.05055096f, -0.06018321f, 
    0.04424777f, 0.18171585f, -0.06794222f, -0.30408570f, 0.29196757f, 0.34735453f, -0.09626858f, -0.64495230f, 
    -0.06601623f, 0.00984919f, 0.08282924f, 0.22866483f, -0.06042067f, -0.06379762f, 0.03127032f, 0.16370913f, 
    -0.06043180f, 0.13565002f, -0.28516665f, -0.05292215f, 0.01060921f, 0.19097568f, -0.02327576f, 0.08582815f, 
    0.33848310f, 0.06110002f, -0.29940584f, 0.07775359f, -0.22944346f, -0.36758500f, -0.04068126f, -0.06510781f, 
    -0.03635414f, -0.05864733f, 0.18843608f, 0.13523631f, -0.02044436f, 0.05950853f, 0.00243433f, 0.08209401f, 
    -0.10324523f, -0.00166343f, -0.18292245f, 0.19589615f, 0.01823045f, 0.05683073f, -0.14723691f, 0.27458698f, 
    0.17491181f, 0.09455660f, -0.14376907f, 0.23967282f, -0.28031796f, 0.26327115f, 0.09593665f, 0.08669759f, 
    0.09871448f, 0.10688780f, 0.08214874f, 0.00531320f, -0.30757689f, -0.04858772f, 0.18507582f, 0.08746014f, 
    -0.13785042f, 0.16897571f, 0.22939268f, -0.18390380f, -0.16494496f, 0.16936494f, 0.16512917f, -0.27661067f, 
    0.31099233f, -0.01318452f, 0.00453163f, 0.15910164f, -0.32284293f, 0.12045498f, 0.16703275f, -0.09155499f, 
    -0.11437237f, -0.07787133f, -0.03486008f, 0.02814229f, 0.08215760f, -0.00831889f, -0.15222056f, -0.02296940f, 
    -0.05783045f, 0.09345967f, -0.02966847f, 0.03236018f, -0.01596697f, -0.12570429f, -0.02987679f, 0.01085057f, 
    -0.13491961f, -0.07891084f, -0.12467299f, -0.12082300f, 0.00663654f, 0.09417271f, 0.11397501f, 0.01335616f, 
    0.02312482f, -0.00783604f, -0.13955899f, -0.09744705f, -0.05333024f, -0.04723271f, 0.09402380f, -0.04901015f, 
    -0.05132487f, -0.04471061f, 0.05313769f, -0.15127881f, -0.11528704f, -0.11837799f, -0.08672516f, 0.04482463f, 
    -0.03200134f, -0.11308870f, 0.06794144f, -0.01799534f, 0.01245219f, 0.07862297f, -0.00238844f, 0.00737782f, 
    -0.07469970f, -0.10959862f, 0.08640217f, -0.13798343f, 0.07754047f, 0.06430253f, 0.08200663f, 0.05272808f, 
    -0.03625873f, -0.12007845f, -0.05125923f, -0.03263845f, -0.15737498f, -0.08625279f, -0.09495088f, -0.05926716f, 
    0.13430440f, 0.08250152f, -0.12637977f, -0.02537734f, 0.03512550f, 0.05792722f, -0.17159176f, 0.14799051f, 
    -0.10921109f, 0.18219838f, 0.18502277f, -0.05431183f, -0.13280548f, 0.00571002f, 0.09485008f, -0.11625443f, 
    -0.16416399f, -0.20937929f, 0.13133624f, 0.33872777f, 0.09037974f, -0.01693245f, 0.12758985f, -0.08876096f, 
    -0.06307899f, 0.32607371f, -0.13478673f, 0.23024763f, -0.07755470f, -0.05258757f, -0.58852357f, -0.01148228f, 
    0.13742994f, -0.07941611f, -0.26392141f, 0.23175128f, 0.31756431f, 0.17445225f, -0.13591279f, 0.10386884f, 
    -0.14357722f, 0.06749087f, 0.01149330f, -0.10222225f, -0.16799456f, -0.41450301f, -0.03015184f, -0.29505894f, 
    -0.20156226f, 0.14277683f, 0.36164603f, -0.12391184f, -0.19354191f, -0.02154933f, 0.00369067f, 0.03404593f, 
    0.20436402f, 0.25245205f, -0.21738198f, 0.04554669f, 0.20846471f, 0.07000578f, 0.29971170f, 0.14476520f, 
    -0.27493957f, 0.04457084f, -0.01366501f, -0.10464859f, 0.09087075f, 0.08625828f, 0.06639787f, -0.00291356f, 
    0.06868767f, 0.26787013f, 0.12306563f, -0.09245382f, -0.33202884f, -0.07213430f, -0.15482385f, 0.05425660f, 
    0.13568646f, 0.12934376f, -0.23402989f, 0.07074197f, -0.07466482f, 0.10071550f, -0.06214710f, 0.30475834f, 
    0.07731452f, -0.24052638f, -0.10499640f, 0.01277285f, 0.07491175f, -0.15052557f, 0.32349455f, -0.02916606f, 
    0.09329254f, 0.02141810f, -0.14016525f, 0.18384640f, -0.18126355f, 0.21936040f, 0.40508083f, 0.00598093f, 
    0.32934386f, 0.00049400f, 0.03064578f, 0.15887274f, 0.17398416f, 0.06716612f, 0.31475329f, 0.09701044f, 
    -0.03857407f, 0.09468641f, -0.16491967f, -0.25603035f, 0.30698058f, 0.35672742f, 0.23640572f, -0.39627069f, 
    -0.11104017f, 0.07080492f, 0.23986629f, -0.00114612f, -0.14317341f, 0.22178209f, -0.16199344f, -0.10275050f, 
    -0.07314220f, -0.01573163f, -0.09896200f, -0.03488683f, -0.06423423f, -0.08515546f, 0.07902015f, 0.05918181f, 
    0.36878046f, 0.13011524f, -0.29858515f, -0.09893867f, -0.39202857f, 0.07020049f, 0.14920571f, 0.06413583f, 
    -0.16358365f, 0.16648494f, 0.26375678f, -0.21124281f, 0.01342535f, -0.09258653f, -0.04169787f, -0.01027159f, 
    0.09916915f, -0.16033807f, -0.03304407f, -0.06116440f, 0.08472965f, -0.02213744f, 0.31915525f, 0.36973345f, 
    0.01526587f, -0.37950930f, -0.12636262f, 0.19826058f, 0.25641865f, 0.18858951f, 0.05141396f, -0.05403408f, 
    -0.20667824f, -0.09186961f, -0.22860146f, 0.32767758f, 0.18073484f, -0.19549459f, 0.02260619f, -0.21642031f, 
    0.04447604f, 0.29106534f, 0.10022222f, -0.01172224f, 0.10041687f, -0.00221878f, -0.01726224f, -0.41962945f, 
    0.12134489f, -0.10628819f, 0.22793896f, 0.06854028f, 0.09398342f, -0.07444441f, 0.14045832f, -0.02684009f, 
    -0.11706838f, -0.11527498f, -0.13234189f, -0.11580428f, 0.09386922f, -0.13099717f, 0.06109248f, -0.12276300f, 
    -0.08673109f, -0.04089424f, -0.03913917f, -0.08533084f, -0.11679242f, -0.02354481f, -0.07148723f, -0.01185352f, 
    -0.15517096f, -0.06279269f, 0.01698727f, 0.01245168f, 0.01627241f, 0.09131508f, -0.11106274f, -0.15441553f, 
    -0.19333440f, 0.06839371f, 0.02375658f, -0.14497685f, -0.09077533f, 0.08492108f, 0.07098404f, 0.00932934f, 
    -0.04421264f, -0.07721474f, 0.11115493f, 0.00466671f, 0.00146852f, 0.08059324f, -0.09990947f, -0.09634431f, 
    0.05297390f, 0.11330821f, -0.11777862f, -0.17397603f, 0.00774755f, -0.07517925f, 0.11765140f, -0.10941700f, 
    -0.01240189f, -0.06033227f, 0.05592690f, -0.04587806f, -0.06039290f, 0.01308153f, 0.10618498f, -0.14929819f, 
    -0.16126916f, -0.08063928f, 0.05270265f, -0.03695056f, 0.04635094f, -0.15490776f, -0.15897541f, 0.01424437f, 
    0.02823478f, -0.05913996f, -0.08860386f, 0.00404028f, -0.09936127f, 0.14100534f, -0.09566675f, 0.04187679f, 
    -0.03495155f, -0.10879352f, -0.08285630f, 0.05894973f, -0.12364625f, 0.01827640f, -0.11679992f, -0.06273791f, 
    -0.20416211f, 0.03279074f, -0.06291156f, 0.08641233f, 0.11546360f, 0.08176193f, 0.07299070f, -0.09428316f, 
    0.16400568f, 0.06102920f, 0.04982165f, 0.03466470f, -0.07271831f, 0.11248451f, 0.16329414f, -0.03175082f, 
    -0.02665401f, -0.00311569f, -0.01795143f, 0.01171397f, -0.13281003f, -0.00891832f, 0.02041434f, 0.03743151f, 
    -0.11092493f, 0.05272737f, -0.05093612f, -0.13327064f, 0.03373630f, -0.08342578f, -0.10352647f, -0.02778120f, 
    -0.00023651f, -0.02810044f, -0.05126320f, -0.11459655f, -0.12640613f, 0.11291103f, -0.03470886f, -0.03049689f, 
    0.00678276f, 0.03209915f, -0.06398054f, -0.03294342f, -0.05049374f, -0.01099131f, 0.11345360f, 0.05630694f, 
    0.02023588f, 0.19279650f, 0.07887440f, -0.05867790f, -0.10775921f, -0.08601458f, 0.07712205f, -0.21068534f, 
    0.05958343f, 0.18130356f, 0.32129300f, -0.10200857f, 0.05388295f, 0.18066375f, 0.30675301f, -0.05378478f, 
    0.12978755f, -0.08528520f, 0.07814503f, -0.14591616f, 0.09613761f, -0.12214720f, -0.11933019f, -0.01379734f, 
    -0.09543673f, 0.03559474f, -0.29512301f, -0.06321630f, -0.00048232f, 0.23213334f, -0.32426500f, -0.14437740f, 
    0.15793134f, 0.03247749f, -0.40699241f, -0.00287360f, 0.21415472f, 0.17534868f, -0.04712145f, 0.01862921f, 
    0.03838358f, -0.02529560f, -0.09496071f, 0.18775856f, 0.08501694f, -0.35980156f, 0.14125457f, -0.14385401f, 
    0.20608535f, 0.24245018f, 0.09713467f, 0.05285877f, -0.08119974f, -0.34206611f, -0.04273906f, -0.30312589f, 
    -0.11375663f, 0.03626797f, 0.02930126f, -0.08290751f, 0.18200907f, -0.11249955f, 0.07113540f, -0.23968653f, 
    0.06162410f, 0.02323608f, 0.09301974f, 0.06635891f, -0.07081653f, -0.30273476f, -0.14524630f, -0.04149647f, 
    0.13315153f, 0.11710259f, 0.28113097f, 0.09381325f, -0.01816851f, 0.29390535f, 0.18314752f, 0.01395513f, 
    -0.10638306f, -0.19264765f, 0.05831069f, -0.18439160f, 0.03176032f, 0.11782841f, 0.08217596f, -0.04344544f, 
    -0.17244108f, 0.02215853f, 0.18623678f, -0.05479413f, 0.05065897f, 0.12970704f, -0.03910362f, -0.13216303f, 
    -0.02377461f, -0.22506754f, -0.12380534f, 0.10988969f, 0.19132830f, 0.02500359f, -0.34607255f, 0.04575906f, 
    0.16171710f, 0.00122643f, -0.12976322f, -0.10195211f, -0.09243181f, -0.07812428f, 0.30626109f, -0.12876621f, 
    -0.06833772f, 0.13670725f, 0.23158596f, 0.05567307f, 0.09168667f, -0.08191200f, -0.04583124f, 0.03135809f, 
    -0.03657632f, 0.26719233f, -0.00190290f, 0.04475920f, 0.37185368f, -0.17822629f, 0.00749636f, -0.15215369f, 
    -0.11424822f, -0.08282145f, 0.05004052f, 0.04725628f, 0.07764586f, 0.00242276f, 0.21195561f, 0.23503138f, 
    0.04321453f, 0.00199696f, -0.11179864f, -0.10695530f, -0.17793429f, -0.21630690f, -0.04443279f, -0.05667930f, 
    -0.38004285f, 0.05568449f, -0.01998096f, 0.19183140f, 0.01105433f, -0.10023379f, 0.06796630f, 0.03255614f, 
    0.15259518f, -0.00901386f, 0.12533940f, 0.17290369f, -0.11320355f, -0.12445343f, 0.37318853f, 0.09261265f, 
    -0.07304696f, 0.08044258f, -0.31719321f, -0.14837067f, 0.37206614f, 0.07200392f, -0.19306301f, -0.01026429f, 
    -0.32363990f, 0.11638621f, -0.01754284f, -0.12189660f, 0.07086150f, -0.09289254f, 0.00512123f, -0.25646386f, 
    0.16350225f, 0.02228652f, 0.42319873f, 0.18804407f, 0.05747773f, 0.26867017f, -0.11350168f, 0.05904434f, 
    0.11645536f, 0.21030295f, -0.04590732f, 0.06400711f, -0.11954667f, 0.14576051f, 0.03397693f, -0.12891240f, 
    -0.16370910f, -0.12745808f, 0.18535630f, 0.05934035f, -0.01287085f, -0.22634371f, 0.04816554f, 0.10327008f, 
    0.01762942f, -0.11073603f, 0.04982430f, -0.05066258f, -0.14616008f, 0.15433909f, -0.00142868f, -0.04206830f, 
    -0.02169205f, -0.00295649f, 0.15145595f, -0.17857730f, -0.06980911f, 0.01357760f, 0.06257735f, -0.18126656f, 
    -0.20893648f, -0.22622572f, 0.01077773f, -0.11178748f, 0.08398452f, -0.00986059f, 0.11866061f, 0.09955030f, 
    0.08231575f, 0.11316872f, 0.05943931f, -0.02208222f, 0.07026885f, -0.01712556f, -0.06747008f, -0.02715471f, 
    -0.09336995f, -0.05286309f, 0.07478727f, -0.24985896f, -0.08083425f, 0.13353148f, 0.21450178f, 0.00163252f, 
    0.02159874f, -0.04745572f, 0.00685532f, -0.12014131f, 0.01455859f, 0.20394178f, -0.21956506f, -0.20098084f, 
    0.00570456f, -0.07959834f, 0.05962965f, -0.13729131f, 0.18196355f, -0.12119356f, 0.06876346f, -0.09297888f, 
    -0.24899977f, 0.20715973f, 0.07911877f, -0.05506558f, -0.01297408f, -0.14774442f, 0.11066670f, -0.02032396f, 
    0.29567593f, 0.05731351f, -0.18638764f, -0.11293980f, -0.23091637f, -0.25515172f, 0.19853833f, 0.03532057f, 
    0.07180080f, 0.06736096f, -0.15573095f, -0.07963620f, -0.07908197f, -0.08892962f, 0.03856255f, 0.05894253f, 
    0.00016942f, -0.01837987f, -0.06632227f, 0.07310797f, -0.11506660f, 0.07871636f, -0.32268271f, -0.01808940f, 
    0.13355885f, -0.23277162f, -0.19802415f, 0.10870396f, 0.18359856f, 0.32933590f, -0.16001602f, 0.00293240f, 
    0.30451021f, -0.08580181f, -0.36443117f, 0.27430990f, 0.13320082f, -0.07952735f, 0.19886093f, -0.14518121f, 
    0.21377502f, -0.03119646f, 0.09186300f, 0.00533426f, -0.12760763f, -0.17316522f, 0.19862780f, -0.17123489f, 
    -0.00185457f, 0.08389193f, -0.02883194f, -0.33299029f, 0.20531194f, 0.17935595f, 0.20060639f, -0.24112071f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.30985752f, 0.14581624f, -0.07086542f, 0.10565498f, -0.00675379f, -0.04723944f, 0.18961900f, -0.14401916f, 
    -0.18346789f, 0.13450749f, 0.05289901f, -0.10149882f, -0.10638341f, -0.12048437f, -0.01333670f, 0.03638765f, 
    -0.14063378f, -0.00051157f, -0.14993025f, -0.14739282f, -0.00346274f, 0.00934214f, 0.18496211f, -0.01249141f, 
    -0.12191436f, 0.13746063f, -0.07960865f, 0.03711871f, -0.01393808f, -0.07307683f, 0.00406520f, 0.03796542f, 
    0.08730482f, -0.07699304f, -0.12520845f, 0.05057865f, -0.07830853f, 0.14119628f, -0.16289935f, 0.01780414f, 
    0.23560543f, 0.06619134f, 0.00845911f, 0.02378640f, 0.20286302f, 0.10802971f, 0.24739397f, -0.06422497f, 
    0.06939975f, 0.05345854f, -0.15698843f, 0.05192110f, 0.01617484f, 0.09748355f, 0.05593958f, 0.12547915f, 
    0.03942535f, 0.06057332f, -0.05105339f, 0.07694884f, -0.04794824f, -0.01415090f, -0.12378914f, 0.03729646f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04868666f, -0.23548974f, 0.07997557f, 0.03306852f, 0.01988212f, 0.02271661f, -0.09676886f, -0.14870845f, 
    0.09640786f, -0.79698962f, -0.31711528f, 0.27578235f, 0.21219364f, 0.09014340f, 0.24179097f, -0.11716686f, 
    0.04754929f, 0.07175816f, -0.04262734f, 0.08624902f, -0.45204663f, 0.11607297f, -0.33540475f, 0.17333260f, 
    0.18617225f, -0.03490707f, -0.00908871f, 0.10881829f, -0.02128379f, 0.14521387f, 0.16796155f, 0.01659084f, 
    -0.34472939f, -0.04335044f, -0.04477724f, -0.32282770f, 0.11637881f, -0.23190318f, -0.12865129f, 0.06640247f, 
    0.07897132f, 0.17678387f, -0.18608168f, -0.10240405f, -0.26418173f, -0.18721382f, -0.47606629f, 0.11787117f, 
    0.07481652f, 0.08689222f, -0.20357141f, 0.23875041f, -0.35012847f, 0.05524689f, -0.08500269f, 0.03055854f, 
    -0.12643301f, -0.10377382f, -0.02485363f, -0.12225354f, -0.34708932f, -0.06305166f, -0.08279604f, -0.22298390f, 
    0.24770814f, -0.43655124f, 0.08163460f, 0.08194954f, -0.05149791f, -0.53534472f, 0.20216644f, -0.09666612f, 
    0.09006932f, 0.26484096f, 0.28168184f, 0.16871995f, -0.03057430f, -0.48910442f, -1.11639714f, -0.05098042f, 
    -0.13702919f, 0.25588134f, 0.00867760f, -0.00322343f, -0.16159749f, 0.00071851f, -0.35579458f, -0.08043821f, 
    -0.14193881f, -0.25704223f, -0.08917943f, -0.21342883f, 0.00628364f, 0.06451816f, 0.27686554f, 0.06529561f, 
    -0.05911005f, 0.10996743f, 0.04269793f, -0.16388628f, 0.20382382f, 0.18695088f, 0.01706993f, -0.17146148f, 
    0.07506500f, 0.13213056f, -0.44606489f, 0.04884932f, 0.08318678f, 0.25503045f, -0.08190684f, 0.03439842f, 
    0.21623960f, -0.01265690f, 0.12630096f, 0.07682328f, -0.18284822f, -0.07764231f, -0.43440208f, 0.13132776f, 
    -0.51417446f, -0.03134939f, -0.16635861f, -0.45050648f, 0.08863782f, -0.01055597f, -0.10294846f, -0.20253870f, 
    0.23816407f, 0.07041168f, -0.01574403f, 0.18932235f, -0.08794444f, -0.08741488f, 0.02689363f, -0.12388586f, 
    -0.07472887f, -0.48111397f, -0.17571442f, -0.31536409f, -0.33519262f, -0.04657688f, -0.13298461f, 0.02627600f, 
    -0.12046301f, 0.09830451f, -0.02749920f, -0.01078006f, 0.33863690f, -0.05211340f, -0.03375769f, 0.07113823f, 
    0.26930344f, 0.22212383f, -0.12212282f, 0.09997275f, -0.08526091f, 0.16065872f, 0.28786886f, 0.18917647f, 
    0.08034069f, -0.37041864f, 0.04607502f, 0.44585937f, -0.10217968f, 0.11671299f, -0.02796067f, 0.12977225f, 
    0.25347102f, -0.04587742f, -0.41723931f, -0.41232893f, -0.00812350f, -0.22354980f, 0.03540913f, -0.25013360f, 
    0.06806590f, -0.03008501f, -0.02881059f, -0.80327249f, -0.00379295f, -0.09497513f, -0.03438454f, -0.47277272f, 
    0.12330607f, -0.19025777f, -0.08724725f, -0.10493180f, -0.13678753f, -0.16990392f, -0.17666109f, 0.23012133f, 
    0.01649650f, 0.06153972f, 0.07002074f, -0.21245854f, 0.07823619f, 0.08173607f, 0.07057346f, -0.08457337f, 
    -0.02007088f, 0.04053715f, -0.19902234f, 0.14126617f, 0.13857602f, -0.21744977f, 0.22296192f, -0.50736427f, 
    -0.52614611f, -0.09393443f, -0.04670550f, -0.01860151f, 0.19331822f, -0.08246885f, 0.00773356f, 0.29450631f, 
    -0.48886201f, -0.08681681f, -0.00443705f, -0.36627224f, -0.11850142f, -0.30249116f, 0.20437838f, -0.31338078f, 
    -0.00083590f, -0.33516514f, 0.03874503f, 0.36157310f, 0.02142630f, -0.36815017f, 0.16446529f, 0.11660029f, 
    -0.16510011f, -0.10813353f, 0.10627756f, -0.30605632f, -0.17568804f, -0.35048124f, -0.35653868f, -0.28489950f, 
    -0.20020823f, -0.47259769f, -0.01205864f, -0.04040302f, -0.16436359f, -0.09194753f, -0.03123898f, -0.07538565f, 
    0.08158910f, -0.15864599f, -0.00721244f, 0.14120993f, 0.28910059f, 0.20208637f, -0.25710452f, 0.20927003f, 
    -0.12573144f, -0.02112568f, 0.10460652f, 0.11017057f, 0.06909411f, -0.06951208f, -0.10904188f, 0.00363900f, 
    -0.01609130f, 0.21305279f, -0.20414175f, 0.11912655f, -0.10170919f, 0.21470991f, 0.09667032f, 0.10372812f, 
    -0.00133976f, 0.03232384f, -0.10850339f, 0.05072781f, -0.13803600f, -0.07008945f, 0.17788459f, -0.00181230f, 
    -0.51584226f, 0.10520408f, -0.01206703f, -0.05087508f, -0.10846347f, -0.01027987f, 0.16379677f, -0.13002183f, 
    0.14399177f, 0.10641660f, -0.02251244f, 0.02386098f, -0.16960619f, -0.20317125f, -0.39129791f, 0.05869573f, 
    -0.53514701f, 0.12876464f, -0.14878371f, 0.04186429f, -0.20863988f, 0.10876687f, 0.11240865f, -0.07537432f, 
    -0.09797578f, -0.42771420f, -0.24084824f, -0.03452152f, 0.04049062f, -0.10055795f, -0.42219457f, 0.20380656f, 
    0.02679112f, -0.07050823f, 0.02491587f, 0.08344863f, -0.38036278f, -0.09126055f, -0.35823193f, 0.24914795f, 
    -0.12196782f, -0.22070912f, -0.13726528f, 0.19631431f, 0.16924173f, -0.07376190f, 0.17409350f, -0.02361282f, 
    -0.05261210f, -0.21794698f, -0.10069226f, -0.20113111f, -0.05068491f, -0.05989084f, -0.18194354f, 0.02067090f, 
    0.09168220f, -0.12885040f, -0.06769574f, 0.04812250f, -0.09009703f, -0.09266838f, -0.07756991f, -0.40598097f, 
    -0.30923662f, -0.07789041f, 0.11226998f, -0.33507749f, 0.02337793f, -0.15212102f, -0.27247345f, -0.11280388f, 
    0.00336144f, 0.01854272f, 0.00196269f, -0.21663399f, -0.01710499f, 0.06505909f, -0.17116953f, 0.05436362f, 
    0.16437669f, 0.29004237f, 0.06902409f, -0.32832849f, 0.28326216f, -0.10297638f, 0.00755958f, -0.34090102f, 
    0.14596379f, -0.23221853f, 0.09791197f, 0.21184711f, 0.23923026f, 0.06259220f, -0.04470999f, 0.09086560f, 
    0.29494202f, -0.06633764f, -0.09081553f, -0.45143545f, -0.41340491f, 0.06798270f, -0.04981122f, 0.00236481f, 
    0.15986355f, 0.13673341f, -0.05234356f, 0.14858045f, -0.14265452f, -0.33801103f, -0.70302182f, -0.10249352f, 
    -0.06152479f, -0.20151922f, 0.25807139f, -0.26302472f, -0.50203788f, -0.09818553f, -0.18921585f, 0.05729938f, 
    -0.09050705f, -0.39158645f, 0.03051151f, -0.08482520f, 0.12816681f, -0.01092290f, 0.23490016f, -0.40075335f, 
    -0.33220175f, 0.15179284f, -0.11951860f, 0.05811197f, -0.01894976f, -0.22299385f, -0.36668858f, 0.19503899f, 
    0.09957154f, 0.15040727f, -0.09172658f, -0.08863367f, -0.36495978f, -0.01110067f, -0.00996630f, -0.07085223f, 
    -0.06396881f, -0.58075935f, -0.22680405f, 0.03341036f, 0.00977738f, -0.26841164f, 0.22183499f, -0.09054194f, 
    -0.36839753f, 0.20397331f, -0.21116154f, -0.37900680f, -0.04321850f, -0.02638735f, 0.32167795f, -0.61248600f, 
    -0.17051944f, -0.07228473f, 0.09811875f, 0.24179561f, 0.24234019f, -0.42845163f, -0.03868060f, 0.11846250f, 
    -0.36506355f, -0.18399988f, -0.11799030f, -0.42553839f, 0.03088038f, 0.43876421f, -0.18639870f, -0.08485559f, 
    -0.08480192f, 0.25095221f, 0.25465721f, -0.12808014f, -0.11617523f, -0.17180142f, 0.09344643f, 0.08354891f, 
    -0.21819647f, -0.40832606f, 0.03937960f, -0.00603632f, 0.09913129f, 0.01969498f, -0.46222740f, -0.23360723f, 
    -0.00295501f, 0.16339539f, 0.14798324f, -0.03420653f, -0.06923120f, -0.19302450f, -0.36736915f, 0.01762439f, 
    -0.23143457f, 0.12381191f, 0.07341920f, 0.32741234f, -0.16178855f, -0.06147298f, 0.04890242f, -0.12213286f, 
    0.13080883f, 0.00381825f, 0.17956713f, 0.17304578f, -0.34980804f, -0.18027818f, -0.15625985f, 0.16311818f, 
    -0.20065397f, 0.06121444f, 0.13742402f, 0.02699392f, -0.04879263f, 0.06977185f, -0.22086851f, -0.38919908f, 
    0.34918058f, 0.02280922f, 0.06927177f, -0.21881606f, 0.07635377f, 0.02861059f, 0.12545346f, -0.25347015f, 
    -0.17121617f, 0.23271300f, 0.20983581f, -0.27510673f, -0.08018269f, -0.26959822f, 0.11599530f, -0.03182337f, 
    0.03058467f, 0.01796925f, -0.21752879f, -0.37930772f, -0.29923308f, -0.32624149f, -0.32829204f, -0.42489165f, 
    0.10817724f, -0.51943225f, -0.06824579f, -0.12066806f, -0.04244095f, 0.09401852f, -0.28873390f, -0.08264443f, 
    -0.38587022f, -0.26159507f, -0.01819387f, 0.25226071f, 0.01928408f, -0.38643116f, -0.38355556f, -0.32748145f, 
    -0.17825757f, -0.11395189f, -0.04407128f, 0.18188246f, 0.04981037f, 0.24874331f, -0.26172078f, 0.09864563f, 
    0.05648591f, -0.38609216f, 0.26766190f, 0.33224568f, 0.14819945f, 0.19503158f, -0.25196487f, 0.01296583f, 
    -0.16884518f, -0.10654338f, -0.01262896f, -0.10189070f, 0.15906680f, -0.04816218f, 0.29471436f, -0.50962991f, 
    -0.23139739f, -0.12750354f, 0.10013788f, -0.21501774f, -0.14372167f, 0.38543028f, -0.31441945f, -0.18868758f, 
    -0.06148182f, 0.31638315f, -0.63674986f, -0.06086140f, 0.08036018f, 0.28245991f, 0.06840909f, -0.03461622f, 
    -0.10033651f, -0.04752509f, -0.11146671f, -0.30287468f, 0.09276108f, 0.52068698f, 0.09455825f, 0.18853134f, 
    -0.36402255f, -0.27334860f, -0.03470753f, 0.11152101f, -0.30085742f, -0.09516353f, -0.02958965f, 0.11901511f, 
    -0.57675147f, 0.14255379f, -0.61986774f, -0.23597944f, 0.04677531f, -0.50665814f, -0.11081086f, 0.01501557f, 
    0.12420821f, -0.19151740f, 0.01237564f, -0.21188475f, -0.50588840f, 0.06678485f, 0.07484008f, -0.25731277f, 
    -0.09773611f, -0.09685970f, -0.01286917f, 0.12394547f, -0.06606876f, -0.19517142f, 0.20318730f, -0.09925406f, 
    -0.07556467f, 0.18308747f, -0.18314423f, 0.07751721f, -0.08403026f, -0.11280963f, 0.03828382f, 0.01937559f, 
    0.18654159f, 0.00739433f, 0.02645925f, 0.13076568f, 0.09713148f, -0.48179138f, 0.05940020f, 0.08509651f, 
    0.39065632f, -0.34452266f, -0.10624532f, -0.27959672f, 0.27402899f, 0.15195033f, 0.19791299f, -0.00926158f, 
    -0.10955439f, -0.20942546f, -0.07359745f, -0.18642803f, 0.29908741f, -0.19779389f, -0.32093057f, 0.04571527f, 
    -0.15256718f, 0.36502540f, -0.02207310f, 0.02458798f, 0.32017863f, -0.10832825f, 0.38533205f, -0.19167353f, 
    -0.28661478f, -0.37166613f, -0.40024668f, -0.08530760f, 0.09194175f, -0.55873066f, -0.24855044f, -0.30982697f, 
    -0.26538473f, -0.27636555f, 0.10416714f, -0.10644796f, 0.08001380f, -0.28136769f, -0.41255406f, 0.14894061f, 
    0.02797180f, -0.55785698f, 0.30464077f, -0.17931645f, 0.17748110f, -0.28354308f, 0.19546846f, -0.24217857f, 
    0.23245311f, -0.08876925f, -0.12107575f, -0.17186338f, 0.19937719f, 0.04939120f, 0.07785504f, -0.02497474f, 
    -0.54202968f, -0.03886583f, -0.01308017f, -0.25728124f, -0.07203054f, -0.13515958f, -0.35685390f, -0.23072936f, 
    -0.29949823f, -0.41663456f, 0.29073304f, 0.15483956f, -0.63943225f, -0.19891129f, -0.03201253f, 0.06644266f, 
    0.03430691f, -0.18363146f, -0.31391424f, -0.25219417f, -0.25723326f, -0.21978042f, -0.32892928f, -0.30584526f, 
    0.32680428f, -0.13178073f, -0.12113629f, 0.01173462f, 0.08823133f, -0.07328714f, 0.34273160f, -0.04415892f, 
    -0.27387512f, -0.04445287f, -0.65889919f, 0.17547485f, 0.08950441f, -0.49035862f, 0.07383049f, -0.10133209f, 
    0.23717836f, 0.04140538f, -0.02850838f, -0.39963514f, 0.18571231f, -0.17110015f, 0.26949209f, -0.51000726f, 
    -0.00917541f, -0.01654936f, 0.04389115f, -0.30227181f, 0.07962579f, 0.31151855f, 0.25183684f, -0.04282112f, 
    0.17631133f, -0.05277620f, 0.14983056f, -0.02210519f, 0.05303368f, -0.08166352f, 0.08863438f, -0.26100987f, 
    -0.21223217f, -0.01151110f, -0.11575244f, 0.09384218f, 0.11762004f, -0.06448460f, 0.06796578f, -0.27113569f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10699303f, 0.19051427f, 0.15792806f, -0.11573498f, -0.02924918f, -0.00730823f, -0.02402394f, -0.17862135f, 
    -0.08958418f, 0.09316508f, 0.15320706f, -0.16099732f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
