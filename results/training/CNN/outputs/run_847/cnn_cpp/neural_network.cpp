#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82196355f, 0.53301132f, -0.30148122f, -0.59195185f, -0.28804544f, 0.38018703f, -0.52664971f, -0.33638901f, 
    -0.13088717f, -0.56454241f, -0.23105749f, 0.01477220f, -0.30961800f, 0.61630166f, 0.09844898f, 0.23103556f, 
    0.16438136f, -0.18234433f, -0.22976466f, 0.26480407f, 0.15991692f, 0.02786849f, 0.27295160f, -0.21326788f, 
    0.00774278f, -0.43522167f, -0.25725102f, 0.20194045f, 0.00326889f, 0.47357270f, 0.58944517f, 0.50994205f, 
    -0.10177847f, 0.56178236f, -0.45543027f, -0.19698949f, -0.18082879f, -0.63196164f, -0.36903870f, -0.37993109f, 
    -0.10258002f, 0.03373925f, -0.37744901f, 0.01379350f, -0.24939729f, 0.40673903f, 0.34566224f, 0.04413659f, 
    0.04405862f, -0.20206556f, 0.85737151f, 0.57984543f, -0.25418413f, -0.59701008f, 0.06429622f, 0.56819046f, 
    -0.51475263f, 0.37235525f, 0.55437934f, 0.66378677f, -0.54900402f, -0.16612701f, -0.32635593f, -0.23544633f, 
    -0.28947011f, -0.23165953f, -0.01227438f, -0.16853786f, -0.28235179f, -0.05742738f, 0.02792945f, -0.04235438f, 
    -0.14225586f, 0.08434690f, 0.11954161f, 0.06157317f, -0.15671209f, 0.45673901f, 0.80311036f, -0.01095674f, 
    -0.55246741f, 0.09564108f, -0.17640440f, 0.11544298f, -0.54019922f, 0.22451968f, -0.40236086f, -0.23852201f, 
    -0.23519334f, -0.52018815f, -0.03161426f, 0.19756977f, -0.13612232f, -0.24745052f, -0.51964200f, -0.34493533f, 
    -0.06357941f, -0.45312339f, 0.17182842f, -0.26079682f, 0.80554760f, -0.10412410f, 0.31663960f, -0.44529659f, 
    -1.00180352f, 0.10214943f, -0.50278783f, 0.01575155f, 0.24005942f, -0.07636163f, 0.63940668f, 0.30757594f, 
    -0.14328568f, 0.19450390f, -0.08040068f, 0.24241506f, 0.07610285f, 0.02229077f, -0.14337876f, 0.28266457f, 
    -0.07808776f, 0.37727898f, 0.16250333f, 0.22366461f, 0.05782595f, 0.03380867f, -0.89557427f, -0.55851674f, 
    0.38442507f, -0.20360853f, -0.70156074f, 0.52767670f, 0.31116265f, -0.06409124f, -0.28707886f, 0.39762110f, 
    0.02057375f, -0.09433458f, -0.28778470f, 0.30906260f, 0.26266566f, 0.46333730f, -0.33934468f, 0.11803187f, 
    -0.02637785f, 0.11153655f, -0.19399714f, -0.07341623f, 0.26382452f, 0.48019356f, -0.28973544f, 0.21562877f, 
    0.52951568f, 0.91148853f, -0.52105325f, -0.12046932f, -0.26955909f, 0.47560811f, 0.22433420f, -0.63325393f, 
    -0.27645800f, 0.04266125f, 0.18452746f, -0.08543928f, -0.10647746f, -0.24083379f, 0.29955286f, 0.27311674f, 
    0.20436256f, -0.14256145f, -0.05142610f, -0.47780663f, 0.02714106f, -0.31659243f, -0.24013139f, -0.40711853f, 
    -0.84708804f, -0.49639398f, -0.48963836f, 0.30369747f, -0.25199890f, -0.31437895f, -0.51330465f, -0.48182732f, 
    0.43487814f, -0.09465335f, -0.00199569f, 0.22400051f, 0.15077648f, 0.08140943f, 0.00655088f, 0.01312126f, 
    -0.10721482f, 0.16718601f, -0.19226882f, 0.38143367f, -0.38616034f, 0.11024997f, 0.03117862f, 0.05292896f, 
    -0.00263343f, -0.45790330f, 0.06876922f, 0.33745396f, 0.52380604f, 0.54880822f, 0.30033708f, 0.12717435f, 
    0.21190184f, 0.16663791f, -0.03324130f, 0.17111431f, -0.24038717f, 0.58739662f, 0.40889394f, 0.42140135f, 
    0.14490569f, 0.14464679f, 0.41824079f, 0.16755307f, -0.11329929f, 0.08533712f, 0.13781446f, -0.16422001f, 
    -0.19346304f, -0.43205675f, -0.68430024f, -0.60503155f, -0.30773029f, -0.28148055f, 0.37926954f, 0.54841000f, 
    -0.31192705f, 0.28392270f, 0.44129467f, 0.10030876f, -0.12416041f, -0.09764313f, 0.15528527f, -0.26208141f, 
    -0.43601933f, 0.27216616f, -0.14721610f, 0.20337713f, -0.05107148f, 0.08620358f, 0.12833801f, 0.26644957f, 
    -0.30324721f, -0.03241493f, 0.30291098f, 0.48111138f, 0.43428543f, 0.60518110f, 0.38941631f, -0.17004769f, 
    -0.40392148f, -0.89602947f, -0.55632502f, -0.33181724f, 0.33540368f, -0.12132449f, 0.11226551f, 0.28540182f, 
    -0.38903478f, -0.31644300f, -0.12056311f, 0.44165063f, 0.39720470f, -0.05085338f, -0.21719906f, 0.09912428f, 
    0.05731299f, -0.14573047f, -0.42310110f, -1.20273530f, -0.02746617f, 0.67690790f, -0.05492235f, -0.92498654f, 
    0.29552287f, 0.70527446f, -0.42924169f, 0.12287140f, -0.15341426f, -0.06197324f, 0.15810604f, -0.08806246f, 
    0.06226418f, 0.26963449f, -0.05960127f, -0.18552068f, -0.24689622f, -0.28173906f, -0.20261639f, 0.34472239f, 
    0.11084645f, 0.11909560f, 0.20971739f, 0.18833129f, 0.28456354f, -0.13731289f, 0.08150651f, 0.02022750f, 
    0.62924665f, -0.72530204f, -0.52105141f, 0.00188431f, 0.46924916f, -0.56809050f, -0.02863188f, 0.17826411f, 
    0.40329096f, 0.22066160f, -0.14322987f, 0.37022626f, -0.12683375f, -0.05535488f, -0.03811180f, -0.05500099f, 
    -0.26298395f, -0.02052275f, 0.09490374f, 0.26179373f, -0.03352632f, -0.24944010f, 0.06735030f, 0.65511471f, 
    0.83197832f, 0.26821673f, 0.00659808f, 0.22607031f, 0.45727444f, 0.02235671f, 0.28685895f, 0.01046192f, 
    -0.45203257f, -0.30256227f, 0.01317464f, 0.10275264f, 0.30388698f, -0.44713360f, -0.30802685f, -0.24722096f, 
    0.01301514f, 0.53323495f, 0.35002214f, 0.17667037f, 0.27115184f, -0.04691395f, 0.45069742f, -0.23146290f, 
    0.22774407f, 0.49390629f, 0.79781020f, -0.08689699f, -0.01665277f, -0.21781832f, 0.62300700f, 0.01802429f, 
    -0.43322423f, -0.21676405f, -0.15808550f, -0.34311646f, 0.01180528f, -0.11295627f, -0.06868524f, 0.19398233f, 
    0.23298033f, 0.32009649f, 0.06874052f, 0.02405158f, 0.09256393f, -0.34747377f, 0.10768543f, 0.88163751f, 
    0.82431424f, 0.33555645f, 0.66213155f, 0.58729023f, 0.11597191f, -0.25675300f, -0.66739619f, 0.28276661f, 
    -0.16087525f, 0.26510394f, 0.07408303f, -0.13567652f, 0.19102901f, 0.03523197f, 0.31628546f, 0.16176566f, 
    0.05376123f, -0.08612243f, -0.01066868f, 0.24278861f, 0.16963248f, 0.00849587f, 0.08386313f, 0.13895939f, 
    -0.89428031f, -0.15332174f, -0.01885661f, -0.61160809f, -0.41859698f, 0.22942133f, -0.25190699f, -0.09906521f, 
    0.08825049f, -0.00232159f, 0.41394547f, 0.32703137f, 0.18201432f, -0.06236653f, -0.10042608f, 0.00922091f, 
    0.33166265f, 0.36120692f, -0.10289367f, -0.34279910f, 0.23224512f, -0.38943008f, -0.06474560f, 0.21101458f, 
    -0.09467436f, -0.00516980f, 0.73950273f, -0.58036244f, -0.98135906f, -0.31068659f, -0.15716068f, 0.67970610f, 
    0.53883040f, -0.13823891f, 0.00591929f, -0.05868516f, -0.06550944f, -0.38741821f, -0.23940405f, -0.21071507f, 
    0.16604836f, 0.06449296f, 0.03829846f, 0.09905954f, -0.10570297f, -0.04210553f, 0.15483855f, -0.26085982f, 
    -0.26078358f, 0.24204300f, 0.90334839f, -0.10705391f, -0.32514274f, 0.15854704f, -0.16011822f, 0.23877348f, 
    0.45573679f, -0.35090488f, 0.54881352f, 0.42351452f, 0.05132112f, 0.31726092f, -0.30661079f, 0.25263202f, 
    -0.21532874f, 0.18995214f, -0.23702541f, 0.01286783f, 0.18391599f, 0.11768862f, 0.28283867f, 0.44743770f, 
    0.19780518f, -0.14330338f, 0.26900518f, -0.52499825f, -0.12202561f, -0.33624583f, -0.19873570f, 0.08356742f, 
    0.44704551f, 0.47403097f, 0.57487774f, 0.40134868f, 0.16652945f, -0.05704772f, 0.03895565f, 0.18393227f, 
    -0.67788792f, -0.16237816f, 0.13551785f, 0.12904409f, 0.20255280f, 0.45036116f, -0.30629429f, -0.20439139f, 
    -0.38997197f, -0.52642769f, 0.08630127f, 0.17914023f, 0.49591401f, 0.37843940f, 0.35027221f, 0.70412105f, 
    0.77624905f, 0.74986404f, 0.22125135f, 0.49440476f, 0.34496793f, -0.15052542f, -0.42843381f, 0.16379346f, 
    0.09166257f, 0.38448092f, 0.35583505f, 0.18197505f, 0.18033217f, 0.31786212f, 0.22579917f, 0.41696662f, 
    -0.28801039f, 0.06129737f, -0.06315949f, 0.17443758f, 0.16576976f, -0.65490508f, -0.38600436f, -0.66128945f, 
    -0.48143783f, -0.59772533f, 0.58590472f, 0.51055574f, -0.08079173f, 0.44349691f, 0.66489416f, -0.02787697f, 
    -0.30056202f, 0.03859520f, -0.23218516f, 0.16049832f, -0.01179858f, 0.15149370f, 0.12780382f, 0.17601997f, 
    -0.15780693f, -0.19597296f, -0.03698233f, -0.12154876f, 0.09531476f, 0.14363550f, 0.17077708f, -0.84512550f, 
    -0.51919961f, -0.02498144f, -0.28990972f, -0.10948022f, 0.42839915f, 0.31019220f, 0.32233793f, 0.53529269f, 
    -0.24949650f, 0.44345990f, -0.30998868f, 0.09031536f, 0.14331038f, -0.06253555f, -0.18204358f, 0.17661528f, 
    0.24439418f, 0.23426042f, -0.17167829f, 0.25033903f, -0.14734304f, 0.08726390f, -0.09857209f, 0.95707637f, 
    0.89621013f, 0.28808421f, 0.76795119f, 0.88123327f, 0.15817535f, -0.11955962f, -0.17695120f, -0.25700215f, 
    -0.05132728f, -0.07146171f, -0.02347353f, -0.03917914f, -0.28323177f, 0.05098266f, 0.05180342f, -0.09918243f, 
    0.16648227f, -0.07018100f, -0.00339126f, 0.45919144f, 0.04339592f, 0.06853909f, -0.13377553f, 0.11872581f, 
    0.39881587f, 0.58944416f, 0.84148455f, -0.11361147f, 0.02026905f, 0.37336934f, 0.44362813f, -0.54763240f, 
    -0.69193155f, -0.21020183f, 0.44051686f, 0.60716528f, -0.35674801f, 0.23921646f, -0.09453096f, 0.40255511f, 
    -0.23822735f, -0.12079324f, 0.03091996f, 0.17988272f, -0.07982887f, 0.21860114f, 0.33289143f, -0.10245251f, 
    -0.00686960f, -0.17493919f, -0.59584028f, 0.11107939f, 0.66593307f, 0.52042937f, -0.67065471f, -0.51335013f, 
    -0.35112953f, -0.80509943f, -0.18641798f, 0.18014507f, 0.30566016f, 0.35555059f, 0.28080359f, 0.15933950f, 
    0.19157219f, 0.30562502f, 0.23737237f, 0.06188157f, 0.20542218f, 0.30870742f, -0.02691833f, -0.45234525f, 
    -0.07739624f, -0.19202790f, 0.67746288f, 0.13538571f, 0.43691498f, -0.22490159f, -0.50897902f, -0.47374246f, 
    -0.36396506f, -0.45138294f, 0.33450907f, 0.41843602f, 0.31690016f, 0.26086941f, -0.13392034f, 0.05055599f, 
    0.29790086f, -0.23634367f, -0.29755509f, -0.04979004f, -0.32008716f, -0.38789505f, -0.49870735f, -0.35411301f, 
    0.04964866f, -0.34325379f, 0.32026371f, -0.16364557f, -1.09368122f, 0.46037799f, 0.72849077f, 0.02925939f, 
    0.58479065f, 0.58399874f, 0.09160227f, 0.33837226f, -0.20066325f, -0.40980309f, 0.19497170f, 0.06422492f, 
    0.20550247f, -0.47101983f, -0.12661810f, 0.07828252f, 0.10356820f, -0.07689756f, 0.25039124f, -0.02062018f, 
    0.04548593f, 0.19238482f, -0.06501969f, -0.00467308f, 0.18392639f, -0.41627532f, -0.52301174f, -0.44347852f, 
    0.50725663f, -0.48843127f, 0.03949079f, 0.67727840f, 0.34403217f, -0.43659583f, -0.31657451f, -0.45106825f, 
    0.05961066f, -0.30933589f, -0.09847297f, -0.39761937f, -0.17086530f, -0.41994587f, 0.11122014f, -0.38230488f, 
    0.07749467f, 0.13916603f, -0.10235457f, 0.01133447f, -0.12218183f, 0.55440748f, -0.80522817f, 0.67955220f, 
    0.68790245f, -0.20552613f, -0.49432886f, 0.22258149f, -0.48060274f, -0.32943058f, -0.33205962f, 0.06191485f, 
    0.35494724f, 0.03355253f, 0.27592784f, 0.18745171f, -0.25693169f, -0.14098993f, -0.48969787f, -0.01403857f, 
    -0.16743864f, -0.38027057f, 0.07893345f, 0.36271557f, 0.02111486f, 0.17440960f, -0.01935919f, 0.20199944f, 
    0.60820109f, 0.16764644f, 0.40264943f, -0.53945738f, 0.04426985f, -0.31553933f, -0.38441595f, -0.40553534f, 
    -0.11836758f, 0.17042865f, 0.19236946f, 0.30087587f, -0.15949602f, -0.26908001f, -0.28198877f, -0.13615681f, 
    -0.49084690f, -0.20084567f, 0.21970619f, 0.55375612f, 0.25675911f, 0.27100170f, -0.10397037f, 0.55228502f, 
    0.91472524f, 0.63560295f, -0.13552310f, 0.16952014f, -0.44392297f, -0.43498901f, -0.23831111f, -0.33746803f, 
    0.31544861f, -0.38319278f, -0.18589418f, 0.09263054f, -0.20313320f, 0.03355435f, -0.39750189f, 0.10607963f, 
    -0.16389160f, -0.30152109f, 0.00492954f, 0.09278189f, 0.28331566f, 0.27264655f, 0.08993116f, 0.38520235f, 
    0.77043670f, 0.01878215f, -0.77835304f, -0.50126529f, -0.01146926f, -0.11037185f, 0.76828742f, -0.52201480f, 
    0.48523811f, -0.14910120f, -0.32495487f, 0.25881624f, -0.18893042f, 0.22705823f, 0.24036752f, 0.00069999f, 
    -0.34143209f, 0.24810499f, 0.00792126f, -0.06274030f, 0.11801048f, -0.13219842f, 0.28607768f, 0.12508091f, 
    -0.19917125f, -0.53707463f, 1.12051141f, -0.18489498f, 0.28486457f, -0.17871697f, -0.80206805f, 0.44496387f, 
    0.17904955f, -0.42734933f, -0.47306302f, 0.26957899f, -0.26170394f, -0.17049693f, 0.14527994f, 0.17067491f, 
    0.04256643f, 0.26499140f, 0.01839218f, 0.09694644f, 0.09318669f, 0.39851093f, -0.04444844f, 0.22637528f, 
    -0.02251181f, 0.08011925f, 0.00837678f, -0.22132698f, 0.28647959f, -0.53713822f, -0.09843079f, -0.00113139f, 
    -0.77589679f, -0.53132230f, -0.49146029f, -0.41357735f, 0.36823303f, -0.19072184f, 0.04563017f, 0.42120436f, 
    -0.45085794f, -0.02824822f, -0.26586944f, -0.09958977f, 0.14984080f, -0.08219893f, -0.30639639f, 0.02457627f, 
    0.05398667f, -0.06814305f, 0.39845091f, -0.61045867f, -0.42135635f, 0.09290881f, 0.71983373f, 0.42821079f, 
    0.71128345f, 0.60778463f, 0.50299853f, -0.02152458f, -0.56881469f, -0.07307671f, -0.21554573f, -0.15836644f, 
    0.19907199f, 0.37924218f, 0.01094508f, 0.07786816f, -0.02116426f, -0.08209409f, -0.17787787f, 0.22807190f, 
    0.14714894f, -0.09966878f, 0.40374243f, -0.07669251f, 0.71848100f, 0.20408295f, 0.03262040f, -0.73692340f, 
    -0.65746111f, 0.25792834f, -0.41088519f, -0.14463784f, -0.55565882f, 0.41297176f, 0.38300866f, -0.14671881f, 
    0.25281522f, -0.30397707f, 0.12563807f, 0.24560411f, -0.00069812f, 0.08867074f, -0.03244725f, -0.04667325f, 
    0.14313672f, 0.00418737f, 0.05322431f, 0.38768065f, 0.07763106f, -0.12959826f, 0.12776339f, 0.81422621f, 
    -0.40887427f, -0.50370979f, -0.57244873f, 0.47554937f, -0.64141077f, -0.46696791f, -0.05943456f, -0.20194902f, 
    0.41688552f, 0.20691188f, 0.05217829f, -0.24129839f, 0.02740520f, -0.26312771f, 0.10271981f, 0.39194313f, 
    0.25135887f, -0.23748598f, 0.12444949f, -0.26714766f, -0.20574588f, 0.39421812f, 0.62982905f, -0.49822843f, 
    -0.81636834f, -0.53182489f, 0.16285746f, 0.71629435f, 0.24837995f, 0.22011502f, 0.20217191f, 0.31416252f, 
    -0.64880413f, 0.37134692f, -0.39155880f, 0.06839618f, -0.12697525f, -0.22138932f, -0.19640590f, -0.26453629f, 
    0.21282130f, -0.06476910f, -0.25447837f, 0.00440202f, -0.23306625f, 0.17962337f, -0.05253164f, -0.41535938f, 
    0.08878183f, 0.28722531f, 0.28386515f, -0.62502348f, -0.20468163f, -0.24063306f, 0.03141418f, -0.36930922f, 
    -0.14505561f, 0.42192507f, -0.33514085f, -0.15380529f, 0.21148074f, 0.63405877f, 0.42347488f, 0.12952229f, 
    0.16305555f, 0.04440968f, -0.43632728f, -0.08269991f, 0.08186714f, -0.24157651f, 0.40417245f, -0.53835654f, 
    -0.11969441f, 0.92235845f, -0.48108679f, -0.64813870f, -0.32002270f, 0.62840235f, -0.67850959f, -0.40595299f, 
    -0.11924378f, -0.42525339f, -0.03726463f, 0.35239720f, 0.11910561f, 0.35410696f, -0.11270168f, 0.01919755f, 
    -0.15311241f, 0.12552032f, -0.07678340f, -0.03543674f, -0.05570288f, 0.11865164f, -0.02295004f, 0.00367967f, 
    0.40532312f, 0.07713231f, -0.36328414f, -0.49153233f, -0.47195899f, -0.59394079f, -0.06432152f, 0.39587086f, 
    0.76060629f, 0.59619701f, 0.29330075f, 0.00638263f, 0.11767596f, -0.36898103f, -0.26176304f, 0.07314681f, 
    0.20940371f, -0.31159887f, -0.23905945f, -0.15928733f, 0.22605656f, -0.03371971f, -0.23138502f, 0.39057493f, 
    -0.40948349f, -0.38756278f, -0.49392581f, -0.79338706f, -0.84025544f, 0.10029436f, 0.13022113f, -0.67674464f, 
    0.45887196f, -0.11981530f, -0.06429248f, 0.01205484f, 0.63907093f, 0.03992294f, 0.17819721f, 0.21218896f, 
    0.14081131f, -0.29712731f, -0.17779073f, -0.26643914f, -0.32185832f, -0.41532138f, 0.10755806f, -0.12761512f, 
    -0.04926069f, 0.08468805f, 0.06024868f, -0.65541464f, 0.55535924f, 0.16162485f, -0.45812881f, 0.85914642f, 
    -0.37718126f, -0.33299237f, -0.72232991f, -0.72001928f, -0.42242524f, 0.32748646f, -0.04281497f, 0.37847146f, 
    -0.10514002f, 0.16481072f, 0.02921120f, -0.01484726f, -0.14324871f, 0.02511057f, 0.19589064f, 0.09611667f, 
    0.12047237f, -0.02200763f, 0.31276134f, 0.05593084f, -1.18910933f, 0.50792807f, -0.36197519f, 0.24210496f, 
    -0.53779173f, 0.38593009f, 0.98719043f, -0.09024575f, 0.21535210f, 0.55994576f, -0.46599331f, -0.01193178f, 
    0.37707713f, -0.25746879f, -0.07583073f, 0.14004280f, -0.08619652f, -0.32092103f, -0.19617215f, 0.05551304f, 
    -0.19918892f, -0.02660440f, 0.17551301f, 0.21881586f, -0.04375941f, 0.64105225f, -0.65704274f, -0.52322936f, 
    0.20295760f, -0.39108053f, -0.64780354f, 0.62701535f, 0.69345379f, -0.58961505f, -0.25884214f, -0.15332840f, 
    -0.35787642f, -0.15959795f, 0.22083160f, 0.22913575f, -0.35110468f, 0.15867920f, 0.10980657f, 0.15191838f, 
    0.04996993f, 0.15840282f, -0.06881818f, -0.05363395f, -0.05988887f, -0.23168449f, -0.37649664f, -0.28402242f, 
    -0.47947785f, -0.53028750f, -0.35606775f, -0.30288154f, -0.06752041f, -0.05048686f, 0.39361444f, -0.08315132f, 
    -0.09548392f, -0.15105841f, -0.12545915f, 0.15684144f, 0.39764079f, -0.36437014f, -0.20468609f, -0.08904417f, 
    -0.43840885f, -0.55888569f, -0.25446638f, -0.46182460f, -0.24833147f, 0.12946585f, -0.23502497f, -1.39779627f, 
    1.09921062f, 0.83517373f, -1.13673961f, -0.27037698f, -0.00417888f, 0.44727933f, 0.33303130f, 0.49316338f, 
    0.11236085f, -0.20078366f, 0.32128087f, -0.23723163f, -0.11400695f, -0.04509592f, 0.04115039f, -0.09385319f, 
    -0.03273239f, 0.01008685f, -0.11758479f, 0.07741693f, 0.18250674f, 0.17929420f, 0.14097884f, 0.10560214f, 
    -0.35756078f, -0.55704600f, -0.68824840f, 0.57886976f, 0.11141983f, -0.59370089f, 0.63150293f, 0.49833760f, 
    0.04435568f, 0.49907526f, 0.38218889f, -0.33616847f, 0.07115769f, 0.09410726f, 0.20895828f, 0.10167883f, 
    0.07776261f, 0.06021331f, -0.28844401f, -0.00940123f, 0.22762586f, 0.26060989f, -0.23069862f, 0.19422011f, 
    0.04003163f, 0.90179187f, 0.95331091f, 0.19811495f, -0.05802654f, -0.19929717f, -0.54551774f, -0.31745884f, 
    0.10199486f, 0.30441424f, 0.02341294f, 0.20917642f, 0.07897560f, -0.12451185f, -0.02658192f, -0.18852173f, 
    0.00593831f, -0.32518819f, 0.11672740f, 0.14191706f, 0.11407242f, -0.02248566f, 0.43088102f, -0.14293596f, 
    0.12862687f, 0.06818311f, -0.88492411f, 0.44819698f, 0.40619907f, -0.08159625f, 0.21384026f, -0.92018867f, 
    -0.15246829f, 0.36752763f, -0.28537691f, -0.03130799f, 0.00185535f, 0.10777604f, 0.35951522f, 0.00703254f, 
    0.34131065f, 0.06364915f, -0.14609970f, -0.12982441f, 0.20379311f, -0.02678590f, 0.14487776f, -0.18608689f, 
    0.05769121f, -0.04604934f, 0.11722686f, 1.06794238f, 0.55546802f, 0.86427999f, -0.10015392f, -0.55209631f, 
    -0.18439449f, 0.04381689f, 0.12951000f, -0.02311315f, 0.27561656f, -0.09027317f, -0.07706558f, -0.17864200f, 
    0.35125855f, 0.18062712f, -0.12408025f, 0.28026918f, -0.02201012f, 0.07105951f, 0.15534632f, -0.26575166f, 
    0.20601784f, -0.12710540f, 0.29045984f, -0.33551002f, -0.66094071f, -0.38466540f, -0.09362411f, -0.59955102f, 
    -0.66935843f, -0.52401662f, -0.00055046f, -0.31428412f, -0.59558016f, -0.27639449f, -0.07093103f, 0.08690383f, 
    0.13645177f, 0.09468165f, -0.37292120f, -0.05738955f, -0.06426844f, 0.10638423f, -0.02330081f, 0.33984995f, 
    -0.04972767f, 0.41762555f, 0.04645281f, 0.34276041f, 0.07479688f, 0.80954379f, -0.82415599f, 0.76575571f, 
    0.50263649f, -0.50129390f, 0.55007362f, -0.83174664f, 0.40873826f, 0.35868648f, 0.26936319f, -0.06404436f, 
    -0.02059006f, -0.51092786f, -0.04236214f, 0.07900578f, -0.05594661f, -0.03540099f, -0.01115241f, -0.15770495f, 
    0.05195098f, 0.06700414f, -0.02564129f, 0.27608898f, 0.07972214f, -0.07809885f, -0.29991448f, -0.33759862f, 
    -0.36058164f, -0.55839306f, -0.23992220f, -0.13826010f, 0.50574160f, 0.40475768f, -0.28454536f, 0.37963754f, 
    0.46924353f, 0.30743012f, 0.24705237f, 0.17064321f, 0.12897223f, 0.13152067f, -0.45515415f, 0.06403852f, 
    0.15577185f, -0.40925077f, 0.19898403f, 0.28014451f, 0.35387185f, -0.14707883f, 0.26268390f, 0.15612525f, 
    -1.08373177f, 0.27353013f, -0.05791458f, 0.53745979f, 0.55079186f, 0.34694967f, 0.15896867f, -0.53726685f, 
    0.21813779f, 0.12359272f, 0.31409317f, 0.14123653f, 0.08107267f, -0.00523352f, -0.34528011f, -0.32035738f, 
    0.01196051f, 0.01723636f, -0.08415949f, 0.14267088f, 0.24653634f, 0.04696647f, -0.12193839f, 0.06402831f, 
    -0.44889462f, -0.56055593f, 0.18934408f, 0.46930259f, 0.59284502f, -0.91266125f, 0.19898714f, 0.41971812f, 
    -0.36045346f, 0.43796530f, 0.22296984f, 0.11566348f, -0.04098584f, -0.03216932f, 0.16757621f, -0.03764023f, 
    0.44546121f, -0.03524830f, 0.14949697f, -0.15746188f, -0.03429002f, -0.45205465f, -0.13509057f, 0.22802809f, 
    0.33793259f, -0.15965283f, 0.98976827f, -0.07922973f, -0.03892054f, 0.62594771f, -0.43809417f, 0.10716220f, 
    0.61355972f, 0.22826432f, 0.21224846f, -0.39533940f, 0.41414511f, -0.16190267f, -0.25737813f, 0.19498008f, 
    0.43962455f, -0.21955441f, -0.37092203f, -0.03747673f, 0.11140706f, -0.36446241f, -0.02452216f, 0.33547699f, 
    -0.04778712f, 0.00071864f, -0.04955237f, 0.72266680f, 0.91285199f, 0.16900767f, 0.45824948f, 0.60244626f, 
    0.15084733f, 0.32251227f, 0.21165527f, 0.14494652f, -0.02381817f, -0.14096527f, 0.22566471f, 0.08320267f, 
    -0.60643744f, 0.09915281f, 0.11746533f, -0.07478300f, -0.35385954f, -0.20241240f, -0.28316256f, -0.35540652f, 
    -0.31479171f, 0.30751187f, 0.14400180f, 0.90092933f, 0.40823743f, -0.59317106f, -0.46774238f, -0.09635368f, 
    -0.59949297f, -0.61870295f, -0.29251373f, -0.47535080f, 0.16584213f, 0.07212763f, -0.29910615f, -0.10301393f, 
    -0.27271685f, -0.41037935f, 0.15975069f, -0.04312218f, -0.16616341f, -0.35726359f, 0.04698624f, -0.43374556f, 
    0.15439510f, 0.36755338f, -0.17746539f, -0.10984026f, 0.60754263f, 0.69246316f, 0.51109833f, 0.56203765f, 
    0.51178479f, 0.06356857f, 0.41120526f, 0.05083646f, 0.18886618f, 0.40568867f, -0.48634818f, -0.43728220f, 
    0.07699733f, -0.15885670f, 0.19573028f, -0.49206504f, 0.11754633f, -0.04775611f, 0.27707714f, -0.27064449f, 
    -0.08724732f, 0.00261665f, -0.34353742f, 0.04480986f, -0.14856631f, 0.28256243f, 0.01547370f, 0.18228012f, 
    0.57983637f, -0.44032490f, 0.57932526f, 0.45545769f, 0.60136390f, 0.35226545f, 0.62938452f, -0.05393164f, 
    -0.43177417f, 0.12095758f, -0.66848451f, 0.00177676f, -0.18400872f, -0.37571156f, -0.06938571f, -0.24911489f, 
    0.07433851f, -0.28218043f, -0.15967324f, -0.04572728f, 0.12133145f, -0.16142625f, -0.19738021f, -0.56557637f, 
    -0.52149576f, -0.76973182f, -0.15735999f, 0.07769836f, -0.27815670f, 0.03962928f, 0.22615577f, -0.01892654f, 
    -0.28192475f, -0.10252742f, 0.14475596f, -0.23855056f, -0.50416803f, 0.35114008f, 0.23126923f, 0.13379183f, 
    0.23988338f, 0.41104236f, 0.12692204f, -0.27567711f, -0.26300064f, 0.22962891f, -0.20050643f, -0.53717321f, 
    -0.86459494f, -0.44769591f, -0.00529679f, 0.08380237f, -0.08881900f, -0.59017140f, -0.03112777f, 0.10605123f, 
    -0.10152664f, 0.50891781f, -0.28871310f, 0.26884463f, 0.06044504f, 0.13355704f, 0.15553987f, 0.39395517f, 
    0.21346982f, -0.26668474f, 0.14507170f, 0.06843565f, -0.00686504f, 0.08420260f, 0.04199711f, 0.06021015f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16645819f, -0.02821744f, 0.04499895f, -0.00091744f, 0.27617055f, 0.29666483f, 0.04761112f, 0.24228212f, 
    0.18321450f, 0.09338904f, 0.20416193f, 0.16128348f, 0.17247011f, 0.38424176f, 0.05979998f, 0.21082966f, 
    0.14421876f, 0.04725889f, 0.10174087f, 0.05962076f, 0.15869085f, 0.01045607f, 0.05131905f, 0.20312315f, 
    0.14967567f, 0.31338289f, -0.02123914f, 0.04564273f, 0.05775871f, 0.04076130f, 0.17054081f, 0.02792023f, 
    0.15017784f, 0.25096014f, 0.29295692f, 0.06993351f, 0.22392233f, 0.07519615f, 0.04200803f, 0.25797462f, 
    0.16671304f, -0.08249152f, 0.22076277f, 0.01044028f, 0.11409345f, 0.23392563f, -0.09351888f, 0.13410361f, 
    0.21078959f, 0.20218752f, 0.20014973f, 0.13855998f, -0.05014522f, 0.02926615f, 0.12425680f, 0.16474630f, 
    0.18310276f, 0.02984540f, 0.21448395f, 0.12518820f, 0.26409125f, 0.05980659f, 0.02459878f, 0.24078500f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22562169f, 0.06544853f, -0.08919516f, -0.20411089f, 0.08789520f, 0.11024316f, -0.02542002f, 0.02487902f, 
    0.01038847f, 0.00623228f, -0.00442459f, -0.02139770f, -0.30847386f, 0.16060837f, 0.21363695f, -0.00275809f, 
    0.02891129f, 0.09218477f, 0.03720600f, -0.02022506f, -0.08679911f, 0.01263526f, 0.05673644f, -0.03416212f, 
    0.24421328f, -0.06260879f, 0.08999017f, -0.09719500f, 0.01791430f, -0.06464157f, 0.04422395f, 0.07061834f, 
    -0.07026275f, -0.00128954f, 0.02830040f, 0.03326301f, 0.10525506f, -0.00527603f, -0.25915468f, 0.22721362f, 
    -0.05287511f, -0.06602946f, 0.14879076f, -0.03813690f, 0.03867394f, -0.03735648f, 0.01355900f, -0.10286870f, 
    -0.02863756f, -0.24659301f, -0.05799615f, 0.02954957f, -0.02553044f, -0.00904383f, -0.06879546f, -0.12277691f, 
    -0.05341318f, -0.07182702f, -0.03908141f, 0.11502663f, -0.21333560f, 0.06170702f, -0.00474996f, 0.14052738f, 
    0.04200367f, -0.07459327f, -0.02441605f, -0.04331193f, 0.09950912f, -0.06675225f, 0.01508236f, -0.00132559f, 
    -0.07304960f, 0.09294472f, -0.11357617f, 0.25054881f, 0.02693325f, 0.07529573f, 0.15598164f, -0.02254850f, 
    0.05591670f, -0.01455451f, -0.02630194f, 0.07451454f, -0.30473822f, -0.23458403f, 0.05572667f, 0.04593033f, 
    0.00972101f, -0.06412782f, -0.07560150f, 0.08402116f, -0.01144954f, -0.02098687f, -0.09669770f, 0.01360105f, 
    -0.08071498f, -0.01531927f, 0.05460098f, 0.10286263f, 0.02746654f, 0.03449574f, 0.06073578f, -0.15115826f, 
    0.12789218f, -0.03570505f, 0.01492241f, -0.07722052f, 0.06284440f, -0.04007580f, 0.04591518f, -0.13368830f, 
    0.10020631f, 0.00351107f, -0.02265786f, 0.06229024f, -0.06720211f, 0.05714055f, -0.06959263f, 0.06347098f, 
    0.14930676f, 0.11844803f, -0.00434067f, -0.00785834f, -0.11894911f, -0.01249449f, -0.02998788f, 0.03487314f, 
    0.09130409f, -0.02575362f, -0.05618771f, -0.04547210f, 0.16192786f, 0.12232488f, 0.20230751f, 0.13063344f, 
    -0.01783768f, 0.06405960f, 0.00933130f, 0.08323538f, 0.05396147f, 0.12368111f, 0.08481932f, 0.01034370f, 
    0.18567742f, -0.01226304f, 0.03140484f, -0.06119546f, 0.01603598f, -0.09068878f, -0.01161589f, 0.08695121f, 
    0.08617214f, -0.00922607f, 0.04684132f, -0.08014592f, -0.06860709f, 0.08248539f, -0.05879495f, 0.15580690f, 
    -0.06225674f, 0.05414351f, -0.02024739f, -0.00901200f, 0.06562126f, -0.09730087f, 0.00186652f, -0.05243013f, 
    0.16102837f, -0.06244883f, -0.16673994f, 0.20816685f, -0.08407595f, -0.01531789f, 0.01097274f, -0.02839027f, 
    -0.00562425f, 0.03812216f, -0.04800121f, 0.08609444f, 0.06578048f, -0.03384660f, 0.05246437f, 0.05362528f, 
    -0.12696819f, -0.10081857f, 0.03360033f, 0.05069930f, -0.01503761f, 0.02953655f, 0.00216761f, -0.02246631f, 
    -0.00131643f, -0.22977619f, -0.13688743f, -0.06460199f, -0.05133238f, 0.03416463f, -0.05246995f, 0.03165990f, 
    0.10597984f, 0.00918116f, -0.11053366f, -0.07018178f, 0.03505766f, 0.07684781f, 0.15006980f, -0.57478619f, 
    0.02066544f, -0.03963694f, 0.04844281f, -0.08978006f, -0.10021938f, -0.05055912f, -0.13582961f, 0.02325400f, 
    -0.02671193f, -0.08497329f, -0.03564439f, 0.12364531f, 0.04774424f, -0.11617581f, 0.03648664f, 0.02158646f, 
    0.04549093f, 0.07366411f, 0.05934830f, -0.05808371f, 0.23213828f, 0.14572066f, -0.00992164f, -0.11446435f, 
    0.14873114f, 0.13600457f, -0.00968231f, 0.07082038f, 0.06680989f, 0.06415231f, -0.12497694f, 0.05970512f, 
    0.10044744f, -0.07541217f, -0.08426599f, 0.17979288f, 0.01295682f, -0.03245987f, -0.06470750f, 0.02975601f, 
    0.08178899f, 0.00824647f, -0.01381209f, 0.01073813f, 0.39449465f, 0.11912653f, -0.03537307f, -0.27853012f, 
    0.04876497f, 0.09010590f, -0.02156683f, 0.08286180f, 0.05945617f, -0.02858707f, -0.04400101f, 0.08140785f, 
    0.01534211f, -0.18777953f, -0.19621129f, -0.24130486f, 0.00121067f, -0.18208629f, 0.01203310f, -0.04516972f, 
    -0.01860020f, -0.01163918f, 0.04215402f, 0.02526292f, 0.21308550f, 0.10223302f, 0.09744386f, 0.00445182f, 
    -0.24210453f, -0.00985393f, 0.06088251f, 0.01558707f, -0.11294438f, -0.00023911f, -0.07403605f, -0.11452296f, 
    -0.24362892f, 0.12052914f, 0.04872326f, -0.13999759f, -0.04470595f, 0.02301241f, -0.01495655f, 0.04636348f, 
    0.05593717f, 0.00361206f, 0.08403733f, 0.01679899f, 0.00477685f, -0.11320746f, 0.02270596f, 0.12105509f, 
    -0.01536234f, 0.06215098f, 0.07176670f, -0.02935105f, 0.00778136f, -0.06218222f, -0.07848506f, -0.07358615f, 
    -0.01097690f, -0.12077513f, -0.09381792f, 0.07630871f, -0.10483719f, -0.05758653f, -0.07376079f, 0.08021768f, 
    0.05781366f, 0.04035532f, 0.02572961f, 0.05053948f, -0.16587432f, 0.16647425f, -0.06658538f, 0.27700052f, 
    0.07964619f, 0.01080536f, 0.08949172f, -0.01889911f, -0.04897203f, 0.04250314f, -0.03609611f, 0.07432124f, 
    -0.17494568f, 0.20233443f, 0.03392875f, -0.09563925f, 0.04746480f, -0.03433132f, 0.10630704f, -0.07098229f, 
    0.07617023f, 0.02672160f, -0.02292909f, 0.02946918f, 0.27255982f, -0.10443181f, -0.17597891f, 0.34173122f, 
    -0.10007913f, -0.03899481f, -0.08155842f, 0.08154438f, -0.12135012f, 0.04684952f, -0.00285855f, 0.06514468f, 
    0.01548231f, 0.06850252f, -0.08031085f, 0.07943574f, -0.00535801f, 0.00529311f, -0.11946210f, -0.10725138f, 
    -0.07485137f, -0.09127332f, -0.02872095f, -0.02315630f, 0.03042961f, 0.16365592f, 0.08046424f, -0.11302163f, 
    0.00124516f, -0.07648969f, -0.01846715f, 0.08037670f, -0.06396076f, -0.11526517f, -0.06903993f, 0.05780216f, 
    -0.13418548f, 0.06913541f, 0.05489286f, -0.35415348f, -0.07789638f, -0.04091553f, 0.02885595f, -0.10208556f, 
    -0.08141162f, 0.05326968f, 0.03425260f, -0.09691174f, -0.01540959f, 0.15953159f, 0.09701646f, -0.09911425f, 
    -0.04855909f, -0.08642139f, 0.02684270f, -0.07886801f, -0.13226859f, -0.04215117f, 0.02085212f, -0.06769145f, 
    -0.22447170f, -0.06152533f, 0.10975893f, -0.10711256f, -0.07567426f, 0.00947556f, -0.03517170f, 0.03710328f, 
    0.00301841f, 0.04952599f, -0.03798421f, 0.00564757f, -0.20041695f, 0.10611128f, 0.06086602f, 0.06807242f, 
    0.05457259f, 0.00257686f, 0.01995332f, 0.01893852f, 0.01417777f, -0.12114625f, -0.04405326f, -0.05720108f, 
    -0.23651041f, -0.04112943f, 0.06739138f, -0.29023689f, 0.03741185f, 0.05523651f, 0.00437639f, -0.04020479f, 
    -0.09810634f, -0.00567215f, -0.03801820f, 0.12492822f, -0.27219069f, 0.09456237f, 0.16929594f, 0.01387583f, 
    -0.00791236f, 0.18136023f, 0.08240052f, 0.12324522f, 0.00808336f, 0.01868771f, -0.09901668f, 0.01648927f, 
    0.26820165f, -0.06752271f, -0.02946203f, -0.30434081f, 0.01618652f, -0.09267277f, 0.12535749f, -0.05738440f, 
    -0.10787237f, -0.03201696f, 0.08205362f, 0.04211381f, -0.18035963f, -0.00646098f, -0.20785238f, 0.03354861f, 
    0.01891371f, 0.03135025f, -0.05479692f, -0.07207501f, -0.01018012f, 0.08217315f, 0.06863844f, -0.01094138f, 
    -0.13117625f, 0.12212369f, 0.13946106f, -0.29401368f, -0.09869249f, -0.03142899f, 0.05114016f, -0.06279646f, 
    -0.05691230f, 0.02932521f, -0.04704783f, 0.08294113f, 0.01529474f, 0.11106049f, -0.18314087f, -0.23879425f, 
    -0.04206860f, -0.03569754f, 0.05700241f, -0.03936848f, 0.05977568f, 0.00517048f, 0.11965214f, -0.03479121f, 
    -0.26575473f, 0.07678370f, -0.04527568f, 0.10226168f, 0.03683482f, -0.15326340f, -0.08491266f, -0.12148000f, 
    -0.01469492f, 0.05358877f, -0.03443578f, 0.09486983f, -0.22464207f, -0.05869633f, 0.17016456f, 0.01269833f, 
    -0.03632566f, -0.05429349f, -0.02210720f, 0.01580307f, 0.05904805f, 0.03289015f, -0.00643314f, -0.00591963f, 
    0.53560168f, 0.19683079f, 0.01677892f, -0.13300006f, -0.04882145f, 0.00547067f, -0.08695338f, 0.02613114f, 
    0.00316848f, -0.05060595f, -0.06978185f, 0.02733956f, -0.23886798f, 0.08652209f, 0.00305266f, 0.02502644f, 
    -0.05754406f, 0.02296982f, -0.16201827f, -0.09659505f, 0.08821209f, -0.07488473f, 0.19514073f, 0.02209594f, 
    -0.07092571f, 0.00097745f, -0.11836251f, -0.15285967f, 0.06228961f, -0.05471640f, -0.03968992f, -0.05315267f, 
    0.00403033f, -0.09423129f, -0.15439400f, -0.03869753f, 0.19742435f, 0.00996283f, 0.11512560f, -0.01932881f, 
    0.03768040f, 0.02331851f, 0.00239379f, -0.06608400f, 0.04608388f, -0.07510816f, -0.00216856f, -0.02493564f, 
    -0.26099706f, 0.21019687f, -0.07720289f, 0.15522499f, -0.04371076f, 0.09835309f, -0.09557761f, 0.01526837f, 
    -0.08350484f, -0.03490349f, -0.08944613f, 0.10087927f, 0.17043403f, 0.01219586f, 0.01817043f, -0.16591042f, 
    -0.02282222f, -0.05222353f, -0.09850816f, 0.01881615f, 0.01091192f, -0.04433656f, 0.01166741f, -0.05946144f, 
    -0.46832511f, 0.08362940f, -0.10084347f, 0.13398497f, 0.00912090f, -0.00967740f, -0.05367586f, 0.02976795f, 
    0.04847466f, 0.03619990f, 0.02856166f, 0.04801175f, 0.11300146f, 0.07541157f, -0.20588803f, 0.03923514f, 
    -0.18174800f, -0.11676979f, -0.04865414f, 0.07169759f, -0.15189557f, -0.03563052f, 0.02942133f, -0.00673143f, 
    -0.31605664f, -0.30190775f, -0.01251038f, -0.03764398f, -0.14166625f, 0.06266531f, 0.06420574f, 0.05891640f, 
    -0.05352317f, 0.00892407f, -0.02255285f, -0.08213782f, 0.25058714f, -0.24067707f, -0.09662763f, 0.34131223f, 
    -0.05512145f, 0.03225640f, 0.04347291f, -0.05329034f, -0.11277962f, 0.00548795f, 0.01433164f, 0.00184177f, 
    -0.21264981f, -0.03822662f, -0.00764042f, -0.03055821f, 0.03066110f, -0.07715885f, -0.00946563f, 0.03256759f, 
    -0.03872468f, 0.03806304f, -0.05418545f, 0.02595343f, -0.09202494f, -0.03117454f, 0.09109925f, -0.11398146f, 
    0.02162718f, 0.01129397f, 0.04148131f, -0.09870236f, -0.00057526f, 0.09287334f, -0.02152789f, 0.01912619f, 
    -0.16944668f, -0.00558092f, -0.03943388f, 0.12212495f, 0.00411662f, 0.01813610f, -0.04672953f, -0.05557951f, 
    -0.04888689f, -0.00543766f, 0.01019804f, 0.04656583f, -0.02907821f, -0.01837464f, -0.01752164f, -0.11251702f, 
    0.00911155f, -0.18477276f, -0.01480914f, 0.00936914f, -0.00293229f, -0.05788884f, 0.07324081f, -0.07706448f, 
    -0.13557518f, -0.03507980f, 0.02771359f, 0.07832660f, -0.01696197f, -0.09194791f, 0.05123417f, -0.04469761f, 
    -0.00735549f, -0.07481668f, -0.03217943f, -0.04924133f, 0.11779952f, 0.01632230f, 0.20597418f, -0.04110786f, 
    -0.14403658f, -0.08312176f, -0.03720314f, 0.20353270f, -0.08225738f, -0.06161660f, 0.03062255f, -0.16625819f, 
    0.03713058f, 0.01014360f, 0.01704711f, 0.19578066f, -0.12262693f, -0.01763726f, 0.05098680f, -0.04706476f, 
    0.01452399f, 0.02134239f, -0.00651230f, -0.02316394f, 0.02914529f, 0.02966038f, -0.05613804f, 0.13516846f, 
    0.05791164f, 0.14032774f, -0.01736890f, -0.09014817f, -0.01912994f, -0.00184827f, 0.05143623f, 0.10088467f, 
    0.06336033f, -0.04971201f, 0.03136925f, -0.30011269f, -0.01492433f, 0.03197279f, 0.04545316f, 0.07039931f, 
    -0.01277493f, -0.00147955f, -0.01512118f, 0.05867329f, -0.14951907f, -0.33999836f, -0.03591681f, 0.14968088f, 
    0.02681832f, 0.06068245f, -0.06517132f, 0.07904299f, -0.05288862f, -0.05555054f, 0.02966572f, -0.05149817f, 
    -0.23305124f, -0.00056437f, -0.09687390f, -0.04819623f, -0.08195518f, -0.08524787f, 0.15602691f, 0.04762065f, 
    0.05089992f, 0.12457190f, -0.16923262f, -0.05429661f, 0.05891239f, -0.05767601f, -0.05791083f, 0.15889683f, 
    0.08457785f, 0.03024990f, 0.00237399f, -0.10386132f, 0.15469712f, 0.12590876f, -0.20886026f, -0.07417847f, 
    0.02323573f, -0.04121416f, 0.14550936f, -0.09689031f, -0.05517669f, -0.01137433f, -0.02275796f, 0.00258172f, 
    0.06667200f, -0.07427767f, 0.02981555f, -0.05808949f, 0.01551075f, -0.12803809f, -0.20039730f, 0.02537759f, 
    -0.09012028f, 0.08766223f, -0.06614513f, -0.05731049f, 0.00881395f, -0.06330646f, -0.15860774f, 0.00718659f, 
    0.14007029f, 0.02219120f, -0.11573356f, -0.17786562f, 0.02035771f, 0.04901429f, -0.05161174f, 0.03948679f, 
    0.00128166f, 0.07122208f, 0.04398005f, 0.03875216f, 0.08838627f, -0.18620023f, -0.17420822f, 0.05833329f, 
    -0.15939850f, 0.10205115f, -0.08548950f, 0.02724736f, 0.03277235f, 0.02447029f, 0.05317329f, 0.11632831f, 
    -0.20817009f, 0.07681476f, -0.37956703f, 0.01700458f, -0.00514492f, -0.12661205f, -0.10008482f, -0.04970743f, 
    -0.01336849f, -0.21404026f, -0.05685163f, -0.05681956f, 0.27319145f, 0.04591741f, 0.06923667f, -0.09327012f, 
    -0.05373320f, 0.00593393f, 0.01072522f, 0.02860396f, -0.01253921f, -0.04327220f, -0.04179499f, 0.00537889f, 
    0.25717816f, 0.02293231f, -0.03381630f, -0.02763340f, -0.12366654f, 0.08695394f, 0.02998165f, -0.01865690f, 
    -0.06829549f, 0.11382747f, -0.07699123f, 0.04866507f, 0.08360159f, -0.02372794f, -0.18145432f, -0.06777186f, 
    0.00925256f, -0.05458986f, -0.04483060f, 0.05241117f, 0.01471968f, 0.03048684f, -0.03663100f, -0.09697710f, 
    -0.00484684f, -0.18568343f, -0.00203679f, -0.00988223f, -0.01439745f, -0.14328897f, 0.01098775f, -0.00179461f, 
    -0.08890329f, -0.06068819f, 0.03790554f, -0.00045121f, -0.63773239f, -0.01708526f, -0.28620860f, 0.02485034f, 
    -0.09909023f, -0.04157501f, 0.05500514f, 0.04031057f, -0.02485410f, -0.12263046f, -0.14186673f, 0.06645450f, 
    -0.17820640f, -0.08452400f, 0.03047906f, 0.07407431f, 0.03406091f, 0.03774828f, -0.02725653f, 0.06079048f, 
    -0.05941341f, -0.02941403f, -0.17451915f, 0.04411364f, 0.06870510f, 0.10923968f, -0.00401268f, 0.18620972f, 
    0.00796315f, 0.00932847f, -0.00509163f, 0.00842399f, 0.00111805f, 0.14426078f, -0.05720660f, 0.02840482f, 
    0.17280018f, -0.05410670f, 0.06565402f, 0.28527197f, 0.02429108f, 0.02415558f, -0.01662890f, -0.00640272f, 
    -0.00079824f, -0.03808328f, 0.00987734f, -0.08594016f, 0.22794744f, -0.10572966f, 0.13827071f, 0.16253568f, 
    -0.15960954f, -0.09274364f, -0.01253230f, 0.00537406f, 0.00468763f, 0.02966669f, -0.02000290f, 0.00602027f, 
    -0.05929898f, -0.00444990f, 0.00314414f, 0.05223335f, -0.14149849f, 0.00656951f, 0.06629919f, 0.08986379f, 
    0.00398288f, -0.02588621f, 0.02084278f, 0.02680585f, 0.11148772f, 0.06931124f, -0.08188173f, -0.34124666f, 
    0.01961513f, -0.06141268f, -0.08941824f, 0.05469890f, 0.11080543f, -0.09160211f, 0.02778706f, -0.03173938f, 
    0.45320067f, -0.10139305f, 0.05279906f, -0.04855708f, -0.06297786f, -0.04384065f, -0.11162853f, 0.00879479f, 
    -0.10480268f, 0.05485707f, -0.05624985f, 0.08658051f, 0.05132701f, 0.00136988f, 0.01136503f, 0.01888991f, 
    0.08041048f, 0.04217649f, -0.02336353f, -0.06492486f, 0.03086544f, -0.02976898f, 0.03547625f, 0.06126934f, 
    0.32345212f, 0.12185376f, 0.02863829f, 0.14025819f, -0.05884786f, 0.00034158f, -0.09374566f, 0.03117604f, 
    -0.01196405f, 0.02613705f, 0.07759000f, 0.07591014f, -0.02225165f, 0.02211216f, -0.02942558f, -0.13835338f, 
    0.03605007f, -0.12173149f, 0.01768765f, 0.07932035f, 0.02378803f, 0.07282084f, -0.04732225f, 0.00492504f, 
    0.23473345f, -0.21448168f, -0.02924176f, -0.02271901f, 0.17227475f, 0.11544070f, 0.06584701f, -0.10944149f, 
    0.00792715f, 0.03774311f, -0.01230279f, 0.09941687f, 0.22265847f, -0.07964591f, 0.09821944f, 0.25397092f, 
    -0.10494424f, -0.04046026f, 0.02912519f, 0.04727721f, -0.04167610f, 0.02029894f, -0.00265819f, -0.00889785f, 
    0.10089643f, 0.02996770f, 0.13079089f, -0.07925601f, -0.06025917f, -0.02833261f, 0.04155393f, -0.10738468f, 
    -0.09672620f, -0.08971602f, -0.07348547f, 0.07971148f, -0.27015266f, -0.05109508f, 0.00820905f, -0.02785295f, 
    -0.01359047f, 0.07408245f, -0.12890522f, 0.00013088f, -0.02810979f, 0.11427813f, 0.10608630f, 0.04975282f, 
    0.07124371f, 0.12157068f, -0.02206719f, -0.07215107f, 0.07043707f, -0.10722490f, -0.09856193f, -0.06231963f, 
    -0.18351355f, -0.07218206f, -0.09729182f, 0.00422339f, 0.23806424f, -0.04834958f, -0.16715942f, 0.08892188f, 
    -0.08476718f, 0.06610708f, -0.04262671f, 0.02163497f, 0.03521553f, -0.01982316f, 0.12997299f, 0.05865078f, 
    0.02172559f, -0.12632196f, 0.06505912f, -0.09952091f, -0.03661015f, -0.03659761f, -0.04582275f, -0.05246640f, 
    0.05548675f, 0.03409856f, -0.24454162f, 0.00434273f, -0.25148162f, -0.05155107f, -0.06051532f, -0.00276026f, 
    -0.07231070f, -0.01750891f, 0.04531254f, -0.08734264f, 0.04591773f, -0.02679699f, 0.00030883f, -0.07137918f, 
    -0.04165960f, 0.05080099f, 0.09710670f, 0.03046438f, -0.02983856f, 0.05577634f, 0.13471404f, 0.04130467f, 
    0.05041830f, -0.06138687f, -0.05932534f, -0.09882054f, 0.14095454f, 0.06040588f, 0.02562393f, 0.04176930f, 
    -0.04055323f, 0.01550996f, 0.12721656f, 0.01244798f, -0.03613809f, 0.00225054f, 0.05628891f, -0.06887395f, 
    0.34929162f, -0.26695648f, 0.04198763f, -0.07454208f, 0.02686186f, 0.00276157f, -0.01137761f, 0.16825706f, 
    -0.11818119f, -0.06722927f, -0.07264265f, 0.10155203f, -0.07078338f, -0.02552566f, -0.27675658f, -0.08422319f, 
    0.02286361f, 0.02933318f, -0.09026327f, -0.05539149f, 0.14618924f, -0.03766088f, -0.01380239f, 0.03089310f, 
    -0.15655309f, 0.00294381f, 0.02643035f, -0.05169858f, 0.14392287f, 0.08444040f, 0.10571904f, 0.06786737f, 
    -0.11546158f, 0.05496595f, 0.00056576f, 0.03320202f, 0.08688383f, 0.15598190f, -0.08972596f, 0.18133448f, 
    -0.05593811f, 0.07350128f, -0.03197630f, -0.06938890f, 0.01268477f, 0.13456990f, -0.00842623f, 0.05653220f, 
    0.16913050f, -0.02045424f, -0.03130828f, -0.01986733f, -0.07129886f, -0.04247647f, 0.07081708f, 0.15823455f, 
    0.03488897f, 0.04038550f, 0.10605543f, 0.07083969f, -0.21093276f, 0.09018641f, -0.12386786f, -0.04710871f, 
    -0.04556476f, -0.09415433f, -0.02920176f, -0.04936782f, 0.15185036f, -0.01869456f, -0.03252755f, -0.02862500f, 
    0.26297206f, -0.24469993f, 0.16918753f, -0.11549225f, 0.01579107f, 0.04052738f, -0.09531038f, 0.00205221f, 
    0.04740376f, -0.08002659f, -0.00275619f, -0.01855585f, -0.17737246f, 0.02876407f, -0.06761409f, 0.16071784f, 
    -0.07185869f, -0.07561408f, 0.04295495f, -0.04373341f, -0.02489638f, -0.02070612f, -0.12447719f, 0.21884073f, 
    -0.17325708f, -0.33712795f, -0.08085684f, -0.19439803f, 0.03200678f, -0.00557936f, 0.11549969f, -0.00188727f, 
    0.06439777f, 0.07184617f, 0.08963776f, -0.03535497f, 0.09852990f, -0.15375026f, 0.02180838f, -0.15615126f, 
    -0.04565633f, -0.05028183f, 0.01505091f, 0.16231193f, -0.00186744f, 0.03451270f, -0.08501156f, 0.04654289f, 
    0.22307482f, -0.09786638f, -0.25902042f, 0.02635575f, 0.06669615f, 0.12053886f, -0.06651500f, 0.12799528f, 
    0.01359370f, -0.19795360f, -0.03336281f, -0.13509564f, -0.08501155f, -0.15165746f, -0.12708867f, -0.38997874f, 
    -0.00881673f, 0.04381189f, 0.08351969f, -0.17676704f, -0.09276916f, 0.07616159f, 0.00627732f, -0.01931125f, 
    -0.34661043f, -0.08863572f, -0.05249282f, -0.10302586f, 0.16142109f, -0.03775794f, -0.02401155f, -0.17792544f, 
    -0.05972414f, 0.03111203f, 0.03973138f, 0.00486329f, 0.18554614f, -0.23903875f, -0.09887731f, 0.09613369f, 
    -0.08935696f, 0.01958460f, -0.04811941f, 0.00440728f, 0.02110219f, 0.08693946f, -0.01876918f, 0.00463218f, 
    0.07353321f, 0.05630856f, 0.00102031f, 0.06738574f, -0.14120732f, 0.04440491f, -0.14695157f, -0.00349215f, 
    -0.06555071f, -0.11731958f, 0.02696266f, 0.07256990f, -0.80313498f, 0.09125211f, -0.28294089f, -0.33888245f, 
    0.03142045f, -0.00393261f, 0.04786962f, 0.07603328f, 0.02764246f, 0.07430970f, 0.03383765f, -0.10305642f, 
    0.26980293f, -0.09144496f, -0.13702871f, 0.04622833f, -0.00402744f, 0.03223095f, -0.05476647f, 0.01991033f, 
    0.13292030f, 0.11223494f, 0.01399571f, 0.06496879f, 0.12856825f, -0.09017937f, -0.06115153f, 0.08617283f, 
    -0.01481819f, -0.06785425f, 0.10896654f, 0.04308243f, 0.04563371f, -0.00949597f, -0.15587033f, 0.10496189f, 
    -0.03724797f, -0.01767839f, -0.09161286f, -0.14495985f, 0.08649250f, -0.06048868f, -0.01938605f, -0.13351251f, 
    -0.14867565f, 0.03919632f, -0.02363980f, -0.08855697f, 0.12701872f, 0.12040792f, 0.03598469f, 0.09950931f, 
    -0.07521690f, -0.15026778f, 0.04964466f, -0.02990966f, -0.01385889f, -0.02416038f, -0.03740715f, 0.03588453f, 
    -0.03304429f, 0.05318694f, 0.05584874f, -0.11212734f, -0.00273904f, -0.09448141f, -0.06799318f, 0.02053052f, 
    0.02459010f, 0.07517166f, 0.02625335f, -0.01669717f, 0.08049963f, 0.31795621f, 0.05386616f, 0.00753662f, 
    -0.09339031f, -0.17005399f, 0.05408421f, -0.08227539f, 0.12677687f, -0.03670035f, 0.06793087f, -0.06957344f, 
    0.12038793f, -0.01267823f, -0.13752159f, -0.07254516f, 0.00667305f, 0.10663474f, 0.00021059f, -0.00081122f, 
    -0.01392850f, -0.02273866f, -0.12744328f, -0.00481368f, 0.18487616f, -0.01518654f, -0.06739645f, 0.02020237f, 
    -0.10168462f, 0.12693654f, 0.00381580f, 0.10286230f, -0.08996971f, -0.08920655f, 0.01004297f, -0.06190157f, 
    0.07365619f, -0.08279043f, 0.11209255f, 0.12107061f, -0.05486466f, 0.00254555f, -0.19769026f, 0.01140963f, 
    -0.06163293f, 0.05891658f, 0.07895981f, 0.07019531f, 0.05777413f, 0.07607005f, 0.06142099f, 0.01598667f, 
    0.09735277f, -0.05893163f, 0.04191357f, 0.00364435f, 0.09352361f, -0.01415191f, -0.06773753f, 0.04843263f, 
    0.09907267f, 0.09425906f, 0.11165727f, 0.05945348f, -0.04937274f, 0.09392692f, 0.02019397f, -0.00485610f, 
    -0.14577040f, -0.03946973f, 0.02830459f, -0.04072287f, 0.18661489f, -0.15475075f, -0.22321822f, -0.39579427f, 
    -0.03003504f, -0.09047367f, 0.11258318f, -0.07079585f, -0.09801880f, -0.01159808f, -0.04890107f, 0.06347527f, 
    0.21128447f, 0.15434903f, 0.03524011f, 0.15852925f, -0.09785894f, -0.01756258f, 0.01737707f, 0.11221119f, 
    -0.00165224f, -0.03520640f, -0.01449895f, 0.01898351f, -0.03302140f, 0.09800561f, 0.15956600f, 0.16748661f, 
    -0.00224559f, 0.08429416f, 0.04235132f, 0.01649487f, 0.06047112f, -0.04248878f, -0.06537598f, 0.04867884f, 
    0.01266826f, -0.05892282f, 0.14627545f, -0.16864012f, -0.01650183f, 0.13831159f, 0.03929309f, -0.02788055f, 
    0.11058696f, 0.04777291f, -0.02879188f, 0.11700802f, -0.01090910f, 0.11943386f, 0.00390371f, -0.05591517f, 
    0.11258625f, 0.08376161f, 0.11425456f, 0.05709402f, 0.09585981f, -0.05447894f, -0.02196833f, 0.12641753f, 
    -0.18733300f, 0.12519489f, -0.12628174f, -0.24353558f, -0.00470456f, -0.05815302f, 0.03123232f, -0.01780534f, 
    -0.05835345f, 0.01297872f, -0.08384065f, -0.05244135f, 0.11418537f, -0.13132523f, 0.01401329f, 0.05528548f, 
    -0.03837266f, 0.01919268f, 0.00438513f, -0.02671368f, -0.01539057f, 0.00824532f, 0.06774750f, 0.05856531f, 
    0.03234588f, 0.02722103f, 0.02910058f, 0.07564547f, 0.09003871f, -0.05834713f, 0.12785393f, 0.03416415f, 
    -0.08479945f, 0.03656892f, 0.04112212f, -0.01085986f, 0.02282099f, -0.03109968f, -0.26105234f, -0.04784020f, 
    0.03358425f, 0.05360098f, -0.05432025f, 0.03530620f, 0.00318723f, 0.06271371f, 0.02289934f, -0.06058462f, 
    -0.36869597f, -0.07693925f, 0.09890728f, -0.10689042f, -0.03234354f, 0.01920366f, 0.05180361f, 0.02724617f, 
    -0.03776454f, -0.04109818f, 0.00708994f, 0.00100719f, 0.36746860f, -0.06109738f, -0.05453980f, -0.08358089f, 
    -0.07508935f, -0.02344697f, -0.03397932f, -0.02810256f, -0.01950180f, 0.01992539f, 0.06694853f, -0.11565584f, 
    -0.17491561f, -0.04318606f, -0.17969607f, -0.00349405f, -0.01552028f, 0.02751576f, -0.03621645f, -0.02586793f, 
    -0.01941770f, 0.01926643f, -0.05181872f, -0.02597944f, 0.07546691f, -0.23846930f, -0.00376854f, -0.08775116f, 
    -0.14630412f, -0.07255059f, -0.09901736f, 0.02873090f, -0.00881511f, -0.05828807f, -0.00247244f, -0.01394631f, 
    0.13233745f, -0.03992593f, 0.04816927f, 0.02816669f, 0.00088182f, 0.06157924f, -0.10879093f, 0.02999766f, 
    -0.07330456f, -0.14272647f, -0.05343065f, -0.00808479f, 0.19985616f, -0.04653946f, 0.14967546f, 0.11204918f, 
    -0.07790586f, -0.05535643f, -0.03679738f, -0.02862681f, -0.02605570f, 0.00572907f, 0.04694352f, -0.01967525f, 
    -0.03801334f, 0.02368397f, 0.01203410f, 0.05213099f, 0.04417239f, 0.07798312f, -0.01455697f, -0.05809047f, 
    -0.08438288f, 0.03264282f, -0.10411742f, -0.01433612f, 0.39745530f, -0.06222574f, -0.09532687f, -0.28555387f, 
    -0.11297767f, -0.05300114f, -0.00512607f, 0.04080432f, 0.04914936f, -0.01964255f, 0.03961619f, -0.11368014f, 
    -0.11460470f, 0.06371942f, -0.16513062f, -0.08364430f, 0.02787949f, -0.00121482f, 0.01300592f, -0.04644136f, 
    0.03549844f, 0.02844046f, 0.01030707f, -0.14363046f, -0.02688296f, -0.00195487f, -0.16033410f, -0.04184792f, 
    0.00371595f, 0.03515858f, -0.03348474f, -0.19068122f, 0.03857386f, 0.02511066f, 0.06929681f, -0.06176795f, 
    -0.27002913f, 0.03762246f, -0.10921726f, -0.03138954f, 0.05818450f, 0.09833340f, 0.05253281f, 0.01455093f, 
    0.02210221f, -0.03660639f, -0.08755903f, 0.08669423f, 0.19044599f, 0.03266737f, -0.03981794f, 0.04721713f, 
    0.10024088f, -0.01296640f, 0.02025027f, -0.02659142f, 0.05402360f, -0.03932771f, 0.03051587f, -0.02696408f, 
    0.06259392f, -0.15754761f, 0.09904432f, -0.05863595f, -0.04699049f, -0.00996294f, -0.04443967f, 0.07709520f, 
    -0.09790236f, 0.07627603f, 0.00306401f, -0.14995036f, -0.11511804f, 0.13356929f, -0.11038619f, 0.14172806f, 
    0.01072271f, -0.06400448f, 0.01706720f, 0.02651994f, -0.03581072f, 0.01225040f, 0.04504785f, 0.03628108f, 
    0.10986014f, -0.08995199f, 0.08566377f, -0.00874884f, -0.03933704f, 0.02128956f, 0.05749761f, 0.03087319f, 
    0.01573713f, 0.00246472f, 0.01367046f, 0.00262651f, 0.08979701f, 0.08607719f, 0.00861351f, 0.09731042f, 
    -0.06281264f, -0.06892531f, 0.06181176f, 0.03016353f, -0.06583216f, 0.01957924f, -0.10405453f, -0.06916258f, 
    0.00887831f, -0.00285387f, 0.02139703f, 0.04200846f, 0.09977869f, 0.06689154f, -0.01263614f, -0.03680832f, 
    -0.01380306f, -0.10100501f, -0.02225559f, 0.02447265f, 0.22052288f, 0.11179297f, 0.18481946f, 0.24419814f, 
    -0.05217657f, -0.10532317f, 0.02427619f, 0.12487713f, -0.01124072f, -0.02714646f, -0.04659459f, -0.03163024f, 
    0.10652837f, -0.05017599f, 0.09410478f, 0.19910927f, -0.10740895f, -0.02991375f, 0.05201176f, 0.06195002f, 
    0.04383286f, 0.00744692f, 0.01644952f, 0.03992944f, 0.03125040f, -0.10924387f, -0.00784408f, -0.11263168f, 
    0.15109830f, -0.07134984f, 0.03307095f, -0.13999613f, 0.03851847f, 0.02168475f, 0.01395159f, 0.02881363f, 
    0.11643476f, -0.01830054f, -0.05490953f, -0.09473781f, -0.05586229f, 0.03701467f, 0.04223730f, -0.01532947f, 
    -0.04817766f, -0.07068983f, -0.00761201f, 0.00009621f, 0.21883881f, -0.08424225f, -0.02331218f, -0.00912659f, 
    -0.00365035f, 0.01222129f, 0.00972204f, 0.03823826f, -0.05443497f, -0.08338909f, -0.08088181f, -0.00900792f, 
    -0.15868016f, -0.02909361f, 0.05202442f, -0.08788683f, -0.10379343f, 0.10771481f, -0.07364181f, 0.11405189f, 
    -0.05082875f, 0.03826351f, 0.08941635f, -0.14048812f, 0.04643480f, -0.15495071f, 0.10122523f, 0.02498788f, 
    -0.12921947f, 0.06434952f, -0.01959062f, -0.05067450f, 0.07640652f, 0.06654396f, -0.08549915f, -0.04491935f, 
    -0.11518076f, 0.16673476f, -0.19833586f, 0.08703260f, -0.02016200f, 0.00739999f, 0.03685168f, -0.00244419f, 
    0.10417304f, 0.04147671f, 0.02327458f, 0.04647344f, 0.05447348f, 0.03607532f, -0.29408649f, -0.25073126f, 
    -0.12753041f, 0.13831826f, -0.14608644f, 0.08872205f, 0.05473539f, 0.04837941f, -0.06077405f, -0.15266289f, 
    0.06258552f, 0.10159393f, -0.15762036f, -0.00764196f, 0.07511762f, -0.01684015f, -0.07958719f, -0.08197447f, 
    0.00559779f, 0.04812066f, 0.02103234f, 0.05407610f, -0.05803576f, 0.12717767f, -0.04061903f, -0.03093886f, 
    0.06050580f, 0.06203770f, 0.02152234f, -0.10874122f, 0.00966921f, 0.05005723f, -0.03341987f, 0.15799284f, 
    -0.02435900f, 0.08061720f, -0.06630164f, -0.11619837f, -0.06644250f, -0.01443060f, 0.04798590f, 0.00919220f, 
    -0.01760573f, -0.08339704f, -0.01561613f, -0.06423144f, -0.04800966f, 0.10416291f, -0.24030419f, -0.07191740f, 
    0.08338790f, -0.02824631f, 0.02202811f, -0.02914695f, -0.11982310f, -0.00037708f, 0.02995561f, 0.04024910f, 
    -0.28819564f, -0.03248155f, -0.25320032f, -0.05685952f, 0.11096148f, -0.02898787f, 0.02384968f, -0.03341009f, 
    -0.06555345f, 0.00603780f, 0.03539473f, -0.06981646f, 0.00056450f, -0.05362612f, 0.06040499f, -0.01683568f, 
    0.01692475f, -0.01803586f, -0.04944135f, -0.00942717f, 0.16032378f, -0.09430717f, -0.06740209f, 0.00221989f, 
    -0.22909036f, -0.09674476f, 0.13451962f, -0.21492913f, -0.08249933f, -0.01534856f, -0.04937463f, -0.02961488f, 
    -0.02846733f, -0.08865341f, -0.02549827f, 0.00327723f, -0.01466605f, 0.08107242f, -0.19766791f, -0.11762349f, 
    -0.01502895f, 0.08147024f, -0.02842119f, 0.00574379f, -0.04837623f, -0.00912917f, -0.06952556f, 0.02113417f, 
    0.01084743f, 0.05858767f, 0.12211783f, 0.18432687f, -0.08440305f, -0.02127935f, -0.02382040f, 0.03675035f, 
    -0.02673591f, -0.04275680f, -0.03065156f, 0.02718566f, 0.14790989f, 0.04400469f, -0.17508110f, -0.04384055f, 
    -0.05086285f, 0.01902514f, -0.08379828f, -0.00148879f, -0.03707663f, -0.03307036f, -0.08819578f, -0.01624295f, 
    -0.38679081f, -0.03647824f, -0.07846178f, -0.26074693f, 0.08796357f, -0.07810498f, 0.02378843f, -0.00509896f, 
    -0.12863182f, 0.04737060f, -0.14816499f, -0.06532233f, 0.21474524f, 0.15602599f, 0.05108804f, 0.21409255f, 
    -0.20412801f, -0.03115700f, 0.04136324f, 0.13450637f, 0.02563505f, -0.03034945f, -0.05106134f, -0.11866652f, 
    0.34327883f, -0.16792944f, 0.08658338f, 0.01436377f, -0.08112610f, -0.03199961f, -0.10892212f, -0.00858695f, 
    -0.04360520f, 0.06024507f, 0.05961699f, -0.02576282f, 0.12627940f, -0.01796565f, -0.06248130f, -0.06253673f, 
    0.10715053f, 0.07583539f, 0.00909138f, -0.06708048f, -0.05818948f, -0.10402899f, 0.06350891f, -0.11147712f, 
    0.24418056f, 0.03822301f, 0.05265499f, -0.01814106f, 0.04000287f, -0.00571867f, -0.02393870f, 0.11401514f, 
    -0.01102661f, 0.03532045f, 0.07220226f, -0.05082941f, 0.42236742f, 0.06525613f, -0.17374632f, 0.00167556f, 
    -0.05533064f, -0.08141598f, 0.03930360f, 0.08361480f, -0.00856648f, 0.01432421f, -0.06264063f, 0.01914285f, 
    0.00642697f, 0.03413360f, -0.12733287f, 0.03905344f, -0.08632422f, -0.10664313f, 0.06040207f, 0.04208094f, 
    0.05741751f, 0.00101381f, -0.03437709f, -0.05810528f, 0.45204985f, -0.03340202f, -0.31096518f, -0.09947578f, 
    -0.04960696f, 0.02494171f, 0.02625582f, 0.00448777f, -0.08452861f, 0.00955503f, 0.06379271f, -0.05285220f, 
    0.28359476f, -0.03679485f, 0.07493271f, 0.15412098f, -0.02698535f, 0.04244484f, -0.01534750f, -0.08848245f, 
    -0.00738287f, 0.02753211f, 0.05624966f, 0.00833426f, -0.02926572f, 0.11059961f, 0.05697712f, -0.03944390f, 
    -0.03407382f, -0.03416413f, 0.06849781f, 0.01539230f, -0.04556614f, -0.00306700f, 0.06978334f, 0.01973389f, 
    0.22292078f, 0.04133562f, -0.31713527f, -0.03759098f, 0.05214031f, 0.08648384f, 0.02125235f, -0.00124102f, 
    -0.04094445f, -0.01653638f, -0.02780678f, -0.10675484f, -0.28349987f, 0.09292952f, -0.03767440f, -0.13746689f, 
    -0.00919159f, 0.01573743f, 0.07922836f, 0.07655786f, -0.08333218f, -0.00193779f, -0.01259040f, -0.08012119f, 
    -0.09122528f, -0.07116943f, -0.12552643f, -0.28252146f, -0.01848019f, -0.03520016f, -0.05635421f, -0.07558139f, 
    0.09502530f, -0.00549224f, 0.05511925f, 0.00953400f, -0.30719516f, 0.07290963f, 0.00960998f, -0.04042672f, 
    -0.08696882f, 0.07635638f, -0.09226406f, 0.05323994f, 0.07285094f, -0.01134432f, 0.05513686f, -0.05611676f, 
    0.10994924f, 0.04364016f, 0.12869599f, 0.10007416f, -0.07167367f, -0.09432178f, -0.04346209f, -0.05543198f, 
    -0.03020573f, -0.11064494f, -0.05001630f, -0.04370627f, -0.02136109f, 0.00111635f, 0.06124201f, -0.00119868f, 
    -0.00255954f, -0.10827556f, 0.02892037f, -0.04194242f, -0.01125566f, -0.09210963f, -0.03465439f, -0.03117906f, 
    0.34834713f, -0.15530187f, -0.09501826f, 0.08428031f, -0.06392889f, 0.02133195f, -0.00537342f, -0.01717745f, 
    -0.06611415f, -0.03164899f, -0.03504207f, 0.00633585f, 0.15985431f, 0.03471249f, -0.17630559f, 0.02577446f, 
    -0.00923753f, 0.09142486f, 0.02202524f, -0.02205547f, -0.02554002f, -0.04348221f, 0.07388508f, -0.06182977f, 
    0.18620194f, -0.06463385f, -0.00606160f, 0.05622432f, -0.00201003f, -0.01309023f, 0.07197218f, 0.02605288f, 
    0.00314396f, -0.00514800f, -0.01132414f, -0.01349883f, -0.26611492f, -0.01042104f, -0.00612296f, -0.21361378f, 
    0.00924796f, -0.05567385f, 0.09417631f, -0.01179317f, 0.01033717f, -0.01886897f, -0.01054451f, -0.09278140f, 
    -0.07516905f, -0.04859330f, -0.01264821f, -0.07433994f, 0.09549971f, 0.04989599f, 0.03560450f, 0.01820305f, 
    -0.01817292f, 0.05041378f, -0.04197254f, 0.04013120f, 0.08157369f, 0.06373620f, -0.05037596f, 0.00503362f, 
    -0.04345739f, -0.05985584f, 0.00173778f, 0.16400014f, -0.10036996f, 0.09677593f, 0.13240628f, 0.00354159f, 
    -0.23846593f, 0.01178756f, 0.06881048f, 0.06433548f, 0.00939329f, 0.03032498f, -0.00793928f, -0.00894963f, 
    -0.01903591f, 0.03515355f, -0.01760279f, 0.00168452f, 0.10458270f, -0.25073993f, -0.01603788f, 0.03577955f, 
    -0.22016941f, -0.00803634f, -0.06098472f, -0.03583044f, -0.02374237f, -0.03592045f, 0.01051398f, -0.06206390f, 
    0.40747607f, 0.12686518f, 0.09761473f, -0.07666084f, -0.01460051f, -0.06689167f, 0.00946081f, 0.07815032f, 
    0.02112581f, -0.02551520f, 0.05438441f, -0.07146780f, -0.03327048f, 0.01097439f, 0.00579976f, 0.08287896f, 
    -0.06491838f, -0.04424081f, 0.03233748f, 0.04642878f, -0.02235743f, 0.07756523f, 0.07138402f, -0.05782413f, 
    -0.18254504f, 0.00945400f, -0.18967293f, -0.04410075f, -0.03899588f, 0.02219296f, 0.02295012f, -0.03064388f, 
    -0.07455321f, 0.05104244f, -0.05150285f, 0.01917349f, -0.20857693f, -0.03175366f, 0.06993900f, 0.18169487f, 
    0.05605847f, 0.10042427f, 0.10135137f, 0.02064761f, 0.01266295f, 0.07995426f, 0.07012758f, -0.09187461f, 
    0.06112480f, -0.27595082f, -0.30213851f, -0.01994956f, -0.16960588f, 0.09769970f, 0.00432275f, 0.18376257f, 
    0.07251041f, 0.04423273f, -0.08432057f, -0.07711011f, 0.14702599f, -0.06828400f, 0.05190333f, -0.03546152f, 
    -0.01005900f, -0.21162182f, 0.04020393f, -0.07442420f, -0.07658090f, -0.06069384f, -0.03985730f, -0.01451610f, 
    0.14457436f, -0.12851605f, -0.05610692f, 0.17367819f, -0.02603062f, 0.01108232f, 0.07042585f, 0.02639632f, 
    -0.08843753f, 0.07042847f, -0.02245051f, 0.04205544f, 0.03606409f, 0.18348147f, -0.01262180f, 0.06437463f, 
    -0.03913427f, 0.00518178f, 0.00649477f, -0.01079871f, 0.00729624f, 0.06324239f, -0.01284060f, -0.13931894f, 
    -0.11727061f, -0.07048751f, -0.04023618f, -0.00024980f, -0.01563444f, 0.02699430f, -0.12624876f, -0.12643464f, 
    -0.00120499f, -0.14279270f, -0.00325658f, 0.04704496f, -0.05280175f, 0.02750061f, -0.06600127f, -0.11265928f, 
    -0.09381032f, -0.12111313f, 0.01537959f, 0.02145723f, 0.09721519f, -0.05583207f, 0.04440334f, -0.03016197f, 
    0.07231590f, -0.06741469f, 0.05344849f, 0.21581452f, 0.00524722f, 0.09577375f, -0.09446671f, -0.02502290f, 
    0.01443767f, -0.05613378f, -0.01204252f, -0.00680536f, -0.01527688f, 0.24711600f, 0.14712086f, -0.14374001f, 
    0.09019950f, -0.03603958f, 0.00243976f, 0.05067457f, -0.08059631f, -0.02977781f, 0.01954061f, -0.03602803f, 
    0.02340325f, 0.10260698f, 0.24722128f, 0.11667651f, 0.06449705f, 0.01555858f, 0.05467317f, -0.03257542f, 
    0.06068556f, 0.02160314f, -0.08045231f, -0.05502945f, -0.39028558f, -0.00243862f, 0.09287573f, 0.07124751f, 
    -0.02910673f, -0.08434114f, -0.01405437f, -0.13947091f, 0.01337228f, -0.05452120f, 0.10179675f, -0.10692971f, 
    -0.00768010f, -0.04874072f, 0.11071999f, 0.00953999f, -0.01592892f, 0.03686073f, -0.03540377f, -0.05624592f, 
    0.10479762f, 0.04537689f, 0.00212229f, 0.08610103f, -0.00062750f, -0.43589598f, -0.43699607f, 0.09164271f, 
    -0.02051558f, 0.00137850f, -0.00501280f, -0.05764100f, -0.01452815f, -0.04454872f, 0.03211132f, -0.07632978f, 
    -0.03563768f, 0.08826175f, 0.02022831f, -0.24296227f, 0.01597652f, -0.04623624f, 0.03798511f, 0.01786261f, 
    0.04276832f, -0.01113296f, -0.10942694f, 0.06443330f, -0.26532122f, 0.04057749f, 0.02307777f, -0.01480783f, 
    -0.08516411f, 0.03268650f, 0.08530702f, 0.05667393f, -0.01070845f, 0.14103256f, -0.09397343f, 0.06923969f, 
    0.09193835f, -0.08248983f, -0.06275477f, -0.10929778f, -0.05682288f, -0.00312769f, 0.00299814f, -0.07978746f, 
    -0.08430674f, -0.04315497f, -0.04944770f, -0.00489384f, -0.32999119f, -0.00183841f, -0.02186433f, -0.19825509f, 
    -0.07778743f, -0.08034541f, 0.00570345f, -0.02960093f, -0.10190587f, 0.07879850f, 0.02396211f, 0.07713930f, 
    -0.47987854f, -0.11557636f, -0.01346820f, -0.00612179f, -0.07044560f, -0.09622314f, -0.01700759f, -0.09221091f, 
    0.05314403f, -0.14458270f, -0.04621742f, 0.01685712f, -0.15170003f, -0.00125784f, -0.09380234f, -0.19875047f, 
    -0.10418396f, -0.04931016f, 0.04358473f, -0.02462548f, 0.01895719f, -0.17353278f, -0.06195518f, 0.00777434f, 
    0.01448859f, 0.00108807f, -0.03982389f, -0.08596914f, -0.05817127f, -0.02892549f, -0.00175512f, 0.03707908f, 
    0.05368539f, -0.08205029f, -0.02501977f, -0.03459066f, -0.05611959f, -0.47044224f, -0.15848038f, 0.10745892f, 
    -0.05293410f, -0.01261396f, -0.09752297f, -0.07479835f, -0.04332289f, -0.14513990f, -0.00015247f, -0.03206411f, 
    0.01932425f, 0.05293075f, 0.09833150f, 0.25584742f, -0.12278470f, -0.16271362f, -0.08840417f, 0.10850453f, 
    -0.04362136f, -0.04221237f, 0.02973493f, -0.06879543f, 0.03950791f, 0.02407876f, 0.16800278f, 0.15624778f, 
    0.07737579f, 0.09997948f, 0.13043056f, -0.13254648f, 0.02747789f, 0.02882376f, -0.09576841f, -0.04877107f, 
    0.00467456f, 0.10579816f, -0.17383076f, 0.12757269f, 0.05538904f, -0.04246958f, 0.10999171f, -0.00589958f, 
    0.03568366f, 0.06070447f, 0.08766057f, 0.04998402f, 0.01271262f, -0.16757156f, -0.19569069f, -0.03712988f, 
    0.05803208f, -0.21383061f, -0.03581452f, 0.11877549f, -0.06207539f, 0.01171265f, 0.07142783f, -0.04121734f, 
    0.00579260f, -0.05186097f, 0.10292782f, 0.18181065f, -0.03952891f, -0.03760476f, 0.11408668f, -0.06832039f, 
    -0.08610066f, -0.04164201f, 0.00501803f, 0.11080614f, -0.15046392f, 0.10101422f, 0.12811045f, 0.05142679f, 
    -0.05572097f, 0.09617079f, -0.08188314f, 0.08330689f, 0.19296707f, -0.01607915f, -0.00915272f, 0.06539381f, 
    -0.17765456f, -0.03908426f, 0.05507969f, 0.10887084f, -0.04850869f, 0.05429005f, -0.04459833f, -0.07240549f, 
    0.00904366f, 0.12871458f, -0.07127104f, 0.03724005f, -0.14589450f, -0.39941633f, -0.20833050f, 0.07405183f, 
    0.05140749f, -0.04154212f, -0.05924353f, 0.03717798f, 0.04245945f, 0.03008546f, -0.07149756f, 0.03944725f, 
    0.19547629f, 0.03332015f, 0.20494056f, 0.12357189f, 0.00167507f, 0.03908918f, -0.00403722f, 0.00139522f, 
    -0.06299535f, 0.01290446f, 0.11335454f, 0.06022210f, -0.25977945f, 0.21473841f, 0.07256213f, -0.10311081f, 
    0.01291104f, 0.06725542f, 0.08964213f, 0.01487105f, 0.01432537f, 0.02551362f, -0.07839258f, -0.05760832f, 
    0.13160768f, 0.04909249f, 0.05835188f, 0.14194074f, 0.08458968f, -0.01285120f, 0.01571840f, -0.02419237f, 
    0.00988958f, -0.04830238f, 0.06468842f, -0.09802358f, -0.24626990f, 0.02029927f, -0.06861817f, 0.02208054f, 
    -0.09890100f, -0.05389872f, 0.06332676f, -0.04858422f, -0.00161229f, -0.01837575f, -0.10713642f, -0.04721107f, 
    0.01528463f, -0.05585451f, 0.00982930f, 0.10824297f, -0.01030134f, 0.08982651f, -0.00891536f, 0.06499015f, 
    -0.01644956f, -0.00561284f, 0.07109358f, 0.00400891f, -0.15361002f, 0.30772117f, 0.02308506f, 0.11727691f, 
    0.04073475f, 0.04418473f, 0.04573804f, 0.06322280f, -0.03980863f, -0.09044038f, 0.04198783f, 0.15036847f, 
    -0.07335016f, 0.05594702f, -0.14520893f, 0.11393546f, -0.01207699f, -0.04404669f, 0.09207480f, -0.08202738f, 
    -0.12534620f, 0.07836264f, 0.10590525f, 0.07653762f, -0.00788630f, 0.02391099f, 0.09008930f, -0.01527251f, 
    0.12501651f, -0.06559311f, 0.00852134f, 0.05926973f, 0.01474873f, -0.04699297f, -0.02710285f, -0.01424792f, 
    0.37430239f, 0.12914221f, 0.05382470f, 0.14377587f, -0.04399014f, -0.10777923f, 0.01471524f, 0.12214059f, 
    0.02089934f, 0.00770852f, -0.14331418f, -0.04872330f, -0.08093283f, -0.17365324f, -0.09538898f, -0.06666883f, 
    -0.05492498f, 0.01267940f, -0.00860555f, 0.03082061f, 0.00681563f, -0.02274651f, 0.03683135f, -0.03963140f, 
    0.09560670f, 0.13065405f, -0.05154585f, 0.01069641f, 0.00676817f, -0.07207447f, 0.07019935f, -0.05905516f, 
    0.00321084f, 0.10220084f, 0.02700355f, 0.04303877f, 0.23311432f, 0.13392715f, 0.25851735f, 0.08060115f, 
    0.14672439f, 0.05570260f, -0.08191366f, 0.05440982f, -0.04024671f, 0.01677096f, -0.06514927f, -0.11992736f, 
    -0.24121730f, 0.24365410f, -0.03451254f, -0.08006828f, -0.02080083f, -0.03245068f, -0.04374872f, 0.06771957f, 
    -0.07225965f, -0.04952340f, -0.02718151f, -0.03955070f, -0.01644884f, -0.23790003f, 0.15278174f, 0.01436701f, 
    0.00279620f, 0.07532213f, 0.06681868f, 0.02602802f, -0.06606347f, -0.02167432f, 0.01124090f, 0.12891716f, 
    0.02894453f, 0.01696538f, 0.07747421f, 0.00177837f, -0.07466614f, -0.07589319f, 0.06125572f, 0.09163497f, 
    -0.01266968f, -0.02764677f, 0.08022557f, 0.11397354f, -0.27455211f, 0.21812625f, 0.26741552f, -0.30940935f, 
    0.02421620f, 0.04864898f, -0.03527004f, 0.09436528f, 0.04097227f, -0.05041619f, -0.05871667f, 0.07224938f, 
    0.14866689f, -0.04138142f, -0.01717946f, -0.03020418f, -0.03118017f, -0.01262721f, 0.06130454f, -0.10664820f, 
    -0.03414173f, -0.02684096f, -0.07573523f, 0.00160216f, 0.00535993f, -0.21439965f, -0.20184812f, -0.01131064f, 
    -0.03295799f, 0.04996247f, 0.01886012f, 0.07759421f, 0.05488516f, 0.02655403f, 0.01580897f, -0.05230061f, 
    -0.34288603f, 0.19873720f, 0.16352376f, 0.08253115f, 0.07079708f, -0.01447617f, 0.00950996f, 0.02371129f, 
    -0.01950047f, 0.07246684f, -0.00020622f, -0.00139952f, -0.31172749f, -0.26751119f, -0.18002677f, -0.05526485f, 
    -0.18345150f, 0.03496800f, 0.04283855f, 0.10955914f, -0.00279639f, -0.10168735f, 0.00463027f, 0.01547027f, 
    0.07130206f, 0.14902815f, 0.08402511f, -0.15251337f, 0.00198773f, -0.12614883f, -0.10900980f, 0.08103897f, 
    -0.00652168f, -0.14830126f, -0.01546878f, 0.04357161f, 0.19213386f, -0.11612218f, -0.05183855f, -0.07273505f, 
    -0.10091262f, 0.15735601f, -0.02161713f, -0.00036114f, 0.04825109f, 0.08643918f, 0.02253616f, -0.02004349f, 
    0.01923706f, -0.00467457f, 0.04163606f, -0.09283914f, 0.02452120f, -0.05463573f, -0.02694939f, -0.02594724f, 
    0.03467287f, 0.05827007f, 0.03395897f, 0.06220654f, 0.11042313f, 0.11368587f, 0.00740607f, 0.03888836f, 
    -0.00507400f, 0.23164080f, -0.08459664f, -0.04619931f, 0.01771376f, -0.05658422f, 0.00485293f, -0.00932592f, 
    -0.15658937f, 0.16323043f, 0.20829441f, 0.06978563f, 0.00507723f, -0.03732851f, 0.02353282f, -0.07293251f, 
    -0.03556777f, -0.00515223f, -0.13270116f, 0.01827254f, -0.31062517f, 0.00941836f, -0.12132785f, -0.09714227f, 
    -0.09888036f, -0.02044925f, -0.01300461f, 0.10272260f, -0.00482352f, -0.01984689f, -0.13688008f, 0.02032646f, 
    -0.09140659f, -0.18427809f, -0.11198917f, -0.08570162f, -0.12821738f, -0.09574600f, 0.05788663f, 0.12491179f, 
    0.05332072f, 0.10213256f, -0.01645976f, 0.06259936f, 0.18087330f, 0.00193183f, 0.04635994f, 0.02531973f, 
    -0.00478441f, 0.18221053f, -0.17478804f, 0.02846068f, 0.07698753f, 0.00332840f, -0.03719166f, -0.04870952f, 
    -0.39801061f, -0.46134096f, -0.28359899f, -0.05107948f, -0.14770292f, -0.04484481f, 0.05297758f, 0.03254455f, 
    -0.04297826f, 0.00718391f, 0.06418388f, 0.07316897f, -0.14694177f, -0.01556573f, -0.04235907f, -0.18105270f, 
    -0.03434440f, -0.04034668f, 0.01558832f, -0.10580195f, -0.00737663f, 0.01050182f, 0.12447048f, -0.04618956f, 
    0.00904563f, -0.02687690f, -0.01413077f, -0.11778074f, -0.00898786f, -0.03718938f, 0.01797538f, 0.02986645f, 
    -0.08179925f, 0.05479781f, 0.02212399f, 0.00270429f, 0.14583008f, 0.04301416f, -0.07388263f, 0.05138478f, 
    -0.09994692f, -0.07860979f, -0.02571853f, -0.07379396f, -0.03066318f, 0.08084258f, -0.01846140f, -0.08562960f, 
    0.23455307f, 0.07547582f, -0.03112636f, -0.14428224f, 0.04925903f, -0.11086269f, 0.06253718f, 0.04427115f, 
    -0.01545039f, -0.17212498f, 0.09022064f, 0.01585223f, 0.23141588f, 0.04195770f, -0.16802035f, -0.18159461f, 
    -0.07294205f, 0.01911219f, 0.08765686f, -0.03937367f, 0.07563532f, 0.03858799f, 0.09714747f, 0.14308415f, 
    -0.12359706f, -0.32580599f, -0.01819200f, 0.14517930f, 0.07541009f, -0.07092265f, 0.05973510f, -0.05338097f, 
    -0.05856948f, -0.00949900f, 0.03890446f, 0.06988513f, 0.02413717f, -0.07121722f, 0.18220694f, 0.06714595f, 
    0.07408089f, 0.09882402f, 0.04246134f, 0.05958287f, -0.01306575f, 0.10099129f, -0.01112817f, 0.11713216f, 
    0.01862864f, -0.03959486f, 0.10437731f, -0.01536734f, -0.17084701f, 0.11484144f, 0.04172179f, -0.04830305f, 
    0.03017427f, 0.05783939f, 0.04204783f, -0.07397654f, -0.29853994f, 0.17553946f, -0.08943790f, -0.06740481f, 
    -0.00955361f, -0.01739967f, -0.04470766f, 0.18177228f, -0.03205084f, -0.00398977f, -0.00051104f, -0.06485651f, 
    0.10364456f, -0.01619539f, -0.00824955f, -0.33628333f, 0.13854015f, 0.08067160f, 0.06685928f, 0.06943553f, 
    -0.03742806f, -0.04653498f, -0.07718845f, 0.03068339f, -0.13212338f, 0.00806258f, 0.00005892f, 0.09089077f, 
    0.13655756f, -0.15538725f, 0.05356605f, 0.03106944f, 0.05797910f, 0.00412123f, 0.02252897f, 0.00199151f, 
    -0.17041367f, 0.01140341f, -0.05957520f, -0.04209025f, -0.02330791f, -0.00712877f, 0.03613891f, 0.08588681f, 
    0.16342194f, 0.01510354f, -0.04128001f, -0.07042861f, -0.14591855f, 0.03168219f, 0.06161026f, 0.16327102f, 
    -0.02404170f, 0.00260400f, 0.06375674f, 0.03290504f, -0.04695843f, 0.07475965f, 0.02062532f, -0.00217456f, 
    -0.23604286f, 0.01626358f, 0.14973213f, 0.08032360f, -0.08626963f, 0.10057689f, -0.01695269f, 0.01067765f, 
    0.02980817f, -0.08894441f, 0.03435512f, 0.06017342f, -0.01326095f, -0.13010362f, -0.08947546f, -0.38872108f, 
    -0.03365910f, -0.09095559f, -0.09303395f, -0.02216815f, 0.00102248f, -0.11930227f, -0.21017019f, -0.10432000f, 
    0.00639672f, -0.07304235f, -0.04018142f, 0.18817578f, -0.04303216f, -0.03755949f, 0.03190118f, -0.10170331f, 
    0.02446019f, 0.01537079f, -0.03425571f, -0.04207459f, -0.01162299f, 0.07018070f, 0.02693955f, 0.01390378f, 
    -0.06196913f, 0.03077216f, 0.01858687f, 0.08114900f, -0.01974055f, -0.04119903f, 0.04266476f, -0.04204472f, 
    0.14489460f, 0.07943596f, -0.13444535f, -0.01527832f, 0.08371189f, 0.00774534f, 0.08506611f, 0.05341309f, 
    -0.02958039f, -0.03394599f, -0.00408385f, 0.07776722f, 0.01704418f, -0.02260257f, 0.13899937f, 0.15758322f, 
    -0.13237233f, 0.00615116f, -0.02578681f, -0.00761410f, 0.04292594f, -0.04495841f, -0.05851833f, -0.02218840f, 
    0.22334509f, 0.22034183f, 0.05542669f, -0.05150494f, 0.00535010f, 0.02062380f, 0.04470747f, 0.15246725f, 
    0.04713661f, 0.07046247f, -0.08326267f, 0.12350415f, -0.11487997f, -0.20935582f, 0.14989385f, 0.15023631f, 
    -0.00865108f, -0.05086831f, 0.09495486f, 0.02661798f, 0.00513994f, -0.01631549f, -0.00781980f, 0.11433588f, 
    -0.17527655f, 0.18517303f, 0.02061532f, -0.04180479f, -0.01672736f, -0.00724252f, 0.05634867f, -0.05568537f, 
    -0.01936438f, -0.03952242f, -0.03686151f, -0.17286868f, -0.22577666f, -0.13633677f, 0.03840302f, 0.10247865f, 
    0.03006776f, -0.15407573f, 0.07634053f, 0.00735320f, -0.07809530f, 0.06158995f, -0.00789287f, 0.02014349f, 
    0.01868579f, -0.03380870f, -0.19698721f, 0.01709810f, -0.02881456f, -0.16334489f, 0.03801646f, 0.08178385f, 
    -0.04089287f, -0.05737315f, -0.00825139f, -0.00757320f, -0.25474820f, -0.13939837f, 0.08651029f, 0.26494271f, 
    0.05622558f, -0.01013491f, 0.01462444f, 0.05095225f, -0.04886103f, 0.00936383f, 0.10038608f, 0.10026281f, 
    -0.34767663f, 0.26361710f, 0.18239895f, 0.19670604f, 0.01766214f, 0.07146917f, -0.08537770f, 0.04888622f, 
    -0.00200200f, 0.03829509f, 0.11250308f, -0.03830952f, 0.23425902f, -0.03241283f, 0.10117035f, 0.12026596f, 
    -0.07536084f, 0.02541965f, 0.02365732f, -0.01886818f, 0.04228589f, -0.09085944f, 0.04518219f, -0.07666153f, 
    -0.32681033f, 0.01534084f, 0.07683530f, -0.07400091f, 0.09064195f, -0.08076771f, -0.03006819f, -0.01696741f, 
    -0.02029707f, 0.03843732f, 0.08438691f, -0.06531546f, -0.26661351f, -0.11435989f, 0.10982599f, 0.16863573f, 
    0.03541716f, -0.07069207f, -0.06321327f, -0.10844701f, 0.08865642f, 0.01072872f, -0.10651944f, 0.00177814f, 
    0.02127084f, -0.28819183f, 0.07960762f, -0.06276651f, -0.04816882f, 0.13437746f, 0.10395343f, -0.10297200f, 
    0.07850403f, 0.11497680f, -0.01736664f, 0.05169499f, -0.23764464f, 0.32373205f, -0.22314928f, -0.14440368f, 
    0.00586651f, 0.02307051f, -0.08979177f, -0.01902072f, 0.05472003f, -0.09035414f, -0.09923773f, 0.01237330f, 
    0.18272266f, -0.25906399f, -0.26983395f, -0.06648119f, -0.07610419f, 0.10808263f, -0.09504007f, 0.00776453f, 
    -0.08191254f, -0.14467043f, 0.10029819f, 0.08409788f, -0.38440651f, 0.14058580f, 0.06145553f, 0.02357702f, 
    0.02010383f, -0.10150190f, -0.12201162f, -0.08585532f, -0.01764940f, -0.02760471f, -0.03190297f, -0.06154545f, 
    -0.14939572f, 0.06976745f, 0.14663057f, 0.00229248f, -0.08490571f, -0.03704341f, -0.09645616f, -0.05427870f, 
    -0.11314721f, -0.03734257f, 0.04144898f, 0.02858499f, -0.11813894f, -0.08343420f, 0.16219909f, 0.14315121f, 
    -0.08864574f, -0.03535336f, 0.02832421f, -0.01372816f, 0.16008213f, 0.11589303f, -0.05112118f, 0.08307066f, 
    -0.04351941f, 0.05561544f, 0.11689635f, -0.06247129f, -0.02982350f, -0.06198749f, -0.16939254f, -0.07547336f, 
    0.09895235f, 0.03159758f, -0.04732457f, -0.01619001f, -0.10010475f, -0.07046092f, 0.08225449f, 0.01028258f, 
    0.06653833f, -0.00471257f, 0.14180475f, -0.05281908f, 0.09762737f, -0.05063858f, -0.00882720f, -0.08183544f, 
    0.12850739f, 0.05458686f, 0.23706482f, -0.05505750f, 0.02548332f, 0.07554402f, -0.01098724f, -0.03439425f, 
    0.01568822f, -0.00057256f, 0.04290041f, -0.06104350f, -0.20689292f, -0.00326196f, -0.21143435f, -0.20561278f, 
    0.03542736f, -0.04737493f, 0.09078011f, 0.03840096f, -0.04448985f, -0.10827291f, 0.07435619f, -0.01400744f, 
    0.04429940f, -0.17067190f, 0.04635776f, 0.00476088f, -0.00544210f, 0.06529773f, 0.04187779f, -0.06826942f, 
    0.07675724f, -0.04284612f, -0.08149184f, -0.09309345f, -0.06533246f, -0.19652408f, 0.15204582f, -0.08478196f, 
    0.06999305f, 0.05165939f, -0.02933760f, -0.04972322f, 0.04179610f, 0.01402088f, 0.00780097f, -0.08684353f, 
    -0.46325248f, 0.02809244f, -0.09209739f, 0.18581818f, 0.16442378f, -0.02146794f, -0.02486091f, -0.03212325f, 
    -0.02214361f, -0.02089965f, -0.00334246f, -0.06776387f, -0.02380089f, -0.18851219f, 0.13236903f, -0.09415720f, 
    -0.00772074f, 0.02488050f, 0.00655106f, -0.10644437f, -0.01845313f, 0.09067399f, -0.10685542f, -0.00315911f, 
    0.03929688f, -0.07657515f, -0.10899565f, -0.07319953f, -0.05814794f, 0.04593815f, 0.04334014f, 0.02145636f, 
    0.01325577f, -0.12326869f, 0.14058019f, -0.03374401f, -0.24438760f, -0.02313024f, 0.11366825f, 0.13838650f, 
    -0.00741341f, 0.16256449f, -0.02799287f, 0.04508668f, 0.02347352f, 0.10100257f, -0.02723463f, 0.11367333f, 
    -0.13859133f, 0.05124453f, -0.06924642f, -0.08587819f, 0.13109310f, -0.02846667f, 0.03358777f, 0.02751648f, 
    0.00522695f, -0.02955429f, 0.00192328f, 0.03604114f, -0.37778988f, 0.24987780f, 0.01112434f, 0.09817593f, 
    -0.02178313f, 0.08455950f, -0.06719141f, -0.07594609f, 0.12403438f, -0.15480264f, -0.07991291f, -0.00899448f, 
    -0.24363653f, -0.12587997f, 0.00940408f, 0.14309220f, 0.10335315f, 0.01777639f, -0.01153062f, 0.07084378f, 
    -0.00246085f, 0.06184838f, -0.13288631f, -0.05790550f, -0.04534118f, 0.19607720f, 0.06964858f, -0.10767145f, 
    -0.01380644f, 0.04688249f, -0.04687712f, -0.10166682f, -0.03456388f, -0.18738665f, -0.02114977f, 0.09891029f, 
    0.07406038f, -0.05787713f, 0.12914993f, 0.09578201f, 0.04430138f, 0.04599275f, 0.14894715f, 0.08018579f, 
    0.03420882f, 0.05320068f, 0.04481891f, 0.09162600f, 0.42328405f, 0.29953611f, -0.09016111f, -0.18636900f, 
    -0.09469706f, -0.09053575f, 0.09520619f, -0.04331743f, -0.01911906f, -0.00602514f, -0.10032633f, 0.07739748f, 
    -0.11541598f, -0.03131282f, -0.03320398f, -0.00121539f, 0.09319761f, 0.11445874f, 0.06865306f, -0.02819909f, 
    0.04221032f, -0.14325856f, -0.05975368f, -0.01457408f, -0.16494070f, -0.22401679f, 0.03819134f, -0.00031497f, 
    -0.14671768f, -0.08425688f, 0.03895995f, -0.12230325f, -0.00435555f, -0.01446231f, -0.05319873f, -0.08517279f, 
    0.01406838f, -0.07103048f, 0.07420338f, 0.07249571f, -0.09027602f, -0.01746811f, 0.03050648f, 0.09702483f, 
    -0.05466774f, -0.01194512f, -0.10971514f, 0.04205907f, -0.11304611f, -0.14883493f, 0.15821497f, -0.21367760f, 
    0.06108150f, 0.11997077f, -0.08507212f, 0.10291093f, 0.13269481f, 0.06706796f, 0.05098686f, 0.06765614f, 
    0.05755762f, -0.13017417f, 0.17612766f, 0.06532609f, 0.08503928f, -0.01254654f, 0.22913216f, 0.10308041f, 
    -0.04080493f, -0.07013834f, -0.03415620f, 0.10084274f, -0.31433505f, 0.05295520f, 0.11251242f, -0.18877029f, 
    0.01061553f, 0.04487120f, -0.09169164f, -0.05569850f, 0.04689397f, -0.10944271f, -0.15559894f, 0.06798360f, 
    -0.15533337f, 0.06317928f, -0.03376694f, 0.00195300f, 0.13065588f, 0.08425182f, 0.05226626f, 0.00898244f, 
    -0.08222926f, -0.03148247f, -0.07970454f, -0.05056072f, -0.39538711f, 0.11835554f, -0.05241707f, -0.26688504f, 
    0.10787863f, -0.09999938f, 0.01247450f, -0.09576155f, -0.00560156f, -0.08130762f, -0.11506456f, -0.00761817f, 
    -0.27702603f, -0.01878560f, -0.02468289f, -0.00115945f, 0.02737084f, -0.20781876f, -0.03760884f, 0.14848626f, 
    -0.02060204f, 0.10791083f, 0.02021490f, -0.16494334f, 0.17394280f, 0.08290724f, 0.02571456f, 0.10177150f, 
    -0.19161342f, 0.05807512f, 0.08701492f, 0.00078222f, -0.04175771f, 0.03763054f, 0.03588268f, 0.00628783f, 
    0.12479235f, 0.10522016f, -0.13552815f, 0.01347706f, -0.02997376f, 0.04536938f, 0.03693864f, 0.16608770f, 
    -0.05696626f, 0.06201613f, 0.01800264f, -0.00035071f, -0.11188328f, -0.14752673f, -0.00554116f, 0.09967627f, 
    -0.07538444f, 0.02027270f, 0.08570843f, -0.02353831f, -0.06944008f, 0.12031831f, -0.06146981f, -0.04147767f, 
    0.04121460f, 0.08510491f, 0.03586846f, 0.01845228f, -0.04055007f, -0.00513388f, 0.00481308f, 0.07237680f, 
    -0.01791324f, 0.10776619f, 0.08482564f, 0.01328412f, -0.20297328f, -0.08242344f, 0.08560403f, 0.05237638f, 
    -0.01218204f, 0.07357693f, -0.11553903f, 0.05762016f, -0.00371896f, 0.05420387f, 0.05077422f, -0.04699202f, 
    -0.00173305f, -0.04679677f, -0.04569588f, 0.23777552f, 0.08240528f, -0.03322138f, -0.02205963f, 0.11216702f, 
    0.00550481f, -0.07698619f, 0.05581537f, -0.00206680f, 0.06232818f, 0.14168876f, -0.04337682f, 0.05216589f, 
    0.13153465f, -0.02985413f, -0.05664946f, 0.06026039f, 0.12569173f, -0.03991452f, 0.03658447f, -0.07878394f, 
    -0.28879586f, -0.15485848f, 0.23271868f, 0.17242132f, 0.03208378f, -0.00473130f, -0.02608755f, -0.10672663f, 
    -0.03122247f, 0.11552502f, 0.03907228f, 0.01811910f, -0.04031909f, 0.04763892f, 0.08035629f, -0.03833375f, 
    0.02447721f, 0.04206992f, 0.07952444f, 0.12343922f, 0.04047058f, 0.03421557f, -0.22451255f, -0.05959227f, 
    0.22676581f, -0.07544269f, -0.02979554f, -0.08861673f, 0.01607943f, -0.00379200f, -0.09296932f, -0.14195521f, 
    0.01208407f, -0.07451424f, -0.11132478f, -0.13010585f, -0.17565258f, 0.12711915f, 0.13741635f, 0.05364061f, 
    -0.01592940f, -0.01502851f, -0.04886360f, 0.04542873f, -0.09015625f, -0.11646472f, -0.03388577f, -0.02728829f, 
    -0.16960119f, 0.07192633f, -0.09498962f, 0.09424530f, 0.00956799f, -0.14321157f, 0.07202947f, 0.05360845f, 
    0.12886538f, -0.08342137f, 0.01978067f, 0.12161177f, -0.30173504f, 0.06000165f, -0.01493106f, -0.03554291f, 
    0.06501793f, 0.01595588f, -0.06650596f, 0.11399060f, 0.02236225f, -0.08208381f, -0.19505805f, 0.08999705f, 
    0.12795611f, -0.04751060f, 0.12610039f, 0.03309968f, 0.00607297f, 0.01378488f, -0.13821021f, 0.06837846f, 
    0.01734616f, 0.04152257f, 0.04542468f, -0.04039340f, -0.17184538f, -0.04318177f, -0.16580421f, 0.00533227f, 
    0.00495872f, 0.08483160f, 0.06488608f, 0.06565213f, 0.02838038f, 0.10901957f, 0.09422573f, 0.02314377f, 
    -0.24261545f, 0.15570316f, -0.00041665f, -0.10112281f, 0.07028955f, -0.01856912f, 0.04394267f, -0.14434029f, 
    -0.00410163f, 0.10434009f, 0.08763240f, 0.07473318f, -0.19518173f, -0.13098344f, -0.18093774f, -0.04858351f, 
    0.13940459f, 0.09669139f, 0.08804835f, -0.05185582f, -0.01335268f, -0.18617964f, -0.01996198f, -0.05829113f, 
    0.03325514f, -0.02476063f, -0.02358712f, 0.09832180f, 0.03515467f, -0.00821205f, 0.07453264f, -0.06293357f, 
    -0.04282723f, -0.03635775f, 0.06424594f, 0.11105218f, -0.49089935f, -0.16684943f, 0.00455869f, 0.12160432f, 
    -0.01836240f, -0.03689517f, 0.03166368f, 0.03462072f, -0.03616122f, 0.03162336f, -0.05685517f, 0.02009400f, 
    0.04481769f, 0.06275582f, -0.00623423f, 0.00723991f, -0.10693417f, -0.05445398f, 0.05071881f, -0.14253905f, 
    -0.04421715f, -0.17453498f, 0.07705387f, 0.12286232f, -0.02699209f, 0.01057439f, -0.02121670f, -0.11861748f, 
    0.02481722f, 0.00582483f, 0.11731881f, 0.18532303f, 0.07217092f, 0.04791456f, -0.11529070f, 0.08387028f, 
    0.06315128f, 0.13089731f, 0.10583045f, -0.32314888f, -0.01128721f, -0.03948008f, -0.13924688f, 0.04635403f, 
    0.13666695f, 0.09921345f, 0.06917643f, -0.00918548f, 0.04639952f, -0.00314830f, -0.00941238f, -0.04938323f, 
    0.05041968f, 0.01367819f, 0.06162202f, -0.05044416f, -0.04769127f, 0.06468107f, -0.05566888f, 0.20722435f, 
    -0.38747922f, -0.34531033f, -0.05028673f, 0.07671747f, 0.08487859f, -0.04972512f, -0.09519510f, -0.09374423f, 
    0.16185798f, -0.07218368f, 0.12413702f, 0.13272187f, 0.20087993f, -0.08825379f, -0.09391976f, 0.06044019f, 
    0.05570402f, 0.18905446f, -0.10718130f, -0.04459458f, 0.19174647f, 0.07559800f, -0.04752177f, 0.01272770f, 
    -0.10052241f, -0.03440776f, -0.14168604f, -0.01596111f, 0.01235816f, -0.01222735f, -0.01309707f, 0.03611783f, 
    0.10609503f, -0.08465280f, -0.07462450f, 0.00187033f, 0.06228035f, 0.14490737f, 0.05795910f, -0.08374040f, 
    0.10975975f, 0.09616654f, -0.14925981f, -0.15656865f, 0.14053965f, -0.07765725f, 0.11766595f, -0.03629094f, 
    -0.06061907f, 0.13492408f, 0.29586965f, -0.08413322f, 0.05417373f, 0.05476400f, 0.14833917f, -0.16072176f, 
    -0.05856299f, 0.11478261f, 0.06664186f, 0.10927189f, -0.23977108f, 0.02313215f, -0.26085988f, -0.04454519f, 
    0.15811025f, 0.12398200f, -0.03163548f, -0.08900524f, 0.03674260f, -0.04420446f, 0.04787514f, -0.04007052f, 
    -0.19182819f, 0.09861138f, -0.10501032f, -0.02608459f, -0.00989438f, -0.08546159f, -0.11692012f, 0.02677164f, 
    -0.02074199f, -0.05777020f, -0.01803719f, -0.05846816f, -0.08049353f, -0.12887728f, 0.08131299f, -0.02428154f, 
    -0.01423052f, 0.09806620f, -0.04704258f, 0.05280569f, 0.09351347f, 0.07022941f, -0.00530972f, 0.14698254f, 
    -0.09623477f, -0.03909105f, 0.06042168f, 0.17918894f, -0.18952328f, 0.07596830f, 0.00654165f, -0.05522054f, 
    0.00474785f, 0.02817767f, -0.06268100f, 0.08022738f, 0.09245140f, -0.09112439f, -0.06597521f, -0.15711622f, 
    0.05726759f, -0.06932769f, -0.04398511f, 0.03546870f, 0.02102415f, 0.13273402f, 0.11724815f, 0.25481585f, 
    -0.00295859f, 0.01395700f, -0.13542263f, 0.04814187f, -0.05594358f, -0.00134285f, 0.14998879f, 0.01678373f, 
    -0.21731943f, -0.17146118f, -0.05591664f, -0.07931936f, -0.49577489f, 0.08639628f, 0.05818208f, -0.02550534f, 
    0.13667598f, -0.13376170f, 0.09658893f, -0.13363010f, -0.04012868f, 0.07149304f, 0.04617928f, -0.15077774f, 
    -0.01971809f, 0.06479554f, -0.04687743f, -0.07950974f, 0.06645900f, 0.13955866f, -0.09839954f, -0.00543557f, 
    -0.06781085f, -0.06620719f, -0.09087240f, -0.21921307f, -0.03323839f, -0.01820594f, 0.18108714f, 0.14661244f, 
    -0.10889105f, 0.14775859f, 0.13259257f, 0.08330831f, -0.08158374f, -0.19169097f, -0.03822367f, 0.01280894f, 
    0.03823335f, 0.06021192f, 0.13257986f, 0.22455721f, -0.01234849f, -0.11119321f, 0.00362531f, 0.18570730f, 
    -0.04349589f, 0.09887893f, -0.05176987f, -0.07892762f, 0.01217985f, 0.01865981f, -0.00323737f, 0.11679954f, 
    0.01530667f, -0.17459765f, 0.00464372f, -0.03406286f, -0.01396211f, -0.13782105f, -0.02722916f, -0.17213894f, 
    -0.07108150f, -0.17155330f, -0.05590916f, -0.03546881f, 0.06630561f, -0.02170799f, 0.15641899f, -0.02967464f, 
    0.14578985f, 0.01447602f, 0.01261749f, -0.09480721f, 0.03025350f, -0.05814700f, 0.16793504f, 0.20186925f, 
    -0.11142789f, -0.04053267f, 0.00116002f, 0.03625810f, 0.20144981f, 0.07015546f, -0.00010387f, 0.07211527f, 
    -0.04509253f, 0.00739905f, -0.00665252f, 0.19342339f, -0.13433470f, -0.01365816f, 0.01105511f, 0.03197324f, 
    0.04478401f, -0.13736099f, -0.02887695f, 0.07799604f, -0.33578703f, 0.13306387f, 0.20319018f, -0.14035401f, 
    -0.08060675f, 0.07080057f, 0.09509353f, 0.06050882f, 0.03418617f, 0.03608176f, -0.01329897f, -0.00559764f, 
    -0.10011993f, -0.02091228f, -0.05198899f, 0.03030675f, 0.03125885f, -0.06925670f, -0.06639835f, 0.04187752f, 
    0.13286398f, -0.05600568f, -0.06886465f, -0.14113787f, 0.02596335f, -0.01436892f, -0.13575682f, 0.09719700f, 
    -0.02590458f, -0.08613195f, 0.00526737f, 0.04647698f, -0.06755259f, -0.00665989f, 0.19698536f, 0.08754745f, 
    -0.04828227f, -0.12065376f, 0.01308571f, -0.15838583f, 0.01946505f, 0.11475654f, -0.05356904f, -0.11125074f, 
    0.00022579f, -0.06182572f, 0.06611551f, -0.02020334f, -0.02270310f, -0.01246695f, 0.10711591f, -0.03407037f, 
    0.13074160f, -0.02245607f, -0.00553457f, 0.17788580f, -0.02022692f, 0.02303579f, -0.02758257f, -0.10794255f, 
    -0.31036994f, 0.11394408f, 0.07252546f, 0.19533989f, -0.08609135f, 0.08280665f, -0.06113563f, -0.04375624f, 
    -0.15902428f, -0.07267886f, 0.05170598f, 0.05477620f, 0.05940343f, -0.05640031f, -0.28976363f, 0.06766789f, 
    0.18019335f, -0.16534136f, -0.00772471f, -0.34294194f, -0.03130522f, 0.08082788f, -0.35337543f, 0.02739280f, 
    -0.29357728f, -0.07010779f, 0.04537888f, -0.11928623f, 0.05077170f, 0.00707197f, -0.01260681f, 0.03402595f, 
    -0.06801984f, 0.04240087f, 0.02285224f, 0.01750900f, 0.03363238f, -0.00208023f, 0.07269275f, 0.22952688f, 
    -0.05576903f, -0.09292784f, 0.06586396f, 0.01379127f, -0.14702585f, 0.13701455f, 0.03008787f, 0.17298625f, 
    -0.24743390f, 0.05331393f, -0.06807835f, -0.08300026f, -0.08472139f, -0.02946037f, 0.12903342f, -0.05756063f, 
    -0.01725308f, -0.03497155f, -0.03240350f, -0.04948777f, -0.24924932f, 0.02744204f, -0.18493365f, -0.04816861f, 
    0.07728884f, -0.06472378f, -0.00677689f, 0.07949381f, -0.01694493f, 0.10404451f, 0.01949746f, -0.17463920f, 
    -0.34012836f, -0.29771465f, -0.14656845f, -0.06972183f, 0.12094545f, 0.02966955f, 0.06549895f, 0.03066812f, 
    0.00372458f, 0.05447478f, 0.01636147f, -0.03721108f, -0.07350325f, -0.33896005f, 0.13237654f, 0.14640127f, 
    -0.04517066f, -0.15082657f, -0.07679997f, -0.03284074f, 0.01876496f, 0.02339816f, 0.08452328f, -0.00394241f, 
    -0.37950292f, 0.05528447f, 0.00448839f, -0.12563162f, 0.08011349f, -0.02318106f, -0.03313684f, 0.08019920f, 
    0.01217303f, -0.08760126f, 0.01539380f, -0.01465803f, -0.02359375f, 0.07774871f, -0.07233708f, -0.00330917f, 
    -0.07465967f, 0.11272267f, -0.04019291f, 0.04867675f, -0.06882764f, -0.10421824f, 0.13827261f, 0.04927964f, 
    0.13765265f, -0.09429812f, -0.02553965f, 0.12491239f, -0.02970673f, -0.10847995f, 0.02943925f, -0.01661628f, 
    0.00107564f, -0.05407081f, 0.04719222f, 0.05196829f, 0.17867427f, 0.03507110f, -0.03002358f, 0.01918938f, 
    -0.01163283f, -0.05648046f, -0.00071864f, 0.03154143f, 0.00420203f, 0.09550809f, 0.10071746f, -0.10596544f, 
    -0.11876912f, -0.01359846f, -0.10834329f, 0.30253199f, 0.12272546f, 0.04165519f, 0.07020988f, 0.06796178f, 
    0.07471609f, 0.09037316f, -0.06246052f, 0.07704382f, -0.08954678f, -0.03785180f, -0.10379226f, 0.15223812f, 
    0.07569128f, -0.08139662f, -0.05822631f, -0.01953022f, 0.03262528f, 0.05818563f, 0.07209267f, -0.04822625f, 
    -0.26433614f, -0.13464463f, 0.03467237f, -0.07833039f, -0.04462082f, -0.02104467f, 0.02044278f, 0.02818044f, 
    0.11824770f, 0.03337187f, 0.17511125f, 0.10111940f, -0.37391931f, -0.04448018f, 0.13764505f, -0.00920916f, 
    0.10510531f, -0.01140088f, -0.08307464f, 0.13384239f, 0.01352038f, -0.00032901f, 0.11475032f, -0.10829370f, 
    0.00299801f, 0.05726185f, -0.06402683f, -0.36811209f, 0.03586440f, 0.10647643f, 0.04623878f, -0.03213689f, 
    0.05157657f, -0.06778888f, -0.03087194f, 0.03814382f, 0.13760541f, 0.04894074f, 0.19229308f, -0.06447472f, 
    -0.06914144f, 0.10756274f, 0.08420412f, -0.16978729f, -0.01305619f, 0.03196775f, -0.24300039f, 0.04761647f, 
    0.04408429f, 0.04345407f, 0.19483441f, 0.18572780f, 0.10979895f, 0.01931951f, -0.05004163f, -0.09454245f, 
    0.08368558f, -0.13118084f, -0.09913523f, -0.07180096f, -0.05433232f, -0.00424721f, 0.17501177f, 0.11665885f, 
    0.13658692f, -0.11095989f, -0.01276558f, 0.00934304f, 0.12193870f, -0.08491992f, -0.08732529f, -0.01956155f, 
    0.09191599f, -0.06261440f, 0.20486033f, -0.06327128f, 0.00157640f, -0.01527682f, -0.13624980f, -0.14480324f, 
    0.02158295f, -0.01836616f, 0.13909955f, -0.06050599f, 0.26241863f, 0.14332962f, -0.02438773f, -0.19655766f, 
    -0.09284590f, -0.14504898f, -0.03925499f, 0.01339439f, -0.17953648f, -0.03166547f, 0.01787513f, -0.22062683f, 
    0.07764563f, -0.10812686f, -0.12194487f, -0.03345805f, 0.10145801f, 0.03978613f, -0.03178716f, -0.14722018f, 
    0.04489642f, -0.00451791f, 0.06722984f, -0.11447567f, -0.27560517f, -0.20216794f, -0.09934779f, 0.07200207f, 
    0.06725870f, 0.07276654f, -0.04005136f, 0.02284187f, -0.10809679f, 0.08176734f, 0.01173344f, 0.17675747f, 
    0.16714405f, -0.10645492f, -0.03831514f, 0.09546342f, 0.00152482f, 0.06608889f, -0.01945559f, 0.00993879f, 
    -0.17145212f, -0.01344561f, 0.14061049f, 0.00104078f, 0.20647749f, -0.17297563f, -0.15689772f, 0.05253623f, 
    0.01888242f, -0.01086151f, -0.17502257f, -0.00277276f, -0.19522361f, 0.02358402f, 0.07304286f, 0.15133537f, 
    -0.45203361f, 0.28026000f, -0.12345600f, 0.18651527f, -0.11817002f, 0.03456984f, 0.08127714f, 0.07381231f, 
    -0.04651796f, 0.05193441f, 0.02818421f, -0.02350699f, 0.27011850f, 0.08967864f, 0.06382592f, -0.30230412f, 
    0.08716454f, 0.05351470f, 0.05445050f, 0.11629726f, 0.06262954f, 0.09939543f, 0.09255422f, 0.04278139f, 
    -0.33883581f, -0.02356609f, -0.10678435f, 0.21581496f, 0.04489668f, 0.06558534f, 0.03999960f, -0.11997876f, 
    -0.11995266f, -0.09170569f, -0.08327010f, -0.18286046f, 0.11923458f, -0.08906067f, 0.01873021f, -0.03774109f, 
    0.01295332f, 0.05056114f, 0.14217584f, -0.09127034f, 0.10443880f, 0.03274675f, 0.15199292f, -0.15184569f, 
    0.10660185f, 0.00033890f, 0.29169714f, -0.14740592f, -0.08007612f, -0.04467587f, 0.14425009f, -0.05138370f, 
    0.10067823f, 0.00850581f, -0.10905597f, 0.08836877f, -0.28551999f, 0.01863245f, -0.07148144f, -0.33105573f, 
    0.10691396f, -0.03167030f, -0.11432147f, -0.16221444f, 0.00425443f, -0.07456192f, 0.02023726f, 0.07240716f, 
    -0.18776254f, -0.17803845f, 0.06508563f, -0.00047647f, -0.03388080f, 0.00960371f, -0.05150777f, 0.12495816f, 
    -0.05480736f, 0.01594444f, -0.06472611f, -0.21689507f, -0.04527965f, 0.01267048f, -0.00334478f, -0.16123663f, 
    -0.16523722f, 0.01170875f, -0.06218316f, -0.12125975f, 0.02821078f, 0.09855186f, 0.02107199f, 0.12937571f, 
    0.17783532f, 0.13290976f, 0.04806522f, -0.17838329f, -0.03263062f, 0.06702605f, 0.00300879f, 0.02892672f, 
    -0.03478095f, 0.04877822f, -0.11013116f, 0.05806400f, 0.36934036f, -0.14472719f, 0.05006319f, 0.04090289f, 
    0.10295212f, 0.12797917f, 0.03710848f, -0.02517799f, -0.18088803f, -0.00000633f, 0.18488035f, -0.16469774f, 
    -0.04371248f, 0.17961751f, 0.12363237f, -0.16086698f, 0.05236404f, 0.03561940f, -0.06362414f, -0.02943353f, 
    0.04211997f, 0.07796873f, -0.05613306f, 0.04233368f, 0.15746528f, -0.07749414f, 0.14231978f, -0.17729220f, 
    0.10792810f, -0.10627505f, -0.01497293f, -0.03566019f, -0.15449530f, -0.10658443f, 0.14625958f, -0.09783711f, 
    0.05573435f, 0.11373935f, 0.01843212f, -0.18535943f, -0.04450668f, 0.11215806f, 0.13386670f, 0.09259514f, 
    -0.16619569f, -0.01698799f, -0.08943896f, -0.04859435f, -0.13814050f, 0.26091769f, 0.00853809f, -0.22325917f, 
    -0.00516275f, 0.06495839f, -0.04803102f, 0.04193747f, 0.01649914f, 0.01195582f, 0.08313917f, -0.05690789f, 
    0.00036990f, -0.12154892f, -0.24160062f, -0.02571821f, -0.06003329f, 0.02234443f, -0.07903939f, -0.02892248f, 
    -0.19364183f, 0.17083094f, -0.10893846f, -0.05933935f, -0.42765260f, -0.14266674f, -0.19370402f, 0.26456568f, 
    0.03854332f, -0.14135636f, 0.13455462f, -0.04784843f, 0.05536786f, -0.06883490f, 0.00845847f, -0.04612857f, 
    -0.25872025f, 0.00657535f, 0.00915964f, 0.06684890f, -0.05705058f, 0.00301364f, -0.07237770f, 0.00723021f, 
    -0.12448935f, 0.01097251f, 0.08701853f, -0.04764860f, -0.23521698f, -0.43655899f, -0.23571597f, -0.10988586f, 
    -0.03139342f, -0.03296630f, 0.04823663f, -0.00303707f, 0.07719059f, 0.14406069f, -0.12131049f, 0.15257160f, 
    -0.09049588f, 0.05985698f, 0.06766378f, -0.18946885f, -0.10745665f, 0.03421212f, -0.05575065f, 0.03181458f, 
    0.06610413f, -0.09228934f, -0.15077464f, -0.20919669f, 0.01395081f, -0.12444690f, -0.10536525f, -0.13624327f, 
    -0.11924838f, 0.05767510f, -0.02517058f, -0.07902739f, -0.00677973f, 0.10699683f, -0.07937440f, -0.00754994f, 
    0.01187196f, -0.10084039f, 0.01779566f, -0.10566365f, 0.01117159f, -0.04607642f, 0.07419709f, -0.02707916f, 
    0.00023760f, 0.03249384f, -0.05308317f, -0.00972800f, -0.11692110f, 0.24766134f, 0.04272427f, -0.36650530f, 
    0.00164954f, 0.04700597f, 0.01195007f, 0.07681722f, 0.00733249f, -0.02948570f, 0.03095641f, 0.05796049f, 
    0.00555254f, -0.00136817f, -0.03630129f, 0.04843562f, 0.06656422f, 0.05261316f, -0.01690675f, 0.05393665f, 
    -0.02597167f, -0.00303195f, 0.00182776f, -0.09511973f, 0.21492359f, 0.08357336f, -0.06388754f, -0.08413886f, 
    -0.06617197f, 0.09310420f, 0.10828376f, 0.08885381f, -0.01099885f, -0.18812740f, -0.04965332f, -0.20625280f, 
    -0.40130514f, 0.18831268f, 0.01250083f, 0.19926371f, 0.07826420f, -0.06127160f, -0.10344244f, -0.00337504f, 
    0.12903738f, 0.13813546f, -0.06413920f, 0.06635495f, 0.18946099f, -0.30572492f, 0.08699542f, -0.01737816f, 
    -0.03811449f, 0.08775412f, -0.00850740f, 0.03824107f, -0.00157663f, -0.07388489f, 0.04832793f, 0.09624229f, 
    -0.16716753f, -0.08246288f, 0.09326003f, -0.06637603f, 0.06464417f, -0.15805793f, 0.09211344f, -0.01082686f, 
    0.02631229f, 0.00253721f, 0.09789661f, 0.16846302f, 0.28216925f, 0.04821127f, -0.05430849f, -0.31227744f, 
    0.04126707f, -0.12465361f, 0.06842744f, -0.03295339f, -0.04064820f, 0.14327154f, 0.13658899f, -0.17357759f, 
    0.11146262f, 0.01628762f, -0.10476888f, -0.15811484f, 0.17314686f, -0.02294698f, 0.03268162f, 0.05914768f, 
    0.06950131f, -0.06078225f, 0.08837049f, 0.00944375f, -0.22896703f, 0.18698612f, 0.02462164f, -0.01065057f, 
    0.06043843f, 0.17757168f, -0.00468890f, 0.09300760f, -0.09186922f, 0.07459987f, 0.02808072f, -0.01282756f, 
    -0.19032423f, -0.18193738f, 0.02935969f, 0.09884891f, 0.12840775f, 0.07461600f, 0.06030028f, -0.03136105f, 
    -0.14922664f, -0.05647179f, 0.01605981f, 0.07369695f, -0.07167220f, 0.03469642f, 0.20281410f, 0.16277091f, 
    0.13052024f, -0.04154211f, 0.03188567f, 0.04858160f, -0.16492766f, 0.10416162f, 0.03082002f, -0.01946655f, 
    -0.01385685f, -0.02691671f, -0.11456460f, -0.00147579f, -0.15911160f, -0.01139609f, -0.06968132f, -0.07439867f, 
    0.00263394f, -0.08102489f, -0.04330640f, 0.04554185f, 0.36949712f, -0.31881496f, 0.00582706f, -0.02460950f, 
    0.07286987f, 0.06329216f, -0.01135859f, -0.09910246f, 0.03829199f, 0.03981052f, -0.08956535f, -0.14552669f, 
    -0.05655663f, 0.02305797f, -0.28871489f, 0.15131049f, 0.04968852f, 0.10581805f, -0.03564034f, -0.01053360f, 
    -0.10369441f, 0.11965296f, 0.07897654f, -0.16348247f, 0.08755517f, -0.21629323f, -0.10866471f, 0.09455349f, 
    0.00563534f, -0.02635895f, 0.06907958f, -0.12582913f, -0.05397022f, -0.13968202f, -0.07970916f, -0.08451205f, 
    -0.08880486f, -0.12575413f, -0.03597998f, -0.22539964f, -0.09779883f, -0.02251881f, 0.00542798f, 0.03151963f, 
    0.04886867f, 0.08662777f, -0.06682503f, 0.16553701f, 0.03914027f, 0.00355975f, -0.03646085f, 0.06237708f, 
    -0.00624828f, -0.14282465f, 0.01942298f, -0.03126341f, -0.08345707f, 0.11299825f, -0.00727411f, 0.01518446f, 
    0.22484304f, -0.19930789f, -0.08674175f, 0.23880637f, -0.03158531f, -0.03531244f, 0.02174344f, 0.02669607f, 
    0.01257941f, 0.01210510f, -0.09854417f, 0.06328899f, -0.22838420f, -0.11971480f, -0.12231335f, -0.14840317f, 
    0.01613358f, -0.00858172f, 0.02287439f, 0.04000564f, 0.01124838f, -0.05895449f, 0.26746985f, 0.08786450f, 
    -0.03923707f, 0.06603726f, 0.05821329f, -0.06945357f, -0.05090062f, 0.00126029f, 0.11701326f, -0.00337156f, 
    0.02858588f, -0.12524648f, 0.06353582f, 0.07432961f, -0.04185248f, -0.02086444f, -0.02789166f, -0.16046982f, 
    -0.05105293f, 0.06269190f, 0.00383068f, -0.00734221f, -0.03707067f, -0.11449483f, -0.05095289f, -0.05462744f, 
    0.18489265f, -0.16503212f, 0.15064551f, 0.08560607f, -0.06506590f, -0.00603632f, 0.04245267f, 0.01731037f, 
    -0.04578223f, 0.04556314f, 0.04638901f, 0.10125813f, 0.02842778f, -0.14738840f, 0.10959126f, 0.05833393f, 
    0.09624336f, -0.05284435f, 0.06249731f, -0.07902387f, -0.07656036f, 0.01475233f, -0.01046955f, 0.12926705f, 
    -0.01074600f, 0.05271476f, -0.18070422f, -0.04218491f, 0.06549910f, -0.00902331f, -0.18734077f, -0.14813578f, 
    -0.01417786f, 0.05618110f, 0.07806411f, 0.00597664f, 0.04536228f, -0.14581434f, -0.18942095f, 0.26565441f, 
    -0.08446888f, 0.02934702f, 0.04225308f, -0.08322491f, -0.04249379f, -0.00376406f, -0.12099733f, -0.02789477f, 
    -0.05472801f, -0.23589990f, 0.14303572f, -0.23906635f, 0.01635996f, -0.01895972f, 0.14768118f, -0.08952628f, 
    -0.00617902f, -0.08702374f, 0.07204676f, 0.00222715f, -0.31910950f, 0.13180362f, 0.01800659f, 0.08197811f, 
    0.06018574f, 0.03802910f, 0.00949951f, 0.04810207f, -0.00627270f, 0.02983398f, -0.10132493f, -0.03001231f, 
    -0.01761388f, -0.02813984f, 0.04355236f, -0.04264791f, -0.03764078f, 0.03880810f, 0.01858135f, -0.01229386f, 
    0.07772706f, -0.00082064f, -0.05681598f, -0.11654171f, -0.15412022f, 0.17170124f, 0.09009977f, 0.13394052f, 
    0.04704710f, 0.00834772f, -0.02648958f, 0.01412164f, 0.03474288f, 0.01792510f, -0.09991270f, -0.04449967f, 
    -0.06038997f, -0.18393876f, -0.35108006f, -0.15721381f, -0.15016837f, 0.05069814f, -0.01415769f, -0.16911821f, 
    -0.01617722f, -0.11711376f, -0.04169466f, 0.05445144f, -0.08694661f, -0.04270013f, 0.07632861f, -0.01475918f, 
    0.08927125f, 0.04252501f, 0.10865498f, 0.03251195f, -0.08729769f, 0.06301899f, -0.08443125f, 0.04302914f, 
    -0.01743900f, -0.00059118f, -0.02438812f, 0.00472887f, 0.00706387f, 0.03694996f, 0.04576942f, -0.03036252f, 
    0.03474553f, -0.04424291f, 0.00927872f, -0.05093319f, 0.40699711f, -0.11995183f, 0.04922532f, 0.13817416f, 
    0.00807966f, 0.00586399f, -0.00041946f, -0.01649192f, 0.04453548f, 0.03530295f, -0.03320066f, 0.07296363f, 
    0.21393964f, 0.01050511f, 0.06204595f, 0.08190254f, 0.02298305f, 0.08996453f, 0.12115213f, -0.01389356f, 
    0.21945244f, -0.05986369f, -0.10504085f, 0.01803885f, -0.44036007f, 0.14503969f, 0.18396528f, -0.03199319f, 
    -0.03793763f, -0.04447970f, 0.03097774f, 0.04200063f, -0.06535257f, 0.04148977f, 0.15142025f, 0.07354099f, 
    0.05736547f, 0.01969257f, 0.06061366f, 0.03016833f, -0.14141580f, -0.13283531f, 0.13907011f, 0.10975891f, 
    0.00667169f, 0.14581373f, 0.07773648f, 0.13253400f, -0.08040171f, 0.02680567f, -0.30169150f, 0.11982679f, 
    -0.04695221f, 0.19961336f, -0.13551332f, 0.13781388f, 0.00367829f, -0.00410268f, -0.00841535f, 0.06064182f, 
    -0.02797353f, 0.21407953f, 0.05772590f, -0.12328263f, -0.03506406f, -0.03798952f, 0.10401094f, 0.02595357f, 
    -0.01804474f, 0.11962606f, -0.04342223f, 0.08491854f, 0.03262788f, -0.21340019f, 0.01524945f, 0.03219746f, 
    -0.01546485f, 0.06017573f, 0.07796007f, -0.02170716f, 0.00646052f, -0.02856973f, 0.11575268f, 0.20578581f, 
    -0.16536631f, 0.00210645f, -0.14599141f, -0.05048500f, -0.12465499f, -0.07088796f, -0.01854202f, 0.12508617f, 
    0.02220186f, 0.05282441f, 0.05599484f, 0.02225335f, -0.18948340f, -0.01166865f, -0.10652001f, -0.28575757f, 
    -0.09249531f, -0.00256532f, -0.02151652f, -0.01365751f, 0.07414710f, 0.02509512f, -0.12728900f, -0.07172179f, 
    0.04571453f, 0.13578317f, 0.03143861f, 0.21162076f, 0.07468801f, -0.08364424f, -0.02752689f, -0.01332253f, 
    -0.03151960f, -0.06000720f, -0.04506666f, 0.02233601f, -0.18511096f, 0.11272828f, 0.04621201f, -0.09319887f, 
    -0.02169839f, 0.01722422f, 0.03850351f, 0.00788745f, 0.00706450f, 0.02452365f, 0.10397115f, -0.05077997f, 
    0.14436834f, -0.00620651f, -0.18092716f, -0.09684931f, 0.00824158f, 0.02461875f, -0.06170663f, -0.04888691f, 
    0.00382804f, 0.09022504f, 0.00381480f, 0.03801224f, 0.13145621f, -0.05523815f, 0.10965458f, -0.04030076f, 
    -0.03512699f, 0.01041746f, -0.01572033f, -0.10003898f, -0.04160236f, -0.01473173f, 0.03798135f, -0.11375581f, 
    -0.11384506f, 0.09108713f, -0.00473462f, 0.06961400f, -0.06247548f, -0.03981248f, -0.10092386f, 0.00024500f, 
    -0.02670407f, 0.03516124f, -0.02069279f, -0.03870210f, 0.18390512f, 0.08303259f, 0.19191806f, -0.05184708f, 
    -0.06672699f, 0.03848877f, -0.08018812f, -0.03390509f, 0.01462109f, 0.09774838f, 0.01041341f, -0.03483842f, 
    0.09609491f, 0.00630456f, 0.05518598f, 0.01442085f, -0.02503885f, 0.01169810f, 0.02234956f, -0.06794303f, 
    -0.04316464f, 0.05044340f, 0.00416125f, -0.10224903f, -0.02987383f, 0.01451852f, 0.10269724f, 0.07905189f, 
    0.00143194f, -0.00779616f, -0.00617123f, -0.02560734f, 0.01506770f, 0.01554607f, -0.03325678f, 0.01215892f, 
    -0.02822258f, -0.04941173f, -0.01439467f, -0.07730500f, -0.07025690f, 0.03930864f, 0.02601749f, -0.09214725f, 
    -0.00178157f, -0.00370119f, -0.00015577f, -0.06070805f, -0.12838936f, 0.14759922f, 0.13331634f, 0.11321001f, 
    0.05912891f, 0.03142198f, 0.01363046f, -0.01818966f, -0.08483216f, 0.06699876f, 0.00852900f, -0.02939492f, 
    -0.16555385f, -0.08524828f, -0.09369597f, -0.00440506f, -0.12593175f, -0.05978173f, 0.01784487f, 0.02313408f, 
    -0.05254473f, -0.00235060f, 0.00192937f, -0.07265723f, 0.22090964f, 0.09590236f, 0.10760026f, 0.14999594f, 
    0.15888016f, 0.09612976f, 0.08017029f, 0.02152032f, 0.00479155f, -0.06630117f, -0.00691502f, -0.04551714f, 
    0.12089900f, -0.14885493f, -0.09230060f, 0.03181750f, -0.01475122f, -0.03385123f, -0.05947528f, -0.00620362f, 
    -0.02069254f, -0.00466337f, 0.00804569f, 0.00889472f, 0.01074871f, -0.16626169f, -0.05703675f, -0.14315319f, 
    -0.08064612f, 0.01229027f, -0.04368304f, -0.07821611f, 0.00007655f, 0.04597903f, 0.00498958f, -0.03324997f, 
    0.00734550f, 0.01812366f, 0.00350181f, -0.06499177f, -0.10049889f, 0.01851656f, 0.04539581f, -0.12538928f, 
    0.02218578f, 0.03763356f, -0.00140006f, -0.03849986f, -0.42208785f, 0.11569911f, -0.12949304f, -0.16465816f, 
    -0.02504530f, -0.03127066f, -0.03155054f, -0.06236528f, -0.05761498f, -0.01508091f, 0.00263944f, 0.00548851f, 
    0.10991716f, 0.17031160f, 0.08707944f, 0.13549243f, 0.16461194f, 0.02246961f, 0.05152669f, -0.00039262f, 
    -0.02247937f, 0.00019502f, 0.01864659f, -0.11215875f, 0.07450126f, 0.08657797f, 0.14737168f, 0.11672582f, 
    0.08325560f, -0.03775166f, 0.02468096f, -0.08906684f, -0.01155693f, -0.05180312f, -0.00596652f, -0.04283133f, 
    -0.27413696f, 0.08540181f, -0.11266752f, 0.01459743f, -0.10332290f, 0.02835384f, 0.01770609f, -0.05795864f, 
    -0.04214982f, 0.00123157f, -0.00282134f, -0.07135865f, 0.03447839f, 0.07253964f, 0.04956701f, -0.00701718f, 
    0.04825559f, -0.05340609f, -0.00902368f, 0.03331294f, 0.04934029f, 0.01712290f, 0.03092806f, 0.01700425f, 
    -0.02177561f, 0.08190477f, -0.00981209f, -0.03699593f, -0.07344653f, 0.02707434f, -0.01137254f, -0.08032299f, 
    0.00298402f, -0.04677917f, -0.02954562f, -0.01368820f, -0.06464670f, 0.15889950f, 0.11437980f, 0.16168813f, 
    0.09339396f, 0.04518822f, 0.06799115f, 0.00688373f, -0.05872806f, 0.01605457f, 0.01570452f, -0.03621436f, 
    0.05420246f, 0.05221346f, 0.09630790f, 0.00785070f, -0.04015935f, 0.05669741f, -0.03058240f, -0.01510783f, 
    -0.04576195f, 0.08383649f, -0.00282907f, -0.04386427f, -0.38292834f, 0.14621066f, -0.02357114f, -0.11515716f, 
    0.00471876f, -0.08212005f, -0.00235644f, -0.08156043f, -0.03797669f, 0.00836635f, -0.01372279f, -0.04346430f, 
    0.05380988f, -0.16793576f, -0.09250946f, 0.02126606f, -0.06978554f, 0.00484522f, 0.05302161f, 0.00418920f, 
    -0.01386803f, -0.01419347f, 0.01510215f, 0.05798964f, 0.01861452f, -0.07847909f, -0.00982566f, -0.08135092f, 
    -0.06655989f, -0.06153474f, 0.04240379f, -0.04145338f, 0.02446790f, -0.00871590f, -0.02574887f, -0.03838704f, 
    -0.11336344f, -0.01368513f, -0.15172614f, 0.04234276f, -0.04517446f, 0.00845705f, -0.05811996f, -0.00105270f, 
    0.02992263f, 0.00137478f, 0.05249323f, 0.02227107f, -0.04374322f, -0.06573398f, 0.11898537f, -0.03229072f, 
    -0.01073871f, -0.01682839f, -0.02088522f, -0.03390749f, -0.04094090f, 0.07430813f, -0.11212584f, -0.03592036f, 
    0.19151685f, 0.05374223f, 0.08341684f, 0.10580497f, -0.01258948f, 0.00750419f, 0.00264873f, -0.02627907f, 
    -0.02754752f, 0.07141569f, 0.04405493f, -0.09257447f, 0.21092936f, -0.01101065f, -0.04709130f, 0.00813244f, 
    -0.07000878f, 0.00625420f, -0.03939122f, -0.02229894f, -0.05615278f, -0.04778525f, -0.08318158f, 0.00977873f, 
    -0.00040531f, -0.34838837f, 0.02225512f, -0.01148156f, -0.03369458f, -0.05655494f, -0.03361424f, -0.07944133f, 
    -0.02861784f, 0.02735761f, -0.00231321f, -0.04553724f, 0.00603116f, -0.17120256f, 0.01811590f, -0.06166415f, 
    -0.01713267f, -0.08370062f, -0.10487555f, -0.01480577f, -0.13109414f, 0.05205039f, 0.04993364f, 0.04021617f, 
    -0.12592775f, 0.03678888f, -0.21982965f, 0.01864489f, -0.11223629f, 0.01686400f, -0.03315236f, -0.04831753f, 
    0.01070327f, 0.01190218f, -0.03506877f, 0.02532649f, 0.08489759f, -0.29349336f, 0.07370843f, 0.00536260f, 
    -0.07432090f, -0.10474582f, -0.04647223f, -0.10308461f, -0.06153355f, -0.08518378f, 0.00869738f, -0.06438303f, 
    0.00901848f, -0.02030635f, 0.02423289f, 0.15239225f, -0.05042541f, -0.08483040f, -0.02069739f, -0.03309661f, 
    -0.01376569f, 0.05522410f, -0.05569042f, 0.02015548f, -0.01421550f, -0.23343299f, 0.14417465f, -0.11494654f, 
    -0.02209808f, -0.04310742f, -0.01273411f, 0.01385191f, 0.04349254f, 0.06425177f, 0.02804860f, -0.05458596f, 
    -0.18958116f, 0.00925549f, -0.06045287f, 0.04659067f, -0.00004683f, -0.07907917f, -0.07351012f, -0.04331810f, 
    -0.00572490f, -0.00297352f, -0.04128064f, -0.06069697f, 0.20500630f, -0.10818584f, 0.06195460f, 0.10656003f, 
    0.04876339f, -0.02207517f, -0.05578584f, -0.03410281f, 0.00863394f, -0.01558886f, -0.13727048f, -0.07262130f, 
    0.12607250f, -0.00506761f, 0.04004717f, 0.06801967f, -0.06908671f, 0.10789739f, -0.02108330f, -0.01147623f, 
    0.07675008f, 0.06208546f, -0.04150953f, -0.05427695f, 0.12939866f, -0.03224771f, -0.01209368f, 0.06513055f, 
    -0.03585164f, -0.06244721f, -0.03517438f, -0.06373046f, -0.03108536f, -0.00993719f, -0.01252760f, -0.08899102f, 
    0.06058065f, 0.12051544f, -0.03588654f, 0.16220905f, 0.03420267f, -0.04145304f, -0.02738822f, -0.00613684f, 
    0.03007739f, 0.07434619f, 0.05279620f, -0.04082946f, 0.08886222f, 0.12666035f, 0.10429479f, 0.07581814f, 
    0.00429704f, 0.08182218f, 0.00612087f, -0.02409969f, 0.04809236f, 0.00986401f, 0.00617195f, -0.07145907f, 
    0.02825912f, -0.03813137f, 0.11660145f, -0.05965091f, -0.07009634f, -0.02225463f, -0.03941320f, -0.03280229f, 
    -0.03017155f, 0.03199454f, 0.00642496f, 0.02503880f, -0.00767400f, -0.13339587f, 0.06008374f, 0.16306296f, 
    -0.06217894f, -0.10632077f, -0.07741549f, 0.05738001f, -0.04032727f, -0.05518418f, -0.02102914f, -0.07056033f, 
    0.01529556f, 0.00333918f, 0.05039851f, -0.01943992f, 0.12756155f, -0.05682798f, 0.01529404f, 0.06310124f, 
    0.00917463f, 0.07215399f, 0.01076812f, -0.00154161f, 0.14924283f, 0.07952966f, 0.10503753f, -0.13325286f, 
    -0.13585605f, 0.03992340f, 0.06515989f, 0.00485215f, -0.01410758f, 0.04766247f, -0.04748524f, -0.07042115f, 
    0.09155916f, 0.13099988f, 0.00522146f, 0.08900450f, 0.02987552f, 0.07427095f, -0.03881058f, 0.00542256f, 
    0.01295720f, -0.03073768f, -0.00525747f, -0.01787327f, 0.27819377f, -0.10285986f, 0.10327177f, 0.18313158f, 
    0.19695474f, 0.02030162f, 0.00629949f, -0.09955141f, -0.00815239f, -0.15972039f, -0.03999927f, -0.09721345f, 
    0.06832340f, -0.00233712f, 0.07107147f, -0.17459254f, -0.07735861f, 0.02421859f, -0.08048785f, -0.04081941f, 
    -0.06021895f, -0.00317862f, 0.03650073f, -0.06309081f, -0.14023617f, -0.02919953f, -0.14229968f, -0.09114812f, 
    0.01015253f, -0.05316829f, -0.05950242f, -0.06179658f, -0.09932589f, 0.01376791f, 0.06463309f, -0.04346443f, 
    0.26378420f, -0.31319776f, 0.05728853f, 0.02255348f, 0.05561919f, -0.08824263f, -0.08439951f, -0.08403658f, 
    -0.01336570f, -0.04386175f, 0.01066067f, -0.00918447f, -0.13864046f, -0.21363750f, -0.14891325f, -0.27132872f, 
    -0.07903587f, -0.02070214f, 0.00502687f, 0.02441187f, 0.01045189f, -0.02311886f, -0.00183780f, -0.03269622f, 
    0.15073140f, 0.15751293f, 0.13598351f, 0.20975222f, 0.11052844f, 0.11519040f, 0.03437806f, -0.01806454f, 
    -0.06527574f, 0.05596564f, -0.14736234f, -0.02044174f, 0.04605348f, 0.13454485f, -0.15573987f, 0.02617565f, 
    -0.03268715f, 0.00596726f, -0.09807950f, 0.06469639f, -0.01501589f, 0.03687136f, -0.03947486f, -0.04565601f, 
    0.10851424f, 0.08198924f, 0.12989828f, 0.07732708f, 0.01410105f, 0.01228276f, 0.02907298f, -0.03982415f, 
    0.00410558f, -0.05854860f, 0.02407761f, -0.01028455f, -0.06339134f, -0.10399202f, -0.02831179f, -0.04620654f, 
    -0.06458179f, -0.05690977f, 0.03602152f, 0.02712506f, -0.09866943f, -0.00564902f, -0.08663216f, 0.00816160f, 
    0.08706712f, -0.13127908f, -0.03656201f, -0.05499828f, -0.11660618f, -0.00308319f, -0.04271138f, -0.05132496f, 
    -0.03078983f, -0.02228425f, 0.04190498f, -0.04077094f, -0.12910584f, -0.12556593f, -0.03100741f, 0.01563167f, 
    -0.04928625f, -0.00686110f, -0.05947914f, -0.01924437f, -0.02307511f, -0.07013522f, 0.01429063f, -0.06366622f, 
    -0.19624259f, -0.02647956f, 0.00912459f, -0.10308854f, 0.02988076f, 0.01588836f, -0.05101394f, -0.08612092f, 
    -0.00436849f, -0.00632087f, -0.07443479f, -0.07620751f, -0.11279777f, -0.03569884f, -0.06797116f, 0.12006085f, 
    -0.03664125f, -0.03399342f, -0.11360118f, -0.01632655f, -0.06904501f, 0.01639332f, 0.03484232f, -0.09356203f, 
    -0.09753525f, 0.11564079f, -0.07000068f, -0.13513601f, -0.11774353f, 0.00435328f, -0.03183905f, -0.03430533f, 
    -0.04521954f, -0.05228282f, -0.03789872f, -0.01891198f, -0.02283386f, -0.02546162f, -0.03480108f, -0.11370919f, 
    -0.07476006f, -0.01605747f, -0.05644244f, -0.03442390f, 0.04846521f, -0.01838842f, -0.02271000f, -0.02661496f, 
    0.13514450f, 0.19187914f, 0.07350332f, 0.14689428f, 0.10132488f, 0.06205313f, 0.04899899f, 0.07405764f, 
    0.01191013f, -0.00221589f, 0.00203071f, -0.01303502f, -0.01953506f, 0.11353731f, 0.12210447f, 0.01166265f, 
    0.03810243f, -0.04686216f, -0.05777204f, -0.01791497f, -0.10360110f, -0.05968344f, -0.01445889f, -0.06535888f, 
    -0.12949990f, -0.06002980f, -0.08142267f, -0.41656226f, 0.04351017f, -0.13911061f, -0.17546219f, -0.05920450f, 
    0.03033465f, 0.00952307f, -0.00837393f, -0.07078978f, 0.11771528f, -0.04943694f, -0.04018450f, -0.04307093f, 
    -0.05365679f, -0.16607721f, -0.00382096f, 0.03392233f, 0.06562705f, -0.05804817f, -0.12530710f, -0.04977576f, 
    0.05125412f, 0.07597857f, -0.06795868f, -0.04809025f, 0.00848820f, 0.05200623f, -0.04827645f, 0.01688406f, 
    0.05064086f, -0.02675722f, -0.10104296f, -0.04396679f, -0.19503169f, -0.22051907f, 0.04939686f, 0.07053167f, 
    0.06954391f, -0.16220431f, -0.05833191f, -0.14395449f, 0.02729787f, -0.17446291f, -0.13284762f, 0.02891467f, 
    0.14410932f, 0.17106797f, -0.07327393f, -0.13171531f, 0.01030077f, -0.02628598f, 0.00444396f, -0.03397996f, 
    0.06523260f, 0.01899139f, 0.00341911f, 0.10873234f, -0.13259012f, -0.05208839f, 0.00413288f, -0.21201919f, 
    -0.01023085f, -0.05723309f, 0.01482161f, -0.01633756f, 0.02514068f, 0.08061703f, -0.11463824f, 0.10269539f, 
    0.06464049f, -0.18017979f, 0.10263048f, -0.06226780f, 0.00020283f, -0.17160253f, -0.03869069f, 0.00020914f, 
    -0.02410853f, 0.01420066f, 0.07911846f, 0.06115463f, -0.19503556f, 0.08452007f, 0.10524843f, -0.07167505f, 
    -0.18036886f, 0.04955636f, 0.02355725f, -0.06648202f, -0.00431161f, -0.00807783f, 0.10943116f, -0.03031266f, 
    0.02267493f, -0.02982478f, 0.06597000f, 0.10380103f, -0.03040282f, -0.04609692f, -0.00202921f, -0.04048572f, 
    -0.05341474f, 0.03223057f, 0.13511728f, 0.08031245f, -0.14388703f, -0.10817588f, 0.20523930f, 0.05035527f, 
    -0.03974165f, -0.05089993f, -0.02874435f, -0.00534199f, 0.00706249f, -0.01117880f, 0.03975793f, -0.04268121f, 
    -0.10597248f, -0.21025631f, -0.12556282f, 0.13128616f, 0.03957461f, 0.01081258f, 0.03870555f, -0.04332580f, 
    0.07245659f, 0.02856577f, 0.11568805f, -0.03134265f, 0.17728780f, -0.24541837f, 0.03615062f, -0.19058569f, 
    0.00999824f, 0.03611752f, -0.00534104f, -0.04476538f, 0.00509348f, 0.03516685f, -0.00488696f, 0.02491376f, 
    -0.25234136f, -0.29221168f, -0.03998891f, -0.09804542f, -0.01758364f, -0.01521861f, 0.00342616f, -0.04830589f, 
    -0.05403957f, -0.02483036f, 0.08496735f, 0.06806773f, 0.05202078f, -0.17370138f, 0.04658279f, 0.11138061f, 
    0.00239375f, 0.00141752f, -0.03849012f, 0.02720722f, 0.03212054f, 0.06808658f, -0.09628901f, 0.00765481f, 
    -0.11133846f, -0.13218430f, 0.11528952f, 0.12316105f, -0.02877623f, -0.06328200f, -0.09573533f, -0.10984076f, 
    0.03508218f, 0.03900586f, 0.07797570f, -0.08770887f, -0.04265168f, -0.06830317f, 0.01167742f, 0.16326118f, 
    0.11274749f, 0.06213140f, -0.03104780f, 0.01295771f, 0.01447142f, 0.01755614f, 0.04701103f, 0.06319415f, 
    -0.05852632f, 0.07809512f, 0.10991706f, -0.06223815f, -0.02632745f, -0.05657168f, 0.15905501f, -0.07644494f, 
    -0.00008338f, -0.06745715f, 0.05909015f, 0.13234605f, 0.02716455f, 0.27258271f, -0.14400728f, -0.03186099f, 
    -0.02439574f, 0.04867335f, -0.13611828f, 0.00099377f, -0.07268619f, 0.02302125f, 0.03717791f, 0.00213084f, 
    0.11947196f, 0.06107066f, 0.05171607f, 0.08511680f, -0.04667551f, 0.04635007f, -0.05436340f, -0.00034134f, 
    0.13631700f, -0.05124867f, 0.10013542f, -0.00025264f, 0.04639338f, 0.03271462f, 0.07204754f, 0.08767840f, 
    -0.19383018f, 0.00219069f, -0.05710099f, -0.13777693f, 0.00045951f, -0.11959229f, 0.12534775f, -0.00732167f, 
    0.15567055f, -0.09016993f, 0.09338456f, 0.13107988f, 0.01778531f, 0.00781632f, -0.05673866f, -0.03817303f, 
    -0.01323477f, 0.09862535f, 0.05200006f, -0.03348088f, -0.12705837f, 0.01999751f, 0.10501367f, 0.10019844f, 
    -0.13723297f, -0.04253648f, 0.00408187f, -0.04525452f, 0.00375306f, 0.03879076f, 0.00782797f, -0.14424087f, 
    -0.01092034f, 0.14192972f, 0.05624904f, 0.07060268f, -0.05987846f, -0.00399080f, -0.15981671f, 0.02877901f, 
    0.06515193f, 0.06113540f, -0.03033798f, -0.04570774f, 0.03813383f, 0.00691512f, 0.00939600f, 0.20400281f, 
    0.06551635f, 0.01559971f, -0.06908315f, 0.01635369f, 0.06979576f, 0.01853012f, 0.04020577f, -0.02107854f, 
    0.12032965f, 0.04414026f, -0.30882043f, 0.03608117f, 0.09484799f, 0.07273743f, 0.02466681f, -0.03321731f, 
    0.00319469f, 0.01442662f, 0.02087149f, 0.01657531f, -0.06269707f, -0.09055192f, -0.12998968f, -0.17609398f, 
    -0.07985966f, -0.07302330f, 0.07929669f, 0.02542780f, -0.01632999f, -0.01063395f, 0.07551264f, -0.02116846f, 
    0.06650012f, 0.07785511f, -0.01571458f, -0.15400140f, 0.15858126f, 0.04326443f, -0.03260428f, 0.05079707f, 
    0.06544679f, -0.02366738f, 0.05826294f, 0.08901010f, 0.12684707f, -0.10724308f, 0.22184873f, -0.00862318f, 
    -0.05393524f, -0.07828272f, -0.01587359f, -0.02134445f, -0.04780089f, -0.09041679f, 0.04365161f, -0.00985653f, 
    -0.27012059f, 0.00713413f, -0.03761326f, -0.14720644f, -0.02513708f, -0.01209262f, -0.10373192f, 0.02607607f, 
    -0.07114448f, -0.07628284f, -0.08655235f, -0.13554168f, 0.08209190f, -0.31494248f, -0.09889264f, -0.18722029f, 
    0.02330989f, 0.00316303f, 0.08894242f, -0.06378108f, -0.05573115f, 0.03324783f, 0.04025612f, 0.07472449f, 
    -0.08479772f, -0.08932938f, -0.01981539f, 0.02551121f, 0.01792097f, 0.04562626f, 0.01262322f, 0.00344698f, 
    0.14475204f, -0.11881192f, 0.04088787f, -0.06022565f, -0.11514944f, -0.18115461f, -0.04551147f, -0.09208702f, 
    0.02683030f, 0.06828034f, 0.00611277f, -0.04822828f, 0.12486396f, -0.00785680f, 0.04319173f, -0.05668183f, 
    0.04637077f, 0.19586034f, -0.16264482f, 0.02017203f, -0.09227666f, 0.00902605f, -0.00324001f, -0.05702262f, 
    0.03931868f, -0.02513923f, 0.02572588f, -0.13990971f, 0.04024707f, 0.04801784f, -0.09650539f, -0.07613465f, 
    0.00542649f, -0.04141532f, -0.09413540f, -0.08823198f, -0.00583829f, 0.02610914f, 0.02210674f, 0.06905504f, 
    -0.14380512f, 0.03005122f, -0.29859948f, -0.16922183f, 0.05234315f, 0.01751599f, -0.03828643f, -0.02846976f, 
    0.00784196f, 0.06126650f, 0.05974329f, -0.01147792f, 0.11854204f, -0.00284833f, -0.01907866f, 0.05864510f, 
    -0.10827391f, -0.04971998f, 0.00032804f, -0.02104648f, -0.03478942f, 0.11191845f, -0.01987228f, 0.04567433f, 
    0.05183716f, 0.23726249f, -0.19518700f, -0.13966306f, -0.01668886f, -0.06437282f, 0.00811562f, -0.13307451f, 
    0.10160720f, -0.01924029f, -0.01733557f, 0.11185177f, 0.20583376f, -0.22837085f, -0.23257174f, -0.19199538f, 
    0.09315847f, 0.03743600f, 0.04402708f, -0.18300432f, -0.07266911f, -0.00497712f, 0.12094653f, 0.06158658f, 
    0.00109133f, 0.16218641f, -0.06584906f, 0.02721615f, -0.05959393f, -0.06358622f, 0.02607128f, 0.06774810f, 
    -0.00792952f, -0.00479294f, -0.03639384f, 0.01696941f, -0.02553477f, -0.15854403f, -0.04624129f, -0.18771455f, 
    0.00517199f, -0.14059040f, 0.08897776f, 0.03645831f, 0.05252303f, 0.03405790f, 0.05416550f, 0.05933210f, 
    0.02447849f, 0.24077751f, -0.20057152f, -0.17764416f, 0.01111577f, -0.02145371f, -0.15095170f, -0.01456527f, 
    0.05524230f, -0.03200725f, 0.14476752f, 0.08764435f, -0.05650413f, 0.07221051f, 0.09734958f, 0.12267219f, 
    0.00289688f, -0.05907151f, 0.05582077f, -0.02801227f, -0.06033342f, 0.06713655f, -0.14223458f, 0.08919682f, 
    -0.14570089f, 0.05528143f, 0.10617653f, -0.08424748f, 0.01324196f, -0.00283914f, -0.04044436f, 0.00259644f, 
    -0.00328416f, 0.06174726f, 0.00356542f, 0.04459687f, -0.16642056f, -0.03560024f, -0.09811589f, -0.15867577f, 
    -0.04952502f, -0.09409461f, -0.05403418f, -0.01133552f, 0.04966820f, 0.03664199f, 0.06025223f, 0.04288879f, 
    0.12518576f, -0.05208501f, 0.02962104f, 0.10058042f, -0.02352891f, -0.08631845f, 0.02114636f, -0.13596433f, 
    0.03837289f, -0.09033548f, -0.02384617f, 0.04159969f, -0.21079311f, 0.00965246f, -0.12705386f, -0.36167023f, 
    -0.02470417f, -0.05447319f, 0.03294798f, 0.06566140f, 0.11504623f, 0.00741730f, 0.04281513f, -0.07615783f, 
    -0.17472677f, 0.02802983f, -0.02241517f, -0.14417441f, 0.06370198f, 0.01270692f, -0.04328461f, -0.04612110f, 
    -0.08750122f, 0.01787855f, -0.05050351f, -0.16464509f, 0.26519054f, 0.17386843f, -0.02123262f, 0.07944552f, 
    0.01330820f, -0.04316390f, 0.03372113f, 0.05474145f, 0.11040805f, -0.01832654f, -0.03838618f, 0.04287792f, 
    0.01018896f, 0.00883456f, 0.13286416f, -0.00451635f, -0.04233180f, -0.09768433f, -0.03063711f, 0.01520042f, 
    0.02254879f, 0.01106699f, -0.14163186f, -0.06718523f, -0.00103848f, -0.03199204f, -0.16976696f, -0.06280005f, 
    0.07411002f, 0.00469160f, -0.04633466f, 0.02072887f, 0.04463506f, 0.03582487f, 0.11125410f, 0.01976142f, 
    0.11060898f, -0.03980703f, 0.07771534f, -0.10061108f, -0.02297018f, 0.04976565f, -0.05434130f, -0.06563695f, 
    0.04673583f, 0.07669831f, 0.10567479f, -0.01324654f, 0.22358398f, -0.06698330f, -0.23066200f, -0.05960673f, 
    0.12977058f, 0.00869588f, -0.03644938f, -0.10131999f, 0.05949789f, -0.00507801f, -0.00123707f, -0.02548803f, 
    -0.03393184f, -0.07464164f, 0.07255659f, -0.20237477f, 0.06256656f, -0.17648998f, 0.17610259f, -0.11633274f, 
    0.02731550f, -0.06100712f, 0.06277554f, 0.02142312f, 0.01123159f, 0.04495604f, 0.03691274f, -0.03997945f, 
    -0.02931353f, -0.08296527f, -0.00857277f, 0.00293384f, 0.04629343f, 0.04452568f, -0.10680711f, 0.02143995f, 
    0.03069104f, 0.04514481f, 0.05905685f, 0.08453915f, 0.08790012f, -0.01119683f, 0.03859005f, -0.02281895f, 
    -0.03436089f, 0.00228259f, 0.14528771f, 0.07303178f, 0.00429767f, 0.01373624f, -0.01582436f, 0.05074167f, 
    -0.00232110f, -0.02046263f, -0.04373294f, 0.03952328f, 0.06564682f, -0.02632108f, 0.05044765f, -0.04080090f, 
    -0.07718888f, 0.01614738f, 0.02530339f, 0.05973537f, 0.01906336f, 0.00590620f, -0.00154591f, -0.06510589f, 
    -0.04210663f, -0.02774334f, -0.05571312f, 0.09101992f, 0.10692552f, 0.03649884f, -0.07835789f, 0.18688349f, 
    0.17596629f, -0.11450493f, -0.09316278f, -0.07923004f, -0.02870933f, 0.06736615f, -0.24975221f, 0.11629038f, 
    0.15175340f, 0.01455280f, 0.01934968f, 0.02006814f, 0.04838757f, -0.00000529f, -0.10950407f, -0.11295960f, 
    0.03395705f, -0.06684338f, 0.02249750f, 0.03534735f, -0.11815018f, 0.16522220f, -0.19369222f, -0.20042101f, 
    0.08377494f, 0.01531422f, -0.06211284f, -0.04334017f, 0.03678700f, 0.00498097f, -0.09752171f, 0.04356762f, 
    0.13079630f, 0.04262354f, -0.08973797f, 0.10741926f, 0.06534573f, -0.00613800f, -0.08897249f, -0.05504726f, 
    -0.06923837f, -0.04437206f, 0.00187494f, -0.15163741f, 0.18873146f, -0.01090452f, -0.04151537f, 0.01643670f, 
    -0.01620136f, -0.12070435f, 0.00933608f, -0.16471329f, 0.03067860f, 0.06442572f, -0.09600108f, -0.14221735f, 
    -0.33443183f, 0.06174146f, -0.00609186f, -0.08186809f, -0.11647880f, -0.02848536f, 0.02259373f, -0.01678314f, 
    0.02567156f, -0.04161980f, -0.00019568f, 0.04890938f, -0.27746692f, -0.05466161f, 0.11883677f, -0.17675728f, 
    0.08325464f, -0.08898415f, -0.02051261f, -0.11952812f, -0.05195983f, 0.08497767f, 0.04680564f, 0.05589728f, 
    -0.26914802f, -0.18321681f, 0.02291328f, 0.14350900f, -0.07615174f, 0.07896887f, -0.09220605f, 0.10834151f, 
    0.00734056f, -0.13933939f, -0.06231452f, -0.01974763f, -0.31390706f, 0.06623851f, -0.09945972f, 0.10965491f, 
    0.13515252f, -0.05957593f, 0.00948910f, -0.08244118f, -0.10054729f, -0.11871418f, 0.14148267f, -0.08703662f, 
    -0.01596028f, 0.25969636f, 0.15770628f, 0.04022635f, -0.07158364f, 0.02288369f, -0.09796181f, 0.11570600f, 
    0.09843808f, -0.00901937f, 0.05043864f, 0.04096095f, -0.10495391f, 0.16231197f, -0.01412138f, -0.09926908f, 
    -0.06717382f, -0.13605961f, -0.04771179f, 0.05276449f, 0.15818663f, 0.05604534f, 0.08529482f, 0.05536209f, 
    0.40419436f, 0.14547537f, 0.13403729f, -0.05655539f, 0.07769102f, 0.02151141f, 0.06249286f, -0.01624471f, 
    -0.08094753f, -0.07441358f, -0.06515173f, -0.03671126f, -0.00410606f, -0.02857395f, -0.18510248f, 0.13611196f, 
    0.04948972f, 0.01668044f, 0.00394568f, -0.04943144f, -0.10456665f, 0.02330004f, 0.07043572f, -0.04638708f, 
    0.14593354f, 0.16770811f, -0.17321858f, 0.29769072f, -0.03833019f, -0.00411348f, 0.04229296f, -0.02734536f, 
    0.00771864f, 0.13546069f, 0.05361231f, -0.01902208f, -0.10276558f, -0.18483183f, -0.13191527f, 0.04529964f, 
    -0.01946209f, 0.13491964f, 0.02128590f, -0.10041954f, -0.01697907f, -0.01426789f, -0.05711133f, -0.00610632f, 
    0.11519584f, 0.11757651f, -0.12589855f, -0.17442900f, 0.11216594f, -0.07585949f, -0.02381049f, 0.03071495f, 
    -0.01036249f, -0.17708461f, 0.02650389f, 0.03879704f, -0.25807983f, -0.33261973f, -0.08156601f, -0.03156380f, 
    0.09632435f, -0.01143633f, -0.14693144f, 0.00503304f, 0.05911041f, 0.05655529f, 0.04905820f, 0.04072054f, 
    -0.18307582f, 0.13697547f, -0.09874921f, -0.34517372f, -0.00920985f, -0.00334694f, -0.01701521f, 0.05716014f, 
    -0.00910691f, 0.13694403f, -0.13014974f, -0.12759578f, -0.02693328f, -0.10204071f, 0.05496563f, 0.07640342f, 
    0.05419973f, -0.08665955f, 0.02255505f, -0.09447709f, 0.06574383f, 0.04859238f, 0.03376080f, 0.07219704f, 
    -0.00438174f, -0.00637934f, -0.08728977f, -0.04393019f, -0.05409990f, 0.06747428f, -0.01224233f, 0.09077730f, 
    0.02614208f, 0.06102531f, -0.00574275f, 0.04988343f, 0.11285403f, 0.00214843f, -0.04050942f, -0.09990898f, 
    0.09237924f, 0.04560503f, -0.06101693f, -0.13811867f, 0.04188966f, -0.04759705f, -0.00450801f, 0.11439547f, 
    -0.21495840f, 0.00430402f, 0.02835241f, -0.00820625f, 0.03629727f, -0.09562414f, 0.01418556f, -0.13757057f, 
    0.07851519f, 0.04373288f, 0.02953751f, 0.11832463f, -0.32658389f, 0.20211719f, 0.03377135f, -0.37354803f, 
    0.07992025f, 0.10504819f, -0.07101198f, -0.08357638f, -0.10433348f, -0.14754313f, -0.01292025f, -0.21440893f, 
    -0.15221097f, -0.10645059f, -0.04285183f, 0.10426183f, 0.07554746f, 0.02684690f, 0.03187364f, -0.07355083f, 
    -0.07427742f, -0.06751092f, 0.11214723f, -0.13479756f, 0.21319801f, -0.17412528f, 0.13936542f, 0.04655451f, 
    0.01190089f, 0.01952345f, -0.04819820f, 0.17377947f, -0.17015691f, 0.16436817f, 0.07908475f, 0.01638252f, 
    -0.15678337f, 0.25768512f, 0.00545188f, -0.07707574f, 0.03842431f, 0.07130783f, -0.00252140f, -0.10031430f, 
    -0.08743088f, 0.04816115f, -0.09294588f, 0.04910859f, 0.10804363f, -0.21199900f, 0.01940313f, 0.22733180f, 
    0.03506562f, 0.02220247f, 0.09438912f, 0.12867229f, -0.05398366f, -0.01491288f, 0.04710957f, -0.07193182f, 
    0.05362638f, 0.13960755f, -0.36370525f, -0.20544201f, 0.11970209f, 0.04803244f, 0.04480524f, 0.02832492f, 
    0.02910318f, -0.07830796f, -0.07135130f, -0.04258581f, -0.36577049f, -0.32589695f, 0.10603476f, -0.15487479f, 
    0.06627320f, -0.01001724f, 0.01175798f, 0.07986680f, 0.06275191f, -0.09291976f, 0.04668896f, 0.03176311f, 
    -0.07213754f, -0.14975983f, -0.02927553f, -0.13190441f, -0.04691000f, 0.09916415f, -0.00824597f, 0.05718323f, 
    0.04734002f, -0.07159377f, -0.03672705f, 0.03567134f, -0.32332954f, 0.12603518f, -0.18963638f, -0.17531742f, 
    0.03565823f, -0.02354015f, -0.03182887f, -0.00666625f, -0.12277328f, 0.00042363f, -0.10568953f, -0.12515995f, 
    0.03784368f, 0.13323677f, 0.10018289f, -0.17480178f, 0.10675215f, -0.04412482f, -0.05899078f, 0.08168292f, 
    0.10886177f, 0.01519811f, 0.02444611f, 0.05043488f, -0.04660961f, 0.12100525f, -0.04251336f, -0.15857138f, 
    0.00354051f, -0.04227639f, 0.07758449f, 0.05379013f, 0.07680417f, 0.07417262f, -0.15046847f, -0.05186343f, 
    0.13242048f, -0.01629854f, 0.16131306f, -0.10913847f, 0.00465930f, 0.04446581f, -0.04143444f, 0.10105138f, 
    0.04900808f, 0.06538752f, 0.05087962f, -0.05290904f, 0.31390879f, 0.03440290f, 0.02940776f, -0.02833113f, 
    0.16233906f, -0.08168859f, -0.06742615f, 0.10415154f, -0.02211151f, 0.03759832f, -0.11536041f, 0.03976605f, 
    0.04856814f, 0.01446275f, -0.15176868f, 0.13004161f, 0.00609186f, -0.06842134f, -0.04853207f, 0.04916076f, 
    0.01296484f, 0.13673230f, -0.01237986f, 0.02952708f, -0.10332179f, 0.07144688f, -0.02261141f, -0.20343389f, 
    -0.03829542f, -0.06586586f, -0.01413004f, 0.05614146f, -0.09674043f, -0.06542724f, 0.10666356f, 0.17567302f, 
    0.06587104f, -0.12596087f, -0.25004989f, -0.28790689f, -0.05463666f, 0.03352417f, -0.07889266f, -0.01581535f, 
    -0.08625612f, 0.01198167f, -0.03662660f, 0.14687023f, 0.06449874f, -0.25316596f, 0.03565187f, -0.19251861f, 
    0.00691288f, 0.09249666f, -0.05738652f, -0.16329768f, -0.03136770f, -0.08487236f, -0.01592865f, -0.01892192f, 
    -0.36686721f, 0.23065127f, 0.03722941f, 0.14712705f, -0.00822671f, 0.03827374f, -0.10718355f, 0.16237959f, 
    0.08141892f, -0.02779648f, 0.10011613f, 0.06295257f, 0.33267128f, -0.24181810f, -0.07587948f, -0.19755566f, 
    -0.04385562f, 0.07610219f, 0.00088205f, 0.11282231f, -0.07692714f, -0.12036661f, -0.02676068f, -0.17222831f, 
    -0.04550057f, 0.00031549f, -0.19058549f, -0.19039461f, 0.06118145f, -0.06094435f, 0.06283272f, -0.03775589f, 
    0.02868416f, 0.10040782f, 0.01475519f, 0.08264557f, 0.29082140f, 0.10787964f, -0.21256515f, 0.13039416f, 
    0.14465348f, 0.01121024f, -0.07630622f, 0.02770702f, -0.01197735f, -0.15627594f, -0.02569039f, 0.05034795f, 
    0.07343807f, 0.16010673f, 0.06957938f, 0.07689992f, -0.06115116f, -0.02441249f, 0.02560500f, -0.03767746f, 
    -0.05693330f, -0.04292724f, 0.05158117f, 0.00953861f, 0.03333456f, -0.00597865f, 0.16898158f, -0.26465532f, 
    0.01940146f, -0.08714843f, -0.05101709f, 0.06981682f, -0.04386542f, 0.07959071f, -0.05190738f, 0.18570302f, 
    -0.33410817f, 0.44489110f, 0.04187327f, 0.18776166f, 0.05228563f, -0.02953181f, -0.08450916f, 0.12700653f, 
    0.17287633f, 0.07888626f, 0.00180498f, 0.00694459f, 0.16859666f, 0.07670495f, 0.07693793f, -0.09345875f, 
    -0.05710633f, 0.13518931f, 0.02220238f, 0.02963791f, 0.09066509f, -0.16613369f, 0.20008367f, -0.21718161f, 
    -0.16216525f, 0.05567901f, 0.41367748f, -0.09723012f, 0.01006853f, 0.04494014f, -0.11972544f, 0.00114077f, 
    -0.02893767f, 0.02280442f, -0.07872929f, 0.02147553f, -0.01780011f, 0.03163066f, 0.05630232f, 0.00879265f, 
    0.04182699f, 0.03301563f, -0.05569631f, 0.07969100f, -0.02946321f, -0.21137558f, 0.14241993f, -0.19148706f, 
    -0.18468128f, -0.25031927f, -0.01747380f, 0.07835368f, -0.13015164f, -0.07560351f, 0.01788488f, -0.00103524f, 
    0.07242517f, 0.16765247f, -0.06755648f, 0.02263154f, 0.22231047f, -0.20483829f, -0.14859983f, -0.35114139f, 
    -0.08610074f, -0.00482604f, 0.06723978f, 0.15900296f, 0.06948140f, -0.06327289f, 0.12839767f, -0.11512355f, 
    0.31277651f, -0.20163687f, -0.00427779f, -0.03940967f, -0.03492829f, 0.02329036f, 0.03119219f, 0.05451527f, 
    0.13926680f, 0.03411099f, 0.08195134f, 0.05079575f, -0.16877177f, 0.07808793f, -0.20083480f, 0.08713730f, 
    -0.07219446f, 0.04447673f, 0.06325442f, 0.07021421f, -0.09496609f, 0.09999750f, 0.01294990f, -0.02620815f, 
    -0.26966780f, -0.18272528f, 0.01340487f, 0.06890233f, -0.07226803f, -0.00602273f, 0.07529074f, 0.04697320f, 
    0.08361378f, -0.04331221f, 0.00912270f, -0.06651113f, 0.05376470f, -0.57372910f, 0.31407529f, -0.04431265f, 
    0.08645890f, -0.00210197f, -0.03969469f, 0.05464473f, -0.12348413f, -0.02502188f, 0.13262087f, 0.08709390f, 
    -0.02560321f, -0.01184782f, 0.07427488f, 0.01901712f, -0.07369306f, -0.04737169f, -0.02093414f, -0.05314652f, 
    -0.08114150f, 0.07386363f, -0.02743147f, 0.02812318f, 0.03073902f, -0.02486444f, 0.24109739f, -0.00288604f, 
    -0.02422557f, -0.02418896f, 0.01736376f, -0.09052262f, -0.08225062f, -0.00851956f, -0.03417649f, -0.07398438f, 
    0.22154860f, -0.35678801f, 0.02950843f, -0.07318795f, -0.00734909f, 0.04031011f, 0.06626238f, -0.02375101f, 
    0.10593314f, -0.03372769f, 0.09301573f, -0.04745319f, 0.14709432f, -0.05672573f, 0.10630219f, 0.12245755f, 
    0.02978559f, 0.14698845f, 0.02520388f, 0.00142590f, -0.00568981f, -0.19815694f, 0.00754156f, 0.05975783f, 
    -0.02658243f, -0.05216879f, -0.02735496f, 0.01611828f, 0.05062334f, 0.07563919f, -0.21829462f, -0.02636624f, 
    -0.13253194f, 0.04755621f, -0.10175493f, 0.10554882f, 0.48758534f, 0.06129824f, -0.12698217f, -0.18807055f, 
    -0.00357199f, -0.03832744f, 0.07485979f, 0.04155990f, -0.05811391f, -0.06331426f, 0.08191311f, -0.04143580f, 
    -0.08825419f, -0.23438253f, 0.05519351f, 0.04055199f, -0.08057163f, -0.09992138f, -0.15699190f, -0.08362675f, 
    -0.03219209f, 0.12202680f, -0.05941392f, 0.00610386f, 0.07789513f, 0.09145062f, -0.38374507f, -0.03749166f, 
    -0.02798120f, 0.00176661f, 0.03752889f, -0.11794742f, -0.11464400f, 0.08044957f, -0.01665530f, -0.00290474f, 
    0.04754104f, -0.16006792f, 0.04629125f, -0.10493372f, 0.02779971f, -0.10421195f, 0.08562671f, -0.14508313f, 
    0.06815167f, -0.01812829f, 0.08447148f, -0.16576423f, 0.21199575f, -0.44030488f, 0.01761424f, 0.08848276f, 
    0.00864861f, 0.03071908f, -0.07408778f, -0.04505923f, 0.05078880f, -0.05207937f, 0.12720869f, -0.10734478f, 
    -0.04961490f, -0.07895809f, -0.03890512f, -0.18464825f, 0.00588562f, 0.00315054f, -0.00915477f, -0.06956640f, 
    0.10646309f, -0.05767773f, 0.08740707f, 0.08660377f, -0.07534574f, 0.08575785f, 0.18451735f, 0.08310939f, 
    -0.12960097f, 0.07189181f, -0.04971870f, -0.13380484f, -0.06844413f, 0.01972944f, 0.10122800f, 0.03984832f, 
    -0.06929035f, -0.11523613f, -0.01313734f, -0.05442159f, 0.03808723f, 0.07479853f, 0.05307272f, 0.05478332f, 
    -0.01793620f, -0.03571904f, -0.12574834f, 0.10586853f, -0.12228956f, 0.13248822f, 0.00358994f, -0.07550237f, 
    0.04464038f, -0.03878058f, 0.00399576f, -0.01797397f, 0.14886731f, 0.10028035f, -0.04330737f, 0.09789075f, 
    0.03861701f, -0.18738972f, -0.01475667f, 0.01577494f, 0.07110395f, 0.00359761f, 0.00006151f, 0.05938469f, 
    -0.10083118f, -0.00606206f, 0.02443880f, 0.01838658f, 0.16674846f, -0.10650850f, 0.06396378f, 0.12788485f, 
    -0.06454272f, -0.11548091f, 0.10552410f, -0.06466570f, -0.09281973f, -0.02912840f, -0.01737296f, -0.12054190f, 
    -0.01848027f, -0.14099362f, -0.10390222f, -0.01427554f, 0.03445629f, 0.11126043f, 0.04042292f, -0.05700461f, 
    0.00905843f, 0.10457931f, -0.04708607f, 0.01657933f, 0.18791470f, -0.08346157f, -0.05951840f, -0.05471491f, 
    0.01638700f, -0.09753903f, -0.03668310f, 0.00485470f, 0.03985532f, -0.02366155f, -0.10229968f, -0.04309337f, 
    -0.40557182f, -0.28610805f, -0.02244101f, -0.00048544f, -0.05119570f, 0.10053517f, 0.05042674f, -0.04337526f, 
    0.13631016f, -0.11348240f, -0.17760436f, -0.02648243f, -0.14581484f, 0.01390801f, 0.05101550f, -0.04361673f, 
    -0.01549842f, -0.03882211f, -0.06124056f, -0.02457565f, -0.06662063f, -0.24236079f, -0.05723936f, 0.10248958f, 
    -0.23092486f, 0.01942184f, 0.23076276f, 0.10266171f, 0.18167508f, -0.07930931f, -0.04262351f, -0.03650877f, 
    0.04323333f, 0.06764273f, 0.02194141f, 0.13184017f, -0.08702007f, -0.02001764f, 0.05664128f, 0.06497334f, 
    0.06241403f, 0.13312174f, -0.00194786f, 0.04981447f, -0.02094256f, 0.02166538f, -0.01838776f, 0.17883450f, 
    -0.38253805f, -0.15048888f, 0.07244180f, -0.10931382f, 0.05052057f, 0.00843737f, -0.11040491f, -0.01995865f, 
    0.07533348f, -0.07278441f, 0.02485280f, 0.02311199f, 0.31884900f, 0.01497879f, -0.03952787f, 0.03040685f, 
    0.03508971f, 0.03454011f, 0.01019334f, -0.02136456f, -0.06874609f, 0.02424771f, -0.05337458f, 0.06463310f, 
    0.00170900f, -0.08007403f, -0.05830538f, 0.05724938f, -0.02132251f, -0.11916865f, 0.04945587f, 0.05708097f, 
    -0.03921065f, 0.08214444f, 0.07402902f, 0.07960413f, 0.23211575f, 0.01767427f, -0.01118714f, 0.08025403f, 
    -0.16953944f, -0.08346267f, 0.03761122f, -0.02146267f, 0.04084139f, 0.02501469f, -0.05227724f, -0.01869441f, 
    -0.01331277f, 0.03046316f, 0.06486078f, -0.17960005f, 0.04276112f, -0.07228865f, 0.02778269f, 0.06983694f, 
    0.03631039f, 0.10699776f, 0.11073902f, -0.05341833f, -0.10317630f, 0.12187660f, -0.19128981f, 0.13329440f, 
    0.01749918f, 0.03746711f, -0.02449271f, -0.00142201f, 0.02053911f, 0.02398041f, 0.10266789f, -0.01971316f, 
    0.09945265f, -0.07814740f, -0.04435549f, -0.03876685f, -0.00244473f, -0.00401946f, 0.06034864f, 0.12100610f, 
    -0.05672213f, 0.00573873f, 0.05897800f, 0.08759465f, -0.07831509f, 0.02659160f, -0.19476502f, -0.10238383f, 
    0.06207547f, -0.06128942f, -0.03271893f, 0.14317603f, 0.00395801f, 0.04380572f, -0.07003041f, 0.16205680f, 
    -0.25086209f, -0.15087889f, -0.05526770f, -0.05488355f, 0.00395963f, -0.03190983f, -0.07884471f, 0.01136578f, 
    -0.07243211f, 0.05838536f, -0.02448550f, -0.06538564f, -0.50911784f, -0.35906571f, -0.05835402f, -0.18910310f, 
    0.05222421f, -0.05053525f, -0.00187200f, 0.05994989f, 0.09241623f, 0.13478807f, 0.03224181f, 0.14051400f, 
    0.01469153f, 0.12149934f, -0.05326506f, -0.02995321f, -0.09999455f, -0.00295962f, 0.04053213f, -0.02613681f, 
    -0.07823505f, -0.01443772f, 0.12645645f, -0.05372340f, 0.09664368f, -0.07117421f, 0.06221497f, -0.03611969f, 
    -0.04986946f, -0.03141563f, -0.10080498f, -0.07908048f, -0.06180162f, -0.12844199f, -0.02429423f, -0.08352484f, 
    -0.33355775f, -0.27187502f, -0.03987443f, 0.16314512f, 0.08502840f, 0.01201972f, 0.03429426f, 0.06971040f, 
    0.16995744f, 0.01176897f, 0.08510865f, 0.06229213f, 0.19530855f, 0.05122836f, -0.00820532f, -0.03990672f, 
    -0.12102102f, 0.02569848f, -0.04663694f, -0.08239589f, 0.02898199f, -0.15525684f, -0.03180700f, -0.06852076f, 
    -0.36007842f, -0.26616755f, -0.15105939f, -0.17042005f, 0.04373892f, -0.03093595f, -0.01167577f, 0.03913894f, 
    -0.06199984f, 0.14067513f, 0.06147801f, 0.02394954f, 0.24584670f, 0.12302069f, -0.08198301f, -0.02009043f, 
    -0.09286009f, -0.08729771f, 0.04645147f, -0.08804622f, 0.03043500f, 0.02394244f, -0.03203951f, -0.04376023f, 
    0.13454318f, -0.06021601f, -0.06230155f, -0.04566973f, 0.06926771f, -0.03016788f, 0.04137691f, -0.04696698f, 
    0.05901315f, 0.04861235f, -0.03410417f, 0.08925961f, -0.43321830f, -0.23797326f, -0.20819013f, -0.31219777f, 
    -0.01337890f, -0.02408007f, -0.06023863f, 0.08283756f, 0.06974550f, 0.09357677f, 0.00548236f, 0.03707718f, 
    -0.32301229f, -0.05941845f, -0.10749929f, -0.18900318f, 0.04363301f, -0.06250348f, 0.03718816f, -0.06370702f, 
    0.10724907f, -0.02219557f, 0.02674908f, 0.03916780f, 0.16970538f, 0.09869721f, -0.01872724f, -0.03693322f, 
    -0.12270666f, -0.02176673f, -0.10459835f, 0.10226075f, -0.10576069f, 0.02836005f, 0.06992535f, 0.05229490f, 
    -0.13069426f, -0.07340065f, 0.10119440f, 0.12396625f, 0.09308205f, 0.07703239f, 0.02047842f, -0.02034453f, 
    0.04647315f, -0.12756491f, -0.11848179f, -0.00826881f, 0.14428437f, 0.10769165f, 0.03517977f, 0.02786703f, 
    -0.12697193f, 0.05599529f, -0.02925548f, 0.09835988f, 0.04398102f, -0.00207036f, 0.08027330f, -0.03484290f, 
    0.19823073f, -0.09327208f, 0.06760285f, -0.04473725f, 0.03359223f, -0.01418348f, -0.06405462f, 0.13824238f, 
    -0.03169486f, -0.01598094f, -0.14867572f, -0.10459462f, -0.06579039f, -0.06963475f, 0.07882404f, 0.08298871f, 
    0.11564463f, -0.01068469f, 0.08672136f, -0.03509371f, 0.01427135f, 0.11125633f, -0.00970803f, -0.08491646f, 
    0.01495709f, 0.06001181f, 0.02989488f, -0.17813013f, 0.09340501f, 0.07836699f, 0.06985038f, 0.09680649f, 
    0.14372125f, -0.06223359f, 0.02796447f, -0.02918392f, -0.23673752f, 0.17512250f, 0.11444201f, -0.08304815f, 
    0.11423620f, 0.01373982f, -0.00120571f, -0.00515410f, 0.08377533f, 0.02459794f, -0.01041753f, 0.00220838f, 
    -0.14432178f, -0.20405468f, 0.13978931f, 0.03760421f, -0.04695946f, 0.03333342f, 0.08884463f, 0.03563673f, 
    0.08767156f, -0.00833054f, -0.03420870f, -0.15543282f, -0.28111044f, 0.10854301f, -0.01813327f, 0.01430583f, 
    0.04381822f, 0.02793510f, -0.09313199f, 0.10263560f, 0.04707701f, 0.10454670f, 0.06240686f, 0.13243486f, 
    0.21048762f, 0.13960244f, 0.05672866f, -0.03703423f, 0.10258799f, 0.09232599f, -0.07856262f, 0.06951503f, 
    -0.07689157f, 0.05080646f, -0.10299651f, -0.08222967f, 0.27261466f, -0.02448173f, -0.14913905f, 0.00960358f, 
    -0.02557139f, -0.09214548f, 0.02201631f, 0.04900526f, -0.05903072f, -0.00226398f, 0.01938034f, -0.00571710f, 
    -0.12599398f, -0.03684834f, 0.05943914f, 0.12044717f, 0.07368781f, -0.01343636f, 0.03328355f, 0.00630903f, 
    -0.02003600f, -0.01879381f, 0.03611489f, 0.13357146f, -0.09527086f, -0.04387141f, -0.03224979f, 0.00439061f, 
    0.02872890f, 0.01702406f, -0.06782669f, -0.01761485f, 0.01850678f, 0.12395525f, -0.05577828f, -0.06474092f, 
    0.05276350f, 0.01057679f, 0.00329482f, -0.05007095f, -0.10617142f, -0.02509121f, -0.00451260f, 0.02813595f, 
    0.02829762f, -0.19736896f, -0.04043578f, -0.14631936f, -0.03388778f, 0.09235423f, 0.01190299f, 0.18318072f, 
    -0.02856733f, 0.07596771f, -0.00156638f, -0.02284623f, -0.09717108f, -0.04191310f, 0.12497550f, 0.15396683f, 
    -0.04447547f, -0.07893117f, -0.13449724f, -0.08984593f, 0.15401891f, 0.08027162f, -0.01421080f, -0.01662523f, 
    0.00673384f, 0.02487859f, 0.01384407f, -0.04893998f, 0.24957168f, -0.09580379f, 0.08324187f, -0.17157482f, 
    -0.06513466f, -0.04506383f, 0.00961497f, -0.09098499f, 0.01029963f, -0.13583709f, -0.11622767f, 0.04428655f, 
    0.16399729f, 0.03328817f, 0.07278477f, 0.14902952f, 0.00553297f, 0.08648392f, -0.04897869f, 0.11545599f, 
    0.04580120f, -0.05148099f, -0.09552737f, 0.01563967f, 0.28011069f, 0.16064927f, -0.14840946f, -0.11309653f, 
    0.06001026f, 0.06394567f, 0.10428312f, 0.06251054f, 0.13394229f, 0.14175789f, 0.00325966f, 0.14679474f, 
    0.00135513f, 0.03451740f, -0.09962947f, 0.04026079f, -0.15483943f, -0.02432767f, 0.00028037f, -0.04603265f, 
    0.05238551f, -0.00784518f, 0.09076588f, 0.03610324f, 0.07832079f, -0.07072583f, -0.04805858f, 0.07796397f, 
    -0.02837198f, 0.04675941f, -0.11500084f, -0.02885941f, -0.03581937f, 0.07359979f, -0.02714917f, -0.07577246f, 
    0.18021420f, -0.09889052f, 0.01979105f, -0.16153680f, -0.03872158f, 0.08093493f, -0.02840379f, -0.12681048f, 
    -0.03601699f, -0.13010359f, -0.18321399f, -0.14461966f, -0.50119072f, 0.08755507f, -0.22222137f, -0.06250149f, 
    0.02239521f, 0.11645975f, -0.04823749f, -0.03806707f, -0.02745507f, 0.11405420f, -0.07695439f, -0.07429835f, 
    0.10669848f, -0.06288540f, -0.10450464f, 0.05964363f, 0.01241995f, 0.00516978f, -0.02681171f, 0.14265761f, 
    -0.01942110f, 0.07452850f, 0.03939864f, 0.04959972f, -0.22997327f, -0.09924202f, 0.14768018f, 0.04326810f, 
    0.08999113f, -0.03094050f, -0.02015399f, -0.03894240f, -0.02450940f, 0.05640566f, 0.00025764f, 0.08572640f, 
    0.01521657f, 0.27560276f, -0.11511795f, -0.12327358f, 0.01850288f, 0.09039078f, -0.01361052f, -0.02237822f, 
    0.04422748f, 0.08677993f, -0.00543401f, 0.12135541f, -0.70081758f, -0.26826212f, 0.03888495f, 0.19124693f, 
    0.12010042f, -0.07025538f, 0.00457625f, -0.13983795f, -0.00029540f, 0.07169350f, -0.05597906f, 0.08416180f, 
    0.14315957f, 0.02884000f, -0.04869259f, -0.05331652f, -0.06055997f, -0.04456470f, 0.01794668f, -0.10117083f, 
    0.02050651f, 0.09701954f, 0.06898464f, -0.07552876f, -0.39489332f, -0.20317167f, 0.01557839f, 0.16995497f, 
    0.13091715f, -0.00934285f, 0.09735706f, -0.07320546f, -0.00357942f, 0.06611557f, -0.08586514f, 0.03279291f, 
    0.14145832f, 0.00111410f, 0.00011816f, -0.05235248f, -0.12845533f, 0.06223242f, 0.06636030f, 0.11458103f, 
    0.01438115f, 0.02181371f, 0.03059288f, -0.01074611f, 0.12273613f, -0.01878573f, 0.10117116f, 0.13895464f, 
    -0.09949439f, -0.14064541f, 0.07148934f, 0.07948805f, 0.02559883f, 0.12065584f, 0.05450943f, 0.04068700f, 
    0.00242462f, 0.08471446f, -0.10703704f, -0.06344423f, 0.01759135f, 0.08592568f, -0.04573986f, 0.08457001f, 
    -0.04900737f, -0.01529401f, 0.08091058f, 0.03155288f, -0.18640006f, -0.06821773f, -0.15172540f, -0.13054669f, 
    0.01200262f, -0.02433167f, -0.13433024f, -0.07541660f, 0.04072146f, 0.06409869f, -0.04965158f, 0.07964862f, 
    -0.39981273f, -0.06034718f, -0.14915475f, -0.27083483f, 0.10752042f, 0.04457327f, -0.17287360f, -0.08094256f, 
    0.08870703f, -0.12327745f, -0.02399709f, 0.01291956f, -0.21956608f, -0.08944991f, 0.15857364f, 0.04379207f, 
    0.09947992f, 0.02923712f, 0.12928031f, -0.12542596f, 0.01571901f, -0.02916459f, -0.10556615f, 0.00993973f, 
    -0.42621908f, -0.09458651f, -0.14299156f, -0.04926816f, 0.08259856f, 0.02615195f, -0.12780917f, -0.09114443f, 
    0.04613301f, -0.04963143f, -0.00600600f, -0.05758705f, -0.01214171f, -0.09316414f, -0.10721780f, -0.04016490f, 
    -0.01526202f, 0.02281693f, -0.02024684f, -0.07683737f, 0.07982834f, -0.04202753f, -0.15796582f, 0.01994411f, 
    0.07516003f, 0.07044991f, 0.00873407f, -0.06124272f, -0.06963275f, -0.06232704f, -0.01355493f, -0.03873412f, 
    -0.00657223f, -0.08449639f, 0.03792750f, -0.06017894f, 0.11512433f, 0.13869810f, 0.06523575f, -0.04239070f, 
    0.06904581f, 0.04851782f, 0.05478680f, 0.06078243f, -0.05584773f, -0.03416553f, 0.03708591f, 0.01973140f, 
    -0.01019274f, -0.16833200f, -0.01224320f, 0.13648628f, -0.16600090f, 0.06197953f, -0.07522574f, -0.00827356f, 
    0.03832056f, -0.11001232f, -0.01003272f, 0.13503917f, -0.16761917f, -0.16896239f, 0.11367929f, -0.13741507f, 
    -0.08281077f, -0.01561827f, -0.02616837f, 0.03405250f, -0.09097096f, -0.10178898f, 0.04643907f, 0.00304292f, 
    0.05559951f, 0.07262978f, -0.03579831f, -0.03867907f, 0.18967021f, -0.04290978f, -0.06087180f, 0.01907691f, 
    0.02580761f, 0.03350212f, 0.08114592f, 0.00929337f, 0.10319578f, 0.01217830f, -0.11439049f, -0.38286248f, 
    0.07313553f, -0.04051436f, -0.01232506f, -0.08560181f, -0.05341749f, 0.12794073f, 0.04706923f, 0.07168776f, 
    0.11445794f, -0.05462084f, 0.09893616f, -0.14573039f, 0.16360378f, -0.10654723f, -0.16113521f, 0.03626205f, 
    -0.02828011f, 0.10363546f, 0.05261321f, -0.05496877f, -0.14215456f, 0.16547047f, 0.12379337f, -0.02185163f, 
    0.04426560f, -0.05916158f, 0.05273436f, -0.15582126f, -0.01816783f, 0.05710117f, 0.00746729f, -0.12118184f, 
    -0.19982223f, 0.02275031f, 0.12390699f, -0.27387896f, -0.10579941f, 0.05577421f, -0.00459864f, -0.02933230f, 
    -0.09499687f, 0.00542763f, 0.04663612f, -0.04757959f, 0.14728922f, 0.04153289f, -0.14080350f, -0.01211635f, 
    -0.04692842f, 0.02196465f, 0.01525920f, 0.13474461f, -0.03106113f, -0.02932343f, -0.03220952f, 0.03849841f, 
    0.05253616f, -0.10310513f, 0.11555628f, 0.00199440f, -0.00094704f, 0.01978806f, 0.02546616f, 0.07541795f, 
    -0.06232131f, -0.07410891f, 0.03590515f, -0.02154849f, 0.16221496f, -0.10694002f, -0.05304009f, -0.01143209f, 
    -0.05302029f, -0.03350027f, 0.06945112f, 0.00243341f, -0.06175996f, -0.07957457f, -0.05518543f, 0.00077409f, 
    0.19787776f, -0.00912271f, -0.22347045f, 0.04580886f, 0.14506887f, -0.04863684f, 0.01914093f, -0.12987527f, 
    0.01336648f, -0.02817384f, 0.04083024f, -0.04048470f, 0.00259931f, 0.01998715f, -0.00854561f, 0.14084566f, 
    -0.10583252f, 0.07742027f, -0.11958370f, -0.02985112f, 0.04379516f, 0.10601092f, 0.07299442f, 0.09191705f, 
    -0.07936688f, -0.00077489f, -0.11152773f, 0.01803762f, 0.04481180f, -0.05640419f, -0.06369193f, 0.11046756f, 
    0.01138952f, 0.04050254f, -0.01270843f, -0.07186797f, -0.05630968f, -0.06759422f, -0.02162556f, -0.12114759f, 
    -0.05070905f, 0.06138222f, -0.04323145f, -0.02899569f, -0.06949349f, -0.01392258f, 0.02742978f, 0.00976075f, 
    -0.08834459f, -0.06479833f, -0.01690218f, -0.11275761f, -0.01190666f, -0.02978332f, 0.00771453f, 0.08983245f, 
    0.02140529f, -0.04036881f, -0.00260632f, -0.02233932f, 0.29500270f, -0.01806336f, -0.13235149f, 0.03624599f, 
    0.03272469f, -0.01720759f, 0.04082048f, 0.01403474f, -0.01961550f, -0.02600024f, 0.00705978f, -0.00083489f, 
    0.11714170f, -0.07088537f, 0.00414658f, 0.01766348f, -0.08743182f, 0.11726080f, -0.05881104f, -0.03394978f, 
    -0.00697128f, -0.03202420f, -0.10152791f, -0.07982013f, -0.02835025f, -0.01171859f, -0.09247761f, 0.06492849f, 
    -0.05811958f, 0.03841254f, 0.09891686f, -0.09591432f, -0.10444815f, 0.07063432f, 0.14042725f, -0.02272948f, 
    0.02663088f, -0.00954200f, 0.03526721f, -0.14972393f, 0.05047054f, 0.07091179f, -0.00001677f, 0.03357885f, 
    -0.01625287f, 0.02512923f, -0.06354591f, -0.06251538f, -0.05993263f, -0.03044283f, -0.01202453f, -0.01315383f, 
    -0.08837850f, 0.04295870f, 0.02958589f, 0.15560170f, -0.03108010f, 0.05477826f, 0.02911887f, -0.21293664f, 
    -0.08152689f, -0.40003666f, 0.08019821f, -0.03426886f, -0.05668398f, 0.07126533f, -0.02073675f, 0.02998868f, 
    -0.01533983f, -0.07465508f, -0.03625402f, -0.07651296f, 0.08212388f, -0.13735761f, -0.00425226f, 0.06922787f, 
    -0.10576189f, -0.04093706f, -0.07257809f, 0.01091369f, -0.12691294f, -0.01977211f, 0.01071663f, -0.10198768f, 
    -0.07833667f, 0.08031289f, -0.03231616f, -0.00347432f, -0.02074973f, -0.08117761f, -0.01003553f, 0.01316628f, 
    -0.08195778f, 0.05717151f, -0.07826037f, 0.01062879f, 0.12820511f, 0.05782285f, -0.23250693f, 0.10329502f, 
    0.20991333f, -0.01748285f, 0.00525479f, -0.11612656f, 0.00647861f, 0.03121961f, 0.00081458f, -0.00366248f, 
    0.42375675f, -0.15912683f, -0.20039888f, 0.20284082f, 0.00615773f, 0.01899309f, -0.01948775f, -0.04169367f, 
    0.07036418f, 0.01266312f, 0.06196138f, -0.03615957f, -0.12474990f, 0.09703375f, -0.08524222f, 0.09185515f, 
    0.03421694f, 0.01805060f, 0.07737824f, 0.01716404f, -0.01590890f, -0.08324865f, -0.00363781f, -0.02691322f, 
    0.28911787f, 0.08611773f, 0.10232663f, -0.13261960f, -0.00153705f, -0.16093417f, -0.03424290f, -0.00118568f, 
    0.01657638f, 0.02367909f, 0.05472842f, 0.04358510f, -0.12592097f, -0.23449537f, 0.12393689f, -0.20991941f, 
    0.01209289f, 0.09036861f, -0.02935332f, 0.00481710f, 0.03658915f, -0.06753029f, -0.19044147f, -0.04017014f, 
    -0.29868355f, 0.18650918f, -0.00147318f, -0.05354609f, 0.04003337f, 0.00674320f, 0.01525674f, -0.10116872f, 
    0.06848750f, 0.09625785f, 0.11527824f, 0.01663996f, 0.14673278f, -0.00311879f, -0.04535631f, 0.03660919f, 
    0.23277882f, -0.12880449f, -0.08984908f, 0.04848035f, 0.05151553f, 0.07204968f, -0.02591311f, 0.06905150f, 
    0.15370144f, -0.00677242f, -0.04838126f, -0.01411809f, -0.08424778f, -0.05466943f, -0.04205071f, 0.04650455f, 
    0.01842549f, -0.01560146f, 0.07602753f, 0.06322230f, 0.43658805f, 0.17629756f, -0.18222703f, -0.04810994f, 
    -0.08999537f, -0.00491667f, -0.03496058f, 0.06240068f, 0.02586534f, 0.09422565f, 0.10157376f, 0.03814946f, 
    0.06362947f, 0.05861408f, -0.13640499f, 0.09173265f, 0.02083251f, -0.00876552f, -0.05661717f, -0.09536348f, 
    0.03718504f, 0.10290620f, -0.07123757f, 0.01397619f, 0.15793359f, 0.01836288f, -0.05371066f, -0.02279336f, 
    -0.06818762f, 0.00900754f, -0.04844693f, 0.02762886f, -0.14742179f, -0.03223161f, -0.05047921f, 0.04259832f, 
    0.11479007f, -0.20924602f, -0.19438803f, 0.11288859f, 0.00372631f, -0.10083516f, 0.06708713f, 0.10326279f, 
    0.05377998f, 0.02606105f, -0.04280682f, -0.02592917f, -0.20580177f, -0.24668553f, 0.20913406f, -0.05637857f, 
    0.04374637f, 0.00081237f, -0.10779687f, -0.07587203f, -0.03191920f, 0.08492266f, 0.10339361f, 0.11316089f, 
    0.15334462f, -0.07947312f, 0.05601487f, 0.05464815f, -0.05970117f, -0.16306867f, -0.06656533f, -0.00738105f, 
    0.04274549f, 0.05409954f, -0.08661682f, 0.00838672f, 0.22239405f, 0.10841963f, -0.06975672f, 0.18884988f, 
    -0.13074087f, -0.01298853f, -0.01797412f, 0.12571503f, -0.01124141f, -0.06959387f, -0.02007715f, -0.06523307f, 
    -0.05317407f, -0.19391587f, -0.12876375f, 0.03920268f, -0.01215658f, -0.13168523f, -0.00960548f, 0.00445627f, 
    0.02241637f, 0.05074794f, -0.03222470f, -0.07842281f, 0.02349473f, 0.00957684f, 0.05314957f, 0.02464131f, 
    -0.08462320f, 0.11676652f, -0.03932323f, -0.07456657f, 0.01976888f, -0.06424023f, 0.08262742f, -0.03115316f, 
    0.08911929f, -0.26789460f, -0.05552231f, 0.22112122f, 0.09999510f, 0.10186381f, -0.00982037f, -0.03983897f, 
    0.11643286f, 0.09462851f, 0.00689847f, 0.00263869f, -0.30230796f, 0.09482917f, -0.00907422f, -0.02356166f, 
    0.04612631f, -0.03554812f, -0.09290438f, 0.09774154f, -0.01789020f, 0.02371225f, 0.10918005f, -0.08422149f, 
    -0.09538475f, 0.12414986f, -0.04131787f, -0.09838464f, -0.01465524f, -0.02897056f, 0.07729023f, -0.02296993f, 
    -0.00975566f, 0.03731338f, 0.04333713f, -0.01500404f, -0.05412857f, -0.21115012f, -0.10567840f, 0.40366036f, 
    -0.03849396f, 0.04270904f, 0.07098185f, 0.10883615f, -0.07336290f, -0.10580329f, -0.02677926f, -0.10357514f, 
    -0.23956455f, 0.00065184f, -0.04807213f, -0.02618561f, -0.02717306f, 0.06197120f, -0.00669308f, 0.11929590f, 
    -0.10072006f, -0.01253775f, -0.10003439f, 0.03775525f, -0.24403170f, 0.06307316f, 0.13530083f, 0.07082815f, 
    0.21556649f, 0.00591002f, 0.08299666f, -0.00270559f, -0.00428535f, -0.03328906f, -0.06335811f, 0.03469156f, 
    0.06322300f, 0.04300879f, 0.02371174f, -0.08586710f, -0.08316378f, -0.06441881f, -0.13061830f, -0.10277788f, 
    0.08628726f, 0.17081650f, 0.07119712f, 0.08609769f, -0.26975030f, 0.14980528f, 0.01977717f, 0.09140226f, 
    -0.12963730f, 0.12458378f, -0.12908906f, 0.12720697f, 0.03021918f, 0.02296562f, 0.12081689f, -0.01726980f, 
    -0.09781517f, 0.16595326f, -0.01152217f, 0.05306572f, 0.00677863f, -0.01750030f, -0.03139440f, 0.01051632f, 
    0.04199223f, -0.01002242f, 0.01937591f, -0.15576601f, 0.34964746f, 0.25062135f, -0.15078233f, -0.04970608f, 
    0.08987648f, 0.11001993f, 0.01852955f, -0.05000740f, 0.08274856f, 0.01072070f, -0.01065362f, 0.00659794f, 
    -0.36470330f, 0.09024607f, 0.03057723f, -0.02777252f, -0.12062953f, 0.10058086f, 0.00542979f, 0.08169264f, 
    0.03445308f, -0.02996606f, -0.02468230f, -0.01812993f, 0.32627803f, 0.12471312f, -0.05676489f, -0.11434982f, 
    -0.02788015f, -0.06131208f, -0.09282875f, 0.04575915f, 0.00221434f, 0.02345864f, -0.03793178f, 0.05148128f, 
    -0.10682660f, 0.10219581f, -0.18053642f, -0.00022372f, -0.24773388f, 0.06553598f, -0.12212399f, -0.08955099f, 
    0.02809354f, -0.04500868f, 0.10980683f, -0.19708011f, -0.09475974f, -0.19699506f, -0.00970956f, -0.34219694f, 
    0.11887957f, -0.02667737f, -0.02718412f, 0.18809746f, -0.07829060f, -0.07330640f, 0.08873751f, 0.16928703f, 
    -0.04934172f, 0.16241319f, -0.03925551f, 0.04142770f, 0.16264190f, 0.04938661f, -0.05190931f, 0.02969133f, 
    -0.08989273f, 0.03836024f, 0.00221060f, -0.13204372f, -0.10124245f, 0.01260987f, -0.09982581f, 0.18370096f, 
    0.01807407f, 0.01141530f, 0.08802174f, 0.02504632f, -0.03962747f, -0.04793926f, -0.04146578f, 0.12178040f, 
    -0.29019773f, 0.16392469f, -0.17109857f, -0.03561893f, -0.01603573f, -0.00003199f, 0.05035137f, -0.01799939f, 
    -0.12845486f, -0.02657148f, -0.01060768f, 0.04967761f, -0.31848669f, 0.18435594f, -0.12706649f, 0.02434884f, 
    0.06992099f, 0.02647310f, -0.02998218f, 0.15059024f, -0.04412140f, -0.09763955f, 0.06442138f, -0.15772551f, 
    -0.14079779f, -0.19175562f, -0.08307216f, -0.20223811f, 0.08610726f, 0.05752913f, 0.01161073f, 0.01531554f, 
    0.03597046f, 0.02882482f, -0.07451829f, -0.00254851f, 0.18472925f, 0.21839412f, -0.18292178f, 0.04368748f, 
    0.09389586f, -0.13898501f, -0.01904717f, -0.02798841f, 0.01109999f, 0.12330881f, 0.15417185f, 0.12047497f, 
    -0.03687359f, -0.03782875f, -0.21700025f, -0.15109330f, 0.15989460f, -0.05860045f, 0.00687023f, 0.02619520f, 
    0.07897982f, -0.02119692f, -0.02043406f, -0.04381371f, -0.36841467f, -0.32740855f, 0.03296538f, -0.11069550f, 
    0.04242803f, -0.04478791f, 0.05482735f, 0.14532773f, 0.01583698f, -0.00423183f, -0.04026684f, 0.00334609f, 
    0.10568895f, 0.07716465f, -0.05569981f, 0.01884030f, -0.09630889f, -0.00018816f, -0.05651938f, -0.13110502f, 
    -0.02928555f, -0.11637475f, -0.08320186f, -0.14806350f, 0.09936768f, 0.01115413f, 0.04083047f, -0.11108301f, 
    -0.18976858f, -0.05158819f, 0.04152115f, 0.03706662f, 0.07777518f, -0.12763233f, -0.02301358f, -0.06929798f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06644927f, -0.00293375f, -0.05156532f, -0.02505130f, -0.01019288f, -0.02451537f, 0.01491399f, -0.01356505f, 
    -0.01820948f, -0.02948237f, 0.03240794f, -0.01611897f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
