#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18750124f, -0.49629065f, -0.42022347f, -0.65408808f, -0.24350996f, 0.28985155f, -0.51768070f, -0.31512597f, 
    -0.39896724f, -0.33178705f, -0.18951109f, 0.31161624f, 0.00269280f, 0.11899555f, 0.01666393f, 0.07121975f, 
    0.00913756f, -0.18470007f, -0.09256183f, -0.25535181f, -0.09836115f, 0.26647112f, 0.26685780f, 0.16203013f, 
    0.21213256f, 0.43243274f, 0.41606247f, 0.85013092f, 0.11343287f, 0.06493060f, 0.09639736f, -0.25061300f, 
    -0.03901831f, -0.12056346f, 0.22991963f, 0.15481617f, 0.19867203f, -0.26872650f, -0.05763415f, -0.19379693f, 
    0.16400656f, 0.11937542f, -0.28087801f, 0.12239581f, 0.29302135f, -0.02409286f, 0.11961143f, 0.23615010f, 
    -0.00721023f, 0.43469328f, 0.27775985f, -0.38613594f, -0.68028885f, -0.30005863f, -0.18320718f, 0.39108202f, 
    0.48431054f, -0.33642715f, 0.33993030f, 0.44371906f, 0.22568627f, 0.57233733f, -0.06304793f, 0.00568187f, 
    0.33579090f, 0.08904506f, -0.22204155f, -0.06748736f, 0.15486473f, 0.10180737f, -0.00390270f, 0.11934725f, 
    -0.01879504f, 0.36435637f, -0.13272274f, 0.12405699f, -0.27236545f, -0.28750908f, 0.13352726f, -0.22729847f, 
    0.01075435f, 0.58981961f, 0.62438446f, 0.45118448f, 0.37541118f, -0.02845593f, -0.08912507f, -0.44185451f, 
    -0.16739649f, -0.15495224f, 0.11782993f, 0.14505991f, -0.25658867f, 0.20281199f, -0.09325381f, -0.10391445f, 
    0.13607243f, 0.36405975f, 0.10932936f, -0.06307743f, -0.33487001f, 0.02201609f, 0.07947400f, 0.02488246f, 
    0.45744255f, -0.57842022f, 0.03522304f, 0.39771873f, -0.52168620f, -0.19786149f, 0.38590863f, 0.13070588f, 
    -0.19865113f, 0.37674597f, 0.21069992f, 0.48759022f, -0.11228645f, -0.32615361f, 0.18511054f, -0.03125523f, 
    -0.01152732f, 0.01434267f, 0.19953828f, 0.17145289f, -0.35530335f, 0.38704050f, -0.36191967f, 0.45933253f, 
    0.67892337f, 0.20062447f, -0.44917041f, 0.07538877f, -0.34703276f, 0.15568581f, -0.24764822f, -0.44049430f, 
    -0.29599807f, -0.40835801f, -0.28067660f, -0.25775504f, -0.25761095f, 0.03049549f, -0.31619853f, -0.00236986f, 
    0.10978407f, -0.04751771f, -0.01831009f, -0.18901803f, -0.16855878f, -0.22927681f, 0.77025020f, 0.53528476f, 
    -0.61474007f, -0.67542666f, -0.80335957f, -0.00172443f, -0.14247374f, -0.11463307f, -0.13536246f, -0.05850263f, 
    -0.22067207f, -0.10068503f, 0.15047550f, 0.28841543f, 0.08352045f, 0.12074272f, -0.04248958f, -0.20136175f, 
    0.01669730f, 0.07308406f, 0.20134518f, 0.12109367f, 0.06463559f, -0.02946443f, 0.12204765f, -0.46323907f, 
    -0.60278785f, 0.43020019f, 0.62241948f, 0.21544135f, 0.66505522f, 0.91762960f, -0.00321614f, 0.19365512f, 
    0.11510672f, -0.34706071f, -0.02635008f, -0.20930780f, 0.22357590f, 0.18098408f, 0.00387262f, 0.18123969f, 
    -0.22995184f, -0.24904676f, -0.16312453f, 0.15766566f, 0.19916922f, -0.10300061f, -0.05230783f, -0.09075736f, 
    -0.51231450f, 0.58666044f, -0.71566713f, -0.74010563f, 0.02281559f, 0.47503451f, -0.47296789f, 0.26299265f, 
    -0.03652154f, 0.26327685f, 0.39304152f, -0.27341402f, 0.12305616f, 0.06794463f, -0.47210413f, -0.16435233f, 
    0.00213312f, 0.08705196f, 0.07038015f, 0.23668697f, 0.14510877f, -0.07167000f, -0.02987225f, 0.06129434f, 
    0.12328679f, 0.27985731f, 0.37924054f, 0.45397985f, 0.61691540f, 0.50634420f, 0.05413408f, 0.29430282f, 
    0.25712708f, 0.04121727f, 0.39715004f, -0.52447259f, -0.44973290f, 0.39164722f, -0.06843385f, 0.09918335f, 
    -0.12625194f, 0.23860574f, 0.10902535f, 0.02053450f, 0.11924578f, -0.10579126f, -0.12140052f, -0.32495862f, 
    0.21764380f, -0.16338611f, 0.57109118f, -0.12890723f, -0.10069814f, 0.06973760f, 0.24476749f, 0.37840724f, 
    -0.18950330f, 0.33534807f, 0.49906260f, 0.41546205f, -0.52771753f, 0.30190095f, -0.14326325f, 0.09617577f, 
    -0.22987881f, -0.08207203f, -0.39982569f, -0.30464813f, -0.30266240f, -0.33021793f, -0.24099034f, -0.01486017f, 
    -0.10782246f, 0.13114761f, -0.04654452f, 0.08785241f, 0.00648486f, 0.27493387f, -0.39247194f, 0.28330299f, 
    -0.76211989f, -0.24082623f, -0.36378559f, -0.58342046f, 0.25519386f, -0.37871438f, 0.56818789f, -0.22146510f, 
    -0.04169773f, -0.00932777f, 0.09707768f, -0.30342075f, -0.23484176f, 0.05166354f, -0.22223623f, 0.08194606f, 
    0.21672343f, -0.00515084f, 0.02517768f, -0.20117997f, 0.51802558f, 0.18192407f, 0.30085477f, -0.09751667f, 
    0.31375518f, -0.39967656f, 0.13602582f, -0.18724093f, -0.40864456f, 0.42084241f, -0.38185379f, 0.01680645f, 
    -0.17505506f, 0.28055283f, 0.07528001f, -0.24158619f, 0.06549894f, 0.29825553f, -0.15741850f, -0.46273977f, 
    0.09893780f, -0.04498729f, -0.26722372f, -0.00947787f, 0.29553473f, 0.62956583f, 0.11782861f, 0.44772169f, 
    0.00244496f, 0.41892108f, 0.27719477f, -0.51292545f, -0.56378633f, -0.36698341f, -0.37012342f, 0.30863008f, 
    -0.15587434f, -0.42319518f, -0.24707590f, -0.17385967f, 0.25681728f, 0.09735145f, -0.33983615f, -0.06119775f, 
    -0.24773222f, 0.04418050f, 0.00349455f, 0.28548279f, 0.21811850f, 0.42789996f, -0.39504528f, -0.64322835f, 
    0.14155830f, 0.65698016f, -0.13579737f, -0.73879474f, -0.05821703f, 0.34921438f, -0.55509996f, -0.34329191f, 
    0.23650341f, 0.17632887f, -0.12158202f, 0.09597775f, 0.07405218f, -0.09334834f, 0.23772977f, 0.14164455f, 
    0.05884440f, -0.34094864f, -0.21242505f, -0.20604433f, -0.09994557f, 0.35504651f, 0.05271424f, -0.81061310f, 
    -0.01242674f, -0.34151956f, -0.48719996f, -0.44257063f, 0.66373092f, 0.42278066f, -0.06358925f, 0.55804801f, 
    0.54173356f, 0.19917433f, 0.02334829f, 0.20389363f, -0.26637647f, -0.11729039f, 0.14010645f, 0.13443306f, 
    0.11574602f, -0.00899947f, -0.00725414f, -0.05422947f, -0.10868891f, 0.12444895f, 0.19404714f, 0.17399846f, 
    0.76566929f, 0.46549553f, 0.45175281f, -0.10072025f, -0.15752040f, -0.04723050f, 0.48937756f, -0.37181643f, 
    -0.36209524f, -0.31776252f, 0.12191445f, 0.33140081f, -0.03467675f, 0.20129858f, 0.18186849f, 0.05818325f, 
    0.20041618f, 0.10552175f, 0.17233077f, 0.28364679f, -0.15871722f, 0.37091929f, 0.07561401f, 0.21274777f, 
    0.15207279f, 0.79311401f, 0.46182486f, 0.26318115f, 0.52523583f, -0.62099004f, -0.16199714f, -0.53664786f, 
    0.37095353f, 0.07472734f, 0.24920610f, -0.05455711f, -0.09529067f, -0.05464920f, -0.10838938f, -0.05617397f, 
    -0.01866395f, -0.09995455f, -0.22002074f, -0.27627653f, 0.06255895f, -0.06844614f, 0.16848892f, -0.15626219f, 
    -0.20304397f, -0.03471635f, -0.31594750f, -0.24888511f, -0.02523296f, 0.01821092f, 0.67568558f, -0.23961924f, 
    -0.47311345f, -0.15451555f, -0.74827617f, 0.20991346f, -0.45143676f, 0.38700390f, 0.42631108f, 0.02059451f, 
    0.20755737f, -0.06992701f, -0.22854701f, -0.16285186f, 0.15697919f, -0.17878449f, 0.17847686f, -0.40206382f, 
    -0.23183767f, 0.04081013f, -0.19617973f, -0.11779424f, 0.63186306f, 0.50848567f, -0.44926095f, -0.63160330f, 
    -0.60126621f, 0.33873674f, 0.17386535f, -0.53124887f, -0.37475169f, 0.09004410f, 0.31794178f, -0.28158712f, 
    -0.14514077f, -0.20671338f, 0.11686230f, -0.17609324f, 0.20157652f, 0.32982883f, -0.21849543f, 0.26160091f, 
    -0.21260199f, -0.10438381f, -0.20107302f, 0.17025952f, -0.72188377f, 0.28434923f, 0.26485854f, 0.42271912f, 
    0.58276778f, -0.61299074f, 0.43777633f, -0.60833353f, -0.22382160f, -0.28679407f, 0.19442016f, 0.15674004f, 
    0.41968265f, 0.11489324f, -0.10416672f, 0.03331567f, -0.08178047f, -0.15205784f, 0.02348749f, 0.16127692f, 
    0.09543920f, 0.26569349f, -0.08425053f, 0.06323425f, 0.27634639f, 0.20279172f, 0.20950247f, -0.28671399f, 
    0.12710413f, 0.57696307f, -0.12095164f, -0.80231702f, -0.41329849f, -0.45678201f, -0.32335961f, -0.01175481f, 
    -0.05475043f, 0.37550947f, 0.23666537f, -0.05419088f, -0.15170105f, 0.10278131f, 0.35924903f, 0.32323676f, 
    -0.19189027f, 0.01593620f, 0.22254452f, 0.10186311f, -0.36432925f, -0.05886856f, 0.33721447f, 0.54597676f, 
    0.35039780f, 0.87182373f, 0.28947854f, 0.41848043f, -0.11090668f, -0.68528748f, 0.27935174f, -0.21296580f, 
    -0.09274302f, -0.21403867f, 0.07609203f, 0.32844833f, -0.48444903f, -0.21977182f, 0.12365038f, 0.00452963f, 
    -0.17456846f, 0.07445602f, 0.28259948f, 0.07792684f, 0.04808015f, -0.00356192f, -0.03913359f, -0.19134454f, 
    -0.60197747f, 0.40038171f, 0.24160887f, 0.28933895f, 0.43067178f, -0.21162969f, 0.69297111f, 0.29082894f, 
    -0.73691124f, -0.07728784f, -0.33441433f, -0.34481108f, -0.02572814f, 0.16367550f, -0.14408664f, 0.07921506f, 
    -0.09943842f, 0.12462678f, 0.22446020f, -0.43242958f, -0.14758529f, -0.11929514f, -0.29385063f, 0.00247442f, 
    -0.11321538f, -0.38134432f, -0.19960406f, -0.21066479f, 0.06917118f, 0.03271697f, -0.00815487f, -0.04981512f, 
    0.43036273f, -0.50401050f, -0.47861397f, 0.03108052f, 0.33354038f, -0.45530078f, -0.36259654f, 0.18153371f, 
    -0.02953285f, -0.13161270f, -0.27389398f, -0.05327857f, -0.03931480f, 0.12429796f, -0.10731060f, 0.44352412f, 
    -0.07812049f, 0.10116918f, -0.30040258f, -0.86197937f, 0.76819056f, 0.49069330f, 0.19784124f, 0.27155560f, 
    -0.25732285f, 0.72261131f, -0.45024115f, -0.31492850f, -0.04713366f, -0.10164312f, 0.21523142f, -0.16829006f, 
    0.14248437f, -0.09663628f, 0.02571489f, 0.00119456f, 0.05011502f, 0.18404520f, -0.21892713f, -0.10485709f, 
    0.16978572f, 0.23866484f, -1.04525173f, 0.28808382f, 0.84689856f, -0.66817915f, 0.24370958f, 0.62310219f, 
    0.11080368f, 0.15767191f, 0.28012273f, -0.19184121f, 0.06249205f, -0.02657290f, -0.27383074f, -0.22377905f, 
    -0.32737467f, -0.39352089f, -0.29476845f, -0.17732498f, -0.38256487f, -0.22246136f, -0.05712430f, -0.01923203f, 
    0.02180429f, 0.11610716f, -0.11714485f, -0.14182362f, -0.98435640f, 0.11540452f, 0.63524604f, -0.06639431f, 
    -0.49071735f, 0.51404440f, 0.09769613f, -0.02597672f, -0.09022978f, 0.03539369f, 0.31471685f, -0.12965401f, 
    0.23492470f, -0.14805183f, 0.28558296f, -0.17347918f, -0.19488090f, -0.01744430f, -0.30375841f, -0.33033517f, 
    0.01838065f, -0.08577222f, 0.38454360f, -0.26239955f, 0.17536621f, 0.67132264f, 0.37326744f, 0.08834738f, 
    0.60387135f, 0.00773042f, 0.18720746f, 0.65594995f, -0.54494190f, 0.21288186f, -0.41081166f, -0.05526249f, 
    0.09520703f, 0.13987198f, 0.14867839f, -0.02664378f, -0.07450490f, 0.10662625f, 0.16121128f, 0.18309562f, 
    0.12130377f, -0.21629162f, 0.23796731f, -0.10680746f, -0.00078669f, 0.67128062f, 0.40292546f, -0.03176636f, 
    0.30680242f, 0.46837685f, -0.02882774f, -0.37204176f, 0.52559209f, 0.42379126f, 0.19425049f, -0.44157699f, 
    -0.18020628f, -0.37895912f, -0.21891406f, -0.09086782f, 0.25710016f, 0.00199816f, -0.17101637f, 0.00223914f, 
    0.16116709f, -0.23644480f, -0.22003825f, -0.00089881f, 0.00464191f, -0.31266388f, 0.84938508f, 0.70345914f, 
    0.26093382f, -0.25668520f, -0.68506461f, -0.33304411f, 0.13221864f, -0.10157395f, -0.08796767f, 0.57663393f, 
    0.30495986f, -0.08217353f, -0.04810306f, 0.17822731f, -0.16133957f, -0.04193456f, -0.28428459f, 0.03849616f, 
    -0.06085708f, 0.06114860f, 0.07394920f, 0.09504191f, 0.14125128f, 0.03427207f, 0.10772127f, -0.24873058f, 
    -0.51733172f, -0.30352202f, -0.29631200f, -0.42899802f, -0.45515850f, -0.20566937f, 0.14971678f, 0.19755769f, 
    0.26625565f, 0.08220425f, -0.24015827f, 0.08459869f, -0.15642582f, -0.36521423f, 0.21499495f, -0.02560446f, 
    0.22626597f, -0.27032089f, 0.21005999f, 0.07633445f, 0.33651522f, -0.05379333f, 0.36599597f, -0.03316252f, 
    0.43395364f, 0.18812378f, 0.37073508f, 0.62980783f, -0.25271314f, 0.11263193f, -0.81755215f, 0.31627548f, 
    0.02782171f, 0.26485395f, 0.30123535f, -0.34235156f, -0.02709911f, 0.05016740f, 0.22945054f, 0.00919235f, 
    0.02046482f, -0.12045740f, -0.15643916f, 0.28695309f, 0.06848960f, 0.11835402f, 0.41157207f, 0.16172957f, 
    -0.14208560f, -0.52130520f, 0.37094033f, 0.16168030f, -0.59237897f, -0.68309283f, 0.46276221f, 0.68997961f, 
    0.32955074f, 0.16361094f, 0.06936517f, -0.29844928f, -0.16348706f, -0.33252022f, -0.08491714f, -0.02677874f, 
    -0.22173056f, -0.04913177f, -0.00684398f, -0.04181260f, -0.14302368f, -0.08814146f, -0.06157461f, -0.19092858f, 
    -0.22433956f, -0.14289267f, -0.63558769f, -0.05678546f, -0.18447167f, -0.00732116f, 0.62502396f, -0.17918800f, 
    0.36814296f, 0.61932981f, -0.55338204f, 0.06597042f, 0.22815345f, 0.10159030f, 0.25305089f, 0.17795834f, 
    0.40821624f, -0.41515294f, 0.30403984f, 0.11372896f, -0.11693418f, 0.25988600f, 0.39728102f, -0.22935645f, 
    0.00833606f, -0.08748057f, -0.44352844f, 0.60506564f, 0.43501315f, 0.43351346f, -0.19685146f, -0.31820869f, 
    0.34156966f, 0.18397762f, 0.29697803f, 0.35938320f, 0.59252769f, -0.16627245f, -0.05190424f, 0.09746260f, 
    -0.41283092f, -0.34734342f, -0.16313547f, -0.04314984f, -0.12849776f, -0.10342026f, -0.28602651f, -0.05304476f, 
    -0.21791781f, 0.22570132f, -0.18791753f, -0.29548469f, -0.17605580f, -0.51498860f, -0.25956327f, 0.19672234f, 
    0.41827771f, -0.82788563f, 0.43820828f, -0.17354338f, -0.65555733f, 0.17321457f, -0.42197654f, 0.02726240f, 
    0.01148760f, -0.14245439f, 0.19381128f, -0.16063029f, 0.33302632f, 0.19069088f, 0.09331898f, 0.01741451f, 
    0.07103977f, -0.29979664f, 0.01295081f, -0.12011871f, 0.10027939f, -0.11848620f, -1.04275334f, 0.56899631f, 
    0.35954249f, -0.19777228f, 0.24094392f, 0.00458298f, 0.43091634f, 0.08828723f, -0.06407768f, 0.04923997f, 
    -0.28617516f, -0.34187010f, 0.21737033f, -0.14327905f, 0.25336617f, 0.31963846f, 0.26537323f, 0.20443882f, 
    -0.24688371f, -0.09636388f, -0.12660080f, -0.06165498f, -0.35746902f, -0.16887826f, 0.15455192f, -0.69842470f, 
    -0.68903327f, -0.22966960f, -0.16644639f, 0.15868467f, 0.56395185f, -0.26030937f, 0.35515580f, 0.51665264f, 
    0.00668231f, -0.23818058f, -0.32121223f, 0.15489297f, -0.08780791f, -0.26500747f, 0.13308597f, -0.05256682f, 
    -0.11263657f, -0.20040008f, -0.12985267f, 0.24542113f, 0.03030774f, 0.31256083f, 0.12141959f, 0.78071570f, 
    0.63102871f, 0.29154393f, 0.34354225f, 0.66910696f, -0.37363791f, -0.50342363f, -0.40091398f, 0.35393327f, 
    0.08240309f, 0.17301878f, -0.00789276f, 0.21572931f, -0.06776712f, 0.04947337f, 0.26018220f, -0.12592310f, 
    -0.04542248f, 0.24592079f, 0.02918589f, 0.18675201f, 0.09304470f, 0.10069942f, -0.04677623f, -0.00005589f, 
    -0.08603092f, -0.67557704f, 0.17258842f, 0.58699822f, -0.25388971f, -0.66066718f, -0.58503580f, 0.39243919f, 
    -0.46674073f, -0.00561464f, 0.21464339f, 0.16137160f, 0.26141709f, -0.10891022f, 0.24360193f, -0.08783109f, 
    0.35161328f, 0.22858126f, -0.10514423f, 0.12524869f, 0.24410161f, 0.07312677f, 0.06316777f, 0.16660932f, 
    0.17311811f, -0.32164916f, -0.30737284f, -0.80286920f, -0.51259685f, -0.10472927f, -0.76359826f, -0.14823237f, 
    0.33617374f, -0.02670453f, 0.38448346f, 0.17778747f, 0.18151742f, 0.35581550f, -0.13490808f, 0.25349468f, 
    0.20489357f, -0.00290787f, 0.05344390f, 0.04748078f, -0.10930201f, -0.16203593f, -0.23605853f, 0.01864830f, 
    0.15697926f, -0.19364877f, 0.76207072f, -0.17460568f, -0.33208904f, -0.36730045f, -0.56463927f, -0.47670841f, 
    -0.07103430f, -0.16360933f, -0.04895344f, 0.23419684f, 0.54093593f, 0.38815558f, 0.34321553f, -0.15359077f, 
    -0.29187125f, 0.24306561f, 0.06290761f, 0.01851928f, 0.13408370f, 0.37695190f, -0.14609945f, 0.13500316f, 
    -0.06040773f, 0.04164014f, 0.07733692f, -0.36902711f, -0.25797775f, -0.17564018f, -0.26895735f, -0.47637388f, 
    -0.07682320f, 0.87869567f, 0.45538485f, -0.04642684f, -0.19041963f, -0.29671532f, -0.00046454f, -0.22605769f, 
    -0.22262019f, 0.12654105f, -0.09991667f, 0.00697477f, 0.08327364f, 0.15914965f, 0.12595148f, 0.13564621f, 
    -0.08689363f, -0.06012845f, -0.14947353f, 0.17910539f, 0.16628699f, -0.04765332f, 0.09550950f, 0.13615046f, 
    0.63569248f, 0.77633303f, -0.30052251f, -0.58682674f, 0.02143938f, 0.04422214f, -0.45732424f, -0.08574837f, 
    0.21407871f, 0.17469957f, -0.34831989f, -0.20667639f, -0.07549509f, 0.28345534f, 0.17489304f, 0.00982321f, 
    0.13531823f, 0.21986434f, -0.20177963f, -0.32670763f, 0.05650640f, -0.18843323f, -0.16640855f, -0.77832597f, 
    0.33469489f, -0.30432415f, 0.56004423f, 0.29332206f, 0.05848016f, 0.34977952f, -0.63071620f, -0.36363786f, 
    0.04666735f, -0.07653536f, 0.10050554f, -0.10814556f, 0.10454969f, -0.24598511f, -0.34898686f, 0.02202850f, 
    -0.09207199f, -0.08275620f, 0.31141838f, 0.36454552f, -0.26343751f, -0.07770483f, 0.71852851f, 0.43199977f, 
    0.59724438f, 0.46609744f, 0.48394555f, 0.07457393f, 0.20100030f, -0.40961143f, 0.29243451f, 0.06788141f, 
    0.19806853f, 0.25836608f, -0.10584633f, 0.01006543f, -0.27433977f, -0.29742378f, -0.16745199f, -0.01977540f, 
    0.09464759f, -0.13594519f, 0.16336380f, 0.46100408f, -0.10711733f, -0.21773885f, 0.34722191f, 0.77990711f, 
    0.03978351f, -0.49236259f, 0.51091206f, -0.12083058f, 0.45285472f, 0.20490462f, -0.12946378f, 0.45819944f, 
    0.31657317f, -0.00243458f, 0.16364378f, -0.14251883f, 0.23169096f, 0.15932854f, 0.18377274f, 0.01378737f, 
    0.07352479f, 0.12602708f, 0.22556244f, 0.44364122f, 0.40305081f, 0.10470996f, -0.30415106f, -0.00774375f, 
    -0.79703307f, 0.14605951f, 0.55935955f, 0.68395263f, -0.23376951f, 0.22769020f, 0.10878995f, 0.43819126f, 
    0.24496557f, -0.13893455f, -0.12905137f, -0.00107648f, -0.02023989f, 0.32964176f, 0.26460043f, -0.01951188f, 
    0.32757199f, -0.13525206f, -0.19974665f, -0.01835671f, -0.03056704f, 0.20470296f, -0.17173856f, -0.01156030f, 
    -0.30430958f, 0.21270594f, 0.27032810f, 0.59895641f, 0.55022866f, 0.33391711f, -0.40916416f, -0.34555292f, 
    0.01810737f, -0.39855486f, -0.24209127f, 0.37899789f, -0.07288484f, -0.02923018f, 0.53777897f, -0.14486167f, 
    0.31401020f, 0.25737250f, 0.44285339f, -0.17923629f, 0.00293923f, -0.01479449f, -0.07053861f, -0.07466742f, 
    -0.26852319f, 0.18212193f, 0.01933491f, 0.42463434f, -0.62353212f, -0.57609397f, 0.45501813f, -0.60037965f, 
    -0.28439340f, 0.23072569f, -0.08551125f, 0.21666858f, 0.34031940f, -0.42405647f, 0.12203074f, 0.08014891f, 
    0.10672202f, 0.12686720f, 0.36237785f, -0.34043640f, 0.36536825f, 0.35300428f, -0.04870993f, 0.19909407f, 
    0.13563198f, -0.33101183f, 0.25564280f, 0.68815613f, -0.37419921f, 0.35650787f, 0.31952465f, 0.48873878f, 
    0.51274520f, -0.11054964f, 0.09659923f, 0.02733514f, 0.19028908f, -0.26725495f, 0.16345172f, 0.13203245f, 
    0.07792293f, 0.19818051f, 0.33275813f, -0.00071051f, -0.11424357f, -0.25875437f, -0.22742744f, -0.05122896f, 
    -0.29983377f, 0.07571480f, -0.14556062f, -0.20512691f, -0.37294444f, -0.29169565f, -0.43238300f, -0.68075824f, 
    0.15466835f, -0.42942312f, -0.31194386f, 0.08004995f, 0.40634093f, -0.40717790f, -0.37103733f, -0.15984598f, 
    0.01944815f, -0.00934586f, 0.01667009f, 0.35111088f, 0.05653042f, 0.06827946f, 0.23405175f, 0.19179972f, 
    0.10037080f, -0.14461082f, 0.15926710f, 0.18350704f, 0.09647888f, 0.00055782f, 0.91961432f, -0.67278671f, 
    -0.16961128f, 0.26966733f, 0.32228589f, -0.74074805f, -0.01737816f, -0.58176225f, -0.52963662f, 0.11454120f, 
    0.01726309f, 0.09909138f, 0.20191514f, 0.05561860f, 0.06529014f, -0.24662569f, -0.15980375f, -0.04569559f, 
    0.44774756f, -0.09743022f, -0.07851848f, -0.20034960f, 0.03013208f, -0.28002676f, 0.62797093f, 0.52958924f, 
    0.48609963f, 0.54143661f, -0.21298748f, 0.30279222f, 0.16944723f, -0.00650610f, -0.66808283f, -0.32684392f, 
    0.28434536f, 0.00022478f, 0.24139485f, 0.04488603f, -0.32455921f, -0.16349143f, 0.16001353f, -0.04615459f, 
    -0.01853873f, -0.21078224f, -0.30819657f, 0.19631304f, -0.15659234f, 0.22094147f, -0.03621699f, -0.46377873f, 
    -0.42534769f, -0.57325935f, -0.58474267f, -0.13847506f, -0.24971919f, 0.59377670f, 0.59345937f, 0.15900764f, 
    0.34893131f, -0.30493453f, -0.05529010f, 0.20430025f, -0.43829119f, -0.17557801f, 0.03647432f, -0.01831335f, 
    0.13526495f, 0.29064730f, -0.43461955f, -0.25799063f, -0.10662124f, -0.23810084f, -0.17719892f, 0.25285417f, 
    0.28545898f, -0.86360753f, 0.06399854f, 0.39597866f, 0.49651849f, -0.77833641f, 0.47816160f, 0.43289465f, 
    -0.13800335f, -0.33126441f, 0.31438074f, 0.00945892f, -0.08686741f, 0.02720726f, 0.00760310f, -0.25358194f, 
    0.14685163f, -0.28954458f, 0.05646427f, -0.08719455f, 0.17100203f, 0.03549526f, 0.23551278f, 0.04863732f, 
    0.17546450f, 0.66484386f, 0.36173156f, 0.59318048f, 0.62111729f, 0.08709611f, -0.62136555f, 0.01091521f, 
    -0.52297825f, 0.25790262f, -0.15265335f, 0.00174243f, -0.24905409f, -0.13120449f, 0.30353811f, -0.07729626f, 
    0.02970621f, -0.11316203f, 0.12190005f, 0.19497854f, -0.19472498f, -0.16852239f, -0.17738481f, 0.00690068f, 
    0.20138544f, -0.03309745f, 0.04212996f, -0.33172908f, -0.59606296f, -0.59271580f, -0.46339419f, -0.19527519f, 
    -0.25480291f, 0.27202311f, 0.23561846f, -0.39053845f, 0.26268014f, -0.19655100f, 0.20028897f, 0.18217687f, 
    -0.00711770f, -0.02042706f, -0.14584632f, -0.02185372f, -0.00969115f, 0.19938266f, 0.28018782f, -0.27687815f, 
    0.32402775f, -0.13484976f, -0.18602778f, -0.32571471f, 0.90566462f, 0.22107585f, -0.14264373f, 0.45649615f, 
    0.24823730f, 0.60230130f, 0.69882923f, -0.22239193f, 0.16931640f, 0.11299478f, -0.14243482f, 0.19056836f, 
    -0.19704662f, 0.08046782f, 0.12002462f, -0.28928113f, -0.07420208f, 0.22451951f, -0.01980909f, -0.10723187f, 
    -0.03593075f, -0.01749791f, 0.02561032f, 0.22257632f, 0.57064444f, 0.07850528f, 0.19289008f, 0.91267568f, 
    0.65995127f, 0.37397167f, 0.12746365f, 0.19220957f, -0.18025324f, 0.07765057f, -0.17097589f, 0.18692327f, 
    0.06855278f, -0.11434290f, 0.07493935f, 0.02110129f, -0.34909090f, 0.40462241f, 0.15554708f, 0.10130294f, 
    0.24818559f, -0.47015253f, -0.21363941f, 0.04243736f, -0.16363093f, -0.45008248f, -0.17801157f, -0.31928346f, 
    0.27264351f, -0.15597919f, -0.39434502f, -0.39389977f, -0.41435727f, -0.08065116f, -0.43638921f, 0.26960179f, 
    0.30224061f, -0.32137817f, -0.16376024f, -0.19157191f, -0.33765417f, -0.20318045f, -0.31249118f, -0.25982732f, 
    0.01742695f, 0.29974052f, 0.28678799f, 0.14701137f, 0.24573150f, -0.07468458f, -1.04968822f, 0.32018635f, 
    -0.03050870f, -0.10019480f, -0.02917911f, 0.48577124f, 0.66233474f, 0.11603709f, 0.48439127f, 0.46544036f, 
    0.04858051f, -0.02561044f, 0.23604168f, 0.03721680f, 0.04108701f, 0.12731577f, 0.11513729f, -0.02464509f, 
    0.07955272f, -0.18884465f, -0.00220453f, -0.14128511f, -0.05856525f, 0.07268648f, 0.07209024f, -0.38593686f, 
    -0.89260483f, -0.56616873f, -0.14264311f, 0.29491568f, -0.55232209f, 0.72204822f, 0.32781452f, -0.09191859f, 
    -0.18732235f, 0.27529082f, -0.00561711f, 0.11423085f, 0.20702836f, -0.04387907f, -0.14287271f, -0.30794290f, 
    0.01035921f, -0.35127670f, -0.14531191f, -0.09379601f, -0.21737197f, 0.20813178f, -0.17862035f, 0.24624577f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29134232f, 0.13957739f, 0.16717440f, 0.07868490f, 0.10123035f, 0.01906692f, 0.04729721f, -0.14873366f, 
    0.20974062f, -0.02902448f, -0.08774767f, 0.01665398f, 0.03698130f, 0.08293311f, 0.14377964f, -0.03344328f, 
    0.19790904f, 0.12367459f, 0.01215612f, 0.13610755f, -0.03696720f, 0.08531520f, 0.05185412f, -0.04049398f, 
    -0.01951439f, 0.07854770f, 0.13930716f, -0.11591064f, 0.16982783f, 0.18889017f, 0.24987772f, -0.02203977f, 
    0.21610752f, 0.05372094f, 0.09384354f, 0.15234709f, 0.23476386f, -0.16685666f, 0.08365125f, -0.04452683f, 
    0.14841263f, 0.09879085f, 0.02094016f, 0.01706224f, 0.00255513f, 0.12146371f, 0.02530054f, 0.11379128f, 
    0.17835771f, -0.06357935f, 0.21749756f, 0.06423592f, -0.12004571f, 0.18602590f, -0.12817164f, -0.04172871f, 
    -0.02410514f, 0.22232872f, 0.12530120f, 0.02324057f, 0.13256714f, 0.27388707f, -0.17474404f, 0.03319122f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10005352f, 0.12176990f, 0.01307395f, 0.17630668f, -0.00840494f, -0.09979051f, 0.00342712f, 0.04812383f, 
    0.03479892f, 0.02929375f, -0.05415639f, 0.06800900f, 0.37309995f, -0.21470220f, -0.16423789f, -0.06989036f, 
    0.07771823f, -0.01940369f, 0.01108750f, 0.02739945f, -0.05683400f, -0.08084577f, 0.06011953f, -0.07972579f, 
    0.06762469f, 0.20305534f, 0.03551482f, 0.14583166f, -0.03168272f, -0.04387534f, -0.01085086f, -0.02621616f, 
    0.03564536f, -0.01187874f, 0.06083755f, -0.11961092f, -0.12256530f, 0.07976929f, -0.02585163f, 0.03711405f, 
    0.02910697f, -0.08471522f, -0.07057874f, 0.09558573f, -0.08218209f, -0.06905958f, 0.06123173f, -0.11341613f, 
    0.07469868f, -0.06145208f, 0.10428210f, 0.01962877f, 0.04106872f, 0.03475809f, -0.02759426f, 0.12383386f, 
    0.05292482f, -0.01986919f, 0.13270484f, -0.13252120f, 0.04741025f, -0.23198745f, -0.03116633f, 0.07738065f, 
    0.05572545f, -0.09244233f, -0.01168703f, -0.01134170f, 0.04226168f, 0.03813469f, 0.06205218f, 0.10200066f, 
    0.06771854f, 0.18162121f, -0.02046523f, -0.05361842f, 0.02241887f, -0.01177556f, -0.12674332f, -0.00940205f, 
    0.03032037f, -0.00136488f, 0.01069779f, 0.07169043f, -0.13362204f, -0.07747681f, 0.13624306f, 0.01410242f, 
    -0.03029615f, -0.13443643f, -0.00605721f, -0.15864447f, -0.00710745f, -0.09246484f, 0.05884823f, 0.05491595f, 
    -0.01248719f, 0.03979777f, 0.11503448f, -0.03275085f, -0.02833668f, 0.03648875f, 0.04560672f, 0.02086796f, 
    0.02554015f, 0.00005296f, -0.09766924f, 0.10744301f, -0.15333980f, -0.07237123f, -0.17201899f, -0.01403860f, 
    -0.01524681f, -0.00435626f, 0.02811186f, -0.02113022f, -0.02547653f, -0.08257964f, -0.02349654f, -0.00724290f, 
    0.24854653f, 0.16905962f, -0.05003068f, -0.03115316f, 0.00690989f, -0.05045022f, -0.08685596f, -0.00428951f, 
    0.07301917f, 0.10436849f, 0.03151665f, 0.04869012f, -0.00406605f, 0.00679492f, -0.12816679f, 0.18626893f, 
    0.05708342f, -0.08268855f, 0.02529345f, 0.00554779f, -0.06254141f, 0.11812259f, -0.05343994f, 0.04585053f, 
    0.02268337f, -0.04191739f, -0.27364975f, -0.00368521f, -0.09022396f, -0.04997564f, 0.12416367f, 0.02126450f, 
    -0.04902888f, 0.07808354f, 0.01883993f, 0.05824825f, 0.19414692f, -0.14493124f, -0.21921936f, 0.02732746f, 
    0.00985736f, -0.05778734f, -0.04526633f, 0.00185932f, -0.13967016f, 0.00794016f, 0.09036148f, -0.08429901f, 
    -0.10500945f, 0.02031752f, 0.15076153f, 0.09229319f, -0.06942081f, -0.02837582f, -0.00280464f, -0.06961630f, 
    -0.01698159f, -0.02723045f, 0.08974034f, -0.01495466f, -0.02497251f, -0.05806759f, 0.12649754f, -0.07886297f, 
    0.01626011f, 0.01530935f, 0.05191487f, 0.19773901f, 0.03441643f, -0.06752775f, -0.06661659f, -0.05502724f, 
    0.32616708f, -0.09660900f, -0.16988450f, 0.10829781f, -0.03859163f, -0.03378827f, -0.02938079f, 0.09615547f, 
    -0.11564960f, -0.11663830f, -0.05968015f, -0.06584205f, 0.37900510f, 0.00960977f, -0.20533977f, -0.05371048f, 
    0.04415211f, -0.01841334f, 0.07422750f, 0.03970971f, 0.10675447f, 0.04957020f, 0.05904527f, 0.03706028f, 
    -0.25891411f, -0.05899509f, -0.07216007f, 0.04173920f, -0.03256186f, 0.08480249f, 0.20234001f, 0.01190314f, 
    0.14431190f, 0.11828245f, -0.06577897f, 0.10308494f, 0.22771844f, 0.15835926f, 0.19276676f, 0.07089415f, 
    0.10878069f, -0.05241928f, 0.12116217f, -0.05285223f, -0.00953616f, 0.11760619f, 0.06106595f, 0.03468069f, 
    -0.10363054f, -0.09576316f, 0.08381467f, -0.06099639f, -0.00500675f, -0.11313537f, 0.07813066f, 0.08788309f, 
    0.00530982f, 0.00854537f, -0.07001328f, 0.01283917f, -0.11121874f, 0.09295560f, -0.09515567f, 0.08858410f, 
    0.08993217f, 0.05388648f, 0.01839479f, -0.05415553f, 0.06065787f, -0.05253646f, -0.16713694f, -0.12763943f, 
    0.09467085f, 0.03590017f, -0.22665057f, 0.02728817f, 0.00418919f, 0.04227142f, 0.03025390f, -0.02724481f, 
    -0.03473206f, 0.03233707f, -0.06786522f, -0.05606662f, 0.31630677f, -0.16080655f, 0.12100729f, 0.00784828f, 
    -0.02942841f, -0.03280155f, 0.07947510f, 0.07404717f, 0.00217455f, 0.00291467f, 0.15431590f, 0.07677226f, 
    0.13067195f, 0.08844513f, 0.12032923f, 0.11747639f, 0.01977813f, -0.15766980f, 0.04959136f, 0.03828694f, 
    -0.06163863f, 0.07530226f, 0.11258680f, -0.02026696f, 0.12649295f, 0.08257750f, 0.17765099f, -0.04397874f, 
    -0.02357034f, -0.12234861f, 0.15802890f, -0.19254257f, -0.11586645f, 0.10150147f, -0.00053894f, -0.02200218f, 
    -0.30164579f, -0.09597669f, 0.10728887f, 0.03602221f, 0.09286532f, 0.03921108f, -0.00855745f, 0.03504706f, 
    0.00329531f, 0.07373017f, 0.13150640f, 0.06625078f, 0.00352060f, 0.02089946f, 0.12415116f, -0.07513644f, 
    -0.10048170f, 0.02983752f, -0.03463946f, -0.07912716f, 0.05461564f, 0.08063781f, 0.02147768f, 0.03644431f, 
    -0.03813711f, -0.25220028f, -0.10978764f, 0.06396015f, 0.01382890f, 0.01908562f, -0.00981701f, 0.00731909f, 
    0.02191181f, -0.01443968f, 0.01438320f, -0.02494072f, 0.10404759f, 0.08954301f, -0.11853108f, 0.07362103f, 
    -0.00464117f, -0.05414027f, -0.08654957f, 0.00003617f, 0.02370074f, -0.03667190f, 0.03720659f, -0.01781083f, 
    0.38302028f, 0.03332713f, -0.02694841f, -0.01170893f, 0.05699310f, -0.01045914f, -0.14979453f, 0.02000607f, 
    0.01447614f, 0.04059159f, 0.08373017f, 0.06370999f, 0.15350984f, 0.16016576f, 0.05840332f, -0.14627725f, 
    0.01030745f, -0.03556368f, -0.05292177f, 0.01344477f, -0.07768843f, 0.04615698f, -0.06239162f, -0.03275819f, 
    0.34104624f, 0.06148867f, -0.05764652f, -0.17806990f, -0.02455786f, 0.01927989f, 0.01010407f, -0.01198670f, 
    -0.07648243f, -0.07255749f, 0.05561341f, 0.00050827f, -0.27287912f, 0.05350486f, 0.17349896f, 0.04261162f, 
    0.04062443f, 0.09420568f, -0.04534329f, 0.02880980f, 0.06475689f, 0.07615590f, 0.04911729f, 0.13610166f, 
    0.11971660f, -0.04597943f, 0.09830772f, -0.03196933f, -0.02690178f, 0.06850590f, -0.03383014f, -0.13594043f, 
    -0.04489713f, -0.03764360f, 0.00531098f, 0.02075382f, -0.03828301f, -0.03046562f, -0.04832279f, -0.14224499f, 
    -0.00441285f, 0.06324700f, -0.05774030f, 0.03301635f, 0.02818478f, 0.06930857f, 0.00300044f, -0.02802549f, 
    -0.22298448f, 0.00937372f, 0.08995488f, 0.09878202f, 0.01775433f, 0.01816840f, 0.08605816f, -0.07620138f, 
    0.00477580f, -0.00069792f, 0.00960589f, -0.01766509f, 0.38984847f, 0.03541266f, 0.16004148f, -0.10606800f, 
    0.02036341f, 0.03083130f, 0.11129567f, 0.01809092f, -0.03436967f, -0.03169442f, 0.09197772f, 0.04274236f, 
    -0.02593472f, 0.24333942f, 0.18237002f, 0.05202726f, -0.01987194f, -0.04689245f, -0.02059646f, -0.03074843f, 
    0.06797317f, 0.08271062f, 0.02774325f, -0.07714963f, 0.10436140f, 0.12396985f, -0.14229795f, 0.06310568f, 
    0.00768915f, 0.11865716f, -0.05239017f, -0.02548951f, -0.06746422f, -0.14890948f, -0.00614239f, -0.12951180f, 
    -0.05004675f, 0.17076536f, 0.06341532f, -0.04997098f, -0.06845532f, -0.08609952f, -0.05055945f, -0.08633884f, 
    -0.04538089f, -0.09188069f, 0.01700915f, -0.05252845f, -0.01911289f, 0.09742283f, 0.02356759f, -0.01293966f, 
    -0.09811549f, -0.16683388f, 0.07910296f, 0.02155338f, 0.06194822f, -0.00886899f, -0.02481270f, -0.02822936f, 
    0.04096963f, 0.08471803f, -0.12401068f, -0.10186372f, 0.06490560f, 0.08166187f, -0.05494168f, 0.00958130f, 
    -0.05341852f, 0.14235000f, -0.09721489f, 0.07542760f, 0.01956713f, 0.13778540f, 0.20729354f, 0.07513450f, 
    -0.05247334f, 0.01937458f, -0.01993128f, -0.01105530f, -0.10627840f, 0.01608117f, -0.02312316f, 0.05545618f, 
    0.16478226f, 0.20733082f, -0.08649808f, 0.14294058f, 0.03005433f, -0.02080794f, -0.06745818f, -0.00153060f, 
    -0.03234676f, 0.02036184f, -0.07890771f, -0.02413349f, 0.06565221f, -0.06183854f, 0.04896017f, 0.21128368f, 
    0.04371735f, -0.03787036f, -0.00277228f, 0.06985667f, -0.00641378f, -0.12245553f, 0.14413853f, 0.05291808f, 
    0.17843521f, 0.05473487f, -0.17631651f, -0.03764625f, 0.05615878f, 0.06070081f, 0.01324905f, -0.06100078f, 
    -0.06772365f, -0.03252054f, -0.05742066f, 0.00602718f, -0.08477462f, 0.19292757f, 0.05882693f, -0.07274728f, 
    0.02005839f, 0.07812641f, 0.05355825f, -0.05452844f, -0.07252177f, -0.09339701f, -0.06520920f, -0.03956201f, 
    -0.04328536f, 0.11912713f, 0.14190789f, 0.08064011f, 0.00548859f, -0.09549163f, 0.05633219f, -0.00460715f, 
    -0.01646046f, -0.03813343f, -0.05813886f, 0.09473608f, -0.02473767f, -0.14204583f, 0.12885989f, 0.01716115f, 
    0.01080344f, -0.08140481f, 0.01643916f, 0.06303404f, -0.01155490f, -0.06710746f, -0.12281051f, -0.13314338f, 
    0.07479730f, 0.03794850f, -0.09056436f, 0.12296626f, -0.04015224f, 0.07330195f, -0.09157971f, 0.03913796f, 
    -0.00978106f, -0.02275905f, 0.04682427f, -0.15412089f, 0.16826250f, -0.07551079f, -0.17275825f, -0.02596689f, 
    -0.01494720f, 0.09628603f, 0.04260375f, -0.02798492f, 0.02607026f, 0.00642181f, -0.02878795f, -0.00415078f, 
    0.07006245f, 0.26818207f, 0.03921153f, 0.13598032f, -0.05184413f, -0.00770607f, -0.03471681f, 0.04066489f, 
    0.04140768f, -0.03352064f, -0.03196272f, -0.00934591f, 0.13172638f, 0.12411116f, -0.01679546f, 0.05368390f, 
    0.14288467f, -0.01820471f, -0.02252559f, 0.16501909f, 0.14420645f, -0.07276599f, -0.01236620f, -0.01344317f, 
    0.29678726f, -0.02655973f, -0.18801965f, 0.05219581f, 0.03697184f, -0.01689330f, -0.00297731f, -0.01433078f, 
    0.05736367f, 0.04382145f, -0.05150766f, -0.05039917f, 0.15790145f, 0.13031830f, 0.12652378f, 0.02029810f, 
    0.01163832f, -0.09805629f, 0.02455623f, 0.10050093f, 0.01882864f, 0.10079568f, -0.04836113f, -0.11270381f, 
    -0.19272582f, 0.00071737f, 0.03553696f, 0.08779038f, 0.01356884f, -0.02567087f, 0.09149290f, 0.01458499f, 
    -0.10896749f, 0.11227255f, 0.01505498f, 0.06815574f, 0.12596883f, -0.15844296f, -0.17049199f, -0.08526997f, 
    0.00345700f, -0.03640557f, 0.01546961f, -0.08232158f, 0.00674680f, -0.08569241f, 0.04146079f, 0.05369423f, 
    0.14113285f, 0.21486276f, -0.02223687f, 0.05321259f, -0.07074524f, -0.02938968f, -0.02624759f, 0.05332270f, 
    -0.01205515f, -0.02821820f, 0.06432249f, -0.04302957f, -0.02144053f, -0.26474425f, 0.05811744f, 0.02547664f, 
    0.00832168f, -0.04838189f, -0.02996991f, 0.07657024f, -0.02344442f, 0.07848616f, 0.05296044f, -0.13994054f, 
    -0.22360046f, 0.07411758f, -0.15956289f, 0.15731564f, 0.13522252f, -0.05703247f, 0.16572545f, -0.08981356f, 
    -0.00655858f, -0.05632275f, 0.01217017f, -0.09970611f, -0.06524906f, -0.02570799f, -0.01982596f, 0.01446704f, 
    -0.04591435f, -0.07680772f, -0.05388829f, -0.06085457f, 0.00794618f, 0.00572804f, 0.04420847f, -0.08869512f, 
    -0.02404753f, -0.01642634f, 0.08573260f, -0.03215609f, -0.03632005f, -0.03818200f, -0.02415898f, 0.08431280f, 
    0.03117926f, -0.08165917f, -0.03159564f, 0.03321734f, -0.03389801f, 0.11212256f, 0.19696812f, 0.12641364f, 
    -0.06262530f, -0.09522241f, 0.06644445f, 0.03342288f, -0.00892109f, 0.19561200f, -0.01821799f, -0.00453552f, 
    0.00319225f, -0.00255229f, -0.03071133f, -0.02009497f, 0.02235374f, 0.01259295f, 0.00561603f, -0.04145126f, 
    -0.04255732f, -0.00294946f, 0.00903185f, -0.03157894f, -0.02034314f, -0.01813349f, -0.02895766f, 0.00755025f, 
    -0.04107061f, -0.00312358f, -0.03374281f, 0.00358472f, -0.03834439f, -0.03800700f, -0.01558880f, 0.02018640f, 
    -0.03823369f, -0.00272991f, 0.00233140f, -0.04028325f, -0.03071586f, 0.01320245f, -0.00780525f, -0.00432928f, 
    0.00308442f, -0.03628196f, -0.00918985f, -0.02512500f, 0.01707481f, 0.01357687f, 0.02434824f, -0.00247403f, 
    0.00219040f, -0.00956933f, -0.03181825f, -0.01618217f, -0.02587495f, 0.00827211f, -0.00681152f, -0.00455177f, 
    0.02569401f, 0.01034995f, 0.00081619f, -0.02956969f, 0.01936145f, -0.00269413f, -0.04260510f, -0.00926075f, 
    0.01090303f, 0.01208254f, -0.00843220f, -0.04036134f, 0.02405910f, -0.01257130f, -0.01685154f, -0.02740600f, 
    -0.02758505f, 0.02590991f, 0.00692760f, 0.01314335f, 0.01650851f, -0.00225344f, -0.01301270f, -0.02102179f, 
    -0.00850085f, 0.01570115f, 0.02842807f, -0.00592488f, -0.04104638f, -0.03937555f, -0.04319452f, 0.02491884f, 
    -0.03786292f, 0.01115643f, -0.02121380f, -0.00203572f, -0.00770774f, -0.02675520f, 0.02738561f, -0.00715733f, 
    -0.04343636f, -0.03746952f, 0.02618149f, 0.00407059f, 0.02231089f, 0.02066063f, 0.02576227f, -0.02701615f, 
    -0.00494022f, 0.00550071f, 0.02487893f, -0.01895389f, -0.00687053f, 0.00088237f, 0.00295474f, 0.02598039f, 
    -0.03657505f, -0.03990421f, -0.02334834f, -0.02732920f, 0.01096726f, -0.03192091f, 0.02218013f, 0.01891924f, 
    -0.00416917f, -0.01237645f, -0.00789807f, -0.01724063f, 0.01077287f, 0.00468784f, 0.01884268f, 0.02479828f, 
    0.00517964f, 0.01159842f, -0.02583263f, 0.02361540f, -0.00495876f, -0.01666683f, -0.03854574f, -0.03320044f, 
    -0.03515008f, -0.02043069f, -0.03568594f, -0.02699610f, 0.02654809f, -0.02239599f, 0.01400916f, -0.03257839f, 
    -0.02680328f, -0.02871006f, 0.01421987f, -0.01061339f, 0.01061817f, -0.02404385f, -0.00052085f, -0.02364772f, 
    0.01124789f, 0.01507302f, -0.02776629f, 0.03465501f, -0.01101497f, 0.00444320f, -0.00831432f, -0.03403699f, 
    -0.03315901f, -0.00469771f, -0.02750005f, 0.00190326f, -0.00823176f, 0.02727094f, -0.04013085f, 0.01111943f, 
    -0.01204152f, -0.03290471f, 0.03786403f, -0.02120553f, -0.03636241f, -0.01792649f, -0.03487991f, 0.02601828f, 
    -0.03721689f, -0.00280600f, 0.00150420f, -0.00863980f, -0.03200572f, -0.00654358f, -0.02083214f, -0.02268053f, 
    -0.00262352f, -0.02238770f, -0.01675595f, -0.02233822f, 0.01982307f, -0.00393050f, -0.00505164f, -0.04343842f, 
    -0.02659157f, -0.01436335f, -0.01607316f, -0.01103736f, -0.00944510f, -0.00331468f, 0.02239502f, -0.00330095f, 
    -0.01535112f, 0.01891721f, -0.02380058f, -0.00786193f, -0.03085536f, -0.02861746f, -0.01128965f, 0.01464352f, 
    -0.00063943f, -0.00377243f, -0.00229639f, -0.02959314f, -0.03375123f, 0.00778046f, -0.01154108f, -0.02384748f, 
    -0.01543268f, 0.03102645f, -0.02631077f, -0.01701173f, -0.02965893f, -0.01597564f, -0.01705493f, 0.01552065f, 
    0.02915779f, -0.00038981f, 0.00427682f, -0.02450346f, 0.00308396f, 0.02233471f, -0.03907677f, -0.03200661f, 
    -0.01447496f, 0.02274964f, 0.00800942f, 0.03168855f, -0.04017723f, 0.02053986f, 0.01189377f, -0.04320247f, 
    -0.00399045f, -0.02333557f, -0.04017751f, -0.01676797f, -0.03342965f, 0.01973750f, -0.00486690f, -0.00620368f, 
    0.01133987f, -0.02081674f, -0.02925495f, 0.01240627f, 0.01225962f, 0.02006928f, -0.00255867f, -0.02968683f, 
    0.01822362f, -0.02582263f, -0.03708606f, 0.01227850f, -0.03517977f, 0.01727756f, 0.02576448f, -0.04093566f, 
    -0.03454757f, -0.00212208f, 0.00146709f, -0.00171222f, 0.00840539f, -0.00374175f, -0.01114068f, -0.00822286f, 
    -0.00001159f, 0.02500857f, 0.02046753f, -0.03026067f, -0.01595854f, 0.02367286f, 0.01668788f, -0.02957563f, 
    -0.01383758f, 0.01249895f, -0.02232051f, -0.03381710f, 0.00905318f, -0.01917588f, 0.00328935f, -0.03736328f, 
    -0.01597950f, -0.02094331f, -0.01838322f, -0.04205515f, -0.00901734f, -0.00740112f, 0.01745039f, -0.02060438f, 
    -0.01178342f, -0.01938824f, -0.03497151f, -0.02678321f, -0.02130551f, 0.02262034f, -0.02510762f, -0.03483223f, 
    0.01306573f, 0.02160070f, 0.02700393f, -0.01867144f, -0.00553001f, 0.00705563f, 0.01229750f, -0.02640501f, 
    0.01081151f, -0.01137642f, 0.01681146f, 0.01186888f, -0.03622253f, 0.00813109f, -0.01294665f, 0.02932619f, 
    -0.01129457f, -0.04262441f, 0.03281789f, -0.03381542f, -0.00432603f, -0.04378722f, -0.00337979f, -0.00989162f, 
    -0.01751806f, 0.01445204f, -0.00578623f, 0.02862949f, -0.01349679f, 0.00908368f, -0.00158423f, -0.03902309f, 
    0.02581132f, -0.03521242f, 0.01844695f, -0.02801114f, 0.02107634f, -0.02365563f, -0.00183851f, -0.02163849f, 
    -0.03451185f, 0.00014927f, -0.03983977f, -0.03582161f, -0.01015851f, 0.03510620f, 0.02183557f, 0.02426308f, 
    -0.03625732f, -0.02659350f, -0.01965260f, -0.00359574f, -0.02159030f, -0.01822604f, -0.00122626f, -0.01971334f, 
    -0.01129433f, -0.04174116f, 0.00003303f, 0.01672759f, -0.02978059f, -0.03184781f, 0.00176405f, 0.02558951f, 
    -0.03584633f, 0.01388089f, 0.01910152f, -0.00932895f, -0.00349004f, -0.00726278f, 0.02429804f, -0.01907684f, 
    -0.00876889f, -0.02932077f, -0.03064801f, -0.01498837f, 0.00947871f, 0.00378647f, -0.01756790f, -0.03596380f, 
    -0.01528598f, -0.00812013f, -0.01185376f, 0.02437832f, 0.02727286f, 0.01775110f, -0.03774569f, -0.00906536f, 
    -0.02660823f, 0.02616398f, -0.00383216f, -0.02542521f, -0.02966567f, 0.02191082f, -0.00285148f, -0.01761338f, 
    -0.03209326f, -0.02159957f, 0.02045781f, -0.00441778f, -0.01660475f, 0.02456032f, -0.00035121f, 0.00643115f, 
    -0.01899303f, 0.00050875f, -0.03088298f, -0.02816477f, -0.03819837f, -0.02391207f, 0.02164641f, 0.02618723f, 
    0.01185644f, 0.01027806f, -0.01258312f, 0.01177088f, 0.02420324f, -0.02079569f, 0.02232437f, 0.02399851f, 
    0.03710333f, -0.03891894f, -0.03342694f, 0.01811525f, -0.00787016f, 0.00461550f, 0.01049908f, 0.00848505f, 
    -0.00176841f, -0.04255622f, -0.00710527f, 0.00125060f, 0.02639408f, 0.02238247f, -0.02244488f, -0.01990301f, 
    0.03036988f, -0.03598266f, -0.02651450f, 0.01300083f, -0.03629641f, 0.01320811f, 0.01683213f, -0.01173630f, 
    -0.02586276f, -0.04219788f, 0.00693786f, -0.00692677f, -0.01071591f, -0.03632108f, 0.01981146f, -0.02004292f, 
    -0.04083604f, -0.03930109f, 0.01110119f, -0.03023051f, 0.00527168f, -0.01338968f, 0.01625830f, -0.00763781f, 
    0.01903588f, -0.03766118f, 0.01637095f, 0.02617678f, -0.01616465f, -0.01072729f, -0.00965017f, -0.03739161f, 
    -0.01885496f, 0.00707700f, -0.02888051f, -0.02474338f, 0.01640583f, -0.01377285f, -0.03577085f, 0.01061032f, 
    0.01365048f, 0.02355710f, -0.00842366f, -0.00132318f, -0.02181687f, -0.01414588f, 0.00435153f, 0.00704331f, 
    0.02406069f, -0.00115611f, -0.02858264f, 0.02130690f, 0.01695482f, 0.00587769f, -0.01625569f, -0.04299876f, 
    0.00186622f, -0.01365124f, -0.01185700f, 0.00422894f, 0.01534522f, -0.02553807f, 0.00636762f, -0.03329279f, 
    0.01206982f, 0.00534383f, -0.01841884f, -0.01080715f, 0.01223856f, 0.00185247f, 0.00078457f, 0.02274910f, 
    0.01846587f, 0.01541056f, -0.02625006f, -0.03651571f, -0.03654647f, -0.03853109f, -0.00216403f, -0.01151902f, 
    -0.03763242f, -0.02756168f, 0.02322416f, -0.04190631f, 0.02892028f, -0.01450090f, -0.01030793f, -0.01332986f, 
    -0.01513859f, -0.03876740f, 0.01178101f, -0.00260061f, 0.00159195f, 0.01141558f, -0.01664375f, 0.00288321f, 
    -0.01617590f, 0.00851869f, -0.00113877f, -0.00379869f, -0.00863985f, 0.00065866f, 0.02403709f, 0.01677268f, 
    0.02124030f, 0.01940271f, -0.01826954f, 0.00547294f, -0.00204899f, -0.01456914f, -0.00877379f, -0.00474825f, 
    -0.00934520f, -0.02720255f, -0.00011527f, 0.00653640f, -0.02435228f, -0.01170852f, -0.00103367f, -0.00901914f, 
    -0.01477853f, -0.01577604f, -0.02576925f, 0.02757201f, 0.00430455f, -0.00665578f, 0.00949355f, 0.02306696f, 
    0.01024985f, -0.01354673f, -0.02658694f, 0.03272099f, 0.00409213f, 0.02240571f, 0.01558090f, 0.01094266f, 
    0.01411067f, -0.00209147f, -0.04207714f, -0.00713376f, -0.01002040f, -0.01332127f, 0.00310841f, -0.00238736f, 
    0.02723015f, 0.02742649f, -0.01976915f, 0.00673017f, 0.01317650f, 0.01904780f, -0.02684260f, -0.00206818f, 
    -0.04091967f, -0.02608872f, -0.01397585f, -0.03333563f, 0.00893445f, -0.01011192f, -0.02003447f, -0.02817916f, 
    -0.01397501f, -0.00359535f, 0.02412554f, -0.00644544f, 0.01173756f, -0.03311713f, -0.03958550f, 0.02453536f, 
    0.00112524f, 0.01757868f, -0.01817628f, 0.01142310f, -0.00137291f, -0.01389225f, 0.02047573f, 0.01999815f, 
    -0.01126604f, -0.03480828f, 0.01901203f, 0.01529093f, 0.02252541f, 0.02999231f, 0.00922532f, -0.04054807f, 
    -0.03469671f, 0.00493877f, -0.00543950f, -0.04253171f, -0.01353436f, 0.02321829f, -0.02645230f, -0.00294060f, 
    -0.01933479f, 0.01325451f, 0.01845131f, 0.00891265f, -0.02646905f, 0.02369532f, 0.00325394f, -0.01072699f, 
    0.00230441f, -0.03561967f, -0.04114215f, -0.00671535f, -0.02318989f, -0.03059660f, -0.01581462f, 0.01743403f, 
    -0.01290000f, 0.01465547f, -0.01312930f, -0.00585442f, -0.03763738f, -0.01629266f, 0.02108706f, 0.01365365f, 
    0.00542963f, -0.01908640f, 0.02599998f, 0.01517455f, -0.01200043f, 0.02224538f, 0.02201426f, -0.03853477f, 
    0.00460290f, -0.00431489f, 0.00746693f, -0.01755527f, 0.00057173f, -0.01702337f, -0.01973068f, 0.01530092f, 
    0.00192440f, -0.00072336f, 0.00956621f, 0.02205645f, 0.01547980f, -0.02506354f, -0.00775672f, -0.04128137f, 
    -0.03165784f, -0.01418161f, -0.04028111f, 0.01466864f, -0.03361519f, -0.04019721f, 0.02069454f, -0.01638218f, 
    -0.03189930f, -0.00079709f, 0.02798806f, -0.02294390f, -0.01604178f, -0.00164704f, 0.00400815f, -0.00158081f, 
    -0.01757211f, -0.02272814f, 0.02288234f, -0.02210694f, -0.03159915f, 0.00496430f, 0.00834518f, -0.01911210f, 
    -0.00042120f, -0.04245439f, 0.00300433f, -0.00763259f, -0.02601050f, -0.03906898f, 0.02026311f, -0.03970644f, 
    0.02612650f, 0.02277557f, -0.00994581f, 0.02500341f, -0.04180329f, 0.01647189f, 0.00015446f, -0.01920475f, 
    -0.02534228f, -0.02861949f, 0.02605565f, -0.02850782f, 0.00664893f, 0.02090803f, -0.01630444f, -0.02273445f, 
    0.00447121f, 0.02139932f, 0.00806141f, 0.02298903f, 0.04008975f, -0.02928294f, -0.01794609f, 0.01869201f, 
    -0.03281986f, 0.02445796f, -0.00877348f, 0.00203384f, 0.00804191f, 0.00367469f, -0.00319805f, 0.00910891f, 
    -0.01065124f, -0.01135542f, -0.03880005f, 0.02835398f, 0.02118574f, -0.01303758f, -0.03042742f, -0.01120882f, 
    0.01529187f, -0.01045419f, 0.02048139f, 0.02638038f, 0.04058572f, 0.01427815f, 0.02200193f, -0.03031145f, 
    -0.00615383f, 0.02998904f, 0.02502134f, -0.00952288f, -0.03527132f, 0.01783566f, 0.01029085f, -0.01633172f, 
    -0.01855625f, -0.00025855f, -0.02051857f, -0.04224382f, 0.01387598f, 0.02533471f, 0.02495736f, -0.00963580f, 
    0.07000067f, 0.04751212f, -0.08765238f, 0.01681299f, -0.01483223f, 0.05725100f, -0.01308301f, -0.06908350f, 
    0.00697040f, 0.02151352f, -0.02164210f, 0.13051511f, 0.20411022f, 0.13604455f, 0.12651829f, -0.10248420f, 
    0.01559259f, 0.06435077f, -0.02970378f, -0.03270742f, 0.01686680f, 0.01942587f, -0.00979743f, -0.11384080f, 
    -0.19715692f, 0.11482489f, -0.08595883f, 0.11808616f, 0.16933925f, 0.10053214f, -0.06519450f, 0.06273592f, 
    0.04399525f, -0.00777024f, -0.10430661f, 0.00404875f, -0.22297472f, -0.07156393f, 0.06626083f, 0.06909795f, 
    0.15220524f, 0.01607141f, -0.08895947f, 0.10284001f, 0.00331162f, -0.05511022f, 0.12648787f, -0.05588787f, 
    0.06384881f, -0.13756831f, -0.06671496f, -0.01517975f, -0.01206879f, -0.07526111f, 0.10218598f, 0.04844624f, 
    -0.08201934f, -0.01742799f, 0.11562109f, -0.08648400f, 0.01694497f, 0.16540800f, 0.15816787f, -0.28514427f, 
    -0.02136867f, 0.07941758f, -0.03386671f, 0.01725807f, -0.07197537f, -0.06356181f, -0.00011166f, 0.11005811f, 
    0.03749796f, 0.14245486f, 0.06184430f, 0.37210432f, 0.08656913f, 0.04375288f, -0.01537385f, -0.03650746f, 
    0.05807326f, -0.16584989f, 0.06219579f, -0.03781714f, 0.28297198f, -0.24514523f, -0.19179808f, -0.16259809f, 
    0.08867951f, -0.02553704f, -0.01101597f, -0.01797690f, -0.01093992f, -0.00361446f, 0.04152507f, 0.04632943f, 
    -0.14476755f, -0.25660449f, 0.09092537f, 0.14960162f, -0.05513602f, 0.06122882f, 0.04741393f, -0.03889987f, 
    -0.13300844f, 0.01213054f, 0.05584972f, 0.16031253f, 0.03112607f, 0.07771204f, 0.06315449f, -0.22414483f, 
    0.07096271f, 0.04631432f, 0.00010819f, 0.10345609f, 0.02182230f, 0.05105364f, 0.00385342f, 0.02642379f, 
    -0.30004728f, 0.09599888f, 0.07737356f, 0.00516583f, 0.01785503f, -0.02509302f, 0.11666667f, 0.06785864f, 
    0.14794752f, -0.02697891f, -0.01700396f, 0.14738582f, 0.00978626f, -0.16887796f, -0.07879477f, -0.03931475f, 
    -0.06424554f, 0.08321848f, 0.06322184f, 0.03440219f, 0.02293786f, 0.05609113f, 0.06801108f, 0.10463585f, 
    0.00280599f, 0.17104533f, 0.05647493f, -0.01528862f, 0.00093999f, -0.01129618f, 0.07871819f, 0.08571032f, 
    0.12700108f, 0.07688625f, 0.00064250f, 0.11323243f, 0.07146074f, 0.13788871f, -0.11338942f, -0.12982114f, 
    0.08460072f, 0.07713161f, 0.03534699f, 0.01493261f, -0.02066050f, -0.02662358f, 0.08896397f, -0.05220927f, 
    -0.03599666f, 0.07152950f, 0.02367191f, -0.12661225f, 0.04168288f, 0.06354824f, 0.01478550f, 0.07105465f, 
    0.05515881f, 0.08777000f, 0.03300661f, -0.01337816f, -0.23597385f, -0.28935823f, -0.06652147f, 0.11632754f, 
    -0.05968896f, 0.00491657f, 0.02046802f, 0.01175443f, -0.11169162f, 0.10459139f, 0.05563908f, 0.01086661f, 
    0.04832345f, -0.04353020f, -0.05435786f, 0.00176419f, 0.18807429f, 0.01855944f, -0.02039399f, -0.02086893f, 
    0.04189422f, -0.06582389f, 0.00736127f, 0.01764930f, -0.38322175f, 0.26555219f, 0.26977468f, -0.07004225f, 
    0.10351222f, 0.03266687f, 0.00569098f, -0.07109702f, 0.08094587f, 0.01348350f, 0.00413967f, 0.03248249f, 
    -0.04489974f, 0.07221620f, -0.11190445f, -0.19438864f, 0.07236082f, -0.07349805f, 0.08086224f, 0.03774089f, 
    0.09525995f, -0.02914580f, 0.03772216f, 0.07668826f, 0.34679738f, -0.28401694f, 0.13749325f, 0.06390884f, 
    0.08291684f, 0.01142032f, 0.14132418f, -0.02415340f, -0.01791902f, 0.03740177f, -0.02436096f, -0.01445995f, 
    0.05693227f, 0.08011135f, -0.14391179f, -0.00625713f, 0.02984190f, -0.03924584f, -0.00108273f, 0.01921885f, 
    0.02344519f, -0.10644078f, 0.06186219f, -0.15788971f, -0.14275339f, 0.05095110f, -0.17734919f, 0.06125487f, 
    0.06403782f, 0.00149480f, 0.02116106f, 0.07897791f, 0.02578380f, 0.07172490f, -0.13431835f, -0.01955569f, 
    -0.22520077f, 0.18681417f, 0.15989676f, -0.27883121f, -0.03259008f, 0.12103959f, 0.00729469f, 0.04930825f, 
    0.04951395f, -0.10824218f, 0.09349161f, -0.05608090f, 0.30240569f, -0.09421236f, -0.17968753f, -0.17836110f, 
    0.08391935f, -0.13315061f, 0.08837482f, 0.14037354f, 0.02803765f, 0.04377108f, -0.15943667f, 0.04627640f, 
    0.06426997f, 0.02637300f, -0.07867661f, -0.00908109f, 0.03283354f, -0.07237910f, -0.05586482f, 0.12304483f, 
    0.02484571f, 0.05009899f, 0.04401132f, 0.16741204f, -0.19262582f, 0.00266919f, 0.02630226f, 0.12521084f, 
    -0.01793376f, 0.01717929f, 0.04180445f, 0.08755215f, -0.02398134f, -0.05509448f, -0.04413367f, 0.07255492f, 
    0.04872681f, 0.01183490f, -0.20615204f, 0.09673601f, -0.06411534f, 0.07796442f, -0.00171858f, 0.03454872f, 
    0.00558988f, 0.07538863f, 0.13809425f, 0.19917783f, 0.02210781f, 0.14823426f, 0.09579419f, -0.18636005f, 
    0.07048105f, -0.02377968f, -0.02472379f, -0.00041503f, -0.01515912f, 0.08569919f, 0.13259865f, 0.06274576f, 
    0.08891242f, 0.09226351f, -0.03143977f, 0.02496757f, 0.05002626f, 0.01395844f, 0.00548298f, 0.03961145f, 
    -0.02154835f, 0.02415393f, -0.00379969f, -0.06271947f, -0.21637067f, 0.20403010f, -0.03564485f, -0.10226243f, 
    0.11165385f, 0.01810003f, 0.07026527f, 0.08409224f, 0.10084686f, 0.08205191f, 0.10645299f, 0.02498359f, 
    0.05719369f, 0.11320726f, 0.16643995f, 0.26591250f, 0.09248453f, 0.05781284f, 0.06124330f, -0.06201951f, 
    0.11875074f, 0.05071736f, -0.02306060f, -0.00295728f, -0.01547724f, 0.07160144f, -0.00917975f, 0.00770909f, 
    0.02557516f, -0.11150584f, 0.01839530f, -0.06278532f, -0.13001819f, 0.02973717f, 0.06955172f, 0.00013092f, 
    -0.12205863f, 0.12256420f, 0.23021784f, -0.18528044f, 0.02949867f, 0.02426341f, 0.01430388f, 0.03342659f, 
    0.06695351f, -0.00711035f, 0.01962316f, -0.00203871f, -0.00096602f, -0.18926561f, -0.00228324f, 0.16273780f, 
    -0.09258415f, 0.03129650f, 0.11441285f, -0.05204060f, 0.01433635f, 0.03725860f, 0.13704571f, 0.09142000f, 
    0.23274796f, -0.16869581f, -0.06331345f, -0.00543870f, -0.01132042f, -0.13792883f, 0.06274106f, 0.03433920f, 
    -0.03829509f, 0.07062592f, 0.03561918f, 0.00126480f, -0.06225043f, 0.04103041f, 0.06886617f, 0.10239379f, 
    0.05085743f, 0.16738220f, 0.06495983f, 0.10099061f, 0.05947359f, -0.03589043f, 0.02887823f, 0.05778932f, 
    -0.13549796f, 0.11460398f, -0.13407269f, -0.04342859f, 0.04066009f, -0.01604756f, 0.02867887f, 0.05043444f, 
    -0.06199205f, 0.04772482f, 0.02938196f, -0.00461635f, 0.34533745f, -0.03590146f, -0.00938523f, -0.21161714f, 
    0.09658993f, 0.00124050f, -0.02038410f, 0.00856818f, -0.09845889f, -0.09283972f, -0.00223020f, 0.06908619f, 
    -0.19954474f, 0.04162129f, 0.11365905f, 0.03009090f, 0.04625067f, -0.02491126f, -0.10578401f, 0.07905723f, 
    0.04718641f, 0.07695896f, 0.04293008f, 0.04395180f, -0.23785329f, 0.17179708f, 0.12923822f, -0.07646729f, 
    -0.01869928f, 0.06927846f, 0.00420779f, -0.00152880f, -0.03524986f, 0.01070977f, -0.05205407f, -0.06359957f, 
    -0.19924949f, 0.09199555f, 0.04647952f, -0.22896084f, 0.03128748f, 0.03610789f, 0.14307392f, -0.04651073f, 
    0.06342379f, -0.04822067f, -0.12070923f, -0.12919842f, -0.08210431f, 0.09105928f, -0.01123901f, 0.09188946f, 
    0.03306253f, 0.06474402f, 0.03660957f, -0.00046728f, 0.01323412f, 0.02496086f, 0.11130276f, -0.00846703f, 
    -0.13315694f, 0.04919555f, -0.01665655f, 0.01659412f, 0.16841404f, 0.02641591f, -0.03315606f, -0.15293786f, 
    -0.11377588f, 0.00817662f, -0.00940254f, -0.06534936f, -0.11085629f, -0.23636901f, 0.05421741f, 0.18919055f, 
    0.01563950f, -0.00235780f, -0.00474971f, -0.01997400f, -0.01448759f, -0.04075282f, -0.00406389f, 0.00996245f, 
    -0.13702688f, 0.34872064f, -0.14992204f, -0.19556797f, 0.01681470f, -0.00686712f, -0.01810991f, 0.04365007f, 
    0.04423730f, 0.00473256f, -0.01415188f, -0.01393276f, -0.13235173f, 0.00485462f, 0.27269414f, 0.09662876f, 
    0.07312343f, -0.02342037f, -0.00020554f, 0.02546254f, 0.06282740f, 0.03690730f, -0.01499012f, 0.17523129f, 
    -0.15912151f, 0.29297400f, 0.03850503f, -0.22157681f, 0.04537396f, 0.03791553f, 0.01275316f, 0.01000909f, 
    0.04985488f, -0.03507748f, -0.02155727f, 0.01962535f, -0.36441037f, 0.22155374f, 0.12250938f, 0.08129609f, 
    0.09399945f, 0.20538506f, 0.12271176f, -0.04008595f, -0.06247386f, 0.00003451f, -0.06052986f, -0.02950103f, 
    0.36416104f, -0.13861281f, 0.06772506f, -0.19085753f, 0.14289023f, -0.00741690f, -0.03509964f, -0.01540628f, 
    0.00107883f, 0.08809138f, 0.05601430f, 0.09011301f, 0.14748859f, 0.06249293f, 0.09951095f, -0.28250840f, 
    0.14731081f, -0.04067510f, -0.07312446f, 0.10674664f, 0.03179682f, -0.00420461f, -0.11945046f, -0.08076749f, 
    0.00044316f, -0.05430980f, -0.01180567f, 0.25542420f, -0.01025232f, 0.05891215f, -0.00338460f, 0.08330984f, 
    0.05384155f, -0.03048406f, -0.01838076f, 0.01338249f, -0.05640317f, 0.18433310f, -0.04305276f, -0.15655255f, 
    0.02915869f, -0.05604232f, 0.03307831f, 0.08036155f, 0.07656555f, 0.03927535f, 0.15360108f, 0.03632212f, 
    0.08942626f, -0.14643756f, -0.13663542f, 0.08960874f, -0.03506258f, -0.02552313f, -0.07799298f, 0.00541772f, 
    0.00374289f, -0.12597992f, -0.03608927f, -0.06768011f, -0.17539287f, -0.15112121f, -0.03212231f, 0.05201360f, 
    0.04455530f, -0.02743034f, 0.00836613f, -0.05384857f, 0.00751006f, 0.01060748f, 0.12671892f, 0.05071460f, 
    -0.04339439f, 0.04126916f, -0.04009978f, -0.21206227f, 0.14818755f, 0.05021217f, -0.07516953f, 0.06153166f, 
    0.11278693f, 0.04062314f, 0.05963764f, 0.01873631f, -0.19192934f, -0.17692761f, 0.01295425f, 0.21383004f, 
    -0.03698710f, -0.04851375f, 0.02446096f, 0.03614096f, 0.00649515f, 0.10226926f, 0.05535329f, 0.02755547f, 
    0.02629166f, -0.02806792f, -0.08833653f, -0.01610749f, 0.09828591f, -0.10642420f, 0.05102820f, 0.07765768f, 
    -0.00477181f, 0.02418986f, 0.10178200f, 0.00837634f, -0.03544455f, 0.13075219f, 0.26977023f, -0.30026111f, 
    0.10421143f, 0.07924748f, -0.05202790f, -0.00405148f, 0.01707677f, 0.06722415f, -0.09693404f, 0.05636603f, 
    -0.00974410f, 0.13268960f, 0.12002596f, 0.07212090f, 0.01991143f, -0.02607330f, -0.05151979f, 0.00133500f, 
    0.03308943f, -0.09583716f, 0.01247657f, 0.07071820f, 0.11807859f, -0.17565000f, -0.26344353f, 0.19351774f, 
    0.04873631f, 0.07416569f, -0.01894530f, 0.05063375f, -0.01473423f, -0.00612568f, -0.06747587f, -0.06277646f, 
    -0.09255819f, 0.20606279f, -0.09064334f, -0.21036991f, -0.03056915f, -0.13975675f, 0.05490459f, 0.04594934f, 
    0.00870017f, -0.08219922f, 0.02150155f, 0.05652699f, 0.02502421f, 0.09022172f, -0.04320531f, -0.00899917f, 
    0.00656397f, 0.08264480f, 0.04736065f, -0.09215707f, 0.04213542f, -0.04753575f, 0.09076085f, 0.08724705f, 
    -0.08148195f, -0.38116696f, -0.06736958f, 0.11652110f, -0.02430597f, 0.02126073f, 0.09968065f, 0.08054767f, 
    -0.17069742f, 0.08461416f, -0.01317902f, 0.06962676f, -0.01904034f, -0.12039544f, -0.01487429f, 0.06333455f, 
    0.09238327f, 0.02518769f, 0.02868863f, 0.10786352f, 0.03189179f, -0.04874222f, 0.13095315f, -0.00527245f, 
    0.05869144f, -0.08523275f, -0.00029256f, 0.01491570f, -0.02634441f, 0.00179611f, 0.02775554f, 0.04081570f, 
    0.10388593f, 0.06896796f, 0.12502033f, 0.03165850f, 0.10044082f, -0.04067603f, -0.20182580f, 0.14729328f, 
    0.12317522f, 0.05741172f, 0.10551389f, 0.02222728f, 0.02748402f, 0.07145164f, -0.03396028f, 0.19747578f, 
    0.06237186f, 0.04804600f, -0.12065811f, 0.05259737f, -0.01673855f, -0.02352713f, 0.17901246f, -0.01269974f, 
    -0.01076053f, 0.11111530f, 0.11790458f, 0.02527317f, 0.09918710f, 0.08928670f, -0.07579164f, -0.16433010f, 
    0.04076552f, 0.04100881f, 0.10257181f, 0.05010550f, -0.01658497f, 0.02107964f, -0.05655634f, 0.06563010f, 
    -0.06917604f, 0.12672411f, 0.26148432f, -0.04048084f, 0.12364466f, 0.07613951f, 0.03944199f, 0.16539402f, 
    0.02065002f, 0.02909886f, -0.01894105f, 0.15583844f, 0.00654319f, 0.01614074f, 0.08814596f, 0.12388711f, 
    0.12551619f, -0.10464959f, -0.02098211f, 0.14225237f, 0.05120247f, 0.13198854f, 0.07694149f, 0.01442904f, 
    0.01732786f, 0.01695240f, -0.13934240f, -0.02130678f, 0.11656745f, 0.08783540f, 0.01045919f, -0.03362071f, 
    0.13453506f, 0.12561028f, 0.04442317f, 0.08114062f, -0.30253613f, 0.00053403f, 0.15633696f, 0.00337311f, 
    -0.03855542f, 0.02406478f, 0.01551168f, 0.02630258f, -0.02470135f, -0.04182165f, -0.01110008f, -0.01487423f, 
    0.08965167f, 0.19420947f, -0.02676344f, 0.23260780f, 0.04940363f, 0.04855582f, -0.00501603f, 0.02977551f, 
    0.14206958f, 0.04109885f, -0.02256033f, 0.07364500f, -0.18941025f, 0.01506584f, 0.02574996f, -0.02494242f, 
    0.13053788f, -0.11522653f, -0.08748434f, -0.07641741f, -0.04736425f, -0.00093851f, 0.01775525f, -0.00471634f, 
    -0.02681989f, -0.10876989f, -0.10936216f, -0.04300831f, 0.06234035f, -0.00018099f, 0.03426063f, -0.00613288f, 
    -0.08423583f, 0.08042152f, 0.07288072f, 0.01104673f, 0.19286256f, 0.27764943f, -0.06840920f, 0.09831510f, 
    0.05110326f, -0.02807436f, 0.05304064f, 0.05546749f, -0.02760510f, -0.00921747f, 0.02596938f, -0.01867447f, 
    -0.09404931f, -0.01182149f, -0.03516444f, 0.09340531f, 0.04042609f, 0.06998602f, -0.03297796f, 0.02682664f, 
    -0.02714069f, -0.04437444f, 0.14314853f, 0.09739187f, 0.14645857f, -0.02287437f, 0.01396751f, 0.26520655f, 
    0.06841124f, 0.02709528f, 0.10944290f, -0.00420105f, 0.07810806f, 0.05290526f, -0.04880364f, 0.10741033f, 
    0.01621694f, 0.16648175f, 0.09991845f, -0.07713058f, 0.06673040f, 0.01768825f, 0.06679405f, 0.06897466f, 
    0.04618514f, -0.00701518f, -0.01129277f, 0.10520167f, 0.22118123f, 0.06691582f, 0.00492502f, -0.03722474f, 
    -0.06194348f, 0.11057767f, 0.08793627f, -0.02275781f, 0.01994716f, -0.06673467f, -0.09807888f, 0.01668760f, 
    0.12207277f, -0.00712517f, -0.05761786f, 0.13918117f, 0.04128095f, 0.00164705f, 0.07794940f, -0.04333327f, 
    -0.02411076f, 0.08549652f, -0.03107641f, 0.02484922f, 0.32761475f, -0.08308692f, -0.17445269f, 0.06201461f, 
    0.05293080f, 0.05411034f, -0.09724242f, 0.09152115f, 0.00463336f, 0.04304415f, 0.02795221f, 0.03207530f, 
    0.15898523f, 0.06234015f, -0.06518029f, 0.19696036f, 0.04576071f, 0.12621640f, 0.09470058f, 0.17852323f, 
    -0.11261540f, 0.08496484f, 0.12903661f, 0.03582289f, -0.13040039f, 0.34901148f, -0.00711329f, 0.11458972f, 
    -0.19028917f, 0.04466479f, -0.05323702f, 0.11731249f, 0.01141594f, 0.06147003f, 0.07514971f, 0.04977523f, 
    0.19742499f, 0.12032680f, 0.07128718f, 0.16309096f, 0.07481559f, 0.03102936f, 0.01242069f, 0.08912708f, 
    0.00938676f, 0.08447649f, 0.03689507f, 0.17006737f, 0.29613525f, 0.12289093f, 0.03626372f, 0.21934259f, 
    0.03666952f, 0.11093401f, 0.07086454f, 0.01452186f, 0.07072482f, -0.00752832f, 0.17087016f, 0.08853158f, 
    0.37332484f, -0.24291651f, -0.06931650f, 0.16896382f, 0.09040863f, -0.12246016f, 0.02736987f, 0.02806257f, 
    0.07305294f, 0.12968384f, -0.01092399f, 0.17871375f, -0.25858572f, -0.11097854f, 0.28216743f, 0.12332927f, 
    0.02884711f, 0.03607369f, -0.09183959f, -0.02200582f, 0.02854294f, 0.04068544f, 0.04531439f, 0.05460913f, 
    -0.03732817f, 0.05637017f, 0.06075700f, 0.03004014f, -0.02857758f, 0.08247357f, 0.14094205f, 0.07361829f, 
    -0.03912219f, 0.08094672f, -0.01415389f, -0.13551889f, 0.28216696f, -0.03790628f, 0.21668866f, -0.10777698f, 
    -0.02290668f, -0.00085485f, 0.11777706f, 0.01629036f, 0.13202126f, -0.00783017f, 0.15669133f, -0.01018122f, 
    -0.05136922f, 0.00218304f, 0.25952032f, 0.18252888f, 0.09535343f, -0.07269709f, 0.00232212f, 0.00895333f, 
    0.10667305f, 0.04207516f, -0.00163258f, 0.03645212f, -0.14229946f, 0.10005496f, 0.01904076f, 0.11666350f, 
    0.15762796f, -0.02670697f, 0.02516143f, 0.06989782f, 0.05484597f, 0.07420978f, 0.06590775f, -0.02808576f, 
    -0.31871092f, -0.03701494f, 0.15483081f, -0.04955346f, 0.03398093f, -0.06227028f, 0.01506455f, -0.02573244f, 
    0.04708581f, -0.02662633f, 0.05495731f, 0.04831973f, -0.09456564f, -0.06036881f, 0.02800805f, -0.03206460f, 
    0.09500643f, -0.04253845f, -0.04841594f, -0.05312131f, -0.07841919f, 0.02794698f, 0.02849515f, 0.07041617f, 
    0.08935279f, 0.01906553f, -0.12147015f, 0.03847755f, 0.12937835f, 0.03403678f, -0.07642572f, 0.06205522f, 
    0.08171651f, 0.11314266f, 0.15889585f, 0.02305365f, -0.17010222f, 0.07930274f, -0.02155464f, -0.03557309f, 
    0.04933617f, 0.10766530f, -0.02826043f, -0.05656648f, 0.14565307f, -0.05841073f, 0.01784316f, -0.10040236f, 
    0.17430088f, -0.22266601f, -0.17444815f, 0.09921066f, 0.17165294f, 0.02569540f, 0.06960969f, 0.08900020f, 
    -0.00900332f, 0.07133997f, -0.06008341f, 0.04382453f, -0.00580799f, 0.03388992f, -0.04693829f, -0.11483940f, 
    -0.07443806f, 0.01267299f, -0.10698161f, 0.00801218f, 0.03865327f, 0.07065193f, -0.01101047f, -0.06139459f, 
    -0.30619422f, 0.21897206f, 0.26423001f, 0.04938261f, 0.09871657f, 0.05951629f, 0.19447839f, -0.02009882f, 
    0.03141482f, 0.10712024f, 0.06660984f, 0.12275068f, 0.00130740f, 0.01240784f, -0.12427925f, -0.07246444f, 
    0.01966244f, -0.03469012f, -0.09540495f, -0.12906225f, -0.04332609f, -0.00859855f, -0.02918447f, -0.00746977f, 
    -0.15761875f, 0.15648042f, -0.04970221f, 0.11890867f, 0.05862000f, 0.03145652f, 0.10738482f, 0.02380188f, 
    0.07798489f, -0.01078363f, 0.02617346f, 0.04964609f, -0.40309322f, 0.00155483f, 0.13044469f, 0.02617909f, 
    -0.07076161f, -0.04588641f, -0.09890189f, -0.07481717f, -0.01397693f, 0.05401354f, 0.01259334f, 0.05134149f, 
    0.18900445f, 0.00047030f, -0.03165815f, 0.00530652f, -0.03476872f, 0.05151070f, 0.27997649f, -0.04434658f, 
    0.02169505f, -0.00652081f, 0.02299810f, -0.06640303f, 0.23442863f, -0.07059443f, -0.10066716f, -0.05300068f, 
    0.11919744f, 0.07050290f, 0.04535682f, 0.03696032f, 0.06658854f, 0.02631112f, 0.04893539f, 0.07607771f, 
    0.05427165f, -0.00415395f, 0.05027626f, 0.09622264f, 0.04857437f, 0.05191503f, 0.01540681f, 0.05135582f, 
    0.05438817f, -0.04402389f, 0.04024728f, 0.10547959f, -0.30588982f, 0.15084916f, -0.06791769f, -0.11492547f, 
    0.10433316f, 0.00311000f, 0.00710030f, -0.09826244f, 0.06335630f, 0.12464980f, 0.00297658f, 0.04841274f, 
    -0.05626589f, 0.02917690f, 0.00729621f, 0.03419039f, 0.02743409f, 0.01222573f, -0.02286910f, 0.06715710f, 
    0.22421487f, -0.06236936f, 0.04935230f, 0.10969366f, 0.03385254f, 0.06880499f, -0.07730028f, -0.06294799f, 
    -0.15363473f, 0.08744336f, -0.01399809f, 0.05052223f, 0.07498299f, 0.00366599f, 0.10314116f, 0.00012312f, 
    0.14280686f, -0.29113457f, 0.21158938f, 0.24011758f, 0.11343227f, 0.03308762f, 0.14072679f, 0.05882606f, 
    0.21201648f, 0.00888580f, 0.15195455f, 0.00889596f, 0.22463617f, 0.02445568f, 0.06591200f, -0.06807489f, 
    0.08360465f, -0.02226448f, 0.05543932f, 0.06145770f, -0.04753218f, -0.01856228f, 0.10479075f, -0.07754259f, 
    0.24008587f, -0.25055963f, -0.13304311f, -0.00572989f, 0.12162834f, 0.04965153f, -0.01755136f, 0.01895818f, 
    0.02348885f, 0.04583754f, 0.13501583f, -0.00589647f, 0.06899435f, -0.17406496f, -0.02797799f, -0.02482850f, 
    0.04765207f, -0.07768180f, -0.02740115f, 0.09868260f, 0.13384925f, -0.01687863f, 0.02082727f, 0.03532693f, 
    -0.31843543f, -0.07018711f, 0.16438112f, -0.00638058f, -0.01345691f, 0.01351585f, -0.00163980f, 0.15010636f, 
    0.02767092f, 0.05594232f, -0.03050238f, 0.01884340f, 0.08105379f, -0.10061900f, -0.01608304f, 0.10667740f, 
    -0.02195095f, 0.08806565f, 0.00406836f, 0.01348163f, -0.07972547f, -0.09060763f, 0.20280264f, 0.13818519f, 
    -0.06045709f, 0.24502642f, 0.07267217f, 0.04829859f, 0.18966623f, 0.08841977f, -0.02187094f, 0.04590766f, 
    0.12271389f, 0.11085524f, -0.00794805f, 0.06726785f, -0.01236297f, -0.22677918f, 0.18567985f, 0.17089576f, 
    0.04601022f, -0.02395463f, 0.03101233f, -0.01321312f, 0.04757218f, 0.08549678f, -0.07313308f, 0.05666675f, 
    -0.03960646f, 0.10088850f, 0.09434631f, -0.10005097f, 0.00618642f, 0.07837638f, 0.01150559f, -0.07657370f, 
    -0.08008235f, 0.12205076f, -0.00746256f, -0.06631000f, 0.26341236f, 0.15592316f, 0.14806923f, 0.18656708f, 
    0.09033887f, 0.02592896f, -0.02083811f, 0.10656954f, 0.13164550f, 0.01189117f, 0.03208765f, 0.08817574f, 
    0.17334479f, -0.10513132f, 0.08507483f, 0.16142872f, 0.06406236f, -0.05688059f, -0.00931175f, -0.11093366f, 
    0.03838710f, -0.04874417f, 0.00259478f, -0.03661707f, -0.12234333f, 0.21360943f, -0.14033273f, -0.10052437f, 
    -0.03586011f, 0.10043222f, -0.02354962f, -0.04431969f, 0.07286528f, -0.03286025f, 0.01969482f, 0.02414988f, 
    -0.14070255f, 0.14557236f, 0.13905172f, -0.06676795f, 0.05567658f, 0.09075004f, 0.01100298f, 0.06569286f, 
    0.07927717f, 0.02856412f, -0.02307820f, 0.00307459f, 0.08027861f, -0.01565654f, -0.01742270f, 0.13954626f, 
    0.14573905f, 0.05349546f, 0.01119102f, 0.01788334f, -0.04464267f, -0.02858957f, 0.15520239f, 0.10199750f, 
    -0.08877484f, -0.01930318f, -0.12300496f, -0.04545165f, 0.06652704f, 0.04407287f, 0.07751773f, -0.04473677f, 
    -0.05063048f, 0.12219894f, 0.06830934f, 0.04555652f, -0.28449583f, 0.01899200f, 0.14362463f, -0.10156402f, 
    -0.02644366f, -0.06788954f, -0.02953688f, 0.04426830f, 0.04788955f, 0.00619701f, 0.12941281f, 0.02750883f, 
    0.10466435f, -0.22933669f, 0.17341919f, 0.03793783f, 0.05169317f, 0.05558527f, -0.00304341f, -0.00150034f, 
    0.05656921f, 0.02304196f, 0.06593695f, -0.01884747f, 0.17123134f, 0.16529250f, 0.18439543f, 0.00341686f, 
    0.02904313f, -0.01406233f, 0.05405119f, 0.09244333f, 0.03676804f, 0.08474401f, -0.05074180f, 0.06917488f, 
    0.03618186f, 0.15830027f, 0.03239881f, -0.00764280f, -0.03859574f, 0.04410399f, -0.08299244f, -0.06776409f, 
    0.06889974f, -0.05627767f, -0.06843260f, 0.04182501f, -0.25724095f, 0.23277779f, 0.00365826f, -0.17033359f, 
    0.06338536f, -0.03437486f, 0.11055961f, -0.11263219f, 0.11323778f, 0.10897383f, 0.03306854f, -0.00509340f, 
    0.02170310f, -0.04078201f, 0.01830516f, -0.02512304f, -0.01551723f, -0.01785816f, -0.03022501f, 0.00485243f, 
    -0.02840672f, 0.01275255f, -0.03607954f, -0.03409075f, -0.00520140f, -0.00512447f, -0.02744763f, -0.00343449f, 
    -0.00603853f, 0.00818318f, -0.01742953f, 0.00794384f, -0.04061399f, -0.03763648f, -0.03080216f, -0.02178540f, 
    0.01351048f, 0.01325802f, -0.02366525f, 0.02786964f, -0.04217323f, 0.01604278f, -0.01198376f, -0.03447666f, 
    0.03423615f, -0.04036117f, 0.00481078f, -0.04251128f, -0.00070353f, -0.03615975f, 0.00221410f, -0.01855906f, 
    -0.02736757f, -0.02012743f, 0.00568849f, -0.01629053f, -0.01060533f, 0.00168244f, -0.02474355f, -0.01279542f, 
    -0.00818160f, 0.00649842f, 0.01086763f, -0.03206832f, -0.00549476f, -0.00331407f, -0.01696361f, -0.00741830f, 
    -0.03707183f, 0.00916411f, -0.02002139f, 0.02507361f, 0.02510346f, 0.01933237f, -0.02312545f, -0.02279676f, 
    0.01740868f, -0.01078033f, -0.03804060f, 0.02673685f, 0.02702622f, -0.00408221f, -0.01805326f, -0.00634488f, 
    0.01625055f, 0.02565060f, -0.01662258f, -0.00127527f, 0.02381178f, -0.01464805f, -0.00670558f, -0.00186633f, 
    0.02504602f, 0.01766088f, -0.02890099f, -0.03166161f, -0.01607005f, -0.04021582f, 0.01495974f, -0.02721731f, 
    0.00747148f, 0.01922465f, 0.02478499f, -0.00119264f, 0.02147947f, 0.01727617f, -0.03764841f, 0.02624200f, 
    0.01194456f, -0.03935141f, -0.00475099f, 0.01508809f, -0.00584933f, -0.01681686f, 0.01085946f, -0.01121592f, 
    -0.02652686f, 0.02442034f, 0.02362420f, -0.02287097f, -0.00621920f, -0.03193126f, 0.01759825f, 0.00086255f, 
    0.00504666f, -0.00193873f, -0.00632602f, 0.01505421f, -0.03603373f, 0.00989167f, -0.03542291f, 0.00815783f, 
    0.02702018f, -0.02138186f, -0.00088439f, 0.01203344f, 0.02669772f, -0.03066127f, 0.01529601f, 0.01961686f, 
    0.02694446f, -0.00841714f, -0.03264838f, 0.03717306f, -0.01976912f, 0.01678704f, 0.00983667f, 0.01075303f, 
    0.00573982f, 0.02104007f, -0.03488221f, 0.03536676f, 0.01994693f, 0.01202909f, 0.01539695f, -0.01539611f, 
    0.02354178f, 0.02866181f, -0.04338221f, -0.03326991f, -0.02449835f, 0.01601093f, 0.02285544f, -0.00270077f, 
    -0.04128869f, 0.02044409f, -0.01229763f, 0.03247386f, 0.01545211f, -0.03387181f, 0.02242281f, 0.02477233f, 
    0.01327983f, -0.00881834f, -0.03351757f, 0.02240853f, 0.01700081f, 0.01022331f, 0.01147462f, 0.00395989f, 
    0.03185412f, -0.02769101f, -0.01446295f, 0.03029640f, -0.03988983f, 0.00164259f, -0.02656434f, 0.03178620f, 
    -0.02388419f, -0.00040186f, 0.00710735f, 0.00617110f, -0.02449042f, -0.02587272f, -0.04211346f, 0.01108620f, 
    -0.03421802f, -0.03379159f, 0.02787751f, 0.01139483f, -0.01148065f, 0.02804166f, 0.03923823f, -0.02977427f, 
    -0.02977612f, -0.01363518f, -0.00694263f, -0.00712124f, 0.00237583f, 0.01168872f, -0.03114275f, -0.01535562f, 
    -0.04134303f, -0.01520760f, -0.01906023f, -0.03334882f, 0.00681581f, 0.02431766f, -0.00929501f, 0.01366088f, 
    0.02486103f, -0.03483412f, -0.01620498f, -0.00410391f, -0.00830628f, -0.01328410f, -0.01384481f, -0.00919077f, 
    -0.02161683f, -0.02045499f, 0.00310102f, -0.02026433f, -0.04280262f, 0.03757338f, -0.03913933f, -0.02672627f, 
    -0.03919120f, -0.02323554f, 0.01596985f, 0.03073561f, -0.01905112f, -0.02616110f, -0.02697297f, 0.01740800f, 
    -0.01823828f, 0.02104872f, -0.02351453f, 0.01951937f, 0.01118607f, -0.03118526f, -0.01544066f, 0.01495333f, 
    -0.01069898f, -0.01998713f, -0.00764418f, -0.01761477f, -0.02610664f, 0.00928881f, -0.02406652f, -0.00858592f, 
    0.02820109f, 0.02508842f, -0.02097097f, -0.02971224f, -0.01604630f, 0.00057270f, 0.01633675f, -0.03708766f, 
    -0.04155653f, 0.00879458f, -0.02098188f, -0.00997058f, 0.02525345f, -0.02336184f, -0.04155451f, -0.02054832f, 
    0.02573238f, -0.00868579f, -0.04043388f, -0.00309775f, 0.01708358f, 0.02608346f, 0.02175428f, 0.02797729f, 
    0.02442298f, -0.02157108f, -0.00277424f, -0.00896858f, -0.00068236f, -0.04003257f, -0.03138513f, 0.02096618f, 
    -0.01145729f, -0.04040545f, -0.02665670f, 0.00062978f, -0.04146283f, -0.00205997f, -0.00878828f, 0.00059535f, 
    0.01543889f, 0.02232066f, 0.02729922f, 0.02644183f, -0.00217808f, -0.02237699f, -0.00500266f, -0.03153291f, 
    0.02731655f, -0.01238727f, -0.00392382f, 0.00335678f, -0.04411435f, 0.02331151f, 0.01662114f, -0.01471053f, 
    0.03548561f, 0.03506910f, -0.02345792f, 0.00517616f, 0.01893768f, -0.00594292f, -0.03953752f, 0.00557172f, 
    0.00931871f, 0.01889868f, -0.02734747f, -0.00596166f, -0.03325846f, 0.01095784f, 0.03325618f, 0.02043018f, 
    0.01668402f, -0.01916271f, 0.02298409f, 0.02304137f, -0.00841033f, 0.02447926f, -0.02023278f, -0.02219467f, 
    0.01615478f, -0.02637939f, 0.02870376f, -0.03599352f, 0.01587800f, -0.03236115f, -0.00472203f, -0.02480512f, 
    -0.00341514f, -0.00820152f, -0.00972387f, -0.02357013f, 0.00772515f, 0.01725273f, 0.02731267f, -0.02055511f, 
    -0.00448060f, 0.00646191f, -0.04097557f, -0.00367176f, 0.03073628f, 0.01134868f, 0.02766491f, 0.00912920f, 
    -0.01809367f, -0.02530371f, -0.02188222f, 0.00398325f, -0.03881339f, 0.01640248f, -0.00275346f, 0.00374444f, 
    -0.00163159f, -0.00192703f, 0.01545451f, 0.02220908f, 0.00984829f, 0.00201776f, 0.01496042f, -0.00227031f, 
    -0.02506948f, -0.02605991f, -0.00890627f, 0.02782123f, -0.02054167f, 0.00922153f, 0.02417530f, 0.04040407f, 
    0.01834730f, 0.03186411f, 0.02065535f, -0.02953060f, 0.02888250f, 0.00391341f, -0.02824436f, 0.02632088f, 
    -0.01790345f, -0.00296101f, -0.02162429f, 0.00547884f, 0.01808667f, -0.01879719f, 0.01499052f, 0.01478642f, 
    0.01549571f, 0.01399018f, -0.00047474f, -0.00632097f, -0.01947410f, -0.00640554f, 0.00938301f, -0.02271048f, 
    -0.01815947f, -0.03612014f, 0.01584870f, 0.01359234f, 0.01780727f, -0.02332759f, 0.03394433f, -0.00282095f, 
    0.00802937f, -0.00827414f, -0.01776257f, -0.02047152f, 0.01015583f, -0.04144555f, 0.02307565f, 0.01504882f, 
    0.01846116f, -0.02240393f, -0.02438489f, -0.00311076f, 0.02302533f, 0.00077502f, -0.00292909f, 0.00323030f, 
    -0.01121155f, 0.01720390f, -0.02746477f, -0.01554181f, 0.01535247f, -0.00215997f, -0.03328449f, 0.00920424f, 
    0.01834961f, -0.03600708f, -0.02162289f, -0.02702931f, -0.01408184f, -0.01326286f, 0.01994844f, -0.00353758f, 
    0.01696743f, -0.00512345f, 0.02253869f, -0.01642206f, -0.04390584f, -0.01953502f, -0.02382315f, 0.02065905f, 
    0.00850732f, -0.02281527f, -0.01104001f, 0.00367547f, 0.00407933f, -0.03205267f, -0.02767073f, 0.02178690f, 
    -0.03941560f, 0.02534387f, -0.01324229f, -0.02580828f, -0.01320707f, -0.03258515f, 0.01813506f, 0.00106257f, 
    0.02844674f, -0.01381161f, 0.00944045f, -0.00023336f, 0.02968093f, -0.01787747f, -0.02836125f, -0.01403489f, 
    -0.04284614f, 0.00741146f, -0.03500842f, -0.01618072f, -0.00427194f, 0.00663632f, -0.00034045f, 0.01057019f, 
    0.01225872f, 0.00485017f, 0.00529702f, -0.02384161f, 0.00113800f, -0.01359926f, -0.01907824f, -0.00805692f, 
    0.01741066f, -0.01389457f, -0.00371504f, 0.01606351f, -0.02963015f, 0.01964838f, -0.02898155f, -0.02077916f, 
    -0.02658874f, 0.00785069f, -0.02538918f, -0.03121955f, -0.02563077f, -0.01962631f, -0.01125816f, -0.03772930f, 
    -0.01257449f, -0.03173584f, 0.01216886f, -0.02644260f, 0.00924772f, -0.04270644f, 0.02135251f, 0.02213146f, 
    -0.01769667f, -0.03137441f, 0.01327258f, -0.02681751f, 0.01646263f, 0.00968123f, 0.00425484f, -0.04137551f, 
    -0.02838167f, 0.00506258f, 0.00102388f, -0.02857629f, -0.01704764f, 0.00469749f, -0.02113855f, -0.00105887f, 
    0.01645759f, -0.03711795f, 0.00555234f, -0.04180953f, -0.00563873f, 0.02407090f, -0.03016650f, 0.01453135f, 
    0.02472989f, -0.02335837f, -0.02992078f, -0.00600156f, 0.01212387f, -0.04058288f, 0.03244550f, 0.02379303f, 
    0.02171543f, -0.00341946f, -0.01815630f, -0.01326596f, -0.00476724f, 0.01510397f, -0.02184295f, 0.01416172f, 
    -0.02269482f, -0.00883623f, -0.01466374f, 0.01212913f, -0.01748197f, 0.00916826f, 0.00748772f, 0.02590365f, 
    -0.03030908f, -0.02107213f, -0.00370563f, -0.01865640f, -0.00098623f, 0.02729365f, -0.02279774f, -0.00212374f, 
    -0.00177284f, 0.00561967f, 0.01460157f, 0.02608514f, -0.03460553f, 0.02574978f, 0.00145533f, -0.03029806f, 
    -0.00296112f, -0.03286372f, 0.01394044f, -0.01003346f, 0.03116306f, -0.00822835f, -0.02496276f, -0.03127968f, 
    -0.03416475f, -0.02054188f, -0.02338035f, -0.03501354f, -0.04177488f, 0.00634657f, -0.02056362f, 0.02347856f, 
    -0.01544596f, -0.03209521f, -0.00252499f, -0.02429905f, 0.01695489f, 0.01747227f, -0.01539170f, -0.04121929f, 
    -0.00883696f, -0.00668770f, -0.00249552f, -0.00559908f, 0.00184954f, 0.00600980f, -0.01940051f, 0.00673931f, 
    0.00612063f, 0.01767600f, -0.02831547f, -0.01620539f, -0.01274064f, -0.01495404f, 0.02398738f, -0.00750294f, 
    0.00539803f, 0.00966692f, -0.01583075f, 0.02018565f, -0.02720240f, -0.02156207f, -0.03896774f, -0.02548424f, 
    0.00384664f, -0.03938067f, -0.01898860f, -0.00807540f, -0.03007781f, -0.00865659f, 0.00869132f, 0.03649241f, 
    -0.02380561f, 0.01510605f, -0.02270989f, -0.00308668f, 0.02417073f, -0.04021061f, -0.00347055f, -0.02901342f, 
    0.00999072f, -0.03255648f, 0.02923836f, -0.00974527f, -0.01917184f, -0.04356408f, -0.02227761f, -0.01675467f, 
    0.02102232f, -0.00990462f, -0.01427177f, -0.01585222f, 0.00007926f, -0.00829676f, 0.03855840f, -0.00089703f, 
    -0.01162764f, -0.01168009f, -0.02655020f, 0.01701655f, -0.03518172f, 0.02561033f, -0.03421263f, -0.04047993f, 
    -0.03955061f, -0.02772474f, -0.01854816f, -0.01767191f, 0.00142987f, -0.01409381f, 0.01643176f, -0.02692700f, 
    0.00921463f, 0.03946171f, -0.03302675f, 0.01444517f, 0.00144393f, 0.01379518f, -0.04123045f, 0.01203071f, 
    -0.00367318f, -0.01533475f, -0.04016848f, -0.03611701f, 0.03560140f, -0.00819129f, 0.00414032f, -0.04120109f, 
    -0.02503312f, 0.04025425f, -0.01875633f, -0.03395604f, 0.00671745f, -0.02275010f, 0.01411372f, 0.02026809f, 
    -0.03791161f, 0.02552745f, -0.00125342f, -0.02571549f, -0.01196549f, -0.02706920f, 0.02158413f, 0.00482490f, 
    -0.04036900f, 0.01252165f, -0.03276324f, 0.01123237f, 0.02081661f, -0.02757692f, -0.00039674f, -0.00181264f, 
    0.02341265f, -0.00569032f, -0.03714715f, -0.03769079f, 0.02634001f, -0.02429095f, -0.02506298f, 0.02223557f, 
    -0.03471394f, 0.02179796f, 0.00052137f, 0.01695828f, -0.03252371f, 0.00780958f, 0.02127224f, 0.02288277f, 
    -0.02879501f, 0.00636902f, -0.00774934f, -0.02158111f, 0.02738963f, -0.01123354f, -0.02860575f, 0.03063998f, 
    -0.02748660f, 0.00256242f, -0.03268550f, 0.01684243f, -0.02047285f, 0.02015125f, -0.00881123f, 0.00606829f, 
    -0.02813983f, -0.04147866f, 0.01135409f, 0.00982251f, -0.02653981f, -0.01283898f, -0.02861603f, -0.00483181f, 
    -0.00265008f, -0.01599976f, -0.03516037f, 0.02455069f, 0.00535772f, -0.01081769f, 0.00316717f, 0.02610518f, 
    -0.03133893f, -0.01551563f, 0.02364855f, -0.00499179f, -0.03239191f, -0.01747765f, -0.03999760f, 0.02253970f, 
    -0.30515528f, -0.06895863f, 0.10350927f, 0.10867226f, -0.03527118f, -0.00705474f, -0.10460775f, 0.05896468f, 
    0.15477495f, 0.09154791f, 0.03848705f, 0.13461974f, 0.03002470f, 0.00238441f, -0.05786097f, 0.02600727f, 
    0.05369391f, 0.08114894f, 0.02177762f, 0.00415919f, 0.06900253f, 0.02295698f, -0.06075663f, 0.03424209f, 
    -0.18946899f, 0.13268809f, 0.12793215f, 0.11872302f, -0.02363398f, -0.08270478f, 0.00170375f, 0.11548600f, 
    0.08775163f, 0.03929368f, 0.05851587f, -0.03208471f, 0.08113182f, 0.15771963f, -0.05784105f, 0.05143538f, 
    0.00622072f, 0.01988742f, 0.11317895f, 0.12005164f, -0.06690818f, 0.06036304f, -0.15160961f, -0.00238774f, 
    0.12098126f, -0.16716854f, -0.02901440f, -0.03820011f, -0.02175416f, -0.08134486f, 0.07493208f, -0.06460766f, 
    -0.11824866f, -0.02869274f, 0.09864222f, 0.08778120f, -0.35613573f, 0.01744745f, -0.03983359f, -0.05045626f, 
    0.03178912f, -0.06314687f, -0.03842970f, 0.11855678f, 0.24303710f, 0.17139697f, -0.04317117f, 0.14101462f, 
    -0.13918136f, 0.15916605f, -0.00846116f, -0.20012493f, 0.04194512f, -0.01012294f, -0.01538687f, -0.09362780f, 
    0.22898306f, 0.04013211f, 0.07808457f, -0.04816314f, -0.18570903f, 0.08348842f, -0.02380260f, -0.17940684f, 
    0.02729928f, -0.06938729f, -0.03371719f, 0.05497358f, 0.10612980f, 0.01176786f, -0.14322171f, -0.03640660f, 
    0.04570348f, 0.11956720f, -0.04067039f, 0.33437616f, 0.03419662f, -0.01752435f, -0.16364826f, 0.10919906f, 
    -0.07548768f, -0.05949214f, -0.07908486f, 0.03093012f, -0.06868511f, -0.04209159f, -0.03154548f, -0.24714835f, 
    0.07161178f, -0.01863805f, 0.02476222f, -0.04371710f, -0.01049256f, 0.01380187f, 0.02051665f, 0.04115605f, 
    -0.18382838f, 0.05849697f, -0.06478170f, -0.05041876f, 0.08957040f, -0.01061836f, 0.08013131f, -0.02244227f, 
    -0.04783213f, 0.00431913f, 0.05094867f, -0.05237162f, 0.01561068f, -0.11213478f, 0.01843036f, 0.05645217f, 
    -0.03958788f, -0.14367379f, -0.04488865f, -0.10910699f, 0.02710398f, -0.00057867f, 0.03392333f, 0.00912164f, 
    -0.14723589f, -0.08980439f, 0.05407911f, -0.02542625f, 0.07905909f, 0.05737614f, 0.02030402f, -0.02962500f, 
    -0.00179920f, -0.03790857f, 0.15914735f, -0.07169280f, -0.07802321f, 0.03065433f, -0.07229372f, 0.14745569f, 
    0.16276012f, 0.02520376f, -0.03195879f, -0.03939889f, 0.15418865f, -0.00884309f, -0.10354222f, 0.00072175f, 
    0.18070596f, -0.04752679f, -0.15755010f, -0.26738426f, -0.01663011f, 0.01078408f, -0.09535231f, 0.01868712f, 
    -0.01545211f, 0.00074466f, 0.01574188f, -0.01775748f, 0.02314657f, 0.09764595f, 0.12316567f, 0.22091877f, 
    0.00335405f, -0.03365745f, -0.07572831f, 0.00576556f, -0.03572552f, -0.02644045f, -0.00805053f, -0.08106785f, 
    -0.05051307f, 0.08274778f, -0.00139849f, 0.01190197f, 0.17118847f, 0.04015171f, 0.09632330f, -0.03017008f, 
    0.01182367f, -0.04497895f, 0.02244131f, 0.06134332f, 0.19076046f, 0.06679046f, -0.07584889f, -0.19399878f, 
    -0.04112290f, 0.05651590f, 0.05881540f, 0.00639947f, 0.04808301f, 0.18454251f, 0.10172419f, -0.02346007f, 
    -0.07772183f, -0.22553802f, -0.03843946f, 0.00656698f, -0.00735669f, 0.07991338f, -0.03708058f, 0.07495852f, 
    -0.11903827f, 0.15047564f, 0.09144557f, 0.02458865f, 0.14789878f, -0.05385894f, 0.07081679f, 0.00655970f, 
    -0.11341047f, -0.01658622f, 0.03493341f, 0.03765952f, 0.05533567f, 0.01303780f, -0.05037483f, 0.01881311f, 
    0.18125074f, -0.01283118f, -0.22121678f, 0.16716005f, 0.06037216f, -0.10852583f, -0.00868795f, 0.05437459f, 
    -0.04776209f, 0.00805146f, 0.07093335f, 0.17423035f, -0.26847467f, -0.07426305f, -0.04207901f, 0.17075288f, 
    0.11071407f, -0.09359933f, 0.04554078f, -0.00642039f, -0.05135131f, 0.00319181f, 0.01514008f, 0.11576064f, 
    0.05005546f, -0.10409612f, 0.06023486f, 0.03457376f, 0.02957989f, 0.01906229f, 0.04040959f, 0.00017812f, 
    0.00553200f, 0.01175337f, -0.10685159f, 0.12065820f, -0.07882380f, 0.08426166f, -0.09598190f, -0.05757055f, 
    0.07165590f, 0.00852104f, 0.03904188f, -0.09238985f, 0.01421859f, 0.00591644f, -0.00781289f, 0.07596105f, 
    -0.13015735f, 0.09668339f, -0.09129255f, 0.21800067f, -0.02067843f, -0.07396527f, 0.03943249f, 0.00979602f, 
    0.04232847f, 0.03095492f, -0.08750549f, -0.16438174f, -0.00120080f, -0.01688987f, 0.03660957f, -0.06014509f, 
    0.08879525f, -0.01569455f, -0.06107230f, -0.10135441f, 0.04202777f, -0.02353458f, 0.06517531f, 0.00223784f, 
    0.22289251f, -0.00061555f, 0.06696843f, -0.06876884f, 0.16241623f, -0.10850050f, -0.00085429f, 0.07832859f, 
    0.08613633f, 0.02760111f, 0.05342172f, -0.01174236f, -0.15940325f, 0.13962263f, -0.02336524f, -0.26501396f, 
    -0.02976575f, -0.03092511f, -0.00938628f, 0.12377489f, -0.04607899f, 0.14904276f, 0.04404059f, -0.01583880f, 
    -0.01127047f, 0.03372872f, -0.03164336f, -0.03763669f, -0.08805231f, 0.04406558f, 0.09174137f, -0.00290218f, 
    -0.14131090f, -0.03485928f, 0.05201926f, -0.02972344f, -0.01876438f, 0.00803352f, -0.14358225f, -0.06352106f, 
    0.17335163f, -0.01157474f, 0.02469886f, -0.04943348f, -0.01162726f, 0.11715979f, 0.14167088f, 0.04561285f, 
    0.04537069f, -0.03626589f, 0.15725149f, -0.14269739f, -0.01793203f, 0.03142152f, -0.00452628f, -0.00212970f, 
    0.06724729f, -0.00992385f, 0.11158765f, -0.05451781f, -0.06110523f, -0.09426841f, 0.00281110f, 0.29279616f, 
    0.06114990f, 0.10720936f, 0.04452763f, 0.00379495f, 0.06165911f, -0.00314089f, -0.00965788f, -0.02781784f, 
    0.11349796f, 0.06282578f, -0.15986741f, -0.03971218f, 0.07396559f, 0.07020600f, -0.04784970f, 0.10462973f, 
    0.11957186f, 0.04331708f, 0.02226154f, -0.07049328f, 0.14361839f, 0.05104567f, -0.01344134f, -0.03472462f, 
    0.04069369f, -0.14867507f, -0.01542958f, 0.16004930f, 0.13208355f, 0.01480056f, 0.01191927f, -0.03339468f, 
    0.04433433f, -0.04454258f, 0.00746396f, -0.00466385f, -0.01917095f, -0.10274913f, 0.22029568f, -0.02060593f, 
    0.06512008f, 0.11803833f, 0.02280853f, 0.05565985f, 0.26652974f, -0.08449743f, 0.04439178f, -0.05862661f, 
    -0.00204533f, -0.03052145f, -0.06885713f, 0.10192499f, -0.01414502f, -0.04015800f, 0.01663827f, 0.07982896f, 
    0.10809896f, -0.06280868f, -0.16039547f, -0.03675231f, 0.08368902f, -0.12844244f, 0.06020686f, -0.08376016f, 
    0.08102626f, -0.05500869f, 0.04698236f, -0.05586985f, -0.18678464f, 0.04093680f, -0.16940014f, -0.08832487f, 
    0.05786785f, -0.09247767f, -0.20194784f, -0.04320709f, -0.07700252f, -0.12371492f, 0.01359915f, 0.17188613f, 
    -0.18736550f, 0.00119300f, 0.06630607f, 0.21840015f, -0.11204215f, -0.02616489f, -0.01653365f, 0.14413455f, 
    -0.01530107f, -0.06516235f, -0.02801608f, -0.04897535f, -0.08920200f, -0.00835313f, -0.15361711f, 0.00993608f, 
    0.04699009f, 0.03068553f, 0.06679061f, -0.00061235f, 0.02846413f, -0.02430942f, 0.00335035f, -0.00040721f, 
    0.18935823f, -0.15656362f, -0.14444794f, -0.00732413f, -0.17335801f, 0.03791324f, -0.00925450f, 0.03901362f, 
    0.06360791f, -0.05606584f, -0.02602502f, 0.02480836f, -0.02127952f, -0.07235071f, -0.01034660f, 0.10983071f, 
    0.04243048f, 0.05284602f, -0.03948089f, -0.14557624f, -0.01127342f, -0.00184239f, -0.03801438f, 0.06125121f, 
    -0.09676135f, 0.10719951f, 0.17342451f, -0.10663775f, -0.08382463f, -0.00891321f, 0.01247130f, 0.02397018f, 
    0.01586180f, -0.12819998f, -0.07362314f, 0.07388095f, -0.12466445f, 0.21659233f, -0.05660691f, 0.24808724f, 
    -0.05343269f, -0.07759923f, -0.00603590f, 0.00888433f, 0.10264775f, -0.02534645f, 0.01452730f, 0.00993641f, 
    -0.23096430f, 0.09999192f, 0.01097761f, 0.01050345f, 0.18763521f, 0.03442270f, 0.11984660f, 0.10868077f, 
    0.03160468f, 0.01352275f, 0.03451515f, 0.04822212f, -0.20211805f, 0.21870354f, -0.06133155f, -0.00682622f, 
    -0.04101961f, -0.01137931f, 0.11777225f, 0.11936164f, -0.07566904f, 0.02066269f, -0.04706856f, -0.06301729f, 
    -0.05988824f, 0.06165952f, -0.10635172f, -0.05182376f, 0.05940036f, 0.05060155f, 0.02357644f, -0.01893377f, 
    0.11604618f, -0.06337123f, -0.03298221f, 0.00782930f, 0.12480683f, 0.17209505f, 0.11413055f, 0.01738540f, 
    0.11346523f, -0.10444519f, 0.12500769f, 0.05294633f, 0.02581217f, -0.01320297f, -0.01849451f, 0.06293341f, 
    -0.04176227f, -0.08660873f, -0.03883206f, -0.28862751f, 0.04648326f, 0.02432630f, 0.03502166f, 0.11180360f, 
    0.13624114f, 0.06156327f, -0.05960466f, 0.08763732f, 0.01896258f, -0.13152762f, -0.14329933f, 0.15970530f, 
    0.04215530f, 0.06117732f, -0.02693640f, -0.03659148f, -0.06388655f, -0.09052707f, 0.02825278f, 0.11778799f, 
    0.00024320f, -0.12519108f, 0.02736034f, 0.38080120f, -0.00866220f, -0.05795829f, -0.15328296f, -0.04769695f, 
    -0.10870799f, 0.05268813f, -0.02875997f, 0.14648886f, -0.16615939f, 0.07361076f, 0.00488774f, 0.01306814f, 
    0.16439885f, -0.04024073f, 0.01720920f, 0.04903931f, -0.07490074f, 0.05735999f, -0.07582612f, 0.07672078f, 
    0.13619792f, -0.14885201f, -0.16597344f, 0.30340624f, 0.06394441f, -0.02353289f, -0.07464714f, -0.09707937f, 
    -0.10886153f, -0.15247031f, -0.03784181f, 0.04207266f, -0.26972845f, 0.04239903f, 0.03737256f, 0.05960001f, 
    0.25201029f, -0.06428897f, 0.02604429f, 0.05256002f, -0.07331926f, -0.06039733f, 0.05117097f, 0.08207089f, 
    -0.07802050f, 0.08245077f, 0.02479773f, -0.12657945f, 0.01372782f, -0.01967182f, 0.01404939f, 0.04027386f, 
    0.05416394f, -0.01496300f, 0.03775055f, 0.07215299f, -0.11730513f, 0.03710619f, -0.02725252f, 0.45587501f, 
    -0.13270694f, 0.07067256f, 0.04542835f, 0.05568614f, -0.06702642f, 0.05985172f, 0.03391658f, 0.01330526f, 
    -0.26114804f, -0.02248731f, -0.10309018f, -0.34904343f, 0.13938594f, -0.05593804f, 0.01092575f, 0.00716720f, 
    -0.04799688f, -0.05342695f, 0.00035384f, -0.03895269f, -0.13874011f, -0.06479623f, -0.06048813f, -0.00479222f, 
    -0.01954459f, 0.12736827f, -0.04276161f, -0.05696779f, -0.11544532f, 0.05333661f, 0.02781815f, 0.07491378f, 
    -0.10327360f, 0.01256838f, -0.05788925f, 0.23173133f, -0.00016760f, -0.18317647f, -0.09749994f, -0.03663171f, 
    0.06444571f, 0.07970289f, -0.03749564f, -0.02827403f, 0.12391746f, 0.04529491f, -0.04790547f, 0.02144080f, 
    0.01873877f, 0.04057373f, -0.08239168f, 0.07143164f, -0.00680669f, 0.00670851f, 0.05561145f, 0.09383930f, 
    -0.12733589f, 0.05895978f, 0.04503184f, -0.17980283f, 0.20502715f, 0.03573994f, -0.02588210f, 0.03253244f, 
    -0.04055717f, -0.00263351f, 0.01026003f, -0.11347698f, -0.19050536f, -0.21751575f, 0.18962830f, -0.10002729f, 
    -0.10091511f, -0.06114537f, -0.01270454f, 0.01001558f, 0.01768129f, 0.12599796f, -0.04373964f, 0.13370396f, 
    0.06863306f, 0.04594782f, 0.07217675f, 0.06753464f, 0.00183050f, -0.09540341f, -0.03267116f, -0.12608258f, 
    0.01550706f, -0.09610464f, 0.05142673f, -0.04304043f, -0.23400635f, -0.00157911f, -0.19187467f, -0.02389393f, 
    0.07312647f, 0.02288685f, 0.02085602f, -0.00280414f, 0.04870377f, 0.11601588f, 0.01312435f, 0.12287374f, 
    0.01467921f, -0.03216723f, -0.03259519f, -0.03581986f, 0.00532366f, -0.00620998f, -0.00679757f, 0.01880737f, 
    0.00738984f, 0.00780316f, -0.01597741f, 0.00819570f, 0.02218335f, -0.03759822f, 0.02573849f, -0.03788012f, 
    0.00086012f, -0.03225888f, -0.04136306f, 0.01675937f, 0.00770013f, 0.00909786f, 0.01610160f, -0.03070984f, 
    -0.02323522f, -0.02431391f, -0.00399050f, -0.01201556f, 0.02115547f, -0.02653880f, -0.02881814f, -0.03729747f, 
    -0.03487580f, 0.01488812f, 0.01440393f, -0.00793689f, -0.00713885f, 0.02506746f, -0.01780869f, -0.01031114f, 
    -0.00447810f, -0.03488773f, -0.02982341f, 0.00034552f, 0.00261138f, -0.00249454f, 0.01442657f, 0.00086134f, 
    -0.01132290f, -0.02519231f, 0.02464176f, -0.03471383f, 0.00384626f, -0.03026491f, 0.02657846f, 0.00372970f, 
    -0.02165119f, -0.00038583f, 0.00720941f, -0.03555405f, 0.00702186f, -0.02634919f, -0.00371407f, 0.02056456f, 
    0.01306665f, -0.01043881f, -0.02989345f, -0.03224749f, -0.02913647f, -0.03994773f, -0.02992427f, -0.01553856f, 
    0.03980310f, 0.02015185f, 0.02203232f, 0.02089348f, 0.02491042f, -0.00578103f, 0.02533560f, 0.01372481f, 
    0.01794593f, 0.01835434f, -0.00737265f, -0.01697536f, -0.00390014f, 0.02570057f, -0.00532363f, -0.01054311f, 
    -0.01362107f, -0.01069971f, -0.01778170f, 0.00729075f, -0.00732464f, -0.00522008f, 0.00890562f, 0.01272569f, 
    0.00889579f, 0.00470502f, -0.01958185f, 0.00751487f, 0.00739117f, -0.01374150f, -0.03368256f, -0.03036533f, 
    0.02361024f, 0.01282321f, -0.00803599f, -0.01927975f, 0.00986141f, 0.00264629f, -0.01219294f, 0.02890289f, 
    -0.02158286f, 0.02481266f, 0.01615341f, -0.00853257f, -0.00732711f, -0.04165556f, -0.03333981f, -0.00927441f, 
    -0.01486406f, -0.02119763f, -0.00297413f, 0.00992963f, -0.03313880f, -0.03864957f, 0.01626095f, -0.02989509f, 
    0.00269891f, 0.01697826f, -0.01792511f, -0.02253538f, -0.01840947f, 0.02209888f, 0.02618231f, -0.02880483f, 
    -0.00962040f, -0.02277574f, 0.00375932f, 0.02579995f, -0.04109547f, -0.03796166f, -0.02420978f, 0.01562410f, 
    -0.02924307f, -0.03419882f, 0.00741152f, 0.02411590f, -0.03254830f, 0.00590094f, -0.00717858f, 0.01469783f, 
    0.00412801f, 0.02003917f, -0.04066594f, 0.02058601f, 0.03433259f, 0.02103054f, -0.01950943f, 0.02359932f, 
    0.01967652f, 0.01664133f, -0.02125211f, 0.02056133f, 0.01938511f, -0.00956068f, -0.01870666f, -0.03351412f, 
    -0.02418628f, -0.02819731f, -0.00269140f, -0.03755201f, 0.02016460f, 0.00900608f, -0.03156514f, 0.00048079f, 
    -0.03098406f, -0.00950394f, -0.01295146f, 0.01910343f, -0.02917985f, -0.03067981f, -0.00837334f, -0.02367094f, 
    -0.01672855f, -0.04202046f, -0.00021652f, -0.02651375f, -0.00542024f, -0.02925486f, -0.00772290f, -0.00747236f, 
    0.02495267f, 0.00417883f, 0.00767449f, 0.00541335f, 0.00739757f, -0.00637662f, -0.00184183f, 0.02522365f, 
    -0.02273876f, -0.03674316f, -0.00462693f, 0.00784151f, -0.01299431f, -0.02278380f, 0.02330707f, -0.01921149f, 
    -0.00837684f, -0.03029658f, -0.03606932f, 0.00952306f, 0.00245214f, -0.00018573f, -0.00588888f, 0.02654522f, 
    -0.01396820f, -0.00937071f, -0.01044133f, 0.00423378f, 0.01955787f, -0.01649303f, -0.03752771f, -0.00941519f, 
    -0.00004540f, -0.00202666f, -0.03363907f, 0.00367017f, 0.01297923f, 0.00495917f, -0.02468785f, -0.03529816f, 
    -0.02265470f, 0.01587025f, 0.01098818f, 0.00527811f, -0.04081992f, -0.01289515f, -0.03886479f, -0.00700902f, 
    -0.03986632f, 0.02236255f, 0.02396417f, -0.00583899f, 0.02780730f, -0.03061048f, -0.02871322f, -0.04168626f, 
    -0.02098330f, -0.03032335f, 0.01155230f, 0.01939860f, -0.02142932f, 0.02793093f, -0.01990655f, 0.00895756f, 
    -0.03821177f, -0.02988388f, 0.00769244f, -0.00978864f, -0.02255257f, 0.00192697f, -0.00408197f, 0.02322235f, 
    -0.02356689f, -0.03461797f, -0.02317845f, -0.00049703f, 0.02952662f, -0.02438970f, 0.02983918f, -0.03277903f, 
    0.00288387f, -0.01264733f, 0.00297303f, -0.00563666f, -0.01503563f, 0.01879389f, 0.00348578f, -0.00915923f, 
    -0.02810070f, 0.02532014f, 0.03000104f, 0.01033812f, 0.01426882f, 0.02181285f, -0.02075467f, -0.02004885f, 
    -0.02363615f, -0.00181005f, -0.03300262f, -0.01145896f, -0.02384857f, -0.02668438f, -0.00631917f, 0.01374580f, 
    0.00670107f, -0.03750257f, 0.00892264f, -0.01174196f, -0.00565371f, -0.02698213f, -0.02077323f, -0.02783493f, 
    0.03500619f, -0.00372293f, -0.00606215f, -0.03401629f, -0.01148647f, 0.02542410f, 0.00777516f, -0.03537886f, 
    -0.01450157f, -0.02011971f, 0.00690728f, -0.01473727f, 0.00051694f, 0.00285665f, -0.03467469f, -0.00764302f, 
    -0.00298920f, -0.02556745f, -0.02637675f, -0.01019971f, 0.02685560f, 0.02123885f, -0.01994061f, -0.02854941f, 
    -0.01194189f, 0.01706043f, -0.03642441f, 0.00562630f, 0.02727145f, -0.00607524f, 0.00188142f, -0.03694737f, 
    -0.03886802f, -0.02109185f, 0.00866484f, -0.00105237f, -0.01713381f, -0.03707820f, 0.02535753f, 0.01426411f, 
    -0.00365289f, 0.00712060f, 0.02603745f, 0.00856134f, 0.01248066f, 0.01147824f, 0.01273310f, -0.00246865f, 
    0.00338123f, 0.00006544f, 0.02851247f, -0.00655525f, 0.02540509f, -0.01438099f, -0.02313962f, 0.01555506f, 
    -0.01189410f, -0.00683159f, 0.02326121f, -0.01558663f, -0.00544516f, -0.01729400f, 0.00782974f, -0.03479602f, 
    -0.04173364f, 0.02179380f, 0.00518665f, 0.00673010f, 0.04013377f, -0.01364316f, -0.00800719f, 0.00668166f, 
    -0.00149775f, 0.00255132f, -0.01257528f, -0.01152450f, 0.01048242f, -0.02015314f, -0.03004120f, -0.02428181f, 
    -0.00373617f, -0.00647101f, -0.01482853f, -0.03642077f, -0.03923470f, -0.01773667f, 0.03343545f, -0.03164392f, 
    -0.02647041f, 0.02944241f, -0.01073758f, -0.04101158f, 0.02027277f, 0.00165339f, 0.01776055f, -0.02134832f, 
    -0.01429206f, -0.00114141f, 0.02351181f, -0.00679554f, -0.00017654f, -0.00704146f, 0.02518535f, 0.00005635f, 
    0.02528989f, -0.03000781f, -0.01807360f, -0.00303279f, 0.02424625f, -0.03243136f, 0.01537509f, -0.03319691f, 
    0.02430698f, -0.02891333f, 0.01676796f, -0.00976988f, 0.01579230f, 0.00529722f, -0.02265582f, -0.03146695f, 
    0.02837180f, 0.01964605f, -0.00495037f, -0.03359464f, 0.02283782f, -0.01583186f, -0.00464817f, -0.02880205f, 
    0.02808321f, -0.03540634f, -0.00716045f, 0.01403174f, -0.03822189f, 0.02483592f, -0.00426576f, -0.01931705f, 
    0.02600775f, -0.03002753f, -0.04011631f, -0.02595907f, 0.00841827f, 0.00585404f, 0.02407091f, -0.02833230f, 
    0.01505852f, -0.03696133f, -0.03454906f, 0.01198415f, 0.00674229f, -0.01629923f, -0.01079941f, -0.02603552f, 
    -0.01029034f, 0.00239691f, -0.03891437f, 0.02390696f, -0.03647528f, -0.01076735f, 0.00925091f, -0.01808831f, 
    0.02279978f, -0.02060391f, -0.01971642f, -0.03994199f, 0.01564360f, 0.01914741f, 0.01331675f, -0.00439579f, 
    -0.00832957f, -0.02057469f, 0.00769116f, 0.00982784f, -0.02400343f, 0.01745427f, -0.01098278f, -0.03473363f, 
    0.00818556f, 0.01263949f, -0.03274599f, 0.02755845f, -0.01270362f, -0.01406308f, -0.01917407f, -0.01464590f, 
    0.01098563f, 0.01452140f, -0.00402962f, -0.02668433f, 0.02973225f, 0.02040192f, -0.02570120f, -0.03986827f, 
    0.02553950f, -0.02265045f, -0.03661527f, -0.01149266f, 0.00935242f, 0.00019468f, -0.03726950f, -0.03076242f, 
    0.00531829f, -0.04114298f, -0.02143988f, -0.00582226f, -0.03241968f, 0.00573810f, -0.01353581f, 0.01662049f, 
    -0.04112624f, -0.03439120f, 0.01903867f, -0.02601753f, -0.00575716f, -0.01004122f, 0.02591518f, -0.03239024f, 
    -0.01759619f, -0.02240027f, 0.00631910f, -0.04130806f, 0.01728369f, 0.00722211f, 0.02632904f, -0.01265043f, 
    0.02965979f, -0.03549985f, -0.02143112f, 0.02155135f, 0.00757508f, 0.01137641f, 0.00156241f, -0.01204522f, 
    0.01901473f, 0.01560183f, 0.02483966f, -0.01468896f, -0.01794211f, -0.03851413f, 0.00537201f, 0.02288185f, 
    0.01427572f, -0.01090193f, -0.03020555f, 0.02234385f, -0.01640431f, -0.00912951f, 0.02615113f, 0.00174913f, 
    0.01152814f, -0.01517522f, 0.01999590f, 0.02481129f, 0.00803601f, -0.03200494f, -0.01177859f, -0.00349285f, 
    -0.04128933f, 0.00368312f, -0.01478390f, -0.01668559f, 0.01490227f, -0.00628339f, -0.00484308f, -0.00744179f, 
    0.01000116f, -0.02311483f, -0.00325512f, -0.01053937f, -0.04008747f, 0.00783763f, -0.03257779f, 0.01681608f, 
    0.01430667f, -0.03832655f, -0.03234486f, -0.02807211f, 0.00845433f, 0.02061000f, 0.01315719f, -0.00907733f, 
    0.01905732f, -0.02275565f, 0.00027502f, 0.02557433f, -0.03279512f, -0.00931979f, -0.02789330f, -0.03564468f, 
    -0.02167288f, -0.02243019f, 0.02474426f, 0.01437112f, 0.02215838f, 0.00892554f, -0.02573568f, -0.01784925f, 
    0.02102111f, 0.02963873f, -0.02814276f, -0.01345180f, 0.02149576f, 0.01392368f, -0.00767096f, 0.02548576f, 
    -0.00297136f, -0.03097030f, -0.03156482f, -0.02513508f, -0.00746835f, -0.01730103f, -0.03715363f, -0.02454523f, 
    -0.02698492f, -0.01536295f, 0.02384088f, 0.02675314f, -0.01519657f, -0.02891168f, 0.00351645f, -0.02410730f, 
    0.02877188f, 0.02788533f, 0.02815538f, -0.01346246f, -0.01235555f, -0.01585397f, -0.03862607f, 0.01054290f, 
    -0.03659222f, -0.03396294f, 0.02617644f, 0.00495546f, -0.03129250f, -0.01573866f, 0.01682052f, 0.01749492f, 
    -0.01513130f, -0.02096218f, 0.02021821f, -0.03210674f, -0.00241674f, -0.00553375f, 0.00617825f, -0.01489178f, 
    -0.01612720f, 0.02660322f, -0.01113874f, -0.01316714f, 0.01392453f, 0.02596414f, 0.00945289f, -0.02584872f, 
    0.02917526f, 0.02099043f, -0.02297470f, -0.02140687f, 0.02062993f, 0.00502330f, 0.01691384f, -0.00218314f, 
    0.02398331f, -0.01406130f, -0.01143772f, -0.03311351f, 0.00164314f, 0.00665129f, -0.01658351f, -0.02979438f, 
    -0.01560811f, -0.03133237f, -0.04130439f, -0.00526581f, -0.01374184f, 0.01673032f, -0.02024769f, 0.01845047f, 
    0.01003381f, 0.01201316f, -0.03077206f, -0.02573282f, 0.02118797f, 0.00346321f, -0.00192398f, -0.03929430f, 
    -0.00161344f, 0.00363782f, -0.01326120f, -0.03250882f, 0.00600693f, 0.01050639f, 0.00669632f, -0.02403292f, 
    0.01794247f, 0.02429691f, 0.01080197f, -0.02775859f, -0.02439288f, -0.01462498f, -0.01875899f, 0.02498730f, 
    -0.00535547f, -0.01172217f, -0.03049150f, -0.00438028f, -0.02358163f, -0.00719475f, 0.02016164f, -0.03587867f, 
    -0.01287287f, 0.02251463f, -0.00574228f, 0.04197162f, -0.00964405f, -0.03860065f, -0.03387006f, 0.01110408f, 
    -0.01170946f, 0.02797824f, -0.02191520f, 0.00270330f, -0.01662487f, 0.01376935f, -0.03810208f, 0.00896680f, 
    -0.00414448f, -0.03833790f, 0.02299941f, 0.02111675f, -0.01566049f, -0.01995291f, -0.01228607f, -0.02148502f, 
    0.00217553f, -0.02397045f, 0.01885757f, 0.02488570f, -0.01532406f, -0.03438340f, 0.00704482f, 0.02706601f, 
    0.01262328f, 0.01529476f, 0.01950642f, 0.01762557f, 0.02061608f, 0.02126516f, -0.03386546f, 0.01260775f, 
    0.02867996f, 0.00527909f, -0.02812789f, 0.02333932f, -0.03536335f, -0.00674439f, -0.02107088f, -0.03581155f, 
    0.00392764f, -0.01635325f, -0.02822661f, 0.02075541f, -0.01910494f, 0.00634089f, -0.01956024f, -0.00603792f, 
    0.22047612f, -0.03339305f, -0.04101669f, 0.19330671f, -0.01771815f, 0.02367149f, 0.07540594f, 0.08288903f, 
    0.01946336f, -0.03983040f, 0.01331572f, -0.02454289f, 0.12148079f, -0.15374681f, -0.01888478f, -0.07271655f, 
    0.03228566f, -0.07020728f, 0.03026948f, 0.02795175f, -0.01232569f, 0.02961400f, 0.16130330f, 0.01129658f, 
    0.08533476f, -0.20277454f, 0.02859223f, -0.04672882f, 0.05446433f, 0.02286871f, -0.04064105f, -0.01067883f, 
    -0.02892320f, -0.02861870f, 0.02277919f, 0.00262533f, -0.18727762f, 0.03937633f, -0.01507715f, -0.00764344f, 
    0.04299062f, 0.05867124f, -0.01915181f, 0.00911589f, 0.00920725f, 0.08621644f, 0.06477928f, -0.06854012f, 
    -0.20199905f, 0.13421597f, -0.01862804f, 0.15128729f, 0.06035508f, 0.01256060f, -0.03739444f, 0.14737348f, 
    0.00198969f, 0.07066728f, -0.11158404f, 0.00800443f, 0.08637960f, -0.03385856f, -0.12180074f, 0.00299353f, 
    -0.01638497f, -0.01023553f, 0.02879621f, 0.02282149f, 0.00996748f, 0.04992573f, -0.12030733f, -0.00090872f, 
    0.16822043f, -0.22556835f, 0.16947685f, -0.10575927f, -0.00997822f, -0.02534667f, 0.05581484f, 0.09344206f, 
    -0.12694567f, 0.06707796f, 0.00778151f, 0.02506352f, -0.21993908f, 0.22336555f, -0.18344031f, 0.07551870f, 
    0.06671239f, 0.03638206f, 0.07013119f, 0.06513054f, -0.05613188f, -0.04197714f, 0.12945707f, 0.06696151f, 
    0.18507360f, -0.23400895f, -0.02911547f, -0.12709486f, 0.01204712f, 0.00371500f, 0.17304517f, 0.04298934f, 
    0.12685777f, 0.02876672f, -0.10555764f, 0.00753424f, -0.05130130f, -0.03071512f, -0.22304323f, -0.01841086f, 
    -0.10431040f, 0.08690286f, 0.03506092f, 0.10226005f, -0.01144081f, 0.00691295f, -0.03013074f, 0.08040264f, 
    0.08598296f, -0.04637123f, -0.08573902f, 0.00372585f, 0.08837333f, -0.00149547f, -0.05300659f, -0.01613776f, 
    0.06355359f, -0.00810837f, 0.01155131f, 0.00925439f, 0.05398854f, -0.01107175f, 0.14624102f, 0.24355505f, 
    0.08540300f, -0.00888537f, 0.05717828f, 0.10062785f, 0.00251307f, 0.11981950f, -0.12117450f, -0.00762540f, 
    0.00598960f, -0.00215408f, 0.00501236f, -0.00427191f, -0.14523041f, 0.00294698f, 0.10157378f, 0.00682630f, 
    0.02364320f, 0.00474759f, -0.04210962f, -0.02396101f, 0.25289482f, -0.15793733f, 0.20280311f, 0.09597108f, 
    -0.05572875f, 0.02712247f, 0.03965582f, 0.06208434f, -0.09663123f, -0.02303177f, 0.01726678f, -0.02738500f, 
    -0.32874846f, 0.15614548f, 0.03092480f, 0.25537542f, 0.05301534f, 0.02766355f, -0.10558223f, 0.02256296f, 
    -0.08267178f, 0.00871197f, 0.05530739f, 0.03188554f, -0.09831533f, 0.01783417f, -0.07550090f, -0.20577647f, 
    0.03063980f, 0.01343726f, -0.06408858f, 0.07056287f, 0.10738654f, 0.00501667f, 0.01524718f, -0.06990361f, 
    0.02478544f, -0.08852139f, 0.17505971f, 0.02473742f, -0.06561308f, 0.00735115f, -0.02773235f, 0.07661892f, 
    0.01083971f, 0.02505623f, 0.00817603f, 0.02563618f, 0.20676635f, -0.08739140f, -0.07346105f, 0.02592309f, 
    0.01647747f, 0.01323285f, 0.09230678f, 0.00596497f, 0.12788159f, -0.01113446f, 0.02392153f, 0.11063347f, 
    0.00530038f, -0.02491820f, -0.01680331f, 0.19839990f, -0.02418465f, -0.08202556f, 0.06164013f, 0.11350155f, 
    0.13365743f, 0.10148882f, -0.14940654f, 0.15241249f, -0.06486917f, 0.20144783f, 0.19739899f, -0.06142084f, 
    -0.00391045f, 0.08960458f, 0.04109891f, 0.08675750f, 0.18916042f, 0.04435735f, -0.01081133f, -0.01296650f, 
    -0.26802787f, 0.10872769f, 0.15480870f, -0.06565418f, -0.04482589f, 0.01054741f, 0.09137069f, 0.09463491f, 
    -0.03617867f, 0.06306803f, -0.02924033f, 0.04308438f, 0.10777128f, -0.01747105f, 0.07484648f, 0.25938597f, 
    0.06400229f, -0.00770657f, 0.05942612f, -0.01506979f, 0.00511337f, -0.00409272f, -0.03078868f, 0.09141009f, 
    0.04033940f, 0.04047559f, -0.01123863f, -0.11407138f, -0.08091476f, 0.02010554f, 0.03172596f, 0.00821710f, 
    0.00679532f, -0.05779595f, 0.03516584f, -0.02045667f, 0.03858516f, -0.02774633f, -0.01408011f, -0.06965391f, 
    0.03552177f, 0.06115959f, 0.01984683f, 0.01201401f, -0.00243047f, -0.02156623f, 0.08190408f, 0.05243176f, 
    0.16758126f, 0.07625228f, -0.07313444f, 0.16004072f, 0.06437075f, -0.07377613f, -0.01233604f, -0.01598526f, 
    -0.03507203f, -0.01664473f, 0.07339268f, -0.03005465f, 0.34800678f, 0.12593983f, -0.11732270f, 0.00975154f, 
    0.05497644f, -0.02033776f, 0.02372457f, 0.06953094f, 0.05088115f, 0.14094859f, 0.03489003f, -0.03991478f, 
    -0.29052311f, 0.27227515f, -0.05272995f, -0.20824067f, 0.04627058f, 0.11852829f, -0.05388021f, 0.09564106f, 
    -0.01679387f, -0.02333932f, 0.00895065f, -0.04844788f, -0.29489622f, 0.21246012f, -0.07033271f, 0.21158209f, 
    -0.09200077f, -0.00123461f, -0.10043303f, 0.07277650f, 0.01253322f, -0.01954985f, -0.14840630f, 0.08842488f, 
    -0.05100621f, -0.07977555f, -0.10647732f, -0.02523155f, -0.08805156f, 0.05764117f, 0.05322735f, 0.10624980f, 
    0.06429468f, -0.01928586f, -0.00408345f, 0.07432570f, 0.17759070f, -0.09424108f, -0.03979858f, 0.09150768f, 
    -0.07338457f, -0.00263780f, -0.00009167f, 0.05054837f, 0.14422163f, -0.13705254f, 0.03576729f, 0.00946682f, 
    0.06999377f, -0.09532299f, 0.06866360f, -0.06262670f, 0.01014874f, -0.00635118f, -0.02013137f, 0.01020817f, 
    0.02499767f, 0.01060298f, -0.04161477f, 0.10715528f, 0.27327362f, 0.10249422f, -0.22814584f, -0.00936938f, 
    0.01521189f, -0.03636681f, -0.03629787f, -0.01542866f, 0.03313692f, 0.01989256f, -0.02851601f, -0.01703933f, 
    0.14882529f, -0.10484844f, 0.09459984f, 0.02089722f, 0.09273258f, -0.00536775f, 0.01482758f, 0.01740680f, 
    -0.02996084f, -0.03754368f, 0.06194561f, 0.11913741f, -0.44562280f, -0.05125318f, 0.20804247f, -0.06745698f, 
    -0.00438316f, 0.09073615f, 0.04751949f, -0.00538932f, 0.07136385f, 0.15858293f, -0.05267860f, 0.09115855f, 
    -0.13681568f, 0.11672246f, -0.03850302f, 0.02461274f, 0.06610774f, 0.08991150f, 0.00528193f, 0.02243195f, 
    0.04195046f, -0.09894654f, 0.00930096f, 0.03822161f, -0.27000171f, -0.01739970f, 0.13234916f, -0.13509989f, 
    0.09311832f, 0.02389513f, -0.03240742f, 0.00219109f, 0.05336045f, -0.04689638f, 0.04517140f, 0.02180476f, 
    -0.20949878f, 0.04455420f, 0.11643200f, 0.23733732f, 0.12948288f, 0.03497546f, -0.00462786f, 0.09085647f, 
    0.01408632f, 0.03106883f, 0.06550306f, -0.01557770f, 0.13806389f, 0.13554606f, -0.07065143f, -0.04202600f, 
    0.12638797f, 0.00583212f, -0.03752645f, 0.05657387f, 0.05995901f, 0.18508421f, -0.00338041f, -0.09460565f, 
    0.04719320f, -0.07517538f, -0.24194950f, -0.03451012f, -0.03675403f, -0.02397502f, 0.03096314f, 0.07003903f, 
    0.03485794f, 0.05737398f, -0.03210988f, -0.01737133f, 0.21950424f, -0.15767516f, -0.10357313f, 0.19259472f, 
    -0.04331988f, 0.00714206f, -0.00448342f, 0.08068477f, 0.06235265f, -0.01649570f, -0.06491669f, 0.14468724f, 
    -0.40072975f, 0.18642610f, -0.12493484f, 0.22507171f, -0.00168493f, 0.02634251f, -0.06785088f, -0.04690795f, 
    0.05833714f, 0.01279392f, 0.11320637f, 0.00998560f, 0.25438279f, -0.03750300f, -0.04247807f, -0.11473488f, 
    -0.00061748f, -0.05667694f, 0.09469429f, 0.09742599f, 0.01491957f, 0.01131731f, -0.07192298f, 0.02646222f, 
    0.12005377f, -0.23648247f, 0.02361702f, 0.04577195f, 0.08709774f, 0.03933873f, 0.02225116f, 0.13539356f, 
    -0.00523269f, 0.08042888f, -0.00907157f, -0.03320566f, -0.31894702f, 0.03568172f, 0.14537962f, -0.03125854f, 
    0.04872774f, 0.04168522f, -0.00229012f, -0.01296348f, 0.06092519f, 0.03723286f, -0.05309650f, 0.01147359f, 
    0.23572102f, -0.05189792f, -0.15800436f, 0.07292388f, 0.03872950f, -0.03365358f, 0.02120896f, 0.08819078f, 
    -0.03800946f, 0.06317748f, -0.07242175f, 0.06890317f, 0.03206582f, -0.06642564f, -0.17197542f, 0.02708318f, 
    0.02567152f, 0.08652229f, 0.06329442f, -0.02038187f, 0.07119519f, 0.02204258f, 0.07640165f, 0.10494257f, 
    0.06503201f, -0.07060941f, 0.04604196f, -0.00611268f, -0.11980654f, -0.00333217f, 0.05118805f, 0.04928081f, 
    0.05975766f, 0.01414751f, -0.04541719f, -0.04518315f, 0.00328022f, -0.10146715f, 0.01445292f, -0.10641529f, 
    0.08962692f, -0.00566362f, -0.03843568f, -0.04476936f, -0.07020434f, -0.01362728f, -0.05896509f, 0.08351195f, 
    -0.23750778f, 0.26465818f, -0.10442762f, 0.02896935f, 0.06718089f, 0.03164572f, 0.10444618f, -0.01614863f, 
    -0.07532808f, -0.05685993f, 0.01160365f, 0.06914251f, -0.20787473f, -0.07023878f, 0.13131550f, 0.04281967f, 
    -0.02731568f, -0.05453753f, 0.00582614f, 0.06783614f, 0.09330738f, 0.02388443f, -0.00756015f, 0.00425560f, 
    0.36626518f, -0.10254113f, -0.05175798f, 0.03164475f, -0.00188477f, -0.05894708f, 0.04950646f, 0.07072569f, 
    0.00424019f, 0.09396396f, -0.00213640f, 0.01485926f, 0.17882644f, -0.05930185f, -0.15023799f, 0.00349018f, 
    -0.03177310f, 0.03276163f, 0.02450080f, 0.13230312f, 0.04941987f, -0.06581053f, 0.04313045f, 0.09393560f, 
    0.27597630f, 0.16298747f, 0.13050631f, 0.14531268f, -0.06264696f, -0.05421196f, 0.08508358f, 0.03800913f, 
    0.07835424f, 0.06193645f, -0.03314345f, 0.08189108f, 0.26235098f, -0.14762819f, 0.07623175f, 0.12474985f, 
    0.02780817f, 0.03238612f, 0.07434940f, -0.02394204f, 0.03354450f, -0.00752724f, -0.01532353f, -0.08305477f, 
    0.06576204f, -0.07645365f, 0.00315564f, -0.04554438f, -0.03513326f, -0.01215087f, -0.01327044f, -0.01335042f, 
    0.00015663f, 0.04624951f, 0.07604562f, -0.03880667f, -0.01734680f, 0.12771258f, 0.00219816f, -0.17084125f, 
    0.03319297f, -0.12489992f, -0.04823906f, 0.03964750f, -0.03989376f, -0.04964764f, -0.02494647f, -0.08855920f, 
    -0.38056833f, 0.14598870f, 0.00326601f, 0.20685364f, -0.01257006f, -0.01825869f, 0.03526200f, 0.06251650f, 
    -0.07973687f, 0.05069965f, 0.08395595f, -0.03410859f, 0.18107848f, -0.05534939f, -0.04394596f, 0.00691822f, 
    -0.04243536f, -0.01624331f, 0.07343218f, 0.02326087f, 0.05305604f, -0.03806588f, -0.02753917f, 0.03463884f, 
    0.36427400f, -0.13773707f, 0.05227324f, -0.06166919f, -0.00510672f, -0.01221998f, 0.03862403f, 0.04044749f, 
    0.00617932f, 0.00163525f, -0.00724422f, -0.06201255f, -0.25118762f, -0.05862744f, 0.01031416f, -0.13537623f, 
    -0.00097135f, 0.07830141f, 0.00915242f, 0.13764210f, -0.01684038f, 0.09836131f, 0.02755528f, -0.02023899f, 
    -0.02149696f, -0.01011576f, -0.06853088f, 0.11605508f, 0.10217611f, 0.04642988f, 0.03951949f, -0.03344787f, 
    -0.02713017f, 0.09183044f, 0.03443961f, 0.09860265f, 0.16294514f, 0.03589867f, -0.09037881f, 0.10636146f, 
    0.06241056f, 0.03493008f, 0.04791440f, 0.03940538f, -0.00214138f, -0.02770624f, 0.08514634f, -0.07493610f, 
    -0.23793750f, 0.12055323f, -0.09249837f, -0.13450249f, 0.12314456f, 0.04464359f, 0.02248546f, 0.13233718f, 
    0.04799183f, 0.07040016f, -0.00900228f, 0.00089928f, -0.05908056f, 0.12140842f, -0.11525170f, 0.12982452f, 
    0.04779319f, -0.09611210f, 0.00121938f, 0.16242713f, -0.04495174f, -0.01450075f, 0.02044939f, -0.13118097f, 
    0.01456833f, -0.01705622f, 0.01150392f, -0.33221000f, 0.01848085f, 0.00039716f, 0.03382941f, -0.05425893f, 
    -0.00298958f, 0.01692707f, -0.00295335f, -0.03385398f, 0.02414073f, 0.19369675f, -0.01584155f, 0.12248401f, 
    -0.06158284f, 0.04057757f, 0.03629057f, 0.03515631f, 0.03123903f, 0.01155506f, 0.06477132f, 0.00414526f, 
    0.31125006f, -0.01053369f, 0.11540458f, -0.00505683f, -0.05695499f, 0.04166671f, 0.04986249f, 0.06866033f, 
    -0.15476261f, -0.01606840f, -0.03116735f, 0.06717461f, 0.10005774f, -0.02162061f, 0.13811037f, 0.12635177f, 
    -0.01833325f, -0.04412678f, 0.00693969f, -0.00004838f, -0.00866847f, -0.03226314f, -0.00074349f, 0.01541396f, 
    -0.21568547f, 0.20025122f, -0.06361257f, 0.16517374f, 0.07172873f, 0.07990032f, 0.00679566f, -0.02806378f, 
    -0.01534136f, 0.04860772f, -0.10245312f, 0.01165067f, 0.24766599f, 0.05930965f, -0.02949760f, 0.07127678f, 
    0.11845569f, 0.08241253f, 0.06249312f, -0.03547653f, -0.01287396f, -0.01496044f, 0.06633668f, -0.05830268f, 
    0.18285972f, -0.12429413f, -0.28710616f, -0.12775888f, 0.02719457f, 0.00267285f, 0.03835619f, 0.03251190f, 
    -0.01509427f, 0.07404216f, -0.05870134f, -0.04865088f, 0.23361747f, -0.17193195f, -0.01184646f, 0.04515080f, 
    -0.06898035f, 0.06393322f, 0.10622391f, 0.14409155f, -0.04874744f, 0.04770432f, -0.03535274f, 0.00261174f, 
    0.08339377f, 0.23228896f, -0.10160825f, 0.09276595f, 0.08071319f, -0.05374536f, 0.01936059f, -0.07385284f, 
    -0.00523072f, 0.03021184f, 0.08070345f, -0.13581125f, 0.18541798f, 0.10805240f, -0.01573952f, 0.21000223f, 
    0.02196158f, -0.01927694f, 0.01220344f, 0.05549210f, 0.06850324f, 0.09727795f, 0.02005133f, -0.01035913f, 
    0.01685161f, -0.25766179f, 0.04920518f, 0.15368639f, 0.01482391f, 0.02878275f, 0.04182227f, 0.10529537f, 
    -0.07860211f, 0.09714351f, 0.03234931f, 0.11622716f, -0.06363101f, -0.01693332f, -0.07529269f, -0.13125516f, 
    0.12539461f, -0.04914171f, 0.00462608f, 0.12590876f, 0.17791276f, 0.06258781f, 0.03252489f, 0.04724449f, 
    0.07178558f, 0.17017464f, 0.08301496f, 0.02623056f, 0.08177512f, -0.03289723f, -0.03321818f, 0.00192539f, 
    0.12699564f, -0.04008709f, -0.02646943f, 0.07149953f, -0.01888024f, 0.04289505f, 0.19282916f, 0.04854360f, 
    -0.04741780f, 0.01714037f, 0.08755416f, 0.02930541f, 0.16321239f, 0.00498030f, -0.01098570f, 0.10832877f, 
    -0.12016264f, -0.16814093f, 0.03632459f, 0.04008247f, 0.10796521f, 0.02329560f, 0.11813682f, -0.03761297f, 
    0.05647630f, 0.04705735f, -0.05267468f, 0.10381001f, 0.31592584f, 0.12545547f, 0.06953834f, 0.11515784f, 
    -0.11193080f, 0.04101906f, -0.03289296f, -0.01604072f, -0.01924855f, 0.04240066f, -0.03064937f, 0.09598348f, 
    0.03206888f, 0.02333958f, 0.00369821f, -0.06221709f, 0.00831690f, -0.01524303f, -0.02523320f, -0.07037579f, 
    0.03788076f, 0.02260884f, 0.01983076f, -0.06216080f, -0.01327201f, -0.06854211f, 0.10141300f, 0.18825819f, 
    0.02076310f, -0.06290548f, -0.10164801f, 0.08517835f, 0.01995790f, 0.07165292f, 0.01100287f, 0.04478230f, 
    -0.08799536f, 0.02170910f, 0.14000069f, 0.07473253f, 0.04936715f, -0.01573448f, -0.18499219f, 0.03541506f, 
    0.14156215f, -0.11815421f, 0.00296550f, 0.00308523f, -0.14519921f, 0.19827920f, -0.24933606f, -0.19463275f, 
    0.01620002f, 0.03918880f, 0.03385730f, 0.05269515f, -0.04348767f, -0.12655242f, 0.03030630f, -0.06631914f, 
    -0.19907454f, 0.04375640f, -0.06644824f, 0.11186359f, 0.00700505f, 0.16502824f, -0.09587134f, -0.16679449f, 
    0.10539632f, -0.08251477f, -0.00086894f, -0.04070215f, -0.02226813f, -0.13110135f, 0.09889251f, -0.00145839f, 
    0.02375138f, 0.04574265f, -0.01322323f, -0.04244402f, 0.07376250f, -0.01750743f, 0.12831324f, -0.01490134f, 
    0.40574551f, -0.03024701f, -0.02163338f, 0.30573058f, -0.03406963f, -0.02447236f, 0.00007089f, 0.03851076f, 
    0.03117876f, 0.08288668f, 0.14472327f, 0.00358974f, -0.35827082f, -0.11154020f, 0.00272176f, 0.08538558f, 
    -0.02677285f, 0.04719846f, -0.07871477f, -0.00815586f, 0.09529734f, 0.09224148f, 0.05557756f, -0.04155864f, 
    -0.19731441f, -0.04757627f, -0.01176944f, -0.19953735f, -0.04270675f, 0.10357765f, 0.06163355f, -0.04660725f, 
    -0.03151582f, -0.09322336f, -0.07616218f, 0.08851160f, 0.12351793f, -0.22525580f, -0.14233698f, -0.04376482f, 
    -0.02003314f, 0.05160897f, 0.02510895f, 0.19127591f, 0.02287392f, -0.03114733f, -0.02182272f, -0.07897561f, 
    0.31872070f, 0.24808501f, -0.08359725f, 0.11116129f, -0.11613094f, 0.05157864f, 0.04953941f, -0.08984001f, 
    -0.00280590f, 0.04677008f, -0.10528868f, 0.03877924f, 0.01554493f, -0.13319020f, -0.09076935f, 0.15652795f, 
    0.10507312f, 0.02232072f, 0.10620096f, -0.02105786f, 0.10108712f, -0.03334255f, 0.00167454f, -0.05178218f, 
    0.12362805f, 0.25497481f, 0.05376402f, 0.13083796f, 0.07231929f, -0.06045810f, -0.02247495f, -0.00423313f, 
    0.03663705f, 0.04349395f, 0.03863438f, 0.02858151f, 0.08659418f, -0.04151225f, 0.12575068f, 0.02492272f, 
    -0.01898265f, 0.05700191f, 0.03513056f, 0.05499131f, 0.01024871f, 0.04400351f, -0.07471655f, 0.05697676f, 
    -0.04187988f, 0.08674683f, -0.17152399f, 0.01537424f, 0.05034612f, -0.04584912f, -0.01207984f, 0.12071477f, 
    0.01897681f, 0.06820744f, -0.02513039f, -0.08209637f, -0.14076696f, 0.00910028f, 0.03108191f, -0.02062177f, 
    -0.14698857f, -0.05841004f, -0.00035153f, 0.13272569f, 0.12356356f, -0.02852501f, 0.05221631f, 0.00166776f, 
    -0.00267013f, -0.14768912f, 0.06900893f, 0.16697842f, -0.04204471f, -0.05168319f, -0.01154071f, 0.02361465f, 
    -0.10538538f, 0.03299036f, -0.01770859f, -0.01172510f, 0.19261214f, 0.07418290f, -0.04902557f, 0.00058156f, 
    -0.04805766f, 0.04167505f, 0.07754920f, -0.00683924f, -0.04099872f, -0.05788507f, -0.00660070f, -0.03546248f, 
    -0.14589246f, 0.19787845f, 0.15146495f, 0.22723520f, 0.00158900f, 0.05813127f, -0.02352720f, 0.03941338f, 
    -0.03720012f, -0.07197188f, 0.09082060f, 0.00794316f, -0.09977245f, 0.16889884f, 0.02087341f, 0.10531285f, 
    0.01345550f, -0.02213385f, 0.02456304f, 0.01962405f, -0.03542346f, 0.04549605f, 0.06685954f, 0.07634145f, 
    -0.01426562f, 0.12893063f, -0.00077180f, 0.00459816f, 0.04541028f, 0.04380881f, -0.11417850f, 0.08881495f, 
    0.00339521f, 0.03819159f, -0.00010547f, 0.09416524f, -0.50500900f, -0.13222314f, 0.04919660f, 0.10177836f, 
    -0.00133807f, 0.06373891f, -0.04111234f, 0.02763263f, 0.09355588f, 0.09535550f, -0.07136145f, -0.04536161f, 
    0.21265492f, -0.04415865f, 0.15185018f, 0.02771375f, -0.03288396f, 0.02344798f, 0.03501031f, 0.01595733f, 
    -0.11678167f, -0.04574070f, -0.06792948f, 0.02220721f, 0.25375971f, -0.04405989f, 0.14042532f, 0.21396033f, 
    0.01378939f, -0.05933677f, 0.01186258f, 0.11730779f, 0.07715066f, 0.08195487f, -0.04345869f, 0.12714165f, 
    -0.08184194f, -0.21738198f, 0.03717624f, 0.13769379f, -0.00834045f, 0.05255534f, -0.01613107f, 0.08764386f, 
    0.09971991f, 0.10382058f, -0.08357916f, 0.04612679f, 0.07515205f, 0.40003133f, 0.00500562f, 0.09456669f, 
    -0.02047863f, -0.10127907f, 0.01240663f, 0.02457390f, 0.10760355f, 0.15515795f, 0.07261717f, -0.01468211f, 
    0.01471764f, -0.02193179f, -0.06127913f, 0.02800771f, -0.01642114f, -0.03872027f, 0.08151238f, 0.02846958f, 
    0.11022465f, 0.03699135f, 0.09233403f, -0.02407910f, 0.02646615f, -0.08180440f, 0.04462637f, -0.16810296f, 
    -0.04633673f, -0.08553889f, 0.00847647f, -0.00356468f, 0.05795375f, 0.01146287f, 0.04657804f, -0.03119547f, 
    0.09105100f, -0.37587181f, 0.08424485f, 0.14271693f, 0.00271852f, -0.01094520f, 0.07301757f, -0.02184473f, 
    0.02921023f, 0.00482212f, 0.09958115f, -0.03392825f, 0.18563829f, -0.23598427f, -0.00964485f, -0.17872970f, 
    0.00493773f, -0.10778906f, -0.02128199f, 0.02154767f, 0.07063263f, -0.01176261f, -0.09471762f, -0.05015981f, 
    0.35594022f, -0.11034784f, 0.07357503f, 0.31747842f, -0.07179254f, -0.11734788f, -0.02290737f, 0.08321471f, 
    0.05671658f, 0.05672807f, 0.17924330f, -0.02312504f, 0.26663494f, -0.23797065f, 0.00261256f, 0.07603543f, 
    -0.16242677f, 0.00491927f, -0.03031090f, 0.12273727f, 0.03446116f, -0.01253554f, -0.03175433f, -0.10857134f, 
    0.03471172f, -0.09969091f, 0.01816767f, -0.02711353f, -0.07205541f, 0.04090283f, -0.00064697f, 0.03026071f, 
    -0.01400952f, 0.00926315f, 0.06758177f, -0.13067220f, 0.03830881f, 0.08366367f, -0.03354472f, 0.16880989f, 
    0.01405791f, 0.02958527f, 0.06405591f, -0.01030892f, 0.00832690f, -0.02481099f, 0.06696365f, 0.03262038f, 
    -0.10174368f, 0.30014360f, -0.12158500f, -0.14847696f, 0.06070188f, 0.05704737f, 0.13532014f, -0.02385536f, 
    0.14714652f, 0.00523887f, 0.01050807f, 0.03799142f, -0.00123834f, -0.16990958f, 0.11121845f, 0.07107248f, 
    -0.14075541f, 0.01193742f, 0.05711465f, 0.03040433f, 0.05939513f, 0.05834637f, -0.00387816f, -0.03372355f, 
    -0.29937220f, 0.06022067f, -0.00211820f, -0.15309629f, -0.12230059f, -0.04547103f, 0.02872920f, -0.00284141f, 
    0.03964525f, 0.14403515f, 0.06175070f, -0.05311166f, 0.01180141f, 0.19079979f, -0.13627121f, -0.00049315f, 
    -0.05185046f, -0.01695316f, 0.01491765f, -0.11032391f, 0.03054929f, 0.09692241f, 0.02778075f, -0.06365801f, 
    0.17143361f, 0.00512079f, 0.12791866f, 0.03434034f, -0.03535228f, -0.13751993f, 0.01549759f, -0.10614049f, 
    0.01461823f, -0.09394122f, 0.07195465f, 0.03485162f, -0.18794023f, 0.14707635f, 0.03032252f, -0.03909381f, 
    -0.02852228f, -0.00664831f, 0.02552216f, -0.07803176f, 0.02430350f, -0.14419909f, 0.08306521f, 0.09906900f, 
    0.24700294f, 0.05549889f, 0.01760296f, 0.03545368f, 0.01300947f, 0.02958926f, 0.02726507f, 0.04409117f, 
    0.14852287f, -0.00918389f, 0.01037709f, -0.02415012f, 0.16256288f, 0.14474994f, 0.04783321f, 0.22763652f, 
    0.07808076f, 0.00951664f, 0.07990333f, 0.03956955f, 0.07464030f, 0.09772564f, 0.05557293f, -0.02868929f, 
    -0.08484940f, 0.12602855f, -0.06118752f, -0.20499374f, -0.02951509f, 0.02196245f, 0.19546971f, -0.00071082f, 
    -0.10067988f, 0.11547384f, 0.07536067f, 0.04656679f, -0.01674927f, 0.33253443f, -0.02599077f, 0.06585908f, 
    -0.05392448f, -0.02705165f, -0.02850292f, 0.00253559f, -0.10329194f, -0.03946823f, 0.07008970f, 0.01033485f, 
    0.48895556f, -0.17909223f, 0.07667459f, 0.06741881f, -0.19145362f, 0.05200876f, -0.04912622f, 0.04535938f, 
    0.08067815f, -0.00050619f, 0.03017999f, 0.06357395f, -0.03361771f, -0.02867781f, -0.03705489f, -0.19545317f, 
    0.17556499f, 0.06632125f, -0.04200701f, 0.03927916f, 0.04592464f, -0.03817597f, 0.00011458f, -0.06062428f, 
    0.14462037f, 0.16557735f, 0.08521508f, 0.16989601f, 0.02788584f, 0.03238470f, -0.03785545f, 0.10414204f, 
    0.04723027f, 0.08470174f, -0.02847366f, -0.01650968f, 0.07995389f, 0.19731054f, 0.07772391f, -0.23815894f, 
    0.01934565f, 0.03012125f, 0.09273863f, -0.07314023f, 0.01617301f, -0.14428326f, 0.16840431f, 0.04664360f, 
    -0.03592242f, -0.01304271f, 0.01983491f, 0.02230483f, 0.03072324f, -0.00521490f, -0.03098661f, -0.08044334f, 
    -0.09800418f, 0.06595126f, -0.00081177f, 0.01185082f, -0.12256011f, 0.13348170f, 0.07813203f, -0.11943041f, 
    0.02248696f, 0.00182976f, -0.04625187f, 0.02708255f, 0.11660457f, -0.01933769f, -0.09921523f, 0.03156895f, 
    -0.04577862f, 0.08271673f, 0.04911895f, -0.09635556f, 0.08962658f, 0.01786671f, 0.08198634f, 0.02032010f, 
    0.15072706f, 0.06279264f, 0.04245380f, -0.09240137f, 0.01950666f, -0.00292441f, 0.03539272f, -0.11614371f, 
    0.03718591f, 0.08619064f, 0.08813348f, 0.06076128f, 0.00094701f, 0.07657647f, 0.13406928f, 0.01256808f, 
    0.23108722f, -0.02612193f, -0.09991646f, -0.00849273f, -0.00386310f, 0.12456852f, -0.04499460f, 0.06334912f, 
    -0.00082534f, -0.06911572f, 0.13325508f, -0.07668439f, 0.11324570f, 0.09018019f, 0.08247061f, -0.11593139f, 
    -0.09472982f, 0.03776801f, 0.04513771f, -0.01465961f, -0.06437483f, -0.16818275f, -0.02554547f, 0.13977823f, 
    -0.36790225f, 0.10961053f, 0.04529269f, 0.31310615f, 0.00623519f, 0.09849374f, -0.01381482f, -0.08180467f, 
    -0.02836355f, -0.10473687f, -0.00782909f, 0.09752867f, 0.14474702f, -0.21918646f, 0.23954444f, -0.04881059f, 
    0.05062242f, -0.01884064f, -0.02466544f, -0.03211556f, 0.00326552f, -0.01985100f, 0.08368716f, 0.10991450f, 
    -0.16124624f, -0.03294492f, 0.00145206f, 0.06334651f, 0.00788000f, -0.06193187f, 0.00774724f, 0.01119499f, 
    0.01340698f, 0.09076906f, -0.00965688f, 0.00342438f, -0.25803661f, -0.04786868f, -0.01110056f, -0.15703133f, 
    0.03766759f, 0.04969621f, -0.01787075f, 0.00836954f, 0.07563164f, 0.04351879f, -0.02661724f, 0.00764311f, 
    -0.04214770f, 0.03388158f, -0.04439664f, -0.07967988f, -0.01729037f, 0.05095736f, -0.02074361f, 0.08200057f, 
    0.08106822f, -0.05463286f, 0.01667169f, -0.00951036f, 0.17883904f, -0.12596449f, 0.06473169f, 0.03631528f, 
    -0.03808590f, 0.08076123f, -0.13332704f, 0.12823486f, -0.00813476f, -0.07071847f, 0.13550305f, 0.01376308f, 
    0.05040527f, -0.05649874f, 0.06248304f, 0.01265738f, 0.03059447f, -0.02591133f, 0.08973299f, 0.03524063f, 
    -0.00834981f, 0.15413807f, -0.02966654f, 0.06408084f, -0.07599211f, 0.06594859f, -0.16749069f, -0.28494099f, 
    0.07938734f, -0.09602745f, -0.03794973f, -0.02771338f, -0.01654127f, 0.01968078f, 0.10605035f, -0.01426456f, 
    0.35099337f, 0.10737967f, -0.12512685f, -0.02344195f, 0.02535683f, 0.08681180f, 0.06026355f, 0.06675727f, 
    0.13175167f, 0.05472773f, -0.01722649f, -0.05989628f, 0.27247024f, 0.13455699f, 0.01907258f, 0.05220428f, 
    -0.02607475f, 0.03978376f, 0.02339649f, 0.03043659f, -0.11497994f, 0.07672477f, -0.02943062f, -0.01357536f, 
    -0.22490487f, -0.04313022f, -0.04265112f, -0.05032217f, -0.03510338f, -0.02296887f, 0.02368268f, 0.10750268f, 
    0.09135859f, -0.05093809f, -0.03359649f, 0.07136891f, -0.37671095f, 0.17880797f, 0.04065221f, -0.17128643f, 
    0.05164494f, -0.00053585f, -0.06312457f, -0.01237731f, -0.05018049f, -0.07465753f, 0.00439779f, 0.00879011f, 
    0.08676736f, 0.03633774f, -0.00347112f, -0.05340054f, 0.09094518f, 0.03708294f, -0.00462695f, -0.00334961f, 
    0.01399126f, -0.04440740f, 0.08501282f, 0.05335690f, 0.11562039f, -0.12497944f, 0.13449554f, 0.20103033f, 
    0.05741368f, 0.03337650f, 0.08125385f, -0.09572370f, -0.07147984f, -0.05966032f, 0.00144000f, -0.04871765f, 
    0.34434894f, -0.10034272f, 0.05146825f, 0.08246140f, 0.03880178f, 0.01379943f, -0.03981653f, 0.06597404f, 
    -0.03192284f, -0.10826913f, 0.00814874f, -0.00799819f, 0.17185692f, 0.14576778f, 0.06434052f, -0.03364789f, 
    0.12078334f, 0.04634816f, 0.03653185f, 0.05720605f, -0.06128980f, 0.10137144f, -0.12928899f, -0.06936697f, 
    -0.35004476f, 0.18825637f, 0.04868406f, -0.34560800f, 0.06102443f, -0.02842059f, -0.05514460f, 0.01194378f, 
    -0.00790162f, 0.02544865f, -0.02153673f, 0.13732652f, 0.23924132f, -0.10219678f, -0.02312860f, -0.12152970f, 
    0.01527351f, -0.00723895f, 0.10627598f, 0.18554443f, 0.17990910f, 0.00952436f, -0.10208318f, 0.03116448f, 
    0.21270521f, 0.21334508f, 0.06137444f, 0.02186516f, 0.05808114f, 0.04897485f, 0.01837824f, 0.11556844f, 
    0.06898785f, 0.08932204f, 0.05695577f, -0.01422543f, -0.32992470f, 0.16484880f, 0.11280680f, 0.13195466f, 
    -0.05267676f, 0.01233795f, 0.06880272f, 0.11812248f, 0.15694532f, -0.06322540f, -0.07761898f, 0.08596184f, 
    0.03207183f, -0.14508022f, 0.01321624f, 0.10023657f, -0.07541352f, 0.04607870f, -0.03720703f, 0.01381243f, 
    0.05491235f, 0.03702530f, 0.11776360f, 0.20584640f, 0.46011207f, -0.01920461f, 0.03636913f, -0.07453746f, 
    0.14088145f, 0.03102988f, -0.01301545f, 0.07751148f, -0.03686607f, 0.11313709f, 0.21069354f, -0.09727784f, 
    -0.22447388f, -0.01473839f, 0.01910317f, -0.21074891f, -0.02728166f, 0.00934225f, -0.00623018f, 0.00977933f, 
    0.01376432f, -0.08213883f, 0.00219149f, 0.00875636f, -0.27748123f, 0.02923997f, -0.02804647f, -0.17419952f, 
    0.03761517f, 0.06785864f, 0.04416088f, 0.04318807f, 0.00660505f, -0.02019823f, 0.03242704f, -0.01838033f, 
    -0.24616568f, 0.06534074f, 0.21039151f, 0.14334361f, -0.02797201f, 0.03036392f, -0.01644084f, -0.00691736f, 
    0.06384316f, 0.02319794f, -0.00041720f, 0.00609394f, 0.04486451f, 0.18054220f, 0.01605681f, 0.10123138f, 
    -0.06284891f, 0.06574579f, 0.01271808f, -0.14849156f, -0.07773260f, 0.07142072f, 0.13580339f, -0.00284785f, 
    -0.10053314f, 0.07569402f, -0.01155958f, -0.12747207f, -0.01480774f, 0.13709478f, 0.01628474f, 0.06270339f, 
    0.00552644f, -0.04525154f, 0.01554830f, 0.01827557f, 0.47261652f, 0.04730470f, -0.06058140f, 0.11533636f, 
    -0.04939612f, 0.02601626f, 0.02881883f, -0.01488943f, -0.00970070f, -0.12428244f, 0.10684934f, 0.07792474f, 
    0.11392323f, -0.08966675f, -0.03905408f, -0.00608606f, 0.04446227f, 0.05522254f, -0.02228792f, 0.10185839f, 
    -0.02279469f, 0.06700416f, -0.08845210f, 0.11735519f, -0.02967432f, -0.06944723f, -0.08129721f, 0.06205018f, 
    -0.06790908f, 0.06931689f, 0.08993325f, 0.01106522f, 0.05396326f, 0.08450157f, 0.05593832f, 0.04719800f, 
    0.37552679f, -0.07448786f, -0.00071986f, 0.04463788f, 0.01396332f, 0.03630165f, 0.02581632f, 0.01274665f, 
    -0.03905278f, -0.01953880f, -0.02430973f, 0.02581463f, 0.27257437f, -0.09644914f, 0.04263816f, 0.01426534f, 
    -0.03837805f, 0.07462177f, 0.09393027f, 0.12378962f, -0.08279643f, 0.03898733f, -0.02790879f, -0.02085562f, 
    -0.09306580f, 0.10023647f, 0.16792253f, -0.04929152f, 0.05330538f, -0.00011867f, 0.05551678f, -0.04764128f, 
    0.01057899f, 0.11493193f, 0.07154910f, 0.01718492f, -0.21554254f, 0.31705657f, 0.08604217f, -0.33808938f, 
    0.01336231f, 0.02244833f, -0.11846910f, -0.00382111f, -0.03018491f, 0.04905739f, 0.12956434f, -0.11583626f, 
    0.38354805f, 0.12799127f, 0.01744607f, -0.12997393f, 0.06067662f, 0.07121863f, 0.05607159f, -0.06789754f, 
    -0.03243639f, 0.02020952f, -0.05194649f, -0.08834139f, -0.19832535f, -0.03668185f, 0.02983133f, -0.03774840f, 
    0.08995901f, 0.13241959f, -0.05708487f, -0.00193990f, -0.01800815f, -0.03274092f, 0.03601270f, -0.14083320f, 
    -0.28241140f, 0.05857955f, 0.22789425f, 0.08922994f, 0.07191153f, -0.05694649f, -0.03183712f, -0.05578247f, 
    -0.01326525f, -0.10944568f, -0.04686206f, -0.11140589f, 0.41008994f, 0.07950819f, 0.05952182f, 0.09134780f, 
    -0.00675228f, 0.01816809f, 0.07899829f, -0.00151722f, 0.00097009f, -0.07790786f, 0.05055071f, -0.01130377f, 
    -0.17932376f, 0.14064805f, 0.05676274f, -0.11311200f, 0.01447468f, 0.07704946f, 0.08016370f, -0.05430615f, 
    0.06198249f, -0.00813656f, -0.08229864f, 0.10693292f, 0.06531621f, 0.11883932f, 0.30617332f, 0.03842700f, 
    -0.00782784f, 0.02308471f, -0.04433493f, -0.01878111f, 0.02528601f, 0.00846165f, 0.07127660f, 0.05162937f, 
    -0.27598974f, 0.11829969f, -0.10703092f, -0.33840823f, 0.02707183f, 0.00640581f, -0.04266028f, -0.10053938f, 
    -0.05221371f, 0.13792554f, -0.00699558f, 0.11794954f, -0.35111460f, 0.03813519f, -0.03742631f, 0.08538228f, 
    0.06640995f, 0.15376404f, 0.11840502f, 0.04416718f, 0.04082846f, -0.01539942f, 0.08176228f, 0.00948719f, 
    0.16834550f, -0.18020529f, 0.06289294f, 0.03897269f, 0.02820246f, 0.12629962f, 0.01162723f, 0.02479151f, 
    0.00294440f, 0.11842846f, 0.13172278f, -0.02028489f, 0.12484361f, 0.18081926f, -0.14265525f, -0.20103560f, 
    -0.09470586f, -0.02882644f, 0.05030546f, 0.00893344f, -0.03983724f, 0.10451917f, -0.07477054f, -0.08953562f, 
    -0.15815327f, -0.01259725f, 0.19246113f, 0.13052435f, 0.01549830f, 0.11809552f, 0.09272072f, 0.01130813f, 
    0.03130909f, -0.04856255f, 0.00088860f, -0.08965774f, -0.19375627f, 0.00139771f, 0.02518474f, -0.09045495f, 
    0.04268549f, -0.03008720f, 0.00324402f, 0.06240628f, -0.07930073f, 0.05540450f, 0.05588630f, -0.12074456f, 
    0.01478139f, 0.06308793f, -0.04931490f, 0.11510082f, 0.08013627f, 0.01007782f, -0.07297595f, -0.03690911f, 
    -0.02235747f, -0.03061977f, -0.04417443f, -0.14187863f, -0.07293984f, -0.02776366f, 0.21908110f, 0.02555384f, 
    0.01723945f, 0.01925422f, 0.03095699f, 0.04986845f, 0.09500391f, -0.06460015f, 0.01170018f, 0.08098908f, 
    -0.27481282f, 0.07148933f, -0.15025587f, -0.19320995f, -0.04969253f, -0.03333876f, -0.02527934f, -0.02318504f, 
    0.08906052f, 0.04556088f, -0.02620952f, 0.02869555f, 0.17273574f, 0.08163945f, -0.01069926f, 0.02630595f, 
    0.05453147f, -0.01560610f, 0.04232589f, 0.02693410f, 0.10093757f, 0.08583310f, -0.02693738f, -0.01304003f, 
    0.51511651f, 0.01383320f, -0.15993562f, -0.01372315f, -0.05292616f, -0.01651023f, 0.06548197f, -0.04367679f, 
    -0.00620481f, 0.02336203f, -0.00087389f, 0.06244125f, -0.14234284f, 0.21107006f, 0.17461520f, -0.24282402f, 
    0.02636108f, -0.04442401f, -0.05350807f, 0.03503722f, 0.00542247f, 0.11336777f, -0.06375930f, -0.09281267f, 
    -0.12171256f, 0.12143870f, 0.00601205f, 0.02240045f, -0.08620969f, -0.00420524f, -0.00948666f, -0.08164253f, 
    0.01927271f, -0.04720035f, -0.05015857f, 0.04580741f, 0.06053511f, -0.25875232f, 0.03842278f, -0.02244968f, 
    -0.03945303f, 0.01827990f, 0.07885777f, -0.00111345f, 0.10879889f, -0.04761400f, -0.06647523f, 0.06135768f, 
    -0.27316704f, 0.09777088f, 0.00658659f, -0.24498713f, -0.05665501f, 0.00923362f, -0.02955570f, 0.05961683f, 
    -0.00356445f, -0.01792189f, -0.10737780f, 0.04593430f, 0.15535852f, 0.08465048f, 0.06532803f, 0.23588359f, 
    -0.07200723f, 0.02338897f, 0.00018008f, -0.07989075f, -0.01818925f, -0.07075383f, 0.13394801f, 0.08775886f, 
    0.44826412f, -0.13032657f, 0.04007462f, -0.04549868f, 0.01240483f, 0.08983932f, 0.13154685f, -0.00297653f, 
    -0.12205407f, 0.00829367f, -0.05330770f, 0.06380953f, 0.10244526f, 0.00998857f, 0.04978108f, 0.06194987f, 
    -0.10951088f, 0.00179739f, -0.04050457f, -0.09767528f, 0.12683468f, 0.12442385f, -0.02382738f, 0.02704055f, 
    0.20161255f, 0.15880696f, 0.02633613f, 0.19148810f, 0.09895100f, 0.20733920f, 0.05274216f, 0.04730377f, 
    0.09416750f, 0.02834845f, 0.04884758f, 0.03195595f, -0.33677000f, -0.14359188f, -0.03542694f, -0.06486465f, 
    0.09307482f, 0.04912770f, 0.01976891f, -0.03289267f, 0.00319645f, 0.09851113f, -0.05779386f, 0.08066423f, 
    -0.18088977f, 0.25387689f, -0.11704497f, 0.14617918f, -0.02088223f, 0.01494640f, -0.01779873f, 0.02528725f, 
    0.07083643f, 0.01023635f, 0.03333109f, 0.18843147f, 0.03182515f, -0.04033881f, -0.08215708f, -0.05816129f, 
    -0.07671236f, 0.04097495f, 0.05038881f, -0.08464266f, -0.00256498f, 0.06361717f, -0.09333096f, 0.07732625f, 
    -0.18571699f, -0.07698449f, 0.19654052f, 0.01755113f, 0.01098441f, -0.14056937f, 0.10317177f, -0.01400158f, 
    -0.01544001f, 0.07826033f, 0.02657479f, 0.21545492f, -0.17378628f, 0.26873499f, 0.28400844f, 0.11173759f, 
    -0.01872045f, -0.04384295f, -0.05196894f, 0.10568315f, 0.05859012f, 0.07514542f, 0.03159310f, -0.00712745f, 
    -0.04620282f, -0.04669978f, 0.08865354f, 0.20421727f, 0.00751652f, 0.09289844f, -0.00084097f, 0.04485158f, 
    0.12336099f, 0.04119118f, 0.09498188f, -0.06488221f, -0.12784992f, 0.21284771f, -0.18299280f, -0.06543173f, 
    -0.02175212f, -0.14068851f, -0.10324964f, 0.08427477f, 0.02538110f, 0.03253573f, -0.07807653f, -0.11288971f, 
    0.01492477f, 0.32085901f, -0.11178594f, 0.23186667f, 0.08423390f, 0.02691691f, -0.03295733f, 0.10404553f, 
    -0.01568382f, 0.02258562f, 0.12010993f, 0.05836969f, -0.06125689f, 0.04593139f, 0.03677519f, -0.13963114f, 
    0.03216224f, -0.03745594f, -0.11118076f, -0.05242320f, -0.03240611f, 0.02997620f, 0.04658739f, 0.05065467f, 
    -0.20906742f, 0.01190301f, -0.04632185f, 0.04114162f, -0.04662137f, 0.00579842f, 0.04281870f, -0.18510541f, 
    0.04361812f, -0.14459521f, -0.02892402f, -0.04400870f, -0.04618866f, 0.13296451f, 0.14766222f, 0.19319080f, 
    -0.03338600f, 0.03735078f, 0.05906692f, -0.22361082f, 0.14692108f, -0.03307395f, 0.06650165f, 0.04026753f, 
    -0.35156447f, -0.09171227f, 0.24340758f, 0.17174579f, 0.06658232f, 0.15176390f, -0.18713041f, -0.03577290f, 
    0.17997938f, -0.05726984f, 0.13456233f, 0.00552302f, -0.22495456f, 0.22766137f, 0.12999311f, 0.20322224f, 
    0.03062895f, 0.09192178f, 0.01008056f, 0.02055370f, 0.09954934f, 0.03025313f, -0.11102386f, 0.14061691f, 
    0.03982537f, 0.03335380f, 0.26516798f, -0.11459699f, 0.11227214f, -0.03505065f, 0.02507166f, 0.09003509f, 
    -0.01654368f, -0.03437236f, -0.01210045f, 0.07774853f, -0.37986416f, 0.23683384f, 0.02841236f, 0.13588962f, 
    0.04003465f, -0.01052641f, 0.06964477f, -0.08815041f, 0.10921444f, -0.00273873f, 0.15398401f, 0.10925557f, 
    -0.32772017f, -0.16038486f, 0.04686928f, 0.02885225f, 0.07335644f, 0.06095999f, 0.02635204f, -0.00168338f, 
    0.06634178f, 0.15565366f, 0.08911299f, 0.09784088f, -0.10723539f, -0.34438553f, -0.00004703f, -0.00746192f, 
    0.00304721f, 0.11350644f, -0.10407691f, -0.09917044f, 0.01051346f, -0.01806465f, -0.10115097f, -0.07719623f, 
    0.25987601f, 0.02272905f, 0.02318905f, 0.13722061f, -0.01740270f, 0.08878311f, 0.00854017f, -0.04434992f, 
    -0.03483823f, 0.04993349f, -0.00478668f, -0.10239597f, 0.11371554f, -0.06483752f, 0.26107666f, -0.02343640f, 
    -0.01655849f, 0.07436801f, -0.00990412f, 0.14218943f, 0.01442195f, 0.07572345f, -0.05862381f, 0.15032795f, 
    -0.26193100f, 0.17951210f, -0.01036602f, -0.01149418f, 0.08499133f, 0.01530835f, 0.03770437f, 0.06811474f, 
    0.11468684f, 0.10704722f, 0.09676865f, 0.11089630f, 0.09319123f, -0.02225466f, -0.04898123f, 0.17331368f, 
    -0.14738700f, -0.03064893f, -0.09436531f, 0.12118984f, 0.06787583f, 0.02650514f, 0.20191109f, 0.08750529f, 
    -0.23737405f, -0.05180569f, 0.09652445f, 0.07483914f, -0.02578993f, -0.06271622f, -0.02624900f, 0.00522699f, 
    0.13505203f, -0.07305880f, 0.09570189f, 0.03329442f, 0.06334703f, 0.03946702f, -0.05037854f, -0.00557770f, 
    0.05793303f, -0.07109462f, -0.04453070f, -0.18324569f, 0.07256578f, 0.08732638f, -0.01713884f, -0.02323550f, 
    0.17653914f, 0.00610496f, 0.08227911f, 0.16205569f, 0.01667397f, 0.05801207f, -0.06163393f, 0.07965326f, 
    -0.05702669f, -0.12749322f, 0.11268972f, 0.08975068f, 0.37868893f, 0.02587890f, 0.08940450f, -0.08838517f, 
    0.00826012f, -0.00253010f, -0.00931685f, 0.03884714f, -0.00028062f, -0.13584290f, 0.08662134f, -0.01054421f, 
    0.24602574f, 0.33932954f, -0.01097429f, -0.04354623f, 0.16569839f, -0.11199109f, 0.03574362f, 0.03029027f, 
    0.04908531f, -0.09161141f, -0.07508633f, -0.09215309f, -0.21745153f, 0.04943608f, 0.22971268f, -0.10491212f, 
    0.06290681f, -0.05022784f, 0.03890129f, 0.00850931f, -0.09347225f, -0.06722500f, -0.08204445f, 0.06593808f, 
    -0.09567849f, -0.14834134f, 0.10318393f, 0.05295548f, -0.00425857f, -0.01751876f, 0.01844524f, -0.06620234f, 
    0.02254689f, 0.10100444f, 0.09748980f, 0.00015279f, -0.07528407f, -0.21162418f, -0.04523445f, -0.03693508f, 
    -0.01436333f, 0.00004650f, 0.03061351f, -0.20153205f, 0.04723656f, 0.04080401f, 0.01669375f, 0.04417257f, 
    -0.38649338f, -0.29995367f, -0.02690082f, -0.02889088f, 0.11000752f, 0.05316973f, -0.00287276f, -0.09910862f, 
    0.10099462f, 0.03859444f, -0.01290329f, 0.01590775f, 0.15306997f, -0.03350092f, 0.15528907f, 0.19598003f, 
    0.24799016f, 0.11468966f, 0.14678246f, 0.07534719f, -0.01327897f, 0.00840742f, 0.02504134f, 0.03145710f, 
    -0.12623610f, -0.10030242f, -0.07046233f, -0.01696778f, 0.08869006f, 0.05979377f, -0.02107593f, -0.10060485f, 
    0.18448025f, 0.07948992f, -0.06550257f, 0.02460359f, -0.03722309f, 0.10376094f, -0.00541302f, -0.05771525f, 
    0.01130729f, -0.08683345f, 0.08106327f, -0.01071365f, -0.01474170f, -0.02451251f, -0.09629884f, -0.04663419f, 
    -0.08109446f, -0.04720420f, 0.02502938f, 0.00519068f, -0.02525762f, -0.07503621f, 0.23579919f, -0.02048316f, 
    0.08139812f, 0.18566495f, 0.02521864f, 0.04513862f, -0.03814692f, -0.04395713f, -0.04842286f, 0.04030009f, 
    0.00384286f, -0.04598767f, -0.10721271f, -0.02875356f, -0.00110456f, -0.08971988f, -0.11516953f, 0.01310675f, 
    -0.15121053f, 0.07723610f, 0.13225098f, 0.03294988f, -0.03786181f, 0.02220602f, 0.05511541f, 0.06093335f, 
    0.11616238f, 0.09666664f, -0.00646950f, -0.01770965f, -0.15235779f, 0.07177018f, 0.09710585f, -0.04251878f, 
    0.02823309f, -0.09566717f, -0.10639063f, -0.05064692f, -0.05789184f, 0.09331849f, 0.09069420f, 0.08681592f, 
    -0.19652027f, 0.20961826f, -0.07888883f, 0.21383239f, -0.05320874f, 0.11322546f, 0.03313622f, 0.06403515f, 
    0.07393112f, -0.08266933f, -0.04375060f, 0.03020105f, -0.32785305f, -0.33693841f, -0.06944171f, -0.00150163f, 
    0.02325957f, 0.00670700f, -0.00371239f, -0.06336667f, 0.02844236f, 0.03044200f, 0.03723784f, 0.07237967f, 
    0.15586261f, 0.00902415f, 0.12819532f, -0.07552607f, 0.06108005f, 0.00099793f, 0.03992331f, 0.06510808f, 
    0.07653818f, 0.09779826f, 0.04664923f, 0.12464917f, 0.04597541f, -0.03665613f, 0.07133207f, 0.01817785f, 
    0.08908795f, 0.08777560f, -0.01576238f, -0.08321027f, -0.02328801f, -0.04619831f, 0.08275643f, 0.10401297f, 
    0.01384816f, 0.05197278f, -0.06443064f, -0.01438295f, -0.12648617f, 0.10992781f, -0.09991171f, -0.04398326f, 
    0.07340179f, 0.09212017f, 0.05220415f, 0.09090411f, 0.03461418f, -0.11443289f, 0.11014873f, -0.03606701f, 
    -0.00566039f, 0.08665961f, 0.10357151f, 0.03751208f, 0.02694198f, 0.07597401f, -0.04032392f, 0.04607638f, 
    0.04321912f, 0.26013306f, -0.16612491f, 0.01733900f, 0.00217264f, -0.08880934f, -0.00332052f, 0.09969576f, 
    -0.01173887f, -0.10669262f, 0.15923420f, 0.00803205f, 0.13534066f, 0.11752987f, -0.08128200f, -0.06340799f, 
    -0.04739266f, 0.03929408f, 0.11772498f, 0.07970101f, 0.03119645f, 0.06428660f, -0.05490338f, -0.04431468f, 
    -0.38901711f, -0.20249182f, -0.11750559f, 0.01950220f, 0.08169843f, -0.00986458f, 0.01533408f, -0.04208663f, 
    0.06330359f, -0.11090917f, 0.10542878f, -0.02853850f, -0.14061968f, 0.17011288f, 0.00343259f, 0.04192002f, 
    -0.03870661f, -0.06272491f, -0.00107573f, 0.02587705f, 0.15552562f, 0.09485226f, 0.12729619f, 0.04790476f, 
    0.01828323f, -0.06961887f, -0.04488090f, -0.10064651f, 0.12616366f, -0.12134010f, 0.03451416f, 0.07425983f, 
    0.01846442f, 0.02183998f, -0.02193108f, -0.01398315f, -0.30428404f, -0.24734657f, 0.04689468f, 0.09078635f, 
    0.06497859f, 0.03395048f, 0.01285412f, 0.02336614f, 0.03858609f, 0.00023600f, 0.19150937f, 0.09863758f, 
    0.13785274f, 0.12436708f, -0.00090301f, 0.04411869f, 0.10050272f, -0.07239184f, -0.06814587f, -0.02974763f, 
    0.05975275f, 0.16786689f, -0.05816489f, 0.18560110f, -0.26965550f, 0.17733951f, 0.06691254f, 0.10475582f, 
    0.08564766f, -0.05987422f, 0.01269109f, -0.07745512f, -0.04777415f, 0.04123897f, -0.05929134f, 0.03449882f, 
    0.23171714f, -0.06252201f, 0.14379476f, 0.07644292f, 0.19621089f, 0.07300831f, 0.07983067f, -0.02005028f, 
    -0.04943623f, -0.04260914f, 0.10432468f, -0.06447757f, 0.13059878f, 0.08770419f, -0.08619054f, 0.07520080f, 
    -0.01260271f, 0.07512958f, -0.05453584f, 0.04423553f, -0.05473122f, -0.01029053f, 0.02135134f, -0.01068227f, 
    -0.32059187f, -0.10379896f, 0.19580738f, 0.09638270f, 0.04238104f, 0.03623400f, 0.06738063f, -0.03064515f, 
    -0.02305238f, -0.14513335f, 0.06121162f, 0.07412545f, -0.02838370f, -0.11024462f, 0.16142464f, 0.10701279f, 
    -0.05142085f, 0.15679955f, 0.00875229f, -0.11846837f, -0.06071031f, 0.05515374f, -0.03588123f, 0.04276874f, 
    -0.38344887f, -0.08199880f, 0.09054162f, -0.14624698f, 0.00418579f, 0.08547833f, -0.04552912f, 0.05984234f, 
    -0.01621930f, -0.06535230f, -0.05613970f, 0.04391843f, -0.30262342f, -0.19147602f, 0.24613544f, 0.09576591f, 
    0.00067154f, 0.08259947f, 0.01197645f, -0.04925225f, 0.01408847f, 0.06406344f, 0.12930815f, -0.03115649f, 
    0.16822785f, 0.09510864f, 0.08018937f, 0.01658062f, 0.06704942f, 0.01756323f, -0.09142360f, 0.08324248f, 
    0.02298444f, 0.03979903f, 0.00471664f, -0.02282623f, -0.07975262f, 0.21940023f, -0.01540009f, -0.00012484f, 
    -0.04210236f, 0.00308193f, -0.14675525f, -0.00879890f, 0.02092512f, -0.05343528f, 0.01583385f, 0.04445391f, 
    -0.10139569f, 0.07998069f, -0.00153939f, -0.02290141f, -0.00614864f, -0.04160238f, -0.03326982f, 0.00255225f, 
    -0.01066162f, 0.06266127f, 0.09752292f, -0.10328174f, 0.18075204f, 0.24086030f, 0.21030708f, 0.03193554f, 
    0.07333364f, -0.01994460f, 0.11804523f, 0.14332248f, -0.00565964f, 0.02614947f, -0.00213556f, 0.09344924f, 
    -0.38663420f, 0.24930148f, -0.01413728f, 0.02979355f, 0.02000039f, -0.09980140f, -0.10965480f, -0.14545788f, 
    0.04321352f, -0.04792110f, 0.18276352f, 0.00772850f, -0.02347243f, -0.13944316f, 0.07650816f, -0.00402915f, 
    -0.00101647f, 0.09616135f, 0.09926771f, -0.05226499f, 0.00580366f, 0.02053005f, -0.09915877f, 0.03170921f, 
    0.02420440f, 0.02040007f, -0.03532214f, 0.01987145f, 0.00573773f, 0.02026602f, -0.02711890f, 0.00769878f, 
    -0.02454538f, -0.01100938f, -0.03081800f, -0.02247347f, -0.01080387f, 0.00290495f, 0.00564290f, 0.01489732f, 
    0.00506862f, -0.00234829f, -0.00942548f, -0.01206283f, -0.01015920f, 0.02811289f, 0.00984584f, 0.02257270f, 
    0.02393032f, 0.01097620f, -0.02617697f, -0.02764096f, -0.01369949f, -0.03104981f, 0.00635276f, 0.00088276f, 
    -0.01284818f, 0.00379700f, 0.02759572f, -0.01602786f, -0.02133388f, 0.01738151f, -0.03319151f, 0.02472113f, 
    0.00580848f, -0.00229603f, -0.02770738f, 0.01051365f, -0.03513473f, -0.00849025f, -0.04062630f, 0.01646239f, 
    0.00637180f, -0.03152959f, 0.01602281f, 0.00260895f, -0.03054023f, -0.01404960f, 0.01110425f, -0.02920960f, 
    -0.00848477f, 0.01241263f, -0.03689147f, 0.00763270f, 0.01124487f, -0.03716617f, -0.00200036f, -0.03997163f, 
    0.02852056f, 0.01840490f, -0.00199242f, 0.00871485f, -0.00677121f, 0.01904884f, -0.03676985f, 0.02416159f, 
    0.00337650f, -0.01467590f, 0.00662081f, -0.02661795f, -0.04190711f, -0.04385097f, 0.03367905f, -0.02659484f, 
    0.01793790f, -0.03372344f, -0.03072683f, 0.00489537f, 0.02072430f, -0.00741873f, 0.02691263f, -0.01287987f, 
    0.02698948f, -0.02134656f, 0.00585202f, 0.02521312f, 0.02204271f, 0.02824177f, -0.03561169f, 0.01451320f, 
    -0.03922506f, -0.02937059f, -0.00689474f, -0.01965158f, 0.00622564f, 0.02185420f, 0.02750391f, -0.00535434f, 
    -0.01630338f, -0.02449246f, -0.01859206f, -0.03185077f, -0.01820353f, -0.02335457f, 0.00817618f, 0.00171628f, 
    -0.00855831f, 0.00453053f, 0.02551356f, -0.00327220f, 0.00460539f, -0.01956486f, -0.01052701f, -0.02830464f, 
    -0.01185966f, -0.02543549f, -0.00845022f, -0.02516835f, -0.00096092f, -0.04238633f, -0.03077512f, -0.00109298f, 
    0.01646170f, -0.00291134f, -0.01762316f, -0.02812795f, 0.00951705f, -0.02289650f, 0.01406977f, -0.03038513f, 
    0.02480277f, -0.01914612f, 0.00198637f, 0.02388112f, -0.02239872f, -0.02996915f, -0.02890921f, 0.01730191f, 
    -0.02204680f, -0.04193583f, -0.00740204f, -0.02040609f, -0.00269122f, -0.01737131f, -0.04049630f, -0.01387822f, 
    -0.00189938f, -0.01730909f, 0.01140307f, -0.03469293f, -0.00471959f, -0.03622898f, 0.02134430f, 0.01578916f, 
    -0.00374672f, 0.02559112f, 0.03480819f, -0.00756247f, -0.03268735f, -0.01140947f, -0.00582370f, 0.00430960f, 
    -0.01822043f, 0.03823244f, 0.02409749f, -0.03268518f, 0.00041501f, -0.02721857f, -0.00547370f, -0.03297816f, 
    -0.00859127f, -0.03540123f, 0.02306502f, -0.04190106f, -0.01314919f, 0.00601862f, -0.01105037f, -0.00729300f, 
    -0.02542908f, -0.01470269f, 0.03066439f, -0.03967062f, -0.01894093f, 0.01815436f, -0.03972293f, 0.00503845f, 
    0.02389933f, 0.01496921f, -0.03607953f, -0.03128173f, 0.03009005f, -0.00231885f, 0.00746539f, -0.01717640f, 
    0.00740329f, 0.01684849f, -0.01268543f, -0.02987066f, -0.02739084f, 0.02227686f, -0.03054930f, -0.02199086f, 
    0.02517875f, -0.01844038f, 0.00177173f, -0.03755116f, 0.00807331f, 0.01881617f, -0.02815446f, 0.02330921f, 
    -0.04332992f, -0.00896339f, -0.01170491f, 0.01574896f, 0.01951687f, 0.01106167f, -0.00224645f, -0.02333154f, 
    -0.00099141f, -0.00634517f, -0.02676228f, 0.00319585f, -0.02892647f, -0.04204220f, 0.01565516f, -0.00175804f, 
    -0.02273455f, 0.01957959f, 0.00710075f, -0.01401886f, -0.02333624f, -0.03372908f, 0.01893950f, 0.01671878f, 
    -0.00463654f, -0.01480744f, -0.04172096f, 0.00586857f, -0.00138249f, -0.03053655f, 0.00867932f, 0.00209884f, 
    -0.02611714f, 0.00460958f, 0.01294504f, 0.02043879f, -0.02189693f, 0.01908919f, -0.04278222f, -0.00859629f, 
    0.00865001f, 0.00175272f, -0.01874629f, 0.00262521f, -0.00399427f, 0.00479735f, -0.01432249f, 0.01325304f, 
    0.02751501f, 0.00117657f, -0.00550004f, 0.00168577f, 0.02664351f, -0.01380183f, -0.00179796f, -0.02360413f, 
    0.00596379f, -0.02226600f, 0.00574693f, 0.00234236f, 0.01674558f, 0.00863131f, -0.00739860f, -0.02410725f, 
    -0.04078126f, 0.02148099f, -0.01239325f, 0.00252297f, 0.01006572f, -0.00590001f, -0.00327163f, -0.04086601f, 
    -0.03992502f, 0.03887434f, 0.02725606f, -0.00277419f, -0.03421551f, 0.00506485f, -0.02737768f, 0.00826522f, 
    -0.03259651f, -0.00807609f, -0.02318378f, -0.01675735f, -0.03306028f, -0.00807977f, 0.02009976f, -0.04001746f, 
    0.02382823f, 0.01661955f, -0.00564040f, 0.01866050f, -0.02592248f, -0.03210605f, 0.01268916f, -0.00774133f, 
    -0.02097487f, -0.01410537f, -0.00005542f, 0.02462346f, -0.01050325f, -0.02878395f, 0.01124706f, -0.02057358f, 
    -0.00162779f, -0.04412143f, 0.00256364f, 0.02328190f, -0.00400575f, 0.00917909f, -0.01965888f, -0.01357503f, 
    -0.03779346f, -0.01025319f, 0.00716057f, -0.01509588f, 0.01706195f, -0.01494958f, 0.00382015f, 0.01453796f, 
    0.00545676f, -0.03916658f, 0.02717280f, -0.04172888f, -0.01751066f, 0.01025215f, 0.01799906f, -0.00502205f, 
    -0.03510351f, 0.01569046f, -0.02568293f, 0.00225104f, -0.00524324f, 0.00485343f, 0.01920325f, -0.00339107f, 
    0.01340910f, 0.01072685f, -0.02458269f, -0.01296420f, 0.01659849f, -0.00594800f, -0.03774498f, -0.00444944f, 
    -0.01052813f, 0.00419832f, 0.02131655f, 0.01467288f, -0.03534731f, 0.01239317f, -0.02564511f, -0.01210548f, 
    0.02795266f, 0.00168418f, 0.01792943f, -0.03223088f, 0.00318580f, 0.01495477f, 0.02214431f, -0.01378271f, 
    -0.03860063f, -0.03494730f, 0.02403550f, -0.04259771f, 0.01780880f, 0.01270597f, 0.02781089f, -0.04107723f, 
    -0.02315513f, 0.02825565f, 0.01824958f, 0.02423566f, 0.02144456f, -0.02243984f, 0.02375575f, 0.01000294f, 
    -0.03669674f, -0.00599173f, -0.01209316f, 0.01482264f, -0.00116638f, 0.01839792f, -0.04269221f, -0.02106376f, 
    -0.00868866f, -0.03895115f, -0.01598584f, 0.01531362f, -0.00285547f, 0.02635643f, -0.00727569f, -0.01855788f, 
    0.00549373f, 0.00119096f, -0.02458069f, -0.00167391f, 0.01179320f, -0.00224414f, -0.01549442f, -0.01156828f, 
    -0.02628898f, 0.01513886f, -0.03572753f, 0.01149638f, -0.03245802f, -0.01114424f, -0.03734196f, 0.01983314f, 
    -0.00867761f, -0.03395985f, 0.03518156f, -0.03946250f, -0.03643947f, -0.00187210f, -0.00040716f, 0.02440411f, 
    -0.01686389f, 0.02103612f, -0.01682799f, -0.02118219f, -0.02255782f, 0.01337385f, -0.02684570f, 0.01624935f, 
    -0.00706918f, -0.04168458f, -0.02311910f, 0.02054109f, -0.03369323f, 0.02230787f, 0.02749225f, -0.02452631f, 
    0.00475908f, -0.02951751f, -0.01339593f, 0.01664705f, 0.00183704f, 0.01365323f, -0.00098213f, -0.01958768f, 
    -0.00495401f, -0.03438276f, 0.00956233f, 0.02004151f, 0.02384195f, -0.02606160f, 0.02327509f, -0.00255532f, 
    0.00044357f, 0.02789017f, 0.00157341f, 0.01039469f, -0.04136134f, 0.00571047f, -0.02942077f, -0.01919433f, 
    0.00723181f, -0.02984801f, 0.00516389f, -0.01426334f, -0.03718278f, 0.02897615f, 0.01280341f, -0.03556111f, 
    -0.01786927f, 0.00000983f, -0.01424411f, 0.01394280f, 0.00452825f, -0.00008698f, -0.00560823f, -0.01373710f, 
    -0.03749572f, 0.01853848f, -0.00578698f, -0.00819449f, -0.02314883f, 0.02770659f, -0.00014144f, -0.00251508f, 
    -0.00612308f, 0.02181286f, 0.00661252f, 0.02603813f, -0.03581672f, 0.02344258f, 0.00721380f, -0.02205927f, 
    0.02056798f, -0.00331292f, 0.01399773f, -0.01034795f, 0.00732013f, 0.02470451f, 0.01357496f, -0.00598316f, 
    0.00517773f, -0.03345369f, -0.00665753f, -0.03424362f, 0.00154160f, 0.01520800f, -0.02109573f, 0.03721499f, 
    -0.02095512f, -0.00132239f, -0.04278499f, 0.00762091f, 0.00700313f, 0.00925171f, 0.02654110f, -0.03433197f, 
    -0.00735688f, 0.01701684f, -0.00793389f, -0.03754219f, -0.03645776f, 0.00331722f, 0.01343096f, 0.01748966f, 
    0.02776547f, 0.00342554f, 0.00739405f, -0.03205543f, -0.03858382f, -0.01218487f, -0.01559156f, 0.00623453f, 
    -0.03897451f, -0.00590381f, -0.02483662f, -0.00379097f, 0.02582054f, -0.01589476f, 0.02181096f, 0.02165421f, 
    -0.00265535f, 0.01145055f, 0.02335973f, 0.01846869f, 0.00983547f, -0.00559194f, -0.00187305f, -0.00369744f, 
    -0.04206427f, -0.00061050f, -0.02648357f, -0.03936461f, -0.00638986f, -0.03861107f, -0.02554081f, -0.04079116f, 
    -0.02793014f, -0.00420438f, -0.02942742f, -0.03406619f, -0.00940585f, 0.00040361f, -0.03315406f, -0.00744193f, 
    -0.00286597f, -0.00800295f, 0.00971206f, -0.00696008f, -0.02393284f, -0.01025750f, 0.00050204f, -0.01546389f, 
    0.00911505f, -0.03165738f, 0.01022265f, -0.00187244f, -0.01565764f, 0.02290370f, 0.00993141f, -0.02880975f, 
    -0.02860203f, -0.02418074f, -0.01124026f, -0.03855444f, 0.02387527f, -0.00954809f, -0.02249460f, -0.01429259f, 
    0.02617991f, -0.02802423f, -0.01309878f, 0.00685138f, 0.02548005f, 0.01048967f, 0.01412355f, -0.00945031f, 
    0.02528672f, 0.01438582f, -0.02387526f, -0.01308713f, -0.01885688f, -0.01132504f, 0.01728883f, -0.01342652f, 
    0.02009616f, -0.03815719f, -0.01850313f, -0.01907146f, -0.02615519f, 0.01585434f, 0.01584970f, 0.00617395f, 
    0.00210329f, 0.01425203f, 0.02473227f, -0.00363937f, 0.02573928f, -0.00556999f, -0.04207982f, -0.01750460f, 
    -0.03157857f, 0.01131358f, -0.03790951f, -0.01175395f, 0.02213652f, -0.01233575f, -0.04019775f, -0.00104909f, 
    -0.01251441f, -0.01525042f, -0.01074620f, -0.03907445f, -0.01904193f, -0.00901661f, -0.03700366f, 0.01443303f, 
    -0.02337917f, -0.02003315f, -0.02116220f, -0.00112589f, -0.01304677f, 0.02685220f, -0.02058601f, 0.00551781f, 
    0.00031464f, -0.02670773f, -0.00720460f, -0.02194005f, -0.01064119f, -0.04109480f, -0.02118555f, -0.02051529f, 
    0.02058186f, -0.01817031f, -0.03931328f, -0.02031503f, 0.02692402f, -0.00173862f, 0.01132208f, -0.02261678f, 
    0.01204171f, -0.00680644f, -0.00861738f, 0.01144817f, -0.03211868f, 0.02232883f, -0.00896223f, -0.01046456f, 
    -0.03737133f, -0.00204387f, -0.00865133f, 0.01239892f, 0.00165829f, 0.00566981f, -0.03826795f, -0.04022021f, 
    -0.00134250f, -0.02003274f, -0.01732098f, -0.01379464f, -0.03031359f, -0.03432549f, 0.01933826f, -0.03451567f, 
    -0.03292158f, 0.01866509f, -0.00512204f, 0.01932778f, 0.02742474f, 0.02094327f, 0.00080104f, -0.01495855f, 
    -0.03988336f, 0.02085448f, -0.04230482f, -0.03656388f, 0.00547457f, -0.01201111f, -0.00479091f, -0.03083003f, 
    -0.03454737f, -0.00687761f, 0.00812926f, -0.02037257f, -0.03689731f, -0.00410825f, -0.03216350f, -0.00075006f, 
    -0.02341479f, 0.02580082f, 0.02369153f, -0.03339507f, -0.01353393f, -0.03288511f, -0.03504684f, -0.01097304f, 
    0.01282380f, 0.00501658f, -0.00507399f, -0.01892837f, -0.02458223f, -0.02362048f, -0.03400478f, -0.00307347f, 
    0.00888365f, 0.00971930f, -0.00509093f, 0.01686553f, 0.02887160f, -0.01649377f, -0.02725836f, 0.01160474f, 
    -0.02291035f, 0.02307636f, -0.02272536f, -0.02317039f, -0.03216212f, 0.02289846f, 0.00801048f, -0.00175994f, 
    0.01362493f, 0.01818007f, 0.02467166f, -0.01932674f, -0.02753016f, -0.00977167f, 0.00022525f, -0.00224027f, 
    -0.00979077f, -0.01104858f, 0.01390179f, -0.00484739f, 0.00356518f, 0.01044260f, 0.02072008f, -0.02166470f, 
    -0.12480556f, 0.04020368f, 0.06118456f, 0.17512651f, 0.03416111f, 0.03155861f, 0.03804946f, 0.08678971f, 
    -0.09029806f, -0.03137400f, -0.08291210f, 0.04448630f, -0.03036237f, -0.02275287f, 0.08220388f, 0.02321451f, 
    0.01603652f, 0.03328787f, -0.07776456f, -0.00490601f, 0.13961525f, -0.05781713f, -0.03340890f, -0.11289559f, 
    -0.30344868f, 0.14644635f, 0.01772532f, -0.03549491f, 0.04790792f, -0.00432423f, -0.00192827f, -0.06638775f, 
    0.01958170f, 0.00479151f, 0.06803685f, -0.13001809f, -0.11765341f, 0.24042717f, -0.05630879f, -0.08082426f, 
    0.08822474f, 0.08997738f, -0.03680632f, -0.03312962f, -0.04241291f, 0.02880828f, 0.12121677f, -0.02130707f, 
    -0.03396202f, -0.17117243f, 0.05852053f, 0.06546780f, -0.08571558f, -0.03259042f, -0.00986358f, -0.15805042f, 
    0.09134761f, -0.00083287f, 0.21746668f, -0.08539798f, 0.22055045f, 0.05883173f, 0.01584479f, 0.19789001f, 
    0.01676833f, -0.02183854f, 0.05305243f, -0.00364110f, 0.01009340f, 0.01489096f, 0.03612958f, 0.15742785f, 
    -0.05119143f, 0.16641638f, -0.00218092f, 0.04494968f, 0.04198997f, 0.06759128f, 0.08137160f, -0.04745017f, 
    -0.01494422f, 0.03387696f, 0.05356801f, 0.01624334f, -0.49942592f, 0.26551005f, 0.29221073f, 0.00356102f, 
    0.13941562f, 0.03663111f, 0.02469675f, 0.02376420f, 0.11756898f, -0.02281706f, -0.03789236f, 0.11908923f, 
    0.07358922f, -0.08043274f, -0.05098682f, 0.07174175f, 0.05750671f, -0.01010714f, -0.12751801f, -0.00622961f, 
    -0.02658616f, -0.03759711f, 0.02759572f, -0.09903214f, 0.09086850f, 0.09860341f, 0.10446590f, 0.04521757f, 
    0.02691243f, -0.01953558f, 0.04688612f, -0.02327118f, -0.04422904f, 0.02210764f, -0.00643861f, 0.01106292f, 
    0.22174390f, 0.12367565f, -0.06922577f, -0.03300281f, 0.10719257f, -0.04179913f, -0.04433367f, 0.02165221f, 
    -0.05588280f, 0.09192397f, 0.11908229f, 0.04046746f, -0.02749591f, -0.01176700f, 0.07930960f, 0.10902708f, 
    -0.06997430f, -0.02523984f, -0.15267782f, -0.13738318f, -0.07208173f, -0.02373849f, 0.09676092f, 0.06187629f, 
    0.16605167f, -0.08322483f, 0.04202673f, 0.06857769f, 0.01036122f, -0.10732332f, -0.00816393f, -0.10003068f, 
    -0.11652625f, 0.10262577f, 0.02294221f, -0.06209934f, -0.01120233f, 0.02785125f, 0.06286490f, 0.12784235f, 
    -0.01560268f, -0.04230753f, -0.04785184f, -0.00121938f, 0.01827533f, -0.06633557f, 0.10775834f, -0.04460162f, 
    0.03876835f, -0.17943527f, 0.04005043f, -0.11196988f, 0.05139571f, -0.07161266f, 0.04106556f, 0.03186749f, 
    0.04491030f, 0.04899616f, 0.06350056f, -0.03091030f, 0.12441386f, 0.07236820f, -0.05089147f, -0.06978427f, 
    0.19810545f, 0.09768261f, -0.00124551f, 0.02651692f, 0.02340903f, -0.00990033f, 0.02254470f, 0.05715378f, 
    -0.00417064f, 0.17089091f, 0.00818697f, 0.07645126f, -0.01236728f, 0.04530619f, -0.00574585f, 0.09367872f, 
    -0.06751078f, -0.09964281f, -0.01743196f, -0.01862674f, 0.29890743f, 0.11013398f, 0.03726465f, -0.00966961f, 
    -0.14152351f, 0.01102136f, 0.00454896f, 0.03169451f, -0.00932052f, 0.17433013f, 0.04170162f, -0.13131674f, 
    -0.40649536f, -0.22156116f, -0.06891915f, -0.06329374f, -0.04704395f, 0.03971554f, 0.03512993f, -0.11606298f, 
    -0.08558054f, -0.02503756f, 0.02697624f, 0.06824567f, 0.17327002f, -0.08913630f, 0.26312071f, 0.20513962f, 
    -0.01423517f, -0.03424034f, 0.08450084f, -0.00583601f, 0.02151710f, 0.04509871f, -0.00290214f, -0.09580100f, 
    -0.27114069f, -0.09376793f, 0.32888317f, -0.06573465f, 0.08828152f, -0.05354545f, -0.04791593f, 0.07280571f, 
    0.02420376f, 0.02235361f, -0.11340347f, 0.06691355f, -0.02063567f, 0.01374708f, 0.01067364f, -0.05319882f, 
    -0.08533800f, 0.09579974f, -0.01954852f, -0.02798508f, -0.01513676f, -0.02086579f, -0.13092150f, 0.08518199f, 
    -0.01513257f, 0.40304920f, 0.00394358f, 0.22306800f, 0.00215504f, 0.10837346f, -0.04049966f, -0.04906228f, 
    -0.11232868f, -0.07199198f, -0.11173229f, 0.09559613f, 0.29661343f, 0.00850147f, -0.04014144f, 0.05183249f, 
    0.00405770f, -0.05781803f, 0.18165447f, -0.06144899f, 0.06166850f, -0.19863977f, 0.07611620f, 0.06100406f, 
    0.08404389f, 0.10388814f, 0.03493588f, 0.04735403f, 0.16576892f, 0.07138994f, -0.03191299f, 0.08668184f, 
    0.03056149f, 0.19143680f, 0.00076427f, -0.02543637f, -0.21115789f, 0.46013793f, 0.08516070f, -0.11691280f, 
    0.11926484f, -0.03443282f, -0.04393483f, -0.24527265f, 0.00540789f, -0.14441587f, 0.06133690f, 0.01828595f, 
    0.20651235f, -0.07132891f, 0.11044539f, 0.14768027f, 0.04479505f, -0.06655455f, 0.10346907f, -0.07076737f, 
    -0.06919280f, 0.00161453f, 0.12361348f, 0.00055708f, -0.04210778f, 0.07924441f, 0.11961233f, -0.02058468f, 
    -0.00099426f, 0.01124342f, 0.06069760f, 0.08422117f, -0.03944296f, 0.09999941f, 0.12958205f, -0.01487583f, 
    0.13209368f, -0.12651354f, 0.05896649f, 0.05012794f, -0.13389839f, 0.03579068f, 0.07405446f, -0.03218757f, 
    0.01318064f, -0.06765886f, -0.02612711f, -0.04965433f, 0.33892292f, 0.11585936f, 0.13810816f, 0.10951739f, 
    -0.09309164f, 0.00507830f, -0.00126013f, -0.04086543f, -0.01355503f, 0.03684265f, 0.09859379f, 0.01534205f, 
    -0.09002229f, -0.03321028f, 0.05313206f, -0.05599783f, -0.07203028f, 0.00226365f, -0.08466101f, -0.02120009f, 
    -0.03768596f, 0.00129719f, 0.03076214f, -0.12934829f, 0.03585063f, -0.04181323f, -0.08225638f, 0.06467950f, 
    0.07971487f, 0.20119193f, 0.03128206f, 0.17968065f, -0.16420072f, 0.02782398f, -0.02003588f, -0.01929449f, 
    0.31051609f, 0.03844053f, -0.02308949f, -0.07894301f, -0.04314985f, 0.07975009f, -0.10249813f, -0.03447731f, 
    0.01491980f, -0.01270558f, -0.05384105f, -0.08678360f, 0.22466685f, 0.04266141f, 0.20934795f, 0.12488061f, 
    0.16348869f, 0.07994304f, 0.05773535f, 0.08239703f, 0.09856591f, 0.03586716f, 0.07297002f, 0.28242934f, 
    -0.19505474f, -0.09505840f, 0.08051703f, -0.10412202f, 0.07435902f, 0.07236496f, -0.04535228f, -0.09485045f, 
    0.03664999f, -0.05304689f, -0.06031586f, -0.02212519f, 0.22602217f, -0.01143127f, 0.02060930f, -0.01723701f, 
    0.02891084f, -0.02062003f, -0.05592821f, 0.05213896f, 0.06589791f, 0.12527156f, -0.02140084f, 0.03210677f, 
    -0.18039849f, -0.06864179f, 0.07993031f, -0.03961247f, -0.00869412f, -0.12029047f, 0.07836649f, -0.09483437f, 
    0.07566224f, -0.02328512f, -0.03028653f, 0.06680412f, 0.28595370f, 0.04008777f, 0.06989022f, -0.06321812f, 
    0.10285090f, 0.02378659f, 0.14292175f, 0.08452228f, 0.08291695f, 0.02538223f, 0.05611215f, 0.15074624f, 
    -0.34371608f, 0.20907462f, 0.05730396f, -0.01049295f, 0.05131497f, 0.09654334f, 0.00249123f, 0.03835491f, 
    -0.04850729f, 0.07287680f, 0.06475164f, 0.12154827f, -0.03453208f, 0.14837179f, 0.09563001f, -0.10318595f, 
    -0.08939461f, 0.10850682f, -0.06545682f, -0.04101983f, 0.03964330f, -0.06094251f, 0.09662534f, -0.19321162f, 
    0.23167083f, -0.16886355f, -0.00867855f, -0.03566518f, -0.06873449f, -0.08803320f, -0.02618706f, 0.02890273f, 
    -0.03076460f, -0.01253778f, -0.16041043f, -0.10174265f, -0.24549346f, -0.12754904f, 0.02489023f, 0.09140161f, 
    0.10096973f, -0.06697416f, 0.04019435f, 0.00150590f, 0.09595507f, -0.01394350f, -0.04149335f, -0.07135934f, 
    -0.02894665f, 0.11837512f, 0.08902980f, 0.10263908f, -0.13214397f, 0.03049440f, 0.07030425f, 0.03630937f, 
    -0.00538182f, -0.05097307f, -0.06142401f, -0.07077686f, -0.08125084f, 0.11769272f, 0.14634389f, 0.11986502f, 
    0.17999239f, 0.11381828f, 0.03034005f, -0.03218495f, 0.04290951f, -0.03387252f, 0.05357124f, 0.12664922f, 
    -0.05184343f, 0.22440580f, -0.09142774f, 0.11436823f, 0.05540971f, 0.01070354f, 0.05412268f, -0.07057577f, 
    -0.02262945f, 0.02656775f, -0.09707426f, 0.11631729f, -0.12479044f, 0.28998706f, -0.09606168f, 0.03346417f, 
    0.07588092f, 0.13429855f, -0.08240099f, 0.11028906f, 0.02680368f, -0.06160857f, 0.07595395f, -0.03523077f, 
    -0.10492469f, 0.23823941f, -0.02265077f, 0.07602352f, -0.00954384f, -0.07167288f, -0.03090144f, -0.04643858f, 
    0.00998769f, -0.01953840f, -0.12641092f, 0.00161173f, -0.09004310f, 0.39145395f, -0.06379571f, -0.02953202f, 
    0.07590238f, 0.06700778f, 0.06161479f, -0.11803164f, -0.02299887f, -0.12963170f, 0.00194654f, -0.03817515f, 
    0.14897415f, -0.00284763f, 0.21345958f, 0.13414630f, 0.08507095f, 0.06160005f, 0.11446726f, 0.07633093f, 
    0.05550038f, -0.00192413f, -0.01925297f, 0.11913510f, 0.22668308f, -0.04088098f, -0.00218977f, 0.07867718f, 
    -0.12913622f, -0.00678524f, 0.16078079f, -0.04259134f, 0.00207495f, 0.09137227f, -0.09736665f, -0.02721741f, 
    -0.11946325f, -0.15700147f, 0.06029118f, 0.02957476f, -0.16362870f, 0.00216826f, -0.06211277f, -0.04084310f, 
    -0.02551307f, -0.10043731f, 0.04416687f, -0.12578958f, 0.22784962f, 0.17276126f, -0.10694600f, 0.07288066f, 
    -0.02700080f, 0.09007336f, -0.00656787f, 0.08884323f, -0.00605897f, 0.05555775f, -0.04574706f, -0.03172217f, 
    0.04936077f, 0.10363372f, -0.08215922f, 0.18649501f, 0.14150150f, 0.02056486f, 0.01508038f, 0.01231682f, 
    0.02770508f, -0.10806067f, 0.06907640f, -0.00095728f, -0.02566170f, 0.21254744f, 0.07655745f, -0.05709550f, 
    -0.09850075f, -0.00398622f, 0.01544616f, 0.00471734f, -0.06738475f, -0.17492916f, 0.10145134f, 0.01309797f, 
    0.14902709f, 0.26742339f, 0.03362648f, 0.10971955f, -0.17280290f, 0.03500136f, -0.00358410f, 0.13902034f, 
    -0.06909606f, -0.03004724f, -0.01784369f, 0.07182321f, -0.13933599f, -0.12820813f, 0.02439203f, -0.05673302f, 
    0.15210202f, 0.01253893f, 0.02357872f, 0.10824473f, -0.00260283f, 0.12515417f, -0.05234938f, 0.18519537f, 
    -0.00007292f, 0.04071153f, 0.05717300f, -0.07141171f, -0.02919354f, -0.09186196f, 0.04389641f, -0.08820871f, 
    -0.06935180f, -0.10102624f, -0.01608237f, 0.02750696f, 0.02313549f, 0.05936886f, -0.05021273f, 0.10231247f, 
    -0.13190113f, -0.02231712f, -0.03546436f, -0.04568440f, -0.04838525f, -0.02504972f, 0.00301513f, 0.02229214f, 
    -0.06811290f, 0.12985840f, -0.12459967f, 0.16945808f, 0.00327426f, -0.03401655f, -0.06878560f, 0.00678165f, 
    0.02160412f, -0.02167395f, 0.00669586f, 0.04648561f, 0.21292256f, -0.09773422f, 0.15603630f, 0.07297102f, 
    0.01377089f, -0.13002197f, 0.03836200f, -0.01123763f, 0.02947618f, 0.01364374f, 0.00190871f, -0.03651024f, 
    -0.08784179f, 0.23879293f, -0.13575506f, -0.04856553f, 0.01986336f, 0.06616210f, 0.11141694f, -0.00063997f, 
    0.06842179f, 0.00784233f, -0.12780109f, -0.15708061f, -0.21432544f, -0.16160540f, 0.06408939f, 0.07438438f, 
    -0.03534005f, -0.08070669f, -0.05074139f, 0.03505147f, -0.02032742f, 0.08192354f, -0.00992048f, -0.00737335f, 
    0.27700526f, 0.01522345f, 0.10935757f, -0.00588911f, 0.10514027f, 0.03244790f, 0.13860576f, -0.11619814f, 
    0.06326714f, -0.11032925f, -0.00339609f, -0.01246756f, -0.48166931f, 0.05232261f, -0.05453593f, 0.00374916f, 
    0.06428087f, 0.04265907f, 0.01241024f, 0.04133120f, 0.09620072f, 0.15949704f, -0.05263204f, 0.14120640f, 
    0.01346892f, -0.02555787f, -0.03062011f, -0.01337577f, -0.01543227f, 0.03383671f, -0.01222704f, -0.00296128f, 
    -0.03722377f, -0.02202024f, -0.01491862f, -0.03231966f, 0.02549835f, 0.00929187f, 0.02226067f, -0.03052201f, 
    -0.02284731f, 0.00346022f, -0.01489709f, 0.02491269f, -0.03903985f, -0.04179852f, 0.00452698f, -0.03433011f, 
    -0.00592381f, -0.02155792f, 0.02360340f, -0.02518136f, -0.03451879f, 0.00545363f, 0.01325545f, -0.01433040f, 
    -0.03707044f, -0.03188733f, -0.01422493f, -0.03732730f, 0.00600172f, 0.00833776f, 0.02192139f, -0.02712390f, 
    -0.02313868f, 0.01776523f, 0.02458905f, -0.03149735f, 0.00800379f, -0.01924691f, -0.01098812f, -0.00043229f, 
    0.01840685f, -0.00246257f, -0.02572544f, 0.01143970f, -0.01037048f, -0.01620224f, -0.02294168f, 0.00997489f, 
    0.02153591f, -0.03356980f, -0.00873736f, -0.03215054f, 0.01842480f, 0.03335645f, 0.01495403f, 0.01231643f, 
    0.02467581f, -0.00935403f, -0.01526427f, -0.01508713f, -0.01946001f, -0.02485334f, 0.01178584f, 0.03318183f, 
    0.03600757f, -0.00921235f, -0.00090802f, -0.01654144f, 0.02403422f, 0.00501720f, -0.00074934f, 0.01809642f, 
    0.00780891f, 0.03011052f, 0.01481506f, 0.03244544f, -0.02564972f, 0.01722131f, 0.01230788f, 0.02807304f, 
    0.00489792f, -0.02337548f, 0.00919223f, -0.03739054f, -0.00736894f, -0.02101432f, -0.01645156f, 0.01790985f, 
    -0.02382589f, -0.01711594f, -0.03372220f, 0.00383106f, 0.00278681f, -0.00851434f, 0.00969391f, 0.02809033f, 
    0.02671308f, -0.01918735f, -0.02989477f, 0.02001153f, -0.03781376f, 0.02046764f, -0.01732773f, -0.03581946f, 
    -0.02197961f, 0.01962223f, -0.01870825f, -0.00446512f, -0.01865171f, 0.01810546f, -0.00539805f, -0.03329247f, 
    -0.00038367f, 0.01732237f, -0.02950322f, 0.00786115f, -0.00052950f, 0.03093713f, -0.01402491f, -0.03539998f, 
    -0.02280115f, 0.01060118f, -0.02245831f, -0.03000575f, 0.03276671f, 0.02665201f, 0.00876566f, -0.02676304f, 
    -0.02973374f, -0.03408648f, -0.01994038f, 0.01006682f, 0.00753614f, -0.02112164f, -0.03646383f, -0.01541941f, 
    -0.01858154f, -0.00864105f, -0.02970201f, -0.01370298f, -0.00502588f, 0.00142442f, -0.01927700f, 0.02669988f, 
    -0.02904494f, 0.01298831f, -0.00559852f, -0.00834182f, 0.02645025f, 0.00013163f, -0.02301093f, -0.00941312f, 
    -0.01052997f, 0.02620210f, 0.02685435f, -0.01610649f, -0.00763937f, -0.02815959f, 0.03300542f, 0.00713729f, 
    0.01366653f, -0.01652988f, 0.00196094f, 0.00043703f, -0.01530838f, -0.00227827f, -0.02496896f, 0.02841963f, 
    -0.00472141f, -0.00123457f, -0.03455147f, 0.00625926f, -0.01152322f, 0.00416384f, -0.01935393f, -0.03413894f, 
    -0.01131045f, -0.03446821f, -0.01478567f, 0.01284816f, 0.01029147f, 0.00979503f, 0.00539980f, 0.01401353f, 
    -0.03920131f, 0.01162872f, -0.03300807f, 0.02244315f, -0.00493710f, -0.02069666f, 0.02084728f, -0.02789192f, 
    -0.03570601f, -0.02854646f, 0.02542600f, -0.00197855f, -0.00247554f, -0.02775273f, -0.00289834f, 0.02489088f, 
    0.01911933f, 0.02029450f, -0.00113852f, -0.04392074f, 0.03282113f, -0.00584364f, 0.01224442f, -0.02344763f, 
    -0.02522533f, -0.02379717f, -0.00353299f, -0.01319853f, -0.03177727f, -0.00065692f, -0.01658692f, 0.01598083f, 
    -0.01095164f, -0.01039577f, -0.03514152f, 0.01167665f, -0.00136085f, -0.00550099f, 0.01229192f, 0.01294633f, 
    0.00618245f, 0.01345136f, -0.03574384f, 0.03231989f, 0.01661553f, -0.01999458f, -0.02805321f, -0.01444070f, 
    -0.00427094f, -0.03337698f, 0.01015264f, 0.02627013f, -0.00575618f, -0.03263847f, -0.02112144f, -0.03046704f, 
    -0.03137860f, -0.00603149f, -0.02137490f, -0.03868093f, 0.00895543f, 0.00747849f, -0.01326441f, 0.00164021f, 
    -0.03002023f, 0.01911744f, 0.01346635f, 0.02698605f, -0.00822547f, -0.03235385f, -0.01487756f, 0.01331201f, 
    0.02326903f, 0.03384778f, 0.01966011f, 0.01363065f, -0.02286021f, 0.00284189f, 0.00061551f, -0.03491757f, 
    -0.00707552f, -0.03088678f, -0.04199345f, 0.02540183f, -0.03051524f, 0.01728445f, -0.01905546f, 0.02647003f, 
    -0.01399753f, -0.04262656f, -0.00772245f, 0.02082560f, 0.03872907f, -0.01341276f, 0.01067274f, -0.01949579f, 
    0.01925878f, 0.01985790f, 0.00799711f, -0.00020544f, 0.00756556f, -0.02349966f, 0.01792483f, 0.02247622f, 
    -0.02354072f, -0.03504619f, -0.02075478f, -0.01656733f, 0.03030658f, 0.00817181f, -0.01120656f, -0.03351535f, 
    0.03287727f, -0.01432225f, -0.02225255f, -0.01648362f, -0.03480946f, 0.01476098f, -0.03394340f, -0.03186738f, 
    -0.01618485f, 0.03465679f, -0.01089633f, 0.02839853f, 0.02202859f, -0.03372635f, -0.00263238f, -0.02238042f, 
    -0.00528702f, -0.01737138f, 0.01016554f, 0.02252206f, -0.01488770f, -0.04046694f, -0.03803587f, 0.02631164f, 
    0.02197296f, 0.01853708f, 0.02372993f, 0.01652374f, 0.00354601f, -0.03785953f, -0.01601584f, 0.01184660f, 
    -0.01896862f, 0.01155455f, 0.00892396f, -0.03540034f, 0.00582009f, -0.03945311f, -0.01987622f, 0.02416831f, 
    -0.01311263f, -0.02553473f, -0.01521959f, 0.01385169f, 0.00388485f, 0.00326613f, -0.00129809f, 0.00488768f, 
    0.02194270f, -0.03232690f, 0.02391752f, 0.01991330f, -0.00971033f, 0.01868682f, 0.02753997f, 0.01027432f, 
    0.02975341f, -0.01697255f, 0.00093369f, 0.01866312f, -0.00806725f, -0.03447460f, 0.01375631f, 0.02143639f, 
    0.03263918f, -0.03310756f, -0.01714702f, 0.01798854f, 0.01247843f, -0.00719506f, 0.02253613f, -0.01846687f, 
    -0.01173198f, 0.00157884f, 0.01465486f, -0.02152332f, -0.02030160f, -0.00277371f, 0.02088800f, -0.03549644f, 
    0.01953771f, 0.01281394f, 0.01218110f, -0.00859241f, -0.04005622f, 0.01987444f, 0.02691648f, -0.00404666f, 
    0.01261861f, -0.00230497f, 0.00641722f, 0.00251874f, 0.00783844f, 0.02795530f, -0.01946478f, -0.03184104f, 
    -0.03531242f, 0.02386811f, -0.01623309f, 0.01207196f, 0.02418381f, -0.02154203f, 0.00504416f, -0.01794965f, 
    -0.02917515f, -0.04173088f, -0.02855985f, 0.00477616f, 0.01395707f, -0.01061571f, -0.01730737f, -0.01527459f, 
    -0.02537823f, 0.00805839f, -0.03242347f, -0.01468020f, -0.01937175f, 0.02476695f, -0.00064234f, -0.01412066f, 
    0.02285397f, -0.02780017f, -0.02974605f, -0.03274827f, 0.02986849f, 0.02659292f, -0.00340091f, -0.00119130f, 
    0.01103574f, 0.01020548f, -0.02159461f, 0.00876803f, 0.02777313f, 0.01050129f, -0.00194728f, 0.01510611f, 
    -0.04198105f, 0.00936874f, -0.01253061f, 0.00560742f, 0.02697157f, -0.03370449f, -0.03737320f, 0.02949314f, 
    0.00686477f, 0.01631086f, -0.00915000f, 0.01135421f, 0.02984575f, 0.01605636f, -0.02650746f, 0.02358202f, 
    0.01383004f, -0.00471132f, -0.03629364f, 0.02966858f, -0.01368930f, 0.01796694f, -0.02797223f, 0.02489446f, 
    -0.03280195f, 0.02756654f, -0.01155587f, 0.01863931f, -0.01725960f, 0.00576135f, -0.00044872f, -0.03633140f, 
    -0.01963690f, -0.02570592f, -0.00707310f, -0.00351645f, 0.00765790f, 0.00822900f, 0.01185270f, -0.03423505f, 
    0.01280216f, -0.02718945f, -0.01880003f, -0.01978810f, 0.04174172f, -0.00656721f, -0.04279228f, 0.01854534f, 
    -0.01624252f, 0.00354766f, 0.00771935f, -0.02922163f, -0.01800653f, -0.01772586f, -0.02126052f, 0.00437245f, 
    -0.01364203f, 0.01961331f, -0.03668505f, -0.00236125f, -0.03947828f, -0.01123876f, -0.04278620f, -0.03786759f, 
    -0.00219672f, 0.01218643f, -0.00894013f, -0.01339788f, -0.03320619f, 0.01606935f, -0.00805359f, -0.02927872f, 
    -0.03006072f, 0.00284588f, -0.01540728f, 0.01943913f, 0.01236651f, 0.00365670f, 0.01923023f, -0.02450915f, 
    0.02878596f, -0.01494443f, 0.00674976f, 0.01284329f, -0.01013006f, -0.04346039f, -0.00564610f, -0.02265463f, 
    0.02102211f, 0.00743916f, 0.02799938f, -0.01665100f, -0.01666997f, -0.00339019f, -0.03075489f, -0.01189908f, 
    -0.00112782f, -0.00221265f, -0.01611670f, 0.01959773f, 0.01975534f, -0.00214888f, 0.01872787f, -0.03497736f, 
    -0.01594100f, -0.02676180f, -0.02805816f, -0.03269590f, -0.03615473f, 0.01842454f, -0.01684558f, -0.02058607f, 
    0.01147582f, -0.04368481f, -0.04534065f, -0.01879134f, -0.01696461f, 0.00856482f, 0.03343845f, 0.00337788f, 
    -0.01772290f, 0.01897057f, -0.02964537f, 0.01810039f, -0.02057444f, -0.03908617f, 0.01772266f, -0.03500713f, 
    0.00819774f, 0.00092382f, 0.02208893f, -0.02436790f, 0.03558947f, 0.02718135f, -0.00748065f, 0.01609389f, 
    -0.04457971f, -0.00596228f, -0.03315223f, 0.03564742f, -0.03734796f, 0.01529726f, -0.01927944f, 0.03010790f, 
    -0.01275875f, -0.02801803f, -0.02288191f, -0.01357100f, -0.02962543f, 0.01887316f, -0.00931501f, 0.01145437f, 
    -0.00595975f, -0.01756960f, 0.02560136f, -0.01214194f, -0.02866628f, 0.03642186f, 0.01397518f, -0.00250512f, 
    0.02896649f, 0.01918671f, 0.00968037f, 0.02374570f, -0.00045542f, -0.02759693f, -0.03648060f, -0.02257821f, 
    0.01858415f, 0.00260835f, 0.02569735f, -0.03480479f, -0.04637580f, 0.02355343f, -0.00879646f, -0.02674106f, 
    -0.00006677f, -0.01857153f, -0.02738996f, -0.01422012f, -0.00635861f, -0.02989494f, 0.01927783f, -0.03052688f, 
    -0.01062656f, 0.01747163f, -0.00803362f, -0.01344890f, -0.03657204f, -0.01994758f, 0.01227055f, 0.00757780f, 
    0.01591746f, 0.00308178f, 0.01667328f, -0.01834655f, 0.02641979f, 0.00720185f, -0.01729323f, -0.02195118f, 
    -0.01860321f, -0.01483081f, 0.01617445f, -0.00275152f, 0.01459676f, 0.02117442f, -0.03701159f, 0.02796443f, 
    0.01175521f, -0.01537698f, 0.00444247f, -0.02091753f, -0.02477672f, 0.00879159f, 0.01732333f, -0.04039655f, 
    0.02934432f, -0.00830539f, -0.01792531f, -0.01475889f, 0.00033655f, -0.00349372f, -0.03285081f, -0.04219090f, 
    -0.03763897f, -0.01131095f, -0.04370935f, -0.02614963f, -0.03012421f, 0.01831065f, -0.03797496f, -0.03227200f, 
    -0.01665060f, 0.01481067f, 0.02135040f, 0.00636072f, -0.00879145f, 0.00162296f, -0.00909873f, 0.01576704f, 
    0.01434583f, -0.02273257f, -0.03637001f, 0.00797616f, -0.00431172f, 0.03372667f, -0.01025578f, 0.00880207f, 
    0.01469366f, -0.02802235f, 0.03010022f, -0.00548785f, 0.00517587f, 0.02981390f, 0.02836249f, -0.01660473f, 
    -0.01287993f, -0.01320119f, 0.02416204f, -0.01553631f, 0.02948380f, 0.00333717f, -0.01528727f, -0.04471587f, 
    -0.00145713f, 0.01963537f, -0.01655263f, 0.00981531f, 0.01071981f, 0.00338741f, -0.03481977f, -0.03506275f, 
    0.01161709f, -0.01537401f, 0.01403531f, 0.02590950f, -0.02779808f, -0.00170945f, -0.00635383f, -0.03285114f, 
    0.00376042f, 0.00606413f, -0.03138814f, -0.02040342f, 0.00323979f, -0.02423359f, 0.01252182f, -0.01078153f, 
    -0.03558228f, -0.03023902f, 0.01272763f, 0.01244797f, -0.03382077f, -0.02360176f, 0.01949183f, 0.02568004f, 
    0.01657042f, 0.03785367f, 0.03544674f, -0.03355369f, 0.00180810f, -0.03015459f, 0.02540582f, 0.02331194f, 
    -0.02525937f, -0.01199243f, -0.03814065f, -0.00730603f, 0.03212896f, 0.01718846f, -0.02768342f, 0.02830520f, 
    0.02191300f, -0.01849596f, 0.03614497f, 0.02116216f, 0.01322803f, 0.00318200f, -0.00066122f, -0.01877429f, 
    -0.01470988f, -0.02369377f, 0.00112542f, -0.00212161f, 0.02864370f, -0.00474384f, -0.04038269f, -0.00664018f, 
    -0.02584847f, 0.01367678f, 0.00642178f, 0.02056762f, -0.03213388f, 0.02797592f, -0.02625735f, -0.02401268f, 
    -0.03691528f, -0.00492171f, -0.02864433f, 0.02815330f, -0.01572997f, -0.03516779f, -0.00133503f, -0.00763415f, 
    0.02027143f, 0.00504492f, 0.00464083f, -0.03699280f, 0.02123174f, -0.02135912f, -0.02718797f, 0.03299297f, 
    0.00594322f, 0.00310092f, 0.01190391f, 0.01464655f, 0.02496349f, 0.02359947f, -0.02128893f, -0.02991056f, 
    -0.01798115f, 0.03154920f, -0.00137171f, -0.03239563f, 0.02775956f, -0.01910358f, -0.03570297f, -0.00488101f, 
    0.02351683f, 0.01920895f, -0.01392816f, 0.02242800f, -0.02078445f, -0.00980239f, 0.02367459f, -0.01803142f, 
    -0.03952786f, 0.00627195f, -0.00613773f, -0.01453521f, -0.03589811f, 0.02279889f, -0.01891947f, -0.00671160f, 
    -0.04814344f, 0.01716230f, 0.02624278f, 0.00161368f, 0.00612536f, -0.01059127f, -0.03859823f, -0.03202283f, 
    -0.02349788f, 0.03275606f, -0.01314204f, -0.01391975f, -0.01764150f, 0.00529022f, -0.02662322f, -0.01849656f, 
    -0.02726503f, -0.03643121f, 0.00241879f, 0.01006661f, 0.00242924f, -0.02668531f, 0.02119983f, 0.03473730f, 
    0.02910135f, 0.01936106f, -0.01952920f, -0.01334881f, 0.00850039f, -0.01682472f, -0.00516681f, 0.03868987f, 
    -0.02789472f, 0.00054609f, 0.02467654f, -0.02432026f, 0.00635142f, -0.00128106f, 0.00298123f, 0.02506529f, 
    -0.01118016f, 0.02174235f, -0.00184488f, 0.00343890f, 0.01480041f, -0.00150837f, -0.01252908f, 0.02967720f, 
    0.01200552f, 0.02622219f, -0.03890897f, -0.01104638f, -0.01747568f, 0.01356640f, 0.03071829f, -0.02367192f, 
    0.00514539f, -0.00589550f, 0.01613043f, 0.00089299f, 0.00609470f, 0.01892253f, 0.01309900f, 0.02692142f, 
    -0.03701874f, 0.01339958f, 0.02913996f, -0.01133091f, 0.02035672f, -0.00961832f, 0.00384879f, 0.00889577f, 
    -0.00446249f, 0.02088165f, 0.01763846f, 0.01136489f, -0.02862648f, 0.01642910f, -0.02434160f, -0.02406155f, 
    -0.02683020f, 0.03015501f, 0.01798522f, -0.03689934f, 0.00412927f, 0.02789126f, -0.02621458f, -0.03427524f, 
    0.02697552f, 0.00858838f, -0.03139066f, -0.00072924f, 0.02031552f, 0.03028703f, 0.00404810f, 0.01542686f, 
    0.01192874f, -0.00208556f, 0.00634140f, -0.01379128f, -0.02164342f, 0.02418105f, -0.02217813f, 0.02150303f, 
    0.03087812f, -0.01561765f, 0.02884006f, -0.03904970f, 0.01806324f, -0.00892256f, 0.01579875f, 0.00366772f, 
    0.00383471f, 0.00153077f, -0.04349252f, -0.02469542f, 0.02886936f, -0.02515179f, 0.02500062f, 0.02698505f, 
    -0.02201070f, 0.00321395f, -0.02936747f, 0.01520021f, -0.03948466f, 0.03392401f, 0.00604538f, -0.00138458f, 
    0.01862895f, 0.01111771f, -0.01302500f, -0.01706518f, -0.00148821f, -0.02136270f, 0.02927636f, -0.01627872f, 
    0.02951323f, 0.00238444f, 0.02816786f, 0.02974096f, 0.02381887f, -0.00629797f, -0.01329659f, -0.03764560f, 
    -0.00702683f, 0.03966923f, 0.02445007f, 0.02171932f, -0.01224659f, 0.02806156f, -0.01739116f, 0.00291191f, 
    0.02084072f, -0.03626754f, 0.02076779f, 0.01026689f, 0.02152009f, -0.01648733f, -0.04240312f, -0.04246303f, 
    -0.04667024f, -0.01263666f, -0.02648617f, 0.01719807f, -0.04254816f, 0.01149434f, 0.02608263f, 0.02189716f, 
    -0.03230576f, 0.00121515f, -0.03108083f, -0.02340991f, 0.01099849f, -0.03999891f, 0.01173173f, -0.04828005f, 
    0.02777494f, -0.01793921f, -0.01589368f, -0.03212230f, -0.00594377f, -0.02656634f, -0.03477232f, -0.02621546f, 
    -0.04315482f, -0.00231166f, 0.02788947f, -0.02108143f, -0.00990112f, -0.02598524f, 0.03868457f, 0.02583834f, 
    -0.01791598f, 0.00800397f, 0.00906993f, 0.03228981f, -0.02363232f, 0.01080338f, -0.01867248f, -0.03446756f, 
    -0.03856948f, 0.01988778f, -0.01434312f, 0.02007336f, 0.01952071f, -0.00344945f, 0.01333265f, 0.01344775f, 
    0.02621513f, -0.00222568f, -0.02289455f, -0.03415434f, 0.02512016f, -0.01940733f, 0.03552558f, 0.00717877f, 
    -0.01716748f, 0.02296961f, 0.00526858f, 0.01095748f, 0.00798033f, -0.00754551f, 0.02847744f, 0.01207046f, 
    0.01800034f, -0.01679090f, -0.00905897f, 0.01123182f, 0.01105667f, -0.00841616f, -0.01170002f, -0.03810936f, 
    0.00398310f, 0.01939048f, -0.00920074f, 0.01761594f, -0.00989327f, 0.03021209f, -0.00884746f, -0.01147413f, 
    -0.03618833f, -0.02823064f, -0.02906601f, -0.01050480f, -0.01534584f, -0.02201720f, -0.01211932f, -0.00204451f, 
    -0.01151042f, -0.00598126f, -0.04158514f, -0.03616061f, -0.03197250f, -0.02910393f, -0.00764580f, -0.02021985f, 
    -0.02149556f, -0.03103070f, 0.01843871f, 0.02224021f, 0.01238845f, -0.00070570f, 0.02990128f, -0.01377206f, 
    -0.01857968f, -0.00926120f, 0.00922589f, -0.02964417f, -0.02119847f, -0.00340393f, -0.01507575f, -0.00262069f, 
    0.01808423f, 0.01700909f, 0.02924828f, 0.01803184f, -0.02660472f, -0.02406392f, 0.01463353f, -0.00589300f, 
    0.01262735f, 0.03257060f, -0.00428153f, -0.00264396f, 0.02420824f, 0.00833116f, -0.01972184f, -0.01490274f, 
    0.03059513f, -0.02384192f, 0.01532454f, -0.02224145f, -0.02345958f, 0.03135953f, -0.02013351f, -0.01344962f, 
    -0.02017317f, -0.01308589f, -0.01890777f, -0.01879662f, 0.01714541f, -0.00032000f, 0.02525173f, -0.01217206f, 
    0.02986337f, -0.00119208f, -0.03300532f, -0.00592561f, -0.03641621f, -0.01610752f, 0.00076921f, 0.01060479f, 
    -0.00202918f, 0.03449129f, -0.04130600f, -0.02017369f, 0.01996669f, 0.02478052f, 0.00380549f, -0.02183516f, 
    0.00697610f, -0.02739253f, -0.02192539f, -0.02093052f, 0.01720169f, -0.02693143f, -0.00485995f, 0.01387473f, 
    0.01029660f, -0.01687562f, -0.00435684f, 0.02114191f, 0.02172709f, 0.01479475f, -0.01565688f, -0.00634274f, 
    -0.02648116f, 0.00160822f, 0.01529959f, 0.00171959f, 0.01937651f, -0.03745672f, 0.03463607f, 0.01074628f, 
    0.01835305f, -0.03431045f, -0.04072795f, 0.00545317f, -0.02712870f, -0.03343206f, -0.03603569f, -0.02773342f, 
    -0.01818724f, -0.00568892f, -0.02312165f, -0.02364878f, 0.02802587f, 0.03100510f, 0.01215437f, 0.00584244f, 
    -0.00016792f, 0.00090872f, -0.01204822f, -0.02362454f, 0.00972188f, -0.01861621f, -0.02569257f, 0.03021380f, 
    0.00010883f, -0.01903001f, -0.01238816f, 0.02599610f, -0.03467006f, -0.02971810f, -0.03101561f, -0.01031057f, 
    0.00895357f, 0.01054466f, 0.01044707f, 0.02329418f, -0.02926052f, 0.03234355f, -0.00990128f, -0.01773793f, 
    -0.00697425f, 0.00486309f, -0.03156330f, 0.00074050f, 0.00019410f, 0.00309340f, -0.02529951f, 0.01850150f, 
    -0.00241271f, -0.02744994f, 0.01805367f, 0.01962445f, -0.00967517f, 0.00048114f, -0.00648472f, 0.02109249f, 
    0.00471118f, 0.03241832f, -0.00458860f, -0.01792718f, 0.00037631f, -0.01640149f, -0.00371779f, -0.02762327f, 
    0.00905969f, -0.01667995f, -0.03599536f, 0.02192983f, -0.03076564f, -0.01774448f, -0.00830311f, 0.03195732f, 
    0.02458489f, 0.00900686f, 0.03657170f, -0.00160131f, -0.00940299f, 0.00767843f, -0.02225481f, 0.01542943f, 
    0.02081725f, -0.01735864f, 0.02943382f, -0.01308662f, 0.00296946f, -0.00308168f, -0.01390833f, -0.01669419f, 
    -0.02018134f, -0.02835117f, 0.03253927f, 0.02303309f, 0.00165520f, -0.00690837f, -0.01546717f, -0.00069986f, 
    -0.01902669f, 0.02673958f, 0.01156518f, -0.00340569f, -0.00925753f, 0.01412137f, -0.00526786f, 0.01104904f, 
    0.02710124f, -0.03304847f, -0.00880635f, 0.02010003f, -0.03842040f, -0.01227539f, -0.02109334f, -0.03309036f, 
    0.02947439f, 0.00844136f, -0.01324465f, -0.01118275f, -0.04784051f, 0.00544286f, 0.03300228f, -0.01569660f, 
    -0.01311871f, -0.03510523f, -0.00506597f, -0.02948926f, -0.00895114f, -0.01910091f, -0.00663263f, -0.03501709f, 
    -0.04350306f, 0.00313995f, -0.00805542f, 0.03339886f, -0.02413257f, -0.01221580f, -0.02513149f, 0.01146611f, 
    -0.02572689f, 0.01289571f, 0.00759122f, -0.03145644f, -0.02407618f, -0.02212376f, -0.03504071f, -0.02499445f, 
    -0.02731630f, 0.02083253f, 0.01021079f, -0.01745240f, -0.00413767f, -0.02464257f, -0.00098223f, -0.04660241f, 
    0.02736226f, 0.03135370f, -0.01646316f, -0.01313431f, -0.00718732f, -0.02679106f, 0.01231732f, -0.02693925f, 
    0.01588067f, 0.00592826f, -0.00128741f, 0.01053698f, -0.03130273f, -0.01892339f, 0.00700001f, 0.03921827f, 
    -0.01121669f, -0.01659609f, 0.00705050f, -0.02386962f, -0.03005989f, -0.02392076f, 0.01299885f, 0.03710566f, 
    0.01878841f, -0.02236429f, 0.02191840f, 0.02800165f, 0.00317589f, 0.02451113f, 0.00699863f, 0.01392766f, 
    -0.01715384f, -0.02141627f, -0.00870044f, -0.00483011f, -0.03157025f, -0.01235624f, -0.00497096f, -0.01643054f, 
    0.01654581f, 0.00358739f, -0.01592037f, 0.01372231f, 0.01036054f, -0.03065348f, -0.02094572f, 0.01336537f, 
    0.00631122f, -0.01560943f, 0.03351979f, 0.00263677f, 0.01894336f, 0.00942728f, -0.02462826f, -0.01472337f, 
    0.00681273f, -0.02432641f, -0.03692943f, 0.03627515f, -0.04224524f, 0.02206823f, -0.00229468f, -0.02069800f, 
    0.01652450f, 0.01831490f, -0.00142184f, -0.01224640f, -0.02033004f, -0.00464613f, -0.02572303f, -0.02845264f, 
    -0.03579814f, -0.00384376f, 0.01044767f, 0.01785684f, -0.03147036f, 0.02231358f, -0.02000651f, 0.01632773f, 
    -0.00156800f, 0.00183482f, 0.00383292f, 0.03147241f, -0.04565795f, -0.04229105f, 0.00824361f, -0.03106863f, 
    -0.03942742f, -0.01136479f, -0.01837242f, -0.03003958f, 0.00094082f, -0.00487892f, -0.03266895f, -0.02356306f, 
    0.01462082f, -0.00289292f, -0.02677190f, 0.01914885f, 0.00735760f, 0.01098144f, -0.00925244f, -0.02229375f, 
    0.03012353f, -0.03997749f, -0.00927895f, -0.00710722f, -0.03084569f, -0.04456066f, -0.01477543f, 0.01654459f, 
    -0.03085868f, -0.01811256f, -0.00647343f, -0.03358610f, 0.01875872f, -0.03848596f, -0.01667864f, -0.01094317f, 
    -0.01294295f, -0.03499185f, 0.02170655f, 0.02109962f, 0.03064962f, -0.03134833f, -0.01009469f, 0.02787623f, 
    0.02656739f, -0.02934409f, -0.02633373f, -0.01207295f, 0.01860948f, -0.00480900f, -0.03908796f, 0.02241718f, 
    0.01925853f, 0.00578062f, 0.01301166f, -0.02791156f, 0.03135571f, 0.01649411f, -0.03510289f, 0.02478379f, 
    -0.02060373f, -0.03146277f, -0.02857124f, -0.03616004f, 0.00248736f, 0.02956741f, -0.03389441f, -0.02866984f, 
    0.02693951f, -0.03770297f, -0.01590444f, 0.01999165f, 0.01680641f, 0.00556101f, -0.02150581f, 0.00223228f, 
    0.02483172f, 0.02778910f, 0.00699610f, -0.02117009f, -0.01665370f, 0.00512525f, -0.02394016f, 0.02060488f, 
    -0.00133068f, 0.00257152f, -0.02609180f, -0.00147308f, 0.01564759f, 0.01446945f, -0.01837656f, 0.00771690f, 
    0.00102732f, 0.00617074f, 0.01284953f, 0.01891015f, -0.02115843f, 0.01441779f, 0.01079076f, -0.01903711f, 
    -0.03495986f, 0.00170739f, 0.00359340f, 0.01858934f, 0.02903276f, 0.00097443f, 0.00392766f, -0.00068630f, 
    0.00102422f, -0.00203709f, 0.02157675f, -0.03045272f, 0.02632300f, 0.01524800f, -0.00309218f, 0.02486619f, 
    -0.00659147f, 0.00473590f, -0.02535852f, 0.01705669f, -0.02214010f, -0.02379751f, 0.02683964f, -0.03306706f, 
    -0.01482977f, 0.02491177f, -0.03486864f, -0.03544610f, 0.02534240f, 0.00894319f, 0.03370868f, -0.01286777f, 
    -0.04547862f, -0.03816597f, 0.01631133f, -0.04269134f, 0.00871083f, 0.01543002f, 0.00503160f, 0.01829667f, 
    -0.03990543f, 0.01622645f, 0.02846049f, 0.00135478f, -0.01851608f, -0.00490243f, 0.02320194f, -0.02530221f, 
    -0.01638635f, -0.03294198f, 0.02437956f, 0.01407051f, 0.01003667f, 0.02947292f, 0.02239912f, 0.02886553f, 
    0.03110093f, 0.03409592f, -0.04797911f, 0.02859672f, 0.00874013f, -0.02453535f, 0.02688751f, 0.00743893f, 
    -0.00664603f, 0.02537902f, -0.01491745f, -0.00658447f, -0.01789124f, -0.00187031f, -0.02714317f, -0.03278498f, 
    -0.03194489f, 0.02928539f, 0.01248619f, 0.01266666f, 0.02572404f, -0.00692417f, -0.03046703f, -0.02758026f, 
    0.01595696f, -0.02119642f, 0.02823018f, 0.01583835f, -0.03179735f, 0.01217672f, -0.01284326f, -0.00113771f, 
    -0.00453876f, -0.01135660f, 0.00042293f, 0.00213588f, 0.04038679f, 0.03491456f, -0.02558221f, -0.00526638f, 
    0.00245027f, -0.02896129f, 0.01713332f, 0.02683643f, -0.03606502f, -0.00571806f, -0.02976508f, -0.03975374f, 
    -0.02765548f, -0.02954258f, 0.00089560f, -0.01542202f, -0.01992667f, 0.00003959f, 0.00495246f, -0.00834723f, 
    -0.00287526f, -0.02537931f, -0.04669224f, 0.00376232f, -0.01927248f, -0.00092452f, -0.00567309f, 0.00812631f, 
    -0.00265915f, 0.00754989f, -0.02648030f, -0.03385661f, 0.01672371f, -0.02947369f, -0.03933641f, -0.02967513f, 
    -0.02665204f, -0.00211381f, -0.01765933f, -0.01537319f, -0.03848587f, -0.01984365f, -0.02598034f, 0.01786209f, 
    0.00236780f, 0.00821335f, 0.00832164f, 0.00139678f, 0.00748717f, 0.00201984f, -0.00425363f, 0.00547099f, 
    -0.01143470f, 0.01145728f, 0.01145650f, -0.03498606f, -0.02838608f, 0.02201081f, -0.00452406f, -0.03621591f, 
    -0.01098515f, 0.00315925f, 0.03297833f, 0.03091316f, -0.02477407f, -0.03815651f, -0.01221700f, 0.00480207f, 
    0.02634233f, -0.03503719f, -0.02558388f, 0.00952973f, -0.02401936f, 0.01553256f, 0.00206340f, -0.02704864f, 
    -0.01036407f, 0.02701320f, -0.02948501f, -0.03203949f, 0.00223695f, -0.02350722f, 0.02266638f, -0.02470038f, 
    0.00622385f, 0.00048002f, 0.00669645f, -0.00896025f, -0.02811093f, 0.01241830f, -0.02734502f, 0.01288346f, 
    -0.00954596f, -0.01729182f, 0.02583926f, 0.02569826f, 0.00667383f, 0.01951655f, -0.02467335f, 0.02489987f, 
    0.00083708f, -0.01149734f, -0.03145348f, -0.00985734f, 0.02490951f, 0.01432599f, -0.00879909f, -0.00920672f, 
    -0.03588348f, 0.00447865f, -0.01217914f, -0.04597518f, 0.00328844f, -0.03663638f, 0.00843040f, 0.00156527f, 
    0.01450286f, -0.02144718f, 0.00912851f, 0.02280373f, -0.01547122f, -0.02850150f, -0.00548912f, -0.00440279f, 
    -0.01176746f, -0.02932335f, -0.01832727f, -0.03703558f, 0.01950118f, 0.02816532f, 0.01347143f, 0.03113293f, 
    -0.04085632f, 0.03112423f, -0.01875700f, 0.03012082f, 0.02302304f, 0.02788168f, -0.00519637f, -0.00507265f, 
    -0.02205571f, 0.01440102f, -0.02396614f, 0.00984563f, 0.02047845f, -0.03327819f, 0.01874834f, -0.00181973f, 
    0.03482627f, 0.01745654f, 0.01558367f, -0.01931470f, -0.03346171f, -0.01481549f, -0.00625753f, -0.03301187f, 
    0.03063292f, -0.03622716f, -0.03183793f, -0.03728468f, 0.00399182f, -0.00345429f, -0.01880408f, 0.00338444f, 
    0.03062090f, -0.02056174f, 0.00216992f, -0.03765317f, 0.02278313f, 0.01455262f, 0.00677072f, -0.04227658f, 
    -0.03052135f, -0.03191715f, -0.02681039f, -0.03691370f, -0.03241624f, -0.01428567f, -0.00670374f, 0.02273004f, 
    0.00719846f, -0.01837816f, 0.00712812f, 0.00134879f, -0.00279607f, 0.02212519f, 0.00036562f, 0.02473424f, 
    -0.01566440f, -0.00760598f, 0.00282398f, -0.00484377f, -0.01552868f, 0.01650622f, 0.00334961f, -0.03123731f, 
    -0.00349225f, 0.03144583f, -0.02957468f, -0.00853394f, -0.03413859f, -0.03830442f, 0.01609000f, -0.00269139f, 
    0.01111224f, -0.00344198f, 0.00716214f, 0.01823069f, -0.02950826f, 0.01737366f, 0.01151325f, -0.02516139f, 
    0.01923602f, 0.01035556f, 0.02764537f, 0.02028548f, 0.00778789f, -0.03381639f, 0.01431513f, 0.01555231f, 
    0.03233215f, 0.00161678f, 0.02830362f, -0.00926632f, 0.02530458f, 0.02882297f, -0.04414575f, -0.01223827f, 
    -0.00796864f, -0.00232368f, -0.03853191f, -0.00985383f, 0.01526667f, 0.03317701f, -0.02895227f, -0.02621697f, 
    0.01755103f, -0.02344087f, -0.03466550f, 0.00726912f, 0.00817551f, 0.02172672f, 0.00814951f, -0.02118517f, 
    0.03071613f, 0.03253233f, 0.01872800f, -0.02389773f, 0.00596350f, -0.03998307f, -0.03336696f, 0.01402381f, 
    0.02530925f, 0.00330088f, -0.01830414f, 0.01038947f, -0.01730034f, -0.03561627f, -0.01695523f, -0.03188120f, 
    -0.03611201f, 0.00904073f, -0.02287343f, -0.01968432f, 0.01337729f, -0.00791214f, 0.00988973f, -0.03490886f, 
    0.01361333f, 0.02231515f, 0.02751213f, -0.03885997f, -0.02790825f, 0.02131315f, -0.01751944f, -0.02055720f, 
    -0.02336487f, 0.02375963f, 0.03444568f, 0.00557064f, 0.01786625f, 0.01107716f, 0.02767630f, -0.03792173f, 
    0.01806104f, -0.00401903f, -0.00016092f, -0.03246493f, -0.00860439f, 0.02711949f, 0.02633370f, -0.03698098f, 
    -0.01534905f, -0.01690109f, -0.01178122f, 0.03197384f, 0.01119017f, -0.00250656f, -0.04202329f, 0.03179242f, 
    0.01131714f, -0.03149097f, 0.01462696f, -0.03216257f, 0.00810097f, 0.01191481f, 0.00388567f, -0.03758885f, 
    -0.00814569f, -0.00368489f, -0.03741442f, -0.00937209f, 0.01446855f, -0.02701198f, -0.03423262f, -0.04495631f, 
    -0.04548883f, 0.02250031f, -0.00787636f, -0.02880041f, -0.00688501f, 0.00229270f, 0.02411888f, -0.03521245f, 
    -0.03491514f, -0.01290029f, -0.01607666f, -0.02001650f, -0.00108185f, 0.00744870f, 0.01174235f, -0.01987992f, 
    0.01371451f, 0.00888945f, 0.00761357f, -0.00883429f, -0.00724374f, -0.03070625f, 0.03104792f, -0.01871407f, 
    -0.01312019f, 0.00939337f, 0.01891942f, -0.04058061f, 0.00081638f, -0.02836325f, -0.02798022f, 0.00996944f, 
    -0.02655779f, 0.00062971f, 0.03137276f, -0.00603683f, 0.02486565f, -0.04029692f, -0.01364898f, -0.02769801f, 
    -0.00550894f, -0.00781529f, 0.00554580f, -0.01972950f, -0.00812571f, -0.03371064f, 0.02744624f, 0.00778830f, 
    0.02944794f, 0.00355654f, 0.00794985f, -0.03741305f, 0.02619191f, 0.01602665f, 0.02959906f, -0.01578443f, 
    -0.02109690f, -0.00696110f, -0.03164862f, -0.03757829f, -0.01746638f, -0.00271878f, 0.01722498f, -0.03314350f, 
    0.01977327f, -0.01178682f, 0.01405811f, -0.00925845f, -0.02950106f, -0.02166303f, 0.02531567f, 0.00533646f, 
    -0.02590752f, 0.00592651f, 0.02346436f, 0.01549374f, 0.00903324f, 0.02383005f, -0.02911272f, -0.00838401f, 
    0.00947628f, 0.02773396f, 0.02626696f, 0.01084418f, -0.02133296f, 0.01208024f, 0.01024749f, 0.00674221f, 
    -0.00836891f, 0.02380992f, 0.00558280f, -0.02498420f, 0.00698873f, 0.02876416f, 0.00821963f, 0.01479428f, 
    0.02566464f, -0.04583913f, 0.01765810f, 0.02439098f, -0.00034696f, 0.02784308f, 0.02539431f, -0.03665002f, 
    -0.00572345f, -0.02646883f, 0.00762849f, -0.01984981f, 0.00114441f, 0.02323917f, -0.02365631f, 0.00093063f, 
    -0.03896965f, 0.02722624f, 0.01690514f, 0.01647429f, -0.04125588f, -0.01449035f, 0.01660911f, 0.03155391f, 
    -0.03300372f, 0.01540650f, -0.01056976f, -0.01299359f, 0.03260175f, -0.02429191f, 0.01280354f, 0.00770348f, 
    -0.01195599f, -0.02624417f, -0.02013187f, -0.00950427f, -0.00404438f, -0.03645008f, 0.01250032f, -0.00787919f, 
    0.00242910f, 0.01715367f, -0.02383056f, 0.00424046f, -0.01815823f, -0.02519196f, 0.00880436f, -0.00345353f, 
    -0.02576115f, 0.01353068f, -0.04186340f, 0.00549272f, 0.00516558f, 0.03258866f, -0.02938695f, -0.01364703f, 
    -0.02214503f, -0.03584348f, 0.00205750f, -0.02521131f, -0.00862274f, 0.02733301f, 0.02360740f, -0.00572899f, 
    0.03235239f, 0.00726357f, -0.02377247f, -0.01737966f, -0.02554005f, 0.03154508f, -0.03212137f, -0.01071860f, 
    0.03179935f, 0.01454921f, -0.03362915f, 0.02653019f, 0.01665093f, -0.03633061f, 0.01310787f, -0.02052411f, 
    0.00125143f, 0.00424342f, -0.01000100f, 0.00217428f, -0.03481054f, -0.00060450f, -0.03183968f, -0.00823775f, 
    0.01531195f, 0.00028600f, 0.00842151f, 0.02472503f, -0.03830386f, 0.03376985f, 0.03038142f, -0.00520698f, 
    -0.01671787f, -0.02090725f, 0.00166927f, -0.03203335f, 0.01052171f, -0.03385408f, 0.01026658f, -0.03198259f, 
    0.02242100f, -0.00546412f, -0.02547860f, -0.02840567f, 0.01455672f, -0.03622525f, -0.00991145f, 0.02976408f, 
    0.01851663f, 0.00018302f, -0.02009016f, 0.01503034f, -0.02617083f, 0.01207272f, -0.00923917f, 0.01388089f, 
    -0.02410570f, 0.02071931f, -0.00618658f, 0.01973261f, -0.03689114f, -0.02979862f, -0.03319214f, -0.02348496f, 
    0.01352344f, 0.02235261f, -0.02158706f, 0.01333617f, -0.02988521f, -0.03620082f, -0.01247183f, 0.01233906f, 
    -0.01577636f, -0.02033116f, -0.00830085f, -0.03657041f, -0.01507969f, 0.01841261f, -0.01832462f, -0.03079668f, 
    -0.01927941f, -0.02199578f, 0.00003093f, -0.01755027f, 0.02293007f, -0.01498311f, -0.00011362f, 0.01695486f, 
    -0.01439191f, -0.01905929f, -0.03735052f, -0.04208098f, 0.01893065f, -0.02224134f, -0.00823284f, 0.02005889f, 
    -0.02300555f, 0.00333677f, 0.00917426f, 0.02505414f, 0.00709055f, -0.01465175f, -0.01928166f, 0.02289844f, 
    -0.02770149f, -0.02383862f, -0.03610175f, -0.03155457f, -0.03096385f, 0.01378338f, -0.01533885f, -0.02602101f, 
    0.01919539f, -0.00063149f, 0.02258467f, 0.01697985f, 0.02188341f, -0.00804581f, -0.01262952f, -0.00985473f, 
    0.02547956f, -0.04175989f, 0.00174155f, -0.00563820f, -0.00939033f, 0.02433531f, -0.02563377f, 0.02747381f, 
    0.00785774f, -0.01407187f, 0.02242147f, 0.00521526f, -0.00420117f, -0.01463343f, 0.02428178f, 0.03456956f, 
    0.01549837f, 0.00993166f, 0.02648913f, -0.02469458f, -0.03920929f, -0.02644058f, -0.01613010f, -0.00487911f, 
    -0.03896848f, -0.00485648f, 0.01591904f, 0.00235162f, 0.02649992f, 0.02587815f, 0.02921811f, 0.00908521f, 
    -0.01836293f, 0.00964329f, -0.01497055f, 0.00859257f, -0.03588969f, -0.03695181f, -0.01254220f, 0.01170989f, 
    0.02734162f, 0.00904360f, -0.02413311f, -0.00534883f, 0.01381570f, -0.02972006f, 0.00181883f, 0.00531714f, 
    0.00970868f, -0.02497144f, 0.01505421f, -0.00203197f, -0.01810668f, 0.01006828f, 0.01287522f, -0.01359707f, 
    -0.02393320f, -0.02810911f, 0.01266838f, 0.01827296f, -0.00534827f, -0.00662446f, 0.01825443f, 0.02880942f, 
    -0.01802362f, 0.02413955f, 0.00288459f, -0.01715463f, -0.03758883f, -0.02743766f, -0.02432686f, 0.01501800f, 
    -0.01920963f, -0.01544868f, 0.02049699f, -0.02574512f, -0.03698004f, 0.02134346f, -0.00976571f, -0.02427292f, 
    -0.03076176f, -0.00645177f, 0.00060010f, -0.03319840f, 0.01368425f, -0.00430039f, -0.01253763f, 0.02017967f, 
    0.01891435f, -0.00638897f, 0.01025427f, 0.01964750f, -0.02450206f, -0.03164158f, 0.02286652f, -0.01265741f, 
    -0.03656866f, -0.00460577f, 0.02549349f, -0.02612605f, -0.00560762f, 0.03044153f, -0.00787970f, 0.00420160f, 
    0.01412375f, -0.03462747f, 0.00856723f, 0.00069254f, -0.02088473f, 0.03265750f, 0.01221623f, -0.01203486f, 
    -0.03768467f, 0.01512308f, -0.02547012f, 0.00531477f, -0.03118969f, 0.01166700f, 0.03929415f, -0.03145507f, 
    0.00254321f, -0.00689272f, -0.03498026f, 0.01676819f, 0.02921530f, -0.00961477f, -0.01482116f, 0.02167878f, 
    0.01492484f, 0.02476415f, 0.01480722f, -0.01491936f, 0.02637117f, -0.02157274f, 0.00971106f, -0.02716203f, 
    -0.00762199f, -0.01918071f, -0.02113233f, 0.00253161f, 0.02656671f, -0.02785934f, 0.00985104f, 0.02759957f, 
    0.00976342f, 0.00452006f, -0.00679658f, -0.00994275f, -0.01785942f, -0.02468350f, -0.01529955f, 0.02527456f, 
    0.02669340f, -0.02604343f, 0.01402536f, 0.02566660f, 0.01527318f, -0.01848327f, -0.03016543f, 0.01647461f, 
    0.01638344f, -0.00105981f, 0.01737310f, -0.01270554f, 0.00780733f, 0.00805842f, 0.00029542f, -0.02126527f, 
    -0.01377739f, 0.04328533f, 0.01706013f, -0.03105330f, -0.03859835f, -0.03625562f, -0.03541360f, 0.01879710f, 
    -0.01416179f, -0.02526350f, -0.00458896f, 0.01332015f, 0.02278478f, -0.01412826f, -0.00836628f, -0.01975554f, 
    0.01406251f, -0.03171968f, -0.02695691f, -0.01913819f, -0.03388555f, -0.03640242f, -0.03484470f, 0.03113207f, 
    0.03019693f, 0.00197589f, 0.00531019f, 0.01852611f, 0.02092681f, 0.02497513f, 0.00778641f, -0.00860677f, 
    0.02540025f, 0.01334101f, 0.01333718f, 0.01868382f, 0.00407925f, 0.01597066f, 0.01328598f, -0.00067033f, 
    -0.01227718f, 0.00094303f, 0.01430321f, -0.01854383f, -0.03477122f, -0.00541955f, 0.02134828f, -0.01044293f, 
    -0.03697797f, -0.01195447f, -0.00687240f, -0.03060222f, 0.00824161f, -0.01448258f, 0.01548525f, -0.01351778f, 
    -0.02031248f, 0.02665235f, 0.01000101f, 0.00284389f, 0.01687738f, 0.00288878f, -0.01582024f, -0.01202272f, 
    -0.01800135f, 0.00751268f, -0.02844463f, 0.01290673f, -0.03647706f, 0.01985535f, -0.03811970f, -0.03401176f, 
    0.01352152f, -0.02268069f, -0.01606093f, -0.00176425f, -0.00621778f, -0.01700028f, -0.02599417f, -0.01303973f, 
    0.01923016f, 0.02819967f, 0.01917480f, 0.02150119f, -0.03280314f, -0.02538609f, -0.01980620f, 0.02230430f, 
    -0.02454737f, -0.03463525f, 0.02139263f, -0.02911563f, -0.00382771f, -0.02100778f, 0.02908981f, 0.03147680f, 
    -0.02707998f, -0.01402926f, 0.01440684f, 0.01061936f, 0.01303994f, -0.01556258f, -0.01848436f, -0.02634399f, 
    -0.00339964f, 0.01559781f, 0.01453120f, -0.00049110f, -0.00912452f, 0.00579827f, 0.00135507f, -0.02394729f, 
    -0.04182173f, -0.00463663f, -0.00632794f, 0.02596291f, -0.01753771f, 0.01774604f, 0.01832775f, -0.02126925f, 
    -0.02622589f, -0.01905404f, -0.02806537f, 0.02588819f, -0.01212687f, 0.01391980f, 0.02783488f, -0.00955554f, 
    0.01201186f, -0.02984004f, 0.01374467f, -0.00789329f, -0.02328021f, -0.03574160f, -0.00486132f, 0.01713552f, 
    0.01063006f, -0.00477942f, -0.02559906f, 0.02352562f, 0.02184207f, -0.02767618f, -0.00694480f, 0.01513154f, 
    -0.01335139f, 0.01256711f, 0.02214662f, 0.01956491f, 0.02087256f, -0.03086486f, 0.00784541f, 0.02475554f, 
    -0.01263431f, 0.02313579f, -0.01054572f, -0.01926767f, -0.01344399f, -0.02102719f, 0.02259825f, 0.00036075f, 
    0.02405156f, -0.00218818f, -0.02117668f, 0.01432747f, 0.00298207f, 0.02344626f, 0.02376693f, 0.01625675f, 
    0.02329252f, 0.00230264f, -0.03203784f, -0.02090203f, -0.02832116f, -0.01070909f, -0.00341410f, -0.01492980f, 
    0.00256130f, 0.02650914f, 0.02988914f, 0.03204721f, 0.02095809f, -0.01344105f, 0.03464295f, -0.03409842f, 
    -0.02806064f, -0.01695475f, -0.01801663f, 0.00784979f, -0.02688961f, -0.00151720f, -0.00098124f, -0.01793216f, 
    -0.02144060f, -0.00606563f, 0.01023304f, -0.00599160f, -0.01179626f, -0.02721900f, 0.01633199f, 0.01460219f, 
    -0.01157058f, -0.02674374f, 0.01497485f, -0.03922104f, 0.01135704f, 0.01116785f, -0.00714517f, -0.01542317f, 
    -0.02196842f, -0.01497443f, 0.03897221f, -0.02774383f, -0.00715670f, -0.00249913f, -0.01671990f, 0.01495526f, 
    -0.02148474f, 0.00257408f, 0.01568573f, 0.00885894f, 0.01390090f, -0.03151982f, 0.01475410f, 0.00719506f, 
    -0.02257436f, -0.03081203f, -0.00172270f, -0.02534320f, 0.03190503f, 0.01953714f, -0.03014549f, -0.03301679f, 
    0.01852379f, 0.00126458f, -0.02736874f, -0.01591567f, -0.01426715f, 0.00850881f, -0.00793658f, -0.00294552f, 
    0.01201426f, 0.02025512f, -0.01754174f, -0.02434008f, -0.02081077f, -0.02697842f, 0.01746770f, -0.01791142f, 
    -0.03575411f, -0.01760633f, 0.00501678f, 0.01212568f, 0.01033870f, 0.01835551f, -0.01811015f, 0.02628532f, 
    0.02845440f, 0.02052909f, 0.00288925f, 0.00056519f, -0.02766204f, 0.02797939f, 0.01724640f, -0.03828373f, 
    0.00227889f, 0.04201180f, -0.03218548f, 0.02539018f, 0.00677072f, -0.03165061f, -0.01865159f, -0.02016137f, 
    0.01019700f, 0.01958312f, 0.00322678f, 0.01279426f, 0.00819253f, -0.00917313f, -0.03199989f, 0.00180622f, 
    -0.04128052f, 0.02987335f, -0.03000615f, 0.01052644f, -0.00704012f, -0.04150605f, 0.01235758f, -0.02972721f, 
    -0.03615412f, -0.02117772f, 0.00919212f, 0.01287762f, -0.00860951f, 0.01094109f, 0.01713672f, -0.03191897f, 
    -0.02551654f, 0.00285041f, 0.01351384f, 0.02793892f, -0.01858107f, -0.02591821f, 0.01957762f, -0.01121748f, 
    -0.01395443f, -0.02716602f, 0.01192944f, -0.02545336f, -0.01548566f, 0.01995502f, -0.02442132f, -0.00830886f, 
    0.01526385f, -0.00315153f, 0.02030467f, 0.00950244f, -0.03428518f, -0.02680136f, 0.00124769f, 0.00072144f, 
    -0.03374931f, 0.03105304f, 0.00306938f, -0.01668081f, 0.01427521f, -0.03105105f, -0.01340815f, 0.02051517f, 
    0.04159183f, 0.02022018f, -0.00102073f, 0.01570573f, -0.04044049f, 0.01935335f, -0.03095857f, -0.03296515f, 
    0.01070706f, 0.04003956f, -0.03042870f, -0.03810521f, -0.00814466f, 0.00322101f, -0.03184843f, 0.01158911f, 
    -0.02435808f, -0.02546677f, -0.01010596f, -0.03109195f, 0.01910333f, -0.03250562f, 0.01971489f, 0.02426361f, 
    -0.01875779f, -0.00084334f, 0.04027196f, -0.02638116f, -0.00166379f, -0.01872438f, -0.02330970f, -0.00212551f, 
    -0.00454121f, -0.02919563f, 0.02893571f, 0.01446202f, -0.02861666f, -0.02933485f, -0.01198741f, -0.00376545f, 
    -0.02156272f, -0.01552836f, -0.02208035f, 0.01519939f, -0.00905884f, -0.02260742f, 0.03003423f, 0.01738002f, 
    0.02918021f, -0.02197186f, 0.02836811f, -0.03080270f, 0.02396991f, -0.01187267f, 0.01558979f, -0.01461217f, 
    0.00007555f, 0.00612008f, 0.02431018f, 0.00230265f, -0.02048527f, 0.00172607f, 0.01954241f, -0.02505892f, 
    0.02874764f, 0.00868991f, 0.01959775f, -0.00725045f, 0.00644863f, 0.02267211f, -0.00308909f, 0.03636218f, 
    -0.02023300f, -0.00449302f, -0.01308023f, -0.01259415f, -0.03859663f, -0.02726058f, 0.02861204f, -0.01938568f, 
    0.00312575f, 0.02646710f, 0.01666893f, -0.02657608f, 0.00460307f, 0.02764416f, -0.01987971f, -0.00351486f, 
    -0.02183129f, -0.01028871f, 0.02997924f, 0.01956342f, -0.02791420f, 0.02141166f, 0.01206379f, 0.01917373f, 
    0.01593069f, -0.00743500f, -0.00717088f, 0.01751661f, 0.01501710f, -0.00156516f, 0.01029150f, 0.00556076f, 
    -0.03931903f, -0.02010883f, -0.00519723f, -0.00399936f, 0.02377269f, -0.00861032f, 0.02204899f, -0.00089063f, 
    -0.02748730f, -0.01442348f, 0.00235946f, 0.00814498f, 0.00345496f, -0.02437216f, 0.00565195f, -0.02356384f, 
    0.00549474f, -0.00482253f, -0.01902064f, -0.02460638f, -0.00306866f, -0.00238622f, 0.01912172f, -0.00258616f, 
    0.00271460f, -0.02841864f, 0.02467531f, -0.00632491f, 0.00185440f, -0.01707949f, -0.02829235f, 0.02898623f, 
    -0.01175062f, 0.00944288f, -0.00791019f, 0.02597467f, -0.01619841f, 0.04226335f, -0.00016620f, -0.00549033f, 
    0.02339939f, -0.02645889f, -0.01846596f, -0.03909505f, 0.00044809f, 0.02811208f, -0.01210861f, -0.02235393f, 
    -0.00566741f, -0.00996758f, -0.00187672f, -0.04092231f, 0.01485107f, -0.01212774f, 0.02896310f, -0.01631361f, 
    0.01129348f, -0.01091268f, 0.02308470f, 0.00705332f, -0.00477867f, 0.00896295f, -0.00595139f, -0.00622478f, 
    -0.02113423f, 0.01312367f, -0.01514880f, 0.02072536f, 0.04185649f, 0.03380203f, 0.00338671f, 0.02907748f, 
    0.00223164f, -0.02463162f, -0.01828167f, 0.00812097f, 0.01137450f, -0.01342452f, -0.00508719f, -0.03135925f, 
    -0.01834122f, 0.01912093f, 0.00690230f, -0.01227787f, 0.00419640f, -0.01161861f, -0.01986394f, 0.03203787f, 
    -0.02978279f, -0.01898039f, -0.02092207f, 0.01966804f, 0.00013320f, 0.02140038f, -0.03441335f, 0.02499421f, 
    -0.02626436f, -0.01323719f, -0.00937195f, -0.03601977f, 0.00055542f, -0.01385648f, 0.01164395f, -0.00775049f, 
    -0.01981960f, 0.02472096f, -0.03416498f, -0.02163243f, -0.03613705f, -0.01052102f, -0.02350335f, -0.00903311f, 
    -0.00583679f, 0.00631208f, -0.01123736f, 0.02675758f, 0.03364683f, -0.02610349f, -0.02909297f, -0.01732234f, 
    -0.02128070f, 0.02452436f, 0.02966587f, -0.03370933f, 0.02294444f, 0.01947697f, 0.03519958f, 0.00761377f, 
    -0.03152492f, -0.00415221f, -0.04127369f, 0.01667895f, 0.03084121f, -0.03336699f, 0.00718648f, 0.02525466f, 
    -0.00885516f, 0.01002289f, -0.02728840f, -0.02895448f, 0.00001026f, 0.00790668f, 0.01018397f, 0.01732012f, 
    0.02549408f, 0.00209715f, -0.01460218f, -0.01347165f, -0.04080857f, 0.00902884f, 0.02626968f, -0.02617251f, 
    -0.01748509f, 0.00509989f, 0.00810097f, -0.00948450f, 0.00841008f, 0.02875486f, -0.01364550f, 0.00632916f, 
    0.01663645f, -0.00026939f, 0.00756902f, -0.02225017f, -0.02937448f, -0.03275256f, -0.00433184f, 0.00562839f, 
    0.01844400f, -0.00604305f, -0.00769744f, 0.02806834f, -0.03373612f, 0.02337749f, -0.02499634f, -0.01796708f, 
    0.01269492f, 0.02039031f, -0.00162938f, -0.02727073f, 0.02348168f, -0.02359542f, -0.03673882f, -0.02502023f, 
    0.03014863f, -0.01158655f, -0.01267949f, 0.02782519f, -0.03538531f, 0.02896462f, 0.01017520f, -0.01352716f, 
    -0.03704648f, 0.00196340f, 0.03122824f, -0.02315157f, 0.00457352f, -0.02493599f, -0.01468485f, -0.00192038f, 
    -0.02261680f, -0.00529956f, 0.02720370f, 0.00496228f, -0.02336728f, 0.00981681f, -0.01365453f, -0.02986886f, 
    -0.02287325f, -0.00507213f, 0.00534420f, -0.00957825f, -0.03482769f, -0.03405061f, -0.04006857f, -0.02646421f, 
    0.02648099f, 0.01984728f, -0.01921218f, 0.02617529f, 0.01766116f, -0.01002726f, 0.01371011f, -0.01035417f, 
    -0.02382792f, -0.02979195f, 0.02548185f, -0.03311362f, 0.00891179f, 0.02873857f, 0.02441923f, -0.01915998f, 
    0.01360096f, 0.02415777f, 0.00994136f, -0.01735693f, -0.02425116f, 0.02675211f, 0.00167319f, -0.02412484f, 
    0.03731957f, -0.03292428f, -0.01127114f, 0.00947913f, -0.03336030f, -0.03249346f, 0.00301253f, -0.01040238f, 
    0.02722137f, 0.01031576f, 0.01628663f, 0.03840735f, -0.04183928f, 0.01013865f, 0.02763275f, 0.00535209f, 
    -0.00074295f, 0.02838116f, 0.00336325f, 0.01297509f, -0.01475387f, -0.01776076f, -0.00620719f, 0.00730848f, 
    -0.01085198f, 0.00854652f, 0.02398928f, 0.00070150f, -0.02324464f, 0.00790410f, 0.01608929f, -0.02145222f, 
    -0.00116521f, 0.02589756f, -0.00641962f, -0.02892494f, -0.01702195f, 0.01222544f, 0.01958847f, -0.01318786f, 
    0.02714805f, -0.01250219f, 0.02546469f, -0.03057448f, -0.01632576f, 0.02672689f, -0.02870363f, -0.00856677f, 
    -0.00671062f, -0.04210621f, -0.02796020f, 0.00610407f, 0.01846610f, -0.03637321f, -0.01272706f, 0.00762279f, 
    0.02432555f, -0.00543353f, -0.01137558f, -0.01505144f, -0.03026567f, -0.00906941f, -0.02159042f, 0.02846620f, 
    0.01054855f, 0.00746838f, 0.00875051f, -0.02607926f, -0.03133546f, -0.01096863f, -0.00604413f, -0.00238050f, 
    0.01790977f, 0.00947216f, -0.01798850f, -0.00633121f, 0.00760855f, -0.00040711f, -0.04139468f, -0.01726376f, 
    -0.02228030f, -0.04169580f, 0.00309247f, 0.01630679f, -0.01288834f, -0.00532544f, 0.02527281f, 0.00358294f, 
    -0.00031751f, -0.04204437f, 0.00176714f, -0.03680736f, 0.00421221f, -0.03407200f, 0.02229824f, 0.01535766f, 
    0.03101529f, -0.01918170f, -0.01060550f, -0.00683116f, -0.03478684f, -0.02901548f, -0.02972019f, 0.01044222f, 
    0.02441291f, -0.01327297f, -0.03966725f, 0.01957557f, 0.02732465f, -0.00479707f, 0.00815658f, 0.02574855f, 
    -0.01000027f, 0.00337480f, -0.02442186f, 0.01099303f, -0.00886609f, -0.01392570f, 0.00755182f, -0.00961087f, 
    0.00933475f, 0.01815983f, -0.01817312f, -0.02093799f, -0.01285673f, 0.02775025f, -0.00079342f, -0.02852371f, 
    0.02239388f, 0.02669468f, -0.03882515f, -0.03371720f, 0.02759798f, -0.02107750f, 0.01119304f, 0.01287630f, 
    -0.01139367f, -0.00005291f, 0.01452749f, 0.01991082f, -0.02265091f, 0.00139136f, 0.02052765f, 0.03098799f, 
    -0.01245544f, -0.00348514f, -0.03270633f, -0.00170364f, 0.00236367f, -0.02713244f, 0.01894789f, -0.00599840f, 
    -0.04214107f, 0.01216181f, -0.01018701f, -0.01139339f, 0.01137212f, -0.02945254f, 0.00701707f, 0.00623564f, 
    -0.04042997f, 0.02241084f, 0.02955407f, -0.03702578f, 0.01217626f, -0.01363590f, -0.01363866f, 0.00529372f, 
    -0.04104949f, 0.02290303f, -0.00549884f, -0.01291792f, 0.00011394f, -0.02559773f, 0.02544801f, -0.03108685f, 
    -0.02648704f, 0.01954130f, -0.03879466f, 0.01192734f, -0.02772394f, -0.03916035f, -0.01143416f, -0.00711165f, 
    -0.02727087f, -0.00758233f, 0.00665155f, 0.01001278f, -0.03961661f, 0.02108477f, 0.01704046f, -0.02232276f, 
    0.01420155f, 0.00320473f, -0.00533618f, 0.01706688f, -0.01209998f, 0.00941158f, 0.00176462f, 0.01385722f, 
    -0.01551347f, 0.02239836f, 0.01497864f, 0.02025145f, -0.00640492f, 0.02142185f, -0.01717361f, 0.01972783f, 
    -0.00033946f, 0.02996062f, -0.02384619f, 0.00680873f, -0.02354067f, 0.01859575f, 0.00349815f, 0.01405859f, 
    -0.03825573f, 0.00783433f, 0.02912332f, 0.01691883f, -0.02978853f, -0.01950557f, -0.01087963f, 0.01161536f, 
    0.03351424f, -0.00143996f, 0.02037548f, -0.00894033f, -0.00294621f, -0.00606774f, -0.01338593f, -0.03377440f, 
    0.01558062f, -0.02248999f, 0.03029617f, 0.03070482f, -0.00400994f, 0.00524371f, -0.02570396f, 0.02834975f, 
    0.00419398f, -0.03636527f, -0.03204456f, 0.00718588f, -0.00107151f, 0.02452563f, -0.00391987f, -0.04500130f, 
    -0.02460526f, 0.02076693f, 0.00575875f, 0.01604373f, -0.03393608f, -0.02351511f, -0.00553899f, 0.01994976f, 
    -0.00293789f, 0.02313724f, -0.03639378f, -0.00700407f, -0.03345129f, 0.01836953f, -0.00934913f, 0.02487935f, 
    0.02766638f, -0.00998215f, 0.01257802f, 0.02076908f, 0.02439877f, 0.01859485f, 0.01328664f, 0.02690853f, 
    -0.03241644f, 0.01888638f, -0.04259898f, 0.02040451f, -0.02484494f, 0.02975440f, -0.03238255f, -0.02191848f, 
    0.01518961f, 0.03217471f, -0.01129689f, -0.02270944f, -0.01598585f, 0.02822935f, -0.00411335f, -0.04085394f, 
    -0.02159256f, -0.00441277f, -0.02331565f, -0.01083118f, -0.02296590f, 0.02064562f, 0.01225919f, 0.02880497f, 
    0.00716173f, 0.01749552f, -0.02876327f, -0.00466980f, 0.03154894f, 0.00925253f, 0.01890214f, -0.00872354f, 
    -0.02487386f, -0.03744784f, 0.02307093f, -0.02253374f, -0.01878342f, -0.03489212f, 0.01398177f, -0.01172534f, 
    0.00486164f, -0.00580249f, 0.03062033f, 0.00805182f, -0.01221964f, -0.04513598f, 0.01587921f, -0.02141592f, 
    -0.03272659f, -0.02755243f, 0.02249950f, 0.02228790f, 0.00190942f, 0.02050779f, -0.01019208f, 0.01698079f, 
    -0.02674690f, -0.02724406f, 0.01514999f, -0.00147725f, -0.01080208f, -0.03161885f, -0.00372171f, 0.02500319f, 
    -0.01500246f, 0.00792040f, -0.04119618f, -0.03795371f, 0.01924420f, 0.00729422f, 0.01483734f, -0.03404859f, 
    0.00498848f, 0.02925693f, 0.00240144f, -0.01317774f, 0.02119543f, -0.04060788f, 0.00652651f, -0.00306658f, 
    0.00720699f, -0.00382892f, -0.00716724f, -0.01795389f, 0.00850732f, -0.00334679f, 0.00717229f, -0.01673552f, 
    -0.00899937f, -0.00888904f, 0.02017032f, 0.00789224f, -0.03390601f, 0.01968220f, -0.02232593f, 0.02068317f, 
    -0.00130238f, -0.03653262f, -0.00574263f, 0.00376907f, 0.01781700f, -0.03480833f, 0.03155559f, -0.02932015f, 
    0.01239733f, 0.00037463f, 0.02781489f, -0.03571575f, -0.00372907f, -0.02031844f, 0.02561450f, -0.01936488f, 
    -0.02849166f, -0.00739059f, 0.02106084f, 0.02332904f, 0.02908330f, 0.01205839f, -0.00860495f, 0.01222311f, 
    0.00410035f, -0.04265483f, 0.01348871f, 0.01354965f, 0.02911861f, -0.03909812f, 0.02495345f, -0.03743026f, 
    -0.02148309f, 0.00094009f, 0.00083112f, -0.00643014f, -0.03970903f, -0.00482740f, -0.00045033f, -0.02421004f, 
    0.00704655f, -0.03331517f, -0.00502858f, -0.00792080f, -0.02816530f, -0.00130497f, 0.00606811f, 0.02473449f, 
    -0.03314432f, -0.01857856f, -0.03022050f, -0.02644395f, -0.00744962f, -0.03271986f, -0.02420634f, -0.00856983f, 
    -0.04183464f, -0.00728724f, 0.01399338f, -0.02285566f, -0.02155441f, -0.02291380f, -0.01879851f, 0.00350514f, 
    0.00112646f, 0.02582168f, -0.00630352f, 0.01775550f, -0.01010142f, -0.03709788f, -0.01845399f, 0.03013701f, 
    0.00307103f, 0.02166914f, 0.01753036f, -0.02548810f, 0.00306465f, -0.00447000f, 0.01267786f, -0.00069283f, 
    -0.02630799f, -0.03839568f, -0.03418242f, -0.01764672f, 0.02188106f, -0.01112429f, -0.03818962f, -0.00979754f, 
    -0.00001859f, -0.03628193f, 0.02153089f, 0.00401946f, 0.02888039f, -0.01627319f, 0.00930168f, -0.03722828f, 
    -0.02439372f, -0.01767531f, 0.01171465f, 0.00915371f, -0.01617303f, 0.00465413f, -0.02672307f, 0.01174610f, 
    0.02370111f, 0.00928582f, 0.02835549f, -0.02835779f, 0.02152020f, -0.01278100f, 0.00183083f, -0.01589557f, 
    -0.03239721f, -0.00788973f, -0.02912986f, -0.00609237f, 0.03122810f, 0.00990767f, -0.03073759f, 0.00369810f, 
    0.00194688f, -0.03276961f, -0.01228459f, -0.01723933f, 0.02298908f, 0.01348422f, -0.00864748f, -0.01812430f, 
    0.02360096f, -0.03256131f, 0.00586526f, 0.01633625f, 0.00684746f, -0.02445751f, -0.00289853f, -0.02439403f, 
    0.01606679f, 0.00977294f, 0.02166778f, -0.03482098f, 0.00375354f, -0.04094814f, 0.00616290f, 0.00211995f, 
    0.02203425f, 0.02815013f, 0.01879396f, -0.02835679f, 0.00973374f, -0.00611937f, 0.02154731f, 0.02423528f, 
    0.00040701f, 0.00966299f, -0.01569211f, -0.02848427f, -0.00178719f, -0.03561403f, 0.01776583f, 0.02096194f, 
    -0.00864559f, -0.02512286f, 0.01886276f, 0.01259634f, -0.01315132f, -0.01788359f, -0.00012558f, -0.02450543f, 
    0.02323585f, 0.00878999f, 0.01945375f, -0.01244573f, -0.00010469f, -0.00861146f, -0.03266080f, -0.01057650f, 
    0.00007506f, -0.03139447f, -0.00254865f, 0.02650761f, -0.00689082f, -0.01895200f, -0.00026645f, -0.02738894f, 
    0.02741131f, 0.00734252f, -0.01511953f, 0.02123796f, -0.02069927f, -0.01039847f, -0.00119212f, -0.03224313f, 
    -0.01475043f, 0.01604028f, 0.00403151f, -0.03740478f, 0.01905741f, -0.02646540f, -0.01431595f, -0.02780668f, 
    -0.01052606f, -0.02108611f, 0.00136581f, 0.01560702f, -0.02912119f, 0.02937545f, -0.00368830f, -0.00343027f, 
    0.01395207f, 0.02232694f, -0.00494346f, -0.01703179f, 0.00600103f, -0.01929681f, -0.01563371f, -0.01314778f, 
    -0.03619278f, -0.00395660f, -0.00556514f, 0.00004464f, 0.02167632f, -0.01851072f, 0.00271341f, -0.01973885f, 
    0.02801522f, -0.00948600f, -0.02842715f, -0.03528534f, -0.00172107f, -0.02001503f, -0.04108700f, 0.02218621f, 
    -0.00722923f, -0.02778773f, -0.03208603f, -0.03127903f, -0.01744151f, 0.01473237f, -0.04384509f, -0.03382142f, 
    -0.02266926f, -0.00917157f, -0.03528903f, -0.01538903f, -0.02666217f, -0.00015893f, -0.03504055f, 0.00396982f, 
    -0.03739393f, -0.04061763f, -0.01612585f, -0.03535853f, -0.02452757f, 0.02489758f, 0.00871676f, 0.00628743f, 
    -0.03697905f, 0.01126857f, 0.02594144f, -0.03288054f, 0.01245579f, -0.03822073f, 0.02027541f, 0.01601670f, 
    -0.00993455f, -0.00381419f, 0.02050619f, -0.01231183f, 0.00639508f, -0.03680073f, 0.02193690f, -0.00668177f, 
    0.01134710f, 0.01068341f, -0.03448021f, 0.00844314f, -0.02718946f, -0.02279762f, 0.01139966f, -0.01410254f, 
    -0.03904065f, -0.02220145f, -0.02954087f, 0.00887018f, 0.00998568f, 0.00519672f, -0.01003052f, 0.02174504f, 
    0.01001470f, 0.02812135f, 0.00458282f, 0.02384482f, -0.03601594f, -0.01520678f, 0.00286049f, -0.00747920f, 
    -0.01263664f, -0.00852946f, 0.01624891f, 0.01099584f, -0.03453178f, -0.03855644f, 0.00788586f, 0.02290781f, 
    -0.02161621f, -0.00443718f, -0.04323151f, -0.03529615f, -0.02547106f, -0.02204349f, -0.01681420f, -0.02672501f, 
    -0.00898597f, 0.02689699f, -0.00813869f, 0.00486383f, -0.00744064f, 0.02325685f, 0.02095590f, 0.02398931f, 
    -0.01059945f, 0.00608495f, -0.03455125f, -0.02867348f, -0.03788177f, 0.01854010f, 0.02591824f, -0.00319668f, 
    0.01356595f, -0.02472620f, 0.00611061f, 0.00024419f, -0.03857630f, 0.00838029f, 0.01801970f, -0.02385612f, 
    0.01603449f, 0.02413868f, -0.00647657f, 0.00201677f, -0.03622897f, -0.00461883f, -0.03349830f, 0.03314726f, 
    0.01814693f, 0.00353202f, 0.02189470f, -0.01714916f, -0.03392080f, -0.02909043f, -0.01749284f, -0.03077008f, 
    -0.03592790f, 0.00984194f, 0.00930439f, -0.02238430f, -0.02890693f, -0.01648168f, -0.01299585f, 0.00935970f, 
    -0.00863517f, -0.00579444f, -0.02074097f, -0.03779697f, 0.00291951f, 0.02249824f, 0.00693625f, 0.00425464f, 
    0.00147822f, 0.02451438f, 0.01354792f, 0.02358492f, -0.03990463f, -0.00853157f, -0.02394773f, 0.01268088f, 
    0.01271085f, -0.02040542f, -0.00878897f, -0.03304650f, 0.00680441f, -0.02331659f, -0.02884886f, 0.02741256f, 
    0.02699775f, -0.02150420f, 0.02921562f, -0.03569907f, -0.00031411f, 0.00475786f, -0.03394223f, 0.01544940f, 
    0.02757639f, -0.00241176f, -0.03673854f, -0.02857877f, -0.00863421f, -0.02924554f, -0.02951960f, 0.02573938f, 
    0.00814448f, 0.02638289f, -0.01794949f, 0.02469867f, -0.00659569f, -0.03939437f, -0.03049880f, 0.00615378f, 
    -0.03760843f, -0.02357950f, -0.03444588f, -0.02712466f, 0.00101718f, 0.00840913f, -0.01913221f, -0.03254274f, 
    0.01601865f, -0.00017391f, -0.00586191f, 0.02081144f, -0.02497077f, -0.02177426f, -0.00511020f, 0.00119386f, 
    0.02161208f, 0.01128112f, -0.02110232f, 0.02396435f, -0.03717523f, -0.00103489f, -0.03818376f, 0.02109300f, 
    0.03629551f, 0.01387915f, -0.02424515f, 0.02341714f, 0.01861704f, -0.03290321f, 0.02735205f, -0.03346452f, 
    -0.14179614f, 0.03980161f, 0.01425130f, -0.06544994f, 0.02076368f, -0.03260559f, -0.03248013f, 0.02319853f, 
    0.00183169f, 0.06731961f, 0.06577730f, 0.06476983f, -0.08305386f, 0.13990378f, 0.17083369f, 0.17268826f, 
    -0.03243081f, 0.02936610f, 0.06836408f, -0.01728340f, -0.02476394f, 0.06064134f, 0.01188144f, 0.07469682f, 
    0.16041733f, -0.15742792f, 0.07246041f, -0.08294079f, -0.09814139f, -0.04888545f, -0.04988798f, -0.02377123f, 
    0.02226434f, -0.01148963f, -0.09274167f, 0.09571511f, 0.40664774f, -0.10908939f, 0.09266178f, 0.14146683f, 
    -0.04162433f, -0.04404591f, 0.01150750f, -0.06911693f, 0.05021496f, -0.09822257f, -0.02146097f, 0.09354768f, 
    0.17664044f, -0.06739229f, -0.00446220f, -0.08004108f, -0.03046522f, 0.03185744f, -0.02488467f, -0.09375834f, 
    0.00675583f, 0.04381134f, -0.12398007f, 0.08830386f, -0.16457500f, -0.05272241f, -0.04267046f, -0.05628559f, 
    -0.02619799f, 0.03491534f, 0.03649107f, 0.02542528f, 0.00688502f, -0.00286910f, 0.04097780f, -0.12406740f, 
    0.11565825f, 0.04071946f, -0.02958540f, 0.00835364f, -0.06851098f, 0.00974416f, -0.04412431f, 0.10591500f, 
    0.01535185f, -0.08294601f, -0.03905527f, 0.00020212f, 0.56831425f, -0.10977175f, -0.05308154f, 0.07498481f, 
    0.02666537f, 0.07212678f, -0.02492859f, -0.01792865f, 0.02072483f, 0.04065978f, 0.03335150f, -0.06183103f, 
    -0.15613484f, 0.09835273f, 0.15595670f, -0.18402462f, -0.03572327f, -0.00480384f, -0.05656854f, -0.01801726f, 
    0.00531367f, -0.01835288f, 0.11780819f, -0.01106242f, 0.27934194f, 0.01642614f, 0.23750523f, 0.18732978f, 
    0.01639730f, 0.06631218f, 0.01208476f, -0.05100469f, 0.06512768f, 0.00642040f, 0.03225655f, -0.00305781f, 
    0.09368052f, 0.11144683f, 0.17499140f, 0.03691072f, -0.08644512f, 0.03568151f, 0.02666718f, -0.03375274f, 
    0.10280558f, 0.00479345f, -0.05775736f, 0.01834594f, -0.04089831f, -0.03509943f, -0.06054275f, -0.27330971f, 
    0.03377791f, 0.15348445f, 0.03364169f, 0.04435794f, -0.01111120f, -0.03254112f, -0.07224350f, 0.00316569f, 
    0.12149709f, -0.01111387f, 0.02359457f, -0.01750944f, 0.11251640f, 0.10949735f, -0.01817846f, 0.03104955f, 
    0.00064301f, -0.04921455f, 0.06252477f, -0.01054663f, -0.20788662f, 0.03587886f, -0.10819803f, -0.10140336f, 
    0.05897670f, 0.06044972f, 0.02973204f, -0.03874915f, -0.01327930f, 0.01055909f, -0.03532818f, 0.09547831f, 
    0.19711448f, -0.07000356f, -0.05508709f, 0.05808210f, -0.09843519f, 0.04905924f, 0.00401745f, 0.05558158f, 
    0.04310226f, -0.00893147f, 0.02823261f, 0.03705538f, -0.09307753f, -0.05214996f, 0.00863511f, 0.04886206f, 
    -0.09967146f, -0.06863702f, 0.02646272f, -0.06594398f, 0.03088201f, 0.05645160f, -0.01115294f, 0.08412569f, 
    -0.00967007f, 0.09959203f, -0.00584516f, -0.03172987f, 0.05052052f, 0.00508164f, 0.04417725f, -0.03689357f, 
    -0.02401353f, 0.09111090f, 0.03143410f, 0.00178700f, -0.14237596f, 0.21401669f, 0.09738303f, 0.09974203f, 
    -0.02334012f, -0.02592093f, 0.07640089f, 0.04087805f, -0.07498505f, -0.06560168f, 0.00538198f, -0.02324745f, 
    0.27031100f, 0.12558801f, 0.00758018f, -0.22638762f, 0.05645726f, 0.03187013f, -0.05818998f, -0.01848841f, 
    -0.09941066f, 0.04295749f, 0.12005173f, -0.11998586f, -0.16194865f, -0.14525451f, -0.32717291f, -0.01613006f, 
    0.13846631f, -0.01269752f, -0.06329842f, 0.00909645f, -0.07687959f, 0.02879740f, 0.03134434f, 0.12632236f, 
    0.27657136f, -0.13033405f, -0.14130419f, -0.05910425f, 0.02035084f, 0.05215724f, 0.00674247f, -0.16207235f, 
    -0.03879537f, 0.06685578f, 0.09488372f, -0.09717102f, -0.08117652f, -0.02201953f, -0.01434641f, -0.28519860f, 
    -0.01238354f, -0.09713229f, 0.10782785f, 0.04167309f, -0.06424781f, 0.06311099f, 0.00518183f, -0.01045997f, 
    -0.11325258f, -0.11808252f, 0.12052613f, 0.01563004f, 0.05299646f, 0.03042151f, 0.03856686f, 0.05407588f, 
    0.01314847f, 0.09213075f, 0.02591583f, -0.00925159f, -0.13175978f, 0.21196245f, 0.01529187f, 0.08701760f, 
    -0.06863214f, 0.03178684f, -0.01250088f, 0.02681204f, -0.07568767f, 0.12852111f, -0.06608506f, -0.05621087f, 
    -0.10640570f, -0.16582657f, 0.03265838f, -0.12423556f, -0.10329368f, 0.00934397f, 0.02300331f, -0.04998236f, 
    0.08323946f, 0.01656001f, -0.01833578f, 0.07152577f, -0.21579158f, -0.21309748f, -0.03280084f, 0.14343244f, 
    -0.01779234f, 0.12939610f, 0.00264444f, 0.09185859f, -0.01702826f, 0.02165279f, -0.08964601f, 0.03685175f, 
    -0.01045366f, -0.24699134f, 0.02907878f, 0.10842287f, 0.00102100f, -0.03738552f, 0.01123737f, -0.00861025f, 
    -0.00659114f, 0.05424766f, -0.01592826f, -0.03197450f, 0.28553358f, -0.18090969f, -0.07929519f, -0.02893808f, 
    -0.12039974f, 0.09497939f, 0.05418441f, -0.07844225f, 0.01686394f, -0.04346228f, 0.00149297f, 0.04615584f, 
    0.21766491f, 0.13925703f, 0.09639655f, 0.01781831f, 0.08663339f, 0.06541134f, -0.00848570f, -0.01040164f, 
    0.01449713f, 0.13683057f, -0.00323319f, 0.09989131f, -0.02729832f, 0.18904354f, 0.10407711f, 0.02842024f, 
    0.07432450f, 0.05283229f, 0.04772809f, -0.01036398f, -0.05342188f, 0.07473261f, -0.03375147f, 0.01552146f, 
    0.12008530f, 0.14742553f, -0.02552361f, 0.07710119f, -0.07965103f, 0.05181311f, 0.11051717f, 0.03610508f, 
    -0.05932575f, -0.06915358f, -0.00026357f, 0.03453686f, -0.14626281f, -0.11571945f, 0.07866642f, -0.03084822f, 
    -0.01873726f, -0.13440658f, 0.06774151f, 0.00608554f, 0.01731791f, -0.00219922f, -0.05370168f, 0.10185719f, 
    -0.23889661f, 0.26755205f, 0.05854906f, 0.09753160f, -0.02125212f, -0.08127562f, 0.10199748f, 0.03528778f, 
    0.02934803f, 0.03550955f, 0.04748594f, 0.01897447f, 0.08505085f, 0.06911182f, -0.20617869f, 0.01983156f, 
    0.08774574f, -0.09040131f, 0.01662776f, 0.03308997f, -0.02038085f, 0.01557013f, 0.04365806f, -0.16305669f, 
    0.27920580f, -0.06245265f, -0.06095066f, -0.00544919f, -0.03085034f, -0.05298381f, -0.06294870f, 0.12168427f, 
    0.01366521f, 0.10897197f, 0.00820168f, -0.08123916f, 0.29681563f, 0.11599685f, 0.03382462f, 0.17314957f, 
    -0.01197352f, 0.05850447f, 0.09338848f, -0.01440921f, 0.06714494f, 0.03152626f, -0.06016088f, -0.03273682f, 
    0.33069625f, -0.02198624f, -0.12854046f, -0.17904860f, -0.02121452f, 0.12181573f, -0.03553122f, 0.07177296f, 
    -0.08502457f, 0.05418633f, 0.07094941f, -0.04440851f, 0.00776443f, -0.07055940f, -0.05328446f, 0.18153633f, 
    -0.05966204f, -0.03635879f, 0.00275505f, -0.04409333f, 0.02962923f, -0.08180093f, 0.04687692f, -0.00013216f, 
    0.21418254f, -0.16539404f, 0.03076047f, -0.13788350f, 0.06110148f, 0.01452450f, -0.11071743f, -0.05823825f, 
    0.07552817f, -0.03819190f, 0.01463473f, -0.00514982f, -0.12876178f, 0.09181252f, 0.20006269f, -0.07087774f, 
    0.09652747f, -0.05380933f, 0.12101408f, -0.03483152f, -0.09270640f, 0.00964532f, 0.00473389f, 0.01613596f, 
    0.08369963f, -0.04386444f, 0.03548608f, -0.06249867f, 0.04630388f, 0.02160994f, 0.03216090f, 0.02494228f, 
    -0.06242478f, 0.05722834f, 0.09463020f, 0.05404570f, 0.06700588f, -0.14123173f, 0.08017783f, -0.00949316f, 
    -0.06987534f, 0.05558791f, -0.08798505f, 0.09025180f, -0.04385630f, -0.07479475f, 0.07542050f, 0.07755943f, 
    0.13439660f, -0.00288720f, -0.06406984f, -0.03096734f, 0.04984328f, -0.07381669f, 0.00389845f, 0.07092179f, 
    -0.09546215f, -0.09143695f, 0.03285258f, 0.08358643f, 0.31674275f, -0.04777017f, -0.24008781f, -0.04295493f, 
    0.07750606f, -0.13125786f, 0.03726250f, 0.06139320f, 0.06996411f, -0.00145207f, -0.02303301f, -0.03115035f, 
    -0.06542298f, -0.00439064f, 0.13162081f, -0.17439796f, -0.12104236f, 0.04419033f, -0.12616785f, 0.03049247f, 
    -0.00542207f, 0.08565401f, 0.04721197f, -0.07197453f, -0.08283258f, -0.01260394f, 0.11899091f, 0.03591938f, 
    -0.06358303f, -0.02076907f, 0.01927885f, -0.02793120f, -0.05853720f, 0.14553212f, -0.05545942f, 0.04655658f, 
    -0.02112320f, 0.08174020f, 0.15934959f, 0.10377300f, 0.04207055f, 0.08599307f, 0.02813073f, 0.00286163f, 
    -0.04968090f, 0.05400539f, 0.09441695f, 0.01120453f, 0.17336863f, -0.09472778f, 0.04862578f, 0.00871661f, 
    -0.08970208f, -0.06512956f, -0.02272382f, 0.07925949f, -0.08463508f, 0.10520686f, -0.00860328f, -0.02377542f, 
    0.29908022f, 0.05491594f, -0.06367229f, 0.08292632f, -0.03423270f, -0.03836329f, -0.08322497f, -0.08721445f, 
    0.01765847f, 0.02018622f, 0.03580273f, -0.10093023f, 0.07846150f, 0.17075984f, -0.01837985f, -0.03067392f, 
    0.10463402f, 0.06837494f, -0.06529279f, -0.05867068f, 0.03723831f, -0.06666028f, 0.07956796f, 0.08143330f, 
    -0.18624048f, -0.05935821f, 0.13205409f, -0.21153535f, 0.04396093f, -0.03651558f, 0.07942153f, -0.01644504f, 
    -0.01966781f, 0.03912811f, -0.01657273f, 0.01945706f, 0.03442385f, 0.14419074f, 0.13538738f, -0.00787865f, 
    -0.02997687f, 0.07768638f, -0.01491485f, -0.06673667f, 0.04030734f, -0.00016805f, 0.04553927f, -0.02069480f, 
    -0.21422906f, -0.24083936f, 0.03149284f, -0.27030721f, 0.02874068f, 0.06871209f, 0.04484581f, 0.05071919f, 
    -0.02754046f, 0.02812640f, -0.02017491f, 0.04612133f, -0.18227270f, -0.10070720f, -0.01835366f, -0.00774469f, 
    0.03194582f, -0.07439109f, 0.02415260f, 0.01562793f, 0.00161439f, 0.07661639f, -0.07027228f, 0.02733264f, 
    -0.01891059f, -0.00964057f, 0.05828162f, 0.14683492f, 0.05111397f, 0.09923659f, 0.06613638f, 0.06967461f, 
    -0.00745087f, 0.07951859f, -0.05813118f, 0.02758422f, 0.25702643f, -0.13460155f, -0.06078850f, -0.04764988f, 
    0.03996491f, 0.09452783f, 0.02638064f, 0.00718937f, 0.06518950f, -0.03963309f, 0.03106365f, 0.01752804f, 
    0.40520880f, -0.20676929f, 0.00834561f, 0.03091699f, 0.07572076f, 0.13717897f, 0.02369574f, -0.04482207f, 
    0.01052242f, 0.06445288f, 0.04819664f, -0.02058076f, -0.01239440f, 0.01272434f, -0.02608286f, -0.02169702f, 
    0.11833233f, 0.06828801f, 0.05675684f, 0.05581091f, -0.02759114f, 0.02721753f, 0.03532169f, 0.03096163f, 
    -0.05691368f, -0.12991105f, 0.08288898f, 0.02758593f, 0.07059248f, 0.00516469f, 0.07606945f, 0.09458100f, 
    0.13197699f, -0.01208605f, 0.03306615f, 0.03176711f, 0.24463175f, 0.13443780f, 0.05100181f, 0.09957414f, 
    0.02595641f, 0.07827178f, 0.01708626f, -0.10909350f, 0.07226875f, -0.05636987f, -0.05221862f, 0.10885885f, 
    0.05894682f, 0.06797091f, 0.22852913f, -0.00675959f, -0.00693467f, 0.01172098f, -0.06586874f, 0.06018361f, 
    0.01052517f, 0.04562268f, 0.03739109f, 0.05108372f, -0.05410688f, -0.03635844f, -0.17762196f, 0.05789379f, 
    0.02548526f, 0.05035042f, 0.02525507f, -0.06872522f, 0.06356231f, 0.00542568f, -0.02541077f, 0.09423329f, 
    -0.09931616f, -0.04592001f, -0.00430932f, 0.06478366f, -0.05485126f, 0.02320433f, -0.01890456f, -0.02053967f, 
    -0.04437930f, 0.03738921f, 0.09810710f, -0.01549754f, 0.52631158f, -0.19577444f, -0.02480520f, 0.08717046f, 
    -0.07558257f, 0.03588973f, -0.12457674f, -0.01071723f, 0.03473801f, -0.06506308f, 0.06910513f, -0.02017769f, 
    -0.02653320f, -0.02539033f, -0.02220125f, -0.02794098f, -0.00935585f, 0.01804969f, -0.01965263f, -0.01915671f, 
    0.02461779f, 0.01777602f, -0.00902653f, 0.02389297f, 0.00110439f, 0.02607207f, -0.03663308f, 0.03072530f, 
    -0.00017672f, -0.01714987f, -0.02827910f, -0.03051654f, 0.00519998f, -0.03247962f, 0.02013149f, -0.00855313f, 
    0.02203200f, -0.03317724f, 0.02714873f, 0.00128543f, -0.03630374f, -0.02877533f, 0.02438370f, -0.02619201f, 
    -0.00733271f, -0.00624144f, -0.02883729f, -0.00601808f, 0.00615107f, 0.01279253f, -0.03382096f, 0.02313685f, 
    -0.00751398f, -0.03063789f, -0.00907886f, -0.03183112f, 0.00724685f, 0.02330442f, 0.01899660f, 0.02697551f, 
    -0.03156367f, -0.02003844f, 0.00116533f, -0.03792299f, -0.01528242f, 0.02598599f, -0.00103946f, 0.01091620f, 
    0.02488667f, 0.00047787f, -0.00036061f, 0.02536156f, 0.00435465f, -0.03952063f, -0.03907456f, -0.00955808f, 
    0.02927181f, -0.00755667f, 0.03039786f, -0.03642693f, -0.00808882f, -0.01001079f, -0.03317251f, 0.00200982f, 
    0.00721463f, -0.01137518f, 0.00955818f, -0.04011169f, -0.03236506f, -0.03583337f, -0.02262268f, -0.03397388f, 
    -0.00841103f, -0.00157933f, -0.01745635f, -0.01057160f, 0.00586188f, 0.01359513f, 0.01905429f, -0.01370145f, 
    -0.02016776f, -0.00593728f, 0.00812662f, 0.02667279f, -0.03406981f, -0.00792798f, -0.03448821f, 0.02280186f, 
    -0.01374680f, -0.00848364f, -0.02595341f, -0.02285153f, -0.02972531f, -0.02835335f, -0.01100657f, -0.01998605f, 
    0.01487285f, -0.01471716f, -0.01271778f, -0.01411249f, 0.01685958f, 0.00742803f, -0.03608916f, 0.01567607f, 
    0.02156262f, -0.03785399f, 0.02987656f, -0.00721272f, -0.03946717f, -0.00159596f, -0.02690010f, 0.03085210f, 
    0.02105688f, 0.00591437f, -0.01605514f, -0.00112534f, -0.01209392f, 0.00823395f, -0.02185113f, -0.02206746f, 
    -0.03608710f, -0.02545079f, -0.01761536f, 0.00001520f, 0.01735282f, -0.01793465f, -0.03985529f, 0.00552968f, 
    0.01028642f, -0.01183289f, -0.03860463f, 0.00783213f, -0.03999721f, 0.02363497f, 0.00253107f, 0.02466136f, 
    -0.00593886f, -0.01899689f, -0.01621632f, 0.00545748f, 0.01107030f, -0.03026612f, 0.02689635f, -0.02235208f, 
    -0.02895162f, 0.00723504f, -0.01211008f, -0.00236387f, -0.02382235f, -0.03843421f, -0.01079083f, -0.03334844f, 
    0.01980999f, 0.00721381f, 0.02449969f, -0.03504319f, 0.01579996f, -0.01238752f, 0.02411048f, -0.01583955f, 
    -0.00479754f, 0.01792525f, -0.00151875f, -0.01439317f, 0.02725338f, 0.00008646f, 0.00384677f, 0.02639980f, 
    0.01315085f, 0.00146905f, -0.04057193f, -0.03653656f, -0.03717409f, -0.03753080f, -0.01682248f, 0.02436430f, 
    0.01540422f, -0.03845809f, -0.02469982f, 0.01808449f, 0.01927441f, -0.01430385f, -0.02721422f, -0.01658194f, 
    0.00459674f, -0.00534853f, -0.01084817f, -0.00673038f, 0.00170838f, -0.00122815f, -0.03905413f, 0.02451969f, 
    0.02044671f, 0.02552580f, -0.03256622f, -0.03114976f, 0.00544520f, -0.02449835f, 0.00963966f, -0.01795329f, 
    0.02292879f, -0.00817604f, -0.02959784f, 0.02535323f, 0.00808681f, -0.01854857f, -0.03604784f, -0.03900106f, 
    0.03310314f, -0.00197963f, -0.02456051f, 0.00665345f, -0.00069904f, -0.02116163f, 0.00545626f, 0.00322391f, 
    0.02840052f, 0.01542053f, -0.03401301f, -0.03173193f, 0.02530246f, -0.01535449f, -0.01485304f, 0.03056334f, 
    -0.01695264f, -0.02527930f, -0.03856678f, -0.01979988f, -0.00446718f, 0.02140436f, 0.00711814f, -0.02575315f, 
    -0.00467656f, -0.02714234f, -0.03776705f, -0.02674488f, 0.00060933f, -0.01529133f, 0.02323557f, -0.03154418f, 
    -0.03875237f, -0.02369799f, -0.01304342f, 0.00519679f, 0.01960121f, -0.02983187f, -0.02787372f, -0.01753490f, 
    0.01076547f, -0.00981797f, -0.02260626f, -0.02083659f, 0.00141198f, -0.02773131f, 0.01395042f, 0.01561487f, 
    -0.01730843f, 0.00610762f, -0.01459002f, -0.01724623f, -0.01005529f, 0.01743339f, 0.02749035f, -0.00174178f, 
    0.00461434f, 0.02138088f, -0.00758813f, -0.01199693f, 0.02947003f, -0.02031414f, -0.02244100f, -0.02880215f, 
    0.02317845f, -0.03487837f, -0.01532522f, -0.01288775f, -0.01031843f, -0.00401955f, -0.02510874f, 0.01992591f, 
    0.02691281f, 0.00451178f, -0.00264388f, -0.02304458f, -0.03815428f, -0.00249743f, 0.00036576f, -0.01780995f, 
    -0.03156323f, -0.00544873f, 0.02571850f, -0.03302554f, -0.01384036f, 0.01000021f, 0.01463040f, -0.00374641f, 
    -0.02315840f, -0.03218799f, -0.01633205f, -0.00788433f, -0.00203739f, -0.02696181f, -0.00558528f, -0.02945064f, 
    -0.01653283f, -0.02386753f, -0.00084384f, -0.02973312f, 0.00688404f, 0.02374443f, -0.01293283f, 0.01019479f, 
    -0.03065239f, -0.02266689f, 0.02749721f, -0.00658449f, 0.01472157f, -0.00166623f, -0.03115880f, -0.00701779f, 
    0.00990645f, 0.00884651f, -0.02532848f, -0.02477467f, -0.03521363f, 0.00658248f, -0.02473128f, -0.00763878f, 
    -0.00527472f, -0.01181751f, -0.01485109f, -0.00288634f, 0.00967116f, -0.03259553f, 0.01524836f, -0.03557947f, 
    -0.02900893f, -0.00857894f, 0.00307611f, -0.00668414f, -0.01355470f, 0.00167029f, -0.00899852f, -0.02666678f, 
    -0.00141470f, 0.01518601f, -0.03717293f, 0.00962446f, 0.01846238f, 0.00428798f, -0.00700455f, -0.02237328f, 
    0.01391375f, -0.01755434f, 0.01617891f, -0.03736645f, -0.02221998f, -0.00032869f, 0.01871249f, -0.02301938f, 
    -0.03121171f, 0.00261057f, -0.02716262f, -0.02787579f, 0.02365655f, 0.02508609f, 0.01393828f, -0.02513707f, 
    -0.00505785f, -0.03077804f, 0.02028671f, 0.00711880f, 0.02260604f, 0.02733177f, -0.02467625f, 0.01653041f, 
    -0.00395225f, 0.01005110f, 0.01943161f, 0.02418357f, 0.00289318f, -0.01119764f, -0.03263973f, -0.01346964f, 
    -0.00748773f, 0.02223821f, -0.03963619f, 0.00530884f, 0.00328948f, 0.02952798f, -0.01035431f, -0.01240692f, 
    0.01634363f, -0.02993556f, 0.03028250f, -0.03140591f, 0.00603754f, -0.01065363f, -0.00692783f, -0.01462712f, 
    -0.01604424f, 0.02266446f, -0.01009072f, 0.02242969f, -0.02233950f, -0.03496671f, -0.01715189f, -0.00708858f, 
    0.01765310f, 0.01812567f, -0.03952879f, -0.00684405f, -0.03558358f, -0.03842892f, 0.01560941f, 0.00667735f, 
    0.00370696f, 0.02017972f, -0.03123095f, -0.03262815f, -0.02095138f, -0.02030471f, 0.02086223f, -0.02774059f, 
    -0.00999838f, 0.02479512f, -0.01556601f, 0.00476504f, 0.00347444f, 0.01418565f, 0.01889463f, -0.02262455f, 
    -0.03324199f, -0.01026029f, 0.01955431f, -0.01323601f, 0.02162269f, -0.02016938f, 0.01038836f, -0.01895833f, 
    0.00071607f, 0.00166833f, -0.01364813f, -0.02156477f, -0.02149744f, -0.03737834f, 0.00749211f, -0.02608551f, 
    -0.02987009f, -0.01528206f, -0.03052736f, -0.00233459f, 0.01527076f, -0.01540185f, -0.01023847f, 0.00723058f, 
    -0.03655112f, 0.00794235f, -0.03013476f, -0.03159493f, 0.01595355f, -0.01411159f, 0.02107877f, 0.01429496f, 
    0.00528521f, -0.02816107f, -0.02859852f, -0.04061173f, -0.03156903f, -0.03715690f, 0.01649377f, 0.01189854f, 
    -0.04053428f, 0.02076956f, 0.02621261f, -0.02025882f, 0.02999632f, -0.03101301f, 0.00920096f, 0.01604858f, 
    0.00082054f, -0.02679953f, -0.01221066f, -0.01648366f, -0.00805813f, 0.02097223f, -0.03639547f, 0.01373446f, 
    0.00234422f, -0.01417354f, -0.04046569f, -0.03726250f, -0.00484386f, -0.00006760f, 0.00821910f, 0.00463788f, 
    -0.00829999f, 0.02676460f, 0.02313587f, 0.02445120f, 0.02430498f, 0.00492411f, 0.02822885f, -0.00355184f, 
    0.02935980f, -0.01615945f, 0.00332662f, 0.00067490f, -0.01074220f, -0.01695772f, 0.02789497f, 0.00825909f, 
    -0.02529770f, -0.01831317f, 0.02388817f, -0.00536928f, 0.00114394f, -0.02696814f, 0.00383268f, 0.00833851f, 
    -0.03683596f, -0.00559814f, -0.03650101f, -0.02251017f, 0.02947125f, 0.02687201f, 0.02779140f, -0.00608980f, 
    -0.01006632f, -0.01154664f, 0.01019909f, -0.00936774f, 0.00764093f, -0.03594222f, 0.02606363f, -0.02737774f, 
    0.00195791f, 0.01983138f, -0.01489350f, -0.00540040f, -0.03909722f, -0.01803898f, -0.02691725f, -0.00386217f, 
    -0.01640553f, -0.01968042f, -0.03822177f, -0.03386728f, -0.03186660f, 0.02234709f, -0.02566947f, -0.00638575f, 
    -0.02202731f, -0.00691689f, -0.01848927f, -0.01735322f, 0.02206184f, 0.00332025f, 0.01000607f, -0.03318974f, 
    -0.01765035f, -0.02955847f, 0.00282545f, -0.02894183f, 0.00335610f, -0.03962516f, -0.02633801f, 0.00445767f, 
    -0.01166953f, 0.02261773f, -0.01675965f, 0.02826770f, 0.01007691f, -0.03792325f, -0.03243960f, -0.03381355f, 
    0.00713471f, -0.00369578f, -0.02516026f, -0.00788700f, 0.02125045f, -0.00786555f, -0.03604731f, -0.01867012f, 
    -0.02752325f, -0.00152739f, -0.02281315f, -0.01083308f, 0.02988544f, -0.01345350f, 0.02552738f, 0.03084172f, 
    0.02290086f, -0.03083699f, -0.00025395f, 0.01117770f, -0.03406320f, 0.02156720f, 0.02435589f, -0.03886312f, 
    0.00266784f, -0.00220820f, -0.01324547f, 0.02423753f, -0.01458338f, 0.01711608f, -0.00703276f, 0.01253371f, 
    -0.01514661f, 0.02110889f, -0.02761007f, -0.01314362f, -0.00046136f, -0.00036046f, -0.01342220f, -0.02420405f, 
    0.00548451f, -0.00134362f, 0.00201575f, 0.00018706f, -0.00668705f, 0.02712099f, -0.02634751f, 0.02990826f, 
    0.02056472f, 0.02904029f, 0.01346591f, -0.01821128f, -0.00928413f, -0.03027062f, -0.03340433f, -0.02374579f, 
    0.01723001f, -0.00937334f, 0.01220397f, -0.03302773f, 0.01630114f, 0.01611705f, 0.03252852f, 0.01583919f, 
    0.01161029f, -0.01086301f, -0.01327971f, 0.02320934f, 0.00306276f, -0.02522622f, -0.00414071f, -0.03400625f, 
    0.00093418f, -0.02892414f, 0.01605940f, 0.01779227f, 0.01491657f, -0.03641457f, 0.02914298f, 0.02736021f, 
    0.00392829f, 0.00209694f, -0.01943018f, -0.02245795f, -0.02401314f, -0.03676847f, -0.02860755f, -0.01766099f, 
    -0.03492979f, 0.02312121f, 0.00372790f, -0.01268250f, 0.00786110f, -0.01906585f, -0.02093249f, 0.03069337f, 
    0.01769130f, -0.00964175f, -0.00987208f, 0.01187495f, 0.03219856f, -0.02674837f, -0.02399176f, -0.00842058f, 
    -0.02671717f, -0.03554543f, -0.00470568f, -0.03892308f, -0.01214434f, 0.02495128f, -0.00389603f, 0.00986817f, 
    0.00826498f, 0.01915389f, -0.00556756f, -0.01611366f, -0.02488437f, -0.01869059f, -0.01261630f, -0.02407530f, 
    -0.02144643f, 0.00176148f, -0.04064112f, 0.01956057f, -0.01836297f, -0.01987063f, 0.01101038f, 0.00443852f, 
    -0.01206057f, 0.02217167f, 0.01947181f, 0.00954836f, -0.01342654f, -0.02976445f, -0.00547503f, -0.02228255f, 
    -0.01097994f, -0.03777397f, 0.01266690f, -0.03701805f, 0.00887042f, 0.02491004f, -0.00827811f, -0.03692883f, 
    -0.02734258f, -0.02072679f, -0.01595136f, 0.01550960f, 0.02278926f, -0.02055119f, 0.01610701f, -0.02124174f, 
    0.02373129f, 0.00988408f, -0.01692712f, 0.01089995f, -0.03251402f, 0.00252671f, -0.01058399f, 0.01314205f, 
    -0.02425733f, -0.00241333f, 0.01868871f, 0.01936528f, 0.01943130f, 0.01808715f, -0.02788642f, 0.01909295f, 
    0.01399841f, -0.00823496f, 0.02028075f, -0.00803819f, 0.01042495f, -0.00401162f, -0.00531884f, -0.02676887f, 
    -0.01191288f, 0.00397681f, -0.03684920f, -0.02067496f, -0.01561316f, -0.00626046f, -0.02817681f, 0.00278557f, 
    -0.16665611f, -0.03123457f, 0.15556991f, 0.04727410f, 0.07420383f, 0.00485732f, 0.06761914f, 0.03088240f, 
    0.02292754f, -0.03754567f, 0.03386901f, 0.05515852f, 0.19908559f, 0.10350229f, 0.18259850f, 0.03079933f, 
    -0.05154378f, -0.05332519f, -0.00074382f, 0.04090089f, 0.03109247f, -0.01276225f, 0.04565420f, 0.18973988f, 
    0.18591709f, -0.21919845f, 0.07156715f, -0.12285861f, 0.05134030f, -0.04784483f, 0.07623949f, -0.02341666f, 
    0.05887416f, -0.00313317f, 0.04339584f, 0.01097284f, 0.25121927f, 0.12681486f, -0.04161123f, 0.10234691f, 
    0.01717899f, 0.01504186f, 0.08428194f, -0.05702328f, 0.09329547f, 0.00986603f, 0.01516235f, 0.11863326f, 
    0.14522672f, 0.07812504f, -0.18784565f, -0.05807520f, -0.04054298f, 0.08056847f, -0.02340179f, -0.01653587f, 
    0.05785393f, 0.08260766f, 0.01953447f, 0.12144840f, -0.05485444f, -0.15602842f, -0.14276697f, 0.18322024f, 
    -0.02574001f, -0.07516224f, -0.02164727f, -0.07206899f, 0.05417451f, -0.05265187f, -0.14826493f, -0.08928058f, 
    -0.05463972f, -0.02994339f, 0.23672317f, -0.32831076f, -0.05504178f, -0.00057647f, 0.00113091f, 0.01521197f, 
    -0.06763150f, -0.07355454f, -0.00694345f, 0.04099152f, 0.06127274f, 0.20198616f, 0.14185801f, 0.08644338f, 
    -0.00639391f, 0.03384814f, -0.00437544f, -0.04194257f, 0.07996745f, 0.07026279f, 0.00671086f, 0.12006167f, 
    0.03662530f, -0.35668850f, 0.22391282f, -0.36049724f, -0.01857725f, 0.05070043f, 0.01204151f, 0.08606417f, 
    0.16270563f, 0.00457692f, 0.01697075f, 0.00100554f, 0.21616508f, -0.00434943f, 0.00319966f, 0.25716215f, 
    -0.07618092f, 0.10062300f, -0.04022921f, -0.03877899f, 0.02072984f, -0.05379278f, 0.02708335f, -0.02670672f, 
    0.40697888f, 0.17220584f, 0.05591477f, -0.02127121f, -0.02009068f, 0.02148436f, -0.10197468f, -0.02494399f, 
    0.00097425f, -0.10567980f, 0.04286967f, -0.08227900f, 0.02319254f, -0.11474326f, 0.09899104f, -0.24167989f, 
    0.05708534f, -0.00405304f, 0.07193628f, 0.15325177f, -0.15005890f, -0.05234283f, -0.17641783f, -0.07352287f, 
    0.16158102f, 0.01358390f, -0.09917066f, -0.13623054f, -0.05385326f, -0.01114447f, 0.00305464f, 0.02087553f, 
    -0.09667181f, -0.06103504f, -0.02050686f, -0.21047984f, 0.11195876f, 0.08665574f, 0.15366770f, -0.20970023f, 
    0.05086286f, -0.04147368f, -0.00489512f, 0.00838140f, -0.04044359f, -0.02692654f, 0.02096966f, 0.02698292f, 
    -0.15047058f, 0.01656272f, -0.27046949f, 0.25717232f, -0.08247061f, 0.06918563f, -0.10176597f, 0.05358057f, 
    -0.00086028f, 0.02828301f, 0.12607343f, 0.07346686f, 0.21366985f, -0.16074252f, -0.06123777f, -0.12640139f, 
    0.13845944f, -0.02002558f, 0.04573775f, 0.04084190f, 0.07479789f, -0.00179153f, -0.00452428f, 0.01033539f, 
    0.26683602f, 0.25783476f, 0.08727869f, 0.00361773f, -0.04028110f, 0.05232932f, 0.02363848f, -0.02177936f, 
    -0.01151531f, 0.03567957f, 0.03833622f, 0.10174759f, 0.13848291f, 0.19604349f, -0.02274651f, 0.10445430f, 
    -0.02923721f, -0.14449410f, 0.03160327f, 0.00294678f, -0.00991355f, -0.03739696f, 0.02736872f, 0.02510036f, 
    0.05594937f, 0.02417183f, -0.04026371f, -0.17064084f, 0.00255249f, -0.00445361f, 0.00558525f, 0.06220673f, 
    -0.11945926f, 0.12545322f, 0.02268167f, -0.02836813f, -0.20609637f, 0.04108426f, -0.16340102f, -0.14036885f, 
    -0.01851177f, 0.10407430f, -0.12062550f, 0.00435976f, 0.10516089f, 0.03913503f, 0.15765984f, 0.08194223f, 
    0.29566112f, -0.23166363f, -0.14125346f, -0.06723191f, -0.14696547f, -0.04228840f, -0.03992928f, 0.05005031f, 
    -0.00548842f, 0.14266466f, 0.06809527f, 0.04532898f, -0.05382693f, 0.08217501f, 0.06614214f, -0.26270485f, 
    -0.02466752f, -0.12345358f, 0.13336274f, 0.06683247f, -0.00564761f, 0.11441004f, 0.01394310f, 0.07216825f, 
    -0.15488026f, -0.07726870f, 0.08266898f, -0.03418687f, -0.02337748f, -0.00119115f, -0.05026213f, 0.04137067f, 
    -0.00107447f, 0.09421399f, -0.01303118f, -0.08306432f, 0.06255249f, 0.36612853f, -0.07061248f, 0.07018348f, 
    -0.01865850f, 0.12619899f, -0.01892501f, 0.03620728f, -0.10740310f, -0.00565112f, -0.00490358f, -0.02437104f, 
    -0.17536989f, -0.04929600f, 0.02109431f, 0.01992789f, 0.08575941f, 0.10432500f, 0.00023763f, 0.02042256f, 
    0.07293528f, -0.06912913f, -0.02849897f, -0.06195692f, -0.35021755f, 0.00329396f, -0.17100200f, 0.33034474f, 
    0.08117477f, 0.13869658f, -0.07048911f, 0.09243340f, 0.03819377f, 0.15658167f, -0.03609869f, 0.07648829f, 
    -0.39881420f, -0.24078466f, 0.15393132f, -0.06904281f, 0.02358621f, 0.02072707f, 0.02581395f, 0.02118079f, 
    -0.03330145f, -0.07344489f, 0.00662876f, -0.19559279f, -0.10542687f, -0.13209178f, -0.29296964f, 0.19524311f, 
    -0.14044307f, 0.05288900f, -0.04789519f, -0.05672851f, -0.01426278f, -0.07912253f, -0.00796720f, 0.09809535f, 
    0.18611406f, 0.13710706f, -0.09671758f, -0.02464214f, 0.04292206f, -0.01616637f, 0.04011224f, 0.05081478f, 
    0.05675289f, 0.09206649f, -0.01373594f, 0.11847027f, 0.26212832f, 0.09118441f, 0.05740223f, 0.18157147f, 
    0.01136611f, -0.07961755f, -0.05437780f, 0.02973775f, -0.00025555f, -0.07199804f, 0.05125725f, -0.09263639f, 
    0.40881434f, 0.15116715f, 0.14530750f, -0.05059315f, -0.02617439f, -0.07271568f, 0.13971005f, -0.03411202f, 
    -0.05426349f, -0.08172293f, 0.06380779f, 0.12280373f, -0.04411476f, -0.21196783f, -0.08933461f, -0.01398646f, 
    0.13474397f, 0.01375037f, -0.00225873f, 0.00213351f, 0.03446356f, 0.01350772f, -0.09167573f, 0.14131881f, 
    -0.08583423f, 0.22185944f, 0.01544872f, 0.20775191f, 0.00377893f, -0.15687193f, 0.02093885f, 0.00695900f, 
    -0.04385042f, 0.02152653f, 0.04850782f, 0.09512654f, 0.09126107f, 0.03816084f, 0.02774326f, -0.13689224f, 
    0.11718585f, 0.01332919f, -0.07537825f, 0.00186967f, 0.02671211f, 0.07192084f, -0.02727442f, -0.10055126f, 
    0.12240880f, 0.01274910f, -0.19406162f, -0.11973275f, 0.10396944f, -0.01681594f, -0.13064925f, 0.03378580f, 
    0.11998545f, -0.03807146f, 0.09964797f, -0.06676235f, 0.38418865f, 0.01790782f, 0.08255841f, 0.02687732f, 
    -0.06331776f, -0.01591204f, 0.02768626f, 0.00932662f, 0.04621358f, -0.02704940f, 0.03456120f, -0.07280585f, 
    0.14266168f, -0.19686070f, -0.24171914f, 0.00242684f, 0.00116670f, 0.08035524f, 0.02383752f, -0.03152207f, 
    0.04464509f, -0.00662472f, 0.11824118f, -0.07214493f, 0.11911387f, 0.14806364f, -0.16070014f, 0.26762769f, 
    0.02529231f, -0.08968185f, 0.11113524f, -0.07725079f, 0.11884774f, -0.02298383f, 0.08418461f, -0.04569974f, 
    0.22459158f, -0.22349085f, -0.09552031f, -0.08243653f, 0.25267684f, 0.06344709f, 0.01853047f, -0.04800569f, 
    0.07029914f, 0.01134223f, 0.01562709f, -0.01169694f, 0.14736629f, -0.02514114f, 0.13669735f, 0.03500370f, 
    -0.05568684f, -0.14506483f, -0.00845358f, 0.03377687f, 0.08101360f, 0.04328681f, 0.01500598f, 0.11887576f, 
    -0.22676840f, 0.00018149f, -0.15723006f, 0.17489934f, 0.08445481f, 0.11966896f, -0.03532029f, 0.00935780f, 
    0.00615057f, 0.04876106f, 0.18414615f, 0.15226696f, 0.04028447f, -0.15159225f, -0.04094110f, -0.09292188f, 
    0.03366487f, 0.11526212f, 0.02374658f, 0.03934450f, -0.09123795f, -0.00778006f, -0.06695160f, -0.01588907f, 
    0.10996151f, -0.16278222f, 0.11347455f, -0.09435534f, 0.10036512f, -0.05811715f, 0.07753024f, 0.09282035f, 
    -0.01848128f, -0.03449244f, 0.06328490f, 0.09021948f, 0.09348471f, 0.20651267f, -0.17469068f, -0.07004122f, 
    0.17734930f, -0.01549398f, -0.06955530f, 0.05750892f, 0.15729170f, 0.00690499f, -0.07199401f, -0.04507428f, 
    -0.16079706f, -0.02444281f, 0.21112165f, -0.12944463f, -0.00216551f, 0.01283369f, -0.09132259f, 0.05641945f, 
    -0.03316324f, 0.10277645f, -0.01672463f, -0.01446124f, -0.10562598f, 0.07760710f, -0.03940714f, 0.15294866f, 
    -0.01533685f, 0.10416982f, 0.02757790f, -0.12093201f, -0.03315461f, 0.05337422f, 0.04738430f, -0.11615711f, 
    0.14291911f, 0.04448476f, 0.17056461f, 0.05756059f, -0.03418091f, 0.07469480f, 0.03723259f, 0.00735355f, 
    -0.05352041f, 0.10348372f, -0.01313038f, -0.03741462f, 0.20906405f, -0.03991364f, -0.09709127f, 0.02136500f, 
    0.13603152f, -0.10788077f, -0.04052333f, -0.01331291f, -0.04044141f, 0.14907520f, 0.09039260f, 0.20625159f, 
    -0.11874091f, 0.22107448f, -0.10834548f, 0.32140362f, -0.02539079f, 0.02751702f, -0.04746246f, -0.07750691f, 
    0.00651687f, 0.01604567f, -0.01059261f, 0.11715604f, 0.10234416f, 0.24225891f, -0.09968040f, -0.02327390f, 
    -0.01578247f, -0.07724085f, -0.10629787f, 0.01040578f, -0.02709381f, 0.17323314f, 0.05806009f, 0.14627358f, 
    0.04419323f, -0.28697366f, 0.23223414f, -0.17091262f, -0.05043174f, 0.03082421f, -0.02855096f, 0.03166784f, 
    -0.09894644f, 0.08792041f, 0.09279574f, 0.08947134f, 0.24441972f, 0.00077281f, -0.08385492f, 0.05811786f, 
    -0.01474311f, 0.00689017f, -0.12794761f, -0.00305271f, 0.09145749f, -0.06979570f, 0.06838357f, -0.01768244f, 
    -0.10506847f, -0.15207697f, 0.00707937f, -0.16979811f, 0.06535017f, 0.12224654f, 0.01894049f, 0.10921616f, 
    0.07485552f, 0.04240610f, -0.01771635f, 0.13309097f, -0.12903027f, -0.24236879f, 0.18212830f, -0.18149710f, 
    -0.04472633f, -0.02069424f, 0.06945356f, -0.02605215f, 0.02274143f, 0.14330424f, -0.04184187f, 0.14915149f, 
    0.07328933f, 0.19426712f, -0.20490433f, 0.08102144f, 0.00825481f, 0.02247260f, 0.01835574f, -0.03790957f, 
    -0.07058016f, 0.09863938f, 0.02734783f, -0.01374760f, 0.34002796f, 0.08604448f, -0.13162635f, -0.18781146f, 
    0.14478865f, 0.04741444f, -0.02597797f, 0.14445075f, 0.08600894f, -0.08678248f, -0.00411077f, -0.05196679f, 
    -0.04568771f, -0.02518757f, -0.14844543f, 0.21667349f, -0.04290540f, 0.03372518f, -0.03922988f, -0.03585258f, 
    0.06991211f, 0.01231202f, 0.06703091f, 0.06308419f, 0.12947409f, -0.07274551f, -0.16629645f, 0.16846044f, 
    -0.06393670f, -0.06500158f, -0.07255565f, 0.00281818f, -0.02088755f, -0.04261645f, -0.01430372f, 0.04350981f, 
    -0.07567383f, -0.30484751f, 0.07865203f, 0.00695618f, 0.12557797f, 0.12258382f, 0.04042403f, 0.14279971f, 
    0.03586973f, -0.03685933f, -0.05793414f, -0.04660608f, 0.27652007f, 0.00447649f, 0.12593457f, -0.10920820f, 
    0.08600776f, 0.09341024f, 0.08031580f, -0.10394507f, 0.06708483f, 0.11379161f, 0.03643531f, 0.06954627f, 
    -0.04063262f, 0.09520960f, -0.06373587f, 0.28519464f, 0.08447121f, 0.05658661f, -0.11742157f, 0.03107172f, 
    -0.03322349f, 0.12687954f, 0.05490885f, 0.13476248f, -0.09875486f, -0.08570105f, -0.09501790f, 0.06227675f, 
    -0.05742212f, 0.01522294f, 0.07826549f, 0.08422264f, 0.07310322f, -0.03104616f, -0.02803900f, 0.07810508f, 
    0.17941849f, -0.06378560f, 0.01954111f, -0.08259065f, 0.05780651f, 0.09519500f, -0.01404699f, -0.05045508f, 
    0.05345203f, -0.01416474f, 0.11455972f, 0.00871987f, -0.06778982f, -0.08108670f, -0.16123489f, 0.11662031f, 
    0.03233730f, -0.00932474f, -0.06824477f, 0.10113733f, 0.01947891f, 0.08876868f, -0.05319728f, -0.03656418f, 
    -0.05660317f, 0.00620690f, 0.05847180f, -0.12712151f, 0.06248135f, -0.03960310f, -0.02606722f, -0.02156205f, 
    -0.13542131f, -0.08900017f, -0.12345452f, 0.01707145f, -0.21948992f, 0.09751938f, 0.08396635f, 0.02609088f, 
    0.00353529f, 0.00268854f, -0.00484147f, 0.04737348f, 0.07577316f, -0.08023971f, -0.03733353f, -0.17283526f, 
    -0.15709670f, 0.02073413f, 0.05300198f, 0.04601296f, 0.06088045f, 0.10184159f, -0.07738265f, 0.01052811f, 
    -0.01980776f, -0.03929539f, 0.16823162f, 0.01855669f, -0.20499168f, -0.03883288f, 0.04256474f, 0.15483294f, 
    -0.03035710f, 0.10754945f, -0.03584648f, -0.05904681f, -0.01608226f, 0.00785696f, 0.18988407f, -0.00771057f, 
    -0.13242416f, 0.03276461f, -0.06258440f, 0.12631798f, -0.02239420f, -0.04544149f, -0.02485432f, -0.14726196f, 
    -0.00305693f, -0.01220388f, 0.13973026f, -0.12120719f, 0.09846895f, 0.16058090f, -0.07144892f, 0.15139022f, 
    0.04595098f, 0.20747909f, 0.03551766f, -0.05722139f, 0.00619601f, -0.06340647f, 0.09880266f, 0.10620775f, 
    -0.07387282f, -0.20668040f, 0.15015745f, 0.07541513f, -0.00234052f, 0.01929664f, 0.16842400f, 0.02926569f, 
    -0.04545349f, 0.02244642f, 0.00916967f, 0.01906859f, 0.00340056f, 0.04887488f, -0.09235989f, 0.07975914f, 
    0.05179161f, 0.03339899f, 0.02149188f, 0.07308716f, 0.06278416f, -0.04158962f, 0.01283929f, 0.10291342f, 
    0.08057479f, -0.02872556f, -0.00894647f, -0.13640222f, -0.04551124f, -0.06554393f, 0.01490179f, -0.00245187f, 
    -0.07399420f, -0.03439903f, 0.06867278f, -0.09001829f, 0.10595915f, -0.01331821f, -0.00107894f, 0.13977084f, 
    -0.08396091f, 0.06134171f, 0.11694014f, 0.06278974f, 0.08254182f, 0.09208690f, 0.00908264f, 0.07771321f, 
    0.03262547f, -0.00006884f, 0.01237153f, 0.10515108f, 0.07765087f, 0.00343189f, 0.01955753f, 0.10933810f, 
    0.05244881f, 0.05946454f, 0.06262615f, 0.15254153f, -0.22400579f, -0.01004351f, 0.14390561f, 0.06276878f, 
    -0.00908782f, 0.16672651f, -0.09924870f, -0.09633974f, 0.06959310f, 0.02160013f, 0.10699961f, 0.09559202f, 
    -0.07488311f, 0.04959672f, 0.23238960f, 0.09980851f, 0.03845168f, 0.00415396f, -0.06004230f, -0.11565701f, 
    0.06223358f, 0.09530716f, -0.13937157f, 0.10172624f, -0.01017455f, 0.02482236f, 0.17939460f, -0.13511515f, 
    -0.01810211f, 0.01164992f, -0.07575719f, 0.04433765f, 0.04883851f, -0.11244426f, 0.10945173f, -0.08758672f, 
    -0.02028496f, -0.17244892f, 0.00948431f, 0.00460141f, 0.01917818f, -0.08204494f, 0.01690400f, 0.05003508f, 
    0.03931342f, 0.01093620f, 0.01351424f, -0.04171410f, 0.06145572f, -0.00998632f, -0.01767331f, -0.03213927f, 
    0.06015905f, -0.00701291f, -0.06426421f, 0.05409220f, -0.01078465f, 0.01227818f, 0.05951790f, 0.06407385f, 
    -0.25913796f, 0.12887608f, 0.09200045f, -0.19110465f, 0.01829449f, -0.00051557f, -0.08715614f, 0.09075354f, 
    0.04125328f, -0.17959882f, 0.00196443f, -0.00538903f, -0.07921639f, -0.12277056f, 0.09975456f, 0.08569951f, 
    -0.05907333f, 0.04772946f, 0.09806987f, 0.05680983f, -0.01636285f, 0.05447053f, 0.00660854f, -0.00243347f, 
    -0.22978288f, -0.11645750f, 0.12495278f, 0.10349269f, 0.00943959f, 0.07590050f, -0.06516146f, -0.16258243f, 
    0.15145561f, -0.06996372f, -0.07253623f, 0.07102355f, -0.13291575f, -0.01999409f, 0.10461088f, -0.07353200f, 
    0.14444196f, 0.00199480f, 0.06657241f, -0.00118721f, -0.08113611f, 0.02314896f, 0.05735554f, -0.08820667f, 
    -0.24541153f, 0.12967974f, 0.13958777f, 0.05038898f, 0.09128244f, 0.01820284f, -0.04546110f, 0.00243467f, 
    -0.02524111f, -0.09617002f, -0.09952909f, -0.12830374f, 0.06233867f, -0.06373011f, 0.19212820f, -0.08352076f, 
    -0.00106003f, 0.13953756f, -0.10245492f, -0.05502411f, 0.04335170f, -0.03098433f, -0.15693025f, 0.00392529f, 
    0.07619325f, 0.21847695f, -0.05112469f, 0.14972281f, 0.00701751f, 0.09711135f, -0.06903620f, -0.00703613f, 
    -0.07822228f, -0.05804417f, -0.01964380f, 0.03727093f, 0.13375376f, 0.00818744f, -0.20652591f, 0.01170356f, 
    0.00652353f, -0.05327255f, 0.19768877f, 0.00482430f, 0.10751561f, -0.12304612f, 0.07425707f, 0.03325616f, 
    -0.09681752f, -0.05987382f, -0.09252781f, 0.01195986f, 0.06735020f, 0.03720903f, -0.01807302f, 0.02667362f, 
    -0.01396677f, 0.11348710f, 0.05502741f, 0.20065765f, -0.14516833f, 0.23719406f, -0.21761499f, 0.10159753f, 
    0.12239190f, -0.06716133f, -0.02324106f, -0.07192390f, 0.01041710f, -0.14243202f, -0.02873002f, 0.00769952f, 
    0.41145125f, 0.11724692f, -0.16301213f, -0.04234176f, -0.03868740f, -0.01743573f, 0.09402795f, -0.01882649f, 
    0.01143856f, 0.03920499f, 0.12491193f, 0.14641841f, 0.04964589f, 0.00365864f, 0.04474264f, 0.20702162f, 
    0.02442322f, 0.05038804f, 0.05546591f, 0.08907764f, 0.07211895f, 0.11802661f, 0.06939936f, -0.01513423f, 
    0.10697065f, -0.07089739f, -0.04391578f, 0.05099564f, -0.10501451f, 0.02690012f, -0.05046308f, 0.06957497f, 
    0.10973089f, -0.11802501f, -0.01235181f, -0.06077201f, 0.11716860f, -0.08779325f, 0.04716883f, 0.12772807f, 
    -0.13841781f, 0.06104618f, 0.08962113f, 0.02988287f, 0.12692733f, 0.04954520f, 0.06573197f, 0.04576153f, 
    -0.40397471f, -0.05557569f, 0.05627751f, -0.04001363f, -0.11198303f, 0.03130350f, -0.04201308f, -0.00274361f, 
    -0.04884533f, 0.01290229f, -0.10742388f, -0.10105786f, 0.03921134f, -0.21984808f, -0.14142320f, 0.00520250f, 
    -0.13378680f, 0.03481906f, 0.01167755f, 0.18758687f, -0.17072365f, -0.02076522f, 0.02670362f, 0.11421210f, 
    0.07710405f, -0.02372140f, 0.01112879f, 0.06628555f, -0.04995386f, 0.12110392f, -0.00731149f, -0.07089967f, 
    -0.05292766f, -0.06941509f, -0.00119099f, 0.00046810f, 0.13676818f, -0.01175652f, 0.15623556f, 0.02741027f, 
    0.07642360f, 0.09308251f, 0.12264179f, 0.05935045f, 0.00914491f, 0.02376547f, 0.05154539f, 0.20867154f, 
    0.04241782f, -0.04919507f, 0.02438859f, 0.05013930f, -0.03016330f, 0.11845470f, -0.12371883f, -0.04603184f, 
    0.02009246f, -0.08269880f, -0.07935081f, -0.05638719f, -0.08901116f, -0.01272712f, 0.07433986f, 0.14236870f, 
    -0.00872329f, 0.11024895f, 0.06018756f, 0.10014822f, 0.01817209f, 0.16801544f, 0.05223357f, 0.13491310f, 
    -0.03370950f, -0.03319277f, 0.10738593f, 0.07825609f, -0.02860627f, -0.06585348f, -0.01052350f, 0.03833978f, 
    0.07996401f, 0.02444249f, -0.07275194f, 0.13543504f, 0.29877287f, -0.07376108f, 0.00513992f, -0.07300372f, 
    0.09194519f, 0.14903899f, 0.19032162f, 0.17693962f, 0.13658303f, 0.07867526f, -0.00478361f, 0.03822180f, 
    -0.19654477f, -0.02211925f, 0.07471510f, 0.04383143f, 0.00436907f, 0.01765578f, -0.07943767f, 0.12752517f, 
    0.01125648f, 0.00662223f, 0.05879041f, 0.14222565f, -0.02903276f, -0.03251392f, 0.16255847f, 0.07169223f, 
    -0.07674450f, 0.11211616f, 0.00344807f, -0.06750012f, 0.04056397f, -0.02206374f, 0.02072177f, -0.12599745f, 
    0.09215226f, -0.20265204f, 0.00381409f, 0.02422987f, -0.00067622f, -0.00780631f, -0.01650950f, -0.01026151f, 
    0.00087634f, 0.08644843f, -0.08997408f, -0.11646473f, -0.02052402f, -0.17842381f, -0.03471787f, 0.15582420f, 
    -0.04064678f, -0.09762375f, -0.00495868f, 0.19709355f, 0.06115420f, 0.01712834f, -0.02911445f, -0.09975771f, 
    -0.10398237f, 0.03441038f, 0.08122267f, 0.11468073f, -0.09537691f, 0.14272559f, 0.06994879f, 0.03981920f, 
    -0.02445595f, -0.04701387f, -0.06135504f, -0.18931857f, -0.21641855f, -0.04175578f, 0.10222865f, -0.02331053f, 
    0.04514347f, 0.01825397f, 0.07030892f, -0.00167840f, -0.06804448f, -0.02743585f, 0.05987994f, 0.08736784f, 
    -0.01782277f, 0.09813815f, -0.07624160f, 0.02692572f, 0.05463479f, 0.01200540f, -0.06582229f, -0.04615412f, 
    -0.01949022f, -0.06975636f, -0.15777378f, 0.11036009f, -0.07098265f, 0.10849215f, -0.22214070f, 0.00751990f, 
    -0.00351756f, 0.05627440f, -0.08863534f, 0.09549135f, 0.15199411f, -0.00259176f, 0.03228776f, 0.04677796f, 
    -0.13532972f, 0.17199573f, 0.05941058f, 0.06545550f, -0.07996327f, -0.12237581f, -0.03418670f, -0.03490505f, 
    0.02866069f, 0.06609938f, -0.08543883f, 0.05145677f, 0.07716645f, 0.18302311f, -0.05815119f, 0.03791452f, 
    0.00093805f, 0.08799560f, 0.15057407f, -0.09742337f, 0.00205337f, -0.14422821f, 0.04049442f, -0.13089101f, 
    0.24477537f, 0.08307856f, -0.07306910f, 0.08848038f, 0.00733879f, 0.09354398f, 0.11060618f, 0.05814710f, 
    -0.00338343f, -0.01185222f, 0.02037534f, 0.04042178f, -0.04360757f, 0.03278264f, 0.02800817f, 0.13231160f, 
    -0.04848128f, 0.02032810f, 0.12274683f, 0.01922185f, 0.11368527f, 0.09654968f, -0.13181697f, -0.15840162f, 
    -0.02338911f, -0.16702288f, -0.04832011f, -0.15480708f, -0.15617608f, -0.01815404f, 0.11743249f, 0.05117586f, 
    0.05021692f, -0.10525171f, 0.07894405f, -0.12058031f, 0.11439698f, 0.05225609f, -0.09393466f, 0.04629034f, 
    0.04829977f, 0.11980606f, 0.02624881f, 0.08796398f, -0.01840824f, 0.06145388f, 0.03512872f, 0.02217749f, 
    -0.19447067f, -0.18130708f, -0.19514634f, 0.05197157f, -0.05272547f, -0.09897552f, 0.11753717f, 0.09547070f, 
    0.08866532f, -0.06196712f, 0.05188905f, 0.07452706f, 0.10864207f, 0.14852285f, -0.17009486f, -0.20328511f, 
    -0.13444483f, 0.12630707f, 0.07360289f, -0.03255631f, 0.01927819f, -0.09844323f, 0.10654785f, -0.05298943f, 
    -0.05565052f, 0.15301096f, 0.03465516f, -0.08931154f, -0.12223827f, 0.03486298f, -0.00151697f, 0.12549618f, 
    -0.08825415f, -0.02849728f, 0.05824326f, 0.08268160f, -0.26042295f, -0.26742825f, 0.03322371f, 0.00172682f, 
    0.02665653f, -0.05178759f, 0.03372061f, 0.08427293f, -0.01733197f, 0.06383605f, -0.01028278f, 0.13161838f, 
    0.22690153f, 0.10430309f, -0.04224815f, 0.14134641f, -0.10686940f, -0.14706832f, 0.06820102f, -0.10709541f, 
    -0.02588912f, -0.05370727f, 0.06317389f, 0.03253127f, -0.10595457f, 0.11745515f, 0.04060385f, 0.10740943f, 
    -0.02438074f, 0.07467096f, -0.00695255f, 0.03199474f, 0.10770468f, 0.05770126f, -0.06513119f, -0.05163400f, 
    -0.11994572f, -0.09712470f, -0.04247885f, -0.03807983f, -0.12787250f, -0.05733098f, 0.05083026f, 0.05195738f, 
    0.07351469f, -0.02007389f, 0.01393798f, 0.08913370f, 0.24257727f, -0.00827985f, -0.13216591f, 0.00451777f, 
    -0.04259226f, -0.08895091f, 0.09566192f, 0.09899163f, -0.05787643f, -0.04585861f, -0.01292893f, -0.01029191f, 
    0.06505066f, -0.00855268f, -0.23882233f, -0.00980804f, -0.06040480f, -0.00417071f, 0.10818128f, 0.03808466f, 
    0.12533562f, -0.01429552f, -0.00230557f, -0.02439171f, -0.22538273f, -0.12520070f, -0.04033693f, 0.03441234f, 
    0.02530339f, 0.00486349f, -0.05664576f, -0.04606434f, -0.04341440f, 0.01985042f, 0.05395561f, 0.00237627f, 
    0.33238566f, -0.01476058f, 0.01328791f, 0.00504108f, 0.08494411f, 0.02104715f, 0.09013295f, 0.04833037f, 
    -0.00609525f, 0.05042353f, -0.04596677f, -0.02567196f, -0.14763901f, 0.06915177f, -0.10223583f, 0.11316018f, 
    -0.01973248f, -0.04995507f, 0.07973489f, 0.02110562f, 0.04981814f, 0.02289733f, 0.00782277f, 0.07985773f, 
    0.13577174f, -0.12184162f, -0.09166475f, 0.24114643f, -0.02406221f, 0.02204630f, -0.00392249f, 0.11491018f, 
    0.00831499f, 0.03918929f, 0.04425243f, 0.00888744f, -0.14196956f, 0.03446626f, 0.03957298f, 0.16583072f, 
    0.01572817f, -0.03580074f, 0.01237230f, 0.05987773f, -0.00274808f, 0.03839644f, -0.04327722f, -0.00154630f, 
    -0.13085309f, -0.21734487f, -0.14388132f, -0.16053081f, 0.03160885f, 0.04302699f, -0.03569770f, -0.04104421f, 
    -0.04098507f, 0.06926462f, 0.03104733f, -0.05048788f, -0.10309767f, 0.03442771f, -0.03382607f, -0.15994190f, 
    0.08118702f, 0.13182019f, 0.01911384f, -0.05166796f, 0.02067671f, 0.04738380f, 0.00410113f, 0.01615802f, 
    -0.12757319f, 0.01855574f, 0.20810358f, -0.03202377f, 0.00085534f, -0.09771447f, -0.03412060f, 0.08609242f, 
    0.02315824f, 0.02761465f, -0.03253544f, 0.02684386f, 0.14933796f, 0.14393966f, 0.08483112f, -0.03005457f, 
    -0.02985538f, 0.08813935f, 0.07011139f, 0.12482325f, -0.06483246f, 0.06276735f, 0.07892539f, 0.05786559f, 
    0.20317821f, -0.13919826f, 0.07330986f, 0.28458580f, 0.04248555f, 0.10349426f, 0.10835803f, 0.08788376f, 
    -0.03354134f, 0.10961247f, 0.08505585f, -0.01410162f, -0.26247993f, 0.09931020f, 0.01704218f, 0.04575517f, 
    0.04383258f, 0.10815337f, 0.03445783f, 0.09270328f, -0.08094153f, -0.01889639f, 0.09316059f, -0.02507666f, 
    0.11452857f, -0.15612577f, -0.10908709f, 0.04457270f, -0.09944215f, 0.04899121f, -0.01228588f, 0.00397701f, 
    0.04215990f, -0.03600416f, 0.03636305f, -0.03604870f, 0.03046274f, 0.14599702f, 0.16745214f, -0.19909634f, 
    -0.10298502f, 0.02511113f, 0.05745681f, 0.04022067f, 0.04256197f, 0.03060140f, 0.01924183f, 0.05429296f, 
    -0.11220740f, -0.00688893f, 0.04703211f, -0.03484996f, 0.00176149f, -0.00720430f, 0.05464655f, -0.03164054f, 
    0.02533616f, 0.00938011f, 0.06040871f, 0.02280412f, 0.05737244f, 0.13460520f, 0.12995368f, 0.17378680f, 
    0.03568286f, 0.10430587f, -0.05561924f, 0.07713741f, -0.03023099f, -0.07449311f, 0.01171116f, 0.03486854f, 
    0.11035299f, 0.07294166f, 0.23726274f, 0.07028003f, 0.01275465f, 0.04297004f, -0.05170057f, 0.01975072f, 
    -0.06188291f, -0.05507790f, 0.07495307f, 0.07176705f, 0.13974889f, -0.00778814f, 0.02852304f, 0.19775771f, 
    -0.02233881f, 0.02000444f, 0.11522922f, 0.11159874f, -0.00409188f, 0.05799492f, -0.02687346f, 0.04339845f, 
    -0.01073207f, 0.16726635f, 0.06772154f, -0.10644615f, 0.07993034f, 0.03252216f, 0.01924357f, 0.15082708f, 
    0.03549284f, 0.02536180f, 0.02770611f, -0.00921785f, -0.12528734f, -0.14544240f, -0.24333389f, -0.21784219f, 
    0.06877994f, 0.10592607f, -0.01123374f, -0.13473442f, 0.05070977f, 0.03889512f, 0.00744613f, 0.00280044f, 
    -0.16573790f, 0.06736059f, 0.15461554f, 0.13986069f, 0.00821488f, -0.06355385f, -0.03417504f, 0.09070917f, 
    -0.06194789f, -0.00191483f, -0.03149403f, -0.04635455f, 0.08736257f, 0.08528616f, 0.02767717f, 0.10700481f, 
    -0.16960417f, 0.01743344f, 0.02003824f, 0.09463605f, -0.04114118f, -0.00177736f, 0.01812349f, 0.01311401f, 
    0.03616195f, 0.02849443f, -0.01980167f, 0.05769486f, 0.05038354f, 0.06894049f, -0.03921725f, 0.02156654f, 
    -0.15252393f, -0.01906469f, 0.11522756f, 0.13774081f, -0.18936479f, -0.06423156f, 0.00975475f, 0.21581060f, 
    -0.01903002f, 0.00257121f, -0.00865383f, 0.04177640f, 0.08737153f, 0.06594616f, -0.06635297f, 0.00102592f, 
    -0.03243290f, 0.14931597f, 0.27709606f, 0.03201440f, 0.09438880f, 0.01826273f, 0.11469740f, 0.05072983f, 
    -0.11730442f, 0.04942774f, 0.01355117f, -0.05065154f, 0.37794986f, -0.03821930f, 0.12802365f, 0.16326547f, 
    -0.06950066f, 0.02352443f, 0.08496476f, -0.02249795f, -0.02329055f, -0.03919338f, -0.01008572f, 0.09497105f, 
    0.14855415f, 0.07838496f, 0.06375165f, -0.07505937f, -0.01563661f, -0.04316115f, 0.09030012f, 0.05349200f, 
    -0.11715974f, -0.00630485f, -0.01606537f, 0.16293511f, -0.08220463f, -0.01856324f, 0.09855083f, -0.00521570f, 
    0.00304524f, -0.01266503f, 0.05218762f, -0.06551594f, 0.00353024f, -0.06189839f, -0.06150021f, 0.07397211f, 
    0.09148122f, -0.01176442f, -0.06693172f, 0.08670473f, -0.00959483f, 0.02088591f, 0.08456139f, 0.01207383f, 
    0.06641344f, 0.21020420f, -0.08026405f, -0.05345673f, -0.01679962f, 0.26069301f, -0.00664531f, -0.15255353f, 
    0.06486234f, 0.04748880f, 0.01168002f, -0.08347281f, 0.11372948f, -0.14666995f, 0.02276657f, -0.08281598f, 
    -0.02498351f, -0.19023423f, 0.10089654f, 0.16955510f, -0.01534620f, -0.09377778f, 0.06839587f, 0.06926057f, 
    0.01811815f, 0.01625432f, -0.01204303f, 0.04805072f, -0.15457353f, 0.29105595f, -0.01578069f, 0.11995303f, 
    0.08252467f, -0.04226208f, 0.07942124f, 0.11387081f, -0.02634177f, 0.06975979f, 0.04357226f, -0.06022871f, 
    -0.09983040f, 0.04055696f, 0.27239749f, -0.15084930f, -0.10963224f, 0.00122316f, 0.08903998f, 0.05623248f, 
    -0.04387908f, 0.00383821f, 0.02567854f, 0.03443836f, -0.00217284f, 0.06468811f, 0.23183878f, -0.09333254f, 
    -0.05419045f, 0.02334462f, 0.08282879f, 0.00900898f, 0.00988797f, 0.05055850f, 0.01571591f, 0.09830120f, 
    -0.18158621f, 0.08511014f, 0.00926282f, 0.07218960f, -0.01784281f, -0.00492400f, -0.03425314f, 0.10119675f, 
    -0.01207289f, 0.02449861f, 0.01626837f, -0.07185289f, -0.07514643f, -0.08977901f, -0.22903132f, -0.01236881f, 
    0.04730771f, 0.08116090f, 0.00067200f, -0.05428938f, 0.03472041f, -0.09803165f, -0.01717490f, -0.03039039f, 
    0.07663838f, -0.07783962f, 0.04807663f, 0.02182725f, 0.09943034f, 0.01158286f, 0.05895176f, 0.11313503f, 
    0.05593304f, -0.03411285f, 0.01381386f, 0.01188372f, -0.14068641f, -0.17578916f, 0.01485874f, 0.05882749f, 
    0.04965152f, 0.05636188f, -0.05291515f, -0.03498071f, 0.09899504f, 0.05598826f, -0.00603378f, 0.09417919f, 
    -0.35466918f, 0.03507661f, 0.05904359f, -0.09300082f, 0.16007082f, 0.04973355f, 0.06336447f, 0.02336083f, 
    0.10381295f, 0.03826186f, -0.08392131f, 0.00851469f, -0.14410827f, 0.01200914f, 0.07881007f, 0.05221519f, 
    0.04365835f, -0.03813188f, 0.00423984f, 0.03901869f, 0.04236638f, 0.02746467f, -0.01054332f, 0.08972550f, 
    -0.14963175f, 0.12029599f, 0.07049083f, 0.00295095f, 0.04885375f, 0.05648466f, 0.01259202f, 0.06328990f, 
    -0.00744475f, -0.02262466f, 0.04147307f, 0.01721633f, -0.04493726f, 0.07802254f, -0.11857554f, -0.06529817f, 
    0.08063457f, -0.01775200f, -0.01135968f, 0.04912602f, 0.02980467f, 0.01927666f, -0.08387957f, 0.02849685f, 
    0.02674959f, -0.08114481f, -0.25999954f, -0.17653741f, 0.00130040f, 0.05567271f, 0.14540936f, 0.03487883f, 
    -0.01356638f, 0.00054528f, 0.07366586f, 0.04790827f, 0.03004018f, 0.08621350f, 0.06852634f, -0.16862857f, 
    -0.00066080f, 0.05931556f, 0.01414901f, -0.02717654f, -0.02962373f, -0.06895887f, 0.00622934f, 0.00161265f, 
    -0.21268034f, -0.00260315f, -0.04788437f, 0.10556971f, 0.04705310f, -0.01719585f, -0.01840309f, 0.10858199f, 
    -0.00132240f, -0.09599970f, -0.07857491f, -0.05165966f, -0.24829859f, -0.20904768f, 0.02347544f, -0.14293495f, 
    0.10001186f, 0.06381139f, -0.08562258f, 0.02707180f, 0.08482365f, -0.05012095f, -0.06223753f, 0.09144647f, 
    0.10065404f, -0.09215977f, -0.09275857f, 0.21301939f, -0.04634801f, 0.00768078f, 0.01173904f, 0.06434021f, 
    0.02413291f, -0.15373279f, -0.07504076f, -0.06524687f, -0.30109066f, -0.07010799f, -0.16635579f, 0.02916760f, 
    0.14518014f, 0.05845746f, 0.13706364f, -0.09397590f, 0.09503701f, -0.00593073f, 0.02672536f, 0.06785747f, 
    0.22032841f, -0.10785236f, -0.07057882f, -0.02890734f, 0.04501207f, 0.07619844f, 0.10005194f, 0.05759294f, 
    0.01315615f, 0.04173770f, -0.01888527f, 0.06583959f, -0.05809900f, 0.15710486f, -0.06370762f, -0.09604327f, 
    0.04829216f, 0.16551690f, 0.02836864f, 0.01777073f, -0.02706813f, 0.12870410f, 0.00768320f, 0.07341052f, 
    -0.11918765f, 0.03804090f, 0.09705367f, -0.10366054f, -0.16734566f, -0.08894809f, 0.01657826f, 0.09233204f, 
    0.10021933f, 0.03454809f, -0.00511296f, -0.01592007f, -0.01969665f, -0.01898342f, -0.03675732f, -0.05957555f, 
    -0.00072117f, 0.03650514f, -0.06373959f, -0.08007552f, -0.03682186f, -0.05820195f, -0.03710168f, -0.02398247f, 
    -0.01327929f, 0.10955948f, 0.09789493f, -0.04635753f, 0.09021823f, 0.06458730f, 0.07970248f, 0.08530488f, 
    0.02196120f, 0.04025861f, 0.05039281f, -0.00008947f, 0.13929576f, 0.10301536f, 0.21281363f, -0.05264591f, 
    -0.14012907f, 0.00675248f, 0.04404915f, 0.01132387f, 0.06574300f, -0.06958560f, 0.02138899f, 0.01696979f, 
    -0.04995327f, -0.11211511f, 0.09194391f, -0.03220104f, -0.00781048f, -0.02233714f, 0.03771555f, -0.00267860f, 
    0.06873491f, 0.00414135f, -0.05195339f, -0.00351485f, 0.13773391f, 0.03469028f, 0.21340424f, 0.07427417f, 
    -0.01320922f, 0.01395435f, 0.07301598f, 0.10087202f, 0.09335649f, 0.04354521f, 0.03550055f, 0.00973350f, 
    0.12908401f, -0.07824808f, 0.02173294f, -0.01893604f, 0.03351865f, -0.01666734f, 0.11385557f, -0.05750941f, 
    -0.02929305f, 0.04592966f, -0.00654314f, -0.04628488f, 0.16611627f, -0.01164949f, 0.18887652f, 0.26365012f, 
    -0.03789618f, 0.00944354f, 0.01492924f, 0.01592024f, 0.06982034f, -0.04768058f, 0.06553739f, 0.05417579f, 
    0.03151952f, -0.02381398f, 0.24324846f, 0.12453203f, -0.09421860f, -0.01229755f, 0.02114963f, 0.11726025f, 
    -0.03869315f, -0.02123563f, -0.01708401f, 0.02630280f, -0.29539275f, -0.22058313f, -0.20901296f, -0.28466651f, 
    0.09403756f, 0.08384673f, 0.03318378f, -0.05433305f, 0.04742328f, 0.04915696f, 0.01178494f, 0.19250618f, 
    -0.02088173f, 0.12424873f, 0.23903593f, 0.02165255f, 0.01889882f, 0.01611432f, 0.02610466f, 0.05344613f, 
    0.00228950f, -0.00964925f, 0.05069739f, -0.10468543f, 0.07161235f, 0.17513819f, 0.10140408f, -0.04783423f, 
    0.01994373f, -0.01134176f, 0.06663134f, 0.10342581f, -0.00078508f, -0.03603205f, 0.02273571f, 0.10675803f, 
    0.01135708f, -0.30372795f, -0.18303189f, 0.08207520f, 0.08676345f, -0.05410707f, 0.02316090f, -0.01606493f, 
    0.06338274f, 0.08596728f, 0.01128469f, 0.01927180f, -0.33008981f, -0.14044318f, 0.14526674f, -0.06693249f, 
    0.01861331f, 0.00926973f, 0.09466987f, 0.08520029f, 0.10641725f, 0.02446549f, -0.04141675f, 0.06023395f, 
    0.05618862f, -0.03295435f, 0.22145163f, -0.22942556f, -0.02542851f, 0.11135279f, 0.03981982f, 0.07992851f, 
    0.11081888f, 0.04046811f, -0.04701579f, 0.07392468f, 0.07344440f, 0.10098110f, -0.00185936f, 0.19768378f, 
    0.06030293f, 0.12977897f, 0.01594568f, 0.02049237f, 0.03501493f, 0.08445410f, -0.00737333f, -0.00265937f, 
    -0.31123668f, -0.04085638f, -0.07347427f, -0.18540791f, 0.04353027f, 0.02185720f, 0.08723738f, -0.04108969f, 
    0.00559453f, 0.06621318f, -0.03242207f, 0.03077237f, -0.17899440f, 0.11690592f, -0.17833161f, 0.05562759f, 
    0.09528069f, -0.06709155f, -0.00052289f, 0.01484638f, 0.07835406f, -0.00321116f, 0.06081982f, 0.01859219f, 
    -0.00221756f, -0.02533286f, -0.07611241f, -0.19561015f, 0.02647438f, 0.01068908f, 0.05692193f, -0.00944956f, 
    0.02151848f, -0.07967535f, -0.01540244f, 0.09177465f, 0.27511260f, 0.12913276f, 0.07539897f, -0.04938700f, 
    -0.03402684f, 0.05122427f, -0.03290030f, -0.01639785f, 0.00012410f, -0.00985639f, 0.11075342f, -0.11284912f, 
    0.03188298f, 0.00430099f, 0.03736350f, 0.11789702f, 0.13668254f, 0.09681219f, -0.07388148f, 0.05758996f, 
    -0.09872121f, -0.08073766f, -0.10387402f, 0.00434919f, -0.23670998f, -0.00841011f, 0.07586590f, 0.19229954f, 
    0.07177665f, -0.04242275f, -0.06446004f, 0.14069527f, -0.01171201f, -0.04198284f, 0.08371129f, -0.04697278f, 
    -0.13681476f, 0.06917664f, -0.08128086f, 0.08018645f, -0.02248610f, -0.07427536f, 0.04653419f, 0.00585773f, 
    -0.06514351f, 0.04198175f, 0.00193578f, -0.13364242f, 0.12893479f, 0.05455738f, -0.03709638f, -0.20821752f, 
    0.08987699f, 0.08183221f, -0.01059238f, -0.01110410f, -0.00424907f, -0.07622147f, 0.00510096f, 0.00126063f, 
    0.22949122f, 0.00094916f, -0.08846840f, 0.00147343f, 0.04634516f, -0.03220389f, 0.03530416f, 0.01607905f, 
    -0.03499864f, 0.03498180f, -0.05739721f, -0.06740210f, 0.19095148f, -0.15014683f, -0.17347483f, -0.01389361f, 
    0.06024284f, 0.03611445f, -0.00049340f, 0.06680840f, -0.00816032f, 0.04681415f, 0.02175264f, 0.00518756f, 
    0.06417384f, -0.18521325f, -0.01091415f, 0.09937162f, -0.03805411f, 0.05344280f, 0.06806274f, -0.05862398f, 
    -0.07633232f, -0.04104707f, 0.04932370f, 0.05417887f, 0.16784835f, 0.12571958f, -0.01753976f, 0.02843900f, 
    0.00704989f, 0.00575384f, 0.02451726f, 0.10483203f, 0.03268068f, 0.04496437f, 0.02627864f, -0.01791530f, 
    -0.16145502f, -0.04540750f, 0.11702871f, 0.03637155f, 0.04947354f, -0.01440829f, 0.09635829f, 0.12037723f, 
    -0.01093933f, 0.08357222f, -0.03584848f, 0.17193216f, -0.10769374f, -0.09398267f, -0.11737074f, -0.08335066f, 
    0.02599644f, -0.09178131f, 0.12053450f, 0.07866011f, 0.07635894f, 0.12562042f, 0.00828131f, 0.07440352f, 
    0.13993624f, 0.23774798f, -0.00554331f, -0.02604355f, -0.02437908f, -0.07556934f, 0.00948119f, 0.01831977f, 
    0.11776660f, 0.04661779f, -0.03793263f, 0.06739065f, 0.14456710f, 0.07663431f, 0.12409525f, -0.03608257f, 
    -0.02051870f, 0.06583890f, 0.04132629f, -0.00419137f, -0.04700497f, -0.00630839f, 0.05925969f, -0.01788663f, 
    -0.28658089f, -0.08534261f, -0.02859842f, -0.00563309f, 0.00933946f, -0.01310701f, -0.04696377f, -0.04052534f, 
    0.00053456f, 0.09265649f, 0.06165957f, 0.07625124f, -0.07937076f, -0.25178519f, 0.04428707f, 0.06484991f, 
    0.02820092f, 0.05127355f, -0.06097190f, 0.09050489f, -0.03826844f, 0.09173701f, -0.01034692f, 0.04805955f, 
    0.26192185f, 0.03835774f, 0.00208974f, 0.00448663f, 0.17496029f, 0.01545019f, -0.01979643f, -0.04688768f, 
    0.02323011f, -0.04053170f, 0.07170705f, -0.03950089f, -0.08686345f, 0.10388325f, 0.27764526f, 0.01395823f, 
    0.09068076f, -0.05668489f, -0.00059728f, 0.01529055f, 0.07818124f, 0.06234924f, 0.04099397f, 0.07966928f, 
    -0.18298332f, 0.01988345f, -0.05516864f, -0.04666293f, -0.02082540f, -0.13343766f, 0.01688947f, 0.06815560f, 
    0.17352207f, -0.04823921f, -0.05274777f, 0.07329940f, 0.18151459f, -0.08006884f, -0.04301968f, -0.12867400f, 
    0.05075480f, 0.00469321f, 0.11842892f, 0.02231763f, 0.08388742f, 0.01171700f, -0.00747688f, -0.01567821f, 
    -0.20987535f, 0.16116950f, -0.14417192f, -0.04456559f, -0.06237841f, -0.01651205f, -0.02181540f, -0.04416605f, 
    0.08063553f, -0.07099382f, 0.05332232f, -0.08749894f, -0.23256423f, -0.07468060f, -0.13275070f, 0.06762055f, 
    0.04326746f, -0.01522720f, -0.03923104f, -0.00935213f, 0.04662531f, -0.02300263f, -0.00991924f, 0.01308254f, 
    0.16631013f, 0.14025487f, 0.07872898f, 0.06381209f, -0.04764326f, 0.10275514f, 0.05307476f, 0.06107784f, 
    -0.00540173f, -0.10618962f, 0.10869089f, -0.09827573f, 0.04134224f, -0.11787853f, -0.12159433f, -0.13013719f, 
    0.04705958f, -0.03266010f, -0.01752032f, 0.06308107f, 0.01675945f, 0.07449161f, -0.02040092f, -0.01409135f, 
    -0.16080697f, -0.11359710f, -0.14759828f, -0.08894763f, 0.01738660f, -0.03438144f, -0.01593617f, -0.04391657f, 
    -0.07862445f, -0.02877747f, 0.00054271f, 0.20872065f, 0.04608718f, -0.17224757f, -0.12582201f, 0.03762906f, 
    -0.02429838f, -0.03720720f, 0.00483268f, 0.07029234f, -0.10425892f, 0.04372824f, -0.04622772f, -0.02180781f, 
    0.16217735f, 0.13820584f, -0.28496623f, 0.00108586f, -0.08671789f, 0.16591497f, 0.00470325f, 0.05283450f, 
    -0.02432356f, 0.08712120f, 0.06174679f, 0.12826648f, -0.17955223f, 0.05092205f, -0.00530698f, -0.00283440f, 
    0.03080722f, 0.00966178f, -0.01373497f, -0.03931030f, 0.04501973f, -0.01490341f, 0.04213209f, 0.06120728f, 
    0.34257656f, 0.16268584f, -0.06493600f, 0.09088976f, 0.08880857f, -0.01878277f, 0.03976825f, 0.03588166f, 
    0.03821852f, 0.01031904f, -0.03814042f, -0.05935086f, 0.11249875f, 0.12818454f, -0.02705380f, 0.02835165f, 
    0.02274981f, -0.01441653f, 0.01676339f, 0.13978198f, 0.09624969f, 0.09861010f, 0.03651964f, -0.01042769f, 
    0.27095962f, 0.03618156f, 0.05736681f, 0.02692743f, 0.10037342f, 0.00846228f, 0.03907694f, 0.03032353f, 
    0.02056799f, 0.07770137f, -0.08216752f, -0.04751169f, -0.00338123f, 0.00710055f, -0.06384563f, -0.04775766f, 
    -0.06570835f, -0.14203396f, -0.00238022f, 0.07581632f, 0.01215766f, 0.02456586f, -0.03092191f, 0.00348795f, 
    0.04109162f, -0.02372059f, 0.21221745f, -0.06394668f, -0.00478170f, -0.01038811f, -0.06819795f, -0.02311644f, 
    -0.02809066f, 0.04540612f, 0.02867858f, -0.01789049f, -0.11573830f, -0.19659597f, 0.06599771f, 0.02117812f, 
    -0.01905606f, -0.01255767f, 0.07871545f, 0.00463893f, 0.01686041f, 0.07312610f, 0.08157058f, 0.05327532f, 
    0.04424016f, 0.04044847f, -0.02331226f, 0.09975705f, 0.01304514f, -0.08034585f, 0.02710859f, 0.00853619f, 
    -0.02277223f, -0.08500712f, 0.05418871f, -0.03701124f, -0.03972765f, 0.08120052f, 0.15131374f, 0.02459164f, 
    0.08897809f, 0.10311545f, 0.03877256f, 0.10801278f, 0.01384666f, 0.01387460f, 0.11234759f, 0.03286361f, 
    -0.24127802f, 0.11482699f, -0.08320488f, 0.03624222f, 0.05252612f, -0.06473275f, -0.02854484f, 0.04151331f, 
    -0.02148831f, 0.01383838f, 0.05743042f, 0.01410668f, 0.01445303f, -0.00693942f, 0.00042889f, -0.15155980f, 
    0.06154747f, -0.00663658f, 0.01234854f, 0.02502383f, 0.06162600f, 0.00814957f, -0.02489309f, -0.02787745f, 
    -0.08782093f, -0.07894827f, 0.08436582f, 0.04538383f, 0.07628549f, -0.03411680f, -0.09024491f, 0.12495621f, 
    -0.07982273f, 0.01197762f, -0.02716125f, -0.00022713f, 0.11427245f, 0.04174074f, 0.10365371f, 0.21681342f, 
    -0.07626368f, -0.00565118f, 0.04039053f, 0.05166043f, 0.08919976f, -0.01209640f, -0.11178611f, 0.00963769f, 
    -0.36818281f, -0.07725140f, -0.04210101f, -0.00456827f, 0.02273260f, -0.02107973f, -0.00459876f, -0.01434328f, 
    0.06902269f, 0.03816622f, -0.04809773f, -0.08170450f, 0.11980508f, 0.24249078f, -0.07051164f, 0.16436598f, 
    -0.00605705f, -0.09652066f, 0.04629578f, 0.09792691f, 0.05385216f, 0.07417150f, 0.04923901f, -0.00561242f, 
    0.09171520f, 0.02124342f, -0.07722826f, -0.07418881f, 0.08185473f, 0.05946134f, 0.09269489f, -0.03040771f, 
    -0.01067363f, 0.10489729f, -0.00681506f, -0.00950356f, -0.35087347f, -0.15265375f, 0.03532918f, 0.06583361f, 
    -0.01794756f, -0.03351942f, -0.01888423f, -0.02206457f, -0.02270806f, 0.02031983f, 0.00305092f, -0.02387036f, 
    -0.05336022f, -0.00692558f, -0.11887222f, -0.04541122f, 0.04772740f, 0.01259728f, -0.10058530f, 0.07593279f, 
    0.00622546f, -0.00525266f, -0.03360525f, -0.04401834f, -0.15603574f, -0.17601481f, 0.00107685f, -0.01610211f, 
    0.08819421f, -0.05009483f, -0.07094852f, 0.04417289f, 0.01630219f, -0.03797802f, -0.01728451f, 0.11220060f, 
    0.26717728f, 0.13742842f, 0.09850625f, 0.13948621f, 0.01415086f, -0.04075842f, -0.00113172f, 0.04013498f, 
    0.10145098f, -0.07998046f, -0.00048034f, -0.03114233f, 0.11206187f, 0.01751500f, 0.17185885f, 0.01416448f, 
    0.03434645f, 0.09967604f, 0.02443867f, 0.00495404f, -0.00033855f, -0.01699148f, -0.07992093f, -0.05954622f, 
    0.22274508f, -0.00298982f, 0.00813852f, -0.13188626f, 0.02108577f, 0.00269332f, -0.06549128f, -0.03699210f, 
    0.01666662f, -0.00307256f, 0.01367237f, 0.02466097f, 0.10160282f, 0.03575918f, 0.10690752f, -0.01607060f, 
    0.12944953f, -0.00949864f, -0.03142307f, 0.05366409f, 0.06273124f, -0.02420029f, -0.12239043f, -0.03655411f, 
    0.11655772f, 0.01824619f, -0.18568935f, 0.10273670f, -0.02213636f, 0.02482115f, 0.06353778f, 0.02444956f, 
    -0.00698733f, -0.03149379f, 0.01687554f, 0.00248133f, 0.10214534f, 0.09952669f, -0.07676563f, -0.13802251f, 
    -0.10828953f, -0.01301827f, 0.06236114f, 0.07605480f, 0.10564329f, -0.03847242f, 0.08003437f, 0.06649622f, 
    -0.02534266f, -0.00107094f, -0.06502207f, 0.06574621f, -0.14756908f, -0.10420319f, 0.04797173f, 0.05927362f, 
    0.05503372f, -0.07069714f, -0.01350743f, 0.01391239f, -0.16247299f, -0.07386140f, -0.17495510f, 0.00641011f, 
    0.03324632f, 0.00574509f, 0.02098159f, -0.09379929f, -0.03561394f, 0.03147270f, 0.11344497f, -0.01589824f, 
    0.20057610f, 0.10643838f, 0.02255629f, -0.08207724f, 0.08521367f, -0.04640136f, -0.06728421f, 0.01207888f, 
    0.04942628f, 0.03562117f, 0.10973466f, -0.02108422f, -0.28449538f, -0.06293190f, -0.00364969f, 0.21026202f, 
    0.02434595f, -0.11193463f, 0.04403013f, 0.04212083f, -0.06604337f, 0.02032520f, 0.07822145f, -0.02614765f, 
    -0.17451665f, 0.06260400f, -0.05758862f, 0.02551092f, 0.09347942f, -0.10989073f, 0.02559200f, 0.07766987f, 
    -0.00728735f, 0.01723969f, 0.03902372f, -0.04311724f, 0.15057354f, 0.14532930f, 0.07193220f, -0.06747349f, 
    0.03743864f, 0.01344966f, 0.01427598f, 0.01090077f, 0.09730086f, 0.01091486f, 0.00892457f, 0.02610596f, 
    0.03811572f, 0.10670062f, 0.05620888f, -0.00194167f, 0.06623644f, -0.02032425f, 0.05335743f, 0.02992001f, 
    -0.04892258f, -0.01814997f, 0.05524879f, 0.04949495f, 0.10374987f, 0.06674083f, -0.22881284f, 0.08807792f, 
    0.05217484f, 0.03844591f, -0.04487364f, 0.07247046f, -0.11275648f, 0.04287897f, 0.03986422f, -0.07726420f, 
    0.17219415f, -0.00224255f, -0.15774861f, 0.03814301f, 0.02619003f, -0.07450718f, 0.07605830f, 0.00719448f, 
    0.06629053f, -0.02147415f, 0.08753060f, 0.02710063f, -0.07412752f, -0.06593911f, -0.07999966f, -0.21936877f, 
    0.03474548f, 0.05177678f, 0.04015050f, -0.03095959f, 0.02445739f, -0.10631251f, 0.01326900f, -0.01599080f, 
    -0.09575848f, -0.19424604f, -0.02697132f, 0.16266143f, 0.02057358f, 0.03975960f, 0.06408317f, 0.17844383f, 
    -0.03682248f, 0.10450487f, -0.03310535f, 0.01324198f, -0.20446664f, 0.01840967f, -0.03684940f, -0.06237920f, 
    0.14661731f, 0.00925478f, 0.02162724f, 0.13738345f, -0.07304701f, -0.15981041f, 0.19869871f, -0.03931011f, 
    -0.04121926f, -0.02331099f, -0.04320863f, 0.00882858f, -0.03989025f, -0.00774322f, -0.00488079f, -0.02028734f, 
    -0.01603455f, -0.03268031f, 0.01460061f, 0.02404667f, 0.01290184f, -0.02871002f, -0.01424843f, -0.03581206f, 
    -0.00587873f, 0.00378535f, -0.03678373f, 0.02062380f, 0.02558121f, -0.00248837f, -0.03614480f, -0.01157347f, 
    -0.00725201f, -0.01091821f, -0.03420805f, 0.01422469f, -0.02021812f, 0.00325616f, -0.02439731f, -0.00282767f, 
    -0.01444059f, 0.01928255f, 0.01728504f, 0.00148265f, -0.03810049f, -0.03237397f, -0.01107086f, -0.00467370f, 
    0.01732403f, -0.04325319f, -0.03082438f, 0.01273442f, -0.00023489f, -0.01085214f, -0.03823128f, 0.00444970f, 
    -0.04456597f, 0.00082787f, 0.00246245f, -0.03744168f, 0.01378326f, -0.03910194f, -0.00227275f, -0.02755832f, 
    -0.04151168f, 0.00804651f, -0.02727912f, 0.01938915f, 0.01707251f, 0.00799614f, 0.00580221f, -0.01087370f, 
    -0.01468372f, -0.02294357f, 0.00338681f, -0.01717149f, -0.01530859f, -0.00705825f, -0.02025675f, 0.02731205f, 
    -0.01496754f, -0.01688992f, -0.02350664f, -0.04403794f, 0.02560706f, 0.00041468f, -0.00838295f, 0.00027891f, 
    0.00326180f, 0.00985019f, 0.00536679f, -0.04281727f, -0.00483747f, 0.02636373f, 0.01485108f, 0.02316955f, 
    0.02587630f, 0.01598597f, -0.03112773f, -0.01053650f, -0.03411992f, 0.00646861f, 0.01196370f, 0.01700886f, 
    -0.01303118f, -0.03891669f, -0.03072757f, -0.00232807f, 0.00191775f, 0.01710324f, -0.01291114f, -0.01434458f, 
    0.00114641f, 0.02687290f, -0.00521830f, -0.02537404f, -0.04056121f, 0.01293915f, 0.00429501f, -0.03418814f, 
    0.01845150f, 0.01410516f, 0.01534604f, 0.01147726f, -0.02508450f, -0.00794329f, -0.01385250f, -0.01840038f, 
    -0.00258330f, -0.03030878f, -0.01448014f, -0.02957806f, 0.02648056f, -0.01587909f, -0.00109445f, -0.03334940f, 
    0.01921006f, -0.00505149f, -0.03425096f, 0.02512045f, 0.02616473f, 0.02601655f, 0.00517550f, 0.00895115f, 
    -0.01630671f, 0.02585084f, 0.01278581f, 0.01680918f, -0.02891981f, 0.03023170f, 0.02357471f, -0.00596039f, 
    0.01448149f, -0.01932552f, -0.03112641f, 0.00190304f, 0.00347191f, -0.01883877f, 0.01217468f, 0.02299110f, 
    0.00738429f, -0.02974876f, -0.02205465f, 0.01530772f, 0.00611630f, 0.00824653f, -0.04149456f, -0.01780997f, 
    -0.03898017f, -0.01080164f, -0.02685290f, 0.00102122f, -0.01540506f, -0.01077722f, -0.00758187f, -0.02500836f, 
    0.02534389f, -0.01034308f, -0.00714042f, 0.00083006f, -0.00103238f, -0.00220867f, -0.02184609f, -0.04223473f, 
    -0.03910527f, -0.00425312f, -0.01906195f, 0.00037070f, -0.04392922f, -0.03993597f, -0.01527743f, -0.03608161f, 
    -0.01245518f, -0.02674360f, 0.02597380f, -0.02583539f, 0.00675627f, 0.01496388f, -0.02875585f, 0.00740314f, 
    -0.00592862f, 0.01809986f, -0.01171986f, -0.00979552f, -0.03969202f, -0.00778746f, 0.01623244f, 0.02834307f, 
    0.00993286f, 0.00359830f, -0.03140315f, -0.01984265f, 0.02414879f, -0.04339171f, 0.01555627f, 0.00438506f, 
    0.01075098f, 0.00068868f, -0.02251849f, -0.03824524f, -0.02869402f, -0.01742725f, -0.04243675f, -0.04000968f, 
    -0.03503982f, 0.00293236f, 0.01472580f, -0.02808938f, -0.00341320f, -0.01235396f, -0.02838445f, -0.01580408f, 
    -0.04024792f, -0.01999049f, -0.04178080f, 0.01651926f, -0.00939511f, 0.01592656f, -0.04426633f, -0.03430359f, 
    -0.03170975f, -0.00202547f, -0.03532503f, -0.02335946f, -0.00555283f, -0.00479432f, 0.02245550f, 0.00012307f, 
    -0.00109318f, 0.02613748f, -0.04067629f, -0.01314411f, 0.00066984f, -0.00786913f, -0.01058929f, -0.02244206f, 
    0.01494270f, -0.01710401f, -0.00720901f, -0.02433976f, -0.00858064f, -0.03223627f, -0.01347988f, -0.00541627f, 
    -0.04012476f, -0.01925777f, 0.00891077f, 0.02352207f, -0.02945962f, -0.03644225f, 0.02232637f, -0.03120712f, 
    -0.04509057f, 0.01669541f, 0.01675043f, -0.03927921f, 0.01843962f, -0.02934374f, 0.01458978f, -0.01553729f, 
    0.01660994f, -0.02757872f, -0.03147880f, 0.02452800f, 0.00169060f, 0.00910047f, 0.00542540f, -0.01716265f, 
    -0.01084109f, -0.04240210f, -0.03541678f, -0.01461441f, -0.04247107f, 0.00686044f, -0.02559829f, -0.02552546f, 
    0.02738278f, -0.00714310f, -0.01356382f, 0.01583447f, 0.00218493f, -0.00681992f, 0.00959929f, -0.00946003f, 
    0.00463623f, -0.00687929f, -0.02352800f, -0.01056703f, 0.00379557f, -0.03768115f, 0.00800357f, -0.03527335f, 
    -0.02508931f, -0.02450774f, 0.00644421f, 0.00786376f, 0.01593853f, -0.01013436f, 0.02987737f, 0.00098926f, 
    0.02445651f, -0.02784208f, 0.00107757f, -0.02328874f, -0.01731311f, 0.00390643f, 0.02123570f, 0.02111400f, 
    0.01156364f, 0.00942868f, 0.02296714f, -0.03220721f, -0.00462023f, -0.02038871f, 0.00204888f, -0.02252547f, 
    0.02269505f, -0.02711777f, 0.00495085f, -0.03312764f, 0.02289659f, 0.01215369f, 0.01658443f, -0.00729869f, 
    0.01842773f, 0.01431161f, 0.01102488f, 0.00766780f, -0.02997541f, 0.01365874f, -0.03205217f, -0.02363651f, 
    -0.03270255f, 0.01099501f, -0.01021291f, -0.01472004f, 0.00694051f, -0.03150443f, 0.02552765f, -0.01876900f, 
    0.01587904f, -0.02542708f, 0.03106723f, 0.00223765f, 0.00720055f, 0.01638432f, -0.00268234f, -0.00084237f, 
    0.00986221f, 0.02108104f, 0.00231215f, 0.02279769f, -0.04499108f, -0.03709266f, -0.00207938f, 0.02742177f, 
    0.01521510f, 0.00719356f, 0.01749086f, -0.02942954f, -0.02705189f, -0.02235258f, 0.00414204f, -0.02637097f, 
    0.00399336f, 0.00505369f, -0.01190323f, -0.02969374f, 0.00585747f, 0.00934363f, -0.02336536f, 0.01175416f, 
    0.02251892f, -0.01199141f, 0.01566264f, -0.00585836f, 0.00308689f, -0.04402846f, -0.00943087f, -0.02840466f, 
    0.02476235f, 0.02835846f, 0.02914669f, -0.00484826f, -0.03626392f, -0.01178757f, -0.02144626f, 0.01065566f, 
    -0.01858084f, -0.00843182f, -0.02623769f, 0.02059441f, -0.01507248f, 0.01087151f, 0.00942339f, 0.02400830f, 
    0.02848398f, -0.01841333f, 0.01504297f, 0.00451282f, 0.00371846f, -0.00750441f, -0.03748030f, -0.01009479f, 
    -0.00414596f, -0.01450661f, -0.01734174f, -0.04181835f, -0.02079290f, -0.02629244f, 0.01446980f, -0.00144482f, 
    0.00127465f, 0.01167269f, -0.03309995f, 0.02180072f, -0.00985732f, 0.00320082f, 0.01523981f, -0.03946339f, 
    0.00595024f, -0.03196194f, -0.01817165f, -0.02643389f, 0.02691116f, -0.00249666f, -0.04328637f, -0.00774526f, 
    -0.00590364f, -0.00326466f, 0.01833939f, 0.00350845f, -0.01275199f, 0.01237550f, -0.01526903f, -0.02668900f, 
    0.01331893f, 0.01122228f, 0.02514750f, -0.00733265f, 0.01444908f, -0.02057724f, 0.02376865f, -0.04232079f, 
    0.02110382f, 0.00045872f, -0.03111761f, 0.02132510f, 0.02473306f, -0.03719831f, 0.02917119f, -0.00769794f, 
    -0.00908003f, -0.04209987f, -0.03273844f, -0.04436375f, -0.02795998f, 0.00394542f, -0.00198330f, 0.01895443f, 
    -0.04048429f, -0.04339536f, -0.01013906f, 0.01010840f, 0.00210123f, 0.00136209f, -0.00378918f, -0.04181297f, 
    0.02358453f, -0.03252441f, -0.02904928f, -0.00995562f, -0.02749329f, 0.00614392f, -0.01218047f, 0.00538505f, 
    0.02228040f, -0.02938546f, 0.01788161f, -0.00836752f, 0.00443138f, -0.01922399f, -0.03833440f, -0.00096567f, 
    -0.01183697f, -0.04160510f, 0.01862590f, -0.03184393f, 0.02700968f, -0.00421017f, -0.02443659f, -0.03238840f, 
    0.01850356f, -0.04458736f, -0.03904268f, -0.02144831f, 0.01467599f, -0.02669425f, -0.03480969f, -0.00467554f, 
    -0.01496258f, -0.04250971f, -0.03122066f, -0.03751084f, -0.00011802f, -0.01291195f, 0.01787078f, -0.02768436f, 
    -0.03393617f, -0.00864553f, -0.02932527f, 0.01802543f, -0.00732393f, 0.01197761f, 0.00517224f, -0.01021226f, 
    -0.03665377f, -0.01490890f, -0.02628831f, 0.00526334f, -0.01029864f, -0.01034437f, -0.01734092f, -0.00603866f, 
    -0.02456315f, -0.02410871f, 0.01597163f, -0.02728550f, -0.03403652f, 0.01951678f, -0.03973162f, 0.02284179f, 
    -0.01827641f, 0.02639154f, -0.02957595f, 0.02525380f, 0.01319151f, -0.02964487f, 0.02466455f, -0.01876715f, 
    -0.00952668f, 0.01252893f, -0.00586842f, 0.00408141f, 0.01536491f, -0.01865382f, 0.03288873f, -0.03107120f, 
    -0.00346507f, -0.04375436f, 0.00725047f, -0.01944211f, 0.00326727f, -0.03648471f, -0.01200140f, 0.01635870f, 
    -0.01019069f, -0.02688299f, 0.00904716f, 0.02659788f, -0.00360820f, 0.00818350f, -0.03564933f, -0.00908877f, 
    0.01351571f, 0.02626490f, -0.01692154f, -0.03198797f, -0.02849876f, 0.01230700f, -0.02013541f, 0.00673356f, 
    -0.03644362f, -0.01752757f, -0.01113238f, -0.03444894f, -0.02080327f, -0.04210792f, -0.00948110f, 0.00482767f, 
    0.02325722f, 0.03215174f, 0.00106926f, -0.02136926f, -0.00706011f, 0.02000335f, -0.02398974f, -0.02069037f, 
    -0.01014100f, 0.00661242f, -0.03173480f, -0.01088830f, 0.01734241f, 0.00154797f, -0.02388158f, 0.02603118f, 
    -0.02094733f, -0.01474482f, 0.02468667f, 0.03323086f, 0.01384443f, -0.00706737f, 0.00002628f, 0.01212835f, 
    -0.00004500f, 0.01660552f, 0.01433473f, -0.01212880f, -0.00211427f, 0.02732057f, -0.04297308f, -0.00068942f, 
    -0.02997188f, -0.03979857f, -0.02641354f, -0.04195141f, 0.01080284f, 0.02058053f, 0.01507948f, 0.01752553f, 
    -0.02818604f, -0.01436582f, -0.00895981f, -0.03893949f, -0.01412349f, 0.00376550f, -0.02300330f, -0.03071517f, 
    0.02425763f, 0.01564903f, -0.01420775f, 0.02409429f, -0.03523419f, 0.01661762f, 0.00695310f, 0.02187827f, 
    -0.03255259f, -0.01997088f, -0.02573024f, -0.03626997f, -0.00702260f, -0.02633586f, -0.04513413f, 0.00911642f, 
    -0.03072105f, -0.00215782f, -0.03722901f, -0.00865778f, -0.00792865f, 0.02628132f, -0.00348291f, -0.03480754f, 
    0.00413877f, -0.02215296f, 0.02361138f, -0.02807140f, -0.03829675f, -0.00087215f, 0.01642023f, -0.03184117f, 
    -0.00190308f, 0.00502474f, 0.02539881f, -0.00870162f, -0.02570153f, 0.02629657f, -0.01680760f, -0.00582003f, 
    0.00421618f, -0.03354330f, 0.02463569f, -0.01343562f, -0.01626405f, -0.04420359f, -0.00420719f, -0.02243346f, 
    -0.04000259f, -0.02624258f, 0.00372122f, 0.00379876f, 0.00007503f, -0.04021223f, 0.02616440f, 0.02517452f, 
    0.00074509f, 0.00170108f, -0.02168226f, -0.03540354f, -0.04240797f, -0.00204912f, -0.04116429f, -0.02178852f, 
    -0.01654896f, -0.00365267f, -0.01418377f, -0.01298950f, 0.01470711f, 0.01435461f, 0.02953872f, 0.01120228f, 
    -0.00874207f, 0.01551632f, 0.02584343f, -0.01544984f, -0.03469066f, -0.01640702f, -0.02452410f, 0.01964550f, 
    0.00420371f, -0.02331803f, -0.03395094f, 0.02162240f, -0.04000627f, -0.00642657f, -0.01190404f, 0.00009846f, 
    0.01995747f, -0.04073504f, -0.00959075f, 0.00195721f, 0.00131195f, -0.02651620f, -0.02118150f, -0.02235493f, 
    -0.03940149f, 0.01434477f, -0.00110815f, 0.01501844f, -0.03346225f, -0.02558907f, -0.04051106f, 0.01581772f, 
    -0.02807141f, -0.00865369f, 0.00949852f, -0.00025701f, -0.01265713f, 0.01848469f, 0.00517690f, -0.01606418f, 
    -0.03368401f, 0.02538047f, 0.01440838f, 0.02034882f, 0.01533214f, 0.00088726f, 0.01582636f, -0.02888874f, 
    0.02233753f, -0.02901093f, -0.01086150f, -0.00033211f, -0.03077508f, -0.03589689f, -0.03130168f, -0.02728916f, 
    0.04463896f, 0.11934680f, 0.07575229f, -0.13613883f, 0.10618290f, 0.02756511f, 0.05984785f, -0.03647278f, 
    -0.03603393f, -0.03935209f, -0.05764679f, -0.01699512f, -0.01432789f, -0.04742755f, 0.03686926f, -0.15934412f, 
    0.04528102f, 0.01753386f, -0.00673763f, -0.04298403f, 0.05932305f, -0.05096220f, 0.04830229f, -0.00914710f, 
    0.17973228f, 0.15750244f, 0.14683171f, 0.09660494f, -0.01531812f, 0.03787465f, -0.00960920f, 0.08717696f, 
    0.08199811f, -0.06674536f, 0.13285016f, 0.02435777f, 0.06096036f, -0.02448008f, 0.02223910f, 0.18403690f, 
    -0.13174216f, -0.06515593f, 0.01500855f, 0.05771848f, 0.04479299f, -0.03383827f, 0.07412399f, 0.01998248f, 
    0.11796760f, 0.09401464f, -0.18423405f, 0.09417581f, 0.00127967f, 0.10696030f, 0.00525596f, 0.02374528f, 
    0.01870864f, -0.00910137f, 0.07974257f, -0.03957700f, -0.06778697f, -0.06367987f, -0.01370434f, 0.05061629f, 
    -0.00624711f, 0.04134527f, -0.03128909f, -0.09304804f, 0.06255094f, -0.07339158f, -0.06027059f, 0.04108937f, 
    -0.26722151f, -0.04192025f, 0.21731970f, -0.14608976f, -0.05917573f, -0.04226288f, 0.02048525f, -0.04140991f, 
    0.01739026f, -0.04157661f, -0.00553418f, 0.05246338f, 0.31517890f, 0.02184998f, -0.08525383f, 0.01263603f, 
    -0.02182699f, -0.08020238f, 0.03758794f, -0.03082505f, 0.06797849f, -0.01644085f, -0.02709106f, 0.09019008f, 
    -0.02695121f, 0.15306319f, 0.11410819f, -0.12499387f, 0.03106821f, -0.01069496f, 0.11978894f, 0.04663931f, 
    -0.02739382f, 0.11791917f, 0.02670020f, 0.08423219f, -0.13980789f, -0.18273376f, -0.21682341f, 0.23006791f, 
    0.08978146f, 0.04120360f, -0.00654489f, 0.02546782f, 0.04764099f, -0.02707592f, 0.00421544f, 0.09514561f, 
    0.17613107f, 0.06992748f, 0.02330211f, 0.06796674f, 0.00589660f, 0.10789264f, -0.05966438f, 0.10649428f, 
    0.16806184f, -0.01061763f, -0.05962228f, 0.07626870f, -0.10883268f, -0.10571523f, 0.07254414f, 0.02216152f, 
    0.02559831f, 0.05775930f, 0.06746266f, -0.04049955f, 0.07020066f, 0.17056087f, 0.06409810f, 0.03039287f, 
    -0.21508484f, -0.05965368f, -0.06352950f, 0.03758726f, 0.02026304f, 0.00269828f, 0.05310474f, -0.00237106f, 
    0.02539477f, 0.12030195f, -0.07386052f, 0.06387404f, -0.10838073f, -0.01648592f, 0.03351191f, -0.27039552f, 
    0.08369855f, 0.04080721f, -0.06886701f, -0.06243681f, -0.00786615f, -0.03428332f, 0.08177603f, -0.07564073f, 
    0.08916555f, -0.04288180f, -0.00454347f, 0.18109354f, -0.03572400f, -0.00502198f, -0.00006507f, -0.01249586f, 
    -0.05627947f, -0.00180772f, 0.01583974f, 0.01831764f, 0.12244675f, 0.13282491f, 0.17432679f, 0.11251219f, 
    -0.00047822f, -0.10768344f, -0.02563066f, 0.17452663f, -0.05197187f, 0.00261436f, 0.04372773f, 0.00947911f, 
    -0.10361396f, -0.06635455f, -0.02828520f, -0.15020567f, -0.01970685f, 0.04143727f, 0.03009425f, 0.04056753f, 
    0.10033414f, -0.03231671f, 0.01421982f, -0.00432232f, -0.13421951f, -0.22031446f, -0.05400361f, -0.06555016f, 
    0.13441029f, 0.06852245f, 0.06994533f, -0.10235224f, 0.07865881f, -0.01187607f, -0.04171407f, 0.05078925f, 
    0.11340754f, -0.02249437f, 0.12890425f, 0.09345142f, -0.05314573f, -0.01549559f, -0.00077341f, -0.07428681f, 
    0.24936867f, 0.03879497f, -0.13247094f, -0.00103907f, 0.02550892f, 0.05537441f, 0.11762793f, -0.21953399f, 
    0.17336333f, -0.00249510f, 0.05731222f, -0.05599475f, -0.03101792f, 0.04324622f, 0.08909272f, 0.04045164f, 
    -0.01540853f, -0.00052796f, -0.12708318f, -0.06832668f, 0.01245436f, -0.02220924f, -0.00709361f, 0.01990146f, 
    0.07964267f, -0.02614703f, -0.02275837f, 0.02210832f, -0.11881824f, 0.04067983f, 0.08434806f, -0.08334252f, 
    0.06960826f, 0.04857011f, 0.00859495f, 0.02906391f, 0.02304403f, 0.02757933f, -0.04831779f, -0.12449414f, 
    -0.21613276f, 0.02845159f, -0.11147307f, 0.01209137f, 0.09658360f, 0.05674354f, -0.03041259f, -0.01015198f, 
    0.09899560f, -0.01452335f, -0.00799088f, -0.11805444f, 0.19003139f, 0.10465552f, -0.13398328f, -0.01981097f, 
    0.03689587f, -0.04143225f, 0.08187458f, 0.20722853f, 0.07386285f, 0.01743564f, 0.05532211f, -0.00258682f, 
    -0.02421086f, 0.08588783f, 0.10707764f, 0.07172793f, 0.03437445f, -0.07238654f, -0.07756038f, 0.01161404f, 
    0.01414848f, -0.10158909f, 0.19396454f, 0.14062440f, 0.03755030f, -0.09441239f, -0.14373629f, 0.29627514f, 
    -0.03449489f, -0.11504941f, 0.01354305f, 0.09719783f, -0.09023160f, 0.10750978f, -0.06436824f, 0.11677565f, 
    0.09627179f, 0.30389252f, -0.08236708f, -0.24798980f, 0.08582679f, 0.09734955f, -0.04647399f, 0.02819354f, 
    0.02480888f, 0.05303733f, 0.09968611f, 0.03990860f, 0.23353437f, -0.17149483f, 0.08692073f, 0.04365122f, 
    -0.08351366f, 0.06880971f, -0.06678196f, -0.04989644f, 0.05232629f, -0.01090250f, -0.04119916f, 0.09169593f, 
    0.00176967f, -0.11804323f, -0.26043826f, 0.08457508f, 0.06446511f, 0.00629584f, -0.06875917f, 0.01792670f, 
    0.06114345f, -0.01987669f, -0.05459291f, 0.00654544f, -0.01676550f, -0.08934537f, -0.17806111f, 0.12960778f, 
    0.02827551f, 0.06508667f, 0.04061466f, 0.04544852f, 0.10464626f, -0.05928039f, -0.02680182f, -0.02384127f, 
    -0.10905381f, -0.14518562f, 0.11825228f, -0.06123755f, 0.00416069f, 0.05868156f, 0.06713057f, -0.04939406f, 
    0.03370277f, 0.03923921f, -0.06710385f, 0.09040102f, 0.21159762f, 0.01338883f, 0.16302492f, 0.06239934f, 
    -0.05608724f, -0.07573031f, 0.01475351f, 0.03207601f, -0.05571150f, 0.09851038f, 0.05921294f, 0.12964156f, 
    -0.06782819f, 0.04687900f, -0.04638382f, -0.03270143f, -0.06900834f, 0.12963687f, 0.05770534f, -0.12020254f, 
    -0.04155670f, -0.02467907f, 0.04612968f, 0.08960303f, 0.04468064f, 0.12445427f, 0.13079342f, -0.01772634f, 
    -0.05575202f, 0.01709724f, 0.11717683f, 0.11559577f, -0.04432545f, 0.02289437f, 0.00816016f, 0.04121521f, 
    0.43229818f, -0.03268414f, -0.14636317f, 0.12885270f, -0.13407232f, 0.03159245f, -0.06534803f, 0.00026209f, 
    -0.01092937f, -0.03181068f, 0.04165418f, 0.01474184f, 0.02116830f, -0.07312252f, 0.01826063f, 0.00853266f, 
    -0.01354809f, 0.10602682f, 0.07404330f, 0.09329253f, 0.01174773f, 0.09706752f, 0.04586536f, 0.00409254f, 
    0.24168204f, -0.10492685f, 0.09776139f, 0.13662742f, -0.01709871f, 0.04406812f, -0.02265503f, 0.05329901f, 
    0.02825650f, 0.12585205f, -0.04063296f, 0.02215998f, 0.40962690f, -0.09547541f, 0.06626084f, 0.01783695f, 
    -0.02519856f, 0.11450151f, 0.08853914f, 0.07151558f, 0.02783134f, 0.07508006f, 0.09295072f, -0.03749365f, 
    -0.01042853f, -0.03105530f, 0.24500836f, 0.25390229f, -0.00446072f, -0.01301747f, -0.11649095f, 0.09072062f, 
    0.10967246f, 0.07031009f, 0.07757947f, 0.07155952f, -0.09264850f, -0.13136162f, -0.03112841f, 0.09909809f, 
    0.05600781f, -0.00943488f, 0.01022462f, -0.01779883f, 0.01899401f, 0.03292735f, 0.00873536f, -0.05712727f, 
    0.24339181f, 0.08271953f, 0.03071176f, -0.01304085f, -0.00554206f, 0.00060767f, 0.06930416f, -0.06157506f, 
    -0.01469667f, 0.07396512f, 0.10675033f, 0.01721661f, 0.38899773f, 0.03688619f, 0.02758971f, 0.11113214f, 
    -0.09935340f, -0.00548917f, 0.10737167f, 0.05949132f, -0.04285359f, -0.00520859f, 0.04346263f, -0.09130988f, 
    -0.08461320f, 0.03695813f, 0.10034224f, -0.11567147f, 0.00878793f, 0.10707687f, 0.01383065f, -0.04881834f, 
    -0.02373019f, 0.13765366f, 0.04080404f, -0.01918869f, 0.18184613f, 0.08975915f, 0.16086051f, -0.03678681f, 
    -0.07636853f, -0.04887563f, 0.05603826f, 0.04697349f, -0.09960097f, -0.01914140f, -0.01703334f, 0.02634752f, 
    -0.07026602f, 0.19574809f, 0.02281342f, -0.00292907f, 0.03939026f, -0.05190558f, -0.07115985f, -0.09324312f, 
    -0.06802168f, 0.00392356f, -0.08884908f, 0.04741384f, 0.16469336f, -0.08981271f, 0.00107394f, 0.18911815f, 
    -0.10524102f, -0.02728422f, 0.04907974f, 0.08811340f, 0.04742657f, -0.04424408f, 0.07082594f, -0.00138756f, 
    -0.13191681f, -0.00822116f, -0.05705729f, -0.04792744f, 0.12648825f, 0.10004932f, 0.00685075f, -0.13106458f, 
    -0.10381459f, 0.03572363f, -0.03160163f, 0.07783990f, -0.02864450f, 0.03742024f, 0.01470968f, 0.04070442f, 
    0.02018780f, 0.05051498f, 0.14639263f, -0.03817957f, 0.03185302f, -0.01718981f, 0.02780223f, 0.03205473f, 
    0.02165901f, 0.06634250f, -0.16595913f, 0.11634555f, -0.00881580f, -0.00940123f, 0.02311833f, -0.03855315f, 
    -0.02222499f, 0.01927666f, -0.01607236f, 0.07569391f, -0.24748433f, -0.05070568f, -0.09710787f, 0.07600154f, 
    0.15376341f, -0.01652224f, 0.04298813f, 0.03998614f, -0.02228088f, 0.06623617f, -0.08739581f, -0.08281019f, 
    0.15494652f, 0.02552452f, -0.03998243f, -0.00506201f, -0.02600293f, 0.03032452f, 0.09997869f, 0.06670726f, 
    -0.00829089f, 0.03649684f, 0.10990316f, -0.01533865f, -0.12234814f, -0.00274663f, -0.24688305f, 0.00762224f, 
    0.10710796f, 0.05644194f, -0.02535191f, -0.04529376f, -0.06435327f, -0.04816975f, -0.03196116f, -0.05414505f, 
    -0.08859123f, -0.05752318f, -0.01118671f, 0.13314284f, -0.04670577f, -0.03052540f, 0.03432593f, 0.12705556f, 
    0.05486684f, -0.01679187f, -0.02534172f, 0.10063177f, 0.04773181f, -0.00047709f, -0.13348725f, -0.25681183f, 
    0.09485618f, 0.11612020f, 0.03701657f, 0.08852100f, 0.02016759f, 0.02041949f, -0.01102041f, -0.11174005f, 
    -0.19329199f, 0.02461254f, -0.15976699f, -0.12724759f, 0.05896848f, 0.10797868f, -0.06112144f, -0.02686269f, 
    -0.01873101f, 0.11673488f, 0.02807941f, 0.00698336f, 0.35275450f, 0.10362671f, 0.21468680f, 0.26559076f, 
    -0.07584643f, -0.14292577f, 0.04042021f, 0.10012266f, -0.01330150f, 0.06177697f, -0.03340790f, -0.10460119f, 
    0.09391319f, -0.00640514f, -0.22190236f, 0.22257075f, -0.04478012f, -0.03528078f, 0.00164690f, -0.06185341f, 
    -0.08147047f, 0.06191669f, 0.04656457f, 0.11789989f, -0.15968093f, -0.16231348f, -0.00845914f, 0.10563700f, 
    -0.04954947f, 0.01564989f, -0.01382390f, -0.04898185f, 0.10544849f, 0.05034053f, -0.08877806f, -0.06638971f, 
    0.11885732f, 0.15509845f, 0.19195271f, -0.05581511f, -0.10980040f, 0.12953988f, 0.02253317f, 0.07540552f, 
    0.00828260f, -0.05994836f, -0.06178366f, -0.02037434f, 0.30631649f, 0.02763771f, -0.15905257f, -0.04004678f, 
    0.07615181f, 0.01192690f, -0.06516055f, 0.04876149f, -0.02955231f, -0.00490390f, -0.01931258f, 0.00734047f, 
    -0.18394727f, 0.05492657f, -0.19000308f, 0.25160170f, 0.08108474f, -0.07734714f, 0.03381215f, -0.10128812f, 
    0.00505905f, -0.00720214f, 0.03258368f, 0.00218947f, 0.05834158f, 0.02445505f, 0.02341974f, -0.03099329f, 
    -0.01908315f, -0.01501863f, -0.02583756f, 0.02775019f, 0.01287854f, -0.04578657f, 0.11895660f, 0.07315585f, 
    0.36785609f, 0.11014480f, 0.00494751f, 0.06167104f, 0.04132581f, -0.01982323f, 0.01326079f, 0.06727695f, 
    -0.02310732f, 0.00029031f, 0.02004415f, 0.00176330f, 0.39117396f, -0.00733905f, 0.14800559f, 0.14424531f, 
    -0.18459396f, 0.02247746f, 0.08688320f, 0.02741012f, -0.07277038f, 0.07418133f, -0.07306531f, 0.02987774f, 
    -0.01346545f, -0.02628484f, -0.00607322f, 0.02177861f, -0.01583824f, 0.00601111f, -0.01582315f, -0.00466401f, 
    -0.03290517f, 0.01636956f, 0.00780920f, 0.00751586f, -0.01847852f, -0.00130017f, -0.00593794f, -0.03784902f, 
    -0.02269101f, 0.02779823f, 0.01179908f, 0.02913763f, -0.03215898f, 0.00235764f, -0.00570119f, 0.00347473f, 
    -0.04032436f, 0.00518012f, -0.03410763f, -0.01236770f, -0.00822066f, 0.02788877f, -0.00899448f, -0.03052110f, 
    -0.01638948f, 0.00206574f, -0.01165671f, 0.01815451f, -0.01037279f, 0.02834286f, 0.01984060f, -0.04133039f, 
    -0.00858919f, 0.00479492f, -0.00683744f, -0.03599180f, 0.01153203f, -0.03589847f, 0.01138436f, 0.00597932f, 
    -0.04100305f, 0.01070337f, 0.02241102f, -0.00249538f, 0.02096594f, 0.02641365f, -0.03133662f, -0.03098043f, 
    0.01676132f, -0.04067168f, -0.02161218f, -0.01651258f, 0.02765267f, -0.00985398f, -0.03081104f, -0.01440800f, 
    -0.00051258f, -0.01930135f, 0.02824187f, 0.00796486f, -0.01436501f, -0.02261739f, -0.01843946f, 0.01267268f, 
    0.00953367f, 0.01721008f, -0.00348917f, -0.00761867f, -0.01472714f, -0.02562045f, -0.02895237f, -0.00428622f, 
    0.01791102f, -0.03780514f, -0.02906019f, 0.03227665f, -0.01581317f, -0.04129807f, -0.00175422f, 0.02734892f, 
    -0.00356092f, 0.00843356f, 0.00042660f, 0.02166687f, -0.03995717f, 0.02863424f, 0.02052462f, 0.02494006f, 
    -0.02352290f, 0.00159900f, -0.00688050f, -0.02258823f, 0.02750193f, -0.00580022f, -0.03197306f, 0.02936050f, 
    -0.00040565f, -0.01634363f, 0.02854241f, 0.01469685f, 0.02464318f, -0.01544350f, 0.00438667f, 0.02534054f, 
    0.01432777f, -0.01092839f, 0.01045242f, -0.03892281f, -0.02227979f, -0.02097381f, 0.00538687f, -0.03795738f, 
    0.00246751f, -0.03076144f, -0.01202359f, -0.03494321f, -0.01643456f, 0.01528267f, -0.00792130f, -0.03687952f, 
    -0.01633610f, -0.03866573f, -0.03107458f, 0.02885021f, -0.04013004f, -0.02754929f, 0.02121493f, -0.03575936f, 
    0.02095742f, -0.01035356f, -0.02825341f, -0.00953675f, -0.02283111f, -0.03870764f, -0.01665506f, -0.00059317f, 
    -0.01790975f, -0.03571483f, 0.02013114f, -0.01379564f, 0.02033780f, -0.00147111f, 0.00671939f, 0.00851347f, 
    -0.02521225f, -0.00696443f, 0.00717013f, -0.02957981f, -0.00475177f, -0.00884757f, -0.02790768f, 0.00513726f, 
    -0.03988381f, 0.02754938f, 0.01777128f, -0.01572496f, -0.02818544f, -0.01425230f, 0.02970015f, -0.00994211f, 
    0.01219661f, -0.02104517f, -0.01922515f, 0.00731638f, -0.01725192f, 0.00627537f, -0.00122538f, 0.01723432f, 
    -0.00855114f, -0.00955602f, 0.01804985f, -0.00799605f, 0.01144490f, 0.02064291f, -0.03180709f, 0.02454246f, 
    0.00090978f, -0.01158936f, 0.01578406f, -0.00849200f, 0.01505524f, -0.02112830f, -0.02666734f, -0.04031654f, 
    -0.01477035f, -0.02788568f, 0.00243399f, 0.00525830f, 0.01172028f, 0.02135282f, -0.00955424f, -0.02222144f, 
    -0.03062751f, 0.01013346f, -0.04196525f, 0.01557702f, -0.00415004f, 0.00161820f, -0.04097057f, -0.00515346f, 
    -0.02371385f, -0.02478569f, -0.04043741f, -0.03279301f, -0.01419807f, -0.03106603f, -0.00017637f, 0.02645592f, 
    0.01007131f, 0.02800641f, -0.00120504f, -0.00619761f, -0.00132969f, 0.02844179f, -0.01435355f, 0.01591896f, 
    0.00277666f, 0.00543461f, -0.03945717f, -0.01437833f, -0.00875372f, -0.03379044f, -0.02880103f, 0.02907061f, 
    -0.00095080f, 0.02928520f, -0.02186043f, 0.00031941f, 0.00762924f, -0.03356588f, -0.03777349f, -0.02451638f, 
    -0.02599643f, 0.03579888f, -0.01839849f, -0.03352351f, -0.03765576f, -0.02711703f, -0.01390716f, -0.00533242f, 
    0.02471714f, 0.02388316f, -0.00644577f, -0.00852341f, -0.02429664f, -0.03931560f, 0.00704079f, -0.00877025f, 
    -0.02299657f, -0.00717111f, 0.02427371f, -0.03314164f, 0.01545180f, 0.01878028f, 0.02429968f, 0.02042538f, 
    0.01682892f, 0.00805456f, -0.03655420f, -0.00448511f, -0.03876625f, -0.01275451f, -0.02856037f, -0.03568937f, 
    -0.00920352f, 0.02915704f, 0.02622876f, 0.01464199f, 0.00120488f, -0.03341623f, -0.01656972f, 0.02890728f, 
    -0.03536124f, -0.01861256f, 0.01070879f, 0.01771677f, -0.03377205f, 0.02345003f, 0.01900472f, 0.01722623f, 
    -0.01221610f, -0.01975127f, -0.00574343f, -0.03266327f, -0.03509611f, -0.01909088f, 0.02749072f, -0.00378744f, 
    0.01881921f, -0.01158308f, 0.00831138f, -0.02832547f, 0.02500091f, -0.01823748f, -0.03018142f, -0.03102913f, 
    -0.02934310f, -0.01618934f, -0.01621651f, 0.02010322f, -0.00300290f, -0.01658087f, 0.00368451f, 0.01688258f, 
    -0.00811682f, -0.01892624f, 0.00575351f, 0.01086802f, -0.02220817f, 0.01595233f, 0.00927515f, 0.01922751f, 
    -0.02639615f, -0.01000900f, 0.01454989f, -0.02761829f, -0.02423290f, -0.01787515f, 0.02092929f, -0.02874482f, 
    0.01866475f, 0.02399680f, -0.00714797f, -0.04161595f, 0.02623451f, 0.01675274f, 0.00470481f, -0.00796708f, 
    -0.01803569f, -0.03591887f, 0.02757431f, 0.01764712f, -0.02955185f, 0.01989442f, -0.03173882f, 0.02942331f, 
    0.01613953f, 0.02307410f, -0.04171432f, -0.02877672f, 0.01368044f, -0.00716081f, 0.01431028f, 0.03528142f, 
    0.02619477f, 0.02330364f, -0.01690231f, -0.03221963f, -0.01480166f, 0.02462950f, -0.02184550f, -0.03207579f, 
    0.00737297f, -0.02503816f, 0.01930445f, -0.00181564f, -0.00333338f, -0.01365596f, -0.02723773f, -0.02418375f, 
    -0.01345001f, -0.03630619f, -0.04126300f, -0.00666947f, 0.02755541f, 0.02430390f, -0.00172939f, -0.03492887f, 
    -0.02883033f, -0.01600607f, -0.01449625f, -0.02889765f, 0.00755771f, 0.00166461f, -0.00719643f, -0.03175670f, 
    -0.04129547f, 0.01027813f, 0.02512226f, -0.03751519f, 0.02147410f, -0.04172957f, -0.00147899f, 0.01186250f, 
    0.02368757f, -0.02801624f, -0.03110997f, -0.01029261f, -0.02521101f, -0.02372190f, 0.00529315f, -0.01264274f, 
    0.00017582f, -0.00290809f, 0.01873373f, -0.02613844f, -0.00871556f, -0.02706417f, 0.00939748f, -0.01729830f, 
    -0.01217765f, -0.02049652f, 0.01619185f, 0.02184295f, -0.00638209f, -0.02897066f, 0.00421254f, -0.02657694f, 
    -0.00107371f, -0.03024916f, 0.02110398f, -0.01448029f, -0.02623816f, -0.02504812f, 0.00258250f, -0.01199190f, 
    -0.03218941f, -0.01597935f, 0.00277812f, -0.01545280f, -0.04057375f, 0.02595245f, 0.00421870f, 0.01937854f, 
    -0.03427386f, -0.00601421f, -0.01705186f, 0.01645929f, -0.03112207f, -0.03640775f, -0.02606774f, 0.00028382f, 
    0.02154401f, -0.00059430f, -0.02751835f, -0.02192329f, 0.01904374f, -0.03125712f, 0.00373704f, -0.01776840f, 
    -0.03506664f, 0.01662852f, 0.02407224f, 0.01493551f, 0.01755948f, -0.00239019f, -0.00604112f, 0.02547438f, 
    0.00151999f, 0.02566204f, -0.01794604f, -0.03222075f, -0.02468675f, -0.00680570f, -0.00259641f, 0.02963759f, 
    -0.03133957f, -0.00703631f, -0.02559564f, -0.02479375f, 0.00624600f, 0.02300739f, -0.03040781f, 0.00635626f, 
    0.01157257f, -0.03302044f, -0.01890190f, -0.03331976f, -0.01364291f, -0.01096348f, 0.02945125f, 0.00588307f, 
    0.02540273f, 0.01178606f, 0.01306286f, -0.03211921f, -0.03110336f, -0.03053945f, -0.02520268f, 0.00869551f, 
    0.02061645f, 0.00862318f, -0.02505089f, 0.00297421f, 0.02730482f, -0.00788815f, -0.01586399f, 0.00807337f, 
    -0.00972221f, -0.03359815f, 0.01968287f, -0.01293770f, 0.01569113f, -0.02971738f, 0.00058681f, -0.00021114f, 
    -0.00473532f, -0.02244611f, 0.01221120f, -0.02598232f, -0.00953139f, -0.03283668f, -0.00580814f, -0.03151334f, 
    -0.00712358f, 0.02322369f, 0.00754985f, -0.02160123f, -0.03880899f, 0.02236325f, 0.00250885f, -0.01726252f, 
    -0.03038641f, 0.00533205f, -0.02336514f, 0.00492096f, -0.02180676f, -0.04179626f, 0.01979075f, 0.02056718f, 
    -0.01718347f, -0.01858858f, -0.02868670f, -0.02679638f, -0.00252001f, 0.00975278f, 0.00223199f, -0.03936794f, 
    -0.02334223f, 0.02379200f, -0.03117883f, 0.00564984f, -0.02805592f, -0.03659705f, 0.01326728f, 0.02909347f, 
    0.01472745f, -0.04164685f, -0.01103683f, 0.00655454f, -0.02553579f, -0.01877388f, -0.00075656f, -0.02658823f, 
    0.03143043f, 0.01218605f, -0.01207550f, -0.03001648f, -0.02833176f, -0.03969444f, 0.03217545f, -0.00315253f, 
    0.01523295f, -0.01769373f, -0.00750228f, 0.02822287f, 0.02882406f, -0.01185947f, 0.01017552f, 0.02144637f, 
    -0.00064181f, -0.02930100f, -0.03065823f, -0.00285619f, 0.02861622f, 0.00743364f, -0.00143009f, -0.03161025f, 
    -0.03185120f, 0.01361886f, 0.02436314f, -0.03051934f, 0.00646068f, -0.03182942f, 0.00088745f, 0.02749979f, 
    -0.00923736f, 0.00688479f, -0.03484883f, -0.02437298f, -0.00241827f, -0.00623979f, -0.03375158f, 0.02006132f, 
    0.02290959f, -0.00967887f, -0.00749208f, -0.00188201f, -0.01587496f, 0.01386745f, -0.01134508f, 0.00563843f, 
    0.01996597f, 0.00599127f, -0.01634622f, 0.01776025f, 0.01697730f, -0.03131592f, 0.01363026f, -0.00458038f, 
    0.02312629f, 0.01919270f, -0.01032237f, 0.01983132f, 0.02453665f, -0.02068211f, -0.01832515f, -0.01274679f, 
    -0.03727221f, 0.02554638f, 0.00199699f, -0.01416132f, -0.02980770f, 0.02846277f, -0.02018018f, 0.02284633f, 
    -0.01109932f, 0.03383585f, 0.02408148f, 0.01727843f, -0.02309229f, -0.00520008f, 0.00643273f, 0.00322353f, 
    0.02899310f, 0.00702517f, -0.04046188f, -0.04003165f, -0.01327589f, -0.01665587f, -0.02279864f, 0.00017173f, 
    -0.00209637f, 0.00182582f, -0.03491584f, -0.04122324f, 0.00316490f, 0.02382480f, 0.01165611f, 0.00005527f, 
    0.00840275f, 0.02040940f, -0.00775452f, -0.02413321f, 0.00393023f, 0.02096605f, 0.02946626f, 0.00114508f, 
    -0.02582330f, 0.02246759f, -0.00248051f, 0.00982448f, 0.00945964f, 0.00820696f, 0.02060892f, -0.03077212f, 
    0.01107381f, -0.03907700f, -0.02594993f, 0.01367249f, -0.01831187f, -0.02972964f, -0.02319083f, 0.01975999f, 
    -0.03169570f, -0.03698738f, 0.00967924f, -0.03362511f, 0.02361427f, 0.02294788f, -0.00459610f, -0.01589393f, 
    0.00090578f, 0.02608275f, 0.00940093f, 0.00943527f, 0.00008313f, -0.01048119f, -0.02644245f, -0.03878105f, 
    -0.01328699f, 0.02623750f, 0.01440671f, -0.03996583f, -0.01554810f, 0.00641399f, 0.01294948f, 0.02877086f, 
    -0.02533560f, -0.00135679f, -0.02420007f, 0.01728657f, 0.02327017f, -0.03734660f, 0.02190376f, -0.00722718f, 
    -0.01373017f, -0.02724952f, -0.02543821f, -0.02151472f, -0.02906562f, 0.02385651f, -0.00293998f, -0.02250604f, 
    -0.01460338f, -0.00706943f, -0.00754636f, -0.02408378f, 0.02750104f, 0.00465623f, -0.02919411f, -0.04004636f, 
    -0.03585015f, -0.00851186f, 0.02898907f, -0.01581714f, 0.00675445f, 0.01168392f, -0.02066940f, 0.02350603f, 
    -0.03416776f, -0.01641656f, 0.00086826f, 0.00845942f, -0.03824416f, -0.02579208f, -0.02692519f, 0.02100028f, 
    0.01549998f, -0.03607876f, -0.00375232f, -0.03120596f, -0.01937780f, -0.03104573f, -0.00545266f, -0.01829755f, 
    -0.02536809f, -0.00716872f, -0.01007355f, -0.00380383f, 0.01991716f, 0.01118810f, -0.01951621f, -0.04102848f, 
    -0.03211885f, -0.03401557f, 0.00701582f, -0.00073766f, -0.03981876f, -0.03191567f, -0.00621558f, -0.03812280f, 
    -0.02361496f, -0.01940221f, 0.01980169f, -0.02911907f, 0.00546958f, -0.01216678f, -0.00437272f, 0.02765232f, 
    -0.00905273f, 0.02335341f, 0.02451024f, -0.00543811f, -0.00116898f, -0.02331292f, 0.00829493f, -0.00893024f, 
    -0.00474496f, 0.02780855f, 0.02430074f, -0.02085785f, 0.02443748f, -0.00515505f, 0.01006344f, 0.01696255f, 
    -0.00379183f, 0.00221247f, 0.01694978f, 0.00135836f, -0.00957844f, 0.02699284f, 0.02849290f, -0.00803088f, 
    0.00063265f, -0.00228297f, -0.01175481f, 0.00780885f, -0.00811575f, -0.01521077f, -0.03414756f, -0.01725997f, 
    -0.00062655f, -0.00608399f, 0.02197222f, 0.00678847f, 0.01494393f, -0.00551344f, -0.00304542f, -0.03912415f, 
    -0.02341284f, 0.00728912f, 0.02898667f, 0.00852158f, 0.02776963f, -0.01266444f, 0.01880134f, -0.02301440f, 
    -0.03238940f, 0.00397713f, -0.02265912f, 0.01384135f, 0.02646471f, -0.03285951f, 0.02291379f, 0.02747448f, 
    -0.00160959f, -0.01942242f, -0.03041588f, -0.01553189f, -0.01336243f, -0.01275708f, 0.00339848f, 0.00739106f, 
    -0.00193677f, -0.00850256f, -0.02367785f, -0.00096444f, -0.00881315f, -0.00317113f, -0.01635087f, 0.01214846f, 
    -0.01240957f, -0.01127448f, 0.02284447f, -0.01293258f, -0.01356360f, 0.00555807f, -0.00813658f, 0.02919713f, 
    0.00322060f, -0.01946045f, -0.00917186f, 0.01280761f, 0.00402004f, 0.02271219f, 0.02235706f, -0.02642713f, 
    0.02981770f, -0.03516727f, -0.00459623f, -0.03885147f, -0.00783715f, -0.03628784f, 0.02436586f, 0.02347867f, 
    0.00423502f, -0.02797477f, -0.02722169f, 0.01452517f, -0.01377346f, -0.03811799f, -0.03119721f, -0.02660966f, 
    -0.02358000f, -0.02965857f, 0.01365609f, -0.00794510f, 0.00136325f, -0.01688339f, -0.03003895f, -0.02545680f, 
    -0.02087247f, -0.00233965f, 0.00254763f, -0.01860137f, -0.00842783f, 0.01495645f, 0.00731724f, 0.01265450f, 
    -0.01803778f, -0.02308251f, -0.00734667f, 0.01950540f, -0.00372239f, -0.02711710f, 0.00520847f, -0.00480931f, 
    -0.00710148f, -0.00298835f, 0.01434014f, -0.01240893f, 0.01512068f, -0.02793990f, -0.00369915f, -0.03145449f, 
    -0.02703287f, -0.03206489f, 0.01927334f, -0.02157217f, 0.02126670f, -0.01937850f, -0.01321764f, -0.03516478f, 
    -0.03881131f, 0.02062436f, 0.02002490f, 0.00820073f, -0.01151627f, -0.03741188f, -0.00702634f, -0.01653544f, 
    -0.01734976f, -0.04113481f, 0.02441480f, -0.02870134f, -0.03250378f, 0.02948932f, 0.01430387f, -0.00466659f, 
    0.01663172f, 0.00631578f, -0.02161453f, 0.00913626f, -0.01491003f, -0.00083750f, 0.01663980f, 0.00349370f, 
    -0.02601419f, 0.01002131f, -0.03339848f, 0.02882634f, -0.01615624f, 0.03002263f, -0.02212004f, 0.02717032f, 
    0.01873193f, -0.03264464f, -0.01865399f, -0.04127172f, 0.00589333f, 0.01620684f, 0.01059423f, 0.02796082f, 
    0.02758504f, 0.02623945f, -0.03912244f, 0.00309903f, -0.01802459f, -0.00200981f, -0.04000907f, 0.01189589f, 
    -0.04146325f, -0.03730575f, -0.00774339f, -0.03413552f, -0.01990431f, -0.00730358f, -0.02253781f, 0.02408269f, 
    0.01011350f, -0.02598033f, -0.03077632f, -0.02544314f, 0.00254156f, 0.00519295f, 0.01484300f, 0.01139372f, 
    0.01964167f, -0.00413201f, -0.04064816f, -0.01381560f, 0.00761558f, 0.00866531f, -0.03066249f, -0.03376305f, 
    0.00660826f, -0.01362679f, 0.02239998f, -0.03099312f, 0.01339333f, -0.02344876f, 0.01940656f, -0.00585334f, 
    0.00127372f, 0.00777884f, -0.00474919f, -0.02009274f, 0.02093057f, 0.01644490f, -0.03812358f, -0.01963047f, 
    -0.01991119f, 0.00265307f, -0.03292061f, -0.01328829f, -0.01170791f, -0.00103051f, -0.01301952f, 0.01558376f, 
    -0.01867603f, -0.00705946f, -0.02475239f, -0.02533980f, -0.04190610f, 0.00688098f, 0.00142317f, 0.02219613f, 
    0.01644053f, 0.01916683f, 0.01491648f, -0.03547421f, -0.00663051f, -0.01853057f, -0.00361007f, -0.01646494f, 
    -0.03931100f, 0.00975827f, 0.00606720f, -0.03469714f, 0.00292918f, -0.01979021f, -0.02653497f, -0.03184954f, 
    -0.03530786f, -0.00930680f, 0.02225835f, -0.00082693f, 0.00357705f, -0.02747709f, 0.02868476f, 0.00448566f, 
    -0.02531254f, -0.01692934f, -0.03505120f, -0.01153290f, -0.03620600f, 0.01586749f, 0.02990135f, 0.01865795f, 
    -0.01227653f, -0.01674953f, -0.00408229f, -0.03494951f, 0.02173980f, 0.02789330f, 0.00509762f, -0.02399276f, 
    0.01523456f, 0.00803098f, -0.03823523f, -0.02425828f, -0.01743768f, 0.01626069f, 0.00048156f, -0.02702605f, 
    -0.01562165f, -0.02672914f, -0.02111950f, -0.00798027f, -0.02010454f, 0.02847488f, 0.02198032f, 0.01920115f, 
    0.00125906f, -0.02522822f, -0.00231405f, 0.01259098f, 0.01773854f, -0.01185211f, 0.02497170f, -0.02816125f, 
    0.02212862f, -0.02252178f, -0.03960174f, -0.01328667f, -0.04180067f, -0.02965816f, -0.01570916f, -0.03991196f, 
    -0.01893338f, -0.03137750f, -0.02819624f, 0.01913530f, 0.01575258f, -0.01017944f, 0.02520918f, 0.01600156f, 
    -0.02999165f, -0.00106528f, -0.03172439f, 0.02579314f, 0.00312513f, 0.02843268f, 0.00160731f, 0.01845047f, 
    0.01214085f, -0.03392416f, 0.00229923f, -0.00873817f, -0.02707768f, -0.03613765f, -0.03484195f, -0.01183531f, 
    -0.00126330f, 0.00803669f, -0.00816116f, -0.02968191f, -0.03561934f, 0.00229303f, 0.02163098f, -0.02200624f, 
    0.00649254f, -0.01198214f, 0.02269906f, 0.02944930f, -0.04039856f, -0.02663776f, 0.02514075f, -0.00113033f, 
    0.00863634f, 0.01478594f, -0.01112177f, 0.00398820f, -0.03198066f, -0.00408234f, -0.01272026f, 0.00023208f, 
    -0.01895121f, -0.03505152f, -0.02516774f, -0.03723528f, 0.01969089f, -0.00051863f, 0.01361062f, -0.02865394f, 
    -0.03500237f, -0.01179627f, -0.02613472f, -0.01821897f, -0.01568437f, 0.02359789f, -0.03046750f, -0.01608754f, 
    -0.03957918f, -0.01558467f, 0.01883834f, -0.00217896f, -0.00500301f, -0.03966169f, -0.01423318f, 0.00466230f, 
    -0.02782436f, -0.02202343f, -0.01296593f, -0.00594314f, -0.01685550f, -0.03069719f, -0.00362033f, -0.04151498f, 
    0.00669907f, -0.00864966f, -0.02325315f, -0.02024516f, -0.01429554f, -0.02926777f, -0.02135003f, -0.01927690f, 
    -0.03557011f, -0.00960145f, -0.02630533f, -0.03881510f, -0.01727203f, 0.01901899f, 0.00915110f, -0.00186696f, 
    -0.03170481f, 0.01821707f, 0.02224157f, 0.02341602f, -0.02856595f, 0.02848035f, -0.01262537f, 0.01695132f, 
    -0.02964825f, -0.03775753f, 0.02171906f, -0.02259786f, 0.00564286f, 0.01474247f, 0.01626879f, 0.00292135f, 
    -0.04185498f, -0.00910778f, -0.01504835f, 0.00552587f, -0.00202467f, -0.04070268f, -0.01289083f, -0.01867812f, 
    0.00338550f, 0.00534715f, -0.03914686f, -0.03552242f, -0.02193964f, -0.00608592f, 0.01115094f, -0.01891740f, 
    0.01258808f, 0.01107430f, 0.01710502f, -0.03104523f, -0.03810493f, -0.04132047f, -0.03321948f, -0.02444535f, 
    -0.00147147f, -0.00921410f, -0.00819303f, -0.01927826f, -0.03256100f, -0.03973143f, 0.02127962f, 0.01686230f, 
    -0.04147447f, -0.02125381f, 0.02416434f, 0.01900943f, 0.00555954f, 0.02049754f, -0.01089818f, -0.01711260f, 
    -0.03947675f, 0.00911877f, -0.02083294f, -0.02721092f, -0.02889545f, -0.01005316f, -0.00255008f, 0.02158739f, 
    -0.01213202f, -0.01899175f, 0.02207922f, 0.02060292f, -0.03157005f, -0.01816130f, 0.00072057f, -0.01779194f, 
    -0.01435270f, -0.01148554f, -0.01536455f, 0.01282473f, -0.02828302f, -0.02743654f, -0.00493037f, -0.03110545f, 
    -0.01585967f, 0.00137636f, -0.00076566f, -0.00383225f, -0.02735680f, -0.03333353f, 0.01600868f, 0.01025612f, 
    -0.01135750f, -0.03900729f, -0.02624818f, 0.00389237f, -0.02246461f, 0.02073522f, 0.00120584f, 0.02420007f, 
    0.00510025f, 0.02923309f, -0.03806839f, 0.00202901f, -0.03486035f, -0.01166856f, 0.00226240f, -0.00503148f, 
    -0.00405155f, -0.03800543f, 0.01088204f, 0.02530713f, -0.00289220f, -0.01807645f, -0.00862543f, -0.01778725f, 
    -0.02144887f, -0.01358001f, -0.01488065f, 0.00078836f, -0.03199390f, -0.04087790f, -0.03397534f, 0.01146382f, 
    -0.03633100f, 0.01096344f, -0.02569414f, -0.03761125f, -0.01278959f, 0.00798959f, -0.01462470f, 0.02277876f, 
    0.03004156f, -0.00163312f, -0.02471320f, 0.01615503f, 0.02668200f, 0.02501075f, -0.02522876f, -0.01071757f, 
    -0.02544629f, -0.01420659f, -0.01392794f, 0.01763071f, 0.00261095f, -0.03326188f, -0.01234100f, -0.03922924f, 
    0.00563121f, -0.03738021f, -0.02086638f, 0.00629359f, -0.01268017f, -0.03490568f, 0.02077805f, -0.00272175f, 
    0.02619069f, 0.00814420f, 0.02087508f, 0.02116094f, 0.00057103f, -0.03582427f, -0.02426304f, -0.01176408f, 
    0.00755069f, 0.00019133f, 0.02736868f, -0.00341325f, 0.01105806f, -0.03901662f, 0.02415689f, 0.00019712f, 
    -0.01476887f, -0.02602959f, 0.02945610f, 0.01448779f, 0.01156538f, -0.02041361f, -0.03652353f, 0.01691164f, 
    0.01448196f, -0.03570965f, 0.02878721f, -0.00325691f, -0.01803279f, 0.02399056f, 0.00383957f, -0.00166274f, 
    -0.02731290f, 0.02844332f, -0.03556383f, 0.02863648f, 0.02320146f, 0.01934984f, -0.04062106f, -0.02475246f, 
    0.01733301f, 0.00652207f, 0.02820141f, -0.03776549f, 0.01583201f, 0.00445875f, -0.03738284f, -0.01173218f, 
    -0.00397976f, -0.01244041f, -0.02952434f, 0.02055274f, 0.01559336f, -0.01096458f, -0.00605354f, -0.00805763f, 
    -0.02927696f, 0.01673381f, -0.04164972f, 0.01628543f, -0.02372781f, -0.02041961f, -0.00128581f, -0.03154473f, 
    0.02660786f, 0.00679938f, 0.01912501f, -0.01471204f, 0.00360769f, 0.01371243f, 0.00387172f, 0.00561219f, 
    0.02879134f, 0.02313956f, 0.01710372f, 0.01956622f, -0.02538425f, -0.01759376f, 0.00481797f, -0.04124780f, 
    0.01932196f, 0.01504227f, -0.01971509f, -0.00872554f, -0.01480434f, -0.00563563f, 0.02561494f, -0.01213034f, 
    -0.04193614f, 0.01037260f, -0.01136968f, -0.02050903f, -0.01972767f, 0.02646635f, 0.01763252f, -0.03677396f, 
    -0.02720867f, 0.01222996f, -0.01308469f, 0.01663966f, -0.01414097f, -0.02335042f, -0.04106807f, -0.00068062f, 
    0.00497202f, -0.00352428f, -0.01114062f, -0.01362996f, -0.01477853f, -0.00864110f, -0.00245865f, 0.00725733f, 
    0.02577766f, -0.03504128f, 0.01563927f, 0.02917914f, -0.01308901f, -0.03586600f, -0.02777066f, -0.00328448f, 
    0.02991437f, 0.01039989f, -0.01828841f, -0.00559635f, 0.02865975f, -0.00729376f, 0.00099457f, -0.03006195f, 
    -0.02703625f, 0.02408445f, -0.00075614f, 0.02849032f, 0.01036250f, -0.01000032f, 0.02578090f, -0.02558753f, 
    -0.03576826f, 0.01622400f, -0.01650271f, -0.02487664f, -0.02352982f, -0.01118379f, -0.00237360f, -0.01588943f, 
    0.01063828f, -0.02006189f, -0.04178160f, -0.01982745f, 0.02452771f, -0.01886211f, -0.00734946f, -0.00489052f, 
    -0.01751438f, 0.02242782f, -0.00879192f, 0.00046129f, -0.00107884f, -0.01538804f, -0.01583129f, -0.01850318f, 
    -0.01460538f, 0.00768364f, -0.01180475f, -0.00500697f, 0.01756614f, 0.01791507f, 0.02704271f, 0.02734938f, 
    0.02860021f, 0.00996815f, 0.00609379f, 0.00443800f, -0.01790884f, -0.02199937f, -0.02642982f, -0.02422020f, 
    0.00224246f, 0.02917696f, -0.02124650f, -0.01893226f, -0.01591295f, -0.02273443f, -0.04024222f, -0.03331660f, 
    -0.00785788f, 0.01864338f, -0.03085183f, -0.02473843f, -0.01539379f, -0.03813351f, 0.00031275f, -0.00769294f, 
    -0.02811978f, -0.02036054f, -0.00849111f, 0.00460897f, -0.02429236f, 0.01305966f, -0.02762798f, -0.00719514f, 
    0.02760302f, 0.01989860f, 0.01308089f, 0.00745031f, 0.01324041f, -0.03073840f, -0.02979854f, 0.01385107f, 
    -0.03960466f, 0.00253473f, -0.02852001f, -0.03049087f, -0.02088726f, -0.02374862f, -0.03199837f, -0.00162758f, 
    -0.01305809f, -0.03124074f, -0.02506568f, -0.02538005f, -0.01520012f, 0.00051032f, 0.01200300f, -0.00194800f, 
    -0.01773255f, 0.01146443f, -0.00418628f, 0.02113867f, 0.01639174f, 0.00867761f, 0.01971537f, 0.01667492f, 
    0.01116663f, -0.03336749f, -0.02481768f, 0.01196284f, -0.02837934f, -0.00076105f, -0.01313492f, -0.00159956f, 
    -0.02925486f, -0.00486184f, -0.00273260f, -0.00681939f, 0.01028966f, -0.02982796f, -0.03384618f, 0.00705399f, 
    0.00979031f, -0.01127472f, 0.01541684f, -0.03726784f, 0.02190960f, 0.00893154f, -0.02124482f, -0.01888931f, 
    0.02061935f, 0.00479658f, -0.03418101f, 0.01023323f, -0.03396041f, -0.01957594f, 0.01921586f, -0.02586342f, 
    0.00279777f, 0.00094110f, -0.03107893f, -0.02062809f, 0.00139015f, -0.03741439f, 0.00410874f, -0.02020028f, 
    0.01215641f, 0.02680139f, -0.02775390f, 0.00640540f, -0.00313925f, -0.02649327f, -0.00983069f, -0.03364915f, 
    -0.03991381f, -0.00369142f, -0.00407978f, 0.00056136f, -0.03833742f, 0.00314141f, -0.00114510f, 0.01286924f, 
    -0.03605372f, 0.02732132f, -0.02668124f, -0.01245168f, -0.01779377f, 0.01974253f, -0.03863244f, 0.02012570f, 
    0.02441177f, 0.01806288f, -0.03660092f, 0.03140547f, -0.01604425f, -0.02370062f, 0.01444962f, 0.01131360f, 
    0.01968895f, -0.01088083f, -0.03667383f, -0.02903663f, 0.01422837f, -0.02637115f, 0.02868182f, -0.03284297f, 
    -0.02663815f, -0.02240339f, 0.02839398f, 0.02027551f, -0.01690397f, -0.00751130f, 0.02712506f, 0.00011285f, 
    -0.01976759f, 0.02260609f, -0.02559056f, 0.00297988f, -0.02536211f, 0.00197323f, 0.02025668f, -0.02127076f, 
    0.00752705f, -0.03405128f, -0.01473932f, -0.03400048f, 0.02931227f, 0.03433489f, -0.00121216f, -0.00743434f, 
    -0.00831741f, 0.02638866f, 0.02279446f, -0.03738702f, -0.00011617f, 0.02613473f, 0.00193863f, 0.02175260f, 
    -0.00061082f, 0.01442937f, 0.01423485f, 0.00888532f, -0.04435537f, -0.01563388f, 0.00091748f, 0.00528862f, 
    0.00930417f, -0.00101653f, 0.00682721f, 0.01984752f, 0.01015120f, 0.00674115f, 0.01354107f, -0.00414178f, 
    -0.03744537f, -0.01066512f, 0.02134294f, -0.00616445f, -0.03966894f, 0.03041316f, -0.00110814f, -0.00480738f, 
    -0.02233195f, -0.00405452f, -0.01074273f, -0.02852918f, -0.00333144f, -0.01630320f, -0.02527353f, -0.02621511f, 
    -0.01774460f, 0.01685013f, -0.02299578f, -0.01381068f, 0.00998213f, -0.02454308f, -0.01854416f, 0.00237215f, 
    -0.01374195f, 0.01258223f, -0.04071745f, -0.00295668f, -0.02750894f, -0.03807712f, -0.00291250f, -0.00338960f, 
    -0.03085190f, -0.00767672f, 0.02124500f, -0.02386871f, 0.00746020f, -0.02641014f, 0.01429388f, -0.00460868f, 
    0.01521588f, 0.01043158f, -0.04078086f, -0.00659175f, -0.03092358f, -0.01707854f, -0.00859557f, 0.02908679f, 
    -0.02982125f, 0.02435167f, -0.00960883f, 0.02457249f, 0.01802827f, 0.03099831f, -0.01710777f, 0.01942748f, 
    0.02061868f, 0.01768569f, 0.01624926f, -0.00238767f, 0.02250945f, -0.00325639f, -0.01878679f, -0.03771748f, 
    -0.02324308f, -0.00599900f, 0.00934789f, -0.02151603f, 0.01561711f, 0.01946747f, -0.00239932f, -0.02578218f, 
    -0.03190287f, -0.00298259f, -0.00737223f, -0.01083832f, -0.00620554f, 0.01329473f, -0.03098273f, 0.02060427f, 
    0.03044758f, -0.01995586f, -0.03566824f, 0.01210392f, -0.04057870f, 0.00667286f, -0.03457901f, 0.01551034f, 
    -0.04127727f, 0.02815784f, 0.00574579f, 0.00051606f, 0.01009792f, 0.00448826f, 0.01305861f, -0.00397554f, 
    -0.02991342f, 0.01894266f, -0.01580202f, 0.01237922f, 0.02768661f, -0.01186382f, -0.03203784f, 0.02652057f, 
    0.02630878f, 0.00415680f, 0.00402551f, 0.02306550f, -0.00810876f, 0.00853935f, -0.03672757f, -0.01040175f, 
    -0.03538706f, 0.02622825f, 0.02772195f, -0.02543835f, -0.01011294f, -0.02283553f, 0.01178159f, -0.00493467f, 
    -0.02290576f, 0.02222249f, 0.01531193f, -0.00522770f, -0.03528509f, -0.01632591f, -0.03527829f, 0.00985342f, 
    0.00435228f, -0.00008683f, -0.02621080f, -0.03413375f, -0.00026881f, 0.02082616f, 0.02033376f, 0.00648841f, 
    -0.03872827f, 0.01561826f, -0.02698335f, 0.02429790f, 0.02614198f, -0.00101341f, 0.01986211f, -0.02760817f, 
    -0.03846977f, -0.01220260f, 0.02266773f, -0.02702150f, 0.00786979f, 0.01861983f, -0.03734096f, 0.02847530f, 
    -0.00404782f, -0.00993163f, 0.00397377f, 0.01268024f, -0.03616605f, -0.01997813f, -0.01413136f, -0.02365031f, 
    -0.04023341f, -0.01689704f, -0.01939291f, -0.00617344f, 0.00019558f, -0.03778676f, -0.03489777f, -0.00928070f, 
    -0.02412820f, 0.01635351f, 0.00463098f, 0.02860397f, -0.02817268f, 0.01280051f, 0.01473402f, -0.01311435f, 
    0.01471032f, -0.03144141f, -0.03387399f, 0.01528324f, 0.00159545f, -0.04250208f, 0.02841247f, -0.02546255f, 
    -0.03000963f, 0.01403659f, 0.00482893f, -0.00513625f, -0.03125532f, -0.01366097f, -0.02038192f, -0.03090449f, 
    0.01516647f, -0.01337305f, -0.02886360f, 0.02611635f, 0.02355797f, -0.02343206f, -0.04139872f, 0.02895919f, 
    0.01988683f, 0.02228102f, 0.01410054f, 0.02766751f, -0.01171262f, 0.00115757f, 0.01904181f, -0.03228024f, 
    -0.01778460f, 0.03178998f, 0.00061203f, -0.00427259f, -0.00901826f, 0.01222986f, -0.02769710f, -0.01533397f, 
    -0.03616273f, -0.00479758f, 0.02225392f, 0.01322048f, -0.02590160f, -0.00505070f, 0.00039291f, -0.03918278f, 
    -0.01719656f, -0.02368280f, -0.01731835f, -0.02351514f, 0.02071025f, -0.03711812f, 0.00660491f, -0.00815795f, 
    -0.02301009f, -0.03631660f, 0.02986623f, 0.00908484f, 0.00708230f, -0.02421462f, -0.00483150f, 0.01820256f, 
    0.03037903f, 0.02102868f, 0.00484403f, -0.02691810f, 0.01757433f, -0.01332113f, -0.00235532f, -0.02200368f, 
    -0.02977153f, -0.02605896f, -0.02644411f, -0.02537620f, -0.01644834f, -0.00855245f, 0.00762709f, -0.00855232f, 
    -0.04259941f, 0.02182182f, 0.00581285f, -0.00409022f, 0.03002809f, 0.01130641f, -0.03254477f, 0.00451552f, 
    -0.00772864f, -0.04337925f, -0.01608601f, -0.01180963f, -0.00354951f, -0.02143385f, -0.02417203f, -0.01568585f, 
    0.01374374f, -0.00104837f, 0.03027439f, -0.01568428f, -0.00446793f, 0.01917921f, 0.00455394f, 0.03015900f, 
    0.00054289f, -0.00610482f, -0.00976351f, -0.01519451f, 0.02096353f, 0.02398448f, -0.04413478f, -0.03942424f, 
    -0.03199509f, 0.00926816f, 0.01501594f, 0.02206149f, 0.01125714f, -0.03857188f, -0.01068178f, -0.03508706f, 
    -0.01629755f, 0.00070888f, -0.00481333f, -0.03099239f, -0.01296333f, -0.01709304f, 0.01910486f, -0.03055363f, 
    -0.00670682f, -0.01695073f, -0.01355634f, -0.03669954f, 0.02373161f, -0.02257440f, 0.01865225f, -0.00465003f, 
    0.00662362f, -0.03219713f, -0.00553608f, 0.00410845f, 0.00913807f, -0.00982102f, -0.01208275f, -0.02660360f, 
    0.00318828f, -0.02892371f, -0.03620173f, 0.01168268f, -0.02640158f, -0.01058955f, -0.01838653f, -0.00513103f, 
    -0.02333103f, 0.02748091f, 0.00379221f, -0.00458282f, 0.01689618f, -0.02460782f, -0.04013301f, -0.03111393f, 
    -0.03785356f, 0.00152280f, -0.01016820f, 0.02363417f, 0.01997544f, -0.04087663f, 0.01196949f, -0.03856821f, 
    -0.03895891f, -0.04144184f, 0.01201331f, -0.01185625f, -0.03810424f, -0.02001162f, 0.02397494f, -0.03959264f, 
    -0.01743729f, -0.01648681f, 0.01716339f, -0.02811886f, 0.02189912f, -0.03923751f, -0.02087058f, -0.03973902f, 
    -0.03390405f, -0.01821324f, -0.01799234f, -0.02205650f, 0.00995369f, -0.02873714f, 0.00454941f, -0.01584751f, 
    -0.03982921f, 0.01844308f, -0.01832318f, 0.03048901f, -0.00529347f, 0.00235804f, -0.02683364f, 0.02054346f, 
    0.01494570f, -0.02746986f, -0.02423895f, 0.00119856f, -0.01798979f, -0.00394412f, -0.00371887f, -0.01601520f, 
    0.01202967f, -0.02173809f, -0.02952596f, -0.02978221f, -0.02219054f, -0.02461748f, 0.01807457f, -0.03983431f, 
    0.00526063f, -0.03951832f, -0.03803289f, 0.02599981f, -0.03086971f, -0.04125315f, 0.01227955f, -0.01713243f, 
    -0.01480333f, -0.03950872f, -0.03230592f, 0.01955561f, 0.00770007f, 0.01903450f, -0.03053442f, -0.00342548f, 
    -0.03403221f, -0.03305259f, -0.01689144f, 0.02891500f, 0.00122361f, -0.01333760f, 0.02647370f, 0.02645601f, 
    0.02239458f, -0.01363184f, 0.02047690f, -0.04051439f, -0.01511228f, 0.01112203f, 0.01563418f, -0.03689008f, 
    -0.01470737f, 0.02761545f, -0.03511238f, 0.00826979f, 0.02381067f, -0.01503610f, 0.01267365f, 0.01496408f, 
    0.02524841f, 0.00034468f, -0.03799303f, 0.00029145f, -0.00878958f, 0.00218275f, -0.00356578f, 0.00207334f, 
    -0.00973634f, -0.01951075f, -0.03576202f, -0.00875059f, -0.03568600f, 0.01341264f, 0.02373812f, -0.00826390f, 
    0.02548696f, -0.04106095f, 0.00565327f, 0.02559521f, -0.03230453f, -0.03928828f, -0.01320625f, 0.01531475f, 
    0.00626029f, -0.04041237f, 0.02387541f, -0.01528384f, -0.03306469f, -0.03908129f, -0.01400258f, 0.00355419f, 
    -0.03478918f, 0.00712502f, 0.00542006f, -0.01769605f, 0.03151521f, 0.02463117f, -0.00647592f, 0.00015236f, 
    -0.01813933f, 0.02350254f, -0.00848670f, 0.02174833f, -0.00210437f, 0.02503251f, -0.02847696f, 0.02186020f, 
    -0.00111597f, 0.01044863f, -0.00025264f, -0.03227863f, 0.02607726f, -0.01132151f, 0.02821430f, 0.00040188f, 
    -0.02589894f, -0.00239025f, 0.00059643f, 0.02667401f, -0.02924164f, 0.00928878f, -0.01095404f, -0.01988720f, 
    0.00407976f, 0.00709053f, -0.01228716f, -0.01313616f, 0.01721021f, -0.01360878f, 0.01570215f, -0.03269403f, 
    0.01496617f, 0.01718441f, 0.01367153f, 0.00539977f, 0.00939683f, -0.02019710f, -0.02275827f, -0.00062056f, 
    0.03148521f, -0.02700076f, 0.02505121f, -0.04351699f, -0.03525833f, -0.03403025f, -0.02600124f, 0.00990043f, 
    0.01150828f, 0.00413349f, -0.00072940f, -0.01864860f, -0.01077825f, -0.03681121f, -0.00811703f, 0.03412482f, 
    0.02719513f, -0.03062010f, -0.01768594f, -0.02428220f, -0.02453926f, -0.00867558f, -0.03045634f, 0.00382788f, 
    0.01357105f, -0.03663659f, 0.00318982f, 0.02808572f, 0.01997744f, -0.02695907f, -0.02913615f, 0.01595793f, 
    0.00197095f, -0.02435986f, -0.03623282f, 0.00229719f, 0.02586712f, 0.01365973f, 0.02638141f, 0.02272273f, 
    -0.03787268f, 0.01391584f, 0.00026432f, -0.04189908f, -0.01849311f, 0.02727356f, 0.01413136f, -0.02407417f, 
    -0.00686461f, -0.03701672f, -0.01428481f, 0.00218405f, -0.01406335f, -0.00287166f, -0.02620579f, 0.02554842f, 
    0.01060844f, -0.02974204f, -0.01510824f, -0.00495445f, -0.00668399f, -0.01357282f, -0.03000022f, -0.03316501f, 
    0.01329553f, -0.00193580f, 0.00489103f, -0.03138124f, 0.02148843f, -0.00872182f, 0.00387623f, 0.02747653f, 
    0.02203176f, 0.02720960f, 0.00836090f, 0.00016215f, -0.02831436f, 0.03319608f, -0.01759855f, -0.00656328f, 
    0.01416771f, -0.01336892f, -0.02434356f, -0.01370006f, 0.00113903f, -0.03952011f, 0.01910719f, -0.02341662f, 
    0.01642516f, 0.00510446f, -0.00215556f, -0.02555499f, -0.00440049f, -0.01518153f, -0.01848736f, 0.00003827f, 
    -0.01655034f, 0.15933536f, 0.02756680f, 0.23674588f, 0.05311988f, 0.05431257f, -0.01297766f, 0.03878413f, 
    0.15719499f, 0.01674244f, 0.08320429f, 0.07004082f, 0.20081364f, -0.07798731f, 0.06854954f, 0.02003755f, 
    -0.04572802f, 0.04745283f, 0.04973694f, -0.03358216f, -0.06807487f, 0.06424149f, 0.05554340f, 0.04142438f, 
    0.00130425f, -0.01654115f, -0.02315733f, 0.04786010f, 0.00529026f, 0.00845225f, -0.07822561f, 0.02603474f, 
    0.00649103f, 0.01995962f, -0.14208360f, 0.07023937f, 0.09794404f, 0.01173215f, -0.00309824f, 0.04570455f, 
    0.05359983f, -0.05195446f, -0.01441049f, -0.03286536f, 0.00385230f, -0.00556395f, -0.12248169f, 0.05801372f, 
    0.05150951f, -0.16127962f, 0.04278770f, -0.12639771f, -0.01797486f, -0.03237141f, 0.07453450f, 0.02219201f, 
    -0.05680004f, 0.04460591f, -0.12949064f, 0.14320631f, -0.08525530f, -0.08152312f, 0.06296045f, -0.12161057f, 
    -0.03877423f, -0.03567400f, -0.03766019f, 0.00808437f, -0.00021354f, 0.08957868f, -0.05210979f, -0.13887067f, 
    0.29581448f, 0.18574522f, -0.08028349f, -0.03430233f, -0.02319162f, 0.00869761f, -0.04768039f, 0.07594657f, 
    0.03624257f, -0.02356892f, 0.06748907f, -0.10570932f, 0.11126179f, 0.03289685f, -0.07241628f, -0.07816211f, 
    -0.00270432f, 0.07482788f, -0.05002783f, -0.07111644f, -0.00959884f, 0.04574547f, -0.00366523f, -0.00254724f, 
    -0.06568951f, -0.11267497f, 0.08348362f, 0.03961810f, 0.02056664f, 0.05195265f, -0.08091891f, -0.03799473f, 
    0.01593043f, -0.06574914f, 0.04600986f, 0.05637994f, 0.25597376f, 0.13775662f, 0.18919162f, -0.04285803f, 
    0.03472633f, 0.08984725f, -0.03839463f, -0.06799085f, -0.01080950f, -0.02390610f, 0.01368903f, -0.00032677f, 
    0.02952565f, 0.10783181f, 0.07792505f, -0.05900550f, -0.05420603f, -0.00777519f, 0.01292290f, -0.08145160f, 
    0.00521363f, -0.07387903f, 0.00680583f, -0.12154093f, 0.05713581f, -0.09569701f, -0.02929895f, -0.07840884f, 
    0.00616689f, -0.08453545f, 0.06268580f, -0.02834963f, -0.04470097f, -0.04859847f, -0.07966455f, -0.02904291f, 
    0.16287994f, -0.00667240f, -0.06841664f, -0.10536502f, 0.04415391f, 0.00996858f, -0.03519898f, 0.04952070f, 
    0.00728491f, -0.10804919f, 0.11498009f, -0.14559835f, -0.00503041f, 0.05202341f, -0.06656059f, 0.22777294f, 
    -0.02244347f, 0.08533099f, 0.04607759f, -0.04931526f, -0.00962158f, 0.10717093f, -0.11028460f, 0.08947656f, 
    -0.10756826f, 0.08493551f, 0.01212211f, -0.02625825f, -0.05921245f, -0.01147146f, -0.08626605f, -0.01733745f, 
    -0.06934862f, 0.01751624f, 0.03709958f, 0.01613911f, -0.33257198f, -0.10935916f, 0.01063255f, 0.03813937f, 
    0.05989509f, -0.00801731f, 0.05694461f, -0.05748944f, 0.04311964f, -0.02883292f, 0.02179120f, -0.03069534f, 
    0.30981886f, -0.03628055f, -0.03681598f, 0.16614218f, 0.04930311f, 0.03586291f, 0.05639887f, -0.09353357f, 
    -0.05299360f, 0.09132893f, 0.03452183f, 0.03915231f, 0.11063456f, 0.24360473f, 0.06105360f, -0.04196773f, 
    -0.01403716f, -0.02114007f, 0.05066952f, -0.02878596f, 0.00718082f, 0.01440690f, 0.02018546f, -0.05483007f, 
    0.09792293f, 0.12710078f, -0.06670170f, -0.14988983f, -0.01123934f, -0.05057314f, 0.11301552f, 0.08345803f, 
    -0.14295796f, 0.11020503f, 0.08110312f, -0.14018562f, 0.28195766f, -0.12448519f, -0.10192928f, 0.05052708f, 
    -0.00804743f, -0.03066054f, -0.02467324f, 0.02571024f, 0.10252312f, 0.05722217f, -0.00049156f, 0.06736056f, 
    0.07654132f, -0.10008649f, -0.11033276f, -0.08836200f, 0.00170909f, -0.02988667f, 0.04446063f, -0.00397940f, 
    0.03427834f, 0.14349054f, 0.13885418f, 0.01898696f, -0.22307259f, 0.02449243f, -0.11559606f, 0.05345356f, 
    -0.00225475f, -0.19395794f, -0.01836959f, 0.00468053f, -0.00018220f, 0.02314389f, 0.13059033f, 0.05323678f, 
    -0.08461770f, -0.10084488f, 0.18053901f, 0.00237776f, -0.05564049f, 0.03072489f, 0.07206953f, 0.04757823f, 
    0.00180311f, 0.00717747f, 0.06573666f, -0.06392597f, 0.03718555f, 0.13530253f, 0.01519367f, -0.03565749f, 
    -0.01107749f, -0.01074764f, -0.11552643f, -0.06569447f, -0.14796202f, 0.12810759f, -0.05874120f, -0.00918906f, 
    0.07667354f, -0.06038311f, 0.02360782f, 0.03883351f, -0.04283831f, -0.02225195f, -0.01925807f, -0.02404897f, 
    0.00738544f, -0.06450131f, -0.06436251f, -0.03051744f, 0.10287983f, -0.09009427f, 0.11609792f, -0.10493927f, 
    -0.00261200f, 0.06590211f, -0.01540001f, 0.00983390f, -0.08664701f, 0.12664650f, -0.00207395f, 0.02625413f, 
    -0.22759864f, -0.09628103f, -0.02856913f, 0.02155641f, 0.01711549f, -0.01005774f, -0.00183032f, 0.06073373f, 
    -0.10420243f, -0.00823997f, -0.05031076f, -0.16657455f, -0.16227843f, 0.02855461f, 0.02336455f, -0.22561495f, 
    -0.08726673f, 0.01493907f, -0.05573517f, -0.02875367f, -0.08323389f, -0.09604904f, -0.13818702f, 0.13031352f, 
    0.28235501f, 0.12352298f, 0.00730400f, 0.10316849f, 0.07070400f, 0.03830419f, 0.04848267f, -0.01414585f, 
    -0.06763997f, 0.14032723f, 0.04688241f, 0.09121282f, 0.15396918f, 0.16311391f, 0.00146878f, -0.03758461f, 
    0.13101400f, -0.04802123f, -0.09379920f, -0.01875705f, -0.03934286f, 0.05452283f, 0.00777961f, 0.00228029f, 
    0.42049199f, 0.09816073f, -0.06769869f, -0.00620687f, 0.01063917f, 0.01754395f, 0.12056737f, -0.06157794f, 
    0.01346275f, -0.03952709f, 0.06993812f, 0.05073225f, 0.03801019f, 0.07114372f, 0.15341964f, 0.07130542f, 
    0.26617551f, -0.06531791f, 0.04356311f, -0.06141125f, 0.08675269f, 0.01040858f, -0.10494095f, -0.02142216f, 
    -0.04697845f, 0.22081161f, 0.09891845f, -0.02645238f, 0.04500034f, -0.09810463f, 0.01025631f, 0.04622881f, 
    0.14104077f, 0.01854127f, 0.10491706f, -0.02238973f, -0.21477568f, -0.01116756f, -0.11039390f, 0.04017089f, 
    0.07828563f, -0.06937217f, -0.03036974f, -0.02096018f, 0.00045625f, 0.00262328f, 0.02756722f, -0.12068322f, 
    0.12165941f, -0.09689227f, -0.08480095f, -0.09283470f, 0.02146464f, -0.14755613f, 0.11208198f, 0.05754878f, 
    -0.02629622f, 0.10535029f, 0.05367129f, -0.11928432f, 0.28873470f, 0.02788921f, 0.06000275f, -0.05765213f, 
    0.05753905f, -0.05089513f, -0.01974801f, 0.01557658f, 0.00608840f, -0.16144794f, -0.00806538f, -0.08619089f, 
    -0.05673461f, 0.05730086f, -0.07618281f, -0.15626891f, 0.04671661f, 0.05803010f, 0.05233981f, -0.02213499f, 
    -0.04480363f, 0.05267530f, 0.08716313f, -0.09968910f, -0.06460000f, 0.14548315f, -0.07505991f, 0.05293748f, 
    0.02830392f, -0.11233494f, -0.10276412f, -0.15576170f, -0.01034838f, -0.10528100f, 0.08423674f, 0.03900589f, 
    0.03762114f, 0.05580103f, -0.05703004f, -0.03196555f, 0.09060023f, 0.00977217f, -0.04526373f, 0.00286382f, 
    0.02388671f, -0.01927745f, -0.03891003f, -0.06148707f, -0.07237046f, 0.00130939f, 0.00731452f, 0.08072630f, 
    0.01069114f, -0.05119371f, 0.03438406f, -0.03479097f, -0.03164164f, -0.03360897f, -0.07221804f, 0.05832709f, 
    -0.22504048f, 0.13931365f, 0.04449203f, -0.03612687f, 0.02481664f, -0.01784897f, 0.02524541f, 0.05223613f, 
    0.00690974f, -0.00143311f, 0.10750708f, 0.08383071f, 0.10035147f, 0.01674519f, 0.12344775f, -0.00489135f, 
    0.00038603f, 0.05936095f, -0.00626425f, -0.05854122f, -0.00381993f, -0.05089480f, 0.01163487f, 0.15858826f, 
    0.29301539f, 0.03274947f, -0.15105088f, -0.08443788f, 0.02815085f, -0.08481671f, -0.01282806f, 0.01802792f, 
    -0.02135198f, 0.07349756f, 0.00640242f, 0.16543892f, 0.02808237f, -0.04599274f, -0.10708172f, 0.13520347f, 
    0.13712412f, 0.00168171f, -0.05608659f, 0.01552556f, 0.03024895f, 0.05774537f, -0.05830808f, -0.06774184f, 
    0.09259207f, 0.14671274f, -0.07382552f, -0.12863380f, -0.04133323f, 0.04508959f, -0.06269984f, 0.07753293f, 
    -0.04958343f, 0.08488964f, 0.09471899f, -0.10361569f, -0.13013683f, 0.00470953f, 0.06864290f, 0.02668539f, 
    0.06154723f, -0.02846594f, 0.08785187f, 0.01758837f, -0.08762926f, 0.06416043f, -0.07710170f, 0.02527764f, 
    0.14211226f, 0.06120427f, 0.09936030f, 0.10200176f, 0.05696492f, 0.09413926f, 0.06937291f, 0.01635205f, 
    0.02580503f, -0.09216259f, 0.08540049f, -0.00047773f, 0.08753912f, 0.05466429f, 0.12495516f, -0.06750567f, 
    0.01297764f, -0.08428581f, -0.10649468f, 0.05398377f, -0.10110606f, 0.14846006f, -0.05995100f, 0.08645365f, 
    0.03514700f, 0.03470673f, 0.01033920f, -0.11730412f, 0.10672060f, -0.10317935f, -0.06353981f, -0.12787385f, 
    -0.01683794f, 0.01171495f, -0.03792583f, -0.00723177f, 0.09009365f, -0.06719644f, 0.10836662f, -0.02766333f, 
    0.11163266f, -0.03622450f, -0.15269688f, 0.00946693f, 0.01782069f, -0.07651646f, 0.11400796f, 0.18835452f, 
    0.04176720f, -0.04334342f, 0.03295126f, 0.09097283f, 0.09483632f, -0.07501758f, -0.11807691f, -0.01274520f, 
    -0.08472419f, 0.11209425f, -0.05100374f, 0.05880654f, -0.00779351f, 0.16986538f, 0.07323899f, -0.08073276f, 
    -0.00653139f, -0.01896432f, 0.00675802f, -0.09694570f, 0.06261951f, -0.07914176f, 0.00788270f, 0.12432009f, 
    0.25739574f, 0.12544525f, 0.17920500f, 0.00233915f, 0.09912177f, 0.10936978f, 0.00342722f, -0.02003917f, 
    -0.00826115f, -0.02243640f, -0.02174718f, 0.01446475f, -0.28078440f, -0.07406227f, 0.03235644f, 0.21536657f, 
    0.13338846f, -0.14876385f, -0.04782774f, -0.03261096f, -0.06407440f, 0.10999351f, -0.02303251f, 0.04501839f, 
    0.07673590f, -0.02331757f, 0.03143226f, 0.12216237f, 0.06384822f, -0.00589886f, 0.04637342f, -0.00749164f, 
    0.02947132f, -0.00397804f, -0.00452764f, -0.02371778f, 0.10579749f, -0.05679928f, 0.03438242f, 0.10080063f, 
    0.08857464f, 0.11243806f, -0.01237251f, -0.06883577f, 0.00993512f, -0.00887136f, 0.05324791f, -0.07520152f, 
    -0.27220273f, -0.22137292f, 0.02678612f, -0.09429345f, 0.14938727f, 0.06542841f, -0.05812151f, 0.12249484f, 
    0.00702555f, 0.07579492f, 0.00966397f, 0.00755811f, 0.12373523f, -0.08406511f, 0.02209469f, -0.06970056f, 
    0.03743115f, 0.04360921f, 0.00002440f, -0.06870208f, -0.05194120f, -0.00917732f, 0.07751623f, 0.11680745f, 
    0.11260027f, 0.06479787f, 0.09279241f, 0.18145530f, 0.15312938f, -0.01144670f, -0.03918951f, 0.07323361f, 
    0.04974624f, -0.03826642f, 0.03060279f, -0.03954213f, 0.03726628f, 0.13901894f, 0.00483010f, 0.15100648f, 
    0.09458496f, 0.07930133f, -0.04522780f, -0.05560030f, -0.00116933f, 0.03477892f, 0.03096492f, -0.00000611f, 
    0.01529843f, 0.17341454f, 0.15521550f, 0.05802629f, 0.13997664f, -0.05936719f, -0.01785072f, -0.00567970f, 
    -0.13430920f, 0.06163983f, 0.10429890f, 0.04284574f, -0.02653078f, 0.00638092f, 0.02544364f, -0.03654006f, 
    -0.02393194f, 0.05224863f, 0.04717514f, 0.03398247f, 0.04902593f, 0.01282307f, -0.08373344f, -0.02928461f, 
    -0.47997975f, -0.06449545f, -0.00296626f, 0.03919221f, -0.04304410f, -0.00057024f, -0.03178629f, -0.00130181f, 
    0.02706739f, 0.02535653f, 0.13626854f, 0.01084261f, 0.05085664f, -0.23637499f, 0.04555358f, -0.02774051f, 
    0.09704410f, 0.09178196f, -0.07708445f, 0.07349700f, -0.02772806f, -0.06501319f, 0.08983532f, -0.05321671f, 
    -0.03806239f, -0.00902813f, 0.02723029f, -0.03366346f, 0.01965517f, -0.01678619f, 0.01850184f, -0.02580224f, 
    -0.02296697f, 0.02559202f, -0.02579280f, 0.00823208f, -0.04115879f, -0.01306122f, -0.00198568f, -0.04120842f, 
    0.00796683f, -0.03047694f, 0.02963299f, -0.01171612f, 0.01517845f, -0.03499218f, 0.00392496f, -0.03499087f, 
    -0.02946357f, -0.02284981f, 0.01323239f, -0.03362008f, -0.02200917f, -0.04122299f, 0.02504333f, 0.00977811f, 
    -0.03574762f, -0.03204618f, -0.00976102f, 0.02284659f, -0.03882077f, -0.04141084f, 0.00953366f, 0.02359557f, 
    0.02224011f, -0.03875886f, -0.00407821f, 0.02586172f, -0.01283667f, 0.00715637f, 0.01215262f, -0.00860950f, 
    -0.01596252f, 0.02127041f, 0.01665328f, 0.02016516f, -0.00057962f, 0.01926700f, -0.03623263f, 0.01085465f, 
    0.02490722f, 0.00786169f, -0.01133695f, -0.03721160f, -0.03708879f, 0.01791005f, 0.01142712f, 0.01444705f, 
    0.01442832f, -0.01592888f, -0.01444529f, -0.03413371f, 0.00837106f, -0.00339275f, 0.02201557f, -0.03371912f, 
    0.00208422f, -0.00082855f, -0.01933330f, 0.00694498f, -0.02658178f, 0.02957174f, -0.02679019f, 0.01737764f, 
    -0.03942559f, -0.03109372f, -0.02144182f, -0.03184095f, -0.02980511f, -0.00161590f, -0.02672024f, -0.00147253f, 
    0.01562804f, -0.00625003f, 0.01995941f, -0.03967075f, -0.01559861f, 0.00779415f, -0.01077518f, 0.00984129f, 
    -0.01749599f, -0.01411936f, -0.00759985f, -0.02282767f, -0.00352319f, 0.00626724f, -0.03919375f, 0.00297038f, 
    0.00616405f, 0.01595164f, 0.02269884f, -0.03270066f, 0.01113619f, -0.02725329f, 0.01477468f, 0.00757316f, 
    -0.00348673f, -0.01567358f, 0.01176198f, -0.00597018f, -0.01126131f, 0.00815149f, 0.01680910f, -0.03362445f, 
    0.00762299f, -0.01906954f, 0.01464451f, 0.01127778f, 0.02614270f, -0.00302542f, -0.01151653f, -0.01195176f, 
    0.00342484f, -0.02994137f, -0.02065621f, -0.00365078f, -0.01332577f, 0.00349912f, -0.02638310f, -0.01755426f, 
    0.01363379f, -0.01473097f, -0.00649934f, 0.00069052f, 0.02295997f, -0.03568035f, -0.00573290f, 0.00495229f, 
    0.02152457f, -0.03348868f, 0.02307547f, 0.01947802f, 0.02879290f, -0.00570892f, 0.00677190f, 0.01060413f, 
    -0.00176327f, -0.03760678f, 0.01241173f, 0.01499605f, 0.00832572f, 0.00053824f, -0.01853172f, -0.03503955f, 
    0.01020606f, 0.01033033f, 0.01879100f, 0.02248968f, -0.02194595f, -0.01243383f, -0.02239860f, -0.00380199f, 
    -0.04010566f, -0.02224504f, 0.02045183f, -0.02505778f, 0.02433253f, -0.02714312f, 0.00978818f, -0.03199789f, 
    0.02833464f, 0.01275482f, 0.02854336f, -0.02765948f, -0.00798558f, -0.01019946f, -0.03514375f, -0.02066492f, 
    0.02802969f, -0.01675681f, -0.00191011f, -0.02497199f, -0.02907383f, 0.01067119f, -0.02779762f, 0.00177446f, 
    -0.00118190f, -0.00695627f, -0.02358846f, -0.02692485f, 0.00304981f, -0.01751895f, -0.01338955f, -0.00243777f, 
    -0.01318158f, -0.01955676f, -0.02320110f, -0.01089209f, -0.00189862f, 0.00311438f, -0.03777399f, 0.01580364f, 
    -0.03007370f, -0.02054111f, 0.01487555f, -0.02895729f, -0.03119863f, -0.01646415f, 0.02495863f, -0.04059990f, 
    0.01008273f, -0.03227380f, -0.03231610f, 0.02107903f, -0.02952302f, -0.03440775f, -0.03919523f, -0.00479155f, 
    0.02249405f, 0.02742414f, -0.03922499f, -0.01918698f, 0.00692178f, 0.00075696f, -0.01564232f, 0.02654019f, 
    -0.01375799f, 0.02581430f, 0.02498922f, -0.03169514f, -0.00269364f, -0.00770947f, 0.00121376f, -0.01661951f, 
    0.00843505f, 0.02175334f, -0.02194411f, -0.02894577f, 0.00026318f, -0.02652959f, -0.03741264f, -0.03223652f, 
    -0.02559621f, 0.01949655f, -0.00418115f, -0.00509049f, -0.03058327f, -0.01846071f, -0.00298292f, -0.03193218f, 
    -0.02563382f, -0.01928383f, 0.01301576f, 0.02251494f, 0.02935548f, 0.01661937f, -0.01141835f, -0.01903850f, 
    0.02477018f, 0.00412402f, 0.02675799f, -0.02116399f, 0.02278572f, 0.01397777f, 0.01661783f, -0.01499674f, 
    0.02979061f, -0.00292453f, 0.02072528f, 0.02285675f, 0.02783908f, 0.01309497f, 0.01197694f, 0.02766814f, 
    -0.00041530f, 0.01887896f, -0.01516689f, 0.02304463f, -0.00600716f, -0.03053932f, -0.01901217f, -0.03680078f, 
    -0.02282441f, -0.03069942f, -0.01842366f, -0.01029456f, 0.00291435f, -0.04151313f, -0.00472704f, 0.01125136f, 
    0.02219716f, 0.00580846f, -0.02679402f, 0.02501485f, -0.01585260f, 0.00970620f, -0.03998898f, -0.00637957f, 
    -0.00767602f, -0.00197070f, -0.01068390f, -0.02187444f, -0.04109868f, 0.01104676f, 0.02190008f, 0.01674859f, 
    0.00958412f, -0.00344982f, -0.03895050f, 0.02778587f, -0.03140243f, 0.01700672f, -0.01634833f, -0.02291003f, 
    0.00001944f, 0.02584763f, 0.02302524f, -0.03131266f, -0.03012419f, -0.02093573f, -0.00372913f, 0.02773765f, 
    -0.03047085f, 0.00897530f, -0.01028451f, 0.00889101f, 0.00231184f, 0.02353936f, -0.03069026f, 0.00482267f, 
    -0.01008453f, 0.02071698f, -0.03466203f, 0.01097257f, -0.01157480f, 0.01157134f, -0.00491254f, -0.01659066f, 
    -0.02117625f, 0.00272644f, -0.02580059f, -0.00009241f, -0.01138218f, -0.02348762f, 0.02745087f, 0.02669238f, 
    -0.00403483f, 0.02315157f, -0.01448704f, -0.02395172f, -0.02765960f, -0.02292185f, 0.00000124f, -0.03521421f, 
    -0.00437800f, -0.00901125f, -0.00051936f, -0.00610280f, 0.01206516f, 0.00326619f, -0.03164401f, 0.02467325f, 
    -0.00638285f, -0.00729385f, -0.00294401f, 0.02174869f, 0.01232039f, -0.02104698f, -0.00257697f, 0.01594065f, 
    -0.03007536f, -0.00413450f, 0.02309049f, 0.02789795f, -0.01350417f, -0.02796714f, 0.02269145f, 0.00637966f, 
    -0.02966782f, 0.02327263f, -0.00667055f, -0.02020567f, -0.01920708f, -0.02880967f, -0.01681323f, -0.01209149f, 
    0.02081082f, -0.03607766f, -0.04058783f, 0.00908922f, -0.01854315f, 0.00388798f, -0.00024818f, -0.01552127f, 
    -0.00213921f, 0.00123537f, 0.01854112f, 0.02516610f, 0.00229000f, -0.03228908f, -0.01750435f, -0.03002331f, 
    0.00561900f, 0.02496403f, -0.01197493f, -0.01919629f, 0.02321268f, -0.02211702f, -0.03062799f, -0.04053916f, 
    -0.01535891f, -0.00909098f, 0.00342694f, -0.03116982f, 0.02725862f, 0.02696067f, -0.01220104f, -0.04025840f, 
    -0.01006396f, -0.01446779f, -0.02595029f, -0.02581280f, -0.01983870f, 0.01279852f, 0.01767817f, -0.00109152f, 
    -0.03679097f, -0.01136503f, 0.01039267f, 0.02771158f, -0.00870711f, -0.01249903f, -0.00570862f, -0.03506496f, 
    -0.01539901f, 0.01820749f, -0.02610777f, -0.02864773f, -0.00717719f, 0.01168966f, 0.01019311f, 0.02569682f, 
    0.01360866f, -0.02314346f, -0.03308361f, -0.03695026f, 0.01996163f, 0.02606997f, -0.02037845f, -0.02025819f, 
    0.02411100f, -0.02807218f, -0.02483640f, 0.01374593f, -0.02616732f, -0.00143394f, 0.00197137f, -0.02100538f, 
    0.02703447f, 0.02759340f, -0.02374715f, 0.01584175f, 0.02563652f, -0.03290503f, -0.01776361f, -0.02055891f, 
    -0.01102244f, -0.02954269f, 0.01162912f, 0.01231082f, -0.02525676f, -0.01569675f, -0.02174174f, 0.02333153f, 
    -0.00135299f, -0.03090255f, -0.00183220f, 0.02597937f, -0.03755400f, 0.00895596f, 0.02245344f, 0.01915815f, 
    -0.00272025f, 0.00775218f, 0.01150478f, -0.01316509f, -0.02733732f, 0.02971863f, 0.04186670f, -0.03506522f, 
    -0.00528171f, 0.01109913f, -0.03793606f, -0.01014568f, -0.00742287f, -0.02131848f, -0.03975841f, -0.02125470f, 
    -0.00076353f, -0.01320282f, -0.02280470f, 0.01329128f, -0.03394273f, -0.01014806f, 0.00746164f, -0.02834025f, 
    0.01361772f, -0.00821438f, 0.02762756f, -0.01673946f, 0.01406649f, -0.02010367f, 0.00777028f, 0.01936094f, 
    0.01304352f, -0.01362814f, -0.03529759f, 0.01139566f, -0.01507870f, -0.04119087f, -0.03145116f, -0.01478159f, 
    0.00418480f, 0.02472388f, -0.00112585f, -0.02007985f, -0.02608219f, 0.01520802f, 0.00803785f, -0.01998966f, 
    0.02001763f, -0.00548103f, 0.02941257f, -0.01475737f, 0.00512050f, -0.02259785f, -0.02505766f, 0.01821054f, 
    -0.02697016f, -0.03329716f, -0.02022062f, -0.03752364f, -0.01004715f, 0.00820466f, 0.01055822f, 0.00345616f, 
    -0.02440340f, 0.02155907f, -0.00378742f, -0.03999332f, -0.00500961f, -0.01449805f, 0.01723761f, -0.02347382f, 
    -0.02880893f, -0.00750962f, 0.01963226f, 0.02016405f, 0.02918610f, -0.00604635f, -0.00273965f, -0.01543221f, 
    -0.01493818f, -0.01967199f, -0.02008816f, -0.01560626f, -0.03447788f, -0.01489417f, -0.02365966f, 0.00543096f, 
    0.00183473f, 0.02663889f, -0.02022294f, 0.02041920f, -0.02131214f, 0.01102951f, -0.01251928f, -0.03015506f, 
    0.01972560f, -0.01733689f, 0.02356171f, -0.01572444f, 0.01442201f, 0.02760243f, -0.01289248f, 0.02415343f, 
    0.02590081f, 0.00083060f, -0.00814798f, 0.01778786f, -0.02890717f, -0.01193486f, -0.04182431f, -0.03764411f, 
    0.02254958f, 0.01144908f, 0.01104387f, -0.00842569f, 0.01894142f, -0.01092230f, 0.01805296f, 0.01079676f, 
    0.00033039f, 0.01179538f, -0.03805738f, -0.04002673f, 0.01663916f, -0.02592520f, -0.02335960f, -0.03987725f, 
    -0.03855319f, 0.00137481f, 0.02149515f, -0.03004943f, -0.02588437f, -0.03118888f, -0.03879214f, 0.02711505f, 
    0.00518709f, -0.03002701f, -0.02617134f, -0.02484287f, -0.00358693f, -0.03422625f, 0.00583344f, -0.00615609f, 
    -0.02190220f, 0.01203257f, -0.01611120f, -0.03324207f, 0.00072906f, -0.03508021f, -0.03714185f, -0.00803919f, 
    -0.01712623f, 0.00476447f, 0.02624395f, 0.02775905f, 0.01549215f, -0.02932961f, 0.01684419f, -0.02318969f, 
    -0.00475506f, 0.02925891f, -0.02654559f, 0.00229889f, -0.03870355f, -0.01177155f, 0.02225398f, 0.02086459f, 
    -0.04103149f, -0.02920636f, 0.02969182f, -0.02287461f, 0.00373933f, -0.03220296f, 0.01312274f, -0.03539281f, 
    -0.00138337f, -0.04175539f, 0.01127673f, 0.01242452f, -0.02725874f, -0.03204465f, -0.01671799f, 0.02791190f, 
    0.02412587f, -0.03613051f, 0.02719117f, -0.03666227f, -0.01879231f, -0.01145161f, -0.01223434f, 0.00116462f, 
    0.00992324f, -0.03951931f, -0.03671405f, -0.00580660f, -0.03755774f, 0.01193724f, 0.02692112f, -0.00709536f, 
    -0.01464627f, -0.01693477f, -0.03935774f, -0.01253583f, 0.01545295f, -0.02763707f, -0.00265596f, 0.00909188f, 
    -0.02806741f, 0.00551586f, 0.02789471f, 0.00166319f, -0.00758153f, -0.00377917f, -0.00829479f, -0.01976156f, 
    0.01079808f, -0.00690812f, -0.03448466f, 0.00185985f, -0.00766905f, -0.03704266f, -0.02792061f, -0.02622688f, 
    -0.03815724f, 0.01374102f, -0.00716651f, 0.01743685f, -0.00339249f, 0.00428253f, -0.00812866f, 0.00335289f, 
    -0.00302301f, 0.01771734f, 0.01839913f, -0.02314908f, 0.02910785f, 0.01890543f, 0.02831314f, -0.03815587f, 
    -0.01699631f, 0.00898339f, -0.00087419f, 0.01142124f, -0.03783237f, -0.02077127f, 0.02883880f, -0.02479839f, 
    -0.01280535f, 0.00938495f, 0.02119086f, -0.01247546f, -0.02331581f, -0.01538659f, -0.00829208f, -0.01947539f, 
    -0.00065807f, -0.01654338f, 0.00719275f, -0.03203585f, 0.01492836f, -0.00172651f, 0.00195068f, 0.02089556f, 
    -0.04037624f, 0.01265309f, 0.02327735f, -0.01920006f, 0.00606511f, 0.02845948f, 0.00022479f, 0.02399513f, 
    0.02249188f, -0.02198795f, 0.00257684f, -0.01421325f, -0.01930367f, 0.01488755f, -0.01562554f, -0.00997035f, 
    -0.01275262f, 0.10607427f, 0.14933012f, 0.05801924f, 0.08712220f, 0.04638730f, 0.06845991f, 0.07052045f, 
    -0.07904084f, -0.02496122f, -0.03959285f, 0.00565655f, -0.16808632f, -0.04832541f, 0.07689065f, 0.00375249f, 
    -0.09434462f, -0.03965877f, -0.10388552f, 0.02237209f, 0.00877275f, -0.05508127f, 0.08278500f, -0.04690132f, 
    -0.04293166f, -0.01124173f, 0.15922923f, 0.00475578f, 0.00303811f, -0.03565131f, -0.05632544f, 0.04974167f, 
    0.00336669f, -0.04289533f, -0.05639526f, -0.03438368f, -0.10957581f, 0.13189283f, 0.06524353f, 0.08671013f, 
    -0.04477791f, -0.02034582f, -0.04722852f, -0.03214600f, -0.00375527f, 0.16899733f, -0.00983166f, -0.04925893f, 
    -0.01955293f, -0.02193125f, -0.10410979f, 0.05359679f, -0.08522538f, -0.06715771f, -0.08465799f, -0.09585628f, 
    0.02491794f, 0.05460426f, -0.04848076f, -0.05637601f, 0.11433806f, 0.03867606f, -0.04420544f, 0.10786637f, 
    -0.08306174f, -0.00815385f, 0.05924445f, -0.01613752f, 0.03723019f, 0.06183692f, -0.00828569f, -0.01093267f, 
    -0.01651999f, -0.06577909f, -0.01156000f, -0.08866502f, -0.07871770f, -0.08270770f, 0.15524197f, 0.00217298f, 
    -0.11177219f, 0.01506518f, 0.03660417f, 0.00544267f, -0.27350038f, 0.37285662f, 0.01926431f, -0.00943890f, 
    -0.02713041f, 0.00346878f, 0.06048470f, 0.08981947f, 0.05670304f, 0.07746551f, -0.03227884f, 0.08296728f, 
    0.08653102f, 0.02698843f, -0.08087903f, 0.01091502f, 0.12865441f, -0.04030579f, 0.01423703f, -0.00081552f, 
    0.00508579f, 0.03024341f, -0.02136351f, -0.11674245f, 0.13133897f, 0.06810507f, -0.08467317f, 0.09958689f, 
    -0.06341726f, 0.14578272f, 0.03990563f, 0.00298322f, -0.01295014f, -0.00301904f, 0.02093511f, 0.01402596f, 
    0.15293299f, -0.00357846f, -0.03346939f, 0.05002186f, -0.00952044f, 0.01440958f, -0.03741193f, 0.04345533f, 
    -0.10237747f, -0.05925569f, 0.02970231f, -0.03959836f, -0.00265369f, -0.12261633f, 0.25647622f, 0.00955105f, 
    0.03747251f, 0.00397480f, -0.05020343f, -0.00192513f, 0.01167962f, 0.03706594f, -0.00806917f, -0.06137232f, 
    0.07222075f, -0.00547369f, 0.15098172f, 0.01395441f, -0.01319547f, -0.08509499f, -0.05968621f, -0.08235377f, 
    0.02256754f, 0.00516621f, -0.04113135f, -0.18486056f, -0.10341545f, 0.05318210f, 0.27215257f, 0.12852785f, 
    -0.04763909f, -0.04823180f, -0.05414657f, -0.02498921f, 0.01347739f, -0.00647961f, -0.02455468f, -0.00523768f, 
    0.06235466f, -0.15891036f, 0.02276846f, 0.08270007f, -0.02837098f, -0.04003511f, -0.05791188f, -0.03567692f, 
    -0.04563630f, 0.05574780f, 0.05689986f, -0.04870960f, 0.00858002f, 0.20244209f, 0.04304612f, 0.10179310f, 
    0.22958970f, -0.02076024f, 0.00694107f, 0.05589324f, 0.17054133f, 0.07669812f, 0.09746008f, -0.03046073f, 
    -0.19155896f, -0.09594153f, 0.14409757f, -0.10118878f, -0.05634548f, -0.02824628f, 0.00826876f, -0.01003546f, 
    0.07005890f, -0.00536679f, -0.02638721f, 0.01753906f, 0.06226877f, -0.10163692f, 0.11844939f, -0.00299181f, 
    -0.13342549f, 0.02276399f, 0.05736464f, -0.08110684f, 0.02187548f, 0.08456261f, 0.07239664f, 0.00667727f, 
    -0.10939759f, -0.09103202f, 0.11479869f, -0.00989436f, -0.03878030f, -0.05306843f, -0.16046797f, 0.00499566f, 
    -0.08163085f, -0.04898093f, -0.10465138f, -0.07027519f, 0.09066667f, -0.04770126f, 0.13640514f, -0.05474394f, 
    0.09484860f, 0.10488893f, -0.00052213f, 0.00549675f, 0.12283598f, -0.05416647f, -0.06473686f, -0.07282971f, 
    -0.35854396f, -0.07166129f, 0.08684029f, -0.12916245f, 0.01411432f, -0.03736001f, -0.05735915f, -0.05387818f, 
    0.02103106f, 0.00954119f, -0.03188635f, -0.01841275f, -0.21130364f, -0.09135906f, 0.14548478f, 0.02243495f, 
    0.05108010f, -0.13713728f, -0.00568047f, -0.01594008f, -0.06798290f, -0.03935388f, 0.07086544f, 0.05582551f, 
    -0.11158548f, 0.15844007f, 0.11831403f, 0.16101277f, -0.09163310f, 0.02506753f, -0.00689271f, -0.02833294f, 
    -0.08757281f, -0.10152668f, 0.01866798f, -0.03481776f, -0.05142507f, 0.22950476f, -0.09856202f, -0.06420692f, 
    0.03889083f, 0.05659386f, 0.07260349f, -0.08071213f, 0.04022751f, 0.04865848f, 0.11698524f, -0.02582132f, 
    0.08259853f, 0.08986627f, -0.02720897f, 0.02149127f, 0.13440943f, 0.13375136f, -0.00684999f, -0.05586744f, 
    -0.00376064f, -0.02768175f, 0.04687225f, -0.00372692f, 0.10508450f, 0.09472829f, -0.11748756f, -0.08740409f, 
    0.07894625f, -0.01074856f, -0.14478262f, -0.01458649f, -0.03736386f, 0.03830434f, -0.01958553f, 0.03976941f, 
    0.22877896f, 0.41235584f, -0.18759036f, -0.23111968f, -0.05247358f, 0.03416137f, 0.10001431f, -0.02636676f, 
    -0.12279437f, -0.00655811f, -0.06947146f, -0.05557300f, -0.07464801f, -0.02684254f, 0.05940241f, -0.01884050f, 
    -0.12205347f, -0.01419572f, 0.01964589f, 0.08421722f, -0.06288410f, -0.01019337f, -0.19466014f, 0.04365369f, 
    0.32288933f, -0.00538976f, -0.12331900f, 0.09679876f, -0.10115253f, 0.00108632f, 0.00199552f, -0.02439312f, 
    -0.04084259f, -0.02204698f, -0.00968396f, 0.03718884f, 0.46732590f, -0.11022744f, 0.00842417f, 0.11117146f, 
    -0.05192754f, 0.05898424f, -0.00971017f, 0.04489406f, 0.06220029f, -0.09946401f, -0.00807600f, -0.01359786f, 
    -0.14819984f, -0.22515193f, 0.06627232f, -0.24554864f, -0.17027600f, -0.08690947f, 0.08706956f, -0.05749274f, 
    -0.07646488f, -0.10403453f, 0.00105561f, -0.03779659f, 0.24749741f, 0.05490853f, 0.09692683f, 0.25947115f, 
    0.19591118f, 0.10795182f, 0.02980025f, 0.16027546f, 0.02964677f, 0.09329713f, 0.01090779f, 0.00469148f, 
    -0.06457976f, 0.02015605f, 0.08309181f, 0.06620594f, -0.06586522f, -0.01389658f, -0.12575929f, -0.09137353f, 
    -0.06714209f, -0.01045927f, 0.04524956f, -0.04418657f, 0.06256551f, 0.18930687f, 0.08670710f, 0.14855453f, 
    0.12801993f, -0.03416150f, 0.15167207f, 0.01956423f, 0.02404743f, 0.06317770f, 0.01310720f, 0.08788687f, 
    -0.08786003f, 0.00226736f, -0.16517854f, 0.02622623f, 0.00025747f, 0.07499434f, -0.16387784f, 0.00524940f, 
    -0.04964770f, -0.08409193f, -0.04997890f, -0.10438950f, 0.07248920f, -0.02465964f, 0.08644378f, -0.08405275f, 
    -0.02395922f, -0.05956232f, 0.08920925f, 0.09331141f, -0.03113150f, 0.02548634f, 0.09029642f, 0.03358070f, 
    0.22902152f, -0.08190493f, 0.17104846f, -0.06899638f, -0.00296811f, 0.02841050f, -0.06931847f, 0.00394816f, 
    0.04722154f, 0.04749053f, 0.07087162f, -0.01276073f, -0.09306662f, 0.14078504f, -0.03560590f, 0.05288979f, 
    0.05178460f, 0.07296297f, 0.08084172f, 0.03012598f, 0.10897657f, 0.15255722f, -0.03821623f, -0.03400286f, 
    -0.27438909f, 0.06215703f, -0.03593077f, 0.17186239f, 0.04683398f, -0.01457679f, -0.06772398f, 0.12697332f, 
    -0.08378062f, 0.01316284f, -0.04861473f, 0.06964965f, 0.02152824f, -0.09564061f, 0.01252120f, 0.23665917f, 
    -0.09690110f, -0.09640647f, -0.01753625f, -0.00363680f, 0.03798717f, -0.03857029f, -0.04101755f, 0.03944945f, 
    0.17618704f, -0.05802167f, -0.12074132f, 0.08627646f, -0.10310373f, 0.06926530f, -0.03205794f, -0.01870985f, 
    -0.02995699f, 0.09623095f, 0.08261845f, -0.02402017f, 0.48803303f, -0.04121605f, 0.13423260f, 0.17517085f, 
    0.04162830f, 0.01675058f, 0.04038679f, 0.13215774f, -0.03498459f, -0.02509729f, -0.02884588f, -0.03757815f, 
    0.21710429f, -0.03528313f, 0.13547064f, -0.02781534f, -0.15907636f, -0.04827464f, 0.19249828f, 0.05100596f, 
    0.01314249f, 0.07822438f, 0.02844269f, -0.10043026f, -0.02510155f, 0.20981227f, 0.20412534f, 0.07384891f, 
    0.08964182f, 0.05384562f, 0.01059652f, 0.06880493f, 0.03986786f, 0.04341391f, 0.00129451f, -0.00636019f, 
    -0.01952907f, 0.04756008f, -0.11854235f, 0.01958672f, -0.00395083f, -0.05498914f, 0.01849494f, -0.09295120f, 
    -0.10895767f, -0.00322717f, -0.02453666f, 0.13959478f, -0.01260752f, 0.04134725f, -0.28481194f, -0.07773032f, 
    -0.06592388f, 0.11556700f, 0.08357833f, 0.03965672f, 0.10886906f, 0.02296001f, -0.05204099f, 0.00074383f, 
    -0.05246643f, -0.00334067f, 0.04024352f, 0.18565273f, -0.13474585f, -0.08728615f, 0.01746825f, 0.02808038f, 
    0.04965898f, -0.04726470f, -0.08813394f, -0.07220840f, 0.13434851f, -0.02145926f, -0.00498913f, -0.03110145f, 
    0.00612162f, -0.04012116f, -0.00770365f, -0.11393412f, -0.02493829f, 0.01685104f, 0.03991789f, -0.02622180f, 
    -0.06565128f, 0.11797304f, -0.10152607f, 0.03433967f, -0.03274346f, 0.14669244f, 0.08597613f, -0.01567720f, 
    -0.05966150f, -0.08160705f, -0.02325606f, -0.03726876f, -0.16115081f, -0.04147089f, 0.00927062f, 0.18006386f, 
    0.03644798f, -0.03121549f, 0.07228759f, -0.06385271f, -0.00392039f, 0.09017503f, -0.09169375f, -0.00617976f, 
    0.17605928f, -0.09230092f, -0.01991854f, -0.02703927f, -0.03762788f, -0.07180446f, -0.02123490f, -0.04560060f, 
    -0.09595338f, -0.08130090f, 0.01015731f, 0.07819464f, -0.05868571f, 0.05662307f, -0.16429736f, -0.03249390f, 
    -0.03446814f, 0.03416027f, 0.01664834f, 0.05563081f, -0.03428936f, -0.10438474f, -0.07167652f, 0.06096372f, 
    0.18477920f, 0.13772945f, 0.05845796f, 0.22260967f, 0.13748063f, 0.05430805f, 0.06089023f, 0.08822545f, 
    0.09530203f, -0.03291048f, 0.08650239f, 0.15577711f, -0.19540657f, 0.06115300f, -0.03959275f, -0.07393069f, 
    0.00297669f, -0.01513527f, 0.11368597f, -0.10506359f, -0.18163656f, -0.02664161f, 0.00980233f, -0.03101715f, 
    -0.15483370f, 0.04694954f, 0.09707058f, 0.03522016f, -0.13309792f, -0.06169055f, 0.03012607f, 0.06891881f, 
    -0.07671690f, 0.04449723f, 0.03976959f, 0.01390030f, 0.12254149f, 0.09522708f, 0.25230429f, 0.13837127f, 
    0.08782684f, 0.11269076f, 0.04956657f, 0.02926234f, 0.00985195f, 0.02372916f, -0.02894813f, -0.01144270f, 
    -0.09673367f, -0.06948788f, -0.05144430f, -0.01960885f, -0.07827037f, -0.07018061f, -0.06922055f, -0.06608187f, 
    -0.02855920f, -0.07353429f, 0.01370416f, 0.03095859f, 0.11439677f, -0.01314649f, -0.09643083f, 0.15278256f, 
    -0.17763756f, -0.04776158f, -0.01499070f, -0.00489449f, 0.03700864f, 0.00978229f, -0.06636757f, -0.04035796f, 
    0.21644965f, 0.09608464f, 0.09980962f, 0.09828790f, 0.02545870f, 0.06205823f, 0.02836231f, 0.02442358f, 
    -0.00443531f, 0.02464904f, -0.00413274f, -0.02173253f, 0.09973282f, 0.14942679f, 0.00208452f, -0.05256860f, 
    -0.05710831f, -0.01058041f, 0.05246871f, 0.02561521f, -0.09688237f, -0.00112740f, 0.03298830f, 0.04071784f, 
    0.00569725f, 0.03784645f, -0.09439185f, 0.03237830f, 0.05057759f, -0.03393482f, 0.00168381f, 0.01367867f, 
    -0.05078504f, 0.02977946f, -0.04552258f, -0.04510087f, 0.02168039f, -0.13941433f, 0.13963571f, -0.07188175f, 
    0.07475986f, -0.03412798f, 0.00268582f, 0.05679289f, -0.09469000f, 0.02327497f, 0.03500323f, -0.04007745f, 
    0.02980750f, 0.31770706f, 0.03812749f, 0.03204447f, 0.09257373f, -0.00522261f, 0.03271800f, -0.04364289f, 
    0.17891181f, 0.04092947f, 0.02992524f, -0.06809229f, -0.05444491f, -0.02417644f, 0.00339318f, 0.02101620f, 
    0.03884158f, 0.15102203f, -0.02750209f, 0.12300432f, -0.06250060f, -0.08761948f, -0.01635983f, 0.11700384f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04528484f, -0.03957363f, 0.05516041f, 0.06840426f, -0.02414820f, 0.02079727f, -0.02589818f, 0.03823528f, 
    0.03285214f, -0.00126797f, 0.06563299f, -0.02905596f, -0.05321628f, -0.00273557f, -0.02335002f, -0.02590627f, 
    -0.00310296f, 0.02220919f, -0.01139609f, -0.03560087f, 0.00266890f, -0.04165611f, 0.00591476f, 0.00726196f, 
    -0.02304819f, 0.01146526f, 0.00104170f, -0.02436832f, -0.00018925f, 0.05226101f, -0.01257074f, -0.05180731f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04526316f, -0.10523523f, -0.51558495f, 0.04780703f, -0.06243444f, -0.54974967f, 0.15485506f, 0.09931264f, 
    0.16390283f, 0.10063491f, -0.41466689f, 0.14257890f, 0.28854352f, 0.10685612f, -0.08322852f, 0.01978623f, 
    0.04448068f, -0.08932115f, -0.20463496f, -0.09631298f, 0.33091807f, 0.23246044f, -0.02332131f, -0.09510960f, 
    -0.11449517f, 0.03073895f, 0.08389837f, -0.07820586f, 0.03872088f, -0.58429402f, -0.16889782f, 0.10213652f, 
    -0.00701868f, 0.17676786f, -0.15604465f, -0.14668520f, -0.17660995f, -0.48565441f, 0.14309871f, 0.22098500f, 
    0.12883762f, -0.49382108f, -0.18082838f, 0.07549731f, -0.26792374f, -0.01996987f, 0.14607139f, 0.06755789f, 
    0.11314242f, 0.12169699f, 0.32303211f, -0.08115746f, 0.34742501f, -0.09737562f, -0.04942695f, 0.18823372f, 
    0.02589350f, 0.03319062f, -0.13226153f, 0.09862495f, -0.09943657f, 0.32831457f, 0.01756675f, 0.18470399f, 
    -0.26399520f, 0.05019171f, -0.14859819f, -0.09005269f, -0.11300721f, 0.32140410f, -0.11783055f, -0.42247456f, 
    0.08970004f, 0.33547309f, -0.38393691f, -0.10785722f, -0.10702663f, -0.08397118f, -0.14810634f, -0.13599226f, 
    -0.08186433f, -0.12699585f, 0.30656543f, 0.08573548f, 0.16359726f, 0.11233976f, -0.43997845f, -0.08229696f, 
    -0.13137670f, 0.37925762f, -0.01560329f, 0.15979029f, -0.07224809f, -0.31284097f, -0.00140613f, 0.27567726f, 
    0.29227015f, 0.12743793f, -0.53065962f, 0.25948316f, 0.07385111f, -0.11744414f, 0.16853039f, 0.26318431f, 
    -0.07938874f, -0.24087892f, 0.22793561f, -0.12318755f, -0.01197458f, 0.00781799f, -0.04465152f, -0.14617562f, 
    0.06661373f, 0.05093736f, -0.32753280f, -0.14786056f, -0.61624765f, 0.19828616f, 0.18461739f, -0.39862972f, 
    0.05263748f, 0.13336994f, 0.12407044f, 0.03860218f, 0.01053450f, -0.42767304f, 0.04490851f, -0.16911989f, 
    -0.19286436f, 0.08491749f, 0.15351933f, -0.17150055f, 0.08513660f, 0.13840008f, 0.08637798f, 0.15603502f, 
    0.05651888f, -0.22663504f, 0.15815029f, 0.12976250f, 0.22080755f, 0.08149236f, 0.08676638f, 0.03188661f, 
    -0.13905556f, -0.02116781f, -0.43488321f, 0.02087649f, -0.31654370f, 0.34302694f, -0.00569656f, 0.32054093f, 
    0.17163396f, 0.03262373f, 0.03661823f, -0.11451367f, -0.06033349f, -0.17269334f, -0.15528220f, 0.43982437f, 
    -0.32139552f, 0.04587177f, -0.11995846f, 0.16469266f, 0.10232834f, 0.55074728f, -0.15714771f, -0.08886702f, 
    -0.20440538f, -0.08108510f, 0.05806454f, -0.14627001f, 0.19107336f, -0.06928369f, 0.02404343f, 0.11356860f, 
    -0.07008095f, 0.02242289f, 0.09982411f, -0.02108710f, 0.16245010f, -0.28303888f, 0.29563391f, -0.18560608f, 
    -0.12523241f, -0.54403311f, -0.03326848f, -0.00001071f, 0.14715888f, 0.31233388f, -0.04992424f, -0.12367170f, 
    -0.25902328f, 0.14628302f, 0.39129049f, -0.05619108f, -0.06991754f, -0.48399454f, 0.05063724f, -0.24211073f, 
    0.16256851f, 0.38729811f, -0.20750460f, 0.16826463f, 0.03713606f, -0.09250250f, -0.07658528f, 0.17184888f, 
    0.01025991f, 0.04736834f, 0.23042212f, 0.09911629f, -0.33261168f, 0.20277075f, 0.23260781f, 0.14049035f, 
    -0.13171029f, -0.20937756f, -0.01402852f, 0.01337805f, -0.14090730f, -0.23587814f, 0.09480641f, -0.74786568f, 
    0.29153186f, -0.09781697f, -0.08395126f, -0.20271501f, 0.10164992f, 0.02304699f, 0.01378796f, 0.00013819f, 
    -0.27738795f, 0.33129078f, 0.16143371f, 0.04535272f, 0.25932473f, 0.04706571f, -0.12835528f, -0.12492602f, 
    -0.04043484f, 0.04319905f, -0.05338379f, -0.12861349f, -0.37468636f, -0.22954826f, -0.28334200f, -0.35386321f, 
    -0.17960417f, 0.20087744f, -0.16523047f, -0.06790794f, -0.08410730f, 0.19843526f, -0.16467957f, 0.43051943f, 
    0.16689210f, -0.16491410f, -0.01741559f, 0.14632629f, -0.16553934f, 0.00529955f, 0.05065698f, -0.48926070f, 
    0.30972189f, -0.47716650f, 0.19022198f, 0.01435659f, -0.06795924f, -0.11530156f, 0.10837194f, 0.06300695f, 
    0.13403046f, -0.03916312f, 0.15313718f, -0.08370789f, -0.09464313f, -0.22473435f, -0.58770531f, 0.20525119f, 
    0.01547661f, 0.11628887f, 0.01234016f, -0.01270076f, 0.05118855f, 0.22257286f, 0.12421982f, -0.39525265f, 
    0.32296419f, 0.05026567f, 0.39035481f, -0.31313738f, -0.01874354f, -0.02448542f, 0.16736057f, 0.01327437f, 
    -0.64222926f, 0.20769279f, -0.13650739f, -0.08718390f, 0.24839726f, -0.00017286f, -0.02488825f, -0.08276262f, 
    -0.16213423f, 0.14655499f, 0.04323233f, -0.09437044f, 0.28579539f, 0.17905828f, -0.09106062f, 0.05573943f, 
    0.07984810f, 0.24954338f, 0.02360627f, -0.08557174f, 0.16895851f, 0.05753016f, 0.01921644f, -0.21060909f, 
    -0.31420031f, -0.03201158f, 0.10481067f, 0.13023090f, -0.03021525f, -0.20141669f, 0.14607944f, 0.11047722f, 
    -0.07901967f, 0.39118046f, 0.30729508f, 0.11896477f, -0.75753957f, 0.04996070f, -0.01368087f, 0.00627492f, 
    0.07411087f, -0.10644098f, 0.02099573f, 0.13230991f, 0.01997824f, -0.50051391f, -0.17212820f, -0.28822783f, 
    -0.11303244f, 0.31296486f, 0.02592961f, -0.05962171f, 0.13947049f, -0.19069585f, 0.06985516f, -0.22055103f, 
    0.49587449f, -0.14113095f, 0.18605463f, 0.20578682f, -0.06108721f, -0.02194155f, 0.15812266f, 0.30695751f, 
    -0.02880729f, -0.09489271f, -0.33260149f, -0.06745218f, -0.12199603f, -0.14438449f, -0.11660036f, -0.07199334f, 
    0.09482499f, 0.11350431f, -0.46401116f, -0.15010858f, -0.09699442f, -0.53112751f, -0.03627424f, 0.31619847f, 
    0.05631509f, -0.09167707f, -0.00552843f, -0.02537088f, -0.09805238f, 0.16192907f, 0.12320327f, -0.40959302f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21037637f, 0.00587347f, 0.02474993f, 0.13457711f, -0.15070224f, 0.00795713f, 0.02290609f, -0.07516753f, 
    -0.12356582f, -0.05595098f, 0.16468817f, -0.02362989f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
