#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.08266962f, -0.07735434f, 0.26370943f, 0.67457151f, 0.24085967f, -0.34236467f, -0.00496146f, 0.04895624f, 
    0.33365044f, 0.55571365f, -0.14391190f, 0.01401099f, 0.59113371f, -0.25259006f, 0.26878512f, 0.76890463f, 
    -0.62465137f, -0.45174399f, 0.75918704f, -0.24149963f, -0.10631470f, 1.00008833f, 0.55111098f, 0.38168782f, 
    -0.36911175f, -0.13786279f, -0.45991015f, 0.49796027f, 0.22497290f, 0.27034703f, -0.69086331f, -0.42133904f, 
    -0.58599341f, -0.07896942f, 0.22473550f, -0.33564481f, -0.19910361f, 0.60268360f, 0.75375605f, 0.34970933f, 
    0.74419224f, 0.24413046f, -0.17952925f, -0.18034549f, -0.29998791f, 0.33893305f, -0.69358337f, -0.81739402f, 
    -0.31641242f, -0.24792565f, -0.07019375f, -0.44328374f, 0.17248434f, -0.38641983f, 0.63126212f, 0.62654543f, 
    0.19876459f, -0.38382226f, 0.78548032f, -0.62398541f, -0.07927928f, 0.23571239f, 0.28073263f, 0.53972447f, 
    0.46445888f, 0.56642723f, 0.43927625f, 0.14681830f, 0.05500349f, 0.11359179f, 0.12050764f, 0.44990307f, 
    0.38114801f, 0.27159333f, 0.17496440f, 0.36437193f, -0.32392210f, -0.58344686f, 0.10138198f, 0.66210139f, 
    0.34504807f, 0.39781705f, -0.26462901f, -0.44956398f, 0.89810801f, -0.48934796f, 0.18743514f, -0.16032854f, 
    -0.50503224f, 0.32251963f, -0.37924811f, -0.58859158f, 0.64877993f, 0.42260090f, -0.41435063f, -0.33122492f, 
    -0.43655512f, -0.67211568f, -0.47707200f, 0.40375331f, -0.05027834f, 0.47111079f, 0.03022986f, -0.20447187f, 
    0.44880167f, -0.62201345f, -0.58993399f, -0.68063307f, -0.90019298f, 1.05693543f, 0.28933939f, -0.39886773f, 
    -0.24459185f, -0.43976751f, 0.21928099f, 0.12642446f, -0.24912934f, -0.50690192f, -0.79578066f, -0.53093934f, 
    -0.27360314f, -0.77175575f, 0.09916095f, 0.34483430f, -0.15178037f, -0.10596183f, 0.70004803f, 0.63150167f, 
    0.40990394f, 0.05063860f, -0.43620387f, 0.39703107f, -0.41768107f, 0.43284348f, -0.40080819f, -0.50801361f, 
    -0.45038703f, -0.00993320f, -0.82138562f, 0.74154234f, -0.31724775f, -0.07331296f, 0.42937499f, 0.29144007f, 
    -0.46154717f, 0.40390834f, -0.56880271f, 0.07914392f, 0.72137374f, -0.14801082f, 0.11379744f, -0.23859645f, 
    -0.47633189f, 0.85113770f, -0.62306058f, -0.31293279f, -0.45078272f, -0.23593432f, -0.19884667f, 0.06084579f, 
    0.15566653f, 0.42447516f, -1.01596928f, -0.52526814f, -0.32915860f, 0.37681925f, 0.37222907f, 0.79744256f, 
    0.45146427f, -0.26283363f, 0.37478879f, 0.80907708f, -0.44052354f, 0.35616913f, -0.86124933f, 0.44676298f, 
    0.60415423f, 0.09074761f, -0.16813111f, 0.16212355f, -0.27653801f, 0.71671170f, -0.79040909f, 0.49323231f, 
    -0.78354341f, 0.23153199f, -0.19288956f, 0.01882725f, 0.16478470f, -0.28250492f, -0.59965086f, -0.44043276f, 
    0.29507965f, 0.98800135f, 0.61618316f, -0.10068109f, -0.41887471f, -0.35041475f, 0.34119484f, 0.03577662f, 
    0.16066554f, -0.36242765f, -0.48372418f, -0.80486417f, -0.66963089f, -0.43242460f, -0.08667372f, 0.74671370f, 
    0.12258732f, 0.45733395f, 0.59959304f, 0.31921771f, -0.65363610f, 0.23414186f, 0.36520147f, -0.27398753f, 
    0.66001511f, 0.77223504f, 0.79836732f, 0.22051005f, -0.48561555f, 0.35086650f, 0.35102990f, -0.34536976f, 
    -0.37025124f, -0.87984604f, -0.40223458f, -0.76608497f, 0.14575335f, 0.29124430f, 0.05165704f, -0.11093915f, 
    0.05105821f, -0.44099447f, -0.95464855f, -0.02531655f, -0.15819596f, 0.01409889f, 0.54237866f, -0.42707297f, 
    0.16335216f, -0.04224379f, -0.19690259f, 0.19771050f, -0.12291826f, 0.17301510f, -0.99484926f, -0.79626161f, 
    -0.67573994f, 0.29795066f, 0.09666146f, 0.47956961f, 0.13264695f, -0.66982687f, 0.49731472f, -0.80560344f, 
    -0.48300409f, 0.13889800f, 0.03052994f, 0.22632624f, -0.00059569f, -0.59514344f, -0.87849027f, -0.63090354f, 
    0.09305508f, -0.36743668f, -0.26346064f, 0.08643841f, 0.45553809f, 0.37201807f, 0.75484931f, 0.66346133f, 
    0.51097345f, -0.31371728f, -0.52402771f, 0.04536242f, 0.04910723f, 0.22206084f, 0.35133523f, -0.02531110f, 
    -0.28147966f, 0.31538808f, -0.96845365f, 0.25268695f, -0.49398449f, -0.34914860f, 0.40729919f, -0.08636988f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03665158f, 0.05360876f, 0.17204061f, 0.07888988f, -0.10598394f, -0.22573827f, 0.23727483f, 0.16104858f, 
    0.10087323f, -0.42286217f, -0.37636095f, -0.35408252f, -0.20018290f, 0.32753244f, 0.11285357f, 0.13855526f, 
    0.09585520f, -0.11813135f, 0.05619523f, -0.09200303f, -0.32895517f, 0.00141159f, 0.21255821f, 0.12074363f, 
    -0.21705545f, -0.12400328f, 0.06162927f, 0.02108156f, -0.07415370f, 0.01763455f, -0.01581931f, 0.17426577f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01886932f, -0.00770372f, 0.05158561f, -0.11890594f, -0.13152739f, 0.03196318f, 0.02793228f, -0.13587317f, 
    0.00673185f, -0.03807061f, -0.26720998f, -0.05779330f, -0.02908605f, 0.10339986f, -0.11481993f, 0.15468365f, 
    0.03933116f, 0.01421665f, -0.07046042f, -0.01235044f, -0.04969294f, -0.00312352f, 0.04463889f, -0.14254133f, 
    0.09560086f, 0.12523958f, 0.15725413f, 0.20566654f, 0.13761047f, 0.26460418f, 0.24537872f, 0.08889437f, 
    0.16793770f, 0.11585683f, -0.15162532f, -0.15211618f, -0.31482989f, -0.00258734f, -0.03986686f, 0.20128305f, 
    0.03585469f, -0.20764829f, -0.02672655f, 0.03018354f, 0.06807119f, 0.27261108f, 0.04660632f, -0.06499874f, 
    -0.04016370f, -0.08438192f, -0.09086414f, -0.03736752f, -0.04465611f, -0.13010962f, -0.21179062f, -0.23014620f, 
    -0.20099899f, -0.02888968f, 0.10617048f, 0.13225852f, -0.05506011f, 0.07150061f, -0.01092244f, -0.50597447f, 
    -0.28845179f, -0.02363011f, -0.03322173f, 0.06236261f, 0.01654487f, 0.09293334f, 0.01593370f, 0.25294784f, 
    0.06584338f, -0.19842449f, -0.07833491f, 0.12417683f, 0.02995280f, 0.26316869f, -0.10572576f, 0.10838038f, 
    0.09910116f, 0.07199632f, 0.19498847f, 0.23433612f, -0.04124022f, 0.12750062f, -0.06821293f, 0.02208910f, 
    0.01359285f, 0.03880696f, -0.25125480f, -0.04975584f, -0.17591022f, 0.01702560f, 0.09041043f, 0.14502804f, 
    -0.14525060f, -0.29608536f, 0.02328327f, -0.39618772f, -0.27166092f, -0.00261956f, 0.01248803f, 0.17133528f, 
    0.06769495f, -0.12610607f, -0.15852793f, 0.04633247f, 0.16265136f, -0.01743043f, 0.01520775f, 0.33041006f, 
    -0.02289682f, 0.08981723f, -0.07704186f, -0.09409427f, -0.12309875f, -0.00486885f, 0.13849424f, -0.31986362f, 
    0.09802094f, 0.04387284f, 0.06085315f, 0.04542122f, 0.01765247f, -0.03925902f, -0.25520104f, -0.42012942f, 
    0.08022162f, -0.03562111f, -0.07696340f, -0.02899605f, -0.17850949f, 0.03649110f, -0.09505236f, -0.12831710f, 
    0.01510682f, 0.00683488f, 0.20836070f, -0.14334273f, 0.06282568f, -0.03792067f, 0.05401933f, -0.10926279f, 
    0.05669499f, -0.06685096f, -0.12397327f, 0.05516112f, 0.04264127f, -0.05978147f, -0.03971480f, -0.01082876f, 
    -0.07616324f, 0.24029149f, 0.02200912f, -0.11208642f, -0.02543379f, -0.11379207f, 0.08780544f, 0.07710230f, 
    -0.16390288f, -0.01339403f, 0.23469356f, 0.25530872f, 0.02114330f, 0.12135101f, 0.01792384f, -0.15626384f, 
    0.00238779f, 0.01628171f, 0.11389858f, -0.32647294f, -0.07425249f, -0.07978877f, -0.03391209f, -0.11062253f, 
    -0.00055310f, 0.06422097f, -0.00279059f, 0.22154370f, 0.30208462f, -0.24393681f, -0.12529886f, 0.10070170f, 
    0.01823533f, -0.02176535f, -0.02297626f, -0.14471722f, 0.04351400f, 0.12681118f, -0.07976186f, -0.06381531f, 
    0.06123185f, 0.04378768f, -0.06596167f, 0.11534923f, 0.12927009f, -0.04016495f, -0.07165050f, 0.15538426f, 
    0.06024108f, 0.15356110f, 0.04266934f, 0.07196001f, -0.02491438f, -0.16064298f, -0.09191935f, -0.13870952f, 
    -0.16758314f, -0.23717621f, -0.19149956f, 0.00492616f, 0.04724552f, 0.09584281f, 0.09758031f, -0.00373654f, 
    -0.18260063f, -0.60264766f, -0.07122448f, -0.00457151f, 0.22483139f, 0.01109103f, -0.07131740f, -0.09948904f, 
    0.11430012f, 0.03315187f, 0.15482408f, 0.06738011f, -0.09686596f, 0.08992805f, -0.09712677f, 0.15236907f, 
    -0.03622231f, -0.04590216f, -0.08909960f, 0.10717626f, 0.04292886f, 0.10324629f, 0.03104602f, 0.16183802f, 
    -0.03119742f, -0.05624437f, 0.07145795f, 0.12876110f, 0.16320413f, 0.07589968f, -0.00536154f, 0.07448253f, 
    0.09733752f, -0.00601241f, -0.07430167f, -0.07220212f, 0.06736181f, 0.40849406f, 0.22283310f, -0.20203348f, 
    0.02773369f, -0.00133229f, -0.01812342f, 0.02423710f, 0.10155195f, -0.01002407f, 0.17985907f, -0.14219658f, 
    -0.04624539f, -0.12635081f, 0.10003557f, 0.01303670f, 0.12394664f, 0.16248542f, -0.05530124f, -0.52974588f, 
    0.02078667f, 0.09158225f, 0.01970508f, 0.08220360f, -0.05074669f, 0.01266543f, 0.07442273f, 0.03590877f, 
    0.26815370f, 0.04263674f, 0.05031222f, -0.05634958f, 0.14332896f, 0.07287975f, -0.03632721f, -0.02702064f, 
    0.02294318f, 0.01622126f, 0.00043932f, 0.03683291f, -0.00601982f, -0.04049851f, 0.05298575f, 0.04767790f, 
    -0.03184665f, 0.01544315f, 0.02954328f, -0.04909706f, -0.05350480f, -0.02315960f, 0.02804943f, 0.03661237f, 
    -0.02016212f, -0.04473657f, -0.06160924f, -0.03142400f, 0.03425494f, -0.02955473f, -0.01359312f, 0.02934616f, 
    -0.05707504f, -0.01557586f, 0.00351233f, -0.04732028f, 0.03044642f, 0.05193992f, -0.03739517f, -0.04514444f, 
    0.03489293f, -0.00076227f, 0.00545390f, 0.02520141f, -0.00578705f, -0.06142789f, -0.05230468f, -0.05689405f, 
    -0.05255452f, 0.04862030f, -0.04336986f, -0.06549110f, 0.00415180f, 0.02986236f, -0.01860076f, 0.04085021f, 
    0.03568115f, -0.04422951f, -0.02195438f, -0.03953346f, 0.04988163f, 0.00628896f, 0.01146113f, -0.02528471f, 
    0.00639029f, 0.03393434f, 0.00863557f, 0.00309721f, -0.05934871f, 0.04319990f, -0.06176517f, 0.02107561f, 
    -0.05025596f, 0.05210656f, 0.02686070f, 0.03038792f, -0.03375959f, 0.00530067f, 0.04313901f, -0.03993652f, 
    0.05247092f, 0.00532520f, -0.04400667f, -0.04916332f, 0.03943279f, 0.02794284f, 0.04908773f, -0.02380743f, 
    -0.00342215f, 0.05001114f, -0.03814529f, -0.04277659f, 0.05031030f, -0.02776041f, -0.02074591f, -0.03368638f, 
    -0.04808301f, 0.04251378f, -0.05293007f, 0.01405377f, 0.02577321f, 0.03044755f, -0.03339187f, 0.04864999f, 
    -0.04786851f, 0.00594125f, -0.04347451f, -0.05962541f, 0.02520597f, -0.04212456f, -0.02351286f, 0.00864704f, 
    -0.02665890f, 0.05266078f, 0.01567703f, -0.01346027f, -0.01694888f, 0.01840370f, -0.03607576f, -0.05221399f, 
    0.00240800f, -0.02831217f, 0.03057981f, 0.00454650f, 0.00143471f, -0.00944449f, -0.04580960f, 0.00742453f, 
    0.04957477f, 0.03975346f, 0.01911441f, -0.01785937f, 0.00090544f, 0.03090352f, 0.04848063f, -0.02339059f, 
    -0.03257811f, 0.04517154f, 0.02947963f, -0.06645605f, 0.04451380f, -0.05903593f, -0.04275520f, -0.02667049f, 
    0.05243758f, -0.04734411f, 0.04776643f, 0.04418236f, 0.03283903f, -0.03948230f, -0.06417148f, -0.01097697f, 
    -0.00828329f, 0.05040195f, 0.03395100f, -0.02023155f, -0.04860491f, -0.04704138f, -0.05091628f, 0.00777339f, 
    -0.01398220f, -0.03094764f, 0.03765531f, -0.03350285f, -0.03140860f, -0.04088306f, 0.03942906f, -0.04523151f, 
    0.04066202f, -0.02447608f, -0.05776631f, -0.03965173f, 0.00256382f, 0.02531958f, -0.05511130f, 0.00281696f, 
    0.04225963f, -0.05087942f, 0.01591280f, -0.05958868f, 0.03729479f, -0.05503843f, 0.02938251f, -0.00397718f, 
    -0.03328090f, 0.00969034f, -0.01029889f, 0.00148234f, -0.04095443f, -0.05172245f, -0.05002641f, 0.04172486f, 
    -0.01925521f, 0.03591885f, 0.04852030f, -0.00306696f, -0.01947602f, -0.02319236f, 0.01404540f, -0.00424528f, 
    -0.04600232f, 0.04348653f, 0.00659980f, 0.01458884f, -0.02557674f, 0.02193907f, 0.02415046f, 0.03212961f, 
    -0.02381532f, 0.03863042f, -0.00975813f, 0.00950336f, -0.01990510f, -0.02672037f, -0.01794096f, -0.04964438f, 
    0.02255640f, -0.03109010f, -0.01293728f, -0.03704631f, 0.00078410f, -0.02670222f, -0.01051930f, -0.00415704f, 
    -0.06420808f, 0.04319037f, 0.00122543f, 0.02234294f, -0.00950093f, 0.03727221f, -0.05030575f, 0.03247396f, 
    0.01165686f, -0.06067165f, -0.03517038f, 0.01895615f, -0.01077453f, 0.02675271f, 0.00990842f, -0.05761088f, 
    -0.00185431f, -0.03474195f, 0.04288821f, 0.01724121f, -0.00680841f, -0.01743049f, 0.01750403f, -0.00033476f, 
    -0.04621341f, 0.03713760f, 0.04656252f, 0.00401172f, -0.03247346f, 0.00487216f, -0.00715641f, -0.00475666f, 
    -0.05389913f, -0.01708492f, -0.03918236f, -0.04908600f, 0.02251792f, 0.02728563f, 0.01384956f, 0.04366054f, 
    0.03927698f, -0.01570824f, -0.01854119f, -0.02938684f, -0.03134685f, 0.02591803f, -0.01428286f, -0.04686131f, 
    -0.00565041f, -0.05209487f, -0.01275469f, 0.00818655f, -0.01613823f, 0.02738710f, -0.00110205f, -0.05071713f, 
    0.04378474f, 0.04061436f, -0.05126376f, 0.01972387f, 0.01814151f, 0.01791183f, 0.01452998f, -0.03293809f, 
    -0.05336287f, -0.03364691f, -0.03426139f, -0.00210484f, 0.03926004f, -0.04273106f, 0.03592547f, -0.02481423f, 
    0.46979085f, 0.07769100f, -0.14865938f, -0.09306628f, -0.04419032f, -0.02031126f, -0.00742663f, -0.02764822f, 
    -0.08358876f, -0.04885286f, 0.07197782f, -0.23233394f, 0.10518341f, 0.04903221f, -0.01860684f, -0.22753146f, 
    -0.01836157f, -0.06654393f, -0.28774211f, -0.19910324f, 0.05436367f, 0.03838046f, -0.14525545f, -0.04123601f, 
    0.00842448f, -0.13785701f, -0.12430987f, 0.04318466f, -0.00906409f, 0.11092455f, 0.12104916f, 0.12799345f, 
    -0.09989698f, -0.16150570f, 0.02238064f, 0.03285656f, 0.27422103f, 0.17345931f, 0.06666599f, -0.01333239f, 
    0.26920250f, 0.17733151f, 0.09513914f, 0.02818372f, -0.25736287f, 0.24113934f, 0.01901743f, 0.20126376f, 
    -0.07906978f, 0.21143168f, 0.15032336f, 0.05314357f, -0.01645327f, 0.27515462f, 0.36540750f, 0.22086637f, 
    -0.00998511f, -0.02297767f, -0.27002445f, 0.14166597f, 0.17907837f, -0.19061601f, -0.27426791f, -0.07824743f, 
    0.11159468f, 0.25915661f, -0.13772959f, 0.07896699f, 0.13181461f, 0.22215095f, 0.07583550f, -0.30096203f, 
    -0.15645340f, -0.12540519f, 0.13312322f, -0.05060257f, -0.08700152f, -0.12868866f, 0.01949214f, -0.22380400f, 
    -0.25102457f, 0.07254999f, -0.17595126f, 0.06854703f, -0.00613119f, -0.08082388f, -0.38618314f, -0.21842954f, 
    -0.06809375f, 0.12966016f, -0.07623734f, -0.40194157f, -0.05747471f, -0.17514183f, 0.00475885f, -0.03276415f, 
    0.03143974f, 0.11089736f, -0.22142324f, -0.56316078f, 0.03444268f, 0.14563183f, 0.06588955f, -0.07641739f, 
    0.06233782f, -0.14203745f, 0.05921355f, -0.10741113f, 0.65550709f, 0.13787955f, 0.10107914f, -0.14824210f, 
    -0.00004640f, 0.06522524f, -0.07192320f, 0.09553009f, -0.15433437f, 0.11463893f, -0.17939037f, 0.25942191f, 
    0.01748784f, 0.13110840f, 0.00989508f, 0.01178882f, 0.01001068f, 0.09605443f, -0.24561399f, 0.01672142f, 
    0.19763635f, 0.24469765f, 0.18559189f, 0.09492476f, -0.14397541f, 0.17690128f, -0.14372715f, 0.38950345f, 
    0.08820911f, 0.04677213f, -0.16743359f, 0.03302515f, -0.00422997f, 0.06747919f, -0.08385876f, 0.04498697f, 
    0.14629093f, -0.09003724f, -0.24343954f, -0.05551789f, 0.05803763f, -0.00064279f, -0.14880811f, 0.15668209f, 
    0.10458409f, 0.47756636f, -0.06043132f, -0.00605744f, 0.19259509f, -0.02348387f, -0.26627091f, 0.04683432f, 
    0.25983402f, -0.04025865f, 0.19850671f, -0.07231837f, 0.06094326f, -0.01580003f, 0.12826481f, -0.11873940f, 
    -0.11272076f, -0.16351472f, -0.12607610f, 0.24950673f, 0.12842369f, -0.06403450f, 0.13575400f, -0.08304174f, 
    0.14476126f, -0.13441713f, 0.03026687f, -0.14772949f, 0.02742236f, 0.02158953f, -0.11249218f, -0.07984427f, 
    0.23254475f, 0.02789271f, -0.11551723f, -0.29937997f, 0.16510491f, -0.30017611f, -0.13063757f, 0.07560134f, 
    -0.10648379f, -0.00531051f, -0.07065015f, -0.08308102f, 0.06688627f, 0.14137627f, 0.13034329f, 0.09617137f, 
    0.14902332f, 0.15355143f, 0.15617849f, -0.13612680f, 0.04942190f, 0.06219891f, 0.16505478f, 0.17436969f, 
    -0.05581535f, 0.09918437f, -0.22100450f, -0.12195587f, 0.13919437f, 0.17883480f, -0.14224398f, -0.43347043f, 
    -0.06476744f, 0.23298217f, 0.32769078f, -0.02932060f, 0.18750605f, -0.02552715f, 0.13520792f, 0.08083245f, 
    -0.00412521f, 0.20975064f, -0.22568496f, 0.13117710f, -0.24879780f, 0.06097864f, 0.08642406f, 0.00325217f, 
    0.16803695f, 0.07380212f, 0.46508020f, -0.15550636f, -0.19308653f, -0.16590306f, -0.03908926f, 0.04030371f, 
    -0.10253534f, 0.06574050f, -0.03571232f, -0.09407419f, -0.06370737f, 0.23918787f, 0.26463461f, 0.14249054f, 
    -0.23469362f, -0.01732987f, 0.17249295f, 0.02047363f, 0.13301124f, -0.06571037f, 0.08106271f, 0.02846071f, 
    0.07650761f, -0.26925337f, -0.19955033f, 0.01610582f, -0.00024208f, 0.14629848f, -0.06179236f, 0.27059034f, 
    0.08002687f, 0.11956254f, -0.09151127f, -0.06048829f, -0.17475541f, 0.05093297f, -0.09194788f, 0.15892296f, 
    0.41610056f, -0.07467452f, 0.23022583f, -0.14396207f, -0.08529846f, 0.12820877f, -0.33355767f, 0.28027105f, 
    0.17176986f, -0.04792700f, -0.13759799f, 0.00996035f, -0.00834898f, -0.04040953f, -0.13821648f, 0.20932792f, 
    -0.02760540f, -0.01888008f, 0.04629470f, -0.04010666f, 0.03064439f, 0.01408971f, -0.05557419f, 0.00544378f, 
    -0.03273186f, 0.05151443f, 0.01778790f, 0.03554091f, 0.02222318f, 0.03458575f, 0.04641876f, -0.00330117f, 
    0.00035970f, -0.04808486f, 0.02120518f, -0.00035861f, 0.02543454f, -0.01079841f, -0.03015744f, 0.02139413f, 
    0.00450580f, 0.03154472f, -0.03833834f, 0.04154537f, 0.01696978f, -0.03454010f, -0.06447116f, -0.02094905f, 
    -0.00608350f, 0.00401766f, 0.04486012f, -0.02440258f, -0.01895773f, 0.04221914f, 0.01436987f, 0.04300972f, 
    -0.01366345f, -0.00741583f, 0.01138128f, -0.04943733f, 0.03687117f, -0.06454562f, 0.04932558f, 0.02353586f, 
    0.03951517f, 0.00060240f, -0.04451193f, -0.03972610f, 0.04334145f, 0.02051250f, 0.02541172f, 0.01756219f, 
    -0.06274971f, 0.03919431f, -0.06306570f, -0.02429218f, -0.06507355f, 0.01506108f, -0.03867386f, -0.06654406f, 
    -0.04293304f, -0.06328679f, -0.01539581f, 0.00548375f, -0.02199705f, 0.00575280f, -0.05130083f, -0.04425006f, 
    -0.05907591f, 0.01185341f, -0.01835503f, 0.03146258f, -0.05186259f, -0.02083670f, -0.04029836f, 0.02484287f, 
    -0.03419305f, -0.02402614f, -0.02528063f, -0.01550300f, 0.04305081f, 0.02085576f, 0.00553651f, -0.05481846f, 
    -0.02945975f, 0.00122296f, -0.00019851f, 0.01051162f, -0.04099643f, -0.00401385f, 0.02189344f, 0.03075335f, 
    -0.04186929f, 0.00225635f, -0.03189871f, -0.02524566f, -0.04657047f, 0.02421938f, 0.01204406f, -0.02255044f, 
    -0.05842423f, 0.02538555f, 0.03720860f, 0.04888980f, -0.01291673f, 0.05171569f, -0.03955109f, -0.00370936f, 
    -0.03010671f, -0.02770390f, 0.01034018f, 0.05619229f, -0.03354062f, -0.04135058f, -0.00242662f, -0.03139323f, 
    -0.06026828f, -0.02525281f, -0.05203376f, -0.04769996f, 0.00424034f, 0.03268661f, -0.03012047f, 0.02061011f, 
    0.00243468f, 0.04685866f, 0.02628337f, 0.02043783f, -0.04602048f, -0.03733792f, 0.04143068f, 0.04300359f, 
    -0.00235970f, 0.02898089f, -0.02769110f, 0.00874898f, 0.03885984f, -0.04885387f, -0.01377400f, 0.02123106f, 
    -0.01917534f, -0.05556545f, -0.01626379f, -0.04319280f, 0.03851239f, -0.04413046f, 0.02390526f, -0.02778905f, 
    0.02812770f, 0.04139391f, 0.01315503f, -0.04739248f, -0.03147167f, -0.01696772f, 0.04898392f, 0.02345206f, 
    -0.06063129f, 0.05326400f, -0.05764156f, 0.05118002f, 0.02703222f, -0.05146668f, -0.04003320f, -0.05794376f, 
    -0.06070876f, 0.01356941f, 0.00645582f, -0.01562294f, 0.01637604f, 0.01828328f, -0.02393644f, 0.04790531f, 
    -0.00422266f, -0.04975778f, -0.03165407f, -0.00781490f, 0.03007871f, 0.04106151f, -0.02083640f, -0.03306377f, 
    0.04425628f, -0.02679310f, 0.04662737f, -0.00611296f, 0.03506824f, 0.01685144f, -0.04885182f, -0.03831292f, 
    -0.04247209f, -0.02486772f, -0.05651798f, 0.01437227f, 0.00073002f, -0.01861657f, -0.02859085f, -0.05945459f, 
    -0.03254288f, 0.00217437f, -0.05831232f, -0.03155256f, -0.01233073f, -0.02835372f, -0.01504861f, 0.04620759f, 
    -0.03230314f, 0.04435402f, 0.02723434f, 0.05153064f, 0.02224077f, 0.00356108f, 0.05218745f, 0.04627910f, 
    -0.05366848f, -0.04215286f, -0.03252689f, -0.01553125f, 0.01856859f, 0.01998347f, -0.00253646f, -0.04375596f, 
    0.03612112f, -0.00232950f, 0.04981191f, -0.04285019f, -0.04862544f, -0.04609377f, 0.00148997f, -0.04594391f, 
    0.05265847f, 0.02382999f, -0.00451452f, 0.02167932f, -0.06289599f, 0.01029459f, -0.02508303f, 0.02601069f, 
    0.04590105f, 0.03152111f, 0.03168987f, 0.01059508f, -0.00089018f, 0.02225569f, 0.00148105f, 0.02787773f, 
    0.03903958f, 0.03954269f, -0.01120868f, -0.01343851f, -0.06304857f, 0.03039131f, -0.05125256f, -0.02599301f, 
    -0.02419197f, 0.01384353f, 0.02930577f, -0.05717334f, 0.00176957f, -0.03936024f, -0.02825989f, -0.06161392f, 
    0.04275235f, 0.03748893f, 0.01456328f, 0.01791383f, -0.02451645f, 0.02558060f, -0.03750790f, 0.05811955f, 
    -0.00104205f, -0.06010464f, -0.03711416f, 0.01514995f, -0.06121851f, 0.00347671f, -0.04970860f, -0.00732118f, 
    -0.02651518f, -0.05111746f, -0.02394930f, 0.04188172f, -0.04855150f, -0.05956654f, 0.01996544f, -0.04259291f, 
    0.04004830f, -0.04820497f, -0.01645796f, -0.00221176f, -0.03438570f, -0.04443124f, -0.04865964f, 0.00212269f, 
    0.02682240f, 0.01831189f, 0.02347643f, 0.03865058f, 0.02855692f, -0.02448647f, 0.03272902f, -0.06759128f, 
    0.01970240f, -0.02113576f, 0.04238235f, -0.05072044f, 0.01356823f, 0.04006096f, 0.04391588f, 0.01371365f, 
    0.02519896f, -0.00330102f, -0.03261710f, 0.01126562f, -0.04624314f, -0.01689504f, 0.02102879f, 0.01435625f, 
    0.00521844f, -0.04803916f, -0.02092179f, -0.01072419f, -0.02623243f, 0.04896405f, 0.02888688f, 0.00252717f, 
    -0.01979279f, -0.06488393f, -0.01185885f, -0.05485363f, -0.02413313f, -0.00629251f, -0.00099668f, -0.05588891f, 
    -0.06578043f, -0.03147313f, -0.02974106f, 0.03517506f, -0.02868302f, 0.01436216f, -0.06028097f, 0.03503084f, 
    -0.02113392f, 0.02972678f, -0.05909413f, -0.03791102f, 0.01413562f, 0.02208221f, -0.05416816f, 0.01143082f, 
    -0.00942663f, -0.01558215f, 0.02629477f, -0.02518218f, 0.03508286f, -0.04047277f, -0.01769727f, -0.05739395f, 
    -0.01341992f, -0.06148148f, 0.05009329f, 0.03292233f, -0.05313702f, -0.01812927f, 0.04696558f, 0.01803209f, 
    0.04257740f, 0.00163467f, -0.02298601f, -0.06084039f, 0.01336580f, 0.04245694f, 0.01532701f, 0.03657874f, 
    0.01116698f, -0.01238647f, -0.02889044f, -0.01040438f, -0.00024704f, -0.03058518f, -0.01231425f, -0.04564859f, 
    0.04453352f, 0.01439949f, 0.02256743f, 0.02605744f, -0.04376561f, 0.01531979f, -0.05264373f, -0.05322188f, 
    0.02348387f, -0.01396789f, -0.04088990f, -0.01668883f, -0.00999460f, 0.00399864f, 0.02258466f, -0.05108080f, 
    -0.04324399f, 0.02713729f, -0.05376492f, 0.05284728f, 0.03744403f, 0.03495947f, 0.04061751f, 0.04418277f, 
    0.05243437f, 0.02871875f, -0.04032310f, -0.03658847f, -0.00651292f, -0.03432329f, -0.02688373f, 0.00375993f, 
    0.03150931f, -0.05342185f, -0.00676543f, -0.06532963f, 0.02853780f, -0.00960046f, -0.06467798f, -0.01119197f, 
    -0.04722862f, -0.02020255f, 0.00659502f, 0.01022692f, 0.04099829f, -0.04917661f, -0.03185721f, 0.00881071f, 
    0.01244352f, 0.01187279f, -0.06472293f, 0.00157567f, -0.05446093f, 0.03508721f, 0.02910252f, -0.03767965f, 
    -0.01035284f, -0.05989015f, 0.01383827f, -0.02158384f, -0.06386533f, -0.02400660f, -0.03856575f, 0.03981491f, 
    -0.01554023f, -0.04744584f, -0.03574309f, -0.01437786f, 0.00373820f, 0.00133144f, -0.04894515f, -0.02429162f, 
    -0.05031544f, -0.03627110f, -0.05916654f, -0.05677373f, -0.00815766f, -0.02102556f, 0.04202623f, 0.02331974f, 
    -0.02261971f, -0.02973796f, 0.04280375f, 0.04751742f, -0.02485696f, -0.01025561f, -0.02443379f, 0.05333963f, 
    -0.00955722f, -0.02130817f, -0.06813644f, 0.05471470f, -0.02216945f, 0.00974438f, -0.00199919f, -0.05895473f, 
    -0.04046712f, 0.03473982f, -0.00044672f, -0.03651737f, -0.03554267f, -0.04140429f, -0.00284577f, -0.06418456f, 
    0.04050134f, 0.02611464f, -0.00990263f, -0.05236210f, -0.04417520f, -0.03729556f, 0.03332809f, -0.06427685f, 
    0.03873828f, -0.04244635f, -0.04176422f, -0.00128086f, -0.06400230f, -0.03269766f, -0.03784810f, -0.04578150f, 
    -0.03925639f, -0.04735731f, -0.03820432f, 0.04621435f, -0.00272671f, -0.01345963f, -0.03582387f, 0.00718952f, 
    0.01721724f, 0.00194746f, -0.01023207f, -0.04163334f, -0.05551761f, -0.00946678f, -0.05151074f, -0.02022090f, 
    0.03387185f, -0.04143846f, -0.04795257f, 0.04379502f, 0.04348857f, -0.04924621f, -0.00355320f, 0.00339714f, 
    -0.01230620f, -0.04595972f, 0.00332643f, -0.02593017f, 0.00377150f, 0.02556044f, 0.05885915f, 0.00861827f, 
    0.04198792f, 0.03802809f, 0.03072057f, 0.00596637f, -0.01171173f, 0.00867695f, 0.01957638f, 0.00305767f, 
    -0.05993416f, -0.00004527f, -0.02534576f, 0.00740036f, -0.00494418f, 0.04277093f, 0.03085349f, 0.03268760f, 
    0.05280234f, 0.00911056f, 0.01912348f, -0.03519426f, 0.02649395f, -0.01282154f, 0.03494405f, -0.04587356f, 
    -0.04483606f, 0.04236668f, 0.05078710f, -0.02957268f, 0.00686966f, -0.01973239f, 0.01262506f, -0.02559426f, 
    0.03542575f, -0.05068182f, 0.01647158f, 0.00838786f, -0.03187699f, 0.04011648f, 0.02507503f, 0.04186510f, 
    -0.03158624f, -0.18293111f, 0.06704227f, 0.00082041f, 0.01531673f, 0.05230584f, 0.11543263f, 0.02875443f, 
    -0.00454798f, 0.19718145f, -0.04300973f, -0.02456132f, 0.09746233f, 0.17121185f, -0.00788704f, -0.03021058f, 
    0.01312567f, -0.06188899f, 0.26605672f, -0.01586933f, 0.25530049f, 0.11334515f, 0.04757164f, 0.27971879f, 
    -0.10166891f, 0.11237559f, -0.12180863f, -0.04318288f, 0.16372499f, -0.10522698f, -0.11767518f, -0.03331029f, 
    -0.04358926f, 0.05221590f, 0.21390706f, 0.06849548f, 0.00810168f, 0.09748513f, -0.39904398f, 0.05846115f, 
    0.02383060f, 0.01310453f, 0.09686492f, -0.18778138f, 0.00091750f, 0.17175083f, -0.06843709f, 0.26964179f, 
    0.10406493f, -0.16283481f, 0.08716921f, -0.05789628f, 0.05542450f, -0.10013747f, -0.05276629f, 0.31576505f, 
    -0.08667469f, 0.00052509f, 0.02648705f, -0.05738603f, 0.04668542f, 0.03152340f, 0.06021757f, 0.00123961f, 
    0.03755129f, -0.09726277f, 0.17802250f, -0.03723679f, 0.03668494f, -0.01233209f, -0.08943013f, 0.13205642f, 
    0.15075499f, -0.23287025f, -0.26031876f, -0.15323563f, 0.15959388f, -0.02158489f, -0.14269651f, -0.05346642f, 
    -0.16873996f, 0.06438567f, 0.12194027f, 0.12788384f, -0.07183747f, -0.20034342f, 0.08030940f, -0.10055985f, 
    -0.03170526f, -0.14491753f, -0.00622495f, -0.20941837f, -0.53711909f, -0.14607663f, 0.05652514f, 0.07973894f, 
    -0.11822762f, 0.20053159f, 0.06132084f, 0.27934185f, -0.12890965f, -0.05262726f, 0.00167263f, -0.00215231f, 
    0.10027896f, 0.05065837f, 0.08877710f, 0.06394623f, -0.22438385f, 0.41416895f, 0.04854319f, -0.29894909f, 
    -0.08224545f, -0.08601487f, 0.05640547f, 0.04605729f, -0.10485420f, -0.00940938f, -0.02429217f, -0.02887162f, 
    0.20512013f, 0.08236700f, 0.11725327f, -0.00552479f, 0.09534808f, 0.02275796f, 0.05535265f, 0.17669331f, 
    0.08841422f, 0.13033773f, 0.15951751f, 0.02401259f, 0.06843659f, 0.01293791f, -0.06129114f, -0.26730350f, 
    -0.08600412f, 0.07919990f, 0.12114084f, 0.01743962f, 0.22084078f, -0.01710359f, -0.06835181f, 0.00030463f, 
    -0.07163866f, -0.01650334f, 0.10843085f, 0.12916975f, -0.00986631f, 0.20635076f, -0.00401064f, 0.03400304f, 
    0.03378345f, 0.06112276f, -0.15570320f, 0.06031976f, -0.09304874f, 0.03567654f, 0.07133362f, -0.00761246f, 
    -0.16913101f, -0.07822644f, -0.26572543f, -0.20924410f, 0.22381717f, 0.04677221f, 0.24128719f, 0.14170171f, 
    -0.02225579f, 0.00699886f, -0.11082985f, 0.15256697f, -0.14464110f, 0.07261784f, -0.08159804f, 0.00549240f, 
    -0.04181702f, 0.12385455f, 0.02297588f, -0.00501237f, -0.10449690f, 0.03812521f, -0.05834571f, 0.05606542f, 
    0.03732970f, -0.05444904f, -0.00989376f, -0.17340289f, -0.03469152f, -0.26575333f, -0.22199018f, 0.28523818f, 
    0.17934300f, 0.08836873f, 0.11238693f, -0.22073479f, 0.08671945f, 0.01221807f, 0.05425914f, 0.25816947f, 
    -0.13378842f, 0.08632798f, 0.00568024f, -0.02959562f, 0.09173206f, 0.07158802f, 0.06299080f, 0.24282856f, 
    0.08082297f, -0.10763901f, -0.00728159f, 0.21795799f, 0.11373720f, 0.07240647f, 0.16330661f, -0.02566574f, 
    0.06980406f, -0.12204524f, -0.17947845f, -0.06890199f, -0.01140406f, -0.08444595f, 0.05970380f, -0.02485630f, 
    -0.11521824f, -0.58698320f, -0.19816934f, 0.45117545f, 0.01823080f, 0.04239212f, 0.06796553f, -0.04074251f, 
    0.11344364f, 0.06227849f, -0.23698752f, -0.01846886f, 0.12288747f, 0.11587544f, -0.01889154f, 0.05198482f, 
    0.16050738f, 0.04412795f, -0.15733857f, 0.08738974f, -0.05319756f, -0.26299974f, 0.03660217f, -0.12293927f, 
    -0.07951665f, 0.10376682f, 0.00985014f, 0.05667914f, -0.09411277f, -0.18832760f, -0.24017745f, -0.03042060f, 
    -0.06223672f, 0.05749907f, 0.12897070f, 0.19987766f, -0.10384993f, -0.28455436f, -0.00082181f, 0.22127001f, 
    0.15878341f, -0.11355626f, -0.04469933f, -0.04859078f, 0.07183680f, -0.09270760f, -0.07138094f, 0.03934434f, 
    0.06241820f, 0.10176646f, 0.01677328f, -0.12422328f, -0.01895597f, -0.10858722f, -0.12036859f, 0.02925447f, 
    0.08239066f, -0.10330672f, -0.01644041f, 0.01601158f, 0.09236942f, 0.19809335f, 0.15546443f, 0.01956412f, 
    -0.33264232f, 0.08205703f, -0.08245643f, -0.01593605f, 0.15522149f, -0.07700157f, -0.06628295f, -0.00495235f, 
    -0.15631750f, -0.15993883f, -0.34086403f, 0.11285608f, 0.02411580f, 0.00306547f, 0.07716385f, 0.04927520f, 
    0.01309912f, 0.06240695f, 0.05527306f, -0.22611199f, -0.06333147f, 0.11043295f, 0.05761736f, -0.10721537f, 
    0.00560778f, 0.05876140f, 0.06381424f, -0.11252804f, -0.29402456f, 0.12597074f, 0.04351198f, -0.01122243f, 
    0.21640478f, -0.10395092f, 0.00301762f, 0.02419989f, 0.04139741f, -0.17109442f, -0.17807189f, -0.00417726f, 
    -0.15675400f, -0.13519077f, -0.05627346f, 0.00677526f, 0.18848638f, 0.24796411f, 0.02427586f, -0.11853232f, 
    -0.08510752f, -0.02205665f, -0.01809837f, -0.12218768f, 0.07043497f, -0.14157794f, -0.18258996f, -0.31856236f, 
    0.02483199f, -0.01207081f, 0.08756573f, 0.10565595f, -0.06613529f, 0.03009760f, 0.07383959f, 0.03175991f, 
    0.07230654f, 0.10533338f, 0.10039602f, 0.01714109f, -0.15346968f, 0.08771760f, 0.13314632f, -0.07803901f, 
    0.01758615f, -0.15739068f, 0.08713944f, 0.03529734f, -0.06753432f, 0.09356289f, 0.07184539f, -0.05235836f, 
    -0.01803523f, 0.19125929f, -0.29216135f, 0.15021797f, 0.25189665f, 0.16429350f, 0.17328687f, 0.08532169f, 
    -0.22579435f, -0.07543328f, 0.08700236f, 0.02334746f, 0.04833367f, -0.01447586f, 0.04323778f, 0.02315727f, 
    -0.30400908f, -0.04163024f, -0.11466378f, -0.04731265f, -0.07335582f, -0.06896403f, 0.01991626f, 0.03640418f, 
    0.00206764f, -0.18463154f, 0.02105871f, -0.00044857f, -0.19360356f, -0.12317511f, 0.26921725f, -0.09494183f, 
    -0.07243433f, -0.05200893f, -0.25085807f, -0.07788584f, -0.05740704f, 0.25947964f, 0.44314378f, -0.01103573f, 
    0.10717045f, 0.07847629f, -0.00136473f, 0.06184509f, -0.01606815f, -0.07704920f, 0.09228203f, 0.14956424f, 
    -0.02999009f, 0.08485197f, -0.07712068f, -0.06408444f, 0.10084308f, -0.11155393f, 0.03757742f, -0.06249146f, 
    0.25641778f, -0.12563276f, 0.16036789f, 0.00745068f, -0.02594521f, 0.05706950f, -0.02270728f, -0.08248799f, 
    0.17473677f, -0.04910931f, -0.01610433f, 0.15703614f, 0.11047603f, -0.06543897f, -0.05630786f, -0.08291614f, 
    -0.04735490f, 0.12754403f, -0.22722331f, 0.05632039f, 0.05080068f, -0.03838987f, 0.00404705f, 0.00095547f, 
    -0.18046777f, 0.09090995f, -0.12169755f, 0.49213296f, 0.10964517f, 0.03249240f, 0.22770114f, -0.13106374f, 
    0.03762652f, 0.07373315f, 0.04451070f, -0.47699714f, 0.06960321f, -0.16418321f, 0.09366747f, -0.12155468f, 
    -0.04453384f, -0.00161036f, 0.16940291f, -0.01839027f, 0.15547498f, 0.18161979f, 0.01373891f, 0.21446608f, 
    0.04308610f, -0.06039902f, 0.13413593f, 0.10827791f, -0.20993528f, 0.22438212f, 0.07430072f, -0.00475068f, 
    0.16245267f, 0.11481178f, -0.29575393f, 0.04077762f, -0.07725812f, -0.07085672f, 0.04867262f, -0.07062986f, 
    0.09638914f, -0.04341400f, 0.09027530f, 0.17063639f, -0.10843731f, -0.18661803f, 0.02620361f, 0.04351896f, 
    -0.10459213f, 0.10921958f, -0.16133666f, 0.05925312f, -0.08749695f, -0.05257163f, 0.01229082f, 0.15580006f, 
    0.23147558f, -0.01459280f, -0.01280384f, -0.09090648f, -0.10714179f, 0.02860771f, 0.00771493f, 0.11094325f, 
    0.04907256f, 0.20999280f, 0.46773940f, 0.20037271f, 0.02432359f, 0.12136827f, -0.09649529f, 0.04966584f, 
    0.05937947f, 0.06333611f, -0.00077987f, 0.33929831f, 0.11722336f, -0.07529359f, 0.05326786f, 0.12051553f, 
    -0.00153858f, 0.03917158f, 0.06443083f, -0.18290718f, -0.33210087f, -0.19861552f, -0.15778533f, 0.04369849f, 
    0.08955110f, -0.07932556f, -0.02419849f, -0.15146841f, -0.16808373f, -0.15101850f, -0.23349862f, -0.05382120f, 
    -0.12130421f, 0.05702401f, 0.00754284f, -0.11039755f, -0.01823654f, 0.35035038f, 0.44957444f, 0.04858043f, 
    0.05291878f, 0.05326192f, 0.08400799f, 0.07274844f, -0.05195564f, 0.06404931f, 0.19531453f, 0.05214765f, 
    0.06928743f, -0.10910885f, -0.12487850f, 0.03937860f, 0.06658251f, 0.07797769f, -0.01698372f, -0.18885481f, 
    -0.21713391f, -0.24185060f, 0.09384876f, -0.03774437f, 0.09435166f, -0.25978148f, -0.06303289f, -0.13402715f, 
    0.01165668f, -0.06263943f, -0.05113785f, 0.01034934f, -0.04242643f, -0.01546672f, -0.03092184f, 0.00196506f, 
    -0.00466582f, 0.02226827f, -0.04761783f, -0.02859483f, -0.01314333f, -0.06422375f, 0.02338096f, 0.01571074f, 
    0.01648924f, 0.03932599f, -0.05061951f, -0.05107050f, -0.04303432f, -0.05127355f, 0.01513898f, 0.04765619f, 
    -0.04251659f, 0.03397423f, -0.05209956f, -0.02327240f, -0.00461016f, 0.00118861f, 0.04024296f, 0.02384357f, 
    0.02115456f, -0.01226086f, 0.02874685f, -0.02359657f, -0.00419298f, -0.04696638f, -0.01568103f, 0.00668192f, 
    0.04784459f, -0.03567104f, -0.02991114f, -0.04548043f, 0.05323962f, 0.05178764f, -0.02196756f, -0.03456541f, 
    -0.01522449f, 0.02295915f, -0.00024369f, -0.04765406f, -0.00271600f, 0.00114409f, -0.03689103f, -0.03667617f, 
    -0.06221445f, -0.01889708f, 0.02707143f, -0.04531517f, 0.00597263f, 0.01775846f, -0.00364275f, 0.00066904f, 
    -0.00200845f, 0.04241939f, 0.02067905f, -0.00033402f, -0.00617523f, -0.05431462f, 0.04787767f, -0.02971326f, 
    0.02910927f, 0.02405106f, -0.01520038f, -0.01732248f, -0.02253551f, 0.03832343f, -0.05783559f, -0.02476844f, 
    0.00063570f, 0.04710394f, 0.01444316f, 0.02687801f, 0.02853252f, -0.01508327f, -0.06693155f, 0.04523286f, 
    0.04939449f, -0.04509588f, -0.02913022f, 0.02857677f, -0.00947410f, -0.02922465f, 0.04544068f, -0.00346967f, 
    -0.04577607f, -0.05002208f, 0.00852339f, 0.03418226f, 0.05072266f, -0.06353230f, -0.02052144f, 0.02343903f, 
    -0.02785068f, -0.06189886f, 0.05198811f, 0.03490500f, 0.00733768f, -0.01714673f, 0.04992086f, -0.04288486f, 
    0.04683992f, -0.02092099f, 0.00487008f, -0.05366844f, -0.05465370f, -0.00264626f, 0.03038132f, -0.05393377f, 
    0.05515180f, -0.02212035f, -0.06166868f, -0.03291516f, -0.03955759f, 0.03457928f, 0.04061629f, 0.03525257f, 
    0.01311865f, -0.01808453f, -0.06514157f, -0.06233867f, -0.03953037f, 0.05208915f, 0.01957379f, -0.01686194f, 
    0.02546860f, -0.05933229f, -0.00664020f, -0.03110076f, 0.00297464f, 0.03351218f, -0.03034499f, 0.01737131f, 
    -0.03378000f, 0.03210443f, 0.00916863f, -0.04457678f, 0.03952052f, -0.02287395f, -0.02008180f, -0.02763347f, 
    0.03635035f, -0.00934629f, 0.03506298f, 0.01479421f, 0.05075227f, -0.01685672f, 0.03774114f, -0.05207105f, 
    -0.00993360f, 0.04659224f, -0.02599683f, -0.01557237f, -0.03451424f, -0.06527957f, 0.00787341f, -0.06314307f, 
    -0.00732381f, 0.03353162f, -0.00675030f, 0.04224955f, -0.05883196f, -0.02631124f, -0.04938143f, -0.02638179f, 
    -0.01216595f, -0.03698520f, 0.02150386f, -0.06287617f, 0.02171041f, -0.05236623f, -0.04943226f, -0.06024927f, 
    0.00147790f, -0.02517154f, -0.00352000f, -0.00302574f, 0.01883917f, -0.02967661f, 0.04867063f, -0.04323261f, 
    -0.00072834f, -0.02325131f, 0.01810278f, -0.04454030f, 0.03233698f, -0.02640082f, -0.06254289f, -0.03464397f, 
    -0.01170747f, 0.00471983f, -0.05987851f, -0.05665919f, 0.04170539f, -0.05664031f, 0.04191266f, 0.04526278f, 
    0.02626014f, -0.05625256f, 0.00569508f, 0.04711295f, 0.01805420f, -0.06155316f, -0.05192451f, -0.01938758f, 
    -0.01254364f, -0.02637954f, -0.04632858f, 0.00159029f, -0.02904844f, 0.03545324f, 0.04861854f, -0.04852983f, 
    -0.05556962f, 0.02924298f, 0.02373712f, 0.02913085f, 0.05761048f, -0.03617676f, 0.00374775f, -0.00526077f, 
    0.02038537f, -0.02660065f, -0.02331859f, 0.00550386f, -0.00302444f, 0.03532596f, 0.00724541f, -0.00635720f, 
    -0.02113072f, 0.04204535f, 0.00795574f, 0.04116267f, -0.00471481f, -0.04527576f, -0.05084531f, 0.03283338f, 
    -0.01739496f, -0.00059390f, -0.06579316f, 0.00219836f, 0.02196695f, -0.05878530f, 0.03667518f, 0.00216421f, 
    0.04840991f, -0.03736605f, 0.02607317f, -0.04790614f, -0.03369324f, 0.03658785f, 0.02053258f, 0.03071279f, 
    -0.02266307f, 0.05835129f, -0.02430000f, -0.02302825f, 0.05316534f, -0.01349006f, 0.00836188f, 0.02369842f, 
    -0.04984175f, 0.02918411f, -0.02512429f, -0.06441534f, 0.03846625f, -0.06638655f, -0.04218996f, 0.02186521f, 
    0.02300256f, -0.03744621f, 0.00567802f, 0.01249185f, 0.05131227f, -0.05785652f, 0.04976419f, -0.05655349f, 
    -0.06502623f, -0.04243861f, 0.09931713f, 0.23062186f, -0.22317794f, -0.03699221f, -0.01287238f, 0.09464548f, 
    0.11479037f, 0.23984145f, -0.13832815f, -0.04900353f, -0.20330428f, 0.01067878f, -0.12858266f, -0.01719943f, 
    0.27712303f, 0.00965445f, 0.37469709f, 0.08646432f, -0.04475187f, -0.12950084f, -0.22817521f, -0.17814654f, 
    0.04349132f, 0.15947361f, -0.02744638f, 0.17932899f, -0.03013027f, 0.07512886f, -0.21631035f, 0.00891719f, 
    -0.18051766f, -0.07454618f, -0.07354043f, -0.01604014f, 0.03561771f, 0.12217838f, 0.10671382f, 0.01658591f, 
    -0.09004162f, 0.04150623f, 0.12569198f, 0.06588026f, 0.07793791f, -0.05982808f, 0.05559982f, 0.11362568f, 
    0.06600436f, -0.19307983f, 0.02963644f, -0.10543160f, 0.11726640f, -0.14816129f, -0.08728531f, 0.05221132f, 
    -0.04291152f, -0.04521318f, -0.12826879f, 0.02173053f, 0.10799063f, 0.07476420f, 0.02249284f, -0.08232610f, 
    0.17383602f, -0.17893803f, -0.06021600f, -0.04989005f, 0.11116783f, 0.03682154f, 0.08017967f, -0.00106066f, 
    0.08725829f, 0.05180577f, 0.10182361f, -0.20299461f, -0.02619298f, -0.20528109f, -0.04736340f, 0.12713139f, 
    0.04460734f, 0.07200062f, 0.00601568f, 0.31204700f, -0.02656746f, -0.05838170f, -0.08236419f, 0.08350078f, 
    -0.12863314f, -0.26295981f, 0.05821715f, -0.03779279f, 0.15186799f, 0.05686282f, 0.01317508f, 0.21550161f, 
    0.07811100f, 0.00997920f, -0.14397383f, 0.22061008f, -0.05451218f, 0.30487281f, -0.04083194f, -0.11274658f, 
    0.00538901f, 0.08603365f, -0.02599269f, 0.16008613f, -0.01724038f, -0.23709613f, -0.11707680f, 0.00128399f, 
    -0.03419701f, -0.08734834f, 0.15631531f, 0.06904846f, -0.11622561f, -0.08447838f, -0.14228527f, 0.14849426f, 
    0.13999854f, -0.01022468f, 0.05150512f, -0.06261791f, 0.01603484f, -0.09417672f, 0.11293669f, 0.13629340f, 
    0.27610189f, -0.13321978f, 0.06399508f, -0.07324684f, -0.07054766f, 0.03659784f, 0.08963633f, -0.04404267f, 
    -0.11708942f, 0.22667959f, 0.13746355f, -0.03810214f, 0.16501489f, -0.06174012f, -0.21548279f, -0.11051075f, 
    0.19159681f, 0.01123337f, -0.07628598f, 0.13923335f, 0.10822315f, -0.12412165f, -0.01402699f, 0.03153558f, 
    -0.06638193f, -0.22100866f, -0.10739302f, 0.18035889f, -0.07325081f, 0.10894815f, -0.07648086f, -0.05679544f, 
    -0.17721356f, 0.06092942f, 0.08511397f, -0.13688467f, -0.11997090f, 0.05032818f, 0.18826276f, 0.12307024f, 
    -0.08210736f, -0.01919693f, 0.04944496f, -0.26150498f, -0.40104470f, 0.02628797f, -0.09316774f, 0.04181419f, 
    0.04530480f, -0.04302003f, -0.08624789f, 0.18984647f, -0.50809121f, 0.07630181f, 0.01148746f, -0.01576572f, 
    0.17825031f, 0.02451725f, -0.04761838f, 0.00024804f, 0.16864888f, 0.24550724f, 0.10036848f, 0.00156551f, 
    0.05080219f, 0.02225969f, -0.15169026f, -0.08464099f, 0.08019776f, 0.02405189f, 0.12188245f, -0.12890658f, 
    -0.12046678f, -0.02199655f, -0.05624170f, 0.09476450f, 0.12343775f, 0.00071461f, 0.01380741f, 0.08401786f, 
    0.09073284f, 0.01805538f, -0.06062514f, -0.00008381f, -0.05578818f, 0.07836866f, 0.10815506f, 0.03223900f, 
    -0.14903559f, 0.13449261f, 0.03185922f, -0.09561086f, -0.04056927f, -0.10317423f, 0.05104202f, -0.02151493f, 
    0.15329115f, -0.00044267f, 0.00961198f, -0.02371776f, 0.06335188f, 0.11729263f, -0.00170402f, 0.04641647f, 
    -0.02924308f, 0.05008636f, -0.19148457f, -0.19005091f, 0.08884453f, 0.15230897f, 0.12992406f, -0.07823965f, 
    -0.03265294f, 0.03127567f, -0.11496548f, -0.03166609f, -0.06564915f, 0.07531931f, -0.05274479f, -0.08716224f, 
    -0.00488691f, -0.01691990f, -0.11727730f, -0.00760824f, -0.16854356f, -0.24148819f, 0.12922266f, 0.05144121f, 
    0.18400042f, -0.01979003f, -0.01180519f, -0.16374043f, -0.05845609f, -0.57608670f, -0.17536016f, 0.33494145f, 
    0.14768356f, -0.01734782f, 0.01542305f, 0.05014905f, -0.01478702f, 0.09412634f, -0.12468887f, 0.05588449f, 
    0.08271256f, -0.16456717f, 0.04166540f, -0.05667184f, 0.01997784f, -0.06177596f, 0.12794094f, -0.01473815f, 
    -0.10058862f, 0.10238538f, 0.15268986f, 0.05549874f, -0.05097441f, -0.20194376f, -0.17519020f, 0.03376568f, 
    0.03232468f, -0.00809844f, 0.04872239f, -0.00468361f, 0.00270728f, -0.03282090f, -0.00748504f, -0.00556208f, 
    -0.00172310f, 0.00626174f, 0.02660144f, -0.06231941f, -0.06053292f, 0.01729996f, -0.03191041f, -0.02110520f, 
    0.01615683f, 0.03978648f, 0.00350964f, -0.05214428f, -0.04599890f, 0.03972785f, -0.02096038f, -0.05389800f, 
    -0.04318560f, -0.03012099f, -0.00448366f, 0.04532813f, 0.04724413f, 0.04953141f, 0.02333267f, -0.00192876f, 
    0.02380485f, -0.00866405f, -0.05115649f, 0.00890789f, 0.00303523f, 0.00431427f, -0.06222101f, -0.03264745f, 
    0.03547880f, -0.06009299f, -0.00189849f, 0.02213976f, -0.07261480f, -0.05908268f, -0.04066996f, 0.03499816f, 
    0.03160260f, -0.04445136f, 0.06215007f, -0.01537994f, 0.03135917f, -0.00422811f, -0.05614435f, 0.03064461f, 
    0.04693969f, -0.00078948f, 0.00070954f, -0.02437367f, -0.07327126f, 0.03849934f, -0.01564283f, -0.06212936f, 
    -0.01257896f, -0.04869597f, -0.01532698f, -0.02780465f, 0.02879136f, -0.01215384f, -0.03072092f, 0.03318314f, 
    -0.00448704f, -0.00913105f, -0.02660943f, -0.03741374f, 0.01300020f, -0.03709720f, -0.07237111f, -0.07198057f, 
    -0.03014643f, -0.05479422f, -0.02290045f, -0.04027423f, 0.01491386f, 0.04818227f, -0.00260109f, 0.04290117f, 
    -0.03937519f, -0.00389866f, 0.02445998f, -0.01066260f, 0.03513838f, 0.02337941f, -0.04790544f, -0.00348122f, 
    -0.04756381f, 0.02560045f, -0.04296319f, 0.05375767f, 0.02688057f, 0.04516962f, -0.02533811f, 0.02823948f, 
    -0.02488563f, -0.00608990f, 0.04314204f, -0.03931867f, -0.02061771f, 0.05515011f, -0.05477551f, -0.02877656f, 
    0.00047232f, 0.03990591f, 0.04236744f, -0.04160794f, 0.04660290f, -0.06367671f, -0.03698431f, -0.04080592f, 
    -0.03289152f, 0.01053189f, 0.04311160f, 0.02193698f, 0.03331558f, 0.00474195f, -0.02925942f, 0.03904980f, 
    0.04550463f, -0.04523179f, 0.02181250f, -0.04675684f, 0.02304189f, 0.00259840f, -0.01538924f, -0.03248486f, 
    0.00520384f, -0.05787278f, 0.01678354f, 0.04284937f, 0.00695553f, 0.03374732f, -0.04460603f, -0.05183416f, 
    0.00543407f, 0.01513490f, -0.03649075f, -0.06415655f, -0.02751738f, 0.04326389f, 0.03700034f, -0.00391290f, 
    -0.00615591f, -0.00722904f, -0.04445015f, -0.03170416f, -0.03337828f, -0.05567183f, 0.02867347f, 0.02914056f, 
    0.04692946f, -0.00225180f, 0.02307019f, -0.04920092f, 0.02315977f, -0.05339228f, 0.03220207f, -0.02362075f, 
    0.05018406f, -0.05892684f, -0.01319799f, -0.04376384f, -0.01748202f, -0.06542781f, -0.00952875f, -0.05460085f, 
    -0.00837729f, 0.03510400f, 0.00902171f, -0.02476894f, 0.04747519f, -0.01635807f, -0.01400415f, -0.01923034f, 
    -0.02592984f, 0.05191372f, 0.01576980f, -0.00370100f, -0.03033286f, -0.03273862f, -0.00036047f, 0.05725363f, 
    -0.00430674f, -0.05328524f, 0.03413822f, 0.01795309f, 0.04540578f, -0.03771488f, -0.05933939f, 0.02811890f, 
    -0.05590782f, -0.04862224f, -0.02821948f, -0.02507049f, -0.00963205f, -0.00805948f, 0.01356411f, -0.03098469f, 
    0.01539536f, 0.02671420f, -0.05077839f, 0.00178235f, -0.06489528f, -0.04041125f, 0.02081083f, -0.04717245f, 
    -0.06057884f, 0.01908432f, -0.02009118f, -0.04489044f, 0.02231205f, -0.02654009f, 0.01654188f, 0.04670085f, 
    -0.00990060f, 0.00404339f, 0.02451479f, -0.00613373f, 0.04803493f, 0.05394261f, 0.04801406f, -0.06763002f, 
    0.00257469f, 0.05277979f, -0.05277738f, 0.01940571f, -0.03139716f, 0.04229135f, -0.04809180f, 0.02535898f, 
    -0.01556302f, 0.04872188f, -0.05322256f, 0.03874271f, -0.04723769f, -0.05038136f, 0.00606910f, 0.02842481f, 
    -0.01544205f, -0.03204624f, -0.00342705f, -0.04662329f, 0.03483380f, -0.02626595f, 0.02458804f, -0.02545330f, 
    -0.01945733f, -0.02431323f, -0.01206174f, -0.02511422f, -0.01422961f, -0.05510934f, -0.06596874f, -0.05228026f, 
    -0.01899340f, -0.00069268f, -0.05507122f, -0.02948388f, 0.02823461f, 0.01812386f, 0.00731491f, 0.03769518f, 
    -0.04213206f, -0.01447059f, -0.02811617f, -0.02848578f, 0.03230343f, 0.03493346f, 0.01565107f, 0.00612651f, 
    -0.05673438f, 0.04805410f, 0.00313352f, 0.01125165f, -0.00849536f, -0.00273948f, -0.06119436f, -0.05275123f, 
    -0.03814534f, 0.09369682f, 0.06406689f, -0.06480809f, 0.07366569f, -0.05899933f, -0.03159961f, -0.07825886f, 
    -0.14072129f, 0.05611843f, -0.10197787f, -0.35016820f, 0.07595708f, 0.08478976f, 0.09761384f, 0.09356681f, 
    -0.08296415f, 0.00361830f, -0.19762740f, 0.02723048f, -0.07099823f, -0.06633098f, 0.08086614f, -0.09365404f, 
    -0.03533771f, 0.04552012f, 0.09840231f, -0.00430873f, -0.24715078f, 0.13844860f, -0.14801459f, 0.02617199f, 
    -0.08424012f, 0.03307262f, -0.06689245f, 0.08774285f, -0.44907063f, 0.25089565f, 0.17686944f, 0.07972809f, 
    -0.08228670f, 0.01476658f, 0.06341951f, 0.09774414f, -0.01186166f, -0.01424712f, 0.32979119f, -0.05935265f, 
    0.14268684f, -0.10432961f, -0.07097783f, -0.03852650f, 0.00594974f, -0.04570656f, -0.24918896f, -0.07166311f, 
    -0.12261338f, -0.13241456f, 0.00078903f, 0.05050103f, -0.03136931f, -0.08801930f, 0.02367458f, -0.23626044f, 
    0.09288133f, 0.11616088f, 0.11591031f, 0.10605834f, 0.14896092f, -0.12905926f, 0.11917756f, -0.08029614f, 
    -0.04169700f, -0.26724243f, 0.14482531f, -0.00244541f, 0.07282753f, -0.07746513f, -0.04277567f, -0.22646359f, 
    -0.06752268f, 0.43495047f, -0.00265264f, -0.15125856f, 0.02821884f, 0.17684822f, 0.23972717f, -0.15876460f, 
    -0.16905788f, 0.05074240f, 0.12658742f, -0.22232892f, 0.23328680f, 0.15392359f, 0.05867727f, 0.07914530f, 
    -0.09957077f, 0.08364045f, 0.03879135f, 0.02385843f, -0.24691831f, -0.13761546f, 0.04316104f, 0.05727172f, 
    0.11511913f, 0.08909633f, 0.18696500f, 0.09568673f, 0.30728677f, -0.13180728f, 0.22507183f, -0.00632599f, 
    -0.13453479f, 0.05481489f, 0.05518761f, -0.06300148f, -0.03777293f, 0.07982626f, -0.09769996f, -0.11035183f, 
    0.13607617f, 0.00535434f, -0.11045460f, 0.04520608f, 0.00854456f, -0.08332798f, -0.04881697f, -0.20209330f, 
    -0.01605901f, -0.03757257f, -0.07875479f, 0.06154563f, 0.02912113f, 0.07485095f, -0.10605429f, -0.22486740f, 
    0.20240189f, 0.20102167f, 0.07257023f, -0.18838300f, 0.00427528f, -0.08093074f, -0.11520550f, -0.00975073f, 
    0.10286006f, 0.24083373f, 0.02822564f, 0.01068846f, -0.03348576f, 0.03650941f, -0.04460845f, 0.05405837f, 
    -0.03991671f, 0.24315862f, -0.03446290f, 0.03153855f, -0.23092960f, -0.25663632f, 0.05395346f, 0.13766055f, 
    0.09278318f, -0.03421043f, 0.01618995f, 0.09938137f, 0.07564832f, 0.08539031f, 0.07073821f, -0.03986033f, 
    -0.11854905f, 0.21464305f, 0.10856799f, -0.18619205f, -0.30356580f, -0.08684759f, -0.24099593f, 0.06604769f, 
    0.13501601f, 0.12577328f, 0.01417908f, -0.01553309f, 0.66324949f, 0.18293750f, -0.08434959f, 0.06997133f, 
    0.04591556f, 0.11608732f, 0.03545359f, 0.09803658f, 0.11004573f, 0.14770959f, 0.16640095f, -0.09944247f, 
    -0.04698828f, 0.04167659f, 0.09401073f, 0.02118613f, 0.14639786f, 0.11461445f, 0.10519058f, -0.01112751f, 
    0.06219565f, 0.04213218f, -0.03535455f, -0.03226724f, 0.21003918f, -0.05470278f, 0.11243235f, -0.10685888f, 
    -0.16644694f, 0.10277130f, -0.20808348f, -0.08449753f, -0.01984403f, -0.10750648f, 0.06262840f, -0.07424687f, 
    -0.20871201f, -0.03853879f, -0.25326872f, -0.04498584f, 0.08480265f, 0.17067043f, 0.18364716f, 0.02071705f, 
    -0.02392902f, -0.01562979f, 0.12251189f, 0.11357629f, 0.09423456f, 0.18128790f, 0.10504174f, 0.00445287f, 
    0.07490522f, 0.10978307f, 0.29343113f, 0.29791471f, 0.17063005f, 0.02544583f, -0.03735054f, 0.05044211f, 
    -0.18061884f, -0.01956749f, 0.04945852f, 0.04020790f, -0.11418560f, 0.00306783f, -0.12846972f, 0.03870608f, 
    -0.17984544f, 0.18733279f, -0.08542007f, -0.01425590f, 0.03407316f, -0.13277574f, 0.19589241f, -0.29937381f, 
    -0.13615490f, -0.03578325f, 0.06997221f, 0.11285846f, 0.04866016f, -0.20088468f, -0.16463803f, 0.04921115f, 
    0.08798768f, 0.07966228f, -0.05899187f, 0.10561652f, 0.06739365f, 0.05247036f, 0.03379772f, -0.25366908f, 
    -0.11939496f, 0.00642560f, 0.05661049f, -0.02971926f, -0.08842510f, 0.07414070f, 0.03056206f, -0.24957982f, 
    0.14212395f, 0.06208390f, -0.02641590f, -0.13526157f, -0.03423431f, -0.07433312f, -0.16153654f, 0.08134167f, 
    -0.04469256f, 0.00142430f, -0.01260260f, -0.01097965f, 0.00048927f, 0.00910556f, -0.05403670f, -0.05505956f, 
    -0.03878470f, 0.05152037f, -0.05297110f, -0.03185606f, -0.06306342f, 0.04343791f, -0.01425169f, -0.02351454f, 
    -0.02901939f, 0.01600553f, 0.05031094f, -0.03380420f, -0.03202679f, 0.03454462f, -0.02749680f, -0.05408332f, 
    -0.06161123f, -0.02710744f, 0.01389523f, 0.01189730f, -0.06248695f, -0.02368648f, 0.00763782f, -0.04849634f, 
    -0.02832865f, -0.02098791f, 0.02968675f, -0.02913261f, -0.01294342f, -0.04704001f, -0.05417458f, -0.04136108f, 
    0.01169903f, 0.01740900f, 0.01541542f, 0.00483085f, 0.04541603f, 0.04004824f, -0.01475763f, -0.04377200f, 
    -0.04951424f, 0.01712259f, -0.04979882f, 0.00150538f, -0.03731080f, 0.05190904f, -0.03968131f, 0.01223028f, 
    -0.03585349f, 0.00924315f, 0.02729955f, -0.01911871f, 0.04165948f, 0.02201209f, -0.04039121f, -0.00625105f, 
    0.01467305f, -0.04371253f, -0.01654657f, 0.05170662f, -0.03391430f, -0.03587100f, -0.04803273f, 0.00797308f, 
    -0.00378630f, -0.04302162f, 0.03652342f, -0.05733647f, 0.04463013f, 0.01425370f, -0.06035936f, 0.00544140f, 
    0.00012470f, 0.01222924f, 0.00240826f, 0.01704453f, -0.00965714f, 0.00362656f, -0.05620370f, -0.00444191f, 
    -0.03759868f, -0.02587151f, 0.01225866f, -0.00804630f, -0.00851306f, 0.01055418f, 0.00877082f, -0.00361748f, 
    -0.04014377f, -0.04825924f, -0.01139326f, 0.02151262f, -0.06337325f, 0.03274856f, -0.01798061f, 0.00370920f, 
    0.03382466f, 0.03993873f, 0.04061121f, -0.05003591f, 0.02240241f, 0.01697001f, -0.02029368f, -0.00981538f, 
    -0.01010378f, -0.03650126f, 0.01763062f, -0.04660615f, -0.03944017f, -0.04302920f, 0.03346119f, 0.01394659f, 
    -0.05719217f, -0.02228210f, -0.04803111f, 0.04746632f, 0.00836090f, -0.00540118f, 0.01669083f, -0.01933995f, 
    -0.01787201f, -0.06171504f, 0.03260955f, 0.04252331f, 0.02044673f, -0.01552090f, 0.00625111f, 0.04795600f, 
    0.05296594f, -0.05256313f, 0.04134763f, -0.04963266f, -0.01011709f, 0.03387376f, -0.01880101f, -0.03757850f, 
    0.04609831f, -0.05359453f, -0.05623954f, -0.06353609f, 0.02713400f, -0.06061183f, 0.02322264f, 0.00415940f, 
    0.04009979f, 0.00809058f, -0.05715355f, -0.00601823f, 0.03037096f, -0.01524362f, 0.03576491f, -0.00253306f, 
    0.02097395f, 0.05570137f, 0.01844884f, 0.05159738f, 0.03262966f, -0.03733047f, 0.02455908f, -0.04136366f, 
    -0.02120065f, 0.01996060f, 0.00075196f, -0.05461913f, -0.02532483f, -0.03697523f, -0.02864762f, -0.00394752f, 
    0.01570008f, -0.03564044f, 0.03746188f, -0.05166951f, 0.00528414f, -0.03635469f, -0.06012523f, -0.05783171f, 
    0.00901886f, -0.04614430f, -0.05010657f, 0.05137791f, 0.00917484f, -0.02442579f, -0.01557194f, 0.00158565f, 
    0.01520814f, 0.01524484f, -0.00502829f, -0.04267246f, -0.02684310f, -0.03834731f, -0.00650724f, -0.03542961f, 
    0.02301094f, -0.04305781f, -0.00059020f, 0.04130789f, 0.01425888f, 0.04942612f, -0.02490989f, 0.04789564f, 
    -0.00105757f, 0.01979395f, -0.01498384f, -0.01044307f, -0.05454287f, -0.03473825f, 0.03170321f, 0.00581937f, 
    0.05303654f, -0.01410192f, -0.00485737f, -0.00288514f, 0.00681431f, -0.02855627f, -0.05838229f, -0.00661330f, 
    -0.03077223f, -0.05054013f, -0.01132750f, -0.03192754f, -0.00511980f, 0.02810879f, -0.01493922f, -0.03580955f, 
    -0.05139420f, -0.03026347f, -0.04382226f, -0.04588342f, -0.05154604f, 0.05062074f, -0.05103194f, 0.04617355f, 
    -0.04210187f, -0.04755858f, 0.02176202f, 0.00128767f, -0.03355320f, 0.04523448f, -0.03587546f, 0.02224486f, 
    0.00831320f, -0.05288254f, -0.00483888f, 0.01910868f, 0.04930529f, 0.00624538f, 0.02439814f, 0.04177556f, 
    0.03100358f, -0.04521154f, -0.02648787f, -0.03708865f, 0.01210481f, -0.02067433f, -0.03226854f, -0.05453039f, 
    -0.03131443f, 0.00585771f, 0.01426775f, 0.00386615f, -0.05832406f, 0.04218059f, -0.04986130f, 0.02083577f, 
    0.04777250f, -0.04530637f, 0.00234167f, -0.02506682f, -0.01717270f, -0.04572166f, 0.05177693f, -0.05889243f, 
    0.03665394f, -0.01544337f, 0.02830862f, 0.02426035f, 0.03965202f, -0.03518135f, -0.01054545f, -0.05326656f, 
    0.09304245f, -0.04619060f, 0.09273928f, -0.07606151f, -0.19242214f, 0.02666958f, 0.08483814f, -0.12383080f, 
    -0.09755553f, -0.16229226f, -0.10097817f, -0.06509001f, -0.00892085f, -0.11792017f, 0.04252029f, 0.10254174f, 
    0.07396351f, -0.09648172f, 0.01650880f, 0.08504765f, 0.01650851f, 0.02005234f, 0.06610321f, 0.02950722f, 
    -0.05476010f, -0.06779278f, 0.05815235f, 0.18923298f, -0.12797834f, 0.06250349f, -0.00632968f, 0.09364466f, 
    0.03056636f, 0.01866931f, -0.07901428f, -0.06462914f, 0.20952262f, 0.10807759f, -0.00846160f, 0.13861425f, 
    0.05820068f, 0.13267003f, -0.20064236f, 0.15817659f, -0.10823167f, -0.00796895f, -0.02093097f, 0.18481088f, 
    -0.03019357f, -0.06535443f, -0.10877928f, 0.14480811f, 0.02068168f, -0.08493462f, -0.16080441f, -0.03532605f, 
    0.04844616f, -0.04637012f, 0.07798291f, 0.08106363f, -0.03041694f, 0.02774801f, -0.03820608f, 0.14185593f, 
    -0.02348581f, 0.03239742f, 0.21857917f, -0.08124619f, 0.14923327f, -0.12647535f, -0.03158704f, 0.04494017f, 
    0.08381795f, -0.00544789f, 0.20890073f, -0.18881407f, -0.08916622f, 0.06424893f, -0.00695010f, 0.06222464f, 
    0.07050593f, 0.37937102f, 0.10813683f, 0.07739430f, -0.17917551f, 0.08755416f, 0.14191467f, -0.27959391f, 
    0.05439233f, -0.29273352f, -0.18439524f, -0.15528277f, 0.21588778f, 0.19194916f, 0.00429137f, -0.06383739f, 
    -0.03035565f, 0.11794081f, 0.13353942f, 0.39882004f, 0.19660029f, -0.27757666f, -0.05785478f, 0.23888697f, 
    0.11972795f, -0.28390580f, 0.38316572f, 0.22673115f, 0.16613090f, -0.15162264f, -0.14540030f, 0.07591402f, 
    -0.21155572f, -0.06969255f, -0.12906106f, -0.01512300f, -0.10284273f, -0.11182415f, -0.01274735f, 0.17069979f, 
    -0.07172397f, -0.05236439f, 0.05953158f, 0.01460077f, 0.00567288f, 0.01208617f, -0.03586580f, -0.13462868f, 
    -0.05057410f, 0.13585353f, 0.13585159f, -0.00265603f, 0.01368692f, -0.08463161f, -0.00461063f, -0.00392712f, 
    -0.12439603f, 0.07727052f, -0.11472607f, -0.08947901f, 0.14648420f, 0.00751531f, -0.00033578f, -0.04272173f, 
    0.10562933f, 0.01264159f, -0.09524229f, -0.04779261f, -0.07123743f, 0.05692064f, 0.13793541f, 0.01574719f, 
    -0.21735160f, 0.13885193f, 0.17105737f, -0.07781555f, 0.07923256f, -0.16517988f, -0.09776183f, -0.05574385f, 
    -0.05751725f, -0.09802112f, 0.23137310f, 0.20646021f, 0.25867242f, -0.16464688f, -0.08533481f, -0.19570608f, 
    -0.08781890f, -0.00051012f, 0.15269662f, 0.04869314f, 0.06165513f, -0.33554298f, -0.00791156f, 0.08968940f, 
    -0.03736462f, 0.09438125f, -0.04764562f, 0.15638791f, 0.21381967f, -0.07839546f, -0.18797551f, 0.09015074f, 
    -0.01029632f, -0.13188066f, -0.02289748f, 0.24626127f, -0.13369937f, 0.26346809f, 0.26049519f, 0.38632452f, 
    -0.03359377f, 0.07821087f, -0.03240806f, -0.04190740f, -0.04245485f, -0.04145095f, 0.00019634f, -0.12390748f, 
    -0.00306637f, -0.01975304f, 0.15016358f, 0.04679446f, -0.14395192f, -0.05359539f, -0.02112924f, -0.14926112f, 
    -0.03305756f, 0.08775029f, 0.19321994f, -0.05221209f, 0.04057497f, -0.00915681f, -0.09867544f, 0.08120646f, 
    0.21517938f, -0.13379206f, -0.21031296f, 0.16328415f, 0.05546940f, 0.03117830f, -0.05196011f, -0.14739548f, 
    -0.07830690f, -0.08514025f, -0.10991906f, 0.28909573f, 0.00270275f, 0.08862317f, 0.01028463f, 0.07072698f, 
    0.10161128f, 0.07217017f, 0.18257993f, 0.00939066f, -0.10923500f, 0.02060396f, 0.02309379f, -0.00592123f, 
    0.33666581f, -0.04996414f, 0.15408562f, 0.18236504f, -0.07115699f, -0.20445915f, -0.13682668f, 0.07456359f, 
    -0.11738967f, -0.14106607f, 0.03719393f, -0.09150719f, 0.26673672f, 0.15967505f, -0.30698687f, -0.19130580f, 
    -0.04795139f, -0.20862092f, -0.08859325f, 0.03663095f, 0.06383424f, -0.14201504f, 0.04002482f, 0.18708366f, 
    -0.06546886f, -0.08717793f, 0.01920405f, -0.06863934f, -0.04042574f, 0.02485389f, -0.01457054f, -0.00695841f, 
    -0.02354492f, 0.12567635f, -0.01143932f, 0.13946758f, -0.06090513f, -0.09531534f, -0.07967984f, 0.10514013f, 
    0.01498403f, -0.11976372f, -0.04362675f, -0.06522884f, -0.10552077f, -0.05620895f, 0.03823145f, -0.03536749f, 
    -0.00884131f, 0.01758194f, 0.01585430f, -0.00695275f, -0.01381367f, -0.03519182f, -0.03809701f, -0.02078413f, 
    -0.06092400f, -0.04693902f, 0.02735031f, -0.06059748f, 0.04982368f, -0.02732232f, -0.04591783f, -0.05706704f, 
    -0.00632507f, 0.04709543f, -0.03595770f, -0.04811782f, -0.01127229f, -0.03889504f, -0.05543873f, 0.00958245f, 
    0.04820241f, 0.03723209f, -0.05823995f, 0.01145860f, -0.02552876f, 0.01991624f, 0.03686746f, -0.01616042f, 
    -0.02994712f, -0.05903690f, 0.00155830f, 0.02576059f, -0.04713873f, 0.01489830f, -0.03294059f, -0.01553325f, 
    0.02571820f, -0.03971852f, -0.03030824f, -0.06189437f, -0.02047131f, 0.02268074f, 0.01632319f, -0.06154009f, 
    0.00174779f, -0.02131124f, 0.00216720f, 0.00866032f, -0.03315060f, -0.02774369f, -0.05337971f, -0.06255675f, 
    -0.03001135f, 0.02563190f, -0.03564698f, 0.00524340f, -0.05853520f, -0.02947171f, -0.02653709f, -0.03848625f, 
    -0.01991635f, -0.00365697f, 0.03666571f, -0.02128795f, -0.04319486f, 0.04989584f, -0.03036742f, 0.01679874f, 
    0.00020930f, -0.04122112f, -0.01964878f, -0.00371872f, 0.01104367f, 0.01792167f, -0.00044483f, -0.01642564f, 
    0.00308850f, -0.00011912f, 0.05165860f, 0.03651734f, 0.01080500f, 0.00403789f, 0.02406419f, 0.00626435f, 
    -0.05364325f, -0.01520417f, 0.02858474f, 0.02255223f, -0.02586824f, -0.04769685f, -0.04437602f, -0.00017440f, 
    0.00624329f, 0.03401877f, -0.01164301f, -0.05915605f, -0.03224844f, 0.05707071f, -0.00651740f, -0.03673145f, 
    0.04082986f, 0.05784829f, -0.01662922f, -0.05303245f, -0.04736587f, 0.01881821f, -0.05491142f, 0.02362878f, 
    -0.02278127f, -0.02894129f, -0.01165322f, -0.04191459f, -0.04577978f, -0.01795484f, 0.05195739f, -0.03017604f, 
    -0.00482353f, 0.00097293f, 0.03843875f, -0.05143234f, -0.00699270f, 0.00929691f, -0.02837782f, 0.03525725f, 
    -0.03586913f, -0.00114887f, -0.03538131f, 0.03528443f, -0.06242575f, 0.02845088f, -0.05146751f, -0.05164847f, 
    -0.04886071f, 0.02699048f, 0.03631989f, 0.00375110f, -0.03660490f, -0.04032029f, -0.00730578f, -0.03334126f, 
    -0.04071438f, -0.02965662f, -0.01232021f, -0.04663760f, -0.06140701f, 0.00089380f, -0.01801195f, 0.05266075f, 
    -0.04623627f, 0.04493058f, 0.00720309f, 0.04605015f, -0.01778429f, 0.03766805f, -0.05613933f, -0.01253530f, 
    -0.01473471f, -0.04063020f, -0.04564833f, -0.01391341f, -0.02039110f, 0.04157310f, 0.04620675f, 0.05315503f, 
    -0.05498631f, 0.04591568f, -0.03843513f, 0.02466020f, 0.02600516f, 0.01951137f, -0.02544861f, -0.04597707f, 
    0.01603005f, 0.03609247f, 0.00377275f, -0.06078674f, -0.00998047f, 0.03263942f, -0.05319432f, 0.01273183f, 
    -0.06127263f, 0.02801452f, -0.02418310f, -0.01427399f, 0.04469221f, -0.03573754f, -0.04402108f, -0.00029625f, 
    -0.01149033f, 0.04224755f, -0.03616677f, -0.02915911f, 0.02683772f, 0.02119692f, -0.04286887f, -0.06003986f, 
    0.02676468f, -0.02545970f, -0.06087817f, 0.02430801f, -0.03557777f, -0.01614110f, -0.04957609f, 0.00812156f, 
    -0.02244576f, 0.03517509f, 0.00969765f, -0.03805528f, -0.00361315f, 0.03164498f, -0.02824291f, 0.02739730f, 
    0.03535841f, -0.04209734f, 0.01405967f, 0.03942432f, 0.04313491f, 0.04571287f, -0.00140523f, -0.00263798f, 
    -0.02698633f, 0.00861368f, -0.01367707f, -0.04991353f, 0.01006276f, 0.01275372f, -0.02049314f, -0.00773785f, 
    -0.03677880f, -0.03284469f, 0.02536744f, -0.04569897f, 0.02089881f, -0.01809807f, 0.03935632f, -0.02826503f, 
    -0.05471392f, 0.01431712f, 0.05129046f, 0.03925442f, -0.04129063f, 0.05119047f, 0.02726325f, -0.01168673f, 
    -0.06082727f, -0.03251909f, 0.04517752f, -0.01810088f, 0.01185124f, 0.01606551f, 0.04973072f, 0.04802610f, 
    -0.04233054f, -0.00991210f, -0.06094233f, 0.03686632f, 0.00005744f, 0.03648017f, -0.06009563f, 0.01560725f, 
    0.02628776f, -0.02514143f, 0.03493863f, 0.01152457f, -0.02391341f, -0.03877156f, -0.05592503f, -0.05995996f, 
    0.01917378f, -0.02106315f, -0.00601930f, -0.06282572f, -0.05654778f, -0.02152735f, 0.04152850f, -0.05186149f, 
    -0.02333231f, 0.03305172f, 0.03908021f, 0.04928986f, 0.01544394f, 0.05106212f, 0.03980820f, 0.00751045f, 
    -0.03810352f, 0.21636912f, -0.28154886f, 0.06161110f, -0.08399778f, -0.04456066f, -0.06734737f, 0.17554171f, 
    0.09117430f, 0.00420755f, -0.02778697f, 0.06565072f, -0.07783777f, 0.00439690f, 0.04114860f, -0.06246196f, 
    -0.02805989f, 0.08562165f, 0.03633971f, 0.23519588f, 0.11344196f, 0.09746688f, 0.17780651f, -0.06632051f, 
    0.12608115f, 0.02886755f, 0.01308566f, 0.04519968f, -0.32571283f, 0.11202467f, 0.04013204f, 0.05075858f, 
    -0.09771332f, 0.02074496f, 0.08165215f, 0.04462552f, -0.08494244f, 0.25573966f, 0.11035459f, -0.12587146f, 
    0.15105483f, -0.01615481f, 0.17951174f, 0.16254818f, 0.03123506f, -0.54204959f, 0.02118694f, 0.03329215f, 
    0.00619255f, -0.13858709f, 0.06781872f, -0.10646911f, 0.07689479f, 0.00024978f, -0.12709391f, -0.10264194f, 
    -0.02056572f, 0.04901207f, 0.02431074f, -0.01981440f, -0.01177141f, 0.02417286f, 0.23412554f, -0.15309061f, 
    0.03300302f, 0.06749500f, -0.03281201f, 0.05894888f, -0.10891687f, 0.11072443f, -0.04564085f, -0.02500060f, 
    -0.11544647f, -0.10568807f, 0.07230577f, -0.06383318f, 0.02547510f, -0.04280180f, -0.08704836f, -0.05026080f, 
    0.06916480f, -0.15083006f, 0.02296783f, -0.03118053f, -0.11307567f, 0.02386545f, -0.04657914f, 0.09466292f, 
    0.06882853f, -0.26259157f, 0.09258146f, -0.01650363f, -0.19166175f, 0.02919665f, 0.26200676f, -0.07926501f, 
    0.10027030f, -0.01881663f, -0.01739082f, -0.08564284f, -0.13672495f, -0.01503795f, -0.00482278f, 0.02677184f, 
    0.12149668f, 0.17619202f, 0.24995825f, 0.09827109f, 0.01612152f, -0.13614264f, -0.27736059f, -0.19763619f, 
    0.14647600f, -0.12272889f, 0.26853946f, -0.16629528f, -0.04719340f, 0.12375636f, -0.25020915f, 0.12222826f, 
    0.00016495f, 0.01550714f, 0.00012249f, 0.15319586f, 0.02015401f, 0.01967937f, -0.30602530f, 0.03882888f, 
    0.11998004f, -0.02680301f, -0.21228801f, 0.20116487f, 0.09625819f, 0.00862460f, 0.00386611f, -0.30981919f, 
    0.04243714f, -0.04670849f, 0.08221225f, 0.10443761f, 0.20235929f, 0.06918575f, 0.10337597f, 0.01987461f, 
    0.11294042f, -0.16478924f, 0.05940862f, 0.17586030f, 0.09485454f, 0.02833166f, 0.06107669f, 0.04003361f, 
    0.11740863f, -0.09853936f, -0.23503923f, -0.04469863f, -0.07591466f, 0.07491895f, 0.06126958f, -0.01316394f, 
    -0.14556986f, 0.17589761f, 0.27508405f, 0.21112990f, -0.35159099f, -0.03149602f, 0.05221035f, 0.11627384f, 
    0.00421008f, 0.07075331f, -0.04915719f, -0.44710162f, -0.00359444f, -0.05408164f, -0.04150441f, -0.10486866f, 
    -0.13986394f, 0.21600617f, 0.00183505f, -0.08046376f, -0.05894975f, -0.25009161f, -0.64487368f, -0.27203310f, 
    0.07343365f, 0.20020656f, 0.03355256f, 0.11363097f, -0.06778497f, -0.01878036f, -0.00657117f, 0.06311402f, 
    0.16708010f, 0.00307282f, -0.00590842f, 0.13476732f, 0.14191647f, 0.17321686f, 0.17570907f, -0.10794664f, 
    0.01869472f, -0.04629495f, 0.06677146f, 0.14853469f, 0.07592769f, -0.02500948f, 0.16601540f, -0.15622653f, 
    -0.09430591f, 0.05412396f, -0.18782473f, 0.12110523f, 0.09325920f, 0.00788700f, -0.04905828f, 0.05808717f, 
    -0.31581333f, 0.00654053f, 0.19767655f, -0.15998736f, -0.01780642f, 0.07047579f, 0.21458550f, 0.13008115f, 
    0.04574828f, 0.12222061f, -0.28394005f, 0.19992034f, -0.04283106f, 0.02680299f, 0.00285344f, 0.05823173f, 
    -0.03269816f, 0.03427463f, 0.18401715f, 0.10464116f, -0.05975962f, -0.02359084f, 0.11679307f, 0.02208816f, 
    0.07557912f, 0.14596023f, 0.05682914f, -0.05445262f, -0.31644776f, 0.07735964f, -0.02042855f, -0.14150827f, 
    -0.00176087f, 0.06060748f, -0.04040332f, 0.13687706f, -0.61114842f, -0.30938506f, 0.15273857f, -0.03555558f, 
    0.01583971f, -0.03928521f, -0.16461556f, 0.19831392f, -0.05764015f, -0.06456345f, 0.05313144f, 0.33945009f, 
    0.09527291f, -0.15207462f, 0.04283036f, 0.13771826f, 0.14435820f, 0.08209005f, -0.32789242f, -0.40103939f, 
    0.16612510f, -0.01306476f, -0.18355507f, -0.02267811f, 0.10915453f, -0.13678665f, -0.05673596f, -0.18129508f, 
    -0.08413065f, 0.06185595f, 0.10708550f, 0.02121717f, 0.02971317f, -0.13555330f, 0.02966179f, -0.02363428f, 
    -0.17315190f, -0.16019271f, -0.06679648f, -0.03976473f, -0.12610465f, 0.02125986f, -0.02921625f, -0.12712401f, 
    0.12795827f, 0.04239082f, 0.26361355f, 0.00881042f, 0.01078723f, 0.13917802f, 0.06637958f, 0.05640824f, 
    -0.04872394f, -0.23403984f, 0.35513893f, -0.08288020f, 0.18191607f, -0.03733011f, -0.04730451f, 0.04375362f, 
    0.06647801f, 0.12712251f, 0.17333901f, -0.10268768f, 0.21388786f, -0.45775506f, 0.22058271f, 0.09762206f, 
    0.03938629f, -0.00656370f, -0.06642511f, -0.12076752f, -0.34071597f, 0.11647201f, -0.21216601f, 0.00504894f, 
    -0.23975953f, -0.10680524f, 0.07598646f, 0.02480547f, 0.07323722f, 0.27268508f, 0.22233759f, -0.12294918f, 
    -0.01084440f, -0.10118085f, -0.19409776f, 0.06173196f, -0.09323116f, 0.04499397f, -0.01765861f, -0.16932318f, 
    -0.47881955f, 0.14584628f, 0.00810684f, 0.01146790f, -0.01841014f, -0.05864171f, 0.03816556f, 0.09786762f, 
    0.05020729f, -0.16429226f, 0.05804767f, 0.00570320f, 0.06202107f, -0.05085696f, -0.03249797f, -0.16404749f, 
    0.44816199f, 0.05168687f, -0.18748282f, -0.06067071f, -0.07241195f, 0.03936322f, 0.14248887f, 0.01259379f, 
    -0.09358803f, 0.23512836f, 0.02950004f, -0.00283178f, -0.12265924f, 0.14395827f, 0.05402536f, -0.04866984f, 
    -0.02016647f, -0.01505848f, 0.05736350f, -0.41295362f, -0.10291715f, -0.25200516f, -0.09646495f, -0.03661306f, 
    0.06615263f, -0.17050654f, 0.10467655f, 0.08034585f, 0.03396095f, -0.13117269f, 0.07423659f, -0.03618098f, 
    -0.02840676f, 0.12518542f, 0.22514248f, 0.06108110f, -0.48316878f, 0.26372528f, -0.34444991f, 0.04118097f, 
    -0.24647355f, -0.07670611f, -0.10509138f, -0.11824671f, -0.01398635f, -0.25917411f, 0.11447445f, 0.36005518f, 
    0.08616252f, 0.06121614f, 0.07990650f, -0.06907240f, 0.12952587f, 0.01055835f, 0.01152567f, 0.10786864f, 
    0.17232992f, 0.11361287f, 0.10493832f, 0.05418346f, 0.14047031f, 0.05275804f, -0.21747099f, -0.11127593f, 
    0.21454716f, -0.08752477f, -0.01827959f, 0.02169608f, 0.14860931f, 0.03353726f, -0.14086275f, 0.02236166f, 
    -0.09917074f, 0.07823824f, 0.02033074f, 0.04663157f, -0.08964660f, -0.18161327f, 0.02209358f, 0.03938653f, 
    0.06795181f, 0.12227402f, 0.05694564f, 0.18630968f, 0.02874057f, -0.07349722f, -0.07229175f, 0.04084572f, 
    0.06107297f, -0.10379390f, -0.14933738f, -0.22049691f, 0.30817044f, -0.33577564f, -0.05616339f, 0.01262059f, 
    -0.14102511f, 0.06764124f, 0.21109942f, -0.07805724f, -0.16591930f, 0.05962260f, 0.03403216f, -0.01092993f, 
    -0.07474620f, -0.01313600f, 0.03137602f, 0.09810700f, -0.48335218f, -0.07353830f, -0.36165872f, -0.04547286f, 
    0.08750907f, 0.08586459f, -0.00131098f, 0.00204810f, 0.15822281f, 0.17441082f, -0.14202619f, -0.00672280f, 
    -0.00053786f, -0.13596088f, 0.06720691f, -0.15790825f, -0.04777053f, 0.14693148f, -0.07792638f, -0.06590683f, 
    -0.29221261f, -0.06483173f, 0.07344642f, -0.03737578f, 0.15698572f, -0.02270163f, 0.28172067f, 0.35487804f, 
    0.01500383f, -0.05475378f, 0.07029460f, 0.02681886f, 0.08806105f, -0.01447130f, 0.13469766f, 0.10800651f, 
    -0.31737944f, 0.12754194f, 0.03649521f, 0.15027897f, -0.02317872f, -0.01935252f, -0.10295140f, -0.00118918f, 
    -0.09381337f, -0.24679598f, -0.30145711f, 0.35330251f, 0.05592717f, 0.09326079f, 0.08537403f, 0.06631713f, 
    0.04751927f, -0.16242833f, -0.42658204f, -0.05892067f, -0.01050890f, -0.01160975f, -0.11249517f, -0.05296552f, 
    0.14093818f, -0.05390134f, 0.06257445f, 0.07157028f, -0.07414313f, -0.25924671f, 0.03304564f, -0.00749035f, 
    -0.06327063f, 0.15725684f, -0.00379259f, 0.00208127f, -0.07252169f, -0.05738589f, -0.00191366f, 0.13555987f, 
    -0.03269745f, 0.01986348f, -0.08974504f, 0.01025332f, 0.05147952f, -0.08427390f, 0.04490849f, 0.28706351f, 
    0.12063733f, 0.07365073f, -0.13277589f, -0.02521149f, -0.05827391f, -0.02904350f, -0.15223612f, 0.32900864f, 
    -0.02734177f, 0.14011605f, 0.05359812f, 0.03770181f, 0.06334683f, -0.09507696f, -0.01657089f, -0.22975245f, 
    0.28833181f, -0.24154255f, -0.01955133f, -0.04276901f, -0.06964643f, 0.07622171f, -0.03949941f, 0.15315798f, 
    -0.02537070f, -0.03074631f, 0.02093140f, 0.01543564f, 0.03814328f, 0.02385778f, -0.05799783f, -0.00231872f, 
    -0.02819535f, 0.01776191f, 0.03001916f, -0.02650465f, -0.04036078f, -0.04265295f, 0.03289669f, 0.05073856f, 
    -0.04751475f, -0.05187078f, -0.05114924f, 0.04253947f, -0.03197897f, 0.05010739f, -0.05134970f, 0.02454903f, 
    -0.05625280f, -0.02087337f, 0.00268450f, -0.03846814f, 0.05023697f, -0.04966486f, -0.03122005f, -0.03058212f, 
    -0.02996366f, -0.03180720f, 0.03920903f, -0.01181902f, -0.03848990f, 0.00862761f, 0.01256327f, -0.01364885f, 
    -0.03719230f, -0.05110962f, -0.01206433f, -0.06283267f, -0.05301367f, 0.05046243f, -0.06250948f, -0.05380839f, 
    -0.01521985f, -0.03072221f, 0.01856973f, -0.05893525f, -0.04818718f, -0.01107937f, -0.01245385f, -0.00908177f, 
    -0.06360316f, -0.03020039f, 0.03722667f, 0.01435611f, -0.06049045f, -0.06420324f, 0.04951235f, 0.04605445f, 
    0.04240961f, -0.06041722f, 0.01237448f, 0.04602288f, -0.01844876f, -0.00357670f, -0.01467245f, -0.01161707f, 
    -0.02145479f, -0.03657151f, 0.02796946f, 0.01462234f, 0.04789310f, 0.04417126f, -0.05450262f, -0.04714974f, 
    0.04576406f, -0.00432785f, -0.03110286f, -0.02338351f, -0.05180684f, -0.05104436f, 0.02377405f, 0.03501579f, 
    -0.03557857f, 0.05017855f, 0.04055430f, 0.01760699f, 0.02135514f, 0.04107346f, 0.01624225f, 0.02136491f, 
    -0.00642541f, 0.04520272f, 0.00269160f, 0.00934528f, -0.04545480f, -0.03000390f, -0.01999545f, 0.01078983f, 
    -0.01725008f, 0.04419453f, -0.01411233f, 0.03880823f, -0.00767070f, -0.03062432f, -0.05955253f, 0.03039459f, 
    -0.05554251f, 0.02075649f, -0.01046477f, -0.00539592f, -0.02642984f, -0.03699415f, -0.05889757f, -0.06158890f, 
    -0.02415267f, -0.03487645f, -0.05249788f, -0.03800229f, -0.00982621f, 0.04871861f, -0.03310638f, -0.00254652f, 
    -0.06035639f, -0.05300318f, -0.02187235f, -0.05139850f, -0.02412770f, 0.02213253f, -0.00280804f, -0.04332064f, 
    -0.03804701f, -0.04787130f, 0.02857710f, -0.01592585f, 0.05073915f, 0.01215011f, -0.02221574f, 0.02438010f, 
    0.05232969f, -0.04218557f, 0.04201063f, 0.03773294f, -0.01242395f, 0.02641947f, 0.02344550f, -0.03061356f, 
    0.01288252f, -0.03471497f, 0.01247102f, 0.02784688f, 0.00047045f, -0.06405025f, -0.02256479f, 0.04757780f, 
    -0.00030041f, -0.00624882f, -0.04463713f, -0.02794803f, -0.00900675f, 0.03761595f, 0.00849505f, -0.03518936f, 
    0.03033746f, -0.05333909f, -0.06011546f, 0.04544819f, 0.03065057f, 0.04672420f, -0.03250272f, 0.03521019f, 
    0.02358390f, -0.03233613f, 0.00941582f, -0.01453454f, 0.02167025f, -0.03513019f, 0.00717575f, -0.00710995f, 
    0.03866421f, -0.00724210f, 0.00133379f, 0.05049701f, 0.01757089f, -0.01128993f, -0.00109100f, -0.06141177f, 
    -0.04121607f, 0.03959470f, 0.03575067f, -0.06302563f, 0.02723139f, 0.03369603f, -0.03545135f, -0.01840284f, 
    0.04391825f, -0.06340183f, 0.04587181f, -0.03142420f, -0.02431879f, -0.04843258f, -0.00591834f, 0.00834849f, 
    0.03189409f, -0.04269962f, -0.05551146f, 0.01254293f, -0.00828778f, 0.01928497f, 0.02692159f, 0.02318856f, 
    -0.05339478f, -0.02964083f, -0.06157163f, -0.01539372f, -0.02348940f, 0.05147807f, 0.02108186f, -0.02378567f, 
    -0.00863293f, -0.01928154f, 0.02172403f, -0.05801246f, -0.03559052f, -0.03707359f, 0.00287463f, -0.04912024f, 
    -0.00693835f, 0.00711995f, 0.03566111f, -0.01042075f, 0.00043084f, 0.03184345f, -0.02120482f, -0.00554836f, 
    -0.01542535f, -0.02308960f, -0.02607565f, -0.01337124f, -0.01666072f, 0.02363522f, 0.02880285f, -0.04862678f, 
    -0.02100179f, -0.00892445f, -0.00438144f, -0.01803666f, -0.03053422f, -0.05320281f, -0.01839351f, -0.01876350f, 
    -0.05723691f, 0.01295019f, 0.01312922f, 0.01605507f, 0.04598265f, -0.00618320f, 0.05137239f, -0.03707337f, 
    -0.04866276f, 0.02479643f, 0.00616629f, -0.05079238f, 0.01733492f, -0.02204832f, 0.03280926f, 0.04817063f, 
    -0.04890622f, 0.01382708f, 0.03446683f, -0.02885644f, 0.01577373f, 0.01071073f, 0.01291521f, 0.02120018f, 
    0.02430276f, -0.01174698f, -0.04577795f, -0.05720141f, -0.02861701f, 0.02092974f, 0.00850908f, -0.05225922f, 
    -0.06014998f, 0.01125354f, -0.05786677f, 0.01939174f, -0.05468567f, 0.03146346f, 0.02566461f, -0.04080086f, 
    0.00444333f, 0.02326196f, 0.04123925f, 0.02539077f, -0.06784910f, -0.03967722f, 0.05043918f, -0.04857731f, 
    -0.01788932f, -0.03913801f, 0.00724689f, -0.03415621f, 0.00626530f, -0.04830565f, 0.03793342f, 0.00838354f, 
    -0.03725656f, -0.03344121f, -0.02265335f, 0.01081284f, 0.05570862f, -0.04726361f, -0.03191586f, 0.03816340f, 
    -0.02645035f, 0.00028675f, -0.01416527f, -0.01922381f, 0.04492335f, -0.01083472f, -0.00099041f, -0.02849707f, 
    -0.05604219f, 0.04756107f, -0.05530236f, -0.00939245f, -0.03487682f, 0.01785313f, 0.04266876f, 0.04181227f, 
    0.01877732f, 0.00263297f, 0.03982744f, -0.01470413f, -0.02493134f, -0.04777551f, -0.03690281f, -0.04621463f, 
    -0.04131311f, 0.04124222f, -0.04729714f, -0.04611200f, -0.05780476f, -0.01788515f, 0.03630925f, -0.00341657f, 
    -0.00947621f, 0.02036728f, 0.03177423f, -0.00535806f, -0.02596483f, -0.00762101f, -0.04991365f, -0.02470707f, 
    0.04376645f, -0.01801282f, -0.03846587f, -0.01586401f, 0.01377422f, -0.03528607f, -0.03254065f, 0.00567954f, 
    -0.02864582f, -0.04158799f, 0.01839084f, 0.02842610f, -0.01354605f, 0.01575492f, 0.00820791f, 0.01918397f, 
    -0.01637489f, -0.01971631f, -0.04135790f, -0.05371892f, 0.04255762f, -0.04239070f, -0.01046552f, 0.03866148f, 
    0.02361867f, -0.01689677f, 0.00550855f, 0.01694133f, 0.00279210f, 0.04292341f, -0.00337238f, -0.04236035f, 
    -0.02674001f, 0.00503257f, 0.02604107f, -0.04214020f, 0.05575588f, 0.00571782f, 0.02564284f, -0.02510213f, 
    0.04458776f, 0.01666157f, -0.03866626f, -0.00240077f, 0.02752736f, 0.02927103f, 0.01112824f, 0.00838168f, 
    0.04145320f, -0.03834146f, -0.01018485f, -0.03200832f, 0.02086421f, -0.01304879f, 0.01694969f, 0.03099821f, 
    -0.02157837f, 0.04404302f, -0.03339002f, 0.01348231f, 0.02204163f, -0.04580495f, -0.05101534f, 0.02215035f, 
    -0.06728733f, -0.04434268f, 0.04194346f, 0.02577589f, -0.04522771f, 0.02420690f, 0.03328770f, 0.03627466f, 
    -0.05796680f, 0.04236639f, -0.04931100f, -0.02255403f, 0.00378548f, 0.00079910f, 0.02790084f, 0.00128375f, 
    0.04943925f, 0.03334408f, 0.00266001f, 0.02757687f, -0.01189655f, 0.05608686f, -0.04329590f, 0.03604121f, 
    -0.05988822f, 0.01520804f, -0.03262530f, 0.01531376f, -0.00402203f, -0.05418922f, -0.05467979f, -0.04223502f, 
    0.03065333f, 0.02615775f, 0.04668314f, -0.04682422f, 0.03195433f, 0.01655989f, 0.05367532f, -0.05638061f, 
    -0.05105934f, 0.05133201f, 0.03174718f, -0.02898888f, -0.05435641f, -0.03837955f, -0.03154923f, -0.05557158f, 
    -0.01620286f, 0.01787772f, -0.05372766f, 0.04650087f, -0.01345959f, -0.02033396f, -0.03316742f, 0.02364298f, 
    -0.00269325f, 0.01717312f, -0.04433535f, 0.00355571f, -0.04982385f, 0.01283570f, -0.04314771f, 0.00709257f, 
    -0.05161360f, 0.02269181f, -0.00384210f, -0.03456322f, 0.01512167f, 0.01286003f, 0.04679080f, -0.03891280f, 
    0.01391973f, -0.00559145f, -0.05812613f, -0.03555160f, 0.02681395f, -0.02757100f, 0.02868576f, 0.00919721f, 
    0.01890392f, -0.02011498f, -0.04216537f, -0.02116936f, 0.04717156f, -0.00967544f, 0.02006092f, 0.04015806f, 
    0.00606994f, -0.01232695f, -0.01370035f, -0.04726078f, -0.03099734f, 0.02117747f, 0.05005224f, 0.02640349f, 
    -0.04674735f, 0.03972866f, 0.00486371f, -0.00991747f, 0.02731451f, -0.02932069f, -0.02261576f, -0.00859062f, 
    -0.00183468f, 0.00144473f, 0.02565835f, -0.00508549f, 0.02953186f, -0.02869836f, -0.02987747f, -0.05262974f, 
    -0.02381292f, 0.00327556f, 0.05366297f, -0.04056127f, 0.03456007f, -0.04174248f, -0.03467121f, 0.02647431f, 
    -0.00969063f, 0.05463546f, -0.06032954f, 0.01062719f, -0.05544155f, 0.03989324f, -0.06610464f, -0.06378790f, 
    0.03851831f, 0.02894408f, -0.06300563f, -0.00324782f, 0.04758730f, -0.03550235f, 0.03956999f, 0.03595383f, 
    0.05431104f, -0.03104957f, -0.06330300f, 0.00032763f, -0.05143628f, -0.02934346f, -0.00541457f, 0.03807875f, 
    -0.01132032f, 0.02569729f, -0.04108796f, -0.00972214f, -0.01872170f, -0.05549545f, -0.04757804f, 0.04723732f, 
    0.14777173f, -0.37543988f, -0.24392000f, 0.05938654f, -0.11527795f, 0.03939828f, 0.23885919f, 0.00767698f, 
    -0.08868194f, -0.03320049f, -0.46562958f, -0.04847030f, -0.00425009f, 0.02495483f, 0.17967379f, 0.04634960f, 
    -0.06685199f, 0.12182521f, -0.25794539f, -0.26601300f, -0.01694693f, 0.14350094f, 0.15292586f, 0.05423732f, 
    -0.20759074f, -0.16843961f, 0.04564100f, 0.12861894f, 0.23577940f, 0.03878072f, -0.00957576f, -0.12316096f, 
    0.00070525f, 0.01769560f, -0.06531204f, 0.18145514f, 0.26079422f, 0.11266169f, 0.12202326f, 0.03938846f, 
    0.13025530f, 0.08111460f, 0.16562328f, 0.05650721f, -0.03952998f, -0.01870880f, 0.05408854f, -0.13562256f, 
    -0.15650672f, 0.03836992f, -0.09694294f, 0.04743185f, -0.06976913f, 0.17866123f, 0.16087793f, 0.26850307f, 
    0.07902440f, 0.04882513f, -0.05564559f, 0.06616101f, -0.13917135f, -0.05765488f, -0.00632525f, 0.38681468f, 
    0.03569674f, 0.08990982f, -0.07199170f, -0.03416781f, 0.19188757f, 0.01790803f, 0.15359943f, -0.02069478f, 
    0.20047021f, -0.11618008f, -0.09124680f, 0.02295155f, -0.02482058f, -0.03427835f, 0.01342148f, 0.05093045f, 
    -0.04963578f, -0.39930850f, -0.59365362f, -0.16612566f, -0.01865098f, 0.24252319f, -0.02360518f, -0.20994695f, 
    0.05157012f, -0.00297185f, -0.25070786f, -0.04254502f, -0.05281747f, 0.16156641f, -0.10489070f, 0.00260971f, 
    0.16215965f, -0.04964920f, 0.08228550f, -0.10900854f, -0.13847035f, 0.24537607f, 0.07307497f, 0.09561425f, 
    -0.00106896f, 0.28870073f, -0.18003938f, 0.05011164f, -0.14139853f, 0.08171631f, -0.11378907f, -0.12338018f, 
    -0.12926948f, -0.18972844f, -0.16225368f, 0.15253548f, -0.14218463f, -0.01950955f, 0.12100570f, -0.39273447f, 
    0.10072416f, 0.15660720f, -0.00068864f, -0.02722886f, 0.03360076f, -0.12731655f, 0.32830876f, 0.07285595f, 
    0.18321823f, 0.16873129f, 0.00501893f, 0.02015675f, 0.22008312f, -0.08497777f, 0.09892316f, -0.25085875f, 
    -0.25196657f, -0.14825258f, 0.13732289f, 0.10289452f, 0.14020111f, -0.12972021f, -0.13340399f, -0.01932690f, 
    -0.14386350f, 0.02425688f, 0.24533916f, -0.12620324f, 0.03264607f, 0.10393564f, -0.13899559f, -0.02097057f, 
    0.15824328f, -0.19771019f, 0.04952875f, 0.02240873f, 0.14606445f, -0.06872647f, -0.22891839f, 0.08931788f, 
    -0.01566890f, -0.03833614f, -0.60651129f, -0.22512516f, -0.09340337f, 0.19914693f, 0.07135766f, 0.12330823f, 
    0.11536346f, -0.05579439f, -0.07819721f, 0.27625737f, 0.12832160f, 0.10116301f, -0.08912011f, 0.05076472f, 
    0.05599751f, -0.03830525f, 0.01712928f, 0.13253956f, -0.16285206f, -0.19968396f, 0.05073549f, -0.26265085f, 
    -0.02320306f, -0.22687779f, -0.05930621f, 0.03090345f, -0.04765050f, -0.07053704f, -0.18132497f, -0.12504348f, 
    0.06861873f, 0.22236505f, 0.02668945f, -0.17452386f, -0.14562801f, 0.21321781f, 0.15497942f, 0.18977332f, 
    0.01286505f, 0.02663490f, 0.16695158f, 0.05118841f, 0.07686868f, 0.02125896f, 0.05494054f, 0.17718099f, 
    -0.02198773f, -0.07824822f, -0.12372963f, -0.15297392f, 0.16258937f, -0.05948680f, 0.09097772f, 0.13707091f, 
    0.19628514f, 0.03715916f, 0.24581225f, 0.18903674f, -0.13595970f, 0.24786936f, 0.28107786f, 0.01752489f, 
    -0.06214262f, 0.14744675f, 0.12495888f, 0.11294633f, 0.03097417f, 0.00557240f, 0.04698877f, -0.14371499f, 
    0.08261745f, 0.05048965f, 0.23914795f, 0.00394205f, -0.01195879f, -0.10468683f, -0.08261195f, -0.18616603f, 
    -0.13313939f, -0.01766086f, -0.02535790f, 0.19847535f, 0.17401309f, 0.05150471f, 0.07571029f, -0.02549823f, 
    -0.05540739f, -0.04706925f, 0.08771722f, -0.05250070f, -0.11925975f, 0.01662845f, -0.14669773f, -0.13081133f, 
    0.11720659f, -0.09756921f, 0.11093811f, -0.02967967f, 0.13335766f, -0.24239671f, 0.12074132f, -0.14454080f, 
    0.12840420f, 0.08064982f, -0.21234329f, 0.11246978f, 0.05646633f, -0.02668242f, 0.55924529f, 0.25157738f, 
    0.17841400f, 0.03596609f, -0.18569364f, 0.08381903f, 0.20398219f, -0.10873094f, 0.03100001f, -0.03628707f, 
    -0.02658496f, -0.06386530f, -0.05657211f, 0.07299218f, -0.19296266f, -0.04952554f, 0.02147609f, -0.00338437f, 
    0.10033365f, 0.06245017f, -0.15995717f, -0.04377705f, -0.08389965f, 0.02929438f, 0.08734333f, 0.13626581f, 
    0.05342302f, 0.14154655f, -0.09745882f, -0.23006485f, 0.07071078f, -0.10152014f, 0.07339600f, -0.08561411f, 
    0.19573237f, 0.09082930f, 0.11895588f, -0.02073223f, -0.03093133f, -0.02852996f, -0.15494609f, 0.05267447f, 
    0.06751239f, 0.08403985f, -0.06862834f, -0.35275120f, 0.27107930f, 0.25448146f, 0.09317796f, 0.07020913f, 
    0.16035342f, -0.03047988f, -0.10359459f, 0.08220077f, -0.18089078f, -0.02544379f, -0.19389105f, 0.00361248f, 
    0.02486427f, 0.02533320f, -0.17988193f, 0.01133029f, -0.19560154f, 0.17418277f, 0.01354616f, 0.11988444f, 
    -0.04745511f, -0.20918387f, -0.11757288f, -0.13145739f, -0.03244635f, -0.01880179f, -0.47694236f, 0.18205918f, 
    0.17651291f, 0.12100907f, 0.05818582f, 0.06937429f, 0.03850693f, -0.13279754f, 0.18600921f, -0.25880325f, 
    0.04087146f, -0.06893561f, -0.12492368f, 0.04066764f, -0.05076339f, -0.09884315f, 0.08479527f, 0.00065118f, 
    -0.04891613f, 0.06724768f, -0.08258525f, 0.07700840f, -0.02866966f, 0.04902491f, -0.07291780f, 0.11990767f, 
    0.02823619f, -0.01017310f, 0.21522765f, 0.08812226f, 0.19351052f, 0.01438503f, -0.16776080f, 0.02567613f, 
    0.12189706f, -0.10338911f, -0.06172916f, -0.03511623f, 0.10134351f, -0.10426774f, 0.03402245f, -0.03931222f, 
    -0.16071941f, 0.12149934f, -0.00812137f, -0.02824808f, 0.03219471f, -0.02083347f, -0.03553493f, 0.00458383f, 
    0.07918151f, -0.13969384f, 0.08729643f, -0.27210930f, 0.12060472f, 0.28898683f, -0.29397473f, -0.11420090f, 
    0.03078355f, -0.05541871f, -0.08761661f, -0.05861965f, -0.08787946f, 0.01767443f, 0.01674814f, 0.04496967f, 
    0.14435500f, -0.10098562f, -0.09693496f, -0.04085072f, -0.11901233f, 0.09737810f, -0.63650531f, -0.14804459f, 
    0.02059798f, 0.00973149f, 0.03004301f, 0.12480538f, 0.07323077f, -0.05034308f, 0.00378398f, -0.00526393f, 
    0.05416301f, 0.04101496f, -0.13127878f, -0.02231170f, 0.07365411f, -0.01698893f, -0.11736251f, 0.10995977f, 
    0.08917490f, 0.05113160f, -0.19207220f, 0.00206299f, 0.14524332f, -0.06082019f, -0.03863893f, 0.04189403f, 
    0.10476708f, 0.03050952f, -0.04643194f, -0.01594578f, -0.11491286f, 0.05906379f, 0.20959619f, 0.00160053f, 
    0.24191901f, 0.03981073f, 0.18560344f, 0.10605553f, 0.07998057f, -0.04936243f, 0.01338210f, -0.15488429f, 
    0.08024529f, 0.03344059f, 0.13289061f, -0.15048724f, 0.01753164f, -0.18884270f, 0.02687846f, 0.11602521f, 
    0.08719867f, 0.14520292f, -0.06260393f, -0.10324028f, -0.07839330f, -0.11867472f, 0.19677474f, -0.12137663f, 
    0.01418397f, 0.13928223f, -0.05900690f, -0.09463176f, -0.04952269f, 0.06535112f, 0.06610931f, -0.07407051f, 
    -0.01362087f, -0.14936666f, 0.05595520f, 0.17340614f, 0.05594299f, -0.07085344f, -0.20409235f, 0.02999198f, 
    0.20169102f, 0.15914409f, 0.10598497f, 0.01498188f, 0.05283448f, -0.06319296f, 0.11607362f, -0.26921865f, 
    -0.03969187f, 0.00876838f, 0.09800219f, 0.01463374f, 0.16326772f, 0.02891273f, 0.02960235f, 0.01250098f, 
    -0.38780734f, -0.16162930f, -0.10026111f, -0.05750065f, 0.11609929f, 0.15928732f, 0.09117200f, -0.11585414f, 
    0.01941636f, 0.07579338f, 0.07486262f, 0.01896384f, -0.14948282f, 0.05343333f, -0.00087139f, -0.14595094f, 
    -0.12812944f, 0.01836484f, 0.07834877f, 0.09567045f, -0.26881632f, -0.11792605f, -0.00046531f, 0.14182666f, 
    -0.08725364f, 0.03526834f, -0.05482147f, 0.30498043f, 0.23912087f, 0.08565429f, 0.14873005f, 0.03435161f, 
    -0.23937111f, -0.08320885f, 0.00050295f, 0.04038492f, 0.12168191f, 0.11258128f, 0.00216025f, 0.15997498f, 
    -0.01331377f, 0.03617523f, 0.08303244f, -0.03322603f, -0.05249357f, 0.04694529f, -0.03773325f, 0.03515993f, 
    -0.03267780f, 0.10119776f, -0.01850298f, -0.11897631f, -0.05796478f, 0.02315115f, -0.58890665f, -0.07169747f, 
    -0.05669301f, 0.11103505f, 0.14490855f, 0.00628466f, -0.14203706f, -0.03038668f, -0.02938584f, 0.05158557f, 
    0.24805124f, 0.21410993f, 0.15065332f, 0.11418378f, -0.13172333f, -0.08898425f, 0.01993527f, -0.00686597f, 
    -0.03881732f, -0.04876489f, 0.04500230f, -0.05851770f, -0.02159929f, -0.05112377f, -0.00520787f, 0.04165543f, 
    -0.02789916f, 0.04744678f, 0.01047520f, -0.01085315f, -0.03008292f, 0.01102004f, 0.01887001f, -0.01180419f, 
    0.00943458f, 0.01397623f, 0.02310411f, -0.03684965f, 0.03196786f, -0.02106260f, -0.01315049f, 0.01576084f, 
    -0.05425358f, 0.01961476f, -0.00783705f, 0.00086135f, 0.01824740f, -0.02414142f, 0.01378767f, -0.01563225f, 
    -0.00942429f, -0.03376350f, 0.00588668f, 0.02482061f, 0.01431285f, 0.00116783f, 0.00641230f, -0.03365107f, 
    -0.02765991f, -0.01193091f, -0.06384259f, 0.03661613f, 0.00806125f, -0.01818870f, -0.04480825f, -0.05749229f, 
    -0.05198841f, 0.02753591f, -0.00855627f, 0.04353020f, 0.00456021f, -0.00383669f, -0.03772943f, 0.02737690f, 
    -0.00706570f, -0.04188842f, -0.00461252f, 0.03215509f, -0.03891414f, -0.00149281f, 0.00451112f, -0.05646752f, 
    -0.05572498f, -0.05883973f, -0.06233455f, 0.04613434f, -0.03596145f, -0.00593115f, -0.04748880f, 0.00597228f, 
    0.01872366f, -0.05002055f, -0.01878187f, -0.01578779f, -0.04356308f, -0.05804654f, -0.06440135f, -0.01321826f, 
    -0.00135203f, -0.03987572f, 0.04715924f, 0.04361365f, -0.01005404f, 0.01269577f, 0.01641825f, 0.04205258f, 
    -0.03062474f, 0.02745302f, -0.02462286f, -0.00473326f, -0.02875354f, 0.03043803f, 0.04279093f, -0.01748714f, 
    0.03385867f, -0.03800976f, -0.00117275f, 0.05824541f, 0.05223304f, -0.05010986f, -0.05020975f, 0.03550327f, 
    -0.03138772f, 0.03672612f, 0.00441697f, 0.01888193f, 0.03178243f, -0.03097095f, -0.01879232f, -0.02887941f, 
    0.02490269f, 0.04284413f, -0.00022692f, 0.00151580f, 0.00008096f, 0.03202405f, -0.06112364f, -0.03817574f, 
    0.02111282f, 0.00028792f, 0.02203524f, -0.01556691f, -0.00272119f, -0.04044648f, 0.00548473f, -0.02615080f, 
    0.03485197f, -0.00152670f, -0.03291006f, -0.01095818f, -0.05723356f, -0.04005385f, -0.03961199f, 0.04417522f, 
    -0.03586996f, 0.03609604f, 0.04861901f, 0.03116984f, 0.01383236f, 0.01647853f, 0.00166281f, 0.01881358f, 
    0.01966859f, -0.04501652f, -0.04997666f, -0.04616480f, 0.01578185f, 0.00477343f, -0.06189207f, -0.04756614f, 
    0.03535346f, -0.04888747f, -0.01005864f, -0.01292776f, -0.00636000f, 0.01793211f, 0.03391280f, 0.03338319f, 
    0.00302748f, 0.03698671f, 0.02499772f, 0.00412338f, -0.02929641f, 0.05788956f, 0.02633135f, -0.05736193f, 
    -0.04580157f, 0.01749053f, 0.02760566f, -0.03183769f, -0.03175406f, -0.03146074f, 0.02320598f, -0.06462946f, 
    0.03657080f, -0.02611093f, -0.01340753f, -0.05366935f, 0.01062884f, 0.05141303f, -0.04106469f, -0.02832831f, 
    0.03220233f, -0.02521535f, -0.04453370f, -0.04689645f, 0.00754593f, -0.01639393f, -0.05008619f, -0.00288326f, 
    -0.02052122f, 0.02533510f, 0.05236386f, -0.01014752f, -0.02142637f, -0.06418319f, -0.05169876f, 0.01954711f, 
    0.01813518f, 0.03712603f, -0.00061599f, 0.02803558f, 0.01934483f, -0.03895029f, -0.03302579f, -0.05902425f, 
    -0.04451740f, -0.04142866f, 0.02449160f, -0.03281014f, 0.04154922f, -0.02566469f, -0.05877923f, -0.00140945f, 
    -0.03051694f, 0.02767914f, -0.00657573f, -0.00153229f, -0.03165868f, 0.00890947f, -0.00042090f, 0.04700863f, 
    -0.02056257f, -0.03922103f, -0.06220532f, -0.00424191f, -0.00008192f, 0.04806236f, -0.01575107f, 0.04100780f, 
    0.02052998f, 0.03801604f, -0.00845840f, -0.04773850f, -0.04885711f, -0.01909527f, -0.03493225f, -0.00807011f, 
    0.04209917f, -0.00793038f, -0.04903800f, 0.00918930f, 0.02756373f, -0.00777292f, 0.00046626f, -0.01634787f, 
    -0.05954977f, -0.06329351f, -0.00032973f, 0.02079107f, -0.05209688f, 0.05133918f, -0.03206707f, -0.02440291f, 
    -0.05245610f, 0.03411707f, 0.00285906f, -0.00592215f, 0.04251390f, 0.02647087f, 0.04996305f, -0.06254183f, 
    0.02778136f, -0.02105328f, 0.05209279f, 0.04931783f, -0.01735908f, -0.03770982f, -0.03078238f, -0.01465142f, 
    0.00039986f, 0.03783659f, 0.03511693f, 0.05073972f, 0.00140491f, 0.04843369f, -0.03904210f, -0.02506771f, 
    -0.02037814f, -0.06338213f, -0.06399176f, -0.04961748f, -0.01487966f, -0.01833206f, 0.00824759f, -0.01729109f, 
    0.11448786f, 0.16873343f, 0.04229846f, -0.18520500f, -0.04119647f, 0.04258374f, -0.02726682f, -0.01033463f, 
    -0.06572890f, 0.07211923f, -0.09336753f, 0.01099913f, 0.22304006f, 0.03119322f, -0.00107384f, -0.09063246f, 
    -0.05726615f, -0.03502402f, -0.16195007f, 0.12299339f, -0.16540155f, 0.13351911f, 0.14960347f, 0.04435407f, 
    -0.04993236f, 0.00961025f, -0.01144809f, 0.34834847f, 0.02419612f, 0.19041392f, 0.05775502f, 0.05507242f, 
    -0.04055548f, 0.12044649f, 0.08511718f, 0.15877919f, -0.32398209f, -0.17870076f, -0.29405409f, 0.19014430f, 
    0.00601180f, 0.07726479f, 0.04241028f, 0.01997645f, -0.15290004f, 0.07109137f, -0.06367111f, 0.17687960f, 
    -0.00355390f, -0.02679373f, -0.01797334f, 0.06573444f, 0.03051540f, -0.03781020f, -0.07269540f, -0.10784242f, 
    0.25534144f, 0.02065156f, 0.15728353f, 0.02589368f, 0.03229451f, 0.06836496f, 0.20324296f, -0.38424852f, 
    -0.19180298f, -0.09382565f, 0.00291886f, 0.09900028f, -0.02711982f, 0.10445220f, -0.08448184f, 0.10874785f, 
    0.12436675f, -0.19878563f, -0.04327515f, -0.05243161f, -0.02223589f, 0.00399063f, 0.04234398f, 0.18680187f, 
    0.08207449f, -0.38032877f, -0.13532375f, -0.11286119f, 0.31611127f, 0.02828111f, 0.16298732f, -0.12846491f, 
    0.03597338f, -0.05148706f, -0.43900710f, -0.14831808f, -0.09049544f, -0.11931692f, -0.04337977f, 0.04326692f, 
    -0.33205014f, -0.14754966f, -0.01361513f, -0.40993908f, -0.25069600f, -0.11562062f, 0.08541159f, 0.05424986f, 
    -0.00466268f, -0.21693711f, -0.18728833f, -0.29917860f, 0.17033201f, 0.17352466f, -0.23889126f, -0.14321500f, 
    -0.12326495f, -0.17593746f, 0.05129196f, -0.09004194f, 0.01510075f, 0.09512152f, 0.10753524f, -0.10035647f, 
    0.04370167f, 0.28685445f, 0.16729690f, 0.09750213f, 0.07330778f, 0.04254023f, -0.10952090f, -0.02708235f, 
    0.02012767f, 0.11187860f, 0.11888707f, -0.04419604f, 0.07015600f, -0.01573920f, -0.05561251f, -0.03725323f, 
    0.13989595f, 0.00728302f, 0.10315108f, -0.36423495f, -0.07580863f, 0.03043805f, 0.18980436f, -0.00621782f, 
    -0.03448480f, -0.29384333f, -0.11146645f, 0.06959841f, 0.12105733f, -0.08036041f, -0.02454509f, 0.00070897f, 
    0.00092445f, -0.07337716f, -0.37786743f, 0.22334112f, -0.10423240f, -0.05793366f, 0.06585412f, 0.21676899f, 
    0.15086281f, 0.00420707f, 0.26559266f, 0.18740831f, 0.01679837f, 0.00200956f, 0.03204227f, 0.14095062f, 
    -0.01353072f, 0.12917885f, 0.02969148f, 0.02123345f, -0.19025685f, -0.12051006f, 0.13527483f, 0.01732488f, 
    0.09665065f, 0.16915344f, 0.07884522f, -0.00950429f, -0.03468874f, -0.37198776f, 0.23538145f, 0.08881228f, 
    0.13713062f, -0.13177468f, -0.03074828f, 0.04872134f, 0.05200139f, 0.22687203f, -0.10166924f, -0.12830864f, 
    0.04462418f, 0.10372065f, 0.04349141f, -0.07192540f, -0.08881515f, -0.01294752f, -0.01473509f, 0.23677316f, 
    0.31238079f, 0.15568969f, 0.14333005f, 0.02027935f, 0.21399668f, 0.11752041f, 0.06688032f, -0.35545051f, 
    -0.06380944f, -0.24412204f, 0.05159176f, 0.05588052f, 0.01183759f, 0.18418796f, 0.13961953f, 0.03109330f, 
    -0.06418099f, -0.11421204f, -0.27399233f, 0.19880092f, -0.00873548f, 0.19702865f, -0.04216012f, -0.19846793f, 
    -0.07911956f, 0.22046678f, -0.08249049f, -0.03562677f, -0.35369954f, -0.10749931f, -0.21137139f, -0.04044838f, 
    0.00634582f, 0.01895187f, 0.05213225f, 0.04351210f, -0.01732976f, -0.07678947f, -0.11740880f, 0.00728160f, 
    0.09693731f, 0.14118704f, 0.15793405f, 0.45891780f, 0.15432693f, 0.09830390f, 0.05111145f, -0.14844912f, 
    -0.04037577f, 0.04428003f, 0.15883379f, 0.13943428f, 0.29493582f, 0.10783347f, -0.09480228f, 0.00597701f, 
    -0.12423974f, 0.08371248f, 0.07122095f, 0.18721305f, 0.08584224f, 0.23501195f, 0.09824649f, -0.15017052f, 
    -0.01053539f, -0.13792738f, 0.07557053f, 0.14440595f, 0.09893302f, 0.00115977f, 0.09855731f, -0.19838697f, 
    -0.10531978f, 0.14218652f, 0.07414118f, -0.03801005f, -0.08060968f, 0.13647583f, 0.00755410f, 0.20223027f, 
    0.12861107f, 0.05163980f, -0.02811244f, -0.11902500f, -0.02653109f, 0.08076936f, 0.08836850f, 0.21675383f, 
    -0.00271674f, -0.06118379f, -0.05565653f, -0.01226231f, 0.00898737f, -0.06155868f, 0.03345700f, -0.02355305f, 
    -0.05327947f, 0.01388106f, -0.02610047f, 0.04499920f, -0.01874880f, -0.04322051f, -0.03405578f, 0.00490267f, 
    -0.02264996f, -0.05266380f, -0.05094226f, 0.01054343f, -0.01006055f, -0.03017219f, 0.04024996f, -0.00401789f, 
    0.03800472f, 0.03926171f, 0.01353731f, 0.00480094f, 0.03323603f, -0.01119026f, -0.00338694f, -0.02238801f, 
    0.05262117f, -0.01219045f, -0.04318618f, -0.05967147f, -0.01188129f, 0.04080814f, -0.04963925f, 0.01025895f, 
    0.03741269f, 0.02099948f, -0.06197416f, 0.01210861f, -0.03804306f, -0.04819186f, 0.05221656f, -0.02228214f, 
    -0.05612291f, -0.05997587f, 0.00704233f, -0.02479497f, 0.01739788f, -0.04133460f, 0.01175322f, -0.02608167f, 
    -0.00111303f, -0.01829716f, 0.02320970f, 0.04766845f, 0.03522644f, -0.02178968f, -0.01045343f, -0.02038279f, 
    0.04568816f, 0.03253867f, 0.02351198f, -0.00789664f, 0.03182710f, -0.01538802f, 0.02852792f, -0.05632163f, 
    -0.03785750f, -0.03066896f, 0.00135079f, -0.03546843f, 0.03374196f, -0.05992266f, -0.03279024f, -0.03580003f, 
    0.01044628f, -0.01736257f, -0.00170952f, 0.03488859f, -0.04209472f, 0.00799033f, 0.00448335f, -0.04830916f, 
    0.00039508f, 0.01749776f, 0.03289136f, 0.03481255f, 0.03790594f, -0.00840134f, 0.04739673f, 0.01316825f, 
    -0.05760222f, -0.03320988f, 0.00541694f, 0.02554274f, -0.03259386f, 0.01373806f, -0.00641568f, -0.00389558f, 
    0.02896719f, 0.04009856f, -0.03934863f, 0.00618294f, 0.05238463f, 0.03701322f, 0.02216117f, -0.01905681f, 
    -0.05658847f, -0.05175233f, 0.01152961f, 0.03219984f, 0.05066667f, -0.01227673f, 0.04686743f, 0.01786753f, 
    0.03137822f, 0.03420002f, -0.03034330f, -0.03137932f, -0.02870073f, 0.03735012f, -0.04620671f, 0.01575608f, 
    0.01218454f, 0.02136896f, -0.01807861f, -0.06228429f, 0.01849749f, -0.04032861f, -0.02134544f, -0.02871332f, 
    -0.00906034f, 0.05020475f, 0.01506923f, -0.01412773f, -0.03093657f, 0.03629061f, -0.01915989f, 0.00671771f, 
    0.03420437f, 0.04846852f, 0.02499953f, 0.04990749f, -0.02556672f, 0.04764419f, -0.01194353f, 0.05253656f, 
    -0.00974531f, -0.04941865f, -0.01035952f, 0.04472461f, -0.06237938f, -0.01940952f, -0.00400153f, -0.05612738f, 
    -0.04567469f, -0.01271433f, -0.00223238f, -0.02433183f, -0.01824633f, -0.02876463f, -0.05186108f, -0.03094009f, 
    -0.04108012f, -0.04445846f, -0.03717149f, 0.04261385f, -0.00965979f, -0.03005093f, 0.04248559f, -0.02342082f, 
    -0.04281897f, -0.04337145f, -0.02901993f, -0.05436038f, 0.04720144f, -0.04112597f, 0.03621851f, 0.03727622f, 
    -0.04957353f, -0.01533419f, -0.06476386f, 0.00739357f, -0.02095642f, 0.04539535f, -0.00986822f, -0.01090102f, 
    -0.03897655f, -0.03373152f, -0.02959714f, 0.01664011f, 0.02190590f, -0.04769290f, -0.05505486f, -0.05433286f, 
    0.03149840f, -0.06328231f, 0.00433401f, -0.02667250f, 0.01693049f, 0.04495601f, -0.02288602f, 0.00872969f, 
    -0.00982378f, -0.02612095f, -0.03854300f, 0.02390414f, -0.05339325f, -0.04916920f, 0.02520295f, -0.02736725f, 
    0.05240545f, -0.05059641f, -0.06132117f, -0.04027942f, 0.04888642f, 0.02061873f, -0.03249022f, -0.04580507f, 
    -0.01049119f, -0.03526868f, -0.01723269f, -0.04115272f, -0.03144847f, -0.00463347f, 0.03579853f, 0.01629590f, 
    -0.05630339f, -0.04510409f, 0.04267088f, -0.04643787f, -0.06027098f, -0.00818323f, -0.03045716f, -0.02250598f, 
    0.01601692f, 0.01854116f, -0.02954610f, -0.02830297f, -0.02727627f, 0.01685856f, -0.05570206f, -0.06394013f, 
    -0.04744019f, -0.02079489f, -0.04747372f, 0.03476859f, 0.02322951f, -0.06405780f, 0.01825802f, 0.03603356f, 
    -0.03828212f, -0.03640086f, 0.00299962f, 0.02166988f, 0.04516393f, 0.04306412f, -0.03508158f, 0.03961524f, 
    -0.02964171f, -0.05177110f, 0.00019651f, -0.06298385f, -0.01150252f, -0.01209036f, 0.03367962f, -0.01734989f, 
    0.00118648f, -0.01634706f, 0.03065658f, -0.05962494f, -0.05790456f, 0.05188604f, -0.06196373f, -0.01988549f, 
    -0.02627214f, 0.05253597f, 0.03802180f, 0.04996087f, -0.03604836f, -0.02776678f, 0.02287287f, 0.00034498f, 
    -0.32361254f, -0.04988401f, -0.01835081f, -0.14820677f, 0.10266893f, -0.12922108f, 0.10668104f, 0.11880185f, 
    0.19619356f, 0.05677330f, 0.08161376f, 0.04594946f, -0.04291352f, -0.11613219f, -0.06956061f, 0.15585648f, 
    0.19533835f, -0.06606684f, 0.20721616f, -0.07207564f, 0.08313361f, 0.04174702f, -0.15741894f, -0.23286436f, 
    -0.04079912f, 0.10497220f, -0.18300693f, 0.15999384f, -0.03827188f, -0.07504729f, 0.09610047f, -0.00100278f, 
    0.14357483f, 0.14253108f, -0.04093058f, -0.02072568f, 0.07912892f, 0.02936040f, -0.20787477f, 0.07345257f, 
    -0.07023424f, -0.10077216f, -0.02014364f, 0.13964713f, -0.12691340f, 0.17616339f, 0.19249409f, -0.01768468f, 
    0.16463523f, -0.04414165f, -0.04205673f, 0.06519409f, 0.03798594f, -0.03393565f, 0.40047282f, 0.17973228f, 
    -0.08111741f, -0.07730369f, -0.00150467f, 0.07181151f, 0.03463910f, 0.06242600f, 0.10700744f, 0.03094112f, 
    0.06233460f, 0.20180295f, 0.11469021f, -0.06584707f, -0.12011559f, -0.22212401f, 0.01418409f, 0.18160765f, 
    -0.00245462f, 0.06987865f, 0.05663484f, 0.13213444f, 0.04647712f, -0.00211989f, 0.04159637f, 0.16127267f, 
    0.12129778f, -0.17134075f, 0.23795564f, 0.14317852f, -0.06813005f, -0.06097300f, 0.07137606f, -0.02265851f, 
    0.10390089f, -0.14374149f, -0.12947352f, 0.26636630f, 0.04570128f, -0.10664868f, -0.00527032f, -0.05343786f, 
    0.13375847f, -0.06961717f, -0.05391268f, 0.05960060f, 0.04596201f, 0.07876447f, 0.02322024f, -0.15295778f, 
    -0.12188537f, 0.04602571f, -0.07069889f, -0.09695090f, -0.15817125f, -0.14903241f, -0.60265255f, -0.04947725f, 
    0.16308053f, 0.23282860f, 0.13006838f, -0.21877989f, -0.04448897f, -0.01923139f, 0.44342726f, 0.05437034f, 
    0.08478201f, 0.00782421f, -0.05442371f, -0.05146610f, 0.07229513f, -0.17175689f, 0.00039087f, -0.15467623f, 
    0.01634003f, 0.19764179f, 0.07871180f, 0.13588192f, -0.08474446f, -0.03985993f, 0.02668513f, 0.13378011f, 
    -0.15896374f, -0.30767375f, -0.01998319f, 0.11011206f, 0.14480306f, -0.01645355f, -0.08437198f, 0.04625308f, 
    0.03072997f, -0.11567387f, -0.32779026f, -0.22732076f, -0.01911252f, -0.10017041f, 0.00450455f, 0.07749064f, 
    -0.02317222f, 0.11464388f, 0.13302103f, -0.21819384f, 0.39047623f, -0.05907268f, 0.16897914f, 0.04319002f, 
    0.27842447f, -0.38751265f, -0.01155604f, 0.29679134f, 0.28851610f, -0.20066251f, -0.02119639f, -0.07376364f, 
    0.02924040f, -0.01526595f, 0.09395296f, 0.08220514f, -0.12491652f, 0.04287347f, 0.10433258f, -0.10267792f, 
    0.10937587f, 0.16631122f, 0.04299882f, 0.23557648f, -0.10431495f, -0.18863037f, -0.34956443f, -0.05989322f, 
    0.06174075f, -0.17045210f, 0.03387766f, 0.08667628f, -0.04454403f, 0.09930165f, -0.18295453f, 0.05726375f, 
    -0.32701102f, -0.09245004f, -0.18760073f, 0.13132203f, 0.01121750f, -0.18371922f, -0.16641465f, -0.23069395f, 
    0.08809758f, 0.10895712f, 0.16341430f, -0.06880488f, -0.08441348f, 0.02899943f, 0.01373807f, 0.03418160f, 
    0.14846730f, 0.17098337f, -0.00348054f, -0.00586070f, 0.03062366f, -0.06042848f, 0.00326631f, 0.04976542f, 
    0.14526710f, 0.01496552f, 0.22691542f, 0.31869188f, 0.03998753f, 0.10758685f, -0.11916100f, 0.03760357f, 
    0.09100212f, 0.06294002f, -0.00689514f, -0.16692637f, -0.08698687f, -0.15765053f, -0.11554532f, 0.16202435f, 
    -0.00025092f, -0.13350917f, -0.39166322f, -0.20263335f, -0.11018221f, -0.03113712f, -0.10329287f, 0.02629010f, 
    -0.00527613f, -0.01628177f, 0.00651965f, 0.15704371f, -0.29432869f, -0.19048415f, 0.09583922f, 0.02278831f, 
    0.12586883f, -0.00367502f, 0.23442356f, 0.08087391f, 0.24403395f, 0.05077628f, -0.10385365f, 0.16252229f, 
    0.00825215f, 0.18592063f, -0.07507674f, 0.04910136f, 0.01851414f, 0.04953870f, 0.29726136f, -0.10780478f, 
    -0.07547531f, -0.04107747f, -0.11712691f, -0.11742996f, 0.01466244f, -0.01478329f, 0.19263712f, 0.05257994f, 
    0.10254852f, 0.17474648f, 0.13027990f, 0.02591947f, -0.09851031f, -0.03866170f, 0.23945393f, 0.04266287f, 
    0.01766071f, -0.26439482f, -0.04035561f, 0.14473253f, 0.00910752f, 0.00243579f, -0.14633656f, 0.11207666f, 
    0.20804980f, 0.15596190f, -0.07708910f, 0.19777471f, -0.13034911f, 0.02442398f, 0.07573840f, -0.00939701f, 
    0.10784817f, -0.18151878f, 0.03364208f, -0.15324582f, 0.00855493f, 0.16015078f, -0.03323790f, -0.06209157f, 
    -0.12852909f, 0.15374717f, 0.08568454f, -0.03582121f, 0.01394810f, 0.08569150f, -0.02102029f, -0.04754618f, 
    0.09161083f, -0.04574417f, 0.05536994f, -0.04453068f, -0.03314480f, 0.13878810f, -0.30751166f, 0.06632259f, 
    -0.10563739f, -0.07519976f, -0.03714572f, 0.05970422f, -0.11813837f, 0.08543532f, 0.00498959f, -0.04571065f, 
    0.03424155f, -0.11339179f, 0.09154116f, -0.01233051f, 0.02415487f, 0.08025954f, 0.30313593f, -0.00751086f, 
    -0.19370914f, 0.06493631f, 0.06106358f, -0.10469120f, -0.02944846f, -0.02820771f, -0.46001595f, -0.10800762f, 
    0.11747263f, 0.15786974f, -0.05826101f, -0.24310212f, 0.09662126f, 0.03699262f, 0.10662584f, -0.04191210f, 
    -0.12760733f, -0.15994227f, -0.00599825f, 0.05963803f, -0.15937251f, 0.05755370f, 0.22281277f, -0.11721016f, 
    -0.15552752f, 0.05496491f, -0.25089985f, -0.20263657f, -0.00093234f, -0.10759681f, -0.17422324f, 0.09092955f, 
    -0.12295567f, 0.62479103f, 0.11266021f, -0.03547550f, -0.13935126f, -0.08313636f, -0.07463618f, -0.02421970f, 
    0.01810284f, -0.09795002f, 0.51689178f, 0.18277100f, 0.01421837f, 0.18756811f, -0.06188484f, 0.09372341f, 
    0.09887154f, 0.06954862f, -0.12726122f, 0.24395202f, 0.18209617f, 0.08092884f, 0.09362874f, -0.03168152f, 
    -0.05103511f, 0.05761022f, -0.02790373f, -0.02877694f, -0.04623872f, -0.05357333f, -0.26034179f, -0.04253936f, 
    -0.24932988f, -0.06726404f, 0.11113086f, 0.26476160f, 0.13706793f, 0.04178640f, 0.08397546f, 0.35070324f, 
    -0.00205026f, -0.13152406f, -0.00665305f, 0.06060136f, 0.09393761f, 0.01251077f, 0.18019208f, 0.12580450f, 
    0.04598784f, 0.03851863f, 0.07757710f, -0.15815328f, -0.00186582f, -0.02017248f, -0.20226246f, -0.18921579f, 
    0.21285951f, 0.26107922f, 0.19546579f, -0.01089124f, 0.05084869f, -0.12129891f, -0.09374166f, 0.11570653f, 
    0.06281386f, -0.11165248f, 0.25505465f, 0.07168684f, 0.03832163f, 0.08894635f, 0.07170229f, -0.01084008f, 
    0.17549291f, 0.13694720f, 0.25597510f, -0.17705010f, -0.09186225f, -0.06283912f, 0.04752279f, -0.14818206f, 
    -0.01879264f, -0.02604733f, 0.01878088f, 0.10600815f, 0.12292365f, 0.07349721f, 0.03367868f, -0.00741488f, 
    -0.10674898f, 0.03303535f, 0.02673431f, 0.34191436f, -0.30036741f, -0.16740939f, -0.26089278f, 0.00057187f, 
    -0.07344611f, -0.08299118f, -0.11069690f, -0.15581863f, 0.27456945f, -0.03404498f, 0.23951402f, -0.19364873f, 
    -0.02080655f, 0.18805510f, 0.12425458f, -0.03657581f, -0.23316051f, 0.02922112f, 0.13502917f, -0.20801538f, 
    0.19652730f, 0.17313282f, -0.05832135f, -0.00095607f, -0.02066414f, 0.19554614f, 0.13120967f, -0.00289081f, 
    0.13326311f, -0.12551336f, -0.16703439f, -0.01594293f, 0.02064527f, -0.00977098f, -0.04865158f, -0.31995121f, 
    -0.03531102f, -0.02238144f, 0.00201157f, 0.02303189f, 0.03680830f, 0.06723164f, 0.11947356f, 0.04818160f, 
    -0.10853046f, 0.10730656f, -0.10620233f, -0.13305727f, 0.08684613f, -0.17311242f, 0.08781306f, 0.07007395f, 
    0.01636420f, 0.02358259f, 0.11578523f, 0.24739574f, 0.12514289f, 0.16025090f, 0.11084335f, -0.06606980f, 
    0.05238913f, 0.16531217f, 0.47838354f, 0.14835940f, 0.27271825f, 0.24945182f, -0.07743812f, -0.06132739f, 
    0.11990052f, -0.00765795f, 0.06103299f, 0.01546542f, -0.01980902f, -0.05635345f, -0.20387629f, 0.12683249f, 
    -0.00614909f, 0.04715461f, 0.05101875f, 0.05419340f, 0.20781833f, -0.07093479f, -0.02634981f, -0.14767833f, 
    -0.03053092f, 0.15624560f, 0.09033622f, 0.20056596f, -0.25174287f, 0.11219564f, 0.20686826f, 0.22862972f, 
    0.07043174f, -0.07812881f, 0.14141305f, -0.00586031f, -0.03152405f, -0.23064119f, -0.44228455f, -0.01977552f, 
    -0.23022325f, -0.07929916f, -0.06066503f, -0.19943732f, -0.09810346f, -0.08219738f, -0.07144310f, -0.11271638f, 
    -0.25975108f, 0.15168373f, 0.09360371f, -0.10745596f, 0.12622625f, -0.09309242f, 0.03631599f, -0.03318676f, 
    -0.36361262f, -0.08207072f, -0.33736554f, -0.03839054f, 0.00979829f, 0.08657794f, 0.07620663f, -0.10770188f, 
    0.22451060f, -0.08290386f, 0.04548392f, -0.18432602f, 0.04970915f, 0.01764579f, -0.04758906f, 0.21146859f, 
    0.07085556f, -0.10284704f, -0.15451396f, -0.03721317f, -0.05411444f, -0.03934542f, 0.20545775f, -0.17087483f, 
    0.10789549f, 0.02319872f, -0.04393179f, 0.05676559f, 0.11130656f, -0.06064745f, -0.10181579f, 0.10824922f, 
    0.22216545f, 0.01293143f, -0.14266975f, 0.09591580f, 0.13221996f, 0.06783366f, -0.00915487f, 0.01937485f, 
    0.27127135f, -0.10186008f, 0.13655691f, 0.12079739f, 0.08933702f, -0.34800729f, -0.14006872f, 0.04450947f, 
    -0.02247845f, 0.05062203f, -0.16641745f, -0.12003405f, 0.10648998f, -0.20828973f, 0.00808662f, 0.21091694f, 
    0.18505967f, -0.00811086f, 0.01747461f, 0.07528506f, -0.07060494f, 0.03006855f, 0.15833053f, -0.12878957f, 
    0.14421993f, 0.27070004f, -0.04304877f, 0.01721605f, -0.11279452f, -0.01942719f, 0.11907139f, 0.09548917f, 
    -0.01527124f, -0.01813133f, 0.18631862f, 0.01153628f, 0.03230625f, 0.03214671f, 0.15831828f, -0.04416315f, 
    0.15241967f, 0.00453466f, -0.21535800f, 0.02247744f, -0.22777258f, 0.08591329f, -0.01055474f, 0.22886391f, 
    -0.12367394f, -0.17106597f, 0.08525246f, -0.13410014f, -0.37645105f, -0.16130628f, 0.15269415f, -0.03333238f, 
    0.10925074f, 0.11551465f, -0.00494256f, -0.06039626f, 0.13840918f, 0.03413298f, 0.04722830f, -0.02474280f, 
    -0.19509146f, 0.03361879f, -0.00914176f, 0.06326781f, 0.13427204f, -0.05966270f, -0.31816950f, 0.05749766f, 
    0.06928278f, 0.06778012f, -0.04024877f, 0.15404345f, -0.09941227f, -0.39772153f, -0.01503331f, 0.01156360f, 
    0.09154505f, -0.02764407f, 0.09188122f, -0.00014240f, 0.11467364f, -0.04867091f, 0.02971182f, 0.17389144f, 
    0.21464662f, 0.03341271f, -0.18699779f, 0.03599038f, 0.20413171f, 0.16585632f, 0.01075467f, -0.00660505f, 
    0.07313391f, -0.21905796f, 0.00007679f, 0.21869142f, 0.10284854f, 0.12051314f, -0.19850615f, -0.15692708f, 
    -0.23325351f, -0.18888131f, -0.21233684f, 0.02122629f, 0.12212507f, -0.08667916f, 0.12103373f, 0.09867324f, 
    -0.00425916f, -0.06637852f, -0.52810985f, -0.48605385f, -0.05447378f, 0.00158069f, -0.03838196f, 0.01946138f, 
    -0.18908568f, -0.20124876f, 0.00891942f, -0.10080300f, -0.35238618f, -0.08801429f, 0.07868475f, 0.11533397f, 
    -0.12429791f, 0.00124361f, -0.01057649f, -0.04438974f, 0.02450756f, -0.10885723f, 0.03985770f, 0.09018642f, 
    0.08473178f, -0.00293638f, -0.14016750f, 0.12017556f, -0.00721808f, -0.43367150f, 0.03355110f, 0.11710289f, 
    -0.03572949f, 0.02521829f, -0.10713440f, -0.28064689f, 0.02879397f, 0.03260002f, -0.27885726f, -0.10430083f, 
    0.02779625f, -0.01434641f, 0.00772597f, 0.06273211f, -0.05454985f, -0.11428156f, 0.13259068f, 0.12182651f, 
    0.01372943f, -0.06783956f, 0.03719449f, 0.14598787f, -0.14919642f, 0.11247630f, 0.09514684f, -0.14422241f, 
    0.02134518f, 0.18106639f, -0.03242035f, -0.14817163f, -0.02879586f, -0.21219066f, 0.07539333f, -0.01812909f, 
    -0.02803303f, 0.15354735f, 0.34149331f, -0.00819373f, 0.01703378f, 0.00828704f, -0.06282403f, 0.09441347f, 
    -0.05063153f, -0.18637571f, 0.21886829f, -0.18176098f, 0.06724912f, -0.04445237f, 0.03561758f, 0.13313447f, 
    0.00595737f, -0.03266411f, -0.35165772f, -0.10325572f, -0.31472102f, 0.06504577f, 0.10841493f, -0.10070489f, 
    0.07280541f, -0.00410093f, 0.09119707f, -0.03439376f, 0.03080231f, -0.04565725f, 0.15927038f, -0.05156572f, 
    0.08554082f, 0.16695493f, -0.23054764f, 0.21932617f, -0.22110792f, -0.10718774f, 0.05023636f, 0.00722645f, 
    0.13248993f, 0.02296894f, 0.03628545f, -0.07803760f, 0.14321472f, -0.14221475f, 0.32913300f, -0.17129429f, 
    0.04547256f, 0.06103212f, 0.00582708f, 0.05694706f, 0.05866096f, 0.07252979f, -0.03296062f, 0.11948760f, 
    0.25196749f, -0.01995385f, -0.23769830f, 0.09753373f, -0.02443697f, -0.01030144f, 0.13983238f, 0.07903890f, 
    0.10464049f, -0.01704505f, 0.07488570f, 0.14559808f, -0.01190349f, 0.07091510f, 0.06997757f, 0.02295616f, 
    0.04711727f, -0.01450401f, 0.00788572f, -0.05872844f, -0.00095734f, -0.03673070f, -0.06021397f, -0.05864269f, 
    -0.00632735f, -0.05152469f, 0.04483328f, -0.06635317f, -0.02926909f, -0.06478177f, -0.06147336f, -0.01730953f, 
    -0.06675953f, 0.02572746f, -0.01113969f, -0.00185006f, 0.03402660f, -0.03254545f, 0.02793805f, -0.03982961f, 
    0.00030380f, 0.03187547f, -0.05945098f, -0.03239693f, 0.04144954f, -0.00920457f, -0.01877000f, 0.02789703f, 
    0.01200754f, -0.06600580f, 0.04825289f, 0.01279384f, -0.04998336f, 0.04031328f, -0.02233417f, -0.06110261f, 
    -0.06880771f, 0.00947687f, -0.05600521f, 0.02111947f, 0.00637783f, -0.05315419f, 0.01730014f, -0.05526275f, 
    0.02845409f, -0.04050078f, -0.02554808f, 0.02414264f, -0.03914560f, -0.00592136f, 0.04685187f, 0.03108886f, 
    -0.04534420f, -0.03088975f, 0.02680878f, -0.06620006f, -0.05080574f, 0.01173295f, -0.03737455f, 0.04259768f, 
    0.02604145f, -0.06773183f, -0.00246934f, 0.04412966f, -0.00172159f, 0.04288577f, 0.01156887f, -0.01397473f, 
    0.03867462f, -0.05070007f, 0.03553566f, -0.01663637f, -0.03672999f, -0.05569874f, -0.04210246f, 0.04256596f, 
    -0.05766318f, 0.01869551f, -0.00228940f, -0.01193083f, 0.03383626f, -0.00565583f, -0.01416453f, 0.05251392f, 
    -0.04976169f, -0.02232964f, -0.04061441f, 0.04276691f, -0.02731076f, 0.00790544f, -0.02784453f, 0.00183723f, 
    0.00649337f, 0.03844354f, -0.05297884f, -0.02393844f, -0.01874258f, 0.03629424f, 0.00998576f, -0.06492323f, 
    0.02349770f, -0.05652991f, -0.00872495f, -0.04606305f, -0.01367965f, -0.01720076f, -0.03440387f, -0.00451282f, 
    -0.04787019f, 0.00593123f, -0.04914967f, 0.02089215f, 0.00367396f, 0.01667883f, -0.06481611f, -0.01564375f, 
    -0.00310087f, -0.04274106f, 0.00216276f, 0.02270238f, 0.01647186f, -0.00033654f, 0.01966481f, -0.00463652f, 
    -0.00666708f, -0.05594959f, -0.04952248f, -0.06444645f, -0.04944871f, 0.02213143f, 0.04297075f, 0.00774334f, 
    0.04200456f, -0.03320849f, 0.02662455f, -0.05281691f, -0.06125614f, 0.02472372f, -0.00983679f, 0.00575393f, 
    0.01925765f, -0.04638413f, -0.02962701f, -0.04619066f, -0.00684515f, -0.04060943f, 0.02661005f, 0.03644150f, 
    0.01091840f, -0.04424343f, -0.06544765f, -0.01866795f, 0.04213123f, 0.02894947f, 0.04789295f, -0.03654544f, 
    -0.01610931f, 0.03364953f, 0.00053430f, -0.04535887f, -0.05923992f, 0.01002193f, 0.05209447f, 0.00694074f, 
    -0.03181033f, 0.01328763f, 0.00607515f, 0.05420751f, 0.00156870f, -0.00110261f, 0.03359500f, -0.06182872f, 
    0.01955344f, 0.00491480f, 0.03142384f, 0.00070967f, 0.01288398f, -0.05614860f, -0.06415111f, 0.03617682f, 
    -0.03735733f, -0.03801011f, 0.04285570f, 0.02997259f, 0.02984835f, 0.02882359f, -0.00282101f, 0.03503496f, 
    -0.06154864f, 0.04239162f, 0.02094385f, 0.00555350f, 0.03828101f, 0.02958533f, 0.04577342f, -0.00922218f, 
    0.03525428f, -0.05653781f, -0.03843542f, -0.05975201f, 0.02406284f, -0.06852011f, 0.02456866f, -0.02835378f, 
    0.03593672f, -0.06204700f, 0.04515487f, 0.01281911f, -0.02588700f, 0.02729614f, 0.00581016f, -0.03632703f, 
    -0.00813783f, -0.02660942f, -0.03602626f, 0.03258187f, -0.02665403f, 0.02483935f, 0.01693974f, -0.01820584f, 
    0.03951151f, 0.04875420f, 0.03019777f, -0.04283148f, -0.04260437f, -0.00894798f, 0.03964126f, 0.04056495f, 
    -0.06795021f, -0.03168577f, 0.00342222f, -0.05060373f, -0.04111059f, -0.05732524f, 0.02471996f, -0.03190417f, 
    0.00864503f, -0.06044806f, 0.02079632f, -0.01554545f, -0.02061748f, 0.01643738f, -0.00967590f, -0.05469308f, 
    -0.04559539f, 0.01297683f, -0.04618113f, 0.02593333f, -0.05319837f, -0.04882891f, 0.01653444f, 0.04611296f, 
    -0.04820627f, -0.01330649f, 0.04093980f, -0.04242817f, -0.04364958f, 0.00200000f, -0.00159800f, -0.02664991f, 
    -0.02523601f, -0.01133713f, -0.00202705f, -0.03759842f, 0.02819598f, -0.06864257f, -0.06183921f, 0.01739928f, 
    -0.04448167f, -0.00281038f, 0.04542824f, -0.02207645f, 0.03438383f, -0.02545094f, 0.02924087f, 0.00313380f, 
    -0.04697579f, 0.03122699f, -0.06068884f, -0.02878669f, 0.00506654f, -0.06092265f, 0.05122540f, 0.02833279f, 
    -0.01967101f, -0.02938362f, -0.01707898f, 0.00494294f, -0.05051139f, -0.02321928f, -0.04192992f, 0.04583336f, 
    0.00058597f, 0.03484458f, -0.06213365f, 0.01330544f, -0.05307185f, 0.00781626f, -0.00743519f, 0.00808947f, 
    -0.02092090f, -0.01976349f, -0.06832519f, 0.03356785f, -0.01752231f, -0.03086214f, -0.03825443f, -0.04288051f, 
    -0.07942584f, -0.05628293f, -0.07605337f, -0.05688861f, 0.00368184f, -0.05227343f, -0.04207177f, -0.01612087f, 
    0.03176751f, 0.02297221f, 0.01089164f, -0.02817479f, 0.01252803f, -0.05106254f, -0.06839899f, -0.01679143f, 
    0.02663482f, -0.02149010f, 0.03668521f, -0.02751798f, -0.01518492f, -0.03655649f, 0.03905145f, 0.03698292f, 
    0.03705116f, -0.04974431f, -0.04487970f, -0.06044985f, 0.00343076f, -0.01810920f, 0.01062321f, -0.07623013f, 
    -0.04294923f, -0.06698152f, -0.02792923f, -0.01825536f, 0.00549826f, -0.04899939f, -0.01696412f, -0.03131068f, 
    0.02195005f, 0.02606626f, -0.03404985f, 0.00085842f, -0.01858986f, 0.01717320f, -0.03495517f, -0.01896464f, 
    -0.03506365f, 0.02950696f, 0.00286294f, -0.03437231f, -0.05899634f, -0.06709960f, -0.05440630f, 0.02443761f, 
    -0.08346890f, -0.03167014f, 0.03728117f, -0.02628312f, -0.02104186f, 0.03547424f, -0.07048643f, -0.07834902f, 
    -0.06291535f, -0.06348578f, -0.03818247f, 0.00597732f, 0.00250640f, 0.00257639f, -0.03518144f, 0.00184757f, 
    -0.07792773f, -0.06770574f, -0.02480365f, -0.01921868f, -0.00049452f, -0.02421899f, -0.04294408f, -0.01108060f, 
    -0.02821871f, -0.01160267f, 0.04006356f, 0.03814475f, -0.02870169f, -0.02286345f, 0.03030071f, 0.03649169f, 
    0.03792673f, -0.04110112f, -0.04490554f, -0.08760525f, 0.05671106f, 0.01542288f, -0.00184429f, 0.05465729f, 
    -0.00391407f, -0.00037601f, 0.01164483f, 0.03338762f, -0.03918700f, 0.03241258f, 0.01383922f, 0.00011735f, 
    -0.00232826f, -0.05162581f, -0.00704381f, -0.03948128f, -0.03422854f, -0.01864842f, -0.00184201f, 0.02759928f, 
    -0.00267001f, -0.02114286f, 0.00093992f, -0.06176988f, 0.01905806f, 0.00586558f, -0.05686489f, -0.05925504f, 
    -0.04153242f, -0.01782339f, 0.00242469f, -0.04189982f, 0.01037633f, 0.01417984f, 0.02666732f, -0.04618719f, 
    0.02752622f, 0.06868099f, -0.05900845f, 0.01029712f, 0.01757239f, 0.03137381f, -0.07452396f, -0.04438637f, 
    0.02138316f, 0.01200453f, 0.00714785f, 0.04180827f, -0.04491851f, -0.02677779f, -0.07183561f, 0.01092798f, 
    -0.07791672f, -0.03399925f, 0.03398583f, -0.02633773f, 0.01660918f, -0.05564277f, 0.05205880f, -0.08091099f, 
    -0.02936923f, -0.00932321f, -0.01752119f, 0.03156052f, -0.02413994f, -0.01015864f, 0.00412595f, 0.02094050f, 
    -0.02879001f, 0.01207517f, -0.02646771f, -0.04701413f, -0.03440527f, 0.03728415f, 0.00740305f, -0.08432986f, 
    0.05995375f, 0.03518794f, -0.03021643f, -0.06830557f, -0.00888967f, -0.02500160f, 0.02676462f, -0.02048537f, 
    -0.07253084f, -0.02564952f, 0.00519462f, -0.04413686f, 0.00368178f, 0.00989119f, -0.06863455f, -0.03001446f, 
    0.01111838f, -0.08038744f, -0.02662457f, -0.06629357f, -0.01480335f, -0.05084793f, -0.00701634f, 0.02763804f, 
    0.00098512f, 0.02466480f, -0.02132612f, 0.02009688f, 0.00875479f, -0.04718548f, -0.01667906f, 0.03060994f, 
    -0.01677609f, 0.04100397f, 0.06535902f, 0.06224365f, 0.02799382f, -0.00096445f, 0.01572694f, -0.03100753f, 
    0.05108834f, -0.00754497f, 0.05906866f, 0.00797534f, 0.04514629f, 0.04126670f, -0.02650567f, -0.03851263f, 
    -0.01511683f, -0.05625292f, -0.05675428f, 0.03541015f, -0.05854373f, -0.02010875f, 0.02559670f, 0.03578694f, 
    -0.03927454f, -0.01427568f, 0.03475649f, -0.03064439f, 0.05710220f, -0.05552232f, -0.07274984f, 0.00104906f, 
    0.04404087f, -0.03841076f, -0.04334438f, -0.01736717f, -0.02756214f, -0.04567128f, -0.05382625f, 0.01083666f, 
    0.02940375f, 0.00486502f, 0.03544336f, -0.06783161f, -0.03226495f, 0.00654174f, -0.04326649f, -0.08197071f, 
    -0.06499609f, -0.03713430f, -0.03644777f, 0.01619378f, 0.00481228f, -0.01764674f, -0.04686549f, -0.04589418f, 
    0.01150595f, -0.06078839f, 0.00064184f, -0.01280816f, -0.01170365f, 0.03138024f, -0.01018186f, -0.06887526f, 
    0.13277124f, -0.10187587f, 0.29126066f, 0.05800238f, 0.01053218f, 0.07852821f, -0.09803659f, -0.09276572f, 
    0.15253283f, -0.00759702f, -0.16681592f, 0.09836038f, 0.10427231f, -0.14545994f, 0.08430956f, -0.12195586f, 
    0.23917376f, 0.03141339f, 0.35467455f, -0.24960433f, -0.00991875f, -0.15787388f, 0.12437210f, 0.16380408f, 
    -0.05067732f, 0.04589735f, -0.01146718f, 0.20960258f, 0.12924400f, -0.12869146f, 0.00452426f, 0.01368809f, 
    0.05888572f, 0.09736407f, -0.01295342f, 0.08060325f, 0.02778450f, 0.06641098f, 0.29534936f, -0.22864777f, 
    0.10214658f, -0.08924624f, 0.01659897f, 0.01243618f, 0.09975995f, -0.13578673f, -0.27685264f, -0.08624028f, 
    -0.24200067f, -0.03717269f, -0.11964178f, 0.11229638f, 0.05519634f, -0.03504861f, 0.14030871f, 0.03655275f, 
    -0.02847241f, -0.31948552f, -0.10080996f, 0.06445404f, -0.02475593f, 0.09662043f, 0.09564602f, 0.07318363f, 
    0.21761997f, 0.16937603f, -0.14885230f, -0.01662936f, -0.04592502f, 0.26395878f, -0.08299739f, -0.06899151f, 
    -0.07697185f, -0.10392604f, 0.22950704f, -0.04792898f, -0.09496773f, -0.01097449f, 0.03300199f, 0.14208017f, 
    0.07084912f, -0.11542789f, -0.50696099f, -0.07050473f, 0.07570181f, 0.18705501f, 0.11805622f, -0.24808048f, 
    0.10607326f, -0.20044200f, -0.19422722f, -0.04884742f, 0.32821256f, 0.05200733f, 0.22228031f, -0.03773741f, 
    -0.02872612f, 0.15772171f, -0.14766325f, -0.03151294f, -0.07100782f, -0.05748376f, -0.12087847f, -0.04398593f, 
    -0.08096298f, 0.18893330f, 0.31111270f, -0.15265985f, 0.03233066f, 0.08618774f, -0.32655981f, -0.13223840f, 
    -0.02253480f, -0.05229089f, -0.26398543f, 0.19763769f, 0.10073411f, -0.13590342f, 0.18143605f, -0.26403543f, 
    -0.11966724f, -0.05036428f, -0.01096999f, -0.12438346f, 0.14633001f, 0.07346741f, 0.32676479f, 0.11998319f, 
    0.03856034f, -0.00850024f, -0.19104655f, -0.08116716f, -0.16073576f, 0.04383532f, 0.01183875f, -0.00500249f, 
    -0.11931442f, -0.22364981f, 0.04729933f, 0.09835770f, -0.00593513f, -0.10968355f, 0.09558611f, -0.13222381f, 
    0.42100871f, 0.09946173f, -0.11738876f, -0.06440927f, 0.13341896f, -0.00205270f, 0.17559560f, 0.01841932f, 
    -0.13137153f, -0.14709367f, -0.45063096f, 0.22118016f, 0.09743633f, 0.12116782f, -0.09498058f, 0.08646087f, 
    -0.03031718f, -0.15541102f, 0.28110012f, 0.37902290f, -0.43348807f, 0.14227442f, 0.14774591f, 0.00794293f, 
    -0.02495195f, -0.05419829f, -0.16391660f, -0.16604608f, -0.30409425f, -0.12253756f, -0.15846576f, 0.07317209f, 
    -0.16231064f, -0.03705034f, -0.07136677f, -0.06146492f, 0.14973685f, -0.00198232f, -0.04460267f, 0.06166411f, 
    0.03612382f, -0.21946038f, 0.20416576f, -0.09721722f, 0.02515196f, 0.16762114f, -0.06473197f, -0.39438847f, 
    0.15380575f, 0.11276578f, 0.05967868f, 0.04843254f, -0.01682618f, -0.07373760f, 0.06034277f, 0.02600043f, 
    0.03788950f, -0.08586282f, -0.01333370f, 0.13234787f, 0.06096182f, 0.18852980f, 0.18901026f, 0.01100258f, 
    -0.16350049f, 0.17905138f, -0.17799270f, 0.00613742f, -0.06964868f, 0.01046841f, 0.14921232f, -0.03944087f, 
    0.00720370f, 0.11037284f, 0.10176857f, -0.05274085f, -0.11044083f, 0.19648220f, -0.05347733f, 0.15732440f, 
    0.03791998f, 0.22819068f, 0.24108064f, -0.25157031f, 0.09593672f, 0.07657488f, -0.00644841f, 0.24685685f, 
    -0.06557523f, -0.09839343f, 0.33029810f, -0.32552934f, 0.39701197f, -0.16924088f, 0.15993419f, 0.05673142f, 
    -0.13551411f, -0.02105614f, -0.11709142f, 0.14400132f, 0.02831812f, 0.03322616f, 0.03913270f, 0.00093154f, 
    0.15015754f, -0.03264443f, -0.06626880f, 0.14694877f, -0.36693451f, -0.12835161f, 0.01278754f, 0.06097449f, 
    0.08965687f, -0.06805675f, 0.06570660f, 0.03957245f, 0.05929849f, -0.44936699f, -0.17878670f, -0.17971760f, 
    -0.18234265f, -0.07847933f, -0.10891078f, -0.04546299f, -0.07558194f, 0.09068687f, 0.35841894f, 0.21342936f, 
    0.14817756f, -0.15176691f, -0.27658194f, -0.00860256f, -0.16862087f, -0.03285995f, 0.08551088f, -0.05899415f, 
    -0.13990358f, -0.09296069f, 0.19913094f, 0.07463815f, 0.10299843f, 0.01890995f, 0.13138650f, -0.08649506f, 
    0.00030794f, 0.05267036f, -0.05903200f, 0.02074707f, -0.01644498f, 0.02530578f, -0.02834593f, 0.02156307f, 
    -0.05729813f, -0.05193761f, -0.04393667f, -0.03804782f, -0.05680324f, 0.00442754f, 0.01142632f, -0.02662003f, 
    0.02144333f, -0.02475597f, -0.01201380f, -0.00933971f, -0.05832632f, 0.03749869f, -0.00138106f, -0.02848683f, 
    0.01017859f, -0.06442765f, -0.04995228f, -0.05659779f, -0.05113529f, -0.04075239f, 0.03115360f, -0.03375740f, 
    0.00321766f, -0.04585104f, 0.01211543f, -0.04531587f, -0.05244617f, 0.00023816f, 0.05060215f, 0.00057681f, 
    0.01470633f, 0.02944779f, -0.01675956f, 0.04955762f, -0.02181395f, 0.01066179f, -0.01097458f, 0.00248390f, 
    -0.05263807f, 0.02334594f, 0.01600737f, 0.00705080f, -0.00439052f, 0.01547635f, 0.03755582f, 0.04911613f, 
    0.05010287f, -0.05496716f, -0.05164869f, -0.04336121f, 0.01941176f, 0.01436746f, -0.01829061f, -0.05341012f, 
    0.01414156f, 0.03005919f, -0.01604930f, -0.05303967f, -0.00004934f, 0.04820566f, -0.05582947f, 0.01720956f, 
    0.02745304f, -0.04444887f, 0.04165509f, 0.01573148f, -0.04092994f, -0.05326015f, 0.02037536f, 0.03690838f, 
    0.03094995f, -0.01595732f, 0.01793267f, 0.02550968f, 0.05561031f, 0.04717240f, -0.03514303f, 0.04618930f, 
    0.01318547f, -0.01778253f, -0.03597804f, -0.06374989f, -0.01144195f, -0.00981145f, -0.03993585f, -0.02430706f, 
    -0.03987863f, 0.03042021f, -0.02589042f, -0.04890695f, -0.05214157f, -0.02506987f, 0.02347141f, 0.03841829f, 
    0.03510494f, -0.04101568f, -0.02591842f, -0.02853671f, -0.01783290f, -0.03926673f, 0.03299496f, -0.06230485f, 
    0.03593158f, 0.02190776f, -0.05463139f, -0.02049439f, -0.03164660f, 0.02894776f, -0.01932754f, 0.00016222f, 
    -0.04750139f, -0.05671785f, 0.04022261f, -0.05451221f, -0.02504873f, -0.03848760f, -0.05891727f, 0.00832537f, 
    0.01946441f, 0.01421614f, 0.01679782f, 0.04984316f, 0.00762943f, 0.01916916f, -0.01594188f, 0.03286349f, 
    -0.04817180f, 0.00538592f, -0.04916192f, -0.02554430f, 0.00787838f, -0.01650231f, -0.00751271f, -0.02136152f, 
    -0.03315277f, -0.00565315f, 0.04051813f, 0.03823771f, -0.02915584f, -0.01459017f, 0.02169220f, -0.04335582f, 
    -0.04181897f, -0.02787508f, 0.01923336f, -0.03103334f, -0.04308761f, 0.04386046f, -0.05252633f, 0.00808578f, 
    0.03653508f, 0.02036836f, 0.04117874f, 0.04259558f, -0.05010803f, 0.04732158f, 0.01697088f, -0.02745359f, 
    0.04410352f, -0.04354282f, -0.05573511f, -0.04465183f, 0.00003554f, -0.04157906f, -0.04558688f, 0.04303530f, 
    -0.01024103f, 0.00243465f, -0.06164235f, -0.03550158f, -0.00266677f, 0.03176367f, 0.04118437f, -0.03197549f, 
    0.00184280f, 0.00100750f, -0.00306636f, -0.02990836f, 0.04171602f, -0.05977733f, 0.03042742f, -0.04729220f, 
    -0.04959618f, -0.00072367f, -0.06079210f, 0.02281252f, -0.04652314f, -0.04147650f, -0.04035036f, -0.04829403f, 
    -0.00520824f, 0.01169780f, -0.05475592f, -0.06029297f, -0.01323468f, -0.05269575f, 0.03817830f, -0.05251673f, 
    -0.01359276f, 0.03883949f, -0.02432912f, 0.01882610f, -0.00622299f, -0.05787192f, -0.00141287f, -0.00643443f, 
    -0.03763821f, -0.03021794f, 0.04890245f, -0.03384989f, -0.04648596f, -0.04906062f, 0.00210590f, -0.05533963f, 
    0.04512621f, -0.05216974f, 0.04184531f, 0.01869877f, -0.04132950f, 0.00655404f, 0.05274362f, 0.02983134f, 
    -0.02973854f, 0.04991870f, 0.05028338f, -0.05894167f, -0.02226363f, 0.01766097f, -0.03431777f, 0.03350877f, 
    -0.02892832f, -0.03691026f, -0.00716517f, 0.03536366f, -0.01741075f, -0.03798531f, 0.04865572f, 0.01640248f, 
    0.00099465f, 0.02876499f, -0.06112460f, -0.02928378f, -0.00564532f, -0.02385253f, 0.02379927f, -0.05861246f, 
    -0.05279695f, -0.05000739f, 0.04790200f, 0.02665243f, -0.04034962f, 0.03472253f, 0.02433130f, -0.04158524f, 
    -0.05493560f, -0.03636185f, -0.03930857f, 0.00372470f, 0.05261997f, 0.00231622f, 0.01565613f, 0.00620953f, 
    0.05159842f, -0.04736675f, 0.01144797f, -0.04577631f, -0.06421135f, -0.03773580f, -0.03896034f, -0.02748455f, 
    -0.03606730f, -0.00748027f, -0.00203594f, 0.04475834f, -0.00184111f, 0.04518948f, 0.03691335f, 0.01257169f, 
    -0.53333074f, -0.15856615f, 0.00834680f, -0.06546406f, 0.11773907f, -0.17276272f, -0.16782577f, 0.21377045f, 
    0.09071907f, 0.11453101f, -0.22184139f, 0.10785456f, 0.08562413f, 0.12215333f, 0.07872865f, 0.15132138f, 
    -0.03586397f, -0.03940134f, 0.19378906f, 0.02273048f, 0.13655862f, 0.06375733f, 0.02411122f, -0.26323175f, 
    -0.12835118f, 0.05553869f, 0.02996874f, 0.03932365f, -0.09492942f, -0.16356248f, -0.15837169f, 0.21184602f, 
    0.18749908f, -0.12163896f, 0.00264394f, -0.01673381f, -0.06371526f, -0.01568859f, -0.00530960f, 0.14574875f, 
    -0.06838679f, -0.13915545f, 0.15856487f, -0.14731368f, 0.02945379f, 0.05668453f, -0.00151031f, -0.18015063f, 
    -0.06268150f, -0.00021418f, -0.18602134f, 0.01613714f, 0.14260060f, -0.09814595f, 0.03898415f, -0.11100204f, 
    -0.12408815f, 0.19270186f, -0.22197996f, 0.05976518f, 0.06682064f, 0.01621590f, 0.13536386f, -0.09608608f, 
    0.31290936f, 0.20828295f, 0.21460669f, 0.14513566f, 0.04460489f, -0.14942433f, -0.06882700f, 0.06197949f, 
    0.10249916f, 0.08522792f, 0.10552920f, 0.11403999f, 0.16210960f, 0.09334392f, 0.06277253f, 0.11687653f, 
    0.01734917f, -0.27725318f, 0.15964232f, -0.30431110f, -0.06829061f, -0.35021561f, 0.04264087f, 0.10002192f, 
    -0.07456009f, -0.08562274f, 0.25521216f, -0.23893014f, 0.02149625f, -0.21225466f, -0.05464439f, -0.00685802f, 
    0.07085542f, 0.04307432f, 0.04455985f, 0.12073664f, 0.22081630f, -0.07244997f, -0.08970106f, -0.08630558f, 
    0.17879309f, -0.03833081f, 0.13983923f, -0.10717746f, -0.33885258f, -0.31467852f, 0.27250180f, -0.16367991f, 
    -0.25933027f, -0.13779235f, 0.15388955f, -0.12423085f, 0.18044528f, -0.50932384f, -0.11049596f, -0.00189972f, 
    -0.08283535f, 0.05380787f, 0.06506250f, 0.19010198f, 0.03479447f, -0.06921030f, 0.10017128f, -0.01107641f, 
    0.06080273f, 0.08760733f, 0.02970749f, -0.04722123f, 0.00708820f, 0.05862278f, -0.01204820f, -0.06174831f, 
    -0.11007542f, -0.04608291f, 0.01202198f, 0.16198860f, 0.14387111f, -0.04090412f, -0.07015058f, -0.07745152f, 
    0.13164471f, 0.14525144f, -0.03159241f, 0.14136694f, -0.12144306f, -0.06107635f, 0.09968396f, -0.17122331f, 
    -0.18706934f, -0.21506637f, -0.11853676f, 0.26123139f, -0.18256526f, -0.16080351f, -0.06941390f, -0.12746648f, 
    -0.05839374f, 0.19528313f, -0.35750985f, -0.21891959f, -0.05701254f, -0.07524233f, -0.01789072f, -0.03956110f, 
    0.08992695f, 0.11161321f, -0.06693658f, 0.23920533f, 0.03687475f, -0.08095854f, 0.10022850f, 0.02098380f, 
    0.06788603f, 0.06839246f, -0.07694859f, -0.03775587f, -0.06411280f, 0.30861697f, 0.22848129f, -0.00445257f, 
    0.06213909f, 0.14081804f, 0.03032486f, 0.03826498f, -0.13168237f, 0.43739682f, 0.01419906f, -0.32035741f, 
    0.14957115f, -0.12282712f, -0.09230085f, -0.10817926f, -0.23900923f, -0.30268693f, -0.00733874f, -0.02467746f, 
    0.00101383f, -0.09560785f, -0.03915966f, 0.12991159f, 0.11147393f, 0.08713859f, 0.15937494f, -0.14004810f, 
    0.10834146f, 0.12936026f, 0.04404996f, 0.26460141f, 0.11549363f, 0.13679329f, 0.08135442f, 0.09215122f, 
    -0.12972641f, -0.18983562f, 0.07072252f, 0.20455661f, 0.03733408f, -0.04899107f, -0.06227886f, -0.00517338f, 
    0.06641228f, -0.10366977f, 0.04324752f, -0.09399313f, 0.09201226f, 0.22066365f, -0.04844438f, 0.07556333f, 
    -0.03867384f, 0.00761875f, -0.61971921f, -0.11330982f, 0.03542240f, -0.05388462f, 0.07988474f, -0.06030638f, 
    0.11995277f, -0.00108513f, 0.02141017f, 0.13407247f, 0.22877887f, -0.13971543f, -0.10092730f, 0.07531467f, 
    0.13820551f, 0.08754987f, 0.03542001f, 0.06456695f, 0.16919784f, 0.15680140f, -0.16874863f, -0.03073292f, 
    0.20379421f, 0.07808088f, -0.05667226f, 0.04125464f, 0.16907209f, -0.55467421f, -0.15920690f, 0.04772770f, 
    -0.10450862f, 0.21315263f, -0.17696923f, 0.07961527f, 0.23760329f, 0.06983665f, 0.15616247f, 0.04655556f, 
    0.05635758f, 0.06680962f, 0.03347697f, -0.05038249f, -0.10455574f, 0.13588005f, 0.01710503f, -0.06073931f, 
    -0.03710690f, -0.14758883f, -0.10541227f, 0.08615357f, 0.06025440f, -0.15969853f, 0.05902551f, 0.12820917f, 
    -0.01577220f, -0.03465065f, -0.03469527f, -0.07075872f, -0.02812146f, -0.01118597f, 0.08154584f, -0.08178062f, 
    -0.11472939f, -0.02602087f, 0.03413201f, -0.06921103f, -0.02730456f, 0.03345207f, 0.02754880f, 0.11048025f, 
    0.07809206f, -0.05521102f, -0.07696331f, -0.01816762f, -0.05084694f, -0.03467559f, 0.03092382f, 0.03991129f, 
    0.09652292f, 0.01038294f, -0.04981116f, -0.14202251f, 0.01534077f, 0.14471176f, -0.01185501f, -0.12527412f, 
    -0.05128853f, 0.11052806f, 0.03761178f, 0.02419806f, 0.08997497f, 0.06710260f, -0.06755292f, 0.03043987f, 
    0.02498068f, -0.06803504f, 0.04221597f, -0.09985618f, -0.07650555f, -0.00152347f, 0.04456806f, 0.02063151f, 
    -0.04604562f, -0.08153369f, -0.11646958f, -0.08951098f, -0.02024894f, -0.04681357f, -0.01911308f, 0.01789430f, 
    -0.11919159f, 0.07211964f, -0.05942520f, 0.03875986f, 0.03969589f, 0.02968670f, -0.00061113f, -0.00371346f, 
    0.01887944f, -0.07059459f, 0.01006979f, -0.06665784f, -0.01201331f, -0.03258348f, -0.07370456f, -0.07388976f, 
    0.02950946f, -0.04289459f, -0.06897453f, -0.08016547f, -0.03829757f, -0.03329704f, 0.04179688f, -0.15815912f, 
    -0.06198310f, -0.16454090f, 0.06356930f, -0.04147381f, 0.02895598f, 0.04320899f, 0.07189588f, 0.08710900f, 
    0.13808499f, 0.02207043f, -0.09078097f, 0.01116202f, 0.00884631f, -0.00915420f, -0.13760538f, -0.08556245f, 
    0.04742022f, 0.12261163f, 0.09860968f, -0.09464333f, -0.11775763f, -0.05817949f, 0.04958903f, -0.09502907f, 
    -0.02961183f, -0.05229687f, 0.09241197f, 0.05276475f, -0.08404147f, -0.12221659f, -0.10657334f, -0.00384451f, 
    -0.09256194f, -0.02560925f, 0.08799228f, 0.02186509f, -0.16214915f, 0.02257718f, -0.06459230f, 0.03698494f, 
    0.00980734f, -0.05361661f, -0.01536555f, 0.04379008f, 0.07628047f, -0.05845815f, -0.00188769f, -0.07689068f, 
    -0.02880906f, 0.01985226f, -0.08435867f, -0.04517129f, -0.15205869f, 0.03033292f, -0.02472220f, -0.12527627f, 
    -0.04545696f, 0.06058569f, -0.00845710f, -0.13687643f, -0.04890433f, -0.02080383f, 0.04205336f, -0.13265274f, 
    -0.05000368f, -0.02797729f, -0.08442227f, -0.01526158f, -0.12221471f, 0.01703072f, 0.14990883f, -0.02870352f, 
    -0.00272253f, -0.08712440f, 0.04834394f, 0.02228321f, -0.05060940f, -0.16994283f, -0.02512343f, -0.15001796f, 
    -0.09384049f, -0.02353478f, -0.05762163f, -0.01529414f, 0.03695715f, -0.20744769f, -0.07704797f, 0.00634375f, 
    0.08317110f, -0.03405365f, -0.08513693f, 0.02710158f, 0.00547113f, -0.05893230f, 0.04014563f, 0.01440219f, 
    0.02091711f, -0.04887185f, 0.00590971f, 0.10447253f, -0.08214929f, -0.04500581f, -0.15146434f, 0.04655671f, 
    -0.08804226f, -0.00893142f, -0.02585252f, -0.04281899f, -0.01582609f, -0.08960069f, -0.02252673f, 0.00485227f, 
    0.00632585f, 0.02831314f, -0.05474328f, 0.11160691f, -0.11838093f, -0.02376592f, -0.14359364f, 0.07314792f, 
    0.01579641f, -0.01142912f, -0.06970155f, -0.11018259f, -0.17595957f, 0.08286116f, -0.12157539f, 0.02993538f, 
    0.07161449f, 0.00133374f, -0.04410476f, -0.06239940f, -0.03518840f, 0.02283162f, -0.02671549f, -0.00767270f, 
    0.00975902f, -0.02077241f, -0.02209555f, -0.00578447f, -0.03909738f, 0.06721349f, 0.02735124f, 0.07784133f, 
    -0.06187927f, -0.06615080f, -0.07724184f, 0.07872705f, -0.06132847f, -0.06987311f, -0.00488228f, 0.10201672f, 
    -0.09938346f, -0.05692298f, -0.07030999f, -0.08817936f, 0.02090337f, -0.13609912f, -0.06700169f, 0.01518443f, 
    0.12182961f, -0.02578760f, -0.08930810f, -0.05139794f, -0.04815264f, 0.02456764f, -0.02124353f, -0.08245014f, 
    0.00618442f, 0.06436191f, -0.02646292f, -0.03361144f, -0.05883915f, -0.11245288f, 0.03694442f, 0.05215519f, 
    -0.11371203f, -0.03943867f, 0.08626544f, -0.05506095f, 0.04783351f, 0.02770965f, -0.03326384f, -0.00255924f, 
    -0.13329037f, -0.01156073f, -0.07948057f, 0.13414855f, -0.03061702f, -0.02993529f, 0.01140839f, -0.00692444f, 
    -0.01800204f, 0.02289663f, -0.01540739f, 0.04341750f, -0.04952366f, 0.00280432f, -0.00730115f, -0.07355577f, 
    -0.15248685f, 0.01722452f, -0.01395471f, -0.09281075f, -0.09506336f, 0.03046642f, 0.15269364f, -0.09726415f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09488449f, 0.03498160f, 0.00296947f, 0.02802089f, -0.04722494f, 0.12837966f, 0.02811247f, -0.04795618f, 
    -0.06517956f, 0.04668908f, -0.02626564f, -0.03765344f, -0.02174114f, -0.02024666f, 0.13756868f, 0.08132190f, 
    -0.05349335f, -0.03984424f, 0.06524339f, 0.10933818f, -0.02696002f, 0.21600185f, -0.02755328f, 0.02993038f, 
    -0.05860331f, 0.16884197f, 0.03616353f, -0.01928997f, -0.02734027f, -0.00933066f, 0.08287603f, 0.00409754f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.44774413f, 0.01571502f, -0.12029736f, 0.09021437f, 0.11379485f, 0.08459891f, 0.09580174f, -0.09034894f, 
    0.20248698f, -0.10776164f, -0.29737243f, 0.15880179f, 0.18929228f, -0.12791577f, -0.02718837f, 0.64604926f, 
    -0.16628778f, -0.01063077f, -0.33412397f, 0.02402173f, -0.15170433f, 0.30356318f, 0.00999397f, 0.48533860f, 
    -0.18398701f, -0.27503309f, -0.17187589f, 0.04501902f, 0.11463821f, 0.12330545f, 0.15073900f, -0.01813893f, 
    -0.13522962f, 0.14544578f, -0.05388239f, 0.14304025f, -0.02562556f, -0.17200813f, 0.11703855f, -0.07445017f, 
    -0.15231778f, -0.03177042f, -0.15316190f, 0.01895985f, 0.10022295f, -0.12194527f, -0.05049005f, 0.00946843f, 
    -0.07149722f, -0.12099361f, -0.15114832f, -0.11336927f, -0.11863790f, -0.13361640f, 0.03275463f, -0.03925305f, 
    0.08345530f, 0.06234070f, 0.03431729f, 0.02652653f, -0.07545535f, 0.04783166f, 0.16020358f, -0.04901537f, 
    0.05677504f, 0.08057383f, 0.10990613f, -0.08058377f, 0.10964420f, 0.14545614f, 0.49183697f, -0.07896750f, 
    -0.10548520f, -0.16751587f, 0.26218921f, -0.12550157f, 0.08188049f, -0.00981612f, 0.33122411f, 0.63082963f, 
    -0.04310057f, -0.13232456f, -0.21365176f, -0.08763488f, 0.09655866f, 0.19005409f, 0.00916034f, 0.09739019f, 
    -0.29442286f, -0.15936576f, 0.06673320f, -0.11873069f, -0.38470116f, -0.17743373f, -0.37386107f, 0.23495440f, 
    -0.14332388f, -0.14437251f, -0.16272901f, -0.02704078f, -0.10049330f, 0.06591409f, -0.21785142f, 0.11793067f, 
    -0.16600001f, 0.15647720f, -0.06756753f, -0.03652159f, 0.03206055f, 0.02044575f, 0.08222469f, -0.10882346f, 
    -0.11937615f, 0.18047707f, 0.10087650f, 0.16990119f, -0.10988141f, -0.01913917f, 0.10158474f, 0.05193222f, 
    -0.18291226f, -0.21862632f, -0.05369012f, -0.08097679f, -0.13795666f, 0.15459442f, -0.17576373f, 0.09831563f, 
    0.07801814f, -0.13167790f, 0.22928524f, -0.01998627f, 0.00331390f, 0.36199519f, -0.38544664f, 0.06753933f, 
    0.77031046f, 0.15360579f, -0.46603855f, 0.16536002f, 0.07910781f, 0.04492917f, 0.10369267f, 0.30935150f, 
    0.14190361f, 0.09867587f, -0.16074270f, 0.21369420f, 0.01045777f, -0.30454731f, -0.11733368f, -0.03633212f, 
    0.31588292f, 0.24577676f, 0.09491070f, -0.00614357f, 0.09255783f, -0.00780640f, 0.19703354f, 0.00640497f, 
    0.03553229f, 0.11426037f, 0.10246637f, 0.10359769f, 0.15298931f, -0.03891484f, 0.25899744f, 0.10839715f, 
    0.18469830f, 0.12118407f, 0.10147243f, 0.05455877f, 0.07824709f, 0.03929867f, -0.09125440f, 0.46059933f, 
    0.00328827f, -0.11759111f, -0.24969812f, -0.36382094f, 0.11355740f, -0.17128506f, 0.16672012f, 0.25377539f, 
    0.09858342f, 0.27145448f, 0.14164028f, 0.00660773f, 0.18152396f, 0.14616318f, 0.56417590f, 0.03358443f, 
    -0.23810369f, -0.10498607f, -0.04640253f, -0.14604272f, -0.00002272f, 0.35632086f, -0.15864742f, 0.11623130f, 
    0.42288294f, -0.04131982f, -0.17836435f, 0.15160954f, 0.11603333f, 0.13052318f, 0.01555446f, 0.34139317f, 
    -0.09359870f, -0.10509542f, 0.21332650f, 0.38437200f, 0.14849588f, 0.21338528f, 0.17506637f, -0.23694299f, 
    -0.03713986f, -0.57455271f, 0.03605189f, -0.02033949f, 0.12195037f, -0.09937835f, -0.34362277f, -0.16469914f, 
    -0.35914314f, 0.13622923f, 0.11731756f, -0.01187421f, -0.00393339f, -0.08245162f, 0.29387975f, 0.04698463f, 
    -0.07117516f, -0.01666821f, -0.26555544f, 0.02245445f, 0.00751546f, -0.00853847f, -0.02578847f, -0.74456668f, 
    0.09725972f, 0.05038173f, 0.06995973f, -0.17930774f, -0.01166241f, -0.06074239f, 0.13756694f, 0.40784347f, 
    0.38213608f, 0.26292378f, 0.08097538f, 0.13170783f, 0.38848957f, -0.10276636f, 0.09458079f, 0.23888496f, 
    -0.12852956f, 0.00631421f, -0.18348984f, 0.15322100f, 0.13788141f, 0.18305436f, 0.14572252f, 0.05483969f, 
    0.17786282f, -0.01184525f, 0.23380613f, -0.09217928f, 0.21475054f, 0.03968503f, -0.10308895f, -0.46631190f, 
    -0.03144617f, -0.14482684f, 0.00127885f, 0.02102816f, -0.14994524f, -0.00658150f, 0.16821486f, -0.28977209f, 
    0.43604389f, -0.26840973f, 0.14604935f, 0.07936278f, -0.26842070f, 0.08018182f, -0.18510164f, 0.08238253f, 
    0.04881658f, -0.03186863f, 0.32162687f, -0.18562730f, 0.13393793f, 0.44250813f, -0.33844557f, 0.10952194f, 
    -0.24606314f, 0.16387028f, 0.04385548f, 0.07478551f, -0.17190441f, -0.02576415f, 0.09002001f, -0.26478437f, 
    0.06790565f, -0.00467086f, 0.37619826f, 0.33557525f, 0.15026645f, 0.18640263f, -0.07625205f, -0.34575707f, 
    0.13951007f, -0.09753799f, 0.03578162f, 0.01923698f, -0.00203240f, 0.03001673f, -0.04548896f, -0.06307053f, 
    -0.01001555f, -0.15473600f, -0.09103303f, 0.07075318f, 0.00291810f, -0.12094483f, -0.06764922f, -0.16082129f, 
    -0.02303434f, 0.16102611f, -0.20375991f, -0.08948020f, 0.05515609f, 0.10983534f, -0.13590169f, -0.15295000f, 
    -0.03768356f, 0.02757900f, -0.00063630f, -0.12600854f, 0.14992732f, -0.09195924f, 0.10509038f, -0.07680896f, 
    0.05163476f, -0.05312635f, 0.13230759f, -0.00731960f, 0.08058706f, -0.03369139f, -0.18215671f, -0.02808752f, 
    -0.12934601f, 0.12427843f, 0.01146297f, -0.00516194f, -0.10533341f, -0.11418144f, -0.59391779f, 0.12744942f, 
    -0.08217558f, 0.10969900f, 0.07631968f, -0.05646693f, 0.27415302f, -0.08109941f, -0.14382321f, 0.27591273f, 
    0.07853068f, -0.02588620f, 0.09558522f, 0.13222711f, -0.18086006f, -0.27357265f, 0.06429117f, 0.30096915f, 
    -0.22453886f, 0.23089999f, 0.08476544f, 0.06683210f, -0.25271603f, 0.14911686f, 0.53003901f, -0.22401093f, 
    -0.29537013f, 0.07491170f, 0.05449131f, 0.12380900f, -0.00942201f, 0.46305317f, 0.08197644f, -0.15487464f, 
    -0.32333311f, -0.13755389f, 0.04507406f, 0.17674525f, 0.08718216f, -0.03734428f, -0.32520911f, 0.18741001f, 
    0.09421846f, 0.00192818f, 0.08424661f, 0.01496824f, -0.06703220f, 0.34969968f, 0.09874039f, 0.08382278f, 
    0.16968000f, -0.60637939f, -0.14476599f, 0.05193628f, 0.13909923f, 0.03358457f, -0.32095927f, -0.11101024f, 
    -0.00128977f, -0.03806970f, 0.11369245f, 0.12604769f, -0.16393968f, -0.15236695f, 0.16526534f, 0.11110909f, 
    0.00186217f, -0.17549491f, -0.39489019f, -0.08541829f, -0.27371824f, 0.02060479f, -0.02803938f, -0.19098325f, 
    -0.11292013f, 0.11751405f, 0.22407325f, -0.25509501f, -0.08131758f, 0.08328511f, -0.08845732f, 0.25877035f, 
    0.15800133f, 0.25867742f, -0.11212830f, -0.12723763f, 0.41711995f, -0.03546115f, -0.30677527f, -0.00485073f, 
    0.00334523f, 0.01248718f, -0.14220329f, -0.16565162f, 0.13145949f, -0.05235518f, -0.20417584f, -0.03831609f, 
    -0.12651004f, 0.09687827f, 0.03312756f, -0.03508820f, 0.00215931f, -0.03867323f, -0.14761724f, 0.07760068f, 
    -0.11453503f, 0.12684035f, -0.01798817f, 0.03658874f, 0.01775280f, 0.02818087f, 0.02134251f, -0.03346077f, 
    0.04346135f, -0.17049576f, -0.05192852f, -0.16591756f, -0.17830648f, -0.12896174f, -0.13526922f, -0.06853431f, 
    -0.23508199f, -0.00286849f, 0.02982241f, 0.13882513f, 0.01453288f, 0.01199677f, 0.36444956f, -0.14477123f, 
    -0.31597680f, 0.03749794f, 0.43132624f, -0.10086001f, 0.10103838f, -0.02967675f, 0.33397609f, -0.53032070f, 
    0.05388311f, -0.04809233f, -0.02451423f, -0.05945453f, -0.03636723f, 0.07995491f, 0.13914691f, -0.28794655f, 
    0.20668350f, -0.03802852f, 0.06865982f, 0.13517591f, 0.17309222f, -0.11274372f, 0.38349965f, -0.20004217f, 
    -0.31676656f, 0.04913800f, -0.03838250f, -0.01576613f, -0.16388415f, 0.03410766f, -0.07862075f, 0.16051616f, 
    0.01923337f, -0.03006193f, 0.00631410f, 0.07162413f, 0.29173839f, -0.08127895f, 0.15886895f, -0.05585284f, 
    0.13456659f, -0.13557838f, -0.06810094f, 0.35942656f, 0.06785670f, 0.00426402f, 0.04696866f, 0.00438092f, 
    0.03847795f, -0.05773924f, 0.01795403f, 0.07172351f, 0.01807258f, -0.01384212f, -0.25451532f, 0.03756258f, 
    -0.00048132f, -0.11254799f, -0.27408043f, 0.10227160f, 0.14500560f, -0.11539810f, 0.43591869f, 0.10772393f, 
    0.33915788f, 0.08257018f, -0.04644378f, 0.05269348f, -0.31604320f, -0.14622261f, 0.41749358f, 0.40688199f, 
    0.02822104f, 0.17374405f, 0.03302776f, -0.06725600f, -0.09456073f, 0.04792973f, -0.07045124f, -0.22382320f, 
    0.23434767f, 0.40306869f, -0.02308111f, -0.03963345f, 0.27723256f, -0.03690262f, 0.34510335f, -0.25449207f, 
    0.20917624f, 0.14963855f, 0.24374247f, -0.06018025f, -0.14899008f, 0.17450002f, 0.00847046f, 0.12310953f, 
    0.03535193f, 0.03454342f, -0.39181352f, 0.06230713f, -0.37894684f, 0.10006680f, 0.13095134f, 0.02873940f, 
    -0.05232160f, 0.00469995f, 0.00095672f, -0.03384189f, 0.10088716f, 0.28161141f, 0.03238283f, 0.15001740f, 
    -0.08544139f, 0.11870703f, -0.04792885f, -0.16140379f, -0.02246324f, -0.01280978f, -0.03086161f, 0.23055652f, 
    -0.24281800f, -0.11304546f, 0.03582249f, -0.02854826f, 0.03150968f, 0.42334935f, -0.32201472f, 0.12590805f, 
    -0.15961631f, 0.14104684f, -0.18257938f, -0.15145822f, -0.28200588f, 0.08914297f, -0.43080387f, 0.43065390f, 
    0.00501047f, -0.13644782f, 0.37656280f, 0.19508986f, -0.11350735f, 0.25541848f, -0.11002144f, -0.11645196f, 
    0.09339319f, 0.13297305f, -0.01355360f, -0.04177832f, -0.07364134f, -0.15634242f, 0.25811753f, -0.16624288f, 
    0.08530082f, 0.11370813f, -0.11928111f, -0.03078673f, -0.03797174f, -0.09417031f, 0.00938129f, 0.11054665f, 
    -0.01936212f, 0.11633318f, -0.13456334f, 0.00917278f, 0.14399917f, 0.15662770f, -0.17497660f, -0.18795042f, 
    0.01652704f, 0.05610114f, -0.06250000f, 0.08243852f, -0.12287654f, -0.10077232f, 0.08750796f, -0.11394549f, 
    -0.18977013f, 0.03839977f, -0.14030744f, -0.05249156f, -0.17294049f, -0.15110199f, -0.17622401f, -0.11866236f, 
    0.16357628f, -0.09127200f, -0.05254756f, -0.01237387f, -0.02282857f, 0.14847112f, -0.22028048f, 0.04303006f, 
    -0.38074371f, -0.02067836f, 0.03482619f, 0.02835315f, 0.50035298f, 0.09762664f, 0.26577416f, -0.12198371f, 
    0.08931363f, 0.11253384f, -0.03734714f, 0.58487034f, 0.12957004f, 0.40950873f, -0.18134007f, -0.05253632f, 
    -0.08201773f, -0.40443495f, -0.05110621f, 0.05832130f, -0.09452309f, 0.14362034f, -0.34639227f, -0.00436447f, 
    -0.13996223f, -0.04646545f, -0.23584126f, -0.02803370f, -0.11699025f, 0.33305424f, 0.07721548f, 0.06622228f, 
    0.00381809f, 0.01447102f, -0.34856102f, -0.10785431f, 0.22345628f, -0.02204600f, -0.16455644f, 0.83336854f, 
    0.06127396f, 0.06337328f, 0.02558577f, 0.06639782f, -0.06917187f, 0.14359732f, -0.05877614f, 0.23758657f, 
    0.01615421f, 0.20590483f, 0.02901139f, 0.06002277f, -0.10904741f, -0.16425432f, -0.01701217f, 0.11591883f, 
    0.02607945f, -0.06169211f, 0.25963748f, 0.13866135f, -0.09712894f, 0.35715282f, -0.21861196f, 0.04420235f, 
    -0.14515556f, 0.12485402f, 0.03605846f, 0.09078196f, -0.27807048f, 0.08231018f, -0.23100820f, -0.26949427f, 
    0.12337682f, -0.00111637f, 0.19812784f, 0.06822277f, 0.13087565f, 0.05519442f, 0.14686312f, -0.21744443f, 
    -0.08049875f, -0.22204432f, 0.06864712f, 0.05142590f, 0.56166184f, 0.14705908f, 0.44953734f, -0.02336288f, 
    -0.13044323f, -0.04150546f, -0.21677433f, -0.08751028f, -0.12263778f, -0.02470224f, 0.42769206f, -0.17191629f, 
    0.35870740f, -0.08560847f, 0.34185597f, -0.02882350f, 0.12092961f, 0.13972047f, 0.14928095f, 0.54851449f, 
    0.04998834f, 0.03619267f, -0.05530319f, -0.29467621f, 0.05124274f, -0.19832973f, -0.09389421f, -0.14911576f, 
    0.25626740f, 0.18139739f, 0.10043384f, 0.04391420f, 0.37919468f, 0.14928044f, 0.45488846f, 0.07832493f, 
    -0.48850155f, -0.11248703f, 0.19110289f, 0.06301581f, 0.07880675f, -0.08588972f, -0.31944731f, 0.10888861f, 
    0.00657512f, 0.07265810f, -0.25523180f, -0.16402902f, 0.17033166f, -0.00886693f, 0.24341623f, -0.64098221f, 
    -0.13744707f, 0.05778375f, 0.28789324f, 0.57502925f, 0.05294432f, 0.05699877f, 0.02773930f, 0.20262679f, 
    0.08252688f, -0.38832065f, -0.08938012f, 0.03148600f, 0.30991530f, -0.11732616f, -0.35012993f, 0.19367690f, 
    -0.03527054f, -0.10155904f, -0.03021938f, -0.15996210f, -0.15578860f, 0.19067910f, 0.26400989f, 0.08393426f, 
    -0.34333152f, 0.06346211f, 0.31903529f, 0.12420899f, 0.51349270f, -0.06369236f, -0.28790161f, 0.49609482f, 
    0.07676835f, -0.02487800f, 0.09202407f, -0.05918266f, -0.09610158f, 0.03312276f, -0.05713128f, 0.29533640f, 
    -0.11373109f, -0.11177868f, -0.10989866f, 0.14360514f, -0.34780028f, 0.11852962f, 0.26397380f, -0.01542783f, 
    -0.12070251f, -0.13165757f, 0.22578970f, 0.04614911f, 0.02910177f, 0.21360615f, -0.24093507f, 0.11696751f, 
    -0.12993740f, -0.11544025f, 0.04591692f, -0.06332448f, 0.21535778f, 0.02524778f, -0.09273011f, 0.29359195f, 
    -0.06152281f, -0.10128447f, 0.31008378f, -0.02541977f, -0.02331676f, 0.03795215f, -0.02946427f, -0.41136700f, 
    0.19051243f, 0.16103712f, -0.13508695f, -0.06855436f, -0.24049224f, 0.07243690f, -0.27355340f, 0.12108838f, 
    0.07044609f, -0.15982480f, -0.07835569f, -0.10435768f, 0.11718053f, 0.27212259f, -0.30862063f, -0.08797737f, 
    -0.16000642f, 0.08376667f, -0.25467294f, 0.07480513f, 0.21385939f, -0.14780630f, 0.07629893f, 0.26356882f, 
    0.16086209f, -0.07527157f, -0.09398469f, -0.05981800f, 0.15285783f, -0.01968132f, 0.11118056f, 0.12509578f, 
    -0.05378648f, -0.06823714f, 0.09070168f, 0.11743797f, -0.08827797f, -0.06542771f, 0.15914249f, -0.17696944f, 
    0.09155507f, 0.03975494f, 0.02101313f, 0.03387207f, 0.03352208f, 0.22578490f, -0.30437347f, -0.13084096f, 
    0.05687810f, -0.11445834f, 0.34558088f, 0.09617493f, 0.47290975f, -0.11987897f, -0.29456258f, 0.44986123f, 
    -0.11358717f, 0.07780610f, -0.18196957f, 0.49973589f, -0.14253396f, 0.00673032f, -0.14784686f, 0.02077712f, 
    0.09705775f, -0.32418352f, 0.09598538f, -0.01996809f, 0.10490052f, 0.06681902f, 0.11739741f, 0.08609112f, 
    -0.39807576f, -0.03192711f, 0.18358067f, 0.17522691f, 0.16947842f, 0.10524090f, 0.55206043f, 0.09984927f, 
    0.21879472f, 0.04777887f, 0.22197847f, -0.13567345f, -0.21798155f, 0.01220892f, -0.06842287f, 0.46822965f, 
    0.15918431f, 0.00343326f, 0.33177468f, -0.37768087f, 0.02688819f, -0.11772825f, -0.07601931f, -0.00815031f, 
    0.05395047f, -0.00315222f, 0.00106176f, -0.14665206f, 0.40153155f, 0.03153558f, 0.16114871f, 0.08273757f, 
    0.09992588f, -0.14182214f, 0.43164557f, 0.10218128f, -0.07924203f, 0.05083960f, -0.08602937f, -0.15250231f, 
    -0.04525897f, -0.10603671f, -0.23135178f, -0.04272703f, -0.13661633f, 0.01163607f, 0.12092956f, -0.57520568f, 
    0.15842834f, -0.09048617f, 0.09531236f, -0.20281059f, 0.17319703f, 0.01618955f, 0.09280182f, 0.27655065f, 
    -0.05674571f, -0.04395285f, -0.08053371f, -0.01060552f, 0.27521300f, -0.06781843f, -0.18357475f, -0.04761912f, 
    -0.15180504f, 0.11476278f, 0.39611998f, 0.16907404f, 0.16626272f, 0.49120677f, -0.09539455f, -0.12234298f, 
    0.41441178f, -0.14156100f, -0.14908414f, -0.04534886f, -0.43495339f, -0.04703621f, -0.11778076f, 0.29845566f, 
    -0.04723076f, 0.04383722f, 0.30670679f, -0.14030850f, -0.02692933f, -0.01237930f, 0.12400829f, -0.19425559f, 
    0.13467026f, 0.27400374f, 0.13428718f, -0.00567383f, -0.15970451f, 0.03028413f, -0.01123437f, 0.04452264f, 
    0.37777990f, 0.09313851f, 0.03361501f, -0.04987405f, -0.12762502f, -0.18824340f, 0.35308865f, -0.14209291f, 
    -0.29794583f, 0.01490399f, 0.44836402f, 0.08942750f, -0.21930693f, 0.10162313f, 0.17903006f, -0.19431016f, 
    0.03125056f, -0.13199067f, 0.38263208f, 0.02135807f, 0.12939638f, 0.22890235f, 0.08871258f, -0.13283475f, 
    0.11858507f, 0.23863012f, 0.06976774f, -0.14232662f, 0.05850061f, -0.07953104f, -0.27188295f, 0.05499057f, 
    -0.43523496f, 0.13293250f, -0.16730396f, -0.09621308f, 0.11207344f, 0.01675986f, 0.41498622f, -0.15108164f, 
    0.10361105f, -0.06493000f, -0.31790462f, -0.13328719f, 0.00093648f, -0.03750359f, 0.01631897f, -0.21039690f, 
    0.12649722f, 0.13377661f, 0.12146034f, -0.28905460f, 0.12414861f, 0.19549176f, 0.05136622f, 0.44796267f, 
    0.21785243f, 0.07821448f, -0.06114622f, 0.10769748f, 0.37078625f, -0.02908268f, 0.06029867f, 0.23527323f, 
    -0.17922580f, -0.15571645f, -0.12222834f, -0.01484217f, 0.17448716f, 0.21080750f, 0.31604743f, -0.04729836f, 
    0.23193349f, 0.00422385f, 0.32735008f, 0.12138692f, 0.30160612f, -0.01611733f, 0.27931401f, 0.66740590f, 
    -0.03066985f, -0.10716689f, -0.24196178f, -0.07012720f, 0.06385940f, -0.05484220f, 0.01238230f, -0.22755830f, 
    0.41332233f, -0.47644085f, -0.04613333f, -0.10104524f, 0.10544415f, -0.02145128f, -0.33551088f, 0.14445691f, 
    -0.34398088f, 0.03231940f, 0.02807345f, 0.13398007f, -0.04380367f, 0.03026833f, 0.17394806f, -0.03529440f, 
    0.16118854f, 0.12827264f, 0.41025367f, 0.08160971f, -0.11164987f, -0.03382446f, 0.47360399f, -0.10930592f, 
    -0.06908836f, 0.08281083f, 0.19112831f, -0.21493289f, -0.01999935f, -0.14378101f, 0.00952961f, -0.43473232f, 
    0.46136793f, 0.29850173f, 0.06737117f, 0.07276604f, 0.39574456f, 0.04126514f, -0.09884287f, -0.07236798f, 
    -0.02801693f, 0.07087079f, 0.37017199f, -0.03390295f, -0.15728180f, 0.42361304f, -0.16357733f, -0.05843170f, 
    -0.13751192f, 0.00446586f, 0.30061164f, -0.10433440f, 0.07016324f, 0.11646020f, -0.03492761f, 0.82910883f, 
    0.04809946f, 0.14787956f, 0.11317481f, -0.05785564f, 0.05598810f, -0.15019691f, -0.15288129f, -0.44061115f, 
    0.12089232f, 0.19418934f, -0.04926007f, 0.05670688f, -0.20998694f, 0.01257179f, -0.13450675f, -0.18330328f, 
    -0.03044786f, -0.12027375f, 0.17183059f, -0.05894240f, -0.08840345f, 0.15298752f, 0.13098532f, -0.00679932f, 
    -0.19738750f, -0.02848033f, -0.06153999f, 0.04605504f, -0.41073403f, 0.06431834f, -0.32888514f, 0.61973715f, 
    -0.02147773f, -0.03705920f, 0.14685817f, -0.28916910f, 0.12137727f, 0.08938909f, 0.15494753f, 0.07747386f, 
    -0.01703591f, 0.63043821f, -0.15262888f, -0.09127185f, -0.04422820f, -0.12093667f, 0.63554919f, 0.04172026f, 
    0.32274184f, -0.07339014f, -0.00703737f, -0.01142374f, -0.12989195f, -0.09541887f, 0.16651306f, -0.15322962f, 
    -0.45143896f, -0.09565459f, 0.51959586f, -0.14964357f, 0.01724259f, 0.15835258f, 0.27977517f, -0.41518128f, 
    0.12268908f, 0.16129631f, 0.28668225f, 0.12582338f, -0.05304920f, 0.11750606f, -0.03167529f, -0.18846984f, 
    0.20065050f, -0.24628952f, 0.01397818f, -0.12361320f, 0.07452983f, 0.05593218f, 0.07871119f, -0.15419078f, 
    0.15260054f, 0.04478493f, -0.15029058f, -0.14209709f, 0.03168805f, 0.08682417f, -0.10203853f, 0.04349079f, 
    -0.09039217f, -0.14274718f, 0.01747025f, -0.01848523f, -0.12956731f, -0.15808678f, 0.12862949f, 0.08500223f, 
    0.16461138f, 0.14187750f, -0.03062509f, -0.14416470f, 0.12864362f, -0.02307943f, -0.00474687f, 0.02585096f, 
    -0.14287405f, -0.18149328f, 0.00799083f, -0.11454175f, -0.14400896f, 0.10728808f, -0.19706815f, 0.14222434f, 
    0.33063641f, 0.07678375f, -0.18009080f, -0.14257029f, -0.00915082f, -0.26578385f, 0.14917392f, -0.05546363f, 
    0.17198350f, 0.10869558f, 0.02191901f, 0.06228150f, 0.09981752f, 0.08552218f, 0.00668694f, -0.27778649f, 
    -0.07515945f, 0.07174323f, -0.46687186f, 0.30010962f, -0.05800569f, -0.03695856f, -0.16989392f, -0.07524033f, 
    0.58434510f, 0.28421953f, -0.14762047f, 0.12199748f, -0.04956761f, -0.16666520f, 0.42486826f, 0.02839587f, 
    -0.16651110f, 0.03530498f, -0.15190624f, 0.16345978f, -0.12819105f, -0.03779957f, -0.06574485f, 0.01506579f, 
    -0.08132669f, -0.03383918f, -0.10361785f, 0.02730968f, -0.01746245f, 0.09380278f, -0.08378751f, -0.07736673f, 
    -0.03198598f, 0.16181423f, -0.00752128f, 0.01167519f, -0.01926393f, 0.02730142f, 0.14219412f, 0.06318212f, 
    -0.01019100f, 0.03711931f, -0.05513503f, 0.04695372f, -0.03930184f, -0.05353364f, -0.15177256f, -0.17322670f, 
    0.44679198f, -0.00113344f, 0.10493907f, -0.10252129f, -0.02786774f, -0.29747054f, 0.36474702f, -0.04981248f, 
    -0.31653178f, -0.11450394f, 0.38876003f, -0.14718707f, 0.37099791f, 0.08279135f, 0.23994480f, 0.05776365f, 
    -0.06765547f, 0.06969408f, -0.20690669f, -0.07058722f, 0.08837153f, 0.01641087f, -0.12134464f, 0.10539402f, 
    0.14076906f, -0.55773020f, 0.01586277f, -0.01934218f, -0.14025286f, 0.14794675f, -0.43500185f, 0.14216317f, 
    0.10985979f, -0.01556864f, -0.00135910f, -0.08513416f, 0.15690631f, -0.07362197f, -0.14254531f, -0.04550606f, 
    -0.02744973f, 0.16922770f, -0.05356653f, -0.17561108f, -0.04276586f, 0.16582727f, -0.07439388f, -0.08025717f, 
    0.00276873f, -0.05137157f, -0.13136138f, 0.07564083f, -0.15785922f, -0.09167901f, 0.13529281f, -0.15138042f, 
    0.00555167f, 0.07358605f, 0.13810532f, -0.17298400f, -0.01096031f, 0.09971605f, -0.14318097f, 0.12905917f, 
    0.41552556f, 0.03317250f, 0.22651391f, 0.06712852f, -0.00972184f, 0.03702112f, -0.04958089f, 0.07586439f, 
    -0.57529986f, 0.00812749f, 0.32876503f, 0.13617845f, 0.08828732f, -0.00919029f, -0.29027718f, -0.50440949f, 
    0.08022172f, 0.08046822f, 0.43194005f, 0.37597647f, 0.00709095f, 0.35833842f, -0.10739449f, 0.22540949f, 
    -0.32344887f, -0.01408210f, -0.01466502f, 0.07520808f, -0.16307296f, -0.13337857f, -0.04750066f, -0.13120747f, 
    0.42231780f, 0.03598968f, 0.13768348f, 0.01266626f, -0.15519679f, -0.04176599f, -0.04575137f, -0.11483220f, 
    -0.61757177f, -0.15378684f, 0.27179852f, -0.05968187f, 0.06129700f, 0.12086677f, -0.26734370f, -0.36055574f, 
    -0.05139012f, -0.12552118f, 0.32435051f, -0.01992589f, -0.02657302f, 0.36107367f, -0.17643154f, 0.12441204f, 
    0.06803997f, 0.26389247f, 0.10822006f, -0.07679420f, -0.42261502f, -0.09676962f, 0.31107956f, 0.01351739f, 
    -0.36143225f, -0.11017293f, 0.20061031f, 0.06252481f, -0.15788628f, -0.02107825f, 0.35237092f, 0.12816703f, 
    0.44218847f, -0.02499360f, 0.27551275f, -0.10990233f, -0.25926507f, 0.05602219f, 0.13251346f, -0.08111646f, 
    -0.05361367f, 0.06834361f, 0.30349731f, -0.25262156f, 0.00433580f, -0.16774201f, 0.14880724f, 0.15622801f, 
    0.06789870f, 0.15033014f, -0.15301254f, 0.01515162f, 0.38688588f, 0.04272190f, -0.03982180f, 0.12451832f, 
    -0.36156920f, 0.15861438f, 0.13870257f, -0.08412966f, 0.12877715f, 0.13691857f, 0.31462109f, -0.02005810f, 
    -0.07510583f, -0.14231856f, -0.03493379f, 0.13593060f, -0.00782066f, -0.03168564f, 0.05258254f, 0.18397935f, 
    -0.13763511f, 0.01652535f, -0.21411227f, -0.18589649f, -0.16292791f, -0.10949653f, 0.10713405f, 0.10978483f, 
    -0.06799089f, -0.14039537f, -0.13701224f, 0.12305988f, 0.25139633f, 0.03648552f, -0.09668620f, -0.10353217f, 
    0.35030332f, 0.00412708f, 0.32759297f, 0.08254722f, -0.02404423f, 0.06710047f, -0.22760290f, 0.10912666f, 
    -0.14882967f, -0.06961902f, 0.43704513f, 0.04017276f, 0.14562707f, -0.01006298f, 0.48266134f, -0.00613655f, 
    0.02945350f, -0.14016224f, -0.09546892f, 0.09142202f, 0.08810773f, 0.22050406f, 0.15239641f, -0.41019088f, 
    0.22571999f, -0.22542505f, -0.05059194f, 0.00426784f, -0.16761608f, 0.11021382f, -0.36840370f, -0.03437860f, 
    -0.10543051f, -0.04460209f, 0.02691489f, 0.01671131f, 0.15625377f, 0.06779053f, -0.02244745f, -0.00871780f, 
    -0.05849479f, -0.08891358f, -0.00681601f, -0.17589813f, -0.13487218f, 0.10952906f, -0.03707622f, -0.03928297f, 
    -0.08512517f, 0.01960642f, -0.14467087f, 0.07504687f, -0.00551605f, -0.00097745f, -0.09822251f, 0.05091139f, 
    -0.14150187f, -0.04265261f, -0.11085325f, -0.13061316f, -0.15531862f, -0.08307979f, -0.14959727f, -0.16354850f, 
    -0.17181869f, 0.02032263f, 0.18312213f, 0.02495662f, 0.15902883f, 0.13843942f, 0.27487209f, 0.15808003f, 
    0.31479022f, -0.02681459f, -0.47012135f, 0.06085128f, 0.37626714f, 0.06675041f, 0.44768193f, 0.07670335f, 
    0.14876208f, 0.01041701f, -0.26299220f, 0.20983604f, 0.10950087f, -0.08784983f, 0.04733982f, 0.36979792f, 
    -0.01339260f, -0.20958799f, 0.11383361f, 0.10514305f, -0.00378221f, -0.11652434f, -0.50456101f, 0.27122080f, 
    -0.15051757f, 0.03881574f, -0.08280587f, 0.07861258f, 0.11989753f, 0.22668505f, 0.07833210f, -0.05370949f, 
    0.10839442f, 0.09042019f, -0.02075665f, 0.09890160f, -0.13364337f, 0.14948998f, 0.01007026f, -0.42861822f, 
    0.16620554f, -0.07913265f, 0.44125527f, 0.31964266f, -0.09643890f, 0.17311658f, -0.06845994f, -0.11256753f, 
    -0.01228529f, -0.00927026f, 0.06156545f, -0.08266931f, -0.52052015f, 0.00581350f, 0.31899330f, -0.28576994f, 
    -0.29965279f, -0.15846899f, -0.00571152f, -0.09081110f, -0.15751135f, -0.02677733f, 0.34959820f, 0.07707705f, 
    0.08596158f, -0.05545572f, 0.13175772f, -0.06333295f, 0.41451132f, -0.03038756f, 0.30999988f, 0.12616710f, 
    -0.08108137f, 0.00195223f, -0.11291553f, -0.10067806f, 0.03080901f, 0.02680279f, -0.08751405f, -0.31835586f, 
    0.30815834f, 0.39182949f, 0.17187209f, -0.18357345f, -0.49400344f, -0.12137903f, -0.20505112f, -0.13668446f, 
    -0.18020910f, 0.04694751f, -0.07848899f, 0.08296066f, 0.15114872f, -0.15029469f, 0.10415914f, -0.11656293f, 
    -0.01632360f, -0.09065071f, -0.15130626f, -0.13733089f, -0.00978633f, -0.10790449f, -0.15527180f, -0.00138217f, 
    0.05804448f, 0.14087282f, -0.12542590f, -0.00622497f, -0.00201184f, -0.06434082f, -0.05245328f, -0.12880029f, 
    0.08412782f, 0.14938620f, 0.14425814f, -0.01602888f, 0.09275787f, 0.02939943f, -0.17177963f, -0.15208343f, 
    0.04735407f, 0.15625946f, -0.17037845f, 0.02444772f, -0.11381356f, -0.07621253f, 0.29839224f, -0.11773024f, 
    -0.22741739f, 0.14536799f, -0.62346560f, 0.12894142f, 0.14321017f, 0.06751512f, 0.40202805f, -0.34111869f, 
    -0.02439649f, 0.02536692f, -0.16547966f, 0.09862836f, 0.03048513f, 0.33145064f, 0.17543741f, 0.47610009f, 
    -0.05007320f, 0.18298478f, -0.07686080f, -0.12143574f, -0.13421677f, -0.11288884f, 0.19652793f, 0.13483937f, 
    0.19756542f, 0.15716186f, -0.05220277f, 0.16830948f, -0.12702318f, -0.34873989f, 0.29424673f, 0.11771519f, 
    -0.00319090f, -0.05033033f, -0.42568439f, 0.00277739f, 0.24286707f, 0.13474800f, 0.47774071f, -0.41633144f, 
    0.07652801f, -0.03920256f, -0.29304701f, -0.16742420f, 0.08002342f, 0.21189900f, 0.15462601f, 0.38570872f, 
    -0.07251399f, -0.00016704f, -0.10157095f, -0.00717518f, 0.30010143f, -0.00606632f, 0.38218608f, 0.07780050f, 
    -0.00337343f, -0.11165263f, 0.01080139f, 0.07815932f, -0.00848500f, -0.10618924f, -0.16772197f, -0.05502977f, 
    0.14726740f, -0.01405007f, -0.14548634f, -0.04368512f, -0.08514165f, 0.06115141f, -0.10735086f, -0.16426979f, 
    0.13629334f, 0.05911472f, -0.15577294f, 0.01210978f, 0.09629950f, -0.16713712f, 0.07915195f, 0.10456073f, 
    0.01922636f, -0.11693620f, -0.07786588f, -0.10485126f, 0.07791043f, 0.03214778f, -0.09027795f, -0.16560839f, 
    0.01460178f, 0.16845942f, 0.01311092f, 0.07784574f, 0.05058037f, -0.17528334f, -0.03905179f, -0.08486743f, 
    0.14096022f, -0.05771457f, -0.19625454f, 0.06332107f, 0.00629626f, 0.03097275f, 0.03047369f, -0.06823353f, 
    0.08571485f, 0.03567633f, -0.12741874f, -0.15605707f, -0.00996398f, 0.00126327f, -0.12816457f, -0.01648538f, 
    0.02097989f, 0.09279431f, 0.06470280f, 0.07684757f, -0.03450341f, 0.07264037f, -0.14468513f, 0.03709423f, 
    0.61578053f, 0.08602368f, 0.19757809f, -0.03008487f, 0.10239492f, -0.34971866f, 0.44817731f, 0.16931094f, 
    -0.30457106f, 0.03176716f, 0.26232171f, -0.17099269f, 0.30160326f, -0.01572843f, 0.06153775f, 0.45563233f, 
    0.03275136f, 0.01251950f, -0.12222739f, -0.02369846f, -0.09002678f, 0.16528238f, 0.11038368f, 0.34760922f, 
    -0.33843836f, 0.05882486f, -0.12272652f, 0.14892013f, -0.26005912f, -0.17617492f, -0.19756536f, 0.01577296f, 
    0.03957768f, -0.08841091f, 0.47404253f, -0.04966862f, -0.14737533f, -0.04387364f, -0.30541644f, -0.04823287f, 
    -0.07593521f, 0.15755901f, 0.18195330f, 0.16767308f, 0.06578805f, -0.08556171f, -0.00427358f, 0.21530980f, 
    -0.12366915f, 0.02943145f, -0.19750473f, 0.03491416f, -0.05102226f, -0.17525183f, 0.12193304f, 0.37382907f, 
    -0.06629181f, -0.18903919f, -0.08522908f, 0.09783705f, -0.23034805f, -0.13041994f, 0.12170585f, -0.08272249f, 
    0.11865431f, 0.13165510f, -0.07989641f, 0.06465632f, -0.14505902f, -0.12935016f, -0.09293671f, 0.04623912f, 
    -0.04999769f, -0.16270757f, 0.02161760f, 0.08403997f, -0.05230913f, 0.10785465f, -0.04027671f, 0.15124613f, 
    0.00132708f, 0.03337314f, 0.03607041f, -0.11507048f, -0.15221389f, -0.11040139f, -0.07309098f, -0.12757684f, 
    -0.05495119f, -0.04824390f, 0.03953056f, 0.00465746f, 0.07079531f, -0.05621250f, -0.05711707f, 0.06072459f, 
    0.18121032f, -0.05055432f, 0.16956072f, 0.05343795f, 0.09472905f, -0.13997886f, 0.21180515f, 0.15050036f, 
    0.14309762f, -0.00889554f, 0.61596602f, 0.00810265f, 0.26620200f, -0.02450264f, -0.49246371f, -0.59911478f, 
    0.11156712f, 0.00348438f, -0.09242332f, -0.26063842f, -0.09104237f, 0.17457218f, -0.08252620f, -0.26556456f, 
    -0.03840655f, -0.31383729f, -0.05948422f, 0.04410919f, 0.07147532f, -0.06760006f, 0.00471645f, 0.10177539f, 
    -0.34316039f, -0.13368534f, 0.12538077f, 0.00101640f, 0.04613150f, -0.20332952f, -0.33967635f, 0.11173543f, 
    0.15975763f, 0.15492842f, -0.34833157f, -0.03258058f, 0.28970522f, 0.00084880f, 0.42147738f, -0.19109748f, 
    0.03012867f, 0.05193894f, -0.01876942f, 0.12829447f, -0.06753590f, -0.05923458f, -0.01399276f, 0.27478161f, 
    0.37387747f, -0.10336970f, 0.15979652f, -0.13616306f, 0.39420086f, 0.09162164f, -0.55293727f, 0.32431826f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27058333f, -0.06656912f, 0.06059419f, -0.16348268f, -0.09389850f, -0.06371704f, -0.03627419f, 0.16358885f, 
    0.03574286f, 0.22189209f, -0.15927647f, 0.09226019f, 0.12549065f, 0.15857574f, -0.02748586f, -0.00161068f, 
    0.25434184f, 0.02409350f, 0.10284302f, 0.21358685f, -0.01236332f, 0.39878383f, 0.00794350f, 0.04855520f, 
    -0.17390381f, 0.16466250f, -0.13559777f, -0.13695721f, 0.06713004f, -0.07301374f, -0.11260118f, -0.09317034f, 
    0.16776136f, -0.02716808f, 0.21552840f, 0.22936642f, 0.03767158f, 0.13368680f, 0.04793410f, -0.04444196f, 
    0.07718673f, 0.05930623f, 0.07094376f, -0.04886690f, -0.17103262f, -0.00406554f, 0.05899591f, 0.02530636f, 
    -0.11369375f, 0.25517944f, 0.14197233f, 0.15099779f, -0.05935189f, -0.08670841f, 0.14126323f, 0.16603625f, 
    0.16620557f, 0.09724856f, -0.05023729f, -0.06974644f, 0.01155414f, -0.02978912f, 0.09049544f, -0.18340833f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13910417f, 0.06856918f, -0.37532550f, -0.03039560f, -0.00880699f, -0.29315001f, 0.37964290f, 0.09871753f, 
    -0.33084717f, -0.03048938f, 0.00545534f, 0.17533179f, 0.22867340f, 0.03536651f, -0.03596640f, 0.19194138f, 
    0.16304860f, 0.22197911f, -0.24179539f, -0.49967355f, -0.05027512f, 0.03793832f, -0.28019610f, 0.18484437f, 
    0.27542731f, 0.41734606f, -0.46623686f, -0.59993142f, -0.33831307f, 0.15146697f, 0.15139741f, 0.03204685f, 
    -0.16986075f, -0.02236592f, 0.12568359f, 0.43631461f, 0.39001706f, -0.48406446f, -1.00250506f, 0.14576612f, 
    -0.01097981f, -0.18965286f, 0.09357794f, -0.02358595f, -0.07903572f, -0.35398942f, -0.59746838f, 0.16402251f, 
    0.06034202f, 0.01035149f, 0.10700785f, 0.22567338f, -0.45484230f, -0.43996704f, -0.12884246f, -0.21562380f, 
    0.14954342f, 0.07815124f, 0.03710425f, -0.48816666f, -0.79558730f, -0.04509054f, -0.01403169f, 0.42714486f, 
    0.03260184f, 0.09132574f, 0.16558243f, -0.22178006f, 0.16955602f, 0.22454330f, -0.46050951f, 0.36565644f, 
    -0.51522690f, -0.29085144f, -0.04793115f, -0.25916535f, -0.53114212f, 0.39886928f, -0.13030167f, -0.20730238f, 
    -0.11568138f, 0.13823587f, 0.11850194f, -0.32354394f, -0.11506280f, -0.38095722f, -0.07813163f, -0.10534688f, 
    0.08496445f, -0.05166400f, -0.49530247f, -0.59372056f, -0.22041668f, -0.33819827f, 0.01349025f, 0.27429336f, 
    -0.03545902f, -0.09007169f, 0.16150244f, 0.04385309f, 0.10781659f, -0.45843035f, 0.03802519f, -0.22322080f, 
    -0.07282033f, 0.28589535f, 0.06876630f, 0.40420699f, 0.00857732f, -0.40309635f, -0.25690955f, 0.18123101f, 
    0.29898977f, -0.19894624f, -0.10895193f, 0.29974946f, -0.88096458f, -0.05346970f, -0.02352960f, 0.24518915f, 
    0.44271001f, -0.02219802f, 0.06024226f, 0.20160395f, -0.24047013f, 0.09098157f, -0.76241082f, 0.38268757f, 
    0.00613089f, 0.04298481f, -0.21749005f, 0.06015726f, 0.32353187f, -0.23774375f, 0.23020536f, 0.18675548f, 
    -0.57621503f, 0.16708030f, -0.01412717f, 0.00086688f, 0.24204634f, -0.14615989f, -0.06468033f, -0.58183533f, 
    0.28909272f, -0.76348990f, 0.03249541f, 0.22050761f, 0.07529557f, 0.21128955f, 0.06628987f, 0.18777707f, 
    -0.75412339f, 0.49395567f, 0.07371565f, -0.00451630f, 0.10280295f, 0.30555260f, -0.26364920f, 0.30018020f, 
    0.07875499f, -0.67156172f, 0.00423792f, -0.56652659f, -0.69112957f, -0.12200557f, -0.22076593f, -0.47323239f, 
    -0.13436686f, -0.73919517f, -0.03362928f, -0.72191548f, -0.05747232f, 0.10621851f, -0.14907314f, -0.10777412f, 
    -0.01713991f, -0.30939746f, 0.09612784f, 0.48541963f, 0.15886326f, -0.78294736f, 0.11875745f, 0.09070460f, 
    -0.03521537f, -0.10204110f, -0.02439763f, -0.31623989f, 0.50371104f, 0.10924691f, -0.10092327f, 0.29284871f, 
    0.07997304f, -0.06487478f, 0.21357997f, -0.01375077f, 0.09764358f, 0.04184220f, -0.12823008f, -0.79082322f, 
    -0.34074149f, 0.21810874f, -0.06659092f, 0.68395877f, -0.09936127f, -0.47697324f, -0.03652167f, -0.02447848f, 
    -0.27906302f, -0.34248975f, 0.05765035f, -0.57957906f, -0.02791964f, 0.20310970f, -0.71039504f, 0.28775150f, 
    -0.33454069f, -0.27485672f, -0.11928166f, -0.12095721f, -0.02637800f, 0.25592443f, -0.47213292f, 0.19422428f, 
    -0.11771979f, 0.07124419f, -0.91267699f, -0.01415621f, -0.29467988f, 0.21188626f, -0.22907102f, 0.20872818f, 
    -0.02020838f, -0.25514200f, -0.03966041f, 0.32509732f, -0.01623758f, 0.23878942f, 0.17244163f, -0.42741185f, 
    0.06600409f, 0.37976280f, 0.05161360f, -0.10150410f, -0.54679161f, -0.38444227f, -0.01547065f, -0.33608326f, 
    0.00604244f, -0.02787283f, 0.11088517f, 0.42702430f, 0.54953337f, -0.11025983f, 0.45552233f, -0.60582799f, 
    -0.38110742f, -0.02416040f, 0.27568287f, -0.20839566f, 0.15536936f, -0.35239893f, 0.16591406f, -0.12481839f, 
    0.02938308f, 0.17498079f, 0.06430208f, 0.13323888f, -0.15893278f, -0.18845792f, -0.15100802f, 0.05141535f, 
    0.17628519f, 0.05277658f, 0.01471929f, -0.12331127f, 0.01654710f, 0.11396758f, -0.02700811f, -0.28897828f, 
    -0.22388797f, 0.09532477f, -0.19488652f, 0.37992811f, -0.21326230f, -0.12802094f, -0.12608285f, -0.03498055f, 
    0.19701278f, 0.01609761f, -0.17743406f, 0.19366583f, 0.25644284f, 0.35726407f, -0.28485474f, -0.00265949f, 
    -0.13557096f, -0.38077974f, -0.10426323f, -0.49179539f, 0.07292946f, -0.23058212f, -0.06753885f, -0.05075776f, 
    -0.15205309f, 0.21395108f, -0.06377268f, 0.32646808f, 0.20020506f, 0.52392054f, 0.10430818f, 0.02320547f, 
    -0.27321634f, -0.05186203f, 0.03408231f, -0.21807782f, 0.24926929f, -0.01407197f, -0.47285670f, 0.15398216f, 
    -0.23599994f, -0.04971145f, -0.37876886f, -0.06557915f, -0.00378070f, 0.16972323f, -0.31369284f, 0.17337225f, 
    0.16594775f, -0.01923785f, -0.13232233f, 0.16678186f, -0.56112134f, -0.14209189f, -0.06832801f, 0.35465494f, 
    -0.43843025f, 0.28392178f, -0.03405724f, 0.10915171f, -0.04826554f, -0.39491990f, -0.14913455f, 0.19155024f, 
    0.31981361f, -0.41419658f, -0.04464960f, -0.73736316f, 0.14720482f, -0.25223500f, 0.08556459f, -0.12099305f, 
    0.04914359f, -0.12193085f, 0.08980025f, -0.23297176f, 0.06865879f, -0.29590562f, 0.35049120f, 0.06011509f, 
    -0.07515965f, 0.39141166f, -0.11901039f, 0.40570632f, -0.05476436f, -0.17853895f, 0.10863023f, 0.10434580f, 
    -0.36221370f, -0.28658924f, 0.04604283f, -0.42320469f, 0.32706913f, 0.10551931f, 0.06223995f, 0.13222793f, 
    0.21374641f, 0.03725307f, 0.06576556f, -0.38257194f, -0.14524455f, 0.08383092f, 0.66086352f, -0.75727683f, 
    -0.59826326f, 0.03421989f, -0.72238648f, -0.07152260f, -0.02677282f, -0.36181620f, 0.06633287f, 0.13634813f, 
    -0.68376553f, 0.31055635f, 0.01056809f, -0.68933284f, -0.18258348f, 0.23078597f, -0.00524714f, -0.26551580f, 
    -0.37706953f, -0.01511562f, 0.03693674f, 0.41577983f, -0.04311885f, -0.33246198f, -0.12217659f, 0.13956513f, 
    -0.19282733f, 0.12215879f, -0.20906039f, 0.32071602f, -0.55364388f, -0.09700310f, 0.14302370f, 0.09781567f, 
    0.30790901f, 0.24865690f, -0.09061301f, -0.73985225f, 0.06255995f, 0.22434646f, 0.31609812f, 0.09507735f, 
    -0.09677589f, -0.45066833f, -0.01165273f, -0.69493061f, 0.07123663f, 0.34943259f, 0.31258503f, 0.19265832f, 
    -0.12077275f, -0.10309474f, -0.09816791f, -0.60059595f, 0.43399638f, -0.55327731f, 0.01858571f, -0.46308628f, 
    -0.72443187f, 0.04866458f, -0.03948424f, -0.10648854f, -0.15145220f, -0.04206349f, -0.73464495f, -0.16861935f, 
    -0.59134418f, 0.05116194f, -0.15392426f, 0.03015630f, -0.01189108f, 0.12229758f, -0.48424250f, 0.08948623f, 
    0.55390435f, -0.24853204f, 0.10787641f, 0.20176104f, 0.00401800f, -0.41790056f, -0.11567067f, 0.22110195f, 
    0.10129483f, -0.12936175f, -0.73902625f, -0.83712858f, 0.01999513f, -0.01363782f, 0.05202755f, -0.60576421f, 
    0.31935263f, -0.12803902f, 0.17567196f, 0.27496660f, -0.51663214f, 0.19552042f, -0.24337581f, -0.48536095f, 
    -0.53094190f, -0.02107820f, -0.23930895f, 0.22895244f, 0.26007748f, 0.08396580f, 0.02489168f, 0.12104004f, 
    0.01144453f, 0.29966694f, -0.10015605f, 0.25185481f, -0.14100654f, -0.16427261f, 0.08404347f, -0.13563167f, 
    0.29316977f, 0.08738709f, 0.02957572f, -0.20135775f, -0.31917897f, 0.37417680f, -0.02480857f, -0.28110158f, 
    -0.15224025f, -0.01832813f, 0.10909496f, 0.05693438f, -0.25279811f, 0.05649066f, 0.09558587f, 0.18125172f, 
    0.34043133f, 0.06703288f, 0.48218125f, -0.06103611f, 0.05451719f, 0.23831578f, -0.07702840f, -0.15150008f, 
    -0.20780236f, -0.94392365f, 0.05052523f, -0.20313321f, -0.34414154f, -0.08722708f, -0.09591796f, -0.69368386f, 
    -0.10783122f, 0.32072315f, -0.06325873f, -0.31921315f, 0.04556926f, -0.39470059f, 0.25426596f, -0.63001108f, 
    0.42847821f, -0.74477565f, 0.40286037f, -0.58749521f, -0.08784981f, 0.09663896f, 0.25422236f, -0.28371531f, 
    -0.05329072f, -0.21493486f, 0.06721005f, 0.17267755f, -0.38980907f, -0.06075267f, 0.16035707f, -0.41329867f, 
    -0.01946505f, -0.10202648f, 0.07886596f, -0.32671502f, 0.07647324f, -0.24364866f, -0.27515987f, 0.17865834f, 
    -0.02921527f, -0.60629207f, -0.01932959f, 0.33706808f, -0.16711591f, -0.00355926f, -0.02787345f, 0.03300612f, 
    0.07672440f, -0.10586143f, 0.03824878f, 0.59763205f, 0.38900331f, -0.06411460f, -0.12649848f, -0.33100858f, 
    0.14702019f, -0.10704063f, -0.20766529f, -0.33811969f, 0.32228509f, 0.11382710f, 0.26832786f, -0.31197500f, 
    -0.13975424f, 0.08611822f, 0.04661723f, 0.05632791f, 0.17749171f, -0.20623481f, 0.02015306f, -0.19783436f, 
    -0.16105334f, 0.10936972f, -0.04754211f, 0.46140754f, -0.10593462f, -0.20644310f, 0.31222987f, 0.18886229f, 
    0.26726168f, -0.45088851f, -0.00249394f, 0.11474719f, 0.08916809f, 0.28743252f, 0.12332631f, -0.32457602f, 
    0.24922800f, -0.37776062f, -0.08803737f, 0.27390400f, 0.03765023f, 0.39740419f, 0.22338988f, -0.22131568f, 
    -0.11278306f, 0.42337885f, 0.02453616f, -0.63968128f, 0.09866620f, -0.54692978f, -0.24228716f, -0.12762128f, 
    -0.07653327f, -0.05977083f, -0.03443137f, -0.20250522f, -0.28638849f, -0.04309649f, -0.05602238f, -0.40829870f, 
    -0.80778772f, 0.09948243f, -0.07213027f, -0.82869631f, 0.06785932f, -0.02627830f, 0.19318931f, -0.30985481f, 
    0.32010558f, -0.00669132f, -0.00211320f, 0.07281870f, -0.30565625f, -0.67272055f, 0.04804228f, -0.26998591f, 
    0.13747624f, 0.00507972f, -0.07206234f, -0.29055828f, 0.01994245f, -0.13838926f, -0.03208742f, -0.22292985f, 
    0.15517831f, 0.02548169f, 0.02200555f, 0.01557282f, -0.05918270f, 0.39666229f, 0.14817666f, -0.22393052f, 
    -0.50985235f, 0.15151696f, 0.03476340f, -0.48258740f, 0.06428322f, 0.12330410f, -0.99617946f, -0.22325797f, 
    -0.36289477f, 0.04071023f, -0.10053948f, -0.08460262f, -0.70941782f, -0.68245441f, -0.39747950f, 0.13869965f, 
    0.05597698f, 0.32097024f, -0.01365197f, -0.00458161f, 0.00990180f, 0.25081262f, 0.31916797f, -0.94868737f, 
    -0.39792514f, -0.05959133f, -0.09185712f, 0.06395657f, 0.26587266f, -0.05267809f, -0.00958740f, 0.53431761f, 
    0.36654180f, -0.04740176f, 0.05545577f, 0.26105309f, -0.67253870f, 0.09035183f, -0.26249516f, -0.10100973f, 
    -0.04459935f, -0.07090306f, 0.32906318f, -0.08850399f, -1.03731775f, -0.23964752f, -0.11488875f, 0.04844611f, 
    -0.41154808f, -0.01628965f, 0.00574407f, -0.96233588f, 0.52025449f, 0.07457475f, -0.00006701f, 0.19293128f, 
    0.04136614f, -0.28663376f, -0.08494754f, -0.06472568f, 0.01265888f, 0.10342517f, -0.02417864f, 0.13519219f, 
    -0.34864581f, -0.00013688f, 0.31898510f, -0.01422215f, -0.13122067f, -0.14557770f, 0.12932833f, 0.08324977f, 
    -0.18009187f, 0.09573108f, 0.21339791f, -0.10863928f, -0.17057894f, -0.03110176f, 0.05540241f, 0.10085498f, 
    -0.06663283f, -0.96772158f, 0.00404172f, -0.14982800f, 0.06791670f, 0.26452696f, 0.23193893f, -0.06984015f, 
    -0.27527508f, -0.12554060f, 0.03920268f, -0.08269069f, -0.15795156f, -0.15456772f, -0.00592381f, 0.06819151f, 
    0.01034306f, 0.06250191f, 0.12365292f, 0.32002848f, -0.44343284f, -0.08791745f, 0.28025371f, -0.27624977f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08223907f, 0.09520160f, 0.01849730f, 0.08832430f, 0.04278620f, 0.15140569f, -0.07116155f, -0.28551087f, 
    -0.24826851f, -0.06943987f, 0.30381653f, -0.07549014f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
