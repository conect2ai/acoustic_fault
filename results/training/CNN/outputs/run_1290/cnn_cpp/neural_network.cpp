#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31856614f, 0.06673919f, -0.51008618f, -0.56506610f, -0.67728955f, 0.04270871f, 0.00248441f, -0.01967232f, 
    -0.00397794f, 0.44218451f, 0.21976069f, 0.28341636f, 0.04657495f, -0.02202094f, -0.17427309f, -0.01669057f, 
    0.16931340f, 0.31845582f, 0.09452488f, -0.19268990f, 0.02847847f, -0.02326004f, -0.12377714f, -0.27986214f, 
    0.07152287f, -0.98062873f, -0.38579404f, -0.08711234f, 0.49990863f, 0.64020628f, 0.09908064f, -0.41005123f, 
    0.19788866f, 0.30179566f, -0.24887301f, 0.08757655f, 0.13885827f, -0.05731335f, 0.21770827f, -0.05063736f, 
    -0.03639374f, -0.08769446f, -0.16429508f, -0.23795119f, -0.00992311f, -0.03982187f, 0.02313870f, -0.10285663f, 
    -0.11879981f, -0.00382490f, -1.05553353f, 0.19149789f, 0.15096757f, -0.80749607f, -0.25906014f, -0.29715347f, 
    0.21856305f, 0.35091293f, 0.48233888f, 0.24864839f, -0.26674482f, -0.18339710f, -0.19485277f, -0.18770276f, 
    0.08452277f, -0.04204876f, 0.30043283f, 0.06490521f, 0.19091359f, -0.04689137f, -0.17490737f, -0.03918213f, 
    0.04503484f, -0.21504076f, -0.30295962f, 1.19552374f, -0.47697952f, -0.40190524f, -0.08999930f, -0.30960330f, 
    0.59356153f, 0.23615147f, 0.56916559f, -0.20288719f, -0.17000991f, 0.01666455f, 0.13562693f, -0.16025925f, 
    -0.24484780f, 0.05071564f, 0.27749789f, -0.13816251f, 0.14108922f, -0.06481201f, -0.31723124f, 0.06329805f, 
    0.04258503f, -0.12974131f, 0.04409988f, 0.04708023f, 0.11452829f, -0.13502000f, -0.45293215f, -0.60493541f, 
    0.69614244f, -0.29295659f, -0.18233868f, 0.19760945f, -0.31118801f, -0.23968007f, -0.07504787f, 0.20306903f, 
    0.34326857f, 0.06620357f, -0.27150431f, -0.22759816f, 0.17859171f, -0.40984592f, -0.05155769f, 0.17211540f, 
    0.36262575f, 0.16765140f, 0.03172503f, 0.12345494f, 0.17292096f, -0.44019666f, -0.26777631f, -0.50815445f, 
    0.11570135f, 0.17427853f, 0.21510887f, 0.25878644f, -0.10060562f, -0.03752959f, -0.33169651f, 0.56319255f, 
    -0.17145450f, 0.13543670f, 0.03382807f, -0.08369949f, -0.09373342f, -0.02079860f, 0.16767387f, -0.09510395f, 
    -0.56447726f, -0.17539984f, 0.03935071f, 0.32827869f, 0.26301125f, 0.33598992f, -0.44732723f, 0.30480313f, 
    0.30594748f, -0.15372011f, 0.22057202f, -0.09995373f, 0.20296121f, -0.11440309f, 0.30144185f, 0.24807814f, 
    0.10475639f, -0.14688824f, -0.26490042f, -0.34140378f, -0.17080192f, 0.32197770f, 0.17748673f, -0.20194870f, 
    -0.32892913f, 0.23860410f, -0.22417623f, 0.03529644f, 0.31979397f, -0.00630466f, -0.32242900f, 0.25949070f, 
    -0.11660131f, 0.24283971f, 0.47061437f, 0.33600733f, -0.09759731f, 0.15964514f, 0.31641093f, 0.22407916f, 
    0.10177597f, 0.26179120f, 0.06238895f, 0.04758878f, -0.16763647f, 0.34034950f, -0.20542148f, -0.04245745f, 
    0.10515242f, -0.15958980f, -0.16842812f, 0.15771998f, -0.05075705f, 0.01085117f, 0.16567060f, -0.10433932f, 
    -0.30563864f, -0.30715114f, -0.37612987f, -0.11003018f, -0.27617645f, -0.13388611f, -0.23024209f, -0.62626606f, 
    -0.54378200f, -0.12358257f, 0.15121286f, -0.08763861f, -0.07700803f, 0.07600489f, 0.01741732f, -0.04466598f, 
    -0.24188699f, -0.08431357f, -0.06237033f, -0.19188742f, -0.15492576f, -0.08496437f, 0.01787926f, -0.40405083f, 
    -0.45758963f, -0.21208458f, -0.20717721f, -0.01149612f, 0.05478324f, 0.32998958f, 0.16145542f, -0.21107382f, 
    -0.02793921f, 0.28638741f, 0.38880175f, 0.22435445f, -0.00093073f, -0.47011986f, -0.11566778f, 0.40245155f, 
    -0.21137029f, -0.16352387f, 0.13907425f, -0.07569942f, 0.17608853f, -0.08378378f, 0.12316944f, 0.16098659f, 
    -0.10383983f, -0.06270540f, -0.35641381f, -0.45247805f, -0.19472203f, -0.02629822f, -0.14646268f, 0.06993000f, 
    -0.27953455f, -0.37114489f, -0.17442000f, 0.03988035f, -0.10390454f, -0.14660609f, -0.05560248f, -0.09123787f, 
    -0.10810684f, -0.05540722f, 0.22047785f, -0.06277480f, -0.07345813f, 0.26235083f, -0.00521592f, 0.17189980f, 
    0.11627346f, 0.20229432f, 0.16503930f, -0.54037327f, -0.28613016f, -0.38053855f, -0.05991642f, -0.31313679f, 
    -0.30634427f, -0.04321862f, -0.09024134f, 0.05989350f, -0.16101196f, -0.08544543f, -0.20913632f, -0.45136133f, 
    -0.39808699f, 0.07448152f, 0.03116188f, 0.02581650f, -0.09545464f, 0.09879208f, 0.10435677f, 0.08295757f, 
    -0.24554257f, 0.02738040f, -0.10116404f, -0.03942350f, 0.19698200f, -0.16297910f, -0.58212459f, -0.66585398f, 
    -0.11705887f, 0.24550040f, -0.09674222f, 0.18695207f, 0.31196925f, -0.08050423f, 0.33424085f, 0.47307888f, 
    0.10712896f, 0.27224422f, -0.11377581f, -0.03889387f, -0.09019955f, -0.22803923f, 0.06752297f, -0.21996976f, 
    0.12868233f, -0.10553525f, 0.29194736f, -0.14748247f, -0.07395961f, 1.09028947f, -0.12404144f, -0.32898569f, 
    -0.52542341f, -0.64459121f, 0.16188392f, 0.28617030f, 0.35939530f, 0.05370294f, 0.14299241f, -0.26779574f, 
    0.08366176f, 0.11667603f, 0.07555648f, -0.27534881f, -0.07723635f, -0.06714075f, 0.02792845f, -0.14949933f, 
    0.22330461f, 0.25399661f, -0.05778932f, -0.07586596f, 0.06892594f, 0.28609502f, 0.11618584f, -0.36479464f, 
    0.23561868f, -0.27281296f, 0.75219548f, -0.16520725f, 0.40824383f, 0.10498817f, -0.33123699f, -0.26498640f, 
    -0.07115094f, -0.00868982f, 0.14631467f, -0.38123721f, 0.11831393f, 0.23073635f, -0.21585210f, 0.20858529f, 
    0.17608231f, -0.14771774f, -0.07255534f, -0.18254638f, -0.22813617f, 0.20045634f, 0.20807542f, 0.08768398f, 
    0.57702011f, 0.28313082f, 0.21591994f, -0.06489564f, -0.40432727f, -0.50280112f, 0.05429037f, 0.43176204f, 
    -0.08724219f, -0.02740950f, -0.37874407f, -0.24638730f, 0.01527485f, 0.08503147f, 0.44109559f, 0.37817749f, 
    -0.09754332f, -0.25768283f, -0.20300029f, -0.04844551f, -0.10923544f, -0.23296510f, 0.04838696f, -0.15358174f, 
    0.22580153f, -0.09658265f, -0.01272042f, -0.10488306f, 0.24798751f, 0.06346808f, 0.23657243f, -0.28457651f, 
    -0.23905416f, -0.15652901f, -0.06771754f, -0.02043190f, 0.23695365f, -0.31665146f, 0.16535954f, 0.07458202f, 
    0.08935290f, -0.02401331f, 0.20914011f, -0.04546938f, -0.20327565f, 0.19924280f, 0.12217247f, 0.05155684f, 
    0.38320225f, -0.56909961f, -0.01367314f, -0.55175048f, -0.72502667f, -0.15764633f, 0.02209073f, 0.23590778f, 
    0.23061118f, -0.02068366f, 0.24907002f, 0.24721172f, 0.44776309f, 0.05616336f, 0.11888334f, -0.26986203f, 
    -0.17673568f, -0.11796203f, -0.08905122f, 0.08047332f, -0.14982389f, 0.02571031f, 0.01234216f, -0.22756955f, 
    0.32801551f, -0.21542782f, -0.72057438f, -0.74553651f, 0.15633422f, 0.57070249f, 0.04908597f, 0.41777030f, 
    -0.23014487f, -0.52510655f, -0.19537739f, -0.50791413f, -0.17582195f, -0.15630354f, -0.06294669f, -0.35190344f, 
    -0.16408373f, -0.39233571f, -0.20095149f, 0.06969232f, -0.01568661f, 0.10304214f, 0.22456406f, -0.08713749f, 
    -0.42140019f, -0.29137638f, 0.08790481f, -0.27648959f, 0.04514743f, -0.00996047f, -0.34661320f, -0.20265807f, 
    -0.32770914f, -0.46474349f, -0.46658295f, -0.08842097f, -0.22034910f, 0.11841930f, -0.12186984f, 0.24236250f, 
    0.35436326f, 0.23793308f, -0.06768661f, 0.04448780f, 0.00385733f, 0.08864570f, 0.10246604f, 0.05911554f, 
    0.23307091f, 0.20980741f, -0.03289237f, 0.16198473f, -0.07317648f, 0.21212238f, -0.52317244f, -0.68781590f, 
    -0.05215806f, 0.02012010f, -0.06150878f, 0.28799859f, 0.32656211f, -0.25627750f, -0.08360132f, 0.07065975f, 
    -0.03616805f, 0.20401151f, -0.20544654f, -0.10972360f, -0.11601419f, -0.43614256f, 0.08088529f, -0.15597664f, 
    0.20395841f, -0.19842879f, -0.46327490f, 0.38621393f, 0.30889732f, 0.34815079f, 0.30067751f, -0.04267590f, 
    -0.01100774f, -0.21523766f, 0.06441256f, 0.06059623f, -0.06986160f, 0.04246380f, -0.00916760f, 0.40261066f, 
    -0.18654495f, -0.17298092f, 0.21576083f, -0.09492218f, -0.15770383f, -0.13489203f, 0.22738042f, 0.02741351f, 
    0.08637878f, 0.15040281f, -0.02274284f, -0.27654380f, 0.25134167f, 0.15839684f, 0.48968199f, -0.91850036f, 
    0.07578154f, 0.50879306f, -0.23545699f, -0.57604682f, -0.05864106f, 0.11801220f, 0.14260224f, -0.44545919f, 
    -0.07999702f, 0.37530178f, 0.01600350f, -0.09138217f, -0.28684875f, -0.08164468f, 0.16534857f, -0.02707299f, 
    0.02164600f, 0.06086211f, -0.43388531f, -0.09438940f, -0.07983693f, -0.26869595f, 0.22198306f, -0.38590878f, 
    0.56096333f, 0.63923311f, -0.42998508f, -0.08834443f, -0.27930325f, 0.02477466f, -0.09092330f, 0.06632248f, 
    0.23992516f, -0.02707101f, -0.20812912f, 0.07935392f, -0.28446761f, 0.16997284f, 0.36010057f, -0.03245581f, 
    -0.21765402f, -0.16254045f, 0.40646625f, -0.01102475f, -0.01683339f, -0.17425604f, -0.02320083f, 0.11847694f, 
    0.73482072f, 0.43235284f, -0.45385155f, -0.77807915f, -0.43782085f, 0.48074669f, -0.08249373f, 0.09580256f, 
    0.11358889f, -0.03588758f, 0.11699662f, -0.16464935f, -0.01706937f, 0.22268525f, -0.17722985f, -0.19063568f, 
    0.23092413f, 0.19658254f, -0.09526555f, 0.02887758f, 0.26240912f, -0.18046971f, 0.03264754f, -0.03860047f, 
    -0.07717732f, 0.48579654f, -0.32242137f, -0.40956047f, -0.51227158f, 0.25494727f, 0.07592636f, -0.02713448f, 
    -0.33143243f, -0.23183693f, -0.43600115f, 0.33705348f, 0.63486010f, 0.24822575f, 0.12300169f, -0.09931148f, 
    -0.21596842f, -0.27262101f, 0.01519573f, 0.10500202f, 0.28428081f, -0.11207967f, -0.18145394f, -0.20550627f, 
    0.39683253f, 0.03379721f, -0.95241678f, -0.38810766f, 0.64684570f, 0.04681299f, -0.05039896f, 0.24049203f, 
    -0.06331368f, -0.04310092f, 0.30565718f, 0.53538287f, -0.01652331f, -0.14841111f, 0.24871506f, -0.24243976f, 
    -0.03568823f, -0.24809071f, -0.02298926f, -0.10494763f, 0.10274340f, 0.22804198f, 0.03503539f, -0.27648750f, 
    0.23442875f, 0.08325133f, 0.06188057f, -0.13535985f, -0.48950365f, -0.24174775f, -0.22506794f, -0.49422014f, 
    0.65812713f, 0.33741224f, -0.22866970f, -0.41086614f, 0.47603524f, 0.18207979f, -0.01320644f, -0.19767605f, 
    -0.10193933f, -0.24085893f, -0.07208463f, 0.02385494f, 0.47639042f, -0.30115899f, -0.35683292f, 0.11944868f, 
    -0.10245908f, -0.15691815f, -0.06221081f, 0.27362081f, -0.42072085f, 0.34189707f, -0.13674426f, -0.55847490f, 
    -0.14456448f, 0.21099520f, 0.16592285f, -0.04662502f, -0.05151745f, 0.01254074f, -0.05096620f, 0.53781688f, 
    -0.21578549f, 0.08605312f, -0.25931787f, -0.02983044f, -0.42357641f, -0.28055522f, 0.01217396f, 0.19201858f, 
    0.07602666f, 0.31073844f, 0.06607692f, 0.26978889f, 0.24527378f, -0.69915581f, -0.17059059f, -0.37220812f, 
    -0.19440347f, -0.45110676f, 0.31954303f, 0.07621427f, 0.09675808f, 0.41970712f, 0.53871340f, 0.15279298f, 
    0.12408000f, 0.10220762f, 0.13383289f, -0.26866511f, 0.06591790f, 0.12728089f, -0.25866249f, -0.04393619f, 
    0.05565446f, -0.02344537f, 0.31681165f, -0.01947062f, -0.14544827f, -0.11587600f, 0.37885994f, 0.53297788f, 
    0.58545363f, -0.31896722f, -0.41152853f, -0.13914530f, -0.18831834f, -0.42505461f, -0.30900657f, -0.32509062f, 
    0.09880540f, -0.18069786f, -0.04399922f, 0.10222081f, 0.34029990f, -0.04088267f, -0.14734341f, 0.09053982f, 
    0.06246800f, 0.22668736f, 0.22019890f, 0.05635338f, -0.24896699f, -0.43861330f, -0.39626753f, 0.80941176f, 
    0.19549762f, -0.35455835f, -0.53833336f, -0.64134401f, -0.17377245f, -0.08863357f, 0.32155049f, 0.40981570f, 
    0.16172455f, -0.08834615f, 0.03921045f, 0.04036800f, 0.17044576f, 0.14446215f, 0.41216317f, 0.03808088f, 
    -0.14059258f, -0.22358438f, -0.01853266f, -0.14678328f, 0.02465212f, -0.15512739f, 0.03227676f, 0.02084126f, 
    0.62052798f, 0.12317213f, -0.26911786f, -0.32929298f, -0.56816876f, 0.07818720f, 0.10017867f, -0.29457527f, 
    0.03254680f, 0.36895958f, -0.02605481f, 0.46693510f, -0.20218584f, -0.24679552f, 0.29116267f, 0.22743542f, 
    -0.11608585f, -0.11787733f, 0.28289357f, -0.21878698f, -0.32669672f, 0.09918766f, 0.01438455f, 0.14611821f, 
    -0.30937085f, 0.01493440f, 0.15229139f, 0.13384485f, 0.23991011f, -0.21303058f, -0.61887437f, 0.23740286f, 
    -0.14730118f, -0.01155888f, 0.59467071f, -0.06601649f, 0.65447187f, -0.42813188f, -0.25207996f, -0.07155707f, 
    0.16604173f, -0.34444982f, 0.17211173f, -0.27095303f, -0.26651803f, 0.17801104f, -0.18577310f, 0.36135098f, 
    -0.12852442f, -0.05087429f, 0.04172760f, -0.94128823f, -0.28161612f, -0.10462383f, -0.42449355f, -0.19083244f, 
    0.00916515f, 0.11067152f, 0.44543174f, -0.15538122f, -0.29694179f, -0.17992024f, -0.25021973f, -0.14379795f, 
    0.26882595f, -0.11253405f, 0.23654789f, -0.25338477f, -0.24028225f, -0.26257280f, -0.36663213f, 0.00845625f, 
    -0.05674478f, -0.17180006f, -0.24623421f, 0.04456966f, 0.48866165f, -0.19920181f, 0.21395953f, -0.25567421f, 
    -0.57660621f, -0.59490752f, 0.17099106f, 0.76912314f, 0.44829673f, 0.10565734f, -0.03741904f, -0.00743566f, 
    -0.14684001f, 0.19159521f, 0.15889251f, -0.03333383f, -0.00900963f, -0.36153218f, -0.01144507f, -0.16375570f, 
    0.01520705f, -0.00287561f, -0.02728789f, 0.13452041f, 0.33999795f, 0.44419625f, 0.53079158f, -0.32384408f, 
    -0.44280627f, 0.15694258f, -0.39549726f, -0.12095195f, 0.11083642f, -0.26291212f, -0.12425447f, 0.10854926f, 
    0.24810924f, -0.08979892f, -0.33147913f, 0.00793473f, -0.19473854f, 0.08077069f, -0.07718560f, 0.22571094f, 
    0.10732421f, 0.13239512f, -0.06190407f, -0.14180799f, 0.11858068f, -0.20459563f, 0.09392513f, -0.24276873f, 
    -0.35745099f, 0.43949828f, 0.23077722f, 0.18483667f, -0.39652041f, -0.40964144f, -0.42802343f, -0.11490672f, 
    0.11436567f, -0.24120048f, 0.00964813f, 0.07234556f, -0.07937995f, -0.23215364f, 0.22028616f, 0.20036212f, 
    -0.25556630f, -0.03225641f, 0.14261180f, 0.18322381f, 0.21270511f, 0.11772946f, -0.00117916f, 0.36687094f, 
    -0.07665552f, 0.25052762f, 0.43629029f, 0.23302111f, -0.29059851f, -0.02212994f, 0.10774795f, 0.40562370f, 
    0.14846535f, -0.08178020f, 0.16122872f, -0.08652972f, -0.21913660f, -0.12813799f, -0.00472148f, -0.35580131f, 
    0.00217501f, 0.13143314f, -0.28436545f, -0.19916944f, -0.03568642f, -0.30295762f, -0.47151029f, 0.70500863f, 
    -0.18839526f, -0.13189444f, 0.09824650f, -0.80102539f, 0.27857491f, -0.31071159f, 0.05345416f, 0.46680862f, 
    0.30955884f, 0.55742657f, -0.48405528f, -0.31970286f, 0.58970284f, -0.26397195f, -0.42287588f, -0.16501887f, 
    0.15534317f, -0.05900420f, 0.31975934f, 0.14655223f, 0.11355682f, 0.14104131f, -0.18851727f, -0.01778277f, 
    -0.57896107f, -0.94880092f, -0.13793604f, 0.67365080f, 0.89760256f, 0.15266663f, 0.04892334f, -0.43387058f, 
    -0.51486969f, -0.14188908f, -0.16383325f, -0.07371368f, -0.07810646f, -0.07104111f, -0.03027320f, 0.10353499f, 
    -0.16787361f, 0.32177672f, 0.49964669f, 0.21739742f, -0.15057090f, -0.04689077f, 0.08797851f, -0.05027777f, 
    -0.23605925f, -0.67663878f, -0.12259468f, -0.18240492f, -0.32561123f, -0.30637342f, 0.10795693f, 0.25395426f, 
    -0.04462839f, 0.30935502f, 0.72484428f, -0.03986201f, 0.02522467f, 0.11606628f, 0.11323154f, 0.04690855f, 
    -0.08252217f, 0.08234599f, 0.00687235f, -0.25287974f, -0.02893680f, 0.02008779f, -0.01965956f, 0.09933211f, 
    -0.06092221f, 0.02644522f, -0.10714889f, -0.19078434f, 0.26819548f, 0.33220023f, 0.12969828f, -0.15198100f, 
    -0.39910087f, 0.52044666f, -0.44644850f, 0.27117738f, 0.20456761f, -0.34878930f, -0.04775926f, 0.31622306f, 
    0.09467258f, -0.21187584f, 0.09537616f, -0.03544089f, 0.21188198f, -0.00042894f, -0.04322660f, -0.29495004f, 
    -0.18215470f, 0.06662274f, 0.27906135f, -0.35930428f, -0.47616273f, -0.17870806f, -0.07362826f, 0.29935423f, 
    -0.10572891f, -0.37621999f, -0.33443260f, -0.19854353f, -0.41111758f, -0.01567836f, 0.12366875f, 0.30215463f, 
    -0.36830619f, -0.27906656f, -0.24750505f, -0.26804557f, -0.51997751f, 0.13907014f, -0.22874892f, 0.04161229f, 
    0.06085158f, -0.28685680f, 0.06679896f, -0.36831230f, 0.10882571f, -0.15736963f, -0.14826669f, 0.05687737f, 
    0.19188736f, -0.36972517f, -0.44887948f, -0.52649355f, -0.48968661f, -0.45598841f, 0.52212024f, 0.49561903f, 
    0.23333625f, 0.44653574f, 0.19458157f, -0.03101228f, -0.18277563f, 0.03105951f, -0.03102468f, 0.00296209f, 
    -0.26299843f, -0.03678031f, 0.03269829f, 0.18213129f, -0.07883824f, -0.69046259f, 0.00667614f, 0.26363283f, 
    -0.11664452f, 0.26257306f, 0.00018747f, -0.25010854f, 0.18129183f, 0.68000817f, 0.19070275f, -0.07549971f, 
    -0.28054610f, -0.02014195f, 0.20467964f, -0.04046718f, 0.28333139f, -0.35781473f, -0.07818059f, -0.07775649f, 
    -0.25910836f, 0.00210963f, -0.25903320f, 0.31352773f, 0.21096988f, -0.01397561f, 0.56974071f, -0.39736035f, 
    -0.02835930f, 0.32337135f, 0.44245645f, -0.13432403f, 0.17783736f, 0.13439754f, 0.07551930f, -0.44714269f, 
    -0.05315089f, -0.02182555f, -0.01808884f, -0.16078261f, -0.07042590f, -0.06495062f, -0.05790517f, 0.12455880f, 
    0.09473162f, -0.00721561f, 0.18491858f, 0.11424441f, -0.20860751f, -0.14207309f, -0.47523969f, -1.02977157f, 
    0.14774176f, -0.02210456f, -0.49033064f, -0.10824002f, 0.34270167f, 0.21823891f, 0.08070321f, 0.03478170f, 
    0.50136483f, 0.17275740f, -0.29973552f, -0.10069312f, -0.27957892f, 0.17418881f, -0.01259344f, 0.03990233f, 
    0.06469204f, 0.20350356f, -0.07781878f, 0.04709475f, -0.02265326f, -0.04676503f, -0.16090864f, -0.27273765f, 
    -0.72436982f, -0.22015925f, -0.06124664f, 0.33321485f, 0.55572265f, 0.03515754f, -0.09080721f, 0.02800645f, 
    0.33754495f, 0.40103191f, 0.19277154f, -0.10763224f, -0.09899995f, 0.10369741f, -0.13325146f, 0.06823738f, 
    0.35038894f, 0.38465253f, 0.44877660f, 0.09358151f, 0.00399741f, -0.07339955f, -0.28808081f, -0.21812305f, 
    -0.26907581f, 0.77082282f, -0.08409999f, 0.18875286f, -0.11292399f, -0.26785073f, 0.36535612f, -0.37550128f, 
    -0.16488478f, 0.46733618f, -0.34295502f, 0.31784326f, -0.22353579f, -0.07071551f, -0.10799300f, -0.02509950f, 
    0.06503654f, 0.40251407f, -0.16322011f, 0.03980264f, -0.08332414f, -0.10250197f, -0.12921044f, 0.05341740f, 
    0.27380130f, -0.19294633f, -0.46833184f, 0.56788474f, -0.15983818f, -0.85336834f, -0.46697125f, 0.02289083f, 
    0.09899841f, 0.33126226f, 0.26448664f, -0.03208916f, -0.31938294f, -0.03913581f, -0.04353285f, 0.12601368f, 
    -0.05120984f, 0.39954832f, -0.28071612f, 0.17798190f, -0.08629614f, -0.00022144f, 0.10948779f, 0.45161361f, 
    -0.41981667f, 0.00623669f, -0.45273820f, -0.71511710f, 0.09251075f, 0.14283539f, -0.66198552f, -0.45587710f, 
    0.60993409f, 0.02740020f, -0.19869453f, -0.26323426f, -0.14463195f, -0.19018485f, -0.10678470f, -0.06835529f, 
    0.12945251f, -0.21683452f, 0.18813555f, -0.37055185f, 0.01405333f, -0.18115474f, -0.26223627f, -0.05861776f, 
    0.18588145f, -0.18559049f, -0.13743816f, -0.17628010f, 0.42900866f, -0.74065918f, -0.41514519f, 0.24080721f, 
    0.03953269f, 0.59815085f, 1.02974904f, -0.42497289f, -0.30617574f, -0.40067574f, 0.08309378f, 0.06640729f, 
    0.06606941f, -0.28535044f, 0.00422081f, 0.04584261f, -0.13453414f, -0.04462649f, 0.21965373f, 0.19277911f, 
    0.04938098f, -0.25770289f, -0.03473013f, 0.11367643f, -0.00466334f, -0.11706325f, 0.10259916f, -0.16096117f, 
    0.25244272f, 0.12661073f, -0.37727994f, -0.37652713f, -0.00811546f, 0.31027463f, 0.05198227f, 0.11207119f, 
    -0.27484336f, -0.00019310f, 0.45352566f, -0.37650889f, 0.06312709f, 0.22203124f, -0.05874929f, -0.51120579f, 
    0.34114799f, -0.00283467f, 0.28355309f, 0.30796149f, 0.16237146f, 0.14210843f, 0.03883579f, 0.43592986f, 
    -0.16945545f, -0.79353881f, 0.27767542f, -0.16510352f, 0.18109831f, -0.44657877f, -0.59762430f, -0.31215498f, 
    0.05833437f, 0.54877496f, 0.37194535f, -0.17910907f, -0.23127778f, -0.24720669f, 0.01157393f, -0.31214595f, 
    -0.46143684f, -0.13045228f, 0.16637938f, -0.25295836f, -0.29957539f, 0.28985822f, 0.05528018f, 0.48155349f, 
    0.32423133f, 0.29023695f, -0.50873214f, 0.67449844f, -0.38807106f, -0.24177040f, -0.02366009f, -0.34723526f, 
    -0.28429100f, -0.24197304f, 0.16312265f, 0.21176665f, -0.23236685f, 0.14957413f, -0.07483421f, 0.13264689f, 
    -0.06335793f, -0.09252492f, 0.11387946f, -0.02179006f, 0.21814203f, -0.10993226f, 0.09891949f, 0.18321067f, 
    -0.63650656f, -0.11526521f, -0.15447195f, -0.52375650f, -0.45194691f, 0.02584935f, -0.20869777f, -0.01174276f, 
    -0.11098916f, 0.11203116f, -0.03560940f, -0.11920027f, -0.12644456f, -0.25788441f, -0.28650415f, -0.05414707f, 
    -0.36883253f, -0.34957883f, -0.16294882f, 0.06971811f, -0.31439468f, 0.20471753f, 0.29619232f, -0.06314088f, 
    0.04484074f, 0.46966499f, -0.92329997f, 0.37031209f, 0.36715397f, -0.04706734f, -0.54106510f, 0.40909982f, 
    -0.28118885f, -0.19843706f, -0.25952592f, -0.09551424f, -0.04777829f, 0.27814874f, -0.12754922f, 0.01328048f, 
    0.11696471f, 0.01656267f, -0.07193132f, 0.03452978f, 0.02904027f, 0.02026731f, -0.02851278f, 0.10015360f, 
    0.06704719f, 0.06551883f, -0.12007915f, -0.50399148f, -0.38223001f, -0.13639557f, -0.26478890f, 0.46053600f, 
    0.17630269f, -0.22427815f, -0.46517390f, -0.03762259f, -0.00608962f, -0.01189098f, -0.23768125f, -0.27141902f, 
    0.23960200f, 0.21426912f, 0.35991654f, 0.24874005f, -0.28310040f, 0.23374996f, -0.37590757f, -0.29430816f, 
    0.13363367f, -0.14272191f, -0.31133944f, -0.38747379f, 0.05563815f, 0.07161524f, 0.44649738f, 0.32608891f, 
    -0.06736402f, 0.12840405f, -0.13605627f, 0.08481729f, 0.42758033f, 0.29110074f, 0.06242564f, -0.02032363f, 
    -0.21777686f, -0.05105292f, -0.22571176f, 0.05018844f, -0.10598221f, 0.10577957f, 0.03165532f, -0.12617293f, 
    0.13785827f, -0.02184690f, 0.21827273f, -0.17833507f, -0.62442273f, -0.52604890f, 0.66584522f, 0.46733809f, 
    0.33714283f, -0.23856044f, 0.12750828f, 0.07512514f, -0.09775351f, -0.01737733f, 0.10696507f, -0.05486155f, 
    -0.21059246f, 0.68211168f, -0.34495988f, -0.36576763f, 0.10211596f, -0.07846533f, -0.07320423f, 0.19893435f, 
    0.20106219f, -0.19902015f, -0.23887216f, -0.15417454f, 0.23818178f, -0.32088503f, -0.19966614f, -0.23564877f, 
    0.14674158f, -0.43439546f, 0.40370709f, -0.46867621f, -0.43522573f, 0.22245154f, -0.67361492f, 0.32776451f, 
    0.23173131f, 0.39582682f, -0.08482078f, 0.16949834f, -0.17306636f, 0.13868798f, -0.00813468f, -0.46482748f, 
    -0.35027716f, 0.00440261f, 0.08928234f, 0.37427506f, -0.20243050f, -0.14932156f, -0.09703942f, -0.01706097f, 
    0.21829763f, 0.06648882f, 0.31270045f, 0.24857394f, 0.22971320f, 0.04568022f, -0.00024774f, 0.35975450f, 
    0.01485913f, 0.04763174f, 0.03702150f, 0.10150098f, -0.00412022f, 0.02175398f, 0.06889102f, 0.08461508f, 
    0.13370116f, -0.37699503f, -0.01468632f, 0.16879769f, 0.15091188f, -0.04577367f, 0.15165800f, 0.24564347f, 
    0.02163122f, -0.14731011f, -0.33975330f, -0.31034029f, -0.13882703f, -0.14982323f, 0.26871189f, 0.33370429f, 
    0.49845913f, -0.09351851f, 0.02360605f, -0.09017608f, -0.09288000f, 0.17330459f, -0.54837161f, -0.20603195f, 
    0.33592483f, 0.25219288f, -0.58620769f, 0.11408462f, 0.21115153f, 0.28758377f, 0.20350040f, 0.20871536f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02884484f, -0.02236026f, 0.00198319f, 0.26399961f, -0.17864078f, 0.23326929f, 0.16148670f, -0.30531126f, 
    -0.26064748f, 0.11965211f, 0.12442792f, -0.14195077f, -0.12484141f, 0.02623627f, -0.08258783f, -0.09309312f, 
    0.32301143f, 0.05207512f, 0.14503081f, -0.10277131f, -0.04063753f, -0.14375624f, 0.40274709f, 0.20419160f, 
    0.11477859f, 0.25208062f, -0.03322209f, 0.18975458f, 0.04749754f, -0.05597336f, 0.01944103f, 0.02911079f, 
    0.03859727f, -0.02810009f, -0.12845831f, 0.35244420f, -0.02848319f, 0.13199620f, -0.14605665f, 0.13371591f, 
    0.21283253f, 0.10566112f, -0.07494319f, -0.05429684f, -0.12527430f, 0.17377037f, 0.10547459f, 0.06901640f, 
    -0.26947144f, 0.06135561f, -0.03010366f, -0.20369753f, 0.24346845f, -0.00681464f, -0.01654456f, -0.10932313f, 
    -0.21024792f, 0.04802608f, -0.13065125f, -0.00799669f, 0.08847383f, 0.08812820f, -0.22605830f, -0.14004862f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00885828f, 0.01951677f, -0.04428159f, -0.00855333f, 0.00854674f, -0.01322558f, -0.04181860f, -0.04135809f, 
    -0.03774640f, -0.02374426f, 0.00027208f, -0.00588321f, -0.01541892f, -0.00644728f, -0.04000315f, 0.00408152f, 
    0.00134793f, -0.02972913f, 0.02033240f, -0.00763003f, 0.00054751f, -0.01135778f, 0.01808533f, 0.01711926f, 
    -0.01285684f, -0.01512388f, 0.00757554f, -0.02283316f, -0.03283964f, -0.03175332f, -0.01185670f, -0.03339948f, 
    -0.03992372f, -0.02066786f, 0.01465201f, -0.03731932f, -0.03891032f, -0.00159561f, 0.00049621f, 0.00413648f, 
    -0.03225630f, 0.02655586f, -0.01660413f, -0.00686335f, -0.00504782f, 0.01174253f, -0.04212771f, 0.02942762f, 
    0.01829658f, -0.00146069f, 0.02440184f, -0.01743799f, 0.01521894f, -0.00468203f, 0.03295998f, -0.02342109f, 
    -0.02039648f, 0.00781520f, -0.00658682f, 0.02056688f, -0.02844119f, -0.02593803f, -0.00880479f, -0.03675415f, 
    0.02098689f, -0.00835316f, -0.01766660f, 0.01641659f, -0.04260348f, 0.01738680f, -0.01847609f, -0.03757760f, 
    -0.03343820f, -0.01016311f, -0.01826830f, -0.03078993f, 0.01859759f, -0.03044957f, 0.01775322f, -0.03575964f, 
    -0.01128220f, -0.03254478f, -0.03001883f, -0.01119649f, -0.04002541f, -0.03169720f, -0.03998648f, 0.00370687f, 
    -0.01498843f, -0.00301375f, 0.00311051f, -0.00836116f, 0.01083796f, 0.02884542f, 0.01001329f, -0.01931413f, 
    -0.00556492f, -0.02493090f, 0.02864117f, -0.03116039f, -0.03587945f, -0.02079702f, 0.00776443f, -0.04273745f, 
    0.01584000f, 0.01475285f, 0.00836047f, -0.00882319f, -0.02900265f, -0.04137972f, 0.01907968f, 0.00661131f, 
    -0.02764890f, 0.02380213f, -0.03348940f, -0.02112214f, 0.02317752f, 0.00377836f, -0.04136450f, -0.01498937f, 
    0.02838374f, -0.02558463f, 0.00169199f, -0.04439282f, 0.00474332f, -0.03742199f, -0.02166318f, 0.01588181f, 
    -0.03994706f, -0.00001039f, 0.01563587f, -0.03235125f, -0.01321254f, 0.02289687f, 0.00412792f, -0.01783624f, 
    0.02593734f, -0.01416538f, -0.00538669f, 0.00746836f, -0.00012488f, -0.01915884f, -0.01914554f, 0.02091746f, 
    -0.00945129f, 0.02688305f, 0.00810721f, 0.01787406f, -0.00975237f, -0.02881494f, -0.03841132f, 0.00140530f, 
    0.02746905f, -0.00502552f, -0.00859202f, 0.02567630f, 0.02045737f, 0.01425179f, 0.01436528f, -0.02200991f, 
    -0.03683482f, 0.01372914f, -0.00794015f, -0.01961098f, -0.01565111f, -0.03859503f, 0.01227309f, 0.02430624f, 
    -0.04104280f, 0.02305651f, -0.03739993f, 0.01755890f, 0.02305407f, -0.00532404f, 0.00363123f, 0.02770238f, 
    -0.03808447f, -0.03968441f, -0.03991740f, -0.01859641f, -0.04156859f, -0.00026067f, -0.01103311f, 0.00034637f, 
    -0.02694263f, 0.00136767f, -0.03919349f, 0.00881481f, -0.03691525f, 0.02006060f, 0.01600522f, 0.01784316f, 
    -0.00232700f, -0.01682074f, 0.01364752f, 0.02851345f, -0.00578145f, 0.01920293f, -0.00867000f, 0.02685958f, 
    -0.02324496f, -0.01357297f, -0.03666571f, 0.00055130f, 0.02683542f, -0.00292676f, -0.02394471f, -0.00523671f, 
    0.02251121f, 0.01818214f, -0.00737843f, -0.02483923f, -0.00021027f, -0.00490180f, -0.03463394f, 0.02600387f, 
    -0.02987341f, -0.02737377f, -0.04292417f, -0.02452694f, 0.01603090f, -0.02477196f, -0.03487347f, -0.00135657f, 
    -0.00227903f, 0.01763982f, 0.01363174f, 0.02720220f, 0.01697859f, -0.00193884f, -0.01081727f, -0.02322239f, 
    -0.03723770f, -0.02298115f, -0.03888343f, -0.02350944f, -0.00352697f, -0.00082831f, -0.03854940f, -0.02129752f, 
    -0.00236909f, -0.02725575f, 0.00890745f, 0.03278840f, 0.00898397f, 0.02062362f, 0.00571291f, 0.00418680f, 
    -0.00196825f, -0.00362530f, -0.02792339f, -0.01476610f, -0.00474475f, 0.00071843f, -0.00757110f, 0.01471007f, 
    0.02742102f, -0.00092756f, -0.02623937f, -0.02774072f, 0.02058038f, 0.02074271f, -0.02639914f, -0.03548326f, 
    0.01208123f, 0.00008178f, -0.01979880f, -0.01413563f, -0.02460751f, 0.00896711f, -0.03406527f, 0.00163451f, 
    -0.03180885f, 0.02304315f, 0.00726944f, -0.04396545f, 0.01631700f, -0.01413242f, 0.02199676f, -0.02764796f, 
    0.02427355f, -0.00827183f, -0.03751156f, 0.02062439f, -0.02611560f, -0.03900566f, 0.01965598f, -0.00465385f, 
    0.02489083f, -0.01703259f, 0.01083095f, -0.01739249f, 0.00676071f, 0.01261466f, -0.03012865f, -0.00306919f, 
    0.00257870f, -0.03257568f, -0.02688100f, -0.02891702f, 0.01650434f, 0.01461257f, -0.00033544f, -0.03951756f, 
    0.02681838f, -0.03462212f, 0.02273507f, -0.01067529f, 0.00300422f, -0.02011827f, 0.00796427f, -0.01436797f, 
    0.01557862f, 0.01515139f, -0.03076017f, -0.04430675f, 0.02995244f, 0.03762700f, -0.02991465f, -0.02038679f, 
    0.01590020f, 0.01005550f, -0.01386265f, -0.01443203f, -0.01242669f, 0.01769452f, 0.00073697f, -0.01639182f, 
    -0.02406279f, -0.01024900f, -0.01434801f, -0.01045246f, 0.02536001f, 0.01836855f, -0.00489110f, -0.02044694f, 
    0.01003951f, -0.00830390f, 0.02102814f, -0.03756568f, 0.02259088f, -0.01869589f, -0.02308425f, -0.03116598f, 
    -0.00126923f, 0.01606733f, 0.02051137f, -0.02139099f, -0.00324022f, -0.03905654f, -0.02036356f, -0.03330218f, 
    -0.02492315f, 0.00369349f, -0.03875494f, 0.03342537f, 0.00236763f, 0.01388194f, 0.00760492f, 0.00585219f, 
    0.00361280f, 0.02562442f, -0.00484957f, 0.02689441f, -0.00431805f, 0.02437796f, -0.02276045f, 0.02305605f, 
    -0.03638405f, 0.00660567f, -0.02685927f, 0.01420459f, -0.02206390f, -0.00698719f, -0.00132193f, -0.03927333f, 
    -0.00049478f, -0.01337701f, -0.02215973f, -0.00056064f, 0.00926024f, -0.01623334f, -0.02803033f, 0.03098659f, 
    -0.01193145f, 0.01646264f, -0.01494723f, -0.03703732f, -0.01653121f, -0.00215105f, 0.02294613f, -0.00941376f, 
    0.01017417f, -0.00246063f, 0.00445270f, -0.03966117f, 0.02130665f, 0.01180193f, -0.02601789f, 0.01770743f, 
    -0.01359949f, -0.00558620f, -0.02050012f, -0.02149548f, 0.00070246f, -0.02930972f, -0.01893632f, 0.01012850f, 
    0.00585264f, -0.00405096f, 0.03235740f, -0.01780707f, -0.01720544f, -0.01298406f, 0.02162186f, -0.01178347f, 
    -0.00062724f, -0.02634824f, -0.01247443f, -0.00217066f, -0.03488196f, -0.01356283f, -0.01289744f, 0.02088182f, 
    -0.00084695f, 0.02592623f, 0.00235933f, -0.02042323f, -0.01287720f, -0.02548190f, -0.04202743f, -0.03816803f, 
    0.01114142f, 0.02286919f, -0.02825452f, -0.00982057f, -0.00526021f, -0.00344146f, 0.02283611f, -0.01550971f, 
    0.02318450f, -0.01916871f, -0.02692432f, -0.03918804f, 0.00227674f, -0.01521950f, -0.02801489f, -0.01008790f, 
    -0.00376448f, 0.01861020f, 0.02847355f, -0.01565418f, -0.02177121f, -0.02734432f, 0.00112035f, -0.02483527f, 
    -0.02895428f, -0.00834896f, -0.03212612f, -0.00215480f, -0.00348343f, -0.04021775f, -0.03603664f, 0.00809352f, 
    -0.00295236f, -0.01119013f, 0.02939093f, 0.01693618f, -0.02040365f, 0.00623434f, 0.01821742f, 0.00657166f, 
    -0.00140556f, -0.00265004f, 0.00343930f, -0.02505521f, -0.00705468f, 0.02354971f, -0.02330482f, -0.00631290f, 
    0.03358922f, -0.01598657f, 0.02145308f, 0.01159926f, -0.03223759f, 0.00148220f, -0.02191866f, -0.02603120f, 
    0.01050334f, -0.02155162f, -0.02773189f, -0.03163887f, -0.01006953f, 0.00992697f, -0.01111501f, -0.02717411f, 
    -0.02861954f, 0.00462083f, -0.01895537f, -0.01171025f, 0.01671046f, 0.03053513f, 0.00871545f, -0.01849149f, 
    -0.03694364f, -0.02274718f, -0.03408699f, -0.03986106f, -0.02999309f, 0.02520711f, -0.02371546f, 0.01100964f, 
    0.00097130f, 0.01577364f, -0.01576743f, -0.03684732f, -0.02587583f, 0.02260210f, 0.02406924f, 0.00473107f, 
    -0.02445875f, 0.02664320f, -0.01666681f, 0.01793995f, -0.03335755f, -0.01743587f, 0.00726086f, -0.01212524f, 
    -0.03168948f, -0.02075309f, 0.01150340f, -0.01830277f, 0.00298581f, -0.00582845f, 0.00324436f, -0.04176521f, 
    -0.03896777f, -0.04378314f, -0.02008708f, 0.01595107f, -0.03682293f, -0.03636439f, -0.00306420f, -0.00287790f, 
    0.02170381f, 0.02378787f, 0.01303202f, -0.02721750f, 0.00981657f, 0.01028009f, -0.02980653f, 0.00503473f, 
    -0.02653214f, -0.02310586f, 0.02758839f, -0.04437630f, 0.00429768f, 0.00832469f, 0.00255628f, 0.00144355f, 
    -0.03107944f, -0.00231742f, -0.01158658f, 0.00544517f, -0.03964399f, -0.01714312f, -0.00850555f, -0.01787646f, 
    0.01574631f, 0.01183826f, -0.04025581f, 0.00985423f, 0.00728630f, -0.00465333f, 0.00174442f, -0.01290664f, 
    0.01998827f, -0.03088496f, 0.02223318f, -0.04217073f, -0.00710610f, -0.03356181f, 0.01002742f, -0.01484401f, 
    -0.03078015f, 0.02329025f, -0.03271661f, -0.00259935f, -0.00170166f, 0.00839515f, 0.00144798f, -0.01935732f, 
    0.01455127f, 0.00109226f, -0.00838588f, 0.00888168f, -0.02181151f, 0.01862753f, -0.02972092f, 0.02258173f, 
    0.01576890f, -0.02687356f, -0.01041675f, -0.02916166f, -0.00478434f, 0.02223333f, -0.01830002f, -0.01190771f, 
    -0.01759065f, -0.03599853f, -0.02343938f, -0.03548642f, 0.02079003f, -0.00624966f, -0.01902113f, 0.04022704f, 
    -0.01885763f, 0.02643771f, 0.01599099f, 0.01426349f, -0.02158834f, 0.00404616f, -0.03826375f, -0.03653078f, 
    -0.01929015f, -0.03062966f, -0.03465948f, 0.02364610f, 0.00969038f, -0.02526873f, -0.02945549f, -0.03634335f, 
    0.01650157f, 0.01169178f, -0.02496551f, -0.01037642f, 0.00130725f, -0.00561794f, -0.00340039f, -0.00452241f, 
    0.02154578f, 0.02584510f, -0.02821149f, -0.00561655f, 0.01347868f, -0.00614896f, 0.02306621f, -0.03651847f, 
    0.02868164f, 0.02589475f, 0.01248525f, 0.02192849f, 0.01459470f, -0.00348210f, -0.03879261f, -0.04283122f, 
    0.01573470f, 0.00790878f, 0.01085962f, 0.01189743f, -0.01604604f, 0.00060440f, 0.00714661f, 0.00677524f, 
    -0.01268172f, -0.01612538f, 0.02024619f, -0.03905920f, 0.02813896f, 0.01010975f, -0.02431650f, -0.03616911f, 
    -0.02173539f, -0.01603639f, 0.00870630f, -0.00531362f, -0.03226659f, 0.00217268f, 0.00825484f, 0.00310002f, 
    0.02588429f, -0.02281690f, -0.04248757f, 0.02578275f, 0.02567386f, 0.03559625f, 0.00695856f, -0.01864541f, 
    -0.02085196f, -0.00690610f, -0.02835661f, -0.00603984f, 0.01948414f, 0.00374696f, -0.01819808f, 0.01443050f, 
    -0.00241074f, -0.01841653f, -0.00894711f, 0.00357952f, 0.01980835f, -0.03599993f, -0.00453184f, -0.03622590f, 
    -0.00985877f, -0.03797704f, -0.03006523f, -0.03789516f, 0.01192652f, 0.02223395f, -0.02543305f, 0.01934194f, 
    -0.02105978f, 0.00833495f, -0.01241314f, -0.03851701f, -0.03738846f, 0.00909176f, 0.00480976f, 0.02132990f, 
    0.02327948f, 0.01349812f, 0.00009343f, -0.01245447f, -0.02070070f, -0.01796142f, 0.02499153f, -0.03347889f, 
    -0.00899037f, -0.00765274f, 0.00460509f, -0.01189850f, -0.04193348f, -0.00829294f, -0.02199757f, 0.01638488f, 
    0.01697116f, -0.03783774f, 0.01278502f, -0.02369562f, -0.02280288f, 0.01190467f, 0.02210523f, -0.01462202f, 
    -0.04200663f, -0.02957243f, 0.01135786f, 0.00664277f, 0.01372964f, 0.01515455f, -0.00859335f, 0.03006090f, 
    -0.02487053f, -0.00270751f, -0.03421162f, 0.02059477f, -0.01771901f, -0.03771231f, -0.00049664f, -0.04115454f, 
    0.02521860f, 0.01754939f, -0.03050078f, 0.01293480f, 0.02232876f, 0.02637083f, 0.01780386f, 0.00840626f, 
    -0.00906806f, -0.00407988f, 0.01578644f, 0.01428569f, 0.02690016f, 0.01348436f, 0.01481870f, -0.02950001f, 
    0.01800049f, 0.02992529f, 0.03703696f, 0.01170015f, -0.01859896f, -0.01250244f, -0.01144969f, -0.01966236f, 
    0.00059990f, -0.01795360f, -0.00182368f, 0.02574030f, 0.01549630f, -0.02055262f, 0.01477265f, 0.04092824f, 
    0.00118688f, -0.01942317f, 0.03232728f, 0.00753663f, 0.01037808f, 0.01406413f, -0.01862706f, -0.00320291f, 
    0.02792905f, 0.02923659f, 0.02134511f, -0.04002769f, -0.00674635f, 0.00344648f, 0.01126155f, -0.03286846f, 
    0.00173921f, 0.02123119f, -0.02569646f, -0.01815116f, -0.00900665f, -0.02836358f, -0.04156212f, 0.02847677f, 
    -0.03840209f, -0.03982866f, -0.03863390f, -0.02837267f, 0.01846124f, -0.01620764f, -0.03154670f, -0.01007545f, 
    -0.01225189f, 0.00225438f, -0.01942946f, -0.03499435f, 0.00174639f, -0.01321868f, -0.00278750f, -0.01925072f, 
    -0.04011363f, 0.02636991f, -0.03953366f, -0.00506541f, -0.04619757f, 0.00858252f, -0.01547327f, -0.00906310f, 
    0.01625590f, 0.00089163f, 0.01716513f, -0.01929135f, 0.01433712f, -0.02703553f, 0.03000738f, -0.00489345f, 
    0.02142786f, -0.03261182f, -0.00219035f, -0.01046615f, -0.03773414f, 0.01307012f, -0.01170355f, 0.00113874f, 
    -0.00038319f, -0.00250404f, -0.03592036f, 0.02763290f, -0.03979872f, 0.02333809f, 0.01363107f, 0.02296327f, 
    -0.04953210f, -0.03989111f, -0.00509062f, -0.02970097f, -0.01283088f, 0.00164873f, -0.03002609f, -0.02528014f, 
    -0.00150135f, 0.01650026f, -0.02739110f, 0.00996094f, -0.00610981f, -0.03116672f, -0.00030650f, -0.02261303f, 
    -0.01677594f, -0.02113250f, -0.01346688f, -0.02506601f, 0.03021519f, -0.01713948f, 0.01643370f, -0.00141257f, 
    -0.03812087f, -0.02992396f, 0.01071916f, 0.00119958f, 0.02873868f, 0.02738273f, -0.03492735f, -0.01086572f, 
    0.02641104f, 0.01553711f, -0.02786942f, -0.02242407f, 0.02164950f, -0.00542095f, -0.00294775f, -0.02528384f, 
    0.01597981f, 0.00139374f, 0.00973565f, 0.01938936f, 0.00276424f, -0.03611739f, 0.01277480f, 0.01615485f, 
    -0.03446783f, -0.01171981f, 0.00148255f, 0.03171486f, -0.03906181f, -0.04645767f, -0.03338245f, -0.00156246f, 
    -0.00899122f, 0.03229022f, -0.02874273f, 0.02048817f, 0.02062926f, -0.00784002f, -0.04270557f, 0.00195017f, 
    -0.01822191f, -0.01028860f, 0.00900376f, 0.00511451f, -0.04289152f, -0.04001641f, -0.02322113f, -0.02833092f, 
    -0.00142912f, -0.01687161f, -0.00708495f, 0.02650457f, -0.01330526f, 0.00553838f, 0.01574466f, 0.02411562f, 
    -0.00504700f, -0.02776830f, -0.00479577f, -0.01708349f, 0.01740196f, -0.04316244f, 0.00048647f, 0.02383829f, 
    -0.03629408f, -0.03589465f, -0.02731171f, 0.00538956f, 0.01781281f, -0.03589466f, -0.00966521f, 0.00272516f, 
    -0.02510854f, -0.03653957f, -0.02546594f, 0.01687555f, -0.00982478f, -0.00608535f, -0.02098147f, -0.01670403f, 
    -0.02530104f, 0.00424971f, -0.01983999f, -0.00542895f, 0.01778165f, -0.00139977f, 0.00714776f, -0.03197445f, 
    -0.04616101f, -0.03967879f, -0.00641760f, -0.02181474f, 0.01521545f, -0.00293635f, -0.00644401f, -0.03683819f, 
    -0.03137304f, -0.02454527f, 0.02269607f, -0.01652407f, -0.02994591f, 0.02141508f, -0.01426529f, -0.02317179f, 
    -0.03651871f, -0.00204446f, 0.01557023f, 0.02117198f, -0.03833212f, -0.02032096f, -0.02292816f, 0.01085132f, 
    -0.00099982f, 0.00381618f, 0.02259282f, 0.00845555f, 0.02982990f, -0.03136470f, 0.00938457f, -0.02733686f, 
    -0.00936865f, -0.02840809f, -0.02958529f, -0.01089597f, -0.00165866f, -0.02123475f, -0.03623660f, -0.02848648f, 
    0.02200431f, -0.00058591f, -0.02144050f, -0.00801931f, -0.00444439f, -0.03045209f, -0.05066611f, -0.03952466f, 
    -0.03708750f, 0.01519194f, 0.01504425f, -0.03150086f, -0.02678357f, 0.00205254f, -0.02534378f, -0.03113587f, 
    0.00294395f, 0.01564845f, 0.02329392f, 0.01835492f, -0.00074894f, -0.03545486f, 0.01029478f, -0.03999527f, 
    0.03059720f, 0.02946808f, -0.00409214f, -0.00099921f, 0.02060355f, 0.01122625f, 0.01757299f, -0.01550709f, 
    0.01275464f, -0.01830895f, -0.00141124f, -0.00865762f, 0.00933213f, 0.01287164f, -0.03255710f, -0.02490442f, 
    0.01857359f, 0.00477040f, -0.00965540f, 0.01387630f, 0.00396611f, -0.03999395f, -0.01855945f, -0.04157438f, 
    -0.00856781f, -0.02315962f, -0.03076215f, -0.01031845f, 0.00921916f, -0.01939819f, -0.01342873f, -0.02831947f, 
    0.00389260f, 0.01252830f, -0.02767321f, -0.01476770f, 0.01792581f, 0.01446538f, 0.01451966f, 0.01396388f, 
    -0.01234256f, -0.04514618f, 0.02097480f, 0.00229354f, -0.00194599f, 0.01152104f, -0.01301400f, 0.00584877f, 
    0.00499625f, 0.01417162f, -0.00479566f, 0.01365736f, 0.00869793f, -0.00052403f, -0.01923040f, -0.02047045f, 
    -0.03138465f, 0.01521643f, 0.02228827f, 0.03002195f, -0.00378213f, -0.02916576f, 0.00494330f, -0.01191506f, 
    0.01054887f, -0.02457484f, -0.00103333f, 0.00876063f, 0.00716262f, 0.00167704f, 0.00051944f, -0.03761905f, 
    0.00491260f, -0.02823406f, 0.00915120f, -0.01562142f, 0.01494224f, 0.01233676f, 0.02886644f, -0.02310264f, 
    0.01081334f, 0.00973429f, -0.02119308f, 0.01022596f, 0.01454129f, 0.01780446f, -0.02807607f, -0.03776158f, 
    0.00766435f, 0.01071820f, 0.02077821f, -0.03571235f, 0.01817786f, 0.01792926f, 0.02981907f, -0.03309249f, 
    -0.00925720f, -0.02662770f, -0.03754676f, 0.03154377f, 0.02289494f, 0.02169331f, -0.00266824f, 0.01199650f, 
    -0.00367411f, 0.02677457f, 0.00424795f, 0.02134796f, 0.02953584f, -0.02402420f, 0.01928090f, -0.00170134f, 
    -0.02112186f, -0.01140288f, -0.05037284f, 0.01593266f, 0.00000760f, -0.04707576f, -0.00660905f, -0.00683380f, 
    0.00241695f, -0.00053201f, -0.01090689f, -0.01867593f, -0.01685918f, -0.01290109f, -0.01488253f, -0.03178796f, 
    -0.03696870f, 0.01812753f, -0.01929268f, -0.00506654f, -0.01267826f, 0.01625579f, -0.03818720f, 0.01940960f, 
    0.01908783f, -0.00715985f, -0.00683933f, -0.04053674f, -0.03445074f, -0.01852035f, 0.00904912f, 0.00778597f, 
    -0.00397698f, -0.02917163f, 0.01566821f, 0.00146604f, 0.00192655f, 0.00315175f, -0.03074742f, 0.01938425f, 
    -0.03424390f, -0.00590343f, -0.00816533f, 0.00347971f, -0.03967543f, -0.01429509f, 0.01463727f, -0.01586813f, 
    -0.01348812f, -0.00806267f, -0.03930210f, 0.00724963f, -0.02807831f, -0.03599177f, -0.02804846f, 0.00986150f, 
    -0.04561002f, -0.00924757f, 0.02738488f, 0.01643626f, 0.00420945f, -0.02004266f, 0.01530470f, -0.00138726f, 
    0.02384535f, 0.01399935f, -0.01365282f, 0.00436283f, -0.04723566f, -0.01192864f, -0.00283662f, 0.00977280f, 
    -0.03725122f, -0.02232145f, 0.02313581f, -0.01742207f, 0.02649390f, 0.02874844f, -0.02356607f, 0.01661713f, 
    -0.03020682f, -0.01321875f, 0.03151397f, 0.01867183f, 0.02715141f, 0.00471276f, 0.01464796f, 0.02249148f, 
    0.01791853f, 0.00416247f, -0.00830086f, -0.01462751f, 0.00503452f, 0.02850147f, -0.03011042f, -0.03220645f, 
    -0.00076442f, 0.02606125f, 0.00935894f, 0.00991733f, 0.02754055f, -0.03535920f, 0.03698518f, 0.01576485f, 
    -0.01770563f, -0.01020509f, 0.00976079f, -0.03593628f, 0.00241964f, -0.00136534f, -0.00832361f, 0.04098122f, 
    0.00210657f, -0.01804522f, 0.00347456f, 0.00126927f, 0.02429166f, 0.00855815f, 0.01517939f, -0.02968536f, 
    -0.02483940f, -0.03308975f, 0.01443668f, 0.01852784f, -0.03801342f, -0.04096993f, -0.00887700f, 0.01105219f, 
    0.01910975f, 0.01084942f, -0.02272172f, 0.02119117f, -0.03645193f, -0.00835252f, -0.02543419f, -0.02298758f, 
    -0.00936345f, -0.00076363f, 0.02789381f, 0.01413517f, 0.02856144f, -0.02798195f, 0.00633801f, -0.02489321f, 
    -0.00044055f, 0.02263603f, -0.03575232f, 0.01047979f, 0.02321468f, 0.01106342f, 0.01160990f, -0.02437324f, 
    0.00957140f, 0.02559708f, 0.00455753f, 0.00741337f, -0.02106711f, -0.00419178f, 0.00527691f, 0.02977146f, 
    0.02537813f, 0.02182617f, -0.04330394f, 0.00247997f, 0.01779898f, 0.00632895f, 0.00708628f, -0.02078387f, 
    0.02288572f, -0.01800053f, -0.04553226f, -0.03108915f, -0.02216110f, -0.00893014f, -0.00077836f, 0.03272497f, 
    0.01230029f, -0.01097347f, 0.01890060f, 0.00218407f, -0.02271603f, -0.00341374f, 0.02010925f, -0.01280411f, 
    -0.01236453f, -0.03001083f, -0.01980582f, 0.01723357f, -0.00689609f, 0.00632927f, -0.02024469f, -0.00550053f, 
    0.01812962f, -0.01617209f, -0.03574927f, 0.00190674f, -0.02395965f, 0.01476921f, -0.01086517f, 0.02140865f, 
    0.03290220f, 0.01488294f, -0.01766467f, 0.03337621f, 0.00492148f, 0.00856675f, -0.01503486f, -0.02904344f, 
    -0.01453350f, -0.02260849f, 0.03155690f, -0.03963466f, -0.03687678f, -0.03247140f, 0.00054601f, 0.02602738f, 
    -0.03148778f, -0.01473826f, 0.01450577f, -0.02272176f, 0.00107416f, -0.02879385f, -0.00661072f, -0.00764328f, 
    0.00463944f, 0.03278684f, 0.01415116f, -0.02619894f, -0.01374856f, 0.00824352f, -0.02818974f, -0.01176636f, 
    0.03223878f, -0.00184593f, 0.02818915f, -0.03321179f, -0.02007724f, -0.00490743f, 0.03289251f, -0.00995470f, 
    0.00323694f, -0.00467452f, -0.00296079f, -0.00535049f, -0.04291986f, -0.02110757f, -0.01697550f, 0.01592469f, 
    -0.03522899f, -0.01358055f, -0.02616686f, 0.02177056f, -0.02346474f, -0.00507616f, -0.02912409f, 0.01009122f, 
    -0.03891950f, 0.00111911f, 0.01802725f, 0.00999235f, 0.02844123f, -0.01553414f, -0.01753550f, -0.02279226f, 
    -0.02769157f, -0.01875611f, -0.04211618f, -0.04081812f, 0.01965139f, -0.04276444f, 0.02412378f, 0.01318598f, 
    0.00742034f, 0.00482448f, -0.00827659f, -0.01955636f, -0.03685851f, -0.02830954f, -0.00971066f, -0.01481777f, 
    0.01708236f, -0.02539667f, 0.02568492f, 0.00869899f, 0.01976847f, -0.01992522f, -0.01396983f, 0.02209949f, 
    -0.03432524f, 0.01628246f, 0.01873204f, -0.00623446f, 0.02162760f, -0.01585524f, 0.00671485f, 0.01203461f, 
    -0.00693689f, 0.00022008f, -0.01812287f, -0.00817588f, 0.02584557f, -0.03132400f, -0.02052592f, -0.03905543f, 
    0.00614832f, 0.03470399f, 0.01248159f, -0.00125390f, 0.00077178f, 0.02529467f, 0.02559980f, 0.01033610f, 
    0.01044687f, 0.01719866f, 0.02391595f, 0.01565641f, 0.00419850f, -0.00560653f, 0.00688255f, -0.01856355f, 
    0.03709185f, -0.02473933f, -0.01473924f, 0.01143335f, 0.00481684f, 0.01803190f, 0.02797146f, 0.00067986f, 
    -0.03167384f, 0.01116916f, -0.00292371f, -0.02608529f, -0.02714117f, -0.00117835f, 0.02729262f, -0.00951105f, 
    -0.03282993f, 0.00207297f, -0.03467217f, -0.01148599f, 0.01475456f, 0.00354592f, -0.01821704f, -0.02525733f, 
    0.00384966f, 0.00286656f, 0.02719727f, 0.00501345f, -0.01942865f, -0.03801779f, 0.00780587f, -0.02199164f, 
    -0.03313076f, 0.01579198f, 0.02602355f, 0.00672058f, 0.00342483f, -0.02635036f, -0.01224897f, -0.00845177f, 
    0.00702270f, -0.01262083f, -0.00166011f, -0.00676561f, -0.02052918f, 0.01172991f, 0.00125242f, 0.02689129f, 
    -0.02687469f, -0.01863920f, -0.03133264f, -0.02067333f, -0.01815526f, -0.02695803f, -0.03070736f, 0.02201694f, 
    -0.00837179f, 0.00974424f, 0.01020808f, -0.00872358f, -0.01938576f, 0.00617119f, -0.04293530f, -0.03279446f, 
    0.00378601f, -0.15710345f, 0.00552500f, -0.10007300f, -0.00075448f, 0.03110698f, -0.17202057f, -0.03124380f, 
    0.11937767f, 0.07861216f, 0.02626742f, 0.06606410f, 0.18989950f, 0.03326073f, -0.42676291f, -0.10227995f, 
    -0.13494869f, -0.11541085f, 0.13469788f, 0.14968133f, -0.11539426f, 0.09541294f, -0.20549475f, -0.08874200f, 
    -0.05561159f, 0.25530505f, 0.03642895f, 0.11062885f, 0.01899619f, -0.11051182f, -0.21501555f, -0.07676240f, 
    0.11501748f, 0.18293984f, -0.04439618f, -0.05351037f, 0.66435587f, 0.24218692f, 0.18580377f, -0.04934311f, 
    -0.15794463f, -0.00628625f, -0.10993791f, -0.08755317f, 0.13288473f, 0.13839372f, -0.21181747f, 0.11677885f, 
    0.07999086f, -0.13717467f, -0.41448084f, 0.34710783f, 0.03643801f, -0.10705096f, 0.17576046f, 0.01694157f, 
    -0.10188249f, 0.07082993f, -0.05680001f, -0.00349973f, 0.03214440f, -0.03583890f, 0.01062512f, -0.25179860f, 
    0.08293496f, 0.00967634f, 0.04414161f, -0.03309268f, 0.00699555f, -0.02440585f, 0.15133716f, -0.08702551f, 
    0.22791705f, -0.00178157f, 0.12679331f, 0.04281991f, -0.10085621f, -0.08617964f, 0.04434910f, 0.06410634f, 
    0.10403865f, 0.10870942f, 0.00637184f, 0.23017307f, 0.13582210f, 0.00994332f, 0.17489329f, 0.05380849f, 
    -0.11443480f, -0.06980299f, -0.04289846f, -0.10352669f, -0.01172607f, 0.11082859f, 0.06742820f, 0.08248133f, 
    0.07843691f, -0.02407893f, 0.01318889f, -0.11729416f, 0.04385506f, -0.00060693f, 0.06045588f, -0.08983653f, 
    -0.12519550f, 0.13824172f, 0.14499398f, -0.07501242f, 0.01212720f, 0.12974630f, 0.02564726f, 0.12309416f, 
    -0.04914586f, -0.01687159f, 0.11865093f, 0.09105896f, -0.04360675f, 0.10512845f, -0.12554583f, 0.16135234f, 
    0.09546525f, 0.06153280f, -0.00676109f, 0.16414109f, -0.04943792f, -0.01069961f, 0.08490311f, -0.01568253f, 
    -0.08619934f, -0.07685043f, -0.11382946f, -0.06265928f, -0.00966646f, 0.12990043f, 0.17548804f, -0.04163169f, 
    -0.04665784f, -0.00483363f, -0.15514293f, -0.19891804f, -0.12608571f, -0.11849944f, -0.07491238f, -0.00585089f, 
    -0.00977877f, 0.13644144f, -0.38227859f, -0.09836598f, -0.19129770f, -0.01254120f, 0.06062278f, -0.03650801f, 
    -0.01435841f, 0.10261725f, -0.14187935f, 0.05295237f, 0.29969889f, 0.17615667f, 0.06383370f, -0.05034792f, 
    -0.06729291f, 0.00281593f, -0.06247202f, -0.09604506f, -0.14480472f, -0.00876328f, -0.00060826f, 0.04602851f, 
    0.22098947f, -0.12575813f, 0.09627552f, 0.21467558f, -0.21418755f, -0.04967313f, 0.04261165f, -0.07682680f, 
    0.13129365f, -0.01538142f, 0.14027709f, -0.25224489f, -0.27490279f, 0.10325636f, 0.33087996f, 0.04447471f, 
    0.02436803f, -0.11724449f, 0.03020148f, -0.01574836f, 0.00279568f, 0.01069520f, -0.11755401f, 0.15610078f, 
    0.04655626f, -0.05190600f, 0.02433703f, 0.08370064f, -0.06122207f, 0.01913964f, -0.01360318f, 0.01342853f, 
    0.00108444f, 0.02188158f, 0.01932608f, -0.02291050f, 0.03163165f, -0.08385615f, -0.03492978f, 0.10526208f, 
    -0.19449745f, 0.00113799f, 0.03867022f, 0.07223797f, 0.09590169f, -0.08651585f, -0.11878140f, 0.00802526f, 
    -0.01335405f, 0.17231452f, -0.24721256f, -0.23782097f, 0.13454178f, -0.09632967f, -0.05430245f, 0.03690495f, 
    0.13900943f, 0.06012888f, 0.09665199f, -0.06872392f, -0.24470499f, -0.20749028f, -0.18217349f, -0.06141657f, 
    0.00125626f, -0.04355936f, -0.04596550f, 0.02795291f, -0.16661373f, -0.04471018f, -0.05197608f, -0.04882886f, 
    -0.01198424f, 0.02008669f, -0.03910244f, 0.26066393f, -0.08159000f, 0.07597188f, 0.20573445f, 0.11446045f, 
    0.01481261f, -0.11702424f, -0.04870620f, -0.11770594f, -0.11373421f, 0.07962328f, 0.10915455f, -0.04067205f, 
    -0.06499016f, -0.13639630f, -0.01911858f, 0.11039417f, -0.11163427f, -0.10542878f, 0.10611555f, -0.10925730f, 
    0.01435481f, 0.21957570f, -0.11674194f, -0.15337160f, -0.01135659f, 0.18221208f, 0.07470868f, -0.21523498f, 
    0.08378603f, -0.11049242f, 0.01260997f, 0.16162139f, 0.20697260f, 0.15928818f, 0.17246243f, -0.00475438f, 
    0.07136474f, 0.01156885f, -0.10710414f, 0.05431703f, 0.01216583f, 0.18212169f, -0.06827564f, 0.04398049f, 
    0.02867868f, 0.12823841f, -0.04104240f, 0.10536791f, 0.07719349f, 0.01118684f, 0.08308094f, 0.13366728f, 
    -0.11628340f, 0.21264051f, 0.05993551f, -0.06693681f, -0.08571010f, -0.11145377f, -0.29911363f, 0.10110160f, 
    0.04520006f, -0.02480432f, 0.12791382f, 0.02120556f, 0.12799138f, 0.11697435f, 0.01019181f, 0.02424406f, 
    0.21849747f, 0.20136939f, -0.03352649f, -0.08765305f, -0.14193040f, 0.02917866f, -0.00631751f, -0.03151629f, 
    -0.12964040f, 0.00687880f, 0.00946794f, 0.05421330f, 0.20259970f, -0.13556546f, 0.15213017f, 0.08363638f, 
    -0.00572075f, 0.01084257f, -0.06489124f, 0.02327069f, 0.15444903f, 0.00143375f, -0.02146706f, 0.02811022f, 
    0.00729846f, -0.06628685f, -0.02332691f, 0.11417270f, -0.00103707f, -0.01610448f, 0.01197579f, 0.03726770f, 
    -0.06875774f, -0.02597567f, -0.22187988f, 0.05312798f, 0.09803819f, 0.18546310f, -0.07334939f, 0.18950297f, 
    -0.14582241f, -0.03878352f, -0.06958225f, -0.11356616f, -0.05556705f, 0.00288869f, -0.06774441f, 0.04053293f, 
    -0.12933469f, -0.19923963f, -0.00624304f, -0.28439105f, 0.17988200f, -0.06977029f, -0.14000475f, -0.05124406f, 
    -0.00743197f, -0.01278094f, 0.03214736f, -0.08024953f, -0.06589117f, 0.19740677f, 0.05055107f, -0.05498733f, 
    -0.05662147f, 0.02973097f, 0.03046089f, -0.05572412f, 0.06076955f, 0.09119023f, -0.03332725f, 0.21157803f, 
    0.01416288f, -0.15013286f, 0.02926608f, -0.07664640f, 0.11963417f, 0.01898336f, 0.03384287f, -0.03152768f, 
    0.13028473f, 0.11506867f, -0.03002626f, 0.11438400f, 0.11289915f, 0.04048165f, 0.32968166f, -0.33565399f, 
    -0.06487561f, 0.08996755f, -0.11266984f, 0.01366291f, 0.03524103f, 0.00211567f, -0.06026098f, -0.05586567f, 
    -0.03890565f, 0.25274816f, 0.17875291f, -0.01840925f, 0.05060141f, 0.09543980f, 0.01556667f, -0.10158726f, 
    0.06284261f, 0.10344240f, -0.11763244f, -0.01704182f, -0.33310583f, 0.27264446f, 0.19771953f, -0.04185499f, 
    0.13283987f, 0.09210269f, 0.06580391f, -0.11858804f, 0.12655522f, 0.00059075f, 0.13350698f, 0.22885425f, 
    0.06794597f, 0.13160437f, 0.10463671f, -0.20876582f, 0.08393760f, -0.18142784f, -0.21189933f, 0.05820831f, 
    -0.00007287f, -0.07614344f, 0.09034356f, -0.02035941f, 0.06335699f, -0.22807011f, -0.05143185f, 0.11179053f, 
    0.04488610f, 0.04349822f, 0.10912769f, 0.10832489f, -0.04000975f, -0.06848133f, 0.03647470f, 0.03163361f, 
    0.02265484f, 0.06135820f, -0.03574327f, 0.03612093f, -0.04236457f, -0.06235502f, 0.06409197f, -0.01545243f, 
    -0.05585437f, 0.10129972f, 0.23403285f, -0.10370508f, -0.08691484f, 0.54678649f, -0.05731462f, -0.33492687f, 
    0.00826978f, 0.00890745f, 0.10532156f, 0.05293018f, 0.15720879f, 0.04202920f, 0.09307476f, -0.08675078f, 
    0.05775717f, 0.08470557f, -0.05517941f, -0.01832959f, -0.02918192f, -0.03913713f, 0.02890198f, -0.01265374f, 
    0.00148105f, -0.05947678f, 0.03800213f, -0.11970411f, 0.31200829f, 0.02788226f, 0.06845603f, 0.10720625f, 
    -0.05564681f, 0.03555062f, -0.07787941f, -0.00621008f, -0.02944291f, 0.04929097f, 0.09150956f, 0.04024027f, 
    -0.22417228f, 0.23085913f, -0.00398315f, -0.01689210f, -0.07696018f, -0.00376480f, 0.07351785f, -0.02506391f, 
    0.05356561f, -0.03993355f, 0.02735269f, 0.06277256f, 0.05815621f, 0.01626391f, -0.33093476f, 0.21351108f, 
    0.01726265f, 0.07634511f, 0.09786951f, 0.01642108f, 0.01666449f, 0.02312622f, 0.06801019f, -0.02625760f, 
    -0.25068340f, -0.16315416f, -0.31291375f, -0.15578684f, -0.06491008f, -0.08370522f, 0.01152993f, 0.05579039f, 
    0.03872398f, 0.00490862f, 0.00494296f, 0.00714583f, -0.00920209f, 0.17281653f, -0.04425504f, 0.01219133f, 
    0.06261597f, 0.02200352f, 0.07215510f, 0.00427041f, 0.16119760f, 0.04193097f, 0.01991574f, -0.03181686f, 
    0.20582651f, 0.25813168f, 0.04038807f, 0.12988150f, -0.16473620f, -0.08897598f, -0.09801478f, 0.01429377f, 
    -0.00729756f, -0.00583389f, 0.03916718f, 0.18525970f, 0.30510184f, -0.04222823f, -0.04041003f, 0.12043782f, 
    -0.04363729f, 0.02791112f, -0.15824775f, -0.04989944f, -0.06957299f, 0.06170267f, 0.01102737f, -0.04321898f, 
    -0.00799862f, 0.01138846f, -0.04762712f, -0.06597361f, -0.00820737f, 0.06864531f, -0.01533096f, 0.16240811f, 
    0.02779530f, -0.23966031f, -0.11118925f, -0.10508453f, -0.26037309f, 0.08820417f, 0.20319118f, -0.10845198f, 
    -0.08011975f, -0.17744598f, 0.24327455f, -0.04452268f, 0.01893606f, 0.17898811f, -0.01457593f, 0.09073771f, 
    -0.21562600f, 0.01907391f, 0.10143376f, 0.36903980f, -0.07825225f, 0.06493617f, -0.09427410f, 0.07136425f, 
    -0.22137488f, -0.05269676f, 0.00912614f, 0.09789434f, 0.10059793f, -0.00159744f, 0.08026403f, 0.25561318f, 
    0.10443059f, -0.02477792f, -0.15397558f, 0.06783654f, -0.02474745f, 0.03130887f, 0.01006319f, 0.00339833f, 
    0.61300391f, -0.29774699f, -0.05691785f, -0.07431898f, -0.08090844f, -0.04009774f, 0.15124637f, 0.09464990f, 
    0.06889949f, 0.10323891f, 0.22099660f, 0.16811010f, -0.31859180f, 0.07439139f, -0.04457754f, -0.09200711f, 
    -0.00704932f, 0.00319985f, 0.11405743f, -0.04537390f, -0.17729895f, -0.11399630f, 0.01376570f, 0.01584904f, 
    0.17414236f, -0.35913619f, -0.23247248f, 0.00770273f, 0.07972714f, 0.03435998f, -0.09956710f, 0.09821843f, 
    0.03615731f, -0.10316484f, -0.05364070f, 0.19999896f, 0.11886999f, -0.19480030f, -0.37859505f, 0.14542563f, 
    -0.10669993f, -0.24584194f, -0.05663238f, -0.06911135f, -0.07054095f, 0.04207856f, -0.12896729f, 0.03232267f, 
    -0.03840780f, 0.22710782f, -0.06020333f, 0.23875496f, 0.07411058f, 0.16855308f, 0.04224649f, -0.06803942f, 
    -0.03639704f, -0.03075686f, -0.15075731f, 0.05115439f, -0.02428890f, 0.10236123f, -0.10133515f, -0.05274925f, 
    -0.23156036f, 0.18359256f, -0.01461104f, -0.32560375f, -0.01380215f, -0.03895541f, 0.18418774f, -0.02800534f, 
    0.02097586f, -0.20486541f, 0.28600106f, 0.00706011f, 0.22386867f, 0.04745533f, -0.06119163f, -0.18454164f, 
    0.19468044f, 0.02283006f, -0.11704744f, 0.01272216f, 0.09742774f, 0.09222890f, 0.12247639f, 0.08262689f, 
    -0.07365735f, -0.07317446f, -0.00260623f, 0.04599799f, 0.01406706f, -0.04134562f, 0.10929445f, 0.13625304f, 
    0.26476124f, 0.44995564f, -0.14219971f, -0.03622642f, -0.14357646f, -0.04400078f, -0.00435247f, -0.00667482f, 
    0.01884277f, -0.03173583f, 0.14595959f, 0.18518099f, -0.33408129f, -0.08222426f, -0.07360555f, -0.20786205f, 
    0.05202989f, -0.03548822f, 0.04740193f, 0.10527113f, -0.02058578f, 0.03798525f, 0.00938308f, -0.00718361f, 
    0.01998045f, 0.01762905f, 0.09640653f, 0.13349469f, -0.08156399f, 0.06238684f, -0.07315822f, -0.05282014f, 
    -0.11050123f, -0.11136974f, 0.07513411f, 0.11886604f, -0.17764015f, 0.17363545f, 0.14777651f, -0.12872508f, 
    0.01521007f, -0.01258549f, -0.12109414f, -0.04000678f, 0.00382808f, 0.05431865f, 0.03920730f, -0.15455319f, 
    -0.04755354f, 0.14265910f, 0.31002513f, -0.35500428f, -0.07511949f, -0.09691842f, 0.16030174f, -0.10772029f, 
    0.02809763f, 0.05489189f, 0.00009115f, 0.05977389f, 0.20328516f, 0.26769611f, 0.22659647f, 0.42267913f, 
    -0.03737620f, 0.05211863f, 0.01434791f, -0.06572053f, 0.02318025f, 0.00566055f, -0.10287441f, 0.02858097f, 
    -0.36855417f, -0.03588006f, 0.07619268f, 0.11845165f, 0.05111593f, -0.16406289f, 0.01686078f, 0.03080721f, 
    0.06664042f, 0.03033679f, -0.03681596f, -0.13261425f, 0.31248078f, -0.12118150f, 0.26900637f, -0.10051803f, 
    -0.01535718f, -0.05468922f, -0.17362103f, -0.01168190f, 0.06680811f, -0.01370841f, -0.16133383f, -0.06854744f, 
    0.03771108f, 0.09348346f, -0.21497239f, 0.19575211f, -0.02847374f, -0.01511046f, 0.14200926f, -0.05492431f, 
    -0.00345170f, -0.01645842f, 0.08625792f, 0.05703681f, 0.38151214f, 0.20491192f, 0.00269071f, -0.02915278f, 
    0.12138983f, 0.03559261f, 0.21798608f, 0.13979079f, 0.04487395f, 0.00052639f, 0.03891222f, 0.17024760f, 
    -0.24204724f, 0.02476553f, 0.11404427f, 0.09956922f, -0.06692491f, -0.04410541f, 0.02453967f, -0.02971558f, 
    0.01822109f, -0.01056883f, -0.03656153f, 0.19479431f, -0.15592845f, -0.18920444f, 0.08765272f, -0.08792660f, 
    -0.11354522f, 0.02614185f, -0.10205176f, -0.12070987f, -0.01875358f, 0.02717719f, 0.23029067f, 0.09870345f, 
    -0.00812395f, 0.08666941f, 0.14983816f, -0.30360803f, 0.04134688f, 0.05057538f, 0.00679977f, 0.09131048f, 
    0.12454264f, 0.03670723f, -0.06639723f, -0.05053370f, 0.18336290f, -0.12317479f, 0.30734298f, -0.14486161f, 
    0.00893361f, -0.13329326f, 0.08947930f, -0.16795880f, 0.09234956f, 0.15388252f, -0.07134154f, 0.04376910f, 
    0.03047820f, 0.02980483f, 0.14434537f, 0.05905256f, -0.04795723f, 0.12070128f, 0.08113495f, 0.16868159f, 
    0.05655716f, 0.02206269f, 0.01932866f, 0.06513931f, -0.17757894f, 0.14926638f, 0.13566716f, 0.13785511f, 
    0.06676362f, 0.01689993f, -0.09406255f, 0.11553019f, -0.01198184f, -0.00098460f, -0.05021056f, 0.04645987f, 
    0.18573132f, 0.15091781f, 0.06447267f, -0.23912060f, 0.00374320f, -0.32067809f, 0.04330062f, -0.13657297f, 
    -0.02353968f, 0.17087001f, -0.01014819f, 0.06156902f, -0.02304267f, 0.01393419f, 0.21335949f, -0.17888607f, 
    0.02251671f, 0.04041633f, 0.08840270f, -0.10254674f, 0.05595592f, 0.12158137f, 0.10383171f, 0.07282216f, 
    -0.15588215f, -0.23174462f, -0.01325606f, -0.15790397f, 0.01322246f, 0.06428340f, 0.08621586f, 0.17583238f, 
    0.02932897f, -0.10674332f, 0.00713544f, -0.16896477f, -0.44184345f, -0.06408890f, -0.23810263f, 0.12857725f, 
    0.16814046f, 0.02080099f, -0.05790935f, -0.26280522f, 0.10719947f, -0.13292110f, -0.16935755f, 0.06095390f, 
    0.03859011f, -0.17974755f, 0.02170103f, -0.22368167f, 0.07079417f, -0.00898125f, 0.21198951f, 0.07150531f, 
    0.12216154f, 0.12970872f, 0.20314401f, 0.09713802f, 0.15198892f, 0.07014140f, 0.10923629f, -0.06387758f, 
    0.07620605f, -0.10805276f, -0.03926199f, 0.01295242f, -0.00282628f, -0.06625251f, 0.03911754f, -0.02914620f, 
    0.11709709f, 0.12181039f, 0.05299486f, -0.17576921f, -0.03480720f, 0.10088643f, 0.04265374f, 0.14904130f, 
    0.15738353f, 0.06450970f, -0.02356235f, -0.04058988f, -0.00406270f, 0.25773641f, -0.01789881f, -0.01099815f, 
    0.05500363f, -0.01919504f, 0.12953685f, 0.08666873f, -0.02062193f, 0.10855719f, 0.08409613f, 0.05805243f, 
    0.09833540f, 0.23409399f, -0.09251188f, -0.14003961f, -0.06171131f, -0.01844334f, 0.11349749f, -0.19101529f, 
    -0.02824298f, 0.00997358f, 0.06141846f, -0.02003240f, -0.18356806f, -0.14028789f, -0.13627620f, -0.13813959f, 
    -0.13299823f, 0.05039169f, 0.05636184f, -0.03870807f, 0.18813577f, 0.08386672f, 0.09992597f, -0.04453448f, 
    0.05605758f, 0.09956521f, -0.08920043f, 0.06037848f, 0.04974043f, 0.16071087f, -0.04014879f, 0.08955854f, 
    0.05400482f, 0.01891751f, 0.12028853f, -0.01441655f, -0.45223758f, 0.13177371f, -0.31477025f, 0.07883126f, 
    0.11751190f, 0.12833180f, -0.04588334f, 0.10092720f, -0.06086670f, 0.09652739f, -0.02242718f, 0.18112430f, 
    -0.12559186f, 0.12293480f, 0.06091373f, -0.10372830f, -0.06598446f, 0.01507956f, 0.34367317f, -0.12089230f, 
    0.04715274f, 0.12512483f, 0.00136306f, -0.15232573f, 0.16550592f, 0.03704580f, 0.17481714f, -0.13942400f, 
    0.07460325f, 0.03048861f, 0.07856342f, 0.11455456f, 0.09447568f, 0.04149603f, 0.13641210f, 0.02710578f, 
    0.19335334f, 0.06146085f, 0.18449429f, 0.07212677f, -0.20605831f, 0.01764705f, -0.07830641f, 0.13332596f, 
    -0.07945515f, 0.07477744f, -0.02678408f, 0.15265369f, 0.31520370f, -0.20098686f, 0.16867426f, -0.28824279f, 
    -0.11197486f, 0.03642540f, -0.07413420f, 0.02235964f, 0.08613207f, -0.09244061f, -0.03523924f, 0.11014567f, 
    0.00316024f, 0.09045446f, 0.23484217f, -0.16701986f, 0.02474752f, 0.07028214f, 0.20888947f, 0.02630566f, 
    0.02431191f, 0.04163933f, 0.18491262f, 0.15728030f, 0.27535796f, 0.09649861f, -0.12603824f, -0.11149149f, 
    -0.06993622f, -0.11782447f, -0.11390489f, -0.08232922f, 0.02744589f, 0.04540571f, 0.09172662f, 0.11625294f, 
    0.04640714f, 0.18756716f, -0.25283507f, -0.15026827f, 0.08938341f, -0.04981177f, 0.01592122f, 0.17380293f, 
    0.04667962f, 0.02977701f, -0.11701486f, -0.08106534f, -0.27214560f, 0.02068537f, 0.28578618f, -0.17596574f, 
    0.02402960f, -0.16397296f, 0.06025784f, -0.12067495f, 0.04220007f, 0.10778754f, -0.02250244f, -0.04451496f, 
    -0.02549830f, -0.12209044f, 0.51124686f, -0.47315997f, -0.03321636f, 0.07990797f, -0.10446437f, 0.05441434f, 
    -0.04559883f, -0.00380227f, -0.09316215f, -0.05234324f, -0.24145146f, -0.15483573f, 0.27534953f, -0.25519341f, 
    -0.04795877f, 0.02852781f, -0.10728002f, 0.09307770f, 0.10302576f, -0.14274864f, -0.10442984f, -0.08849980f, 
    0.16871765f, 0.20135027f, -0.03894553f, 0.13909492f, 0.12761833f, 0.13166980f, 0.10056739f, 0.13407619f, 
    0.10179880f, -0.06911244f, -0.05860602f, -0.13505809f, -0.29702002f, -0.00274267f, 0.00280709f, -0.11951907f, 
    -0.01372147f, 0.12047710f, -0.05636580f, -0.24567960f, 0.22762619f, -0.07796463f, -0.02056329f, 0.18205658f, 
    -0.58053356f, 0.25066069f, -0.63183874f, 0.30915847f, 0.01469910f, -0.03140080f, -0.05151172f, 0.25784928f, 
    0.11252855f, -0.11748297f, -0.03595701f, -0.01948707f, -0.01337779f, -0.07762031f, 0.24347205f, -0.06620280f, 
    0.09264372f, -0.02289489f, 0.23422302f, 0.14210589f, 0.09875350f, 0.06603499f, 0.02991896f, 0.03135244f, 
    0.02528594f, -0.00902001f, 0.06094043f, 0.04824873f, 0.01016123f, -0.04725669f, 0.03913893f, -0.16691093f, 
    0.01680439f, -0.01876293f, -0.20117876f, -0.17991431f, 0.08932763f, -0.00952599f, -0.21635519f, -0.51128793f, 
    -0.22089365f, 0.02348827f, 0.22423862f, -0.05339451f, 0.05469400f, 0.05955882f, 0.03567331f, -0.07523660f, 
    0.03351318f, -0.32029381f, 0.16373457f, -0.32133329f, 0.11166716f, 0.06185990f, 0.02004087f, 0.15530168f, 
    0.14168879f, -0.02819867f, 0.05345757f, -0.00460792f, 0.34835559f, -0.02814165f, 0.06353465f, -0.01729246f, 
    -0.15797870f, -0.09085707f, -0.13374433f, -0.02981417f, 0.03848303f, -0.09279280f, 0.10108527f, 0.12394054f, 
    -0.21632802f, -0.19759718f, 0.03675073f, -0.01774080f, 0.08396423f, 0.06833585f, -0.08188537f, -0.02184536f, 
    -0.08329792f, 0.17324145f, 0.00796518f, 0.00687017f, 0.06048572f, 0.07402713f, -0.01618812f, 0.09612105f, 
    -0.01685446f, 0.14579044f, 0.04675119f, 0.17137486f, 0.11032867f, -0.00874634f, -0.10513220f, 0.00101294f, 
    0.01808251f, 0.07468774f, 0.01303707f, -0.04188981f, 0.14686815f, -0.03209548f, 0.16506086f, 0.06677266f, 
    -0.02261709f, 0.03616311f, 0.00689715f, -0.09513663f, 0.08925161f, 0.43597981f, 0.06372011f, 0.21367474f, 
    -0.00979557f, -0.01292974f, -0.07250600f, -0.07478385f, 0.24569607f, -0.09577843f, -0.00316222f, -0.05325048f, 
    -0.07554060f, -0.17899609f, 0.09042414f, -0.15273482f, -0.04258699f, -0.06586935f, 0.10178114f, 0.06330366f, 
    -0.01536623f, -0.15744716f, 0.00327873f, 0.03096300f, 0.01427745f, -0.15967861f, 0.15278165f, 0.07552580f, 
    -0.02209747f, -0.09401190f, -0.21368721f, 0.02005298f, 0.10184884f, 0.03491754f, -0.14689149f, -0.02567551f, 
    0.04250062f, -0.08101287f, 0.03621590f, -0.00300715f, -0.00406513f, 0.06212095f, -0.06776929f, -0.12469498f, 
    0.17209524f, -0.01632795f, 0.08533046f, 0.13342439f, -0.19003730f, 0.16869400f, -0.27215531f, -0.23806362f, 
    -0.02513677f, 0.12094385f, -0.04140564f, 0.23657508f, -0.12621979f, -0.02829544f, 0.09485777f, 0.01866063f, 
    -0.48028845f, 0.26767597f, -0.24137390f, 0.01251144f, 0.17118157f, 0.08006066f, -0.00434985f, -0.20737304f, 
    -0.08138942f, -0.05093470f, -0.08928294f, 0.06420133f, -0.02329231f, 0.40003189f, -0.17522345f, -0.20303431f, 
    0.05331448f, 0.11119386f, -0.00532154f, 0.21833855f, 0.09814471f, -0.05562762f, -0.10210583f, -0.03475536f, 
    0.55758202f, -0.17197517f, 0.25890315f, -0.28367224f, 0.04699270f, -0.09377320f, -0.07013029f, 0.03508966f, 
    0.15109010f, 0.02491823f, 0.00146862f, 0.19409652f, -0.20856591f, 0.12814419f, -0.27584183f, 0.07447971f, 
    -0.01407729f, 0.15130533f, 0.13231038f, -0.04701022f, 0.05604721f, 0.06804533f, -0.08061273f, 0.23755568f, 
    0.09338031f, 0.17290349f, -0.07211905f, -0.07624385f, -0.05135492f, -0.01580887f, -0.00882491f, 0.05508288f, 
    0.09113406f, -0.14643681f, -0.09629969f, -0.00920964f, -0.64314866f, -0.13619927f, -0.61352617f, 0.01715165f, 
    0.09187616f, -0.19015744f, 0.09955480f, 0.10064328f, 0.04516974f, -0.02101090f, 0.05801893f, -0.08674734f, 
    -0.12334585f, 0.25177291f, 0.03800925f, -0.11562365f, -0.05903606f, 0.20622592f, 0.01678529f, 0.15706532f, 
    0.01260326f, -0.00788843f, 0.06244559f, 0.02267298f, -0.08721317f, -0.19642726f, 0.20961133f, -0.31760573f, 
    0.17360592f, 0.08701370f, -0.09784418f, -0.04462652f, -0.02301093f, 0.05111244f, 0.15883557f, 0.03718113f, 
    0.08885562f, -0.07199133f, 0.08568919f, -0.24121970f, 0.13358158f, 0.19112802f, -0.07210053f, 0.08394948f, 
    0.11595004f, -0.05707500f, -0.01825912f, 0.05097839f, -0.03350407f, -0.24989365f, 0.11048009f, -0.07699854f, 
    0.03771491f, 0.02600165f, 0.01349030f, -0.08691616f, 0.04392094f, -0.00550127f, -0.00422943f, 0.10223314f, 
    0.12848017f, -0.01959933f, 0.10214980f, 0.18164159f, -0.12728351f, -0.00155453f, -0.06519134f, 0.01565381f, 
    -0.05985916f, 0.13713625f, -0.08979616f, -0.14319272f, 0.35011342f, 0.25387707f, -0.00023602f, -0.10612126f, 
    -0.03366670f, 0.07066214f, -0.00509861f, 0.03441825f, -0.08376626f, -0.09617369f, 0.15513457f, -0.00871471f, 
    0.07287437f, -0.08466348f, 0.05356788f, -0.00213130f, -0.01077158f, 0.00647070f, -0.01746956f, -0.11708044f, 
    0.04246183f, 0.09333516f, 0.17086293f, 0.19163440f, -0.07787995f, -0.05988540f, 0.18054889f, -0.25182515f, 
    -0.01365220f, 0.08654354f, 0.03710526f, -0.10536331f, 0.27965969f, 0.11060508f, 0.05541624f, 0.20719223f, 
    -0.02717698f, -0.00414014f, -0.00159264f, -0.03400912f, 0.02650788f, 0.02907209f, 0.01129474f, 0.01491481f, 
    0.03394357f, -0.00833223f, 0.02361602f, 0.02426657f, -0.02292148f, 0.00241386f, -0.00292884f, 0.01382342f, 
    0.00305746f, -0.00324919f, 0.02343536f, -0.00459653f, 0.00544323f, 0.01222215f, 0.02619151f, -0.01911483f, 
    -0.00913673f, 0.02478713f, -0.01661406f, 0.01420670f, 0.00436671f, -0.02004738f, 0.00729245f, 0.03323668f, 
    -0.02244871f, 0.01418939f, 0.02919362f, -0.00058336f, -0.02237010f, -0.02265918f, -0.02753513f, -0.00725107f, 
    -0.03555568f, -0.01662690f, -0.01495699f, -0.01201914f, 0.02405306f, 0.02868868f, 0.01576762f, 0.02863516f, 
    -0.04188440f, 0.01423155f, -0.00477882f, 0.00464254f, -0.00596786f, -0.04194152f, -0.00175381f, 0.00226094f, 
    0.03582352f, -0.02648563f, -0.03416203f, -0.02493796f, -0.00103865f, -0.03173809f, -0.01402659f, -0.00462973f, 
    -0.02035880f, 0.02572589f, -0.01023240f, -0.01692807f, -0.00268445f, 0.00233907f, 0.01928930f, 0.02784007f, 
    -0.02413478f, -0.00931690f, 0.00381691f, 0.01900092f, -0.01929475f, 0.02020228f, -0.00817576f, -0.02132624f, 
    -0.02700364f, 0.01072293f, 0.03382989f, -0.00168544f, -0.00696914f, 0.01907264f, -0.03289800f, 0.01232908f, 
    -0.00948590f, 0.00519669f, -0.00441421f, 0.02461402f, -0.02538880f, -0.02173377f, 0.00340618f, -0.00700954f, 
    -0.00508458f, 0.01456160f, -0.01827577f, -0.02930657f, 0.01703986f, -0.03391002f, 0.00868135f, 0.00318307f, 
    0.00352696f, -0.03008156f, 0.00421102f, -0.01708384f, 0.00322480f, -0.01438871f, 0.02113999f, -0.00534220f, 
    -0.00867544f, -0.03737625f, -0.00320993f, 0.00732578f, 0.01291982f, -0.00976436f, 0.00057557f, -0.03518479f, 
    0.01623824f, -0.03112256f, -0.04002736f, -0.02044575f, 0.01875217f, -0.00776463f, 0.00765391f, -0.03224516f, 
    -0.02498600f, 0.02744419f, -0.03283303f, -0.03355891f, -0.00741668f, 0.00325068f, -0.00470348f, -0.03312206f, 
    -0.02578758f, -0.01038115f, 0.01686500f, -0.00700939f, 0.02952905f, 0.02788750f, -0.00180297f, 0.02394100f, 
    0.00666087f, 0.03363981f, 0.01407232f, 0.02939732f, -0.02869771f, -0.02968135f, -0.02468386f, -0.02846490f, 
    0.03128224f, -0.02138693f, -0.01005275f, 0.02089309f, -0.02727068f, -0.00895283f, 0.02347135f, 0.01159456f, 
    -0.01216477f, -0.02359843f, -0.01105359f, -0.02124963f, 0.02207056f, -0.03604471f, -0.04092289f, -0.01491943f, 
    0.02987346f, -0.02582016f, 0.00382260f, -0.00973976f, -0.00802584f, 0.00431829f, 0.01836339f, -0.01690376f, 
    -0.01718758f, 0.01780222f, -0.01183933f, -0.02248387f, -0.01943798f, -0.04066096f, -0.01934445f, 0.01424081f, 
    -0.02776586f, 0.01618505f, -0.03669200f, 0.02134424f, -0.03524534f, -0.03012701f, 0.02339656f, 0.00576686f, 
    -0.03204162f, -0.01833742f, 0.01871214f, 0.00855043f, 0.02922573f, -0.02834376f, 0.00449824f, 0.01496301f, 
    0.02563693f, 0.01049509f, -0.01044967f, 0.00404009f, -0.02019353f, -0.04155013f, -0.01592050f, 0.01362458f, 
    0.00682099f, 0.00098849f, 0.01805144f, 0.00488008f, 0.03258279f, 0.01393011f, 0.02752005f, -0.04188040f, 
    -0.02668682f, 0.02118326f, -0.01040978f, -0.02289041f, -0.01558778f, 0.00282462f, 0.02401017f, 0.00081253f, 
    0.01215401f, -0.03341925f, -0.02053481f, 0.03835189f, -0.00747233f, 0.02735988f, -0.01728237f, 0.02569423f, 
    -0.01785008f, 0.02054000f, -0.00843157f, -0.00073387f, 0.00145242f, -0.00996805f, 0.02325725f, 0.01883912f, 
    -0.01111505f, -0.03209666f, -0.04017060f, -0.01957132f, -0.03596226f, 0.03974049f, 0.03921867f, 0.01676617f, 
    -0.02171023f, -0.01866185f, -0.00864874f, -0.03774790f, -0.00483795f, 0.01154449f, 0.00732087f, 0.00305017f, 
    0.00413647f, 0.01270841f, 0.01573647f, -0.01390510f, -0.03330516f, -0.02799254f, 0.02141574f, -0.00434694f, 
    -0.03971017f, -0.02233051f, -0.00161336f, -0.02805337f, 0.02542228f, 0.02616380f, -0.03785429f, -0.02187936f, 
    -0.00325076f, 0.00409042f, 0.00448025f, -0.02184409f, 0.03360028f, 0.00447806f, -0.01476309f, 0.02491214f, 
    0.00442970f, -0.03966500f, -0.01101376f, 0.01882843f, 0.02687354f, 0.01608474f, -0.00678067f, 0.02460852f, 
    0.00437591f, -0.01714075f, 0.00070382f, -0.01536253f, -0.02508742f, -0.03329171f, -0.00440440f, -0.00874230f, 
    0.03883744f, -0.03534714f, -0.01618954f, 0.03365842f, -0.01754032f, 0.01283766f, -0.02058755f, 0.01240100f, 
    -0.00732670f, -0.03850469f, -0.01003012f, -0.03216188f, -0.02390020f, 0.00102442f, -0.02421222f, 0.02089585f, 
    -0.03875062f, 0.00872788f, 0.00730802f, -0.01651502f, 0.03419343f, -0.02279296f, -0.03826556f, -0.04134568f, 
    -0.02729994f, 0.01512130f, -0.00099376f, 0.00324257f, 0.00802393f, 0.00851416f, 0.00900913f, 0.01060452f, 
    -0.02151234f, 0.01754082f, -0.01034009f, -0.03387448f, -0.00870535f, -0.01356293f, -0.03874948f, -0.01122372f, 
    -0.03067761f, 0.02346775f, -0.01799743f, -0.02719402f, -0.02669489f, -0.00703489f, -0.00263420f, 0.02830702f, 
    -0.01835907f, 0.00026765f, 0.01139746f, -0.01066155f, 0.02802954f, 0.03490515f, -0.03106349f, -0.03857014f, 
    -0.02365237f, -0.04164329f, -0.00265175f, -0.00193762f, -0.02191461f, 0.00000365f, -0.01849577f, -0.00682116f, 
    0.02381628f, 0.00184111f, -0.03612696f, 0.01499717f, 0.02099978f, 0.01789264f, 0.02653736f, 0.01585476f, 
    -0.03119359f, -0.00459004f, -0.02979261f, -0.03972708f, -0.02881083f, 0.00910935f, -0.03870647f, -0.04002488f, 
    0.00062112f, 0.02819808f, 0.01665749f, 0.02184393f, 0.02731080f, 0.02988919f, -0.02861531f, 0.03155922f, 
    -0.01379273f, -0.01804005f, -0.00306400f, -0.03123763f, 0.03663884f, -0.03420854f, -0.02417525f, 0.02827317f, 
    -0.00759687f, -0.02046527f, -0.01376490f, 0.01972933f, 0.02709396f, -0.00113955f, 0.04135095f, 0.00708027f, 
    0.00151149f, -0.00552201f, -0.00959401f, -0.00827887f, -0.02716840f, -0.03902789f, -0.03409920f, -0.02701113f, 
    -0.01126496f, 0.01196155f, -0.01394755f, -0.03023025f, -0.03709979f, -0.00989224f, 0.00310385f, -0.00433759f, 
    -0.00295000f, -0.04001559f, -0.03696650f, 0.01904395f, -0.00394171f, 0.00027212f, 0.01802699f, 0.01932915f, 
    0.01022640f, -0.00016967f, 0.01244198f, -0.01764371f, -0.00003234f, -0.03039568f, -0.02388593f, -0.02604305f, 
    -0.03272931f, -0.01767540f, 0.00922324f, 0.00095913f, -0.03894898f, 0.01383057f, 0.00237268f, -0.03375426f, 
    -0.00138469f, -0.03225458f, -0.00167730f, -0.02556495f, 0.01704709f, 0.00433303f, -0.00058575f, 0.02857043f, 
    -0.02829444f, -0.01837366f, 0.03029492f, -0.02817494f, 0.01723854f, -0.02025483f, -0.03654359f, 0.02944332f, 
    0.00638860f, 0.01953358f, -0.01528634f, -0.03090975f, -0.03717734f, 0.00691628f, -0.02522137f, 0.02234976f, 
    0.01457347f, 0.03028000f, 0.03640971f, 0.00344058f, 0.01128195f, 0.02898338f, 0.02281320f, 0.00283326f, 
    0.02842519f, 0.01173379f, -0.02304622f, 0.00590343f, -0.02152383f, 0.00260703f, -0.00912127f, 0.00838771f, 
    -0.02622495f, 0.02383104f, -0.02304090f, -0.02384324f, -0.03195535f, 0.00791839f, -0.00549128f, -0.03575224f, 
    -0.02519368f, -0.02652146f, -0.01617349f, -0.03513338f, -0.00913726f, 0.02616302f, 0.00840687f, -0.00273914f, 
    -0.02315274f, -0.01212970f, -0.02609795f, -0.03253795f, 0.02996030f, -0.02869248f, 0.02802297f, -0.00061198f, 
    -0.01803495f, 0.00563406f, -0.02213389f, -0.03426741f, -0.02630608f, -0.03139520f, -0.04001962f, 0.01431616f, 
    -0.01673395f, -0.01072231f, 0.02709791f, -0.02578657f, 0.02105695f, -0.02044795f, -0.02240743f, -0.02121361f, 
    -0.01280096f, 0.01966064f, 0.02805760f, -0.00253859f, 0.01708064f, -0.00523501f, 0.00042759f, 0.00029832f, 
    0.02785069f, 0.02895612f, -0.03495374f, -0.02372685f, 0.00029455f, 0.01437844f, -0.03429508f, -0.03080589f, 
    -0.02639155f, 0.00901602f, -0.02986404f, -0.02804178f, 0.02319793f, 0.02268095f, -0.00072601f, 0.00730948f, 
    0.02006150f, -0.03815011f, 0.02920112f, -0.02597963f, 0.00106668f, -0.00266608f, 0.02683944f, 0.02615953f, 
    0.01981772f, 0.00518150f, -0.00227779f, -0.00862155f, 0.01416498f, 0.00276490f, -0.01354834f, 0.02769265f, 
    0.01146779f, -0.01909067f, 0.02901818f, 0.03463669f, -0.01466737f, 0.01950650f, -0.02279364f, 0.01698560f, 
    -0.02229997f, -0.00050239f, -0.03679598f, -0.01376090f, -0.02519444f, 0.00916643f, -0.00138377f, -0.02763480f, 
    -0.02277375f, -0.02284874f, -0.03621927f, -0.01205128f, -0.01086367f, -0.01133752f, 0.01583088f, 0.02984696f, 
    -0.01267980f, -0.01871021f, -0.00041059f, -0.02425383f, -0.00674295f, -0.00640160f, 0.01602928f, -0.01323452f, 
    0.01475744f, -0.02805026f, -0.03370510f, -0.01497026f, 0.02898401f, -0.02446358f, -0.01370551f, 0.00828059f, 
    0.03959398f, 0.01796216f, -0.03558779f, -0.02181022f, 0.00182310f, 0.01221263f, -0.03713625f, -0.01396995f, 
    0.01482936f, -0.01436957f, -0.01682691f, 0.01806268f, -0.03633706f, 0.02661923f, -0.00684029f, 0.01807740f, 
    -0.03135610f, 0.02514572f, 0.02079324f, 0.00186067f, -0.02884316f, 0.02908990f, 0.02297036f, -0.01917739f, 
    0.01914683f, -0.03957495f, 0.01997609f, -0.03672052f, 0.02063051f, -0.01588821f, 0.02461405f, -0.02241731f, 
    -0.02769636f, 0.01104893f, 0.00851242f, 0.00261092f, -0.00100251f, -0.02627702f, 0.01680392f, -0.01260039f, 
    -0.01017200f, 0.00377626f, -0.03522383f, 0.01437461f, -0.03039595f, -0.00366241f, -0.01724534f, 0.02552685f, 
    0.02662385f, -0.02730986f, 0.00745174f, 0.01628244f, -0.03688002f, -0.01612056f, 0.02154993f, -0.00917607f, 
    -0.01691818f, 0.02341607f, -0.00990795f, -0.00055897f, 0.02752773f, -0.01252989f, -0.01286043f, -0.02555953f, 
    0.01848728f, 0.03138868f, -0.00499653f, 0.03127865f, 0.00436990f, -0.00327787f, 0.02358779f, 0.02082953f, 
    -0.02307495f, -0.03274675f, -0.00144718f, -0.00883542f, 0.00731735f, 0.02585042f, -0.04178325f, -0.02149193f, 
    -0.02105887f, -0.02679617f, -0.03242241f, 0.00228403f, -0.00409665f, -0.00357454f, 0.01236673f, 0.01353602f, 
    -0.03381989f, -0.02378115f, 0.00983291f, 0.02635195f, 0.01255752f, 0.00418878f, -0.03339431f, -0.03926673f, 
    0.00246879f, 0.01886023f, -0.03995949f, -0.00752900f, -0.02926357f, -0.03635993f, -0.02356081f, -0.03002041f, 
    -0.01554443f, 0.00115365f, -0.01249715f, -0.00178490f, 0.00563082f, -0.00578078f, 0.02777611f, 0.02163203f, 
    0.02824230f, 0.01377636f, 0.02714127f, 0.01060348f, -0.02961121f, 0.02260187f, 0.03591380f, -0.04081661f, 
    -0.02072207f, 0.01701060f, 0.01708793f, 0.02590252f, -0.02094135f, -0.01447868f, -0.03763649f, -0.03251482f, 
    -0.01573887f, -0.00305818f, -0.03018892f, -0.01445439f, -0.03181636f, -0.02484675f, -0.00814521f, -0.04012824f, 
    -0.00908391f, -0.00440221f, -0.00458713f, 0.01542544f, -0.04186434f, 0.01470338f, 0.01501079f, 0.03127616f, 
    0.03534279f, -0.00843573f, 0.03728424f, -0.02768933f, 0.01402647f, 0.01525314f, 0.03209944f, -0.01975874f, 
    -0.04091081f, -0.01670801f, -0.00279061f, 0.00694658f, -0.01647161f, 0.03892040f, -0.04140978f, -0.00800241f, 
    -0.03862918f, -0.02111817f, 0.00498100f, 0.00711029f, 0.01132799f, -0.01039268f, -0.02594757f, 0.03004632f, 
    -0.00437662f, -0.02425648f, -0.00295133f, -0.02347618f, 0.02727810f, 0.00938490f, -0.03225097f, 0.02063712f, 
    -0.01351689f, -0.01716779f, 0.01288450f, 0.00678581f, 0.00685415f, 0.01556175f, -0.00228848f, -0.00921210f, 
    -0.00149498f, -0.03606546f, -0.01447702f, -0.03744847f, 0.00313964f, 0.01054062f, -0.03356713f, -0.02493839f, 
    -0.00654873f, -0.03527425f, -0.01970495f, -0.00362741f, -0.03193252f, -0.02931183f, -0.02623482f, 0.01490346f, 
    0.00334349f, -0.02017764f, 0.02959114f, -0.01118450f, 0.02361852f, -0.01224146f, 0.00444836f, -0.02583419f, 
    -0.01315949f, 0.00432325f, 0.02783261f, 0.00392547f, -0.01159406f, -0.02892422f, 0.00808006f, -0.00504878f, 
    0.01025662f, -0.01107185f, -0.02860953f, 0.02755354f, -0.01521357f, 0.00632739f, -0.04237901f, 0.02469677f, 
    -0.04174561f, -0.02464420f, -0.01073656f, 0.01805863f, 0.00091487f, 0.02530146f, 0.00508571f, -0.04037614f, 
    -0.03841254f, -0.02712357f, 0.01710056f, -0.04233800f, -0.02140112f, -0.01720452f, -0.03611571f, -0.02173238f, 
    -0.00478295f, -0.00092456f, 0.01093909f, 0.02352924f, -0.01607840f, 0.00840860f, -0.02289940f, 0.00631447f, 
    -0.00654381f, -0.01000068f, -0.03022640f, -0.01793153f, 0.00902558f, -0.00831519f, -0.01272809f, -0.00701258f, 
    -0.03037716f, -0.04182521f, -0.03902600f, 0.01848461f, -0.00513668f, 0.00243063f, -0.00995877f, -0.04056702f, 
    0.00961043f, -0.03115607f, 0.00079685f, 0.01284142f, -0.01302318f, -0.03485160f, 0.02261193f, -0.02081702f, 
    -0.01466913f, -0.02298427f, -0.03352591f, 0.01455112f, 0.01438894f, 0.00870223f, -0.02237680f, -0.01151357f, 
    0.00097746f, 0.02019779f, -0.01471959f, 0.00780510f, -0.00765400f, -0.03241388f, 0.01324129f, -0.00614452f, 
    -0.01643850f, -0.00802425f, -0.03092293f, 0.01149734f, -0.00493733f, 0.02835323f, -0.01028303f, -0.03679367f, 
    -0.01333925f, -0.00790722f, 0.00270112f, -0.01712759f, 0.00591401f, -0.01823648f, 0.01679366f, -0.01675948f, 
    0.00580460f, -0.00549628f, 0.00054252f, -0.03161822f, -0.00165845f, -0.01087059f, -0.01534876f, 0.01352691f, 
    0.01071061f, -0.01767137f, 0.02267310f, 0.01208817f, -0.03004098f, -0.04096799f, -0.02717875f, 0.00687298f, 
    0.00501969f, 0.02000596f, 0.00620507f, -0.00746958f, 0.00689630f, -0.01230674f, -0.04179447f, -0.00283674f, 
    -0.03006320f, 0.02349545f, 0.00936468f, -0.03229763f, -0.03781709f, 0.00788633f, -0.02103758f, -0.03705477f, 
    -0.01301704f, -0.01197025f, -0.01283764f, -0.01658307f, -0.03641386f, -0.01434500f, -0.03287948f, -0.00975291f, 
    0.01435619f, -0.00625834f, -0.02276264f, -0.02218389f, 0.01309109f, 0.01445970f, 0.01319786f, -0.02104143f, 
    -0.00139982f, -0.02345665f, -0.03747273f, 0.01260820f, 0.01716773f, -0.03579844f, 0.00387046f, -0.02428286f, 
    -0.00254184f, 0.01564163f, -0.00119749f, 0.00820598f, 0.02482154f, -0.02559325f, -0.01063716f, -0.03336997f, 
    -0.01347501f, -0.00796852f, -0.03773521f, 0.01544273f, -0.01031366f, -0.03981622f, -0.00250195f, 0.00290410f, 
    0.00727371f, -0.02458125f, -0.01600630f, 0.01593541f, -0.03899748f, -0.02042166f, 0.01382604f, -0.00995196f, 
    -0.01246838f, -0.01500034f, 0.00656658f, 0.00883070f, 0.02735312f, -0.04156964f, -0.01798851f, -0.02658062f, 
    -0.01518176f, 0.01194003f, -0.03696906f, 0.00649559f, 0.02510419f, -0.02472224f, 0.00102799f, -0.02664414f, 
    0.01770821f, -0.02865249f, 0.02906912f, -0.01887533f, 0.00701144f, -0.03410979f, 0.02704635f, -0.01524440f, 
    -0.03685934f, -0.03179730f, 0.02961405f, -0.00287678f, -0.04157019f, 0.01778048f, 0.02243005f, -0.00037764f, 
    -0.00965332f, -0.01301595f, -0.02708966f, -0.03017150f, 0.01689211f, -0.00102338f, -0.03592304f, -0.01528722f, 
    -0.03722853f, -0.03704182f, -0.03825232f, -0.01432231f, 0.01679140f, 0.01245805f, 0.01620788f, -0.01914152f, 
    -0.00986672f, -0.02543822f, -0.01883250f, -0.02195839f, -0.02095257f, 0.02797596f, -0.00326855f, -0.03321133f, 
    -0.02900477f, -0.04075304f, 0.01754408f, -0.00250312f, 0.02275751f, -0.00594154f, -0.02758975f, -0.03548867f, 
    0.00308456f, -0.00728047f, 0.02193380f, 0.02693189f, -0.03963582f, 0.00857739f, -0.01164896f, -0.01900000f, 
    -0.03844387f, -0.00114490f, -0.02600173f, 0.00677481f, -0.03664194f, 0.01684911f, 0.00609539f, 0.02211265f, 
    0.00265860f, 0.00773419f, -0.02278071f, -0.02100010f, -0.00375853f, -0.00934274f, -0.03523950f, -0.03979369f, 
    -0.02444960f, 0.01304429f, -0.02585774f, -0.04037027f, 0.01610106f, -0.00901995f, -0.02165647f, -0.01023602f, 
    -0.00806181f, 0.00377062f, -0.01075015f, -0.03788968f, -0.03558248f, 0.01822526f, 0.00282900f, 0.01290015f, 
    -0.01712473f, -0.00352252f, 0.01718984f, 0.01338391f, 0.02463933f, -0.00093919f, 0.02304611f, 0.02209397f, 
    -0.03847502f, 0.01782629f, 0.02604840f, -0.00874423f, -0.01111418f, 0.01980894f, -0.01156047f, 0.01207599f, 
    0.02518686f, -0.04223308f, -0.03821674f, 0.00312946f, -0.00673517f, -0.03762298f, 0.02124039f, 0.01662134f, 
    0.01701535f, -0.01998825f, -0.03755539f, 0.00915727f, 0.01926399f, -0.03040110f, -0.00683953f, -0.03325327f, 
    0.01408176f, -0.04182956f, -0.00756860f, -0.01199915f, 0.02491919f, -0.02615755f, 0.02813249f, 0.00956397f, 
    -0.01791391f, 0.02441341f, 0.02924465f, 0.02256961f, 0.00756352f, 0.02825513f, -0.03521988f, -0.01726225f, 
    0.00860909f, -0.00459374f, -0.01717995f, -0.00498429f, -0.02017165f, -0.01443991f, 0.02706254f, 0.01263087f, 
    0.01572202f, -0.01002630f, -0.02327539f, -0.01864743f, -0.02796834f, -0.00971405f, 0.00659523f, -0.02769725f, 
    0.02477963f, 0.00287311f, -0.00585492f, -0.01891196f, -0.02788764f, 0.01675367f, 0.00094932f, -0.04085000f, 
    0.01231921f, -0.02467734f, 0.02485265f, -0.03899257f, -0.01978979f, -0.03512295f, -0.01686441f, -0.00037602f, 
    0.00020528f, -0.03992416f, 0.01367411f, 0.01152253f, -0.02475025f, -0.03052418f, 0.01650192f, -0.00716369f, 
    -0.01212856f, -0.04053489f, 0.00411951f, 0.01463715f, -0.02573774f, -0.01931207f, -0.02689164f, -0.00210607f, 
    -0.04090393f, -0.02425060f, -0.01368058f, -0.00052496f, -0.01030900f, -0.03050377f, -0.00903444f, -0.04311156f, 
    0.02654247f, -0.01159345f, -0.03962124f, 0.01105131f, -0.00976610f, -0.00532058f, -0.00998675f, -0.01537190f, 
    0.00708040f, -0.01154679f, -0.00400465f, -0.01807502f, 0.00380142f, 0.02145117f, 0.00451981f, 0.00542346f, 
    0.02759133f, 0.02911000f, -0.02754613f, 0.01238180f, 0.00952126f, 0.00670966f, -0.01225745f, -0.01003151f, 
    -0.00601696f, -0.00252989f, -0.01558776f, -0.00042700f, -0.02863752f, -0.04211821f, -0.01593457f, -0.00048517f, 
    -0.04326693f, -0.00947231f, 0.00682119f, -0.03727961f, -0.00415480f, 0.02901562f, -0.00322672f, -0.02869832f, 
    -0.01243974f, -0.02227447f, 0.00183056f, -0.00247168f, 0.02524547f, -0.02452650f, 0.02177948f, -0.00212416f, 
    -0.01366933f, 0.00325341f, -0.02773296f, 0.01721901f, 0.00260206f, 0.00629437f, -0.02247079f, -0.01434077f, 
    -0.02824035f, -0.00158558f, 0.02492663f, 0.00718601f, 0.02178345f, 0.01600756f, 0.02713598f, 0.00090549f, 
    -0.00930953f, 0.00934183f, -0.03577885f, -0.02061713f, -0.03749100f, 0.02538591f, -0.03754881f, -0.00512986f, 
    0.00734116f, -0.04163758f, -0.00924504f, -0.02402969f, -0.02644189f, 0.01813632f, 0.01060889f, -0.01307329f, 
    -0.01694199f, 0.00832100f, -0.02067531f, -0.01977228f, -0.02902381f, 0.02884437f, 0.00819906f, -0.01149020f, 
    0.00527156f, -0.03947125f, 0.01285039f, 0.02179926f, -0.01299579f, -0.02806531f, 0.01166106f, 0.00412927f, 
    -0.01670254f, 0.00346361f, -0.01791501f, -0.00418322f, 0.00324811f, -0.01053245f, -0.02018000f, 0.01940118f, 
    0.00397728f, -0.02378581f, 0.00588328f, 0.00826798f, 0.00284689f, 0.02839503f, 0.01796688f, 0.02346924f, 
    0.00468906f, -0.04178123f, 0.01705925f, -0.03951390f, 0.01042790f, -0.04191813f, -0.04296154f, -0.04178863f, 
    -0.02533188f, 0.02930844f, 0.00227269f, -0.03814347f, -0.02752905f, 0.00540349f, 0.01389225f, 0.02587633f, 
    0.01261827f, 0.01524105f, -0.03045815f, -0.01588028f, -0.03972579f, 0.01857656f, 0.00466268f, -0.01830240f, 
    0.01250103f, -0.02977043f, -0.00285320f, -0.03501818f, 0.02517467f, 0.02323193f, 0.02914325f, -0.02640378f, 
    -0.00461800f, -0.02072520f, -0.02796728f, -0.00352723f, -0.02657629f, -0.02398834f, -0.03114566f, -0.01150169f, 
    -0.02450594f, -0.00882543f, -0.02735906f, -0.01344849f, 0.02623485f, 0.01201188f, -0.03652252f, -0.00741266f, 
    -0.00091562f, 0.02162483f, -0.01546642f, 0.00545539f, 0.01428098f, 0.02118509f, -0.00953108f, -0.02065697f, 
    -0.04270854f, 0.02318098f, 0.02153587f, -0.00026734f, 0.02968727f, -0.03577682f, 0.01166662f, -0.01174632f, 
    0.00013547f, 0.02332392f, -0.03392563f, 0.00487684f, -0.01293364f, 0.01951000f, -0.01631421f, -0.02895625f, 
    0.02703894f, -0.03406199f, -0.04043230f, 0.01144167f, 0.01541085f, -0.01553833f, -0.00034290f, 0.02960991f, 
    0.01518140f, -0.00369656f, 0.02842341f, -0.01382665f, 0.02038070f, -0.00352441f, -0.02999760f, -0.03881986f, 
    -0.03907233f, -0.00183503f, -0.01697054f, 0.00843530f, 0.02154635f, 0.01465768f, -0.02760572f, -0.03269639f, 
    -0.00538316f, -0.03465130f, 0.01444649f, 0.02555096f, -0.02983417f, -0.00593305f, -0.00059387f, 0.01241173f, 
    -0.01212870f, 0.00397920f, -0.03148685f, -0.01887888f, -0.01347874f, -0.03156899f, -0.01517536f, -0.00520651f, 
    0.01016972f, 0.02748947f, -0.02694177f, 0.01452998f, -0.00429048f, 0.02803526f, -0.00053795f, -0.00171508f, 
    0.00943870f, -0.03947882f, -0.00267021f, 0.01413261f, 0.01551561f, -0.03746670f, -0.03396082f, -0.02732616f, 
    -0.01379477f, 0.01909033f, -0.03897478f, -0.00939662f, -0.00576672f, -0.04173210f, -0.02702233f, -0.00213960f, 
    -0.03701863f, 0.02165899f, 0.00131458f, 0.02863258f, 0.01713985f, 0.01724277f, -0.02259608f, -0.00495800f, 
    0.00449858f, -0.02001569f, -0.00736742f, 0.00174157f, 0.00048922f, -0.02344722f, 0.02103586f, 0.02574852f, 
    -0.02950638f, -0.02504220f, -0.03124238f, 0.01828581f, 0.00796094f, 0.00752503f, 0.01789418f, 0.02860855f, 
    0.01108458f, 0.00103644f, -0.00815653f, -0.02556417f, 0.02224762f, -0.01426714f, 0.02499018f, -0.02278473f, 
    -0.03492649f, 0.02167659f, -0.04136987f, 0.00064018f, 0.01323896f, 0.01690436f, 0.02344357f, -0.00687358f, 
    0.00431474f, -0.03222608f, -0.03504143f, -0.01808523f, -0.00950619f, 0.01823719f, -0.01850252f, -0.02722250f, 
    0.02031642f, 0.01879302f, 0.02819903f, 0.00161217f, -0.03082127f, -0.01828676f, -0.01595620f, 0.00247581f, 
    -0.00095399f, -0.03440669f, 0.01092244f, 0.00222414f, -0.00586219f, 0.01612571f, -0.03340900f, -0.04132374f, 
    -0.02007153f, -0.02815609f, -0.03490762f, 0.02073632f, 0.02050035f, 0.01744182f, 0.01565089f, -0.02173114f, 
    0.02702766f, 0.00431711f, -0.01084427f, 0.02590742f, -0.01246168f, -0.00908966f, 0.02115246f, -0.01296236f, 
    -0.00232410f, -0.01465983f, 0.01968571f, -0.00044649f, 0.00559623f, -0.00806603f, 0.02904326f, -0.00133650f, 
    -0.01830993f, -0.01070365f, -0.02731433f, 0.00988142f, -0.00834122f, -0.01769115f, 0.00707839f, -0.00385131f, 
    0.02885874f, 0.00140867f, 0.00795151f, -0.01448500f, 0.02645350f, -0.00935979f, -0.01509080f, 0.00217896f, 
    0.02885775f, 0.02543768f, -0.03847259f, -0.00513909f, -0.00788245f, 0.00319479f, -0.03125345f, -0.00300891f, 
    0.02986545f, 0.01968937f, 0.01071036f, -0.01146339f, 0.02800994f, 0.02449076f, -0.02465764f, -0.02852330f, 
    0.00453027f, 0.02102353f, 0.02765669f, -0.00443916f, -0.01576724f, -0.03507856f, -0.01124753f, 0.02563606f, 
    0.01387023f, 0.01321068f, -0.00667326f, -0.00085166f, -0.01576539f, -0.01920661f, -0.00332408f, 0.00652668f, 
    0.01058045f, -0.02676721f, 0.00198583f, -0.03153103f, -0.01321759f, -0.03170459f, 0.02706521f, -0.01513547f, 
    0.01744987f, -0.00858743f, 0.02003814f, 0.01436068f, 0.02923972f, -0.03386189f, 0.01587675f, -0.03661507f, 
    0.00290295f, 0.00482728f, 0.00531577f, 0.01977787f, -0.02914072f, -0.03588054f, 0.00096450f, -0.00169447f, 
    0.01942245f, -0.02351023f, 0.01691280f, -0.00480414f, -0.01872375f, -0.01754210f, -0.01616077f, 0.02755972f, 
    -0.01537349f, 0.00242764f, 0.01232560f, -0.03582383f, -0.04118180f, -0.03300160f, 0.00830589f, -0.00590844f, 
    -0.03262812f, -0.02208968f, 0.00217781f, 0.00054898f, 0.02644918f, 0.00152247f, 0.01086665f, 0.00360154f, 
    -0.02857065f, -0.01640892f, 0.00705985f, 0.00838688f, -0.01501400f, -0.02299240f, 0.00499253f, -0.00756198f, 
    0.00758587f, -0.03715016f, 0.01810932f, -0.00150641f, 0.01588790f, 0.02763820f, 0.01504620f, -0.00536139f, 
    -0.03347678f, -0.01338040f, -0.03404615f, -0.00998579f, -0.02868305f, -0.00111069f, 0.02772663f, -0.00886401f, 
    0.02331966f, 0.00633444f, 0.00225516f, 0.01374265f, -0.03602566f, -0.03737189f, -0.03504055f, -0.00567862f, 
    -0.00294687f, -0.02670582f, 0.01197073f, 0.01715326f, -0.01286895f, -0.03491348f, -0.03913051f, -0.00228501f, 
    -0.03796658f, 0.02729147f, -0.01211208f, 0.02349673f, -0.02926156f, -0.03049387f, 0.00342650f, -0.04082556f, 
    0.01526485f, -0.03253142f, -0.01067103f, -0.00978995f, -0.00564347f, -0.02635053f, 0.02311817f, 0.00192840f, 
    -0.00042336f, 0.00015744f, -0.00767021f, -0.00642480f, -0.00685048f, -0.02173175f, 0.00129242f, 0.02413169f, 
    -0.02481707f, -0.02916279f, 0.01865245f, -0.03708076f, -0.01584641f, -0.03570835f, 0.02714349f, -0.02977604f, 
    -0.03714357f, 0.01797037f, 0.00884199f, -0.04029493f, 0.00358761f, -0.04079038f, -0.03798002f, 0.02384037f, 
    -0.00012280f, -0.02651200f, 0.02575511f, 0.02264891f, -0.00995176f, -0.02811367f, -0.04115863f, -0.00733784f, 
    -0.03421374f, 0.02150379f, -0.01417841f, -0.01808217f, -0.00788969f, -0.03351755f, 0.00136418f, 0.02402270f, 
    -0.00097812f, -0.02768371f, -0.04010175f, 0.00520986f, 0.00693111f, 0.00395106f, 0.02045720f, 0.00763367f, 
    -0.01610503f, 0.00261798f, 0.01677566f, -0.00681733f, -0.03911332f, -0.01105041f, 0.01738990f, -0.00101779f, 
    -0.00139702f, 0.01977813f, 0.00584938f, -0.04108611f, 0.01335177f, -0.00420035f, -0.03615431f, -0.03268343f, 
    -0.03026589f, -0.00198333f, -0.02112569f, -0.00652341f, -0.03540560f, 0.00552078f, -0.02906677f, 0.00858481f, 
    -0.03976233f, 0.00599125f, -0.01742237f, 0.00150101f, 0.01037511f, -0.00500234f, 0.01100721f, -0.03815140f, 
    0.00599397f, 0.01725085f, 0.03002085f, 0.02143189f, 0.00681064f, -0.00537869f, 0.02651091f, -0.00580668f, 
    0.00322905f, 0.01603322f, -0.01555974f, 0.02241029f, 0.00457373f, -0.02875488f, -0.02560397f, -0.03502299f, 
    -0.03955480f, 0.01412371f, -0.00271407f, -0.03906948f, -0.03036389f, -0.02548788f, 0.00577685f, -0.00038389f, 
    -0.00684270f, 0.01315863f, -0.03118667f, 0.01051798f, 0.01894221f, -0.03728985f, -0.00425633f, 0.02222688f, 
    -0.01960171f, 0.00285169f, 0.00037109f, -0.02003162f, -0.01898159f, 0.00327101f, -0.02729164f, -0.01360768f, 
    -0.01815857f, 0.01974221f, -0.01357572f, -0.02849906f, -0.00487169f, -0.04065810f, -0.02009905f, 0.00541415f, 
    0.00346411f, -0.03155896f, 0.00585237f, -0.02350693f, 0.02837998f, 0.00378484f, 0.00451045f, 0.02248157f, 
    0.00786287f, -0.01329972f, 0.02195204f, -0.02413756f, 0.01220953f, -0.00978644f, -0.03191983f, 0.00293446f, 
    0.00425508f, 0.00906722f, 0.02135081f, 0.02842777f, 0.00203133f, -0.01974862f, -0.01639707f, 0.02956012f, 
    0.00854595f, -0.00067120f, -0.04168537f, 0.02649117f, -0.01065535f, 0.01127855f, -0.03811986f, -0.03399299f, 
    -0.00714325f, -0.04162968f, -0.03049100f, 0.02335608f, -0.01816414f, -0.04086984f, -0.03279021f, -0.00328507f, 
    -0.00207378f, -0.01419424f, -0.00446142f, -0.01337824f, 0.02995207f, -0.02923271f, 0.02743723f, -0.02631297f, 
    -0.00104871f, -0.00833726f, -0.00772080f, -0.00621691f, -0.01640759f, 0.00015436f, -0.02333823f, 0.00941845f, 
    0.00637005f, 0.01328396f, 0.01709391f, 0.01452100f, 0.00108534f, -0.02564575f, 0.00781574f, -0.01192852f, 
    -0.02964677f, -0.03419842f, -0.04072079f, 0.02300856f, -0.01439154f, 0.02717640f, -0.00067718f, 0.02053600f, 
    -0.02656236f, 0.00249014f, 0.02304590f, -0.02199109f, -0.02294537f, -0.03015641f, 0.01911588f, 0.00560540f, 
    -0.01166581f, 0.02834337f, -0.03184752f, -0.02446555f, 0.00016453f, -0.02846339f, -0.02834610f, 0.01780671f, 
    -0.00990531f, 0.01660509f, 0.01665421f, 0.02036090f, -0.03729513f, -0.00537294f, -0.02114729f, -0.01049816f, 
    0.00748986f, -0.02376828f, -0.02718253f, -0.02816594f, 0.01846889f, 0.00224169f, -0.00239498f, -0.03226615f, 
    -0.01025278f, -0.02003364f, 0.01244971f, 0.01008187f, 0.02481231f, -0.00969537f, -0.01509268f, 0.02778382f, 
    -0.01531125f, -0.03341604f, -0.04136201f, -0.03690508f, -0.01305630f, -0.01436311f, -0.02760453f, -0.01949358f, 
    -0.00884359f, 0.01244274f, -0.03322968f, 0.00966794f, -0.01567838f, -0.00540990f, 0.01204295f, -0.00724672f, 
    -0.03452743f, -0.03091005f, -0.00768371f, 0.02941742f, -0.00635807f, -0.00435395f, -0.00201037f, -0.02953770f, 
    0.01694328f, 0.02159623f, -0.03801233f, -0.00951372f, -0.03758124f, 0.00581020f, -0.00107595f, 0.02568741f, 
    -0.00833622f, -0.03756931f, -0.00970853f, 0.02963888f, 0.02168850f, -0.01424451f, -0.00956262f, 0.01431427f, 
    0.02556044f, -0.03268903f, 0.02277326f, -0.01553528f, -0.00091062f, 0.00662098f, -0.02581482f, 0.01862429f, 
    0.01564640f, 0.01164610f, 0.00255954f, -0.02025339f, 0.02020677f, 0.02321455f, 0.01251233f, 0.03382264f, 
    -0.01414879f, -0.02611458f, 0.00832707f, -0.02718595f, -0.02152011f, 0.02474940f, -0.01563777f, -0.01411367f, 
    -0.00569815f, 0.01826178f, 0.02426597f, -0.03860593f, -0.01457150f, 0.01685948f, -0.01979417f, 0.01455121f, 
    -0.01076669f, 0.02545628f, 0.01168446f, -0.01518936f, 0.02862231f, -0.03656461f, -0.01170482f, -0.00594567f, 
    0.02727461f, -0.04164727f, -0.03247440f, 0.01969894f, -0.01668024f, -0.01504743f, 0.01071494f, -0.02493361f, 
    0.00347423f, -0.02273939f, -0.03603014f, -0.00845497f, 0.02784651f, -0.00074437f, -0.02791002f, -0.00488243f, 
    0.02021576f, -0.03829271f, 0.00637962f, -0.03297094f, -0.02264048f, -0.00960964f, -0.00123730f, -0.00239356f, 
    0.00298044f, 0.02568277f, 0.02809694f, -0.02129461f, -0.02789818f, 0.00290386f, -0.03372172f, -0.01024662f, 
    -0.02531720f, 0.03092370f, 0.01892515f, 0.00537384f, 0.00385412f, -0.04080141f, -0.03917459f, 0.00807241f, 
    -0.03576809f, -0.00802258f, 0.01150622f, -0.02726903f, -0.02972274f, -0.03149275f, -0.03364073f, -0.03405694f, 
    0.01062339f, 0.01581560f, 0.02392102f, 0.01148517f, -0.02632692f, -0.01144677f, -0.02977549f, 0.02940137f, 
    0.01771800f, -0.00593909f, 0.01428613f, -0.02074541f, -0.02691289f, -0.00541481f, -0.03979737f, 0.02485324f, 
    -0.02618526f, -0.02381164f, -0.02485405f, 0.01579481f, 0.01984809f, -0.01127336f, 0.02019877f, 0.02908771f, 
    -0.03507408f, 0.02439094f, -0.03984559f, 0.00878651f, -0.02215018f, -0.03411282f, -0.01686805f, 0.02179221f, 
    -0.00671816f, -0.03097996f, 0.01806260f, -0.02176723f, -0.03234810f, -0.03682845f, -0.02969944f, 0.01791812f, 
    -0.02815427f, -0.00699227f, 0.00746710f, 0.01651421f, 0.02868848f, 0.01427399f, 0.00835892f, -0.04033550f, 
    -0.01759997f, -0.00811556f, 0.01634643f, 0.02444852f, -0.03074735f, 0.00022505f, -0.02702401f, -0.03984046f, 
    -0.02703980f, 0.00066064f, -0.02285784f, 0.00500375f, -0.03462165f, 0.01401026f, 0.01240361f, -0.01688147f, 
    -0.02941125f, -0.04207011f, -0.01321641f, 0.01410636f, 0.02314212f, -0.01628650f, 0.02041171f, -0.00224854f, 
    -0.00025760f, -0.02298187f, -0.01888268f, -0.00051119f, -0.03463553f, 0.01960324f, 0.00861083f, -0.00032445f, 
    -0.01604816f, -0.01097072f, -0.03112969f, 0.02900597f, 0.01557872f, -0.00287025f, -0.02837690f, 0.02770539f, 
    -0.03500777f, -0.01190089f, 0.02383633f, 0.01851749f, -0.00147907f, -0.03686598f, -0.00248615f, -0.03859755f, 
    -0.02392005f, -0.00017339f, 0.02728804f, -0.00069326f, -0.01236955f, 0.02060737f, -0.03456749f, 0.02019255f, 
    0.01972983f, -0.00813666f, -0.02840096f, 0.00922519f, -0.02774717f, -0.03514247f, -0.01967712f, -0.02046294f, 
    0.01860858f, 0.01437950f, -0.03210301f, 0.00235823f, -0.02229821f, 0.01749007f, -0.00766682f, -0.02221315f, 
    -0.02481383f, -0.02112114f, 0.01896306f, -0.03320825f, 0.01250040f, -0.03487945f, -0.01483564f, -0.03591226f, 
    -0.01115231f, -0.00666216f, -0.02797435f, 0.02165427f, -0.01679685f, -0.03456235f, 0.01008525f, -0.01919655f, 
    0.00803559f, -0.04009422f, 0.00644496f, 0.02321132f, -0.03379606f, 0.00245902f, 0.02552209f, -0.00131457f, 
    -0.03342095f, 0.00540513f, 0.01562266f, 0.00363080f, -0.02924867f, -0.02754955f, 0.01739265f, -0.03265358f, 
    -0.01444618f, -0.03175428f, 0.00868577f, -0.01769409f, -0.02124586f, 0.01581763f, 0.02268658f, -0.00531744f, 
    0.03005558f, -0.00227589f, 0.01259781f, 0.02545182f, 0.01807584f, 0.00684856f, 0.02653625f, -0.02777566f, 
    -0.02290449f, -0.03908017f, -0.00658743f, 0.00758319f, 0.02425769f, 0.01020286f, 0.00968397f, -0.01596485f, 
    -0.02150910f, 0.02127819f, 0.01822432f, -0.03047821f, 0.01649808f, 0.00304359f, -0.03694449f, 0.01687314f, 
    -0.03333582f, -0.03591783f, 0.01637866f, 0.00649006f, -0.00457774f, -0.03028974f, -0.04053413f, 0.01361388f, 
    0.02618737f, -0.01163069f, -0.00896251f, -0.00591222f, -0.03766939f, -0.01334454f, -0.03171808f, 0.02067732f, 
    -0.02865838f, -0.03241711f, 0.01570174f, -0.04005289f, -0.04061920f, -0.01941139f, -0.03714171f, -0.03823625f, 
    0.00206928f, 0.01961794f, -0.00821521f, -0.01647690f, -0.00088955f, -0.00449429f, 0.02630339f, 0.01871285f, 
    -0.00262776f, 0.01148637f, -0.04197268f, -0.00143234f, 0.02111486f, -0.00688348f, -0.01457966f, -0.01665570f, 
    -0.03952328f, -0.00710186f, -0.01368517f, 0.00503855f, -0.03206926f, -0.02178049f, 0.00705106f, -0.00412649f, 
    -0.03568068f, -0.01572428f, -0.00533048f, -0.00166246f, 0.01369989f, 0.02708199f, -0.03377516f, -0.00331219f, 
    0.00506566f, -0.02558231f, -0.00922049f, -0.01030932f, 0.00070246f, -0.01900902f, -0.01500944f, 0.00723762f, 
    -0.00939380f, 0.03005458f, 0.00110282f, -0.03265563f, -0.02982208f, -0.01256508f, -0.01238833f, 0.02036623f, 
    0.13222797f, 0.16366205f, 0.10464962f, -0.10057867f, -0.14565940f, -0.05591615f, -0.07677323f, -0.04694267f, 
    0.10884070f, 0.05297977f, -0.02882949f, 0.04284225f, -0.27426198f, 0.05393827f, -0.43316099f, -0.00024439f, 
    0.04344869f, -0.09968100f, -0.05302577f, 0.12437347f, 0.00652788f, 0.04803474f, -0.12081482f, 0.04530963f, 
    0.36268622f, 0.07955010f, -0.01626645f, 0.14369662f, 0.06039070f, -0.09718033f, -0.08830412f, -0.14507893f, 
    0.07230636f, -0.00275298f, 0.06565774f, 0.19935969f, 0.20127331f, 0.27820325f, 0.02418326f, -0.16531955f, 
    0.03329836f, -0.06339138f, 0.07159340f, -0.07736474f, -0.05364802f, 0.09139065f, 0.20963460f, 0.13170581f, 
    -0.07651667f, -0.14325288f, -0.04865981f, 0.06024600f, 0.13145104f, 0.10473080f, -0.01709513f, 0.09920336f, 
    0.07987750f, 0.06631947f, -0.15391248f, -0.09929718f, -0.23298971f, 0.03915003f, 0.24183512f, -0.03514915f, 
    -0.11621501f, -0.16847278f, 0.10371479f, 0.09264569f, -0.06730934f, 0.18090044f, 0.15177426f, -0.14282073f, 
    0.13049984f, -0.15984692f, 0.03607076f, 0.10937697f, 0.02872998f, 0.05584597f, -0.15254906f, -0.12094683f, 
    0.02055140f, -0.02984279f, 0.15379240f, 0.04276335f, 0.07387150f, -0.04418520f, -0.04670458f, 0.09344681f, 
    -0.06282686f, -0.09132139f, -0.04145936f, 0.03177861f, -0.06418855f, 0.06285920f, -0.18865675f, -0.05466474f, 
    -0.31173331f, -0.14823754f, 0.11743739f, 0.18218622f, -0.15438020f, 0.07082888f, 0.09279278f, 0.00982188f, 
    0.00366306f, 0.08788813f, 0.14423873f, 0.03328769f, -0.06633344f, -0.10794335f, -0.00924517f, 0.04577265f, 
    0.12516510f, 0.04121319f, -0.05195327f, 0.04223363f, 0.12001155f, 0.01147373f, 0.00427869f, 0.18122908f, 
    -0.27549240f, -0.12245462f, 0.15393090f, 0.20691158f, -0.00880239f, 0.00122155f, 0.01726363f, 0.02996959f, 
    0.01894337f, 0.09041129f, -0.04613870f, -0.09589242f, -0.19709742f, -0.01699077f, 0.10777120f, 0.21553850f, 
    0.06213163f, -0.09760597f, 0.07357733f, 0.03988854f, 0.01079386f, 0.02839190f, 0.06067901f, -0.00742557f, 
    -0.21092261f, 0.38616845f, 0.03713990f, 0.00533758f, -0.06481631f, -0.03879855f, 0.00267517f, -0.17632367f, 
    0.15593287f, 0.06442413f, -0.07736785f, 0.00620164f, 0.17093053f, 0.12274723f, -0.18038996f, 0.02446233f, 
    0.04441619f, -0.05756532f, 0.05126556f, -0.04306864f, 0.00392879f, 0.10820542f, -0.20774765f, -0.05091789f, 
    -0.03147312f, 0.24447244f, -0.20148732f, -0.03917058f, 0.10142362f, -0.12987827f, -0.06616963f, -0.06390986f, 
    -0.00096156f, 0.03358531f, 0.06687472f, -0.09054221f, 0.25071976f, -0.20753796f, 0.06987958f, 0.00783961f, 
    -0.04230956f, 0.06178573f, 0.05733559f, -0.07203885f, -0.02728818f, 0.05528684f, 0.02823379f, 0.04493778f, 
    -0.00937087f, -0.03492146f, 0.02665671f, -0.08517425f, -0.01754477f, -0.00142381f, 0.03254132f, 0.09633829f, 
    0.05959678f, -0.06412528f, 0.00046381f, -0.01978084f, 0.05612942f, 0.10802776f, 0.17671376f, 0.13387968f, 
    -0.05841157f, -0.08953646f, 0.06257569f, -0.04483170f, 0.08200977f, 0.18055499f, -0.08610664f, -0.09738658f, 
    -0.39909402f, 0.04674707f, 0.18772979f, 0.22834682f, 0.06554278f, -0.12526266f, -0.03482860f, 0.15561920f, 
    0.04112056f, 0.08567368f, 0.11897754f, 0.08479493f, -0.15072991f, -0.22935879f, -0.00112242f, 0.07568069f, 
    0.18378954f, 0.16122486f, -0.01942825f, -0.10624682f, 0.04396985f, 0.02847772f, -0.00003262f, 0.02229025f, 
    -0.11383247f, 0.12671414f, -0.04681223f, 0.18025742f, 0.04349328f, 0.02044909f, 0.18781133f, 0.02951274f, 
    0.00338171f, 0.21629612f, -0.28292796f, -0.03448646f, 0.06721964f, 0.03101743f, -0.05341464f, -0.12794161f, 
    0.00764547f, -0.12225840f, 0.06416041f, 0.00843051f, -0.01766793f, -0.03088341f, -0.09881854f, -0.00042696f, 
    -0.08650476f, 0.27398625f, -0.01773516f, 0.23970398f, -0.11117896f, -0.16397566f, 0.07449640f, -0.12898874f, 
    0.16336444f, -0.01104187f, -0.11732197f, 0.07459614f, 0.55328095f, -0.13438849f, 0.17181258f, -0.10672456f, 
    -0.07158682f, -0.03646301f, 0.03215510f, -0.01006793f, -0.02121831f, 0.00401456f, 0.15560773f, 0.17645609f, 
    0.27852446f, 0.24880245f, 0.09866242f, -0.23185088f, -0.05968270f, 0.05599306f, -0.00135990f, 0.05865366f, 
    0.24967866f, -0.24400795f, 0.07092853f, -0.06199133f, -0.31227854f, 0.05974764f, 0.28116378f, 0.07228161f, 
    -0.03109525f, -0.03795362f, 0.09751399f, 0.00583803f, -0.02173384f, -0.08561276f, -0.01334772f, 0.02635536f, 
    -0.17304119f, -0.12699607f, 0.00674879f, 0.20050198f, 0.20367226f, 0.07571423f, -0.18458870f, 0.08973021f, 
    0.05435202f, 0.18232504f, -0.09958279f, 0.07993270f, -0.14268044f, 0.04996537f, 0.42651543f, 0.08460348f, 
    0.11918551f, 0.10043079f, -0.03032744f, 0.01836213f, 0.03462230f, 0.12660961f, 0.11888479f, 0.03974096f, 
    0.04515434f, 0.02739097f, -0.09213048f, 0.08654911f, 0.14209035f, -0.06249948f, 0.00460931f, 0.16894074f, 
    0.16334789f, 0.03431626f, -0.18694568f, 0.00300749f, 0.03047683f, -0.07028442f, 0.10026678f, 0.16621892f, 
    -0.00985442f, -0.01177316f, -0.07390327f, -0.12007857f, 0.01254177f, -0.23329292f, 0.08399199f, 0.09801525f, 
    0.11153399f, -0.01716612f, 0.12190127f, -0.24931873f, 0.04114781f, 0.01833559f, -0.02884743f, 0.10950600f, 
    0.16693723f, -0.13934341f, -0.01242619f, 0.13328092f, 0.17127843f, 0.26407430f, -0.10005160f, 0.03137562f, 
    -0.08289862f, 0.07957090f, -0.06879518f, -0.14257267f, 0.05864637f, 0.03648595f, -0.04291321f, 0.08828945f, 
    0.10129575f, 0.21395570f, -0.00205168f, -0.09514717f, 0.01267763f, 0.03244332f, -0.09693167f, -0.21931601f, 
    0.07070909f, 0.07544822f, 0.07328238f, 0.08088354f, -0.08496346f, -0.24173746f, -0.22449148f, -0.01791372f, 
    -0.04362857f, -0.17869550f, 0.01256186f, -0.08839241f, 0.01045357f, 0.10125753f, -0.13311023f, 0.08825494f, 
    -0.22620822f, 0.13888349f, 0.05107591f, 0.20910496f, -0.09462301f, 0.07796689f, -0.01016037f, -0.06341010f, 
    0.21609706f, -0.00893177f, 0.05369140f, 0.02869130f, 0.13204366f, -0.15503903f, 0.00517937f, 0.23151687f, 
    -0.04238496f, 0.08310813f, -0.02235981f, 0.01969591f, -0.00064079f, 0.17302004f, -0.01885758f, 0.00572840f, 
    0.28274590f, 0.01264403f, 0.35248855f, -0.37656510f, -0.02827720f, 0.02061214f, -0.07559286f, 0.11620931f, 
    0.12489142f, -0.05754925f, 0.03228279f, -0.06181361f, -0.09702763f, -0.06923375f, 0.14988892f, -0.02849577f, 
    0.01572863f, -0.06016385f, 0.09301546f, -0.00763024f, 0.08354703f, 0.00364648f, -0.00511438f, -0.09324016f, 
    0.13860074f, 0.01203979f, -0.07946113f, -0.08907022f, -0.09733284f, -0.03355075f, -0.00623184f, -0.01145026f, 
    0.20527591f, -0.06893990f, 0.06216664f, -0.01885762f, 0.05131030f, 0.25983700f, 0.19846217f, -0.11957470f, 
    0.02145744f, 0.15698190f, -0.14668150f, -0.04677608f, 0.13064292f, 0.00474141f, 0.10103848f, 0.05875624f, 
    -0.34840164f, 0.14696698f, 0.17594449f, 0.15341073f, -0.03948525f, -0.01581999f, -0.00177018f, 0.25278404f, 
    0.09336033f, 0.07122657f, 0.14681357f, -0.04840148f, 0.17995377f, -0.16103028f, 0.12914790f, 0.10546017f, 
    0.01562182f, -0.00050368f, -0.01826494f, -0.14927608f, -0.03319004f, -0.04032476f, 0.06550551f, 0.06572010f, 
    0.00539319f, 0.12805159f, -0.15605910f, -0.01490638f, 0.05247272f, 0.05848651f, 0.01678666f, -0.01321425f, 
    -0.04891670f, -0.01681031f, 0.07143143f, 0.04618208f, -0.24471675f, -0.04289535f, 0.12145035f, 0.24264607f, 
    -0.12537202f, 0.09869744f, 0.12968142f, 0.05029428f, 0.05230476f, 0.09742144f, 0.12192735f, -0.12555052f, 
    -0.36047396f, -0.20173256f, 0.01344932f, 0.16270493f, 0.17819479f, 0.11739966f, 0.17890881f, -0.04783266f, 
    0.03661480f, -0.18939845f, 0.10586867f, 0.05009277f, -0.12797979f, -0.05298227f, -0.00652516f, 0.07328951f, 
    0.13041617f, 0.03474513f, -0.10152073f, -0.02745457f, -0.08493041f, 0.05847604f, 0.04527312f, 0.14703125f, 
    0.10703764f, 0.16264029f, -0.13575022f, 0.14879492f, 0.00988047f, 0.02103341f, -0.03656722f, 0.14459324f, 
    0.05318844f, 0.05485497f, -0.02023797f, 0.11942370f, 0.13076797f, -0.15072703f, 0.08197773f, 0.07507290f, 
    0.08640438f, 0.00107233f, 0.02795717f, -0.08863897f, -0.02530449f, -0.09303337f, 0.07781979f, 0.13216132f, 
    0.02957989f, -0.04755748f, -0.05935616f, -0.06363921f, -0.15923908f, -0.04016958f, -0.00293523f, 0.12539387f, 
    -0.12137983f, -0.09955113f, -0.05970108f, -0.10295509f, 0.11545899f, 0.13530526f, 0.26650816f, -0.30492476f, 
    -0.01309272f, -0.12933044f, 0.13260438f, -0.17313567f, -0.05515563f, 0.06891032f, -0.04716848f, 0.05608265f, 
    0.31005335f, 0.12894671f, -0.21738787f, 0.10776371f, 0.07789592f, -0.01324379f, 0.21339859f, 0.13678080f, 
    0.04080366f, -0.09035123f, -0.01182021f, 0.19731587f, -0.02874135f, -0.09191915f, 0.30212122f, 0.23789530f, 
    0.06224581f, 0.00130464f, 0.11429411f, 0.05565989f, 0.07806023f, 0.05753441f, -0.06173931f, -0.02361923f, 
    -0.16246533f, 0.23933728f, -0.04953754f, -0.13213173f, 0.09911443f, -0.05557292f, 0.16433184f, 0.15647638f, 
    0.14404482f, 0.15189682f, 0.13834204f, -0.17658669f, -0.01613440f, -0.15377511f, -0.07417397f, -0.04146070f, 
    -0.21831398f, -0.04233230f, -0.02363477f, 0.14461990f, 0.01046113f, -0.08831741f, 0.11110101f, -0.10417048f, 
    -0.00559213f, -0.06195814f, 0.32265115f, 0.02610626f, 0.09663788f, 0.00793987f, -0.09032530f, 0.04655565f, 
    0.09828915f, 0.06833587f, -0.06350957f, -0.03930995f, 0.02355744f, -0.10759612f, 0.05069447f, -0.08234277f, 
    -0.08462685f, 0.10084721f, 0.08417406f, -0.07978003f, 0.03148013f, -0.02054866f, -0.11017480f, 0.01345990f, 
    -0.05754742f, 0.09256801f, 0.05175103f, 0.33825743f, 0.08038613f, 0.10720848f, -0.03436519f, -0.15908346f, 
    0.07545206f, 0.05720735f, 0.07168540f, -0.16811943f, -0.19879039f, 0.26575485f, -0.28399429f, 0.14528129f, 
    -0.02483244f, -0.17943393f, 0.05196524f, -0.33502179f, 0.04531755f, 0.01049450f, -0.06015805f, -0.06245090f, 
    -0.19798233f, -0.09264354f, 0.32412025f, -0.10559346f, -0.02402736f, -0.00710136f, 0.05352360f, 0.05478988f, 
    0.13421433f, 0.02899033f, 0.04379458f, -0.03643327f, -0.10851797f, 0.00737861f, -0.00025833f, 0.02537523f, 
    0.04797610f, -0.07108524f, -0.03243295f, 0.12248544f, -0.05774629f, 0.01515772f, 0.03594581f, 0.02278448f, 
    -0.04403111f, 0.27204287f, -0.32415530f, -0.04734710f, 0.06286462f, -0.02114012f, -0.04143857f, 0.01919249f, 
    -0.16330983f, 0.08596873f, 0.09334256f, 0.10629058f, -0.27443478f, 0.03732030f, 0.20331043f, 0.16658068f, 
    0.01259485f, -0.19367038f, 0.20922202f, -0.02430012f, -0.04696518f, 0.12249123f, -0.04760441f, -0.00929865f, 
    -0.09543688f, -0.07888170f, 0.01679876f, 0.02385873f, 0.01700162f, 0.03734802f, -0.00777824f, 0.00178123f, 
    -0.13089399f, -0.04829736f, -0.02375682f, -0.07676136f, -0.06592134f, -0.01441134f, -0.07220814f, 0.07975088f, 
    -0.00404779f, 0.10744265f, -0.05289152f, 0.00002764f, 0.01451146f, 0.26437163f, 0.11698186f, -0.09549986f, 
    -0.26872757f, -0.07716778f, -0.15438566f, 0.31227589f, 0.09285666f, 0.09488872f, -0.08178240f, -0.05790178f, 
    -0.00308003f, 0.15808679f, 0.06664005f, 0.25153038f, 0.21941328f, 0.13270056f, 0.22650762f, -0.12026188f, 
    0.00728137f, 0.11343870f, -0.11001027f, -0.03794774f, 0.07180062f, 0.01854990f, 0.20292509f, 0.22724207f, 
    0.18754165f, -0.10860331f, -0.06786592f, -0.01565013f, 0.06572974f, 0.00844405f, 0.11288744f, -0.07056232f, 
    -0.10812834f, -0.01252000f, 0.18293749f, 0.40276614f, -0.68082595f, -0.20529598f, -0.05640121f, 0.13233268f, 
    0.21091723f, 0.07815543f, 0.21734956f, -0.06015497f, -0.08287985f, 0.08816533f, 0.13120244f, 0.09834404f, 
    0.21059951f, 0.20101295f, -0.09542736f, -0.10650679f, 0.03390682f, -0.07185222f, -0.02942955f, 0.12461734f, 
    0.06822903f, -0.13295542f, -0.10713039f, -0.31964967f, 0.12465642f, 0.06610128f, -0.01665377f, 0.04085935f, 
    0.02145493f, -0.00062514f, 0.03048952f, -0.03439877f, -0.09958198f, -0.25169113f, -0.03788619f, -0.24539410f, 
    -0.05079696f, -0.02085355f, -0.19314688f, -0.02662267f, 0.00077160f, 0.00263637f, 0.06535899f, 0.09056493f, 
    -0.01225758f, -0.04308191f, 0.01712588f, 0.17314334f, -0.04729362f, -0.14192362f, 0.04268541f, 0.12426724f, 
    0.17037770f, -0.02788862f, -0.04670145f, -0.18908972f, -0.07993437f, -0.07746853f, -0.16349025f, -0.01686893f, 
    0.17203355f, 0.14627697f, -0.00600149f, 0.12917644f, 0.04537988f, 0.04858773f, 0.08344024f, 0.18489178f, 
    0.15007773f, -0.01232344f, 0.09518405f, 0.24448645f, 0.12870036f, -0.24529375f, 0.15927181f, -0.33034253f, 
    0.08476508f, -0.03864508f, -0.09824003f, -0.26569572f, 0.06741022f, -0.02080142f, 0.04366775f, -0.00599411f, 
    0.06091399f, 0.02487678f, -0.05897038f, -0.19536352f, -0.03798534f, -0.03630419f, -0.02389266f, 0.04398459f, 
    -0.07587434f, -0.06350884f, -0.06391673f, -0.05555018f, 0.25676644f, -0.01823436f, -0.04057985f, -0.10530982f, 
    0.06075963f, -0.10476229f, 0.06203071f, 0.09043580f, 0.09508946f, 0.02951031f, 0.09127805f, 0.14643152f, 
    0.29319945f, -0.23467521f, -0.04705832f, 0.26074713f, -0.02814772f, 0.04813243f, -0.02748483f, -0.12856694f, 
    0.16063067f, 0.03018557f, 0.02462094f, 0.01606069f, -0.46562186f, -0.06297666f, 0.03414684f, 0.13287231f, 
    0.19762629f, -0.04536430f, -0.02601822f, -0.08949738f, -0.11686523f, -0.00747590f, -0.01245611f, -0.06137894f, 
    -0.28902590f, 0.40357450f, 0.00646926f, 0.09024379f, 0.19415155f, -0.22768548f, -0.10210428f, -0.15330310f, 
    -0.06033326f, 0.21769497f, -0.08045755f, -0.16861272f, 0.03093167f, 0.05475481f, 0.21345961f, 0.32182270f, 
    -0.08264039f, -0.08373238f, -0.06471562f, 0.01843046f, 0.09182278f, 0.12829092f, 0.11092536f, 0.10410647f, 
    -0.23727898f, 0.10795870f, -0.07276763f, -0.05313502f, 0.11297600f, -0.13343272f, -0.15268332f, -0.05500651f, 
    -0.33647078f, -0.19378617f, -0.31501254f, -0.35584787f, 0.17497772f, 0.16123202f, -0.06785461f, 0.12179513f, 
    0.05637311f, -0.04639776f, -0.03194868f, -0.02809176f, -0.05799400f, 0.04874123f, -0.01332823f, 0.13691778f, 
    0.23956725f, 0.18433243f, 0.04936085f, -0.05252688f, -0.01037276f, 0.03881942f, 0.13684729f, 0.06027346f, 
    -0.09850372f, 0.07575712f, -0.07543370f, 0.06187003f, 0.20192926f, 0.04100268f, -0.09300294f, -0.13465436f, 
    0.00553879f, 0.06210868f, -0.00532537f, 0.19006753f, 0.12571014f, -0.14105351f, -0.08969396f, -0.19911067f, 
    0.17954776f, -0.02185988f, 0.01995702f, 0.18938327f, 0.06794480f, 0.04870703f, -0.10098007f, 0.00023152f, 
    -0.06392889f, -0.02577295f, 0.07397504f, -0.10234284f, -0.08889223f, -0.06311301f, -0.01295457f, 0.18493254f, 
    0.09757737f, 0.16991551f, -0.09813168f, -0.23300807f, -0.15554105f, -0.14880447f, -0.27864885f, -0.27407700f, 
    0.07250264f, -0.25431773f, 0.09243449f, 0.10812219f, -0.07641114f, -0.04686910f, 0.03856198f, 0.14352269f, 
    -0.02709451f, 0.15601769f, -0.02052855f, -0.12592202f, -0.13080184f, 0.06558520f, -0.12485985f, -0.10431255f, 
    -0.16170143f, -0.06157060f, -0.14299297f, -0.13287145f, -0.00008381f, -0.01674394f, 0.04056209f, -0.02325271f, 
    -0.47866401f, -0.16816191f, -0.08508619f, 0.07469087f, -0.01920668f, 0.12015473f, -0.10985048f, -0.01086158f, 
    0.05660754f, 0.04896409f, 0.08957914f, 0.21693029f, 0.10785259f, -0.09093152f, -0.13562672f, -0.06948084f, 
    -0.01816555f, -0.08940848f, 0.04821156f, 0.08391487f, 0.08600866f, 0.09411784f, 0.08070394f, -0.16294041f, 
    -0.12139663f, 0.22726606f, -0.09063414f, -0.24564306f, 0.12371594f, 0.04267908f, -0.01941365f, -0.16475372f, 
    -0.07864355f, -0.03789787f, -0.02337500f, -0.13999680f, -0.00315193f, 0.02259696f, -0.09950139f, 0.13464385f, 
    0.00084882f, -0.00510943f, 0.06413656f, -0.00723649f, -0.00352238f, -0.00719530f, 0.05247379f, 0.11484396f, 
    0.10244337f, 0.16268846f, -0.28250518f, 0.00307489f, 0.14486994f, 0.00496947f, -0.20818920f, 0.08566812f, 
    -0.11951680f, -0.05118933f, -0.24674951f, -0.19357418f, 0.23135062f, -0.15085751f, 0.05640751f, -0.03919529f, 
    -0.03820390f, -0.08799753f, 0.03458873f, 0.03985047f, 0.10780467f, 0.07914639f, 0.01847068f, 0.11719837f, 
    -0.16775879f, 0.36577898f, 0.08090800f, 0.36017442f, 0.15640974f, 0.14871016f, 0.05207752f, 0.13411553f, 
    0.19926395f, 0.08300269f, 0.04013829f, 0.22951989f, -0.63819361f, -0.37939325f, 0.15385403f, 0.10404623f, 
    -0.03836472f, 0.12703411f, 0.00099128f, -0.11111664f, -0.07369763f, 0.13225713f, 0.10547300f, 0.11595420f, 
    -0.30733848f, -0.16819993f, -0.11695978f, 0.25356147f, -0.09704689f, 0.10409343f, 0.03922175f, -0.07333297f, 
    0.00538987f, 0.14501372f, 0.00005115f, 0.22134085f, -0.03814606f, 0.06885917f, 0.04038888f, 0.13498226f, 
    -0.02985178f, 0.24033940f, -0.03277040f, -0.27942589f, 0.01429615f, -0.12590413f, 0.01215354f, 0.24472067f, 
    0.07363455f, -0.12692989f, 0.04191897f, 0.13272822f, 0.06086436f, 0.05674153f, 0.10884355f, 0.07971480f, 
    0.00841854f, 0.09675973f, 0.05806823f, 0.33231792f, 0.13766924f, -0.22085641f, 0.15225197f, -0.12144785f, 
    -0.14487448f, 0.00895044f, -0.21546866f, -0.20673968f, -0.04566426f, 0.07103402f, -0.04660894f, -0.03988286f, 
    -0.17438845f, 0.00054094f, -0.06115083f, 0.21187285f, 0.00571431f, 0.29888675f, -0.14232503f, 0.08356825f, 
    -0.10039907f, -0.01758890f, -0.14688113f, -0.04839063f, 0.05510112f, 0.16155528f, -0.13891943f, 0.03157468f, 
    0.01925552f, 0.02134170f, -0.06263789f, 0.02931073f, -0.24533281f, -0.16307680f, -0.15359323f, -0.23883599f, 
    -0.10728744f, -0.28970000f, 0.02551080f, 0.09296343f, 0.09163207f, -0.11462986f, -0.13410194f, -0.11871986f, 
    0.42507756f, 0.22509179f, 0.20105101f, 0.37904975f, -0.48271763f, -0.43583786f, 0.18478511f, -0.18315858f, 
    -0.12502569f, 0.20015009f, -0.07127774f, -0.19383828f, 0.00034544f, 0.02326048f, -0.07889464f, 0.03716361f, 
    0.24246171f, 0.25370046f, 0.05264938f, -0.12758686f, -0.03741538f, 0.12525611f, -0.02669259f, -0.08364417f, 
    -0.00459634f, 0.05107597f, 0.02224534f, 0.07683393f, 0.09015740f, -0.06706885f, -0.06332482f, 0.05907327f, 
    -0.01702242f, 0.02293538f, -0.13634504f, -0.27961221f, 0.06770079f, 0.06233900f, 0.00702267f, 0.19511324f, 
    0.27191010f, -0.44634646f, -0.07127343f, -0.02061892f, 0.09310423f, -0.02344959f, -0.26599932f, -0.07609446f, 
    -0.00653449f, 0.03575607f, -0.04908061f, -0.23408145f, 0.11278392f, 0.20119785f, -0.03543404f, -0.02609112f, 
    0.07743044f, -0.10637528f, 0.01921796f, 0.11805877f, 0.08672287f, 0.04187097f, 0.09519394f, 0.13648386f, 
    0.22751923f, 0.12857884f, -0.00919889f, 0.06638699f, 0.06064144f, -0.01451699f, 0.17174275f, 0.24551134f, 
    0.22822465f, 0.14245047f, 0.15899906f, -0.04515793f, 0.24184653f, -0.04086215f, 0.16725476f, 0.08164173f, 
    -0.11167324f, 0.07124352f, 0.00445325f, -0.15960123f, -0.00841884f, -0.09209993f, 0.11156707f, -0.01481315f, 
    0.10700303f, -0.08566248f, 0.27415735f, 0.09670566f, 0.07439708f, -0.02810825f, 0.10190539f, 0.02887627f, 
    0.31678039f, 0.01800756f, 0.00315346f, 0.06289633f, 0.19289720f, -0.02944312f, -0.07196182f, 0.00051457f, 
    0.04268152f, -0.02166995f, 0.02572517f, -0.07214850f, 0.07633112f, 0.01870766f, 0.14426090f, 0.27471033f, 
    0.01070648f, -0.09522181f, 0.29064900f, 0.20306540f, 0.04256702f, 0.10852199f, -0.00085853f, -0.03982960f, 
    0.10082504f, 0.16401178f, 0.17730023f, -0.02034883f, -0.27069175f, -0.27977693f, -0.05126984f, 0.07192795f, 
    -0.04656461f, 0.05744762f, -0.04298040f, 0.03208645f, -0.03857110f, 0.03253067f, 0.00912765f, 0.09014198f, 
    0.19681276f, -0.14783491f, 0.03594241f, 0.27316669f, 0.06785341f, 0.12041602f, -0.14908919f, 0.03943441f, 
    0.17180866f, -0.00802452f, 0.06031638f, 0.18650483f, 0.07669669f, 0.01979422f, -0.07230426f, 0.08770103f, 
    -0.03560593f, 0.13004030f, 0.05915813f, 0.17890263f, 0.10008423f, 0.05758166f, 0.13566186f, 0.06207897f, 
    -0.11707890f, 0.29387709f, -0.27288333f, -0.09978213f, 0.00281138f, -0.05230752f, 0.06081476f, 0.00400150f, 
    -0.03794420f, -0.08793589f, -0.03303388f, -0.02960911f, 0.08405186f, -0.36982960f, 0.36371472f, -0.05125898f, 
    0.11377401f, 0.02433883f, -0.19123501f, -0.04408350f, -0.06153689f, -0.30899858f, -0.21110889f, -0.42108664f, 
    0.04715599f, 0.28336713f, -0.05703648f, 0.10869817f, 0.00850268f, -0.02142785f, 0.13100307f, -0.00603627f, 
    0.04776536f, 0.18774298f, 0.02356770f, -0.03388183f, -0.25644249f, 0.31998572f, 0.28343365f, 0.25564769f, 
    0.10995342f, -0.11418771f, -0.05478645f, -0.01566747f, 0.00745883f, -0.22580467f, -0.12078086f, -0.35033056f, 
    0.13321479f, 0.05331672f, 0.03246652f, 0.10003629f, -0.03935539f, -0.05943874f, -0.06495743f, 0.16197173f, 
    0.01023880f, 0.01895290f, -0.00255741f, 0.08714225f, 0.04723555f, -0.04532494f, 0.16444325f, -0.01940917f, 
    0.26052752f, -0.08521669f, 0.05050054f, 0.07013705f, -0.16199586f, 0.03800539f, -0.27836427f, -0.27008414f, 
    0.14617011f, 0.01877479f, -0.17365155f, 0.09796864f, -0.00000715f, 0.03103575f, 0.17630684f, 0.16606981f, 
    0.03120549f, 0.08077588f, -0.01772863f, 0.20095757f, -0.04787771f, -0.19997634f, 0.15899949f, 0.01564083f, 
    -0.01650791f, 0.03355908f, -0.08159432f, -0.26336768f, -0.04792814f, 0.03157693f, -0.01818359f, 0.00409072f, 
    0.10669584f, -0.18660717f, 0.09899893f, 0.10237731f, 0.05564820f, 0.05929894f, -0.10024029f, -0.00103386f, 
    -0.18783759f, -0.07856800f, -0.15347660f, -0.12819844f, 0.34066716f, -0.03781737f, -0.11127769f, 0.08813134f, 
    0.05709778f, 0.06250045f, -0.04137231f, 0.17419258f, 0.17675836f, -0.03835886f, -0.12886976f, 0.05315986f, 
    0.00252612f, -0.06098700f, -0.04485218f, 0.06752709f, 0.11695426f, -0.12295987f, -0.00577082f, -0.12409224f, 
    -0.07278921f, -0.10007063f, -0.04427946f, -0.22964339f, 0.04093745f, 0.01424717f, 0.06976931f, 0.19534294f, 
    0.05988808f, 0.04402591f, 0.09302103f, -0.21470606f, -0.18847309f, -0.26474196f, -0.14343676f, -0.03271205f, 
    -0.08688099f, -0.12955663f, -0.24879119f, 0.08210382f, -0.10060688f, 0.02881145f, 0.07871880f, 0.00352197f, 
    -0.14863671f, -0.07552841f, 0.06634928f, -0.01325610f, 0.07821362f, 0.17221646f, -0.16484365f, -0.38865152f, 
    -0.01684740f, -0.04714238f, 0.06579150f, 0.04158354f, -0.16299273f, -0.04003723f, -0.04057613f, -0.05173644f, 
    0.44422454f, -0.05308367f, -0.05210954f, -0.00931965f, 0.14768478f, 0.09015169f, -0.03277250f, 0.03760305f, 
    -0.16039285f, -0.02267593f, -0.10704479f, -0.00903771f, -0.19655618f, 0.20424193f, -0.07306677f, 0.19022165f, 
    -0.01840628f, 0.08535782f, 0.12367134f, -0.06942795f, 0.14668840f, -0.06560282f, 0.07248166f, -0.07968094f, 
    0.02519544f, -0.05555554f, -0.05716388f, 0.17624180f, 0.14607491f, 0.07203638f, 0.19833496f, -0.05981756f, 
    -0.15960538f, 0.07523982f, -0.01070412f, 0.06878521f, -0.10010799f, 0.03558759f, -0.12054925f, -0.01018706f, 
    -0.13550140f, 0.00923147f, 0.11808098f, -0.01608311f, 0.06544557f, 0.08316231f, 0.06299862f, 0.14559829f, 
    0.03126854f, 0.22746612f, 0.20896937f, -0.07498308f, -0.00524256f, -0.02289489f, -0.12341776f, -0.01326349f, 
    -0.01287665f, 0.20297080f, -0.12959719f, 0.07609625f, 0.07360872f, 0.02054010f, -0.03244000f, -0.07987136f, 
    -0.14998721f, -0.04025185f, 0.01125218f, 0.00420128f, -0.01702803f, 0.10732123f, 0.06404169f, 0.13352747f, 
    -0.05497524f, -0.01467432f, -0.05379201f, 0.06567235f, -0.01818339f, -0.06496736f, 0.03210356f, -0.07366484f, 
    0.06664096f, -0.04537388f, 0.06608275f, -0.09268256f, -0.00490594f, -0.04241760f, -0.05063976f, -0.18582606f, 
    0.05260942f, 0.02020156f, -0.00954987f, 0.11298972f, 0.04143621f, 0.12365042f, 0.12020556f, 0.08414925f, 
    -0.00959445f, 0.02304834f, -0.05759415f, -0.03160539f, 0.03830170f, -0.00784906f, 0.07465094f, -0.04374059f, 
    -0.02360714f, 0.10078920f, -0.03027673f, 0.04755523f, 0.18056475f, 0.04099615f, -0.01720133f, -0.08060824f, 
    0.01646211f, 0.02287238f, 0.07174850f, -0.02203066f, -0.01723109f, -0.05899809f, -0.04910238f, -0.00251023f, 
    -0.11356378f, -0.12234352f, -0.31528363f, -0.04551584f, -0.06290703f, 0.13613449f, 0.10128668f, 0.02373000f, 
    -0.02788894f, 0.07917347f, 0.02082553f, -0.06104644f, -0.19769202f, -0.10783113f, -0.05604993f, 0.36349761f, 
    0.05517041f, 0.26910174f, -0.00876634f, -0.07160323f, 0.06377189f, 0.12561743f, -0.04821129f, 0.09844019f, 
    0.41595653f, 0.34751725f, -0.28278431f, 0.19147724f, -0.19169289f, -0.15657341f, -0.13991326f, -0.21557859f, 
    0.04684573f, 0.08098587f, 0.08595496f, 0.10654062f, 0.14345250f, -0.26110905f, 0.49561167f, 0.06590939f, 
    -0.03115319f, -0.10248401f, -0.15276907f, 0.03656253f, -0.11136423f, 0.02196220f, 0.19916844f, 0.05456493f, 
    -0.06804740f, 0.20728610f, 0.02113260f, -0.02034919f, -0.01911996f, 0.01582700f, -0.07987419f, -0.12014384f, 
    -0.00565613f, 0.05495343f, 0.06760586f, 0.08831499f, -0.10164170f, -0.22249407f, -0.17489117f, 0.04531722f, 
    -0.05320867f, 0.13541834f, 0.15081225f, 0.05440672f, 0.00933982f, 0.05253923f, 0.13828222f, -0.11462568f, 
    -0.05110752f, 0.24268799f, 0.02754981f, -0.03490075f, 0.02509279f, -0.05406482f, -0.03698144f, 0.07059085f, 
    -0.00643055f, -0.00353457f, 0.02442405f, -0.00396493f, 0.01558330f, -0.28799978f, -0.02895504f, -0.13901214f, 
    0.06703116f, 0.18565123f, 0.09842288f, -0.00528323f, -0.10049791f, 0.00462232f, 0.01691461f, -0.01528314f, 
    -0.05521134f, -0.11045637f, -0.05867212f, 0.09560571f, 0.08374069f, 0.10594782f, 0.25219619f, 0.00935200f, 
    0.18126313f, 0.04486853f, 0.19257195f, 0.15082189f, -0.10449698f, 0.11181255f, 0.12837496f, 0.00439396f, 
    0.02466313f, -0.07921498f, -0.05265862f, -0.00391088f, -0.06587293f, -0.00592948f, 0.09473749f, 0.04796721f, 
    0.13648939f, 0.16777971f, -0.03027426f, 0.27313313f, 0.09361847f, 0.03209771f, 0.02399651f, -0.07637106f, 
    -0.00512170f, 0.03579651f, -0.06803422f, 0.08510887f, 0.45487586f, -0.02823640f, 0.39260602f, 0.01370316f, 
    0.11563895f, -0.20545450f, -0.19446421f, 0.03566288f, -0.10264047f, 0.19287640f, 0.21288279f, -0.01215489f, 
    -0.07387632f, -0.24543028f, -0.13023573f, 0.18124025f, -0.05446824f, 0.11611381f, 0.15878384f, 0.11807778f, 
    0.02549785f, -0.08260342f, -0.01890226f, 0.04337475f, -0.26340747f, -0.04066757f, -0.08775365f, 0.24684097f, 
    0.00966374f, 0.17340618f, 0.03414505f, 0.02361478f, -0.02712077f, -0.02831718f, -0.04129671f, 0.02981943f, 
    0.09613902f, -0.08010749f, 0.06741530f, -0.26650229f, 0.32576019f, 0.15063773f, -0.07148026f, 0.05447964f, 
    0.07496931f, -0.01474327f, 0.15637015f, 0.04998670f, -0.16068995f, -0.08212920f, 0.00644777f, 0.06431307f, 
    0.15505964f, 0.01776646f, -0.04976511f, 0.10131802f, -0.03884427f, -0.06191659f, 0.09448184f, 0.11706131f, 
    0.09646200f, -0.04737926f, -0.07520426f, 0.21231925f, -0.15960494f, 0.05174455f, 0.14799057f, -0.09888989f, 
    0.03748494f, 0.14483434f, -0.04871504f, -0.01247594f, -0.10456342f, -0.30548394f, -0.06392795f, -0.08749422f, 
    0.04628446f, 0.03019912f, -0.06663238f, 0.05710365f, -0.19835840f, 0.05223703f, 0.00223291f, -0.08798996f, 
    -0.24891703f, -0.12295330f, 0.15260859f, 0.05054151f, 0.03553479f, 0.01329227f, -0.16247261f, 0.13699724f, 
    -0.04380788f, 0.06705749f, 0.03103320f, -0.05633851f, 0.00749849f, -0.07984632f, -0.18240912f, 0.08343839f, 
    -0.05623220f, 0.11564040f, 0.08930434f, 0.15614428f, 0.05899033f, -0.11164458f, -0.07650530f, 0.06919546f, 
    -0.23906372f, 0.07160331f, -0.14294101f, 0.18111491f, -0.05096835f, 0.02009765f, 0.05862552f, 0.14397517f, 
    0.11727048f, 0.02418970f, 0.04773565f, -0.01263023f, 0.35044971f, 0.40682858f, 0.19817118f, 0.07015249f, 
    0.01804020f, -0.05222166f, -0.03647653f, -0.02918938f, -0.10012385f, 0.10513675f, 0.00972591f, 0.22706133f, 
    -0.06605135f, -0.08188751f, 0.03243354f, 0.01952786f, 0.10873407f, 0.07812981f, -0.03093301f, 0.00407390f, 
    0.13604823f, 0.09135573f, -0.12500213f, -0.15800568f, 0.41773745f, -0.05502975f, 0.04647950f, 0.02099393f, 
    0.17193288f, 0.08509417f, -0.11267450f, -0.02259729f, -0.04826020f, 0.10357881f, -0.03601536f, 0.06481197f, 
    0.03291247f, 0.06492198f, 0.41177446f, 0.00543977f, 0.10454607f, 0.02992358f, -0.28274798f, -0.09992783f, 
    -0.04448151f, 0.11033209f, 0.07097643f, 0.03488436f, 0.03102613f, 0.11454742f, -0.05375038f, -0.11335534f, 
    -0.11317090f, 0.00759712f, 0.08383665f, 0.03238001f, 0.02415758f, 0.04655064f, 0.12741290f, 0.08634994f, 
    0.02691394f, 0.05837062f, -0.07639697f, -0.15138325f, -0.07528944f, -0.01204919f, -0.01461211f, 0.03839192f, 
    -0.00196279f, -0.17868330f, -0.03237949f, -0.13506271f, -0.25532755f, -0.10553294f, 0.25061011f, 0.20697035f, 
    0.06355158f, -0.01872155f, 0.01560689f, -0.11269642f, -0.08317310f, 0.21066386f, 0.15577148f, 0.05251363f, 
    0.09528110f, 0.51351982f, -0.18260011f, -0.13082774f, 0.09230087f, -0.04648319f, 0.11735691f, 0.02317490f, 
    -0.03225148f, -0.07716365f, -0.05269061f, -0.02492762f, -0.12157946f, -0.29299468f, -0.11253193f, -0.21204191f, 
    0.09849534f, 0.11384005f, -0.01857476f, -0.01701507f, 0.04659709f, 0.04742053f, -0.04032336f, -0.14139403f, 
    0.20049143f, 0.20586045f, 0.03584822f, -0.16254909f, 0.05159269f, -0.09903844f, -0.02026940f, -0.07630738f, 
    0.19373006f, -0.01712448f, 0.04191550f, -0.00561850f, -0.01280706f, 0.07531003f, -0.06985927f, -0.03365887f, 
    -0.00772798f, 0.03407180f, 0.03946671f, -0.02216082f, 0.04678611f, -0.07765083f, 0.01514291f, -0.01713756f, 
    -0.30113927f, -0.21173899f, -0.16566662f, 0.03750485f, 0.20195851f, 0.10934228f, 0.04980591f, 0.01375637f, 
    -0.04911393f, -0.06191778f, 0.04325275f, 0.04071843f, 0.18653598f, -0.22006129f, 0.00863769f, -0.30017513f, 
    0.06006756f, 0.06793319f, 0.02585557f, 0.00901777f, 0.15236782f, 0.08128659f, 0.04277905f, 0.10658963f, 
    0.02423693f, 0.36966449f, -0.09013724f, 0.12295385f, -0.13964559f, -0.07833828f, 0.01690969f, -0.12535155f, 
    -0.02564748f, 0.15899174f, -0.01736987f, -0.05833410f, 0.10744601f, -0.07439980f, -0.15128246f, -0.18314511f, 
    0.20543683f, -0.04826602f, -0.03123578f, 0.04882389f, -0.12770078f, -0.08179119f, -0.04557280f, -0.07741606f, 
    0.03002204f, -0.00833705f, -0.07100104f, -0.23807290f, -0.04279263f, -0.09891398f, 0.00711703f, 0.00904879f, 
    -0.17816757f, -0.20230171f, 0.17883632f, -0.05638794f, -0.22193363f, 0.11552389f, 0.29736367f, 0.17624299f, 
    -0.07733267f, -0.05129472f, -0.10764933f, -0.09540995f, 0.08487473f, -0.03569411f, 0.14084817f, 0.03773338f, 
    0.26221639f, -0.13312794f, 0.04473317f, 0.22583178f, -0.05948253f, 0.03009961f, 0.07419118f, 0.05505674f, 
    -0.18761404f, -0.01047450f, -0.04333830f, -0.05209833f, 0.16014722f, -0.01760155f, 0.12057809f, 0.09379361f, 
    0.03306600f, 0.05737055f, 0.00532426f, 0.01970217f, -0.13270299f, 0.05468896f, 0.06614311f, -0.10899355f, 
    -0.17459400f, 0.48433602f, -0.15848120f, 0.01306152f, 0.01623723f, 0.05371093f, 0.21803246f, 0.08619115f, 
    0.06751687f, -0.12228858f, 0.04094444f, -0.07939825f, 0.09989196f, 0.05084454f, 0.08691145f, -0.05982833f, 
    0.09569733f, -0.05963151f, -0.16060008f, -0.12006294f, -0.02052985f, 0.18125163f, 0.03091057f, 0.07125582f, 
    -0.02472631f, -0.02922235f, 0.14290501f, 0.03584962f, 0.05492092f, 0.03876802f, -0.01375222f, 0.13886026f, 
    -0.08211351f, -0.11883648f, 0.01920170f, 0.18375602f, -0.12314284f, -0.16830096f, 0.36912891f, 0.16951326f, 
    -0.10194480f, 0.02215759f, -0.33864373f, -0.14677234f, -0.05425618f, 0.11631840f, 0.00792305f, 0.18096280f, 
    0.11888580f, -0.14065786f, -0.07540826f, 0.01069706f, 0.09269377f, 0.09732124f, 0.13090120f, -0.01202017f, 
    0.00722312f, 0.07248253f, -0.00074963f, 0.02868460f, 0.04744375f, 0.17634773f, -0.19582516f, 0.41462287f, 
    -0.01290419f, -0.02520318f, 0.12396623f, -0.12785140f, -0.00761554f, 0.08914346f, -0.08855599f, 0.03857742f, 
    -0.08584422f, 0.06302289f, -0.03904250f, 0.07328531f, 0.01450379f, -0.01060815f, 0.06358509f, -0.08714569f, 
    0.03576717f, -0.01852481f, -0.11225913f, -0.09747910f, 0.10780062f, 0.32485640f, 0.01575647f, -0.16243772f, 
    -0.05258286f, -0.03502346f, 0.05162629f, 0.05246500f, 0.06034615f, 0.00775067f, 0.10217588f, 0.07194581f, 
    0.40072370f, 0.42820975f, -0.11237393f, -0.28145242f, -0.05980274f, -0.03137678f, 0.00773084f, 0.03652268f, 
    0.11400612f, 0.15054457f, -0.01458171f, -0.03952439f, -0.11591712f, -0.19036442f, -0.15930419f, -0.03750004f, 
    0.04005857f, 0.04993029f, 0.17767006f, -0.00011070f, 0.04982006f, 0.25563100f, -0.02036056f, 0.10762965f, 
    -0.06244222f, 0.06620440f, -0.01733823f, -0.09716976f, -0.07975023f, 0.03455311f, -0.04217416f, 0.00539859f, 
    -0.04911511f, 0.15162541f, 0.04497720f, 0.22709449f, -0.07072119f, -0.17759165f, 0.05080120f, 0.09185446f, 
    0.05995519f, 0.16658495f, -0.07082383f, 0.04180093f, 0.00452951f, 0.09746227f, 0.17205657f, 0.12725773f, 
    0.01354053f, 0.01155268f, 0.02465751f, -0.02720954f, -0.03331991f, -0.00022221f, -0.03351701f, 0.02624359f, 
    -0.03468493f, 0.01935883f, -0.01153897f, -0.03799874f, -0.00009625f, 0.00568714f, 0.01251137f, -0.02386562f, 
    0.01891447f, 0.02172863f, -0.03478164f, -0.00145039f, 0.00675692f, -0.02251630f, -0.01395590f, -0.04136628f, 
    -0.01354910f, -0.04220000f, 0.00457718f, 0.00352078f, -0.02391539f, -0.02773603f, 0.02827427f, -0.00318685f, 
    -0.00857296f, -0.02297558f, 0.01864170f, -0.03386253f, 0.00393237f, -0.02409315f, -0.03875492f, 0.01527176f, 
    0.00608189f, -0.03385606f, 0.02214293f, 0.00617780f, -0.02637742f, -0.02681582f, 0.02145413f, -0.02261251f, 
    -0.01478932f, -0.04066051f, -0.03213415f, -0.01381999f, -0.02378111f, -0.00958002f, -0.00667815f, -0.03506048f, 
    0.01567147f, 0.00064140f, -0.03177743f, -0.04179394f, -0.01371439f, -0.03016429f, -0.02224661f, -0.02802948f, 
    -0.04001299f, -0.01564237f, 0.01046797f, 0.01061813f, -0.00596468f, -0.03316373f, -0.01959665f, 0.02244162f, 
    -0.02089184f, -0.03820353f, 0.02885433f, 0.02364897f, -0.04191662f, -0.00791991f, -0.01302895f, -0.01186487f, 
    0.00207857f, 0.01912054f, -0.01801468f, 0.02618895f, -0.02193800f, 0.01491191f, -0.02459687f, -0.02543356f, 
    -0.01694583f, 0.01532886f, -0.04212122f, -0.02206867f, -0.00285020f, -0.01123096f, -0.00173978f, 0.00712749f, 
    -0.03081157f, 0.02939085f, -0.00588766f, -0.00253923f, -0.01728017f, -0.01613037f, 0.02103857f, -0.01417838f, 
    -0.02643040f, -0.03855103f, 0.00299192f, 0.02875927f, 0.01882885f, -0.02689472f, 0.00134925f, 0.00127077f, 
    -0.02249894f, -0.01282340f, 0.00884789f, 0.01441253f, 0.02448360f, -0.00223971f, -0.01416132f, -0.02031051f, 
    -0.00813802f, -0.01440881f, -0.00467785f, -0.00346668f, -0.02734743f, 0.01314470f, -0.04135229f, 0.00176188f, 
    -0.02764150f, -0.02569679f, 0.02799839f, -0.00637814f, -0.02844390f, 0.00375042f, 0.00965121f, 0.00266456f, 
    0.02841754f, -0.00309818f, 0.02521345f, -0.01885626f, -0.03248028f, 0.02463757f, -0.01992454f, 0.00020233f, 
    0.00748251f, 0.02056959f, -0.03063573f, 0.01203553f, 0.00295960f, -0.02218629f, 0.01451454f, -0.03002324f, 
    -0.01525093f, -0.03563812f, -0.02437266f, -0.01153330f, -0.02646478f, -0.04150771f, -0.00827813f, 0.02397980f, 
    0.02749982f, 0.00930959f, -0.00987187f, -0.00578416f, -0.03874224f, -0.01352814f, -0.03862317f, 0.02532258f, 
    -0.02103049f, 0.02736259f, 0.02709355f, 0.00224044f, -0.03150621f, -0.01579623f, -0.03842693f, -0.03820383f, 
    0.02196458f, 0.02031747f, -0.03984340f, 0.02031287f, -0.02864375f, 0.00499982f, -0.03107329f, -0.00482474f, 
    0.01099487f, -0.01411800f, -0.03078023f, 0.00710540f, 0.00653747f, 0.01096143f, 0.00162239f, -0.03483573f, 
    -0.01932792f, -0.03939310f, 0.00848569f, -0.02336989f, -0.01538957f, -0.03273826f, -0.03826348f, 0.02724380f, 
    0.00626969f, -0.03961900f, 0.01962182f, -0.00909432f, 0.02238924f, -0.04056492f, -0.02830388f, 0.01675803f, 
    0.02596825f, 0.01975743f, -0.01343816f, -0.02166338f, 0.00214815f, 0.00340016f, 0.02015306f, 0.01485478f, 
    0.02533695f, -0.04074359f, -0.03962399f, -0.03089732f, -0.03531701f, -0.00132750f, -0.02545636f, -0.04028010f, 
    0.02809476f, 0.01114397f, 0.01856578f, 0.01956321f, -0.00698937f, -0.03001489f, 0.02843435f, -0.03901456f, 
    -0.03796694f, -0.02548245f, -0.02612612f, -0.00524028f, -0.02160833f, -0.04238622f, 0.01872769f, -0.00735667f, 
    -0.01067639f, -0.03250229f, 0.00984459f, -0.00403744f, 0.00693372f, 0.00199287f, -0.01528557f, -0.02270711f, 
    0.00388727f, -0.02294333f, -0.00596660f, -0.01698425f, 0.01792764f, -0.02648379f, 0.00758951f, 0.02016129f, 
    0.02089798f, 0.01497301f, -0.00162766f, 0.00668191f, -0.01073429f, -0.03903355f, 0.02566040f, 0.01804913f, 
    0.02089233f, -0.03563811f, -0.02776054f, 0.02002086f, -0.00917837f, -0.03409415f, -0.00029429f, 0.02592797f, 
    -0.00483236f, -0.00677002f, -0.03977893f, 0.02957478f, -0.04086324f, -0.01241673f, -0.01242959f, -0.04169175f, 
    0.00670957f, -0.03169944f, -0.03417216f, 0.01740246f, 0.01898410f, 0.02804056f, -0.00009640f, -0.00301445f, 
    0.01013843f, 0.00099759f, -0.00559454f, 0.02087469f, -0.02451885f, -0.02485531f, -0.02859411f, 0.01764011f, 
    -0.03558986f, 0.01840703f, 0.02033494f, -0.00393617f, -0.01497358f, 0.00933961f, -0.01412162f, 0.01544979f, 
    0.02634818f, -0.02098578f, -0.03179204f, 0.02755585f, 0.00675157f, -0.00588147f, -0.02241863f, 0.02194371f, 
    0.01756271f, 0.01336432f, -0.00464754f, -0.01168401f, 0.01571308f, 0.02284898f, 0.00654943f, 0.01533157f, 
    0.00894311f, 0.00921417f, -0.04011917f, -0.00668919f, -0.02793717f, -0.04101026f, -0.03797137f, 0.00787752f, 
    -0.00829462f, -0.02277918f, 0.02056860f, -0.01040857f, 0.02719861f, 0.00366205f, 0.01713818f, -0.01945984f, 
    -0.02094298f, -0.02323614f, -0.03735418f, 0.01836242f, -0.01443674f, -0.00227861f, -0.01871671f, 0.02677303f, 
    0.01598917f, 0.00008139f, -0.01950256f, 0.02140585f, -0.00889440f, -0.03887536f, -0.01094469f, -0.02704364f, 
    -0.03331165f, -0.04019107f, -0.01417302f, 0.00398465f, 0.00127606f, -0.00377244f, 0.00336043f, -0.02156329f, 
    -0.02658249f, -0.01184607f, -0.00683051f, -0.01950957f, -0.02222535f, 0.01632215f, -0.03035723f, 0.01548621f, 
    -0.02098942f, -0.00167058f, 0.02474575f, 0.01676105f, -0.00458368f, -0.01551032f, -0.02137909f, 0.00014850f, 
    -0.04162561f, 0.00478818f, 0.00846764f, 0.02227077f, -0.01490613f, 0.00801579f, -0.03984486f, -0.03711905f, 
    -0.00497704f, 0.02478824f, 0.01274422f, -0.01353858f, 0.02475279f, 0.02561304f, -0.02484314f, -0.01125174f, 
    0.00254510f, 0.00935336f, -0.02557643f, -0.00798792f, 0.00006982f, 0.01870689f, -0.02171117f, -0.02129394f, 
    0.02858146f, -0.03564603f, -0.03046308f, -0.00963106f, 0.02187049f, -0.02284632f, -0.02151282f, -0.00568019f, 
    0.01815762f, 0.01185115f, 0.01439872f, 0.02668106f, -0.03212929f, 0.01955714f, -0.02907301f, 0.00288497f, 
    -0.02654622f, -0.04138575f, -0.00943823f, 0.01799013f, 0.02713300f, -0.03711191f, 0.01992722f, -0.01268376f, 
    0.02548470f, -0.02752351f, 0.00814697f, -0.01626009f, 0.02069272f, -0.02273120f, -0.03364834f, -0.01578970f, 
    -0.03785068f, -0.03862920f, -0.03645530f, -0.01770443f, -0.02475755f, -0.04028090f, -0.03875068f, -0.03643821f, 
    -0.03183134f, -0.02634600f, -0.03029167f, -0.01727118f, -0.03650370f, -0.03385817f, 0.00088267f, -0.04165205f, 
    0.02249006f, -0.02177340f, 0.01422970f, -0.02111295f, -0.03118893f, -0.02119190f, 0.02795627f, 0.02949527f, 
    -0.03062201f, -0.03972282f, 0.01009333f, 0.00081338f, -0.02403723f, -0.01259590f, -0.02546946f, 0.00704489f, 
    0.01585739f, 0.02229731f, -0.02121262f, 0.00416910f, 0.00378284f, 0.01817071f, -0.02882133f, -0.01252101f, 
    -0.03780998f, 0.00265842f, -0.01387350f, 0.00600998f, -0.02513230f, -0.03147002f, -0.03764408f, -0.00525373f, 
    0.00151150f, -0.01502758f, -0.02883078f, 0.02949312f, 0.01896253f, -0.00494098f, -0.03524122f, 0.00852941f, 
    -0.03199932f, 0.00536346f, -0.01960055f, -0.02659069f, 0.02169563f, -0.00717415f, -0.00241923f, 0.01811675f, 
    0.00397349f, -0.00118869f, 0.00570218f, -0.04003174f, -0.02126467f, 0.02051691f, 0.00652637f, -0.01512178f, 
    0.01246882f, 0.00217600f, -0.00723296f, 0.01301774f, 0.02015601f, -0.03638302f, 0.02528973f, 0.01111481f, 
    0.00482200f, -0.03395052f, -0.01881893f, -0.04127130f, 0.02317870f, 0.00735234f, -0.00972320f, 0.00152187f, 
    0.00966038f, -0.03894795f, -0.01196050f, -0.00095287f, -0.02865652f, -0.00978457f, -0.01597049f, 0.01623910f, 
    -0.00737881f, 0.02170436f, -0.00502758f, -0.01520367f, -0.01466279f, 0.00312322f, -0.02251566f, -0.01921304f, 
    0.01962871f, 0.01383322f, -0.00118481f, -0.01579939f, 0.00984792f, -0.03761437f, 0.01098349f, -0.03810352f, 
    -0.04057714f, -0.02993537f, 0.00569037f, 0.02463734f, -0.02817499f, 0.02910257f, -0.01013207f, 0.01560395f, 
    -0.01420032f, -0.03104571f, 0.02551830f, -0.01767551f, -0.03772551f, -0.01581225f, 0.01752105f, 0.02927269f, 
    -0.03422338f, 0.00466921f, 0.01536724f, 0.00815665f, -0.00831789f, -0.03233083f, -0.01072712f, 0.01671038f, 
    0.01286869f, -0.01768477f, 0.01085884f, -0.03052358f, -0.03021494f, -0.00275694f, 0.02870470f, 0.01798393f, 
    -0.02044032f, 0.00369819f, 0.02749349f, -0.00249658f, -0.02808949f, -0.03627275f, 0.00075080f, 0.01048276f, 
    0.01405568f, -0.00808339f, -0.00737491f, 0.01973679f, -0.02772033f, -0.02566427f, 0.00639050f, -0.02973082f, 
    -0.02918992f, -0.00538595f, 0.01976292f, 0.00694500f, 0.01355193f, -0.03289164f, 0.01624455f, -0.02330714f, 
    0.02179607f, 0.01489020f, 0.00957063f, -0.01687544f, 0.01393129f, -0.02976259f, -0.00048269f, 0.00597202f, 
    -0.03579451f, -0.00482121f, 0.01535941f, 0.00098546f, -0.03587996f, 0.00986284f, 0.02952858f, 0.02742027f, 
    0.00181651f, -0.03644357f, -0.02016048f, -0.03461954f, -0.03528881f, -0.00994364f, 0.00761767f, 0.00152231f, 
    0.01931336f, -0.01864194f, -0.02456260f, -0.00098472f, -0.00405161f, 0.00801385f, -0.01077160f, 0.00728336f, 
    -0.00622409f, -0.00015571f, -0.01512576f, -0.01963615f, -0.00172571f, -0.00174467f, -0.04160824f, 0.00752194f, 
    -0.02391603f, -0.01297345f, -0.03782773f, -0.00626055f, -0.02321843f, -0.00363005f, -0.03946662f, 0.01284490f, 
    0.00521407f, 0.01030042f, -0.02449253f, -0.02688490f, -0.02498372f, 0.01425672f, -0.00885764f, -0.03120553f, 
    -0.04149200f, -0.02873077f, 0.02308735f, 0.01110374f, 0.00266019f, 0.00061831f, 0.02193226f, -0.00743399f, 
    0.02844378f, -0.02880943f, -0.03643280f, -0.00926300f, 0.01294425f, 0.01791241f, -0.00458848f, -0.03801383f, 
    -0.00293367f, -0.02376028f, -0.01302725f, -0.00261697f, 0.02249987f, -0.01227358f, -0.03534070f, -0.03781401f, 
    -0.03615384f, -0.00569664f, 0.00965495f, 0.00307444f, -0.02229597f, -0.03728982f, -0.01858756f, -0.01272397f, 
    -0.01804259f, 0.00043305f, -0.01963195f, -0.03402956f, -0.02681310f, 0.00067225f, 0.00867926f, -0.01879186f, 
    -0.02468424f, -0.03583409f, 0.02679978f, -0.01304393f, 0.02127765f, 0.01185574f, -0.00592542f, 0.00616670f, 
    0.00240645f, -0.03532371f, 0.01449887f, 0.02210576f, -0.00728304f, 0.00414255f, -0.02233793f, -0.00121931f, 
    -0.02497629f, 0.00299626f, 0.02950119f, -0.02063215f, -0.00273921f, -0.00400198f, -0.00564641f, 0.02248928f, 
    -0.02709528f, 0.02721691f, -0.02217693f, 0.00628226f, 0.00606790f, -0.00849688f, -0.02117521f, -0.02380525f, 
    -0.02659086f, -0.01226579f, 0.01779968f, -0.01468704f, -0.01367371f, 0.01037421f, -0.02595788f, 0.02794319f, 
    0.02408895f, -0.03013004f, 0.02544090f, 0.01603086f, -0.03659581f, -0.02480146f, 0.01271510f, 0.01107307f, 
    -0.01696986f, -0.03298487f, -0.00010878f, -0.03487145f, 0.00655228f, 0.01353183f, -0.01753481f, 0.00399863f, 
    -0.04056781f, -0.01621974f, -0.02120486f, -0.01602672f, 0.00028541f, -0.01844552f, -0.03254290f, 0.02365164f, 
    0.00901835f, -0.02180975f, -0.02458862f, 0.01050072f, 0.01681220f, 0.01033405f, 0.01417410f, 0.02888294f, 
    -0.03848228f, 0.01336471f, 0.00767799f, -0.00690128f, 0.01009890f, 0.02954556f, 0.03004726f, 0.02296081f, 
    -0.03369482f, 0.03065620f, 0.02045979f, 0.00564080f, -0.02835665f, -0.03229027f, 0.02020868f, 0.02976301f, 
    -0.01813916f, 0.02048250f, -0.02236858f, -0.01211879f, 0.01810086f, -0.02634376f, -0.03766560f, -0.00532481f, 
    -0.02017569f, -0.03162007f, -0.00110026f, -0.02136833f, 0.00675659f, 0.00811234f, 0.01314475f, -0.02619853f, 
    -0.01287671f, -0.01325798f, 0.01549235f, -0.00658049f, -0.00895366f, -0.02332981f, -0.03492538f, -0.03762680f, 
    -0.02656104f, 0.00171364f, 0.00126057f, -0.00449770f, 0.02031847f, 0.02293478f, -0.00505645f, -0.00122044f, 
    -0.01488272f, -0.01121370f, 0.01774194f, -0.02360165f, 0.01506818f, 0.00969835f, 0.02791558f, -0.04053639f, 
    -0.01795454f, -0.01433471f, 0.02651465f, -0.00095686f, -0.03406425f, -0.03827175f, -0.02077822f, -0.02536227f, 
    -0.00149883f, -0.01678736f, -0.02234929f, -0.02899858f, 0.02510402f, -0.03236251f, 0.00162632f, -0.01536705f, 
    0.01871501f, -0.02242167f, -0.03421533f, -0.02784778f, 0.01004882f, 0.01901154f, 0.01399089f, -0.02508281f, 
    -0.00547157f, -0.02102043f, 0.02486734f, -0.00313199f, -0.00668377f, 0.02716183f, 0.02632305f, -0.02761906f, 
    -0.00515349f, -0.03925718f, -0.03326504f, 0.02204273f, 0.00094645f, -0.01068094f, -0.00944814f, -0.02222932f, 
    -0.01599311f, 0.03059812f, 0.02997601f, -0.03880495f, -0.03388037f, 0.00883159f, -0.01453748f, -0.01801040f, 
    0.00200677f, -0.01036271f, -0.02456086f, 0.01107534f, -0.00810219f, 0.02609813f, -0.01300466f, -0.01166398f, 
    0.00908199f, 0.01266364f, 0.03188534f, -0.01229412f, 0.00613750f, -0.00882758f, -0.03234395f, 0.00309118f, 
    -0.02508805f, 0.01978159f, 0.02849384f, -0.03413141f, 0.01691563f, 0.01211333f, 0.02272057f, 0.02209206f, 
    -0.01213136f, 0.02952558f, -0.01189193f, 0.02736829f, -0.00335521f, -0.01986416f, -0.01059929f, 0.00035921f, 
    -0.01279769f, 0.01812428f, 0.03013062f, 0.00079528f, 0.02005786f, -0.01910156f, -0.00887757f, -0.03047549f, 
    -0.00781841f, 0.01139439f, 0.00971992f, -0.01714482f, 0.01224112f, -0.02633292f, -0.00905763f, 0.02369997f, 
    0.02036807f, 0.03239089f, -0.01814246f, 0.00741677f, -0.04026895f, 0.00231679f, 0.01388744f, 0.01380052f, 
    0.01860680f, -0.03691629f, 0.00281744f, -0.01429291f, -0.01239753f, -0.00619751f, -0.02977649f, -0.04080399f, 
    0.00474992f, -0.00630332f, 0.01176667f, 0.00065432f, -0.02939710f, 0.01994098f, 0.00695494f, 0.00041438f, 
    0.00946856f, -0.01501579f, -0.02932684f, -0.03038993f, -0.01271991f, -0.04801632f, 0.02479851f, -0.02233221f, 
    0.01823162f, -0.03277124f, 0.00262723f, -0.00411450f, -0.00074792f, -0.03183116f, -0.01811820f, -0.03119253f, 
    0.02474308f, 0.00396434f, 0.02076075f, -0.01239051f, -0.02643463f, -0.04122452f, 0.00630171f, -0.02528798f, 
    -0.00863675f, -0.01382834f, -0.00090440f, 0.00542983f, -0.01430598f, -0.01388178f, -0.03017453f, 0.00136539f, 
    0.00762497f, -0.03221864f, -0.02007379f, -0.00741992f, -0.02346672f, -0.03427439f, -0.04108300f, 0.00943857f, 
    -0.00476782f, -0.03398454f, 0.02867153f, -0.03017410f, -0.03351696f, 0.02612617f, -0.00983373f, -0.01624877f, 
    0.00828409f, -0.03597469f, -0.02169845f, -0.00124430f, 0.00737738f, 0.00474924f, 0.00989841f, -0.00350522f, 
    -0.01608202f, 0.02690250f, -0.01963669f, -0.04376198f, 0.00232846f, -0.01607233f, 0.02948444f, 0.01262553f, 
    0.01245002f, -0.01585869f, -0.01523763f, -0.00066647f, -0.01633549f, 0.00861453f, 0.00978931f, 0.01861829f, 
    0.00317930f, -0.02479329f, -0.02289128f, 0.03249209f, -0.03658936f, -0.01240237f, -0.02455957f, -0.04278764f, 
    0.01588804f, 0.00976625f, -0.02197250f, -0.01122750f, 0.00561004f, 0.01066087f, -0.01574940f, -0.01600586f, 
    -0.01803212f, -0.00912273f, -0.02036353f, -0.00728171f, -0.03008230f, -0.01035661f, 0.00939446f, 0.00821650f, 
    0.00636416f, -0.02389634f, 0.02309299f, -0.01003635f, -0.03863800f, -0.03663357f, -0.01508060f, -0.01152911f, 
    -0.01610553f, 0.01735010f, 0.02519863f, -0.03377842f, -0.02822399f, -0.03992341f, -0.02796992f, 0.01600716f, 
    0.00627748f, -0.00249681f, -0.03106553f, -0.03895843f, -0.03575040f, 0.02167090f, -0.02154325f, 0.00933845f, 
    -0.03199052f, 0.02607903f, -0.03575454f, 0.02204910f, 0.00189018f, 0.02584739f, -0.03387250f, -0.03354541f, 
    -0.02843224f, -0.00758618f, -0.03216622f, 0.01221927f, 0.02581958f, 0.00893416f, 0.01358843f, -0.00165596f, 
    0.02171206f, -0.01182874f, 0.00126627f, 0.03426860f, -0.00553147f, 0.00858050f, -0.02513082f, -0.01413080f, 
    -0.01147713f, -0.01926378f, 0.02446426f, -0.03246820f, 0.02758256f, 0.02744639f, -0.02062832f, 0.00149981f, 
    -0.02672393f, -0.03572913f, 0.03098922f, 0.02437247f, -0.01656920f, -0.03190053f, -0.00433866f, -0.02858689f, 
    0.02137027f, -0.02105092f, -0.00226701f, -0.03685030f, -0.02896161f, 0.01121296f, 0.01879184f, -0.03889668f, 
    -0.03343775f, 0.01562842f, 0.01884911f, -0.00186274f, 0.02910413f, 0.02223924f, 0.00303540f, -0.00567198f, 
    -0.00443278f, 0.02794044f, -0.02918352f, 0.00089752f, 0.00491508f, -0.01413631f, 0.02381969f, -0.03279191f, 
    0.00005671f, -0.01985268f, 0.02412695f, 0.02972142f, -0.01589068f, 0.02982927f, -0.00623680f, -0.02867134f, 
    0.00366093f, -0.00231635f, -0.01649400f, 0.02927030f, -0.00406080f, -0.00253545f, -0.01317926f, -0.00391746f, 
    -0.03206424f, 0.02725074f, 0.00740382f, 0.02337186f, -0.04062705f, -0.00753081f, -0.03458275f, 0.02073864f, 
    0.01458931f, -0.01288885f, -0.04081449f, 0.00772343f, -0.03638308f, 0.00242820f, 0.02010035f, 0.02938903f, 
    0.00842854f, 0.00471833f, -0.03024092f, -0.02091468f, 0.00484893f, -0.02169885f, -0.04374504f, -0.00365660f, 
    -0.02896442f, 0.02707526f, 0.01927538f, -0.03020411f, -0.02514318f, -0.02811757f, 0.02998709f, -0.00320555f, 
    -0.00691416f, -0.01957016f, 0.02358958f, 0.02673127f, 0.01448200f, 0.01007083f, 0.01519927f, -0.02902199f, 
    -0.03361525f, 0.02371517f, 0.02003536f, 0.00089983f, 0.00929649f, -0.03747040f, -0.02653261f, 0.00327364f, 
    -0.02135100f, -0.02637067f, 0.01636972f, -0.00792872f, 0.00503169f, -0.04091534f, -0.00076650f, -0.03761361f, 
    -0.02214099f, 0.00727439f, 0.00757688f, 0.01395475f, 0.01880052f, -0.00030726f, -0.02454564f, -0.01669627f, 
    0.03016300f, -0.00230956f, -0.00987189f, -0.00912897f, -0.02980468f, 0.02008122f, 0.00012799f, 0.00558840f, 
    -0.02129900f, 0.02815605f, -0.01013359f, -0.02179679f, 0.00632048f, -0.01073564f, 0.01588556f, 0.01901591f, 
    -0.00638853f, -0.01205631f, -0.02904193f, 0.03541915f, -0.00942190f, 0.01592351f, 0.02466797f, -0.00877051f, 
    0.01577564f, -0.03928570f, -0.00393667f, 0.03138281f, 0.00428130f, -0.00325466f, -0.00486199f, 0.02496404f, 
    -0.03426204f, 0.02536794f, -0.03267419f, -0.02171978f, 0.01700105f, -0.01269108f, -0.00862322f, -0.01731021f, 
    -0.02958239f, -0.02980408f, 0.02669818f, -0.01698754f, 0.00362857f, -0.01449818f, 0.03604408f, 0.00535051f, 
    -0.03580631f, -0.00572039f, 0.02146350f, 0.00774965f, -0.00306129f, -0.02210130f, 0.00639941f, 0.00835796f, 
    0.00359596f, -0.02756429f, -0.03078210f, -0.02801599f, 0.02028908f, 0.02186877f, 0.00002794f, -0.01606092f, 
    -0.00832339f, 0.01073474f, -0.00424154f, -0.01476966f, 0.02919005f, 0.01720847f, -0.03092343f, 0.00740494f, 
    -0.01722986f, -0.03532389f, -0.03251443f, 0.02640912f, 0.00995363f, 0.00850737f, -0.00614561f, -0.03090554f, 
    0.01964798f, 0.00712996f, 0.03628019f, 0.01552279f, 0.01538383f, -0.02766881f, -0.00587072f, -0.03303882f, 
    -0.00234553f, -0.00730492f, 0.01003283f, -0.00042131f, -0.00542236f, -0.00471199f, -0.02445293f, 0.02609429f, 
    0.00591919f, 0.00731972f, 0.01133875f, -0.00494113f, 0.02199872f, -0.02153620f, 0.01583833f, -0.03073041f, 
    -0.02381432f, 0.00996864f, 0.02875381f, -0.00112894f, -0.00363632f, 0.01349387f, -0.01038721f, -0.00623654f, 
    -0.01896140f, -0.01042657f, -0.00696164f, -0.03006218f, 0.01022111f, -0.01167944f, -0.00968187f, 0.02129524f, 
    -0.00341725f, 0.01944363f, 0.01052308f, -0.00162803f, 0.01601659f, -0.03045094f, 0.02689926f, 0.01994668f, 
    -0.00022678f, -0.00882823f, -0.02764932f, -0.01437729f, -0.00941034f, -0.00684163f, 0.02513566f, -0.01523426f, 
    -0.03015563f, -0.03084188f, 0.00301289f, 0.01115434f, -0.00493583f, 0.00852962f, 0.01728142f, -0.02364701f, 
    -0.02684129f, -0.00108936f, -0.02546039f, 0.02159666f, 0.01212862f, 0.00965954f, -0.02578053f, 0.00453619f, 
    0.02655734f, 0.00084195f, -0.01794547f, -0.00399427f, 0.03098447f, 0.01453461f, -0.03132156f, -0.00771921f, 
    0.01940377f, 0.00232075f, -0.03091053f, 0.02571473f, 0.00018624f, 0.03689598f, 0.00870219f, -0.03420995f, 
    0.02973918f, 0.02129012f, 0.02451470f, -0.02552514f, 0.00757833f, 0.01363690f, -0.03768194f, -0.01479664f, 
    -0.01105278f, -0.01105820f, -0.02027784f, -0.01476600f, -0.01960069f, -0.02905425f, -0.00598512f, -0.02926940f, 
    0.00358088f, 0.00584563f, 0.00957277f, 0.02528949f, -0.02249033f, -0.02317288f, 0.01651512f, -0.01308410f, 
    0.01891147f, 0.00518038f, -0.04078038f, -0.00311714f, 0.02921867f, 0.00975642f, -0.02416415f, 0.00457268f, 
    -0.02083129f, -0.01011339f, 0.02127701f, 0.00346793f, -0.00227318f, 0.00581590f, -0.01684718f, -0.01988901f, 
    0.00373366f, -0.01042791f, -0.01552536f, -0.01727217f, -0.00381897f, 0.01892746f, 0.01038533f, -0.02584483f, 
    0.00479947f, -0.00016462f, -0.01492441f, -0.03569237f, -0.02846533f, 0.02948523f, -0.01189528f, -0.01423497f, 
    0.00122966f, -0.02751333f, -0.03665597f, 0.01570306f, -0.02820286f, -0.03477125f, 0.02628052f, 0.01202621f, 
    0.02501072f, -0.02019056f, -0.03153003f, -0.01603102f, 0.00761309f, 0.00242718f, -0.03359453f, 0.01792873f, 
    0.00724986f, -0.03421693f, -0.02387756f, 0.02588583f, -0.00377146f, -0.02835067f, -0.00146895f, 0.02501109f, 
    -0.01552702f, 0.01539655f, 0.00539850f, 0.00926278f, 0.00622356f, -0.00159306f, -0.00707485f, -0.00939800f, 
    -0.00182744f, -0.01148822f, 0.01678004f, -0.00386366f, -0.00494062f, -0.03000371f, 0.00775188f, 0.00424605f, 
    -0.00303941f, -0.02185502f, 0.01465870f, 0.02251883f, -0.03516301f, -0.03254898f, -0.02452215f, -0.03351906f, 
    -0.01630776f, -0.03198917f, 0.01065032f, -0.01056980f, 0.00234515f, -0.04036023f, -0.03768438f, 0.02583738f, 
    0.01068485f, 0.01448226f, -0.02800747f, 0.02591694f, 0.02142672f, 0.02260574f, -0.00417904f, -0.00327513f, 
    -0.00556970f, -0.02340214f, -0.02549905f, 0.02890345f, -0.01614851f, 0.00035580f, -0.00180675f, -0.01448068f, 
    0.03559175f, 0.00075200f, 0.00579266f, -0.01360120f, -0.00193176f, -0.00248016f, 0.01651081f, 0.01149158f, 
    -0.03481002f, -0.02463915f, 0.00676397f, -0.00161446f, 0.02171693f, -0.02267458f, 0.00390823f, -0.01354999f, 
    -0.01561227f, -0.03489337f, -0.03471929f, 0.01419165f, 0.00934544f, 0.01629367f, -0.00489413f, 0.02970074f, 
    0.02916569f, -0.00816410f, 0.01631604f, -0.00381272f, -0.00587141f, -0.00612503f, -0.01904702f, 0.01035133f, 
    0.01962388f, -0.02740353f, 0.01496307f, 0.00015171f, -0.00021445f, 0.00750086f, -0.00001754f, -0.01559779f, 
    -0.01776793f, -0.02795320f, 0.02793873f, -0.00795503f, 0.02767286f, 0.00319062f, 0.03025293f, -0.00409110f, 
    0.00576394f, -0.02172162f, 0.02622248f, 0.02867229f, -0.03407960f, -0.01294016f, 0.02042633f, 0.01448709f, 
    -0.02471136f, -0.00929993f, -0.03763083f, -0.00097909f, -0.03144251f, -0.02630244f, -0.04079494f, 0.00394585f, 
    0.02671187f, 0.00520552f, -0.02985728f, -0.02806859f, -0.01004186f, -0.03892339f, 0.02004116f, -0.00928984f, 
    -0.03671002f, -0.00814701f, 0.00971204f, -0.02699675f, -0.03691727f, 0.01114807f, -0.01727838f, -0.01186640f, 
    -0.01966337f, -0.02827985f, -0.02729608f, -0.03937939f, -0.02847155f, -0.00113678f, -0.02285189f, 0.01791381f, 
    -0.03211007f, 0.00638110f, -0.01646379f, 0.01809509f, -0.02114925f, -0.00247459f, 0.00453807f, -0.00247786f, 
    -0.00304848f, -0.03556284f, -0.01639616f, -0.01833884f, -0.01643999f, -0.03213775f, -0.02451167f, -0.04132321f, 
    0.01825997f, 0.01152042f, 0.00219870f, 0.00156819f, -0.02953118f, -0.04273092f, 0.00114967f, 0.00334276f, 
    0.00868731f, -0.01334221f, -0.03120594f, 0.00369413f, -0.03453058f, 0.01867566f, -0.03304188f, -0.01742489f, 
    -0.02825509f, -0.03255200f, -0.02943792f, 0.02388645f, -0.01016599f, 0.01446155f, 0.01882560f, -0.01009905f, 
    -0.02031275f, -0.03047897f, -0.02203561f, 0.01244236f, 0.03293040f, -0.03404842f, 0.01692538f, 0.01147301f, 
    0.01708495f, 0.03425599f, 0.03008804f, 0.03554023f, -0.01157038f, -0.01153168f, -0.01577392f, 0.02516439f, 
    -0.03192969f, -0.03673960f, -0.00819902f, 0.01538755f, -0.03660912f, -0.02388372f, -0.00635309f, -0.01189417f, 
    0.02727171f, 0.01391193f, 0.01415487f, -0.00248899f, 0.00557155f, -0.02702836f, 0.02304142f, -0.02107120f, 
    -0.02038116f, -0.03521315f, -0.02154164f, -0.01340247f, -0.04221005f, -0.00700282f, -0.02564449f, 0.02051379f, 
    -0.01708464f, 0.01193199f, -0.01921439f, 0.02879951f, -0.00199391f, -0.00721489f, 0.00532358f, 0.01689611f, 
    0.00761471f, 0.02270005f, 0.00760990f, 0.02452529f, -0.02101425f, -0.01451789f, -0.04108956f, 0.01167781f, 
    -0.02423407f, 0.03563009f, -0.01929064f, 0.01505299f, 0.00170861f, -0.00281931f, -0.04000574f, -0.02363262f, 
    -0.03386491f, 0.02920721f, -0.02418643f, 0.00152708f, 0.01967295f, -0.01815035f, 0.02338740f, -0.02070514f, 
    -0.02003618f, 0.00348131f, 0.01915128f, 0.00735839f, -0.00684841f, -0.03104786f, -0.02959633f, -0.02297531f, 
    -0.01052906f, -0.00949190f, -0.00043845f, 0.00863344f, 0.01873667f, -0.02645171f, 0.00523017f, -0.00945122f, 
    0.01879038f, -0.03991849f, 0.02290422f, 0.01989595f, 0.02243216f, 0.02915416f, 0.01473780f, -0.00455924f, 
    -0.03569721f, 0.01216944f, 0.01428656f, -0.00863217f, -0.04216002f, -0.03686534f, -0.03751807f, -0.00820819f, 
    0.01225283f, -0.03709753f, -0.03745803f, 0.00780879f, -0.01190299f, 0.02543074f, 0.01632000f, -0.02250354f, 
    0.02443921f, 0.02243830f, -0.02166027f, -0.01560767f, -0.00799292f, -0.00326554f, 0.00411850f, -0.04063156f, 
    -0.03805170f, 0.00805513f, -0.02523647f, -0.00561783f, 0.00048123f, 0.02035004f, 0.00317124f, -0.01814578f, 
    -0.03132626f, 0.02295080f, 0.00930547f, -0.00617766f, 0.00670527f, 0.01870464f, 0.01485409f, 0.02815380f, 
    0.02858555f, 0.00895331f, -0.03335240f, -0.02817980f, -0.00998278f, 0.02130060f, -0.01830346f, 0.01482854f, 
    0.02232148f, -0.01521623f, -0.04289604f, 0.02747743f, 0.00059955f, -0.03821680f, 0.01389077f, -0.02621556f, 
    -0.01604065f, 0.00891205f, -0.01986375f, 0.02665838f, -0.03739360f, -0.01110122f, -0.02427296f, -0.00211143f, 
    0.02770964f, -0.04161331f, -0.01850712f, -0.01268880f, -0.00035917f, -0.03178469f, -0.02604997f, -0.01188170f, 
    -0.02528224f, -0.02263532f, -0.01006318f, -0.00674092f, -0.01247961f, -0.00726077f, 0.01017948f, 0.00044719f, 
    -0.02667192f, -0.02995630f, 0.01334848f, 0.02348014f, -0.01236225f, -0.04104541f, -0.04000953f, -0.02114419f, 
    0.00760777f, -0.02301271f, -0.01076273f, 0.01135469f, 0.00068558f, -0.02314510f, 0.00381670f, -0.03147847f, 
    -0.02141811f, 0.01679048f, -0.02282199f, 0.00545675f, -0.03046747f, -0.04053602f, 0.00726974f, 0.01141571f, 
    -0.02962416f, -0.00786338f, -0.01148169f, -0.01080762f, 0.01574850f, 0.01679393f, 0.00882722f, 0.01704482f, 
    -0.02379693f, -0.03685976f, 0.00669926f, 0.00914407f, -0.01204297f, 0.01906117f, -0.03889972f, 0.02775530f, 
    -0.01438586f, 0.01007314f, -0.01197226f, -0.01303935f, -0.02649857f, 0.00670352f, 0.02427562f, 0.01216510f, 
    0.00875059f, -0.00755140f, -0.02456580f, 0.01727653f, -0.02936083f, -0.01998143f, -0.02596788f, -0.03406072f, 
    0.00656828f, -0.02267528f, -0.02166716f, -0.00093236f, -0.03978230f, -0.00696032f, -0.04326794f, -0.03884817f, 
    0.02901765f, -0.00862650f, -0.01380152f, 0.00288896f, 0.01853395f, -0.00385550f, 0.01514391f, -0.02920093f, 
    -0.00755484f, 0.01583308f, -0.02777446f, 0.01803559f, -0.00578762f, -0.02957359f, 0.01914630f, 0.01098505f, 
    -0.03884452f, -0.04090388f, 0.02645861f, 0.01620010f, -0.03751627f, 0.02576309f, -0.03373139f, -0.03392325f, 
    0.03063826f, -0.01944500f, -0.04228279f, -0.01058141f, -0.02909287f, -0.02816280f, -0.02050286f, -0.01892584f, 
    -0.02672619f, 0.00305619f, -0.01500564f, -0.00052984f, -0.03906411f, -0.00857186f, -0.00984045f, -0.00331018f, 
    -0.00092098f, 0.01102511f, 0.01837563f, -0.00872506f, 0.02019663f, -0.03090645f, -0.01584624f, -0.00198369f, 
    0.00755272f, -0.02047251f, -0.01304908f, -0.02139034f, 0.01574730f, 0.02213773f, 0.01852638f, -0.03554111f, 
    -0.02766860f, -0.01901659f, -0.00854546f, -0.03537409f, -0.02199534f, 0.03343364f, -0.01442779f, -0.01510659f, 
    0.02227932f, -0.01358583f, -0.01220020f, 0.02195559f, 0.00581552f, -0.00663482f, -0.01211465f, -0.01824014f, 
    -0.01087089f, 0.01671639f, -0.01559597f, -0.00436063f, 0.02231571f, -0.01827559f, 0.00124595f, 0.00932402f, 
    -0.01591699f, -0.02596910f, 0.00071500f, 0.00148345f, -0.01762738f, 0.00639533f, 0.00159732f, 0.02012626f, 
    -0.03706823f, -0.01921315f, -0.01679099f, 0.02253945f, -0.00825265f, -0.03077534f, 0.01468561f, 0.01034407f, 
    0.00292272f, 0.02800436f, 0.02882764f, -0.01949158f, -0.00596889f, 0.02406687f, 0.00219028f, -0.04361393f, 
    0.02253383f, -0.04030961f, 0.02568495f, -0.03359701f, 0.02051548f, 0.01718982f, -0.03590564f, 0.00326641f, 
    -0.00989557f, 0.03289995f, 0.01513862f, -0.01449527f, 0.01117522f, -0.00742533f, 0.00851924f, -0.02994958f, 
    -0.00490258f, -0.00112800f, -0.01995444f, -0.02732554f, 0.01960122f, 0.02346068f, 0.00631117f, 0.01376500f, 
    0.00407172f, -0.03586426f, -0.00136743f, 0.03492125f, -0.00073048f, -0.04038581f, -0.01836581f, 0.02922451f, 
    0.02017346f, -0.04210765f, 0.01147875f, -0.00833044f, 0.00875464f, 0.00777862f, 0.02568624f, -0.01624210f, 
    -0.02001135f, -0.03199247f, 0.00175335f, -0.00269664f, -0.00267861f, -0.03506509f, 0.00742116f, 0.01146217f, 
    0.01984812f, -0.04170023f, 0.00973142f, -0.01351382f, -0.01543022f, 0.01831741f, 0.00434630f, 0.00476114f, 
    0.02495350f, -0.01391289f, 0.02001967f, -0.01018323f, -0.02295070f, -0.02640633f, 0.01134510f, -0.02604865f, 
    -0.00530760f, -0.00810495f, -0.02232737f, 0.01563051f, -0.02646034f, 0.00047843f, -0.00195812f, -0.02444163f, 
    -0.02221685f, 0.00012565f, -0.04125011f, 0.02018938f, 0.02240059f, -0.02437878f, 0.01455988f, 0.01296755f, 
    -0.01687078f, -0.01673358f, 0.01925101f, -0.03698008f, -0.01484656f, 0.03040736f, -0.02587071f, 0.03433424f, 
    -0.00986611f, 0.02140068f, 0.03574297f, -0.00090967f, 0.02189620f, -0.02473122f, 0.01203300f, -0.02567534f, 
    0.00924260f, -0.02327432f, -0.00314445f, -0.03021405f, -0.02957426f, -0.01855059f, -0.01487611f, 0.00358122f, 
    -0.03436336f, -0.01895351f, -0.01526016f, -0.01841598f, 0.01383540f, 0.01884298f, 0.01805042f, -0.02443052f, 
    -0.02717535f, 0.01628734f, 0.03863157f, 0.02377351f, 0.02589659f, -0.01748447f, 0.01318184f, -0.02243573f, 
    -0.01371731f, -0.02286189f, -0.00422746f, 0.00163179f, -0.03339945f, 0.00151438f, 0.00009571f, 0.02630144f, 
    -0.02577290f, 0.00672138f, -0.00114733f, 0.00224393f, -0.01125335f, -0.03253847f, 0.02369882f, -0.01520782f, 
    -0.02485036f, -0.00463193f, -0.02977165f, 0.01276312f, -0.00669183f, 0.02263337f, 0.01533463f, -0.02875277f, 
    -0.01417450f, -0.02200523f, 0.00425491f, 0.00226352f, -0.04000052f, -0.01418121f, -0.00543151f, 0.00731675f, 
    -0.00832757f, -0.01438185f, -0.04158705f, 0.00551566f, -0.01932307f, -0.01144551f, -0.01770493f, 0.02305186f, 
    0.02167860f, 0.02045856f, -0.01548680f, -0.00319087f, -0.03386731f, -0.01650555f, -0.03992311f, 0.01959664f, 
    0.01248979f, -0.02043746f, 0.00839442f, -0.02446071f, 0.02182115f, -0.00764200f, -0.01406099f, 0.02539974f, 
    0.00752766f, 0.02140896f, -0.01421066f, 0.02301648f, -0.00951867f, -0.01140558f, -0.00430608f, 0.00519093f, 
    -0.01079669f, -0.03875859f, -0.01026824f, -0.01735573f, -0.04122964f, -0.00405386f, -0.00206981f, 0.02654301f, 
    0.00120965f, 0.02601992f, -0.03886843f, -0.01129337f, 0.00072095f, -0.00071014f, 0.00434479f, -0.03216076f, 
    0.02328839f, 0.00860773f, -0.02048689f, -0.00733287f, 0.02078794f, -0.03097531f, -0.02673853f, 0.00728770f, 
    -0.04344388f, 0.00238703f, 0.00896119f, 0.00787993f, -0.02700744f, 0.00725324f, -0.01191569f, -0.01048078f, 
    -0.03964821f, -0.01468660f, -0.00438396f, -0.00305677f, -0.03009850f, -0.03549260f, 0.00580788f, 0.01689010f, 
    0.02428511f, 0.01083072f, -0.01233146f, 0.00492388f, -0.02586493f, 0.00587852f, 0.02314989f, 0.01312223f, 
    0.00753153f, 0.01404759f, -0.02110296f, -0.00788313f, -0.02098673f, -0.02303323f, -0.00732829f, 0.03514424f, 
    0.04123361f, -0.00249902f, -0.03493350f, 0.00527068f, -0.02829859f, 0.01950538f, -0.00316773f, -0.02735568f, 
    -0.03652641f, 0.02640647f, -0.03877368f, 0.01675263f, -0.00162927f, -0.01574959f, 0.02282245f, 0.02018245f, 
    -0.00163533f, 0.03302082f, -0.03201882f, -0.03863189f, -0.04313359f, -0.02556457f, -0.00010665f, -0.01415487f, 
    0.02061064f, 0.00396924f, -0.03097892f, -0.03225060f, 0.02979338f, -0.03959415f, 0.01294248f, -0.03391163f, 
    -0.02662894f, -0.00905126f, -0.01159531f, 0.00725444f, -0.00907665f, 0.00766818f, -0.02307036f, -0.02009110f, 
    0.00435525f, -0.00980330f, 0.00404576f, -0.01100167f, -0.01318418f, 0.02509591f, -0.04012457f, -0.00415881f, 
    -0.02931247f, -0.00939892f, 0.01436629f, -0.04070394f, 0.01869382f, 0.02474830f, -0.01500431f, 0.02090811f, 
    -0.00104580f, -0.00648831f, -0.01149017f, 0.02654199f, -0.01222440f, -0.00666480f, 0.00086338f, 0.00141625f, 
    0.01802588f, -0.01758004f, -0.01605794f, -0.03793861f, -0.01335428f, 0.00708543f, -0.02142429f, -0.04152304f, 
    -0.00584189f, 0.01662262f, -0.02886004f, 0.00562129f, -0.01856107f, -0.02431648f, 0.01107001f, -0.03587990f, 
    -0.03707968f, -0.03023265f, -0.01421798f, -0.01790966f, -0.02688882f, 0.01074844f, 0.02551817f, -0.02149717f, 
    0.19496422f, -0.13879745f, -0.21639654f, -0.08781932f, 0.01206343f, 0.15172952f, 0.10103749f, 0.26471567f, 
    -0.07926093f, 0.03689618f, 0.10567298f, 0.11466467f, -0.00845620f, -0.27629465f, 0.21340388f, 0.22956344f, 
    0.07100745f, -0.08211932f, 0.01703205f, -0.13503714f, 0.17039847f, -0.00822985f, 0.16127868f, -0.04449508f, 
    -0.41708449f, 0.11997554f, 0.00539166f, 0.13393743f, -0.12083434f, 0.26498765f, 0.16906819f, 0.20006797f, 
    0.09057902f, 0.04625303f, 0.11419155f, -0.02716968f, -0.23799154f, -0.19135451f, -0.03379801f, -0.05897910f, 
    -0.18697354f, 0.04156754f, 0.14112273f, 0.07398984f, 0.24482544f, 0.09586836f, 0.13543235f, 0.06771474f, 
    0.07557741f, -0.01024192f, -0.04830778f, -0.34412378f, 0.03824970f, 0.02265678f, 0.01281111f, -0.09903102f, 
    -0.12118556f, 0.05062410f, -0.03492752f, -0.03496086f, -0.19471751f, -0.03780133f, 0.07823367f, -0.15179817f, 
    -0.02439155f, 0.00604554f, 0.03208229f, 0.12561837f, -0.02642877f, -0.11012405f, -0.04005424f, -0.08476000f, 
    -0.26037490f, 0.01466035f, -0.04227258f, 0.24455687f, -0.06714837f, -0.04156202f, -0.08531812f, 0.04269050f, 
    0.04231242f, 0.01451536f, 0.06507884f, -0.00927424f, -0.06764494f, 0.08929309f, -0.16291872f, 0.08197739f, 
    -0.00439002f, -0.06016911f, -0.04155609f, 0.03815892f, -0.00961875f, -0.01433929f, -0.05907263f, -0.04842144f, 
    -0.01696653f, 0.02829229f, -0.00653669f, -0.19290827f, -0.00070475f, -0.10895221f, -0.03734961f, -0.12964053f, 
    -0.04298648f, -0.09781183f, -0.02694798f, -0.00256802f, -0.11690801f, 0.02786428f, -0.08709137f, 0.31337631f, 
    -0.03769276f, 0.09820196f, -0.10751508f, 0.07604786f, 0.18356684f, 0.07072209f, 0.10415215f, 0.04498157f, 
    0.14481327f, 0.02423524f, 0.06189691f, -0.17557928f, 0.14117520f, -0.00404395f, 0.08573734f, -0.01741531f, 
    0.02640334f, -0.02209888f, -0.01785479f, 0.00288474f, 0.14810538f, 0.03899137f, 0.11116309f, -0.06822961f, 
    -0.02544662f, 0.02131897f, 0.17430581f, -0.07510623f, 0.06159149f, 0.01588030f, 0.08404274f, 0.05882683f, 
    -0.16937718f, -0.14872208f, -0.06787981f, -0.14619909f, -0.05965754f, 0.08864947f, -0.13458578f, 0.17098846f, 
    -0.13980657f, -0.09663357f, 0.05508342f, 0.08222482f, -0.31231698f, -0.03379349f, -0.01015606f, 0.12280060f, 
    -0.05050425f, 0.09073452f, -0.06438565f, 0.01941242f, 0.04136250f, -0.04221414f, -0.03618004f, 0.06992144f, 
    0.30637357f, -0.21053085f, -0.30547619f, -0.02838904f, 0.00728789f, -0.15078408f, -0.10879003f, 0.07938593f, 
    -0.15875950f, 0.18808931f, -0.00062487f, 0.16759856f, 0.02544967f, -0.20181146f, 0.15735792f, 0.14392863f, 
    0.10700206f, -0.03820382f, -0.08899275f, -0.00434113f, -0.02946511f, -0.08597771f, 0.13216197f, 0.01092826f, 
    -0.05766322f, 0.01966625f, -0.15596867f, 0.01353103f, 0.01951244f, 0.15255857f, -0.04412819f, 0.04957584f, 
    0.02727659f, 0.11886039f, -0.11188712f, 0.07303348f, -0.29097086f, 0.03545967f, -0.07639790f, -0.09945904f, 
    -0.03320885f, 0.11288127f, 0.04580601f, 0.06068028f, -0.13067900f, -0.03889199f, 0.12222558f, 0.02608614f, 
    0.30769223f, 0.20248456f, 0.00101006f, -0.07324713f, 0.02904889f, -0.05506453f, 0.12624769f, -0.07619585f, 
    0.10455566f, 0.06438437f, 0.14299659f, 0.09600300f, 0.00425102f, -0.06279204f, -0.01081384f, -0.27085024f, 
    0.02941149f, -0.04911366f, -0.03008621f, -0.11446536f, -0.08348433f, -0.08656769f, -0.05045307f, -0.08785225f, 
    -0.30498874f, -0.10977715f, -0.05403646f, -0.20245442f, 0.08488244f, 0.17951424f, -0.05680710f, 0.06044506f, 
    -0.03708818f, 0.01796454f, 0.06636779f, 0.12865718f, -0.09115264f, -0.07377083f, 0.04395303f, -0.08325908f, 
    0.10413602f, -0.04944324f, -0.02974561f, 0.03664578f, -0.15734746f, -0.00817520f, -0.03058781f, 0.19272806f, 
    0.38071683f, -0.09342773f, 0.14072441f, 0.06252068f, 0.14199810f, 0.08000247f, 0.17548774f, 0.02784373f, 
    0.14283966f, 0.04860616f, -0.01171190f, 0.16225478f, -0.25086460f, 0.07546689f, 0.16747178f, 0.07355021f, 
    0.32246825f, -0.21818863f, -0.07034520f, 0.15009518f, 0.01464114f, 0.07912625f, 0.06096204f, 0.03383566f, 
    0.04472651f, -0.07211155f, -0.01659715f, -0.29520109f, 0.04356674f, 0.13932852f, -0.05274662f, 0.18049219f, 
    0.07621923f, 0.00223366f, -0.00538125f, 0.18907905f, 0.20852615f, -0.03770288f, -0.17675315f, -0.09543595f, 
    -0.14487368f, 0.11292122f, -0.09868540f, -0.05612251f, -0.01213490f, 0.13501835f, -0.16360447f, 0.08965910f, 
    -0.22683586f, -0.26559374f, -0.03209438f, 0.31606579f, 0.08119527f, -0.07956176f, -0.02029420f, 0.14529832f, 
    0.13339701f, -0.10094226f, 0.09016120f, -0.13907810f, -0.13378935f, 0.28220901f, 0.08152600f, -0.04525001f, 
    0.11218525f, 0.08438198f, 0.13641517f, 0.11375654f, 0.00940288f, -0.02107419f, 0.13667893f, 0.15927237f, 
    -0.31358221f, -0.14771549f, -0.13650516f, -0.01542372f, 0.08629750f, 0.18126689f, 0.04587138f, -0.03225257f, 
    0.02642428f, -0.02076588f, -0.15997104f, -0.01578698f, -0.47535214f, -0.09124532f, -0.02080751f, 0.10585503f, 
    -0.04956001f, -0.00870950f, -0.01533328f, 0.04791888f, 0.02959011f, 0.01925863f, 0.06232964f, 0.06996759f, 
    -0.21614829f, -0.05399135f, -0.12560388f, -0.07598095f, 0.05388857f, 0.03579757f, 0.10419517f, 0.05769879f, 
    -0.13358192f, 0.22624961f, 0.07947196f, 0.02619188f, 0.24606611f, -0.03486930f, -0.18747503f, -0.07962094f, 
    -0.04441326f, -0.00717633f, 0.09527211f, 0.08854002f, 0.00982482f, -0.02771087f, 0.02324951f, 0.12084221f, 
    0.33593285f, 0.02415057f, -0.14980957f, 0.05298667f, -0.05809873f, -0.01906351f, 0.05421664f, 0.15048608f, 
    0.10555937f, 0.08180414f, 0.07345946f, 0.11444727f, 0.19722526f, 0.20509547f, -0.07869695f, 0.49487108f, 
    -0.07663493f, -0.04745635f, 0.09031302f, 0.12161813f, -0.04446406f, 0.07182527f, 0.02024193f, 0.13823494f, 
    0.39138246f, -0.23362331f, 0.05154555f, -0.11956251f, 0.02737680f, 0.08685709f, -0.05093575f, -0.11897302f, 
    0.05756454f, -0.02896162f, -0.00765788f, -0.08951452f, 0.55353874f, 0.11351463f, 0.00507634f, 0.20851572f, 
    0.11085038f, -0.02614131f, -0.05987649f, 0.21908292f, -0.02433766f, 0.14399256f, 0.05968237f, 0.03182380f, 
    0.01866314f, -0.04638319f, 0.11073335f, 0.03606271f, -0.05208875f, 0.20182076f, 0.01879305f, -0.13469115f, 
    -0.04949000f, 0.01316581f, -0.03098408f, -0.01979779f, -0.07789907f, 0.14566071f, -0.19422652f, -0.31473854f, 
    0.01540234f, 0.04247320f, 0.05716746f, 0.05405059f, -0.02813275f, 0.04230338f, -0.09496138f, 0.01252586f, 
    -0.11202697f, -0.09131139f, -0.07304513f, -0.01335819f, -0.01995361f, -0.00807710f, -0.03768749f, 0.03325831f, 
    -0.01621765f, -0.14491463f, 0.26166964f, 0.04215782f, -0.04488596f, -0.05075745f, 0.16360056f, 0.52091658f, 
    0.18807350f, 0.03179202f, -0.14796533f, 0.13202880f, 0.10002311f, 0.05092859f, 0.19884390f, 0.18592784f, 
    0.41619107f, 0.13475810f, 0.02035849f, -0.03145647f, 0.09858290f, -0.08970206f, 0.22209945f, 0.06108533f, 
    -0.01410578f, 0.14287606f, -0.01197908f, 0.02189021f, -0.56433034f, -0.06289255f, -0.02479463f, 0.08840689f, 
    -0.06321347f, 0.11002211f, -0.02121787f, 0.01077723f, 0.01893021f, 0.09236187f, 0.06797705f, 0.08956938f, 
    0.19212924f, 0.07044248f, -0.13528658f, 0.08304087f, 0.26043999f, -0.10441537f, 0.06211467f, 0.01694028f, 
    0.05867197f, -0.07166165f, 0.13910408f, -0.05054280f, 0.13225251f, 0.14045878f, 0.01984749f, -0.20811093f, 
    -0.04149376f, -0.01821443f, -0.02849155f, -0.13506386f, 0.05462601f, -0.01136902f, 0.07500996f, 0.05730166f, 
    0.13060825f, -0.11491097f, -0.15331174f, -0.28718156f, -0.16373625f, -0.12970287f, -0.08620786f, -0.21573125f, 
    0.05031610f, 0.00058653f, -0.12487125f, 0.00022905f, -0.09754143f, -0.37238058f, 0.22741908f, 0.18220478f, 
    0.06169295f, -0.03687761f, -0.02001977f, 0.06432202f, 0.10003871f, 0.18732917f, 0.19908974f, 0.07373074f, 
    0.11780914f, -0.10709500f, -0.11400632f, 0.17457278f, -0.03865951f, -0.08377735f, 0.01828119f, -0.11584881f, 
    -0.13956258f, 0.11872105f, 0.02706739f, -0.20933683f, -0.55756003f, 0.19165079f, -0.05403605f, -0.06501828f, 
    -0.07264348f, 0.18017936f, 0.09168393f, 0.15054601f, 0.16511729f, 0.02080774f, 0.07422470f, 0.02622794f, 
    -0.29862624f, -0.20769860f, -0.16540441f, -0.07228834f, 0.02739573f, -0.10712738f, -0.06015250f, -0.02466260f, 
    0.12310788f, 0.25988609f, 0.31687233f, 0.11157206f, 0.06429590f, -0.34837002f, 0.24482037f, -0.01374420f, 
    -0.02872420f, 0.08337536f, -0.08919736f, 0.03734243f, 0.20500262f, -0.10332707f, 0.10096230f, 0.01754181f, 
    -0.27604440f, -0.03278498f, 0.04801747f, -0.26457721f, 0.07328068f, 0.07128449f, -0.12662919f, 0.18079627f, 
    0.18675299f, 0.03236001f, -0.03775645f, -0.03591595f, -0.28775948f, -0.00379217f, -0.07363541f, -0.34305301f, 
    0.01674639f, -0.02073993f, 0.02536348f, -0.06338789f, 0.02965986f, -0.04353864f, 0.00469373f, -0.01277322f, 
    -0.22153455f, -0.11656530f, -0.21543741f, 0.22469753f, -0.10402741f, -0.06241158f, 0.20858343f, 0.16316356f, 
    0.08944036f, 0.16850616f, 0.09420130f, -0.00007284f, 0.16509387f, -0.14900313f, 0.21927398f, -0.00375188f, 
    0.19318253f, 0.06019722f, -0.13633436f, -0.07933833f, 0.11577578f, -0.10799725f, 0.12713151f, 0.01228603f, 
    0.02712756f, -0.04247101f, -0.26069003f, -0.23335776f, -0.03315414f, 0.24335378f, -0.01815287f, 0.07653849f, 
    -0.02411784f, 0.01850280f, -0.02625418f, 0.10458282f, 0.27326256f, -0.00830917f, -0.06703428f, -0.16463666f, 
    0.00786073f, 0.30446717f, -0.23668087f, -0.02967072f, -0.12485915f, 0.06228498f, -0.01387849f, 0.08833987f, 
    -0.09731166f, -0.03137212f, -0.08772092f, -0.28598422f, -0.06395773f, 0.00681472f, 0.07512546f, -0.09532304f, 
    0.04197967f, 0.00120610f, -0.03764013f, -0.04506630f, 0.46609449f, -0.23984934f, -0.25091168f, -0.03324657f, 
    -0.13228302f, 0.07687363f, 0.06486411f, -0.10066604f, 0.18437707f, 0.03004108f, -0.14561507f, 0.05747966f, 
    0.15328635f, 0.03190893f, -0.01720042f, -0.16510023f, -0.09819010f, 0.03880663f, 0.07240444f, -0.00966529f, 
    -0.07334621f, -0.05405408f, 0.09603792f, -0.08691593f, 0.05340152f, 0.15812622f, -0.14863403f, 0.19318749f, 
    -0.00739809f, -0.08088297f, -0.01416346f, 0.06388520f, -0.04437286f, -0.03148801f, 0.13288097f, -0.04223356f, 
    0.33585989f, -0.36645064f, 0.07902645f, 0.07036841f, 0.27450377f, -0.00742363f, 0.11365212f, 0.07105174f, 
    0.08300868f, -0.04081227f, 0.10524525f, 0.00145315f, -0.01684860f, -0.08934889f, -0.14497723f, -0.10859095f, 
    -0.08808882f, 0.00801607f, 0.08516050f, -0.07448495f, 0.14721906f, 0.02509684f, 0.09064606f, 0.11221942f, 
    -0.24367623f, -0.08429093f, -0.17433105f, -0.06394744f, -0.04749899f, -0.06716211f, -0.08752484f, -0.01244221f, 
    0.01461217f, 0.06844182f, -0.01298597f, -0.01700532f, -0.09593164f, -0.25156176f, -0.09198826f, 0.23314637f, 
    0.02997354f, 0.05643533f, -0.12471759f, 0.11620952f, 0.04542108f, 0.07316505f, -0.07221157f, 0.00438666f, 
    0.00119601f, -0.02326942f, -0.02391103f, -0.04347197f, 0.00992336f, 0.02166808f, -0.01005147f, -0.02752692f, 
    -0.03222686f, -0.02313721f, 0.00773964f, 0.02419653f, -0.00745476f, -0.01188604f, 0.02932852f, -0.00686805f, 
    -0.01896889f, 0.02233257f, 0.02237972f, 0.00083459f, -0.00310708f, 0.01145641f, -0.02677725f, 0.00928380f, 
    0.01415319f, -0.01674950f, 0.00597168f, 0.02849661f, -0.00490657f, 0.02002391f, 0.01841963f, -0.03604690f, 
    0.01696826f, 0.02864817f, -0.02991605f, 0.00370832f, -0.01267153f, -0.01511430f, -0.00500778f, -0.01320189f, 
    -0.00703199f, -0.01647020f, -0.00775531f, 0.00285194f, -0.00858081f, 0.03693210f, 0.00320569f, -0.00911309f, 
    0.00421119f, 0.01172524f, -0.03813864f, 0.00905643f, -0.02279151f, 0.03193401f, 0.02421616f, 0.03437658f, 
    -0.02971108f, -0.01464599f, -0.02440630f, -0.01202739f, -0.01743258f, 0.00379845f, -0.02900516f, -0.04210899f, 
    -0.00059998f, -0.00942288f, -0.01832036f, -0.03475402f, 0.01640017f, 0.01921203f, -0.03374629f, 0.01617891f, 
    -0.03024711f, 0.00954881f, 0.03736153f, 0.00408726f, 0.00616048f, -0.01728803f, -0.00378629f, -0.00474920f, 
    -0.03163642f, -0.02380312f, 0.01159023f, 0.02405102f, 0.01422287f, -0.03563999f, -0.01546525f, 0.01789217f, 
    -0.01373537f, -0.03163717f, -0.03265627f, -0.02714672f, 0.00589143f, -0.01513403f, 0.00138777f, -0.02368246f, 
    0.00697396f, 0.00210215f, 0.00310437f, -0.03938365f, 0.00977104f, -0.01585782f, -0.02832388f, -0.03893456f, 
    0.01088400f, 0.00985772f, -0.02795125f, 0.00927973f, -0.00020121f, 0.00603896f, -0.02785725f, -0.00177032f, 
    0.00272824f, 0.02151423f, 0.01360677f, -0.00109318f, 0.01289435f, -0.02981346f, -0.00381610f, -0.01972514f, 
    -0.01488895f, 0.02064786f, 0.01514672f, -0.00459400f, 0.00112360f, 0.00421151f, 0.02654128f, -0.01864377f, 
    -0.04241559f, 0.02007521f, 0.00353305f, 0.02183696f, -0.03619104f, -0.03993140f, -0.03286611f, -0.02780336f, 
    -0.01963507f, -0.04082574f, 0.00745168f, -0.03046001f, -0.00973388f, -0.03264422f, -0.00203606f, -0.02968462f, 
    -0.00763160f, 0.01481566f, 0.03529312f, -0.01740115f, -0.00433121f, -0.00701335f, 0.01543634f, -0.02567167f, 
    0.03000656f, 0.00301193f, 0.03804582f, -0.04001167f, 0.00410443f, 0.02787360f, -0.03362478f, 0.00815436f, 
    -0.02965464f, -0.01060133f, 0.01270219f, 0.01424993f, -0.03540159f, -0.02133234f, 0.01288300f, -0.00450051f, 
    -0.01990832f, -0.02480234f, 0.03793297f, -0.02120031f, 0.01131587f, 0.00428310f, -0.02428886f, 0.01336165f, 
    0.00989534f, -0.02151642f, -0.01256196f, 0.02486830f, 0.02376114f, -0.03622735f, -0.03082964f, 0.03277302f, 
    0.02624057f, -0.00369934f, 0.00671170f, -0.02204793f, 0.03747888f, -0.02184922f, -0.02536629f, 0.02831281f, 
    0.02542477f, -0.02606184f, -0.01311441f, -0.00224659f, 0.00579762f, -0.01737933f, -0.04082807f, -0.01339447f, 
    -0.00284287f, 0.00646189f, 0.00635371f, -0.00882286f, 0.00025320f, -0.01333748f, -0.04248459f, 0.01180270f, 
    -0.04366665f, -0.00435948f, 0.01731614f, -0.01472225f, -0.02995692f, 0.00180015f, 0.01980465f, 0.00686148f, 
    -0.02341272f, -0.01014531f, -0.02684745f, -0.02911894f, 0.00778913f, -0.01644591f, 0.01766402f, 0.03046264f, 
    0.01797192f, -0.00923316f, -0.00737456f, -0.01508352f, -0.00116117f, 0.01290349f, -0.04486276f, -0.03901454f, 
    -0.01254139f, 0.00622933f, -0.00066188f, -0.01283077f, -0.00500875f, -0.03288575f, 0.01257238f, 0.01025131f, 
    0.01980098f, -0.01551313f, -0.03728118f, 0.01348859f, -0.01456875f, 0.00333464f, -0.01975934f, 0.01350912f, 
    -0.03279560f, -0.01636190f, 0.02220639f, 0.01490730f, -0.01612787f, 0.02874927f, 0.03242712f, 0.00787378f, 
    -0.02736561f, 0.01671479f, -0.02052658f, -0.02108849f, 0.02846778f, 0.01150863f, -0.00262582f, 0.00361278f, 
    -0.00200131f, -0.00763719f, 0.02495159f, -0.00885473f, 0.03205170f, -0.01666874f, -0.00316148f, -0.04429742f, 
    -0.00120240f, 0.00785437f, -0.00784237f, 0.02168714f, 0.01550321f, 0.02233127f, -0.02810913f, -0.02038433f, 
    0.02020914f, -0.03507612f, 0.00323476f, 0.00816619f, -0.01702905f, -0.00697048f, -0.02074363f, -0.00387688f, 
    -0.01263470f, -0.00000010f, -0.02934190f, 0.00219619f, -0.02157397f, 0.02480159f, 0.00707593f, 0.02198379f, 
    0.01941060f, -0.00995677f, 0.01370320f, -0.02750911f, 0.01179427f, 0.00642197f, 0.01978713f, 0.01987615f, 
    0.02324905f, -0.03972325f, -0.00661190f, 0.00809622f, 0.01150120f, 0.00849468f, -0.02590284f, 0.03627655f, 
    0.01855999f, 0.00446695f, 0.02169418f, 0.00803252f, -0.02095885f, -0.01791230f, -0.04066620f, -0.00643358f, 
    0.02474863f, -0.03837873f, 0.01201557f, -0.03406661f, -0.01250782f, -0.00567198f, -0.00853653f, -0.02253368f, 
    -0.03293311f, -0.03253217f, -0.02074970f, 0.01426975f, 0.01605606f, -0.00935370f, -0.01822520f, -0.00312273f, 
    -0.01215936f, -0.01583526f, 0.01194078f, 0.01290974f, -0.03657536f, 0.00871862f, 0.00421884f, -0.01271499f, 
    -0.01765909f, 0.02698557f, -0.00213602f, -0.01095186f, 0.02307384f, 0.02370832f, -0.03211626f, -0.02446747f, 
    -0.01218254f, -0.00320826f, -0.00708464f, 0.03114466f, 0.02249344f, -0.01302258f, -0.02017502f, -0.02756338f, 
    0.00892615f, 0.01902286f, -0.01173452f, -0.00788936f, -0.00830135f, -0.01692032f, 0.00548852f, -0.01042258f, 
    0.02111341f, 0.02397467f, 0.02867110f, -0.02371841f, -0.00710854f, -0.02250374f, -0.01393589f, 0.01006060f, 
    -0.02366879f, 0.01924393f, 0.01359012f, 0.01910919f, -0.02957073f, -0.00323610f, 0.01475020f, 0.01102947f, 
    -0.01110912f, 0.01867792f, 0.02087023f, -0.02340648f, 0.01147169f, 0.02062121f, 0.01617322f, 0.00603003f, 
    0.01681026f, 0.02971053f, -0.04431566f, -0.00822263f, 0.02177745f, 0.01508562f, 0.02471481f, -0.02505758f, 
    0.01836742f, 0.02972006f, 0.00309199f, -0.03789658f, -0.00756070f, -0.01530063f, -0.00448075f, -0.00199381f, 
    -0.00768900f, -0.04068524f, -0.00042823f, 0.01156857f, -0.03766379f, 0.00170010f, -0.00837733f, -0.02523014f, 
    0.00123473f, 0.00791326f, 0.01321915f, 0.01890143f, -0.02917800f, 0.01222667f, 0.02671096f, -0.01341201f, 
    0.03291228f, 0.01837823f, -0.00042329f, -0.02906543f, 0.02869020f, -0.02540088f, -0.03918584f, -0.02101465f, 
    -0.00701575f, -0.00565744f, -0.01585987f, 0.01428646f, -0.03894734f, -0.03473053f, -0.00052427f, -0.00900196f, 
    0.02121601f, -0.00623859f, -0.01743087f, -0.03710624f, 0.02478962f, -0.04530263f, -0.03029441f, -0.03017800f, 
    0.02072781f, 0.00790008f, 0.02969632f, -0.03318231f, -0.02682420f, -0.02956317f, 0.01457167f, -0.02570947f, 
    -0.02135677f, 0.01913760f, 0.00024971f, 0.02405786f, 0.00105432f, 0.03026549f, -0.01836130f, -0.02723169f, 
    -0.03986958f, 0.02612875f, 0.00932302f, 0.02246331f, 0.02611695f, 0.02326290f, 0.00413809f, 0.03395446f, 
    0.00907324f, -0.00421890f, 0.03390899f, -0.02192872f, 0.02626332f, -0.03423558f, -0.00737907f, -0.00816555f, 
    0.01016160f, -0.00874921f, 0.02808400f, 0.00841928f, -0.00084516f, -0.04541302f, 0.02854574f, -0.01048897f, 
    0.02410419f, -0.00887705f, -0.03359406f, -0.00542845f, 0.03069964f, 0.02326862f, -0.03006991f, 0.00387734f, 
    -0.02501437f, -0.03348656f, 0.02418608f, 0.00988497f, -0.02140116f, 0.00311034f, -0.01070870f, -0.03363575f, 
    -0.02465304f, 0.02662257f, 0.01071000f, 0.03056359f, 0.02012668f, 0.00308799f, -0.04341547f, -0.00183401f, 
    0.01960315f, -0.03413629f, -0.02748212f, -0.02031880f, -0.01818370f, 0.02328927f, 0.02175114f, -0.01904779f, 
    0.01344194f, 0.02335703f, -0.00358917f, 0.02628027f, 0.02420519f, 0.00416557f, 0.03568903f, -0.02057262f, 
    -0.00356947f, -0.00582258f, -0.04581594f, -0.02965035f, -0.01997387f, -0.03529448f, 0.01430473f, 0.01411629f, 
    0.01848303f, -0.02355497f, -0.00990711f, -0.00514190f, -0.02491910f, 0.02677786f, -0.00359748f, 0.03788591f, 
    0.02534694f, 0.02520645f, -0.01747111f, -0.02996826f, 0.03604213f, 0.00174098f, 0.02241675f, 0.03123427f, 
    -0.02028773f, -0.02591483f, -0.03729543f, 0.00535164f, 0.01959767f, -0.04058886f, -0.00019337f, -0.00168989f, 
    0.02635603f, 0.01440637f, -0.01636690f, 0.01767257f, -0.01639636f, 0.01381338f, 0.01800005f, -0.03343293f, 
    0.02268617f, -0.03380226f, 0.00746041f, -0.00862202f, 0.02977823f, -0.02085165f, -0.00690016f, -0.02356228f, 
    -0.03608972f, -0.03746550f, -0.00420107f, 0.01224671f, -0.01024217f, -0.00700253f, 0.01377407f, -0.03567487f, 
    0.02835819f, 0.01112754f, 0.00368913f, -0.02470333f, -0.01636342f, 0.03233815f, -0.03632095f, 0.00941270f, 
    0.00100551f, -0.02669211f, -0.03349873f, -0.02327239f, -0.03285049f, 0.01193877f, -0.01163304f, -0.00062125f, 
    -0.01567439f, 0.02989836f, -0.03944328f, -0.04401334f, -0.01699717f, 0.02204345f, -0.00184657f, 0.02156769f, 
    0.01923468f, 0.01858663f, -0.01300324f, -0.01486958f, -0.04616254f, -0.00141464f, -0.02533515f, -0.02376993f, 
    -0.00073001f, -0.01975773f, 0.02995162f, 0.01734537f, 0.03430186f, -0.03750610f, 0.00365921f, 0.00004052f, 
    -0.00970528f, 0.02243167f, 0.01212915f, -0.04062784f, -0.03879226f, 0.01586992f, 0.00559137f, -0.03621113f, 
    0.00822513f, 0.01551859f, -0.01246561f, -0.03211167f, 0.00348340f, 0.01703461f, -0.01379875f, 0.00277724f, 
    -0.00905081f, -0.01585421f, 0.00718293f, -0.01973539f, 0.00287546f, -0.03437452f, 0.00172555f, -0.00209943f, 
    -0.00806329f, -0.01020982f, 0.00124696f, -0.03886338f, 0.00775293f, -0.02398391f, 0.02741136f, 0.01666789f, 
    0.02000888f, 0.03079286f, 0.01346227f, 0.00864936f, 0.01073438f, 0.01673205f, 0.00711951f, 0.01897221f, 
    -0.02831186f, -0.02784746f, -0.01188244f, -0.03702859f, 0.01120652f, 0.03348434f, 0.00282472f, -0.03486465f, 
    -0.01804174f, -0.01565989f, 0.01015235f, -0.02093850f, -0.00746360f, 0.01696434f, 0.01845325f, -0.03496460f, 
    0.02605368f, 0.01684266f, 0.00851365f, 0.00291051f, -0.00537666f, -0.03007280f, 0.01990834f, 0.02558092f, 
    -0.01505707f, 0.01816627f, 0.01916495f, -0.00534199f, -0.03216374f, -0.00003658f, -0.02303494f, -0.00465243f, 
    -0.00374892f, -0.00020163f, -0.01216021f, -0.00640380f, 0.00520267f, -0.00253708f, -0.02375731f, 0.01571776f, 
    0.00841193f, -0.02897634f, -0.01128740f, -0.02234785f, 0.00662073f, -0.03147047f, 0.02051341f, -0.01795938f, 
    0.02060765f, -0.02948971f, 0.01286241f, -0.01386929f, -0.00781579f, -0.01887731f, -0.02827445f, -0.03004155f, 
    -0.00234314f, -0.02777793f, -0.02347140f, 0.00410529f, -0.00372227f, -0.02344990f, -0.02562771f, -0.00632769f, 
    -0.04152303f, -0.00467242f, -0.02479644f, -0.00144388f, -0.00603338f, -0.00886861f, -0.03424307f, -0.01821652f, 
    0.01419701f, 0.02469886f, 0.00110982f, -0.00722397f, 0.01481184f, 0.02252526f, -0.01586550f, -0.01208807f, 
    0.00323791f, -0.03446745f, -0.01971673f, -0.00023675f, -0.01252138f, 0.01949630f, -0.04002163f, 0.02589788f, 
    0.02120995f, 0.03243655f, -0.04051303f, 0.02293670f, 0.01614797f, -0.02980255f, -0.00069770f, 0.02819942f, 
    0.03430364f, 0.00010214f, -0.03576211f, 0.02978506f, 0.00847048f, -0.02689939f, -0.03519582f, -0.02275175f, 
    -0.26024899f, -0.32267016f, -0.22511780f, 0.08391507f, 0.04442231f, 0.00400680f, -0.02126800f, -0.03347284f, 
    -0.09053987f, -0.05423394f, 0.11183502f, -0.00326486f, 0.24172384f, 0.27895474f, -0.11255566f, -0.29786819f, 
    -0.04423310f, 0.07432867f, 0.07934472f, -0.00039454f, -0.16145213f, -0.02235088f, -0.10712921f, -0.16789536f, 
    0.39785001f, 0.01134034f, -0.04036407f, -0.02373902f, 0.15223347f, 0.01800995f, -0.07999650f, 0.09148435f, 
    -0.00903991f, 0.11286283f, -0.05122309f, -0.09542131f, 0.14208925f, 0.10353387f, 0.12418384f, 0.19436392f, 
    -0.01298538f, 0.03552454f, -0.08921936f, -0.08526981f, 0.13807756f, 0.08016414f, -0.11169650f, -0.07376921f, 
    0.00213435f, -0.06419603f, -0.11585858f, 0.25511414f, 0.11882002f, -0.01539145f, 0.32572287f, -0.05231713f, 
    -0.15969804f, 0.09311512f, 0.12447104f, 0.10840704f, 0.07397473f, -0.05338822f, -0.23846085f, 0.00989899f, 
    0.02878779f, 0.03729513f, 0.02536779f, 0.00271134f, 0.16399412f, 0.08535111f, 0.04248384f, 0.18589912f, 
    0.17893191f, 0.16263151f, 0.19308130f, -0.13706312f, -0.07625223f, -0.05607557f, -0.07001407f, 0.00136564f, 
    -0.01155993f, 0.06078725f, -0.24880402f, 0.06515782f, 0.04271256f, -0.05807308f, 0.05910250f, -0.24010810f, 
    -0.22926880f, -0.09740639f, -0.10127588f, -0.11365256f, 0.00087937f, 0.11328548f, 0.17623821f, 0.14708035f, 
    0.12207580f, 0.03954947f, -0.04893612f, -0.05348335f, 0.07965520f, -0.00886134f, 0.06399468f, 0.03631091f, 
    -0.14708444f, -0.09106869f, 0.03666207f, -0.09703792f, 0.01194022f, -0.17595537f, 0.05480711f, -0.31028813f, 
    -0.04231489f, 0.00290064f, 0.06674244f, -0.03492849f, 0.11447193f, 0.20883420f, 0.09051926f, 0.10811823f, 
    0.11111216f, 0.04999679f, 0.02280157f, -0.02103894f, 0.02953695f, 0.02981808f, 0.06196484f, 0.07243843f, 
    -0.01946122f, 0.07956231f, 0.02683723f, 0.10760798f, 0.23429401f, 0.17287619f, 0.03318446f, -0.10642674f, 
    0.06156496f, 0.02155723f, -0.05299623f, -0.03273700f, 0.00428014f, -0.00991085f, 0.00300731f, -0.05817170f, 
    -0.17723203f, -0.30919963f, -0.44061801f, -0.02967587f, 0.00359784f, 0.03937545f, 0.10450354f, -0.04723509f, 
    -0.14013618f, 0.13279645f, -0.01370699f, -0.00217816f, -0.24979900f, -0.10746338f, -0.06408555f, 0.11426769f, 
    0.02060732f, 0.13718221f, -0.02345031f, -0.09748884f, 0.14899473f, 0.13339876f, 0.16743006f, 0.19277804f, 
    0.30691230f, 0.18524343f, 0.05697761f, 0.21631971f, -0.09825309f, 0.04192147f, 0.02302346f, -0.18885873f, 
    -0.01625975f, -0.01530951f, 0.04307659f, -0.05697385f, -0.09011818f, 0.03574253f, 0.43297252f, 0.08008699f, 
    -0.05532737f, -0.13284025f, -0.07979147f, -0.03889117f, -0.17157860f, -0.23067565f, -0.17920455f, -0.02249324f, 
    -0.00740627f, 0.06470937f, 0.03991235f, -0.05465553f, 0.05956778f, 0.01554897f, 0.01468910f, -0.04936088f, 
    0.08712786f, 0.19132064f, 0.14661050f, 0.15158793f, -0.02059825f, -0.32369325f, -0.24310166f, 0.00192174f, 
    0.01562577f, 0.17785275f, 0.17503898f, 0.13299638f, 0.07982931f, -0.03586347f, -0.00546686f, 0.01501973f, 
    0.03301165f, 0.24520893f, -0.05706526f, -0.14715171f, 0.02575826f, -0.03347784f, -0.09567134f, 0.19254856f, 
    -0.01222672f, -0.03098401f, 0.04385919f, -0.06386290f, 0.05419920f, -0.15123284f, -0.07557029f, -0.11178558f, 
    0.06867808f, 0.06081192f, 0.09926724f, 0.03011297f, -0.19816673f, 0.03208336f, 0.07512132f, 0.07244132f, 
    0.02155335f, -0.07515864f, -0.03313226f, 0.09071245f, 0.08972561f, 0.12085685f, 0.29596597f, -0.05744124f, 
    0.17524709f, -0.12850873f, 0.19951874f, 0.00989483f, -0.17747645f, 0.10551389f, 0.09228159f, -0.13562085f, 
    -0.16574074f, -0.10044928f, -0.07731704f, 0.03571039f, -0.00426299f, 0.12559727f, 0.15994973f, 0.05183830f, 
    0.08332896f, 0.12741978f, -0.06401926f, 0.18599112f, 0.12274225f, 0.11520503f, 0.02016034f, 0.00795593f, 
    -0.06982443f, -0.09400647f, -0.01392877f, 0.01203928f, 0.17552550f, 0.12452211f, 0.28231972f, -0.10214096f, 
    0.13027263f, -0.07016513f, -0.11358469f, 0.06677418f, -0.00147272f, 0.12726912f, -0.00147951f, -0.04219139f, 
    -0.17570640f, -0.23325467f, -0.14376326f, 0.22106330f, -0.00866634f, -0.00407752f, 0.25902736f, 0.09982773f, 
    -0.05864513f, 0.04888505f, -0.00361872f, -0.08949842f, -0.16180566f, -0.10911281f, -0.09090663f, 0.09854778f, 
    -0.00215421f, -0.03266976f, 0.00860869f, 0.07509104f, -0.02421064f, 0.00280303f, 0.00073264f, 0.01738442f, 
    0.31815371f, -0.09741057f, -0.08850182f, -0.41008654f, -0.02915365f, 0.05991495f, -0.03004109f, -0.04985879f, 
    0.22602592f, 0.04134368f, 0.26615319f, 0.12734148f, 0.07194848f, -0.19307823f, -0.10034955f, -0.05244979f, 
    0.15334325f, 0.09460369f, -0.14329088f, 0.17336603f, 0.08225633f, -0.04456436f, 0.06988426f, 0.05210628f, 
    0.06056083f, -0.14592050f, -0.10598522f, -0.00127269f, -0.23352668f, 0.13120489f, 0.21893059f, 0.01645517f, 
    0.02729891f, 0.21635319f, 0.01639085f, 0.07798944f, -0.10488293f, -0.29474685f, -0.22947517f, -0.15940681f, 
    0.06103644f, 0.11867522f, -0.06142091f, 0.00979110f, -0.03954126f, 0.03299661f, 0.04455685f, -0.02494484f, 
    -0.28683197f, -0.11441331f, 0.16355102f, -0.04284244f, 0.01114791f, 0.02910537f, -0.08766709f, 0.04172362f, 
    -0.15504572f, -0.05765336f, -0.06915267f, -0.18775441f, -0.28018910f, -0.11774322f, -0.03061510f, 0.02124570f, 
    -0.05324520f, 0.04702435f, 0.02441511f, -0.16804548f, 0.09476814f, -0.05881761f, 0.00225697f, 0.10672899f, 
    -0.42191732f, -0.15501314f, 0.21678227f, 0.03617745f, -0.08026424f, 0.00454312f, 0.05419317f, -0.12342758f, 
    0.05338510f, 0.07699215f, -0.03871626f, -0.02448260f, 0.30596098f, 0.37868917f, 0.55698144f, -0.09774069f, 
    -0.04162928f, 0.01467107f, -0.18301679f, -0.01990470f, -0.03060854f, 0.02140353f, -0.01394791f, 0.07009626f, 
    -0.07189710f, 0.01220862f, 0.07962720f, -0.02976161f, 0.14703991f, 0.08760855f, 0.02211426f, 0.00509219f, 
    -0.00572074f, 0.06931203f, -0.14082940f, -0.19047749f, 0.07026339f, 0.12601411f, 0.15882063f, -0.14473003f, 
    0.08590554f, -0.01796318f, -0.07075089f, -0.18619987f, 0.02365100f, 0.01191719f, 0.03303584f, 0.19042858f, 
    -0.04228917f, 0.29349822f, 0.16750091f, 0.01133356f, 0.02115298f, -0.06128104f, -0.09188616f, 0.08932843f, 
    0.06008223f, 0.16436821f, 0.04004948f, 0.01214541f, 0.06297902f, 0.04411954f, 0.00977319f, 0.01131771f, 
    -0.04372091f, 0.01525185f, 0.17616698f, 0.16203550f, 0.08763194f, 0.02335127f, 0.14433879f, 0.22897418f, 
    0.02534747f, 0.12338205f, -0.02696575f, -0.08066166f, -0.05971596f, -0.06154738f, -0.04179265f, -0.04651979f, 
    -0.30397174f, -0.22332454f, -0.21128809f, -0.26506111f, -0.19584671f, 0.02501011f, 0.01265409f, -0.14245147f, 
    0.09495226f, -0.01155132f, 0.04812665f, -0.09903534f, -0.02662751f, 0.20924187f, 0.00965679f, 0.10789448f, 
    0.20142429f, 0.40803635f, -0.17912059f, -0.14661261f, 0.15865669f, -0.10121076f, 0.15183516f, 0.07362869f, 
    -0.02714852f, -0.04231510f, 0.01173236f, 0.02650963f, 0.02293765f, -0.24524347f, -0.14303666f, -0.21668176f, 
    0.06094861f, 0.07868765f, -0.05150571f, -0.07005279f, 0.10994306f, 0.02797006f, 0.06218229f, -0.03982865f, 
    0.04517443f, 0.13219066f, 0.02618625f, -0.19404395f, -0.06287046f, -0.04192043f, 0.03204728f, -0.20042804f, 
    0.16300179f, -0.02881928f, -0.06422693f, 0.02184960f, 0.08386877f, 0.06413028f, -0.16099936f, -0.01961611f, 
    0.10633288f, 0.04567316f, 0.07230794f, 0.09462260f, 0.00502992f, -0.10612916f, -0.02897948f, -0.05942531f, 
    -0.09931388f, -0.04030553f, -0.08497850f, 0.03635935f, 0.04438982f, 0.00886078f, 0.06041759f, 0.06421684f, 
    -0.00641392f, -0.11117744f, -0.00132963f, 0.02316299f, 0.26287791f, -0.08397207f, -0.03034156f, -0.21580657f, 
    -0.03704556f, -0.02350681f, 0.03092734f, -0.05739824f, 0.33666074f, 0.05365505f, 0.05056766f, 0.07717806f, 
    0.01718171f, 0.19464754f, 0.02889846f, 0.10469425f, -0.11549412f, -0.04962379f, -0.08379792f, -0.14915259f, 
    -0.32299146f, -0.00920760f, -0.04737278f, -0.13447374f, 0.35846794f, -0.08320048f, -0.16314475f, -0.07953852f, 
    0.13655128f, -0.04105279f, -0.00061065f, 0.02460088f, -0.05998081f, -0.00955476f, -0.08560555f, -0.13242598f, 
    0.00345899f, -0.02639156f, -0.11733276f, -0.22636235f, 0.00172618f, -0.04676378f, -0.01344603f, -0.10801617f, 
    0.04589055f, -0.12347124f, 0.10606697f, -0.10850278f, -0.33102423f, 0.20252965f, 0.03828401f, 0.18647988f, 
    -0.14248566f, -0.05369078f, -0.02085831f, 0.06453335f, -0.10013989f, 0.10746611f, -0.04441382f, 0.00556329f, 
    0.04280477f, -0.04485634f, 0.13359609f, 0.35146993f, -0.03886823f, 0.09964293f, 0.06526695f, -0.01662733f, 
    -0.20822364f, 0.05969106f, -0.03958641f, -0.05948656f, 0.17783763f, 0.11398709f, 0.04629841f, 0.07420877f, 
    0.01035804f, 0.11929972f, -0.01600592f, 0.10461581f, -0.11399025f, 0.04918322f, 0.03639450f, -0.06687254f, 
    0.24237253f, 0.26259059f, -0.01641397f, -0.18232629f, -0.00252206f, 0.01743197f, 0.11575393f, 0.07872990f, 
    0.02695296f, -0.01090533f, 0.08271679f, 0.00401996f, -0.01418565f, 0.11189406f, -0.08910843f, -0.17696314f, 
    0.17989174f, 0.00661659f, 0.15807793f, -0.21850602f, 0.03126088f, 0.23569460f, 0.10483513f, 0.20118558f, 
    0.04090787f, -0.03493281f, 0.13263950f, 0.07245666f, 0.02891276f, 0.05547046f, 0.00833148f, 0.21336301f, 
    0.04364771f, -0.02183391f, -0.05956999f, 0.14560971f, -0.09680352f, 0.00281274f, 0.15448132f, 0.24455956f, 
    0.00288634f, -0.16962107f, -0.01690291f, -0.00525109f, -0.04312797f, 0.12668341f, 0.05361218f, 0.12458615f, 
    0.12486192f, -0.06814957f, -0.06453756f, 0.05023266f, 0.05249251f, 0.11484886f, 0.17224246f, 0.05202560f, 
    0.01571421f, 0.03340426f, -0.05635662f, 0.03774348f, 0.10463287f, 0.21070255f, 0.06264782f, 0.24262260f, 
    0.02515960f, 0.11599578f, 0.15608224f, -0.08629078f, -0.08799671f, 0.07393064f, 0.08267673f, 0.07587977f, 
    0.06819507f, 0.12703168f, -0.01434500f, 0.11884429f, 0.09261572f, -0.04069236f, 0.01742079f, -0.01714442f, 
    0.08483742f, 0.00647227f, -0.04985723f, -0.04688847f, 0.21913670f, 0.20763458f, 0.01277223f, -0.20668188f, 
    -0.13802871f, -0.10853859f, -0.06831613f, -0.13596857f, 0.05532617f, -0.06118233f, 0.03768859f, 0.06492200f, 
    0.38420165f, 0.55065829f, -0.13624455f, -0.27717659f, -0.21745759f, -0.03765466f, 0.00910109f, -0.03973076f, 
    0.05150394f, -0.05709935f, 0.03372807f, -0.09995923f, -0.00325617f, -0.13382757f, -0.12537344f, -0.08649370f, 
    0.11074831f, 0.18709882f, 0.09867837f, 0.10331922f, -0.06510230f, 0.14582267f, -0.02472233f, 0.06657711f, 
    -0.09817337f, 0.03253938f, -0.09825419f, -0.08807310f, -0.22888045f, -0.00184478f, -0.08746403f, -0.10035837f, 
    0.02332808f, 0.07219891f, 0.11024011f, 0.27506667f, -0.20491141f, -0.18408297f, 0.04149714f, -0.11673137f, 
    0.14851519f, 0.10781722f, -0.06345420f, -0.04939215f, 0.06179805f, 0.10259469f, 0.32409188f, 0.22152700f, 
    -0.00530105f, -0.03810767f, -0.03653712f, 0.03126929f, 0.02073964f, 0.01707945f, 0.02917107f, -0.01768198f, 
    0.01885326f, -0.01580824f, -0.04105107f, 0.02342663f, -0.02708198f, 0.02088237f, -0.01082014f, -0.02465218f, 
    -0.02356123f, -0.03402168f, 0.01480711f, -0.01574538f, -0.01645772f, -0.02276095f, 0.02595968f, -0.00969540f, 
    0.00823199f, 0.02805447f, -0.00804642f, 0.01940846f, -0.00056607f, 0.02394675f, 0.01403889f, 0.00339289f, 
    -0.01656831f, -0.01830369f, 0.02737519f, 0.02702566f, -0.01992183f, -0.01767484f, 0.02363319f, 0.02397526f, 
    -0.00638552f, -0.02084452f, 0.00332559f, 0.01222166f, 0.00703792f, -0.01571528f, -0.01028598f, -0.00604734f, 
    0.03026896f, -0.01181732f, -0.03142693f, 0.01069365f, 0.00521477f, -0.01005642f, -0.03510016f, 0.01748915f, 
    0.01801791f, -0.00792735f, -0.03407009f, -0.03964629f, 0.03780343f, -0.02434741f, -0.01527787f, 0.02529007f, 
    0.00311286f, -0.03255505f, -0.02812293f, -0.00033831f, -0.00654487f, -0.04197083f, -0.00583824f, -0.01730089f, 
    0.00260553f, 0.01481929f, 0.00601236f, 0.02664598f, 0.00147515f, -0.02211850f, -0.02851295f, 0.01772153f, 
    -0.00502294f, -0.03179233f, -0.01785163f, 0.02310440f, -0.01283553f, 0.01495150f, -0.00409929f, -0.00196947f, 
    0.01157738f, -0.03967983f, 0.02247337f, 0.00624767f, -0.00777395f, -0.00107682f, -0.01215669f, -0.02127351f, 
    0.03319952f, -0.03206934f, -0.00783247f, -0.00395024f, -0.01393957f, 0.00057488f, -0.01818736f, -0.00755788f, 
    0.01160524f, 0.01652087f, -0.04177482f, 0.01808252f, -0.01203548f, 0.00235943f, 0.00091986f, -0.02711478f, 
    -0.02298699f, -0.01305055f, -0.01434419f, 0.01695642f, 0.01176601f, -0.01369016f, -0.03194370f, -0.01552382f, 
    0.00543987f, 0.00479582f, 0.02190417f, -0.03749234f, 0.00866143f, -0.00677259f, 0.03442045f, 0.00749489f, 
    0.02704817f, -0.02544151f, -0.01429167f, -0.01401111f, -0.02530703f, -0.01258027f, -0.02648656f, 0.02611348f, 
    0.01918767f, -0.00963147f, 0.00294455f, -0.01826460f, 0.02352658f, -0.02661601f, -0.03632277f, 0.02048254f, 
    -0.03095786f, -0.03004284f, 0.01606876f, 0.02561460f, 0.01334436f, 0.01210478f, -0.02387434f, 0.02421600f, 
    0.01714897f, 0.00189357f, -0.02698687f, -0.03012218f, -0.02208224f, 0.00936310f, -0.02116749f, 0.01171073f, 
    -0.03104370f, -0.04025463f, -0.03838304f, -0.02335283f, 0.00853101f, 0.01924164f, -0.02789721f, -0.04123864f, 
    0.01122398f, -0.03895396f, 0.02134746f, -0.03356280f, -0.03556366f, 0.01120087f, 0.02410051f, -0.03213910f, 
    -0.02776446f, 0.02350060f, -0.03378043f, 0.00841118f, -0.01262902f, 0.02187558f, -0.00157253f, -0.00622387f, 
    -0.04286209f, -0.02869837f, 0.00010335f, -0.00167154f, -0.02403751f, -0.02308409f, -0.02177188f, 0.02081499f, 
    0.00491237f, 0.01039722f, 0.00327428f, -0.03119923f, -0.03840075f, -0.00347453f, -0.03231537f, 0.02306948f, 
    -0.03235267f, -0.00408180f, 0.00901806f, -0.03536639f, 0.00788604f, 0.01229829f, 0.00495192f, -0.03004462f, 
    0.00353415f, -0.00577526f, 0.01110538f, -0.01382858f, -0.03227662f, -0.00860343f, 0.01838263f, 0.02763907f, 
    0.01511602f, 0.02059893f, -0.01165974f, -0.00835095f, -0.00956428f, 0.00186847f, 0.02715656f, 0.01615237f, 
    -0.02510939f, -0.02681814f, -0.02867114f, 0.00203435f, 0.01797641f, -0.00991603f, 0.02127342f, -0.02023206f, 
    0.02774762f, 0.00006065f, -0.01434978f, -0.01815466f, -0.00734591f, -0.00933194f, 0.01279854f, 0.02827017f, 
    0.03226323f, -0.01000710f, 0.00450130f, -0.00004728f, -0.00144941f, 0.02361329f, -0.02112019f, 0.00217465f, 
    0.02705160f, 0.00113872f, -0.00610914f, 0.00958505f, -0.03725243f, -0.03848915f, 0.00899294f, 0.01322487f, 
    -0.01634395f, -0.03455006f, 0.01557879f, -0.00078715f, -0.03542645f, -0.03431426f, -0.02125673f, -0.00624368f, 
    -0.02154794f, -0.02746582f, 0.01227812f, -0.00244420f, 0.00043170f, 0.02498269f, 0.01598588f, 0.00991501f, 
    -0.03537497f, -0.01004903f, -0.00514605f, -0.04233703f, -0.00163684f, 0.00505295f, -0.02024402f, -0.01544966f, 
    0.02019012f, 0.01351425f, -0.00592334f, -0.01058067f, 0.02443734f, 0.01434986f, -0.00363304f, -0.02801346f, 
    0.01235354f, -0.01562500f, 0.02975640f, -0.00007871f, -0.03639910f, -0.03003348f, 0.00246618f, -0.02858697f, 
    0.02729850f, 0.02064819f, -0.00487763f, 0.00732300f, -0.02248182f, -0.00127493f, 0.00398743f, -0.00517296f, 
    -0.00415984f, -0.02154475f, -0.02671686f, -0.00613310f, -0.03728045f, -0.04108001f, 0.00294798f, -0.00100409f, 
    -0.01406562f, -0.01754118f, -0.01079029f, 0.00084256f, 0.01739168f, -0.03662336f, -0.02561803f, -0.00362456f, 
    0.02246626f, 0.00505279f, -0.04126361f, -0.02365846f, -0.03408062f, -0.02872103f, -0.03318593f, -0.04022709f, 
    -0.02576129f, -0.01272388f, -0.00310458f, 0.02261548f, -0.00360598f, -0.03025425f, 0.01387840f, 0.02392918f, 
    0.01947147f, -0.02512308f, 0.02391577f, 0.01713551f, -0.00548400f, -0.04103579f, 0.00017689f, -0.02999669f, 
    -0.00289648f, 0.00899407f, -0.01746601f, -0.02030138f, 0.00477448f, 0.01806320f, 0.02175753f, 0.01884667f, 
    -0.00139680f, -0.02937106f, -0.00882144f, 0.03043368f, -0.01395472f, -0.02890851f, -0.00110702f, -0.00576326f, 
    0.00944930f, 0.00041638f, 0.01760676f, -0.00948031f, 0.02185440f, 0.02493215f, -0.00645217f, -0.00904204f, 
    0.00134154f, -0.02739601f, -0.03610247f, -0.03123352f, -0.04298755f, -0.03565326f, 0.02891697f, -0.01995306f, 
    -0.00107445f, -0.01943539f, -0.01129509f, -0.02106468f, 0.02132360f, 0.01981221f, 0.01207833f, -0.01607268f, 
    -0.02050690f, -0.01064111f, 0.00745061f, 0.02742681f, -0.02350736f, 0.03206792f, -0.03774149f, -0.00473864f, 
    -0.02275721f, 0.01820083f, -0.02008860f, 0.00776459f, 0.02607333f, -0.02586734f, 0.01561257f, -0.03797975f, 
    0.01765290f, 0.01378594f, -0.01320282f, -0.01919015f, 0.03267109f, -0.02888468f, 0.00560641f, -0.03141750f, 
    0.01439853f, -0.02832559f, -0.02966313f, 0.02993066f, -0.01249328f, 0.00715374f, -0.02480519f, 0.01310750f, 
    -0.02566880f, 0.00383266f, 0.00428337f, -0.03608222f, -0.00610967f, -0.01198165f, 0.00847717f, 0.00812953f, 
    -0.03583319f, -0.01258765f, -0.00766122f, 0.00570030f, 0.00384184f, -0.02985919f, 0.02052301f, 0.00187218f, 
    -0.00239410f, -0.03083878f, 0.01139384f, 0.01935525f, -0.03571822f, 0.02916497f, 0.00552867f, -0.03750527f, 
    -0.02687648f, -0.03723570f, 0.02763490f, 0.02000891f, -0.01153156f, 0.02268119f, 0.02374583f, -0.02320407f, 
    0.02647460f, -0.02265370f, -0.02930829f, -0.03578694f, -0.00705542f, -0.00032354f, -0.02967151f, -0.00692896f, 
    -0.04348381f, -0.03676867f, -0.03116366f, 0.00062307f, -0.00822026f, -0.02320082f, 0.02292065f, -0.03698145f, 
    -0.01657670f, 0.00603640f, 0.02738897f, -0.00377648f, 0.01518773f, -0.00433635f, -0.02309178f, 0.02693611f, 
    -0.00269811f, 0.00869667f, 0.00550162f, -0.03863177f, -0.00674384f, 0.00614708f, -0.00853235f, 0.00556499f, 
    0.00268544f, -0.00703963f, -0.03451094f, -0.00212573f, -0.02728784f, -0.01825669f, 0.00865586f, 0.01198236f, 
    -0.00447079f, 0.01105528f, 0.01576400f, 0.02641372f, 0.00030088f, -0.00101531f, -0.03791720f, -0.02500137f, 
    -0.01218414f, 0.01797027f, -0.01161569f, -0.02479942f, 0.01286561f, -0.00609206f, -0.00911541f, 0.01895261f, 
    -0.02878545f, 0.02391972f, -0.01217432f, -0.01451889f, -0.00693770f, 0.01643030f, 0.01080867f, 0.01307383f, 
    0.01897903f, 0.02807111f, -0.00845909f, -0.02508460f, 0.03794759f, -0.02739046f, 0.02421304f, 0.02062973f, 
    0.02725613f, -0.00054421f, 0.00687356f, -0.03580284f, 0.02536087f, 0.02594614f, -0.03661702f, 0.03056664f, 
    -0.00702951f, -0.03410511f, -0.03816858f, 0.02310391f, -0.01387344f, -0.00863335f, 0.02149247f, -0.02546733f, 
    -0.02317636f, -0.01127350f, -0.02394880f, 0.00123999f, -0.01921048f, -0.01389945f, 0.02726410f, -0.03287899f, 
    -0.03913072f, 0.02535328f, 0.00893420f, 0.02888877f, -0.00236436f, 0.00126587f, 0.01821378f, -0.02987699f, 
    0.02372598f, -0.01063214f, 0.00808854f, -0.03355430f, -0.03808931f, 0.01995837f, -0.02708728f, -0.01516271f, 
    -0.00346400f, -0.01408166f, -0.01006955f, 0.02722478f, -0.02664737f, -0.01197260f, -0.02549159f, -0.02120048f, 
    0.00896846f, 0.00523533f, -0.02152968f, -0.02083738f, 0.02202259f, 0.00213998f, -0.02611190f, -0.01192249f, 
    0.00425857f, 0.00763975f, -0.00727730f, 0.00251658f, 0.01941047f, -0.01308579f, 0.03168077f, -0.02433837f, 
    -0.02591125f, 0.01844266f, -0.02736644f, -0.04361083f, 0.00723376f, 0.01322217f, 0.01687484f, 0.00421379f, 
    0.00138600f, -0.02636969f, 0.01275047f, 0.01540500f, 0.01695868f, 0.00048404f, -0.00640880f, 0.01825415f, 
    -0.02442222f, 0.02872737f, -0.03565245f, -0.00305245f, 0.00140634f, 0.03620442f, -0.01000325f, -0.00407254f, 
    -0.02257164f, -0.02391332f, 0.02393490f, 0.02061579f, 0.01566873f, 0.02141318f, 0.01900295f, -0.00111097f, 
    -0.01950602f, -0.02844870f, 0.01335145f, -0.03856159f, -0.02362674f, -0.01059222f, 0.01283654f, 0.02261762f, 
    0.00236175f, -0.01228192f, -0.01544721f, -0.03604891f, -0.02831517f, 0.00113591f, -0.04019606f, -0.00386414f, 
    0.00958034f, 0.01030937f, -0.02101281f, 0.02237957f, 0.00467649f, -0.02208802f, 0.00204624f, 0.00410595f, 
    -0.02647597f, -0.00077630f, 0.01654800f, 0.01080404f, -0.02638227f, -0.02317352f, 0.01950267f, -0.03496100f, 
    0.01102828f, -0.02015254f, -0.02802824f, 0.01193670f, -0.00318057f, -0.01307349f, -0.03204387f, -0.03291201f, 
    0.01501669f, 0.02717244f, 0.01666646f, -0.01251903f, -0.01830880f, 0.00610699f, 0.00142796f, 0.00081471f, 
    0.03070633f, 0.00769860f, -0.00545470f, -0.02620411f, -0.01295559f, 0.02805636f, 0.00445123f, 0.02429358f, 
    0.02245283f, -0.03144512f, -0.02182606f, -0.02646136f, 0.02922609f, -0.03795113f, 0.01495987f, -0.01656847f, 
    0.00974418f, -0.02252954f, 0.02823277f, -0.00811323f, 0.02548766f, 0.03148723f, -0.00321121f, -0.02639278f, 
    0.02298668f, -0.03304792f, -0.00090456f, -0.00620880f, -0.01847443f, -0.01186130f, 0.01645466f, -0.01255621f, 
    0.01769747f, -0.03787468f, 0.03237640f, 0.00623098f, 0.02641447f, 0.03406357f, 0.02668947f, -0.00991265f, 
    0.01839599f, 0.02418976f, 0.01139651f, 0.00611563f, -0.00465331f, -0.03806936f, -0.01762919f, -0.02446261f, 
    -0.01747736f, -0.00396561f, -0.04104640f, -0.01549406f, -0.00286543f, -0.01408840f, 0.02033384f, -0.02218301f, 
    -0.01237600f, 0.00717027f, -0.01295816f, 0.01114900f, 0.01515755f, -0.03479607f, -0.00207047f, -0.00148496f, 
    -0.02275568f, 0.01869237f, -0.01749448f, -0.01158157f, 0.02207448f, 0.01794829f, 0.00049848f, 0.00289938f, 
    -0.01470364f, -0.04259012f, 0.01568514f, -0.01833994f, -0.03885701f, -0.01788441f, -0.00083321f, 0.01497933f, 
    -0.03972293f, -0.03457771f, 0.02755041f, -0.03513773f, -0.02592643f, -0.02485867f, 0.00476840f, 0.02655643f, 
    -0.00913413f, 0.02753766f, -0.00356795f, 0.00459142f, 0.01607052f, 0.02898116f, -0.00419492f, 0.02641423f, 
    -0.04187115f, 0.00231351f, 0.01953455f, 0.02674416f, 0.00980198f, 0.00581889f, -0.01236955f, -0.03484280f, 
    -0.25560138f, 0.11760149f, 0.02750312f, 0.25099796f, 0.01372750f, -0.08528903f, 0.16860211f, -0.02674023f, 
    -0.11143191f, -0.11483375f, 0.01045840f, 0.00444353f, 0.01592189f, 0.19786426f, -0.05543399f, 0.03577806f, 
    0.08922458f, 0.07174423f, -0.13035385f, -0.04272514f, 0.04221828f, 0.01560265f, 0.16618475f, 0.17575106f, 
    0.66314113f, -0.05045559f, -0.11362092f, -0.16439709f, 0.10037240f, -0.08041807f, 0.10816838f, -0.13744003f, 
    -0.14739831f, 0.04684768f, 0.09948552f, 0.15798633f, -0.73897535f, 0.05772670f, 0.13388523f, 0.31378642f, 
    0.04833713f, 0.01450367f, 0.01723694f, 0.09020487f, 0.00143642f, 0.04088007f, 0.19046028f, 0.14842433f, 
    -0.16016594f, -0.25392422f, 0.33052137f, -0.14494385f, -0.09751276f, 0.19347519f, -0.06264860f, 0.10251088f, 
    0.08326912f, -0.03870817f, -0.01045870f, -0.10128315f, 0.08594581f, -0.01796391f, -0.16282228f, 0.34924456f, 
    0.10326841f, 0.01973426f, -0.02228582f, 0.16059610f, -0.04324616f, 0.05823478f, -0.04851710f, 0.07711266f, 
    0.06195138f, 0.09746321f, -0.07614658f, -0.20476680f, -0.02829809f, -0.00116599f, -0.03735593f, -0.13091351f, 
    0.05188664f, 0.12729427f, 0.14936699f, -0.00649368f, -0.10870930f, 0.12137499f, -0.22927754f, -0.22229439f, 
    -0.05294969f, 0.05884870f, 0.04010281f, 0.03364612f, 0.00003667f, -0.02926261f, 0.00822214f, 0.02212622f, 
    -0.06872091f, -0.15524699f, -0.29963133f, 0.10732616f, -0.00590805f, -0.02687577f, -0.01079688f, -0.07657912f, 
    0.22581527f, 0.15912069f, 0.02214335f, 0.01712907f, -0.00451402f, 0.09990532f, -0.10034104f, 0.04982448f, 
    0.00398915f, -0.00300666f, 0.11483066f, -0.02835887f, 0.04315843f, 0.14402947f, 0.23148076f, 0.17686377f, 
    -0.09200909f, 0.03410807f, -0.08549877f, 0.13036193f, -0.01888540f, 0.02409972f, -0.04626802f, -0.05846375f, 
    -0.01074522f, -0.03953364f, -0.01226136f, -0.02533087f, -0.02783269f, -0.06574556f, -0.17907827f, -0.05792991f, 
    -0.02012198f, 0.03795139f, 0.01327240f, 0.13824108f, 0.04008717f, 0.06917538f, 0.02142578f, 0.04200646f, 
    -0.03839828f, -0.00917662f, 0.40958503f, 0.31160459f, -0.07893280f, -0.05119878f, -0.01624786f, 0.04924206f, 
    -0.00206483f, -0.01426813f, 0.02566441f, -0.01553363f, -0.39133477f, -0.03715289f, 0.28060368f, 0.11677111f, 
    -0.02252849f, 0.12262201f, -0.03889764f, 0.10244197f, -0.14255637f, 0.09833339f, 0.10334098f, 0.01508655f, 
    -0.10417049f, 0.27320403f, 0.11581886f, -0.09642889f, -0.06344372f, 0.03576065f, 0.07178693f, 0.05520245f, 
    -0.04111797f, -0.01721493f, 0.02861613f, 0.03760457f, 0.38957772f, -0.02267148f, -0.14582652f, -0.12250037f, 
    -0.21152359f, -0.11591358f, -0.01994902f, 0.08438408f, -0.07233981f, 0.03787133f, -0.03899305f, -0.16854477f, 
    -0.05563724f, 0.05151188f, 0.15723830f, -0.05169129f, 0.03461408f, 0.03971710f, -0.08041143f, 0.13765116f, 
    -0.10084166f, -0.04751689f, -0.00436544f, -0.03918030f, 0.23538443f, 0.08843654f, 0.23569266f, 0.04642100f, 
    -0.00897953f, -0.16119997f, 0.02701835f, 0.11782274f, -0.01922515f, 0.04019494f, 0.02323337f, -0.14230730f, 
    -0.15096354f, -0.26102453f, 0.05212997f, 0.24689986f, 0.08717998f, 0.24164185f, -0.03482237f, -0.03518005f, 
    0.00186556f, 0.13298176f, 0.07205421f, 0.20167844f, 0.00758713f, 0.00015713f, 0.00344303f, 0.01273492f, 
    -0.06536574f, 0.01186965f, 0.02869776f, -0.06618917f, -0.05530046f, -0.02555723f, -0.11311454f, -0.02247854f, 
    0.18867035f, -0.06719254f, 0.35973221f, -0.03952857f, 0.02699165f, -0.09338670f, -0.02167948f, 0.16133128f, 
    0.16424352f, 0.03301689f, 0.09966076f, 0.02980654f, -0.03464276f, -0.04591815f, 0.00178077f, -0.03823543f, 
    -0.02819090f, -0.01871781f, 0.03379954f, 0.03419431f, -0.00796886f, -0.00206294f, -0.12363797f, 0.00820575f, 
    -0.17925699f, 0.10387714f, 0.10160406f, 0.32071370f, 0.17118140f, 0.10125833f, -0.04466083f, 0.23688202f, 
    -0.01529229f, 0.19242798f, 0.12336937f, -0.07115126f, 0.26373309f, -0.10725951f, 0.21434677f, -0.24839796f, 
    -0.10025558f, -0.06708345f, 0.19175063f, 0.03737999f, 0.11436439f, -0.00137567f, 0.16647567f, -0.00258890f, 
    -0.19713980f, -0.14247575f, 0.34628341f, 0.29159445f, -0.03424596f, -0.02849920f, 0.00049926f, 0.10234270f, 
    -0.14293103f, 0.03078897f, 0.01519617f, 0.10954606f, -0.14541617f, -0.08066271f, 0.23931390f, 0.19308111f, 
    -0.07000072f, 0.05466938f, -0.09722374f, 0.12553976f, -0.05003673f, 0.05264557f, -0.02309356f, -0.19441251f, 
    -0.08345090f, 0.01630371f, -0.07681340f, 0.00585669f, 0.24006379f, 0.09426440f, 0.08008166f, -0.20089336f, 
    0.02176774f, 0.07915212f, 0.08110327f, 0.05209287f, -0.13883428f, 0.29802218f, -0.09086362f, 0.40117481f, 
    0.08705561f, -0.03403880f, -0.08780583f, -0.04110448f, -0.07920830f, -0.06262773f, 0.03188170f, -0.09818406f, 
    0.17257553f, -0.04796608f, 0.11555832f, -0.07603236f, -0.00626605f, 0.13587196f, 0.19190274f, 0.21353376f, 
    -0.12145126f, 0.04597620f, 0.10224340f, -0.08126128f, 0.22729068f, 0.10484900f, 0.03177501f, -0.03740043f, 
    -0.01969105f, -0.10716045f, 0.05008061f, 0.18140547f, 0.05846520f, 0.07172028f, -0.07559977f, -0.08089142f, 
    -0.09677754f, 0.19179489f, 0.42165413f, 0.19322084f, 0.04911237f, -0.06602467f, -0.04460642f, -0.20504227f, 
    0.04230662f, 0.00899589f, -0.10646531f, 0.19097932f, -0.32020634f, -0.14632140f, 0.05817634f, 0.09415840f, 
    -0.00052662f, 0.05912544f, 0.02347448f, 0.09989807f, -0.01330537f, -0.00848333f, 0.14633937f, 0.12340946f, 
    -0.37740582f, 0.22964610f, 0.07154886f, 0.25903043f, 0.04476733f, 0.06224402f, 0.05425912f, 0.11536525f, 
    -0.03457782f, -0.00130971f, 0.06925160f, 0.23113291f, 0.05118749f, 0.22149281f, -0.12556688f, 0.15758255f, 
    0.03425043f, 0.07916933f, 0.07390406f, -0.12956695f, -0.09313895f, -0.08345044f, 0.25361082f, 0.07696551f, 
    -0.38154528f, 0.03776760f, 0.01552435f, 0.09018455f, 0.08730314f, -0.12664828f, 0.12372639f, 0.15986265f, 
    0.00798013f, 0.02925271f, 0.11175281f, 0.09431226f, 0.33799651f, -0.00314498f, -0.15836169f, -0.13605124f, 
    -0.01282021f, 0.04413985f, 0.10376442f, 0.01199044f, 0.02092480f, 0.06304660f, 0.15622310f, 0.09053043f, 
    -0.06759003f, -0.05494761f, 0.63481766f, 0.01222675f, 0.23098493f, 0.02008248f, 0.21389139f, -0.02803832f, 
    -0.13228305f, 0.01808839f, -0.00520332f, 0.03722229f, 0.02975422f, 0.03098489f, 0.14187169f, 0.18223685f, 
    -0.04014119f, 0.11754312f, -0.13679695f, -0.07437075f, 0.02437908f, 0.04571209f, 0.07592581f, -0.00122554f, 
    -0.00361863f, -0.05759287f, -0.07201292f, -0.07986388f, -0.06290357f, 0.06387639f, -0.10782211f, -0.07193778f, 
    0.20732267f, 0.20107095f, -0.04641705f, 0.33622566f, -0.11384463f, -0.18689209f, 0.38347536f, 0.37108403f, 
    -0.11513970f, -0.12425668f, 0.14577714f, -0.08180438f, -0.20176415f, 0.04919480f, -0.13508356f, 0.21556695f, 
    -0.17672861f, 0.10574250f, -0.25777540f, 0.23360310f, -0.05198101f, 0.10523284f, -0.04100904f, -0.03446403f, 
    -0.00107917f, -0.04594262f, 0.04165583f, 0.11187723f, 0.01531263f, 0.24098746f, 0.01403588f, -0.09016269f, 
    -0.01491184f, -0.07743710f, 0.07043006f, -0.01109090f, 0.01680415f, 0.07053783f, -0.13909881f, -0.06420580f, 
    0.09417655f, -0.23951070f, 0.20725827f, -0.09914348f, -0.00282021f, -0.03283420f, 0.17718746f, 0.01626496f, 
    0.08878840f, -0.01872560f, -0.05147901f, -0.01423931f, -0.08217258f, -0.32693246f, 0.16836365f, 0.01795452f, 
    0.12712832f, -0.08733209f, -0.12136759f, -0.05306664f, 0.17066394f, 0.17212391f, 0.15518148f, -0.06398869f, 
    -0.12317814f, -0.20937170f, 0.06066770f, 0.18140571f, 0.02914535f, 0.09031110f, -0.07815139f, -0.09339572f, 
    0.07826284f, 0.08568578f, 0.03039373f, -0.11775653f, 0.33146998f, 0.01999214f, -0.12339845f, -0.00375980f, 
    -0.00712910f, 0.04094849f, -0.01327365f, -0.09997807f, -0.03829456f, 0.04758717f, -0.02198751f, 0.17841320f, 
    -0.18213500f, 0.24986285f, -0.01400565f, 0.09171184f, -0.03302126f, 0.14431362f, 0.13970181f, 0.08525871f, 
    0.06872796f, -0.03061925f, -0.00349955f, 0.10329306f, 0.26808503f, -0.01233209f, -0.04285743f, -0.03520232f, 
    0.08187685f, -0.13164429f, 0.04168275f, -0.10568033f, -0.09977769f, 0.05540474f, 0.14178066f, 0.14402832f, 
    -0.08827219f, -0.10682364f, -0.20487145f, -0.20385312f, 0.01691709f, -0.01290484f, -0.00326690f, -0.10232431f, 
    0.03406042f, 0.13325341f, 0.00408419f, 0.10941392f, -0.04712390f, 0.08884677f, 0.11732458f, 0.46369722f, 
    0.02902658f, -0.00585992f, -0.08675520f, 0.14757299f, 0.04630679f, -0.15423875f, -0.11177352f, 0.02673134f, 
    0.55150312f, 0.02384139f, 0.21501100f, -0.01180648f, -0.18512280f, -0.17011352f, 0.20385288f, 0.02890174f, 
    -0.00319735f, 0.09643026f, -0.02744543f, 0.10474972f, 0.19549860f, -0.10975344f, -0.01549496f, 0.08126511f, 
    -0.04438521f, -0.05757688f, 0.01585956f, -0.15394063f, 0.08665409f, 0.04121897f, 0.06877711f, 0.05013610f, 
    -0.49866921f, 0.42234796f, 0.19984457f, 0.29752505f, 0.12526827f, 0.15148313f, -0.11292613f, 0.04802448f, 
    0.02470363f, -0.16824532f, -0.00299075f, -0.05841281f, 0.11689241f, -0.03640038f, -0.05595894f, -0.09208837f, 
    0.05421907f, 0.00214028f, 0.05242597f, 0.13140024f, -0.02229803f, 0.10092516f, -0.06778710f, -0.11456902f, 
    -0.18869542f, -0.10886817f, 0.27212122f, 0.10390028f, 0.00646302f, -0.01062383f, 0.10625460f, -0.00818424f, 
    0.06794641f, 0.16343626f, 0.16361754f, -0.01993060f, -0.07378743f, 0.06108872f, 0.53301132f, -0.15894215f, 
    -0.01404795f, 0.19791165f, 0.09424963f, 0.13260560f, -0.04247278f, -0.03399365f, 0.07687134f, -0.06972363f, 
    0.08177558f, -0.25885528f, 0.01359794f, -0.10311398f, -0.04023926f, -0.22863887f, 0.02401799f, 0.03045772f, 
    0.00940777f, 0.08032639f, 0.07339747f, 0.04342970f, -0.18376140f, 0.19258836f, 0.15617947f, 0.32668620f, 
    0.01806907f, -0.08003604f, -0.03386495f, 0.39515281f, -0.04751199f, -0.07090084f, -0.03129099f, -0.01030447f, 
    -0.15513316f, 0.09563279f, -0.20124416f, 0.24806805f, -0.18860684f, -0.08862486f, 0.02854768f, 0.06554864f, 
    -0.07061312f, 0.03312419f, -0.03531243f, -0.04667154f, -0.04630909f, 0.17656051f, -0.11024556f, -0.19574916f, 
    -0.05465783f, 0.13692600f, 0.08049440f, -0.08759028f, -0.00706080f, 0.07521801f, -0.07232542f, -0.06134648f, 
    -0.40339884f, 0.17536971f, 0.04647308f, -0.04934967f, -0.03486919f, 0.07022790f, 0.03079132f, -0.04689454f, 
    0.12645258f, -0.00121270f, 0.06753156f, -0.05619302f, 0.03236954f, -0.11211944f, 0.13720919f, 0.31166294f, 
    0.07245088f, -0.07428391f, 0.04994448f, 0.00389341f, 0.04926047f, 0.00352346f, -0.04633258f, 0.00397561f, 
    -0.06723052f, 0.02021064f, -0.13313062f, -0.14667784f, -0.00611875f, -0.02521527f, 0.06807294f, 0.04881322f, 
    0.06314996f, 0.20777102f, -0.03891957f, -0.11096482f, 0.07067819f, 0.00336217f, -0.05203059f, 0.07488568f, 
    -0.00266162f, 0.06824239f, 0.11212407f, -0.02972340f, -0.18182102f, -0.03266698f, 0.13516751f, 0.02937561f, 
    -0.01834554f, 0.13165763f, 0.12705608f, 0.05337768f, -0.04875817f, -0.02696306f, 0.03286823f, -0.03527160f, 
    0.12622505f, 0.14687856f, 0.01022359f, -0.01593524f, 0.10745216f, 0.13825352f, -0.31902838f, -0.18894264f, 
    -0.01695499f, -0.05860866f, -0.15543623f, 0.03045547f, -0.02193425f, 0.24441010f, 0.03492831f, 0.07350863f, 
    0.31816408f, -0.07923318f, -0.09655311f, 0.01508645f, 0.06459285f, -0.06781742f, -0.01025854f, -0.03573649f, 
    0.03571143f, -0.06725882f, 0.02379289f, 0.18114384f, -0.08134566f, 0.41964743f, 0.31375521f, -0.06354447f, 
    0.07037372f, 0.05135769f, 0.00554677f, -0.02648427f, 0.05651231f, 0.09234151f, 0.25394809f, 0.13359396f, 
    -0.21139501f, -0.27824566f, 0.04290560f, 0.03372580f, 0.12019539f, 0.04249161f, -0.10742947f, 0.05885328f, 
    0.01778265f, -0.01288773f, -0.05232980f, 0.02047762f, -0.04524159f, -0.11039838f, 0.15018883f, 0.04770960f, 
    -0.07511991f, -0.09357670f, 0.13848692f, 0.09887963f, -0.05332808f, 0.16211231f, 0.06329385f, 0.08085430f, 
    0.63578320f, 0.05374459f, 0.14864248f, -0.11768965f, 0.00225472f, 0.05440698f, -0.05315090f, -0.03698563f, 
    0.04275299f, -0.00564686f, 0.06182750f, -0.15561019f, 0.16032214f, 0.04563037f, -0.02694796f, -0.10963722f, 
    -0.01488757f, -0.06066839f, 0.00291516f, -0.00993273f, 0.13976476f, 0.04970536f, -0.19319308f, -0.09112906f, 
    -0.24664432f, -0.18181299f, -0.01395213f, 0.16764888f, -0.03529639f, 0.14497823f, 0.09701084f, -0.02318034f, 
    -0.00744580f, 0.06887147f, 0.05830699f, 0.21870519f, 0.22355446f, -0.06222088f, -0.05895830f, -0.09057172f, 
    0.09395301f, 0.02860363f, -0.05369511f, 0.05722398f, 0.04907181f, -0.07738518f, 0.10027508f, 0.12507862f, 
    -0.33319166f, -0.26048779f, -0.03638859f, 0.27647197f, -0.02656067f, 0.00429795f, -0.07204375f, -0.02729664f, 
    -0.05660753f, -0.05678948f, -0.07458653f, -0.01737347f, -0.30233186f, -0.19004650f, -0.18347260f, 0.17061894f, 
    -0.03808933f, -0.00126343f, -0.02719406f, 0.00863078f, -0.05073000f, -0.08513244f, -0.11686119f, -0.05632612f, 
    -0.23198062f, 0.50539708f, 0.41623488f, 0.07512589f, -0.02054117f, -0.07989670f, -0.03392443f, -0.05389090f, 
    0.15222010f, 0.00916131f, 0.24225475f, 0.07694960f, -0.00136901f, 0.13678791f, -0.10958940f, 0.04464891f, 
    0.08786707f, -0.07273968f, 0.12515692f, 0.00616214f, 0.13223851f, 0.25458586f, 0.10346701f, 0.03701907f, 
    -0.05906434f, 0.32623234f, 0.12628205f, 0.03573721f, 0.11670861f, -0.00682722f, -0.06757784f, -0.03862139f, 
    -0.01317720f, -0.00721564f, 0.01792554f, 0.00709148f, 0.40138310f, 0.25456384f, -0.15783915f, -0.15092444f, 
    -0.17590031f, 0.04859715f, 0.04917672f, 0.04486191f, -0.04271027f, 0.08265153f, 0.07659618f, 0.00171199f, 
    -0.02131030f, -0.04037276f, 0.05360209f, -0.00531666f, 0.01711785f, -0.06688777f, 0.04784096f, 0.10927368f, 
    0.07227086f, -0.04947614f, -0.02192451f, -0.06634416f, 0.06304117f, 0.09718178f, 0.22408177f, 0.16418643f, 
    -0.10947955f, -0.19169620f, 0.09341872f, 0.04009887f, 0.10100710f, 0.15134017f, 0.05826684f, 0.11255576f, 
    -0.33147237f, -0.22993530f, 0.12040671f, 0.19369800f, 0.14707749f, 0.08755507f, -0.06747480f, -0.01367853f, 
    -0.14301257f, 0.00255156f, 0.00692140f, 0.11506241f, -0.22627389f, -0.21364862f, -0.11320298f, 0.01161861f, 
    0.03312786f, 0.04770629f, -0.01126678f, -0.08680259f, 0.03709181f, -0.02478884f, -0.05624132f, -0.04851061f, 
    -0.12318527f, 0.15517223f, 0.03996850f, 0.20422707f, -0.09041250f, -0.16833197f, 0.17174840f, 0.01877273f, 
    -0.00780554f, 0.26440021f, -0.00472444f, 0.18287989f, 0.09579260f, 0.01209963f, -0.05418468f, -0.04913917f, 
    0.12661578f, -0.00689603f, 0.08789406f, -0.03449229f, 0.06666999f, 0.06248166f, -0.03213099f, -0.02591308f, 
    -0.22335900f, 0.04452650f, -0.04701504f, 0.09162772f, -0.03865654f, 0.01181882f, 0.12659627f, -0.15213451f, 
    0.06038095f, 0.00104039f, 0.13265754f, 0.05695239f, 0.65444958f, -0.01464702f, -0.04288397f, -0.08207490f, 
    -0.23607211f, 0.16680886f, 0.09558335f, 0.01567932f, 0.03123077f, 0.00894085f, 0.08521976f, 0.08494505f, 
    0.13917719f, 0.33960977f, 0.21965961f, -0.04579803f, 0.11271106f, -0.05649867f, -0.07042121f, 0.03778188f, 
    0.18204962f, 0.09487423f, 0.27522993f, 0.01615995f, -0.39517248f, -0.06112393f, 0.31651852f, 0.10838681f, 
    -0.01614287f, -0.12044119f, 0.07787224f, 0.02552969f, -0.08849233f, -0.19648682f, 0.03343005f, 0.11673331f, 
    0.28426230f, -0.20519902f, -0.17190790f, 0.11214484f, 0.08590011f, 0.05123114f, -0.11278865f, 0.02459054f, 
    0.09949970f, 0.00643287f, 0.08543992f, 0.09764780f, -0.17890443f, -0.05535458f, 0.23228709f, 0.20403406f, 
    0.09150425f, 0.06367689f, 0.07109035f, 0.03487181f, -0.06140865f, 0.07146647f, -0.00812396f, -0.05079084f, 
    0.04361981f, -0.05788311f, -0.11775865f, 0.13166422f, 0.08024714f, -0.19771589f, 0.09989716f, 0.02705476f, 
    0.07306784f, 0.03570016f, 0.04410186f, 0.01422384f, 0.17795072f, 0.03495067f, 0.09210309f, 0.09353291f, 
    -0.02782167f, -0.02379441f, -0.07823241f, 0.06960393f, 0.10050087f, -0.06891855f, 0.10435752f, 0.08688718f, 
    0.03344947f, -0.08830532f, 0.11572881f, 0.09707081f, 0.04691685f, 0.12564486f, -0.00873982f, 0.00788162f, 
    0.12067029f, 0.04424367f, 0.07868183f, 0.14774711f, 0.22741526f, 0.28193012f, -0.11172982f, 0.02131170f, 
    -0.01354859f, 0.03038792f, -0.08468008f, 0.02163386f, 0.07386164f, 0.09059688f, 0.31239551f, -0.08381612f, 
    0.01413336f, 0.09110408f, -0.02978332f, 0.00851306f, 0.08087927f, 0.05128197f, -0.04144151f, 0.00960772f, 
    0.07991431f, 0.00341182f, 0.13783810f, -0.00110798f, 0.27495971f, -0.19352235f, -0.43689185f, -0.17865781f, 
    -0.00456785f, -0.10390673f, -0.02416626f, -0.10210975f, 0.02624632f, 0.02628529f, -0.20549144f, 0.00063074f, 
    -0.36655471f, -0.04497950f, -0.11913770f, 0.06814990f, -0.09865279f, 0.02618413f, 0.18176433f, -0.03086638f, 
    0.04375985f, 0.02750186f, 0.19676185f, 0.06278618f, 0.37857351f, 0.00738996f, -0.25371787f, 0.02395648f, 
    -0.10264757f, -0.04115388f, 0.00876501f, 0.13320252f, 0.05377066f, 0.06435600f, 0.11902173f, -0.04424949f, 
    0.23125380f, 0.17147096f, 0.27830863f, -0.11729975f, 0.18908544f, -0.09759410f, 0.22104736f, -0.07504050f, 
    0.05053789f, 0.01601488f, 0.03422481f, -0.01172147f, -0.13475330f, -0.19925371f, 0.19914718f, 0.23281984f, 
    0.04233297f, -0.03100478f, -0.13715041f, 0.06885538f, -0.00404854f, -0.03847947f, -0.06961896f, -0.03892176f, 
    0.17874940f, 0.07712728f, 0.07707707f, -0.15337476f, -0.05814418f, -0.01714444f, -0.01030523f, -0.04531195f, 
    0.33534637f, 0.22367083f, 0.03655018f, 0.05479702f, -0.02977842f, 0.37156838f, 0.23932847f, 0.02084588f, 
    0.05246340f, 0.02202702f, 0.08280865f, -0.07590567f, 0.18758006f, 0.10889025f, 0.05772856f, 0.10015411f, 
    -0.27738321f, -0.25521326f, -0.00294071f, 0.38458845f, -0.08792787f, 0.07854451f, -0.16202982f, 0.18919797f, 
    -0.04883294f, -0.04621761f, 0.00375845f, 0.06549803f, 0.26270732f, -0.05276511f, 0.03072144f, 0.05990706f, 
    -0.02703218f, -0.03218827f, 0.04609811f, -0.05528532f, 0.03800017f, 0.00245413f, 0.09147907f, 0.17118408f, 
    0.06588586f, 0.03326510f, -0.23330681f, 0.00398469f, -0.04471057f, 0.12133733f, -0.02064730f, -0.01946834f, 
    -0.11227997f, -0.08953081f, 0.09687524f, 0.07380868f, -0.25258568f, -0.25620461f, 0.01464005f, 0.04983172f, 
    -0.04935388f, 0.04456031f, 0.08620493f, 0.03830443f, -0.09910214f, 0.14156760f, 0.16152573f, -0.00552722f, 
    -0.36467999f, -0.24269217f, -0.01542533f, 0.20982221f, 0.18569525f, 0.12237176f, 0.03362291f, 0.03366147f, 
    0.05664894f, -0.17481740f, 0.04731359f, 0.04112061f, 0.40743729f, 0.14320214f, -0.21889123f, -0.09803636f, 
    0.01206371f, 0.03480830f, -0.04120740f, -0.03759127f, -0.15336722f, 0.17747897f, 0.06360288f, 0.11802192f, 
    0.12975956f, 0.20558713f, 0.16342758f, -0.00681586f, 0.05481242f, 0.02199439f, -0.04609392f, -0.01219708f, 
    0.15115117f, 0.06564198f, 0.07693566f, 0.08252244f, 0.23199432f, -0.18307117f, 0.05625438f, -0.00148296f, 
    0.03753811f, -0.08012933f, -0.03121135f, -0.13066721f, 0.02039631f, -0.02893274f, 0.07684454f, 0.13822383f, 
    0.06950123f, -0.02609662f, -0.06732202f, -0.09298122f, 0.02535400f, -0.06540684f, -0.04169472f, -0.08975284f, 
    0.01815088f, 0.14647159f, -0.16528659f, -0.16884184f, 0.18338889f, 0.16956183f, 0.36269504f, -0.22467390f, 
    0.15600672f, 0.03263408f, 0.14395787f, -0.04693240f, 0.11595501f, 0.09475913f, 0.03900624f, 0.01338992f, 
    0.33903813f, 0.12683733f, -0.04621733f, -0.05000029f, 0.03506236f, -0.17407024f, 0.22284430f, 0.15379541f, 
    0.01234990f, 0.10033879f, 0.01089690f, 0.12997711f, -0.06161030f, -0.25330016f, 0.15513529f, 0.11608362f, 
    0.14322826f, -0.02053566f, 0.06036224f, -0.13821377f, 0.02240260f, 0.08729094f, -0.04193537f, 0.05323818f, 
    -0.22908697f, -0.00214288f, 0.23603120f, 0.06808660f, 0.10507579f, 0.05505332f, -0.00743341f, -0.03243154f, 
    0.01063833f, 0.04438498f, 0.17855528f, -0.02114617f, 0.02532364f, -0.10300833f, -0.10384527f, -0.09721685f, 
    -0.19507571f, -0.08144594f, 0.15405436f, 0.18737352f, 0.00219894f, -0.09089200f, 0.03606003f, -0.07142377f, 
    -0.17176548f, -0.08482996f, 0.27564412f, 0.03645929f, 0.11938341f, -0.09120499f, -0.02500355f, -0.02401486f, 
    -0.03242488f, 0.04764013f, 0.11432987f, 0.09828290f, -0.16948013f, -0.03460221f, 0.26275912f, -0.07094605f, 
    0.07398318f, 0.10920607f, 0.19379583f, -0.05002055f, 0.03641870f, -0.04428576f, -0.00173165f, 0.00855864f, 
    -0.13545242f, -0.17295381f, 0.00037521f, 0.23536287f, 0.02544969f, -0.12166237f, 0.04877738f, -0.00064685f, 
    -0.08926829f, -0.03213945f, 0.00606881f, -0.00890580f, -0.26741654f, 0.05407756f, -0.09067059f, 0.29512686f, 
    0.12596525f, -0.12813342f, -0.02861963f, -0.13241616f, 0.00779771f, -0.06650592f, -0.04630424f, -0.00343164f, 
    -0.28615987f, -0.21830468f, 0.02177482f, 0.12178407f, 0.01856593f, 0.07705992f, 0.06060034f, -0.01039397f, 
    -0.08689810f, -0.04878774f, -0.09873879f, 0.03121169f, 0.17209166f, 0.01960013f, -0.01115200f, -0.10340732f, 
    0.01766267f, 0.05887487f, -0.02590260f, 0.05051809f, 0.06904802f, 0.03691860f, -0.04305831f, -0.00242909f, 
    -0.11681233f, 0.32030994f, -0.22315018f, -0.00594203f, 0.01584470f, 0.01209720f, -0.11202102f, -0.05637350f, 
    0.02197487f, -0.05225707f, 0.11808333f, 0.01654477f, -0.22395834f, -0.04006481f, 0.20196362f, 0.12063269f, 
    0.07657170f, -0.17008513f, 0.01015878f, 0.00579521f, 0.12759666f, 0.04222876f, 0.02461717f, -0.00779337f, 
    0.01778938f, 0.03471975f, 0.05816091f, -0.03607299f, 0.07180423f, 0.04725442f, -0.03765173f, -0.02428374f, 
    0.13402730f, 0.03772035f, -0.06485480f, 0.03384575f, 0.00339667f, 0.12529567f, -0.15143093f, 0.07830942f, 
    0.12143566f, -0.15539993f, 0.15072973f, 0.04649088f, 0.06909442f, 0.23370752f, 0.02617064f, -0.07104160f, 
    -0.02449506f, -0.26377946f, -0.13336459f, 0.07262219f, 0.05904142f, 0.16754305f, -0.10702452f, 0.11644336f, 
    -0.03220349f, -0.03046151f, -0.11596130f, -0.05211083f, -0.07013105f, -0.08607892f, -0.06247423f, -0.13995974f, 
    -0.07404445f, -0.08581005f, -0.00589154f, 0.04566488f, -0.07689792f, 0.01031457f, 0.10849586f, -0.04178058f, 
    -0.28735000f, -0.16606124f, -0.18418968f, -0.06281499f, -0.05516239f, -0.01125658f, -0.18661262f, 0.00867049f, 
    -0.06632533f, 0.01999279f, -0.04560954f, -0.05464960f, 0.20817100f, 0.00772485f, -0.09917525f, -0.01123611f, 
    0.03452843f, -0.00096348f, -0.07773416f, 0.06134659f, 0.33608583f, -0.00949418f, -0.04483881f, -0.11763275f, 
    -0.02205052f, -0.32357955f, -0.16486053f, -0.24367964f, -0.04671988f, -0.09558690f, -0.07615247f, -0.14015557f, 
    -0.12617274f, 0.07949705f, 0.11781051f, 0.04353768f, -0.32818449f, -0.13981257f, -0.00832334f, 0.00804720f, 
    -0.16810331f, 0.07217809f, -0.14098348f, -0.11311628f, 0.09281529f, 0.05742823f, 0.06076277f, 0.09726960f, 
    0.29056025f, 0.04402311f, -0.14694029f, 0.15444323f, 0.00547233f, 0.02174369f, 0.08985425f, 0.09226336f, 
    -0.04407946f, 0.05160975f, 0.07244334f, 0.13587253f, 0.04842358f, 0.04469422f, 0.14399907f, 0.09281981f, 
    0.05958466f, -0.01667866f, -0.02692831f, 0.07626725f, -0.01953586f, -0.00718627f, 0.10312469f, 0.16425544f, 
    -0.01835407f, -0.05680293f, -0.17470093f, 0.03182858f, 0.02946452f, 0.06033175f, -0.08772132f, -0.11457660f, 
    -0.06394339f, 0.00785748f, 0.01568826f, -0.01436026f, -0.04356753f, 0.29414403f, -0.12161733f, 0.21933085f, 
    -0.03489440f, 0.00136210f, 0.01634421f, 0.13892357f, -0.00781492f, 0.03054589f, 0.12403927f, 0.16181946f, 
    0.01890773f, -0.01940068f, -0.20706983f, -0.22458361f, 0.17706461f, 0.07137939f, 0.02321086f, -0.15159571f, 
    -0.02823085f, 0.01755547f, 0.04247067f, 0.10482851f, -0.16321604f, -0.41857374f, -0.45605776f, -0.11610930f, 
    -0.10191499f, -0.02155128f, 0.04467238f, -0.23790362f, -0.02360172f, -0.05255360f, 0.03627930f, -0.00522021f, 
    -0.07277915f, -0.01579393f, 0.06024287f, -0.05624198f, 0.02096700f, 0.11637924f, -0.04157964f, 0.10686718f, 
    0.00015061f, -0.05845260f, -0.11656487f, -0.05283026f, 0.16035531f, 0.15251689f, 0.04725572f, 0.08226496f, 
    0.02728334f, -0.14212681f, -0.15373100f, 0.00325517f, 0.20794149f, -0.01525057f, 0.03690227f, 0.13559440f, 
    0.03759800f, -0.08661173f, 0.23870230f, 0.11567458f, 0.09418806f, 0.07424325f, -0.00195521f, -0.05114764f, 
    0.08208393f, -0.01835205f, -0.02106736f, 0.08335967f, 0.13064918f, 0.07127310f, -0.11842975f, 0.02376935f, 
    0.06572501f, 0.02622244f, 0.07827533f, 0.05793873f, -0.01452334f, 0.07113910f, 0.02809855f, -0.00656933f, 
    0.00069742f, -0.03327115f, -0.00048295f, 0.17529258f, 0.06791616f, 0.07759058f, -0.11251426f, -0.09309406f, 
    0.04001675f, 0.11189495f, 0.00665016f, 0.06687986f, -0.32777527f, -0.12120719f, -0.06066474f, 0.02715980f, 
    -0.07105536f, 0.26741853f, 0.05293910f, 0.01193080f, 0.09408113f, 0.04655254f, -0.00467032f, 0.03431809f, 
    0.04674692f, -0.02027585f, -0.33454585f, -0.03429424f, 0.11945864f, 0.01924519f, 0.01074421f, -0.20719129f, 
    0.02098968f, -0.07185978f, 0.13441980f, 0.03516590f, -0.06901815f, -0.16230778f, -0.08762590f, -0.06912985f, 
    -0.00945780f, -0.04599990f, 0.00924409f, -0.07785900f, -0.12472105f, -0.04870198f, 0.03679666f, 0.01990078f, 
    -0.05894288f, -0.28235894f, -0.11663117f, 0.03157848f, -0.01986168f, 0.12362076f, 0.02259798f, 0.14034869f, 
    0.13160540f, 0.07709268f, 0.10668426f, 0.03019858f, 0.00805080f, 0.08221984f, 0.02075727f, 0.11888453f, 
    0.13822874f, 0.01117813f, 0.06697926f, 0.05966075f, -0.06840918f, -0.01620314f, 0.09264177f, 0.02902208f, 
    0.24544698f, 0.17146134f, 0.07353713f, -0.12095585f, 0.04075080f, 0.04589935f, 0.05742689f, -0.02838589f, 
    0.10453889f, -0.03481421f, -0.01422110f, 0.05519454f, 0.20133658f, -0.01747866f, 0.05431454f, 0.09663036f, 
    -0.02703013f, -0.00946265f, 0.07491215f, 0.10770573f, 0.06114620f, -0.00164086f, 0.07278002f, -0.10916539f, 
    0.23146728f, -0.14486547f, 0.00827149f, -0.04464479f, 0.20811124f, 0.02747150f, -0.20066546f, 0.06633882f, 
    -0.00648506f, -0.00115804f, -0.06207434f, 0.07741490f, 0.23398794f, -0.01148556f, -0.13945422f, -0.16499242f, 
    -0.09150664f, -0.06790169f, -0.10705506f, -0.12885793f, 0.17671137f, 0.00696577f, -0.03299577f, 0.03530446f, 
    -0.13217773f, 0.02845163f, -0.07100240f, 0.24330138f, -0.04214418f, -0.14209405f, 0.08536445f, 0.04930417f, 
    0.05254456f, 0.09924534f, 0.05574517f, -0.04113375f, -0.09897061f, 0.00688838f, -0.15665664f, 0.18135180f, 
    0.11519199f, -0.03700839f, 0.06478388f, 0.03202030f, 0.04149043f, 0.16385838f, 0.08178544f, 0.05932416f, 
    -0.08408249f, -0.05020571f, -0.08825805f, 0.07515244f, -0.06894974f, -0.18526852f, -0.19015664f, -0.13207002f, 
    0.03401492f, 0.01956620f, 0.10209616f, -0.05900259f, -0.46378174f, -0.09996825f, -0.01873481f, 0.01620967f, 
    0.02219168f, 0.05211324f, 0.09088872f, 0.01073540f, -0.11216963f, 0.08014726f, -0.02900044f, -0.05283834f, 
    0.03697174f, -0.31563261f, 0.09148994f, 0.21924867f, 0.06578549f, 0.16440715f, 0.05953483f, -0.09786776f, 
    -0.25174439f, -0.12689242f, -0.04245770f, -0.06827338f, 0.19003642f, -0.03312001f, -0.07876939f, -0.04272658f, 
    0.05078956f, 0.00456580f, 0.05722781f, -0.11107523f, 0.15545850f, -0.18221016f, -0.00650757f, -0.09275071f, 
    0.10620899f, -0.08891491f, -0.24113831f, 0.11068780f, 0.00798386f, 0.05933754f, 0.08253558f, -0.04343413f, 
    0.19924565f, 0.04849800f, 0.07819555f, -0.16101637f, 0.35662273f, 0.23511046f, -0.09509721f, 0.17996979f, 
    0.04650703f, 0.03993543f, 0.01809532f, 0.01035884f, 0.00620119f, 0.06797860f, 0.13591376f, 0.03288173f, 
    0.16688494f, -0.50689173f, -0.35718170f, -0.37763378f, 0.05207595f, 0.14456430f, 0.02844640f, -0.13565855f, 
    -0.08260268f, 0.17760609f, 0.02266405f, 0.00828906f, 0.20634805f, 0.31475633f, -0.07025512f, 0.08373892f, 
    0.11398557f, -0.05866942f, 0.17732528f, 0.10755461f, 0.03449214f, 0.09460722f, 0.08086377f, 0.10630299f, 
    0.41754061f, -0.01790345f, 0.04123445f, -0.03270405f, -0.22882041f, 0.16243857f, 0.01909013f, -0.02353211f, 
    -0.09380028f, -0.10618024f, 0.02242747f, -0.02547136f, -0.14681359f, -0.17666768f, -0.17429161f, -0.01573029f, 
    0.08101745f, -0.01250113f, -0.08710335f, -0.13136084f, 0.00450626f, 0.06722382f, 0.05963596f, 0.14881204f, 
    -0.05093905f, 0.01326808f, -0.00211140f, 0.09405256f, -0.01756479f, 0.04624170f, -0.00380779f, -0.02487421f, 
    -0.10503586f, -0.03081994f, 0.03289439f, -0.15287629f, 0.15093344f, 0.35667601f, -0.02249013f, 0.38493285f, 
    0.28897673f, 0.03548582f, -0.12391421f, 0.13159928f, 0.20128322f, -0.01437098f, 0.04762121f, 0.09157967f, 
    0.05037721f, 0.07408670f, -0.15636377f, 0.03300519f, 0.00694313f, 0.03044938f, 0.03453620f, -0.08239406f, 
    -0.02164378f, 0.04921512f, -0.01772564f, -0.01487239f, -0.38154784f, 0.02840696f, -0.10933433f, -0.00424856f, 
    -0.01486314f, 0.02262537f, 0.12444068f, 0.08580705f, -0.04313217f, 0.10595542f, -0.02579453f, -0.07380278f, 
    0.09811784f, 0.14050646f, -0.03015615f, 0.17116800f, 0.02170924f, -0.02046399f, 0.11659513f, 0.06279448f, 
    0.13000558f, 0.00372954f, 0.03410944f, -0.03068509f, -0.03021688f, 0.02707367f, -0.33327004f, -0.26189554f, 
    0.03160028f, 0.00982946f, 0.04985728f, -0.14921233f, -0.05106740f, 0.16569830f, 0.09235184f, 0.06631550f, 
    0.25218844f, 0.13738206f, -0.01811147f, -0.33135256f, -0.20836881f, -0.11004037f, -0.20268343f, -0.11107807f, 
    -0.02138285f, -0.04857450f, -0.14450794f, 0.04070153f, -0.08385851f, -0.11592684f, -0.11797317f, 0.07831191f, 
    0.00172586f, -0.03741797f, 0.07615460f, 0.11285432f, 0.02038211f, 0.18716730f, 0.12325656f, -0.01536947f, 
    0.13292710f, 0.11242795f, 0.06002904f, 0.09102487f, 0.07754256f, 0.07832421f, -0.08246194f, -0.02004846f, 
    -0.17335905f, 0.04812998f, -0.07604862f, -0.07202870f, -0.34680688f, 0.01491259f, -0.09375079f, -0.04448462f, 
    -0.05444008f, 0.08835086f, 0.07158333f, -0.02376337f, -0.03061691f, 0.12133853f, -0.06844475f, -0.02245109f, 
    -0.10483942f, -0.03441342f, -0.04574423f, 0.05441625f, -0.05800218f, -0.05318597f, 0.06796657f, 0.08979008f, 
    -0.04692550f, 0.14781813f, 0.13876531f, -0.01220166f, 0.22895806f, -0.10704933f, -0.01396330f, 0.12130822f, 
    0.14609461f, -0.02954353f, 0.11309715f, 0.04941512f, 0.09889688f, 0.16292891f, 0.02424455f, -0.04452316f, 
    -0.04763094f, -0.44172460f, 0.01019361f, -0.25735331f, 0.09100194f, -0.10170794f, -0.26108521f, 0.08369506f, 
    -0.05383848f, 0.03696840f, -0.10319722f, -0.08367928f, -0.45866242f, -0.62361896f, -0.16995561f, -0.14877883f, 
    0.10963785f, -0.16918494f, -0.02781506f, -0.20309441f, 0.00325659f, 0.03972607f, 0.05886775f, -0.03013953f, 
    0.07472920f, -0.07976764f, -0.11875842f, 0.12701192f, -0.05643226f, -0.04419488f, -0.07211639f, -0.02902815f, 
    0.13877438f, 0.08150622f, 0.12482422f, -0.01343543f, 0.02821030f, 0.01357687f, -0.00686646f, 0.05806012f, 
    0.13001642f, -0.01831469f, -0.00198215f, -0.14966485f, -0.09852684f, 0.03381799f, 0.09978084f, 0.08093774f, 
    0.14959374f, -0.26194251f, -0.28569975f, -0.25132418f, -0.13138391f, 0.11785398f, -0.02483777f, -0.05430840f, 
    -0.03542500f, 0.01850378f, 0.06497330f, 0.07035338f, 0.34982777f, -0.20870051f, 0.03716031f, 0.00366338f, 
    0.02186681f, 0.25953767f, 0.07760499f, -0.13513879f, -0.08657093f, 0.00506675f, -0.03271979f, 0.15787618f, 
    -0.22669283f, -0.44121677f, -0.24297884f, -0.16931611f, -0.04964498f, -0.08108003f, 0.11437915f, -0.08120559f, 
    -0.01069974f, 0.03316612f, 0.00846441f, 0.06452361f, 0.47586223f, -0.21061899f, -0.12428985f, 0.07538629f, 
    0.02450991f, 0.22312675f, -0.08464302f, -0.01641149f, 0.10924781f, 0.07754557f, 0.01615044f, 0.12220453f, 
    -0.10939137f, -0.02330345f, -0.32010660f, -0.05665659f, 0.06666540f, -0.03315750f, -0.02478522f, -0.11637294f, 
    -0.11217940f, -0.04210249f, -0.06901312f, -0.03518572f, 0.14270233f, 0.12307303f, -0.01079889f, 0.30196753f, 
    0.05792161f, 0.01061919f, 0.02674439f, 0.03174734f, 0.06586736f, -0.01369389f, 0.10264954f, 0.08537190f, 
    0.18875073f, -0.10614730f, 0.13651575f, 0.03444328f, 0.00717698f, -0.01749675f, 0.04356827f, 0.02479779f, 
    -0.00114389f, -0.12760913f, 0.19731969f, 0.08124040f, -0.32338697f, -0.23524511f, -0.32206020f, -0.26670739f, 
    0.11464118f, 0.08355784f, 0.02850846f, 0.00443105f, 0.05343310f, 0.17580166f, -0.06499147f, 0.02402413f, 
    0.00809388f, 0.06734886f, 0.02618068f, 0.09051471f, 0.01493395f, -0.00582041f, -0.06170794f, 0.06213374f, 
    0.05987029f, 0.11900392f, 0.08915635f, 0.08919001f, -0.07304369f, 0.11865956f, -0.10525066f, 0.20249125f, 
    -0.00349428f, -0.01410007f, -0.05923777f, 0.10914968f, 0.06736109f, 0.03618502f, 0.08700838f, 0.12198936f, 
    0.09907184f, -0.11956986f, -0.21403462f, -0.03697149f, 0.02648000f, -0.01491232f, 0.20759137f, 0.27342635f, 
    -0.15932015f, -0.04575956f, -0.00399881f, -0.10340584f, -0.00593348f, -0.14782301f, 0.31811330f, 0.23948298f, 
    -0.09248508f, -0.00367150f, -0.07024179f, -0.10420893f, 0.15496543f, -0.00344936f, -0.00838511f, 0.05640785f, 
    -0.55490595f, -0.06889684f, -0.15679997f, 0.04398720f, -0.06145314f, -0.04035601f, 0.15226595f, 0.18391207f, 
    -0.00685248f, -0.11125161f, -0.01885156f, -0.16799475f, -0.39339077f, -0.06365484f, -0.09971397f, -0.15661456f, 
    0.00945981f, 0.06646968f, -0.01997687f, 0.15197581f, 0.30447859f, -0.08845045f, 0.09726542f, -0.12603335f, 
    0.10515960f, -0.03291699f, 0.10482232f, -0.32878911f, 0.00242737f, 0.21873456f, -0.10003603f, 0.02015990f, 
    -0.01954171f, 0.05296370f, 0.03974263f, -0.04142353f, -0.04382829f, 0.06959684f, 0.15516834f, 0.09598719f, 
    -0.07608875f, 0.10595343f, 0.04593359f, 0.08448186f, 0.12040536f, -0.06708607f, 0.00034511f, -0.00040377f, 
    -0.16550359f, -0.11904347f, -0.13298956f, 0.25338441f, -0.11390160f, -0.01448405f, -0.05238037f, -0.00233777f, 
    0.05348714f, -0.10399709f, 0.00730737f, 0.05842796f, -0.17392804f, 0.04312049f, -0.10270321f, 0.04970108f, 
    0.06792873f, -0.07500374f, -0.12267567f, 0.04582287f, 0.02058737f, -0.03599231f, 0.04256105f, -0.02718673f, 
    0.01060005f, 0.15668677f, 0.19447297f, 0.04832971f, 0.10305335f, -0.01641287f, 0.00559000f, -0.00316334f, 
    0.03759081f, -0.17762448f, -0.19264925f, 0.00044206f, -0.09683912f, 0.08078598f, -0.10726587f, 0.14541182f, 
    -0.12533337f, -0.03915489f, -0.10159050f, 0.02349516f, 0.06746395f, 0.12845224f, 0.08546377f, 0.06464874f, 
    -0.10353227f, -0.01021766f, 0.07351989f, 0.00309278f, 0.22105226f, 0.12106521f, 0.11219897f, 0.05072058f, 
    0.04821352f, -0.01911806f, 0.05676809f, 0.13410306f, -0.13498482f, 0.02497493f, 0.00781031f, 0.22872956f, 
    0.06111692f, 0.02950982f, 0.12866768f, 0.05905554f, -0.02306245f, 0.00773936f, 0.08601208f, 0.07892931f, 
    -0.11764678f, 0.14620042f, 0.18503657f, -0.23904172f, -0.02333643f, 0.03283988f, -0.08841723f, -0.04576926f, 
    0.05413684f, 0.00296216f, 0.08873346f, -0.02334723f, -0.26567414f, -0.03058823f, -0.00294506f, 0.13603184f, 
    -0.00999507f, -0.12487604f, -0.11731995f, -0.02788136f, 0.27611464f, 0.06497687f, -0.07844507f, 0.08199195f, 
    -0.02925033f, -0.14599076f, -0.07853342f, -0.17421094f, -0.01001197f, -0.00308712f, -0.11763226f, 0.19041705f, 
    -0.07479080f, -0.02020400f, -0.05141745f, 0.27544570f, -0.10844173f, -0.17252335f, -0.28836039f, 0.05325837f, 
    0.08347160f, 0.03964399f, -0.02727848f, -0.08605921f, -0.05080189f, -0.05471738f, 0.09423765f, -0.01426495f, 
    -0.12377062f, -0.12322908f, -0.12259393f, 0.00010128f, 0.07442572f, 0.12633099f, 0.02123947f, -0.01295132f, 
    0.10083348f, 0.08904217f, 0.05702384f, 0.14734690f, -0.22093061f, 0.14621203f, -0.01533988f, -0.03941871f, 
    0.00617911f, 0.06749476f, -0.00905548f, 0.03928683f, -0.00745471f, 0.06382924f, 0.09230231f, -0.16288809f, 
    0.17895782f, 0.11967359f, 0.19108424f, 0.03277353f, -0.00125262f, 0.12764986f, 0.10210437f, -0.02502528f, 
    0.00266188f, 0.01791639f, 0.02923140f, 0.10609967f, -0.07234550f, 0.01311773f, -0.01540653f, -0.07473125f, 
    0.09346227f, 0.12119286f, 0.19785078f, 0.02639955f, -0.04367995f, 0.00009059f, -0.04267224f, -0.04761557f, 
    -0.09909584f, 0.07556608f, -0.09195641f, -0.10481651f, 0.01404719f, 0.11916494f, -0.14815669f, -0.00267254f, 
    0.17711331f, 0.09556183f, 0.05844687f, 0.12746151f, -0.00133910f, -0.11907873f, -0.12764691f, 0.05498154f, 
    0.14341602f, -0.05670941f, 0.02193972f, -0.15605707f, 0.07464197f, 0.05052937f, -0.08072139f, 0.14383771f, 
    0.28442743f, 0.00092586f, 0.25865042f, 0.19834946f, 0.12048282f, 0.15388419f, 0.08018760f, 0.11990149f, 
    0.13029586f, 0.10017724f, 0.08797017f, -0.06376704f, -0.41575652f, -0.02054422f, -0.07051450f, 0.32406291f, 
    0.14979759f, -0.24816251f, 0.09086849f, 0.21203734f, -0.00493415f, -0.05906576f, 0.02173430f, 0.11532816f, 
    0.02241682f, 0.03321011f, -0.10790341f, -0.18566263f, 0.04326192f, 0.10287409f, -0.17884092f, -0.00016239f, 
    0.15328480f, -0.13427319f, -0.06373730f, 0.00639634f, 0.22130701f, 0.11703224f, 0.07839394f, -0.18497024f, 
    0.02913151f, 0.20297019f, -0.17731525f, 0.04177215f, 0.00163196f, -0.07519969f, -0.08083052f, -0.02559974f, 
    -0.33026531f, -0.28010446f, 0.18473412f, 0.29056844f, -0.09671964f, -0.21464762f, -0.01069841f, 0.16551854f, 
    0.15608115f, 0.00422682f, 0.03413524f, -0.03011678f, -0.16497365f, 0.16461346f, 0.11348310f, -0.02577394f, 
    0.07555640f, 0.09407794f, 0.11652110f, 0.07975038f, -0.03411511f, -0.05821925f, 0.18551174f, 0.10706892f, 
    -0.12730257f, 0.08403886f, 0.00566102f, -0.11692113f, 0.02366679f, 0.12250248f, -0.01436745f, -0.15337887f, 
    0.24081038f, 0.10566933f, 0.06602333f, -0.04693041f, -0.48276812f, -0.23496510f, -0.05734211f, -0.09421003f, 
    0.03287571f, -0.12654735f, 0.03178270f, 0.15896006f, 0.00303288f, 0.03236275f, 0.01013477f, 0.02097543f, 
    -0.04196493f, 0.18880144f, -0.08061972f, 0.20804018f, 0.11332140f, -0.01586476f, 0.09038817f, 0.14091015f, 
    -0.08640911f, 0.12013825f, -0.16264115f, -0.18343933f, 0.11195284f, -0.10827877f, -0.24240102f, -0.07336582f, 
    0.00392484f, -0.08852639f, -0.00877980f, 0.16212106f, 0.00498818f, -0.07198825f, -0.04443282f, -0.04972200f, 
    0.25108793f, 0.08839899f, -0.23085473f, -0.06399565f, -0.01186562f, 0.01996899f, 0.07775208f, 0.20445214f, 
    0.01756102f, -0.11631624f, 0.02628054f, -0.08587226f, 0.06590504f, 0.22341207f, -0.29086405f, 0.40133759f, 
    -0.06775776f, -0.13130319f, 0.10932353f, 0.07774799f, 0.04292794f, -0.12738572f, 0.00464053f, 0.11849095f, 
    0.36591187f, -0.19581942f, -0.03646803f, 0.07334914f, 0.07034366f, 0.03323814f, -0.00169715f, 0.09333084f, 
    0.09528179f, -0.22326826f, -0.03440717f, -0.23896708f, 0.42986259f, 0.04986046f, -0.20925659f, 0.27292272f, 
    -0.09456218f, -0.05136448f, 0.00294313f, 0.20734975f, -0.03476424f, 0.14091130f, -0.06358396f, 0.03033826f, 
    -0.05703453f, 0.01627095f, -0.35141787f, 0.38054454f, -0.09701277f, 0.18897973f, 0.04656616f, 0.03486243f, 
    -0.01311670f, -0.11016949f, -0.06690340f, -0.08098620f, -0.08137409f, 0.17892225f, -0.07252843f, -0.24572302f, 
    0.09634992f, 0.11268467f, 0.09234829f, -0.01619600f, 0.06143400f, 0.16671754f, 0.03304772f, 0.01970562f, 
    -0.15218185f, -0.24525179f, -0.06383231f, 0.01632797f, 0.04175278f, 0.02833976f, -0.02720590f, 0.00411280f, 
    0.00554043f, -0.21718766f, -0.05773381f, -0.02760401f, 0.07677593f, 0.06429765f, -0.21361354f, 0.26767483f, 
    0.01114634f, 0.08664745f, -0.21043158f, 0.00596219f, 0.12370727f, 0.16788583f, 0.13574173f, 0.10785490f, 
    0.10639489f, 0.03058369f, 0.18046492f, -0.01947080f, 0.09400260f, 0.04201571f, 0.14049476f, 0.05099066f, 
    -0.02363571f, 0.10337989f, -0.02573995f, 0.02894074f, -0.56497705f, -0.18997440f, -0.02996768f, 0.03085988f, 
    -0.14198130f, -0.10200953f, 0.01005445f, 0.14884266f, 0.02770559f, 0.04535761f, 0.04315078f, 0.07259125f, 
    0.13640377f, -0.06451756f, 0.07822575f, 0.27333724f, 0.22736515f, -0.11496554f, -0.15133908f, 0.06735900f, 
    -0.05140929f, 0.12476919f, 0.10339060f, 0.01312335f, 0.11349734f, 0.21420935f, 0.30773878f, -0.10032523f, 
    -0.01066419f, 0.10962433f, 0.00965566f, -0.02565112f, 0.10292721f, -0.06674013f, -0.02729210f, 0.08453835f, 
    0.06221373f, 0.13212143f, 0.20361820f, -0.26006114f, 0.12827221f, -0.09423782f, -0.11538798f, -0.23911577f, 
    -0.06947751f, -0.06680065f, -0.15971398f, -0.04050298f, -0.03832609f, -0.12017204f, 0.08873997f, 0.25767514f, 
    -0.05697003f, -0.08491693f, -0.11129809f, -0.01621370f, 0.13889338f, 0.12341149f, 0.09596240f, 0.21730581f, 
    -0.04889885f, -0.13531116f, -0.06432308f, -0.08353228f, -0.00038073f, 0.04968253f, 0.02857818f, -0.09017006f, 
    -0.03734826f, -0.00908412f, -0.00821518f, -0.16672233f, -0.67453378f, 0.07555922f, -0.01245245f, -0.06933679f, 
    -0.03082066f, -0.06434843f, 0.04912644f, 0.16674320f, 0.10316139f, -0.08796189f, -0.09908565f, -0.02212098f, 
    -0.20237078f, -0.18134618f, -0.08924840f, -0.06333775f, 0.05353544f, -0.10490905f, -0.11597896f, -0.02352826f, 
    -0.02811502f, 0.28842938f, 0.32296664f, 0.14814301f, 0.10248827f, -0.02550163f, -0.16059682f, -0.18841907f, 
    0.05592343f, 0.18130252f, -0.30178696f, 0.22614864f, 0.17129514f, -0.04850498f, 0.09569499f, -0.11053002f, 
    -0.09581204f, -0.00254717f, -0.27489322f, -0.36501229f, 0.20282240f, -0.13001353f, 0.00814474f, 0.20735833f, 
    0.13365880f, -0.00113221f, -0.11269627f, -0.11600317f, -0.18309160f, 0.10293454f, -0.04941620f, -0.24344634f, 
    0.04108080f, -0.05094984f, 0.15873580f, -0.03483447f, 0.04348022f, -0.09999674f, -0.08295845f, -0.09889430f, 
    -0.18166450f, 0.09051789f, 0.10818821f, -0.12253189f, -0.07358472f, 0.00097831f, -0.03991558f, 0.00598660f, 
    0.19071436f, 0.15004909f, -0.01578606f, -0.00155907f, 0.15865032f, -0.05436290f, -0.06193479f, 0.05466833f, 
    0.03485054f, 0.10942897f, -0.07556182f, -0.08328401f, 0.14416537f, 0.05271837f, 0.01040070f, 0.09670312f, 
    0.09466188f, 0.21127744f, -0.00129014f, -0.18874462f, -0.00254542f, 0.14112592f, -0.07186332f, -0.05632431f, 
    -0.05887683f, -0.09770080f, 0.14469688f, -0.08854000f, -0.14635158f, -0.12671641f, -0.09873573f, -0.08291954f, 
    0.12870108f, 0.39489108f, -0.03964867f, 0.01134739f, -0.03579666f, -0.04800202f, 0.04275578f, 0.00010995f, 
    -0.08550071f, -0.08565146f, 0.05018108f, -0.14671059f, -0.04784780f, 0.08016862f, 0.09405974f, 0.02279768f, 
    0.12277640f, 0.02133921f, 0.05417347f, -0.04294518f, 0.31728905f, -0.17104931f, 0.03703085f, 0.08439139f, 
    0.17259513f, 0.19353595f, -0.07338794f, 0.22428076f, 0.16770504f, 0.11640496f, -0.01813301f, 0.06919038f, 
    -0.02794486f, 0.05871225f, -0.07370507f, -0.13504700f, -0.00559208f, 0.08504406f, 0.06478630f, 0.09252983f, 
    -0.14598328f, -0.08747327f, 0.15411516f, 0.00831466f, -0.11621691f, -0.04470539f, -0.09200640f, 0.16289257f, 
    0.03668954f, -0.04863145f, -0.09240332f, 0.08573698f, 0.03604692f, -0.07720061f, -0.00252035f, 0.01482759f, 
    0.25052911f, -0.48291522f, 0.26437131f, 0.16074412f, 0.10668437f, -0.08128633f, 0.01888752f, 0.06312877f, 
    0.05410627f, 0.06145883f, -0.05060253f, 0.02277937f, 0.30437362f, 0.19657563f, -0.02290283f, 0.00763866f, 
    -0.02106550f, 0.06683833f, 0.03202850f, -0.14392899f, 0.07957309f, 0.01533390f, 0.11393445f, 0.02403533f, 
    -0.07552196f, -0.03784401f, -0.03210884f, -0.02458123f, 0.02766015f, -0.11685027f, -0.08961474f, -0.03378658f, 
    0.14434154f, 0.11908950f, 0.03321800f, 0.08038075f, -0.01681058f, -0.10036088f, -0.15921746f, 0.15651102f, 
    -0.17037833f, -0.09472783f, -0.14570895f, -0.02590080f, 0.21807478f, 0.07166105f, 0.05622070f, 0.14615636f, 
    -0.01183766f, 0.01527309f, -0.01569156f, -0.00620771f, -0.01294172f, -0.01812125f, -0.03806232f, 0.00283585f, 
    0.00318998f, 0.01055454f, -0.03164545f, 0.02203969f, 0.00847574f, 0.00295031f, -0.00822275f, -0.01022950f, 
    -0.00262423f, -0.00230424f, 0.01491605f, 0.02069218f, -0.03346283f, -0.03115433f, 0.02766930f, 0.02167180f, 
    0.01613433f, 0.01878140f, -0.01715120f, -0.01953334f, 0.00916893f, -0.00842950f, 0.01648670f, -0.02179048f, 
    -0.02136106f, 0.00668773f, -0.03374841f, 0.01161953f, 0.00636829f, 0.01856033f, -0.00795272f, 0.02345186f, 
    -0.00862207f, 0.03433189f, -0.02766674f, -0.00906127f, 0.00336776f, 0.02501947f, 0.00844377f, -0.00059783f, 
    -0.01131724f, 0.00007871f, 0.02579242f, 0.00331716f, -0.00574520f, 0.00797180f, -0.03318541f, -0.02773641f, 
    -0.01375329f, -0.03477871f, -0.02032238f, 0.02690123f, 0.01420642f, -0.02531899f, -0.02715740f, 0.01579362f, 
    0.00207170f, 0.00550273f, 0.00195260f, -0.02167495f, -0.00136228f, -0.03944788f, -0.02658719f, -0.00676305f, 
    -0.03522826f, -0.02219388f, -0.00423222f, -0.03906854f, -0.01779952f, -0.00215014f, -0.01294777f, -0.01633058f, 
    -0.01890911f, 0.00382676f, -0.02685306f, 0.02222475f, -0.03495269f, 0.01907870f, -0.03588498f, -0.01681281f, 
    -0.02658731f, -0.01795139f, -0.02296963f, -0.00596183f, -0.00270813f, -0.02970887f, -0.02654644f, -0.00553399f, 
    -0.01856512f, -0.01581208f, -0.02202146f, -0.03306863f, -0.03303663f, -0.02147770f, -0.02226875f, -0.03222897f, 
    0.00840404f, 0.02818222f, 0.02252365f, 0.02858262f, 0.02399576f, 0.00939877f, -0.02660188f, -0.01714489f, 
    0.01806983f, 0.00902798f, -0.01099251f, -0.03444269f, -0.02901218f, 0.00213926f, 0.00959789f, -0.00278608f, 
    -0.02301331f, -0.01968797f, -0.01269790f, 0.02432318f, 0.02477787f, -0.04102481f, 0.01322719f, -0.01866886f, 
    -0.01395976f, -0.03471870f, -0.02160994f, -0.00545470f, -0.01480021f, -0.00425390f, -0.03577287f, -0.02585084f, 
    0.02182033f, -0.00107081f, 0.02361093f, 0.00532017f, -0.00171108f, -0.02317263f, -0.02289961f, -0.00133370f, 
    0.02611104f, 0.00935291f, 0.02152031f, -0.02494570f, -0.00322121f, -0.01472113f, 0.02373713f, -0.00139609f, 
    -0.01854234f, -0.04099813f, -0.00405479f, -0.01036868f, -0.01851900f, 0.01723768f, 0.01756451f, 0.00632840f, 
    -0.00165564f, 0.01886891f, 0.01146011f, 0.00416162f, -0.03529029f, 0.00940573f, 0.02677203f, -0.00103398f, 
    0.02336781f, -0.00113002f, -0.00604359f, 0.01097227f, -0.04082849f, 0.00570713f, -0.02596162f, 0.00235006f, 
    0.02380555f, -0.02825449f, 0.01089061f, 0.02987765f, -0.04047317f, 0.02777079f, -0.01417717f, -0.02272856f, 
    0.02001105f, -0.01975606f, -0.03443242f, 0.02957815f, -0.02598515f, -0.03457659f, -0.00775917f, 0.00478147f, 
    -0.00668035f, -0.03459289f, 0.01942554f, -0.02037736f, 0.01697388f, -0.01276529f, 0.00091383f, -0.02750265f, 
    0.01728139f, -0.02758965f, -0.00429800f, 0.02391588f, 0.03333963f, -0.01752978f, -0.03772254f, -0.04027391f, 
    -0.00568958f, -0.01613601f, 0.02325360f, -0.02890624f, 0.02729142f, -0.02275212f, 0.02933432f, -0.02642304f, 
    -0.00576837f, 0.01197541f, -0.01271538f, -0.02977818f, -0.03252236f, -0.03312188f, -0.03913089f, 0.01511520f, 
    0.02428214f, 0.00403720f, -0.00146921f, -0.03356441f, -0.00299200f, 0.01292836f, 0.02855970f, -0.02043140f, 
    0.00576438f, -0.00869117f, -0.02214994f, -0.01921235f, -0.02276830f, -0.03615734f, 0.00170170f, 0.02145151f, 
    0.00671072f, 0.01504647f, -0.01235172f, 0.02569877f, 0.00179796f, -0.02796049f, -0.01479014f, -0.02897658f, 
    -0.00291660f, -0.02013815f, -0.01544188f, -0.01966722f, 0.02022714f, 0.00083442f, -0.02351462f, -0.02772084f, 
    0.01492559f, -0.01762925f, -0.02091786f, -0.03559147f, -0.04080864f, -0.00262062f, -0.02514374f, 0.00541274f, 
    0.00757874f, -0.02927121f, -0.02378367f, 0.00963146f, -0.00303689f, -0.02116103f, 0.01575087f, -0.01367042f, 
    -0.03399667f, 0.01391690f, -0.03155582f, 0.02389607f, 0.02814109f, 0.00978182f, -0.01607030f, -0.03743818f, 
    0.00031577f, -0.00142428f, 0.01070477f, 0.02913309f, -0.00030564f, 0.02313571f, -0.00601366f, -0.02243441f, 
    -0.00692671f, -0.00277652f, 0.02812298f, 0.01437064f, -0.00304987f, -0.01886116f, -0.01416780f, 0.01805994f, 
    -0.01576291f, 0.01214756f, 0.01658751f, -0.00723280f, -0.02363553f, 0.02103171f, -0.03338423f, 0.01565812f, 
    0.01750170f, -0.02302858f, -0.02186949f, -0.01608392f, -0.04086308f, 0.01184565f, -0.00534961f, -0.03079249f, 
    0.02742925f, 0.00195448f, -0.02413495f, 0.02603475f, 0.01455711f, 0.03083322f, 0.02849423f, -0.02919923f, 
    -0.03879933f, 0.01853875f, -0.03433413f, -0.00138529f, 0.02412246f, 0.01856689f, -0.00695607f, -0.03923962f, 
    -0.03438197f, 0.00821984f, 0.01137625f, 0.01293098f, -0.01584181f, 0.02678530f, -0.01303157f, -0.04087291f, 
    0.02371236f, -0.03468417f, -0.02925174f, -0.03884244f, -0.01970641f, 0.02318539f, -0.00995873f, -0.01394443f, 
    -0.02021368f, 0.00223033f, 0.02653186f, -0.04086571f, -0.01744393f, -0.01126129f, -0.01421029f, 0.00096512f, 
    -0.02485875f, -0.01541468f, -0.01365275f, -0.00722211f, 0.03043335f, 0.02280631f, 0.00689446f, -0.00081904f, 
    -0.02220021f, -0.02324787f, -0.00184170f, 0.01842325f, -0.02821428f, -0.01644159f, 0.02746127f, -0.01166667f, 
    0.02566642f, 0.00415368f, -0.03278219f, 0.00334153f, 0.03056997f, 0.01883047f, -0.02804508f, -0.02627863f, 
    -0.01604326f, 0.00276918f, -0.01793850f, 0.00462912f, -0.02170285f, -0.01146654f, -0.00256448f, -0.01668281f, 
    -0.01682694f, -0.01232455f, 0.01956678f, 0.00043312f, -0.02125445f, -0.01975220f, 0.01282953f, 0.02644728f, 
    0.01011741f, -0.01721898f, -0.00786415f, -0.02739723f, 0.01832396f, 0.01291186f, -0.03901874f, 0.01763809f, 
    0.02130679f, 0.00125653f, 0.00430643f, 0.02890761f, -0.00063469f, 0.00920478f, 0.01159677f, 0.01084653f, 
    -0.00404555f, 0.01229238f, -0.02204896f, 0.02199256f, -0.03679407f, -0.01700204f, -0.02600845f, -0.01160428f, 
    -0.00923762f, -0.03825635f, -0.02230360f, -0.01292834f, 0.00385343f, 0.01518693f, 0.01691545f, 0.00362077f, 
    0.02350327f, -0.03533516f, -0.02451085f, 0.03040027f, 0.01684415f, -0.01376497f, -0.04118971f, -0.01451918f, 
    -0.02011131f, 0.01975546f, -0.02802046f, 0.00384052f, -0.03135229f, 0.02298063f, 0.00398384f, 0.01762476f, 
    0.02421791f, 0.00804714f, -0.02298058f, 0.00248395f, 0.02083672f, -0.01721820f, -0.02745939f, -0.03130240f, 
    -0.02183470f, -0.02171570f, -0.02849637f, 0.02786241f, -0.03019666f, -0.03247101f, -0.01793032f, 0.00817202f, 
    0.01013727f, 0.01738071f, -0.03087275f, -0.03327501f, -0.01568903f, -0.03031479f, -0.02889579f, -0.00197301f, 
    0.01700967f, 0.00985654f, -0.02498764f, -0.00563401f, -0.02435657f, 0.01050924f, 0.01537209f, -0.02802050f, 
    0.01404401f, -0.01071564f, -0.03115451f, -0.02306398f, -0.01722589f, -0.00801023f, -0.02859796f, 0.00382056f, 
    -0.00429534f, 0.00482430f, -0.00390896f, 0.00675951f, 0.02681021f, -0.00029965f, -0.02189216f, -0.00849606f, 
    -0.02249949f, 0.00521142f, 0.01254097f, 0.02455768f, -0.00877179f, 0.03057160f, -0.01654478f, -0.02296465f, 
    0.02187604f, -0.00156931f, 0.02866868f, -0.01381244f, 0.02938418f, -0.03948351f, -0.02415917f, -0.01644990f, 
    -0.02308517f, 0.00681614f, -0.00137447f, 0.00825692f, -0.03099799f, 0.01044740f, -0.00078112f, 0.00357914f, 
    0.01777431f, 0.02975350f, -0.02823025f, -0.02404644f, -0.00656200f, -0.03970251f, 0.01578913f, -0.00541067f, 
    -0.02779865f, -0.00644680f, 0.02665350f, 0.02790439f, 0.01015875f, 0.01741139f, -0.01249731f, 0.00829771f, 
    0.00457471f, -0.00594062f, -0.03688329f, 0.02175038f, 0.01872544f, 0.01179302f, -0.02660063f, 0.02673558f, 
    0.02464242f, -0.03202242f, 0.01780036f, -0.02355503f, 0.01352150f, 0.02065022f, -0.02081691f, -0.02318797f, 
    -0.00749092f, 0.01090302f, -0.01607719f, 0.02132895f, 0.00647045f, -0.00169078f, 0.00303702f, -0.03114847f, 
    -0.02256221f, -0.03335208f, -0.01003768f, 0.02498575f, 0.02867124f, -0.01551059f, 0.00731983f, 0.02959522f, 
    -0.01305001f, -0.01356567f, 0.03594862f, -0.01437542f, -0.01424267f, -0.01400473f, -0.00959328f, -0.02804216f, 
    -0.03034126f, -0.03040758f, -0.03228629f, 0.00299366f, 0.00261820f, -0.02311539f, 0.01572306f, -0.00978723f, 
    0.01982749f, -0.01624229f, 0.00901767f, -0.00944555f, -0.01471386f, 0.02121639f, -0.02900796f, -0.01839574f, 
    -0.03649885f, -0.01407589f, 0.02963843f, -0.03924945f, 0.00344239f, 0.02482850f, -0.01440373f, 0.00601137f, 
    -0.00973131f, 0.00831449f, 0.01194114f, 0.01639908f, 0.00498201f, -0.01549007f, -0.00325966f, 0.02878518f, 
    0.02662010f, -0.01289636f, 0.03000894f, -0.04072725f, -0.03034044f, -0.01382205f, -0.03156288f, -0.01894218f, 
    -0.03061358f, -0.02495018f, 0.00832588f, 0.03065149f, 0.01408152f, -0.01631294f, -0.00530783f, 0.00842650f, 
    0.03070637f, 0.02569755f, 0.00737845f, -0.02036139f, -0.00524807f, 0.00146586f, 0.01170726f, -0.01690605f, 
    0.01026162f, 0.01619073f, -0.03104910f, -0.00899779f, 0.00731377f, 0.01468617f, 0.01121965f, 0.01000225f, 
    0.01353143f, 0.00186197f, -0.03204994f, 0.01841059f, -0.02074876f, 0.01220602f, 0.00058006f, -0.01434303f, 
    -0.02786279f, -0.02064240f, -0.00068304f, 0.01389474f, -0.03867302f, -0.00653992f, 0.02191060f, 0.01978339f, 
    -0.03160649f, 0.00805400f, -0.00357242f, -0.03535892f, -0.01602356f, -0.02830063f, -0.03100831f, -0.03480687f, 
    -0.02075488f, -0.03964740f, -0.01501529f, -0.00632830f, 0.00399759f, -0.02833145f, -0.03194747f, -0.01725317f, 
    0.01621366f, -0.01544373f, 0.02337987f, 0.01117845f, 0.00151767f, -0.03400813f, 0.00263836f, -0.03023786f, 
    -0.01511745f, -0.01446716f, -0.01741262f, -0.03811684f, 0.01615757f, -0.00919997f, -0.02465243f, -0.02338853f, 
    -0.03288390f, -0.00137362f, -0.02716385f, -0.02441762f, -0.02144407f, 0.00624518f, -0.01229741f, -0.01430158f, 
    0.01339063f, 0.02546664f, 0.02706525f, -0.00925649f, 0.00516167f, 0.00709813f, -0.02125787f, -0.01661824f, 
    -0.00243776f, -0.00735062f, -0.00640365f, 0.01268773f, 0.01293881f, -0.00586072f, 0.02085817f, 0.00338626f, 
    0.01376413f, -0.03058666f, 0.01515369f, 0.00857560f, 0.00771680f, -0.01927158f, -0.02541448f, -0.01458752f, 
    0.02848146f, -0.00831805f, 0.00643157f, -0.00878687f, -0.02681846f, -0.02278609f, 0.02506923f, -0.03985876f, 
    0.00969429f, -0.01610881f, -0.02628024f, 0.02111403f, -0.00612078f, -0.03237693f, 0.01003470f, -0.00128154f, 
    -0.02130632f, -0.00891596f, -0.02106490f, 0.02123826f, 0.02015604f, -0.03116682f, -0.02062701f, -0.02293040f, 
    -0.00678637f, -0.03667548f, 0.01634195f, 0.01362121f, 0.01846928f, -0.03776696f, -0.02152776f, 0.01073283f, 
    -0.01601498f, -0.00918036f, -0.00003090f, 0.01606939f, -0.01357503f, -0.02368773f, -0.03268938f, 0.03143614f, 
    -0.00675649f, 0.00923643f, -0.01217709f, 0.00302519f, -0.02901598f, -0.00140599f, 0.00938953f, -0.01292903f, 
    -0.03659583f, 0.00692356f, -0.00459873f, 0.02235085f, 0.00439218f, -0.02278560f, 0.00703811f, -0.02360763f, 
    0.11551707f, -0.18716076f, -0.11302971f, 0.10588948f, 0.15396415f, 0.09043230f, -0.05685689f, 0.13253103f, 
    0.05613149f, -0.08213568f, 0.06907663f, -0.03502942f, -0.09429223f, 0.10836694f, 0.02178436f, -0.30108821f, 
    -0.05085288f, 0.11096268f, 0.05978781f, -0.05530509f, -0.09875505f, -0.03233421f, -0.13634717f, 0.01374313f, 
    0.09774769f, 0.17085436f, 0.23548208f, -0.02903650f, 0.16216612f, 0.11535156f, 0.04824293f, 0.07828823f, 
    0.01203100f, 0.09403471f, -0.07534992f, -0.11534415f, 0.17952482f, -0.12911008f, -0.28631055f, 0.18046226f, 
    0.01518015f, -0.02448525f, -0.01535395f, -0.01469318f, -0.14988555f, -0.14546704f, -0.31086987f, -0.06411634f, 
    0.39230588f, 0.39903787f, 0.18346347f, 0.22418420f, -0.08620691f, -0.05100580f, 0.02448443f, 0.19455735f, 
    -0.06516845f, -0.02203858f, 0.05764068f, -0.00905320f, 0.17607673f, 0.22256263f, 0.06782409f, 0.05985724f, 
    0.11831859f, 0.19294055f, 0.00144485f, 0.02099200f, 0.10532719f, -0.00063937f, 0.00682085f, -0.01913962f, 
    -0.15032746f, -0.29147971f, 0.00752578f, -0.21209575f, -0.02476912f, -0.10953256f, 0.09992962f, 0.06804354f, 
    -0.06510723f, -0.04404855f, -0.02265261f, -0.01216310f, -0.31944168f, -0.19913222f, -0.08309247f, -0.17071711f, 
    -0.00568966f, 0.02487635f, -0.04565709f, -0.02124859f, 0.00362922f, 0.09194565f, 0.13791993f, 0.22686936f, 
    0.41935134f, 0.31714424f, 0.11834155f, 0.05246457f, 0.21878560f, 0.03666846f, -0.03582346f, 0.05006050f, 
    -0.03605991f, -0.04797303f, -0.02984919f, -0.05994888f, -0.19208293f, 0.17877653f, -0.18529564f, -0.01746410f, 
    0.01582686f, 0.01233111f, 0.03896683f, 0.07299879f, -0.03290049f, 0.02441544f, 0.00041258f, 0.04352552f, 
    0.38362131f, 0.38090530f, 0.11180329f, 0.07206725f, -0.03401144f, -0.06951211f, 0.08735363f, 0.00479509f, 
    -0.02945445f, -0.00596307f, -0.04545772f, 0.03319396f, 0.27097923f, 0.24008530f, 0.23772231f, -0.02755623f, 
    0.05355422f, 0.09771970f, -0.13297080f, -0.10034619f, -0.02869402f, -0.05492907f, -0.04799717f, -0.10117523f, 
    0.21233219f, -0.28492174f, -0.26622045f, 0.08640905f, 0.03503004f, 0.15972276f, -0.02472346f, 0.10821155f, 
    -0.06653407f, 0.12781611f, 0.06190967f, 0.00902827f, 0.22325896f, -0.11181742f, -0.00434874f, 0.11757935f, 
    0.08734956f, 0.10787804f, -0.03100198f, 0.03662609f, 0.01198626f, -0.02266236f, 0.12804024f, 0.08588959f, 
    -0.04677502f, -0.19280760f, 0.01027680f, 0.04074083f, -0.09903435f, 0.04189288f, 0.01687943f, 0.01488373f, 
    -0.01205082f, 0.10336154f, -0.04124044f, 0.04607428f, -0.42319083f, -0.07279013f, 0.01483114f, -0.23378111f, 
    -0.01731773f, -0.10249988f, -0.11805491f, 0.02324152f, 0.03084492f, -0.03195880f, -0.06047898f, 0.04210690f, 
    -0.00396357f, -0.00246029f, -0.07441515f, 0.01320393f, 0.02078072f, 0.02439936f, 0.05216705f, -0.04675001f, 
    0.01625462f, 0.07654167f, 0.05994684f, 0.06779890f, 0.20746388f, 0.02757074f, -0.06161453f, 0.06661738f, 
    0.08020984f, 0.22610945f, 0.01191122f, 0.03343853f, -0.00094567f, -0.00281161f, 0.06394523f, -0.00270437f, 
    0.31021440f, 0.27609286f, -0.11059265f, -0.07449802f, -0.00319544f, -0.05148231f, 0.02739514f, 0.01729896f, 
    -0.00375572f, -0.15973543f, -0.16238301f, 0.00686133f, 0.25899088f, 0.29209781f, 0.16314495f, 0.09741119f, 
    0.06052107f, -0.00763856f, -0.00279548f, 0.21736346f, -0.04146229f, -0.00244146f, -0.02841082f, 0.00335765f, 
    0.34775147f, 0.04049141f, 0.00423913f, 0.17303468f, 0.16758922f, 0.10455140f, -0.05977557f, 0.12122272f, 
    0.13027602f, -0.04940410f, 0.18609503f, -0.00979659f, -0.12510756f, -0.14502989f, -0.12741649f, 0.01997535f, 
    0.00315346f, 0.01675757f, -0.04549899f, -0.00956387f, 0.08362260f, 0.04932399f, 0.11603943f, 0.05052670f, 
    0.24213636f, 0.12756257f, 0.25729665f, -0.17361346f, -0.03639713f, 0.05333683f, -0.09683876f, 0.04006426f, 
    -0.17078795f, 0.00487445f, -0.03574032f, 0.07330162f, -0.11922925f, -0.00395742f, 0.13553803f, 0.03980538f, 
    0.04711759f, -0.13703486f, 0.06604706f, -0.11835175f, 0.17079216f, 0.05513484f, -0.01593946f, -0.04591079f, 
    0.01099418f, -0.26788726f, -0.12495467f, 0.28338096f, 0.00917282f, -0.00588348f, 0.06980789f, 0.01659179f, 
    -0.10320318f, -0.03523931f, 0.00589905f, 0.01884607f, 0.32671908f, 0.08666302f, -0.21233918f, 0.15418392f, 
    0.21989375f, 0.10200211f, -0.02013583f, 0.08147985f, 0.07183897f, 0.11893184f, -0.00736946f, -0.04244224f, 
    -0.10549804f, 0.19522241f, 0.12197114f, -0.29501227f, 0.05365451f, 0.08258340f, 0.20855430f, -0.01095318f, 
    0.04552676f, 0.11887714f, 0.00955372f, 0.09157751f, 0.35529852f, 0.15722141f, -0.12870274f, 0.10075963f, 
    0.07981375f, 0.02324728f, 0.17065941f, 0.14446704f, -0.00758071f, -0.10879321f, 0.15947662f, -0.05975892f, 
    0.21335228f, 0.15856704f, 0.11339101f, 0.09370013f, -0.07523701f, 0.02474836f, 0.08634963f, 0.05542238f, 
    -0.07300056f, 0.04437402f, 0.05135227f, 0.03210573f, 0.05192041f, 0.03666293f, -0.05927227f, -0.09078293f, 
    0.09142771f, 0.13200942f, 0.09714400f, 0.13066898f, -0.03808141f, 0.21758047f, -0.01977356f, 0.01802340f, 
    0.09135718f, -0.06502714f, -0.04390787f, 0.06449055f, -0.07480695f, -0.09469568f, 0.06235510f, -0.07304659f, 
    0.07984303f, -0.02381666f, 0.02084836f, -0.05510871f, -0.07694656f, -0.24877755f, -0.00004486f, 0.05106343f, 
    -0.00625802f, -0.00628886f, -0.08666291f, -0.03104600f, 0.00956570f, -0.06663968f, -0.02492809f, 0.18418598f, 
    0.02089638f, -0.02490526f, -0.07141153f, 0.15254648f, 0.04906582f, -0.10622348f, 0.05205367f, -0.02639399f, 
    0.07641523f, -0.07368482f, -0.07419048f, 0.00387278f, -0.11061995f, 0.14744948f, 0.38985038f, -0.26634720f, 
    -0.02663875f, -0.03075120f, -0.06261940f, 0.08530368f, -0.16731542f, 0.00452814f, 0.11685144f, -0.16982351f, 
    0.26658362f, 0.17767543f, 0.27158430f, 0.08253276f, 0.04303362f, 0.07500514f, -0.13058423f, 0.12273956f, 
    0.00472392f, 0.08359345f, -0.06799817f, 0.02050422f, -0.43607026f, 0.08844748f, 0.18554854f, -0.21432865f, 
    -0.04894822f, -0.02573658f, -0.00461404f, -0.06758836f, 0.01195778f, -0.05422056f, 0.02886294f, 0.13574660f, 
    0.10487802f, -0.24112330f, -0.12822755f, -0.05497883f, -0.16426860f, -0.03139460f, -0.05148381f, -0.01456065f, 
    -0.00196025f, -0.01228285f, 0.04061915f, 0.01478815f, 0.32110196f, 0.25726065f, 0.04327361f, 0.20982599f, 
    -0.05736610f, 0.05485418f, 0.10232782f, 0.10317820f, -0.06105110f, -0.08737594f, -0.02012860f, 0.06313103f, 
    -0.32198328f, -0.17959747f, -0.14602213f, -0.12815191f, -0.05816552f, -0.02978489f, -0.06280384f, -0.00387682f, 
    -0.29958251f, -0.14653923f, -0.06947713f, -0.17278050f, -0.10622296f, -0.00733867f, -0.19927625f, 0.03594946f, 
    0.04431108f, 0.07993685f, -0.04948623f, 0.11346661f, 0.12906238f, 0.12646942f, 0.04295773f, -0.15807673f, 
    0.23471537f, 0.35443866f, 0.10455598f, 0.03237826f, 0.03858000f, -0.02447264f, 0.00775542f, -0.10970860f, 
    -0.04843045f, -0.05745178f, -0.09026933f, -0.01628962f, -0.07464055f, 0.07241955f, -0.00544604f, -0.10623132f, 
    0.07432302f, 0.03189396f, -0.00204851f, 0.09254937f, 0.05857214f, 0.09694266f, -0.00033057f, -0.03822590f, 
    -0.22748438f, -0.01499950f, 0.08922342f, 0.02926853f, -0.01800425f, -0.08235275f, -0.07639042f, 0.09910554f, 
    0.27743307f, 0.15496491f, -0.13178797f, 0.05016967f, 0.30084112f, 0.32367966f, -0.07246951f, 0.11202082f, 
    0.15493025f, 0.07586553f, 0.03998804f, 0.00009672f, -0.09611017f, -0.06274800f, -0.11802270f, 0.18284982f, 
    0.35327068f, 0.38966918f, 0.08636070f, 0.11272605f, 0.01809081f, 0.05674958f, -0.00814349f, 0.14299545f, 
    0.04687582f, 0.09830593f, 0.00982008f, 0.04480604f, -0.10868613f, -0.03827821f, -0.00592365f, -0.16947106f, 
    -0.01448024f, 0.02194173f, 0.05670647f, 0.15608510f, 0.08532925f, -0.01626820f, -0.01662218f, 0.02922926f, 
    -0.16869245f, -0.18897353f, -0.19595952f, -0.26875785f, -0.13926682f, -0.05532525f, -0.12302891f, -0.05810873f, 
    -0.12911387f, -0.06508353f, 0.01967393f, 0.03712964f, 0.07556722f, 0.21311682f, -0.07450899f, -0.02221269f, 
    0.09552296f, 0.07341243f, 0.02474834f, 0.08247733f, -0.15655831f, 0.00217843f, 0.03887891f, -0.22680654f, 
    -0.12558995f, 0.02775047f, 0.03747358f, -0.03049168f, 0.04760692f, 0.08767975f, 0.04334435f, 0.07939252f, 
    -0.09695225f, -0.06869157f, 0.02179976f, 0.07587238f, -0.16412321f, -0.09053742f, -0.28200570f, 0.16035765f, 
    -0.17243075f, -0.06474544f, -0.02555071f, 0.09504151f, -0.00778235f, 0.21096024f, 0.04232069f, 0.02039500f, 
    0.19712588f, -0.18428767f, 0.40299478f, 0.26983041f, 0.00546697f, 0.13674995f, 0.05358993f, -0.08245792f, 
    -0.07677180f, -0.05732194f, 0.09114831f, -0.08293906f, 0.27799556f, 0.20443051f, 0.07508761f, 0.19550517f, 
    0.06073142f, 0.03741063f, 0.00128503f, 0.11703445f, -0.17346852f, -0.12120539f, 0.09707206f, 0.09410103f, 
    0.14484355f, 0.01470956f, -0.11793432f, 0.07992850f, 0.12977767f, 0.01325825f, 0.09028927f, -0.16606250f, 
    -0.10716021f, 0.00412883f, -0.00460752f, 0.09905976f, -0.02041067f, 0.09479544f, 0.05616669f, -0.06989517f, 
    0.05329510f, 0.04416323f, 0.04870088f, -0.03548823f, 0.06480677f, 0.04916152f, 0.04615558f, 0.08655020f, 
    0.33281639f, 0.12240635f, -0.04499359f, 0.17928788f, 0.10226418f, 0.01825604f, 0.07555161f, 0.12028697f, 
    -0.07202028f, -0.10070344f, -0.01166833f, 0.00569774f, 0.31617135f, -0.04778068f, -0.05530808f, 0.04202722f, 
    -0.14312333f, -0.10167734f, 0.02951580f, 0.07348304f, 0.00024155f, 0.09468313f, 0.05765365f, -0.04940218f, 
    0.31334072f, 0.21338341f, 0.08651520f, 0.08633860f, 0.09586775f, 0.12118931f, 0.09298869f, 0.16182728f, 
    -0.06670989f, -0.05525823f, -0.11567829f, 0.08023193f, 0.26524088f, 0.29179543f, 0.28844374f, -0.12080573f, 
    -0.16858572f, 0.13417065f, 0.12630612f, 0.24948849f, -0.07236823f, 0.07190484f, 0.07608808f, 0.04834817f, 
    0.32623842f, 0.30701813f, 0.14435022f, 0.35808456f, 0.13755356f, -0.05902458f, -0.06473622f, 0.00273750f, 
    0.02494783f, 0.02445036f, -0.05220297f, -0.04437260f, -0.29790860f, -0.11664158f, -0.11416271f, -0.12952305f, 
    -0.06145465f, 0.01652593f, 0.00672277f, -0.00359121f, -0.00952716f, 0.00090787f, 0.03161684f, 0.11948000f, 
    -0.01913486f, -0.10468072f, 0.00411631f, -0.23180680f, -0.10387849f, 0.05912456f, 0.08550259f, -0.00358377f, 
    0.06011962f, -0.04963824f, -0.18533368f, 0.16373354f, 0.21000312f, 0.15498702f, 0.06365474f, -0.02354509f, 
    0.04926939f, 0.24647458f, 0.01277832f, 0.17298140f, 0.02875973f, 0.02797641f, -0.00213785f, 0.09464908f, 
    -0.15433629f, -0.10912501f, -0.17552993f, -0.14945626f, 0.02547185f, 0.03837503f, 0.04636792f, -0.02824642f, 
    0.07271887f, 0.05532060f, 0.17367005f, 0.22250809f, 0.05383979f, 0.14042011f, 0.07541780f, -0.15519494f, 
    0.09835445f, 0.05353930f, -0.00908578f, 0.04374077f, -0.00846463f, -0.06582848f, 0.07484082f, -0.05447116f, 
    0.00033310f, -0.03974443f, 0.01668887f, 0.02725074f, -0.00203688f, -0.03755217f, 0.01862980f, -0.01184677f, 
    -0.01682462f, -0.00562239f, -0.01631715f, -0.00566894f, -0.01677763f, -0.00679473f, 0.00191188f, 0.03039620f, 
    -0.01875407f, -0.01769901f, 0.00183414f, -0.02744153f, 0.01583370f, 0.00228326f, -0.01842731f, -0.02769087f, 
    -0.00017195f, 0.01797236f, -0.03147403f, -0.00672087f, 0.01018553f, -0.00111550f, 0.02767117f, -0.01646208f, 
    -0.00563752f, -0.00974521f, -0.02084364f, -0.01455192f, 0.01988392f, -0.03312864f, 0.02633649f, -0.03044731f, 
    -0.03324451f, 0.00947996f, -0.03834387f, 0.00230253f, -0.01580783f, -0.00425945f, 0.00793137f, -0.01347632f, 
    -0.04290536f, -0.03394004f, -0.00686669f, 0.02704089f, -0.03001576f, -0.02783976f, -0.01702666f, 0.01508525f, 
    0.03001132f, -0.02191358f, 0.02124616f, -0.03109929f, -0.02444721f, -0.02283396f, -0.00465710f, 0.02586721f, 
    -0.00876997f, 0.02429118f, 0.03215893f, -0.01780103f, 0.02839729f, -0.01177057f, 0.02149186f, -0.03039788f, 
    0.03091902f, 0.00335057f, 0.02286754f, -0.02517234f, -0.03137704f, -0.01861489f, -0.02605822f, 0.02946445f, 
    -0.00843518f, 0.02337644f, 0.01114184f, 0.01181926f, -0.04162529f, -0.02092508f, 0.01272714f, 0.02894441f, 
    0.01275422f, -0.02055839f, -0.02421078f, 0.00781754f, -0.02139059f, -0.02494190f, -0.01662094f, 0.03549037f, 
    -0.02257124f, -0.00577080f, 0.02862290f, 0.00697580f, -0.00528734f, -0.03358144f, -0.00664874f, -0.03413247f, 
    -0.04244150f, 0.01173640f, 0.01010259f, -0.03762937f, 0.03404409f, -0.01386617f, 0.00879833f, -0.00495666f, 
    -0.02711272f, 0.00974327f, -0.03474027f, 0.00823925f, 0.03235876f, 0.00299373f, -0.01562784f, -0.03298287f, 
    -0.03100323f, 0.02917316f, 0.02356466f, 0.00217588f, 0.00151121f, -0.01409649f, 0.01895420f, 0.01811370f, 
    -0.01257189f, -0.03331036f, 0.00363361f, 0.00840417f, -0.03672906f, -0.00471405f, 0.02087984f, -0.00466183f, 
    -0.00282293f, -0.00332418f, 0.02562030f, 0.01743822f, -0.00590191f, 0.01719280f, -0.03514002f, 0.02231352f, 
    0.01697886f, 0.01205181f, 0.01725929f, 0.02255084f, -0.02295451f, -0.01119935f, 0.02440854f, 0.02943259f, 
    0.00661550f, 0.03491982f, -0.02071458f, 0.01575968f, 0.01368379f, 0.01509362f, -0.01883276f, 0.02747334f, 
    -0.00773357f, -0.01087016f, -0.02942581f, -0.03606236f, -0.03258079f, 0.00093346f, 0.01152394f, -0.02221962f, 
    0.01111397f, -0.00359197f, 0.00542552f, 0.02943042f, 0.01132871f, -0.01352452f, 0.00321277f, -0.03568485f, 
    -0.00229626f, -0.00218613f, -0.00787425f, 0.02175594f, -0.01180968f, -0.00941074f, 0.02429370f, 0.00944600f, 
    -0.02362021f, -0.01646587f, -0.02229596f, 0.02511627f, -0.02547785f, 0.00329346f, 0.01749935f, -0.04132710f, 
    0.00494443f, 0.02573119f, -0.00749170f, 0.03436267f, -0.01800807f, 0.02414205f, -0.00331922f, -0.00879921f, 
    0.02415147f, -0.01624526f, -0.01801728f, 0.02076946f, 0.01196255f, -0.02612254f, 0.02145673f, 0.03066904f, 
    -0.02489318f, -0.01774122f, -0.03076765f, -0.03146215f, -0.00272676f, 0.02650910f, -0.02343709f, -0.03655390f, 
    0.01004012f, -0.00170085f, -0.01426812f, 0.02984989f, -0.02819446f, -0.03648014f, -0.04016163f, 0.00366955f, 
    0.01025968f, 0.03032812f, 0.03141896f, -0.01348471f, -0.03828310f, -0.04331516f, -0.00081516f, 0.00247895f, 
    -0.02713862f, -0.02767940f, -0.00828036f, 0.01449654f, 0.00337377f, -0.01013843f, -0.03280317f, 0.00980719f, 
    0.01173900f, -0.01004579f, -0.03403782f, 0.00710002f, -0.01217409f, -0.01752424f, -0.02132003f, 0.02595823f, 
    -0.02554210f, -0.01662781f, 0.02728410f, -0.02350577f, 0.01948902f, -0.03777252f, -0.00469359f, -0.00328090f, 
    0.01232032f, -0.00332628f, -0.00600080f, -0.01155481f, 0.01966418f, 0.01530298f, -0.03337439f, -0.01434220f, 
    -0.02640873f, 0.03173720f, -0.03169958f, -0.00955646f, -0.03326879f, 0.01174028f, 0.00162286f, -0.01398903f, 
    0.01503608f, -0.02847710f, 0.01249544f, 0.00921363f, 0.01824414f, -0.01128589f, -0.03379513f, 0.03279014f, 
    -0.02773623f, -0.01391380f, -0.00273269f, -0.02252170f, -0.02118271f, -0.00998876f, -0.03558901f, 0.01732748f, 
    0.02271868f, -0.03103361f, 0.00770576f, 0.02171259f, -0.01845148f, 0.01495475f, -0.01040591f, -0.01874997f, 
    -0.02353241f, -0.02822332f, 0.01005878f, -0.01396291f, -0.03533639f, -0.02338817f, -0.01407715f, -0.03718155f, 
    0.01204918f, 0.01444130f, 0.00287535f, -0.02429500f, 0.00548423f, -0.00979084f, 0.01870225f, 0.00287070f, 
    -0.03619592f, 0.02463422f, 0.00494325f, -0.02550826f, 0.02651545f, 0.01858156f, 0.00387158f, 0.01861784f, 
    -0.00040558f, -0.01658829f, 0.01244047f, 0.02374196f, -0.00096878f, 0.00622237f, -0.00669183f, 0.02950229f, 
    -0.03595663f, 0.01902790f, 0.00160632f, -0.01767793f, -0.01097979f, 0.02727155f, 0.01692368f, 0.02171393f, 
    -0.00453133f, -0.01751920f, -0.02898646f, 0.00233521f, 0.01977989f, -0.02949619f, -0.02672858f, -0.02152418f, 
    -0.00474123f, 0.02512423f, 0.01504430f, -0.03242392f, -0.03273523f, -0.00105557f, -0.02345611f, 0.01053678f, 
    -0.01676617f, -0.02966202f, 0.00842213f, -0.02837667f, 0.02892056f, -0.02188933f, -0.00306513f, -0.03710484f, 
    0.00460410f, -0.02834862f, -0.03709306f, -0.02014204f, -0.01326198f, -0.03313292f, -0.00256187f, 0.01584611f, 
    -0.00741405f, -0.01534399f, 0.01943276f, 0.01633652f, 0.03166787f, 0.01413378f, -0.01688992f, -0.03226059f, 
    -0.02739494f, -0.02298870f, -0.03747519f, -0.01658262f, -0.02955750f, 0.03081361f, 0.01895243f, -0.03252956f, 
    -0.00398000f, 0.00360215f, -0.00317579f, 0.01496745f, 0.01718324f, 0.01418323f, -0.00676437f, 0.00347223f, 
    0.02868263f, -0.01816617f, -0.01722650f, -0.02739046f, 0.00779048f, 0.00459038f, 0.02781346f, -0.00757097f, 
    0.00684320f, 0.01991294f, -0.01620925f, -0.00658213f, -0.03473274f, -0.03158705f, -0.01978007f, -0.00299121f, 
    0.01126315f, 0.02927391f, 0.00062370f, -0.01767959f, 0.00760457f, 0.00641076f, 0.02770577f, 0.00770171f, 
    -0.00081050f, 0.01746405f, -0.00880011f, 0.01879185f, -0.01937245f, -0.01820615f, -0.02447190f, -0.00517199f, 
    -0.03255305f, -0.03780597f, 0.03068776f, -0.03389961f, -0.00116600f, 0.01458626f, -0.00879735f, 0.01156503f, 
    -0.02426628f, 0.01231558f, -0.00408686f, -0.01970932f, 0.02019995f, 0.02382753f, 0.01035937f, 0.02400251f, 
    0.00001101f, 0.00488381f, -0.03707312f, -0.03777587f, 0.02433614f, 0.00239888f, -0.02510347f, -0.03165237f, 
    -0.02118064f, -0.01242727f, 0.01461204f, 0.02088399f, 0.01813205f, -0.01876019f, 0.00139367f, -0.01589772f, 
    -0.01349672f, -0.03837936f, 0.01498774f, 0.02754033f, 0.00884870f, -0.02263969f, 0.02407242f, -0.01063207f, 
    0.02782389f, -0.02666451f, 0.00207344f, -0.02226753f, 0.02181890f, -0.02690148f, 0.02487631f, 0.00660821f, 
    -0.01107126f, -0.02157222f, -0.02420046f, -0.01887858f, -0.03041672f, -0.00569989f, 0.02403962f, 0.01247687f, 
    0.00668484f, -0.00666374f, 0.01635450f, -0.02319042f, -0.02297576f, 0.00554943f, 0.01496628f, -0.02647203f, 
    0.00086673f, 0.01233527f, 0.02951865f, -0.01523145f, -0.03468772f, -0.01598528f, -0.01626257f, -0.03617082f, 
    0.01613983f, 0.00187965f, -0.01898725f, -0.03127280f, 0.03438867f, 0.00089892f, -0.01168146f, -0.00639198f, 
    -0.03602170f, -0.01914572f, -0.03984044f, -0.01864694f, -0.01741846f, 0.01383462f, -0.02875182f, 0.00519065f, 
    -0.00840049f, 0.02672409f, 0.02719720f, 0.02993003f, -0.00545532f, 0.00720458f, -0.03679664f, -0.00225831f, 
    -0.01095413f, -0.02612780f, -0.00176312f, 0.00379249f, 0.02505182f, -0.03179563f, -0.03841062f, -0.03888134f, 
    0.01300133f, 0.01368277f, -0.02077483f, -0.00007720f, -0.02035285f, -0.03687687f, -0.01871562f, 0.01224637f, 
    -0.02731818f, 0.02835241f, 0.02802146f, 0.01231189f, -0.02139022f, 0.00155636f, -0.04039030f, -0.01216062f, 
    0.01179699f, -0.03170457f, 0.01379424f, -0.04163107f, -0.00724706f, -0.02787912f, -0.02611249f, -0.03121144f, 
    -0.02775200f, 0.02810559f, -0.00631741f, 0.03041366f, 0.01713648f, -0.00532407f, 0.01049515f, -0.01223336f, 
    0.02904609f, -0.01090301f, -0.01451957f, -0.03489231f, -0.01794033f, 0.02033032f, 0.01364544f, -0.03800318f, 
    0.01210369f, 0.02936004f, -0.00942333f, 0.01076258f, 0.02480293f, 0.00178525f, -0.02353578f, 0.00261091f, 
    -0.03526032f, -0.00306742f, 0.00533377f, 0.02157646f, -0.02235601f, 0.02564547f, 0.01972722f, 0.01866579f, 
    -0.02603626f, -0.00385909f, 0.03198184f, -0.02454798f, -0.01277067f, -0.02506863f, -0.00495900f, 0.00152151f, 
    -0.01662356f, -0.01439199f, -0.03733974f, -0.00270190f, 0.02370444f, -0.01912428f, 0.00879479f, 0.00605047f, 
    0.00842695f, -0.00352155f, -0.00102487f, -0.03081272f, -0.01974710f, 0.00712326f, -0.03610965f, 0.00345804f, 
    0.02383141f, -0.02558522f, 0.02962364f, -0.04058723f, -0.00205379f, -0.02412184f, 0.02386116f, 0.02217168f, 
    0.01197319f, 0.01502030f, -0.03179726f, -0.01427892f, 0.01383746f, 0.00566849f, -0.00569140f, 0.01232170f, 
    0.00607493f, -0.03886282f, -0.00038382f, 0.01932306f, -0.01173024f, 0.00170779f, -0.03952685f, -0.03166348f, 
    0.00321334f, 0.00557436f, 0.01571462f, -0.00086060f, -0.02832123f, 0.00906055f, -0.03026778f, -0.01888629f, 
    -0.00767544f, 0.03008015f, 0.00727647f, -0.01896071f, 0.02527460f, -0.00009485f, 0.01914109f, -0.03176026f, 
    -0.01384212f, -0.03618354f, 0.02257335f, -0.03225585f, -0.03248122f, -0.01270487f, 0.00900985f, 0.00514264f, 
    -0.03668592f, 0.00826640f, -0.03306276f, 0.01298849f, -0.02919562f, -0.02589892f, -0.01866666f, -0.03365836f, 
    -0.01485808f, 0.02414698f, 0.02375494f, 0.02441150f, -0.01847035f, 0.01186487f, -0.01834332f, -0.00392716f, 
    -0.02218037f, -0.03725995f, 0.01924279f, -0.03843560f, 0.00617032f, -0.01888738f, 0.02005876f, -0.03181397f, 
    -0.02822054f, -0.03137987f, 0.02031561f, -0.02842289f, -0.01842355f, 0.01620426f, -0.03214071f, 0.01045956f, 
    -0.00472046f, 0.02038501f, 0.00630582f, 0.01272272f, 0.01833522f, -0.04250511f, -0.02780330f, 0.03059920f, 
    0.01265613f, 0.00340997f, -0.00871576f, 0.02215646f, -0.03091343f, -0.00560467f, -0.01879705f, -0.02909119f, 
    -0.02078086f, -0.02935273f, -0.03618291f, 0.01109040f, -0.03400606f, 0.01073421f, 0.01295916f, -0.00564282f, 
    -0.03770362f, 0.03328189f, -0.02998481f, -0.01616029f, -0.00983190f, 0.03638281f, 0.01604570f, 0.02302266f, 
    -0.00989643f, 0.01736086f, -0.00875381f, 0.02913871f, 0.00459042f, -0.03007823f, 0.01033557f, -0.01532634f, 
    0.01213363f, -0.01650089f, 0.02603157f, 0.02191982f, -0.03749462f, 0.01953502f, -0.03664289f, 0.00565054f, 
    0.02562417f, -0.01136835f, -0.02452303f, 0.01785529f, -0.03330739f, 0.00676657f, 0.00021863f, -0.02968565f, 
    -0.03361822f, 0.00551803f, 0.00988681f, -0.00026014f, 0.02664700f, 0.03367273f, 0.00430819f, -0.01203150f, 
    0.03352790f, -0.01452152f, -0.02238585f, 0.00263137f, 0.03024361f, 0.00295235f, 0.02009957f, -0.02346452f, 
    0.00118542f, -0.00338423f, 0.02857615f, 0.01219452f, -0.00447142f, 0.00543234f, -0.01113514f, -0.00985681f, 
    0.00615647f, -0.00805699f, -0.03945253f, -0.01522721f, -0.02240548f, -0.01186183f, -0.02296566f, 0.01870610f, 
    0.00511515f, -0.03549256f, 0.00630587f, -0.02564210f, 0.01523882f, 0.00698701f, -0.03960266f, -0.00338322f, 
    -0.03497341f, 0.01458415f, -0.02935369f, -0.00863242f, 0.01060133f, -0.01702213f, 0.01518386f, -0.00584126f, 
    -0.02278533f, -0.00505051f, 0.00557224f, -0.02418589f, -0.00526286f, -0.02476840f, 0.00160639f, -0.03319940f, 
    0.02082342f, 0.00254919f, -0.01568230f, -0.00243049f, -0.02656781f, 0.02433906f, -0.01976329f, 0.00875895f, 
    -0.02647193f, -0.01444033f, -0.03721632f, -0.03323057f, 0.02081471f, 0.01733475f, -0.01652584f, -0.03737769f, 
    -0.02973165f, 0.02572472f, -0.02149295f, -0.03061552f, -0.02779634f, -0.00727839f, -0.03625759f, -0.01193398f, 
    0.01944966f, 0.00413413f, 0.02292765f, 0.00034332f, 0.01817788f, -0.02689790f, -0.03751635f, -0.01229571f, 
    0.02106171f, -0.03183142f, -0.00939547f, 0.01493391f, 0.00667269f, 0.00532390f, 0.02828842f, 0.00050260f, 
    -0.02366369f, -0.01027783f, -0.01926531f, 0.01039383f, -0.02088616f, -0.01247227f, -0.01226058f, -0.02376979f, 
    -0.03152915f, -0.02487154f, -0.02525470f, 0.00459285f, 0.01330314f, -0.01931467f, 0.01103875f, -0.01980337f, 
    -0.00153362f, 0.01345003f, 0.02336890f, -0.03398176f, -0.00872836f, 0.01854259f, 0.02719686f, 0.00859752f, 
    -0.00697348f, -0.03915013f, -0.03406971f, 0.01717864f, -0.04037425f, 0.01846324f, -0.02213934f, 0.01398664f, 
    0.01980835f, -0.00005139f, -0.02635750f, -0.02295817f, -0.02910009f, -0.02852349f, -0.03958028f, 0.00501859f, 
    -0.02081715f, 0.00215798f, -0.00493942f, -0.00380069f, -0.02078218f, 0.01403986f, -0.00747723f, -0.02320414f, 
    0.02830379f, 0.00189439f, 0.00430428f, -0.00189588f, -0.00059813f, -0.01277445f, 0.00520707f, -0.00199355f, 
    -0.01572366f, -0.00077768f, 0.01146664f, -0.01425234f, 0.00758112f, -0.00434874f, -0.02210341f, -0.02371849f, 
    -0.00110353f, 0.02075234f, -0.00391921f, -0.01706982f, -0.02947166f, -0.03462403f, 0.01601715f, 0.02769759f, 
    0.00844287f, 0.02534035f, -0.02956736f, 0.01851002f, -0.04020302f, 0.00340769f, -0.02900067f, -0.02332308f, 
    -0.03542088f, 0.00031853f, -0.02920716f, 0.01328576f, 0.01453474f, -0.01068467f, -0.00942831f, 0.01769494f, 
    -0.00177788f, 0.00316230f, 0.01420808f, 0.01469434f, 0.00452867f, 0.01099661f, 0.00091486f, -0.00547265f, 
    0.00707908f, -0.03090211f, -0.02939412f, -0.02162048f, -0.00141726f, -0.03505010f, 0.00057106f, 0.01923716f, 
    -0.03814463f, -0.03751423f, -0.01774648f, 0.02630116f, 0.01831572f, 0.02007244f, -0.03182418f, 0.02551492f, 
    -0.01070075f, -0.01696420f, 0.02058317f, 0.02204104f, 0.02228605f, -0.03447036f, -0.04065382f, 0.02542809f, 
    -0.02856553f, -0.00945206f, 0.01393738f, -0.01453794f, -0.02500567f, -0.02242298f, -0.00047017f, -0.03301547f, 
    0.02271381f, 0.02875025f, 0.02609252f, -0.03439862f, 0.02551886f, -0.02582901f, -0.02164819f, 0.01978478f, 
    0.01980590f, -0.03917965f, -0.00993960f, -0.02423597f, -0.01094476f, -0.03480398f, -0.01509551f, 0.01303382f, 
    -0.01216608f, 0.02303025f, -0.01159104f, -0.04147817f, 0.00238627f, -0.03524244f, -0.02418600f, -0.03489332f, 
    -0.01316735f, 0.01968077f, -0.00088552f, -0.03310848f, -0.02867794f, 0.01247822f, -0.03242845f, -0.02103224f, 
    0.00224639f, -0.02365879f, 0.00300282f, 0.00036973f, -0.01455980f, -0.02711780f, -0.02591644f, -0.00092866f, 
    0.01171959f, 0.00572367f, -0.00119823f, -0.01385731f, 0.02168547f, -0.00472695f, 0.00316836f, 0.02830086f, 
    -0.01572628f, 0.00520297f, -0.02109695f, -0.02693691f, -0.02420638f, 0.01337246f, 0.02562847f, 0.02735670f, 
    -0.02811229f, -0.03244873f, 0.01021003f, 0.00201728f, -0.01369577f, -0.01917376f, 0.00189394f, -0.01263375f, 
    0.00051060f, 0.02146747f, -0.02244626f, -0.00857369f, 0.01127319f, -0.04058305f, -0.01233675f, 0.00928186f, 
    -0.01326180f, -0.01093319f, -0.01232836f, -0.01751387f, -0.03794962f, -0.01209097f, -0.00433858f, -0.04047606f, 
    0.02614195f, -0.01853207f, -0.03806108f, -0.03272852f, -0.02172638f, -0.01494161f, -0.00605257f, -0.01004810f, 
    0.01288056f, -0.03535312f, 0.02690391f, 0.00788756f, -0.03725716f, 0.01787935f, -0.04358917f, -0.00929181f, 
    -0.01876208f, 0.02056746f, -0.01793827f, 0.00596210f, 0.01698412f, -0.01422777f, 0.01616738f, -0.01475913f, 
    -0.01506047f, 0.00128655f, 0.02454629f, -0.01854133f, -0.04431837f, -0.00914549f, -0.00784534f, -0.00628889f, 
    -0.02674413f, -0.00493375f, -0.01772595f, 0.00906820f, -0.02236021f, 0.00286103f, -0.04039171f, -0.02783640f, 
    -0.00766884f, 0.01559579f, -0.03143606f, -0.01160139f, -0.01967785f, 0.02490110f, -0.02620877f, -0.00199677f, 
    0.01341673f, -0.03798945f, -0.02289923f, 0.02332848f, -0.01712115f, -0.01633567f, -0.02731306f, -0.03833498f, 
    -0.02655610f, 0.00818322f, -0.03219562f, 0.01018638f, 0.00273614f, 0.02548798f, -0.03468396f, -0.00781159f, 
    -0.00274910f, 0.01539735f, 0.00482753f, 0.00051718f, 0.02335494f, 0.01581520f, -0.03257154f, 0.02339129f, 
    0.00377895f, -0.02047758f, 0.02671969f, -0.03907391f, 0.01992104f, -0.03642148f, -0.04371837f, -0.04175681f, 
    -0.01202022f, 0.02468863f, -0.00686403f, 0.01188991f, 0.00426703f, 0.00689516f, -0.04115454f, 0.02317547f, 
    0.00837071f, 0.02290636f, 0.00024802f, -0.04035857f, -0.03377151f, -0.00117223f, -0.04013124f, 0.01377230f, 
    -0.03991241f, 0.02673723f, 0.01011024f, 0.01371280f, -0.02318620f, 0.01593054f, -0.03800214f, 0.01825955f, 
    0.02656885f, -0.02989320f, 0.02096501f, -0.02595768f, 0.00450091f, -0.02459199f, 0.02392297f, -0.00743543f, 
    -0.03201426f, -0.03502532f, -0.02189828f, 0.00488890f, 0.00542054f, 0.02937479f, -0.02490667f, -0.00306230f, 
    -0.01962088f, -0.00044629f, -0.01107016f, 0.00600390f, -0.02766597f, -0.03255418f, 0.02173751f, -0.03547548f, 
    -0.01234284f, 0.00141140f, -0.04113105f, 0.01119692f, -0.02145762f, -0.01220640f, 0.01343397f, -0.02967021f, 
    -0.01765379f, -0.02080226f, -0.03479299f, 0.00815959f, -0.02635829f, 0.02094387f, -0.01363634f, -0.03892419f, 
    -0.01276841f, -0.04179446f, 0.01339069f, -0.03208427f, -0.04077361f, -0.03910717f, -0.01289910f, -0.01073226f, 
    -0.01543223f, -0.02666745f, -0.01520661f, -0.00530307f, -0.02574695f, -0.02409739f, 0.02214781f, -0.03150049f, 
    -0.02571223f, -0.01566183f, -0.00947781f, 0.02174286f, -0.02708878f, -0.01618374f, -0.01967928f, -0.02179953f, 
    -0.01642835f, 0.00056797f, -0.00709798f, -0.01975532f, 0.00265722f, -0.03026413f, -0.01643304f, 0.00889996f, 
    0.01397234f, 0.00066834f, -0.02056999f, -0.01808252f, -0.03381501f, -0.00578822f, -0.02764470f, 0.00747283f, 
    0.00133903f, -0.03091113f, 0.00504174f, -0.00921580f, 0.00047097f, 0.02863223f, -0.01326167f, -0.00923727f, 
    -0.00682497f, 0.01785634f, 0.00818954f, 0.02677513f, 0.00563681f, -0.00436389f, 0.01364012f, -0.03348093f, 
    0.01804442f, 0.00279692f, 0.01985629f, -0.00965141f, 0.01667422f, -0.02372463f, -0.02661626f, -0.01657004f, 
    0.02099571f, -0.00086177f, -0.00853938f, 0.02191267f, -0.03802627f, 0.01558282f, -0.03760083f, -0.02372945f, 
    -0.02883780f, -0.01752312f, -0.03239475f, 0.00232558f, 0.01895218f, 0.01768994f, 0.02109084f, -0.01600603f, 
    0.00990726f, -0.01817283f, 0.02935244f, -0.02054621f, 0.00237650f, 0.01786670f, -0.02997086f, 0.02632969f, 
    -0.00240794f, -0.01602396f, 0.00380399f, 0.02809722f, -0.01173613f, -0.01830433f, -0.01654215f, 0.01229125f, 
    -0.04140275f, 0.01928487f, -0.03781489f, -0.00596335f, -0.01827831f, 0.00346560f, -0.00967389f, 0.01330002f, 
    0.00239422f, -0.03124673f, 0.00944926f, -0.00298395f, 0.00659007f, -0.03028639f, -0.01965019f, -0.03268482f, 
    0.02460955f, 0.02410129f, -0.00802471f, 0.01145781f, -0.02536448f, -0.01621523f, -0.02628930f, -0.03540700f, 
    -0.03877547f, 0.00058827f, -0.00225038f, -0.00640151f, 0.01631223f, -0.02424829f, -0.00559935f, 0.02424739f, 
    0.01506245f, 0.01870255f, 0.01878721f, -0.00905742f, 0.00277424f, -0.03135126f, 0.00768250f, -0.00883899f, 
    0.01675064f, 0.00615781f, 0.02161682f, 0.01994669f, -0.04045661f, -0.00045344f, -0.01037253f, 0.01202391f, 
    0.00140741f, -0.01505376f, -0.00226901f, -0.00093327f, -0.00467732f, -0.00871343f, -0.02041109f, 0.01614950f, 
    -0.01347788f, 0.01689641f, -0.00835873f, -0.00400451f, -0.02509375f, 0.02735150f, -0.01730550f, -0.00690630f, 
    0.02003612f, -0.03706812f, 0.00341643f, 0.02648458f, -0.00102119f, -0.02821290f, -0.02099091f, -0.03475712f, 
    -0.03287010f, -0.01716560f, -0.03221469f, -0.01825405f, -0.03772654f, 0.02780845f, 0.01186469f, -0.01331897f, 
    0.00548425f, 0.02465839f, -0.03693561f, 0.02343982f, -0.01922981f, 0.00001660f, -0.04077299f, -0.03281527f, 
    -0.03345729f, -0.02197744f, 0.00245227f, 0.01768371f, -0.01430111f, 0.02603635f, -0.01090117f, 0.01306805f, 
    0.02558112f, -0.03021773f, -0.04191199f, -0.00181682f, -0.00169092f, 0.01380198f, 0.00143351f, -0.00071624f, 
    0.00361399f, -0.01594198f, -0.01334765f, -0.03562490f, -0.03304370f, 0.02180940f, 0.00941570f, -0.02453104f, 
    -0.03007805f, 0.00239089f, 0.01288374f, 0.00361279f, -0.00981745f, -0.03525043f, -0.03782359f, -0.03664390f, 
    0.01626044f, 0.00328111f, 0.00447401f, 0.02260149f, 0.02461794f, 0.02407884f, 0.00311032f, 0.01475328f, 
    0.01628952f, -0.04243795f, -0.03525226f, -0.01881014f, -0.01212986f, 0.02575785f, 0.00410260f, 0.01533463f, 
    0.00252884f, 0.02873316f, -0.04189907f, -0.04259434f, -0.01439046f, 0.00207871f, -0.01170828f, -0.02896335f, 
    -0.03955487f, -0.03475750f, 0.02718961f, -0.03568293f, -0.03724881f, 0.02346781f, -0.01432747f, -0.01002324f, 
    -0.01186987f, 0.01143950f, -0.03194978f, -0.00321593f, -0.01467819f, 0.01304010f, -0.03118343f, -0.03546640f, 
    0.00312318f, 0.01544122f, -0.02567933f, -0.00381106f, -0.03477395f, -0.01942842f, -0.03638352f, 0.01614583f, 
    -0.01363525f, -0.01153310f, 0.00572059f, -0.03863453f, -0.01446671f, 0.01256187f, -0.03781922f, -0.01228866f, 
    0.02216038f, -0.04088012f, -0.02910965f, 0.00233026f, -0.02715164f, -0.00969835f, -0.01216544f, 0.02369185f, 
    0.02385563f, -0.00712252f, -0.01640392f, -0.00699420f, -0.01450761f, -0.01281569f, -0.00654530f, -0.03484443f, 
    -0.04059427f, -0.02337565f, 0.00555022f, 0.01797899f, 0.02802343f, 0.00058140f, -0.00607246f, 0.01826716f, 
    -0.00116480f, -0.02679684f, -0.02454149f, -0.02370314f, -0.01031839f, -0.00589702f, 0.01878505f, -0.03587085f, 
    0.01014121f, 0.01412418f, 0.00854223f, -0.04015857f, -0.03341316f, -0.00200499f, -0.00169919f, -0.00925214f, 
    -0.03431470f, -0.01537735f, -0.01626615f, 0.02226207f, 0.00738304f, -0.01415560f, 0.02016545f, -0.01507519f, 
    0.02496417f, 0.02195968f, -0.01043834f, -0.02321032f, 0.00949930f, 0.02450290f, -0.03372017f, -0.02844845f, 
    0.02224329f, -0.01184917f, 0.01891114f, 0.00876897f, 0.01992559f, -0.00782048f, -0.04081456f, -0.01595099f, 
    0.02724799f, -0.00579580f, -0.01929324f, 0.01636743f, 0.02728230f, -0.03992214f, 0.00809444f, 0.00891432f, 
    -0.03061438f, 0.01025831f, 0.02488219f, 0.00245992f, -0.03204676f, 0.02062440f, -0.03011490f, 0.02762069f, 
    0.01770767f, -0.00633425f, -0.01055874f, 0.02887612f, -0.01333632f, 0.00037644f, -0.01217021f, 0.02659749f, 
    -0.03448048f, 0.01349070f, -0.02553893f, -0.00470254f, -0.00884611f, -0.02808158f, -0.04010570f, -0.00081889f, 
    0.01270971f, 0.02912167f, -0.02433940f, -0.00596938f, 0.01378079f, -0.02597709f, -0.03893937f, 0.01361195f, 
    0.01630207f, -0.00590411f, -0.01580116f, 0.01952496f, -0.03007232f, -0.00900365f, 0.02543639f, -0.00397207f, 
    -0.00328511f, -0.02739138f, -0.00296991f, -0.03115402f, -0.03888216f, -0.02408154f, -0.01644446f, -0.01946182f, 
    0.01459848f, 0.01244093f, 0.00981302f, -0.02901203f, -0.01575760f, 0.02966191f, 0.00079977f, 0.01544277f, 
    -0.03573144f, -0.03581774f, -0.00818051f, 0.01149274f, -0.00957232f, -0.02098385f, -0.00609300f, 0.02405113f, 
    0.02478026f, 0.00383712f, -0.03549473f, -0.00470261f, 0.01573923f, 0.01136264f, -0.01891180f, 0.00223430f, 
    -0.02181730f, -0.02666795f, -0.03485793f, 0.01513969f, 0.03821176f, -0.01389754f, 0.02912285f, -0.03219737f, 
    -0.03372874f, 0.01347452f, -0.03519107f, 0.00923084f, -0.02954903f, -0.01570633f, -0.03638218f, -0.02460996f, 
    -0.00545343f, 0.00374120f, -0.01687907f, -0.00679287f, -0.00324855f, -0.01905781f, -0.03495091f, 0.00619078f, 
    0.00888645f, -0.02232936f, 0.02270863f, -0.00857236f, -0.02375128f, -0.02730552f, -0.01651970f, 0.02867088f, 
    -0.03110437f, -0.02700039f, 0.01900891f, 0.01572949f, 0.00271372f, 0.02323661f, -0.01838710f, -0.01492976f, 
    -0.01121860f, -0.01883295f, 0.01093065f, 0.00795195f, 0.02758149f, -0.03186625f, -0.00267029f, -0.02874808f, 
    -0.03644245f, -0.03130505f, 0.02677444f, 0.01060257f, 0.01975209f, 0.03020586f, -0.01573843f, -0.03425784f, 
    -0.00621385f, -0.03804823f, 0.02652157f, -0.00589922f, -0.03800555f, 0.02668774f, -0.02622447f, -0.00942004f, 
    0.01860452f, -0.03275497f, -0.02404816f, -0.03630546f, -0.01702519f, -0.00100078f, -0.00662528f, 0.02422549f, 
    -0.01799527f, 0.00768031f, -0.03943876f, -0.02752446f, -0.03804606f, -0.01617142f, -0.02203138f, -0.00111524f, 
    -0.00736618f, 0.01040643f, 0.02412918f, 0.01744639f, -0.01478064f, -0.00347991f, -0.01355895f, 0.02613393f, 
    -0.02494301f, -0.02115837f, -0.03912812f, -0.00876412f, 0.01349303f, -0.03665197f, 0.02029209f, 0.01561732f, 
    0.01679736f, 0.02221684f, 0.02794044f, 0.02422660f, -0.02521389f, 0.01572537f, -0.02464371f, 0.00548543f, 
    0.00892140f, 0.00540935f, 0.00333317f, -0.03323722f, -0.01515832f, -0.01446598f, -0.00445154f, -0.02792936f, 
    -0.01745267f, -0.01703039f, -0.03353599f, 0.03068580f, -0.02494551f, -0.00727987f, -0.03020890f, -0.01910287f, 
    -0.03192842f, -0.02584255f, -0.03100397f, -0.00031705f, -0.01354228f, -0.02619820f, -0.00221853f, -0.00033980f, 
    -0.01081632f, -0.01185575f, -0.02703836f, 0.00641965f, 0.01242427f, -0.02540323f, 0.02615674f, 0.02960085f, 
    -0.00095698f, -0.00810959f, 0.03008238f, -0.03113284f, 0.00036900f, 0.01264838f, 0.01744846f, 0.00757022f, 
    -0.01108712f, -0.00180785f, -0.01705121f, -0.03322268f, -0.03067440f, 0.01151324f, 0.00223288f, -0.02277690f, 
    0.00661359f, -0.02720986f, 0.02917240f, -0.00363738f, -0.02067944f, -0.01525133f, 0.02218170f, -0.00678351f, 
    0.00766025f, 0.02937141f, 0.02515060f, -0.02238511f, -0.00005893f, 0.02494328f, 0.02987916f, -0.00289150f, 
    -0.01012384f, -0.01200876f, 0.02073305f, -0.03036603f, -0.02330490f, -0.01575092f, -0.00626305f, 0.01723414f, 
    -0.01161767f, 0.00324919f, -0.01948355f, -0.00220764f, 0.00496473f, -0.00213918f, -0.00896433f, 0.02171371f, 
    -0.01001614f, -0.01829587f, -0.02506215f, 0.00063862f, -0.03542458f, -0.03035044f, -0.00052160f, -0.03620131f, 
    0.02452432f, 0.00042554f, 0.02782319f, -0.02305079f, -0.03909872f, -0.01455989f, 0.02155813f, -0.01633799f, 
    0.00338929f, -0.03596638f, -0.00326657f, -0.03218612f, 0.02208208f, 0.01328692f, -0.02995020f, -0.00942288f, 
    0.01267857f, -0.00565345f, -0.04166180f, -0.00276844f, 0.00414634f, -0.03658496f, -0.01665283f, 0.02667708f, 
    0.00591213f, 0.02741195f, -0.00505603f, -0.02620447f, -0.00957157f, 0.01587255f, -0.02672160f, 0.03001753f, 
    0.02888393f, -0.02952831f, 0.00072957f, -0.03343966f, -0.03623184f, -0.03916482f, -0.00221781f, 0.02559287f, 
    -0.00359590f, 0.01205811f, -0.00001084f, 0.02135333f, -0.01563718f, 0.00377861f, -0.00574449f, -0.01957837f, 
    -0.01470473f, -0.01813492f, -0.00481748f, 0.03077650f, 0.00168774f, -0.03516364f, 0.00062588f, -0.00923588f, 
    -0.02424388f, 0.00258082f, -0.00689617f, 0.01127917f, -0.01819666f, -0.03651118f, 0.01966359f, 0.01595913f, 
    -0.01882804f, -0.03155091f, 0.01837778f, -0.02984155f, -0.03568279f, -0.02007848f, -0.03708244f, -0.01541867f, 
    -0.01918162f, -0.01876305f, 0.02559518f, 0.02168668f, 0.01331852f, -0.01394786f, 0.01890169f, -0.03206441f, 
    0.03149430f, -0.00575367f, 0.01046172f, -0.01814105f, 0.00872329f, -0.03698160f, -0.03256657f, 0.00748213f, 
    -0.01651129f, -0.02967209f, 0.00109592f, -0.02581697f, 0.00855976f, 0.01375304f, -0.02016746f, -0.00661750f, 
    0.02648035f, -0.01435211f, -0.03374717f, -0.01660767f, -0.00187948f, 0.02674519f, -0.03703932f, 0.00567115f, 
    -0.01268448f, -0.03700429f, -0.00765531f, 0.00311919f, 0.00012653f, -0.03401749f, -0.01607828f, -0.00287372f, 
    -0.02606702f, -0.03343372f, 0.01891523f, -0.00690636f, 0.02872858f, -0.04216468f, 0.00529498f, 0.02591317f, 
    0.01030635f, -0.00963375f, -0.01636821f, 0.01971981f, -0.02292216f, -0.01920614f, -0.02556955f, 0.00867556f, 
    -0.03252696f, 0.03102379f, -0.00951594f, 0.01118068f, 0.01907285f, -0.03659976f, 0.01347597f, -0.01737200f, 
    -0.02290565f, 0.01932304f, -0.03569252f, -0.01676831f, -0.00962284f, -0.00422177f, 0.01843765f, -0.03564993f, 
    0.02695333f, -0.03639119f, -0.01868158f, 0.00492231f, -0.01268659f, 0.00663139f, 0.01969861f, 0.02752693f, 
    -0.01110467f, -0.01484307f, -0.02623941f, -0.03013199f, 0.02618136f, 0.01446230f, -0.03205065f, -0.03759944f, 
    -0.02581530f, 0.01635848f, -0.03238183f, -0.02723186f, 0.02381987f, -0.03162306f, 0.01690485f, 0.00944254f, 
    -0.01916215f, -0.02555338f, 0.02314196f, 0.01239207f, 0.00187719f, -0.01353745f, -0.01007015f, -0.03757826f, 
    0.01374379f, 0.01374820f, 0.01314114f, 0.00984148f, -0.01644459f, -0.02921646f, 0.00943319f, -0.03122340f, 
    -0.01855431f, 0.00406944f, -0.02033973f, -0.02486657f, 0.01975059f, -0.02089166f, -0.03566743f, 0.01309838f, 
    0.02752081f, -0.00037334f, -0.02863837f, 0.01937596f, 0.00680921f, 0.00002219f, 0.03940661f, 0.00185814f, 
    0.02344090f, -0.02587220f, -0.03113894f, 0.03148926f, 0.00768332f, 0.02460658f, -0.00081243f, -0.00335979f, 
    -0.00594458f, -0.01231202f, 0.02952215f, -0.01451511f, 0.01395004f, -0.01407869f, 0.03073535f, 0.02803860f, 
    0.00430301f, -0.00222688f, -0.02108608f, -0.01070160f, -0.01555744f, -0.01809574f, 0.01008171f, 0.03130774f, 
    0.00454289f, -0.01866023f, -0.01196102f, -0.03884477f, -0.03227860f, -0.02500652f, 0.02003762f, -0.01380354f, 
    0.00673168f, 0.02730983f, 0.00675638f, -0.00154528f, 0.02925076f, -0.00794503f, 0.01716958f, -0.02172421f, 
    -0.01071753f, -0.03349690f, 0.00075236f, -0.03290341f, 0.01957024f, -0.03462617f, -0.00800612f, 0.01598571f, 
    -0.02806661f, -0.04017974f, 0.01761097f, 0.00925891f, -0.00560557f, -0.00851083f, -0.03295842f, -0.02153835f, 
    -0.02666127f, 0.02224446f, -0.02781909f, -0.02045075f, -0.02763454f, 0.01877791f, -0.03562814f, 0.00600299f, 
    -0.00890716f, -0.00782703f, 0.02817647f, -0.00073205f, 0.03051239f, 0.01936785f, 0.01199503f, 0.00492968f, 
    -0.03917073f, 0.03038636f, -0.02994847f, -0.03531955f, 0.01384741f, -0.01853210f, -0.02536049f, -0.00090834f, 
    -0.00706292f, -0.03197517f, 0.02423798f, -0.00123708f, 0.01375985f, -0.00396170f, -0.03774801f, -0.02243748f, 
    -0.01903586f, -0.02411686f, -0.01442688f, -0.04102650f, -0.03119398f, -0.02982539f, -0.02499935f, 0.01204391f, 
    0.00933846f, -0.03396563f, 0.01163835f, -0.00806557f, -0.02871623f, 0.01107761f, -0.02813235f, -0.02832892f, 
    0.01805087f, -0.00096722f, 0.01301506f, -0.00956320f, -0.02680198f, -0.00507640f, 0.00713441f, 0.00020692f, 
    0.01071240f, -0.01315427f, -0.00132997f, 0.00118572f, 0.02320059f, -0.03956655f, 0.00143451f, 0.00556379f, 
    0.01214041f, -0.01521407f, 0.02064331f, -0.00698347f, -0.01465888f, -0.02239557f, 0.02298879f, -0.00721499f, 
    -0.03225866f, -0.03218738f, -0.00787241f, -0.01974106f, 0.02966135f, -0.00318416f, -0.04001505f, -0.02560044f, 
    0.02524248f, -0.03231170f, 0.00167139f, -0.03005766f, -0.00681271f, 0.03526375f, -0.01363823f, 0.02290831f, 
    -0.01726121f, 0.02815337f, 0.01771976f, -0.02779483f, 0.02280641f, 0.02982038f, -0.04189860f, 0.02788410f, 
    0.00547460f, -0.00095962f, -0.00507977f, -0.04130878f, -0.01565809f, 0.01760534f, 0.00333840f, 0.01014046f, 
    -0.03692865f, 0.02059601f, 0.00045673f, -0.02545599f, -0.03909942f, 0.00063254f, -0.00633166f, 0.01990386f, 
    -0.03219615f, 0.00167971f, -0.02966032f, -0.03853640f, 0.01462578f, -0.03703858f, 0.02100853f, 0.02179438f, 
    0.01948877f, 0.02508071f, 0.00393047f, -0.01031665f, 0.01357617f, -0.01921636f, 0.02369926f, -0.03819172f, 
    -0.03000403f, 0.03358521f, 0.02561349f, 0.02492610f, -0.02641624f, 0.01272335f, 0.01766936f, 0.00068955f, 
    -0.00702868f, 0.01371964f, 0.00610085f, -0.00582701f, -0.01694375f, 0.01613061f, -0.02182834f, 0.01231503f, 
    0.02648641f, -0.01104462f, 0.00054298f, -0.03378641f, -0.02801293f, -0.02764584f, -0.00265316f, -0.00386799f, 
    -0.00584324f, 0.02910435f, -0.02048718f, -0.04042867f, -0.03779018f, 0.03710295f, -0.01924612f, -0.00844483f, 
    -0.02047632f, 0.00034442f, -0.02132941f, 0.04170388f, 0.01726952f, -0.01026141f, -0.04025805f, -0.01451550f, 
    0.02459764f, 0.00189408f, -0.00102606f, -0.01696930f, 0.00150017f, -0.00277164f, -0.02921371f, 0.02155634f, 
    -0.01709016f, -0.01180153f, -0.02464517f, -0.02668913f, -0.01539390f, 0.01857959f, -0.03905435f, 0.00082797f, 
    0.02853346f, 0.00027161f, 0.02417837f, -0.00931110f, -0.01800874f, 0.01958948f, 0.00050211f, -0.00975151f, 
    -0.02336452f, -0.01027875f, -0.01149953f, -0.01034390f, -0.02138940f, -0.01264025f, -0.00809743f, -0.00426686f, 
    -0.00312217f, 0.00676331f, -0.02632917f, -0.01134572f, -0.01267872f, -0.03369993f, 0.00203211f, -0.01156063f, 
    -0.03709712f, -0.00464540f, -0.01945086f, 0.02922514f, 0.00201767f, 0.03039519f, 0.01925907f, -0.02362056f, 
    0.01594068f, -0.02364371f, 0.02209643f, 0.01086421f, 0.01587965f, 0.01592073f, -0.03251462f, -0.03289903f, 
    0.01678577f, 0.02022424f, 0.01042547f, 0.01725574f, -0.01277756f, -0.04121714f, -0.00144277f, -0.01206812f, 
    0.00955238f, -0.03483019f, -0.01822605f, 0.00443422f, 0.01417704f, -0.00461599f, -0.02850102f, 0.00412757f, 
    -0.01129926f, -0.03209082f, -0.02040883f, -0.01260450f, -0.01413586f, 0.03036865f, -0.00128644f, 0.01601835f, 
    0.02594623f, -0.00664283f, -0.00088752f, -0.00708965f, -0.04427843f, -0.02649976f, -0.02928466f, -0.04476501f, 
    0.01435299f, 0.02601270f, -0.01714824f, -0.02656396f, 0.02498763f, -0.03884618f, -0.03737183f, -0.03137323f, 
    0.02169141f, -0.02016983f, -0.00317495f, -0.03037555f, 0.01316838f, -0.03312182f, -0.01146864f, 0.02991304f, 
    0.02754349f, 0.00468349f, 0.01246984f, 0.00894828f, -0.02750396f, 0.01110725f, -0.02064797f, 0.03280098f, 
    -0.00082365f, 0.01529560f, -0.02732071f, 0.01982759f, -0.01972744f, 0.03474629f, 0.01209359f, 0.00743228f, 
    -0.02214010f, 0.02638112f, 0.00069313f, 0.01852723f, -0.03434965f, 0.01570088f, -0.02938642f, -0.02884260f, 
    -0.00777243f, -0.00851498f, 0.01597666f, -0.03272537f, 0.01247399f, 0.02896523f, 0.02709764f, -0.00115580f, 
    -0.01092321f, -0.00231131f, 0.00696412f, 0.01328799f, -0.02129216f, 0.02450937f, -0.01006702f, 0.02661602f, 
    0.02998016f, -0.01532890f, -0.04037089f, -0.01229423f, -0.01966822f, 0.00220882f, -0.04203019f, -0.02426812f, 
    0.00782616f, 0.00193499f, 0.02625688f, -0.03847221f, 0.01135150f, 0.01788659f, 0.03199644f, 0.01051530f, 
    -0.01245160f, -0.01089095f, -0.00310019f, -0.02547599f, 0.01380688f, -0.02837583f, -0.01608292f, -0.01566688f, 
    -0.02635301f, 0.00655689f, -0.03743030f, -0.03290557f, 0.00786739f, 0.01562504f, -0.01867018f, -0.00752088f, 
    0.00179613f, -0.00292156f, -0.03707585f, -0.03856169f, 0.00252682f, -0.03068490f, -0.02456114f, 0.02285507f, 
    0.01538663f, -0.01147850f, 0.00413583f, -0.00886518f, -0.00085558f, -0.03729945f, -0.02263047f, -0.03988951f, 
    -0.02791811f, -0.02833975f, -0.02208360f, -0.00156133f, -0.03756384f, -0.02796056f, -0.01068720f, 0.02617486f, 
    0.01611797f, 0.01891162f, -0.01679935f, -0.02167730f, -0.02894494f, 0.02903516f, 0.02697488f, 0.01295477f, 
    0.00710392f, -0.01692071f, -0.03265010f, -0.04520104f, -0.03777612f, -0.00191790f, -0.01220984f, -0.03208014f, 
    0.01257294f, -0.02504034f, -0.01569732f, -0.03404405f, -0.00007680f, -0.02228712f, 0.00606576f, -0.04329743f, 
    -0.01656564f, -0.03236916f, 0.00228569f, 0.00921190f, 0.00345343f, 0.02509614f, 0.01391739f, -0.00826184f, 
    -0.02737570f, 0.00049211f, 0.02355520f, 0.02357992f, 0.01367140f, -0.01301772f, 0.00062897f, -0.04143110f, 
    0.02090893f, -0.00356291f, -0.03532855f, 0.00076505f, -0.02306911f, -0.00465900f, -0.00305095f, -0.00633458f, 
    0.00223551f, 0.00526313f, -0.01305228f, -0.01645577f, -0.01297488f, -0.00446852f, -0.01265064f, 0.02225722f, 
    0.01913933f, -0.01446724f, 0.01000999f, -0.02026646f, -0.01100834f, 0.02876547f, 0.03687515f, -0.02468308f, 
    -0.01826706f, -0.03749565f, -0.00161567f, -0.01484350f, -0.00609336f, 0.01855860f, 0.01374546f, -0.00805255f, 
    -0.03410259f, -0.00922423f, -0.02622741f, 0.00745693f, -0.01474193f, 0.02180770f, 0.01081869f, 0.01692464f, 
    -0.02556254f, -0.01666767f, -0.01611814f, -0.02398487f, 0.01721142f, -0.03054763f, -0.03247885f, -0.03132621f, 
    -0.00841178f, -0.04132400f, -0.03551529f, 0.03052059f, -0.02741765f, -0.03137837f, 0.02882372f, -0.03483358f, 
    -0.04479766f, 0.02369170f, -0.01163845f, -0.02621650f, -0.02130109f, 0.00164067f, 0.00290464f, 0.02770272f, 
    0.00709395f, -0.00060458f, 0.01958822f, 0.01074605f, -0.02255182f, 0.00650536f, -0.02457114f, -0.00117359f, 
    -0.00634621f, 0.01253489f, 0.00403542f, 0.00963539f, 0.01315684f, -0.04134861f, -0.01378361f, -0.00799717f, 
    -0.00091433f, 0.03006727f, -0.02951017f, -0.03060892f, -0.02365092f, 0.02192771f, -0.03122382f, 0.01043759f, 
    0.00372437f, -0.01791579f, 0.02457642f, 0.02693841f, -0.01769690f, 0.00044156f, 0.01473885f, -0.00688491f, 
    0.01637759f, -0.01813624f, -0.01712748f, 0.00109490f, -0.01780511f, -0.03438124f, -0.04144634f, 0.02206070f, 
    0.01245722f, -0.00293405f, -0.01731085f, 0.01415833f, -0.04084587f, -0.00370893f, -0.04251331f, 0.02297851f, 
    -0.03210194f, 0.02391918f, -0.01361304f, 0.00129510f, 0.00337079f, -0.03710666f, 0.00984747f, 0.03308647f, 
    -0.04185204f, -0.02936569f, -0.02631514f, 0.01164814f, -0.02080538f, 0.01093436f, -0.02826457f, -0.04172303f, 
    -0.03437613f, -0.03073124f, -0.00321800f, -0.04088059f, -0.01780172f, -0.02114717f, 0.00642688f, 0.02461499f, 
    -0.01818195f, -0.03483931f, -0.03287660f, -0.00114254f, 0.00541503f, -0.04057398f, -0.00625885f, -0.03276784f, 
    -0.03757651f, 0.02019460f, -0.02413759f, -0.00649272f, 0.00838289f, -0.03823636f, 0.00260327f, 0.01763197f, 
    0.01883867f, -0.03733785f, 0.00907629f, -0.02720669f, -0.00397328f, 0.02992242f, -0.01720787f, 0.02234849f, 
    0.00079218f, -0.02265144f, -0.03480865f, 0.01135344f, -0.01518123f, -0.02110936f, -0.01481128f, -0.03189765f, 
    0.02016793f, -0.00842909f, -0.01221080f, -0.00603744f, -0.00317360f, -0.03604575f, 0.00906488f, -0.01698045f, 
    -0.01356713f, 0.02580368f, -0.03081332f, -0.04379475f, 0.02888041f, -0.00226294f, 0.00511963f, -0.02278521f, 
    0.03099283f, -0.03911141f, -0.02855202f, 0.00979208f, -0.02569950f, 0.01567405f, -0.00420774f, -0.01092058f, 
    0.01185613f, -0.02573561f, 0.00380410f, 0.02119657f, 0.02786092f, -0.02495015f, -0.03258392f, 0.02780310f, 
    -0.02386740f, 0.00084335f, -0.02535586f, -0.00662984f, -0.00325467f, 0.01457765f, 0.01319678f, -0.00945074f, 
    0.01810389f, 0.02358092f, 0.00279121f, 0.02189850f, -0.03222364f, 0.02288215f, -0.02762043f, -0.02551967f, 
    -0.02141083f, 0.02779472f, 0.01153036f, 0.00026857f, -0.01967259f, 0.02599590f, 0.00880144f, -0.01073819f, 
    -0.01773554f, 0.01510201f, 0.00785259f, -0.01992398f, 0.01660177f, -0.01439694f, -0.03133623f, -0.03718365f, 
    0.02489676f, -0.03530813f, 0.02684309f, 0.03028180f, -0.03818194f, 0.02510227f, -0.01350975f, -0.00618009f, 
    0.01503276f, 0.00047992f, -0.03964075f, -0.02885000f, -0.03269843f, 0.01169549f, 0.01177429f, -0.03489597f, 
    -0.02565653f, -0.00341556f, -0.03753885f, 0.02786961f, -0.03795160f, -0.03735172f, 0.02554503f, -0.01739585f, 
    0.00844393f, -0.01196727f, -0.00195069f, -0.00109192f, -0.02339315f, -0.01935524f, -0.00100985f, 0.03039105f, 
    -0.02633937f, 0.01103046f, 0.01051345f, 0.01906471f, 0.02971030f, 0.02692101f, 0.02399173f, -0.03175583f, 
    -0.02260271f, -0.02295673f, -0.04064725f, 0.02638685f, -0.03313282f, 0.01492008f, -0.03279642f, 0.00063706f, 
    -0.02900791f, 0.02065125f, -0.01802948f, -0.03082326f, -0.01164779f, -0.02012055f, -0.04375556f, 0.01160531f, 
    -0.03882402f, 0.02896561f, 0.03087898f, -0.00044179f, 0.02781637f, -0.02604168f, -0.04233085f, -0.02337332f, 
    0.00344338f, 0.00646191f, -0.03077117f, 0.02304081f, 0.02229221f, -0.01803497f, 0.02460340f, -0.01411792f, 
    0.00434309f, -0.03119250f, -0.02679304f, 0.03254699f, -0.02481881f, 0.01983912f, -0.00543621f, -0.01972737f, 
    0.02995739f, 0.00510915f, -0.01094138f, -0.02752047f, -0.04143599f, 0.00353152f, 0.02486183f, 0.01781827f, 
    0.00398933f, -0.02160634f, -0.00746141f, -0.00249377f, -0.00276941f, -0.00296915f, -0.01162883f, -0.00864913f, 
    -0.02768522f, 0.01018339f, 0.01643107f, 0.01914914f, -0.02471735f, -0.00735229f, 0.01831345f, -0.00623232f, 
    0.01249197f, -0.03643887f, 0.00915446f, -0.01020292f, 0.00059138f, 0.02596135f, 0.02668032f, -0.04215969f, 
    -0.03289923f, -0.00012830f, -0.01901804f, -0.03132333f, -0.01629733f, -0.01430437f, 0.02091386f, -0.00435384f, 
    0.02562527f, -0.01727465f, -0.04113457f, 0.01201088f, -0.03511097f, -0.04014524f, 0.01948325f, -0.03903594f, 
    -0.04246876f, -0.01317242f, -0.00177581f, 0.01883706f, 0.02145532f, -0.00510207f, 0.00027113f, -0.00140579f, 
    -0.01074666f, -0.01085257f, -0.01255323f, 0.03236450f, 0.02922071f, -0.01384319f, -0.01322813f, -0.01036784f, 
    -0.02712475f, 0.01232717f, 0.01049031f, -0.00081350f, 0.02509396f, -0.01583115f, -0.00774270f, -0.01735915f, 
    -0.00885518f, 0.00730318f, -0.03123548f, -0.00128438f, 0.00426020f, -0.01408620f, -0.03833379f, 0.00953995f, 
    -0.04103159f, 0.01454399f, -0.02398563f, -0.02542828f, -0.00994059f, 0.01062956f, 0.01888165f, 0.02243115f, 
    -0.02858392f, 0.00029331f, 0.01814094f, -0.02376820f, 0.01065199f, -0.00492461f, 0.01908315f, 0.02274136f, 
    -0.02034825f, 0.00871607f, -0.03936088f, -0.02569683f, -0.03912438f, 0.01933486f, -0.00574126f, -0.01077471f, 
    -0.03147161f, 0.01085263f, -0.02088125f, -0.02178916f, -0.00922019f, 0.02176868f, 0.02373322f, -0.00975737f, 
    -0.01318645f, 0.02858679f, -0.00198100f, -0.01115008f, -0.00878124f, 0.02427259f, -0.01344559f, -0.00390817f, 
    0.01514750f, 0.02421164f, 0.00540573f, -0.02334177f, -0.01962873f, 0.01174308f, -0.01079514f, -0.02861881f, 
    -0.00095321f, 0.01821491f, 0.03105701f, -0.01726532f, -0.02055033f, -0.03326602f, -0.01883415f, 0.02569987f, 
    -0.02512191f, -0.02401887f, -0.03502634f, -0.00658518f, 0.02677064f, 0.02093656f, 0.00763818f, 0.02693816f, 
    -0.00855169f, 0.00306293f, -0.04044849f, -0.01439856f, -0.03930344f, -0.01105589f, -0.01045497f, -0.03559294f, 
    -0.01559047f, -0.04238604f, -0.01663588f, 0.01810871f, 0.01338961f, 0.02784870f, 0.00438632f, -0.01605719f, 
    -0.01245969f, -0.03752691f, -0.01088871f, -0.01205345f, 0.00861831f, 0.02043093f, 0.00907566f, -0.03233749f, 
    -0.03242467f, -0.00628428f, 0.00718133f, -0.04089930f, 0.01851977f, -0.03239315f, 0.02391644f, -0.01874281f, 
    0.01418656f, -0.00851468f, 0.00650747f, -0.02792932f, -0.02766797f, -0.01623091f, 0.02747982f, 0.02601546f, 
    -0.04077372f, -0.03870825f, -0.02071758f, -0.00791661f, -0.03235744f, 0.02146405f, -0.01984828f, -0.01708379f, 
    0.03462701f, -0.01672594f, -0.04358665f, -0.02077007f, 0.02244722f, -0.03343694f, 0.02736736f, -0.03079616f, 
    0.00269771f, -0.01723008f, -0.00452585f, 0.00307469f, 0.02336624f, 0.01128433f, -0.01557692f, -0.00333445f, 
    -0.00655284f, -0.00774440f, -0.04178234f, 0.01847900f, -0.02078492f, 0.01907033f, -0.02860472f, -0.03193067f, 
    -0.00958887f, -0.04349822f, 0.00590265f, 0.02645197f, 0.02008847f, 0.00752904f, 0.02468049f, 0.02384704f, 
    -0.01218733f, -0.00127903f, -0.02921619f, -0.03772254f, -0.02749994f, 0.01957295f, 0.00556307f, -0.02905425f, 
    -0.01849581f, -0.02305538f, 0.00364056f, -0.03386990f, -0.01830401f, 0.02155334f, -0.03325581f, 0.01968790f, 
    0.02931586f, -0.01400886f, 0.00840759f, -0.00176788f, -0.00591605f, 0.01380736f, 0.02240245f, -0.04095597f, 
    -0.02988237f, -0.03954598f, 0.02842855f, -0.02221242f, -0.02585762f, 0.01543040f, -0.03202657f, -0.02445509f, 
    -0.01783475f, -0.02553111f, -0.01097135f, -0.01370442f, -0.00878102f, 0.02730368f, 0.03092674f, 0.02879270f, 
    -0.03842883f, 0.02043419f, -0.04285049f, -0.00306218f, -0.03727115f, 0.00210347f, -0.01286808f, 0.02713537f, 
    -0.03058032f, 0.03196264f, -0.03300268f, -0.00248356f, 0.00231775f, 0.02616438f, 0.01605465f, -0.03648438f, 
    -0.02804174f, 0.01344777f, 0.00388988f, 0.01481435f, 0.01734208f, -0.02225220f, -0.03829937f, -0.00468950f, 
    0.01517947f, -0.00381593f, 0.00532871f, -0.03792688f, 0.02497933f, -0.02341289f, -0.00756470f, -0.03274081f, 
    -0.00448668f, -0.02867652f, -0.02148540f, -0.01901918f, -0.03212023f, -0.03522821f, -0.02074461f, -0.02698994f, 
    -0.01945900f, 0.02524810f, -0.00470369f, 0.02138588f, 0.01726281f, -0.03774343f, 0.02599472f, -0.03754137f, 
    0.01005642f, 0.02710437f, -0.00213514f, -0.04102081f, -0.03650159f, -0.01019703f, -0.03923766f, 0.02521477f, 
    0.01033606f, 0.02967189f, -0.00347667f, -0.03052412f, 0.01216274f, 0.02618172f, -0.01483689f, 0.03897877f, 
    -0.00862928f, 0.02733790f, 0.02687645f, 0.00936231f, -0.01011044f, 0.01322930f, -0.00129866f, 0.02431330f, 
    0.00947679f, -0.03398926f, -0.01478876f, 0.02916605f, 0.02438568f, 0.02935749f, 0.02773249f, 0.00997862f, 
    0.02047689f, 0.02786367f, -0.02585817f, 0.00445640f, 0.02672514f, -0.00032573f, 0.00150874f, -0.02365346f, 
    0.00000919f, 0.03128844f, -0.03030299f, -0.03122460f, -0.00260396f, 0.00656612f, 0.01499210f, -0.01613852f, 
    0.00549688f, -0.03832726f, -0.02086735f, -0.02787857f, -0.00132887f, 0.01091952f, -0.02561250f, 0.02716772f, 
    -0.03220500f, -0.02731008f, -0.02591771f, 0.01803754f, 0.00996012f, -0.02972805f, -0.02451959f, 0.02500803f, 
    -0.00115772f, 0.00423770f, -0.04046389f, -0.02283261f, -0.01420115f, 0.02611463f, 0.01279230f, -0.03995190f, 
    0.00812902f, 0.00653644f, -0.03631359f, -0.03478216f, -0.03980698f, -0.03418173f, 0.01312153f, -0.03485793f, 
    -0.01169198f, -0.03128726f, -0.03927027f, 0.00851922f, 0.02221690f, -0.02963825f, -0.02566853f, 0.00384567f, 
    -0.02244849f, -0.01968410f, -0.03035492f, 0.00023613f, 0.02149604f, -0.03675368f, -0.01320452f, -0.01226875f, 
    0.00567410f, 0.00607138f, -0.02227157f, 0.02812305f, -0.03437159f, 0.02917678f, 0.00228057f, -0.02266221f, 
    0.01497132f, -0.01058645f, 0.01737931f, -0.00685658f, 0.00580698f, 0.01738841f, -0.01591230f, 0.01584415f, 
    -0.02880440f, 0.02555435f, -0.02221919f, 0.00134413f, -0.01990494f, -0.01950305f, 0.01164962f, 0.01275519f, 
    0.00504952f, 0.02633143f, 0.01421461f, 0.03000965f, -0.00544199f, -0.02708528f, -0.00108187f, -0.02097209f, 
    -0.03974134f, -0.00931120f, -0.01996434f, 0.00227563f, -0.01935154f, -0.00680726f, -0.00941964f, -0.00498248f, 
    -0.03605961f, -0.02763811f, -0.01200214f, -0.03241976f, -0.01270252f, -0.03520897f, 0.01751112f, -0.03380106f, 
    -0.00346898f, -0.02601066f, 0.02609764f, -0.03246454f, 0.00115687f, 0.02472623f, -0.02781710f, -0.03012262f, 
    0.01904470f, 0.03451030f, -0.00116384f, -0.02855557f, 0.01492894f, -0.01486250f, 0.00910171f, 0.00435137f, 
    0.01149522f, -0.00205689f, 0.03056953f, -0.01177746f, 0.02726782f, -0.02463364f, -0.02197786f, 0.02373411f, 
    0.02889998f, 0.00189475f, 0.00880761f, 0.00838577f, -0.03632679f, -0.01092246f, 0.01150146f, 0.00120575f, 
    0.01347892f, -0.01733045f, -0.02336479f, 0.01974223f, -0.03013432f, -0.03236900f, 0.00133618f, -0.04010700f, 
    -0.03441391f, -0.01154541f, -0.03639328f, -0.02495795f, -0.02846753f, 0.00449401f, -0.02527418f, -0.00738480f, 
    -0.02397216f, -0.01083464f, -0.01500688f, 0.01580308f, 0.02607646f, 0.01009074f, -0.03442621f, -0.00580770f, 
    0.00573113f, 0.02847104f, -0.03585773f, 0.01158554f, -0.03542031f, -0.01314242f, 0.00736661f, 0.01765160f, 
    -0.00172594f, -0.00325151f, 0.00144092f, -0.03906344f, -0.00094306f, -0.01744991f, -0.00809467f, 0.02294670f, 
    -0.02525823f, -0.01810564f, -0.00997571f, -0.00978464f, -0.02461183f, -0.03272989f, -0.02989244f, -0.01063095f, 
    -0.03524806f, -0.00734759f, -0.02455240f, -0.01644104f, -0.01082224f, -0.01812854f, -0.03054979f, -0.02301290f, 
    -0.02993751f, -0.02559425f, -0.01333249f, -0.03385600f, -0.04089524f, -0.02151019f, -0.00226641f, -0.02794551f, 
    0.00018321f, -0.03351222f, -0.03473242f, 0.02973432f, -0.02003554f, 0.01948199f, -0.02898141f, 0.01648791f, 
    -0.02714838f, -0.03853236f, -0.02776074f, -0.01778311f, 0.01925326f, -0.00367237f, 0.01918001f, 0.01625274f, 
    0.02122523f, -0.03359864f, 0.02507596f, 0.02221073f, -0.00751499f, -0.00237341f, -0.00923038f, -0.01797852f, 
    0.02856156f, -0.00615320f, -0.01686594f, 0.01428525f, -0.00591375f, 0.00337009f, -0.02615701f, -0.02006297f, 
    -0.03813380f, -0.00976306f, -0.01597962f, -0.01303549f, 0.03028261f, 0.01648036f, 0.00129356f, 0.02777622f, 
    -0.03322365f, -0.02741260f, 0.01582455f, 0.00615346f, -0.03838319f, -0.02347527f, 0.01473972f, -0.02107599f, 
    -0.02331524f, -0.03167081f, 0.02521896f, 0.01845866f, 0.00802109f, 0.01946971f, 0.01742899f, 0.02667651f, 
    0.02140320f, 0.00283942f, 0.03041382f, 0.02985329f, -0.02197823f, -0.00910651f, 0.01192447f, 0.03576871f, 
    0.00081439f, 0.00242609f, 0.02625636f, -0.00804078f, -0.00231726f, -0.01345165f, -0.00053406f, 0.00591333f, 
    -0.01227964f, 0.02019759f, -0.03777228f, -0.00814434f, 0.02990813f, -0.03856028f, -0.02706326f, -0.02776713f, 
    -0.00768031f, -0.00601050f, -0.00073496f, -0.01555578f, -0.01282564f, 0.01416402f, -0.03294886f, -0.00357234f, 
    0.03042787f, 0.02730884f, 0.02233607f, -0.03418593f, -0.03218303f, -0.03594541f, 0.00770064f, -0.00251681f, 
    0.01990640f, -0.01917306f, -0.01776758f, -0.01277110f, 0.00177219f, -0.02108599f, -0.02786922f, -0.01941105f, 
    -0.00158960f, -0.00399902f, -0.01935385f, -0.03731864f, -0.03954063f, -0.02261453f, -0.02275819f, 0.01828585f, 
    0.01245245f, -0.00226165f, -0.02167345f, -0.01619469f, 0.01823830f, -0.03489120f, 0.00676972f, 0.00838419f, 
    0.02505050f, -0.00966987f, 0.02322752f, -0.01586750f, 0.01228421f, -0.02029668f, -0.03813103f, -0.00479890f, 
    0.00502363f, 0.00790231f, -0.00454803f, 0.00225158f, -0.00885091f, -0.02287038f, -0.00718739f, 0.01860910f, 
    -0.02232588f, 0.02892326f, -0.03301108f, -0.03938257f, -0.00492255f, 0.00636128f, 0.02197046f, 0.00912574f, 
    0.00939706f, -0.03710598f, -0.00505522f, 0.01813665f, -0.00113225f, 0.02197676f, 0.01888180f, 0.01588245f, 
    -0.00754804f, -0.03127919f, 0.01886640f, 0.02248070f, 0.03000979f, -0.04080929f, -0.03220637f, -0.00026438f, 
    -0.01553075f, -0.01040964f, -0.04027058f, -0.02428734f, -0.03499446f, -0.03795391f, -0.02888629f, -0.01012211f, 
    0.00654352f, 0.00278567f, -0.02166846f, 0.01959098f, 0.02706978f, -0.02908817f, -0.02761810f, -0.03342349f, 
    0.02621711f, -0.01806363f, -0.02763586f, -0.00644890f, 0.01912038f, -0.03408018f, 0.02452178f, -0.02137636f, 
    0.02751226f, -0.02070079f, 0.00102480f, -0.00314677f, -0.04079017f, -0.02472716f, -0.03903197f, 0.00779826f, 
    -0.03215888f, -0.01446176f, -0.00179987f, 0.01690012f, -0.00267013f, 0.01948029f, -0.00147108f, -0.03736453f, 
    0.01227695f, -0.01940388f, -0.02964664f, -0.01919720f, 0.00178253f, -0.02318655f, 0.01305875f, 0.02232843f, 
    -0.02510160f, -0.02268892f, -0.01219226f, -0.02855188f, -0.02649286f, 0.00281881f, -0.02270832f, 0.02208702f, 
    -0.03811149f, 0.03971520f, 0.01395781f, -0.01326626f, -0.00140610f, -0.03380555f, 0.00679006f, -0.03321410f, 
    -0.02842197f, -0.02998528f, 0.00240212f, 0.01612304f, -0.03524929f, 0.00746148f, -0.00236400f, 0.00751794f, 
    0.00033285f, 0.00640585f, 0.00005053f, -0.00954601f, -0.02948765f, -0.03551999f, 0.02996430f, 0.01968708f, 
    -0.02120307f, -0.01246554f, -0.02653969f, 0.02410799f, -0.01742841f, -0.00244005f, 0.00655723f, -0.03657613f, 
    -0.03450354f, -0.01868103f, 0.01293664f, -0.02572530f, 0.00239803f, 0.02674551f, -0.00461795f, 0.01994177f, 
    -0.02153984f, 0.00004208f, 0.02195906f, -0.00612305f, -0.03921486f, -0.04008730f, -0.00371594f, 0.02926150f, 
    0.01815653f, -0.00477023f, 0.01474580f, -0.00980785f, -0.01661934f, 0.00471205f, -0.01058399f, -0.00003931f, 
    -0.03254971f, -0.01495576f, 0.00594353f, -0.04080961f, 0.02798449f, -0.02859949f, -0.01759300f, 0.01956353f, 
    0.02280602f, 0.02428943f, 0.01526587f, -0.03386480f, 0.01928018f, 0.02972588f, 0.00728411f, -0.00674019f, 
    0.00172142f, -0.03102623f, -0.00055310f, -0.02324762f, -0.01466166f, -0.01915500f, 0.01984292f, -0.03269255f, 
    -0.03413076f, -0.03995059f, -0.04005908f, 0.01798309f, -0.01677793f, -0.01078444f, -0.01497860f, -0.03528468f, 
    -0.00241484f, 0.02247462f, -0.03397197f, -0.00018237f, -0.02004805f, 0.01987863f, -0.02003679f, 0.01569821f, 
    0.00000939f, 0.01934295f, -0.03517637f, -0.03830046f, 0.01645028f, -0.02261886f, 0.00149681f, -0.00125857f, 
    -0.01584268f, 0.01736381f, 0.02017989f, 0.00397167f, -0.00845124f, 0.01242092f, 0.02402593f, 0.02039000f, 
    -0.03575435f, 0.02703812f, -0.01207315f, -0.01637669f, 0.02926628f, -0.01282878f, -0.03285255f, -0.03365691f, 
    0.00602411f, -0.03694302f, 0.00019236f, 0.01204656f, 0.00866931f, -0.02759062f, 0.01978812f, -0.03344211f, 
    -0.03221217f, -0.02849133f, 0.01884999f, 0.00477523f, -0.03014020f, 0.02642244f, -0.02573369f, 0.00935059f, 
    0.02537904f, -0.02557591f, 0.02012631f, -0.04101551f, -0.03467675f, -0.00494392f, -0.00191648f, -0.03463720f, 
    -0.01706203f, 0.02139702f, 0.01029505f, -0.00943634f, -0.03558984f, -0.03974916f, -0.00379809f, 0.00863209f, 
    0.01727800f, -0.03855091f, 0.01472404f, -0.04120577f, 0.01411009f, -0.03277464f, 0.00786248f, 0.01091006f, 
    0.02526166f, -0.02784007f, -0.00964261f, 0.02580452f, -0.03381884f, -0.03092114f, 0.01873002f, 0.01427285f, 
    0.02791051f, -0.01476821f, 0.02325128f, -0.00633559f, -0.03222292f, 0.00481451f, -0.00352589f, 0.00584153f, 
    -0.02837499f, -0.00483804f, -0.00908683f, -0.03657537f, -0.02996856f, 0.02408045f, 0.00379040f, -0.02569391f, 
    -0.03009890f, -0.02170797f, -0.00476664f, -0.00434444f, 0.01495605f, -0.00503990f, -0.01753091f, -0.02949853f, 
    -0.00980195f, 0.00041293f, -0.01100025f, -0.00699185f, 0.02029444f, -0.02359129f, 0.02135388f, 0.00895091f, 
    -0.01081358f, -0.00095114f, -0.03264560f, -0.01258703f, -0.02684047f, -0.03559316f, 0.02420580f, 0.01561174f, 
    0.02633180f, 0.02780255f, 0.01148369f, 0.01123761f, 0.01175054f, 0.00230014f, 0.00491408f, -0.03806274f, 
    -0.03024635f, -0.04027469f, 0.02514977f, 0.02125941f, -0.01119364f, -0.00375822f, -0.03479604f, -0.03220686f, 
    -0.02784258f, 0.02538637f, -0.00994187f, -0.02788311f, 0.02718855f, 0.02215875f, -0.01225877f, 0.01287723f, 
    -0.01123804f, 0.02159771f, -0.04105225f, 0.01108097f, -0.02394060f, 0.01901218f, -0.03287613f, 0.00814703f, 
    -0.00480300f, 0.02675077f, 0.02635565f, -0.01216230f, 0.00997044f, 0.01783808f, -0.01959674f, -0.03746206f, 
    -0.00238711f, -0.00088194f, 0.02037988f, -0.00922733f, -0.03407041f, -0.03563576f, 0.01296148f, 0.02129174f, 
    0.00159616f, -0.04011548f, 0.02390924f, 0.01060073f, 0.00164393f, -0.01492026f, 0.01772561f, -0.01225637f, 
    -0.00332709f, -0.00256763f, 0.02555509f, -0.01620791f, 0.02952744f, 0.02618285f, 0.02284584f, -0.02324337f, 
    -0.00949639f, 0.01089350f, -0.01859324f, -0.03660654f, -0.01355094f, -0.00812901f, 0.00495163f, 0.01629682f, 
    -0.02584994f, -0.01213593f, 0.02045250f, -0.03372933f, -0.02001387f, -0.03582587f, -0.00959527f, 0.00899157f, 
    -0.00434322f, -0.01570840f, -0.01919910f, 0.00975538f, -0.02306339f, 0.00594776f, 0.03053237f, -0.03010899f, 
    0.03241200f, -0.01841938f, 0.02284175f, -0.01004257f, 0.01853858f, 0.00055176f, -0.02323415f, 0.01040619f, 
    -0.03455358f, -0.04556980f, -0.00033577f, 0.00991842f, -0.03898673f, -0.02163192f, -0.02231334f, 0.03565244f, 
    -0.01403350f, 0.01094979f, -0.00801926f, -0.00603441f, -0.02012153f, -0.01527186f, -0.03192767f, -0.00953741f, 
    -0.01675120f, -0.01362966f, 0.03412652f, -0.00716601f, -0.02186598f, 0.01509749f, -0.01742340f, -0.02696802f, 
    -0.02079525f, -0.02108183f, -0.03730915f, -0.04355522f, 0.00304528f, 0.00997223f, 0.02387360f, -0.04115400f, 
    0.00117194f, 0.03158201f, 0.03412298f, -0.03123085f, -0.04376527f, -0.00343679f, -0.00931593f, -0.05700585f, 
    -0.01402476f, -0.01968400f, -0.02657825f, 0.02297123f, 0.01300538f, -0.04820370f, 0.02285114f, -0.04646198f, 
    -0.00038892f, 0.01330454f, -0.03094149f, 0.02723744f, -0.01457137f, 0.02451041f, 0.02747651f, -0.01137876f, 
    -0.04806327f, -0.02569549f, -0.03928821f, -0.03250835f, -0.04254486f, -0.00611927f, -0.03000784f, 0.01629630f, 
    -0.01160939f, -0.04818688f, 0.00939963f, -0.03322214f, 0.01091499f, -0.00044502f, -0.01660108f, -0.02134055f, 
    -0.00286642f, -0.00691881f, -0.01947704f, 0.00825889f, -0.03309403f, -0.04044441f, -0.01680755f, -0.03193239f, 
    -0.01655496f, 0.02082864f, -0.00810942f, -0.00407669f, -0.01173160f, 0.00005594f, -0.01802077f, -0.00461740f, 
    -0.02583006f, -0.00438795f, -0.03254890f, -0.02508883f, -0.04464585f, -0.06479399f, -0.06798039f, -0.01227348f, 
    -0.01953567f, -0.01917024f, -0.04044753f, -0.05487115f, -0.00634471f, -0.01428784f, -0.01459114f, 0.01809307f, 
    -0.03794133f, -0.01818608f, 0.00851820f, 0.00392797f, 0.00016639f, -0.00847727f, -0.04365815f, -0.03988273f, 
    -0.00361154f, 0.02333128f, 0.01633080f, 0.00743548f, -0.02755141f, -0.02359705f, -0.00417025f, -0.03373159f, 
    -0.03337239f, 0.01366614f, 0.01639168f, -0.02191000f, 0.00290487f, -0.03719676f, -0.02160920f, -0.04327214f, 
    -0.05581497f, 0.00756361f, 0.01388669f, -0.03338708f, -0.00689189f, 0.02980224f, -0.00467858f, -0.01477420f, 
    0.00827651f, 0.00780042f, -0.01684701f, 0.00586412f, -0.04221192f, -0.04669833f, -0.02713256f, -0.02586162f, 
    -0.00329924f, -0.03026181f, -0.00820240f, 0.00033100f, -0.02389403f, -0.03063361f, -0.00518810f, -0.00599287f, 
    -0.00871233f, -0.02467871f, -0.02021761f, -0.02637541f, -0.04823758f, -0.02319896f, -0.03373535f, 0.01053486f, 
    -0.04302829f, -0.03075718f, -0.01365681f, -0.03281672f, 0.00093642f, 0.01747499f, 0.02265588f, 0.00811990f, 
    -0.02844164f, -0.02338654f, -0.01164891f, -0.04834040f, -0.00968952f, -0.03924724f, -0.04384760f, -0.03595079f, 
    -0.02732430f, 0.01725529f, 0.01240981f, 0.02467136f, -0.00678046f, -0.03198379f, 0.00265331f, -0.03433425f, 
    -0.03027139f, 0.02056896f, -0.01049296f, -0.01218353f, -0.03379166f, -0.02412735f, 0.00918464f, 0.00783014f, 
    -0.04671488f, 0.02282650f, 0.00132920f, 0.00890405f, -0.00153746f, -0.02035461f, -0.06164299f, -0.01523818f, 
    -0.01772702f, -0.02572682f, -0.04282873f, -0.00669698f, -0.00629158f, -0.01364139f, 0.00132323f, -0.03229481f, 
    -0.01004900f, -0.03827208f, -0.01988718f, -0.03501789f, -0.04195245f, -0.03031087f, 0.00772142f, -0.00197206f, 
    0.01058934f, -0.01479811f, -0.01822524f, -0.06194232f, -0.03336713f, -0.02327677f, 0.02059290f, -0.00644918f, 
    0.00603599f, -0.01575542f, -0.00892559f, -0.01769085f, 0.01472826f, 0.01465225f, 0.01051110f, 0.00746628f, 
    -0.02606523f, -0.02085596f, -0.03407599f, 0.02597873f, -0.02096235f, 0.00680934f, -0.04679286f, 0.00232673f, 
    -0.05716446f, -0.00334277f, -0.02360464f, -0.00161784f, -0.02589995f, 0.01563487f, 0.02630257f, -0.01539061f, 
    -0.04919218f, 0.01963958f, -0.05942165f, 0.01148159f, -0.02278220f, -0.00435694f, -0.01266129f, -0.03835911f, 
    0.00152548f, -0.04040151f, -0.04985898f, -0.00027406f, -0.01202545f, -0.03850879f, -0.05219740f, -0.05120514f, 
    -0.01561453f, -0.03948965f, 0.00418507f, -0.03046184f, -0.02209132f, -0.02281005f, -0.03071322f, -0.01267575f, 
    -0.01924234f, 0.00673839f, -0.03684831f, -0.02788587f, 0.00970774f, 0.00257320f, -0.06158881f, -0.03794124f, 
    0.02694074f, 0.02080902f, 0.03447339f, 0.02227445f, 0.02175610f, -0.00732988f, -0.02025884f, 0.01219786f, 
    -0.01835857f, -0.04430292f, -0.03701741f, 0.00905814f, -0.04363874f, -0.04814811f, -0.03123617f, 0.01176159f, 
    -0.01305339f, 0.01314887f, -0.04138301f, -0.02778274f, -0.04189444f, 0.01354588f, 0.01657891f, 0.02250439f, 
    -0.02923332f, 0.03204663f, 0.01009507f, 0.03170878f, -0.03241501f, -0.05085261f, -0.04332479f, -0.01861607f, 
    -0.03476184f, -0.04513395f, -0.00151463f, -0.00157166f, -0.01755766f, -0.06012856f, 0.02312967f, -0.03936402f, 
    -0.00531405f, -0.02284339f, -0.03940836f, 0.00697340f, -0.02747287f, -0.00840053f, -0.02573866f, -0.05951089f, 
    -0.00948172f, 0.01017564f, 0.01187460f, 0.01252199f, -0.04403830f, -0.01346322f, -0.00729138f, 0.01786901f, 
    -0.00944022f, -0.01975477f, -0.03649174f, -0.00905629f, 0.02173795f, 0.02594699f, 0.02396222f, 0.03610689f, 
    -0.00008692f, 0.00476155f, -0.00503556f, 0.00527164f, -0.05717675f, -0.05292730f, -0.00934330f, 0.03487736f, 
    0.01124590f, -0.02971355f, -0.01685246f, -0.04115230f, 0.02722049f, -0.02737774f, 0.00401974f, -0.02423056f, 
    -0.04360911f, 0.01941278f, -0.06210695f, -0.02968202f, -0.01386396f, 0.02627929f, 0.04131496f, 0.03105398f, 
    -0.02700397f, -0.01940041f, -0.01374463f, 0.00282310f, -0.01268437f, -0.05141700f, -0.04324320f, -0.00809213f, 
    -0.02327262f, 0.02246901f, -0.00456323f, -0.02340708f, 0.01051874f, 0.01921980f, -0.05001012f, -0.04485290f, 
    -0.01757697f, 0.00140279f, -0.02047832f, -0.01161345f, -0.01475448f, -0.03157081f, -0.00920599f, -0.02623843f, 
    0.02600070f, -0.00152229f, -0.03430236f, 0.02009843f, -0.01698000f, -0.05008584f, -0.00770679f, 0.00585949f, 
    -0.02897798f, -0.02885912f, -0.00866148f, 0.01853198f, -0.05286493f, -0.01285114f, -0.04939890f, -0.05607498f, 
    -0.05888022f, 0.01630318f, -0.05872247f, -0.06635792f, -0.00522089f, 0.03193938f, 0.00807232f, 0.00037347f, 
    0.00266506f, 0.02688652f, -0.02563136f, -0.02254574f, -0.03194545f, -0.05046505f, 0.00485052f, -0.00256253f, 
    -0.03904415f, -0.00761308f, -0.05367966f, -0.05658275f, 0.00291856f, -0.02664148f, -0.00354851f, -0.05039884f, 
    0.03266661f, -0.02420191f, -0.01753417f, -0.02709714f, -0.01140993f, -0.02515497f, 0.00348603f, -0.03109490f, 
    -0.01533701f, -0.01154062f, -0.02409203f, -0.03221399f, 0.02318484f, -0.03095346f, 0.02340708f, 0.03030931f, 
    0.00012932f, 0.01045274f, 0.01300809f, -0.02165296f, -0.02583610f, -0.00643671f, 0.00466629f, 0.02940123f, 
    -0.02909753f, -0.00558451f, 0.00650941f, -0.02950822f, 0.01258527f, -0.04034383f, 0.00453900f, 0.00926971f, 
    -0.01318699f, -0.01203509f, -0.02536019f, -0.00383101f, -0.06824958f, -0.04101190f, -0.07122480f, -0.03550950f, 
    -0.01725881f, 0.00594683f, -0.03759892f, 0.00312326f, -0.01074155f, -0.00423563f, -0.04009463f, 0.00047468f, 
    0.01376945f, -0.01528850f, 0.00901603f, -0.00784666f, -0.00303894f, 0.00191891f, -0.00599509f, 0.01328698f, 
    0.02614222f, -0.02190906f, 0.00929633f, 0.02912885f, -0.05949620f, -0.01914530f, -0.01164105f, -0.03624067f, 
    -0.01456908f, -0.03633564f, -0.03542550f, 0.01704105f, -0.03798263f, -0.00765002f, -0.02354819f, -0.03710206f, 
    -0.05109337f, -0.04030953f, 0.02631620f, -0.02297054f, -0.02233276f, -0.02002175f, -0.00921384f, -0.02876758f, 
    -0.03620208f, -0.03645254f, -0.00227819f, -0.02501122f, -0.05525286f, -0.01191231f, 0.00418708f, -0.04795791f, 
    -0.00041917f, -0.03836422f, -0.04880440f, -0.00610133f, -0.00402217f, -0.03381470f, 0.00735617f, -0.05159533f, 
    -0.05387117f, -0.02852296f, 0.01707519f, -0.02229218f, 0.01257403f, 0.02107379f, -0.04872942f, -0.00610466f, 
    -0.01350431f, -0.00094856f, 0.01051418f, -0.00370353f, -0.00826183f, -0.03877096f, -0.05662740f, -0.04200889f, 
    0.00010351f, 0.01404694f, -0.03430231f, -0.04395936f, 0.01865208f, 0.00436605f, -0.01308037f, -0.02282137f, 
    0.01110277f, -0.04200550f, -0.01609977f, 0.00079334f, -0.01303963f, 0.02064832f, 0.03806426f, 0.02066823f, 
    -0.00983781f, 0.00257692f, 0.01582196f, -0.02304042f, 0.00550273f, 0.01666477f, -0.03581582f, 0.00859795f, 
    -0.02133850f, -0.00028024f, 0.00688053f, 0.01343737f, 0.00704304f, 0.02992807f, -0.04106545f, 0.00259059f, 
    -0.02973811f, -0.06088246f, -0.03451443f, 0.01830271f, -0.01285962f, 0.00664811f, -0.00537700f, -0.03589027f, 
    -0.00760648f, -0.03054238f, -0.03153471f, 0.00025075f, -0.01562917f, -0.06619131f, -0.01481245f, -0.01003404f, 
    -0.01010986f, 0.01149008f, -0.01944922f, -0.02627856f, -0.00669925f, -0.02396286f, -0.05348701f, 0.00202543f, 
    -0.05653319f, 0.01321568f, -0.02254579f, -0.01132735f, -0.04309953f, -0.02345455f, -0.05899822f, -0.05810509f, 
    -0.01507484f, -0.04837232f, -0.04269472f, -0.01739040f, -0.02382228f, -0.01180556f, 0.02748817f, -0.03594780f, 
    -0.00788972f, -0.05147342f, -0.05102368f, -0.05691499f, -0.02121644f, -0.02256495f, 0.01836732f, -0.01611759f, 
    -0.01865058f, -0.02075482f, -0.04592499f, -0.03570973f, 0.02374522f, -0.01788678f, -0.03129719f, -0.01540728f, 
    -0.03096941f, -0.07323994f, -0.04074596f, -0.03840989f, -0.01770668f, 0.00824853f, 0.02230164f, -0.01227181f, 
    0.01825138f, -0.00271403f, -0.00853175f, -0.04730248f, 0.00830720f, -0.03304115f, -0.02207620f, -0.00134282f, 
    -0.01187520f, -0.01879349f, -0.00506826f, -0.07688520f, -0.01683782f, -0.05142515f, -0.00376523f, 0.00288666f, 
    -0.01414721f, -0.05224463f, -0.02089942f, 0.00671245f, 0.03619201f, -0.02543809f, -0.02391425f, 0.00260912f, 
    -0.05481490f, -0.03338074f, 0.00904212f, -0.04383809f, -0.03593232f, -0.04107862f, -0.01600084f, -0.02695311f, 
    -0.00812657f, -0.03599145f, -0.02645339f, -0.01073318f, -0.01342923f, -0.02877814f, -0.00375726f, -0.00922403f, 
    -0.03252548f, -0.03276475f, 0.01298472f, -0.05445440f, 0.00697237f, 0.02587125f, -0.01802362f, -0.02741757f, 
    -0.01819826f, -0.04908707f, -0.01586373f, -0.04163342f, -0.02298908f, 0.00691762f, -0.00513342f, -0.03249482f, 
    -0.02439615f, 0.01919128f, -0.01398433f, -0.00358667f, -0.02037375f, -0.00951975f, -0.02642437f, -0.00099706f, 
    0.00322258f, 0.01177909f, 0.00027007f, 0.02004118f, -0.02082404f, 0.00167365f, -0.03277997f, 0.00179373f, 
    -0.02960326f, -0.02065440f, -0.00962279f, -0.02525532f, 0.00025319f, -0.02896111f, 0.01286903f, -0.00925006f, 
    0.01147574f, 0.02524161f, 0.02340652f, -0.00196194f, 0.01271386f, -0.02619952f, -0.04208561f, -0.02056249f, 
    0.01353751f, -0.00853498f, 0.01493044f, -0.02681575f, 0.00231764f, -0.03480597f, -0.03949947f, -0.01739514f, 
    0.02018993f, -0.04199379f, 0.00240423f, 0.02715338f, -0.01596761f, 0.00559616f, -0.03673954f, -0.00948272f, 
    -0.02492729f, -0.06734000f, -0.05717876f, -0.03745095f, 0.01812212f, -0.01572992f, -0.00246295f, -0.03853933f, 
    -0.01209418f, -0.03139425f, -0.01206575f, -0.01424491f, -0.03668918f, -0.00201231f, -0.00683084f, -0.03302712f, 
    -0.02512311f, -0.02861998f, -0.01365819f, -0.03798024f, 0.01784039f, 0.00103265f, -0.00467224f, 0.01143062f, 
    0.00048807f, 0.00989393f, -0.03685269f, -0.02697768f, 0.00727070f, -0.01521323f, -0.01588608f, -0.02233827f, 
    0.02157993f, -0.00527902f, -0.03088416f, 0.00381358f, -0.03054094f, 0.02230170f, 0.02637984f, -0.02645801f, 
    -0.02716294f, 0.02571766f, -0.01376767f, -0.03329638f, -0.01105891f, 0.02734318f, -0.01014314f, 0.00284940f, 
    -0.02240235f, -0.02596674f, 0.00336116f, 0.00087432f, -0.04012659f, -0.04051140f, -0.03178593f, -0.00230372f, 
    0.01313417f, -0.02465793f, 0.01166893f, -0.00928656f, 0.02111021f, 0.03144024f, -0.02936648f, -0.03760246f, 
    -0.01284398f, -0.00693860f, -0.01790123f, 0.01506823f, 0.02829031f, -0.00302695f, 0.00006103f, -0.01386044f, 
    -0.01459469f, 0.01207786f, 0.02273557f, -0.03989933f, 0.02708851f, 0.02520822f, 0.02776486f, 0.00309602f, 
    0.00224337f, 0.01893632f, 0.00841124f, -0.04340256f, -0.03690221f, 0.00792536f, -0.04238515f, 0.01010783f, 
    0.02121856f, 0.01231625f, -0.03286175f, 0.00426625f, 0.00257961f, -0.03063638f, 0.01520381f, -0.04071950f, 
    0.00437404f, -0.02448794f, 0.01287489f, -0.03322857f, -0.03587967f, 0.01854845f, 0.01259936f, -0.00782936f, 
    -0.00901873f, -0.01778289f, -0.01781215f, -0.04032771f, -0.00286998f, -0.03013045f, -0.02236088f, -0.00968349f, 
    -0.02332387f, 0.03811064f, 0.02269657f, -0.00176280f, -0.00593347f, -0.02401961f, -0.01238852f, 0.00832697f, 
    -0.04100818f, -0.02995770f, 0.00331294f, 0.02503266f, 0.01174345f, -0.02538148f, 0.00043576f, 0.00760858f, 
    0.02877021f, -0.03539421f, 0.01981957f, -0.03851048f, 0.00050898f, -0.03099265f, -0.04176472f, -0.00974103f, 
    -0.03343443f, -0.02133555f, -0.03889032f, -0.01462671f, 0.00612427f, -0.02429491f, -0.01463504f, 0.01218607f, 
    -0.02695333f, 0.00642909f, 0.02087720f, -0.03221804f, 0.00567364f, -0.00384582f, -0.01191235f, -0.03302980f, 
    -0.02865557f, -0.03248961f, 0.01677902f, 0.02183642f, -0.01640104f, 0.00314201f, -0.02781055f, -0.01116109f, 
    0.03068564f, -0.02370553f, 0.01577609f, 0.00005025f, -0.01215659f, 0.00891893f, 0.02239902f, 0.02250173f, 
    0.02370571f, 0.02490179f, 0.02255305f, -0.04192632f, 0.02088795f, -0.02965899f, -0.03186906f, -0.03380148f, 
    -0.00663353f, 0.02787784f, -0.04101957f, -0.03293103f, -0.03321190f, 0.01982513f, -0.01574845f, 0.00235087f, 
    -0.00216375f, -0.01138260f, 0.01281678f, -0.02374670f, -0.02708136f, -0.02037668f, -0.02402192f, 0.02426134f, 
    0.01097249f, -0.02605751f, 0.01614513f, -0.03407950f, 0.01421115f, -0.01454568f, -0.04233553f, -0.02474665f, 
    -0.02834738f, -0.00438322f, -0.03396323f, -0.03810314f, -0.02380901f, -0.03735983f, 0.02620134f, 0.01734462f, 
    0.00462236f, -0.01841994f, 0.01102739f, -0.03110059f, -0.00827779f, -0.01689466f, -0.03835748f, -0.01675386f, 
    0.00727575f, -0.02533652f, -0.00128504f, -0.02371553f, 0.01124909f, -0.02586424f, -0.02577847f, -0.00663033f, 
    0.02776118f, -0.00718441f, 0.02866783f, -0.02037893f, -0.01846249f, -0.01250999f, -0.03166009f, -0.02779975f, 
    0.02264510f, -0.00297991f, 0.01965378f, -0.03301296f, -0.02602913f, 0.01226817f, 0.00937416f, -0.00567930f, 
    0.00929360f, 0.02884841f, 0.02718958f, 0.02138385f, -0.02707748f, 0.02022325f, -0.03114830f, -0.00508992f, 
    -0.03124974f, 0.00284813f, 0.00665599f, -0.03095190f, 0.02400547f, -0.02178156f, 0.00141782f, 0.02912244f, 
    -0.01434601f, -0.02336673f, 0.02142640f, -0.00877667f, -0.00316805f, -0.04083808f, 0.01483893f, 0.01357216f, 
    -0.00714135f, 0.00166161f, -0.04379427f, -0.00918262f, -0.00242857f, -0.03692162f, 0.00784430f, 0.02693545f, 
    -0.02091523f, 0.01998190f, -0.00265103f, 0.01223161f, -0.01558195f, -0.00382496f, 0.02327221f, 0.00369217f, 
    0.01753419f, 0.00352836f, -0.00569372f, -0.00983936f, -0.04109003f, -0.02802557f, -0.01181265f, 0.02567242f, 
    -0.02010136f, 0.02753378f, 0.02220939f, -0.02051444f, -0.02477862f, 0.01329020f, 0.02300868f, -0.01231737f, 
    -0.00818429f, 0.00180223f, -0.01792043f, 0.00825595f, -0.00269331f, -0.02041036f, 0.01796681f, -0.00833103f, 
    0.02763632f, 0.01124356f, -0.04098833f, -0.03684788f, 0.00309142f, 0.01234023f, -0.02669027f, 0.02587155f, 
    0.00765500f, -0.00651625f, -0.00665834f, -0.01128877f, 0.00180329f, -0.00977005f, -0.00954347f, -0.04199667f, 
    -0.02747313f, 0.01524067f, -0.00568211f, -0.01370506f, -0.00581775f, 0.00464062f, -0.03830206f, 0.02263983f, 
    0.00063578f, 0.02085320f, -0.02391370f, -0.02213487f, 0.02523678f, 0.00222553f, -0.02015243f, 0.01415399f, 
    -0.04040571f, -0.01916161f, 0.01957714f, 0.00831804f, 0.01354420f, 0.00033942f, -0.00746634f, -0.03119966f, 
    -0.00323444f, -0.00568264f, -0.00006597f, -0.02221088f, -0.01736298f, -0.01392214f, -0.02345932f, 0.01701542f, 
    -0.03936584f, -0.04016675f, -0.03387094f, -0.01054750f, 0.02091439f, -0.00081223f, -0.00840938f, -0.00560880f, 
    0.02215922f, -0.02246247f, 0.01878262f, 0.01631339f, 0.03921805f, -0.01972933f, -0.02533297f, -0.00001571f, 
    0.00556924f, 0.01505210f, -0.01471355f, 0.00031998f, 0.00878736f, 0.00748158f, -0.01617480f, -0.03883178f, 
    -0.01252650f, -0.03657629f, 0.02102576f, -0.01883355f, -0.02348109f, -0.00040831f, -0.00596386f, 0.01543997f, 
    -0.01669980f, -0.00824431f, 0.02817705f, 0.00123970f, 0.01809087f, -0.00600848f, -0.01588047f, -0.01465015f, 
    -0.03593304f, -0.03292390f, 0.00849698f, 0.01900791f, -0.01767455f, -0.02984393f, 0.01645086f, -0.00159989f, 
    0.02269719f, -0.02932648f, -0.03172170f, 0.02424780f, -0.00878390f, -0.01778374f, -0.00581161f, -0.02758191f, 
    -0.02274280f, 0.01773173f, -0.04122457f, -0.02860656f, -0.00319653f, -0.02915970f, 0.00882454f, -0.02156140f, 
    0.01444375f, -0.02494553f, -0.01899052f, 0.02631798f, -0.01466592f, 0.03112610f, -0.02944665f, -0.00667661f, 
    -0.01885542f, 0.01044591f, 0.01084286f, -0.01961173f, 0.01303274f, 0.00886445f, -0.00695031f, 0.00658479f, 
    0.02470634f, 0.00834276f, 0.03284303f, 0.01844759f, 0.02180153f, 0.02524160f, 0.00397678f, -0.02078076f, 
    -0.03609907f, -0.03629844f, 0.00094058f, 0.01236198f, 0.01681913f, -0.03155699f, -0.03889237f, 0.00002559f, 
    -0.01958234f, -0.02068637f, 0.01074996f, 0.00056838f, -0.01621018f, -0.02563844f, -0.03778667f, 0.01988764f, 
    -0.02084816f, 0.00547034f, -0.01332567f, -0.02238619f, -0.02268680f, 0.00748289f, 0.02755312f, -0.03325863f, 
    0.01117794f, -0.03647571f, -0.03927715f, 0.00297869f, 0.00649326f, -0.02272949f, 0.01828270f, -0.00111698f, 
    0.00114672f, -0.00093741f, -0.02120383f, -0.01043985f, 0.01659282f, -0.02278455f, -0.01662699f, -0.02636332f, 
    0.03517514f, 0.01920880f, 0.02175751f, 0.00803322f, 0.01618619f, -0.02075860f, -0.00838611f, 0.01708145f, 
    -0.00828863f, -0.01753137f, 0.00126963f, -0.00415130f, -0.00921445f, 0.02387892f, -0.00652693f, -0.01925231f, 
    -0.02997066f, -0.00045035f, -0.02799486f, -0.02757228f, -0.02787075f, -0.02825915f, -0.02442770f, -0.03000878f, 
    0.03018206f, -0.03866150f, -0.01383260f, -0.01149267f, 0.00320891f, -0.00778346f, -0.01591393f, -0.01156686f, 
    -0.00910863f, 0.02579913f, 0.00650893f, -0.00166230f, 0.03643762f, 0.00325176f, -0.00391338f, -0.00700285f, 
    -0.01709340f, -0.00376908f, 0.00856408f, 0.02612887f, 0.00753089f, -0.04095168f, -0.01151247f, -0.01289068f, 
    -0.03688797f, -0.03605982f, 0.01395364f, 0.00580136f, -0.00127459f, 0.00421195f, -0.01350215f, 0.01546091f, 
    0.01805288f, -0.02363258f, 0.00911086f, 0.02162152f, 0.00174731f, -0.00632061f, -0.01244163f, -0.00517966f, 
    0.02435464f, -0.01667292f, 0.02269429f, -0.02313672f, -0.00840823f, 0.00552024f, -0.03321965f, -0.03939055f, 
    -0.02308677f, 0.02301585f, 0.02083697f, 0.02818760f, 0.00923427f, -0.03599586f, 0.00544376f, -0.00723461f, 
    -0.03661409f, -0.00939875f, 0.01616882f, -0.03515172f, -0.00880472f, -0.01804138f, 0.00051701f, 0.02159471f, 
    0.01945314f, 0.02321871f, -0.03412205f, -0.00376355f, -0.02253277f, -0.04117260f, -0.00660298f, 0.01816343f, 
    0.02441568f, 0.00527369f, -0.02940762f, 0.01803073f, 0.01295289f, 0.00690240f, -0.01452644f, -0.02923916f, 
    -0.01244702f, 0.00969072f, 0.00348992f, -0.00379585f, 0.00893184f, 0.02418864f, 0.00793896f, 0.03316919f, 
    0.02188787f, -0.03596126f, -0.00021399f, 0.02541911f, -0.01560007f, -0.02161276f, -0.02617544f, 0.01757363f, 
    -0.01963186f, -0.02471520f, 0.01830105f, 0.00967875f, 0.01799094f, 0.02411118f, 0.00011143f, 0.02813457f, 
    -0.02350487f, -0.04069928f, 0.01189233f, 0.01074966f, -0.03017051f, 0.00180217f, -0.00043733f, -0.00041760f, 
    0.00625489f, 0.03018398f, -0.02538565f, -0.01077470f, -0.00331893f, -0.04233191f, 0.03100706f, 0.01806538f, 
    0.00024695f, -0.03229783f, 0.00498388f, 0.00996434f, 0.02955781f, -0.00107688f, -0.03988471f, 0.02287256f, 
    0.01664568f, -0.01260091f, -0.02891327f, 0.02383806f, 0.01699959f, 0.00053824f, 0.03099419f, 0.00133322f, 
    -0.02699913f, -0.00107509f, -0.04195005f, -0.00717992f, -0.03327865f, 0.00514474f, -0.03970071f, 0.02187272f, 
    -0.03626861f, -0.02074223f, -0.00913382f, -0.02591712f, 0.01279844f, -0.01960088f, 0.02033630f, 0.00637259f, 
    0.03739674f, 0.02204915f, -0.02296437f, 0.01982205f, -0.00773707f, 0.01404693f, 0.01950279f, -0.02267373f, 
    0.02656459f, -0.00897836f, -0.02215527f, -0.01898677f, -0.01178849f, 0.01173364f, 0.01794498f, 0.00101919f, 
    -0.01031626f, 0.00576656f, 0.01480677f, 0.01886773f, -0.01229442f, -0.03212153f, -0.01003948f, -0.03236705f, 
    0.02769211f, -0.01320866f, -0.01888433f, 0.01930239f, 0.00598121f, -0.01960462f, -0.03310066f, 0.00102515f, 
    -0.01460863f, 0.03026253f, -0.03721419f, 0.02061363f, -0.04139180f, -0.03512076f, 0.01236075f, -0.00950762f, 
    0.01061047f, 0.02910470f, -0.02977860f, -0.03269292f, -0.02374095f, -0.01603627f, 0.00649625f, -0.04112329f, 
    -0.02315054f, 0.02253283f, -0.00005332f, -0.00653554f, -0.01162110f, -0.02490929f, -0.00942849f, 0.02025104f, 
    0.01371132f, -0.02323023f, 0.00201972f, 0.00201013f, -0.01307828f, -0.00744434f, 0.02775187f, 0.03357608f, 
    -0.02880137f, 0.00374792f, -0.01857835f, -0.01128932f, -0.01151141f, 0.02380858f, -0.01837936f, -0.01761860f, 
    -0.00393266f, 0.02724170f, 0.00069561f, 0.02011018f, 0.01720692f, -0.03447167f, 0.01942354f, 0.01485398f, 
    0.02462799f, -0.00795752f, 0.01675699f, -0.00395838f, -0.02469105f, 0.02328663f, -0.03571781f, -0.00704793f, 
    0.01097284f, -0.03891346f, -0.00771095f, -0.02386108f, -0.00195308f, 0.00312973f, -0.03099216f, 0.00115754f, 
    0.02108471f, 0.01890336f, -0.00731155f, -0.00031658f, -0.03813326f, -0.03761153f, -0.02474513f, -0.01763361f, 
    0.02263268f, -0.00401122f, -0.01129243f, -0.02378631f, 0.00120158f, 0.01784322f, -0.02209391f, -0.00271200f, 
    -0.02908929f, -0.01258912f, -0.01602911f, -0.00219884f, 0.00091468f, 0.01108224f, 0.00636806f, -0.00205762f, 
    0.00074943f, 0.01541265f, -0.03853763f, -0.01051320f, -0.01091564f, -0.02022737f, -0.03985650f, -0.01025562f, 
    0.31390437f, 0.17509526f, 0.14300285f, 0.03138542f, 0.00544519f, 0.12083042f, -0.06771205f, 0.16687547f, 
    0.14259292f, 0.13866597f, 0.02583684f, 0.08741419f, 0.04004054f, -0.13893668f, -0.10723132f, 0.13356423f, 
    0.00616730f, -0.09806910f, -0.06770802f, -0.03519667f, 0.08903570f, 0.20070285f, 0.00246629f, 0.17336120f, 
    -0.15524253f, 0.17743377f, 0.09784935f, 0.21445647f, 0.05473106f, -0.04073359f, 0.15605302f, 0.13556710f, 
    0.02236099f, 0.05961226f, 0.11331072f, 0.22788319f, 0.02983036f, 0.24509130f, 0.02093057f, -0.33844876f, 
    0.01765027f, 0.01203042f, -0.05672927f, 0.00819707f, 0.00223404f, 0.03843731f, 0.01182623f, 0.12997541f, 
    0.29168460f, 0.11082738f, -0.12107460f, -0.03081800f, 0.01059773f, 0.02172997f, -0.14121853f, 0.07255737f, 
    0.06818955f, -0.03788168f, -0.10422841f, -0.13877213f, 0.02055256f, 0.16511633f, 0.33145419f, -0.15277675f, 
    0.12021082f, 0.06193787f, 0.16555265f, 0.03524659f, -0.06330731f, -0.19671221f, -0.04250304f, -0.22049408f, 
    -0.03563913f, -0.13874638f, -0.21543843f, 0.00074464f, 0.03544303f, -0.04965169f, 0.01233051f, 0.03740404f, 
    0.01554724f, -0.00303891f, 0.12466508f, -0.09019078f, -0.31843457f, -0.17454083f, -0.18762711f, 0.06719945f, 
    0.14832109f, -0.07890109f, -0.09454204f, -0.06905280f, 0.00290663f, -0.01342503f, -0.15352276f, -0.01749832f, 
    -0.03347880f, 0.13383412f, 0.32266611f, 0.11549777f, 0.17275070f, 0.08643972f, 0.07722443f, 0.05135224f, 
    0.02440676f, 0.00760800f, -0.01162210f, 0.19228990f, 0.00667908f, 0.06092685f, -0.18331850f, 0.01908937f, 
    0.03659504f, -0.02762394f, -0.04804792f, -0.04556227f, 0.00201763f, 0.02418085f, -0.13862860f, 0.14266860f, 
    0.03656881f, -0.06131415f, 0.16905883f, 0.21276999f, 0.03196057f, 0.02555150f, 0.05530617f, 0.04878876f, 
    -0.02880278f, -0.05681927f, -0.04998336f, -0.09810525f, -0.17661716f, -0.01673294f, 0.13865523f, 0.22253633f, 
    0.07137671f, -0.05132985f, 0.06526270f, -0.05658102f, -0.03768762f, 0.00763473f, -0.03546703f, 0.04573558f, 
    0.01760370f, 0.51793391f, 0.15723991f, 0.03101051f, -0.01226780f, 0.03520498f, 0.02847111f, -0.01368826f, 
    0.11118845f, -0.17525746f, 0.06275833f, -0.01284042f, 0.21665534f, 0.20110661f, -0.18943535f, 0.03611355f, 
    -0.04737271f, -0.08464807f, -0.07021908f, -0.04452358f, -0.06010690f, -0.06425914f, -0.06726144f, -0.05662886f, 
    -0.19437367f, -0.17325562f, -0.07277168f, -0.06376750f, -0.01376577f, 0.01705376f, -0.08109827f, 0.16902336f, 
    -0.02142803f, 0.01615377f, -0.09950677f, -0.06918838f, -0.22591217f, -0.12903897f, -0.50529701f, -0.19747736f, 
    -0.02702346f, 0.00472629f, 0.00870353f, -0.03617378f, 0.13217103f, 0.05345564f, 0.04169327f, -0.00896866f, 
    -0.06069597f, -0.12903872f, -0.13661779f, 0.02361673f, -0.03066000f, 0.11144453f, 0.05653369f, 0.07952560f, 
    0.09599540f, -0.10508868f, -0.12063984f, -0.09134517f, 0.07217968f, 0.37297952f, 0.20799257f, 0.34648463f, 
    0.03159345f, -0.04187541f, 0.03363786f, 0.05792801f, 0.04621910f, -0.02229856f, 0.03428621f, -0.02292302f, 
    0.04692787f, 0.08280016f, 0.03160459f, 0.09703569f, 0.15572834f, 0.03712192f, 0.10070904f, -0.06362225f, 
    -0.01241047f, -0.01237873f, -0.04615794f, 0.17238264f, -0.00887243f, -0.00765782f, 0.04638541f, 0.12213500f, 
    0.04281205f, 0.08619004f, -0.03847519f, 0.03230638f, 0.13544141f, -0.04248314f, -0.03396253f, -0.06781291f, 
    0.04366602f, 0.26813760f, -0.05875490f, 0.25760385f, 0.02257599f, 0.11604428f, -0.13130662f, 0.09961716f, 
    -0.15934899f, 0.04900599f, -0.08107501f, 0.05205778f, -0.00621860f, -0.19187121f, -0.20892666f, -0.06866767f, 
    0.09350341f, 0.07338636f, 0.04680456f, 0.02591551f, -0.01478322f, -0.07029920f, -0.10045212f, -0.10169287f, 
    0.14361981f, 0.01245042f, 0.11016232f, 0.01466953f, -0.13830313f, 0.01443549f, 0.08993979f, -0.11014570f, 
    0.16025676f, 0.06477761f, 0.06371073f, 0.06688450f, -0.02524575f, -0.07276463f, -0.24338152f, 0.17595224f, 
    -0.02443555f, -0.01439708f, -0.09919582f, 0.06000681f, 0.02172353f, 0.10818784f, -0.01938996f, 0.09550538f, 
    0.10116178f, 0.52639180f, 0.06770021f, -0.18099962f, 0.07662202f, 0.09187960f, -0.17477022f, -0.03495074f, 
    0.17989729f, 0.00533298f, 0.11896947f, 0.20681174f, 0.07587066f, 0.21916598f, 0.06721273f, -0.09213484f, 
    0.08601379f, 0.08233295f, 0.08420476f, -0.06734063f, -0.06978599f, -0.07201426f, 0.06455506f, 0.04993336f, 
    0.09824493f, -0.07437063f, 0.10213302f, 0.18319851f, -0.08449345f, -0.00787858f, -0.05023595f, 0.09821369f, 
    -0.02436485f, 0.02134412f, -0.18073788f, -0.10046998f, 0.03997514f, 0.11818761f, 0.36418238f, 0.04981330f, 
    -0.01595735f, 0.08492816f, 0.17796807f, -0.04776002f, -0.02128663f, 0.05308617f, 0.04288692f, 0.15979996f, 
    0.04915502f, 0.20939884f, -0.12824488f, 0.05730128f, 0.24564055f, 0.04690246f, -0.06559242f, 0.04545344f, 
    0.07336169f, -0.15298109f, -0.15456453f, -0.08315923f, 0.15345968f, 0.18497570f, 0.23934297f, 0.26914680f, 
    -0.07424774f, -0.02526427f, 0.12140413f, 0.18809211f, 0.12185522f, -0.00606902f, -0.06221094f, 0.20042910f, 
    0.10131172f, -0.00635607f, -0.18076271f, 0.09367623f, 0.18985148f, 0.10866681f, 0.00882797f, -0.00447914f, 
    0.10828076f, 0.06544251f, 0.00953905f, 0.10789238f, 0.28951812f, 0.38979879f, -0.11378155f, 0.07675502f, 
    -0.02100243f, -0.06860077f, -0.01685677f, 0.05927516f, -0.01147488f, 0.08966248f, -0.05341397f, 0.15922146f, 
    0.33228755f, 0.07735445f, -0.24948536f, -0.04275414f, 0.08728439f, -0.01714852f, 0.08649997f, 0.08420150f, 
    0.03261505f, -0.05772734f, -0.01366620f, 0.17389782f, -0.12110700f, -0.41490105f, -0.52369028f, -0.24929129f, 
    0.07467466f, -0.19319920f, -0.04923545f, 0.04529676f, 0.08124303f, 0.05405219f, -0.13937631f, -0.02269174f, 
    0.19877560f, 0.05390115f, 0.08054244f, 0.22296198f, 0.03997783f, 0.03606015f, 0.10852895f, -0.06630585f, 
    0.08861113f, -0.03042631f, 0.05757735f, 0.20533505f, -0.13242140f, -0.10220391f, -0.26553896f, 0.06477880f, 
    -0.18798690f, -0.05640268f, -0.06884792f, 0.11335409f, 0.05336418f, 0.14126888f, -0.04736417f, 0.04427227f, 
    0.08545619f, -0.15446348f, -0.39141905f, -0.04781787f, -0.04695558f, -0.00732940f, -0.05003341f, 0.05716270f, 
    -0.01217955f, -0.12461010f, -0.01374187f, -0.08541895f, -0.02131517f, -0.01753777f, -0.00376683f, -0.07627057f, 
    0.14471596f, -0.03543969f, 0.05229877f, 0.03662428f, -0.02632478f, -0.08294394f, -0.13624805f, -0.16620439f, 
    -0.15746482f, -0.37311184f, -0.20778869f, -0.13349779f, 0.02953832f, -0.07663053f, -0.01954817f, -0.02014937f, 
    0.23454732f, 0.11397702f, 0.28321770f, 0.17534085f, -0.04202206f, 0.41097420f, -0.29337069f, -0.24772839f, 
    -0.00144547f, 0.07808287f, -0.05956039f, 0.08730517f, 0.15736721f, -0.00013220f, 0.03558283f, 0.05124124f, 
    -0.02721617f, -0.15965398f, 0.43527034f, 0.17970178f, -0.01809403f, 0.07136784f, -0.04038902f, 0.03344410f, 
    -0.02115279f, -0.00442410f, 0.03214795f, 0.02219601f, 0.18235949f, 0.03010065f, 0.23106624f, 0.32063997f, 
    -0.06125120f, 0.02089067f, 0.04298357f, 0.15376988f, -0.04709342f, 0.03582272f, 0.02831056f, 0.19705451f, 
    -0.16013120f, -0.04415808f, -0.36201310f, 0.12815054f, -0.00880640f, 0.04069504f, -0.13935786f, 0.10143776f, 
    -0.07518801f, 0.00744604f, 0.07308596f, -0.10264454f, -0.02153992f, 0.17869742f, -0.01045096f, 0.07460180f, 
    0.00491133f, 0.07883730f, 0.08891963f, -0.01107446f, 0.01838130f, 0.03559140f, 0.08449399f, 0.15700670f, 
    -0.04066321f, 0.14356372f, 0.17790431f, 0.07869106f, 0.01060131f, -0.09650603f, -0.04856377f, 0.03328529f, 
    0.00591505f, -0.09595372f, -0.02172876f, 0.08377656f, 0.08298105f, 0.00543482f, -0.04210316f, 0.22756398f, 
    0.01361803f, -0.02881356f, 0.02829642f, 0.03519749f, -0.06415655f, 0.03052840f, 0.08576957f, -0.01939903f, 
    0.00602569f, -0.23718084f, 0.05020748f, -0.00219792f, -0.01540500f, -0.04367438f, -0.06185291f, -0.07751058f, 
    0.19509901f, -0.07431981f, -0.02729128f, 0.16795160f, -0.09757401f, 0.10628863f, 0.19942127f, 0.22497532f, 
    -0.05944780f, 0.02049763f, 0.05809860f, 0.09541865f, 0.08562100f, 0.03937439f, 0.12992853f, 0.21201319f, 
    -0.09716896f, -0.12870228f, 0.01323201f, 0.05163874f, 0.06118805f, 0.01100573f, -0.08338059f, 0.15506095f, 
    0.02298944f, 0.18479653f, 0.14904751f, 0.19820739f, -0.14510655f, -0.15125187f, -0.11602683f, -0.45840406f, 
    -0.03241154f, 0.00699422f, 0.07689933f, -0.08185213f, 0.19167005f, -0.04080312f, 0.02878086f, -0.01576448f, 
    0.10885313f, 0.16856730f, -0.05842975f, 0.17340665f, 0.14284374f, -0.04147051f, -0.13755953f, 0.26402706f, 
    0.09652162f, -0.07142228f, 0.10806651f, 0.14655434f, -0.22163929f, 0.00208250f, 0.11053602f, 0.14664099f, 
    0.24990743f, -0.01309721f, -0.05121699f, 0.02949377f, 0.02927866f, -0.03062973f, 0.05960795f, 0.11031166f, 
    -0.10202314f, -0.15138549f, 0.01415754f, -0.09139624f, -0.05935530f, 0.01211750f, 0.00410811f, -0.04838274f, 
    -0.04406226f, 0.05943812f, 0.09790796f, 0.15039799f, -0.02007721f, -0.33607516f, -0.12258774f, 0.05914393f, 
    -0.09936979f, 0.01515654f, -0.09603406f, 0.23301150f, 0.06951284f, -0.28200403f, 0.00298814f, -0.22045735f, 
    0.16264074f, 0.16495150f, -0.17460373f, -0.04638041f, 0.16190593f, -0.02571979f, -0.11063685f, -0.13415612f, 
    -0.05136748f, -0.00963670f, 0.09495844f, -0.01738164f, -0.08973336f, -0.16930982f, -0.24958789f, -0.05815797f, 
    -0.02210350f, 0.07279513f, 0.03100416f, -0.04244387f, -0.01059780f, -0.01706103f, -0.14251097f, -0.17111677f, 
    -0.10908740f, 0.32269949f, 0.10448570f, 0.31256017f, 0.07511048f, 0.10868993f, -0.00900339f, 0.01997143f, 
    -0.01763284f, -0.11572911f, -0.04428054f, 0.02389341f, 0.07353598f, -0.13811053f, -0.12096890f, -0.02098243f, 
    -0.02435998f, 0.11021686f, -0.09555294f, -0.19667178f, 0.16387536f, -0.03464457f, -0.07280426f, -0.11076114f, 
    -0.04513690f, -0.12740004f, 0.26659620f, 0.05171764f, 0.11686613f, 0.04332519f, 0.01430800f, 0.01809344f, 
    -0.02825420f, -0.00583941f, -0.01171423f, 0.15630586f, -0.27635577f, -0.35085246f, -0.12102880f, 0.05538119f, 
    0.15057921f, -0.09579397f, -0.08246315f, 0.06116183f, -0.04561722f, 0.00918106f, -0.00440404f, 0.09208401f, 
    0.03906186f, -0.45184848f, -0.19702113f, 0.12756313f, 0.16652147f, -0.01423745f, -0.15074350f, -0.07862157f, 
    -0.09159783f, 0.01660115f, -0.07655710f, 0.12446555f, 0.12537006f, 0.24433894f, 0.06919033f, -0.05832198f, 
    -0.01504965f, -0.07460308f, 0.02898268f, 0.05654901f, 0.13720825f, -0.00237458f, -0.00951600f, -0.04664306f, 
    -0.02958689f, -0.14388499f, -0.06291667f, -0.07775977f, 0.16187142f, -0.00428910f, -0.10349808f, 0.03785423f, 
    0.09141873f, -0.10961811f, 0.07516467f, 0.05797454f, 0.10699543f, 0.05289910f, -0.11131592f, -0.08455001f, 
    -0.07830743f, -0.06857279f, -0.06342015f, 0.05317955f, 0.06248501f, -0.02018539f, -0.15811914f, -0.14718318f, 
    -0.16616181f, 0.10086251f, 0.21394452f, -0.45943660f, -0.02835596f, -0.02469443f, -0.01424056f, -0.07961391f, 
    0.07698146f, -0.02843388f, -0.04895348f, -0.08159156f, -0.32226056f, -0.21544790f, 0.32165617f, 0.49883848f, 
    0.08795922f, -0.08669677f, -0.05242867f, -0.09405322f, 0.18860036f, -0.04105736f, 0.08515308f, 0.07918130f, 
    -0.33641106f, -0.15208486f, -0.08214038f, -0.23572794f, 0.01299215f, -0.13528861f, -0.12149558f, -0.19354852f, 
    0.11669935f, -0.04957722f, -0.01362239f, 0.01102562f, 0.74956322f, -0.17020997f, 0.14321309f, 0.01284152f, 
    0.00016749f, -0.11049608f, -0.06324374f, 0.02287848f, -0.10976230f, 0.05769883f, 0.06326547f, 0.13256048f, 
    -0.15616797f, 0.07002202f, 0.23663348f, -0.05447638f, -0.09512828f, 0.00143432f, -0.07280586f, 0.12328297f, 
    0.07600392f, -0.11602822f, 0.01212088f, 0.00072269f, 0.10862200f, -0.00255758f, 0.04597668f, 0.11326641f, 
    0.20970084f, 0.02017888f, 0.11539070f, 0.24132082f, -0.02893325f, 0.06349088f, -0.03510937f, -0.03775351f, 
    -0.12468184f, 0.06469154f, 0.12519291f, 0.23860036f, -0.07992504f, -0.02678333f, -0.07377085f, -0.14738290f, 
    0.13220710f, 0.09727976f, 0.18696512f, 0.08227884f, 0.23003620f, 0.17803480f, 0.06699543f, 0.16888885f, 
    0.04119711f, 0.02615619f, -0.06178722f, -0.09165340f, 0.07520148f, -0.01822844f, 0.12230411f, -0.04393709f, 
    -0.00173422f, -0.05199309f, 0.06209860f, -0.03827169f, -0.05493928f, 0.06587477f, 0.05200972f, 0.25197926f, 
    0.14741804f, 0.19699495f, 0.10496863f, 0.00469613f, 0.11293934f, 0.05845137f, 0.17884783f, 0.21803540f, 
    0.03544304f, -0.10799885f, -0.00133914f, -0.12884115f, 0.10940518f, 0.00580723f, 0.05543776f, 0.00567918f, 
    -0.03662198f, 0.07867902f, 0.15374973f, 0.10460708f, 0.05687715f, 0.05014192f, 0.05308485f, 0.21644996f, 
    0.04953036f, -0.12329102f, -0.01021393f, -0.11986378f, -0.05984077f, 0.08242533f, 0.23725909f, 0.05470444f, 
    0.09979971f, 0.03158360f, -0.04965204f, 0.21927099f, 0.06032306f, -0.01389704f, -0.03866156f, 0.01796497f, 
    0.14652582f, -0.11272562f, 0.22735131f, -0.26996660f, -0.02631570f, -0.20478269f, -0.10293159f, 0.03272509f, 
    0.10244735f, 0.11640290f, 0.13340816f, 0.05661661f, 0.43460494f, -0.18724030f, 0.20012477f, -0.40815994f, 
    0.08217473f, -0.01383869f, 0.08715510f, -0.00492215f, -0.16240025f, 0.03265705f, 0.04270666f, -0.04793114f, 
    -0.06099226f, -0.06899242f, 0.27337056f, -0.08118517f, 0.04733542f, 0.05993694f, 0.02482955f, 0.03165690f, 
    0.07317308f, -0.07290833f, -0.06911240f, -0.06426099f, 0.31679770f, 0.36723951f, -0.21432416f, 0.18545921f, 
    0.10495646f, -0.06056955f, -0.03393806f, -0.11013915f, 0.05321040f, -0.00921477f, 0.03985265f, -0.07222353f, 
    0.18290983f, -0.03825572f, 0.01382248f, -0.11379445f, 0.07787482f, 0.11495796f, 0.13681941f, 0.05503042f, 
    -0.03526590f, -0.02515546f, -0.08128045f, -0.11254895f, -0.02872714f, -0.09596144f, 0.16846907f, -0.22859266f, 
    0.05856429f, -0.05036010f, -0.05486907f, 0.05843260f, 0.04731493f, 0.01605835f, 0.00389350f, 0.10290156f, 
    -0.07117333f, -0.36908132f, 0.09071691f, 0.14563225f, 0.05222721f, 0.06881920f, 0.10965121f, 0.09853679f, 
    0.19349487f, 0.02802085f, 0.01175575f, 0.00612217f, 0.02649670f, 0.38455167f, 0.03771930f, 0.02442875f, 
    0.04676890f, -0.13186792f, 0.02718326f, 0.01873374f, -0.12825614f, -0.07403123f, -0.06403887f, -0.03086688f, 
    0.02825775f, -0.19037907f, 0.10904850f, -0.30199635f, 0.00600345f, -0.01187184f, 0.05758915f, 0.00254360f, 
    -0.02052156f, 0.03672069f, 0.05362588f, -0.02721777f, 0.25966781f, -0.00654098f, -0.02209273f, 0.03638444f, 
    -0.02677578f, -0.01356943f, 0.04736312f, -0.09246840f, 0.03818275f, -0.04266394f, -0.02478223f, -0.09538738f, 
    -0.15845761f, 0.06425101f, -0.01119897f, -0.05757678f, 0.10280371f, -0.01182031f, 0.00326918f, 0.26763535f, 
    0.10811216f, 0.00944734f, 0.14277470f, 0.22846854f, -0.08816129f, 0.15986788f, -0.22406144f, -0.03635103f, 
    0.12447193f, 0.20257337f, 0.20124878f, 0.08678962f, 0.17809708f, -0.02443526f, -0.04917201f, 0.04429549f, 
    0.24129745f, -0.00666830f, 0.24764465f, -0.39236501f, -0.11250218f, -0.02700181f, 0.19016397f, 0.17101537f, 
    -0.08856694f, 0.11884785f, 0.06943788f, 0.00366103f, 0.19964196f, -0.00853811f, 0.27322429f, -0.06503589f, 
    0.01016112f, 0.09714879f, 0.24445684f, 0.06003289f, 0.14869340f, 0.11324378f, 0.01147498f, 0.05795942f, 
    -0.25062084f, 0.09860025f, -0.04673943f, 0.07780456f, -0.07227555f, 0.10462254f, 0.10816704f, -0.18583092f, 
    -0.07178148f, 0.09660627f, -0.07686912f, 0.14634767f, 0.19593552f, 0.14079748f, -0.11161738f, -0.11992944f, 
    -0.05735383f, 0.00162373f, 0.00090713f, -0.03705695f, 0.02832376f, 0.01289298f, -0.03599122f, 0.04786937f, 
    -0.17616062f, 0.03856497f, 0.15722735f, -0.15125419f, 0.18715227f, 0.08940436f, 0.13607179f, 0.13349885f, 
    -0.06938192f, -0.06361829f, 0.10906265f, 0.11052961f, 0.01216744f, 0.08689386f, -0.12077177f, -0.23241076f, 
    -0.09489452f, -0.10389367f, -0.14777997f, -0.27549979f, -0.03238579f, -0.00471923f, 0.03865030f, -0.10604925f, 
    0.35018432f, 0.19629888f, -0.13867445f, -0.24687088f, -0.02775741f, 0.02255236f, 0.06756426f, 0.13126579f, 
    0.03601777f, -0.02328181f, 0.05718669f, 0.09506451f, -0.03053766f, -0.25304022f, 0.22742894f, -0.31838202f, 
    -0.02829560f, -0.10464093f, -0.00811875f, -0.02203245f, 0.18633716f, 0.12787290f, 0.12318784f, -0.03739240f, 
    0.05619660f, -0.18404168f, 0.22230075f, -0.39630109f, -0.03008958f, 0.02737861f, -0.01806288f, 0.10597234f, 
    0.07964614f, 0.07862888f, 0.11692245f, 0.06956873f, -0.28111997f, -0.16126657f, 0.12909193f, 0.30223167f, 
    -0.09205353f, 0.07079449f, -0.07511370f, -0.07110400f, 0.06513623f, -0.08968347f, 0.02667227f, -0.05784928f, 
    -0.12286229f, 0.13709375f, 0.05549757f, 0.04646177f, 0.14389355f, -0.09023279f, -0.02777685f, 0.22055840f, 
    0.11692414f, 0.04459264f, 0.16082142f, 0.13499734f, -0.28699210f, 0.01474115f, 0.21180822f, -0.01780038f, 
    0.14437595f, 0.04902313f, 0.02836721f, -0.14797333f, 0.21492697f, -0.02958275f, 0.17425364f, 0.10656011f, 
    0.43266362f, 0.25859004f, 0.13979724f, 0.20073248f, 0.14992195f, -0.10974828f, 0.32731873f, 0.06921738f, 
    -0.05126446f, -0.04065269f, -0.10758743f, 0.07497880f, 0.03600224f, -0.06421469f, 0.16202441f, 0.12581834f, 
    0.04635110f, 0.04295369f, 0.03303681f, 0.06693900f, 0.03262793f, 0.04877885f, -0.08227685f, -0.04225089f, 
    0.13360769f, 0.08591860f, 0.17606303f, 0.14180312f, -0.03308012f, -0.04601933f, -0.05088142f, -0.12037028f, 
    0.03778297f, 0.28556064f, -0.08450582f, 0.04198055f, 0.41163394f, -0.31495905f, 0.15687843f, -0.14151563f, 
    -0.11237627f, -0.12018885f, 0.22517839f, -0.04947150f, 0.01782357f, 0.01739380f, 0.15750970f, -0.02062980f, 
    -0.28827405f, -0.34465814f, 0.13546363f, 0.01192415f, 0.03748216f, 0.06748794f, 0.12120601f, 0.12414625f, 
    0.06999549f, -0.03436768f, 0.06797104f, 0.00537198f, 0.00959461f, 0.12293771f, -0.09564869f, -0.18473792f, 
    -0.06004757f, -0.16018811f, -0.14525691f, -0.17333256f, 0.03406651f, -0.04486413f, 0.02720617f, 0.02915022f, 
    -0.17610383f, -0.13837072f, 0.05739165f, -0.12427735f, 0.05604010f, 0.09087775f, 0.13379830f, -0.05237251f, 
    -0.02421527f, 0.12109913f, -0.07588608f, -0.10118049f, -0.12503468f, -0.22592491f, 0.15490523f, 0.18843494f, 
    0.08814055f, 0.05043595f, 0.08321477f, 0.13799846f, 0.09902298f, 0.08566505f, 0.01389380f, 0.08242676f, 
    0.15527731f, 0.04409181f, 0.12416308f, 0.07619291f, 0.02768795f, 0.17543398f, 0.15260032f, 0.02257202f, 
    0.00602421f, 0.07527699f, 0.04332370f, -0.06142939f, -0.32926092f, 0.18480647f, 0.22814044f, 0.29593456f, 
    0.07624105f, -0.06942219f, 0.06491823f, -0.10941967f, 0.04364829f, -0.06454516f, 0.07609464f, -0.09181871f, 
    0.17259850f, -0.03718874f, 0.15924814f, 0.05968944f, -0.03112884f, 0.11464617f, 0.10853072f, 0.18583949f, 
    0.11558824f, -0.11474617f, 0.06237506f, 0.07849906f, -0.13215119f, -0.13965023f, -0.06447821f, -0.07436779f, 
    -0.06068454f, -0.02637549f, -0.15572847f, -0.15349670f, 0.15832765f, -0.02198840f, -0.00003215f, 0.00361590f, 
    -0.11133266f, -0.10178503f, -0.04955930f, 0.05950223f, -0.06560448f, -0.00644609f, 0.03297751f, -0.15822665f, 
    0.29314908f, 0.02677725f, -0.12329290f, 0.04422824f, 0.56093329f, -0.02621226f, -0.04852085f, 0.24240416f, 
    0.00869025f, -0.00893812f, 0.15205967f, 0.07976764f, -0.00412844f, 0.08911368f, 0.05726440f, -0.02834943f, 
    -0.53486282f, 0.06812815f, -0.03483066f, -0.41494057f, 0.00660559f, 0.03459298f, 0.02319327f, -0.05814875f, 
    0.01489991f, 0.03031097f, 0.09381779f, 0.10650771f, -0.15745339f, 0.13521567f, -0.00908650f, 0.05075736f, 
    0.00919206f, 0.02229273f, 0.10090980f, 0.16320975f, 0.14137784f, 0.08920836f, 0.02105527f, 0.14755760f, 
    0.32043251f, -0.29577872f, 0.07989579f, 0.20771344f, -0.00352111f, 0.13555776f, -0.01899801f, 0.07228455f, 
    0.17966975f, 0.01100519f, -0.04140363f, 0.29216319f, -0.14930069f, 0.03173345f, -0.02090622f, 0.04314724f, 
    0.14138566f, 0.09177306f, 0.04585228f, 0.02283708f, -0.02779474f, -0.10268541f, -0.09611031f, -0.10514548f, 
    -0.01692799f, 0.05818469f, 0.11731233f, 0.19242322f, -0.12229887f, 0.16780934f, 0.07421080f, 0.19297586f, 
    0.08103534f, -0.00793559f, 0.01655660f, 0.09829404f, 0.58170325f, 0.25636148f, -0.30642638f, -0.10161562f, 
    0.18424639f, -0.01577315f, 0.03206177f, 0.12090054f, -0.00986546f, -0.06252582f, -0.08417289f, -0.01709502f, 
    -0.14973533f, 0.10844883f, 0.04476766f, -0.12961610f, 0.11070330f, 0.01244409f, 0.02352076f, 0.00852578f, 
    0.01601990f, 0.07387499f, 0.10637876f, -0.00081090f, -0.09998383f, 0.03862149f, 0.04769166f, -0.35159090f, 
    0.03393983f, -0.06227962f, 0.02286771f, 0.22721091f, -0.05688213f, -0.09083935f, 0.13754451f, 0.01356720f, 
    -0.04472029f, -0.02173564f, 0.07172573f, -0.16721067f, 0.05265031f, 0.07983862f, -0.04671848f, 0.18856630f, 
    0.11545830f, -0.04474391f, -0.08895227f, -0.00927145f, 0.01748606f, -0.08141168f, 0.04442209f, 0.19283377f, 
    -0.01814208f, 0.04106442f, -0.01860323f, -0.11127453f, 0.12404841f, 0.06646778f, -0.15640049f, -0.03578641f, 
    -0.47239548f, -0.29364786f, 0.35299081f, 0.35971874f, -0.03640434f, 0.05610482f, -0.02472241f, -0.16770783f, 
    0.19400959f, -0.02608088f, -0.10202882f, 0.13322404f, -0.15064485f, 0.10937770f, 0.23163964f, 0.21335015f, 
    -0.04700785f, -0.04892310f, 0.06521867f, 0.19947830f, -0.11016248f, -0.01651256f, 0.26132536f, -0.10001748f, 
    0.12184364f, -0.01107673f, 0.07375862f, 0.11218446f, 0.02683166f, -0.01898484f, 0.02529014f, -0.06876840f, 
    0.16366574f, 0.19533299f, 0.03337989f, -0.13169317f, 0.00411466f, 0.04555957f, 0.13377476f, -0.22716741f, 
    0.06570063f, 0.07091129f, 0.13522947f, -0.05220032f, -0.08726188f, 0.05579200f, -0.08984092f, -0.12826790f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02503431f, 0.00325738f, 0.19916546f, 0.08770154f, 0.00536751f, 0.02181743f, -0.02072844f, 0.06825042f, 
    -0.11017001f, 0.03656099f, -0.02354882f, -0.03435592f, -0.01069513f, 0.12988429f, 0.01609954f, 0.04140213f, 
    -0.02724233f, 0.00277374f, 0.08833219f, 0.07396755f, 0.10943265f, 0.00609691f, -0.04504211f, -0.00977873f, 
    -0.03280777f, -0.01927854f, 0.02772302f, 0.03058528f, -0.02651967f, 0.02758436f, 0.07847530f, 0.12171658f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05592225f, 0.10921086f, -0.02709826f, 0.20974334f, -0.04596084f, 0.08366839f, 0.12090658f, 0.24389146f, 
    -0.40119952f, -0.32942227f, -0.06006650f, 0.00334120f, 0.02256137f, 0.15205400f, 0.03616022f, -0.43620646f, 
    -0.02805966f, 0.03542406f, 0.27401280f, -0.02558579f, 0.30923903f, 0.09474903f, -0.23113999f, -0.01188468f, 
    -0.11235922f, 0.01071081f, -0.11672175f, -0.00245964f, 0.14209621f, -0.08631901f, 0.29529774f, 0.23455796f, 
    -0.10299176f, -0.14928120f, -0.14841934f, 0.23435724f, -0.14360094f, 0.03120707f, -0.08734063f, -0.03405766f, 
    -0.13584097f, 0.22196287f, 0.07484784f, -0.11402600f, -0.15960933f, -0.52287215f, -0.14746302f, 0.49194244f, 
    0.14700454f, 0.09801725f, 0.16458355f, -0.03185346f, 0.07109692f, -0.06416963f, 0.14937444f, 0.10415603f, 
    -0.11879901f, -0.14027627f, -0.09818997f, 0.03593101f, -0.09188318f, 0.15560059f, -0.35762218f, 0.23134217f, 
    -0.12727612f, 0.07713566f, 0.54920298f, 0.13867943f, -0.01209100f, -0.12567405f, -0.15019339f, 0.02984010f, 
    -0.25844979f, 0.02166407f, 0.14536855f, 0.08687204f, -0.00673167f, 0.42656642f, 0.18200308f, 0.38409343f, 
    0.15741299f, -0.14174238f, -0.34426641f, 0.14106391f, 0.15249842f, -0.11884117f, 0.11954346f, -0.01189418f, 
    -0.14318378f, 0.15479872f, -0.00160266f, -0.02194116f, -0.00792427f, -0.06520122f, -0.09173583f, 0.18453418f, 
    0.14352120f, 0.16265449f, 0.22575538f, -0.08030833f, 0.03198796f, -0.15083417f, 0.06176480f, -0.02464381f, 
    0.32600886f, 0.14411442f, 0.08837575f, 0.02607562f, -0.01331238f, -0.21189894f, -0.11203576f, 0.12646660f, 
    0.07328580f, -0.31369716f, -0.03014759f, 0.21667933f, 0.17442493f, -0.11147715f, -0.21609031f, -0.05023295f, 
    -0.11697196f, -0.02263311f, -0.06538365f, -0.07216984f, 0.05032745f, 0.02806493f, -0.18050389f, 0.14144836f, 
    -0.12425468f, 0.07457836f, 0.14907476f, 0.42164060f, 0.04089810f, -0.07451476f, 0.04519541f, 0.13061225f, 
    -0.01689057f, -0.03576540f, -0.00682191f, 0.06720670f, 0.13693656f, -0.13571076f, -0.06693161f, 0.09337051f, 
    -0.15491624f, -0.17282191f, -0.22750382f, -0.38250661f, 0.28460664f, 0.00281431f, 0.42405754f, -0.08328293f, 
    -0.14297476f, 0.08869299f, -0.15163709f, -0.13320211f, 0.05743134f, 0.12664554f, 0.21643363f, 0.05983215f, 
    -0.06159831f, 0.02594751f, 0.47310445f, 0.45621541f, -0.04075681f, -0.05408412f, 0.12162767f, 0.13729985f, 
    -0.00405328f, -0.24639188f, 0.10730042f, 0.03081010f, 0.15893827f, -0.13234532f, 0.10186180f, 0.07381982f, 
    0.07252602f, -0.14546899f, 0.16464156f, -0.38505822f, -0.30715719f, 0.10061704f, -0.30711502f, -0.00795536f, 
    0.15981525f, 0.09306974f, 0.14033607f, -0.09837280f, -0.02242466f, 0.17245080f, 0.07758307f, 0.24755019f, 
    -0.14615524f, 0.16369629f, -0.07868633f, -0.01113681f, 0.16269033f, -0.03491546f, -0.17450441f, -0.01211879f, 
    -0.02730994f, -0.10581139f, -0.08127592f, 0.00789120f, -0.01727193f, -0.00552142f, -0.03166857f, 0.04900985f, 
    0.13170953f, -0.10684892f, 0.13318609f, -0.11680256f, -0.09246243f, 0.05838837f, -0.06677663f, -0.08427787f, 
    0.01181431f, 0.14351235f, -0.08398034f, 0.09455542f, -0.17314509f, 0.13167541f, -0.14792852f, -0.10399952f, 
    0.00950355f, -0.07321732f, 0.08650550f, 0.14535414f, 0.13429807f, 0.13997546f, -0.12368467f, -0.03100516f, 
    0.19281614f, -0.41633055f, 0.05774188f, 0.00850392f, -0.06621418f, 0.16076455f, 0.06973163f, -0.25393865f, 
    0.14319880f, -0.01733176f, -0.17664164f, -0.16879500f, -0.12381262f, 0.17476724f, 0.23921590f, -0.13546522f, 
    -0.17558530f, 0.10924793f, -0.08853942f, -0.06393678f, 0.15463421f, -0.00489937f, 0.12039973f, 0.22965810f, 
    0.09683230f, -0.00818370f, 0.26211795f, 0.01822178f, -0.01729262f, -0.13313271f, -0.01921258f, -0.01602460f, 
    -0.29551736f, -0.19823657f, 0.10941947f, 0.00262998f, 0.11455332f, 0.04628791f, 0.05343045f, -0.22303617f, 
    -0.15987724f, 0.01909437f, 0.17273065f, 0.16428541f, 0.41137913f, 0.13007809f, 0.03613451f, 0.07323381f, 
    0.11839724f, 0.17286968f, -0.12354238f, 0.01580939f, -0.01232995f, 0.01456587f, 0.30880466f, -0.04556368f, 
    0.01186076f, -0.09255812f, -0.28595564f, -0.36547375f, -0.10664292f, -0.10921418f, -0.16932975f, 0.33353284f, 
    -0.14487298f, -0.11209940f, 0.08988583f, -0.09001935f, -0.01094280f, 0.37808943f, -0.11534400f, -0.30178383f, 
    0.11190118f, 0.01993696f, 0.08354215f, 0.06924489f, 0.21325773f, -0.09774225f, -0.12094700f, 0.05890874f, 
    0.10937347f, -0.16859546f, 0.14264016f, -0.11804321f, -0.12674677f, 0.04496238f, 0.30114621f, 0.26984891f, 
    -0.15484075f, 0.07048951f, -0.53754938f, 0.12741280f, 0.17588182f, 0.05125155f, -0.08751849f, 0.07355309f, 
    -0.04266487f, 0.13927627f, -0.14236939f, 0.11662780f, 0.16267449f, 0.38723114f, 0.17672257f, -0.16434959f, 
    -0.14435977f, -0.03270591f, 0.02548135f, 0.03172362f, 0.41581714f, -0.08382505f, -0.25630775f, -0.02972722f, 
    0.05930388f, -0.08452144f, 0.06267303f, -0.02287058f, -0.06402551f, 0.07186432f, -0.05417953f, 0.28194952f, 
    -0.16891091f, -0.14081858f, -0.34629256f, -0.61633283f, 0.15383349f, -0.09842604f, -0.02412275f, -0.02301987f, 
    0.09570434f, -0.02650147f, 0.05814208f, 0.08894335f, -0.17611909f, 0.24098802f, -0.04969556f, -0.09181625f, 
    -0.05805199f, 0.20545954f, 0.04243733f, 0.13311838f, -0.14640112f, -0.07513175f, 0.04099948f, -0.15834507f, 
    0.06873830f, -0.02325227f, -0.17244405f, -0.11839260f, -0.05189941f, 0.05647654f, -0.25144798f, 0.17340678f, 
    -0.14361337f, -0.16609812f, -0.06882595f, 0.35424453f, 0.12345787f, 0.07180601f, -0.09495717f, -0.10431884f, 
    0.25157133f, -0.29899654f, -0.08597852f, 0.14255278f, 0.01843715f, 0.05670257f, -0.11794119f, -0.07651247f, 
    -0.03611977f, 0.17092012f, 0.08400670f, 0.01935616f, -0.16568413f, -0.00642866f, -0.12401579f, 0.10800583f, 
    0.14341727f, 0.00134040f, -0.13455521f, -0.06137980f, 0.11778536f, 0.04958694f, -0.11840604f, 0.03365691f, 
    -0.08898919f, 0.07841717f, 0.21808681f, 0.00719175f, 0.12347038f, -0.03943816f, -0.10581654f, -0.07530606f, 
    0.06121595f, 0.14858136f, 0.08098014f, 0.06781107f, -0.15006582f, 0.28367084f, 0.05009693f, 0.37482822f, 
    -0.02365266f, 0.26930779f, -0.07883173f, 0.07189272f, 0.28387907f, -0.15651767f, 0.17605300f, 0.03184582f, 
    0.01232100f, 0.00258118f, -0.07638525f, -0.16646281f, -0.06996798f, -0.13635108f, -0.38377449f, -0.12334309f, 
    0.11248519f, -0.12211291f, -0.40020555f, 0.21632259f, 0.15194064f, -0.02795009f, 0.11866460f, 0.03205452f, 
    0.15709114f, -0.06671341f, -0.11294913f, 0.04015566f, -0.10048138f, 0.14824887f, 0.09302683f, -0.15476009f, 
    0.00439318f, -0.37603691f, 0.03686577f, 0.19150957f, -0.20231004f, 0.05806160f, -0.06545798f, 0.14177236f, 
    -0.08963342f, 0.07735106f, -0.01117970f, 0.04014901f, 0.17292701f, -0.13053571f, -0.25334835f, 0.03047570f, 
    0.02357788f, -0.07082883f, -0.34491062f, -0.31404144f, -0.12547341f, 0.09803770f, -0.08706287f, 0.02021754f, 
    0.45023155f, 0.18585220f, 0.04685441f, -0.06863649f, -0.16502281f, -0.16134298f, -0.07354391f, 0.21221520f, 
    0.03254833f, 0.24643010f, -0.02334207f, -0.14382122f, 0.05137730f, -0.06406830f, 0.34731421f, 0.05611307f, 
    -0.12610535f, -0.05652504f, 0.15636301f, 0.05058330f, -0.07672583f, -0.00849691f, 0.10623879f, -0.09213176f, 
    -0.16929807f, 0.04362856f, -0.04755193f, 0.06060453f, 0.05829105f, 0.02010215f, -0.08705059f, 0.09287731f, 
    -0.29190999f, -0.02367720f, -0.13366936f, -0.14804624f, 0.02522187f, -0.33177871f, -0.07121421f, 0.11062915f, 
    -0.11335123f, 0.33511853f, -0.02097599f, -0.22750126f, -0.25012490f, 0.03911059f, 0.12048203f, -0.13382375f, 
    -0.13130105f, -0.16166699f, 0.09165391f, 0.03497345f, -0.11999596f, -0.07691983f, -0.30556652f, 0.40562114f, 
    0.10799487f, 0.09576774f, -0.10259517f, 0.03209088f, 0.13094999f, 0.15422346f, 0.03873772f, 0.01468401f, 
    0.36974940f, -0.39977461f, -0.17076033f, -0.14681996f, -0.08550812f, -0.26390377f, -0.00831980f, -0.24234731f, 
    0.08587336f, -0.06869170f, 0.06395549f, -0.13193491f, 0.02746094f, -0.08612765f, 0.14158283f, -0.09376409f, 
    0.04210915f, 0.07249831f, 0.08649082f, 0.14597698f, 0.00470109f, 0.04765238f, 0.25390756f, -0.06688222f, 
    0.06693334f, 0.12858030f, -0.04392099f, -0.14737909f, -0.11397453f, 0.16998875f, 0.11598043f, 0.03634663f, 
    0.09862520f, -0.11762029f, -0.07944997f, -0.08414131f, -0.08198444f, -0.11099885f, 0.09185915f, 0.16185248f, 
    -0.00825072f, -0.16820736f, -0.03711711f, -0.02139725f, -0.03553091f, -0.10138746f, -0.13221018f, -0.01388447f, 
    0.09489153f, 0.09229945f, -0.09547909f, 0.17061736f, 0.11823142f, -0.16726211f, 0.01214817f, -0.19949411f, 
    -0.09690793f, 0.06203159f, 0.09639768f, -0.09774593f, 0.12141202f, -0.04223279f, 0.05741752f, 0.21794027f, 
    0.49576807f, -0.19418293f, 0.04536847f, 0.12163837f, -0.02128194f, -0.21553363f, -0.01875069f, -0.22236140f, 
    -0.07266723f, 0.20987105f, 0.26620284f, -0.39217627f, -0.19078672f, 0.09648977f, -0.23714706f, -0.03059539f, 
    -0.15046035f, -0.00429339f, -0.09751615f, -0.17222036f, -0.11435875f, 0.06792320f, 0.18272692f, 0.07679854f, 
    -0.11610919f, 0.14147514f, -0.19805770f, -0.29139265f, 0.13047184f, -0.11261444f, -0.15882860f, -0.05337312f, 
    0.05526485f, 0.29830256f, 0.01920124f, -0.06733068f, -0.00892110f, 0.39153698f, 0.12936307f, 0.17977040f, 
    -0.01978921f, 0.11330789f, 0.26996481f, 0.12573022f, -0.03010415f, 0.10809832f, -0.45253801f, -0.08184840f, 
    0.03607262f, 0.01573923f, -0.06182081f, 0.05024056f, 0.04460634f, -0.01015100f, -0.30341944f, -0.02513502f, 
    0.04821868f, -0.09875856f, 0.09105251f, 0.04679651f, -0.01593395f, -0.05124870f, -0.06602153f, 0.06420155f, 
    0.07428633f, -0.10472976f, 0.04470439f, -0.03207520f, -0.13293698f, -0.30467892f, 0.06640202f, -0.28283441f, 
    -0.11363730f, -0.10317612f, -0.17736036f, 0.15662014f, -0.01891567f, -0.11438809f, 0.09977313f, -0.08392809f, 
    -0.15255614f, 0.01918256f, 0.10553806f, -0.06739496f, 0.02937253f, -0.08936717f, -0.09873409f, -0.20232551f, 
    -0.03002893f, 0.01444298f, -0.31171784f, -0.22872110f, -0.03812265f, -0.16000733f, -0.07424626f, 0.13941598f, 
    0.46419483f, 0.23000593f, -0.07928026f, 0.04374602f, 0.16625094f, 0.37766042f, -0.10777920f, 0.15740670f, 
    -0.12942119f, -0.17537875f, -0.12922196f, 0.03226367f, 0.22356096f, 0.07914784f, 0.17784019f, -0.10223944f, 
    0.06219048f, -0.13337718f, 0.02241919f, -0.05576218f, -0.10148177f, 0.01858044f, 0.11983263f, -0.08755230f, 
    -0.02433039f, 0.05789201f, 0.01751485f, 0.05604710f, 0.00054199f, 0.16699475f, 0.12914020f, -0.18514813f, 
    -0.10144530f, 0.04195524f, 0.02976597f, -0.08652389f, 0.07841638f, -0.11301021f, 0.13948353f, -0.06388677f, 
    0.14108106f, -0.12651837f, -0.18324785f, -0.11782906f, -0.00178892f, 0.03526182f, -0.04139953f, 0.08754854f, 
    0.14118084f, -0.16265024f, 0.02597842f, -0.02214956f, -0.03916542f, 0.02249011f, 0.07958876f, -0.12362442f, 
    0.14284393f, 0.11906244f, -0.27983162f, 0.02704550f, 0.02791856f, 0.04481995f, 0.16173801f, 0.15247717f, 
    0.10604601f, 0.30025581f, -0.10891199f, 0.13429932f, 0.09950100f, 0.13721772f, -0.11678902f, 0.11605997f, 
    -0.03279405f, 0.43522266f, 0.13184223f, -0.45051411f, 0.24844851f, 0.13831519f, -0.21995959f, -0.04211728f, 
    0.10159741f, 0.07238124f, -0.05333193f, 0.08350611f, 0.10190111f, 0.08085103f, -0.08134842f, -0.12880760f, 
    0.01232171f, 0.13690211f, 0.49684089f, -0.21872632f, -0.04953656f, 0.01042773f, -0.11345083f, -0.08876138f, 
    -0.53036821f, 0.05759783f, 0.13481256f, -0.06861100f, -0.08823247f, 0.14843906f, -0.03084497f, 0.02320720f, 
    -0.17797461f, 0.04535062f, 0.01028517f, 0.03292361f, -0.18486643f, -0.03192965f, 0.06552889f, 0.13051547f, 
    0.13248554f, 0.05751301f, 0.11342292f, -0.04810331f, 0.08340003f, 0.06951372f, 0.01336558f, 0.20838645f, 
    -0.12513229f, 0.15571837f, 0.31939861f, -0.13865909f, 0.11300832f, 0.07276243f, -0.09162535f, 0.15965213f, 
    0.01610759f, 0.21456751f, -0.16796218f, 0.01942773f, 0.09726435f, 0.09095020f, 0.11895214f, -0.09890132f, 
    -0.03884356f, -0.15972917f, 0.02836013f, 0.01017503f, 0.13872956f, 0.00753243f, 0.15227127f, 0.16013883f, 
    -0.14221327f, 0.12174577f, 0.01703753f, 0.09900192f, 0.01452326f, 0.02532696f, 0.11860781f, -0.01913462f, 
    0.00830330f, 0.00745163f, 0.55654001f, -0.17532654f, 0.12508525f, 0.03618128f, 0.04540520f, 0.25185320f, 
    -0.12022275f, 0.39681625f, 0.12355407f, -0.16535273f, 0.05990947f, -0.12346408f, -0.13645634f, 0.28913495f, 
    0.04471309f, -0.02012954f, 0.25851843f, -0.25552636f, -0.37780404f, 0.04616873f, -0.10432296f, -0.17767166f, 
    -0.12320372f, -0.10075421f, 0.05246300f, -0.09064352f, 0.01919655f, -0.07618582f, 0.15447456f, -0.08442164f, 
    -0.07650304f, 0.10077859f, -0.29839236f, 0.00909702f, -0.11525850f, 0.10396873f, 0.16561830f, -0.21914892f, 
    0.52213705f, -0.18526098f, 0.15179174f, 0.02768606f, -0.11682641f, -0.08714156f, -0.06283335f, -0.33468729f, 
    -0.12656806f, 0.28767538f, 0.03869494f, 0.08650338f, -0.06572516f, -0.15587211f, 0.02031887f, 0.12320294f, 
    -0.09437156f, 0.04270294f, -0.04334266f, 0.08741935f, 0.10020924f, 0.13923497f, -0.00069632f, 0.22076726f, 
    0.11618599f, 0.04745854f, -0.01323068f, 0.12134893f, -0.02881213f, -0.07564773f, -0.01229523f, -0.04074489f, 
    0.08385620f, 0.06440272f, -0.05139092f, 0.14932646f, 0.03948928f, 0.29434761f, 0.07114369f, -0.00813359f, 
    0.00733880f, 0.11500826f, -0.03153699f, -0.11249403f, -0.01676335f, -0.15117103f, -0.02942003f, -0.15474002f, 
    -0.16442329f, -0.13910708f, 0.11206004f, 0.06534344f, 0.06383582f, 0.15405433f, -0.07664219f, -0.22191018f, 
    0.04790676f, 0.09920613f, 0.11021343f, 0.01569623f, 0.03321313f, -0.12368044f, 0.06578426f, -0.08631495f, 
    0.16739409f, -0.04684256f, 0.04875909f, 0.11610910f, -0.01333244f, 0.02786114f, -0.08824266f, 0.09189007f, 
    0.14494672f, -0.24602062f, 0.22686549f, 0.18139777f, -0.09112379f, -0.06380980f, 0.03151916f, -0.04529553f, 
    0.09974154f, 0.01524222f, -0.06146289f, -0.04361693f, 0.17875576f, -0.10681769f, -0.33018929f, -0.07050682f, 
    -0.13862859f, -0.14289206f, -0.09659054f, 0.00483247f, -0.03906648f, -0.10555337f, -0.02750554f, 0.32273883f, 
    -0.21209255f, 0.05568700f, 0.10015379f, -0.17070208f, 0.12855858f, -0.35611451f, 0.05642582f, -0.08996175f, 
    0.15293224f, 0.24706733f, 0.32800585f, -0.00100692f, -0.05863595f, -0.11572997f, -0.01293788f, 0.14833376f, 
    -0.16592014f, -0.02327519f, 0.06425530f, -0.08081216f, 0.05616302f, 0.14752436f, 0.06427583f, 0.01264515f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.29995865f, 0.11429787f, -0.05054003f, -0.03524059f, -0.03673229f, 0.07862534f, -0.16962624f, -0.07368372f, 
    -0.03335587f, 0.09172861f, 0.13130049f, -0.03949324f, 0.03825237f, -0.12306376f, 0.12351981f, -0.08613601f, 
    -0.07335691f, -0.20622723f, 0.02096911f, -0.12463818f, -0.03184619f, 0.06163469f, -0.29068887f, -0.14072530f, 
    0.03868274f, 0.08721179f, -0.13723709f, -0.08227146f, -0.20231876f, -0.18005003f, 0.02966820f, 0.22577897f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.50567442f, -0.24910718f, 0.14763929f, 0.02856709f, 0.20220655f, -0.24662462f, -0.00095558f, 0.33417332f, 
    -0.08813342f, -0.32327044f, -0.24872507f, -0.03559007f, -0.32816190f, 0.05576814f, -0.08619939f, 0.17881045f, 
    -0.40097424f, 0.02017386f, -0.09956411f, -0.26372808f, -0.31153247f, -0.05132657f, 0.20175532f, -0.10487034f, 
    -0.60048860f, -0.19397557f, -0.06659114f, -0.33072788f, 0.01235818f, 0.03358204f, 0.20530634f, -0.50598139f, 
    -0.00242444f, 0.11286687f, 0.29959238f, 0.12712270f, 0.13280350f, 0.07426658f, -0.06721977f, 0.22285812f, 
    -0.00019645f, 0.04835492f, -0.17901325f, -0.10029019f, -0.16107650f, -0.12748791f, -0.11071856f, -0.16035047f, 
    0.20335113f, -0.48101130f, 0.03509315f, -0.60666126f, 0.00531216f, 0.05085053f, -0.12792681f, -0.13248776f, 
    -0.80755442f, 0.34254235f, 0.10718098f, 0.29079860f, -0.46497667f, -0.24717493f, 0.03176985f, -0.04464647f, 
    0.18522069f, -0.27267405f, 0.05921704f, 0.03325484f, 0.06108919f, 0.24221022f, 0.07922827f, -0.24545449f, 
    0.16875173f, -0.03972352f, -0.40235507f, 0.18412033f, -0.03598209f, -0.13337994f, 0.17248973f, -0.25045937f, 
    -0.50607675f, -0.45994917f, 0.05522876f, 0.23555698f, -0.49984112f, -0.04163249f, -0.24916746f, 0.14637753f, 
    0.23944545f, 0.01783775f, 0.03820830f, 0.41653913f, -0.30171403f, 0.10985994f, 0.04496150f, 0.12542151f, 
    -0.35300568f, 0.07976829f, -0.43862736f, -0.30328321f, -0.11590393f, -0.35292366f, 0.03964078f, -0.23455684f, 
    -0.28524110f, -0.01560959f, -0.30416605f, -0.96055990f, -0.21111545f, -0.01532148f, -0.51989084f, 0.34873685f, 
    -0.16360697f, -0.07326584f, -0.03288376f, 0.22385536f, -0.30998686f, -0.53093004f, 0.17388822f, 0.04666186f, 
    0.06142775f, -0.29691598f, 0.08353058f, 0.36719233f, 0.02652613f, -0.01455539f, -0.10940198f, 0.14547367f, 
    0.02392337f, -0.01552654f, -0.29237652f, 0.23595448f, -0.00425481f, -0.27290297f, 0.11630107f, 0.18040460f, 
    0.21573591f, 0.13985623f, -0.08385795f, -0.13522910f, -0.06565718f, -0.20628160f, -0.16925476f, 0.12386779f, 
    -0.17889591f, 0.32537839f, 0.09113144f, 0.18553364f, 0.16590986f, -0.15830259f, -0.02354919f, -0.05993850f, 
    -0.26608831f, 0.07488412f, 0.03760979f, -0.31481257f, 0.11973894f, -0.09061727f, -0.06048782f, -0.04236597f, 
    0.13882437f, -0.01852112f, 0.16163611f, 0.15956984f, 0.31496382f, -0.28163633f, 0.04348634f, -0.20041151f, 
    0.05111634f, 0.13057390f, 0.34391591f, -0.10432208f, -0.18295458f, -0.11371034f, -0.00613830f, -0.03894307f, 
    -0.37088561f, -0.22934908f, 0.05586972f, -0.62508178f, -0.02804241f, -0.04072783f, 0.15299883f, -0.14788665f, 
    0.04231702f, -0.28245860f, 0.07492714f, -0.25366503f, -0.48350000f, -0.04726505f, -0.21556382f, -0.09474499f, 
    0.38204908f, -0.29785612f, -0.26210791f, -0.25670320f, -0.92571634f, -0.06136692f, 0.12884374f, -0.67841935f, 
    0.25326464f, 0.39411235f, 0.27100590f, -0.26589543f, -0.03400405f, -0.32751060f, -0.06644940f, -0.36919835f, 
    -0.26968777f, -0.50102860f, -0.09273025f, 0.17711361f, 0.07678433f, 0.00498939f, -0.42340225f, 0.11400977f, 
    -0.06618603f, 0.01380882f, -0.03017617f, 0.06794709f, -0.20882383f, -0.15143563f, -0.02885690f, 0.17317213f, 
    -0.22662356f, 0.25346813f, -0.17087704f, 0.03096111f, -0.39189669f, 0.31761512f, -0.15362297f, -0.36405435f, 
    -0.42671114f, -0.20046635f, 0.07119206f, -0.06629285f, 0.02520318f, -0.20697477f, 0.31353959f, -0.14775953f, 
    0.16981474f, -0.03953262f, 0.05024665f, 0.18819885f, 0.18897203f, -0.59825450f, -0.22127299f, -0.13099487f, 
    0.29339024f, -0.30116743f, -0.11305720f, 0.26909903f, -0.27687189f, -0.04877678f, 0.12665685f, 0.08037084f, 
    -0.43826374f, 0.21102832f, 0.23740469f, -0.37754327f, -0.58389914f, -0.57828647f, -0.05498641f, -0.36487949f, 
    -0.19037567f, -0.20028862f, 0.11798597f, -0.34243006f, 0.11407441f, 0.36976299f, -0.05654484f, -0.06096056f, 
    -0.28778329f, -0.10885914f, 0.15330988f, -0.37426800f, 0.15876639f, -0.58696187f, -0.04280422f, -0.14675383f, 
    0.10841621f, -0.00169853f, -0.03802544f, 0.07169154f, -0.22156097f, 0.12696357f, -0.03748003f, -0.11706590f, 
    0.27972713f, 0.03202955f, -0.09731598f, -0.13957387f, -0.06614613f, 0.39702642f, -0.09299905f, 0.23786017f, 
    -0.13007835f, -0.00452182f, 0.22104388f, -0.28902489f, 0.25237224f, -0.46062234f, -0.15719715f, -0.45334506f, 
    -0.09558531f, -0.20262527f, 0.11938419f, 0.26805556f, -0.35038093f, -0.09202227f, -0.15293300f, 0.14438868f, 
    -0.05313179f, 0.06918247f, -0.22788356f, -0.43514052f, 0.38611975f, -0.08229495f, 0.08608202f, -0.00202570f, 
    -0.01774718f, 0.30589899f, -0.08399027f, -0.53733170f, 0.01180620f, -0.04252203f, 0.12646037f, -0.32271972f, 
    0.05671429f, -0.31885234f, -0.13634251f, -0.46607220f, -0.30838758f, 0.13270541f, -0.37834248f, 0.03557139f, 
    0.53049785f, -0.40196106f, -0.02768198f, -0.20961955f, -0.43658656f, -0.18381035f, -0.65927726f, -0.16482416f, 
    0.21649276f, -0.13189381f, -0.13293014f, -0.17022902f, -0.10688178f, -0.10424364f, -0.56964427f, 0.27282146f, 
    -0.08248197f, -0.16685931f, -0.09582563f, -0.37423205f, -0.33621529f, -0.52111959f, 0.09888190f, -0.09228635f, 
    -0.20764793f, 0.33429834f, 0.29870448f, 0.46490926f, -0.28251129f, -0.14203916f, -0.44314325f, 0.01309015f, 
    0.27391413f, -0.33885381f, -0.00870350f, -0.17098096f, 0.14687330f, -0.40944332f, -0.01877766f, 0.09240049f, 
    0.34804472f, 0.21016335f, -0.07577485f, -0.12748057f, 0.01538136f, -0.03654853f, -0.27479890f, 0.03393365f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09778897f, 0.18403392f, 0.22526799f, -0.20336427f, -0.04016307f, -0.08566783f, 0.11595111f, -0.14892937f, 
    -0.03257580f, -0.11640073f, 0.00309207f, 0.02086664f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
