#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66598994f, 0.55284023f, -0.27569610f, -0.80752099f, 0.40797210f, -0.74070048f, -0.70407987f, 1.42545831f, 
    -0.94100612f, -1.08496046f, -0.22437111f, -0.08260001f, 0.44737896f, 0.24298903f, 0.04622374f, 0.40822214f, 
    0.32505485f, -0.26384288f, -0.26842725f, 0.08804531f, -0.18172716f, -0.11465786f, 0.06405726f, 0.15873951f, 
    0.03086704f, -0.13458310f, -0.45001236f, 0.02602888f, 0.97263253f, -0.11932455f, -0.18086672f, 0.00864714f, 
    -0.84960651f, -0.29329523f, -0.66023195f, -0.16800840f, -0.32132357f, 0.11561020f, 0.19811597f, 0.22483531f, 
    0.38131729f, 0.85096782f, 0.40932953f, -0.42255276f, -0.23071952f, -0.44937402f, -0.35758138f, -0.14340208f, 
    -0.04887456f, -0.00079944f, -1.77687430f, 0.95531625f, -0.03412677f, -1.61135602f, -0.51665646f, 0.57083774f, 
    0.99375731f, -0.37165982f, 0.06926080f, 0.62522817f, -0.01399324f, 0.19397561f, -0.13880536f, -0.16160831f, 
    -0.12718934f, -0.07682469f, -0.06003140f, -0.05125779f, 0.18944350f, 0.13474077f, 0.03441241f, 0.09670755f, 
    0.02102216f, 0.08031816f, -0.05865420f, -0.60676694f, -0.30429438f, -0.26999852f, -0.65851659f, -1.03873384f, 
    0.61335874f, -0.16107261f, -0.02692154f, 0.46135962f, -0.34857216f, -0.16399460f, -0.39562160f, 0.18504502f, 
    0.84531510f, 0.36631414f, 0.34530789f, 0.28551924f, 0.12278698f, -0.32877538f, -0.01047438f, 0.24679118f, 
    0.64920664f, -0.03696718f, -0.25154987f, -0.40961105f, -0.22780272f, 0.96474993f, 0.42068741f, -0.01469661f, 
    0.17040369f, 0.56282687f, 0.31776032f, -0.24356943f, -0.33032033f, -0.08660792f, 0.49475789f, 0.21038629f, 
    -0.00204162f, -0.82691193f, -0.58783472f, -0.16964716f, -0.44575974f, 0.01401391f, 0.32347581f, -0.09177131f, 
    0.19112377f, 0.06733698f, 0.23597018f, -0.14809482f, -0.51541632f, -1.26690197f, -0.61160690f, -0.71275091f, 
    -1.10653293f, -0.75848687f, 0.68031275f, 0.08827086f, 0.27524632f, 0.40105271f, 1.13448703f, -0.05451272f, 
    0.05767144f, 0.16767345f, 0.00066204f, -0.23849450f, -0.13727821f, 0.28473681f, 0.05324829f, 0.10776474f, 
    -0.11724266f, -0.24206769f, -0.07571080f, -0.01022532f, -0.35218656f, -0.18505351f, -0.88058490f, 0.94958591f, 
    0.71571219f, -0.90022421f, -0.78175557f, -0.25570145f, -0.18534850f, -0.92602092f, -1.06758499f, -0.89902967f, 
    -0.03685568f, 0.68442327f, -0.71515632f, -0.71792763f, -0.01982830f, -0.25787354f, 0.10370547f, -0.19522287f, 
    -0.16409798f, -0.38599199f, 0.04687080f, -0.39942139f, -0.00707480f, -0.36685821f, -0.39957628f, -1.80447531f, 
    0.35725674f, 0.68072301f, 0.09388085f, 0.86208975f, -1.01594877f, -0.86406726f, 0.61036950f, 0.25558150f, 
    0.10510959f, -0.18319528f, -0.40308020f, -0.55675530f, 0.06194768f, -0.09669529f, -0.04316894f, -0.62310016f, 
    -0.16262496f, -0.32765460f, -0.16638741f, -0.23333666f, -0.19444558f, -0.02443528f, -0.08393396f, -0.38192478f, 
    -1.18124878f, -0.56777138f, 0.48567209f, 0.34592789f, 0.60687047f, 0.08009882f, 0.44302091f, -0.43476930f, 
    0.42879251f, 0.71379340f, -0.23563816f, 0.43472874f, 0.26134422f, -0.16750242f, -0.21725753f, -0.25394672f, 
    -0.09256143f, -0.56652862f, 0.24273530f, 0.35757780f, -0.03421437f, 0.07638192f, 0.04264414f, -0.20077486f, 
    0.04763893f, -0.48502141f, -0.46452022f, 0.15698586f, 0.32995462f, 0.18018185f, 0.35168210f, 0.20188071f, 
    0.13540503f, -0.14725617f, 0.32257235f, 0.34699130f, -0.28891602f, -0.01634738f, -0.00611784f, -0.25958851f, 
    0.19796495f, -0.04302179f, -0.00231773f, -0.29125977f, -0.66644233f, 0.10755218f, 0.89205027f, 0.51698011f, 
    0.49102542f, 0.34883696f, -1.31817889f, -0.86301523f, -0.55739820f, -0.49441805f, -0.06124511f, -0.25454390f, 
    0.15846451f, 0.07406581f, 0.77694196f, -0.38070053f, 0.98165470f, 0.67616582f, 0.23352489f, 0.38710919f, 
    0.07545958f, -0.36116818f, -0.47844130f, -0.13276881f, -0.45340702f, -0.67786485f, 0.16122124f, -0.05094515f, 
    0.45991492f, -0.31204370f, -0.12526624f, 0.59885311f, 0.60085636f, 0.81483763f, 0.43475768f, 0.69361150f, 
    0.10944901f, -0.21171288f, -0.06250889f, 0.31153086f, -0.17166893f, 0.36788657f, 0.04700346f, 0.02309043f, 
    -0.10557611f, -0.27307004f, -0.29841954f, -0.18934269f, -0.18979861f, 0.10156766f, -0.17427456f, -0.11124936f, 
    0.09321368f, 0.04331414f, 0.09843149f, 0.01364141f, 0.09592938f, -0.61654484f, -0.66995931f, -0.50614715f, 
    -0.89408469f, -1.16689527f, -0.49641031f, -0.72058642f, -1.38854480f, -1.35390747f, 0.64592576f, -0.30633625f, 
    0.13526161f, 0.56754011f, 0.34764537f, 0.18451658f, -0.17040813f, 0.13497904f, 0.18510807f, -0.07148547f, 
    -0.33986166f, -0.25010672f, 0.23251322f, 0.49650145f, 0.18571620f, -1.64441967f, -1.41605723f, -0.80546075f, 
    -0.76194549f, -0.25009069f, 1.04992867f, 0.03745550f, -0.81287581f, -0.80560154f, -0.18110007f, -0.27873626f, 
    -0.30498701f, -0.06050436f, 0.08210424f, -0.19932826f, -0.00878874f, -0.63292354f, -0.06877109f, -0.05363642f, 
    -0.47816068f, -0.37599370f, 0.32442856f, 0.01854888f, 0.02716404f, 0.10996127f, 0.26086131f, 0.74043930f, 
    0.63485318f, -0.36703372f, -0.60605943f, -0.48047677f, 0.23583157f, 0.53010094f, -0.12677412f, -0.25056672f, 
    -0.83122295f, 0.02810615f, 0.50339574f, -0.08771111f, -0.43438560f, 0.24352755f, 0.39090082f, -0.42099768f, 
    -0.24329838f, 0.35970172f, 0.03640967f, 0.16587926f, -0.24246849f, -0.17726141f, -0.08941399f, -0.34509039f, 
    -0.98898971f, -0.06339554f, 0.10445989f, -0.04965269f, -0.78740454f, -0.37686154f, 0.07779516f, -0.16486055f, 
    -0.11148603f, -0.54237598f, -0.46613720f, 1.18568015f, -0.59259540f, 0.28237572f, -0.33960408f, -0.49965912f, 
    -0.10623428f, 0.26206440f, -0.38883194f, -0.07833114f, -0.02844631f, -0.25361761f, 0.21839803f, 0.74869168f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14101107f, 0.34468403f, 0.44679222f, 0.62220037f, 0.53194654f, 0.12204501f, 0.27314830f, 0.16042840f, 
    0.70660675f, 0.53468782f, 0.41921237f, -0.24821885f, -0.25660163f, 0.17874515f, 0.75083619f, 0.34377307f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29747024f, -0.03393191f, 0.01773941f, -0.02335609f, -0.25880122f, -0.08863816f, -0.02893300f, 0.00301693f, 
    -0.02173955f, 0.19286753f, -0.02818201f, -0.04079925f, 0.36133981f, -0.24053544f, 0.05706869f, -0.54254860f, 
    0.01075998f, -0.31561461f, -0.00634604f, 0.11485539f, -0.10176801f, -0.00061522f, 0.10405202f, 0.12234810f, 
    -0.35513583f, -0.41255799f, -0.16108914f, -0.19314305f, -0.15721682f, 0.47304198f, -0.10292196f, 0.07189222f, 
    -0.15022762f, -0.15845469f, 0.00999500f, -0.06950283f, 0.25104442f, -0.09369031f, -0.09653319f, -0.23661321f, 
    -0.12726936f, 0.24383841f, -0.30779395f, -0.28569788f, -0.18024419f, 0.04744413f, 0.07530566f, 0.03068039f, 
    -0.95131570f, -0.48811251f, -0.50867003f, 0.00599353f, 0.03327253f, -0.12043457f, 0.14442942f, 0.05037188f, 
    -0.00329199f, -0.10606911f, 0.03484011f, 0.05075159f, 0.11576016f, -0.06723852f, 0.01723279f, -0.10796164f, 
    0.14411697f, 0.40821207f, 0.07372196f, -0.25021082f, -0.01163138f, 0.08639921f, 0.06307374f, -0.17042919f, 
    0.33250147f, 0.57247013f, -0.18457650f, -0.17749065f, 0.11091845f, 0.08788108f, 0.00054341f, 0.09387787f, 
    -0.04233507f, -0.11089028f, -0.18351865f, -0.15090948f, 0.13935852f, 0.26900923f, 0.51421028f, -0.13607951f, 
    -0.21696621f, 0.03751146f, -0.00362634f, 0.14914034f, -0.09754356f, -0.09497923f, -0.16477184f, 0.07977646f, 
    0.23631380f, 0.17705001f, -0.03352764f, -0.35056284f, -0.05093084f, 0.01157871f, 0.09043701f, 0.02357311f, 
    -0.22108813f, -0.18964416f, -0.03749108f, -0.52266145f, -0.14016651f, -0.02313842f, 0.07793799f, 0.05904992f, 
    -0.06841491f, -0.13386154f, -0.01097089f, -0.04761564f, -0.16520099f, -0.18503261f, -0.20884822f, -0.27527624f, 
    0.25630328f, 0.19242834f, -0.08738951f, -0.24699989f, 0.14980645f, 0.15788262f, -0.06896221f, 0.04452965f, 
    -0.04066945f, 0.02065622f, -0.18346117f, 0.08683109f, -0.54858702f, -0.66525567f, -0.44085804f, 0.05231291f, 
    0.09751689f, 0.11783744f, -0.00120573f, 0.14365186f, 0.01820347f, -0.01986056f, 0.03037642f, 0.09552854f, 
    0.68315524f, 0.34066164f, -0.23994467f, -0.36260283f, 0.22998045f, 0.02673008f, 0.01008970f, 0.18826592f, 
    -0.00633949f, 0.10861280f, 0.01987240f, -0.05248567f, 0.61897868f, 0.33830523f, -0.35819075f, -0.26666072f, 
    0.08607225f, 0.36670917f, 0.24411242f, -0.21530214f, -0.01369504f, -0.09373991f, -0.04143761f, 0.03840208f, 
    -1.64880860f, -1.10698056f, 0.06807145f, 0.04185063f, -0.02765585f, -0.01778548f, -0.31714740f, 0.02521303f, 
    0.05497512f, -0.06902974f, -0.05263905f, -0.11517627f, 0.22975451f, 0.24510527f, 0.03921867f, -0.29926607f, 
    0.24422626f, -0.22230832f, -0.05345030f, -0.33911777f, -0.15985517f, -0.29861018f, -0.08058523f, -0.15903479f, 
    0.23934743f, -0.28867713f, -0.26315945f, 0.11315012f, -0.24257050f, 0.08705306f, 0.29658559f, -0.28996286f, 
    -0.12144049f, 0.21648549f, -0.08381310f, 0.10162200f, -0.12128507f, -0.00900561f, 0.04091497f, -0.50411254f, 
    0.27428147f, -0.31314337f, 0.05907359f, -0.40470707f, 0.11282386f, -0.11785889f, -0.06126774f, 0.06140648f, 
    -0.05296350f, 0.20281452f, -0.06631625f, -0.31145957f, 0.14191540f, 0.06754328f, -0.32206362f, -0.09982494f, 
    -0.06347161f, -0.05224911f, -0.13408841f, 0.03497285f, -0.27862972f, 0.15864639f, 0.25934309f, -0.00214633f, 
    0.24641904f, 0.06215587f, -0.24064627f, 0.06024143f, -0.21640956f, 0.01283552f, 0.11155225f, -0.12526555f, 
    0.54699957f, -0.04211697f, -0.04280486f, 0.36764249f, -0.06190877f, 0.02470931f, -0.03304999f, -0.01995578f, 
    -0.06448094f, -0.06290179f, -0.01586884f, 0.08304364f, 0.16733229f, 0.11026656f, -0.22272392f, -0.14729388f, 
    -0.00767053f, 0.15965830f, -0.27644145f, -0.48113748f, 0.04376265f, -0.11045181f, 0.01589085f, -0.19932747f, 
    -0.11105380f, -0.25704518f, 0.01790477f, -0.41401136f, 0.07137199f, -0.08823397f, -0.52636063f, 0.34606883f, 
    -0.05566387f, 0.06233825f, -0.05605021f, -0.02094894f, -1.18539655f, -0.23294583f, -0.48377353f, -0.64944452f, 
    -0.02160359f, -0.06789951f, 0.00758099f, 0.19538327f, 0.11225846f, 0.01780320f, -0.22802451f, -0.49904278f, 
    -0.00989523f, 0.24786565f, -0.12639099f, 0.21451576f, -0.06075297f, -0.00774977f, 0.02114297f, 0.04109825f, 
    -0.11512903f, 0.10998689f, -0.10389549f, 0.22657955f, 0.00386571f, -0.03621968f, 0.07179893f, 0.15500894f, 
    0.11520238f, 0.01988005f, 0.03258603f, 0.15182301f, -0.14959683f, 0.04207781f, 0.15206788f, 0.03675088f, 
    -1.02323246f, -0.34721339f, -0.54523695f, -0.28207952f, -0.21573825f, 0.17213322f, 0.01578365f, 0.18815677f, 
    0.03311756f, -0.00962084f, 0.06954747f, 0.10598157f, 0.25109330f, 0.11325376f, 0.15709721f, 0.26450184f, 
    -0.12747267f, -0.17294711f, -0.09624553f, -0.02723406f, 0.06056435f, -0.02476843f, -0.03583713f, 0.08952847f, 
    0.16610566f, -0.00628761f, 0.42324278f, -0.24059162f, -0.07935668f, -0.07571590f, 0.08218304f, -0.02151977f, 
    -0.04183814f, 0.03543685f, 0.08575623f, -0.02540077f, 0.49221885f, 0.33630002f, 0.39854279f, 0.45340136f, 
    0.04628334f, -0.04568249f, 0.33500186f, 0.15465936f, 0.03093806f, 0.03314419f, 0.08859449f, -0.13623108f, 
    0.45664579f, 0.01840045f, 0.28862301f, -0.11709644f, 0.02243111f, -0.15164629f, -0.04232046f, 0.09521974f, 
    0.05427660f, -0.01182787f, -0.08529150f, 0.04508464f, -0.22093423f, 0.15570064f, 0.02646849f, 0.04631464f, 
    0.05583045f, 0.49928406f, 0.34743199f, -0.06151256f, 0.23035729f, -0.03877077f, 0.00571963f, -0.03419412f, 
    -0.23380288f, -0.17126399f, -0.25677580f, 0.04037181f, -0.22189865f, -0.12949911f, 0.18451297f, -0.61439157f, 
    0.13957697f, 0.00374556f, 0.04379296f, -0.13466556f, -0.10623632f, -0.21291669f, -0.16323526f, -0.00796524f, 
    0.14419159f, 0.04296705f, -0.00538740f, -0.15461989f, -0.08044689f, 0.01222354f, 0.08264821f, -0.04911607f, 
    0.81967390f, 0.34796616f, 0.19725125f, 0.35374585f, -0.00207370f, -0.16974656f, -0.17324130f, 0.40456113f, 
    0.11087035f, 0.05366501f, -0.04982235f, 0.01019667f, -0.11926875f, -0.06263974f, 0.34040722f, 0.43717608f, 
    -0.05812975f, -0.02418944f, 0.14829159f, 0.06609930f, 0.13219321f, -0.01467783f, 0.04898175f, 0.05725972f, 
    0.30402622f, -0.06421839f, -0.17876333f, -0.61333472f, -0.02138527f, 0.00133385f, 0.01900375f, 0.06008874f, 
    -0.00006443f, -0.08793878f, 0.13110933f, -0.10334548f, 0.07637708f, 0.45361242f, 0.24313752f, 0.41845307f, 
    -0.16435011f, -0.06098717f, 0.14499636f, 0.05424915f, 0.14017330f, -0.05303823f, 0.10264894f, 0.11484527f, 
    0.35531110f, 0.03325776f, 0.38396612f, -0.97671252f, 0.22767259f, -0.08400355f, -0.26628554f, -0.17843114f, 
    -0.03079577f, 0.08782143f, -0.02172915f, 0.00856714f, 0.07281249f, -0.07809347f, -0.50701141f, 0.26109099f, 
    0.03772968f, 0.13714609f, 0.03108063f, -0.23728906f, -0.08031114f, -0.01869324f, -0.06325365f, 0.04089923f, 
    0.27244136f, -0.13640057f, -0.24657030f, 0.36810488f, 0.08572983f, -0.10657169f, -0.02302041f, 0.08537038f, 
    -0.05487977f, -0.07046317f, 0.01643836f, -0.04940970f, 0.00312117f, -0.11959336f, -0.08264560f, 0.02385569f, 
    0.11337438f, -0.10866638f, -0.04017784f, -0.03460428f, 0.01723935f, -0.21580875f, -0.05737469f, -0.18915199f, 
    0.01092499f, 0.28347164f, 0.02661870f, 0.05787534f, -0.03606291f, -0.03997841f, 0.15885511f, 0.08548944f, 
    -0.03255669f, -0.15253624f, -0.24748556f, 0.17230283f, -0.42076522f, -0.11424959f, 0.15666775f, -0.27561820f, 
    -0.03590029f, -0.04125690f, 0.04775618f, 0.07165471f, -0.09623469f, -0.11589547f, -0.06934229f, -0.02801710f, 
    -1.90239191f, -0.75174749f, -0.38332638f, -0.68238032f, -0.14806905f, -0.04895518f, 0.21069106f, -0.29769507f, 
    -0.06929256f, 0.00479229f, 0.04610033f, -0.11911312f, -0.51986057f, -0.28340128f, 0.88796425f, 0.62504983f, 
    0.03932653f, -0.05848442f, -0.09392339f, 0.47710484f, 0.05020519f, -0.08670369f, -0.04877686f, -0.08354846f, 
    0.29077259f, -0.01603871f, -0.04091898f, -0.13794021f, 0.05606146f, -0.01381848f, -0.03580397f, 0.19462441f, 
    0.03322750f, -0.12689874f, -0.11951734f, 0.06332258f, 0.13869873f, -0.12551312f, -0.70781660f, -0.08308864f, 
    -0.13780639f, 0.17545216f, -0.01579592f, -0.10694795f, -0.25267220f, -0.03918804f, -0.03956512f, -0.22225228f, 
    0.16782589f, -0.54928458f, 0.29523376f, 0.63803291f, -0.09348578f, 0.00767597f, 0.23263462f, -0.06747729f, 
    0.08629265f, -0.01188598f, -0.09160774f, -0.11364236f, 0.26302108f, 0.44834155f, -0.11756921f, 0.62403488f, 
    -0.44018200f, -0.21669041f, 0.14039388f, 0.00751276f, -0.30928835f, 0.43543679f, -0.35421428f, 0.08257629f, 
    1.33675349f, -0.25619709f, -0.24708472f, 0.47237915f, 0.18796499f, -0.01172300f, -0.38607007f, -0.40067089f, 
    -0.21616939f, -0.22808416f, 0.11404793f, -0.15259132f, 0.17424715f, -0.41766402f, 0.11318687f, 0.27935588f, 
    -0.22150512f, 0.17333581f, -0.20274803f, 0.11987808f, -0.01714781f, -0.03320313f, -0.11632888f, 0.04099448f, 
    -0.69950080f, 0.26896957f, 0.25765055f, -0.23328625f, -0.23954470f, 0.27829045f, -0.25225970f, -0.07781796f, 
    0.06938913f, 0.23186384f, -0.12091046f, 0.01979588f, 0.51782316f, -0.74854046f, 0.07747764f, 0.17461020f, 
    0.31131291f, 0.09517106f, 0.10631267f, 0.00389460f, -0.07570579f, 0.00470741f, -0.02764728f, 0.26392624f, 
    0.01365716f, -0.32063061f, 0.14100659f, 0.05795087f, 0.01832663f, 0.09478492f, 0.01518327f, 0.15361905f, 
    -0.03618179f, -0.00430808f, -0.17879753f, 0.18783483f, 0.66561139f, 0.30098164f, -0.21929783f, -0.60687971f, 
    -0.18422994f, -0.13596916f, -0.03614847f, -0.15284534f, -0.21897595f, 0.01333666f, 0.07236680f, 0.00217614f, 
    -0.46602306f, 0.11980122f, -0.35850438f, -1.10592866f, 0.05087312f, -0.02503808f, -0.23810261f, 0.04146172f, 
    -0.21660444f, -0.26822242f, -0.31653032f, -0.15003890f, 0.23402716f, -0.10314427f, 0.02749985f, -0.01046254f, 
    0.02806518f, 0.02605048f, -0.05069153f, -0.19644502f, -0.00548383f, -0.03930573f, -0.16647439f, 0.04053197f, 
    0.16626959f, -0.10090155f, 0.03059712f, 0.10687574f, 0.18527846f, 0.11392605f, 0.16831926f, -0.03752362f, 
    -0.10849998f, 0.20193243f, -0.04253971f, 0.06946000f, -0.41512960f, -0.11736383f, 0.31213471f, 0.04297684f, 
    -0.20784317f, -0.21601185f, -0.10861565f, -0.18722191f, -0.05221098f, 0.09769370f, -0.07405151f, -0.03060517f, 
    -0.08395267f, -0.32076785f, -0.06548958f, 0.24186769f, -0.03440484f, 0.26501870f, 0.17374623f, 0.21543856f, 
    0.14340703f, -0.06678578f, 0.12246396f, -0.18943514f, -0.24962278f, -0.16041082f, -0.26366866f, 0.20951916f, 
    0.16711162f, -0.03858499f, -0.10416131f, 0.03797002f, -0.02339262f, 0.04745411f, 0.12871316f, 0.06591217f, 
    0.29920062f, -0.16593675f, 0.34246552f, -0.42696300f, -0.45156354f, -0.27960292f, -0.12547927f, -0.11271318f, 
    -0.09662060f, 0.16249217f, 0.14863756f, 0.05717431f, -0.07836451f, 0.16869584f, -0.29396886f, 0.06610738f, 
    0.20099774f, -0.10429077f, -0.13925374f, -0.15943103f, -0.11562177f, 0.07503992f, 0.00720713f, -0.00856360f, 
    -0.08523047f, 0.56744462f, -0.03720090f, -0.40609410f, -0.07024977f, 0.10960341f, -0.22287680f, -0.01052199f, 
    -0.00944047f, -0.26434734f, 0.03352180f, -0.18725373f, 0.26728725f, 0.23916245f, 0.12322446f, -0.01926346f, 
    -0.00513009f, 0.04380284f, -0.18793610f, 0.07360660f, -0.19242308f, -0.03576443f, -0.09397348f, -0.10951269f, 
    -0.30857986f, -0.13353713f, -0.09416026f, 0.10931064f, -0.11756878f, -0.45796338f, 0.13984191f, -0.17645927f, 
    -0.03407047f, -0.09780136f, 0.02747073f, -0.06713464f, -0.29422566f, 0.09010602f, -0.21159126f, -0.04832926f, 
    -0.22118279f, -0.41764602f, -0.18518358f, 0.01814609f, 0.20781820f, 0.06871738f, -0.02465102f, 0.14997704f, 
    0.78117746f, -0.11226916f, -0.61811191f, 0.19736886f, 0.21074596f, -0.02680113f, 0.22497839f, -0.07760995f, 
    -0.15960072f, -0.20609923f, -0.01697874f, -0.00609159f, -0.34590477f, 0.17580616f, -0.03723020f, 0.12017191f, 
    -0.07540736f, -0.12988572f, 0.17507958f, 0.15536110f, 0.00968134f, -0.24888018f, -0.06696787f, 0.07848427f, 
    0.27958497f, 0.13816841f, -0.14261056f, 0.44855016f, 0.27010554f, -0.16029319f, 0.00505455f, -0.10855803f, 
    0.06682638f, -0.10456601f, 0.24036101f, -0.10645989f, -0.26981926f, -0.09567432f, -0.10224312f, 0.47423565f, 
    0.01953701f, -0.10486452f, -0.00176199f, -0.05556048f, 0.02846025f, -0.07456838f, 0.10022154f, 0.42408803f, 
    0.17501901f, -0.28509524f, -0.08463383f, -0.16056205f, -0.09501170f, -0.16849950f, 0.02909960f, -0.05034794f, 
    -0.12018229f, -0.05876691f, -0.15464041f, -0.17969429f, 0.26354989f, 0.08293138f, 0.07497777f, -0.01568339f, 
    -0.02034106f, 0.08277920f, 0.07031958f, 0.00804417f, -0.04894518f, -0.34393340f, -0.10703662f, -0.39985043f, 
    0.32192379f, 0.07012845f, 0.28217924f, 0.19640298f, -0.03784412f, -0.09702866f, -0.00171417f, -0.07830989f, 
    0.29985499f, -0.13932344f, -0.16422927f, -0.08679830f, -0.09341543f, 0.04254879f, -0.02559658f, 0.23062196f, 
    0.18494411f, 0.13763925f, 0.06445537f, 0.09011628f, 0.05919139f, 0.10549188f, 0.08045273f, 0.06768294f, 
    0.23680763f, 0.37013599f, 0.32533777f, 0.37330687f, -0.09045590f, 0.09736311f, 0.13296932f, 0.24062964f, 
    -0.00809242f, 0.08573924f, 0.00847161f, 0.05660726f, 0.02536224f, -0.20860212f, 0.01111800f, 0.06383080f, 
    -0.22271034f, -0.07701217f, -0.20616701f, -0.09856843f, 0.00405532f, -0.11012746f, 0.02689754f, 0.06695135f, 
    0.03565590f, 0.03679985f, -0.64068609f, -0.31242785f, 0.06800747f, 0.01361244f, -0.05512860f, -0.09234984f, 
    0.05547459f, -0.18908900f, -0.12406364f, -0.33883318f, 0.08704517f, -0.04674212f, 0.05143795f, -0.04527429f, 
    -0.28011721f, -0.03297708f, 0.05669321f, 0.03009166f, -0.10021152f, -0.02976648f, -0.14490055f, -0.10635599f, 
    -0.14833441f, 0.09790805f, -0.16839541f, -0.03377935f, 0.31933403f, -0.11819941f, -0.20497718f, 0.05660025f, 
    -0.12971251f, -0.05633250f, -0.06942968f, 0.10071237f, -0.00750176f, -0.04299298f, 0.16383809f, 0.03903139f, 
    -0.13721579f, 0.19104715f, -0.26353586f, 0.08267891f, -0.06829046f, -0.16882177f, 0.20797233f, -0.00195516f, 
    -1.18010890f, 0.17687149f, -0.15542863f, -0.38949099f, -0.10848282f, -0.03150648f, 0.07312085f, 0.10167566f, 
    0.29419190f, 0.14690763f, -0.06635819f, 0.03279860f, 0.28045598f, -0.00331769f, -0.21165353f, -0.19361003f, 
    0.36674252f, -0.05294341f, 0.31016275f, 0.11521899f, 0.08546873f, -0.07620703f, -0.01464359f, 0.02584612f, 
    -0.55713481f, 0.07975103f, -0.33274359f, 0.08362076f, 0.09992386f, -0.17039457f, -0.06062492f, 0.04296702f, 
    0.11842027f, 0.02329989f, 0.04455394f, -0.12422761f, -0.58400422f, -0.51278174f, -0.17952624f, -0.39882961f, 
    -0.01995634f, -0.08949189f, -0.07536854f, 0.14842549f, -0.19563161f, -0.10565572f, 0.04876799f, -0.05331999f, 
    -0.15750359f, 0.51302731f, 0.11395577f, -0.00789526f, -0.12748182f, -0.10744723f, 0.18800290f, -0.24952938f, 
    0.09970698f, -0.07661304f, 0.05227793f, -0.10501522f, -0.38597816f, -0.03888175f, 0.69312042f, 0.30004627f, 
    0.05514151f, -0.15584080f, 0.05535498f, -0.04586089f, 0.05730191f, 0.02478143f, -0.32334393f, -0.30903372f, 
    -0.51710713f, -0.85804594f, 0.26592526f, 0.29519558f, 0.00601366f, -0.11139816f, -0.09299162f, 0.02297983f, 
    0.09899294f, 0.03690623f, 0.17857704f, 0.17188118f, -0.09479248f, -0.11420458f, -0.07398640f, 0.06097179f, 
    -0.14095584f, 0.04355964f, -0.09951328f, -0.15980028f, 0.25977847f, 0.04522517f, 0.06770272f, 0.23819131f, 
    0.20929562f, 0.11967634f, -0.09214111f, 0.05864709f, 0.04005660f, -0.13900381f, 0.05534755f, -0.12889305f, 
    -0.00530310f, -0.05389339f, 0.02469276f, -0.31036270f, -0.36287490f, -0.24852222f, 0.03925784f, 0.14988732f, 
    0.08334874f, 0.03849655f, -0.03571450f, -0.01984333f, 0.01333948f, -0.09590687f, -0.03257476f, 0.01163084f, 
    -0.01331740f, 0.31267491f, 0.05066969f, 0.05965358f, 0.37926880f, 0.16748814f, -0.05502521f, -0.49694195f, 
    -0.00371371f, 0.10458191f, 0.01812287f, 0.09088905f, -0.31287670f, 0.19194232f, 0.08275394f, -0.59762120f, 
    0.13675302f, 0.02833451f, 0.07327166f, -0.40721700f, 0.07950193f, -0.02526134f, -0.11807626f, 0.07544082f, 
    0.07627264f, -0.24971309f, -0.59523338f, 0.70585084f, -0.00773454f, 0.14813882f, 0.09874972f, -0.03740461f, 
    0.12960197f, 0.01763554f, 0.28515521f, 0.14965251f, 0.18540090f, -0.04281785f, 0.32450014f, 0.12499279f, 
    0.13909604f, 0.12797722f, -0.33309829f, 0.12145509f, 0.20359971f, 0.19524758f, 0.02850856f, 0.25880566f, 
    0.01458568f, 0.32939085f, -0.01154445f, -0.51527202f, 0.14528170f, 0.06569152f, 0.08506762f, 0.32462457f, 
    0.14840539f, -0.07305291f, 0.05658728f, 0.16510898f, -0.55422723f, -0.51490676f, -0.56533307f, 0.18467663f, 
    -0.07187614f, 0.24886928f, 0.16222179f, -0.04235256f, 0.09943169f, 0.07575125f, 0.10940340f, 0.20894159f, 
    -0.42735490f, -0.24263033f, 0.96753174f, 0.38235545f, -0.09737926f, -0.29776230f, 0.07914111f, 0.00444458f, 
    -0.05809466f, -0.05889758f, -0.02696265f, 0.01572982f, 0.02919993f, 0.25937456f, 0.16588949f, -0.46753111f, 
    -0.02765093f, -0.11038092f, 0.13569494f, 0.12210517f, 0.20377800f, 0.01185725f, -0.03991889f, 0.02738800f, 
    0.10075915f, -0.19346625f, -0.02934535f, -0.04144238f, 0.17166379f, 0.12526767f, -0.04643593f, -0.19110143f, 
    0.04230935f, 0.08732659f, 0.06525873f, 0.02030732f, -0.47367537f, 0.26945812f, 0.41895872f, 0.23439869f, 
    -0.18595462f, 0.02521155f, 0.00449852f, 0.37272546f, -0.05379480f, 0.38253716f, -0.17675808f, 0.09302354f, 
    -1.18557119f, -1.52893770f, -0.32370284f, 0.21914561f, 0.05273707f, 0.16792646f, 0.00944899f, -0.37136564f, 
    0.03786887f, -0.19784901f, 0.16474667f, 0.09341869f, 0.64769340f, -0.02988647f, -0.79677075f, -0.09654523f, 
    -0.07908221f, -0.07103042f, 0.05556416f, 0.14617473f, -0.16651331f, 0.04136873f, 0.55537498f, 0.15868147f, 
    -0.05832594f, -0.03577518f, 0.43543822f, 0.12494815f, 0.12087964f, 0.05292038f, 0.00269215f, 0.06693162f, 
    0.19736981f, -0.02686047f, 0.34810591f, 0.40779689f, -0.08063632f, 0.03933210f, 0.13182372f, -0.30677286f, 
    -0.14732942f, -0.43248647f, -0.03774711f, 0.01464496f, -0.04666241f, 0.08571213f, -0.15425795f, -0.43999246f, 
    -0.85704452f, 0.84111273f, 0.90394092f, -0.32456267f, -0.17668569f, 0.12894417f, -0.27465731f, 0.05293683f, 
    -0.14209503f, 0.19123924f, 0.10111991f, 0.02633650f, -0.10499060f, -0.26370478f, -0.09072924f, -0.18291375f, 
    0.15214083f, 0.12565382f, 0.02593464f, -0.09732598f, -0.16896854f, 0.00898511f, -0.09941799f, -0.14771394f, 
    -1.56748581f, -1.23643422f, -0.84294808f, -0.52062351f, -0.11962886f, -0.34057361f, -0.24762613f, -0.52274287f, 
    -0.03243564f, -0.07716984f, 0.02167055f, -0.05091701f, -1.01648736f, -0.80669928f, 0.57659572f, -0.61949497f, 
    0.20189545f, -0.32335925f, -0.14963989f, -0.26633516f, -0.11630197f, 0.10202769f, -0.05566612f, 0.01707739f, 
    0.18069850f, 0.01869836f, 0.09271383f, -0.40763581f, -0.09632671f, 0.13135523f, 0.27912939f, -0.16508767f, 
    -0.00375484f, 0.13682137f, -0.01485451f, 0.09619667f, -0.46453127f, 0.24156319f, 0.06144042f, 0.09723440f, 
    -0.22694241f, -0.53495097f, 0.19631219f, 0.10832724f, -0.29242879f, 0.01200055f, -0.02333020f, 0.20737499f, 
    -0.39506647f, 0.49199423f, -0.21214657f, 0.29895061f, -0.12943080f, -0.29322106f, 0.25230312f, 0.04292160f, 
    0.03116567f, -0.06865788f, -0.03534773f, 0.00957986f, -0.17440255f, -0.47617954f, 0.05414531f, -0.33139032f, 
    0.07409291f, -0.03025607f, 0.00116561f, -0.12560077f, -0.11276147f, 0.11553071f, -0.16540486f, -0.07123969f, 
    0.84332651f, -0.48702949f, -0.62762761f, 0.31995532f, -0.13182089f, -0.14901949f, 0.27144495f, -0.01249540f, 
    0.01115230f, -0.06174397f, -0.01123086f, 0.15922540f, -0.48747241f, 0.08260906f, -0.00522753f, -0.45435882f, 
    -0.19789813f, -0.00857214f, -0.17059037f, -0.27588585f, 0.07389905f, 0.12381253f, 0.02501429f, 0.03969722f, 
    -0.20778161f, 0.31133872f, -0.04771633f, -0.33741766f, 0.09959631f, -0.01488351f, -0.05644943f, 0.02578902f, 
    0.08954676f, 0.08222944f, 0.03747982f, -0.21481194f, 0.61733800f, -0.80359739f, -0.00839398f, -0.24111198f, 
    -0.18934610f, -0.07549904f, -0.28881356f, 0.29909870f, 0.19657676f, -0.04176485f, 0.08009763f, -0.02251204f, 
    -1.25085402f, 0.24766912f, -0.42533755f, 0.47277841f, -0.13902047f, 0.03906121f, -0.08828145f, 0.05987353f, 
    -0.06741989f, -0.13779241f, 0.02071357f, -0.17083730f, 0.57889122f, -0.17490059f, -0.39676216f, 0.37536505f, 
    0.00060835f, -0.02696016f, -0.09749421f, -0.09023654f, 0.06160982f, 0.13961194f, -0.12140470f, -0.06813847f, 
    0.63505751f, 0.29789576f, -0.08534783f, -0.47542763f, -0.00226749f, 0.09233082f, -0.14863938f, -0.08763919f, 
    -0.34064284f, 0.02850008f, -0.16818734f, -0.43490791f, 0.22865270f, 0.00722496f, -0.06439099f, -0.19293466f, 
    -0.23148800f, 0.03482466f, 0.10667569f, 0.06230896f, -0.05616924f, 0.04366071f, 0.05066577f, 0.05923996f, 
    0.90265316f, -0.90552384f, -0.89677876f, -0.22694588f, 0.12765811f, 0.02898817f, 0.06624835f, 0.00537967f, 
    0.16910253f, -0.14298807f, 0.12547198f, 0.12178719f, 0.04754506f, 0.12855467f, 0.01231072f, -0.33726412f, 
    0.06237847f, -0.06752238f, -0.05339643f, 0.00295818f, 0.08344651f, 0.00606950f, 0.07028466f, -0.08175540f, 
    -1.12010825f, 0.66838586f, -0.12645006f, 0.74287438f, 0.19558716f, -0.20649050f, 0.04766159f, 0.13121989f, 
    0.02351202f, 0.08511937f, -0.10046143f, -0.07579014f, 0.11357027f, -1.13569152f, 0.36501813f, -0.69475228f, 
    -0.08908055f, -0.11459088f, -0.05399103f, 0.41032106f, 0.05952563f, 0.08280140f, -0.03448082f, 0.01770906f, 
    -0.01106678f, 0.38369483f, -0.70834178f, 0.36743888f, -0.04108158f, 0.15325823f, -0.04689457f, -0.25858104f, 
    0.05343675f, 0.13850413f, 0.17052458f, 0.07714088f, -0.90576929f, -0.38112053f, -0.12023663f, -0.20730250f, 
    -0.23950630f, -0.23491991f, -0.18843089f, 0.02216280f, 0.00128852f, 0.03728577f, 0.07128521f, -0.01614154f, 
    -0.51776749f, -0.27671358f, -0.05813151f, 0.43565041f, 0.14616936f, 0.11369216f, -0.02673054f, 0.29229823f, 
    0.24156733f, -0.08147296f, 0.07039408f, 0.07543490f, -0.02875082f, 0.02468710f, -0.29313329f, 0.29101530f, 
    0.01162503f, 0.02190751f, 0.24311759f, -0.19250785f, 0.26078826f, -0.12343816f, -0.06721088f, -0.00052932f, 
    -0.07785812f, -0.37538162f, -0.20831618f, 0.73684514f, -0.30432558f, 0.24153262f, 0.14787346f, 0.15970357f, 
    0.02790071f, 0.10396617f, 0.08223378f, -0.01662572f, -0.08531925f, -0.68339372f, 0.01801115f, 0.17636117f, 
    0.23387122f, 0.18583070f, 0.11503018f, 0.08124265f, -0.26572835f, -0.00214472f, -0.24778506f, 0.01343495f, 
    -0.03556459f, 0.06629521f, 0.21011788f, -0.29104242f, -0.24507643f, -0.11690047f, 0.09167737f, -0.02162329f, 
    -0.24266694f, 0.01582598f, -0.17481941f, -0.08664474f, -0.38984042f, -0.49301589f, -0.47906622f, 0.20727071f, 
    -0.03126201f, 0.05145267f, 0.07280222f, 0.20052043f, -0.20890157f, 0.07962224f, -0.07675903f, -0.18764131f, 
    -0.13200167f, 0.38006335f, -0.20794456f, -0.03919818f, -0.13009650f, -0.05866285f, -0.37240693f, -0.26971132f, 
    -0.12619972f, 0.06352408f, -0.14702740f, 0.07699411f, 1.25602114f, 0.27575576f, -0.86579329f, -0.44735044f, 
    0.07851405f, -0.07637695f, 0.11259942f, 0.02883027f, 0.16174187f, -0.01989752f, 0.08375578f, 0.16786709f, 
    0.16336723f, -0.10857188f, -0.17506997f, -0.38325247f, -0.06322154f, -0.00643718f, 0.20545253f, 0.09004017f, 
    0.18392301f, 0.07001789f, 0.33570594f, 0.04718305f, -0.25139263f, -0.06220411f, -0.19146742f, -0.02343488f, 
    0.12179321f, 0.14181347f, -0.08864373f, -0.00256613f, 0.23107934f, 0.42165938f, 0.12453902f, 0.36516070f, 
    0.02148964f, -0.79489505f, -0.42600882f, -0.38911805f, -0.00629869f, 0.09256586f, 0.10120994f, -0.00504652f, 
    -0.16790392f, -0.20121603f, -0.09749818f, -0.11781465f, -0.28037402f, 0.18718098f, -0.00078396f, -0.44616961f, 
    -0.21676478f, -0.19514084f, 0.08267910f, -0.08241849f, -0.04209040f, 0.04328729f, 0.06617098f, 0.04084022f, 
    -0.56794691f, -0.49405497f, 0.27805215f, -0.21464068f, -0.36654606f, -0.35351607f, -0.28857690f, -0.08981261f, 
    0.03854439f, -0.03265192f, 0.08290014f, 0.11183470f, 0.09011373f, -0.77918679f, -0.94376349f, -0.35699663f, 
    -0.14751077f, 0.18183702f, 0.12766214f, -0.04442067f, -0.11305872f, 0.03299566f, -0.06167801f, 0.09899464f, 
    -0.65596282f, 0.23810077f, 0.44864345f, 0.42377305f, -0.08155213f, 0.02072946f, -0.12758675f, 0.11032796f, 
    -0.29953757f, -0.02124261f, -0.03965042f, 0.03683094f, 0.62989247f, -0.57799971f, -0.46808526f, 0.21626388f, 
    0.01658652f, 0.15932974f, 0.35062736f, 0.05225393f, 0.28500310f, -0.00353647f, 0.10622315f, 0.19617711f, 
    -0.66707736f, 0.22040211f, -0.66378623f, 0.18372041f, 0.06524666f, -0.52092713f, 0.11452337f, -0.10765693f, 
    -0.08686300f, -0.16069169f, -0.01953384f, -0.28539053f, 0.19097671f, -0.37287438f, -0.52550131f, 0.19335517f, 
    0.28061497f, 0.16307071f, 0.04672952f, 0.40871233f, 0.15098427f, 0.04915845f, 0.00272284f, -0.25369108f, 
    -0.72094095f, 0.44438425f, 0.05607832f, -0.70121515f, 0.15427795f, -0.20977506f, 0.04638599f, -0.38324243f, 
    0.05498340f, 0.07472849f, 0.04147765f, 0.06176488f, -0.09317710f, 0.57010448f, -0.71789396f, 0.04458990f, 
    -0.24099381f, 0.16141030f, -0.10849299f, -0.08613382f, 0.20428151f, -0.09170450f, -0.00438373f, 0.00105484f, 
    -0.33856496f, -0.45830452f, 0.21143134f, 0.03885773f, -0.08320672f, 0.32771915f, 0.03691843f, -0.23966351f, 
    0.16694243f, 0.10251915f, 0.05537381f, -0.07994521f, 0.42790774f, 0.28484014f, 0.39504570f, -0.11570361f, 
    -0.04207627f, -0.28178352f, -0.16953534f, -0.23741615f, 0.18749376f, -0.13024098f, 0.00369196f, 0.12496023f, 
    -0.56743175f, 0.01825039f, -0.27647531f, -0.23531739f, -0.29154390f, 0.02836206f, 0.00805788f, 0.10672849f, 
    0.24572897f, 0.11583134f, -0.03919952f, 0.07488353f, -1.21207571f, 0.03995867f, -0.44143984f, 0.68669498f, 
    0.03595082f, 0.32117453f, 0.07034381f, -0.08866414f, 0.11888120f, 0.11994439f, 0.21467248f, 0.07414288f, 
    -0.33395579f, 0.18820098f, 0.37301433f, 0.39554209f, -0.03822556f, -0.08251290f, -0.42932016f, -0.05625708f, 
    0.01072345f, -0.13245094f, -0.09964155f, -0.17654322f, 0.23675589f, 0.00401254f, 0.22433969f, 0.19438817f, 
    0.02281616f, 0.28674999f, -0.18377639f, 0.00811477f, -0.11874502f, -0.30632964f, -0.09110419f, -0.24010634f, 
    -0.06758544f, 0.25347573f, 0.54633826f, 0.47624317f, 0.21625482f, -0.41090238f, -0.23804054f, -0.13831808f, 
    0.07031006f, 0.05948416f, -0.02826179f, 0.14042619f, -0.13899919f, -0.48351267f, -0.33044520f, 0.26136658f, 
    0.15899816f, 0.26723018f, 0.12755847f, -0.10971383f, 0.08809712f, -0.00707275f, 0.13172980f, -0.12137924f, 
    -0.29160801f, 0.10324057f, 0.39133173f, -0.33888942f, -0.02103496f, -0.09247935f, 0.14092076f, 0.39945889f, 
    -0.18038830f, 0.00014442f, -0.06863090f, -0.10405483f, -0.29361823f, -0.01082051f, -0.06014626f, 0.18224722f, 
    -0.28061116f, 0.39438367f, -0.14046291f, 0.19228673f, 0.08668609f, -0.07394432f, 0.06046152f, 0.18829791f, 
    -0.71703339f, 0.46056223f, -0.85206485f, -0.09467331f, 0.34959945f, -0.00770450f, 0.06011983f, 0.07659440f, 
    0.20198406f, 0.00462866f, -0.10225958f, 0.15695103f, -0.16478541f, -0.13494469f, -0.66900760f, 0.00594377f, 
    -0.09762958f, -0.23247099f, -0.02237849f, 0.07349984f, -0.12403145f, -0.15459129f, 0.00774187f, 0.11855713f, 
    -0.66738009f, -0.82641363f, 0.17384411f, -0.11784938f, 0.20871775f, 0.31691185f, -0.27154675f, 0.23617540f, 
    -0.23001181f, 0.03490106f, -0.07166680f, 0.10858623f, -0.44078326f, 0.20229180f, 0.06177128f, 0.13549989f, 
    -0.13813680f, 0.32313004f, -0.19845098f, -0.14522967f, -0.15938424f, -0.25555030f, -0.04961519f, -0.10587408f, 
    0.86886621f, -0.48005277f, 0.69744813f, -0.18045789f, 0.17208597f, -0.15577553f, 0.12694311f, 0.14744948f, 
    -0.08532109f, 0.05607910f, 0.07729348f, -0.20965487f, 0.18521079f, 0.33275345f, -0.08772226f, 0.21219561f, 
    0.16223939f, -0.17808944f, 0.07486136f, 0.17109637f, -0.45517710f, 0.21651506f, -0.14022259f, -0.31859747f, 
    -0.03955384f, -0.08913123f, 0.08371247f, 0.24828106f, -0.08680340f, -0.28899425f, -0.11606127f, 0.17177948f, 
    -0.05481087f, -0.29858342f, -0.44353995f, 0.03189293f, -0.17393109f, 0.01767139f, -0.11377297f, 0.00927489f, 
    0.05662287f, -0.50501323f, -0.16909835f, -0.10445642f, -0.09782957f, 0.29783082f, -0.01385695f, -0.52078009f, 
    0.34941396f, -1.02871692f, 0.33786315f, -0.18309729f, -0.22222918f, 0.03797605f, 0.28431922f, -0.22928974f, 
    0.05150608f, -0.08276478f, -0.00586505f, -0.15981686f, 0.03674950f, -0.21197438f, 0.76356858f, -0.26809841f, 
    -0.34582546f, 0.19113658f, 0.01552743f, -0.11203799f, -0.07384029f, -0.08898958f, -0.44869226f, -0.45821735f, 
    -0.16483825f, -0.07545611f, 0.16258277f, -0.41787186f, -0.13573752f, 0.00194492f, 0.15246625f, 0.06538939f, 
    0.03838066f, 0.09426501f, 0.02503365f, -0.04269748f, -0.03490027f, 0.09040818f, -0.06633417f, -0.00804168f, 
    -0.19494319f, 0.05691120f, 0.14948218f, -0.05854491f, 0.10810103f, 0.41568369f, 0.20987840f, 0.56566721f, 
    0.22176908f, 0.25298688f, -0.05331493f, -0.23692483f, 0.03962404f, -0.12652837f, 0.04657451f, 0.03505269f, 
    -0.08271412f, -0.20800272f, -0.13315997f, 0.04285872f, -0.31326860f, -0.26134908f, -1.32494569f, -0.42226776f, 
    -0.53171051f, -0.17932981f, 0.05586656f, -0.04176558f, 0.05539759f, 0.26649693f, 0.13779098f, 0.02729739f, 
    -0.38571963f, -0.46147406f, -0.29349527f, 0.37841389f, 0.00989202f, -0.06727502f, -0.26793176f, 0.02357204f, 
    0.25345927f, 0.11847018f, -0.05242976f, 0.17741016f, -0.29430586f, -0.22991064f, -0.42274147f, 0.37762550f, 
    -0.11477090f, -0.18592227f, 0.07565268f, 0.03547743f, -0.10570598f, 0.20343375f, 0.08510605f, -0.00642506f, 
    0.28425255f, -0.70280540f, 0.31055132f, 0.09223005f, -0.33785397f, 0.10789028f, 0.29583567f, 0.20230214f, 
    -0.03419774f, -0.08708306f, -0.23121701f, 0.01213128f, -0.63907653f, 0.15323143f, 0.83826137f, 0.15630692f, 
    -0.06305546f, 0.13532893f, -0.13964835f, 0.08147564f, 0.28557056f, 0.11948807f, 0.44828969f, 0.22846472f, 
    1.27066827f, -0.24135850f, 1.08334482f, -0.56244397f, -0.15354407f, 0.20235498f, -0.50770247f, 0.42731956f, 
    0.06595235f, 0.03999885f, -0.02782359f, 0.17817450f, 0.08761211f, 0.40059099f, 0.40364042f, 0.20995289f, 
    0.14192703f, -0.03631117f, 0.22388190f, 0.14003362f, 0.14932770f, 0.15841781f, 0.23314412f, 0.01044582f, 
    -1.01468694f, 0.15024130f, -0.21918777f, 0.08803590f, 0.13636968f, 0.13604078f, 0.16810907f, 0.22164993f, 
    -0.24173658f, 0.09498093f, 0.03819988f, -0.12491596f, 0.25721210f, -0.11269189f, 0.73126405f, 0.38570687f, 
    -0.19613290f, 0.21630789f, 0.14490497f, -0.07025428f, -0.11595464f, -0.10923307f, -0.24171874f, -0.07479459f, 
    -0.12263923f, 0.26931968f, 0.18804617f, -0.17173570f, -0.13783954f, 0.19508298f, 0.02237326f, -0.08405715f, 
    -0.01622181f, 0.16642284f, 0.00324344f, 0.28457466f, -0.18605088f, 0.29716635f, -0.52744192f, -0.49710643f, 
    -0.03550019f, -0.14460862f, 0.05128324f, -0.18196823f, 0.12298380f, 0.16076015f, 0.12799098f, -0.16391169f, 
    -0.46218112f, -0.12857808f, 0.15436503f, 0.07404847f, -0.06459995f, 0.07516403f, 0.10655450f, -0.19561954f, 
    0.10225340f, 0.17324449f, -0.13468741f, 0.14607640f, 0.09971151f, -0.96341717f, 0.46900836f, -0.32679200f, 
    0.13618222f, 0.21734253f, 0.14329645f, -0.03860861f, 0.13673517f, 0.03176690f, 0.27995276f, 0.22410871f, 
    -0.60662293f, 0.01070593f, -0.61831766f, 0.00801380f, 0.26908579f, 0.26400340f, 0.21974786f, -0.22912039f, 
    0.17346296f, 0.09076404f, -0.18960245f, 0.11654065f, -0.47455239f, 0.12872688f, -0.33215979f, -0.00582755f, 
    0.12983657f, -0.10820571f, 0.17511202f, 0.03967818f, -0.27576607f, -0.35955650f, -0.19056560f, -0.52730143f, 
    -0.28433377f, -1.03236818f, -0.14107585f, 0.04358055f, -0.20325208f, -0.10320812f, 0.02921663f, -0.10563380f, 
    -0.18131641f, 0.23477906f, 0.20187771f, -0.11412629f, 0.71983922f, 0.48333737f, 0.13731000f, -0.15671454f, 
    -0.11584395f, 0.11875363f, -0.02646303f, 0.16420886f, -0.23387627f, 0.09411149f, 0.04719364f, -0.14710426f, 
    -0.10281605f, -0.20260441f, -0.30314648f, -0.21872872f, -0.20277591f, -0.11882819f, -0.43251660f, -0.01375586f, 
    -0.02870088f, -0.13699837f, -0.15432411f, -0.07618982f, -0.40848383f, -0.02577085f, 0.16517225f, 0.11662077f, 
    -0.14465104f, -0.27699021f, -0.21404405f, -0.02958657f, -0.15834659f, -0.14858587f, 0.03158574f, -0.12214743f, 
    0.47243240f, -0.17727627f, 0.69415164f, -0.64374864f, 0.07392069f, -0.01626153f, -0.05221706f, -0.00625813f, 
    -0.23370647f, 0.18430209f, 0.28034645f, 0.08716216f, 0.09231871f, -0.31598625f, 0.18775244f, 0.00032438f, 
    0.14733675f, -0.53026938f, -0.22101985f, -0.01749965f, -0.18617935f, -0.02135853f, 0.04079740f, -0.27843133f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.45812476f, 0.17805131f, 0.06945104f, -0.18449016f, -0.12560570f, 0.19576687f, 0.15846783f, -0.28330317f, 
    0.08926640f, 0.04414951f, 0.06922206f, -0.01108593f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
