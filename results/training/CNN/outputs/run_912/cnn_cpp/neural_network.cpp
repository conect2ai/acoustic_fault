#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03925630f, -0.23089933f, -0.27389389f, -0.45299158f, -0.40167329f, -0.40988332f, -0.60981452f, 0.03519575f, 
    0.09038123f, -0.84489316f, -0.47190523f, -0.90352702f, 0.22571084f, -0.08076556f, -0.02993388f, 0.26236069f, 
    -0.08109370f, 0.32630065f, -0.33371565f, -0.80978906f, -0.35292593f, 0.30528519f, -0.66940862f, 0.15272307f, 
    -0.30765760f, 0.29056475f, 0.25148496f, 0.80332524f, 0.06576116f, 0.19211303f, 0.00800185f, -0.04245874f, 
    -0.46812662f, -0.15112205f, 0.41966012f, 0.02772838f, 0.13735980f, 0.18820761f, -0.08269039f, -0.17975406f, 
    -0.87025583f, -0.85078222f, -0.24460202f, 0.44829300f, 0.50254470f, -0.44578120f, -0.30249259f, 0.40296745f, 
    -0.40496638f, -0.55580968f, 0.19941857f, 0.39779416f, 0.10020951f, 0.55214858f, -0.87805861f, -0.48754606f, 
    -0.25218096f, 0.30804545f, -0.21588200f, -0.32698622f, -0.04368737f, -0.16530608f, 0.26626581f, 0.48866132f, 
    -0.07780086f, 0.43444014f, 0.46727347f, 0.10825520f, 0.42315617f, -0.36751795f, -0.71689361f, -0.29847208f, 
    -0.15968567f, 0.35320038f, 0.24047475f, 0.13859889f, -0.58227479f, 0.63288563f, 0.47939911f, -0.15370053f, 
    0.16309361f, 0.43051812f, 0.16572204f, 0.60695100f, 0.30454615f, 0.02198049f, 0.56475216f, -0.15277474f, 
    0.11731204f, 0.34004092f, 0.00077895f, -0.51522422f, -0.76187229f, -0.23852547f, -0.68092716f, -0.23530188f, 
    0.12205714f, 0.04883546f, 0.08316471f, -0.45913234f, 0.40791759f, -0.01105536f, 0.24270906f, 0.94751185f, 
    0.52899027f, 0.13100564f, 0.26544017f, 0.23393835f, -0.47016099f, -0.61064255f, 0.51791412f, -0.51045072f, 
    0.26274088f, -0.48951086f, 0.34253296f, -0.19697225f, 0.50846094f, -0.26829901f, 0.42957136f, 0.13855462f, 
    0.86022526f, 0.75862271f, -0.59448552f, 0.11375619f, 0.02876339f, -0.11939631f, 0.66706550f, 0.44404933f, 
    0.21517497f, -0.15043268f, -0.29668167f, 0.50641465f, -0.03492931f, 0.41385069f, 0.26803452f, 0.59607649f, 
    0.68119693f, -0.11215541f, -0.03866212f, -0.96688080f, 0.24156246f, -0.33602595f, -0.08541030f, 0.03310955f, 
    -0.24645275f, -0.08686077f, -0.62996799f, 0.42954576f, -0.27699125f, 0.45675400f, -0.54017663f, -0.03090381f, 
    -0.21904817f, 0.35087785f, 0.53509545f, 0.55939007f, 0.49495021f, 0.67008519f, -0.29305974f, 0.54424489f, 
    0.26066115f, 0.04840867f, 0.17768489f, 0.38658923f, 0.66897345f, -0.47584426f, -0.55615145f, -0.59532529f, 
    -0.13969439f, 0.00718102f, -0.10154211f, 0.50087994f, 0.55390751f, 0.48371285f, -0.29912809f, -0.32417452f, 
    0.04219584f, 0.02743066f, 0.20960808f, -0.32129189f, -0.45804316f, -0.64083767f, 0.10851090f, 0.73811752f, 
    0.52896142f, 0.69155353f, 0.13243501f, -0.36018232f, 0.16755103f, -0.64354825f, -0.12732090f, 0.02751309f, 
    -0.19122964f, 0.62285864f, -0.65892106f, -0.13859916f, 0.33873838f, -0.06064461f, -0.12506548f, -0.64818674f, 
    -0.59694815f, 0.36867431f, -0.00195127f, 0.68925530f, 0.41199023f, -0.22258851f, -0.25292867f, 0.02000744f, 
    0.00212422f, 0.74490196f, -0.67922932f, -0.05097664f, 0.83932948f, 0.37468919f, -0.12961468f, -0.54022807f, 
    -0.33514628f, -0.55094641f, -0.78079146f, -0.24742807f, 0.73617607f, 0.51195073f, -0.08563256f, 0.12626548f, 
    0.31103885f, -0.64364737f, -0.70448792f, -0.57644826f, -0.79307568f, 0.10039390f, 0.37051019f, 0.04632491f, 
    -0.15769559f, -0.18581799f, 0.50444841f, -0.59834123f, 0.24941321f, -0.73740327f, 0.23360901f, -0.18449204f, 
    0.37178096f, 0.37997514f, 0.38778117f, -0.62375617f, 0.52955925f, -0.33602890f, -0.52410054f, 0.79551166f, 
    -0.30216455f, 0.32584631f, -0.16715746f, -0.28971744f, 0.56791532f, 0.29596344f, 0.51829785f, 0.57393676f, 
    -0.55276585f, 0.10146382f, 0.32209074f, -0.02256248f, 0.36533779f, -0.53890753f, -0.43247184f, -0.02560177f, 
    0.38670394f, 0.62569636f, -0.30009010f, -0.07102367f, -0.38705564f, -0.66424519f, 0.66461504f, -0.36687160f, 
    -0.02917564f, -0.32383972f, -0.75660545f, -0.45518264f, -0.01567508f, -0.02234469f, -0.40166965f, 0.41904870f, 
    0.67490822f, 0.63113415f, -0.27316174f, 0.31602815f, -0.05469004f, -0.13753173f, -0.30065811f, 0.48160583f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10252686f, -0.17282039f, -0.27270922f, -0.01332877f, -0.06765080f, 0.09315798f, 0.15719873f, -0.01289142f, 
    0.29194072f, 0.29507783f, -0.09599587f, 0.23092553f, -0.08376814f, -0.29829934f, -0.14817797f, 0.12111297f, 
    -0.24049659f, 0.11220101f, 0.18583168f, -0.07334675f, -0.30187693f, 0.00949461f, 0.08194625f, -0.33238590f, 
    0.09762089f, 0.02601077f, -0.16205660f, 0.00388071f, -0.21391331f, -0.24535415f, 0.33612671f, -0.11026122f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.21090680f, -0.00024482f, -0.19452134f, 0.06912364f, 0.05930024f, 0.02735358f, -0.05271347f, -0.03913576f, 
    0.04851549f, 0.00200589f, -0.04029080f, 0.18247873f, 0.03908486f, 0.05600134f, -0.06777074f, 0.00175344f, 
    0.09028146f, 0.01918191f, -0.18114442f, 0.01810470f, 0.26501000f, -0.02345053f, -0.25843048f, -0.13810779f, 
    0.03819297f, 0.12599014f, 0.13948883f, -0.22266199f, 0.06749791f, 0.15379506f, 0.07681306f, 0.10857148f, 
    -0.03717711f, -0.14163825f, 0.05363619f, 0.06476005f, -0.08206471f, 0.17524979f, -0.20736980f, -0.08487277f, 
    0.13991123f, 0.02776288f, 0.01528711f, 0.08637296f, 0.09852377f, 0.04509147f, 0.18843742f, 0.11866611f, 
    -0.03829482f, -0.16588517f, 0.00245486f, 0.01534486f, -0.04170724f, 0.10126480f, -0.08374802f, -0.11223789f, 
    0.07598420f, -0.05311272f, -0.04891664f, 0.03715047f, 0.02939484f, 0.02837567f, 0.16814613f, 0.09799373f, 
    0.12794572f, 0.03277538f, 0.08826809f, -0.10720584f, 0.00037413f, -0.10295791f, 0.01963828f, 0.07345571f, 
    -0.07451591f, 0.17056532f, -0.02122280f, 0.05591430f, -0.09354550f, -0.06239707f, -0.04808378f, -0.00165894f, 
    0.06873939f, -0.21602939f, 0.07584354f, 0.09252155f, 0.10652374f, 0.08997196f, -0.06325244f, 0.06913428f, 
    0.01498511f, 0.16439170f, 0.03388028f, -0.04365279f, 0.04332859f, 0.04662905f, -0.04760868f, 0.07249265f, 
    -0.00576351f, 0.07116006f, -0.00430431f, 0.10818499f, 0.20302354f, 0.01552681f, -0.07936748f, -0.08600014f, 
    -0.11517161f, 0.13641325f, 0.08641831f, -0.00405011f, -0.11567745f, -0.22917734f, -0.09586414f, -0.02669971f, 
    -0.15620075f, -0.02662117f, 0.04008974f, -0.08269903f, -0.07248598f, 0.03147962f, -0.18567157f, -0.18309882f, 
    -0.00556902f, -0.00468025f, 0.25124052f, 0.06992591f, -0.03639116f, 0.02465644f, -0.14281455f, 0.02687917f, 
    0.05891113f, 0.09022304f, 0.03160069f, 0.00502366f, 0.12047289f, -0.08664937f, -0.01546091f, -0.40025499f, 
    -0.17186908f, -0.05046803f, 0.18243356f, 0.01853327f, 0.11803620f, -0.00311852f, -0.17566846f, 0.04016520f, 
    0.11488450f, -0.08914998f, -0.05904673f, 0.06916752f, 0.02072128f, -0.08251256f, 0.08514866f, -0.15681291f, 
    -0.06069108f, -0.10228761f, -0.15732212f, -0.01446514f, 0.02098557f, 0.07429706f, 0.04450204f, 0.14357108f, 
    0.01494783f, 0.12177427f, -0.07747346f, -0.01280518f, -0.05842337f, 0.00635989f, 0.13644546f, 0.04955416f, 
    -0.09679365f, -0.04811280f, 0.07602672f, -0.38786867f, -0.24036281f, -0.05630681f, -0.00817956f, 0.10113790f, 
    -0.03165899f, -0.07758190f, -0.06911137f, -0.07067847f, 0.22597677f, 0.17459384f, 0.22492225f, -0.02645275f, 
    -0.25797895f, -0.24491982f, 0.05702186f, 0.12797570f, -0.01992634f, -0.08451466f, -0.15600374f, -0.39495048f, 
    -0.04071583f, -0.03752263f, 0.11702527f, 0.06377555f, -0.01725711f, -0.15508065f, -0.05771555f, 0.06495877f, 
    0.13489105f, 0.11832870f, 0.02838779f, -0.09144627f, 0.09323423f, 0.13375050f, -0.01081390f, -0.09003748f, 
    0.03781889f, 0.08466168f, -0.03188181f, -0.19521518f, -0.13907166f, -0.09281866f, 0.02114596f, -0.20075108f, 
    0.02007132f, 0.10297574f, 0.12554678f, 0.09171188f, 0.00701929f, 0.14265801f, 0.08494697f, 0.01041149f, 
    -0.00811166f, -0.06737492f, -0.10871529f, 0.04904681f, -0.00127182f, 0.05757416f, -0.07826112f, -0.08767210f, 
    0.02037661f, 0.02949896f, 0.05790666f, 0.03717512f, -0.09222124f, -0.00382151f, 0.08277629f, -0.08428199f, 
    0.06604950f, -0.10145864f, -0.04432873f, -0.08516665f, -0.06055107f, -0.34355405f, 0.07041217f, -0.00750973f, 
    0.07352194f, 0.06036681f, -0.06784088f, -0.18319455f, -0.19368631f, 0.02006363f, 0.14523190f, 0.03509776f, 
    0.07291144f, 0.04356230f, 0.01059285f, -0.04473354f, 0.05045942f, 0.07402503f, -0.11320779f, -0.13597533f, 
    0.06553444f, 0.07865053f, -0.01939739f, 0.17644796f, -0.07702296f, -0.10463933f, -0.13117872f, 0.18412700f, 
    0.04072223f, 0.09228864f, 0.08409332f, -0.03657512f, -0.02384763f, 0.06298815f, -0.01560550f, -0.28374395f, 
    -0.23722953f, -0.23089588f, 0.11766191f, -0.00133542f, 0.03293805f, -0.01058020f, -0.03740901f, 0.05487184f, 
    -0.26004413f, -0.12056565f, -0.14022100f, -0.06897529f, 0.08820918f, 0.04161080f, -0.13364272f, -0.05994495f, 
    -0.21232520f, 0.07082347f, 0.22525723f, 0.12436768f, 0.06080653f, -0.07562404f, -0.02542617f, 0.07602835f, 
    0.16769421f, -0.07442914f, -0.15153897f, 0.28916276f, 0.21087037f, 0.09590554f, -0.00374770f, -0.14106809f, 
    -0.09822980f, 0.02922317f, -0.16889930f, -0.36225682f, 0.25929296f, 0.04441898f, -0.04057400f, 0.10881954f, 
    0.05499559f, -0.07747497f, 0.15233618f, -0.09645222f, -0.45782045f, -0.03567703f, -0.28732541f, 0.05706027f, 
    -0.09928808f, 0.02417475f, -0.08977716f, 0.13454965f, -0.08803417f, 0.08469750f, -0.00873878f, -0.21600674f, 
    0.12472899f, -0.03892415f, 0.11437465f, 0.04566006f, -0.16954757f, -0.08785227f, 0.34416810f, 0.04522824f, 
    0.17314894f, 0.05506383f, 0.03732225f, 0.02342586f, 0.02221237f, 0.06140251f, -0.03215887f, -0.29453000f, 
    0.00966855f, -0.31836540f, 0.10781644f, -0.10888720f, 0.08227727f, 0.07031008f, -0.11575076f, 0.04790398f, 
    -0.20170493f, 0.11935002f, -0.16113067f, 0.13224687f, 0.08037940f, 0.00269296f, 0.10792984f, -0.01644996f, 
    -0.06373300f, -0.29433325f, -0.12868308f, -0.11332951f, 0.02473819f, 0.05792320f, -0.05353805f, -0.07441527f, 
    0.10825815f, 0.26222074f, -0.05650232f, 0.24792817f, -0.09595279f, -0.07197148f, 0.10608900f, -0.20456381f, 
    0.07196023f, 0.16217026f, 0.07725682f, 0.30043685f, 0.17518118f, 0.07516183f, 0.02320195f, 0.02667325f, 
    -0.04235210f, -0.13968489f, 0.11210635f, 0.00045815f, 0.38247186f, -0.18595161f, -0.23349740f, -0.12605149f, 
    0.11293934f, -0.15758547f, -0.02296324f, 0.04034466f, -0.09579767f, 0.31555447f, 0.20569678f, -0.30016667f, 
    -0.02444363f, -0.00021274f, 0.07835295f, -0.00006317f, 0.08899349f, 0.17983030f, -0.25863728f, 0.24978429f, 
    -0.03032480f, -0.08474303f, 0.04199259f, 0.03476090f, 0.02885320f, 0.02593428f, 0.15663899f, -0.36768302f, 
    0.05034803f, 0.01085621f, -0.04819873f, 0.16440150f, 0.06779059f, -0.03312987f, 0.06245903f, 0.10698515f, 
    0.08598754f, 0.27984306f, 0.09977039f, 0.20541815f, -0.04974611f, -0.09166847f, -0.12056091f, -0.15349512f, 
    0.07966891f, 0.06660232f, -0.03097236f, -0.10808487f, 0.01697155f, 0.08776391f, -0.13397489f, 0.05669956f, 
    -0.02732939f, -0.00041604f, -0.22701982f, 0.03530927f, -0.26231778f, -0.17859682f, 0.09933195f, -0.00270211f, 
    -0.18000406f, 0.00548979f, 0.04962532f, -0.13326561f, 0.28941128f, -0.38338211f, -0.17901912f, 0.03488317f, 
    0.01411437f, -0.02515517f, 0.12402449f, -0.04380480f, 0.19801542f, 0.12157023f, 0.17105049f, 0.02680569f, 
    -0.07105873f, 0.07253549f, -0.03807401f, 0.00232972f, 0.02354808f, 0.06036700f, -0.16552979f, -0.34849891f, 
    -0.04742336f, 0.09514876f, 0.07534671f, -0.08109467f, 0.04605773f, -0.01831563f, -0.17161115f, 0.13849127f, 
    0.21779011f, 0.13401864f, -0.03935695f, 0.04947445f, 0.20242688f, -0.02962490f, 0.07990996f, -0.19457978f, 
    0.05258509f, -0.41258922f, 0.04857859f, -0.17304015f, -0.08998943f, 0.08790443f, -0.01731767f, 0.13076578f, 
    0.46616885f, 0.17935957f, -0.01969951f, -0.02328745f, -0.03060282f, 0.11445843f, -0.05072186f, 0.03225617f, 
    0.06963199f, 0.53068352f, -0.03601721f, -0.00274073f, -0.00333225f, 0.03169508f, -0.04210307f, 0.06592967f, 
    0.03746771f, 0.05219637f, 0.30217072f, 0.05404820f, -0.27960819f, 0.20788565f, 0.08964606f, 0.00646029f, 
    -0.21717897f, 0.05668701f, -0.02511832f, -0.11745349f, 0.02723988f, -0.16831268f, 0.15441127f, 0.04553019f, 
    -0.04979800f, -0.08944689f, -0.04255272f, 0.08515900f, -0.40970379f, 0.20223802f, -0.23166470f, 0.05816680f, 
    -0.01241022f, 0.07852952f, -0.15108213f, 0.05849086f, -0.08005604f, 0.63220662f, -0.03985214f, -0.07532759f, 
    0.03513705f, -0.03727693f, 0.00737163f, 0.03705306f, 0.00901982f, -0.07536808f, -0.40548497f, 0.06223987f, 
    0.00158378f, -0.15090705f, -0.04981987f, 0.00300434f, -0.08388701f, -0.01416898f, 0.03767937f, -0.17621681f, 
    0.09274202f, -0.02263691f, -0.02815284f, 0.04044311f, 0.01252520f, -0.10834430f, 0.02597121f, 0.05708940f, 
    -0.18215385f, 0.04692827f, -0.09773343f, -0.00559067f, 0.12379175f, 0.06218946f, -0.07810060f, 0.08954835f, 
    0.14122263f, -0.05055709f, 0.07667719f, -0.04546201f, 0.03701468f, 0.01190851f, -0.10018018f, -0.12584198f, 
    0.14620073f, -0.01815902f, -0.22495866f, 0.04128432f, -0.39733306f, -0.06488992f, -0.00279097f, -0.03056750f, 
    -0.06214378f, 0.00597548f, 0.00830372f, 0.24932097f, 0.18059914f, -0.05290044f, -0.04140189f, -0.15669011f, 
    0.00855135f, -0.14664145f, 0.06082758f, 0.00812649f, 0.15607862f, -0.03453715f, -0.18131718f, 0.06407671f, 
    0.18344359f, -0.05882166f, -0.00440960f, -0.11441214f, 0.14312507f, -0.10073492f, 0.08218413f, -0.23219937f, 
    -0.09556349f, 0.12364829f, 0.04831113f, 0.20272717f, -0.16611156f, -0.04685634f, 0.01573378f, -0.12543194f, 
    -0.09672654f, 0.06894290f, -0.05504915f, -0.03223710f, 0.04076810f, 0.01546190f, 0.01063719f, 0.18988016f, 
    0.08908244f, 0.01993608f, 0.01971559f, 0.18898657f, 0.06055437f, 0.12455775f, 0.00751602f, 0.01401024f, 
    -0.16905120f, -0.14041267f, 0.00933165f, -0.11126867f, 0.10237718f, 0.24716334f, 0.15730307f, 0.09418689f, 
    -0.02763864f, 0.13588290f, 0.23268661f, 0.24745059f, 0.10117736f, 0.03023674f, 0.02753067f, -0.13308036f, 
    0.04807633f, -0.00766688f, -0.29331794f, 0.01032400f, -0.39099345f, -0.07639631f, -0.02684435f, 0.00298546f, 
    -0.04624615f, -0.10572555f, 0.01665265f, 0.08383524f, -0.38882503f, 0.01761639f, -0.02807382f, -0.00990241f, 
    0.01484975f, -0.04594838f, -0.03156172f, -0.20651281f, 0.10166886f, -0.22817865f, 0.07133193f, -0.01173832f, 
    0.06851353f, 0.06667736f, 0.02792024f, 0.09500505f, -0.08347389f, -0.25694209f, -0.09137541f, -0.00888969f, 
    0.20038615f, -0.00466788f, -0.06238977f, 0.11485312f, -0.11439993f, -0.01167449f, 0.12206587f, 0.17955855f, 
    0.09475023f, -0.07906273f, -0.03260809f, -0.03777533f, -0.09498079f, -0.05041913f, 0.12631050f, 0.08315244f, 
    0.22058828f, 0.15929709f, -0.10947466f, 0.11448041f, -0.02958423f, -0.01186691f, -0.04022786f, 0.16500856f, 
    -0.22032838f, -0.04941056f, 0.05572373f, -0.07160237f, -0.02073423f, 0.00131061f, -0.08434265f, 0.00190327f, 
    0.02784953f, 0.06990921f, 0.01773374f, 0.02799046f, -0.09418029f, 0.05633280f, 0.14968055f, -0.04204973f, 
    0.01788908f, -0.04119379f, 0.08045086f, 0.14933504f, 0.09511027f, 0.01356569f, 0.13666292f, 0.06007415f, 
    0.10109000f, 0.02856197f, 0.04106800f, 0.29667991f, 0.24501579f, 0.28359187f, 0.03683882f, -0.12351234f, 
    0.05759839f, 0.09835203f, 0.05742695f, 0.00961031f, 0.01954771f, -0.31462580f, -0.11953641f, 0.14736839f, 
    0.03348567f, 0.18272750f, -0.06507839f, 0.04028148f, -0.07350402f, 0.07751911f, -0.05618839f, -0.02510374f, 
    -0.08426497f, 0.15091048f, -0.05721213f, -0.07090878f, 0.03141506f, -0.20481803f, 0.18569444f, 0.02633111f, 
    -0.31500015f, -0.05481626f, 0.16226968f, 0.12859565f, -0.08213757f, -0.06981692f, -0.00196192f, -0.10598005f, 
    -0.01884357f, 0.17578082f, 0.05748820f, 0.05487616f, 0.15676038f, 0.18728419f, -0.00139776f, 0.20021904f, 
    -0.05197805f, -0.17841308f, -0.00562369f, 0.19783999f, 0.11751813f, 0.06220491f, -0.11675894f, -0.05533022f, 
    -0.15826181f, -0.00062780f, 0.09477561f, -0.34298030f, -0.01720596f, 0.03686854f, 0.07106581f, -0.03072902f, 
    0.06338025f, 0.10561652f, 0.29671398f, -0.00483306f, -0.05838351f, -0.00918948f, -0.00681047f, -0.15670717f, 
    0.08668567f, -0.21124254f, -0.06497999f, -0.08084309f, -0.20063773f, 0.02657383f, -0.20443144f, 0.05446586f, 
    0.00166460f, -0.16362131f, 0.19142540f, -0.14180610f, 0.25692487f, 0.04229163f, 0.02839502f, -0.00953570f, 
    -0.17688297f, 0.07127633f, 0.04375476f, 0.01589002f, -0.06600817f, -0.13751015f, -0.29027507f, -0.40640804f, 
    0.12333118f, 0.04820612f, -0.07604890f, 0.12486587f, 0.03629823f, -0.05335253f, 0.07856254f, -0.01734566f, 
    -0.20072688f, -0.07071602f, 0.01298458f, 0.02187096f, 0.06501092f, 0.16003922f, 0.07837681f, 0.13210203f, 
    0.23507683f, 0.26813325f, 0.04833543f, 0.03189603f, -0.03671529f, -0.07010961f, -0.02500144f, -0.18134429f, 
    0.02166951f, 0.07024733f, -0.12529214f, 0.00178404f, 0.12381503f, 0.10992893f, -0.36035186f, -0.03043412f, 
    -0.26607347f, 0.40753826f, 0.09354720f, 0.03938305f, -0.16056299f, -0.02771396f, 0.05842403f, 0.21542114f, 
    0.01123398f, -0.00525376f, 0.24756393f, 0.22674146f, 0.26898578f, -0.19832601f, 0.16274908f, 0.03692326f, 
    0.02885177f, 0.10258577f, -0.00509418f, -0.15860042f, -0.16100262f, -0.00185829f, -0.02356861f, -0.01787551f, 
    0.14518712f, -0.04386475f, 0.03088952f, -0.02330998f, -0.21294059f, -0.19852605f, -0.21376438f, -0.06625188f, 
    0.04613174f, 0.12796852f, -0.07214624f, -0.01736080f, -0.11297042f, -0.20568448f, -0.28729907f, -0.09662019f, 
    -0.08479603f, -0.09759904f, 0.07152019f, 0.12326009f, 0.06008166f, 0.06897527f, 0.38529497f, 0.12279215f, 
    0.14515857f, -0.06880130f, 0.01217165f, 0.11811718f, 0.11634494f, 0.09714436f, -0.06167950f, -0.16754006f, 
    -0.04158647f, -0.03000557f, 0.08269538f, 0.14078787f, -0.04965236f, 0.00604671f, -0.03836291f, 0.13539441f, 
    0.00954812f, -0.19730143f, -0.02459464f, 0.13160877f, 0.00000955f, 0.00043023f, -0.10660170f, -0.02144814f, 
    0.08973677f, -0.21230952f, -0.13353065f, -0.01982136f, -0.07130071f, 0.02977436f, -0.00250187f, 0.05211905f, 
    -0.03663179f, 0.23362117f, -0.00388159f, 0.12900779f, -0.28060436f, 0.02620407f, 0.04484827f, 0.06695288f, 
    -0.10064927f, 0.02889370f, -0.05010142f, 0.19458754f, 0.05016296f, -0.02126884f, -0.06693556f, 0.01085895f, 
    0.00470295f, 0.06561849f, -0.00944863f, 0.04745837f, 0.04026854f, -0.11873762f, 0.06424898f, 0.05821052f, 
    -0.06027583f, 0.07975214f, -0.03462450f, -0.03760393f, -0.00542982f, -0.12789965f, -0.03927349f, -0.02836706f, 
    -0.10707013f, 0.05098401f, 0.05347087f, 0.06434361f, 0.18212368f, 0.14413863f, -0.18967257f, 0.10529380f, 
    0.01459774f, 0.14224640f, -0.05704852f, -0.04538315f, 0.09759820f, -0.03791850f, 0.23092115f, -0.06563848f, 
    -0.12546697f, -0.16411552f, -0.16382980f, -0.00150948f, 0.13501248f, 0.00381645f, 0.09818102f, -0.03529312f, 
    0.27258709f, 0.33947739f, 0.30618820f, 0.18735711f, 0.17048855f, -0.01051793f, -0.00155603f, 0.17628996f, 
    0.12002649f, -0.26335052f, 0.01958436f, -0.20917819f, -0.03642750f, 0.05554073f, -0.06114555f, 0.02325389f, 
    0.13917698f, -0.02630670f, -0.06179473f, -0.29464790f, -0.07963948f, -0.04129260f, -0.08684766f, 0.08067610f, 
    -0.24948289f, -0.06614428f, -0.22788262f, -0.24031992f, -0.21824078f, -0.28418341f, -0.07325090f, 0.05171856f, 
    -0.05990402f, 0.02850028f, -0.06325302f, -0.13474698f, 0.38221940f, 0.16976778f, 0.04265370f, 0.11795700f, 
    -0.04044731f, -0.04875620f, 0.18140896f, 0.03674978f, 0.08071817f, 0.08776492f, 0.10547212f, -0.08885211f, 
    0.01413514f, 0.10361520f, -0.09860922f, 0.13028166f, -0.01698528f, -0.01174447f, 0.16774122f, 0.19696103f, 
    0.05160103f, 0.09373806f, -0.02704470f, 0.16859271f, 0.02143452f, 0.08142368f, -0.09586149f, -0.22996749f, 
    0.17383905f, -0.05405939f, 0.04557858f, 0.10949049f, -0.37912586f, -0.04518266f, -0.07015283f, 0.09136295f, 
    0.05577141f, 0.23674212f, -0.04242511f, 0.27754000f, 0.04292121f, -0.04119055f, 0.07348802f, -0.04833582f, 
    0.00100875f, -0.02777610f, 0.07621870f, 0.02544557f, 0.23181666f, -0.11240349f, 0.02339289f, 0.01051668f, 
    -0.10359968f, 0.03519348f, -0.07748245f, 0.10650965f, 0.06881873f, -0.00910066f, -0.06590566f, -0.09885564f, 
    -0.12521306f, -0.09785815f, -0.02033263f, 0.05599337f, 0.05015028f, 0.01244090f, 0.10950310f, -0.08335590f, 
    0.02929858f, -0.08622313f, -0.07458285f, -0.23101012f, -0.29508927f, 0.04383260f, -0.30364725f, 0.12459084f, 
    0.04350847f, 0.05538535f, -0.13370404f, 0.10688380f, -0.08076598f, 0.32098103f, 0.49289176f, 0.21310809f, 
    0.12561642f, 0.18061401f, 0.05116352f, 0.10711255f, 0.17802267f, 0.05330594f, -0.09134351f, -0.21389024f, 
    0.09878448f, -0.05828349f, 0.08374443f, -0.07256826f, -0.12408169f, 0.11455653f, -0.09322894f, -0.34426892f, 
    0.36368355f, -0.09071286f, -0.12124854f, 0.15086608f, 0.11189761f, 0.04867544f, 0.11481234f, 0.07592348f, 
    0.03093099f, 0.09872700f, -0.18387197f, -0.05921939f, 0.07491890f, 0.36610866f, 0.07472569f, 0.08840330f, 
    -0.03036524f, 0.43864548f, 0.07298595f, 0.02474004f, -0.08274708f, 0.18889266f, -0.02452726f, 0.02173718f, 
    0.08707938f, 0.14350587f, 0.18046285f, -0.11443884f, 0.01584150f, -0.14035931f, 0.12653536f, 0.12548251f, 
    -0.27709347f, 0.09841694f, 0.01470754f, 0.16245626f, -0.04616233f, -0.13848852f, 0.11232308f, -0.04918541f, 
    0.18617541f, 0.09832417f, 0.01749305f, -0.09944452f, 0.01397165f, 0.01998394f, -0.10394437f, 0.21748133f, 
    -0.11199969f, 0.26205972f, -0.16479830f, 0.05412998f, 0.02225904f, -0.03035481f, 0.15321030f, -0.04056828f, 
    0.16390993f, -0.09729741f, -0.08457947f, 0.00508308f, -0.04251395f, -0.05672373f, 0.34672844f, 0.15144190f, 
    0.12515458f, 0.03216265f, -0.00509631f, 0.13670221f, 0.04007511f, 0.00730891f, 0.20818645f, -0.13448553f, 
    0.09140603f, 0.22471790f, 0.14362547f, 0.01241950f, -0.08018937f, 0.01654335f, -0.12793106f, 0.08048539f, 
    0.19356677f, 0.29683879f, 0.07930533f, 0.13185145f, 0.27178571f, 0.08199215f, 0.16002883f, 0.03831138f, 
    0.08307478f, 0.05471966f, 0.19293101f, 0.12326579f, -0.01390555f, 0.16035803f, -0.10822722f, 0.17120518f, 
    0.02941860f, -0.12639923f, -0.02659419f, 0.02144863f, -0.00714536f, -0.17887773f, 0.12988204f, 0.07188063f, 
    -0.11654323f, -0.01491349f, 0.15324534f, -0.20381586f, -0.08684698f, -0.04400437f, -0.21207869f, 0.06182666f, 
    -0.27548310f, -0.09143050f, 0.05226474f, 0.03178275f, -0.07703842f, 0.10036286f, 0.00120967f, 0.25694185f, 
    0.03628031f, 0.01628439f, -0.12446875f, 0.03848197f, -0.09502035f, -0.35325485f, -0.33227909f, 0.05236328f, 
    -0.06740043f, -0.07225072f, -0.05004092f, -0.10142741f, 0.02378716f, 0.12175518f, 0.10522128f, 0.16321629f, 
    -0.02096824f, -0.17226529f, -0.03464853f, -0.24225754f, 0.30769780f, -0.14761017f, -0.19621038f, 0.14387734f, 
    0.19539444f, -0.08998166f, 0.23389198f, 0.08603679f, 0.21906260f, -0.07579940f, -0.17207348f, 0.06152356f, 
    -0.25256005f, -0.26924086f, -0.31399265f, -0.09773464f, 0.20506853f, -0.20362677f, 0.05458508f, 0.14556675f, 
    0.01021898f, 0.16799599f, 0.24052510f, 0.13013127f, -0.25303349f, -0.07331841f, -0.01264207f, -0.13671124f, 
    0.16758844f, -0.16454652f, 0.03624470f, 0.10124869f, -0.12161890f, 0.17482752f, 0.02839476f, 0.21416557f, 
    0.07817324f, -0.05882067f, -0.17836867f, 0.19685778f, -0.03039823f, -0.21637771f, 0.12551008f, -0.06017432f, 
    0.07437046f, 0.22850624f, -0.25682324f, -0.25072393f, -0.13612282f, -0.08853693f, -0.13036884f, -0.19525151f, 
    -0.14716977f, -0.17949232f, -0.08717778f, -0.08168547f, 0.07643590f, -0.02229552f, -0.04622665f, -0.08862105f, 
    0.17902662f, 0.18480301f, 0.07396739f, 0.12904692f, 0.06395314f, 0.25947696f, 0.17338406f, -0.09568271f, 
    -0.07461271f, 0.01716720f, -0.10735122f, 0.03859743f, -0.06610047f, 0.07026131f, 0.02091020f, 0.09659849f, 
    -0.01799486f, 0.03124851f, -0.02435576f, -0.00028483f, -0.28223670f, -0.17963591f, 0.21578175f, -0.05820622f, 
    0.10279369f, -0.29439694f, 0.04901388f, 0.02251050f, 0.02302855f, 0.10012154f, 0.03319350f, 0.01434490f, 
    -0.01846362f, 0.31376845f, -0.05737496f, 0.02905074f, 0.00279916f, 0.03208761f, 0.02262681f, -0.03211058f, 
    0.09509494f, 0.06551510f, 0.06123408f, 0.06988755f, -0.05362181f, 0.22517574f, 0.11462221f, -0.00625278f, 
    0.02313628f, -0.07210597f, -0.12243145f, 0.32317406f, -0.01989236f, 0.00718906f, 0.05366852f, 0.21692382f, 
    0.08886383f, -0.00490633f, 0.15538497f, -0.05274154f, 0.15205282f, 0.26759696f, 0.04646505f, -0.24281101f, 
    -0.00977227f, -0.06300087f, 0.11173671f, -0.22723238f, 0.04188455f, 0.13680626f, -0.51564139f, -0.22102030f, 
    -0.12622479f, -0.00061272f, -0.11201564f, 0.00940545f, -0.17802712f, -0.01047376f, -0.06222830f, 0.16587083f, 
    -0.26942781f, 0.26756871f, 0.16755769f, 0.14930628f, -0.03876402f, 0.11773692f, 0.10740890f, 0.24630973f, 
    0.25219539f, -0.12433140f, -0.19447517f, 0.03863582f, 0.03683523f, -0.01212940f, -0.03235544f, -0.17764647f, 
    0.01770950f, -0.06440399f, 0.04347528f, 0.02841095f, 0.03538779f, -0.02073350f, -0.05189530f, 0.04988042f, 
    -0.03464671f, -0.04776786f, -0.03506062f, 0.00765826f, -0.02424662f, -0.06340589f, 0.01287702f, -0.05692200f, 
    -0.01684820f, -0.05911164f, 0.02205031f, -0.02535544f, -0.00531900f, -0.00036531f, 0.04467145f, -0.03225299f, 
    -0.02884284f, 0.01257150f, 0.01156615f, -0.00494326f, -0.01344518f, -0.05334659f, -0.00112989f, -0.03473875f, 
    -0.05321535f, 0.03045285f, -0.04093546f, 0.00044341f, 0.04239651f, 0.00120385f, -0.05656398f, -0.06373850f, 
    -0.06055611f, 0.02892450f, -0.05599264f, -0.00875832f, -0.03334612f, -0.04017388f, 0.02466168f, -0.05313927f, 
    -0.03893851f, 0.00036367f, -0.06311420f, -0.02810473f, 0.04130366f, -0.05519072f, -0.05432012f, -0.02105034f, 
    0.02737013f, 0.03491518f, -0.01189463f, -0.04172227f, -0.04532900f, -0.03255474f, -0.04802392f, -0.01114276f, 
    0.03228876f, 0.03665874f, 0.01800807f, -0.02190840f, -0.06089394f, 0.04867206f, -0.04977534f, 0.03556633f, 
    0.04366643f, -0.02683886f, 0.00230951f, -0.03891723f, 0.00969549f, 0.03225380f, -0.01854543f, -0.04541029f, 
    0.01981348f, 0.03885660f, 0.01389419f, -0.05650593f, 0.00485708f, -0.02075663f, -0.03499656f, 0.01313280f, 
    0.01541099f, 0.01075508f, -0.03156020f, 0.01547922f, 0.01019217f, 0.02096686f, 0.03867598f, 0.04748261f, 
    0.01783644f, -0.05905577f, 0.00625199f, -0.05564207f, -0.03495407f, 0.02290094f, -0.03235216f, 0.00390045f, 
    0.04604280f, 0.03680699f, -0.02448719f, -0.01598923f, 0.03979335f, -0.02307882f, -0.00472582f, -0.05107092f, 
    -0.04612452f, -0.06274942f, -0.02729957f, 0.01630569f, -0.03559319f, 0.01643066f, -0.06363580f, -0.00055485f, 
    -0.03885654f, -0.00560380f, -0.03607078f, -0.04361182f, 0.03707014f, -0.03265064f, 0.04464482f, -0.02182120f, 
    -0.00882487f, 0.02287630f, 0.02977911f, 0.00428350f, -0.05365493f, -0.04624663f, -0.03661567f, -0.02251445f, 
    0.02416215f, -0.05737241f, -0.03059304f, -0.05769311f, -0.04981671f, -0.01863280f, -0.01724243f, -0.06139437f, 
    0.05192344f, 0.01967258f, 0.01271880f, -0.06091427f, -0.03226705f, 0.01721866f, 0.00092355f, 0.02121766f, 
    0.03532007f, -0.00562234f, 0.02117654f, -0.01909409f, -0.04420892f, -0.04274286f, -0.04520237f, 0.03650128f, 
    -0.02014649f, -0.00199780f, -0.03237410f, 0.00485455f, 0.04225766f, 0.02266981f, -0.04783649f, 0.05144639f, 
    0.03278856f, -0.00543502f, 0.01275681f, -0.00408092f, -0.05196564f, -0.04283674f, 0.01378978f, -0.04334930f, 
    -0.00931426f, -0.01326204f, 0.01435150f, 0.04555700f, 0.03147501f, -0.03532147f, -0.02078549f, -0.03568977f, 
    0.05173257f, 0.02300210f, 0.00441535f, 0.03628770f, -0.04569506f, -0.00465108f, -0.04109605f, 0.00842897f, 
    0.05054728f, 0.01806312f, 0.04606784f, 0.02160757f, -0.03747380f, 0.02112556f, 0.01708189f, 0.00298857f, 
    -0.03063600f, -0.05467833f, -0.03586971f, -0.00458985f, -0.01576618f, -0.04001344f, -0.01321174f, 0.00786675f, 
    -0.02340913f, 0.04271587f, 0.01856566f, 0.04505534f, -0.06212916f, 0.02530973f, -0.05535122f, -0.02044838f, 
    0.01366990f, 0.02495984f, 0.03604064f, 0.04192093f, 0.04781048f, 0.01396064f, -0.00007610f, -0.03131791f, 
    -0.02700931f, -0.00233278f, 0.04008566f, 0.01102528f, 0.00926775f, 0.04514776f, -0.05581639f, -0.02207651f, 
    -0.05222186f, 0.04593506f, -0.01706067f, -0.02080165f, 0.01786009f, 0.05139762f, 0.02327402f, -0.00876085f, 
    -0.04654553f, 0.01811663f, 0.03839759f, -0.05843351f, 0.00953904f, -0.05969515f, -0.04733375f, -0.04554795f, 
    0.02355861f, -0.04893696f, 0.02360183f, -0.05475973f, -0.02426327f, 0.00315714f, -0.01738815f, -0.01449300f, 
    -0.03459222f, 0.04079124f, 0.01480915f, 0.02696758f, 0.05274041f, 0.03405599f, -0.00396034f, -0.06012927f, 
    0.00816543f, 0.01345482f, 0.05185995f, -0.05581247f, -0.03475637f, -0.02367132f, 0.03265789f, 0.00838950f, 
    0.00370757f, -0.04069049f, -0.02431793f, -0.03433207f, -0.03055072f, -0.02323783f, 0.03559214f, -0.00740770f, 
    -0.04487539f, -0.00183426f, 0.04263925f, -0.05285890f, -0.03135028f, -0.01001316f, 0.02059332f, -0.03119876f, 
    -0.02577814f, -0.06347748f, 0.03814270f, 0.03892834f, 0.03769222f, -0.01091294f, -0.05197493f, -0.02588014f, 
    -0.00685930f, 0.03735594f, -0.04514275f, 0.01232628f, 0.04819340f, 0.00850950f, -0.03501813f, -0.06277881f, 
    0.02287944f, 0.04485184f, 0.00410035f, 0.00573578f, 0.05200370f, 0.00091410f, 0.03198323f, -0.05858369f, 
    0.05001930f, -0.04597543f, 0.04817413f, 0.02428773f, -0.06164812f, 0.04428872f, -0.00035385f, 0.01485309f, 
    0.03174570f, 0.04289393f, -0.01409064f, 0.02907229f, -0.01665404f, 0.01693457f, 0.00015626f, 0.04671477f, 
    0.04787556f, -0.05790569f, -0.03039568f, -0.00971107f, -0.01660760f, -0.02084778f, -0.06084976f, 0.01959952f, 
    -0.03565397f, -0.02142891f, 0.03797189f, 0.00827770f, -0.01068117f, -0.01885300f, -0.00992322f, 0.03477993f, 
    0.01917808f, -0.02017455f, -0.04851166f, 0.05130228f, 0.00858352f, -0.05668302f, -0.05405231f, 0.00441190f, 
    0.03746082f, -0.06551687f, -0.01749755f, -0.05858098f, 0.00302167f, -0.01430869f, 0.02389144f, -0.04927964f, 
    -0.05615581f, 0.04298794f, -0.01729533f, 0.02506051f, 0.01656332f, 0.03948674f, 0.04594031f, -0.01824867f, 
    -0.00080374f, -0.02976794f, -0.06418650f, -0.00422080f, -0.01815493f, 0.03830574f, -0.06022575f, 0.01303547f, 
    -0.05234176f, 0.00275121f, -0.02894770f, -0.00042153f, 0.04778472f, 0.02273971f, -0.03889466f, -0.01576173f, 
    -0.02144603f, -0.04168436f, -0.02585226f, -0.00451207f, -0.04534038f, 0.02337559f, -0.03178626f, -0.03407588f, 
    -0.04662741f, 0.03768424f, -0.04115098f, 0.01355290f, 0.02407855f, 0.02217362f, -0.01058086f, -0.02871927f, 
    -0.05194873f, -0.02416334f, -0.03422312f, 0.00621044f, 0.03868284f, 0.04704424f, -0.05705015f, 0.02950853f, 
    -0.02288023f, -0.00017765f, 0.02282444f, 0.04983442f, -0.00793929f, 0.03252650f, -0.05944295f, -0.03215744f, 
    -0.05295276f, -0.01605702f, 0.05005274f, -0.00109941f, 0.02625638f, -0.02100733f, 0.01404626f, 0.00090449f, 
    -0.03313463f, -0.05823650f, 0.00500445f, 0.01825204f, 0.00257313f, 0.02706117f, -0.01379794f, 0.00393811f, 
    0.04022670f, 0.00073452f, -0.02276281f, -0.01730972f, -0.04490965f, -0.05546700f, 0.05503169f, 0.03772483f, 
    -0.06093748f, 0.00912550f, -0.05336235f, -0.01750301f, -0.01143391f, -0.03426113f, 0.04071846f, -0.00629638f, 
    -0.00049095f, 0.04476089f, 0.00762648f, -0.06256532f, -0.02060758f, -0.02267385f, 0.02140000f, 0.02325086f, 
    0.05203768f, 0.00751312f, -0.01524273f, -0.02295065f, 0.03917532f, 0.01064272f, 0.02517252f, 0.00825348f, 
    0.02977515f, -0.05478778f, -0.01885997f, -0.05685734f, -0.01139786f, -0.04362625f, -0.00126628f, 0.00571431f, 
    -0.02127395f, -0.02365540f, 0.03447626f, 0.04758894f, -0.04113254f, -0.04457066f, -0.05719728f, -0.03938919f, 
    -0.05530279f, -0.05415049f, 0.04845416f, 0.00321912f, -0.02392925f, -0.01502553f, -0.02725107f, 0.03915093f, 
    -0.00357945f, -0.05895930f, 0.04004749f, -0.04378473f, -0.01038089f, -0.04621598f, 0.05103186f, -0.04149021f, 
    0.04438736f, 0.00442163f, 0.00844177f, 0.04504653f, -0.02107448f, -0.01261746f, -0.04947606f, -0.04239924f, 
    -0.04503968f, -0.02817869f, -0.05819913f, -0.00367490f, 0.04619479f, -0.05366513f, 0.00381737f, -0.03542505f, 
    -0.00860441f, -0.05150291f, -0.05149056f, -0.01960151f, -0.03623310f, 0.01756662f, 0.02886852f, -0.01830569f, 
    -0.04461136f, -0.02644101f, 0.00300031f, 0.02485563f, 0.03778422f, 0.03171773f, -0.03885607f, 0.00946634f, 
    -0.02137861f, 0.01345458f, -0.01839639f, -0.05641337f, 0.01393304f, 0.00360796f, 0.03207689f, -0.01731627f, 
    -0.05614043f, -0.01887615f, -0.00276525f, -0.04914834f, 0.02119901f, -0.05783798f, -0.05506446f, -0.04837026f, 
    -0.04587271f, 0.01763782f, -0.02283770f, 0.03689941f, 0.00134207f, 0.01532266f, -0.04822151f, 0.01650636f, 
    0.02019697f, -0.03486523f, -0.06115505f, -0.00996363f, 0.02930411f, -0.00997387f, 0.02315738f, 0.04940527f, 
    0.04217875f, -0.04055334f, 0.01492983f, 0.03016423f, -0.03986260f, -0.04041257f, 0.00320731f, -0.04713183f, 
    -0.02497153f, 0.04726158f, 0.04025662f, 0.04044845f, 0.02204041f, 0.01984008f, -0.02604260f, 0.02426796f, 
    0.06825393f, 0.02949020f, 0.08948261f, -0.03477253f, -0.08479971f, 0.06181755f, 0.06612951f, 0.16398694f, 
    -0.05959151f, -0.83340412f, -0.06754149f, 0.19291376f, 0.12864040f, 0.26489675f, -0.02496372f, 0.13824521f, 
    -0.01404391f, -0.00164229f, -0.39264798f, -0.40135720f, 0.05271555f, 0.17745908f, -0.04878050f, -0.11267620f, 
    0.09924120f, -0.05406925f, -0.10180795f, 0.05687078f, 0.19278982f, 0.07686806f, -0.08648265f, -0.00060804f, 
    0.07443985f, -0.15563431f, 0.11486009f, -0.00319008f, 0.05949110f, 0.16658816f, -0.10049332f, -0.12049075f, 
    0.05236993f, -0.07007767f, 0.05618503f, 0.10574989f, 0.09572156f, 0.15020564f, -0.11176330f, -0.05297780f, 
    0.07282723f, 0.04038438f, -0.06609584f, 0.07895298f, 0.06253260f, 0.09108502f, -0.48542893f, -0.31649461f, 
    0.01145929f, 0.12105483f, 0.27875414f, 0.01270797f, 0.13752270f, 0.17351171f, -0.01017955f, 0.38155988f, 
    -0.03651094f, -0.12898992f, 0.03970296f, -0.09565080f, 0.06463219f, 0.14949313f, -0.07240900f, 0.17690296f, 
    -0.03135933f, -0.21153450f, -0.22402418f, 0.01922026f, -0.04654007f, -0.06839275f, 0.02941586f, -0.03840756f, 
    -0.06958239f, -0.00469680f, 0.35170731f, 0.27096644f, 0.01591717f, 0.06979845f, -0.07717901f, -0.03421937f, 
    -0.00954198f, -0.08558062f, 0.06354603f, -0.08814798f, 0.10667495f, 0.12845716f, -0.02493701f, 0.09077939f, 
    0.15232286f, -0.02047664f, 0.22228099f, -0.25311524f, -0.04942560f, -0.14966407f, -0.16662991f, 0.06962901f, 
    0.15201423f, 0.08246780f, 0.05932164f, 0.00544575f, 0.10424779f, -0.25273839f, -0.12401663f, 0.07162979f, 
    0.10117152f, -0.05080400f, 0.07736185f, -0.17154163f, 0.03577183f, -0.30863574f, -0.26632625f, 0.04755360f, 
    0.13739331f, -0.04578260f, -0.00651681f, 0.03943362f, -0.12040621f, -0.09181201f, -0.32984254f, 0.01603670f, 
    0.10875189f, 0.09079880f, 0.02111320f, -0.04427266f, -0.03348399f, -0.08958796f, -0.06010823f, -0.29199457f, 
    -0.06472266f, 0.05480836f, 0.12572594f, 0.05578417f, 0.04066253f, 0.00266928f, 0.00269105f, 0.07673550f, 
    0.00092369f, 0.04051520f, 0.11346916f, -0.00476202f, -0.01540791f, 0.02463734f, 0.17717764f, -0.36112607f, 
    0.10645061f, -0.25884062f, -0.18561420f, 0.05514363f, 0.25010923f, 0.02158022f, -0.08500732f, 0.15638110f, 
    0.01998922f, -0.08508949f, 0.02556239f, 0.12587194f, 0.27865037f, 0.05073908f, -0.00972096f, 0.00800192f, 
    -0.09105610f, 0.14611143f, 0.08954366f, -0.21675414f, -0.02698308f, 0.39453557f, 0.14183210f, 0.09736919f, 
    -0.04623979f, -0.01246798f, 0.04732640f, 0.08910786f, -0.36066768f, -0.31319699f, -0.18019338f, -0.01420768f, 
    0.08325364f, 0.08950499f, 0.12173358f, -0.01979132f, 0.02964009f, -0.16555248f, -0.07696459f, 0.08698253f, 
    0.04184176f, 0.03312654f, 0.11302789f, -0.02451533f, 0.00899745f, -0.08714348f, -0.23187612f, -0.05304700f, 
    -0.09306379f, 0.04922767f, 0.07566031f, 0.19128753f, -0.04385509f, 0.10517590f, 0.03855972f, 0.07925896f, 
    -0.30089131f, -0.11778069f, -0.03196235f, 0.07527413f, -0.04636527f, 0.09926061f, 0.03875083f, 0.12543212f, 
    -0.26909399f, 0.01275905f, 0.07482314f, 0.04603450f, 0.13845634f, -0.05639140f, -0.03601841f, -0.15896243f, 
    -0.01118294f, -0.43220234f, -0.18374850f, -0.04549114f, 0.29411846f, 0.17483795f, 0.02788714f, 0.04019038f, 
    -0.13223305f, -0.06250450f, -0.10634571f, -0.18380412f, -0.05307908f, -0.34882674f, -0.20910276f, 0.05760129f, 
    0.09944160f, 0.04627487f, 0.08699272f, -0.29445392f, -0.07896619f, 0.23907524f, 0.00575557f, 0.03951707f, 
    -0.02246662f, 0.27507135f, -0.07700239f, -0.01915240f, -0.12698573f, 0.07954928f, 0.12805951f, 0.14116335f, 
    -0.09509303f, -0.22379476f, -0.10144601f, -0.19433604f, 0.06720749f, 0.08061722f, 0.10996190f, 0.03026214f, 
    -0.10530536f, 0.07426686f, -0.06024866f, 0.10040640f, 0.10097579f, 0.04212712f, 0.03138214f, 0.00846715f, 
    0.11634150f, -0.11084945f, -0.19261733f, 0.22667322f, 0.04550704f, 0.14234954f, 0.10712111f, -0.10037872f, 
    0.16772932f, 0.12524995f, 0.17835170f, 0.15731798f, 0.04602700f, 0.16340688f, -0.06544006f, -0.00938080f, 
    -0.07005379f, -0.02307552f, 0.00702267f, 0.01830401f, -0.07948767f, -0.02973826f, 0.03636143f, -0.08293738f, 
    -0.02706514f, -0.05587899f, -0.05034143f, 0.02921332f, 0.01478008f, -0.02236839f, 0.02151630f, -0.00261592f, 
    -0.01205141f, -0.07355250f, 0.03064035f, 0.01180916f, -0.00158929f, -0.04451948f, -0.06052744f, -0.01070801f, 
    -0.09030011f, -0.06003678f, -0.09515020f, -0.05036634f, -0.05962492f, -0.03162502f, -0.09019105f, -0.04155023f, 
    -0.06758808f, 0.03254328f, -0.05645526f, -0.06269852f, -0.02250639f, -0.03582394f, 0.00000128f, -0.03188178f, 
    0.03759041f, -0.05956467f, -0.06469200f, -0.07407842f, -0.02486915f, -0.07737559f, -0.00371996f, -0.09535314f, 
    -0.00311985f, 0.02472066f, -0.01062155f, -0.05276216f, -0.03835941f, -0.03890651f, -0.05545918f, -0.02461145f, 
    -0.06375004f, -0.02217140f, -0.06009825f, -0.02610634f, 0.00729625f, -0.06545699f, -0.05251802f, 0.00721957f, 
    -0.01786761f, -0.05671911f, 0.00658392f, 0.00694794f, 0.01992356f, 0.02956794f, 0.02703329f, -0.00241376f, 
    -0.00969916f, -0.00647009f, -0.03961402f, -0.06208488f, -0.05276206f, -0.00205794f, 0.00771874f, -0.01157090f, 
    -0.05884444f, -0.07313156f, 0.00116003f, -0.01397087f, -0.01979593f, -0.01362380f, -0.08241379f, -0.07260334f, 
    -0.07444782f, -0.04677209f, -0.00671696f, -0.01829529f, 0.01631167f, -0.01395588f, -0.02784395f, 0.01456913f, 
    0.00043641f, 0.02910299f, 0.02495250f, -0.01725294f, 0.02587575f, 0.00207429f, -0.03109635f, 0.00573128f, 
    -0.02058417f, -0.08189475f, 0.00923755f, 0.02332302f, -0.04686703f, -0.00657205f, -0.04546545f, -0.02305961f, 
    0.02781141f, -0.06998487f, 0.01860929f, -0.00220143f, -0.00010140f, -0.02321972f, -0.07519450f, -0.00219273f, 
    -0.04266007f, -0.03727808f, -0.09296769f, 0.01293609f, -0.07320871f, 0.00173478f, 0.02399918f, 0.01815004f, 
    -0.02826174f, -0.05984000f, 0.00712998f, -0.07176331f, -0.01790834f, -0.08415074f, 0.00167141f, 0.00824205f, 
    0.01822237f, -0.06545645f, 0.01644798f, 0.02872994f, -0.03143228f, -0.07167552f, -0.04747058f, -0.06444566f, 
    0.01948447f, -0.04535021f, -0.06239628f, -0.01723283f, -0.07753886f, 0.02980162f, 0.01098937f, 0.00042691f, 
    -0.08713421f, -0.09798945f, 0.02575326f, -0.00909205f, -0.05006395f, -0.01481643f, -0.06433228f, -0.05639759f, 
    -0.06190477f, -0.04593767f, -0.08505774f, 0.01798644f, -0.03581293f, 0.00811451f, -0.01458884f, -0.03077210f, 
    -0.07050904f, -0.03195048f, 0.01225187f, 0.01510379f, -0.00825804f, 0.01885715f, 0.00638222f, -0.00450059f, 
    -0.02560633f, -0.07490917f, -0.04969101f, -0.06171826f, -0.09520765f, -0.05602043f, -0.06623007f, -0.05882160f, 
    -0.04594506f, -0.04130382f, -0.09053029f, -0.03820705f, -0.01232745f, 0.03332307f, -0.02693758f, 0.01271969f, 
    -0.05501177f, -0.05031309f, -0.07253242f, -0.02437116f, -0.00667097f, -0.06579903f, -0.06808238f, 0.01110425f, 
    -0.00925896f, -0.08931632f, -0.01714321f, -0.01042090f, -0.05629831f, -0.01715275f, 0.00542980f, 0.02608864f, 
    -0.05459570f, 0.01727317f, -0.02349882f, -0.00734147f, 0.02034868f, 0.00835164f, -0.00184304f, -0.02120278f, 
    -0.01017076f, -0.06978172f, -0.07060385f, -0.06897701f, -0.00998452f, -0.03433662f, -0.00842261f, -0.08490062f, 
    -0.00295436f, -0.00461790f, 0.02499576f, -0.02066541f, -0.00232115f, 0.02262484f, -0.06373033f, -0.05607834f, 
    0.00411818f, -0.02795946f, 0.01867212f, -0.07084666f, 0.01293591f, -0.04971441f, 0.04059244f, -0.01827892f, 
    -0.00316524f, 0.01781373f, -0.07945455f, -0.07588728f, -0.03598233f, -0.04670130f, 0.02584530f, -0.02167737f, 
    0.01201931f, 0.01129279f, -0.02487339f, -0.06623618f, -0.06684002f, -0.04676116f, -0.02573394f, -0.02702636f, 
    -0.02161999f, -0.01572825f, -0.00454919f, 0.00632092f, -0.06291314f, 0.01962420f, 0.03261041f, -0.04988799f, 
    -0.07205481f, -0.05158956f, -0.02978378f, -0.01525554f, -0.03451186f, -0.03313614f, -0.05010138f, -0.04834905f, 
    -0.06374930f, 0.02315969f, -0.08586103f, -0.08638247f, 0.00679101f, 0.01194594f, -0.03212356f, -0.05286941f, 
    -0.08941697f, -0.03037563f, -0.02619094f, -0.04293326f, -0.10778527f, -0.00730901f, 0.02566979f, 0.04391164f, 
    0.00601975f, -0.05201024f, -0.22529028f, 0.09793661f, 0.09620391f, 0.05882544f, 0.02850049f, 0.03774063f, 
    -0.04481405f, 0.01300642f, 0.35453245f, 0.20227198f, 0.06859802f, -0.07280768f, 0.19649260f, 0.09938636f, 
    0.01876619f, 0.06009191f, -0.19812475f, 0.27828872f, 0.20017760f, 0.12948543f, -0.05480618f, 0.05247826f, 
    -0.10415293f, -0.03815310f, 0.10350263f, 0.00143026f, -0.10132854f, 0.03139354f, 0.01675552f, -0.04150587f, 
    0.06132295f, 0.09694748f, 0.05523772f, 0.10102735f, -0.10072023f, -0.20386608f, -0.17832783f, -0.01774889f, 
    0.04571462f, -0.00664177f, 0.03900426f, 0.09928881f, -0.04177723f, 0.06264601f, 0.02284013f, -0.05923652f, 
    0.13580796f, -0.06198818f, 0.03406686f, 0.06583807f, 0.11211900f, 0.14544107f, -0.02985371f, 0.16018561f, 
    0.15646142f, 0.05568078f, -0.03687946f, 0.15159234f, 0.08724947f, 0.07761902f, 0.07192126f, 0.14288041f, 
    0.19942650f, 0.15191412f, -0.05753376f, -0.06021554f, -0.03469150f, 0.05830150f, -0.04958583f, 0.02372110f, 
    -0.00104805f, 0.09970377f, 0.11244880f, 0.01474994f, -0.03600673f, 0.01925065f, -0.03427712f, 0.06460683f, 
    0.09890243f, 0.08430243f, 0.08152430f, 0.14899206f, -0.03198851f, 0.04775095f, -0.04098349f, 0.00328570f, 
    -0.02647770f, 0.05400013f, 0.10210066f, 0.25433156f, 0.16816340f, 0.15910940f, -0.05669034f, 0.05443151f, 
    -0.11847811f, -0.02352960f, -0.06314041f, 0.07048576f, -0.05197154f, -0.04472588f, -0.01301967f, -0.06943260f, 
    -0.12771524f, -0.01943137f, 0.03579327f, -0.15206505f, -0.34080848f, -0.21266273f, 0.09645028f, 0.17175455f, 
    -0.09957615f, 0.17126139f, -0.03616911f, 0.02473690f, -0.04386726f, -0.26063520f, -0.03144871f, -0.29253727f, 
    0.03463709f, -0.03283154f, -0.09137876f, -0.10730302f, -0.02393203f, 0.01076394f, 0.25613150f, 0.04962543f, 
    -0.00066363f, 0.00674838f, 0.06668559f, -0.00926267f, 0.05209042f, 0.10596023f, -0.10436103f, -0.18860286f, 
    -0.00961400f, -0.01909588f, -0.06006114f, 0.02518426f, 0.16943681f, 0.07858416f, 0.05330614f, -0.02971641f, 
    0.00855332f, 0.03992638f, -0.16101879f, 0.11448332f, -0.09024982f, -0.15992515f, 0.06001048f, 0.01182257f, 
    -0.13030447f, 0.14533593f, 0.34089404f, 0.02076839f, 0.12967326f, -0.00439111f, 0.00986354f, 0.00695724f, 
    0.03464560f, -0.03327865f, 0.02108603f, -0.34004721f, 0.08643342f, 0.01944997f, -0.02070260f, 0.00583995f, 
    0.01075151f, 0.03381885f, 0.14209074f, 0.06587543f, -0.23114520f, 0.01062886f, 0.05237809f, -0.00356312f, 
    0.04888785f, 0.11105254f, 0.03701876f, 0.09523714f, 0.01064758f, -0.16350771f, 0.00144346f, -0.00713097f, 
    -0.07696154f, -0.21203998f, 0.00254414f, 0.08965666f, -0.05105026f, -0.27125442f, -0.32326677f, -0.21421936f, 
    0.04067812f, 0.20017107f, -0.14979009f, -0.04418751f, -0.06820983f, 0.06921045f, -0.03285567f, -0.09405134f, 
    0.10947374f, -0.11907047f, -0.06227941f, -0.03088132f, -0.11084264f, -0.03580689f, -0.20220950f, 0.05767264f, 
    -0.44663876f, 0.23320420f, -0.06821400f, -0.05287943f, 0.02730863f, 0.05761717f, 0.11429164f, 0.00865572f, 
    -0.14778779f, -0.06487116f, -0.11572731f, 0.05494913f, -0.02008067f, -0.05387515f, 0.00987049f, -0.02281319f, 
    0.06866002f, -0.35489997f, 0.06524932f, 0.04158748f, -0.03648350f, -0.08175419f, 0.04331213f, -0.12859993f, 
    0.04127437f, -0.09959458f, -0.06268877f, -0.18853396f, 0.03081484f, 0.17429304f, 0.07155098f, 0.06872557f, 
    -0.03422869f, 0.03192331f, 0.04206457f, -0.05405347f, -0.14522329f, -0.50131249f, -0.06312137f, 0.15320398f, 
    0.02615573f, 0.17025037f, -0.11388586f, -0.08588691f, -0.03050403f, 0.21782398f, 0.07608970f, 0.05698878f, 
    0.12532544f, 0.02252829f, -0.07979195f, 0.04263997f, 0.13916758f, -0.09763850f, -0.33977813f, -0.16996127f, 
    0.01767155f, -0.00422231f, 0.07888824f, 0.14653142f, -0.12283130f, -0.01448270f, 0.10242915f, -0.17831010f, 
    -0.02432821f, 0.10061238f, 0.03979170f, 0.06652126f, 0.09532093f, 0.08167201f, -0.04119992f, 0.05359982f, 
    -0.08117501f, 0.09442986f, 0.02470301f, -0.01443686f, -0.01618989f, 0.15843220f, 0.13103783f, 0.15998366f, 
    -0.05345193f, 0.02974539f, -0.00606445f, 0.00424922f, 0.01357572f, -0.05618546f, -0.02381937f, 0.02033151f, 
    0.01413396f, 0.03667527f, 0.03835096f, -0.03245080f, -0.04797415f, -0.05601596f, 0.04942907f, 0.05792578f, 
    -0.02067368f, -0.02000407f, 0.02013287f, -0.00686997f, -0.02041472f, -0.05525192f, -0.05459940f, -0.05878028f, 
    0.05002272f, -0.04554804f, 0.00505358f, 0.01186588f, -0.06565240f, 0.02442213f, -0.05669881f, 0.02790498f, 
    -0.02477423f, -0.06302992f, 0.00116177f, 0.03999991f, 0.03843895f, -0.03565704f, 0.03766417f, -0.05566483f, 
    -0.03983793f, 0.02552795f, -0.04514384f, -0.06234704f, -0.01722676f, -0.05821879f, 0.03327972f, -0.02621438f, 
    -0.05762750f, 0.00129531f, -0.02111899f, -0.02832102f, 0.03981738f, -0.04824370f, 0.03408165f, 0.03439770f, 
    -0.05506496f, 0.04698227f, 0.01773132f, 0.03033566f, 0.02747353f, -0.04293101f, -0.04983872f, -0.05605702f, 
    0.04767857f, -0.05500053f, -0.02510865f, -0.00362546f, 0.03920830f, 0.02005738f, 0.01173147f, -0.01747244f, 
    -0.01479127f, -0.03335287f, -0.02563541f, 0.02976245f, 0.04122025f, 0.03536536f, 0.04439576f, -0.05804261f, 
    -0.01850968f, 0.03790949f, 0.00603632f, 0.05495445f, 0.00230175f, 0.01839736f, -0.05022126f, 0.02352520f, 
    0.02535084f, 0.03509011f, -0.01733525f, -0.04667382f, 0.03332837f, -0.05333987f, -0.03897872f, -0.02424664f, 
    0.04067801f, 0.02502619f, -0.02670634f, -0.01069060f, -0.00756524f, -0.06119888f, -0.06276225f, -0.05894486f, 
    0.01515582f, -0.02202151f, 0.00853020f, 0.02081367f, -0.05289978f, -0.04206244f, 0.00214549f, -0.05198751f, 
    -0.03214701f, -0.00312609f, -0.00609352f, -0.01409502f, 0.02082083f, -0.02640199f, 0.03470627f, 0.00683942f, 
    0.04214440f, -0.01192313f, -0.01356072f, 0.01974742f, 0.02515633f, -0.02710533f, -0.04737211f, 0.01453091f, 
    -0.02085906f, 0.04062649f, 0.03432408f, -0.02715558f, 0.05302401f, -0.01988987f, -0.04438012f, -0.04584451f, 
    -0.04339879f, 0.03945548f, -0.00640816f, 0.01174827f, 0.04211316f, -0.01023396f, 0.01391787f, -0.03770138f, 
    -0.01262457f, -0.03215791f, -0.03252158f, -0.02156901f, 0.03405983f, 0.01729048f, -0.04064086f, -0.04610762f, 
    0.03107247f, -0.05003066f, 0.02268175f, -0.02871710f, 0.03885500f, 0.04829504f, -0.01659119f, 0.00035402f, 
    -0.03241661f, 0.02871406f, 0.00837197f, 0.00005668f, -0.03436632f, -0.02604830f, -0.00882189f, 0.02873311f, 
    0.00746628f, 0.03172113f, 0.00968311f, -0.04790229f, -0.05565087f, -0.02812405f, 0.00020466f, -0.05210257f, 
    0.00736873f, 0.01994619f, 0.02382669f, -0.05408359f, -0.04675503f, -0.03032370f, -0.01115606f, -0.06779748f, 
    0.01467428f, 0.01880663f, -0.05069417f, -0.03227375f, -0.04242711f, -0.02532496f, -0.05252683f, -0.04696818f, 
    -0.05682530f, 0.02412540f, -0.02809162f, -0.00349480f, 0.00616874f, -0.03800575f, 0.02440378f, -0.04289203f, 
    0.00119315f, 0.03724151f, -0.05553230f, -0.01587949f, -0.06274085f, -0.01561502f, -0.06315084f, -0.02872896f, 
    0.02242298f, -0.03134710f, 0.00618887f, -0.00523612f, -0.06495302f, -0.06547002f, -0.00033498f, -0.03971846f, 
    0.02951164f, -0.04883888f, -0.05433100f, 0.04066444f, -0.01529635f, 0.04377932f, -0.05811423f, 0.01739308f, 
    -0.04157050f, -0.01835688f, -0.03777871f, 0.02459594f, 0.05093306f, 0.01553549f, 0.05146800f, -0.01806991f, 
    -0.01229360f, 0.00196216f, 0.00244027f, -0.05276776f, -0.05062326f, -0.00784150f, 0.03698591f, -0.02689289f, 
    -0.04630806f, -0.00197492f, 0.04623426f, -0.04907282f, 0.00380220f, -0.02683323f, -0.01687009f, 0.02752492f, 
    0.02895832f, 0.04822524f, -0.03160543f, 0.03721536f, 0.02846855f, -0.00361234f, 0.04614153f, 0.03756453f, 
    -0.04463560f, 0.03510565f, -0.04985041f, 0.04495012f, -0.03484875f, -0.06526132f, 0.02051433f, -0.03268776f, 
    0.04905093f, 0.00266588f, -0.05794204f, -0.05491174f, -0.05729234f, -0.04670625f, 0.01985055f, 0.01637892f, 
    0.02222944f, 0.03873333f, -0.01989158f, 0.00813952f, -0.00064698f, -0.04270458f, 0.04208275f, -0.05591240f, 
    -0.04964656f, 0.00973548f, -0.04283251f, -0.03605329f, -0.04658220f, -0.02506759f, -0.02553698f, -0.01891129f, 
    -0.03479673f, 0.05265639f, 0.01280509f, 0.04626988f, -0.04519660f, -0.02032945f, -0.05335976f, -0.04805441f, 
    0.02557638f, -0.03098201f, 0.00357539f, -0.00255697f, 0.00669170f, 0.02571848f, -0.03557859f, -0.02656035f, 
    -0.05312115f, 0.01631415f, -0.01110543f, 0.03451310f, -0.03047169f, 0.00507615f, -0.01969889f, -0.02388115f, 
    -0.04243217f, 0.00595853f, -0.03466845f, -0.04279795f, 0.03423792f, -0.03693094f, 0.00592373f, 0.03766693f, 
    0.00058449f, 0.02367998f, -0.03562206f, -0.00996119f, 0.05699652f, -0.02179981f, -0.05813237f, 0.03506964f, 
    -0.02466184f, -0.03080296f, 0.02061665f, -0.04527780f, -0.00275682f, -0.01280739f, 0.03665444f, -0.00925476f, 
    0.00989524f, -0.01589315f, -0.03028087f, 0.04721715f, -0.01041692f, 0.05772555f, 0.03819738f, -0.02935477f, 
    -0.05721794f, -0.01303918f, 0.04885806f, 0.01926372f, -0.04559204f, -0.00692551f, -0.04230300f, -0.02212482f, 
    -0.03439582f, 0.02024325f, -0.02294045f, -0.05759292f, -0.05836024f, -0.03123741f, -0.00597654f, -0.00109177f, 
    -0.01900231f, -0.04558726f, -0.02273761f, -0.02365520f, 0.05340812f, -0.03731568f, 0.01928021f, -0.04705202f, 
    0.00132494f, -0.03297496f, -0.02038511f, 0.06018278f, -0.05653718f, -0.03364735f, 0.02821834f, -0.01135601f, 
    -0.03385542f, -0.04003036f, -0.02370756f, -0.06233485f, 0.01971482f, -0.03054309f, 0.04602833f, -0.02273341f, 
    -0.05062971f, 0.00930636f, 0.02992801f, 0.03935869f, -0.05162954f, -0.01418320f, 0.00243181f, -0.01632357f, 
    -0.05541962f, 0.04078432f, 0.03248341f, -0.01862475f, -0.00525399f, -0.05255048f, 0.00313517f, -0.01424169f, 
    -0.00159466f, -0.01648982f, 0.03441773f, -0.05385958f, -0.05596672f, 0.05003569f, -0.01321878f, -0.05275131f, 
    0.01939354f, -0.02445906f, 0.02687047f, 0.05043199f, 0.00479321f, -0.02564215f, -0.01838711f, -0.05125361f, 
    -0.03152075f, -0.00260680f, -0.05899920f, 0.00598212f, -0.00831600f, -0.02400318f, 0.05133796f, -0.02009324f, 
    0.03337453f, 0.02516451f, -0.00171490f, -0.03370839f, -0.02057939f, -0.00548714f, -0.06102784f, -0.04870414f, 
    -0.00515054f, -0.03859190f, 0.04273672f, 0.01858972f, -0.05090353f, 0.05390342f, 0.01536923f, -0.03832892f, 
    -0.00696094f, -0.01737179f, -0.03258666f, -0.03993444f, 0.00298020f, 0.02554082f, 0.03455727f, -0.02395836f, 
    -0.00904029f, -0.00049163f, 0.01528683f, 0.02095322f, 0.04723145f, -0.06120247f, -0.05858090f, -0.02856970f, 
    -0.00247042f, 0.05879253f, -0.00729405f, -0.02408604f, 0.00324458f, -0.01103758f, -0.03346096f, -0.04368609f, 
    0.00344011f, 0.01938391f, 0.04367048f, -0.06123851f, -0.00169764f, 0.02812538f, -0.03348224f, -0.02344352f, 
    -0.01979663f, -0.02015948f, -0.01716993f, 0.04365010f, 0.00322052f, -0.03487639f, 0.02898516f, -0.05504395f, 
    0.04126830f, 0.01564648f, -0.00164285f, -0.01094377f, -0.02123209f, 0.02322662f, -0.00301148f, 0.00074841f, 
    -0.02574567f, -0.03044609f, 0.00577476f, -0.03671701f, -0.01547296f, 0.00693601f, -0.03773125f, -0.01601861f, 
    -0.04880576f, -0.01852306f, -0.05194335f, 0.02533317f, 0.05993534f, -0.02468234f, -0.02782973f, -0.01681074f, 
    -0.05423772f, -0.06669148f, -0.04099833f, 0.03894856f, 0.03195127f, 0.04492135f, -0.02836745f, -0.03669596f, 
    -0.05741994f, 0.03108349f, -0.04403300f, 0.05456106f, -0.00568831f, 0.00545792f, 0.03772931f, 0.04275733f, 
    -0.02552375f, -0.02352392f, -0.03287568f, 0.03115346f, -0.02183812f, 0.03507404f, -0.05807060f, 0.05431497f, 
    0.04324866f, -0.01128186f, -0.03243749f, -0.03214438f, -0.04785018f, 0.02307502f, -0.00806435f, -0.02081486f, 
    -0.03941173f, -0.01456810f, -0.01596672f, -0.03932750f, -0.01982730f, 0.04451752f, 0.01821809f, -0.04210632f, 
    -0.03840470f, 0.01103806f, -0.04999904f, -0.05012333f, 0.05070533f, -0.04496536f, 0.04101007f, 0.05119384f, 
    0.03003075f, 0.02127775f, -0.03128938f, -0.03709194f, 0.03935058f, -0.03676825f, -0.04559778f, -0.03669002f, 
    0.03777169f, 0.04123956f, -0.02593743f, -0.01751762f, -0.04551313f, -0.01109176f, 0.04251043f, 0.01240931f, 
    0.03574279f, 0.05671961f, -0.06032991f, 0.01927765f, 0.00746073f, 0.00569954f, -0.00995544f, -0.06531713f, 
    0.16453807f, 0.12998503f, -0.10612625f, 0.06694194f, 0.02289228f, 0.07875201f, 0.19010970f, -0.11389288f, 
    -0.02504057f, 0.05468348f, -0.12708810f, -0.03429480f, 0.11837661f, 0.14721757f, -0.07396311f, 0.09062929f, 
    0.10400338f, 0.02913800f, 0.13067222f, -0.22591598f, 0.03971279f, 0.13891037f, 0.02604206f, -0.16299862f, 
    0.08762323f, -0.00030546f, 0.08555602f, -0.16145691f, -0.19119720f, 0.00091888f, -0.13223660f, 0.10214722f, 
    -0.12289207f, 0.02260798f, -0.04988424f, -0.05521299f, 0.20204812f, -0.30138451f, 0.01393471f, -0.01170717f, 
    0.05044802f, -0.06768031f, 0.14189069f, -0.04028301f, 0.05691525f, 0.06985583f, -0.14369738f, -0.00533908f, 
    -0.06547260f, 0.02237376f, -0.15703306f, 0.10890656f, -0.16531423f, 0.03020356f, 0.07925148f, -0.03668668f, 
    0.02805854f, 0.09001722f, 0.10082318f, -0.04737069f, -0.03742937f, 0.02832938f, -0.01206877f, -0.12262234f, 
    -0.06202675f, -0.28275818f, 0.07844493f, 0.03986475f, 0.21626720f, 0.04061148f, 0.06218110f, -0.09489385f, 
    -0.07596601f, -0.07049470f, -0.05779972f, 0.07181983f, -0.12239427f, -0.04490591f, 0.11648099f, 0.06475795f, 
    -0.05242240f, -0.23296444f, -0.09796508f, -0.01084403f, 0.09041248f, 0.13491917f, 0.02579660f, -0.09565893f, 
    -0.00878292f, -0.00269881f, 0.12088423f, -0.10930334f, -0.26571631f, 0.07041817f, -0.07830516f, -0.00779456f, 
    -0.06075033f, -0.03650969f, 0.07922800f, -0.08809796f, 0.18954231f, 0.04625041f, 0.11425009f, 0.03128092f, 
    0.10248140f, -0.03041244f, -0.04234562f, 0.09387170f, 0.04614028f, -0.07142310f, 0.12532255f, -0.02552042f, 
    -0.02909290f, -0.10249864f, 0.07683619f, -0.12260334f, 0.04287314f, 0.23828329f, 0.15057847f, -0.11168231f, 
    -0.03562206f, -0.02397554f, -0.03568487f, -0.18650386f, 0.19040309f, 0.00735806f, 0.05247885f, -0.19602016f, 
    0.02263281f, -0.11162408f, 0.12870891f, -0.11187548f, 0.07493695f, 0.05379520f, -0.12984771f, 0.20580104f, 
    -0.22592036f, -0.30328196f, -0.04502377f, 0.06434550f, 0.04811518f, -0.00877328f, 0.07808609f, -0.07409562f, 
    0.22015791f, -0.01966277f, 0.10013027f, -0.04290526f, -0.00029325f, 0.16759068f, 0.10442265f, -0.06683843f, 
    -0.04865500f, -0.16388662f, -0.05061295f, -0.08599246f, -0.08613497f, 0.02525912f, 0.13120113f, -0.10368147f, 
    -0.02027271f, -0.11044037f, 0.01496136f, -0.09528477f, 0.15155883f, 0.01192346f, 0.01949385f, -0.05953659f, 
    0.06071355f, -0.00453096f, 0.07929569f, -0.26710823f, -0.41238829f, 0.04341925f, 0.07083303f, 0.08948357f, 
    -0.12365834f, 0.09587063f, -0.02210168f, 0.01258264f, 0.12443333f, -0.07742167f, -0.11558381f, 0.11098437f, 
    -0.00317163f, 0.07006069f, -0.00454983f, 0.10403333f, 0.10177740f, 0.04015709f, 0.17298116f, 0.14275897f, 
    -0.01367666f, -0.16115198f, -0.14129961f, 0.01910882f, 0.03186646f, 0.00418512f, 0.13048513f, 0.01501187f, 
    0.00361790f, 0.05045001f, 0.10962277f, 0.01530833f, 0.07132822f, 0.03554695f, 0.20000269f, 0.09639637f, 
    -0.32387954f, -0.01116921f, -0.16763286f, 0.04873957f, 0.10203588f, 0.26755622f, 0.07271275f, -0.06955269f, 
    -0.09983842f, 0.03384503f, -0.06231382f, 0.20098373f, -0.03873435f, 0.04548823f, -0.06030453f, 0.03180776f, 
    0.06831291f, -0.00342902f, 0.04863880f, -0.03717879f, 0.12370336f, 0.04948790f, -0.09252506f, -0.00522221f, 
    -0.06856180f, 0.11993200f, -0.09621343f, 0.01454565f, 0.12442724f, -0.24439074f, -0.01715663f, 0.02105340f, 
    0.07963987f, -0.08289240f, -0.05735154f, 0.04585536f, 0.14618433f, -0.08528969f, 0.05555523f, -0.13179000f, 
    0.08548349f, -0.00545747f, 0.09164698f, -0.04530000f, -0.18301757f, -0.25639704f, -0.13892345f, 0.02631920f, 
    -0.13656789f, 0.07353663f, -0.07581040f, -0.14740856f, 0.05489580f, -0.12793405f, 0.22021610f, -0.04911429f, 
    -0.00469255f, -0.03761572f, 0.08053558f, -0.05292708f, 0.02250204f, 0.11635193f, 0.06441588f, 0.00161116f, 
    0.04345580f, 0.04582375f, -0.02387062f, -0.07336956f, 0.09799456f, -0.03384482f, -0.03475687f, -0.27463868f, 
    -0.07587779f, 0.00387105f, -0.05084257f, 0.00026287f, 0.18892694f, -0.00513470f, 0.14649661f, -0.06124068f, 
    -0.02571965f, -0.03357048f, -0.05239303f, 0.01735484f, 0.00339534f, -0.05658980f, -0.00850651f, -0.01583762f, 
    -0.00229172f, -0.05372817f, -0.02205638f, -0.06207601f, 0.05288437f, -0.01786665f, 0.02583103f, -0.00049894f, 
    -0.05643199f, -0.05619938f, 0.03926961f, -0.04750955f, 0.00668335f, 0.01914634f, -0.05213604f, 0.06091899f, 
    -0.01160790f, 0.02466108f, -0.05936947f, -0.06204738f, -0.04751567f, 0.00231594f, -0.06235138f, -0.03183607f, 
    0.00357281f, 0.04981833f, 0.01661549f, 0.00060404f, -0.02306241f, 0.02657003f, 0.02053789f, -0.04702282f, 
    -0.04202083f, -0.04766461f, -0.02455899f, 0.02624907f, 0.01944254f, 0.00877906f, -0.01889051f, -0.04530529f, 
    0.03551868f, -0.05939315f, 0.00755662f, -0.05212829f, -0.02878959f, -0.01664117f, -0.04667808f, 0.01441946f, 
    -0.01461154f, 0.02451604f, -0.05123071f, 0.04223129f, -0.01136855f, 0.00268352f, -0.04635455f, -0.04556382f, 
    -0.06171268f, -0.04918116f, -0.05038412f, -0.00090957f, -0.04966968f, -0.01117471f, -0.00066465f, -0.01063649f, 
    0.02154883f, -0.03204319f, 0.03077832f, -0.05765658f, -0.04502875f, -0.03164314f, -0.00878804f, 0.03392438f, 
    0.04046252f, -0.04078757f, -0.02540487f, 0.03126092f, 0.02103193f, 0.00923895f, 0.01178965f, 0.01709351f, 
    0.04466762f, 0.05239253f, -0.00170251f, -0.05343734f, 0.00079471f, -0.04118654f, -0.05622387f, -0.05612782f, 
    0.01184801f, -0.04890297f, -0.02193577f, -0.05774831f, 0.00130371f, -0.00572812f, -0.02112521f, 0.00770745f, 
    0.01783760f, 0.03535617f, 0.01108738f, -0.04284064f, -0.00048375f, 0.04680975f, -0.04497688f, -0.00544052f, 
    0.01403429f, 0.02148329f, -0.06189436f, 0.00174987f, 0.03410901f, -0.03182353f, 0.00437064f, 0.02701016f, 
    -0.02888441f, -0.06384754f, -0.02239870f, -0.03124638f, 0.04281615f, -0.03586584f, 0.04828764f, 0.03479488f, 
    0.01850628f, -0.05133129f, -0.06178923f, -0.04111577f, -0.03193675f, -0.00613892f, -0.01684352f, 0.04569844f, 
    0.02010280f, 0.02129467f, 0.00041866f, 0.01773739f, -0.01087072f, 0.03253847f, 0.01380512f, -0.02321657f, 
    -0.06088876f, 0.02004224f, 0.00537909f, 0.05171114f, 0.01132045f, 0.02763493f, -0.05508721f, -0.01752302f, 
    0.00599506f, -0.04313435f, -0.04812604f, 0.02991800f, 0.00839519f, 0.03215950f, 0.02874065f, 0.03447030f, 
    0.03007503f, 0.01373628f, -0.03634281f, 0.00250508f, 0.05274131f, 0.00708584f, 0.02965969f, 0.03370968f, 
    -0.06317081f, -0.03651796f, 0.04044825f, -0.00549828f, -0.02002300f, 0.01054537f, -0.05192614f, 0.04589304f, 
    0.02542823f, -0.03324395f, -0.05434214f, -0.02521478f, -0.00519289f, 0.01691552f, -0.03199304f, -0.06639590f, 
    -0.00584088f, 0.06510425f, -0.04425224f, 0.03154761f, -0.02217869f, -0.06384158f, 0.00798982f, 0.01542123f, 
    0.02803635f, -0.01796108f, 0.03945244f, -0.05505315f, -0.02284386f, -0.06501654f, -0.04340048f, 0.04230575f, 
    -0.05821879f, -0.01947278f, -0.04924393f, -0.03717859f, 0.00963717f, 0.03147442f, 0.00981740f, 0.01333555f, 
    0.01485005f, -0.00417917f, 0.00189478f, -0.05619757f, -0.06261357f, 0.02799156f, 0.03770088f, -0.05397023f, 
    0.02620873f, -0.01753714f, -0.01612359f, -0.03323428f, 0.04290764f, -0.04427996f, 0.00983335f, -0.00998346f, 
    -0.04565619f, 0.00459276f, -0.01817572f, 0.02173391f, 0.04542157f, -0.03788115f, -0.03817183f, -0.01996414f, 
    -0.01862615f, -0.01898913f, -0.04545787f, -0.03336786f, -0.00073699f, -0.06016675f, -0.02172045f, -0.00961254f, 
    -0.03435384f, 0.04230523f, 0.03149866f, -0.04670265f, -0.00216120f, -0.01238187f, 0.04686860f, -0.06580567f, 
    -0.00833202f, 0.00580077f, -0.05719565f, 0.02247331f, -0.05702507f, -0.00318077f, -0.05269714f, 0.00222905f, 
    0.04834140f, 0.04924146f, 0.02970738f, -0.05102254f, -0.03969141f, 0.05018982f, 0.01539495f, -0.00022545f, 
    -0.06176500f, 0.02644928f, 0.04673224f, -0.02281825f, -0.01627933f, -0.06139908f, 0.04706031f, 0.04818041f, 
    -0.01575429f, 0.01518067f, -0.03800120f, -0.04612467f, -0.00910506f, -0.03826614f, 0.01745746f, -0.00172968f, 
    0.01463506f, 0.03489368f, 0.01093151f, 0.02738683f, -0.05890094f, -0.04947451f, -0.01182668f, -0.05306517f, 
    0.00375458f, 0.08248550f, 0.02849370f, -0.27936709f, 0.08568087f, -0.08897600f, 0.19853388f, -0.02183864f, 
    0.19483027f, -0.05868792f, 0.02147682f, 0.17472948f, 0.08495056f, 0.12804013f, 0.06131966f, 0.04614791f, 
    -0.03281808f, 0.08019366f, 0.09914155f, -0.06987673f, 0.13565281f, -0.08744303f, -0.04129568f, 0.00915285f, 
    0.11248507f, -0.14907119f, -0.08720293f, 0.17131549f, 0.06884749f, -0.09823934f, -0.11184707f, -0.04758782f, 
    0.01576471f, -0.05257551f, 0.06147827f, 0.08605158f, -0.06271204f, 0.00998760f, 0.06352562f, -0.07462214f, 
    -0.03076803f, -0.15093747f, 0.09040496f, 0.12701289f, 0.05698889f, -0.03140902f, 0.05687192f, -0.07572977f, 
    0.12899506f, 0.05605232f, -0.06371171f, 0.04195096f, 0.00153631f, -0.14915594f, -0.00636174f, 0.07561006f, 
    0.05577065f, 0.03796229f, 0.03276599f, 0.07620821f, 0.03702183f, -0.07498303f, -0.05283252f, 0.00904437f, 
    0.05229704f, -0.18410571f, -0.07516931f, -0.00097275f, 0.26590458f, 0.23648249f, 0.15152566f, -0.38831317f, 
    -0.10728842f, -0.03804888f, -0.11872454f, -0.09756950f, 0.09305278f, 0.01392329f, -0.09190857f, 0.02574691f, 
    -0.18468529f, 0.00445242f, -0.07692963f, -0.30378613f, 0.04123016f, 0.12991306f, 0.13087785f, 0.18299896f, 
    -0.07634173f, -0.19180527f, 0.03750762f, -0.02863157f, 0.06379305f, -0.05952617f, 0.19880311f, 0.01166451f, 
    0.03482853f, 0.05237269f, 0.03409800f, -0.09274572f, 0.15077466f, 0.20467813f, 0.19807388f, -0.02793161f, 
    0.17011963f, 0.10552087f, -0.02352924f, -0.07669470f, -0.00909624f, 0.04383375f, -0.07120913f, 0.08446810f, 
    -0.00258081f, -0.02254311f, 0.05435460f, 0.10512985f, -0.00919782f, -0.01836241f, 0.18339776f, 0.01144243f, 
    0.26089945f, 0.02017076f, 0.01839308f, 0.11483587f, 0.07782156f, -0.18983617f, -0.08742669f, -0.11368826f, 
    -0.17561059f, 0.05928167f, 0.17203632f, -0.02147572f, -0.01234953f, -0.10996871f, -0.08888955f, 0.30247244f, 
    0.02772839f, -0.09194099f, -0.04518595f, -0.03943072f, -0.02901934f, 0.05019486f, 0.10074536f, 0.04226126f, 
    0.33835030f, 0.15581824f, 0.22418638f, -0.16096434f, 0.05055432f, 0.09004331f, 0.01449297f, -0.04264941f, 
    -0.04687161f, 0.14499491f, 0.10892961f, -0.13549294f, 0.29487333f, 0.03452922f, 0.06011409f, 0.03341108f, 
    0.15281484f, 0.01792374f, 0.14629970f, 0.05127434f, -0.03488408f, -0.11933740f, 0.01936283f, -0.06910087f, 
    0.01554747f, 0.16930898f, -0.09219194f, 0.06217632f, 0.06506201f, -0.02630948f, 0.05645001f, 0.18812332f, 
    0.00986667f, 0.00217526f, -0.05450515f, -0.09689046f, -0.19102754f, -0.11073474f, 0.00121070f, 0.26559916f, 
    0.04302972f, -0.04458308f, 0.08325219f, -0.18793043f, -0.00897155f, -0.05840991f, 0.12504041f, 0.17408785f, 
    0.09481192f, -0.10122333f, 0.00691969f, -0.01889282f, 0.08249582f, 0.04175366f, 0.05980799f, 0.10611020f, 
    0.16765983f, 0.12105602f, 0.12962306f, -0.01713351f, -0.14457130f, 0.05513346f, -0.01011874f, 0.11276882f, 
    -0.09508479f, -0.21911587f, 0.02049151f, 0.12145692f, 0.02019224f, 0.11328366f, -0.13714829f, -0.25364986f, 
    0.00872037f, 0.04861209f, 0.14991467f, 0.09852558f, 0.10058599f, -0.00311142f, 0.05804382f, 0.00755828f, 
    -0.10516209f, 0.02097508f, 0.20811749f, 0.17715827f, -0.12137271f, -0.00269540f, -0.15694134f, -0.12066756f, 
    -0.00996105f, 0.06947797f, 0.07755414f, 0.06356312f, -0.09665036f, -0.18148670f, -0.01650279f, -0.22041588f, 
    0.06588759f, -0.00758332f, -0.05339281f, -0.09717166f, 0.30939838f, -0.06795345f, 0.00617132f, 0.02694089f, 
    -0.08388066f, -0.14017506f, 0.09236250f, 0.04386383f, 0.04183354f, 0.03668991f, -0.22936241f, -0.13866344f, 
    0.10314256f, -0.06722128f, -0.05416121f, -0.07688927f, -0.20472915f, -0.19394121f, 0.17727466f, 0.21909222f, 
    0.09888136f, -0.22732252f, 0.11723813f, -0.05940615f, -0.02181523f, 0.15760165f, 0.08160365f, 0.03476766f, 
    0.15288049f, -0.12278642f, -0.04708254f, -0.05404589f, 0.04314032f, 0.08871587f, 0.04921753f, 0.09007531f, 
    0.17963956f, -0.07453168f, 0.07876431f, 0.05523209f, 0.02129684f, 0.00945899f, 0.20520806f, -0.17899451f, 
    0.03185082f, -0.04019728f, 0.00601274f, 0.02540994f, -0.05833124f, -0.04222899f, -0.02122142f, 0.02000874f, 
    0.03101260f, 0.02103026f, 0.03880989f, 0.01655475f, 0.01104142f, -0.02379879f, 0.05938738f, -0.05942972f, 
    -0.06098068f, 0.01132930f, 0.04615361f, -0.03182970f, -0.03812810f, 0.00930673f, 0.01524194f, 0.04317263f, 
    -0.00635865f, 0.02764321f, -0.03490671f, -0.00081311f, -0.04153601f, 0.04655458f, 0.04284903f, -0.01909121f, 
    -0.01982979f, 0.04451942f, -0.05723160f, -0.02652185f, -0.06090881f, -0.00775331f, -0.02812785f, -0.00069146f, 
    -0.03670850f, -0.00930886f, -0.01645061f, 0.03324186f, -0.04115501f, 0.03269758f, 0.03305003f, -0.01517922f, 
    0.03692061f, -0.06580669f, -0.01473713f, 0.01908652f, 0.02570645f, -0.03068166f, 0.05235115f, 0.04689788f, 
    -0.05461174f, -0.00855866f, -0.02210584f, -0.03362031f, -0.00717603f, 0.02275024f, 0.00395959f, -0.03427649f, 
    -0.02744191f, 0.03310555f, -0.02093793f, 0.03931398f, 0.00881520f, -0.05581619f, 0.05330294f, 0.02619643f, 
    -0.05644321f, -0.04193792f, -0.05266080f, -0.05749758f, -0.01481597f, 0.02218624f, 0.01451425f, 0.03217917f, 
    -0.04274471f, -0.05232087f, -0.06583321f, -0.03772994f, 0.02879686f, -0.05579519f, 0.00134273f, -0.06860229f, 
    -0.02524787f, -0.05425652f, 0.01053615f, -0.03853942f, 0.04172101f, 0.05519630f, 0.05458118f, 0.03113025f, 
    -0.06289914f, -0.05384593f, -0.06541505f, -0.00291617f, 0.03907249f, 0.01398189f, 0.00702186f, -0.02806335f, 
    -0.03039402f, -0.00851412f, -0.04269107f, -0.06091753f, -0.03818128f, -0.04886301f, 0.02736304f, -0.03845053f, 
    -0.04991962f, 0.05535706f, -0.01819841f, -0.04903101f, -0.05353434f, 0.05205013f, -0.02355799f, 0.02615026f, 
    0.00353918f, -0.00447480f, 0.03349657f, -0.03826946f, 0.05210687f, -0.00536772f, 0.00612893f, -0.02002718f, 
    0.01991201f, 0.03112804f, -0.04207016f, -0.05122849f, -0.00080209f, -0.06244113f, 0.02285205f, -0.00629472f, 
    -0.01422089f, 0.02030927f, -0.03565732f, -0.04815624f, -0.01325218f, -0.03591039f, 0.04915176f, -0.04280604f, 
    0.04584868f, -0.01557081f, 0.00486722f, -0.01658986f, 0.05154812f, -0.01174710f, 0.01603870f, 0.00195692f, 
    0.02284154f, 0.02881417f, -0.00795820f, 0.02094998f, 0.00070660f, -0.06261177f, 0.04870286f, -0.04196300f, 
    0.00238898f, -0.03814131f, 0.02369733f, -0.01074089f, -0.04757297f, 0.00157050f, -0.04396091f, -0.03648668f, 
    -0.02006762f, -0.05477258f, 0.00605069f, -0.04028267f, -0.00737833f, -0.00833969f, -0.03386258f, -0.00655877f, 
    -0.03773306f, -0.04957501f, 0.03129690f, 0.01449376f, 0.04166957f, 0.01649808f, 0.00894789f, -0.02388762f, 
    -0.04611407f, 0.01167438f, 0.01434490f, 0.02512958f, 0.04401457f, 0.03255307f, -0.00079709f, -0.05473263f, 
    0.01768918f, -0.04499618f, 0.01847068f, -0.03116219f, 0.01000457f, 0.05270851f, 0.02375454f, 0.01976895f, 
    0.02541590f, 0.03386730f, -0.04749238f, -0.01465598f, 0.05051432f, -0.00276420f, 0.02630251f, 0.00309797f, 
    0.04709775f, -0.04607898f, -0.05527109f, -0.02381537f, -0.02245049f, 0.05014768f, -0.00699080f, -0.01720770f, 
    -0.04266367f, -0.01921963f, -0.05313025f, 0.02599639f, 0.02593136f, -0.03576886f, 0.02312152f, 0.03457326f, 
    -0.04679099f, -0.03833026f, 0.05302903f, 0.02802559f, -0.03448017f, 0.04262866f, -0.02136373f, -0.01346157f, 
    0.05001907f, 0.01323116f, -0.00331534f, 0.00371570f, -0.02071413f, -0.05584640f, 0.04804441f, 0.05090927f, 
    -0.04706079f, -0.03596715f, -0.00421796f, -0.05584930f, -0.02238043f, 0.03664406f, -0.02008064f, -0.02040789f, 
    -0.04676261f, -0.03380923f, -0.03250634f, -0.04255921f, -0.06245873f, 0.03476013f, 0.01272474f, -0.05166649f, 
    -0.05053388f, 0.01294328f, -0.01315635f, -0.04531953f, 0.04499618f, -0.03507988f, -0.04282387f, 0.03874466f, 
    -0.02979329f, -0.00032757f, -0.04554563f, 0.00910828f, 0.01315686f, -0.04135788f, 0.03049690f, -0.02885000f, 
    -0.06182219f, 0.01028514f, 0.02637241f, -0.01151113f, 0.01571700f, 0.03750726f, -0.05961416f, 0.01558799f, 
    -0.03134058f, 0.00186052f, -0.00527112f, 0.05275399f, 0.03955558f, -0.03864325f, 0.00888812f, -0.03202629f, 
    0.21989082f, 0.14284042f, 0.10445540f, -0.04753521f, 0.07157015f, 0.00009305f, 0.03268831f, -0.01308383f, 
    -0.02305953f, 0.05262783f, 0.20052689f, 0.06451575f, -0.09970646f, 0.12077565f, -0.03834030f, -0.08131742f, 
    0.03666287f, 0.01247913f, 0.12011354f, 0.01888961f, -0.14382786f, 0.23859540f, -0.12231990f, -0.11037990f, 
    -0.01105654f, 0.20079818f, -0.01024243f, -0.10482445f, -0.17912468f, -0.30215266f, 0.00284396f, -0.01252760f, 
    -0.01200545f, 0.02907125f, 0.00663574f, 0.04249436f, 0.23047850f, 0.05557641f, 0.03863935f, 0.02484910f, 
    0.07423695f, 0.07828074f, -0.12155715f, 0.09401120f, 0.06805348f, 0.01106038f, 0.13725021f, -0.26578367f, 
    -0.07887288f, 0.05293939f, 0.06441559f, -0.00313258f, 0.12010089f, 0.11403573f, -0.01084052f, 0.08760402f, 
    0.00293678f, -0.09727992f, -0.03133635f, 0.07317985f, 0.00593971f, -0.04796489f, 0.09182079f, -0.19556932f, 
    -0.17690741f, 0.18168198f, 0.08209147f, 0.01486036f, -0.03744827f, 0.03110878f, -0.19262680f, 0.09468091f, 
    -0.03166999f, 0.03337800f, -0.12207923f, 0.10007478f, -0.04364062f, 0.13983788f, -0.00950994f, -0.03056032f, 
    0.10542185f, -0.33177823f, -0.37194017f, 0.06006580f, 0.17820448f, 0.00785795f, 0.01111941f, 0.08050191f, 
    0.07347235f, 0.03149423f, 0.25860867f, -0.03824948f, -0.21177563f, 0.04055118f, 0.01129428f, -0.00247418f, 
    -0.04459979f, -0.06521159f, -0.06013994f, 0.06917945f, 0.09848724f, 0.13871303f, 0.10775235f, 0.01120938f, 
    -0.05918083f, 0.09588143f, 0.00974682f, 0.06966875f, -0.11518086f, 0.28764713f, 0.10485127f, -0.12064215f, 
    -0.12954499f, -0.17548825f, -0.19524936f, -0.02015696f, -0.00893475f, 0.02724278f, 0.06448716f, -0.18505920f, 
    0.00550575f, 0.06041466f, -0.16060466f, 0.02010898f, 0.03348982f, 0.08803474f, -0.18665458f, -0.39621651f, 
    -0.06459327f, -0.07089270f, -0.05798826f, -0.08777910f, 0.07351359f, 0.05236518f, 0.04481840f, 0.04076378f, 
    -0.47411576f, 0.25621703f, 0.10769912f, 0.03283680f, -0.12418575f, -0.04147311f, -0.08539045f, -0.02757206f, 
    0.04285043f, -0.02909267f, -0.06905813f, -0.08983481f, 0.08067346f, -0.09412899f, 0.06249984f, 0.08500590f, 
    -0.03622546f, -0.21780446f, -0.21071163f, -0.19232035f, -0.18915565f, -0.01069536f, 0.08295303f, 0.11901900f, 
    0.08617625f, 0.08891184f, 0.09678493f, 0.10764930f, 0.25051114f, 0.17644687f, 0.11590671f, 0.05186867f, 
    -0.01332410f, -0.15595987f, -0.02468869f, -0.03147083f, -0.49045891f, 0.02697308f, 0.16202411f, -0.03003154f, 
    -0.09531333f, 0.00396069f, -0.23258899f, -0.13066828f, 0.35859394f, 0.38960984f, 0.01274484f, 0.06150531f, 
    -0.09757850f, -0.19561610f, -0.07193559f, 0.12428658f, 0.03037495f, -0.00758717f, 0.02474993f, 0.10719301f, 
    -0.07956349f, -0.16097732f, 0.12334451f, 0.01568073f, 0.06231452f, -0.17824119f, 0.09715914f, 0.15704447f, 
    -0.02983185f, 0.10086891f, -0.00445696f, 0.09243039f, 0.08226781f, 0.09494155f, -0.08686069f, -0.08694631f, 
    0.05334573f, 0.04729563f, 0.08751187f, -0.21372029f, -0.14915128f, -0.06540275f, 0.10934878f, 0.02636698f, 
    0.20423527f, 0.12498227f, 0.08472133f, -0.14096059f, -0.17769140f, -0.16279399f, 0.05393974f, 0.21921200f, 
    -0.08479370f, 0.03903961f, 0.01167690f, -0.00615492f, -0.21794003f, 0.09316111f, -0.11382992f, 0.03586087f, 
    0.10551369f, -0.07685804f, 0.00708304f, 0.12725751f, 0.13014428f, -0.02975187f, -0.14699726f, -0.04375922f, 
    0.12554103f, 0.02067465f, 0.00762535f, -0.04271276f, -0.11279353f, -0.07161602f, 0.06677831f, 0.09849743f, 
    -0.07104047f, 0.03576612f, -0.10208832f, -0.08504678f, -0.31202582f, -0.49602970f, 0.11666469f, 0.11906309f, 
    0.13095331f, 0.18283205f, 0.00404712f, -0.12722661f, -0.03444593f, -0.46019346f, -0.04755836f, 0.00257864f, 
    -0.14890487f, 0.15061307f, -0.02350582f, -0.02457266f, 0.06647744f, 0.07178621f, 0.28458548f, 0.31294292f, 
    -0.00916076f, 0.15409510f, -0.07254060f, 0.11223906f, 0.08215042f, -0.21309301f, -0.09719816f, -0.27805769f, 
    -0.57894939f, -0.00605914f, 0.16203241f, 0.01254008f, 0.15012001f, -0.06523830f, -0.01032428f, -0.07529496f, 
    -0.09030429f, -0.16954422f, -0.03840768f, 0.06554680f, 0.09822444f, 0.08378866f, -0.08223019f, -0.00607788f, 
    -0.04885896f, -0.06682332f, 0.19476469f, -0.34993434f, 0.07974062f, 0.04669947f, -0.00890334f, 0.05568881f, 
    0.00779112f, -0.06943446f, -0.10772026f, 0.07551539f, 0.09919108f, 0.01977869f, -0.07124536f, 0.02682355f, 
    -0.01727799f, 0.06811723f, -0.04771516f, 0.07192046f, -0.09900396f, 0.06002007f, 0.11814965f, 0.03091243f, 
    0.04936408f, -0.22855966f, 0.05222824f, -0.06612304f, -0.08801636f, -0.15912774f, 0.01527709f, -0.11210069f, 
    0.15227535f, -0.08137322f, -0.00979375f, 0.04476038f, 0.08921315f, -0.16270058f, 0.06548652f, -0.25809214f, 
    -0.06188702f, -0.05416881f, -0.10528001f, 0.00772364f, -0.02983326f, -0.05690553f, -0.33815715f, 0.21145298f, 
    -0.16700475f, 0.09211693f, 0.02546065f, 0.06780883f, 0.10364291f, -0.01331483f, 0.08443964f, -0.07395890f, 
    -0.01294872f, 0.00684394f, -0.02393733f, -0.10333274f, 0.05780518f, -0.00489817f, 0.15840581f, 0.21435867f, 
    0.07356068f, 0.17949827f, -0.18120842f, 0.01332487f, 0.02565799f, 0.10891259f, 0.06326459f, 0.01874384f, 
    -0.05297954f, -0.09214816f, 0.02836408f, -0.10530779f, -0.01547084f, 0.04461392f, 0.03275227f, -0.10433278f, 
    -0.12987876f, 0.14233205f, -0.18935725f, -0.25244063f, -0.02587712f, 0.02808576f, 0.03654305f, 0.12559184f, 
    -0.03524062f, 0.00807860f, 0.03492697f, 0.31533992f, 0.30730468f, 0.04897357f, -0.09109614f, -0.14839824f, 
    0.10305071f, 0.01129327f, -0.00374505f, -0.03804248f, -0.27134719f, 0.00205358f, -0.34186536f, -0.03263440f, 
    -0.06671581f, 0.13582726f, 0.01115884f, 0.03935743f, -0.09755071f, 0.04423634f, -0.35738179f, 0.19750650f, 
    -0.10454579f, 0.13664712f, -0.16122510f, -0.23599984f, 0.04859789f, 0.07184975f, 0.02018919f, -0.02326622f, 
    -0.21370572f, 0.05060083f, -0.05450739f, -0.02916898f, -0.01375951f, -0.18853164f, 0.17974690f, 0.12546888f, 
    -0.07344167f, 0.00149954f, 0.06895080f, -0.10179111f, 0.09544303f, 0.04607338f, 0.08154315f, -0.01752187f, 
    -0.01521057f, 0.01038732f, -0.14164461f, 0.24025172f, 0.07833618f, -0.08913887f, 0.15334469f, 0.22486608f, 
    0.04179876f, -0.00119302f, -0.05273856f, 0.28639275f, 0.09262726f, -0.03202043f, -0.10565932f, -0.10175395f, 
    -0.09086809f, 0.01723949f, -0.15021946f, -0.05074653f, 0.15472528f, 0.07415805f, -0.02115799f, -0.02477709f, 
    -0.13488169f, -0.01859545f, 0.09080557f, 0.17512882f, -0.08619335f, -0.11340721f, 0.02849260f, -0.04943715f, 
    0.10050976f, -0.08690611f, -0.12978488f, 0.01619013f, -0.08403467f, 0.37905303f, 0.02778368f, -0.15912566f, 
    0.04809637f, -0.30933225f, 0.03118490f, 0.10792421f, -0.03033928f, -0.30448321f, -0.14778236f, -0.26933175f, 
    -0.05487634f, 0.09939827f, 0.13441573f, 0.24042650f, -0.02904399f, 0.07440189f, 0.10896228f, 0.29379404f, 
    0.04896081f, 0.13563290f, -0.09160034f, -0.05802371f, 0.00983649f, 0.12927118f, -0.10008369f, -0.43313369f, 
    0.02255798f, -0.31035143f, 0.05401098f, -0.06540711f, 0.10778800f, 0.13854942f, 0.05213990f, -0.05064273f, 
    0.42298701f, -0.10107706f, 0.07518230f, -0.10293663f, -0.06576941f, 0.10829395f, 0.04880402f, 0.04725242f, 
    0.10654181f, 0.21906514f, 0.07038567f, -0.13298580f, 0.18674675f, -0.18253240f, -0.07797545f, -0.02915297f, 
    0.03963694f, 0.15128149f, -0.02482629f, -0.25705668f, -0.13131486f, -0.08724532f, 0.11595789f, -0.02148799f, 
    -0.08553778f, -0.02140350f, 0.01286608f, 0.14220902f, 0.03295353f, -0.29998228f, 0.08201039f, -0.05994330f, 
    0.24241827f, -0.06955505f, -0.06156354f, -0.15479811f, -0.06047167f, -0.07824935f, 0.17335860f, -0.01646559f, 
    0.01097965f, 0.00033194f, -0.26581079f, 0.01807153f, 0.00551072f, 0.16936040f, -0.05191837f, -0.07890289f, 
    0.03269505f, 0.14163908f, -0.20340037f, 0.13956521f, 0.06644994f, -0.08604535f, -0.21669787f, 0.17441839f, 
    0.06253833f, 0.09640733f, 0.09969077f, 0.04445520f, 0.00927377f, 0.05521085f, -0.01520176f, 0.03494244f, 
    0.15388240f, -0.16487741f, 0.04480690f, -0.09835308f, 0.10158846f, 0.05694015f, -0.06337276f, 0.02393998f, 
    0.20950565f, 0.09025739f, -0.02213910f, 0.24097306f, 0.02520479f, 0.12084879f, -0.04249164f, -0.10794368f, 
    0.14750145f, 0.01899369f, -0.03420920f, 0.02640356f, -0.08924513f, -0.14321066f, 0.07032895f, -0.03442459f, 
    0.01236848f, -0.01179335f, 0.14130473f, 0.00696397f, -0.08892810f, -0.01108043f, -0.33802721f, 0.00084754f, 
    0.01149413f, -0.01074115f, 0.14630365f, -0.16869879f, 0.22054601f, -0.03144244f, 0.13085222f, 0.08972617f, 
    0.00660541f, -0.07169554f, 0.03173248f, -0.01276371f, 0.22193259f, 0.08810836f, 0.02931967f, 0.03553497f, 
    -0.12661871f, -0.08373918f, 0.06952979f, 0.06321178f, 0.05079207f, 0.24723148f, 0.13929033f, -0.19504468f, 
    -0.02905884f, -0.10885141f, -0.22403058f, -0.07400328f, 0.21290599f, -0.06462468f, 0.12459160f, 0.04016600f, 
    -0.12116659f, -0.13852642f, -0.01338352f, 0.13148634f, 0.15330447f, -0.10022554f, 0.06437444f, -0.12017821f, 
    -0.23942810f, -0.16171560f, -0.07804327f, 0.20208772f, 0.04297891f, -0.12463995f, 0.05528033f, -0.16369982f, 
    -0.00574089f, 0.08271457f, -0.14461599f, 0.09525540f, 0.19977252f, 0.34685791f, 0.09392991f, 0.00864180f, 
    -0.00935948f, 0.00228816f, -0.11995302f, -0.19117376f, 0.27474448f, 0.11501903f, 0.13217285f, -0.10344467f, 
    -0.05043353f, -0.12839203f, 0.09322280f, -0.31609261f, 0.09538981f, -0.05278556f, -0.02108446f, 0.02892567f, 
    -0.09958162f, 0.19114339f, 0.12190367f, 0.08502295f, 0.21877232f, 0.12537819f, -0.15914941f, 0.13240595f, 
    -0.04640149f, 0.24702828f, 0.03089060f, -0.04541437f, 0.02689442f, -0.05885162f, 0.06676255f, 0.05704354f, 
    0.07718258f, -0.17733254f, 0.00998505f, 0.09576336f, 0.11513291f, 0.04065031f, 0.00421208f, -0.18542668f, 
    -0.07980504f, 0.00560614f, -0.05018787f, 0.10279701f, -0.09346950f, 0.12325358f, -0.12416760f, -0.01745454f, 
    -0.03119505f, 0.10505991f, -0.04573951f, -0.12704295f, -0.05332206f, -0.05036346f, -0.29594186f, 0.12634873f, 
    0.17561899f, 0.08006199f, 0.14555046f, 0.14817385f, 0.11311600f, -0.03922602f, -0.07517756f, 0.00823967f, 
    -0.01632596f, -0.35842630f, 0.16469322f, 0.00097266f, 0.13220865f, 0.22608221f, -0.22784102f, 0.15614429f, 
    0.06514655f, -0.27092656f, -0.12917680f, -0.06883458f, -0.05420721f, 0.04554553f, -0.17467715f, 0.13284054f, 
    0.08128913f, -0.08577645f, 0.35045162f, 0.36094788f, 0.12870458f, 0.21032187f, 0.12908475f, -0.02562533f, 
    -0.04394462f, -0.01015169f, 0.09148538f, 0.00288882f, 0.17259549f, -0.12804982f, 0.12404715f, 0.02891257f, 
    -0.08894753f, 0.01654455f, -0.22864386f, -0.08394745f, 0.35824317f, 0.07863624f, -0.04660061f, -0.16252935f, 
    -0.05736420f, -0.04081848f, -0.13681862f, 0.07177654f, -0.28559363f, 0.10913784f, -0.10818377f, -0.02612803f, 
    0.10599454f, 0.12359761f, 0.23764518f, 0.14516899f, 0.06897083f, 0.08389978f, 0.06480560f, -0.15043095f, 
    0.21287762f, 0.01031563f, 0.03583065f, 0.22829801f, -0.09049999f, 0.07237265f, -0.17607003f, -0.02397580f, 
    0.13841282f, -0.02648866f, 0.01397718f, -0.02761335f, -0.10670187f, -0.04504362f, -0.00738451f, -0.12373141f, 
    0.19676381f, 0.11416778f, 0.25389385f, -0.19406177f, -0.03910735f, -0.01201534f, 0.01140595f, 0.03469614f, 
    -0.14188968f, -0.09010142f, -0.27139327f, 0.21531360f, -0.09357322f, 0.07156417f, -0.13023593f, -0.01288485f, 
    0.16117252f, 0.04026971f, 0.19412369f, 0.14243004f, 0.05720158f, -0.08420854f, -0.12276399f, -0.00866369f, 
    0.13255359f, 0.16828862f, 0.06117154f, 0.13434973f, 0.04612815f, -0.08916833f, 0.02734232f, -0.01045938f, 
    0.01431790f, 0.13402155f, -0.04300895f, 0.20118481f, -0.04750681f, -0.19414765f, -0.12827165f, -0.02673534f, 
    0.08935317f, -0.00556619f, -0.14396577f, -0.07538572f, -0.21055393f, -0.13077532f, -0.26266912f, -0.17291574f, 
    -0.10808992f, -0.09970809f, -0.01858836f, -0.04539435f, 0.05382028f, 0.28759599f, 0.17154016f, 0.31359690f, 
    0.14484213f, -0.04021020f, 0.06283312f, 0.08866646f, 0.08263915f, 0.06783513f, 0.22107644f, -0.11792307f, 
    0.00312979f, -0.06529956f, 0.19692881f, 0.04800818f, 0.15525249f, -0.03553662f, -0.23175184f, -0.37688065f, 
    -0.00549403f, 0.01629999f, -0.03974939f, -0.00056718f, 0.08182161f, 0.12042487f, -0.09870176f, -0.07145432f, 
    0.01438013f, -0.18791886f, 0.19883420f, 0.11161878f, 0.05721033f, 0.00463719f, -0.05187050f, -0.02594225f, 
    -0.01462109f, -0.09472875f, 0.02529005f, -0.05790715f, 0.11522968f, 0.15751885f, -0.12358498f, -0.13381210f, 
    0.07049125f, -0.06398986f, 0.07208955f, 0.35723263f, 0.05395638f, -0.12781814f, -0.17941307f, -0.10809317f, 
    0.01189434f, 0.04621040f, 0.03304597f, 0.01743105f, -0.05212019f, 0.00069287f, -0.01790125f, 0.10606097f, 
    0.00367294f, -0.04627475f, -0.03007283f, 0.12853017f, -0.02135105f, 0.10296383f, -0.20574529f, -0.12226644f, 
    0.07723095f, 0.04391090f, -0.06626138f, -0.04063446f, -0.14058851f, -0.00977967f, -0.00766726f, 0.00582941f, 
    0.01674515f, 0.10764321f, 0.08291421f, -0.03372224f, -0.06012194f, 0.07444949f, 0.02056209f, 0.31503135f, 
    -0.05770271f, 0.06382893f, -0.08738782f, -0.14550501f, -0.06662217f, -0.04511879f, 0.09286489f, 0.00456336f, 
    -0.17956853f, -0.20721784f, -0.01281654f, -0.01618845f, 0.05062418f, 0.11995847f, -0.05261661f, -0.12736435f, 
    0.01630717f, -0.15903050f, 0.14036053f, 0.08990201f, 0.03370462f, -0.10727328f, -0.07771106f, -0.09247074f, 
    -0.03987205f, -0.15541975f, -0.07272315f, 0.07798769f, 0.14332581f, 0.18363574f, -0.10830198f, 0.07440493f, 
    0.00239689f, -0.10326919f, 0.05752743f, 0.03224454f, -0.26531771f, 0.19880721f, -0.05450654f, 0.01411200f, 
    0.16780585f, -0.03610774f, -0.00051486f, -0.02056787f, 0.06258098f, -0.13535284f, -0.01104471f, 0.19657107f, 
    0.04630736f, 0.00573334f, -0.06589885f, -0.05726929f, -0.02918132f, -0.07408911f, -0.15207584f, -0.17447683f, 
    0.05909121f, 0.16149889f, 0.03438899f, -0.03339039f, -0.22512276f, -0.05205449f, -0.02008345f, 0.05054041f, 
    -0.14683093f, -0.15863521f, -0.07747631f, -0.26579368f, -0.01049902f, 0.02769080f, -0.09612975f, 0.10774812f, 
    0.26722115f, 0.27396703f, -0.10003472f, -0.07169571f, -0.01009685f, 0.02672362f, 0.22646691f, -0.04333980f, 
    0.18324323f, 0.26008618f, 0.10011689f, 0.23868738f, -0.22882275f, -0.02526348f, -0.19540453f, -0.10628805f, 
    0.19646308f, -0.12654991f, 0.09307840f, -0.17412440f, -0.03544034f, -0.03537777f, 0.03225983f, -0.04033254f, 
    0.07972267f, 0.08131029f, 0.06797098f, 0.12915543f, -0.02797066f, -0.10494431f, -0.00502274f, -0.06234080f, 
    0.08812550f, 0.02638808f, 0.01251304f, 0.25861055f, 0.17472376f, 0.15292735f, -0.38434717f, -0.19637726f, 
    -0.07425801f, 0.04841214f, 0.03856486f, 0.05670446f, 0.02655570f, 0.05675969f, -0.04769821f, 0.15823795f, 
    0.03294096f, -0.11418703f, 0.02603533f, -0.01948612f, -0.25569248f, -0.06332028f, -0.11999533f, 0.10468266f, 
    0.00536937f, 0.09064756f, 0.10312537f, -0.05941081f, 0.00945470f, -0.07684609f, 0.07797537f, -0.01880766f, 
    0.15118374f, 0.05482323f, 0.05042968f, -0.00089365f, 0.11862110f, -0.07218771f, 0.07953904f, -0.03684635f, 
    -0.22965093f, 0.01792670f, -0.18139821f, -0.03853406f, -0.12028360f, 0.17659864f, -0.06292751f, 0.12901157f, 
    0.15386344f, 0.03547477f, 0.18821260f, 0.03906062f, 0.01134393f, 0.01142088f, -0.07127319f, 0.02939092f, 
    0.07946403f, -0.00578444f, 0.08316446f, 0.08486719f, -0.05832991f, 0.08405018f, -0.00831424f, -0.05358011f, 
    0.12088031f, 0.10614349f, 0.23800522f, -0.08926582f, -0.19662935f, -0.06860617f, 0.10985111f, 0.18660891f, 
    -0.08238867f, -0.04479766f, -0.08437169f, -0.13801496f, -0.22359733f, 0.02108225f, -0.10702102f, 0.02159997f, 
    0.24067889f, -0.00358383f, -0.09215362f, -0.07472335f, -0.05222156f, -0.01242210f, -0.06657777f, -0.20868018f, 
    -0.03423405f, -0.10811360f, -0.09844571f, 0.01713324f, -0.23434591f, 0.09572716f, -0.11722476f, -0.10274819f, 
    0.02289093f, 0.06351869f, 0.08965877f, 0.20707379f, -0.11802391f, -0.07817876f, 0.22596911f, 0.07807203f, 
    -0.12453008f, -0.18452564f, 0.12971652f, 0.12147726f, 0.10495798f, 0.03284761f, 0.11171273f, -0.02228468f, 
    0.07636067f, 0.14194773f, -0.08729896f, -0.17890236f, -0.07195902f, 0.08994056f, -0.00309283f, -0.22180475f, 
    -0.04637736f, -0.02562996f, -0.00416683f, 0.03224791f, -0.04524863f, 0.03397532f, -0.03681308f, 0.04571098f, 
    0.04186810f, -0.05209392f, 0.04434725f, 0.01899619f, -0.05592957f, 0.01095464f, -0.04551014f, 0.01522741f, 
    0.01859263f, -0.04030822f, -0.06209886f, -0.02311477f, -0.02777269f, -0.02709067f, -0.03351816f, -0.05670530f, 
    0.03893573f, -0.05039034f, 0.01896065f, -0.00172084f, 0.01179737f, -0.05344843f, 0.02537735f, 0.00629773f, 
    -0.04107025f, -0.06913644f, 0.00771528f, 0.03818602f, -0.06049452f, -0.03900741f, 0.03925175f, -0.04216439f, 
    -0.03395875f, -0.01880214f, 0.00907734f, 0.02573269f, -0.00664692f, 0.03977401f, -0.03113689f, 0.01783535f, 
    -0.03982437f, -0.00450834f, -0.01994443f, -0.04825197f, 0.01944107f, -0.03892332f, 0.03453868f, 0.01594059f, 
    -0.03557984f, 0.00639838f, -0.01615280f, 0.02670694f, -0.06202425f, -0.00097646f, 0.02084255f, 0.00153988f, 
    -0.03944018f, -0.02021252f, -0.00752159f, 0.03846137f, 0.03505656f, -0.04433813f, 0.03741118f, -0.02229153f, 
    -0.05684986f, 0.03067974f, -0.01072763f, -0.00053947f, 0.03604518f, 0.01878405f, 0.02299039f, -0.00545686f, 
    -0.05118445f, 0.05040717f, -0.02363356f, 0.01636015f, -0.05996748f, 0.03631924f, 0.01103837f, -0.00016646f, 
    0.00990629f, 0.04916867f, -0.01783655f, 0.01666936f, 0.03604149f, 0.02035115f, -0.01665216f, 0.03039745f, 
    -0.04245009f, 0.04033504f, 0.00198212f, 0.00524310f, -0.03371361f, -0.00893986f, 0.01784070f, 0.01985429f, 
    0.02040306f, -0.00546552f, -0.04512259f, -0.00418000f, 0.03861132f, -0.01558450f, -0.00519900f, -0.04030009f, 
    0.01498134f, 0.00301895f, -0.02811700f, 0.04573926f, -0.00730492f, 0.02072615f, -0.03516429f, 0.01405721f, 
    -0.03141474f, -0.02989875f, -0.04944686f, -0.05517970f, -0.03959545f, -0.03566639f, 0.02361180f, -0.04672073f, 
    0.00263052f, -0.02797328f, -0.01087095f, -0.03129166f, -0.06085599f, -0.00109993f, -0.05559509f, -0.06789498f, 
    -0.00823955f, 0.04058656f, 0.00352394f, 0.03935460f, 0.01328720f, -0.01684205f, -0.06342342f, -0.06843187f, 
    -0.03772797f, 0.02514239f, -0.05552767f, 0.03464063f, -0.04698189f, 0.04632263f, 0.04046796f, 0.03170130f, 
    -0.02205921f, 0.05172192f, 0.01435036f, -0.06596645f, 0.02610419f, -0.02738957f, -0.00783565f, -0.03741260f, 
    -0.04069462f, 0.04787903f, 0.01577844f, -0.01812937f, 0.02457439f, 0.03844447f, -0.04243566f, 0.02399772f, 
    0.03695440f, 0.02985636f, 0.00309692f, -0.00076053f, -0.01701773f, 0.01137298f, 0.02733454f, -0.04267316f, 
    -0.05150726f, -0.02896774f, -0.03811467f, 0.03913283f, -0.04694278f, -0.01168422f, 0.03731641f, 0.04371068f, 
    -0.00633813f, -0.01665911f, 0.02879473f, 0.03774437f, -0.01469916f, -0.05261023f, -0.05260706f, -0.03178183f, 
    0.01211098f, -0.07239146f, -0.00021230f, -0.00671240f, -0.01559222f, -0.04282313f, 0.01291217f, -0.06344372f, 
    0.00506002f, -0.01782414f, -0.01543154f, -0.01549665f, -0.00607656f, 0.00115886f, 0.01033644f, -0.04732738f, 
    0.03545923f, -0.03108284f, -0.03854883f, -0.03023640f, -0.02377308f, 0.02221631f, -0.06612694f, -0.01768971f, 
    0.03207228f, -0.06012785f, 0.00136497f, -0.06827629f, -0.02852067f, 0.04022120f, 0.02092810f, -0.03517906f, 
    -0.01792223f, -0.06494673f, 0.03644903f, -0.04735360f, -0.00016172f, 0.02745378f, -0.01404511f, -0.00127675f, 
    0.01884793f, -0.05293738f, -0.03879827f, -0.04381683f, 0.02231955f, 0.04422499f, -0.01845774f, -0.02849438f, 
    0.04118964f, 0.01900515f, 0.00606427f, -0.00309744f, -0.05748050f, 0.01609950f, 0.02464725f, -0.05197079f, 
    0.03256781f, -0.04331317f, 0.00183021f, -0.05538732f, -0.02725339f, -0.02627652f, -0.04092096f, -0.02903272f, 
    0.00023555f, -0.02667551f, -0.02414712f, -0.00090779f, 0.01034034f, 0.00574114f, 0.02854238f, -0.03893615f, 
    -0.02008728f, 0.00520198f, 0.03420485f, -0.02499941f, -0.05994102f, -0.00542844f, 0.00175339f, -0.00274716f, 
    0.05270208f, -0.00584163f, 0.04281627f, -0.05830567f, 0.03877153f, 0.01413534f, 0.00045667f, 0.02351263f, 
    -0.02715769f, 0.00918140f, -0.03556807f, 0.00008364f, -0.01885908f, -0.04265454f, 0.01761940f, 0.04181914f, 
    0.04372105f, 0.02849132f, -0.04137762f, -0.01423692f, -0.02886799f, -0.01666940f, -0.06696662f, -0.03174474f, 
    -0.00533966f, -0.04359534f, 0.04080670f, -0.03699333f, -0.00773301f, 0.00918434f, -0.03986906f, 0.03205958f, 
    0.02820643f, 0.01360391f, -0.00817439f, -0.07102279f, 0.03179425f, -0.01436429f, -0.06269962f, -0.01862808f, 
    -0.00329810f, -0.06569291f, 0.01074032f, 0.00277109f, 0.01707856f, -0.01210467f, -0.03484917f, -0.00680067f, 
    -0.05972553f, -0.00563140f, -0.00306360f, 0.03836332f, -0.05873001f, 0.02481446f, -0.06672727f, -0.03930210f, 
    -0.06652322f, -0.06645495f, 0.00497480f, 0.02719148f, -0.02404437f, 0.01890146f, -0.05365162f, 0.02737286f, 
    0.02116941f, 0.01760888f, 0.00321839f, 0.03933217f, -0.01353128f, -0.00485329f, -0.06851017f, -0.02865435f, 
    -0.00211559f, -0.05579862f, -0.02679498f, 0.03103697f, -0.07478131f, -0.05358641f, -0.02452808f, 0.02558275f, 
    0.04048593f, -0.01761565f, 0.03481854f, -0.02260082f, -0.02328141f, 0.03529057f, 0.02370935f, 0.02252324f, 
    -0.07513605f, -0.05173330f, -0.02445597f, -0.05188959f, -0.02988299f, -0.06946451f, 0.03458165f, -0.07137321f, 
    0.00031619f, -0.01921746f, -0.04817079f, -0.04832141f, 0.02773190f, -0.00989976f, -0.01303077f, -0.06338210f, 
    -0.02124058f, -0.05646465f, 0.03638252f, 0.03370147f, 0.03190485f, -0.05930171f, -0.05116985f, -0.03042493f, 
    0.01720178f, 0.02246249f, -0.06431930f, -0.01308920f, -0.06841335f, -0.01989590f, 0.03330637f, 0.04077896f, 
    -0.05359669f, -0.01719932f, 0.05223006f, -0.05306537f, -0.00667808f, 0.02963140f, -0.03414812f, -0.03493919f, 
    0.01599250f, -0.03113652f, 0.02541910f, 0.03114354f, 0.03040064f, -0.04175638f, 0.04830136f, -0.01877549f, 
    0.05128647f, -0.01509994f, -0.07795013f, -0.00091234f, -0.04592068f, 0.02498392f, -0.06635537f, -0.03465423f, 
    -0.05673209f, -0.07698365f, -0.06576382f, -0.00391324f, 0.04248182f, -0.06216459f, -0.02268977f, -0.05196325f, 
    -0.04352429f, 0.00433283f, -0.05318402f, -0.04732971f, 0.00290047f, -0.03926445f, -0.03502306f, 0.00483890f, 
    -0.02855048f, -0.04487098f, 0.03349645f, 0.03876964f, -0.07005022f, -0.02634115f, -0.02731051f, 0.00008745f, 
    -0.05461669f, -0.01070329f, -0.04395078f, -0.07312690f, -0.05349855f, -0.01225857f, -0.05309883f, -0.06376634f, 
    -0.00062160f, -0.03394999f, -0.06433102f, -0.03654280f, -0.06513809f, 0.02512763f, -0.04682751f, -0.06584504f, 
    -0.02989128f, 0.02436064f, -0.07266060f, -0.03411245f, 0.01145212f, -0.01520183f, 0.02487426f, -0.03874846f, 
    0.01633645f, 0.04146899f, -0.06917772f, 0.03725116f, 0.00205677f, -0.03326612f, 0.00721043f, 0.03049207f, 
    0.00458542f, -0.05939430f, 0.05324657f, 0.04380662f, 0.05010960f, -0.02829777f, -0.05613722f, -0.07499124f, 
    -0.07313906f, -0.03178911f, 0.02201165f, -0.02338635f, -0.06476533f, -0.05433814f, -0.01950329f, -0.00251479f, 
    -0.07633143f, -0.05132234f, 0.03572132f, -0.06535724f, 0.00208856f, -0.05643144f, -0.03455599f, -0.00160806f, 
    -0.02966828f, 0.02558625f, 0.01956758f, 0.00953401f, -0.00160196f, -0.01086479f, 0.00000438f, -0.05122611f, 
    -0.04317791f, 0.03480268f, 0.00253749f, -0.00784054f, -0.04359854f, -0.02275882f, -0.02523806f, -0.05523867f, 
    -0.00269388f, 0.03157743f, -0.01957138f, -0.02290156f, 0.01321704f, 0.00755414f, 0.00992377f, -0.04354636f, 
    0.02428732f, 0.02047122f, -0.04578692f, 0.01472679f, -0.00397108f, -0.00741608f, -0.06068054f, -0.03405681f, 
    0.03876384f, 0.02660314f, -0.05351816f, -0.01014595f, -0.03941839f, 0.03373374f, -0.00483878f, -0.04500857f, 
    0.01266739f, -0.06818307f, -0.01056444f, 0.01177006f, 0.03210267f, 0.02949758f, -0.01576092f, -0.05881748f, 
    -0.04626179f, -0.05853820f, 0.01173588f, -0.03160187f, -0.03965567f, -0.02151454f, -0.03935232f, 0.00014320f, 
    -0.04534101f, 0.03227281f, -0.05349614f, -0.04437255f, 0.03265236f, -0.06654756f, 0.02367945f, -0.05930678f, 
    -0.04382288f, -0.03811054f, -0.02360718f, -0.05217773f, -0.06186593f, 0.01789170f, 0.03441412f, 0.02037585f, 
    -0.00465710f, -0.03453473f, -0.02455033f, 0.00961230f, 0.00983213f, -0.02979898f, -0.03091642f, 0.03003903f, 
    0.04902011f, -0.01404739f, -0.00730083f, 0.05184165f, -0.07007244f, 0.03992638f, -0.02243559f, -0.00237746f, 
    -0.01423483f, 0.05129821f, -0.03769776f, -0.03458210f, -0.05923668f, -0.01634118f, 0.03728455f, -0.00111774f, 
    -0.01369119f, -0.05528937f, -0.02629417f, -0.00248069f, 0.00888372f, -0.00522132f, -0.04861508f, 0.03844622f, 
    0.01358682f, -0.06083024f, 0.03713583f, 0.04919453f, -0.02682565f, 0.00438276f, -0.00362090f, 0.03558651f, 
    -0.05950810f, 0.02704697f, 0.03411380f, 0.01022794f, 0.04396238f, 0.02032336f, 0.03258201f, -0.05308466f, 
    -0.04002932f, 0.04164123f, 0.00178980f, -0.05174456f, -0.06576166f, 0.04849654f, -0.00625437f, -0.01875394f, 
    0.03741392f, -0.06346488f, -0.01236432f, -0.00025785f, -0.02857587f, 0.05393005f, 0.00227103f, -0.01682063f, 
    -0.00106891f, -0.06059402f, -0.05851525f, 0.00456682f, 0.02906861f, 0.00937655f, -0.00088838f, 0.02619358f, 
    0.01654948f, 0.03407476f, 0.04813804f, -0.05871861f, -0.01069701f, 0.04201163f, -0.05858874f, -0.04251927f, 
    -0.04791969f, -0.01401785f, -0.01514616f, -0.02101851f, -0.01028827f, 0.00968522f, 0.02451544f, -0.05351335f, 
    0.02111537f, -0.03090550f, -0.02535451f, 0.05200433f, 0.01866118f, -0.04505121f, -0.05465350f, -0.01979195f, 
    0.00774583f, 0.02641357f, 0.02357009f, -0.06306158f, -0.06415372f, 0.04138339f, -0.06617486f, 0.00320383f, 
    0.04312492f, 0.03990328f, 0.00327288f, 0.04924689f, 0.00218572f, 0.01984056f, 0.00212610f, -0.05775052f, 
    0.02435304f, 0.01860129f, -0.00778465f, -0.00347909f, 0.01214829f, -0.02842726f, -0.02649593f, 0.02878698f, 
    0.00093585f, -0.00056495f, -0.04677287f, -0.03001032f, -0.00259004f, -0.03758390f, 0.02139635f, -0.03775509f, 
    -0.04581943f, -0.05502838f, -0.03461094f, -0.00127643f, -0.02475367f, -0.02355323f, -0.03259445f, -0.02512993f, 
    0.00674825f, -0.02161013f, -0.05273636f, -0.02462731f, -0.04454264f, -0.00667750f, 0.01843099f, -0.03882055f, 
    -0.07309853f, -0.00357120f, -0.04722736f, 0.03717275f, -0.00632353f, 0.02961976f, 0.02758844f, -0.03510127f, 
    0.00241836f, -0.03061130f, 0.02299159f, -0.03275396f, 0.01400107f, -0.06236098f, -0.00520726f, 0.02865603f, 
    0.00420005f, -0.04145018f, -0.05815316f, 0.00007448f, -0.04463761f, -0.06950223f, 0.02510224f, -0.05139351f, 
    -0.02650973f, -0.01616780f, -0.06905277f, -0.03109033f, 0.05242055f, 0.01641629f, -0.02983980f, -0.03447220f, 
    -0.01095519f, 0.01678430f, 0.00758164f, 0.01264228f, 0.01266815f, -0.00783394f, 0.02989091f, -0.04048254f, 
    -0.00629054f, -0.04714444f, 0.04831975f, -0.03483748f, -0.03383046f, 0.04323310f, 0.04221769f, -0.04272950f, 
    -0.03727587f, 0.00462395f, -0.01360612f, 0.03438885f, -0.05993232f, -0.01365429f, 0.02061055f, -0.01281746f, 
    -0.02248478f, -0.05200539f, -0.06574795f, -0.03770252f, 0.03230072f, -0.04109580f, -0.01252949f, -0.00898489f, 
    0.04756580f, 0.02510529f, 0.03394878f, -0.03073797f, -0.03270729f, -0.00142170f, -0.00303222f, -0.03549140f, 
    -0.06456153f, 0.00779172f, 0.02564597f, -0.00771519f, -0.00105573f, 0.00343475f, -0.06134867f, 0.00201857f, 
    -0.01943188f, -0.00955007f, 0.03332459f, -0.05905846f, 0.03423123f, -0.04806897f, 0.03097977f, -0.00954727f, 
    -0.05140128f, -0.05031123f, 0.03953845f, -0.02673293f, 0.02345201f, -0.05563158f, -0.01293843f, -0.01110771f, 
    -0.02910851f, 0.02777849f, -0.01682816f, -0.06646872f, -0.00559003f, 0.02491196f, -0.06533653f, 0.01174957f, 
    -0.00875340f, -0.01172720f, -0.05280328f, -0.02763088f, 0.01054269f, 0.01972810f, -0.01730463f, 0.03846337f, 
    0.04805978f, 0.03934783f, -0.05622433f, 0.04825687f, -0.04863751f, -0.06675845f, 0.01246293f, -0.02540759f, 
    -0.06201515f, 0.01238477f, -0.05274284f, -0.05084581f, 0.00116004f, -0.03032094f, -0.00467813f, -0.05680513f, 
    -0.03522551f, 0.01615096f, -0.01861259f, 0.01027976f, -0.03734231f, -0.04482941f, -0.05105392f, -0.04341976f, 
    0.03783720f, -0.00325343f, -0.02406972f, 0.04491409f, 0.00142815f, 0.00996517f, -0.05074806f, -0.03263685f, 
    -0.01444030f, -0.04567765f, -0.00511110f, -0.04653954f, -0.00206530f, 0.00073642f, 0.03101645f, -0.01930536f, 
    -0.00060247f, 0.05619701f, -0.24076922f, -0.10429764f, 0.04052120f, 0.14500982f, -0.14792494f, -0.14244181f, 
    -0.07864130f, -0.12515236f, 0.35022634f, -0.17285602f, 0.03762050f, -0.09458986f, -0.01723330f, -0.07774434f, 
    0.14285448f, -0.21099560f, -0.24534202f, 0.05515467f, 0.01821698f, 0.11459525f, -0.00026475f, 0.11065668f, 
    -0.04085874f, 0.13001677f, -0.07838392f, -0.04638736f, 0.10367332f, -0.01179759f, -0.03774937f, -0.05772988f, 
    0.10535217f, -0.08991903f, -0.04290095f, 0.13079049f, -0.02268229f, -0.15560110f, -0.02443147f, 0.12365042f, 
    0.12316792f, 0.09769326f, -0.15175515f, -0.07779069f, -0.12405029f, 0.06430245f, 0.02666266f, -0.16201124f, 
    -0.00996798f, -0.11603352f, -0.08525392f, 0.09426775f, 0.13573223f, 0.07965682f, -0.08008195f, 0.02767886f, 
    -0.00309547f, 0.13331716f, -0.04816464f, 0.07863703f, 0.09543152f, 0.24105620f, 0.08583844f, 0.11788247f, 
    -0.13721740f, 0.10207859f, -0.10208670f, -0.19344522f, -0.29482418f, 0.12052710f, 0.13697995f, -0.01795934f, 
    0.19302988f, -0.03078204f, 0.01386845f, 0.07800529f, -0.25764969f, 0.15427324f, 0.16642784f, 0.13697495f, 
    -0.00827130f, 0.01174437f, 0.01167279f, 0.11745276f, 0.06736827f, -0.01765231f, -0.24847734f, -0.01760097f, 
    0.06577348f, 0.13620023f, -0.11610442f, 0.22511701f, -0.23585989f, 0.19587786f, -0.05636318f, 0.13322212f, 
    0.06904776f, -0.12323269f, -0.08585154f, -0.06020198f, -0.14800876f, 0.09366714f, -0.14339231f, 0.01848482f, 
    -0.17459902f, 0.15175278f, 0.00412184f, 0.06335214f, -0.13750151f, 0.05253344f, -0.30864030f, 0.02041302f, 
    0.10299208f, 0.10818668f, 0.04540849f, 0.06262231f, 0.01779653f, -0.32472128f, -0.20796558f, 0.08932851f, 
    0.01277437f, 0.06114117f, 0.09817526f, -0.03659565f, -0.26288417f, 0.11050460f, 0.11766370f, 0.18885720f, 
    -0.06859764f, 0.18157490f, 0.00109967f, -0.12618496f, -0.03061029f, 0.10170877f, 0.15628366f, 0.09537063f, 
    0.09600002f, 0.10427038f, 0.17394936f, -0.08346467f, 0.12945549f, -0.14533202f, 0.01562102f, 0.03290549f, 
    0.00153479f, 0.43316481f, -0.07120117f, -0.07340491f, 0.05526679f, -0.18004736f, -0.11613642f, -0.21815854f, 
    -0.09963596f, 0.13990989f, -0.05030163f, 0.04395368f, 0.11086090f, 0.09045208f, 0.02850829f, 0.11135826f, 
    0.03498371f, 0.15309872f, -0.00019555f, 0.05133779f, -0.00660548f, -0.04926460f, 0.00626000f, 0.19755645f, 
    -0.04710609f, -0.02518016f, -0.05273737f, 0.02734178f, -0.03181588f, 0.14634696f, 0.08545107f, -0.14745253f, 
    0.21248659f, -0.06564988f, 0.07380313f, 0.06559701f, -0.05811154f, 0.06064751f, 0.12662980f, -0.11384229f, 
    -0.00704357f, -0.06530398f, 0.03514976f, 0.03371010f, -0.10371775f, -0.10369688f, -0.17932165f, -0.05277918f, 
    0.00739178f, 0.13466389f, 0.21763071f, -0.14924273f, -0.06073667f, 0.09341084f, -0.00084048f, 0.14240009f, 
    -0.07797828f, 0.01738434f, -0.03665635f, 0.17466894f, 0.15068126f, -0.01807352f, -0.15182815f, 0.01568793f, 
    -0.06940490f, 0.08897170f, 0.15932037f, -0.12096985f, 0.00347391f, 0.12137638f, 0.09014303f, -0.04765249f, 
    -0.03487185f, -0.23750791f, -0.09469839f, 0.05934005f, 0.01898125f, 0.03488194f, -0.04930822f, -0.21643254f, 
    -0.08735272f, -0.14633164f, 0.11870992f, -0.08327232f, 0.18939894f, -0.09254097f, 0.04204567f, 0.04088517f, 
    -0.02871072f, -0.15245561f, -0.11977063f, -0.05724725f, 0.03874876f, -0.05373186f, -0.04412340f, -0.01696165f, 
    -0.00776413f, -0.15868850f, 0.11494646f, -0.10659826f, -0.21408927f, -0.12046067f, -0.14015116f, 0.05311695f, 
    0.15262227f, 0.12198840f, -0.11588995f, -0.03185612f, 0.09300754f, 0.00471133f, 0.10464419f, 0.05198004f, 
    -0.08039039f, -0.03133849f, -0.05932521f, 0.14803584f, 0.00994741f, 0.24294946f, -0.07597455f, -0.02471511f, 
    -0.02911377f, 0.02673684f, -0.10578135f, 0.07127463f, -0.07794539f, -0.15708388f, 0.04666037f, 0.06567638f, 
    -0.23549651f, 0.08870035f, 0.08081005f, 0.28626522f, 0.00998678f, -0.15332235f, -0.04693730f, -0.07955024f, 
    -0.15075521f, 0.03158213f, 0.18882035f, -0.11395194f, -0.10443530f, 0.02293970f, 0.12947883f, -0.08941449f, 
    -0.34925711f, -0.00638277f, 0.02887801f, -0.18893579f, 0.08601869f, 0.05652237f, 0.02306744f, 0.10746782f, 
    -0.13413802f, 0.03474822f, -0.37845427f, -0.01374745f, 0.08271499f, -0.01168308f, 0.10497143f, 0.04145671f, 
    -0.21320027f, -0.11762516f, 0.00012324f, -0.28241423f, -0.20708911f, 0.07008583f, -0.07480116f, 0.07567967f, 
    0.04787345f, 0.09564722f, -0.12874220f, 0.14377321f, 0.08261073f, -0.08486018f, 0.03358361f, -0.17545480f, 
    0.04226373f, 0.06267735f, 0.00201763f, -0.03253363f, -0.16673879f, -0.01408356f, -0.07494239f, -0.20596416f, 
    -0.01233493f, -0.11860764f, -0.01807870f, 0.03568606f, 0.04119963f, -0.10951833f, -0.15592468f, 0.02752387f, 
    0.17642446f, -0.07111669f, 0.05452072f, -0.00038420f, -0.02725094f, -0.05612537f, 0.01968113f, -0.16647810f, 
    0.09410495f, 0.07167587f, 0.09848840f, 0.09788792f, -0.06299181f, -0.13431360f, -0.07913283f, 0.17247266f, 
    0.07972943f, 0.05545776f, -0.08900114f, -0.06678019f, -0.05082232f, 0.07864659f, 0.30870691f, 0.02384328f, 
    0.04753016f, 0.03693807f, -0.08449625f, 0.09196092f, 0.15604410f, 0.03250406f, -0.09359179f, -0.00194887f, 
    -0.00507072f, 0.00239252f, -0.07563210f, 0.13523485f, -0.06111113f, 0.08714955f, -0.03124821f, 0.12816006f, 
    -0.03465845f, -0.05627567f, -0.38574496f, -0.08671526f, 0.10937702f, -0.07806360f, 0.08689584f, -0.00119454f, 
    0.10757929f, 0.00295927f, -0.09255909f, 0.22463001f, 0.10950334f, -0.32071930f, 0.16620336f, 0.06293797f, 
    0.07381806f, -0.08366010f, -0.00335561f, 0.05322395f, -0.22194491f, -0.13826634f, 0.08432848f, 0.02820736f, 
    -0.00947179f, -0.03595073f, -0.13982856f, 0.01331072f, 0.08536332f, -0.16963130f, 0.24447484f, -0.25423574f, 
    0.01266725f, -0.06983362f, 0.14568561f, 0.02487232f, 0.03273375f, 0.10188705f, 0.02139977f, -0.19870488f, 
    -0.15762725f, -0.20026618f, 0.04727455f, -0.00005215f, -0.06846060f, -0.05464349f, -0.02499254f, 0.07270183f, 
    0.08952808f, 0.02785219f, -0.19466193f, -0.06892435f, -0.02809729f, 0.05284009f, 0.09098031f, -0.03376855f, 
    0.03457490f, 0.03426341f, -0.16568133f, -0.18338819f, 0.03496581f, 0.07926351f, 0.05227883f, 0.19650750f, 
    -0.00159642f, 0.11919633f, 0.06096439f, -0.06786939f, -0.12578478f, -0.05254799f, 0.11199681f, 0.04419294f, 
    0.16030052f, 0.10246752f, -0.01286750f, 0.01217287f, 0.02916600f, -0.00897664f, -0.05845845f, 0.06326570f, 
    0.08062779f, 0.04664217f, -0.03131139f, 0.18089412f, 0.12903550f, 0.17418072f, -0.17773344f, -0.10139348f, 
    -0.06781710f, -0.05986058f, 0.01223612f, 0.06484770f, 0.29735574f, -0.04101202f, 0.05282216f, 0.21076708f, 
    0.22485803f, 0.09642509f, -0.14215374f, -0.07804357f, 0.07022626f, -0.01545804f, 0.20773499f, 0.15804712f, 
    -0.06787610f, -0.06137267f, 0.14865611f, -0.09830320f, -0.15278296f, 0.12186827f, 0.15196763f, 0.01066766f, 
    -0.25419068f, 0.22289105f, 0.19847310f, 0.09844663f, -0.10314660f, -0.05123068f, -0.02001770f, -0.10144868f, 
    -0.43141016f, 0.15686440f, -0.19406386f, -0.02450064f, -0.22160399f, 0.12070984f, 0.09447092f, -0.01624980f, 
    0.27685708f, -0.26914337f, -0.12342887f, 0.25951037f, 0.03216731f, 0.01557966f, -0.08914474f, -0.17169155f, 
    0.00850768f, 0.24049278f, -0.13906685f, -0.02121395f, -0.05275764f, -0.11896609f, -0.15636718f, 0.05201079f, 
    0.12889384f, 0.06873985f, -0.03386641f, -0.11110400f, 0.04227474f, 0.04251402f, 0.01904180f, -0.04525087f, 
    0.03500325f, -0.11419117f, -0.18578893f, 0.10113084f, -0.08885243f, -0.26880530f, -0.04223011f, -0.22893423f, 
    0.05183026f, -0.08941800f, 0.19219257f, 0.03583230f, 0.18731681f, -0.09799083f, -0.05575484f, -0.27024063f, 
    0.04669767f, -0.10623455f, 0.02571865f, -0.14613877f, -0.04916634f, -0.03765531f, 0.03485526f, -0.00625326f, 
    -0.09021675f, -0.14741474f, 0.02554278f, -0.08822162f, 0.05696106f, 0.06091629f, -0.08412350f, 0.16741244f, 
    0.05947202f, -0.00727081f, 0.02521695f, 0.03725777f, 0.15889530f, 0.14605722f, 0.01512966f, 0.06415327f, 
    -0.13191995f, 0.08397111f, -0.05668385f, 0.00716801f, 0.18715145f, 0.08062592f, 0.03624467f, -0.15143289f, 
    -0.16874166f, -0.02153365f, -0.13757561f, 0.02680025f, -0.21258810f, -0.07662649f, 0.13725917f, -0.08960330f, 
    0.03506722f, -0.38769224f, -0.16628909f, 0.35208991f, 0.08121808f, 0.15882878f, 0.09513211f, -0.11184321f, 
    -0.05674607f, 0.10672976f, 0.24332073f, -0.12390773f, 0.15292104f, 0.05938151f, -0.07310706f, 0.02377246f, 
    0.04176743f, 0.04817300f, 0.06574116f, 0.42884701f, -0.09783437f, -0.17479797f, 0.04975300f, -0.00797471f, 
    0.01723203f, -0.03405165f, -0.07455472f, -0.17299308f, -0.16717495f, -0.05487757f, -0.39562187f, 0.07183388f, 
    -0.03916643f, -0.09218857f, 0.08653056f, -0.18496326f, 0.07876544f, 0.39208475f, 0.13077922f, 0.06527369f, 
    0.00910137f, 0.02354709f, -0.02448815f, 0.02969911f, -0.01112617f, 0.09999652f, -0.19597644f, -0.17379294f, 
    0.24956587f, 0.06304733f, -0.05125666f, 0.10070671f, 0.05999003f, 0.14569464f, 0.07358920f, 0.10152085f, 
    -0.13114448f, 0.03352078f, -0.13617408f, 0.05814979f, -0.13626823f, -0.09138179f, 0.15844226f, 0.13790269f, 
    0.19286281f, 0.13876018f, -0.07701983f, 0.04595046f, 0.08686911f, 0.02949294f, -0.01230301f, 0.01841660f, 
    0.05518440f, -0.01473907f, 0.16127449f, 0.01329546f, 0.13245384f, 0.18441042f, 0.10206543f, 0.10188475f, 
    0.00009525f, 0.01644308f, 0.09687081f, 0.16121277f, 0.18219197f, 0.19399662f, -0.11201248f, -0.07845790f, 
    -0.05652175f, 0.04143679f, -0.04252483f, -0.15859856f, 0.03503494f, 0.18089373f, -0.04052621f, -0.05924259f, 
    0.00343787f, -0.00323214f, 0.06490865f, -0.03766054f, -0.08940658f, -0.27331409f, -0.14467151f, 0.06179135f, 
    0.01078543f, 0.04730571f, 0.11661340f, -0.17789336f, 0.08344475f, 0.24712236f, -0.07894026f, -0.40641421f, 
    0.07234279f, -0.24485978f, -0.04675983f, 0.09936818f, -0.17558120f, -0.01627444f, 0.05204128f, -0.00128693f, 
    0.12446374f, 0.03496465f, -0.07061614f, -0.03610172f, 0.09164275f, -0.15981472f, -0.12423839f, -0.03089964f, 
    0.02372555f, -0.09320791f, -0.11112410f, 0.14244443f, 0.08876332f, -0.03302004f, 0.14799082f, 0.03406969f, 
    0.07445388f, 0.00588075f, -0.01098892f, 0.05420578f, 0.27384424f, -0.02528500f, 0.12809701f, -0.07626049f, 
    0.23297662f, 0.21586524f, 0.08685803f, -0.32333952f, 0.00393218f, -0.13567483f, 0.02900639f, 0.03384746f, 
    0.04761702f, 0.06765123f, -0.12875783f, 0.07707477f, -0.51121724f, 0.12852272f, -0.05369817f, 0.04990879f, 
    -0.04155747f, 0.03763247f, 0.08004272f, -0.21452773f, 0.14050961f, -0.00797678f, 0.06472733f, -0.02237218f, 
    -0.10885524f, 0.14952570f, 0.08213522f, -0.20508583f, 0.10947637f, -0.10237996f, 0.22118580f, -0.15955493f, 
    -0.09190655f, -0.01242846f, -0.16129267f, 0.08707833f, -0.00053311f, -0.23462352f, -0.05012522f, -0.13025644f, 
    0.02142014f, 0.00720363f, 0.03018519f, 0.08492278f, 0.04338539f, 0.04939925f, -0.01009433f, 0.04318527f, 
    0.10940018f, -0.02076721f, 0.03607355f, 0.04377978f, -0.09117042f, 0.12516788f, -0.04673713f, -0.11343416f, 
    0.16019340f, -0.21359700f, 0.03535140f, 0.16952379f, -0.03978446f, 0.14955074f, 0.02395442f, 0.08666533f, 
    0.06688252f, -0.03121969f, 0.29753363f, -0.11593728f, -0.05291067f, 0.08202440f, -0.12452316f, -0.02350662f, 
    -0.00279123f, -0.38870049f, -0.24451646f, 0.27859482f, 0.04273582f, 0.03487697f, 0.03078240f, 0.05851170f, 
    0.05546429f, 0.12693956f, 0.01883885f, 0.06377936f, -0.09903059f, -0.05123763f, -0.04724256f, 0.08659201f, 
    -0.00357239f, -0.03054175f, -0.11347752f, -0.36046857f, 0.22649273f, -0.28989676f, 0.07166294f, -0.01432055f, 
    0.03691658f, -0.08243489f, 0.00505303f, -0.30081806f, 0.15392448f, 0.05497232f, -0.03626247f, 0.02034407f, 
    0.03706976f, -0.00226340f, 0.03426679f, -0.13895008f, 0.17518686f, -0.34249112f, -0.55812067f, -0.01011192f, 
    -0.10700557f, -0.09567745f, 0.10118679f, -0.06874175f, 0.05455941f, 0.15318088f, 0.16329978f, -0.00029012f, 
    -0.04782483f, 0.14363790f, -0.07021299f, -0.03295399f, 0.05960589f, 0.14067110f, -0.07970795f, -0.18503268f, 
    0.02541206f, -0.14190242f, 0.10719319f, -0.13376607f, -0.00520530f, -0.11221562f, 0.01202260f, 0.08919606f, 
    -0.07773595f, 0.27989632f, -0.17070590f, -0.05815668f, -0.16810293f, -0.03617366f, 0.22466181f, 0.03571821f, 
    0.09264826f, 0.11125024f, 0.09724412f, 0.19280550f, -0.02479707f, 0.04088274f, 0.09560830f, 0.08273339f, 
    0.21566302f, 0.02753393f, 0.19993135f, 0.04925496f, -0.15572000f, 0.11104976f, -0.06690103f, 0.18609221f, 
    0.03333629f, 0.08835742f, 0.01132154f, 0.17335184f, -0.16480273f, -0.12914747f, -0.03613249f, -0.10689349f, 
    0.14875455f, 0.08282824f, 0.06862525f, 0.06830098f, 0.23244146f, 0.14921805f, -0.12358637f, 0.13658872f, 
    -0.13439396f, 0.03964455f, 0.20635591f, -0.06041789f, -0.02930135f, -0.34741670f, 0.09276900f, -0.10633291f, 
    0.06213024f, 0.13406734f, 0.12179856f, 0.04996794f, -0.01734947f, -0.15805529f, 0.03219737f, 0.13203381f, 
    0.02494751f, -0.06564053f, 0.05030068f, -0.10270146f, 0.14754713f, -0.10050538f, -0.05527044f, -0.21785970f, 
    0.01301111f, -0.10740962f, 0.20811819f, 0.26660153f, 0.21460745f, 0.20886113f, -0.13986827f, 0.07248396f, 
    -0.11194067f, -0.12683561f, 0.01094774f, 0.04944697f, 0.01611271f, 0.10133912f, -0.06999850f, -0.04356123f, 
    -0.06794956f, -0.15913588f, 0.02414255f, 0.12876949f, 0.11434790f, 0.06930652f, 0.05376301f, 0.21017821f, 
    0.07666203f, 0.05182501f, 0.30400953f, 0.01034436f, -0.16304027f, -0.01045607f, -0.09450740f, -0.10246186f, 
    0.05918977f, 0.28216910f, 0.11658104f, -0.16903898f, -0.09707557f, -0.07809183f, 0.21823899f, 0.12979820f, 
    0.23562758f, -0.13534942f, 0.04250997f, -0.03317923f, -0.17106290f, 0.05608517f, -0.07622956f, -0.01279250f, 
    0.24538630f, 0.07573118f, -0.12573002f, 0.23413266f, -0.16273950f, -0.05051478f, -0.29969406f, -0.21539794f, 
    0.12109965f, 0.03485651f, -0.07125585f, 0.01658486f, 0.02061398f, 0.01869959f, 0.10117970f, 0.11935882f, 
    0.05393181f, -0.02350995f, -0.01814753f, 0.09529912f, 0.19890770f, 0.03888452f, 0.09416631f, 0.23007293f, 
    0.08141237f, 0.04238313f, 0.15732712f, 0.10679853f, 0.05301187f, 0.08329479f, -0.04090665f, 0.13410199f, 
    0.05977072f, -0.00907075f, -0.07743799f, -0.12299062f, 0.13314438f, -0.19272490f, -0.01809557f, -0.14461167f, 
    0.24286258f, 0.36066544f, 0.03128050f, -0.05424497f, 0.04185685f, 0.04147346f, 0.05017444f, 0.07634223f, 
    0.10742445f, 0.18664651f, 0.54645145f, 0.10007595f, 0.02840972f, -0.07501095f, 0.03114341f, 0.25470889f, 
    0.12695979f, -0.05000327f, 0.09065840f, 0.63847935f, -0.05073791f, 0.13551737f, 0.03545379f, -0.05785047f, 
    0.13691066f, 0.15094703f, 0.06274173f, 0.20096877f, -0.43883464f, -0.09090459f, -0.00735236f, 0.07192147f, 
    0.17342094f, -0.02827925f, -0.09592120f, -0.05793282f, -0.02976663f, -0.08498351f, 0.05333070f, -0.00513060f, 
    -0.05013113f, 0.07097233f, 0.07250304f, -0.21309370f, -0.08215193f, 0.02145116f, -0.05670847f, -0.09702697f, 
    -0.16288146f, 0.22297737f, 0.07718164f, 0.00447237f, -0.26150209f, 0.09605495f, -0.05060018f, -0.02029400f, 
    -0.07481615f, -0.28423339f, 0.05043394f, -0.02108033f, -0.35826489f, -0.07803715f, 0.04180104f, 0.02017991f, 
    -0.18471967f, 0.01723970f, -0.11684628f, 0.06023930f, 0.05535768f, 0.18943694f, 0.02218442f, 0.09582664f, 
    -0.04881023f, -0.06567466f, 0.05165496f, -0.18339844f, -0.10831002f, -0.05816147f, -0.05332000f, -0.02610995f, 
    -0.02799652f, 0.11073302f, -0.20698582f, 0.18223469f, -0.13499151f, 0.05786877f, 0.00186208f, 0.18060213f, 
    0.03327269f, 0.36790332f, -0.31698751f, -0.02391231f, -0.02533635f, 0.01724768f, -0.01707316f, 0.14736478f, 
    -0.00280583f, -0.19380416f, 0.16264367f, -0.15034351f, 0.38209930f, -0.47281808f, 0.21276484f, 0.12622246f, 
    -0.11580360f, 0.12239342f, 0.10052364f, 0.14756782f, 0.03684610f, -0.63773876f, -0.00614551f, 0.05941427f, 
    0.03430318f, 0.03718488f, 0.12338612f, -0.35194078f, 0.06012839f, -0.09232000f, 0.16507435f, 0.13238221f, 
    -0.25321776f, -0.02043791f, -0.18376033f, 0.07236351f, -0.08002337f, 0.11551308f, -0.04628208f, 0.42131621f, 
    0.27461186f, -0.00132385f, -0.04026893f, 0.03450376f, -0.10141708f, 0.12114663f, 0.09374963f, 0.20942611f, 
    -0.25321662f, -0.06733871f, -0.19296454f, -0.04974049f, 0.03062302f, -0.16147971f, -0.04591671f, -0.06483426f, 
    -0.02696371f, -0.23708320f, -0.12881894f, 0.10873310f, 0.00486942f, 0.09043119f, -0.06705569f, 0.00426112f, 
    0.02482757f, -0.12504099f, -0.18597516f, 0.11115885f, 0.04180955f, 0.00501311f, 0.01868850f, -0.11049601f, 
    -0.17719439f, 0.01610611f, -0.10691158f, 0.11004011f, 0.02083876f, -0.13476238f, 0.13726115f, 0.06110193f, 
    0.03354024f, 0.01802774f, 0.14126247f, 0.03430713f, -0.10893887f, 0.03753034f, -0.22061270f, 0.09465294f, 
    0.21405460f, -0.06830150f, 0.06781046f, 0.01918376f, 0.07031918f, 0.20794082f, 0.03972891f, 0.06476269f, 
    0.04031882f, -0.08017583f, 0.01488987f, -0.08193087f, -0.01542941f, 0.00416919f, -0.08988762f, -0.17927419f, 
    0.03146520f, -0.01873865f, -0.19240907f, 0.05831518f, -0.08523705f, -0.00272464f, 0.02466900f, 0.12281000f, 
    0.13298073f, -0.13376907f, 0.01347374f, -0.20116816f, 0.09376555f, 0.06154719f, -0.02320304f, -0.00109493f, 
    0.20961273f, 0.17524025f, 0.10633334f, 0.12718961f, 0.11613626f, -0.08773653f, 0.17740239f, 0.06713135f, 
    0.05262846f, -0.00990122f, -0.04015975f, 0.07312821f, 0.19158731f, -0.05039809f, 0.08397771f, -0.04315691f, 
    0.04052110f, 0.06464840f, 0.09647151f, 0.13983750f, -0.09877708f, -0.04026097f, 0.04888775f, -0.11855065f, 
    0.07214382f, -0.05637592f, -0.17538780f, 0.31633997f, 0.06047056f, 0.22760610f, -0.15550125f, 0.06186440f, 
    0.16219644f, -0.17901820f, 0.06930453f, -0.01008795f, -0.12866819f, -0.09631544f, -0.06158703f, 0.15462042f, 
    -0.03066758f, 0.10141665f, 0.12234501f, -0.12584566f, -0.02117731f, 0.18272574f, -0.02234846f, -0.06909896f, 
    0.04527231f, -0.06957400f, 0.09084705f, -0.11600226f, -0.10084035f, 0.04451361f, 0.27279201f, 0.00307379f, 
    0.18867467f, 0.20035079f, 0.00061599f, 0.00034032f, -0.03625150f, 0.01458188f, 0.05876251f, 0.04592009f, 
    -0.00846916f, 0.16257486f, 0.15570697f, 0.11144435f, 0.04052533f, 0.03556897f, 0.08095686f, -0.11025089f, 
    -0.07781671f, -0.08912351f, 0.08089570f, -0.02514492f, 0.24353057f, -0.12893037f, 0.02154204f, 0.01077051f, 
    -0.15014465f, 0.24524796f, -0.02211401f, 0.09963883f, 0.03649790f, 0.03806734f, -0.10357441f, -0.00364023f, 
    0.12473623f, 0.18433122f, 0.05589703f, -0.25767234f, -0.05048222f, 0.11843890f, 0.09831296f, -0.07920600f, 
    0.10110942f, -0.16552635f, 0.06005237f, 0.14633185f, -0.32559258f, -0.03821998f, 0.22206947f, 0.06313377f, 
    -0.11376734f, -0.11685675f, -0.05919179f, 0.08559589f, 0.24322568f, 0.22910830f, 0.24332310f, -0.14717971f, 
    -0.01905057f, 0.02713135f, -0.01616512f, -0.18833463f, -0.06182944f, -0.06526809f, -0.11410281f, -0.21328823f, 
    -0.08920821f, -0.22138542f, 0.19694796f, 0.01208308f, 0.04194703f, 0.07206874f, 0.04213732f, 0.11450601f, 
    0.28055719f, -0.07238732f, 0.01152259f, -0.08257362f, 0.03501840f, -0.08262192f, -0.01629044f, 0.06646639f, 
    0.13024586f, 0.08251191f, -0.06954802f, -0.10471958f, 0.00548021f, 0.10251100f, -0.01180916f, 0.18767723f, 
    0.17308708f, 0.09590428f, 0.12351712f, -0.11925390f, 0.07232030f, 0.06045014f, -0.11707432f, -0.03192732f, 
    0.02104392f, 0.08535562f, -0.03731101f, 0.03850376f, -0.06982568f, -0.04644297f, -0.16377874f, -0.07221303f, 
    0.01230024f, 0.10623339f, 0.07224792f, -0.00147422f, -0.17163613f, 0.07606184f, 0.02802975f, 0.21791670f, 
    -0.15850957f, 0.12280539f, -0.17271386f, 0.09938416f, -0.10062280f, -0.22685181f, -0.07817148f, 0.10142711f, 
    -0.05630071f, -0.15198028f, 0.05515094f, -0.10683819f, 0.20093846f, -0.04133362f, 0.04222232f, 0.25007638f, 
    0.03873057f, -0.11247484f, 0.02186252f, -0.12542042f, 0.06574629f, 0.16807087f, -0.07222602f, -0.07992759f, 
    -0.04090414f, 0.06505533f, 0.01083330f, -0.02659190f, -0.05615915f, -0.06287987f, 0.00228867f, 0.15665269f, 
    -0.07760181f, 0.17960064f, -0.01575132f, 0.12277745f, 0.10742718f, 0.12194455f, -0.02532429f, 0.00478470f, 
    -0.21336392f, -0.06270289f, 0.23261462f, -0.05401534f, -0.07280587f, 0.04479656f, 0.03919432f, 0.06189465f, 
    0.03972945f, 0.04826235f, -0.00079876f, -0.04105578f, -0.05463939f, -0.05739307f, 0.00947366f, 0.01082719f, 
    -0.03145754f, 0.00841431f, -0.01252176f, 0.04752566f, 0.04455034f, 0.02405209f, 0.03317240f, -0.02098776f, 
    -0.03706981f, -0.02397439f, -0.05005280f, -0.00302934f, -0.02053497f, -0.00124796f, 0.01995470f, 0.04483238f, 
    0.01037527f, -0.02877846f, 0.00836938f, 0.03522552f, -0.06787683f, -0.04721274f, -0.01857615f, -0.03420747f, 
    0.00292650f, 0.04050606f, -0.05923324f, -0.00110584f, 0.04112132f, -0.03988943f, 0.02111407f, 0.02981685f, 
    -0.06540692f, -0.04489945f, 0.00589505f, -0.03574160f, -0.00423164f, 0.04356596f, -0.05643404f, -0.04507400f, 
    -0.01841982f, -0.00280735f, 0.01894168f, -0.05076298f, -0.04940781f, -0.00903040f, 0.03158531f, 0.03884672f, 
    -0.04795645f, -0.06692065f, -0.00399628f, -0.02305439f, 0.03549910f, -0.05560580f, 0.02384857f, -0.04774188f, 
    -0.05334374f, 0.00906758f, -0.05902620f, 0.02869582f, -0.05630887f, 0.05111886f, 0.01880107f, -0.02194116f, 
    0.00189685f, -0.02539728f, 0.02371462f, 0.01894758f, -0.02236674f, -0.05144757f, 0.03283433f, 0.04736738f, 
    0.01277335f, 0.01390639f, -0.02814013f, -0.05816270f, -0.05963770f, 0.01348159f, -0.05886759f, -0.02508038f, 
    -0.05718807f, -0.00504421f, 0.03447321f, 0.02480700f, -0.02142510f, -0.04263526f, 0.03095532f, 0.04143519f, 
    -0.03982616f, -0.01101307f, 0.03061596f, 0.01582320f, -0.03212560f, 0.01061385f, -0.00080070f, -0.03454643f, 
    -0.01211890f, 0.03291155f, -0.06307045f, -0.00667712f, 0.04113503f, -0.02512470f, 0.04722474f, -0.06164764f, 
    0.04014145f, 0.03621495f, -0.06790912f, 0.01500216f, -0.04431434f, -0.05995538f, -0.00859893f, -0.01739803f, 
    -0.03556419f, 0.00957376f, -0.04464585f, -0.01163389f, 0.03077479f, -0.00241621f, -0.06334383f, -0.03391675f, 
    -0.02458073f, 0.01710137f, 0.00794365f, -0.05300194f, 0.00328983f, -0.04895583f, 0.00408278f, -0.01537054f, 
    -0.03024348f, -0.05986904f, -0.06175056f, 0.03092805f, 0.04159628f, 0.00434675f, -0.02750089f, 0.00719249f, 
    0.02565451f, 0.03346571f, -0.05256833f, -0.04502366f, 0.00774359f, 0.04516385f, 0.04466327f, -0.01775320f, 
    -0.00552894f, -0.03142376f, 0.01175108f, 0.02603365f, -0.01436081f, -0.06403472f, -0.03023434f, -0.04726384f, 
    0.03627145f, 0.01998426f, -0.00877542f, -0.00415768f, -0.05840346f, -0.04096729f, -0.03061090f, 0.01433455f, 
    -0.04560799f, -0.06147758f, -0.05968039f, -0.00203253f, 0.01654912f, 0.05502430f, -0.01376774f, -0.00792384f, 
    -0.06269044f, -0.03673466f, 0.03001349f, -0.01720777f, 0.01273450f, -0.04225792f, -0.05012825f, 0.01888769f, 
    0.04640358f, -0.01798549f, 0.02132077f, -0.02083051f, -0.00055156f, -0.01713397f, 0.00155386f, -0.05522960f, 
    -0.02379564f, 0.04150669f, 0.02603705f, -0.02457958f, -0.01053153f, -0.00607628f, 0.02791206f, -0.03356250f, 
    -0.03182525f, -0.05153172f, 0.00984425f, 0.03686998f, -0.06428222f, 0.03797015f, 0.02942455f, 0.03028371f, 
    0.03459052f, 0.00018294f, -0.05263957f, -0.04651167f, -0.00117931f, -0.03762190f, 0.01564321f, 0.01822909f, 
    0.01248856f, -0.04102367f, -0.01949407f, 0.03558035f, -0.00770464f, -0.00738881f, -0.01872922f, -0.02293911f, 
    -0.06562601f, 0.01973714f, 0.00310641f, -0.00080178f, -0.04265316f, -0.04961954f, -0.04597909f, -0.00555289f, 
    0.03174823f, -0.02852292f, 0.01014033f, -0.05982113f, -0.01644456f, 0.03941162f, -0.01906333f, -0.03766021f, 
    0.02517842f, -0.03501288f, 0.04221366f, -0.00475298f, 0.00177102f, 0.01103400f, -0.04062397f, 0.04248739f, 
    0.00358880f, -0.01397954f, -0.06772874f, 0.00448469f, -0.01109600f, 0.04561023f, 0.02418980f, 0.00798588f, 
    0.03108473f, -0.01068610f, -0.01739700f, -0.00745308f, 0.02161118f, -0.01796592f, 0.01387999f, -0.02869194f, 
    0.02120400f, 0.04313526f, -0.01590621f, -0.00362478f, -0.05665307f, 0.03624446f, 0.02068086f, -0.02945387f, 
    0.02436078f, -0.04170858f, -0.00766830f, -0.00587916f, 0.04487354f, 0.00804981f, 0.01361472f, 0.04371214f, 
    -0.02601672f, -0.00510703f, 0.02813067f, 0.02230209f, -0.01610565f, -0.03654537f, -0.02170836f, 0.03634939f, 
    -0.07073191f, -0.05166350f, 0.02902851f, 0.09299764f, 0.05011769f, -0.00278010f, -0.11465174f, -0.01023952f, 
    0.08892648f, -0.17966993f, 0.20391232f, -0.12497365f, -0.13399543f, -0.02567621f, -0.12178186f, 0.14530145f, 
    -0.06180813f, -0.08216240f, -0.33481011f, -0.23642714f, -0.17295197f, 0.03135104f, -0.01233640f, -0.11920591f, 
    0.03771641f, 0.03309819f, 0.03371006f, 0.11750561f, 0.04373067f, -0.01797869f, -0.12507646f, 0.18670051f, 
    0.06960695f, -0.02346648f, -0.03123608f, 0.02855546f, 0.01058443f, 0.01289824f, 0.02104510f, -0.18023273f, 
    0.04302811f, -0.05263352f, -0.08970835f, 0.06345163f, 0.29433075f, -0.10638381f, -0.07364631f, -0.09986015f, 
    0.06326604f, -0.09951819f, -0.19656317f, -0.22825164f, 0.03977579f, 0.13147734f, -0.05988584f, 0.03025955f, 
    -0.18673395f, -0.09970327f, 0.05444707f, -0.04182570f, 0.14082898f, 0.07089313f, 0.15125678f, 0.09377307f, 
    0.07638680f, 0.07397223f, -0.14976773f, -0.02191478f, -0.07066903f, 0.21643905f, 0.15287958f, 0.06933437f, 
    -0.20996414f, 0.09257404f, 0.03876822f, 0.11780147f, -0.06019671f, 0.05228039f, 0.04643854f, 0.00649166f, 
    0.12997858f, 0.03874822f, 0.12384874f, 0.20465073f, 0.06336360f, -0.04715854f, -0.01634762f, 0.11800186f, 
    0.00130750f, -0.07217498f, -0.53194064f, -0.13105817f, 0.28317636f, -0.12325249f, 0.11019136f, -0.19900192f, 
    0.09208328f, 0.00413535f, -0.33872053f, 0.07806198f, 0.17377658f, -0.22966185f, -0.03034923f, 0.05894317f, 
    0.00629987f, 0.09441061f, -0.10805254f, 0.11006757f, -0.08388673f, -0.11770259f, 0.03789003f, 0.09366652f, 
    -0.04149049f, -0.01002357f, 0.02087262f, 0.01724204f, -0.01560209f, 0.02520829f, -0.03716652f, 0.26007134f, 
    0.00512314f, 0.09645783f, -0.02775107f, 0.05843839f, -0.08512882f, -0.12841013f, 0.01338143f, 0.10691088f, 
    -0.05064275f, 0.00346383f, -0.03246770f, -0.01202418f, -0.10029250f, 0.01541572f, 0.03701661f, -0.05993449f, 
    0.04998874f, 0.21575652f, -0.08702528f, -0.11560245f, -0.01030291f, -0.05058295f, 0.01727098f, -0.06120825f, 
    0.18055220f, 0.07209732f, -0.04851556f, 0.15624695f, 0.01270613f, 0.04216188f, 0.03056728f, 0.02397984f, 
    -0.04343237f, -0.11494910f, 0.08664373f, 0.24189009f, -0.07647545f, 0.14631374f, -0.07293118f, 0.00988477f, 
    0.09530229f, -0.12609510f, 0.08793765f, 0.16554150f, 0.00666144f, -0.03666824f, 0.02116810f, -0.01453740f, 
    -0.06074787f, 0.05192599f, 0.04637462f, 0.10502984f, 0.21243896f, 0.17507757f, -0.02269160f, -0.12036862f, 
    0.11402003f, -0.14598536f, -0.08973940f, -0.04756466f, 0.01556583f, 0.09004378f, -0.32079005f, -0.06900281f, 
    0.04803245f, 0.05949131f, 0.08554492f, -0.08899889f, -0.00180191f, 0.00767010f, 0.12655583f, 0.01563826f, 
    0.12971629f, 0.04207213f, 0.16432749f, -0.24921212f, -0.04471160f, -0.01465918f, 0.09250550f, 0.08692671f, 
    -0.13154046f, 0.06938307f, -0.02452584f, 0.01232068f, 0.17095463f, 0.01369469f, -0.08443595f, -0.51353413f, 
    -0.03081868f, -0.38578171f, 0.07280376f, 0.04257330f, -0.01336589f, 0.09237309f, -0.05657632f, -0.06626052f, 
    -0.01880100f, -0.12509070f, -0.28096661f, 0.02414228f, 0.05345446f, 0.02167758f, -0.05624377f, -0.07028405f, 
    -0.10595965f, -0.30107275f, 0.05807211f, -0.16123469f, 0.16711375f, 0.06509867f, 0.00238111f, 0.09624169f, 
    -0.06763821f, -0.06775421f, -0.09040204f, 0.00850151f, -0.01696326f, -0.11931179f, 0.05625680f, 0.11001479f, 
    -0.11227211f, -0.15542538f, 0.05308174f, 0.11056424f, -0.12833811f, -0.10469463f, 0.06580073f, 0.21229769f, 
    0.04169261f, -0.03730056f, -0.07557484f, 0.10572649f, -0.15756617f, 0.05833273f, 0.18702248f, -0.10280888f, 
    0.00076888f, -0.00732338f, -0.14095344f, 0.13722479f, -0.15910645f, 0.15187246f, 0.00731900f, -0.15751486f, 
    -0.01479263f, -0.06073850f, -0.02342435f, 0.15068175f, 0.08029768f, 0.04884159f, -0.04951159f, 0.00406923f, 
    0.02294763f, -0.04219716f, 0.19378573f, 0.13020822f, 0.09724174f, 0.17335878f, 0.05675015f, -0.02230866f, 
    0.11158970f, 0.06417076f, -0.12958311f, 0.00704391f, 0.16625014f, 0.17127901f, -0.01207520f, -0.06514544f, 
    0.22984090f, -0.08281817f, 0.11124471f, 0.11879738f, 0.09657487f, -0.15007444f, -0.14995372f, -0.19447227f, 
    -0.00238956f, -0.19347432f, 0.08463375f, 0.16209888f, -0.02584014f, -0.00168404f, 0.28324103f, 0.06302530f, 
    0.18938015f, 0.07055929f, 0.06931960f, -0.07923926f, 0.07013996f, -0.06215213f, 0.04517389f, -0.16263588f, 
    -0.04602309f, 0.14652926f, -0.10963318f, -0.18896537f, -0.03045473f, 0.00074656f, -0.03691509f, -0.14243796f, 
    0.03934432f, 0.06719945f, -0.01408770f, 0.13728315f, -0.06167029f, -0.18705827f, -0.01239951f, 0.00915979f, 
    -0.02397482f, 0.00060181f, -0.09968693f, -0.00922074f, 0.07756852f, 0.10015532f, -0.29616529f, 0.00840175f, 
    -0.16047810f, 0.07888092f, -0.12323844f, 0.00796279f, -0.00461921f, 0.01211734f, -0.00241154f, 0.03895934f, 
    0.23258543f, -0.10974887f, -0.21918289f, 0.24284342f, 0.01014887f, 0.06233506f, 0.04560298f, 0.15891470f, 
    -0.11896815f, 0.05267071f, -0.11295558f, 0.04632847f, 0.13581276f, 0.11367961f, -0.24588925f, 0.01707291f, 
    -0.04776474f, -0.22906646f, -0.32249349f, -0.16504583f, 0.14376484f, -0.04923379f, 0.02452896f, 0.03193532f, 
    -0.06707803f, -0.00670176f, -0.07073724f, 0.08776565f, 0.06973387f, -0.02797718f, 0.08479141f, 0.00298699f, 
    -0.01804153f, 0.12771145f, 0.00705747f, 0.09399232f, 0.17346229f, -0.20743096f, 0.04601806f, -0.16694842f, 
    -0.01075001f, 0.04271335f, 0.19719982f, -0.22480519f, 0.10664545f, 0.08936601f, 0.08804188f, -0.16521277f, 
    -0.11509383f, 0.03175609f, 0.11068397f, 0.06375196f, -0.00381521f, -0.21748257f, 0.05982873f, -0.02944387f, 
    0.01922791f, -0.02907250f, -0.08154730f, -0.10408187f, -0.03154106f, 0.17448890f, 0.26922929f, -0.13520283f, 
    -0.01603477f, -0.12944481f, 0.02406229f, -0.14854026f, -0.04386955f, 0.14493209f, -0.20334734f, -0.01464559f, 
    0.18967177f, 0.08207289f, 0.03492873f, -0.04604235f, 0.02876057f, -0.00779813f, 0.25293347f, 0.02822105f, 
    0.07530822f, -0.08276524f, 0.07552879f, -0.03683166f, -0.13620684f, -0.08258632f, 0.04571467f, 0.07794540f, 
    0.17699388f, -0.00088491f, 0.13341105f, -0.05335140f, 0.28918841f, 0.12620851f, -0.06830105f, -0.08900849f, 
    -0.08570878f, -0.18477097f, 0.04551756f, 0.08834203f, 0.02180232f, 0.01937084f, 0.10753716f, -0.03645662f, 
    -0.04053633f, -0.04843271f, 0.02499238f, -0.00888838f, 0.06305362f, -0.01324941f, -0.14684209f, 0.07154877f, 
    -0.13381493f, -0.00790276f, 0.12800407f, -0.38323966f, -0.02992314f, 0.25843138f, 0.01124930f, 0.00001423f, 
    0.15688348f, 0.13365254f, -0.06662221f, 0.06797235f, 0.09518430f, -0.20859222f, 0.02669400f, -0.00257825f, 
    -0.04555117f, -0.19273598f, 0.15027337f, -0.05072453f, 0.02032474f, 0.06560581f, 0.20859694f, -0.10850314f, 
    -0.10040767f, -0.14638698f, 0.02452109f, -0.02724989f, -0.01697046f, -0.07481631f, -0.10265202f, -0.15118419f, 
    0.03931282f, -0.02940931f, 0.12483844f, 0.06873825f, 0.14031051f, -0.07458220f, 0.07338663f, 0.04107165f, 
    -0.17421207f, 0.05216426f, -0.03518625f, -0.00188072f, 0.09223894f, -0.01680233f, -0.03482795f, -0.02159252f, 
    0.13406466f, -0.20242304f, 0.25369334f, 0.02267091f, -0.15250236f, -0.01000484f, 0.14619061f, 0.10769694f, 
    -0.00077202f, 0.10761626f, -0.21859315f, 0.30300292f, 0.17423151f, -0.02466590f, 0.02223128f, -0.13873327f, 
    -0.03688414f, -0.00687470f, 0.15112880f, -0.08654520f, 0.21382795f, -0.07657588f, -0.06186498f, -0.21688646f, 
    -0.03860072f, -0.09969291f, 0.08204041f, 0.14360331f, 0.11804815f, -0.09559084f, -0.11666924f, -0.10582166f, 
    -0.08444449f, -0.07188540f, -0.08763054f, -0.00467228f, -0.13235559f, 0.13215905f, 0.04235570f, -0.04723504f, 
    0.08864073f, 0.17802218f, -0.11332693f, 0.01650199f, 0.08478466f, 0.04870196f, 0.20841049f, 0.22745366f, 
    -0.02960977f, 0.00687076f, 0.04334484f, -0.18802609f, -0.10226823f, 0.05604746f, 0.25456065f, 0.08565097f, 
    0.08586687f, -0.01163012f, -0.10502318f, -0.08689417f, -0.00019566f, -0.16334911f, 0.05450704f, -0.21861754f, 
    0.04160189f, 0.10352750f, 0.09635009f, 0.03939314f, 0.25763676f, 0.02864896f, 0.00538009f, 0.01388149f, 
    0.13411434f, -0.03246159f, 0.01569861f, 0.11975332f, 0.10676979f, -0.09212865f, 0.01967439f, 0.04447944f, 
    0.04701441f, 0.10583572f, 0.13828889f, -0.03219046f, -0.02441233f, 0.06212435f, -0.08222416f, 0.10900577f, 
    0.01606138f, -0.07203199f, 0.21571311f, -0.07174300f, 0.09832069f, -0.19738008f, 0.07101854f, -0.20556524f, 
    0.01809010f, -0.12221961f, -0.04768221f, -0.17023857f, -0.12581278f, -0.11752574f, -0.07297444f, 0.03750278f, 
    -0.03441917f, 0.04616245f, -0.16499650f, 0.09830973f, -0.02845070f, -0.12003555f, 0.01334693f, -0.07754910f, 
    -0.15435833f, -0.07953332f, -0.05705722f, 0.14089526f, -0.02247478f, 0.08496632f, -0.08078962f, -0.14320159f, 
    -0.03027514f, -0.06990805f, -0.01338557f, -0.04318795f, -0.08153524f, -0.11456067f, 0.12617695f, 0.06347165f, 
    0.04374864f, -0.04432174f, 0.08858609f, 0.00843681f, -0.12330646f, 0.10643417f, -0.13190100f, -0.38565686f, 
    0.13744740f, -0.03048127f, 0.06084921f, 0.25993654f, 0.05567121f, 0.07905933f, 0.10402323f, -0.02192004f, 
    0.00155903f, -0.08201967f, -0.14865735f, -0.01398187f, 0.09636738f, 0.03521037f, -0.03235360f, -0.14354999f, 
    -0.11865056f, -0.15322353f, -0.00105512f, -0.03364785f, 0.06942888f, 0.11471763f, 0.07249072f, -0.06889581f, 
    -0.00033766f, -0.24870408f, -0.10569065f, -0.00337751f, 0.01724579f, -0.13815518f, 0.08809772f, -0.18050349f, 
    -0.01540950f, 0.04214221f, 0.11149855f, 0.08258518f, 0.03349234f, -0.04161875f, 0.09840208f, -0.02510173f, 
    0.02564411f, 0.01483358f, -0.07802353f, 0.02124706f, 0.16408762f, 0.05484077f, -0.00313859f, -0.08386078f, 
    -0.07219547f, 0.00694204f, 0.00507808f, 0.09631135f, 0.06792262f, 0.08358876f, 0.05065444f, 0.16809446f, 
    0.07741103f, 0.02522408f, -0.05632924f, -0.05689220f, 0.06647881f, -0.05511446f, 0.03215253f, -0.12211523f, 
    0.05370908f, -0.00497420f, 0.06732626f, -0.01353904f, 0.02317445f, -0.01734326f, 0.08231525f, 0.00850295f, 
    0.08652122f, -0.09258086f, 0.00264753f, 0.14677073f, -0.14070259f, 0.11326165f, 0.04722322f, 0.02789076f, 
    0.30097005f, 0.22421281f, 0.14472118f, -0.01722372f, 0.03499527f, 0.09807961f, 0.16902265f, 0.01727871f, 
    0.03059717f, -0.10254344f, -0.00874127f, 0.11985846f, 0.11562959f, -0.09953395f, 0.04908195f, 0.03277925f, 
    -0.16354363f, -0.00433783f, -0.11474456f, 0.02594329f, -0.02433804f, 0.13940759f, -0.01876464f, -0.18212354f, 
    0.00217037f, 0.10618152f, -0.00402934f, -0.27529991f, -0.11010076f, 0.05381555f, 0.10725868f, 0.20849887f, 
    -0.09523951f, 0.17341912f, -0.03815423f, 0.07663790f, -0.00895106f, -0.02611575f, -0.08578476f, -0.04035512f, 
    -0.06988264f, 0.11158355f, -0.02106592f, 0.17185333f, -0.14623182f, 0.08733235f, 0.21789777f, 0.24407771f, 
    -0.08435861f, 0.00524008f, -0.16913942f, 0.04272909f, 0.07261898f, 0.02665067f, 0.01484884f, 0.05609716f, 
    -0.08407447f, 0.04737187f, 0.11135015f, 0.04040923f, -0.04255717f, -0.05965000f, -0.04703166f, 0.09120677f, 
    -0.06152639f, -0.03102279f, 0.06212556f, -0.00570786f, 0.02949802f, -0.02088607f, -0.18555407f, -0.06694941f, 
    0.01260181f, -0.03643063f, -0.00804402f, 0.03475073f, -0.10671555f, 0.05717116f, -0.01413882f, 0.10351173f, 
    -0.05025703f, -0.02774533f, -0.05507058f, 0.07163597f, -0.03439616f, 0.04097911f, 0.02902707f, -0.00697736f, 
    0.02683589f, 0.08371968f, 0.04589624f, -0.08138798f, 0.01057366f, -0.09882978f, 0.08261859f, -0.10813944f, 
    0.02595424f, 0.01621102f, -0.06274648f, 0.20137228f, 0.17151280f, 0.03412406f, -0.02068102f, 0.03686045f, 
    -0.05476707f, 0.11086584f, -0.09134243f, 0.09767704f, -0.34203497f, 0.07195146f, -0.06708460f, 0.10644381f, 
    0.02472252f, 0.04534497f, -0.17351685f, 0.07167636f, -0.12166001f, -0.05363661f, 0.11772003f, 0.27312180f, 
    0.02798199f, -0.04288575f, 0.08710049f, 0.02010296f, 0.16441412f, -0.17091128f, 0.02902622f, 0.03628078f, 
    -0.05307980f, -0.11123385f, 0.04711240f, -0.14971204f, 0.04198903f, -0.00477087f, 0.00312849f, -0.02928319f, 
    0.12936972f, 0.25844604f, 0.14640917f, 0.10415213f, 0.03867803f, -0.05237911f, 0.03428743f, -0.14603823f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07663408f, -0.04015510f, 0.09054621f, -0.05027868f, 0.19597530f, 0.03600545f, -0.03971760f, 0.16256852f, 
    -0.03896932f, 0.01218253f, 0.04741140f, -0.00868883f, 0.06150918f, 0.01239503f, -0.00857101f, -0.06801316f, 
    0.20551617f, 0.07056050f, 0.19164103f, 0.02757210f, -0.05842947f, 0.02637747f, -0.03086705f, 0.09182703f, 
    0.06116823f, 0.02074704f, 0.16350234f, 0.12897624f, -0.02405434f, 0.08051565f, -0.11545369f, 0.02983488f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39435527f, 0.03714468f, 0.38217741f, -0.37234056f, 0.18185426f, -0.02396984f, 0.06891528f, -0.29021254f, 
    0.07126137f, -0.12416250f, -0.12243299f, 0.16075219f, 0.11221577f, -0.12979262f, -0.05951232f, -0.03614005f, 
    -0.15748732f, -0.05875695f, 0.05362124f, 0.14257450f, 0.15443243f, 0.00352737f, -0.04615455f, -0.15768732f, 
    0.46487483f, -0.25694528f, 0.18523887f, -0.04273934f, 0.14970206f, 0.15646078f, -0.37611488f, 0.18390848f, 
    -0.07410665f, 0.42053124f, 0.17291881f, 0.27576518f, 0.09985223f, 0.07246805f, -0.03891566f, -0.08356098f, 
    0.06755067f, 0.23158446f, 0.01105074f, 0.07933351f, -0.03576569f, 0.14107513f, 0.06862441f, -0.13944691f, 
    -0.55897284f, 0.26046032f, -0.02597826f, 0.56143707f, 0.14630707f, 0.12319652f, 0.15140046f, 0.00490255f, 
    0.44396034f, 0.02296891f, -0.23816858f, 0.06500311f, 0.00854543f, 0.42730078f, -0.08035616f, 0.00619384f, 
    0.12005194f, -0.02126675f, -0.14791662f, 0.04958333f, 0.04170217f, -0.17016757f, -0.07393385f, -0.05690332f, 
    0.01297077f, -0.06168645f, 0.02374616f, -0.04953559f, -0.09810186f, 0.03736072f, -0.00626656f, 0.13971075f, 
    -0.15205787f, 0.05676425f, -0.15000498f, -0.01711804f, 0.03778231f, 0.12640129f, 0.04281464f, -0.00705109f, 
    0.10917284f, -0.19413754f, 0.00293664f, -0.05849765f, 0.14272907f, -0.08192776f, -0.05953168f, -0.06856085f, 
    -0.27553460f, 0.02227837f, 0.17976899f, -0.01396425f, 0.06340931f, 0.08562927f, -0.06141293f, 0.43332195f, 
    0.04341943f, 0.40962002f, -0.07399338f, 0.02702648f, -0.00493048f, -0.03799547f, 0.03879876f, 0.00752705f, 
    -0.10855867f, 0.21932712f, -0.21659891f, 0.23097250f, 0.00285806f, -0.01968724f, 0.15074284f, 0.57845747f, 
    0.06526240f, -0.34482467f, 0.18047157f, 0.09307261f, -0.03201119f, 0.38829386f, -0.28640777f, -0.08731709f, 
    0.10285928f, -0.05594341f, -0.06270767f, 0.02751773f, -0.14946713f, -0.06701397f, -0.11546502f, -0.17805244f, 
    0.14129953f, -0.14561020f, -0.04623506f, 0.02162759f, 0.07597201f, 0.05574640f, -0.08313676f, 0.12240604f, 
    0.01955123f, 0.17133881f, 0.01615419f, -0.05771125f, -0.05730404f, -0.02161578f, 0.02787224f, -0.02520513f, 
    0.26287937f, 0.06895806f, -0.18585260f, 0.11681965f, 0.10991587f, -0.06794856f, -0.07969111f, 0.03155368f, 
    -0.22417305f, 0.37162921f, 0.20499986f, 0.14187329f, -0.01108877f, 0.12765764f, 0.07177597f, -0.33076328f, 
    -0.12895510f, -0.34648466f, 0.10338984f, -0.02760193f, 0.02692444f, 0.04394123f, -0.05471131f, -0.11747024f, 
    0.25058714f, -0.27343142f, 0.10245912f, 0.18369162f, -0.06601008f, -0.17021047f, 0.10622928f, 0.52182698f, 
    -0.13967645f, 0.37298843f, -0.12038944f, 0.22264396f, -0.02760054f, -0.29898277f, -0.18066685f, -0.15509850f, 
    -0.12768802f, -0.65934610f, 0.24096178f, -0.01266469f, 0.29252315f, -0.17996144f, -0.07146589f, -0.33734393f, 
    0.11456032f, 0.56088763f, 0.08082516f, -0.15541287f, 0.01929573f, -0.16743381f, 0.19466951f, -0.14793728f, 
    0.28408843f, 0.25405648f, -0.00015591f, -0.16267762f, -0.11016107f, -0.04026427f, 0.06925302f, 0.04232716f, 
    -0.19823772f, -0.54285192f, 0.41567472f, 0.21677323f, 0.15088008f, -0.48680857f, -0.32969895f, 0.09559734f, 
    0.01999505f, -0.00605457f, 0.07887949f, 0.00723387f, -0.16605000f, 0.13080184f, -0.07424720f, 0.06799744f, 
    0.02679814f, -0.07204940f, -0.10622922f, -0.03474906f, -0.12808526f, 0.07590852f, 0.07093877f, 0.07068086f, 
    0.09341673f, -0.10693325f, -0.20139013f, 0.08377135f, -0.13134854f, 0.04189363f, -0.17037913f, -0.00653070f, 
    -0.17766652f, -0.09169503f, -0.04238963f, -0.15985903f, -0.02656876f, -0.19219072f, 0.00333819f, 0.02879547f, 
    -0.20434631f, -0.19986086f, 0.04045253f, -0.18922152f, 0.00976279f, 0.08555343f, -0.12431819f, -0.19415951f, 
    0.13181837f, -0.10978163f, 0.02629115f, 0.08970217f, 0.07252044f, 0.02684257f, 0.41230589f, -0.05081478f, 
    -0.23962910f, 0.16610673f, 0.18730904f, 0.42439774f, -0.02440204f, 0.13494682f, -0.12013105f, -0.26498371f, 
    0.35473120f, 0.90260857f, -0.07774457f, 0.27038169f, -0.06158106f, -0.19540682f, -0.52141505f, -0.20534115f, 
    -0.00182233f, 0.01391507f, -0.30219269f, 0.27942026f, -0.03287119f, -0.02660383f, -0.11714929f, -0.24594605f, 
    -0.04536201f, -0.43862593f, 0.09192691f, -0.12918003f, 0.41100562f, -0.14109433f, 0.30424643f, -0.12724330f, 
    0.14465132f, -0.04625118f, 0.27865353f, -0.14122726f, -0.05348424f, -0.06151431f, 0.08821566f, -0.45208168f, 
    -0.20087038f, 0.06813125f, 0.22292747f, 0.00976076f, -0.10893396f, -0.29129249f, 0.38274741f, 0.43235105f, 
    0.07891601f, -0.06818614f, 0.04791785f, -0.14047070f, -0.10431513f, -0.08298091f, -0.13436390f, -0.11110735f, 
    -0.08372724f, 0.02530157f, -0.17559744f, 0.10926452f, 0.01943423f, -0.00754104f, -0.11759169f, -0.13051070f, 
    0.06129964f, 0.01158627f, -0.12185438f, -0.09467912f, -0.15103996f, 0.16171794f, -0.05474220f, -0.06930969f, 
    -0.00801214f, -0.09048405f, -0.03831047f, -0.02615176f, 0.00656724f, 0.00996840f, -0.04455758f, 0.01784038f, 
    -0.62830818f, -0.19504733f, 0.49089801f, -0.30779159f, 0.19225156f, -0.16132160f, -0.16089812f, 0.01150742f, 
    -0.12441701f, 0.12661704f, -0.12950473f, -0.01588397f, -0.03950050f, -0.09626818f, 0.19657911f, 0.01971408f, 
    -0.09996712f, -0.11976221f, -0.06866885f, 0.22325779f, -0.16175537f, 0.15885483f, 0.19016030f, 0.11221471f, 
    -0.11621892f, 0.05152923f, 0.36928320f, 0.14226615f, -0.14900805f, 0.03578507f, -0.37421355f, -0.10750683f, 
    -0.13016519f, -0.21961792f, -0.09425331f, 0.03049885f, 0.06578301f, -0.04423027f, 0.11131672f, 0.33162671f, 
    -0.06953683f, 0.16262983f, -0.08178758f, 0.03776735f, 0.09800688f, 0.02365498f, 0.05097471f, 0.13767596f, 
    -0.51226389f, -0.02685612f, 0.25921538f, -0.14827605f, -0.10626729f, -0.15979530f, -0.17472731f, -0.17385824f, 
    -0.29059565f, 0.05332854f, -0.14424494f, 0.06945699f, 0.17622443f, -0.05121738f, 0.07951287f, 0.31379524f, 
    -0.15406556f, -0.17095895f, -0.09884863f, 0.05365182f, -0.08489048f, 0.15875319f, -0.12674004f, -0.11125242f, 
    -0.13986517f, -0.02587441f, -0.10450502f, 0.03161979f, -0.01884272f, -0.07821983f, 0.00586412f, 0.01620580f, 
    0.09921756f, -0.01965307f, 0.12162244f, -0.06308112f, 0.15506841f, -0.12143200f, -0.12506984f, -0.07283093f, 
    -0.09891756f, -0.08420424f, -0.15889800f, -0.12400821f, -0.02562844f, -0.14543770f, -0.04693707f, -0.11679092f, 
    0.53232586f, 0.30188593f, -0.05248449f, 0.01507560f, 0.29932502f, 0.05880438f, 0.14402716f, -0.06779596f, 
    -0.02310839f, 0.49906832f, -0.16214462f, 0.13586043f, -0.50211114f, 0.01584458f, -0.22360790f, -0.16509871f, 
    -0.09488975f, 0.35434771f, -0.06382574f, 0.21150826f, -0.03930596f, 0.10639153f, -0.15971346f, 0.28147012f, 
    -0.03350877f, 0.17199089f, 0.23259188f, 0.34682870f, -0.14053409f, -0.21503879f, -0.36933765f, -0.33638501f, 
    0.09445643f, -0.18681206f, 0.03561108f, -0.12268736f, 0.05107420f, -0.16595662f, 0.06999593f, -0.22121263f, 
    -0.12327059f, 0.08585919f, 0.11959805f, 0.06669557f, -0.16596952f, -0.11761070f, 0.04171507f, 0.09560481f, 
    -0.05615226f, -0.17231090f, -0.15380426f, 0.12287320f, 0.09588865f, -0.04048732f, 0.05086143f, -0.17247126f, 
    0.03611573f, 0.07256515f, -0.03290545f, -0.11662241f, 0.16812094f, -0.06132711f, -0.02620560f, -0.14977367f, 
    -0.03225405f, -0.07765880f, 0.30762747f, -0.46559402f, 0.27935517f, -0.09897210f, -0.03060510f, 0.50118923f, 
    -0.07289188f, 0.11926056f, 0.12138498f, 0.11693321f, -0.16085215f, -0.11963096f, 0.09809529f, 0.00645604f, 
    0.25498062f, -0.20416667f, 0.35010001f, 0.11466862f, 0.12111434f, -0.17345138f, -0.14005940f, 0.16098388f, 
    -0.06665786f, 0.60512060f, -0.02271636f, 0.04331589f, 0.03611536f, 0.26613906f, -0.46270564f, -0.28260508f, 
    -0.39882034f, 0.08746907f, 0.01916540f, -0.02926894f, -0.09281714f, -0.10611969f, 0.13063039f, 0.32279757f, 
    0.14366776f, -0.42764691f, 0.16851789f, 0.02731227f, 0.46115631f, -0.04379289f, 0.21243423f, 0.07254107f, 
    -0.28095931f, -0.29532579f, -0.02437119f, 0.09096248f, 0.08452502f, -0.06996216f, 0.03607242f, -0.06537417f, 
    0.14361858f, -0.02239753f, 0.07991409f, 0.11171861f, -0.06449313f, 0.03324093f, 0.38130504f, 0.30391356f, 
    0.50715500f, 0.51743287f, -0.28074086f, 0.06237623f, 0.02326809f, -0.01138526f, -0.10007071f, 0.35889271f, 
    0.11320379f, -0.03794968f, 0.10874223f, -0.04812864f, -0.27698979f, -0.08782993f, -0.09139688f, 0.13613413f, 
    0.22045219f, 0.12770171f, 0.28471899f, 0.06633207f, 0.08356858f, 0.16254719f, 0.14481990f, 0.05950193f, 
    -0.38015419f, 0.05714030f, -0.14473228f, 0.18838543f, 0.13556188f, -0.06433228f, -0.13597228f, -0.01935518f, 
    -0.35627162f, -0.26263419f, -0.14331172f, 0.56870288f, 0.26260719f, 0.08275993f, -0.00058574f, -0.24638030f, 
    0.12452207f, 0.01175853f, -0.10677928f, -0.06050395f, 0.25425681f, 0.11377737f, -0.04269667f, -0.15946762f, 
    0.32857946f, 0.33596244f, 0.10416438f, 0.01601032f, -0.06546354f, -0.13413960f, -0.06371154f, -0.18257079f, 
    0.50464326f, -0.63372308f, 0.08085206f, -0.21984394f, 0.01190789f, 0.42869285f, 0.25322425f, 0.13818790f, 
    0.00982513f, 0.05528687f, -0.20631807f, -0.10250563f, 0.06144527f, -0.08877875f, 0.12603787f, -0.01859763f, 
    0.10862160f, -0.13093339f, 0.01079271f, -0.05877789f, 0.11585312f, -0.04407808f, 0.03726456f, -0.11868039f, 
    0.09842835f, 0.05844335f, -0.17667115f, -0.17590165f, 0.02305013f, -0.00283794f, 0.00057920f, -0.00090842f, 
    -0.11640406f, -0.17896496f, -0.10138220f, 0.06140779f, -0.15641247f, -0.07027623f, -0.18222044f, 0.03549202f, 
    -0.00861648f, 0.56711072f, 0.24303728f, -0.03362092f, -0.10141141f, 0.15099750f, -0.14404806f, 0.07493495f, 
    0.07923431f, -0.65838206f, -0.06579572f, 0.09474038f, 0.00637121f, 0.12006273f, -0.12194274f, -0.16526443f, 
    -0.03410357f, -0.18347737f, 0.05300912f, 0.26521838f, -0.11697626f, -0.07999185f, 0.16001597f, 0.03841742f, 
    -0.34693658f, -0.28878629f, 0.34622687f, 0.19906536f, -0.06399322f, -0.15612641f, -0.28881395f, 0.08043432f, 
    -0.23699459f, -0.08104759f, 0.30414146f, -0.20982337f, 0.02879661f, -0.00213968f, 0.14993347f, 0.29966420f, 
    -0.13191250f, -0.34100056f, -0.09037458f, 0.04801399f, 0.52065349f, -0.16910931f, 0.18222323f, 0.07649735f, 
    0.19617099f, -0.42222381f, 0.18369420f, -0.07566665f, -0.02502614f, 0.09637049f, 0.15562861f, -0.24786580f, 
    -0.12625654f, -0.13396268f, 0.23492761f, -0.20489787f, 0.15035202f, -0.03961299f, 0.24696532f, 0.41044644f, 
    0.06103744f, 0.01927309f, 0.12095188f, -0.38055554f, -0.10626297f, 0.00655096f, -0.00672190f, -0.14078468f, 
    -0.12041461f, 0.23720457f, 0.02782771f, 0.03192460f, 0.15313846f, -0.02253406f, -0.19562067f, -0.14743182f, 
    0.13456064f, -0.30097505f, 0.09614379f, -0.11790053f, 0.17016815f, -0.12289721f, 0.10791718f, 0.02097786f, 
    0.15500320f, 0.01461950f, -0.07516890f, 0.12030559f, -0.04288083f, 0.03236159f, 0.46397984f, 0.11053021f, 
    0.13213038f, 0.04219223f, -0.13593602f, -0.01581633f, -0.13981710f, 0.17006835f, -0.11879441f, -0.18692097f, 
    -0.08328178f, -0.02693023f, 0.09322081f, -0.11876091f, 0.10764459f, -0.12597719f, -0.15175149f, -0.01156564f, 
    0.14065097f, -0.06320807f, 0.01556140f, 0.06088493f, 0.06142013f, 0.10272825f, -0.00136007f, 0.10903194f, 
    -0.03154101f, -0.12537931f, -0.14741705f, -0.10781933f, -0.05002880f, 0.10205388f, -0.03254111f, -0.17429678f, 
    0.46010756f, -0.11622100f, -0.43692794f, 0.12851946f, -0.01589413f, -0.13541566f, 0.10162783f, -0.15542801f, 
    -0.08270653f, 0.30852804f, 0.14297122f, -0.15037404f, -0.19502121f, -0.10911508f, -0.15354748f, 0.11166011f, 
    0.26038191f, 0.54653728f, 0.12358712f, 0.04803444f, 0.16433242f, -0.08703193f, -0.13720986f, 0.36642873f, 
    -0.20375773f, -0.19582485f, 0.20835117f, 0.32828334f, -0.09179966f, 0.15176141f, -0.38794708f, -0.25423768f, 
    0.22429033f, 0.24602929f, -0.37725207f, -0.04915918f, 0.25656977f, 0.02799305f, -0.14011261f, -0.24344017f, 
    -0.12726592f, -0.17716347f, -0.12455063f, 0.07388684f, 0.11699454f, -0.13674682f, -0.05122523f, -0.16697684f, 
    0.19784409f, 0.26833820f, 0.40946817f, -0.13072512f, -0.08888319f, -0.07951856f, 0.00141744f, -0.31854761f, 
    -0.33507898f, -0.20027077f, -0.05397314f, 0.39592847f, 0.01102013f, -0.35624278f, -0.00528715f, 0.20386922f, 
    -0.20246843f, 0.40794528f, 0.00533194f, 0.21638094f, -0.04734859f, -0.13623573f, -0.03439939f, 0.06627525f, 
    -0.14149205f, -0.23462428f, -0.03961954f, -0.09624112f, 0.10331330f, -0.09060429f, 0.30313778f, -0.05830625f, 
    -0.49039838f, 0.26110163f, -0.03727935f, 0.47674024f, -0.03523914f, -0.06073180f, 0.00973376f, -0.06574930f, 
    0.52638412f, -0.34795216f, -0.14280222f, 0.07970068f, -0.15128915f, 0.24782027f, 0.05828016f, 0.00684169f, 
    0.00925908f, -0.48311585f, -0.22985023f, -0.32724670f, -0.07885808f, -0.16574761f, -0.04905440f, 0.01362271f, 
    0.01478478f, -0.36647105f, 0.06213427f, 0.03904450f, 0.37570971f, -0.14700675f, 0.17075463f, 0.14108239f, 
    0.36013681f, -0.01009418f, 0.20531006f, 0.05893850f, -0.16595513f, 0.07854528f, 0.09492631f, -0.12571190f, 
    0.12335431f, 0.45171240f, 0.29065347f, 0.34237853f, -0.16298710f, -0.52386498f, -0.09251949f, 0.19339672f, 
    -0.10883557f, 0.12496226f, -0.15407884f, -0.15720971f, -0.13739851f, -0.11394221f, 0.07132534f, -0.11788385f, 
    -0.11344014f, -0.04111081f, -0.12852998f, 0.04926103f, 0.03507926f, 0.05509902f, -0.08682906f, 0.12248224f, 
    0.03504972f, 0.01429214f, 0.16730273f, 0.06116635f, -0.16613765f, 0.02700545f, -0.17514546f, 0.15500224f, 
    -0.15834215f, -0.17000954f, -0.10248162f, -0.07265194f, 0.05173798f, -0.08755466f, -0.06392191f, -0.06136621f, 
    -0.09354181f, -0.14107522f, -0.08212724f, -0.16475980f, -0.00730371f, 0.11907553f, 0.07611554f, -0.17198351f, 
    0.12288217f, -0.05554558f, 0.03252053f, 0.16025169f, -0.16249728f, -0.12832554f, 0.09545184f, -0.15451981f, 
    0.01223371f, -0.15040985f, -0.12509054f, -0.05006677f, -0.02591001f, 0.01433520f, -0.07378948f, -0.09220756f, 
    0.01675417f, -0.01514721f, 0.12192928f, -0.20196602f, -0.02667383f, -0.06064552f, -0.08428195f, -0.17045733f, 
    -0.18049972f, -0.19072731f, -0.14344628f, 0.01250550f, -0.18614623f, -0.13495155f, -0.05942703f, -0.14921762f, 
    0.15111051f, 0.07535855f, 0.03882043f, 0.16332926f, 0.03113318f, 0.05174868f, 0.12890083f, -0.15968871f, 
    -0.09240483f, 0.11847226f, -0.07696653f, -0.03800173f, -0.04473104f, -0.17620897f, -0.16570681f, 0.15684989f, 
    -0.11452440f, -0.16476543f, -0.15625864f, 0.02056082f, 0.02131562f, -0.10115106f, 0.13211107f, 0.00865362f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27337694f, -0.06511560f, -0.16058764f, 0.15420298f, 0.04501563f, 0.02981154f, 0.26625368f, -0.18856809f, 
    0.03449091f, -0.08344089f, 0.16962151f, 0.17737514f, 0.16475889f, -0.01509095f, -0.10404800f, 0.08143435f, 
    0.44527787f, 0.11963481f, 0.26831579f, 0.08232691f, -0.20370544f, -0.17764980f, 0.04131272f, 0.10340107f, 
    -0.08860277f, -0.06719141f, 0.06667524f, 0.00285639f, 0.25951216f, -0.02481117f, 0.10365611f, 0.12245735f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.28049958f, 0.18004398f, -0.03459655f, 0.09469905f, 0.24881798f, -0.29958513f, -0.01516380f, 0.05944349f, 
    0.49879220f, 0.00070834f, 0.12274039f, -0.09067985f, -0.30629337f, -0.06059967f, 0.04394807f, 0.01098538f, 
    -0.14211939f, -0.18413080f, -0.14893383f, -0.02301251f, 0.14434947f, -0.26862493f, -0.22981381f, -0.02826123f, 
    0.14317228f, 0.22317338f, 0.27304485f, 0.36948976f, 0.33492768f, -0.15351842f, 0.09527929f, 0.05094403f, 
    0.45131961f, -0.01897916f, 0.06889994f, 0.24916627f, -0.08041608f, 0.12955125f, 0.33700222f, -0.02182845f, 
    0.31598255f, -0.15590651f, 0.00116496f, 0.22941497f, -0.60998887f, -0.00511857f, 0.25509197f, -0.14019118f, 
    0.32715756f, -0.28773499f, -0.12293864f, 0.30790576f, 0.08072369f, 0.20117371f, 0.12810904f, -0.36297476f, 
    -0.12099401f, -0.01196858f, -0.26265866f, -0.28720447f, 0.26745942f, -0.08203243f, -0.09033907f, 0.06644218f, 
    0.00203579f, -0.18379144f, -0.05546086f, -0.14839700f, -0.14176229f, -0.05264736f, 0.26742509f, 0.07407214f, 
    0.42946059f, 0.13615404f, -0.06497002f, 0.27501902f, -0.31321618f, -0.13808915f, 0.05528574f, 0.12403981f, 
    -0.17520919f, -0.15904476f, -0.29890037f, -0.19911923f, 0.18104008f, 0.09528971f, -0.09756687f, -0.36669940f, 
    0.12196279f, 0.16881296f, 0.00812263f, 0.01416402f, 0.40665466f, -0.03187981f, -0.08026541f, -0.00035866f, 
    0.26449814f, -0.00712169f, 0.05079657f, -0.02531968f, 0.02269153f, 0.23303047f, -0.02651902f, 0.16822024f, 
    0.14194722f, -0.00542626f, -0.09890198f, 0.28826916f, -0.12673490f, -0.08749395f, -0.11247114f, -0.01288056f, 
    0.14608070f, 0.04972284f, -0.29948747f, 0.08351026f, -0.11522158f, 0.06730031f, 0.36976358f, 0.03213051f, 
    -0.18379688f, -0.04237779f, -0.39378959f, -0.02962573f, 0.15136509f, 0.05564532f, -0.15910117f, 0.07413649f, 
    -0.01899598f, 0.34176564f, 0.00047196f, 0.36853537f, -0.00953022f, -0.01422816f, 0.14291970f, 0.07665346f, 
    -0.10945344f, -0.32429564f, 0.13864765f, 0.21708460f, 0.61487603f, -0.14878103f, 0.48467621f, 0.04892077f, 
    0.13016173f, -0.06832168f, 0.57006383f, -0.17450362f, 0.05027246f, 0.27614671f, -0.17941044f, 0.10659967f, 
    0.02939640f, 0.20166220f, 0.15896977f, -0.00819734f, -0.39391059f, -0.08528246f, -0.08287767f, 0.09168775f, 
    -0.37984100f, 0.22011429f, -0.12369490f, -0.17906992f, 0.01702719f, -0.05140937f, 0.01508546f, -0.04000064f, 
    0.29369512f, 0.26702645f, -0.10762621f, -0.30504853f, -0.17494060f, -0.11983968f, 0.34641287f, 0.13273068f, 
    -0.02173784f, -0.02479219f, 0.54864234f, 0.07567424f, 0.14062214f, -0.04300077f, -0.04187150f, 0.12691917f, 
    -0.07143661f, 0.24676596f, 0.18569188f, 0.06197613f, 0.30468684f, -0.03793878f, -0.16284566f, 0.10915247f, 
    0.67275572f, 0.53046632f, 0.06786034f, 0.19912286f, 0.04887583f, -0.02596643f, 0.21479253f, 0.13061753f, 
    0.20349589f, -0.27470264f, 0.02528501f, 0.46698081f, 0.02334184f, -0.07437129f, 0.30162343f, 0.11374142f, 
    0.20944674f, 0.06486803f, 0.00741851f, -0.23211077f, 0.01278521f, 0.18660738f, -0.01276631f, -0.24441250f, 
    -0.10248563f, 0.13892169f, -0.01727848f, 0.47533926f, -0.43156192f, -0.05111085f, 0.01238492f, 0.02334550f, 
    -0.05986452f, 0.08570530f, 0.05337105f, -0.18950596f, 0.12561592f, -0.01646242f, -0.04399803f, -0.15256397f, 
    0.01483312f, 0.05190490f, -0.08834266f, 0.00554773f, 0.02693942f, 0.07763767f, -0.13898639f, 0.06363863f, 
    0.10860518f, -0.08819172f, -0.10702501f, -0.15944813f, 0.06671841f, -0.01043696f, -0.11772294f, 0.02484662f, 
    0.12394166f, 0.08731683f, -0.13903567f, -0.06807257f, 0.01622128f, -0.13296601f, 0.04951848f, -0.07230567f, 
    -0.02431864f, -0.15928245f, -0.15077658f, -0.23735684f, 0.09054770f, -0.02306178f, 0.08968319f, 0.05093504f, 
    0.59946126f, 0.51251018f, 0.10275205f, -0.00342380f, 0.10474508f, -0.00362655f, -0.18546270f, 0.09067262f, 
    0.22651340f, 0.32083198f, -0.13111848f, -0.19134639f, -0.10363378f, -0.03721310f, 0.43733215f, 0.38698936f, 
    -0.00305394f, -0.41730583f, 0.04793710f, -0.29249039f, 0.47494429f, -0.03620463f, 0.06982086f, -0.04382571f, 
    -0.21550548f, 0.25642192f, 0.14097804f, 0.20996688f, -0.25501364f, -0.04653101f, 0.13541566f, 0.09713633f, 
    0.49102151f, -0.47636524f, 0.02204563f, 0.20081908f, 0.10214575f, 0.04671445f, 0.49320295f, -0.07876924f, 
    0.21006829f, -0.43187493f, 0.03162123f, -0.36451262f, 0.01240146f, -0.70310855f, -0.58397204f, 0.31386927f, 
    -0.00781277f, 0.31233573f, 0.01512352f, -0.13700208f, -0.01466554f, 0.01712837f, -0.15112284f, -0.09784219f, 
    -0.32151332f, 0.02991872f, -0.16815366f, 0.09472170f, -0.05772741f, 0.06848062f, -0.19783866f, 0.13899368f, 
    0.32496515f, -0.11328297f, 0.12326322f, -0.40288043f, -0.02060474f, -0.10675388f, 0.35240254f, 0.01720785f, 
    0.26370353f, -0.02473581f, 0.43361098f, -0.18710390f, -0.13065454f, -0.04013269f, -0.15327603f, -0.00042563f, 
    0.03411004f, 0.11758008f, 0.14710353f, 0.20824282f, 0.36839104f, 0.11657628f, -0.10443299f, 0.16565627f, 
    -0.45189887f, -0.07777702f, -0.14850362f, 0.05498323f, -0.28792733f, 0.52850974f, -0.08179743f, -0.04478364f, 
    0.52544928f, -0.09797923f, 0.11688151f, 0.20651259f, 0.08485945f, 0.04858124f, 0.00924269f, 0.04369917f, 
    0.18235661f, 0.05648544f, 0.03885010f, -0.43000367f, 0.08952804f, -0.29457512f, 0.10612255f, -0.29243234f, 
    -0.15456098f, 0.04516620f, -0.55972320f, 0.00285862f, 0.39447677f, -0.01855163f, -0.04037776f, -0.11045340f, 
    -0.03565451f, 0.04219321f, -0.15110022f, -0.18863912f, -0.04664757f, -0.25657618f, 0.18941098f, 0.08599350f, 
    0.14119399f, 0.62451923f, 0.01421520f, -0.10794739f, -0.20314062f, -0.10819229f, 0.00476052f, -0.11705883f, 
    -0.21841364f, 0.15659869f, -0.07140160f, 0.53279132f, -0.07455147f, -0.27325624f, 0.18308145f, 0.00046018f, 
    0.14490677f, -0.22314891f, 0.29423532f, 0.22906360f, 0.32342833f, 0.10589492f, -0.06546880f, -0.09001250f, 
    -0.46919531f, -0.60664427f, -0.01445938f, -0.24129868f, -0.02587590f, 0.02568846f, 0.30425620f, 0.12993626f, 
    -0.24533714f, 0.44150397f, -0.17371207f, 0.02028673f, 0.20659898f, 0.08712124f, -0.04665042f, -0.09298490f, 
    0.08608346f, -0.08427380f, 0.26714370f, 0.10221849f, 0.04530332f, 0.16184780f, 0.11676022f, 0.07770599f, 
    -0.11889328f, 0.23981777f, 0.59974271f, -0.48463866f, 0.53762591f, 0.13805327f, -0.07502500f, 0.13729213f, 
    0.03948110f, -0.09616075f, 0.14773065f, -0.01448039f, 0.00667978f, 0.13110736f, -0.01575549f, -0.07275520f, 
    0.07317981f, 0.02943795f, -0.07424711f, 0.11423495f, -0.05381752f, 0.09295302f, -0.07205419f, 0.05389285f, 
    -0.03461909f, -0.13453494f, 0.13392359f, -0.16562890f, -0.05871690f, -0.12115107f, -0.03240489f, 0.09168037f, 
    -0.02054503f, -0.02536116f, -0.20507100f, 0.10613968f, -0.15700100f, 0.13303891f, -0.04741322f, 0.10227455f, 
    -0.21490154f, 0.00355128f, -0.09436875f, 0.12823229f, 0.01584391f, -0.29410172f, 0.01891832f, 0.11458560f, 
    -0.05476816f, 0.04857325f, 0.02182174f, -0.20816305f, 0.15818271f, 0.03305976f, -0.12488480f, 0.16839650f, 
    -0.05329634f, 0.31471980f, 0.15065104f, 0.47927070f, -0.03989330f, -0.53636128f, 0.00859635f, 0.36238357f, 
    0.14858955f, 0.27344966f, 0.09603470f, 0.24436581f, 0.34061670f, -0.10484566f, -0.12110124f, 0.08136897f, 
    -0.27518287f, -0.44617447f, 0.03517700f, 0.08159737f, -0.14046563f, -0.21127032f, 0.31115201f, -0.04489455f, 
    -0.12830007f, 0.10948791f, 0.17168361f, 0.10649680f, 0.15268090f, 0.03078612f, 0.11608125f, 0.02194722f, 
    -0.06339725f, -0.03362963f, 0.08535365f, -0.11776938f, -0.16722973f, 0.12393276f, 0.05992898f, 0.14714225f, 
    0.07697001f, 0.68582422f, 0.25874731f, -0.46805093f, 0.63084531f, -0.13350768f, 0.01613516f, 0.14566232f, 
    -0.28641725f, -0.41348377f, 0.06032299f, 0.17221814f, -0.10831524f, 0.08523958f, 0.40182847f, 0.10445827f, 
    0.03238161f, 0.18999247f, 0.09626585f, 0.21180841f, 0.05798571f, -0.02204423f, 0.11725484f, -0.12383327f, 
    -0.16884235f, -0.29350039f, -0.20435064f, -0.01090296f, -0.14304797f, 0.06671996f, -0.23110124f, -0.23129171f, 
    -0.19163522f, 0.54838377f, 0.37266394f, -0.35395452f, 0.51750481f, 0.03101239f, 0.01542839f, -0.07084148f, 
    -0.16806801f, -0.38258469f, 0.06895254f, 0.23735446f, -0.03810287f, 0.16005896f, 0.10319997f, -0.09456532f, 
    -0.49442708f, -0.16521710f, -0.06979250f, 0.10066085f, -0.12176449f, -0.01810380f, 0.27201587f, -0.10947932f, 
    0.43796104f, -0.01912614f, 0.35360214f, -0.29886433f, -0.12617321f, 0.34899226f, 0.27335596f, 0.10342631f, 
    0.05008600f, 0.36948982f, 0.09103581f, -0.08669062f, 0.10964710f, -0.13580313f, -0.08497009f, -0.07755367f, 
    0.26511019f, 0.12820227f, 0.13912863f, 0.21552485f, -0.03833412f, 0.01795433f, 0.29536936f, 0.00548066f, 
    -0.50655186f, -0.17655981f, -0.17230043f, 0.05933741f, -0.07216533f, -0.06913904f, 0.35065421f, 0.01912794f, 
    0.22720592f, -0.49103799f, 0.27595732f, 0.14658621f, -0.16202185f, 0.09791461f, -0.12903145f, -0.03498206f, 
    -0.03027688f, 0.28938043f, 0.29827514f, -0.16487651f, -0.42938182f, -0.16047809f, 0.05315611f, 0.17360614f, 
    0.03937278f, 0.04339743f, 0.00428987f, 0.03652906f, -0.06198996f, 0.02451961f, 0.10323020f, 0.03702596f, 
    0.43513349f, -0.20766421f, 0.12102430f, 0.07461466f, 0.13423370f, -0.01579150f, -0.15505150f, 0.02104651f, 
    0.29841256f, -0.00924872f, -0.11424964f, -0.40774226f, -0.15511112f, -0.38404545f, 0.00975511f, -0.27497846f, 
    -0.07164629f, -0.25695902f, -0.57522374f, -0.18012191f, 0.18611382f, 0.03848886f, 0.04484833f, -0.01369001f, 
    -0.16598396f, 0.04502450f, -0.00726241f, 0.01556324f, 0.06484424f, 0.09617808f, -0.06190970f, 0.03583669f, 
    -0.03629629f, 0.05799776f, 0.04224138f, -0.13098466f, -0.13328516f, 0.08574960f, 0.01044411f, 0.04300921f, 
    -0.10777425f, -0.09630366f, 0.03822081f, -0.16725960f, -0.12697452f, -0.15346549f, -0.09611175f, 0.04761700f, 
    0.13743775f, 0.08387392f, -0.06728517f, -0.15088084f, -0.14788330f, -0.13137197f, 0.14462630f, -0.06057248f, 
    0.44031417f, -0.12116286f, -0.02749277f, 0.25207806f, -0.09323104f, 0.03187121f, 0.30203223f, -0.06479018f, 
    -0.09857547f, -0.13301939f, 0.08170200f, 0.55940825f, -0.06946417f, 0.08366466f, -0.18660653f, -0.15779574f, 
    0.30525711f, 0.08153568f, -0.48825851f, 0.25378883f, -0.16146661f, -0.09988833f, 0.37305558f, 0.08485865f, 
    0.13177237f, -0.25511143f, -0.43503699f, -0.14853385f, 0.14091238f, -0.10047252f, -0.01322490f, -0.05489422f, 
    -0.64019293f, 0.29071945f, 0.13050205f, 0.10271175f, -0.17469546f, -0.01752115f, -0.42359868f, -0.13271120f, 
    -0.32153058f, 0.27144259f, -0.02661015f, -0.38734886f, 0.29093137f, -0.05702983f, -0.34528470f, 0.15999924f, 
    0.01542418f, 0.50889522f, 0.47384006f, 0.08651722f, -0.10986242f, 0.21559113f, 0.25510228f, 0.10922030f, 
    -0.00039329f, -0.11253406f, -0.16226283f, 0.55027223f, -0.04907215f, -0.11007813f, 0.04401555f, 0.10649296f, 
    0.39887416f, 0.07199240f, -0.07312153f, 0.04004580f, -0.04140600f, -0.57077664f, 0.24573772f, -0.08898557f, 
    0.04173097f, 0.35243565f, 0.15266983f, 0.21215510f, 0.52876902f, -0.07984208f, -0.16633871f, -0.07617016f, 
    -0.29648238f, 0.64675254f, -0.39361843f, 0.03238534f, -0.04429436f, 0.22715895f, 0.43392861f, 0.22580077f, 
    0.04882127f, -0.25850993f, -0.07941244f, 0.13650951f, 0.39372173f, -0.13313884f, -0.19488165f, -0.11010677f, 
    0.25213096f, 0.14849307f, -0.04735312f, 0.28154972f, 0.15898944f, -0.42889035f, 0.06336097f, 0.17014796f, 
    -0.25797218f, 0.01543052f, 0.07068593f, 0.25446209f, 0.31123227f, -0.11810986f, -0.16027036f, -0.04546413f, 
    0.36099294f, 0.10973514f, -0.23907347f, 0.45359787f, 0.04778216f, -0.40044686f, 0.28111073f, 0.22004347f, 
    -0.16261080f, 0.01880411f, -0.15568370f, 0.08104420f, -0.28149566f, -0.15593778f, 0.13834542f, 0.14546983f, 
    0.34206387f, 0.14988714f, -0.05019655f, 0.07417633f, -0.07600703f, -0.58543468f, 0.17376548f, -0.01844110f, 
    0.03078615f, 0.29364520f, -0.15116979f, 0.22053733f, 0.48343706f, -0.14042360f, 0.13430600f, -0.01410301f, 
    -0.19747582f, 0.50301826f, -0.39632812f, -0.06292380f, -0.12296928f, 0.15652792f, 0.19073179f, 0.07587448f, 
    -0.11947516f, -0.34204486f, -0.02895773f, 0.49201432f, -0.02114347f, -0.07500800f, 0.05155583f, -0.06693995f, 
    0.14184766f, -0.26179096f, 0.15102054f, -0.29641637f, -0.00442884f, -0.51101422f, -0.06336788f, 0.09535429f, 
    0.29494342f, 0.05780206f, -0.15353721f, 0.23780382f, 0.33843052f, -0.03701216f, -0.04379088f, 0.09132026f, 
    0.35970977f, 0.14631255f, 0.36252323f, -0.52319449f, -0.09120800f, 0.21167175f, 0.31260175f, 0.42344025f, 
    0.08279360f, -0.24952887f, 0.56616157f, -0.08080160f, 0.48083964f, -0.07372392f, 0.13287283f, -0.08084620f, 
    -0.46333137f, 0.03877769f, -0.03231443f, -0.39302632f, -0.06314574f, 0.80133080f, 0.06129016f, 0.02151123f, 
    -0.27439925f, 0.36205056f, -0.14759535f, -0.22441587f, 0.01244394f, 0.03952987f, 0.02445133f, -0.06748085f, 
    -0.09670018f, -0.08446927f, 0.16085416f, 0.32744801f, 0.11686916f, -0.29426548f, 0.02564418f, -0.07080524f, 
    0.15874913f, -0.03530094f, 0.68539923f, -0.21484005f, 0.00210342f, -0.13983488f, 0.07587497f, 0.08291718f, 
    0.17610762f, 0.30286998f, -0.15641461f, -0.09432074f, -0.05276148f, -0.36327171f, 0.15950911f, 0.13214760f, 
    0.33596388f, 0.11143620f, -0.04986071f, -0.26383650f, -0.04220044f, -0.03333856f, 0.26491344f, 0.11151016f, 
    -0.20993912f, -0.39182687f, 0.04038252f, 0.28266609f, -0.13450748f, -0.30969828f, -0.28186724f, -0.19741921f, 
    -0.03469943f, 0.51719779f, 0.64368826f, 0.32707193f, 0.09939631f, 0.06085689f, 0.14664543f, 0.01870476f, 
    0.42070639f, 0.68978494f, -0.02144666f, 0.28775817f, -0.05276606f, 0.28956118f, -0.11108559f, 0.04250695f, 
    0.40488526f, -0.18244979f, 0.04395716f, 0.47436151f, -0.34197357f, 0.10219342f, 0.13906492f, -0.11089547f, 
    0.14400013f, 0.17853069f, -0.22894967f, -0.02775680f, 0.04441325f, 0.20479345f, -0.11743888f, -0.25247425f, 
    -0.14170882f, 0.15272816f, -0.14760709f, 0.62905276f, -0.33341703f, -0.09469406f, 0.04752266f, 0.11998922f, 
    0.36198401f, 0.04732418f, -0.11650796f, -0.12255666f, 0.02869530f, 0.88860720f, -0.06490430f, -0.14601527f, 
    0.26912490f, -0.03938489f, -0.11884888f, 0.27490360f, -0.38725233f, 0.11265724f, -0.04410082f, 0.04124239f, 
    0.23869558f, 0.16450748f, 0.00190904f, -0.46835321f, -0.14791621f, 0.87621486f, 0.01946229f, -0.20678711f, 
    0.10705233f, -0.19819403f, 0.19332103f, 0.07384213f, 0.31468141f, 0.16314729f, -0.02839726f, -0.16427438f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15816513f, 0.06881014f, -0.11604007f, 0.08010317f, 0.01946173f, -0.08367872f, 0.22575150f, -0.03874122f, 
    0.23691496f, 0.22471482f, 0.22302099f, -0.00376535f, 0.18965764f, 0.01370871f, 0.06268749f, 0.34706041f, 
    -0.00843991f, 0.02739864f, 0.27227536f, 0.18723907f, 0.08202478f, -0.07955579f, 0.32195854f, 0.05303001f, 
    0.22035868f, 0.33774653f, -0.01958544f, 0.19023982f, -0.10851543f, -0.00212665f, 0.06410760f, 0.11172605f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.49238729f, 0.10696535f, -0.27095076f, 0.01397623f, -0.30634725f, -0.05991767f, 0.05359069f, 0.06428272f, 
    -0.13918829f, -0.50433499f, -0.05968095f, -0.67720735f, 0.13341030f, -0.53284478f, 0.13714376f, 0.36053514f, 
    -0.46551389f, -0.28950402f, -0.78830498f, -0.31626138f, -0.06217660f, 0.09130961f, -0.01741688f, -0.14120227f, 
    0.27999988f, 0.16885507f, 0.18925332f, -0.49487555f, -0.35448796f, 0.41653696f, 0.20723534f, -0.09014734f, 
    -0.01504721f, 0.17900917f, 0.00163930f, -0.34634596f, 0.16897894f, 0.01061816f, 0.14719623f, 0.06913263f, 
    -0.69249845f, 0.45772171f, -0.16597605f, -0.44134903f, -0.11861474f, -0.31628802f, 0.09633735f, -0.04074824f, 
    -0.19613495f, 0.00595850f, -0.20799939f, 0.41745996f, -0.53039378f, 0.05832103f, 0.04119739f, -0.09966626f, 
    -0.54130626f, 0.17093721f, -0.27501714f, -1.13134897f, 0.47749573f, 0.41867098f, 0.14233367f, -0.53777665f, 
    0.09675218f, -0.11626972f, -0.41595089f, -0.47010872f, 0.31981516f, 0.07582272f, 0.22098094f, 0.06747085f, 
    -0.32261002f, 0.08369613f, 0.25347376f, -0.63982731f, -0.50349087f, -0.25177771f, 0.03280833f, -0.78908396f, 
    -0.53630441f, -0.37279871f, -0.04036846f, 0.14799674f, -0.65283698f, 0.05079791f, -0.78514040f, -0.17279015f, 
    -0.38642576f, -0.48592591f, -0.21634047f, 0.49160236f, -0.15804443f, 0.37336308f, 0.25064158f, 0.45274580f, 
    0.07023821f, 0.02832590f, -0.04415599f, 0.01549242f, -1.17578864f, 0.00378324f, -0.58746558f, -0.08811458f, 
    0.37291077f, -0.35140491f, -0.32159200f, -0.58664405f, 0.18669234f, 0.38379955f, 0.02088461f, 0.21687309f, 
    0.35633990f, 0.13622673f, -0.16148825f, -0.39113301f, -1.22016394f, 0.07046455f, 0.20851202f, -0.27892843f, 
    0.02330232f, 0.20491418f, -0.40119290f, 0.23084526f, 0.30218682f, 0.05544109f, -0.72626990f, -0.13223773f, 
    0.03027752f, -0.13403141f, -0.16885552f, -0.24824475f, -0.03897662f, 0.10794551f, -0.04889367f, -0.19805911f, 
    0.24618953f, 0.26728830f, 0.21808979f, -0.05201799f, -0.03516659f, -0.08016148f, -0.11532962f, 0.08610113f, 
    0.00943813f, -0.17140664f, 0.03736952f, -0.18665409f, -1.05077040f, -0.00505406f, -0.11930384f, 0.40920654f, 
    0.20221998f, 0.06935845f, 0.11991634f, 0.48848027f, -0.55147564f, -0.27012548f, -0.14101760f, -0.17774513f, 
    -0.37991118f, -0.09470038f, -0.30519065f, -0.01232195f, 0.17667598f, -0.42143217f, 0.11910852f, 0.00066334f, 
    -0.82823354f, 0.19375327f, -0.21859944f, -0.15598820f, -0.31115311f, -0.40634903f, -0.12887530f, 0.15300687f, 
    0.22565953f, 0.01724410f, 0.24952169f, -0.03277845f, 0.28705734f, -0.01345125f, 0.23703916f, 0.47250089f, 
    0.06310897f, 0.31872237f, -0.04171052f, -0.79025906f, -0.38832483f, -0.57646841f, 0.18455800f, 0.07076525f, 
    -0.79972118f, 0.28968892f, -0.47267514f, 0.22386667f, 0.07101521f, -0.62253088f, 0.08677756f, -0.15610142f, 
    -0.08790009f, -0.66474670f, -0.47301990f, -0.38201371f, -0.25915381f, -0.26292121f, 0.14800151f, -0.55005485f, 
    -0.37082162f, -0.37692124f, 0.01205733f, 0.09691112f, -0.17858705f, -0.04177839f, 0.49959916f, -0.74012154f, 
    0.28463164f, 0.26039749f, 0.19303697f, 0.01623732f, -0.40895420f, -0.76492035f, 0.03705272f, 0.22071385f, 
    -0.15119679f, -0.93037808f, -0.07272263f, -0.33543530f, -0.01641838f, 0.10555442f, -0.29306486f, -0.08073583f, 
    0.13384101f, -0.07622536f, -0.38420528f, -0.20496319f, 0.23155108f, 0.16960119f, -0.10511959f, 0.11618940f, 
    -0.55412114f, -0.08160634f, -0.86748660f, -0.41839749f, -0.99331349f, 0.03528182f, -0.66075402f, 0.34837845f, 
    0.37485981f, -0.12669042f, 0.40672958f, -0.12060109f, 0.41389456f, 0.16823065f, -0.15742223f, -0.08941758f, 
    0.26172391f, 0.14392561f, 0.26568085f, -0.15716399f, 0.22877197f, 0.15749966f, -0.13802458f, 0.03146656f, 
    -0.53891546f, 0.39970613f, 0.28415793f, 0.49906361f, -0.67319334f, -0.01011188f, -0.10766692f, 0.01208723f, 
    0.46149606f, 0.29237556f, 0.23899342f, -0.10039604f, -0.25474697f, 0.02696928f, -0.53024840f, -0.01812251f, 
    -0.52929795f, -0.48584774f, -0.78293955f, -0.51274604f, -0.26750734f, 0.02255994f, -0.07285751f, -0.09858251f, 
    -0.05642771f, 0.14642270f, 0.18342358f, 0.09838013f, -0.19828695f, -0.00746435f, 0.04230341f, -0.11664863f, 
    0.28950754f, 0.03457523f, 0.10831382f, 0.66589653f, -0.10666063f, -0.49684709f, -0.07257285f, -0.33963886f, 
    -0.61520451f, -0.47177827f, -0.04413467f, -0.44310436f, 0.88116258f, 0.09718077f, 0.08853596f, 0.35535488f, 
    -0.09297618f, -0.18420956f, -0.06703439f, -0.01529499f, -0.00189036f, -0.48115298f, 0.14602382f, 0.36525458f, 
    -0.67036325f, -0.00872942f, -0.35857660f, -0.44930875f, -0.20297386f, 0.16603379f, -0.27809188f, 0.10717599f, 
    -0.17407985f, -0.48708838f, 0.19853117f, -0.63234144f, -0.06354897f, 0.41687018f, -0.13511612f, 0.21126734f, 
    0.38655204f, 0.24939102f, 0.30417702f, 0.32227936f, -1.36063898f, 0.00194412f, -0.50358295f, -0.35319480f, 
    -0.20250875f, -0.31619292f, -0.38894051f, 0.05784250f, 0.25475779f, 0.18643811f, -0.46229991f, 0.14165886f, 
    0.14583355f, 0.14903428f, 0.67728561f, -0.06042821f, -0.38501072f, -0.08847495f, -0.05308405f, 0.16860047f, 
    -0.03811290f, -0.90963227f, -0.40600669f, -0.37766737f, 0.08668214f, 0.11452982f, -0.08866984f, -0.20821561f, 
    0.42512283f, 0.46654043f, -0.06234270f, -0.15397164f, -0.58598793f, 0.13523808f, 0.08310141f, -0.64733708f, 
    0.22514655f, -0.39510882f, 0.13458155f, -0.10534794f, -0.41181839f, 0.08532428f, -0.10721929f, 0.18516444f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.25429586f, -0.02999179f, -0.12700263f, -0.00787368f, 0.18250759f, 0.17236358f, 0.08464506f, -0.10235136f, 
    -0.46692199f, 0.01292383f, 0.13414186f, -0.34629405f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
