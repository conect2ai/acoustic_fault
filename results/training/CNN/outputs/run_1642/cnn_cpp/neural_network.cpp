#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.65441900f, -1.29356456f, -1.15394568f, -0.69812709f, -0.42303765f, 0.62024027f, 0.98397052f, -0.04048992f, 
    -0.00903673f, 0.81516945f, 0.45965040f, -0.27831644f, -0.41806054f, -0.25844780f, -0.40743506f, -0.18439913f, 
    -0.43922141f, -0.06912371f, 0.43637434f, -0.66875887f, 0.00387172f, -0.01634175f, 0.16547021f, -0.13710050f, 
    0.51031280f, 0.00748502f, -0.15430778f, -0.45669144f, -0.73047477f, -0.38469988f, 0.40105441f, -0.40476069f, 
    -0.13115844f, -0.37679294f, -0.55049622f, 0.27429730f, 1.07003224f, -0.31929955f, 0.58628577f, -0.09590392f, 
    -0.45430866f, -0.46823815f, -0.20303737f, 0.15868144f, 0.01303939f, 0.11393667f, -0.02058324f, -0.31479177f, 
    0.53205001f, 0.19454616f, -1.77448189f, -0.53724688f, -0.82897979f, 0.00002462f, 0.22602397f, 0.76701552f, 
    0.33099467f, -0.23326020f, 0.38935450f, 0.93454522f, 0.33321315f, -0.09394190f, -0.56032163f, 0.22054020f, 
    -0.19517699f, -0.35223556f, -0.26821393f, -0.45331925f, -0.19402370f, -0.66381013f, 0.07604976f, -0.05949454f, 
    -0.22828995f, 0.01467897f, -0.49219179f, -1.13881159f, -0.47983542f, -0.18675140f, -0.08568688f, -0.43612152f, 
    -0.38253680f, -1.21045446f, -1.06909597f, -0.40998679f, 0.32638708f, -0.53102982f, -0.55039752f, 0.26676896f, 
    0.68153429f, -0.31019911f, 0.22824717f, -0.42339653f, -0.17354269f, -0.31702805f, -0.74702400f, -0.08656946f, 
    -0.15860005f, -0.61142474f, -0.39159819f, -0.27449772f, 1.33029509f, -0.25353819f, -0.04963382f, -0.38689804f, 
    -0.70370859f, -0.90597236f, -0.74064595f, -1.14071095f, -0.97041017f, -1.27513707f, -0.05168972f, 0.19905750f, 
    -0.12004989f, -0.12452772f, 0.48659369f, 0.03426515f, 0.36268780f, 0.15658732f, 0.19663353f, 0.16053875f, 
    -0.43495309f, -0.18411647f, -0.12105471f, -0.01829759f, 0.12830698f, -0.28671688f, 0.14215830f, -0.07313147f, 
    0.22050130f, -0.22461966f, 0.32362768f, 0.55696625f, 0.57033616f, -0.05921882f, -0.04671995f, 0.08191574f, 
    0.35241559f, 0.24584399f, -0.38870415f, -0.36434886f, -0.27429900f, -0.00727336f, -0.30086324f, -0.40214419f, 
    0.30564204f, 0.17117085f, 0.55130899f, -0.08771043f, 0.02069574f, 0.55616933f, 1.12020683f, 0.46133760f, 
    -1.09263241f, -1.25144827f, -1.39461970f, 0.78261912f, 0.63004112f, 0.48571452f, -0.27132428f, -0.31005871f, 
    -0.43716857f, -0.35999435f, -0.05649861f, -0.09368432f, 0.17884752f, 0.09568424f, -0.37399271f, -0.31579071f, 
    -0.42660180f, -0.48659661f, -0.35570905f, -0.36591649f, -0.69455796f, -0.18701780f, -0.26923627f, 1.04903269f, 
    -0.63224614f, -0.24370824f, 0.53269017f, -0.07760675f, 0.43028626f, 0.36087549f, 0.36500433f, -0.30466133f, 
    -0.24726436f, -0.06910390f, 0.42822215f, -0.34145030f, -0.47529036f, -0.18928508f, -0.04260935f, 0.32773083f, 
    0.12044597f, -0.39487770f, 0.17181154f, -0.08513144f, -0.56183034f, -0.40864718f, -0.06916765f, -0.25982615f, 
    -1.13597238f, -0.66452813f, 1.07004154f, 1.36676061f, -0.14048861f, -0.09167554f, -0.57300752f, -0.04538305f, 
    -0.54666948f, -0.19350751f, 0.00404260f, -0.39915976f, 0.06664044f, -0.17957577f, 0.33404124f, -0.24178910f, 
    -0.05508523f, 0.24755761f, 0.29809010f, 0.38040867f, 0.15384494f, -0.11012833f, -0.02308038f, 0.33121753f, 
    -0.12784584f, -1.76836812f, -0.74108899f, -0.39137620f, -1.24068677f, -1.14431822f, 0.38420656f, 0.64125508f, 
    -0.79020202f, -0.76396161f, 0.89823872f, -0.01599377f, 0.33100006f, -0.35295343f, -0.61071116f, -0.65484142f, 
    -0.07594602f, 0.54920071f, -0.11116773f, 0.00077011f, 0.05781553f, -0.08372986f, -0.14159168f, -0.04230085f, 
    -0.00717921f, -0.05227973f, 0.66119826f, 0.24384433f, 0.17943625f, 0.09257858f, -0.15158269f, 0.78115916f, 
    -0.05491853f, -0.03942609f, 0.45417669f, -0.23574649f, 0.09258086f, 0.27103144f, -0.21681498f, -0.74809599f, 
    -0.26369345f, -0.47564852f, 0.01126955f, 0.15359302f, -0.28029305f, -0.20379876f, -0.12252729f, -0.31332150f, 
    -0.11627562f, 0.28874499f, 0.37713361f, -1.35508430f, 0.80166227f, 0.45204082f, -0.53481030f, 0.42482546f, 
    -1.05146563f, -0.56156474f, 1.13294244f, 0.95355940f, -0.10927878f, -0.36369067f, 0.01104697f, -0.02059974f, 
    -0.23515971f, -0.15108813f, 0.39098376f, -0.16714691f, -0.39231461f, -0.09638043f, 0.16847810f, -0.05969030f, 
    0.23241524f, -0.07151893f, 0.02616527f, -0.05252089f, -1.16465056f, -0.45209846f, -0.26677188f, -0.65586388f, 
    -0.13733546f, 0.09753662f, -0.14086774f, -0.76841158f, -0.96807897f, -1.03395164f, -0.37991458f, -0.25168794f, 
    -0.21521926f, 0.03004071f, -0.24005678f, 0.18943281f, -0.98341817f, -0.50907177f, -0.25259191f, -0.26315048f, 
    0.02131066f, 0.75917590f, 0.38220119f, 0.17284028f, 0.20177668f, -1.30226314f, 0.33861202f, 0.08720640f, 
    -1.39009023f, -0.99907529f, -0.05512263f, 0.06783414f, 0.20114060f, 0.64098835f, 0.78063321f, 0.01727277f, 
    0.29494876f, 0.15532792f, 0.25013268f, 0.17492174f, -0.10853817f, 0.02689144f, 0.17773294f, -0.02041589f, 
    0.19610119f, 0.13493153f, 0.21133471f, 0.26142842f, -0.19847366f, -0.24346730f, 1.08698416f, 1.03352034f, 
    0.32567033f, 0.55960828f, -0.01738947f, 0.14076400f, -0.03868806f, -0.30422637f, -0.22756273f, 0.15443043f, 
    0.01257696f, 0.02232858f, -0.18547972f, -0.18749572f, -0.17630446f, -0.14361240f, 0.16401190f, -0.12933756f, 
    0.13713750f, -0.23567459f, -0.02403498f, 0.10288790f, 0.11428403f, -0.25868469f, -0.30606312f, -0.62342578f, 
    -1.46559083f, -0.20150818f, 1.46965444f, 0.89937150f, 0.04755387f, -0.05655041f, -0.50598699f, 0.02672791f, 
    0.29000929f, 0.11461627f, 0.44615671f, -0.18005715f, 0.14197741f, 0.34146380f, 0.08091648f, -0.38723707f, 
    -0.35867235f, 0.31926554f, 0.22672470f, -0.20368709f, -0.34499925f, -0.30645704f, -0.36139995f, -0.55831331f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.64676636f, 0.78505820f, 0.37282529f, 0.34891999f, -0.12064090f, 0.71576595f, 0.21058170f, 0.26574314f, 
    0.55757177f, 0.08117481f, 0.79336494f, 0.60776269f, -0.02939920f, 0.28625950f, 0.14638135f, 0.39276382f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09761769f, 0.19020055f, -0.42117649f, -0.01711652f, 0.08600567f, 0.02379513f, 0.04039508f, -0.19841689f, 
    0.06482405f, -0.02509612f, -0.19130351f, -0.24779414f, 0.32633072f, 0.09695620f, -0.34438419f, -0.20800060f, 
    -0.01384891f, -0.13681807f, -0.37208509f, -0.08362256f, -0.12393801f, -0.08223513f, -0.09443206f, -0.12733977f, 
    0.16170518f, 0.07732706f, 0.00351773f, -0.17926447f, -0.02022289f, 0.13867487f, 0.10194604f, 0.03659647f, 
    -0.01649745f, 0.04280420f, 0.02554321f, -0.16206425f, 0.55820739f, 0.39083517f, 0.01178657f, -0.21686865f, 
    0.11035948f, 0.03668858f, -0.04388828f, 0.11813273f, -0.12837206f, -0.36091200f, -0.07206032f, -0.04824501f, 
    0.45447484f, -0.03847507f, -0.15355514f, -0.14901806f, 0.21960200f, 0.05726555f, 0.12144540f, 0.12080564f, 
    0.04861500f, 0.14823733f, 0.08868214f, 0.09757826f, -0.26795793f, -0.15066549f, -0.14984994f, 0.04475909f, 
    -0.05450172f, -0.12316022f, 0.04915655f, 0.01271743f, -0.05701561f, -0.18532723f, -0.11152030f, -0.59971613f, 
    -0.07140937f, -0.28112566f, -0.23028386f, 0.02864284f, 0.12140936f, 0.03737031f, -0.46403140f, -0.30022573f, 
    -0.07603572f, -0.11303673f, 0.04241317f, 0.02713769f, 0.03632120f, -0.49835736f, -0.47349492f, 0.06957895f, 
    0.01216090f, -0.00934123f, 0.23514523f, -0.14402209f, -0.03287140f, -0.05555942f, -0.05225086f, 0.06286486f, 
    0.49679670f, -0.01171260f, 0.06598606f, -0.52675968f, -0.09218397f, -0.18491876f, -0.13496138f, -0.07143073f, 
    -0.00258852f, -0.14262687f, -0.13749845f, 0.05237987f, 0.53515899f, 0.20067272f, -0.07846920f, -0.24539042f, 
    0.30909032f, 0.37656596f, 0.09837908f, 0.24752718f, -0.01798147f, 0.00328191f, 0.09378438f, -0.03472739f, 
    -0.65987492f, -0.13738647f, -0.53511864f, -0.12560233f, -0.04952522f, -0.04484037f, 0.02686941f, 0.10084876f, 
    -0.08760160f, -0.11470302f, 0.05207689f, 0.04411455f, -1.36796963f, -0.05378651f, 0.42275751f, -0.22245668f, 
    -0.09865567f, -0.15467778f, -0.11669974f, -0.00242907f, -0.00591296f, -0.15805599f, -0.12137017f, -0.08522277f, 
    0.46300924f, 0.17725895f, -0.48169470f, -0.23678881f, 0.13919835f, 0.24387293f, 0.00762974f, -0.00792731f, 
    -0.18108340f, -0.18777514f, -0.05828159f, -0.04591027f, 0.19955115f, -0.26027054f, 0.20682009f, -0.00841860f, 
    0.00072696f, 0.21294516f, -0.16878890f, -0.00425671f, -0.17153910f, -0.07691806f, 0.01938645f, 0.01385443f, 
    -0.78218955f, -1.00868297f, -0.61175108f, 0.41052145f, 0.06907988f, 0.02083573f, 0.07569466f, -0.00201987f, 
    -0.09066964f, -0.01793519f, 0.17191339f, 0.14858788f, 0.26237476f, 0.15211993f, 0.05650472f, -0.15587592f, 
    0.16008873f, -0.00140973f, 0.11215756f, 0.00310936f, 0.10598595f, -0.16842450f, 0.15442646f, -0.15733413f, 
    0.36278927f, 0.04836378f, -0.28646991f, -0.59983122f, -0.04400175f, 0.11179695f, 0.09868613f, -0.09558406f, 
    0.14772245f, 0.04491644f, -0.02218882f, 0.00069806f, -0.20626299f, -0.49325863f, -0.16056168f, 0.08782142f, 
    0.15573180f, 0.23461996f, 0.08903893f, 0.21651372f, 0.08349314f, 0.17951971f, -0.01533503f, 0.10696565f, 
    0.22936890f, -0.06643819f, -0.47185376f, -0.38766515f, -0.08723924f, -0.02885895f, -0.03829299f, 0.06725051f, 
    -0.30000538f, -0.15199758f, -0.11219532f, -0.20388345f, -0.06016022f, -0.06978521f, -0.04034886f, 0.58394110f, 
    0.25932640f, 0.01342014f, -0.16154782f, -0.15252560f, 0.05019363f, -0.05857378f, 0.12096511f, -0.19926380f, 
    0.24968086f, 0.04879728f, -0.34524849f, -0.67754555f, -0.35991180f, -0.24555653f, -0.32197276f, -0.36997283f, 
    -0.00715155f, -0.00890909f, 0.00668355f, 0.09966630f, 0.14353190f, 0.02976494f, 0.01507194f, 0.07931512f, 
    0.03417670f, 0.10289706f, -0.04915526f, -0.03457427f, 0.02776772f, 0.21988624f, -0.07236277f, 0.19934250f, 
    0.71793360f, -0.22632037f, 0.50574702f, -0.07844327f, 0.09382483f, -0.09120679f, -0.08021378f, -0.13291156f, 
    -0.02964486f, -0.11437163f, -0.14629821f, -0.38035902f, 0.62167990f, -0.00742623f, 0.00115967f, -0.03876482f, 
    -0.08117995f, -0.13130352f, 0.01594249f, -0.04708036f, 0.17527941f, -0.34874779f, -0.00653403f, 0.39117435f, 
    -0.47549784f, 0.19232489f, -0.30966884f, -0.24799649f, 0.11527878f, 0.27061960f, -0.00287529f, 0.02223911f, 
    0.05251927f, -0.00938486f, 0.06961062f, -0.02745650f, 0.62928748f, 0.14264302f, 0.01120138f, 0.07083613f, 
    -0.09858064f, -0.01592716f, -0.36011365f, -0.31620425f, -0.03061247f, -0.01555536f, -0.19682977f, -0.04054394f, 
    0.74349082f, 0.33873186f, 0.12829067f, 0.31864521f, -0.08408781f, -0.04496288f, 0.08227748f, -0.00382113f, 
    0.06382536f, -0.04597201f, -0.02481411f, 0.19247915f, -0.92612660f, -0.17402597f, 0.24098034f, 0.00806283f, 
    -0.00104220f, 0.09791159f, -0.10731675f, 0.01851367f, 0.09541517f, 0.14581387f, -0.16496596f, 0.12226462f, 
    -0.16450906f, 0.10580284f, 0.33795592f, 0.44147259f, -0.18112385f, 0.06859703f, 0.14559002f, 0.27364543f, 
    -0.07590120f, -0.03742740f, 0.02157990f, -0.01756651f, -0.66125727f, 0.00625479f, 0.11393590f, -0.05004190f, 
    0.13557129f, 0.23136149f, -0.28674072f, -0.05026997f, -0.25629306f, -0.02669362f, 0.01095623f, -0.02743254f, 
    0.19424659f, 0.30635551f, -0.02396155f, 0.20274097f, -0.10426642f, -0.05860276f, 0.02237784f, 0.07155964f, 
    -0.06272242f, 0.03540850f, 0.08468430f, -0.09005661f, -0.05137996f, 0.02381633f, -0.09819559f, 0.02964772f, 
    -0.09892594f, -0.10958003f, 0.03768251f, 0.07526390f, -0.25993210f, -0.09438092f, -0.09088652f, -0.10754051f, 
    -0.32358399f, 0.64022779f, 0.63399267f, -0.42069227f, -0.02670125f, 0.21547917f, -0.29992589f, -0.01941051f, 
    0.01335117f, -0.04915028f, 0.06865612f, -0.12856539f, -0.50496691f, -0.22116151f, -0.34175622f, -0.27975804f, 
    0.15642011f, -0.13213022f, 0.13916871f, 0.16088359f, -0.13287446f, -0.05894818f, -0.13042036f, -0.07122676f, 
    -0.02251130f, 0.05746241f, 0.46200722f, 0.33220288f, 0.05599248f, -0.02099261f, 0.06167077f, 0.08691326f, 
    0.06067308f, -0.16883732f, -0.06603562f, 0.08277216f, -0.15537210f, -0.74166685f, -0.18910769f, 0.10599929f, 
    0.12438221f, -0.15045168f, -0.28757098f, 0.02582852f, -0.07385877f, -0.13181123f, 0.09760376f, -0.15441529f, 
    -1.15320301f, -0.33454224f, -0.25992846f, -0.56759602f, 0.11491796f, 0.10976092f, -0.22122118f, -0.54991758f, 
    0.08775907f, 0.01086933f, 0.00572493f, -0.00464551f, 0.04560500f, -0.12206320f, -0.23350957f, -0.27113068f, 
    0.13331695f, -0.08679000f, -0.20180599f, 0.07566802f, 0.08308833f, -0.26221511f, -0.06663986f, -0.26936638f, 
    -0.12303288f, 0.47019601f, 0.45985910f, -0.06558761f, -0.09274676f, -0.00334845f, 0.25900823f, -0.12877554f, 
    0.05899812f, 0.11200090f, -0.17037942f, -0.02210326f, -0.04022580f, -0.06807815f, -0.08226824f, -0.08103371f, 
    -0.03040030f, -0.08972093f, -0.01459523f, -0.03777763f, 0.31567883f, 0.06869114f, -0.12574410f, 0.33654737f, 
    0.26868328f, 0.42993012f, -0.17472541f, -0.01961643f, -0.11006640f, -0.46656460f, 0.24831370f, 0.12288626f, 
    -0.07804692f, 0.04068541f, 0.08079185f, -0.11099064f, 0.15754765f, 0.32384422f, 0.54132271f, 0.63075781f, 
    -0.34724092f, -0.06749227f, -0.07080867f, 0.28202540f, 0.11516529f, 0.04266893f, -0.13333058f, 0.07070454f, 
    -0.14201541f, 0.18470311f, 0.05598805f, -0.67566866f, -0.00935932f, 0.02391072f, -0.00679494f, -0.00002908f, 
    -0.01161210f, -0.02014714f, 0.03357472f, 0.00799918f, 0.33324218f, 0.19350640f, -0.37441921f, 0.04973065f, 
    -0.22246075f, 0.13053590f, 0.03996958f, -0.06853192f, -0.00258856f, 0.00314881f, -0.27944437f, 0.21311468f, 
    -0.79078251f, -0.33776489f, -0.23174708f, -0.15139551f, 0.33394980f, -0.14472680f, 0.15017526f, 0.11863128f, 
    -0.02404436f, -0.11770741f, -0.14438653f, -0.05634144f, 0.30793047f, 0.33100504f, 0.08127885f, 0.40962133f, 
    0.00111469f, 0.00139365f, 0.23938294f, 0.04773749f, 0.07752334f, 0.14246477f, 0.10127787f, 0.10283460f, 
    -0.53950953f, -0.26271209f, 0.25320289f, -0.92013991f, 0.05921713f, -0.05902122f, -0.05547690f, 0.04173821f, 
    0.05150478f, -0.14967644f, -0.06713881f, 0.17622723f, 0.03069984f, 0.05462263f, -0.10056137f, 0.19865227f, 
    0.00494682f, -0.06151541f, 0.01461572f, 0.13101701f, -0.08647231f, 0.30430943f, -0.01593876f, 0.15183370f, 
    -0.32405204f, 0.07210442f, -0.21281303f, 0.20153877f, 0.28210771f, 0.00713569f, 0.11445796f, -0.21400684f, 
    0.00674326f, 0.09733716f, 0.15705338f, 0.17374538f, -0.20392586f, -0.08632443f, -0.32240891f, 0.39017519f, 
    0.07700015f, -0.07979380f, 0.14171113f, 0.02071660f, -0.02423432f, -0.12096903f, 0.19536060f, -0.27711096f, 
    0.21824268f, -0.27867705f, -0.08527174f, -0.17903815f, 0.30027696f, 0.07231346f, -0.00923676f, -0.17498730f, 
    -0.25682411f, -0.07291865f, -0.09509563f, -0.09151372f, -0.18019827f, -0.20154655f, -0.06791311f, 0.09238618f, 
    0.02683361f, -0.01783989f, -0.00889206f, 0.06031945f, -0.10219687f, 0.11846570f, -0.11901639f, -0.14073586f, 
    -0.14983909f, -0.39606148f, 0.26000410f, 0.49311465f, -0.08198364f, 0.26727164f, 0.24373922f, 0.05339394f, 
    0.08096474f, 0.05159045f, -0.13182078f, -0.02803653f, -0.02406871f, -0.00013266f, -0.22803408f, 0.18029550f, 
    0.14931667f, -0.30914235f, -0.22176604f, -0.05212505f, -0.44293290f, 0.22910528f, -0.00201974f, -0.23014538f, 
    -0.18119556f, -0.10150695f, -0.09092258f, 0.69257617f, 0.15803944f, 0.03010752f, -0.10581629f, -0.14440577f, 
    -0.00205039f, 0.05467876f, 0.14311691f, 0.22223890f, -0.27031192f, 1.09740067f, -0.06870925f, 0.22497685f, 
    -0.09989313f, -0.08670250f, 0.23874202f, 0.10428584f, -0.15075541f, 0.23832434f, -0.17403819f, -0.01670206f, 
    -0.34878039f, 0.61669111f, 0.08141008f, 0.51275456f, -0.11645086f, -0.27312261f, -0.47104934f, -0.13078763f, 
    -0.13120054f, -0.35355696f, -0.01756172f, 0.03198224f, 0.02727507f, -0.37550274f, -0.11102749f, 0.29914209f, 
    0.12579739f, -0.07957619f, -0.04715681f, -0.10736267f, 0.11681718f, 0.17630382f, 0.01957541f, 0.14679813f, 
    -0.65134174f, -0.05695061f, 0.04905374f, -0.26860073f, 0.13090464f, -0.08037569f, 0.03870155f, -0.20266049f, 
    -0.32182661f, 0.11400237f, -0.14712389f, -0.04436770f, 1.43741870f, -0.11932781f, -0.32319149f, -0.47063726f, 
    0.11931399f, -0.26603466f, 0.01012617f, 0.01833168f, -0.07218782f, 0.00763082f, -0.20516470f, -0.23894057f, 
    0.18561940f, -0.09941341f, -0.06491893f, 0.28630626f, 0.03716557f, 0.13022205f, -0.01282694f, 0.12805916f, 
    -0.09955559f, -0.12905300f, 0.04999162f, -0.04738517f, 1.00417721f, -0.20575005f, 0.04211107f, 0.30372295f, 
    0.14626464f, -0.03769363f, -0.00532260f, 0.01325977f, -0.12174129f, -0.08314122f, -0.19737607f, 0.05107315f, 
    -1.36429393f, -0.18084291f, -0.27240011f, -0.08526587f, -0.18572500f, -0.13409308f, -0.54473609f, 0.19768032f, 
    0.13669433f, 0.09286995f, 0.03827572f, 0.17991075f, -0.26649922f, 0.58000058f, -0.81988710f, 0.05195649f, 
    0.05390948f, 0.02132581f, 0.09580432f, -0.09945673f, -0.05943843f, -0.20936063f, -0.02154265f, -0.02513373f, 
    -0.22234173f, 0.08681970f, -0.00699162f, 0.11448644f, -0.21842958f, 0.07284206f, -0.22851984f, 0.17190504f, 
    -0.15426497f, -0.24476025f, -0.32240599f, -0.09970197f, 0.16387351f, 0.30566284f, 0.12843415f, 0.08248427f, 
    -0.25275594f, -0.08701847f, -0.08022561f, -0.09651007f, -0.04311492f, -0.16156144f, -0.17850861f, 0.00403351f, 
    0.00287453f, 0.26535121f, -0.28307632f, 0.25848630f, -0.18067825f, -0.10851982f, 0.13364190f, 0.02188048f, 
    0.17572789f, -0.11233278f, 0.00031987f, 0.14431302f, 0.02426684f, 0.12616831f, 0.07348251f, 0.09266905f, 
    -0.19282326f, 0.01081249f, 0.01026110f, -0.25079104f, -0.02591387f, 0.17524469f, -0.00926148f, 0.28576452f, 
    0.29566815f, 0.71713871f, 0.34802487f, 0.17698190f, 0.02183620f, 0.25410831f, 0.22103932f, 0.21529163f, 
    -0.00634974f, -0.07991638f, -0.03454110f, -0.13526581f, 0.44581723f, 0.13532214f, 0.05378555f, -0.05656768f, 
    -0.02498595f, 0.02355628f, 0.09711672f, -0.10905862f, -0.17937824f, -0.20528951f, -0.24887168f, -0.33396438f, 
    -0.34916764f, 0.10944082f, -0.15342066f, -0.16390000f, -0.08549923f, -0.22243312f, -0.13273300f, -0.04244906f, 
    0.07233752f, 0.11324435f, -0.07762367f, 0.32017189f, 0.14812426f, -0.09316671f, 0.10563076f, -0.25004360f, 
    0.05416641f, 0.06532575f, -0.00419328f, 0.04382892f, 0.12593095f, -0.04884791f, 0.18922378f, -0.17003648f, 
    -0.07114906f, -0.60445565f, 0.04935018f, 0.45008376f, -0.25643769f, -0.17637765f, 0.02517271f, 0.06374239f, 
    -0.20158124f, -0.08635864f, -0.09521471f, 0.02277545f, -0.06853655f, 0.07138313f, 0.07687131f, 0.29846489f, 
    -0.14833792f, -0.20299801f, -0.02129345f, -0.20560421f, 0.00110846f, -0.00730324f, 0.08451646f, -0.00285406f, 
    0.02289934f, -0.39246011f, -0.24304223f, -0.18819641f, 0.15573156f, -0.00748209f, 0.08138754f, 0.09561906f, 
    -0.12279239f, -0.06895535f, -0.14193328f, -0.30422175f, -0.05933548f, -0.30421352f, -0.48042813f, -0.75144231f, 
    0.12186303f, -0.12452527f, 0.05756243f, 0.08429274f, 0.20475468f, -0.21340427f, -0.05999471f, -0.13193721f, 
    0.05456252f, 0.06859253f, 0.13781488f, 0.14418998f, 0.14342453f, -0.14934658f, -0.00226942f, -0.08974718f, 
    0.07266887f, -0.06945566f, -0.01160596f, 0.04590195f, -0.30118269f, 0.26766762f, -0.04480074f, 0.12195844f, 
    -0.10316295f, -0.24503419f, -0.07774525f, -0.05137400f, 0.03893012f, -0.28664511f, 0.01028387f, 0.07055275f, 
    0.31215310f, -0.15134719f, -0.19079044f, 0.23705499f, 0.18052192f, 0.08809983f, 0.21902610f, 0.01830271f, 
    0.12324575f, 0.11625364f, 0.02753632f, 0.05404177f, 0.18384954f, -0.33190230f, 0.24559070f, 0.12350563f, 
    -0.08473271f, -0.03635380f, -0.09143946f, 0.00341648f, -0.13434853f, 0.29776755f, -0.12391836f, 0.33191943f, 
    0.10504849f, -0.28142047f, 0.02022213f, -0.25900796f, -0.16075395f, 0.04772216f, -0.02091479f, 0.01559571f, 
    0.00625268f, -0.01846760f, 0.01993849f, 0.11332181f, 0.17464492f, 0.28853804f, -0.12311864f, -0.39679730f, 
    -0.02940773f, 0.31605983f, -0.05914479f, -0.02088378f, 0.05604957f, 0.20748709f, 0.10189193f, 0.04379188f, 
    -0.87895375f, 0.04193422f, 0.21222302f, -0.03863449f, -0.07392708f, -0.00831939f, -0.02913322f, -0.07406650f, 
    0.26163551f, -0.11699028f, -0.06340931f, -0.07698209f, -0.03075153f, 0.16988058f, 0.53543162f, -0.23015976f, 
    0.01590821f, -0.00369797f, -0.16757630f, 0.18859166f, -0.00506310f, -0.23914370f, -0.16213498f, -0.07002158f, 
    0.02133168f, -0.01610659f, 0.08554799f, -0.08315367f, 0.14553542f, -0.09357136f, -0.30087507f, -0.00012784f, 
    -0.03049590f, -0.07529651f, 0.06201176f, 0.00606818f, -0.23258428f, -0.21711212f, -0.20497170f, 0.45193943f, 
    -0.09521776f, -0.18039899f, -0.04195139f, -0.12030276f, 0.30943915f, 0.04631314f, 0.23915631f, 0.36289150f, 
    0.06177584f, 0.08069807f, -0.38904947f, -0.37594664f, 0.01977527f, 0.13899356f, -0.00033129f, 0.07638057f, 
    0.18219963f, -0.20921856f, -0.20800640f, -0.21760456f, -0.06275391f, -0.25161046f, -0.28030857f, 0.04606176f, 
    0.00107871f, 0.12264708f, -0.02376438f, 0.01065643f, -0.19210404f, -0.21548977f, -0.25178882f, -0.42827782f, 
    0.34523305f, -0.35160112f, 0.28794390f, 0.20089513f, 0.16130055f, 0.09558888f, 0.24001178f, 0.20844938f, 
    0.09184395f, 0.08674328f, -0.08472720f, -0.04413805f, -0.48223296f, 0.12968703f, -0.00523671f, -0.31599891f, 
    0.11846277f, 0.16627213f, 0.15964758f, 0.23199315f, 0.00830263f, -0.09016177f, 0.11307015f, -0.02384613f, 
    -0.09593789f, -0.28691337f, -0.45867729f, 0.11673874f, 0.09082308f, -0.01510080f, -0.08858577f, -0.00123865f, 
    0.16737835f, -0.10155350f, 0.23267405f, 0.34066194f, -0.68146074f, 0.07802292f, -0.02974609f, 0.47101825f, 
    0.06615443f, 0.02034046f, 0.04029607f, -0.07189093f, -0.07420927f, -0.08365329f, 0.07691758f, 0.13059224f, 
    0.04509451f, 0.35615966f, 0.19887763f, -0.41898876f, 0.19283950f, -0.02576226f, 0.35638854f, -0.10827473f, 
    0.14082687f, 0.16260181f, -0.01246707f, 0.08055249f, -0.42229807f, -0.37431520f, -0.27886704f, -0.01918188f, 
    -0.14504634f, -0.09287373f, 0.04342828f, 0.14315443f, 0.10740128f, 0.04730752f, 0.06910179f, -0.12503888f, 
    -0.04116823f, -0.46748722f, -0.01232255f, 0.17759347f, 0.15490264f, 0.06063724f, -0.15612034f, -0.04622827f, 
    0.12372632f, -0.16297895f, -0.03207891f, -0.21274447f, 0.05115954f, -0.19205384f, 0.20384361f, -0.07530420f, 
    0.18296669f, -0.11466645f, -0.01323784f, 0.07380904f, -0.17629719f, -0.12281014f, -0.09247258f, 0.00703519f, 
    -0.54368114f, 0.22653098f, 0.52424127f, 0.24122712f, 0.20541523f, -0.10616673f, 0.23758869f, 0.17114995f, 
    -0.00394534f, 0.18363515f, 0.03377845f, -0.15359399f, -0.30078965f, 0.10252239f, 0.63110709f, 0.09406706f, 
    -0.11883181f, -0.32022050f, 0.05462010f, -0.37155983f, 0.08418802f, -0.28162241f, -0.07493952f, 0.06363562f, 
    -0.48087725f, 0.13987586f, 0.55290788f, -0.13486420f, -0.00867091f, 0.04993432f, 0.06294569f, 0.07076278f, 
    0.06771791f, 0.20913561f, 0.21667254f, 0.07566900f, -0.78032392f, -1.47946954f, -1.21355438f, -0.27441409f, 
    -0.21254024f, 0.00341651f, 0.37729323f, -0.33524355f, -0.08570388f, 0.10786886f, -0.04893167f, 0.19054252f, 
    -0.44925737f, -1.02175069f, -1.04674840f, -0.07119349f, -0.06787104f, 0.06513283f, 0.23527506f, -0.54011250f, 
    0.18175185f, -0.11033366f, 0.04573769f, 0.06007400f, -0.15569264f, -0.11047132f, 0.29087532f, -0.00287876f, 
    0.03295076f, -0.26971751f, 0.03632912f, -0.11577034f, 0.03636326f, -0.06450269f, -0.16411455f, 0.02525733f, 
    0.69537944f, 0.58584517f, -0.20403874f, -0.17223208f, 0.02204760f, -0.04005320f, 0.05407138f, 0.10671017f, 
    0.18621680f, 0.14096943f, 0.28432912f, 0.24874283f, -0.32553533f, 0.09476538f, 0.06561019f, -0.02592768f, 
    0.10318726f, 0.09265839f, 0.12767702f, -0.14331473f, 0.04559135f, 0.24977502f, 0.22612308f, 0.10890803f, 
    -0.62897789f, -0.43049723f, -0.24815615f, 0.67026341f, -0.05706970f, 0.37890905f, -0.04867576f, -0.26471964f, 
    -0.05541459f, 0.04075107f, 0.01517801f, 0.09856482f, -1.14764941f, -0.87619621f, 0.91804844f, 0.51647437f, 
    -0.54065013f, -0.05046005f, 0.20944203f, -0.37203699f, -0.11099637f, 0.00393215f, 0.04702063f, -0.04629228f, 
    -0.07737585f, -0.10938350f, 0.16496639f, -0.11914725f, 0.09822194f, -0.08928718f, 0.06308960f, -0.03089769f, 
    0.01504071f, 0.14976600f, -0.26120907f, -0.02654598f, -0.04647578f, 0.12810756f, -0.11023965f, -0.14952841f, 
    0.05339196f, -0.06283043f, 0.05814723f, -0.09959048f, -0.00244301f, 0.08167786f, 0.29917237f, -0.21237572f, 
    -0.72985321f, -1.53364813f, -0.36963010f, -0.30893388f, -0.08518522f, -0.49135599f, -0.27491128f, -0.50034374f, 
    -0.16922507f, 0.03638558f, -0.04985709f, -0.10151292f, 0.17738830f, 0.06186998f, 0.26209691f, 0.20439859f, 
    -0.17221972f, 0.01704164f, -0.31211102f, 0.08382798f, 0.07508161f, -0.00593878f, 0.03130086f, 0.09042263f, 
    0.10791233f, -0.18904404f, -0.25189108f, -0.20823681f, -0.01002569f, 0.10629309f, 0.04082114f, -0.19665402f, 
    -0.07351028f, -0.06604398f, -0.06848425f, -0.20170459f, -0.43264326f, 0.10643677f, 0.07287340f, 0.17091949f, 
    0.02023228f, 0.09810978f, 0.07868057f, 0.04588624f, 0.39431408f, -0.03896553f, 0.44310430f, 0.05841982f, 
    -0.53216833f, -1.56722343f, -0.06831983f, -0.41413164f, 0.14615577f, -0.02552572f, 0.27262387f, 0.06086842f, 
    -0.11106610f, 0.02406134f, -0.01509441f, 0.02334369f, -0.52415681f, 0.60325110f, -0.12601420f, 0.05082320f, 
    0.07637288f, -0.26191989f, -0.10987705f, -0.23451319f, -0.18507944f, -0.00792690f, 0.06200736f, 0.01218562f, 
    0.96915382f, -0.66375190f, -0.19331409f, -0.89537603f, 0.05774406f, -0.13822670f, -0.18889207f, 0.02217652f, 
    0.25425565f, 0.17463711f, 0.02602757f, 0.01073308f, -0.17513777f, -0.99280655f, 0.82770389f, 0.32677719f, 
    -0.00999573f, 0.06393338f, -0.08462953f, 0.18694797f, -0.01457214f, 0.00232516f, -0.11040162f, -0.21782959f, 
    -0.76561201f, 0.07952397f, 0.15644434f, -0.23217210f, 0.26334125f, 0.17078403f, 0.16002096f, 0.13324767f, 
    -0.06836880f, 0.07802274f, -0.11381133f, -0.15213569f, 0.25765264f, 0.23353893f, -0.11739675f, -0.15368345f, 
    -0.15091440f, 0.03309367f, 0.14221926f, -0.09177504f, -0.19673342f, 0.09166697f, -0.38909262f, -0.10374278f, 
    -0.18003036f, 0.48140690f, -0.35622448f, 0.60690123f, -0.12043438f, 0.00231491f, 0.29532200f, 0.11076540f, 
    -0.09206482f, -0.00745560f, 0.02531066f, 0.04757931f, 0.08552153f, 0.17949265f, 0.32858276f, 0.15128438f, 
    0.01023994f, -0.14739464f, 0.08936812f, -0.00662119f, -0.27116469f, -0.10788164f, 0.03379383f, -0.53020579f, 
    0.05588476f, -0.30596390f, -0.23372835f, -0.01177872f, -0.34794086f, -0.15297304f, -0.06176130f, -0.18135460f, 
    -0.02490279f, 0.23066086f, 0.08815934f, -0.01976031f, 0.34199053f, -0.87799609f, -0.63412684f, -0.82829589f, 
    -0.00776049f, -0.12266439f, -0.06067307f, 0.32844481f, 0.10667136f, -0.06044634f, -0.00267095f, -0.07379948f, 
    0.26798433f, 0.11671130f, 0.07754474f, -0.55137610f, -0.02773125f, 0.09911336f, -0.02020026f, 0.07039560f, 
    -0.06695340f, -0.00155773f, -0.03997367f, -0.17671764f, 0.61122423f, 0.56288809f, -0.14956622f, 0.29589304f, 
    -0.08319346f, 0.08592733f, -0.05259304f, -0.11468514f, -0.03858099f, 0.03800857f, -0.23456176f, -0.29088879f, 
    -1.19666350f, -0.16620165f, 0.18700483f, 0.50208259f, 0.08784738f, -0.18662000f, -0.08444913f, 0.07169515f, 
    -0.02856622f, -0.10155968f, -0.06716925f, -0.00507309f, 0.61110598f, -0.23178452f, -0.25002968f, -0.29031742f, 
    -0.02899833f, -0.00577412f, -0.02086741f, -0.09364955f, 0.11268320f, -0.06207399f, 0.08001003f, 0.03015982f, 
    0.10906320f, 0.09768382f, 0.09950357f, -0.13098416f, 0.03656553f, -0.01289413f, -0.11280475f, 0.03910809f, 
    0.16789266f, 0.00741090f, 0.07745671f, 0.10131108f, 0.35256726f, -0.26578042f, -0.06309849f, -0.42178106f, 
    0.11997142f, 0.21245654f, 0.01631470f, -0.02384730f, -0.06846685f, 0.06984800f, -0.10886156f, -0.08616191f, 
    0.10751927f, -0.87123585f, 0.42173913f, 0.46496454f, -0.16577080f, -0.03929548f, -0.00487769f, 0.05983490f, 
    0.13589469f, 0.01834574f, 0.11107302f, 0.31978202f, -0.16674873f, -0.31894287f, 0.04732678f, -0.03048849f, 
    -0.14789635f, -0.05046057f, 0.00620481f, 0.01734933f, 0.13759440f, 0.03912082f, 0.21119723f, -0.00624884f, 
    -0.08921693f, -0.31961936f, -0.06153072f, -0.35580900f, -0.08527421f, 0.13328730f, 0.27380240f, -0.02960146f, 
    -0.15789461f, 0.24343371f, -0.27401882f, -0.21651091f, 0.41502881f, -0.38732949f, -0.36087239f, -0.55638778f, 
    0.06280932f, 0.12996863f, 0.02666916f, 0.02428989f, 0.07968631f, -0.16909978f, -0.18138756f, -0.23498146f, 
    -0.35825667f, -0.32104829f, 0.22985765f, 0.23005654f, 0.17640136f, 0.07179325f, -0.15884595f, -0.24291553f, 
    0.11332591f, -0.04379423f, 0.10218011f, 0.02539424f, -0.22628635f, 0.04986556f, -0.03230522f, 0.11448628f, 
    -0.16122681f, 0.04385976f, 0.10119551f, 0.02100412f, 0.11432629f, 0.20811008f, 0.23655255f, 0.25759149f, 
    -0.96778613f, -0.62422091f, -0.11407886f, 0.38479823f, 0.03103779f, 0.27159658f, -0.18540207f, -0.01850678f, 
    -0.33981916f, -0.00145808f, 0.06799740f, -0.32770115f, -0.47850049f, -0.20990101f, -0.01856503f, -0.16827096f, 
    -0.18930595f, 0.01095402f, -0.19602816f, -0.26381591f, 0.11703631f, -0.50210220f, -0.37200513f, -0.10941100f, 
    0.67256659f, 0.37817639f, -0.02094644f, -0.24741542f, -0.00530922f, 0.02563983f, 0.07782461f, -0.08905467f, 
    0.12752335f, 0.12753084f, 0.15089066f, 0.19324039f, -0.16914098f, -0.66619778f, -0.64008009f, 0.39085072f, 
    0.07993689f, 0.33416396f, 0.11048920f, 0.02511584f, -0.01510835f, 0.00296373f, 0.01452447f, 0.02163168f, 
    -0.24222527f, 0.39737502f, -0.09434058f, 0.10345115f, -0.18979585f, -0.12314969f, 0.04256925f, 0.06453642f, 
    0.00043766f, -0.01935809f, 0.19115248f, 0.08088396f, 0.68947268f, 0.17766252f, -0.07296883f, 0.18585841f, 
    0.11040766f, 0.09320948f, 0.07491652f, 0.02440784f, -0.10397048f, 0.03954007f, 0.34765205f, 0.00874476f, 
    -0.22672425f, -0.93996626f, -0.19466835f, -0.41235131f, -0.17345329f, 0.30216154f, -0.05128553f, 0.15088411f, 
    -0.07507187f, 0.37124607f, 0.03603258f, 0.13466240f, -0.46223569f, -0.50398070f, -0.36163309f, 0.14605831f, 
    -0.04959719f, 0.32805169f, 0.11343510f, 0.10950308f, 0.08471302f, 0.03886365f, -0.15384288f, -0.00713494f, 
    -0.85071635f, 0.38917440f, 0.32018742f, -0.04673062f, -0.08181558f, -0.18311051f, -0.12420503f, -0.15300721f, 
    -0.25034264f, 0.00737514f, -0.12431204f, 0.00004058f, 0.23372792f, -0.17273697f, -0.22096863f, -0.47084290f, 
    -0.10398544f, 0.09970940f, 0.04534781f, -0.15922160f, 0.09442408f, -0.15553510f, 0.02313995f, -0.25300127f, 
    0.60868621f, -0.28067154f, 0.51895607f, -0.24321063f, 0.11005924f, -0.19030558f, -0.04259954f, 0.03226226f, 
    -0.09971487f, -0.09788901f, -0.01285756f, -0.10404207f, 0.06766198f, 0.35393840f, 0.02009946f, -0.35039720f, 
    0.26786369f, -0.41003379f, -0.06293162f, -0.13421376f, 0.07750539f, -0.16068408f, -0.09351955f, -0.02979619f, 
    0.21121569f, -0.05725299f, 0.48586085f, 0.81875300f, 0.02615367f, -0.01492367f, -0.20480244f, -0.30079129f, 
    -0.07200181f, -0.14877352f, 0.06555829f, 0.05117701f, -0.24900985f, 0.06954029f, -0.18118185f, -0.05101360f, 
    -0.16902731f, 0.16092178f, 0.16215034f, 0.06179899f, 0.12206473f, 0.28031659f, 0.12851812f, -0.09605750f, 
    0.35596147f, -0.01283584f, 0.00384784f, -0.44223258f, -0.23078790f, -0.19023722f, 0.21372569f, 0.30347201f, 
    -0.09254336f, -0.00039904f, 0.03925961f, -0.11251428f, -0.10578183f, 0.32761857f, 0.19160014f, 0.24573015f, 
    0.24388433f, 0.16781317f, -0.29848295f, -0.05123105f, -0.02837916f, 0.08282945f, -0.19511256f, -0.04998251f, 
    -0.13709085f, 0.23702353f, 0.12262106f, -0.78528279f, 0.07044723f, -0.12007136f, 0.06739983f, 0.19498697f, 
    -0.11025494f, 0.14382210f, 0.10604651f, 0.09920114f, -0.07905401f, -0.19118580f, 0.24674574f, -0.23091817f, 
    0.06345867f, 0.08318891f, -0.09939252f, 0.21675286f, 0.12101772f, 0.11589177f, 0.21644326f, 0.26479575f, 
    0.32634342f, -0.98050636f, -0.26825315f, -0.24834023f, 0.09867066f, -0.06548415f, -0.25401589f, 0.38332385f, 
    -0.11468067f, -0.24051157f, -0.02234701f, -0.14953896f, -0.71274710f, -0.13140111f, 0.10996190f, -0.72253692f, 
    0.08760065f, -0.04106287f, -0.02749164f, 0.14305986f, 0.16432354f, -0.05109316f, 0.04477302f, 0.06474999f, 
    -0.03486582f, -0.43684953f, -0.01709305f, 0.06731433f, -0.09360291f, 0.24120688f, 0.03845482f, 0.03035991f, 
    -0.15181917f, 0.15359232f, 0.08578903f, -0.04067437f, -1.41115713f, 0.29892263f, -0.67105401f, 0.49180222f, 
    0.03109213f, -0.29553494f, 0.01174360f, -0.25353938f, 0.12139145f, -0.21964122f, -0.04588026f, -0.13698487f, 
    -0.54295427f, -0.12284148f, 0.34874085f, -0.12601076f, -0.46669042f, 0.27815530f, -0.33199877f, 0.09198748f, 
    0.08342388f, -0.02363220f, 0.03436544f, -0.07853214f, -0.37385666f, 0.74124330f, 0.16585504f, -0.35447729f, 
    -0.30436122f, -0.29319265f, 0.03790474f, -0.45697010f, 0.22887096f, -0.08024000f, 0.19902982f, 0.12398521f, 
    0.07796238f, -0.69091398f, -0.26478556f, -0.09666187f, 0.05264342f, 0.31409350f, 0.14868294f, -0.00833879f, 
    0.01272053f, -0.06673983f, -0.02553167f, 0.09678734f, 0.17184611f, -0.45553577f, 0.56460363f, 0.27128941f, 
    -0.04842297f, -0.01539576f, -0.27442920f, -0.22202668f, 0.00027411f, -0.01549356f, 0.07868016f, -0.00481436f, 
    -0.02278010f, -0.03722730f, 0.09107993f, 0.44562253f, -0.17169699f, -0.11445069f, -0.10374065f, -0.05840265f, 
    0.05625282f, 0.12295654f, -0.18218160f, 0.10816962f, 0.18456300f, 0.04127230f, 0.75863075f, 0.21764512f, 
    -0.19024935f, 0.18765905f, -0.03430746f, -0.02717277f, 0.14011456f, 0.05117951f, 0.38516825f, -0.22216856f, 
    -0.05885744f, 0.21646181f, -0.28807089f, -0.38213253f, 0.21178477f, -0.04595026f, -0.12792836f, 0.02667028f, 
    -0.14759231f, 0.04831613f, -0.25414100f, -0.25199753f, -0.41236570f, 0.55342555f, -0.40670291f, -0.03979484f, 
    -0.14446008f, -0.03119460f, 0.22736645f, 0.05660804f, 0.05808264f, 0.07005574f, -0.33711982f, 0.00532037f, 
    -0.39748010f, 0.18408546f, -0.14896576f, 0.12181140f, 0.20083348f, -0.28729793f, -0.54309779f, 0.26386449f, 
    -0.02074813f, 0.04937578f, 0.06823736f, -0.09668669f, 0.15739225f, -0.01457505f, 0.67848265f, -0.38765612f, 
    -0.49088243f, 0.33679470f, 0.16726954f, 0.03389136f, 0.01108487f, -0.26447111f, 0.30878434f, 0.19458045f, 
    0.24852613f, -0.41831902f, -0.01724911f, 0.23429377f, 0.17505604f, -0.21824369f, -0.02388233f, 0.00625896f, 
    -0.17098346f, -0.07755505f, -0.47773978f, -0.53401917f, -0.31365982f, 0.33797580f, 0.38095039f, -0.15962814f, 
    0.18768397f, -0.07387180f, -0.54778469f, 0.09025842f, -0.40874150f, -0.23257042f, -0.10493573f, -0.47585723f, 
    -0.55073237f, -0.63464588f, 0.53203368f, -0.07416650f, -0.00620607f, 0.36402947f, 0.08892383f, 0.12354495f, 
    -0.00613634f, 0.22593343f, -0.07585663f, 0.06676754f, -0.15027675f, -0.33880362f, 0.19276123f, -0.02208507f, 
    -0.01067676f, -0.38847056f, -0.07895031f, 0.03905008f, -0.17429107f, 0.21659805f, 0.03679958f, -0.14567274f, 
    0.14503482f, 0.36770540f, 0.09108394f, 0.06283812f, -0.13971248f, -0.16859208f, -0.11714829f, -0.01767108f, 
    0.23557159f, -0.26037070f, 0.13587342f, 0.23362714f, 0.64463884f, 0.12255070f, 0.35836977f, -0.14853354f, 
    -0.51779938f, 0.03302897f, 0.21891990f, 0.15277688f, -0.02831256f, 0.06838600f, 0.08155194f, 0.14307790f, 
    0.03954392f, -0.10751820f, -0.18944682f, 0.10388323f, -0.31075752f, -0.20371208f, -0.10034231f, 0.36010653f, 
    0.14052001f, 0.27549833f, -0.00510871f, 0.19420688f, 0.52024269f, -0.19739957f, 0.18679838f, -0.17154984f, 
    0.09292898f, -0.28228816f, 0.13816337f, 0.13266194f, -0.18515359f, 0.33232501f, 0.04997326f, -0.04513051f, 
    0.04864212f, 0.01263394f, -0.61483335f, -0.27345306f, -0.45544916f, -0.24736476f, -0.08575411f, -0.02286354f, 
    -0.21217366f, 0.10607289f, -0.09456170f, -0.27006176f, -0.94293475f, 0.57739002f, -0.38259527f, -0.33701527f, 
    0.04601786f, 0.44544750f, -0.20278789f, 0.19340749f, 0.05492339f, -0.06867476f, -0.31953740f, -0.34585828f, 
    -0.53763616f, 0.81661612f, -0.65274507f, 0.42331484f, 0.24456787f, -0.06387538f, -0.15414032f, 0.02574144f, 
    -0.30719703f, -0.00567609f, 0.25978523f, 0.10308991f, -0.14921902f, -0.38793072f, 0.06807999f, 0.11662004f, 
    -0.17473528f, -0.13140012f, 0.10990399f, 0.13737230f, -0.05181064f, -0.12006238f, -0.37901211f, 0.02248583f, 
    -0.55772942f, 0.06328897f, -0.73626179f, 0.07100901f, 0.05468463f, -0.22999460f, -0.06777311f, -0.12136481f, 
    -0.02730069f, 0.06462339f, 0.28299585f, 0.08134075f, -0.12532715f, -0.46388793f, 0.07331030f, -0.00475389f, 
    0.20687692f, -0.08756167f, 0.02303333f, -0.05336028f, 0.18055589f, 0.18438363f, 0.15084322f, 0.11305648f, 
    0.01889008f, -0.35078785f, 0.22286068f, 0.23974903f, -0.13950710f, -0.18063749f, -0.39979327f, -0.11833923f, 
    0.01725506f, -0.05117835f, -0.14341234f, 0.10485031f, -0.22425658f, 0.02671166f, -0.27300456f, -0.39815739f, 
    0.01980012f, 0.14513025f, 0.05239848f, 0.25389510f, -0.07647406f, -0.14695108f, -0.06072161f, -0.40572938f, 
    -0.86619043f, 0.22013852f, 0.60134864f, -0.53016436f, -0.08427485f, 0.07104998f, -0.01485486f, 0.07354510f, 
    -0.14054325f, -0.00792508f, 0.10489713f, 0.01997562f, -0.24783352f, 0.26954660f, -0.40531191f, 0.36104396f, 
    -0.17612657f, 0.07138830f, 0.09187412f, 0.44733956f, -0.01709063f, 0.29466885f, 0.12165321f, 0.14838283f, 
    -0.33482322f, 0.63617021f, 0.15345153f, -0.20965117f, 0.26416790f, -0.05907719f, 0.23327972f, -0.17059880f, 
    0.02800631f, -0.13793847f, -0.02363241f, 0.07047489f, -0.26985535f, 1.06440389f, -0.63147146f, -0.10253308f, 
    -0.00868182f, 0.04295051f, 0.32052803f, -0.12575540f, 0.12242008f, 0.18246236f, -0.09202965f, -0.15519316f, 
    -0.05766857f, -0.04383447f, 0.29629767f, 0.34650898f, -0.06486699f, -0.00153880f, -0.11583479f, -0.10271040f, 
    -0.21508075f, 0.11041380f, -0.20412983f, -0.22848065f, 0.38134721f, -0.66951090f, 0.62301975f, -0.29818168f, 
    0.23093681f, 0.41349179f, -0.03652699f, 0.14281471f, -0.18249243f, 0.03747542f, 0.29126006f, 0.18376376f, 
    -0.46723166f, -0.63549501f, -0.02717799f, -0.21581708f, -0.40329871f, -0.22551997f, -0.23102918f, -0.48181346f, 
    0.06897169f, -0.19933450f, 0.06188706f, -0.10814795f, -0.01799094f, 0.02712135f, 0.15393837f, -0.44543993f, 
    0.03320315f, 0.07594287f, 0.30943170f, -0.11041674f, 0.01106405f, 0.17840333f, -0.25812396f, -0.16130906f, 
    0.53339344f, 0.42395294f, 0.19034281f, -0.07589657f, -0.04103664f, -0.09856912f, 0.14276536f, 0.00044873f, 
    -0.13457979f, 0.13393144f, 0.21099959f, -0.11506887f, -0.31354329f, 0.06571762f, -0.69035041f, 0.34142691f, 
    0.01089976f, -0.07853916f, 0.19665042f, 0.08823891f, 0.30003619f, 0.02031441f, 0.00941359f, 0.12930772f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.31753334f, 0.25793833f, 0.06395784f, -0.26020443f, -0.14594658f, 0.13597389f, -0.00486952f, -0.30063829f, 
    0.10516822f, 0.13739054f, 0.02538759f, 0.05808778f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
