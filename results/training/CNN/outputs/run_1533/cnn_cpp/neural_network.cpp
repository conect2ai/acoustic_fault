#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17320871f, 0.36126471f, 0.49195248f, 0.38099477f, -0.49359167f, -0.77437139f, -0.93993330f, 0.14239219f, 
    0.64742571f, 0.38303605f, 0.39645970f, -0.24784134f, 0.11078871f, 0.43455517f, -0.42644975f, -0.29385751f, 
    0.49360064f, 0.16233115f, -0.42153981f, -0.68547869f, -0.11237318f, -0.12510076f, 0.23223251f, 0.37848133f, 
    0.02489696f, -1.20337403f, -1.17730892f, -0.88772070f, -1.05615890f, -0.77358264f, 1.10852313f, 0.05502985f, 
    -0.98904479f, -0.58615649f, 0.42447868f, -0.41453716f, -0.85628885f, -0.93434280f, -0.20712964f, -0.48334825f, 
    0.08899032f, -0.29484329f, -0.29722127f, -0.36629683f, -0.64310455f, -0.24455322f, -0.07402368f, 0.12781727f, 
    -0.25441951f, -0.14713137f, -0.80680853f, -1.66899467f, -0.49933133f, 0.43703932f, 0.54324853f, -0.69544345f, 
    -0.52104592f, -0.44638860f, 0.18025845f, 0.52897984f, 0.43789622f, 0.17434597f, 0.42119020f, 0.65588677f, 
    -0.37734047f, 0.06059196f, -0.12895533f, -0.31895313f, 0.17684644f, -0.04180887f, 0.00489514f, -0.15664318f, 
    -0.27471030f, -0.23940666f, 0.26936567f, -0.62515551f, 0.70706666f, -0.67758507f, -1.07937324f, 0.43931529f, 
    -0.43383637f, -0.06612432f, 1.06168568f, 0.60797703f, 0.76753014f, 0.07865458f, -0.55034685f, -0.31118530f, 
    -0.48815376f, -0.02709113f, 0.25089288f, -0.15592755f, -0.04179673f, 0.02637936f, 0.09911990f, -0.12649077f, 
    0.05720636f, 0.15852782f, 0.09011438f, 0.24770577f, 0.30697200f, 0.37803265f, -0.25902954f, -0.08135128f, 
    -0.18478467f, -0.02810976f, 0.13156992f, 0.14315161f, 0.02468022f, 0.12601271f, 0.16870391f, 0.22686943f, 
    0.52774894f, -0.40768239f, -0.20579469f, -0.38300270f, -0.17469622f, 0.03213207f, 0.30602381f, -0.49755576f, 
    0.56656981f, 0.40183231f, 0.25720122f, -0.10939542f, -0.25308123f, 0.35604045f, 0.05257685f, -0.80391687f, 
    -0.81053787f, 0.34550443f, 0.19781184f, 0.33070487f, -0.46059856f, 0.28993613f, 0.09562153f, -0.01468971f, 
    -0.15916805f, -0.01019949f, 0.09993099f, 0.24722758f, -0.13552575f, -0.35680339f, 0.18707386f, -0.18765733f, 
    -0.45714039f, 0.13334391f, 0.34748337f, -0.39102301f, 0.11744762f, 0.47822708f, -1.24446976f, -0.65853512f, 
    -0.76538181f, -0.78371394f, -0.83459544f, -0.35345459f, -0.08178039f, 0.60580665f, 0.83245397f, 0.30168334f, 
    0.08494456f, 0.44284561f, 0.05278863f, 0.23805213f, -0.55543023f, -0.44148788f, -0.36403653f, -0.19396500f, 
    -0.34836668f, -0.41318733f, -0.03375482f, -0.15682003f, 0.22700997f, 0.29073325f, -0.10173167f, -0.72192228f, 
    -0.58545250f, -1.15509248f, -0.82329786f, -0.59463036f, -0.48365274f, -0.15900563f, -1.01519835f, -1.74179721f, 
    -1.10248661f, 0.75945699f, 0.52305609f, 0.40182930f, 0.10185990f, 0.17040075f, 0.17495695f, -0.21374546f, 
    -0.15054008f, -0.03272886f, -0.15895367f, 0.17749965f, 0.07755601f, 0.18706778f, 0.54681718f, -0.23792578f, 
    -0.85455734f, 0.71464729f, 0.85113138f, -0.19109590f, 0.47323936f, -0.19229901f, -0.06716185f, 0.40815082f, 
    0.59650010f, -0.28287056f, -0.92206126f, -0.52668685f, 0.42802933f, 0.07794935f, -0.11943804f, 0.30059919f, 
    -0.23169437f, -0.36861372f, -0.07399888f, 0.56345677f, 0.11177185f, -0.38239393f, -0.16678835f, 0.01610563f, 
    -0.05391313f, -1.10908210f, 0.75801021f, -0.01177822f, 1.16110134f, -0.32045951f, 0.40993512f, -0.56774914f, 
    -0.58653021f, 0.22053544f, 0.46554583f, 0.14521825f, 0.10665809f, -0.07599192f, -0.19119677f, -0.19036466f, 
    0.13425927f, -0.20627114f, -0.03128865f, -0.07124981f, -0.27279887f, -0.57571912f, -0.50064975f, -0.49011213f, 
    -0.78500503f, -1.28151548f, 0.78777003f, -0.01057837f, 0.18375154f, 0.62175381f, 0.34177679f, 0.39026800f, 
    0.57061619f, 0.02084423f, -0.17731848f, 0.01951225f, 0.18802467f, 0.72154200f, 0.18281253f, -0.20973888f, 
    -0.05364392f, -0.02803620f, -0.15116002f, -0.03750056f, -0.17460072f, 0.01655900f, 0.12027179f, -0.21025841f, 
    0.25981596f, 0.17470576f, -0.09220677f, -0.96044177f, -0.41898778f, 0.29006615f, 0.72468120f, 0.57857323f, 
    -0.49787593f, -0.32423607f, 0.42099848f, -0.07294737f, 0.19252157f, -0.21898103f, 0.49437475f, -0.43591478f, 
    0.32790780f, -0.40941498f, 0.01574196f, 0.44698751f, 0.10442576f, -0.08831106f, 0.17067008f, 0.07821719f, 
    0.12136690f, 0.06551583f, -0.37620705f, -0.15211642f, 1.35138261f, 0.41953686f, 0.29365975f, 0.06314680f, 
    0.20709130f, -0.50803238f, -0.23889753f, 0.29647908f, -0.30306756f, -0.75682539f, -0.35485950f, -0.13971585f, 
    0.13167953f, -0.28612867f, -0.11998099f, 0.23028302f, 0.42998108f, -0.22564994f, -0.33511040f, -0.00234518f, 
    -0.26586062f, 0.14239356f, 0.08847623f, 0.34730729f, 0.07479544f, -1.55423844f, -1.29694307f, -0.39806768f, 
    0.64965671f, 0.50981027f, 0.75088906f, 0.56174588f, 0.29089332f, 0.67412883f, 0.86111999f, 0.20462236f, 
    -0.02533844f, 0.00862362f, 0.20841454f, -0.25122088f, -0.02793332f, 0.04396738f, -0.04864883f, -0.19661403f, 
    -0.08677373f, -0.01891817f, 0.02491714f, 0.05006776f, -0.09584163f, -0.09642410f, -0.42782572f, -1.39592957f, 
    -0.27795109f, 0.66979986f, 0.99583650f, -0.83460516f, -0.14585796f, -0.05217483f, -1.44482219f, -1.18111217f, 
    -0.29452181f, -0.83209008f, 0.56407249f, -0.66294402f, -0.63483673f, 0.00214646f, -0.64875764f, 0.16734955f, 
    -0.22869515f, 0.26839399f, 0.14739938f, -0.31284010f, -0.06660070f, 0.03207399f, 0.00776428f, 1.30101073f, 
    -1.29001904f, -1.37298679f, -0.30775040f, -1.02355182f, 0.80799234f, 0.48619109f, 0.62411308f, 0.17745592f, 
    -0.03493036f, -0.25004736f, -0.05033660f, -0.02445542f, -0.14153586f, 0.38168594f, -0.10412814f, -0.30973327f, 
    -0.00495126f, -0.13486803f, -0.02500372f, -0.00967457f, -0.23897496f, -0.37266237f, -0.22018038f, -0.03932319f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49018711f, -0.19559713f, 0.33518541f, 0.39342949f, 0.73729229f, 0.63577032f, 0.66129953f, -0.11265600f, 
    0.82742763f, -0.15412375f, -0.09175391f, 0.79449910f, 0.37215269f, 0.40476960f, 0.25801980f, 0.21928816f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.43723723f, -0.51718754f, 0.30458662f, -0.98566252f, -0.19765154f, -0.02337416f, -0.19626050f, -0.03319952f, 
    -0.03480829f, -0.23895787f, -0.24631326f, 0.03239179f, 0.53011012f, 0.31197745f, -0.12086104f, -0.20740746f, 
    0.12878418f, 0.24876447f, 0.02961691f, -0.15463030f, -0.20087740f, -0.09262018f, -0.08846408f, 0.05351745f, 
    0.61413616f, 0.63018405f, 0.28882632f, -0.70530725f, -0.04833687f, 0.11544622f, 0.43113175f, -0.07778532f, 
    0.03458498f, -0.24469166f, -0.11058640f, 0.06463683f, -0.44904739f, -0.04658529f, -0.20819660f, -0.11838745f, 
    -0.00039236f, 0.20543729f, 0.12114635f, -0.00064494f, 0.25578156f, -0.19974069f, 0.08034275f, -0.03882438f, 
    -0.28640422f, -0.23862880f, -0.23408641f, 0.05632471f, -0.07573713f, -0.12910797f, 0.01563923f, -0.11311059f, 
    -0.13846850f, -0.08284846f, -0.21949413f, -0.03565137f, -0.08480523f, -0.14604525f, -0.47089851f, -0.15874042f, 
    0.05852882f, -0.08679324f, -0.07535415f, -0.48354423f, -0.45392704f, -0.40061221f, -0.12984632f, -0.23191224f, 
    0.12761392f, 0.03147793f, -0.00813667f, -0.12618485f, 0.07411020f, 0.18571046f, 0.00131550f, 0.07258496f, 
    -0.14675130f, -0.13593338f, -0.04058114f, 0.04084816f, 0.49697697f, 0.45407099f, -0.37319076f, -0.21618870f, 
    0.14542413f, 0.00878903f, -0.04416291f, 0.02268047f, -0.05933325f, 0.00357872f, 0.02805488f, -0.02202654f, 
    -1.23998225f, -0.48436162f, -0.09540208f, 0.01791690f, 0.06096045f, -0.00302750f, -0.00251740f, 0.15544301f, 
    0.02265626f, -0.05082434f, -0.00193257f, -0.16027465f, -0.18240790f, 0.29205978f, 0.00555675f, -0.06583121f, 
    -0.03254936f, -0.04573570f, 0.07364812f, 0.15333262f, -0.16767570f, 0.12282273f, 0.08487537f, 0.25734153f, 
    -0.07558052f, 0.02726257f, -0.04423738f, 0.02288486f, 0.00339045f, 0.03728132f, 0.03400326f, 0.11882091f, 
    -0.10034803f, -0.05772182f, 0.09062860f, -0.13645230f, 0.28691050f, 0.14732280f, 0.26860502f, -0.37215608f, 
    -0.07051211f, -0.14850022f, -0.06308527f, -0.00736543f, -0.16911848f, -0.18898481f, -0.48198971f, -0.04408723f, 
    -0.31893304f, -0.03548806f, -0.34549043f, 0.27998784f, -0.05766609f, -0.08467598f, -0.09739137f, 0.03564512f, 
    0.04829339f, 0.11707059f, 0.01533589f, 0.04655984f, 0.34760764f, 0.13756846f, 0.03523793f, -0.03602080f, 
    0.11312979f, 0.09760110f, 0.19528238f, 0.00658570f, -0.15342180f, 0.07393588f, -0.08890586f, -0.19630429f, 
    0.73658228f, -0.15915908f, 0.03330452f, -0.21152475f, 0.28759995f, -0.01474104f, 0.02973742f, -0.10974690f, 
    0.01319539f, -0.09951209f, -0.09447370f, -0.07848889f, 0.08198682f, -0.09127483f, -0.41528332f, 0.06711101f, 
    0.24063320f, 0.09429464f, 0.00296423f, -0.27999273f, -0.03112905f, 0.06598234f, -0.16278251f, 0.15013777f, 
    -0.41416821f, 0.49706537f, 0.37753281f, -0.44068304f, 0.23962970f, 0.04509425f, 0.07153614f, 0.11212378f, 
    0.11606435f, 0.04488150f, -0.01276979f, -0.04715803f, 0.67045158f, 0.47520515f, 0.23766661f, 0.22743386f, 
    0.09034259f, -0.12789729f, 0.07827823f, 0.34815937f, 0.10926106f, -0.01776061f, -0.12577125f, -0.16515499f, 
    -0.79256845f, -0.21191829f, -0.27832475f, 0.20413181f, 0.16440612f, 0.18770416f, 0.27998701f, -0.26100948f, 
    0.03817471f, -0.13731579f, 0.05496060f, 0.01352508f, -0.75731146f, 0.36177781f, 0.21328112f, -0.05024489f, 
    0.01157873f, -0.01765118f, -0.05988384f, -0.15596214f, -0.24278027f, 0.08195416f, -0.10234416f, 0.01846656f, 
    0.01220141f, 0.01657496f, 0.20674507f, 0.01550290f, 0.13644174f, 0.00320024f, -0.05527015f, 0.18578906f, 
    -0.04687237f, -0.06412192f, -0.10713590f, 0.10177320f, 0.31471184f, 0.01555557f, -0.07888533f, 0.12733418f, 
    -0.01587315f, 0.26647016f, 0.14874506f, 0.00895298f, 0.16127370f, 0.12119249f, 0.03427196f, -0.32852769f, 
    -0.39517799f, -0.34890586f, -0.44099340f, -0.37794197f, 0.01895101f, 0.24275517f, 0.11634628f, 0.15845175f, 
    0.11894565f, -0.00808378f, 0.02098777f, -0.02759211f, 0.14928481f, -0.14260325f, 0.40395868f, 0.05792717f, 
    -0.10995875f, 0.10459401f, 0.07036793f, -0.15476461f, -0.06094263f, 0.01598287f, -0.04544218f, 0.16030627f, 
    0.03457100f, 0.06966576f, 0.16571255f, 0.18223719f, -0.09485044f, -0.09149719f, -0.01914621f, 0.03659994f, 
    0.14417438f, 0.17265372f, 0.02080188f, -0.08201458f, -0.19999830f, 0.13750248f, 0.03778762f, -0.08211369f, 
    -0.07017789f, -0.00743349f, -0.04415888f, 0.04017305f, -0.43987629f, -0.34996530f, -0.31553310f, -0.26630545f, 
    0.31663051f, 0.14161184f, 0.19014329f, 0.16194506f, -0.07869533f, -0.18024728f, -0.07103181f, -0.13938324f, 
    0.01177448f, 0.07062653f, -0.05124943f, 0.11113813f, -0.56970567f, 0.20593528f, 0.01975412f, 0.00437608f, 
    0.03580112f, 0.21414454f, 0.06850398f, 0.15403911f, 0.03682338f, -0.16402777f, -0.09689405f, 0.17802745f, 
    0.52045465f, -0.06347609f, 0.03475472f, 0.02241720f, -0.07203329f, -0.21037650f, 0.00274724f, -0.21578605f, 
    -0.10828907f, 0.01579065f, -0.03683206f, 0.06789504f, 0.15232027f, 0.05466552f, -0.21419904f, 0.11651903f, 
    -0.14902414f, -0.06688082f, 0.00088961f, -0.08844882f, -0.12891479f, 0.01547666f, -0.06285667f, 0.17350452f, 
    -0.59758800f, -0.16944814f, -0.27461579f, -0.36564645f, -0.19216192f, -0.12469199f, 0.14502372f, -0.55773234f, 
    0.08002446f, 0.10443375f, 0.01915542f, -0.04799400f, 1.00264776f, -0.16106142f, -0.10048564f, -0.12508385f, 
    -0.07775780f, 0.05329116f, -0.09751976f, -0.43236366f, 0.11217542f, -0.33144653f, -0.21589909f, -0.21668565f, 
    -0.93176180f, -0.26199979f, -0.19557664f, -0.15063554f, 0.01785620f, 0.00151989f, 0.11106882f, -0.13807967f, 
    0.02856657f, -0.12778278f, 0.14161091f, 0.03984843f, -0.78315669f, 0.08666755f, 1.08305073f, 0.32802984f, 
    -0.21145621f, 0.17145562f, -0.10979345f, -0.10075726f, 0.01210729f, -0.03950541f, -0.01185559f, -0.15222508f, 
    0.03315369f, -0.24689823f, -0.30257323f, 0.18304442f, -0.14836361f, 0.02364530f, -0.55812168f, 0.13088630f, 
    -0.09847954f, -0.11174340f, 0.20041813f, -0.08596279f, 0.18380125f, 0.42155793f, -0.08347650f, 0.22133897f, 
    -0.01526675f, -0.05677019f, 0.01585085f, 0.02751081f, -0.10599685f, -0.02671217f, -0.30332670f, 0.06325688f, 
    0.03205339f, -0.13678801f, -0.21882452f, 0.07838828f, 0.17045934f, 0.08233793f, -0.06428745f, 0.21320948f, 
    0.08072924f, -0.22269350f, 0.22790265f, 0.02901541f, -0.23408483f, -0.09362495f, 0.19168815f, 0.20271605f, 
    0.08602799f, 0.33126926f, -0.18088455f, 0.16357385f, -0.02749518f, 0.00392579f, -0.15805295f, 0.08159060f, 
    0.32369184f, 0.88021725f, 0.03257823f, 0.26909715f, -0.10963351f, 0.02099039f, 0.10897049f, 0.03076008f, 
    -0.25966007f, -0.13710228f, -0.13773736f, 0.08486711f, -0.91872108f, -0.84551120f, 0.10319267f, -0.69449431f, 
    0.04192690f, -0.44970739f, 0.00257306f, -0.14184171f, -0.04794133f, 0.02399678f, -0.02188907f, -0.02532200f, 
    0.18524951f, 0.04918104f, -0.61126018f, 0.12468359f, -0.06540823f, -0.07322860f, 0.04533837f, 0.04175591f, 
    -0.11311473f, 0.17019364f, -0.06722537f, -0.26960662f, 0.28407854f, -0.00817084f, -0.08032990f, 0.09280168f, 
    0.00143026f, -0.17050794f, 0.04325444f, -0.03165660f, 0.15876783f, 0.09160996f, 0.24189898f, -0.04519888f, 
    -0.25181541f, -0.07241596f, -0.06800672f, -0.09809254f, -0.01592349f, -0.13738447f, 0.03114020f, 0.16482444f, 
    -0.07254515f, -0.05975015f, -0.05222158f, 0.02356280f, 0.10962230f, -0.00898693f, -0.38552296f, 0.11146870f, 
    -0.06589946f, 0.05800135f, 0.02601535f, 0.04534353f, 0.17975388f, 0.07396038f, -0.01515938f, 0.19097383f, 
    -0.19641308f, -0.14921926f, 0.04080688f, -0.02107918f, -0.17412966f, 0.03572272f, 0.06545464f, -0.04697996f, 
    0.06819468f, -0.06275375f, -0.14863688f, 0.06837342f, -0.25162601f, -0.23392342f, 0.43363190f, 0.32510507f, 
    0.03577932f, 0.00978078f, 0.08763245f, 0.22855926f, -0.04901897f, -0.08960286f, 0.02357583f, 0.09233964f, 
    0.05392297f, 0.13811830f, -1.07048059f, -0.29611808f, -0.15804127f, -0.08769917f, 0.19624034f, -0.03544266f, 
    -0.06798784f, 0.06654087f, 0.10241446f, -0.18198057f, -0.24511084f, 0.73732680f, 0.54350948f, 0.19351849f, 
    -0.15306303f, 0.04064363f, 0.03675250f, -0.09721049f, -0.01435250f, 0.21655691f, 0.14001903f, 0.22483853f, 
    0.43083611f, -0.16629362f, 0.34281662f, -0.00448391f, -0.14958102f, -0.22001402f, -0.23129719f, -0.18969902f, 
    0.04463670f, -0.11218227f, -0.19536416f, -0.10051325f, -0.11884277f, -0.18085508f, -0.13340501f, 0.34274501f, 
    -0.00164065f, 0.03774581f, -0.15633823f, -0.15760957f, -0.04997720f, 0.00137893f, 0.04214577f, 0.21237113f, 
    -0.32901379f, -0.12151518f, -0.43531480f, -0.00878975f, -0.08862235f, -0.04690459f, -0.12524456f, -0.11126179f, 
    -0.12835084f, 0.09701646f, -0.12766233f, -0.23951855f, 1.66153920f, -0.10762940f, -0.61699247f, 0.23664872f, 
    0.21409027f, -0.08363377f, 0.00366134f, -0.01907609f, -0.02635356f, -0.08524708f, 0.14559536f, 0.00596553f, 
    -0.38407812f, 0.12785400f, -0.23424110f, 0.08555899f, -0.11570281f, 0.23314545f, -0.32492015f, -0.29070568f, 
    0.04326277f, 0.09552528f, -0.04256352f, -0.15427803f, -0.04166207f, 0.13375959f, -0.21534674f, 0.56498545f, 
    0.20795774f, -0.36547801f, -0.27628955f, -0.09050304f, -0.21761931f, -0.44318983f, 0.03690619f, -0.11043918f, 
    0.31003958f, -0.20394877f, 0.04553004f, 0.36618552f, 0.07047434f, -0.09939113f, 0.04661356f, -0.09918964f, 
    0.05358792f, 0.15285014f, -0.15079303f, 0.17995222f, -0.10840151f, -0.11952811f, -0.09000184f, 0.41320494f, 
    0.18918805f, 0.02504860f, 0.14436668f, 0.03520307f, 0.05128085f, 0.03600014f, 0.12749788f, -0.06096958f, 
    0.73406452f, 0.10557393f, 0.17888522f, -1.08744013f, -0.33254424f, -0.13121183f, -0.07556046f, 0.12470990f, 
    0.05997147f, -0.10857678f, 0.24670963f, -0.28694126f, -0.12624599f, 0.54350787f, 0.06631777f, 0.06096475f, 
    -0.02513758f, 0.17991081f, -0.02688994f, 0.03921045f, -0.03688904f, -0.01899175f, -0.09440664f, -0.02318384f, 
    -0.34662139f, -0.72681713f, -0.08906531f, -0.02261367f, 0.10367762f, -0.50110573f, 0.23771901f, -0.33114630f, 
    -0.10107187f, 0.23014122f, -0.23557453f, -0.07898332f, 0.29371238f, 0.41143665f, -0.36237714f, -0.51826507f, 
    -0.22206967f, 0.00019000f, 0.04835822f, 0.07832672f, -0.03658322f, 0.11419138f, -0.22301996f, -0.02088180f, 
    -0.62932360f, -0.37412900f, 0.49255982f, 0.27798405f, -0.03048599f, -0.19169846f, -0.30427435f, -0.20389713f, 
    -0.09601270f, 0.16354004f, -0.09182464f, -0.11077477f, -0.26287770f, 0.28686655f, -0.02461410f, -0.72543490f, 
    0.65639800f, 0.44796467f, 0.19670415f, 0.07797732f, -0.42575020f, 0.15392743f, -0.08876741f, -0.13318130f, 
    -0.16196284f, 0.71002609f, -0.42319527f, 0.36096880f, -0.05893411f, 0.05572582f, -0.00407043f, -0.10246468f, 
    -0.13174796f, -0.05564322f, 0.01358146f, -0.06902844f, -0.61275554f, 0.20679012f, 0.03490550f, 0.49408036f, 
    0.17017554f, 0.14685576f, 0.01828831f, -0.10504138f, -0.19245100f, 0.19090712f, 0.06064911f, 0.08153779f, 
    -0.60106057f, -0.02427675f, -0.45009264f, 0.40007290f, -0.35233909f, -0.16439684f, -0.15328078f, 0.08042686f, 
    -0.14748774f, -0.00953465f, -0.03254705f, -0.11477169f, -0.23633632f, -0.07724069f, -0.03513232f, 0.16570462f, 
    0.04743405f, -0.01511920f, -0.15478612f, -0.13691702f, -0.04530685f, 0.05910805f, 0.23251560f, 0.12788074f, 
    0.37293011f, 0.08155280f, 0.05505788f, 0.25295067f, -0.10143218f, -0.00632133f, -0.22442694f, -0.10419301f, 
    -0.19321084f, 0.21263982f, -0.14605016f, -0.00275565f, -0.29440561f, -0.20492733f, -0.37092236f, -0.33950266f, 
    0.11758801f, 0.06118178f, -0.07744533f, 0.34296703f, 0.05489077f, -0.09061883f, -0.36400586f, -0.23598738f, 
    -0.01750915f, 0.17171672f, -0.08573230f, -0.10044850f, 0.09253221f, 0.02760010f, 0.05252505f, -0.12288503f, 
    -0.07701322f, -0.18192701f, -0.38050443f, -0.46529344f, -0.23281716f, -0.23220167f, -0.04873537f, 0.04689593f, 
    -0.15611546f, -0.07302930f, -0.22044817f, 0.05168586f, -0.23074754f, 0.08511174f, -0.01909979f, -0.13690189f, 
    0.18252936f, 0.21744049f, 0.18758504f, 0.32577723f, 0.03205737f, -0.16559607f, 0.06806613f, 0.03943599f, 
    -0.15815002f, -0.06257642f, -0.02212678f, -0.01568705f, 0.36813125f, 0.36838809f, 0.22623695f, 0.28839222f, 
    -0.01653526f, -0.04665542f, -0.04279519f, 0.00264799f, 0.05841460f, 0.12555905f, 0.06617508f, 0.04795695f, 
    -0.08472577f, -0.66473138f, -0.15825328f, -0.49514768f, 0.13789068f, 0.01069415f, -0.05178995f, -0.07947483f, 
    0.01778218f, -0.11332795f, -0.11284027f, 0.15150204f, 0.55076212f, -0.26445150f, -0.25810432f, 0.09591399f, 
    0.04529212f, -0.07234782f, 0.02809682f, -0.16647092f, 0.17039359f, 0.29555538f, 0.44104692f, 0.48859090f, 
    -0.03627831f, 0.05926837f, -0.08465655f, 0.09176052f, 0.30211779f, 0.07489111f, 0.07006760f, 0.00181095f, 
    0.12684661f, 0.04085446f, -0.02578938f, 0.00462036f, -0.08587827f, -0.60700971f, 0.28345165f, 0.33967456f, 
    -0.41437876f, -0.25524694f, -0.15966490f, -0.21311763f, -0.07678045f, -0.13205588f, 0.13191004f, -0.04327324f, 
    0.10903872f, 0.10271800f, 0.21893115f, 0.11538661f, -0.07098076f, 0.12826058f, -0.02028329f, 0.20128830f, 
    0.09317192f, -0.07378713f, 0.03788438f, -0.13112131f, 0.27389431f, -0.30520394f, -0.05229546f, 0.07298051f, 
    -0.15341301f, 0.11463995f, 0.02959053f, 0.01286341f, 0.01428617f, -0.07348682f, -0.05610382f, -0.00959089f, 
    -0.18054542f, -0.13100089f, 0.35099015f, -0.22664374f, -0.10377945f, 0.14844778f, -0.08324248f, 0.15534171f, 
    -0.07675474f, -0.13289776f, -0.06303184f, -0.03440330f, -0.23881608f, -0.09439805f, 0.18463013f, -0.01239404f, 
    -0.12369870f, -0.12654696f, -0.03405310f, 0.05737840f, 0.01656292f, -0.09033871f, -0.13950810f, 0.21387984f, 
    0.16592291f, -0.10133956f, -0.25177816f, 0.22489172f, 0.07993858f, 0.06377223f, -0.09458902f, -0.01501874f, 
    -0.06090789f, 0.00187355f, 0.14976059f, 0.00451804f, -0.18928331f, 0.17378019f, 0.11929899f, -0.50603229f, 
    -0.05287673f, -0.08503927f, 0.10311525f, 0.03539947f, -0.02774431f, -0.03615015f, -0.15321201f, 0.00372414f, 
    0.17018025f, -0.34669793f, 0.47653043f, -0.12483846f, -0.07725839f, 0.07790364f, 0.00940395f, 0.14882359f, 
    0.28188482f, -0.06601382f, -0.02240301f, 0.15592428f, -0.01702676f, -0.02828841f, 0.02563417f, -0.07976916f, 
    -0.15210657f, -0.07541504f, -0.11531229f, -0.16387221f, 0.07320572f, -0.13500229f, -0.04872387f, 0.21098629f, 
    0.16766885f, -0.18221632f, -0.16242853f, -0.16897270f, -0.29585955f, -0.25437754f, -0.14557406f, 0.01046870f, 
    0.16335389f, 0.11808255f, 0.24608807f, -0.05912247f, -0.19522390f, 0.03520369f, -0.05234145f, -0.55326432f, 
    -0.12944156f, -0.16206819f, 0.07839384f, 0.05430106f, 0.32719550f, -0.00812077f, 0.00850697f, 0.38577193f, 
    -0.13056515f, -0.11544973f, -0.13634756f, 0.02770563f, -0.01068637f, -0.06119567f, -0.08953168f, -0.16072863f, 
    0.07143481f, -0.00083062f, 0.11840334f, -0.22627768f, -0.04400857f, 0.41145691f, 0.06678848f, -0.20950337f, 
    0.33538005f, 0.27274072f, 0.08532331f, -0.09804610f, 0.13261695f, 0.05881772f, -0.00164306f, 0.00202961f, 
    -0.36458564f, -0.05720660f, 0.29018092f, 0.71031320f, 0.14481692f, 0.02185571f, 0.04401705f, 0.12261543f, 
    -0.03363081f, -0.15840545f, -0.06963100f, 0.01023150f, -0.19971305f, -0.20694797f, 0.04077977f, -0.02255285f, 
    -0.01412469f, 0.07522779f, -0.07272381f, 0.17262183f, -0.01675990f, -0.64689714f, -0.43944436f, -0.48573363f, 
    -0.03077296f, -0.05089408f, -0.09579105f, 0.11119672f, 0.20300628f, 0.00958173f, -0.14725854f, -0.00304576f, 
    0.12311324f, -0.15192783f, 0.22523181f, -0.04485812f, 0.31636229f, -0.36524373f, 0.33956853f, 0.16157486f, 
    0.07910596f, -0.39714554f, -0.02119843f, -0.02113105f, -0.09194942f, 0.14122991f, 0.26361740f, -0.19959272f, 
    -0.03995810f, -0.16109973f, -0.23905431f, 0.19768275f, 0.19374683f, 0.30629751f, -0.04711384f, -0.07398706f, 
    0.13176757f, -0.07165547f, 0.09120075f, 0.07285203f, -0.61201149f, -0.82470316f, -0.05063054f, -0.18194619f, 
    -0.00758803f, -0.10423590f, -0.12140694f, -0.08417469f, 0.18499170f, -0.09816322f, 0.06091842f, 0.09396331f, 
    0.46911794f, 0.18711908f, 0.25976598f, -0.05026411f, 0.16157246f, 0.08494901f, 0.05441255f, 0.24399634f, 
    0.09828181f, 0.01235801f, -0.05058824f, 0.06965682f, -0.06535245f, -0.26269615f, -0.38486376f, -0.41280937f, 
    0.08729400f, -0.02291377f, -0.01619704f, 0.27845150f, 0.08237424f, 0.04235579f, 0.01763506f, -0.47055370f, 
    0.69198656f, -0.08512867f, -0.49389511f, -0.38893226f, -0.34099820f, 0.15900515f, 0.06798378f, 0.03303669f, 
    -0.10580472f, 0.11479293f, -0.48432434f, -0.13643232f, -0.80064738f, -1.45357347f, -0.21970512f, -0.11459573f, 
    -0.12138497f, -0.12602587f, -0.04747109f, -0.19212420f, -0.19038218f, 0.13710451f, 0.10009151f, 0.07896033f, 
    -0.89304525f, -0.14201328f, 0.53814644f, -0.40838382f, -0.50946927f, -0.16963120f, -0.01865846f, 0.29216188f, 
    -0.09917004f, 0.06931943f, -0.06598954f, 0.00341813f, 0.29551816f, -0.16639747f, -0.30604514f, 0.84834987f, 
    -0.08991936f, -0.16272013f, 0.02643444f, 0.47030193f, 0.04198621f, 0.03512793f, 0.53714460f, -0.44219932f, 
    0.23161511f, 0.04019257f, -0.09870521f, -0.07951672f, -0.02092846f, -0.07697513f, 0.11617537f, -0.00169194f, 
    -0.06905052f, 0.19124031f, -0.18792896f, -0.03085001f, 0.05609662f, 0.28684640f, -0.06994007f, -0.02434838f, 
    0.25505072f, -0.26901713f, 0.20889875f, 0.15218036f, 0.14056055f, 0.18694337f, -0.02847536f, 0.10177940f, 
    -0.51970530f, 0.57757640f, 0.81974983f, 0.20230485f, -0.20757559f, 0.05649902f, -0.16388564f, -0.06805442f, 
    -0.11802790f, 0.18302029f, -0.12777109f, 0.05864004f, -2.09239531f, -0.62480181f, 0.09586997f, -0.53275263f, 
    -0.39520526f, -0.22867011f, -0.49324724f, -0.36734566f, -0.11807790f, 0.01769047f, 0.04568236f, -0.14505522f, 
    -0.06672006f, 0.09521447f, -0.10207768f, -0.19568253f, 0.05980178f, 0.14686838f, -0.00925263f, -0.24618924f, 
    -0.12969245f, -0.14167829f, 0.04686946f, 0.15323794f, -0.12205818f, -0.15765026f, 0.00660633f, 0.06991338f, 
    0.00972883f, 0.13960028f, 0.08491350f, 0.14060099f, 0.54783911f, 0.35480848f, 0.36803889f, 0.05088869f, 
    -0.09452054f, -0.02864248f, -0.06372973f, 0.03575568f, 0.09374772f, 0.09931839f, 0.00757069f, -0.09869341f, 
    -0.14304063f, -0.08030085f, -0.32542339f, -0.33128673f, -0.11945826f, 0.04160182f, -0.01548239f, 0.01122574f, 
    -0.14967702f, -0.08134539f, 0.07669253f, 0.03131387f, 0.07442920f, 0.11502720f, 0.38083261f, 0.06061939f, 
    -0.19792716f, -0.06761797f, 0.16429141f, -0.52549154f, 0.05918239f, 0.13496082f, 0.08612043f, -0.02210494f, 
    -0.00170498f, -0.04011147f, -0.04097655f, -0.02074693f, -0.31038383f, 0.16301225f, 0.35330781f, 0.01203864f, 
    -0.06134993f, -0.05794269f, -0.13870783f, 0.09429058f, -0.02806827f, 0.17001644f, 0.09304950f, -0.10163683f, 
    -0.71672815f, -1.07188404f, -0.20851304f, 0.26068929f, 0.20004161f, -0.18938267f, -0.04081254f, -0.27526236f, 
    -0.00700364f, 0.06548751f, -0.00162492f, 0.13382004f, -0.30660233f, 1.01215386f, -0.10403963f, 0.13623439f, 
    -0.07501070f, 0.01924472f, 0.10618699f, -0.06997719f, 0.21187873f, 0.00924183f, 0.11840414f, 0.05308246f, 
    -0.11900419f, -0.37728760f, 0.28908604f, 0.47277448f, -0.27144131f, 0.12386381f, -0.27087197f, -0.11684246f, 
    0.07173614f, -0.29252207f, -0.06943692f, -0.11134277f, -0.02043750f, -1.09769738f, 0.73708338f, -0.97548836f, 
    0.09526715f, -0.25562534f, -0.01641297f, 0.40981477f, -0.16392860f, -0.07729252f, -0.07955513f, -0.00869063f, 
    0.57815623f, -1.30246699f, 0.09389023f, -0.30384856f, 0.28592891f, 0.28534889f, 0.00865726f, 0.26751494f, 
    -0.07022277f, 0.04879406f, -0.04718539f, -0.00791743f, 0.30905938f, -0.53849447f, -0.12826781f, 0.04990567f, 
    0.06032318f, 0.06601825f, 0.21112643f, -0.03158414f, 0.03031933f, 0.11515843f, -0.10519332f, -0.11825813f, 
    0.06819580f, -0.03197632f, 0.00499746f, -0.11410860f, -0.00127338f, -0.03870466f, -0.07531648f, 0.05630100f, 
    -0.04641520f, 0.11224777f, -0.09367704f, -0.05278997f, 0.04769732f, -0.06233107f, 0.54153019f, -0.26895627f, 
    0.06010659f, -0.11867346f, 0.11576979f, -0.07131282f, 0.12306713f, 0.31392840f, 0.10729709f, -0.03615685f, 
    0.43587989f, -1.08652580f, -1.17862070f, -1.14599276f, -0.17132288f, -0.19687648f, -0.29754075f, 0.03975294f, 
    0.11961535f, 0.18479124f, 0.01945661f, 0.07329155f, -1.16935980f, -0.15763444f, 0.19197814f, -0.04171344f, 
    0.19964533f, -0.16584522f, -0.04087944f, 0.24259433f, 0.05747743f, -0.00065053f, 0.04199136f, 0.09858657f, 
    -0.03031817f, 0.14506833f, -0.81931478f, 0.18971291f, 0.05314198f, -0.00670225f, -0.13234882f, -0.17934924f, 
    -0.18553948f, 0.28752008f, -0.03645186f, -0.08474525f, 0.70316172f, 0.01993068f, 0.24559656f, -0.37225217f, 
    -0.09326629f, 0.04330553f, -0.04709016f, -0.04785059f, -0.03624943f, 0.16264470f, -0.07375123f, 0.08717139f, 
    -0.05149062f, 0.16619246f, -0.01276970f, -0.12490371f, -0.05491048f, 0.04651379f, 0.04863650f, 0.11126278f, 
    0.15427700f, -0.08871930f, -0.03464428f, -0.10372873f, 0.37993190f, -0.05909176f, -0.05122771f, 0.01225747f, 
    -0.18915541f, -0.01990910f, 0.00315217f, -0.50271183f, -0.17158435f, 0.03135309f, -0.12902664f, -0.06977822f, 
    -0.23746391f, 0.20125854f, -0.13714096f, -0.09635884f, -0.00660505f, -0.11853991f, 0.06199142f, -0.03079533f, 
    0.06021582f, 0.05740448f, -0.00943645f, 0.03127085f, 0.59176111f, 0.02204901f, -0.13209026f, -0.42053899f, 
    -0.01475755f, 0.12477227f, -0.02832393f, -0.00295459f, -0.03991738f, 0.00997893f, -0.13884392f, -0.36631006f, 
    -0.98535126f, 0.61464733f, 0.50269091f, 0.10448005f, 0.25162381f, -0.19762287f, 0.14978465f, 0.24783532f, 
    -0.02288508f, 0.02438739f, -0.09231318f, -0.01820210f, -0.35072199f, -0.82863820f, -0.30771330f, -0.16018821f, 
    -0.06702524f, -0.09227805f, 0.10823775f, 0.09755684f, -0.14981702f, -0.22652391f, 0.00085400f, -0.10013921f, 
    0.35150033f, 0.48458168f, -0.21036100f, -0.11997160f, 0.24568076f, -0.14370760f, -0.18090643f, 0.23101275f, 
    0.12513487f, 0.27348146f, 0.37179342f, 0.19917987f, 0.18103075f, -0.81568837f, -0.68236208f, -0.38201961f, 
    -0.07026602f, -0.03394935f, 0.13034043f, 0.02493526f, 0.04969306f, -0.01864226f, 0.03597027f, -0.13989201f, 
    1.03184164f, -0.46793410f, -0.57140166f, -0.50616938f, 0.00113009f, -0.11942614f, 0.05419571f, -0.17648557f, 
    0.13524717f, -0.37795326f, 0.19544367f, -0.05029090f, 0.21839303f, -0.21584067f, -0.16485068f, -0.11327375f, 
    -0.18780126f, -0.28428537f, 0.05690282f, -0.10258756f, -0.06013045f, 0.11633120f, 0.07367799f, 0.17222130f, 
    -0.25441247f, 0.11463302f, -0.05948343f, 0.11434762f, -0.04694479f, 0.05356804f, 0.02959804f, -0.10677916f, 
    -0.21130441f, 0.14976099f, 0.12870218f, 0.32435036f, -0.51346409f, -0.27041531f, -0.20949446f, -0.24519746f, 
    0.01437785f, -0.05217017f, 0.16988419f, -0.01070975f, -0.00150989f, 0.21596435f, 0.08722242f, 0.30292636f, 
    -0.42639694f, -0.51604044f, -0.74060118f, 0.33686593f, 0.13576989f, 0.29162583f, 0.16293260f, 0.12747754f, 
    0.12186866f, 0.03762451f, 0.09373856f, -0.05221968f, -0.44221872f, -0.91550893f, -0.72694892f, 0.09282012f, 
    -0.34854937f, 0.10958564f, -0.06006370f, -0.03472204f, -0.01903643f, -0.08771691f, 0.07696010f, -0.03415893f, 
    0.64500374f, 0.41464183f, 0.35790503f, -0.12621519f, 0.04127663f, -0.20567520f, -0.03204399f, 0.03390696f, 
    -0.01974733f, -0.10774025f, -0.20579471f, 0.01874973f, -0.10645296f, -0.13505897f, -0.28843868f, -0.24392627f, 
    0.21712849f, -0.10219415f, 0.08645804f, -0.13945812f, -0.24279986f, 0.15508710f, -0.94712979f, -0.58950216f, 
    -0.41315353f, 0.02682441f, 0.16683294f, -0.24679370f, -0.24003190f, 0.03012208f, 0.02078042f, -0.08424878f, 
    0.12261955f, 0.00371506f, 0.05394396f, 0.11306394f, 0.27750021f, 0.05837502f, -0.41285676f, -0.30597669f, 
    0.26750675f, 0.12483689f, 0.09701519f, -0.05811248f, -0.00993470f, -0.00736927f, -0.10645977f, 0.27910432f, 
    -0.76700127f, 0.29645938f, 0.16209862f, 0.22995020f, 0.08576726f, -0.09311281f, -0.13122599f, -0.13362914f, 
    0.11905815f, 0.09752325f, 0.07355921f, 0.14640997f, -0.16650671f, -0.26759648f, -0.42081460f, -0.45932931f, 
    -0.12951793f, -0.04192377f, 0.08139150f, 0.09338786f, 0.31972918f, 0.17397073f, 0.12815681f, -0.01344489f, 
    1.08284175f, 0.45424592f, -0.05602697f, 0.16789038f, -0.37299544f, 0.08489817f, -0.15135470f, -0.47482473f, 
    0.08664624f, 0.02537837f, 0.01071571f, 0.17815903f, -0.10279740f, -0.80378735f, 0.17340149f, 0.38723671f, 
    0.01842862f, 0.14233273f, 0.20720986f, 0.18453050f, -0.25078711f, -0.09730873f, -0.22123812f, -0.18014975f, 
    -0.32006714f, 0.11996742f, -0.75743854f, 0.40042910f, -0.02700276f, 0.09961104f, 0.10433863f, -0.05120990f, 
    0.07804514f, -0.09280314f, 0.03802798f, -0.05848234f, 0.21076162f, -0.15393516f, -0.13952541f, 0.00054254f, 
    -0.07618438f, 0.29582179f, -0.06867254f, 0.16370186f, 0.20196635f, 0.10544588f, 0.01992315f, 0.00673584f, 
    -0.35503283f, -0.26462373f, 0.40446216f, 0.52396953f, 0.04734022f, -0.50630677f, -0.07686077f, -0.02488013f, 
    -0.11986958f, 0.03460239f, -0.02178988f, 0.03214318f, -0.25457492f, -0.29183677f, 0.17095307f, -0.32309255f, 
    -0.02003436f, -0.42839083f, 0.26263016f, -0.37614194f, -0.23854530f, 0.13909926f, 0.08514797f, -0.16533406f, 
    -0.12683585f, 0.16198887f, 0.22640686f, 0.08850274f, 0.11716714f, 0.19738591f, -0.01466620f, -0.24543339f, 
    0.36099473f, 0.11247143f, -0.42286775f, 0.05228440f, 0.46289742f, -0.16160403f, 0.18080920f, -0.38779265f, 
    -0.10582602f, -0.65284187f, -0.05228444f, -0.30432615f, -0.29538882f, -0.13786221f, -0.17150646f, 0.05613277f, 
    0.20576648f, 0.12345894f, 0.17033827f, -0.08533421f, 0.23220037f, -0.39613435f, -0.16562025f, -0.12247750f, 
    -0.06825253f, -0.03080665f, 0.16466609f, 0.08329115f, -0.28329366f, 0.19785129f, 0.26700622f, -0.68917930f, 
    -0.16443525f, 0.08451609f, 0.03492781f, 0.34088251f, 0.03635321f, -0.04120990f, 0.05130510f, 0.00162888f, 
    -0.97282130f, 0.23101121f, -0.56806082f, 0.18163760f, 0.24679315f, -0.13232970f, -0.01619331f, -0.07498957f, 
    0.00939898f, -0.08295350f, 0.07028992f, 0.22520389f, 0.19366807f, -0.43133506f, 0.30920982f, 0.07471553f, 
    -0.10912509f, 0.16691855f, -0.10496289f, 0.14450856f, 0.08538795f, 0.21517785f, 0.39981809f, 0.14340332f, 
    0.12095614f, -0.51995629f, 0.10518362f, -0.24509157f, 0.28469202f, 0.19425677f, -0.12356282f, -0.08301548f, 
    0.15853482f, 0.04463177f, -0.15705672f, 0.00080859f, -0.24016784f, -0.38068327f, -0.30299819f, 0.37793967f, 
    0.16426103f, 0.30683875f, -0.14165337f, -0.22829656f, 0.21583083f, 0.06062022f, 0.01837130f, -0.06988328f, 
    -0.41569677f, -0.22865589f, -0.75000918f, 0.14822192f, 0.35572273f, 0.01735184f, 0.13366687f, 0.11879523f, 
    -0.08855736f, -0.11764994f, 0.10861532f, -0.17029406f, 0.31010762f, 0.49058071f, 0.34108809f, 0.97972643f, 
    0.27006021f, -0.02019316f, -0.28467491f, -0.23583396f, 0.10225338f, -0.04495367f, -0.02156278f, -0.04157015f, 
    -1.22342050f, -0.55718142f, 0.27156839f, -0.48467028f, 0.18075390f, -0.11192375f, -0.21528235f, 0.38728726f, 
    0.00658056f, -0.06158438f, 0.00806764f, -0.04752899f, 0.09530356f, -0.26585373f, 0.51310188f, -0.33174425f, 
    -0.03698953f, -0.31953332f, -0.20821726f, 0.28753257f, -0.10674118f, -0.06703112f, 0.03043394f, 0.09064860f, 
    -0.58525765f, 0.28200200f, -0.56034553f, 0.03587905f, -0.16529816f, 0.25556913f, 0.37484404f, -0.29826498f, 
    -0.13559146f, 0.08901886f, 0.04939374f, 0.21198961f, -0.08313051f, -0.02590304f, -0.83216536f, 0.35429251f, 
    0.06458548f, -0.19133504f, 0.10308959f, 0.06578834f, 0.12616612f, 0.07125992f, -0.36812150f, -0.54735303f, 
    -1.24162793f, 0.57017004f, -0.36343715f, -0.00198889f, 0.04531445f, 0.20039904f, -0.08641600f, 0.06987327f, 
    -0.14990132f, 0.01352501f, -0.28989360f, -0.04957813f, 0.36592117f, 0.47017494f, 0.49529424f, 0.12784414f, 
    -0.30612874f, 0.11263160f, 0.29777804f, 0.04078827f, 0.15353592f, 0.01532779f, -0.16345105f, 0.27655351f, 
    -0.39742610f, 0.23554979f, 0.27023724f, 0.21738163f, -0.10928793f, -0.12247079f, 0.06448726f, 0.21457072f, 
    0.00652042f, 0.11889862f, 0.28664914f, 0.33968666f, 0.29772982f, 0.44388971f, 0.15702438f, 0.06345776f, 
    -0.01634263f, 0.37135953f, 0.51861745f, 0.02786681f, 0.18133681f, 0.03693695f, 0.50615329f, 0.35538682f, 
    0.17802331f, 0.14160356f, 0.15050936f, -0.53781205f, -0.14182222f, -0.07054985f, -0.14292508f, -0.04711061f, 
    0.12683198f, -0.38214219f, 0.20328395f, -0.33402061f, -0.13362423f, -0.53411585f, -0.09193236f, 0.39113516f, 
    -0.09255152f, 0.13614766f, -0.26984674f, 0.01403319f, 0.07354787f, 0.09676851f, -0.00366144f, -0.08886313f, 
    0.45517972f, 0.00881779f, 0.22040384f, -0.26635212f, -0.60981292f, 0.16292299f, -0.01338513f, 0.09039001f, 
    0.06034187f, -0.19608140f, -0.25720060f, -0.05472732f, -0.17747334f, 0.41967148f, -0.38594961f, 0.03818339f, 
    -0.07676480f, 0.39381954f, 0.09439697f, -0.00958738f, -0.08373977f, -0.37688452f, -0.64270794f, -0.23485935f, 
    -0.59048158f, -0.18381393f, -0.29785800f, -0.76276404f, -0.26265371f, -0.01995384f, -0.64228433f, 0.11535282f, 
    -0.06988911f, -0.01333503f, 0.06804419f, -0.00726445f, -0.26830322f, 0.44704902f, 0.52896613f, -0.05228302f, 
    -0.05555769f, 0.00985019f, -0.38540730f, 0.15438288f, -0.37869668f, 0.08947634f, -0.03487333f, -0.08156828f, 
    -0.21097703f, -0.31186160f, -0.24943464f, -0.14365348f, -0.50557059f, 0.00389531f, -0.20994100f, 0.45154485f, 
    -0.18356036f, 0.00488771f, 0.23045796f, -0.00184706f, -0.25613680f, 0.45930851f, -0.20315501f, -0.62087274f, 
    0.14265616f, -0.15845749f, -0.02223844f, -0.21223448f, -0.12014233f, 0.23349749f, 0.04702288f, 0.10051901f, 
    -0.55815077f, -0.54828495f, 0.04586399f, 0.60719103f, -0.12120422f, 0.29114226f, -0.45435122f, 0.23768935f, 
    -0.01229629f, -0.10139844f, 0.29122084f, 0.27015492f, -0.41164008f, 0.50792307f, -0.13757241f, 0.30726209f, 
    0.09964976f, 0.02653167f, -0.13248511f, 0.10690562f, -0.14070834f, -0.01741078f, -0.14865984f, -0.72341174f, 
    0.62024188f, -0.45481005f, 0.75783086f, 0.50384820f, 0.40827197f, -0.20022473f, 0.27505413f, 0.01283079f, 
    -0.11903585f, 0.05535508f, -0.08112036f, -0.13109168f, -0.39031813f, 0.35168824f, -0.38582993f, 0.09127357f, 
    -0.13128550f, 0.04784016f, -0.07658137f, -0.16142726f, 0.11161695f, 0.20804855f, 0.25069094f, -0.05613612f, 
    0.06704607f, -0.18867353f, -0.59196180f, 0.51766866f, 0.61238831f, -0.58247638f, -0.25456581f, -0.13110749f, 
    0.22419269f, 0.28333914f, 0.20333982f, -0.01808792f, 0.34082383f, -0.19631876f, 0.57229590f, -0.48217872f, 
    -0.00436428f, 0.30793229f, -0.43232393f, 0.17187509f, -0.24238347f, 0.01551468f, 0.12053002f, 0.14837155f, 
    -0.00108150f, 0.00763708f, 0.32193401f, -0.14782779f, -0.37588891f, 0.04085104f, 0.18907322f, -0.10389979f, 
    -0.05457527f, -0.12886782f, 0.05653713f, -0.31853083f, -0.31112620f, -0.22476520f, -0.26880902f, 0.29614711f, 
    0.12459581f, 0.14517273f, -0.32411218f, 0.44910067f, -0.17947175f, -0.34516954f, 0.08046846f, -0.19325165f, 
    0.06103263f, -0.70647144f, 0.06374738f, -0.65519792f, -0.05097087f, -0.17340469f, 0.11373149f, 0.05247499f, 
    -0.06659707f, 0.13345760f, 0.03818289f, -0.08283728f, -0.42862394f, -0.23403879f, -0.27269498f, 0.12374602f, 
    -0.28356349f, -0.17044125f, -0.06173141f, -0.24356201f, -0.12063124f, -0.02570732f, -0.20392650f, -0.15173160f, 
    0.32494223f, -0.42622003f, 0.32538185f, -0.70297390f, 0.08526994f, 0.02092062f, 0.03736430f, -0.02564617f, 
    -0.04955263f, 0.09758245f, 0.14471164f, 0.25686413f, -0.25583923f, 0.06690133f, -0.18009534f, 0.05133419f, 
    0.00002573f, -0.15291351f, 0.11035266f, 0.09917679f, 0.17256814f, 0.05395376f, 0.17786527f, 0.18190919f, 
    0.23162818f, 0.43627247f, -0.51907963f, 0.09233027f, -0.10166845f, -0.02212853f, 0.28629968f, 0.32813489f, 
    -0.49292371f, 0.10359266f, -0.16437873f, -0.02681492f, -0.12175967f, 0.06826980f, -0.30284393f, -0.41713938f, 
    0.02960726f, 0.42705566f, -0.04199467f, 0.03819223f, -0.02028197f, 0.02216007f, 0.18762699f, -0.05269052f, 
    0.87021214f, 0.31389359f, 0.21871835f, -0.39184400f, -0.19559473f, 0.16197619f, -0.18969546f, 0.23218849f, 
    -0.16789962f, 0.09594602f, -0.15293278f, -0.18783610f, -0.84844697f, 0.03910472f, -0.67415756f, 0.45393825f, 
    0.26261258f, -0.10027120f, -0.00565163f, -0.06876259f, 0.00905657f, 0.03756832f, 0.05608710f, 0.00171905f, 
    -0.01376900f, 0.03389988f, 0.46502754f, 0.49684989f, -0.35073796f, -0.20242865f, -0.06169526f, -0.00400056f, 
    0.08512835f, 0.03175048f, -0.03203553f, 0.03007417f, -0.58561772f, -0.00145486f, 0.34970450f, -0.26122925f, 
    -0.12322556f, -0.23500273f, 0.18309124f, 0.28746983f, -0.36694267f, -0.02397894f, 0.17052434f, 0.11363654f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35289162f, 0.35014036f, 0.09000958f, -0.17518164f, -0.22101583f, 0.10699148f, 0.11335940f, -0.32761985f, 
    0.10122099f, -0.00575661f, 0.08860423f, -0.07168868f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
