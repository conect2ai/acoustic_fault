#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19805698f, -0.70886010f, -0.67902046f, -0.94429606f, 0.43877330f, -0.56902105f, 0.54446882f, 0.17627440f, 
    -0.15857954f, 1.11878967f, 0.67397571f, 0.51995057f, 0.49963531f, 0.11495051f, 0.32888207f, -0.02483100f, 
    0.28923607f, -0.10444207f, 0.91723007f, -0.82035303f, -0.59730154f, -0.52860457f, 0.10960685f, -0.16434452f, 
    -0.29371637f, 0.11130756f, 0.45732492f, -1.05236399f, 0.94608927f, -0.36857769f, 0.01692598f, 0.10643654f, 
    -0.67840660f, -0.01746239f, -0.21410099f, 0.52656913f, -0.66204804f, 0.38146204f, 0.77785176f, -0.06809491f, 
    -0.06103110f, -0.99793458f, 0.09753181f, -0.02421578f, -0.03885007f, 0.38373488f, 0.74847847f, 0.54897183f, 
    0.42545602f, 0.49299800f, -0.41983464f, -0.06807749f, 0.69083583f, -0.39658293f, 0.39710695f, -0.52540731f, 
    0.89419770f, 0.45505935f, -1.32645130f, 0.81730527f, 0.11409423f, -0.17678924f, 0.05709391f, -0.78569406f, 
    1.03454387f, -0.24851117f, 0.78610325f, -0.31449932f, -0.49870089f, -0.08769796f, -0.10529026f, -0.29846394f, 
    -0.31525475f, 0.43521085f, 0.34603500f, -0.11265684f, -0.70722783f, 0.74889332f, -0.33623552f, 0.47555223f, 
    -0.04058870f, 0.52408159f, 0.52816564f, 0.36002263f, 0.45624366f, 0.63064390f, 0.13447598f, -0.77643949f, 
    -0.00018964f, 0.15143068f, 0.01098460f, 0.91203600f, -0.82111883f, 0.79445642f, 0.46080112f, -0.54476005f, 
    0.35692054f, 0.39404434f, 0.16514423f, -0.71223652f, -0.55410558f, -0.62646651f, 0.57091290f, 1.00413454f, 
    -0.27097115f, -0.12353000f, -0.34961629f, -0.62904066f, -0.09914005f, -0.74508828f, -0.49729148f, -0.76977301f, 
    -0.22303811f, -0.22606489f, -0.59721541f, -0.37736008f, -0.45308769f, -0.44497284f, -0.15034465f, -0.64908004f, 
    0.62327087f, -0.60674697f, 0.47803512f, -0.59694111f, -0.27274403f, -0.53465527f, -0.70614499f, -0.12288345f, 
    0.00410612f, -0.35447100f, -0.14068456f, -0.74859238f, -0.46999186f, -0.10651650f, 0.20670170f, -0.45638698f, 
    0.58157343f, -0.14391606f, 0.56257385f, 0.67046827f, 0.25420731f, -0.38339958f, 0.14871454f, -0.00469003f, 
    -0.90280253f, -0.80146974f, -0.35370588f, -0.25912604f, -0.54313183f, 0.33396265f, -0.09546490f, 0.24630405f, 
    -0.33790195f, 0.24075791f, 0.20953931f, 0.30607039f, -0.52758366f, -0.45228437f, -0.71503001f, -0.43206957f, 
    -0.57718474f, -0.22476518f, -0.12560856f, -0.69369280f, -0.75056612f, -0.71455055f, -0.03527003f, 0.17698993f, 
    -0.47377706f, 0.06901154f, 0.27137023f, -0.78607935f, -0.30404231f, -0.62279463f, 0.33516118f, -0.45206621f, 
    -0.34320155f, 0.13686781f, 0.60615987f, 0.17031959f, 0.01819557f, 0.19218209f, -0.40730387f, 0.61355871f, 
    -0.61253482f, 0.04204529f, -0.69239819f, -0.07080073f, 0.73850965f, -0.30234644f, -0.80035603f, -0.38555393f, 
    0.25933942f, 0.96800137f, 1.09164059f, -0.11566740f, 0.00008995f, 0.04844654f, 0.14551225f, 0.24584755f, 
    0.19842915f, -0.90200502f, -0.15615538f, -0.94516391f, -0.17238124f, 0.46189013f, -0.06839221f, 0.67110246f, 
    0.65887064f, 0.41783682f, -0.30810165f, -0.60189450f, -0.67503357f, 0.44444093f, 0.31362748f, 0.51444781f, 
    0.41662422f, 0.58403957f, 0.28074232f, -0.84993142f, -0.24628922f, -0.47382396f, 0.03100997f, -0.27097997f, 
    0.09894511f, -0.74770200f, 0.52427864f, 0.52606642f, 0.71957064f, 0.32740012f, 0.57433742f, 0.63402861f, 
    0.28776106f, 0.09177437f, -0.91151541f, -0.10963636f, -0.71190894f, -0.69798309f, 0.66741496f, 0.95500398f, 
    0.23045196f, -0.01037477f, 0.46827292f, -0.62742758f, -0.06891681f, 0.70284963f, -0.68150073f, 0.42652449f, 
    -0.04338817f, 0.03532285f, 0.49931866f, -0.32699576f, 0.03601168f, -1.26800549f, -0.03183637f, -0.78664511f, 
    -0.29918048f, 0.07528239f, 0.40711305f, 0.33599752f, 0.32305560f, 0.65206271f, -0.14521745f, 0.69524229f, 
    -0.91295087f, 0.61212873f, -0.25553003f, 0.14112805f, -0.35716203f, -0.23110954f, 0.84481668f, 1.10551417f, 
    -0.92816967f, -0.25193086f, 0.26878473f, 0.48769817f, 0.28815863f, -0.27132559f, -0.24572901f, 0.94864017f, 
    0.44384101f, -0.93606675f, 0.64782882f, -0.44966257f, -0.21853235f, -0.16248599f, -0.06704087f, 0.20559548f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02796988f, 0.44956192f, 0.01559592f, -0.05798247f, -0.11679360f, 0.16611339f, -0.27880144f, -0.40268016f, 
    -0.15932153f, 0.03617711f, -0.08279444f, -0.16967687f, -0.33649683f, -0.36047557f, 0.39868322f, -0.05437560f, 
    -0.08646322f, 0.09263896f, -0.13192953f, -0.08973840f, -0.29130951f, -0.00079773f, 0.10452557f, -0.13445194f, 
    0.35366696f, 0.16604988f, 0.20087533f, 0.17691398f, 0.10798232f, -0.27543452f, -0.28031772f, 0.01289748f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03839445f, 0.00587858f, 0.00238045f, -0.07650033f, 0.01109241f, 0.00247820f, -0.00184012f, -0.02325526f, 
    -0.05347749f, -0.07495873f, 0.00842937f, -0.04218569f, -0.00116104f, -0.04558137f, -0.02563355f, 0.02076343f, 
    -0.03957489f, -0.08974554f, -0.04617080f, -0.07945935f, -0.03199115f, -0.07649007f, 0.00737762f, 0.02157641f, 
    0.00444136f, -0.01559816f, -0.00979953f, -0.01632121f, 0.00866086f, -0.01041854f, -0.00508003f, -0.08591279f, 
    -0.03455026f, 0.02140687f, -0.03460281f, -0.06476142f, -0.03883608f, -0.03072769f, -0.05892982f, 0.01712847f, 
    -0.03586242f, 0.00798220f, -0.05648350f, -0.04737797f, 0.02666904f, -0.02230299f, 0.00133959f, -0.05758823f, 
    -0.03430191f, -0.00034074f, -0.00598767f, -0.03647843f, 0.00825701f, -0.02189149f, -0.05409806f, -0.04448764f, 
    -0.02050766f, -0.05491852f, -0.02546512f, 0.00588572f, -0.05456680f, -0.05095884f, -0.00229939f, -0.08935507f, 
    -0.05324623f, 0.00841609f, -0.01834514f, 0.02053367f, -0.02252035f, 0.00706594f, -0.02404441f, 0.00693919f, 
    0.00726316f, -0.04551565f, -0.05866838f, -0.00415401f, 0.02389371f, -0.07255010f, -0.00965104f, 0.00878450f, 
    -0.03036193f, 0.00524773f, -0.06805467f, -0.00220685f, 0.00341227f, -0.04592584f, -0.06603038f, -0.02511362f, 
    -0.00270353f, -0.07491394f, -0.05389497f, 0.02778883f, 0.02418320f, -0.07738746f, -0.04127184f, -0.05253803f, 
    -0.06055182f, -0.05461887f, -0.02043485f, -0.00151307f, -0.05971130f, 0.03006827f, 0.01722551f, 0.02223617f, 
    -0.04393598f, -0.00491560f, -0.02040678f, -0.01424983f, -0.06940419f, 0.02988797f, -0.06861949f, -0.05921474f, 
    -0.05681137f, 0.02216388f, -0.07591717f, -0.05417263f, -0.04647574f, -0.01981146f, -0.08939441f, -0.01188312f, 
    -0.02964723f, -0.06221998f, -0.05489965f, 0.00005139f, -0.02489317f, 0.02971562f, -0.01310133f, -0.00226326f, 
    0.01031294f, 0.01605478f, -0.05917396f, 0.01238385f, -0.07899360f, -0.01916115f, -0.01649139f, -0.01049053f, 
    -0.06940255f, 0.03234270f, -0.03428540f, -0.07062989f, -0.03062678f, 0.03097569f, -0.07554779f, -0.00673234f, 
    -0.00217515f, 0.01687500f, 0.02548329f, -0.06257772f, -0.00582085f, -0.01363780f, -0.08448095f, -0.01152111f, 
    0.04607134f, 0.03722901f, -0.08047009f, 0.02054144f, -0.07068905f, -0.02118198f, -0.04128799f, -0.00221151f, 
    0.02274353f, -0.03041892f, -0.04306178f, -0.07141770f, -0.00968804f, 0.00915220f, -0.06860234f, 0.01541751f, 
    -0.00183903f, 0.01760150f, 0.01547533f, -0.01146394f, -0.03030246f, -0.02630978f, -0.03792151f, -0.05143314f, 
    -0.00993744f, -0.03410450f, 0.01823767f, 0.04580064f, -0.03792088f, 0.02127638f, -0.00804634f, -0.04043089f, 
    -0.09033397f, 0.00368480f, -0.07667209f, -0.00842162f, -0.00805968f, 0.01465976f, -0.02574314f, -0.02823393f, 
    -0.05837872f, -0.02810858f, -0.00222431f, 0.01863561f, -0.03000006f, -0.04395035f, -0.07604751f, -0.02935369f, 
    0.00149750f, -0.05073648f, -0.07073393f, -0.02314310f, -0.02989384f, -0.07053366f, 0.01567364f, -0.00005896f, 
    -0.09008943f, -0.07123283f, -0.07486303f, -0.04440598f, -0.02802373f, -0.07486243f, 0.02025332f, -0.01575038f, 
    0.00655713f, -0.08926179f, -0.04161585f, -0.08724161f, -0.03317233f, 0.01462906f, -0.00100498f, -0.04734775f, 
    -0.06537338f, -0.02481540f, -0.05019300f, -0.06743257f, -0.03534264f, -0.05150472f, -0.01099940f, -0.06558245f, 
    -0.00336529f, 0.01639620f, 0.00897813f, -0.06222853f, -0.02257084f, -0.02802917f, -0.08743705f, 0.01719967f, 
    -0.08675664f, 0.00051294f, -0.06392702f, -0.04394570f, -0.06880666f, -0.06963677f, 0.01959990f, 0.03493452f, 
    0.00590561f, -0.03694050f, 0.00121930f, -0.03311352f, -0.05589564f, 0.00237277f, -0.07766439f, -0.04539661f, 
    0.01966572f, -0.04439561f, -0.09530342f, -0.05224341f, -0.01382255f, -0.07333067f, 0.00542101f, -0.07115985f, 
    -0.05398151f, -0.07992955f, -0.06346555f, -0.08290689f, -0.06195752f, -0.07329255f, -0.01595566f, -0.07632225f, 
    -0.02472242f, -0.06967451f, -0.04475766f, -0.05779503f, -0.06123969f, -0.03717778f, -0.01736269f, -0.05261320f, 
    -0.04960974f, -0.03644196f, 0.01086999f, 0.00373262f, -0.08154345f, -0.03524250f, -0.00836437f, -0.05963382f, 
    -0.37889209f, 0.08320575f, 0.12179536f, 0.30662471f, 0.09401363f, -0.07607936f, 0.02769764f, 0.08270333f, 
    0.03155678f, 0.11783741f, 0.15160695f, 0.18728258f, 0.25924063f, 0.26358160f, 0.14225051f, 0.22473185f, 
    -0.03515602f, 0.04189410f, -0.32191288f, -0.39807373f, -0.30643013f, -0.02671801f, -0.11711919f, -0.13547528f, 
    0.00359384f, 0.10445655f, 0.04668100f, -0.38126510f, -0.09058056f, -0.04253515f, -0.06863634f, 0.02236535f, 
    -0.06247656f, -0.05188480f, 0.07795486f, -0.19237085f, 0.22499131f, -0.02011732f, -0.20447855f, -0.18476039f, 
    0.07112130f, -0.19696005f, -0.00578346f, 0.03601207f, 0.03897573f, 0.23023841f, -0.17302436f, 0.20386444f, 
    0.26989779f, 0.28914544f, 0.00600677f, 0.02307091f, -0.15166928f, 0.12412738f, -0.61645991f, -0.42949814f, 
    -0.10641232f, 0.17465170f, 0.20788577f, 0.12896809f, 0.08429057f, 0.06004099f, -0.16125868f, -0.20711069f, 
    -0.06117560f, 0.16526465f, 0.00917881f, 0.04618738f, -0.35997045f, -0.10296114f, 0.15605518f, -0.08325213f, 
    0.02215392f, -0.12393886f, -0.09680356f, 0.14872655f, 0.00563142f, 0.01600699f, -0.18592432f, -0.20376860f, 
    0.02180172f, -0.06969056f, -0.10156856f, 0.12917846f, 0.07812680f, 0.06415199f, 0.16972795f, 0.13452396f, 
    0.02050015f, 0.11739254f, -0.09625711f, -0.09457670f, -0.02887464f, 0.25984985f, 0.12244801f, -0.19154130f, 
    -0.13770215f, -0.11456171f, -0.09712727f, -0.23402815f, 0.27186874f, -0.49157354f, 0.02040675f, 0.06229463f, 
    0.09184372f, 0.01344603f, -0.17662252f, -0.07268523f, 0.07708228f, -0.01319075f, 0.26766497f, 0.32822946f, 
    -0.15808691f, 0.04871829f, -0.09017555f, 0.00926371f, -0.36917648f, 0.23297793f, 0.34193608f, -0.20374365f, 
    0.26886317f, -0.17237292f, 0.10662121f, 0.01877773f, 0.05174408f, -0.04870180f, 0.14935359f, 0.04629093f, 
    -0.03550322f, 0.01678718f, 0.10335978f, 0.07512257f, 0.26797408f, 0.04323738f, 0.00011556f, -0.11537104f, 
    0.13675621f, 0.03351827f, 0.36694291f, 0.03961697f, -0.01832404f, 0.00146625f, 0.09268074f, 0.17280054f, 
    0.02468542f, 0.08183359f, -0.17410710f, 0.22464108f, 0.16330582f, 0.02113666f, 0.17646948f, 0.11573171f, 
    -0.04128616f, 0.19687471f, 0.10333613f, 0.30080333f, -0.08423969f, 0.11220822f, 0.05954881f, 0.23633161f, 
    0.32148758f, 0.04523778f, 0.09457489f, -0.07721069f, 0.09813985f, 0.05650261f, 0.01233924f, -0.04504723f, 
    -0.00301119f, 0.09835283f, 0.03119200f, -0.35728890f, -0.15231168f, 0.07650759f, 0.11419763f, 0.01584512f, 
    0.04566417f, 0.21798301f, 0.11719323f, -0.06890584f, -0.11048597f, -0.12147218f, -0.00251244f, 0.03077228f, 
    -0.12066953f, 0.00069353f, -0.01118279f, 0.00356400f, 0.00865518f, -0.39177254f, 0.15894970f, -0.30164635f, 
    0.08892792f, 0.07778913f, -0.03783502f, -0.04772685f, -0.07428284f, 0.00548692f, 0.19043693f, 0.13515729f, 
    0.13119942f, -0.27477801f, 0.15517960f, -0.01824379f, 0.07747670f, 0.01043013f, 0.17733791f, 0.27966729f, 
    0.38444668f, 0.05696480f, 0.19214964f, 0.05510122f, -0.00049298f, -0.06095080f, -0.05026007f, 0.04355200f, 
    0.34003800f, 0.48770925f, 0.27851903f, -0.07504982f, 0.03276667f, 0.14494416f, 0.17256740f, 0.08288019f, 
    0.23157784f, -0.05219765f, 0.01557593f, -0.01223433f, 0.09484100f, 0.14586546f, 0.12433996f, -0.07473220f, 
    0.15341087f, 0.02281578f, -0.73244077f, 0.03707698f, -0.05560244f, 0.11869907f, 0.07191209f, 0.10172157f, 
    0.17977072f, 0.06546920f, -0.19791277f, 0.19757271f, -0.12286565f, -0.01755540f, 0.02424378f, -0.07886031f, 
    -0.05627108f, -0.08080533f, 0.08274642f, 0.09044108f, -0.28587869f, -0.22494477f, -0.05988009f, 0.15999955f, 
    0.11256249f, 0.05018929f, 0.13520072f, 0.21945250f, 0.25931573f, -0.05716068f, 0.09896358f, 0.04365798f, 
    -0.03308444f, 0.03292418f, 0.04242013f, -0.29186887f, 0.20655049f, 0.01362940f, -0.06610601f, -0.12419007f, 
    -0.39488092f, 0.01485080f, -0.12920931f, -0.16249982f, -0.00741012f, 0.01051064f, 0.03351291f, 0.04437732f, 
    0.13092212f, -0.04295578f, 0.12061715f, -0.02569774f, -0.17808942f, -0.03369509f, -0.14474620f, 0.07423331f, 
    0.00544228f, -0.07096677f, -0.02741759f, -0.02906643f, -0.04870568f, -0.00984235f, 0.01583387f, 0.03419221f, 
    0.00976705f, 0.02284935f, 0.04276051f, -0.00579823f, -0.03316896f, 0.02269800f, 0.00703727f, -0.03738200f, 
    -0.03137792f, 0.04032401f, -0.06154719f, -0.00641722f, -0.00186635f, -0.04232235f, -0.05884963f, -0.05189783f, 
    0.02910278f, -0.05025119f, 0.01759159f, -0.00401910f, -0.07528905f, -0.01277927f, -0.04517478f, -0.05652367f, 
    0.03316327f, -0.05164956f, -0.03072201f, -0.00967041f, 0.01660404f, 0.00754830f, -0.03892556f, -0.06477206f, 
    -0.02546979f, -0.02076420f, -0.05503473f, -0.03357132f, 0.03324496f, 0.02738889f, 0.01228335f, 0.00596195f, 
    0.02964081f, -0.02611827f, -0.02974050f, -0.02908288f, 0.00422218f, 0.00020102f, 0.00338154f, -0.05859683f, 
    -0.03838563f, 0.01591616f, 0.02597317f, 0.00134139f, -0.04203762f, -0.01952605f, -0.01306349f, -0.05402723f, 
    0.03481806f, -0.03940517f, 0.04324044f, 0.04405193f, 0.02518250f, -0.05497564f, 0.05084896f, -0.01689995f, 
    0.04242967f, 0.03355036f, -0.01196882f, 0.01524113f, -0.03944067f, -0.01963919f, -0.01735469f, 0.02293653f, 
    0.02124208f, 0.00609172f, -0.02841439f, -0.05511507f, 0.03789141f, 0.04587394f, -0.01642070f, 0.00927980f, 
    0.02243224f, -0.01730261f, 0.04597526f, 0.00233160f, 0.02394080f, -0.05683392f, -0.00790216f, 0.02393826f, 
    0.02953168f, 0.00114372f, -0.01999971f, -0.00981665f, 0.02772340f, 0.03065860f, -0.00013181f, -0.05083729f, 
    0.01771771f, -0.07998224f, 0.03367257f, -0.05870126f, 0.00712440f, -0.04052522f, -0.02200839f, 0.02145881f, 
    -0.04359280f, -0.05984285f, -0.06945496f, 0.03455399f, 0.00869469f, -0.06263890f, 0.03438255f, 0.05540326f, 
    0.02071087f, 0.03459344f, 0.02454402f, 0.02065680f, 0.04083252f, -0.00172168f, 0.02409257f, 0.02802375f, 
    -0.00362957f, -0.03656117f, -0.05483429f, 0.05162587f, -0.04577593f, 0.03238680f, 0.01262757f, 0.04902033f, 
    -0.05142815f, -0.02499845f, -0.05004980f, -0.00000023f, -0.05347036f, 0.04132682f, -0.02923745f, 0.05631123f, 
    0.04410389f, 0.04429504f, -0.01590396f, -0.00706590f, 0.01844955f, 0.02379182f, 0.01135391f, 0.02409263f, 
    -0.02258674f, -0.02005749f, 0.04051080f, -0.04861474f, -0.01918754f, 0.02672657f, -0.03551911f, 0.00859969f, 
    -0.02933779f, -0.00211315f, 0.00144420f, -0.02577165f, -0.00659950f, -0.05057701f, -0.04528157f, -0.04682192f, 
    -0.01435187f, 0.03167571f, -0.06512041f, -0.00944952f, 0.02252048f, -0.05853977f, 0.03810692f, -0.00374824f, 
    -0.05691168f, 0.02855653f, -0.04141084f, 0.02567653f, -0.04624400f, -0.02869978f, -0.01998918f, 0.01535657f, 
    0.01754702f, -0.04059365f, -0.04987547f, -0.06000719f, -0.02294207f, -0.00135805f, -0.01411473f, -0.03267018f, 
    -0.00298683f, -0.01588655f, -0.06029545f, 0.00021231f, 0.04008220f, -0.05561163f, -0.03794893f, -0.04346380f, 
    0.04667553f, 0.03010373f, -0.01813768f, 0.05723934f, -0.03658060f, -0.04047265f, 0.01165762f, -0.02204487f, 
    0.02451763f, -0.00277295f, -0.07360974f, 0.03025164f, -0.05594026f, 0.00039996f, 0.00150269f, 0.04636129f, 
    -0.01141638f, -0.00113864f, 0.04581473f, 0.00226975f, -0.03311298f, 0.04223351f, 0.02962190f, -0.00953390f, 
    0.04373529f, 0.01327385f, -0.00586912f, 0.00387653f, -0.04804989f, -0.03332198f, 0.05472453f, 0.03886719f, 
    -0.05272977f, -0.02339799f, 0.02582455f, -0.01972200f, -0.06951064f, -0.02556094f, -0.03527502f, 0.02013504f, 
    0.01604547f, -0.05861056f, -0.00637116f, -0.00961559f, 0.00262700f, -0.02532120f, -0.07130897f, -0.00541920f, 
    0.03886857f, -0.05285970f, -0.05921143f, -0.02685086f, -0.04517198f, 0.00644337f, -0.07063715f, 0.02533636f, 
    -0.01693079f, -0.00900488f, -0.03516963f, -0.05793512f, 0.01236577f, 0.04995055f, -0.05772958f, -0.05670436f, 
    0.02887433f, -0.00936403f, -0.00180053f, 0.01851541f, 0.01431824f, -0.01105082f, 0.03826503f, 0.03028237f, 
    0.01519256f, 0.05343562f, 0.04240173f, 0.01475568f, 0.00190703f, -0.05222044f, 0.03027374f, -0.03240064f, 
    -0.05578143f, 0.02233385f, -0.04377126f, -0.00605574f, 0.05370594f, 0.02641596f, -0.01327673f, -0.02663431f, 
    0.02277587f, -0.05305400f, 0.03623448f, -0.00094329f, -0.00492811f, 0.02114762f, 0.01750072f, -0.04657431f, 
    -0.06013108f, 0.00492157f, -0.04576680f, -0.00558332f, -0.02836050f, 0.04284636f, -0.06069010f, 0.03752150f, 
    0.02859619f, 0.00370504f, 0.02143781f, 0.01337544f, 0.03073786f, -0.03351861f, -0.00274412f, -0.00676274f, 
    -0.06277238f, 0.02282424f, -0.03424653f, 0.03367271f, 0.02653234f, -0.02497916f, -0.05395990f, 0.01582022f, 
    0.02249874f, 0.03813965f, 0.04421911f, 0.03386918f, -0.04122126f, 0.02393435f, -0.05120587f, 0.04751460f, 
    0.03258545f, -0.03816225f, -0.05488687f, -0.05642430f, 0.02192309f, 0.03788294f, -0.04176294f, -0.04516282f, 
    -0.06964409f, -0.02317597f, 0.01119715f, 0.00544166f, 0.03221355f, 0.02424896f, -0.06701693f, 0.01647838f, 
    -0.05230289f, 0.05268829f, -0.02096851f, 0.00713285f, 0.03211425f, -0.06948449f, -0.00127253f, 0.05027685f, 
    -0.00564671f, -0.00372025f, -0.01531537f, 0.01620085f, -0.06132561f, 0.02403285f, -0.03932130f, -0.01094128f, 
    -0.07088905f, 0.03085860f, -0.03178014f, -0.05598785f, 0.03274630f, 0.00893421f, 0.03177519f, -0.04910722f, 
    -0.05557258f, 0.00706952f, 0.01239794f, 0.02026236f, -0.04808132f, -0.03234066f, -0.04631235f, -0.03210509f, 
    0.02558870f, 0.02514922f, 0.04537564f, 0.00885497f, -0.01665200f, 0.04030090f, 0.02199746f, -0.00797913f, 
    -0.03520981f, -0.06069703f, -0.02788052f, 0.04547070f, -0.00914249f, -0.04915818f, 0.01743838f, -0.01765934f, 
    0.03444214f, -0.04240795f, -0.05180635f, -0.03105089f, 0.01340855f, -0.02476426f, 0.00683471f, -0.02169833f, 
    -0.01181725f, 0.05588751f, -0.02591788f, -0.06137180f, -0.04113578f, 0.00314623f, -0.03037694f, 0.02189946f, 
    -0.03955732f, -0.03083036f, 0.03413028f, 0.05248334f, -0.02206049f, -0.03574806f, -0.00317267f, 0.01010807f, 
    -0.02173761f, -0.04324572f, 0.04763767f, -0.04516310f, -0.01684299f, -0.06484739f, 0.03800659f, 0.03369797f, 
    -0.06540548f, 0.00366210f, -0.06086659f, -0.04691012f, 0.03099488f, 0.02478904f, -0.05571126f, 0.02102470f, 
    -0.05453075f, -0.04428848f, 0.04488199f, 0.03285289f, -0.00200247f, -0.00423773f, -0.01230763f, -0.02076649f, 
    0.04774701f, -0.00467082f, 0.04375249f, 0.02757193f, 0.03168534f, -0.06163035f, 0.04755122f, 0.02988279f, 
    0.04529213f, -0.01093777f, -0.00919231f, 0.03662534f, 0.04193235f, -0.02110182f, -0.00046184f, -0.04457997f, 
    0.04228080f, 0.04829509f, 0.00600745f, 0.01216361f, -0.02288969f, 0.04283885f, -0.02042834f, -0.04963553f, 
    -0.00813898f, -0.01159285f, 0.03395169f, -0.05988803f, 0.03148084f, 0.00161193f, -0.07175283f, -0.02500989f, 
    0.02771096f, -0.06238788f, -0.02687398f, -0.04018714f, 0.01402985f, 0.00654915f, -0.06133675f, 0.04315911f, 
    -0.05023946f, 0.02252441f, -0.03895477f, 0.01723813f, -0.05259909f, -0.01189565f, 0.03278331f, 0.00944284f, 
    -0.04623964f, 0.01561383f, 0.00137770f, -0.05379365f, 0.00463892f, -0.00770726f, -0.05136120f, 0.03836819f, 
    0.00787926f, -0.02781142f, -0.03254984f, -0.06219101f, -0.01397668f, 0.00836247f, 0.00007710f, 0.04417178f, 
    0.01727996f, -0.02845565f, -0.06153798f, -0.03628440f, 0.02616308f, -0.02666603f, 0.01224697f, -0.02896975f, 
    0.00803483f, 0.03560362f, -0.01246154f, -0.01994950f, 0.02000672f, -0.04267700f, -0.05656254f, -0.00353479f, 
    0.00085324f, -0.04184847f, -0.05972179f, -0.04408196f, 0.01071149f, -0.02985267f, 0.02658206f, -0.04183371f, 
    -0.04997212f, -0.00538521f, -0.02645906f, 0.03353674f, -0.04873874f, -0.03993912f, 0.00673836f, -0.02247455f, 
    0.00736607f, 0.02811417f, -0.03584158f, 0.03739933f, -0.04535010f, -0.04392621f, -0.06836066f, 0.00549335f, 
    0.00673001f, -0.03102734f, -0.06480290f, 0.03360607f, -0.03895736f, -0.02157225f, 0.03144360f, 0.00572293f, 
    0.02510119f, -0.05815773f, -0.04972146f, -0.00009734f, -0.05228477f, -0.06127620f, 0.02501512f, 0.04434213f, 
    -0.04034630f, 0.03389140f, -0.03625828f, -0.01775357f, 0.02527280f, -0.06958875f, -0.00997583f, 0.00499565f, 
    -0.05689509f, -0.03701314f, 0.02930970f, -0.05430837f, 0.03215668f, -0.00604531f, -0.02922247f, 0.01532551f, 
    -0.08070108f, 0.09478357f, -0.42574379f, 0.20388184f, 0.06550123f, 0.03471809f, -0.20137401f, 0.05458051f, 
    -0.00300517f, -0.66597384f, 0.18176989f, 0.07373342f, -0.08935669f, 0.14852695f, 0.07843109f, 0.04349159f, 
    0.09421266f, 0.02536087f, 0.05133855f, -0.14626776f, -0.07762509f, 0.10487159f, -0.12585127f, 0.02806079f, 
    -0.01405126f, -0.03447930f, 0.02990452f, 0.25865987f, -0.06027040f, -0.16340302f, -0.11442589f, -0.09941524f, 
    -0.02635911f, 0.09382039f, -0.02931040f, -0.10745858f, 0.36540800f, -0.22008716f, 0.15169480f, -0.14650956f, 
    -0.05726855f, 0.14155194f, -0.22576948f, -0.01559668f, 0.07662863f, -0.15369301f, 0.26453933f, 0.03917503f, 
    0.07109839f, -0.00255694f, 0.26535061f, -0.04351369f, 0.04059216f, -0.09873355f, -0.67598855f, -0.18087931f, 
    0.19263206f, 0.09826711f, 0.22911195f, 0.16246894f, -0.15881422f, 0.05385480f, 0.05041537f, 0.21584824f, 
    -0.30561495f, -0.12263218f, -0.06481641f, -0.07436074f, -0.16356887f, 0.04263875f, -0.11528329f, 0.12973960f, 
    -0.18996456f, 0.11519182f, 0.14653111f, -0.08307251f, 0.11853055f, -0.00628039f, -0.02639791f, 0.13082580f, 
    0.11415913f, -0.45139000f, 0.06822114f, 0.04469592f, -0.09529889f, 0.02453519f, 0.06225088f, 0.14092819f, 
    -0.15971074f, 0.03991966f, -0.08690779f, -0.11342741f, -0.03151335f, -0.10053430f, 0.06565177f, -0.10687552f, 
    -0.02159027f, 0.02847029f, 0.04755815f, 0.36550334f, -0.34913391f, -0.17216849f, -0.30106607f, -0.18842980f, 
    0.15955849f, -0.17554751f, 0.16566102f, 0.01675777f, -0.20820238f, 0.08049909f, -0.10745352f, 0.05345241f, 
    -0.08101368f, 0.12139431f, -0.17089333f, 0.07885586f, 0.01436421f, -0.22235344f, -0.21074682f, -0.19535859f, 
    -0.15289906f, 0.04202303f, -0.02637692f, -0.13922021f, -0.31847331f, 0.11185694f, 0.15809156f, 0.04744960f, 
    0.01439633f, -0.06924545f, 0.18010634f, -0.01425136f, 0.10429554f, 0.02356974f, -0.02193455f, 0.35556239f, 
    -0.03246428f, -0.12106870f, -0.03899712f, 0.09705874f, 0.07025914f, -0.18910986f, -0.07626823f, -0.06275569f, 
    0.01728922f, 0.05760792f, -0.29313260f, -0.10576332f, -0.08468696f, 0.09593074f, 0.16281427f, -0.00537594f, 
    -0.04210964f, 0.19378650f, 0.12124734f, 0.16205095f, -0.08241321f, 0.10282616f, -0.00659882f, 0.01656828f, 
    -0.11807998f, -0.07409431f, -0.26536250f, -0.04695587f, 0.12690143f, 0.08303113f, -0.07036424f, 0.16076016f, 
    0.08971108f, 0.04149668f, 0.26171723f, 0.29009205f, 0.01887922f, -0.19371578f, -0.10260133f, -0.00644333f, 
    -0.09974498f, 0.20182212f, 0.03739265f, -0.19020027f, 0.14376062f, -0.23738725f, -0.15544701f, -0.04126925f, 
    -0.00729086f, -0.11011235f, 0.14694750f, 0.15027042f, 0.03304047f, 0.07663072f, -0.27546909f, -0.15344474f, 
    -0.13930404f, -0.19070408f, 0.00190947f, 0.04013744f, -0.03538394f, -0.01623568f, 0.39452517f, -0.02443740f, 
    -0.01765564f, 0.05691888f, 0.03469764f, -0.01165701f, 0.08109987f, -0.11141247f, 0.02765755f, 0.07947999f, 
    0.17614493f, -0.10194500f, 0.24227488f, -0.03008112f, -0.10327705f, 0.00892932f, 0.31554571f, -0.01023607f, 
    0.33344844f, 0.25197947f, 0.18333626f, 0.15064052f, -0.01958150f, -0.06161015f, 0.08168206f, -0.06214979f, 
    0.08214836f, 0.30750099f, -0.24564509f, -0.19304690f, 0.08410946f, 0.08225366f, 0.19070227f, -0.02828853f, 
    0.21493000f, -0.11009428f, -0.12335047f, -0.00626254f, -0.08369020f, -0.12882325f, 0.08636482f, 0.06468272f, 
    0.10136474f, 0.07957091f, -0.02007022f, 0.30842310f, -0.08218101f, 0.03203505f, 0.04297373f, 0.16993372f, 
    0.08777144f, -0.12792507f, -0.10020854f, 0.25883120f, 0.30835348f, 0.17677253f, 0.10769821f, 0.12622853f, 
    -0.08877003f, -0.04731170f, 0.14153850f, 0.03392962f, -0.20869625f, 0.20849431f, 0.10061292f, 0.23121554f, 
    0.01207522f, -0.02970691f, -0.13311087f, 0.09407693f, -0.03805605f, 0.10183566f, -0.70965356f, 0.29100123f, 
    -0.06134258f, 0.06212107f, -0.03436656f, 0.04199544f, 0.06000710f, -0.02828610f, -0.14473756f, 0.13979705f, 
    -0.02132160f, -0.06669953f, -0.00419351f, 0.17192402f, -0.16276836f, 0.11524670f, -0.19898088f, 0.00682603f, 
    0.03326321f, -0.00227539f, -0.03033014f, -0.06097894f, -0.01925756f, -0.04295233f, -0.01491124f, -0.05827846f, 
    0.05087025f, 0.03733028f, -0.01945064f, -0.03279454f, 0.04542068f, 0.01817589f, -0.02672410f, -0.00146115f, 
    -0.03606747f, 0.00408488f, -0.03839069f, -0.04443117f, -0.00222419f, -0.01211509f, -0.01971092f, -0.00593517f, 
    0.02597889f, 0.04638169f, 0.00872177f, 0.01888382f, -0.00956093f, -0.03299511f, 0.04753666f, 0.02689682f, 
    -0.01000129f, -0.04223396f, 0.03025871f, 0.01840518f, -0.03922625f, 0.03369046f, 0.01424539f, 0.05069265f, 
    0.03093129f, 0.04300894f, -0.02972981f, -0.00157444f, -0.04701300f, 0.02258917f, 0.01131938f, -0.00783399f, 
    0.05338447f, -0.03166304f, 0.02344834f, -0.02772273f, -0.01227575f, 0.03743354f, 0.01314291f, -0.02160854f, 
    -0.00690013f, -0.03565783f, 0.04362012f, 0.03488797f, 0.04621077f, -0.05720402f, 0.02478524f, -0.05893156f, 
    0.00857669f, 0.02584930f, 0.00741440f, 0.03039343f, 0.01052284f, -0.05011097f, -0.01214785f, 0.03617984f, 
    -0.06206961f, 0.02774184f, -0.05277032f, 0.00110124f, 0.05119980f, -0.04745410f, -0.06247583f, -0.03469723f, 
    -0.05212539f, 0.01128739f, 0.00708778f, -0.02207726f, -0.04818384f, 0.03675013f, -0.01861786f, -0.03731485f, 
    -0.05479060f, -0.05602735f, 0.03982607f, -0.02019624f, -0.04459497f, 0.03734477f, 0.00590979f, 0.05100293f, 
    -0.03828318f, -0.03566893f, -0.05479486f, -0.00216416f, -0.05120419f, -0.01735088f, 0.03962258f, -0.01431388f, 
    0.03419958f, 0.04142488f, -0.00856002f, -0.01301945f, 0.05681619f, -0.04759931f, -0.04227445f, 0.01699524f, 
    0.04524129f, -0.02346071f, -0.05460127f, -0.02843072f, -0.03520726f, -0.02194545f, 0.03622181f, 0.05262249f, 
    -0.01696175f, 0.01598576f, -0.05891392f, -0.03224564f, 0.01587179f, -0.04866292f, 0.04212990f, 0.05311395f, 
    -0.05051545f, -0.05840202f, -0.05932056f, -0.02526949f, -0.02551646f, -0.05896559f, -0.04892646f, 0.04332042f, 
    0.04151995f, -0.04387868f, 0.01450896f, 0.00335515f, -0.01109585f, -0.02863194f, -0.02073643f, -0.02409428f, 
    -0.02901511f, -0.01937402f, 0.02551560f, -0.01650096f, -0.05858054f, 0.05251112f, 0.03769211f, -0.04647476f, 
    -0.00201647f, 0.02709431f, 0.01171984f, -0.01846071f, -0.00004728f, -0.03943039f, -0.01990408f, 0.00516586f, 
    0.02864132f, -0.05688761f, -0.01762144f, -0.03884891f, 0.00916931f, -0.01460227f, -0.03818088f, 0.03318956f, 
    -0.03085659f, 0.01712259f, 0.04944798f, -0.03088153f, 0.04215682f, -0.04626735f, -0.00814904f, -0.02580887f, 
    -0.01635966f, -0.00181723f, 0.02863774f, -0.02942462f, -0.00038860f, -0.03984266f, -0.02021886f, -0.00380445f, 
    0.00755325f, 0.04090183f, 0.01616947f, -0.03956053f, -0.04263446f, -0.04838078f, -0.00264416f, -0.05260201f, 
    -0.00667192f, 0.01305555f, 0.00316299f, -0.04892476f, -0.05087849f, -0.01763233f, -0.02686026f, 0.03605646f, 
    -0.06099089f, -0.02590992f, -0.05955566f, -0.03097039f, -0.03000423f, 0.02468030f, -0.00030353f, 0.04707618f, 
    -0.05212853f, -0.02694829f, 0.00430644f, -0.00640132f, -0.02530195f, 0.05287293f, -0.03616373f, 0.04511967f, 
    -0.06032588f, -0.04780794f, -0.03499713f, 0.01435990f, -0.02742486f, 0.02210781f, -0.02647405f, 0.05297400f, 
    0.01741548f, -0.06190213f, 0.03328918f, -0.04781995f, 0.02863977f, -0.02397729f, 0.05247619f, -0.05642993f, 
    -0.05965004f, -0.01733854f, -0.00170384f, -0.04764206f, -0.04162557f, -0.01913834f, -0.05976929f, -0.04032840f, 
    0.01465594f, -0.01785848f, -0.03761972f, 0.02112484f, -0.05626970f, 0.04196329f, -0.03718695f, -0.00192341f, 
    -0.03759096f, -0.00694801f, -0.01255462f, 0.01729093f, 0.04486871f, -0.04684497f, 0.05040177f, 0.04591056f, 
    -0.00281331f, 0.02368633f, -0.01180884f, -0.03655014f, -0.03029259f, -0.01109991f, -0.04614688f, 0.01258638f, 
    0.02070970f, 0.00575235f, 0.04892839f, 0.03500944f, -0.03721419f, 0.00510093f, 0.05668392f, 0.03658574f, 
    0.05369285f, 0.03400393f, 0.01844816f, 0.00583905f, -0.00277732f, 0.01160721f, -0.03978540f, -0.00215298f, 
    -0.05666045f, -0.05177781f, 0.04483262f, -0.05296002f, -0.05180549f, -0.05799006f, -0.04771579f, 0.03478897f, 
    0.00532040f, 0.02367805f, -0.05786859f, -0.02448517f, -0.04923164f, -0.00816763f, -0.02501873f, -0.00809817f, 
    0.02181361f, 0.01125332f, -0.00345788f, -0.06407216f, -0.04648469f, 0.04524280f, -0.01096099f, -0.00450826f, 
    -0.05213892f, -0.05302884f, 0.01748245f, 0.00161865f, -0.03629297f, 0.04597382f, 0.03179514f, -0.04786917f, 
    -0.00882714f, -0.03594513f, 0.04274096f, -0.00528334f, -0.00673467f, 0.00626877f, 0.00225655f, -0.02699333f, 
    -0.05209620f, -0.03356152f, -0.04627994f, 0.03737484f, 0.04088911f, 0.02935270f, -0.03971972f, -0.03171300f, 
    0.02838705f, 0.03820323f, 0.03152541f, 0.03368532f, -0.03031322f, 0.00098155f, -0.00898860f, -0.04203279f, 
    0.01941899f, 0.02855641f, 0.04313031f, -0.06580164f, -0.00026672f, -0.00124443f, -0.03373431f, -0.04668008f, 
    0.01812918f, 0.00256674f, 0.03776568f, -0.05901078f, -0.02587717f, -0.04920594f, -0.03499484f, -0.01815593f, 
    -0.00245341f, 0.02055071f, -0.04205622f, 0.02157244f, 0.03372005f, -0.00551665f, 0.01693667f, 0.00996380f, 
    -0.05887755f, -0.05252238f, -0.02521139f, 0.00726688f, -0.01483583f, 0.00832991f, -0.00896162f, 0.03162969f, 
    -0.01869689f, -0.04108518f, -0.05994505f, -0.03754831f, -0.03617557f, -0.00296930f, -0.03230978f, -0.00405184f, 
    -0.03472599f, -0.00675387f, -0.02094954f, 0.02821202f, 0.01352404f, -0.05415270f, -0.02897725f, 0.03013151f, 
    -0.02172066f, -0.00664803f, -0.01522465f, -0.04668194f, -0.06431308f, 0.01750266f, -0.03947100f, 0.02027149f, 
    0.02354466f, -0.05265925f, 0.01724360f, 0.00022047f, 0.02588655f, 0.00899366f, 0.03016247f, 0.06331347f, 
    0.03909012f, 0.02119471f, 0.01711498f, 0.02633766f, -0.02263137f, 0.02318551f, -0.05342730f, 0.04085915f, 
    -0.04097746f, 0.01301670f, -0.04327488f, -0.05695647f, 0.00244008f, -0.04421762f, -0.02400874f, -0.06201336f, 
    -0.00284766f, 0.05411302f, -0.03068073f, -0.03933102f, -0.04324498f, -0.02069384f, -0.03355632f, -0.01344815f, 
    -0.06069826f, 0.03322722f, -0.05262882f, 0.00009536f, 0.00601327f, -0.02026481f, 0.03847867f, -0.02418080f, 
    0.02612436f, 0.01234343f, -0.04688538f, -0.04423589f, -0.02902454f, -0.03948784f, 0.01557341f, 0.03025218f, 
    0.02559936f, 0.01508494f, 0.02789343f, 0.03319947f, -0.02281658f, -0.00506438f, -0.04133600f, 0.03770506f, 
    0.01236564f, 0.02200581f, -0.03873480f, 0.01605330f, 0.00995019f, -0.01984329f, -0.06242494f, -0.03888852f, 
    -0.05064069f, 0.00036863f, -0.05211327f, 0.01191740f, -0.05442852f, -0.05109787f, -0.01889791f, -0.04001729f, 
    0.01222486f, -0.04908750f, -0.02870368f, -0.01635451f, 0.00824804f, 0.02058396f, 0.03244803f, 0.01204648f, 
    -0.03706670f, -0.02085596f, 0.03131856f, 0.02503759f, 0.03573670f, 0.01835465f, 0.00915344f, -0.01757938f, 
    -0.03177942f, 0.05018517f, -0.00892820f, -0.04416250f, -0.06345134f, 0.01986535f, 0.04190173f, 0.00290401f, 
    0.03724942f, -0.00580107f, -0.01822915f, -0.03337899f, -0.03365093f, 0.02130550f, -0.00101083f, -0.04456643f, 
    -0.02210596f, 0.00819794f, -0.01005101f, -0.03348863f, 0.02102262f, 0.01054866f, 0.00748513f, -0.00870989f, 
    -0.03215213f, -0.02641693f, -0.01805059f, 0.01789627f, -0.01126769f, 0.04495380f, 0.01705206f, -0.01385299f, 
    -0.00921937f, 0.04468934f, 0.02593148f, -0.02501392f, 0.03176255f, 0.03028699f, -0.05729579f, 0.04638381f, 
    -0.00398611f, 0.00978819f, 0.01944923f, 0.01046818f, -0.04508829f, 0.04508427f, -0.02666116f, 0.00856587f, 
    -0.05949450f, -0.03347797f, 0.03351256f, 0.04541193f, -0.02390212f, -0.04699505f, 0.04531550f, -0.03178404f, 
    -0.03661599f, 0.03770341f, -0.04604663f, 0.00834096f, 0.03769639f, 0.01952397f, -0.02091129f, 0.03477042f, 
    0.02743816f, -0.03299787f, -0.06158542f, -0.01561193f, -0.03501780f, -0.04078215f, -0.02809603f, 0.03052624f, 
    -0.04361564f, 0.04173091f, 0.01342743f, 0.03268227f, -0.01857496f, 0.00048116f, 0.00723809f, -0.00846387f, 
    -0.00719147f, 0.04115311f, 0.03877797f, 0.03275052f, 0.02716528f, -0.00361288f, -0.04355763f, -0.02533450f, 
    0.02020134f, 0.01841689f, -0.02629614f, 0.01682665f, -0.05450973f, -0.04160471f, -0.05584894f, -0.03225849f, 
    -0.06264366f, 0.00555105f, -0.17886886f, 0.05201766f, 0.04833897f, 0.13601986f, -0.06530630f, -0.21345514f, 
    0.05434001f, 0.06607741f, 0.32806331f, 0.29496780f, -0.26784518f, -0.06684950f, -0.00788300f, 0.02275771f, 
    -0.05465945f, -0.09474017f, -0.29750407f, 0.11570912f, 0.06965186f, -0.08466322f, 0.05936574f, -0.05980028f, 
    -0.06256769f, 0.01537748f, 0.03739047f, 0.35704511f, -0.22991902f, -0.28789532f, -0.01978514f, -0.14193530f, 
    -0.08733016f, -0.21772428f, 0.06847151f, 0.07810931f, 0.07098520f, 0.14638311f, 0.06391279f, 0.05479001f, 
    -0.04584161f, -0.03815565f, 0.12937754f, 0.18239340f, 0.14678253f, 0.09688679f, 0.16384931f, -0.03559737f, 
    -0.04074417f, 0.03333925f, 0.00353869f, 0.04739572f, 0.04407581f, -0.04155453f, 0.04705093f, 0.05176043f, 
    0.10304878f, -0.09016711f, 0.07954992f, -0.00364755f, 0.04592475f, 0.03142707f, -0.07137043f, -0.09663497f, 
    0.11650787f, -0.00131387f, -0.02551384f, -0.04725737f, -0.05034736f, 0.05367361f, -0.01599541f, 0.04939006f, 
    -0.14287254f, 0.02020995f, 0.24942075f, 0.02483119f, 0.01975536f, 0.09847298f, 0.03525379f, -0.02818198f, 
    0.29616985f, 0.07900576f, 0.24645858f, 0.07644823f, -0.27419955f, 0.09093377f, 0.10292514f, -0.06329629f, 
    -0.04021829f, 0.07679868f, -0.02653244f, -0.08894684f, 0.07987538f, -0.04323115f, 0.09467088f, -0.23583157f, 
    -0.06270926f, -0.10357685f, 0.07291266f, 0.14233185f, -0.19604827f, -0.42208835f, 0.30335948f, 0.11302068f, 
    0.13283010f, 0.21707101f, -0.03511747f, -0.11517122f, -0.06553792f, 0.06992251f, -0.25508565f, 0.07975757f, 
    -0.08321022f, 0.23750678f, -0.00161748f, -0.07219935f, 0.11292687f, -0.26657239f, 0.15437616f, -0.00236770f, 
    -0.08294789f, 0.07878283f, -0.12164021f, 0.14391498f, -0.09333401f, -0.06600206f, 0.14493558f, -0.00863658f, 
    -0.14770423f, 0.16836615f, 0.05172139f, 0.02108669f, 0.06359366f, 0.12169550f, 0.20400673f, 0.32488978f, 
    -0.30491689f, -0.00332643f, -0.10451910f, 0.04585489f, 0.02411198f, -0.07763004f, -0.19284289f, -0.17534767f, 
    -0.58406579f, -0.14208968f, -0.19338274f, 0.07429452f, 0.00876276f, 0.11495419f, -0.24890964f, 0.04816625f, 
    0.15182194f, 0.04443129f, 0.15286544f, 0.00765191f, 0.02765694f, 0.01652860f, 0.17819752f, 0.01869077f, 
    0.26633671f, 0.14091696f, -0.18186431f, 0.09359682f, -0.18046902f, 0.06286415f, -0.12134407f, 0.22313459f, 
    -0.06114566f, 0.02959544f, 0.14227268f, -0.15013663f, -0.10613608f, -0.16062938f, 0.19282958f, 0.03861477f, 
    -0.06022847f, 0.02032179f, 0.06220358f, -0.16672404f, -0.04212295f, 0.02066113f, -0.22515023f, 0.07918816f, 
    0.04242446f, -0.07346131f, -0.03597926f, 0.14150748f, -0.04528156f, 0.22322105f, -0.28349900f, 0.00050309f, 
    0.11714116f, 0.02100491f, 0.15746991f, 0.11925001f, -0.17002335f, -0.10343671f, 0.07624511f, 0.12485965f, 
    -0.17065910f, 0.02319281f, 0.08799909f, 0.08741292f, -0.02259460f, 0.10725623f, -0.00430724f, 0.42674696f, 
    0.29654908f, 0.02429174f, -0.14372638f, -0.17112219f, -0.13709815f, -0.09108210f, 0.09459167f, 0.01540800f, 
    0.14389428f, 0.35120890f, 0.07462612f, -0.02690913f, -0.02511467f, -0.01100524f, -0.01276082f, 0.08414501f, 
    0.03574205f, -0.16533104f, -0.38606384f, -0.06260839f, -0.16443396f, 0.07820323f, 0.08767333f, 0.08621912f, 
    -0.17572407f, -0.17567091f, -0.10760829f, -0.32922664f, 0.06520136f, -0.01253273f, 0.04705317f, 0.21238945f, 
    -0.08777823f, -0.15410446f, -0.07300712f, -0.18384080f, -0.16634172f, 0.10936115f, -0.00757054f, 0.09955064f, 
    0.02534937f, 0.06436912f, -0.03588464f, -0.01873422f, 0.15369250f, 0.08386114f, -0.08218927f, 0.06846002f, 
    0.17762205f, -0.03769862f, 0.01917759f, -0.04825166f, -0.12621140f, 0.01081236f, -0.04516420f, 0.15399846f, 
    0.12102611f, 0.13633776f, -0.05795498f, -0.04686139f, -0.02187550f, -0.00651356f, -0.31657326f, -0.07056862f, 
    0.47576928f, -0.27482602f, 0.26867083f, 0.04250450f, 0.16150695f, 0.10932706f, -0.05669248f, -0.22884656f, 
    -0.18416969f, 0.08172391f, 0.00229818f, 0.07631443f, -0.19036864f, -0.00174135f, 0.05920536f, 0.00858525f, 
    0.03852268f, 0.03802095f, -0.06319471f, -0.00842757f, -0.05094071f, -0.00665242f, 0.02320682f, -0.02425802f, 
    0.03867291f, -0.01958143f, -0.02839618f, 0.01325693f, 0.03453776f, -0.01622625f, -0.02903945f, 0.04878388f, 
    0.01841970f, 0.01650187f, -0.03939682f, -0.04131149f, -0.03310620f, 0.03650021f, 0.04200718f, 0.05142632f, 
    0.01974935f, 0.00570889f, -0.01189205f, -0.05630988f, -0.03306704f, -0.06005916f, 0.00402097f, -0.03776441f, 
    0.05090101f, -0.02727301f, -0.02937275f, -0.00928378f, -0.01371877f, -0.02191669f, -0.04829222f, -0.02324402f, 
    -0.03771165f, 0.04412095f, -0.04996664f, 0.03972214f, -0.02413654f, -0.02721809f, -0.05322815f, 0.01902560f, 
    -0.02433060f, 0.04066867f, -0.04865961f, 0.01180565f, 0.00359815f, -0.00815208f, -0.05536824f, 0.05751653f, 
    -0.04899526f, -0.02556577f, -0.03908563f, -0.00260283f, -0.00815411f, 0.04986127f, 0.04140030f, -0.03342889f, 
    0.04038563f, -0.05002460f, -0.01058301f, 0.00585771f, 0.04125670f, 0.03069590f, -0.01542894f, -0.02744852f, 
    0.00331461f, -0.05279416f, 0.04162209f, 0.01076070f, 0.03987376f, 0.01204121f, -0.02418822f, 0.02570129f, 
    -0.04889439f, 0.03587482f, 0.03395931f, -0.05015938f, -0.03812214f, 0.01500210f, -0.02599605f, -0.05350355f, 
    -0.02518929f, 0.04822162f, -0.01303223f, 0.04739055f, -0.04099711f, -0.05535383f, 0.01972674f, -0.00772599f, 
    -0.00710530f, -0.00889433f, 0.04974407f, 0.04763591f, 0.00616508f, 0.03735342f, -0.05728143f, 0.01193681f, 
    0.04930739f, -0.04138838f, -0.02105019f, 0.01523233f, -0.03322933f, -0.06395818f, -0.05554932f, -0.00920042f, 
    -0.04172809f, -0.01353809f, 0.01153570f, 0.02762293f, -0.04512363f, -0.06332564f, -0.05136750f, -0.03801688f, 
    -0.03630861f, 0.03394934f, -0.02117494f, 0.05093468f, -0.04394487f, 0.04837985f, 0.03679698f, 0.02373726f, 
    0.03929888f, 0.04653121f, -0.06422773f, 0.01109496f, 0.04215641f, -0.02666434f, 0.03228954f, 0.01075880f, 
    -0.02314472f, -0.02773583f, -0.02682359f, -0.03535619f, -0.00832050f, -0.06290719f, 0.03385584f, -0.02349187f, 
    0.00849850f, -0.00888009f, -0.03598013f, 0.01366927f, 0.03031988f, -0.01147566f, 0.02384666f, -0.01193486f, 
    0.02121178f, 0.03703214f, 0.04862239f, -0.03356367f, 0.02133919f, 0.03034479f, -0.00257390f, -0.05333746f, 
    -0.05963666f, 0.02905373f, -0.05982637f, -0.01599015f, -0.06316592f, 0.00421791f, -0.00370882f, -0.05901924f, 
    -0.05771656f, -0.02035166f, -0.00385039f, -0.03381669f, -0.05110527f, 0.03953047f, -0.02549657f, -0.00065535f, 
    -0.06029260f, -0.03253837f, -0.04410511f, -0.05205668f, -0.01010310f, 0.03628842f, -0.04483228f, 0.02753584f, 
    -0.01494229f, -0.00975654f, -0.00901360f, -0.02815211f, -0.03845747f, 0.01337033f, -0.05426063f, 0.02354676f, 
    -0.00352293f, -0.03347467f, -0.01088931f, -0.00742459f, 0.03928350f, 0.00707328f, 0.02294086f, -0.03706709f, 
    0.03722764f, -0.00066337f, 0.04374301f, 0.02299065f, 0.04269110f, -0.00935364f, -0.03475776f, -0.05988468f, 
    -0.00363478f, 0.02899300f, 0.00268909f, -0.06486215f, -0.00396386f, 0.03945591f, 0.03710527f, 0.01259137f, 
    0.03640744f, 0.01409731f, -0.03971814f, 0.01550129f, -0.04070893f, -0.01509164f, -0.02895206f, 0.03326453f, 
    -0.06187012f, -0.04756165f, -0.05807434f, -0.00992433f, -0.04266324f, -0.05106429f, -0.03925886f, -0.04988533f, 
    0.04504405f, -0.03415871f, -0.01613973f, -0.05866412f, 0.02956042f, 0.01741728f, 0.02649905f, -0.01624787f, 
    0.00613071f, -0.00596670f, -0.01112092f, -0.02316035f, 0.05118687f, -0.06060350f, 0.03453492f, 0.04613269f, 
    0.01579639f, -0.01803382f, 0.00326611f, -0.04378711f, 0.01262183f, -0.05665000f, 0.02631454f, 0.00437229f, 
    -0.05006138f, -0.00175932f, 0.00868024f, -0.00229799f, -0.04864020f, 0.01611019f, -0.02251748f, -0.03669467f, 
    -0.04074420f, -0.01565903f, 0.04439811f, -0.01692064f, 0.03521967f, -0.03445526f, -0.05332413f, 0.03498266f, 
    -0.02770083f, -0.02481940f, 0.02948382f, 0.02020580f, -0.02391458f, -0.01967380f, -0.06080371f, -0.05748444f, 
    0.04658581f, -0.04090420f, -0.04720053f, -0.06187195f, -0.03678650f, 0.02390915f, 0.00744894f, -0.03975151f, 
    0.02326247f, 0.09876984f, -0.06251845f, -0.13084786f, -0.04022074f, 0.15781176f, -0.26460940f, 0.19802295f, 
    0.08796030f, 0.31773305f, -0.17227237f, -0.19105859f, 0.32183087f, 0.29151282f, 0.12766473f, 0.19498521f, 
    0.11277313f, -0.13598645f, -0.03722575f, -0.21438411f, 0.14133887f, -0.04710411f, 0.06098497f, 0.08780611f, 
    0.22524971f, 0.10638215f, 0.01867974f, 0.16509756f, -0.04600092f, -0.06830278f, 0.00932286f, -0.07623367f, 
    0.03294016f, 0.09105524f, -0.02490442f, 0.04312128f, -0.29096934f, 0.29349139f, -0.30767536f, -0.00539951f, 
    -0.20058165f, 0.06746167f, 0.03086882f, -0.01594148f, 0.15479690f, 0.21726231f, -0.04261968f, -0.12049331f, 
    0.23745508f, -0.00323617f, 0.22897179f, 0.16630027f, -0.04140852f, 0.02757183f, 0.13368197f, -0.05169993f, 
    -0.26751861f, 0.08662181f, 0.20262142f, 0.07910008f, 0.03055845f, 0.04784010f, -0.19340546f, -0.24493909f, 
    -0.04924022f, -0.27994746f, 0.00739565f, -0.23473684f, 0.03668027f, -0.00365162f, -0.09292295f, -0.05902413f, 
    -0.25574291f, 0.00782088f, -0.15211610f, 0.10593794f, 0.14811049f, 0.06780704f, 0.07127415f, -0.27020454f, 
    -0.15603121f, -0.11747158f, -0.20964272f, -0.10300650f, 0.18379219f, 0.09156993f, 0.04395117f, 0.11410425f, 
    -0.11170708f, -0.12669165f, 0.27369413f, -0.14545250f, 0.02991152f, 0.03042300f, -0.03713654f, 0.16803211f, 
    0.03165373f, -0.00635095f, -0.12395147f, -0.50370067f, -0.19496588f, 0.29781976f, -0.16926019f, -0.23894049f, 
    0.09278926f, -0.03695530f, 0.24863191f, 0.22293362f, -0.26323581f, -0.25317147f, 0.08398900f, -0.26122785f, 
    0.00466630f, 0.08876756f, 0.24547067f, 0.05606863f, 0.13534774f, -0.34237462f, -0.29717353f, 0.19727099f, 
    -0.04971405f, 0.07887660f, 0.00222261f, -0.08547802f, -0.05994559f, 0.02616497f, -0.22261672f, 0.00551492f, 
    0.06182406f, 0.05933018f, -0.12324785f, 0.04054236f, 0.17920952f, 0.18544671f, 0.08490116f, 0.04490703f, 
    0.00765381f, 0.33021393f, 0.08381706f, 0.01076686f, 0.06773647f, -0.07323072f, 0.13861780f, -0.15036345f, 
    -0.03897149f, -0.00554388f, -0.04814547f, 0.00594062f, 0.04459661f, 0.02856004f, -0.06681421f, 0.04154472f, 
    -0.00819342f, 0.33418763f, 0.12522186f, -0.07656714f, 0.10923440f, 0.04172427f, -0.04762410f, 0.10588411f, 
    0.32424054f, 0.10852604f, -0.11628180f, 0.01342441f, 0.04136550f, -0.15458737f, 0.02495241f, -0.07988115f, 
    0.18500260f, -0.04344161f, 0.12670241f, 0.14101268f, 0.06947608f, 0.00861738f, -0.17137714f, -0.10804299f, 
    -0.01089586f, 0.02259992f, -0.02768964f, -0.03056277f, 0.04978631f, -0.21590340f, 0.01895699f, 0.19517300f, 
    0.02647936f, -0.15534209f, 0.01696686f, 0.23483956f, -0.08033991f, -0.13126411f, 0.03507641f, 0.28866562f, 
    0.00777467f, -0.12601911f, 0.19849841f, -0.13692701f, -0.05699159f, -0.10573736f, 0.18816401f, 0.08543823f, 
    0.15294327f, -0.00784355f, -0.00990205f, -0.16382509f, 0.06610619f, 0.08485239f, 0.18477803f, 0.55348986f, 
    0.06784767f, 0.03741134f, 0.15842582f, -0.00838868f, -0.08001623f, 0.10889354f, -0.01196025f, -0.25970978f, 
    0.38327831f, 0.32138297f, 0.04638890f, 0.25519171f, 0.02177762f, -0.09541295f, 0.09065392f, 0.22223504f, 
    0.13849404f, -0.06562679f, 0.04268874f, 0.02733991f, 0.00843272f, 0.21571790f, 0.13644665f, -0.08830868f, 
    -0.02182719f, -0.23195055f, -0.16129984f, 0.27299443f, 0.22128749f, -0.12676381f, 0.06859584f, 0.09399988f, 
    -0.04177808f, 0.08477185f, 0.00903829f, -0.13402727f, 0.15437993f, -0.28699818f, -0.06002281f, 0.10227428f, 
    -0.04681861f, 0.14727530f, 0.07316819f, 0.05519605f, 0.04250972f, -0.01344752f, 0.03171002f, -0.08612883f, 
    -0.07216864f, -0.09568918f, -0.00812109f, -0.03064304f, -0.17026284f, 0.14371519f, 0.19060144f, -0.20246565f, 
    0.12376308f, -0.01944086f, -0.16359761f, 0.09165174f, 0.18639678f, 0.10737450f, 0.23932803f, 0.13565229f, 
    -0.01298313f, 0.09859973f, 0.07002293f, 0.11372258f, 0.06319659f, 0.03466561f, -0.08762099f, 0.26705498f, 
    0.08524370f, 0.38791731f, 0.06665449f, 0.01581171f, 0.01266057f, 0.11431166f, 0.06309720f, -0.03940655f, 
    0.33969316f, 0.24694125f, -0.16529073f, -0.03443567f, -0.01570405f, -0.15541947f, 0.09279555f, 0.11496789f, 
    0.03156771f, 0.05394866f, -0.09842061f, 0.06827158f, 0.24571529f, -0.09512981f, -0.02672132f, 0.01459121f, 
    -0.05982811f, 0.03839662f, 0.02372760f, 0.19582476f, -0.03117386f, -0.00783076f, 0.10095757f, -0.07696318f, 
    0.20128056f, 0.04930583f, -0.12036642f, -0.17037582f, -0.05191343f, -0.30614117f, 0.09417936f, 0.05342975f, 
    0.03801431f, 0.11711285f, -0.14115271f, 0.20207050f, -0.06478734f, -0.21953753f, -0.22358982f, 0.13411598f, 
    0.02130967f, 0.04574678f, -0.09643631f, 0.03314193f, 0.00548401f, 0.05577454f, -0.11960218f, -0.22718042f, 
    0.00469619f, -0.06974141f, 0.08731035f, -0.18578216f, -0.10853397f, 0.07456422f, 0.04181655f, 0.14172129f, 
    0.00199513f, 0.03451145f, -0.11745024f, -0.15120074f, 0.02670733f, 0.08642282f, 0.05813205f, -0.17362955f, 
    -0.47297338f, -0.43468443f, -0.00870262f, -0.11217378f, 0.01214138f, -0.05630898f, -0.27107209f, 0.07138683f, 
    -0.05414470f, -0.07737225f, -0.00048210f, -0.11897301f, -0.20570454f, 0.10916007f, 0.02088685f, -0.07813621f, 
    0.04249757f, 0.00040405f, -0.15875965f, 0.00486881f, 0.10431363f, -0.17356227f, 0.04112998f, 0.13210492f, 
    0.15065458f, 0.02130512f, -0.04269137f, 0.13096355f, -0.36758959f, 0.07188065f, -0.25309625f, -0.07723325f, 
    0.12718065f, -0.03719737f, 0.20527431f, -0.07842313f, -0.09718336f, 0.03715336f, -0.03312415f, -0.04694082f, 
    0.11158541f, 0.00516117f, 0.07370234f, -0.05407397f, -0.19114037f, 0.03088048f, 0.01319254f, 0.13836850f, 
    0.04230300f, 0.00585948f, 0.07541467f, -0.04860613f, 0.12557189f, 0.12709247f, 0.09645609f, -0.06332542f, 
    -0.11361648f, -0.10378675f, -0.04456833f, -0.00891183f, 0.07154411f, 0.05819385f, -0.14797328f, -0.08095796f, 
    -0.15263888f, -0.02865781f, -0.14397584f, -0.05481120f, 0.07508530f, -0.03695384f, 0.04117770f, 0.20445117f, 
    -0.03504435f, -0.06510698f, 0.00896752f, -0.10127587f, -0.00513913f, -0.02049727f, 0.13850534f, -0.00261016f, 
    -0.49679273f, 0.18398492f, 0.08256228f, 0.20101376f, 0.07587624f, 0.01174058f, 0.01550953f, -0.02658103f, 
    0.11344461f, -0.10886034f, 0.10453885f, -0.22868641f, 0.08431042f, 0.12001641f, -0.09661566f, 0.05512852f, 
    0.03117818f, 0.02331482f, -0.21747234f, 0.12649731f, 0.12590326f, 0.05593531f, -0.09914314f, -0.26774496f, 
    0.05553041f, 0.09047082f, -0.14638607f, 0.18633473f, -0.12888229f, 0.02984201f, -0.06189828f, -0.03719502f, 
    -0.20584518f, -0.01501308f, 0.09990730f, -0.00230086f, -0.14749429f, -0.02369835f, 0.08841325f, -0.05824229f, 
    0.02927069f, -0.22855511f, 0.16381842f, 0.06219522f, 0.11507316f, 0.10544500f, 0.08880541f, 0.27440158f, 
    -0.10636560f, 0.08771677f, -0.00467791f, 0.04887081f, 0.16905159f, -0.02264196f, 0.09401868f, 0.11191192f, 
    -0.26634610f, -0.00888604f, 0.07915719f, -0.08274297f, 0.01871650f, 0.04904360f, 0.07855031f, -0.06668405f, 
    0.19372916f, -0.05431974f, 0.25568262f, 0.14725761f, -0.04289015f, -0.01696222f, 0.05451892f, -0.07372883f, 
    -0.17962492f, 0.02765515f, -0.16182685f, 0.16479503f, 0.10136325f, -0.03169396f, 0.09346995f, 0.03164396f, 
    -0.12987283f, 0.44508746f, 0.08640208f, -0.00582937f, -0.16978139f, 0.02554934f, 0.03345382f, -0.03977997f, 
    -0.04244312f, 0.17202526f, 0.00086878f, 0.02945849f, 0.20416808f, -0.20569314f, 0.16042714f, -0.10251385f, 
    0.12251431f, -0.08836326f, 0.14211746f, -0.04571626f, 0.02679292f, 0.02279484f, 0.01593870f, 0.10732115f, 
    -0.10520502f, 0.06881564f, 0.01269483f, 0.17784609f, 0.23450772f, 0.26626652f, 0.03237505f, 0.15777868f, 
    -0.07669612f, -0.13498668f, 0.17778461f, 0.14185593f, -0.04599989f, -0.07567278f, -0.09394568f, -0.31241578f, 
    0.12349658f, -0.07999037f, -0.00360743f, 0.09624981f, -0.14345764f, -0.07606413f, -0.18169753f, -0.11793890f, 
    -0.27576479f, 0.09267575f, -0.03542073f, -0.04472782f, -0.18743575f, -0.11026916f, -0.19827361f, -0.20059879f, 
    0.05180397f, 0.18735062f, -0.05763118f, 0.06863830f, -0.17206539f, 0.14993651f, 0.03696377f, -0.16581298f, 
    0.04333813f, 0.02741148f, -0.05269534f, 0.03415349f, 0.04705467f, 0.02286226f, 0.02271459f, 0.02741436f, 
    -0.03748974f, -0.01163117f, -0.05012972f, -0.01449353f, -0.04652731f, 0.01396642f, -0.05511915f, -0.06893940f, 
    -0.03352463f, -0.03263887f, 0.03091021f, -0.00262199f, 0.04782093f, -0.00091132f, -0.05768379f, -0.01427829f, 
    -0.00847504f, 0.01747986f, 0.01047829f, -0.02372712f, -0.04167784f, -0.00629531f, -0.05225245f, 0.02844255f, 
    -0.04416244f, -0.05822243f, -0.03087959f, -0.01988879f, -0.01224789f, -0.04064076f, -0.01761637f, 0.01458087f, 
    -0.04084687f, -0.05413599f, 0.01324684f, -0.01146561f, 0.02150023f, -0.01917532f, -0.04539650f, -0.01857799f, 
    -0.05012243f, 0.01948794f, 0.01842586f, -0.05146332f, 0.02430035f, -0.05021837f, 0.04694467f, 0.00013013f, 
    -0.02279348f, -0.00715629f, -0.01008070f, -0.02416983f, -0.00634015f, -0.04174193f, -0.04595685f, -0.08184744f, 
    -0.04145685f, -0.02949966f, -0.05145268f, -0.01028886f, 0.04271746f, -0.08356576f, -0.00651138f, 0.01900999f, 
    0.01119092f, 0.00826940f, -0.05459484f, 0.00356864f, -0.04739814f, 0.00311862f, -0.04526638f, -0.06119925f, 
    -0.08308520f, -0.00401000f, -0.04883945f, 0.04643576f, -0.03667267f, -0.02083396f, -0.02283908f, -0.03853980f, 
    -0.01975786f, -0.04401663f, -0.01906754f, 0.03803925f, -0.01527748f, -0.03962091f, 0.00156595f, 0.00322032f, 
    -0.02005131f, 0.05592236f, -0.04224244f, 0.00995333f, 0.05707894f, -0.04856516f, -0.03033868f, 0.00510516f, 
    -0.05096024f, 0.01992205f, -0.06293544f, -0.07464007f, -0.04655719f, -0.01531248f, -0.04668403f, -0.03077353f, 
    -0.05978506f, -0.05771697f, 0.04319319f, -0.00508089f, 0.04292342f, -0.02635986f, -0.05136364f, 0.01966693f, 
    -0.04448587f, -0.06344210f, -0.05752784f, -0.06030861f, 0.03087815f, -0.02880114f, 0.02248758f, -0.04855739f, 
    -0.02570994f, -0.01171638f, -0.08375230f, -0.01072731f, -0.01746355f, -0.03316761f, -0.02672074f, -0.06865514f, 
    -0.06593304f, -0.02082389f, -0.02783052f, -0.04134680f, 0.02177326f, -0.04162604f, 0.03808334f, 0.00945333f, 
    0.03653248f, 0.03868506f, -0.05012911f, -0.03872437f, -0.02346188f, 0.02756453f, -0.05050540f, 0.02207646f, 
    -0.07418409f, -0.05610808f, 0.00108651f, -0.01575322f, 0.02327382f, -0.05627131f, 0.03565571f, -0.05575047f, 
    0.04590690f, 0.00325098f, 0.04448337f, -0.05863501f, 0.00842885f, -0.06320163f, -0.04413378f, -0.04709949f, 
    0.00812049f, -0.00073548f, -0.02477119f, 0.04821723f, -0.01843445f, 0.03898507f, 0.01338432f, -0.02965824f, 
    -0.07367357f, 0.00266958f, -0.01443011f, 0.04168200f, -0.04850350f, -0.05308249f, 0.03107922f, -0.04599580f, 
    0.04015168f, 0.02399349f, 0.02792752f, 0.01939422f, 0.06379108f, 0.02088710f, 0.03876340f, 0.01970397f, 
    0.03071290f, -0.03370947f, -0.06341413f, -0.01285730f, -0.00738487f, 0.02271317f, 0.02634941f, -0.02703172f, 
    0.00017074f, -0.01994076f, 0.04697517f, 0.04375773f, 0.04148879f, -0.05639681f, 0.00426792f, -0.01997240f, 
    -0.01943479f, -0.05293497f, 0.03090126f, 0.05086921f, -0.01918534f, 0.03086529f, -0.03891211f, -0.04005131f, 
    -0.05852336f, 0.00776918f, -0.00978242f, 0.00521598f, -0.00686879f, 0.01640256f, -0.05310541f, -0.02178024f, 
    -0.01997243f, 0.00726984f, 0.01589990f, -0.02675967f, -0.04113101f, 0.04263735f, -0.04695407f, -0.07171897f, 
    -0.01843376f, 0.00252536f, -0.02439667f, -0.01553463f, -0.02871074f, -0.03540183f, -0.02373034f, -0.02662222f, 
    -0.01826550f, 0.01780854f, 0.01177453f, -0.01165343f, -0.06463100f, 0.00293862f, -0.04075958f, -0.01083205f, 
    -0.04536444f, 0.04149195f, 0.02855055f, -0.06325991f, 0.00945557f, 0.04179128f, 0.00777405f, -0.05212105f, 
    -0.06346326f, -0.07397514f, -0.04770433f, -0.00888833f, 0.01526411f, -0.05734104f, -0.02812872f, -0.03764636f, 
    -0.05801189f, 0.02992477f, -0.02025562f, -0.04967156f, -0.00928827f, -0.00123050f, -0.06000215f, -0.03784486f, 
    -0.02938322f, 0.02225435f, -0.05727540f, 0.04130214f, -0.05012225f, -0.04911891f, -0.01844611f, 0.00001206f, 
    -0.03919031f, 0.00682617f, -0.08341479f, 0.01767007f, -0.00991946f, -0.08969400f, -0.01986624f, 0.04398629f, 
    0.12903140f, -0.02712515f, 0.08058655f, -0.05211229f, 0.19758391f, 0.31714952f, -0.01447356f, -0.03659393f, 
    -0.00520958f, 0.14023550f, 0.24956144f, 0.29532382f, 0.13376887f, -0.16186641f, -0.01120238f, 0.05882195f, 
    -0.03631597f, -0.01516322f, -0.45133662f, -0.34710661f, 0.13113140f, 0.13828416f, -0.09935384f, 0.02421888f, 
    -0.11030959f, -0.06340013f, 0.01516607f, -0.60820925f, 0.08915979f, -0.08282501f, 0.10720913f, 0.03292558f, 
    0.11255245f, 0.10595547f, -0.02527601f, -0.01674770f, -0.23028153f, -0.18219137f, 0.00255851f, 0.16044170f, 
    0.19686665f, -0.07125422f, -0.02498115f, -0.03982695f, 0.10598930f, 0.19538102f, 0.08735276f, 0.30469778f, 
    -0.04736039f, -0.18654431f, -0.09079403f, -0.04937329f, 0.00520802f, -0.17719465f, 0.05184414f, 0.34851128f, 
    0.07478934f, -0.23286888f, -0.13424915f, -0.06482729f, 0.00971316f, -0.01192932f, 0.17351428f, -0.32425824f, 
    -0.27179709f, -0.21911775f, 0.04464830f, 0.10935980f, -0.12005795f, -0.03287067f, -0.06925025f, 0.04749274f, 
    -0.11423186f, 0.00011411f, -0.18343605f, -0.02214544f, -0.11500005f, -0.02217306f, 0.05604464f, 0.03122368f, 
    -0.01241022f, 0.16077697f, 0.22344019f, 0.23820986f, -0.02796601f, -0.08077905f, -0.19095543f, -0.08504700f, 
    0.04820570f, -0.12738860f, 0.04084185f, -0.21132001f, -0.26684266f, 0.06809055f, -0.01486180f, -0.11685891f, 
    -0.01264409f, 0.12308291f, 0.16041896f, 0.05799687f, -0.40823239f, -0.24571468f, 0.02956117f, 0.03343597f, 
    -0.23515540f, 0.25890040f, -0.07888528f, -0.27191836f, 0.04187290f, 0.14884599f, -0.15293448f, 0.26818806f, 
    0.01432733f, 0.23538592f, 0.08171023f, -0.05007358f, -0.01188776f, 0.32978457f, 0.14546813f, -0.37458602f, 
    -0.08558227f, -0.21397598f, -0.27787817f, 0.29219884f, 0.20619622f, -0.17297387f, -0.15033633f, 0.10805973f, 
    -0.00545311f, 0.22901689f, 0.11621414f, 0.13055323f, 0.09863330f, 0.04527923f, 0.17673239f, -0.09038123f, 
    0.00003683f, -0.08210236f, 0.09098203f, 0.01427372f, -0.38985568f, -0.12308303f, 0.15633406f, -0.16836430f, 
    0.10065636f, 0.30038366f, 0.34962335f, 0.09032550f, -0.17637576f, -0.02758935f, -0.11419999f, 0.13212363f, 
    -0.00571146f, 0.07536706f, 0.00677195f, -0.08858350f, 0.09897901f, 0.03400878f, 0.23952739f, -0.23494481f, 
    0.11763716f, 0.21306658f, -0.30506146f, 0.20465969f, 0.11518015f, -0.02383055f, -0.16150013f, -0.09133637f, 
    0.02682340f, -0.01414996f, 0.05560413f, -0.03990393f, 0.23451696f, -0.08995071f, 0.11526072f, 0.10792863f, 
    0.09879784f, 0.01471093f, -0.02761597f, 0.02467938f, -0.16822186f, -0.19574232f, -0.25859123f, -0.00346041f, 
    0.06150115f, 0.09001481f, -0.19710502f, 0.08909663f, 0.06633689f, 0.10888804f, -0.06151750f, -0.08851352f, 
    0.16585746f, 0.07130031f, -0.18393224f, 0.09917024f, -0.09123687f, -0.05025936f, 0.09812741f, -0.37105671f, 
    -0.36720014f, 0.01530607f, 0.12459867f, 0.28986356f, -0.05649251f, 0.01468057f, 0.05778997f, 0.14528421f, 
    -0.05975291f, -0.09066051f, 0.09795907f, 0.00958663f, 0.03862016f, 0.00288715f, -0.09710267f, 0.32050136f, 
    0.07307876f, -0.10169405f, -0.07950083f, 0.03568989f, 0.06940641f, 0.23870148f, 0.02371861f, 0.06259041f, 
    0.21174221f, -0.13169073f, 0.14433028f, 0.09616751f, 0.03996025f, -0.16548233f, -0.01804363f, 0.21356335f, 
    -0.04939859f, 0.09409479f, 0.46917492f, 0.06020918f, 0.04541746f, 0.10371518f, -0.06678444f, -0.06793596f, 
    -0.13536772f, -0.02690344f, -0.01419247f, -0.07420222f, -0.17488632f, -0.34607139f, 0.06775636f, -0.02155562f, 
    0.05063310f, -0.05882228f, 0.13127568f, -0.07590543f, -0.16047592f, -0.00209879f, 0.13451487f, -0.05034627f, 
    0.21268453f, 0.14067256f, -0.02392781f, 0.02402366f, 0.01398697f, -0.08727087f, -0.19004476f, -0.16112697f, 
    0.16943677f, -0.00127749f, 0.10813432f, 0.04299486f, -0.07364997f, -0.06144395f, 0.13773650f, -0.02092463f, 
    -0.09596659f, -0.05299830f, -0.13542169f, 0.00757760f, 0.05344497f, 0.02647228f, 0.04007390f, -0.28942710f, 
    -0.27613240f, -0.25848535f, 0.01085885f, -0.08447720f, 0.02082150f, 0.02572684f, -0.10580418f, 0.07783281f, 
    0.03358869f, 0.00316864f, 0.03193956f, 0.04064721f, 0.04630333f, -0.05762435f, 0.02945486f, 0.00376497f, 
    0.03563748f, 0.04823441f, 0.00249709f, -0.03485753f, -0.04235807f, -0.04372615f, 0.02760600f, 0.03609449f, 
    -0.04595271f, 0.04564466f, 0.04230961f, 0.05082934f, -0.05565905f, -0.03700999f, -0.05104809f, 0.01721562f, 
    0.03711271f, 0.03356767f, -0.01237074f, -0.06140934f, -0.00782451f, -0.01732696f, -0.05277820f, -0.00977161f, 
    -0.00344500f, -0.02656203f, -0.01798002f, 0.01047080f, 0.04818721f, 0.05056712f, -0.02093119f, -0.03708339f, 
    0.01074040f, 0.03657559f, -0.02895965f, -0.01700285f, 0.03281377f, -0.00918069f, 0.04973082f, -0.02767816f, 
    -0.02217439f, -0.01160111f, -0.04091799f, -0.01849359f, -0.05944458f, -0.03524296f, -0.03559956f, -0.06420202f, 
    0.01530076f, 0.04624868f, 0.05318720f, 0.02311455f, -0.04080993f, 0.01408573f, -0.05330916f, 0.00752878f, 
    -0.02342261f, 0.01315677f, 0.00101972f, -0.03947601f, -0.04621533f, -0.02652370f, 0.04983714f, 0.04969316f, 
    -0.02978027f, 0.00995879f, -0.05199859f, -0.04131812f, -0.05973678f, -0.03012579f, -0.02732422f, 0.01004238f, 
    -0.05855085f, 0.04783167f, -0.00859972f, 0.02251614f, -0.03506592f, 0.04041945f, -0.04229024f, 0.02887245f, 
    -0.03269515f, -0.01570471f, 0.03736749f, -0.01297711f, 0.02828241f, 0.00623306f, 0.00570391f, 0.00741380f, 
    -0.00585652f, -0.02072032f, 0.02793722f, -0.05983837f, 0.00873866f, -0.02044851f, -0.02422634f, -0.05201901f, 
    0.05025631f, 0.03449670f, -0.05255725f, 0.02563936f, 0.02441943f, 0.00237332f, 0.04352443f, -0.02111563f, 
    -0.02492220f, 0.03947393f, 0.01371912f, -0.00427842f, -0.01629782f, -0.04846647f, 0.02024599f, -0.01196650f, 
    0.01748773f, -0.03996925f, -0.02580507f, -0.04758080f, 0.04741310f, 0.04736158f, 0.04336602f, 0.02273349f, 
    -0.03146957f, 0.02898218f, -0.06201567f, -0.06149361f, -0.02841995f, -0.05886541f, -0.04182389f, -0.04240434f, 
    0.00854698f, 0.00946923f, -0.04221646f, 0.05071948f, -0.06197675f, -0.02281921f, 0.00826773f, 0.02110014f, 
    -0.03487410f, -0.05503927f, 0.05860593f, -0.02124636f, 0.03450622f, 0.05081692f, 0.04555475f, 0.00572508f, 
    -0.02053184f, 0.04661633f, -0.04965242f, 0.00277095f, 0.00196840f, 0.00040011f, -0.00399224f, 0.00514846f, 
    0.00431176f, 0.05151021f, -0.04208821f, -0.04768738f, -0.03477636f, 0.04532413f, 0.04534577f, 0.04493716f, 
    0.03825350f, 0.02164682f, -0.04533303f, -0.01445757f, -0.04670422f, -0.01097196f, -0.01042759f, 0.02039353f, 
    -0.01578833f, -0.05284826f, -0.03940432f, 0.04742052f, 0.04275492f, 0.03364820f, -0.02124354f, -0.02697802f, 
    0.01465556f, -0.05181162f, -0.05947092f, 0.00261974f, 0.02014518f, -0.01830702f, -0.04790331f, 0.02366065f, 
    -0.05967022f, -0.03879531f, -0.05189781f, 0.01272112f, 0.01843677f, -0.06167791f, 0.00411482f, -0.05386040f, 
    -0.03216085f, -0.05820641f, 0.00851761f, -0.04860286f, 0.02347392f, 0.02950395f, -0.04571554f, -0.02383592f, 
    -0.01445212f, 0.00239910f, -0.05962841f, -0.00861498f, -0.01068865f, 0.00025418f, -0.02002005f, -0.00343626f, 
    -0.05358759f, 0.01977449f, -0.02611773f, 0.02547894f, -0.03866223f, 0.01157016f, -0.01553324f, 0.04971166f, 
    -0.01432272f, -0.01176803f, 0.05036087f, 0.01993943f, -0.01186930f, -0.04131256f, -0.04758493f, -0.00545267f, 
    0.02044692f, 0.02137848f, -0.00615836f, -0.05930013f, -0.04189824f, -0.04635701f, -0.05867148f, -0.05411882f, 
    -0.00726928f, -0.02913029f, 0.04396776f, 0.00647919f, -0.03740702f, 0.02972334f, -0.02939933f, -0.00957267f, 
    -0.04895014f, 0.00344049f, -0.06191719f, 0.03152238f, 0.00293810f, 0.02074852f, -0.01494182f, -0.03755209f, 
    0.02537202f, 0.04546168f, 0.04625114f, 0.01108752f, -0.00957255f, -0.06227585f, 0.02391672f, -0.02745968f, 
    -0.04987609f, -0.04763517f, -0.02119176f, -0.00191428f, -0.00443407f, -0.00787922f, -0.00046555f, 0.02281314f, 
    -0.05616118f, 0.01334998f, -0.01160894f, 0.01584522f, 0.03325349f, -0.02142813f, 0.00084902f, -0.03449283f, 
    -0.05888645f, -0.05151545f, -0.02396386f, -0.05320348f, 0.03302652f, -0.00427199f, -0.04353369f, -0.04390151f, 
    -0.01101841f, 0.04448053f, 0.00635049f, -0.01274721f, -0.02320604f, -0.03343637f, 0.00632309f, -0.02845685f, 
    0.04027190f, -0.00085798f, -0.01681594f, -0.05074339f, -0.02220625f, -0.04502933f, -0.04460062f, 0.04725721f, 
    -0.03925176f, -0.01227639f, -0.01995489f, -0.02001073f, 0.01711078f, -0.04891064f, -0.03059707f, -0.01585099f, 
    -0.01407009f, -0.03002058f, -0.00952416f, -0.06585551f, 0.04850554f, -0.05725447f, 0.04623857f, -0.00077233f, 
    -0.05925841f, -0.05355993f, 0.03773978f, -0.06827679f, -0.01663041f, 0.00158172f, -0.01439098f, 0.01746787f, 
    -0.05975803f, -0.01250860f, 0.01288277f, -0.02872755f, 0.00822867f, 0.03877575f, 0.03609433f, -0.00326233f, 
    -0.00282136f, 0.00615548f, -0.01322361f, 0.03726115f, -0.05247060f, -0.04964600f, 0.01320959f, -0.05048970f, 
    0.02087587f, 0.03597870f, -0.02260460f, 0.04743741f, -0.01785967f, 0.04674548f, -0.00468421f, -0.04615972f, 
    0.02766709f, -0.03176169f, 0.03195380f, -0.00301320f, -0.05303972f, -0.03529080f, 0.01006032f, -0.06046656f, 
    -0.01825116f, -0.06677818f, 0.00464725f, -0.02007643f, -0.01477511f, 0.01216756f, -0.05985382f, -0.05203687f, 
    0.04103321f, -0.02431686f, 0.02956211f, -0.04372018f, 0.02473462f, -0.00746695f, 0.00052028f, 0.03495354f, 
    -0.05779392f, 0.03329206f, -0.06032086f, -0.02362377f, 0.01183887f, -0.05144967f, -0.02803297f, -0.01317041f, 
    -0.05039583f, -0.03726082f, -0.04852270f, 0.01877038f, 0.01625691f, -0.03339852f, 0.00766472f, -0.00840570f, 
    0.01894999f, -0.00878540f, 0.04072789f, -0.04066087f, 0.02048036f, -0.04182638f, 0.02750716f, 0.04936866f, 
    -0.05874912f, 0.04918730f, -0.04744111f, -0.01279040f, -0.03905359f, 0.01179258f, 0.00418805f, -0.06399344f, 
    -0.02822753f, -0.00594959f, 0.02277117f, 0.05685975f, -0.05371916f, 0.02054387f, 0.00078461f, -0.05198372f, 
    0.03268975f, -0.03796692f, -0.05065836f, 0.00663315f, -0.03367880f, -0.03817074f, -0.00268899f, -0.04093165f, 
    -0.06719843f, -0.01640120f, 0.02239988f, 0.02247440f, 0.04372339f, -0.06709553f, -0.04134716f, -0.03660940f, 
    -0.00863414f, -0.02049775f, 0.04448735f, 0.01105999f, 0.03311723f, -0.00977519f, -0.04201154f, -0.06058416f, 
    -0.03138807f, -0.05575182f, -0.04706994f, 0.01385611f, 0.00447826f, 0.01203834f, -0.02701679f, -0.00246357f, 
    0.03292715f, -0.03665005f, 0.03462451f, -0.05531735f, 0.00233238f, 0.04533865f, -0.06462298f, 0.01399738f, 
    0.04870687f, -0.01806604f, -0.05863117f, 0.00750117f, 0.04405670f, -0.00315095f, 0.00834625f, -0.04078619f, 
    -0.05419671f, -0.02856006f, -0.01855939f, -0.00995217f, -0.02360467f, -0.06359947f, -0.04510716f, 0.04634142f, 
    0.03631969f, -0.06340154f, 0.02274894f, -0.03807743f, 0.00923587f, 0.02761923f, 0.04312883f, 0.00374294f, 
    -0.04497009f, -0.04237026f, 0.00979255f, -0.00531283f, 0.01778722f, -0.00331775f, -0.05943267f, -0.05248264f, 
    -0.02703443f, -0.04337130f, 0.03378688f, -0.04600384f, -0.03513150f, 0.03328677f, -0.06137469f, 0.03332743f, 
    0.01332007f, -0.02922497f, -0.03280751f, -0.04763620f, -0.00754894f, -0.01097614f, -0.04572408f, -0.01371697f, 
    0.01327774f, 0.03235389f, 0.01269329f, 0.01503839f, 0.02322344f, 0.03924489f, -0.05154450f, 0.01717108f, 
    -0.04424627f, -0.05824719f, -0.00618453f, 0.01662589f, -0.02780757f, -0.01284444f, -0.01664549f, -0.06803212f, 
    -0.04478637f, -0.03394639f, -0.05274920f, -0.00283610f, -0.03142079f, -0.02621758f, 0.02412249f, 0.02272094f, 
    -0.00745472f, 0.03873270f, 0.02135497f, 0.02657929f, -0.01539155f, -0.01804329f, -0.04009924f, -0.00869923f, 
    -0.00827600f, 0.02419071f, 0.04375449f, 0.01940492f, -0.03446392f, -0.00503376f, 0.00375716f, 0.01071326f, 
    0.02655916f, -0.04480652f, 0.03691958f, -0.00566337f, 0.03849049f, 0.00709654f, -0.02809385f, -0.02846980f, 
    0.02110390f, 0.01731471f, 0.00496008f, 0.01330487f, -0.00434475f, 0.01297092f, -0.00281854f, 0.01705633f, 
    -0.04760638f, 0.01278841f, -0.01273507f, -0.03603479f, -0.05902960f, -0.05557131f, -0.01037990f, -0.04340668f, 
    0.00112189f, 0.02674648f, -0.02135572f, 0.04084456f, -0.05025464f, -0.02936320f, -0.06251137f, 0.02584697f, 
    -0.03836358f, 0.03800800f, 0.05153106f, -0.03593687f, -0.05033344f, 0.03559482f, 0.00657488f, -0.03261949f, 
    -0.00232669f, 0.06086541f, -0.01709676f, -0.00812822f, 0.00556954f, -0.02393718f, 0.05043586f, -0.02104279f, 
    0.04966613f, -0.02833480f, -0.03867914f, -0.04142316f, -0.05475294f, -0.00462339f, -0.06613474f, -0.05867693f, 
    -0.01223950f, 0.03449799f, -0.04761183f, -0.04350616f, -0.05404840f, 0.04592397f, -0.06177351f, -0.01738980f, 
    -0.05218940f, -0.02873816f, 0.02961656f, 0.01844856f, -0.02176495f, -0.06384131f, 0.00150535f, 0.00486236f, 
    -0.01186914f, -0.06225696f, 0.02146177f, -0.03644150f, 0.05475670f, -0.02138513f, -0.01312248f, 0.04165467f, 
    -0.05406302f, -0.01109941f, -0.00236081f, -0.03810238f, 0.04238774f, -0.01679805f, 0.01722346f, 0.02226948f, 
    -0.00735603f, 0.01899762f, 0.00191001f, 0.04930955f, -0.01465707f, 0.01994234f, -0.06245324f, -0.03655988f, 
    0.05044717f, -0.00036043f, 0.02792207f, -0.02047515f, -0.00544530f, -0.01646130f, 0.03001740f, -0.06282907f, 
    -0.01087055f, -0.02227435f, 0.02601270f, -0.00846079f, -0.01029853f, -0.02128499f, -0.03473506f, 0.02917955f, 
    0.01629393f, 0.04729065f, -0.02732202f, 0.03132772f, -0.01644670f, 0.02722841f, -0.03656832f, 0.00848025f, 
    0.02606582f, -0.00116445f, -0.06570960f, 0.02359311f, 0.02470402f, 0.00466282f, -0.05246596f, 0.03214926f, 
    -0.06588115f, 0.01949673f, 0.01783512f, -0.04964600f, -0.04587257f, -0.01616303f, 0.03613726f, 0.05026599f, 
    -0.04558478f, 0.02094978f, -0.03166429f, 0.03339872f, -0.03128749f, -0.05945406f, -0.02887770f, -0.00974145f, 
    -0.03147501f, -0.00028588f, -0.03640509f, -0.05613031f, 0.00387320f, 0.02614658f, 0.00310391f, 0.04626327f, 
    0.04251301f, -0.06115487f, 0.04674373f, 0.00364312f, -0.01384012f, -0.05438555f, -0.00529831f, 0.02807807f, 
    0.01234271f, 0.03079131f, 0.00645329f, -0.04287123f, -0.02441844f, 0.04496086f, -0.03904691f, 0.00058570f, 
    -0.04365432f, -0.00159762f, 0.00111380f, -0.03217071f, 0.03308969f, 0.00713912f, 0.02807077f, 0.00509355f, 
    -0.05506937f, -0.01695992f, 0.02091300f, 0.02571011f, -0.02952209f, -0.00079235f, -0.02108389f, -0.05700130f, 
    -0.05634723f, 0.02701920f, -0.00048987f, 0.03546654f, -0.00867674f, -0.05887733f, 0.04624005f, 0.00426717f, 
    -0.03610235f, 0.04131356f, 0.02704007f, 0.02943408f, -0.02901825f, -0.03481139f, -0.03315538f, 0.04020493f, 
    0.03439327f, -0.01135773f, 0.05119608f, 0.00888036f, -0.00175033f, 0.00562963f, -0.02929059f, -0.01299947f, 
    -0.00334598f, -0.00200552f, -0.01097356f, -0.05863119f, -0.01014342f, -0.00894602f, -0.00674817f, 0.04544507f, 
    -0.01902096f, -0.05967354f, -0.00489848f, 0.04087575f, 0.01732665f, 0.02425182f, 0.01249170f, -0.03999713f, 
    0.01981805f, -0.00111429f, 0.03498157f, 0.02438128f, -0.01549765f, -0.02346975f, 0.03179929f, 0.04855684f, 
    0.02622858f, -0.05767654f, -0.06015222f, -0.02080845f, -0.02787699f, 0.04602806f, 0.01100331f, -0.02615904f, 
    -0.04395318f, 0.02501438f, 0.04377003f, 0.05176045f, -0.02989482f, -0.04108318f, -0.01724912f, -0.02031153f, 
    0.02453752f, -0.05543081f, 0.04296117f, -0.01458582f, -0.03475114f, -0.04381737f, 0.01566380f, -0.03462574f, 
    -0.05814117f, 0.03526104f, 0.03458007f, -0.02948742f, -0.04877851f, -0.00315748f, -0.04569310f, -0.00781404f, 
    -0.04570495f, -0.04846488f, -0.00048479f, 0.04155445f, 0.02273032f, 0.01637939f, -0.05943935f, -0.00388213f, 
    0.02219834f, -0.04198585f, -0.02614680f, -0.00298295f, -0.04403815f, -0.04332467f, -0.03956424f, -0.00442685f, 
    -0.04705659f, 0.01093300f, -0.04775368f, 0.03651146f, -0.06091819f, -0.04330610f, -0.06047405f, -0.03816183f, 
    -0.05489730f, 0.00553253f, 0.02340502f, -0.04399109f, -0.04997645f, -0.03974782f, 0.05638558f, -0.00404731f, 
    -0.00591528f, 0.02211998f, 0.03122667f, 0.00090906f, 0.03699709f, 0.02799512f, -0.02860302f, 0.02480997f, 
    -0.04327794f, 0.03007286f, 0.00906925f, 0.01108947f, 0.04356986f, -0.03152871f, 0.00844440f, 0.00609398f, 
    0.01695996f, -0.00265029f, 0.03950920f, -0.05054120f, 0.02363631f, -0.02309125f, 0.01962767f, -0.00507236f, 
    -0.27055505f, 0.21961737f, -0.21212396f, 0.04725881f, -0.06351132f, -0.20395620f, -0.09162323f, -0.14937942f, 
    -0.32109064f, -0.30213955f, -0.15428224f, 0.02269512f, 0.00120492f, -0.04099821f, 0.05732907f, 0.05299836f, 
    0.04575595f, 0.07218494f, -0.21243538f, 0.05597741f, -0.32775319f, 0.03712047f, -0.21613652f, -0.09645653f, 
    0.02910100f, -0.01069428f, -0.08823295f, 0.33259714f, -0.11220772f, 0.07945165f, -0.11339399f, -0.09400844f, 
    -0.02795783f, 0.06293527f, -0.28966501f, -0.00875659f, 0.14282504f, -0.16895542f, 0.07147174f, -0.02846887f, 
    0.03045362f, -0.13663642f, 0.05614232f, -0.01898469f, 0.17800003f, 0.29522499f, -0.13052671f, -0.09495600f, 
    -0.04921681f, 0.14437172f, 0.03127747f, 0.15614644f, -0.08686171f, 0.08167964f, -0.04806587f, -0.59381068f, 
    -0.15998654f, 0.01145632f, 0.20212996f, 0.27593759f, -0.09948204f, -0.12905838f, -0.09528363f, 0.41202044f, 
    -0.28577730f, -0.02945307f, -0.07564518f, -0.18310748f, 0.04381806f, -0.02159943f, 0.07269935f, -0.04164735f, 
    -0.31566703f, -0.38640675f, 0.15394174f, -0.14419536f, 0.00066811f, 0.13059843f, -0.17343311f, 0.16336894f, 
    -0.12239397f, -0.30056083f, 0.03240222f, 0.15396434f, 0.17627433f, -0.03107793f, 0.17901713f, 0.04231250f, 
    0.12038324f, -0.04284832f, 0.38358483f, 0.12372385f, -0.04342568f, -0.09393963f, 0.12475001f, -0.17298441f, 
    0.02930972f, 0.00424299f, 0.09416487f, 0.11115971f, 0.48520410f, 0.08127373f, 0.03601705f, -0.01213364f, 
    -0.11856608f, -0.07033542f, 0.24782355f, 0.22705773f, 0.08046266f, 0.33456004f, -0.19229028f, -0.06431434f, 
    -0.00404270f, -0.08112255f, 0.12861905f, 0.06514385f, 0.04054077f, 0.34425813f, 0.25933656f, 0.18277785f, 
    -0.01080722f, -0.01809080f, 0.23264778f, -0.13247231f, 0.18092421f, 0.22172219f, -0.08475620f, 0.08397071f, 
    0.13208729f, -0.11875579f, -0.14133546f, 0.00746805f, 0.10994382f, -0.12211666f, 0.03067558f, -0.31483495f, 
    0.11548910f, 0.04824664f, 0.08372290f, 0.10961314f, -0.17836110f, -0.05494139f, 0.04841700f, 0.13726045f, 
    0.05543003f, 0.17336708f, 0.04988258f, -0.05336379f, -0.08200245f, -0.19632693f, 0.03936248f, 0.15103526f, 
    0.04004979f, -0.04023045f, -0.03597315f, -0.14463155f, -0.19688500f, -0.01583198f, 0.12540260f, 0.01565866f, 
    0.09045641f, 0.09686974f, 0.01564006f, 0.19310351f, -0.33349195f, -0.07745613f, -0.24823776f, 0.00303840f, 
    0.16961782f, 0.08891950f, -0.01999852f, -0.02318555f, 0.00872016f, 0.09269767f, -0.08892953f, 0.08533821f, 
    -0.09365042f, 0.15114664f, 0.03063439f, -0.08276348f, 0.30806899f, -0.11881497f, -0.08856727f, -0.01002855f, 
    0.07004278f, 0.16240513f, 0.34891075f, 0.05299738f, -0.17065868f, 0.11803048f, 0.08656219f, -0.07640391f, 
    0.09286664f, -0.00496549f, -0.17300949f, -0.03477389f, 0.13053851f, 0.21889971f, 0.06569696f, -0.08707584f, 
    0.06496349f, -0.07136510f, 0.09096975f, -0.04910699f, 0.02873074f, -0.12776701f, -0.10560018f, 0.41406497f, 
    -0.27165434f, 0.06459924f, -0.11309204f, 0.05537154f, 0.09598242f, -0.01249997f, 0.08651412f, -0.01700290f, 
    0.19928245f, -0.10420662f, -0.02733919f, -0.17526306f, -0.04518627f, 0.06353936f, 0.12110075f, 0.03611520f, 
    0.12141750f, -0.43873557f, -0.07355266f, 0.09840690f, 0.20636603f, 0.02707654f, 0.12419774f, -0.02406853f, 
    0.04943996f, 0.04612778f, -0.08606032f, 0.04575696f, 0.02928354f, -0.01172824f, -0.13318257f, -0.04730661f, 
    0.03697005f, -0.02860141f, -0.01109247f, -0.03070149f, 0.17736687f, 0.02317108f, -0.04429951f, -0.17533182f, 
    0.05412422f, -0.02921560f, 0.02093988f, -0.05265176f, -0.15844686f, 0.11523784f, -0.07181266f, -0.12741032f, 
    -0.15135343f, -0.12875295f, 0.14797191f, -0.11582235f, -0.00763196f, -0.42263693f, 0.00911670f, 0.11117163f, 
    -0.06560793f, 0.07341968f, 0.11169063f, 0.03585999f, -0.06822088f, -0.04366085f, 0.16691071f, 0.08557975f, 
    -0.27944165f, 0.10644682f, -0.07269519f, 0.05442631f, 0.05832653f, -0.02367150f, 0.00699481f, 0.25639728f, 
    0.01194717f, -0.22492449f, -0.09538025f, -0.14934924f, -0.19707480f, 0.20261671f, 0.06039387f, 0.03280641f, 
    0.20996727f, -0.10479651f, -0.19200832f, 0.06516591f, 0.10678627f, -0.00001256f, -0.15289840f, -0.01813501f, 
    0.00928961f, -0.00119661f, 0.09017190f, 0.00928762f, -0.20275840f, 0.04622474f, 0.13643217f, -0.11692528f, 
    -0.07354038f, -0.17516221f, 0.39742279f, -0.25207445f, -0.24753347f, -0.01660624f, 0.14926805f, 0.13832380f, 
    0.12721226f, 0.12317608f, -0.15236709f, 0.06314619f, 0.14037143f, -0.23438199f, 0.03969165f, -0.04469495f, 
    0.10027268f, 0.00657308f, 0.08386796f, -0.13831994f, 0.06058294f, -0.21277297f, 0.02442504f, -0.12419992f, 
    -0.01441306f, 0.05195503f, -0.05736476f, -0.01359795f, -0.20402245f, 0.02054100f, -0.13509965f, 0.07591083f, 
    -0.31022012f, 0.24103789f, 0.09338092f, -0.08177473f, 0.05751353f, -0.23295933f, -0.38674408f, 0.48316866f, 
    0.11391804f, 0.03718470f, 0.17740890f, -0.16356766f, -0.04826602f, -0.04338385f, -0.09506554f, 0.03856401f, 
    -0.34259713f, 0.04871559f, -0.20248283f, 0.00204370f, 0.10149000f, 0.05622135f, -0.03442512f, -0.06422362f, 
    -0.17688064f, -0.04415062f, 0.01528822f, 0.02777373f, 0.23478603f, -0.07772707f, 0.08451925f, 0.03943260f, 
    -0.02282829f, -0.26720580f, -0.03578912f, 0.07114623f, -0.14291793f, 0.01044322f, -0.03266582f, 0.24951264f, 
    0.11080951f, -0.03158289f, 0.18626225f, -0.12071662f, 0.01385163f, -0.02611266f, -0.04215333f, -0.03070198f, 
    -0.07449567f, -0.05896908f, 0.09598449f, 0.04937746f, -0.05201553f, -0.16126511f, 0.07686826f, -0.19827208f, 
    -0.05556948f, 0.07969593f, 0.18501922f, 0.10218663f, -0.17579837f, 0.06023090f, -0.03844279f, -0.11223833f, 
    0.12359522f, -0.11336303f, 0.32117668f, -0.13871723f, 0.08054033f, -0.18076240f, 0.13574937f, -0.04406261f, 
    0.05213066f, -0.00193661f, 0.28735411f, -0.06666552f, 0.15934120f, 0.10735595f, -0.24710515f, -0.03829167f, 
    0.18409508f, 0.00361124f, -0.30794358f, -0.01019756f, 0.31521279f, -0.15833922f, 0.10603505f, 0.15866040f, 
    -0.00981279f, -0.00375858f, -0.07260544f, -0.14982457f, 0.07314330f, 0.00380720f, 0.18140802f, 0.11723149f, 
    -0.01225279f, -0.27308923f, -0.22429641f, -0.13429965f, 0.07967058f, 0.02880651f, -0.06560181f, -0.07116540f, 
    0.26047471f, 0.00362168f, -0.09195995f, 0.00858964f, 0.06726050f, -0.11493051f, 0.06094706f, 0.15749797f, 
    -0.03345288f, 0.18987848f, 0.23775612f, -0.18370435f, 0.07566127f, -0.28730580f, 0.15589879f, -0.14533192f, 
    0.16096336f, -0.04082358f, -0.05317906f, -0.05070590f, -0.28601670f, 0.11298875f, 0.15116780f, -0.22429486f, 
    -0.07057609f, -0.14572977f, -0.06864721f, -0.08480070f, -0.17932762f, -0.06104067f, 0.15170591f, -0.08626832f, 
    0.15362824f, -0.05292052f, -0.18557127f, 0.22390053f, -0.05808050f, 0.22978307f, 0.20158924f, 0.10505176f, 
    -0.17839648f, -0.11984351f, -0.10244741f, -0.04306868f, 0.14813411f, 0.07715024f, 0.01096648f, 0.21558104f, 
    -0.36281273f, 0.15642099f, -0.07471440f, 0.06376784f, 0.05261271f, -0.15063746f, -0.12167723f, -0.01483023f, 
    0.16603750f, 0.14789490f, 0.20381649f, 0.18117614f, -0.06238116f, 0.01886584f, 0.01212911f, -0.12303935f, 
    0.24032713f, 0.06808215f, -0.31664377f, 0.13598242f, 0.02361355f, 0.02144479f, 0.07652927f, -0.02115223f, 
    -0.07732390f, 0.15365726f, -0.00558024f, 0.05714178f, -0.11890025f, -0.00364112f, 0.05862360f, -0.13505906f, 
    -0.08023425f, -0.10223623f, 0.22856370f, 0.21122019f, -0.08327045f, -0.16562387f, 0.10580020f, -0.02383789f, 
    0.00602289f, -0.05181973f, 0.02471121f, 0.15464295f, 0.06081739f, -0.08152782f, 0.08499093f, -0.00792786f, 
    0.01538676f, -0.24600117f, -0.00157692f, -0.05758567f, 0.54459697f, -0.10745171f, 0.12128837f, -0.00884139f, 
    0.11520512f, -0.04651181f, -0.03843254f, 0.09389824f, -0.03918409f, 0.22308448f, 0.05037026f, -0.14301261f, 
    0.06519218f, -0.06570206f, 0.19452749f, -0.03795265f, -0.10699289f, -0.02581027f, 0.42153552f, -0.02353104f, 
    -0.04134270f, 0.07161582f, 0.04355716f, -0.02155924f, 0.12208291f, 0.05356221f, -0.17233099f, 0.39133492f, 
    -0.41890612f, 0.02354172f, -0.09800754f, -0.03823619f, 0.07464969f, -0.09925739f, 0.01576659f, -0.20908627f, 
    0.05728167f, -0.11765441f, 0.19361842f, -0.01996120f, 0.18044539f, -0.06304633f, 0.04912331f, -0.08781598f, 
    -0.08554035f, -0.24726635f, -0.26922438f, 0.08728887f, -0.06417003f, -0.12674671f, -0.01269314f, 0.13622575f, 
    -0.11946191f, 0.12101919f, 0.15201110f, 0.21448646f, 0.14272526f, -0.30271378f, -0.00706596f, -0.07258395f, 
    -0.08327077f, 0.07978175f, -0.15372097f, -0.10458613f, -0.16528018f, 0.10445160f, 0.09727123f, -0.09698433f, 
    0.11468507f, -0.20339558f, 0.05283071f, -0.04885410f, 0.16983217f, -0.07937201f, -0.00880077f, -0.03120985f, 
    0.04932965f, 0.09077768f, -0.04567858f, 0.02136230f, -0.06100203f, -0.05191229f, -0.18622637f, -0.17163481f, 
    -0.10357136f, 0.19528207f, 0.03412790f, -0.16004486f, 0.09531543f, -0.02288695f, 0.01479229f, 0.00830140f, 
    -0.35001791f, -0.01208274f, -0.11527916f, 0.22788088f, -0.07424827f, 0.14037614f, -0.00584240f, -0.31012335f, 
    -0.09064885f, 0.01757002f, 0.02831781f, -0.12860252f, 0.01240288f, -0.03858209f, 0.00940172f, -0.13401313f, 
    0.02330525f, 0.00841991f, -0.18092027f, -0.10358263f, -0.05296385f, 0.01619625f, -0.09704786f, -0.04829826f, 
    0.04067370f, -0.25743598f, 0.07511786f, -0.14364827f, -0.03659340f, 0.29569846f, 0.12222910f, -0.16623548f, 
    -0.03033120f, -0.05765356f, -0.18117078f, 0.10071822f, 0.11603806f, -0.04446253f, -0.04521439f, 0.00604621f, 
    0.08652098f, 0.00550078f, -0.04266280f, -0.11152147f, 0.31213784f, 0.24197879f, 0.07350428f, 0.15666783f, 
    -0.22627078f, -0.11449367f, 0.29802036f, -0.00272609f, 0.23086235f, 0.00194813f, 0.11577848f, -0.04774240f, 
    0.01400151f, 0.09248119f, -0.08200655f, 0.08552162f, -0.04551917f, 0.44227967f, 0.25675973f, 0.00199713f, 
    0.08997523f, 0.05609722f, 0.08374907f, -0.17585161f, 0.13926476f, 0.16843298f, -0.11443102f, -0.08798932f, 
    0.00326641f, -0.07021403f, -0.00634604f, -0.09683773f, -0.14430101f, 0.00206347f, 0.03728235f, -0.37630615f, 
    0.10323641f, -0.05808575f, 0.12074978f, 0.04391524f, -0.17987168f, 0.06765798f, 0.17719083f, 0.12912829f, 
    0.30520988f, -0.21126918f, 0.05436522f, 0.17483850f, 0.15179749f, -0.03776120f, -0.00677544f, 0.18793942f, 
    -0.21973680f, 0.10509031f, -0.06169088f, -0.07921879f, -0.02669548f, -0.03561249f, 0.09950504f, -0.13653877f, 
    -0.00993641f, -0.08922193f, 0.32138151f, 0.02294769f, 0.26738939f, -0.16220455f, -0.05365516f, -0.05154150f, 
    -0.08221420f, 0.16085209f, -0.01926092f, -0.15808524f, -0.12507817f, 0.10753387f, 0.01217597f, 0.11764543f, 
    -0.01783234f, 0.01934621f, 0.08690903f, -0.05941552f, 0.36072618f, 0.19676886f, 0.20179036f, 0.04563442f, 
    0.02418393f, 0.05386491f, -0.17814294f, -0.00444708f, 0.03079054f, 0.22010291f, -0.25384995f, 0.20275867f, 
    0.00504836f, 0.08961793f, -0.16654067f, 0.01913955f, 0.21447383f, 0.07475081f, 0.14017993f, -0.27078480f, 
    0.01127462f, 0.08228262f, -0.00848571f, -0.05963862f, -0.15204078f, -0.05447988f, -0.14483449f, 0.07707254f, 
    -0.31980917f, -0.09550323f, -0.16293716f, -0.22311810f, -0.06742972f, 0.03643486f, -0.09012244f, -0.08213773f, 
    0.28690839f, -0.26909003f, -0.01447438f, -0.07223982f, -0.11364469f, -0.00597065f, -0.15203269f, -0.07881133f, 
    0.10779428f, -0.04206929f, 0.07732900f, -0.10409534f, 0.13233985f, 0.15648183f, 0.11553474f, 0.13224164f, 
    -0.07651145f, 0.12451301f, 0.13257523f, -0.17535432f, 0.12589183f, 0.00419451f, 0.11932299f, -0.00289772f, 
    0.01570389f, 0.11809608f, -0.05209571f, -0.01940371f, -0.20323877f, 0.02862731f, 0.05605726f, -0.04500456f, 
    -0.09069171f, -0.09573610f, -0.09041837f, -0.02601313f, 0.36973599f, -0.03041039f, 0.00280343f, -0.33625987f, 
    -0.02479585f, 0.03367924f, 0.06990353f, -0.03262688f, -0.03389127f, 0.34942764f, -0.12400419f, 0.12422937f, 
    0.15478313f, -0.00852258f, 0.16029856f, -0.00884987f, 0.14362265f, 0.05830700f, -0.11456950f, 0.10207248f, 
    0.16737808f, 0.05957134f, -0.05738096f, -0.09399319f, 0.07648279f, -0.08442475f, 0.05983490f, 0.34927091f, 
    0.12029314f, 0.18841343f, -0.15986896f, 0.10340478f, 0.01687898f, 0.12306426f, 0.08878249f, -0.03198470f, 
    -0.25537586f, -0.00763164f, 0.10332226f, 0.03049281f, 0.07049686f, 0.15230668f, -0.03021079f, -0.11839654f, 
    -0.18070547f, 0.07962873f, 0.05734824f, 0.02095425f, 0.01316610f, 0.03635531f, 0.04774508f, 0.00507411f, 
    -0.03196584f, -0.10493117f, -0.16558532f, -0.67471308f, 0.10946962f, -0.22179928f, 0.13581418f, -0.09804064f, 
    -0.14013182f, 0.01336667f, -0.09718677f, 0.51907670f, 0.13584247f, -0.14989586f, 0.06836842f, 0.03642422f, 
    -0.00155220f, 0.06625429f, -0.03101382f, -0.09933873f, -0.21243325f, -0.04277356f, 0.12837280f, -0.05286098f, 
    -0.19613938f, -0.04581796f, -0.09187374f, 0.28358427f, 0.04660274f, -0.06716554f, 0.22332865f, 0.15261924f, 
    -0.02172478f, -0.11132116f, -0.12579365f, -0.05507049f, 0.13532072f, 0.04684579f, -0.14437133f, -0.14827305f, 
    -0.11544210f, 0.06343034f, 0.18391031f, -0.03500738f, -0.00170308f, 0.04958531f, -0.09182614f, 0.56706792f, 
    -0.10621703f, 0.08917893f, -0.04062656f, -0.04354262f, 0.05536008f, 0.17364867f, 0.10258777f, -0.07181738f, 
    -0.17657630f, 0.02202564f, -0.05842130f, 0.03084373f, -0.04891270f, -0.05218239f, -0.06047690f, -0.10742800f, 
    0.22106951f, -0.02425196f, 0.30841467f, 0.03038555f, -0.13939516f, 0.07465023f, 0.05934247f, 0.23394187f, 
    0.16066314f, 0.13591273f, 0.22979939f, -0.24310036f, -0.19418426f, 0.09624285f, 0.06277285f, -0.05020342f, 
    -0.11555121f, 0.08177863f, -0.06361748f, 0.51620126f, 0.34780288f, 0.07177376f, 0.10625575f, 0.13042201f, 
    0.00502326f, 0.19366741f, -0.17405292f, -0.20143156f, -0.24418890f, -0.00079015f, 0.03671006f, -0.10339738f, 
    -0.12189140f, -0.07519411f, 0.11853539f, -0.00595690f, -0.07216815f, 0.20939241f, 0.09908538f, -0.00948659f, 
    0.25214666f, 0.02401285f, 0.07538175f, 0.13282402f, 0.10584099f, 0.00395505f, -0.28693739f, 0.01594910f, 
    0.05278025f, 0.06482156f, -0.07576892f, 0.08142330f, 0.18105565f, 0.03177999f, 0.09413552f, 0.25106791f, 
    0.14771640f, 0.08491141f, 0.15788813f, 0.05352258f, -0.08743625f, 0.22867864f, -0.06762398f, 0.09444855f, 
    -0.46104604f, -0.05468706f, -0.43216452f, -0.18706787f, -0.04930568f, 0.19930215f, -0.11262017f, -0.00539894f, 
    0.04439580f, 0.03035400f, -0.05025687f, 0.10386513f, 0.02294559f, 0.09996287f, 0.01563617f, 0.30949050f, 
    0.15657862f, 0.03911845f, -0.25080490f, 0.13397579f, -0.01364683f, 0.01493195f, -0.11109948f, -0.00938123f, 
    0.11415352f, -0.05267391f, 0.08464099f, -0.16653205f, -0.00156840f, -0.34876427f, 0.05924312f, -0.08967169f, 
    -0.18679801f, 0.06535481f, -0.01334093f, 0.01125939f, -0.12430401f, -0.35699323f, -0.00458773f, 0.00670678f, 
    -0.10789718f, -0.04677281f, -0.00225176f, 0.12388556f, -0.17463647f, -0.01710819f, 0.56283087f, -0.52505058f, 
    0.03195577f, 0.09562562f, 0.10637513f, 0.03546250f, -0.03177613f, -0.00980881f, 0.06067133f, 0.05727098f, 
    -0.12371849f, 0.12894681f, -0.11536043f, -0.09558832f, -0.22036400f, 0.01169979f, 0.15024610f, -0.00140984f, 
    -0.05518233f, 0.02937071f, -0.32510445f, -0.19430351f, -0.05287379f, -0.30545428f, -0.03635098f, 0.02839550f, 
    0.14446972f, 0.11904831f, -0.05615951f, -0.07118184f, -0.06678940f, -0.06391070f, 0.04258369f, -0.03642302f, 
    0.07083591f, -0.05070880f, 0.19955777f, 0.40809682f, 0.08242954f, 0.18076408f, 0.01381755f, -0.05941436f, 
    -0.04089249f, 0.11380630f, 0.13429059f, 0.32886189f, -0.32685876f, 0.16332664f, 0.00778923f, -0.10353073f, 
    0.03322263f, 0.00718940f, 0.03457195f, -0.30845669f, -0.20844735f, 0.00774968f, 0.00279921f, 0.04824862f, 
    0.02820043f, -0.17036985f, -0.10737959f, -0.08209315f, -0.18875338f, -0.45404688f, 0.19752139f, 0.04101121f, 
    0.12094219f, 0.01730318f, 0.14298601f, 0.09163875f, -0.00508971f, 0.18342461f, 0.08843098f, -0.32239285f, 
    -0.16264607f, -0.09183317f, 0.09349285f, 0.24772383f, -0.05240596f, -0.07787143f, -0.06333058f, -0.00852972f, 
    0.05864803f, -0.26173082f, -0.06565994f, -0.02259324f, -0.01538491f, -0.03923827f, -0.00756134f, -0.08594552f, 
    -0.56009656f, 0.02437666f, -0.12448090f, -0.06756540f, 0.00366926f, -0.19171369f, -0.05665433f, 0.05689210f, 
    -0.40043855f, 0.03664786f, -0.04110724f, 0.34460467f, 0.13692626f, -0.07892978f, -0.05734561f, 0.00498300f, 
    -0.10984042f, -0.07864685f, 0.20721272f, 0.20124348f, 0.19693184f, 0.10616290f, 0.05670615f, 0.10074174f, 
    -0.03874688f, -0.06240615f, 0.18200508f, -0.01385573f, -0.17576636f, -0.30480462f, 0.04145004f, -0.00607982f, 
    -0.17566158f, -0.06738567f, 0.06973129f, 0.12870330f, -0.13831039f, -0.03807472f, -0.08145534f, 0.02723160f, 
    -0.00274597f, 0.07308941f, -0.10715021f, 0.13695854f, -0.05874938f, 0.19503666f, 0.06017360f, 0.12858233f, 
    -0.04997092f, -0.11633510f, 0.18425478f, 0.05509857f, 0.14918536f, -0.16345319f, -0.00600726f, 0.15832086f, 
    -0.03781185f, 0.00401400f, 0.06442150f, 0.12449715f, 0.09770186f, -0.03630853f, 0.17764853f, -0.36578101f, 
    -0.27583382f, -0.13627206f, 0.01723967f, 0.07196359f, -0.03753053f, -0.08384845f, -0.09876319f, 0.30401072f, 
    -0.15067334f, -0.13131127f, -0.28554511f, 0.02292644f, -0.20212057f, 0.07527772f, -0.26037040f, 0.08080354f, 
    0.03230931f, -0.21813197f, -0.03760896f, -0.20054585f, 0.18298636f, 0.14381906f, -0.24013470f, 0.09166584f, 
    -0.04163652f, -0.14437972f, 0.15041508f, 0.12656704f, 0.13757619f, -0.04908864f, -0.03381888f, 0.18042284f, 
    0.13125534f, 0.05561216f, -0.33008149f, 0.05594718f, -0.04427594f, -0.00024796f, -0.12874918f, -0.29104403f, 
    0.11205151f, -0.20668434f, -0.08366280f, -0.21701519f, -0.13182962f, -0.30353114f, 0.43656194f, 0.17869031f, 
    0.07421198f, -0.05181270f, 0.02555410f, -0.00111789f, 0.00247469f, 0.03828519f, 0.15863840f, 0.08700444f, 
    -0.08862259f, -0.02522708f, -0.17881888f, 0.05690480f, -0.09413581f, 0.00332204f, -0.07935622f, 0.01645850f, 
    0.00502852f, 0.04078196f, 0.16008657f, -0.06297798f, 0.11124714f, 0.13090669f, 0.05688043f, -0.10560399f, 
    -0.02716849f, 0.26329768f, -0.00554881f, 0.13074487f, 0.19956245f, 0.06675668f, 0.15951683f, 0.17070414f, 
    -0.03432336f, -0.05553285f, 0.07641352f, -0.06414822f, -0.16005868f, 0.03078926f, 0.14786105f, 0.09865464f, 
    -0.39319134f, -0.22366674f, -0.14619927f, 0.38488877f, 0.14834946f, -0.02578331f, 0.03485836f, -0.15191683f, 
    -0.11544183f, 0.01665193f, 0.09225114f, 0.24575567f, -0.01339799f, 0.04869584f, -0.11786102f, 0.24686287f, 
    0.13593516f, 0.30476731f, 0.07678148f, -0.01203266f, -0.03675415f, 0.11529219f, -0.07923095f, 0.04721980f, 
    -0.04744874f, -0.02614481f, 0.14653693f, -0.31839597f, -0.28438649f, 0.02683446f, 0.27450755f, 0.19383687f, 
    0.03796719f, 0.16240539f, -0.00775492f, -0.05757651f, -0.07208184f, -0.10877878f, -0.06030046f, -0.26432562f, 
    -0.01448351f, -0.00423005f, 0.21625780f, 0.09604383f, -0.02014010f, 0.10496433f, 0.21649273f, -0.18918523f, 
    0.14992282f, 0.09948006f, 0.12944470f, -0.01533020f, -0.10863377f, 0.07088868f, 0.01397892f, 0.02542478f, 
    0.20918499f, -0.25712612f, 0.03329690f, -0.11110959f, -0.17691040f, 0.10869086f, 0.16733930f, -0.10869417f, 
    0.08026622f, 0.20095372f, -0.44605967f, 0.02779143f, -0.22729738f, 0.06492715f, 0.07008832f, -0.04188655f, 
    -0.08956779f, 0.09396449f, 0.34584880f, -0.27915275f, 0.05772096f, -0.05814359f, 0.07497016f, 0.08574121f, 
    0.10653128f, 0.04821093f, 0.07131621f, 0.10125222f, -0.07383128f, 0.09577831f, 0.14237249f, -0.07687479f, 
    -0.06603461f, 0.03455060f, 0.01421969f, -0.15899035f, -0.22997813f, 0.06497464f, 0.11705565f, 0.15389612f, 
    -0.00391096f, -0.16222192f, 0.00887033f, -0.18979821f, -0.26279011f, 0.14549789f, 0.31204769f, 0.02096244f, 
    -0.05799834f, -0.00108758f, -0.05115536f, 0.02649160f, -0.02653789f, 0.14992134f, -0.06056248f, 0.10874800f, 
    -0.01485612f, -0.02442361f, -0.03130024f, -0.06135436f, -0.11499552f, -0.32076472f, 0.15418364f, 0.22965738f, 
    -0.01333460f, -0.02388054f, -0.02815492f, -0.16177677f, -0.06889313f, 0.02907825f, -0.25819686f, -0.11737759f, 
    0.22166550f, 0.10519844f, -0.21871701f, -0.16104956f, -0.08261599f, -0.06255892f, -0.09729253f, -0.00114614f, 
    0.07875350f, 0.16493039f, -0.08977144f, -0.12874690f, 0.00229655f, -0.00591477f, -0.05058026f, 0.07099631f, 
    -0.05737504f, -0.01217203f, -0.01837654f, -0.00585280f, -0.04648307f, -0.05136979f, -0.03338733f, 0.01485815f, 
    -0.01047156f, -0.03034030f, 0.04547061f, 0.02382830f, 0.03116622f, -0.03829139f, -0.02506524f, 0.02476072f, 
    0.03095900f, 0.02386660f, 0.00708203f, 0.02904620f, -0.00538277f, -0.04177993f, 0.02240786f, -0.04689823f, 
    -0.04689608f, -0.06499743f, -0.04014980f, 0.01676722f, -0.05563661f, 0.02724488f, -0.03456817f, 0.02892151f, 
    -0.00809762f, 0.02695957f, 0.01816527f, -0.03095493f, -0.04650326f, -0.05021455f, 0.03263176f, 0.02501183f, 
    -0.03974181f, -0.01688280f, -0.04716833f, -0.00885376f, -0.04726332f, -0.00482926f, 0.01837177f, 0.03710263f, 
    0.04211040f, -0.06245126f, -0.00151209f, -0.04303153f, -0.05859219f, 0.03549955f, -0.02179100f, 0.02254892f, 
    0.01422242f, -0.04097338f, -0.02742169f, -0.05873930f, -0.01302491f, -0.03947808f, -0.04105536f, -0.05322266f, 
    -0.05871673f, 0.02825038f, -0.01755169f, -0.02342741f, -0.05620345f, 0.03732410f, -0.03391493f, -0.04752097f, 
    0.04700426f, -0.05645857f, 0.00593523f, -0.06691434f, -0.00877580f, -0.03358395f, -0.06743274f, 0.02037175f, 
    -0.02538453f, -0.01950115f, 0.00171354f, 0.03885719f, 0.03082751f, 0.04851170f, 0.02538582f, -0.00878391f, 
    -0.03833679f, 0.00696200f, -0.00994600f, -0.04836779f, -0.03675900f, -0.02142044f, 0.05050571f, -0.01833647f, 
    0.04273390f, 0.04610996f, 0.01841841f, -0.03293825f, -0.00207965f, 0.04985146f, 0.02840718f, 0.00023096f, 
    -0.02660083f, 0.03384263f, -0.01180873f, -0.03382674f, -0.01984015f, -0.00985688f, 0.03182473f, -0.02245486f, 
    0.01282192f, -0.04346279f, 0.01377639f, -0.01454453f, -0.05802664f, 0.00864419f, -0.02599784f, 0.01673013f, 
    0.01903629f, 0.02229906f, 0.02990776f, -0.04726904f, 0.04244289f, 0.03140202f, -0.02611634f, 0.04437606f, 
    0.04451596f, -0.01373467f, -0.02288076f, -0.02384106f, 0.01254943f, -0.01049385f, -0.00932214f, 0.00295487f, 
    -0.06242970f, 0.02834263f, 0.03163845f, 0.00227931f, -0.03117953f, -0.01184217f, 0.01436001f, 0.00125875f, 
    0.05422499f, -0.04803283f, 0.01098421f, -0.04534626f, 0.03088266f, 0.00637251f, 0.00049138f, -0.03365247f, 
    -0.01542066f, 0.02954974f, -0.03974080f, -0.05544969f, 0.03546827f, 0.03964959f, -0.05588249f, -0.06752340f, 
    0.02446770f, -0.00969187f, -0.01043651f, -0.00103063f, -0.01230027f, 0.03290931f, 0.02477087f, -0.00553370f, 
    -0.04356894f, 0.00847049f, 0.03849139f, -0.02134576f, -0.05827191f, -0.04213899f, 0.01469517f, -0.02036615f, 
    -0.02740116f, 0.04651782f, -0.03659947f, -0.03822985f, 0.04203011f, -0.04548347f, -0.06014028f, 0.03990251f, 
    -0.06499919f, -0.02501569f, -0.04532280f, -0.06531511f, -0.01531512f, 0.02537234f, 0.02720264f, 0.02767923f, 
    0.02133118f, 0.00415980f, -0.00924009f, 0.00696189f, -0.05219208f, 0.03515531f, -0.06385044f, 0.02698931f, 
    -0.04754636f, 0.04438762f, 0.03296372f, -0.02073906f, -0.05753710f, -0.03563165f, 0.01455706f, -0.06373999f, 
    -0.04089318f, 0.01105766f, 0.03566910f, 0.02265380f, 0.02452024f, -0.03194448f, 0.01155131f, -0.04040984f, 
    -0.01121909f, 0.03639844f, 0.00260297f, 0.04169933f, -0.03375033f, -0.00010149f, -0.02277598f, -0.06598938f, 
    0.04223365f, -0.01728751f, 0.03929294f, 0.04252390f, 0.03371200f, 0.04597750f, -0.06429044f, -0.01388809f, 
    -0.04797050f, -0.01651465f, -0.04371278f, -0.02606901f, 0.01933626f, -0.03883448f, 0.00339008f, -0.05882802f, 
    -0.05282133f, 0.04990849f, -0.06341678f, 0.02027839f, -0.05409110f, -0.05622721f, 0.03925655f, 0.00563788f, 
    -0.02292324f, -0.02475525f, 0.04284189f, -0.02459476f, 0.01141014f, 0.04813356f, -0.01510045f, 0.02680490f, 
    -0.01117357f, -0.01891182f, -0.04111437f, -0.02402822f, 0.00552617f, -0.01550379f, 0.00924430f, -0.03195346f, 
    0.02026309f, -0.06079138f, -0.05772067f, -0.04464853f, -0.06261257f, -0.02976843f, -0.03153564f, -0.06675728f, 
    -0.03250172f, -0.03142766f, 0.03513180f, 0.02703378f, 0.02693375f, -0.06003037f, 0.04260109f, -0.03771999f, 
    0.04567425f, -0.02452279f, -0.06393142f, -0.06279746f, -0.03626510f, -0.06268457f, 0.00160708f, -0.06297011f, 
    -0.05019599f, -0.05676620f, -0.01165107f, 0.04032348f, -0.01107055f, 0.04168572f, -0.05621603f, -0.01360680f, 
    -0.01462999f, -0.03604934f, -0.05671261f, 0.01404199f, 0.00185617f, -0.03802567f, -0.03226881f, -0.04639738f, 
    0.00811621f, -0.02072041f, -0.05467035f, -0.05233249f, -0.04229952f, -0.01347404f, -0.00784976f, 0.04838273f, 
    -0.05129944f, 0.01371514f, -0.01210965f, -0.03377847f, 0.05176502f, 0.00889749f, -0.05965665f, 0.02341882f, 
    0.01331675f, -0.00477351f, 0.01112427f, 0.01655845f, -0.03241144f, 0.03279658f, -0.04186108f, 0.00878968f, 
    -0.05711635f, 0.01317208f, 0.01418947f, -0.02945339f, 0.03083596f, 0.04256715f, 0.00116671f, -0.05026611f, 
    -0.05835623f, -0.01937565f, 0.00332078f, -0.03658880f, -0.02892762f, -0.05221044f, -0.02979989f, -0.00045321f, 
    0.00357613f, -0.05508517f, -0.04236618f, -0.03010607f, 0.00921492f, -0.04549230f, 0.01133042f, 0.04647774f, 
    -0.06010169f, 0.01939750f, 0.02919709f, 0.00987265f, -0.01902562f, -0.03479367f, 0.00154976f, 0.02779643f, 
    0.01563045f, 0.01504758f, 0.01058383f, 0.00362432f, 0.04882230f, 0.01596107f, -0.04977773f, -0.04063931f, 
    -0.03323049f, -0.05644090f, -0.04503779f, 0.03855718f, -0.01716279f, 0.04590598f, 0.03870628f, -0.05745335f, 
    -0.03748244f, 0.04763374f, 0.04712946f, -0.00199214f, 0.00156331f, -0.01777443f, -0.02899254f, -0.00968389f, 
    -0.05444271f, 0.04006559f, 0.02052437f, 0.01792461f, -0.01418825f, -0.05854024f, 0.01674934f, 0.01788254f, 
    -0.05645709f, -0.04202883f, 0.00183567f, -0.01532203f, -0.01955932f, 0.04721231f, -0.03193414f, -0.04311112f, 
    -0.01090123f, -0.04936085f, 0.01461783f, -0.01784013f, -0.05798557f, -0.02286843f, -0.00421106f, 0.01325638f, 
    -0.03788695f, -0.06084323f, -0.03001644f, -0.01413531f, -0.01412364f, 0.00443674f, -0.03251310f, -0.03097063f, 
    0.01033764f, 0.05377397f, -0.06346630f, 0.02758252f, 0.01543261f, 0.02206526f, 0.01684812f, 0.00898772f, 
    -0.04961217f, -0.04490253f, 0.00684731f, 0.00759328f, 0.00980854f, 0.02914735f, 0.03103763f, 0.00205012f, 
    0.04957519f, -0.05170221f, -0.01457114f, -0.00966013f, 0.04535392f, -0.00512266f, 0.01155120f, -0.01376143f, 
    0.01374209f, 0.02878428f, -0.04336817f, -0.01349751f, 0.01934469f, -0.04230278f, -0.02582601f, 0.04450899f, 
    -0.04419148f, -0.05074271f, -0.05072812f, 0.03333484f, 0.01595957f, -0.05646861f, -0.02286167f, 0.04455361f, 
    0.00250826f, 0.00835343f, -0.00676444f, -0.02117183f, -0.03571973f, -0.04116726f, 0.04256710f, -0.03031263f, 
    -0.02810751f, -0.00328384f, 0.02789581f, -0.05186043f, -0.00706444f, -0.00116419f, -0.05313613f, 0.01510441f, 
    -0.00627955f, -0.02303437f, -0.00987921f, 0.01489456f, 0.04135565f, -0.03796581f, -0.02941196f, 0.03399382f, 
    0.00115480f, -0.06386685f, -0.05169268f, -0.05813620f, 0.01734783f, -0.01118440f, -0.04263396f, -0.00481108f, 
    -0.01437681f, 0.04671647f, 0.03176326f, 0.04114017f, 0.03298358f, 0.00167080f, 0.00544138f, -0.00288783f, 
    -0.01784745f, 0.00123285f, 0.03217806f, -0.05328093f, -0.05596242f, -0.03438062f, -0.04780220f, 0.00948169f, 
    -0.01148710f, -0.01585760f, -0.02014185f, -0.02056101f, -0.00014841f, 0.03523551f, -0.04293523f, -0.01840235f, 
    0.03578278f, 0.01138478f, -0.01773535f, 0.00883667f, 0.02605652f, 0.02528518f, -0.05625255f, -0.05272335f, 
    -0.03608265f, -0.05624830f, 0.04500601f, -0.05922049f, -0.02218273f, -0.04616959f, -0.04485263f, 0.02940713f, 
    0.03244067f, 0.02776109f, 0.01514844f, -0.04356913f, -0.05904381f, 0.03472596f, -0.04031434f, 0.04939016f, 
    0.00486229f, 0.04321562f, 0.01098643f, 0.00506371f, -0.00009339f, 0.00064948f, -0.05947651f, 0.02103851f, 
    0.04500788f, -0.02942270f, -0.02362034f, -0.04958511f, 0.00103452f, -0.04172550f, 0.04842843f, -0.04945367f, 
    0.02907603f, -0.03176093f, 0.04128212f, -0.01974787f, 0.05158572f, -0.02188566f, -0.02437945f, -0.04171613f, 
    0.00876622f, 0.03679818f, -0.03402545f, 0.03719433f, -0.03893169f, -0.03837774f, 0.04570428f, -0.02113614f, 
    -0.03471758f, 0.04504117f, -0.03727957f, -0.02760344f, -0.00719733f, -0.00668221f, -0.04979808f, -0.02776851f, 
    -0.04605852f, -0.10221552f, 0.08810461f, 0.11865719f, -0.04332637f, -0.18292551f, 0.09406266f, -0.03200312f, 
    -0.08088304f, -1.14851987f, -1.04341865f, -0.14360037f, -0.03952195f, 0.03807749f, -0.07136098f, 0.13992377f, 
    0.03948052f, -0.01186888f, 0.06747743f, -0.15364332f, 0.11848831f, -0.00263705f, -0.07612880f, 0.07740810f, 
    0.13987644f, -0.04319396f, 0.05184640f, 0.27033880f, -0.15713750f, -0.05598343f, 0.13947241f, -0.07925777f, 
    0.03366680f, -0.13895229f, -0.05526203f, 0.01497215f, 0.06755429f, 0.14923261f, 0.07269827f, 0.21094203f, 
    -0.09705885f, 0.05875736f, -0.18149769f, 0.01834298f, 0.15009122f, -0.41980305f, -0.18619421f, -0.40483341f, 
    0.07851576f, 0.07162101f, 0.06546181f, -0.15118760f, 0.15910847f, -0.10630696f, -0.25454107f, -0.20036405f, 
    -0.04827187f, 0.11295883f, 0.13146357f, 0.06174790f, -0.09986719f, 0.11868518f, 0.15914504f, 0.23350054f, 
    -0.29105395f, -0.19369987f, 0.03021485f, 0.04549579f, -0.16204815f, 0.08060526f, -0.09159669f, -0.16762815f, 
    -0.35271889f, -0.16702326f, -0.01872401f, 0.18196905f, -0.01283766f, -0.07680828f, 0.09336087f, 0.08974747f, 
    -0.08335603f, -0.72396159f, -0.27760944f, -0.28961274f, -0.01281702f, -0.00978922f, 0.01152699f, -0.03642931f, 
    0.05886112f, -0.04271715f, 0.07297345f, -0.21398816f, 0.02064947f, -0.03581639f, -0.06858766f, 0.11747785f, 
    0.01443622f, 0.12650311f, 0.05257993f, 0.24896313f, 0.07530970f, -0.10120866f, -0.07062509f, 0.13795614f, 
    0.10211181f, 0.17506915f, 0.07442485f, -0.05994600f, -0.22868244f, 0.14648017f, 0.19459403f, 0.00931574f, 
    0.11547010f, -0.08363011f, -0.00973076f, -0.02959664f, -0.22925350f, 0.22764345f, -0.03338728f, -0.01153529f, 
    -0.15982871f, 0.23300411f, 0.09618758f, -0.01823612f, 0.15204452f, -0.22750232f, 0.10841600f, 0.28091738f, 
    -0.03916564f, -0.10044949f, -0.11977965f, 0.08154150f, 0.01895756f, -0.06472842f, 0.06007496f, -0.23440842f, 
    0.17225026f, -0.16989318f, 0.13264419f, 0.03459924f, 0.08738489f, -0.09378833f, 0.16217591f, -0.16410483f, 
    -0.04775834f, 0.03591296f, -0.08835796f, -0.05845977f, -0.11093929f, -0.21430893f, -0.01513937f, 0.12080763f, 
    0.09349956f, -0.15320395f, 0.16030395f, 0.21794815f, 0.16069852f, -0.09476243f, 0.11774821f, -0.20875439f, 
    -0.16383401f, -0.18734622f, -0.09425779f, 0.02443702f, 0.04872171f, -0.11809520f, -0.00155636f, 0.06879604f, 
    0.08296873f, 0.18715826f, -0.03048260f, 0.17137130f, 0.06029459f, 0.05482894f, -0.15114568f, -0.19129491f, 
    0.04250818f, -0.13256244f, 0.07254525f, 0.09023973f, 0.10141919f, 0.06838510f, -0.04088418f, -0.03387525f, 
    -0.10145573f, 0.04721134f, 0.21021256f, 0.17621985f, 0.15427242f, 0.38686398f, 0.19267371f, -0.01839958f, 
    -0.05941125f, 0.00154311f, -0.24758355f, 0.02323466f, 0.27190086f, -0.03952054f, 0.30424491f, 0.26394221f, 
    0.21493393f, 0.21381554f, 0.06671261f, 0.14906397f, -0.21784157f, 0.10482239f, 0.09072448f, -0.08897989f, 
    -0.23506343f, -0.07362647f, 0.23268169f, 0.14083424f, 0.08930469f, -0.12408809f, 0.00710776f, 0.21799821f, 
    0.06882218f, 0.12216505f, 0.26324850f, 0.29044768f, 0.12514585f, 0.15737432f, -0.09231115f, -0.03765553f, 
    0.02014977f, -0.32659972f, -0.01953133f, -0.05866211f, 0.06616607f, 0.19855551f, -0.00074118f, 0.07550266f, 
    -0.23628226f, 0.04862759f, 0.08881297f, 0.06032997f, 0.06090643f, -0.03152995f, 0.01983729f, -0.04108668f, 
    0.10350850f, 0.11577895f, 0.06801645f, 0.10098153f, 0.26886719f, 0.15219250f, -0.10865363f, -0.12791257f, 
    0.03491105f, -0.10240170f, 0.14126483f, 0.06990301f, 0.14420228f, 0.09545860f, -0.02945252f, -0.14487639f, 
    -0.07246098f, -0.16148156f, 0.14524250f, -0.03190278f, 0.13268694f, -0.47754106f, -0.32703584f, -0.00501720f, 
    0.16224746f, 0.07955797f, 0.11997753f, -0.05723931f, 0.03233202f, -0.26448804f, -0.13539772f, -0.32806912f, 
    -0.25000837f, -0.00815854f, -0.08311684f, -0.13314474f, -0.03256024f, -0.01066731f, -0.00708162f, 0.02764251f, 
    -0.02710619f, 0.07341764f, -0.08774389f, -0.02705012f, -0.02604587f, 0.11887299f, -0.03636036f, -0.01829881f, 
    0.37545049f, -0.14506114f, 0.18726785f, 0.10014459f, -0.02821993f, -0.06590097f, -0.22236405f, 0.01893968f, 
    -0.27670383f, 0.01944586f, 0.16342649f, -0.16938324f, 0.17304976f, -0.00025657f, 0.18767741f, -0.10744330f, 
    0.05327747f, 0.14373709f, -0.04731263f, -0.02222326f, -0.01744886f, 0.26563182f, 0.00794118f, 0.38603649f, 
    -0.01072123f, 0.03089990f, -0.10082020f, -0.13268004f, -0.13164034f, -0.12756856f, -0.02181979f, -0.11806120f, 
    0.12567741f, -0.15051569f, 0.16376105f, -0.06042804f, 0.51757586f, -0.25566989f, -0.10839948f, 0.00285650f, 
    0.04395808f, -0.09769629f, 0.02785865f, -0.02541317f, 0.06753454f, 0.16304812f, -0.14510825f, -0.03653379f, 
    0.02764781f, 0.06763735f, 0.04410787f, -0.01844097f, -0.04325391f, -0.08318012f, -0.64674991f, 0.14440545f, 
    -0.19787151f, -0.05032653f, 0.23437542f, -0.06071754f, -0.11562631f, -0.06613681f, 0.06573838f, -0.08620139f, 
    -0.28849089f, 0.34227288f, -0.04605395f, 0.07840729f, -0.14376043f, -0.19964349f, 0.06717942f, 0.22284263f, 
    -0.02241161f, 0.14949757f, -0.30877846f, 0.08649651f, 0.09873157f, -0.01612159f, 0.00809043f, -0.13260518f, 
    0.04990442f, -0.00812564f, -0.13004403f, 0.04301746f, 0.18161096f, 0.12668964f, -0.08872373f, 0.01557509f, 
    0.08248994f, 0.24146193f, 0.24298292f, -0.18494615f, -0.09888604f, -0.01455447f, 0.05533797f, 0.03145196f, 
    0.00018601f, -0.11367700f, 0.14140913f, 0.18763921f, -0.05379924f, -0.08270151f, -0.09770929f, -0.09733704f, 
    -0.02919387f, 0.06546229f, -0.14419515f, 0.08774137f, -0.05330881f, 0.14259131f, 0.14658111f, -0.00877958f, 
    0.09910665f, 0.11172231f, -0.14441776f, 0.16687025f, -0.07789868f, -0.07332305f, 0.35307145f, 0.01487458f, 
    0.00170357f, 0.01387082f, -0.12291784f, -0.18588494f, 0.17237544f, -0.06174807f, 0.03279904f, -0.24393320f, 
    -0.11215088f, -0.13134861f, -0.04858071f, -0.12762184f, -0.15001579f, -0.05444450f, -0.09637634f, 0.10539287f, 
    -0.04163687f, -0.15839908f, -0.09696278f, -0.08462494f, -0.03946867f, -0.18736184f, -0.05844790f, 0.23612733f, 
    -0.05828824f, -0.05625961f, -0.44586992f, 0.02224919f, 0.06683922f, -0.05437959f, 0.00159084f, -0.05856111f, 
    0.03862108f, -0.01874200f, 0.15641385f, -0.08596063f, -0.21027297f, -0.09452261f, 0.08766557f, -0.10765606f, 
    -0.06417330f, 0.03644593f, 0.33305094f, -0.02006115f, -0.06673998f, 0.15042248f, 0.11031519f, 0.06658336f, 
    -0.03829003f, -0.07055899f, 0.22729202f, -0.07547206f, 0.07561782f, -0.19697349f, -0.20692363f, 0.01352796f, 
    0.01582633f, -0.08581434f, 0.13026442f, -0.24757142f, -0.25469020f, 0.10652910f, 0.04002843f, -0.03087389f, 
    0.20450081f, 0.16752605f, -0.05372125f, -0.04708107f, 0.16527879f, 0.07016091f, 0.27607808f, -0.22638828f, 
    -0.01668971f, -0.14942996f, 0.09382058f, 0.02598612f, -0.08547285f, 0.15219358f, 0.23183411f, 0.10589503f, 
    -0.37013194f, 0.02668648f, -0.06755057f, 0.01659412f, 0.03077446f, -0.04498205f, -0.16780630f, 0.09759822f, 
    0.36676407f, 0.11844492f, 0.00567137f, 0.10946463f, 0.11197929f, 0.10153186f, 0.13816306f, -0.02494789f, 
    0.13751821f, 0.28040189f, -0.09880485f, -0.14494988f, 0.03203845f, 0.01234788f, -0.10980041f, 0.02981455f, 
    -0.09083747f, 0.41989088f, 0.15555654f, 0.07758690f, -0.19366945f, -0.03415342f, 0.00591545f, 0.02616168f, 
    0.08850959f, -0.04341225f, 0.15181923f, 0.25182229f, -0.18789664f, 0.02265090f, -0.06754892f, 0.09509698f, 
    0.09224981f, -0.03182692f, 0.12169561f, 0.44770971f, -0.20120563f, -0.35578924f, 0.08139639f, -0.07623604f, 
    0.07058535f, -0.07672460f, 0.04509519f, -0.04483897f, 0.65820801f, -0.17133650f, -0.02999656f, 0.18023510f, 
    0.06936138f, -0.03123611f, 0.07739101f, -0.01482971f, -0.14425613f, 0.09170412f, 0.09670848f, -0.19025482f, 
    0.10523438f, 0.08222446f, 0.02858435f, -0.15713772f, 0.07691509f, 0.02004868f, 0.24211448f, -0.25349167f, 
    -0.38601950f, -0.22625044f, -0.01165134f, 0.15766205f, 0.18524313f, 0.15374587f, 0.22619887f, -0.14959514f, 
    -0.44205934f, -0.14567921f, -0.06320085f, 0.04322356f, -0.08127008f, 0.10091392f, -0.04704696f, -0.00899571f, 
    0.33953619f, -0.15750045f, -0.18557100f, -0.00149923f, -0.10995289f, 0.27395031f, 0.05998672f, -0.02835080f, 
    0.06360287f, -0.12392722f, 0.10983784f, 0.15916283f, 0.16879651f, -0.03200988f, -0.06990221f, 0.01325281f, 
    -0.03469212f, 0.16469604f, -0.03324900f, 0.06113750f, -0.11797433f, 0.18648744f, -0.12166289f, 0.12285896f, 
    -0.07371414f, -0.11009119f, -0.11475192f, -0.07393323f, -0.07990841f, -0.16924761f, 0.05373980f, 0.11164621f, 
    0.18986459f, 0.05820601f, 0.00023647f, -0.11542080f, -0.28787369f, -0.04681881f, -0.12944111f, 0.02020896f, 
    0.08798903f, 0.05804685f, -0.00174706f, -0.01706143f, -0.01167430f, 0.00085790f, 0.07381303f, -0.03869776f, 
    0.04532614f, -0.06992310f, -0.08533870f, -0.05503904f, 0.05296173f, 0.03897116f, -0.19454968f, 0.19933298f, 
    -0.06050590f, 0.03099158f, -0.04320276f, -0.03064399f, 0.01777132f, -0.03195337f, 0.23758923f, -0.35878217f, 
    -0.08099118f, -0.10861348f, 0.27937657f, 0.09358190f, 0.05885929f, -0.06643443f, -0.18256773f, 0.09881700f, 
    0.26594046f, -0.03520056f, -0.14483169f, 0.00643040f, -0.02027501f, -0.12552078f, 0.18749936f, 0.07840364f, 
    0.16963167f, 0.21930943f, -0.08046662f, 0.17100964f, -0.06638872f, -0.12708825f, -0.03615544f, -0.15923193f, 
    0.33824232f, 0.09094505f, 0.13750428f, -0.06449392f, -0.19367574f, 0.06415784f, -0.02052375f, 0.03387871f, 
    0.07367751f, 0.04715922f, 0.01320487f, -0.03638825f, 0.11809029f, 0.08860696f, -0.09422296f, 0.03054254f, 
    0.04992666f, 0.08739625f, -0.12963639f, -0.33576605f, 0.17982118f, -0.11101557f, 0.07783379f, 0.08079851f, 
    0.06166745f, 0.01689343f, -0.22445142f, 0.00312054f, 0.16771428f, 0.18111441f, 0.08616736f, -0.14970562f, 
    -0.10869466f, 0.02144392f, 0.00296367f, 0.08230556f, 0.05358142f, -0.22101527f, -0.24379328f, -0.14805201f, 
    -0.32832250f, -0.01410305f, 0.04550830f, -0.04269561f, -0.08103515f, 0.05996747f, 0.11783163f, 0.10339335f, 
    -0.02468892f, 0.11473963f, -0.03994253f, -0.16801903f, -0.03581641f, 0.19409885f, 0.21407627f, 0.12006282f, 
    0.02671104f, 0.21569148f, 0.17705235f, 0.21838492f, -0.07953337f, -0.05701410f, 0.12597066f, 0.05610950f, 
    -0.15343006f, -0.47468266f, -0.13521227f, 0.01511557f, 0.06258787f, 0.02377338f, -0.07613336f, -0.18358126f, 
    -0.09440069f, -0.09906282f, 0.18714365f, 0.00943750f, -0.02211817f, 0.06998254f, -0.14992742f, -0.03297689f, 
    0.04844723f, 0.04070931f, 0.00885733f, 0.00462278f, 0.17657220f, -0.11748711f, -0.13877724f, 0.00749930f, 
    -0.06023177f, 0.16680473f, 0.16838743f, -0.03092149f, -0.00911059f, 0.05106116f, -0.10069748f, -0.10905135f, 
    -0.01662237f, 0.04546919f, 0.02262612f, 0.30098629f, 0.06696183f, 0.10954177f, 0.23830906f, 0.36288837f, 
    -0.13089004f, 0.27630544f, -0.09785245f, -0.06550586f, -0.02266397f, -0.07933387f, -0.15463661f, -0.28570530f, 
    -0.03278048f, 0.00267571f, -0.04777553f, 0.15272719f, -0.15628596f, 0.00306139f, -0.15097731f, -0.06901754f, 
    -0.06775264f, -0.01601847f, 0.12698349f, 0.12996939f, 0.01480386f, -0.14215185f, -0.10986574f, 0.15597172f, 
    -0.24444664f, -0.10153260f, 0.11326250f, 0.11931209f, -0.02892869f, 0.07811431f, -0.04239004f, -0.01812549f, 
    -0.04926052f, 0.25823539f, 0.18628706f, 0.11167178f, -0.01634151f, 0.03101841f, 0.10901055f, 0.20809346f, 
    0.10299131f, 0.05860880f, 0.31492028f, 0.28515539f, 0.12029337f, -0.10554694f, -0.05221136f, 0.03768257f, 
    -0.06160074f, 0.00183518f, -0.06252017f, -0.08750211f, 0.02133845f, -0.24486540f, 0.01774209f, 0.01458901f, 
    0.09963715f, 0.07204458f, -0.06003010f, -0.04758448f, 0.12566812f, 0.17009084f, -0.14158386f, -0.12269928f, 
    -0.16727851f, 0.12108807f, 0.18066187f, -0.05390097f, 0.19006819f, -0.33518013f, -0.13645218f, -0.06673835f, 
    0.24868533f, -0.05020731f, 0.09574488f, 0.05851254f, -0.21163346f, -0.16116768f, -0.01332950f, -0.11151657f, 
    -0.09768346f, -0.08670970f, -0.15107322f, -0.21613675f, 0.04299019f, -0.06974279f, 0.13912913f, -0.06223340f, 
    -0.10496329f, 0.06382103f, 0.03968082f, 0.14468373f, 0.05862355f, -0.19133382f, 0.02462651f, -0.29726988f, 
    -0.03338034f, -0.01348520f, -0.01750848f, -0.03365479f, -0.04537881f, -0.01500759f, -0.01765612f, -0.06315259f, 
    0.02583233f, 0.02666855f, -0.06890733f, 0.01441737f, -0.02863873f, 0.01833251f, 0.02636533f, -0.03787517f, 
    -0.04661962f, 0.01644854f, -0.01078463f, -0.02680670f, -0.04398998f, 0.01064625f, -0.04695414f, -0.06665912f, 
    -0.01736068f, -0.01498760f, -0.00308296f, -0.04793786f, -0.05927889f, 0.02507004f, 0.02292535f, 0.03625202f, 
    -0.06030701f, 0.03137638f, 0.00027472f, -0.06215414f, 0.02869398f, -0.03403780f, 0.03500191f, -0.03299718f, 
    -0.05699445f, -0.03375691f, -0.02854745f, -0.03831429f, -0.00234732f, 0.00751037f, -0.01826341f, -0.03636079f, 
    0.00536202f, -0.02845862f, -0.06520063f, 0.03507501f, -0.06207969f, -0.01159093f, -0.02718423f, -0.05056959f, 
    0.04246866f, -0.02148265f, -0.03681497f, -0.01680513f, 0.04467114f, 0.03063017f, -0.03678428f, -0.05279165f, 
    -0.06433436f, 0.00346113f, -0.05651799f, -0.04101445f, -0.03901584f, -0.04501975f, 0.01526456f, -0.03316457f, 
    -0.06102410f, -0.04747979f, 0.00694418f, -0.04666849f, -0.01286701f, -0.04252984f, -0.02985701f, -0.01234777f, 
    -0.00317675f, -0.00011550f, 0.03204578f, -0.01120777f, -0.02323211f, -0.03267005f, -0.02391187f, -0.02189169f, 
    0.00934625f, -0.00759882f, -0.02080073f, 0.03496112f, -0.03367307f, 0.03040864f, -0.04999103f, -0.00541356f, 
    0.03503849f, -0.06719823f, 0.03748299f, 0.04057281f, -0.04201683f, 0.00629828f, -0.05561984f, 0.01735115f, 
    -0.00249944f, -0.02993653f, 0.02877160f, -0.05851700f, -0.04500923f, -0.01636003f, -0.02228600f, 0.02521419f, 
    -0.00589370f, -0.05360804f, 0.00745832f, -0.03986399f, 0.01519797f, -0.03083204f, 0.02818421f, -0.02236931f, 
    -0.05416759f, 0.01959859f, -0.00014672f, -0.03399832f, 0.01589181f, -0.03067708f, -0.02744560f, 0.00039951f, 
    -0.01758378f, -0.01180801f, -0.04654988f, 0.00824681f, 0.02342988f, -0.05168829f, -0.02650817f, -0.00121827f, 
    -0.04750886f, -0.05653346f, -0.03681776f, 0.02951424f, 0.02908403f, -0.02021727f, 0.02581764f, -0.01480283f, 
    -0.05244613f, 0.01711043f, -0.01643164f, -0.03758604f, -0.03060259f, -0.05987448f, 0.00548595f, -0.05686399f, 
    -0.05503858f, -0.03799653f, 0.01232815f, -0.04797148f, 0.00215528f, -0.04913562f, 0.00423770f, 0.01551414f, 
    -0.05468328f, -0.05081904f, -0.04169792f, -0.01828125f, -0.05256884f, 0.01706472f, -0.06227762f, -0.02362257f, 
    -0.00581409f, -0.06541637f, 0.03356134f, -0.02515025f, -0.05314893f, 0.03783788f, -0.03918323f, -0.06300757f, 
    0.00529745f, -0.05843325f, 0.02603502f, -0.01795850f, 0.02004387f, 0.00368511f, -0.00252432f, 0.03836844f, 
    -0.04449145f, -0.03667501f, 0.00708778f, 0.00780734f, 0.00002024f, -0.01198508f, -0.03477901f, 0.01948933f, 
    0.00084707f, -0.06578905f, 0.01841761f, 0.00778004f, 0.01108067f, 0.02459018f, -0.01702470f, 0.00231945f, 
    -0.02249511f, 0.04174958f, -0.05927377f, 0.02766313f, -0.03019379f, -0.02280993f, -0.06512792f, -0.00839112f, 
    0.01959681f, 0.02601994f, -0.05644023f, -0.02312975f, -0.05128546f, -0.05389455f, 0.02571664f, -0.02569991f, 
    -0.05549502f, -0.02319139f, 0.01147676f, 0.04787589f, 0.01907544f, -0.00755646f, -0.05616535f, 0.02459764f, 
    -0.02462964f, 0.02960311f, -0.03128271f, -0.03865375f, -0.03656298f, 0.01409987f, -0.04134547f, 0.01123240f, 
    0.02300265f, 0.02795287f, -0.05752323f, -0.04536233f, 0.02679194f, 0.01354480f, -0.02028244f, -0.04669876f, 
    0.01657065f, -0.03216882f, -0.04794777f, 0.03501332f, 0.02980829f, -0.04811202f, 0.03896615f, 0.04268261f, 
    -0.02856723f, 0.01652530f, -0.06063099f, 0.03142782f, 0.01769349f, -0.04590939f, -0.06541742f, -0.05886512f, 
    -0.02905539f, -0.00652982f, -0.06584990f, -0.06444605f, -0.03993116f, -0.03516065f, 0.00171828f, -0.06404203f, 
    -0.03238925f, 0.01738231f, 0.05195215f, 0.04495546f, -0.05733747f, 0.00265987f, 0.03822154f, 0.04457846f, 
    -0.00513635f, -0.03926247f, -0.04634815f, -0.02042036f, -0.05196473f, 0.03612077f, 0.00986896f, 0.04890734f, 
    -0.01294103f, -0.02350514f, 0.00985262f, -0.05260199f, -0.06618732f, 0.03456318f, 0.00857847f, -0.00682000f, 
    -0.10364220f, 0.07130629f, -0.21454753f, 0.04073825f, 0.12253058f, 0.09950102f, 0.19874591f, 0.01753325f, 
    -0.12182742f, 0.06861982f, 0.18373367f, 0.27184758f, -0.00210778f, 0.05507405f, 0.02392295f, 0.01071148f, 
    0.18129891f, 0.07592737f, -0.22076832f, 0.00223763f, -0.24083836f, 0.17402931f, -0.04034970f, -0.04954134f, 
    -0.11944012f, -0.09856238f, -0.07982995f, 0.08282419f, -0.28231421f, 0.13275394f, -0.08176469f, 0.12117123f, 
    0.03776832f, 0.00897135f, -0.10760540f, -0.14841242f, -0.05352178f, -0.07622365f, 0.13842897f, 0.12789164f, 
    0.11882745f, 0.14127980f, 0.02768991f, -0.06428736f, -0.06800474f, 0.01771950f, 0.03517556f, 0.04067016f, 
    0.08878041f, -0.15362273f, 0.20383973f, 0.08832201f, 0.17671184f, -0.11351781f, 0.40324607f, 0.29757327f, 
    -0.00442559f, 0.03872691f, -0.01722330f, 0.25550562f, 0.09922884f, -0.08710040f, 0.15285951f, -0.47552696f, 
    -0.30428898f, 0.09687176f, 0.12464738f, 0.12785618f, 0.06559611f, -0.04998878f, -0.05827904f, -0.25569794f, 
    0.02310079f, -0.09315898f, 0.25205472f, 0.19575836f, -0.05540558f, 0.03665849f, 0.16872743f, 0.10007612f, 
    0.32746041f, 0.05685623f, 0.06158216f, -0.07844441f, -0.00931400f, -0.03718193f, -0.08344193f, 0.01647022f, 
    0.15790682f, 0.15406071f, -0.16736054f, 0.22578390f, 0.22198410f, 0.25430107f, 0.18561782f, -0.03747551f, 
    0.10058326f, 0.14550392f, 0.04806341f, -0.02807389f, -0.36795637f, -0.37432852f, 0.05033277f, 0.09456749f, 
    -0.13287459f, 0.17742088f, 0.08619279f, -0.25894475f, -0.25002697f, 0.13030323f, -0.44111833f, -0.01164888f, 
    0.19854705f, 0.00167968f, -0.17808327f, -0.11251365f, -0.17616755f, -0.25851092f, 0.26233506f, 0.31707084f, 
    0.02642750f, -0.09112212f, -0.05609702f, 0.03895748f, -0.07950968f, -0.06482534f, 0.04371381f, -0.08951622f, 
    0.04248170f, 0.00812695f, -0.04859051f, 0.07068968f, -0.02049487f, 0.21386495f, -0.03801674f, 0.08002804f, 
    0.03116983f, 0.01100028f, 0.05876921f, 0.03741553f, -0.08141255f, 0.13390091f, -0.01537343f, 0.11323602f, 
    -0.32143444f, 0.08508774f, -0.39261481f, -0.19431409f, 0.07446006f, 0.01992677f, -0.09422939f, 0.16891408f, 
    0.01195841f, 0.05040466f, -0.00575847f, -0.05948338f, -0.09153961f, -0.13124736f, 0.14619595f, -0.13464344f, 
    -0.03972912f, 0.09368309f, -0.34479815f, 0.13037495f, -0.50333047f, 0.03113152f, -0.06622650f, -0.17582594f, 
    -0.05673172f, -0.01056809f, -0.10249525f, -0.19838457f, 0.06043234f, 0.17300501f, -0.07260023f, -0.06750640f, 
    0.03971830f, 0.03871931f, 0.05212466f, 0.03624783f, -0.41491741f, 0.31869826f, 0.26348129f, 0.15035827f, 
    -0.02302248f, -0.24566825f, 0.20276907f, 0.10032739f, 0.08511610f, 0.17247841f, -0.16862392f, -0.36779216f, 
    -0.04871865f, 0.09811111f, 0.07403196f, -0.05260810f, 0.03065074f, -0.18186431f, 0.06298865f, -0.01561876f, 
    0.01627349f, 0.01767786f, 0.14880678f, 0.35942367f, -0.00693529f, -0.06177794f, -0.03276800f, 0.25546697f, 
    0.21275736f, 0.00314474f, -0.07362904f, -0.10828517f, 0.26421440f, -0.05176708f, 0.05403628f, 0.00521673f, 
    0.11887438f, 0.03336176f, 0.13778970f, 0.01587888f, -0.00512121f, 0.11155659f, -0.10878167f, 0.05117565f, 
    0.02382484f, -0.02282151f, -0.34322941f, -0.09651616f, -0.00032253f, 0.08499263f, -0.03878201f, 0.20192239f, 
    -0.01258662f, 0.09616238f, 0.13241154f, -0.31959113f, -0.11541305f, -0.03751915f, 0.01279058f, 0.12600435f, 
    0.04849353f, 0.12699731f, -0.09827907f, 0.02216734f, -0.16207395f, -0.07063987f, -0.05754963f, 0.24216856f, 
    -0.15141699f, 0.15017831f, 0.07963659f, -0.00964791f, -0.01591504f, 0.05212435f, -0.05246143f, -0.01247201f, 
    0.03755061f, 0.00452411f, 0.10999923f, -0.06068873f, -0.04053962f, 0.00003536f, -0.09177372f, 0.12055475f, 
    0.06340539f, 0.17825918f, -0.15333572f, -0.19618940f, -0.06826022f, 0.13741685f, -0.04280461f, -0.15749879f, 
    0.22403736f, -0.02098127f, -0.05556250f, -0.00325429f, -0.25033692f, 0.04761125f, 0.16728163f, -0.39024824f, 
    0.16731328f, 0.27121228f, 0.29038313f, 0.02893897f, 0.01697951f, -0.01291263f, -0.08025499f, 0.09287968f, 
    -0.01931505f, -0.04593896f, 0.28824463f, 0.14188690f, 0.19620875f, 0.00836234f, -0.05398049f, -0.13263401f, 
    0.10035741f, -0.27278832f, -0.05548173f, 0.11443295f, -0.09052534f, -0.09908850f, 0.16097437f, 0.13602997f, 
    0.11419751f, 0.03368973f, 0.07772396f, 0.06872562f, 0.14371130f, 0.04174063f, 0.07050458f, -0.02362580f, 
    0.04526189f, -0.08356884f, 0.05035461f, -0.08927819f, 0.31473905f, -0.02984113f, -0.14161840f, -0.19451916f, 
    -0.12157635f, 0.21029584f, 0.14761783f, 0.10478845f, 0.12232102f, 0.20489445f, -0.05210773f, 0.28138804f, 
    -0.07744351f, -0.11799702f, 0.17284629f, -0.01657190f, -0.10370624f, -0.31626710f, 0.04120195f, 0.15099648f, 
    0.20191194f, -0.03132037f, 0.07052138f, 0.26800078f, -0.05649615f, -0.03369213f, 0.09545009f, -0.02616334f, 
    -0.27634472f, -0.07241241f, 0.11588968f, -0.03851908f, -0.00892258f, -0.18791807f, 0.00649949f, -0.19586283f, 
    0.06588744f, -0.15616445f, -0.10942901f, -0.01994240f, -0.00557134f, 0.14198476f, 0.05051531f, 0.13420641f, 
    0.18868990f, -0.11699019f, -0.17673755f, -0.05978688f, 0.25622460f, -0.01925259f, 0.08393656f, 0.02945197f, 
    0.16384476f, -0.01567750f, 0.06819548f, 0.24643932f, 0.08171395f, 0.00957198f, 0.05469016f, 0.16971177f, 
    0.12446577f, 0.01098646f, -0.21562149f, 0.03892177f, 0.07142408f, -0.08244056f, -0.17501964f, 0.06861088f, 
    0.08269585f, 0.03590010f, 0.09046175f, 0.07721934f, 0.15216935f, 0.28748423f, 0.03733496f, 0.03330786f, 
    0.07399145f, -0.01801551f, 0.26041570f, 0.01627446f, 0.16757691f, -0.10159735f, 0.45030075f, -0.07826937f, 
    -0.00695655f, -0.08428116f, -0.20069490f, 0.05320175f, 0.15268543f, 0.10339714f, 0.01336777f, 0.25213575f, 
    0.40596181f, 0.16037412f, 0.03906117f, -0.05916660f, -0.16587813f, 0.04911776f, 0.08579252f, 0.08134738f, 
    -0.00929547f, -0.06691265f, -0.00013506f, 0.12267881f, -0.00967372f, 0.11008493f, 0.04526657f, -0.02114760f, 
    0.09961981f, 0.11271627f, -0.09858002f, 0.07818777f, -0.02823499f, 0.11700138f, 0.00786120f, 0.22919147f, 
    0.17608528f, -0.10539649f, 0.42820898f, 0.00817339f, -0.11018904f, 0.15543330f, -0.02541731f, 0.06712001f, 
    -0.04877179f, 0.15707840f, -0.01358347f, 0.03884462f, -0.09870100f, 0.20951279f, -0.05641054f, 0.06655720f, 
    -0.17546369f, -0.03628151f, 0.14955391f, -0.21372683f, 0.17061886f, 0.05474905f, 0.11170524f, 0.02564473f, 
    -0.00571974f, -0.03163609f, 0.14601658f, 0.02793813f, 0.07371354f, 0.08540516f, -0.01584239f, -0.10011388f, 
    0.09222634f, 0.10263211f, 0.06616747f, -0.01632797f, -0.23557976f, 0.06251813f, 0.12146867f, -0.03268268f, 
    0.06269208f, 0.15032092f, -0.09647978f, -0.06050165f, 0.20316175f, 0.12755890f, 0.01444501f, 0.11924774f, 
    -0.14943117f, 0.01984009f, 0.22297327f, 0.19505753f, -0.00946041f, 0.09192701f, 0.11621019f, -0.05152643f, 
    -0.16511101f, 0.02961905f, 0.17016277f, -0.12464835f, -0.22073193f, 0.16359961f, 0.02271855f, -0.70871305f, 
    0.14378640f, 0.08219478f, 0.05309036f, -0.10790285f, -0.07774580f, -0.18996815f, 0.14455748f, 0.05918621f, 
    -0.13349430f, -0.02560922f, 0.03993786f, 0.02958073f, 0.14650750f, 0.06682984f, -0.06509229f, -0.18977353f, 
    0.03323842f, 0.18658200f, 0.00239085f, -0.27750149f, -0.09347477f, 0.18066201f, 0.00169705f, 0.05641829f, 
    0.06842620f, -0.24715309f, 0.25689992f, -0.07073821f, 0.14136761f, -0.03729517f, -0.10106006f, -0.04265355f, 
    0.06056014f, -0.10050132f, 0.10680166f, 0.10624280f, 0.05701923f, -0.12439381f, 0.13231793f, 0.00467434f, 
    -0.19310349f, -0.27686316f, 0.05912842f, 0.08317041f, 0.04400735f, -0.03905614f, 0.19181378f, 0.05166250f, 
    0.09814052f, -0.06458502f, -0.00597792f, 0.14909051f, 0.17687854f, 0.11808326f, 0.00719859f, 0.19521987f, 
    0.15911818f, 0.13973151f, -0.01902723f, -0.13039717f, -0.03269239f, 0.00792340f, -0.47610027f, -0.02717185f, 
    -0.03058276f, -0.19535914f, -0.01157735f, 0.03538723f, 0.03904844f, -0.03813528f, 0.08234874f, -0.37897632f, 
    0.10602093f, -0.02935259f, -0.03075740f, 0.01406838f, 0.22701894f, -0.11070579f, 0.02235624f, 0.07143614f, 
    -0.12634438f, 0.28191814f, 0.01365404f, -0.03798538f, 0.08788545f, -0.12036539f, -0.27061117f, -0.09312069f, 
    0.11534628f, -0.20438559f, -0.18874100f, -0.25815693f, 0.12800895f, 0.15733936f, 0.01117626f, 0.02459948f, 
    -0.05957842f, -0.14888717f, 0.10086247f, 0.17651048f, -0.12433445f, -0.21450517f, -0.01889046f, -0.06691372f, 
    0.08988023f, 0.00209520f, 0.11289125f, 0.39314532f, 0.23666611f, 0.18373112f, 0.02086076f, -0.04564258f, 
    0.01174350f, -0.07730842f, 0.07800516f, 0.10256648f, 0.02153348f, 0.11017899f, 0.23636757f, 0.08326569f, 
    0.00428171f, -0.03777292f, 0.06471239f, -0.09249460f, -0.01318250f, -0.09164821f, 0.09513205f, -0.02638995f, 
    0.02002194f, -0.01379208f, 0.07924210f, -0.03237115f, 0.12473191f, -0.41420984f, 0.31785911f, -0.05965990f, 
    -0.24367219f, -0.08966094f, 0.27627823f, 0.09394646f, 0.04637096f, 0.04953595f, -0.22591336f, 0.79703271f, 
    0.13211636f, 0.01573198f, -0.11589935f, 0.13134682f, -0.07696681f, 0.01997877f, 0.16178799f, -0.07248054f, 
    -0.09193113f, -0.08159450f, 0.02017375f, 0.07638244f, 0.13350315f, 0.17066741f, 0.10274984f, -0.07035208f, 
    -0.21782504f, -0.23691568f, 0.08978936f, -0.11670163f, 0.07223832f, 0.18814790f, 0.12305437f, -0.04721671f, 
    0.07478854f, -0.37405479f, 0.23698415f, 0.13060147f, 0.17281175f, -0.13756591f, 0.07815754f, -0.02076459f, 
    0.06553296f, -0.03596266f, 0.06878527f, -0.27627501f, 0.20780201f, 0.09798105f, 0.14923063f, -0.17632268f, 
    0.15989184f, 0.00987823f, 0.10034333f, 0.27279699f, 0.14568475f, 0.13242465f, 0.05806027f, -0.04263060f, 
    -0.19688059f, -0.13633494f, -0.02241174f, -0.02633236f, 0.23964633f, 0.16394724f, 0.17803471f, 0.28969872f, 
    0.04288135f, -0.19405459f, 0.12156221f, -0.07610606f, 0.08856973f, 0.17942809f, 0.02098723f, -0.03383270f, 
    0.12062673f, 0.03303204f, -0.29828507f, -0.01202146f, -0.10247670f, -0.01942781f, 0.04046646f, 0.03416672f, 
    0.35184661f, -0.01150718f, 0.10587513f, -0.01989107f, 0.15420051f, 0.09824540f, -0.12657903f, -0.22204112f, 
    -0.01089233f, 0.01846276f, 0.20903926f, 0.06756252f, 0.11032742f, -0.22590105f, -0.12713954f, -0.08028071f, 
    0.15158339f, 0.03410465f, -0.07864136f, 0.07367214f, -0.04406476f, -0.03467919f, -0.14377713f, 0.24946231f, 
    0.05912026f, 0.04278548f, 0.09991216f, -0.01512404f, 0.06892822f, -0.03592061f, 0.14468475f, -0.05606183f, 
    -0.19518240f, -0.01771058f, 0.03752332f, -0.10133305f, -0.08247884f, 0.00740502f, 0.06936903f, 0.18246497f, 
    0.06486947f, 0.32488853f, 0.07298452f, 0.15451728f, 0.15390320f, 0.07528470f, 0.06528372f, -0.01336722f, 
    -0.09508601f, -0.08825555f, -0.07541304f, 0.11265346f, -0.25896308f, -0.04237178f, -0.06260762f, 0.02443784f, 
    0.09292978f, 0.03422654f, 0.14117867f, -0.08117452f, -0.07425458f, -0.06964520f, -0.15099660f, 0.21207519f, 
    0.04084872f, -0.14603224f, -0.04740396f, -0.03475926f, -0.06717908f, 0.03211962f, 0.00909893f, -0.10475764f, 
    -0.04193497f, -0.11897772f, 0.06772116f, 0.10179286f, -0.20947374f, -0.14513676f, 0.04004811f, 0.18305717f, 
    -0.18604146f, -0.10766282f, -0.13469355f, 0.02550079f, 0.03695812f, -0.18826804f, 0.04159455f, -0.02126353f, 
    0.07599173f, 0.00387415f, 0.05112932f, -0.12787890f, -0.01779312f, 0.00465341f, 0.16766413f, 0.03430228f, 
    -0.00926379f, -0.07996517f, -0.18274216f, 0.04447592f, 0.09000617f, 0.12636483f, -0.10105024f, 0.03760394f, 
    0.04346658f, 0.07040755f, -0.00352235f, -0.17878439f, 0.14402463f, 0.11028282f, -0.03086197f, 0.02948863f, 
    0.01002222f, -0.14464411f, -0.05164316f, 0.06646551f, 0.02837658f, 0.09583837f, -0.14584272f, -0.02182963f, 
    0.23712838f, -0.05429601f, -0.12189485f, 0.00099269f, -0.26282340f, -0.20172030f, 0.01311138f, 0.11388948f, 
    -0.10571336f, 0.02283967f, 0.15964423f, 0.11193518f, -0.08714903f, 0.12846847f, -0.14028952f, -0.01054569f, 
    -0.32548496f, -0.11790830f, 0.04870960f, 0.16350168f, 0.05562904f, -0.01630425f, -0.38726416f, 0.15798371f, 
    -0.02484343f, -0.12957628f, -0.15903148f, 0.01181372f, -0.14833938f, 0.03827812f, 0.09834408f, -0.18440506f, 
    0.00882106f, -0.01978040f, -0.03474313f, -0.03516172f, -0.00201166f, -0.05673779f, -0.05967741f, -0.02311421f, 
    0.03932852f, -0.04236075f, -0.00559887f, 0.03105107f, -0.00660430f, 0.04593275f, -0.04380631f, -0.02299375f, 
    0.03906844f, -0.05860832f, 0.04604286f, -0.04657715f, -0.01761721f, 0.04495489f, 0.03059837f, 0.02647721f, 
    -0.02235555f, -0.02256511f, -0.00169445f, 0.01191138f, -0.01612262f, 0.04224026f, 0.01074663f, -0.04609472f, 
    -0.03818333f, -0.02811470f, -0.02010863f, -0.03850809f, -0.02545665f, -0.04808702f, -0.00386442f, -0.04098383f, 
    0.00329619f, 0.06168864f, 0.03448076f, 0.02098111f, -0.03473756f, -0.06114678f, 0.02940455f, -0.04546379f, 
    -0.02752690f, -0.02768395f, -0.00219513f, -0.00959174f, -0.03159054f, -0.06049660f, 0.02573451f, 0.02661489f, 
    -0.05768045f, 0.03386091f, 0.00191714f, -0.01312859f, 0.04605535f, -0.04662211f, -0.04060666f, 0.03823174f, 
    -0.02665785f, 0.02182459f, 0.04531914f, -0.03505112f, -0.04234259f, -0.02298524f, 0.04660306f, 0.03031739f, 
    -0.00792417f, -0.00752090f, 0.00684351f, -0.01230089f, -0.00672147f, 0.02313657f, -0.05660874f, -0.05076652f, 
    -0.02030575f, 0.05241359f, 0.03625828f, 0.05538971f, 0.01336567f, 0.04556290f, 0.03444220f, 0.01808925f, 
    -0.02541040f, 0.03916631f, 0.02886492f, 0.01659526f, -0.01507786f, -0.02323564f, -0.03372029f, 0.00784173f, 
    -0.00124262f, -0.04179182f, -0.02904735f, -0.01843718f, -0.02420177f, -0.03349455f, -0.02062548f, 0.00409332f, 
    -0.05244969f, 0.00603425f, -0.01035574f, -0.00823156f, -0.03045818f, 0.02582997f, -0.00096535f, 0.04761851f, 
    0.04385056f, -0.03614028f, 0.02810363f, 0.04091270f, -0.02779251f, -0.04620639f, -0.01256496f, -0.00963620f, 
    -0.06457651f, -0.01212165f, -0.01924410f, -0.04565098f, 0.01664715f, 0.01103887f, -0.07057239f, 0.04258791f, 
    -0.05604003f, -0.01172614f, 0.01691832f, 0.05487790f, -0.03332408f, 0.01772298f, -0.05271408f, -0.01370209f, 
    -0.00467174f, -0.00243785f, 0.03633679f, 0.03777822f, -0.05228849f, -0.01106706f, 0.02010041f, -0.02174287f, 
    -0.03205779f, -0.05690654f, 0.02574675f, -0.03582166f, 0.00023891f, -0.06408815f, -0.01744456f, -0.05667779f, 
    -0.01051066f, 0.04166199f, 0.04184924f, -0.01488393f, -0.03998686f, 0.03452230f, 0.00829284f, 0.00317438f, 
    -0.02151498f, -0.05802489f, 0.03457439f, -0.04889190f, 0.00378851f, -0.04584152f, 0.03502501f, 0.03009080f, 
    -0.03594019f, 0.00399195f, -0.03254736f, -0.04300498f, -0.05388429f, 0.05935062f, -0.00315895f, 0.02777798f, 
    0.01262668f, -0.04461782f, -0.01896187f, 0.03001487f, -0.04983773f, 0.05042669f, -0.01513587f, 0.00195403f, 
    0.04766466f, -0.03377157f, -0.03014869f, 0.00523319f, 0.00690024f, 0.00254851f, 0.01838848f, 0.02318997f, 
    0.00088402f, 0.04774007f, 0.04505432f, 0.01124410f, -0.01802475f, -0.00181835f, -0.00338491f, -0.01616251f, 
    -0.05034775f, 0.05948382f, 0.00118305f, 0.02934329f, -0.02208947f, 0.04143117f, -0.03651754f, 0.02622869f, 
    -0.01380336f, -0.03963806f, -0.03862292f, -0.02822468f, -0.01950740f, -0.05096031f, -0.01945402f, 0.01818252f, 
    -0.05405162f, 0.01382617f, -0.01155383f, -0.01937810f, 0.01641787f, -0.04626901f, 0.01709783f, 0.02229941f, 
    0.00266582f, 0.04412592f, -0.01241580f, -0.02808261f, -0.06050818f, -0.01855766f, -0.01109858f, 0.02646358f, 
    -0.03525132f, -0.01107714f, 0.01905509f, -0.03050462f, 0.05427608f, -0.03853641f, -0.06404027f, -0.01880018f, 
    -0.05519216f, -0.03695128f, -0.03600646f, -0.00750235f, -0.02761510f, 0.03273197f, -0.01486504f, 0.03921737f, 
    -0.02215782f, 0.01155094f, -0.05655403f, -0.05414763f, 0.01935566f, -0.04545964f, -0.04674954f, 0.02348831f, 
    -0.03847146f, -0.02579201f, -0.05793624f, 0.03927490f, 0.01103371f, -0.05315300f, 0.00505709f, -0.02001528f, 
    -0.04502940f, -0.01390685f, 0.01681681f, 0.03046874f, -0.01118220f, -0.01119087f, -0.00662874f, 0.01752213f, 
    0.04007321f, 0.02537403f, -0.03270911f, 0.05251778f, -0.05812174f, 0.00030884f, 0.02821184f, 0.04224377f, 
    -0.01166122f, 0.03899292f, 0.03217109f, -0.01177165f, -0.03576408f, 0.01046985f, 0.02880907f, 0.02115626f, 
    -0.19260526f, 0.29683697f, 0.05885795f, 0.06422599f, 0.12108340f, 0.00272511f, 0.06674384f, -0.02066420f, 
    0.03543874f, 0.11741225f, 0.21722500f, 0.35027373f, 0.10393883f, 0.19498427f, -0.03644177f, -0.02443808f, 
    -0.03529393f, -0.08561155f, 0.11943048f, 0.09606141f, 0.01123511f, -0.04915475f, -0.05100570f, 0.02962298f, 
    -0.10347567f, -0.03836981f, -0.13311988f, -0.47741470f, -0.05757634f, -0.35497156f, 0.24796559f, -0.09874127f, 
    0.19384623f, 0.01421266f, 0.02532977f, 0.09975021f, -0.10992313f, -0.14555721f, -0.31537488f, -0.03264407f, 
    0.09739948f, -0.13529833f, 0.17324379f, 0.04624426f, 0.07944186f, 0.14854194f, 0.02702810f, -0.06025572f, 
    -0.11715724f, -0.09519111f, -0.05739585f, 0.05327905f, 0.06386626f, -0.07432118f, 0.17360368f, 0.07000843f, 
    -0.26253211f, -0.10262121f, 0.14522788f, 0.09066401f, -0.10646283f, 0.23046282f, 0.02963753f, -0.75340688f, 
    -0.30802953f, -0.55405259f, -0.05590611f, -0.13178000f, -0.09801015f, -0.01153294f, 0.02519079f, -0.07494085f, 
    -0.16623223f, -0.03787570f, -0.05939713f, -0.04686897f, 0.03079095f, -0.00043663f, 0.17011812f, -0.03752970f, 
    -0.21616964f, 0.10092967f, -0.06561951f, -0.10865430f, 0.02794267f, -0.09164736f, -0.06782202f, 0.07158763f, 
    0.13598773f, -0.03948802f, 0.17919835f, 0.08665177f, -0.35770047f, 0.06238754f, -0.09813842f, -0.02546615f, 
    0.16996795f, 0.01709127f, 0.20041040f, -0.08031954f, -0.21086739f, 0.35499069f, -0.05229774f, 0.03017989f, 
    0.07112570f, 0.04589485f, -0.03555729f, 0.13899407f, 0.22153629f, 0.18724683f, -0.01467289f, 0.09511103f, 
    -0.13413343f, 0.06383736f, 0.11835854f, -0.04377060f, 0.19094105f, 0.36175987f, -0.04849489f, 0.01922181f, 
    -0.07685086f, -0.04483708f, -0.01820566f, 0.02141443f, 0.02112040f, 0.15583427f, -0.31899881f, 0.12736592f, 
    0.05129841f, -0.06773120f, -0.00483675f, 0.10402842f, 0.01482138f, 0.09202079f, 0.02318431f, 0.00030979f, 
    0.00914779f, -0.10678296f, 0.04535925f, -0.05248907f, -0.13705848f, 0.02848669f, 0.17460363f, 0.02456706f, 
    -0.23100278f, -0.16991195f, 0.30050793f, 0.08547993f, 0.00720623f, -0.08949943f, -0.02348257f, -0.04047674f, 
    0.10177932f, -0.27460900f, 0.02850955f, -0.31524017f, 0.09762930f, -0.04870420f, 0.02328289f, -0.15584861f, 
    0.04559337f, 0.08930508f, -0.06501465f, 0.31496954f, 0.20721561f, -0.14275977f, -0.20742086f, -0.09622940f, 
    0.12582263f, -0.06301458f, -0.10934410f, -0.08531571f, -0.01254270f, 0.29878762f, 0.06194515f, 0.29110917f, 
    0.13904299f, -0.08522819f, 0.04164474f, -0.12547804f, 0.05633297f, 0.09674951f, -0.28697988f, 0.01756513f, 
    0.00187808f, 0.07556021f, 0.10018664f, -0.09962775f, 0.10189192f, 0.06612805f, -0.21816824f, 0.18018954f, 
    -0.00277936f, 0.07937232f, 0.07477289f, -0.07772849f, 0.00979997f, 0.05612176f, 0.03836970f, 0.07347690f, 
    -0.47999033f, 0.22374365f, 0.02344696f, -0.05872466f, 0.00651316f, 0.09909543f, -0.00670164f, 0.29020196f, 
    0.37415355f, -0.23235261f, -0.01408490f, -0.06385207f, -0.17763068f, 0.00860194f, -0.19716813f, -0.00334866f, 
    -0.25035310f, -0.09478459f, -0.31984934f, 0.10698591f, -0.00959045f, -0.03069862f, -0.03554096f, 0.03557917f, 
    -0.01072501f, -0.06038725f, 0.14803167f, -0.04334575f, 0.03706630f, -0.05534688f, -0.07147638f, -0.19595270f, 
    -0.02137231f, 0.07498325f, -0.01866504f, -0.06746134f, 0.28288150f, -0.12755050f, 0.00735174f, 0.14738224f, 
    -0.01829535f, 0.02921193f, 0.14549072f, -0.41899323f, 0.12724994f, -0.08080910f, 0.11633773f, -0.02534229f, 
    -0.02711392f, 0.05106541f, -0.13566884f, -0.04819446f, 0.02238807f, 0.12995185f, 0.05801514f, 0.13370638f, 
    -0.15562236f, 0.15607296f, -0.09222127f, -0.12287776f, -0.04924062f, -0.35548121f, -0.16889219f, -0.30452120f, 
    0.05977333f, 0.04858964f, 0.11870060f, -0.04092417f, -0.06524590f, 0.24259041f, 0.04720116f, 0.44744429f, 
    -0.14027499f, 0.00231379f, -0.18405667f, -0.06781767f, 0.05922429f, 0.02547381f, -0.03360778f, 0.00639178f, 
    0.32008621f, 0.08815835f, -0.19699536f, 0.08864052f, -0.05512793f, -0.17211238f, 0.01106087f, 0.01053014f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01395100f, 0.12881270f, 0.00081249f, 0.02003176f, 0.13661587f, -0.01806033f, -0.04553756f, 0.09172707f, 
    -0.04594475f, 0.19121844f, -0.01386989f, -0.05636358f, 0.10522108f, -0.04520950f, 0.02794551f, 0.00121721f, 
    -0.05402742f, -0.05037433f, -0.11925171f, 0.07701221f, 0.09532375f, -0.01324020f, -0.05004057f, 0.11753526f, 
    -0.11032511f, 0.02389855f, 0.01531648f, 0.09202021f, 0.00509184f, -0.07453251f, 0.01927357f, 0.05149673f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07174754f, 0.28039268f, -0.09998853f, -0.12739024f, -0.33529705f, -0.03440276f, 0.12250923f, 0.10008059f, 
    -0.09479199f, 0.21521799f, -0.02838172f, -0.07517009f, -0.00896895f, -0.01637491f, -0.11851115f, 0.05495030f, 
    -0.21266203f, -0.39396223f, 0.05041464f, -0.49905586f, 0.62042534f, -0.06350251f, 0.08821236f, -0.27208325f, 
    -0.35781509f, 0.26405394f, -0.09570764f, 0.27141741f, -0.12140869f, 0.11687749f, -0.15321937f, 0.61324912f, 
    0.12502488f, 0.24143328f, -0.17268333f, 0.03632299f, -0.48014110f, 0.00252669f, 0.15327986f, -0.20052314f, 
    -0.11557726f, 0.19243164f, -0.14216638f, -0.07443243f, 0.31435308f, -0.06254623f, 0.00527951f, -0.14132449f, 
    0.48391870f, -0.30159727f, 0.50140142f, 0.08541531f, 0.26078844f, 0.14532007f, 0.02069386f, -0.18670329f, 
    -0.50983816f, -0.01524812f, -0.03120568f, 0.26124197f, 0.12741013f, -0.04834595f, 0.00969429f, 0.52852941f, 
    -0.12919173f, 0.28379747f, 0.16989727f, 0.08839665f, 0.42284241f, -0.09549846f, -0.05516983f, -0.04957986f, 
    -0.15430607f, 0.40237591f, -0.49679893f, -0.11408972f, -0.04426101f, -0.16697346f, 0.16406870f, -0.16489199f, 
    -0.17783132f, -0.10078898f, -0.35004812f, 0.08349265f, 0.17580065f, 0.07760739f, 0.09388851f, 0.43783280f, 
    -0.13659491f, -0.17260508f, -0.03021551f, -0.02328329f, 0.11701265f, -0.05545397f, -0.11242146f, -0.59669864f, 
    0.13349019f, -0.14956075f, 0.07427429f, 0.11456451f, -0.13794711f, -0.15630572f, 0.14178520f, -0.14650381f, 
    -0.15448141f, -0.02054056f, -0.15642944f, 0.14473332f, -0.15423022f, -0.03495569f, 0.01160334f, -0.14882939f, 
    0.04468177f, -0.06833738f, 0.01679621f, -0.13624774f, -0.00780037f, 0.07537696f, -0.02236579f, -0.06655261f, 
    -0.15243101f, -0.16134231f, -0.02785399f, -0.05690562f, -0.05651342f, 0.10310899f, 0.16711920f, -0.14007641f, 
    -0.16128296f, -0.13446851f, 0.10856470f, -0.11429405f, -0.19917545f, 0.15644385f, -0.14558472f, -0.02210822f, 
    0.16442224f, 0.05792947f, -0.03382538f, 0.14066316f, -0.17691444f, -0.07367638f, 0.06995939f, 0.00336888f, 
    -0.04825328f, -0.00997986f, 0.03566346f, 0.14819799f, 0.08115792f, 0.09190523f, -0.13024084f, -0.09285530f, 
    -0.10059205f, -0.20247827f, -0.14494120f, -0.16064723f, -0.10288806f, 0.01876074f, -0.03033519f, -0.13557318f, 
    -0.07716400f, -0.13505080f, -0.16289181f, -0.09843124f, 0.13915804f, 0.01495566f, 0.06653360f, -0.10225122f, 
    -0.14657989f, 0.01651368f, -0.06859187f, -0.10227181f, -0.14888443f, 0.13167711f, 0.15661417f, 0.12423687f, 
    0.10668696f, -0.13951510f, -0.02348074f, 0.05315545f, -0.15038663f, 0.03135612f, -0.13690464f, 0.04869954f, 
    0.09185493f, -0.15929011f, -0.09549852f, 0.09928063f, -0.18407996f, -0.21710600f, 0.10456239f, -0.00157057f, 
    -0.11506724f, 0.25426653f, 0.05009944f, -0.10812178f, 0.39505014f, 0.15662208f, -0.08781508f, 0.13996816f, 
    0.08405613f, 0.29742688f, 0.24268642f, 0.14208488f, -0.05992007f, 0.15761694f, -0.04681704f, -0.07716196f, 
    -0.32137743f, -0.19355358f, -0.03675380f, -0.67486560f, 0.02529338f, 0.11029135f, 0.13183719f, 0.34470397f, 
    0.10618547f, 0.03073773f, 0.09448073f, 0.35826135f, -0.26506424f, -0.05817531f, -0.13963613f, -0.04279217f, 
    -0.07596511f, -0.02335850f, -0.01848902f, -0.03349470f, -0.30876246f, 0.06726702f, -0.07882021f, -0.05893293f, 
    -0.04852531f, -0.04277808f, 0.49346951f, -0.14951456f, 0.33221227f, 0.05745652f, -0.02635383f, -0.05655789f, 
    -0.70081592f, 0.19365375f, -0.43073338f, 0.25949508f, 0.17927393f, 0.00242229f, -0.06693423f, -0.02483968f, 
    0.36871189f, 0.57460481f, -0.11023761f, 0.01871870f, 0.33047491f, 0.02971351f, -0.00979059f, -0.04118325f, 
    0.14438292f, 0.29964289f, -0.03444470f, -0.00703253f, 0.30475235f, -0.11487686f, -0.01354609f, 0.14119470f, 
    0.05092526f, 0.20218311f, -0.33094344f, -0.08919770f, -0.44514671f, -0.03862497f, 0.08389203f, -0.03970143f, 
    0.69625497f, -0.27478459f, 0.16309080f, 0.09476919f, 0.06076942f, 0.05103223f, -0.05498929f, -0.06641059f, 
    0.15504856f, -0.37698790f, -0.07948480f, -0.21628565f, 0.10000161f, 0.32441476f, -0.11718298f, -0.42572314f, 
    -0.08297010f, -0.11309028f, -0.03714680f, 0.07675342f, 0.00516347f, 0.12003698f, -0.10187637f, -0.18338393f, 
    -0.00031283f, -0.15441494f, 0.14016485f, 0.17388971f, -0.05569438f, 0.05539179f, -0.02437763f, 0.08556428f, 
    -0.09599403f, -0.12854533f, 0.12273114f, 0.07088450f, -0.14442870f, -0.14653194f, -0.01901065f, -0.16819377f, 
    -0.01890353f, -0.06370825f, -0.10688605f, -0.06165788f, -0.02025101f, 0.00110406f, 0.02439773f, -0.03623888f, 
    -0.02868687f, -0.15733507f, -0.01839622f, 0.04423550f, -0.05140323f, -0.04590974f, -0.04175231f, 0.00865628f, 
    -0.10911085f, -0.26837945f, -0.06983980f, 0.10727299f, -0.24440323f, -0.04852259f, -0.11255468f, 0.03867108f, 
    0.36006066f, 0.08883318f, 0.35049167f, -0.44324335f, 0.25124833f, 0.10161845f, -0.14895807f, 0.13806139f, 
    -0.31375906f, 0.06513143f, -0.02190932f, -0.02345436f, 0.32989240f, 0.00607983f, -0.16432734f, 0.15562701f, 
    -0.04137050f, 0.01255413f, 0.11862422f, -0.08347613f, 0.04616916f, -0.06475640f, 0.08385410f, -0.00548335f, 
    -0.15041237f, -0.02311004f, 0.12246444f, -0.12125709f, -0.09298436f, 0.08845125f, -0.02896997f, 0.06148445f, 
    -0.02197749f, -0.03389547f, -0.14032502f, 0.00575825f, -0.11395179f, 0.01852512f, -0.02126013f, 0.07766179f, 
    -0.02689134f, -0.16802348f, -0.06327808f, -0.00921574f, 0.02892606f, -0.17870958f, -0.02904598f, -0.10944219f, 
    0.04037445f, 0.35862643f, -0.15613727f, -0.15026864f, 0.21258773f, -0.00500922f, 0.04938719f, -0.02516236f, 
    0.00273234f, -0.18118225f, -0.31183013f, -0.00123536f, 0.49015540f, 0.17251569f, -0.13736293f, -0.10092050f, 
    0.02415240f, -0.38811448f, 0.13319543f, 0.51853549f, 0.08006069f, 0.15390351f, 0.04729313f, -0.08608958f, 
    0.05664140f, 0.22330980f, 0.12978303f, 0.07968056f, 0.22249052f, -0.06763041f, -0.14168245f, -0.85475403f, 
    -0.11967095f, 0.00225453f, 0.04664836f, -0.09149398f, 0.21280219f, -0.04793974f, 0.04492407f, -0.01193089f, 
    0.11841176f, 0.35951051f, -0.03823699f, -0.10019100f, -0.08126939f, 0.14633405f, -0.05907726f, -0.03130635f, 
    0.10009926f, 0.35806248f, 0.19726744f, -0.37137717f, -0.00953605f, -0.04896126f, -0.10978208f, -0.06846302f, 
    -0.12871890f, -0.34745270f, 0.12326482f, -0.00921470f, -0.18105976f, 0.14607421f, 0.13419831f, 0.71063501f, 
    -0.08207089f, 0.21955705f, -0.00969026f, -0.00243061f, 0.34285280f, -0.00247679f, 0.02476317f, 0.17900853f, 
    0.16628395f, 0.15675415f, -0.03882871f, -0.02406956f, -0.05693712f, -0.00486765f, -0.14547038f, -0.03212472f, 
    0.05772656f, 0.04593004f, -0.68186986f, 0.26244578f, 0.79338109f, -0.04114542f, -0.16848020f, -0.29281813f, 
    -0.44491655f, -0.48768091f, 0.03518086f, 0.08577475f, 0.23399661f, 0.26617754f, 0.15769833f, -0.07779509f, 
    -0.05205741f, -0.35311264f, 0.08562961f, 0.02186732f, 0.05818686f, 0.07745774f, 0.14631324f, 0.15752530f, 
    -0.05422906f, 0.14262919f, 0.47282410f, 0.05166707f, 0.08178513f, -0.11102549f, -0.03993823f, -0.00806560f, 
    -0.25586364f, 0.25477317f, -0.02790256f, -0.22795749f, -0.18588494f, 0.06680690f, 0.16918741f, 0.46101010f, 
    0.08106905f, 0.09766521f, -0.12067884f, 0.37972653f, -0.02312257f, -0.06080467f, 0.06465705f, 0.77423352f, 
    0.01536288f, -0.32621545f, -0.17791419f, 0.16513504f, 0.38109097f, -0.12538213f, 0.13179840f, 0.22377241f, 
    -0.06338959f, -0.18053886f, -0.09857555f, -0.04467784f, 0.10484917f, -0.06476629f, 0.07258537f, 0.15407428f, 
    0.10633935f, 0.35195151f, -0.63540691f, 0.71061891f, 0.05623065f, -0.11217697f, 0.07416090f, 0.16772419f, 
    -0.13102722f, -0.23603183f, 0.12644583f, 0.00545633f, 0.39713323f, 0.31963840f, 0.09115160f, -0.02012391f, 
    -0.09799601f, 0.52309680f, -0.13940699f, 0.15989377f, 0.53212571f, 0.17177838f, -0.10637319f, 0.35568532f, 
    -0.09530441f, 0.26765788f, 0.00723076f, 0.02806238f, 0.22319591f, 0.17056209f, -0.00750433f, 0.04809660f, 
    0.10173296f, 0.26152271f, -0.17087738f, -0.40415686f, -0.15314090f, 0.11408198f, -0.10098566f, -0.40630338f, 
    0.64174169f, -0.15129928f, -0.05053011f, 0.10051969f, -0.32377779f, 0.00445941f, 0.06704973f, -0.29976934f, 
    -0.08655836f, 0.13409899f, 0.07670908f, -0.06463003f, 0.55282366f, 0.08390769f, 0.10998568f, 0.33812258f, 
    0.08030129f, -0.09797188f, -0.43130404f, 0.13898617f, 0.26124072f, -0.09103549f, -0.05379291f, 0.14513995f, 
    0.18066104f, -0.02839069f, 0.18243724f, -0.08362404f, -0.15009718f, -0.11941156f, 0.10694640f, 0.24874297f, 
    -0.20845357f, -0.18047100f, 0.14364898f, 0.63622558f, -0.00005614f, -0.48059845f, 0.04966083f, -0.38741192f, 
    0.08617342f, -0.12867734f, 0.01141255f, 0.14759761f, -0.21609999f, -0.06411590f, -0.14874971f, -0.23878421f, 
    -0.05606608f, -0.15935221f, 0.23434095f, 0.10620818f, -0.33571774f, 0.10864859f, 0.09280262f, 0.08507060f, 
    0.63052922f, -0.39131853f, 0.55257386f, 0.39310423f, 0.06907661f, -0.02678478f, -0.04180316f, 0.52257019f, 
    0.07192205f, 0.08146851f, 0.09445952f, -0.08021507f, 0.25380501f, 0.26377466f, 0.13175319f, 0.45525503f, 
    0.06204857f, -0.16249482f, 0.16886604f, 0.13562092f, -0.02870373f, -0.04462873f, 0.01859632f, 0.16190831f, 
    -0.07362254f, -0.16274548f, -0.13247094f, 0.07050312f, -0.13198765f, 0.00303346f, -0.15464132f, 0.09355794f, 
    0.03481887f, 0.10115338f, 0.03651837f, -0.07604927f, -0.13346432f, 0.10176405f, 0.15764742f, 0.00811161f, 
    0.00521184f, 0.08087689f, -0.07213513f, -0.08675314f, -0.11352858f, -0.17895196f, -0.15144561f, 0.05084713f, 
    -0.02857246f, 0.24085219f, 0.12310012f, -0.08574910f, -0.34060854f, 0.10108358f, 0.07428355f, 0.18689793f, 
    -0.04622142f, -0.16262084f, -0.18822540f, -0.01366942f, 0.46149635f, -0.08787181f, 0.17348313f, 0.13558803f, 
    -0.32587412f, -0.25401583f, 0.02454828f, 0.24983302f, 0.21805418f, -0.16637294f, -0.15435290f, -0.08827803f, 
    0.22937624f, 0.21017796f, 0.11461082f, 0.54938465f, 0.18847261f, -0.24832152f, 0.03798971f, 0.48213995f, 
    -0.03622868f, -0.03738632f, -0.02195068f, -0.15213837f, -0.22322141f, 0.08533081f, -0.08446112f, 0.30864719f, 
    -0.08643802f, 0.06774387f, 0.07336067f, 0.02138052f, 0.64148527f, 0.09326965f, 0.06302901f, 0.04142510f, 
    -0.02430393f, 0.31114742f, 0.13537388f, 0.35002339f, 0.20840783f, 0.05471262f, 0.17107181f, -0.57999659f, 
    0.37896574f, 0.01250922f, -0.11050688f, 0.27057189f, -0.08356378f, -0.14761180f, 0.06623755f, 0.68375826f, 
    0.06084003f, 0.00369299f, 0.09890926f, -0.03049553f, 0.07476047f, -0.08013532f, -0.07349753f, -0.13905218f, 
    0.00985819f, -0.17868188f, -0.03660892f, -0.01978301f, -0.13097164f, -0.11753656f, 0.09029871f, -0.07851972f, 
    -0.00253457f, -0.03293446f, 0.01763910f, -0.15086579f, -0.00468825f, 0.00212389f, -0.15396173f, -0.16954240f, 
    0.12418813f, 0.01602004f, 0.06585582f, -0.02641462f, -0.14357179f, -0.15025847f, 0.11565727f, 0.09418589f, 
    -0.11135541f, -0.24787204f, -0.12993886f, -0.16124520f, 0.51369381f, 0.07852183f, -0.03414809f, 0.04589107f, 
    0.00582050f, 0.10597510f, 0.47187233f, 0.02638681f, 0.16541240f, 0.16149311f, -0.16460238f, -0.15842779f, 
    0.11841508f, 0.44061989f, -0.08535186f, -0.26913208f, -0.79107946f, 0.17612809f, 0.00151960f, 0.77275944f, 
    0.51292688f, 0.49955985f, -0.06933392f, -0.14633401f, 0.12122876f, -0.18865767f, -0.17759745f, -0.18984982f, 
    0.16965888f, -0.07720806f, -0.05037040f, -0.04813728f, -0.17776553f, 0.02727715f, -0.00398981f, -0.09422471f, 
    -0.11732418f, -0.01879352f, -0.05620297f, -0.17480063f, -0.14897585f, -0.01975256f, -0.10094851f, 0.00152019f, 
    -0.05261195f, 0.02266131f, -0.12285200f, 0.01087077f, 0.04099022f, 0.15043955f, 0.15489973f, -0.02150900f, 
    -0.07565730f, -0.13437845f, 0.01231834f, -0.07431631f, -0.05637555f, 0.15622249f, 0.09169241f, -0.03333853f, 
    0.13002270f, -0.06428722f, 0.07122009f, -0.05582465f, 0.34130102f, -0.08575489f, 0.12031805f, -0.15943329f, 
    -0.13418709f, 0.30237505f, 0.11672352f, -0.04159722f, -0.20946082f, -0.17031725f, -0.00573980f, -0.13473164f, 
    0.13781436f, 0.23981205f, 0.35211673f, -0.68553007f, -0.00732901f, 0.12523849f, -0.10357670f, 0.23306610f, 
    -0.21724987f, 0.30527979f, 0.06995454f, -0.26458174f, 0.02226359f, 0.11748959f, 0.02392670f, 0.08922144f, 
    0.09997157f, 0.12681049f, 0.16787155f, 0.07235661f, 0.15957452f, 0.05301717f, -0.04194547f, -0.20510623f, 
    -0.11570282f, 0.22154064f, 0.01217700f, -0.12835787f, -0.19563060f, 0.10215591f, -0.15863757f, -0.13211419f, 
    -0.19311786f, -0.22459848f, 0.02918523f, -0.49947438f, -0.00627828f, -0.11713711f, 0.03863857f, 0.60245085f, 
    -0.45202750f, 0.25774905f, -0.08412641f, -0.21611305f, 0.38732585f, 0.23833515f, -0.03917270f, -0.48674476f, 
    -0.17292820f, 0.24002960f, 0.13878813f, -0.06441475f, -0.07563718f, -0.06753016f, 0.15753309f, -0.27493286f, 
    -0.09609022f, 0.19092649f, 0.46887931f, -0.03054184f, 0.36761761f, -0.10257405f, -0.01829848f, -0.00677656f, 
    0.42851865f, 0.23079756f, 0.45483541f, -0.39485893f, -0.47011274f, 0.01259818f, -0.08519020f, 0.18991378f, 
    -0.27170524f, 0.47618186f, -0.15623872f, -0.36322969f, 0.02017571f, -0.21443382f, 0.10210295f, 0.03199150f, 
    0.10566044f, 0.16072257f, -0.00257724f, -0.00627759f, -0.41166693f, -0.07888373f, 0.03203314f, -0.18203843f, 
    0.10348137f, -0.18656322f, -0.44659200f, 0.11255575f, 0.58942181f, 0.00554494f, -0.05961658f, -0.05636985f, 
    0.47311550f, -0.01686738f, 0.60791868f, 0.80985391f, -0.13055177f, 0.04272171f, -0.14601701f, -0.11933863f, 
    0.05283307f, 0.28108996f, -0.14004093f, -0.14804918f, 0.28277588f, -0.07681526f, -0.02009615f, -0.27969158f, 
    0.19647132f, -0.34676495f, -0.14676200f, 0.05340030f, -0.12080879f, -0.02599493f, -0.13354343f, 0.12411334f, 
    0.15038644f, 0.08755787f, 0.31679446f, -0.20075800f, -0.28726599f, 0.09538045f, -0.17423260f, 0.07645848f, 
    0.00366300f, 0.40531820f, -0.09535436f, 0.44814774f, 0.19838440f, -0.14889686f, 0.05984351f, -0.05093011f, 
    0.11218738f, -0.19235317f, 0.06147306f, -0.26015809f, 0.37757692f, 0.59813011f, -0.00788267f, -0.00888169f, 
    0.14010918f, 0.06717540f, -0.12646677f, -0.10078732f, 0.25793123f, 0.03166981f, 0.12281718f, -0.20651653f, 
    -0.13195643f, 0.35685065f, -0.09595429f, -0.13586901f, -0.38372043f, -0.08987758f, 0.08356384f, 0.05530562f, 
    0.16747998f, 0.31263605f, 0.24117483f, 0.27939901f, 0.17635924f, -0.04152333f, 0.03050907f, -0.32303572f, 
    -0.12009583f, -0.20867723f, -0.01230425f, -0.46477354f, 0.09058376f, 0.22841366f, 0.08547334f, -0.08806573f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06994419f, 0.15465774f, 0.40410584f, 0.05425302f, -0.07752068f, -0.05341309f, 0.04831153f, 0.29249859f, 
    0.06809989f, -0.16718248f, 0.10061253f, -0.14870042f, -0.07600682f, -0.05032651f, 0.11330196f, 0.02552078f, 
    0.15055043f, -0.05574660f, -0.04303611f, 0.06983362f, 0.16959512f, 0.05120235f, 0.14780954f, -0.03108228f, 
    0.01208247f, 0.01168078f, 0.14609499f, 0.10991824f, 0.00706465f, 0.13947624f, -0.16380011f, 0.00505269f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.49940774f, -0.03219272f, 0.09896876f, 0.08580294f, -0.08341988f, -0.08711769f, -0.59395796f, 0.17040312f, 
    0.27137867f, -0.06379306f, -0.25771466f, -0.11100688f, 0.18348029f, -0.32802394f, 0.12489332f, -0.36102566f, 
    0.46378714f, -0.31687313f, -0.45438090f, 0.37751645f, 0.13363262f, 0.03113927f, 0.05457191f, -0.14068292f, 
    -0.25178879f, -0.00578346f, -0.62701494f, -0.28008083f, -0.62334037f, 0.35358810f, 0.49856400f, 0.27583060f, 
    -0.23032467f, 0.09631413f, -0.13098839f, -0.10064954f, 0.01540505f, 0.10412215f, -0.36232170f, 0.29124185f, 
    -0.67201906f, 0.13540037f, 0.29461873f, 0.12646574f, 0.32931426f, -0.43209371f, -0.02358756f, 0.14573027f, 
    0.39850914f, -0.23197663f, 0.30607912f, -0.29877031f, -0.04935145f, 0.31074697f, 0.30110919f, -0.09592366f, 
    -0.05516287f, 0.00089343f, -0.31276467f, -0.25772554f, 0.09384243f, 0.36839229f, -0.14327753f, -0.71807259f, 
    -0.42466226f, -0.97013980f, -0.25705063f, -0.08425509f, -0.05798849f, -0.02697438f, -0.05714999f, 0.42837089f, 
    -0.06334472f, 0.08665227f, -0.23325887f, -0.13532118f, -0.30123764f, -0.01987619f, -0.24363244f, 0.18671769f, 
    0.07744882f, 0.50067586f, -0.71178889f, -0.70927036f, 0.08014464f, 0.05843983f, 0.18137284f, -0.05846029f, 
    0.54347581f, -0.08454010f, 0.02038813f, -0.58172876f, -0.35925543f, -0.43729109f, 0.55398762f, -0.05610542f, 
    -0.76301432f, -0.11936075f, 0.11018833f, 0.00673692f, -0.13166563f, -0.18092205f, -0.26965633f, -0.50927627f, 
    0.24398677f, 0.00978132f, 0.16064715f, 0.01512092f, -0.35769850f, 0.16180052f, -0.02006572f, 0.16159846f, 
    0.64218354f, -0.30543855f, 0.11613911f, 0.30707687f, 0.04162699f, -0.72743779f, -0.45983502f, 0.01451602f, 
    0.29256168f, 0.11664898f, 0.17217685f, 0.08660646f, 0.01795266f, -0.16619179f, 0.34995720f, 0.03977153f, 
    0.40022478f, 0.10429199f, 0.25563565f, 0.17649317f, -0.06562854f, -0.06596129f, -0.11367954f, 0.24281399f, 
    0.02544469f, -0.12584977f, 0.06555583f, 0.12151162f, 0.08186235f, -0.08461597f, 0.38751331f, -0.42756718f, 
    0.03591808f, -0.18767123f, -0.75179476f, -0.24830395f, -0.12976535f, -0.22170255f, -0.21361567f, 0.06089116f, 
    -0.41592091f, -0.13351682f, 0.20990421f, 0.38090321f, 0.01465806f, -0.24787895f, 0.16664989f, 0.36671969f, 
    0.12975012f, 0.15903294f, 0.20139845f, 0.00507062f, -0.07154837f, 0.09727863f, 0.01742320f, -0.13161424f, 
    0.33431742f, -0.01451537f, -0.32730755f, -0.11283512f, 0.50630009f, -0.43398076f, -0.08479534f, -0.66203809f, 
    -0.40129250f, 0.23939976f, 0.39306682f, 0.20374718f, -0.10697788f, 0.28283313f, -0.03606528f, 0.14936253f, 
    -0.38816109f, -0.02316860f, -0.54305935f, -0.19044864f, -0.36524543f, 0.24607417f, -0.46409005f, -0.48091766f, 
    -0.20287964f, -0.44905722f, 0.21633221f, 0.11735541f, -0.06827865f, 0.09816607f, 0.24731915f, -0.21433611f, 
    0.22694352f, 0.01908621f, -0.58219463f, -0.11571236f, 0.21712914f, -0.06450249f, 0.40452322f, -0.15020417f, 
    0.38018477f, 0.33430603f, 0.48736763f, -0.78878802f, -0.10563309f, -0.17448542f, -0.13984327f, -0.05777411f, 
    -0.04071926f, 0.12897293f, -0.04934762f, 0.00602651f, -0.68084216f, -0.77548277f, -0.00461187f, -0.09888607f, 
    -0.05305685f, 0.25620452f, -0.63372940f, 0.02855141f, -0.14114092f, 0.07601344f, -0.59292877f, -0.26393172f, 
    0.19708860f, -0.03343718f, 0.42686796f, 0.12745053f, 0.14514452f, -0.35177660f, -0.61273295f, -0.18512580f, 
    -0.25790349f, -0.93580681f, -0.23873523f, 0.52100027f, -0.17604659f, -0.27889565f, -0.33871284f, -0.02297551f, 
    -0.10843173f, 0.11255736f, 0.33471090f, 0.23006162f, 0.11699304f, 0.35413104f, 0.27417690f, 0.07551944f, 
    0.41344219f, 0.16314937f, -0.85427278f, -0.02755228f, -0.15332083f, -0.01800954f, 0.16456926f, 0.14721237f, 
    -0.52699769f, 0.07989547f, -0.35039321f, 0.15024887f, -0.37144694f, 0.09249683f, -0.33752289f, 0.41346756f, 
    -0.60958552f, 0.12940493f, -0.67279482f, 0.29801190f, -0.10898380f, 0.24882752f, 0.26206991f, -0.18140310f, 
    0.07140980f, 0.00163912f, -0.03016146f, -0.55189914f, 0.33134994f, -0.39514893f, -0.34120819f, -0.78120923f, 
    0.48317045f, 0.30777270f, -0.00846322f, 0.14751206f, -0.20127816f, -0.15233164f, 0.11013153f, -0.20108794f, 
    -0.07954053f, -0.14587770f, 0.58977765f, -0.13182826f, -0.54629511f, 0.42166451f, 0.21363987f, 0.35229632f, 
    -0.20844978f, -0.14981219f, 0.06374495f, 0.05158149f, -0.04379367f, 0.22836833f, 0.17468916f, 0.06257687f, 
    -1.04517436f, -0.09833731f, -0.06629130f, -0.22176431f, -0.76740402f, -0.52482957f, 0.00860587f, -0.11068555f, 
    -0.41090852f, -0.35881501f, 0.35884693f, 0.01691646f, -0.15480165f, 0.07581936f, 0.41997930f, 0.19968973f, 
    -0.26699963f, 0.07856803f, -0.34039572f, 0.11278480f, 0.00829444f, -0.19020404f, -0.58621711f, 0.35429484f, 
    -0.38042951f, -0.19936408f, 0.25569370f, 0.06489800f, 0.04970562f, -0.10009304f, -0.48458159f, -0.14262915f, 
    0.54716951f, -0.11626458f, 0.25254562f, 0.44026577f, 0.24249578f, -0.38055766f, -0.36339545f, -0.47318676f, 
    -0.23921116f, 0.09567371f, 0.07307493f, -0.02652166f, -0.00849099f, -0.04199504f, 0.01438554f, -0.44498658f, 
    0.20072275f, 0.09029595f, -0.85362875f, -0.03623403f, 0.01811129f, 0.43029737f, -0.32729465f, -0.30228186f, 
    -0.63394129f, 0.38403979f, 0.10475083f, -0.31200841f, 0.05612412f, -0.47308785f, 0.10106275f, -0.00986982f, 
    0.09144966f, 0.14050052f, 0.32053497f, -0.12528129f, 0.62800598f, 0.18724442f, -0.37972528f, 0.51048803f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08376742f, -0.08026078f, 0.00145597f, 0.11678519f, 0.09134463f, -0.06252238f, -0.04045321f, -0.09163355f, 
    0.03331755f, 0.19112900f, 0.12507559f, -0.00218511f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
