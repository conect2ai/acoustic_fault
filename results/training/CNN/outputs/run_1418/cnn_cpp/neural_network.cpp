#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.76676995f, 0.92706817f, 0.31855589f, -0.53397375f, -0.14251161f, -0.46144536f, -0.15021937f, 0.29030806f, 
    -0.13274896f, -0.65471417f, -0.02300135f, 0.17816071f, 0.60799152f, -0.25282624f, 0.54561305f, -0.34932208f, 
    -0.38950083f, -0.33637035f, 0.01757495f, 0.06071910f, 0.15710668f, -0.39555153f, -0.23221333f, -0.41035861f, 
    0.53283209f, -0.11936694f, -0.19164819f, 0.85067737f, -0.66800034f, 0.65757596f, -0.02614883f, 0.30154639f, 
    0.02921106f, 0.11205011f, 0.26241195f, 0.27713388f, -0.33246991f, -0.94714594f, 0.22857432f, -0.09436244f, 
    0.35232389f, -0.45166093f, 0.33627799f, -0.15615688f, -0.59360886f, 0.21006626f, -0.04906555f, 0.30785650f, 
    -0.14869954f, -0.69521177f, 0.86766630f, 0.32895070f, -0.33742017f, -0.15428279f, -0.56590688f, -0.26146287f, 
    -0.07262472f, 0.20892988f, -0.38825479f, -0.58652020f, -0.25272194f, -0.19216461f, -0.21659438f, -0.23668861f, 
    0.70461255f, -0.70717728f, -0.53378642f, -0.35373414f, -0.22409034f, 0.24906704f, 0.17523786f, 0.35056758f, 
    0.82378608f, -0.77483833f, -0.53448308f, 0.43314782f, 0.08462434f, 0.61844528f, -0.20508499f, -0.09593778f, 
    -0.35033229f, 0.40132937f, 0.59593207f, -0.28502503f, -0.07523671f, -0.35139215f, -0.10916083f, -0.39862126f, 
    -0.42328635f, -0.28655732f, 0.14557813f, 0.38491958f, 0.11815907f, 0.19053189f, -0.06722803f, -0.32408443f, 
    0.56464309f, -0.08594389f, 0.51034230f, 0.27097723f, -0.30153129f, 0.69889688f, 0.03627278f, 0.10924017f, 
    0.31079265f, 0.25058836f, -0.04708195f, 0.01063166f, -0.01593397f, 0.18381763f, 0.05198237f, 0.70668262f, 
    0.25288442f, 0.86644095f, -0.11701162f, 0.45631853f, -0.31668204f, 0.03417049f, 0.21386322f, -0.33731377f, 
    -0.16734277f, 0.12856905f, -0.41200525f, -0.42981246f, -0.12377892f, 0.47564635f, 0.04179516f, -0.71281153f, 
    -0.91885430f, 0.42535990f, 0.16525282f, 0.23595349f, 0.30560824f, -0.04459293f, 0.10090854f, -0.44184503f, 
    -0.11281696f, 0.14207172f, 0.07555690f, -0.81199104f, -0.77115816f, 0.16571580f, 0.13606814f, 0.28307360f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07008306f, -0.29208022f, 0.21175277f, 0.14375991f, 0.09949994f, -0.00176724f, -0.43990210f, 0.00116909f, 
    -0.15560375f, -0.01593355f, 0.12590057f, 0.09159479f, -0.08432346f, 0.27010971f, 0.27836609f, -0.12254220f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.33656436f, -0.37180296f, -0.19142824f, -0.09701082f, 0.14880799f, -0.00064276f, -0.09673243f, 0.00236445f, 
    -0.08567572f, -0.18637162f, -0.03987847f, -0.08772121f, -0.01056098f, -0.18663307f, -0.10146762f, -0.10293898f, 
    0.06890941f, -0.05407382f, -0.10666858f, -0.26848319f, -0.24454334f, -0.00579055f, 0.19984363f, -0.09855542f, 
    0.10821662f, 0.05387301f, 0.08558673f, 0.34598616f, 0.16593093f, -0.27520722f, -0.07574026f, -0.09431660f, 
    0.26023757f, 0.14631332f, -0.08595452f, -0.09013208f, 0.08762626f, -0.26607281f, -0.20968680f, -0.01692656f, 
    0.18381770f, -0.03437725f, 0.04202638f, 0.02712460f, 0.21820474f, 0.15713584f, 0.01353746f, -0.00758963f, 
    0.00878744f, 0.26402625f, 0.04129355f, -0.05105806f, 0.12669782f, 0.17957501f, 0.13522288f, -0.07556722f, 
    -0.00141367f, -0.44790542f, -0.11282618f, -0.39824069f, 0.03269985f, 0.08722852f, 0.12684214f, -0.25003096f, 
    -0.31785399f, -0.56612617f, 0.15724517f, -0.01446057f, 0.07329430f, 0.11461344f, -0.19197173f, 0.00842340f, 
    -0.20617896f, 0.34658718f, 0.01404810f, -0.08339091f, -0.04455166f, 0.09557647f, 0.04698447f, -0.11202750f, 
    -0.02148114f, -0.20363446f, -0.16787849f, 0.34240592f, -0.03720082f, 0.09680849f, -0.06474696f, 0.04424681f, 
    -0.01449976f, 0.13283005f, 0.22613753f, -0.04511511f, 0.03711233f, 0.02798619f, -0.04205730f, 0.11797198f, 
    -0.03274637f, -0.05123428f, -0.07312702f, 0.25063065f, 0.07630137f, 0.01090367f, -0.05135819f, -0.08844534f, 
    0.02747335f, 0.11766376f, -0.01676466f, -0.10922578f, -0.14644296f, -0.10573781f, -0.04538162f, 0.06390425f, 
    -0.00803583f, -0.01283812f, -0.03226444f, 0.05652906f, 0.20632945f, -0.01263789f, -0.17899618f, 0.01327901f, 
    0.15751815f, -0.07035135f, -0.01982740f, -0.00170853f, 0.06336729f, 0.03188779f, -0.24181043f, 0.36912054f, 
    0.42297852f, 0.08996919f, 0.31024206f, 0.18195960f, 0.10356238f, 0.07843194f, 0.21106176f, -0.32740885f, 
    -0.48292089f, -0.28227484f, 0.08507822f, -0.04665195f, -0.29602104f, 0.02010875f, -0.05038107f, -0.06307128f, 
    -0.16338508f, 0.19031596f, 0.11207501f, 0.01595338f, -0.00032354f, -0.00720704f, -0.01981315f, 0.05019492f, 
    -0.12048119f, 0.26506802f, -0.14821942f, -0.18068814f, -0.29727596f, -0.20897442f, -0.05358246f, 0.11013315f, 
    0.31282398f, 0.27316982f, 0.12826438f, 0.12983420f, 0.12794104f, 0.13642663f, 0.18504165f, -0.05994576f, 
    -0.06681931f, 0.15142182f, 0.00111729f, 0.07343904f, 0.11406622f, 0.12163085f, -0.15748003f, -0.08827965f, 
    0.04400031f, 0.08455094f, 0.15232681f, -0.09378968f, 0.20847805f, 0.10693928f, -0.08690067f, -0.01578996f, 
    0.13568820f, 0.10465340f, -0.08377604f, -0.01447901f, 0.14732797f, 0.18091856f, -0.03893320f, 0.00599186f, 
    -0.25490829f, 0.17017783f, -0.05494729f, 0.22883999f, 0.05103809f, -0.14750157f, 0.35765967f, 0.18649900f, 
    0.15541270f, -0.09521440f, -0.04922548f, -0.08762374f, 0.07857085f, -0.00592010f, 0.12050208f, 0.02080247f, 
    0.23502651f, 0.04738612f, 0.12745288f, -0.06676349f, -0.14239646f, -0.23666558f, 0.14426802f, -0.08163295f, 
    -0.33484456f, 0.06830429f, 0.21435812f, -0.12506716f, 0.08264808f, 0.16844890f, 0.10116275f, 0.23940976f, 
    -0.00433798f, -0.08315338f, 0.02838016f, 0.33547419f, -0.04080410f, -0.11894266f, 0.13344897f, 0.09158579f, 
    0.04705879f, -0.09394589f, -0.11360518f, 0.23147458f, -0.14509931f, 0.18826486f, 0.10252386f, -0.21124640f, 
    -0.04500474f, 0.20139749f, -0.42205390f, 0.13961039f, 0.15178055f, 0.12466847f, -0.15771882f, 0.17103386f, 
    -0.18817709f, 0.18329675f, -0.00162626f, -0.03000739f, 0.19288127f, -0.09462335f, 0.01201149f, -0.12163658f, 
    0.02904089f, -0.00964514f, -0.11598069f, -0.29470921f, -0.16267778f, 0.19161724f, 0.19903365f, 0.00703858f, 
    0.17230342f, -0.14076683f, 0.10293011f, 0.08960386f, 0.01061376f, 0.09093865f, -0.03894573f, -0.18848065f, 
    0.27336013f, 0.07742421f, 0.11661809f, -0.16157861f, -0.19938463f, 0.05023493f, -0.01487216f, 0.29838786f, 
    0.03531497f, 0.12731487f, 0.19339347f, 0.01463905f, -0.24439022f, 0.15003647f, -0.14921349f, -0.24627174f, 
    -0.14453384f, -0.00292187f, -0.02872827f, 0.05611884f, 0.05299037f, 0.04605218f, 0.13688238f, -0.07439281f, 
    -0.11307729f, -0.02218037f, 0.20633624f, 0.21554810f, 0.26122871f, -0.10368387f, 0.15322715f, -0.20501465f, 
    -0.12844534f, -0.41229171f, -0.04087175f, 0.29618713f, 0.01342043f, 0.03977260f, 0.06153521f, 0.04822787f, 
    0.01790669f, 0.09281953f, -0.01412739f, -0.11596792f, 0.00858959f, -0.08422127f, 0.11304829f, 0.23449260f, 
    0.01214495f, 0.13208334f, 0.01145334f, 0.24064834f, 0.00838714f, 0.16881989f, 0.12311550f, 0.06794592f, 
    0.03464583f, 0.03340575f, -0.22297853f, 0.20661509f, -0.17336138f, -0.18694270f, -0.03284063f, -0.03474611f, 
    0.00345304f, 0.23944585f, -0.02003176f, -0.14732048f, 0.02381238f, 0.08777492f, -0.27390125f, -0.36853918f, 
    0.00346456f, 0.06560717f, 0.10696682f, -0.09373437f, 0.14867353f, -0.01435992f, -0.16973184f, -0.00692650f, 
    0.06402098f, 0.16598713f, 0.01306494f, -0.18145557f, 0.07638355f, 0.11236846f, 0.16692677f, 0.11925649f, 
    0.12194458f, -0.01205899f, -0.04294986f, -0.01866921f, 0.03687738f, 0.01135160f, -0.32890815f, -0.06807615f, 
    -0.04155380f, -0.01638511f, -0.09542363f, -0.01535060f, 0.10354570f, 0.15796255f, 0.08834530f, -0.18874697f, 
    -0.08495098f, -0.15583035f, -0.11541551f, 0.08324673f, -0.12302180f, 0.19834934f, 0.02510587f, -0.07969359f, 
    0.16753776f, 0.25391227f, 0.32461202f, 0.04737513f, -0.00756397f, -0.03649145f, 0.14462963f, 0.24735914f, 
    0.18473060f, -0.04257387f, 0.12845008f, -0.19692732f, -0.29702228f, -0.06393502f, -0.09679456f, 0.12176117f, 
    0.15949741f, -0.06730124f, 0.05336454f, 0.10583541f, -0.19772881f, 0.20367658f, 0.00156731f, 0.10517232f, 
    -0.07828038f, 0.09007064f, 0.06659921f, 0.17737950f, 0.10528927f, 0.17088224f, -0.05211893f, 0.12396390f, 
    0.07168371f, -0.07700095f, 0.11074642f, -0.02433972f, -0.08923319f, 0.09039851f, -0.04665708f, -0.13030304f, 
    -0.09621657f, -0.11904304f, -0.03454854f, 0.07834866f, 0.13048750f, 0.20707698f, 0.11313547f, 0.06184452f, 
    0.01333687f, -0.04619364f, 0.04217439f, -0.10079904f, 0.03595580f, 0.11358267f, 0.03639239f, -0.03475318f, 
    -0.05760439f, -0.04272240f, 0.18683898f, 0.33688924f, -0.33401805f, -0.06754515f, -0.11699374f, -0.04487241f, 
    -0.04740315f, 0.21360755f, 0.11634061f, -0.19905400f, -0.09401789f, -0.17711292f, 0.04011371f, -0.02434780f, 
    0.15968095f, 0.12794982f, -0.05848401f, -0.08873743f, -0.06037606f, -0.10320650f, 0.04207110f, -0.00103354f, 
    0.12067211f, 0.13622284f, 0.02814073f, -0.08945214f, -0.23349887f, 0.07606499f, 0.11986388f, 0.17243508f, 
    -0.01292812f, 0.11398998f, 0.20447657f, -0.01196342f, 0.12949097f, -0.23204970f, -0.09672122f, -0.20248070f, 
    0.01091764f, -0.04052062f, -0.04326252f, 0.18046904f, 0.05055983f, -0.04238598f, 0.07062550f, 0.04474992f, 
    -0.34805298f, -0.20342132f, 0.33845934f, 0.21270870f, 0.03453116f, -0.04115421f, 0.20380621f, -0.08860199f, 
    0.38132820f, 0.01861522f, -0.08884791f, -0.09518143f, 0.04334090f, -0.21916759f, -0.10678683f, -0.32246342f, 
    -0.25736034f, -0.01745523f, -0.13805683f, 0.00428090f, -0.12429415f, -0.02508323f, -0.15607007f, -0.07131476f, 
    0.21671425f, -0.03230340f, -0.04987357f, 0.02755063f, 0.16897073f, -0.10669790f, 0.08341000f, 0.16122121f, 
    0.16356064f, 0.16557609f, 0.08558032f, 0.05729715f, 0.02337631f, 0.19963138f, -0.00046023f, 0.11814526f, 
    0.07579709f, -0.16231675f, -0.23291072f, 0.10685712f, -0.02875050f, -0.06549340f, 0.14926518f, 0.18667753f, 
    0.11649033f, 0.16684963f, 0.12204645f, 0.00476338f, 0.39793658f, 0.18435839f, 0.03871832f, -0.05841260f, 
    -0.07485354f, -0.04849758f, -0.00078221f, 0.00891550f, -0.01236919f, -0.07226513f, 0.04692620f, -0.17143962f, 
    -0.04809522f, -0.10120395f, -0.07930045f, -0.06262281f, -0.29950681f, 0.03727685f, 0.23921590f, 0.20930122f, 
    0.31556171f, -0.05714210f, -0.04811276f, -0.13009501f, -0.04604804f, -0.04533656f, 0.06131181f, -0.02673435f, 
    0.17256008f, -0.14745139f, 0.02375280f, -0.06803817f, -0.38326296f, -0.15218344f, -0.23237717f, -0.13010186f, 
    0.24426614f, 0.34772849f, -0.05668905f, -0.04627696f, -0.13243678f, -0.14924853f, -0.01780001f, 0.00598839f, 
    0.24561320f, -0.02602914f, -0.10452262f, 0.00785970f, -0.01915832f, -0.04070861f, 0.01249217f, 0.21529521f, 
    0.08181476f, 0.07970281f, 0.02436936f, 0.11363721f, -0.08551764f, 0.13889411f, 0.12893549f, -0.04587926f, 
    0.12585960f, 0.01897263f, 0.11336964f, 0.18782316f, 0.07245247f, 0.03311810f, 0.06872106f, -0.19559965f, 
    -0.05398338f, 0.01972705f, -0.01761433f, -0.29569304f, -0.03647455f, -0.07583133f, -0.15853932f, 0.09781525f, 
    -0.02410966f, 0.03438673f, 0.22928604f, -0.00339579f, 0.22279051f, 0.33166656f, 0.27060756f, -0.18190616f, 
    -0.06966414f, 0.06197768f, 0.00637116f, -0.09874023f, 0.14275891f, 0.10538419f, -0.06030582f, -0.17995080f, 
    0.00584077f, 0.06413066f, -0.05724244f, 0.02176890f, -0.20296247f, 0.09853665f, 0.29027313f, -0.04397723f, 
    -0.06314236f, -0.04203634f, 0.11893906f, 0.12816913f, -0.10477102f, -0.01446315f, -0.11208928f, -0.05025631f, 
    -0.39703155f, 0.09214923f, 0.15012307f, 0.14550373f, 0.18064241f, 0.12128469f, -0.09139968f, 0.23670998f, 
    0.22966315f, 0.20693688f, 0.22409561f, 0.25562093f, 0.22006732f, 0.02090375f, 0.07782257f, 0.04587048f, 
    0.07362317f, 0.07936100f, 0.06827023f, 0.25329390f, -0.10264543f, -0.11280368f, -0.07172772f, 0.04072820f, 
    -0.13133137f, -0.17804202f, -0.22470643f, 0.27430847f, 0.08408879f, 0.05650754f, 0.17816201f, -0.02873206f, 
    -0.00901318f, -0.01032441f, -0.13143061f, 0.02507927f, -0.29201657f, -0.22546953f, -0.04887315f, 0.13193440f, 
    0.05022004f, 0.16838664f, -0.15188645f, -0.19662333f, -0.04711340f, 0.06816368f, 0.12086332f, 0.06728093f, 
    0.13125868f, 0.06570225f, -0.07537915f, -0.03310971f, -0.07508732f, -0.13624071f, -0.09645575f, -0.10672755f, 
    -0.05823030f, -0.01219557f, 0.18384357f, 0.04563653f, -0.02467279f, -0.08522721f, -0.03098224f, 0.12328223f, 
    -0.19855569f, -0.24235937f, 0.48730180f, 0.03419152f, 0.10991836f, -0.05772047f, 0.01097678f, -0.06243246f, 
    0.20571844f, -0.09869707f, 0.23508276f, 0.08919777f, 0.01191663f, -0.16204275f, -0.10441029f, -0.08735141f, 
    0.08129748f, -0.05018690f, 0.07364236f, -0.16883224f, 0.07930926f, -0.13074471f, 0.07150787f, -0.06949227f, 
    -0.08525909f, -0.26019135f, 0.04112196f, 0.02714474f, -0.11620039f, 0.03546892f, -0.06988285f, 0.04651289f, 
    0.12143069f, 0.22153941f, 0.18389598f, 0.44308597f, 0.24939947f, -0.02673418f, 0.01112723f, -0.03634960f, 
    -0.05929704f, -0.15487072f, 0.13356663f, 0.04501623f, -0.12168630f, 0.22758450f, -0.07038462f, 0.16152051f, 
    0.13368411f, -0.04061225f, 0.00677625f, -0.01933798f, 0.17844087f, 0.09392063f, -0.00797449f, 0.11886978f, 
    -0.02811859f, 0.06172101f, 0.16686091f, 0.11557744f, 0.00379313f, -0.06982024f, -0.06975297f, -0.34417713f, 
    0.12673163f, 0.06257933f, 0.05471166f, 0.00000599f, 0.03864159f, 0.01744881f, 0.00338367f, 0.05922320f, 
    -0.09426471f, -0.22070356f, 0.12018006f, -0.09791107f, 0.03328496f, -0.03080661f, 0.19379745f, -0.18717158f, 
    -0.10089198f, -0.03409532f, -0.01966120f, 0.06447998f, -0.04565256f, -0.03352613f, -0.02928057f, -0.20600675f, 
    -0.06744367f, -0.07664097f, -0.06852783f, -0.16838367f, 0.02028104f, -0.13813126f, 0.03934775f, -0.07963628f, 
    0.01512158f, -0.08925525f, 0.06521103f, -0.01999152f, 0.09193585f, 0.05311707f, -0.15402731f, -0.02229849f, 
    0.13120942f, 0.09494124f, 0.00848785f, 0.22275135f, 0.20165193f, 0.17472966f, -0.13840099f, 0.04024178f, 
    -0.19400075f, 0.04707070f, -0.04908840f, 0.05734932f, -0.17852367f, -0.26882413f, 0.05955849f, 0.09770643f, 
    0.14060369f, -0.15955500f, -0.06806511f, -0.01662984f, 0.10503248f, 0.06830614f, -0.05312973f, 0.15495804f, 
    0.19356038f, -0.07691597f, 0.02312716f, 0.15880407f, 0.12972762f, 0.20140810f, -0.25512120f, 0.02496376f, 
    0.24324842f, -0.10355353f, 0.10991334f, 0.03032481f, -0.12294864f, 0.06754230f, -0.05752482f, -0.28347051f, 
    -0.19239464f, -0.30706206f, 0.03603447f, 0.06931008f, -0.22764526f, 0.19175397f, 0.07505672f, 0.03871362f, 
    -0.14536680f, -0.25570187f, -0.02286942f, 0.06114019f, -0.10622643f, -0.05169576f, -0.15208662f, 0.05987956f, 
    0.25375319f, -0.79023904f, -0.20384866f, -0.10558730f, -0.08743022f, -0.09574685f, -0.11621769f, -0.01528280f, 
    -0.14750934f, -0.11188149f, 0.07636330f, 0.15198292f, -0.00253538f, 0.09362762f, -0.03093959f, 0.16796459f, 
    0.02224047f, 0.14749286f, 0.09095822f, 0.08177312f, -0.16584583f, -0.09174258f, -0.21239895f, 0.06825162f, 
    -0.22420977f, -0.06213590f, 0.16340257f, 0.08048414f, 0.18550071f, 0.02606199f, 0.09409919f, -0.08415902f, 
    0.02852522f, 0.08843044f, 0.14726691f, 0.09688914f, -0.13673529f, -0.19240674f, 0.01900107f, -0.00900603f, 
    -0.08257742f, 0.06739955f, 0.08895727f, -0.09824605f, 0.12734792f, -0.07735274f, -0.26190084f, -0.15411839f, 
    0.14628635f, -0.29448044f, 0.12834865f, -0.06938349f, 0.07030787f, -0.10466305f, -0.31940752f, 0.13698986f, 
    -0.02272254f, 0.10548630f, 0.05138186f, 0.05000932f, -0.03140336f, -0.03258848f, -0.03022880f, -0.14096159f, 
    0.50878596f, 0.18196301f, -0.30901605f, 0.10511163f, -0.05699456f, -0.10461900f, 0.04773471f, -0.04849679f, 
    0.02800214f, 0.18960495f, 0.07121274f, 0.01194963f, 0.19702157f, 0.09373445f, -0.00393863f, 0.06329723f, 
    -0.11910047f, -0.22629292f, -0.13256742f, -0.06802159f, -0.01877615f, -0.00065025f, -0.06542607f, 0.09382193f, 
    -0.07134303f, 0.26035464f, 0.16169153f, -0.02246359f, -0.02686973f, -0.01256698f, -0.07113470f, 0.03929592f, 
    -0.03348162f, -0.07219075f, 0.06421737f, 0.07737648f, -0.38004729f, -0.24849004f, -0.04965179f, -0.03123532f, 
    -0.02770975f, -0.20041779f, -0.17983991f, -0.09868795f, -0.04479591f, 0.17624959f, -0.04439923f, 0.06711958f, 
    -0.20687704f, 0.07727256f, 0.16672355f, 0.13690309f, 0.08733488f, 0.07132497f, -0.04421204f, -0.00286363f, 
    -0.23202194f, -0.20388219f, -0.14041072f, 0.25027269f, 0.16052054f, 0.14749031f, 0.09064816f, -0.39765400f, 
    -0.13800213f, 0.23282896f, -0.07654043f, 0.09638602f, -0.03849622f, -0.04956507f, 0.09444185f, -0.13295874f, 
    0.06934977f, -0.04694982f, 0.00096272f, 0.02474565f, -0.01462354f, 0.03698257f, -0.00792146f, -0.04989992f, 
    -0.05297651f, -0.08779502f, -0.02649122f, 0.04103803f, -0.04941930f, 0.01878329f, 0.06603696f, -0.01809655f, 
    -0.08668466f, 0.05683083f, -0.03036784f, 0.05890495f, 0.04956586f, -0.03020184f, 0.01419076f, -0.08264269f, 
    -0.02766268f, -0.01912352f, -0.01147933f, 0.07486817f, 0.04948540f, -0.05484950f, 0.05340720f, -0.05141033f, 
    -0.00221254f, -0.09025913f, -0.05015390f, -0.09411936f, 0.03719414f, 0.03922657f, 0.05606942f, 0.06210746f, 
    -0.03430141f, 0.06816956f, 0.06903060f, -0.08588322f, 0.06551608f, -0.00423127f, -0.07397960f, -0.04417412f, 
    0.06990455f, -0.03562890f, 0.03021172f, 0.00980265f, 0.05880385f, -0.07887633f, -0.00941486f, -0.06799585f, 
    -0.02734062f, -0.07434601f, 0.01433133f, -0.06614263f, -0.05840801f, 0.02482743f, -0.02546102f, -0.03498282f, 
    0.02187374f, -0.00625083f, 0.05306922f, 0.00308881f, -0.06831247f, -0.00002686f, -0.04301523f, 0.00448450f, 
    -0.01704296f, 0.02914541f, -0.02061160f, -0.03536049f, -0.02598924f, 0.02436503f, -0.07959858f, 0.04179109f, 
    0.05425950f, 0.03575296f, -0.07735720f, -0.05350613f, -0.04097250f, 0.02241507f, -0.02012338f, -0.03198810f, 
    -0.09232719f, -0.09458417f, -0.07108402f, -0.00534330f, -0.07432634f, 0.01363428f, 0.01922337f, 0.01614551f, 
    -0.07516008f, -0.10099985f, -0.08835346f, -0.02915622f, -0.02903637f, -0.06843530f, -0.06162954f, -0.01914006f, 
    0.04048040f, 0.03501675f, 0.03182905f, 0.02254260f, -0.01642684f, 0.04215821f, -0.01018162f, 0.02244761f, 
    -0.04450848f, 0.04518278f, 0.04745665f, -0.04971315f, 0.04805757f, -0.06948075f, 0.00501869f, 0.02357009f, 
    -0.08946060f, -0.01800612f, -0.03159378f, -0.01269497f, 0.01241015f, 0.01152597f, 0.04165512f, -0.04307722f, 
    0.05799455f, 0.03000193f, 0.01989464f, -0.09538314f, -0.06752442f, -0.01244767f, 0.02874139f, -0.01079891f, 
    -0.00675376f, -0.00212312f, -0.06489610f, 0.03975579f, 0.07673113f, -0.06532507f, -0.04515781f, 0.00626847f, 
    0.16123317f, -0.05038306f, 0.01114069f, 0.12149655f, -0.10781495f, 0.06087588f, -0.03828818f, 0.03606740f, 
    0.19777350f, -0.12733334f, -0.12942140f, -0.29395548f, -0.20896378f, -0.13121672f, 0.05675361f, 0.09737021f, 
    -0.26550424f, 0.12698790f, -0.07704988f, 0.11747318f, 0.29354632f, 0.00487656f, 0.27207947f, -0.09613752f, 
    0.01284055f, 0.08938733f, 0.04962000f, 0.12237563f, 0.02386016f, -0.01224239f, 0.06547498f, -0.12736562f, 
    0.01524260f, 0.19104414f, 0.04068519f, -0.11339252f, 0.25848362f, -0.18075439f, -0.33591536f, -0.06997862f, 
    0.01231376f, 0.24932645f, 0.00965329f, -0.00680909f, -0.09534046f, 0.03347679f, 0.19230375f, 0.07322603f, 
    -0.05635943f, 0.08040664f, -0.23322001f, 0.00740376f, -0.07976892f, 0.10126150f, -0.05404789f, 0.12165469f, 
    -0.43085262f, -0.30730489f, -0.13252348f, -0.01618529f, 0.17171788f, 0.00486625f, 0.05692992f, -0.17190988f, 
    -0.56012148f, -0.26642507f, -0.00186068f, 0.10136719f, 0.02293805f, 0.06675334f, 0.05973395f, -0.02760570f, 
    -0.46242151f, -0.27830356f, -0.13989170f, -0.04256617f, 0.17514430f, -0.20813446f, -0.05663015f, -0.09681673f, 
    -0.04311339f, -0.02028390f, 0.02154487f, -0.02414471f, -0.08108107f, 0.09424209f, 0.04316220f, 0.06885448f, 
    -0.13311768f, 0.19614357f, 0.21663485f, 0.16409311f, -0.09585316f, 0.05725565f, -0.07723586f, -0.04110308f, 
    0.12716945f, 0.09203188f, 0.12374936f, 0.14610432f, 0.16383511f, -0.18548524f, 0.02669038f, -0.12609392f, 
    0.00628153f, 0.00554500f, 0.00475835f, 0.00266597f, 0.30382529f, 0.42465553f, 0.05977848f, -0.21550827f, 
    -0.13608329f, 0.02735137f, 0.02324111f, -0.07540838f, -0.01891750f, -0.27445990f, 0.30033457f, -0.10032072f, 
    0.28485689f, 0.12708879f, 0.19632262f, 0.12859097f, -0.01170474f, 0.07324792f, -0.42144763f, -0.61882430f, 
    -0.46618184f, 0.08072395f, 0.28531289f, 0.02597404f, -0.08640766f, -0.03993415f, -0.02687979f, -0.22740445f, 
    0.61935979f, -0.11432690f, 0.04519928f, -0.30830339f, -0.03196895f, 0.11707448f, -0.03126911f, -0.09463348f, 
    -0.75535131f, -0.22586699f, 0.13893428f, -0.09425913f, -0.06962135f, 0.06682523f, 0.02558048f, 0.10437329f, 
    0.09218676f, 0.17475913f, 0.31893998f, 0.06462937f, -0.03200873f, 0.08139686f, -0.10837147f, 0.14649859f, 
    0.11381866f, -0.14354637f, 0.06620514f, 0.08878727f, 0.06548385f, -0.09613980f, 0.15466627f, -0.05784195f, 
    -0.05210962f, 0.06658534f, 0.07837431f, -0.22327767f, -0.08926167f, 0.00014852f, -0.10874087f, 0.08650192f, 
    0.17128415f, -0.00933596f, 0.00772121f, 0.09490807f, 0.38639286f, -0.10629905f, -0.07279232f, 0.01754541f, 
    -0.06974163f, 0.12194312f, -0.06144550f, 0.07459245f, -0.04243586f, -0.32823265f, 0.04356806f, 0.01798829f, 
    0.27119914f, -0.01172762f, -0.09330945f, 0.10168243f, 0.04248852f, 0.13888863f, 0.63465273f, 0.18720469f, 
    -0.03167054f, -0.13772331f, 0.13534477f, -0.04157792f, -0.10957754f, -0.12149920f, -0.09696889f, -0.07300399f, 
    0.02723398f, 0.19350755f, -0.00501740f, -0.05408128f, 0.00892866f, 0.02848158f, -0.02178639f, 0.12231135f, 
    0.54913855f, 0.16960077f, -0.04804432f, -0.07360915f, 0.07966919f, 0.08440381f, 0.18377189f, -0.09299076f, 
    0.02572634f, -0.09540716f, 0.14864334f, 0.17085786f, -0.03648166f, 0.01567567f, -0.02872821f, 0.09464345f, 
    0.08373908f, -0.11234540f, -0.21888679f, -0.07589035f, 0.29970625f, -0.13980499f, -0.02818593f, 0.13028036f, 
    -0.01535191f, 0.12082958f, 0.12122867f, -0.21286663f, -0.19628911f, 0.21007535f, -0.01968881f, 0.31508133f, 
    -0.11479961f, -0.15165658f, 0.06246547f, -0.03884805f, -0.40442121f, -0.05031819f, 0.05750711f, 0.05898897f, 
    -0.07688353f, -0.18163376f, -0.14416239f, -0.00593213f, 0.01848425f, 0.01749725f, -0.06488045f, 0.10542561f, 
    0.03391596f, 0.14308479f, 0.05328730f, 0.19990870f, -0.00318512f, -0.18308681f, 0.17021455f, -0.08639152f, 
    -0.20011492f, -0.03948575f, 0.19422548f, -0.03207278f, -0.03766359f, 0.03232491f, -0.04215111f, 0.16122103f, 
    0.24967773f, 0.16383941f, -0.24273480f, -0.06218244f, -0.03342620f, 0.01707678f, 0.12530991f, 0.13210811f, 
    0.17452119f, -0.05781286f, -0.14532335f, 0.09970187f, -0.06357285f, 0.09281727f, 0.11023165f, 0.01162800f, 
    0.05643446f, 0.09594709f, -0.03001237f, -0.04386677f, -0.15194568f, 0.05841229f, 0.00494444f, -0.00130811f, 
    0.04571410f, -0.09190360f, 0.06893292f, 0.10480833f, 0.20693821f, 0.16280782f, 0.11404376f, 0.05832470f, 
    0.01528932f, -0.04161401f, -0.14527813f, 0.31937420f, 0.00612896f, -0.52226472f, -0.08013427f, -0.02359660f, 
    0.05730554f, 0.26540890f, -0.13050550f, -0.02793106f, 0.19723599f, -0.06523097f, 0.22940795f, 0.08987996f, 
    -0.07616933f, 0.10918943f, 0.07912528f, -0.11848303f, 0.04311788f, 0.01500688f, -0.36759222f, -0.29216260f, 
    0.04081699f, -0.04267836f, -0.08812229f, 0.03264413f, 0.03468119f, 0.15037240f, -0.18527171f, -0.15329406f, 
    0.23380241f, 0.07622263f, -0.02587027f, 0.04353755f, -0.00496661f, 0.00236911f, 0.07599567f, 0.40395811f, 
    0.12959692f, -0.14756696f, -0.21569289f, -0.25802422f, 0.13834107f, -0.00515671f, 0.22718763f, -0.13271251f, 
    -0.29113904f, -0.18484928f, -0.35054627f, -0.24484685f, -0.04492323f, -0.09229782f, -0.01340371f, 0.00905424f, 
    0.11238706f, 0.46648115f, 0.10892479f, 0.07963493f, 0.06741735f, -0.14143810f, -0.06757062f, 0.11436348f, 
    0.00434166f, 0.14135389f, -0.02810567f, -0.08964852f, -0.05534001f, -0.03332251f, -0.03714338f, -0.06326964f, 
    0.07270080f, -0.02721590f, -0.11074999f, 0.20705438f, 0.08039880f, -0.29866835f, 0.13009638f, -0.10413370f, 
    0.02451982f, -0.02721826f, -0.18096769f, -0.04116548f, -0.06804124f, 0.19274710f, -0.37938777f, 0.06785279f, 
    -0.11846862f, 0.03734004f, 0.04721811f, 0.03452250f, 0.24018954f, 0.09340259f, 0.01049597f, 0.15588519f, 
    -0.08335361f, 0.08897395f, -0.04186721f, -0.05172857f, -0.16117543f, -0.05428081f, -0.05177163f, -0.02856274f, 
    -0.07597835f, -0.08275425f, 0.18036734f, -0.00945681f, -0.04234244f, 0.11049065f, 0.02114725f, 0.17334391f, 
    0.00119781f, 0.48862186f, -0.02803176f, -0.15343393f, -0.07438502f, 0.15938738f, -0.01719231f, 0.09633873f, 
    0.40503207f, -0.15669796f, 0.20691361f, 0.16877609f, 0.22438665f, 0.01282134f, 0.14261952f, 0.04431274f, 
    0.01274832f, -0.40964833f, 0.03393762f, 0.17205891f, 0.13935572f, 0.10460948f, -0.06638715f, 0.02901828f, 
    -0.09178160f, 0.04057471f, -0.17518362f, -0.04817124f, -0.09947417f, -0.03464241f, -0.05997860f, -0.13057370f, 
    -0.11913349f, 0.15824163f, -0.04888354f, 0.12520446f, -0.15772374f, 0.21342392f, 0.04287015f, 0.14186537f, 
    0.07904991f, 0.21987118f, 0.01368012f, -0.09061113f, -0.40707183f, -0.22225063f, -0.27665672f, -0.00535556f, 
    0.07287171f, 0.00731335f, 0.03029971f, 0.03075480f, -0.03612873f, 0.09772925f, 0.00565129f, 0.12183806f, 
    0.23441249f, 0.07736641f, -0.00329127f, 0.18400562f, 0.21307218f, -0.07125015f, -0.08612122f, -0.25845024f, 
    0.12260896f, 0.05590447f, -0.04379000f, 0.00334268f, -0.00144262f, 0.03602442f, 0.14721574f, -0.10409009f, 
    -0.10514186f, -0.27868864f, -0.18971606f, 0.19598471f, 0.12563486f, -0.13494499f, -0.25884384f, -0.05554283f, 
    0.48621070f, -0.23107366f, -0.12355410f, 0.12528822f, -0.11731254f, -0.12801579f, 0.11989833f, -0.24013352f, 
    -0.16141331f, 0.04347426f, -0.19149145f, -0.18261595f, -0.07430454f, 0.20668252f, 0.07701921f, 0.08500066f, 
    -0.06540506f, 0.07989424f, 0.34910211f, 0.02634437f, 0.13545257f, -0.04335376f, 0.07553256f, 0.16584384f, 
    -0.26062387f, -0.07123421f, -0.00924087f, -0.01078578f, 0.11492845f, 0.11438923f, -0.15983647f, -0.09990077f, 
    0.02652489f, 0.06772444f, -0.04496938f, 0.02436871f, 0.39931569f, 0.14532721f, 0.42607135f, -0.09914954f, 
    -0.09617756f, -0.31794482f, 0.08165567f, 0.08736499f, -0.11192968f, 0.04388818f, -0.05764941f, -0.19924261f, 
    -0.01471071f, -0.05833711f, 0.20637287f, -0.07865296f, -0.05704840f, -0.09483608f, 0.23498382f, 0.08891673f, 
    -0.15319903f, -0.09257793f, -0.07077815f, -0.03558646f, 0.07512059f, -0.07241555f, 0.09851097f, -0.25177950f, 
    -0.00869017f, 0.23105940f, -0.07064895f, -0.05317060f, 0.23482513f, -0.03899935f, -0.01854252f, 0.21425256f, 
    0.37135065f, 0.08929805f, 0.14231282f, -0.05600920f, 0.20236400f, -0.05842479f, 0.00055144f, 0.19575925f, 
    -0.02552610f, -0.02294971f, 0.20566571f, -0.00737404f, -0.09219141f, 0.09070412f, -0.16990694f, -0.07428057f, 
    -0.26278925f, 0.07682711f, -0.24384032f, -0.17795351f, 0.17528331f, -0.06717486f, -0.08617284f, 0.13221735f, 
    0.02911636f, 0.04014936f, -0.06493820f, 0.37949952f, -0.03770213f, -0.17022420f, -0.21330617f, 0.19645131f, 
    0.17833093f, -0.02527337f, 0.13378222f, -0.17865035f, 0.25409541f, -0.26474342f, 0.10068004f, -0.12314589f, 
    0.09427283f, -0.01148488f, 0.07282128f, 0.00408790f, -0.09126797f, -0.00218265f, -0.05173519f, 0.60842782f, 
    -0.08137865f, -0.08535709f, -0.17787996f, -0.13440727f, 0.02194879f, -0.02517785f, 0.22110161f, -0.37880051f, 
    0.54958850f, -0.39853400f, -0.13303278f, -0.03706613f, -0.05372915f, 0.10984178f, -0.00324824f, -0.08552660f, 
    -0.03598312f, -0.35575646f, -0.14722347f, -0.01592426f, 0.14791486f, 0.08762345f, -0.03764466f, 0.06718814f, 
    -0.47205469f, -0.44415250f, -0.14990793f, 0.15137744f, -0.10479908f, 0.17739324f, 0.05073017f, -0.08178400f, 
    0.07368269f, 0.32741287f, 0.04911739f, -0.11483791f, -0.11369856f, -0.14509012f, 0.16234669f, 0.01617416f, 
    -0.01257221f, 0.04335744f, 0.14714745f, 0.26214597f, 0.07489780f, 0.02864937f, -0.00960598f, -0.11421998f, 
    0.00199418f, 0.18303937f, 0.06408349f, 0.07239915f, 0.18395853f, 0.01219595f, -0.18965709f, 0.02757752f, 
    0.03815072f, 0.08066427f, 0.04336909f, -0.16939369f, -0.03313633f, 0.05448462f, -0.10484730f, -0.00227711f, 
    -0.12728706f, -0.14032505f, -0.15880825f, 0.03075858f, 0.12841496f, 0.06744905f, 0.17729300f, 0.28020301f, 
    -0.09774756f, -0.02615354f, -0.05158253f, 0.15092291f, 0.05417833f, -0.05731302f, 0.16293471f, -0.19883537f, 
    -0.27010593f, 0.06645503f, -0.05568678f, -0.03261749f, 0.00065943f, 0.05146530f, 0.01877094f, -0.21057303f, 
    0.04898748f, 0.31498960f, -0.04880181f, -0.00320963f, -0.41260260f, -0.12683727f, -0.03039311f, 0.02420972f, 
    0.35776505f, -0.62314045f, -0.56613106f, 0.06186410f, 0.18202858f, -0.02443052f, -0.08504765f, 0.03244026f, 
    -0.02287398f, -0.63475055f, -0.18599881f, 0.18816979f, -0.22089234f, 0.04743160f, -0.04770194f, 0.17209768f, 
    -0.02043932f, 0.01340133f, 0.17134392f, 0.16012006f, 0.04241402f, 0.10790958f, 0.10364172f, -0.03428167f, 
    0.01467350f, -0.03903528f, 0.01281162f, -0.48950878f, -0.19218674f, -0.64797252f, -0.07554403f, -0.02529773f, 
    -0.07908928f, 0.01775861f, 0.05668638f, 0.02478089f, 0.34079832f, -0.21486740f, 0.19884509f, -0.05932003f, 
    -0.05655513f, 0.12563416f, -0.05156413f, 0.02989591f, -0.09943118f, -0.62989438f, -0.45948222f, 0.29152417f, 
    -0.28762639f, 0.04510200f, 0.10978172f, -0.04681588f, 0.08000930f, 0.04998486f, 0.15052156f, 0.12954794f, 
    0.13749701f, -0.14597698f, 0.05525362f, -0.08004816f, 0.13938849f, 0.05674725f, -0.00127016f, 0.13703252f, 
    0.28904456f, -0.11781327f, -0.17109926f, -0.02630249f, -0.05820338f, 0.12715597f, 0.12344375f, 0.00890216f, 
    0.23421614f, -0.42204243f, -0.21145624f, -0.08289218f, -0.02605398f, -0.07213103f, 0.12127126f, 0.00285321f, 
    -0.00041582f, -0.02726397f, 0.41167963f, -0.12497685f, -0.02640947f, -0.04263197f, 0.03389744f, 0.05207620f, 
    0.08326522f, -0.18065912f, 0.00734234f, -0.01234094f, 0.02364183f, -0.00238534f, -0.02462611f, 0.05394654f, 
    0.00909047f, -0.04939869f, 0.04966567f, -0.52171683f, -0.01435113f, -0.49642929f, -0.07320379f, 0.08111943f, 
    0.08589772f, 0.01306567f, 0.01366938f, 0.00937730f, 0.19958639f, 0.29083043f, -0.27684638f, -0.26500496f, 
    -0.15669377f, -0.25110218f, 0.10705252f, 0.06375382f, 0.03987910f, -0.28777620f, 0.06453080f, 0.18417613f, 
    0.04268656f, 0.00423101f, -0.00856808f, 0.13026279f, 0.01713485f, -0.00424070f, 0.24458143f, -0.01003295f, 
    -0.16845448f, -0.12667255f, -0.05472873f, 0.11229433f, 0.05171351f, 0.10629795f, 0.01188148f, 0.08111194f, 
    0.26104096f, 0.34698576f, -0.14482608f, 0.13634253f, -0.20527770f, -0.00509546f, 0.03108943f, 0.12593251f, 
    -0.08313996f, 0.27844131f, -0.10226648f, 0.09175197f, -0.08923531f, 0.18140803f, -0.20605509f, -0.29761046f, 
    -0.04813013f, 0.07476438f, -0.07533351f, -0.40231678f, -0.18669318f, -0.05186192f, -0.17060456f, 0.37155762f, 
    0.10165772f, -0.00298758f, 0.11521053f, -0.04672170f, 0.15607850f, 0.25090325f, 0.03988340f, 0.10693755f, 
    0.13890861f, -0.29801938f, 0.07405301f, -0.27382675f, -0.05871842f, -0.04860182f, 0.06809593f, 0.01457381f, 
    -0.11185084f, 0.12471005f, -0.00694813f, -0.07792372f, -0.08929522f, 0.26318279f, 0.22167596f, -0.03471065f, 
    0.12939936f, -0.22906542f, 0.10972891f, 0.02479377f, -0.04061570f, -0.18205474f, 0.04162670f, -0.36365345f, 
    0.17171927f, -0.36067832f, -0.07820725f, 0.01245283f, 0.25362489f, -0.11891877f, -0.07665100f, 0.16759226f, 
    0.36552677f, -0.17871577f, -0.05083996f, -0.13697551f, 0.26625216f, -0.12717646f, -0.02199530f, 0.11768085f, 
    -0.01998912f, 0.35101777f, 0.01078075f, 0.08912351f, 0.08558874f, -0.05282764f, 0.04226580f, -0.20516573f, 
    -0.32538158f, 0.10841588f, 0.16803062f, 0.14048240f, -0.05590831f, 0.15916981f, 0.19777021f, 0.07426756f, 
    0.08573184f, 0.06664348f, 0.18858933f, 0.09760019f, 0.16080742f, 0.03028054f, 0.02372243f, 0.10014585f, 
    -0.05353664f, -0.01581725f, 0.03685478f, 0.08124714f, -0.32151029f, 0.25051740f, 0.16073991f, 0.11466461f, 
    0.05266975f, 0.01193685f, -0.02309494f, -0.04100545f, -0.06242345f, -0.02102983f, 0.03277306f, 0.01895218f, 
    -0.12194308f, 0.08623586f, 0.24842055f, -0.06566233f, 0.01469650f, -0.05985873f, -0.11982916f, -0.25084713f, 
    -0.29712185f, -0.01891455f, -0.08475352f, 0.20622051f, 0.25808758f, 0.04110075f, -0.00840653f, 0.36509278f, 
    -0.02821048f, 0.01209448f, 0.02570458f, 0.02113355f, 0.12197225f, -0.12925731f, -0.22603090f, 0.04817330f, 
    0.54897469f, 0.02919342f, 0.07786994f, -0.01672064f, 0.24453886f, 0.12745878f, 0.21081284f, -0.01681732f, 
    -0.25447595f, 0.20184503f, 0.13474783f, 0.02316986f, -0.02371048f, -0.06666441f, -0.26989597f, -0.08402301f, 
    -0.42186478f, 0.36926487f, 0.03393744f, 0.01500443f, 0.11106583f, -0.07872713f, -0.07193975f, 0.13951319f, 
    -0.11201464f, -0.88291872f, -0.01183398f, 0.16640514f, -0.02325719f, 0.06149001f, 0.04281738f, 0.06653772f, 
    -0.06377006f, -0.03081925f, -0.07568072f, -0.36101246f, 0.31744292f, -0.03453293f, 0.03407359f, -0.19466075f, 
    0.02014725f, -0.05921563f, 0.07597907f, -0.06504383f, -0.17945775f, -0.18988428f, -0.11061918f, 0.19216019f, 
    0.12726970f, 0.05571511f, -0.16033228f, -0.04378614f, -0.04214399f, 0.03443789f, 0.04654507f, -0.08564279f, 
    -0.04077109f, 0.06463806f, -0.10564636f, 0.12078346f, -0.01920492f, -0.40491986f, 0.29983941f, 0.06799129f, 
    -0.25319853f, -0.01314469f, -0.05876668f, 0.01859001f, -0.05847642f, 0.23311801f, -0.19696803f, -0.03781157f, 
    0.29961637f, -0.02463255f, -0.16337717f, -0.11400098f, 0.09951590f, 0.13705099f, -0.05437452f, -0.15027459f, 
    -0.09320934f, 0.25456887f, 0.11295038f, 0.28201899f, 0.15086693f, 0.14937487f, 0.06998194f, -0.11419287f, 
    0.29331478f, 0.08129226f, -0.08836500f, -0.08579881f, -0.20615666f, 0.18927787f, -0.06285451f, -0.08860703f, 
    0.12370356f, 0.15454878f, -0.38732007f, 0.15601043f, 0.07273607f, 0.13713266f, -0.11070441f, 0.02690586f, 
    -0.12727368f, 0.13432539f, -0.19615157f, 0.02459648f, -0.15522607f, -0.02528929f, 0.16262051f, -0.04702014f, 
    -0.04928666f, 0.08308639f, 0.02132125f, 0.00590955f, 0.13226378f, 0.08028932f, -0.01905261f, 0.10480020f, 
    0.06273560f, 0.05299492f, -0.16585463f, 0.03860082f, -0.26143438f, 0.03645065f, 0.16626175f, -0.15891273f, 
    -0.28315258f, -0.13155986f, 0.19390355f, 0.02149017f, -0.01486486f, 0.00541844f, 0.29517025f, 0.06424654f, 
    0.08013411f, 0.14200582f, -0.02483134f, 0.01982190f, 0.05535117f, -0.10662511f, -0.13889883f, 0.00770332f, 
    0.51739764f, 0.07778795f, -0.16789177f, 0.09554089f, 0.05100766f, -0.16943343f, -0.07178447f, -0.19312634f, 
    0.03514891f, -0.03056804f, -0.01492783f, -0.08549649f, -0.25732622f, 0.20282972f, 0.22415671f, 0.08817091f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.28462705f, 0.07070540f, 0.07204246f, 0.09750778f, 0.01334665f, 0.16171181f, 0.25065595f, -0.10149702f, 
    0.20347221f, -0.03773876f, 0.10226513f, -0.03561155f, 0.09827968f, 0.02215921f, 0.24476959f, 0.15881240f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.45850113f, 0.09021839f, -0.32683226f, -0.04070460f, 0.06198442f, 0.24342692f, -0.29806924f, 0.16778563f, 
    -0.35549709f, 0.07964195f, 0.00025318f, -0.21376449f, 0.51606870f, -0.33151785f, 0.14145270f, 0.38284871f, 
    -0.42238632f, 0.35870075f, 0.16524154f, -0.17254090f, 0.02196771f, -0.04159638f, -0.04362884f, 0.15315302f, 
    0.51684856f, -0.00992087f, -0.07133696f, 0.02776643f, 0.26822293f, -0.22971815f, -0.25082147f, 0.46801814f, 
    0.20812392f, -0.07727813f, 0.24488991f, -0.43821898f, -0.30518326f, -0.06489798f, 0.47484028f, 0.12070674f, 
    -0.27374414f, 0.29397318f, 0.00269663f, -0.30995217f, -0.03273597f, -0.40381074f, 0.27791032f, 0.46439105f, 
    0.19743221f, -0.04266451f, -0.23324822f, -0.23440555f, -0.21280615f, -0.16725737f, -0.20677510f, -0.21359408f, 
    -0.23298843f, 0.05185682f, 0.06644519f, -0.05553461f, -0.04611969f, 0.18750191f, -0.20196158f, -0.04137190f, 
    0.08310590f, -0.15054104f, 0.06583990f, -0.45033601f, 0.19626163f, 0.17910236f, 0.31789732f, 0.00018469f, 
    0.51851338f, 0.24796835f, 0.30624923f, 0.12971538f, -0.01964632f, -0.68865073f, -0.21374191f, -0.21901020f, 
    0.54813486f, 0.13530155f, -0.19083989f, -0.25609168f, 0.02915285f, -0.07766267f, 0.19984384f, -0.07927850f, 
    -0.08417503f, 0.10439977f, -0.36537209f, 0.32411107f, 0.10930762f, -0.51882172f, -0.14189872f, 0.13885792f, 
    -0.16063651f, -0.20027451f, -0.13485046f, -0.17735705f, 0.04130695f, 0.09339730f, 0.21352236f, -0.14507124f, 
    -0.18361132f, -0.05441484f, -0.17361589f, 0.00766384f, -0.06444540f, -0.25507858f, 0.09261893f, -0.07195047f, 
    0.53456062f, 0.04364887f, -0.19178146f, -0.03157400f, 0.10457078f, 0.22634648f, -0.10672823f, -0.13199306f, 
    -0.12226576f, -0.10697723f, -0.04237716f, -0.01066225f, 0.16838194f, -0.06081640f, -0.06372695f, -0.15000002f, 
    -0.29765245f, 0.14944388f, 0.29165280f, -0.19740440f, 0.13115899f, 0.02249818f, 0.36210668f, -0.14747702f, 
    -0.12607910f, -0.05817429f, 0.44096816f, -0.02716534f, -0.44242841f, 0.22793031f, 0.06680872f, -0.16612396f, 
    0.33676463f, 0.15900613f, 0.19852243f, 0.06221908f, 0.23049939f, 0.04689289f, 0.03516492f, -0.08925472f, 
    -0.03973248f, -0.28467092f, 0.27593085f, -0.21425731f, -0.13792062f, -0.25300264f, 0.01177773f, -0.31297225f, 
    -0.07709050f, 0.27802193f, 0.24892579f, -0.22162111f, -0.22811221f, 0.12437695f, -0.53083706f, 0.11909919f, 
    0.30929625f, 0.18476595f, 0.05258142f, -0.03937629f, 0.37121633f, -0.22623129f, -0.27457678f, 0.38145667f, 
    0.52399635f, -0.05218770f, -0.11353768f, 0.27899176f, 0.31679612f, 0.26654398f, 0.27990118f, -0.15947475f, 
    -0.35460466f, -0.33738196f, 0.40799275f, -0.04335863f, 0.05672019f, -0.14810884f, -0.06026577f, 0.16817267f, 
    0.15711153f, -0.14849687f, 0.20236817f, 0.13014026f, -0.08277740f, -0.01016990f, 0.06727370f, -0.11646619f, 
    -0.00510698f, -0.03641599f, -0.20503822f, -0.17028052f, -0.10540655f, 0.06117260f, -0.21193925f, -0.08557195f, 
    -0.49358398f, 0.18772250f, -0.00696198f, 0.34714741f, -0.02926814f, -0.22413118f, -0.33010936f, -0.06133163f, 
    0.13697226f, 0.28441706f, 0.16302021f, 0.14154799f, 0.47295603f, 0.33181161f, 0.15900765f, -0.02848875f, 
    0.19624063f, 0.27624476f, 0.20132290f, 0.05096508f, -0.04054892f, 0.36468506f, -0.22005749f, 0.21447138f, 
    0.17303360f, -0.29462525f, -0.24145879f, -0.26288494f, 0.32675585f, -0.25133550f, 0.10138629f, 0.27882242f, 
    -0.01374924f, 0.33322155f, -0.25998816f, 0.07193689f, 0.36370742f, -0.21001868f, 0.08097269f, 0.11456486f, 
    -0.18580329f, -0.29300362f, 0.12929055f, 0.01521326f, -0.48796162f, -0.23115458f, 0.22549081f, 0.14131472f, 
    -0.18767415f, 0.00758503f, -0.09400304f, -0.25363722f, -0.05032732f, 0.08446309f, 0.09809079f, 0.19135210f, 
    -0.06167778f, 0.03631189f, 0.00585277f, -0.30408993f, -0.05121303f, 0.10608260f, -0.17314035f, -0.09683879f, 
    -0.00926933f, 0.13559550f, 0.22165291f, -0.26894936f, -0.11325594f, 0.23375712f, 0.21994947f, 0.08490754f, 
    0.38471308f, 0.03759945f, -0.34707621f, -0.39461207f, 0.21048206f, -0.06403024f, -0.01610800f, 0.35139352f, 
    -0.17618655f, -0.02919746f, 0.36335582f, -0.36618379f, -0.07352591f, 0.27251703f, 0.07381274f, 0.14565751f, 
    0.30583388f, 0.10469810f, 0.48459816f, -0.42482483f, -0.06866927f, -0.09171265f, -0.02215925f, -0.33205304f, 
    -0.16447636f, 0.23802882f, -0.10646378f, 0.31465381f, 0.33548281f, -0.20223036f, 0.18181051f, 0.14105429f, 
    0.00253361f, -0.10667557f, 0.42370889f, -0.06565744f, 0.38907522f, 0.50238919f, 0.00911038f, -0.10396618f, 
    0.23512450f, 0.15960507f, -0.01965592f, -0.37828207f, 0.04135398f, 0.03006585f, -0.19924499f, -0.07517398f, 
    0.30009437f, 0.48056811f, 0.14000957f, 0.04631081f, 0.14913712f, -0.15233015f, -0.24855423f, -0.20062265f, 
    0.14534438f, 0.09244666f, 0.15366718f, -0.25206614f, 0.02433531f, -0.06887520f, -0.26321068f, 0.07409450f, 
    -0.26421666f, -0.22300327f, -0.04950050f, -0.14645867f, -0.25244576f, 0.07877266f, -0.13521875f, -0.07612230f, 
    -0.32693014f, 0.15104055f, -0.04134272f, 0.23726222f, -0.14744723f, 0.26720768f, -0.48539680f, 0.24400331f, 
    -0.01852326f, 0.02933704f, 0.03753424f, 0.42480811f, -0.13406159f, 0.39048624f, -0.28012401f, -0.23001175f, 
    0.04191775f, 0.25053346f, -0.09573643f, -0.27179706f, 0.11927555f, 0.16768719f, -0.23647346f, 0.06844252f, 
    -0.05257303f, -0.29289180f, 0.09921023f, -0.25241283f, 0.45607799f, -0.47320053f, 0.33465883f, 0.15446901f, 
    0.16288903f, -0.11415453f, 0.27395168f, -0.34370974f, -0.17599760f, 0.31734544f, 0.30278486f, -0.06608087f, 
    0.22026601f, 0.48114589f, -0.23896809f, 0.26623446f, -0.47142950f, 0.28786644f, -0.23026684f, -0.33833069f, 
    -0.04816306f, 0.04368502f, -0.10135898f, -0.15865660f, -0.21348056f, -0.02331701f, -0.24702284f, -0.03400740f, 
    -0.01382038f, -0.02974820f, -0.22426853f, -0.12101504f, 0.10247892f, 0.10265765f, 0.05269766f, -0.23144016f, 
    -0.03404459f, -0.15516430f, 0.20562917f, -0.08970961f, 0.14249039f, -0.26191193f, 0.03692877f, -0.02217396f, 
    0.13596249f, -0.16583323f, -0.17492236f, -0.25095373f, -0.19370124f, -0.06544117f, -0.20368733f, -0.14670844f, 
    -0.22808707f, -0.15167175f, 0.37633547f, 0.13533628f, 0.10811974f, -0.18958828f, 0.23010410f, 0.07560933f, 
    -0.30582872f, 0.27000836f, -0.70088243f, 0.36583307f, -0.52051312f, 0.03985737f, -0.10570962f, 0.27949870f, 
    -0.13019332f, -0.29047975f, 0.11894856f, 0.03823885f, 0.22640753f, -0.32587084f, 0.32463706f, -0.22525062f, 
    0.18304017f, -0.03022083f, 0.32055801f, 0.25949878f, -0.17645702f, 0.71388400f, 0.09224243f, -0.11559775f, 
    0.12659818f, -0.10886845f, 0.22657306f, -0.14858156f, -0.38333046f, 0.24299553f, 0.33343008f, 0.02347305f, 
    0.02398629f, 0.01696076f, -0.03668908f, 0.24290650f, -0.21129069f, 0.00452763f, 0.03286364f, 0.41856444f, 
    -0.03233421f, -0.26231679f, 0.06802937f, -0.03491826f, -0.00571728f, 0.07607742f, 0.07418875f, -0.11677107f, 
    -0.33636299f, 0.48419908f, -0.78680640f, 0.34028950f, -0.26690352f, 0.22988117f, 0.18259175f, -0.03979766f, 
    -0.14882591f, 0.02329575f, -0.22206682f, 0.10416584f, -0.10930670f, -0.18611525f, -0.14168862f, -0.02695245f, 
    0.10637037f, -0.21632895f, -0.08446573f, -0.12269391f, 0.16727504f, 0.00675715f, 0.01376454f, -0.21768261f, 
    -0.13856478f, 0.03160430f, -0.18066525f, 0.16259916f, 0.00063184f, -0.06713367f, 0.12376330f, -0.09584507f, 
    -0.21304467f, 0.55763179f, -0.10646213f, 0.32663980f, -0.13869865f, 0.39430958f, 0.08624537f, -0.03185355f, 
    0.41660097f, -0.00288052f, -0.01595363f, 0.30812809f, 0.29531652f, 0.32129532f, -0.38898793f, -0.24084064f, 
    -0.48853573f, -0.35772693f, -0.17159460f, 0.23619233f, -0.18175466f, 0.47172111f, -0.03006326f, -0.19751394f, 
    -0.48799720f, -0.22533801f, 0.28894570f, 0.20445730f, -0.15831554f, 0.35570094f, 0.34113392f, -0.14135846f, 
    -0.39194891f, 0.19653945f, 0.08443392f, 0.14328861f, 0.26662362f, 0.09643374f, 0.18088190f, 0.43552884f, 
    0.09314173f, -0.04406882f, 0.08758856f, 0.28495252f, 0.19964513f, 0.08388498f, 0.22285146f, -0.01606432f, 
    -0.53542131f, -0.32046509f, 0.03988673f, -0.07156765f, 0.21351279f, -0.14693613f, 0.18987024f, 0.36812103f, 
    -0.00855212f, -0.06839802f, -0.00601525f, -0.19884354f, 0.10407662f, -0.17917308f, -0.25841790f, 0.09506318f, 
    0.23960724f, -0.02208122f, 0.10013911f, -0.16445048f, -0.17474510f, 0.17587949f, -0.24858190f, -0.15609434f, 
    -0.23941210f, 0.11672723f, -0.21086846f, 0.10658395f, 0.08394282f, -0.24289264f, 0.45119390f, -0.06050558f, 
    -0.22038195f, 0.06596830f, 0.21936253f, 0.18991716f, -0.21340866f, 0.04282288f, 0.44681761f, -0.09923552f, 
    0.48333511f, 0.43183938f, -0.38220128f, 0.32142007f, 0.27500659f, -0.20898506f, -0.30150431f, 0.13730770f, 
    0.12278154f, -0.16458164f, 0.07794691f, -0.31949195f, -0.20030282f, 0.10938821f, 0.11282481f, 0.04062779f, 
    -0.12962672f, -0.07003988f, 0.41302383f, 0.22366691f, -0.22003251f, 0.32818508f, 0.54430187f, 0.14356123f, 
    -0.12765880f, -0.30152395f, 0.12469993f, -0.10345957f, -0.25343746f, -0.29914099f, 0.23824061f, 0.32949632f, 
    0.12726334f, 0.03888752f, -0.01924427f, -0.07744747f, -0.28540936f, -0.05050927f, 0.14887105f, -0.16940992f, 
    -0.41038832f, 0.50538546f, 0.11427572f, -0.37049800f, -0.63234049f, -0.80912471f, 0.36952436f, 0.13115232f, 
    -0.13700245f, 0.16064551f, 0.12120553f, 0.12938195f, 0.15578942f, -0.00740489f, -0.32555693f, -0.12878804f, 
    -0.29006711f, 0.38509616f, -0.28123203f, -0.36908859f, 0.21791656f, -0.64071596f, 0.12533875f, 0.26232070f, 
    0.66238368f, 0.18854466f, -0.04155197f, -0.13972700f, 0.26509517f, 0.20864677f, 0.22390719f, 0.08499394f, 
    -0.19989307f, -0.14511015f, 0.03017003f, -0.44346163f, -0.15325254f, -0.18509018f, -0.10647998f, -0.03553131f, 
    0.37446374f, 0.01130092f, -0.20203634f, -0.39001822f, -0.25436482f, 0.40031549f, 0.43053514f, -0.14744365f, 
    -0.15790582f, -0.04086162f, -0.07796448f, 0.42351174f, -0.16194321f, 0.27393085f, 0.31870046f, -0.22872338f, 
    0.09703299f, 0.32328880f, 0.11349362f, 0.50301319f, 0.38104948f, -0.34488970f, -0.11972300f, -0.07569453f, 
    -0.13314947f, -0.43327552f, 0.42187607f, -0.29418606f, -0.09998497f, -0.16649215f, 0.12243008f, -0.43444139f, 
    -0.52890557f, 0.30383795f, -0.32179973f, 0.42996088f, 0.32600117f, 0.05647079f, 0.22267069f, 0.22943267f, 
    -0.27246135f, -0.35884351f, 0.15561463f, -0.19148253f, 0.29237345f, 0.42399079f, 0.36635873f, 0.28205231f, 
    -0.10164884f, -0.11658084f, -0.05303941f, -0.04309058f, 0.34687224f, -0.02336481f, -0.36689642f, -0.01170948f, 
    0.49937204f, -0.19537859f, 0.26744369f, 0.10458153f, 0.31713146f, 0.54934168f, 0.13064563f, -0.19795735f, 
    0.19197693f, 0.05457865f, 0.36166117f, -0.28014305f, -0.04115593f, 0.00172348f, 0.49574095f, -0.14445913f, 
    0.20607477f, 0.10385709f, -0.21739575f, -0.52763832f, -0.52133971f, -0.22533272f, 0.00416248f, 0.38150838f, 
    -0.39017597f, -0.23936772f, 0.25564250f, -0.16805391f, -0.19300969f, 0.23933367f, 0.41252694f, -0.06614959f, 
    0.25206947f, -0.05441310f, 0.22563094f, 0.31996307f, 0.00929111f, 0.40981200f, 0.07441125f, 0.43614540f, 
    -0.09126497f, -0.17072453f, -0.21195750f, -0.01137046f, -0.18197639f, 0.01327610f, 0.21867199f, -0.10992491f, 
    -0.18161814f, -0.04923110f, 0.05914577f, 0.15571164f, 0.08110770f, -0.16794400f, -0.07999291f, 0.04858202f, 
    -0.10129067f, -0.14755578f, -0.15529221f, -0.01922011f, -0.19402419f, 0.16835512f, 0.00547412f, 0.14762136f, 
    -0.06960941f, -0.11907583f, 0.07954825f, 0.02857685f, -0.13927579f, -0.02048171f, -0.17978582f, -0.13166413f, 
    -0.49910071f, 0.32122567f, 0.28851429f, 0.15828252f, 0.11275600f, -0.05924867f, 0.25677192f, 0.16225828f, 
    0.35529321f, 0.47857296f, 0.22857106f, -0.44850683f, 0.07354692f, 0.08691168f, 0.23083393f, 0.17862813f, 
    0.58967352f, 0.31651145f, -0.28443757f, 0.29540280f, 0.34498370f, -0.26977372f, 0.09957885f, 0.07308473f, 
    -0.36023414f, 0.12083505f, -0.04528834f, -0.13164493f, -0.56648362f, -0.25163031f, -0.00136251f, -0.24583773f, 
    0.42438367f, 0.24765196f, 0.07727174f, -0.17766355f, 0.22722974f, 0.33865246f, 0.13342372f, 0.23747495f, 
    0.39876285f, -0.36792600f, 0.11444654f, -0.42858261f, 0.16954961f, -0.43150905f, -0.08499856f, 0.01428877f, 
    0.25289652f, 0.07266965f, -0.19821580f, -0.06356177f, 0.37515962f, -0.32520679f, 0.22036688f, -0.22307508f, 
    -0.21650714f, -0.10211848f, 0.06015907f, 0.07914867f, -0.46727613f, 0.10178798f, 0.03825429f, 0.35219267f, 
    0.19188935f, 0.14975789f, 0.31103492f, -0.32110015f, 0.01277420f, 0.40331689f, 0.20972724f, 0.13744958f, 
    -0.11485396f, -0.26691404f, 0.34479308f, -0.28525326f, -0.21265388f, -0.51118827f, 0.13938253f, 0.11437881f, 
    -0.10459602f, 0.19737403f, -0.21025823f, 0.03746418f, -0.02684665f, -0.02177718f, -0.01478822f, -0.00409489f, 
    0.16105957f, -0.09276225f, 0.32228938f, -0.02414739f, 0.52390236f, 0.35589489f, -0.03380600f, 0.44774944f, 
    -0.00376470f, 0.07542103f, 0.01551579f, 0.09985496f, -0.36642912f, -0.17049229f, -0.13446681f, 0.00559762f, 
    0.32416251f, -0.50724721f, -0.09607326f, 0.18044518f, 0.03394956f, 0.05795572f, -0.58213520f, -0.23689017f, 
    -0.38263053f, 0.04855355f, -0.31771070f, -0.11418196f, -0.01827394f, 0.16851412f, 0.30959448f, 0.13728170f, 
    0.22894560f, 0.25212544f, 0.32514554f, 0.16489504f, 0.30603391f, 0.21294007f, 0.12549089f, -0.33292103f, 
    0.01897115f, -0.09221409f, 0.35001606f, -0.41178024f, 0.17538574f, 0.32170820f, 0.69630098f, -0.08056772f, 
    -0.05776540f, -0.16186823f, 0.07611624f, -0.21682714f, -0.50508851f, 0.35555828f, 0.13966751f, 0.25556424f, 
    -0.39080885f, 0.25853968f, -0.00147294f, 0.11480148f, 0.00481871f, -0.29077581f, -0.09960321f, 0.26119769f, 
    -0.43122721f, 0.30937070f, 0.02975028f, 0.21594977f, -0.25433519f, 0.61065465f, 0.04840150f, -0.25932008f, 
    -0.40414959f, 0.31153324f, -0.41069371f, 0.52794194f, 0.26593229f, -0.08123418f, -0.34319326f, -0.05445512f, 
    0.25004321f, 0.12915650f, -0.07016435f, -0.09847759f, -0.03483244f, 0.32521975f, 0.20819032f, -0.13975011f, 
    0.05739965f, 0.13355482f, -0.06767828f, -0.05765549f, -0.00328689f, -0.19224870f, 0.15145496f, -0.09569409f, 
    0.15216321f, 0.06239954f, -0.20876312f, 0.05128590f, 0.37726706f, 0.22564317f, -0.75992078f, -0.70330143f, 
    0.20981397f, 0.03812017f, 0.11488879f, 0.18250783f, -0.18851696f, 0.17854254f, -0.03629644f, 0.05171101f, 
    0.07885110f, 0.31540275f, 0.52841806f, 0.11921341f, -0.35114342f, 0.20181417f, -0.26822075f, -0.57091981f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21748590f, -0.06286030f, 0.37983578f, 0.22452848f, -0.19144030f, -0.05355845f, 0.14055081f, 0.39047331f, 
    0.43902937f, 0.06358124f, 0.23223108f, 0.37637529f, 0.14058842f, -0.41097340f, 0.41926104f, 0.08512733f, 
    -0.27499738f, -0.06631598f, -0.02139495f, -0.15732309f, -0.11209676f, -0.02111230f, 0.13041754f, 0.47153813f, 
    -0.10067322f, -0.20623466f, 0.17296652f, -0.17244077f, -0.04270945f, 0.06739463f, -0.33728069f, 0.20081238f, 
    0.04434098f, -0.13101280f, 0.22341493f, 0.11745115f, -0.11520650f, 0.34009987f, 0.18082204f, 0.53050327f, 
    0.25553197f, 0.10645781f, 0.48156011f, -0.06795586f, 0.18226540f, 0.06101463f, -0.38079858f, 0.03997215f, 
    -0.12402602f, -0.28130767f, -0.16790622f, 0.24806657f, 0.37593296f, 0.37718773f, 0.36328211f, 0.27735022f, 
    -0.44016144f, 0.65252841f, 0.21459520f, 0.08909411f, -0.14942940f, -0.21864134f, 0.76861238f, -0.41443488f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04445202f, 0.07528139f, -0.12688656f, 0.11587952f, -0.03336802f, -0.01691447f, -0.02130668f, 0.09744138f, 
    0.10899696f, 0.09144967f, -0.10287999f, -0.03843264f, -0.11458698f, 0.07106677f, -0.01935258f, -0.11277592f, 
    -0.09052783f, 0.10284254f, 0.02357130f, -0.11001018f, -0.04701847f, -0.06459874f, -0.09656183f, 0.01405555f, 
    0.02332956f, 0.04437079f, 0.06139208f, 0.06120488f, -0.09764913f, 0.09937558f, -0.04810779f, 0.08086070f, 
    -0.08046168f, -0.00559912f, 0.01831257f, -0.06258614f, 0.01893391f, 0.00261140f, 0.06160403f, 0.00287255f, 
    0.12229326f, -0.03062476f, -0.00538475f, -0.04454202f, 0.08853744f, -0.08463778f, -0.01030748f, -0.02811730f, 
    -0.09434533f, 0.05876418f, -0.12114188f, -0.03534969f, -0.00064115f, -0.06014689f, -0.00167485f, -0.02654485f, 
    -0.09005735f, 0.05345772f, 0.10869886f, -0.09462485f, 0.03611983f, -0.08426246f, -0.05351529f, -0.05632602f, 
    -0.10796499f, 0.11140610f, 0.07155234f, -0.09372801f, -0.05657281f, -0.06778829f, 0.05406855f, 0.16281135f, 
    0.11399090f, 0.08311537f, 0.18373656f, 0.20931229f, -0.06233613f, 0.02334251f, 0.26856452f, 0.07884487f, 
    -0.08396354f, 0.17803954f, 0.05246336f, 0.03827214f, -0.05776194f, -0.00654456f, -0.01648733f, 0.13684893f, 
    -0.04964071f, 0.12157518f, 0.08318410f, -0.13809283f, -0.01801047f, 0.17209949f, 0.01929259f, -0.12075341f, 
    -0.16573460f, 0.25306308f, 0.20834908f, 0.19816723f, -0.08388290f, -0.05478233f, -0.11181173f, 0.37962744f, 
    -0.26661074f, -0.17241958f, 0.12900752f, -0.10213081f, 0.19046721f, 0.15764931f, -0.13041107f, 0.31264183f, 
    0.03227609f, 0.02938954f, -0.05935192f, 0.08353949f, -0.27417389f, -0.09064813f, 0.01987043f, 0.25954974f, 
    0.08749183f, 0.31320038f, -0.31916761f, 0.22143275f, -0.11702945f, -0.07522306f, -0.01417121f, -0.04026294f, 
    0.08913340f, -0.31612712f, 0.12464978f, -0.00390373f, -0.28424421f, -0.88538533f, -0.08768011f, -0.11262089f, 
    0.10891041f, 0.08860440f, -0.21270274f, 0.11965793f, -0.05886156f, -0.05311541f, 0.03739396f, 0.15099813f, 
    -0.03929713f, -0.20801719f, -0.05640115f, -0.01663220f, -0.78023332f, -0.08146498f, 0.00200104f, 0.12629172f, 
    -0.39215243f, 0.06033768f, -0.02210621f, -0.55855221f, 0.18931119f, -0.06058124f, -0.84449250f, 0.00357121f, 
    0.09285090f, -0.08488508f, 0.22035436f, 0.27861091f, 0.02022252f, 0.37517241f, 0.01860618f, 0.22245826f, 
    0.23610821f, -0.10729856f, 0.16109645f, -0.25963536f, 0.07287464f, 0.30310240f, -0.12906995f, 0.00408193f, 
    0.09214494f, -0.09329214f, 0.01216593f, 0.04456922f, 0.30436179f, 0.13349500f, 0.21161655f, 0.09622458f, 
    0.07693136f, -0.02946702f, 0.17057842f, 0.18339363f, -0.09837473f, 0.16834985f, -0.05539721f, -0.19119467f, 
    0.61229402f, -0.22892159f, 0.21022464f, -0.06210650f, -0.48588073f, 0.12841186f, -0.11955497f, 0.20347053f, 
    0.06691384f, 0.08427805f, 0.00827152f, 0.24772379f, 0.04270856f, 0.19430754f, 0.04111816f, 0.21437649f, 
    -0.10574209f, -0.10556483f, -0.23143555f, 0.18210882f, -0.17663059f, -0.11812192f, -0.10981335f, 0.35520867f, 
    -0.39942083f, 0.08629741f, -0.01760739f, -0.03758690f, -0.08845795f, 0.03231126f, 0.27761632f, -0.00049478f, 
    -0.03324284f, 0.23908013f, 0.20197164f, 0.36192784f, 0.08780774f, 0.20774488f, 0.23844968f, 0.06768110f, 
    0.51859111f, 0.39363188f, 0.13132715f, 0.11730119f, 0.19327760f, 0.13253932f, -0.16964491f, -0.25608262f, 
    -0.34684357f, -0.03934740f, 0.04987524f, -0.09080425f, 0.28542912f, 0.05427508f, -0.08571988f, 0.17696731f, 
    0.03942597f, 0.29527959f, -0.09058185f, -0.07002196f, -0.11890592f, 0.06092873f, -0.39450693f, -0.01041979f, 
    0.26361728f, -0.01096436f, -0.15090545f, -0.01532220f, -0.04478411f, 0.04239133f, -0.03135097f, 0.21042068f, 
    -0.03770388f, 0.14454938f, 0.05979280f, 0.09261072f, -0.01114537f, -0.01365333f, 0.18910684f, 0.01254837f, 
    0.08077417f, 0.22982049f, 0.11782774f, 0.03427959f, 0.07225912f, -0.07182612f, -0.17789556f, 0.33648044f, 
    -0.17944510f, 0.04259436f, -0.01899196f, -0.13831191f, -0.10707735f, 0.04447395f, -0.21484818f, -0.11465191f, 
    -0.37114266f, -0.13585964f, -0.24579889f, -0.05476611f, -0.07396705f, -0.00380234f, 0.38636917f, -0.05725767f, 
    -0.23378196f, -0.09804398f, 0.39948633f, -0.05036398f, 0.29348284f, -0.07435652f, 0.13757022f, -0.16374683f, 
    -0.27258933f, 0.08615841f, 0.02088048f, -0.01517403f, 0.32109097f, 0.40840322f, -0.06164884f, 0.11635295f, 
    0.06373814f, 0.05144465f, -0.09383512f, 0.03935419f, -0.38830656f, -0.13261119f, 0.25688443f, 0.01740133f, 
    0.40622741f, 0.16206422f, 0.24811916f, -0.01717346f, -0.27803567f, 0.25736025f, -0.09043975f, 0.13532491f, 
    -0.16944413f, -0.00959367f, 0.36933777f, -0.02830943f, -0.11764619f, -0.09174462f, 0.36542448f, -0.34914291f, 
    0.00488554f, 0.25823516f, -0.08159144f, 0.05517450f, 0.05074969f, -0.06461422f, 0.18008897f, 0.30261853f, 
    -0.09373109f, -0.01262754f, -0.05256829f, 0.22258392f, -0.59883225f, -0.06306490f, 0.16024499f, 0.07524854f, 
    -0.16608323f, 0.06563893f, 0.13329715f, 0.08523453f, -0.10382839f, -0.39464390f, 0.08757351f, -0.06577691f, 
    -0.08039670f, 0.29080498f, 0.34485832f, -0.14414734f, -0.02075572f, 0.09887364f, -0.12782821f, 0.38256451f, 
    -0.21870403f, -0.09721719f, 0.02520242f, 0.05704105f, -0.23172504f, 0.25335073f, -0.15397517f, 0.22825202f, 
    0.32737932f, -0.72903073f, -0.19481030f, -0.12065094f, -0.31667346f, -0.07259426f, -0.30246884f, -0.20007583f, 
    0.10796116f, 0.08399922f, -0.04114119f, -0.11496048f, -0.11076144f, -0.02193043f, -0.04896554f, -0.11196952f, 
    -0.09475790f, -0.09953873f, -0.06239942f, 0.02640110f, -0.11204909f, 0.06393739f, 0.00324522f, 0.02329903f, 
    0.06213352f, -0.05185658f, -0.01494747f, -0.02901851f, -0.09195751f, 0.03748807f, 0.08099659f, 0.00777946f, 
    -0.03249054f, 0.06704912f, 0.12437680f, -0.00541061f, -0.03147905f, -0.04075569f, -0.05964477f, -0.05663995f, 
    -0.10336594f, -0.09568310f, -0.08711752f, -0.09179597f, 0.08715749f, 0.03020617f, -0.12551180f, -0.04002039f, 
    -0.09637307f, 0.10489909f, 0.07378388f, -0.00187550f, 0.01664760f, 0.06438506f, 0.11146401f, 0.01752745f, 
    -0.06318925f, 0.08709168f, -0.05661121f, -0.06061932f, 0.03357886f, -0.04683131f, 0.06473005f, 0.02710441f, 
    0.08635096f, 0.11301242f, -0.11208017f, -0.07062753f, -0.07100330f, -0.08687520f, -0.09966508f, -0.00715894f, 
    -0.19262955f, 0.03004580f, 0.32516617f, 0.10270590f, 0.17592075f, -0.33088881f, -0.07329408f, -0.09113321f, 
    0.22589134f, 0.05687165f, -0.03920345f, -0.13078862f, 0.11555876f, -0.25252044f, 0.08973676f, -0.00690316f, 
    -0.05698784f, 0.29052389f, 0.21866249f, -0.08550117f, -0.20187758f, 0.05164604f, -0.48545235f, 0.04493371f, 
    -0.05139781f, -0.12302436f, -0.01603059f, -0.00350586f, 0.02672973f, 0.23608801f, -0.18656047f, -0.08215825f, 
    -0.05413761f, -0.52959681f, 0.14058962f, 0.06648757f, -0.08345488f, -0.06138837f, -0.18953598f, 0.38477841f, 
    0.16510020f, 0.09564292f, 0.09286594f, 0.03888131f, -0.11053421f, 0.08809975f, -0.25140786f, 0.34895754f, 
    0.23887804f, -0.04243923f, 0.08457609f, 0.11273555f, -0.16994438f, 0.06744451f, 0.06280394f, 0.37093869f, 
    0.08056371f, 0.09903781f, -0.11243907f, 0.31401315f, 0.02227446f, -0.39058203f, -0.22108801f, -0.13508254f, 
    0.45336542f, -0.27000359f, 0.13258080f, 0.00988066f, -0.02797663f, 0.09646469f, 0.03765437f, 0.22962992f, 
    -0.00662582f, 0.11614006f, -0.10151137f, 0.34904736f, -0.03184977f, -0.06069702f, 0.09356894f, -0.24774088f, 
    -0.09451316f, -0.09918328f, -0.17473587f, 0.05528504f, 0.02420004f, -0.08882117f, -0.22780465f, 0.17151268f, 
    -0.03268984f, -0.08779489f, 0.02970282f, -0.35106447f, -0.02069230f, -0.19202149f, 0.06284250f, 0.04894924f, 
    -0.12662406f, 0.28216571f, -0.08267856f, 0.23865204f, -0.07978839f, 0.05820966f, 0.19347158f, -0.03087429f, 
    -0.14544839f, -0.13929325f, 0.36719853f, 0.33384356f, 0.19081400f, 0.00894321f, 0.03934992f, -0.57372910f, 
    -0.24576406f, -0.04887195f, -0.05673788f, -0.16000938f, 0.18212633f, 0.06386529f, -0.09024108f, -0.05923786f, 
    0.14189030f, 0.13958395f, 0.24504888f, -0.06679751f, -0.19640192f, -0.08290952f, 0.18430002f, 0.00611538f, 
    0.09417463f, 0.20912279f, 0.17130770f, 0.10785332f, 0.04903572f, -0.24802783f, 0.05615415f, 0.01659439f, 
    -0.13191371f, -0.20558858f, 0.27078095f, -0.26450258f, -0.09387481f, 0.31265792f, 0.08381939f, -0.12148052f, 
    -0.01252194f, 0.24952990f, -0.08222512f, 0.08962756f, 0.11600485f, -0.04455948f, -0.21332091f, 0.21317576f, 
    -0.10828046f, 0.11796746f, 0.07769659f, 0.38538763f, -0.06649668f, -0.08558269f, 0.51289928f, 0.04006828f, 
    0.11171503f, -0.23661235f, 0.15123309f, -0.17487299f, -0.07860944f, -0.15819612f, 0.04607661f, -0.13549130f, 
    0.07587953f, 0.29008299f, -0.02463888f, -0.16223782f, -0.09337092f, 0.05568067f, -0.04156683f, -0.07606163f, 
    -0.03058018f, 0.06965793f, -0.07738777f, 0.25342393f, -0.31110176f, 0.11192430f, -0.28447297f, -0.11694908f, 
    0.29783660f, -0.53424150f, 0.09099492f, -0.25595170f, 0.03752755f, 0.36151311f, -0.07179096f, -0.26257718f, 
    -0.18831211f, -0.20191215f, 0.02337638f, -0.04925209f, 0.08864354f, 0.12250412f, 0.00202941f, -0.02287672f, 
    0.16445976f, 0.12881871f, -0.30156016f, 0.14759423f, 0.03882041f, -0.36434206f, -0.04034042f, 0.37659001f, 
    0.04977906f, -0.02819748f, -0.08370568f, -0.00011774f, -0.25451231f, -0.10904577f, 0.00894790f, -0.37578267f, 
    -0.08095688f, -0.01365018f, -0.04199187f, -0.10330928f, 0.28981304f, 0.08803040f, 0.07790721f, 0.09391782f, 
    -0.02658528f, 0.37780029f, 0.01427992f, 0.23320568f, -0.05782585f, -0.07121456f, 0.30113620f, 0.05436324f, 
    -0.01683073f, -0.13531317f, 0.34961465f, -0.10735373f, 0.16928969f, 0.05245325f, 0.03475923f, 0.23957355f, 
    -0.16341680f, -0.19474109f, -0.01851105f, -0.06915503f, 0.57214969f, 0.09787606f, 0.57939994f, 0.15884250f, 
    -0.23514035f, -0.36668989f, -0.32676160f, 0.28746814f, 0.02534717f, -0.00319410f, -0.29483977f, -0.13823964f, 
    0.10992616f, -0.22673918f, 0.19282812f, -0.11276209f, -0.07146792f, -0.01783998f, -0.11566984f, 0.05562252f, 
    0.18590663f, 0.29714656f, 0.23808341f, 0.05749556f, -0.22521488f, -0.08112314f, -0.02388249f, -0.24408002f, 
    0.03061008f, 0.17111877f, 0.41478685f, 0.10881669f, 0.17786796f, 0.00006617f, -0.37912419f, -0.01295107f, 
    0.15819412f, -0.02121575f, 0.06005403f, 0.06544284f, -0.19818717f, -0.21474472f, 0.17344171f, -0.11632793f, 
    -0.18062209f, -0.28682214f, 0.19841337f, -0.10090157f, -0.10644452f, -0.12154031f, -0.11891560f, 0.21520425f, 
    0.44170633f, 0.42801139f, 0.28399858f, -0.34665245f, 0.21442604f, -0.12345053f, -0.25585625f, 0.17901978f, 
    -0.20411216f, -0.11315697f, -0.09354758f, 0.07479055f, -0.01822541f, 0.24818774f, -0.12855092f, 0.45165175f, 
    -0.30481336f, 0.11131123f, -0.20453422f, 0.10429655f, -0.03808473f, -0.23150276f, 0.70083117f, 0.35474262f, 
    -0.02030214f, -0.04941911f, -0.10152465f, 0.03557989f, -0.03287183f, 0.03503649f, 0.12126669f, -0.00986990f, 
    -0.11731809f, -0.15180871f, -0.09197459f, 0.02313599f, 0.03824455f, -0.11039662f, -0.01521311f, -0.00320932f, 
    0.04921041f, 0.03747991f, 0.03805679f, 0.05720340f, 0.03419566f, 0.04226753f, -0.10924644f, 0.02680302f, 
    -0.02528008f, -0.00088277f, 0.01709796f, -0.02968659f, -0.13302606f, 0.01587589f, -0.06337021f, 0.08401105f, 
    -0.12381917f, 0.07103344f, 0.06745122f, -0.09422180f, 0.01396142f, -0.11023346f, -0.06842949f, -0.08533019f, 
    0.01584698f, -0.09362207f, 0.04189488f, -0.01722815f, -0.05989043f, -0.10227273f, -0.08534110f, -0.05434033f, 
    -0.04785389f, 0.10581975f, 0.11244171f, 0.00914142f, 0.02259070f, -0.13246670f, -0.13725823f, -0.11274120f, 
    0.09284502f, 0.02426638f, 0.00268199f, 0.11426929f, 0.05755527f, 0.05635213f, 0.02290365f, -0.07186732f, 
    0.03755473f, -0.16040987f, -0.12895574f, -0.00716698f, -0.29275352f, -0.10340139f, 0.04054630f, 0.06140039f, 
    -0.02852391f, 0.04242491f, -0.14333761f, 0.10293473f, 0.03478686f, 0.00022183f, -0.05231580f, 0.41864622f, 
    0.10289080f, 0.06194518f, -0.27594501f, 0.15237401f, -0.28339776f, -0.09149458f, -0.32814747f, 0.15783173f, 
    -0.46116266f, 0.09767871f, 0.08678959f, -0.28138682f, 0.14060338f, -0.23582645f, -0.39298347f, -0.00203389f, 
    0.04659683f, 0.01274305f, -0.23601961f, 0.03565519f, 0.08378570f, 0.01625470f, 0.62676924f, -0.08701178f, 
    -0.15998372f, -0.03117199f, 0.44771078f, -0.19457202f, 0.13656390f, 0.28805399f, 0.14420140f, 0.08471034f, 
    -0.17672554f, -0.01207141f, 0.08430117f, 0.10761664f, 0.37969825f, 0.17164241f, 0.43532005f, -0.07825875f, 
    0.03183701f, -0.11799221f, -0.05727469f, 0.19507729f, 0.01396089f, 0.28409883f, 0.12249328f, -0.23297155f, 
    0.28853178f, 0.07386413f, 0.20990306f, -0.06207279f, 0.04032976f, 0.22207902f, 0.05166480f, 0.09507672f, 
    0.05390179f, -0.13807875f, 0.07930215f, -0.04405366f, -0.06301555f, -0.19364233f, 0.21166529f, -0.33767110f, 
    0.22104253f, 0.26533583f, 0.18403152f, -0.01036168f, 0.07134384f, 0.06694771f, 0.07516244f, 0.17682104f, 
    0.17437364f, 0.01577514f, -0.06941287f, 0.18446721f, -0.31266519f, 0.07776105f, 0.33144298f, 0.05691118f, 
    0.02640953f, 0.00590079f, -0.10067143f, 0.04076180f, -0.01919013f, -0.15566814f, -0.12021203f, 0.12834482f, 
    0.22353411f, 0.26816419f, 0.29555276f, 0.09988955f, -0.32083550f, 0.04833082f, -0.11167102f, 0.15588877f, 
    0.04704254f, -0.03654769f, 0.01133420f, -0.01553029f, -0.20620689f, 0.19618884f, -0.05972408f, 0.28621322f, 
    -0.08017922f, 0.13813031f, -0.03547187f, 0.16934849f, -0.24914347f, -0.10446577f, -0.25696585f, -0.18115121f, 
    -0.00663395f, 0.01182587f, 0.05463684f, 0.06596692f, 0.00247075f, -0.03358907f, -0.05550171f, -0.01403132f, 
    -0.04249081f, -0.12281221f, -0.06868471f, 0.07225524f, -0.02296376f, -0.00718886f, -0.02055445f, -0.07412276f, 
    0.07640851f, 0.00638475f, 0.03597710f, -0.06179862f, -0.01887286f, -0.05643408f, -0.12139066f, 0.02056849f, 
    0.06003524f, -0.03131716f, 0.02567628f, -0.10985918f, -0.10914440f, 0.03678779f, -0.07258366f, -0.12132432f, 
    0.08535524f, 0.03338221f, -0.07788700f, -0.00596054f, -0.06509684f, -0.05039409f, -0.08232665f, -0.01410395f, 
    -0.00310172f, -0.07256912f, -0.03490679f, -0.04833160f, -0.06103039f, 0.00621209f, 0.04075985f, -0.01393479f, 
    0.01257610f, 0.10574791f, 0.04966411f, -0.06222869f, 0.06064631f, 0.01278040f, -0.06827475f, -0.01686153f, 
    -0.11775209f, -0.03635676f, -0.02369627f, 0.07975675f, -0.07718839f, 0.01210360f, 0.09563653f, -0.04466261f, 
    0.25217178f, -0.27202442f, 0.07306889f, -0.10412852f, -0.57873768f, 0.07129031f, -0.03450923f, 0.14432196f, 
    0.07026619f, 0.10855975f, -0.26912242f, 0.08911397f, 0.08896613f, -0.00185783f, 0.09654361f, 0.68170726f, 
    0.06338855f, 0.10526099f, -0.23274611f, -0.02046762f, -0.26104727f, -0.01062475f, -0.37366658f, 0.33204654f, 
    -0.50803220f, -0.10722037f, 0.09571984f, -0.21807182f, -0.25041071f, -0.65572059f, -0.29896295f, 0.11692980f, 
    0.09742992f, 0.21138687f, -0.21695995f, 0.04027481f, -0.05036695f, 0.15817361f, 0.59437430f, -0.08751015f, 
    0.31880856f, 0.43472496f, 0.27501658f, -0.23600587f, 0.37561741f, 0.32004526f, -0.00251551f, -0.00140565f, 
    -0.56823409f, -0.07852112f, -0.13386862f, 0.08853190f, 0.41242939f, 0.17771505f, 0.21364480f, 0.14301573f, 
    -0.00598068f, -0.11093755f, -0.05840745f, -0.09876096f, -0.07900429f, 0.45331541f, -0.06889352f, -0.36105499f, 
    0.06819442f, -0.03484213f, -0.02111164f, -0.01498902f, 0.05304320f, 0.09186552f, -0.04588208f, -0.05271012f, 
    -0.02503133f, -0.08106393f, -0.08018735f, 0.04868639f, -0.11423568f, -0.09466522f, -0.15432037f, 0.05411475f, 
    -0.05699679f, -0.15365955f, 0.02024135f, -0.04959546f, -0.03611444f, 0.06587352f, -0.05788543f, -0.02081924f, 
    -0.00799572f, -0.00612402f, -0.03144971f, 0.08763213f, -0.02255132f, -0.08446173f, 0.05236156f, -0.07876816f, 
    0.01950366f, -0.11041452f, -0.02375390f, -0.16621622f, 0.00738463f, -0.17796765f, 0.01379809f, -0.15962236f, 
    -0.06220672f, -0.11396184f, -0.12211692f, -0.09318376f, 0.02136109f, -0.04515335f, 0.00418938f, -0.02211751f, 
    0.06256797f, 0.00795262f, 0.10143876f, -0.14334378f, -0.15496619f, 0.01321175f, -0.08441938f, -0.01120000f, 
    -0.02550437f, 0.14629012f, -0.07351445f, -0.00260420f, -0.10420813f, -0.01441078f, 0.01688322f, -0.03294430f, 
    0.00506478f, 0.02399384f, 0.19848722f, 0.06299333f, 0.12934218f, 0.14841004f, 0.12856320f, 0.12874985f, 
    0.01284219f, 0.09788908f, -0.04691795f, 0.14011897f, 0.15569425f, -0.22695853f, -0.06951860f, 0.19298220f, 
    -0.11494423f, 0.11742721f, 0.07718454f, 0.12778534f, 0.20104082f, -0.06422982f, -0.12874825f, -0.02349030f, 
    -0.02711830f, -0.01550601f, 0.06362396f, -0.00078678f, 0.20955312f, 0.05748221f, -0.16340275f, -0.05880881f, 
    0.09204589f, 0.07676946f, -0.04928371f, 0.01431287f, -0.07591016f, -0.02814718f, 0.18321505f, 0.12068133f, 
    0.04957125f, -0.15620057f, 0.30588409f, 0.12998442f, -0.06328948f, -0.12323020f, 0.00743646f, 0.32989484f, 
    -0.16170810f, -0.13206039f, -0.07138211f, -0.11591531f, 0.25596169f, 0.03404778f, 0.25684661f, 0.22327740f, 
    0.00183722f, 0.54814506f, -0.11366745f, 0.19785735f, -0.09159096f, -0.17489146f, 0.40099159f, -0.19480987f, 
    0.06257779f, 0.04638501f, -0.06508542f, 0.05440643f, -0.05933574f, 0.01229169f, -0.08887767f, 0.27764982f, 
    0.10118238f, 0.18804589f, -0.05333668f, 0.34624541f, -0.06030907f, -0.20100880f, 0.22666429f, 0.14016762f, 
    0.06456129f, -0.01631026f, 0.44093087f, -0.04998017f, -0.05888122f, -0.11007760f, 0.02106280f, 0.42563552f, 
    -0.02849583f, -0.04542741f, -0.04423979f, -0.17016779f, -0.19929190f, -0.22834474f, -0.10736957f, 0.03373367f, 
    -0.34219372f, 0.23373699f, -0.19951831f, 0.21428970f, 0.11456814f, -0.17838113f, 0.14065588f, 0.16816911f, 
    -0.12125054f, 0.06814525f, 0.64917409f, -0.05827773f, 0.30860534f, -0.01924516f, 0.07124962f, 0.21567707f, 
    -0.19342425f, -0.01114986f, 0.10148672f, 0.08337158f, 0.13645744f, 0.55313426f, -0.08176621f, 0.53284186f, 
    -0.20218582f, -0.12207513f, -0.17864549f, 0.12518053f, -0.39072341f, -0.10035782f, -0.07163043f, 0.02140911f, 
    -0.03362926f, 0.02850476f, -0.17262535f, -0.07877531f, 0.08058100f, 0.10013581f, 0.09533107f, 0.11599601f, 
    0.09503511f, -0.01773751f, -0.07582539f, 0.11330291f, 0.01071019f, 0.24669893f, -0.19756544f, 0.36821088f, 
    -0.15454096f, -0.22049734f, -0.10462303f, 0.27486932f, 0.04168388f, 0.00892144f, 0.15777649f, -0.25321272f, 
    -0.00194561f, 0.11086307f, -0.00992500f, -0.11918572f, 0.13952845f, -0.31637841f, -0.32415491f, -0.02490187f, 
    0.21427365f, 0.24553160f, -0.10808840f, -0.09468897f, 0.06969681f, 0.20657559f, 0.22187768f, -0.25386867f, 
    -0.11823282f, -0.14530261f, -0.07572573f, -0.06410668f, 0.18413036f, 0.23156586f, 0.14547518f, -0.35766858f, 
    -0.06991480f, -0.09861638f, 0.01850399f, 0.15867089f, 0.29435641f, -0.23939297f, 0.14932600f, -0.34217796f, 
    0.16968046f, -0.18674399f, 0.03725446f, 0.05919536f, 0.31129119f, 0.32478210f, 0.35652697f, 0.05069293f, 
    0.08591732f, 0.05166379f, 0.01039216f, -0.10934903f, 0.27339604f, 0.06062107f, -0.11064374f, -0.13440324f, 
    0.07418364f, 0.08306207f, -0.13346195f, -0.16887778f, -0.01001194f, 0.03370529f, 0.00272689f, 0.11451444f, 
    0.02912026f, -0.09849618f, 0.38946375f, -0.02711995f, 0.25629306f, -0.11803003f, -0.07613848f, 0.30481645f, 
    0.03724238f, -0.09856980f, 0.07758534f, 0.21205489f, -0.20549078f, -0.20240609f, 0.09978133f, -0.06160063f, 
    0.16168541f, -0.39923978f, -0.04465777f, -0.02466621f, -0.07050973f, 0.12404070f, -0.16080090f, 0.06897707f, 
    0.48935425f, 0.13621169f, -0.20082419f, 0.07880096f, 0.09665611f, -0.19736998f, -0.06177886f, -0.14985739f, 
    -0.20509146f, -0.06675193f, -0.06003868f, 0.14111984f, -0.01101341f, 0.24841757f, -0.19442914f, 0.24656621f, 
    -0.14413220f, 0.21398410f, 0.33750409f, -0.24002035f, -0.00207635f, 0.04354410f, 0.09703912f, 0.22344615f, 
    -0.13658817f, 0.06137948f, -0.11144754f, 0.11072741f, -0.11046875f, -0.11231542f, 0.12275288f, -0.10532950f, 
    -0.13823627f, -0.01075813f, -0.04925584f, 0.00949214f, -0.04480657f, -0.06515338f, 0.05785640f, -0.11937036f, 
    -0.06230660f, 0.08766568f, -0.11494745f, -0.03094400f, -0.02299228f, -0.08541583f, 0.03729882f, -0.10043518f, 
    -0.01767397f, -0.03905784f, -0.08182521f, 0.03261401f, -0.06514727f, -0.11357743f, -0.09463830f, -0.06676996f, 
    -0.08981141f, 0.09768434f, 0.01876379f, -0.12434541f, 0.04470448f, -0.13584815f, -0.09375963f, 0.00425153f, 
    0.04459645f, 0.05760176f, 0.07883958f, -0.11982391f, -0.07728005f, -0.01566103f, -0.11146218f, -0.04952044f, 
    0.01790389f, -0.03373082f, -0.11472684f, -0.00182971f, 0.04486768f, -0.12740588f, 0.11684661f, -0.01200970f, 
    0.02504029f, 0.02902743f, 0.10147091f, 0.01720726f, 0.07433403f, -0.01072928f, -0.07521926f, 0.01102439f, 
    -0.11258654f, -0.19824192f, 0.36664733f, 0.07629797f, -0.42300713f, -0.21569446f, 0.02554943f, -0.52595687f, 
    0.18338378f, -0.29740444f, -0.06840563f, -0.48731107f, -0.18961197f, 0.20210223f, -0.09148182f, -0.28879330f, 
    0.03798681f, 0.35360935f, -0.00373428f, 0.12991843f, -0.23302911f, -0.11197147f, -0.06212181f, -0.19556509f, 
    0.37222743f, -0.06116889f, -0.09105039f, -0.08575805f, 0.13444138f, 0.09193580f, 0.19971138f, -0.03928724f, 
    0.38412192f, -0.52747053f, 0.18684229f, -0.11548983f, 0.04575403f, 0.28670847f, -0.24147597f, -0.04434305f, 
    0.11113980f, 0.21507065f, -0.38874766f, 0.27502120f, -0.38431978f, 0.17206430f, -0.28828257f, 0.17698242f, 
    0.17210461f, -0.04772019f, 0.05500373f, 0.28284216f, -0.01818932f, -0.43867281f, 0.02896574f, -0.11144359f, 
    0.10674769f, -0.17308579f, 0.19038968f, 0.27781007f, 0.27696747f, 0.19350345f, 0.23560226f, -0.15912844f, 
    -0.33520782f, -0.01184889f, -0.10620127f, -0.12207038f, 0.09329470f, 0.02092846f, -0.11230693f, 0.01664350f, 
    0.16181082f, -0.04542893f, -0.05823183f, -0.08915745f, -0.02739962f, 0.24769992f, -0.15501778f, 0.14428219f, 
    -0.00829160f, -0.14985852f, 0.10545340f, 0.17503643f, 0.05050239f, 0.10384123f, -0.11340459f, -0.31911165f, 
    0.05509044f, -0.01117262f, 0.03381294f, -0.17524205f, 0.38261855f, -0.09396483f, 0.01209528f, 0.08916995f, 
    0.27144569f, -0.15670997f, -0.02956328f, 0.05255074f, 0.08563050f, 0.12481269f, 0.16418917f, -0.13430849f, 
    -0.30522743f, -0.30742729f, -0.05919304f, 0.08795213f, 0.04172782f, 0.17825925f, 0.33477864f, -0.31192410f, 
    0.04891737f, 0.06419057f, 0.02080645f, 0.17475173f, 0.01660004f, -0.05398367f, 0.34458786f, -0.24894685f, 
    0.17988101f, -0.28556773f, 0.37973666f, 0.11811348f, 0.33603805f, 0.20851712f, 0.48280659f, -0.05569753f, 
    -0.19814527f, -0.01003204f, -0.32626840f, -0.12961322f, -0.32897082f, -0.19820556f, -0.07095980f, 0.05362100f, 
    0.05524390f, 0.18913306f, 0.04336684f, 0.08008595f, 0.00827599f, -0.13984248f, 0.27053493f, 0.05465696f, 
    0.03896385f, 0.24938914f, 0.27089891f, 0.04216013f, -0.14741796f, -0.03528746f, -0.24972218f, 0.04607005f, 
    0.01762893f, -0.10389183f, -0.02853632f, -0.14170091f, -0.08031254f, -0.01731333f, -0.37923497f, 0.06026114f, 
    -0.38339692f, 0.31701371f, -0.24571691f, -0.08483673f, 0.01008822f, -0.19096941f, 0.36979455f, 0.21728547f, 
    -0.61737978f, -0.12798682f, 0.32590008f, -0.10157715f, 0.34858817f, 0.10196740f, 0.17707302f, -0.03227749f, 
    -0.21787220f, -0.06547929f, 0.05375318f, 0.08482697f, 0.15311894f, 0.27755898f, -0.25422481f, -0.02747836f, 
    -0.32178065f, -0.04103310f, -0.37505031f, 0.19012974f, 0.03621741f, 0.12701815f, -0.02464769f, 0.19305290f, 
    -0.13709120f, 0.17404437f, 0.29833108f, -0.01585975f, -0.18067747f, -0.21786650f, 0.09435319f, -0.07369160f, 
    0.23531941f, -0.01815258f, -0.02188220f, 0.10077707f, 0.07843659f, -0.17202587f, 0.09684899f, 0.12501948f, 
    0.04743917f, 0.28771853f, 0.01581050f, -0.09764013f, -0.44682327f, 0.04445131f, -0.53022414f, 0.18469277f, 
    -0.34123370f, -0.00746046f, 0.10252551f, -0.29813686f, 0.02352392f, 0.39955965f, -0.05824961f, -0.01341201f, 
    0.00432131f, -0.39896426f, 0.23043495f, 0.14423083f, -0.09765535f, 0.09416152f, -0.27690005f, 0.49828652f, 
    0.08518646f, -0.00904365f, -0.09437618f, 0.17768763f, -0.12822375f, 0.00365276f, -0.13796061f, 0.38732693f, 
    0.53525740f, -0.05493149f, -0.11314088f, 0.16628300f, -0.25595719f, -0.00215728f, 0.25116733f, 0.33909091f, 
    0.00297485f, 0.04458252f, -0.19779572f, 0.39110613f, -0.21158858f, -0.31673172f, 0.01686542f, -0.53584880f, 
    -0.04518379f, 0.47557294f, -0.13004251f, 0.01845983f, -0.09006707f, -0.28364912f, 0.01415058f, -0.23905416f, 
    0.09589022f, 0.08168891f, 0.33001572f, -0.32528996f, -0.05366943f, 0.44828603f, 0.04608339f, 0.12955566f, 
    -0.08702233f, 0.18017447f, 0.19133972f, 0.01969633f, 0.03167260f, 0.02700254f, -0.12523875f, 0.12853992f, 
    -0.15046008f, -0.09827334f, -0.11921597f, 0.75795698f, -0.05907139f, -0.22360221f, 0.45248207f, 0.11879907f, 
    0.02667537f, -0.31496644f, -0.04285693f, -0.17372866f, -0.03189553f, -0.04606514f, 0.20764151f, -0.12108802f, 
    0.17919025f, 0.39739323f, -0.18132792f, -0.60711998f, 0.24829812f, 0.14730917f, 0.13176388f, -0.01641764f, 
    -0.14114803f, 0.08529553f, 0.05946865f, 0.30002233f, -0.12079325f, 0.11247893f, -0.00238273f, -0.09232888f, 
    0.11382240f, -0.17380917f, 0.09494265f, -0.30618054f, 0.35129711f, 0.43372568f, -0.42725185f, -0.02930527f, 
    -0.14407358f, 0.02419249f, 0.13758992f, -0.07251237f, -0.25058442f, -0.46451071f, -0.06487795f, -0.12615965f, 
    0.31021610f, -0.05979682f, 0.06164450f, 0.08647916f, 0.40530443f, 0.33263886f, -0.13016228f, 0.23674324f, 
    -0.12620389f, -0.21239552f, -0.12064360f, 0.22252223f, -0.31543940f, 0.04121092f, 0.04577392f, 0.04355679f, 
    -0.28902960f, -0.04452926f, -0.00946695f, -0.47240016f, 0.25487360f, 0.10832048f, -0.67560601f, -0.10544132f, 
    0.29861265f, 0.16463284f, 0.37779662f, 0.10344946f, -0.15064391f, 0.17969535f, -0.07646725f, 0.40719855f, 
    -0.09789734f, -0.13357848f, -0.31188211f, 0.00220778f, 0.06285875f, 0.42323339f, -0.15375789f, -0.10164644f, 
    0.23882018f, 0.02897209f, 0.12371095f, 0.29682165f, -0.21684355f, -0.25471342f, 0.14859073f, 0.06923584f, 
    0.06397048f, -0.33567613f, 0.21262769f, 0.09143949f, 0.20416282f, 0.34473947f, -0.02011446f, 0.17133847f, 
    0.24394798f, 0.01557449f, -0.22629586f, -0.11372151f, -0.30088452f, 0.02568707f, 0.12292464f, 0.25267017f, 
    0.06684355f, 0.12364769f, -0.01632022f, 0.07284693f, 0.04437707f, -0.05659663f, 0.20649554f, -0.03169517f, 
    0.06095893f, -0.20769607f, -0.49740490f, 0.06554581f, 0.01623276f, -0.01935387f, -0.04478928f, 0.20564122f, 
    -0.09838822f, 0.05376117f, -0.09823380f, -0.34390977f, -0.37257510f, 0.00753801f, -0.04104752f, -0.06225499f, 
    0.15770222f, 0.23809727f, 0.02225958f, 0.22425070f, -0.00910543f, -0.12769800f, 0.16596906f, -0.01131479f, 
    -0.70922345f, -0.04396599f, 0.10960981f, 0.21657212f, 0.15300429f, 0.20959635f, -0.06410041f, -0.54391032f, 
    -0.16785234f, 0.08276807f, -0.04137746f, -0.15961301f, 0.16390465f, 0.09702458f, -0.02983393f, 0.12460501f, 
    -0.00747879f, 0.36576411f, 0.01473983f, 0.01997624f, 0.31912553f, 0.11433807f, 0.06477689f, 0.12033023f, 
    -0.05084329f, 0.06407826f, 0.00665037f, 0.09065460f, -0.00718222f, -0.10113844f, -0.04561865f, 0.05272752f, 
    0.06933236f, 0.02689109f, 0.16239056f, 0.23778981f, -0.02237129f, -0.09948955f, 0.01584578f, 0.10340464f, 
    -0.09186711f, 0.07774004f, -0.22528103f, 0.11086859f, -0.16461954f, -0.00295319f, 0.10647124f, 0.08256966f, 
    -0.06050111f, -0.04395594f, -0.04685227f, -0.18282218f, -0.04058994f, 0.15257210f, -0.33518475f, -0.06807003f, 
    -0.24366428f, -0.09634474f, 0.29473326f, 0.37640741f, 0.07043784f, 0.06517251f, -0.07755026f, 0.42760193f, 
    -0.22917971f, -0.03831821f, -0.10293819f, 0.14984570f, 0.03404716f, 0.24550909f, -0.00746150f, -0.06669752f, 
    0.25349671f, -0.01781281f, -0.02413615f, -0.07427559f, -0.21770403f, 0.00709555f, -0.02134556f, 0.09905391f, 
    0.23492451f, 0.25495183f, 0.16432498f, 0.14521962f, -0.10653798f, 0.00532917f, 0.46893430f, -0.14105201f, 
    -0.36067644f, -0.32020944f, 0.19580539f, -0.00939555f, -0.18571782f, 0.32211959f, 0.09126130f, -0.05591315f, 
    0.00923753f, -0.01177668f, -0.17724112f, -0.40195119f, 0.02622805f, 0.04986932f, -0.38112551f, -0.32763186f, 
    0.05812632f, -0.12465028f, 0.34574685f, -0.04677083f, -0.04957917f, -0.02697380f, -0.01213071f, -0.29846591f, 
    0.41764715f, -0.11163388f, -0.00865898f, 0.28849062f, 0.14061497f, -0.21005563f, 0.52611035f, 0.09240217f, 
    0.38468158f, -0.02205533f, 0.06727482f, -0.15769172f, 0.15800367f, 0.24836980f, -0.07290676f, -0.16287722f, 
    0.41687804f, 0.20370764f, -0.25480938f, 0.03232550f, 0.17854013f, -0.10745884f, -0.24154697f, 0.04875318f, 
    -0.15869331f, 0.01765116f, -0.07334831f, 0.16677962f, 0.37512687f, -0.38295543f, 0.05018637f, -0.19481523f, 
    -0.32967433f, 0.06895001f, -0.00662984f, 0.02365624f, 0.37909320f, 0.03545485f, 0.37786263f, 0.40754640f, 
    0.22237627f, 0.11939242f, -0.07213134f, 0.09247625f, -0.35702747f, 0.14853954f, -0.10048850f, 0.02626323f, 
    -0.01983798f, 0.04962869f, 0.05592875f, -0.04897458f, 0.07825202f, 0.23938866f, 0.08929289f, 0.34527087f, 
    0.03478800f, -0.09061572f, -0.22420405f, 0.03766963f, -0.28864568f, 0.06389497f, -0.11601983f, 0.37693182f, 
    -0.30684105f, 0.09413947f, 0.08584747f, 0.14613706f, -0.01385857f, -0.12675795f, 0.31089398f, -0.05063548f, 
    0.13064316f, 0.23381874f, 0.07952862f, 0.10873336f, -0.00176867f, 0.09914167f, 0.01356139f, -0.00841961f, 
    0.40521285f, 0.31948757f, -0.12213156f, -0.08576228f, 0.12723613f, 0.03098703f, -0.06003100f, -0.01580853f, 
    -0.33507782f, 0.04837000f, 0.06102171f, 0.00971847f, 0.28922766f, 0.07095500f, -0.06268201f, 0.00345036f, 
    -0.16735755f, 0.34327611f, 0.11809891f, -0.18416870f, 0.16458526f, 0.32195067f, 0.46879560f, -0.14645554f, 
    -0.03806074f, -0.06091474f, -0.10607404f, 0.11565964f, -0.03708191f, 0.04357061f, 0.07058915f, -0.02892203f, 
    -0.17976075f, 0.01181288f, 0.01772163f, -0.00957660f, -0.02235709f, -0.04658017f, -0.12316895f, -0.06701238f, 
    -0.01084451f, -0.07349530f, -0.11308052f, -0.10951599f, 0.06698831f, -0.11487147f, -0.04655187f, -0.11501358f, 
    -0.10299461f, -0.12421778f, -0.12126334f, -0.07158266f, -0.12833814f, -0.02426263f, -0.02134174f, -0.05867832f, 
    -0.00142029f, 0.08568233f, 0.01575535f, -0.15774174f, -0.04271059f, -0.11396314f, -0.03532442f, 0.02039675f, 
    0.00631617f, -0.08920922f, -0.01437412f, -0.14716636f, -0.07395531f, -0.01895025f, 0.05524151f, -0.17828809f, 
    0.08880173f, 0.04661008f, 0.03413509f, -0.15381005f, -0.01576956f, 0.07419229f, -0.10301454f, 0.03916763f, 
    -0.14620271f, 0.08191802f, -0.10711507f, 0.04896832f, 0.04555462f, -0.06366377f, 0.03724096f, -0.01486420f, 
    0.18257622f, 0.29458126f, 0.05984347f, 0.10507340f, -0.41033587f, -0.19064029f, 0.08673891f, -0.23317808f, 
    -0.04898426f, -0.09188267f, 0.01915690f, -0.01533320f, 0.16248158f, 0.12473160f, 0.05494683f, 0.28194034f, 
    -0.16326189f, 0.01180071f, -0.11691574f, 0.15473393f, 0.02511803f, 0.03976423f, 0.15757960f, 0.03042992f, 
    -0.40708548f, -0.08357449f, -0.07307268f, -0.07350757f, -0.08406928f, -0.20563422f, -0.23398611f, 0.02322989f, 
    -0.01866855f, 0.11115814f, -0.10160519f, 0.19814685f, -0.11863085f, 0.12085854f, 0.63927794f, 0.02741637f, 
    0.05089688f, 0.29275236f, 0.09189267f, -0.47569817f, 0.37939227f, 0.31608900f, -0.05635000f, 0.10806807f, 
    -0.19861336f, -0.12480047f, 0.11437756f, 0.20187524f, 0.21872795f, 0.24335267f, 0.06270586f, -0.03990919f, 
    0.42467269f, 0.08753234f, -0.14847420f, -0.12716192f, 0.12572217f, 0.39945766f, 0.37017697f, 0.04513590f, 
    -0.04860349f, 0.08869198f, -0.03566484f, 0.11645903f, -0.04750289f, 0.04395547f, 0.03860587f, -0.05752257f, 
    0.05334814f, 0.09682766f, -0.13160855f, 0.03156004f, -0.03046520f, -0.06485413f, 0.00342008f, 0.09112399f, 
    -0.06505910f, 0.00628607f, -0.11765202f, 0.00450841f, -0.03529049f, -0.06772323f, -0.06787404f, -0.06721529f, 
    0.00928794f, -0.07719457f, -0.01230758f, 0.01677212f, 0.08491103f, 0.04413949f, 0.04513642f, 0.04881433f, 
    -0.12807460f, -0.13394928f, -0.11488149f, -0.06328009f, 0.08510493f, 0.01863589f, -0.06772264f, 0.03140530f, 
    0.00276109f, 0.05119742f, 0.01982231f, 0.03356445f, -0.04426892f, -0.12182226f, 0.08327904f, -0.01950624f, 
    0.02050095f, 0.09395060f, -0.04709478f, -0.10186693f, 0.01066206f, -0.09053779f, 0.00355867f, 0.06200123f, 
    -0.03517114f, -0.11779800f, -0.06483114f, -0.03733690f, 0.07426635f, 0.03560880f, -0.02478823f, -0.14741303f, 
    0.03922783f, 0.09066629f, 0.28280306f, -0.02907328f, -0.08294041f, -0.11836382f, 0.04237558f, -0.14513049f, 
    0.10376011f, 0.15458527f, 0.02367049f, 0.12381072f, -0.26223657f, -0.06300667f, -0.09974276f, 0.45166361f, 
    0.03481029f, -0.00250270f, 0.13036510f, -0.05559118f, -0.09602614f, -0.05246663f, 0.15303889f, 0.24968255f, 
    -0.22518581f, -0.01021948f, 0.04171775f, 0.00915746f, -0.17491686f, 0.09638567f, -0.03514874f, -0.01620012f, 
    -0.05627665f, 0.01285231f, 0.06120853f, 0.30988052f, -0.09521289f, 0.19187410f, -0.11672141f, 0.26994836f, 
    0.31037739f, 0.01431530f, 0.09866740f, 0.02663563f, 0.12425739f, 0.02766078f, -0.11823952f, 0.26879302f, 
    -0.06274928f, 0.01982513f, 0.09247769f, -0.04023832f, -0.12773699f, -0.07553927f, 0.14792870f, 0.39320490f, 
    0.10129937f, -0.22124071f, -0.11746404f, 0.16042039f, -0.15326287f, -0.20799465f, 0.02349693f, -0.11559992f, 
    -0.03791422f, -0.08976929f, -0.10977924f, -0.00048470f, 0.05025907f, -0.01487035f, 0.04668136f, 0.07092229f, 
    0.04207423f, 0.03415002f, 0.01087599f, -0.11397110f, -0.09067729f, -0.04496953f, 0.10360003f, 0.01745632f, 
    -0.10787064f, -0.12303960f, -0.08466390f, -0.07536250f, -0.10130137f, -0.11716479f, -0.04976591f, 0.01433866f, 
    -0.09548809f, -0.05314435f, 0.12210122f, -0.10040180f, -0.10770456f, 0.07852516f, 0.06068577f, 0.11666569f, 
    -0.10996418f, -0.03029788f, -0.00151412f, -0.08359720f, 0.11724780f, -0.11740105f, 0.02440611f, -0.00447576f, 
    0.10607553f, -0.04468177f, -0.12120612f, -0.05010436f, 0.03869657f, -0.10668683f, -0.00572622f, -0.10793260f, 
    -0.04591753f, -0.08482687f, 0.04223338f, -0.04853739f, -0.06604494f, 0.07585359f, -0.04873914f, 0.06556930f, 
    -0.08667600f, 0.02945757f, 0.05206451f, -0.00477076f, 0.06839882f, -0.05385357f, 0.09496617f, -0.04516102f, 
    0.60425407f, 0.03693311f, 0.27325451f, -0.06674746f, -0.52291828f, -0.21801998f, 0.07038935f, -0.15317799f, 
    -0.17501992f, -0.24288835f, 0.02427285f, -0.04208634f, 0.26298290f, 0.05989106f, 0.23615520f, -0.12002003f, 
    0.00325287f, 0.30269659f, -0.30768263f, -0.13467251f, -0.35090542f, -0.10017645f, 0.02758403f, 0.07349449f, 
    0.00351264f, 0.02165267f, -0.13789666f, 0.32953057f, -0.28588700f, 0.19263080f, 0.44664612f, 0.10685814f, 
    0.19357778f, -0.15610218f, 0.23774713f, 0.24193253f, -0.07412446f, -0.10666214f, 0.03628232f, 0.09255265f, 
    0.11915906f, 0.36891076f, 0.01745762f, -0.10036829f, -0.51423013f, 0.13522346f, -0.40189749f, 0.21121453f, 
    0.01440467f, -0.04499612f, -0.00894453f, 0.04896495f, -0.15661095f, -0.16272955f, 0.04427071f, -0.21479061f, 
    -0.01818056f, 0.39303136f, -0.13789593f, 0.05141573f, -0.03908621f, -0.04148704f, 0.23186164f, -0.43937647f, 
    0.17400719f, -0.45997950f, 0.23285946f, 0.04180679f, -0.06555135f, 0.13827507f, -0.00926353f, -0.06669217f, 
    0.12880699f, 0.05353176f, -0.15010239f, 0.12327414f, 0.10546161f, -0.30964711f, -0.07174598f, 0.25667766f, 
    0.01272635f, 0.01877856f, 0.26407260f, -0.06452280f, 0.11410470f, 0.04064775f, -0.37455106f, -0.04778633f, 
    0.26482394f, 0.04561147f, 0.07571226f, -0.01392198f, -0.08106840f, 0.00508521f, -0.15412845f, -0.08342192f, 
    -0.08851811f, -0.16497670f, 0.04814503f, 0.04040894f, -0.04236595f, 0.14036258f, 0.05503312f, 0.15401521f, 
    0.50544149f, -0.01588283f, 0.38334233f, 0.25899583f, -0.09032625f, -0.15804884f, -0.35639328f, 0.31305927f, 
    -0.25363982f, 0.05211981f, 0.09224999f, 0.08568316f, 0.15931778f, 0.10869818f, -0.02759514f, 0.37697050f, 
    -0.26732126f, 0.00638433f, -0.00374618f, 0.17250647f, -0.04205162f, -0.18874989f, 0.17337731f, 0.19453190f, 
    -0.09701861f, 0.03260794f, -0.00134051f, -0.12174781f, -0.04794864f, -0.00035185f, -0.00578558f, -0.03236051f, 
    -0.09496167f, 0.00944481f, -0.03691809f, 0.04563862f, 0.03714193f, -0.12801647f, -0.01967282f, 0.06634074f, 
    -0.06498191f, -0.08395877f, 0.07659341f, -0.12229985f, 0.06603042f, 0.08152419f, 0.00523894f, 0.09963732f, 
    -0.13585426f, -0.01627485f, 0.11000763f, 0.09742426f, -0.03617915f, 0.09287973f, 0.05382735f, 0.07220206f, 
    0.04899302f, -0.11751053f, -0.06751456f, -0.13487022f, 0.07820548f, -0.02919443f, -0.03083608f, 0.08349705f, 
    0.02813179f, 0.06687950f, 0.01793414f, 0.01442018f, -0.06721246f, -0.02812515f, -0.01803148f, 0.00831437f, 
    -0.02551776f, 0.04655826f, 0.08798417f, -0.06724372f, 0.00269881f, 0.04387313f, -0.06370240f, -0.11334485f, 
    -0.02686509f, 0.00899246f, 0.03639345f, -0.03724610f, -0.10615540f, 0.02984804f, -0.03525782f, -0.11564949f, 
    -0.05590586f, -0.21450759f, 0.26079193f, 0.07543813f, 0.09782941f, -0.35962456f, 0.02751370f, -0.17305663f, 
    0.28520703f, -0.11922874f, -0.15353978f, -0.03731108f, -0.18527332f, 0.21456219f, -0.06449226f, -0.06133818f, 
    0.06693893f, -0.16064818f, 0.37960657f, 0.23552716f, 0.03013978f, -0.00555705f, 0.01183896f, 0.07527198f, 
    -0.15730207f, 0.11420950f, 0.05682687f, -0.73750579f, 0.27374363f, -0.03628135f, -0.63023239f, -0.02419958f, 
    0.31087068f, -0.14250718f, 0.34352764f, 0.05764271f, -0.10804097f, 0.54626286f, -0.27781844f, 0.05156717f, 
    0.11887111f, -0.01075084f, -0.21115103f, 0.05829335f, 0.11287372f, 0.27076811f, -0.04421282f, -0.05289289f, 
    0.32003337f, 0.09446274f, -0.02375438f, 0.29763791f, -0.06411444f, -0.20276214f, 0.18050165f, 0.02333486f, 
    0.00438513f, -0.08300629f, 0.48560539f, 0.09767480f, 0.38365838f, 0.19429478f, -0.21078877f, 0.14850274f, 
    -0.04151202f, 0.18766777f, 0.11488076f, -0.11331303f, 0.04133870f, 0.12894106f, 0.05297419f, 0.04491611f, 
    0.22507741f, 0.24906936f, 0.05248848f, 0.05451269f, -0.01497273f, -0.17051350f, 0.32846552f, -0.18850332f, 
    0.02246207f, 0.11914218f, 0.46455929f, -0.12799981f, 0.02351465f, -0.01078621f, -0.02195816f, 0.21527889f, 
    0.14351533f, -0.10605559f, 0.05141480f, -0.20195639f, -0.19212475f, 0.01776584f, -0.22403555f, 0.03002687f, 
    -0.28940484f, -0.00942628f, -0.11958188f, -0.13681395f, -0.12304233f, -0.16559736f, -0.03426469f, 0.27785507f, 
    0.21313369f, 0.27180117f, 0.29520959f, -0.01223648f, 0.12115808f, 0.01358220f, -0.09649882f, 0.35809591f, 
    -0.00654959f, 0.04229450f, -0.02033029f, 0.15158959f, 0.16840915f, 0.67299348f, -0.16350242f, 0.47584122f, 
    -0.23111956f, 0.41318819f, -0.07477107f, 0.10083018f, -0.26412550f, -0.16718611f, 0.33054239f, 0.15129216f, 
    0.60826331f, -0.05036082f, 0.31338456f, -0.01433992f, -0.33881438f, 0.22204259f, 0.10720674f, 0.20746049f, 
    -0.14006022f, 0.01619456f, 0.00244187f, 0.09691203f, -0.01232668f, 0.03554199f, 0.19333041f, 0.05089407f, 
    -0.06006573f, 0.19005573f, -0.14567304f, -0.03756090f, -0.10907967f, 0.00380192f, -0.11663967f, 0.35062730f, 
    -0.61280483f, 0.00818257f, 0.05711988f, -0.45756197f, -0.30646169f, -0.09250142f, -0.15250809f, -0.01488393f, 
    0.08908019f, 0.01324654f, -0.00466612f, 0.16483609f, 0.01133171f, 0.20850851f, 0.18869577f, -0.05465483f, 
    0.52145261f, 0.39577329f, 0.28059289f, -0.03409603f, 0.04017555f, 0.26912487f, -0.20928276f, 0.14647482f, 
    -0.38065994f, 0.10973769f, 0.00670245f, 0.07953736f, 0.31880471f, 0.10820021f, 0.08862694f, 0.10524594f, 
    0.27091417f, 0.07094946f, -0.00531697f, -0.10255586f, -0.23094960f, 0.07342389f, 0.10816396f, -0.59022295f, 
    -0.28266534f, 0.22500321f, -0.12134504f, -0.06740894f, 0.09196619f, -0.09105003f, -0.01165200f, -0.05147661f, 
    0.26427501f, 0.04276443f, 0.11066613f, -0.13818954f, 0.04431603f, 0.08367343f, 0.05793896f, 0.11143290f, 
    0.08084343f, 0.17341252f, 0.36609510f, 0.03729056f, -0.01119895f, -0.04198230f, -0.27951857f, -0.01051267f, 
    0.25611797f, -0.02569871f, -0.07881378f, -0.18098003f, 0.26736027f, -0.06893667f, -0.12782082f, 0.00290661f, 
    0.07995601f, -0.29746732f, 0.03271997f, -0.22794721f, 0.02094008f, 0.26273075f, 0.19747761f, 0.07082774f, 
    -0.15820915f, -0.07023536f, -0.11825608f, -0.10457093f, 0.04661337f, -0.00692288f, 0.13963889f, 0.01084727f, 
    0.08185305f, -0.03391630f, 0.07764691f, 0.24946485f, -0.07483824f, 0.16969737f, -0.03871047f, -0.00839289f, 
    -0.21279645f, -0.23442872f, 0.12924451f, 0.22800969f, 0.24119261f, 0.40715098f, 0.14575207f, -0.01478306f, 
    0.02718282f, -0.11908275f, 0.26024687f, -0.09828622f, -0.17394519f, -0.36885455f, -0.00887608f, -0.01319517f, 
    0.12213480f, 0.15679650f, 0.02006018f, 0.19979243f, -0.10700961f, -0.22539485f, 0.16792373f, 0.12820944f, 
    0.00466892f, 0.05205376f, 0.13588370f, 0.13224663f, -0.25010172f, 0.06366891f, -0.18955295f, 0.17643572f, 
    -0.37902361f, -0.08821104f, 0.04944084f, -0.65954107f, -0.05008867f, -0.12238092f, -0.91363603f, 0.02831150f, 
    -0.27929521f, 0.13043791f, 0.06226415f, 0.09157662f, 0.11213605f, 0.03914262f, 0.09869874f, 0.18334144f, 
    -0.08949429f, -0.10122970f, 0.41379011f, -0.40846568f, 0.38739926f, 0.19002798f, -0.09282576f, 0.14780252f, 
    -0.03375219f, -0.07276816f, -0.12627102f, 0.03086788f, 0.07157837f, 0.36120310f, 0.11809282f, 0.40257236f, 
    0.17527212f, 0.19509682f, -0.05802586f, 0.10641488f, -0.06425099f, -0.03291683f, 0.40388218f, -0.08047320f, 
    -0.18190321f, 0.18647818f, -0.14235872f, 0.03524983f, -0.10107759f, -0.49165064f, 0.01741555f, -0.25059941f, 
    0.18607789f, -0.00715066f, -0.02824667f, -0.04624505f, 0.09315496f, 0.24095675f, 0.15127143f, -0.04887850f, 
    0.07621261f, 0.13068922f, 0.43862391f, 0.27488449f, 0.02424674f, 0.00811781f, -0.22337234f, 0.03970297f, 
    -0.39468014f, 0.04280668f, -0.04818220f, 0.05777802f, 0.10161709f, -0.49451107f, -0.74055541f, -0.05360509f, 
    -0.04774745f, -0.29852349f, -0.15912250f, -0.09833651f, -0.07647285f, -0.15684436f, 0.22303189f, -0.24684918f, 
    -0.12265778f, 0.00949534f, 0.08322158f, -0.57455099f, 0.21134910f, 0.15318263f, 0.12809779f, -0.03254481f, 
    -0.07120096f, -0.13234715f, 0.12026037f, 0.28859794f, -0.18559660f, 0.17116123f, -0.11687087f, -0.11557511f, 
    0.31674233f, -0.22502699f, 0.16002689f, -0.03775029f, 0.26391733f, 0.44913262f, 0.02184412f, -0.03574620f, 
    0.08646914f, 0.02434387f, 0.09859326f, 0.02007261f, -0.35062060f, -0.65726590f, 0.10412900f, -0.24071845f, 
    0.02922083f, -0.11816418f, -0.20203273f, -0.04441742f, -0.01893383f, 0.13564260f, -0.03684021f, 0.34388703f, 
    0.01583998f, 0.00553827f, -0.31277230f, 0.17825736f, -0.62706858f, 0.02192847f, 0.65693343f, 0.18264914f, 
    -0.69790703f, -0.07050654f, -0.05201767f, -0.15821944f, -0.04138099f, -0.00808235f, -0.56380481f, -0.01041551f, 
    0.06598592f, 0.00045004f, 0.32732210f, 0.32292101f, 0.04963392f, 0.36842564f, 0.00359950f, 0.40556303f, 
    0.34186086f, 0.24850339f, -0.18104838f, -0.19509515f, 0.17046124f, 0.26902369f, -0.13152507f, 0.00358268f, 
    0.22579092f, 0.05796330f, -0.07193507f, 0.15335806f, -0.00211209f, -0.07458919f, 0.18347417f, 0.12009703f, 
    -0.01878296f, -0.15050361f, 0.01398311f, 0.11109097f, 0.07206698f, 0.24472590f, 0.05112631f, -0.56810820f, 
    0.26751718f, 0.14532334f, -0.02480443f, -0.04288273f, 0.13848086f, 0.22739919f, -0.05051853f, 0.17261544f, 
    -0.07910131f, 0.02883829f, 0.27447563f, 0.01919411f, 0.20936617f, -0.05041561f, 0.26829183f, -0.08938854f, 
    0.04290991f, 0.09433921f, -0.10295609f, -0.06400388f, 0.19228290f, -0.10451166f, 0.06279321f, 0.30843008f, 
    -0.03144841f, -0.00693768f, 0.12369864f, 0.02994665f, -0.31984016f, 0.15920007f, -0.36139387f, 0.04877946f, 
    -0.05309549f, -0.25352600f, -0.25004220f, -0.27947482f, 0.02325112f, 0.06961219f, 0.42244858f, 0.09673240f, 
    -0.26967475f, 0.08156842f, 0.22994156f, -0.05766703f, -0.01937433f, -0.44803664f, -0.08308113f, 0.01344774f, 
    -0.22704864f, -0.00221634f, -0.06138839f, -0.03419859f, 0.50973094f, 0.28319475f, 0.14269081f, 0.14370276f, 
    -0.08050916f, 0.82020354f, -0.05932731f, 0.04575983f, -0.63589126f, -0.01494162f, 0.71285951f, -0.02463695f, 
    0.00262946f, 0.06866272f, 0.08208741f, 0.12304439f, 0.00967537f, -0.14680880f, 0.09458308f, -0.06694964f, 
    0.03109729f, 0.04679026f, -0.13332166f, -0.02329037f, 0.06656811f, -0.16787721f, -0.00405639f, 0.09242195f, 
    -0.04980260f, -0.12983871f, -0.04427704f, -0.12031943f, -0.08012582f, 0.11522436f, -0.01466228f, -0.06318802f, 
    -0.03604936f, -0.03777288f, -0.09801874f, -0.01227278f, 0.05022607f, -0.09189264f, 0.07563736f, -0.11515087f, 
    -0.02831007f, 0.07711551f, -0.03123065f, -0.08335388f, 0.03522833f, -0.01686797f, -0.11955351f, -0.03288315f, 
    -0.10526936f, -0.05995229f, -0.12366551f, -0.12496755f, -0.08594787f, -0.12093752f, -0.03444972f, 0.04229080f, 
    0.03234503f, -0.11610857f, 0.05014467f, -0.01630589f, -0.09415753f, 0.02838176f, 0.05163628f, -0.09658240f, 
    -0.06629648f, -0.03220893f, -0.01059160f, 0.04453254f, -0.05145068f, 0.08235116f, -0.04268083f, -0.02984455f, 
    0.09623867f, -0.13857149f, -0.08748551f, -0.09243725f, -0.42698285f, -0.23610349f, 0.00318276f, -0.00305866f, 
    0.04565149f, 0.30671206f, -0.10031924f, 0.02632814f, -0.00370958f, 0.03868794f, 0.25715107f, 0.37558421f, 
    -0.08433669f, 0.08386832f, 0.02620453f, 0.19536734f, -0.08853166f, 0.02562885f, -0.02590732f, 0.45432079f, 
    -0.48243621f, -0.10932440f, -0.09266406f, -0.40746814f, -0.08829799f, -0.44237608f, -0.53864783f, 0.00357130f, 
    -0.19457665f, -0.07858025f, -0.20568994f, 0.10920176f, -0.00497962f, 0.02696517f, 0.26419926f, 0.06115485f, 
    0.08524842f, 0.26439050f, 0.12386740f, 0.06715880f, 0.43652657f, 0.26344997f, 0.25047454f, -0.02614083f, 
    -0.37315848f, -0.02819800f, -0.08151449f, -0.05449663f, -0.00853279f, -0.01537168f, -0.08327597f, 0.22874752f, 
    -0.15484135f, -0.20666836f, -0.04494284f, -0.23007618f, -0.03998363f, 0.19092692f, 0.04245285f, -0.01798906f, 
    0.05649702f, 0.15033388f, 0.01263954f, -0.03855366f, 0.02685231f, -0.57457054f, -0.04137822f, 0.01972337f, 
    -0.00024806f, 0.18151456f, 0.26590711f, 0.05703494f, 0.16082674f, 0.04441217f, 0.11588670f, -0.33057830f, 
    -0.06270619f, 0.27552658f, 0.75263184f, 0.23520471f, 0.21837713f, -0.11716963f, -0.42323422f, 0.12889221f, 
    -0.04364519f, 0.11062171f, 0.03267951f, -0.19016591f, 0.03958455f, 0.05857546f, -0.41188911f, 0.03746922f, 
    -0.15890752f, -0.40887246f, 0.03731390f, -0.05487211f, -0.06103083f, -0.55275106f, 0.02651814f, -0.07436363f, 
    -0.20479536f, 0.04561723f, 0.08990077f, -0.56975019f, 0.06098175f, 0.00221468f, 0.15062675f, -0.07493746f, 
    -0.01480236f, -0.03915885f, 0.08823702f, 0.28063491f, -0.44308242f, 0.30271634f, -0.30610886f, 0.18005906f, 
    0.39783385f, -0.44145986f, 0.02729971f, -0.15950064f, -0.12973486f, 0.09389410f, -0.37729606f, 0.22622856f, 
    0.11099959f, 0.23523255f, -0.27918223f, 0.11779253f, 0.22296819f, 0.00258952f, -0.03341126f, -0.01907906f, 
    -0.24597423f, -0.04391611f, 0.13046256f, -0.03328288f, -0.05115467f, 0.32556379f, 0.21584004f, 0.06950085f, 
    0.08793259f, 0.00732040f, 0.28843367f, 0.03177972f, 0.11970130f, -0.08679269f, 0.05229619f, 0.29017758f, 
    -0.02241995f, 0.05006695f, 0.10359053f, -0.03936905f, -0.01766326f, 0.06940326f, 0.02193132f, -0.11137793f, 
    -0.20357208f, -0.27628669f, 0.16660815f, -0.17204818f, 0.06924145f, -0.08368704f, -0.00544716f, 0.22152214f, 
    -0.08397783f, -0.06487298f, -0.21584243f, -0.00469516f, 0.03791762f, 0.08837301f, 0.12998429f, -0.63997084f, 
    0.22109503f, -0.12059227f, -0.13079315f, 0.13332617f, -0.92492425f, 0.20537090f, -0.47250637f, 0.06523840f, 
    0.29020891f, 0.24839096f, 0.33660010f, -0.52042985f, -0.30485290f, -0.01443437f, 0.01065095f, 0.00074052f, 
    0.16861817f, 0.12210096f, 0.08054506f, 0.10272551f, -0.26018396f, -0.00518241f, 0.11783414f, 0.06695104f, 
    0.13809401f, 0.09451496f, 0.19760318f, 0.11907010f, -0.11523954f, 0.03699094f, 0.40353480f, 0.25291538f, 
    -0.03254827f, 0.07381480f, -0.21863686f, -0.02078479f, -0.19298075f, -0.07717209f, -0.10398401f, 0.30564639f, 
    -0.13957013f, -0.03141537f, -0.07023827f, 0.20023906f, -0.22307743f, 0.13784137f, -0.00655739f, -0.08429343f, 
    0.00022675f, 0.10659976f, 0.12558118f, 0.35945725f, 0.05295266f, -0.07394054f, 0.13630582f, 0.47549146f, 
    -0.11718117f, 0.17214788f, 0.16294344f, -0.02170597f, 0.26113656f, -0.02478920f, -0.14219968f, 0.35765746f, 
    0.09163009f, -0.03832373f, 0.07824752f, 0.06681223f, -0.22256947f, -0.02924844f, 0.08956462f, 0.23903576f, 
    -0.11707429f, 0.20851208f, -0.19016664f, 0.16054477f, -0.17016599f, -0.00224809f, -0.23714727f, -0.23911367f, 
    -0.32395330f, 0.13961485f, -0.14324218f, 0.09258825f, -0.03300212f, -0.09657272f, -0.02032093f, 0.00942280f, 
    0.31074938f, 0.05678770f, 0.00966269f, -0.06873205f, 0.04927844f, 0.07412765f, -0.00880755f, 0.17423843f, 
    0.05467062f, 0.03777325f, 0.24437140f, 0.13958807f, 0.01972475f, -0.09748645f, -0.07468536f, 0.00263758f, 
    0.13563284f, -0.04247634f, 0.09873404f, -0.26797768f, 0.27416435f, -0.11255895f, -0.63760144f, 0.04703111f, 
    0.25362337f, -0.11614859f, 0.08850429f, -0.16498029f, -0.01097902f, 0.30486241f, -0.05660893f, 0.05089232f, 
    -0.21012129f, -0.29073080f, -0.13441867f, -0.00429645f, 0.03058409f, 0.13795833f, -0.10966261f, 0.13488346f, 
    0.18869330f, -0.04736309f, 0.01510177f, 0.09803657f, -0.16946766f, -0.00004849f, 0.02655382f, -0.07380277f, 
    -0.10900349f, 0.30141583f, 0.21075477f, 0.27449813f, 0.42904207f, 0.19260459f, 0.43016678f, -0.15939142f, 
    -0.13054746f, 0.02076638f, -0.02779238f, -0.11173409f, -0.01983435f, -0.11631326f, -0.06774874f, -0.13968638f, 
    0.02629074f, 0.07828087f, -0.12376031f, -0.13400254f, 0.05803438f, -0.01027045f, 0.04610322f, -0.02172069f, 
    -0.06725588f, 0.01139357f, -0.14282268f, 0.06687701f, -0.05455871f, 0.00365718f, -0.04361703f, -0.08175454f, 
    -0.09296753f, 0.00023942f, 0.07307501f, -0.10281010f, -0.10175328f, -0.07447595f, -0.09829728f, 0.06860745f, 
    -0.14093681f, 0.02870980f, -0.06961958f, -0.12384310f, 0.09223065f, 0.08830718f, 0.07356717f, -0.11122308f, 
    0.02579608f, -0.10035200f, -0.06906014f, 0.02792266f, -0.00159327f, -0.01839943f, 0.02863615f, 0.10578756f, 
    0.03566356f, 0.11816560f, 0.09718634f, 0.01624583f, -0.04314133f, 0.04961127f, -0.02081378f, -0.12811379f, 
    -0.13166387f, 0.00274804f, -0.08733425f, 0.03877303f, -0.06071823f, -0.00503790f, -0.03954230f, -0.07215513f, 
    0.09100825f, 0.09617604f, -0.19908069f, -0.08056739f, 0.22570585f, -0.07381861f, -0.05857660f, -0.03632179f, 
    0.08347441f, -0.07527065f, 0.20754354f, -0.12413678f, 0.06015933f, 0.24059042f, -0.12429733f, -0.39072886f, 
    0.09879810f, 0.03604266f, 0.29062775f, 0.12622581f, 0.21146418f, -0.02561298f, 0.08943257f, -0.09682201f, 
    -0.07843833f, 0.01337679f, 0.02562167f, -0.20361547f, 0.07909357f, 0.05821218f, -0.01307057f, 0.03401117f, 
    0.02648403f, -0.02368847f, 0.02290813f, -0.21832518f, 0.03728973f, 0.11746681f, 0.00622231f, -0.24153729f, 
    -0.14856099f, -0.21739326f, -0.19961546f, -0.02546359f, -0.10969191f, 0.22007306f, 0.33386433f, -0.23579730f, 
    0.16478501f, 0.05165442f, 0.14560550f, 0.07982964f, -0.20989206f, 0.13861473f, -0.25416833f, -0.02274326f, 
    0.46050090f, -0.47937605f, 0.24057281f, -0.07280927f, 0.19235933f, 0.28401020f, -0.34789029f, 0.33164907f, 
    -0.00882255f, 0.18591970f, 0.17347030f, -0.01339835f, 0.15062185f, -0.80879885f, 0.08216190f, -0.35528177f, 
    -0.00105784f, 0.22025001f, 0.06323710f, 0.00057707f, 0.20148131f, -0.19920006f, 0.02244227f, 0.13255224f, 
    0.03932051f, 0.21335925f, 0.36417294f, 0.01870298f, 0.01491094f, -0.08017521f, 0.14864640f, 0.07018853f, 
    -0.04303433f, -0.10010399f, -0.02087539f, -0.16276695f, -0.33305547f, -0.10900787f, -0.81930995f, -0.03462996f, 
    -0.38265654f, -0.59515560f, 0.00489193f, 0.10183027f, 0.08471169f, -0.02294071f, 0.10283187f, 0.24274705f, 
    0.31544828f, 0.34411168f, 0.26400056f, -0.72335291f, 0.13117971f, -0.02400565f, -0.23964231f, 0.29263449f, 
    -0.16031690f, 0.07406233f, 0.00179414f, 0.22142453f, 0.07330393f, 0.28579557f, -0.06362141f, 0.36508286f, 
    -0.08508336f, 0.07191778f, -0.12402749f, 0.06204537f, -0.38037708f, -0.10511480f, -0.40246516f, 0.07630081f, 
    0.09520095f, 0.04046993f, 0.38839725f, 0.10545410f, 0.30809900f, 0.14659621f, -0.02534501f, 0.02366718f, 
    0.16307878f, 0.05204018f, 0.08361255f, 0.19705436f, 0.06940559f, -0.30163011f, 0.00336377f, -0.01890000f, 
    0.09035531f, 0.04231282f, 0.43742156f, -0.10805268f, 0.21116225f, -0.05875149f, 0.09356740f, 0.27675614f, 
    0.13098305f, -0.09714118f, -0.06050922f, -0.36555687f, -0.19878201f, -0.06510321f, -0.34914842f, -0.08659794f, 
    -0.04350819f, -0.09518635f, -0.04180053f, -0.05245095f, 0.06296087f, -0.04045443f, -0.00225236f, 0.13443014f, 
    0.35297462f, 0.12248970f, 0.23305017f, 0.24420482f, 0.06320430f, -0.05003538f, -0.17196362f, 0.32770911f, 
    -0.23978528f, 0.02314909f, -0.05552069f, -0.07884985f, 0.16402109f, 0.20847273f, 0.04286352f, 0.42429513f, 
    -0.12630059f, 0.35731900f, 0.04662456f, 0.20018283f, -0.04141282f, -0.25815168f, 0.33168194f, 0.14235266f, 
    0.21253590f, 0.10026749f, 0.46943116f, -0.04766837f, 0.15166695f, -0.01057142f, 0.05452759f, 0.06627847f, 
    0.20130986f, -0.01270436f, 0.16423872f, 0.00047385f, 0.02606432f, -0.14883417f, 0.14848341f, -0.33656913f, 
    0.05714546f, 0.30762067f, 0.26149443f, -0.08339768f, 0.05931194f, -0.03708653f, -0.13649221f, 0.17894040f, 
    -0.00132316f, 0.11577630f, 0.09417497f, -0.51446140f, 0.01380628f, 0.19276476f, -0.51632255f, -0.00939777f, 
    0.03357913f, -0.39878923f, 0.21328351f, -0.03875495f, 0.06734108f, 0.11827583f, -0.52190924f, 0.27278602f, 
    0.07815488f, -0.07102925f, -0.04289665f, -0.04574131f, -0.26166490f, -0.02829037f, -0.20283486f, 0.16543002f, 
    0.36245722f, 0.00195004f, 0.00296188f, 0.27059078f, -0.56012672f, 0.28146014f, -0.11224394f, 0.25320724f, 
    0.19511408f, 0.60799378f, 0.27131817f, 0.30259252f, -0.12526238f, -0.10603415f, 0.43329027f, -0.18356764f, 
    0.07380745f, 0.07184217f, 0.01141140f, -0.03457828f, 0.16147229f, -0.09590672f, -0.04275112f, -0.05297108f, 
    0.01983652f, 0.11687992f, 0.13273300f, 0.09842466f, 0.14192335f, 0.17119510f, 0.25535136f, -0.18346484f, 
    0.04902836f, 0.23019944f, -0.00905366f, 0.19397435f, 0.22110555f, 0.01730073f, -0.35511553f, 0.27113092f, 
    -0.11296184f, -0.01620166f, -0.04111246f, -0.13959247f, 0.11860813f, -0.01157415f, -0.01867814f, -0.11716214f, 
    -0.11201987f, -0.08582225f, 0.06611033f, 0.07036190f, 0.01272076f, -0.05064490f, -0.04732351f, 0.08253688f, 
    -0.45233634f, -0.00009965f, -0.08340740f, -0.05571984f, -0.09083012f, 0.18892254f, 0.31353551f, -0.25698620f, 
    0.16159810f, -0.09975865f, 0.06367481f, 0.02049037f, -0.39480320f, 0.21553181f, -0.22159141f, -0.04601805f, 
    0.43529293f, -0.20289245f, 0.13116631f, 0.07729371f, 0.17606190f, 0.12901770f, -0.21911131f, -0.09423038f, 
    0.30598170f, 0.15966557f, -0.33010402f, -0.11268611f, -0.10522866f, 0.00587002f, 0.08425888f, 0.11049370f, 
    -0.13818693f, 0.17677522f, 0.11332185f, 0.20132314f, -0.12913415f, 0.24194863f, 0.16525626f, -0.02653678f, 
    -0.12763342f, -0.19480780f, -0.41094959f, 0.21768834f, 0.01131550f, 0.09819974f, -0.32775593f, 0.18562426f, 
    -0.10208563f, 0.07391956f, 0.07370064f, -0.13474797f, -0.01721550f, -0.03787396f, -0.08982422f, 0.02449111f, 
    -0.04423628f, 0.04201882f, 0.02320659f, 0.19557607f, 0.01538946f, -0.17700414f, 0.19454567f, -0.21972191f, 
    -0.51295269f, 0.16685560f, -0.07677844f, 0.19554411f, 0.02855442f, 0.17094690f, 0.18028562f, -0.61957663f, 
    0.06349392f, 0.09193534f, -0.04196157f, -0.05104991f, -0.19445764f, 0.22887349f, -0.09660751f, 0.00197344f, 
    0.24330068f, -0.15448205f, 0.16762127f, -0.36345768f, -0.09623901f, 0.20990169f, 0.24443951f, -0.14865433f, 
    0.01061367f, -0.30996245f, 0.28823400f, -0.08844657f, 0.00571091f, -0.32643789f, 0.01731713f, -0.12599905f, 
    0.23736106f, -0.00030525f, -0.22447513f, -0.06878762f, -0.07621177f, -0.17437375f, -0.08578814f, 0.25079432f, 
    0.04967901f, 0.12896404f, 0.08449715f, 0.03666487f, -0.21430193f, -0.07757170f, -0.31866679f, 0.00358819f, 
    0.22175956f, -0.11021942f, -0.13126855f, 0.31798714f, -0.09975802f, -0.08116250f, 0.34980649f, 0.13987143f, 
    0.16215475f, -0.34619424f, -0.01346658f, 0.07603719f, 0.09355918f, 0.13345088f, -0.10333700f, 0.25018832f, 
    0.29071763f, 0.09934254f, 0.08730626f, 0.03966929f, 0.04368980f, 0.14386356f, -0.19883564f, 0.10560320f, 
    -0.08338059f, 0.09684119f, 0.06321205f, 0.12487410f, 0.41083747f, -0.09125023f, 0.05242036f, 0.07585289f, 
    -0.81321830f, -0.12954697f, 0.15843922f, 0.23942401f, 0.25522548f, 0.09033263f, 0.14182889f, -0.26386321f, 
    0.27036902f, 0.00897068f, 0.02860319f, -0.06906821f, -0.16722757f, 0.00471290f, 0.09655938f, 0.12018923f, 
    -0.08723905f, 0.19143409f, -0.07878619f, 0.23265147f, -0.12881047f, -0.13707127f, 0.24667782f, -0.01946288f, 
    0.00356043f, 0.05210746f, -0.23857063f, -0.01171492f, -0.09513369f, -0.04856496f, -0.36977535f, 0.37598708f, 
    -0.33694297f, -0.09298301f, -0.10371502f, -0.46001029f, -0.16683434f, -0.27112472f, -0.07017080f, -0.03552256f, 
    -0.24210942f, 0.06402021f, 0.03802318f, 0.29380083f, 0.09583320f, -0.06790680f, 0.13858369f, 0.12263736f, 
    -0.22026218f, 0.20265117f, 0.26655263f, 0.05005164f, 0.10445614f, 0.16858381f, 0.18789497f, -0.13138680f, 
    -0.21304943f, 0.05996083f, 0.06939233f, 0.09985346f, -0.14015882f, 0.31721050f, -0.07045124f, 0.05422728f, 
    -0.07918626f, -0.40279204f, 0.09309962f, -0.03559480f, -0.40593201f, -0.09404238f, -0.13104630f, -0.40770265f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11819014f, 0.06830343f, 0.05345750f, 0.04780246f, 0.34558958f, 0.06585987f, 0.01278074f, 0.01988142f, 
    0.02862662f, 0.05577657f, 0.09215005f, 0.20617259f, -0.14109522f, 0.14870243f, 0.08319924f, -0.01776527f, 
    0.03112326f, -0.00117367f, 0.12637939f, 0.30893248f, 0.12237453f, 0.16816890f, -0.11679745f, -0.05619771f, 
    0.15624210f, 0.30636993f, 0.17497717f, -0.04748623f, 0.20096822f, 0.36104473f, 0.24766949f, -0.06888257f, 
    0.14331652f, 0.01735616f, 0.00708337f, 0.01988532f, 0.11221768f, 0.00361231f, -0.05162522f, 0.20876771f, 
    -0.12033093f, 0.22374122f, 0.31764299f, 0.02581311f, 0.37951565f, 0.09449343f, -0.05381235f, 0.18098538f, 
    0.54064840f, -0.08901178f, 0.14118837f, -0.12337625f, 0.03586469f, 0.28721324f, 0.42835951f, -0.13186957f, 
    -0.20900254f, 0.04918562f, 0.12961976f, 0.21320508f, 0.10567112f, 0.15704834f, 0.24587050f, 0.15677343f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.08513425f, -0.65827006f, 0.05268044f, -0.09283997f, -0.17261180f, 0.37774456f, 0.09223110f, -0.61786789f, 
    -0.37077320f, 0.10014174f, -0.05602571f, -0.29748097f, -0.00952944f, 0.07103568f, 0.02323641f, 0.08541751f, 
    -0.17858079f, -0.04434483f, -0.32805169f, -0.02425352f, 0.17210956f, 0.08493958f, -0.10189680f, 0.28610295f, 
    0.21955644f, 0.15142237f, -0.67396134f, 0.20984875f, 0.03798267f, 0.16190860f, -0.54871535f, 0.28348956f, 
    0.08210146f, -0.00026940f, 0.09828900f, -0.03057242f, -0.69166690f, 0.02028643f, -0.11444464f, -0.51049083f, 
    -0.07843263f, 0.17564991f, -0.07654251f, -0.40008840f, 0.20853755f, -0.79124016f, 0.17251906f, 0.02192737f, 
    0.21855073f, -0.11390413f, -0.57561523f, 0.12667954f, -0.33245251f, -0.86292064f, 0.10004304f, -0.07784349f, 
    0.28990594f, -0.15715374f, -0.45007923f, -0.08775084f, -0.00144517f, -0.33519307f, 0.04965950f, -0.22782244f, 
    -0.07043757f, -0.06967402f, -0.20986851f, -0.34828827f, 0.13610791f, -0.68562371f, -0.07387389f, 0.16219227f, 
    0.00962000f, -0.08309072f, 0.00277712f, -0.06061381f, -0.07048626f, -0.61452913f, -0.01185099f, 0.09515508f, 
    -0.30108163f, -0.00198174f, 0.09322105f, -0.14639178f, -0.07490760f, 0.25338501f, 0.04155153f, 0.32686910f, 
    0.12728003f, -0.25555277f, 0.19653882f, -0.22873825f, 0.01826633f, -0.16879150f, 0.04992517f, 0.31887046f, 
    -0.21954334f, -0.07504933f, -0.77942598f, -0.02174258f, -0.02729217f, -0.05550468f, 0.45673084f, 0.23467697f, 
    0.08875714f, 0.19436596f, 0.03870561f, -0.56929469f, 0.14482763f, -0.33794475f, -0.62250894f, -0.16735891f, 
    0.44964275f, -0.09313074f, -0.13515952f, -0.28741655f, 0.11581252f, -0.03028448f, 0.22817169f, 0.00740542f, 
    -0.16792631f, -0.62270635f, 0.14195809f, 0.30017975f, 0.11900601f, 0.10398477f, 0.24615070f, -0.12131856f, 
    -0.05112972f, -0.07573108f, 0.32258531f, 0.26308402f, 0.00588681f, -0.08231908f, -0.06946684f, -0.00419439f, 
    -0.11382151f, -0.56979001f, 0.16197258f, 0.05704977f, 0.05901169f, 0.16923183f, 0.08913687f, -0.04689449f, 
    0.29887766f, 0.02144944f, 0.15025404f, 0.03478796f, -0.09373919f, 0.08014061f, 0.02020675f, -0.99495429f, 
    -0.06936472f, -0.23462263f, 0.09402365f, -0.94627905f, -0.24000350f, -0.41768372f, -0.07650478f, -0.01927046f, 
    0.06268009f, -0.09990607f, 0.02256754f, -0.13777351f, 0.11615860f, 0.00449859f, 0.21753490f, 0.27296314f, 
    0.12345486f, -0.16395254f, 0.06770471f, 0.42854905f, -0.22404194f, 0.07427110f, -0.79436320f, 0.18998209f, 
    -0.03739014f, -0.04767893f, 0.02105915f, -0.65488362f, 0.22358705f, -0.01418725f, -0.29848957f, 0.01416574f, 
    0.04356839f, 0.32661980f, 0.25566122f, -0.23375499f, -0.63128287f, -0.91197646f, 0.13778439f, 0.06358084f, 
    -0.05567640f, -0.18541926f, -0.10310183f, 0.18843743f, -0.45408875f, -0.01838703f, -0.09608047f, -0.13156074f, 
    -0.56419182f, 0.08796784f, -0.08952560f, 0.14199571f, -0.07378381f, -0.07519560f, -0.29605478f, 0.00357565f, 
    0.30215412f, -0.08757291f, -0.12484653f, -0.01874330f, 0.09859080f, 0.41276431f, -0.06481249f, -0.10637958f, 
    -0.13416496f, -0.69770271f, -0.31760886f, 0.30169967f, 0.06062670f, -0.37613899f, -0.20913717f, 0.35054719f, 
    0.30710626f, 0.04065532f, 0.15909232f, -0.08868723f, 0.12936564f, 0.07373355f, -0.29090044f, 0.18939133f, 
    -0.00690783f, 0.05618357f, -0.00566184f, 0.23682466f, 0.01220332f, -0.19929259f, -0.06842547f, 0.06422385f, 
    -1.23185039f, -0.00494878f, 0.27988753f, -0.21738124f, -0.11656895f, -0.08174153f, -0.00767362f, -0.11610226f, 
    -0.11663544f, 0.13971813f, 0.08358127f, -0.22121277f, -0.31804651f, -0.12856294f, 0.13262171f, -0.09981073f, 
    -0.08633362f, 0.04854717f, 0.09554076f, 0.01200099f, -0.53581375f, -0.27467248f, -0.01724783f, -0.02802787f, 
    -0.24535191f, -0.07213042f, 0.05849965f, -0.77879316f, 0.02901009f, 0.20827015f, -0.25527066f, -0.05518393f, 
    0.02506148f, 0.04323247f, 0.01004832f, -0.88258910f, 0.19046226f, -0.40254048f, -0.09708592f, 0.00027698f, 
    0.12300882f, -0.29157943f, 0.10379681f, -0.06655147f, 0.26509619f, 0.02621235f, 0.19738226f, -0.33784401f, 
    -0.07311635f, -0.02357111f, 0.20208842f, 0.08552426f, 0.09853192f, 0.10004561f, 0.26537141f, -0.30014965f, 
    0.05933200f, 0.17393525f, -0.89739215f, 0.05514726f, -0.00114184f, -0.12116197f, -0.10414819f, 0.24143521f, 
    0.01846069f, -0.03028658f, -0.18702435f, -0.03424575f, -0.01229349f, -0.07143474f, 0.10504478f, -0.08513588f, 
    0.05282464f, -0.52262837f, -0.35176286f, -0.13582033f, -0.03114301f, 0.05392550f, -0.00073182f, -0.57804382f, 
    0.03179606f, 0.02507570f, 0.08456355f, -0.02732753f, -0.30647066f, -0.45845753f, -0.13467187f, 0.15263328f, 
    0.09194088f, -0.16184108f, -0.01764563f, 0.09339840f, 0.08907932f, -0.33893561f, -0.10834912f, -0.01501083f, 
    -0.88260913f, 0.06107385f, 0.02226987f, 0.23683958f, 0.01123893f, 0.06098871f, -0.00387060f, -0.07614104f, 
    0.02481209f, -0.24318732f, 0.18590575f, -0.17814714f, 0.19816241f, 0.15128097f, 0.07908823f, -0.04004389f, 
    -0.06420660f, -0.09583672f, -0.14894482f, -0.06860920f, 0.12637421f, 0.09159459f, -0.77107269f, 0.14047986f, 
    -0.09558631f, 0.23416813f, 0.01078770f, -0.47010365f, -0.00773766f, 0.13911678f, 0.00466895f, 0.11297559f, 
    -1.34052181f, -0.02817650f, -0.37710503f, 0.31161872f, -0.17892206f, -0.17700711f, 0.12900473f, -0.13182622f, 
    0.21112129f, 0.07426320f, 0.12988943f, 0.17673260f, 0.07975272f, -0.01844557f, -0.03472379f, -0.30288616f, 
    -0.01188282f, -0.02249246f, -0.35066593f, 0.28823540f, 0.20207033f, 0.13953583f, -0.05219401f, -0.36603197f, 
    0.31282431f, -0.12571765f, 0.14618216f, 0.16883528f, 0.04611957f, 0.25982139f, -0.09340945f, -0.08429612f, 
    0.37267223f, -0.12595764f, 0.18104346f, 0.22291906f, 0.00878437f, -0.10903866f, -0.00920976f, -0.38780487f, 
    -0.13582619f, 0.09805390f, -0.48025870f, -0.55923694f, -0.77184707f, 0.33256871f, -0.16121148f, -0.69368136f, 
    -0.00100097f, -0.05935552f, 0.07919673f, 0.05285131f, -0.12843519f, -0.04809810f, -0.03149695f, 0.39989257f, 
    0.10746385f, -0.74318361f, -0.09874910f, 0.29306346f, -0.55167264f, 0.06099383f, -0.21526040f, -0.64249146f, 
    0.26597181f, -0.12670615f, 0.06158651f, -0.32756302f, -0.40952563f, 0.09253908f, -0.43098533f, 0.06597610f, 
    -0.18812232f, -0.39931411f, 0.10035392f, -0.77281290f, -0.15159167f, 0.14414996f, -1.04141808f, 0.09424312f, 
    0.11168211f, -0.13894135f, -0.61284053f, -0.49244538f, 0.13208549f, -0.13709480f, -0.05890206f, -0.18015943f, 
    -0.06603694f, 0.40585414f, -0.64691269f, -0.04152701f, -0.03910435f, 0.42090362f, -0.04135862f, 0.10611111f, 
    0.14958598f, -0.06405612f, -0.11848070f, -0.16247387f, -0.19753018f, -0.03683865f, -0.03883140f, -0.70762390f, 
    0.17185538f, 0.12350793f, -0.01914424f, 0.65987724f, -0.64774877f, -0.40371314f, 0.02197344f, -0.77043432f, 
    -0.11382531f, 0.02188068f, 0.32407954f, 0.02362546f, -0.29460934f, 0.07476433f, -0.20200339f, -0.29267654f, 
    0.07325768f, -0.41261077f, -0.17213321f, -0.22814989f, 0.19337244f, -0.03145883f, 0.58638126f, -0.82761616f, 
    -0.30800343f, -0.12838607f, 0.20020978f, 0.35925254f, 0.18697304f, -0.04951941f, -0.09767829f, 0.01202812f, 
    0.17170632f, -0.14198937f, -0.39740181f, -0.10646974f, 0.17381591f, 0.14287850f, -0.84767878f, 0.09301259f, 
    -0.07938693f, 0.21368466f, -0.58394617f, -0.77559781f, 0.13758987f, 0.23599266f, 0.08862422f, 0.22524746f, 
    -0.25976825f, 0.10610036f, 0.07260867f, 0.26659814f, -0.13070270f, -0.36011013f, 0.23909402f, -0.09130234f, 
    -0.44589531f, 0.01225993f, 0.15195340f, 0.16906989f, -0.60508561f, -0.13886937f, -0.00695423f, -0.41619489f, 
    -0.38842100f, 0.37444898f, 0.05578409f, 0.11584985f, -0.46383950f, -0.12784472f, -0.07106403f, -0.05721422f, 
    -0.80559754f, -0.11314841f, -0.14311378f, -0.12662514f, 0.01364991f, 0.10110369f, -0.34976429f, 0.02226918f, 
    0.02402123f, -0.39660078f, 0.29848063f, -0.61416996f, 0.09179529f, 0.06852940f, -0.17051861f, -0.72928858f, 
    0.34667546f, -0.05254055f, -0.19576922f, 0.25342017f, -0.09052196f, 0.17726138f, -0.09821993f, 0.03314590f, 
    -0.10081080f, 0.36391160f, 0.21590118f, 0.11945385f, -0.02633861f, -0.43045917f, -0.10001521f, -0.23702154f, 
    -0.05569639f, 0.15042499f, -0.00630020f, 0.08912534f, 0.08635183f, -0.08693985f, -0.10685134f, -0.21458676f, 
    0.05441659f, -0.55880111f, 0.13918614f, -0.28209868f, 0.06468305f, 0.27557528f, -0.43479821f, -0.09198682f, 
    0.24662277f, -0.04497226f, -0.00707981f, 0.15230940f, 0.15603462f, -0.52565783f, 0.09082342f, -0.53648388f, 
    -0.05976842f, 0.29570290f, 0.04339978f, -0.23555058f, 0.11281087f, 0.27543280f, 0.18746173f, -0.82129377f, 
    0.14181931f, -0.04845708f, 0.16521803f, 0.08853637f, -0.06564222f, 0.00584707f, -0.47941306f, -0.22648177f, 
    -0.01226818f, -0.13804267f, -0.02463553f, -0.09300273f, 0.01492863f, 0.07859305f, -0.02614731f, 0.14400481f, 
    -0.34759805f, 0.03076836f, 0.17612031f, -0.41097969f, -0.29994369f, 0.12171975f, 0.12269671f, 0.02621635f, 
    -0.51871216f, -0.35626942f, -0.21891710f, -0.48434663f, -0.08390105f, 0.02993234f, -0.05002593f, 0.09940886f, 
    -0.05136294f, 0.04887193f, -0.44105339f, 0.03143550f, -0.32294449f, 0.39588127f, 0.09214988f, 0.15267678f, 
    -0.08788043f, 0.23149700f, -0.35349798f, 0.05600089f, 0.08406533f, -0.48942485f, 0.21557099f, 0.08257335f, 
    -0.34275237f, 0.07184183f, -0.11162280f, -0.19602391f, -0.40715352f, -0.56057030f, -0.03461605f, 0.13541837f, 
    -0.45662802f, -0.20604903f, 0.32479590f, 0.26639724f, 0.03736020f, 0.37077853f, -0.03863303f, -0.04293149f, 
    0.22178911f, 0.02916849f, -0.01579707f, 0.10455729f, 0.07747348f, 0.04256032f, 0.59329486f, -0.04750884f, 
    0.03536752f, -0.18440980f, 0.04790579f, 0.21057756f, -0.29714116f, -0.13206397f, -0.39392343f, 0.15653957f, 
    -0.39033228f, -0.09142508f, -0.45273951f, -0.38237649f, -0.78822011f, 0.16477874f, -0.19783865f, 0.03806245f, 
    -0.75817239f, 0.17330134f, -0.11236279f, 0.21916851f, -0.05990575f, 0.19481127f, -0.15189812f, 0.05157024f, 
    0.05265530f, 0.05905683f, -0.03443925f, 0.13882773f, 0.17101610f, 0.37032115f, -0.02128854f, -0.24272817f, 
    0.26792178f, 0.27637342f, -0.77440494f, 0.15067039f, 0.09896102f, -0.23993902f, 0.09697851f, -0.08877295f, 
    -0.13184427f, -0.07063637f, -0.22481345f, 0.06411523f, -0.62837994f, -0.05455032f, -0.12921271f, 0.13773753f, 
    -0.80939418f, 0.12295749f, -0.29093593f, 0.00407213f, -0.14226738f, 0.18248793f, 0.13962530f, 0.25994888f, 
    -0.10995343f, 0.01721196f, 0.01593829f, 0.00529801f, -0.03735671f, -0.12386994f, 0.05657374f, -0.53420538f, 
    -0.01815237f, -0.25214952f, 0.00109783f, 0.21068791f, -0.30568320f, 0.09791049f, -0.01024899f, -0.02964656f, 
    -0.36546549f, -0.12417394f, 0.20401411f, 0.16132466f, 0.24943544f, 0.12997130f, -0.36834583f, 0.11264771f, 
    -0.11171028f, 0.09841184f, -0.02003972f, -0.05226493f, 0.21014790f, 0.15763201f, -0.40128678f, 0.32795674f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.24789955f, 0.43337780f, 0.04253843f, 0.02802641f, -0.08601383f, -0.10557803f, -0.16960488f, -0.12157878f, 
    0.02566459f, 0.14487110f, -0.00535225f, -0.18825997f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
