#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.89492869f, 0.18610790f, 0.38719112f, -1.05993629f, -0.39517060f, 0.26163399f, 0.34946966f, -0.12953745f, 
    -0.05980957f, 0.40418535f, 0.13389036f, 0.24527098f, -0.01491263f, -0.31403691f, -0.24856885f, 0.38042682f, 
    -0.18798336f, -0.11536999f, -0.22983752f, -0.19940484f, -0.06892069f, 0.16095591f, 0.00511913f, 0.08851915f, 
    -0.07281627f, 0.76941663f, -0.80518866f, -0.42067823f, 0.45955241f, 0.40994617f, -0.39638960f, 0.42171478f, 
    -0.22587356f, -0.00568288f, 0.11447206f, -0.09593555f, 0.11526242f, 0.05250182f, -0.16431908f, 0.06790314f, 
    -0.28499463f, 0.14337666f, -0.13696197f, -0.22492199f, 0.05788119f, 0.08590408f, -0.09357837f, 0.09179553f, 
    0.31619349f, 0.36882523f, -0.20928024f, -0.18813944f, 0.52305037f, 0.29558933f, 0.29411834f, -1.01530707f, 
    -0.67743528f, 0.03963371f, 0.39739877f, 0.42814726f, 0.04182999f, -0.04441533f, -0.08109977f, 0.24481784f, 
    0.15950595f, -0.09475318f, -0.30569318f, 0.28324676f, -0.19019458f, -0.69201392f, -0.04584607f, 0.12867874f, 
    -0.10217604f, 0.23474932f, 0.11611035f, -0.36100963f, -0.43791226f, -0.26333633f, 0.06753595f, -0.04868903f, 
    -0.40104610f, -0.38588881f, -0.47794518f, 0.08599827f, -0.31987914f, 0.05422526f, -0.23353522f, -0.11516257f, 
    0.63647807f, -0.16810599f, -0.30024809f, -0.00939691f, -0.03642109f, -0.26882026f, -0.35139126f, -0.44777098f, 
    -0.16346735f, 0.04448755f, -0.10243238f, -0.20308186f, -0.82791620f, -0.13607036f, 0.83352542f, -0.10367025f, 
    -0.30787331f, 0.23078299f, -0.20593941f, -0.50731200f, -0.15545049f, -0.24015523f, 0.29746783f, -0.35335681f, 
    -0.22605659f, -0.43590626f, -0.37380224f, -0.07968996f, -0.14019981f, 0.05325804f, 0.17604651f, 0.16232410f, 
    0.16142336f, -0.08324012f, -0.32057697f, -0.25121778f, -0.39543855f, 0.26902631f, -0.56858629f, 0.36974260f, 
    1.02774358f, 0.18093684f, 0.14032654f, -0.38657930f, -0.48157474f, 0.00191475f, -0.24368633f, 0.21443678f, 
    -0.31065989f, -0.01772442f, -0.00490983f, 0.32105222f, -0.41199565f, -0.11565533f, 0.35607660f, -0.03954032f, 
    -0.12343358f, 0.26266736f, -0.25493428f, 0.08518010f, 0.13769931f, -0.11547001f, 0.30746996f, -0.12376316f, 
    -0.84132421f, -0.33013818f, 0.14370154f, 0.40671781f, 0.02124608f, 0.24637851f, 0.40503708f, -0.08922982f, 
    0.32937977f, 0.10443444f, 0.27840781f, 0.22520655f, -0.20951758f, 0.17143132f, -0.40771914f, 0.16020790f, 
    -0.27427563f, -0.63795280f, -0.28966159f, 0.36030859f, 0.44281587f, 0.29148498f, 0.20854500f, 0.68062836f, 
    -0.75609040f, -0.38124740f, -0.52338260f, -0.07356933f, -0.37523922f, -0.43329868f, -0.25210932f, 0.18039630f, 
    -0.06025643f, 0.11312917f, 0.39711380f, 0.44309935f, -0.12727459f, -0.14220332f, 0.28500226f, 0.43443194f, 
    -0.17010307f, -0.03454344f, 0.13854027f, 0.05079025f, -0.18768135f, -0.08506627f, -0.18770698f, -0.14504813f, 
    1.23864365f, -0.31718376f, -0.59987438f, -0.61675525f, -0.73593169f, 0.57931435f, 0.21578476f, 0.26734051f, 
    0.05794509f, 0.16765226f, 0.01796060f, 0.04663147f, 0.28581762f, -0.08921561f, -0.21437924f, -0.12439425f, 
    -0.19054657f, 0.27763066f, 0.04905500f, -0.00659791f, 0.21808960f, -0.08338575f, -0.07678450f, 0.08792464f, 
    -0.24151434f, 0.78412747f, 0.68958378f, -0.29506549f, 0.27934587f, -0.43917021f, -0.21592031f, 0.30391413f, 
    0.36624879f, 0.10900657f, -0.01292661f, -0.40507576f, 0.31573251f, 0.20546725f, -0.03592656f, -0.20212106f, 
    0.25986516f, -0.11662254f, -0.26727724f, -0.09118562f, -0.07028226f, -0.13189395f, 0.00455549f, 0.18190520f, 
    -0.21541870f, 0.03355283f, -0.54354388f, -0.59746069f, -0.75006580f, -0.06396938f, -0.13833585f, 0.20759259f, 
    0.46497315f, 0.40832835f, 0.03175209f, 0.37649983f, 0.18130487f, 0.48086879f, -0.06713714f, 0.18427564f, 
    -0.20536752f, -0.31051618f, -0.02662551f, -0.19979489f, 0.18058701f, 0.31830770f, 0.42152765f, -0.10655270f, 
    0.09662696f, 0.00632085f, -0.10392777f, 0.41454032f, 0.59069377f, 0.26938325f, 0.31872302f, 0.13675006f, 
    -0.13570924f, -0.35581160f, -0.07599765f, 0.39506519f, 0.15900207f, -0.21696004f, 0.06517807f, 0.07229251f, 
    -0.05868171f, -0.28302288f, -0.12537971f, 0.17289062f, 0.03846567f, 0.07134217f, 0.26571655f, -0.25364032f, 
    -0.26272887f, -0.09176761f, -0.35433614f, -0.65377408f, -1.24925423f, 0.56830937f, -0.58146489f, -0.60169810f, 
    0.12537806f, 0.13865788f, 0.27203989f, 0.37224731f, 0.45899734f, 0.41143578f, -0.07913121f, -0.08350381f, 
    0.21145290f, -0.10869813f, 0.07960797f, 0.04254683f, 0.19315125f, -0.00303885f, -0.15145430f, 0.02331265f, 
    -0.14405520f, 0.04474176f, -0.20153961f, -0.18292286f, -0.19645035f, -0.46576032f, -0.42266175f, -0.41483814f, 
    -0.09411205f, -0.32683194f, -0.20273963f, -0.20962994f, -0.17814969f, -0.29023623f, -0.62037331f, 0.35624722f, 
    -0.19594382f, 0.11617617f, 0.11710926f, 0.27835631f, -0.05187010f, 0.12245256f, 0.16031811f, -0.33370581f, 
    -0.09927154f, 0.10622185f, 0.39004526f, 0.16614610f, 0.13866219f, 0.46187964f, -0.87045747f, -0.45917100f, 
    -0.55737287f, -0.64858192f, -0.04248010f, 0.56040800f, -0.01242774f, -0.34617186f, -0.47406700f, -0.11735249f, 
    -0.36230224f, -0.17883897f, -0.15192614f, -0.22011273f, -0.20268004f, -0.01888112f, -0.47270772f, -0.09022732f, 
    0.04874106f, -0.00813037f, -0.09201520f, 0.06796042f, -0.07544082f, -0.21979211f, 0.01868476f, 0.19252846f, 
    0.40448177f, 0.29624557f, 0.60244977f, 0.49113810f, -0.05961747f, -0.73737448f, -0.66843235f, -0.39239672f, 
    -0.22455153f, -0.32704028f, 0.02908751f, -0.02960519f, -0.31015125f, -0.07931217f, 0.06499260f, 0.24949647f, 
    0.09127451f, -0.04238302f, 0.19735062f, 0.15861684f, -0.11961146f, -0.30211845f, 0.20813289f, 0.31857455f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26042023f, 0.28754807f, 0.08732250f, 0.03876336f, 0.05919801f, 0.33663890f, -0.00186403f, 0.23287563f, 
    0.37246370f, 0.34196034f, -0.10618944f, 0.16776928f, -0.01049422f, -0.02410843f, -0.07108963f, 0.31716198f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.60937977f, 0.32724005f, 0.40138534f, 0.12996058f, 0.17100833f, -0.10455099f, -0.06243373f, -0.09382842f, 
    -0.00978657f, 0.01980017f, 0.06100183f, 0.14141731f, -0.27306494f, 0.13402110f, -0.31924123f, 0.25267151f, 
    0.06509463f, 0.01233018f, -0.07805500f, 0.26400891f, 0.02841796f, -0.03799414f, 0.04831807f, -0.00479538f, 
    0.17062017f, -0.23045611f, -0.50627685f, -0.07928687f, -0.05376624f, -0.11295184f, 0.12806998f, -0.02527374f, 
    -0.01221535f, 0.09753333f, 0.12896718f, -0.04841441f, -0.25049281f, -0.00913356f, -0.00729520f, 0.24500005f, 
    0.06068002f, -0.04782258f, 0.04419568f, -0.01807630f, -0.02521048f, 0.08972889f, 0.17946045f, 0.12035786f, 
    0.06678638f, -0.27066210f, 0.10889830f, 0.03952370f, -0.00463262f, -0.06975126f, -0.11011735f, -0.25777110f, 
    -0.04877580f, 0.09579843f, 0.12094720f, 0.03846485f, -0.59564072f, 0.47788033f, -0.40533453f, 0.39564073f, 
    0.07324491f, -0.14942627f, 0.21007514f, 0.06219016f, 0.06842788f, 0.04026284f, -0.07486476f, 0.14119549f, 
    -0.24351105f, -0.02511580f, -0.06649882f, 0.10089722f, -0.08256926f, 0.03188412f, 0.01539094f, 0.10842364f, 
    -0.30799124f, -0.00202775f, 0.33273968f, 0.04677229f, -0.21314409f, 0.05757877f, -0.13876672f, 0.39007413f, 
    -0.07296793f, 0.05962999f, -0.03814290f, -0.11652108f, 0.07781369f, 0.13723809f, -0.07149125f, -0.09157830f, 
    0.12569761f, 0.49132892f, 0.26249698f, 0.08179031f, 0.04326072f, 0.08984333f, 0.07282697f, -0.06203180f, 
    0.14165780f, 0.14145756f, 0.09976494f, 0.00666379f, -0.06799645f, -0.00307137f, 0.04946847f, -0.20735094f, 
    0.00884628f, 0.04647003f, 0.01798291f, -0.01997350f, -0.08005684f, -0.09986715f, 0.05130795f, -0.04687838f, 
    -0.33013657f, 0.08404707f, 0.30432364f, 0.07829478f, 0.09560897f, 0.00489937f, -0.11364442f, -0.00922040f, 
    0.20143427f, 0.11679435f, 0.02248835f, -0.00026310f, -0.06614682f, 0.04087034f, -0.04900789f, -0.06450756f, 
    -0.02728154f, -0.02722144f, -0.09677311f, -0.08027645f, 0.03181104f, -0.05480033f, -0.13309456f, -0.13124570f, 
    -0.05829237f, 0.16493697f, 0.24887480f, 0.13769037f, 0.15301153f, -0.01705662f, -0.07704646f, -0.06386618f, 
    -0.16729379f, 0.05002899f, 0.11606809f, 0.05557401f, -0.18993846f, -0.09217241f, 0.18183161f, 0.30050740f, 
    -0.22675763f, -0.15255395f, 0.05680728f, -0.02466799f, -0.05101429f, 0.05027653f, -0.06212299f, 0.04237797f, 
    -0.27761799f, -0.17064048f, 0.31280997f, 0.41782585f, -0.04855593f, -0.05989080f, -0.00651588f, -0.19963923f, 
    -0.01225482f, -0.00831217f, 0.00101539f, 0.02176224f, -0.09982494f, -0.27051586f, 0.06207539f, 0.20349844f, 
    -0.05270978f, 0.19525170f, 0.21775869f, 0.17394978f, 0.07546003f, 0.02982642f, -0.03239071f, 0.03061194f, 
    -0.05323204f, 0.06994153f, -0.02347428f, 0.09049498f, -0.11840252f, -0.10224787f, 0.20238307f, -0.15747704f, 
    -0.04701316f, 0.00632248f, 0.34332538f, -0.09651190f, 0.04189936f, -0.27190590f, -0.02674066f, -0.12136748f, 
    0.01012380f, -0.07520037f, -0.31016883f, 0.02152525f, -0.25065225f, -0.32088834f, -0.33649483f, -0.36606103f, 
    -0.05992140f, 0.05752662f, -0.06552456f, 0.19981121f, 0.12017193f, 0.14787994f, 0.11251280f, -0.20020857f, 
    -0.28201306f, -0.03629639f, 0.18868789f, 0.19061832f, 0.04819684f, 0.07544328f, 0.11153821f, 0.22854452f, 
    -0.04256885f, 0.01214598f, -0.02567945f, -0.11830123f, 0.05718521f, 0.14758559f, 0.06454657f, 0.22086526f, 
    -0.00260165f, -0.15830472f, 0.08979688f, 0.30765161f, 0.00653357f, -0.08437645f, 0.25032878f, -0.09947658f, 
    0.08771808f, 0.19880038f, 0.15162808f, 0.17801435f, 0.10488793f, -0.27141830f, 0.02313787f, 0.07085931f, 
    0.17793769f, -0.03157783f, -0.00679113f, -0.05745405f, -0.18923862f, -0.14207970f, -0.25220805f, 0.01804642f, 
    -0.00903464f, 0.04249190f, 0.19214718f, 0.12524633f, -0.11280004f, -0.08974507f, -0.30359629f, 0.16226779f, 
    -0.08033361f, -0.04030982f, -0.08966649f, -0.17349838f, 0.01724926f, 0.18646033f, 0.34466487f, 0.06625362f, 
    -0.06224949f, 0.00134874f, 0.06005096f, -0.04183410f, 0.12685230f, 0.04558845f, -0.00904883f, -0.16996850f, 
    -0.20269981f, -0.04233669f, 0.17611402f, -0.22611457f, 0.22188121f, 0.16756029f, 0.10515628f, 0.05015003f, 
    0.16384962f, 0.06572383f, -0.14092292f, 0.10266487f, -0.08155315f, -0.14486296f, -0.15818250f, -0.16999990f, 
    0.19203049f, -0.03807257f, 0.03757580f, 0.03725503f, -0.09330337f, 0.05783329f, 0.24574663f, 0.13282441f, 
    0.06136578f, 0.34822544f, 0.40797511f, 0.03964937f, -0.07547776f, -0.04794183f, -0.10934194f, 0.07412597f, 
    0.03558373f, -0.09647148f, -0.11144200f, -0.08189470f, 0.03574416f, -0.18777156f, -0.27297097f, 0.03320398f, 
    -0.09765051f, 0.08667111f, 0.07258175f, 0.02328022f, 0.19903232f, 0.22587788f, 0.21020854f, 0.34240904f, 
    -0.39998859f, -0.10324147f, 0.11034592f, -0.22754236f, -0.19928910f, -0.04816198f, 0.03752068f, 0.28716511f, 
    0.06061312f, 0.10130844f, 0.22241865f, 0.16109745f, -0.00017051f, -0.00856284f, 0.17016967f, 0.21963623f, 
    -0.00228520f, -0.13398659f, -0.03452564f, -0.09360000f, -0.09489345f, -0.09623568f, -0.11485951f, -0.16290696f, 
    -0.20206332f, -0.14722359f, 0.17967203f, -0.01002957f, -0.06211754f, -0.06538366f, -0.16334383f, 0.12763913f, 
    0.07027255f, 0.08358230f, 0.07317736f, 0.20108002f, 0.29770255f, -0.13623466f, 0.15250000f, 0.26835570f, 
    0.12872851f, -0.02726764f, 0.11308564f, 0.04316701f, -0.08335249f, -0.02208292f, -0.27419540f, -0.13502733f, 
    0.01018966f, 0.02507244f, -0.03773170f, 0.02928489f, -0.02761086f, 0.17408428f, 0.15559524f, 0.03950768f, 
    0.11672875f, 0.00888071f, 0.06461944f, 0.09625889f, 0.04806946f, -0.21398923f, 0.22002642f, -0.12284288f, 
    -0.03490043f, 0.11783091f, -0.00802243f, -0.13599811f, -0.05287330f, -0.18258789f, -0.06223885f, -0.28141764f, 
    -0.58316845f, 0.10079928f, 0.40421492f, 0.09152901f, -0.09335066f, 0.08981658f, -0.07927750f, -0.09480114f, 
    -0.02953075f, -0.16798471f, -0.19121332f, -0.19899189f, 0.14193794f, 0.23600145f, 0.13480346f, -0.09724312f, 
    0.17034891f, 0.05376076f, 0.14553134f, 0.04547909f, -0.06764425f, 0.10952213f, 0.00646799f, 0.09642077f, 
    0.22856520f, 0.31873614f, -0.28007644f, -0.08667757f, 0.07684765f, 0.02221770f, -0.02685354f, 0.19287877f, 
    0.20760582f, 0.02405405f, 0.00416270f, 0.14851403f, 0.12501979f, -0.41103789f, 0.09623559f, -0.09257306f, 
    -0.05373058f, 0.11095033f, -0.07818413f, 0.13772643f, -0.02013066f, -0.02057784f, -0.05838331f, -0.06148262f, 
    0.19816579f, 0.06917995f, -0.02184067f, -0.08449952f, -0.08301208f, -0.22432037f, 0.10743426f, -0.26907972f, 
    -0.05431424f, -0.06911506f, -0.16563974f, 0.02141151f, 0.24886505f, 0.25233442f, 0.39318976f, -0.24188575f, 
    0.12676719f, 0.04733074f, -0.08900478f, 0.07866055f, 0.07277833f, 0.12043787f, 0.05901189f, 0.11011121f, 
    0.31258976f, -0.01985177f, 0.06240912f, -0.30391994f, 0.03765143f, -0.01583879f, -0.16844961f, 0.02224687f, 
    0.05182880f, -0.00650274f, -0.02917943f, 0.17368747f, -0.23298782f, -0.02269702f, -0.11867614f, 0.08026414f, 
    -0.01338520f, -0.04303350f, -0.05046999f, -0.09206238f, 0.13874915f, 0.09058683f, 0.12348917f, 0.03065653f, 
    0.30791980f, 0.21195351f, 0.03162441f, -0.08768176f, -0.02875716f, -0.02971679f, -0.25006530f, 0.08305819f, 
    0.12125848f, -0.05595269f, -0.10180368f, 0.10969078f, -0.20221068f, -0.18006767f, -0.23663881f, 0.04156894f, 
    0.01448903f, -0.03964416f, -0.01467326f, -0.12997667f, 0.13897672f, -0.08645876f, 0.22379528f, 0.09016372f, 
    -0.07496423f, 0.19458702f, 0.16402505f, 0.26718232f, -0.04477176f, 0.02670321f, 0.04585986f, -0.16527934f, 
    0.15871732f, 0.14355542f, 0.02217531f, 0.06249457f, 0.27483770f, 0.27087063f, 0.17083260f, -0.06325901f, 
    -0.03833891f, 0.17821108f, 0.15958592f, 0.10630107f, 0.04506833f, -0.15480410f, 0.07201545f, -0.06733360f, 
    0.23245966f, 0.14521624f, -0.07863986f, -0.01504183f, 0.10462885f, 0.17612992f, -0.09483907f, 0.06038367f, 
    0.03654242f, 0.07653856f, -0.01863816f, 0.12763904f, 0.01015816f, 0.00164301f, -0.21789999f, 0.04567142f, 
    0.27013472f, 0.18236338f, 0.27742729f, 0.29205742f, 0.07082840f, -0.03756278f, -0.00640193f, -0.06727262f, 
    -0.22582227f, -0.01683470f, -0.10050134f, -0.15638302f, 0.00829628f, -0.03614801f, 0.18158557f, -0.00017118f, 
    0.03745048f, -0.14070754f, 0.09093882f, -0.01974148f, -0.07010628f, -0.33854941f, 0.29834619f, -0.28949067f, 
    0.07228220f, 0.17266996f, -0.17635445f, 0.04843358f, -0.10024966f, -0.13452384f, 0.08737203f, -0.00433644f, 
    -0.36184469f, -0.25221646f, 0.09289198f, 0.46228832f, 0.04907938f, 0.14817722f, 0.11134019f, -0.03802524f, 
    0.04896259f, 0.07821565f, -0.03067123f, 0.13785808f, 0.02889179f, 0.27483499f, 0.14612603f, 0.13154419f, 
    -0.04136882f, 0.03034779f, 0.14393635f, 0.03956968f, 0.10569872f, 0.00480454f, -0.10534037f, 0.03984061f, 
    -0.10380843f, -0.07448954f, 0.02527137f, 0.27293006f, 0.09329433f, -0.04380225f, 0.08197769f, 0.04511486f, 
    -0.11151495f, -0.02462203f, -0.13950260f, -0.03134803f, 0.26634201f, -0.71146399f, 0.11806596f, 0.12268758f, 
    0.17289881f, 0.25702640f, 0.04166688f, 0.06549695f, -0.09497552f, 0.10972473f, -0.13559447f, 0.04695690f, 
    0.38346779f, 0.11466393f, 0.07747243f, 0.06302339f, -0.09833843f, -0.11260111f, -0.13182272f, -0.21200006f, 
    0.11305556f, -0.11035705f, 0.11414912f, 0.06274007f, 0.07173350f, -0.01014851f, 0.43606618f, -0.14345339f, 
    0.02291248f, 0.12246744f, -0.19099936f, 0.14399572f, -0.15124887f, 0.02448949f, 0.00815371f, -0.13865337f, 
    0.07954287f, -0.11858239f, -0.01119278f, -0.49043798f, 0.09150805f, 0.00640558f, -0.10741178f, 0.07493392f, 
    0.03281333f, -0.16067980f, -0.17663451f, -0.01261531f, -0.02114862f, -0.27058563f, -0.24602163f, 0.10181535f, 
    0.13808456f, -0.06928117f, -0.03742298f, -0.07915157f, 0.13236418f, -0.14150168f, 0.07795758f, -0.16086832f, 
    0.06958161f, 0.12784813f, 0.11018468f, -0.15463933f, 0.02437057f, -0.02138103f, -0.15827903f, 0.03637687f, 
    0.13288853f, 0.09537190f, -0.03847078f, 0.02572588f, -0.11655074f, -0.50246209f, -0.40391529f, 0.09920096f, 
    -0.07330082f, 0.06677294f, 0.04627188f, -0.07963988f, -0.00508863f, -0.09148216f, 0.21598245f, -0.20770857f, 
    -0.31869686f, -0.00645896f, 0.00663085f, -0.15661055f, -0.08116361f, -0.11958916f, -0.05642127f, 0.07914919f, 
    0.10922369f, -0.12996368f, 0.05989648f, -0.15210374f, 0.15364133f, 0.19180603f, 0.30557927f, 0.17277709f, 
    0.06314052f, 0.24737638f, 0.18619300f, 0.22356316f, 0.10460300f, -0.00691096f, 0.11636473f, 0.15192220f, 
    -0.25209114f, -0.00439725f, 0.12948935f, -0.26727882f, -0.09291025f, 0.10308265f, 0.00259249f, 0.11332365f, 
    -0.02176466f, 0.00675063f, -0.01550219f, 0.14292170f, 0.01877767f, -0.50455230f, 0.09006882f, 0.23757958f, 
    0.41760716f, 0.25265059f, 0.15257110f, 0.08611349f, 0.17767283f, -0.05445329f, 0.04373474f, -0.10395321f, 
    0.12929834f, -0.09127934f, 0.16626495f, 0.00514787f, -0.02448756f, -0.20907150f, 0.15043409f, 0.00516557f, 
    0.07076020f, -0.22126460f, 0.11942353f, -0.09861818f, -0.00665044f, -0.06608814f, 0.07614673f, -0.03826649f, 
    0.03438874f, 0.26836574f, -0.17169425f, 0.12413928f, -0.02269169f, -0.25545463f, 0.09942664f, 0.13312599f, 
    -0.23304527f, 0.13608623f, -0.41560555f, -0.01638279f, -0.24703476f, -0.05741605f, 0.00381325f, -0.19288915f, 
    -0.06195004f, -0.02091671f, 0.05397597f, 0.06189339f, -0.12281542f, 0.20603733f, 0.05443068f, 0.14644864f, 
    0.13398331f, 0.07536630f, 0.18782270f, 0.03388828f, 0.13353607f, 0.11544998f, -0.07151876f, 0.08518068f, 
    0.15339011f, -0.26564586f, -0.04286878f, 0.13578822f, 0.15892792f, 0.06454539f, 0.10045484f, -0.01694258f, 
    0.02434652f, 0.11056064f, 0.05404238f, -0.00358774f, 0.02747311f, 0.18688868f, -0.02041722f, 0.29200664f, 
    0.09399820f, 0.01851350f, -0.08508164f, 0.15399285f, -0.01206909f, -0.03505145f, 0.03301323f, 0.17010064f, 
    0.15160675f, 0.15803240f, 0.08645479f, -0.04222005f, -0.20249428f, -0.09476249f, -0.20414458f, 0.04279809f, 
    -0.00039101f, 0.07164492f, 0.02235203f, -0.02147743f, -0.16396508f, 0.00842563f, -0.00676394f, 0.02905178f, 
    0.13286260f, 0.11899312f, -0.25184026f, 0.29933944f, 0.00380072f, -0.04630376f, -0.11985689f, -0.16058695f, 
    0.35559964f, 0.03185765f, -0.04618180f, 0.12591697f, 0.06145586f, -0.09299824f, -0.07258117f, 0.19535623f, 
    0.21509746f, -0.07944913f, -0.08833371f, 0.07337966f, 0.30429044f, 0.13655636f, 0.21742943f, -0.07906075f, 
    0.03108825f, 0.05997465f, 0.11370128f, 0.04817516f, 0.19727816f, 0.10322076f, 0.13756528f, -0.00313096f, 
    -0.27444977f, 0.18191889f, 0.27740228f, -0.00928984f, -0.08566207f, -0.05324404f, -0.08040851f, -0.09473290f, 
    0.03458426f, 0.03535389f, -0.12563032f, -0.09997679f, 0.18417826f, -0.00519146f, -0.09522167f, -0.00438367f, 
    -0.13064173f, -0.00014082f, 0.03345965f, -0.13658814f, 0.31659645f, 0.09338846f, 0.06195039f, -0.01456934f, 
    -0.40208143f, -0.06234005f, 0.18568978f, -0.30576476f, -0.20548482f, -0.15367720f, -0.05513814f, 0.06984357f, 
    0.11634751f, -0.12354792f, -0.00897822f, -0.06258838f, -0.25478041f, -0.06046220f, -0.03022781f, 0.00800257f, 
    -0.12101260f, -0.12844901f, -0.04964101f, 0.05887223f, -0.05753291f, -0.00167297f, 0.02430756f, 0.01973511f, 
    -0.18275540f, -0.31428003f, 0.12069605f, 0.02720975f, -0.05003379f, 0.00660983f, -0.01277399f, 0.09897848f, 
    0.09467883f, 0.10814370f, -0.02936869f, -0.01739537f, 0.18675110f, -0.11460976f, -0.02365310f, 0.22048451f, 
    -0.02256052f, 0.13707481f, 0.12198558f, 0.11241063f, -0.08864817f, -0.00915177f, 0.03205210f, -0.09011472f, 
    0.32084861f, 0.04005947f, -0.00806861f, 0.22983833f, 0.01974790f, 0.00124529f, 0.00574543f, -0.23123665f, 
    0.04492789f, -0.03828231f, 0.01858204f, 0.14956412f, 0.05780046f, 0.03455257f, 0.06750888f, -0.27805308f, 
    0.06471726f, -0.22253861f, -0.04541213f, -0.22482394f, -0.36514756f, -0.06984408f, -0.49302581f, -0.40847018f, 
    -0.25434351f, -0.03311148f, 0.35912237f, 0.23885575f, -0.00363154f, 0.02454617f, -0.13552980f, -0.29494593f, 
    -0.11949448f, -0.23660269f, -0.06111622f, -0.04327359f, 0.17944191f, 0.12057634f, 0.10096191f, 0.11169922f, 
    0.02484480f, -0.01002910f, 0.00804405f, 0.13280165f, -0.03877820f, 0.13410117f, 0.18429260f, -0.02415414f, 
    0.12551488f, 0.16596831f, -0.00747090f, 0.21540542f, 0.09955227f, 0.07766064f, 0.09456156f, 0.08222585f, 
    0.18758726f, 0.29882568f, 0.03218307f, 0.06240508f, 0.09877221f, -0.00882482f, 0.15966183f, -0.09593615f, 
    -0.10578854f, -0.10449753f, -0.17607117f, -0.10102433f, -0.18188006f, -0.01167409f, -0.22010435f, 0.01388231f, 
    0.06701983f, -0.00492079f, -0.26216504f, 0.27386743f, -0.00070833f, -0.17461726f, -0.13272987f, -0.33958191f, 
    -0.10544214f, -0.20631810f, -0.02569688f, -0.10687330f, 0.05924390f, 0.04793107f, 0.02216244f, 0.15443672f, 
    -0.04720276f, 0.02108861f, 0.16181083f, -0.00381650f, -0.13393448f, 0.15218344f, -0.05701211f, 0.10286992f, 
    -0.55183518f, 0.20311868f, 0.02281486f, 0.33076066f, -0.00616351f, 0.13839409f, -0.02913908f, -0.18553841f, 
    0.03090814f, 0.14870137f, 0.07711967f, 0.05834111f, -0.28425765f, 0.16006421f, -0.13141534f, 0.10377566f, 
    0.11937201f, 0.02828285f, -0.21537496f, -0.16673012f, 0.08864172f, -0.08002009f, 0.10919988f, -0.05187473f, 
    0.41217834f, 0.40691459f, -0.02338476f, -0.03378120f, -0.10528195f, -0.15711869f, -0.20264082f, 0.00772219f, 
    -0.24255753f, 0.05237358f, -0.16306747f, -0.02545130f, -0.03845746f, -0.17619464f, 0.01438270f, 0.02865923f, 
    -0.05937925f, 0.07985649f, 0.06811971f, -0.08848669f, 0.22992307f, 0.04994253f, 0.01081943f, 0.24173954f, 
    0.91309363f, -0.11174061f, 0.01570980f, 0.15891756f, 0.05488694f, -0.00827305f, 0.06933925f, -0.27408630f, 
    0.00348151f, 0.17127213f, 0.18995450f, 0.28841978f, 0.27568328f, -0.08091608f, -0.07977755f, 0.06208383f, 
    0.04735595f, 0.05317141f, 0.04150001f, 0.21291013f, 0.04501837f, -0.05636391f, -0.10379037f, -0.20882644f, 
    0.11534519f, 0.01458663f, -0.17230786f, 0.06678992f, 0.12824260f, 0.05990751f, -0.01200547f, 0.08144828f, 
    0.03758822f, 0.14958699f, 0.21913953f, 0.00897424f, 0.00351665f, 0.18813013f, 0.39273724f, 0.17155932f, 
    0.09602583f, 0.13378859f, -0.01159195f, 0.16913298f, -0.24254254f, 0.00518099f, -0.24941406f, -0.17004631f, 
    0.14652929f, 0.24860242f, 0.03223169f, 0.20510872f, 0.02421847f, -0.03072083f, -0.06329288f, -0.18756174f, 
    -0.02774656f, 0.18961354f, -0.07311729f, 0.10626607f, 0.03490762f, 0.27984777f, -0.16524358f, -0.08103698f, 
    0.11622154f, -0.17258076f, 0.01719765f, -0.05704750f, -0.06732734f, 0.15875995f, 0.01425343f, -0.08762831f, 
    0.63326126f, 0.05038754f, 0.03510575f, -0.06721728f, 0.25877175f, -0.36873186f, -0.13550973f, -0.07763640f, 
    0.05267887f, -0.00822327f, 0.01516215f, 0.06105465f, 0.15565872f, -0.13904175f, 0.01494952f, 0.17446035f, 
    0.07078081f, 0.09624887f, 0.01475586f, 0.19742459f, -0.07859357f, 0.03014062f, 0.04681910f, 0.07669882f, 
    -0.01039820f, 0.01591367f, 0.26172119f, 0.20828718f, -0.12584648f, -0.11927079f, 0.10874164f, 0.09737533f, 
    -0.00325809f, 0.00606129f, 0.02802371f, 0.08778735f, 0.23779194f, -0.04760378f, -0.07503156f, 0.07261472f, 
    -0.08360240f, -0.19437101f, 0.12625311f, -0.22857746f, 0.07485660f, 0.01676470f, -0.00445595f, 0.04010221f, 
    -0.06108421f, -0.09681641f, 0.16868171f, 0.09516143f, -0.03942137f, -0.04597106f, -0.09890936f, -0.11695103f, 
    0.05801718f, 0.10947581f, 0.10004857f, 0.05219649f, 0.00373001f, 0.04468035f, 0.20494294f, 0.27518821f, 
    0.02755660f, -0.00979075f, 0.23623198f, -0.21552196f, -0.14610417f, -0.00864945f, -0.10465929f, -0.05350856f, 
    -0.11730256f, 0.00488222f, 0.62033778f, -0.13849914f, -0.24578451f, 0.18323827f, 0.00007062f, -0.03451863f, 
    -0.08276241f, 0.16732691f, 0.12924547f, 0.09654151f, -0.29474086f, -0.04795688f, 0.05037590f, -0.18237811f, 
    -0.07678743f, -0.06558467f, -0.34117618f, -0.04023854f, -0.04504212f, 0.04952696f, 0.11485402f, 0.07752242f, 
    -0.07370912f, -0.03172648f, -0.23060873f, -0.00448054f, 0.08522714f, -0.02245189f, -0.00975899f, 0.06710114f, 
    -0.00804314f, -0.01001734f, 0.13576894f, 0.02748053f, -0.32736963f, -0.19545962f, -0.03962009f, -0.21720038f, 
    -0.02301514f, -0.01621826f, -0.06183670f, -0.05847260f, 0.08564227f, 0.07916657f, -0.03373618f, 0.09518823f, 
    0.23109227f, -0.13625009f, -0.08114851f, 0.00818005f, 0.23589370f, -0.07286078f, -0.30870342f, -0.41042095f, 
    -0.18774940f, 0.06169661f, -0.04221246f, 0.17904364f, 0.17460212f, 0.05330462f, 0.08583941f, 0.31199321f, 
    0.06524406f, -0.00699935f, 0.05797640f, 0.22675601f, 0.10730472f, -0.00947589f, -0.12203533f, -0.06381200f, 
    0.09494352f, -0.01118976f, -0.03455196f, 0.17788558f, 0.11571094f, 0.14965306f, 0.10419239f, 0.11350778f, 
    -0.06660011f, -0.14221968f, 0.17288756f, -0.00532230f, 0.31875449f, -0.00657857f, 0.25121140f, 0.12259991f, 
    -0.15657225f, -0.24166760f, 0.11148214f, -0.13971001f, -0.03367265f, 0.12745032f, -0.12786411f, -0.08941874f, 
    -0.12046453f, -0.04085764f, -0.38749483f, -0.47074246f, -0.14434382f, 0.08116271f, 0.12211632f, 0.08482672f, 
    0.04729322f, -0.19932784f, 0.11245500f, -0.01720742f, 0.10964805f, 0.11665321f, 0.26492548f, -0.15761155f, 
    -0.05135181f, 0.06533889f, 0.00600595f, 0.07586934f, -0.07211836f, 0.14851876f, -0.03295013f, 0.22858532f, 
    -0.07894482f, -0.01872658f, 0.44043154f, 0.26790920f, -0.03845979f, -0.09986503f, 0.06462301f, -0.01417618f, 
    0.08936112f, -0.02820009f, 0.01293636f, 0.18996815f, -0.03432902f, 0.12503280f, -0.18776827f, -0.20594910f, 
    -0.08636992f, 0.06601540f, 0.17179146f, 0.09172379f, -0.11644047f, -0.07092881f, -0.08191516f, -0.19910155f, 
    -0.24561088f, -0.03125664f, 0.01840733f, 0.14000428f, -0.13772145f, -0.25698495f, 0.16442178f, -0.00628156f, 
    -0.15141621f, -0.08251892f, -0.24907291f, -0.00625020f, 0.38079834f, -0.24207340f, 0.35689333f, -0.12905781f, 
    -0.02915998f, 0.12499052f, 0.05242752f, 0.04428590f, 0.07207289f, 0.00879745f, 0.00598741f, 0.01853718f, 
    0.34829488f, 0.03513098f, 0.00737871f, 0.07086092f, 0.19863391f, 0.18881840f, 0.14608631f, -0.07073826f, 
    0.04440260f, -0.21430558f, -0.07301590f, 0.08300475f, 0.03165952f, 0.02344644f, 0.26740435f, -0.12256991f, 
    0.13486867f, -0.10347385f, 0.02303716f, 0.05056553f, -0.29998758f, -0.20672403f, 0.06655321f, 0.01074074f, 
    -0.19318032f, -0.19438352f, 0.19642980f, -0.19100991f, 0.07867604f, 0.00816244f, -0.04431224f, 0.05620452f, 
    -0.14626475f, -0.32782871f, -0.08366779f, -0.22741199f, -0.06785093f, -0.07570842f, -0.00239587f, 0.16345221f, 
    0.11023927f, 0.02342929f, -0.08305456f, 0.04849198f, 0.20009658f, 0.10129359f, -0.01125696f, -0.16375239f, 
    0.24816234f, -0.02120392f, -0.18264823f, -0.08059257f, 0.00449063f, 0.06307723f, -0.00347420f, 0.21259817f, 
    -0.12130714f, 0.07308551f, 0.12157089f, 0.11118912f, -0.02958112f, 0.03188795f, 0.08160701f, 0.10478792f, 
    0.19561186f, 0.04150536f, 0.12345278f, 0.05888507f, 0.16368002f, 0.03759931f, 0.17081414f, -0.03407494f, 
    0.17285790f, 0.02283153f, 0.01128378f, -0.04567054f, -0.09246595f, 0.10652198f, -0.01243797f, 0.16249683f, 
    -0.00549859f, -0.01941137f, -0.11120565f, -0.20934410f, 0.30124733f, 0.19173720f, -0.00298081f, 0.09412897f, 
    0.11145619f, 0.40745008f, 0.24981317f, 0.29462904f, 0.02292073f, -0.05060971f, 0.08026039f, 0.17930026f, 
    -0.16617087f, -0.10766101f, -0.39129487f, -0.50450081f, -0.13628235f, 0.21024217f, 0.03613444f, 0.10498120f, 
    -0.15392333f, -0.13968411f, -0.00457819f, 0.00802002f, 0.16946599f, -0.10795696f, 0.06600158f, 0.23483789f, 
    0.07742231f, 0.02057368f, -0.18920685f, -0.06593181f, 0.07999004f, -0.03471811f, 0.02940309f, 0.05716554f, 
    0.51851499f, 0.16578662f, 0.14507474f, 0.28132060f, 0.13537246f, 0.16224928f, 0.05445319f, 0.13043459f, 
    0.03354386f, -0.19016011f, -0.08077560f, 0.33499888f, 0.03115721f, 0.29510269f, -0.12933406f, 0.17543413f, 
    0.01079408f, 0.12713476f, 0.05588454f, 0.00658169f, 0.11983690f, 0.16266881f, 0.17956971f, 0.23837280f, 
    0.54223299f, 0.15690583f, -0.00506098f, -0.22052309f, 0.32725000f, -0.16614702f, -0.01028206f, -0.05822939f, 
    -0.01632378f, 0.04262892f, 0.04025056f, 0.07490853f, -0.00587464f, -0.02452815f, -0.09380419f, 0.08787323f, 
    0.18074691f, 0.14120454f, 0.25970119f, 0.30527142f, 0.09312031f, -0.04526808f, 0.00659054f, -0.06849091f, 
    0.05564826f, -0.05724123f, 0.24977084f, 0.05613847f, 0.13416508f, -0.10100614f, 0.01814306f, 0.24897537f, 
    0.07353082f, -0.07176828f, 0.00749048f, -0.02232285f, 0.10973331f, 0.63455385f, -0.02159391f, 0.16352813f, 
    0.06784472f, -0.17431928f, 0.07959973f, -0.00053817f, 0.06716561f, 0.08777718f, 0.11616440f, -0.01112816f, 
    -0.17907092f, -0.08493575f, -0.23912948f, -0.01293684f, -0.15427922f, -0.00837465f, 0.14196555f, 0.04675296f, 
    0.12219920f, 0.20398431f, 0.34460211f, 0.28728959f, -0.20333429f, -0.20847242f, -0.26267764f, 0.34165841f, 
    0.15406443f, 0.06339011f, 0.18088074f, 0.11046083f, -0.01400149f, -0.08243230f, -0.11054557f, -0.02795207f, 
    0.06001200f, 0.13768151f, 0.24120151f, 0.36346230f, -0.14472327f, -0.02047485f, 0.16418940f, 0.37471661f, 
    0.07080097f, 0.13188343f, 0.35349044f, 0.03877715f, 0.12938988f, 0.18749556f, 0.40136179f, -0.14263593f, 
    -0.17950220f, 0.17693758f, -0.10879523f, -0.08647295f, -0.00807881f, -0.01176407f, 0.09263325f, 0.19996710f, 
    -0.16884144f, -0.20554233f, -0.25584888f, -0.14346567f, -0.10195819f, 0.02194581f, 0.09191705f, 0.13390569f, 
    0.00560926f, 0.02537503f, 0.16134357f, -0.18064865f, -0.08775170f, 0.27587983f, -0.00329011f, -0.17186272f, 
    -0.11543415f, 0.03646247f, -0.12348855f, 0.00278981f, -0.05041371f, 0.05582673f, -0.18124124f, -0.00034404f, 
    0.24754520f, -0.25700676f, -0.19525810f, -0.09912898f, 0.12483299f, -0.04474663f, -0.11091331f, -0.10414344f, 
    -0.12763689f, 0.08814208f, -0.04968543f, -0.08304055f, -0.16462442f, -0.02207983f, -0.17207702f, 0.16030186f, 
    0.08610335f, 0.21766613f, 0.01224497f, 0.20861606f, -0.10026342f, 0.10860218f, -0.00886841f, 0.02248934f, 
    0.13318284f, -0.10152633f, -0.01581384f, 0.34090564f, 0.12618835f, 0.03580343f, 0.24293382f, 0.14625537f, 
    0.13480848f, -0.06370624f, -0.04970295f, -0.14244287f, 0.10959510f, 0.23957446f, 0.28826666f, 0.09729373f, 
    -0.03615452f, 0.05499681f, -0.08091889f, -0.02906066f, -0.11002026f, -0.01251260f, 0.07688344f, -0.08660138f, 
    -0.60769314f, -0.10727903f, -0.01655394f, -0.49401993f, -0.07884647f, -0.03310245f, -0.00731845f, 0.08681222f, 
    0.08079984f, 0.13331777f, 0.02324004f, 0.10245647f, 0.21895860f, 0.08021738f, -0.02494833f, 0.07165666f, 
    0.26842880f, -0.11986566f, 0.06766241f, 0.18859135f, -0.22782299f, -0.07960226f, -0.10902032f, -0.04215384f, 
    0.14419594f, 0.21821190f, 0.11740616f, 0.20329486f, -0.05746063f, -0.01340568f, 0.02070220f, -0.02094510f, 
    -0.04658645f, -0.14573848f, -0.07225198f, -0.05526550f, 0.20063302f, -0.15155655f, -0.08211977f, 0.10291681f, 
    -0.01902714f, -0.02935779f, -0.10988400f, -0.12535901f, -0.01892671f, -0.05327116f, 0.05536917f, 0.03235533f, 
    -0.13024187f, -0.15369716f, 0.01793094f, -0.06285381f, -0.15383749f, 0.16330986f, 0.13141334f, 0.00824170f, 
    0.03995054f, 0.07877929f, 0.04527071f, 0.13438223f, 0.44739276f, 0.10716111f, 0.11320640f, 0.11982822f, 
    0.11814881f, -0.01830306f, -0.05611033f, 0.04182893f, -0.10238706f, -0.02890661f, 0.08552767f, 0.01754950f, 
    0.22044338f, -0.08473580f, 0.39383283f, 0.14081021f, 0.09013958f, -0.12623833f, -0.18369329f, -0.00354371f, 
    0.00154325f, 0.05376992f, -0.04566073f, -0.05550535f, -0.16147149f, 0.22378664f, 0.56207460f, -0.15353003f, 
    0.04050311f, -0.31748074f, -0.06264528f, 0.15242581f, -0.04253137f, 0.08586603f, -0.09728106f, -0.19595478f, 
    0.27317566f, -0.32439104f, 0.29768422f, -0.30573499f, 0.10659821f, -0.03258736f, 0.08223613f, 0.08284958f, 
    0.01406185f, 0.20110889f, 0.06706771f, -0.01943403f, 0.29556715f, 0.12633543f, 0.09126446f, 0.33269522f, 
    0.06817633f, -0.18902037f, 0.10351709f, 0.14048105f, 0.20494121f, 0.20419614f, 0.01545115f, 0.02493527f, 
    0.12092465f, 0.06873947f, -0.15054099f, -0.07631872f, -0.00883502f, 0.04889230f, -0.09654953f, -0.02713887f, 
    -0.01468369f, -0.10053705f, -0.19154042f, 0.07203718f, 0.11072995f, -0.12502393f, 0.15206623f, 0.18099314f, 
    0.03285589f, 0.02370715f, 0.13641466f, 0.10781226f, 0.10752353f, 0.15048160f, 0.15605941f, 0.29790822f, 
    -0.23619476f, 0.01650619f, -0.05969150f, -0.11411563f, -0.17223957f, -0.03888180f, -0.11569139f, -0.04924857f, 
    -0.05510921f, -0.02013050f, 0.04735972f, 0.12259793f, 0.00579908f, 0.00395191f, 0.01067083f, -0.13923232f, 
    0.12506697f, -0.00888110f, -0.02629657f, 0.19588277f, -0.19976738f, -0.28109702f, -0.06804413f, -0.27634081f, 
    0.00399871f, -0.16238132f, -0.14693600f, -0.51690257f, -0.04534486f, 0.10434355f, -0.09299505f, 0.05184749f, 
    0.03503533f, 0.00493640f, 0.10569465f, -0.01357825f, 0.59233975f, 0.21076737f, 0.11086147f, -0.02243465f, 
    0.05471141f, 0.02407367f, 0.13214703f, -0.13786846f, -0.08702304f, -0.00661473f, -0.16481709f, 0.03731645f, 
    -0.00699413f, -0.06302409f, 0.01368177f, -0.05416628f, -0.03057373f, 0.05519341f, 0.05587349f, 0.03575480f, 
    -0.06648248f, -0.01192171f, -0.05009461f, -0.06099046f, -0.03162608f, -0.03357860f, -0.02949547f, -0.04913636f, 
    0.00450202f, 0.05807442f, 0.03869416f, 0.03556825f, -0.00816481f, 0.01686001f, -0.04165410f, -0.06853209f, 
    0.00410952f, 0.04203319f, -0.06757390f, -0.06397105f, 0.04957270f, -0.05712167f, -0.02137700f, 0.01149085f, 
    -0.02208009f, 0.03475790f, 0.03604601f, -0.02655729f, 0.00750275f, -0.02706881f, 0.04367803f, -0.07160253f, 
    -0.02569665f, -0.00634071f, -0.06127630f, -0.01725797f, -0.06596231f, -0.00694402f, 0.00015732f, -0.02251557f, 
    0.01877798f, -0.00260859f, -0.01371913f, -0.06892069f, 0.05759791f, -0.05426536f, 0.03132118f, -0.06459156f, 
    0.01054800f, 0.02698196f, -0.05304469f, -0.04335719f, 0.02488100f, 0.04066179f, 0.01587256f, -0.03733420f, 
    -0.05776837f, 0.01879170f, 0.01925781f, -0.07166951f, -0.00213629f, -0.05348488f, 0.06413133f, -0.02771501f, 
    -0.05524494f, 0.03921360f, -0.04104689f, -0.01411562f, -0.01633841f, 0.03740374f, -0.01465076f, 0.00406176f, 
    -0.00022792f, -0.04936491f, 0.03986003f, -0.04834703f, 0.02869839f, 0.05252156f, -0.05726028f, 0.02101755f, 
    0.01875465f, -0.04015847f, 0.03624223f, 0.04799790f, -0.06584805f, -0.06826083f, -0.03010377f, -0.07016505f, 
    -0.04308970f, -0.04624972f, 0.03577954f, 0.01583560f, -0.07859176f, 0.04827513f, 0.02071612f, -0.00246276f, 
    0.01072025f, 0.03550594f, 0.01376445f, 0.02639081f, -0.04050673f, -0.05443485f, -0.05439565f, 0.00669424f, 
    -0.01523006f, -0.01446523f, -0.05820505f, -0.06813878f, -0.05845563f, -0.03178680f, -0.07323291f, -0.05892555f, 
    -0.02907193f, 0.01358127f, -0.02248321f, -0.06076757f, -0.02075963f, 0.04514178f, -0.02470349f, -0.04641259f, 
    0.02027338f, -0.02583653f, -0.05364680f, 0.05843237f, -0.00925307f, -0.02750494f, -0.05569913f, -0.03468614f, 
    -0.03761540f, -0.04666173f, -0.03146118f, -0.02511625f, 0.03374547f, 0.04000110f, 0.05581075f, -0.00196143f, 
    0.04247186f, -0.03271620f, 0.00772589f, 0.06243080f, 0.00692749f, -0.04177246f, -0.01538910f, 0.02837197f, 
    -0.05183308f, -0.02583939f, -0.02878208f, -0.04709712f, 0.05946058f, -0.07348754f, 0.01058163f, 0.02856706f, 
    -0.07543290f, -0.03017414f, 0.01314304f, 0.05590165f, 0.02970968f, -0.07305647f, 0.03238844f, -0.04850458f, 
    -0.04523076f, -0.02904924f, 0.01162980f, 0.05696132f, 0.03518454f, -0.00301843f, -0.04527500f, -0.06907351f, 
    -0.02387222f, -0.07694703f, 0.02059721f, 0.00655746f, -0.00657517f, 0.01730845f, -0.01690378f, -0.01624559f, 
    -0.03038999f, 0.03731651f, -0.02379468f, -0.01038925f, -0.01527108f, -0.02844016f, 0.02377374f, -0.02561508f, 
    0.05145970f, -0.21327908f, -0.30119628f, 0.36641175f, 0.07636199f, 0.20273444f, 0.00772390f, 0.01289931f, 
    0.12100369f, 0.10271230f, -0.06692493f, 0.02698097f, 0.08062794f, 0.11076830f, 0.25351030f, -0.22604197f, 
    -0.06063184f, -0.23185255f, 0.12850712f, -0.42248410f, 0.05022290f, 0.14251330f, -0.18862343f, -0.02605014f, 
    0.38318717f, 0.06924377f, 0.35028702f, -0.08140107f, 0.14688596f, -0.20437627f, -0.13595223f, 0.09387070f, 
    -0.01134878f, 0.06169185f, -0.10708907f, 0.14547141f, 0.05442709f, -0.16206598f, -0.07701606f, -0.03570449f, 
    0.02394508f, 0.09681911f, -0.04645940f, 0.16784774f, 0.02045852f, -0.07723810f, -0.01150822f, -0.03681559f, 
    -0.01442194f, 0.12668072f, 0.25876647f, 0.09140439f, 0.05090188f, 0.01184556f, -0.04895262f, 0.06354091f, 
    0.05804349f, 0.02154222f, -0.00934848f, 0.02756328f, 0.30230430f, -0.05827565f, 0.16022186f, -0.18746755f, 
    -0.15816759f, -0.01620377f, -0.10787658f, -0.14957081f, -0.07795236f, 0.00177371f, 0.00749303f, 0.03916771f, 
    -0.28462946f, -0.17214465f, -0.11254123f, -0.01774715f, 0.09287367f, 0.06493445f, 0.00589179f, -0.24522308f, 
    0.13093330f, -0.02576536f, -0.02639912f, -0.10414023f, 0.18014897f, -0.14653218f, -0.21924336f, 0.20084511f, 
    -0.00245360f, -0.00320901f, 0.26992491f, -0.02191409f, -0.10550640f, -0.11938485f, -0.01453546f, 0.22752705f, 
    -0.59854269f, -0.23060438f, -0.18008316f, 0.38581917f, -0.05143348f, 0.12999351f, -0.05947158f, -0.04557848f, 
    0.00544769f, -0.01556350f, 0.21026988f, 0.15625340f, -0.28727078f, 0.18834740f, -0.00808954f, 0.05918219f, 
    -0.04846207f, -0.07888462f, -0.29244557f, -0.06818457f, 0.01515544f, -0.02592745f, -0.03718553f, 0.15169163f, 
    0.25613353f, -0.42938706f, -0.47006765f, -0.06738279f, -0.03787572f, 0.02225422f, 0.15951042f, -0.06199301f, 
    -0.06350973f, 0.09441643f, -0.03131304f, -0.01134780f, -0.15068176f, 0.10652770f, 0.15091178f, -0.04167712f, 
    -0.11370040f, 0.11759941f, -0.01673249f, 0.02474173f, 0.13007869f, 0.01416596f, -0.19133303f, 0.13914046f, 
    0.78300148f, -0.36665696f, -0.35301507f, 0.01451175f, 0.20062956f, 0.13626039f, 0.12277850f, -0.01671978f, 
    -0.01779792f, 0.01793571f, 0.04108738f, 0.04545104f, 0.26460508f, -0.01719633f, -0.21562630f, 0.13293578f, 
    0.19086647f, 0.11020371f, -0.00623049f, 0.04474089f, 0.03600002f, 0.07449167f, -0.14860095f, 0.08881508f, 
    0.16808678f, -0.03260415f, -0.28980404f, 0.07208930f, 0.11799497f, 0.02905233f, -0.01257700f, -0.01461751f, 
    0.04050071f, -0.06205578f, 0.08967377f, 0.06721795f, 0.12022966f, 0.30462384f, 0.33241472f, 0.00953781f, 
    -0.14806138f, -0.02366798f, -0.01256035f, 0.06061258f, -0.00296913f, 0.04448088f, -0.02182252f, 0.05905132f, 
    0.64030057f, 0.07665609f, 0.30024117f, 0.15507501f, -0.13032462f, -0.03444546f, 0.10779686f, 0.05106637f, 
    -0.18239686f, -0.26647174f, -0.01759931f, 0.09399720f, -0.01558181f, 0.09077959f, 0.02465648f, 0.20154038f, 
    -0.01194110f, -0.01311723f, -0.02519150f, -0.02283268f, -0.18382411f, -0.09244911f, 0.10914843f, 0.01164736f, 
    -0.81132936f, 0.10544029f, 0.02769398f, -0.23498462f, -0.13307402f, 0.10852848f, -0.02925944f, -0.08997142f, 
    -0.04916952f, -0.05631750f, 0.00449111f, 0.03934314f, 0.22138551f, 0.31643525f, -0.07487702f, 0.12019269f, 
    0.01727743f, -0.12858169f, 0.11790670f, 0.29009846f, -0.03694257f, -0.01077473f, 0.04703267f, 0.03093543f, 
    0.33600643f, 0.07905099f, -0.24359666f, 0.02276798f, -0.02299719f, -0.11907481f, -0.09414431f, 0.16867287f, 
    -0.02648730f, -0.12443703f, -0.09502038f, 0.01304513f, -0.68543464f, 0.31456965f, -0.21154131f, -0.39488575f, 
    -0.15437189f, 0.10566373f, 0.01767176f, 0.13547719f, 0.01701269f, 0.01325990f, 0.01865040f, 0.14430690f, 
    0.03492243f, -0.08898547f, 0.00766339f, 0.27713129f, 0.02758210f, 0.06717498f, 0.23969330f, -0.00388710f, 
    -0.14651115f, 0.18978590f, 0.19129696f, 0.00203458f, 0.04054370f, 0.17754680f, -0.03160540f, 0.23287220f, 
    -0.03200400f, -0.13665648f, -0.07836716f, 0.06670266f, -0.07415823f, 0.02958129f, -0.15237983f, -0.02570323f, 
    0.28528035f, -0.12554623f, 0.13799398f, 0.16049442f, 0.00417659f, -0.09588470f, -0.13059731f, 0.24364491f, 
    0.07069770f, 0.00684577f, -0.09368046f, 0.07770421f, -0.53304785f, -0.36306971f, -0.10824952f, -0.23361763f, 
    0.07710127f, 0.19366203f, 0.06084568f, 0.04103686f, 0.00207928f, 0.01199644f, -0.03600439f, 0.12437252f, 
    0.07748796f, 0.40810624f, 0.07941962f, 0.03278983f, 0.13438626f, 0.06627239f, 0.10053632f, 0.16612375f, 
    0.00315996f, 0.12263490f, -0.02963849f, -0.04370489f, -0.35038269f, -0.02691657f, -0.16926499f, -0.17863925f, 
    -0.00678897f, -0.10315983f, 0.03819799f, -0.09731673f, 0.05933447f, 0.09563947f, 0.10560977f, 0.13707910f, 
    0.21677409f, -0.03430135f, 0.25470546f, 0.16197786f, 0.08009528f, 0.07139412f, 0.10660081f, -0.02242651f, 
    0.03623834f, 0.18078075f, 0.01200170f, -0.01609568f, 0.19508392f, 0.36903784f, 0.36489749f, 0.19508041f, 
    -0.07429002f, 0.08757753f, 0.04336630f, 0.29072776f, -0.03162404f, -0.05796264f, 0.16551094f, -0.03617202f, 
    0.41635805f, 0.07563312f, -0.10147891f, 0.41644007f, 0.00926962f, 0.06097751f, 0.06600358f, 0.18132354f, 
    -0.07828807f, -0.17330658f, -0.05057414f, -0.00605269f, -0.26041752f, -0.06857397f, -0.45920381f, 0.03576896f, 
    -0.01499140f, -0.00148189f, -0.02808729f, 0.07999603f, 0.00686265f, -0.01775515f, -0.01078319f, 0.00587184f, 
    -0.06262171f, 0.05199685f, 0.03569020f, -0.06769587f, -0.07398766f, 0.06277933f, -0.05260840f, 0.05003365f, 
    -0.00918984f, -0.01086999f, -0.07157131f, -0.06150753f, 0.01750112f, 0.00357134f, -0.04944822f, -0.02431648f, 
    0.05077771f, 0.04441265f, -0.01575562f, 0.01662368f, 0.01402603f, -0.03996767f, 0.02792890f, 0.03279274f, 
    -0.05877199f, -0.00975711f, -0.06869275f, 0.03704722f, 0.00012524f, -0.07113455f, -0.00527912f, 0.03172906f, 
    -0.03501694f, 0.01037423f, -0.05952687f, -0.03569959f, 0.01747235f, -0.00293898f, 0.00548618f, 0.02857867f, 
    -0.07244646f, -0.04679285f, 0.03887800f, 0.03014308f, -0.05940439f, 0.03775668f, -0.06181279f, -0.06651546f, 
    -0.05649311f, -0.01091609f, -0.02681152f, -0.02352427f, 0.06926948f, -0.02166495f, -0.06058509f, 0.05899261f, 
    -0.02880719f, -0.06241962f, -0.06197523f, 0.06656900f, 0.06318955f, 0.05853156f, 0.02717575f, 0.02978951f, 
    -0.04185470f, 0.01371314f, -0.04763293f, -0.05627047f, -0.07243033f, -0.04719070f, 0.06399931f, -0.03136422f, 
    0.05055141f, -0.03695990f, -0.02491058f, 0.04473670f, -0.07113352f, 0.01602107f, -0.05630119f, 0.06464215f, 
    -0.07224607f, -0.02523641f, 0.01290843f, 0.01027334f, -0.06920485f, 0.00604262f, -0.07020530f, 0.04015730f, 
    0.01612924f, -0.01424525f, 0.05225326f, 0.05169628f, -0.02204982f, -0.06667379f, 0.01667763f, -0.06893506f, 
    -0.04344933f, -0.06699614f, -0.00016825f, -0.01963721f, -0.03375596f, -0.02501973f, -0.07351765f, -0.05036791f, 
    0.02135042f, -0.07052311f, -0.01735700f, -0.00120375f, -0.03169193f, -0.04378013f, 0.05902234f, -0.03614809f, 
    0.02543194f, -0.01311534f, -0.02516489f, 0.04435767f, 0.06432520f, 0.03977449f, -0.05760650f, -0.03219026f, 
    -0.04548221f, -0.06681981f, 0.05415909f, 0.01223928f, -0.01397128f, -0.01371889f, 0.05035399f, 0.00911673f, 
    -0.04114215f, -0.03690515f, -0.04001112f, -0.07699251f, -0.04736272f, -0.06972480f, -0.06695785f, -0.02323285f, 
    0.05693177f, 0.00815991f, -0.01691546f, 0.05631024f, 0.02235500f, -0.04498276f, -0.04754135f, 0.05149248f, 
    -0.00916198f, 0.01310875f, -0.03681707f, -0.02444716f, 0.02702080f, 0.02071108f, 0.02413741f, -0.00069658f, 
    0.04176168f, -0.07124539f, -0.03466910f, -0.07059190f, -0.02726192f, -0.01085730f, 0.05739253f, -0.06177596f, 
    0.05654740f, -0.02529473f, -0.01207544f, -0.05651356f, 0.02995574f, 0.03530559f, 0.04922194f, -0.01146114f, 
    -0.03401601f, -0.03865014f, 0.02961129f, -0.04984839f, -0.06998514f, 0.01245300f, -0.04530265f, 0.05996532f, 
    0.01901064f, 0.03518428f, -0.05305093f, 0.01819534f, -0.04637226f, -0.03595867f, -0.01760791f, 0.06548800f, 
    -0.03641926f, 0.05317657f, -0.07594461f, 0.00598405f, 0.06228326f, -0.01524798f, -0.01563187f, -0.06836633f, 
    -0.03403590f, 0.07947712f, 0.01408559f, -0.12031697f, 0.05042425f, 0.07718715f, 0.09434302f, -0.05805479f, 
    0.18155724f, 0.14481893f, 0.03628913f, 0.03910540f, -0.29305759f, 0.05268756f, 0.09537002f, -0.04069084f, 
    -0.07203966f, 0.00870522f, -0.11258569f, 0.01816026f, 0.02917032f, -0.01948594f, 0.21085730f, 0.07631596f, 
    0.19599395f, 0.06018760f, 0.24361217f, 0.13012369f, 0.31312370f, 0.06218707f, 0.07749696f, 0.06150852f, 
    0.06148909f, 0.15598434f, -0.03108827f, 0.20777778f, 0.07871716f, 0.34163401f, -0.01093764f, -0.16846529f, 
    -0.09946006f, 0.05136211f, 0.04571460f, 0.12847665f, 0.06223058f, 0.14507943f, 0.02614179f, -0.09521201f, 
    0.19562481f, 0.13415031f, 0.01998712f, -0.05492405f, 0.04234372f, -0.08715749f, 0.20810369f, 0.17752112f, 
    0.06217297f, 0.14951369f, 0.00901150f, -0.12883171f, 0.24325611f, -0.30452663f, -0.18211359f, -0.01368135f, 
    0.04062533f, 0.07741387f, -0.03096257f, -0.03301563f, 0.08382846f, -0.01810871f, 0.01869882f, 0.17368783f, 
    -0.13274091f, 0.03600709f, -0.34025085f, -0.05853186f, -0.04228211f, -0.00153882f, -0.20866664f, -0.22032806f, 
    -0.00418244f, -0.08295271f, -0.26767296f, 0.01707442f, 0.35236087f, 0.18434969f, 0.06494478f, -0.09546401f, 
    0.18956497f, 0.06882617f, -0.09177863f, 0.19715567f, -0.09585328f, 0.13070272f, 0.11215078f, 0.12956566f, 
    -0.09427091f, 0.00188920f, -0.26236376f, 0.07128908f, -0.03653407f, 0.19875512f, -0.17757504f, -0.17714094f, 
    -0.03731134f, -0.00587160f, -0.11353546f, -0.06175489f, -0.26255774f, -0.34687635f, -0.13998598f, 0.04094731f, 
    0.12010337f, 0.13746446f, 0.08154748f, -0.05272443f, 0.10592936f, -0.10838165f, -0.18075833f, -0.03798070f, 
    -0.04736808f, -0.25979105f, -0.10485515f, -0.13092270f, 0.05388168f, -0.08848136f, -0.23512080f, -0.02334286f, 
    -0.25217745f, 0.05272903f, -0.03664368f, -0.16766834f, -0.28062087f, -0.20825352f, -0.18121019f, 0.00413657f, 
    -0.04178896f, 0.03106918f, -0.02464818f, -0.10843547f, -0.14276163f, -0.13549912f, -0.32738590f, -0.33915460f, 
    -0.10612632f, -0.09110574f, 0.08743539f, -0.05454177f, 0.23234025f, 0.06964900f, 0.09542766f, 0.06476112f, 
    0.00866505f, 0.01861774f, 0.17307641f, -0.05926220f, 0.46531534f, 0.14163344f, -0.13985412f, -0.01441750f, 
    -0.00792867f, 0.19229440f, 0.12198765f, 0.07440693f, 0.05763629f, 0.07826819f, 0.09790345f, 0.08371791f, 
    0.26269087f, 0.12354874f, -0.32955471f, -0.28862149f, 0.05080305f, 0.23243487f, 0.10672803f, -0.00592653f, 
    0.09831709f, 0.07810608f, 0.17388624f, 0.07162093f, -0.01820081f, -0.06282577f, 0.02787149f, 0.00296663f, 
    -0.00223767f, -0.15192857f, 0.05436375f, 0.11724294f, 0.14513268f, 0.00233990f, 0.14451815f, 0.02100844f, 
    0.09644847f, 0.10068062f, 0.18317960f, 0.05530848f, -0.26315612f, 0.00203600f, 0.08822060f, 0.16960734f, 
    0.03909204f, 0.02015335f, 0.10957780f, -0.05854041f, 0.09037177f, -0.13137463f, -0.29697168f, 0.33811077f, 
    -0.17614906f, 0.28156790f, -0.14318854f, 0.29149106f, -0.01741331f, -0.32504302f, 0.05143571f, -0.13686730f, 
    -0.30486482f, 0.34168029f, -0.05111488f, -0.14754580f, -0.02318249f, 0.18525609f, 0.06521098f, 0.06002378f, 
    -0.08919958f, -0.14315695f, -0.06859653f, 0.06114494f, 0.03965987f, 0.05506315f, -0.06320948f, -0.09640583f, 
    0.07769123f, -0.09313008f, -0.01832309f, -0.06432920f, 0.07111539f, -0.03618665f, 0.09911832f, 0.04054514f, 
    0.39185140f, 0.13784777f, -0.30042493f, -0.19834980f, 0.06406076f, 0.04728638f, -0.03176501f, -0.11357574f, 
    0.06507926f, 0.04820012f, 0.07675674f, 0.00830529f, -0.57424217f, 0.66029084f, 0.08210671f, -0.02759426f, 
    0.07418385f, -0.12845559f, 0.02101867f, 0.19805384f, 0.09208366f, -0.24992597f, -0.00320396f, -0.04624971f, 
    -0.16303587f, 0.10606097f, -0.19921300f, 0.01216933f, -0.08185984f, 0.03303334f, 0.15409735f, 0.24969895f, 
    -0.10876321f, 0.03236303f, -0.20360169f, -0.06454433f, -0.03891218f, 0.11576583f, -0.27964962f, 0.00934681f, 
    -0.05477205f, 0.14838573f, -0.03799972f, 0.06701089f, 0.16886966f, -0.02461231f, 0.02311682f, 0.01189091f, 
    0.31556624f, 0.16696641f, -0.29900566f, 0.22059084f, 0.11096510f, 0.05276293f, -0.06683204f, 0.20013386f, 
    -0.00676525f, -0.00365223f, 0.16953255f, -0.00575808f, 0.19190022f, 0.04838599f, -0.06413730f, -0.28782299f, 
    -0.10144927f, 0.14585282f, 0.05321154f, 0.01545386f, -0.10645522f, 0.01389960f, 0.13878766f, 0.07664797f, 
    -0.10899016f, 0.36016846f, 0.00617180f, 0.09944092f, 0.01715782f, -0.16074483f, 0.01026158f, 0.07678938f, 
    0.00491277f, -0.17383958f, -0.19676645f, -0.03113722f, 0.26284885f, 0.21141610f, 0.00657654f, -0.15978026f, 
    0.00630238f, -0.02004054f, -0.32002193f, 0.06132009f, -0.06967887f, 0.17590551f, -0.04872534f, 0.16383009f, 
    -0.27063227f, 0.07584843f, 0.20637180f, -0.02352778f, -0.04385180f, 0.18734281f, 0.07380354f, 0.26480657f, 
    0.17807816f, 0.20014122f, 0.09231631f, 0.08934148f, -0.12388902f, 0.02798992f, -0.02626596f, -0.18152006f, 
    -0.14762330f, -0.17332990f, -0.02656688f, -0.20305340f, -0.10762451f, -0.14547466f, -0.11647614f, -0.20224234f, 
    0.19777051f, 0.11126890f, 0.10804431f, 0.24487486f, -0.00273750f, -0.04408352f, 0.07608470f, 0.05940635f, 
    -0.09010341f, 0.02006396f, -0.13417947f, 0.00143317f, -0.11129900f, 0.26585659f, -0.12643068f, -0.06086289f, 
    -0.00632739f, -0.11478249f, -0.15755165f, 0.24208453f, -0.08438216f, 0.00367343f, -0.06645649f, -0.11361229f, 
    -0.16870765f, 0.07936199f, 0.11266149f, -0.00521064f, 0.14019050f, 0.00723037f, -0.02139394f, -0.02037533f, 
    -0.07243764f, 0.09161351f, 0.12023565f, 0.15077336f, -0.28429469f, 0.18619376f, -0.14780708f, 0.00967868f, 
    0.09217425f, 0.10069910f, -0.02970526f, 0.18988526f, 0.14741331f, 0.12248375f, 0.04224061f, 0.20379449f, 
    0.73210233f, 0.00625695f, -0.06587078f, -0.18493779f, 0.17364374f, -0.10442662f, 0.07617964f, 0.11163861f, 
    -0.12245008f, 0.16451924f, 0.00999048f, 0.19690989f, -0.12968525f, -0.04367103f, -0.00750179f, -0.05769369f, 
    0.11752526f, 0.06475517f, 0.04351433f, 0.04305361f, 0.03044168f, 0.11428668f, -0.09666330f, 0.07240435f, 
    0.02736175f, -0.16098124f, 0.25010088f, -0.00768263f, 0.03355179f, -0.02550830f, 0.01681346f, 0.02368836f, 
    0.01208701f, 0.03645374f, 0.05526083f, -0.17152309f, 0.08641907f, 0.22303149f, -0.04220994f, 0.38121518f, 
    0.11931045f, 0.06818376f, 0.11207279f, -0.04429512f, 0.06487446f, -0.04465717f, 0.06480870f, 0.12638827f, 
    -0.12527047f, -0.02962741f, -0.08134890f, 0.04972924f, -0.14714737f, 0.05735305f, -0.04506629f, 0.03841729f, 
    0.12408431f, 0.16378497f, 0.17748542f, 0.22127138f, 0.05248635f, -0.16935717f, -0.16196162f, 0.09195007f, 
    0.16371642f, 0.04436326f, -0.02830476f, 0.11535104f, 0.00150726f, -0.10790049f, -0.01590391f, -0.11219550f, 
    0.11408677f, -0.04152239f, -0.09846184f, 0.10825363f, 0.00716471f, 0.05666968f, 0.02074343f, 0.12193079f, 
    0.10960825f, 0.03680156f, 0.06474513f, 0.00432052f, 0.30792451f, -0.06084675f, 0.20845059f, 0.02315618f, 
    -0.08492909f, 0.05320893f, 0.06638544f, 0.03502459f, 0.00024684f, -0.02473640f, 0.04787548f, 0.14046057f, 
    -0.47263294f, -0.30711675f, 0.01637794f, -0.06102834f, -0.13515292f, 0.04923596f, -0.00500385f, 0.02374724f, 
    0.00254636f, 0.10300355f, 0.12422803f, -0.15971573f, -0.07633073f, -0.05747400f, -0.07909884f, -0.02123462f, 
    0.02771985f, 0.11041399f, 0.04355110f, 0.01498721f, -0.17496337f, 0.02229349f, -0.23664917f, -0.36133885f, 
    -0.44473913f, -0.10885520f, -0.01390969f, -0.26625940f, -0.01360665f, -0.14169413f, -0.24722026f, -0.01858600f, 
    -0.18581340f, 0.04894373f, 0.10864015f, -0.03381234f, -0.17208554f, -0.06740759f, -0.23610759f, 0.02393840f, 
    0.04691160f, 0.06897864f, 0.00776649f, -0.04839298f, -0.10325034f, 0.00032588f, -0.11638303f, 0.06285385f, 
    -0.12744738f, -0.06776712f, -0.04605858f, -0.02777728f, -0.02343087f, 0.00291792f, 0.07218124f, -0.13548908f, 
    -0.07067643f, 0.08159607f, -0.00780000f, 0.03137804f, 0.09677441f, -0.02908367f, 0.17203021f, 0.15940860f, 
    0.03231670f, 0.25361714f, 0.09255137f, -0.08912288f, -0.09222423f, -0.07218458f, 0.02797081f, -0.06005725f, 
    0.10108837f, 0.02735702f, 0.25545445f, 0.22010763f, -0.02184340f, 0.01467806f, -0.01528136f, 0.05367808f, 
    0.12382560f, 0.15575078f, 0.06126407f, 0.10286205f, 0.13961147f, -0.03511457f, -0.08070804f, 0.09865655f, 
    0.04897277f, -0.09484664f, -0.00565544f, -0.22647549f, -0.21572044f, 0.02602386f, -0.09468558f, -0.22871101f, 
    0.27766666f, -0.23627624f, -0.21895118f, 0.24751320f, -0.11688025f, -0.07191827f, -0.15352224f, -0.15944368f, 
    0.11329088f, -0.08867863f, -0.11909860f, -0.14388192f, -0.10951772f, -0.30441397f, -0.05447992f, 0.26152670f, 
    0.05745117f, 0.00139023f, -0.02882449f, -0.03167134f, 0.16755822f, -0.04151671f, 0.12303816f, 0.02419515f, 
    -0.11951349f, -0.03787035f, 0.33812824f, 0.14030996f, 0.05589462f, 0.18848358f, 0.02273445f, -0.02637881f, 
    0.16618995f, 0.11669103f, 0.11092622f, 0.17390728f, 0.06194121f, 0.23953502f, -0.02595319f, 0.08556277f, 
    -0.00803487f, 0.07105891f, -0.01011293f, -0.00549614f, -0.12367654f, -0.06844768f, -0.15092933f, -0.03631685f, 
    -0.22414535f, -0.11850491f, -0.02713749f, -0.24860136f, -0.19332810f, -0.19178231f, 0.16148348f, -0.03055690f, 
    -0.11405543f, 0.16987418f, 0.05042808f, -0.19240537f, -0.24608208f, 0.00868050f, -0.19151944f, 0.30562896f, 
    -0.18464816f, -0.10269149f, 0.15345287f, -0.06694642f, 0.08879709f, 0.05399489f, -0.02144502f, -0.02999922f, 
    -0.26167262f, 0.33202109f, 0.11994869f, 0.04231358f, -0.02595536f, -0.00191921f, 0.26667938f, -0.19387512f, 
    -0.04928633f, 0.27854654f, 0.21643174f, 0.05117372f, -0.09839445f, 0.16865419f, -0.02126200f, -0.04264680f, 
    0.02565291f, -0.18186702f, 0.05951747f, 0.03540795f, -0.09620192f, 0.23755501f, -0.00953358f, -0.04944408f, 
    0.01236853f, -0.03310049f, 0.05993884f, 0.14698912f, 0.02475938f, 0.00121356f, -0.08150109f, 0.08726887f, 
    -0.09113856f, -0.21855706f, 0.00717729f, -0.00816428f, 0.00503795f, -0.04320031f, 0.02872730f, -0.20977773f, 
    -0.15796870f, 0.06076387f, 0.10690359f, 0.05189309f, 0.19007798f, 0.16139129f, 0.12578125f, 0.19295722f, 
    0.57125038f, 0.08183271f, -0.10975312f, 0.11928904f, 0.03390741f, 0.02184583f, 0.19214001f, -0.03991586f, 
    -0.02285687f, 0.00755645f, -0.01601492f, 0.32737353f, -0.33861524f, -0.22868238f, -0.01788071f, 0.07304580f, 
    -0.07821345f, -0.22742042f, -0.13733985f, -0.01651134f, -0.00105795f, -0.04439187f, -0.23260681f, -0.26055798f, 
    -0.25573346f, -0.09053940f, 0.24643213f, 0.05647704f, 0.00032363f, 0.00219896f, -0.04485578f, 0.15403308f, 
    0.18427272f, -0.06546713f, 0.07849822f, -0.10009468f, -0.01843415f, 0.02064906f, 0.19547641f, 0.05502870f, 
    -0.00834691f, -0.20485473f, -0.12344753f, 0.08076939f, -0.11421899f, 0.03831503f, -0.03435948f, 0.06491722f, 
    -0.00613515f, 0.06324568f, -0.01425367f, -0.01939197f, 0.06017464f, 0.12862724f, -0.03529520f, 0.11926267f, 
    0.09657801f, -0.04981232f, -0.00961319f, 0.16873083f, -0.03387051f, 0.08583683f, 0.06441363f, 0.07744066f, 
    -0.01610639f, 0.16510703f, 0.11673351f, -0.09850135f, 0.10816068f, 0.15757625f, 0.19862980f, 0.25399271f, 
    0.24341770f, 0.00014872f, 0.37135342f, 0.14302096f, 0.34652439f, 0.00094435f, -0.14292064f, 0.09934641f, 
    -0.00460006f, -0.02374903f, -0.09082821f, 0.08148149f, 0.02204573f, 0.12266668f, -0.03684661f, -0.23221830f, 
    0.06898399f, 0.03003934f, 0.14758092f, 0.05183379f, 0.09065963f, -0.04984697f, -0.06026656f, -0.06513403f, 
    0.01001310f, 0.20279987f, 0.11437585f, -0.16508467f, 0.06301420f, 0.06336838f, -0.04945293f, 0.20038094f, 
    0.00726573f, -0.02154865f, -0.19135301f, -0.17234474f, 0.23292914f, 0.28953794f, 0.22433129f, -0.02643892f, 
    0.05066653f, 0.02099817f, 0.02035371f, 0.03267336f, 0.02638720f, 0.07168531f, 0.03489711f, 0.01704070f, 
    -0.22145379f, -0.16224033f, -0.39093801f, -0.02519475f, -0.05821133f, 0.11967205f, 0.05506263f, -0.18826036f, 
    0.10254265f, 0.06300972f, -0.01004766f, 0.21095867f, 0.17973427f, -0.23287614f, -0.16907078f, 0.04586814f, 
    0.03063080f, 0.02434883f, 0.04277164f, 0.21549107f, -0.16430311f, -0.10893431f, 0.03001716f, -0.08731278f, 
    -0.36839807f, -0.05142362f, -0.26893654f, 0.34127820f, -0.01450932f, -0.04637877f, 0.15276349f, 0.12982805f, 
    0.02941135f, -0.05221329f, 0.17310104f, -0.06703709f, 0.24924685f, -0.03291780f, -0.00689898f, 0.13963373f, 
    -0.06869252f, 0.10693018f, 0.00693829f, -0.05045021f, 0.03684786f, -0.01436411f, -0.11388163f, 0.17181180f, 
    0.06498455f, -0.47078490f, -0.28211209f, -0.00505817f, -0.08785231f, 0.05440316f, 0.14895271f, 0.08991852f, 
    -0.01583814f, 0.14574741f, 0.09844296f, -0.17396612f, -0.09663143f, 0.01190625f, -0.01202232f, -0.01386818f, 
    -0.03080368f, -0.02623061f, -0.01920159f, 0.00613152f, -0.15169443f, -0.12041689f, -0.29258004f, -0.18787085f, 
    0.14699513f, -0.30477890f, -0.32622015f, -0.10159665f, -0.12050553f, -0.03875404f, 0.09264041f, 0.09440690f, 
    0.07826020f, -0.07470294f, 0.05580683f, -0.14201714f, 0.02671605f, 0.05516719f, -0.18433294f, -0.03732877f, 
    0.07798293f, 0.24628569f, -0.04765353f, -0.10031431f, -0.03938325f, 0.09413707f, -0.13047966f, 0.02888412f, 
    0.29924297f, 0.14938831f, -0.08387811f, 0.07515430f, 0.10952547f, -0.00526080f, 0.09906046f, 0.06879541f, 
    -0.03817044f, -0.06676863f, -0.03320917f, -0.07546229f, -0.26139030f, 0.38092101f, 0.27021819f, -0.05361471f, 
    0.11659117f, -0.02079402f, -0.01664873f, 0.00641507f, -0.02386074f, -0.09083365f, 0.10035061f, -0.08914488f, 
    0.20208034f, 0.03562062f, 0.03105731f, -0.22284906f, -0.04309901f, 0.10387057f, 0.26968852f, 0.15173192f, 
    -0.01802981f, 0.09476682f, -0.03492672f, -0.00324963f, -0.22013028f, 0.16855298f, -0.02295451f, 0.06026120f, 
    -0.14429535f, 0.13875629f, -0.07453109f, 0.08139389f, 0.10002262f, -0.03432145f, 0.19457760f, 0.09877670f, 
    -0.24311109f, 0.08131517f, 0.32288140f, 0.00201471f, 0.05762132f, 0.15940221f, -0.15473644f, 0.16321614f, 
    0.02776893f, 0.03609750f, -0.17318818f, -0.06532364f, 0.20058142f, 0.27807790f, -0.03717994f, -0.20875750f, 
    0.01676487f, 0.06700144f, -0.01779882f, 0.07978532f, -0.08975674f, -0.09312855f, -0.13474838f, -0.18512565f, 
    0.22954713f, 0.23717009f, 0.01308601f, -0.11785392f, 0.03545212f, 0.06561042f, -0.05864567f, 0.00787034f, 
    -0.00769522f, -0.18103926f, -0.17846930f, -0.28940108f, -0.28673533f, 0.14977631f, -0.01464242f, -0.17468777f, 
    -0.01751655f, 0.16923000f, -0.11421504f, 0.03966346f, 0.09673239f, 0.02838617f, -0.02598043f, 0.14482230f, 
    -0.02534439f, 0.10560519f, -0.37290719f, -0.04318881f, -0.05289911f, -0.02268900f, 0.07312946f, -0.12616576f, 
    -0.00765838f, 0.19258247f, -0.16728050f, 0.04886442f, 0.20505674f, 0.18333675f, -0.09799581f, -0.03089046f, 
    0.07768916f, 0.08670774f, 0.01919720f, 0.15819383f, -0.19239731f, -0.22628252f, 0.00099592f, 0.06364077f, 
    -0.00773190f, -0.14082798f, -0.34093571f, 0.17060409f, 0.01250636f, -0.10065798f, -0.08385396f, 0.16126975f, 
    0.05282316f, 0.02987417f, 0.04940755f, -0.07777499f, -0.12671228f, -0.21727543f, -0.15953369f, -0.06283941f, 
    -0.06980536f, 0.09106047f, 0.16651697f, -0.03553670f, 0.05197236f, 0.11115853f, -0.18163320f, 0.04360677f, 
    -0.20775627f, -0.04755297f, -0.13968359f, -0.12695502f, -0.06869937f, 0.04557705f, -0.00662425f, 0.15057817f, 
    -0.09388533f, 0.11598001f, 0.02083433f, -0.09533279f, -0.21195404f, -0.08569830f, -0.20123057f, 0.00540345f, 
    0.06101934f, 0.05899073f, -0.10027347f, -0.03154730f, -0.13452688f, -0.07220352f, 0.01033098f, -0.29514512f, 
    -0.11355925f, -0.14588830f, -0.04876390f, -0.21560524f, 0.03296995f, 0.02742721f, 0.08617338f, 0.10700762f, 
    0.21462679f, 0.17875710f, 0.03500940f, -0.03355424f, 0.27111816f, 0.26844704f, 0.02561279f, 0.02326496f, 
    -0.01189508f, 0.09483692f, -0.01143244f, -0.05373614f, -0.05211693f, -0.03816793f, 0.09284928f, 0.01452641f, 
    0.39856160f, 0.32411131f, -0.09525539f, 0.04583224f, 0.09246953f, 0.09180001f, 0.19127229f, -0.01731252f, 
    -0.19406191f, -0.13204724f, -0.22260460f, -0.14309153f, -0.18381865f, -0.01835812f, -0.20419173f, -0.00071718f, 
    0.10319782f, -0.01839517f, -0.12582426f, 0.01720688f, -0.02531854f, -0.00997267f, 0.13942811f, 0.09782606f, 
    -0.53308976f, 0.18514775f, -0.07850691f, -0.28821728f, 0.01318255f, -0.04001320f, 0.10751194f, 0.02546251f, 
    0.07802550f, -0.04363439f, 0.13487606f, 0.13235766f, 0.05750503f, -0.26946422f, -0.08882417f, 0.08234135f, 
    0.18083371f, 0.24541938f, 0.14695427f, 0.22402911f, 0.03247372f, -0.24634296f, -0.14730537f, -0.03485411f, 
    -0.27356461f, -0.10022464f, 0.44693279f, 0.47858831f, 0.10513383f, -0.00006677f, -0.00168660f, -0.08447693f, 
    -0.01895281f, -0.05827563f, -0.06093048f, -0.17124580f, 0.16610819f, 0.12419830f, 0.21182743f, -0.05764079f, 
    0.07213426f, -0.08488666f, -0.09230684f, -0.25629407f, 0.14669739f, -0.05466771f, -0.04565346f, 0.14100993f, 
    0.02663775f, 0.19756827f, -0.14913970f, -0.20678033f, -0.03384138f, -0.05703053f, 0.10396011f, 0.15642659f, 
    0.06239225f, -0.02283104f, 0.02560268f, 0.22984675f, 0.38595417f, 0.00769026f, 0.27642292f, 0.05867179f, 
    0.09471059f, -0.12908626f, 0.01546292f, 0.08511221f, -0.02426154f, 0.02162457f, 0.05275707f, 0.07838345f, 
    0.18562435f, -0.35120600f, 0.04716065f, -0.06047931f, -0.03733451f, -0.00310691f, -0.02786992f, -0.12570015f, 
    -0.00109600f, -0.12991409f, -0.00064647f, -0.11551286f, 0.19422659f, 0.01245771f, 0.57945412f, -0.20571902f, 
    0.01132123f, -0.05946963f, -0.14820220f, 0.01097890f, 0.08818422f, 0.06646302f, 0.24894030f, -0.02628165f, 
    0.16656424f, -0.26164600f, 0.22985134f, -0.55942827f, -0.09155136f, 0.05023470f, 0.03144091f, 0.18268444f, 
    -0.03847146f, -0.09078588f, 0.24473542f, -0.05163828f, 0.63208658f, -0.27943933f, -0.15073939f, 0.40235746f, 
    -0.07419971f, -0.03967139f, -0.03123779f, 0.04007760f, 0.15728234f, 0.03311213f, 0.05577845f, -0.09670050f, 
    0.14435548f, -0.22807278f, -0.32614076f, -0.12020716f, -0.04749690f, -0.09317900f, -0.03725486f, 0.00736225f, 
    -0.02605818f, 0.10796113f, -0.12680928f, 0.00784826f, 0.22034417f, -0.26095495f, 0.05362145f, 0.29777774f, 
    0.24646382f, -0.02251204f, -0.11796200f, -0.03084456f, -0.11687443f, 0.04236703f, 0.12113231f, -0.03317232f, 
    -0.95094770f, 0.01765275f, -0.16143808f, -0.02161661f, -0.15249591f, -0.07344556f, -0.18343748f, 0.02639289f, 
    0.24315456f, -0.10999329f, 0.06591536f, -0.01192191f, 0.08788221f, 0.18588619f, 0.12490795f, -0.18965662f, 
    -0.02048692f, 0.16134331f, 0.04493615f, 0.00486651f, -0.05972439f, -0.16317128f, 0.02709756f, -0.19728312f, 
    0.16789365f, 0.41371590f, 0.28796569f, -0.21657337f, -0.02625977f, 0.17881532f, -0.02655569f, -0.05067293f, 
    0.02873446f, -0.07194470f, -0.00718373f, -0.00388021f, 0.22651936f, 0.26521823f, 0.06008118f, -0.31417981f, 
    0.20645954f, -0.02577421f, -0.00209194f, 0.25310153f, -0.05170470f, 0.00385409f, -0.07967347f, -0.05463770f, 
    -0.26547602f, 0.43018183f, -0.27286828f, 0.14942616f, 0.08636038f, -0.10417101f, 0.01690072f, -0.06790373f, 
    0.13629830f, 0.02366913f, 0.21281369f, 0.15603818f, 0.18862076f, -0.30200216f, -0.09199818f, 0.13155413f, 
    0.04105402f, -0.01729410f, 0.14445497f, 0.02770395f, -0.19898304f, -0.11193189f, -0.34364453f, -0.38218111f, 
    -0.08894195f, -0.23001041f, 0.46562609f, 0.36993262f, 0.25922847f, 0.03776001f, -0.05376327f, -0.10283366f, 
    -0.04969582f, -0.07381289f, 0.07078994f, -0.06158280f, 0.26615751f, -0.10772382f, 0.31878486f, 0.02567726f, 
    -0.02659491f, -0.21580456f, -0.09583251f, -0.29116580f, 0.29371706f, 0.06704139f, 0.05055322f, 0.16948630f, 
    0.00870442f, 0.24749795f, 0.00224055f, 0.03940338f, 0.03252866f, -0.08433575f, 0.03964237f, 0.08480978f, 
    0.17294264f, -0.08189925f, -0.00645028f, 0.19544351f, 0.16164182f, 0.02634823f, 0.22863942f, -0.03352199f, 
    0.05784276f, -0.23031217f, 0.06776439f, -0.09647725f, -0.02856608f, -0.00551264f, 0.01251321f, 0.06606463f, 
    -0.04508639f, -0.35697913f, 0.04526753f, -0.10329364f, -0.08118051f, 0.07352580f, -0.01613449f, 0.12935400f, 
    -0.01238059f, -0.16201535f, 0.01777608f, -0.15835290f, 0.32212940f, -0.02894904f, 0.52056754f, 0.00317010f, 
    -0.05517348f, -0.18572028f, 0.05254791f, -0.19179748f, 0.11962722f, 0.05219118f, 0.02422847f, -0.02840524f, 
    -0.23487668f, -0.00947492f, 0.32689419f, -0.28086925f, -0.15291548f, 0.13804494f, 0.08598056f, 0.08701775f, 
    -0.09434330f, -0.08653682f, 0.29662332f, -0.03052638f, 0.38538486f, -0.42975831f, -0.31789669f, 0.18807706f, 
    -0.00515934f, -0.04969148f, -0.11107001f, 0.04556873f, -0.01848505f, 0.03432511f, 0.09877571f, -0.13242355f, 
    0.19536649f, 0.03839390f, -0.43038586f, 0.21234719f, 0.06931705f, -0.11330525f, 0.11696621f, 0.10518502f, 
    -0.09156866f, 0.00679382f, -0.18454212f, 0.03035253f, 0.20483489f, -0.24400374f, 0.06253882f, 0.03743601f, 
    0.16345491f, 0.11556216f, -0.21037304f, 0.00939633f, 0.03853679f, 0.13283843f, 0.21772377f, 0.23298678f, 
    -0.25457472f, 0.02696261f, -0.16130149f, 0.25411993f, 0.11343484f, 0.02330646f, -0.09801578f, 0.13864873f, 
    0.17198426f, 0.03501814f, 0.04656833f, -0.10464223f, 0.28925616f, 0.40109912f, 0.55291510f, 0.13410936f, 
    0.00886784f, 0.12167738f, 0.14251541f, -0.19262668f, 0.11978928f, -0.12456861f, -0.16731340f, -0.26166227f, 
    0.12249757f, 0.45041054f, 0.30223635f, 0.20202306f, -0.00724724f, 0.17490035f, -0.01202982f, 0.06789417f, 
    0.01421258f, 0.00195673f, 0.07704869f, 0.06855418f, 0.25090197f, 0.52635592f, 0.36189410f, -0.17267855f, 
    0.10464846f, -0.33653742f, -0.19189101f, 0.13767505f, -0.07015684f, 0.02634390f, -0.00063715f, -0.10797630f, 
    -0.39578080f, -0.01772612f, -0.06193974f, 0.10988725f, -0.17486157f, 0.05723946f, -0.14623880f, 0.26160741f, 
    -0.02567108f, 0.03696467f, -0.22859909f, -0.07705162f, 0.27157217f, -0.07280051f, 0.10125849f, 0.15260431f, 
    -0.11566746f, 0.20805326f, 0.20967203f, -0.04271949f, 0.20383215f, -0.02223854f, 0.10806109f, 0.22394028f, 
    -0.08359239f, 0.35158205f, 0.16271414f, -0.18847367f, 0.20486800f, -0.09181447f, -0.23099762f, 0.11949386f, 
    0.07010246f, 0.02383488f, 0.07862642f, -0.10948457f, 0.16729067f, -0.01143084f, 0.06196209f, -0.24986622f, 
    0.07383954f, -0.14194173f, 0.14482978f, -0.00249734f, 0.16476369f, -0.03444948f, -0.02244096f, -0.02684638f, 
    0.14138736f, 0.32951424f, -0.04672090f, -0.20257224f, -0.08457077f, -0.01880543f, -0.14847720f, 0.25223926f, 
    0.00368025f, -0.12348080f, 0.03038966f, -0.13240536f, 0.15374626f, -0.04085696f, 0.12873325f, -0.19955595f, 
    -0.02078620f, -0.12681137f, -0.09092171f, -0.06258838f, 0.09601449f, 0.04305490f, 0.19803107f, -0.05517351f, 
    -0.02224820f, 0.11877179f, 0.23380703f, -0.03279094f, 0.05198851f, -0.00759236f, 0.11915638f, 0.01606731f, 
    0.18063672f, 0.16759865f, -0.17095555f, 0.03617638f, 0.04961888f, -0.17296383f, -0.06905472f, -0.21554442f, 
    -0.09714688f, 0.05706948f, -0.03421597f, 0.00920765f, 0.06197858f, -0.09982973f, 0.00719783f, 0.04345984f, 
    0.51500076f, -0.15627743f, -0.06385250f, -0.19264118f, 0.04722753f, -0.05620277f, -0.00051742f, 0.07867020f, 
    0.00094167f, 0.05974289f, 0.19017404f, 0.08711837f, 0.15476942f, 0.09335393f, 0.17128079f, 0.05565029f, 
    0.00052858f, 0.09466154f, 0.01070490f, 0.00514243f, 0.04312927f, 0.13611861f, -0.19077344f, 0.11151300f, 
    0.24992014f, -0.30968174f, -0.17729053f, -0.00596317f, -0.00452096f, 0.11368882f, 0.17843407f, -0.09104553f, 
    -0.01432768f, -0.15844058f, 0.04360484f, 0.00536532f, -0.03519110f, 0.16886158f, 0.19064513f, 0.02179740f, 
    0.21004701f, 0.02399884f, -0.08462377f, -0.03917868f, -0.27276671f, 0.01343106f, 0.01841564f, 0.06174025f, 
    -0.47049797f, -0.10209787f, -0.19150798f, -0.08485809f, -0.02186681f, 0.08604630f, -0.01860235f, -0.14063445f, 
    0.03869749f, 0.11608411f, -0.05717167f, -0.04447689f, -0.20895313f, 0.09922207f, -0.07953904f, -0.24776874f, 
    0.04108489f, 0.06464469f, 0.02979349f, -0.03357479f, -0.01658585f, 0.02310437f, 0.01450355f, -0.03507479f, 
    0.32821950f, 0.27084899f, 0.03829407f, 0.05652291f, 0.02716036f, -0.00580233f, 0.13734680f, -0.01445824f, 
    0.03680424f, -0.01775086f, -0.09575476f, -0.03938649f, -0.09425005f, 0.33771396f, -0.25557417f, -0.15292779f, 
    0.02634943f, -0.12048274f, -0.15880407f, -0.10297399f, -0.06195844f, -0.00241254f, 0.15542421f, 0.03435386f, 
    0.51462597f, 0.05182329f, 0.31248808f, 0.17935894f, 0.16807678f, -0.16611621f, 0.06972580f, 0.08788718f, 
    0.06920286f, -0.16541831f, 0.10655891f, 0.12570068f, 0.09101345f, 0.04102131f, -0.07499519f, 0.25662467f, 
    0.02885216f, -0.02921984f, 0.00894008f, -0.01738297f, -0.07171096f, -0.19057746f, -0.03372369f, 0.10831717f, 
    -0.27114499f, -0.31812483f, -0.25744167f, 0.17104492f, -0.33506343f, 0.00797314f, -0.02222687f, 0.06235068f, 
    -0.09879641f, -0.08036152f, -0.07051180f, 0.05272797f, -0.26999679f, 0.00975665f, 0.05632284f, 0.17772445f, 
    0.10180447f, 0.03220535f, 0.17296503f, 0.07343105f, 0.13978682f, 0.08437593f, 0.12806883f, 0.04284270f, 
    -0.07259788f, -0.12140147f, 0.05602298f, -0.10718516f, 0.24709038f, 0.20340987f, -0.13665709f, 0.03613046f, 
    0.05311907f, -0.00613109f, 0.06659721f, 0.20159191f, -0.40765229f, 0.56299824f, -0.04254254f, 0.46071404f, 
    -0.06244057f, -0.11935930f, 0.03353272f, 0.22580789f, -0.06661759f, -0.00603094f, -0.02192951f, 0.12176124f, 
    0.05728789f, 0.12826964f, -0.05081007f, -0.16675426f, -0.28821072f, 0.00167706f, 0.19003023f, 0.08564172f, 
    0.07913655f, 0.05355725f, 0.25562349f, -0.17978331f, -0.34999922f, 0.15812600f, -0.21302977f, 0.29367137f, 
    0.12004901f, 0.21602391f, 0.05697772f, -0.03337825f, 0.14751761f, 0.12829582f, -0.24339634f, -0.03366459f, 
    0.48461580f, 0.48799631f, -0.15271620f, 0.14834704f, 0.02326590f, 0.08087130f, 0.16849540f, 0.11256906f, 
    0.21634066f, 0.08082641f, 0.35018283f, 0.03676556f, 0.45377746f, 0.24608903f, 0.06497438f, -0.08712294f, 
    -0.20139326f, -0.11721880f, 0.00644810f, -0.05617182f, 0.28659856f, 0.17731218f, 0.34836346f, 0.00942516f, 
    -0.26139775f, 0.05053191f, 0.11144490f, 0.06902163f, -0.03692317f, -0.03252158f, 0.12065486f, 0.09928335f, 
    0.03478226f, -0.06044992f, -0.23579097f, -0.30857381f, 0.11156637f, 0.09352034f, -0.03263538f, -0.03184145f, 
    -0.18254551f, -0.11730059f, -0.08274131f, -0.01535878f, 0.43977296f, 0.18450160f, 0.11324788f, 0.11158815f, 
    0.27078846f, 0.02827922f, -0.02555593f, 0.07914130f, 0.08572421f, -0.12932168f, 0.16187228f, 0.13060483f, 
    0.01984830f, -0.20051537f, -0.09317808f, 0.13088962f, -0.28477368f, -0.19403507f, 0.09148070f, -0.01069081f, 
    -0.08131560f, -0.11785056f, 0.03789775f, 0.06802481f, -0.14929305f, -0.06772467f, -0.05084339f, -0.13173720f, 
    -0.38707501f, -0.10652944f, 0.33391845f, 0.29402754f, -0.01583330f, -0.05998420f, 0.06884211f, -0.09147035f, 
    0.14171562f, -0.02790390f, 0.00258381f, -0.10374002f, -0.00621602f, -0.04480001f, 0.14237657f, 0.17490266f, 
    -0.04086488f, 0.04459432f, -0.01938500f, 0.17071250f, -0.07780332f, -0.02569054f, -0.04610497f, -0.00375922f, 
    0.03040292f, 0.00527062f, 0.01747656f, 0.06169853f, 0.00505208f, -0.03299849f, -0.00407229f, 0.06297409f, 
    -0.05465601f, -0.00157821f, 0.03564623f, -0.06666247f, -0.03157048f, 0.00031643f, -0.02921497f, 0.01122316f, 
    0.05020095f, 0.04927549f, -0.03402297f, 0.05532202f, 0.04019915f, -0.02273288f, 0.00395030f, -0.06824055f, 
    0.01113813f, 0.05736573f, 0.03714035f, -0.00390739f, -0.00172924f, 0.01046947f, 0.05803004f, 0.05254507f, 
    0.05550469f, 0.00154784f, -0.00644160f, -0.00692847f, -0.05985377f, -0.05947930f, -0.00555981f, -0.06583200f, 
    -0.05893996f, -0.07164767f, 0.04004383f, 0.01646140f, 0.01363475f, -0.06136062f, -0.07604711f, 0.01681277f, 
    0.05286658f, 0.05165555f, -0.01592130f, -0.05876626f, 0.00631107f, 0.05007635f, -0.05969382f, -0.07314649f, 
    -0.03771322f, -0.01613544f, 0.01043181f, 0.06106211f, 0.06060223f, -0.04966044f, -0.06139718f, -0.06012430f, 
    -0.00388421f, -0.03865151f, -0.01620170f, 0.01087844f, -0.00121157f, -0.05997453f, 0.05852433f, -0.07484543f, 
    -0.06275720f, 0.05305563f, 0.04691955f, -0.06389383f, 0.06424193f, 0.00583021f, 0.03206393f, -0.03643394f, 
    -0.03769025f, -0.06146586f, 0.06476567f, -0.00131028f, -0.04312722f, 0.04801559f, -0.06675275f, -0.07262620f, 
    0.04486564f, -0.02035165f, -0.07730876f, -0.06348326f, -0.06177669f, 0.04155893f, -0.01730726f, 0.03031210f, 
    0.05023961f, -0.03047350f, -0.06044384f, -0.05283775f, -0.02091401f, 0.06557138f, -0.03351856f, -0.06823536f, 
    -0.04088509f, 0.03350461f, 0.02698821f, 0.01896822f, 0.05005641f, -0.06325550f, -0.05235131f, 0.02882372f, 
    -0.01102618f, -0.01124149f, -0.00884777f, -0.04471276f, -0.06496917f, -0.07010853f, -0.01129307f, -0.02381238f, 
    0.03822720f, -0.00949369f, -0.03351006f, -0.00012800f, 0.03981997f, 0.04886260f, -0.06140076f, 0.00577170f, 
    -0.05697291f, -0.04964263f, 0.06400006f, -0.02476583f, -0.04512386f, -0.06968266f, -0.07175343f, -0.05488889f, 
    0.02415021f, -0.06818303f, 0.01770549f, 0.00095250f, -0.04518824f, 0.00536029f, -0.02276641f, 0.00827527f, 
    0.03893529f, -0.05803611f, -0.06568513f, -0.01002898f, 0.01014765f, 0.01984609f, 0.03520980f, -0.05180670f, 
    -0.06455468f, 0.00133047f, 0.04343742f, 0.00889847f, -0.04557071f, 0.02459023f, -0.03550742f, -0.01226492f, 
    0.01419211f, 0.01124371f, 0.01461692f, 0.03730815f, 0.02642937f, 0.04128471f, 0.05225088f, -0.01125001f, 
    -0.00261860f, 0.03642677f, -0.02793718f, -0.03821971f, 0.01179146f, 0.06163220f, 0.01697667f, 0.03109641f, 
    0.00059401f, -0.00484483f, 0.00177656f, 0.00228286f, 0.04498818f, 0.02663207f, 0.05833536f, 0.02190965f, 
    -0.03923979f, 0.01813277f, -0.06488668f, 0.01835781f, -0.07211544f, -0.07750256f, 0.03130976f, -0.04987699f, 
    -0.40035874f, 0.13619496f, 0.11877341f, -0.05135008f, 0.05664954f, -0.07487276f, 0.17044282f, 0.00902440f, 
    0.32139021f, 0.07402108f, -0.09956253f, -0.10686123f, 0.02050225f, -0.35043162f, 0.23314363f, -0.18200509f, 
    0.06221946f, 0.18195640f, 0.06671196f, 0.03642124f, 0.19722326f, -0.07699162f, 0.06005893f, 0.36409739f, 
    -0.16933031f, -0.21873604f, -0.20799553f, 0.43199819f, -0.16333254f, 0.14625067f, 0.08906141f, 0.16242002f, 
    0.15538621f, 0.14043118f, -0.04593658f, 0.07745979f, -0.00870506f, 0.14495961f, 0.20058204f, 0.05578790f, 
    -0.08668700f, 0.10049212f, 0.04315376f, 0.03913442f, -0.02131713f, 0.06594009f, -0.18441236f, -0.11224466f, 
    -0.04917835f, 0.01242039f, 0.12205167f, -0.02727130f, -0.00310904f, 0.00850386f, 0.09017652f, 0.09871978f, 
    -0.16926350f, -0.10298709f, -0.01319921f, -0.02602959f, 0.55670124f, -0.53752083f, -0.07886967f, -0.07263067f, 
    -0.11014053f, 0.22667699f, -0.06201356f, 0.14920312f, -0.00248338f, 0.19831191f, 0.13837092f, 0.00419551f, 
    -0.05029235f, -0.13023461f, 0.01317262f, -0.48562554f, -0.18038532f, -0.06110065f, -0.06284902f, -0.06503510f, 
    0.04805996f, -0.12414494f, -0.01963124f, 0.09495914f, 0.20087112f, -0.01521272f, 0.36002958f, -0.10175226f, 
    0.16906343f, 0.10757767f, -0.20490861f, 0.22152747f, -0.05980376f, -0.08143739f, 0.20407404f, 0.00183454f, 
    0.26592115f, 0.05924465f, 0.14326255f, -0.37859097f, 0.08679283f, -0.08272452f, -0.01718498f, 0.12202343f, 
    0.08017774f, -0.10548624f, 0.04618307f, -0.11095612f, 0.54639226f, -0.47374311f, -0.15317675f, 0.26085800f, 
    -0.15235226f, -0.09411785f, 0.19834714f, -0.10595780f, 0.21850668f, 0.10741957f, -0.15428835f, 0.04473533f, 
    -0.11013447f, -0.28487292f, 0.10985209f, 0.04940598f, -0.06647176f, -0.09416889f, -0.26381937f, -0.01046934f, 
    0.06299352f, -0.06682023f, 0.13857336f, 0.03602762f, -0.12220325f, -0.54444802f, -0.16913080f, -0.19411781f, 
    -0.13638568f, -0.18919322f, 0.01502018f, -0.13953738f, -0.09937949f, -0.23422891f, 0.00109609f, -0.22728013f, 
    -1.13232589f, 0.32411510f, -0.03939496f, -0.26051497f, -0.12961701f, -0.15942416f, -0.24119259f, 0.09275570f, 
    0.15330225f, -0.18931037f, 0.03951177f, 0.10652231f, 0.15066336f, 0.13558170f, 0.08929447f, 0.02658683f, 
    -0.06196432f, 0.02919371f, 0.10146210f, 0.04015647f, -0.06076955f, -0.02670181f, 0.05318336f, 0.07581178f, 
    -0.01358886f, 0.28036031f, 0.29758525f, -0.10666063f, -0.04267669f, 0.14702892f, 0.12510559f, 0.05291497f, 
    0.04786871f, 0.07044522f, -0.11485966f, 0.00534117f, -0.05047367f, -0.18614252f, -0.01973248f, -0.23942402f, 
    0.03082248f, 0.00469337f, 0.17682548f, 0.06476964f, 0.14138673f, -0.06488642f, 0.15412851f, 0.18270929f, 
    -0.23276044f, 0.15996000f, 0.13498683f, 0.02556828f, 0.02536741f, -0.21056154f, -0.04236704f, 0.00258573f, 
    0.05630352f, 0.28056338f, 0.08176910f, -0.08767349f, -0.04273132f, 0.19043869f, -0.47123328f, -0.00597322f, 
    0.12266137f, -0.08495159f, 0.02089681f, 0.35957938f, 0.06503621f, 0.05415704f, -0.07860337f, -0.07339048f, 
    0.86004686f, 0.09898746f, -0.10905233f, -0.17475407f, 0.21317685f, -0.03910290f, 0.11885421f, 0.12517771f, 
    -0.02924841f, 0.14456955f, 0.11138535f, 0.08946402f, -0.10855139f, -0.21483977f, 0.07569943f, 0.20238872f, 
    -0.01454286f, -0.07190664f, -0.12610723f, -0.01208003f, 0.28457949f, 0.10237441f, 0.07714248f, 0.18174827f, 
    -0.13765414f, -0.23732050f, 0.30131620f, 0.14279455f, 0.08523747f, 0.12336538f, 0.18664478f, -0.17818551f, 
    0.01169707f, 0.14201427f, 0.27820534f, 0.10099231f, 0.06491494f, 0.20377891f, -0.00834957f, 0.14258555f, 
    0.17189148f, -0.08359343f, 0.17745069f, -0.12949114f, -0.05610661f, -0.00908161f, -0.05611129f, 0.06607128f, 
    -0.10930159f, -0.09111179f, 0.10884010f, 0.17867517f, -0.02069701f, 0.03756834f, -0.16447692f, 0.19778392f, 
    -0.05463618f, 0.18104865f, 0.02626969f, -0.07655482f, -0.07676163f, -0.10163610f, -0.07822436f, -0.01669669f, 
    0.06806019f, -0.03512805f, 0.07135230f, 0.14139451f, 0.14433977f, 0.01829664f, -0.12967765f, -0.09016836f, 
    -0.02895381f, -0.34723398f, -0.04631953f, 0.21167137f, 0.01274746f, 0.15159690f, 0.11824487f, 0.11764981f, 
    -0.13312721f, 0.19501679f, -0.01336293f, -0.01664109f, 0.19330372f, -0.06507751f, 0.02228278f, 0.01809694f, 
    -0.01761873f, -0.00491839f, 0.09023421f, 0.12164100f, -0.08891996f, 0.13253342f, 0.19264774f, -0.01060524f, 
    -0.40362448f, -0.00699128f, -0.12310874f, 0.09130900f, -0.05331144f, -0.03738213f, 0.03333804f, -0.05930175f, 
    -0.01913787f, 0.08718742f, -0.08353639f, -0.05700040f, 0.25018361f, -0.08374422f, 0.10180340f, -0.02714168f, 
    0.03157646f, 0.11901359f, -0.02166616f, 0.14057033f, -0.13879123f, 0.16947354f, -0.09483995f, 0.08199429f, 
    -0.10466145f, -0.07560015f, -0.02151952f, -0.30670819f, -0.02673686f, -0.02413684f, -0.12738194f, 0.13375001f, 
    -0.03153041f, 0.12973408f, 0.09446241f, -0.02938778f, -0.26287186f, -0.17727174f, -0.12303875f, -0.01551090f, 
    -0.08336683f, -0.27857807f, -0.10455835f, -0.02304123f, 0.06338754f, -0.08727804f, -0.09483062f, -0.03026271f, 
    -0.04279588f, -0.22425628f, 0.04004828f, -0.10990274f, -0.05812684f, 0.02478611f, 0.09262705f, -0.04148259f, 
    0.14515428f, 0.17491050f, 0.14958361f, 0.03189515f, 0.24606732f, -0.00213195f, 0.17668155f, -0.06456961f, 
    -0.09339958f, 0.02660979f, 0.07844604f, -0.22213402f, 0.00419834f, 0.01133837f, -0.11453100f, -0.07139528f, 
    -0.01602571f, -0.06639682f, -0.07210782f, -0.05982285f, 0.03617660f, -0.05587627f, 0.02067950f, -0.03600593f, 
    0.03334424f, -0.06993265f, -0.01425612f, -0.06520987f, 0.00341148f, -0.04816968f, 0.00633157f, -0.09110893f, 
    0.02163954f, 0.00154569f, -0.04339875f, -0.02798358f, -0.08091500f, -0.07148307f, -0.07604193f, -0.05150715f, 
    -0.02738276f, 0.04701691f, 0.01691788f, 0.03357199f, 0.01657788f, 0.01386276f, -0.06486643f, -0.05048877f, 
    -0.06753070f, -0.06548189f, -0.02761106f, -0.01686898f, 0.04305794f, 0.00637322f, -0.00358502f, -0.05442101f, 
    -0.05117746f, 0.00080662f, -0.05014124f, -0.02277041f, 0.01116575f, 0.06805816f, -0.05622603f, -0.00597150f, 
    0.02028852f, 0.01818686f, -0.06485889f, 0.04647699f, -0.02761702f, 0.00081449f, -0.00293698f, -0.02435661f, 
    -0.00131854f, -0.04559002f, -0.00458747f, -0.08185676f, -0.01927035f, 0.01851060f, -0.04318298f, 0.02099223f, 
    -0.01940034f, -0.05919294f, -0.07873034f, -0.03808932f, 0.00711292f, 0.00991841f, -0.06942699f, -0.04150290f, 
    -0.08121036f, -0.02814206f, -0.09748767f, 0.00960871f, -0.01551423f, 0.00303094f, 0.04062667f, -0.03654432f, 
    -0.01609406f, 0.02529736f, 0.01566139f, -0.04615392f, -0.08263543f, -0.01879922f, 0.00697941f, -0.05039546f, 
    -0.05074940f, -0.06168412f, 0.00736328f, 0.03714648f, -0.06895481f, -0.00221124f, -0.00081160f, 0.03849431f, 
    0.03171594f, -0.04780240f, 0.00379180f, -0.00461548f, -0.04682253f, -0.02926848f, 0.02145046f, 0.01982669f, 
    -0.01558530f, -0.03237204f, -0.02258087f, -0.06527450f, -0.06707101f, 0.01529282f, -0.05439468f, 0.02318546f, 
    0.04220356f, -0.02337618f, -0.01865119f, 0.03539393f, -0.08640071f, 0.01112156f, -0.00232007f, -0.00845564f, 
    0.03279996f, -0.08587112f, -0.00511704f, -0.03544392f, -0.03162719f, -0.05143531f, -0.07235464f, 0.01450149f, 
    0.03114057f, -0.09902652f, 0.02748844f, 0.03581678f, 0.00617663f, -0.07613000f, -0.05140478f, 0.04511438f, 
    -0.07741488f, 0.01734046f, 0.02973735f, -0.03679617f, -0.00493274f, -0.04305181f, -0.03738651f, -0.05311940f, 
    0.03520764f, -0.06213057f, -0.09142075f, -0.03396951f, -0.00038793f, 0.02031057f, -0.06500226f, 0.05290625f, 
    -0.05489245f, -0.06562024f, -0.02227227f, 0.02325205f, -0.02569843f, 0.03518507f, -0.02761113f, 0.03956547f, 
    -0.09313147f, -0.04802744f, 0.00735405f, -0.01069069f, -0.08043078f, -0.05786116f, -0.01094850f, -0.00445454f, 
    -0.08339997f, 0.05046215f, 0.03406798f, 0.00370915f, -0.00561646f, -0.01457992f, 0.03425897f, 0.02982406f, 
    -0.08841279f, -0.01674777f, -0.04822439f, 0.00106915f, -0.01956483f, 0.04279485f, -0.01576037f, 0.00984879f, 
    -0.02589094f, 0.01328353f, 0.01736569f, -0.08515068f, -0.06494852f, -0.04294794f, -0.06495267f, 0.02629043f, 
    0.10451322f, -0.18945359f, 0.23144339f, 0.24664943f, 0.04389749f, 0.15178858f, 0.01946462f, 0.14474775f, 
    0.15707113f, 0.19726987f, 0.02868195f, -0.01295386f, 0.19312589f, -0.18727018f, 0.29531729f, -0.06360955f, 
    0.14590573f, -0.06319291f, 0.08824363f, -0.13472535f, 0.17729682f, -0.07153626f, -0.05006217f, -0.04746254f, 
    -0.24377072f, -0.03331840f, -0.35358202f, 0.21241741f, -0.10335802f, 0.08836330f, -0.07657193f, -0.06919426f, 
    -0.11081471f, -0.18642499f, -0.03211176f, -0.15492103f, -0.20130226f, -0.36475688f, -0.29768986f, -0.19183500f, 
    0.01868824f, 0.10969594f, -0.01045109f, -0.13497500f, -0.08375322f, 0.10622763f, 0.16695902f, -0.03785774f, 
    -0.28651214f, 0.09087901f, -0.11239589f, -0.33704957f, 0.09819639f, 0.26670742f, -0.35603797f, -0.06295528f, 
    0.04833247f, 0.00908584f, 0.13896152f, 0.14983162f, -0.01024161f, -0.31990159f, -0.03185105f, 0.03980988f, 
    -0.08699874f, 0.20596321f, -0.02632518f, 0.27654099f, -0.03657909f, -0.00989854f, 0.01131442f, -0.11455150f, 
    -0.04906577f, 0.13128828f, 0.23132606f, -0.15717170f, 0.05062832f, -0.09362096f, 0.05012091f, -0.00526376f, 
    -0.07893866f, 0.06288598f, 0.12718210f, 0.24371412f, -0.15221533f, 0.05162708f, -0.13254833f, -0.19206993f, 
    -0.06167632f, 0.09603179f, 0.18666162f, -0.02723663f, 0.12692161f, 0.17193948f, -0.01237403f, 0.00994267f, 
    0.10548652f, 0.55290329f, 0.11335636f, -0.16381991f, 0.05378133f, -0.04315376f, 0.09813692f, -0.20511767f, 
    0.26414117f, 0.22735357f, 0.02898750f, 0.17942376f, -0.05385433f, 0.41705146f, 0.08367094f, 0.03185128f, 
    -0.06513631f, -0.06743631f, -0.05144211f, -0.04399488f, 0.13220546f, 0.05071821f, 0.03901505f, 0.13581514f, 
    0.23611508f, 0.06340848f, 0.45675185f, 0.10485647f, 0.04452326f, -0.09561793f, -0.14656895f, -0.20743074f, 
    0.17640103f, -0.22581108f, 0.21565057f, 0.20162463f, 0.03765285f, 0.15647793f, 0.03872744f, 0.03660358f, 
    -0.15052536f, -0.06101938f, 0.07325587f, -0.01174356f, 0.24084611f, 0.03240518f, 0.07694601f, 0.17780709f, 
    0.23084775f, 0.41613597f, 0.06342555f, 0.19973983f, -0.09458095f, -0.08349983f, -0.03089222f, -0.23814592f, 
    0.00209499f, -0.02511292f, 0.02228839f, 0.28300381f, -0.58530289f, -0.46641335f, -0.27635768f, -0.36042991f, 
    0.09315550f, -0.24039452f, -0.01714306f, -0.17200357f, -0.03687783f, -0.04691497f, 0.01404405f, -0.08640822f, 
    -0.21019165f, -0.10057890f, 0.32360694f, -0.11894640f, -0.18474528f, -0.22792830f, -0.07003883f, -0.12792517f, 
    -0.01117977f, -0.04232680f, -0.00021734f, 0.04968846f, -0.33093685f, -0.09194250f, -0.14761440f, -0.18220407f, 
    0.16871737f, 0.16520210f, 0.19933164f, 0.17464292f, 0.04079993f, 0.07343536f, 0.10425647f, 0.09351527f, 
    -0.18377912f, 0.11425376f, -0.05216259f, 0.12381524f, 0.14328477f, -0.03778929f, -0.05615523f, 0.02996410f, 
    0.19035740f, 0.27423042f, 0.12376616f, -0.00281104f, -0.15788750f, 0.00046373f, -0.06210072f, -0.09018902f, 
    0.13072373f, -0.01334243f, -0.09536293f, 0.03721936f, 0.17793563f, 0.04538395f, -0.14033471f, -0.03329106f, 
    0.97987914f, -0.34067938f, 0.03715347f, 0.20739459f, 0.22974600f, -0.11537782f, 0.20810863f, 0.03228702f, 
    -0.11009374f, 0.08012026f, -0.03139972f, 0.17024986f, -0.09884334f, -0.18908444f, 0.06776395f, 0.01078625f, 
    -0.04277302f, 0.17991130f, -0.17669548f, -0.14065908f, 0.08635513f, -0.00768604f, -0.06073068f, 0.02070312f, 
    -0.18384317f, -0.11185142f, 0.35452881f, 0.15868407f, 0.05816359f, 0.04374643f, 0.20045978f, -0.07717486f, 
    -0.03708722f, 0.12211633f, 0.03568923f, 0.01999755f, 0.42272037f, -0.27921292f, 0.13629125f, 0.19573019f, 
    0.32079318f, 0.09082925f, 0.21292643f, -0.07243243f, -0.07530500f, -0.02211160f, -0.14851916f, 0.03929642f, 
    -0.19824323f, -0.06538549f, -0.05657435f, -0.12182509f, -0.01987805f, -0.01394809f, -0.13549785f, 0.14213651f, 
    0.11288656f, -0.01685068f, 0.06722289f, -0.01211281f, 0.23306379f, 0.03385785f, 0.06288650f, 0.02063837f, 
    0.08452689f, 0.09470022f, 0.11809321f, -0.12258765f, -0.02974374f, -0.07234396f, 0.07031891f, -0.15317431f, 
    -0.55217719f, 0.16935401f, -0.11354324f, 0.07478796f, -0.01867291f, 0.32443723f, 0.24928512f, -0.21854787f, 
    0.06408498f, 0.12340548f, 0.04188695f, -0.01361049f, 0.03304890f, -0.12971403f, -0.17767350f, 0.10008065f, 
    -0.00460100f, -0.09860723f, -0.10420805f, 0.19635618f, 0.04511853f, 0.04614048f, 0.09783450f, 0.05670368f, 
    -0.33838657f, -0.13943176f, 0.27997208f, 0.35158217f, -0.01171717f, 0.07234763f, 0.00424734f, 0.16517004f, 
    0.04960164f, 0.05562765f, 0.07346544f, -0.14546151f, -0.10928025f, -0.43119583f, -0.23219258f, -0.19594555f, 
    -0.11713994f, 0.14566730f, 0.09811236f, 0.27382776f, 0.05733962f, 0.06717855f, 0.07514562f, -0.01884948f, 
    -0.24213365f, -0.00278405f, -0.04749631f, -0.05315867f, 0.01860723f, -0.04515065f, -0.00236539f, 0.31459585f, 
    -0.01632704f, 0.05406512f, 0.16965801f, 0.05396640f, 0.05055211f, -0.15504110f, -0.04970711f, 0.04980724f, 
    0.02629295f, 0.05420828f, -0.06672537f, -0.15166543f, 0.01408388f, -0.13190050f, -0.21148205f, 0.03373414f, 
    -0.23072451f, -0.06371953f, 0.02805441f, -0.22748786f, 0.05520819f, 0.00476593f, 0.04529992f, -0.13037987f, 
    -0.11838564f, 0.04826327f, 0.01822787f, -0.00208595f, 0.12535344f, -0.00362918f, 0.63332939f, 0.09694984f, 
    0.15475878f, 0.11608425f, 0.14892523f, 0.06433576f, 0.02369367f, -0.06828611f, -0.05529790f, -0.01402039f, 
    -0.18949525f, -0.09200457f, 0.02787504f, 0.06992856f, -0.11283205f, -0.04452527f, 0.03934612f, 0.00841789f, 
    0.14170241f, 0.09795114f, 0.12551385f, 0.12437839f, 0.20000897f, -0.44262165f, 0.33783311f, -0.40459388f, 
    0.17892461f, -0.11482827f, -0.07859143f, -0.34235913f, -0.17235760f, -0.00170068f, -0.09406684f, -0.35852700f, 
    -0.17287639f, 0.02110028f, -0.08537514f, 0.33100176f, 0.11150039f, 0.23669551f, -0.13658200f, -0.35110301f, 
    0.13166146f, -0.11137131f, 0.04249363f, -0.02304506f, 0.07380296f, -0.01430440f, 0.01473045f, 0.16959026f, 
    0.05988433f, 0.08379660f, 0.06545839f, 0.05882740f, 0.20288365f, 0.16118008f, -0.00497933f, 0.06789188f, 
    -0.17664644f, -0.00015913f, 0.00698388f, 0.31508586f, 0.09612180f, 0.06103832f, 0.23400162f, 0.03368876f, 
    0.18063620f, 0.12902598f, 0.08163219f, 0.21111742f, 0.45071957f, -0.73225123f, 0.03992538f, -0.19914207f, 
    0.06940353f, 0.25859874f, -0.16835749f, -0.03347440f, -0.04352662f, 0.03302461f, -0.06581904f, -0.08410055f, 
    0.14041345f, 0.01503776f, 0.31594390f, -0.10308363f, -0.05159786f, -0.37730637f, -0.13301508f, -0.15658438f, 
    0.05974377f, 0.02623735f, 0.08302277f, -0.13289155f, -0.07746936f, 0.01920896f, 0.40823567f, -0.05346221f, 
    -0.11609776f, -0.08935746f, 0.10189661f, 0.04247419f, 0.06542969f, 0.14176938f, 0.05997722f, 0.04848181f, 
    -0.09271517f, 0.10227875f, 0.32298321f, -0.41263932f, 0.11330946f, -0.08638322f, 0.15113927f, -0.02853644f, 
    -0.04274433f, 0.11128426f, -0.00003856f, 0.16104418f, -0.22202758f, 0.07732996f, -0.02682488f, 0.01359411f, 
    0.05410377f, -0.38137209f, -0.02240425f, -0.00051938f, -0.09494812f, 0.15078577f, 0.05006545f, 0.12784021f, 
    0.36722609f, 0.29735142f, 0.16923362f, -0.01447320f, -0.17671564f, -0.07342651f, -0.17323132f, 0.04089239f, 
    0.19707157f, -0.09843341f, 0.00977478f, -0.00167531f, -0.06754027f, -0.16679640f, -0.22037798f, -0.11418166f, 
    -0.01158307f, 0.06374627f, 0.29482868f, -0.14863215f, 0.12740321f, 0.06581449f, 0.19853975f, 0.16564819f, 
    0.17318757f, 0.22873633f, 0.00505727f, 0.24509962f, -0.42610386f, -0.22207606f, 0.07876554f, -0.21707238f, 
    0.19407195f, -0.03504384f, 0.05754683f, 0.21887037f, 0.07395656f, -0.07186807f, 0.06865031f, 0.04004736f, 
    0.13011777f, -0.05541402f, 0.07512009f, 0.32014331f, -0.06643836f, -0.31284398f, -0.02300279f, -0.11491375f, 
    -0.19846380f, -0.08716918f, 0.08153447f, -0.32284433f, -0.11588026f, 0.08629984f, -0.03815894f, 0.19555789f, 
    0.17424966f, 0.10209319f, 0.00139458f, 0.20189451f, 0.12235224f, -0.47858322f, 0.04714111f, 0.16097207f, 
    0.16883807f, 0.04468973f, 0.06746347f, -0.08546255f, 0.01337831f, -0.04314033f, -0.21666060f, -0.08686211f, 
    -0.22783314f, -0.06993482f, 0.00977374f, 0.03432978f, 0.07164623f, 0.07459084f, 0.00447233f, 0.06329258f, 
    -0.09383712f, 0.03938344f, -0.20101447f, -0.06789933f, 0.05357452f, -0.04591566f, 0.03183318f, 0.12351821f, 
    -0.07600801f, 0.12574883f, 0.02024587f, -0.20424961f, 0.08126949f, -0.06542715f, 0.05851239f, 0.20647997f, 
    -0.35286763f, 0.16285193f, 0.05589726f, -0.01347324f, -0.12776940f, -0.07709438f, -0.08974550f, 0.10087200f, 
    0.00711434f, 0.11085451f, 0.01851777f, -0.05349805f, 0.00844620f, 0.00545708f, 0.02347875f, -0.24327375f, 
    0.03520409f, -0.01989998f, 0.19520909f, 0.06661510f, 0.01650386f, 0.02221760f, -0.00508312f, 0.01522232f, 
    -0.15150928f, 0.07443395f, -0.14710152f, -0.19134246f, -0.07331895f, 0.13360335f, -0.14624780f, 0.16303454f, 
    -0.03951915f, -0.01663795f, 0.00901511f, -0.13656516f, -0.00724135f, -0.06970856f, 0.13079752f, 0.31902692f, 
    -0.04121092f, -0.05127538f, 0.05265941f, 0.02846530f, -0.06030368f, -0.00817052f, 0.06730875f, -0.09569518f, 
    0.12635240f, 0.19952953f, 0.14576896f, -0.10817581f, -0.05866681f, -0.14221196f, 0.08829772f, -0.06461877f, 
    0.24853259f, 0.18580252f, 0.05280429f, -0.09119314f, -0.01998374f, 0.04628751f, -0.14605877f, -0.10882962f, 
    -0.03019556f, 0.14786805f, -0.00539747f, 0.00538663f, 0.15673101f, -0.02388357f, 0.00155818f, 0.05764674f, 
    1.06498158f, 0.14067526f, -0.16281563f, -0.44784647f, 0.04103690f, 0.04307484f, -0.05343308f, -0.14324267f, 
    0.24212441f, -0.00753685f, 0.12290142f, 0.11874896f, 0.25205788f, 0.04076575f, 0.00902358f, 0.00385587f, 
    0.00084815f, -0.03393218f, 0.02194609f, -0.09795145f, -0.00812957f, -0.04461927f, -0.03731462f, 0.00360428f, 
    -0.17787385f, -0.27098691f, -0.03898830f, -0.04766967f, 0.12734619f, 0.10770127f, -0.02203832f, -0.17250155f, 
    -0.00325571f, -0.09799622f, -0.00368457f, 0.00533451f, -0.10629164f, -0.01130822f, 0.07969205f, 0.04647942f, 
    0.10072182f, 0.00263839f, -0.05776181f, -0.06239611f, -0.11922301f, -0.04373220f, 0.14633247f, -0.13214238f, 
    -0.53019166f, 0.14420632f, 0.05743247f, 0.14702804f, 0.14446865f, -0.00371727f, 0.01390404f, -0.12191021f, 
    -0.02351159f, 0.03393932f, -0.11524294f, -0.10970940f, -0.21474491f, 0.06235241f, 0.19545019f, -0.27686608f, 
    0.00821944f, 0.06617379f, 0.32974154f, 0.06837530f, -0.04225660f, 0.02361027f, 0.17392480f, 0.01611717f, 
    0.01835770f, 0.26678798f, 0.18374135f, 0.01238730f, 0.03079831f, 0.18846999f, 0.06506090f, -0.17605057f, 
    0.15469728f, 0.07899103f, 0.01795356f, 0.02498689f, -0.01278342f, 0.00218106f, -0.21662445f, 0.14869808f, 
    0.15781620f, 0.09074954f, 0.02349209f, -0.10840612f, 0.05486515f, 0.01940013f, 0.03286325f, 0.11009451f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09044080f, 0.05652750f, 0.06905810f, 0.13690084f, 0.24239494f, -0.16621049f, 0.08070169f, -0.18058987f, 
    0.14609952f, 0.04311242f, 0.03886050f, -0.04026435f, -0.18604633f, 0.03467976f, 0.04736693f, 0.02431247f, 
    0.15359224f, -0.01207682f, 0.04929670f, -0.03730873f, 0.20302686f, -0.06218658f, 0.08793265f, 0.23592335f, 
    -0.05736225f, 0.30226597f, 0.08584829f, -0.10003916f, 0.10884889f, 0.09600585f, 0.03126282f, 0.22889294f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.32229909f, -0.14775251f, -0.00200273f, 0.07438470f, 0.17325112f, -0.41055727f, 0.04184308f, -0.04330993f, 
    -0.06369742f, 0.59360319f, -0.05753223f, -0.23182137f, -0.16356814f, -0.14904512f, 0.06259983f, 0.00770194f, 
    0.22931845f, -0.22548492f, -0.00141706f, -0.15405820f, 0.46659589f, 0.32735100f, 0.26224971f, 0.01199697f, 
    0.08784656f, 0.66857016f, 0.05107547f, -0.13901125f, 0.25972030f, -0.06421525f, 0.29291993f, 0.27283669f, 
    -0.16406715f, -0.30485645f, -0.05651218f, 0.04203846f, 0.01978468f, 0.32663652f, 0.15620185f, 0.09938762f, 
    0.27369732f, -0.28359419f, 0.06129937f, 0.59720844f, -0.13700792f, 0.11690210f, -0.11928353f, -0.27894327f, 
    0.22842424f, -0.09194466f, 0.30544409f, 0.20467483f, -0.15832247f, -0.05391885f, 0.06685931f, 0.03662659f, 
    0.12062175f, -0.30866683f, -0.06864122f, -0.17127602f, -0.11333776f, 0.25647774f, 0.02159625f, -0.30507955f, 
    -0.04167288f, -0.19563164f, 0.24663083f, 0.06638180f, 0.02775015f, -0.20084196f, -0.03323640f, 0.02015529f, 
    0.07113699f, -0.15169875f, -0.06994442f, 0.21782047f, -0.19473779f, 0.06412303f, 0.35829595f, -0.17675067f, 
    0.08138189f, 0.14368874f, 0.32967642f, -0.08793142f, -0.25693572f, -0.43508834f, 0.16892202f, -0.05261017f, 
    0.14240640f, 0.19337052f, -0.04493285f, 0.13888361f, 0.43987018f, 0.13006976f, 0.12702689f, 0.06609781f, 
    -0.07302061f, 0.04691596f, -0.05969463f, -0.12930560f, -0.08764921f, -0.02547373f, 0.02708309f, 0.07141875f, 
    -0.25093988f, -0.12238517f, 0.02506297f, 0.04850803f, -0.05020370f, -0.12735288f, -0.13310640f, -0.03583837f, 
    -0.16958831f, 0.09662504f, -0.21974264f, -0.11757182f, -0.10256124f, 0.11538334f, 0.02314346f, -0.00073640f, 
    -0.00545757f, -0.09410790f, -0.11300986f, -0.00191880f, -0.31072536f, -0.21632342f, 0.13777040f, -0.27135420f, 
    0.33987308f, 0.10661124f, 0.23505709f, 0.42393830f, 0.26963022f, 0.14216922f, 0.10595799f, -0.11112300f, 
    -0.00944498f, -0.21438247f, 0.04233272f, -0.14242655f, 0.12790051f, -0.15314950f, 0.18253560f, -0.08654293f, 
    0.00924389f, -0.02875641f, -0.33638898f, 0.06481296f, -0.18877988f, -0.26646674f, -0.32700267f, 0.31277865f, 
    0.07864520f, -0.12073878f, -0.11711077f, 0.00251830f, 0.20615819f, -0.06124191f, 0.28787899f, 0.25801742f, 
    0.35416445f, 0.28122005f, 0.09453991f, 0.48097491f, 0.35955006f, 0.18360022f, -0.16488633f, -0.03189865f, 
    0.10193154f, -0.53338021f, -0.05492713f, -0.02151134f, 0.21792467f, -0.05800587f, 0.12138817f, 0.22780648f, 
    0.18968467f, -0.10448659f, 0.09473557f, 0.06234114f, 0.03391876f, 0.03960118f, -0.56601572f, 0.28664550f, 
    0.15078811f, -0.02579184f, -0.27138403f, 0.04596285f, -0.07397939f, 0.12676273f, -0.20906816f, -0.14277260f, 
    -0.02379746f, 0.01151726f, 0.10972632f, 0.31337705f, -0.15221582f, 0.13920489f, 0.11355486f, -0.01486150f, 
    0.00179783f, -0.10097999f, 0.13550071f, 0.00342673f, -0.26403338f, -0.00080391f, 0.10922907f, -0.54756653f, 
    0.15685125f, 0.41047660f, -0.01954853f, -0.10541502f, -0.13441022f, -0.05032798f, -0.42604983f, 0.17320156f, 
    0.03294754f, 0.38618138f, -0.08765741f, 0.08362269f, 0.11942243f, 0.37228578f, 0.47082171f, -0.02103287f, 
    0.01132297f, -0.43795446f, 0.05783741f, -0.07555886f, 0.12230451f, -0.33512050f, -0.18497704f, -0.48186633f, 
    0.23891053f, 0.01217155f, 0.11611400f, -0.23804648f, -0.09999716f, 0.12412295f, 0.07915755f, 0.23464911f, 
    0.39483565f, 0.01818928f, 0.47071138f, 0.33983457f, 0.31050149f, -0.08861238f, 0.22051589f, 0.16203554f, 
    -0.14185666f, 0.35367796f, -0.26949313f, -0.03982021f, 0.16203161f, 0.23416157f, -0.31484261f, 0.08980110f, 
    0.06747255f, -0.29883251f, -0.13250540f, -0.35609686f, -0.30061406f, 0.17506798f, 0.19445488f, -0.04424594f, 
    0.35641041f, -0.17993726f, 0.10401272f, 0.49778643f, 0.19309632f, -0.04808982f, -0.33290660f, -0.18358375f, 
    -0.25135040f, 0.55772060f, 0.04824198f, -0.17286766f, 0.01387968f, 0.27359551f, 0.04123885f, 0.19058770f, 
    -0.16380370f, -0.16597529f, -0.30990046f, 0.10309143f, 0.28626099f, -0.15829571f, -0.01546582f, -0.03830538f, 
    0.21412221f, 0.05422052f, -0.40470088f, 0.00761746f, -0.13367763f, 0.15355748f, -0.32454410f, 0.14168823f, 
    -0.36656123f, -0.34229875f, 0.14748035f, -0.37076932f, 0.47046855f, 0.02809841f, 0.19514899f, -0.00641548f, 
    -0.40085179f, 0.06434013f, -0.07870524f, 0.16197972f, -0.04791407f, -0.01295446f, -0.05375764f, -0.15700564f, 
    -0.13466530f, -0.41175732f, -0.08705588f, 0.07404224f, -0.21801500f, -0.08366240f, -0.22250693f, 0.01855853f, 
    0.22275469f, 0.59122819f, -0.04059642f, 0.13084716f, 0.26320064f, 0.06551633f, 0.17752345f, 0.02510553f, 
    -0.05372949f, 0.41525620f, -0.14008906f, -0.13363296f, 0.11328255f, -0.06916691f, 0.09176189f, -0.36799884f, 
    0.14524411f, 0.22645344f, -0.37897539f, -0.25194696f, 0.01412585f, 0.09959752f, -0.55649990f, 0.02541172f, 
    -0.08293704f, -0.00044565f, 0.17661691f, 0.00537093f, -0.22214803f, 0.00467074f, 0.39689177f, -0.24790141f, 
    -0.08726990f, -0.09167278f, -0.13554205f, -0.21502222f, 0.08476543f, -0.45820001f, -0.05391437f, 0.03301230f, 
    0.07602429f, 0.14083001f, -0.04264325f, 0.36005399f, -0.26527640f, 0.00980209f, -0.07569063f, -0.02225965f, 
    0.35304868f, -0.06194774f, 0.18017094f, -0.07804852f, 0.00310823f, 0.29079199f, 0.11346542f, 0.22448821f, 
    -0.04557683f, -0.09902102f, 0.52605915f, -0.11710341f, -0.26986974f, 0.33055955f, -0.33716258f, 0.00742803f, 
    -0.15809210f, -0.36202291f, 0.21469681f, 0.07218382f, 0.28454867f, -0.15602612f, -0.10009202f, 0.10122471f, 
    0.14258097f, -0.02593781f, -0.13505755f, 0.10903968f, 0.29254717f, 0.05224594f, -0.01752301f, 0.04466441f, 
    -0.06450051f, -0.41852424f, 0.40464956f, 0.27190119f, 0.27895829f, 0.27057680f, 0.03251193f, 0.21484140f, 
    -0.01108073f, 0.35903141f, -0.12371355f, -0.15393221f, -0.36259872f, -0.28342959f, -0.06445572f, 0.08010726f, 
    0.43955514f, 0.42379713f, -0.07330401f, -0.10783318f, 0.38582304f, -0.17070213f, 0.15531141f, -0.51863784f, 
    0.21737355f, 0.19803430f, 0.14313574f, -0.23984541f, 0.04381232f, 0.17817749f, -0.31333241f, 0.24332070f, 
    0.18129325f, 0.22924015f, -0.30986160f, -0.29949591f, 0.03606378f, 0.08854359f, 0.08502305f, 0.25241145f, 
    -0.05982475f, -0.13008755f, 0.25780806f, 0.03420978f, 0.17939901f, 0.20353653f, -0.03946152f, -0.05951063f, 
    0.29067621f, -0.24118382f, -0.31169054f, -0.06931443f, 0.06921126f, 0.01424927f, 0.21603329f, -0.17195968f, 
    0.37660888f, -0.05161243f, 0.15565923f, 0.04478752f, -0.14989132f, 0.16423605f, 0.13488023f, -0.11956065f, 
    0.41750309f, -0.11220156f, 0.07759297f, -0.01353955f, -0.05356899f, 0.12579598f, -0.13218202f, -0.02837423f, 
    -0.06498430f, -0.23480666f, 0.39106199f, 0.06294486f, -0.23700319f, 0.26273930f, -0.34126437f, 0.12342879f, 
    -0.42270967f, 0.56402737f, 0.19515550f, 0.18589953f, -0.20800486f, 0.72015792f, 0.12468440f, 0.15473233f, 
    0.12000153f, 0.10411321f, 0.03233624f, 0.50823087f, -0.02676696f, -0.02554581f, 0.25206640f, -0.30332494f, 
    -0.07846730f, 0.00804349f, 0.18748318f, 0.01751371f, 0.01044533f, 0.22950253f, -0.30807468f, -0.16342360f, 
    -0.03066248f, -0.02093743f, 0.14483191f, 0.06278435f, -0.04349787f, 0.55887544f, 0.40323880f, -0.56983960f, 
    -0.28947166f, -0.07530487f, -0.16750509f, 0.11043796f, 0.04274648f, -0.09655172f, -0.18779513f, -0.01813490f, 
    -0.16047871f, -0.02705520f, -0.13628259f, -0.16540340f, 0.09533335f, 0.02568823f, 0.08979511f, 0.05899035f, 
    0.01465652f, 0.07305060f, -0.07199202f, -0.22015361f, -0.26424843f, -0.09109938f, 0.01415489f, -0.07841613f, 
    0.02072410f, 0.16110779f, 0.01052105f, 0.15145679f, -0.24652569f, 0.02222270f, 0.04821243f, -0.21010242f, 
    -0.04484898f, 0.00385519f, 0.28312948f, -0.08218385f, -0.23041178f, 0.30084097f, 0.24800946f, 0.04155579f, 
    -0.10002047f, -0.29972678f, 0.16392851f, 0.26767850f, 0.23072678f, 0.11950646f, 0.17076471f, -0.16878660f, 
    0.17176928f, -0.21875791f, -0.04361138f, 0.28160489f, 0.30958414f, 0.15988377f, -0.09699596f, 0.01326891f, 
    0.14583029f, 0.01061814f, -0.25091311f, -0.13989817f, -0.28626481f, 0.31719226f, -0.02880303f, 0.05710094f, 
    0.25320899f, -0.28745401f, -0.35715947f, -0.46190056f, 0.14378059f, 0.03758094f, 0.27862200f, -0.12517972f, 
    0.46798766f, -0.40310404f, -0.07065314f, 0.23833309f, 0.09047339f, -0.03897264f, 0.10539213f, 0.12100402f, 
    0.32300943f, 0.32451680f, 0.33987921f, 0.06456030f, -0.35559049f, -0.31021902f, -0.14755845f, 0.18663150f, 
    0.01295385f, -0.33547074f, 0.27199173f, 0.09521305f, 0.03204105f, 0.05294788f, -0.31242454f, -0.17827648f, 
    0.14877914f, 0.21952721f, -0.08754033f, 0.43931881f, 0.34357619f, -0.30607855f, 0.09107728f, -0.00761180f, 
    0.17243503f, 0.47069299f, 0.05896258f, -0.42452744f, -0.00840563f, 0.00968684f, -0.07975457f, -0.52433997f, 
    0.15760751f, -0.04555678f, -0.00802360f, -0.01685129f, 0.21974990f, -0.12624981f, -0.37891096f, 0.14661743f, 
    0.03437931f, 0.66070986f, 0.30335978f, -0.07562488f, -0.43085670f, 0.32003862f, 0.13135752f, -0.12589291f, 
    -0.15082426f, 0.07769570f, -0.18222992f, 0.00148101f, -0.15345038f, 0.03023782f, 0.06380215f, -0.04412793f, 
    -0.01823739f, -0.11277204f, 0.17652252f, 0.01560778f, -0.01743531f, -0.17340334f, -0.09543035f, -0.16621186f, 
    0.13122025f, -0.01819500f, -0.17483413f, 0.09551955f, -0.08713529f, -0.08482473f, -0.20157894f, -0.07815196f, 
    0.04549074f, 0.14547145f, -0.09452000f, 0.14134958f, 0.00379056f, -0.01220395f, 0.04324827f, 0.04000410f, 
    -0.22342016f, 0.02701777f, 0.16388994f, 0.06591636f, 0.05041990f, 0.71543038f, -0.08557285f, -0.05235866f, 
    0.06496923f, 0.01157669f, -0.03407876f, 0.39169773f, 0.02898880f, -0.02470914f, -0.13055575f, 0.16098735f, 
    -0.39856806f, 0.42819950f, 0.24250381f, -0.00314108f, 0.02020216f, 0.26640192f, -0.33309650f, 0.19222155f, 
    0.03585185f, -0.41852823f, -0.09587680f, 0.10671510f, 0.08516907f, -0.15452988f, 0.44077927f, -0.56527370f, 
    0.12322551f, 0.64440364f, 0.26387280f, -0.11231528f, -0.11499084f, 0.31622875f, 0.11792102f, 0.16389035f, 
    -0.22739178f, 0.42275199f, -0.07052441f, -0.14568225f, 0.02812313f, -0.10206156f, -0.03902287f, 0.43438807f, 
    -0.10732041f, 0.04066152f, -0.21185863f, -0.05339086f, 0.32124820f, 0.36073846f, -0.07066405f, 0.06299751f, 
    0.06480514f, -0.26473570f, -0.07703271f, 0.11308817f, 0.08475470f, 0.16714214f, 0.19027363f, 0.10874285f, 
    -0.35329106f, -0.00040379f, 0.16668397f, -0.09016392f, 0.30120027f, -0.11946028f, 0.01508122f, -0.10402307f, 
    -0.11912017f, 0.47798857f, 0.04194305f, 0.24357218f, -0.03131322f, -0.07673887f, 0.09480921f, -0.05858798f, 
    -0.03877008f, 0.24976803f, -0.15775961f, -0.29602575f, -0.18516050f, -0.35023326f, -0.06915859f, 0.12084493f, 
    -0.10914145f, -0.13124406f, 0.26684418f, -0.01453905f, 0.42214251f, 0.15634005f, 0.47936085f, 0.00195845f, 
    0.23454875f, -0.23930727f, 0.31100386f, -0.26182339f, 0.03883245f, -0.20015492f, 0.13256887f, -0.37309238f, 
    0.25921047f, -0.07202450f, 0.06178003f, -0.18630159f, 0.44412366f, -0.12470774f, -0.11651850f, 0.10868156f, 
    -0.14405379f, 0.27710509f, -0.20739211f, -0.08484390f, -0.11133230f, -0.01993382f, -0.10157806f, 0.29489526f, 
    0.02724223f, -0.16331641f, -0.21698076f, 0.08765912f, 0.15115409f, -0.44167420f, 0.10261637f, 0.26090047f, 
    -0.17981298f, -0.04004965f, -0.10739072f, 0.04214029f, -0.18871149f, -0.03073158f, 0.03082028f, -0.06763382f, 
    0.02070135f, 0.04146051f, 0.07026432f, -0.01006067f, -0.15274593f, -0.10066121f, -0.13132447f, 0.09579653f, 
    -0.02891873f, 0.04853433f, -0.16156457f, -0.03787831f, 0.13174203f, -0.12723343f, -0.08790399f, -0.18913323f, 
    -0.11422130f, 0.03413283f, -0.13757768f, 0.15537220f, 0.00639077f, -0.03859535f, 0.03073378f, 0.01764846f, 
    -0.13268407f, -0.22965604f, 0.41333270f, 0.37004316f, -0.32021865f, -0.02459161f, 0.19608736f, -0.30743381f, 
    0.03836336f, 0.06902486f, 0.04981951f, -0.00264084f, 0.36431980f, -0.02686870f, 0.05370707f, 0.17382011f, 
    -0.00771090f, -0.12944116f, 0.20137154f, 0.32224181f, 0.31791076f, 0.32513320f, 0.03242755f, -0.13542867f, 
    0.01754213f, 0.18479243f, -0.04382972f, 0.02774440f, -0.48280120f, -0.40337649f, -0.03246982f, 0.18928155f, 
    -0.36516035f, -0.28604716f, -0.08241452f, -0.00392553f, 0.19536488f, 0.14774849f, -0.03914046f, 0.10448882f, 
    0.17369425f, 0.39769667f, -0.04475508f, 0.31104439f, -0.08174737f, -0.14418513f, -0.26088405f, -0.77103496f, 
    0.14471474f, 0.06025099f, 0.14822352f, -0.01733181f, 0.12277623f, -0.26009408f, 0.18883558f, -0.00550312f, 
    0.11188328f, -0.14114179f, -0.20143178f, -0.07900444f, 0.09932560f, -0.20642033f, 0.28399292f, 0.04496409f, 
    -0.00851806f, -0.00512333f, 0.06893328f, -0.31243166f, 0.13117528f, 0.29742664f, -0.02564948f, 0.04825298f, 
    0.15498656f, 0.38705829f, -0.12568159f, -0.27221283f, 0.36632249f, -0.11192161f, 0.08492175f, 0.55038261f, 
    0.10266026f, -0.17946652f, 0.07154750f, 0.16594270f, 0.07242457f, -0.13089885f, -0.00873637f, 0.11963847f, 
    -0.07368340f, -0.39538965f, 0.15586880f, -0.05454038f, -0.18298919f, -0.39726430f, -0.37620381f, -0.19023123f, 
    -0.19066145f, -0.00410615f, -0.16284761f, -0.08813576f, 0.11685403f, -0.17194371f, -0.29507077f, 0.11773389f, 
    0.15558983f, 0.19705774f, -0.16014892f, 0.09570972f, -0.40468544f, 0.00680545f, -0.38238305f, 0.24234992f, 
    0.20449749f, 0.19639878f, -0.03509007f, 0.06007317f, 0.07685325f, -0.65246898f, 0.10786422f, 0.23021877f, 
    -0.12157389f, -0.24324423f, 0.03503677f, -0.15540269f, 0.12492098f, 0.02084454f, -0.03343361f, 0.20873721f, 
    -0.17572837f, -0.19228815f, 0.38650969f, 0.36088410f, -0.17754062f, 0.18078995f, 0.41383120f, 0.01605963f, 
    0.21947950f, 0.21517251f, -0.14875627f, 0.25710639f, 0.24657962f, 0.13439688f, 0.32666236f, -0.45198441f, 
    0.13478683f, -0.21876708f, 0.06986226f, 0.06628051f, 0.53564024f, 0.35663679f, 0.08043136f, -0.15796660f, 
    0.16379139f, 0.53831887f, -0.01175278f, 0.01312878f, -0.29776341f, -0.05504919f, 0.19811963f, 0.06312265f, 
    0.27646020f, 0.28233027f, -0.20197962f, -0.13390745f, -0.06323227f, -0.01006560f, 0.06847920f, -0.31107035f, 
    -0.03282138f, 0.14236236f, 0.00654432f, -0.35110155f, -0.42272359f, 0.15865110f, -0.22193936f, 0.14818539f, 
    -0.07776342f, 0.50470603f, 0.03372224f, -0.22114961f, 0.43207198f, 0.31670195f, -0.29254612f, 0.27822939f, 
    -0.02331271f, 0.40666783f, 0.31319708f, 0.07847083f, 0.20400493f, 0.42330489f, 0.07920410f, -0.17180802f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.23516765f, 0.02924371f, 0.32981563f, -0.03984726f, 0.11869740f, 0.12634884f, 0.11461349f, 0.29176816f, 
    0.17651729f, 0.00692799f, -0.10217256f, 0.04645491f, 0.11172449f, 0.30803338f, 0.21726499f, -0.01874168f, 
    -0.09994179f, 0.01207105f, 0.02689647f, 0.33590898f, 0.02457369f, 0.04298867f, -0.09236952f, 0.12352936f, 
    0.21857825f, 0.05414090f, -0.00594852f, 0.17668566f, -0.08454074f, -0.11315409f, 0.05417268f, 0.04953352f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.18862388f, 0.08436836f, -0.31354004f, 0.06654445f, -0.16560772f, -0.08776502f, -0.28634194f, 0.01909293f, 
    -0.07536804f, 0.07347255f, -0.34194070f, -0.35444769f, 0.21687715f, -0.71663463f, -0.32427332f, 0.23671912f, 
    0.03593631f, 0.26840761f, -0.34437838f, -0.78488290f, -0.09887233f, 0.09914021f, 0.19941631f, -0.03586980f, 
    -0.14850689f, -0.09703850f, 0.21104181f, -0.25218096f, 0.32560980f, -0.28733930f, 0.19052857f, -0.36326289f, 
    0.21864422f, -0.21285017f, -0.29899988f, -0.10086336f, -0.06973066f, -0.19062634f, -0.54762608f, 0.20865379f, 
    0.13815336f, 0.12820753f, -0.51225424f, 0.11728016f, 0.26613873f, 0.07399864f, 0.07802258f, -0.83112514f, 
    -0.10604902f, -0.09083760f, -0.15174782f, -0.02666723f, -0.00805029f, -0.55735791f, -0.11694708f, 0.39183712f, 
    0.37514171f, -0.13304155f, 0.34574166f, 0.34217915f, 0.13394688f, 0.04627345f, 0.20885499f, -0.28850791f, 
    -0.16861218f, -0.41166681f, 0.15063420f, -0.21975277f, 0.02621936f, 0.16013031f, 0.08197372f, 0.24715184f, 
    0.56516129f, 0.11354122f, -0.18922277f, -0.19844079f, -0.11432227f, 0.22121035f, -0.07952810f, -0.30699193f, 
    -0.09161951f, -0.03113140f, 0.03591458f, -0.32965875f, 0.12972686f, 0.23793869f, 0.13717835f, -0.21815267f, 
    0.39413083f, 0.05611489f, -0.62213665f, -0.24330391f, -0.12923068f, -0.73368728f, -0.17400515f, 0.38079259f, 
    -0.77871633f, 0.32954592f, -0.46673056f, 0.06605039f, 0.07917135f, 0.03968600f, 0.20877893f, -0.49246177f, 
    0.41116807f, -0.55576462f, 0.05590326f, -0.01273878f, -0.09007121f, -0.13360633f, 0.24736755f, 0.08601762f, 
    -0.25558767f, 0.14706030f, 0.36080873f, -0.26307622f, -0.03998979f, -0.00524044f, -0.02916961f, 0.06145221f, 
    0.08768559f, 0.01534912f, -0.00299338f, -0.29496622f, -0.03193673f, -0.20715474f, 0.10638194f, -0.13370052f, 
    -0.02481297f, 0.01619172f, -0.00821305f, -0.04487834f, 0.17130663f, 0.19686280f, -0.04626365f, -0.62955511f, 
    -0.17085490f, -0.28839168f, 0.24078441f, 0.12577885f, 0.11781093f, 0.01689138f, -0.12213521f, 0.12031092f, 
    -0.21270460f, 0.03301413f, -0.62952000f, 0.05691059f, -0.16187285f, 0.06332049f, 0.21053417f, -0.76295727f, 
    -0.11261568f, -0.14293243f, 0.04248248f, 0.31233191f, -0.08722311f, 0.13662334f, 0.07697158f, -0.12085001f, 
    0.36390966f, -0.08473723f, -0.05283761f, -0.13945685f, -0.11388839f, 0.03970107f, 0.22542046f, 0.24830726f, 
    -0.24438949f, -0.14342993f, -0.23915723f, 0.17408241f, 0.23323895f, -0.25561970f, 0.05039463f, -0.07174142f, 
    -0.00360508f, 0.11627517f, -0.33501622f, 0.32195857f, 0.08169457f, -0.40300563f, -0.09232833f, -0.38683671f, 
    -0.36055112f, 0.04560272f, 0.13532111f, -0.18842982f, -0.56458551f, -0.05354971f, 0.23272726f, 0.06401440f, 
    0.02628975f, -0.57916451f, 0.14526656f, -0.18996988f, 0.17297602f, -0.04639495f, 0.24295421f, 0.06618152f, 
    -0.49681643f, -0.03308517f, 0.06256489f, 0.02696532f, -0.58840966f, 0.35906073f, -0.04603516f, -0.26661173f, 
    -0.13096188f, -0.52867085f, 0.02178171f, 0.08898686f, 0.00863122f, -0.52526188f, 0.06831438f, 0.29152742f, 
    0.02195391f, 0.04252099f, -0.36805129f, -0.59272671f, -0.44158775f, 0.26481834f, -0.88780397f, 0.24772324f, 
    0.16630599f, 0.12607020f, 0.02037052f, -0.04868745f, -0.43275899f, -0.46778637f, 0.22989884f, -0.15491754f, 
    0.46610329f, -0.46897998f, 0.07199233f, -0.16398847f, -0.10802466f, -0.16514140f, -0.44049436f, 0.38160214f, 
    -0.15467852f, -0.53384340f, -0.02550071f, -0.11286556f, -0.02488489f, 0.57137847f, -0.11986515f, 0.03814602f, 
    -0.56532836f, -0.14759901f, -0.20251651f, 0.38147607f, -0.61915112f, 0.18776751f, -0.16628274f, 0.11197950f, 
    -0.05145179f, 0.46074143f, 0.19127782f, -0.19179077f, -0.50980920f, -0.69385016f, -0.13485302f, 0.11305930f, 
    0.11411428f, -0.26833147f, -0.50297940f, 0.16817605f, -0.14062686f, 0.00143299f, 0.30494541f, 0.23267168f, 
    0.04093749f, -0.08275300f, 0.38284054f, -0.11541915f, -0.02081287f, -0.40726072f, -0.52493483f, -0.00213720f, 
    -0.50835413f, 0.08245201f, -0.49956524f, 0.01557772f, -0.33035868f, -0.15784815f, -0.00894373f, -0.27434695f, 
    0.25602868f, -0.76381063f, 0.06741184f, 0.02301913f, 0.17375810f, -0.35325554f, 0.26318944f, -0.28300396f, 
    -0.20475255f, -0.56150699f, 0.30470604f, -0.60020125f, -0.49866599f, 0.11002005f, -0.30644822f, 0.04421624f, 
    -0.08438986f, -0.12900774f, -0.55900145f, 0.15687802f, -0.02084094f, -0.24367952f, 0.24865855f, 0.29525650f, 
    0.17573477f, 0.12236238f, -0.14514793f, 0.03717035f, -0.20351537f, -0.22882327f, 0.20729783f, 0.02150626f, 
    -0.48289889f, 0.06273186f, 0.08947958f, -0.15924369f, 0.28918001f, 0.35429859f, -0.10034448f, 0.17972869f, 
    -0.50279844f, -0.33130074f, -0.00388746f, -0.27932784f, 0.21007128f, 0.01430431f, 0.11286552f, -0.38097677f, 
    -0.25837681f, -0.17205307f, 0.33783504f, 0.29910934f, -0.16905378f, -0.31578666f, -0.64347088f, -0.17081705f, 
    0.34782401f, 0.02632162f, -0.11480488f, -0.35610080f, 0.68611556f, -0.20631678f, -0.07945070f, -0.51114452f, 
    0.06813663f, -0.28727233f, -0.63786459f, -0.08879915f, -0.58257681f, -0.19071956f, -0.24344556f, 0.03069018f, 
    -0.07633461f, -0.57042867f, 0.18470503f, 0.33940396f, -0.25655678f, 0.29225907f, 0.33824065f, -0.00273449f, 
    0.03217390f, -0.24501923f, 0.06527214f, 0.27812979f, 0.13800524f, -0.31941697f, 0.09714206f, -0.25829592f, 
    -0.54507709f, -0.16247927f, -0.10639778f, -0.43484801f, 0.50299883f, -0.08189201f, -0.08016125f, 0.37689888f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.29108724f, -0.06869577f, 0.20043364f, -0.00682559f, -0.03078163f, -0.03485858f, 0.10710177f, -0.10047271f, 
    0.14988016f, 0.02357365f, 0.03797189f, -0.14647976f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
