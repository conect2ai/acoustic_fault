#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73331589f, 1.12463629f, 0.42453530f, 0.00994868f, -0.76598179f, -0.36314085f, -0.16157649f, -0.11338144f, 
    0.02403314f, -0.05831404f, -0.03264387f, -0.41398966f, -0.06873046f, 0.12607577f, -0.37921476f, 0.37209901f, 
    -0.05381838f, -0.19616105f, 0.31533477f, -0.13377933f, -0.15420783f, 0.20417938f, -0.37892100f, -0.28642777f, 
    -0.33831513f, -1.20200872f, -1.02842462f, -0.43069226f, -0.48064485f, 0.61707580f, -0.52338749f, -1.15460122f, 
    -1.36154842f, -1.08296311f, -0.56298673f, -0.24219564f, -0.35939023f, 0.60748178f, -0.04735459f, -0.38669768f, 
    -0.28729779f, -0.50791967f, -0.36243242f, -0.23841849f, -0.26039588f, 0.15840168f, -0.26103863f, -0.16222045f, 
    0.20928709f, 0.06003430f, 0.33835602f, -1.44569659f, -0.98685753f, -0.67152792f, -0.18395686f, 0.10147691f, 
    0.19050212f, 0.19525412f, 0.79186296f, 0.22890750f, 0.11529037f, -0.28310245f, 0.16478378f, -0.10024917f, 
    0.22652438f, -0.00694893f, 0.07598767f, -0.10400445f, 0.14610045f, -0.31295177f, -0.22317594f, -0.52658904f, 
    -0.48522738f, -0.53783935f, -0.36709246f, -0.57968533f, 1.25827670f, 0.18752928f, -1.24320996f, 0.06168557f, 
    -0.60338175f, -0.91016102f, -0.72184956f, -1.28003311f, -1.52120054f, 0.16014034f, 0.60299766f, -0.13938384f, 
    -0.35374510f, -0.08453303f, 0.05427276f, 0.21316513f, 0.19462259f, 0.39563391f, -0.21985762f, 0.08902447f, 
    -0.25264964f, -0.28271207f, 0.14283265f, -0.31470126f, -1.32802725f, 0.00197164f, -0.53407353f, -1.41843116f, 
    -1.74630058f, 0.55192864f, -0.15544544f, 0.31482002f, 0.94352913f, 0.04847780f, -0.35199219f, -0.35322103f, 
    -0.22287984f, -0.42152610f, -0.33603299f, 0.69385159f, -0.25421131f, -0.23743114f, 0.29363993f, 0.42641893f, 
    -0.22453187f, -0.04576281f, 0.30930328f, 0.07083932f, 0.04685274f, -0.77454722f, -1.20692861f, -1.08077335f, 
    -0.46000525f, -0.58907360f, 1.24303281f, -0.42499050f, -0.64266878f, -0.23727827f, 0.24749497f, -0.47505161f, 
    -0.44396296f, -0.42711741f, -0.53534067f, 0.46783537f, -0.29729033f, -0.16995317f, 0.02090484f, 0.03914906f, 
    -0.15411393f, 0.03623851f, -0.31388211f, -0.08278628f, -0.02318171f, -0.26163453f, 0.99149489f, -0.00816397f, 
    -0.29425922f, -0.12881655f, -0.28483045f, 0.30294874f, 0.61355001f, 1.06081402f, -0.48004335f, -0.52608937f, 
    -0.35086426f, -0.37703067f, -0.05857001f, -0.27034876f, -0.38712621f, -0.19493793f, 0.04908431f, 0.25546119f, 
    0.07905535f, -0.21587490f, 0.31340244f, -0.34021363f, -0.62222922f, 0.43132603f, 0.33505839f, -1.58212876f, 
    -1.36607313f, -0.73393774f, 0.72443670f, -0.13766870f, -0.30349040f, 0.11837821f, 0.16133846f, -0.13018310f, 
    -0.52022743f, 0.51769549f, -0.36295515f, -0.11886448f, 0.71692926f, -0.53994828f, -0.00466699f, -0.03813744f, 
    -0.00620500f, -0.03578367f, -0.11133948f, 0.08368998f, 0.47973207f, 0.47041121f, 0.27194995f, 0.02737424f, 
    0.55933285f, -0.24632496f, 0.13594922f, 0.45689103f, 1.01673019f, 0.02114099f, -0.64267647f, -0.53109241f, 
    -0.66810554f, -0.56151032f, 0.06202980f, 0.35528272f, 0.10163149f, 0.08954448f, 0.59301680f, 0.27767617f, 
    -0.00373506f, -0.33468491f, -0.37562221f, -0.01104136f, -0.47905001f, 0.25430313f, 0.32663664f, 0.12425645f, 
    -0.15004040f, 0.97572750f, 0.41227496f, 0.62016600f, 0.47475630f, 0.44770011f, -0.48469979f, -0.22209677f, 
    0.18118568f, 0.67389607f, 0.24750678f, -0.02885013f, -0.11514499f, 0.36488876f, 0.05582406f, 0.52007031f, 
    -0.17188837f, 0.06721657f, 0.15495829f, 0.06688607f, -0.20551933f, 0.21783689f, 0.12290997f, -0.01751319f, 
    0.19602181f, -0.44653329f, -1.63464272f, 0.63576084f, -0.47342822f, -0.97230333f, 0.27152246f, -0.05722192f, 
    0.83494210f, 1.17185700f, 0.32857507f, -0.31967407f, -0.45822006f, 0.10242759f, 0.01393026f, 0.16573237f, 
    -0.05631500f, -0.09733559f, -0.22978333f, -0.23614401f, 0.23503798f, -0.11740839f, 0.28916147f, 0.15841277f, 
    0.24821445f, -0.15541038f, -0.31348878f, 1.03021979f, 0.53489459f, 0.38271287f, -0.12880683f, -0.00473873f, 
    -0.06629431f, 0.22264433f, 0.37318391f, -0.35227215f, -0.09160493f, -0.35774034f, 0.14262100f, 0.08124322f, 
    -0.31718752f, -0.44808576f, -0.15175095f, -0.45104229f, -0.09820578f, -0.01001433f, -0.23808502f, -0.12085844f, 
    -0.29528964f, 0.21540436f, 0.53012252f, -0.12038379f, -0.05332415f, -0.24155256f, -0.15890847f, -0.16089274f, 
    0.90097952f, -0.29942372f, 0.15130414f, 0.17684190f, 0.14306942f, 0.75735539f, -0.38988215f, 0.79466188f, 
    -0.84371424f, -0.01015603f, 0.62411231f, -0.19675604f, 0.06426529f, -0.28087226f, -0.09704406f, 0.04360968f, 
    0.30373663f, -0.67559379f, 0.07865380f, 0.47121578f, -0.03133814f, 0.88645560f, 0.21231784f, -0.33865970f, 
    0.07291352f, -0.19798945f, 0.77005649f, -0.36551207f, -0.68219173f, -0.14711666f, -0.11335640f, -0.02868821f, 
    0.51815307f, -0.73893672f, 0.35830167f, -0.38691005f, 0.05723117f, 0.15404160f, 0.43690476f, -0.01392727f, 
    -0.32834682f, -0.37249053f, -0.18437484f, 0.13656250f, 0.30190200f, 0.21659632f, -0.08560114f, 0.10798471f, 
    -0.10650765f, 0.37757948f, 0.11044875f, -0.84330481f, -0.37334657f, 0.96774536f, -0.50442994f, 0.04357350f, 
    0.63152945f, 0.22232822f, -0.16190071f, -0.17779455f, -0.00129630f, 0.35102287f, 0.35915434f, -0.04947139f, 
    -0.25305715f, -0.01477586f, 0.29915226f, 0.17637369f, -0.26043466f, 0.27812144f, 0.31865731f, -0.86437875f, 
    0.93281460f, 0.71900719f, -0.53553486f, -0.18765102f, 0.42463937f, 0.18471801f, -0.25196096f, -0.21622299f, 
    0.25023004f, 0.08013650f, -0.34764040f, -0.32343602f, -0.25935483f, -0.06148008f, -0.10123676f, -0.04942844f, 
    -0.14281090f, -0.19542566f, -0.36799189f, -0.44136873f, -0.46329972f, -0.68964744f, -0.60969782f, -1.21172714f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.65168780f, -0.16329859f, 0.05868710f, 0.80242336f, 0.13500112f, 0.29416871f, 0.63839549f, 0.38401222f, 
    0.16243151f, 0.07290228f, 0.30136999f, 0.35549611f, 0.82786047f, 0.66581905f, 0.52451617f, 0.09241692f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.96023905f, -0.57922482f, 0.10357676f, 0.07622197f, 0.08541261f, 0.07346913f, -0.02224946f, -0.12076319f, 
    -0.12897319f, -0.06839018f, -0.21839085f, 0.12712255f, 0.70765370f, 0.52771014f, -0.25959516f, -0.44057080f, 
    0.12400786f, 0.15196107f, 0.13145098f, 0.04979310f, -0.14385529f, -0.23562431f, -0.14555328f, -0.21255624f, 
    0.19055736f, 0.11151940f, 0.14461066f, 0.05987444f, 0.21902537f, 0.20054877f, 0.03576832f, -0.15676989f, 
    -0.01494484f, 0.20013575f, 0.08319362f, 0.13987747f, 0.26492250f, 0.37321538f, -0.63752651f, -0.11723341f, 
    -0.10322056f, 0.09896392f, -0.04028416f, 0.13694426f, 0.10650577f, 0.02101107f, 0.04282163f, 0.00007767f, 
    -0.04496762f, -0.07871371f, -0.07151753f, -0.24006468f, 0.03710769f, 0.45963374f, -0.07327979f, 0.15919043f, 
    0.06433932f, -0.00159359f, 0.14259137f, -0.03915345f, 0.58979529f, 0.34949720f, -0.09459704f, -0.28694183f, 
    0.23555748f, 0.21983092f, -0.10348599f, -0.34535155f, 0.00736506f, -0.03134070f, -0.05320555f, 0.06204817f, 
    -0.41963142f, -0.96884924f, -0.70800865f, 0.23966517f, 0.15304582f, 0.06778891f, 0.01555675f, 0.08363622f, 
    0.06057936f, -0.00658930f, -0.08745632f, 0.02183385f, 0.51309186f, 0.28642750f, 0.06553297f, -0.45996302f, 
    0.17639421f, 0.19740532f, 0.09793780f, -0.00624963f, -0.00368206f, -0.08375243f, -0.09297746f, 0.03821615f, 
    -0.01908620f, 0.04138132f, -0.23481140f, -0.06143829f, -0.08787458f, -0.09289902f, -0.10305195f, -0.27239054f, 
    0.09624506f, 0.06541501f, -0.01065081f, -0.13329227f, -0.14768092f, -0.12208079f, 0.03156802f, 0.14156698f, 
    0.13460338f, 0.07383138f, 0.10186661f, 0.07235491f, 0.10170354f, -0.03079610f, 0.00598490f, -0.07989069f, 
    -0.39088386f, -0.71236467f, -0.25802919f, 0.01018171f, 0.04713438f, 0.10851227f, -0.04417453f, -0.02223517f, 
    -0.07050943f, -0.08872070f, -0.18336961f, 0.01158755f, -0.36884502f, -0.44073346f, -0.94208282f, 0.43226072f, 
    0.08184646f, 0.04705097f, 0.02833828f, 0.03384740f, 0.00712956f, 0.06952403f, 0.03298187f, 0.10554494f, 
    -0.52290815f, 0.11762607f, -0.10991012f, -0.08427758f, -0.06456591f, -0.02833331f, -0.10525327f, -0.10021804f, 
    -0.20575462f, -0.10017537f, -0.51822335f, -0.32524872f, -0.02884541f, -0.09770354f, -0.69718730f, -0.04454133f, 
    -0.27087688f, 0.08521405f, -0.23837286f, -0.13034461f, -0.34970710f, -0.12236562f, -0.09238782f, -0.16378425f, 
    -0.00614852f, 0.05455778f, 0.11954820f, 0.00691421f, -0.31230679f, 0.00531827f, -0.35259131f, -0.22616401f, 
    -0.02579348f, -0.04812195f, -0.05464720f, 0.01010544f, -0.54601681f, -0.00723288f, -0.30024663f, 0.02226545f, 
    -0.03966368f, 0.05616528f, -0.01642715f, 0.12728462f, -0.08139868f, 0.12996000f, 0.01876583f, 0.17572223f, 
    0.06060381f, -0.17644325f, -0.01159975f, 0.00904877f, -0.01003392f, -0.05983126f, -0.13438334f, -0.00859950f, 
    0.04891746f, 0.01987479f, 0.11843661f, -0.05143030f, -0.12187914f, 0.08127949f, -0.05703297f, 0.52699304f, 
    -0.03529240f, 0.02192853f, 0.34891617f, -0.25800315f, 0.07671038f, -0.00176042f, 0.09568693f, 0.10829622f, 
    0.05009989f, -0.26336753f, -0.12728441f, 0.02833371f, 0.03349877f, 0.08024748f, -0.12010787f, -0.38576818f, 
    -0.18024161f, -0.27497107f, -0.09589517f, -0.25573725f, 0.02853780f, -0.42268756f, -0.18117256f, -0.23607320f, 
    -0.19091499f, -0.05483590f, -0.18302752f, 0.01721159f, -0.06266655f, 0.03843703f, -0.08319117f, 0.24387699f, 
    0.16503675f, 0.72500420f, -0.13425396f, -0.47709563f, -0.27899146f, 0.03692569f, 0.03342951f, -0.25936258f, 
    -0.08365893f, -0.02315621f, -0.05015700f, -0.25808161f, 0.45980483f, 0.25762007f, 0.11217002f, -0.39477575f, 
    -0.02080561f, 0.16195333f, -0.07333128f, 0.09717692f, 0.14442670f, -0.01784413f, -0.02506019f, -0.23788147f, 
    1.13925493f, 0.04105919f, 0.47467133f, 0.21971974f, -0.10918240f, -0.08638802f, 0.16874196f, -0.15081437f, 
    0.21343794f, -0.15280862f, 0.02238365f, 0.14869548f, -0.23815808f, 0.18023238f, 0.24830848f, -0.05019737f, 
    -0.09792700f, -0.07005816f, 0.39409867f, 0.06729849f, -0.14823964f, -0.10576389f, 0.08893283f, -0.00053309f, 
    0.18183509f, -0.06049878f, -0.40473652f, -0.00930837f, -0.07137808f, -0.21430710f, 0.00229801f, 0.03118340f, 
    -0.12486438f, 0.12422176f, -0.03505985f, 0.15633939f, 0.10286968f, 0.15693590f, 0.19574064f, 0.21351774f, 
    -0.05321606f, -0.17205241f, -0.04336841f, -0.04346194f, -0.00892012f, 0.00851815f, 0.09253982f, 0.06372480f, 
    -0.68370008f, -0.86524481f, -0.18039134f, -0.15061153f, -0.15544751f, -0.03146203f, 0.00135319f, 0.02772366f, 
    0.13634552f, 0.13964690f, 0.01766820f, 0.02001963f, 0.63919419f, -0.01035723f, 0.53167027f, 0.19806990f, 
    -0.09433836f, -0.14713970f, 0.07882192f, -0.00062630f, 0.00006012f, 0.07080098f, -0.03174422f, 0.04079302f, 
    -0.13590732f, 0.15993534f, 0.13098539f, 0.08373177f, -0.07533129f, 0.03167492f, -0.08278543f, -0.11318254f, 
    0.29570073f, 0.19624478f, 0.00078476f, -0.08151510f, 0.40268862f, 0.04509570f, -0.29009497f, -0.22541687f, 
    -0.09940302f, -0.25266430f, -0.10332106f, -0.02956776f, 0.01291434f, 0.14530183f, -0.02155270f, 0.16435915f, 
    -0.16192760f, -0.05866763f, 0.01306707f, 0.02494886f, 0.15222648f, 0.10464086f, 0.09823151f, -0.22732081f, 
    -0.16016449f, -0.02969265f, -0.05017272f, 0.22488874f, 0.21139000f, 0.11374888f, 0.17056224f, 0.05576463f, 
    -0.02710240f, -0.00486712f, -0.14998482f, 0.04931619f, -0.32428810f, -0.40472028f, -0.38197821f, -0.35362452f, 
    -0.30202731f, -0.11290684f, 0.31400248f, -0.24361926f, 0.02697424f, -0.01918428f, -0.05583462f, 0.13920793f, 
    0.04829718f, -0.08713751f, 0.04880447f, 0.24949847f, -0.83594984f, -1.18224061f, -0.61823267f, -0.35842228f, 
    0.29777533f, -0.03386075f, -0.19014338f, 0.08329728f, -0.03594752f, -0.05641746f, -0.02418755f, -0.10034317f, 
    -0.21504301f, 0.19914187f, 0.11551602f, 0.30047539f, -0.11897807f, 0.01819348f, 0.09330413f, 0.03432628f, 
    0.12273670f, 0.09655913f, 0.17614032f, 0.26765350f, -0.69366741f, -0.57613903f, 0.02337179f, -0.53236425f, 
    0.17582424f, -0.20411964f, -0.22296177f, 0.10429531f, 0.02091053f, -0.07501361f, -0.00691605f, -0.04327596f, 
    0.23580596f, 0.93619257f, 0.23651838f, 0.66976500f, 0.02546278f, -0.06351085f, 0.16419746f, -0.07402474f, 
    -0.00682487f, 0.07989272f, -0.19638386f, 0.09211622f, -0.30890813f, 0.13823524f, 0.92098129f, 0.47383440f, 
    -0.06727199f, -0.04301438f, -0.00650856f, 0.03466021f, -0.00881468f, 0.14678071f, -0.07762008f, -0.06713073f, 
    -0.40187463f, -0.08869103f, -0.10062417f, -0.24414186f, 0.07760481f, 0.09322876f, 0.09328052f, 0.07718864f, 
    0.04002201f, -0.15618397f, 0.11212865f, -0.14180808f, -0.27750230f, -0.36079466f, 0.08975282f, -0.20684022f, 
    -0.16215235f, -0.02635921f, 0.11789090f, 0.28904486f, 0.00559258f, -0.07560427f, 0.02707117f, -0.08337113f, 
    -0.19979177f, 0.06729908f, -0.24736899f, 0.10315796f, -0.40129304f, -0.80170864f, -0.31632116f, 0.00430948f, 
    0.06901985f, 0.05487257f, -0.10111170f, 0.11242406f, -0.60840279f, -0.08252587f, 0.17962956f, 0.21213010f, 
    -0.12565184f, -0.03551302f, 0.03278285f, 0.04354407f, 0.02732875f, 0.00500820f, -0.06319308f, 0.05133160f, 
    0.16246419f, 0.15693150f, 0.10856182f, 0.29617167f, -0.02385854f, -0.08611570f, 0.19667818f, -0.06032005f, 
    0.06330251f, -0.23708276f, -0.16928151f, -0.18951941f, -0.11523958f, -0.04274869f, 0.20101544f, -0.37435812f, 
    0.03179438f, -0.01486914f, 0.01378462f, 0.03053503f, -0.01447370f, -0.10022796f, 0.04299377f, -0.07201684f, 
    0.28934580f, -0.31017885f, 0.12231950f, 0.23589449f, -0.11423843f, -0.04072918f, 0.13543607f, 0.04088391f, 
    0.00573328f, 0.16425924f, -0.19531593f, 0.28227237f, -0.68328744f, 0.21049829f, 0.19586931f, -0.31651175f, 
    0.36608005f, -0.19919917f, 0.10159737f, -0.13136248f, -0.00652906f, -0.01469126f, 0.16451205f, 0.02994789f, 
    -0.06618468f, -0.07451843f, -0.04796802f, 0.16826415f, 0.00237616f, -0.40435973f, 0.12769343f, -0.24806514f, 
    0.07152776f, 0.01634054f, 0.02032093f, 0.04521964f, 0.19741182f, -0.05198291f, 0.09649362f, -0.23732720f, 
    -0.01775476f, -0.05196468f, -0.09860860f, -0.08276741f, 0.06709171f, 0.33888653f, 0.17193469f, 0.20111771f, 
    -0.52433062f, -0.18332291f, 1.04187942f, 0.02277520f, -0.24669969f, 0.01151213f, 0.06445639f, 0.19725460f, 
    0.02315959f, -0.03649691f, 0.21524753f, -0.03517469f, -0.04420933f, -0.01570152f, -0.31099391f, 0.14985162f, 
    0.10478508f, 0.11371183f, 0.02517174f, 0.04029392f, -0.22693487f, -0.01023666f, -0.08661587f, -0.12083386f, 
    -0.28970626f, 0.05195564f, -0.34407184f, 0.33886516f, 0.19890079f, 0.12092773f, 0.21522202f, -0.02277891f, 
    -0.15907024f, 0.09997329f, -0.27530652f, -0.05510115f, 0.11811727f, -0.32365173f, 0.46783906f, 0.05241628f, 
    0.01254954f, 0.05997045f, -0.01637231f, 0.06201975f, 0.10980345f, -0.05007427f, -0.10762235f, 0.07155355f, 
    0.69175440f, -0.56953031f, 0.20396762f, 0.34423211f, 0.09561625f, -0.08417577f, -0.05659153f, -0.09696937f, 
    0.05993307f, -0.01097732f, -0.00914086f, 0.33850411f, -0.28698614f, -0.15272947f, -0.26746005f, 0.13408151f, 
    0.22042365f, -0.00287989f, 0.04664984f, -0.22556749f, -0.10891874f, 0.05741170f, -0.05791295f, -0.04305333f, 
    -0.16143015f, 0.47247815f, -0.25881997f, 0.20573916f, 0.31674051f, -0.19039813f, 0.30273512f, -0.16715378f, 
    -0.22937138f, 0.07713320f, 0.01336700f, -0.24590756f, 0.02768902f, -0.05551497f, -0.11690311f, 0.04684518f, 
    0.13391715f, -0.08022531f, -0.17139682f, -0.12501805f, -0.08367953f, -0.00493343f, 0.10335584f, -0.14471269f, 
    -0.06247348f, 0.13730033f, 0.11462002f, 0.61854267f, 0.02489323f, -0.38255641f, 0.06161389f, 0.23027499f, 
    0.00255977f, 0.13431124f, -0.00724673f, 0.19626723f, -0.72946048f, -0.24393472f, 0.08361445f, -0.56196791f, 
    -0.68871695f, 0.07024232f, -0.17195678f, -0.02333494f, 0.29663724f, 0.34433952f, -0.26230565f, -0.01584413f, 
    1.60141230f, 0.02143788f, -0.22651713f, -0.05651762f, 0.40903452f, 0.09036681f, 0.13761333f, 0.05306426f, 
    -0.15002702f, 0.02112613f, 0.07642050f, 0.02239582f, -0.82332706f, 0.07937145f, 0.34622470f, 0.01608739f, 
    0.00964323f, -0.14366421f, -0.21681252f, -0.10360432f, -0.01617343f, 0.01826058f, 0.05420189f, 0.26101515f, 
    -0.41472098f, -0.20262918f, -0.60213459f, -1.01731420f, 0.04953151f, -0.23168458f, 0.14390825f, -0.62431949f, 
    -0.21050604f, -0.07764981f, -0.27765918f, 0.07978201f, -0.45666233f, -0.13359484f, -0.29809228f, 0.47758129f, 
    -0.34142229f, -0.13905154f, -0.05580463f, -0.30821222f, -0.33006009f, 0.11400881f, -0.03809683f, -0.10759582f, 
    0.49148902f, -0.11939484f, -0.50064009f, -0.21893510f, -0.06238973f, -0.20815283f, -0.01238226f, -0.17522579f, 
    -0.02579380f, 0.11904042f, -0.29937154f, -0.04650169f, 0.18439998f, 0.06992588f, 0.45696580f, -0.14521937f, 
    -0.15806487f, 0.08547319f, 0.08862141f, 0.00049732f, -0.12969124f, -0.04215009f, 0.12511334f, 0.03590377f, 
    0.20398962f, 0.27118927f, -0.49955180f, 0.23557006f, -0.00115701f, -0.01219894f, 0.08802043f, -0.14144078f, 
    0.12068752f, 0.02468584f, -0.06166339f, -0.04193003f, 0.09892149f, 0.11348525f, 0.36825714f, 0.30126405f, 
    -0.06839501f, -0.01909281f, -0.12304775f, 0.08828059f, -0.00978907f, 0.04551000f, -0.01799341f, 0.07741480f, 
    -0.10219174f, 0.04691112f, 0.05287859f, -0.04642321f, -0.23872949f, 0.09753934f, -0.06748581f, 0.11537113f, 
    0.10292085f, 0.08027920f, 0.09732225f, 0.38889945f, 0.40181983f, 0.29982528f, 0.00615996f, 0.31747264f, 
    0.32837817f, -0.12071454f, 0.14130391f, -0.07339060f, 0.09770340f, -0.05525941f, 0.06911869f, -0.14704639f, 
    -0.19313674f, -0.00648887f, -0.06053226f, 0.34503976f, 0.06004443f, -0.32648560f, -0.15161809f, 0.09039157f, 
    -0.00507451f, 0.01890188f, -0.11466798f, 0.08367135f, -0.14300489f, -0.16429304f, -0.02450777f, 0.05981699f, 
    -0.36460671f, 0.03475910f, -0.00899537f, -0.14272237f, -0.13047457f, -0.11162041f, 0.06960930f, 0.14332254f, 
    -0.77132946f, 0.06073683f, -0.23673533f, -0.70018029f, 0.02336032f, 0.11315817f, -0.18130225f, 0.06652822f, 
    -0.03946078f, -0.05710525f, -0.08560047f, -0.25888574f, 0.17887796f, -0.07563899f, 0.27208027f, 0.18540424f, 
    -0.31379801f, -0.06756511f, -0.06357311f, 0.01432815f, 0.04465013f, 0.04158504f, -0.09513881f, 0.02344856f, 
    0.08613455f, -0.04426919f, 0.51546210f, 0.13761552f, 0.10361727f, 0.46261972f, 0.18533370f, 0.05880006f, 
    0.02477051f, -0.13895567f, -0.07175153f, -0.00302659f, 0.00275996f, -0.13836794f, -0.01609221f, -0.02547297f, 
    0.14851069f, 0.02254666f, 0.16290027f, 0.03023295f, 0.08671708f, -0.06020762f, 0.01095788f, 0.09311526f, 
    -0.20917727f, -0.32007131f, 0.11901276f, -0.69679981f, -0.16848966f, -0.03697432f, -0.10092168f, 0.20961908f, 
    0.06066566f, -0.16982731f, -0.31094787f, -0.36036360f, -0.23384206f, -0.03947938f, -0.93559414f, 0.07877661f, 
    0.05058024f, 0.09136179f, 0.04614426f, 0.15185465f, 0.08187311f, 0.00716491f, -0.07853249f, -0.08466386f, 
    0.04378089f, -0.06634075f, -0.23579821f, -0.03713759f, -0.10641223f, -0.03178976f, -0.07104395f, 0.04605305f, 
    -0.35560074f, -0.31869811f, -0.23901275f, -0.25476569f, 0.01930500f, -0.06619842f, 0.02928360f, 0.08014299f, 
    0.07914432f, 0.02765978f, 0.13139771f, -0.06355279f, -0.03214087f, -0.09210919f, -0.27985755f, -0.08498060f, 
    0.01119920f, -0.11304317f, 0.25229362f, -0.06248890f, -0.20968288f, -0.25383979f, -0.01994211f, 0.13677940f, 
    0.10193530f, -0.15579522f, -0.09338357f, -0.19011602f, 0.27682620f, -0.07439421f, -0.51451272f, 0.00575889f, 
    0.06040353f, -0.16077493f, 0.02299354f, -0.14666788f, 0.01610535f, 0.05410122f, 0.24093948f, 0.36109343f, 
    0.37434188f, 0.06408741f, -0.35366935f, 0.29647452f, 0.05245818f, 0.06752113f, 0.07507321f, 0.04148549f, 
    0.00253022f, 0.05051565f, -0.08072507f, -0.16861109f, 0.09773574f, 0.22533439f, 0.47855863f, -0.47392532f, 
    0.15710485f, 0.02760776f, -0.01652415f, 0.12176257f, 0.13721110f, -0.02883799f, 0.00933762f, 0.09809966f, 
    0.14618045f, -0.29138684f, 0.03493621f, -0.33622772f, -0.05889270f, -0.11871877f, 0.09423994f, 0.21961401f, 
    0.02944161f, -0.23617648f, 0.22223516f, -0.17102969f, -0.01403771f, 0.57765120f, 0.11253401f, -0.20657705f, 
    0.20139948f, -0.05475422f, 0.11827817f, 0.22506464f, -0.10087407f, 0.04196236f, 0.17496455f, -0.11941467f, 
    -0.45996174f, -0.28018707f, -0.35763422f, -0.33055708f, 0.26483783f, 0.05801416f, -0.04979192f, 0.03752059f, 
    -0.09694194f, -0.02071211f, -0.02500986f, 0.09054843f, -0.25793582f, 0.04577854f, 0.27303147f, -0.10750009f, 
    0.03915007f, -0.14204660f, -0.08639131f, 0.16715167f, -0.02849542f, 0.01756989f, -0.08956876f, -0.04397552f, 
    -0.23011786f, -0.21942569f, -0.76949865f, -0.05203313f, 0.01568403f, 0.06292138f, -0.16035300f, -0.00441929f, 
    -0.05391701f, -0.10035092f, 0.04463160f, 0.12470576f, -0.21029913f, 0.08810368f, 0.00546498f, 0.08182240f, 
    0.13977747f, 0.15211570f, 0.14764670f, -0.07367714f, 0.15585218f, 0.15982075f, -0.03835887f, 0.04073300f, 
    -0.40678030f, -0.08538565f, 0.21072417f, -0.15872326f, -0.07597353f, 0.13324168f, 0.26528636f, -0.21233796f, 
    -0.03672953f, -0.20830010f, 0.00852911f, 0.08329869f, -0.22674276f, -0.42380902f, 0.05533004f, 0.20612271f, 
    0.10482579f, 0.03826012f, -0.13434228f, -0.02199756f, -0.13512030f, 0.04956090f, 0.06490626f, -0.15516695f, 
    -0.76755214f, 0.70186281f, -0.82700646f, 0.00951946f, 0.12455200f, -0.26333582f, -0.02047064f, -0.13879173f, 
    0.15395996f, 0.14086173f, 0.04480330f, -0.13933386f, 0.06785750f, -0.04719835f, -0.58673650f, 0.32193577f, 
    0.10424119f, 0.15216407f, -0.11944664f, 0.02292968f, 0.12328114f, -0.00271448f, -0.00901637f, 0.07852412f, 
    -0.30120608f, -0.02786767f, 0.11602888f, 0.06322187f, -0.02285256f, -0.20129435f, -0.03959218f, 0.22821572f, 
    -0.03492224f, 0.03932689f, 0.30493730f, 0.29160756f, 0.02882500f, 0.18437316f, -0.15339856f, -0.38378978f, 
    0.14327174f, 0.20198892f, -0.10929390f, 0.00015683f, 0.30031896f, -0.04983911f, 0.13292831f, 0.08496543f, 
    0.09673089f, 0.02913141f, -0.08508899f, 0.05876346f, 0.13838236f, 0.13793050f, -0.18747856f, 0.17687537f, 
    0.03030538f, 0.00240864f, 0.15059358f, 0.09562784f, -0.37688899f, -0.01233150f, -0.03851065f, -0.11413962f, 
    0.02060920f, 0.06823657f, 0.01762240f, 0.09089120f, 0.09582514f, -0.52399427f, -0.71235436f, -0.67718679f, 
    0.30998474f, -0.00506500f, -0.33426443f, -0.17117198f, 0.06392577f, 0.10491267f, 0.38226312f, -0.03745626f, 
    -0.02047586f, 0.06697380f, 0.07408261f, -0.09257075f, -1.40012181f, -1.00447297f, -1.12559843f, 0.02154250f, 
    0.00354642f, -0.26757434f, -0.36398458f, -0.17731188f, -0.16601974f, -0.02882491f, -0.12783210f, -0.01306275f, 
    -0.14453378f, 0.80642456f, -0.12691985f, 0.04218425f, -0.26181701f, 0.06091091f, 0.04759063f, 0.10167486f, 
    -0.02647605f, 0.04169242f, -0.03699394f, 0.02949630f, -1.37654936f, -1.94004798f, -0.56978828f, -0.12901607f, 
    0.07185176f, 0.33520794f, -0.00271541f, -0.54396671f, 0.12135645f, -0.01286075f, 0.01855315f, -0.00250476f, 
    -0.56410646f, 0.09359158f, 0.41932201f, 1.31221139f, 0.00877077f, -0.23661155f, 0.05400333f, -0.07025001f, 
    0.02012455f, 0.09182724f, 0.09190360f, -0.10564701f, -0.85921353f, -0.07644545f, -0.12656449f, -0.14139773f, 
    -0.15848644f, 0.01149060f, 0.22430335f, 0.12987100f, 0.03778645f, -0.00037811f, 0.12575604f, -0.00516227f, 
    -0.24430338f, 0.35422462f, 0.14374638f, -0.66081530f, 0.21691261f, -0.13780023f, 0.09295271f, -0.23965725f, 
    0.02848430f, 0.26118019f, -0.09040477f, 0.28277728f, -0.95506042f, -0.49503472f, 0.89224577f, -0.72747856f, 
    -0.30580673f, -0.24143428f, -0.32837892f, -0.60548294f, -0.11597347f, 0.02248585f, -0.14967412f, -0.05635508f, 
    -0.41144142f, -0.52884567f, 0.16226193f, 0.23706326f, 0.34231469f, 0.16764462f, 0.33599079f, 0.03764126f, 
    0.07315794f, -0.18282141f, 0.09889250f, -0.05025912f, 0.24980536f, -0.24682304f, -0.41371232f, -0.07645434f, 
    -0.10698019f, 0.00375713f, 0.11254450f, 0.05927341f, -0.12354028f, -0.12508595f, -0.30531666f, -0.04056733f, 
    -0.47550181f, 0.24117771f, 0.64463609f, -0.08726007f, -0.17888542f, 0.22163409f, 0.03587805f, -0.05679768f, 
    -0.08390311f, 0.20239949f, 0.18711103f, 0.12699403f, -0.33664083f, -0.04281091f, -0.15605576f, -0.45946977f, 
    0.18822703f, 0.00297772f, 0.00202189f, -0.04082866f, -0.10545883f, 0.05225157f, -0.19502667f, -0.07792775f, 
    0.16411531f, -0.03024860f, -0.03433013f, 0.16117625f, 0.16128868f, -0.04770067f, 0.24405713f, 0.41951326f, 
    0.23669784f, 0.03318257f, 0.45508310f, 0.11377496f, 0.10593380f, -0.02481405f, -0.15459235f, -0.02256887f, 
    0.14396979f, 0.28626916f, 0.30582845f, 0.22200623f, 0.07916999f, 0.05419082f, -0.38219333f, 0.02275469f, 
    0.03840529f, -0.03310528f, -0.01160589f, -0.04205413f, -0.19028851f, -0.19457315f, 0.12319178f, 0.12781209f, 
    0.16879719f, -0.10314570f, -0.09639093f, -0.22036020f, 0.14132237f, -0.15932833f, 0.06674298f, 0.03429539f, 
    -0.05683880f, 0.08756357f, 0.12168512f, 0.05091545f, 0.15697052f, 0.32023048f, 0.55740279f, 0.18409432f, 
    -0.05247447f, 0.24560617f, 0.05849505f, 0.02306879f, -0.05255713f, -0.08721957f, -0.09628652f, -0.03202007f, 
    0.02516670f, 0.05038676f, 0.15449597f, -0.02728815f, 0.19922249f, -0.99734217f, 1.00926459f, 0.66794425f, 
    -0.07836836f, 0.01591216f, -0.22858465f, 0.25595352f, -0.01154293f, -0.02703484f, -0.04428906f, -0.06941757f, 
    0.22775953f, -0.84691203f, -0.37001073f, -0.39311355f, -0.19357364f, -0.12332938f, 0.09514369f, -0.01593178f, 
    0.07797643f, 0.14866656f, -0.12362101f, 0.03118811f, -1.48558903f, 0.53791946f, -0.31512237f, 0.42853943f, 
    0.15822849f, -0.14647873f, -0.13726451f, -0.07952878f, 0.00308980f, -0.10528222f, 0.02906473f, 0.07899355f, 
    -0.14798218f, -0.23909806f, -0.88640219f, -1.07911515f, -0.16905543f, 0.18518209f, -0.19382758f, 0.01707515f, 
    0.06717998f, -0.09608833f, -0.03354394f, 0.06279312f, 0.43969458f, -1.09874117f, 0.51959735f, -0.72634721f, 
    -0.10310838f, -0.06082457f, -0.07642756f, 0.35416809f, 0.07239290f, -0.02720984f, 0.11296562f, -0.07977472f, 
    0.06178716f, 0.29532689f, -0.09584467f, 0.26902544f, -0.03209345f, 0.11223464f, 0.06820438f, -0.01101169f, 
    -0.09609435f, 0.23864707f, 0.01594275f, -0.10513847f, 1.39094663f, -1.48070180f, -1.07271826f, -0.73588616f, 
    0.05279494f, -0.19535074f, -0.11528324f, 0.18143131f, 0.05090060f, 0.11156009f, -0.07300013f, -0.06194142f, 
    -0.21134081f, -0.15549248f, 0.35469347f, -0.21679212f, 0.07616946f, 0.21521644f, 0.15799445f, 0.14072962f, 
    0.08853613f, 0.03280762f, -0.00522916f, -0.26844886f, 0.12569146f, 0.00566083f, 0.01640539f, -0.07249954f, 
    -0.02297543f, -0.01442523f, -0.12127460f, -0.08526444f, 0.13189089f, 0.05933737f, 0.08374833f, -0.09447233f, 
    0.75014848f, 0.46221927f, -0.76902646f, 0.31666318f, 0.19289243f, -0.05080349f, 0.07244474f, -0.14928772f, 
    -0.03891868f, -0.26097134f, 0.01808347f, 0.43035156f, -0.07759953f, 0.28994098f, -0.26369825f, -0.11458642f, 
    0.08605602f, -0.03258597f, 0.02614365f, -0.04789920f, 0.10622813f, 0.10066811f, 0.15016556f, -0.03620454f, 
    0.27923208f, -0.25744981f, -0.08673640f, -0.33051232f, 0.07547597f, -0.00047293f, -0.07537918f, -0.24351399f, 
    -0.28164941f, -0.07229474f, -0.26102379f, -0.49062628f, -0.15783820f, -0.09461515f, 0.42100665f, -0.34036484f, 
    -0.07378008f, 0.07570875f, -0.03352404f, 0.04253134f, -0.20230496f, -0.19603881f, 0.15949155f, -0.00536627f, 
    0.04754994f, 0.12842734f, -0.12598017f, 0.08493423f, -0.01915679f, -0.37194598f, -0.11804560f, -0.20654556f, 
    -0.07814816f, 0.06535070f, -0.13223878f, 0.05681380f, 0.09448489f, 0.10374459f, 0.04502415f, 0.13975888f, 
    -0.06254590f, 0.02215096f, -0.00453282f, -0.02016627f, -0.00989529f, -0.12495291f, -0.14350766f, -0.01427045f, 
    -0.87442833f, 0.36635810f, 0.25492129f, 0.17872258f, 0.00128564f, -0.00011407f, -0.39247254f, -0.09356084f, 
    -0.39536443f, -0.20129605f, -0.22001544f, -0.26568890f, 0.42971277f, -1.00482178f, -1.02105594f, -0.71098161f, 
    -0.35604003f, -0.35174796f, 0.04099723f, -0.28195915f, 0.22712989f, 0.08281326f, 0.11563370f, 0.10405041f, 
    0.29262954f, -0.70570648f, -0.13679534f, 0.09297705f, 0.23146752f, 0.16769275f, 0.09534632f, -0.06463744f, 
    -0.29894340f, -0.33022282f, -0.34044680f, -0.73822933f, 0.25675094f, 0.39958656f, -0.18420897f, 0.14719412f, 
    -0.02018813f, 0.27205598f, 0.06412014f, -0.11569966f, 0.01823155f, 0.10734393f, 0.04969186f, 0.06518847f, 
    -0.04896760f, -1.18319261f, -0.45880917f, 0.74106365f, -0.04270457f, 0.18533692f, 0.20049597f, 0.17648672f, 
    -0.13331097f, -0.04628086f, 0.08713897f, -0.21846795f, 0.37411815f, -0.67246062f, -1.13700807f, 0.08589830f, 
    0.33579868f, 0.06471512f, 0.25887656f, -0.20032725f, 0.10219290f, -0.22327228f, -0.01870703f, -0.05281221f, 
    -0.33699697f, 0.00113660f, 0.61683452f, 0.46554372f, -0.27378139f, -0.21503353f, -0.02550084f, -0.07466277f, 
    0.13043070f, -0.00288615f, 0.27637166f, 0.06512659f, 0.18791792f, -0.56037617f, -1.16217577f, -0.03070725f, 
    0.28390518f, 0.11724010f, 0.20060015f, 0.22264744f, 0.14258470f, -0.08222301f, 0.03120279f, 0.18905585f, 
    0.09695415f, 0.12530781f, 0.12213148f, -0.37348065f, -0.18177931f, -0.23567823f, -0.37383017f, -0.21340720f, 
    0.24144213f, 0.07043952f, 0.07666805f, 0.29809210f, -0.19143917f, 0.28363431f, 0.11420603f, -0.19354807f, 
    0.08226234f, -0.11992364f, -0.05952663f, -0.11009570f, -0.09061262f, -0.14984861f, -0.00749777f, 0.16856492f, 
    0.10262219f, -0.70448887f, 0.12111213f, -0.01875143f, -0.27182069f, -0.00228549f, 0.14736891f, 0.13918921f, 
    0.06662054f, 0.30219620f, 0.13172178f, 0.07969511f, -0.54804671f, 0.25702310f, 0.24958079f, 0.16332765f, 
    -0.20063855f, -0.16726311f, -0.26594764f, -0.07757834f, -0.06660414f, 0.00430081f, 0.07656848f, 0.20926376f, 
    0.41111326f, -0.15897539f, 0.04343052f, -0.46012142f, 0.10091871f, -0.02123062f, 0.06299104f, -0.12741567f, 
    0.22572374f, -0.13541661f, 0.30793023f, 0.03301012f, -0.47628978f, 0.02644622f, 0.28611404f, 0.13688418f, 
    -0.15360077f, -0.27091131f, 0.07508578f, 0.21484779f, 0.29050338f, 0.00300966f, -0.03193283f, 0.09796539f, 
    -0.02931099f, 0.28443071f, -0.16079843f, 0.07906970f, 0.03531907f, 0.04346431f, -0.00780679f, 0.02458298f, 
    0.22835562f, 0.14845142f, 0.19762196f, 0.32459381f, -0.16721782f, -0.06205056f, 0.10584002f, 0.03410676f, 
    -0.13008296f, -0.08094168f, -0.20038942f, 0.09619957f, -0.11139483f, 0.44501293f, -0.22555438f, -0.71044582f, 
    -0.14549665f, 0.20736912f, -0.58966845f, -0.04493751f, 0.02291039f, 0.07492261f, 0.29550231f, -0.05152916f, 
    0.09756199f, 0.01324206f, -0.14851160f, 0.19731769f, -0.79538161f, -0.50808245f, 0.40160453f, 0.06866962f, 
    -0.29904306f, -0.07595429f, 0.04260523f, 0.24021940f, 0.06075790f, 0.05321455f, 0.15085618f, 0.00548600f, 
    0.29039976f, 0.13022906f, 0.67925966f, 0.01419990f, -0.07749892f, -0.33433366f, -0.17933914f, -0.28161690f, 
    0.03729357f, 0.12133392f, -0.00907842f, 0.10376184f, -0.43785626f, 0.12336593f, -0.24040236f, -0.03938464f, 
    -0.12680921f, -0.09190004f, 0.32651529f, -0.06851283f, 0.09085068f, 0.11485668f, -0.09354270f, -0.07105507f, 
    -0.80471891f, 0.13530135f, -0.00559168f, -1.21832716f, -0.34339762f, -0.11957984f, 0.04897780f, -0.14220612f, 
    0.01899668f, -0.10347208f, 0.17512445f, 0.00851021f, 0.45437020f, -0.56484634f, 0.41112509f, -0.18836565f, 
    -0.01453049f, -0.00740956f, -0.10669045f, 0.14084218f, 0.14918531f, -0.00140931f, 0.04579111f, 0.23083605f, 
    -0.13823193f, -0.31979421f, -0.13018639f, -0.10911181f, 0.11001989f, -0.03695361f, 0.08876679f, 0.13559625f, 
    -0.26354247f, 0.07245928f, -0.08123634f, -0.08090570f, -0.26038352f, 0.25508252f, 0.07589440f, 0.76773453f, 
    0.14672023f, 0.07711756f, -0.58636916f, 0.30414513f, -0.00832085f, -0.25229898f, -0.08407638f, -0.09598499f, 
    0.57190090f, -0.68379676f, -0.05152686f, -0.05924417f, 0.33292755f, 0.04660675f, -0.02995812f, 0.11123540f, 
    -0.09519287f, -0.40244454f, -0.28041801f, -0.46472770f, -0.12269174f, 0.01806102f, -0.51258540f, 0.10518157f, 
    0.40376702f, 0.33796686f, 0.41612676f, -0.20109062f, 0.26705372f, -0.15100850f, 0.01813596f, 0.12146212f, 
    -0.24991903f, 0.46265182f, 0.35760513f, 0.67665178f, 0.21048066f, -0.26694354f, -0.34246314f, -0.26570791f, 
    -0.02394315f, -0.23060358f, 0.13095370f, -0.00789261f, -0.42013001f, -0.37865877f, 0.13400507f, 0.08726270f, 
    0.21998620f, 0.21060397f, 0.22977705f, -0.08624602f, 0.07766271f, -0.07644226f, 0.12440411f, 0.07490442f, 
    0.32784280f, 0.13220936f, 0.38376752f, -0.03455282f, 0.09428468f, -0.11723664f, -0.25534630f, -0.33352560f, 
    -0.09572030f, -0.02756932f, -0.07959661f, -0.27932912f, 0.43205982f, -0.85439503f, -0.13324003f, -0.06190697f, 
    -0.02428712f, 0.22220835f, 0.06692532f, 0.03863597f, -0.12192637f, -0.09403701f, -0.10548166f, -0.33523262f, 
    -0.40439659f, -0.31934556f, -0.45216206f, 0.17443576f, 0.28084898f, 0.30516681f, 0.10990398f, -0.00942770f, 
    0.01684494f, -0.02959939f, -0.10421817f, -0.35544643f, -0.08082479f, -0.14867602f, -0.06636366f, -0.01499864f, 
    -0.07001787f, 0.21036793f, 0.13855480f, 0.02417520f, 0.20496018f, 0.16147093f, 0.34621936f, 0.28014946f, 
    0.11798237f, -0.14693330f, -0.21154869f, -0.13585770f, -0.26161340f, -0.03434700f, 0.10777055f, -0.12547797f, 
    -0.20581825f, 0.27316901f, -0.52633786f, -0.20962948f, -0.50363350f, -0.10572187f, -0.40635043f, 0.05943480f, 
    -0.22605044f, 0.07114171f, 0.06210673f, -0.12626082f, 0.16595544f, 0.25233445f, -0.00442764f, 0.03968215f, 
    -0.57915831f, 0.45239669f, -0.23150104f, 0.12645632f, -0.03534313f, -0.31839222f, -0.18820029f, 0.04569228f, 
    -0.24591638f, -0.12375645f, -0.34049514f, -0.83765638f, 0.03205277f, -0.86477172f, 0.35832277f, -0.06082521f, 
    0.03437704f, -0.14840443f, 0.19994521f, 0.04903709f, -0.12412710f, 0.14562391f, -0.05172899f, -0.06057948f, 
    0.22483483f, -0.23489407f, 0.09925857f, -0.07205445f, -0.02777025f, 0.03872342f, -0.21233112f, 0.17331527f, 
    0.07354368f, 0.01541382f, -0.09193584f, -0.25503337f, -0.45498154f, 0.39705032f, -0.72006023f, 0.33218327f, 
    0.12163828f, -0.01990016f, -0.12379691f, -0.00439498f, -0.25606298f, 0.18940389f, -0.13873294f, -0.04055779f, 
    -0.01866468f, -0.37381741f, 0.30584148f, 0.54335445f, 0.10516033f, -0.07492074f, -0.23116848f, 0.15973325f, 
    0.23803350f, 0.03476818f, 0.25535011f, 0.22801000f, -0.57491612f, 0.70849258f, -0.25594425f, 0.17917153f, 
    -0.29255724f, -0.03633611f, -0.18606476f, 0.28665990f, -0.06632058f, 0.21267633f, -0.07181752f, 0.27200353f, 
    -0.73973554f, 0.23530594f, -0.03171208f, 0.12257271f, 0.19047174f, 0.20451477f, -0.03248831f, 0.08738207f, 
    -0.14164008f, 0.01089530f, 0.11357680f, -0.01089958f, -0.47649193f, 0.02799237f, -0.78444171f, -0.67122245f, 
    -0.26399800f, -0.18939969f, -0.01499027f, 0.10727523f, -0.22436604f, 0.11944579f, 0.06524036f, 0.05576703f, 
    0.69124693f, -0.16289781f, 0.52365118f, -0.48370197f, -0.11680943f, -0.24046800f, -0.08461892f, 0.18183553f, 
    -0.16715677f, 0.06791467f, -0.39190605f, 0.06953483f, -0.25626490f, -0.19205989f, -0.10356427f, -0.28145218f, 
    -0.30585858f, -0.02382000f, -0.23980869f, 0.25962076f, 0.07196909f, 0.18339664f, 0.23680998f, 0.14292732f, 
    -0.68847793f, 0.45416248f, 0.65830612f, -0.09105202f, -0.04667491f, 0.19585232f, -0.12189668f, 0.02225262f, 
    0.00030991f, 0.06295078f, 0.34104905f, 0.08278859f, 0.10134733f, 0.11938926f, 0.47974467f, 0.38047379f, 
    0.06738159f, 0.09337617f, 0.12726122f, -0.22180559f, -0.14535739f, 0.09625432f, 0.19176413f, 0.24839994f, 
    -0.22647496f, -0.46491525f, 0.49383155f, -0.05397504f, -0.16005401f, 0.16958575f, 0.05424906f, 0.06858425f, 
    0.03647958f, 0.00989302f, 0.12022737f, 0.14683519f, 0.30773517f, 0.08804122f, 0.03305447f, 0.16680224f, 
    -0.05686937f, -0.09718064f, 0.01902882f, -0.01887531f, -0.05501186f, -0.42423561f, -0.23488683f, -0.51684314f, 
    0.40164915f, -0.29496911f, 0.49041897f, -0.18074687f, -0.01832894f, -0.03588837f, -0.18766820f, 0.20986681f, 
    -0.16846336f, 0.06916128f, 0.12988476f, 0.14768669f, -0.15162612f, -0.94368035f, -0.19917059f, 0.12334939f, 
    -0.27298895f, -0.43135145f, 0.03598142f, -0.58692634f, 0.01381786f, 0.03163926f, 0.06571636f, -0.07957687f, 
    -0.32429981f, -0.18897980f, -0.05600262f, -0.35702783f, 0.02780284f, -0.16742396f, -0.08952631f, 0.25453076f, 
    -0.01652856f, 0.08567519f, 0.12074395f, 0.01044666f, -0.08202554f, -0.67423052f, 0.72592092f, -0.12672441f, 
    -0.38381174f, -0.15614949f, -0.21837068f, -0.01799839f, 0.06268491f, 0.14921810f, -0.15860067f, 0.15747726f, 
    -0.02818442f, -0.43033478f, 0.67361522f, -1.14887464f, 0.17672046f, 0.00736930f, -0.07640749f, -0.18624642f, 
    0.20306663f, 0.05747013f, 0.02339810f, 0.24539047f, -0.07234724f, -0.00643357f, -0.10359921f, 0.55460030f, 
    -0.21932144f, 0.12599097f, 0.44182894f, 0.16330931f, -0.01455149f, 0.11981983f, 0.09511369f, -0.06221780f, 
    -0.07524130f, 0.06789923f, 0.06862056f, -0.20159933f, -0.08644839f, 0.01944672f, -0.21968283f, 0.29840761f, 
    -0.36964425f, 0.01780750f, -0.10928991f, -0.03846811f, 0.09105084f, -0.20257989f, 0.27664423f, 0.58038318f, 
    0.22388235f, -0.19632325f, -0.30437297f, 0.01530142f, -0.00836942f, -0.17084557f, 0.05127057f, -0.23684369f, 
    0.47817540f, 0.60104001f, -0.28224051f, -0.35181236f, -0.28576127f, 0.11976300f, -0.35095575f, -0.04501140f, 
    -0.21790928f, 0.20165943f, 0.10228036f, -0.03887458f, 0.50599241f, 0.26391229f, 0.15435010f, -0.22676036f, 
    -0.13788363f, -0.01612123f, -0.22578900f, 0.26145887f, -0.17524271f, 0.05591948f, -0.29859230f, -0.17731687f, 
    -0.19948043f, -0.24206492f, 0.32807717f, -0.24663500f, 0.09699012f, 0.31253296f, -0.09423532f, -0.03442464f, 
    -0.20188569f, -0.10781308f, 0.06198079f, 0.09393113f, 0.59774095f, 0.00627390f, 0.06756704f, -0.18597959f, 
    -0.17771231f, -0.08732351f, -0.33207881f, 0.08337764f, -0.27618858f, 0.14193711f, -0.08224847f, -0.34809220f, 
    -0.17919414f, 0.01572700f, -0.59644699f, 0.56743133f, 0.31241819f, 0.37613285f, 0.05436144f, -0.17920151f, 
    0.02186886f, 0.11120628f, -0.27764997f, 0.22369851f, -0.08363993f, -0.00564654f, 0.32291660f, 0.60346568f, 
    0.04462793f, 0.13496831f, -0.12695387f, 0.13868839f, -0.28704971f, -0.07666282f, 0.03943867f, -0.21687292f, 
    0.33025217f, 0.34073102f, 0.24189037f, -0.30525973f, 0.01746648f, 0.06789000f, 0.19189179f, 0.38975897f, 
    -0.17769665f, -0.06467348f, -0.04824199f, -0.37962693f, -0.23642121f, 0.14209665f, -0.16921575f, -0.29275736f, 
    0.07525801f, 0.02809330f, -0.07080048f, 0.17422615f, 0.12283038f, 0.14054246f, 0.19531317f, 0.22556953f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.27415955f, 0.11555342f, 0.09123535f, -0.17595665f, -0.15404136f, 0.10942508f, 0.09336189f, -0.23415981f, 
    0.14950009f, 0.03041748f, 0.01776915f, -0.03791165f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
