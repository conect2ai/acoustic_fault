#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.05786093f, 0.37102139f, 0.14345899f, -0.26354802f, -0.54027432f, 0.16145590f, 0.62302476f, 0.34685975f, 
    -0.26781738f, -0.66268969f, -0.12298688f, 0.44636017f, 0.01696349f, 0.06985124f, -0.41847548f, -0.19819400f, 
    -0.23900019f, -0.45891654f, 0.30071554f, -0.11786318f, 0.13026404f, 0.13848422f, 0.26911610f, -0.41591311f, 
    -0.36006027f, -0.69882095f, 0.20482369f, 0.14503281f, -0.62673163f, 0.06990788f, -0.30169001f, -0.30714363f, 
    -0.44823551f, 0.37222499f, -0.00978665f, -0.07905428f, -0.19906466f, -0.21852903f, 0.32218853f, -0.29669091f, 
    0.06264267f, -0.11667584f, -0.01153464f, -0.29823986f, -0.20338342f, 0.14557782f, 0.39243785f, 0.44427720f, 
    -0.03155889f, 0.35255957f, 0.68110424f, 0.63995010f, 0.06111534f, -0.03456588f, 0.01441327f, -0.14542614f, 
    0.03191912f, 0.13079216f, -0.35257336f, -0.44872370f, -0.18034746f, -0.13461420f, 0.00497098f, -0.07759915f, 
    -0.29633337f, -0.01574928f, -0.09847812f, 0.12967961f, 0.08682814f, -0.16779271f, 0.00163503f, 0.01545316f, 
    -0.11614756f, -0.00682199f, 0.28402898f, 1.18999493f, -0.87511349f, -0.58067673f, -0.39536110f, -0.41806731f, 
    0.35172963f, 0.49242944f, 0.56315321f, 0.18275997f, -0.08275235f, -0.25115255f, -0.02087657f, -0.06900907f, 
    0.05989418f, 0.28720599f, 0.09618839f, -0.15174821f, 0.08741637f, -0.03104488f, -0.18919505f, 0.11607961f, 
    -0.24496861f, -0.11605980f, -0.01242922f, -0.09179063f, 0.85543090f, 0.78691089f, 0.30620828f, -0.02543097f, 
    0.13969135f, -0.18743961f, -0.46460843f, -0.12258588f, -0.31073272f, -0.53854555f, 0.28798521f, 0.08421747f, 
    -0.14693128f, -0.09998483f, 0.23406421f, -0.08588009f, 0.06703513f, -0.11591684f, -0.06632003f, 0.03253690f, 
    -0.07865148f, 0.25838083f, 0.04731321f, -0.08221512f, -0.24687706f, -1.41706085f, 0.13996394f, -0.51064759f, 
    -0.39352602f, 0.17296505f, 0.56681401f, 0.31273946f, 0.54315782f, -0.02748530f, 0.40207660f, 0.12694797f, 
    -0.24812621f, -0.13950129f, -0.42328691f, 0.14408426f, 0.22006792f, 0.10735077f, 0.06925721f, 0.21795483f, 
    0.06319804f, 0.00299244f, -0.14010622f, -0.04062764f, -0.03427013f, -0.24000506f, 0.06083685f, -0.08498167f, 
    -0.20185134f, -0.13291670f, -0.28647539f, 0.55139124f, 0.03101977f, -0.11386074f, -0.10261908f, 0.24634440f, 
    -0.13007075f, 0.84646064f, -0.29981697f, -0.08782479f, -0.18208212f, -0.11085027f, -0.35815474f, -0.05251496f, 
    0.12050994f, 0.15690793f, 0.14062561f, 0.23938717f, 0.17959337f, 0.02406107f, -0.05988551f, -0.14736491f, 
    -0.52774662f, -0.46941862f, -0.08205120f, -0.56608236f, -0.23895162f, -0.43359914f, -0.37287930f, -0.05320578f, 
    0.16934426f, 0.19058564f, -0.01762816f, -0.22334787f, -0.08500958f, -0.09494159f, -0.09343122f, 0.04222280f, 
    0.21099842f, -0.01528724f, -0.35191613f, -0.33611697f, -0.21482494f, -0.12326009f, -0.17136467f, -0.36903673f, 
    -0.74895936f, -0.35050938f, 0.53504890f, 0.65421617f, 0.05612001f, -0.94434291f, -0.73620993f, -0.21307006f, 
    0.17200679f, 0.19417951f, 0.12343464f, -0.17015021f, -0.13511005f, 0.61226803f, -0.19857931f, -0.30664980f, 
    0.12984087f, 0.05658256f, -0.35065997f, -0.76319551f, -0.07351053f, 0.19827966f, 0.10015835f, -0.00715074f, 
    -0.11770303f, 0.36541325f, -0.00606506f, 0.09902894f, 0.33241749f, 0.47898990f, 0.30951872f, 0.23538858f, 
    -0.05252579f, 0.09677287f, 0.15200767f, -0.14782242f, 0.11327439f, -0.25345969f, -0.11562111f, -0.08620843f, 
    -0.11543422f, 0.05319981f, 0.17475347f, -0.04760095f, -0.31036940f, -0.30342966f, -0.16562453f, -0.11863676f, 
    -0.42053011f, -0.29689041f, 0.06990333f, -0.77822375f, -0.92482191f, -0.63961762f, -0.36709055f, 0.68184429f, 
    -0.24578753f, -0.01674398f, 0.09999223f, 0.06167875f, 0.26197448f, -0.31108573f, 0.01305656f, -0.13938740f, 
    0.28116953f, 0.13600165f, -0.02918700f, -0.24567142f, 0.21950677f, -0.19903462f, -0.13945013f, -0.14325458f, 
    0.18716085f, -0.01689471f, 0.06384454f, -0.44686899f, 0.30038652f, 0.04568349f, 0.20145777f, 0.35938117f, 
    0.24863555f, 0.42723233f, 0.27612880f, 0.16833758f, 0.12106037f, -0.21852638f, -0.01558143f, 0.17836356f, 
    -0.07107327f, 0.11796024f, 0.09243944f, -0.38817605f, -0.25404915f, -0.13542360f, -0.12492054f, 0.13542005f, 
    0.03790123f, 0.09535013f, -0.03735480f, 0.10814087f, -0.94271660f, 0.14190163f, 0.51167494f, 0.47573718f, 
    -0.37526265f, 0.14494795f, 0.04651869f, -0.15201433f, -0.23116934f, -0.03723506f, -0.19943334f, -0.14849274f, 
    -0.13038561f, 0.10380289f, 0.06998170f, 0.03030807f, 0.02723110f, -0.28877634f, -0.03679692f, -0.01691905f, 
    -0.21968442f, -0.28724661f, -0.17063046f, -0.23704450f, -0.34903595f, 0.21819256f, 0.53734982f, 0.24709569f, 
    -0.41312540f, 0.18088403f, -0.21948871f, -0.23460750f, 0.15946114f, 0.23926370f, -0.06402619f, -0.08497717f, 
    0.01572759f, 0.19701067f, 0.19710518f, 0.05443089f, 0.27178708f, 0.11530021f, -0.47620791f, 0.27932569f, 
    0.06224488f, 0.26401463f, 0.03782865f, -0.31818455f, 0.28756911f, 0.11956083f, 0.03386723f, -0.20110933f, 
    -0.13264214f, -0.52280319f, 0.04246967f, -0.24799201f, -0.51002419f, -0.21853033f, -0.09353341f, -0.29195920f, 
    -0.31249157f, 0.18106851f, 0.41883275f, -0.20946883f, -0.31323162f, 0.09866706f, -0.18517418f, -0.34361127f, 
    0.02676047f, 0.02944080f, 0.23850311f, -0.34824726f, -0.44955677f, -0.38774705f, -0.28011116f, 0.04542671f, 
    -0.65763754f, -0.55028617f, -0.51874399f, -0.36425987f, 0.51078659f, 0.17012094f, -0.00890492f, 0.13952526f, 
    -0.54112685f, 0.52320373f, -0.37153894f, -0.17380974f, 0.46477273f, -0.13787694f, -0.38924798f, -0.04347149f, 
    -0.14279073f, -0.02135973f, -0.21072119f, -0.20820306f, 0.07712980f, 0.50492245f, 0.09327114f, -0.32434323f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25291553f, 0.16338825f, 0.25674292f, 0.03910709f, 0.24439782f, 0.04747702f, 0.07694067f, 0.10503884f, 
    0.15521325f, 0.05692621f, 0.12108786f, 0.44526929f, 0.27217650f, 0.41998449f, 0.06926377f, 0.09304650f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16886172f, -0.35419545f, -0.01303549f, -0.30565923f, 0.01400086f, -0.02837903f, 0.01649959f, 0.14090225f, 
    0.07106412f, 0.16133030f, -0.10959052f, -0.43148711f, 0.26150289f, 0.14141233f, 0.00833896f, 0.02557009f, 
    0.17694485f, 0.08375025f, 0.09009361f, -0.12072926f, 0.08044297f, 0.05144455f, -0.08767859f, -0.03365474f, 
    -0.19285762f, -0.04059929f, -0.30400407f, -0.15772545f, -0.03642491f, 0.00885081f, -0.05304602f, -0.13448405f, 
    0.05152112f, -0.01485394f, 0.00796409f, -0.09344801f, 0.09772800f, 0.15239538f, 0.13970868f, -0.12292608f, 
    0.00225018f, -0.06495581f, -0.00303853f, -0.03558863f, -0.01768231f, -0.00284676f, -0.07242316f, 0.00062125f, 
    -0.00838811f, 0.03168572f, 0.20590666f, 0.08146080f, -0.14913693f, 0.08550559f, 0.23766679f, 0.12360068f, 
    0.04596430f, 0.00656562f, -0.03127107f, -0.03026954f, 0.31085047f, 0.00863899f, 0.13494903f, 0.00491069f, 
    0.10161037f, 0.03579684f, -0.02906639f, -0.00778147f, -0.22535120f, 0.03254676f, 0.06708685f, 0.01440017f, 
    0.14313574f, 0.10029589f, -0.02404144f, 0.01048157f, 0.03484892f, 0.16868807f, 0.13307588f, 0.15501930f, 
    -0.02784356f, 0.15449844f, 0.19280867f, 0.15333577f, -0.02410083f, 0.12898180f, -0.08245444f, -0.11390588f, 
    -0.11432246f, -0.30327541f, 0.09933924f, -0.19440474f, -0.22529420f, -0.19075996f, -0.07619478f, 0.02919538f, 
    -0.12162242f, 0.29050514f, -0.06067199f, -0.16617945f, -0.01492072f, -0.21922524f, 0.01327275f, -0.36366436f, 
    -0.09891465f, -0.29820588f, -0.16139950f, 0.17381525f, 0.07704484f, 0.08884904f, 0.02868300f, 0.00139094f, 
    0.01147632f, -0.05296464f, 0.02583334f, -0.02218318f, 0.05912358f, 0.02269924f, 0.00220066f, 0.03203440f, 
    0.09315809f, 0.12301365f, 0.16682018f, 0.19414145f, -0.05285416f, -0.02612942f, -0.04141612f, -0.10970223f, 
    -0.21141495f, -0.05382436f, 0.03006106f, -0.07483539f, 0.33146510f, 0.22321719f, 0.15779729f, 0.09451927f, 
    0.09368315f, 0.06404935f, 0.06526174f, 0.05652165f, 0.16897500f, -0.00006083f, -0.19233701f, -0.21190816f, 
    0.05817844f, -0.07793228f, -0.06524634f, -0.17141508f, -0.08411702f, -0.15157439f, -0.22745691f, -0.04682563f, 
    0.25985587f, -0.08303066f, -0.09394670f, -0.13896304f, 0.01909011f, 0.06291652f, 0.06993485f, 0.04642292f, 
    0.03167839f, 0.11512789f, 0.06934015f, 0.03103911f, 0.16394918f, 0.08977094f, 0.07144468f, 0.00105871f, 
    0.00800074f, 0.05939407f, -0.07019407f, -0.01929165f, -0.04963923f, -0.15789814f, -0.10629561f, -0.43158123f, 
    -0.12910002f, -0.37076941f, 0.11016878f, -0.22403771f, 0.24975681f, 0.07319837f, 0.26468980f, -0.01383143f, 
    -0.16671950f, -0.29597113f, 0.23864135f, -0.22366473f, -0.04801796f, 0.10737515f, 0.20176741f, -0.04519786f, 
    0.33579439f, -0.04356343f, -0.04164575f, 0.20766503f, -0.13348626f, 0.10749010f, -0.11890453f, 0.02603695f, 
    0.02957201f, -0.00985942f, 0.15770033f, 0.04422347f, 0.14122806f, 0.08066509f, 0.22931285f, -0.12228004f, 
    0.00771999f, 0.19438368f, -0.09274127f, -0.03619803f, -0.04422009f, 0.05821991f, -0.03837326f, 0.02515597f, 
    0.25019079f, -0.22326501f, 0.20701344f, 0.20716649f, -0.07647594f, 0.02165757f, -0.14447203f, -0.01722051f, 
    0.04128150f, 0.05243538f, 0.03341024f, 0.03313610f, -0.12658009f, -0.12034635f, -0.24528587f, 0.02394872f, 
    0.02197737f, 0.05399952f, -0.05760045f, 0.12882587f, 0.06661400f, 0.01531962f, 0.02860925f, -0.10527711f, 
    0.06428865f, -0.23438200f, 0.11442484f, 0.14056508f, -0.06727111f, -0.00689683f, -0.16132304f, -0.11192085f, 
    -0.10110921f, 0.09105785f, -0.01568663f, 0.02689003f, -0.21936208f, 0.20115167f, -0.12180741f, -0.12884299f, 
    0.19130941f, 0.15835005f, 0.16344243f, -0.01295811f, -0.11945433f, 0.02654034f, 0.03620967f, 0.02102991f, 
    -0.08912718f, -0.06035939f, -0.15373896f, 0.17418770f, -0.03551120f, 0.14624970f, -0.10143979f, -0.10302240f, 
    -0.08115604f, 0.22916329f, 0.18048351f, 0.03559525f, -0.02799997f, 0.12200668f, -0.08516110f, -0.09496062f, 
    0.10200381f, 0.06363256f, -0.05017066f, 0.01584874f, -0.00780825f, -0.07790054f, -0.03994230f, 0.04984162f, 
    0.15146923f, 0.26977211f, 0.42488140f, -0.15238734f, 0.10178684f, -0.10385479f, 0.10796965f, 0.03971334f, 
    -0.01018477f, 0.07649137f, -0.00997668f, -0.04706919f, -0.13372855f, 0.05473915f, -0.24104829f, 0.08403477f, 
    -0.05542960f, 0.11004659f, -0.04426219f, 0.00297715f, 0.03993729f, 0.03447641f, -0.06627845f, -0.00249055f, 
    0.09456494f, 0.16944697f, -0.21326694f, -0.01122799f, 0.20065694f, 0.04484186f, 0.07570357f, -0.02373792f, 
    0.00718468f, 0.03184576f, 0.06271575f, 0.01840651f, -0.07591973f, -0.04508324f, 0.00185385f, -0.08461934f, 
    0.07355815f, -0.03625691f, -0.01545588f, 0.08849180f, 0.05990480f, 0.04189663f, 0.15604597f, 0.24659829f, 
    -0.10141950f, 0.22334825f, 0.12983999f, -0.07340476f, -0.02739501f, 0.09723704f, -0.03010956f, 0.11492015f, 
    0.08596164f, -0.01753685f, -0.00356003f, -0.10989744f, 0.01967182f, -0.11972618f, 0.11162037f, 0.00256644f, 
    -0.10373337f, -0.00702355f, 0.08501621f, 0.08081974f, 0.00549295f, 0.05341785f, 0.02086626f, 0.02317918f, 
    0.10488125f, -0.06226208f, 0.05357151f, 0.11722899f, 0.06775650f, 0.09376752f, -0.12044194f, 0.06733110f, 
    -0.03985667f, 0.01125568f, 0.00755476f, 0.07138614f, 0.13425122f, 0.06133298f, -0.20912004f, 0.04953924f, 
    0.13897699f, 0.15582377f, -0.11008964f, 0.04687482f, 0.00837086f, -0.07309023f, -0.14831892f, -0.04808917f, 
    0.12867190f, -0.12080842f, -0.11875445f, 0.07319844f, 0.04108313f, 0.07246321f, 0.07222673f, 0.11944712f, 
    0.00563104f, 0.02608057f, -0.24532902f, -0.12661514f, 0.10406854f, 0.14660273f, 0.06015695f, -0.02117023f, 
    -0.02719483f, 0.15629852f, 0.07121743f, -0.23261362f, -0.00322686f, 0.08307931f, 0.05857018f, 0.18372919f, 
    -0.19232656f, 0.00529542f, -0.17685568f, 0.30841196f, 0.04346821f, 0.03736603f, -0.01744209f, 0.10446934f, 
    0.13577540f, 0.02485783f, -0.05703991f, -0.00557721f, -0.28378680f, -0.03417454f, -0.09660374f, -0.01003966f, 
    0.14201795f, -0.07243107f, -0.02260096f, 0.08402693f, 0.03771265f, -0.07456321f, -0.03949794f, 0.10232905f, 
    -0.40802318f, 0.16081177f, 0.00845439f, 0.15450162f, 0.10541116f, 0.04673459f, 0.11738305f, -0.04566890f, 
    0.08650463f, 0.07941378f, -0.01652673f, 0.02844520f, 0.25070092f, -0.05723169f, 0.05789202f, -0.05576900f, 
    -0.00732039f, 0.00406638f, 0.00831093f, 0.06982843f, -0.05837749f, -0.00001551f, -0.14998963f, -0.05107028f, 
    -0.04846868f, -0.06678916f, 0.28866875f, -0.04366432f, -0.11495104f, 0.12026126f, 0.07685458f, -0.11397143f, 
    -0.01871218f, -0.11706229f, 0.23573484f, -0.02354035f, 0.14570525f, 0.18872711f, 0.02754464f, -0.04696687f, 
    0.20049804f, 0.16929442f, 0.04667610f, 0.02732030f, -0.09478998f, -0.12415721f, -0.08234542f, 0.01121937f, 
    0.06323168f, 0.28093386f, 0.20753296f, 0.01206883f, -0.12406932f, 0.04618505f, -0.00510896f, -0.10427719f, 
    -0.12978597f, -0.08162870f, -0.00594366f, 0.16958517f, -0.01374347f, -0.16003574f, 0.04424773f, -0.15869540f, 
    -0.01884508f, -0.04374465f, 0.07111032f, 0.05345165f, 0.15068555f, -0.23034589f, 0.00867495f, 0.07594275f, 
    -0.02106741f, 0.08181483f, -0.15545699f, 0.12182888f, 0.06961803f, 0.14185929f, 0.08428248f, -0.00839776f, 
    -0.00463024f, 0.02201269f, -0.14633662f, 0.11630944f, 0.27950907f, 0.09203499f, 0.04737085f, -0.10231915f, 
    0.01588504f, 0.03769762f, 0.09760913f, -0.01407634f, 0.09189463f, -0.01864593f, 0.04383583f, 0.10406364f, 
    0.14939886f, -0.09800624f, -0.02165220f, -0.06711034f, -0.12125736f, -0.00065021f, -0.12826489f, -0.00093449f, 
    -0.06907278f, -0.04192542f, -0.26631889f, -0.18241838f, -0.01753698f, -0.04295110f, -0.00482858f, 0.01763694f, 
    0.03983265f, 0.05503830f, 0.01860018f, 0.00392857f, -0.06927158f, 0.14367454f, -0.07269647f, 0.02111728f, 
    0.21425015f, 0.14651340f, 0.15061979f, 0.09696431f, 0.06869145f, -0.03399050f, -0.04703991f, 0.04889132f, 
    0.05020792f, -0.06306420f, -0.04186010f, 0.00123319f, 0.16172491f, 0.22588041f, -0.19731031f, 0.09902526f, 
    0.01907365f, -0.03431617f, 0.01464424f, 0.03000730f, 0.04700127f, 0.07846414f, -0.20811358f, 0.09714937f, 
    -0.03611371f, 0.11338441f, 0.07185681f, 0.04762707f, 0.14267609f, -0.09574621f, 0.16788632f, 0.00487290f, 
    0.05046754f, 0.10606309f, -0.21042721f, 0.07302096f, -0.13002071f, 0.19478080f, -0.00954705f, 0.13923694f, 
    -0.02336547f, 0.00557660f, 0.17852670f, -0.07042572f, 0.07396264f, -0.10951890f, -0.01752108f, 0.00249704f, 
    -0.03831511f, 0.09930870f, -0.17963752f, -0.12965496f, 0.09909301f, -0.01849664f, 0.11976465f, 0.03885363f, 
    0.10598432f, -0.00319702f, 0.03029694f, -0.02011831f, 0.00799933f, 0.03703872f, 0.13646011f, -0.07703399f, 
    0.02916883f, -0.16772585f, -0.07898356f, 0.04542969f, -0.02304533f, 0.04366312f, -0.00766773f, 0.07715150f, 
    -0.12720722f, 0.28712234f, -0.23595862f, 0.10860179f, 0.05363728f, 0.12983499f, 0.31924832f, -0.00648623f, 
    0.07565217f, -0.03549038f, -0.03598673f, -0.02925532f, 0.03947866f, -0.13895524f, 0.30161396f, 0.18021178f, 
    -0.13553748f, -0.15243462f, -0.16924626f, 0.06503700f, 0.15659633f, 0.07620357f, -0.09100990f, -0.02561934f, 
    0.09154772f, 0.07397070f, 0.38300738f, -0.09754912f, -0.09835137f, 0.02367693f, 0.01591962f, 0.04948583f, 
    0.04758442f, -0.23295015f, 0.09377807f, 0.03706707f, 0.02182585f, 0.12256473f, -0.04976812f, -0.02431094f, 
    0.01154029f, -0.07105049f, 0.03885768f, -0.01883673f, 0.05295404f, 0.02510607f, -0.12530126f, 0.02361876f, 
    -0.23090796f, -0.01383053f, -0.09276001f, 0.37289140f, -0.12000477f, 0.11087587f, 0.03358256f, -0.17475845f, 
    -0.04525899f, -0.15055960f, 0.04132778f, 0.02983894f, 0.17711808f, -0.10082861f, 0.18933308f, 0.05011780f, 
    0.10207964f, -0.05894212f, 0.06402364f, -0.08547442f, 0.14623097f, -0.19172415f, 0.14386639f, 0.05008183f, 
    -0.04333006f, 0.13715120f, 0.08718224f, 0.00567686f, -0.13811262f, -0.07447375f, 0.02739647f, 0.07713300f, 
    0.00706148f, 0.03162383f, -0.05326331f, 0.06734300f, 0.24958341f, 0.03747308f, 0.05944529f, 0.02696591f, 
    -0.01125284f, 0.02249374f, 0.06333829f, -0.11582215f, 0.03106167f, 0.01975679f, -0.00717076f, -0.06541789f, 
    0.20809287f, -0.14638488f, -0.12760098f, 0.07475565f, -0.01805421f, -0.01089863f, 0.05297348f, -0.01963747f, 
    0.01285733f, 0.08101582f, -0.09990277f, 0.10241607f, -0.07328200f, 0.07659192f, -0.13357407f, -0.05415113f, 
    0.00148568f, 0.03453648f, 0.02201778f, 0.08010193f, -0.01117613f, 0.13802819f, -0.12864877f, 0.07145738f, 
    -0.03820347f, -0.00921868f, 0.01296155f, -0.04193589f, 0.05503152f, -0.00864474f, -0.05576513f, 0.11371519f, 
    0.08104685f, 0.04585513f, -0.10300708f, -0.04357086f, 0.06159092f, 0.16113916f, 0.04947707f, 0.07764162f, 
    0.00101874f, -0.28739467f, -0.00056340f, 0.09957983f, -0.02586300f, -0.00702781f, -0.17792410f, 0.04954284f, 
    0.10237333f, 0.18398286f, 0.00248843f, 0.08046788f, 0.07694241f, -0.07965514f, 0.01395032f, -0.18016289f, 
    0.01658875f, 0.03817813f, -0.05759283f, -0.03507017f, 0.04293716f, 0.18694283f, 0.12077349f, 0.30892777f, 
    -0.07777590f, -0.05105700f, 0.17253724f, 0.07723299f, 0.09058979f, 0.06286248f, 0.00432667f, 0.14012660f, 
    0.03289333f, -0.07477037f, -0.38145652f, 0.13621148f, -0.05614371f, 0.02207470f, 0.03934265f, -0.07901920f, 
    0.15500243f, 0.04329736f, -0.05412315f, 0.04132375f, 0.11655723f, -0.01891955f, 0.00410474f, -0.16408932f, 
    -0.00563722f, -0.01067746f, -0.13988377f, 0.00569322f, 0.01305390f, -0.03856548f, 0.01067270f, -0.00707861f, 
    -0.27096820f, -0.15896571f, -0.05596674f, -0.08874944f, 0.10621282f, -0.10259513f, 0.05799282f, -0.13528591f, 
    0.00334716f, -0.03298575f, 0.00429285f, -0.03410313f, -0.14860454f, 0.10755183f, 0.11464467f, 0.07336818f, 
    -0.04108454f, -0.01323928f, 0.06365974f, 0.17610173f, -0.06287251f, 0.04317471f, -0.00160724f, 0.06615029f, 
    0.02470298f, 0.14516370f, 0.11824318f, -0.11051965f, -0.10731865f, 0.06199408f, 0.01495046f, -0.00617142f, 
    0.02952939f, 0.18076283f, 0.04654697f, 0.07808403f, 0.06746332f, 0.00680730f, 0.07822901f, 0.17085776f, 
    -0.01148924f, 0.00843486f, -0.05660829f, 0.07257002f, 0.05065144f, -0.09450411f, -0.10075373f, -0.19790429f, 
    -0.05071203f, 0.11399600f, 0.09460960f, 0.44051251f, -0.07243881f, 0.11370254f, 0.03515841f, 0.03818170f, 
    0.02468058f, 0.07625709f, -0.13536957f, 0.05152690f, 0.01142912f, -0.14808908f, -0.00253948f, -0.25204581f, 
    0.00070974f, -0.00125653f, -0.04888768f, 0.04978809f, 0.06001788f, -0.15619279f, 0.00436348f, -0.15786418f, 
    -0.08545479f, 0.13208441f, 0.06816307f, 0.18692669f, 0.11869792f, -0.04200144f, 0.06257324f, 0.16273756f, 
    0.00602914f, 0.00120131f, -0.16102783f, -0.02103685f, 0.01190016f, -0.15112731f, -0.09937497f, -0.18454453f, 
    0.10046194f, -0.06478202f, -0.03165298f, 0.05287183f, 0.08156058f, 0.05226279f, 0.12356425f, 0.14760838f, 
    -0.09900486f, 0.04669058f, 0.16644688f, 0.12255277f, -0.01092883f, 0.00893518f, -0.15202938f, -0.09656262f, 
    -0.17930020f, -0.08198542f, -0.20545956f, -0.09377813f, -0.12593123f, -0.08713115f, -0.13521351f, -0.13394113f, 
    -0.00253105f, -0.02255693f, -0.02883456f, 0.00719148f, 0.05659169f, 0.15107472f, 0.14358142f, 0.10642630f, 
    0.12985732f, 0.04523823f, 0.12565474f, 0.10282996f, 0.13536052f, -0.03353776f, -0.09309474f, 0.05616472f, 
    0.02759722f, -0.03194394f, -0.03644503f, -0.07018366f, -0.01091720f, 0.29195145f, 0.06971066f, 0.11905555f, 
    -0.05143536f, -0.13618919f, 0.05456792f, 0.01772249f, -0.01732055f, -0.06517836f, -0.24796952f, -0.05895767f, 
    0.00703228f, -0.00229440f, 0.07917623f, -0.00726468f, -0.10330452f, 0.03777158f, -0.07694951f, -0.06706850f, 
    -0.05645100f, 0.05209391f, -0.01845303f, -0.00691619f, -0.03437442f, -0.03605229f, -0.04570749f, -0.05671642f, 
    0.00254379f, 0.04077997f, -0.02766660f, 0.00292623f, -0.00321044f, 0.00873544f, 0.00643940f, -0.05751383f, 
    0.07355720f, -0.00544494f, 0.08536923f, -0.03578926f, 0.03830095f, -0.01678461f, -0.05027374f, -0.06178847f, 
    -0.05571136f, -0.02743420f, -0.02123241f, 0.03055705f, -0.02359597f, 0.00668517f, -0.05051721f, -0.00078603f, 
    -0.09412422f, -0.00209926f, 0.00339155f, -0.01620851f, -0.07977691f, -0.03715095f, -0.00784589f, -0.07272669f, 
    -0.01169011f, -0.04758757f, 0.02685251f, 0.08247648f, 0.04140093f, -0.00147386f, 0.03587628f, -0.09927331f, 
    0.03999092f, -0.00465579f, -0.07621095f, -0.02237496f, 0.01865516f, -0.03738463f, -0.08558736f, 0.01659164f, 
    -0.00956127f, -0.01556594f, 0.03729068f, 0.05097886f, -0.04362055f, -0.01104919f, -0.10057832f, -0.02989237f, 
    0.00900052f, -0.03837221f, 0.01492160f, -0.00589179f, -0.10543510f, -0.08293501f, -0.05741800f, -0.02255050f, 
    -0.06038335f, -0.02977259f, -0.07982676f, 0.00715334f, -0.03573414f, 0.00026971f, -0.02883342f, 0.03727269f, 
    0.02070513f, -0.06216322f, -0.00459322f, -0.05289752f, 0.01127366f, -0.10696907f, -0.00550174f, -0.01450778f, 
    0.06185238f, -0.01895203f, -0.04304280f, 0.01792751f, -0.06190936f, -0.03105490f, -0.01932972f, -0.01293614f, 
    -0.07978203f, -0.08381239f, -0.09626935f, -0.07407588f, 0.03719088f, -0.08116648f, 0.02157189f, 0.04747644f, 
    0.04011382f, -0.05515578f, -0.00059435f, -0.06003290f, -0.06025603f, -0.07016823f, 0.04792642f, -0.06548074f, 
    0.03206169f, -0.01055627f, 0.00536056f, 0.01548275f, -0.05647025f, -0.02413951f, -0.04477793f, 0.06613632f, 
    0.00013578f, -0.09520429f, 0.00270374f, -0.07564270f, 0.02482657f, 0.04943706f, -0.05010097f, -0.03706358f, 
    -0.08043945f, 0.01905514f, -0.06478048f, -0.02597086f, -0.03335814f, 0.01949889f, 0.01712256f, 0.05220322f, 
    0.06688827f, 0.06953578f, 0.02732674f, 0.05281361f, -0.03736731f, -0.00301475f, -0.04093185f, -0.09306046f, 
    -0.05333967f, -0.01229676f, -0.06828207f, 0.00146726f, -0.05866298f, -0.06103007f, -0.08577429f, -0.02913686f, 
    -0.05657103f, 0.03703805f, 0.02305272f, -0.08316765f, -0.04352650f, 0.03233905f, -0.04145873f, -0.09929454f, 
    -0.00529432f, -0.04812663f, 0.05610431f, 0.04646286f, 0.05024253f, -0.02038782f, 0.02287266f, -0.04103738f, 
    -0.01518758f, 0.03394435f, -0.04038969f, -0.04001999f, -0.01684610f, -0.05403253f, -0.02636543f, -0.03649396f, 
    -0.06799474f, -0.10298089f, -0.06928668f, 0.06989399f, -0.07489585f, 0.02045092f, -0.06136702f, -0.00486075f, 
    0.20663536f, 0.00108218f, -0.09014447f, -0.01910463f, -0.00249120f, -0.10193717f, 0.02200391f, 0.07922893f, 
    0.06419072f, 0.00831654f, 0.05980736f, -0.04175765f, 0.10932623f, -0.04219680f, 0.06223070f, -0.07143525f, 
    0.03929162f, 0.18321322f, 0.00578380f, -0.02343614f, -0.00405879f, -0.01675812f, -0.22876479f, 0.00982139f, 
    -0.09199031f, -0.22840042f, 0.14133595f, 0.29034534f, -0.11873312f, 0.07563166f, -0.16172257f, 0.03580843f, 
    0.05784241f, -0.04650088f, -0.10160436f, -0.20655507f, -0.35574955f, 0.09962998f, 0.21353488f, 0.06096445f, 
    0.03415176f, -0.03656963f, -0.13047411f, -0.07552937f, 0.01624573f, 0.08631705f, 0.10225178f, 0.11145860f, 
    -0.42796943f, -0.10827968f, 0.04538413f, 0.27292758f, -0.04006791f, 0.05691588f, -0.21980357f, 0.06229101f, 
    0.12655433f, 0.02361924f, -0.07200242f, 0.02445519f, 0.01113914f, 0.02828993f, 0.32095948f, 0.10488137f, 
    0.21988003f, 0.01059425f, -0.01140829f, -0.19449864f, -0.11238328f, 0.01480266f, 0.12434249f, 0.08074562f, 
    0.06242128f, -0.32078239f, -0.13695191f, -0.30714452f, 0.04957669f, 0.01568387f, -0.08873865f, 0.02611669f, 
    -0.01273159f, -0.06660295f, -0.08673294f, -0.15647464f, 0.09284548f, 0.12756637f, 0.07740405f, -0.02529776f, 
    0.23532909f, 0.10044283f, 0.06790522f, 0.04458630f, 0.03959099f, 0.04601950f, 0.10980618f, 0.14142214f, 
    -0.01438743f, 0.18253355f, 0.25430149f, 0.11695461f, -0.01970706f, -0.03600347f, -0.01621022f, 0.14820133f, 
    -0.11723173f, -0.09405999f, 0.03962883f, 0.05985049f, -0.01525946f, -0.03489773f, -0.03241848f, 0.08799475f, 
    -0.00977509f, -0.08085737f, 0.02655748f, 0.00285182f, 0.09028097f, 0.20951939f, 0.06446178f, 0.08256065f, 
    0.06624438f, 0.05823744f, 0.21634014f, 0.01803479f, -0.00815951f, -0.04896372f, 0.19739959f, -0.11739489f, 
    -0.09767487f, 0.04464622f, -0.01043309f, 0.04333691f, -0.00143286f, -0.00431930f, 0.12938355f, 0.30926347f, 
    -0.10791355f, -0.17929204f, -0.13422173f, -0.21686934f, -0.15294115f, -0.00302905f, -0.10744270f, 0.02291339f, 
    0.11914777f, 0.28564271f, 0.03815793f, 0.03096553f, 0.05189245f, 0.04956081f, -0.08113708f, -0.00051193f, 
    -0.01000185f, 0.06725448f, -0.03987565f, -0.01429198f, -0.16143447f, -0.18093105f, 0.01250604f, 0.05721847f, 
    -0.00736681f, -0.03444856f, -0.05956292f, 0.08824362f, 0.07993435f, -0.04229494f, -0.03378148f, -0.08649945f, 
    0.02106495f, 0.15661225f, -0.03995688f, 0.03344905f, 0.07800118f, -0.00114592f, 0.04315260f, -0.00618674f, 
    0.09671512f, 0.08216631f, -0.04999954f, 0.03821578f, 0.06409942f, 0.06058023f, -0.03470475f, 0.06494629f, 
    0.04788234f, 0.01118984f, 0.04051520f, -0.07071801f, 0.00768443f, -0.09795345f, 0.09715272f, -0.04151586f, 
    0.08358825f, -0.19178522f, 0.10887279f, 0.25231281f, 0.09932537f, -0.19098474f, -0.03361604f, 0.02982591f, 
    0.09988832f, -0.04286162f, 0.23901695f, 0.05127337f, -0.24533077f, -0.24681193f, -0.15848781f, -0.16905254f, 
    0.23489603f, 0.02609560f, 0.12579201f, -0.08587407f, -0.10036393f, -0.12205447f, 0.01225309f, -0.06530719f, 
    0.65434039f, 0.23107980f, 0.32187405f, 0.39468259f, -0.06737230f, -0.04194429f, -0.01420819f, -0.05256012f, 
    0.01927956f, 0.01000979f, 0.02748649f, -0.05454385f, 0.16164166f, -0.19773601f, -0.04910038f, -0.01004862f, 
    -0.01468993f, 0.00542360f, -0.10398857f, 0.08358148f, 0.12963836f, -0.07179993f, -0.07756554f, -0.04630238f, 
    0.27091745f, 0.28798866f, 0.16384374f, 0.11617371f, 0.14316775f, 0.00663379f, 0.02690023f, 0.05215462f, 
    -0.08005934f, -0.09002714f, 0.05196264f, -0.05411800f, -0.21678174f, -0.04159619f, -0.36756870f, -0.22823638f, 
    0.04383294f, 0.09784371f, -0.05147227f, -0.03721782f, -0.02244747f, -0.05668722f, -0.01857986f, 0.18525206f, 
    0.00549567f, -0.02877083f, -0.13805629f, 0.01075355f, 0.05514679f, -0.09151543f, 0.02222978f, -0.01547327f, 
    -0.02457335f, 0.12341071f, -0.09344932f, -0.02291147f, -0.13914208f, 0.05467874f, -0.06928953f, 0.03051472f, 
    -0.09755419f, -0.11518106f, -0.03582861f, 0.04980345f, 0.10081654f, 0.08398321f, 0.13513127f, 0.21753892f, 
    -0.32858810f, -0.02127339f, 0.01643709f, -0.27949002f, 0.00178974f, 0.03290582f, 0.21216750f, -0.10478977f, 
    -0.08979878f, 0.04274755f, 0.08938321f, 0.00860612f, 0.24736226f, 0.11008207f, 0.19912031f, 0.15166295f, 
    -0.02429818f, 0.01538166f, -0.09300242f, -0.06110890f, 0.22046816f, 0.21170999f, 0.04851326f, 0.25979850f, 
    -0.19094412f, -0.57193792f, -0.54783177f, -0.10974490f, 0.05104432f, -0.03659667f, -0.20462306f, -0.11326756f, 
    0.10738607f, -0.00832332f, -0.01920018f, -0.09530944f, 0.13179697f, 0.17720136f, 0.10968941f, 0.15565997f, 
    -0.03200321f, 0.05556536f, -0.02676108f, -0.00800917f, -0.08767400f, -0.07061321f, -0.02320479f, 0.02921275f, 
    0.00409227f, 0.12435148f, 0.11339758f, 0.05544211f, 0.06888568f, -0.05653144f, -0.03425242f, 0.00729481f, 
    0.00416462f, -0.08358814f, 0.01974633f, 0.00298557f, 0.05881996f, -0.01315147f, 0.05577660f, 0.00881559f, 
    -0.06837605f, 0.09156647f, -0.00086721f, -0.01205237f, -0.08148278f, -0.01956569f, -0.09875821f, 0.01718681f, 
    0.11534711f, -0.07423067f, 0.11916380f, 0.01611180f, 0.02979828f, 0.00791138f, 0.02981392f, 0.15833832f, 
    0.09011927f, 0.16651422f, 0.12415911f, 0.18516314f, -0.20653442f, -0.63599557f, -0.60671622f, 0.20471118f, 
    -0.06579695f, 0.02511705f, 0.12377828f, 0.07126255f, 0.17740151f, 0.04268252f, 0.11378630f, 0.02706083f, 
    -0.13694535f, 0.00655877f, -0.13847068f, 0.22692999f, 0.01065646f, -0.14429928f, 0.07711514f, -0.08358320f, 
    -0.00491940f, 0.09235308f, 0.10809110f, 0.09847791f, 0.27666152f, -0.07370278f, 0.27017766f, -0.06337784f, 
    0.00122723f, 0.12425309f, 0.12446486f, 0.02330318f, 0.14761600f, -0.10394197f, -0.01348936f, -0.20358330f, 
    0.09968182f, 0.13765703f, 0.21925399f, 0.08257806f, 0.07890215f, -0.02594494f, -0.08614046f, 0.22252530f, 
    -0.02056137f, -0.04045346f, 0.05603715f, -0.09166963f, -0.36138782f, -0.45780218f, 0.11764117f, 0.13849856f, 
    0.05263525f, 0.04889917f, -0.03770758f, 0.12166534f, -0.20468509f, -0.05270084f, 0.05630646f, 0.11139580f, 
    -0.03504882f, 0.46125239f, 0.18468797f, 0.23489760f, -0.08538697f, 0.05227817f, -0.10043889f, 0.09816230f, 
    0.06574674f, 0.06675496f, 0.06324133f, -0.07828084f, -0.28449705f, -0.17239991f, -0.47050166f, -0.28770155f, 
    0.10571498f, 0.15127239f, 0.06393246f, -0.06967685f, 0.01023049f, -0.01850075f, 0.08943915f, 0.07651901f, 
    -0.04359146f, 0.04419380f, -0.34977916f, -0.04924977f, -0.09475318f, 0.06651614f, 0.09621852f, -0.07190496f, 
    0.17828837f, -0.10785551f, -0.19482806f, -0.17127006f, 0.19766434f, 0.05462226f, 0.07922472f, -0.03237070f, 
    0.12955086f, -0.08424300f, -0.10410977f, -0.01074633f, 0.10087240f, 0.02751885f, 0.00179480f, 0.10222653f, 
    0.17723526f, -0.23197870f, 0.37479153f, 0.28400263f, 0.13105762f, 0.03605735f, 0.09671323f, -0.02160973f, 
    0.01998856f, 0.06991225f, 0.08825864f, -0.01907685f, -0.04716025f, 0.05757980f, -0.16716346f, 0.12540771f, 
    -0.02773947f, 0.06535871f, 0.05678254f, -0.07907329f, 0.08375893f, 0.13725372f, 0.01978227f, 0.06129894f, 
    0.18552272f, -0.41589445f, 0.23904495f, -0.07691111f, -0.01367089f, -0.03173381f, 0.12972857f, -0.12309486f, 
    -0.01982659f, 0.01943118f, -0.03676055f, 0.08040170f, -0.01228642f, 0.02660787f, -0.04926592f, -0.01879929f, 
    0.05107359f, 0.05763483f, -0.12305494f, -0.01296997f, -0.09548762f, 0.04371591f, -0.12146074f, -0.11391065f, 
    0.03432407f, 0.01665922f, -0.01656269f, -0.03209823f, 0.13044100f, 0.04511657f, 0.08738199f, -0.00439676f, 
    0.02246819f, -0.00372762f, 0.03944923f, 0.12425806f, -0.03691939f, 0.01565238f, 0.22278330f, -0.12130852f, 
    -0.02721194f, -0.01836425f, -0.18131840f, -0.00318032f, -0.02065273f, 0.03113342f, -0.05528754f, 0.04671286f, 
    0.06010734f, -0.17331570f, 0.21686281f, -0.18750231f, -0.08059718f, -0.09620201f, -0.04632017f, -0.12780209f, 
    0.06199751f, 0.04241524f, 0.05837892f, -0.01812761f, 0.10505638f, -0.20443153f, -0.02648096f, 0.28533155f, 
    0.08863202f, 0.07191566f, -0.01454237f, 0.04766350f, 0.04825329f, -0.02996912f, 0.03299726f, 0.09017336f, 
    -0.09874704f, 0.23279145f, 0.06473624f, 0.04351836f, 0.03874096f, 0.15908515f, 0.09060828f, -0.11693973f, 
    0.02263017f, 0.09499907f, 0.02182971f, -0.01387649f, -0.25802833f, 0.08240441f, 0.11566764f, 0.17642996f, 
    -0.00518347f, -0.14339818f, 0.11746748f, -0.10267805f, 0.07780738f, 0.08548107f, 0.05016111f, 0.02640861f, 
    0.24480551f, 0.02504944f, -0.28697643f, -0.14090948f, 0.09446242f, 0.01452883f, 0.04244380f, 0.03347392f, 
    -0.00212921f, 0.05573696f, 0.01934331f, 0.04627172f, 0.10390542f, -0.16692355f, -0.10425311f, -0.07488945f, 
    -0.07899850f, -0.07172792f, 0.02002944f, -0.02175137f, -0.03304520f, 0.13989300f, -0.04977811f, 0.00624958f, 
    0.12533981f, 0.25095537f, -0.39702779f, -0.00796821f, 0.04158182f, 0.26422197f, 0.14288986f, -0.07565507f, 
    -0.07307380f, -0.02960421f, 0.07433336f, -0.07719583f, -0.42699441f, 0.01176080f, -0.04240242f, -0.14062409f, 
    -0.09006739f, -0.01997918f, -0.11734878f, -0.05172193f, 0.06468847f, -0.12519325f, 0.00625402f, 0.08086594f, 
    0.01034456f, 0.06072871f, 0.09708159f, -0.22170056f, -0.08925606f, 0.10474976f, 0.00401955f, -0.13042004f, 
    0.07052976f, -0.09021064f, 0.02737471f, -0.13566247f, 0.06548890f, -0.01957899f, 0.10208052f, -0.10360492f, 
    0.02743114f, -0.04236648f, 0.06119961f, 0.13886410f, 0.10440474f, 0.02834067f, 0.03738910f, -0.05397118f, 
    0.06192665f, -0.19600597f, 0.00109374f, 0.36625627f, 0.14014128f, 0.08977898f, 0.05359504f, 0.11280958f, 
    0.09462743f, 0.08139846f, 0.08360279f, 0.09201264f, 0.23822685f, -0.10136323f, 0.19777372f, 0.07193398f, 
    0.03348146f, -0.03234142f, 0.02070880f, -0.10633814f, 0.10273728f, -0.04318047f, 0.07298830f, -0.14579143f, 
    -0.03760754f, -0.24515295f, 0.20597798f, -0.20974547f, -0.12054094f, -0.08686478f, 0.00949498f, 0.11405551f, 
    0.11354512f, -0.01709441f, -0.03737969f, -0.00702680f, 0.01674861f, 0.15276602f, 0.12177009f, 0.15554985f, 
    0.06580017f, -0.05899301f, -0.13793170f, -0.04093912f, -0.05234368f, -0.09224671f, -0.02824079f, 0.10958789f, 
    -0.15854815f, -0.20774439f, 0.01737747f, 0.09669567f, -0.06408145f, -0.04670969f, 0.01455740f, -0.01600940f, 
    0.07802898f, -0.04947262f, -0.00977397f, 0.16602056f, 0.00578360f, 0.14059781f, -0.05165673f, -0.09839930f, 
    0.16789986f, -0.04109756f, 0.05407973f, -0.05792377f, -0.03308663f, 0.02426002f, -0.03583528f, 0.09216957f, 
    -0.07307963f, 0.09536747f, 0.21109313f, -0.04104845f, 0.05803977f, -0.00971574f, 0.06430838f, 0.01649848f, 
    0.09140145f, 0.01711125f, 0.01190904f, -0.04891612f, 0.06082775f, 0.04066665f, -0.03224725f, -0.01716232f, 
    -0.00240082f, -0.07336944f, -0.09722996f, -0.05396223f, 0.05013154f, 0.13496339f, -0.01170411f, -0.06890366f, 
    -0.03634081f, -0.06366650f, 0.06079734f, -0.05859658f, -0.00223357f, -0.05651972f, -0.07808058f, -0.00816922f, 
    0.01803384f, -0.03018340f, -0.04834870f, 0.03915898f, 0.03657699f, -0.03837023f, 0.04701108f, 0.03112207f, 
    0.01742822f, 0.04668629f, -0.07359316f, -0.05994850f, 0.05988295f, -0.06133649f, 0.03371602f, -0.02324785f, 
    -0.02800480f, -0.07115375f, -0.02324362f, 0.04987907f, -0.05659581f, 0.06299803f, -0.00362242f, -0.00109537f, 
    -0.02516888f, -0.04315696f, -0.07768297f, -0.04703474f, 0.05531667f, -0.03711687f, -0.00119391f, -0.00772061f, 
    0.06180330f, -0.01141793f, -0.03686461f, 0.01371115f, 0.02007441f, 0.01935445f, -0.07450688f, 0.00531224f, 
    -0.01678509f, 0.03680425f, -0.07841109f, 0.03365643f, -0.07746317f, 0.02922089f, 0.04825279f, -0.03458598f, 
    0.02465418f, -0.06315716f, 0.02054795f, -0.06700992f, 0.02535084f, 0.05380305f, -0.04846182f, -0.00729301f, 
    0.04115881f, 0.01797095f, -0.03356462f, 0.00736696f, 0.01071248f, -0.03622111f, 0.06102597f, 0.00667140f, 
    -0.06881551f, -0.04516538f, 0.01430385f, 0.01058946f, -0.07071319f, 0.01841572f, 0.04652583f, 0.01828199f, 
    -0.01200775f, -0.04307943f, -0.06743489f, 0.01784853f, 0.00776631f, -0.01604642f, 0.06332559f, 0.04063294f, 
    -0.02406989f, -0.02112871f, -0.06525335f, -0.06852688f, -0.01589987f, -0.01916294f, -0.02831133f, -0.02613731f, 
    -0.02316004f, 0.05721921f, 0.03503513f, -0.06078096f, 0.00568262f, 0.06283806f, -0.05319677f, -0.00978907f, 
    0.02300750f, -0.02745963f, -0.05544820f, 0.04339970f, -0.04003251f, -0.05233857f, 0.00269825f, 0.02930635f, 
    -0.03635220f, 0.01564834f, -0.06873063f, -0.04560167f, 0.01267930f, -0.06385621f, 0.05307661f, -0.07954688f, 
    -0.05605360f, -0.00851398f, -0.01401974f, 0.02194981f, -0.04324877f, -0.04801328f, -0.06697153f, -0.06930348f, 
    -0.04754199f, -0.00437160f, 0.06305190f, -0.07087669f, 0.02543075f, 0.04693478f, 0.02203082f, -0.05499920f, 
    -0.06099194f, -0.02753288f, 0.03941230f, 0.02065426f, 0.06235852f, 0.04766525f, -0.00277254f, 0.01549447f, 
    0.03636036f, 0.01149083f, -0.00131636f, -0.02069160f, 0.02101290f, -0.00818689f, -0.02495586f, -0.03339061f, 
    -0.02744126f, -0.03592570f, 0.02561225f, 0.00478546f, -0.06139033f, 0.01619553f, -0.00060442f, -0.05235050f, 
    0.03060215f, -0.02746169f, -0.03063627f, -0.06560645f, 0.04632410f, 0.05194122f, -0.00085407f, -0.04693164f, 
    -0.00400610f, -0.04037900f, 0.00884171f, 0.04883393f, 0.01421374f, 0.00494892f, 0.04918922f, 0.04791389f, 
    0.00434843f, -0.05196038f, 0.04100343f, -0.04140151f, -0.02523469f, -0.05361812f, -0.00784562f, 0.01164669f, 
    -0.07297955f, 0.01664530f, -0.06332561f, 0.02981123f, 0.00720676f, -0.04988860f, 0.00555103f, -0.01648249f, 
    0.04627989f, 0.00168753f, -0.02706366f, -0.04615116f, -0.05485045f, 0.00671037f, -0.01854245f, -0.00963470f, 
    0.02845915f, -0.05031554f, -0.04669991f, 0.00406665f, -0.01058262f, 0.02597008f, -0.02651621f, 0.05437322f, 
    -0.06009023f, -0.01870936f, 0.00191578f, 0.00262996f, -0.01243537f, -0.04878391f, -0.03027803f, 0.00736765f, 
    -0.04534663f, 0.03567937f, -0.03296516f, -0.01812522f, -0.00032201f, -0.05793618f, -0.06643324f, -0.04064614f, 
    -0.00786482f, 0.00236125f, -0.06398214f, -0.00313168f, -0.05546452f, -0.05578502f, -0.05416669f, -0.01425060f, 
    -0.04101391f, 0.03004544f, -0.02719757f, -0.06588940f, -0.07302836f, -0.02393276f, -0.00925590f, -0.01507353f, 
    -0.01528911f, -0.04611283f, -0.01026054f, -0.06682761f, -0.01914671f, 0.00346206f, 0.00671609f, 0.01709857f, 
    0.05574030f, 0.04449427f, -0.02385437f, 0.04831408f, 0.06289703f, 0.06785730f, -0.07160930f, -0.01485774f, 
    -0.04266612f, 0.01572051f, 0.04372034f, 0.01934826f, -0.00150664f, 0.01193338f, -0.04027489f, 0.00075944f, 
    -0.06128625f, 0.05205147f, 0.02528330f, 0.05144855f, 0.02432239f, -0.00644360f, 0.02305771f, -0.03137615f, 
    -0.05428028f, 0.03983200f, -0.07463957f, -0.06254349f, 0.01228878f, -0.00642038f, -0.04363529f, 0.04166584f, 
    0.00735412f, -0.06836998f, 0.01773079f, -0.04150273f, 0.00477477f, 0.04237726f, 0.04090606f, 0.00748584f, 
    -0.01989789f, 0.00953124f, -0.03751258f, 0.02335751f, -0.06690792f, -0.00342227f, -0.04884581f, 0.04052984f, 
    0.06530958f, -0.01570443f, -0.06017456f, -0.03385778f, 0.01292063f, 0.01058546f, -0.02425617f, -0.06558318f, 
    -0.05351843f, -0.01697063f, -0.01340325f, 0.04372040f, -0.04529966f, -0.01533483f, 0.02901246f, -0.03818445f, 
    -0.06659391f, -0.07649637f, -0.00589677f, -0.04561501f, -0.04500102f, 0.01061303f, 0.06540051f, -0.01661516f, 
    0.03008139f, -0.07038484f, -0.02583229f, 0.06545730f, 0.02055906f, 0.05503999f, -0.05049448f, -0.02353490f, 
    -0.02090290f, -0.00461140f, -0.02110106f, -0.05878722f, 0.05260459f, 0.00361877f, 0.01038235f, -0.02158815f, 
    0.05452225f, -0.03202681f, 0.00175750f, 0.00015472f, 0.03503183f, -0.00646941f, 0.03240801f, -0.06767353f, 
    0.02509996f, -0.05835630f, -0.02038064f, 0.04436048f, -0.01695345f, 0.04244813f, -0.03068832f, -0.04824158f, 
    -0.05434329f, -0.03098213f, -0.01732906f, 0.03473099f, -0.00734661f, -0.02433696f, 0.03166620f, 0.05933877f, 
    0.01274874f, -0.01423779f, 0.03565583f, -0.05614758f, -0.05618104f, 0.06072685f, 0.01186227f, -0.01082323f, 
    0.04941360f, 0.02179084f, 0.01994595f, -0.03753025f, 0.04037092f, 0.00501519f, 0.01483481f, -0.05276020f, 
    0.00946485f, -0.06236339f, -0.06641246f, 0.02895351f, -0.01468425f, -0.07057509f, -0.05314430f, -0.02328824f, 
    0.29190335f, -0.15225078f, 0.12290335f, -0.18539055f, -0.14028916f, -0.08362675f, 0.11009095f, -0.03832857f, 
    0.05493953f, 0.12552868f, 0.10313506f, 0.22972161f, -0.11494964f, -0.12612592f, -0.01553697f, 0.00195276f, 
    0.07961021f, -0.09055481f, -0.01767976f, 0.16768904f, -0.10072847f, -0.02536276f, -0.01276709f, 0.00843499f, 
    0.21390292f, 0.22248083f, 0.19235635f, -0.13959235f, -0.12851952f, -0.04943734f, -0.06425387f, -0.06696398f, 
    -0.12042084f, -0.04658694f, 0.09499034f, 0.00230050f, 0.34781107f, 0.16987370f, 0.04779375f, -0.00888770f, 
    -0.08470003f, 0.13446692f, -0.09112713f, -0.01088072f, -0.03107798f, 0.02485415f, 0.05225101f, -0.07528418f, 
    0.21819863f, -0.05549318f, 0.18356621f, -0.20568272f, -0.12769553f, -0.27566677f, -0.01499066f, -0.02376101f, 
    -0.11154173f, 0.06798380f, 0.01362143f, 0.06068397f, -0.07944658f, 0.03317170f, -0.12255364f, 0.00433975f, 
    -0.04099587f, 0.06667320f, 0.11085606f, -0.03524720f, -0.11864546f, -0.08106574f, -0.01956008f, 0.04921395f, 
    0.07444914f, 0.11227871f, -0.10148888f, 0.14500588f, 0.12034253f, -0.01091090f, 0.10515630f, 0.07018284f, 
    -0.13585410f, 0.21926697f, -0.14553033f, 0.06031012f, -0.06581854f, 0.01474290f, -0.01311641f, 0.05459075f, 
    -0.12145368f, 0.08131552f, 0.02596961f, 0.06655727f, 0.06278581f, -0.00928348f, -0.05809291f, -0.08940254f, 
    -0.19753869f, -0.01068536f, -0.37798363f, -0.28388149f, -0.05008324f, -0.04838650f, 0.10918800f, 0.09783805f, 
    -0.03020903f, 0.05019191f, -0.00454782f, -0.01048117f, -0.06802680f, 0.17867172f, 0.01897043f, 0.04455413f, 
    0.00881086f, -0.08336425f, -0.10239677f, -0.05465211f, 0.11238074f, 0.12370496f, 0.08833966f, 0.07621408f, 
    -0.07724676f, 0.28634149f, 0.04444897f, 0.07287279f, -0.02328972f, 0.07058381f, -0.04667165f, 0.03742613f, 
    0.00670751f, -0.01336461f, 0.06804596f, -0.19553724f, 0.00503952f, -0.01321663f, 0.06273130f, 0.03463725f, 
    -0.04700689f, 0.04860288f, 0.04987162f, 0.03921971f, 0.08108279f, 0.13165842f, 0.03782290f, 0.11504968f, 
    -0.11463931f, 0.09050826f, 0.15432255f, 0.14406611f, -0.03518900f, -0.05010073f, 0.02799905f, 0.06217562f, 
    0.08558366f, 0.07655556f, 0.12660539f, 0.02420524f, 0.14811136f, -0.04315571f, 0.05729793f, 0.01519709f, 
    -0.01387500f, -0.03006060f, -0.00765524f, -0.00748996f, 0.01026068f, 0.06256729f, 0.18726528f, 0.07487161f, 
    -0.00475986f, -0.08995206f, -0.12892498f, 0.17623980f, 0.11220786f, 0.08361873f, -0.09846268f, 0.00223792f, 
    -0.06979917f, 0.09515145f, 0.13776286f, 0.00453290f, -0.26174861f, 0.11301687f, 0.23710875f, -0.00930261f, 
    -0.00168846f, 0.06767844f, 0.26137778f, 0.15359405f, 0.04221425f, 0.04795111f, 0.12063850f, -0.14743692f, 
    -0.05823130f, 0.01984153f, 0.24101815f, 0.04149606f, 0.00891018f, 0.10388515f, 0.06741814f, -0.10012975f, 
    0.02693824f, 0.04283045f, -0.13748679f, 0.01272483f, 0.09918829f, 0.14342254f, 0.07750469f, -0.02888420f, 
    -0.09504411f, 0.18274555f, -0.02168894f, -0.19667666f, -0.00278830f, -0.09750113f, -0.12225492f, -0.20072652f, 
    -0.03194198f, -0.07311056f, 0.02647755f, 0.14322397f, 0.13907722f, 0.02457107f, -0.01467669f, -0.02845093f, 
    -0.12275444f, 0.06544448f, -0.09012971f, -0.05316593f, -0.13967641f, -0.26059568f, -0.11898223f, 0.02844293f, 
    0.05699102f, -0.30858612f, 0.00588701f, 0.01532309f, 0.01068208f, 0.07996040f, 0.03726356f, 0.15760589f, 
    0.25345767f, 0.12973864f, -0.12159959f, 0.14959374f, -0.01130306f, 0.31968674f, 0.17969020f, 0.07331286f, 
    -0.13624851f, -0.07564745f, 0.07453132f, -0.18834415f, 0.37472436f, -0.04833151f, 0.06896473f, -0.05497462f, 
    0.03743211f, 0.19550712f, -0.06310139f, 0.01438590f, 0.06597468f, -0.01494587f, 0.11672445f, -0.04450317f, 
    0.00050270f, 0.07008634f, 0.18610385f, -0.02990402f, -0.00108750f, 0.09349187f, 0.05051677f, -0.08245071f, 
    0.03266004f, -0.09006990f, -0.07763851f, -0.04614127f, 0.17567357f, 0.14125040f, 0.09162812f, 0.05614597f, 
    0.09846540f, -0.04298975f, -0.01601878f, 0.13290702f, 0.12115776f, 0.23348668f, 0.04563063f, 0.16048302f, 
    0.03821847f, 0.19141582f, 0.13961734f, 0.27285513f, 0.15162306f, -0.07259116f, -0.05531679f, -0.05582955f, 
    -0.17709209f, 0.04452021f, 0.10681867f, 0.10107604f, -0.03222619f, -0.08419716f, 0.10065059f, 0.17611733f, 
    -0.09946132f, -0.01311978f, 0.00589787f, 0.01651799f, 0.02749866f, 0.13383774f, 0.05912619f, 0.15258178f, 
    0.36273146f, -0.07203864f, -0.03351670f, -0.10841774f, -0.11316537f, 0.00138106f, 0.08773909f, 0.03867751f, 
    -0.02601789f, -0.07620329f, -0.15376174f, 0.09844390f, -0.03112867f, 0.14247632f, -0.04732357f, 0.02279484f, 
    0.01029998f, 0.02219870f, -0.12529634f, -0.23182875f, -0.17053460f, -0.17074195f, -0.01572945f, -0.07495828f, 
    0.08092505f, -0.09907145f, -0.23498455f, -0.08953468f, -0.03443203f, 0.06689727f, 0.01985607f, 0.00192052f, 
    0.04380073f, -0.02154067f, 0.10532745f, 0.10284097f, -0.15209702f, 0.01162723f, -0.25162864f, -0.26436499f, 
    0.03407385f, 0.02935271f, -0.09743527f, -0.26808834f, -0.03156008f, -0.26244536f, -0.29863384f, -0.23629946f, 
    -0.00676113f, 0.16806677f, 0.08486927f, -0.14269277f, 0.06585431f, 0.00603748f, 0.25029352f, -0.01655222f, 
    0.01895943f, -0.03443204f, -0.06942500f, -0.07060338f, 0.30172083f, -0.15329236f, -0.19771084f, 0.33991408f, 
    -0.07993218f, 0.01429425f, -0.13536468f, 0.10569099f, 0.05182125f, 0.09715415f, -0.01360253f, 0.07446303f, 
    -0.01450424f, 0.28528130f, 0.17319900f, 0.11813889f, -0.10758286f, 0.15217617f, -0.15556861f, 0.12609193f, 
    0.02647689f, 0.06833102f, 0.22892436f, 0.04641087f, 0.27764452f, -0.12473164f, -0.03737260f, -0.04827870f, 
    0.10067864f, 0.00551085f, -0.00133062f, 0.00219990f, 0.03893356f, 0.06728496f, -0.05732757f, 0.15014391f, 
    -0.02465976f, -0.10956009f, 0.23605259f, 0.09182388f, -0.02767520f, 0.05954195f, -0.01174088f, 0.00288678f, 
    -0.00494126f, -0.01192539f, -0.05375955f, -0.05600975f, -0.45929360f, 0.04009653f, 0.06515380f, 0.10366058f, 
    0.05928978f, 0.00574826f, 0.07779305f, 0.05512816f, -0.01102906f, 0.01094452f, 0.10277876f, -0.03237446f, 
    -0.11029739f, -0.19635779f, 0.20388891f, 0.04055417f, -0.09890373f, 0.11781403f, -0.16564856f, -0.02994392f, 
    0.01023272f, -0.01390781f, -0.03891585f, 0.03658127f, 0.20316720f, 0.10018421f, -0.10942407f, -0.16485488f, 
    0.19550551f, -0.00367309f, 0.13858736f, -0.06144818f, 0.04693268f, -0.01498882f, 0.12242021f, 0.10214080f, 
    -0.16209289f, -0.09133935f, -0.19673969f, 0.16958620f, 0.02016008f, 0.13029477f, 0.01549194f, -0.02130891f, 
    -0.01649578f, 0.04924673f, 0.15599473f, 0.06986222f, -0.03299670f, -0.20164789f, -0.05478384f, 0.12613159f, 
    0.09070814f, 0.04093185f, -0.05535185f, 0.01447254f, -0.09936250f, 0.03013218f, -0.04230534f, 0.02487963f, 
    0.24137999f, 0.06075408f, 0.00979437f, -0.04520326f, 0.08245924f, -0.06455293f, 0.02941558f, 0.00000245f, 
    0.03184692f, 0.06849761f, 0.14270152f, 0.03297715f, -0.09069540f, 0.13417415f, -0.17526154f, -0.10981798f, 
    -0.00266030f, 0.00602971f, 0.06599773f, -0.04146449f, -0.00062327f, 0.17677875f, 0.03910663f, 0.00058620f, 
    0.03476910f, -0.21150786f, -0.03170128f, 0.05260576f, 0.09275241f, -0.02556947f, 0.02800261f, -0.07208163f, 
    -0.06535308f, 0.02757223f, -0.01244178f, 0.08228988f, -0.12744634f, 0.04147464f, -0.01807674f, -0.21885125f, 
    0.04486722f, 0.03372378f, -0.03692424f, -0.04888390f, -0.05849365f, -0.01969311f, -0.03358103f, 0.16807710f, 
    -0.07825981f, 0.13996679f, 0.02166305f, 0.06199883f, -0.02666511f, -0.02444402f, 0.01007258f, -0.04757723f, 
    0.05927052f, 0.06704811f, 0.11488926f, -0.03980606f, -0.11199100f, 0.02965055f, 0.05831839f, -0.04140543f, 
    -0.00074901f, -0.01911215f, 0.06718703f, 0.00365610f, 0.04876797f, 0.01214498f, 0.15686662f, -0.02204807f, 
    -0.11167728f, -0.13800214f, 0.11376483f, -0.09394188f, 0.04959241f, -0.09246747f, 0.07019656f, 0.01932636f, 
    -0.03281884f, -0.01258849f, -0.03510420f, -0.07014295f, -0.12679549f, -0.22236946f, -0.10536738f, 0.10823216f, 
    0.13788289f, 0.08369702f, -0.06803218f, -0.09612995f, -0.07570038f, 0.03143221f, -0.00671332f, 0.01157437f, 
    -0.01027700f, 0.10410737f, 0.09073476f, -0.07035933f, 0.02815386f, 0.00018080f, -0.00091750f, -0.11165035f, 
    0.10539205f, -0.14377122f, 0.16546482f, 0.07658900f, 0.20696430f, 0.01089263f, -0.03600279f, 0.13241895f, 
    -0.03044794f, -0.12743399f, -0.01454087f, -0.06026644f, 0.00678875f, -0.13830090f, -0.09654813f, -0.12189344f, 
    0.19859737f, -0.14350933f, -0.05921564f, -0.00194021f, -0.00515650f, -0.00571093f, 0.15863566f, 0.05455936f, 
    -0.01229435f, -0.02115675f, -0.00295224f, -0.19030003f, -0.19323270f, 0.42370245f, 0.04583512f, -0.05129513f, 
    0.01266606f, -0.04534735f, 0.07828444f, 0.06879421f, -0.04581854f, 0.02321113f, 0.10373859f, 0.00729523f, 
    0.16741198f, -0.32333359f, -0.05931241f, -0.07591309f, 0.01538717f, 0.12645802f, 0.10239547f, -0.02346383f, 
    0.02674532f, -0.21330673f, -0.02092994f, -0.04633569f, -0.04735519f, 0.10932257f, 0.42949677f, 0.16178042f, 
    0.19198230f, 0.05265427f, 0.05523931f, -0.03106752f, -0.06432515f, -0.12546490f, 0.08176214f, 0.01253829f, 
    0.14684205f, 0.18233454f, -0.17568314f, -0.21831758f, 0.12093608f, 0.06134968f, -0.18653493f, -0.08311242f, 
    0.22178747f, 0.02636490f, 0.17595418f, 0.01935639f, -0.03587838f, -0.12448127f, 0.11399613f, 0.23108642f, 
    -0.10280588f, 0.07134970f, -0.02901084f, -0.03531917f, 0.06074320f, 0.09011007f, 0.11633767f, 0.11956848f, 
    -0.10453341f, -0.24331231f, -0.19873592f, 0.37384671f, -0.00872315f, 0.00414689f, -0.00013263f, -0.01388078f, 
    0.00502634f, 0.00547644f, 0.03057893f, 0.01024791f, 0.09791789f, -0.21722178f, -0.07523151f, -0.01457914f, 
    -0.09092808f, 0.04535971f, 0.10205862f, 0.06094771f, 0.07113919f, 0.23223339f, 0.18900344f, 0.09802282f, 
    -0.19543347f, -0.01622328f, 0.33632627f, 0.10413996f, -0.04331269f, -0.06968142f, 0.01479108f, -0.01870631f, 
    -0.01669638f, -0.04550676f, 0.01580636f, 0.04547637f, -0.03620866f, 0.06448104f, 0.01290401f, 0.08079000f, 
    0.09155712f, -0.03149281f, -0.09584115f, 0.02551176f, -0.00305015f, -0.05428099f, 0.12830062f, 0.00828905f, 
    -0.19239551f, 0.09300229f, 0.09098414f, 0.27679864f, -0.13434464f, 0.00532755f, 0.06580546f, -0.04760096f, 
    -0.02316533f, 0.10442074f, 0.16443104f, 0.17339849f, -0.03881685f, 0.08261803f, -0.25566468f, -0.09038202f, 
    0.09225484f, 0.10959605f, 0.10825233f, 0.04273827f, 0.18496646f, 0.03642807f, 0.01803661f, -0.10891847f, 
    -0.12360807f, -0.03749057f, 0.11499284f, -0.15278742f, 0.11301839f, -0.02801996f, 0.21732989f, 0.03649820f, 
    0.16484500f, 0.07532720f, -0.03261446f, 0.12112851f, -0.26074317f, 0.00997472f, 0.17035288f, 0.05952414f, 
    0.05382698f, -0.07708974f, -0.00142586f, -0.03005642f, 0.09706545f, -0.04618943f, 0.13779554f, 0.04125231f, 
    -0.07462388f, 0.11562992f, 0.30191359f, 0.06941611f, -0.02525000f, -0.01529615f, -0.02791562f, -0.12098572f, 
    -0.02337683f, 0.04903739f, -0.00144800f, 0.15248540f, -0.09250829f, 0.17481919f, -0.12584282f, -0.12889118f, 
    0.09017095f, 0.02095960f, 0.05894190f, 0.01630756f, -0.02800050f, 0.07816436f, -0.02930497f, -0.04444753f, 
    0.30879465f, -0.09380244f, 0.06120378f, 0.22097224f, 0.04983711f, -0.03457726f, 0.03579465f, 0.08953857f, 
    -0.05842621f, -0.06336993f, -0.03170184f, -0.12918414f, 0.25241315f, -0.11081075f, 0.11751884f, -0.10316735f, 
    -0.05349180f, -0.08581243f, -0.15524012f, -0.06639849f, 0.04172051f, 0.08751248f, 0.02317811f, -0.00674466f, 
    0.17515482f, 0.10907619f, -0.16789399f, 0.11951283f, -0.08932799f, 0.17307952f, 0.18409719f, 0.08239612f, 
    -0.08315443f, 0.03088559f, 0.07907849f, -0.20329402f, -0.23243545f, -0.11391267f, -0.05446083f, -0.00476938f, 
    -0.11241680f, 0.10359270f, -0.26837084f, -0.24658799f, 0.10359621f, -0.00825314f, -0.04369251f, 0.03957594f, 
    0.10005105f, 0.08113212f, 0.10316619f, -0.36394140f, -0.09315648f, -0.00646823f, -0.13351856f, -0.03032886f, 
    0.04201777f, -0.01969667f, -0.00428903f, -0.11513810f, 0.12987669f, 0.00644391f, 0.16375013f, -0.08204962f, 
    0.15502693f, 0.04265820f, 0.05664087f, 0.11591586f, 0.10108169f, -0.02048494f, -0.06324810f, 0.05837386f, 
    -0.17703636f, 0.09574359f, -0.13220684f, 0.04004943f, 0.07891021f, -0.00094657f, 0.09755349f, -0.07459208f, 
    -0.08299407f, 0.13182084f, -0.03290304f, -0.15564886f, 0.09857657f, -0.00701904f, 0.23372704f, 0.06643975f, 
    -0.04534946f, 0.04742487f, 0.05293596f, -0.06758104f, 0.19127984f, -0.06592980f, -0.06868711f, 0.03648559f, 
    0.14726762f, -0.35167721f, 0.04508182f, -0.22965352f, 0.01938370f, 0.02378890f, -0.04283791f, -0.01875990f, 
    0.08094794f, 0.02497719f, 0.05866100f, -0.03635055f, -0.03326653f, 0.11257809f, 0.21521714f, 0.18766853f, 
    -0.08642610f, 0.05604591f, -0.11446562f, -0.21967104f, 0.00033888f, -0.00558079f, -0.07451867f, 0.00978544f, 
    -0.00354196f, -0.03375886f, 0.01904878f, 0.00361844f, 0.00677897f, 0.01988717f, -0.05391221f, -0.04691194f, 
    0.04454587f, -0.04365111f, -0.00684338f, 0.04915901f, 0.04858449f, 0.13574821f, -0.10799287f, -0.10970218f, 
    0.11922685f, -0.14970721f, 0.03926526f, -0.04997626f, 0.05277568f, 0.06378102f, -0.16414465f, -0.04103729f, 
    0.00127246f, 0.02805614f, 0.13887152f, 0.02355274f, 0.11783112f, 0.01099654f, 0.05393922f, 0.10915513f, 
    -0.06806067f, 0.12195238f, 0.03588030f, 0.00695995f, 0.12220301f, -0.24380845f, -0.18529734f, 0.00264677f, 
    -0.05338294f, 0.05783906f, -0.03252373f, 0.13172634f, 0.09340749f, 0.04710985f, 0.03783756f, 0.00343881f, 
    -0.08779012f, 0.10328687f, -0.06101444f, 0.02145944f, -0.09846818f, 0.14192809f, -0.12873513f, 0.15389673f, 
    0.15090628f, -0.05060530f, 0.06403740f, 0.17821209f, -0.07618567f, -0.00567679f, -0.02603416f, -0.09452241f, 
    0.03618370f, -0.00805183f, -0.09495065f, -0.02722684f, 0.04634329f, 0.04155209f, 0.06250068f, 0.06951582f, 
    -0.23243614f, -0.10445843f, 0.07067907f, 0.16581018f, -0.00873833f, 0.05953558f, 0.10266960f, -0.04310437f, 
    -0.06033719f, 0.01491188f, -0.00951047f, 0.07876278f, 0.04136711f, -0.00548783f, -0.11688180f, -0.00660286f, 
    0.04551459f, -0.01900266f, 0.10706566f, -0.04460898f, 0.19392541f, 0.02980893f, 0.11083760f, 0.05168126f, 
    -0.13334565f, -0.32984933f, 0.01375961f, -0.07155609f, 0.18503176f, 0.10739631f, -0.00854889f, -0.00593650f, 
    -0.02507617f, -0.00755245f, -0.06189756f, -0.05111371f, -0.07749613f, 0.27262497f, 0.04778210f, -0.10236999f, 
    0.10520408f, 0.06899924f, 0.04854747f, 0.02804743f, 0.09153169f, 0.04394330f, 0.06011068f, 0.03910052f, 
    -0.17415847f, -0.23225367f, 0.12725072f, -0.11338985f, 0.09111407f, 0.05654698f, -0.15995260f, -0.08069379f, 
    0.01486947f, 0.13294122f, 0.18457152f, -0.01691446f, -0.02632843f, 0.03235468f, 0.06276456f, -0.02030095f, 
    0.04194251f, 0.04043581f, 0.03985981f, 0.01187643f, -0.11738569f, -0.14550988f, 0.05690386f, -0.03659058f, 
    0.24620588f, -0.01683560f, 0.22454353f, -0.11935364f, -0.01337954f, 0.00659425f, -0.12689139f, 0.11673521f, 
    0.04269251f, 0.08257791f, -0.06120284f, 0.02423679f, -0.01403876f, -0.15897800f, 0.11955736f, -0.08189330f, 
    0.01071434f, 0.04083210f, 0.10844012f, -0.00233131f, -0.03139388f, 0.08002394f, 0.08440714f, -0.03117419f, 
    0.03693403f, -0.10158837f, -0.06564335f, -0.17962673f, 0.14648113f, 0.15123053f, 0.00055414f, -0.03998753f, 
    -0.00434207f, -0.03493655f, -0.03773195f, 0.03793417f, -0.08020581f, 0.06470718f, 0.19050446f, 0.04123623f, 
    0.05533654f, -0.00374460f, -0.04498307f, -0.08383195f, -0.05277827f, 0.04427343f, 0.14632390f, 0.06577653f, 
    -0.15918639f, 0.06332321f, -0.01105745f, 0.09725425f, -0.09678901f, -0.05908766f, 0.00219381f, 0.09768825f, 
    0.08866910f, 0.03082636f, 0.10962053f, -0.12773345f, -0.06862108f, 0.05233961f, -0.01535894f, 0.00259953f, 
    0.03317720f, -0.11645090f, -0.00568870f, -0.01166871f, -0.00149268f, -0.10773610f, 0.06187793f, -0.05014965f, 
    -0.04867267f, 0.10838647f, -0.03297582f, 0.05496941f, 0.02237439f, 0.19705452f, -0.04345357f, 0.06283981f, 
    -0.05732742f, -0.13130894f, 0.10021967f, 0.04873225f, 0.06764350f, -0.06703763f, -0.06360100f, -0.13566180f, 
    0.10563397f, 0.15021704f, -0.04536560f, -0.07948856f, 0.02988013f, -0.01751340f, 0.07925498f, -0.02299240f, 
    0.15396249f, -0.06044600f, 0.38401243f, -0.19246545f, 0.09502392f, 0.00370765f, 0.09743733f, -0.09016084f, 
    0.07633851f, -0.01634251f, -0.04462349f, 0.14708844f, -0.20679189f, 0.00444410f, -0.17056251f, 0.05229429f, 
    -0.03312604f, -0.09376212f, 0.09008470f, 0.04730605f, 0.00699009f, -0.15414414f, 0.03365530f, -0.02667286f, 
    0.18749632f, -0.13339019f, 0.04597824f, -0.27134049f, -0.05829491f, -0.06570106f, 0.12568958f, 0.05754253f, 
    0.01035964f, -0.00422013f, 0.04089784f, -0.02716710f, 0.27690935f, 0.12014204f, 0.07071342f, -0.10322236f, 
    -0.09320024f, -0.02340008f, -0.09274971f, 0.05538005f, -0.00394503f, 0.12702362f, 0.00640489f, 0.10459518f, 
    0.34047818f, 0.08333532f, -0.24923548f, -0.15858255f, -0.08735285f, -0.00101688f, 0.19252482f, 0.03765667f, 
    -0.07565028f, 0.02756333f, 0.00321503f, 0.08851921f, -0.22366062f, -0.15956606f, 0.30017436f, 0.13775980f, 
    0.02459475f, 0.04261656f, -0.07480223f, 0.05004147f, 0.00955403f, 0.02446116f, 0.08695053f, 0.04467374f, 
    0.07324199f, 0.29256073f, 0.15274440f, 0.10247523f, 0.10147889f, -0.04359521f, 0.14128731f, 0.16756047f, 
    -0.02652566f, 0.01254322f, -0.20689741f, 0.10912306f, -0.02047327f, 0.05841153f, -0.03553559f, -0.11425088f, 
    -0.04697609f, -0.05847826f, 0.05701086f, -0.05015615f, 0.07639923f, 0.18020982f, -0.02459116f, -0.02096970f, 
    -0.44391400f, -0.02122086f, -0.36304712f, 0.01872080f, -0.04791618f, -0.01760791f, 0.01674570f, 0.02776194f, 
    -0.09134537f, -0.07180405f, 0.02653171f, 0.07978301f, 0.02971386f, -0.03530085f, 0.10789391f, 0.04212371f, 
    -0.07803103f, 0.02438884f, -0.09467018f, -0.02927248f, 0.01877442f, 0.14585464f, 0.05293170f, 0.15116253f, 
    0.10532349f, 0.22260515f, 0.14387017f, 0.07907145f, -0.12814476f, -0.11029598f, -0.03825564f, 0.14928450f, 
    -0.00661323f, 0.05702088f, 0.14477324f, -0.10684253f, -0.16840185f, -0.03766116f, 0.11109555f, 0.22378004f, 
    -0.03999596f, -0.02373647f, -0.01224498f, -0.00817221f, 0.03304479f, 0.00346345f, -0.03390628f, -0.01738046f, 
    0.01800054f, -0.17775615f, -0.10873326f, -0.05142416f, 0.00492941f, 0.10952650f, 0.12525779f, -0.01283344f, 
    0.05988805f, 0.12634794f, 0.08331081f, 0.14660580f, 0.09083553f, -0.04097242f, 0.02148466f, 0.03386784f, 
    0.05460517f, 0.10036702f, 0.05083418f, 0.04870777f, -0.00643794f, -0.04559706f, -0.05652979f, -0.03677478f, 
    -0.04276807f, -0.01807356f, -0.08095320f, -0.01648856f, 0.04919868f, -0.13864784f, 0.05440248f, -0.05221360f, 
    -0.03464752f, 0.13630955f, -0.00452778f, 0.09923401f, -0.10135487f, 0.11926904f, 0.20503838f, -0.00160649f, 
    -0.11452630f, -0.11654862f, -0.05032481f, 0.12225600f, -0.07652026f, 0.04430044f, 0.08473948f, 0.01693791f, 
    0.10123063f, -0.11020844f, -0.00004739f, -0.12569411f, -0.06837024f, -0.04019618f, -0.12073343f, -0.10431920f, 
    0.00236330f, 0.00758577f, 0.14247786f, -0.10066363f, 0.13577034f, -0.21007660f, -0.06739782f, 0.11140100f, 
    0.07859662f, -0.03605300f, -0.04250432f, 0.02650680f, -0.05300584f, -0.11500194f, -0.10723940f, -0.01983079f, 
    0.18669558f, 0.24948786f, 0.31484658f, 0.04893542f, -0.14672272f, -0.08043054f, -0.14791191f, -0.01895299f, 
    -0.07019962f, -0.04815390f, 0.04068671f, -0.09556250f, 0.04238839f, 0.18631415f, 0.13270830f, -0.04125152f, 
    -0.06399655f, -0.01268191f, -0.04020880f, -0.05899390f, 0.02644738f, -0.03873919f, 0.00369663f, 0.00264429f, 
    0.08878815f, 0.15692452f, 0.35373738f, -0.03273591f, -0.12610129f, -0.10359617f, -0.05567515f, -0.06513774f, 
    -0.07568225f, 0.03462321f, -0.04188510f, 0.13115826f, -0.07092717f, -0.08474684f, -0.05004680f, 0.04083220f, 
    0.10837042f, -0.04037382f, 0.15902540f, 0.01886920f, 0.05423731f, 0.10845657f, -0.01603302f, -0.01135600f, 
    0.17018516f, 0.31402004f, -0.29568419f, 0.16031487f, 0.16736877f, 0.05475897f, -0.00085046f, -0.00163015f, 
    0.03175775f, -0.04118818f, -0.16495951f, 0.05941858f, -0.09988307f, -0.01417085f, -0.08611159f, 0.10233161f, 
    -0.04030226f, -0.09499663f, -0.02896557f, -0.01647820f, 0.09675358f, 0.09858911f, 0.06741717f, 0.06140247f, 
    -0.02135713f, -0.10243800f, -0.24608108f, -0.01378735f, -0.06567609f, -0.00509149f, -0.09866727f, 0.08754868f, 
    0.06988750f, -0.14354454f, 0.09876629f, 0.12714940f, -0.06697545f, 0.16385697f, -0.21271616f, -0.00567556f, 
    -0.05251789f, 0.00828303f, -0.02324249f, 0.06376243f, 0.00912598f, 0.20582266f, -0.08943917f, 0.14730169f, 
    -0.11518338f, 0.06393573f, 0.24699455f, 0.21055573f, -0.12270749f, 0.04240733f, 0.07446080f, 0.01908681f, 
    -0.09438833f, -0.09622134f, 0.04468067f, -0.05169382f, -0.02009388f, -0.00784134f, -0.03278443f, 0.05188169f, 
    -0.04968666f, 0.00749039f, 0.00878806f, 0.14490867f, -0.07070500f, -0.06173613f, 0.03152820f, -0.16537359f, 
    -0.09403877f, 0.08854362f, 0.10195645f, 0.07474383f, -0.03241730f, -0.07855697f, 0.00526072f, -0.11490186f, 
    -0.02127249f, 0.10062472f, 0.07087985f, 0.15307276f, 0.22284915f, 0.00310849f, 0.15911534f, 0.02987188f, 
    0.00718063f, 0.09961674f, 0.06904262f, 0.13090518f, 0.16779494f, 0.02213291f, 0.03440420f, -0.00110617f, 
    0.00236070f, -0.10282019f, -0.01735628f, 0.04105619f, 0.00418149f, -0.08633690f, 0.09579825f, -0.00574999f, 
    0.09279630f, 0.05184757f, 0.11804040f, -0.01128791f, -0.22929652f, 0.02703115f, 0.39451760f, 0.14639477f, 
    -0.09444725f, -0.03344710f, 0.19708829f, 0.07324967f, 0.05158388f, -0.01788799f, 0.08914522f, -0.10178288f, 
    0.00238222f, 0.21163933f, -0.03965453f, 0.02507178f, -0.09096565f, -0.00326703f, 0.09073288f, 0.09601620f, 
    0.03875507f, 0.21093671f, -0.03853073f, 0.12415548f, -0.21598682f, 0.16954544f, 0.12892398f, 0.04078392f, 
    -0.00202185f, 0.00651367f, 0.16852836f, 0.10614234f, 0.04449003f, 0.25449932f, 0.15697904f, 0.02893589f, 
    -0.02151594f, -0.24497321f, -0.28560409f, -0.12283158f, -0.03496029f, 0.05554997f, -0.07819556f, -0.07964253f, 
    0.01631402f, 0.07783001f, -0.09720399f, 0.12035497f, 0.34959033f, -0.34254131f, -0.29726759f, -0.24571183f, 
    -0.05404633f, -0.18351218f, -0.08493371f, 0.10597952f, -0.02656556f, -0.00196720f, 0.09321140f, -0.14160375f, 
    0.08818005f, -0.12178827f, -0.41188124f, -0.21780397f, -0.01900283f, -0.11727984f, 0.12083584f, 0.00825010f, 
    -0.13120307f, -0.01435190f, -0.03154134f, -0.10678384f, -0.38004878f, 0.29285976f, -0.08482525f, -0.10859333f, 
    -0.19484851f, 0.05269181f, -0.00804574f, 0.04834754f, 0.11929628f, -0.03819448f, -0.04409264f, 0.10302347f, 
    -0.10828397f, -0.26632392f, 0.19990967f, -0.11876255f, -0.11675493f, -0.03902496f, 0.10561775f, 0.07061233f, 
    0.05757334f, 0.09621010f, 0.14300710f, -0.10707234f, 0.23498917f, 0.19825077f, 0.10018172f, -0.03211251f, 
    0.09059585f, 0.12585698f, 0.02059194f, 0.07549210f, -0.08342221f, -0.07017692f, -0.06235259f, -0.10588646f, 
    0.00841722f, 0.06446188f, 0.33935839f, -0.04967955f, 0.16060247f, 0.10175958f, 0.13690150f, 0.17652452f, 
    -0.03014056f, 0.15760283f, 0.01167289f, -0.18616289f, -0.01382564f, -0.15879017f, 0.01710472f, -0.05573345f, 
    0.04649867f, -0.03746750f, -0.03937146f, -0.16426270f, -0.11597919f, -0.35473821f, -0.09653705f, -0.24631314f, 
    0.23508455f, 0.07990663f, -0.02391086f, -0.14509824f, 0.15119769f, -0.04604965f, 0.10615896f, 0.05422148f, 
    0.01137044f, -0.02035287f, -0.12740865f, -0.10558281f, -0.11150417f, -0.23268747f, -0.04964407f, -0.06931940f, 
    -0.09885149f, -0.01818614f, -0.04485922f, -0.04950028f, 0.13030092f, 0.10789727f, 0.12903072f, 0.18836229f, 
    0.01981119f, 0.01633333f, 0.11235551f, -0.07808492f, 0.05024547f, 0.19570713f, -0.02851797f, 0.17857067f, 
    -0.00275262f, -0.01503635f, -0.01400189f, -0.10099707f, -0.04634119f, -0.04467903f, -0.15066007f, -0.07182480f, 
    0.06134056f, 0.04773416f, 0.09167441f, -0.00545827f, -0.05408499f, -0.03903788f, 0.08103208f, 0.15238138f, 
    0.22877303f, 0.14923958f, 0.06277204f, 0.11673823f, 0.09703890f, 0.06024653f, -0.09466301f, 0.09210628f, 
    -0.05053429f, 0.03935644f, 0.03744025f, 0.03653212f, 0.25233164f, 0.07048326f, -0.22668794f, 0.00293276f, 
    0.06248576f, 0.02893905f, 0.14254270f, 0.06687456f, -0.05967210f, 0.05952559f, -0.05019088f, -0.03355276f, 
    -0.14754371f, -0.10082059f, 0.08531626f, 0.11813921f, -0.01861275f, -0.11789826f, -0.03665417f, -0.17411140f, 
    0.08166943f, 0.04260340f, -0.11683765f, 0.18271939f, 0.07970917f, 0.08630231f, 0.05678069f, 0.14094250f, 
    0.08054588f, -0.23902859f, -0.03931402f, -0.02042473f, -0.13006806f, -0.18713330f, -0.20361935f, -0.18401195f, 
    -0.03212305f, -0.04571121f, 0.00906824f, 0.17301546f, -0.07602056f, 0.06575891f, 0.03569189f, 0.14523396f, 
    0.06417104f, -0.00454893f, -0.04243029f, 0.01659744f, -0.01040529f, -0.18579309f, 0.12127898f, -0.02044847f, 
    -0.04518000f, -0.17063838f, -0.03970180f, -0.15038566f, 0.08104073f, 0.12794900f, 0.06890298f, 0.14403658f, 
    0.08044324f, 0.22726531f, -0.14068983f, 0.09025560f, 0.11712277f, 0.22696149f, 0.10376653f, 0.06428108f, 
    0.01158889f, 0.08866418f, 0.04496494f, 0.13936222f, -0.26185590f, -0.16030943f, 0.09604321f, 0.10227377f, 
    -0.10381134f, 0.10850862f, -0.09054463f, -0.01665068f, 0.20742138f, 0.21190292f, 0.18219641f, 0.18579383f, 
    0.10625897f, 0.35034943f, 0.06022002f, -0.06132605f, 0.07272213f, 0.10142205f, 0.08550280f, -0.06021138f, 
    0.21861763f, 0.12558381f, -0.14612010f, 0.05891012f, 0.09400528f, 0.15105344f, 0.16790065f, 0.08870764f, 
    -0.11437890f, -0.35109290f, -0.13196376f, -0.02386800f, -0.01028554f, -0.03488475f, -0.09176891f, -0.00389016f, 
    -0.15731323f, -0.05677622f, -0.21868084f, 0.16288000f, -0.07168164f, -0.16914934f, -0.02705797f, -0.27643690f, 
    -0.19519617f, -0.09313335f, 0.01947371f, -0.14328457f, 0.06668029f, -0.36114213f, 0.19816816f, 0.09121939f, 
    -0.09729581f, -0.03758165f, 0.00758874f, -0.07218204f, 0.25619790f, 0.12486199f, 0.18992822f, 0.16994147f, 
    0.11355314f, -0.00105297f, 0.15416001f, -0.00048762f, 0.10776719f, 0.03730287f, -0.06233685f, -0.00812100f, 
    -0.07407199f, -0.01154797f, -0.15072139f, -0.02401144f, -0.07090706f, 0.21060626f, 0.20698501f, 0.19618767f, 
    -0.03593187f, 0.03243047f, -0.10007110f, -0.06907432f, 0.11960103f, 0.17473680f, 0.12532471f, 0.14172852f, 
    0.00602506f, -0.15878744f, -0.00262998f, 0.16798262f, -0.23377824f, -0.07636546f, -0.27519798f, -0.17709486f, 
    -0.06777240f, 0.07925943f, -0.00087139f, 0.05720483f, 0.01051205f, 0.06928629f, -0.06091009f, -0.01976781f, 
    0.12651624f, 0.05770327f, -0.02983839f, 0.00967946f, 0.18642192f, 0.05326995f, -0.06327487f, -0.05394454f, 
    0.02401513f, 0.21371709f, 0.02324552f, -0.06446223f, -0.19880486f, -0.18305305f, -0.19874953f, 0.05272349f, 
    -0.09394439f, -0.26067120f, -0.21127182f, -0.06665722f, 0.04652214f, -0.02940878f, -0.02080121f, 0.03397053f, 
    0.02199608f, -0.28947109f, -0.06187315f, 0.06673974f, -0.09597958f, -0.22324087f, 0.01261636f, -0.13159966f, 
    -0.03808875f, 0.26958227f, 0.16020626f, 0.07505316f, -0.03865480f, 0.10526390f, -0.09572556f, 0.25136375f, 
    0.14256085f, 0.12707096f, 0.21176612f, 0.14992818f, -0.00871392f, -0.18310192f, -0.14033481f, 0.06224460f, 
    0.06825866f, -0.02669181f, 0.07377183f, 0.09138311f, 0.05768174f, 0.14123484f, 0.06820385f, 0.10320525f, 
    0.02703113f, -0.02127999f, 0.37971440f, 0.00424841f, -0.03549407f, 0.01272823f, 0.05561534f, -0.09964164f, 
    -0.01044954f, -0.04158769f, 0.05823945f, 0.02520755f, -0.06783953f, 0.03927698f, 0.31263131f, 0.06031241f, 
    -0.12357800f, -0.04902124f, -0.09375616f, -0.13113190f, -0.06430565f, 0.04205132f, 0.15337332f, -0.00561391f, 
    -0.17410856f, -0.15244429f, 0.06648079f, -0.15776551f, -0.13113819f, -0.02596698f, -0.09494496f, 0.17581661f, 
    -0.03108957f, -0.00502107f, -0.03866832f, 0.03265449f, 0.15200023f, -0.15264092f, 0.01350655f, 0.08819485f, 
    0.09702152f, -0.00961298f, 0.01472490f, -0.11249440f, 0.12292172f, 0.01884421f, 0.15360050f, 0.02254149f, 
    -0.02721611f, -0.16330560f, -0.08569524f, 0.08155597f, 0.10286541f, -0.05173304f, 0.11705367f, 0.11851466f, 
    0.03936918f, 0.09118056f, 0.03843031f, 0.06725854f, -0.14217985f, -0.15289934f, -0.05615472f, -0.06700533f, 
    0.00822835f, -0.04073839f, 0.02012984f, 0.06093911f, 0.15401982f, -0.02252751f, -0.00019527f, -0.08287666f, 
    0.12839203f, -0.12501320f, -0.28823191f, 0.11809034f, 0.23064929f, -0.07856687f, -0.04220700f, 0.13739966f, 
    0.18549725f, 0.16152900f, 0.10471124f, 0.03407609f, 0.05112237f, 0.12027347f, -0.01687447f, -0.08068686f, 
    -0.10006411f, -0.01194481f, -0.04583384f, -0.03775468f, -0.08892136f, 0.15120351f, -0.08517544f, 0.02894680f, 
    -0.07091153f, -0.17718513f, 0.15915716f, -0.11620129f, -0.03189313f, -0.02283422f, 0.05229028f, 0.00023721f, 
    -0.02302732f, -0.02265105f, 0.10230970f, -0.02779113f, -0.12203860f, 0.12111322f, -0.07101654f, -0.00857995f, 
    -0.03980668f, -0.02764252f, -0.03198870f, -0.07349841f, 0.01593326f, 0.05724372f, 0.04343078f, 0.01040579f, 
    -0.04461663f, 0.26916119f, 0.09312830f, 0.03185200f, 0.07258932f, 0.17716362f, 0.13191681f, 0.03993533f, 
    0.10739571f, 0.15204901f, 0.20862682f, -0.07221557f, -0.09465241f, 0.08544348f, 0.08739977f, -0.03955018f, 
    -0.04762860f, -0.12439343f, 0.01517888f, -0.04446134f, 0.06396604f, 0.03945318f, 0.19595721f, 0.05775093f, 
    -0.17525193f, -0.07714405f, -0.01731395f, -0.06024694f, 0.00732198f, -0.12960510f, 0.09199950f, -0.03013441f, 
    -0.00345361f, 0.17816147f, 0.08121917f, -0.02169850f, -0.29035303f, -0.20001787f, 0.04888665f, 0.08171538f, 
    0.01320133f, -0.10844699f, 0.12921327f, 0.06792575f, -0.04597389f, -0.00373294f, 0.15155588f, 0.04927073f, 
    0.32925266f, 0.11373685f, -0.05378820f, 0.03419340f, -0.02545791f, 0.05872826f, 0.03447336f, 0.12433397f, 
    0.04869221f, 0.05064747f, 0.17399159f, -0.01137332f, 0.08260426f, -0.07832193f, 0.07379839f, -0.00742800f, 
    0.03953893f, 0.08775149f, 0.13896024f, 0.02169341f, -0.03989671f, 0.05445545f, -0.00304842f, 0.16371055f, 
    -0.02414127f, -0.03478884f, 0.14659452f, 0.07666774f, -0.11111483f, 0.06418813f, -0.05446197f, -0.15608260f, 
    0.06637417f, 0.02503864f, 0.04746012f, -0.02891564f, -0.14352143f, 0.43392512f, 0.06538216f, -0.11199314f, 
    -0.07302922f, 0.07592238f, -0.04342705f, 0.09538970f, 0.10698377f, -0.03815028f, 0.10531655f, -0.09313553f, 
    -0.38668090f, -0.38544342f, 0.25407910f, 0.04252041f, -0.06818008f, -0.14929403f, -0.34744295f, -0.19213875f, 
    -0.04108582f, -0.07695919f, -0.15853624f, 0.07792703f, -0.31292856f, 0.15507446f, 0.13481404f, 0.00262363f, 
    0.01799376f, -0.21705252f, 0.13585874f, 0.02183566f, -0.00897228f, 0.05804593f, 0.05046682f, 0.03025367f, 
    -0.21553122f, -0.28017586f, 0.02905583f, 0.05863440f, -0.06718381f, -0.11341804f, -0.06839388f, 0.04717825f, 
    0.11867935f, 0.06168753f, 0.21069939f, 0.09465555f, -0.11450141f, -0.00588663f, -0.05190647f, -0.03961142f, 
    0.09575588f, 0.00932850f, 0.10107766f, -0.04625757f, -0.10272595f, -0.09746446f, 0.07110569f, -0.11342315f, 
    0.10099782f, 0.10637256f, 0.13951796f, -0.06640615f, -0.01969246f, 0.07015548f, 0.04351038f, 0.22149791f, 
    0.05888471f, -0.07954510f, 0.11434239f, 0.07714733f, -0.04064155f, 0.01748200f, -0.11908030f, -0.01870878f, 
    -0.11537940f, -0.05677352f, -0.07637055f, -0.12080783f, -0.01366078f, -0.04190972f, 0.04561462f, -0.05314413f, 
    -0.28375244f, 0.17672738f, 0.04547438f, 0.30341497f, 0.15943050f, 0.00790915f, 0.11371712f, 0.03853332f, 
    0.03429272f, 0.05508503f, -0.03328930f, 0.02076574f, 0.08749624f, -0.07526710f, 0.14460349f, 0.02466457f, 
    -0.13880454f, -0.12206848f, -0.15388410f, -0.03857567f, 0.07008482f, 0.11133464f, -0.00865775f, 0.18883626f, 
    0.05015874f, 0.26722419f, 0.18407440f, 0.08375898f, 0.04676557f, 0.07551659f, -0.09107098f, 0.04410725f, 
    -0.02467573f, 0.00086376f, -0.02886061f, -0.13487172f, -0.04345707f, -0.08355822f, 0.15583003f, 0.08776648f, 
    -0.04893131f, 0.02100396f, -0.07340211f, 0.13825889f, -0.03366966f, 0.13816841f, 0.19233409f, 0.11699872f, 
    -0.01659168f, -0.12853709f, -0.02708515f, 0.04728705f, 0.07131772f, 0.06549337f, -0.07923550f, 0.00598675f, 
    0.04028131f, -0.01208467f, 0.13635461f, 0.03460372f, -0.24999508f, 0.21842581f, 0.09360854f, -0.00645809f, 
    0.15839437f, 0.12360607f, 0.02685412f, -0.03386374f, -0.02064277f, 0.02728289f, -0.07872493f, 0.03496057f, 
    -0.21292087f, -0.06639570f, 0.00614897f, 0.12707554f, -0.01152551f, 0.03193314f, 0.05355112f, 0.06109090f, 
    0.02661836f, 0.07282265f, 0.00037113f, 0.06895155f, 0.00713163f, 0.17912476f, 0.10965236f, -0.03119840f, 
    -0.00541779f, -0.03181439f, 0.02966965f, -0.10842045f, 0.09009579f, -0.03059534f, -0.08950655f, -0.09387688f, 
    -0.17439933f, -0.21585090f, -0.04329254f, 0.24877067f, 0.05261688f, 0.09901763f, 0.08360912f, 0.13149600f, 
    0.10143015f, 0.08049461f, -0.00251156f, -0.11147939f, -0.31140441f, -0.35381755f, -0.07049815f, -0.02052843f, 
    0.07245799f, -0.11625643f, 0.02163348f, -0.01489604f, 0.10378474f, 0.08422653f, 0.05240647f, 0.07646014f, 
    -0.04124531f, 0.14880767f, -0.19530432f, 0.15487473f, 0.03573054f, 0.13043220f, 0.00521103f, -0.00826627f, 
    0.03650899f, -0.00866902f, 0.14512466f, -0.06312480f, -0.19124146f, 0.00423178f, -0.21566996f, -0.30190831f, 
    0.00056950f, 0.05068276f, 0.04156004f, -0.00517612f, -0.06203497f, -0.04738418f, -0.00959561f, 0.07143517f, 
    -0.07616669f, -0.19107586f, -0.14012513f, -0.22677588f, -0.13627782f, 0.00590539f, -0.06068155f, -0.19094875f, 
    0.12036214f, -0.05835671f, -0.06771436f, -0.23594981f, 0.30960974f, 0.10457282f, 0.23951694f, 0.09450441f, 
    0.19871107f, 0.03288686f, 0.07441866f, 0.05930433f, 0.01351340f, 0.11819274f, -0.00204897f, 0.20724554f, 
    0.18110581f, 0.02559995f, 0.41895297f, 0.11756947f, 0.00382520f, 0.01162132f, -0.06576391f, -0.00480155f, 
    0.05612180f, 0.07888562f, -0.03270580f, 0.03129078f, -0.07979318f, -0.26652542f, -0.09127988f, 0.06478514f, 
    0.00904701f, 0.09770865f, 0.16611005f, -0.06534980f, 0.25405777f, 0.06859350f, 0.05397380f, 0.05365217f, 
    0.29093814f, -0.25192073f, 0.14475222f, -0.21870710f, 0.05448274f, -0.00241157f, 0.13741213f, -0.02656404f, 
    -0.04711852f, -0.11780346f, 0.00806640f, -0.00556032f, -0.14718789f, -0.00291319f, 0.04027313f, 0.12964576f, 
    0.14554672f, -0.06950112f, -0.08760738f, -0.22461678f, 0.00421317f, 0.03484160f, 0.05328551f, 0.11104874f, 
    -0.00241588f, 0.05676614f, -0.04476966f, 0.07594483f, 0.01566014f, -0.06673623f, -0.02401870f, -0.00469752f, 
    0.01810776f, 0.00391969f, -0.04956346f, 0.06824087f, -0.28937906f, 0.04510212f, -0.17308885f, -0.18399081f, 
    0.07841702f, -0.08613608f, -0.04179848f, -0.00029482f, 0.08429718f, -0.10258944f, -0.02165874f, -0.06207994f, 
    0.07311143f, 0.23119226f, 0.19965319f, -0.02982647f, -0.04543874f, 0.07574936f, 0.03036394f, 0.08732325f, 
    0.09891543f, 0.09631801f, 0.02119941f, -0.03607606f, 0.33759606f, -0.11460481f, -0.16772713f, -0.02407355f, 
    -0.06844043f, 0.03483411f, 0.01597463f, -0.05966492f, -0.00678263f, -0.02703173f, 0.03496593f, -0.04470168f, 
    0.33635229f, 0.02722851f, -0.03666136f, 0.08654610f, -0.02452152f, -0.17686616f, 0.09262659f, 0.09816776f, 
    -0.04349002f, -0.01701323f, -0.02692102f, 0.06615101f, 0.03206183f, 0.03293292f, 0.06700584f, 0.15990688f, 
    0.06865355f, 0.17619999f, 0.18275648f, 0.16034293f, 0.00499686f, 0.07162561f, 0.07129130f, 0.05667495f, 
    0.43203548f, 0.26977390f, 0.16606581f, 0.08710124f, -0.16178672f, -0.08063920f, -0.05660587f, -0.00926414f, 
    -0.04259653f, 0.04626539f, 0.08555133f, 0.03630650f, 0.17249656f, -0.08777320f, -0.03267122f, -0.05156221f, 
    -0.00543558f, -0.03388827f, -0.03527022f, 0.07473392f, -0.10610742f, -0.06090854f, 0.01120552f, -0.10477391f, 
    0.04241866f, 0.06000587f, 0.13416187f, -0.02882927f, -0.09469189f, -0.32583708f, -0.04939113f, 0.12889530f, 
    -0.03986413f, 0.08411542f, 0.01152848f, 0.02721142f, 0.36262909f, -0.24435969f, -0.18302687f, -0.11130574f, 
    0.04220478f, -0.06510166f, -0.06071202f, 0.05346468f, -0.16379218f, -0.08178765f, -0.13955531f, 0.00340962f, 
    0.16883637f, 0.06180390f, 0.16140689f, -0.01770118f, -0.15995264f, -0.15709971f, 0.12216406f, 0.15590879f, 
    -0.15991974f, 0.21736462f, 0.06665545f, 0.07226641f, -0.07431769f, -0.01626190f, 0.03356270f, -0.08455156f, 
    0.12632620f, 0.01243107f, -0.04112241f, 0.16577837f, -0.08141987f, -0.16125138f, -0.15021417f, -0.09676152f, 
    -0.20364541f, 0.22387928f, -0.23578808f, 0.11793759f, 0.01495433f, 0.01226660f, 0.03335172f, 0.08821840f, 
    -0.12001768f, 0.02839662f, -0.12233851f, -0.06619358f, 0.01055581f, 0.13865261f, 0.11600386f, 0.02337813f, 
    -0.00358219f, 0.03602311f, -0.05126936f, -0.05494228f, 0.16065483f, -0.10449511f, -0.03962128f, 0.03511256f, 
    -0.00320549f, 0.13866054f, -0.18833353f, 0.09897505f, -0.00943372f, -0.09320338f, 0.11363858f, -0.01028924f, 
    -0.05832825f, 0.11389202f, -0.09223823f, -0.18327028f, 0.17569010f, 0.02315310f, 0.00888752f, -0.01714741f, 
    -0.03005997f, -0.03992042f, 0.05703225f, 0.02122187f, 0.14672050f, 0.03147709f, -0.00553727f, 0.03498747f, 
    0.13606344f, 0.14996952f, 0.12743369f, -0.00976457f, 0.04989414f, -0.01090038f, -0.04389783f, 0.11815817f, 
    0.01263174f, 0.06759325f, -0.10925927f, -0.18068786f, -0.07554453f, 0.02407185f, 0.03468259f, -0.00248527f, 
    -0.05386873f, 0.03793439f, 0.04337208f, 0.01022284f, -0.02806242f, 0.03556892f, 0.15110214f, 0.12502100f, 
    -0.01809311f, -0.09018906f, 0.02310412f, 0.24477050f, 0.11501495f, 0.01143561f, -0.12586419f, 0.09009650f, 
    -0.08460737f, -0.01561395f, -0.03695183f, -0.00114112f, -0.00248483f, 0.06910113f, -0.15981477f, 0.11342014f, 
    -0.15182920f, -0.10922739f, 0.32235202f, 0.21386477f, -0.02226024f, 0.07063289f, -0.05720904f, 0.05000470f, 
    -0.17237920f, 0.35622051f, -0.21653332f, 0.06980387f, -0.06388629f, 0.16150549f, 0.11432240f, 0.01206488f, 
    0.05927068f, 0.07836962f, 0.15738633f, 0.05779900f, 0.01477639f, -0.10648972f, 0.17893831f, -0.25523785f, 
    -0.06488629f, 0.00997688f, -0.11294466f, -0.07738341f, -0.07606098f, -0.09790950f, -0.07513156f, -0.08821046f, 
    -0.18828231f, -0.09098721f, 0.20564328f, -0.01245093f, 0.21704806f, -0.05270955f, -0.06986671f, -0.00206839f, 
    -0.02838078f, -0.03053610f, -0.12898958f, -0.11867183f, -0.55348623f, -0.22803390f, -0.24132866f, 0.01179020f, 
    -0.08458807f, -0.05958530f, 0.20339325f, 0.18856509f, 0.18279359f, 0.02324654f, 0.13418259f, 0.07008756f, 
    0.09613150f, 0.05676927f, 0.11138476f, 0.10724409f, 0.02400774f, 0.26913470f, -0.02316577f, -0.01301869f, 
    -0.01928276f, -0.11589515f, -0.00817617f, -0.09245681f, -0.16174267f, 0.34983081f, -0.12272649f, -0.27033764f, 
    0.02561891f, -0.00418395f, 0.18822280f, 0.18263817f, 0.01385325f, -0.01324797f, 0.16456279f, 0.02608060f, 
    -0.22024833f, -0.33680642f, -0.11628473f, 0.12040629f, 0.04927628f, -0.01884788f, -0.00752365f, -0.07865244f, 
    0.07754727f, -0.03083054f, 0.02310354f, -0.16349120f, 0.16476053f, 0.07317071f, -0.03606145f, -0.09113779f, 
    0.13058773f, -0.00666822f, 0.01148542f, -0.07105467f, 0.05274833f, 0.00285905f, 0.19609642f, 0.11124410f, 
    0.38472834f, -0.13055065f, 0.41629973f, -0.07884224f, 0.17477788f, 0.05963011f, -0.08259470f, 0.08390180f, 
    0.08098339f, -0.10086793f, 0.06939301f, 0.08034935f, -0.07266103f, -0.05387004f, -0.27844438f, 0.08065759f, 
    0.02507785f, -0.09176263f, 0.01972156f, -0.02514530f, 0.11962301f, 0.10635345f, 0.15573111f, -0.00094319f, 
    0.20180982f, -0.09959268f, 0.09011502f, -0.08230719f, 0.09031428f, 0.05310450f, 0.11472284f, 0.03811880f, 
    -0.01436799f, -0.20696567f, -0.03456702f, -0.00831166f, 0.06188949f, 0.06275409f, -0.17461079f, 0.01771326f, 
    0.10344659f, 0.00188973f, 0.02495030f, 0.02467461f, -0.02501709f, -0.02404503f, 0.15305103f, 0.17478532f, 
    0.08027538f, 0.06151735f, -0.05881216f, -0.08196892f, 0.04242082f, 0.01670938f, -0.00519516f, -0.00901306f, 
    0.02670432f, -0.00769884f, 0.11544286f, 0.22118218f, -0.08843789f, 0.07857496f, 0.12304290f, -0.03235579f, 
    0.02616917f, 0.10751726f, -0.05555842f, 0.05267548f, -0.04951694f, -0.11251360f, -0.05581393f, -0.05520489f, 
    -0.03633436f, 0.00838527f, -0.02569914f, -0.08390720f, -0.03007067f, 0.08923548f, 0.07013925f, -0.04230455f, 
    0.14263557f, 0.01032470f, 0.15760821f, 0.10991578f, 0.09595694f, -0.06645461f, -0.04296151f, -0.11110044f, 
    0.09978409f, 0.12781718f, -0.16502233f, -0.14817831f, 0.09844141f, -0.06771038f, -0.01386058f, 0.06151810f, 
    -0.00132500f, 0.06022533f, 0.35067385f, -0.11520338f, 0.09778753f, 0.02530478f, 0.20047517f, -0.11960637f, 
    0.11302681f, 0.05771252f, -0.08037225f, 0.04194676f, 0.01805909f, -0.03072656f, -0.15186025f, 0.10089587f, 
    -0.02600942f, -0.12650879f, 0.05511216f, 0.14668739f, 0.01789957f, 0.02537608f, 0.02144682f, 0.22143765f, 
    -0.02042771f, 0.15071869f, -0.07398509f, -0.26906094f, -0.02438700f, 0.02762534f, 0.03948900f, -0.01732063f, 
    0.05894354f, -0.02387548f, -0.06132036f, 0.04257402f, -0.27552196f, 0.31825459f, 0.06372788f, -0.08621733f, 
    -0.08923413f, -0.07283127f, -0.00853496f, 0.08507404f, -0.01098788f, 0.13856208f, 0.06771833f, -0.03940343f, 
    0.02549391f, 0.01382501f, 0.04907889f, 0.04362525f, 0.00117077f, 0.01802232f, 0.22000934f, -0.08404537f, 
    -0.05118909f, 0.00122016f, -0.02822186f, -0.00293886f, -0.11927430f, -0.23488431f, 0.23914236f, 0.09745330f, 
    -0.16286995f, -0.13594407f, -0.03138189f, 0.06019321f, -0.01117577f, 0.06624334f, 0.02684540f, -0.09900730f, 
    -0.02293564f, 0.19538173f, 0.07233890f, 0.02619381f, -0.02545192f, -0.13681084f, -0.04567330f, 0.02632376f, 
    -0.00779958f, -0.02024633f, 0.17306741f, 0.12389255f, -0.14629118f, -0.08220401f, -0.16105419f, 0.05310116f, 
    -0.02656196f, 0.03216725f, 0.08871864f, -0.02926404f, 0.11133634f, 0.15099286f, 0.06222668f, 0.00023061f, 
    -0.16183540f, -0.12282829f, -0.30360138f, 0.22373860f, -0.00435809f, 0.07433881f, 0.00438500f, 0.00506391f, 
    0.02094774f, 0.07341584f, 0.18066281f, 0.17873926f, 0.05069544f, 0.11518435f, -0.06541684f, -0.05502422f, 
    0.02496240f, -0.05471060f, -0.07687147f, -0.05468788f, 0.01183159f, 0.00219884f, 0.08680348f, 0.06533381f, 
    -0.28149450f, 0.12441404f, -0.00118198f, 0.27429032f, -0.07520525f, -0.11074652f, 0.03913597f, 0.14417228f, 
    0.02691484f, 0.12726565f, 0.00295176f, 0.00110829f, 0.06068669f, 0.00509674f, 0.04043977f, -0.21345142f, 
    -0.07692444f, -0.02303661f, -0.06057497f, -0.00837714f, 0.15751548f, -0.07266369f, -0.08039898f, 0.10498103f, 
    0.00761526f, 0.04626036f, 0.02899825f, 0.16440278f, -0.09295683f, 0.21549477f, 0.24050863f, 0.06611854f, 
    0.04912565f, 0.06601458f, 0.01924452f, 0.03756101f, 0.06947663f, -0.00017606f, -0.08587471f, -0.12441672f, 
    -0.06170560f, -0.09963133f, 0.02903513f, -0.04463163f, -0.06580248f, 0.02921975f, -0.05999274f, -0.06948269f, 
    -0.05780203f, -0.02804627f, 0.10096244f, -0.18014616f, 0.12387481f, -0.11243760f, 0.17483091f, 0.06274919f, 
    0.06778024f, 0.04352194f, -0.08535966f, 0.00936065f, -0.19014409f, 0.03925249f, 0.14672343f, 0.18849538f, 
    -0.08954906f, -0.14285071f, 0.13262536f, 0.04405087f, 0.08274944f, 0.14565893f, 0.08339608f, 0.05684610f, 
    0.21947062f, -0.15070140f, -0.19123869f, -0.02304637f, 0.11878858f, -0.15965851f, 0.07984471f, -0.12118439f, 
    -0.24371238f, -0.10567751f, -0.11041883f, -0.01260456f, 0.12913387f, 0.21523649f, 0.36240497f, 0.15114924f, 
    -0.00851260f, 0.10624035f, 0.03122269f, -0.00102667f, 0.02018539f, -0.09207251f, 0.03935644f, -0.01665953f, 
    0.11790799f, -0.06703857f, -0.18460768f, -0.00562172f, -0.09172446f, -0.11530714f, -0.05485727f, -0.05030933f, 
    0.06889611f, 0.06818466f, 0.05818508f, 0.07936464f, 0.02098979f, -0.11341576f, -0.15109217f, -0.02066492f, 
    0.01476072f, 0.09266067f, -0.06096056f, 0.14827526f, -0.01013201f, 0.04433529f, -0.06071896f, -0.01298206f, 
    -0.11717703f, 0.07648545f, -0.15388739f, -0.18958400f, -0.04240475f, -0.29994670f, 0.01756011f, -0.06273136f, 
    -0.03961411f, 0.12486228f, 0.05468995f, 0.04651909f, -0.04835128f, 0.24045734f, 0.02205322f, 0.22173528f, 
    0.10300077f, 0.10747947f, 0.18775041f, 0.36188129f, -0.05727451f, 0.05759365f, -0.07961284f, 0.04103667f, 
    0.13403006f, 0.28093269f, -0.10086654f, -0.04718655f, -0.06256211f, -0.02211360f, 0.04320084f, 0.16633797f, 
    -0.02156474f, 0.10687606f, 0.09112160f, -0.05631725f, 0.03732031f, 0.15713890f, 0.04025498f, -0.01257376f, 
    -0.00651102f, 0.01531764f, -0.02061417f, 0.16516253f, 0.11390942f, 0.05856452f, 0.02142599f, 0.03356856f, 
    -0.24708727f, 0.21213861f, 0.16148038f, 0.15197839f, -0.00968287f, -0.10706066f, 0.00881112f, -0.09427413f, 
    0.04079659f, -0.08375486f, -0.10606775f, -0.10525784f, -0.24940006f, -0.18771504f, -0.23017308f, -0.14137615f, 
    0.02050212f, 0.08948472f, 0.01277847f, 0.09235665f, -0.06660099f, -0.10828809f, -0.14040694f, 0.10967877f, 
    0.13437587f, 0.33271414f, 0.11837472f, 0.21796948f, 0.05076012f, 0.17774223f, -0.06489165f, 0.14639555f, 
    0.01182073f, 0.10395597f, -0.05437575f, 0.01104888f, 0.03549087f, -0.28715098f, -0.30337641f, -0.17427367f, 
    -0.04501914f, 0.01618127f, 0.02139112f, 0.08039900f, 0.13582171f, 0.05203619f, 0.10694956f, -0.06880561f, 
    0.11627450f, -0.05223257f, -0.06553286f, -0.11975806f, -0.03536539f, -0.02299249f, -0.02254875f, -0.05915442f, 
    -0.02320797f, 0.01509396f, -0.13460478f, 0.01168582f, -0.09246926f, -0.24434668f, -0.07794268f, -0.07917386f, 
    0.06297074f, 0.11351284f, -0.00485727f, 0.14089696f, 0.10257276f, 0.07825013f, 0.07574069f, 0.07391893f, 
    0.19168290f, 0.09375469f, 0.07144225f, 0.22238064f, 0.04942509f, -0.01155052f, -0.07455388f, 0.10463879f, 
    0.01454187f, 0.01590348f, 0.02217940f, 0.06309322f, 0.28516677f, 0.28997165f, 0.12143212f, 0.08843917f, 
    -0.02003364f, 0.04378149f, 0.11233347f, 0.14044343f, -0.01848360f, -0.01668571f, 0.03829736f, -0.12026378f, 
    -0.07283217f, -0.01516011f, -0.03527703f, 0.01975361f, -0.05508199f, 0.04454583f, -0.03090994f, -0.02988159f, 
    -0.01409378f, 0.02763285f, -0.01512823f, -0.05174861f, -0.01256423f, -0.03760155f, -0.03534805f, 0.01196140f, 
    0.02753726f, -0.01097475f, -0.00427101f, -0.02550732f, 0.06150454f, -0.04550156f, -0.02113547f, 0.00525514f, 
    -0.01521167f, -0.06093323f, -0.07820960f, 0.04991032f, -0.04394270f, -0.04997580f, -0.06827800f, -0.07023939f, 
    0.01608845f, -0.03616587f, 0.06122664f, -0.04311403f, 0.01019615f, -0.02101391f, -0.02865130f, -0.01867943f, 
    -0.05447792f, -0.06443424f, -0.00401683f, -0.05014151f, -0.00449130f, -0.07285731f, 0.00091351f, -0.06542361f, 
    0.03469145f, 0.05470345f, -0.06585437f, 0.00400268f, -0.00052399f, 0.06209565f, -0.02209508f, -0.01276430f, 
    -0.00601162f, -0.02533626f, -0.00293347f, -0.02516968f, 0.04656526f, -0.04762427f, -0.07358390f, -0.03745674f, 
    -0.03938802f, 0.05563474f, -0.00820627f, 0.02320046f, 0.05416507f, -0.06806045f, -0.06782748f, 0.05243357f, 
    -0.07278420f, 0.02919463f, -0.06956263f, 0.03557425f, 0.00746431f, -0.02433356f, -0.02655137f, -0.01308952f, 
    -0.04712716f, 0.01701305f, -0.04704668f, 0.02626926f, 0.03289199f, -0.07468566f, -0.01024885f, 0.03723031f, 
    -0.00222649f, 0.05900145f, 0.05168568f, -0.03084259f, -0.06174163f, -0.02886203f, -0.06471647f, 0.01124591f, 
    -0.07459230f, 0.01830007f, -0.01924461f, -0.00917359f, -0.02821814f, 0.00204486f, -0.07235115f, -0.04953304f, 
    -0.05772797f, -0.01208311f, -0.00649246f, -0.07800630f, -0.02668936f, 0.03407703f, -0.06687640f, 0.01384592f, 
    -0.04286989f, 0.06446452f, -0.02163407f, 0.01505193f, -0.01197546f, 0.04984643f, -0.01019373f, -0.05443659f, 
    0.05768897f, 0.05647378f, -0.04197783f, -0.00201471f, -0.03514405f, -0.04114498f, -0.05681624f, 0.00985042f, 
    0.02089987f, 0.03960246f, -0.01726737f, 0.04741701f, 0.04809936f, -0.03676257f, -0.05521011f, 0.04141745f, 
    0.03481127f, -0.04716964f, 0.00935125f, 0.01906252f, -0.07157825f, -0.06225921f, -0.05599994f, 0.00986452f, 
    0.02579115f, 0.05249109f, 0.00244049f, 0.04690947f, 0.04676116f, -0.07908358f, -0.08072145f, -0.06775939f, 
    0.04748686f, -0.04827330f, -0.03993893f, -0.04663934f, 0.00239227f, -0.03878938f, -0.01622314f, 0.00548590f, 
    0.01114227f, -0.03787354f, 0.02645545f, 0.04878942f, 0.05561984f, 0.03041823f, -0.06777053f, -0.01774269f, 
    0.02387897f, 0.02072003f, -0.00321142f, 0.05530374f, -0.02113044f, -0.01726172f, 0.01315942f, -0.04657994f, 
    -0.01198484f, 0.01108709f, -0.04354035f, -0.01038210f, 0.06152260f, 0.00085677f, 0.01562663f, -0.04391547f, 
    -0.02016491f, -0.01929311f, -0.02413537f, -0.00368359f, 0.02078227f, -0.02119751f, 0.05709035f, -0.04957035f, 
    -0.02607729f, 0.00932812f, -0.17341506f, 0.27790263f, -0.08935469f, 0.08919710f, -0.04333388f, 0.12758583f, 
    -0.10268250f, 0.13679907f, 0.02569307f, -0.16649403f, 0.28991872f, -0.05835701f, 0.10599971f, 0.18768327f, 
    0.07186379f, 0.02671495f, 0.11610297f, -0.06997924f, 0.07260222f, 0.15899038f, 0.02365344f, 0.21828663f, 
    -0.08432396f, 0.29004776f, 0.09696323f, 0.25068805f, -0.00828667f, -0.02768395f, 0.00749975f, -0.00940418f, 
    0.08991047f, 0.01693731f, 0.04764039f, -0.01301133f, -0.36554560f, -0.19400372f, -0.11989810f, -0.02036545f, 
    0.02512430f, -0.02878728f, 0.09491117f, -0.04716520f, -0.00481293f, -0.06909605f, -0.16642463f, -0.11689902f, 
    -0.31773117f, 0.15165354f, 0.40430075f, 0.23756514f, 0.01236805f, -0.04017453f, -0.17626457f, 0.08386134f, 
    -0.01188444f, -0.05387777f, 0.02415464f, 0.01210344f, 0.31272182f, -0.18563615f, -0.31559178f, -0.24408354f, 
    -0.02906086f, -0.07043141f, 0.06460837f, 0.05820228f, -0.02356119f, 0.09846738f, -0.01988765f, -0.08396107f, 
    -0.11635886f, -0.13959517f, 0.10361815f, 0.01376380f, -0.11069982f, 0.23368482f, 0.12326264f, 0.00615408f, 
    0.10964625f, -0.12574252f, 0.22367279f, -0.02497414f, -0.12110656f, -0.01788672f, 0.01141339f, 0.19676355f, 
    0.04121415f, 0.01729674f, 0.06496474f, 0.04485294f, -0.05703989f, -0.12421983f, 0.01679413f, -0.00530343f, 
    0.39032245f, -0.05064962f, -0.04389537f, 0.16581050f, -0.00113249f, 0.08455055f, 0.05659772f, 0.04473805f, 
    0.01761796f, 0.03917900f, 0.05470890f, 0.23634920f, -0.02910775f, 0.12480335f, 0.03093357f, -0.15425152f, 
    -0.01609778f, -0.01363847f, 0.03490338f, -0.10406014f, 0.03627464f, -0.10153704f, -0.10628919f, -0.09604660f, 
    -0.24654260f, -0.25239807f, -0.18077846f, 0.19641267f, 0.03608401f, 0.08645409f, 0.14058027f, -0.06915928f, 
    -0.05809399f, -0.02762509f, -0.11337715f, 0.06147235f, 0.15255894f, 0.14497861f, 0.10567226f, -0.22325690f, 
    -0.01959549f, -0.00118946f, 0.04526416f, -0.08180466f, -0.03237735f, 0.05517825f, 0.00496030f, 0.07810572f, 
    0.09782989f, 0.10254766f, 0.14875865f, 0.11071928f, -0.06371024f, -0.03779774f, -0.07983854f, 0.02399979f, 
    0.02040384f, -0.00102449f, -0.17878139f, -0.19973449f, -0.07017383f, -0.02904243f, -0.02007693f, 0.06453559f, 
    0.13525277f, 0.02143017f, -0.02881941f, 0.08578961f, 0.03481875f, 0.03438481f, 0.13866572f, 0.00293274f, 
    0.15072618f, -0.09675681f, 0.24169491f, 0.05132594f, 0.01223490f, -0.02461215f, 0.02010670f, -0.04177551f, 
    0.02142693f, -0.06714690f, -0.07774059f, 0.03532037f, -0.16541304f, -0.13576160f, -0.13439634f, 0.17206587f, 
    0.12546128f, 0.12428372f, 0.12780483f, -0.09379510f, 0.09940867f, 0.07066328f, -0.08902414f, 0.16289639f, 
    -0.15128163f, 0.08992585f, 0.06180101f, -0.04051823f, 0.05817727f, 0.09863014f, -0.00650102f, -0.02791493f, 
    0.06405227f, -0.00629748f, 0.09243025f, 0.02181012f, 0.09110817f, -0.22163755f, -0.13272673f, -0.02848059f, 
    0.00096859f, 0.06737325f, -0.20716712f, -0.16379896f, -0.15235442f, -0.16016930f, -0.06090662f, -0.20813879f, 
    -0.15830284f, 0.16225708f, 0.32378098f, 0.11206832f, 0.14312987f, -0.11561240f, 0.06677715f, 0.04210418f, 
    -0.07777314f, -0.07619081f, -0.06524283f, -0.16883424f, -0.44599131f, 0.12624218f, 0.01231035f, 0.28284144f, 
    -0.05438638f, 0.07686281f, 0.17090170f, -0.16423422f, 0.08241783f, 0.07755087f, 0.10660502f, 0.35658294f, 
    0.11664584f, 0.16701144f, 0.32419702f, 0.04002277f, 0.01749554f, 0.22227359f, 0.06104652f, -0.02199937f, 
    0.07887341f, -0.12082049f, 0.07857149f, -0.09944658f, 0.40933773f, -0.28813958f, 0.09394595f, 0.07728287f, 
    0.14931889f, 0.22261184f, 0.03560933f, 0.14903435f, -0.01001710f, -0.06711004f, 0.20741686f, -0.01028767f, 
    -0.06272875f, 0.09296074f, -0.09591562f, 0.12538774f, 0.08200847f, 0.05502839f, -0.08519503f, -0.21017699f, 
    0.11539745f, -0.14478569f, -0.13290469f, 0.00396957f, -0.07151205f, -0.17710555f, -0.07253547f, 0.16055070f, 
    -0.07368226f, 0.08670925f, 0.10497292f, 0.03853581f, 0.09894137f, 0.16263865f, 0.03444846f, 0.08384690f, 
    0.28573141f, -0.18686222f, -0.06882653f, 0.23761329f, 0.01142083f, -0.08673604f, -0.08967556f, -0.08409125f, 
    -0.02622888f, -0.06284913f, 0.19919930f, 0.12999816f, -0.06238133f, -0.01225209f, -0.09700813f, -0.13352153f, 
    -0.10167567f, -0.21679831f, 0.06553623f, -0.01716057f, 0.10526527f, 0.48839206f, 0.32608607f, 0.35097113f, 
    -0.13337924f, 0.02201758f, 0.24334453f, 0.03160229f, -0.16283779f, 0.16747908f, 0.14677593f, 0.07082962f, 
    0.00315835f, -0.14489229f, 0.11827093f, 0.11672995f, 0.05163203f, 0.15951124f, -0.06362268f, -0.10293922f, 
    -0.03936418f, -0.08894569f, 0.01574105f, -0.22443417f, -0.09799223f, -0.04003080f, 0.01729361f, -0.15080905f, 
    0.06817834f, -0.03665074f, -0.17745478f, 0.13796152f, -0.05460272f, -0.13694416f, 0.03785726f, 0.00489506f, 
    0.00039464f, 0.20269254f, 0.24312991f, 0.30111855f, -0.04650403f, 0.06457014f, -0.18341567f, -0.20779054f, 
    0.03026975f, -0.05646516f, -0.05479418f, -0.17001687f, -0.07266837f, -0.24239917f, -0.24376829f, -0.31413761f, 
    -0.03916048f, -0.00135714f, -0.00536971f, -0.00125170f, -0.10469463f, 0.06292130f, 0.31670341f, -0.06085308f, 
    0.12200058f, 0.03578763f, -0.01321680f, 0.10315444f, 0.00700418f, -0.12198465f, 0.22932778f, 0.03505818f, 
    -0.03871794f, 0.02925929f, -0.11058081f, 0.02459756f, 0.11135117f, 0.07287780f, 0.08985552f, -0.02099733f, 
    -0.07266115f, 0.02816578f, -0.05157390f, 0.01691855f, 0.06356944f, -0.07187947f, 0.06214410f, -0.03880635f, 
    -0.07775845f, 0.00672610f, 0.03924731f, 0.05280587f, -0.05726197f, -0.02120132f, -0.02582164f, -0.05796878f, 
    0.02804837f, -0.05974354f, 0.05033352f, -0.03234122f, -0.00106771f, 0.02178318f, 0.04330980f, -0.02490768f, 
    0.01257703f, -0.03782552f, 0.04716286f, -0.01850082f, -0.05407602f, -0.01487391f, -0.02756340f, -0.00030557f, 
    -0.06679276f, 0.03703509f, -0.04813119f, 0.00502409f, 0.02376498f, 0.00890744f, -0.03021466f, 0.00375423f, 
    -0.06844240f, 0.01910210f, 0.00727290f, -0.01099105f, -0.04741523f, 0.05299423f, 0.00994135f, 0.04641283f, 
    -0.00261482f, -0.03430172f, 0.00462880f, -0.03114969f, -0.04032178f, -0.01940908f, -0.03797504f, 0.05005878f, 
    -0.07550371f, 0.03695768f, -0.04778202f, -0.05581459f, -0.02428912f, 0.04587493f, -0.06416897f, -0.06834532f, 
    0.01804140f, 0.02143715f, 0.03925800f, 0.06090660f, -0.02105983f, -0.03594875f, -0.04318505f, -0.05974277f, 
    0.04017076f, -0.06923459f, 0.06457120f, -0.00495505f, -0.07231968f, -0.04850338f, 0.05062041f, -0.05249706f, 
    0.05013148f, -0.00691401f, -0.04582402f, 0.03022765f, -0.02039519f, 0.02564503f, -0.07363409f, 0.00348441f, 
    -0.07032169f, 0.05074947f, 0.03170982f, 0.05450019f, -0.06220683f, -0.07475184f, -0.04327776f, 0.03102772f, 
    0.01420118f, 0.05216991f, -0.06799335f, 0.06138590f, -0.01243792f, 0.00476287f, 0.01477754f, -0.05391964f, 
    -0.05279434f, 0.03825313f, 0.04963141f, -0.04421424f, -0.05938659f, -0.06452460f, -0.04664081f, 0.04629511f, 
    -0.02267947f, -0.01145674f, 0.03628331f, -0.04644790f, -0.02774167f, -0.06195424f, -0.01307371f, -0.07165666f, 
    0.00290018f, -0.02096351f, -0.01454843f, -0.06792006f, 0.06549359f, -0.01764338f, -0.04832871f, 0.03906168f, 
    -0.02664338f, -0.06966456f, 0.01391757f, -0.03622803f, -0.01297363f, 0.05525010f, -0.01679472f, -0.01572151f, 
    -0.03044170f, -0.01191497f, -0.06290133f, -0.04560419f, -0.03866901f, -0.01863619f, -0.00996951f, -0.02689878f, 
    0.00541259f, 0.02836635f, 0.04717826f, -0.01946805f, -0.07620610f, 0.00093481f, 0.03663091f, 0.00839129f, 
    -0.06474311f, 0.06372037f, -0.07300703f, 0.05372248f, -0.03592124f, -0.00863123f, 0.02345458f, -0.05227499f, 
    -0.02694659f, 0.04223446f, 0.00788796f, -0.02724616f, -0.06232008f, 0.05980453f, -0.05614402f, -0.03456019f, 
    0.05056720f, -0.01304820f, -0.02430869f, -0.06116915f, -0.03831256f, 0.06451272f, -0.03276871f, 0.00563970f, 
    -0.02411417f, 0.01045507f, 0.02259001f, 0.05780700f, -0.02745071f, 0.04667020f, 0.03723357f, 0.00426546f, 
    -0.01709940f, -0.07119233f, 0.05920123f, -0.00295167f, -0.02742119f, 0.05021772f, -0.06966168f, 0.04553746f, 
    0.24624184f, -0.13968092f, 0.38164780f, -0.26334780f, 0.07837054f, 0.07164325f, 0.08833669f, -0.07641942f, 
    0.00049757f, 0.02634556f, -0.03914467f, 0.09444790f, -0.02104924f, -0.01563862f, -0.05684839f, 0.00940127f, 
    0.01681016f, -0.02933385f, 0.09135392f, 0.13065042f, -0.03197210f, -0.14845347f, -0.09286197f, 0.03799525f, 
    0.02313173f, 0.09875338f, 0.14271641f, -0.14146537f, -0.02090036f, -0.05772955f, 0.00115249f, -0.07783857f, 
    -0.06723537f, -0.00635567f, 0.05640516f, -0.03661309f, 0.08362629f, 0.41745725f, 0.22368427f, -0.11748106f, 
    -0.02046655f, 0.04288580f, -0.16531284f, 0.03141674f, 0.05047223f, 0.01849554f, -0.04349176f, -0.02408282f, 
    0.17179170f, 0.03398842f, 0.11551864f, 0.00755633f, 0.07483166f, -0.01281007f, 0.07748394f, -0.10803510f, 
    -0.04874267f, -0.08108500f, -0.01811311f, 0.01739477f, -0.18268727f, -0.22169095f, 0.22794931f, 0.15828088f, 
    -0.00578236f, -0.13788827f, -0.08169805f, -0.00359145f, -0.09388431f, -0.00215209f, -0.01161403f, 0.07106131f, 
    0.16536531f, 0.35864735f, 0.07389523f, 0.08443783f, 0.04430537f, 0.09546728f, 0.00602380f, -0.07007457f, 
    -0.01814419f, 0.03432788f, -0.09924280f, 0.18074550f, -0.13073170f, 0.06783997f, -0.00877349f, 0.10725889f, 
    -0.21274278f, -0.09249014f, 0.08507193f, -0.04330355f, 0.04875648f, 0.06975789f, -0.01768920f, -0.06145124f, 
    -0.16549243f, -0.05956467f, -0.37889963f, 0.05652931f, -0.12422737f, 0.02736949f, 0.00654868f, 0.00271863f, 
    -0.06597279f, 0.03292725f, 0.15419570f, 0.24983767f, -0.09755280f, 0.01546319f, -0.02071672f, -0.19253571f, 
    -0.06118229f, -0.11553803f, -0.18195888f, 0.00809102f, 0.14562267f, 0.18713930f, 0.06564943f, 0.05323949f, 
    -0.09421506f, 0.16636853f, 0.16837676f, 0.22220364f, 0.01355796f, -0.12433844f, 0.01219296f, 0.03973075f, 
    -0.01583344f, 0.05080445f, 0.05210868f, -0.12157032f, 0.02114221f, -0.06237074f, 0.17838623f, 0.01059214f, 
    -0.02414346f, -0.00882056f, -0.09951132f, 0.08688540f, 0.18287514f, 0.00198170f, -0.05344311f, -0.00199826f, 
    -0.03857875f, -0.11539607f, 0.10559925f, 0.12320209f, -0.03689028f, 0.07652974f, 0.00693283f, -0.02785479f, 
    0.17407303f, 0.15822273f, 0.07763921f, 0.08049716f, 0.21107632f, 0.01619876f, 0.01839806f, -0.04549180f, 
    0.09392853f, 0.11047369f, -0.01391660f, 0.06268762f, -0.01247250f, 0.06338464f, 0.05042109f, 0.05000282f, 
    -0.06941571f, -0.14586262f, -0.06215348f, -0.00786032f, 0.08835196f, -0.02839863f, 0.06049581f, -0.00739914f, 
    0.00266083f, 0.07090643f, -0.00090586f, -0.00085531f, -0.24389628f, 0.26848039f, 0.23885234f, 0.17039619f, 
    -0.13806935f, -0.15830255f, 0.00948576f, 0.06116036f, 0.08711798f, 0.09787458f, 0.04038304f, -0.01284070f, 
    -0.07323579f, 0.02066958f, -0.03328264f, 0.06050112f, -0.03411171f, -0.05987601f, 0.00610553f, -0.02690312f, 
    -0.05623722f, 0.00332906f, -0.06313234f, -0.02567354f, 0.03172079f, 0.02103247f, 0.03879558f, 0.03256452f, 
    -0.04979165f, 0.05779180f, -0.04948430f, -0.00597026f, -0.03085542f, -0.05552207f, -0.05572666f, -0.00905088f, 
    0.00395626f, 0.00407481f, -0.00385082f, -0.03466260f, -0.02497506f, -0.08342207f, -0.03372628f, 0.04663222f, 
    -0.06859095f, -0.03480082f, -0.06834725f, -0.04233459f, -0.00457414f, 0.06211356f, -0.07453272f, -0.04798155f, 
    0.00969555f, 0.03094967f, 0.03820575f, 0.04411409f, -0.07495908f, -0.00148057f, -0.07770056f, 0.05145869f, 
    -0.00834411f, -0.01699442f, 0.03233342f, 0.00739702f, -0.07477695f, 0.05026430f, -0.08012322f, 0.00708309f, 
    0.01691997f, 0.04189219f, 0.03179906f, -0.03728176f, 0.02781614f, -0.03309806f, 0.01599518f, -0.01252008f, 
    -0.03293125f, 0.04373927f, -0.06485303f, -0.07965066f, -0.07425495f, -0.03960209f, -0.01822921f, -0.05300191f, 
    -0.05300090f, 0.05770246f, 0.00185251f, -0.04946972f, -0.02595173f, -0.04150148f, -0.07208172f, -0.05838885f, 
    -0.04966073f, 0.04325861f, -0.05095625f, 0.00865408f, 0.00358819f, 0.02294995f, 0.04421828f, 0.02120739f, 
    0.04114805f, -0.00832397f, -0.02682081f, -0.02480017f, 0.03655994f, -0.04278488f, 0.00458682f, -0.02844084f, 
    -0.06237572f, -0.06888209f, -0.04011910f, -0.05458207f, -0.06619126f, -0.07582780f, -0.00794959f, -0.10979009f, 
    -0.06041855f, -0.00878592f, -0.05289742f, -0.00568164f, 0.03201622f, -0.00861861f, 0.02167027f, -0.04692863f, 
    0.00853083f, 0.02753397f, -0.01462505f, 0.04039510f, 0.04477112f, -0.02008008f, 0.02441357f, -0.06934233f, 
    0.05271574f, 0.02128936f, -0.00431219f, 0.05951601f, 0.01227851f, -0.04609779f, 0.00098587f, -0.07465197f, 
    0.02037159f, -0.00710413f, -0.04453140f, -0.01579027f, -0.06694495f, -0.02485867f, 0.00257956f, 0.00760261f, 
    -0.00590233f, 0.02732081f, 0.03017671f, 0.01661900f, -0.02793612f, 0.01865634f, -0.06503226f, 0.00949819f, 
    -0.04868326f, -0.07336039f, -0.07426620f, -0.07067725f, -0.06504790f, -0.00951720f, 0.02376002f, -0.04683965f, 
    -0.00613033f, -0.06818129f, -0.03271405f, -0.10598060f, -0.07078269f, 0.03328979f, 0.03826978f, -0.05414315f, 
    -0.07185732f, 0.05348670f, 0.03562928f, -0.04856799f, 0.03039517f, -0.00407149f, 0.05687286f, -0.05218437f, 
    0.00079801f, -0.06024135f, -0.05585754f, 0.02648981f, -0.02955444f, 0.02583540f, 0.06434276f, -0.01869297f, 
    -0.11240805f, -0.05430254f, -0.06370437f, -0.11794131f, 0.00227306f, 0.04168919f, 0.01923056f, -0.00402918f, 
    0.03651227f, -0.06651671f, 0.04878541f, -0.01893656f, -0.08403451f, -0.12611854f, -0.01523782f, 0.01670024f, 
    0.07386499f, 0.08256900f, 0.11778143f, 0.07305339f, 0.09506323f, 0.22551639f, 0.11592624f, 0.06002988f, 
    -0.13697186f, 0.16001405f, 0.01072689f, 0.12913768f, -0.11297281f, -0.00932003f, 0.09798557f, -0.11852013f, 
    -0.10393096f, -0.11988308f, -0.02557301f, -0.05059244f, -0.05777424f, -0.06818559f, 0.02990120f, -0.07577617f, 
    0.21175683f, -0.10124709f, 0.06410424f, -0.15558009f, 0.01937964f, 0.04989132f, -0.00258689f, -0.08691555f, 
    -0.04657893f, 0.06088991f, -0.06506600f, -0.00849544f, -0.06273180f, 0.01717444f, -0.31809953f, 0.02813981f, 
    -0.07619686f, -0.06103849f, 0.01666384f, 0.12769242f, 0.10258221f, -0.00312512f, 0.13602959f, 0.05352807f, 
    0.42945814f, -0.06888933f, 0.13478090f, 0.16692308f, 0.01110022f, 0.06902353f, 0.05210355f, -0.13818011f, 
    -0.01947551f, 0.01149719f, -0.09567842f, -0.04423235f, -0.12422790f, -0.08474037f, -0.00066983f, -0.24862196f, 
    0.07827852f, -0.00486212f, 0.08010228f, 0.15722637f, 0.03687822f, 0.06629181f, 0.22167291f, 0.03118576f, 
    -0.08498734f, 0.22033513f, 0.06477457f, 0.30383545f, -0.01552001f, 0.13481158f, 0.09918365f, -0.00643559f, 
    -0.03996966f, 0.07269063f, 0.14016542f, 0.12381495f, -0.13796766f, -0.15848748f, -0.33401877f, -0.09237123f, 
    -0.24044326f, 0.00000427f, 0.12705600f, -0.06426392f, 0.09810752f, 0.05347826f, -0.07914988f, -0.16728064f, 
    -0.12043737f, -0.13258237f, 0.03439989f, -0.08837698f, 0.01399619f, -0.01225904f, 0.11918563f, -0.05506394f, 
    0.06008910f, 0.01299721f, 0.01685805f, 0.04709481f, -0.05171626f, 0.07783717f, -0.03571659f, -0.02819533f, 
    -0.00137616f, -0.02733277f, -0.03933951f, -0.01004465f, -0.00693001f, -0.00132185f, 0.05444561f, -0.02216887f, 
    -0.24910702f, 0.14203960f, -0.20762846f, 0.14794853f, -0.07275599f, 0.13596764f, -0.06944422f, 0.06478508f, 
    0.06840812f, -0.07116809f, 0.04466843f, 0.00416686f, 0.03650413f, -0.10913037f, -0.06173469f, -0.24839829f, 
    0.07343513f, -0.05048318f, -0.01721481f, 0.08496412f, 0.14102899f, 0.05708634f, -0.03106770f, 0.07652635f, 
    -0.16129537f, -0.20377131f, -0.03778033f, 0.01462756f, 0.04042641f, -0.01986806f, 0.15990604f, 0.07719243f, 
    0.11708840f, 0.07602872f, 0.04841754f, 0.21846138f, 0.19172259f, -0.09601715f, 0.04631932f, -0.11063699f, 
    0.04259863f, 0.15127292f, 0.10004033f, -0.00961515f, -0.03362224f, 0.08710788f, 0.02623774f, -0.05140029f, 
    -0.09323316f, -0.27586928f, 0.00149573f, -0.14696607f, 0.04366525f, 0.01928698f, 0.00000129f, 0.00150963f, 
    0.03806014f, 0.06083465f, -0.05956301f, -0.01240893f, -0.26072320f, -0.02402945f, 0.11114385f, 0.16169518f, 
    -0.04186364f, -0.02080349f, 0.00506260f, -0.02432198f, -0.10672664f, 0.05672454f, -0.13260518f, 0.10083967f, 
    -0.05701933f, -0.03166108f, -0.13470954f, -0.07834124f, 0.08714812f, -0.01197832f, 0.04206308f, -0.06234015f, 
    0.17930475f, -0.01476346f, 0.04876985f, 0.15957698f, -0.24049652f, 0.08641667f, 0.03888449f, -0.15691428f, 
    0.01091427f, 0.00214403f, 0.10386185f, -0.07058980f, 0.02741121f, -0.09803689f, 0.06149797f, 0.01798170f, 
    -0.11560005f, -0.14315028f, -0.15313606f, -0.02573235f, 0.18695149f, 0.09547137f, 0.12010449f, 0.10395619f, 
    -0.05084918f, 0.07140845f, 0.03834419f, 0.06514981f, 0.25885072f, 0.09216337f, -0.03641682f, -0.11869185f, 
    0.05847842f, 0.02505142f, 0.04896162f, -0.07464230f, 0.14951797f, 0.12718514f, 0.05671235f, 0.12311053f, 
    0.08859318f, -0.07130850f, -0.21898742f, -0.08239956f, 0.16677734f, 0.06543726f, 0.22515613f, -0.15657689f, 
    -0.00360986f, -0.03042901f, 0.01891848f, -0.03936477f, -0.55600232f, 0.24992281f, 0.12238638f, 0.00494764f, 
    -0.15957549f, 0.06607950f, -0.01207493f, -0.05929077f, 0.09943675f, 0.03960144f, 0.12255687f, 0.06753555f, 
    0.02966775f, -0.06846747f, -0.02249236f, -0.12159908f, 0.09376992f, 0.05860325f, -0.12914078f, -0.09310976f, 
    0.15673907f, 0.04157934f, -0.03188830f, -0.03975210f, 0.11326232f, 0.17699470f, 0.10557680f, -0.17518063f, 
    -0.07595724f, 0.07126488f, 0.10187528f, 0.01526196f, -0.06678580f, 0.05425708f, -0.01000405f, 0.01012656f, 
    0.02061462f, -0.05653867f, 0.23573659f, -0.08940394f, -0.00870181f, 0.04398673f, -0.08746791f, 0.06049859f, 
    0.10654746f, -0.01980548f, -0.00915520f, 0.12339035f, -0.00246388f, -0.15169755f, -0.00430678f, 0.04390562f, 
    0.12327792f, 0.02509887f, 0.05845796f, 0.11568308f, 0.08086179f, -0.07108227f, 0.14703450f, 0.06929425f, 
    0.08810695f, 0.03519463f, 0.11975930f, -0.15779488f, 0.04263130f, 0.05552646f, 0.05684867f, 0.09959323f, 
    0.08461677f, -0.06971359f, -0.03803084f, 0.02616379f, -0.12025666f, -0.09987833f, 0.10314015f, 0.22591586f, 
    -0.02902927f, -0.06317961f, 0.00198025f, -0.05025905f, 0.05194554f, -0.06278317f, 0.09715213f, 0.00963251f, 
    -0.10552372f, -0.05241159f, 0.02724790f, 0.06374026f, 0.05965795f, 0.07131936f, 0.01383217f, 0.00103408f, 
    0.05445191f, -0.03798718f, -0.00144134f, 0.07431283f, -0.01812716f, -0.03813793f, -0.02948160f, 0.01542195f, 
    -0.01216304f, 0.04227181f, 0.00323461f, -0.05899134f, -0.05946813f, -0.10679904f, -0.06100753f, 0.04342430f, 
    0.11563100f, 0.05856830f, -0.12604411f, -0.03016638f, -0.10908444f, 0.21063448f, 0.02700482f, 0.01939210f, 
    -0.00821491f, -0.06402549f, 0.12493028f, 0.12520279f, 0.17657062f, 0.20973690f, 0.03116745f, -0.30591792f, 
    -0.03883877f, 0.06843123f, -0.07511512f, -0.10517771f, 0.14264052f, 0.06573509f, 0.04894317f, -0.13637578f, 
    0.11636283f, 0.09534366f, 0.15659827f, 0.17994718f, 0.10991745f, -0.12218506f, -0.03769813f, 0.00518881f, 
    -0.00819440f, -0.02572580f, -0.02882244f, -0.01624496f, 0.11238901f, -0.14238165f, -0.10065421f, 0.23152947f, 
    -0.09396224f, -0.03048302f, -0.08865392f, 0.11451188f, 0.08866277f, -0.01833266f, -0.09824884f, -0.10060399f, 
    0.29873806f, 0.27832374f, 0.07770135f, 0.03931333f, 0.19707359f, 0.06075924f, 0.10771415f, 0.11289591f, 
    -0.00395508f, -0.07282139f, 0.06162796f, 0.01421174f, -0.19515152f, 0.27425388f, 0.03581087f, 0.21841231f, 
    -0.05493394f, 0.13028106f, 0.10799750f, -0.09992770f, -0.01235778f, -0.02716929f, -0.03660287f, 0.10301486f, 
    0.25490457f, -0.01426256f, 0.38583454f, 0.03941941f, 0.05896384f, 0.01966116f, -0.02130467f, 0.06284790f, 
    -0.04674819f, -0.21646550f, 0.03488157f, -0.15486497f, 0.51557440f, -0.46000803f, -0.12749289f, -0.05273528f, 
    0.04762603f, -0.09931179f, -0.12082333f, -0.05670783f, 0.05499236f, 0.12586184f, 0.03544476f, -0.07046866f, 
    -0.01373998f, 0.32940972f, -0.13343225f, 0.13995151f, -0.01696549f, -0.12841757f, 0.01009879f, -0.06148160f, 
    -0.15629087f, -0.29886436f, -0.04402554f, 0.07137647f, -0.11361068f, -0.16573781f, -0.06286722f, 0.30504191f, 
    -0.08023282f, 0.04972354f, 0.00107461f, 0.05678015f, 0.18438518f, 0.07398329f, 0.03164321f, 0.04627305f, 
    0.01086749f, -0.06517968f, -0.22855400f, 0.21988407f, -0.13021649f, -0.02354378f, -0.12915389f, -0.10149696f, 
    -0.10774807f, 0.04936813f, 0.08008859f, 0.06396563f, 0.05232199f, 0.04884073f, -0.06593623f, -0.01753068f, 
    -0.18059559f, -0.08336826f, -0.21618964f, -0.07400147f, -0.00205546f, 0.26225197f, 0.24872531f, 0.09221611f, 
    -0.30753353f, 0.07434339f, 0.02135130f, 0.14523031f, -0.11090387f, 0.02739759f, 0.05306169f, -0.00128581f, 
    0.09065843f, 0.01599489f, -0.00119356f, -0.01512713f, 0.11065325f, -0.05220425f, -0.04406844f, -0.24034907f, 
    -0.10504447f, -0.18989533f, -0.11363159f, -0.23031707f, 0.00722335f, -0.02895433f, -0.05058984f, -0.10047520f, 
    0.08460278f, 0.06703306f, 0.05902997f, 0.08689976f, 0.13175933f, 0.06535129f, 0.19359125f, -0.15427379f, 
    -0.04096190f, 0.16855256f, 0.10683312f, 0.26626462f, 0.10601126f, -0.27088952f, -0.10015818f, -0.34879848f, 
    -0.07592841f, -0.05768403f, -0.02610556f, -0.21548197f, -0.04359055f, -0.08659756f, -0.09070835f, -0.34085768f, 
    -0.02710527f, 0.03111837f, 0.10301749f, -0.00609025f, 0.13009049f, -0.05077187f, 0.26575670f, 0.05512740f, 
    0.15118766f, 0.08549390f, -0.04463277f, 0.03802552f, -0.26133838f, -0.04329184f, 0.24818234f, 0.24766827f, 
    -0.01713404f, -0.03229708f, 0.03133469f, 0.11159687f, 0.05527830f, 0.07952137f, 0.01096128f, 0.16830507f, 
    -0.09645288f, 0.36553171f, -0.13245970f, 0.19213703f, -0.04051692f, -0.04113641f, -0.02237932f, -0.00135946f, 
    0.08444479f, 0.15872107f, 0.23675527f, -0.10453823f, -0.02427373f, 0.10403606f, 0.06184158f, 0.10038903f, 
    0.01991867f, 0.07010308f, 0.12800042f, -0.04229639f, 0.02398323f, -0.01558470f, -0.09188592f, -0.00765653f, 
    0.05153636f, 0.06532075f, -0.28735965f, 0.16178642f, 0.07369000f, -0.12672265f, 0.00991032f, 0.17780644f, 
    0.11486825f, 0.04900415f, -0.01711015f, 0.01807663f, -0.19749647f, -0.13075741f, 0.06694900f, -0.25115159f, 
    -0.14846738f, -0.33101609f, -0.09002189f, -0.02594558f, 0.05670467f, 0.15787829f, -0.01295433f, 0.02318829f, 
    -0.30607861f, 0.01783135f, -0.41408381f, 0.07377616f, 0.00288170f, -0.03521454f, 0.00140982f, -0.09352343f, 
    0.04392622f, -0.09332844f, -0.02243030f, 0.01346748f, -0.17632304f, 0.14575604f, 0.07172508f, 0.03522312f, 
    -0.10679569f, -0.08209427f, -0.12471859f, 0.02929028f, 0.11256833f, -0.05179792f, -0.01613164f, 0.10863376f, 
    -0.06356073f, -0.30161434f, 0.09667075f, -0.39799979f, 0.00768769f, 0.06893345f, -0.18626823f, -0.14272225f, 
    0.12537147f, 0.08989359f, 0.15627901f, -0.02970779f, 0.01661647f, -0.00148924f, 0.12587275f, -0.03233882f, 
    0.08549721f, 0.05838925f, 0.06996587f, 0.07143924f, -0.08464376f, -0.09526894f, -0.00435363f, 0.06323589f, 
    0.16396073f, -0.18311405f, 0.19317530f, 0.37670156f, 0.15325561f, 0.26899311f, 0.03390954f, 0.04125489f, 
    0.12140323f, -0.03306513f, 0.01237976f, -0.06262790f, 0.28736404f, -0.19029249f, 0.18987557f, -0.02229412f, 
    -0.00842160f, -0.06533096f, 0.24906014f, -0.04779989f, 0.01093360f, 0.05073041f, 0.13940679f, -0.18602885f, 
    -0.16181511f, -0.25134033f, 0.19592224f, -0.18434381f, -0.04215506f, -0.09182653f, 0.07887123f, -0.00602970f, 
    -0.05931303f, -0.20187907f, -0.12753969f, 0.15741725f, 0.03640810f, 0.14127795f, 0.11757676f, 0.19917335f, 
    -0.02154110f, -0.02728926f, -0.09415063f, -0.22517252f, -0.01044387f, 0.13413034f, 0.13439250f, 0.08161802f, 
    0.05463748f, -0.05674624f, -0.04065258f, 0.09286316f, -0.03152891f, 0.09676186f, -0.08018045f, 0.06444895f, 
    0.03022560f, 0.08567423f, 0.04361426f, 0.00143871f, -0.46570492f, 0.10531720f, -0.33141512f, 0.03576488f, 
    0.03343808f, -0.01638704f, 0.12017650f, -0.02020081f, 0.01392359f, 0.10728370f, -0.02058452f, 0.12492858f, 
    -0.11241978f, 0.08585755f, 0.12986703f, -0.02033137f, 0.00809085f, 0.12645304f, 0.12273383f, 0.09218947f, 
    0.15799747f, 0.03288249f, 0.02282033f, 0.03926259f, 0.02519368f, 0.10980561f, -0.14111882f, -0.24240352f, 
    -0.04894499f, -0.15035623f, -0.05724492f, -0.10688388f, 0.02469934f, 0.01405270f, 0.02907723f, -0.02149252f, 
    -0.03913523f, 0.22714469f, -0.11322556f, 0.22269961f, 0.05552825f, -0.12566842f, -0.06344721f, 0.10212701f, 
    0.13895312f, -0.13727210f, 0.05500062f, 0.06575376f, 0.14302006f, -0.05003223f, -0.11606570f, 0.14615925f, 
    -0.02160553f, 0.22338095f, -0.19620049f, 0.01647881f, -0.12984739f, -0.20396625f, -0.18162045f, -0.09504227f, 
    -0.01188685f, 0.21678351f, 0.06111408f, 0.18398732f, 0.11607322f, -0.15396440f, -0.04534316f, -0.02458946f, 
    -0.01628029f, -0.09309052f, -0.10887777f, -0.01878777f, -0.05003281f, 0.28930277f, 0.01754176f, 0.21065770f, 
    -0.19163986f, -0.16071060f, 0.22790617f, -0.25927186f, 0.03758436f, 0.22464074f, 0.15557596f, 0.23532139f, 
    -0.29957837f, -0.06072379f, 0.00927082f, 0.13138683f, 0.01769421f, -0.09059745f, 0.00781248f, -0.06783988f, 
    0.16415918f, -0.16374093f, -0.12582390f, 0.08535039f, 0.82931513f, -0.08786007f, 0.01521635f, 0.02398387f, 
    0.00661862f, -0.06128713f, -0.12971795f, 0.07410429f, 0.07420189f, -0.06026883f, 0.08236942f, 0.04962238f, 
    0.10282882f, -0.24007896f, 0.16622612f, -0.11821043f, 0.14957853f, -0.07385901f, 0.03928959f, 0.11146629f, 
    -0.04746197f, -0.13780472f, -0.09685902f, -0.07997255f, -0.01580839f, -0.12054335f, 0.06440559f, 0.11946321f, 
    0.09289027f, 0.12405915f, -0.01161813f, 0.00215262f, 0.05133930f, 0.09399337f, 0.14282680f, 0.13657062f, 
    0.11219072f, 0.10333936f, 0.11784688f, 0.12069395f, -0.05502648f, 0.17822176f, -0.12363208f, 0.02423608f, 
    -0.02680663f, -0.19437361f, 0.00162757f, 0.04408389f, 0.14521055f, -0.09532619f, 0.23468484f, -0.04258316f, 
    -0.11812242f, -0.19394316f, 0.11716425f, 0.00783909f, 0.01559963f, 0.15420909f, 0.16251229f, 0.26349768f, 
    -0.11708853f, -0.01562499f, 0.14307652f, -0.06720467f, -0.09258346f, 0.08813414f, 0.14625837f, -0.00140576f, 
    0.00279404f, -0.15699680f, 0.02878654f, 0.11011081f, 0.26158810f, 0.17144413f, -0.00654608f, 0.13852069f, 
    -0.08188599f, -0.16300641f, 0.09161262f, -0.36486700f, -0.09992994f, -0.02465172f, 0.16102122f, -0.09447252f, 
    0.37000808f, 0.11349194f, -0.10425284f, 0.04006106f, 0.09237957f, 0.02877179f, -0.02353319f, 0.00792614f, 
    0.06751239f, 0.26130247f, 0.17431915f, 0.20156203f, -0.35564643f, 0.01978244f, -0.28110975f, 0.05916977f, 
    -0.00563140f, -0.17379266f, -0.00340531f, -0.17223318f, -0.07227420f, -0.09510668f, -0.22250785f, -0.21199484f, 
    -0.19709431f, 0.10429582f, -0.24313536f, 0.15920621f, 0.09668826f, 0.17229401f, 0.05114482f, 0.12061670f, 
    0.01422720f, 0.02058677f, 0.07832984f, 0.12351170f, -0.00387404f, 0.15874092f, 0.22298147f, -0.13883114f, 
    -0.03841744f, -0.15469617f, 0.11452344f, 0.01799519f, 0.11012784f, -0.06608164f, 0.00146574f, 0.03468715f, 
    -0.05611775f, -0.13658629f, -0.16289183f, 0.07744825f, -0.00513145f, 0.02919570f, -0.04571276f, -0.09663413f, 
    -0.18742794f, 0.10387362f, -0.10485186f, -0.06243761f, 0.12996274f, 0.22938639f, 0.19307433f, 0.06041683f, 
    0.08657230f, 0.04049151f, 0.02635988f, -0.05823988f, -0.04263056f, -0.00817731f, 0.12981702f, -0.03403385f, 
    -0.24389608f, 0.12405182f, -0.10237424f, 0.06749990f, -0.03734914f, -0.12966911f, -0.04364463f, -0.06287393f, 
    0.05847121f, 0.07555223f, 0.07942749f, 0.10881259f, 0.09451753f, -0.31527466f, -0.21831444f, -0.04057990f, 
    0.05762048f, 0.00803505f, 0.05053845f, 0.23421466f, 0.03278933f, -0.12137326f, -0.14640345f, 0.12577440f, 
    -0.17534754f, 0.32260191f, -0.00158925f, 0.09776492f, -0.03991424f, -0.12931255f, -0.16161983f, -0.06744031f, 
    -0.03105893f, 0.05429953f, 0.07047421f, 0.00858605f, 0.19425759f, 0.14554308f, -0.09819830f, -0.03057767f, 
    -0.15359257f, 0.12073752f, -0.00113545f, 0.28973535f, -0.01799727f, -0.09388995f, -0.27644676f, -0.10244550f, 
    0.00794055f, 0.05118004f, 0.15220778f, 0.15688762f, -0.20243341f, 0.07471370f, 0.23608251f, -0.06012577f, 
    -0.08796042f, 0.01034087f, 0.00699522f, -0.04255971f, 0.06731577f, 0.14735357f, 0.04835691f, -0.00654761f, 
    0.16418496f, 0.01584522f, 0.07537782f, 0.02066634f, 0.10109278f, -0.04324251f, -0.00675399f, -0.05165387f, 
    0.04910041f, 0.17068569f, 0.14184269f, -0.21439958f, 0.03016575f, 0.05475415f, 0.12096889f, -0.09347443f, 
    0.02392044f, 0.04920117f, -0.22831146f, 0.05220877f, -0.22539771f, -0.13177107f, -0.13679303f, -0.10909230f, 
    0.06139960f, 0.03696363f, 0.02265869f, 0.02837169f, -0.00985414f, -0.02502133f, -0.01572780f, 0.01710013f, 
    0.24241871f, 0.05793716f, -0.15430313f, 0.10914051f, 0.07844210f, 0.29247668f, -0.02449708f, -0.00033532f, 
    -0.09641288f, -0.08641548f, -0.00274184f, -0.00242350f, 0.08154228f, 0.02556828f, 0.01127693f, -0.27700993f, 
    -0.02209943f, 0.01798855f, -0.00157587f, 0.05732874f, 0.01879169f, 0.18706207f, -0.00705115f, 0.08328784f, 
    0.12050314f, -0.13349830f, -0.08590010f, -0.21192162f, 0.08805019f, 0.03388967f, 0.10544476f, 0.05572462f, 
    0.01745762f, 0.03353963f, -0.14517686f, -0.07374959f, -0.12546660f, -0.01001447f, 0.09190882f, 0.06146855f, 
    0.02584166f, 0.06677189f, -0.14833117f, 0.07076014f, -0.00912049f, 0.02294899f, -0.03812883f, 0.02772474f, 
    0.12379294f, 0.09392995f, 0.08763845f, 0.20317808f, -0.01367370f, -0.02771321f, -0.07647274f, -0.03768172f, 
    0.11075306f, -0.04377853f, 0.07079593f, 0.14274357f, 0.24525021f, -0.02978664f, -0.04523199f, 0.06647062f, 
    0.07099514f, 0.18153149f, -0.15108477f, 0.08755983f, -0.01190776f, 0.02283349f, -0.08724963f, 0.04197288f, 
    0.16940644f, -0.18602581f, 0.07032764f, -0.17516871f, 0.03879478f, -0.18283936f, -0.05573301f, -0.13212390f, 
    -0.02099967f, -0.00980726f, 0.04672803f, 0.08701106f, 0.13825689f, -0.07382365f, -0.09693771f, -0.04248929f, 
    0.06270397f, 0.11683457f, -0.00272066f, 0.07116548f, 0.00214412f, -0.11017136f, -0.03106849f, -0.13178810f, 
    -0.04456701f, -0.23177227f, 0.24948093f, -0.06754333f, 0.01766630f, -0.00615189f, 0.06499854f, 0.11778017f, 
    -0.09245688f, 0.01283659f, 0.03663081f, 0.00423410f, 0.27344742f, 0.22323541f, 0.27723882f, 0.00502624f, 
    -0.03433280f, 0.04929933f, 0.00409811f, 0.00035131f, 0.04222028f, -0.00770004f, 0.06622942f, 0.13860311f, 
    0.28101763f, -0.12756966f, -0.15015715f, -0.15098758f, -0.03510239f, -0.08260543f, 0.17881830f, -0.00402933f, 
    -0.06285507f, -0.03140603f, -0.04916070f, 0.10180274f, -0.13822564f, 0.02049495f, 0.23836382f, 0.17458609f, 
    0.04969554f, 0.14065361f, 0.06328566f, 0.00885514f, 0.09732746f, 0.19813587f, 0.15904894f, 0.07814135f, 
    0.12048761f, 0.29898691f, -0.36295304f, -0.03549477f, 0.19158819f, -0.06562756f, 0.01868694f, 0.07691866f, 
    -0.07378659f, 0.01875954f, -0.09157098f, 0.06649537f, 0.09162988f, 0.08297083f, -0.03832999f, 0.04707165f, 
    -0.01019733f, -0.03110729f, -0.05826594f, 0.06094830f, 0.12130684f, 0.16718574f, 0.06581410f, 0.20648716f, 
    -0.21040592f, 0.11215536f, -0.21630764f, -0.30747962f, -0.03123868f, -0.26427925f, -0.02188550f, 0.07921841f, 
    -0.02766368f, -0.15378274f, -0.06292447f, -0.00806443f, -0.03799220f, -0.06174671f, -0.18200763f, 0.03342257f, 
    -0.02870565f, 0.02948146f, 0.02132614f, 0.05707390f, -0.11473688f, 0.29267165f, 0.12434809f, 0.27223739f, 
    0.19725242f, 0.19578440f, 0.17921710f, 0.04747663f, -0.01787745f, -0.03725503f, -0.13695951f, -0.09003531f, 
    -0.08120125f, 0.07852754f, 0.17305842f, 0.08116507f, -0.18371780f, -0.14042152f, -0.05342453f, 0.11519204f, 
    0.04539821f, -0.00578625f, 0.02991003f, 0.03161357f, -0.02196856f, 0.02385905f, 0.08533346f, -0.05029600f, 
    0.08516774f, 0.03556976f, 0.02730862f, -0.04987124f, 0.06039548f, -0.04599296f, 0.08956008f, -0.00249745f, 
    -0.02116505f, 0.10002596f, 0.23190938f, 0.23658602f, 0.08458218f, 0.01446996f, 0.04913703f, -0.03389278f, 
    -0.07801308f, 0.07062260f, -0.03360051f, 0.03206312f, 0.12485334f, -0.07684657f, -0.07712724f, -0.06128801f, 
    -0.14823866f, -0.06341100f, -0.21503286f, -0.03733335f, 0.10410482f, 0.05889421f, -0.00512949f, -0.04032975f, 
    -0.02908434f, 0.05441993f, 0.12291355f, -0.02320531f, 0.07806466f, -0.03797413f, 0.34532499f, 0.03707533f, 
    -0.06834607f, -0.04391844f, 0.05679895f, 0.12328650f, -0.10722969f, -0.07503409f, 0.29611120f, -0.00082080f, 
    -0.02332795f, -0.00278699f, -0.10517222f, -0.15940383f, 0.04491583f, -0.22511825f, 0.11916071f, -0.13881893f, 
    0.00597313f, -0.03117082f, -0.01088953f, -0.23268415f, 0.12961324f, -0.10195316f, 0.02754281f, 0.11533001f, 
    0.01859763f, 0.02040738f, 0.04079230f, -0.04112625f, 0.00478479f, -0.24460199f, -0.12384696f, -0.11285632f, 
    0.01414882f, 0.48353624f, 0.05904083f, -0.07927679f, 0.04558831f, -0.03325276f, 0.03845640f, 0.01387628f, 
    -0.03223339f, 0.05306553f, 0.04257699f, -0.02686927f, -0.10820207f, 0.14773118f, 0.16813000f, -0.03456128f, 
    0.00505927f, 0.04369302f, 0.06482858f, -0.07407139f, 0.08190339f, -0.06235914f, 0.03786461f, 0.09138758f, 
    0.05240040f, 0.26075891f, 0.23703454f, -0.00718108f, -0.08474006f, -0.04190198f, 0.13187513f, -0.03202786f, 
    0.06295207f, -0.00162732f, 0.00995213f, -0.07794263f, 0.24689613f, -0.19686621f, 0.09083070f, 0.19897562f, 
    -0.11372185f, -0.09708276f, 0.09945644f, 0.18418118f, -0.02063592f, 0.06259581f, -0.04993393f, 0.00031923f, 
    0.09258948f, 0.22158232f, -0.03581014f, -0.05811777f, 0.02256676f, -0.06415946f, 0.05865142f, 0.06186424f, 
    0.06286538f, -0.21212354f, -0.12961489f, -0.07359468f, -0.03797327f, -0.05604892f, -0.03572436f, 0.06229802f, 
    -0.03446810f, 0.11542270f, 0.04651744f, -0.07009520f, -0.02298846f, 0.05736904f, 0.05948802f, 0.08744518f, 
    -0.06768416f, -0.09620674f, -0.11524967f, 0.10562387f, -0.11490683f, 0.14645368f, -0.04794366f, -0.08923212f, 
    -0.11154428f, -0.20862490f, 0.02474545f, 0.08653586f, 0.08603553f, 0.00379166f, -0.08842102f, -0.09850038f, 
    0.02977000f, -0.08213582f, -0.04780719f, -0.06772671f, 0.01176441f, 0.14256804f, 0.07353830f, 0.12640435f, 
    -0.10959698f, 0.10836682f, 0.17429949f, 0.17808257f, -0.00967181f, 0.04115331f, 0.06060802f, 0.02452203f, 
    -0.12359779f, -0.09529497f, 0.05555885f, 0.02560187f, 0.30950615f, -0.11403839f, -0.01110697f, -0.04935240f, 
    0.03095439f, -0.07024154f, 0.06041046f, -0.02373284f, 0.11518698f, -0.02706785f, -0.07832909f, -0.11380637f, 
    0.13349618f, -0.07074130f, -0.05463177f, 0.01541504f, -0.04677843f, -0.02675666f, 0.00943656f, -0.10625362f, 
    0.12104717f, 0.17843387f, 0.09450063f, 0.11545862f, 0.02910257f, 0.01603362f, -0.01321559f, 0.03096168f, 
    0.03063169f, 0.05692600f, -0.08003739f, 0.09779052f, 0.04725661f, -0.07552192f, -0.17873360f, 0.03577717f, 
    0.00439428f, -0.08983454f, -0.01075411f, 0.01184494f, 0.05312368f, 0.09982890f, 0.06453618f, -0.14138833f, 
    0.13400377f, 0.02131056f, -0.03486354f, 0.05957449f, -0.13615134f, 0.05164745f, 0.23706409f, -0.03435644f, 
    -0.03155449f, -0.07097666f, 0.05487971f, -0.07118316f, 0.02074616f, -0.01396311f, 0.05411006f, 0.01754403f, 
    -0.09855138f, 0.15060715f, 0.02174491f, -0.04981774f, 0.00285737f, 0.01715187f, 0.05930065f, -0.09862186f, 
    -0.09038948f, -0.00611504f, 0.13746633f, -0.00158961f, 0.06574772f, -0.02867096f, -0.02050729f, -0.04098888f, 
    0.03379160f, -0.05143928f, -0.03834301f, -0.10769348f, -0.02629989f, -0.08124407f, 0.07020859f, 0.02692593f, 
    -0.19231275f, 0.00689496f, -0.16370812f, -0.00002981f, 0.10583413f, 0.14972681f, 0.09498009f, 0.00899423f, 
    -0.00343185f, -0.07499932f, -0.17477275f, -0.07551803f, -0.16761099f, 0.22959447f, -0.21966369f, -0.25100261f, 
    0.06153910f, -0.10544160f, 0.00367037f, 0.14156680f, 0.20087485f, 0.10942447f, 0.07336977f, -0.00880474f, 
    0.11067539f, -0.16713628f, -0.10363506f, 0.11197210f, 0.27047026f, 0.28439543f, 0.21711777f, -0.16173759f, 
    0.00793977f, -0.24164611f, 0.04957644f, -0.07956951f, -0.32415703f, 0.30731791f, 0.20535821f, -0.00188328f, 
    0.00362558f, 0.05840216f, 0.12652646f, 0.22499821f, -0.13441639f, -0.03865481f, -0.00335789f, 0.03036166f, 
    -0.16567416f, -0.13229105f, -0.02185487f, 0.03808461f, 0.11768803f, -0.03924318f, -0.19263372f, -0.32806763f, 
    0.16212866f, 0.01366589f, 0.29670203f, -0.01178519f, -0.01115541f, -0.09981316f, -0.04768591f, 0.03950552f, 
    -0.13340552f, 0.05754061f, 0.04814658f, -0.05623271f, -0.04350235f, 0.00972231f, 0.04361642f, -0.02119103f, 
    0.23798729f, -0.20029080f, 0.25549886f, -0.04261596f, 0.07024999f, 0.10154589f, 0.03331080f, -0.02158554f, 
    0.07680706f, -0.04882354f, 0.03408398f, 0.13799508f, -0.09345047f, -0.08109578f, -0.02924426f, -0.17611556f, 
    0.07278757f, -0.00180927f, 0.12349800f, 0.02033364f, 0.07035659f, 0.11400940f, 0.19703165f, 0.05629003f, 
    -0.23352461f, 0.03005520f, -0.00957094f, 0.11256508f, 0.06483535f, 0.11706201f, -0.01377828f, 0.01769770f, 
    0.05451575f, -0.17633523f, -0.10745682f, -0.00159368f, 0.12496614f, 0.11493287f, 0.15286228f, -0.22067499f, 
    0.12805106f, -0.04946083f, -0.04121816f, 0.08633288f, -0.00084003f, 0.12343986f, 0.21500477f, 0.17036128f, 
    -0.20416236f, -0.10310640f, -0.08134292f, 0.13770910f, -0.04576385f, -0.04328857f, 0.13054988f, -0.03257034f, 
    0.05442047f, -0.00464740f, 0.14486414f, 0.03325805f, -0.09559461f, -0.04767640f, -0.30217806f, 0.00667918f, 
    0.07281131f, 0.14130044f, -0.01830613f, -0.00842992f, -0.10096408f, 0.00396248f, 0.01431422f, -0.19316106f, 
    0.06029837f, 0.07214020f, 0.15147220f, -0.00505925f, -0.06044787f, 0.16839202f, 0.09128534f, 0.00289156f, 
    0.00917922f, 0.00474302f, 0.08137141f, 0.11902976f, 0.00349813f, 0.10917050f, 0.07923373f, -0.05051339f, 
    0.12087469f, 0.05094215f, -0.16350295f, -0.15806215f, 0.05431797f, -0.02586830f, 0.07909139f, 0.00588907f, 
    0.24002051f, -0.10025559f, 0.13745064f, -0.06133065f, 0.08608233f, 0.00668972f, -0.00590616f, -0.02557305f, 
    0.04669164f, -0.14469093f, 0.07016540f, -0.03378444f, 0.29694018f, -0.02208294f, -0.09427238f, -0.22213809f, 
    -0.06195243f, 0.07884842f, -0.11775474f, -0.02274599f, 0.04088007f, 0.00502806f, -0.08392186f, 0.06880622f, 
    -0.11630191f, -0.15201208f, 0.08110322f, -0.01346452f, 0.03157623f, -0.00804586f, 0.05536391f, 0.01879120f, 
    0.02626562f, -0.06353913f, -0.10107703f, -0.05939217f, -0.18953867f, 0.46362495f, -0.04842331f, -0.01820866f, 
    -0.04668405f, -0.07994150f, 0.04900559f, 0.03400490f, 0.18743898f, -0.01660951f, 0.02984649f, 0.02391241f, 
    -0.06741858f, -0.43816277f, 0.22073962f, 0.12117375f, -0.01537733f, -0.06229853f, -0.04325027f, -0.13055517f, 
    -0.02382056f, -0.09395964f, 0.01403715f, -0.03770256f, 0.10824921f, -0.10624616f, 0.22204782f, 0.04157860f, 
    0.12817179f, 0.01189737f, 0.08409875f, 0.06298682f, -0.09504750f, 0.12032437f, 0.20581360f, -0.00024599f, 
    -0.04187639f, 0.06158096f, -0.00387207f, 0.21139532f, 0.00262958f, -0.01815668f, -0.20098644f, -0.04963324f, 
    0.01525589f, -0.03004491f, 0.13355882f, 0.07635122f, -0.10996544f, -0.01253510f, -0.12702088f, 0.11323538f, 
    0.03205783f, 0.15845972f, 0.11347102f, 0.02959200f, -0.00651777f, 0.05926203f, 0.02222014f, 0.09730291f, 
    0.09479413f, 0.17765938f, 0.05149166f, -0.21375364f, -0.05316923f, -0.02630638f, 0.02371654f, 0.01165494f, 
    -0.14752072f, -0.00700872f, 0.12406740f, 0.08239327f, -0.13635509f, -0.00285605f, -0.19504660f, -0.13160677f, 
    -0.01739869f, -0.01708892f, -0.02591396f, 0.04678937f, -0.03166313f, 0.25339857f, 0.08912743f, 0.17552324f, 
    -0.18663500f, 0.38962623f, -0.15719180f, 0.34980854f, 0.04433276f, 0.05906861f, -0.04959548f, -0.04857426f, 
    0.02037657f, 0.05567482f, 0.08971398f, 0.04431193f, 0.05047757f, -0.06862064f, 0.07778412f, -0.18958612f, 
    0.05647619f, 0.03241332f, -0.03697180f, 0.02202502f, 0.06536620f, -0.04951986f, 0.09208372f, 0.06341899f, 
    0.12069130f, 0.12777589f, 0.17122975f, 0.06883665f, -0.01063937f, 0.11812567f, 0.09343740f, 0.07673781f, 
    0.03649939f, 0.13168816f, 0.14231232f, 0.00292599f, 0.04403425f, -0.05939540f, -0.08612074f, -0.01027716f, 
    -0.13181938f, -0.01227763f, -0.03218173f, 0.04427628f, 0.02054647f, 0.04622064f, 0.02031607f, -0.11767855f, 
    0.00972043f, 0.05711032f, -0.12206925f, 0.00930424f, 0.01353264f, 0.06121287f, 0.11996419f, -0.07019068f, 
    0.08438873f, 0.05956003f, -0.05301284f, -0.01646942f, -0.16672342f, 0.18955414f, 0.19477910f, 0.09296769f, 
    0.12762977f, 0.14805786f, 0.00065686f, -0.09709618f, 0.04479687f, 0.08524095f, -0.02264032f, 0.14076392f, 
    0.03466666f, 0.00851863f, -0.06756750f, 0.27859274f, 0.01587739f, -0.06404973f, 0.03330801f, 0.09926271f, 
    0.03839490f, 0.04492953f, 0.03329601f, 0.00003827f, -0.14330468f, 0.02327435f, -0.06289255f, 0.05544507f, 
    0.14054735f, 0.18237802f, 0.19174030f, -0.04152757f, 0.04476399f, -0.01912855f, -0.04150004f, 0.01887098f, 
    0.47564408f, 0.25747567f, 0.05505853f, 0.27121258f, 0.03234706f, -0.03944754f, -0.03942945f, 0.00434396f, 
    -0.00646173f, -0.05064771f, 0.00480292f, 0.05906401f, 0.21194489f, -0.13258809f, -0.01019170f, 0.03483225f, 
    0.00042021f, -0.10743169f, 0.02820821f, 0.06463964f, 0.02477440f, 0.02589319f, 0.03559713f, -0.00196042f, 
    0.03166413f, 0.30974206f, -0.04921453f, 0.16555035f, 0.01270685f, -0.06330387f, 0.04201064f, 0.18374372f, 
    -0.04143064f, -0.05021503f, 0.08622605f, 0.01313356f, 0.21342096f, -0.03709446f, -0.15745023f, -0.01680604f, 
    -0.02687865f, -0.05365223f, -0.19994669f, 0.03559441f, -0.03277434f, -0.13855118f, -0.15002128f, 0.09850659f, 
    0.13117093f, -0.00291070f, 0.12222300f, -0.16391374f, -0.05387093f, -0.01974601f, 0.10248959f, -0.01345369f, 
    0.08223440f, 0.07564735f, 0.03635999f, 0.04810035f, -0.10186754f, -0.03077024f, 0.12604778f, -0.06989318f, 
    0.06065125f, 0.03631107f, 0.00564697f, 0.07974388f, 0.00205512f, 0.00262166f, 0.07341916f, 0.02244597f, 
    -0.36070767f, -0.04049760f, -0.05966276f, 0.30595973f, 0.01721641f, 0.10630196f, 0.11531467f, -0.11575007f, 
    -0.05232900f, -0.02624062f, -0.06908149f, -0.09125821f, 0.21214724f, 0.07146427f, 0.21617115f, 0.16596554f, 
    0.02151234f, 0.02240668f, 0.01005713f, -0.01090287f, 0.26252231f, 0.08959538f, 0.11245238f, 0.14781727f, 
    -0.29007807f, -0.77673596f, -0.30036205f, -0.53207552f, -0.05710813f, -0.00833495f, -0.01560687f, -0.14605801f, 
    0.00530067f, -0.02266476f, -0.03119499f, 0.02875374f, 0.20095599f, 0.21703836f, 0.08931621f, 0.17697684f, 
    0.02508533f, -0.05747135f, -0.05643304f, -0.06060523f, -0.00615538f, -0.02049305f, -0.02542564f, -0.08526969f, 
    0.05563301f, -0.04701817f, 0.00592957f, 0.08372345f, -0.07836016f, -0.00822050f, -0.06247719f, -0.01926559f, 
    -0.03568086f, -0.10258919f, -0.12009196f, -0.03132715f, -0.07252800f, 0.15047371f, -0.05531793f, -0.04904350f, 
    -0.01994020f, -0.01786881f, -0.03638861f, -0.03391299f, -0.07125086f, 0.02926708f, 0.01018693f, -0.01705068f, 
    -0.21437238f, 0.02469648f, 0.11361647f, -0.06676115f, -0.00066702f, 0.04494051f, 0.06878221f, 0.14378124f, 
    -0.03640248f, -0.02100143f, -0.01984924f, -0.00512635f, 0.09802770f, -0.48097742f, -0.41314998f, 0.08939482f, 
    -0.06093012f, -0.06395876f, 0.05757613f, 0.11619589f, 0.10105718f, 0.02842244f, -0.00295941f, 0.01583733f, 
    -0.11963309f, 0.11686122f, -0.25824603f, -0.05842390f, 0.08156750f, 0.03989322f, 0.04296806f, 0.04223106f, 
    -0.09438928f, 0.02769243f, -0.09467056f, -0.19408216f, 0.21516635f, 0.01298169f, 0.13882513f, 0.00055023f, 
    -0.13785635f, -0.09253813f, 0.09670027f, -0.19549671f, 0.08364845f, 0.05508387f, 0.04257800f, 0.05600153f, 
    0.04027475f, -0.06727049f, -0.16683593f, 0.07931116f, -0.00994763f, 0.11543298f, -0.00005879f, 0.02882611f, 
    0.10251566f, -0.02463210f, 0.03858219f, 0.01670211f, -0.08694924f, -0.04497873f, 0.06705373f, 0.09558445f, 
    -0.00894617f, 0.00403188f, -0.07210708f, -0.03498780f, 0.07520074f, -0.19514531f, -0.02076174f, -0.03329305f, 
    -0.05351600f, -0.02191601f, -0.00690328f, 0.10975657f, -0.00018731f, 0.29777732f, 0.07577708f, 0.03315586f, 
    0.09220353f, 0.12447275f, 0.07753434f, 0.00357740f, 0.18360327f, 0.12368128f, 0.12603053f, 0.08150373f, 
    0.14543653f, -0.03600903f, -0.03447253f, -0.06662562f, 0.08585542f, 0.09441569f, 0.04672033f, 0.08317190f, 
    0.04893043f, 0.00959256f, 0.09184743f, -0.14396867f, -0.06692787f, 0.17104872f, 0.12460776f, 0.00890244f, 
    0.09876382f, -0.21362205f, 0.21084952f, 0.10162789f, 0.06281370f, -0.08838712f, 0.05546504f, -0.12745005f, 
    0.24956539f, 0.11608247f, 0.08366778f, -0.05837167f, -0.14201507f, -0.16473959f, -0.15839612f, 0.03680776f, 
    -0.14479871f, -0.01325767f, 0.23199533f, 0.26976007f, 0.01568426f, 0.17042777f, -0.13673261f, -0.27202594f, 
    -0.00143342f, -0.18364038f, 0.00487827f, 0.04165779f, 0.01477694f, -0.06488392f, -0.05647868f, 0.01015322f, 
    0.08636793f, 0.02912697f, 0.05124110f, -0.04555533f, -0.00309464f, -0.17321613f, 0.00233286f, -0.05459190f, 
    0.09526833f, -0.14838028f, 0.26719424f, -0.07200875f, 0.08723788f, -0.02131542f, 0.17944799f, -0.05637290f, 
    0.02879232f, -0.10546381f, 0.00398225f, 0.05708351f, 0.04374260f, 0.10151240f, 0.03279550f, 0.01549800f, 
    0.04713249f, 0.08569622f, 0.02518464f, -0.00548292f, -0.05529709f, -0.01966725f, -0.00453658f, -0.11818343f, 
    -0.02831127f, -0.10686049f, -0.09565536f, -0.02790502f, -0.14708304f, -0.18788351f, -0.08718576f, -0.13818279f, 
    -0.10492686f, 0.08106723f, 0.00857393f, -0.01709881f, 0.03992805f, -0.02010025f, 0.00196043f, -0.02953784f, 
    -0.02249319f, -0.03500993f, 0.06676273f, -0.01346826f, 0.05508334f, 0.13489096f, -0.00839482f, -0.02741292f, 
    -0.16696255f, 0.00296779f, -0.03523772f, -0.23309417f, 0.18863037f, 0.03550397f, -0.12341505f, -0.12540798f, 
    -0.13805863f, -0.18324903f, 0.01306596f, -0.11022686f, 0.14187302f, -0.05522718f, -0.03384997f, -0.10202537f, 
    -0.01308316f, -0.09460796f, 0.05254208f, -0.05155885f, 0.19644214f, 0.00779535f, -0.13472240f, 0.20432983f, 
    0.21876924f, -0.25110754f, 0.09084130f, 0.13318905f, 0.00435895f, 0.03998961f, 0.04300217f, 0.22904119f, 
    -0.03478406f, -0.02319887f, -0.22214161f, 0.15525235f, 0.21437365f, 0.12241757f, 0.00635486f, 0.03928034f, 
    -0.00818766f, 0.19245814f, -0.00365840f, 0.04269531f, -0.01038823f, 0.08867784f, 0.00099838f, 0.15310208f, 
    -0.24511704f, -0.09945296f, 0.18012404f, 0.19516617f, -0.08189368f, -0.01411641f, -0.03773538f, -0.13520567f, 
    -0.04500391f, 0.00405739f, 0.01056260f, 0.09594756f, 0.08044981f, 0.05497886f, -0.06938790f, 0.18200833f, 
    -0.01290043f, 0.06015887f, -0.04717559f, -0.12636641f, -0.03515901f, -0.03565140f, 0.05745089f, 0.09377477f, 
    -0.34492880f, -0.18223092f, 0.03067062f, 0.08253593f, 0.07243531f, -0.08016463f, -0.00997025f, 0.10882802f, 
    -0.13636953f, 0.14306812f, -0.00655445f, 0.04002294f, 0.55405557f, -0.12476911f, -0.03167237f, -0.08370767f, 
    0.03419550f, 0.24567164f, 0.13294518f, 0.08199300f, 0.03448492f, 0.09627738f, -0.06449351f, -0.08171199f, 
    0.00013056f, -0.07740092f, 0.15110350f, 0.17020200f, 0.02283424f, 0.07680718f, 0.10762266f, 0.17706114f, 
    -0.38404486f, 0.01632714f, 0.06234198f, -0.12552737f, 0.09058582f, 0.06598854f, -0.07536369f, 0.04426564f, 
    0.21684441f, 0.11307731f, -0.02164679f, 0.09388201f, -0.09294871f, 0.01978424f, 0.02361854f, 0.01238959f, 
    -0.00593096f, 0.46734154f, 0.08285487f, -0.34439948f, 0.03136238f, -0.16812032f, 0.05003421f, 0.04837964f, 
    -0.17367637f, -0.08249331f, -0.08706030f, 0.06989820f, -0.23629706f, 0.14390317f, 0.00065598f, -0.09442902f, 
    -0.06837041f, -0.12692647f, -0.13393989f, -0.07235292f, -0.02878452f, -0.03263915f, -0.13487761f, 0.11575627f, 
    0.17235760f, 0.10910989f, -0.40879899f, 0.12030982f, 0.03443925f, 0.22189139f, -0.01350619f, -0.07755820f, 
    -0.14826204f, 0.18581417f, 0.04284738f, -0.08736378f, 0.11606668f, -0.05527423f, 0.10022320f, -0.19229922f, 
    -0.14874622f, -0.12834051f, 0.08265233f, 0.01779124f, -0.00279663f, 0.07691877f, 0.06638566f, 0.04864755f, 
    0.18446550f, 0.17030042f, 0.04805927f, -0.14711398f, 0.00503104f, 0.09525229f, -0.07006936f, 0.13494125f, 
    0.05097746f, 0.04295914f, -0.09582550f, -0.14909524f, -0.08854944f, -0.10274989f, 0.14028935f, 0.08729926f, 
    -0.05237364f, 0.01466542f, 0.03643719f, -0.10293423f, -0.00568284f, 0.01763161f, -0.04161640f, 0.01118119f, 
    0.08618966f, 0.07463585f, -0.06548076f, 0.09462535f, 0.13428611f, 0.04974510f, -0.02838717f, -0.08650331f, 
    -0.04250897f, -0.02236178f, -0.04414344f, -0.06439400f, 0.26292261f, -0.10004451f, -0.12320778f, 0.11344929f, 
    0.06676876f, 0.08101446f, 0.06138898f, 0.17565787f, -0.19852261f, 0.00174021f, -0.04982675f, 0.02298265f, 
    -0.08669916f, -0.03483647f, 0.05521215f, 0.01051830f, 0.02171110f, -0.04579622f, -0.01034199f, -0.07139950f, 
    -0.04176701f, 0.01504481f, -0.07195445f, 0.00518690f, -0.07667364f, 0.04350647f, -0.06409385f, -0.08267361f, 
    0.04768564f, -0.05506433f, 0.01317344f, -0.00142678f, 0.03819102f, 0.05466763f, -0.07714027f, -0.05194286f, 
    -0.06040616f, -0.01637927f, -0.02103626f, -0.01192374f, 0.01966594f, 0.02486976f, -0.05214652f, -0.04805736f, 
    0.05343759f, -0.02185483f, 0.05240104f, 0.01253655f, -0.01457961f, 0.04066344f, -0.07037542f, 0.00886477f, 
    -0.01831151f, 0.05366420f, 0.03599005f, 0.03230774f, 0.04247820f, -0.07135734f, 0.03968650f, -0.04690224f, 
    -0.03189635f, -0.06361172f, -0.02086452f, -0.07358709f, 0.00946835f, -0.05989121f, -0.03755765f, -0.03117826f, 
    -0.06018377f, -0.04143360f, -0.01169672f, -0.01975001f, -0.06082712f, 0.00281036f, 0.04221594f, -0.07311071f, 
    0.00960366f, -0.07428467f, -0.04497309f, 0.05618301f, -0.01854278f, -0.00377025f, 0.00000283f, -0.05576775f, 
    -0.04282415f, -0.01642724f, -0.04296312f, -0.04743988f, -0.05454188f, -0.07241527f, -0.05937369f, 0.00753564f, 
    -0.03630430f, -0.08990429f, -0.03855789f, -0.01539388f, -0.07013705f, -0.02978854f, -0.08659657f, -0.05409540f, 
    -0.05971499f, -0.05250279f, -0.01607084f, -0.03675782f, 0.03530242f, -0.03598836f, -0.02729249f, 0.03647525f, 
    -0.03084994f, 0.05629850f, -0.07365521f, -0.03095522f, -0.07143629f, -0.02499451f, -0.02299775f, 0.01917051f, 
    0.05577254f, -0.00842358f, -0.00485564f, 0.03546079f, 0.00998987f, 0.03648432f, -0.08048961f, 0.01396857f, 
    0.00286968f, 0.02306304f, -0.00886407f, 0.02323937f, -0.02466129f, -0.04068780f, -0.00790443f, -0.04629452f, 
    -0.03737433f, 0.03873760f, -0.01405980f, -0.01857539f, 0.00104059f, -0.02698980f, -0.00064745f, 0.04009298f, 
    -0.04131263f, -0.03001907f, -0.03060880f, -0.07094902f, 0.06006925f, -0.04468339f, -0.00395658f, -0.03018091f, 
    -0.00335823f, -0.05622000f, -0.05507576f, 0.01091708f, 0.06145588f, -0.06159113f, -0.04672942f, 0.00923621f, 
    -0.05096731f, -0.07968144f, 0.05639768f, -0.08224679f, -0.03357814f, 0.00913650f, 0.05561522f, -0.05391987f, 
    0.06205229f, -0.07023621f, 0.00304681f, 0.00499272f, 0.02490352f, -0.04859791f, 0.01881355f, 0.00770509f, 
    0.03777504f, -0.02319179f, -0.06446931f, -0.02588067f, 0.05065852f, -0.06948064f, -0.08678067f, 0.00612854f, 
    -0.03582248f, -0.01001393f, -0.04624012f, 0.00421421f, -0.02235516f, 0.03247081f, 0.00467269f, -0.06632959f, 
    -0.06062454f, -0.05005735f, 0.00429330f, -0.00045831f, -0.05003611f, -0.05404846f, 0.00139821f, -0.06232848f, 
    -0.06529005f, -0.08112612f, -0.01563098f, 0.00585024f, 0.01471575f, 0.05161373f, 0.04705063f, 0.04614245f, 
    0.16619807f, -0.33061272f, -0.08859271f, -0.07032133f, 0.09361567f, -0.07220604f, 0.20170531f, -0.06549608f, 
    -0.06190744f, -0.15117951f, -0.08877231f, -0.06934899f, 0.28917983f, -0.00969134f, 0.10916574f, 0.08264772f, 
    0.09539390f, 0.13809535f, -0.04817044f, -0.05152620f, -0.02345341f, -0.07824068f, -0.05226304f, 0.13018036f, 
    -0.20824336f, 0.01865320f, 0.08272876f, -0.02467298f, -0.08099758f, -0.14400560f, -0.00680947f, -0.04095740f, 
    -0.04213827f, -0.02868969f, 0.04826886f, -0.06230057f, -0.21695055f, 0.08767498f, 0.32714888f, 0.13064098f, 
    -0.05244863f, -0.01832985f, -0.02178021f, -0.11105699f, -0.13053633f, 0.03604928f, -0.00938733f, 0.18181500f, 
    -0.42165992f, 0.30036631f, 0.22908023f, -0.01718872f, -0.10623833f, 0.07533061f, -0.07369458f, 0.16792995f, 
    -0.05583464f, 0.14194272f, 0.00647790f, 0.13195689f, 0.26347584f, -0.28262511f, 0.13332689f, 0.22983673f, 
    0.08160100f, 0.02715769f, 0.18787785f, 0.17644897f, -0.00642777f, 0.10934636f, -0.03318631f, 0.00073142f, 
    0.11462639f, 0.13464004f, -0.04988476f, 0.03764689f, -0.04098873f, 0.01953048f, 0.12272759f, 0.10830168f, 
    -0.10258927f, -0.06272271f, -0.11410495f, 0.01191647f, 0.07876235f, 0.14233442f, 0.03429320f, 0.11676744f, 
    0.11407617f, -0.07372523f, -0.00627460f, -0.02130031f, -0.01603055f, 0.02391516f, 0.00644611f, 0.13038565f, 
    -0.03558430f, 0.26074943f, -0.11754812f, -0.05689082f, -0.01108323f, -0.04786641f, 0.11330733f, -0.02267647f, 
    -0.09667236f, -0.09051439f, 0.10890878f, 0.03404227f, -0.27468678f, -0.09654122f, -0.23201464f, -0.14420576f, 
    -0.03507999f, -0.03947936f, -0.05631347f, -0.10462637f, -0.10889577f, 0.23967186f, -0.05645024f, 0.23418880f, 
    0.01232644f, 0.18068224f, 0.19288091f, 0.27049726f, -0.00604122f, 0.06511519f, -0.00366215f, -0.10505485f, 
    -0.05379393f, 0.05385835f, -0.04222383f, 0.08032661f, 0.01522527f, -0.21247678f, -0.22981437f, -0.20078336f, 
    -0.09845299f, 0.00424735f, 0.08143640f, 0.00933836f, 0.03868118f, -0.08695937f, -0.08658447f, -0.15439348f, 
    0.25417116f, 0.05243550f, 0.03111946f, -0.00933099f, -0.00763664f, 0.05491717f, -0.01721116f, -0.11254668f, 
    -0.08168652f, 0.12563738f, 0.01675964f, 0.10567348f, -0.02162895f, -0.15183565f, 0.18597019f, -0.04618114f, 
    -0.06041745f, 0.11038477f, -0.04897529f, -0.00908403f, 0.00864365f, -0.01929300f, -0.05023365f, -0.06071322f, 
    0.06276729f, 0.01548022f, 0.00476859f, 0.04569695f, 0.06746010f, -0.10377663f, -0.04003155f, -0.05084949f, 
    0.02110282f, -0.05687229f, 0.03141192f, -0.03116300f, 0.06633327f, 0.17005469f, 0.31592819f, 0.21174294f, 
    0.00820227f, 0.03002560f, 0.18745847f, 0.10023763f, -0.06428669f, -0.01056077f, 0.04537214f, 0.08724650f, 
    -0.01023466f, 0.04643499f, -0.04264998f, 0.03505815f, 0.01777370f, -0.08069688f, 0.01426635f, -0.00099957f, 
    0.01156179f, -0.01672603f, -0.00349544f, 0.01910233f, -0.04346256f, -0.00660719f, -0.04964399f, -0.07097788f, 
    -0.01247266f, 0.04066530f, -0.00694319f, -0.07045136f, -0.07016070f, -0.05320892f, -0.01499672f, -0.03705379f, 
    -0.05302866f, -0.03522159f, -0.02230845f, 0.01052541f, -0.06320102f, 0.00121958f, -0.06426657f, -0.01704508f, 
    -0.00084381f, -0.00733195f, -0.08255997f, -0.02890127f, 0.03380690f, -0.07294563f, -0.07061365f, 0.01302522f, 
    -0.04802503f, 0.04084619f, 0.00391674f, 0.00956527f, -0.07818968f, 0.00453264f, 0.04233997f, 0.02026754f, 
    -0.06815770f, -0.04082407f, -0.07727556f, 0.01641877f, -0.02291300f, 0.01318128f, 0.01039964f, 0.03905437f, 
    0.04065009f, -0.05383051f, 0.00680515f, -0.05716830f, 0.04643794f, 0.04529418f, 0.00456844f, -0.06234713f, 
    -0.07962685f, -0.09904237f, -0.07012672f, -0.07110807f, -0.07732780f, -0.09284575f, 0.03484746f, -0.07310236f, 
    0.05563666f, -0.02239810f, 0.01917946f, 0.02414890f, -0.06646437f, 0.02408183f, 0.00075330f, -0.09594998f, 
    -0.08127875f, 0.01510780f, -0.03018272f, 0.03615248f, -0.08286898f, -0.09066736f, 0.04163744f, -0.03657309f, 
    -0.06628740f, -0.07730143f, -0.04153094f, 0.07045074f, -0.06657976f, 0.03786882f, -0.02497519f, -0.02271561f, 
    -0.08126394f, -0.09412052f, 0.04654872f, 0.01170433f, 0.00982720f, 0.06354405f, -0.08504302f, -0.03597522f, 
    0.05272242f, -0.07410319f, 0.05491538f, -0.00710888f, -0.04438684f, 0.03701727f, -0.00696972f, -0.02199357f, 
    -0.08737723f, 0.00671116f, 0.02853734f, -0.06043640f, 0.02486859f, 0.01140662f, 0.01732957f, -0.10250558f, 
    0.05803167f, -0.02327653f, -0.05999925f, 0.01200539f, -0.02092857f, -0.02027376f, -0.05039465f, 0.06319362f, 
    0.04173646f, -0.04845149f, -0.01845137f, -0.06913090f, 0.00798853f, -0.06665897f, -0.02969693f, 0.03264511f, 
    0.04395735f, -0.08147459f, -0.01311211f, -0.05461565f, -0.01656356f, 0.01018165f, -0.01112286f, -0.07219344f, 
    -0.02645518f, -0.01577609f, -0.06179871f, 0.01287377f, -0.03973500f, 0.03209340f, 0.02746810f, -0.03111655f, 
    0.02189412f, 0.06049522f, 0.01487670f, -0.00057931f, -0.02755436f, -0.00765045f, 0.02357809f, -0.03259791f, 
    0.03923416f, -0.01572544f, -0.05443592f, 0.05136957f, -0.00329450f, 0.01358791f, 0.01428783f, -0.09071440f, 
    -0.03420307f, -0.07955553f, 0.00450285f, -0.03545925f, -0.08274785f, -0.08791561f, -0.00647432f, 0.06486417f, 
    0.01067988f, 0.02282084f, 0.06387577f, -0.00509051f, 0.03361155f, 0.00761137f, 0.01302214f, -0.07916125f, 
    0.01286421f, -0.02230911f, 0.04209351f, -0.01032525f, -0.06722806f, 0.06222733f, -0.04406822f, -0.05262594f, 
    0.05953757f, 0.10705329f, 0.12751655f, 0.10679859f, 0.00148394f, 0.14757727f, -0.18996021f, 0.21360205f, 
    0.13357632f, 0.05002018f, 0.14343987f, 0.04844885f, 0.17733122f, -0.12398303f, -0.17058529f, -0.02462975f, 
    -0.01292850f, 0.06752115f, -0.11534906f, 0.08729514f, 0.00938147f, 0.15175933f, -0.07066997f, 0.05495395f, 
    0.02876400f, -0.00719421f, 0.38671532f, 0.06665430f, -0.05456144f, 0.09063910f, 0.04382696f, -0.13978617f, 
    -0.07442973f, -0.05126420f, 0.07651588f, 0.08499648f, -0.15016861f, 0.29401571f, 0.18763001f, 0.10171973f, 
    -0.03647037f, 0.03237136f, 0.01579838f, -0.14521277f, 0.02902742f, 0.10598286f, 0.06051460f, 0.00212872f, 
    -0.16122992f, -0.53867298f, 0.25910828f, -0.07357850f, -0.09616923f, -0.08046212f, -0.14404097f, 0.10409874f, 
    -0.03019493f, 0.00910002f, -0.08087397f, 0.11264303f, 0.60463440f, -0.07884170f, 0.01724304f, 0.01475951f, 
    0.19427547f, -0.03027032f, 0.00080431f, -0.03732939f, -0.04674854f, 0.02610289f, 0.14477076f, -0.00901927f, 
    -0.14541924f, -0.17483670f, -0.03374697f, 0.08540546f, 0.01780322f, 0.02833689f, -0.03357641f, 0.05318192f, 
    -0.11359841f, 0.08280718f, 0.04422090f, 0.13760109f, -0.21714024f, -0.16684306f, -0.09455393f, 0.07802793f, 
    0.01762720f, 0.00255615f, -0.04551206f, 0.04015866f, -0.06690046f, -0.05780600f, 0.04065492f, 0.04442507f, 
    0.12948835f, -0.01389455f, -0.24759646f, -0.01622538f, 0.12688041f, -0.01194666f, -0.06120082f, 0.16625156f, 
    -0.01509848f, -0.01106043f, 0.00785732f, 0.02559519f, 0.00291620f, 0.14468738f, -0.07597682f, -0.06575606f, 
    -0.04802140f, 0.01213726f, -0.03654029f, -0.05899260f, -0.07630514f, 0.30852324f, 0.13770942f, 0.08520588f, 
    -0.10818494f, -0.13757101f, -0.06152118f, -0.05221010f, 0.02012087f, -0.03905708f, 0.12783803f, -0.06337301f, 
    0.01309638f, -0.07992484f, 0.13596076f, 0.06602511f, -0.00038073f, 0.22069287f, -0.05639188f, -0.16659822f, 
    -0.07566752f, 0.00293258f, 0.04244653f, -0.08922328f, -0.03755769f, 0.03021532f, 0.02876956f, 0.03825465f, 
    -0.00721170f, 0.23422755f, 0.14841639f, 0.04159592f, 0.03154999f, 0.05083245f, 0.00203652f, -0.05823090f, 
    0.03655906f, -0.00636378f, 0.23291062f, 0.00004335f, -0.04734171f, 0.02423547f, -0.05442920f, -0.10883452f, 
    -0.12310744f, -0.13314830f, 0.12278287f, -0.08823379f, 0.01651426f, -0.07549847f, 0.16797040f, -0.11776946f, 
    -0.15478802f, -0.09115918f, -0.13618386f, 0.03053447f, 0.05836609f, 0.08945096f, 0.20913240f, -0.01977550f, 
    -0.09075713f, 0.02001821f, 0.07115843f, -0.02652349f, -0.13459146f, -0.23399708f, 0.07094719f, 0.02626544f, 
    0.07456358f, 0.06021172f, 0.07866932f, 0.12124639f, -0.02926416f, -0.02795035f, 0.11933579f, 0.03732995f, 
    -0.25402829f, 0.01992321f, 0.31974581f, -0.11846037f, 0.09815941f, -0.02127473f, 0.26780415f, 0.12195823f, 
    0.20481993f, 0.12535158f, 0.01086240f, 0.22464466f, -0.27248129f, -0.07995050f, -0.10635430f, 0.13244078f, 
    0.09067770f, -0.28988171f, 0.11616180f, 0.25293782f, -0.04684250f, 0.03434519f, 0.07284240f, 0.06465094f, 
    -0.22071382f, 0.20634572f, -0.01043168f, -0.19897974f, 0.01104367f, 0.05027700f, 0.12763615f, 0.06340469f, 
    0.03170036f, -0.06528257f, 0.01354105f, -0.04515177f, 0.26196152f, 0.08762556f, 0.11230981f, -0.11633792f, 
    -0.03215187f, -0.05862347f, -0.07668498f, -0.12681454f, 0.09159964f, 0.15971772f, 0.02496166f, 0.08814108f, 
    0.00322067f, 0.28235680f, -0.17280996f, -0.13147041f, 0.12425483f, 0.06460629f, 0.29530877f, 0.08053768f, 
    0.00814939f, -0.10298708f, 0.02631471f, -0.05875568f, -0.21322858f, -0.20783688f, 0.14506830f, 0.18770024f, 
    -0.23514779f, -0.03018680f, -0.03781182f, 0.04102536f, 0.16062656f, 0.01052696f, -0.07140194f, -0.11863589f, 
    0.20696045f, 0.13486469f, 0.28161472f, -0.13341069f, 0.12361558f, -0.03037636f, 0.10845937f, 0.13543116f, 
    0.15659922f, 0.16483273f, -0.10880581f, 0.04899789f, 0.06384737f, 0.05934657f, -0.02575368f, -0.12160101f, 
    -0.11628407f, -0.09207034f, 0.02490067f, 0.03927180f, 0.12896578f, 0.11335111f, 0.07744153f, -0.02334886f, 
    -0.01712638f, -0.18611011f, -0.39102831f, 0.12584996f, 0.10058310f, 0.07777141f, 0.02933134f, 0.20298339f, 
    0.03484853f, 0.04411488f, 0.03641000f, 0.09749363f, 0.06175588f, -0.05916627f, 0.22969168f, -0.06834096f, 
    -0.09225352f, -0.00743594f, 0.01267304f, -0.02590628f, 0.08463447f, -0.08008460f, -0.03330930f, -0.00166762f, 
    0.10888281f, -0.05895872f, 0.23089665f, -0.05704165f, -0.08777738f, 0.00036356f, 0.00542090f, 0.12802082f, 
    -0.02828534f, -0.01680619f, 0.00966140f, -0.14189839f, -0.03628113f, 0.02463500f, 0.10588516f, 0.13510081f, 
    -0.05917712f, -0.00818094f, -0.04271109f, -0.07181853f, 0.10802891f, 0.15974255f, 0.16031165f, 0.05228395f, 
    0.04546748f, -0.18141413f, -0.06453287f, 0.12001397f, 0.04306953f, 0.01357421f, 0.12604684f, 0.05199086f, 
    0.13542877f, 0.11468386f, 0.09913138f, 0.15117657f, -0.02937581f, 0.12670304f, -0.00272435f, 0.01723441f, 
    0.04384607f, 0.04576285f, 0.07234702f, 0.00566977f, 0.06493295f, -0.02227122f, 0.16193710f, 0.06473149f, 
    -0.00234355f, 0.02101164f, -0.10307284f, -0.10381232f, 0.06026004f, 0.03288862f, 0.03136384f, 0.06826916f, 
    0.00154939f, 0.12445789f, 0.12949143f, 0.08342206f, -0.00804158f, 0.09795659f, 0.06635129f, -0.25224999f, 
    -0.06788916f, -0.09788602f, 0.08738538f, 0.00787891f, 0.07470385f, -0.00953828f, 0.12902348f, -0.00198658f, 
    0.15092532f, -0.11213760f, -0.01928635f, -0.20739467f, 0.10503434f, -0.12549488f, 0.15352975f, -0.06667346f, 
    0.05137330f, -0.00878661f, 0.07612371f, 0.17386147f, -0.36884388f, 0.01111330f, 0.05353937f, -0.14640686f, 
    0.04896353f, -0.04754540f, 0.04273748f, 0.09541665f, 0.04783645f, -0.17513950f, -0.07388869f, -0.15751368f, 
    0.09482944f, -0.09593894f, -0.01567988f, -0.20491335f, -0.00938749f, -0.02630350f, 0.01282119f, 0.11169954f, 
    -0.01398143f, -0.04426480f, -0.01553060f, 0.04158785f, 0.29698387f, 0.14412989f, -0.14757918f, -0.06046914f, 
    -0.07570431f, 0.01728133f, 0.03767556f, 0.04220783f, 0.10182164f, -0.03773095f, 0.00375831f, 0.18254092f, 
    0.34436160f, 0.03977912f, -0.10362598f, -0.12172582f, 0.01721563f, -0.00100006f, 0.10636210f, -0.13304678f, 
    -0.06800023f, -0.02583711f, 0.03313504f, -0.00072603f, -0.57719463f, 0.05083299f, 0.07372035f, 0.16174059f, 
    -0.10463408f, 0.13242237f, 0.08821581f, 0.10435369f, 0.03152364f, -0.01579083f, 0.02818266f, 0.01697876f, 
    0.01238455f, 0.14878467f, -0.09357745f, -0.03365488f, 0.06760421f, -0.13554937f, -0.13652126f, 0.03115508f, 
    0.03292956f, 0.09405836f, -0.15613168f, -0.04997231f, 0.05966812f, 0.19709349f, 0.03693402f, -0.13109352f, 
    -0.05786127f, -0.04560470f, 0.03080537f, 0.00971176f, 0.03385964f, 0.18136787f, 0.13297954f, 0.06554956f, 
    -0.26332891f, -0.09085850f, 0.03259097f, -0.19053008f, 0.05016168f, -0.10983136f, 0.10694578f, 0.10722684f, 
    0.05400297f, -0.05285370f, 0.07440747f, -0.08940178f, -0.07516225f, 0.03666876f, -0.02042416f, 0.08758263f, 
    0.07031455f, 0.06972969f, -0.05371290f, 0.04360872f, 0.05827031f, 0.03954541f, 0.05860863f, 0.04542382f, 
    0.07295649f, 0.21029067f, 0.09350487f, -0.02617327f, 0.02526024f, 0.02816832f, 0.05674903f, 0.22619706f, 
    0.04841603f, -0.00137148f, 0.08856575f, -0.11171637f, -0.02666213f, -0.05447342f, 0.10450072f, 0.21310452f, 
    -0.04621356f, -0.05229533f, 0.04365774f, 0.08891982f, 0.08907001f, -0.04954470f, 0.05628159f, -0.03250802f, 
    -0.02675728f, -0.11426450f, -0.00826275f, -0.09268695f, -0.02154776f, 0.01274514f, 0.09542045f, -0.02927523f, 
    0.13659734f, 0.05526802f, 0.06107479f, 0.26937151f, 0.16845347f, -0.03848263f, 0.05581732f, -0.00782849f, 
    -0.00997730f, 0.06468148f, -0.09631367f, 0.04738003f, 0.00281734f, -0.02017895f, -0.07346340f, 0.06859613f, 
    0.11278515f, 0.01981999f, -0.13327922f, -0.03987955f, -0.02383201f, 0.03462220f, -0.04439907f, -0.02391082f, 
    -0.02887223f, 0.02265614f, 0.04176299f, 0.09617246f, 0.09584497f, 0.21831857f, 0.16776417f, -0.14114225f, 
    -0.15644029f, 0.01131568f, 0.00353497f, -0.05583836f, -0.04201991f, 0.03974760f, 0.15651862f, -0.09887315f, 
    0.09663268f, -0.01534572f, -0.15355358f, 0.26437092f, -0.07170868f, 0.10931308f, 0.06370478f, -0.13578148f, 
    -0.07654301f, 0.13446735f, 0.01888504f, 0.04810652f, 0.00721262f, 0.00319765f, 0.36085376f, 0.01936621f, 
    -0.00655068f, 0.07634576f, 0.12363853f, -0.06815825f, 0.09494498f, 0.00177166f, -0.06360643f, -0.11914301f, 
    0.52596200f, 0.14492270f, 0.22274756f, 0.11437172f, 0.00992661f, 0.03030825f, -0.10273708f, 0.04832982f, 
    -0.02321298f, 0.01246789f, 0.00134396f, -0.07868701f, -0.04260230f, -0.35301960f, -0.31731358f, -0.05939424f, 
    0.01204737f, 0.04181663f, -0.06751364f, 0.10135431f, -0.02612928f, 0.02766169f, 0.03660656f, -0.01220425f, 
    0.18368708f, 0.30951750f, 0.15034005f, 0.24453478f, -0.05720566f, 0.02963894f, -0.18210724f, 0.04010256f, 
    -0.00778814f, 0.07203205f, 0.07906111f, -0.00939492f, -0.24219954f, -0.03590796f, -0.39890885f, -0.22163676f, 
    0.04455191f, 0.00636663f, 0.06056184f, 0.13236187f, -0.12927549f, -0.09419543f, 0.08009856f, 0.08294573f, 
    0.00317256f, 0.11332425f, -0.13018125f, 0.14440498f, -0.06100665f, 0.09876332f, 0.12146024f, 0.02912620f, 
    0.07241879f, -0.02891690f, -0.01391508f, -0.07114907f, -0.02652206f, -0.05324779f, -0.12784402f, -0.15403967f, 
    -0.14351104f, -0.11258878f, -0.12495750f, -0.10989252f, 0.14101075f, 0.06429159f, 0.03245171f, 0.00330353f, 
    -0.03450686f, -0.16552643f, 0.21500261f, 0.22612432f, 0.07032425f, -0.02231442f, 0.15245569f, 0.04699188f, 
    0.05327290f, 0.11223604f, 0.16129257f, -0.07972025f, 0.08726016f, 0.18870653f, -0.04238051f, 0.18218935f, 
    0.00599316f, 0.03248623f, -0.01123745f, -0.06593774f, 0.27559331f, -0.02189934f, -0.05145992f, -0.00792279f, 
    -0.02442541f, -0.19059753f, 0.00299412f, -0.04870544f, 0.01342299f, -0.06998511f, 0.22819346f, -0.02892350f, 
    0.04624676f, -0.01076253f, -0.05881345f, -0.04802417f, 0.06195876f, 0.03501895f, -0.10130657f, -0.03050903f, 
    0.07788658f, -0.00232728f, -0.07045665f, -0.03650432f, -0.00606000f, -0.11698252f, -0.16014360f, -0.03182018f, 
    -0.19802095f, 0.05038076f, 0.04212316f, -0.05539505f, 0.00468033f, -0.01044103f, 0.00212847f, 0.06002221f, 
    -0.00723480f, -0.04944962f, -0.04134334f, 0.08092991f, 0.16362093f, -0.02017874f, 0.14230262f, -0.02368522f, 
    0.07127853f, 0.11154808f, -0.10273091f, 0.06697181f, -0.09108159f, -0.02909707f, -0.08757527f, 0.05129461f, 
    0.07494614f, -0.22534911f, 0.09303875f, -0.13817148f, -0.00265335f, -0.21965301f, -0.02309578f, -0.08497209f, 
    0.03242327f, 0.03280767f, 0.03918761f, 0.02724386f, -0.02968669f, -0.29718176f, -0.13274823f, 0.30261877f, 
    -0.05734025f, 0.01733003f, 0.15707277f, -0.06764403f, 0.14065577f, 0.12393162f, 0.00517961f, -0.00065408f, 
    0.07061660f, -0.06740803f, 0.05732258f, -0.00052369f, 0.00255629f, -0.06516042f, 0.00977194f, -0.07129757f, 
    -0.03237173f, -0.06007495f, -0.02846162f, 0.01248684f, -0.01955914f, -0.01338555f, 0.06366349f, -0.03265020f, 
    0.01399994f, -0.03249013f, 0.01854937f, 0.00638676f, -0.02792478f, -0.07767903f, 0.05161678f, 0.01429112f, 
    0.00959585f, 0.05325818f, -0.03518654f, -0.01325682f, 0.01739069f, 0.01546375f, -0.07154711f, 0.01349470f, 
    -0.04522652f, -0.03848760f, -0.05874218f, -0.05234868f, -0.06731406f, 0.04245769f, -0.03444561f, 0.05072555f, 
    -0.01510912f, 0.02706239f, 0.01172329f, -0.02144408f, -0.03116118f, 0.03651805f, -0.03469843f, 0.00331188f, 
    -0.03795119f, 0.00455886f, 0.06530154f, 0.01151841f, 0.03202838f, 0.05190156f, -0.04432585f, -0.04411991f, 
    0.02526168f, 0.05677173f, -0.01935634f, 0.04368342f, -0.00829521f, -0.00482243f, 0.03645540f, 0.00501518f, 
    -0.00556808f, -0.01251841f, -0.06043504f, -0.04350731f, 0.05337027f, -0.05240076f, 0.00045081f, -0.06026874f, 
    0.06025287f, -0.00109587f, -0.01032738f, -0.06377604f, 0.00778090f, -0.04995074f, 0.05541229f, -0.06571443f, 
    -0.06497675f, -0.01392255f, 0.04877339f, -0.03417581f, 0.02837904f, 0.01646728f, -0.04301215f, -0.01009211f, 
    0.05630449f, 0.04721425f, -0.01347368f, 0.03759846f, -0.02708478f, -0.05116965f, 0.04259413f, -0.00527134f, 
    -0.02755199f, 0.05158546f, -0.06785993f, -0.01505461f, 0.01018479f, -0.01209015f, -0.01786364f, -0.02304183f, 
    0.04922748f, 0.01412675f, 0.03091166f, -0.00844094f, -0.06116781f, -0.04475217f, 0.01436750f, 0.02859483f, 
    -0.01526177f, -0.08063309f, 0.02738164f, 0.06004727f, -0.01780797f, 0.02708412f, -0.07983337f, -0.02472816f, 
    0.06106270f, 0.04413541f, -0.00286106f, 0.04072004f, 0.04699136f, -0.02283484f, -0.06482925f, 0.06833025f, 
    0.03705667f, -0.07342837f, -0.05727745f, 0.00328471f, -0.02137235f, -0.06720277f, -0.07034754f, -0.02873034f, 
    -0.01707863f, -0.02304967f, 0.06447557f, 0.07237431f, -0.05217979f, -0.05330950f, 0.04892408f, -0.03067320f, 
    0.05655157f, -0.04610929f, -0.01680180f, -0.03070757f, -0.05128551f, 0.04074264f, -0.06967851f, -0.04830863f, 
    0.01133405f, -0.02077488f, -0.02304837f, -0.01301858f, -0.02087191f, 0.06773805f, -0.02731514f, -0.00416153f, 
    -0.07625657f, 0.02253022f, -0.00011883f, -0.01939232f, -0.02985064f, -0.05361965f, 0.02394507f, -0.01700296f, 
    -0.07502097f, 0.04747831f, -0.02514312f, -0.03088258f, 0.01005895f, -0.07502919f, -0.00912652f, 0.02326214f, 
    -0.04740598f, 0.03543184f, -0.06822511f, 0.04372333f, 0.01824879f, 0.02176259f, 0.05548551f, -0.06707925f, 
    -0.06621304f, -0.05258208f, -0.02061186f, 0.00705853f, 0.03003566f, 0.03459188f, 0.05248066f, 0.05877237f, 
    0.10123701f, 0.19940066f, 0.04557969f, -0.02645141f, -0.17217976f, 0.05920405f, 0.04752969f, 0.08151281f, 
    0.02926753f, 0.17764877f, 0.19761053f, 0.10387312f, -0.15202390f, -0.00720261f, 0.14373650f, -0.25431341f, 
    -0.04005719f, 0.00701857f, -0.03410550f, -0.03574637f, -0.00429594f, -0.00274708f, 0.05925477f, 0.04482340f, 
    -0.05636384f, -0.12679882f, 0.15529786f, -0.07430727f, 0.01941798f, 0.07680362f, -0.05643447f, -0.06708287f, 
    -0.00770616f, -0.00046864f, -0.04946264f, -0.02942361f, -0.15711500f, 0.01216511f, -0.11848593f, -0.03124823f, 
    -0.00559840f, 0.03496780f, 0.06834836f, 0.03508688f, 0.17345771f, 0.03419012f, 0.02593395f, -0.06470008f, 
    0.05454030f, -0.09812552f, 0.05287555f, 0.08083576f, 0.07381411f, 0.04638675f, 0.02237363f, -0.08255023f, 
    -0.05512958f, -0.02980872f, -0.07941463f, -0.00771280f, -0.43388987f, 0.15121721f, 0.01759862f, -0.23960823f, 
    -0.03309920f, -0.04686392f, 0.05174341f, 0.11486497f, 0.00950519f, -0.00908044f, 0.12260181f, 0.08348440f, 
    -0.21386792f, -0.17467323f, -0.03816270f, 0.26905325f, 0.02962643f, 0.02911039f, 0.01026691f, -0.11710373f, 
    0.08640612f, 0.09654699f, 0.05728655f, -0.01391500f, 0.00170696f, 0.06308085f, -0.05421300f, -0.20247743f, 
    -0.00150909f, 0.03448209f, 0.01284661f, -0.05640960f, -0.06616147f, 0.00349190f, 0.09467486f, -0.05142512f, 
    0.23282120f, -0.04149954f, 0.19228825f, -0.09790509f, 0.08910966f, 0.13394755f, 0.05942248f, 0.01213466f, 
    0.08555747f, 0.01808662f, 0.16071706f, 0.02692136f, -0.06936339f, 0.14171147f, -0.19313264f, 0.04118710f, 
    -0.03153165f, -0.04898806f, -0.00120327f, 0.04789197f, 0.07211548f, -0.05804886f, 0.04966977f, -0.21500432f, 
    -0.10068928f, 0.02104144f, -0.00621433f, -0.07097486f, 0.11291303f, -0.01101375f, 0.04973537f, 0.13258237f, 
    0.02518179f, -0.02812110f, -0.08210595f, -0.08549173f, -0.00840444f, -0.03565187f, -0.02591752f, -0.06157723f, 
    -0.05611761f, -0.08690239f, -0.07127577f, 0.02277855f, 0.09719933f, 0.02475854f, 0.13541254f, 0.20609982f, 
    -0.01883062f, 0.01434180f, 0.14125614f, -0.04363760f, 0.00116971f, 0.05152952f, 0.00687558f, 0.08395624f, 
    0.13687931f, 0.05839087f, 0.02815184f, -0.05293532f, 0.10479151f, -0.03352398f, 0.04763499f, 0.04794666f, 
    -0.05062896f, 0.06128257f, 0.01952762f, 0.13778022f, -0.01937042f, 0.03332733f, 0.06511269f, 0.09750314f, 
    -0.02951915f, -0.04351260f, 0.05188558f, -0.06383786f, 0.02609146f, 0.01303502f, -0.08188280f, 0.06256132f, 
    0.06197680f, 0.08475100f, -0.00572647f, 0.02906090f, -0.13737597f, 0.07890400f, -0.15275638f, -0.07960665f, 
    0.07374627f, 0.12308454f, -0.12610206f, -0.13789073f, -0.00996943f, -0.03969306f, 0.01007981f, -0.02213510f, 
    -0.06631239f, -0.07085633f, 0.11182854f, -0.27654538f, 0.11460693f, 0.00537167f, 0.18549152f, -0.08445701f, 
    0.04185629f, 0.05917915f, 0.08392203f, 0.12860748f, -0.29627380f, -0.02230969f, -0.11550347f, -0.01493501f, 
    0.20281652f, -0.17220922f, 0.20101482f, 0.06949422f, 0.10622397f, -0.01197076f, 0.05906156f, 0.11412089f, 
    -0.09216123f, 0.08440515f, -0.08309123f, -0.22951846f, 0.10961123f, 0.00818807f, 0.04765254f, 0.06552834f, 
    0.01839055f, -0.08429387f, -0.08469540f, 0.04484868f, 0.29372522f, 0.09521588f, 0.02655885f, -0.22510067f, 
    -0.08235275f, 0.04777007f, -0.04976254f, -0.07022924f, 0.08739442f, -0.00187678f, 0.01325082f, 0.04131377f, 
    0.17041655f, 0.08332183f, -0.24961092f, -0.23075090f, 0.09841511f, 0.03415536f, 0.15832338f, -0.17305398f, 
    0.00412377f, -0.04748053f, -0.10031620f, 0.05805323f, -0.46427351f, 0.01032112f, 0.10584176f, 0.14886577f, 
    -0.17682782f, -0.04436346f, 0.01665955f, 0.10646830f, 0.08942105f, -0.05181556f, -0.13452239f, -0.09233077f, 
    0.09150052f, 0.02046990f, -0.09176639f, -0.08546964f, 0.09288254f, -0.13300145f, -0.13987458f, -0.10727526f, 
    0.14537658f, 0.15092884f, -0.10073749f, -0.08027448f, 0.01746003f, 0.15276906f, 0.16171014f, -0.09051700f, 
    -0.07572372f, -0.02716771f, 0.14990297f, 0.03667189f, 0.17084858f, 0.17325053f, 0.14939326f, 0.00274768f, 
    -0.04586240f, -0.18730423f, -0.23782745f, -0.05268923f, 0.02806355f, 0.07960980f, 0.01554338f, 0.25699759f, 
    0.10910881f, 0.11578749f, 0.10656454f, 0.09424858f, 0.12175806f, -0.03150300f, -0.01921198f, 0.03004044f, 
    0.03560514f, 0.05102523f, -0.04611411f, 0.08829784f, 0.00481232f, -0.10267940f, -0.10407582f, -0.03533572f, 
    -0.04877474f, 0.10590846f, 0.31735128f, -0.02015200f, -0.03046447f, 0.04279421f, -0.04560237f, 0.09230872f, 
    -0.02527653f, -0.02716372f, 0.07882985f, -0.00355078f, -0.07385850f, -0.08596842f, 0.14450225f, 0.14563672f, 
    -0.08182732f, 0.07022616f, 0.00413940f, -0.03753190f, 0.10109191f, 0.05077713f, 0.18128754f, 0.18822590f, 
    -0.01375826f, -0.10060392f, -0.01306105f, 0.14615376f, -0.02657825f, 0.16756296f, 0.13922513f, 0.03948127f, 
    0.13257420f, -0.04328929f, 0.00163426f, -0.03371068f, 0.01477314f, 0.01797372f, -0.01469279f, 0.07362487f, 
    0.05737610f, -0.00128335f, 0.00077855f, -0.06191690f, 0.04553525f, -0.18060319f, 0.05306174f, 0.04322219f, 
    0.05265056f, 0.04070406f, -0.01532100f, -0.01047701f, -0.04828524f, 0.07476952f, -0.06154028f, 0.09790143f, 
    0.00689388f, 0.06560057f, 0.09048885f, 0.03081208f, -0.09505141f, 0.11731996f, 0.16979483f, -0.23730665f, 
    -0.02406624f, -0.05829138f, 0.02082486f, 0.02165812f, 0.02305246f, 0.00245574f, 0.08713266f, -0.21674737f, 
    -0.00810415f, 0.28391874f, -0.06368167f, 0.09986878f, -0.00950521f, -0.05464568f, 0.03706706f, -0.03273992f, 
    0.10466882f, 0.13356897f, 0.22620814f, 0.01092050f, -0.12097344f, -0.05115278f, 0.08143806f, 0.19537440f, 
    0.11426868f, -0.15217483f, 0.14287804f, 0.10504627f, 0.06509203f, 0.14265618f, -0.04114076f, 0.19727018f, 
    0.20327254f, 0.12125818f, 0.00497636f, 0.09557412f, -0.08029788f, 0.05896113f, -0.14232142f, 0.05811758f, 
    0.02592313f, -0.03211996f, 0.02922606f, -0.08283758f, -0.09142917f, -0.25016874f, 0.37865385f, -0.14046356f, 
    -0.07074083f, -0.02468072f, -0.07610056f, 0.05195380f, -0.07337958f, 0.09130803f, -0.08274334f, -0.17263801f, 
    -0.32651457f, 0.27266452f, -0.02987199f, -0.02582138f, 0.04300045f, 0.05138258f, -0.08257452f, 0.04067182f, 
    -0.00544064f, -0.05283472f, -0.13360776f, 0.01292963f, -0.42422539f, 0.06560007f, -0.08609011f, 0.00618420f, 
    -0.10806321f, -0.08121458f, -0.04583669f, 0.01446852f, 0.10529552f, -0.08331448f, -0.00595753f, 0.12511083f, 
    0.06837130f, -0.19468763f, 0.06003821f, -0.30957121f, -0.06697715f, 0.13213854f, 0.02216497f, 0.00025719f, 
    0.33953249f, 0.16500829f, 0.05434338f, 0.06127090f, 0.04089310f, -0.01380953f, 0.12172252f, -0.02011069f, 
    0.03569988f, -0.09022107f, 0.04779837f, 0.01061976f, 0.00256405f, -0.10616259f, -0.01568379f, -0.14034504f, 
    0.12425452f, -0.20849295f, -0.04329294f, 0.48228344f, 0.09922270f, 0.12818763f, 0.12526998f, 0.19544630f, 
    0.07911760f, 0.10855677f, 0.17232969f, -0.12976250f, 0.14508067f, -0.01689575f, 0.01361122f, 0.03891252f, 
    -0.06487691f, -0.03815960f, 0.01723563f, -0.07371862f, 0.09654738f, -0.11872300f, 0.01718540f, -0.22858709f, 
    -0.09959801f, -0.09157471f, 0.35900795f, -0.09511433f, 0.12044702f, -0.11483679f, 0.19958641f, 0.01707156f, 
    0.02689771f, -0.06410466f, -0.13577887f, 0.02377725f, -0.08591428f, -0.01859436f, -0.02128307f, 0.20918906f, 
    -0.06526478f, 0.02963896f, -0.08211803f, -0.15450229f, 0.13826981f, 0.03620175f, -0.05776678f, 0.04970137f, 
    -0.13656723f, 0.10147725f, 0.18627791f, 0.25075170f, 0.00391798f, 0.00787857f, 0.04411002f, -0.00372826f, 
    0.01888679f, -0.05774949f, -0.07183946f, -0.13527505f, -0.17799203f, -0.01009015f, 0.10206854f, -0.08151798f, 
    0.03955716f, -0.06619111f, -0.04943999f, 0.21956280f, 0.09719510f, 0.18743488f, 0.21160674f, 0.22967076f, 
    -0.06467699f, -0.03969202f, 0.17606843f, -0.00609788f, 0.07261637f, -0.13012691f, -0.09546460f, 0.11524781f, 
    -0.08667042f, 0.06834882f, 0.00241664f, -0.05454917f, -0.18312736f, 0.12601389f, -0.00416632f, -0.08169682f, 
    -0.03995687f, -0.07739720f, 0.00524678f, 0.02542955f, -0.00614493f, -0.00287926f, 0.00558303f, -0.07124919f, 
    0.20242646f, -0.13782761f, 0.24858329f, -0.20057702f, 0.02955162f, -0.02497721f, 0.05028918f, -0.03503802f, 
    -0.03544599f, 0.06286248f, -0.02505795f, 0.15522338f, -0.19753727f, -0.03537536f, -0.03377298f, -0.07803304f, 
    0.05788867f, -0.01808473f, 0.14946774f, 0.10624222f, 0.02997589f, -0.08903162f, -0.10182378f, -0.02953098f, 
    0.21135481f, -0.09217288f, 0.26484087f, -0.05457508f, -0.05928534f, -0.13130383f, 0.00396373f, 0.01631236f, 
    -0.13739242f, -0.08395950f, -0.07063074f, -0.02984367f, 0.17057826f, -0.01984132f, 0.05874218f, -0.14798053f, 
    -0.02550759f, 0.00968249f, -0.12215073f, 0.05122101f, -0.14412455f, 0.05404975f, -0.01671994f, -0.03114577f, 
    0.25941548f, 0.07406820f, -0.03605368f, 0.04038229f, -0.02033532f, 0.00533371f, -0.03972595f, 0.00557722f, 
    -0.11570146f, 0.05437500f, -0.06626412f, 0.06472131f, -0.34914470f, -0.08205966f, 0.09960734f, -0.03093425f, 
    -0.01919195f, 0.12447871f, -0.03687043f, 0.00066544f, 0.04862462f, 0.04639924f, 0.06767491f, 0.06124433f, 
    0.00408585f, 0.25324643f, -0.14083233f, 0.08849412f, 0.04901137f, -0.08172137f, -0.03713427f, 0.07054142f, 
    -0.10205202f, 0.04869208f, -0.21817259f, 0.08068548f, 0.04790374f, 0.10009527f, -0.00124047f, -0.01626960f, 
    0.00960488f, -0.10724500f, -0.05915398f, 0.01695077f, 0.10545954f, 0.10368547f, -0.05133351f, 0.08957212f, 
    -0.37901840f, 0.05509645f, -0.37592432f, 0.04853223f, 0.13999878f, -0.18493301f, 0.18096446f, -0.03525705f, 
    0.06942312f, 0.09517830f, 0.03345528f, 0.05754511f, -0.09739420f, 0.10566467f, -0.08167635f, 0.06041038f, 
    -0.03739468f, -0.04422834f, -0.04532606f, 0.08098540f, 0.08352973f, 0.19941562f, -0.03750826f, 0.15415375f, 
    0.15079319f, 0.09973200f, 0.23469420f, 0.11646885f, -0.06192834f, -0.12127734f, -0.02002027f, -0.00927817f, 
    -0.03710222f, 0.11260501f, 0.08387214f, -0.03708675f, -0.06338301f, 0.04348547f, 0.12761496f, 0.20475896f, 
    -0.01113629f, 0.06830071f, -0.09266004f, 0.00121461f, 0.05412417f, -0.00366139f, -0.04584290f, -0.01468646f, 
    -0.03216442f, 0.07168011f, 0.05794940f, -0.03554349f, 0.14628242f, 0.05654649f, 0.00655583f, 0.06353611f, 
    0.03201774f, -0.03552277f, 0.06628225f, 0.12786455f, 0.12417232f, 0.00063182f, 0.12365133f, 0.00899399f, 
    0.01363991f, 0.13441977f, 0.07252605f, 0.04901697f, 0.00809038f, -0.01129327f, 0.00571597f, 0.07644963f, 
    -0.08904278f, -0.21057057f, -0.07367736f, -0.15123390f, 0.17528808f, -0.10727368f, 0.04533692f, -0.02883372f, 
    0.06047027f, 0.06938154f, 0.01175051f, -0.05735033f, -0.01341552f, -0.07699649f, 0.19317405f, 0.25576329f, 
    -0.06855654f, -0.20078379f, 0.05217430f, 0.22583218f, -0.04471618f, -0.02536570f, 0.10999268f, 0.00815927f, 
    -0.11414105f, -0.19705097f, 0.28803307f, -0.16392225f, -0.00665336f, -0.00764021f, -0.09970996f, -0.12079468f, 
    -0.05945455f, -0.05680294f, -0.07427787f, 0.08352184f, -0.05921802f, 0.15833037f, -0.06325138f, 0.09406769f, 
    0.03027445f, -0.05815188f, 0.05286314f, 0.00765985f, -0.00145909f, -0.05335776f, -0.03341260f, -0.14071222f, 
    0.12221042f, -0.04743738f, -0.06283475f, 0.02329264f, -0.01364786f, -0.08875819f, -0.05227888f, -0.00696079f, 
    -0.05425614f, -0.05704837f, -0.01034257f, -0.05507694f, 0.41142446f, -0.01471474f, 0.06979772f, -0.08292098f, 
    -0.02582400f, -0.09008925f, -0.02828203f, -0.09119731f, 0.02055457f, 0.01746678f, 0.01953288f, 0.08926924f, 
    0.39097857f, 0.09991010f, -0.11078297f, 0.04002875f, -0.03447355f, 0.13401042f, 0.14051567f, 0.01521523f, 
    -0.17116950f, -0.06824390f, 0.07870256f, -0.08442885f, -0.10487648f, 0.04460653f, 0.06660603f, 0.12703457f, 
    0.04418608f, 0.20495938f, -0.10665012f, -0.06222942f, 0.07485137f, 0.04021471f, 0.02289302f, 0.08787210f, 
    0.17751765f, 0.26349336f, -0.06877502f, -0.11009409f, 0.07756767f, 0.00052805f, 0.10162640f, 0.04514995f, 
    -0.01623391f, -0.05097173f, -0.15597844f, 0.03324059f, 0.13961159f, 0.11056640f, 0.04010896f, 0.10698914f, 
    -0.00303618f, 0.01136766f, -0.02777268f, 0.08061009f, 0.02693313f, 0.11566749f, 0.02408873f, 0.04626914f, 
    -0.33137596f, 0.07126453f, -0.23657569f, -0.08088861f, 0.00434759f, -0.16311292f, 0.01163030f, -0.01287572f, 
    -0.06951300f, 0.06437431f, -0.04899861f, 0.04054981f, 0.07989728f, -0.09395687f, 0.12859266f, 0.05779070f, 
    -0.03500105f, 0.02656915f, -0.10514339f, 0.04730337f, -0.03676017f, 0.16703956f, 0.00583241f, 0.16329356f, 
    0.33711454f, 0.07591841f, 0.04305045f, -0.13477151f, -0.02574550f, 0.06639096f, -0.12465526f, -0.00426382f, 
    -0.04247868f, -0.00347993f, 0.05096715f, -0.03623435f, -0.10914765f, 0.05523703f, 0.06430613f, 0.18712312f, 
    0.01760375f, 0.02648819f, -0.07795405f, -0.00683603f, -0.07713653f, 0.04012036f, -0.02508065f, 0.02735350f, 
    -0.15981573f, -0.17505698f, -0.03902345f, -0.09294661f, 0.00933875f, -0.00686347f, 0.08062055f, 0.01225013f, 
    -0.00374043f, -0.04893905f, 0.05895114f, 0.11325666f, 0.01528523f, 0.06377015f, -0.10908897f, -0.09026925f, 
    0.08555418f, -0.00565287f, -0.03732125f, -0.07449328f, 0.04537325f, -0.04343295f, -0.09506883f, -0.09597847f, 
    -0.09074625f, 0.11013445f, -0.07960739f, -0.06480530f, 0.10299451f, 0.07623871f, 0.07389405f, -0.05611828f, 
    -0.10869829f, 0.05218764f, 0.09495520f, 0.03614319f, 0.22307751f, -0.11084460f, 0.19453861f, 0.01994551f, 
    -0.02801026f, -0.07385011f, -0.02144129f, 0.23591651f, 0.00157830f, -0.01742955f, 0.08954299f, 0.00291129f, 
    -0.05967240f, 0.20501474f, -0.04936138f, 0.14446689f, -0.02534199f, -0.06521086f, 0.05533582f, 0.15780443f, 
    0.07257639f, 0.10628002f, -0.06790630f, 0.09666333f, -0.01188342f, 0.10803422f, 0.13372710f, 0.28676751f, 
    0.19630504f, 0.06478830f, 0.08010952f, 0.02034424f, 0.01887011f, 0.11915350f, -0.04626450f, 0.16079125f, 
    0.03873303f, -0.00041242f, 0.08830061f, 0.29697287f, -0.12722188f, -0.11824583f, 0.03496804f, 0.06086788f, 
    -0.03535347f, -0.00580031f, -0.12017260f, 0.09163307f, 0.46894056f, -0.14688781f, 0.28958404f, -0.08690447f, 
    -0.11229803f, -0.19105972f, -0.01182914f, -0.27169189f, 0.06711531f, 0.10478260f, 0.07215989f, 0.00252125f, 
    -0.28483129f, -0.04345777f, -0.13105541f, 0.07900675f, -0.03447897f, -0.06077052f, 0.03185812f, 0.10595345f, 
    -0.02057430f, 0.04063169f, -0.16021681f, -0.04471751f, 0.16047573f, 0.06975681f, -0.11145245f, 0.02060370f, 
    -0.14359300f, 0.03529584f, -0.08156824f, -0.02228870f, 0.17546712f, 0.01036618f, -0.05497047f, 0.06051632f, 
    0.18034384f, -0.17398521f, 0.24696101f, -0.24305408f, 0.03490368f, -0.00710187f, -0.03705736f, 0.21381707f, 
    0.08529093f, 0.20295012f, -0.00136632f, -0.00615268f, 0.15595509f, 0.12136914f, 0.30174643f, -0.11884234f, 
    0.11623876f, -0.01282844f, -0.10718130f, 0.06460316f, -0.01689739f, -0.20004044f, 0.03529255f, -0.09057143f, 
    0.06945756f, 0.13508165f, -0.00904907f, 0.22473784f, 0.02415046f, 0.03729555f, -0.04886650f, 0.11243162f, 
    0.01896076f, -0.02650218f, -0.12187712f, -0.20757045f, 0.28861186f, 0.09160247f, 0.35672590f, 0.22387512f, 
    -0.08619214f, -0.03880465f, -0.05897787f, -0.21627043f, -0.02632590f, -0.16417991f, -0.14032042f, -0.07965693f, 
    0.11691612f, -0.25586262f, 0.02323370f, -0.39752549f, 0.13671219f, 0.04269561f, 0.00036718f, 0.03607430f, 
    -0.14052618f, -0.03683995f, -0.11639667f, 0.07141504f, 0.13169046f, 0.13331716f, 0.09926120f, 0.24778862f, 
    -0.05720628f, -0.00221131f, -0.05924861f, -0.24074826f, 0.11517696f, 0.09871653f, 0.08894251f, 0.11301852f, 
    0.22549815f, 0.03031123f, 0.13897417f, 0.09255840f, 0.00484370f, -0.01732422f, -0.19369939f, 0.05110451f, 
    -0.06014606f, -0.10300649f, -0.04031002f, -0.22934055f, -0.29732314f, 0.06888764f, 0.00928934f, 0.14471312f, 
    -0.01390376f, -0.21231659f, 0.06891133f, -0.03016650f, 0.08723572f, 0.02663236f, 0.05170008f, 0.15615319f, 
    -0.00459984f, 0.20068018f, -0.06053012f, 0.09174269f, 0.10649347f, 0.14002892f, -0.09849153f, 0.18126598f, 
    -0.12475098f, -0.04505769f, -0.04725663f, -0.09882821f, 0.08072872f, -0.03305084f, -0.22754924f, -0.22118503f, 
    0.06620208f, -0.12517405f, 0.11026606f, 0.22340782f, -0.02835276f, 0.01832228f, -0.12716483f, -0.12294055f, 
    -0.02123018f, 0.21911766f, -0.16413173f, 0.19629759f, 0.15484485f, -0.32554701f, 0.08148693f, -0.00133519f, 
    0.15504637f, 0.05258846f, 0.14395121f, -0.03911272f, 0.04122933f, -0.02146097f, 0.12204026f, 0.21270731f, 
    -0.01559607f, 0.22004338f, 0.08531635f, -0.06295453f, -0.02420528f, -0.17655113f, -0.22326925f, -0.23227811f, 
    0.08489610f, 0.19637461f, -0.04696458f, 0.25614187f, 0.09080353f, -0.14512663f, -0.14146978f, 0.11967988f, 
    0.03136857f, 0.00315624f, -0.02902184f, -0.20527309f, -0.45105165f, -0.12833165f, -0.14304833f, -0.01976794f, 
    0.00793444f, -0.04137904f, 0.20524894f, 0.06209704f, 0.06100217f, 0.17088878f, 0.02869515f, 0.16778518f, 
    -0.30866766f, 0.20130236f, 0.14965050f, 0.20973849f, 0.05611667f, -0.11264490f, -0.10218180f, -0.07454481f, 
    0.13627435f, -0.14859454f, 0.01213773f, 0.02670171f, 0.19566043f, -0.08566409f, -0.18217012f, -0.18797310f, 
    -0.05294216f, -0.17820886f, 0.05039327f, 0.04354677f, -0.04134417f, -0.00579958f, 0.04763915f, 0.09121347f, 
    -0.06662454f, -0.26398909f, -0.02085040f, -0.34945726f, 0.02876325f, -0.02593617f, -0.07334386f, -0.14420392f, 
    0.16925491f, -0.12059802f, -0.00151267f, -0.12142589f, 0.07026857f, 0.01359154f, 0.06540818f, 0.09545434f, 
    0.04925711f, 0.03849612f, 0.00380462f, 0.01269005f, 0.03794357f, 0.09112196f, 0.08802982f, 0.22050834f, 
    0.08974548f, -0.23482138f, 0.40284255f, 0.45166951f, 0.02196641f, 0.11822839f, -0.12895671f, 0.06697852f, 
    0.02641643f, -0.12422960f, 0.04145738f, -0.00051584f, 0.18280005f, -0.02841609f, 0.08346748f, 0.03033310f, 
    -0.04713862f, -0.11229607f, 0.16505931f, 0.12473237f, 0.06488841f, 0.15116082f, 0.25297195f, 0.00270941f, 
    -0.25775975f, -0.06857947f, 0.15934023f, -0.04182087f, -0.04836408f, 0.03293397f, 0.10894020f, 0.11716335f, 
    0.06650746f, -0.03659018f, -0.14861302f, 0.28406873f, 0.08583669f, 0.05952110f, -0.20727386f, 0.03221807f, 
    -0.05455887f, -0.12234172f, -0.08553325f, -0.13571049f, -0.11125907f, 0.04093319f, -0.06547105f, -0.09541637f, 
    0.18386152f, 0.06007944f, 0.00453656f, 0.26118392f, -0.11452638f, -0.06687069f, -0.04528834f, -0.08140437f, 
    -0.02608098f, 0.06596421f, 0.03655699f, 0.13183179f, -0.36986136f, -0.05205091f, -0.12068739f, -0.07888196f, 
    -0.07144881f, -0.05865121f, -0.15669602f, -0.01273587f, -0.10807694f, 0.05416968f, -0.15828592f, -0.17010818f, 
    0.03427689f, 0.07094109f, 0.10935356f, 0.08883649f, 0.02049057f, 0.06488215f, 0.02286197f, 0.01968443f, 
    0.13991685f, 0.04438879f, 0.07927144f, 0.12831028f, 0.02648002f, 0.17237571f, 0.04965032f, 0.14105688f, 
    0.01392832f, -0.00563853f, 0.03575589f, -0.13437787f, 0.09985572f, -0.00118361f, 0.12262695f, 0.06885890f, 
    0.13740112f, -0.10230099f, 0.23642334f, -0.04720703f, -0.00656075f, 0.00405772f, -0.01787462f, -0.08643343f, 
    -0.12050164f, -0.02612054f, 0.02574834f, -0.06281866f, 0.04587218f, 0.03002088f, 0.02671246f, 0.04369247f, 
    0.02080118f, 0.05750278f, 0.01603807f, 0.07652471f, 0.04091828f, -0.21815401f, -0.04659875f, -0.24426018f, 
    0.28934285f, 0.09948286f, 0.07324164f, -0.13128255f, -0.04796977f, -0.09749270f, -0.00093012f, -0.03428299f, 
    -0.05124517f, -0.02030167f, -0.00582330f, -0.19678223f, -0.04640406f, 0.16297458f, 0.12064075f, 0.03109162f, 
    -0.06938884f, 0.02789607f, -0.05945450f, 0.10783580f, -0.13321048f, 0.05549170f, -0.01729398f, 0.05700224f, 
    0.21160904f, 0.09011229f, 0.14373030f, 0.06282131f, -0.13078703f, 0.13595374f, 0.02090627f, -0.09486726f, 
    -0.03405978f, 0.01608716f, -0.07723030f, 0.01755693f, -0.02573532f, -0.10395051f, 0.14964837f, 0.10488021f, 
    0.11962716f, 0.06913595f, 0.06715874f, 0.01344194f, -0.16322361f, -0.02525845f, 0.16264856f, 0.13833839f, 
    0.17740183f, 0.29655844f, -0.20650496f, 0.01914911f, 0.00642759f, 0.08210452f, 0.09330228f, 0.09012064f, 
    -0.04597021f, -0.04980362f, 0.01014064f, 0.08916760f, -0.01896386f, -0.00309243f, -0.03021025f, 0.11467144f, 
    -0.19052306f, -0.15565142f, -0.01255277f, -0.07931748f, 0.16194710f, 0.15585902f, 0.01310982f, 0.01814455f, 
    -0.35417050f, -0.11001958f, -0.24324310f, 0.17649861f, -0.06582026f, -0.05314873f, 0.08232182f, -0.05711180f, 
    0.05525961f, 0.05808032f, 0.00564861f, 0.09435076f, -0.03690861f, 0.19450891f, -0.07936367f, 0.07585613f, 
    -0.05818425f, -0.05997523f, -0.10451712f, 0.01904885f, 0.14058754f, 0.22977738f, -0.02340996f, 0.06318926f, 
    -0.02645066f, 0.22492965f, 0.28852361f, 0.31579849f, -0.15916440f, -0.17350125f, 0.00776993f, -0.01234348f, 
    0.01972746f, 0.07445075f, 0.12281179f, 0.00233847f, 0.00736846f, -0.00141223f, -0.12338863f, -0.02506339f, 
    0.07824747f, -0.01786380f, -0.00209735f, 0.10094083f, 0.02910964f, -0.12182588f, -0.19638479f, -0.14235397f, 
    -0.08032481f, -0.02382749f, -0.03181247f, 0.01020077f, 0.08669712f, 0.02821835f, 0.03970180f, -0.09180449f, 
    0.07956544f, 0.11875269f, 0.01900016f, 0.22905324f, 0.13354704f, -0.06503156f, 0.01182609f, -0.07734696f, 
    0.02271505f, 0.16534898f, 0.01360750f, 0.02499154f, 0.10654069f, 0.07150339f, -0.09700308f, -0.09409150f, 
    -0.12588784f, -0.18358693f, -0.01519645f, -0.10068678f, -0.03229344f, -0.11566985f, -0.00053011f, -0.04660929f, 
    0.07848970f, 0.08331685f, -0.00574166f, -0.04111449f, -0.16298395f, 0.09215158f, 0.40184870f, 0.29955086f, 
    -0.13012172f, -0.13940050f, 0.03481990f, 0.11208190f, -0.00748009f, -0.00231463f, 0.17094260f, -0.08133633f, 
    0.21983376f, -0.05018486f, -0.22843544f, 0.03822370f, -0.09756273f, -0.05748039f, 0.00087169f, 0.02216978f, 
    -0.11409014f, 0.04410837f, 0.07088922f, 0.10710452f, -0.01363721f, 0.07214634f, 0.02381969f, -0.15636247f, 
    0.10632399f, 0.13164306f, -0.08020261f, 0.03429251f, -0.07115371f, 0.00251998f, -0.00215081f, -0.10302318f, 
    0.01648038f, 0.02461558f, 0.30014524f, 0.02329491f, -0.08272370f, -0.10732702f, -0.06689433f, 0.01427038f, 
    -0.12989913f, 0.01899573f, 0.00004881f, -0.00868979f, 0.18468219f, -0.12891889f, -0.07635934f, 0.09266529f, 
    -0.04373483f, 0.14450541f, 0.06724910f, -0.05427613f, 0.09112231f, 0.03827119f, 0.05328042f, 0.16012633f, 
    0.00229437f, 0.13568570f, 0.02044488f, -0.08178605f, -0.02309126f, -0.22841404f, -0.18744856f, 0.07335666f, 
    -0.01868845f, 0.01425908f, 0.05608001f, 0.10663532f, -0.03851128f, 0.04117713f, -0.16965410f, -0.04862277f, 
    -0.03998286f, 0.08582093f, 0.17420530f, 0.14857841f, -0.02899728f, -0.03832126f, 0.03125451f, 0.06424480f, 
    0.05301643f, -0.02021781f, -0.16380951f, 0.09105450f, -0.00839288f, -0.12666334f, 0.06764388f, 0.12437209f, 
    -0.19228636f, 0.18638542f, -0.12316567f, -0.09571870f, 0.05195357f, 0.11567906f, 0.00811607f, -0.12246479f, 
    0.06901556f, -0.00419823f, 0.05071494f, 0.08204639f, 0.03906385f, 0.02193136f, -0.01648529f, -0.00294845f, 
    -0.00436524f, 0.19442357f, 0.14198844f, -0.31106520f, 0.12755412f, -0.05950123f, -0.00180118f, 0.09856256f, 
    0.02039355f, 0.01569972f, -0.12101149f, -0.08682995f, -0.13379987f, 0.02512975f, -0.12912954f, 0.11877283f, 
    0.02571821f, 0.06124296f, 0.01053468f, 0.08525917f, -0.02609644f, 0.10249668f, -0.04016071f, 0.19657154f, 
    0.23772945f, 0.11596376f, -0.09735203f, -0.17562374f, 0.10323180f, 0.09857213f, 0.05886539f, 0.00536541f, 
    0.01279776f, 0.08806087f, -0.01026525f, -0.02654352f, -0.04194556f, -0.17707914f, -0.10602381f, 0.11132747f, 
    -0.03608338f, 0.09113313f, 0.00541234f, 0.09537733f, 0.06303030f, 0.15213473f, 0.07875851f, 0.10068924f, 
    0.04928860f, 0.09843552f, -0.02315190f, -0.22807188f, 0.13607104f, -0.09276271f, -0.07209899f, 0.00186199f, 
    0.04965986f, 0.13202265f, -0.01395795f, 0.07872438f, -0.04395889f, 0.00181871f, 0.16819328f, 0.11021502f, 
    0.01132235f, 0.07549618f, -0.09953576f, -0.01980836f, -0.02793200f, -0.05868070f, 0.07063624f, 0.04734935f, 
    0.10253264f, -0.02334448f, -0.09612986f, 0.12203444f, -0.01612801f, 0.02738700f, -0.17150900f, 0.08562709f, 
    -0.03245572f, 0.01770765f, 0.12984963f, 0.05273882f, 0.14302839f, -0.02971718f, -0.03643774f, -0.16342385f, 
    -0.03792998f, 0.22556862f, 0.08289529f, 0.05509394f, -0.02802624f, -0.08715894f, 0.15659755f, -0.06528696f, 
    0.09951690f, -0.01179965f, -0.37387446f, 0.03095466f, -0.01972348f, 0.00361065f, -0.02099102f, 0.02331086f, 
    -0.14117698f, -0.08808775f, 0.16621855f, -0.06585987f, 0.18508747f, 0.14156976f, 0.51695198f, 0.27843642f, 
    -0.00953466f, 0.15382014f, -0.04947399f, 0.00932129f, -0.01868079f, 0.01946923f, 0.01129776f, -0.17336915f, 
    0.28269577f, -0.09469959f, -0.19055055f, 0.02831463f, -0.12122093f, -0.11176319f, -0.15763268f, -0.01117082f, 
    0.04998979f, 0.07303462f, -0.00790186f, -0.11989214f, -0.03062977f, -0.25618437f, -0.15225957f, 0.10880663f, 
    0.08097495f, 0.09617178f, 0.01492039f, -0.04516785f, 0.11395630f, -0.10284692f, 0.01416837f, -0.00201324f, 
    0.13889045f, 0.01367595f, 0.07289176f, -0.03467885f, -0.15149370f, -0.09844670f, -0.20352758f, 0.08728568f, 
    0.02268839f, 0.00344122f, 0.11992734f, 0.05713337f, -0.13108557f, 0.48353851f, -0.20771323f, -0.06255541f, 
    0.36720628f, 0.12613401f, 0.19158255f, 0.01610816f, 0.03748501f, -0.08759154f, -0.04407413f, 0.08300234f, 
    0.05234212f, -0.01747790f, -0.40376988f, -0.17537194f, 0.08733238f, 0.16411453f, -0.04745466f, 0.20177336f, 
    -0.07325266f, 0.10789252f, -0.00892287f, 0.01013636f, 0.11454693f, 0.18587050f, 0.23909031f, -0.02922729f, 
    0.01332498f, -0.00945455f, 0.01067535f, 0.02740952f, -0.00717765f, 0.01983054f, 0.11528768f, 0.10298831f, 
    0.14338580f, 0.05628970f, 0.55463094f, 0.24692905f, -0.14342123f, -0.05576703f, 0.06821152f, -0.04609080f, 
    -0.03714339f, -0.14251895f, -0.05330930f, 0.02246733f, -0.19525419f, -0.16283919f, -0.22463125f, -0.15144306f, 
    -0.01340149f, 0.05295526f, -0.00260365f, -0.01351591f, 0.12934840f, -0.01670761f, -0.01284456f, 0.13232552f, 
    0.25277451f, 0.13132086f, 0.21668728f, -0.09150366f, 0.17354706f, 0.05049489f, 0.07581735f, -0.02372604f, 
    0.01484729f, 0.01640826f, 0.07494520f, -0.07461740f, -0.24796683f, -0.22307903f, -0.29532799f, 0.03818977f, 
    0.04522800f, 0.02349642f, -0.08713681f, -0.00581030f, -0.00412344f, 0.01789117f, 0.03804661f, -0.06449653f, 
    -0.12191124f, 0.20485695f, 0.05423795f, 0.04049962f, 0.05430478f, -0.19721244f, -0.01770035f, 0.00635727f, 
    -0.18206936f, 0.01878444f, 0.04748000f, 0.17863423f, -0.02106357f, -0.12044815f, -0.08377170f, -0.06034624f, 
    0.03291152f, 0.05945639f, -0.09196682f, 0.05026635f, 0.19051927f, 0.00010298f, 0.06860306f, 0.05326372f, 
    0.23714907f, 0.06155853f, 0.19598186f, 0.20617200f, -0.04643063f, 0.02965587f, 0.05377292f, 0.09488316f, 
    0.02508531f, 0.00362807f, 0.03554895f, 0.09167185f, 0.26114395f, 0.17271951f, 0.02660977f, 0.02177201f, 
    0.02324902f, 0.22435518f, 0.13444766f, 0.02875857f, 0.05809857f, 0.04241246f, 0.05545055f, -0.13922751f, 
    -0.00599230f, 0.22994614f, 0.22209929f, -0.10117456f, -0.12335540f, 0.17184751f, -0.05529316f, 0.11709850f, 
    0.14781260f, 0.14092164f, 0.35101950f, 0.18104821f, -0.14211847f, -0.16194789f, -0.14373328f, -0.03684984f, 
    0.10189087f, -0.20639180f, 0.06905818f, 0.06695287f, -0.04339430f, 0.06262985f, 0.01440527f, 0.12062008f, 
    0.01071032f, -0.02948086f, 0.02887249f, -0.09028553f, 0.05581317f, -0.03814602f, 0.05110674f, -0.08448479f, 
    -0.14452133f, -0.02171872f, 0.03309091f, 0.02785281f, -0.01332192f, 0.16225219f, -0.04789952f, -0.04063164f, 
    -0.05451448f, 0.00905545f, -0.03148580f, -0.05564954f, 0.14233719f, 0.10955618f, 0.10408302f, -0.00764428f, 
    0.15489651f, -0.19384345f, 0.06966107f, -0.20668872f, 0.06491873f, 0.02156132f, 0.04698303f, 0.00397859f, 
    -0.07189516f, -0.03434141f, -0.05487336f, -0.00755465f, -0.17306203f, 0.02276419f, -0.03824369f, -0.09603632f, 
    -0.00283142f, 0.03459811f, 0.07192932f, -0.03193602f, 0.13561246f, 0.06096205f, 0.19509310f, 0.07965080f, 
    -0.08754126f, -0.14521001f, -0.04251741f, -0.02603902f, 0.12005054f, 0.01963506f, 0.01965253f, -0.00997962f, 
    0.02671668f, 0.16115466f, 0.02743176f, -0.00960620f, -0.01186315f, -0.06109631f, -0.04886539f, -0.08918138f, 
    -0.04356893f, 0.00995062f, -0.06312685f, -0.00768381f, 0.09041858f, -0.05688082f, 0.03108586f, -0.05171074f, 
    0.17395847f, -0.19492450f, -0.20248550f, -0.02472912f, 0.13443279f, -0.05071140f, 0.02452409f, 0.19437033f, 
    0.06195522f, 0.08536653f, 0.06156499f, 0.11149166f, -0.04578475f, 0.05602608f, 0.07066041f, -0.01310456f, 
    -0.03893322f, 0.02865777f, 0.02854694f, 0.04016596f, -0.09666424f, 0.02831135f, 0.06897099f, -0.16576670f, 
    -0.14577812f, -0.07559263f, 0.01279428f, -0.11500399f, 0.03558238f, -0.02132126f, 0.02200998f, 0.07257850f, 
    0.13667202f, 0.01402986f, 0.11712035f, 0.00788455f, -0.23451766f, 0.07888870f, 0.13285200f, 0.07926694f, 
    0.00308104f, 0.01131427f, -0.07527988f, -0.10778233f, -0.07144436f, 0.09032544f, 0.10340258f, 0.30037203f, 
    -0.21322057f, 0.04186282f, 0.17045693f, 0.05336250f, 0.02811512f, 0.01868570f, 0.04955858f, 0.09902798f, 
    0.06922214f, -0.05772100f, 0.22183436f, -0.16455895f, -0.04141902f, 0.01565428f, 0.00336279f, 0.05314911f, 
    0.04802741f, -0.06512617f, 0.13542247f, -0.05370637f, 0.07810375f, -0.09898864f, 0.20565248f, 0.07997552f, 
    -0.05538855f, -0.14142151f, 0.04311674f, -0.01581867f, -0.08674802f, 0.04967127f, 0.09063749f, -0.03247258f, 
    -0.01542986f, 0.00796014f, 0.03733844f, -0.01541827f, -0.16839693f, -0.16987297f, 0.04268599f, -0.04485219f, 
    0.04744650f, 0.10544501f, -0.01638508f, 0.01008752f, 0.02925706f, 0.05274595f, 0.15195426f, -0.04297475f, 
    -0.01671829f, 0.11684680f, 0.05362526f, -0.03645089f, 0.09491876f, 0.03692286f, 0.06318020f, -0.09198004f, 
    0.03709856f, 0.00104078f, 0.23251741f, 0.11206725f, -0.21871859f, -0.05792413f, 0.03660700f, 0.18120329f, 
    0.02111088f, -0.12562715f, 0.15128483f, 0.16600217f, 0.00593165f, 0.04153308f, 0.08272195f, -0.00746131f, 
    0.25947961f, 0.08160668f, -0.28087449f, -0.20475630f, 0.01742625f, 0.05788311f, 0.09071931f, -0.10046946f, 
    0.04874765f, 0.05681217f, 0.04071301f, 0.06224142f, 0.25690809f, 0.11362525f, -0.03789534f, -0.06899130f, 
    0.02012454f, -0.05306196f, 0.02435493f, -0.11015085f, 0.05296903f, 0.02275303f, -0.01950336f, -0.14836895f, 
    0.27655411f, -0.03714353f, -0.29067492f, -0.28730747f, 0.02554077f, -0.03518060f, 0.03125579f, 0.02388466f, 
    -0.07146963f, 0.01341702f, -0.05457946f, -0.05114678f, -0.28021348f, 0.13080251f, -0.04043850f, -0.01106617f, 
    0.02928341f, -0.03798617f, -0.00062519f, 0.01342068f, -0.08150505f, -0.10433979f, -0.11018416f, 0.02093789f, 
    0.03909510f, 0.00589763f, 0.05197275f, -0.19713444f, 0.12500070f, -0.03799296f, -0.01745673f, 0.03425781f, 
    -0.00985788f, 0.13081354f, -0.02418356f, -0.10359843f, -0.05491835f, -0.09043965f, 0.06505112f, 0.03679631f, 
    -0.18357791f, -0.05096758f, 0.00822586f, 0.06787634f, 0.08792807f, 0.07030202f, 0.09133333f, -0.07415152f, 
    0.01321677f, -0.29049161f, -0.08503413f, 0.20732161f, -0.05763830f, 0.01238723f, 0.03254972f, 0.12079430f, 
    0.00947545f, 0.16016530f, 0.04786504f, 0.07908640f, 0.18570618f, -0.07510227f, 0.12928717f, 0.01992839f, 
    -0.05139203f, 0.03614448f, -0.06850635f, 0.02295726f, 0.01630844f, -0.15185767f, 0.02415608f, -0.13417603f, 
    -0.16399470f, -0.02886482f, 0.19022655f, -0.09008951f, 0.07544548f, 0.04063427f, 0.00338108f, 0.04335545f, 
    0.14254907f, -0.07105578f, 0.04029600f, -0.12238359f, -0.00332153f, 0.03774832f, 0.03490163f, 0.18162325f, 
    -0.01254202f, -0.02429724f, -0.00790071f, -0.06814922f, -0.01479178f, 0.00753491f, 0.04931568f, 0.00547667f, 
    -0.15956393f, 0.01161533f, 0.03627480f, 0.18314727f, 0.02503623f, -0.02710628f, 0.09586649f, 0.05152928f, 
    -0.01528433f, -0.01103512f, 0.00353620f, 0.02513574f, 0.02192890f, -0.02381624f, -0.04973225f, -0.01200082f, 
    0.00549715f, -0.05572113f, -0.01446668f, 0.00716011f, 0.01644226f, -0.01785326f, 0.15530264f, 0.05728551f, 
    -0.00066941f, -0.01836680f, 0.02735745f, 0.01059488f, -0.06645869f, -0.00246031f, 0.07224531f, 0.06135686f, 
    0.06875973f, 0.05420468f, 0.03186864f, 0.09482206f, -0.10615136f, 0.06060812f, 0.10747330f, -0.12712279f, 
    0.07962785f, -0.02959545f, 0.09194218f, -0.05552370f, 0.14327413f, 0.17069085f, 0.01863451f, -0.16442689f, 
    0.19025986f, -0.10770934f, -0.12118784f, 0.30976179f, 0.04068885f, -0.03331021f, 0.02514635f, 0.03380643f, 
    -0.15543865f, 0.04608758f, 0.00006266f, -0.16409691f, 0.28884205f, 0.18821728f, 0.31232759f, 0.10987106f, 
    -0.01605958f, 0.17434166f, 0.04808988f, -0.05329530f, 0.05756338f, 0.07568395f, -0.02976403f, 0.02055979f, 
    0.29542667f, 0.14195615f, -0.06566053f, 0.23240519f, 0.05235558f, -0.06126077f, -0.11557020f, 0.00762947f, 
    0.08452623f, -0.06687789f, -0.04486267f, -0.01884887f, -0.13825378f, -0.23274960f, -0.18316424f, 0.02070417f, 
    0.08418474f, -0.02172335f, 0.03871490f, 0.16022013f, 0.04156435f, -0.03664687f, -0.07442865f, -0.02607928f, 
    -0.14665918f, 0.32049584f, 0.21683092f, 0.32071444f, 0.02338420f, -0.02297874f, -0.01641238f, 0.00571136f, 
    -0.01499831f, 0.07323214f, 0.03670352f, 0.02310508f, 0.00306498f, 0.03742472f, -0.14849271f, -0.09659984f, 
    0.10574146f, 0.13959990f, 0.19874433f, 0.18011105f, -0.07472238f, 0.07154452f, -0.02529094f, -0.03921116f, 
    -0.13604519f, -0.06026350f, -0.02255922f, 0.10107703f, -0.16652443f, 0.06178112f, 0.03516288f, 0.03373969f, 
    -0.10186875f, 0.03220616f, -0.04554564f, -0.04679123f, 0.02790979f, 0.19146462f, -0.01768609f, -0.08570263f, 
    0.14807238f, 0.07443827f, -0.06595866f, -0.02866044f, 0.03558753f, -0.04282940f, 0.05887569f, 0.06672689f, 
    -0.13615893f, 0.23596901f, 0.51624340f, 0.21156926f, -0.02757777f, 0.12101627f, 0.06761764f, -0.08862248f, 
    -0.04539930f, -0.00902409f, -0.01141458f, 0.05962024f, -0.21986510f, 0.05167262f, -0.23424427f, -0.00229492f, 
    -0.01387700f, -0.01718261f, 0.01623256f, -0.06352217f, 0.07504389f, -0.21548660f, -0.04949310f, -0.01808653f, 
    -0.02024837f, 0.09740410f, -0.16535127f, 0.31855240f, 0.20457992f, 0.03568334f, 0.04311529f, -0.01861046f, 
    0.07232182f, -0.03581996f, -0.10783954f, 0.04563547f, 0.10157182f, -0.05616102f, -0.08547669f, -0.24375823f, 
    -0.01616738f, 0.01535166f, -0.04860276f, 0.09775156f, 0.11608067f, -0.00666936f, -0.05020450f, 0.13041931f, 
    0.02822319f, -0.02756290f, -0.02321755f, -0.02686034f, 0.05908166f, 0.09627499f, 0.05329568f, 0.01319149f, 
    0.03117510f, -0.09061789f, -0.13259366f, -0.05365548f, -0.01202799f, -0.14685869f, -0.01960479f, -0.12563819f, 
    0.03863407f, 0.09811247f, -0.03440368f, 0.03749509f, -0.05158070f, 0.07531255f, -0.07799647f, 0.04861676f, 
    0.31883803f, -0.01761593f, 0.27779660f, 0.12985578f, 0.01788955f, -0.09845953f, -0.00484218f, -0.03238558f, 
    0.09880072f, -0.02140194f, -0.11494394f, 0.06033490f, 0.19206224f, 0.19671592f, -0.19494231f, 0.26434594f, 
    0.07087091f, 0.15122803f, -0.01552737f, 0.04081243f, 0.05793091f, 0.10007080f, -0.12365889f, 0.04059314f, 
    -0.27163848f, 0.12978365f, 0.08897383f, -0.02253978f, 0.04426990f, -0.08870238f, 0.19251850f, -0.16738096f, 
    0.02003848f, 0.16810809f, -0.02392783f, 0.02118321f, -0.07985180f, 0.07241432f, 0.18117668f, 0.19268031f, 
    0.04855709f, -0.08145145f, 0.23205279f, 0.04621115f, -0.04732268f, 0.04629153f, 0.13278556f, -0.05186565f, 
    0.02206952f, 0.08723921f, -0.45349512f, -0.27485546f, 0.01816138f, -0.05302570f, 0.04556108f, 0.11610851f, 
    0.04892773f, 0.00053912f, -0.05682502f, -0.09002697f, 0.29456034f, -0.44449458f, -0.08394471f, -0.32016417f, 
    -0.03207592f, -0.15951845f, 0.00936078f, 0.11131654f, 0.12221388f, 0.07460416f, 0.01506238f, 0.09865698f, 
    0.28625721f, 0.64052510f, -0.40568084f, -0.27160078f, 0.11398403f, 0.06765723f, 0.19082353f, -0.05233969f, 
    -0.02079573f, -0.17979106f, 0.08795388f, -0.06143423f, -0.53027910f, 0.32113120f, -0.14724587f, -0.01313564f, 
    -0.19340363f, -0.04159963f, -0.07317805f, 0.16141520f, 0.23287536f, -0.01582174f, -0.16763771f, -0.04453218f, 
    0.06892850f, 0.06139671f, 0.08152451f, -0.15636136f, -0.00445399f, 0.10440054f, 0.14996514f, 0.06561764f, 
    0.21011490f, -0.01465622f, -0.06644162f, -0.01201309f, 0.18745500f, 0.04193988f, 0.10986467f, 0.02085411f, 
    -0.06935477f, -0.02069324f, 0.12342049f, 0.11136916f, 0.05465464f, 0.03836962f, 0.01663961f, -0.01269789f, 
    0.09870825f, -0.12645380f, 0.06314785f, 0.17099161f, -0.10464310f, 0.15245222f, 0.17468157f, -0.05413659f, 
    0.04953702f, 0.13416599f, -0.01769818f, -0.04748228f, -0.08002181f, -0.39907378f, -0.08693574f, -0.07431046f, 
    0.00205725f, -0.06460892f, 0.01200613f, -0.09740728f, 0.00045806f, -0.23461857f, -0.05372338f, -0.07889591f, 
    0.22029589f, 0.00601384f, 0.10963658f, -0.04243254f, 0.02226955f, 0.02249194f, 0.03578311f, 0.10930556f, 
    0.03911373f, -0.09277675f, -0.07964634f, -0.08896178f, -0.45121539f, -0.22301279f, -0.15538704f, -0.05162757f, 
    -0.00330653f, -0.06212008f, -0.07658859f, 0.02006599f, 0.16723996f, 0.09372716f, 0.14665908f, 0.09721149f, 
    -0.12549022f, -0.12654883f, 0.00415865f, 0.08830979f, 0.13981320f, 0.01196429f, 0.02120144f, 0.02270534f, 
    -0.08389517f, -0.09122046f, -0.07614035f, 0.13295360f, -0.16815016f, 0.08647873f, -0.18088795f, -0.09536202f, 
    0.16238549f, -0.03650215f, -0.05648341f, 0.00506848f, 0.04587859f, 0.02464830f, -0.08001381f, 0.18310715f, 
    0.22406904f, 0.12704152f, 0.20012209f, 0.01439594f, -0.02028676f, -0.06273126f, 0.05859757f, 0.09694662f, 
    -0.04840833f, -0.00085174f, -0.05998118f, 0.06462236f, 0.13745767f, 0.07624901f, 0.09423643f, -0.10754376f, 
    -0.01597317f, -0.08974250f, 0.01595375f, -0.00218380f, 0.14862968f, -0.07682708f, -0.01779186f, -0.05838465f, 
    0.12682879f, -0.00607443f, -0.11046585f, 0.16454908f, 0.03442730f, -0.18320794f, 0.06283613f, 0.03822858f, 
    0.02988510f, 0.00167353f, 0.00957516f, -0.12849051f, 0.08514144f, 0.01121245f, -0.05970091f, 0.00863209f, 
    0.03620118f, 0.19423451f, -0.00538716f, 0.13693401f, -0.07198025f, -0.04369457f, -0.04844064f, 0.15877615f, 
    -0.07048305f, 0.21806823f, -0.03297318f, -0.04322112f, 0.08388572f, -0.14956327f, -0.04405401f, -0.04386860f, 
    0.04638590f, 0.00605908f, -0.10139868f, 0.06217407f, -0.00508063f, 0.11255544f, -0.23200366f, -0.02019827f, 
    -0.08643504f, -0.05696764f, 0.25450826f, -0.01584952f, 0.14464571f, 0.11872615f, 0.03679982f, 0.06516336f, 
    -0.27879241f, -0.02840317f, 0.14277367f, -0.07442266f, 0.05783292f, -0.22418840f, 0.03908787f, -0.16055270f, 
    0.10112878f, -0.15592793f, -0.01420799f, -0.00863782f, 0.24385716f, -0.00770332f, -0.23393421f, -0.20894662f, 
    -0.21176621f, -0.28263998f, 0.02828828f, 0.23104723f, 0.02995210f, -0.00760267f, -0.01745454f, 0.02828453f, 
    -0.05466365f, -0.14390765f, 0.12270822f, 0.02855841f, 0.03090052f, -0.06081074f, 0.05601750f, -0.13586499f, 
    -0.02301411f, -0.07947566f, 0.03668303f, -0.01795155f, -0.10274116f, -0.10298417f, -0.00291581f, 0.11544070f, 
    -0.01496312f, 0.05766277f, 0.14884369f, 0.01232299f, 0.08344099f, 0.00698915f, 0.01386642f, 0.04070337f, 
    0.07497416f, -0.01191672f, 0.28138456f, -0.03011760f, -0.04789481f, 0.21718198f, -0.09637271f, 0.00330085f, 
    0.04722754f, 0.02080217f, 0.03440274f, 0.07490640f, 0.08027185f, 0.01415099f, 0.08555188f, -0.03832856f, 
    -0.05998980f, -0.24843997f, -0.06102911f, 0.02949606f, 0.00972171f, 0.06087054f, 0.04235157f, 0.04352265f, 
    -0.34487143f, 0.17475212f, -0.21115042f, 0.28348011f, -0.05529884f, 0.14062694f, -0.01414664f, 0.04615590f, 
    0.11077719f, -0.03191400f, 0.07429378f, 0.04837191f, 0.22744761f, -0.00359855f, -0.15815844f, -0.24914517f, 
    -0.09170792f, -0.15828133f, 0.03156652f, 0.07963276f, 0.12709357f, 0.07777330f, 0.04671397f, 0.07418634f, 
    0.22143972f, -0.05980087f, 0.07909374f, 0.13323107f, -0.06363015f, 0.04560132f, 0.10385017f, -0.02504344f, 
    0.11526059f, 0.17883724f, 0.03694020f, 0.00568006f, -0.15231419f, -0.13717736f, -0.17618190f, 0.12462986f, 
    -0.05171330f, 0.04102286f, -0.01828339f, 0.03658520f, -0.08358324f, -0.00147663f, -0.03423649f, -0.03694895f, 
    0.22323488f, 0.01860937f, 0.00156854f, 0.18347640f, 0.03815764f, 0.06982988f, -0.12191997f, 0.02290175f, 
    0.04259878f, -0.03657160f, 0.01162569f, 0.10512671f, -0.07510374f, 0.21901107f, 0.13859810f, -0.12861466f, 
    0.07832895f, 0.03478797f, 0.11040182f, -0.06290267f, 0.17150453f, 0.05296494f, -0.04214932f, 0.10522249f, 
    -0.20216143f, 0.10221995f, -0.09450768f, -0.02611422f, -0.09843110f, -0.04178723f, -0.00381343f, 0.20241915f, 
    0.00040318f, 0.07934489f, 0.12254506f, 0.17559217f, -0.17644435f, -0.00532970f, -0.05992647f, -0.05267427f, 
    0.05394161f, -0.12563370f, -0.10955702f, 0.09140860f, -0.13615893f, 0.02310350f, -0.00634542f, -0.13170071f, 
    -0.24845064f, -0.07267017f, 0.07140454f, -0.05194632f, 0.00194415f, 0.01606215f, 0.00428149f, -0.08375246f, 
    -0.04933412f, 0.08319935f, 0.01957206f, 0.03304735f, 0.08048517f, -0.23794676f, 0.16347621f, 0.12465385f, 
    -0.02963736f, 0.00284260f, -0.08240173f, -0.12776989f, -0.03532659f, 0.16524008f, 0.04485242f, 0.07396094f, 
    -0.00309819f, -0.04833680f, -0.21575269f, -0.25809878f, 0.08158852f, 0.11992647f, -0.06557562f, 0.17329349f, 
    0.00006902f, 0.07243820f, 0.06083716f, -0.05361671f, 0.28022113f, 0.06187569f, 0.05183016f, 0.05541033f, 
    0.07191265f, 0.09287728f, -0.03461807f, 0.03684475f, 0.12499237f, -0.02557240f, 0.10873111f, 0.00577880f, 
    0.02606391f, -0.15628262f, 0.15757221f, 0.01363937f, 0.08197829f, -0.02229401f, 0.13717052f, 0.11670903f, 
    0.01282757f, 0.12486276f, -0.10762606f, 0.14119740f, 0.04490769f, -0.00696523f, 0.05616042f, -0.17555150f, 
    0.03113663f, 0.07224773f, -0.05088170f, 0.12189632f, -0.01414669f, -0.01236689f, 0.00848939f, -0.10586067f, 
    0.13130459f, -0.00700974f, 0.02099887f, -0.21165720f, 0.12956902f, 0.06241167f, 0.01435414f, 0.05916281f, 
    0.07172395f, 0.10028923f, -0.04424044f, -0.04013324f, -0.15414493f, -0.06209730f, 0.06044580f, 0.03312647f, 
    0.04279521f, 0.02571535f, -0.01091981f, -0.02305218f, 0.04778690f, 0.17298421f, 0.02319560f, -0.07487419f, 
    0.25446603f, -0.15958452f, -0.09651873f, -0.37880147f, -0.06715713f, 0.08928759f, 0.10772431f, 0.12440796f, 
    -0.01504285f, -0.05229528f, 0.10068039f, -0.10836851f, -0.08485240f, -0.04053907f, -0.05760752f, 0.13553147f, 
    -0.05384989f, 0.14141029f, 0.09271766f, 0.03686824f, -0.07040359f, 0.11578155f, 0.10595744f, 0.06199395f, 
    0.01589110f, -0.06522802f, -0.15956289f, -0.07401519f, 0.13511632f, -0.04637761f, -0.09179648f, 0.07696898f, 
    0.09154985f, -0.02156406f, 0.06611760f, -0.03822298f, -0.10329233f, 0.13368595f, 0.05961408f, -0.01554259f, 
    0.02321855f, -0.08691698f, 0.06282336f, 0.06928512f, 0.00111591f, 0.01656927f, 0.10610080f, 0.03691949f, 
    -0.09086540f, 0.05252215f, -0.16338983f, 0.07949162f, -0.01337688f, 0.07665283f, 0.11200047f, -0.02680716f, 
    -0.07352528f, 0.08226435f, 0.07989082f, 0.03889246f, 0.22849174f, -0.16820209f, 0.04069954f, -0.22287454f, 
    0.08161086f, 0.03756104f, -0.02596378f, 0.16085459f, -0.14558211f, -0.09732427f, 0.06542654f, 0.03270839f, 
    -0.19206516f, 0.31862482f, 0.14541590f, 0.02589431f, 0.01890286f, -0.07586270f, 0.08245516f, -0.05940126f, 
    0.06444492f, 0.00762358f, 0.19909424f, 0.09991585f, -0.11130827f, -0.01761561f, -0.02106378f, -0.01364723f, 
    0.06076325f, 0.03545025f, -0.07108176f, -0.13743159f, -0.02103871f, -0.17224430f, -0.14033903f, -0.16345584f, 
    -0.07237615f, 0.02703663f, -0.07882050f, 0.09401639f, 0.16005294f, -0.10281274f, 0.07560816f, 0.08477818f, 
    -0.04855174f, -0.10062653f, -0.12893958f, -0.13635333f, -0.36073685f, 0.29456595f, 0.03617758f, -0.22927457f, 
    -0.03684681f, -0.07738418f, 0.10541444f, 0.15667887f, 0.08457041f, 0.17539291f, 0.08672506f, 0.17740339f, 
    0.03834622f, -0.06249512f, -0.12254009f, 0.09177648f, 0.04338114f, 0.30010298f, 0.09127545f, -0.16269264f, 
    -0.05425001f, -0.18986565f, 0.06866662f, 0.10586882f, -0.11257078f, 0.02437201f, 0.43053257f, 0.14500417f, 
    -0.07280053f, -0.13892122f, -0.09456567f, 0.09066249f, 0.00355968f, -0.03041869f, 0.09822120f, 0.03699243f, 
    -0.13167016f, 0.07233497f, 0.09455509f, 0.01893913f, -0.06178237f, -0.05680031f, -0.14804676f, -0.16092317f, 
    0.19572701f, -0.02140444f, 0.07266906f, 0.07862016f, -0.07269216f, -0.14966889f, -0.06741519f, 0.20752245f, 
    -0.10790352f, -0.00545206f, 0.06946661f, 0.05550041f, 0.15689968f, 0.16934535f, 0.07543343f, 0.09011608f, 
    0.15486364f, -0.17454383f, -0.03929734f, 0.31885320f, 0.14762403f, 0.07552234f, -0.11848476f, -0.18831471f, 
    0.16284822f, 0.02410484f, 0.06785806f, 0.12964389f, 0.01793917f, -0.23629777f, -0.04937392f, -0.16473092f, 
    -0.09034122f, -0.06735104f, 0.03976984f, 0.01676334f, 0.17296971f, 0.33578497f, 0.32394475f, 0.13856152f, 
    -0.17382260f, 0.01134319f, 0.24809824f, 0.11814660f, -0.05732291f, -0.11950000f, -0.04206383f, 0.14443961f, 
    0.03817256f, -0.22568944f, -0.05393285f, 0.09387103f, 0.03969553f, 0.13077183f, 0.10117723f, -0.04821889f, 
    0.12876645f, -0.06640334f, -0.14248274f, -0.06184481f, -0.07675382f, 0.07959688f, 0.03024560f, 0.02801340f, 
    0.06879199f, -0.14695144f, -0.04849378f, 0.22417819f, -0.05159733f, -0.04538236f, 0.11079668f, -0.02897810f, 
    0.13201697f, 0.05561724f, 0.27628121f, 0.26611337f, -0.18346621f, 0.00972192f, -0.35439670f, -0.12686945f, 
    0.12605834f, 0.16506985f, -0.05906554f, -0.04208035f, -0.03875086f, 0.00942188f, -0.09353153f, -0.15233690f, 
    -0.14041606f, 0.02204647f, 0.07529273f, -0.16500729f, -0.06386907f, -0.02366840f, 0.16123593f, 0.02413796f, 
    0.26208469f, -0.00502619f, -0.07047650f, 0.16522947f, -0.01648616f, 0.07163085f, 0.21299118f, 0.07295565f, 
    0.01263034f, -0.09494738f, -0.10463575f, -0.05013712f, 0.10501333f, 0.00606138f, 0.11848504f, 0.04873896f, 
    0.01596636f, -0.01711348f, -0.30849162f, -0.05359144f, -0.10188558f, 0.10828049f, -0.01525364f, 0.01964999f, 
    -0.09005296f, -0.02784266f, -0.04350393f, 0.23616597f, 0.10716110f, 0.06494071f, 0.19859266f, 0.16617319f, 
    0.03941928f, -0.06649312f, -0.01693455f, 0.26184136f, -0.03303941f, 0.04132936f, 0.08074591f, -0.04266180f, 
    0.00169208f, -0.31093282f, -0.31260556f, -0.41010633f, -0.20860459f, -0.06306081f, -0.08326171f, -0.15089750f, 
    -0.19971904f, -0.05115072f, 0.04706484f, 0.07851017f, 0.55111223f, -0.43941206f, 0.05955033f, 0.27825513f, 
    -0.03988982f, 0.14963792f, -0.03970771f, -0.20463057f, -0.07064623f, -0.06319047f, 0.12042062f, 0.13024129f, 
    -0.05538453f, -0.34412405f, -0.31386694f, -0.48787245f, -0.10206521f, 0.09051820f, -0.06195904f, 0.05827099f, 
    -0.09420837f, 0.05318813f, -0.05311515f, -0.08099599f, 0.28731346f, 0.29314685f, -0.31893265f, 0.06165013f, 
    0.16485757f, 0.29554814f, 0.11110756f, 0.02984502f, 0.23136292f, 0.02369599f, -0.00607922f, -0.05093213f, 
    0.07212456f, -0.00692798f, -0.25352696f, -0.28639188f, 0.14813194f, 0.02875640f, 0.24305750f, 0.25598520f, 
    -0.25348231f, -0.00448468f, -0.07737297f, 0.04187930f, 0.18531154f, 0.17695795f, 0.25600168f, 0.05801788f, 
    0.06050745f, 0.08172271f, -0.12825145f, 0.13173610f, 0.06748519f, 0.05866981f, 0.06544214f, 0.06210475f, 
    -0.06905059f, 0.12478185f, 0.08311111f, -0.07940359f, 0.18352258f, -0.03684861f, 0.05665345f, 0.14345011f, 
    0.06528524f, -0.05657773f, -0.12676167f, 0.01110709f, -0.17587619f, -0.19114627f, -0.34389955f, -0.16586983f, 
    -0.14405654f, -0.04953182f, -0.04344337f, -0.04801350f, -0.22090583f, -0.17190960f, -0.17561269f, 0.00286521f, 
    0.33757347f, 0.11563754f, 0.19362868f, -0.12748814f, 0.08486672f, 0.28611001f, 0.18340516f, -0.08296590f, 
    0.05008361f, -0.03273014f, 0.13559127f, -0.01150604f, -0.64018697f, -0.68350440f, -0.59999371f, 0.07710539f, 
    -0.15269659f, -0.14006181f, -0.06862846f, -0.00377153f, -0.01619271f, 0.12541172f, 0.00765884f, -0.13566869f, 
    -0.09974245f, 0.11101017f, 0.10988872f, 0.01310072f, 0.08984824f, -0.15803052f, -0.11523554f, 0.08274026f, 
    0.05253422f, 0.08888695f, 0.16853541f, 0.06060820f, -0.05597532f, -0.40414038f, -0.11115887f, -0.11658219f, 
    0.06647827f, 0.01472166f, -0.04779232f, -0.17018305f, 0.10352459f, -0.05472691f, 0.01073219f, -0.02865389f, 
    0.12545502f, 0.19764906f, -0.11523578f, 0.25262693f, 0.09675460f, 0.12274928f, -0.07065338f, 0.05589091f, 
    -0.09566431f, 0.04717254f, 0.23686725f, 0.10647564f, 0.22770189f, 0.08166224f, 0.23873927f, -0.00101983f, 
    0.07764442f, 0.14417724f, 0.25924274f, 0.24122132f, 0.02582381f, -0.14998241f, 0.09302498f, -0.00400181f, 
    -0.00380167f, 0.07984735f, -0.30066410f, 0.09924347f, 0.05446619f, -0.05866197f, -0.03111547f, 0.09705658f, 
    0.15241574f, 0.01588025f, 0.17250760f, 0.00807146f, 0.10249703f, 0.20639777f, 0.24429162f, 0.04150056f, 
    -0.01445789f, 0.04075227f, 0.01796719f, 0.03393994f, 0.10806327f, 0.05495074f, -0.21936324f, -0.11903942f, 
    -0.03081967f, -0.25628179f, -0.21730796f, 0.19591649f, 0.02742372f, 0.05043661f, -0.13280003f, 0.21810885f, 
    0.06932566f, 0.01553078f, -0.18452160f, -0.17674327f, -0.24335769f, -0.22436354f, -0.16662802f, -0.04809345f, 
    0.09681743f, -0.23845811f, 0.01016704f, -0.15312374f, 0.12419470f, 0.06038566f, 0.15819867f, 0.12255576f, 
    -0.21915188f, -0.28328475f, -0.18717675f, 0.07111213f, -0.00597313f, 0.00262496f, -0.01631179f, 0.05167513f, 
    0.05359577f, -0.20024855f, -0.09247990f, -0.05443629f, -0.04388769f, 0.29007065f, -0.06266653f, -0.15549195f, 
    0.17087954f, 0.04206337f, 0.05068077f, 0.03886582f, -0.09754799f, -0.02583355f, 0.13404173f, 0.14677417f, 
    0.06675286f, -0.21470706f, -0.21396327f, -0.41012710f, 0.02079129f, 0.00112810f, -0.09722008f, 0.02699075f, 
    0.17296162f, 0.04006600f, 0.20354302f, -0.06149037f, 0.21354707f, 0.16806309f, 0.24721959f, 0.03374944f, 
    0.12248632f, 0.07245468f, 0.04511480f, 0.06647391f, -0.01633205f, 0.01699123f, 0.08773703f, 0.08357868f, 
    0.17209382f, 0.01612205f, 0.46170625f, 0.25749022f, -0.08617194f, 0.08353442f, -0.07096287f, 0.05579444f, 
    0.04126712f, 0.03881885f, -0.06742237f, -0.02346338f, 0.14580722f, -0.21948871f, -0.15023834f, -0.02372973f, 
    0.06076561f, -0.14514965f, 0.19144990f, -0.10907100f, 0.03625195f, 0.04178594f, 0.05311265f, -0.00436178f, 
    0.03623768f, -0.06557975f, 0.18140037f, -0.08926357f, 0.00574559f, -0.07998066f, 0.15426692f, -0.02485960f, 
    -0.09069663f, -0.13415037f, -0.06624892f, 0.04337891f, -0.12300303f, 0.03487341f, -0.03358116f, 0.12529925f, 
    0.16623290f, 0.00508114f, -0.06638055f, -0.04452653f, 0.04481092f, 0.04832328f, 0.10345697f, 0.16863930f, 
    -0.07270513f, 0.27979937f, 0.03956432f, 0.15065745f, -0.05667838f, 0.01821292f, -0.06693690f, -0.05304212f, 
    -0.17389190f, -0.03041882f, 0.00203411f, 0.02767152f, -0.21329115f, -0.12567042f, -0.19178690f, -0.05156168f, 
    0.06015995f, 0.02643375f, 0.03407815f, 0.05588211f, 0.13784306f, 0.10506767f, 0.12987645f, -0.01945569f, 
    -0.04025187f, 0.26007435f, 0.20467380f, 0.04591447f, 0.12805180f, 0.11464816f, -0.04043074f, 0.10589006f, 
    0.09275147f, 0.06185966f, 0.02541603f, 0.02988804f, 0.17030798f, 0.20840058f, -0.01419905f, 0.00997074f, 
    0.00324854f, -0.03104034f, 0.02284550f, -0.05316982f, 0.01185133f, -0.10811510f, -0.05477384f, -0.08478289f, 
    -0.03764559f, 0.17009178f, 0.05040026f, -0.23210584f, 0.20758462f, -0.10321059f, 0.24526411f, -0.15540433f, 
    0.11863384f, 0.10152287f, -0.01541017f, 0.02386781f, -0.26881495f, 0.03777325f, -0.02007592f, 0.06911018f, 
    -0.04953271f, -0.07457468f, 0.08746123f, 0.06251647f, 0.03570164f, -0.07528599f, 0.02124917f, 0.00762476f, 
    0.07030019f, 0.24362339f, -0.33378795f, -0.29965582f, 0.08986998f, 0.02094756f, 0.10107224f, -0.05188583f, 
    0.08163040f, 0.03648390f, -0.04127252f, 0.04301647f, 0.20804118f, 0.15122490f, 0.04387285f, -0.21673553f, 
    -0.09456100f, -0.11425955f, -0.01167528f, -0.12307338f, 0.04911729f, 0.04249706f, 0.05156062f, 0.12644988f, 
    0.30614045f, 0.29651043f, -0.26710105f, -0.16425659f, 0.13028567f, 0.06818051f, 0.30900967f, -0.11273225f, 
    0.05823299f, -0.04038958f, -0.00481394f, -0.07941353f, -0.38536081f, -0.10285665f, 0.10326994f, 0.17940390f, 
    -0.09762789f, -0.15436816f, -0.03436069f, 0.09055489f, 0.02988904f, 0.03577926f, 0.00739334f, -0.06571005f, 
    0.08400839f, 0.11948362f, 0.08993342f, -0.17854187f, 0.07736360f, 0.00990785f, -0.02849901f, -0.06039285f, 
    0.13241743f, -0.10034481f, 0.02413251f, 0.07733245f, -0.05270604f, 0.08778815f, 0.09654853f, -0.00650330f, 
    -0.14849430f, 0.06665269f, 0.03593064f, 0.06065713f, 0.01358023f, 0.13164939f, 0.10751484f, -0.04005328f, 
    -0.22439002f, -0.20850261f, -0.13905698f, 0.28446925f, -0.05110905f, 0.19590272f, -0.07330082f, 0.13588046f, 
    0.02231404f, -0.04757513f, 0.13042501f, 0.04696082f, 0.22451764f, -0.04753545f, 0.24048124f, 0.03170269f, 
    -0.01781697f, -0.08089941f, 0.06104301f, 0.06390063f, 0.03308611f, -0.11093894f, 0.12137754f, -0.06440337f, 
    -0.09960610f, 0.05442699f, 0.21762654f, -0.04753115f, -0.03168116f, -0.04367730f, -0.02199895f, 0.20096065f, 
    0.00651291f, -0.00394226f, -0.10945439f, -0.01834758f, 0.17766240f, 0.01122069f, 0.12037379f, 0.21710578f, 
    0.04277385f, -0.03492120f, 0.00723845f, -0.05978312f, 0.09243847f, -0.06052643f, 0.07671207f, 0.04076858f, 
    -0.00090114f, -0.20675515f, -0.08343279f, 0.06899946f, -0.12840974f, 0.03962686f, 0.11281908f, -0.05252863f, 
    0.12160719f, 0.09812360f, 0.10458422f, 0.15709552f, 0.17692214f, 0.02610848f, -0.09370402f, 0.05122178f, 
    0.12004653f, 0.11171502f, -0.02394033f, 0.01534073f, -0.00119854f, -0.03927785f, -0.07141387f, -0.03471099f, 
    -0.05006339f, 0.03340785f, 0.07730689f, -0.03521387f, -0.07735436f, -0.00839652f, 0.02168691f, 0.08042827f, 
    0.08447032f, 0.02106627f, 0.06688780f, 0.09063810f, -0.09291018f, 0.19086269f, 0.20557070f, -0.05792017f, 
    -0.13738632f, -0.12126051f, -0.05088113f, -0.16404873f, -0.00880864f, 0.03529806f, 0.08067150f, -0.07974050f, 
    -0.17900258f, 0.34069103f, 0.10166240f, 0.14336386f, -0.10239340f, 0.20378050f, -0.06638947f, 0.06579300f, 
    0.02290349f, 0.11675560f, 0.18970741f, 0.04840213f, 0.16388276f, 0.02094421f, 0.04646309f, -0.09307921f, 
    0.01234872f, -0.04970325f, 0.09909256f, 0.02933952f, 0.07504103f, 0.07507496f, 0.05605724f, 0.13271800f, 
    -0.04708481f, -0.02428847f, 0.08991400f, 0.03274599f, 0.01311040f, 0.07262717f, -0.07058813f, -0.01885531f, 
    -0.13558620f, 0.05302460f, -0.05547190f, 0.03816682f, -0.45160535f, 0.04875137f, -0.10458273f, 0.01968478f, 
    -0.01859850f, -0.10020866f, 0.06993538f, 0.17199917f, -0.09160145f, 0.12763380f, 0.03819521f, -0.01125463f, 
    -0.10265615f, -0.16711313f, 0.17833732f, -0.00831966f, 0.06165533f, 0.17933111f, -0.08531519f, 0.10876303f, 
    0.06559168f, -0.07937425f, 0.07217351f, -0.01916124f, 0.08064158f, 0.20046693f, -0.13934337f, -0.17417915f, 
    0.04284473f, -0.02977222f, 0.01144714f, 0.08979209f, -0.01201992f, 0.03060938f, 0.14660223f, 0.04249049f, 
    -0.21971843f, -0.23300932f, 0.10833260f, 0.10168410f, -0.01395042f, 0.14464270f, 0.07518739f, -0.05353458f, 
    0.05448597f, -0.01410613f, 0.19249830f, 0.00600944f, -0.11269775f, -0.20837945f, -0.09932689f, 0.03625188f, 
    -0.02174866f, -0.00261803f, 0.03048232f, -0.02731512f, -0.07418771f, -0.12142141f, -0.00823542f, -0.07520769f, 
    0.32891789f, -0.16449407f, 0.03907125f, 0.00287306f, 0.07629631f, 0.21369860f, 0.01022813f, 0.07940342f, 
    0.07855693f, 0.02925639f, 0.19803259f, 0.11157740f, -0.03070037f, 0.12650485f, -0.11878558f, -0.01878460f, 
    -0.08170425f, -0.02141516f, 0.00986844f, -0.01284875f, 0.01065102f, 0.14964727f, -0.01980946f, -0.09247188f, 
    -0.04136474f, -0.23564020f, -0.05112417f, -0.09801122f, -0.06860124f, -0.05474943f, 0.12777583f, 0.05936946f, 
    -0.06126349f, -0.10600918f, -0.01511285f, 0.08608732f, -0.09598465f, 0.13816606f, -0.05608911f, -0.19383669f, 
    -0.03476354f, 0.02774320f, 0.06010208f, 0.01023454f, 0.08633463f, 0.09318569f, 0.02500898f, 0.15481214f, 
    -0.19953233f, 0.14499378f, 0.01876872f, 0.05411821f, -0.10598034f, -0.02025694f, 0.07345390f, 0.11101598f, 
    -0.03072535f, -0.12917885f, 0.09546472f, -0.01554083f, 0.00195688f, -0.01402192f, 0.04300929f, -0.10546370f, 
    -0.00531977f, -0.05771260f, 0.09102833f, 0.02280028f, -0.02561594f, 0.05847229f, 0.10098466f, 0.11163430f, 
    -0.08462156f, -0.12120397f, 0.09902855f, -0.15801850f, 0.04854808f, -0.06225879f, 0.15797339f, -0.05220232f, 
    -0.01629761f, -0.00425929f, -0.02877316f, -0.07423886f, -0.11179900f, -0.07679110f, -0.15095705f, 0.08508047f, 
    0.05149447f, 0.17011611f, -0.13063574f, -0.09269189f, -0.09531161f, 0.08512299f, 0.03279544f, 0.06337065f, 
    -0.00366300f, 0.00475824f, -0.02730100f, -0.07787923f, 0.02933985f, -0.01922735f, -0.06359318f, -0.00248092f, 
    0.05661439f, 0.02237514f, -0.00757118f, -0.07753637f, -0.01433665f, -0.06278329f, -0.06249843f, -0.01736146f, 
    0.04436245f, -0.06373252f, 0.02673290f, -0.07145458f, 0.05723778f, -0.01441507f, -0.00734554f, 0.03452868f, 
    0.04280176f, -0.04095746f, 0.00193414f, 0.00218469f, -0.03158306f, 0.01116624f, -0.05960433f, -0.06944720f, 
    -0.00463373f, 0.03140249f, -0.03166701f, -0.03733128f, -0.05525657f, -0.06277825f, 0.00495857f, -0.06737625f, 
    -0.02460108f, 0.03603542f, 0.01059722f, -0.05190080f, 0.00948483f, -0.07096516f, -0.00592065f, -0.06724555f, 
    0.00351409f, 0.01898892f, -0.01891544f, -0.02948168f, -0.05548277f, 0.04896789f, 0.01792522f, -0.05861531f, 
    0.00536623f, 0.00117000f, 0.00840697f, 0.03527861f, -0.02093010f, -0.06583133f, 0.01794720f, 0.06045527f, 
    0.06405183f, -0.04992452f, 0.04897868f, -0.02747235f, -0.02473559f, -0.00355423f, -0.07109145f, -0.04432298f, 
    -0.04028377f, 0.03829306f, 0.01570767f, 0.00099597f, -0.02771237f, 0.04754638f, 0.00032302f, -0.01642684f, 
    -0.06359791f, 0.01940903f, -0.01388946f, -0.05139792f, -0.04220732f, 0.00544643f, 0.05678575f, -0.04117974f, 
    -0.07897995f, 0.01021506f, -0.01051423f, 0.00365524f, -0.06828560f, 0.05104096f, 0.05977613f, -0.05642026f, 
    0.05031023f, 0.03344987f, -0.01140169f, -0.04631009f, -0.01290820f, 0.01506962f, -0.02963258f, 0.01314401f, 
    -0.00230312f, -0.00257215f, 0.06395735f, -0.02500550f, 0.00060307f, 0.04945865f, -0.02297670f, 0.00821702f, 
    -0.04091162f, 0.05729691f, -0.06854747f, -0.06492294f, 0.01297675f, -0.05576108f, -0.04430709f, -0.02515763f, 
    -0.05153125f, -0.04436382f, -0.06919608f, 0.01683692f, -0.07915295f, 0.05230537f, -0.04063677f, -0.02239809f, 
    0.02018580f, -0.04477339f, -0.00615320f, -0.00450362f, 0.00006673f, -0.02918276f, -0.07161633f, 0.04460019f, 
    0.00108607f, -0.04444749f, -0.05263538f, -0.02812142f, -0.00225280f, -0.07770029f, 0.04846594f, 0.02109984f, 
    0.00201628f, -0.07772492f, 0.01275938f, 0.02436821f, 0.05791260f, 0.06208900f, -0.06751679f, -0.02216055f, 
    0.00973236f, -0.06099282f, -0.06279854f, 0.03824860f, -0.01803035f, -0.01213357f, -0.07337133f, -0.04240994f, 
    0.03047803f, 0.05872505f, 0.05596222f, -0.04014943f, -0.06452080f, -0.00071832f, -0.00428176f, -0.00952198f, 
    -0.04835131f, -0.02764100f, 0.01555540f, 0.04499047f, 0.01087596f, 0.03859703f, -0.01359561f, 0.03635553f, 
    -0.00228399f, 0.02764522f, -0.05307460f, -0.06812813f, -0.02464289f, -0.02884524f, -0.04946984f, 0.02400846f, 
    0.00680288f, -0.06115131f, -0.04982982f, -0.01740536f, -0.07622103f, -0.06026250f, 0.04775691f, -0.04204462f, 
    0.04768851f, 0.00205597f, 0.01542156f, 0.00920876f, 0.03277623f, 0.00194822f, -0.03558503f, 0.00900800f, 
    -0.07780205f, 0.02146159f, -0.04162261f, -0.07651396f, 0.05964749f, 0.05118154f, -0.06715745f, -0.00044357f, 
    -0.01604272f, -0.05661555f, 0.04769381f, 0.00882758f, 0.01395831f, -0.01615221f, -0.03290699f, 0.05890451f, 
    -0.06305839f, 0.06389530f, 0.01719934f, 0.00268083f, -0.01657685f, 0.04721878f, 0.02200122f, -0.00153984f, 
    0.02641128f, 0.02874994f, 0.03682321f, -0.05181227f, -0.05652336f, 0.01565018f, -0.08049309f, 0.05486630f, 
    0.04176518f, -0.00426592f, 0.04038023f, -0.07228436f, -0.03901504f, 0.05869826f, -0.05426722f, -0.05390206f, 
    -0.05519101f, 0.00645704f, -0.06025716f, 0.01350711f, 0.02105463f, 0.04446177f, 0.03458574f, -0.02906747f, 
    0.00038211f, -0.04573578f, -0.07389302f, -0.03259192f, 0.02421565f, 0.00017424f, 0.02806159f, 0.04011892f, 
    0.01879541f, -0.05727624f, 0.02747679f, -0.05360720f, 0.01332919f, -0.01166516f, -0.01781761f, -0.01443644f, 
    0.00886077f, -0.04517319f, 0.02022511f, 0.00057223f, -0.01535448f, 0.02270206f, -0.05975497f, -0.04371497f, 
    0.01328334f, 0.01086581f, 0.04185840f, 0.00894380f, -0.05857628f, -0.05708620f, 0.04132751f, -0.02873396f, 
    -0.05962905f, -0.06498170f, 0.01471938f, -0.03040076f, -0.00533002f, 0.04651298f, -0.04482688f, -0.02522671f, 
    -0.06382664f, 0.01052866f, 0.00195875f, -0.04905128f, 0.04921032f, 0.00135990f, -0.03495201f, 0.01880931f, 
    -0.06858731f, -0.05674325f, 0.00707912f, -0.01107272f, -0.07482172f, -0.03767850f, 0.05307541f, -0.04710056f, 
    0.02913181f, -0.07200021f, -0.03385964f, -0.00397841f, -0.06884903f, 0.06218563f, 0.03406810f, -0.02626052f, 
    -0.01365203f, 0.06286214f, 0.00226587f, -0.06181103f, -0.01714046f, -0.02887362f, 0.03078818f, -0.02581924f, 
    0.02383833f, -0.07386759f, 0.04482028f, -0.01613692f, -0.02136170f, 0.04852627f, -0.00175974f, -0.06399375f, 
    -0.07852658f, -0.03292085f, 0.03894540f, -0.01576693f, 0.00017816f, -0.03318723f, -0.05416023f, 0.04103268f, 
    0.01797229f, 0.02422136f, -0.04815020f, -0.00458628f, 0.01398197f, 0.04444990f, -0.00825764f, -0.06889617f, 
    -0.07211073f, -0.04480997f, -0.02354413f, -0.06040690f, -0.02659329f, -0.07995402f, -0.05018054f, 0.00941209f, 
    -0.02719964f, -0.02833603f, -0.00270977f, -0.02950651f, -0.06838072f, 0.01493531f, 0.03693044f, -0.01872451f, 
    -0.02480889f, -0.03867853f, 0.01659697f, 0.04730953f, 0.05744693f, -0.01813818f, -0.06160985f, -0.02812846f, 
    0.05169125f, -0.07736305f, 0.03344190f, 0.04719352f, -0.06047613f, 0.04466858f, 0.00155169f, 0.04539744f, 
    -0.06049059f, -0.02648930f, 0.00719642f, -0.06779551f, 0.00917231f, -0.06463487f, 0.00694237f, -0.04613871f, 
    -0.00582780f, 0.04278751f, -0.37994230f, 0.08555535f, -0.03198257f, -0.11658490f, 0.01512246f, 0.14367484f, 
    -0.05004070f, 0.15879941f, 0.12150579f, 0.01193532f, -0.18978041f, -0.05300494f, 0.01188665f, -0.09728473f, 
    0.18921128f, 0.06347056f, 0.00197641f, 0.00607887f, -0.06598348f, 0.06937682f, 0.01837651f, 0.08125231f, 
    -0.03274648f, 0.13606493f, 0.01562843f, 0.26857823f, -0.03679555f, 0.08038666f, -0.06160903f, 0.05737743f, 
    0.01237024f, 0.00553753f, 0.04829281f, 0.02279476f, 0.01920770f, -0.32095394f, -0.02441422f, 0.01375238f, 
    -0.00096496f, 0.14439432f, 0.11448167f, -0.14785542f, 0.09229202f, 0.03165222f, -0.00413997f, 0.04214318f, 
    -0.26334411f, 0.21388657f, 0.09268906f, -0.15679349f, 0.09698472f, -0.00439141f, -0.06560806f, -0.05442637f, 
    -0.07342412f, 0.03471684f, -0.02987781f, 0.03222477f, 0.02060792f, 0.08750324f, -0.18634681f, -0.06884252f, 
    -0.06854747f, 0.09910329f, 0.09525280f, 0.08352545f, 0.06749257f, -0.03143902f, -0.13901977f, -0.03217762f, 
    0.10467736f, -0.27080727f, 0.05942050f, -0.11239267f, 0.05447295f, 0.04862664f, 0.04050776f, -0.02983369f, 
    0.19130261f, 0.12753250f, -0.00697836f, -0.06387435f, 0.06227760f, 0.05217947f, 0.11356634f, -0.20524094f, 
    -0.01190835f, 0.04240922f, 0.10270056f, -0.00375153f, -0.00970001f, -0.15691456f, 0.05249868f, 0.02615255f, 
    0.26193053f, -0.01453565f, 0.35832620f, -0.08617767f, 0.02993513f, 0.07717323f, 0.03424516f, 0.13065402f, 
    -0.01328044f, 0.03229091f, 0.12410302f, 0.05241316f, 0.00218850f, -0.01184904f, 0.00482755f, 0.05838643f, 
    0.01916871f, 0.01340578f, 0.00486625f, 0.04140281f, 0.11510357f, -0.02161362f, -0.01705373f, -0.09291252f, 
    0.17713401f, -0.26040056f, 0.05298438f, -0.28995964f, 0.11405233f, 0.18116871f, 0.18934746f, -0.01899363f, 
    -0.07441270f, -0.07623239f, -0.06668311f, -0.04807406f, -0.04723540f, -0.08281168f, -0.01908216f, 0.22757258f, 
    -0.04298730f, 0.10395759f, 0.04929328f, 0.08445142f, -0.01723731f, 0.11850611f, 0.10889205f, 0.03862008f, 
    0.12846085f, -0.00762551f, -0.02246059f, -0.01671814f, 0.05656945f, -0.02519199f, -0.10622238f, -0.06083485f, 
    0.04658953f, -0.02041988f, -0.10683005f, -0.15863080f, -0.14299409f, -0.00754260f, 0.07702514f, 0.10914798f, 
    0.03886165f, -0.07935574f, -0.00737109f, 0.01027443f, 0.01609221f, -0.03917646f, 0.03757234f, 0.10280497f, 
    0.22557057f, 0.13567173f, -0.09503863f, 0.23032729f, -0.04306833f, 0.05813520f, -0.19939590f, 0.14023547f, 
    -0.11512352f, -0.05760891f, 0.05401295f, -0.03554240f, 0.20101249f, -0.03694687f, -0.05157769f, -0.25830656f, 
    0.03179848f, 0.08721913f, 0.22672917f, -0.07981361f, 0.08333789f, -0.07392000f, 0.04084652f, -0.13145959f, 
    0.13720647f, 0.01005655f, 0.19075854f, -0.07946064f, -0.02960314f, 0.12639518f, 0.05834537f, 0.06083272f, 
    0.07184090f, 0.11520946f, 0.09701841f, 0.11973634f, -0.14416791f, 0.01856174f, 0.00109236f, 0.09758149f, 
    0.12890597f, -0.12273385f, 0.09570441f, 0.07437224f, -0.02852890f, -0.03415933f, 0.06181506f, 0.06410183f, 
    0.15583195f, 0.10101775f, 0.25659138f, -0.19203155f, -0.21466978f, -0.15555096f, -0.04532492f, -0.08206434f, 
    -0.03335010f, 0.01091552f, -0.02138622f, -0.05156057f, 0.26254910f, -0.05992759f, 0.19863094f, -0.04378331f, 
    -0.03223564f, 0.03224175f, -0.15155423f, 0.04762461f, -0.01632077f, -0.03829178f, 0.02200869f, -0.00374597f, 
    0.23140943f, 0.32316849f, 0.04526129f, -0.17146280f, -0.06134583f, -0.07326651f, -0.08253050f, 0.08703756f, 
    -0.05848692f, 0.06345902f, 0.00117851f, 0.02218278f, -0.30602297f, -0.13000734f, -0.07227015f, 0.11203062f, 
    -0.02068603f, -0.03026492f, -0.06853275f, 0.03737044f, 0.00358932f, -0.00210748f, -0.01266080f, 0.04002795f, 
    0.06456280f, 0.20964381f, 0.03235711f, 0.06196940f, -0.01939145f, 0.05469357f, 0.14794923f, 0.09535069f, 
    -0.03850429f, 0.05375295f, -0.19379519f, 0.10488424f, -0.09243840f, 0.08738280f, -0.00003747f, -0.08638756f, 
    -0.01165084f, -0.09959605f, 0.00836550f, 0.06674653f, 0.10579918f, 0.02170457f, -0.03181819f, -0.06904195f, 
    -0.26029018f, -0.03091736f, -0.36750913f, 0.03779428f, 0.06967644f, -0.07671995f, 0.15685917f, 0.05231776f, 
    0.01965249f, 0.05056193f, 0.06167484f, 0.11741728f, -0.04902096f, 0.07675488f, 0.01935317f, -0.01450740f, 
    -0.13439496f, -0.06396989f, -0.17481226f, -0.01209529f, 0.02268078f, 0.00580039f, -0.07293689f, -0.04056989f, 
    0.04073729f, 0.14572231f, 0.20737472f, 0.03905929f, 0.02422208f, -0.09858267f, 0.01519694f, 0.15089945f, 
    -0.03405639f, 0.10294700f, 0.01431204f, -0.06104928f, -0.15786274f, 0.00227449f, 0.01368648f, 0.11546344f, 
    -0.07873572f, -0.01674623f, -0.06346081f, -0.05351913f, 0.08437737f, 0.06480418f, -0.03839405f, 0.04928717f, 
    0.03131197f, -0.00428560f, 0.07249362f, -0.00626171f, 0.12754489f, -0.00885715f, -0.00037465f, 0.10784978f, 
    0.18492082f, 0.06362432f, -0.00854692f, 0.00466538f, 0.11775102f, -0.01613169f, 0.11666559f, 0.06461901f, 
    0.02655373f, -0.08405583f, -0.02704379f, 0.10692092f, 0.06130281f, 0.06085528f, 0.00603383f, 0.19326645f, 
    -0.03482249f, -0.10072526f, -0.05902887f, 0.06552749f, 0.07180155f, -0.12795629f, -0.08308163f, 0.01802055f, 
    -0.04154484f, 0.08275662f, 0.09058198f, -0.08817472f, -0.17573656f, 0.09011751f, 0.17666072f, 0.09129558f, 
    -0.02844956f, -0.16056690f, 0.17070298f, 0.26836377f, 0.00390162f, -0.00356909f, 0.01023413f, -0.01057240f, 
    0.29748130f, 0.10767525f, 0.31703344f, -0.07346024f, 0.01268132f, 0.21904664f, -0.06441418f, -0.00048040f, 
    0.13166809f, -0.03865117f, 0.12051197f, 0.18176442f, -0.03204007f, 0.08774162f, 0.00655411f, -0.10424468f, 
    -0.11626228f, -0.05412960f, 0.04039815f, 0.01093512f, 0.00110630f, 0.11821575f, 0.03850168f, 0.03317931f, 
    0.36165926f, -0.31732017f, 0.07273884f, 0.06287485f, 0.07901608f, 0.02658654f, -0.06271213f, -0.08748726f, 
    -0.02275417f, -0.03764350f, -0.06464764f, -0.04695476f, 0.09796970f, 0.13114807f, -0.17479572f, -0.02524914f, 
    -0.04072933f, -0.08611259f, -0.09929748f, 0.09402661f, -0.04135240f, -0.05384500f, 0.12989433f, -0.28580827f, 
    0.41456792f, -0.25861311f, -0.07020787f, 0.04369680f, -0.00802053f, 0.12787430f, -0.03643760f, 0.05342562f, 
    -0.10352412f, -0.02759127f, -0.06145217f, 0.02481530f, -0.37770864f, 0.17149541f, 0.20543131f, -0.01163944f, 
    0.06751101f, 0.04532386f, -0.03387559f, -0.04748004f, -0.08254655f, 0.02720553f, 0.16966926f, 0.04897282f, 
    -0.19203310f, 0.09788758f, -0.01584856f, 0.16709702f, -0.05100245f, 0.05879412f, -0.12218666f, -0.06751158f, 
    -0.10902176f, 0.09521540f, 0.05321256f, -0.01033972f, -0.08429120f, 0.03141482f, -0.04230936f, 0.00010696f, 
    0.06046505f, -0.04901772f, -0.06663873f, 0.09201961f, 0.06049167f, 0.10185920f, 0.00042209f, -0.14091568f, 
    -0.15701494f, 0.20124173f, -0.04828261f, -0.00236887f, -0.06353290f, -0.03235145f, 0.09931765f, 0.16702770f, 
    0.03430908f, 0.19296788f, 0.11132479f, -0.02255743f, 0.02775235f, 0.12437597f, -0.04975152f, 0.18038617f, 
    -0.00768776f, 0.09494475f, -0.00730568f, 0.00727016f, 0.12105233f, -0.02513974f, -0.04501560f, -0.08884903f, 
    -0.02852533f, 0.14374322f, -0.12300603f, 0.06524175f, 0.12307354f, -0.24050368f, -0.05805876f, -0.04089214f, 
    0.17625710f, -0.02612334f, 0.04208171f, -0.00911450f, -0.20205106f, 0.02269582f, 0.16142611f, 0.03810442f, 
    -0.06009356f, -0.05359583f, -0.07211632f, 0.00032132f, -0.00883925f, -0.02152906f, 0.03464575f, 0.21256319f, 
    -0.19905421f, 0.08113763f, 0.15613586f, -0.14943446f, 0.08102203f, 0.19569249f, 0.06776513f, 0.05724401f, 
    0.08424310f, -0.10996594f, 0.11847517f, -0.12332705f, 0.15792403f, 0.02612641f, -0.03643739f, -0.08856589f, 
    0.03773027f, 0.13350296f, 0.01884817f, -0.01200278f, 0.03899972f, -0.10270823f, 0.13398638f, 0.02616882f, 
    -0.20039935f, -0.15901391f, 0.15089692f, -0.04999709f, 0.12365245f, -0.06934903f, -0.00343566f, -0.01129663f, 
    0.08076563f, 0.03787692f, -0.13469850f, -0.08825471f, -0.16159242f, 0.00347813f, -0.16457289f, 0.24527185f, 
    -0.00938005f, 0.08806300f, -0.04836179f, 0.07527018f, 0.04426837f, -0.03040526f, -0.07318220f, -0.07252204f, 
    -0.16508015f, -0.07630650f, 0.29236522f, -0.24508314f, -0.08978959f, 0.00246703f, -0.05267603f, -0.14404455f, 
    0.18914749f, 0.21269016f, -0.01397137f, 0.12071037f, -0.13589643f, -0.06269619f, -0.09705184f, -0.04034868f, 
    -0.11867639f, 0.07958952f, 0.03054612f, -0.00610070f, -0.00888071f, -0.13912316f, -0.15536533f, -0.22060136f, 
    0.39620551f, -0.14372514f, 0.16883245f, 0.03606642f, -0.15418872f, -0.12732479f, -0.00876529f, -0.03850283f, 
    0.02540619f, -0.05889444f, -0.08689037f, 0.07539162f, 0.01919778f, -0.20013149f, 0.07195760f, -0.05441681f, 
    -0.07113653f, -0.19061476f, -0.04748316f, 0.09376152f, -0.06905671f, 0.06117215f, 0.05927465f, -0.01001615f, 
    0.35320616f, 0.01778135f, -0.02688835f, -0.04051534f, -0.06053232f, 0.07593884f, 0.18185781f, 0.06403761f, 
    -0.10209071f, -0.03244172f, 0.05293978f, 0.03564294f, 0.00751151f, 0.02986708f, 0.15342404f, -0.04052889f, 
    0.05107791f, 0.21175478f, -0.01653377f, -0.03294659f, -0.01868675f, -0.15300801f, 0.05979367f, 0.06858772f, 
    0.14625686f, 0.14317766f, 0.03436486f, -0.15926808f, 0.12817276f, -0.00430135f, -0.02945141f, -0.03238068f, 
    0.03075799f, 0.11426756f, 0.00046306f, -0.12714823f, 0.05447596f, -0.02566082f, 0.14156307f, 0.12685670f, 
    0.00985021f, 0.07985601f, -0.19211592f, 0.12724178f, 0.00193102f, 0.04132464f, 0.10031587f, 0.14547729f, 
    -0.29500195f, 0.00789455f, -0.12533015f, 0.17237042f, 0.03004967f, 0.18568903f, -0.02325332f, -0.02599312f, 
    -0.16908264f, -0.09757105f, 0.00245254f, -0.04139516f, -0.01508128f, 0.01231487f, 0.09004700f, 0.17531139f, 
    -0.03172415f, 0.09523891f, 0.06795772f, 0.06453083f, 0.22256774f, 0.14519203f, 0.16924916f, 0.20394327f, 
    0.10441151f, -0.25359413f, 0.05661097f, -0.21312404f, 0.01766172f, -0.25684991f, -0.08144815f, -0.00473627f, 
    -0.17485903f, -0.04441954f, 0.13446541f, -0.09569409f, -0.04814029f, 0.22625121f, 0.17925498f, 0.27798164f, 
    -0.04377189f, 0.05024775f, -0.00080530f, -0.03947383f, -0.04084693f, 0.02215251f, -0.04280539f, -0.01062868f, 
    0.11566944f, 0.04274875f, -0.01500283f, 0.04105753f, -0.10121068f, 0.13410901f, 0.00549194f, -0.05221460f, 
    0.02504521f, 0.04562545f, 0.14285801f, 0.13809633f, 0.09262002f, 0.10517298f, -0.03227301f, -0.02516604f, 
    0.04481645f, 0.03767473f, 0.15857294f, -0.07652181f, 0.06225681f, -0.11695578f, -0.04577376f, -0.05876895f, 
    -0.20933077f, 0.09056757f, 0.12848389f, -0.15991040f, 0.13209215f, -0.10009412f, 0.16685973f, 0.10111624f, 
    -0.09083155f, 0.06376086f, 0.07760585f, 0.18865736f, -0.01608253f, -0.31590629f, -0.26539397f, 0.07416263f, 
    -0.14702106f, -0.31426412f, -0.10855521f, 0.22340636f, -0.03375745f, -0.03137428f, 0.00420140f, 0.10675710f, 
    -0.07593168f, -0.07504716f, -0.07844709f, -0.07407989f, 0.13074005f, -0.22293852f, -0.08372938f, -0.09445108f, 
    -0.05580396f, -0.21600261f, -0.09023929f, 0.02904513f, 0.14425720f, 0.02479940f, 0.07958826f, 0.17998657f, 
    0.10176364f, -0.03409940f, -0.04737956f, 0.04809494f, -0.00365439f, -0.13416256f, -0.03107243f, -0.04905839f, 
    -0.18569519f, -0.08214968f, -0.00437810f, 0.10144876f, 0.12594454f, 0.02483943f, 0.05698159f, 0.09661854f, 
    -0.00929569f, -0.07568616f, 0.05018023f, -0.02529423f, 0.17782024f, 0.32967997f, 0.29723325f, 0.27124727f, 
    -0.02477191f, 0.08215276f, 0.04872920f, -0.27171344f, -0.07790263f, 0.08752577f, 0.06028410f, 0.19167453f, 
    -0.23625776f, -0.08383533f, -0.12997960f, 0.02221879f, 0.12435976f, 0.12837982f, -0.00297415f, -0.10588179f, 
    0.03854785f, -0.03957030f, -0.02889489f, 0.07909712f, 0.25534582f, -0.12781051f, 0.20451269f, 0.34135202f, 
    0.12097260f, 0.10820789f, -0.02182739f, -0.06912118f, 0.02945856f, 0.02186236f, 0.02265265f, -0.12837480f, 
    0.22844046f, 0.31081757f, -0.30355647f, -0.26010159f, 0.09137554f, -0.09766956f, -0.02348007f, 0.06111373f, 
    -0.10623561f, -0.25444409f, -0.21399470f, -0.08133551f, 0.05410838f, 0.09466622f, 0.15303142f, 0.18858741f, 
    -0.00470393f, -0.01762002f, 0.10218505f, 0.00612484f, 0.14444849f, 0.15850855f, 0.00889070f, 0.15364695f, 
    -0.08940625f, -0.00057545f, -0.12618977f, 0.06136842f, -0.00950940f, -0.14881997f, 0.00948827f, 0.06033347f, 
    0.07383014f, -0.10008206f, -0.10687979f, 0.10690686f, -0.09859747f, -0.21378644f, -0.04187717f, -0.09973719f, 
    -0.03228103f, -0.10706306f, -0.06433046f, 0.01420347f, -0.15624881f, 0.21636556f, 0.03687478f, 0.31142813f, 
    0.04965879f, 0.18104573f, 0.21095914f, 0.20430377f, 0.00450400f, 0.22940859f, -0.03944353f, -0.07893537f, 
    -0.03344561f, 0.01545960f, 0.06523605f, 0.17221360f, -0.07304768f, -0.12703471f, -0.04959570f, 0.02065425f, 
    0.09714607f, -0.06173984f, -0.01973751f, 0.01431304f, -0.07468174f, -0.07800002f, 0.00344018f, -0.10297032f, 
    0.08022834f, 0.02671912f, -0.05200365f, 0.12312517f, 0.05265605f, -0.08679157f, -0.13859424f, 0.00367253f, 
    -0.03073501f, -0.01362392f, 0.08207107f, 0.22135955f, -0.12664314f, -0.18379933f, -0.16923307f, 0.01821411f, 
    -0.01657842f, 0.00723618f, -0.18204215f, -0.08546121f, 0.12763241f, -0.07886668f, -0.24645306f, -0.10106685f, 
    -0.06841598f, 0.13973549f, -0.08604809f, 0.00093596f, 0.08557805f, -0.01501154f, 0.10097667f, -0.03804228f, 
    0.10002904f, 0.04104672f, -0.00161519f, -0.03783869f, 0.05349443f, 0.21010306f, 0.43538573f, 0.03009491f, 
    0.04731165f, 0.01649977f, 0.07661424f, 0.05315842f, -0.00947044f, -0.11679570f, 0.18155606f, 0.01877884f, 
    -0.26515242f, 0.27355286f, 0.22726004f, -0.13275936f, -0.01184198f, -0.02933101f, -0.01869813f, 0.05414317f, 
    0.10933722f, 0.08361303f, 0.13968149f, 0.11312516f, -0.08277986f, -0.10799854f, -0.15273324f, 0.14901802f, 
    0.05189268f, -0.22386996f, 0.05963128f, 0.14552541f, 0.01320650f, 0.09070662f, -0.02342519f, 0.22446413f, 
    -0.19842865f, 0.08121645f, -0.07203127f, -0.02333447f, -0.03229556f, 0.02726848f, 0.01299261f, -0.03321814f, 
    -0.01038693f, -0.02777778f, 0.00962180f, -0.00143322f, -0.11960144f, 0.29379573f, 0.12820995f, -0.07222082f, 
    -0.09496047f, -0.01916957f, -0.05823401f, -0.15081105f, 0.06966155f, 0.11055534f, -0.00800851f, 0.02084516f, 
    -0.03117798f, -0.12019539f, 0.10437293f, -0.08412240f, 0.05058400f, 0.20874152f, 0.15118045f, -0.06908684f, 
    -0.00825841f, -0.09323149f, 0.02469051f, -0.06249107f, -0.13418777f, -0.05449227f, 0.10863711f, 0.06195268f, 
    -0.08206481f, -0.12915026f, -0.10169908f, -0.11059177f, 0.14597237f, 0.14057428f, 0.14691147f, -0.02307072f, 
    -0.14443183f, -0.05106134f, 0.05535631f, -0.13015154f, 0.10585722f, -0.03065115f, -0.06781138f, -0.15937886f, 
    0.14025773f, 0.02649179f, 0.18246754f, 0.02675941f, -0.03860938f, -0.08843174f, 0.06502374f, 0.05874341f, 
    -0.07238136f, 0.05400939f, 0.11096354f, -0.07014169f, 0.08704869f, 0.09164190f, 0.01679400f, -0.06758714f, 
    0.28107330f, -0.30671901f, -0.30350664f, 0.25218502f, 0.09297408f, 0.11307632f, -0.08792692f, 0.21714696f, 
    0.05148934f, 0.08303455f, 0.23115803f, 0.19908936f, 0.06577517f, -0.01597298f, 0.04470707f, -0.15022542f, 
    -0.00603669f, -0.04435991f, 0.06378759f, 0.04092013f, -0.09551235f, 0.18390523f, 0.11656388f, -0.06139235f, 
    -0.20745449f, -0.14228436f, 0.21399534f, 0.06015156f, -0.01785295f, 0.02167397f, -0.04269882f, 0.12127007f, 
    0.09018756f, -0.01935091f, 0.10672995f, 0.03090073f, -0.05198845f, 0.12213717f, 0.13000228f, -0.04491954f, 
    0.00142362f, -0.00816290f, -0.06951698f, -0.13062964f, 0.02786995f, 0.02366857f, 0.12388672f, 0.12292281f, 
    -0.05675271f, 0.10957528f, 0.05720108f, 0.34143394f, -0.08081838f, 0.08624791f, 0.11436683f, 0.03354457f, 
    0.03250384f, 0.13538755f, 0.13275328f, 0.03615793f, -0.03311431f, -0.06155523f, -0.04293436f, -0.00632901f, 
    0.01338444f, -0.05506773f, 0.00889568f, -0.01943909f, 0.01560946f, 0.05952986f, 0.10089939f, -0.02126794f, 
    -0.11470479f, -0.01239940f, 0.01107949f, -0.06442209f, 0.06011843f, -0.01636183f, 0.22032714f, 0.11348310f, 
    0.02627642f, -0.00559085f, -0.03357822f, -0.02885499f, -0.31673202f, -0.03487923f, 0.19772422f, -0.07356441f, 
    0.03807041f, -0.10072289f, -0.06357078f, -0.07677835f, 0.13670020f, 0.06050623f, 0.06252817f, -0.06059643f, 
    0.02554598f, 0.12041264f, 0.14291345f, 0.08843537f, -0.12861566f, 0.08538411f, 0.03398273f, -0.04190549f, 
    -0.06976569f, -0.05827771f, 0.19997227f, 0.04765121f, 0.09184660f, -0.23828180f, 0.06151496f, 0.02602226f, 
    -0.07211646f, 0.11131808f, -0.17771056f, 0.02529745f, 0.01941073f, -0.03571863f, -0.07312020f, -0.12712872f, 
    0.32724616f, 0.04436825f, 0.26522768f, 0.01573469f, -0.04646105f, 0.04846444f, -0.06904671f, -0.03426835f, 
    -0.04907133f, -0.02079673f, 0.05425315f, -0.12311566f, -0.27613595f, 0.11006954f, 0.04818016f, 0.21435934f, 
    -0.08234017f, 0.05167209f, 0.03019433f, 0.12308599f, -0.16403094f, 0.01401910f, 0.08351920f, 0.01066411f, 
    0.10296986f, -0.10548966f, 0.35310858f, 0.04910858f, -0.25393069f, -0.04812189f, -0.16092117f, 0.16957524f, 
    -0.02581145f, -0.03691668f, -0.09464364f, 0.06166212f, 0.32006332f, 0.07732972f, -0.16298707f, -0.17672709f, 
    0.17221656f, -0.09442707f, 0.13948695f, -0.10332414f, -0.04703014f, 0.06916426f, 0.12283100f, 0.13239042f, 
    -0.12231879f, -0.00064301f, -0.29252583f, 0.19921790f, -0.04643731f, -0.05894249f, 0.03278241f, 0.05524131f, 
    -0.04068183f, -0.03835932f, 0.04467333f, 0.00488164f, -0.13438109f, -0.17197242f, -0.10698736f, 0.03215474f, 
    -0.04330838f, 0.04455102f, -0.14034192f, 0.04655733f, 0.08068401f, 0.00938280f, 0.10192528f, 0.11278029f, 
    0.18691298f, -0.14076898f, -0.13600476f, 0.02052644f, -0.00529569f, -0.05053852f, -0.10821046f, 0.01637616f, 
    0.01302215f, -0.03160995f, 0.10856304f, 0.01661224f, -0.02362426f, 0.26547745f, -0.15034820f, 0.05196279f, 
    -0.03817368f, 0.04550633f, -0.08551645f, -0.00141409f, -0.04533787f, 0.17402469f, 0.07074166f, 0.02090192f, 
    -0.09299000f, -0.10163815f, 0.03599983f, 0.13967574f, 0.00700735f, -0.17539826f, -0.01901689f, -0.06194413f, 
    0.10139470f, 0.03530320f, 0.09638334f, -0.01324877f, -0.01060142f, 0.17675976f, -0.11906169f, -0.06463671f, 
    -0.06706769f, 0.01286883f, 0.00215130f, -0.07924254f, -0.09620281f, -0.06278014f, -0.05604011f, -0.04493789f, 
    -0.02257629f, 0.27724698f, 0.11983240f, 0.08883342f, 0.11761773f, 0.04932066f, 0.12240721f, -0.01127576f, 
    0.06460097f, 0.01713375f, 0.11394858f, 0.10406784f, 0.08545747f, -0.05450712f, 0.09565588f, -0.21161771f, 
    0.00754580f, 0.05686850f, 0.00815414f, 0.05850795f, -0.06110086f, 0.03664376f, 0.08136144f, -0.05896083f, 
    -0.15665045f, -0.16943036f, 0.07858969f, -0.08039385f, 0.03587506f, -0.06752615f, 0.12543932f, -0.01198654f, 
    0.13812236f, 0.02644508f, 0.00895678f, 0.07673404f, -0.28167987f, -0.19755590f, 0.06044733f, 0.29010525f, 
    -0.02382028f, 0.05929617f, 0.03212586f, 0.03775841f, -0.04850494f, 0.00431894f, -0.01930554f, 0.06199121f, 
    -0.05773453f, 0.20063989f, 0.15972152f, 0.00800962f, -0.15305617f, 0.10020070f, -0.06377683f, -0.02910790f, 
    -0.09540911f, 0.09121186f, 0.23761559f, 0.20098045f, -0.30799970f, -0.18981710f, 0.07863038f, 0.00714121f, 
    -0.07898929f, 0.05590102f, 0.10810045f, 0.05962731f, -0.09441870f, -0.08787404f, -0.04056874f, -0.08549179f, 
    -0.06580915f, -0.00841358f, 0.16341883f, -0.03253914f, 0.18870836f, 0.02585139f, -0.07574418f, -0.06139906f, 
    -0.21213055f, -0.11513647f, -0.12427769f, -0.09266482f, -0.07167459f, -0.01882328f, 0.01770518f, -0.01928822f, 
    -0.12548693f, -0.07178000f, -0.02416740f, 0.19368628f, -0.04103165f, 0.00826715f, 0.01569106f, -0.01875423f, 
    0.18545251f, -0.00956449f, 0.07955635f, 0.12581600f, 0.13464688f, 0.27902639f, 0.02356704f, -0.06250213f, 
    -0.11036101f, -0.18515383f, 0.06770217f, 0.08392661f, -0.31891704f, 0.18611693f, 0.03547412f, 0.02105817f, 
    -0.03789691f, 0.01116561f, -0.06598226f, 0.03290272f, -0.04203296f, 0.03786909f, 0.03696618f, 0.07702247f, 
    -0.02633099f, 0.18891913f, -0.02963134f, 0.12041908f, 0.06364427f, 0.09137200f, 0.17697318f, -0.02849923f, 
    0.02768128f, 0.03572481f, 0.08004524f, -0.11620694f, -0.28382823f, -0.30308494f, -0.22320166f, -0.17352720f, 
    0.08861455f, 0.02028801f, -0.01659564f, 0.10579139f, -0.03764285f, 0.06955019f, -0.07102962f, 0.11022750f, 
    0.19891432f, -0.34147078f, -0.16458035f, -0.00135310f, 0.13169253f, -0.14877804f, 0.11935402f, 0.08642668f, 
    -0.05245372f, 0.04409697f, 0.05081101f, 0.01776670f, 0.05734809f, 0.14886716f, -0.03499276f, -0.01023493f, 
    -0.08564642f, -0.05934124f, -0.06194275f, 0.06955564f, -0.03369953f, 0.11495594f, 0.09399571f, -0.10842182f, 
    0.00062098f, -0.07539288f, 0.06266481f, -0.22491096f, 0.10702829f, 0.01104042f, -0.14155935f, 0.13154879f, 
    -0.12355459f, -0.01917821f, 0.08505737f, 0.04771351f, -0.08182110f, 0.06204422f, 0.10560908f, 0.03519595f, 
    0.00147120f, -0.00532032f, -0.04410034f, -0.03065348f, 0.00952511f, -0.00647925f, -0.07155906f, 0.08631327f, 
    -0.37544107f, -0.17164731f, -0.04255987f, -0.07705767f, -0.09909274f, -0.04061716f, 0.04687555f, 0.03300363f, 
    0.16516544f, 0.03617585f, 0.08843057f, 0.14196067f, 0.14851822f, 0.01297559f, 0.08669437f, -0.06613455f, 
    0.18909153f, 0.06543859f, 0.11586845f, -0.02095453f, 0.11230573f, -0.01038254f, 0.04932527f, 0.08253156f, 
    -0.14719963f, -0.23280188f, 0.07764624f, -0.06875153f, -0.06039122f, -0.10514598f, 0.15890780f, -0.06714199f, 
    -0.01467733f, -0.01513810f, 0.13847445f, -0.00014896f, -0.03833584f, -0.10196235f, 0.12615953f, 0.14416368f, 
    0.09235055f, 0.16314614f, -0.09977269f, 0.11055440f, -0.04325337f, -0.21144462f, 0.13683486f, 0.04272799f, 
    -0.22683805f, 0.29804754f, -0.03213473f, 0.21710488f, -0.06216633f, 0.18437736f, -0.00792514f, 0.04773849f, 
    0.02731951f, 0.13743722f, -0.00514244f, 0.03441885f, -0.03002562f, 0.04578776f, 0.04927787f, -0.03149221f, 
    -0.08151931f, 0.01511716f, -0.12446989f, -0.11005019f, -0.10414921f, 0.01246633f, 0.06420850f, -0.02675226f, 
    -0.16570234f, 0.07756570f, -0.00510514f, 0.04386506f, 0.26845559f, 0.05447536f, -0.03351403f, 0.03016851f, 
    -0.09345786f, 0.03401679f, -0.14678071f, 0.02786752f, -0.45475048f, -0.54332560f, -0.27076626f, -0.03495848f, 
    -0.10607926f, -0.17904498f, 0.15230782f, 0.14686191f, 0.15668799f, 0.00897967f, 0.02565368f, 0.06615121f, 
    -0.07961431f, 0.16636349f, -0.07566164f, 0.08047692f, 0.20069824f, 0.20042139f, 0.07867077f, 0.07738257f, 
    -0.01338656f, 0.03140441f, 0.00265422f, -0.06386052f, 0.16410871f, 0.11364584f, -0.21163578f, -0.35394254f, 
    -0.12238461f, 0.08532813f, 0.01412898f, 0.21600184f, 0.15985458f, 0.00955201f, 0.05913077f, -0.02691272f, 
    -0.21864635f, -0.22150014f, 0.22790693f, 0.13619097f, -0.06427476f, 0.11959276f, 0.10567208f, -0.01236898f, 
    0.11018357f, 0.08817625f, 0.07519769f, -0.08423719f, 0.12524930f, 0.05175001f, -0.06108213f, -0.07387888f, 
    0.17164434f, 0.05127045f, 0.12612897f, 0.09916873f, -0.12509112f, -0.05519782f, 0.04462440f, -0.00100406f, 
    0.39317787f, 0.03586143f, 0.32659471f, 0.10998624f, 0.20458998f, 0.05626487f, 0.01760460f, 0.03491663f, 
    0.09838788f, 0.17970750f, 0.10709274f, -0.05171680f, -0.09472302f, -0.07328796f, -0.07159399f, -0.02935819f, 
    -0.07536702f, -0.03959953f, 0.13208562f, -0.12172762f, 0.07466088f, -0.02801816f, 0.04771627f, -0.05873692f, 
    0.20768039f, -0.33020768f, -0.18327498f, -0.08799925f, 0.07136633f, 0.13237786f, -0.00873445f, 0.10100695f, 
    -0.06643876f, -0.15575992f, -0.17144895f, -0.00200914f, 0.02819621f, 0.14721635f, -0.06885359f, -0.16196322f, 
    -0.00646764f, -0.00019773f, -0.03334031f, -0.02692593f, 0.06720150f, 0.00231215f, 0.11459944f, 0.19401938f, 
    0.00309968f, 0.01276064f, -0.06951813f, -0.09641603f, -0.04474345f, 0.01127879f, 0.18443274f, 0.07020856f, 
    0.05152296f, 0.04244803f, 0.03128104f, 0.06191547f, -0.12820131f, 0.13749439f, -0.03641025f, 0.03932909f, 
    0.03163711f, -0.03128850f, 0.09266408f, -0.02297255f, 0.00771267f, -0.05385187f, 0.09460385f, 0.02173899f, 
    0.03831093f, 0.05382359f, 0.20335230f, -0.09942643f, -0.11778672f, 0.04103881f, 0.14633721f, -0.01102469f, 
    0.06096962f, -0.07942690f, -0.03595783f, 0.01493503f, 0.17099455f, -0.19176002f, -0.31179577f, 0.03569907f, 
    0.15207343f, 0.15457973f, -0.10834672f, -0.02915009f, -0.00044564f, 0.00838187f, -0.06238163f, 0.15500087f, 
    0.11678052f, -0.36450613f, 0.01097482f, -0.02255446f, 0.04685131f, 0.03123654f, 0.12513225f, 0.01948545f, 
    -0.08726349f, -0.07213639f, -0.18859397f, 0.05441933f, 0.03824279f, 0.18398777f, 0.14387411f, 0.07879980f, 
    -0.00315805f, 0.16706492f, -0.03860271f, 0.01052900f, -0.03380547f, -0.17239170f, 0.00850242f, -0.18781780f, 
    0.03924815f, -0.16565470f, -0.12395648f, -0.21880907f, -0.09448514f, -0.16415855f, 0.04176921f, 0.00760810f, 
    0.08020114f, 0.03998769f, -0.00074568f, -0.04764435f, 0.18801060f, -0.20394966f, -0.01282703f, 0.09507543f, 
    0.04149128f, -0.04459144f, -0.05231712f, 0.10152584f, -0.06679900f, 0.00630488f, -0.03973426f, 0.11647742f, 
    0.42563513f, 0.14626716f, -0.34981567f, -0.06949273f, -0.15586488f, 0.02610490f, 0.21306381f, 0.14538485f, 
    -0.07666668f, 0.18984643f, 0.04897154f, -0.01810094f, 0.04708281f, -0.09757654f, 0.12794051f, 0.05616907f, 
    0.13943419f, 0.24027361f, 0.00235288f, 0.08116172f, -0.01057225f, 0.05978986f, -0.02045050f, -0.04736783f, 
    0.04654645f, 0.35991162f, 0.04404768f, 0.02417466f, 0.04869154f, -0.00227422f, 0.12639724f, 0.18203652f, 
    -0.11330251f, 0.00596490f, -0.07274551f, -0.00627999f, 0.15624318f, 0.19738109f, 0.09260140f, -0.01587696f, 
    0.11253530f, 0.01834501f, 0.08675706f, 0.05044682f, 0.04220196f, 0.18114305f, 0.10314342f, 0.17852794f, 
    -0.31143564f, 0.14817129f, 0.03985265f, 0.02498123f, 0.04253801f, -0.10827803f, 0.18837477f, -0.08426281f, 
    -0.05163151f, -0.02968017f, 0.00154724f, 0.02199787f, -0.28704560f, -0.13667671f, -0.15566407f, 0.03999824f, 
    -0.11391279f, -0.01031763f, -0.12397994f, -0.09940911f, -0.06617569f, -0.03725683f, -0.02200445f, 0.16505992f, 
    0.23049279f, 0.15681823f, -0.03407343f, 0.04105730f, -0.08105764f, 0.02964377f, -0.10570290f, 0.06249347f, 
    -0.00858659f, 0.07236806f, -0.07806703f, -0.03257231f, -0.10242507f, -0.19591476f, -0.19328269f, 0.00229530f, 
    -0.03764379f, 0.01946519f, 0.05525783f, -0.05936670f, -0.02530901f, -0.11290479f, 0.05944446f, -0.04696296f, 
    0.08445549f, -0.13673466f, -0.07499836f, -0.18084244f, 0.08024468f, -0.03143693f, 0.06622513f, 0.10631125f, 
    0.00852843f, -0.06074564f, -0.07945691f, 0.13491839f, 0.12240152f, -0.10260700f, -0.06715716f, -0.10762098f, 
    -0.04936680f, 0.13141418f, -0.05963884f, 0.02862588f, 0.07949018f, 0.07574493f, -0.13056666f, -0.05116412f, 
    0.07739421f, 0.05638317f, 0.00161216f, -0.07297042f, -0.01883297f, -0.06550353f, -0.00077663f, 0.05903315f, 
    0.05006021f, 0.07132054f, -0.04641745f, 0.10060618f, 0.26928642f, 0.06838483f, 0.08274163f, 0.19763765f, 
    -0.11752237f, 0.00351300f, 0.09021293f, 0.28511858f, -0.00800917f, 0.00920409f, 0.09182047f, 0.08004475f, 
    0.04376731f, 0.04947855f, 0.01482275f, 0.01245265f, 0.00540246f, -0.02346532f, 0.02150264f, -0.05300110f, 
    -0.01222803f, -0.04478711f, 0.02022069f, -0.03202645f, 0.03421471f, -0.02939256f, 0.04965479f, -0.06939793f, 
    -0.06368469f, 0.00617925f, 0.04182551f, -0.04467875f, -0.06178026f, -0.06624818f, -0.03225686f, 0.02927567f, 
    0.04424806f, -0.02570751f, -0.04319080f, -0.05283187f, 0.06058678f, 0.04178502f, 0.05354942f, 0.00618729f, 
    -0.06753401f, 0.00737255f, -0.01629648f, 0.03082005f, -0.00603861f, 0.05392699f, -0.00789152f, -0.04114036f, 
    0.02690108f, -0.06500041f, 0.00866375f, 0.01732525f, -0.06936440f, -0.07469214f, -0.00976689f, 0.01500957f, 
    0.02944759f, -0.05337102f, 0.05384526f, -0.06800533f, -0.04519202f, -0.03256325f, -0.01655227f, -0.01148711f, 
    -0.03346334f, -0.04881690f, -0.03700856f, -0.04117258f, -0.02394577f, 0.04766890f, 0.04937544f, 0.04887279f, 
    -0.07716534f, -0.00475280f, -0.07502908f, -0.06174801f, 0.01207202f, 0.02805830f, -0.02059897f, 0.01037947f, 
    -0.07676259f, -0.02375724f, -0.01286487f, 0.00562580f, 0.03497582f, -0.02933654f, -0.02606190f, -0.04095532f, 
    0.05316263f, -0.04935664f, 0.05723087f, 0.05234996f, -0.02182849f, -0.04513925f, 0.02664594f, -0.03440841f, 
    -0.07814480f, 0.05126935f, -0.00796839f, 0.01808265f, -0.05976044f, 0.05627408f, -0.03143568f, -0.07884442f, 
    0.04397725f, -0.04069962f, 0.02521698f, -0.01035897f, 0.02116984f, 0.02094060f, -0.03532667f, -0.01907405f, 
    0.02225349f, 0.02533895f, -0.07183595f, -0.05289455f, -0.03655131f, -0.07764172f, -0.03936115f, -0.04022305f, 
    0.06189844f, -0.02387991f, -0.06798282f, 0.00829125f, 0.00248293f, -0.03684393f, 0.00937900f, -0.05187399f, 
    0.05581038f, 0.05865636f, 0.03718547f, -0.00874228f, 0.04953717f, -0.01298190f, 0.01997893f, 0.01241436f, 
    -0.03834251f, 0.02015695f, 0.05266045f, 0.03978327f, -0.07555669f, -0.06107520f, 0.02697485f, -0.03633050f, 
    -0.01380393f, 0.04750663f, -0.00203337f, -0.05429679f, -0.03183061f, -0.04496269f, -0.04068708f, -0.06352088f, 
    0.05244554f, 0.01370292f, -0.05987028f, -0.00099875f, -0.04427101f, 0.00684521f, -0.00770139f, 0.03278081f, 
    -0.06465003f, -0.00804304f, -0.05848928f, 0.02191596f, -0.02321200f, -0.07005866f, -0.01656616f, -0.00859964f, 
    0.00571701f, -0.04630471f, -0.01781786f, 0.03772804f, -0.04729809f, -0.06569231f, -0.01434152f, -0.06410047f, 
    0.03812630f, -0.00031713f, -0.05739078f, 0.01156291f, 0.01390313f, 0.04603454f, -0.07386603f, -0.04803953f, 
    -0.02689813f, -0.07785372f, 0.01502349f, 0.02479769f, -0.01235305f, 0.01358727f, 0.04284247f, 0.03614708f, 
    0.05569885f, 0.03074962f, 0.02617525f, 0.03458632f, 0.00533762f, -0.00219928f, 0.01264553f, 0.04024944f, 
    0.14980310f, -0.29907489f, 0.24599268f, -0.08762640f, 0.06514958f, 0.08231938f, -0.02004306f, 0.06696819f, 
    -0.12245093f, 0.01991872f, -0.11053488f, 0.06397270f, 0.00210132f, 0.08800855f, -0.11598853f, -0.05290413f, 
    0.06027596f, -0.09304858f, 0.00633400f, 0.12239306f, -0.06652283f, 0.05834787f, 0.02852165f, 0.18942964f, 
    -0.21054547f, 0.11773877f, 0.09381717f, -0.13658418f, -0.13072155f, -0.11524070f, -0.01055823f, -0.06990800f, 
    -0.14829177f, 0.00018510f, 0.01652440f, 0.07843896f, 0.15109399f, 0.24050047f, 0.05801804f, -0.03230361f, 
    -0.03204039f, -0.03199775f, -0.08710723f, -0.09652431f, 0.13933206f, 0.04570631f, -0.00399491f, 0.10810832f, 
    -0.03823127f, -0.01236188f, 0.02759216f, -0.07164398f, 0.10754886f, -0.17217469f, -0.02576074f, -0.02159759f, 
    -0.14911401f, 0.04498043f, 0.00243748f, 0.06524679f, 0.02999412f, -0.26392049f, 0.03925356f, 0.02039431f, 
    -0.04177897f, -0.02228609f, -0.08206479f, 0.03044202f, 0.07131218f, 0.10308082f, -0.07532600f, -0.02846561f, 
    0.05332456f, 0.21411233f, 0.21723036f, 0.14494322f, -0.09986254f, -0.07838056f, 0.09690341f, 0.03550348f, 
    -0.10999136f, 0.03902392f, -0.08603678f, 0.02900637f, -0.15931556f, 0.02638422f, -0.17996614f, 0.03844767f, 
    0.03177643f, 0.04026381f, 0.12023233f, 0.03789623f, 0.04219993f, 0.05359789f, -0.05168778f, -0.01258461f, 
    -0.17097615f, 0.14473201f, -0.46400848f, -0.32748601f, -0.02514766f, -0.01789828f, 0.15401337f, 0.10586724f, 
    -0.06329672f, 0.13370197f, -0.01723473f, 0.11380485f, -0.14082862f, 0.01700518f, -0.02093958f, -0.05533544f, 
    -0.09130984f, -0.02717484f, -0.06079410f, 0.01087416f, -0.18143137f, -0.10200435f, -0.08192793f, 0.16374198f, 
    0.01491494f, 0.20303728f, -0.17269608f, 0.29053226f, -0.04935751f, 0.09624285f, -0.04617114f, 0.08420755f, 
    0.00023942f, 0.08998223f, 0.04312514f, -0.01461642f, 0.03137659f, -0.15931997f, 0.08063120f, -0.13733621f, 
    -0.02312503f, 0.04607823f, -0.00892809f, -0.04221169f, 0.05721511f, 0.01196229f, 0.07354729f, 0.05406912f, 
    0.11441857f, -0.09075268f, 0.03452949f, -0.06404104f, 0.10577364f, 0.00917177f, 0.09458138f, 0.05595214f, 
    0.09665512f, 0.10229459f, 0.01009536f, -0.02117623f, 0.10156952f, -0.02272295f, 0.11982287f, 0.10517463f, 
    -0.04107610f, 0.09967476f, -0.00775052f, 0.04700212f, -0.01888316f, 0.04601983f, 0.08181003f, 0.01923159f, 
    0.09160751f, -0.04481704f, -0.18156029f, 0.10211481f, -0.01089538f, -0.00205979f, 0.02903090f, -0.07700698f, 
    0.02275236f, 0.07045320f, -0.07785038f, -0.07913645f, -0.05645156f, 0.10704773f, 0.17737061f, 0.06296073f, 
    0.04227426f, 0.11310975f, 0.09271999f, 0.21256761f, -0.02932253f, 0.10635393f, -0.04831181f, 0.00376202f, 
    0.03164615f, 0.09524206f, 0.12906452f, 0.07287769f, -0.04142229f, 0.08167805f, -0.15413481f, 0.07447846f, 
    -0.02849575f, -0.07320711f, 0.15752134f, 0.09513213f, 0.07396907f, 0.06734445f, -0.03145682f, 0.09243760f, 
    0.05687558f, 0.03285761f, 0.00807361f, 0.15961847f, -0.07534512f, 0.14376202f, 0.04804691f, 0.07697006f, 
    0.22449812f, -0.07028829f, 0.05590369f, 0.05964002f, -0.07350922f, 0.02023351f, -0.01194225f, -0.09939180f, 
    -0.02363728f, 0.01459216f, 0.00928476f, -0.00763263f, 0.20239104f, 0.04684987f, -0.07935035f, -0.02274379f, 
    0.03301973f, 0.05369778f, -0.09748483f, -0.06474762f, 0.04483740f, 0.01905620f, 0.00973503f, -0.13827664f, 
    0.05900140f, -0.38939980f, 0.04939001f, -0.07481651f, 0.00243704f, -0.06853606f, -0.18653080f, 0.08491400f, 
    -0.04764943f, 0.01528603f, -0.00585147f, 0.02943974f, 0.19310351f, 0.08294798f, -0.01889053f, 0.03417452f, 
    0.15106377f, -0.08262312f, -0.09178557f, -0.00006460f, -0.02979458f, -0.12517111f, -0.05749946f, 0.04621614f, 
    -0.04998637f, -0.08663473f, -0.05108709f, 0.00103820f, 0.02599809f, -0.03851858f, 0.01210259f, 0.04710991f, 
    -0.15280570f, 0.23691033f, -0.02040709f, 0.03820530f, -0.14662804f, -0.07400043f, 0.01588715f, 0.01500610f, 
    0.02942684f, 0.00542435f, -0.07110330f, 0.05424584f, 0.03356608f, 0.03120629f, -0.07184166f, -0.10425361f, 
    0.01940851f, 0.09422992f, -0.15166350f, 0.05043251f, 0.01630070f, -0.05464539f, 0.08044925f, 0.09339859f, 
    0.01984348f, 0.17987767f, -0.16895966f, -0.04064713f, 0.03967839f, 0.05372016f, 0.16237493f, -0.01455704f, 
    -0.01576319f, -0.01019728f, 0.00033587f, -0.02004265f, 0.06668700f, 0.09626804f, -0.10548122f, -0.08845499f, 
    0.03849967f, 0.01317873f, -0.06016661f, 0.00346467f, 0.06918863f, 0.08520317f, -0.07412966f, -0.01448415f, 
    -0.03206007f, 0.01471236f, 0.07984132f, -0.04746285f, -0.04798884f, 0.07226709f, 0.04884198f, 0.06421973f, 
    0.01136027f, 0.02666373f, -0.06578133f, -0.01009537f, 0.05231066f, 0.09783351f, 0.11709601f, 0.05589348f, 
    -0.12151475f, 0.21037664f, 0.12888314f, 0.03739190f, 0.04142859f, -0.03152227f, 0.04604129f, 0.06183915f, 
    -0.08045437f, -0.00688912f, 0.06809545f, -0.09927827f, -0.08877098f, -0.00162647f, 0.02639742f, 0.01880462f, 
    -0.02760325f, -0.02440775f, 0.12762892f, -0.06673615f, 0.02242368f, 0.01373990f, 0.18125728f, -0.03675966f, 
    -0.05653288f, -0.07867487f, 0.03167473f, 0.09427235f, 0.14033590f, -0.03344831f, 0.05883724f, 0.05972882f, 
    -0.03309249f, 0.14705400f, -0.06419221f, -0.06794714f, -0.10224479f, -0.15889610f, -0.11059977f, 0.09943479f, 
    0.13767929f, 0.00886671f, -0.04988496f, 0.02347842f, 0.00100653f, 0.01819776f, 0.03962223f, -0.02967816f, 
    -0.21653125f, 0.06810098f, -0.07557758f, 0.30412436f, 0.04634845f, -0.08675430f, 0.09331458f, -0.00574833f, 
    -0.05375021f, 0.09741765f, 0.18014939f, -0.13246712f, 0.21911500f, 0.04107858f, 0.14095657f, -0.03866566f, 
    -0.07648113f, 0.09946250f, -0.07368549f, -0.17124991f, -0.07261632f, -0.11309119f, -0.12512529f, -0.14147006f, 
    0.17238727f, 0.22478707f, -0.09914803f, 0.31003150f, 0.13698791f, -0.07397912f, -0.05059321f, 0.11978121f, 
    0.04517879f, 0.06810604f, -0.12021565f, 0.02861210f, -0.54823011f, -0.51218969f, -0.35007888f, -0.11533918f, 
    -0.04421980f, -0.24045306f, 0.16540189f, 0.25967336f, 0.10271607f, 0.08585226f, 0.11524677f, 0.14909966f, 
    0.06903519f, 0.11261990f, 0.07429945f, 0.40640998f, -0.10397249f, -0.04228776f, -0.04807012f, -0.05267379f, 
    0.04032462f, -0.15067428f, 0.09286813f, -0.16526654f, -0.30323473f, 0.07961522f, -0.29598248f, -0.47406170f, 
    -0.03951502f, 0.09512284f, 0.02024605f, 0.11862668f, -0.03839107f, -0.08242084f, 0.05798487f, -0.01000655f, 
    -0.25155610f, -0.23972520f, -0.10581005f, 0.07647518f, -0.11626111f, -0.06353801f, -0.17295226f, -0.28573823f, 
    0.16736305f, -0.01058460f, 0.07435443f, -0.09316583f, 0.24647047f, 0.04849794f, -0.00141872f, 0.20012191f, 
    0.09702807f, 0.11137317f, 0.13134161f, 0.06493135f, -0.10768375f, 0.04240404f, 0.15468878f, 0.08785763f, 
    0.26175967f, -0.02686728f, 0.55204493f, 0.12889919f, 0.02763803f, 0.18576780f, -0.02487781f, 0.04342209f, 
    -0.00640966f, 0.00779296f, -0.06670007f, -0.02692733f, -0.19529092f, -0.09226060f, -0.12006558f, 0.13032101f, 
    0.04375492f, -0.09619959f, 0.21066679f, -0.05957372f, 0.18998238f, 0.14259662f, 0.17277992f, -0.06402255f, 
    0.12825242f, -0.09683071f, -0.06926961f, -0.00818889f, 0.11373680f, -0.03523968f, -0.02566119f, 0.10599813f, 
    -0.02190166f, -0.16846685f, -0.08141726f, 0.12848207f, -0.02824245f, 0.03201583f, -0.07075913f, -0.16713937f, 
    0.11512633f, -0.06794468f, -0.17388830f, -0.14426717f, -0.00977360f, 0.10637547f, 0.14882897f, 0.10744143f, 
    0.05147545f, -0.01376959f, 0.02986056f, 0.09702742f, -0.19861761f, -0.03871504f, 0.04895360f, 0.06392457f, 
    -0.00832392f, -0.11550461f, -0.01425673f, 0.14327061f, -0.13684949f, -0.07908043f, -0.23916446f, -0.15694311f, 
    -0.05506793f, 0.12756412f, -0.12444903f, -0.03623777f, 0.00197765f, -0.13019222f, 0.00982708f, -0.23201080f, 
    0.08341806f, 0.13696787f, 0.32674894f, 0.09457885f, -0.05149073f, 0.08982466f, 0.08813488f, 0.18936180f, 
    0.02946336f, -0.12741104f, -0.08348080f, 0.17581271f, 0.12054879f, -0.04163186f, -0.12821065f, 0.11318332f, 
    0.17501310f, 0.07367040f, -0.11797944f, -0.04570345f, 0.05199637f, -0.00119073f, 0.04149445f, 0.11674841f, 
    0.07034028f, 0.20648970f, -0.08733480f, 0.23339346f, -0.01230008f, -0.01936433f, 0.04987825f, 0.07302015f, 
    0.06703354f, 0.13635616f, 0.15902022f, -0.00912313f, 0.12787484f, -0.09071469f, 0.18410496f, 0.05960040f, 
    0.03109003f, -0.04821350f, 0.10570790f, 0.06894705f, 0.04186260f, -0.01587250f, -0.05518025f, -0.00740747f, 
    0.17635821f, 0.22167014f, 0.02695250f, -0.01093664f, 0.03263612f, 0.00471673f, -0.13740422f, -0.06115336f, 
    -0.00050100f, 0.06122397f, -0.01895655f, -0.11097771f, -0.20348741f, 0.05865639f, 0.03435940f, 0.00634676f, 
    0.01114368f, 0.02295171f, 0.08099955f, 0.04479710f, -0.04826192f, -0.00049023f, -0.01929289f, -0.07106572f, 
    -0.12378055f, 0.08547316f, 0.24332646f, -0.06220752f, -0.06835437f, -0.18329014f, -0.20714398f, 0.00928596f, 
    0.09992926f, -0.05031689f, -0.04025533f, 0.09595645f, -0.08479433f, -0.02744215f, -0.30868769f, -0.18325630f, 
    0.02205288f, -0.20636140f, 0.05408297f, 0.06465256f, -0.00475157f, 0.05584650f, 0.07794156f, 0.15218855f, 
    -0.09099119f, -0.00134504f, -0.20170565f, 0.03305512f, -0.05140780f, 0.07724039f, 0.11638895f, -0.01901980f, 
    0.08964643f, -0.03229861f, 0.10347124f, 0.04272757f, -0.19076277f, -0.12349717f, -0.03515352f, 0.07321128f, 
    -0.10695113f, -0.01589969f, -0.07904842f, -0.03224337f, 0.03807010f, -0.03513486f, -0.00885425f, -0.10627822f, 
    0.19244896f, -0.22628942f, 0.05167219f, 0.27307644f, 0.13158214f, 0.17606275f, 0.00637756f, 0.06922120f, 
    0.08445650f, -0.08414331f, 0.12938020f, 0.04055928f, -0.07001247f, 0.13100061f, -0.07257546f, -0.06996337f, 
    -0.05758555f, -0.12496763f, -0.10303746f, -0.08122283f, 0.02700634f, 0.08773801f, -0.03432752f, -0.11929986f, 
    -0.28415293f, -0.02481592f, 0.11057778f, 0.14509414f, -0.01954288f, -0.10444423f, 0.10752439f, 0.02548554f, 
    0.06078291f, -0.02407044f, 0.04001701f, 0.06624524f, 0.04440617f, 0.04934599f, -0.16123684f, -0.15996149f, 
    -0.04144412f, -0.10382866f, -0.09593427f, 0.04146175f, 0.03315857f, 0.03247277f, 0.00547035f, -0.00384250f, 
    0.00185056f, 0.12024149f, 0.15183529f, 0.17640539f, 0.04418943f, -0.00695035f, 0.10406665f, -0.03686504f, 
    0.10446870f, 0.10704814f, -0.01812569f, -0.01604685f, 0.02297997f, -0.02588046f, 0.17695263f, -0.01457981f, 
    0.03008645f, -0.03990820f, -0.00637196f, 0.09812041f, 0.03562190f, 0.05272526f, 0.10605653f, 0.15645617f, 
    0.05179713f, -0.12534253f, 0.03780927f, 0.01074084f, -0.00627191f, -0.04971300f, -0.05765848f, 0.01790574f, 
    0.08890524f, -0.02421862f, -0.02939006f, 0.02284457f, -0.22127786f, -0.01829893f, 0.21747237f, 0.05809379f, 
    0.01479251f, 0.09528006f, 0.10518184f, -0.04670712f, 0.08022974f, 0.10456576f, 0.00231113f, -0.04686457f, 
    -0.04990338f, 0.13727739f, 0.22880195f, 0.02056878f, 0.14745186f, 0.08709289f, 0.02719357f, -0.03665977f, 
    0.06681925f, 0.01266338f, 0.00415796f, 0.00794149f, -0.07261149f, 0.17886877f, 0.01359119f, -0.03101508f, 
    -0.06693224f, -0.22051971f, 0.07119380f, -0.05626838f, 0.02640914f, 0.04892744f, -0.01947496f, 0.04359861f, 
    0.12241300f, -0.13980725f, -0.35074741f, -0.04222990f, 0.03393396f, 0.07441111f, 0.08783765f, -0.02999327f, 
    0.04394965f, 0.08502167f, -0.08458135f, -0.03991200f, 0.09420332f, 0.07690854f, -0.35765675f, -0.28222904f, 
    0.07844295f, -0.15049860f, -0.08038452f, 0.17897207f, 0.16919461f, -0.01247928f, 0.07494574f, -0.10548282f, 
    0.39368826f, -0.12301582f, -0.23106456f, 0.10572797f, 0.12343137f, 0.15471706f, 0.21812300f, -0.07683785f, 
    0.05410621f, -0.03672516f, 0.06285580f, -0.13025473f, -0.63572735f, 0.23551503f, 0.20939419f, 0.01614388f, 
    -0.05997582f, -0.08280680f, -0.04278873f, -0.04322961f, -0.07570633f, 0.02845315f, 0.03959067f, 0.02069506f, 
    -0.13847819f, 0.05951980f, 0.21679196f, -0.01344816f, -0.03572546f, 0.06789006f, -0.15913968f, -0.14930645f, 
    0.20452267f, 0.02860673f, 0.25376165f, 0.00385584f, -0.09443881f, 0.04677137f, 0.06713252f, 0.05164856f, 
    -0.14639209f, 0.00961424f, 0.11938645f, 0.06581525f, 0.10327148f, 0.05391989f, -0.00146245f, -0.03690570f, 
    -0.17667232f, -0.14027388f, 0.07479392f, 0.17473906f, -0.08972832f, 0.08973680f, 0.00436603f, 0.01449211f, 
    -0.03279439f, 0.19680323f, 0.00369447f, 0.06671862f, 0.20973478f, -0.13048998f, 0.13624288f, 0.02519584f, 
    -0.01682229f, 0.00148133f, -0.03483720f, 0.04621107f, 0.12664606f, -0.16006954f, 0.15785186f, -0.14041100f, 
    -0.13780275f, 0.03334022f, 0.00779177f, 0.02829498f, 0.09648476f, -0.08857283f, -0.06929620f, 0.14429219f, 
    0.02686086f, -0.05047289f, -0.00974531f, -0.00052375f, 0.05508066f, 0.13915429f, 0.32206279f, -0.02841053f, 
    0.09078439f, -0.09075070f, -0.03069118f, -0.04433579f, 0.03030903f, -0.01542074f, 0.15077269f, 0.05710468f, 
    -0.19127640f, -0.08035751f, 0.08818539f, 0.17962307f, -0.16775562f, 0.07273105f, 0.09456397f, 0.04855720f, 
    0.06382731f, -0.08104714f, 0.06894585f, -0.04991382f, -0.03203801f, 0.07988619f, -0.17760395f, -0.10057876f, 
    0.06874004f, 0.08205529f, 0.04419560f, -0.03205830f, -0.05464397f, -0.06411178f, 0.06474935f, 0.00559846f, 
    0.07330629f, 0.01490812f, 0.23584965f, -0.17767021f, -0.07132342f, 0.02680972f, 0.01417940f, 0.12719613f, 
    0.02970750f, 0.03347377f, 0.04801909f, 0.01951750f, -0.11015851f, 0.20006517f, -0.10295361f, -0.00136917f, 
    0.07034229f, -0.02073939f, -0.09331797f, -0.10253652f, 0.07576706f, 0.01669108f, 0.02625618f, 0.06870192f, 
    0.05791628f, 0.00956152f, -0.04498800f, 0.19058014f, -0.04065195f, -0.01055771f, -0.02206497f, 0.10466420f, 
    -0.03153083f, 0.11091954f, 0.17989476f, 0.00958407f, 0.34292945f, -0.12434831f, -0.10697626f, -0.04234382f, 
    -0.02553270f, 0.09499455f, -0.08349662f, 0.09735317f, -0.03259415f, 0.04986876f, 0.07702166f, 0.03887042f, 
    -0.15668817f, 0.14115728f, 0.10444504f, 0.20717049f, 0.02778410f, -0.04898581f, 0.03325826f, -0.13416731f, 
    -0.11414152f, -0.04744828f, 0.05116061f, -0.00056405f, -0.18824695f, 0.03335469f, -0.19838989f, 0.07009249f, 
    0.04396863f, 0.10797452f, 0.05950272f, -0.03965232f, 0.14106740f, 0.07378066f, 0.06973079f, -0.03762087f, 
    -0.10774326f, -0.13721842f, 0.32310700f, 0.11567477f, -0.03992637f, -0.14903221f, -0.09305186f, 0.05825429f, 
    0.05160163f, 0.04880683f, 0.01152349f, -0.01030555f, 0.41852817f, -0.00429811f, -0.32431349f, -0.32578501f, 
    0.13873979f, -0.07699363f, 0.19588596f, 0.10422560f, -0.04409813f, 0.08445814f, -0.01937234f, -0.09503836f, 
    -0.22748064f, -0.12137763f, -0.02992226f, 0.13789542f, 0.07211526f, -0.02207984f, 0.13156962f, 0.06279209f, 
    -0.18631983f, 0.09862687f, 0.16942367f, -0.04811265f, -0.12707388f, -0.07286290f, -0.08083389f, 0.03548993f, 
    0.04893749f, 0.05778246f, 0.02126940f, -0.07333481f, -0.11366162f, -0.11828493f, 0.06286209f, -0.00105128f, 
    0.40838668f, 0.13966273f, 0.17879018f, -0.28537950f, -0.02935032f, -0.00645214f, -0.04361767f, 0.09529189f, 
    0.01445636f, -0.00256175f, 0.01129476f, 0.11918785f, -0.12486707f, 0.09314271f, 0.08136766f, -0.11082093f, 
    0.03486595f, -0.13631411f, -0.00025118f, -0.07212275f, -0.00865793f, 0.00480898f, 0.01281233f, -0.08327311f, 
    -0.08964462f, -0.04252534f, -0.44155177f, 0.06814439f, 0.09506296f, 0.10758170f, 0.00360912f, 0.00037948f, 
    0.07018358f, -0.05677816f, -0.00464411f, -0.06434017f, 0.16835439f, 0.07150768f, 0.02061724f, -0.19172293f, 
    0.05366606f, -0.02658169f, 0.00452090f, -0.04130176f, 0.07006891f, 0.01432079f, 0.08838015f, 0.08893072f, 
    0.05993220f, 0.23057376f, 0.03784090f, 0.06585169f, 0.02438756f, -0.05205046f, -0.02585459f, -0.08016971f, 
    -0.00255087f, 0.01716787f, 0.06655256f, -0.07189012f, 0.00671077f, 0.01716603f, 0.04793451f, 0.12940221f, 
    0.04593063f, -0.07283437f, -0.02756633f, -0.05840936f, 0.06291443f, -0.03290284f, 0.09866033f, -0.02936318f, 
    0.15428923f, 0.00165736f, -0.03559718f, 0.12876001f, -0.03563027f, 0.07070637f, -0.06050304f, -0.01491562f, 
    0.01082794f, -0.05991336f, 0.07640934f, 0.15759560f, 0.03596769f, -0.14527376f, -0.07633024f, -0.04012479f, 
    0.05381794f, 0.25830978f, 0.01409696f, 0.01984686f, 0.09665976f, 0.12424125f, -0.07587232f, 0.12593997f, 
    0.25963488f, -0.02852016f, -0.05445160f, 0.00996427f, -0.06561595f, 0.13261940f, 0.02620029f, 0.11018626f, 
    -0.00653068f, 0.13835414f, 0.11279023f, 0.11248024f, -0.14472455f, 0.07762896f, 0.08789906f, -0.02927594f, 
    0.14509985f, 0.04919927f, 0.17442530f, 0.11630416f, -0.06500751f, 0.20020396f, 0.12777524f, 0.18630204f, 
    0.09975601f, -0.06822654f, 0.11173214f, 0.05836657f, -0.07680520f, 0.04443147f, -0.08547528f, -0.05517147f, 
    0.02881359f, -0.06866613f, 0.03186286f, 0.01441439f, 0.38624391f, -0.05622322f, -0.00983938f, -0.08004986f, 
    -0.13117933f, -0.01778910f, -0.09886804f, 0.00453677f, 0.03661489f, -0.06065501f, 0.00310091f, -0.10315593f, 
    0.05779429f, -0.13560888f, 0.05097146f, 0.02715969f, -0.07003088f, -0.22049673f, -0.05532343f, -0.00601756f, 
    -0.18083359f, 0.04678351f, -0.11666473f, 0.07205336f, -0.22907865f, 0.04803509f, -0.16902037f, -0.05006965f, 
    -0.03082608f, 0.05345855f, 0.07848740f, -0.04183103f, 0.02749272f, 0.02199188f, -0.07552389f, 0.10987582f, 
    -0.16504988f, -0.21605809f, -0.01399384f, 0.09025381f, 0.00321824f, -0.09823136f, -0.00172253f, 0.13579848f, 
    -0.04795999f, 0.15437099f, 0.01703530f, -0.02744760f, -0.02597518f, 0.12517425f, 0.05734125f, -0.18234105f, 
    0.18358096f, 0.12665974f, 0.06409278f, -0.02929578f, -0.09505576f, -0.18971629f, -0.06920867f, -0.01885419f, 
    0.11738300f, 0.22577299f, 0.22493237f, -0.29703027f, 0.13556510f, 0.01010076f, 0.14236383f, 0.10151091f, 
    0.03867655f, 0.02490426f, -0.10991471f, -0.06055886f, 0.00437798f, 0.07918708f, 0.04318533f, 0.12035739f, 
    -0.03477016f, -0.11220286f, -0.08893529f, -0.16302098f, -0.12805331f, -0.38928229f, -0.13088991f, -0.09040734f, 
    0.10228908f, 0.05755054f, -0.23437330f, 0.02853336f, 0.23573047f, 0.04654977f, 0.11236106f, 0.02499346f, 
    -0.07263251f, 0.05553962f, 0.01153228f, -0.00243386f, -0.06920012f, -0.01117749f, 0.12660493f, 0.08504476f, 
    -0.18971351f, -0.02841373f, -0.06416506f, 0.05044613f, 0.11472868f, 0.08669441f, 0.05472222f, 0.12177966f, 
    0.06106905f, 0.18240985f, 0.16685173f, -0.02855481f, 0.11225016f, 0.01825668f, -0.13396506f, 0.17852335f, 
    0.00398272f, -0.01399846f, -0.09610392f, -0.27476805f, 0.04995769f, -0.04118836f, 0.13134913f, 0.03329679f, 
    -0.00711002f, -0.01533240f, 0.07162332f, 0.06999203f, 0.08195594f, 0.06121545f, 0.14812717f, 0.07533532f, 
    0.20701627f, 0.07585079f, -0.09324922f, 0.14484753f, 0.14315879f, 0.12077101f, -0.15530299f, 0.04568769f, 
    -0.16349687f, -0.04774406f, 0.05461010f, 0.05755637f, 0.00136444f, 0.01659762f, -0.17961979f, -0.17454073f, 
    0.03857522f, 0.04447657f, 0.10989352f, 0.02337048f, -0.07733282f, -0.01889427f, -0.03298271f, -0.02951138f, 
    -0.01707736f, 0.02207197f, 0.26485595f, 0.07383588f, 0.04862295f, 0.03833074f, 0.06122300f, -0.05800427f, 
    0.03227704f, 0.02800895f, -0.06994974f, 0.01189553f, -0.17003006f, 0.06105262f, 0.03066172f, -0.03727471f, 
    -0.06852315f, -0.01527175f, 0.03632335f, -0.12165204f, -0.08293463f, -0.11809902f, 0.00231407f, -0.19785741f, 
    -0.06552380f, -0.19276430f, -0.16609564f, -0.03896751f, 0.08186866f, 0.03771180f, 0.00619300f, 0.15904878f, 
    0.00179010f, -0.00738503f, -0.16111068f, -0.14483309f, -0.17776534f, 0.04735519f, -0.18618132f, -0.24712087f, 
    -0.03959323f, -0.15348335f, -0.17669541f, 0.36614707f, 0.10862923f, 0.04057202f, -0.02866056f, 0.15066816f, 
    0.27835637f, 0.06488021f, -0.24395441f, 0.21945243f, 0.09971492f, 0.26774785f, 0.22463286f, -0.00402819f, 
    -0.11038037f, -0.23012955f, 0.00498177f, -0.08072513f, -0.57006508f, 0.09859616f, 0.34754369f, 0.02959016f, 
    -0.15591043f, -0.04656360f, -0.06851856f, 0.16145429f, -0.01558704f, -0.00906208f, -0.00720160f, 0.04121319f, 
    -0.08310045f, 0.09990457f, 0.04679151f, 0.03148915f, -0.12663679f, 0.03031271f, -0.01267520f, -0.07308511f, 
    0.14401737f, -0.05391860f, 0.18212141f, 0.01824253f, 0.14163665f, 0.07726067f, -0.08069707f, -0.05058596f, 
    -0.07007554f, -0.08451176f, 0.08603811f, 0.06168107f, 0.09361631f, 0.05407939f, 0.08657523f, 0.00505539f, 
    -0.12618017f, -0.02501782f, 0.11809599f, 0.16476321f, 0.08148000f, 0.04945802f, 0.16152233f, -0.07392121f, 
    0.11479969f, 0.14145789f, 0.10016435f, 0.00716296f, -0.12667909f, -0.14005682f, -0.11585151f, 0.08507874f, 
    0.00681756f, -0.06570455f, -0.01532853f, -0.02126329f, 0.17867324f, 0.06756261f, 0.22083582f, 0.02526456f, 
    0.04891780f, 0.06334703f, 0.09161527f, 0.13222630f, -0.06923464f, -0.13097152f, -0.08384567f, 0.09993005f, 
    0.02195038f, -0.09720746f, -0.23160771f, 0.03689380f, -0.06100371f, 0.07251123f, 0.04736419f, -0.09484077f, 
    0.07588636f, 0.01869802f, -0.00299955f, 0.07646812f, 0.05519529f, 0.06294211f, 0.01022687f, 0.06360898f, 
    -0.00228507f, -0.29100189f, -0.03870753f, 0.02833815f, -0.07507826f, 0.12062799f, 0.14421315f, 0.00014772f, 
    0.09825845f, 0.05602720f, 0.07087773f, 0.23654906f, 0.09420303f, -0.02822758f, -0.17428546f, -0.16248171f, 
    0.11895362f, 0.27182370f, 0.02388479f, 0.05299760f, -0.01161533f, 0.04336367f, -0.06016878f, -0.09511623f, 
    -0.03898994f, 0.02546157f, 0.21855371f, -0.11841633f, -0.06169637f, -0.07800513f, 0.16128954f, 0.00186804f, 
    0.10702217f, -0.03995252f, -0.04857352f, 0.09974971f, 0.15086854f, 0.21919051f, 0.05769204f, 0.14865586f, 
    -0.01765181f, -0.09255284f, -0.25157094f, -0.02166145f, 0.03511776f, 0.01182165f, -0.07912001f, 0.07517202f, 
    -0.09043439f, -0.03304415f, 0.13383676f, -0.01191882f, 0.01281160f, -0.14614038f, 0.03362552f, 0.06135970f, 
    0.02384683f, 0.01176305f, 0.21345256f, 0.05739217f, -0.24585392f, -0.04424464f, -0.31376612f, -0.13402683f, 
    0.17566884f, -0.06549447f, 0.06045018f, -0.01006238f, -0.14390278f, -0.03135617f, -0.01852501f, -0.01575306f, 
    0.26133487f, 0.17206196f, 0.12971525f, 0.25882751f, -0.01135460f, 0.03795411f, 0.11342353f, 0.02179432f, 
    -0.07244661f, -0.01358883f, 0.01535513f, -0.03134527f, 0.21634097f, -0.02559093f, -0.05645727f, -0.05786407f, 
    -0.01134627f, -0.09590607f, 0.04713041f, 0.01509262f, 0.23190284f, 0.11563042f, 0.01083236f, 0.00588167f, 
    0.26367444f, 0.04000652f, 0.04299350f, 0.05647245f, 0.09649312f, 0.18567914f, 0.14763130f, 0.10024907f, 
    -0.09097959f, -0.14208974f, 0.07454620f, -0.08235989f, -0.15869917f, 0.10918117f, -0.14510792f, -0.10298640f, 
    -0.14498517f, 0.15637711f, 0.04628475f, 0.11427853f, 0.06008505f, 0.00294472f, -0.00769614f, 0.03752233f, 
    0.02467931f, 0.05486801f, 0.10269836f, 0.00805645f, 0.03460474f, 0.01292002f, -0.05777498f, -0.15209453f, 
    0.07143874f, 0.26822752f, -0.13067442f, -0.03900427f, -0.11077718f, -0.03580514f, -0.00758119f, -0.03528414f, 
    -0.06659204f, -0.06191866f, -0.01343795f, 0.00784171f, 0.00580441f, -0.06426826f, 0.08836444f, 0.05269167f, 
    -0.04002989f, -0.14407359f, -0.21234789f, -0.35313269f, -0.03138663f, -0.10454488f, -0.00182484f, -0.02753371f, 
    -0.12975529f, 0.05988647f, -0.09010557f, 0.07704272f, 0.02140472f, -0.09425244f, 0.21809965f, 0.10037506f, 
    0.00260586f, -0.09318609f, 0.03745498f, 0.03045541f, 0.18926185f, 0.34717715f, 0.16125013f, 0.30894831f, 
    -0.05992136f, -0.17066380f, -0.42660347f, -0.29496962f, -0.03373655f, 0.05866466f, -0.28288269f, 0.08800284f, 
    -0.04237821f, -0.01106585f, -0.03147263f, -0.13297084f, 0.05047296f, 0.18534376f, 0.28207412f, 0.15550701f, 
    -0.10252096f, -0.04211659f, 0.00520553f, -0.12021288f, -0.06571813f, 0.07542764f, 0.06464501f, 0.14123791f, 
    -0.23806337f, -0.11101252f, 0.03594847f, 0.08657864f, -0.08604095f, 0.02064144f, -0.00564865f, 0.04628406f, 
    0.07596334f, -0.06445082f, 0.06768908f, -0.05938974f, 0.03269147f, 0.11226813f, -0.01077029f, 0.07226153f, 
    0.13975592f, 0.00610377f, 0.01837371f, 0.02537968f, -0.04537484f, -0.04257907f, 0.05365926f, -0.03529046f, 
    -0.01711062f, 0.09116966f, -0.01825792f, -0.02142079f, 0.00727669f, 0.09586429f, 0.10242642f, 0.17893951f, 
    -0.13777825f, 0.04095492f, 0.08240385f, 0.15372337f, 0.02805635f, -0.37523314f, -0.32553208f, -0.27401474f, 
    -0.03804649f, 0.03484552f, -0.00597439f, 0.16867580f, 0.16261734f, 0.03577881f, 0.27341306f, -0.00957489f, 
    -0.01068110f, 0.31885737f, -0.23257869f, 0.07670487f, -0.02206825f, 0.07171409f, 0.06675636f, -0.13566881f, 
    0.11347356f, 0.23638304f, 0.06974104f, -0.09347568f, -0.18370755f, 0.01259265f, 0.07985790f, -0.04482893f, 
    0.11737163f, 0.03208544f, 0.05847396f, 0.04165769f, 0.07742269f, 0.01018679f, 0.00070712f, -0.02653247f, 
    -0.12271780f, 0.13272449f, -0.35148892f, -0.18849224f, 0.10920121f, -0.05599485f, -0.06679149f, -0.03216797f, 
    0.04807047f, 0.06674833f, -0.06535460f, 0.03566639f, -0.04551473f, -0.13105269f, -0.05589262f, -0.21443500f, 
    -0.14163543f, -0.09714634f, -0.05624144f, -0.08566498f, 0.11740822f, 0.10104702f, -0.00870981f, 0.04992816f, 
    -0.29275292f, 0.14146836f, -0.28919861f, -0.07848217f, 0.09578715f, 0.07213148f, -0.12120238f, -0.12266029f, 
    -0.03173238f, -0.11132460f, 0.02459723f, -0.08677263f, -0.46741849f, 0.16808230f, -0.14044456f, -0.03220909f, 
    -0.14709242f, -0.13367088f, 0.04913326f, 0.11677909f, 0.12965451f, -0.00366150f, 0.02804755f, 0.05642867f, 
    -0.02570376f, -0.18070132f, 0.17152004f, -0.09354603f, -0.02957076f, 0.04113164f, -0.08241206f, -0.03441840f, 
    0.18561083f, 0.12487728f, 0.12348972f, -0.02543736f, 0.08767942f, 0.10304827f, 0.06551063f, -0.07777801f, 
    0.04783770f, 0.11198004f, 0.05587928f, -0.03577683f, 0.05186007f, 0.07115476f, 0.07145647f, -0.13018681f, 
    0.16077791f, -0.21966690f, 0.23943223f, 0.20189524f, 0.02207127f, 0.12613492f, 0.01096143f, 0.05412076f, 
    0.14215949f, -0.02791276f, 0.08717071f, 0.02890837f, 0.08292955f, -0.07779036f, -0.08281628f, -0.20660107f, 
    0.01058830f, -0.08578554f, -0.01897320f, -0.05821499f, 0.11927392f, -0.06087449f, 0.16520932f, -0.14700454f, 
    -0.04065226f, -0.03757738f, 0.07349866f, -0.00686463f, 0.03429080f, -0.00119277f, 0.16915256f, 0.16597179f, 
    0.03426767f, -0.04740898f, -0.08342638f, -0.03649859f, 0.13876651f, -0.03322119f, 0.06263478f, 0.15876845f, 
    -0.03147645f, -0.02981654f, -0.10308439f, 0.03311705f, 0.12025537f, 0.12026587f, 0.10622476f, 0.26485977f, 
    0.10809229f, -0.13605089f, 0.04225720f, 0.03879071f, -0.00048936f, 0.05869213f, -0.03457526f, 0.08330661f, 
    0.09230157f, 0.08155639f, 0.10325658f, 0.00888588f, -0.19812852f, 0.04468848f, -0.06144910f, 0.16703686f, 
    0.04887195f, 0.11366896f, 0.07116627f, -0.02976505f, -0.11422201f, 0.03936857f, 0.03507000f, 0.21113914f, 
    0.03752294f, 0.05951383f, -0.05258085f, -0.02004627f, -0.05239132f, 0.17049521f, 0.03847924f, 0.07455708f, 
    0.00521041f, 0.07075270f, -0.04659913f, 0.03753577f, 0.02044103f, 0.21883366f, -0.05639978f, -0.25508037f, 
    -0.05361342f, -0.06280483f, 0.03133021f, -0.20682810f, 0.05576836f, -0.01929950f, -0.15419218f, -0.07160541f, 
    0.09383832f, -0.18631846f, 0.13837035f, 0.10840087f, 0.14291562f, -0.04515885f, -0.05494584f, 0.10398600f, 
    0.00893262f, -0.01195146f, -0.20593667f, 0.06006377f, 0.06034603f, 0.18151121f, -0.09604742f, 0.00102880f, 
    0.08920756f, 0.15108138f, 0.07655102f, 0.04609713f, 0.00752784f, -0.02908134f, 0.02218891f, 0.04552003f, 
    -0.35272631f, -0.18642174f, -0.09024372f, -0.04126634f, 0.01154248f, 0.07084436f, 0.07273792f, 0.04975536f, 
    -0.02347943f, -0.13624634f, -0.05267941f, 0.05477412f, 0.14813615f, 0.18791117f, -0.13308601f, -0.00162315f, 
    -0.03888064f, -0.02932887f, -0.02825631f, -0.04284210f, 0.13478881f, 0.00381994f, 0.08910044f, 0.15317686f, 
    -0.14707772f, -0.26053575f, -0.20080197f, 0.02141871f, 0.11480730f, 0.07197367f, 0.12714107f, -0.19473130f, 
    -0.11302804f, -0.03882860f, 0.04998791f, -0.02220733f, -0.04528610f, -0.11748411f, 0.23720677f, 0.06450535f, 
    -0.03226316f, 0.09591625f, -0.05795509f, 0.03843499f, -0.04812415f, 0.09279358f, -0.03704242f, -0.02531672f, 
    0.07063214f, -0.02675420f, 0.13869505f, 0.13527924f, 0.07481034f, 0.01874219f, 0.04619071f, -0.08935731f, 
    -0.12704080f, -0.09586486f, 0.13113932f, -0.06960642f, 0.06328835f, 0.15438408f, -0.07505126f, 0.13139725f, 
    0.10770918f, 0.14261621f, 0.02879459f, 0.00810878f, 0.03984511f, 0.02253354f, 0.02121853f, 0.01188456f, 
    0.00533272f, 0.21140532f, -0.06471005f, -0.41725224f, -0.00560631f, 0.07089636f, 0.11640799f, 0.02199661f, 
    -0.00387167f, 0.10288168f, -0.09477001f, 0.11624554f, -0.09656797f, -0.06101240f, 0.01859144f, -0.16461889f, 
    0.04809666f, -0.05132113f, -0.03186320f, -0.06219558f, -0.08658958f, 0.06657603f, -0.00194798f, 0.14478062f, 
    0.15530702f, 0.21809344f, -0.31065607f, 0.21282715f, 0.00835944f, 0.08287030f, -0.17368320f, 0.03930787f, 
    -0.03147548f, 0.00866389f, 0.04356494f, 0.03005009f, 0.07579519f, -0.05739322f, 0.21356161f, -0.16673735f, 
    -0.07343441f, 0.02681877f, 0.06035781f, -0.05430995f, 0.00189995f, -0.03510739f, 0.11137194f, 0.16137797f, 
    0.07925946f, -0.02420075f, 0.06641095f, 0.05841525f, -0.00682519f, 0.10199907f, 0.09992611f, 0.08496450f, 
    -0.00970251f, -0.03481336f, -0.04243035f, -0.00020970f, -0.03579717f, -0.08872804f, -0.09755578f, -0.08761567f, 
    -0.03123731f, 0.12394706f, 0.10031714f, -0.02353510f, -0.05660906f, -0.01583307f, -0.01897718f, -0.10300570f, 
    0.16633166f, 0.17442895f, -0.07959031f, 0.07686876f, -0.04256577f, 0.22502343f, -0.00810380f, 0.02202631f, 
    0.04019094f, 0.02078709f, 0.02967504f, 0.10381521f, 0.25067514f, 0.20946057f, -0.01545237f, -0.00089649f, 
    0.01975554f, 0.09144872f, -0.06647828f, 0.10558300f, 0.03190551f, 0.05829154f, 0.02984652f, 0.05181957f, 
    0.33647260f, -0.17712861f, 0.05868601f, -0.10222612f, 0.04382526f, 0.09360877f, -0.05007764f, 0.13410176f, 
    0.06266786f, 0.13561246f, 0.02041182f, 0.12840720f, -0.00593793f, 0.01935376f, -0.18091740f, -0.05590468f, 
    0.19657721f, 0.04186597f, 0.06238759f, 0.06188415f, -0.03320041f, 0.17041530f, 0.06170288f, 0.23399015f, 
    0.03346019f, 0.02614840f, 0.18119474f, 0.01727394f, -0.17126757f, -0.08188633f, -0.01337344f, -0.13495848f, 
    -0.09029140f, -0.01882985f, 0.00325073f, 0.10340400f, 0.50000179f, 0.18862034f, -0.00917504f, -0.08577718f, 
    -0.07058776f, 0.08917608f, 0.00829752f, -0.18553896f, 0.11448424f, -0.05386637f, 0.05975280f, -0.10587980f, 
    0.16175827f, -0.15026644f, 0.14677700f, -0.06265282f, -0.10890695f, -0.35121915f, -0.06340812f, -0.00269173f, 
    -0.13866378f, 0.06264115f, -0.09903023f, 0.00497169f, 0.12227847f, -0.04664714f, -0.04851380f, 0.00907789f, 
    0.08592324f, 0.09087447f, -0.01289710f, -0.10410635f, 0.04956850f, 0.07392425f, -0.04664497f, -0.03937959f, 
    -0.01710062f, -0.09910272f, 0.10980109f, -0.02089521f, 0.09337609f, 0.06974358f, 0.09111457f, 0.20758294f, 
    -0.08715644f, 0.19055650f, 0.02654097f, 0.14479482f, -0.14424692f, 0.13880584f, 0.04581803f, -0.06112843f, 
    0.09518372f, 0.03419099f, -0.02858371f, 0.12022509f, -0.05763175f, -0.11563865f, -0.03964211f, -0.11472261f, 
    0.00021813f, 0.31350505f, -0.15282431f, -0.38933432f, 0.00057741f, -0.04940889f, 0.01246358f, 0.24652828f, 
    0.01446701f, 0.08433757f, -0.07648292f, -0.00808117f, -0.00639877f, 0.08152276f, 0.11866061f, -0.02176652f, 
    -0.07434918f, -0.03468224f, -0.21404609f, -0.12230478f, -0.10029273f, -0.14012046f, -0.09047962f, -0.10218377f, 
    0.07518367f, 0.13784146f, -0.21120985f, 0.04892452f, 0.07957435f, 0.16672400f, 0.02994887f, 0.01339732f, 
    -0.09152304f, 0.12737006f, 0.07891440f, -0.03633010f, -0.01919986f, -0.02583847f, 0.16730145f, 0.01184853f, 
    -0.13361484f, -0.08493190f, -0.06458746f, -0.06433994f, 0.02783971f, 0.02336831f, 0.15993722f, 0.09393883f, 
    -0.03647967f, 0.09196726f, 0.27615926f, -0.05222484f, -0.00278263f, 0.08708684f, -0.02725490f, 0.13306905f, 
    -0.01645379f, 0.09533542f, 0.00332860f, -0.27840784f, 0.11623946f, -0.01656584f, 0.12750980f, 0.02694033f, 
    -0.06497313f, -0.13498588f, 0.11881056f, 0.03200649f, 0.07053789f, 0.01039588f, 0.11329985f, 0.02622879f, 
    0.01101708f, -0.03831760f, -0.13594759f, 0.17851299f, 0.10760735f, 0.17833090f, -0.09255074f, -0.02145701f, 
    -0.13807116f, 0.02478370f, 0.17901035f, -0.00548128f, -0.08347656f, 0.00844429f, 0.02327725f, -0.14833598f, 
    0.04919085f, 0.06103498f, 0.21744332f, 0.10411514f, -0.03601687f, 0.13280270f, 0.07866923f, -0.08718453f, 
    0.02163255f, -0.04628283f, 0.00626570f, 0.00599988f, -0.05503684f, -0.04559121f, -0.03589104f, 0.00997812f, 
    -0.00534988f, -0.01113599f, -0.05027807f, 0.05367904f, -0.04743697f, 0.05671423f, -0.06941193f, -0.03432864f, 
    -0.02061111f, 0.04233987f, 0.04258695f, 0.03317723f, -0.05731719f, -0.05776694f, 0.05046614f, -0.01829259f, 
    -0.07322402f, 0.03522445f, -0.07043819f, -0.07803738f, -0.03503511f, 0.03562693f, 0.04005912f, 0.03183979f, 
    -0.04538685f, -0.04184654f, 0.05172355f, 0.03698268f, 0.04626471f, 0.02357334f, -0.01604225f, -0.06010479f, 
    -0.01504560f, 0.01845554f, 0.00238914f, -0.05444039f, -0.06630050f, -0.03508947f, -0.06642581f, -0.07525934f, 
    0.01335194f, 0.01571853f, 0.04893201f, -0.05086378f, 0.02237318f, 0.01806606f, -0.02510787f, -0.03757534f, 
    -0.04162220f, -0.07656041f, 0.00128913f, -0.05054475f, 0.00346074f, -0.04687913f, -0.08499517f, -0.01304104f, 
    0.05939403f, -0.01647198f, -0.01782838f, -0.06689847f, -0.04438492f, -0.07294634f, 0.01580491f, -0.00611887f, 
    0.01939827f, -0.05831378f, -0.02803319f, -0.04178038f, 0.03595994f, -0.07710539f, 0.02182331f, -0.07896582f, 
    0.03863300f, -0.02502729f, 0.01947591f, -0.06522390f, 0.04744409f, 0.01341649f, 0.06229861f, -0.06108903f, 
    0.03022779f, 0.05385705f, -0.02685116f, -0.03606180f, -0.02101990f, 0.03386197f, 0.02179876f, 0.02947709f, 
    -0.05888214f, 0.05752060f, -0.05494029f, -0.03963462f, 0.00072234f, 0.04022080f, -0.06120395f, -0.03383309f, 
    0.01848506f, -0.05003447f, -0.00468178f, -0.05156282f, -0.02106229f, -0.07671659f, -0.00738693f, -0.00276645f, 
    -0.01586461f, 0.05092644f, 0.04932518f, 0.05087561f, -0.02905889f, -0.04985731f, -0.07815189f, 0.05958850f, 
    0.02285878f, -0.04237672f, 0.03924802f, -0.00552010f, -0.04810943f, 0.05190098f, -0.07282034f, 0.05018529f, 
    0.00095494f, -0.05301329f, 0.04155417f, 0.03744740f, 0.04916236f, 0.00002827f, -0.00506238f, 0.03900013f, 
    0.03576786f, 0.03325682f, 0.00928216f, 0.04601982f, 0.02716364f, -0.07206801f, 0.02797575f, 0.02319192f, 
    -0.06607680f, 0.02402752f, -0.05198309f, 0.01662144f, -0.05133316f, -0.07278577f, -0.07168560f, 0.02086309f, 
    -0.00980781f, -0.00458268f, -0.00082716f, -0.03403401f, -0.06570373f, 0.05516048f, 0.02038378f, 0.03197218f, 
    -0.04434906f, -0.06206553f, 0.05788337f, -0.07686078f, -0.06948450f, -0.07467535f, -0.03797026f, 0.04714774f, 
    -0.03340679f, 0.06080640f, 0.05146091f, -0.01927019f, -0.06110216f, 0.04287297f, 0.06351717f, 0.03059266f, 
    -0.06487180f, -0.04642903f, 0.01184377f, 0.02946787f, 0.01919682f, -0.07396505f, -0.02370188f, 0.01674382f, 
    -0.06155966f, 0.05885669f, -0.08468528f, -0.03766685f, 0.04598406f, -0.01292023f, -0.07046463f, 0.04021534f, 
    0.08015531f, 0.13634406f, 0.02854416f, 0.21158449f, 0.04157046f, 0.10785164f, -0.02853063f, -0.00246033f, 
    -0.07456242f, -0.09027144f, 0.01924147f, 0.01908454f, 0.14983834f, 0.17291419f, 0.11629103f, 0.14942372f, 
    -0.06611168f, 0.00812997f, 0.07760176f, 0.06350595f, 0.00494395f, 0.08182978f, 0.02615453f, 0.01887872f, 
    0.36088252f, 0.03981017f, -0.22420935f, 0.08565147f, 0.02829093f, -0.05309883f, 0.02144695f, -0.14808190f, 
    0.04981735f, 0.03007833f, -0.04235803f, 0.02059095f, 0.24012536f, 0.14519112f, -0.26776919f, -0.09185457f, 
    0.07300265f, -0.03634893f, -0.00101890f, 0.01088571f, -0.00995142f, -0.01684015f, 0.03331544f, -0.14961626f, 
    0.31376886f, -0.11602921f, 0.04986133f, 0.12094325f, -0.02681888f, -0.08217742f, -0.06106649f, 0.11066490f, 
    0.00125883f, -0.01902402f, 0.07333693f, -0.05975009f, 0.12358567f, 0.19009291f, -0.02326428f, -0.00011108f, 
    0.06086290f, -0.07442904f, -0.08071804f, -0.03043403f, -0.24363501f, -0.08598956f, -0.09275410f, 0.03101837f, 
    0.03004700f, 0.14847596f, 0.07161468f, 0.04605906f, -0.02802540f, 0.04146929f, -0.02314766f, 0.07303637f, 
    -0.06258682f, 0.05413953f, 0.28971711f, 0.03944444f, -0.10206280f, -0.01753077f, -0.01999040f, 0.09204274f, 
    -0.08386715f, 0.01133194f, -0.11416462f, 0.02748502f, 0.07539173f, -0.10104620f, -0.08181509f, -0.15955362f, 
    -0.11388151f, -0.01112979f, -0.02387386f, 0.10104891f, -0.17442845f, 0.12370095f, -0.03277691f, 0.01506678f, 
    -0.00820618f, 0.11893146f, -0.13893321f, -0.02456785f, 0.20723556f, 0.19235450f, 0.14161459f, 0.07161191f, 
    -0.02723812f, 0.00847837f, -0.08761039f, -0.03537121f, 0.18971616f, -0.02730089f, -0.02360912f, -0.02126023f, 
    -0.12547533f, 0.06257997f, -0.21236157f, 0.03273226f, -0.00723272f, 0.06278554f, -0.15690155f, -0.01247349f, 
    0.10316953f, 0.01095931f, 0.05286543f, -0.08797588f, 0.25906092f, 0.26882613f, 0.22263981f, -0.00819676f, 
    -0.02582322f, 0.03244051f, 0.02998327f, -0.06923613f, 0.15818627f, -0.04705881f, -0.01411671f, 0.00480498f, 
    -0.27001083f, 0.05636222f, 0.04001249f, 0.08963390f, -0.07562187f, -0.09679222f, -0.01828141f, -0.06255532f, 
    -0.01843156f, -0.16668384f, -0.02866605f, -0.07650146f, 0.07833496f, 0.05017211f, -0.08889434f, -0.00898802f, 
    0.00735102f, 0.00687006f, 0.10720657f, -0.00358122f, -0.02352839f, -0.07765466f, 0.16305509f, -0.11547534f, 
    0.02957748f, -0.07029390f, 0.17913662f, -0.03161648f, 0.07794697f, -0.03050483f, 0.06952754f, 0.03508680f, 
    0.00204491f, 0.00660506f, -0.17420976f, 0.01368384f, 0.01858065f, 0.05625601f, -0.11392137f, 0.16994309f, 
    -0.05208175f, 0.09235942f, -0.07577771f, -0.00243801f, 0.07150439f, 0.10789707f, 0.02311042f, -0.07889848f, 
    -0.10686333f, -0.16328305f, -0.03812104f, 0.03959708f, 0.17503975f, -0.07593651f, -0.05792679f, -0.00524071f, 
    -0.04385815f, -0.04966822f, -0.18930978f, 0.11079275f, 0.01453422f, 0.12630051f, 0.07696202f, 0.24437271f, 
    -0.01271463f, 0.15078291f, 0.05878457f, 0.14228314f, -0.01217829f, -0.19303554f, -0.05836830f, -0.17682731f, 
    -0.20761871f, 0.00231337f, -0.14484093f, 0.08072263f, 0.08888114f, -0.00254236f, -0.03337622f, -0.02823301f, 
    -0.12938756f, -0.21364044f, -0.14353296f, -0.06163419f, 0.11914489f, -0.28285310f, -0.21219799f, 0.08862881f, 
    -0.08221159f, -0.07995607f, -0.10855678f, -0.19466940f, 0.10405896f, 0.04090132f, 0.00369141f, 0.21781002f, 
    0.04104687f, 0.27411747f, -0.25085407f, 0.20196222f, 0.18425573f, 0.08657922f, 0.08183452f, 0.02629702f, 
    -0.16228104f, -0.12344782f, -0.06364582f, -0.10646613f, 0.12085330f, -0.12043531f, -0.05679822f, 0.04570979f, 
    -0.10458598f, 0.05744889f, -0.04786015f, 0.10148560f, 0.16099578f, 0.11062071f, -0.04545267f, 0.05672501f, 
    0.08965458f, 0.25690725f, -0.08591723f, -0.16921164f, 0.04958132f, -0.07974803f, 0.18406034f, 0.05044398f, 
    -0.13410443f, -0.29441690f, -0.02616225f, 0.08675814f, 0.14941308f, 0.06540115f, 0.14385034f, 0.17078343f, 
    -0.00797574f, -0.00359131f, 0.09711168f, 0.07224185f, 0.09529610f, 0.22816369f, 0.02982807f, 0.15296398f, 
    -0.01985789f, 0.11021734f, 0.09557828f, 0.14581467f, -0.03836077f, 0.11217443f, 0.00334847f, -0.00820310f, 
    -0.04051076f, 0.08742456f, 0.01795208f, 0.11816610f, -0.07945208f, -0.15171477f, 0.03014965f, -0.05643738f, 
    -0.15077370f, -0.25195581f, -0.12829161f, -0.12877193f, -0.07245814f, -0.00091421f, -0.02826702f, 0.23359342f, 
    0.27972949f, 0.14520541f, 0.01139292f, 0.07091527f, -0.13898498f, 0.08773279f, 0.10309704f, 0.04811647f, 
    -0.02421377f, 0.03646101f, -0.02495145f, 0.05035881f, -0.14546612f, -0.17432715f, -0.04964386f, -0.06693586f, 
    -0.08358508f, -0.28597480f, -0.17077394f, -0.11152248f, -0.06233546f, 0.01575323f, 0.00107355f, -0.03375896f, 
    0.20767480f, -0.00534494f, -0.10249679f, 0.01863492f, 0.02543849f, 0.07852949f, -0.08609731f, 0.02063152f, 
    -0.03984679f, 0.01698397f, 0.01317030f, 0.15648662f, -0.13468246f, -0.32587224f, -0.30863535f, -0.22702798f, 
    -0.04660892f, 0.05003093f, -0.08667704f, -0.17569393f, 0.00986414f, -0.18893375f, -0.13055718f, -0.09142640f, 
    0.10480408f, 0.26040235f, 0.13200289f, 0.13847122f, -0.02535293f, 0.01980221f, 0.15738328f, 0.01790187f, 
    0.08377702f, 0.03228147f, -0.01170898f, 0.01876643f, 0.35835716f, 0.18220846f, 0.14244024f, 0.23671739f, 
    -0.05793972f, 0.01846080f, 0.12848312f, 0.16825201f, 0.04695442f, 0.04082756f, 0.01449042f, 0.05815021f, 
    -0.07920356f, -0.12520717f, 0.19996801f, -0.06102395f, 0.14884017f, 0.01691388f, 0.07560354f, -0.00851996f, 
    -0.01383715f, 0.18549551f, -0.04245369f, 0.03819258f, -0.15333110f, 0.02550708f, -0.05971388f, 0.16146083f, 
    0.08560996f, -0.22360228f, 0.15833014f, 0.08728114f, 0.12170576f, 0.00127839f, 0.10786363f, 0.15071061f, 
    -0.18799067f, 0.25231546f, -0.05310593f, -0.02505888f, -0.00225991f, -0.09504718f, 0.05629601f, -0.01259612f, 
    -0.07089873f, -0.05463616f, -0.01655186f, 0.01806114f, 0.21459407f, -0.23676462f, 0.20632584f, -0.13665426f, 
    -0.04202293f, -0.04306568f, -0.01482597f, -0.00302526f, 0.09419783f, -0.00355193f, -0.09661849f, 0.09798189f, 
    0.03241871f, 0.47871733f, -0.08183093f, -0.06838597f, 0.01342384f, -0.10238043f, 0.13370173f, -0.04126950f, 
    0.02008381f, -0.03261100f, 0.04937905f, -0.06211088f, -0.47209513f, -0.10999272f, -0.07782968f, 0.01380381f, 
    -0.27100825f, 0.06696276f, -0.07959908f, 0.06178695f, 0.09897336f, -0.00011811f, -0.19896385f, -0.15026689f, 
    0.12929152f, 0.12931947f, 0.07125462f, -0.03618873f, -0.10050023f, -0.09413843f, -0.08257112f, -0.06606425f, 
    0.12649901f, 0.02819975f, -0.16409770f, -0.07281762f, 0.09212811f, 0.02012958f, 0.04042458f, 0.00093169f, 
    -0.09614789f, -0.02468563f, 0.17042278f, -0.02470079f, 0.07350679f, 0.01948879f, -0.00713951f, 0.05709617f, 
    -0.05603172f, -0.04076277f, -0.12995651f, 0.12309210f, 0.04072738f, -0.05203773f, 0.17300574f, 0.16483141f, 
    0.13401769f, 0.05546172f, 0.08784908f, 0.16440246f, 0.00182222f, 0.00747952f, 0.02599438f, 0.05648379f, 
    -0.09678410f, -0.06574581f, -0.08586522f, 0.03949421f, -0.03371005f, -0.08921256f, -0.06633723f, 0.13773613f, 
    0.13777818f, 0.02418606f, 0.21631305f, 0.06016930f, -0.01459810f, -0.05954102f, 0.02086222f, 0.15320341f, 
    -0.10568590f, -0.04445247f, 0.00041836f, 0.03676825f, -0.06508368f, -0.04625886f, 0.22557320f, 0.13969685f, 
    0.03736941f, -0.02395220f, -0.03392607f, 0.00856684f, 0.09373535f, 0.12293931f, 0.08452409f, 0.07868659f, 
    0.01026314f, -0.25288808f, -0.02584405f, 0.03547586f, 0.16725487f, 0.11920086f, 0.17976563f, 0.08895436f, 
    0.08684489f, 0.06902193f, -0.02226269f, -0.01847153f, 0.00581853f, 0.00344424f, 0.07982159f, -0.02569816f, 
    0.13989034f, -0.04625766f, -0.10947759f, 0.04363656f, 0.08830795f, 0.01403000f, 0.05247072f, 0.07783826f, 
    0.18113257f, 0.00869730f, 0.01728361f, -0.02670269f, -0.06405896f, -0.07441188f, -0.09166399f, -0.00928864f, 
    0.02215698f, 0.10877536f, 0.08931989f, -0.06317604f, 0.00644105f, 0.06228726f, 0.07700028f, -0.06456631f, 
    -0.07478334f, -0.07462676f, 0.04266936f, 0.04408593f, 0.02298184f, 0.02156289f, 0.02127706f, -0.01743280f, 
    0.38352078f, 0.06828502f, 0.03610146f, 0.01811590f, -0.12077776f, 0.01754761f, -0.08435258f, 0.10479721f, 
    0.08065744f, 0.00545842f, 0.10257714f, 0.11642338f, 0.22987039f, -0.13850431f, -0.03420924f, -0.00685102f, 
    0.12862298f, 0.05260466f, -0.01104053f, 0.12829223f, -0.02744380f, 0.08550255f, 0.06861244f, 0.23971505f, 
    0.11664291f, 0.23831084f, 0.44435754f, 0.00494673f, -0.18544148f, -0.04823392f, -0.13556395f, -0.23459198f, 
    -0.08969232f, -0.09264091f, 0.13845000f, -0.00052680f, -0.17247787f, 0.15650409f, 0.03318959f, 0.02300311f, 
    -0.02867719f, 0.14631017f, 0.04543685f, -0.15871733f, -0.04059825f, -0.00657132f, 0.08435130f, -0.05474082f, 
    -0.17399175f, -0.08624450f, 0.45676637f, -0.05192875f, -0.18569106f, -0.27757803f, -0.31480300f, 0.00882484f, 
    -0.07672554f, 0.07372365f, -0.11271654f, 0.20692116f, 0.25410637f, -0.13017415f, -0.14461504f, -0.14692982f, 
    0.12738113f, -0.04033436f, 0.18314628f, -0.00290734f, -0.11221295f, 0.03607830f, 0.05920786f, 0.01002870f, 
    -0.04212241f, -0.00648718f, -0.02237071f, 0.22274621f, 0.01290449f, -0.06559145f, 0.14790808f, 0.13429488f, 
    0.01892896f, 0.15669835f, 0.13952173f, 0.06734890f, -0.16536891f, -0.14962232f, -0.13188256f, 0.02189153f, 
    -0.04603768f, 0.09181016f, 0.06031279f, 0.04540760f, -0.07569142f, -0.03622815f, 0.01273924f, -0.09712961f, 
    0.15576160f, 0.10772435f, -0.25781915f, -0.02882251f, 0.03817141f, -0.00951376f, 0.06511396f, 0.09502019f, 
    0.01158431f, 0.00661028f, 0.05526501f, 0.13811144f, -0.02948895f, 0.32271919f, -0.20137356f, -0.19635084f, 
    -0.06270647f, -0.06110622f, -0.18625598f, -0.12935258f, -0.08392753f, 0.06274629f, -0.12995015f, -0.00787135f, 
    -0.18411006f, 0.16605005f, -0.02146170f, 0.24623092f, -0.02976893f, 0.03084880f, 0.10664079f, -0.05447700f, 
    -0.04715668f, 0.12144937f, 0.06371400f, 0.04227102f, 0.07528895f, 0.06674352f, 0.06398061f, -0.15249695f, 
    -0.11590452f, -0.06152643f, 0.03784566f, -0.04537367f, 0.08476031f, 0.10814601f, -0.01764346f, 0.16407850f, 
    0.05994238f, 0.19902952f, 0.19199254f, -0.03504326f, 0.04076982f, -0.01453336f, -0.04695783f, 0.10888395f, 
    -0.01425067f, 0.05558227f, 0.07006130f, -0.18655673f, 0.06601983f, -0.11105213f, 0.17014895f, 0.01023536f, 
    -0.05621979f, -0.04752445f, 0.12809578f, 0.07447735f, 0.03919699f, 0.10132260f, 0.31600687f, 0.15585074f, 
    -0.07287417f, -0.25328863f, -0.01695584f, 0.16292973f, 0.09461913f, 0.01166058f, -0.03180845f, -0.02917130f, 
    -0.03499825f, 0.04185602f, 0.03505192f, -0.03226101f, -0.26650202f, -0.09930293f, 0.13593034f, 0.05560907f, 
    0.08672998f, 0.08860636f, 0.10340914f, 0.14684740f, 0.00586424f, 0.13544829f, 0.07940987f, 0.01604578f, 
    0.13377725f, -0.05241489f, 0.04712065f, 0.04425342f, 0.13328262f, -0.12038793f, 0.15467115f, 0.11225928f, 
    0.10501482f, -0.07774477f, -0.06952694f, 0.06359086f, -0.10094821f, 0.04059185f, 0.01647974f, 0.09967720f, 
    0.13469844f, 0.13279086f, 0.05273756f, 0.16399314f, -0.01705165f, 0.05323146f, 0.05375796f, 0.10839981f, 
    0.05573908f, 0.32186210f, 0.04009534f, -0.19047365f, -0.10947260f, -0.15996675f, 0.01468695f, -0.10748837f, 
    -0.00448087f, 0.01410620f, 0.13786002f, 0.06729372f, 0.43622416f, 0.08892061f, 0.12210748f, 0.03290593f, 
    -0.07558105f, 0.01290626f, -0.07587906f, -0.27664772f, 0.05982915f, 0.00675442f, -0.01349162f, 0.03100914f, 
    -0.07851389f, 0.18522558f, -0.01237388f, -0.33253795f, -0.10344705f, -0.27703470f, -0.01570657f, -0.04240388f, 
    -0.00593148f, 0.02075095f, -0.12983640f, 0.06096753f, 0.05706761f, -0.24815787f, -0.17789283f, 0.02198356f, 
    -0.15325579f, -0.08167825f, -0.11141230f, 0.04190869f, 0.06017309f, 0.04127872f, -0.09187903f, -0.06556636f, 
    0.20564227f, 0.07418720f, 0.21167766f, -0.08814567f, -0.05718322f, -0.05377590f, 0.17569089f, 0.22766349f, 
    -0.14724673f, -0.01690388f, -0.09253937f, 0.09694666f, -0.11317103f, 0.08339274f, 0.04337990f, -0.09076516f, 
    -0.01201545f, 0.02119678f, 0.02365348f, -0.01204663f, 0.09015556f, -0.06006297f, -0.02855263f, 0.01117100f, 
    -0.24440767f, 0.08999284f, -0.31335583f, -0.14383136f, -0.09535933f, 0.05109333f, 0.10487548f, 0.09517641f, 
    0.02146649f, -0.04063855f, -0.05040716f, 0.12271122f, 0.14690036f, 0.03195363f, 0.18676743f, -0.02513564f, 
    -0.16497445f, -0.16879822f, -0.15184307f, -0.12265669f, -0.03341384f, -0.19519733f, -0.04717566f, 0.08204518f, 
    0.02161467f, 0.16066942f, -0.05357470f, 0.06371456f, 0.04250922f, 0.16630822f, 0.02278174f, 0.02844648f, 
    0.09852800f, 0.09068072f, 0.13290718f, -0.08241713f, 0.21563798f, -0.21332082f, -0.08352989f, 0.02399195f, 
    -0.16754855f, -0.09404110f, 0.09911458f, -0.04990517f, 0.11563289f, 0.02220294f, 0.06797820f, 0.01856861f, 
    0.22823724f, -0.09969947f, 0.02545078f, -0.08749668f, 0.18523294f, -0.08029813f, -0.02219417f, -0.02823981f, 
    0.10486601f, 0.22339971f, 0.00901914f, -0.03727414f, 0.03727429f, -0.11132063f, 0.00222172f, 0.11742095f, 
    0.05264373f, -0.13403200f, 0.06811672f, 0.00187796f, -0.01549076f, 0.01208176f, -0.02813067f, 0.09238243f, 
    0.08251244f, 0.02724755f, -0.13536234f, 0.16651979f, 0.10310563f, 0.06064472f, -0.08400782f, 0.02752985f, 
    -0.04361384f, 0.02253000f, 0.04428585f, 0.07099730f, -0.03480854f, 0.13076521f, 0.10615917f, -0.19038925f, 
    -0.08473685f, -0.03866668f, 0.27164772f, 0.14507650f, 0.12059544f, 0.00070308f, 0.00483898f, -0.09815404f, 
    -0.00876927f, 0.15352006f, 0.05996077f, 0.28531861f, -0.03704573f, -0.03733874f, 0.18303144f, 0.13260725f, 
    0.15586087f, 0.23753820f, 0.24992074f, 0.26356819f, -0.02547145f, -0.07284837f, -0.08980891f, 0.15060449f, 
    -0.05902988f, -0.01497512f, -0.01787481f, 0.04233669f, 0.12481303f, 0.15953366f, 0.12325707f, 0.03422668f, 
    0.16252126f, 0.23579687f, 0.06993650f, 0.18777837f, -0.01198329f, -0.08629711f, 0.02992998f, -0.04434645f, 
    -0.03270542f, 0.04026081f, 0.07688146f, 0.03088029f, 0.23205014f, -0.04476476f, -0.00204047f, -0.02790717f, 
    0.01928885f, -0.03558703f, 0.01590960f, -0.05710614f, 0.03453376f, -0.05132782f, -0.06698278f, 0.03024986f, 
    0.14491744f, 0.15116321f, 0.04714031f, 0.09080072f, -0.06112365f, -0.13856125f, 0.10949585f, 0.19382229f, 
    -0.06189459f, 0.04777531f, -0.01554659f, -0.04246582f, 0.62922770f, -0.08213504f, -0.38159299f, -0.25290591f, 
    0.15567030f, -0.06589142f, -0.08535261f, -0.05246397f, 0.03887963f, -0.02197543f, -0.10072729f, -0.03930616f, 
    0.05081175f, -0.08412356f, 0.18235941f, -0.15315765f, -0.06643674f, 0.05444232f, 0.10412656f, 0.12499516f, 
    0.08469638f, 0.11013646f, -0.01774886f, 0.01908126f, -0.12838724f, -0.18968846f, -0.05555282f, 0.04375178f, 
    -0.06916406f, 0.10166302f, -0.08312760f, 0.15563545f, 0.03314637f, -0.06760787f, 0.06960931f, -0.08316637f, 
    0.02288636f, -0.13161549f, -0.20790839f, -0.00821465f, 0.03445353f, 0.14035705f, -0.04348012f, 0.02065757f, 
    0.05852268f, 0.03096418f, 0.25838405f, 0.09548224f, 0.15366916f, 0.00113476f, 0.16032298f, -0.00668694f, 
    -0.01838960f, 0.05094144f, -0.10186661f, -0.12449516f, 0.06724892f, 0.06283984f, 0.04870808f, -0.14399403f, 
    -0.01998092f, -0.18333127f, -0.26693344f, -0.22528441f, 0.02443671f, -0.06261230f, -0.01193665f, -0.06722604f, 
    -0.03671102f, -0.07074756f, -0.10162280f, -0.12069414f, 0.14667611f, 0.23265712f, -0.04649885f, 0.04556977f, 
    -0.16602826f, -0.07332430f, 0.05063213f, -0.17207989f, -0.01559677f, 0.09459238f, -0.01271978f, -0.03154143f, 
    0.00108009f, 0.06131511f, -0.01540229f, 0.05852027f, 0.11730973f, 0.03992141f, 0.05724845f, -0.01343364f, 
    0.02565081f, 0.02148849f, 0.10967267f, 0.03167764f, -0.06160796f, 0.08040719f, -0.04722942f, -0.13263513f, 
    -0.01007085f, -0.14557947f, 0.12716398f, -0.08881877f, 0.00349904f, 0.01093563f, 0.05419087f, 0.04243501f, 
    -0.10243998f, -0.14455344f, 0.00513763f, -0.05998098f, 0.08070526f, 0.03107962f, 0.03375079f, 0.12627868f, 
    -0.10850430f, 0.06817240f, 0.02053334f, 0.08666218f, -0.09004550f, -0.34121007f, -0.13047086f, 0.02043336f, 
    0.07925956f, -0.06296654f, 0.09577189f, 0.16662768f, 0.05050058f, 0.05474580f, -0.06183797f, 0.01556096f, 
    -0.14330719f, 0.02082322f, -0.11366972f, -0.00850268f, -0.03523692f, -0.06827905f, 0.14953794f, -0.17759794f, 
    -0.06337297f, 0.05471152f, 0.15483642f, -0.03589480f, -0.05151248f, -0.11690059f, 0.14743723f, -0.02147076f, 
    -0.04700742f, -0.07201663f, -0.00948682f, -0.17068495f, 0.02851718f, -0.10167889f, -0.08512837f, -0.16542988f, 
    -0.04680868f, 0.01164389f, 0.12594871f, -0.02878403f, 0.16794170f, 0.01903615f, 0.01355078f, 0.13195215f, 
    -0.06327017f, 0.02792125f, -0.08420862f, -0.15192741f, -0.26552173f, -0.05385402f, 0.11773355f, -0.00256809f, 
    0.02673701f, 0.02757156f, 0.07896281f, 0.00545436f, -0.00094900f, 0.07601602f, 0.03682669f, 0.18497434f, 
    0.07462128f, 0.25512531f, 0.19620591f, 0.05957770f, 0.06366444f, 0.21423566f, 0.19501355f, -0.06481562f, 
    -0.02955959f, 0.02390113f, -0.01015166f, -0.01811554f, -0.27299902f, 0.03611218f, -0.08310723f, -0.05944289f, 
    -0.05663344f, -0.01901684f, 0.16941348f, 0.04701282f, 0.15078254f, 0.08405005f, 0.10596675f, 0.02485615f, 
    -0.07077437f, 0.05591302f, -0.21051869f, -0.09381332f, 0.04882963f, 0.12331160f, -0.04460205f, -0.11869612f, 
    0.24142380f, -0.15523416f, 0.01483204f, -0.09324586f, 0.17082070f, -0.02395218f, 0.04198704f, 0.07406877f, 
    0.02214496f, -0.06177079f, 0.04720625f, -0.02808687f, 0.03920231f, 0.13391346f, 0.03622171f, 0.16425888f, 
    0.07880977f, -0.19540806f, 0.21412310f, 0.16175614f, 0.07721549f, 0.00553022f, -0.01331803f, -0.16648293f, 
    0.04654649f, -0.15654883f, 0.19967268f, 0.11259589f, -0.03309296f, -0.00715407f, -0.15552965f, 0.02710784f, 
    -0.00308699f, 0.02423424f, 0.09205576f, 0.03824757f, 0.00727268f, 0.06719952f, 0.05535458f, 0.05422933f, 
    0.11252821f, -0.05637855f, 0.31778353f, 0.15625772f, -0.09992281f, -0.06456796f, 0.02989393f, 0.09575558f, 
    -0.04574740f, -0.04239326f, -0.03797868f, 0.15397798f, 0.00824373f, -0.00328533f, -0.11257336f, 0.03844463f, 
    0.11076815f, 0.00678495f, 0.05117820f, 0.07613408f, -0.04944574f, -0.05978532f, -0.05252428f, -0.11918329f, 
    0.03314371f, -0.09747140f, -0.16181032f, 0.03868857f, -0.08433012f, -0.10904374f, -0.04910403f, -0.12754418f, 
    0.03632865f, 0.05443752f, 0.16865771f, 0.35426289f, 0.05291949f, -0.04550716f, 0.08853082f, -0.07427751f, 
    0.06089167f, 0.03191416f, 0.02415675f, 0.06560896f, 0.04641844f, -0.00208200f, -0.08296597f, 0.03852779f, 
    -0.02898960f, 0.02178716f, 0.10498196f, -0.03992774f, -0.06278528f, -0.03438283f, 0.09293217f, -0.06068092f, 
    0.01958824f, -0.08459999f, 0.04039070f, -0.11511854f, -0.02440606f, 0.12430847f, 0.21690986f, 0.04015006f, 
    -0.05137495f, -0.08579746f, -0.14135244f, -0.12941624f, 0.04877268f, -0.05603462f, 0.08692069f, 0.03559685f, 
    0.04606202f, 0.12626901f, -0.04393710f, -0.05189381f, 0.02351154f, -0.06020845f, -0.07155544f, 0.15838604f, 
    0.10069440f, 0.13285626f, 0.11458433f, 0.09305508f, 0.00587399f, 0.02394504f, 0.02793477f, 0.26136407f, 
    0.06638918f, -0.00728081f, 0.18169041f, 0.15063317f, 0.04562159f, 0.09880313f, 0.09360415f, 0.05059038f, 
    0.03751667f, 0.09853391f, 0.03153997f, -0.02841601f, -0.12870479f, -0.03072020f, -0.00475685f, 0.02206095f, 
    -0.04820570f, -0.00744950f, 0.10720103f, -0.00690921f, 0.37741464f, -0.12466868f, 0.37443957f, -0.05948098f, 
    -0.03389465f, 0.06087268f, -0.04047883f, -0.14199136f, -0.04605466f, 0.09339621f, 0.07381617f, -0.03941714f, 
    -0.21200128f, 0.06140932f, -0.23631702f, -0.20445368f, -0.12092321f, -0.21824712f, -0.07524746f, 0.12660716f, 
    0.01837710f, -0.00298116f, -0.05378651f, -0.01309646f, 0.03160439f, -0.09694725f, -0.00490813f, 0.08904438f, 
    -0.02631272f, 0.01548558f, -0.06432458f, -0.06994025f, 0.10843170f, -0.06623239f, -0.08073641f, 0.13846686f, 
    0.22771122f, -0.08377909f, 0.14530498f, -0.36984387f, 0.05293433f, -0.03641791f, 0.00577827f, 0.24707380f, 
    -0.01190724f, 0.15545280f, -0.14336006f, 0.02410530f, -0.05316897f, 0.02849454f, 0.20158079f, -0.19009754f, 
    -0.08170465f, 0.06035373f, -0.10408839f, 0.10336139f, 0.10705318f, -0.02543803f, -0.00885857f, -0.07587527f, 
    -0.14243242f, -0.03684947f, -0.29325032f, 0.22394009f, -0.03512174f, -0.01185788f, 0.00499926f, 0.13657908f, 
    0.17820105f, -0.02681562f, -0.11108498f, -0.04424873f, 0.12768407f, -0.00435770f, 0.19743668f, 0.07624182f, 
    -0.12100865f, -0.10201699f, -0.04357892f, 0.01101758f, -0.06841198f, -0.08377437f, -0.04815143f, -0.10377117f, 
    0.11059040f, -0.06686834f, 0.22953507f, -0.22579975f, -0.04679381f, 0.04565033f, 0.11012385f, -0.05822965f, 
    -0.01670115f, -0.01896417f, 0.05391648f, 0.03291873f, -0.02677368f, 0.02013363f, -0.06235377f, 0.21937624f, 
    -0.19113423f, -0.07716525f, -0.02023442f, -0.10203502f, -0.05909147f, 0.20889407f, 0.07379287f, 0.03938970f, 
    0.08349049f, 0.05219617f, 0.01971148f, 0.05264806f, 0.14493468f, 0.06939036f, -0.03213936f, 0.06631836f, 
    -0.11956436f, 0.09971776f, 0.01786718f, -0.16143130f, -0.17639250f, 0.03571684f, -0.00890128f, 0.06322854f, 
    -0.03920151f, -0.11095601f, 0.01309861f, -0.00212217f, -0.00228820f, 0.05321028f, 0.11422905f, 0.14990047f, 
    -0.09832038f, -0.03797144f, -0.20324904f, 0.05415753f, 0.13821211f, 0.06860785f, -0.09770037f, 0.12786116f, 
    -0.03649894f, 0.06372605f, 0.03196279f, 0.01098933f, -0.00821565f, -0.05941943f, 0.06060485f, -0.12632294f, 
    -0.02674715f, -0.14009590f, 0.26780814f, 0.15962751f, 0.02424271f, -0.01914717f, 0.03396516f, -0.10877111f, 
    0.01281106f, -0.08077833f, 0.08903600f, 0.00176994f, 0.14646980f, -0.13648383f, -0.02357138f, 0.05446665f, 
    -0.02454167f, -0.10507961f, -0.21283187f, 0.06407426f, 0.04851332f, 0.28027025f, -0.01770510f, 0.17696632f, 
    -0.02779944f, 0.04743874f, 0.18207672f, 0.15128841f, -0.05467386f, 0.10796697f, 0.01759635f, -0.08545866f, 
    0.21487272f, -0.01198970f, -0.17828980f, 0.06445803f, -0.07486392f, -0.05439310f, 0.03258410f, 0.04315878f, 
    -0.01239457f, 0.02224270f, 0.02720276f, 0.14238457f, 0.39067623f, 0.00793156f, 0.07913452f, -0.02681760f, 
    0.07055760f, -0.03629607f, -0.05919695f, 0.06035447f, -0.00783794f, 0.02355802f, -0.00019056f, -0.04081794f, 
    0.05311969f, -0.17371662f, -0.34405774f, 0.04166715f, 0.03967004f, -0.10385734f, 0.01311653f, 0.13608097f, 
    -0.05938032f, 0.04263964f, -0.01914151f, -0.07531960f, 0.25140843f, 0.07340451f, 0.20934497f, 0.15730722f, 
    -0.02993382f, 0.04462028f, -0.15030697f, 0.07039811f, 0.03944065f, -0.09873189f, -0.08972482f, 0.04553760f, 
    0.21783036f, 0.10200108f, 0.19763663f, -0.05486657f, -0.06848410f, -0.08644418f, -0.00594186f, 0.12154064f, 
    -0.03129511f, 0.07853818f, -0.05424187f, 0.05316481f, 0.03237793f, 0.09247734f, 0.13723876f, 0.06843685f, 
    0.02374906f, 0.05030887f, 0.04637884f, 0.18901387f, 0.14469106f, 0.01882001f, -0.02550107f, -0.12945752f, 
    -0.37563151f, 0.22834152f, -0.27033025f, 0.12480763f, -0.09512798f, -0.01487083f, 0.17365097f, -0.07279099f, 
    -0.04638446f, -0.01151499f, -0.22329047f, -0.06056934f, 0.15738964f, 0.00889319f, 0.29956290f, 0.11018995f, 
    -0.04368556f, 0.06465532f, -0.05338407f, -0.01158296f, 0.03115472f, 0.00456741f, 0.08082282f, 0.06321039f, 
    0.07650373f, 0.06383867f, -0.01716824f, -0.12889391f, -0.03141725f, 0.02938911f, -0.05232354f, -0.05621848f, 
    -0.04839691f, 0.01768834f, -0.04376452f, -0.02247369f, 0.11431039f, 0.13047779f, 0.15103659f, 0.15603325f, 
    -0.04754902f, 0.00139690f, -0.05722826f, -0.00700684f, 0.07037383f, 0.05774887f, 0.06240573f, -0.02076337f, 
    0.06478152f, -0.07297462f, 0.01223841f, -0.12296320f, 0.02289327f, -0.00959969f, 0.00990289f, 0.08660781f, 
    -0.06411919f, -0.04765974f, -0.03962795f, -0.06975419f, -0.07957155f, 0.06371075f, -0.15382591f, -0.06606933f, 
    0.03280587f, 0.03945497f, 0.07217200f, -0.00747316f, -0.00731504f, -0.02266477f, 0.05044615f, -0.05559380f, 
    -0.15638670f, 0.13898861f, -0.00790501f, 0.02355279f, 0.23282094f, 0.10054153f, 0.00562987f, 0.04539330f, 
    -0.00897134f, 0.05169516f, -0.00454871f, 0.05015916f, 0.10234218f, 0.04943731f, -0.18670079f, 0.12680683f, 
    0.02533504f, -0.22298852f, -0.04046492f, 0.24646838f, -0.07469441f, -0.03024687f, -0.01868494f, -0.02716626f, 
    0.11230882f, -0.19795083f, -0.16594194f, -0.02357706f, -0.05357573f, -0.12303264f, -0.02220792f, 0.10508022f, 
    -0.08898807f, -0.24098103f, -0.05931121f, 0.07283266f, 0.07289913f, 0.06346060f, 0.17276534f, 0.18354429f, 
    0.06568026f, 0.09490873f, 0.01099802f, 0.17491463f, -0.02906012f, -0.03123261f, -0.00600209f, -0.08983942f, 
    -0.24238467f, -0.22287458f, -0.12702729f, 0.03759682f, 0.02073757f, 0.04985964f, -0.06790691f, -0.10920590f, 
    -0.21163946f, -0.11691736f, 0.06863615f, 0.00116635f, 0.26217103f, 0.15947182f, 0.15406805f, 0.47580993f, 
    -0.03457309f, 0.14450714f, -0.00070149f, -0.26896787f, -0.12522539f, 0.00692188f, 0.02717780f, 0.09313224f, 
    -0.55706853f, -0.37580884f, 0.03520792f, -0.17521168f, -0.00722949f, 0.13549271f, -0.11027084f, 0.10023008f, 
    -0.10529716f, 0.00837621f, -0.02155220f, 0.11954497f, 0.54191130f, 0.14317226f, -0.10397436f, 0.25561559f, 
    0.17981125f, 0.10256221f, 0.10228030f, 0.00546812f, 0.01275260f, 0.07742876f, 0.01837589f, -0.10146645f, 
    0.11829163f, 0.11363991f, -0.15374157f, -0.01404037f, 0.07318035f, -0.03963993f, 0.13846728f, 0.27168101f, 
    -0.30025226f, -0.18611822f, -0.09145323f, 0.09936251f, 0.11642660f, 0.14899974f, 0.13056791f, 0.09855962f, 
    0.15348341f, 0.08540046f, -0.09351283f, 0.08161934f, 0.02729379f, 0.08443277f, -0.00988983f, 0.10907456f, 
    -0.13711275f, 0.20977086f, 0.08346941f, -0.07208154f, 0.14659509f, -0.03400783f, -0.03129905f, 0.07540106f, 
    -0.07106920f, -0.01948658f, -0.06133240f, 0.00347135f, -0.10124468f, 0.01694269f, -0.18884833f, -0.24013063f, 
    -0.05113345f, -0.12040017f, -0.18355983f, -0.06092317f, -0.25229198f, -0.00022371f, -0.12997295f, 0.30882251f, 
    0.23581386f, 0.27189925f, 0.10572429f, 0.10979252f, 0.05417607f, 0.22533496f, 0.00708403f, -0.09794108f, 
    -0.02531711f, 0.12494691f, 0.01695868f, -0.02952116f, 0.09868544f, -0.31896794f, -0.34627691f, -0.11308207f, 
    -0.14734729f, -0.09437215f, 0.01340660f, 0.05545579f, -0.06405198f, -0.03345223f, -0.00338529f, -0.02356229f, 
    0.17453623f, 0.18503439f, -0.03766920f, -0.11806232f, 0.15211719f, -0.06690560f, -0.09060217f, 0.02182524f, 
    -0.01133814f, 0.03760708f, 0.09647570f, -0.00259951f, -0.16027755f, -0.45064741f, 0.02371148f, -0.11997825f, 
    0.01677193f, 0.00088291f, -0.09534204f, -0.01634626f, -0.04403044f, -0.00859689f, -0.06940842f, -0.15003684f, 
    0.13598482f, 0.07213034f, -0.11992320f, 0.24080868f, 0.15627696f, -0.00151010f, -0.04935615f, 0.00010931f, 
    0.00716778f, 0.05693508f, 0.06571040f, 0.11217393f, 0.26627737f, 0.11995207f, 0.19264974f, 0.19937927f, 
    0.01303844f, 0.11849129f, 0.17110018f, 0.14733800f, 0.06260196f, -0.05328546f, -0.06754567f, 0.05577920f, 
    0.04548076f, 0.25929976f, 0.13905810f, 0.14392145f, 0.10790861f, 0.02757185f, -0.01582282f, 0.17234039f, 
    0.21212599f, -0.14181592f, 0.03458838f, 0.00197257f, 0.08689088f, -0.02963196f, -0.12985791f, 0.01842175f, 
    -0.08438836f, 0.11991686f, -0.03850219f, -0.14298141f, -0.08119319f, -0.04994428f, -0.12804820f, 0.11122482f, 
    -0.15789509f, -0.01875357f, 0.06444141f, 0.10412980f, 0.13030057f, -0.02163225f, 0.01546787f, -0.04049554f, 
    -0.00647239f, -0.00948393f, 0.02617764f, -0.09605804f, -0.39720169f, 0.47732922f, 0.01526348f, 0.03061480f, 
    -0.01073713f, -0.12889114f, 0.12700030f, -0.01144178f, 0.02195051f, 0.15448304f, 0.16317874f, 0.05900856f, 
    -0.46327928f, -0.31874898f, -0.01711372f, 0.00550920f, 0.06519103f, -0.06196786f, -0.08312000f, -0.08988362f, 
    0.12496767f, -0.08539808f, -0.03817695f, 0.04211794f, 0.64233434f, -0.12073102f, 0.46567780f, 0.19419810f, 
    0.10936980f, -0.10155959f, -0.07415288f, 0.14837918f, -0.18508634f, -0.08872322f, 0.15386641f, -0.01004554f, 
    -0.16248173f, -0.15654573f, 0.31776848f, 0.06555545f, 0.11656451f, -0.04350548f, -0.15560472f, -0.00836603f, 
    0.01876028f, 0.00365410f, 0.15749665f, 0.08936648f, -0.18793353f, -0.08225264f, -0.05917173f, 0.05763990f, 
    0.08350485f, 0.05887208f, 0.00430079f, 0.04610461f, 0.03464742f, 0.04393021f, -0.01853783f, 0.06306173f, 
    0.07384082f, 0.08764168f, -0.02228859f, 0.19460954f, -0.01408525f, 0.07529372f, -0.09774631f, -0.02909144f, 
    -0.00145616f, -0.04625594f, -0.05518723f, 0.12485204f, 0.06230313f, -0.04923125f, 0.15282604f, -0.11261986f, 
    -0.14417601f, -0.10988408f, 0.06101152f, 0.08673037f, 0.17176855f, 0.22807288f, 0.26434407f, -0.00035685f, 
    -0.23754665f, 0.12324750f, -0.01362900f, 0.16496587f, -0.02858427f, 0.02194521f, 0.04153502f, 0.05445952f, 
    -0.02942890f, -0.10753307f, -0.02544494f, 0.17488939f, 0.27690250f, 0.12208384f, 0.00755598f, 0.00678641f, 
    0.05368787f, -0.01323819f, 0.05043178f, -0.05579228f, 0.01380661f, 0.05115150f, 0.14918049f, 0.00886412f, 
    0.14083217f, 0.01387416f, 0.02943910f, 0.11519872f, -0.06705914f, -0.01425613f, -0.02344482f, 0.07281759f, 
    0.10634691f, 0.14388257f, 0.08156841f, 0.03849638f, -0.28107202f, -0.02582653f, -0.30210364f, 0.02969874f, 
    0.00298246f, -0.04399325f, 0.02219503f, -0.07989246f, 0.03821173f, -0.06345689f, -0.05427784f, -0.16212237f, 
    -0.20528334f, -0.04383659f, -0.16503440f, 0.01112727f, -0.00148839f, 0.06404555f, 0.17380208f, 0.00297244f, 
    0.21346918f, -0.01378974f, -0.11528150f, 0.09226459f, -0.18649302f, 0.22001830f, -0.01361441f, 0.00840093f, 
    0.00981199f, -0.13565704f, -0.05305327f, 0.07681561f, 0.03440405f, -0.06053173f, -0.00823364f, 0.03873235f, 
    -0.08560292f, 0.04826721f, 0.07051564f, 0.03430665f, -0.06736857f, -0.02535276f, 0.03274470f, -0.04196920f, 
    -0.05181940f, -0.08044476f, 0.04308451f, 0.05171046f, -0.01034540f, 0.04863081f, 0.05182101f, -0.03423040f, 
    -0.01092292f, -0.07329414f, -0.00734428f, -0.06055193f, -0.01005847f, -0.04026110f, -0.07024217f, -0.08291152f, 
    0.03299053f, -0.05295315f, -0.05977424f, 0.00335447f, 0.02703906f, 0.04634702f, 0.04985351f, -0.07699514f, 
    0.00823878f, 0.00168420f, 0.04620387f, -0.06016340f, 0.03532354f, -0.09158918f, -0.08863080f, -0.05373546f, 
    -0.04078451f, -0.00373881f, -0.05694160f, 0.02483515f, -0.02862709f, -0.00552298f, -0.06724670f, -0.07148472f, 
    0.02088451f, 0.02582959f, 0.00728999f, -0.05963226f, 0.02167241f, 0.03247790f, -0.07698511f, 0.04792666f, 
    -0.02899840f, 0.05802031f, 0.02019848f, -0.05746397f, -0.07387973f, -0.08035243f, -0.05542588f, 0.05109902f, 
    -0.08230975f, -0.03341188f, -0.04616193f, -0.04014431f, -0.00816378f, 0.02416954f, 0.04154088f, -0.07740489f, 
    -0.06688681f, -0.04365247f, -0.02684895f, -0.05602884f, -0.05840702f, -0.05719139f, -0.01424704f, 0.04726399f, 
    -0.01712040f, -0.01555774f, 0.02813667f, 0.02160582f, 0.00336549f, -0.01668472f, -0.06928324f, 0.00996494f, 
    -0.07107951f, -0.04120138f, -0.01095715f, -0.02439966f, -0.05477207f, -0.02483220f, 0.01850304f, 0.03061712f, 
    -0.01357896f, -0.04044511f, 0.01452426f, -0.07667092f, -0.04691054f, 0.00396727f, -0.07213467f, 0.00058630f, 
    0.05971007f, 0.03847969f, -0.02429597f, 0.02768021f, -0.03494509f, -0.03092525f, -0.00398144f, -0.06499692f, 
    -0.05001412f, -0.03730048f, -0.03018604f, -0.07458071f, -0.08095359f, 0.00285791f, -0.07075882f, -0.04256620f, 
    -0.07834127f, 0.00738795f, 0.01390325f, 0.06801751f, -0.04427823f, 0.00292141f, 0.04895257f, 0.03632193f, 
    0.02893454f, -0.04700042f, 0.02425939f, -0.06262808f, -0.00742732f, -0.07342479f, -0.00572485f, -0.07868772f, 
    -0.07340238f, 0.02206385f, 0.03286280f, -0.00559548f, 0.04011022f, -0.02232484f, -0.04564196f, -0.03476787f, 
    -0.03596814f, -0.05916736f, 0.01647855f, -0.06584483f, 0.04853271f, -0.03398425f, -0.01006161f, -0.06706401f, 
    -0.03720263f, -0.02543784f, -0.07052050f, -0.07234687f, -0.00035945f, 0.07434504f, 0.03987206f, -0.03290217f, 
    -0.03406271f, 0.04013602f, -0.02519169f, -0.06304707f, -0.04952041f, -0.07182750f, 0.05672197f, 0.04418746f, 
    0.02119270f, -0.02418483f, 0.04959479f, -0.06492418f, 0.02481679f, -0.03174983f, -0.02255396f, 0.04148694f, 
    0.05503158f, -0.00359468f, 0.02012020f, -0.02507942f, 0.03213134f, 0.05206585f, -0.00258501f, 0.05307701f, 
    -0.02579005f, 0.00996951f, 0.03823855f, -0.00336832f, 0.03632371f, -0.04399775f, -0.05921707f, -0.07763108f, 
    0.02750793f, 0.01181426f, 0.31600690f, 0.06245324f, -0.08912646f, 0.00311264f, 0.05634963f, -0.00399015f, 
    -0.05784919f, 0.27735171f, 0.15436652f, 0.07411631f, -0.14021318f, -0.28833920f, -0.23575318f, -0.30987117f, 
    0.10467188f, -0.04934018f, -0.12631674f, 0.12469459f, 0.00664735f, -0.01992549f, 0.04775738f, -0.14812194f, 
    0.32374269f, 0.24532059f, 0.30887455f, -0.06334921f, -0.13860856f, -0.08825543f, 0.03853096f, -0.10086010f, 
    0.01371199f, 0.06432237f, -0.04078368f, 0.06682203f, 0.01632727f, -0.01414678f, -0.13223195f, -0.15446755f, 
    -0.10587416f, -0.06978372f, 0.00491973f, 0.03457253f, 0.11086318f, 0.14301784f, 0.05719433f, 0.16968341f, 
    0.44288707f, 0.19567671f, 0.37032366f, 0.16057006f, -0.11592454f, -0.21226542f, 0.08634904f, 0.09191411f, 
    -0.06467167f, 0.00466790f, 0.04169291f, -0.00152873f, -0.15740658f, 0.01909720f, -0.10547163f, -0.16147308f, 
    -0.10091284f, 0.10243775f, -0.00855540f, 0.22077666f, -0.08836351f, 0.03595109f, -0.05537633f, -0.00557671f, 
    -0.04887686f, 0.14186302f, -0.12692353f, 0.25979128f, 0.01378829f, -0.09223943f, 0.10602843f, 0.03742235f, 
    -0.03868057f, 0.36888388f, 0.00830690f, 0.03652892f, -0.24047276f, -0.28103134f, -0.34040374f, 0.13398321f, 
    -0.12613493f, 0.03779662f, -0.00398433f, -0.09754895f, 0.07536194f, 0.03397748f, 0.04670430f, -0.02999716f, 
    -0.03905712f, -0.07218541f, -0.07016029f, -0.37947467f, 0.07275195f, -0.02611617f, -0.01025926f, -0.03985889f, 
    0.02102608f, -0.02005509f, -0.15726838f, -0.25034440f, -0.07647333f, 0.13487868f, 0.07248253f, 0.10206470f, 
    0.01079298f, 0.02770332f, -0.01479760f, -0.00690279f, 0.14303246f, 0.11330409f, 0.08411609f, 0.20106669f, 
    -0.16359407f, -0.10726163f, -0.46806476f, -0.01827235f, -0.06057709f, 0.02835559f, -0.07154768f, 0.18319345f, 
    -0.05914078f, -0.05314444f, 0.07051331f, -0.09569862f, 0.14793719f, 0.12987868f, 0.06065695f, -0.09451387f, 
    0.03217641f, -0.00851097f, -0.04696324f, -0.04874235f, 0.12819237f, 0.08971869f, -0.00711881f, 0.16324767f, 
    -0.00868453f, -0.08220044f, -0.10185372f, -0.10271659f, 0.08323614f, 0.04741171f, 0.20347853f, -0.03782139f, 
    0.09947802f, -0.05586036f, 0.18172058f, 0.08845859f, 0.19077531f, 0.05198171f, 0.03418893f, 0.00287423f, 
    0.13892141f, 0.10948705f, -0.03692274f, 0.01020169f, 0.03255741f, -0.02704202f, 0.14969139f, -0.03794771f, 
    0.08814745f, -0.33117720f, -0.05314615f, 0.03050782f, 0.01452009f, 0.11113833f, 0.05802880f, -0.08399785f, 
    0.01940593f, 0.10114823f, 0.05052103f, 0.19261695f, -0.27159318f, -0.40094951f, -0.22868486f, -0.13359435f, 
    -0.15302961f, -0.03097431f, -0.03805650f, 0.05470718f, -0.10652556f, 0.07301948f, 0.14491281f, 0.11924215f, 
    0.25018319f, 0.16755809f, 0.02808732f, 0.33282432f, -0.15904845f, 0.14643361f, -0.14725311f, 0.12942769f, 
    -0.01162580f, 0.10021400f, 0.12503372f, -0.02225658f, 0.17560941f, 0.01146621f, 0.05548240f, 0.00740950f, 
    0.07942060f, 0.07737597f, 0.05590906f, 0.09006563f, -0.01008997f, 0.10839825f, 0.01101322f, 0.19096456f, 
    0.25229713f, 0.04600046f, 0.32456389f, 0.26253697f, -0.12456396f, -0.01045904f, -0.06240878f, -0.14253797f, 
    -0.01266798f, -0.04039648f, 0.01502854f, -0.01527837f, -0.20408690f, -0.16717269f, -0.01702086f, 0.10839944f, 
    -0.01517399f, 0.02797577f, 0.01160298f, -0.02934799f, -0.01863417f, -0.03859358f, 0.00737781f, -0.15468638f, 
    -0.17739594f, -0.12279393f, 0.35311323f, 0.15544076f, -0.11273810f, -0.09069730f, -0.15956128f, 0.07059193f, 
    -0.02852119f, 0.03519253f, -0.11847294f, 0.04464009f, 0.30532336f, -0.03099065f, -0.31526947f, -0.25946119f, 
    0.17128354f, 0.01276606f, 0.12834264f, -0.02757212f, 0.01210970f, 0.01414646f, 0.03051499f, 0.08342764f, 
    -0.24638490f, -0.18566403f, -0.05249869f, 0.13535042f, -0.08475242f, 0.07563386f, 0.11936785f, 0.05538880f, 
    -0.08889519f, 0.24400003f, 0.15515980f, -0.01418501f, -0.07689449f, -0.01612621f, -0.13785176f, 0.09275584f, 
    0.15179422f, -0.00738032f, 0.01940987f, 0.10408891f, -0.07936180f, -0.17165747f, -0.03599316f, -0.10042007f, 
    0.17170160f, 0.23548315f, -0.00021731f, 0.02501292f, 0.13587554f, 0.05513482f, 0.13525589f, 0.02104499f, 
    0.04149002f, 0.15489677f, 0.06086094f, 0.04648370f, -0.08232088f, 0.27812546f, -0.16458116f, 0.03116919f, 
    -0.16372189f, 0.01989473f, -0.07153456f, -0.06721157f, -0.09902415f, -0.06939244f, -0.10345356f, -0.07581908f, 
    -0.01763330f, -0.09458097f, -0.15515251f, 0.14765495f, 0.05217445f, 0.00321254f, 0.09732302f, -0.06231732f, 
    -0.01457962f, 0.05138458f, 0.04289554f, -0.04411616f, 0.02872243f, 0.14170322f, 0.00608484f, -0.23964956f, 
    -0.16239205f, 0.00789824f, -0.05203081f, 0.00918587f, 0.09290025f, 0.10393976f, 0.02308023f, 0.19460914f, 
    -0.04856615f, 0.32869840f, 0.11404049f, -0.01522999f, -0.03262328f, 0.10664888f, -0.01264706f, 0.08079688f, 
    -0.00653700f, -0.13320763f, -0.11833569f, -0.24892986f, -0.07685823f, -0.04173294f, 0.13255413f, -0.06253266f, 
    0.00873203f, -0.05751969f, 0.02848524f, 0.14129053f, 0.03806822f, 0.12430877f, 0.26998723f, 0.08739871f, 
    -0.00237667f, -0.11133469f, 0.15053275f, 0.10405988f, 0.13796432f, -0.11303029f, -0.04218972f, 0.02626206f, 
    -0.03156143f, -0.00333998f, -0.09946209f, -0.12621221f, -0.10608193f, -0.21145822f, -0.22641172f, 0.26180115f, 
    0.07980157f, 0.18503647f, 0.06204418f, 0.07096558f, -0.02171085f, 0.03525423f, -0.00955399f, 0.00414823f, 
    0.11587653f, 0.02478021f, 0.16397795f, 0.03534583f, 0.00752547f, -0.07460917f, 0.03001319f, -0.00691527f, 
    -0.03405972f, 0.02578425f, 0.13325393f, 0.07346839f, 0.10668945f, -0.15884309f, -0.06633145f, 0.16169776f, 
    0.08305708f, -0.02449719f, -0.01847370f, 0.04733938f, 0.01736331f, 0.01743155f, 0.00365113f, 0.09866839f, 
    0.10282008f, 0.38751975f, 0.27906790f, -0.14147530f, -0.13462789f, -0.01949551f, -0.02119797f, -0.00499546f, 
    -0.08592236f, -0.01115815f, -0.01667357f, -0.06473324f, -0.03007023f, 0.16130239f, 0.10986166f, -0.00689081f, 
    0.00306962f, 0.11210719f, -0.04017451f, -0.03073608f, -0.09737720f, -0.00297958f, -0.03067310f, 0.05785080f, 
    -0.01079830f, 0.22420558f, 0.32184312f, -0.18259148f, -0.08382736f, -0.16281128f, -0.08544506f, 0.01919855f, 
    -0.03622983f, 0.04032666f, -0.05832876f, 0.06463542f, 0.12861454f, -0.22771706f, -0.03282873f, 0.01594139f, 
    -0.01390233f, -0.01258343f, 0.04822118f, -0.01461318f, -0.03212003f, 0.12757300f, 0.03995903f, -0.00581962f, 
    -0.00550393f, 0.12930973f, -0.17238997f, 0.15966497f, -0.04514846f, -0.02813210f, 0.03149583f, 0.12630393f, 
    0.04661582f, 0.02646864f, -0.14081000f, 0.13581961f, -0.13439326f, -0.09243779f, -0.05532565f, 0.07846515f, 
    -0.10511389f, -0.07880848f, 0.08029420f, 0.03016559f, 0.10960391f, 0.07532447f, 0.00200619f, -0.04219818f, 
    -0.04932439f, 0.02548652f, -0.41962841f, 0.07922054f, 0.04122761f, 0.04770271f, 0.04807851f, 0.11736336f, 
    0.04690766f, -0.04003164f, 0.09731629f, 0.10545886f, -0.14833781f, 0.19396794f, -0.19069615f, -0.11221983f, 
    -0.06684498f, -0.10934371f, -0.11152811f, -0.06753950f, -0.07986978f, 0.07223269f, -0.04649840f, 0.02915911f, 
    -0.19021241f, 0.14074185f, 0.12476581f, 0.29391748f, -0.09235804f, -0.08183797f, 0.08359329f, 0.01162490f, 
    0.07591381f, 0.02534264f, 0.09945242f, 0.04434129f, 0.04362623f, -0.14329478f, -0.18030150f, -0.07565913f, 
    -0.03701094f, -0.08600651f, -0.05264688f, 0.06306282f, 0.10449411f, 0.02240457f, -0.11958730f, -0.00138441f, 
    0.01836053f, 0.15316567f, 0.09830822f, -0.00794939f, 0.07065752f, -0.02629162f, 0.09464514f, 0.04555088f, 
    0.02860812f, 0.18169144f, 0.06631071f, 0.04957541f, 0.06528255f, -0.03351958f, 0.09789871f, -0.02489571f, 
    -0.06853399f, -0.04769341f, -0.09717236f, 0.04370817f, 0.05244375f, 0.07920098f, -0.02357503f, 0.06281967f, 
    -0.02976768f, -0.10350633f, -0.07192310f, 0.00196353f, 0.07152836f, -0.08242351f, -0.04083936f, -0.09867823f, 
    0.03359200f, 0.13690451f, 0.05691405f, -0.00605942f, -0.25323260f, -0.00700889f, 0.27291918f, 0.10079972f, 
    -0.09793837f, -0.00878834f, 0.22476600f, 0.13553527f, 0.00204096f, 0.07548784f, 0.09736305f, 0.07669672f, 
    -0.13179852f, 0.01229391f, 0.08456200f, 0.21591073f, 0.12384723f, 0.06898309f, -0.05989331f, -0.01060553f, 
    0.02146533f, -0.10276343f, -0.04147528f, 0.03840668f, 0.10112118f, 0.08800997f, 0.02011202f, 0.01210199f, 
    -0.01838598f, 0.02903348f, -0.04372957f, -0.12864643f, -0.12126862f, -0.06084079f, -0.04185107f, -0.08877275f, 
    -0.19903490f, -0.32254851f, -0.04224189f, 0.16467610f, 0.06656449f, -0.01402246f, 0.07930730f, 0.15738763f, 
    -0.01907569f, -0.10493624f, -0.11933882f, -0.17070201f, -0.02712851f, -0.08826825f, -0.08911993f, 0.09873874f, 
    -0.16444206f, -0.33664805f, -0.18332805f, -0.11165794f, 0.14601751f, 0.11396769f, 0.00237525f, 0.11323521f, 
    0.01862443f, -0.01686064f, -0.25416639f, 0.27580690f, 0.01243126f, 0.29562384f, 0.19220716f, 0.16393659f, 
    -0.06593385f, 0.01326168f, -0.06436038f, -0.27175474f, 0.19863220f, -0.08731235f, 0.12709080f, -0.11884041f, 
    -0.06500521f, 0.19467233f, -0.39619964f, -0.26802918f, 0.05914683f, 0.11159781f, 0.17882065f, 0.05104528f, 
    -0.03926661f, -0.06706619f, 0.13647021f, -0.24870849f, 0.01418706f, -0.04300116f, -0.18669818f, -0.03760798f, 
    -0.01834961f, -0.06525740f, -0.09329738f, -0.15877889f, 0.34062618f, 0.12652342f, 0.20688061f, 0.11728006f, 
    0.13383591f, -0.03759787f, -0.01423126f, 0.05684479f, 0.05414844f, 0.19216183f, 0.09303124f, 0.14994259f, 
    0.11642326f, 0.14795543f, 0.15822908f, 0.10374456f, 0.13901900f, 0.00370197f, -0.00719588f, -0.03098307f, 
    -0.11387322f, 0.11369964f, 0.08622309f, 0.10380017f, -0.03433364f, -0.10565525f, 0.11924050f, 0.11250569f, 
    -0.08517441f, 0.11496966f, 0.10543122f, -0.14255381f, 0.08745095f, 0.01868621f, -0.10601157f, 0.00761142f, 
    0.32983938f, -0.08471914f, 0.05103398f, -0.08569244f, -0.07176831f, 0.02119046f, 0.02589031f, -0.04540654f, 
    0.03800951f, 0.03537189f, -0.01171103f, 0.01884630f, -0.00644888f, 0.15618925f, 0.19865641f, 0.19837715f, 
    -0.10129040f, -0.00153128f, -0.15065339f, -0.51957273f, -0.22048859f, -0.16334206f, 0.01315563f, -0.10115910f, 
    0.14399137f, -0.01382141f, 0.03294400f, -0.02253274f, 0.01796872f, 0.06194752f, -0.00747428f, 0.07457814f, 
    0.03083766f, 0.03296396f, -0.00092201f, 0.02451589f, -0.33853269f, 0.13017784f, -0.34785616f, -0.35113582f, 
    -0.02838954f, -0.05283549f, -0.05580876f, -0.33480009f, 0.00128068f, -0.19978373f, -0.33141088f, -0.27605084f, 
    0.03822324f, 0.21859212f, 0.12014184f, -0.06108052f, 0.04799213f, 0.06574068f, 0.15391482f, 0.06113920f, 
    0.05195551f, 0.03711220f, 0.01024134f, 0.04895956f, 0.46875072f, 0.02428003f, -0.11162335f, 0.19041254f, 
    -0.02243367f, 0.03139754f, -0.06375255f, 0.17017074f, 0.11240749f, 0.06502046f, -0.03499109f, -0.03345058f, 
    0.00769420f, 0.25420046f, -0.08652232f, 0.17421056f, -0.13612379f, 0.01557503f, -0.02564737f, 0.21007811f, 
    0.05606973f, 0.01408983f, 0.14440723f, 0.03941599f, 0.10942098f, -0.04332570f, 0.09020679f, 0.13914461f, 
    0.06816373f, -0.00955957f, 0.09677686f, -0.01012754f, -0.04065353f, 0.22405885f, 0.07196283f, 0.27207261f, 
    0.11515435f, 0.15183903f, 0.03664511f, 0.25788504f, -0.04187938f, 0.02890587f, -0.03413404f, -0.03146114f, 
    0.00209413f, -0.00237255f, -0.06553501f, 0.11409351f, -0.17824028f, -0.03810978f, -0.02849481f, -0.07447580f, 
    -0.05917813f, -0.05413705f, 0.09834354f, -0.06684999f, 0.10167409f, -0.05414381f, 0.00543220f, -0.16253991f, 
    -0.32513660f, -0.20175017f, 0.10064206f, -0.01464004f, 0.01558034f, -0.09437726f, -0.13791956f, 0.06016444f, 
    0.01874216f, -0.02713252f, -0.09906376f, 0.02207169f, 0.26233381f, 0.10648970f, -0.20875868f, -0.25710070f, 
    0.00692246f, -0.07273473f, -0.04262001f, 0.08670567f, -0.01788505f, 0.00010739f, -0.08440597f, 0.02783757f, 
    -0.18122737f, -0.30567548f, 0.10836064f, -0.04671862f, -0.05881533f, 0.05594565f, -0.05039991f, -0.08522993f, 
    0.06334613f, 0.20261990f, 0.25623402f, -0.07003276f, -0.12632869f, -0.09560879f, -0.00732005f, 0.03845131f, 
    0.12418973f, -0.00258757f, -0.01944410f, 0.11666723f, -0.12017112f, -0.13235766f, -0.00938333f, -0.12660003f, 
    0.23479743f, 0.11150673f, 0.08580079f, 0.04239708f, 0.03624647f, 0.07446664f, 0.01910186f, 0.11395250f, 
    0.04588147f, 0.05181451f, -0.00886708f, 0.03705685f, 0.08436693f, 0.07518673f, 0.08825926f, -0.10062774f, 
    -0.04031105f, 0.04107357f, 0.03125915f, -0.07232867f, -0.08595911f, -0.14556229f, -0.05388775f, -0.17858045f, 
    -0.10350173f, -0.11123581f, -0.16746098f, -0.09065853f, 0.13387837f, 0.00275622f, 0.07096851f, -0.03480668f, 
    -0.00741714f, -0.09213493f, -0.00898061f, 0.08757135f, 0.01809296f, 0.09694117f, 0.02026055f, -0.28244802f, 
    -0.09405287f, -0.02366034f, -0.02846957f, -0.13835283f, 0.12743856f, 0.12655205f, 0.13557720f, 0.17893341f, 
    -0.04533108f, 0.14803520f, 0.13988011f, 0.13805197f, -0.14498477f, -0.01565824f, 0.01134515f, 0.01551769f, 
    -0.10068539f, -0.11917508f, -0.08728661f, -0.32434765f, -0.26323184f, 0.05364722f, -0.07008430f, 0.02513582f, 
    -0.05122389f, -0.03590444f, 0.05790935f, 0.03656726f, 0.06760602f, 0.04609134f, 0.21369213f, 0.09887279f, 
    0.00960116f, 0.07133429f, 0.15561377f, 0.10246134f, 0.03420583f, 0.06738050f, 0.00722712f, 0.02927204f, 
    -0.07252557f, -0.02435546f, -0.01126780f, -0.04533354f, -0.05771239f, -0.10410909f, -0.23397674f, 0.05381691f, 
    0.14859110f, 0.09655672f, 0.03318397f, -0.02198490f, 0.10721766f, 0.09347270f, -0.04286979f, 0.12672539f, 
    0.02167485f, -0.07763872f, 0.12349531f, 0.04953129f, -0.00321037f, -0.07932445f, 0.06278764f, -0.06087355f, 
    -0.05028136f, -0.02926623f, -0.04047506f, -0.06027575f, 0.03423129f, 0.07841463f, -0.00261394f, 0.13727605f, 
    0.01136719f, -0.15919423f, 0.25790322f, 0.04110420f, 0.03994704f, -0.03121871f, -0.09963772f, 0.06540897f, 
    0.07481304f, -0.02145326f, -0.08674315f, 0.19553518f, -0.01391028f, 0.11998706f, 0.10018599f, 0.21364568f, 
    -0.06203141f, -0.03826169f, -0.10651802f, -0.21267414f, -0.37828743f, -0.21011592f, 0.37067181f, -0.15347786f, 
    0.11382266f, -0.14435893f, -0.14648943f, 0.24485448f, 0.03733512f, -0.00533627f, -0.13805561f, -0.01799058f, 
    -0.02718800f, 0.30898136f, -0.07737708f, 0.12734532f, 0.04323116f, 0.19753572f, 0.07850355f, -0.05431186f, 
    0.02458174f, -0.12830114f, 0.11563376f, -0.10631764f, -0.48612440f, -0.08985142f, 0.17981140f, 0.18222660f, 
    -0.03168884f, -0.01889208f, -0.00160652f, 0.10964183f, 0.04336884f, 0.07918140f, -0.04249905f, 0.00381673f, 
    0.05757257f, 0.16276158f, 0.00762115f, -0.03011543f, -0.08341309f, 0.15931363f, -0.05481416f, -0.05984672f, 
    0.25403026f, -0.07762366f, -0.00462541f, 0.08607630f, -0.03466298f, 0.01204685f, -0.01279810f, 0.09690215f, 
    -0.05163576f, -0.16348168f, 0.14134204f, 0.01477329f, 0.00908232f, -0.00665396f, -0.04903959f, -0.00900875f, 
    -0.10541719f, -0.10896994f, -0.14923559f, 0.26342362f, -0.02379804f, 0.03678183f, 0.05406359f, -0.02517417f, 
    -0.04692386f, 0.10813566f, 0.12653662f, 0.05717917f, -0.13051343f, -0.01301547f, -0.09724206f, 0.05811461f, 
    -0.06978326f, -0.04922620f, -0.03054325f, -0.03718368f, 0.01370055f, -0.01626370f, -0.07342618f, -0.04537774f, 
    -0.15320890f, -0.09954528f, 0.08667000f, 0.22933187f, 0.08793465f, -0.09471421f, -0.02553122f, 0.07548266f, 
    -0.05236340f, -0.02328256f, -0.17709154f, 0.07380101f, -0.16096415f, -0.09417824f, 0.02512181f, -0.00774717f, 
    0.03593744f, 0.03402289f, -0.07445794f, 0.03113740f, 0.17349252f, -0.03094777f, -0.06992301f, 0.03135717f, 
    -0.05793448f, -0.00544214f, 0.09786082f, 0.18411401f, -0.01383068f, 0.04430375f, 0.01561902f, -0.00201987f, 
    0.03176576f, -0.02609754f, -0.01356661f, 0.04774570f, -0.05603848f, 0.01224357f, -0.00846339f, -0.14278710f, 
    0.05534466f, 0.10715563f, 0.07950456f, 0.17304753f, 0.15778632f, 0.12701625f, 0.12870030f, -0.01751996f, 
    -0.00639545f, -0.05114771f, 0.09892081f, -0.07705649f, 0.01968508f, -0.08471960f, 0.11639353f, 0.01287892f, 
    0.08978128f, 0.01390256f, -0.13948800f, -0.03811428f, -0.07898553f, 0.07511125f, 0.07545202f, 0.19848633f, 
    0.00970463f, -0.00234238f, 0.00393688f, 0.07491489f, -0.00460600f, 0.00903091f, 0.04538263f, 0.04698965f, 
    0.10767303f, 0.21193442f, 0.16457720f, 0.07782824f, -0.04838378f, 0.05915133f, -0.03910005f, 0.06131058f, 
    0.06300049f, 0.16727176f, 0.15182354f, 0.15697601f, 0.00077746f, 0.04479489f, 0.14236131f, 0.15923235f, 
    0.05422853f, -0.17184047f, 0.12472062f, 0.10569935f, 0.06381869f, 0.15417120f, 0.05457656f, 0.10571050f, 
    0.47359014f, 0.04662631f, 0.04390956f, -0.08012762f, -0.13967752f, -0.06306662f, -0.08837704f, 0.02450579f, 
    -0.09400956f, -0.06236919f, 0.00627453f, 0.00099355f, 0.11262590f, -0.20682362f, 0.19859736f, -0.14169291f, 
    -0.06469257f, -0.07646235f, -0.14472379f, 0.05104530f, -0.10545096f, -0.00302115f, 0.06362024f, -0.18001747f, 
    0.21110743f, 0.14124361f, 0.05688514f, -0.13988476f, -0.18360741f, -0.06082832f, -0.05300067f, 0.10910836f, 
    0.00153565f, -0.09146417f, -0.09259155f, -0.02456633f, -0.30629313f, 0.13422562f, -0.14370559f, 0.02129634f, 
    -0.01000788f, -0.15323745f, -0.07933611f, -0.11612477f, 0.03618146f, -0.00952705f, -0.01894404f, 0.17337744f, 
    -0.06376000f, 0.11904889f, 0.01991026f, -0.08628897f, -0.02456040f, 0.04679636f, -0.05782651f, 0.06016574f, 
    0.04442891f, 0.13435458f, 0.02815269f, 0.10743290f, -0.04740994f, -0.05504604f, -0.00431050f, 0.06642257f, 
    -0.09125488f, -0.08566269f, -0.12064004f, 0.05643407f, -0.00791910f, -0.13131137f, -0.12062474f, -0.17989612f, 
    -0.01631179f, -0.13810253f, -0.22564232f, 0.33589205f, 0.07682522f, 0.06855553f, 0.10089096f, 0.02221912f, 
    0.18837622f, 0.07680064f, 0.10790542f, 0.01210234f, 0.10534016f, 0.17250466f, 0.04884248f, 0.07153453f, 
    0.00173721f, -0.01843120f, -0.06070013f, -0.05317738f, 0.05927797f, -0.12865320f, -0.01403448f, -0.16360390f, 
    -0.00333975f, -0.05404099f, 0.17408787f, -0.07763597f, 0.10827985f, -0.20361920f, 0.08431783f, 0.03408360f, 
    0.07473388f, 0.02774155f, 0.06960509f, 0.03675172f, -0.06787433f, 0.11801422f, 0.06186672f, 0.08402243f, 
    -0.09645059f, -0.03789187f, -0.13024010f, -0.05674055f, 0.13607267f, 0.13204226f, -0.13076849f, 0.03873790f, 
    -0.21521653f, 0.00649260f, 0.17932357f, 0.15473561f, 0.05550092f, 0.06850926f, 0.06459692f, 0.03903356f, 
    0.12353321f, 0.01102725f, -0.06271644f, -0.05907211f, 0.03250446f, -0.00591354f, 0.03537136f, -0.07490069f, 
    0.06102571f, -0.07439479f, 0.00999074f, 0.05735690f, 0.06622421f, 0.15979017f, 0.04847521f, 0.17627844f, 
    -0.04513238f, -0.04413150f, 0.12041433f, -0.01237007f, 0.13602234f, -0.14721742f, 0.06712147f, 0.02764526f, 
    -0.05902272f, -0.01486341f, -0.02855963f, -0.03529517f, -0.21577156f, -0.02916182f, 0.07478980f, 0.06727861f, 
    0.08695260f, -0.07988821f, 0.11170620f, 0.15010892f, 0.02778262f, -0.00215629f, 0.06595975f, 0.06186358f, 
    0.25045276f, -0.05541319f, 0.08817854f, -0.08635633f, -0.04204949f, 0.00591816f, 0.19437923f, -0.08759066f, 
    0.14096825f, -0.04044500f, 0.14821479f, -0.03457508f, -0.00861089f, 0.02176939f, 0.02583551f, -0.04022709f, 
    0.02868094f, 0.03656745f, 0.11250146f, 0.08030792f, -0.00213242f, -0.03515735f, 0.01791469f, 0.13720714f, 
    0.40785196f, 0.02683039f, 0.06103596f, -0.17315660f, -0.01704342f, 0.05768016f, 0.05230937f, -0.02706395f, 
    -0.01032034f, 0.01202070f, -0.03801031f, 0.02158534f, -0.05761124f, 0.31854111f, -0.04172791f, -0.09769471f, 
    -0.04695855f, -0.01376886f, 0.05042184f, -0.06517219f, -0.01778458f, -0.02763321f, -0.00876303f, -0.09936978f, 
    0.28798366f, -0.07973576f, 0.21780704f, -0.03366563f, 0.07200815f, -0.03301407f, 0.08425485f, -0.11277841f, 
    0.01136321f, -0.01579546f, -0.13350947f, 0.09941877f, -0.38921085f, -0.07766528f, -0.00949830f, 0.10076277f, 
    -0.01861869f, -0.12755801f, 0.21556965f, -0.00916532f, -0.12770212f, -0.03084861f, 0.10205611f, -0.05253473f, 
    -0.00241588f, 0.15696652f, -0.22267477f, 0.08937323f, 0.09154760f, -0.12829643f, -0.13775015f, 0.00565768f, 
    0.01856880f, 0.05288143f, 0.02391227f, 0.12020545f, -0.14874701f, 0.01324717f, 0.00432929f, -0.01564592f, 
    -0.15541841f, -0.05196719f, 0.08516695f, -0.07892500f, 0.04032649f, 0.04228686f, 0.13150972f, -0.07281561f, 
    -0.19364363f, -0.04270576f, -0.04595020f, 0.09436228f, -0.11254130f, 0.01746748f, -0.07700931f, 0.23731299f, 
    -0.13192455f, 0.06110241f, 0.15367188f, 0.02176598f, 0.02640477f, 0.12678012f, -0.02049963f, 0.03721357f, 
    0.04476222f, -0.02342627f, 0.01976970f, 0.07388238f, 0.01127813f, -0.01683804f, 0.03507500f, -0.11885149f, 
    -0.23092906f, 0.31788716f, 0.19161512f, 0.21859904f, 0.01583410f, -0.11253671f, -0.01642224f, 0.11480770f, 
    0.10936063f, 0.06339865f, 0.01631782f, -0.09862831f, 0.04481608f, -0.00747477f, 0.02306118f, 0.11181405f, 
    -0.02444011f, 0.04351686f, -0.08448672f, 0.04651896f, 0.02107764f, -0.17199677f, 0.04639243f, 0.12064737f, 
    -0.03088927f, 0.19046761f, 0.16644451f, 0.10154767f, -0.02824045f, 0.13972788f, -0.05088158f, 0.00512219f, 
    0.01378463f, 0.09558555f, 0.07706851f, 0.02815536f, 0.12550731f, -0.09677482f, 0.03350584f, -0.06026683f, 
    -0.07503390f, 0.07525076f, -0.01561257f, -0.01516635f, -0.00876683f, -0.00858655f, -0.03070077f, 0.04733859f, 
    0.00572117f, -0.08288830f, 0.00737107f, 0.00107384f, -0.08088733f, -0.04751783f, 0.00990519f, 0.07246289f, 
    0.06202980f, 0.11375386f, -0.02808206f, -0.02097245f, -0.24381451f, 0.27983117f, 0.15800686f, 0.14202487f, 
    -0.04418416f, -0.05005472f, 0.15893947f, -0.09844564f, 0.05968047f, 0.01382351f, 0.03378730f, -0.07673248f, 
    -0.03868859f, 0.16673973f, 0.07320283f, 0.08293065f, -0.05486534f, 0.15762542f, 0.09112936f, -0.11143685f, 
    0.05975413f, 0.01635469f, 0.09727789f, -0.05630079f, 0.05086476f, -0.18941559f, 0.00779349f, 0.11533083f, 
    -0.02351429f, -0.01974151f, -0.02751102f, 0.11033495f, 0.06037768f, 0.10070407f, 0.01882698f, 0.19894521f, 
    0.05386950f, 0.28003109f, 0.01098908f, -0.09436924f, 0.05139333f, -0.04529584f, 0.09338924f, -0.07605519f, 
    -0.03995161f, 0.05736118f, 0.03245921f, -0.07371109f, -0.23255788f, 0.27206892f, -0.11806221f, -0.08780374f, 
    -0.02379356f, -0.01405937f, 0.08823730f, -0.02511944f, -0.05498695f, 0.03161088f, -0.03884004f, -0.07141297f, 
    0.10137527f, -0.01762956f, 0.26656839f, 0.12140638f, 0.00610340f, -0.01480882f, 0.04954495f, -0.04138949f, 
    -0.05201170f, -0.04992622f, 0.01871917f, -0.10079501f, 0.07352251f, -0.03767540f, -0.07122692f, -0.06678944f, 
    -0.04146307f, -0.20129798f, 0.03223606f, 0.05094790f, -0.24554765f, 0.10766918f, 0.14661571f, 0.00627314f, 
    -0.09562903f, 0.07497997f, -0.10960534f, 0.04503381f, -0.02826444f, 0.13454010f, -0.10384437f, -0.02556617f, 
    -0.04343930f, -0.05476060f, 0.19152746f, 0.01942043f, -0.16150559f, -0.13185152f, -0.11737118f, 0.20149082f, 
    -0.06930874f, 0.14350146f, 0.05400110f, 0.01609254f, -0.00107169f, -0.00948101f, 0.02194191f, -0.00367349f, 
    0.17154397f, -0.19756643f, -0.07922505f, 0.12537782f, -0.08769411f, 0.08272552f, -0.10051448f, 0.03601348f, 
    -0.08045952f, 0.14375482f, 0.17108975f, 0.22873631f, -0.03041903f, 0.07431914f, -0.05143266f, -0.04449219f, 
    0.03732154f, 0.02276237f, 0.04691824f, 0.04160044f, 0.05668898f, 0.13822249f, 0.08027933f, -0.06794351f, 
    -0.28613591f, 0.00538441f, -0.04276258f, 0.26166138f, -0.02232745f, -0.03970420f, 0.03042140f, 0.11571129f, 
    0.09765713f, 0.04329398f, 0.07192621f, 0.04651278f, 0.16087554f, 0.01874338f, 0.01890758f, -0.20976104f, 
    0.03805422f, 0.02137415f, -0.05094046f, 0.00589744f, 0.09341317f, -0.14819419f, -0.09309936f, 0.02515046f, 
    -0.07978531f, 0.12760065f, 0.11482795f, 0.15455621f, -0.00115396f, 0.01833749f, 0.17514513f, 0.06475177f, 
    0.11214367f, 0.08028909f, 0.13654913f, 0.02824669f, 0.09984071f, -0.01422035f, -0.08555503f, -0.11206486f, 
    -0.00175916f, -0.02633647f, 0.01085077f, -0.12532371f, -0.07717857f, -0.02195944f, 0.00132371f, -0.14473043f, 
    0.01256804f, -0.07498622f, 0.10577336f, -0.00353542f, 0.05781994f, 0.06024873f, 0.08530756f, -0.06186455f, 
    0.02788032f, -0.02234716f, -0.07195166f, 0.06436270f, -0.17498644f, 0.04641177f, 0.07693165f, 0.12710725f, 
    0.02472301f, 0.06911792f, 0.01278749f, -0.14391348f, 0.12246263f, 0.23395859f, 0.04472487f, 0.03751505f, 
    0.13563588f, 0.14359882f, 0.12157489f, -0.00264188f, -0.06209306f, 0.07345830f, 0.10443595f, 0.14634842f, 
    -0.01523173f, 0.21171868f, 0.21885093f, 0.08702413f, -0.09049447f, 0.09356155f, 0.13648160f, -0.20922309f, 
    -0.01137093f, -0.01182315f, 0.15738045f, 0.00537289f, -0.04408450f, 0.11878264f, -0.01728097f, -0.01978633f, 
    0.17236482f, -0.19094455f, 0.14494528f, 0.10230201f, 0.03086302f, 0.08026242f, -0.11678061f, -0.07013501f, 
    -0.11322947f, -0.00128060f, -0.11394608f, -0.01973838f, -0.02581684f, -0.05534155f, -0.20427133f, -0.18574812f, 
    -0.01365256f, -0.06422983f, -0.03566195f, 0.09509753f, 0.09213780f, -0.02541929f, 0.02484288f, -0.22161119f, 
    0.12673488f, -0.16275020f, 0.08192835f, 0.10224798f, 0.10393743f, 0.06335408f, 0.02468984f, -0.06125396f, 
    -0.09709895f, -0.14874792f, -0.09534121f, 0.01407504f, -0.43875629f, 0.24963771f, -0.04217136f, -0.17273130f, 
    -0.01120947f, 0.02192058f, 0.00248288f, -0.06129577f, -0.04528320f, 0.07793292f, -0.05854715f, 0.00709577f, 
    -0.20118745f, -0.11018855f, 0.03401945f, 0.09767042f, -0.03830706f, 0.04743139f, -0.05363573f, -0.02963169f, 
    0.06743281f, 0.08682931f, 0.18329182f, 0.00191091f, -0.03434116f, 0.10635260f, -0.14869064f, -0.11512252f, 
    0.05776699f, -0.04538875f, 0.02689946f, -0.02261558f, -0.15792409f, -0.21861781f, -0.05274381f, -0.18834144f, 
    0.09603430f, 0.19044465f, 0.27204606f, -0.09139550f, 0.14758748f, -0.01331337f, 0.21911141f, 0.11365592f, 
    0.11055547f, 0.10181825f, 0.12358613f, -0.15010923f, -0.01184614f, 0.09925575f, -0.10479373f, 0.11209968f, 
    -0.02823818f, 0.07922278f, -0.04117668f, -0.02050344f, -0.04678907f, -0.18904498f, 0.00311500f, -0.23553783f, 
    0.06750789f, 0.07316964f, -0.09983113f, 0.06632164f, 0.17040926f, -0.07746550f, 0.07885714f, 0.10851470f, 
    -0.00603744f, -0.03711706f, -0.11177762f, -0.05480463f, -0.05097403f, 0.04597294f, 0.12463298f, 0.03689797f, 
    -0.10532748f, 0.00585634f, -0.15111260f, 0.00634860f, 0.13294734f, 0.09115135f, 0.09470408f, 0.30147496f, 
    -0.16595252f, 0.10558932f, 0.20473695f, -0.04264385f, 0.01317032f, 0.16203517f, 0.01516867f, 0.15271582f, 
    0.01630586f, -0.16103294f, -0.07895986f, -0.18543476f, 0.14681031f, 0.02625222f, 0.13881950f, -0.04060807f, 
    0.08560032f, 0.03517650f, 0.07215633f, 0.13725629f, -0.00302241f, 0.08253402f, 0.21222085f, 0.06383533f, 
    0.02990565f, -0.06667325f, 0.10192131f, -0.06628299f, 0.00301448f, -0.05598183f, -0.12034325f, 0.06902476f, 
    -0.05611066f, 0.00034296f, 0.03474649f, 0.02356533f, -0.04306171f, 0.03126870f, -0.24417183f, 0.06532547f, 
    0.04929062f, 0.00413144f, -0.09668986f, -0.09527043f, 0.02448881f, 0.08315721f, -0.07811732f, 0.06995565f, 
    -0.00823453f, -0.03916782f, -0.02351770f, 0.03553716f, 0.04798527f, 0.01473098f, -0.07118990f, 0.02297013f, 
    -0.06718182f, 0.03194358f, -0.02205812f, -0.00100429f, -0.05211969f, -0.06516337f, -0.04531680f, -0.06005619f, 
    -0.07359401f, -0.07331757f, -0.06264587f, -0.02607389f, -0.02122602f, -0.07921617f, -0.04808541f, -0.05584757f, 
    0.02759691f, -0.05177043f, -0.07775839f, -0.05447256f, 0.02699072f, -0.02534760f, -0.06014399f, -0.06774475f, 
    -0.04100625f, 0.04102726f, 0.02350396f, -0.03258565f, 0.04545778f, -0.06631797f, -0.07778597f, 0.01782481f, 
    -0.03910792f, 0.05745972f, 0.03817499f, 0.04612685f, 0.04256969f, -0.05464976f, -0.02306311f, -0.05113976f, 
    0.03055644f, -0.06077276f, -0.07257261f, -0.00635970f, -0.04559952f, 0.01324555f, -0.00400567f, -0.03755114f, 
    0.00154144f, -0.04673638f, 0.04585631f, -0.01149340f, 0.03070967f, -0.00956924f, -0.05258612f, 0.04804479f, 
    -0.00372886f, -0.01374441f, -0.02235198f, 0.02961793f, -0.05451411f, 0.04018564f, 0.02660868f, -0.04279197f, 
    0.03630701f, -0.05313496f, 0.06271119f, -0.03983204f, -0.02781044f, 0.03822430f, -0.05129018f, -0.02541184f, 
    -0.04455584f, -0.00021798f, 0.04519308f, 0.00718870f, -0.02574761f, -0.06215765f, -0.02960281f, -0.07656409f, 
    0.03490321f, -0.07003287f, -0.08995645f, 0.00791134f, -0.08500455f, 0.03150096f, -0.06141136f, 0.05142726f, 
    -0.07326066f, 0.01279039f, 0.04121577f, -0.03158880f, -0.06218909f, -0.06187715f, -0.00966535f, -0.05033582f, 
    -0.03532913f, -0.05089391f, -0.08670259f, 0.03191342f, 0.05322086f, 0.05207893f, -0.00926003f, -0.02710628f, 
    -0.07399946f, -0.06155532f, 0.00365386f, 0.01510843f, -0.02415361f, -0.07038883f, 0.02442740f, -0.07622102f, 
    0.04779343f, 0.01697888f, 0.00335459f, -0.08845658f, -0.01194787f, -0.04048925f, -0.06237197f, -0.00831861f, 
    -0.00766923f, 0.03862282f, 0.02785936f, 0.02474137f, 0.02895692f, 0.03992864f, -0.03016425f, 0.04905854f, 
    -0.04322614f, -0.01172275f, -0.07536174f, -0.03497222f, 0.01152579f, 0.02545809f, -0.00783425f, -0.06077764f, 
    -0.02626082f, -0.06267088f, -0.05467682f, -0.04426501f, -0.07198960f, -0.04584621f, -0.02614278f, 0.01712327f, 
    0.02912523f, -0.08667563f, -0.09082867f, -0.08192214f, 0.04425915f, 0.02132947f, -0.07452016f, -0.03378053f, 
    -0.04869359f, 0.01447360f, -0.06119095f, 0.04225152f, 0.05496379f, -0.04726034f, -0.05275694f, -0.01506128f, 
    -0.05623982f, 0.03198947f, -0.08952522f, 0.03802193f, 0.04881848f, 0.04193379f, -0.08511288f, -0.04804911f, 
    -0.04328891f, -0.09077268f, -0.01506862f, 0.03559031f, -0.00648942f, 0.02104359f, -0.02853441f, -0.08613458f, 
    -0.00184518f, 0.03035944f, -0.08229663f, -0.00394922f, 0.02171550f, -0.00024098f, -0.01635169f, 0.04086168f, 
    -0.10682108f, 0.14710408f, -0.20249830f, 0.00535999f, 0.03356076f, -0.09937146f, 0.00836851f, 0.01639510f, 
    -0.00419620f, 0.00535473f, 0.10490124f, -0.06643357f, 0.18899365f, 0.12647852f, 0.14102693f, 0.19049889f, 
    -0.05887747f, -0.09016330f, 0.06733401f, -0.00160907f, 0.10609990f, 0.04572973f, -0.08824763f, -0.04245781f, 
    -0.06652959f, -0.21387011f, -0.13924947f, 0.15377961f, -0.02298066f, 0.03224219f, -0.07223292f, 0.05664583f, 
    0.04343367f, 0.06462624f, -0.02358182f, -0.11342330f, -0.08271004f, -0.29924735f, 0.01563000f, 0.06356642f, 
    0.11038916f, -0.06806923f, 0.03379542f, -0.22768764f, 0.03923895f, 0.03895498f, 0.05794218f, 0.02629836f, 
    -0.19826505f, -0.10518072f, -0.15216060f, 0.01533573f, 0.05441589f, 0.09789522f, -0.03631134f, 0.04022992f, 
    0.01950311f, -0.04000939f, 0.14134483f, -0.12855802f, -0.12993404f, 0.42724201f, -0.14488460f, 0.01307091f, 
    0.23680520f, 0.05047201f, 0.08198591f, -0.04121127f, -0.02947648f, -0.06269564f, 0.11069503f, 0.24530478f, 
    0.07383880f, -0.17103019f, -0.27218997f, -0.50358176f, 0.09476385f, 0.06239709f, 0.03573292f, 0.00748908f, 
    0.16957819f, 0.06379197f, 0.00928558f, 0.02280283f, 0.16242541f, 0.13498765f, 0.25771067f, 0.13007487f, 
    -0.00320713f, -0.00850051f, 0.00935223f, 0.06465849f, 0.01072405f, -0.04576370f, 0.06217169f, 0.13867956f, 
    0.24282867f, -0.08701517f, 0.32781878f, 0.30603838f, 0.00731254f, 0.14180323f, -0.07538041f, 0.02392071f, 
    -0.07976668f, -0.05022996f, -0.00919270f, 0.10221080f, -0.07825134f, -0.34748504f, -0.07680169f, 0.04177781f, 
    0.08571505f, -0.02890785f, 0.03780957f, -0.01813189f, -0.03480564f, 0.04146988f, 0.05314304f, -0.13221855f, 
    0.22659783f, -0.05465019f, 0.24498750f, -0.21578804f, 0.05611178f, 0.08604868f, 0.08088459f, -0.02363748f, 
    -0.07017566f, -0.10389708f, -0.07016770f, -0.02585412f, -0.27936020f, 0.01667307f, -0.03485026f, 0.11077286f, 
    0.19461165f, -0.00383628f, -0.15887016f, -0.06767229f, 0.01059011f, 0.13473460f, 0.09650195f, 0.06865319f, 
    -0.23732811f, 0.17700337f, 0.18262424f, 0.25406742f, -0.07393290f, -0.10778784f, -0.13369647f, -0.02497075f, 
    -0.03806931f, 0.00069814f, -0.05237911f, 0.01613007f, -0.28660154f, -0.14291288f, -0.24248551f, -0.01483933f, 
    0.04202496f, -0.13634312f, -0.05202078f, 0.02484004f, 0.19126825f, 0.06752859f, 0.05683642f, 0.15159364f, 
    0.11903568f, 0.21417709f, 0.15347405f, 0.08129865f, 0.03352037f, 0.08164681f, 0.06710736f, 0.02944586f, 
    -0.07566703f, -0.03645756f, 0.11010793f, 0.06650295f, 0.21922311f, 0.16427554f, -0.02745430f, -0.00910346f, 
    0.03660271f, -0.05359456f, 0.14993382f, -0.02106034f, 0.01713039f, 0.00224736f, 0.16833523f, -0.09139615f, 
    -0.00066292f, -0.07485413f, 0.06356378f, -0.05043088f, -0.06850943f, 0.02160078f, -0.05994784f, 0.05447146f, 
    0.06038806f, -0.07210424f, -0.00626576f, 0.04876497f, -0.02535359f, 0.03758255f, 0.02523990f, -0.06769107f, 
    -0.06876885f, -0.06579033f, -0.06940390f, 0.05584214f, 0.01106237f, -0.05183386f, -0.05664447f, -0.03833393f, 
    -0.04029998f, -0.07006361f, -0.02388801f, 0.05519224f, 0.00412250f, 0.01101217f, 0.00832544f, 0.01556756f, 
    -0.07331590f, 0.01366364f, 0.05732336f, 0.02159811f, -0.06511879f, -0.06394722f, 0.06593169f, -0.06390434f, 
    -0.00000985f, -0.04594348f, -0.03922257f, 0.01790402f, -0.04922068f, 0.05268383f, 0.03253132f, 0.00209455f, 
    -0.00379890f, 0.02893364f, -0.04024734f, -0.05610756f, -0.05126857f, 0.01671424f, -0.07411876f, -0.04534322f, 
    -0.05243404f, 0.04443799f, 0.00383176f, -0.04582646f, 0.01426006f, 0.02022978f, -0.00284298f, 0.03459205f, 
    -0.01665922f, -0.07692771f, -0.06608596f, -0.00209880f, 0.03823163f, -0.06449121f, 0.03402954f, 0.02636465f, 
    0.04038582f, -0.01283324f, -0.06109071f, 0.05253077f, -0.06609248f, 0.02805597f, -0.05732155f, -0.03683985f, 
    -0.05067818f, 0.01699222f, 0.02800924f, 0.04237992f, -0.03725114f, -0.02073547f, -0.07073351f, 0.00994047f, 
    -0.00893966f, 0.03584098f, 0.00560607f, -0.03195508f, 0.02829156f, 0.03640648f, -0.05887172f, -0.04477710f, 
    -0.02572006f, -0.04097133f, 0.02030948f, 0.06520550f, 0.04917971f, 0.05158556f, 0.01361934f, -0.03666934f, 
    -0.04813511f, 0.05509548f, -0.04541694f, 0.05011583f, 0.01794674f, -0.01110660f, -0.03936383f, 0.03888877f, 
    -0.05843634f, -0.01227645f, 0.02177022f, -0.03348206f, 0.04603527f, -0.03633237f, 0.00254026f, -0.03749842f, 
    0.00900347f, -0.00937819f, 0.06058045f, 0.05112750f, 0.06588122f, -0.05102926f, -0.03336015f, 0.05880626f, 
    -0.03199637f, -0.05080920f, 0.03148879f, -0.05567121f, -0.02889263f, -0.06137556f, -0.00812067f, -0.01645838f, 
    -0.03732873f, -0.04082111f, -0.07220217f, -0.05978513f, -0.03557003f, 0.05769992f, -0.05634442f, 0.00305196f, 
    0.00674545f, -0.06335384f, -0.06541770f, 0.06574494f, 0.06156453f, 0.05501064f, 0.06284802f, -0.07559810f, 
    -0.04155296f, 0.01199645f, -0.02353628f, 0.04270026f, -0.01278658f, -0.02457331f, -0.01861145f, -0.03592415f, 
    -0.00296213f, -0.03469447f, -0.04266453f, 0.01758663f, 0.06366694f, 0.01893454f, -0.07029412f, -0.02906403f, 
    0.03365525f, -0.06147758f, 0.05129812f, -0.06940604f, 0.04654298f, 0.02749489f, -0.02098326f, -0.04691309f, 
    -0.05944667f, 0.02084032f, -0.01824174f, -0.01854538f, -0.04372329f, 0.04482503f, -0.03983072f, -0.05323664f, 
    -0.00326461f, 0.05094165f, -0.04449488f, -0.05150308f, -0.00993391f, -0.02522358f, 0.06312799f, -0.01852248f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00907396f, -0.02525673f, -0.08128511f, 0.01458910f, 0.00426357f, -0.01182968f, 0.07766539f, 0.05762708f, 
    -0.09233665f, 0.08577067f, -0.08055878f, 0.03040433f, 0.19297536f, -0.09894255f, -0.02876147f, -0.03871658f, 
    0.01469502f, 0.03328982f, 0.19807696f, 0.12124059f, 0.12146722f, 0.08714411f, 0.13118422f, 0.12954760f, 
    0.06988432f, 0.08367864f, 0.02830889f, 0.13922170f, -0.00363979f, 0.03193208f, -0.07069223f, 0.01783223f, 
    -0.05143877f, 0.12950702f, -0.06482816f, 0.01979621f, 0.15002953f, -0.03131320f, 0.11308922f, -0.07898834f, 
    -0.10984039f, 0.05653143f, 0.06707493f, 0.09867699f, 0.04144426f, -0.06075418f, -0.14415954f, -0.09048851f, 
    -0.08292291f, 0.01793511f, -0.03469409f, 0.09267917f, 0.15037034f, 0.15281995f, -0.04269712f, -0.00452978f, 
    0.05081659f, 0.22539610f, 0.14093210f, 0.11784036f, 0.01992912f, 0.00197347f, -0.01050320f, 0.09894188f, 
    0.02905382f, -0.05116401f, 0.09671223f, 0.14192984f, 0.03047325f, 0.11080717f, 0.03394799f, -0.02599997f, 
    -0.02520724f, -0.10760758f, 0.03026939f, 0.09032045f, 0.08147312f, -0.07148030f, 0.01533505f, 0.05929534f, 
    0.15745671f, 0.11786540f, 0.03668909f, -0.06301685f, 0.09573934f, -0.09291963f, -0.07789125f, 0.02104544f, 
    0.04322824f, -0.00618522f, 0.16975079f, 0.00365115f, -0.02341311f, 0.06028977f, 0.02259229f, -0.09919497f, 
    0.12343034f, 0.08141797f, 0.06533684f, 0.06203283f, 0.00267957f, 0.11909805f, -0.05357679f, 0.04813480f, 
    -0.04633510f, 0.16227728f, 0.07487614f, 0.14064099f, 0.07458726f, 0.04028037f, 0.07322210f, 0.00262683f, 
    -0.02885951f, 0.02789123f, -0.02847486f, 0.11846090f, 0.08909386f, 0.04306647f, -0.05152385f, 0.04205290f, 
    0.12754934f, 0.18133086f, 0.20734966f, 0.01499008f, 0.10621723f, -0.02099474f, 0.06714089f, -0.06325797f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18183811f, 0.17535304f, 0.10484368f, -0.08440983f, -0.05139127f, -0.01125988f, 0.12934200f, -0.26454186f, 
    0.08934367f, -0.25201234f, 0.07263185f, -0.07799795f, -0.28704220f, 0.23198363f, -0.03815594f, -0.21087928f, 
    -0.02017410f, 0.10338561f, -0.14121248f, -0.34267855f, 0.14696106f, -0.28416437f, -0.31118482f, -0.11902446f, 
    0.20328867f, -0.07735466f, 0.29038000f, -0.42123517f, 0.09529344f, -0.00915091f, -0.12944272f, 0.03332134f, 
    0.00889861f, -0.38649112f, -0.03883795f, 0.02578472f, 0.08772203f, -0.40240851f, -0.04330509f, 0.17925924f, 
    0.14723045f, 0.07158007f, -0.10866510f, 0.01972382f, 0.00097720f, -0.05103397f, 0.15075652f, 0.15837258f, 
    -0.00612352f, 0.02524697f, -0.07197769f, -0.19751181f, -0.24059029f, 0.05727082f, -0.04874523f, -0.02406764f, 
    -0.00720573f, -0.17578585f, -0.51175308f, -0.11356679f, 0.06451021f, 0.07924813f, 0.06773060f, -0.21748219f, 
    0.16876690f, 0.12671091f, -0.21338850f, -0.27508003f, 0.06657417f, -0.04677528f, 0.03962325f, 0.11758529f, 
    -0.08610738f, 0.12161139f, 0.13766700f, -0.23561417f, -0.19716349f, 0.03399102f, 0.05496126f, 0.11910737f, 
    -0.26305452f, -0.10400743f, 0.09586280f, 0.05145155f, -0.33799899f, -0.31302622f, -0.02473195f, 0.22084758f, 
    0.16183543f, -0.03286202f, -0.10609831f, -0.12471405f, 0.25944245f, -0.29465240f, -0.14373013f, 0.06539575f, 
    0.09992420f, 0.03584103f, -0.08713806f, -0.04707376f, 0.11671469f, -0.04686809f, -0.01185034f, -0.15632898f, 
    0.17309245f, -0.21410340f, -0.31589550f, -0.10447716f, -0.46137840f, 0.03070249f, -0.22796611f, -0.01083640f, 
    0.18584318f, -0.02263802f, -0.09835280f, -0.14834663f, -0.09478856f, -0.33783823f, 0.25821927f, -0.11661347f, 
    -0.26948780f, -0.48402807f, -0.20499589f, -0.28924063f, 0.00182883f, -0.01125671f, 0.04125715f, -0.02200220f, 
    0.00546560f, -0.00499832f, -0.08117355f, -0.09717098f, 0.12121104f, -0.00457180f, -0.16286710f, 0.42378566f, 
    -0.09277762f, -0.05943443f, 0.04160305f, 0.01170889f, 0.28069603f, -0.43207034f, -0.18119763f, -0.15046427f, 
    0.24587582f, -0.06197465f, 0.08133354f, 0.09193085f, 0.14626428f, -0.00502041f, -0.01433796f, -0.02837533f, 
    -0.19102612f, 0.17566587f, -0.43269148f, -0.16384970f, 0.12478644f, 0.03487767f, -0.14631051f, -0.38580406f, 
    -0.09281261f, 0.05844563f, -0.07436946f, -0.05904780f, 0.01404316f, 0.03573604f, -0.34029770f, -0.15672302f, 
    0.06343730f, 0.07701837f, 0.03102458f, -0.39895296f, -0.16932189f, 0.15110950f, -0.05925292f, 0.02334497f, 
    -0.09207220f, 0.00908757f, -0.06947801f, -0.06570606f, 0.00435425f, 0.12041987f, 0.05430948f, 0.04307418f, 
    -0.11398261f, 0.07727789f, 0.04036499f, 0.08529163f, 0.17649032f, 0.27179956f, -0.29238763f, 0.01898331f, 
    0.13583331f, 0.07524575f, -0.02963623f, 0.04853652f, -0.03456272f, 0.10607845f, -0.03088336f, 0.02460136f, 
    -0.48752594f, 0.36704364f, -0.09276266f, 0.00899915f, -0.32669464f, 0.06938949f, -0.05294001f, 0.07503497f, 
    0.13925558f, -0.03027748f, 0.21916726f, 0.15939537f, -0.09951138f, -0.11275733f, -0.18649802f, -0.37684342f, 
    0.07044609f, -0.00794810f, 0.11883557f, 0.03910366f, -0.53501284f, -0.04088185f, -0.07133681f, -0.06912494f, 
    0.23143514f, -0.34864736f, 0.29250836f, -0.11502005f, -0.00444559f, 0.28515068f, -0.08107585f, 0.03498678f, 
    0.08145968f, 0.05323436f, 0.05613535f, 0.35847390f, 0.16378182f, -0.11376731f, 0.22345960f, 0.10691512f, 
    0.25489303f, -0.38918912f, -0.04673995f, 0.19777639f, -0.00070720f, 0.07108640f, -0.45351970f, -0.04771659f, 
    -0.11665756f, 0.13553697f, -0.00166924f, -0.15011404f, -0.00741920f, -0.06447197f, 0.03875937f, -0.07300222f, 
    0.03397758f, -0.08281296f, -0.00718272f, 0.05610368f, -0.05848069f, -0.04434429f, 0.36955592f, -0.46665028f, 
    -0.12168094f, -0.11928354f, 0.05860734f, -0.06273455f, 0.12685172f, -0.39533967f, -0.07215034f, 0.05740246f, 
    -0.33957458f, -0.03331673f, 0.09846974f, 0.29410848f, -0.74296528f, -0.01664828f, 0.10614010f, 0.36204126f, 
    -0.22560281f, -0.04377883f, 0.05563178f, 0.00397739f, -0.01227625f, -0.03745088f, -0.12160695f, 0.16338471f, 
    -0.09178928f, 0.19675420f, 0.04994254f, -0.29394782f, 0.08332995f, -0.07834717f, 0.10352592f, 0.28246212f, 
    -0.26677194f, 0.15176609f, 0.17836273f, -0.16392772f, 0.07649516f, -0.33909178f, 0.03706240f, -0.16901480f, 
    -0.03857750f, 0.20825882f, -0.05189231f, 0.07298263f, 0.06550311f, 0.14101985f, -0.19407989f, 0.07102874f, 
    0.05092500f, 0.12077053f, 0.20679687f, 0.03760763f, -0.18149565f, 0.04919009f, 0.18389161f, 0.10507909f, 
    0.03131535f, -0.10097431f, -0.00392799f, -0.02304229f, -0.14340469f, -0.61679703f, 0.12907591f, 0.03690337f, 
    0.12153766f, -0.51592463f, 0.01422841f, 0.11923598f, -0.20364700f, -0.01232779f, 0.07503585f, 0.15111546f, 
    0.10537731f, -0.14927191f, -0.15237594f, 0.13429855f, 0.08877109f, -0.08866189f, -0.21516894f, -0.48842418f, 
    -0.21924546f, 0.01923493f, 0.03946617f, -0.09376620f, -0.80029660f, 0.12829795f, -0.21013291f, -0.15401091f, 
    0.00953265f, -0.11693334f, -0.40090606f, 0.20127949f, -0.06904402f, 0.03404881f, -0.03118102f, -0.29419708f, 
    -0.16572255f, 0.05619267f, 0.23134139f, 0.26485255f, -0.23277032f, 0.15557620f, 0.19857085f, -0.07011251f, 
    0.01971115f, 0.25140134f, -0.06952576f, -0.38762572f, -0.15192473f, 0.14787754f, -0.50601828f, -0.30929381f, 
    -0.00143632f, -0.05593235f, 0.12095425f, -0.03613074f, -0.14387362f, 0.03402847f, -0.16732989f, 0.02026795f, 
    0.22814575f, 0.13920061f, -0.02219220f, -0.36054188f, 0.04914020f, -0.03081161f, 0.10372648f, 0.07351587f, 
    0.02818924f, -0.32941812f, 0.02779082f, 0.03036287f, -0.02501878f, -0.04072263f, 0.24850632f, 0.13806887f, 
    -0.19159536f, 0.08004873f, -0.39035317f, 0.17682864f, -0.25459087f, -0.50597090f, 0.04594439f, 0.08678672f, 
    0.03162028f, 0.02345562f, -0.03322333f, -0.05263755f, 0.01699123f, 0.00691596f, 0.13873900f, 0.11290703f, 
    0.04786461f, -0.10744528f, 0.05221394f, -0.48428819f, -0.17545167f, 0.31053412f, -0.08438195f, 0.13711645f, 
    -0.08138127f, 0.05073598f, 0.01265086f, 0.02496347f, 0.14675690f, -0.11676131f, 0.03274433f, 0.05620062f, 
    -0.10278218f, 0.09086923f, -0.03015701f, 0.42717078f, -0.35358161f, -0.23523101f, -0.17999837f, -0.05740313f, 
    -0.13681786f, -0.28024149f, -0.17977123f, -0.14726272f, -0.10758016f, -0.11217843f, 0.11946371f, 0.02035979f, 
    -0.07102242f, 0.11253216f, -0.02259918f, -0.12185877f, 0.03203863f, -0.31232914f, 0.05430639f, -0.12960087f, 
    0.03541281f, -0.01142301f, 0.10643782f, -0.39824829f, 0.21870050f, 0.07031704f, 0.04544739f, -0.11016423f, 
    -0.23081218f, -0.00436480f, -0.12440285f, 0.11715050f, 0.03895753f, 0.31907448f, -0.03471362f, -0.12534435f, 
    -0.11505382f, 0.00320398f, -0.09770134f, 0.14096190f, 0.06029104f, 0.02932851f, -0.12042110f, 0.18781604f, 
    -0.09426624f, -0.20708889f, 0.02397802f, -0.47299728f, 0.01190289f, -0.01873306f, 0.05011733f, 0.22198828f, 
    0.03122365f, -0.45673883f, 0.17344327f, -0.25017482f, 0.18728687f, -0.01832059f, -0.21269344f, -0.04888820f, 
    0.13089733f, 0.11408766f, 0.05509615f, -0.29027122f, 0.22634640f, 0.01136871f, -0.01521279f, 0.19546621f, 
    -0.06033823f, -0.13570260f, 0.03526010f, 0.18641490f, -0.08002572f, -0.05320964f, 0.09396254f, -0.00316363f, 
    0.13556345f, -0.09396879f, 0.06287759f, 0.14719242f, 0.09309860f, 0.01294426f, -0.03324438f, -0.28442627f, 
    0.17295580f, 0.09758538f, -0.01270011f, 0.00521959f, -0.19982472f, 0.09295735f, -0.12656131f, 0.06830824f, 
    0.04212318f, -0.15002824f, -0.05029058f, 0.13152820f, -0.16970468f, 0.19613950f, -0.28067875f, -0.16508695f, 
    0.11178238f, -0.12809126f, -0.09998181f, 0.07162856f, 0.05295945f, -0.05695105f, 0.05514759f, 0.10093403f, 
    -0.02953198f, 0.07081661f, 0.02413867f, 0.07421505f, -0.00295840f, 0.12113141f, -0.03396282f, 0.02317646f, 
    0.03973676f, 0.00485938f, 0.22311465f, 0.13574833f, 0.02759155f, 0.14081739f, 0.08575863f, -0.10143191f, 
    0.00626579f, 0.13662925f, -0.02231764f, -0.48809648f, -0.02045216f, 0.05332501f, 0.17652658f, 0.07632387f, 
    -0.22791272f, 0.04023984f, -0.13430421f, -0.01233514f, 0.10195124f, -0.23053542f, 0.12244345f, 0.16177614f, 
    -0.14802659f, 0.05648866f, -0.27203730f, -0.06079449f, 0.09286097f, 0.14778829f, 0.08087084f, -0.25775209f, 
    0.16374940f, -0.09653904f, 0.00482263f, 0.17292698f, -0.17434074f, 0.01807290f, 0.05155804f, -0.07159700f, 
    -0.10113902f, -0.19995995f, -0.24202621f, 0.20398901f, 0.01134213f, -0.31481975f, -0.16339649f, -0.10098304f, 
    0.12036714f, 0.06275396f, 0.01133608f, -0.22219636f, 0.17331044f, -0.06614040f, 0.06790283f, -0.08752387f, 
    -0.25244722f, 0.21733004f, -0.29220065f, -0.03683458f, 0.09954193f, -0.33177477f, 0.06485385f, 0.00967954f, 
    0.19952381f, 0.17518058f, -0.32073694f, -0.02099277f, -0.40943903f, 0.15352058f, -0.27833468f, -0.01782182f, 
    0.03667090f, -0.05466443f, -0.08555391f, 0.05672158f, -0.23008125f, -0.03934848f, 0.09310314f, -0.30254608f, 
    0.24754190f, -0.17435332f, -0.01171944f, 0.11501852f, -0.21600342f, -0.04159580f, 0.03952481f, 0.01146359f, 
    -0.32248133f, 0.10347661f, 0.04142814f, -0.05606938f, 0.18133825f, -0.08129069f, -0.01526345f, 0.06578123f, 
    0.03104845f, 0.19876216f, 0.01454530f, -0.07707223f, -0.07990014f, -0.29794550f, -0.04342147f, -0.02066374f, 
    0.02580178f, 0.08988753f, -0.19984224f, -0.28645289f, 0.24293834f, 0.05470236f, -0.08886946f, 0.16799317f, 
    0.11624646f, -0.01551137f, 0.11521729f, -0.10910514f, -0.00604301f, -0.08740272f, 0.03888280f, -0.35477966f, 
    -0.02770224f, -0.15075809f, -0.02468563f, -0.02647533f, 0.09668439f, -0.82434666f, 0.38194570f, -0.20786031f, 
    -0.03884383f, -0.23955710f, -0.29213434f, 0.20701623f, -0.11496674f, 0.08564799f, 0.00228716f, -0.21050936f, 
    -0.09069069f, -0.20786467f, -0.05012278f, -0.20328832f, -0.04669094f, 0.04406416f, 0.18782805f, 0.04615179f, 
    0.17474476f, 0.07813398f, 0.31996104f, -0.10576455f, -0.19266616f, 0.17911573f, 0.10479589f, -0.25228852f, 
    -0.03037347f, 0.12395231f, 0.02631790f, 0.06478542f, 0.07164408f, 0.21423821f, 0.04651530f, -0.07535407f, 
    -0.02041174f, -0.07665294f, 0.17518425f, 0.07269065f, 0.07359271f, -0.08036166f, 0.02219639f, 0.14540458f, 
    -0.07297210f, 0.07843783f, -0.40372324f, -0.23626509f, 0.04252453f, -0.16323233f, 0.04918905f, 0.07612015f, 
    -0.21152231f, -0.01562116f, -0.21352403f, -0.00918170f, 0.23855942f, 0.05302757f, 0.23891535f, -0.04851662f, 
    0.15122443f, 0.10811197f, 0.00619591f, 0.33521581f, -0.06509697f, -0.06210421f, -0.01214189f, 0.09463599f, 
    -0.06359740f, 0.00576957f, -0.15500031f, -0.14184257f, -0.10073592f, 0.00677237f, -0.00128823f, -0.05819556f, 
    -0.15278046f, -0.15605730f, -0.03221146f, -0.24250111f, 0.04006658f, -0.18814592f, -0.15977314f, 0.24300328f, 
    0.11899676f, 0.12619458f, 0.06648689f, 0.04661137f, 0.22248052f, -0.01815159f, 0.15284921f, -0.00337270f, 
    -0.10895209f, -0.06323101f, -0.26949269f, -0.08994612f, -0.44679523f, -0.04583627f, -0.40012935f, -0.24280572f, 
    -0.57804269f, -0.03509970f, -0.01558972f, -0.00688904f, 0.24266247f, -0.23273966f, -0.02496959f, 0.15569212f, 
    -0.14722243f, 0.13869180f, 0.19049324f, 0.04375790f, -0.19574302f, -0.17373423f, 0.02516142f, 0.07937785f, 
    -0.49367732f, -0.34325993f, 0.12691346f, 0.10284647f, -0.48613787f, -0.06422106f, -0.31577656f, 0.15211681f, 
    0.01469989f, 0.19558312f, 0.06388760f, 0.27010840f, 0.14808683f, 0.02078153f, -0.26925668f, -0.05134815f, 
    -0.43009040f, 0.15735744f, 0.03255957f, 0.40815833f, 0.23237261f, -0.31334680f, -0.07240821f, -0.21860172f, 
    -0.06549655f, -0.37258765f, 0.02775650f, 0.12000468f, 0.11414213f, 0.23569672f, -0.28683358f, -0.03885365f, 
    0.16214673f, 0.15173459f, -0.45878085f, 0.04381155f, 0.10525436f, -0.56175184f, -0.22736868f, 0.06994344f, 
    -0.06762124f, -0.70319074f, 0.14174607f, 0.07421356f, -0.40499482f, -0.44199577f, 0.12284017f, 0.09128966f, 
    0.21687835f, -0.25817919f, -0.46122399f, 0.19880062f, 0.03317542f, -0.02462996f, -0.02258928f, -0.15947802f, 
    0.00355038f, 0.13107090f, -0.02118804f, -0.02108341f, 0.19086918f, -0.05654812f, 0.08067548f, -0.13825828f, 
    -0.15676191f, -0.09750941f, 0.13432395f, 0.02602808f, -0.11758026f, -0.06803533f, 0.25893185f, 0.01516281f, 
    -0.09628403f, 0.19653915f, 0.11970234f, 0.02218995f, 0.18515213f, 0.08842004f, 0.00386857f, 0.09521201f, 
    -0.35306370f, -0.04575844f, -0.01059149f, 0.00691716f, -0.15916188f, -0.01523850f, -0.22203401f, -0.03558911f, 
    -0.73733199f, 0.07604980f, -0.08483573f, 0.19214588f, -0.43267801f, 0.01189286f, -0.48947233f, -0.20508212f, 
    -0.21749614f, -0.08899670f, 0.16032404f, 0.15253140f, 0.04090650f, -0.01248217f, -0.60407984f, -0.00302928f, 
    0.19673061f, -0.32689258f, 0.10476770f, 0.22634408f, -0.15122546f, -0.10549688f, -0.42404133f, -0.07729965f, 
    0.02223006f, 0.06122280f, -0.05119814f, 0.00184339f, -0.12157714f, 0.20110591f, -0.02680814f, -0.03689161f, 
    -0.04029577f, -0.10948168f, -0.03787487f, -0.29845622f, -0.07725348f, -0.15035355f, 0.08393902f, -0.44504777f, 
    -0.05168314f, 0.16082959f, 0.05912909f, -0.01134887f, -0.30476353f, 0.00834897f, 0.14566627f, 0.22194885f, 
    -0.05962646f, -0.19636343f, 0.07240009f, 0.00422171f, -0.32436678f, 0.25564691f, 0.23893139f, 0.38462302f, 
    -0.05881521f, -0.32459980f, 0.12420515f, -0.13684843f, -0.28130934f, 0.20475219f, 0.14550808f, -0.10974017f, 
    -0.04620906f, -0.27403834f, -0.01975788f, 0.12613016f, 0.03643611f, -0.26063392f, 0.07067510f, 0.03527265f, 
    -0.10844383f, -0.24188627f, 0.06998745f, -0.24260080f, -0.13408111f, 0.17737539f, 0.31244010f, -0.10508845f, 
    -0.14294834f, -0.44943258f, -0.08913723f, 0.00310510f, -0.02634592f, -0.03793863f, 0.36746019f, 0.14304100f, 
    0.05597635f, -0.27834889f, -0.13211221f, 0.04276276f, 0.10195396f, 0.07131409f, -0.06581920f, 0.00154576f, 
    -0.07271510f, -0.34367922f, -0.01048647f, -0.49818006f, 0.02423574f, 0.04226686f, -0.12369569f, 0.27504632f, 
    -0.36452898f, 0.07702918f, -0.15667580f, 0.02201666f, 0.26161525f, 0.14820039f, -0.10795406f, 0.07552029f, 
    -0.37511352f, -0.19734201f, -0.02759624f, 0.18682025f, -0.32924092f, -0.24331474f, 0.00555273f, 0.14104322f, 
    -0.04484203f, -0.19413389f, -0.02282213f, 0.18264161f, 0.25796783f, -0.09857611f, 0.14455615f, 0.13315070f, 
    -0.35323751f, 0.18867880f, 0.01658611f, 0.01881183f, -0.02249422f, 0.03768741f, -0.08094612f, 0.23529620f, 
    -0.33126965f, 0.02974862f, -0.16537845f, 0.08141412f, -0.31613401f, 0.04717221f, -0.34957555f, -0.08955634f, 
    -0.08617964f, -0.02617873f, 0.02854208f, -0.26871797f, -0.24336512f, -0.03857110f, -0.19909503f, -0.13397066f, 
    0.07542186f, -0.07965121f, 0.03056543f, -0.01887342f, 0.02177893f, -0.37690842f, 0.18358439f, -0.50240457f, 
    -0.11577681f, 0.13881473f, -0.20549016f, 0.04818325f, -0.07852077f, -0.05270233f, 0.20165135f, 0.11993905f, 
    0.10881270f, 0.01982441f, 0.11072230f, -0.03353276f, -0.26112291f, -0.01781002f, 0.32470810f, 0.10011675f, 
    -0.02958416f, -0.05268486f, 0.07768216f, -0.05469224f, -0.17830326f, -0.35165942f, -0.18720126f, -0.27862284f, 
    0.22357078f, -0.18793829f, 0.01717081f, -0.06902427f, -0.06434085f, -0.15233383f, -0.14863040f, 0.24659988f, 
    -0.07792617f, 0.14079709f, 0.05042414f, 0.21708880f, 0.11416729f, -0.28618422f, -0.09254879f, -0.07791302f, 
    0.10724599f, 0.04030200f, 0.14336461f, -0.10897401f, -0.27826896f, 0.17293712f, -0.32569531f, -0.40893358f, 
    0.09584411f, -0.36125305f, 0.12489679f, -0.08802947f, -0.01547059f, -0.14004177f, 0.00786703f, 0.15689069f, 
    -0.27358735f, -0.33968130f, -0.58732009f, -0.21403150f, 0.23816366f, -0.05658916f, -0.02294827f, 0.21947278f, 
    0.04258495f, -0.23213002f, -0.37086815f, -0.19111767f, 0.17294897f, -0.09139081f, 0.08053234f, 0.33281758f, 
    -0.52612495f, 0.02756106f, 0.21920289f, 0.00690805f, -0.19268987f, 0.06094799f, -0.28275397f, 0.26388478f, 
    0.15588638f, -0.52123493f, 0.13453856f, 0.13207901f, 0.06672559f, 0.19256994f, 0.00524713f, -0.22015952f, 
    -0.32781562f, 0.23912336f, 0.26579103f, 0.07139757f, 0.10782892f, -0.03478674f, 0.05269281f, -0.34667033f, 
    -0.25517723f, -0.13729568f, -0.06332903f, 0.08072226f, 0.27721557f, 0.10051059f, -0.28490371f, 0.31602615f, 
    0.03331822f, -0.01577069f, -0.26744092f, 0.10027689f, 0.04385846f, 0.08048982f, -0.18329389f, -0.09118961f, 
    -0.16695689f, -0.30224431f, -0.19769764f, 0.16128783f, -0.08987420f, 0.01356522f, 0.09154139f, -0.13783456f, 
    -0.11536232f, 0.19500707f, -0.01277560f, -0.05012827f, -0.15419273f, 0.33445519f, -0.01865322f, 0.20406717f, 
    0.30957654f, 0.07637434f, 0.16180736f, -0.18865140f, -0.05620920f, 0.44872436f, 0.17083825f, -0.37583438f, 
    0.29133937f, -0.24959445f, -0.08856919f, 0.00720821f, -0.18313241f, 0.01431607f, -0.45185590f, 0.13790929f, 
    -0.09252291f, 0.01909845f, 0.04246008f, -0.27380112f, 0.06285462f, -0.11078615f, 0.24442744f, 0.04942058f, 
    -0.24415903f, 0.10395388f, -0.13312763f, -0.03862663f, -0.18191358f, 0.11783963f, 0.02425781f, -0.37423709f, 
    -0.08095225f, -0.19648489f, -0.05933658f, 0.07797234f, 0.16107385f, -0.02321133f, -0.36099592f, 0.03993803f, 
    -0.20130603f, 0.13953952f, 0.13790284f, 0.15771176f, 0.30437556f, 0.17135330f, -0.07701297f, -0.01231565f, 
    -0.40131313f, -0.04991844f, 0.06096344f, 0.04608039f, -0.43156400f, 0.30987355f, -0.50292587f, 0.11888959f, 
    0.18084601f, 0.06738030f, 0.18123293f, 0.09168811f, -0.01370149f, 0.06376589f, 0.00279229f, -0.21312575f, 
    0.03427293f, 0.09717994f, 0.30207098f, 0.07563841f, 0.16852516f, -0.20750514f, 0.12555231f, -0.02674501f, 
    0.04431117f, 0.00383521f, -0.13323760f, 0.07967722f, -0.24598034f, -0.28953797f, 0.13388397f, -0.62014675f, 
    -0.30517882f, 0.12718865f, 0.16396476f, -0.09584048f, -0.05349969f, -0.13634501f, 0.05804014f, -0.07960036f, 
    0.10212676f, 0.12411029f, -0.33317015f, -0.23891200f, 0.00434478f, -0.01366900f, 0.24137817f, 0.28291091f, 
    -0.30531052f, 0.07199267f, 0.01410418f, -0.17394891f, -0.40047798f, -0.16960630f, 0.44647065f, -0.27944395f, 
    0.12372600f, 0.10433982f, -0.17262986f, -0.14503233f, -0.18425539f, 0.00736151f, 0.20568658f, 0.07511180f, 
    0.06524543f, 0.16795769f, 0.30426866f, 0.23975474f, 0.20353921f, -0.05885053f, -0.02384049f, -0.32913288f, 
    -0.48862970f, -0.20550497f, 0.00168849f, -0.09315980f, -0.00950299f, 0.12758480f, -0.06480885f, -0.15190464f, 
    0.00646586f, -0.19443654f, 0.16969627f, -0.30379114f, 0.14585210f, 0.06414325f, -0.05097122f, 0.18486387f, 
    -0.23447706f, 0.28272343f, -0.47684151f, 0.23223409f, 0.08662042f, 0.04172716f, 0.04488924f, -0.39123243f, 
    0.02745050f, 0.19979820f, -0.05987275f, 0.24977247f, -0.21374723f, 0.02201572f, -0.20258407f, -0.25424001f, 
    0.06177713f, -0.11319379f, -0.24451303f, -0.16029260f, 0.23848180f, -0.15725143f, -0.18454596f, 0.27535194f, 
    -0.05992994f, 0.07354230f, -0.07184917f, 0.03474277f, -0.08556489f, -0.09036737f, -0.19068840f, 0.00928844f, 
    0.07097653f, -0.08850267f, -0.15024231f, 0.09977069f, -0.21501020f, -0.00285660f, -0.27428123f, -0.01174351f, 
    -0.18680000f, -0.27537999f, -0.12343025f, -0.16224357f, 0.20177601f, -0.27082774f, 0.07491037f, -0.24945542f, 
    -0.13070746f, -0.70709974f, -0.22064438f, -0.09899157f, -0.05855034f, 0.04869855f, -0.02576626f, -0.39823321f, 
    0.05247669f, 0.31599385f, -0.33367357f, -0.36754137f, -0.09821696f, -0.17650563f, -0.12032381f, -0.08811509f, 
    0.18896587f, 0.05757894f, 0.25185147f, 0.05737270f, -0.17873281f, -0.13898429f, 0.18478489f, -0.06482498f, 
    0.18195617f, 0.15657811f, -0.21262695f, -0.13190174f, 0.24051033f, 0.20399335f, 0.05451109f, 0.13383067f, 
    -0.02142464f, -0.08255693f, 0.15988906f, 0.14747234f, -0.12744087f, -0.51858044f, -0.18006352f, 0.29644892f, 
    -0.04984942f, 0.22773102f, 0.07491578f, -0.05734475f, 0.24303256f, 0.03162469f, 0.07402094f, 0.13464954f, 
    0.14730513f, -0.00711655f, 0.12220183f, 0.07554980f, 0.21332918f, 0.02814828f, -0.39363080f, -0.00553516f, 
    -0.17719093f, 0.09735455f, -0.39292613f, -0.24094324f, -0.47848544f, -0.08321819f, -0.07825809f, 0.01177429f, 
    0.37166753f, 0.04738436f, -0.01884965f, 0.03141886f, 0.09348594f, 0.30641913f, 0.14590503f, -0.01385189f, 
    0.03213265f, -0.30971903f, 0.11010265f, 0.25227621f, -0.15785627f, -0.30466554f, 0.12967309f, -0.10375024f, 
    -0.00286898f, -0.02288242f, 0.23133211f, 0.00749364f, 0.05441892f, 0.05438847f, -0.14424323f, 0.07571579f, 
    0.05652440f, 0.03849925f, -0.06795258f, 0.24499901f, -0.24216720f, 0.00032220f, -0.39303231f, -0.53625518f, 
    -0.27217340f, 0.08515030f, -0.07362189f, -0.17812978f, -0.07963274f, -0.13928185f, -0.10721531f, -0.31186673f, 
    -0.03566895f, 0.07576078f, -0.03993967f, -0.01595015f, -0.08922832f, 0.12900887f, 0.37265787f, 0.01405752f, 
    0.19699633f, -0.07947240f, 0.11876699f, 0.28265202f, 0.03723414f, -0.47960988f, -0.06721887f, 0.28888255f, 
    -0.00582872f, 0.13181628f, 0.01730014f, -0.08082093f, 0.04592471f, 0.10989429f, -0.34341422f, -0.05775692f, 
    -0.04890573f, -0.05190734f, -0.26333803f, -0.07039484f, 0.17922831f, -0.04512513f, 0.01512398f, -0.25399587f, 
    0.14780040f, 0.21816665f, 0.10209505f, -0.39927843f, -0.05815732f, 0.33566594f, 0.23464355f, 0.08754393f, 
    0.32225725f, 0.06738176f, -0.10927723f, -0.07150991f, 0.26631382f, 0.15330936f, -0.10062743f, -0.14201863f, 
    -0.06900458f, 0.20814969f, -0.12394713f, -0.11253327f, -0.41814274f, -0.20121035f, 0.02982614f, -0.08557356f, 
    -0.17608996f, -0.01844211f, 0.09107237f, -0.37512279f, -0.07532012f, 0.24535021f, -0.23033364f, -0.31872040f, 
    -0.39273262f, -0.37659720f, 0.02171109f, 0.15559639f, 0.17217109f, 0.14794618f, -0.05279296f, -0.28182852f, 
    0.12729307f, 0.19230530f, 0.08925714f, 0.05607001f, 0.22573629f, -0.06555343f, -0.15242724f, 0.06012273f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16422470f, 0.07455353f, 0.15046330f, -0.04185834f, -0.11370305f, -0.00088108f, 0.08079901f, -0.03270304f, 
    0.11695526f, -0.01689566f, 0.08989896f, 0.01019592f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
