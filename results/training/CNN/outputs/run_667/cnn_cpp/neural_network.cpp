#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72555918f, 1.04839444f, -0.41837037f, -0.85890526f, -0.83887655f, 0.82309932f, 0.80933666f, -0.41458815f, 
    0.56406766f, 0.98879147f, -0.18340553f, -0.09696554f, 0.37848955f, 0.18677324f, -0.56707054f, -0.08569357f, 
    -0.44560549f, 0.26646206f, 0.12577848f, -0.13463180f, -0.56064188f, -0.40259844f, -0.02797863f, -0.23522303f, 
    -0.03840377f, -0.66618723f, -1.78196788f, -0.39217615f, -0.05794989f, -0.26934907f, -1.30312216f, 0.83385724f, 
    0.91801572f, -0.46940163f, -0.10622525f, -0.26592737f, -0.11942212f, 0.02716903f, 0.04183356f, 0.32811290f, 
    -0.45315647f, -0.11475037f, -0.54832894f, -0.16727872f, -0.07008049f, 0.01639655f, 0.02584068f, -0.09387244f, 
    0.16569470f, 0.09160680f, 0.00497077f, -1.26273799f, 1.44454730f, 0.79290920f, -1.32101345f, 0.35870904f, 
    -0.35406655f, 1.06648064f, -0.35721195f, -0.35671625f, 0.12588346f, -0.40991917f, 0.34317714f, 0.57631290f, 
    0.35473210f, 0.21358696f, 0.17181107f, 0.16389038f, -0.07795797f, 0.08045990f, 0.31522185f, 0.55384701f, 
    0.30791056f, 0.17129661f, -0.07968838f, -1.27828741f, -1.06454813f, 0.41278872f, 0.72082090f, -0.01742873f, 
    0.94262052f, 0.27436551f, -0.30128384f, -0.04313439f, -0.49117130f, 0.04146152f, 0.31136119f, -0.48296776f, 
    0.50193644f, 0.19434486f, -0.29345843f, 0.09377871f, -0.19372806f, -0.24272755f, -0.54151535f, -0.25864935f, 
    -0.24539018f, 0.28955698f, 0.17847364f, -0.21763720f, 0.99232674f, 0.97823805f, 0.74363703f, 0.78250223f, 
    0.57044494f, -0.07154994f, -0.15862882f, 0.33283064f, 0.43684638f, 0.62634385f, -0.15955040f, -0.21186376f, 
    -0.35002056f, -0.14011624f, 0.21373427f, 0.55422127f, 0.27469331f, -0.38963363f, -0.85101938f, -0.50634956f, 
    0.24459706f, 0.04819312f, -0.04930092f, 0.10003370f, 0.37044188f, 0.32920331f, -1.66898131f, -1.13399935f, 
    0.01725847f, 0.74221569f, 0.96305400f, 0.54479837f, -0.42988852f, 0.79768795f, 0.52503115f, -0.10549017f, 
    0.02772009f, -0.25012088f, 0.43344647f, 0.14696889f, -0.02134315f, -0.11384466f, 0.41652137f, 0.06007919f, 
    -0.28706026f, 0.01996864f, -0.17193593f, -0.07845631f, -0.17474066f, 0.16439544f, -0.06539263f, -0.32119071f, 
    -0.81555253f, -1.12710249f, 0.11360054f, -0.24986406f, -0.57703859f, -0.54072767f, 0.69630092f, -0.38101438f, 
    -0.68312871f, -0.87511182f, -0.65739733f, -0.71010232f, -0.96627784f, -0.14668001f, -0.02922826f, -0.24369040f, 
    -0.36854228f, -0.44398928f, 0.17793638f, -0.17346919f, 0.15788879f, -0.18511888f, -0.44069040f, 1.85059273f, 
    -0.04058875f, 0.59852785f, 1.80949044f, 0.92951912f, -0.09500675f, 0.69124919f, 0.60307163f, 0.16098984f, 
    -0.10808729f, -0.34615600f, 0.03094159f, -0.17325200f, -0.04405303f, -0.00369898f, -0.21753916f, 0.09907516f, 
    0.52455729f, 0.29270789f, 0.11205379f, -0.16941352f, 0.11589806f, -0.45020092f, 0.00387659f, -0.01667711f, 
    -1.60927618f, 1.77212250f, 0.97163713f, -1.23225164f, -0.15573411f, 0.06216533f, 0.66573560f, -0.25376916f, 
    -0.09813915f, -1.08159888f, 0.00564137f, 0.41184241f, -0.39913070f, 0.04722139f, -0.03742571f, -0.10492440f, 
    -0.13852096f, -0.31174231f, -0.41596967f, -0.06407709f, 0.13095805f, -0.17399183f, 0.06334347f, 0.35321715f, 
    0.09566720f, 0.18782115f, 0.55171269f, 0.71885073f, 0.92937869f, 0.05640800f, 0.38789570f, 1.13562119f, 
    -0.23620385f, 0.09386226f, 0.72732902f, 0.19339758f, 0.38784432f, 0.43115827f, -0.11094549f, 0.59298670f, 
    -0.52193981f, -0.45346370f, -0.25736272f, -0.08115845f, 0.09815255f, -0.00507253f, 0.60810989f, 0.76007843f, 
    0.52079469f, 0.54071784f, -1.42105532f, -0.03848892f, 0.03968989f, -1.30404425f, -0.76059014f, 0.83097672f, 
    -1.04716587f, 0.05073696f, 0.44210723f, 0.37927681f, 0.21116593f, -0.63238329f, 0.69294679f, 0.27434176f, 
    0.09267404f, -0.05875424f, 0.12049420f, -0.23259890f, -0.19417502f, 0.06647191f, -0.11291651f, -0.04202118f, 
    -0.13152227f, -0.27140021f, -0.04921194f, 1.32580781f, 0.75415856f, 1.23440909f, 0.90461403f, 1.26956689f, 
    0.92625147f, -0.17679842f, -1.32432353f, -0.56982136f, -0.50667971f, 0.42773089f, 0.42505211f, -0.25442806f, 
    0.29275411f, -0.52400869f, -0.02075736f, -0.09970769f, 0.06463779f, 0.05991413f, -0.12264448f, 0.10313394f, 
    0.19025160f, 0.04777227f, -0.13174962f, 0.08038746f, 1.88296223f, 0.96886796f, -0.77309436f, -0.73936403f, 
    -0.39216095f, -0.49546862f, 0.84026879f, 0.03629924f, 0.73166215f, 0.53608382f, 0.07863474f, 0.54763329f, 
    0.09420211f, -0.27025804f, 0.21045533f, 0.20130992f, -0.11053351f, -0.11656130f, 0.14596072f, 0.61160469f, 
    -0.20382510f, 0.11874172f, 0.15940689f, -0.14544569f, -0.03181811f, -0.78207862f, -0.07119557f, -0.66200054f, 
    -0.37231722f, 0.05813102f, 0.38209072f, 1.78614724f, 0.75310767f, 0.86012387f, 0.53441268f, 0.08924097f, 
    -0.64212340f, -0.45332798f, -0.70734787f, -0.19937584f, 0.27501214f, 0.09607612f, -0.23698358f, 0.15079284f, 
    -0.35359734f, 0.06287470f, -0.05073946f, -0.13310210f, -0.01360699f, -0.17323555f, -1.04135358f, -0.86210537f, 
    -0.44907549f, -0.38533598f, -0.85097396f, -0.32301486f, 0.44676208f, -0.41332483f, 0.52498919f, 0.36424261f, 
    0.33773047f, -0.28087306f, -0.27683309f, 0.03647265f, 0.37790045f, 0.27329630f, 0.23508197f, 0.15480641f, 
    0.49131936f, 0.32436123f, 0.51992226f, 0.42917362f, 0.68232822f, 0.59506750f, 0.13709018f, 1.49798357f, 
    1.32322872f, 0.10375074f, 0.03921450f, -0.16195986f, -0.95811039f, -0.96449971f, 0.47557890f, 0.04475857f, 
    0.35673168f, -0.29692033f, -0.18013774f, 0.25937849f, 0.13201244f, 0.12849115f, -0.04742899f, -0.10733478f, 
    -0.28049624f, 0.08190761f, 0.61283064f, 0.43602872f, 0.62038624f, -0.18963766f, 0.09915924f, 0.06958935f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01021952f, 0.59738868f, 0.27899945f, 0.60051143f, 0.72432703f, 0.40631545f, -0.05811124f, 0.18461922f, 
    0.09711586f, 0.06844679f, 0.19818571f, 0.18468270f, 0.37555259f, -0.01994345f, 0.35168707f, 0.39974174f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.75536585f, 0.05037889f, -0.09963190f, -0.36145476f, 0.08751463f, 0.07713605f, 0.09166738f, -0.07687233f, 
    0.01383458f, -0.00338683f, 0.01433003f, -0.07357775f, -0.67750055f, -0.10036525f, -0.15272298f, 0.17566103f, 
    0.03670700f, 0.04083252f, -0.20258361f, -0.08239851f, 0.17021376f, -0.19053744f, -0.06989890f, -0.11087544f, 
    -0.07073133f, -0.12320132f, -0.15878180f, 0.46763229f, -0.13115968f, 0.12954400f, 0.12578444f, -0.21970114f, 
    0.07413926f, 0.07234316f, -0.04275214f, -0.20870461f, -0.63522923f, -0.01958631f, -0.28059810f, 0.13561615f, 
    0.19550794f, -0.13654158f, -0.02916004f, -0.01551503f, 0.05690930f, -0.17632620f, 0.08837163f, -0.10637192f, 
    0.10023724f, -0.24768889f, 0.00167931f, 0.18910851f, -0.04718392f, -0.09788188f, 0.14932586f, -0.04735412f, 
    0.03829705f, 0.03229010f, 0.16504580f, -0.45813245f, -0.18533009f, 0.01730896f, 0.27483603f, 0.00323629f, 
    -0.03423267f, 0.02705922f, 0.03053376f, -0.24311715f, -0.11940152f, 0.00827640f, -0.05468402f, -0.10857937f, 
    -0.38763535f, 0.06105695f, 0.37527978f, -0.17958234f, 0.10361475f, 0.05183095f, 0.01123819f, 0.01968989f, 
    -0.05409105f, -0.00491343f, 0.19732729f, -0.07294361f, 0.47211766f, 0.02485206f, -0.44932199f, 0.67618960f, 
    -0.32038689f, 0.00586149f, 0.02183375f, 0.03193051f, -0.00281176f, -0.04463540f, -0.10418604f, -0.00155546f, 
    -0.31796578f, 0.23039584f, 0.39520019f, -0.34226179f, -0.12263742f, 0.11868995f, 0.20466468f, -0.09172489f, 
    0.03232110f, -0.09422732f, 0.01797460f, 0.08694657f, -0.08016025f, 0.02638489f, 0.04797440f, 0.11326938f, 
    -0.34589157f, -0.14781049f, -0.09899603f, -0.24079475f, -0.11570530f, 0.24001887f, 0.13052173f, 0.25270212f, 
    0.38743985f, -0.37570679f, -0.10186982f, -0.22074765f, -0.11220926f, -0.02668762f, -0.10136439f, 0.00265725f, 
    0.00097575f, -0.04742387f, 0.07294665f, -0.14487608f, 0.20622823f, -0.23927867f, 0.34057665f, 0.03467759f, 
    -0.39117730f, -0.22373119f, 0.02250924f, 0.14232376f, 0.02700568f, 0.14031856f, -0.08644633f, 0.00143430f, 
    -0.24872379f, -0.23295349f, -0.04626546f, -0.63828582f, -0.13798986f, -0.11782351f, -0.05950716f, 0.27868477f, 
    0.10321811f, 0.05248249f, 0.20499504f, -0.00195980f, 0.40783247f, 0.51991868f, 0.14971843f, -0.34089556f, 
    0.08933237f, 0.06710274f, -0.03884789f, -0.08147216f, -0.22560021f, 0.03209771f, -0.05777492f, 0.16821909f, 
    0.25710642f, -0.00833091f, -0.35369715f, -0.22724417f, -0.04862966f, 0.16700783f, 0.12236367f, 0.17127068f, 
    0.04225512f, -0.17141339f, -0.05437331f, 0.00967537f, 0.27127552f, 0.04189526f, -0.00067180f, -0.27838859f, 
    -0.08772035f, 0.03946334f, -0.09020711f, 0.04512211f, 0.01217944f, -0.12233793f, -0.12529317f, 0.26609144f, 
    -0.68823838f, -0.11248036f, -0.01320489f, -0.20390978f, -0.10427137f, -0.04278872f, -0.10554671f, -0.21787523f, 
    0.00486642f, -0.19429800f, 0.03916242f, 0.06449386f, 0.27553287f, -0.23606397f, 0.22361982f, -0.01799333f, 
    -0.16825256f, -0.00824682f, -0.03819578f, 0.10510968f, -0.05266727f, -0.13802120f, 0.05803878f, -0.11053747f, 
    -0.89272338f, 0.30891454f, -0.10885796f, 0.19342552f, -0.08653511f, -0.04602331f, -0.00293177f, -0.08697896f, 
    0.22426458f, 0.07468633f, 0.12406728f, 0.07831997f, -0.09088068f, 0.25447187f, -0.66347110f, 0.30984506f, 
    0.01282667f, 0.09977051f, -0.00454923f, -0.05700599f, -0.20011127f, -0.00848254f, 0.01694635f, 0.08514214f, 
    0.47403118f, 0.12453650f, 0.12144619f, 0.25136793f, -0.06897371f, 0.02967880f, -0.02949043f, 0.00652539f, 
    -0.07354612f, -0.12457799f, -0.06316743f, 0.09907963f, 0.77965790f, -0.29966062f, -0.12429872f, -0.35021952f, 
    -0.02622822f, 0.00537078f, -0.28891918f, 0.06777687f, -0.11200858f, 0.08487500f, -0.07901426f, 0.00964492f, 
    -0.18550730f, -0.13322341f, 0.33097863f, -0.51500207f, 0.14635257f, -0.08961842f, 0.03107378f, 0.12648426f, 
    0.14498912f, -0.22643588f, -0.34673557f, -0.25402880f, 0.52537113f, -0.04647290f, 0.00084327f, 0.53894770f, 
    -0.06518295f, 0.00670820f, -0.06017809f, -0.08640343f, 0.15754555f, -0.14820929f, -0.09136038f, 0.01610888f, 
    -0.81653494f, -0.07782784f, -0.36187413f, -0.54230046f, -0.20486090f, 0.04883636f, 0.01872420f, 0.01740393f, 
    0.09969880f, 0.00491074f, -0.03343885f, -0.01615835f, 0.12491636f, 0.23912877f, 0.11045741f, 0.33726832f, 
    -0.18975040f, 0.09639584f, 0.15461020f, -0.04178673f, 0.11390743f, -0.06980380f, -0.06773755f, -0.02484101f, 
    -0.51356971f, 0.24399425f, 0.08853260f, -0.12333412f, 0.18883914f, -0.20050609f, 0.22662728f, 0.16556504f, 
    -0.09292031f, 0.09814529f, 0.04969472f, -0.01626651f, 0.16964629f, -0.33523777f, 0.18356636f, 0.20368618f, 
    -0.31741658f, 0.04707911f, -0.10734861f, -0.02428521f, -0.11342972f, -0.03241004f, 0.04473079f, -0.09821779f, 
    0.90769094f, -0.24431543f, 0.20373070f, -0.31085557f, 0.00695643f, -0.36313951f, 0.06773515f, -0.14690185f, 
    -0.27321097f, 0.03928085f, -0.04652243f, 0.21744224f, 0.04850081f, -0.03841253f, -0.18921287f, -0.11017621f, 
    0.22964920f, -0.00372897f, -0.23192406f, 0.02732036f, 0.27157977f, 0.24380015f, -0.30422196f, 0.03457152f, 
    0.13440153f, 0.01101771f, -0.35474411f, -0.06801682f, -0.04524560f, -0.03493068f, -0.11355601f, -0.04853019f, 
    0.14643988f, 0.02473590f, -0.15644848f, 0.20432588f, 0.20612431f, -0.27506509f, 0.00692254f, 0.03111571f, 
    -0.05666625f, -0.08877949f, 0.11875483f, 0.08671957f, -0.05739038f, 0.02007462f, -0.07962735f, 0.12925878f, 
    0.70794255f, 0.26976141f, 0.02103591f, 0.10396471f, 0.11222017f, -0.02102266f, 0.22440031f, -0.00271644f, 
    -0.23653397f, 0.03479725f, 0.14736456f, -0.18041641f, 1.11943531f, -0.13604291f, -0.44133997f, 0.33691341f, 
    -0.21032806f, -0.21429096f, -0.26268676f, 0.08640361f, -0.00166466f, 0.08852904f, -0.14155966f, -0.00909210f, 
    -0.30539316f, -0.15500601f, -0.41308069f, -0.39680681f, -0.40548614f, 0.09023865f, -0.14798771f, -0.14093859f, 
    0.22670481f, -0.12342647f, -0.12594350f, -0.11336006f, 0.48176023f, -0.53379124f, -0.18428247f, -0.05203591f, 
    -0.12734824f, -0.06351084f, -0.43145797f, 0.12233388f, 0.13062450f, 0.01607984f, -0.10327046f, -0.11704255f, 
    -0.04013060f, 0.03598849f, 0.08419523f, 0.00314291f, 0.14411883f, -0.20151466f, -0.01207849f, -0.08618663f, 
    -0.06033882f, 0.11034846f, 0.03514792f, -0.14444749f, -0.23099695f, -0.38613740f, 0.35120329f, 0.08315559f, 
    -0.14797272f, 0.01525634f, 0.00774953f, 0.04821553f, -0.04761036f, -0.15251230f, -0.28487426f, -0.05796665f, 
    -0.78704119f, -0.20289887f, -0.46253610f, 0.00526531f, 0.00063509f, 0.31533518f, -0.06685043f, -0.16706951f, 
    0.09133330f, 0.14796822f, 0.03114688f, -0.03767832f, -0.30076027f, 0.08234681f, -0.12384833f, -0.15341839f, 
    0.28774357f, 0.01194923f, -0.14866357f, 0.14209227f, -0.10648206f, -0.12760599f, 0.04881606f, -0.04557207f, 
    0.48326293f, 0.07945422f, -0.65911227f, -0.22900330f, 0.08748136f, -0.01777391f, 0.16968390f, -0.23576684f, 
    0.08734061f, -0.11440611f, 0.01316437f, -0.03419646f, 0.23726451f, -0.02303199f, 0.12779711f, -0.18454383f, 
    0.10808155f, 0.02987882f, -0.15972379f, -0.16640373f, -0.06334893f, 0.26718691f, 0.10382190f, -0.02908988f, 
    0.16892269f, 0.31764176f, -0.08488304f, 0.01940406f, 0.05833648f, -0.24337277f, -0.20386370f, -0.07619130f, 
    -0.16660176f, 0.16633563f, -0.02326915f, 0.03876485f, 0.23580962f, -0.08383206f, 0.13386716f, -0.04720934f, 
    0.22363971f, -0.00410926f, 0.06709095f, -0.12040137f, 0.02685096f, 0.15636754f, 0.08094262f, -0.00106046f, 
    0.00813758f, 0.26259255f, 0.09551257f, -0.01406755f, -0.14989328f, -0.24402604f, 0.14238903f, 0.07899857f, 
    -0.04831954f, -0.20270428f, 0.03434901f, -0.11875018f, 0.54436010f, 0.12058373f, 0.12865642f, 0.30849934f, 
    -0.29992327f, -0.24310757f, -0.00588613f, 0.25338149f, 0.04826761f, -0.10510620f, 0.03438363f, -0.14830096f, 
    0.37259725f, -0.21758211f, 0.23622008f, 0.00629285f, -0.33485046f, -0.06066370f, -0.30792719f, 0.03036144f, 
    -0.21483664f, -0.13604802f, 0.07308555f, -0.06611281f, -0.42254943f, 0.22474605f, -0.01889775f, -0.38147381f, 
    0.05781854f, -0.12244570f, 0.21505043f, 0.05290060f, -0.09811607f, -0.20586869f, -0.13901827f, 0.02704249f, 
    -0.32047060f, 0.33150995f, 0.07124551f, -0.38672015f, -0.04987267f, 0.08813661f, -0.25489864f, 0.06512000f, 
    0.02516366f, -0.13417646f, -0.08553798f, 0.31677687f, 0.30490461f, 0.12272966f, 0.11073934f, 0.09291488f, 
    0.02076961f, -0.19782971f, 0.08819970f, -0.13405803f, -0.06332739f, 0.07402786f, -0.09311172f, 0.20760044f, 
    0.31530544f, -0.09129821f, 0.13444248f, 0.00145256f, 0.10688371f, 0.22661567f, 0.10079935f, 0.04401906f, 
    -0.18836728f, -0.03265337f, -0.15215583f, 0.04688254f, 0.30020121f, 0.19629325f, 0.08322145f, -0.03549840f, 
    0.01525996f, 0.05851740f, -0.12064441f, 0.22125754f, 0.03227039f, 0.11042344f, 0.15399691f, 0.07317521f, 
    -0.47283021f, -0.51582962f, -0.56666946f, 0.04798623f, -0.38311580f, -0.12895074f, -0.10573690f, 0.00159852f, 
    -0.04356238f, -0.09139584f, -0.10040820f, 0.06817470f, 0.04149456f, 0.21487664f, -0.23633972f, 0.07637732f, 
    -0.13606954f, 0.18822105f, 0.00951530f, -0.12965274f, -0.00118260f, 0.03016817f, -0.04086992f, -0.00072147f, 
    0.18606563f, -0.02267851f, 0.34121567f, 0.01099260f, -0.17891401f, -0.03554998f, -0.08636593f, 0.01688978f, 
    -0.11906217f, 0.27502033f, -0.04123156f, 0.06237904f, -0.58836383f, -0.80905187f, 0.25287643f, -0.11582100f, 
    -0.27264771f, 0.04887549f, 0.25483900f, 0.03524062f, 0.10307030f, -0.10879210f, 0.17454189f, -0.01063514f, 
    0.40196526f, 0.69707930f, 0.26192212f, -0.15243563f, 0.05433058f, -0.01502573f, 0.05321226f, 0.16106702f, 
    -0.11818540f, 0.05060843f, -0.06306359f, 0.05171256f, -1.13479376f, -0.16652562f, 0.11732449f, -0.26107091f, 
    -0.14107329f, -0.01255430f, -0.06535736f, 0.03830603f, 0.17623045f, 0.11394703f, -0.04652128f, 0.13031870f, 
    0.04289215f, 0.26494113f, -0.12611794f, -0.21385033f, 0.07562485f, -0.05845475f, 0.02211734f, 0.05602659f, 
    0.10890652f, 0.08201817f, -0.14802343f, 0.09956651f, 0.36495420f, -0.83686936f, 0.02834582f, 0.46245545f, 
    0.11054237f, 0.06509387f, -0.15780424f, -0.00628984f, 0.00012319f, -0.06402700f, -0.07670774f, -0.10297845f, 
    -0.14594984f, -0.74733412f, -0.24411467f, 0.00570223f, -0.19602409f, -0.04486523f, 0.00801913f, 0.14711128f, 
    -0.18441541f, 0.09382387f, 0.05645723f, 0.17573963f, -0.88157266f, 0.09137093f, -0.09456044f, -0.18216555f, 
    0.05911675f, -0.01090446f, 0.22692190f, 0.03709366f, -0.04952056f, -0.02005402f, 0.05668524f, -0.18933715f, 
    0.01817176f, 0.17973810f, -0.00007687f, -0.40973413f, -0.34527794f, -0.22380678f, 0.01373384f, 0.00946864f, 
    0.08233156f, -0.40728316f, 0.17094572f, -0.03967160f, 0.28561872f, -0.59931743f, -0.27328524f, 0.01748228f, 
    0.16016455f, 0.20418838f, 0.04245556f, -0.01083844f, -0.03799819f, 0.00162040f, 0.00631388f, -0.07127400f, 
    -0.16229281f, 0.05361086f, 0.15135205f, 0.31781876f, 0.05996004f, 0.13218036f, 0.05794627f, 0.20843306f, 
    0.23613796f, 0.19272783f, -0.00674515f, 0.13092206f, -0.90549833f, 0.04049722f, -0.22333665f, 0.07465991f, 
    0.07965522f, -0.01462979f, -0.00330759f, 0.06939639f, -0.31198239f, -0.32685086f, 0.06098169f, 0.07097339f, 
    -0.25495955f, -0.29726261f, 0.11331024f, -0.44150296f, 0.09623524f, 0.09466407f, -0.27871644f, 0.07229536f, 
    -0.08374827f, -0.20131837f, -0.03252039f, 0.08895063f, -0.01565667f, 0.19101296f, -0.04485574f, -0.76279283f, 
    -0.11782831f, -0.12702735f, -0.06647032f, 0.02943964f, 0.19037406f, -0.18508455f, -0.24850599f, 0.02190326f, 
    0.24792269f, -0.08476709f, 0.12077282f, 0.08145729f, -0.20271528f, 0.08208316f, 0.17337757f, 0.08529989f, 
    0.12706694f, 0.32008547f, -0.09685869f, 0.16935971f, -0.85768718f, 0.23431139f, -0.06098791f, 0.33788204f, 
    -0.03881687f, -0.16750221f, 0.23853591f, -0.16484740f, -0.12253153f, -0.28550705f, 0.19412497f, -0.07815843f, 
    0.27598917f, -0.15476356f, -0.05306687f, 0.36465865f, -0.10885409f, -0.10632917f, -0.05708168f, 0.05189368f, 
    0.06564046f, -0.18232924f, 0.21552482f, 0.29728723f, 0.39703125f, 0.37467888f, -0.18472138f, -0.19618590f, 
    -0.05472466f, -0.06227916f, 0.18183611f, 0.21454394f, -0.09714512f, 0.16579510f, -0.03929448f, -0.03795745f, 
    0.48530114f, 0.52654821f, -0.10161051f, -0.54763174f, 0.05197503f, -0.22879024f, 0.10086279f, -0.16359335f, 
    -0.05602168f, 0.09915514f, -0.00062312f, -0.00309370f, -0.81054568f, 0.19233634f, -0.08493903f, 0.02979363f, 
    0.07178455f, -0.10501635f, -0.09077725f, 0.05968729f, -0.15637091f, -0.19687763f, -0.06754866f, -0.05228409f, 
    0.62189597f, -0.03022830f, 0.01030577f, 0.05791288f, -0.02398546f, 0.05544384f, 0.01810682f, 0.17327029f, 
    0.15274534f, -0.01438363f, 0.11224356f, 0.07252149f, -0.20316719f, 0.16930331f, 0.10011783f, 0.10142938f, 
    0.03925354f, -0.01842071f, -0.09198856f, 0.14058457f, 0.08155886f, -0.11632684f, -0.10644858f, -0.05242461f, 
    -0.12787397f, -0.20800391f, -0.05711972f, -0.18868908f, -0.08504868f, 0.06636744f, 0.07221731f, -0.03766522f, 
    0.04807117f, 0.08208992f, -0.02436239f, -0.12037385f, -0.55736333f, -0.32461643f, 0.00486341f, 0.19697903f, 
    0.01986938f, 0.11061265f, 0.20427677f, -0.01960195f, 0.04135219f, -0.06886934f, 0.30574900f, 0.10818475f, 
    -0.24862665f, -0.14876203f, 0.02531892f, 0.48454368f, 0.04247728f, 0.17882302f, -0.03918633f, 0.32404941f, 
    0.05031722f, -0.09088687f, -0.05059479f, -0.16305847f, 0.01019763f, -0.83137572f, 0.04555785f, 0.35040224f, 
    -0.45947412f, -0.20065011f, 0.06324007f, -0.35873330f, -0.00032024f, 0.24810296f, 0.07653272f, -0.18548818f, 
    0.13227376f, -0.20013453f, -0.18735419f, -0.17339091f, 0.00515912f, -0.26194468f, -0.14013663f, -0.10775917f, 
    -0.17723833f, -0.37874475f, 0.10739741f, -0.18283339f, -0.71818131f, -0.05066705f, -0.47775128f, -0.16781820f, 
    0.15815268f, 0.08200245f, 0.22225265f, 0.09915963f, -0.16704161f, 0.12636776f, 0.07157649f, -0.10245635f, 
    0.16759220f, 0.07064912f, -0.17893262f, 0.07670330f, 0.00479565f, -0.12169790f, 0.04156909f, 0.18920431f, 
    0.02782507f, 0.06877483f, 0.14544672f, 0.01821929f, -0.62783933f, 0.01199704f, 0.37004235f, 0.07275318f, 
    -0.11660816f, 0.03606232f, 0.20887628f, -0.07821773f, -0.10908853f, 0.11483827f, 0.04038381f, -0.11232217f, 
    0.16607623f, 0.02435753f, 0.01951310f, 0.11299105f, -0.01326723f, 0.08261766f, -0.06081131f, 0.04790539f, 
    0.04477146f, -0.07554872f, -0.29810709f, 0.14657572f, -0.63906175f, 0.13901706f, -0.32664391f, -0.31097254f, 
    0.10047883f, -0.03128841f, -0.14431342f, -0.06531856f, 0.14096886f, -0.12949078f, 0.13988341f, 0.08541399f, 
    0.49849701f, -0.09063340f, 0.06895355f, 0.08954108f, 0.04757624f, 0.13279724f, 0.42091325f, 0.13862729f, 
    -0.04298448f, -0.05554926f, -0.19399533f, -0.20462920f, -0.05754869f, 0.22533171f, 0.33734313f, -0.34021407f, 
    -0.05807392f, 0.05303765f, -0.02479461f, -0.05916588f, 0.05605515f, -0.07554313f, 0.20392546f, 0.06456916f, 
    -0.51711076f, -0.35205811f, 0.32224256f, 0.68021590f, -0.04179623f, 0.00782647f, -0.16026634f, 0.17514530f, 
    0.06252860f, 0.16390048f, -0.03832234f, 0.00472886f, -0.14154537f, -0.04661686f, 0.19120429f, -0.21077555f, 
    -0.21334191f, 0.15257165f, 0.29903063f, 0.38100681f, 0.22526781f, -0.09056161f, -0.06985257f, -0.25047520f, 
    -0.58204329f, -0.76555228f, -0.00517846f, 0.26116702f, 0.00156871f, 0.00502541f, -0.19160977f, -0.27470779f, 
    -0.00904009f, -0.19283518f, -0.30271512f, -0.02391235f, 0.04046591f, -0.05348739f, 0.26495215f, 0.31462917f, 
    0.03901534f, 0.19026530f, 0.23473990f, -0.06944282f, -0.10540869f, -0.00529483f, -0.06722689f, 0.32737544f, 
    0.22076097f, -0.16277534f, -0.14178914f, -0.06801044f, -0.05857006f, -0.06452899f, 0.01933561f, -0.10501448f, 
    -0.00124484f, -0.09485970f, -0.10545287f, -0.04459758f, -0.12613544f, 0.20552979f, -0.00539536f, -0.22318922f, 
    0.00192655f, 0.22709933f, -0.19889840f, -0.22194648f, 0.25011250f, -0.05751466f, -0.23055887f, -0.00540132f, 
    -0.71644551f, -0.33327276f, -0.02981734f, 0.13747276f, 0.20442580f, -0.05421892f, 0.26075903f, -0.04942456f, 
    0.15400167f, 0.25129884f, 0.03417887f, 0.11937019f, 0.14815557f, 0.24106838f, 0.23478292f, -0.10048336f, 
    -0.01632064f, -0.18118641f, -0.22178192f, 0.04850127f, 0.08143973f, -0.06549943f, 0.28365171f, -0.06302360f, 
    0.06015886f, -0.27031446f, 0.07892673f, 0.49227613f, -0.02122308f, 0.13664584f, 0.17056632f, 0.15014887f, 
    0.03633573f, 0.13922179f, -0.38793856f, 0.12789418f, 0.35021108f, -0.06380552f, 0.06586852f, -0.31441996f, 
    0.04846237f, -0.03436060f, -0.02028725f, -0.33479166f, 0.11993571f, -0.10121172f, 0.13489854f, 0.08667533f, 
    -0.40916651f, -0.46574512f, 0.46853578f, -0.06690715f, 0.17454790f, 0.02818687f, 0.04718517f, 0.04899336f, 
    -0.02953619f, -0.24358787f, 0.03621908f, -0.11249874f, 0.58110762f, -0.39982352f, -0.16964218f, -0.21988462f, 
    0.03472709f, 0.19066429f, -0.01277610f, 0.04685032f, 0.09813403f, 0.17832680f, 0.03171052f, -0.06340003f, 
    -0.47357765f, 0.43644273f, 0.25590062f, -0.06624331f, 0.00714304f, -0.13296644f, -0.06244838f, -0.04668212f, 
    0.10447234f, -0.03715768f, 0.30127937f, -0.15517475f, -0.08967029f, -0.41321647f, 0.05658135f, -0.45179874f, 
    0.01461482f, 0.04536884f, 0.01645038f, 0.06192661f, 0.11920942f, 0.26975977f, -0.08815046f, 0.05334281f, 
    -0.46481153f, 0.04973963f, -0.19292916f, -0.33195385f, -0.18349335f, -0.04396269f, 0.06977604f, -0.21375801f, 
    -0.08629052f, 0.13032582f, 0.08884324f, 0.16555573f, 0.43103692f, 0.12125264f, 0.36306176f, -0.59654492f, 
    -0.06014482f, 0.17074916f, 0.16534024f, 0.19480176f, -0.08563719f, 0.00469871f, -0.13707864f, -0.04055259f, 
    0.32485250f, -0.66450334f, 0.07570469f, 0.29788697f, 0.16618313f, -0.16249374f, -0.08962515f, 0.06322492f, 
    -0.12956914f, -0.06435317f, -0.12732852f, 0.00310171f, 0.28278622f, -0.13489509f, -0.06529350f, 0.02792435f, 
    0.11002962f, -0.34196490f, -0.18130235f, -0.09141518f, -0.11736619f, 0.04997138f, 0.05416402f, -0.22977781f, 
    0.22326681f, -0.06648750f, -0.24648431f, 0.13882922f, -0.13739908f, 0.32034624f, 0.11155812f, -0.04807303f, 
    -0.25690079f, 0.13961427f, 0.16870245f, 0.10742291f, -0.06790646f, 0.29852119f, 0.02348465f, -0.41469836f, 
    -0.14499983f, 0.06425264f, 0.00667304f, 0.08378445f, 0.14474411f, -0.05458142f, 0.08494170f, -0.00605370f, 
    -0.90203303f, -0.03935554f, 0.13837115f, 0.50634879f, 0.00184577f, 0.02401679f, 0.12543631f, -0.03241401f, 
    0.02000111f, -0.19989282f, 0.08712457f, -0.12364005f, -0.24304247f, -0.67363787f, 0.04109529f, -0.01435626f, 
    0.04696701f, 0.00515941f, 0.00813152f, 0.04783975f, -0.09238438f, -0.13004304f, 0.35106957f, 0.26742670f, 
    -0.02950699f, 0.08436369f, -0.36099845f, -0.36944193f, -0.09317254f, 0.13541086f, 0.03092177f, -0.27447197f, 
    -0.33273578f, -0.12172090f, -0.05523362f, -0.45522028f, -0.50950354f, 0.27037930f, 0.04686716f, -0.07143222f, 
    -0.02257929f, 0.20440005f, -0.10902611f, 0.18624444f, 0.02024000f, 0.02620556f, -0.07267381f, -0.10240766f, 
    -0.46380928f, 0.24013358f, -0.02801735f, 0.05943882f, 0.25330934f, -0.19487184f, 0.00800467f, 0.14144537f, 
    0.07550433f, 0.05197728f, 0.03453822f, -0.12174553f, 0.48838428f, -0.03545984f, 0.32514605f, -0.06424095f, 
    -0.08151283f, -0.09526328f, -0.09478851f, -0.13071059f, -0.09160316f, 0.11148407f, -0.10886376f, 0.04651909f, 
    0.50950354f, -0.08801930f, -0.11229260f, -0.24679814f, -0.24094839f, -0.21454346f, -0.01404726f, -0.00472681f, 
    -0.01254350f, -0.09982792f, 0.06716922f, -0.15354657f, 0.03353377f, 0.03098252f, 0.32638708f, 0.12846698f, 
    0.12410869f, -0.13944362f, -0.13119616f, -0.13601643f, -0.06620747f, 0.07533432f, -0.22738007f, -0.22860764f, 
    -0.30700135f, -0.06281019f, -0.23581314f, -0.48239097f, 0.20431852f, 0.05340277f, -0.08190513f, -0.15725702f, 
    -0.07305660f, 0.00217572f, 0.04556711f, -0.04193190f, -0.33310696f, 0.12780662f, 0.12918717f, -0.03701818f, 
    -0.21092369f, 0.24041130f, -0.16567434f, -0.24662805f, -0.29344285f, -0.08956702f, -0.16022468f, -0.04905539f, 
    0.40697733f, 0.45403579f, -0.15114069f, 0.49160448f, 0.11607520f, 0.00601540f, -0.20277892f, -0.22473241f, 
    -0.29566666f, -0.09700692f, -0.03018601f, -0.00941561f, 0.21010685f, 0.20465872f, -0.13152885f, -0.11709169f, 
    -0.16600122f, 0.07608273f, 0.04880615f, -0.13092035f, -0.04746677f, -0.01909018f, -0.09424171f, -0.16745454f, 
    0.43971977f, -0.19062376f, 0.28380445f, 0.37245393f, 0.06785206f, -0.14146712f, 0.02760507f, -0.33914715f, 
    -0.20323700f, -0.21042843f, -0.03546355f, -0.07682387f, 0.02469125f, 0.09157110f, -0.07191525f, -0.26358297f, 
    0.00220700f, -0.09427033f, -0.09744170f, -0.08699571f, -0.27827555f, 0.03336391f, -0.16195141f, 0.03366940f, 
    0.08529081f, 0.21564879f, -0.05379758f, 0.57339668f, 0.40942994f, 0.05093016f, 0.03605954f, 0.09571112f, 
    0.00313510f, -0.02834472f, -0.09578910f, -0.23469740f, -0.85266918f, 0.12115301f, -0.31742135f, -0.15903449f, 
    -0.09856160f, -0.11074975f, -0.01122594f, -0.06790728f, -0.16633435f, 0.10934242f, -0.06201918f, -0.09441938f, 
    -0.29905370f, -0.00924573f, -0.30292499f, -0.07522963f, 0.01586190f, 0.11054485f, -0.14962962f, 0.04821604f, 
    0.07774465f, 0.01599436f, -0.06557236f, -0.15866041f, -0.43620148f, 0.28933710f, 0.04929924f, -0.03097400f, 
    0.27173024f, 0.08228163f, 0.13318735f, 0.10901614f, 0.03383103f, 0.02201925f, 0.20028527f, 0.06746882f, 
    0.14981999f, 0.53179562f, 0.19653691f, 0.26853949f, 0.25351432f, 0.09124769f, 0.05250696f, 0.01961820f, 
    -0.07374191f, 0.04338871f, 0.16165632f, -0.08103149f, -0.46949643f, 0.22803977f, -0.36703101f, -0.26678193f, 
    -0.00950217f, 0.04247508f, -0.25312826f, -0.08474161f, -0.39371696f, -0.13809243f, 0.17388272f, 0.05990404f, 
    0.08085069f, 0.24376756f, -0.29623190f, 0.23336802f, 0.02372868f, -0.15100151f, -0.20834568f, -0.03912101f, 
    -0.04800843f, -0.39803365f, 0.30081239f, -0.13041583f, -0.48505265f, -0.13745672f, 0.17982139f, -0.45369935f, 
    0.40301871f, 0.21826825f, 0.12859459f, 0.14147714f, -0.01447060f, -0.12297122f, -0.05443749f, -0.09174875f, 
    0.03869572f, 0.01418468f, -0.02923398f, -0.18283851f, 0.05715389f, -0.01854039f, 0.05377477f, 0.14772607f, 
    -0.04123939f, 0.08374822f, 0.19795871f, 0.05567952f, -0.34093326f, -0.69996744f, 0.40359247f, -0.12551156f, 
    -0.27782771f, -0.05120192f, 0.21149303f, -0.13171501f, -0.20783487f, 0.04785175f, -0.08255731f, 0.12941049f, 
    0.06874874f, -0.15460458f, 0.03418300f, 0.00878986f, 0.17486627f, -0.10400058f, -0.16076024f, 0.06036912f, 
    -0.07119279f, -0.18659416f, -0.29464814f, 0.05471282f, -0.19651185f, 0.13763919f, 0.46217331f, 0.29738176f, 
    -0.16930638f, -0.16100550f, -0.07768092f, 0.08480544f, 0.00244268f, -0.10307325f, 0.00123555f, -0.00222998f, 
    -0.47469971f, -0.40126657f, -0.21687827f, -0.16016859f, 0.13823509f, 0.08951136f, -0.26910722f, 0.24397874f, 
    0.06381641f, -0.06643847f, -0.06167849f, -0.56746113f, 0.29374379f, -0.07459117f, 0.26420796f, 0.45153964f, 
    0.06504299f, -0.20267858f, -0.11859563f, -0.16915925f, 0.04487228f, -0.07290925f, 0.22248396f, 0.03250774f, 
    0.39284420f, 0.22311834f, -0.40913182f, -0.12279591f, -0.02608732f, 0.04701648f, -0.06045800f, -0.05246612f, 
    0.00603748f, 0.05610683f, -0.12803635f, 0.07094736f, 0.40806466f, 0.13189693f, -0.40853322f, 0.16257979f, 
    0.09266281f, 0.27020606f, -0.06031072f, -0.05897601f, -0.04385348f, -0.10805141f, -0.05529549f, -0.03362440f, 
    -0.29822201f, 0.04189330f, 0.22899008f, -0.37523219f, -0.02286864f, -0.10281857f, -0.13736102f, -0.05655091f, 
    0.11186295f, 0.00374839f, 0.11340658f, -0.00053994f, -0.30283445f, 0.04496581f, -0.01790355f, 0.36596149f, 
    0.11537164f, 0.05863404f, -0.10594250f, -0.08890439f, 0.14172481f, -0.06466109f, 0.16277915f, 0.07873861f, 
    0.18166374f, 0.50392187f, -0.60775274f, 0.05368455f, -0.08800696f, 0.07808053f, -0.48733082f, -0.26266074f, 
    0.04370738f, 0.09696531f, 0.03678213f, 0.16042908f, 0.29728892f, 0.01151718f, -0.00146891f, 0.25624979f, 
    -0.50076038f, -0.19933559f, -0.15142816f, -0.12299382f, -0.01419201f, -0.27393070f, -0.23296982f, -0.17515191f, 
    -0.08965953f, -0.12422329f, 0.44187346f, 0.04031365f, -0.11078463f, -0.14724810f, 0.13704406f, -0.24102835f, 
    0.11904842f, 0.03791393f, -0.02350733f, 0.16284667f, -0.08920096f, -0.44129825f, -0.64858007f, -0.43777889f, 
    0.17726159f, -0.07321400f, -0.09675591f, 0.05621450f, 0.11351412f, 0.11111532f, 0.10257465f, -0.14549460f, 
    -0.01762863f, -0.42476484f, 0.50010794f, -0.29528782f, -0.06400161f, 0.03239283f, 0.12710348f, 0.05694083f, 
    0.12700929f, 0.41284508f, 0.10922532f, 0.10807101f, 0.12041173f, -0.28147721f, -0.14780036f, 0.28405336f, 
    -0.10162137f, 0.01054478f, 0.01519960f, 0.02229080f, -0.16698335f, 0.20472817f, -0.15216477f, 0.01113188f, 
    1.17749834f, 0.44156763f, -0.14295140f, -0.06878134f, 0.06524312f, -0.05942571f, -0.08871169f, 0.04275243f, 
    -0.30412227f, -0.00568998f, -0.06885514f, 0.14666857f, 0.19162053f, -0.11229613f, -0.42504385f, 0.18402091f, 
    0.07402733f, -0.07576276f, -0.09264022f, 0.13574351f, 0.06719159f, -0.08950640f, 0.13022213f, 0.08803272f, 
    -0.00363192f, 0.06513971f, 0.03689005f, -0.22519456f, 0.10914817f, 0.01528268f, -0.10049807f, -0.22427337f, 
    -0.04901524f, -0.25781086f, 0.25612748f, 0.01150855f, 0.06529702f, 0.39726952f, -0.20409213f, 0.14719339f, 
    0.28185380f, 0.00961301f, -0.10984974f, -0.02048070f, -0.04836193f, 0.10302094f, -0.13998884f, 0.17357640f, 
    -0.01375503f, 0.25518337f, -0.19262221f, 0.08250884f, -0.03552385f, 0.05165438f, -0.28735274f, 0.18548445f, 
    -0.03407855f, 0.02438450f, 0.11662386f, 0.14101900f, -0.45940617f, 0.09566061f, -0.46034780f, -0.15802892f, 
    0.10677574f, -0.20148806f, 0.09810624f, -0.10577080f, -0.15524177f, -0.02843088f, -0.04402647f, 0.07309800f, 
    -0.21173057f, -0.63277537f, -0.12603433f, -0.14850101f, 0.06337914f, -0.08143528f, -0.00922292f, 0.05782482f, 
    -0.04593059f, -0.17912664f, 0.20627126f, 0.09387630f, -0.18376407f, 0.09013456f, -0.07252688f, -0.52875578f, 
    0.21083862f, -0.05854542f, -0.03361318f, -0.21059828f, -0.06178509f, 0.02393224f, -0.04431404f, 0.19185174f, 
    -0.75685871f, -0.23362020f, 0.08507094f, -0.48820204f, 0.14939059f, -0.15760976f, 0.15110143f, 0.08566267f, 
    0.27671808f, -0.14124790f, 0.12071957f, 0.04282422f, -0.43919575f, 0.82360685f, -0.33128724f, -0.95501906f, 
    0.09914681f, -0.07722615f, 0.06149001f, 0.16098511f, -0.10277038f, 0.17112692f, 0.04689503f, -0.13751765f, 
    -0.13305438f, 0.54441297f, 0.22333695f, 0.28896976f, 0.18113688f, 0.08592796f, -0.17488053f, 0.18698722f, 
    0.16656803f, -0.04433658f, -0.03530255f, -0.07604902f, 0.09411605f, -0.34066892f, -0.00738382f, 0.31124228f, 
    0.21635239f, -0.11756700f, -0.06380344f, 0.13300927f, -0.29299518f, -0.12177724f, -0.00858668f, 0.02142991f, 
    -0.56021231f, -0.49273214f, -0.14873691f, 0.03254304f, 0.10621532f, 0.00127632f, -0.06474481f, -0.13341828f, 
    -0.07303325f, -0.09594943f, -0.02371359f, -0.17353085f, -0.12171523f, -0.09458220f, 0.32546851f, 0.07492781f, 
    0.10015428f, -0.03296669f, 0.12572914f, -0.07058127f, -0.16801682f, -0.19030628f, -0.13949957f, -0.07024906f, 
    -0.29341006f, -0.00771871f, -0.58294159f, 0.04668172f, -0.14658466f, -0.05726099f, -0.07078854f, 0.03868065f, 
    -0.24737725f, -0.05805934f, 0.15338922f, -0.21483955f, 0.32117817f, -0.08198394f, 0.02531140f, -0.02841809f, 
    -0.10361683f, 0.36570665f, 0.06070654f, 0.07107072f, 0.03527024f, 0.19178325f, -0.04078187f, -0.06484505f, 
    -0.39010429f, -0.11847053f, 0.08871802f, 0.45560479f, -0.08212642f, 0.10303391f, 0.30748546f, -0.02617710f, 
    0.01575467f, 0.22396447f, 0.11912053f, 0.09217989f, 0.36567074f, 0.20308383f, 0.19209370f, 0.36212504f, 
    0.06250668f, -0.09842289f, 0.10443519f, -0.06895772f, -0.00689652f, -0.18136150f, -0.07591305f, -0.01616160f, 
    -0.64080441f, -0.13041925f, -0.32282466f, 0.05280592f, 0.15455386f, 0.22696166f, -0.02900760f, 0.08914098f, 
    0.07859133f, -0.11340343f, 0.06628968f, 0.47151095f, 0.50642908f, 0.33129206f, -0.09439791f, 0.35366249f, 
    -0.02955898f, -0.18368292f, 0.20719354f, 0.35450006f, 0.05987542f, -0.02667428f, 0.13214669f, 0.03071882f, 
    -0.19561800f, -0.30326313f, 0.39669904f, 0.23132367f, 0.00053526f, 0.00056867f, 0.15931185f, 0.23924465f, 
    0.08509716f, -0.28354776f, -0.32440409f, -0.09182107f, -1.30514860f, -0.91546410f, -0.27179322f, -0.44524544f, 
    -0.13912329f, -0.12035108f, -0.20606139f, -0.01106985f, -0.22700426f, 0.05836825f, -0.08212246f, -0.08966014f, 
    -0.86133897f, 0.18852912f, -0.37391719f, -0.11797448f, 0.24957298f, 0.09500124f, -0.23582035f, 0.06546351f, 
    0.25279361f, 0.21521950f, -0.21081926f, -0.14730904f, -0.18362141f, 0.15914556f, -0.44146159f, -0.23171404f, 
    -0.02446838f, 0.06655547f, -0.03425866f, 0.03555228f, 0.28690997f, 0.14618954f, 0.15528546f, 0.03539665f, 
    0.20220265f, 0.12003992f, -0.19455630f, -0.20754233f, -0.16765334f, 0.00873025f, 0.24595867f, -0.06058846f, 
    -0.22246325f, 0.01831190f, 0.02051499f, 0.02517835f, -0.56671011f, -0.19732177f, -0.27270889f, -0.70352548f, 
    0.09556617f, -0.01602781f, -0.08563542f, -0.02663993f, 0.25247413f, 0.00596886f, 0.05165443f, 0.10386055f, 
    -0.72341108f, -0.92789471f, 0.16232221f, 0.06017008f, -0.01938285f, 0.19733573f, 0.07725038f, -0.12154165f, 
    0.19359945f, -0.00531001f, 0.12298319f, 0.06262035f, 0.61024046f, 0.08131035f, -0.18423676f, -0.11266690f, 
    -0.16058536f, -0.24662741f, 0.08707992f, -0.17719896f, 0.00816238f, -0.14040120f, -0.44056362f, -0.12126911f, 
    0.27494010f, -0.08903879f, -0.07180811f, -0.12786086f, -0.14459838f, -0.19427101f, 0.06771766f, -0.14388295f, 
    0.24649334f, 0.42600614f, 0.20032609f, 0.27906668f, -0.86126208f, 0.02566247f, 0.19350132f, 0.29261166f, 
    0.03611236f, 0.13937536f, -0.03044004f, 0.01041904f, 0.05871258f, 0.15860640f, 0.09531056f, 0.24619141f, 
    -0.35861176f, -0.36734861f, -0.06806086f, 0.14666606f, -0.02735818f, 0.15496297f, -0.12917289f, -0.06894955f, 
    0.04489843f, 0.00681375f, -0.11676531f, 0.04248072f, -0.64324272f, 0.51106274f, 0.14814983f, 0.04561459f, 
    0.15153672f, -0.10820015f, -0.00383023f, -0.08972297f, 0.17671496f, 0.08167170f, 0.10318012f, 0.10642003f, 
    -0.54132640f, 0.11267000f, 0.24972625f, -0.00085780f, -0.28797224f, -0.04283125f, -0.06551262f, 0.20683312f, 
    0.00277577f, -0.03234486f, 0.04456823f, -0.02484694f, -0.22284386f, -0.16931590f, 0.27850991f, -0.19432457f, 
    -0.05804211f, 0.00044974f, 0.09803537f, -0.28086129f, -0.16424021f, 0.13485965f, 0.13972645f, 0.14451711f, 
    0.11407068f, 0.22154374f, -0.05977426f, -0.39268374f, 0.04796353f, -0.13073464f, -0.00005044f, 0.17900358f, 
    -0.11283971f, 0.12349010f, -0.05069285f, -0.06826224f, 0.39983675f, -0.30036643f, -0.03981286f, 0.05777335f, 
    -0.09941766f, -0.20328683f, 0.20994149f, 0.14016438f, 0.02507881f, 0.07968555f, -0.13223344f, -0.06314135f, 
    0.10749233f, 0.01060010f, -0.39548871f, 0.08700507f, 0.03428983f, -0.16156261f, -0.15970610f, -0.48254722f, 
    0.07102612f, 0.09413093f, 0.27812755f, 0.21703123f, -0.73847461f, -0.29735559f, -0.05628144f, -0.71144056f, 
    0.17476124f, -0.05576957f, 0.02386178f, -0.03527129f, 0.02718390f, -0.01345660f, -0.12147187f, 0.14264990f, 
    -0.07546594f, -0.21508783f, -0.06378209f, 0.42624468f, -0.16004865f, 0.12278705f, -0.25038764f, 0.00363915f, 
    -0.05034183f, 0.02109435f, 0.16257508f, 0.06434369f, 0.33131596f, -0.51977688f, -0.21278523f, 0.10784686f, 
    0.22866605f, 0.07383337f, -0.03816173f, 0.00816021f, -0.20431226f, -0.19050801f, -0.07940266f, -0.03964635f, 
    0.25286296f, -0.38133717f, -0.09795211f, 0.12559438f, -0.06976217f, 0.30791667f, 0.00262568f, 0.05916701f, 
    -0.09416955f, 0.09176496f, -0.02949800f, 0.00843246f, 0.61452061f, -0.32277703f, -0.67209959f, 0.38212827f, 
    0.07352550f, -0.04171685f, 0.04794802f, -0.12147423f, 0.08560528f, 0.02898954f, 0.02189618f, -0.17799434f, 
    -0.14656037f, 0.32511383f, 0.01455299f, 0.21294619f, 0.18669906f, 0.20985357f, -0.04091545f, -0.16285489f, 
    0.00735752f, 0.11543549f, -0.05717656f, -0.25266048f, -0.56507033f, -0.31030241f, 0.07290562f, 0.04440439f, 
    -0.22234590f, -0.15961330f, 0.18991606f, 0.18150148f, -0.42809546f, 0.10335293f, 0.10224869f, -0.20927568f, 
    0.11997674f, 0.32626697f, 0.19111125f, -0.13125560f, -0.15446091f, -0.04756182f, -0.32338923f, 0.00280171f, 
    -0.30401233f, 0.11622292f, -0.20188735f, -0.29528752f, 0.63245964f, 0.67493737f, -0.16239998f, 0.14740296f, 
    0.19474244f, 0.06762093f, -0.07061068f, 0.04534786f, 0.11029705f, -0.11019071f, -0.04155468f, 0.14927566f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19541934f, -0.01259116f, -0.18463761f, -0.02066609f, 0.11114857f, 0.01932723f, 0.04532700f, -0.20927404f, 
    -0.07339700f, 0.04666667f, 0.24331623f, 0.00385467f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
