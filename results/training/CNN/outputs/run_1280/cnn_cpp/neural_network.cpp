#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.39471984f, 0.48864385f, -0.37685779f, -0.19968410f, -0.70242786f, -0.26830664f, -0.27631164f, 0.01196016f, 
    -0.70665371f, -0.73084706f, -0.19608286f, -0.44817212f, -0.02753157f, 0.28664070f, -0.14525838f, -0.17185505f, 
    -0.23582092f, 0.27476811f, -0.32860306f, -0.06040847f, -0.04484979f, -0.03953001f, -0.02256178f, 0.16466267f, 
    -0.07776308f, 1.16819358f, -0.66362268f, -0.47199816f, -0.60838681f, -0.73249710f, 0.27541727f, 0.29238781f, 
    0.32730427f, -0.11857578f, 0.01335646f, 0.30034235f, -0.11583972f, 0.08402392f, 0.04645574f, 0.11688748f, 
    0.12461809f, -0.15041217f, 0.05343109f, 0.20390227f, -0.18310258f, -0.21514085f, 0.15343620f, 0.09635195f, 
    -0.14492366f, -0.34254113f, -0.01837057f, -0.31792527f, -0.48162162f, -0.13236830f, 0.18857998f, -0.37934840f, 
    -0.53881752f, -0.37503743f, -0.25727090f, -0.46013364f, 0.40056109f, -0.14863771f, 0.21468066f, 0.43112040f, 
    0.13165520f, -0.11886351f, 0.12776636f, -0.07795106f, 0.04856091f, -0.25008881f, -0.29198003f, -0.17403749f, 
    0.32669342f, 0.19618699f, -0.20456108f, 0.39727336f, 0.59795582f, 0.37292984f, -0.60524553f, -0.67955148f, 
    0.09804171f, 0.30749580f, 0.39410329f, -0.49236003f, -0.24273442f, -0.18920922f, 0.00083320f, -0.19039604f, 
    0.08929387f, -0.04069443f, 0.29713640f, 0.02343354f, 0.25971690f, -0.30108106f, 0.18578526f, -0.10629965f, 
    -0.22013256f, -0.18385227f, 0.07325961f, 0.05749726f, -0.52743411f, 0.74684411f, 0.28012896f, -0.34369868f, 
    -0.28343570f, -0.23033428f, 0.12274533f, -0.46419865f, -0.09697977f, 0.47692919f, -0.00656705f, 0.22616759f, 
    -0.20406719f, -0.16129577f, 0.14451084f, 0.02924400f, -0.14896470f, 0.19837721f, 0.12776761f, -0.18794993f, 
    -0.04533487f, -0.33925939f, -0.16731241f, -0.41697428f, -0.46126533f, 0.67140734f, 0.31871673f, -0.58461195f, 
    -0.44560581f, -0.36533818f, 0.00341104f, 0.21380560f, 0.15066113f, -0.09221512f, 0.26816604f, -0.08675902f, 
    0.11605541f, 0.10933316f, 0.03896835f, 0.01064298f, 0.26477686f, -0.18273243f, -0.13097741f, -0.16177042f, 
    -0.08763389f, -0.00150130f, 0.08545190f, -0.14024925f, 0.33190081f, -0.08668994f, -0.77858084f, 0.01559337f, 
    0.43010846f, -0.37450516f, -0.03961222f, 0.76971823f, -0.03125221f, -0.34734517f, -0.23582053f, -0.03093329f, 
    0.31017688f, -0.40090117f, -0.37239090f, -0.42604136f, -0.38623625f, -0.11539146f, 0.16909650f, -0.06039213f, 
    -0.10544015f, -0.00431711f, 0.01562749f, 0.08209392f, 0.16917495f, -0.01953238f, -0.30949542f, 0.40197039f, 
    0.16575304f, 0.27565661f, -0.18174689f, 0.13377827f, -0.22716776f, 0.14932880f, -0.22608228f, 0.21247557f, 
    -0.36919534f, -0.13964140f, 0.24769600f, 0.07943279f, -0.24835385f, 0.07304859f, -0.11036378f, -0.23215993f, 
    0.03038128f, -0.15826555f, 0.26869509f, 0.10711121f, 0.20325445f, -0.12256385f, -0.22096525f, -0.04120090f, 
    0.37631941f, 0.36505234f, 0.40549439f, 0.28789034f, 0.38189968f, -0.01221985f, 0.13682769f, 0.12722194f, 
    -0.34888983f, -0.24127671f, -0.03870840f, 0.08930767f, 0.03371732f, -0.14281537f, 0.19949326f, -0.03605394f, 
    0.17582695f, -0.14205965f, -0.19476758f, 0.13551129f, -0.04864028f, 0.25145045f, 0.03656661f, -0.14305967f, 
    -0.20924336f, 0.32608843f, -0.08315696f, -0.46560088f, -0.21765713f, -0.19328895f, 0.10806739f, -0.01448758f, 
    0.33078322f, -0.26869637f, -0.21767087f, 0.14073612f, -0.07435150f, 0.26203653f, -0.28192985f, -0.03713907f, 
    -0.31762171f, 0.22355400f, 0.02944405f, -0.11393631f, -0.19012994f, -0.12130504f, 0.21144450f, 0.09806412f, 
    0.39906517f, 0.31317186f, -0.36618653f, -0.65153116f, 0.03722636f, 0.13936290f, 0.53013122f, 0.07450309f, 
    0.39173800f, -0.60934299f, -0.56171477f, 0.70445240f, 0.31015468f, -0.17712897f, -0.10875657f, 0.12802885f, 
    -0.07548703f, 0.34726736f, 0.01630023f, -0.46558735f, -0.09293040f, 0.03083872f, -0.01078546f, -0.14891072f, 
    0.10075350f, 0.16103102f, 0.08323582f, -0.31923985f, 0.36081716f, -0.24186100f, -0.17873521f, 0.11820938f, 
    -0.23485361f, -0.21391574f, 0.31424814f, 0.65841699f, -0.05416255f, 0.14319867f, 0.10093825f, -0.15297239f, 
    0.29054219f, -0.37105656f, 0.18354940f, -0.05550156f, -0.11807327f, -0.22237419f, -0.06382628f, -0.14483565f, 
    0.01841261f, 0.28300872f, 0.01660751f, 0.22853200f, 1.11532092f, -0.44542077f, -0.62625176f, 0.00611518f, 
    -0.70782089f, 0.68013120f, 0.07252584f, 0.21236441f, -0.00256233f, -0.05848160f, 0.12731594f, 0.26654768f, 
    -0.08151518f, -0.10003053f, -0.19388855f, 0.10732771f, -0.21148245f, 0.20106576f, -0.15021099f, -0.09490370f, 
    -0.09601162f, -0.12212098f, 0.11570685f, 0.18465897f, -0.02753402f, -1.03358543f, 0.31783426f, 0.50039577f, 
    -0.47739995f, -0.16678448f, -0.12683085f, -0.04886775f, -0.02009166f, 0.44167838f, 0.30111289f, -0.14555888f, 
    -0.30280831f, -0.08414703f, 0.25533158f, -0.18376422f, 0.15889025f, 0.20431992f, -0.15955238f, -0.02610095f, 
    -0.06440310f, -0.01771691f, -0.06553867f, -0.08556271f, -0.35042199f, -0.29957753f, 0.09740164f, -0.27731147f, 
    -0.18224172f, -0.40784931f, -0.04527005f, -0.55372524f, -0.47891304f, 0.15171273f, -0.17883766f, -0.16233526f, 
    0.21231079f, -0.10150283f, -0.06130289f, -0.12724023f, -0.29394248f, -0.36492848f, -0.22667344f, -0.24592356f, 
    -0.24761571f, -0.31432548f, -0.30255860f, -0.18146026f, -0.10075570f, -0.31723851f, -0.32883951f, 0.09115724f, 
    0.29141352f, 0.02759374f, -0.17952938f, 0.02675023f, -0.04944529f, 0.01198798f, -0.00489238f, -0.05101857f, 
    -0.33448943f, -0.21052311f, 0.15908456f, -0.09413174f, -0.19562042f, 0.34192374f, -0.02837618f, 0.27071175f, 
    0.02874530f, -0.24878363f, 0.02157632f, -0.33570832f, -0.03283362f, 0.16729783f, 0.03175424f, 0.27688196f, 
    -0.02990188f, -0.27623230f, -0.62236679f, -0.61263949f, -0.33433551f, -0.59878165f, -0.55707920f, -0.59723067f, 
    -0.68451977f, -0.62398893f, 0.35193351f, 0.23845643f, 0.38657430f, 0.09947690f, 0.02611637f, 0.09317430f, 
    0.12236928f, -0.16632251f, 0.17800339f, -0.12312466f, -0.01874460f, 0.11194709f, 0.03834327f, 0.21413898f, 
    0.00377036f, -0.31340775f, -0.63939029f, -0.25857586f, -0.17721860f, -0.26870230f, 0.30905145f, 0.47508425f, 
    -0.35129309f, -0.27538982f, 0.14391576f, 0.27658969f, 0.05263367f, 0.36612818f, 0.00464715f, 0.12750216f, 
    -0.09879851f, -0.30001175f, -0.03619794f, 0.17905796f, 0.04236954f, -0.00365006f, -0.15493803f, 0.03419665f, 
    0.02522884f, -0.01445575f, 0.66189343f, 0.72448575f, -0.03791717f, -0.09716608f, 0.17259862f, -0.51222360f, 
    -0.27991027f, 0.48113880f, -0.38507548f, -0.55854905f, -0.07518282f, -0.12044526f, -0.19784313f, -0.01675561f, 
    0.01044897f, 0.26243341f, 0.15165763f, -0.03661328f, -0.09791107f, -0.04956562f, 0.02266955f, -0.09564329f, 
    -0.13320614f, -0.03354813f, 0.05516721f, -0.21353924f, -0.53769976f, -0.90144914f, -0.73099840f, -0.52785838f, 
    0.57259989f, 0.07327814f, 0.62141901f, 0.36074531f, 0.05438806f, 0.04932456f, 0.10816871f, -0.11588722f, 
    -0.25316700f, 0.29028371f, -0.07470432f, 0.05687457f, 0.01097433f, 0.16866629f, -0.06670035f, 0.01223883f, 
    0.04253482f, -0.13993780f, 0.02913362f, 0.09532762f, -1.22663021f, -0.48425609f, -0.17513347f, 0.07426842f, 
    -0.13571265f, 0.13659900f, -0.06997931f, 0.47323379f, -0.19359265f, 0.16355103f, 0.41428602f, 0.13823391f, 
    0.23302104f, -0.01164381f, 0.05898044f, 0.13965602f, -0.29146975f, -0.23071931f, -0.17575243f, 0.00675097f, 
    0.16490382f, 0.02819246f, 0.38351670f, -0.09214941f, -0.18019405f, 0.27727699f, 0.50914085f, 0.31779531f, 
    -0.13549933f, 0.16882771f, 0.15130100f, 0.09937862f, -0.10315844f, 0.08979739f, 0.18043417f, 0.31451154f, 
    -0.07402712f, -0.04377603f, -0.13256688f, -0.04858930f, -0.18598580f, -0.11280335f, -0.06771106f, 0.15623167f, 
    -0.10083034f, 0.00775264f, -0.10364060f, 0.13330966f, -0.05502421f, 0.11479853f, 0.55521446f, 0.41929165f, 
    0.30617070f, -0.30381042f, -0.25723234f, -0.25806504f, -0.23267041f, 0.18921269f, -0.37749687f, -0.13255292f, 
    -0.02101065f, -0.18365405f, 0.10865128f, 0.16625124f, -0.08557302f, -0.38473913f, -0.34157768f, 0.18786588f, 
    0.17595550f, -0.08059970f, -0.28258044f, -0.32062015f, -0.17849883f, -0.31763726f, -0.50220853f, 0.73447543f, 
    -0.33297986f, -0.46392754f, 0.14811052f, 0.15981343f, 0.10263621f, 0.40658122f, 0.59711087f, -0.05540410f, 
    0.02836788f, -0.45457464f, 0.16891402f, -0.20422643f, -0.26859283f, -0.01050426f, -0.12074705f, -0.07146154f, 
    0.24476413f, -0.20047882f, -0.18115143f, 0.08036543f, -0.11958374f, -0.23125391f, -0.02885066f, 0.05154590f, 
    -0.23723745f, -0.38480791f, 0.06944504f, 0.25565413f, -0.06846016f, -0.39634827f, -0.51743639f, -0.20935820f, 
    0.04332899f, -0.09645027f, 0.17202632f, 0.32676008f, 0.17035033f, 0.20361948f, -0.10203657f, 0.20380801f, 
    -0.12937000f, 0.08592585f, -0.33765247f, -0.20258045f, -0.23691925f, -0.09404618f, -0.17842302f, -0.06465530f, 
    -0.33647642f, -0.29188135f, -0.73390436f, -0.11724676f, 0.50050694f, 0.55086303f, 0.77729064f, 0.30988595f, 
    -0.30254042f, -0.39559886f, -0.30822891f, -0.00052367f, -0.18271162f, -0.10500783f, -0.37385017f, -0.06296410f, 
    -0.23505972f, 0.21591739f, 0.29164934f, 0.16511504f, -0.09188306f, 0.15721066f, 0.15666491f, -0.13840945f, 
    -0.10801221f, -0.19231406f, 0.23625664f, -0.72788072f, -0.52505213f, 0.15258174f, -0.34390247f, -0.09831796f, 
    0.12964585f, 0.33341357f, 0.10447336f, 0.24776219f, -0.17835490f, -0.24944422f, 0.11290687f, -0.01335428f, 
    0.37599769f, 0.09969132f, -0.03005449f, 0.12861973f, -0.05362469f, -0.26336738f, -0.18854344f, -0.25423303f, 
    0.01061130f, -0.12628731f, 0.08765296f, -1.34698570f, -0.52839798f, -0.50803006f, -0.68256319f, -0.33829445f, 
    0.78608394f, 0.17261030f, -0.89921677f, -0.43185303f, 0.66184533f, -0.26604056f, -0.40431583f, -0.15554745f, 
    -0.15921021f, -0.32463229f, 0.19518529f, 0.02597285f, -0.22063684f, -0.09737365f, -0.21180233f, -0.08846883f, 
    -0.05670955f, -0.15561992f, 0.06002006f, -0.05775151f, 0.54168963f, -0.29620102f, 0.08576914f, 0.18179442f, 
    -0.15192388f, -0.43705067f, -0.23150904f, 0.33731255f, 0.13077645f, 0.24300462f, -0.18601255f, -0.09954568f, 
    -0.01013238f, -0.17459048f, -0.05952368f, 0.26827601f, -0.24399222f, -0.24116898f, 0.15459642f, 0.05022609f, 
    -0.28035715f, -0.21063881f, 0.05496379f, 0.27888572f, 0.11642677f, -0.48166439f, 0.19275752f, -0.30256712f, 
    -0.68947250f, -0.24506491f, -0.15583324f, -0.33463728f, -0.42711106f, -0.64428794f, -0.13732614f, -0.01067076f, 
    0.20711255f, 0.40534157f, -0.03263305f, -0.09647501f, -0.05816205f, -0.28142324f, -0.28970012f, -0.28918993f, 
    -0.28409037f, -0.04426353f, -0.19010434f, -0.24091572f, -0.17678958f, -0.33355561f, 0.83730191f, -0.46319562f, 
    -0.39898589f, 0.07084504f, 0.15360841f, 0.55253172f, 0.63207167f, -0.14841022f, -0.43480632f, -0.42678162f, 
    -0.39981446f, -0.01214166f, -0.13803500f, -0.21324667f, 0.12768772f, -0.03763180f, 0.19888951f, 0.14395201f, 
    0.09770069f, -0.10408162f, -0.00531051f, -0.17446014f, -0.26045874f, 0.11399728f, 0.11372824f, -0.77653539f, 
    -0.35592255f, 0.35909289f, 0.05917199f, 0.03926539f, -0.04892454f, -0.13998380f, 0.28867826f, 0.20553760f, 
    0.52751815f, -0.10176402f, -0.22360137f, 0.26151699f, -0.25477028f, 0.16493946f, -0.30250746f, -0.05554029f, 
    -0.01998227f, -0.14948265f, 0.20901775f, -0.05412495f, -0.12085218f, 0.30346030f, 0.07941635f, 0.23132659f, 
    0.18143702f, 0.45704949f, -0.32917008f, -0.44796547f, -0.66939110f, -0.23050821f, 0.42416152f, -0.03181068f, 
    0.45678240f, -0.04289039f, -0.31085351f, 0.06537954f, -0.27140093f, -0.32211745f, 0.00082505f, 0.29847375f, 
    -0.22059713f, -0.35866448f, 0.29222077f, 0.21408784f, -0.33563650f, -0.21114323f, 0.42033654f, -0.30510601f, 
    0.09047798f, -0.76470256f, -0.33946651f, -0.02285480f, -0.73319197f, -0.63529497f, 0.55300331f, -0.02474287f, 
    0.11079931f, 0.33611608f, 0.62985349f, 0.19787420f, -0.06957474f, 0.02708711f, -0.20436525f, 0.06215661f, 
    -0.36273161f, -0.25831637f, 0.08032647f, -0.10898332f, -0.06099426f, 0.01112779f, 0.07639325f, 0.37335169f, 
    0.06706391f, 0.26324376f, -0.58774722f, -0.34012872f, -0.07059614f, -0.42423218f, -0.36141166f, -0.12698485f, 
    0.05195599f, -0.18292141f, -0.06847522f, 0.03081302f, 0.06257920f, 0.14526518f, 0.21778236f, 0.28208789f, 
    -0.43377027f, -0.42583066f, -0.33772457f, -0.22159487f, 0.33950356f, 0.28446606f, -0.18717268f, 0.04754201f, 
    -0.00772874f, 0.06680133f, -0.12981644f, 0.25026011f, 0.19763798f, -0.37840435f, -0.36138958f, 0.31040058f, 
    0.04125579f, 0.05126283f, 0.01427192f, -0.12465413f, -0.21484080f, -0.14779435f, 0.32109132f, -0.00555386f, 
    0.08334468f, 0.08245219f, -0.26634809f, -0.06966309f, 0.25193489f, -0.26396525f, -0.33137864f, 0.12606350f, 
    0.05982798f, 0.07865371f, 0.33166319f, 0.22607476f, 0.19068141f, 0.56666446f, 0.49762306f, -0.22697863f, 
    -0.84374279f, -0.62457401f, -0.20787030f, -0.24653830f, -0.01422284f, 0.48490357f, 0.19070771f, -0.03490724f, 
    0.32400429f, -0.33429474f, 0.29008263f, 0.01086852f, 0.17074649f, 0.12583850f, -0.03656614f, -0.38582125f, 
    -0.14998171f, 0.34025824f, 0.05886848f, 0.03396545f, -0.02984619f, -0.35402259f, -0.41983202f, -0.32517177f, 
    0.23839493f, 0.21416354f, -0.59855372f, -0.62848711f, 0.16709700f, -0.08262987f, -0.41962707f, 0.25709668f, 
    -0.34047928f, -0.14231960f, -0.08964105f, 0.03799412f, 0.05570107f, -0.11701511f, -0.21736273f, -0.15420708f, 
    -0.23829824f, -0.42007017f, 0.23101887f, 0.06237257f, -0.39422423f, 0.46278948f, -0.43534151f, 0.46854690f, 
    0.29382518f, -0.52899414f, -0.20857775f, 0.05523884f, 0.32185730f, 0.21666852f, -0.09180032f, 0.03070746f, 
    -0.23871030f, -0.01653621f, -0.00471017f, 0.06616239f, 0.10969204f, 0.68611032f, -0.02760316f, -0.19363108f, 
    -0.40563694f, -0.20491004f, 0.02390561f, 0.52445191f, 0.04781368f, 0.01006066f, -0.15716548f, 0.38033995f, 
    -0.11427864f, 0.13329838f, 0.48254398f, 0.08654843f, -0.20354654f, -0.24001248f, -0.15800777f, -0.38992363f, 
    -0.44470376f, 0.02858206f, 0.09800361f, -0.20216818f, 0.21493760f, 0.18881918f, 0.00138342f, 0.43086711f, 
    0.27673483f, -0.15807739f, 0.29631355f, -0.26708731f, -0.21093564f, -0.28875390f, -0.01719138f, -0.03240713f, 
    0.17814316f, 0.37848032f, 0.15250392f, -0.18909428f, -0.25600219f, -0.09766349f, 0.09010117f, 0.15032403f, 
    -0.11592374f, -0.09649961f, -0.14169630f, -0.08448436f, 0.51380676f, -0.25875261f, -0.10441533f, 0.01579113f, 
    -0.15685688f, -0.04619209f, -0.19133069f, 0.24187201f, -0.07839945f, 0.15350497f, -0.21767052f, -0.00063572f, 
    0.24879038f, -0.35711604f, -0.32379958f, -0.24111153f, 0.06539281f, -0.63931149f, -0.35269260f, -0.38272393f, 
    -0.23500124f, -0.27052042f, -0.35642031f, 0.14946029f, -0.18621884f, -0.37482744f, -0.42517337f, -0.29990134f, 
    -0.43048775f, 0.04675474f, -0.01349348f, 0.01395050f, -0.16601047f, 0.11224763f, 0.19044930f, -0.05917393f, 
    0.37151074f, 0.24447259f, 0.32849249f, -0.30216867f, -0.17756855f, 0.32517120f, 0.40499315f, 0.02838197f, 
    -0.28768501f, -0.13992400f, -0.18670055f, 0.03222275f, -0.28818390f, 0.54139072f, -0.12924555f, -0.12398918f, 
    0.37909138f, -0.14825471f, 0.17915682f, -0.23552667f, -0.02927917f, -0.16456297f, -0.04824151f, 0.16428012f, 
    0.19200057f, -0.12889233f, 0.23298569f, -0.43960071f, -0.20546988f, -0.33745483f, 0.36477011f, 0.24120969f, 
    -0.37567183f, -0.40163314f, -0.25451866f, -0.11209158f, 0.26737115f, -0.22757567f, -0.42235970f, 0.26742905f, 
    -0.13920881f, -0.25987011f, -0.23016608f, -0.47381794f, -0.15199767f, -0.40483102f, -0.36769205f, -0.25923857f, 
    0.06915896f, -0.16074580f, -0.01923522f, -0.23942541f, 0.13268140f, 0.10448274f, -0.01113897f, 0.33120146f, 
    -0.24469227f, -0.55562615f, -0.26682779f, -0.25120771f, 0.50561565f, 0.31632560f, -0.09476208f, -0.40009907f, 
    0.03253699f, 0.51690614f, -0.11641083f, 0.19581009f, -0.21818361f, 0.06233322f, -0.01527397f, -0.19606002f, 
    -0.11095864f, 0.06720421f, -0.18696406f, 0.01735547f, -0.15793581f, -1.07408249f, -0.52615821f, -0.25471988f, 
    0.23866135f, -0.31312194f, 0.24114862f, 0.60075980f, 0.02059884f, 0.28631726f, -0.00339175f, 0.24912098f, 
    0.09281386f, 0.18264969f, -0.21808866f, -0.16638124f, -0.14498149f, -0.14354934f, -0.11605486f, -0.13204187f, 
    0.01942235f, -0.06461924f, -0.12302736f, -0.24350114f, -0.00119391f, -0.09791134f, -0.39408734f, -0.14153162f, 
    0.43571061f, 0.84869635f, 0.44661376f, -0.35730100f, -0.58902985f, -0.42335469f, -0.40038145f, -0.09067515f, 
    0.09360895f, 0.20453528f, 0.22203808f, -0.15990281f, -0.04718317f, 0.00656105f, -0.03420597f, 0.14003043f, 
    0.05171779f, -0.10736772f, 0.30097768f, -0.24720895f, 0.17829612f, 0.14572655f, -0.02763795f, -0.11181620f, 
    -0.18862426f, 0.12220593f, -0.50158805f, -0.54717809f, 0.14054547f, 0.24560463f, 0.28342611f, -0.01951191f, 
    0.17405310f, -0.32187551f, 0.18707941f, 0.06326694f, -0.02951630f, 0.01730012f, -0.35420758f, 0.32650480f, 
    -0.09646380f, -0.16079344f, -0.01058817f, 0.07258904f, -0.23019071f, -0.21206146f, -0.25758794f, -0.49765477f, 
    0.07319885f, -0.36345538f, -0.46891221f, -0.03000008f, -0.65021634f, -0.17211540f, 0.18906242f, 0.01072038f, 
    -0.04422075f, -0.17458634f, -0.33346313f, -0.00763204f, 0.26802954f, -0.31635037f, -0.17002793f, 0.25835121f, 
    0.07803228f, -0.16030709f, -0.06676963f, 0.03575233f, 0.00856154f, 0.02347589f, -0.05822813f, 0.32523990f, 
    0.45799392f, -0.29953092f, -0.13195862f, -0.43454781f, -0.16037752f, -0.08717413f, -0.36086160f, -0.43203342f, 
    -0.12497138f, 0.19293821f, 0.31009048f, -0.39289388f, -0.30074683f, 0.18454385f, -0.33836129f, 0.18402436f, 
    -0.11310215f, -0.07498283f, -0.08427662f, 0.17906816f, 0.27062535f, -0.06484433f, -0.32964528f, -0.12659696f, 
    -0.20860578f, -0.41508198f, 0.00059989f, -0.32253811f, -0.52057439f, -0.45071366f, 0.35993034f, -0.07241480f, 
    0.13949990f, -0.05010499f, 0.62341338f, 0.15086584f, -0.07377642f, -0.03670043f, 0.02926858f, -0.05950186f, 
    0.23218891f, -0.32507655f, -0.26116854f, 0.06171647f, -0.23155774f, 0.30579540f, -0.06561818f, 0.03978942f, 
    0.08129586f, 0.34266660f, 0.06741925f, -0.55519605f, 0.10390265f, 0.09586921f, 0.05347273f, 0.24430971f, 
    -0.32846662f, -0.71801591f, -0.24182086f, -0.47274932f, -0.60053915f, -0.05113089f, 0.84991217f, -0.39603537f, 
    -0.18132012f, 0.01525882f, -0.15184973f, 0.02971127f, -0.05917895f, 0.15027347f, -0.16698664f, -0.22930121f, 
    -0.01830646f, -0.04839006f, 0.17103802f, -0.16073151f, -0.10464959f, -0.42314082f, -0.42268547f, -0.42353743f, 
    -0.29328436f, -0.01258403f, -0.57437360f, -0.14271383f, -0.22782944f, -0.20060849f, 0.36022285f, 0.33442059f, 
    0.30052531f, -0.13861290f, -0.24214582f, 0.28044251f, 0.10317819f, 0.09122558f, -0.05272957f, -0.12136656f, 
    0.02870470f, 0.32275462f, -0.31998518f, -0.24707711f, 0.29191691f, 0.34885585f, -0.59566623f, -0.60552198f, 
    -0.43107525f, -0.63928777f, -0.02014246f, -0.07310591f, 0.32330739f, 0.46810237f, 0.25606191f, -0.19684570f, 
    -0.20475580f, -0.54348248f, -0.27208376f, -0.08057762f, -0.52606380f, -0.10571770f, -0.22408740f, -0.28166047f, 
    -0.23898759f, -0.03656862f, 0.06862745f, 0.06094045f, -0.23044308f, 0.11363682f, -0.97889149f, 0.54458767f, 
    0.12261885f, -0.10218585f, 0.31093988f, -0.68288314f, -0.04841338f, 0.27423716f, 0.34230533f, -0.28192323f, 
    0.48146969f, -0.21525545f, 0.23632292f, -0.28526154f, -0.00734280f, -0.07160521f, -0.03884832f, 0.16977367f, 
    -0.21417852f, -0.22429763f, -0.08728744f, 0.06513469f, -0.06642058f, -0.00341647f, 0.12713009f, -0.91728342f, 
    -0.59335339f, 0.48422089f, 0.49115586f, 0.50551456f, 0.17173825f, 0.57456535f, -0.55422735f, -0.60700411f, 
    -0.57479417f, -0.25261185f, -0.10114574f, -0.14597820f, -0.07820115f, -0.07481172f, -0.15759015f, -0.40117860f, 
    0.05277579f, 0.44173875f, 0.21716371f, -0.03092020f, -0.09279332f, 0.15730326f, -0.14609110f, -0.04044200f, 
    -0.57314026f, 0.18900137f, -0.16485487f, 0.51921028f, -0.28946581f, 0.19762744f, 0.13938215f, -0.09220736f, 
    -0.17613582f, 0.20579861f, -0.33987948f, 0.06183678f, -0.12169612f, 0.13352750f, 0.14671382f, 0.17986652f, 
    0.07560711f, -0.08542915f, 0.11344612f, 0.10212245f, -0.20633706f, -0.11999686f, 0.20648913f, 0.06272905f, 
    -0.12285870f, -0.24852452f, 0.02358456f, 0.16819894f, 0.17382771f, 0.07719881f, -0.00524475f, 0.00965390f, 
    0.17887920f, 0.00709642f, 0.22289416f, 0.31587270f, -0.23029216f, -0.05538366f, 0.03622635f, -0.23172940f, 
    -0.31462976f, -0.02219041f, 0.06622689f, 0.27571717f, 0.08194484f, -0.03445368f, -0.04045044f, -0.18136376f, 
    0.07059714f, -0.02691714f, -1.05213714f, -0.48016733f, 0.07823603f, 0.32098690f, 0.33300948f, 0.39090943f, 
    0.44396615f, 0.28001383f, 0.20666356f, -0.07120860f, 0.06473870f, 0.07336229f, -0.01660088f, 0.18852012f, 
    -0.26037568f, 0.24427342f, 0.29200795f, -0.30036429f, -0.19332720f, -0.30595064f, 0.22640751f, -0.02899437f, 
    0.04726438f, 0.04772088f, -0.00873787f, -0.43658870f, -0.48880377f, -0.15578103f, 0.48802027f, -0.10403137f, 
    -0.27456123f, 0.14178312f, 0.29843614f, 0.31590933f, 0.21542060f, 0.11506816f, -0.20357506f, -0.10739105f, 
    0.01024877f, -0.04746481f, -0.07451157f, -0.01824470f, -0.24728501f, -0.40590364f, 0.56107271f, -0.19330670f, 
    -0.21525191f, 0.18346918f, 0.01393455f, 0.09900445f, -0.71023625f, 0.00196422f, 0.58006978f, 0.66328800f, 
    -0.06613570f, -0.05274214f, -0.36334470f, -0.58430803f, -0.25995624f, -0.30956423f, -0.15824752f, -0.13676344f, 
    -0.44226983f, -0.11502756f, 0.07012658f, -0.03537123f, 0.22849719f, -0.03745683f, -0.08466599f, 0.31289417f, 
    0.34952444f, -0.16151905f, -0.03964989f, -0.40089953f, -0.41081238f, -0.21220487f, 0.28520888f, 0.08126369f, 
    -0.32877922f, -0.15454371f, -0.06509047f, 0.30113649f, 0.33774078f, -0.12507425f, 0.12515642f, -0.13217096f, 
    -0.21274693f, -0.07882367f, -0.08742709f, -0.22241642f, 0.09828644f, -0.43987474f, 0.22555070f, -0.06542758f, 
    -0.02143209f, 0.13899606f, 0.01346419f, 0.02492576f, -0.00877135f, 0.53391749f, 0.00230013f, -0.45821321f, 
    -0.71575910f, -0.63097364f, -0.36841795f, 0.02004081f, -0.21302383f, -0.19010641f, -0.00411553f, 0.18701220f, 
    0.04311981f, 0.13308935f, -0.03186798f, -0.21309718f, -0.13823755f, 0.10436767f, -0.08489329f, 0.17625485f, 
    0.14987999f, 0.28105631f, 0.04113598f, -0.34355929f, -0.33301726f, 0.09242746f, -0.37878940f, 0.60728300f, 
    0.70696610f, 0.31705162f, -0.36916229f, 0.02975316f, -0.24237838f, -0.41927952f, -0.00850232f, -0.01721871f, 
    -0.28879824f, -0.06412476f, -0.01450458f, 0.13555011f, -0.09426406f, -0.25857642f, 0.11825275f, -0.07855806f, 
    0.00136746f, 0.29470009f, -0.18290222f, -0.16655859f, 0.43224993f, -0.15293325f, -0.26681119f, -0.18480782f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03895874f, 0.13369869f, -0.04641182f, 0.23732445f, -0.03856755f, 0.36837110f, 0.11680834f, 0.13360126f, 
    -0.09701801f, 0.08772334f, 0.24662395f, 0.36524618f, 0.38774604f, 0.01060942f, -0.32004225f, 0.30674201f, 
    -0.14111601f, 0.17018250f, 0.11705531f, -0.02292269f, 0.32012501f, -0.12429219f, -0.04474297f, 0.20797916f, 
    0.12189069f, 0.31323916f, 0.07057481f, -0.32995448f, 0.47674179f, 0.00483904f, 0.24448629f, 0.14464191f, 
    0.07267785f, 0.45481035f, 0.17720445f, 0.14957079f, 0.24673370f, 0.16500857f, 0.05796158f, -0.13901961f, 
    0.25505736f, -0.16646880f, 0.10118119f, 0.16319959f, 0.45584884f, -0.02620287f, 0.17930675f, 0.02410473f, 
    0.02415732f, -0.08198114f, 0.36884099f, -0.10640334f, 0.24888390f, -0.31834316f, 0.14091292f, 0.08743332f, 
    0.11058831f, -0.09654372f, 0.01538367f, 0.17029445f, -0.29390901f, -0.08334140f, -0.20399638f, 0.25638971f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17222732f, 0.00046631f, -0.08345046f, -0.10033995f, 0.05104179f, -0.07275617f, -0.00973290f, -0.02808770f, 
    -0.02240903f, -0.00628104f, -0.01489094f, 0.01380417f, 0.15217257f, -0.04464999f, -0.22458503f, 0.13568245f, 
    0.07763534f, -0.02635235f, -0.00879233f, 0.00929208f, 0.00240733f, 0.05065884f, -0.16184066f, 0.07643148f, 
    0.35506788f, 0.15985861f, 0.01401571f, -0.25594497f, 0.02614730f, -0.01045014f, -0.15117741f, 0.04152962f, 
    0.02873533f, 0.08275392f, -0.04543808f, 0.02503819f, -0.08569372f, -0.25170261f, 0.13402799f, 0.14964449f, 
    0.02033375f, 0.05353445f, -0.22492175f, -0.05450945f, -0.02712049f, 0.06665152f, 0.00166004f, -0.08364447f, 
    -0.10276522f, 0.08541734f, 0.02043562f, 0.07971874f, -0.00939386f, -0.01995659f, 0.03828924f, -0.02467488f, 
    0.05443693f, 0.19013067f, 0.09161685f, 0.14614406f, -0.20014489f, -0.13018867f, -0.25944242f, 0.22040974f, 
    0.00355522f, -0.00441857f, 0.00454658f, -0.09911817f, -0.16549940f, -0.16750798f, -0.18853448f, -0.04638874f, 
    0.17362611f, 0.23715079f, -0.29612520f, -0.20331377f, -0.15813997f, 0.12484650f, -0.09396490f, 0.01724095f, 
    -0.02832865f, 0.07810192f, -0.14301324f, -0.15299998f, -0.16677742f, -0.05594954f, -0.16482112f, 0.05926566f, 
    0.02230280f, 0.00353546f, -0.09640710f, 0.01136670f, -0.03035207f, -0.01733055f, 0.03770418f, -0.02524777f, 
    -0.05714048f, -0.06808213f, 0.02016854f, 0.07407098f, 0.07645925f, 0.02342593f, 0.02401080f, -0.02081356f, 
    0.01933871f, 0.05478984f, 0.07802863f, 0.05236611f, 0.13150534f, -0.02131494f, -0.11603884f, 0.03298946f, 
    0.08196598f, -0.04926192f, -0.15576904f, -0.11449182f, 0.02643865f, -0.05286129f, -0.03724762f, 0.02013086f, 
    0.16300081f, 0.27991900f, -0.04845037f, -0.07195686f, -0.08330861f, -0.04534305f, 0.07111212f, -0.06380512f, 
    -0.10179234f, 0.01304833f, -0.14380735f, -0.13865727f, -0.15096958f, -0.20402677f, 0.10441729f, -0.20672792f, 
    -0.06457032f, 0.00564487f, 0.00284231f, 0.07418397f, -0.06753443f, -0.13948748f, -0.20634213f, -0.14341043f, 
    -0.11041983f, -0.39118707f, -0.68790841f, 0.15005991f, 0.00990165f, -0.09213104f, -0.03774077f, -0.07793739f, 
    -0.06908859f, -0.08111343f, -0.41750336f, -0.10025241f, -0.28579596f, 0.03485594f, 0.16133118f, -0.04473688f, 
    -0.05128999f, 0.10255035f, -0.04136169f, 0.17919336f, 0.11535803f, 0.06847442f, -0.08945719f, -0.09553710f, 
    0.24378799f, 0.20048031f, 0.09920799f, -0.08244050f, -0.16261591f, -0.05991238f, -0.09276629f, 0.01532699f, 
    -0.19331515f, -0.14189872f, -0.04633195f, 0.04858306f, 0.04333178f, -0.13434666f, 0.02437655f, -0.00401403f, 
    -0.14587472f, -0.10783712f, -0.03951379f, -0.08135526f, -0.02101669f, -0.02229710f, -0.01481845f, -0.09383052f, 
    0.32296720f, 0.27628943f, -0.32856116f, -0.14280288f, -0.00011713f, -0.11917160f, -0.16621165f, 0.07154522f, 
    0.02257765f, 0.00937520f, 0.00123723f, 0.01964564f, 0.12449734f, 0.13055839f, -0.17600425f, 0.04553814f, 
    0.09199408f, 0.00358029f, 0.02216640f, -0.10237018f, 0.01175512f, -0.09255620f, -0.09600826f, -0.00738985f, 
    -0.22958060f, -0.18541302f, -0.05966000f, -0.09640804f, -0.03206587f, -0.02836249f, -0.06039408f, 0.02404062f, 
    0.02133480f, 0.08453120f, 0.00546632f, -0.01315497f, 0.25196996f, -0.15736070f, -0.08085325f, -0.02659150f, 
    0.09013712f, 0.13788998f, -0.08332014f, -0.01784669f, 0.01956569f, 0.00337052f, 0.04683445f, 0.04538953f, 
    0.15814427f, 0.07783657f, -0.02672586f, -0.18959676f, 0.06721626f, 0.09822872f, -0.00097415f, 0.04399845f, 
    -0.11039466f, -0.14359243f, -0.14743081f, 0.03711778f, -0.12021267f, -0.24278523f, -0.30422595f, 0.07867889f, 
    0.01823999f, 0.01676067f, 0.03196413f, 0.05444373f, -0.02503691f, -0.01672767f, 0.01532931f, 0.06564558f, 
    -0.21248147f, -0.15446213f, -0.06937540f, 0.01624486f, 0.00767161f, -0.10013095f, -0.22778666f, -0.01979615f, 
    -0.01208874f, 0.03128537f, 0.04443546f, 0.12299008f, -0.31815177f, -0.50723636f, -0.47653592f, 0.13714752f, 
    0.00671724f, 0.06627145f, 0.07922012f, 0.03016149f, 0.10689487f, 0.03090470f, -0.02821266f, -0.06806339f, 
    0.16275713f, 0.11558460f, 0.04197976f, -0.23000494f, -0.05412202f, -0.07260184f, -0.13458925f, -0.00513987f, 
    0.08163332f, -0.04341061f, -0.18222639f, 0.01062724f, 0.32235590f, -0.14945516f, -0.24892583f, -0.10275961f, 
    -0.14644174f, -0.21558830f, 0.11805085f, -0.00980769f, -0.04809384f, -0.05561593f, 0.04469506f, 0.05790514f, 
    -0.08134201f, 0.01991020f, 0.05540748f, 0.04815526f, 0.10804220f, 0.05294078f, 0.02777685f, -0.06377888f, 
    -0.01115183f, 0.00084840f, 0.04565820f, 0.04816574f, 0.37132114f, 0.28616062f, -0.09871762f, -0.13715792f, 
    0.12272859f, 0.21775609f, 0.05121295f, 0.00587673f, -0.06280754f, -0.02949282f, 0.01581522f, -0.09422996f, 
    -0.66066682f, -0.10045288f, -0.03670731f, -0.14727759f, 0.00080159f, 0.03655980f, 0.01606098f, 0.02034871f, 
    -0.04025820f, -0.04269845f, 0.02036534f, 0.07017964f, 0.18207659f, 0.18842053f, -0.14923784f, -0.06924096f, 
    0.01908737f, 0.10032653f, -0.06267764f, 0.05914577f, -0.05049491f, -0.13238096f, -0.06347344f, 0.03042855f, 
    0.12280174f, -0.27440554f, -0.19046974f, 0.06089797f, -0.10883521f, -0.07806748f, -0.00610158f, 0.03150400f, 
    -0.14466421f, -0.01404663f, 0.03517754f, 0.02711137f, 0.06388801f, 0.02908985f, 0.28314450f, -0.18029477f, 
    -0.08471407f, 0.01436272f, 0.07359471f, 0.00913239f, -0.04132628f, -0.10882318f, -0.00314987f, -0.28265026f, 
    -0.18459338f, -0.07528611f, 0.03721042f, -0.14613432f, 0.08750701f, 0.10509709f, -0.08616365f, 0.09548073f, 
    0.06094320f, -0.02776871f, -0.05497170f, -0.10841337f, 0.06424446f, -0.11252036f, 0.03774117f, -0.10214612f, 
    0.06634420f, 0.11273909f, -0.03128850f, -0.03606473f, 0.00147365f, -0.08166118f, -0.11055126f, 0.00815273f, 
    0.21293581f, 0.14677100f, -0.04512129f, -0.14819649f, 0.06413139f, -0.15315858f, 0.00829371f, 0.03372907f, 
    0.02370997f, -0.00121329f, -0.02499570f, -0.02714478f, -0.08198703f, -0.02459451f, -0.18543600f, 0.07248876f, 
    0.05512430f, 0.07914399f, -0.08579994f, -0.10582197f, 0.03115313f, -0.03765723f, -0.08031274f, -0.17887017f, 
    0.08533228f, -0.12333740f, -0.00838556f, -0.20473900f, -0.15388857f, 0.00433424f, -0.08129892f, -0.15106924f, 
    -0.09891789f, -0.11158182f, -0.01622954f, 0.00168347f, 0.19472821f, 0.09627298f, 0.14724948f, -0.25452751f, 
    0.07016715f, 0.08705380f, -0.00981991f, -0.14741386f, -0.06124477f, 0.02287241f, -0.09474941f, -0.08389055f, 
    -0.20607151f, -0.02683101f, 0.04265232f, -0.04402343f, -0.00081208f, -0.04470883f, -0.06120654f, -0.02767572f, 
    -0.09667020f, 0.04077619f, 0.00209358f, -0.06173121f, 0.05428237f, -0.01659478f, 0.01618120f, -0.11931816f, 
    0.12152012f, -0.19677852f, 0.06657179f, 0.07612847f, 0.04385253f, 0.10310131f, 0.01599249f, 0.01245139f, 
    -0.12746741f, -0.55379808f, -0.16148221f, 0.03722652f, 0.04638274f, 0.02904714f, -0.00336655f, 0.03225734f, 
    -0.00965282f, -0.05774130f, -0.01300139f, 0.01036289f, 0.26547459f, 0.16833730f, -0.02452875f, -0.21619664f, 
    0.18079662f, 0.10371041f, 0.08839126f, 0.04845004f, -0.00294612f, -0.05910583f, -0.04949217f, -0.08556928f, 
    -0.36664048f, 0.26018229f, -0.01208833f, -0.12400200f, -0.12449683f, 0.07136696f, -0.01009475f, -0.02037415f, 
    -0.02185863f, 0.03032549f, 0.03296712f, -0.15303272f, 0.21905449f, 0.21175686f, 0.10075092f, -0.04624823f, 
    -0.10990722f, -0.09509111f, -0.08209624f, -0.20496438f, -0.11908606f, -0.13800554f, -0.07066349f, 0.05394631f, 
    -0.33870968f, -0.05295043f, 0.18275337f, -0.18808036f, -0.00649307f, -0.05861903f, -0.05251702f, 0.00604848f, 
    -0.00057847f, -0.28614685f, -0.05156671f, -0.14105137f, 0.27238554f, 0.22866341f, -0.11365096f, -0.10833446f, 
    0.09830343f, 0.01259461f, 0.07503770f, -0.05866903f, 0.01524441f, -0.06609139f, 0.03692167f, 0.05614616f, 
    0.06229950f, 0.33477503f, 0.01764317f, -0.13492081f, -0.02424512f, -0.00840220f, -0.19602589f, 0.10427713f, 
    -0.00328582f, -0.02089115f, -0.02312484f, -0.00715835f, -0.23407297f, -0.19726780f, 0.04987857f, 0.05167723f, 
    0.05514013f, 0.05209101f, -0.01785877f, -0.03859801f, -0.01639175f, 0.12639402f, -0.02209491f, -0.02369426f, 
    0.14418125f, 0.08568714f, -0.08369383f, -0.01380106f, 0.04505319f, -0.06566779f, 0.09035994f, 0.05085423f, 
    -0.05258990f, -0.06315752f, 0.02167398f, 0.00167456f, 0.04687994f, 0.20190117f, 0.05161340f, -0.03886874f, 
    0.13182457f, 0.14606743f, 0.09250354f, 0.00912906f, -0.04713248f, -0.07723892f, -0.05821930f, 0.12457407f, 
    0.01475314f, 0.02014378f, -0.08009707f, -0.01992858f, -0.02673006f, 0.07705024f, -0.11434423f, -0.03139929f, 
    -0.03728738f, -0.20561875f, -0.08519048f, -0.02951159f, 0.20589907f, 0.21954209f, -0.08554626f, -0.08372284f, 
    0.08979238f, 0.04112807f, -0.04038180f, 0.08604228f, 0.02350862f, 0.01834918f, -0.04328433f, -0.04860709f, 
    0.30996239f, 0.13296258f, -0.13018639f, -0.22573589f, -0.02666654f, -0.02001357f, -0.00077257f, -0.11334450f, 
    0.05373263f, -0.00556241f, 0.04722133f, 0.01244294f, 0.24865390f, -0.01426555f, 0.04320770f, -0.00577732f, 
    0.10440516f, 0.06424765f, -0.15312622f, -0.10491285f, -0.03696879f, 0.07072697f, 0.05861778f, 0.10441045f, 
    -0.40718517f, -0.02171716f, 0.45735678f, -0.10224558f, -0.18561545f, 0.14005941f, 0.02469420f, 0.06724062f, 
    -0.04532889f, -0.04914449f, 0.05448690f, -0.11036247f, 0.54999620f, 0.15520564f, -0.08061958f, -0.17032984f, 
    0.05928789f, -0.11850239f, 0.17924836f, -0.05270415f, -0.09191346f, -0.06376857f, 0.02050890f, 0.04803875f, 
    0.04607743f, -0.08174382f, -0.00726189f, -0.01221474f, -0.01167515f, -0.00175947f, -0.15516287f, -0.16527985f, 
    -0.12511846f, 0.00279794f, 0.02670664f, 0.01955013f, -0.03242173f, 0.02790479f, 0.07459681f, 0.01967435f, 
    0.03532632f, 0.01409782f, 0.05656469f, 0.03598755f, 0.07969451f, -0.02636399f, 0.00936508f, 0.08298593f, 
    0.07250581f, -0.06905172f, 0.00707405f, 0.01252709f, -0.01548347f, 0.01441882f, 0.09291466f, 0.05683636f, 
    -0.28917655f, -0.11382899f, -0.27789494f, -0.11589783f, 0.18066847f, -0.01635469f, 0.09097083f, -0.12981763f, 
    0.00212271f, 0.03971940f, 0.03629959f, 0.05063073f, -0.00279786f, -0.18558270f, 0.01574243f, -0.11855277f, 
    0.35950431f, 0.18623975f, 0.01152512f, -0.21244746f, 0.05569164f, 0.11996254f, 0.08100975f, 0.10546035f, 
    -0.01707940f, 0.01080198f, -0.05570753f, 0.03584282f, -0.07207499f, -0.04993121f, 0.08597990f, 0.17507569f, 
    -0.02621160f, 0.00072894f, -0.01156160f, 0.03815500f, -0.00890351f, 0.00025480f, 0.03686221f, -0.09535712f, 
    0.29412797f, 0.17666176f, -0.14035136f, -0.01167656f, 0.26564777f, 0.20946474f, 0.13394061f, 0.05875879f, 
    0.02347599f, 0.04968178f, 0.07638405f, 0.08050848f, -0.42919523f, -0.29685354f, -0.25398478f, 0.21146046f, 
    0.04388906f, 0.01431074f, -0.05164339f, 0.01776447f, -0.04983610f, 0.03971232f, 0.02858382f, -0.00055745f, 
    0.15205555f, -0.06394936f, 0.18347989f, -0.24930504f, -0.12860505f, -0.19238153f, -0.09354278f, -0.00951740f, 
    -0.04674856f, 0.02977082f, -0.01388510f, 0.06511058f, 0.27173895f, -0.12618396f, -0.19436079f, -0.02242688f, 
    -0.08106108f, 0.02547176f, -0.08895911f, -0.07127451f, 0.04100181f, -0.10896175f, 0.02470795f, -0.04608994f, 
    0.00493939f, 0.07109582f, 0.02062768f, -0.01643951f, -0.10167149f, -0.14860733f, 0.31967950f, 0.02025946f, 
    0.03876714f, -0.00798702f, 0.06152216f, 0.01009040f, 0.40355283f, -0.19864380f, 0.05182884f, -0.23493992f, 
    0.02104829f, -0.08744198f, 0.06724612f, -0.04886197f, 0.10666876f, 0.00951072f, -0.23655558f, -0.03172287f, 
    -0.10024297f, -0.00967580f, 0.06799017f, -0.13764401f, 0.09661591f, 0.05512279f, -0.16409726f, 0.04669588f, 
    -0.11663118f, -0.26846772f, -0.02866497f, -0.24179623f, 0.29284650f, -0.22926573f, 0.14064384f, -0.12196005f, 
    0.00069822f, 0.02414027f, 0.07111516f, 0.05961772f, 0.09602553f, -0.06488381f, -0.02415426f, 0.02174382f, 
    0.24848899f, -0.00413366f, -0.07278810f, -0.29894510f, 0.00307514f, -0.28617221f, 0.01957006f, 0.08995056f, 
    -0.04279407f, 0.04491822f, -0.01965123f, 0.01526488f, 0.21705380f, 0.09552284f, -0.02705956f, 0.02158798f, 
    0.01749617f, -0.08620735f, -0.08108113f, 0.01756528f, 0.01668895f, 0.07771289f, -0.01586045f, -0.01716601f, 
    0.12299568f, 0.09536974f, 0.08057266f, 0.08236834f, -0.05573820f, -0.06138199f, -0.05318871f, -0.00778843f, 
    -0.00590610f, 0.03033544f, -0.02571450f, 0.03066902f, 0.07186895f, -0.01185706f, 0.02882705f, -0.04834131f, 
    0.12956470f, 0.02126919f, 0.06731555f, 0.00358763f, -0.05078140f, 0.05361841f, -0.01730014f, -0.01108481f, 
    0.25578174f, -0.06331775f, -0.25570717f, -0.04286768f, -0.07983314f, 0.16496357f, 0.16685422f, 0.01741374f, 
    -0.05967382f, -0.09976715f, 0.16342352f, 0.01858641f, -0.22453910f, 0.03168774f, 0.13575190f, -0.08245426f, 
    0.03191581f, 0.01998985f, 0.04109302f, -0.03096126f, 0.17285247f, 0.06316141f, 0.07705900f, 0.27007768f, 
    0.79329133f, -0.01833419f, -0.07494005f, -0.05811593f, -0.05653243f, -0.05871030f, 0.05570240f, 0.01339192f, 
    0.07832135f, 0.08679364f, 0.00016093f, 0.11612438f, -0.25059524f, -0.03317321f, -0.02633043f, -0.09743738f, 
    0.06254986f, 0.00229067f, -0.23087096f, 0.06802779f, -0.14661802f, 0.01482640f, -0.03320812f, -0.07414236f, 
    -0.04054408f, 0.05200602f, -0.05228394f, -0.11824279f, 0.02946079f, -0.05478174f, -0.04088680f, 0.34650230f, 
    -0.01881122f, -0.06838015f, -0.10636204f, 0.01685204f, 0.09306334f, 0.01692010f, 0.03962017f, 0.02811440f, 
    0.03253895f, 0.04991001f, 0.04049374f, -0.10819230f, -0.07328902f, 0.13794881f, -0.04800838f, 0.00181393f, 
    -0.00606738f, 0.02306336f, 0.16802250f, 0.13696814f, -0.13854136f, 0.03045253f, -0.03710398f, -0.01370459f, 
    -0.03931557f, -0.05033416f, 0.01938424f, 0.07870482f, 0.01601485f, -0.06198980f, -0.08015649f, -0.10862153f, 
    0.00058087f, 0.01320783f, 0.04929300f, 0.11164485f, -0.02100439f, -0.03941085f, 0.10401857f, 0.00946371f, 
    0.15472098f, 0.05993584f, 0.00908872f, -0.01760704f, -0.03759803f, -0.05862362f, 0.10237339f, -0.14225289f, 
    -0.04429043f, 0.05864154f, -0.02089021f, 0.07073817f, 0.04655022f, 0.17181097f, -0.11627720f, -0.06658930f, 
    -0.03297761f, 0.04224917f, -0.02302678f, -0.30026397f, -0.02043224f, 0.03195916f, -0.08065143f, -0.08244007f, 
    -0.52423871f, -0.25016627f, -0.31322011f, -0.05580648f, 0.00018443f, 0.01242758f, 0.07273827f, 0.05240378f, 
    -0.22002710f, 0.08943960f, 0.06400342f, 0.01847157f, 0.20073868f, 0.24045184f, 0.09708732f, 0.19769335f, 
    -0.02198941f, -0.00839526f, -0.01075062f, -0.04674127f, 0.02206532f, 0.00217558f, 0.05375013f, -0.01414634f, 
    0.08422162f, -0.04681666f, 0.04803488f, -0.19084097f, 0.00048791f, -0.02807645f, -0.09124215f, 0.01438492f, 
    -0.03510159f, -0.12201771f, 0.03718678f, -0.04999088f, 0.85610622f, 0.22533673f, 0.40415448f, 0.04358196f, 
    0.00765910f, 0.01351797f, -0.04979821f, -0.01324667f, -0.03639439f, 0.07710398f, -0.09774032f, -0.18231492f, 
    -0.12674828f, -0.02576668f, -0.11134619f, -0.06903984f, -0.04132449f, 0.01665924f, 0.08772475f, 0.18946674f, 
    -0.07279460f, -0.21354692f, 0.12671462f, 0.01843730f, 0.04912126f, -0.17560333f, -0.09099254f, 0.16273816f, 
    -0.05084293f, 0.08031236f, -0.04307486f, 0.13251813f, 0.07482222f, -0.07014722f, -0.06821773f, 0.02283718f, 
    0.13620164f, -0.00544732f, -0.07539245f, -0.01975570f, 0.02468514f, 0.00180750f, 0.00875761f, -0.25924787f, 
    0.11552412f, 0.01036513f, 0.04663273f, 0.04347572f, 0.62504631f, 0.22742221f, 0.13718906f, 0.23303753f, 
    0.03561787f, -0.06162927f, -0.00639176f, 0.00830539f, 0.03513355f, -0.01395530f, -0.02750530f, -0.12797777f, 
    0.20600238f, 0.26461613f, 0.16191234f, 0.13313140f, -0.02977904f, -0.01718094f, 0.03230280f, -0.08445760f, 
    0.05132674f, -0.04440732f, 0.00670180f, 0.01073426f, 0.01873074f, -0.13495249f, 0.06276060f, 0.29471362f, 
    0.04993159f, 0.14322688f, -0.01904825f, 0.24393317f, -0.00169627f, 0.06993814f, 0.00372040f, 0.06856179f, 
    0.71577108f, -0.18534736f, -0.02980557f, 0.22111200f, -0.02260350f, -0.02489313f, 0.01303850f, -0.18280442f, 
    0.16490190f, -0.00195020f, 0.01000005f, 0.04159159f, -0.25333261f, 0.19623543f, -0.11467455f, -0.14710951f, 
    -0.06757654f, 0.07289425f, 0.03166310f, -0.03250124f, -0.00181158f, 0.10610983f, -0.00547409f, 0.12011069f, 
    -0.01585788f, 0.08713318f, 0.01492988f, -0.15578946f, -0.07803212f, 0.06098003f, -0.05982607f, -0.20869847f, 
    -0.03155851f, 0.04447968f, -0.05901868f, -0.14656782f, -0.07479338f, 0.18696421f, -0.20586164f, -0.44132164f, 
    -0.02259612f, 0.04141211f, -0.02412497f, 0.10590345f, -0.10481951f, 0.07460859f, 0.00461801f, -0.06869844f, 
    0.05066351f, -0.07740439f, -0.02493479f, 0.01582915f, -0.05998425f, 0.13035922f, 0.07038385f, -0.05418130f, 
    0.01184024f, -0.06182364f, 0.08071804f, 0.05557759f, 0.05259441f, -0.01423804f, -0.00305249f, 0.01264360f, 
    -0.06469297f, 0.11739156f, 0.10843698f, 0.09049038f, -0.01148168f, -0.00290983f, -0.02568160f, 0.02230382f, 
    -0.02778616f, -0.07815376f, 0.18238956f, -0.29276288f, 0.07233230f, 0.07539327f, -0.16295302f, 0.05714403f, 
    -0.06161533f, 0.03151927f, -0.02382501f, -0.01536075f, -0.27014396f, 0.22828276f, -0.27217129f, -0.20862998f, 
    0.04556299f, 0.07846061f, 0.21474732f, -0.14891067f, -0.01307495f, 0.06301638f, 0.01333534f, 0.02866322f, 
    0.02344990f, -0.20236707f, 0.17030211f, 0.03241197f, 0.00007610f, 0.03671028f, -0.02395459f, 0.03224782f, 
    -0.09436146f, -0.04994218f, 0.00951704f, -0.00806858f, -0.07820804f, 0.05131072f, -0.03558174f, -0.07616948f, 
    -0.04447242f, 0.02106061f, -0.05065234f, -0.12047895f, 0.05228356f, 0.06064615f, -0.04713313f, 0.08012901f, 
    0.32256854f, -0.06603863f, 0.07831737f, 0.06658685f, -0.01419654f, -0.01601155f, -0.00993916f, -0.01055304f, 
    0.01213193f, -0.02459192f, -0.05542014f, 0.01191122f, 0.12432969f, 0.18829532f, 0.10056680f, -0.00338735f, 
    0.11325286f, -0.06792653f, -0.02662400f, 0.13143282f, -0.04673179f, -0.03242475f, -0.07220545f, 0.03362763f, 
    0.09442724f, 0.05776256f, -0.18882856f, 0.05123301f, -0.03900271f, 0.02900174f, 0.04094154f, 0.07629147f, 
    -0.05252372f, 0.04396619f, -0.07201172f, 0.03569088f, -0.11901793f, -0.01200277f, -0.18730715f, 0.09224627f, 
    0.08780718f, 0.02153980f, 0.02179224f, 0.02002298f, 0.04193485f, 0.02399268f, -0.15549465f, -0.23784888f, 
    -0.20724514f, 0.06526627f, -0.03729941f, 0.00644105f, 0.10655072f, 0.00006837f, 0.00087819f, 0.04688513f, 
    0.16401835f, -0.00757538f, 0.04056372f, -0.07261999f, 0.13925076f, -0.39879003f, -0.34609047f, -0.06557862f, 
    -0.04756895f, -0.04458977f, 0.02035916f, -0.03407328f, 0.01213141f, -0.06270545f, -0.10523441f, -0.08376788f, 
    -0.28956890f, 0.22071068f, -0.13154927f, 0.06221623f, -0.15741257f, -0.10572508f, 0.05013333f, 0.07106279f, 
    -0.06339575f, -0.01408887f, 0.03110701f, 0.00321000f, 0.02729814f, -0.14322673f, 0.03986447f, -0.15266843f, 
    -0.00095655f, 0.02045768f, -0.07451159f, -0.07376218f, -0.06137142f, -0.20153166f, -0.15223436f, -0.24889839f, 
    0.22636777f, 0.19021589f, -0.02804049f, -0.01873844f, 0.03819578f, 0.17631492f, 0.19963174f, 0.04005929f, 
    0.00893590f, -0.06960072f, -0.04722860f, -0.06190310f, 0.01121522f, 0.07969376f, -0.05203934f, 0.12528802f, 
    -0.09006340f, -0.01219684f, -0.11142308f, -0.25947398f, -0.04133157f, -0.05003176f, 0.02386376f, 0.08055408f, 
    -0.16353542f, 0.11173946f, -0.08250367f, -0.00891966f, -0.02193740f, 0.05289230f, 0.08024400f, 0.00748373f, 
    -0.01433304f, 0.17524138f, -0.04880585f, -0.12124561f, -0.09236201f, -0.24458794f, -0.31448272f, 0.05170672f, 
    -0.22808328f, -0.09018792f, -0.14492512f, 0.26920736f, -0.02286029f, 0.08081353f, -0.03727429f, 0.04479305f, 
    -0.11273244f, 0.05068053f, -0.03538231f, 0.03211427f, -0.10434859f, 0.11252443f, -0.18439049f, -0.15257330f, 
    -0.03686225f, -0.00310349f, -0.05217808f, 0.02083004f, 0.18439309f, 0.30273658f, -0.16133712f, -0.18571880f, 
    0.00227847f, 0.01947684f, -0.02332680f, 0.05070266f, 0.01946435f, 0.04837354f, -0.20798551f, -0.12836716f, 
    -0.76313657f, -0.35904029f, -0.20299423f, -0.13126065f, 0.00071410f, 0.05816145f, -0.06683726f, 0.02340082f, 
    0.06400919f, 0.13586473f, -0.11908954f, 0.04981812f, 0.07125585f, -0.47679606f, -0.02731330f, -0.30570346f, 
    -0.07040472f, 0.00742619f, 0.11555300f, 0.01358804f, 0.11543994f, 0.03413085f, 0.08655403f, -0.07203972f, 
    -0.05199506f, 0.05021552f, 0.01477186f, 0.01638902f, 0.03248918f, -0.00609857f, -0.09138682f, -0.02388791f, 
    0.12146576f, -0.00176464f, -0.02221152f, -0.07052917f, 0.09811077f, 0.06750790f, 0.03734154f, 0.05512867f, 
    -0.00706668f, 0.01545084f, 0.02039072f, -0.00737654f, 0.13774444f, -0.07277688f, 0.03729022f, 0.01862611f, 
    0.03309727f, -0.11965401f, 0.10539966f, 0.11293851f, -0.09488119f, -0.02013897f, 0.02121354f, 0.00020431f, 
    0.05500995f, -0.18092826f, 0.00092132f, -0.00852063f, -0.07910461f, 0.11746456f, -0.03451907f, -0.00690717f, 
    -0.02623964f, 0.01822965f, 0.01501464f, -0.08041804f, -0.01544888f, -0.14756072f, -0.13729043f, 0.17634112f, 
    -0.34992877f, 0.04744106f, -0.16178311f, -0.64683259f, 0.04338014f, -0.17489809f, -0.16723733f, 0.14322038f, 
    0.06625272f, -0.00405556f, -0.00853994f, -0.06054565f, 0.01056304f, -0.01908856f, 0.07098617f, -0.05766384f, 
    -0.08937356f, 0.03643971f, 0.03630328f, -0.07619517f, 0.00745860f, -0.00430927f, -0.02302820f, -0.05051427f, 
    0.26169685f, 0.11796819f, 0.13869868f, 0.09899631f, -0.16808043f, -0.09656996f, -0.28291494f, -0.15121189f, 
    0.06823111f, -0.10420553f, 0.02411268f, -0.05911764f, 0.17135364f, 0.04044301f, 0.16855462f, 0.06003374f, 
    0.00058983f, -0.06567243f, -0.02958032f, 0.00948683f, -0.07692408f, 0.01252652f, 0.03886825f, 0.04805321f, 
    -0.45280731f, -0.34580415f, 0.09215858f, -0.53571969f, -0.08095072f, 0.00374953f, -0.02535260f, -0.26562285f, 
    -0.00427112f, -0.08008913f, 0.02873362f, -0.04511534f, -0.17117734f, 0.27612302f, 0.22909884f, -0.08000812f, 
    -0.02503713f, -0.02363364f, 0.07273085f, -0.18073542f, 0.15513037f, -0.01318457f, 0.17053710f, 0.03444032f, 
    -0.14226891f, -0.12001913f, -0.07090601f, -0.17054945f, -0.10528647f, -0.14297400f, 0.14498383f, -0.17553632f, 
    -0.02232174f, -0.02451518f, 0.03530122f, 0.00995332f, 0.06205714f, 0.04428691f, 0.08983431f, -0.69555205f, 
    0.00710123f, -0.08620095f, -0.05105307f, 0.10078704f, 0.03001411f, 0.05060893f, -0.01316085f, 0.02004885f, 
    0.14541501f, -0.03522995f, 0.03295811f, -0.01649313f, 0.06152366f, 0.00018249f, -0.10791416f, -0.11560559f, 
    0.12832987f, 0.21628977f, 0.12238298f, 0.11518435f, 0.02535141f, 0.00894778f, 0.09047995f, 0.03633440f, 
    -0.02981962f, 0.02310793f, 0.02456897f, 0.03729561f, -0.08928927f, 0.03492170f, -0.15347616f, 0.05478958f, 
    -0.02491470f, 0.04420961f, 0.22065704f, 0.12534052f, 0.07433455f, -0.10483797f, -0.06910459f, 0.07206801f, 
    0.08115692f, 0.03983522f, -0.15223494f, 0.08479461f, 0.00456653f, -0.01024635f, 0.10432927f, -0.23184228f, 
    0.01179662f, 0.00773908f, -0.01786143f, 0.05463087f, 0.01761581f, 0.01450550f, -0.04480894f, 0.06110490f, 
    -0.02915450f, 0.04486023f, -0.16923700f, -0.08942814f, -0.02721106f, -0.05179278f, 0.01944371f, 0.05832346f, 
    0.01464410f, 0.03325398f, -0.00697976f, 0.02844046f, -0.05146050f, 0.02304890f, 0.04156207f, 0.00255102f, 
    -0.27788565f, 0.10009696f, -0.03735917f, -0.10920671f, 0.00450766f, -0.07052503f, -0.00278419f, -0.05796051f, 
    0.02631034f, -0.31680959f, 0.08487114f, 0.10491330f, 0.06458240f, -0.08727620f, -0.02435027f, 0.02187108f, 
    0.06088223f, -0.11096521f, 0.01676249f, 0.00385674f, 0.04185589f, -0.07514493f, -0.30832657f, 0.09158636f, 
    -0.00609096f, 0.06152000f, 0.04837771f, -0.08884939f, 0.01993822f, 0.01441586f, -0.12565269f, 0.17188823f, 
    -0.39266294f, 0.40292752f, 0.20920357f, -0.14616087f, -0.00308011f, -0.01410032f, 0.00241525f, -0.04591091f, 
    0.02271073f, -0.02248144f, -0.01626683f, 0.08116446f, 0.34431437f, 0.03734025f, -0.11924119f, 0.17639631f, 
    0.00505389f, 0.05564345f, -0.01965950f, -0.11379373f, -0.01318643f, -0.08039261f, -0.05299216f, 0.06384508f, 
    -0.60277373f, 0.03190247f, -0.13765118f, -0.12511967f, 0.00344547f, 0.03820442f, 0.08904925f, -0.30175450f, 
    -0.02135538f, -0.00169766f, -0.04106240f, 0.05270447f, -0.01075120f, 0.02183612f, 0.00625696f, -0.00072760f, 
    -0.00169490f, -0.01088444f, 0.06808794f, -0.17538700f, 0.01776216f, 0.02403121f, -0.00469072f, 0.02665501f, 
    -0.76279593f, -0.72432184f, -0.37912488f, -0.38429421f, -0.00322749f, -0.16603337f, 0.12614398f, -0.14735761f, 
    0.02618720f, -0.00615299f, 0.04265159f, -0.03658126f, 0.08594953f, -0.05908891f, 0.20519368f, 0.04541480f, 
    -0.00440523f, -0.00681774f, -0.02377484f, 0.01744051f, -0.12166763f, 0.00075999f, 0.15198900f, -0.02790894f, 
    -0.30448195f, -0.29489559f, 0.03255251f, 0.21682452f, -0.01246051f, -0.04790311f, 0.02853497f, -0.07227503f, 
    0.00774832f, -0.01442428f, -0.01092855f, 0.05311390f, -0.17014425f, 0.53451073f, 0.36782697f, 0.19191889f, 
    -0.08034030f, 0.00305345f, 0.04051437f, 0.05869552f, 0.01691650f, 0.06267118f, -0.06139125f, 0.08032797f, 
    0.19186771f, 0.05160091f, 0.18630527f, 0.19941106f, 0.10292796f, -0.06483237f, 0.14502048f, -0.05632480f, 
    0.05883577f, -0.01192569f, -0.03311246f, -0.00782527f, -0.24812976f, -0.30616876f, 0.25068817f, -0.24522159f, 
    -0.01802166f, -0.00699532f, 0.01396227f, 0.06361288f, 0.00222724f, 0.00756006f, -0.00814315f, 0.02271086f, 
    -0.13370496f, -0.03774486f, 0.09062593f, -0.08912428f, 0.00335666f, -0.06947444f, -0.01306736f, -0.14965275f, 
    0.05405818f, -0.18531135f, 0.00147504f, -0.02004038f, -0.07313448f, 0.01396035f, 0.07196841f, 0.03281708f, 
    -0.02414039f, -0.04482930f, 0.05060314f, -0.03818614f, 0.02740685f, 0.06563670f, 0.07157082f, 0.13037109f, 
    -0.01531153f, 0.00647223f, -0.07064082f, 0.14227669f, 0.04489265f, 0.04795093f, -0.02975741f, -0.00841501f, 
    0.10171606f, 0.10775340f, -0.03073131f, 0.04199625f, -0.03639185f, 0.14035089f, -0.11181686f, -0.02011331f, 
    0.02598698f, -0.00550946f, 0.01726397f, 0.04144701f, 0.06490675f, 0.07914815f, -0.01004013f, -0.04871344f, 
    -0.01084815f, 0.02511416f, 0.20814463f, 0.04197168f, -0.04489218f, 0.09653293f, 0.10519084f, -0.09115797f, 
    0.06901860f, 0.10140122f, 0.12483731f, -0.04612055f, -0.00785628f, -0.27272767f, 0.68273985f, 0.65210903f, 
    -0.04999590f, -0.01884770f, -0.08900609f, 0.10705383f, 0.03061325f, -0.01087711f, -0.04017591f, 0.04556679f, 
    -0.17152174f, 0.16436505f, -0.10690055f, 0.11764768f, -0.01822296f, 0.00055208f, -0.00227515f, 0.02275203f, 
    -0.03280381f, 0.06897970f, -0.02174528f, 0.02630180f, 0.08781559f, -0.22007459f, -0.03964575f, 0.02262648f, 
    0.01259811f, -0.00627871f, -0.00470096f, -0.20076963f, -0.02710433f, -0.01553457f, 0.01815362f, 0.00437457f, 
    -0.18734218f, 0.09816524f, 0.09501074f, -0.14550795f, 0.05292221f, -0.03899452f, -0.00607581f, -0.06406204f, 
    0.08901150f, 0.01878871f, -0.05636503f, -0.07732346f, 0.10803950f, -0.02299713f, -0.11880856f, 0.03686230f, 
    0.02227630f, 0.02173536f, -0.03272500f, 0.01290014f, 0.00672804f, -0.02422714f, -0.06160816f, -0.10257627f, 
    0.01214852f, 0.30178443f, 0.08659957f, -0.04078200f, -0.02095882f, -0.04032327f, -0.03246022f, -0.01685674f, 
    -0.00541013f, 0.02768598f, -0.17977336f, 0.06309801f, 0.05451427f, 0.32724988f, 0.15235327f, 0.24865361f, 
    0.03903647f, 0.06970615f, -0.02420671f, 0.03942743f, -0.02112395f, 0.00495791f, -0.02360902f, 0.00179576f, 
    0.18181470f, 0.16915067f, -0.01016930f, 0.23184365f, -0.04630897f, -0.05094129f, -0.03358613f, 0.18439344f, 
    0.01566636f, -0.07768976f, 0.07044800f, -0.03739431f, -0.18061133f, -0.26354465f, 0.04454206f, 0.01045669f, 
    -0.08840699f, -0.04472725f, -0.04396724f, -0.04255995f, -0.01717043f, 0.00971245f, -0.05623071f, -0.06774393f, 
    -0.14530148f, -0.20043361f, 0.17133366f, 0.04184596f, 0.07393397f, -0.05254695f, -0.19563116f, 0.05274164f, 
    0.09476407f, 0.01313245f, -0.08311821f, 0.08836442f, -0.30711675f, 0.09404990f, -0.34375277f, 0.15318356f, 
    0.05413396f, -0.04963797f, 0.01762882f, -0.04274166f, 0.01118448f, -0.05046406f, -0.01103230f, 0.06555372f, 
    0.24162172f, -0.27974129f, -0.00071549f, 0.13202304f, 0.09805610f, -0.05618697f, -0.07621723f, -0.01118526f, 
    -0.04434255f, -0.29367208f, -0.06960102f, 0.18797162f, -0.08030301f, 0.02377897f, -0.05202686f, -0.08494461f, 
    -0.12523907f, -0.20668532f, -0.09304050f, -0.10977445f, 0.09786374f, 0.01751779f, 0.01085218f, 0.05029878f, 
    0.03966787f, -0.02987628f, 0.07041271f, -0.16149679f, 0.02686548f, 0.02664640f, 0.01011206f, 0.06556998f, 
    -0.04514384f, -0.03799317f, 0.00655393f, -0.04639450f, -0.82897890f, -0.03957933f, -0.12076357f, -0.34029308f, 
    0.03384215f, 0.08191311f, 0.05205313f, 0.03374933f, -0.05523869f, -0.03958423f, -0.02067197f, -0.01300806f, 
    -0.25107265f, -0.15964314f, -0.14697674f, 0.02449583f, -0.17918874f, -0.01840762f, 0.00384007f, -0.02256086f, 
    0.02538674f, 0.02142848f, -0.08491475f, 0.01531978f, -0.04181609f, 0.06064314f, 0.00707333f, 0.07444198f, 
    0.03302303f, -0.02192980f, -0.04426366f, 0.06893203f, -0.06818283f, -0.10690709f, 0.10974267f, -0.06798545f, 
    -0.10290148f, 0.02889826f, -0.05970602f, 0.13416576f, -0.02833059f, 0.04918857f, 0.00355491f, -0.04354462f, 
    0.02764382f, -0.17073591f, 0.08506969f, 0.03997166f, 0.18726537f, 0.01790069f, 0.13777101f, 0.08028688f, 
    -0.02877803f, -0.03028807f, 0.01405433f, 0.05007974f, -0.10466922f, -0.00345783f, 0.15938845f, -0.06094586f, 
    -0.19203836f, 0.01144311f, -0.05698197f, -0.05638213f, -0.00479899f, -0.19321084f, -0.01048463f, 0.05320825f, 
    0.00095748f, -0.04112651f, 0.02227362f, -0.00677997f, 0.18293059f, 0.13497826f, 0.05591654f, 0.06142670f, 
    -0.03760574f, -0.01904020f, 0.07996952f, -0.10030676f, 0.14042206f, 0.18439472f, 0.02044256f, 0.13510606f, 
    0.05409551f, 0.10105601f, 0.10984057f, -0.05826077f, -0.18320197f, 0.01835361f, 0.21830864f, -0.14075023f, 
    -0.03417356f, -0.03409264f, -0.00605510f, 0.05889135f, -0.19584610f, -0.07092909f, -0.02695340f, 0.28632578f, 
    0.01819430f, 0.08694267f, 0.01876413f, -0.01323701f, -0.04242904f, 0.06032125f, 0.01386230f, -0.13732386f, 
    -0.07233185f, 0.04257257f, 0.08597513f, 0.14025515f, -0.01094499f, -0.03571273f, 0.07256813f, -0.14131370f, 
    -0.10248963f, 0.10156938f, -0.09404451f, -0.13297005f, -0.46283993f, -0.17553516f, -0.17820868f, -0.22689953f, 
    0.12465258f, -0.02309245f, 0.05115588f, -0.00156429f, -0.03593890f, -0.09177118f, -0.04507682f, 0.00296245f, 
    -0.05787999f, 0.03626673f, -0.21826655f, 0.03112036f, 0.03750116f, 0.06547161f, -0.06823135f, 0.03718502f, 
    0.06523388f, 0.00362628f, 0.03494834f, 0.03692645f, -0.37255952f, 0.61037385f, 0.28720480f, 0.07731900f, 
    -0.09647246f, -0.04913807f, -0.03561606f, -0.09612278f, -0.03781508f, -0.10784459f, -0.11040471f, 0.01074919f, 
    -0.06445656f, 0.03176383f, -0.55346948f, -0.21428852f, 0.19109958f, -0.01039991f, -0.14182599f, -0.05319839f, 
    -0.01711297f, 0.04884772f, 0.05955458f, 0.08619273f, 0.17688283f, 0.33937702f, -0.17204496f, -0.01305071f, 
    0.01039498f, 0.06114193f, 0.00713611f, 0.15295060f, -0.04733563f, 0.04891556f, 0.08233152f, -0.16315101f, 
    0.08131339f, -0.02529279f, 0.07829135f, 0.06998525f, 0.08691321f, -0.07715293f, -0.03428011f, -0.08903863f, 
    -0.02714186f, 0.07188340f, 0.03293843f, 0.04798923f, -0.05809891f, -0.03009561f, -0.06679544f, -0.03730310f, 
    -0.00764647f, -0.02896623f, 0.01161416f, 0.07867989f, -0.02721072f, -0.06892595f, 0.02355414f, 0.02587006f, 
    0.02210060f, -0.46769539f, 0.05979311f, 0.10184747f, 0.03309567f, 0.06525623f, 0.03569186f, 0.11142284f, 
    -0.00732838f, -0.11435798f, -0.21615139f, 0.08831181f, -0.00402674f, 0.08823674f, 0.01278954f, 0.02281148f, 
    0.03030759f, 0.07649343f, 0.00888452f, -0.01214062f, 0.07735799f, 0.02474604f, -0.14413421f, 0.10566234f, 
    -0.15534675f, 0.20915607f, -0.19447243f, -0.19340424f, 0.04488634f, -0.21368724f, -0.06522039f, -0.08487517f, 
    -0.00380406f, 0.06363361f, -0.10006814f, 0.05598160f, 0.02870033f, -0.02260437f, 0.03430348f, -0.33280972f, 
    -0.00821405f, 0.05441968f, -0.05597261f, 0.01908145f, -0.07481479f, -0.03856877f, 0.01300449f, -0.09245645f, 
    -0.15358473f, 0.01623029f, 0.07146167f, 0.22149186f, 0.01404876f, -0.11034112f, 0.21273051f, -0.06815643f, 
    0.00927922f, 0.09238493f, 0.00312655f, -0.00041567f, -0.24343647f, -0.15698524f, 0.34345424f, -0.23298559f, 
    -0.00214241f, 0.03287372f, -0.04926476f, 0.04711277f, 0.00829262f, -0.03418073f, 0.08504807f, 0.00954292f, 
    -0.05898178f, -0.22600144f, 0.10222989f, 0.22029561f, -0.06835546f, 0.03483415f, 0.08029377f, 0.08866679f, 
    -0.07788444f, -0.05626942f, -0.06336032f, -0.11531463f, -0.80187398f, -0.01842121f, 0.14263077f, 0.31721887f, 
    -0.08157513f, 0.12824276f, -0.16425358f, -0.04801368f, 0.02672230f, -0.09816789f, 0.00921423f, 0.17204466f, 
    0.01862094f, -0.29359910f, -0.18049724f, 0.07718238f, -0.07170195f, 0.08357309f, 0.01463430f, -0.00033528f, 
    -0.03553743f, -0.06971031f, 0.11335165f, 0.01037277f, 0.08666044f, -0.04645721f, 0.30244479f, 0.30438712f, 
    -0.10248133f, -0.20976795f, 0.05092653f, 0.04246724f, -0.00967449f, 0.20878059f, 0.02842047f, -0.16900620f, 
    0.23073882f, -0.06179636f, 0.03094633f, -0.06542426f, -0.10275670f, 0.07598685f, 0.00816617f, -0.10277808f, 
    -0.03900393f, -0.11644943f, -0.06947879f, -0.02380981f, -0.34994635f, -0.00197751f, -0.05581063f, 0.23999834f, 
    -0.10401376f, 0.00043548f, -0.08805101f, -0.09856245f, -0.09274676f, 0.00812083f, 0.10898689f, 0.05218499f, 
    0.24300639f, -0.00604764f, 0.11387165f, -0.07172444f, 0.07359899f, 0.06383209f, -0.06792419f, 0.00392924f, 
    -0.04903094f, 0.13485277f, -0.00264887f, -0.00433891f, -0.32523239f, -0.20962280f, 0.40825367f, -0.14376187f, 
    -0.13906068f, 0.01985100f, -0.13239752f, -0.19087601f, 0.02264858f, 0.01612921f, -0.16505326f, -0.05792777f, 
    -0.34514990f, -0.53954184f, -0.17584778f, -0.22605966f, -0.16923471f, -0.16136305f, -0.23198910f, -0.04570423f, 
    0.05348441f, -0.02620292f, -0.01882019f, 0.07126023f, -0.14627235f, 0.12332150f, 0.04501246f, 0.36016631f, 
    -0.01662211f, -0.14359158f, 0.00128549f, -0.12440003f, -0.00510903f, 0.05775808f, 0.02095513f, 0.15482451f, 
    -0.14349160f, 0.10522010f, -0.35824022f, -0.43637705f, -0.07012446f, -0.01133232f, -0.10098305f, -0.13062337f, 
    -0.06393468f, -0.14470002f, -0.11723025f, -0.06572924f, 0.26242965f, -0.26396924f, -0.16430601f, -0.07327714f, 
    -0.07122047f, -0.00656983f, -0.06900828f, -0.15560494f, -0.17948560f, 0.01119694f, -0.01293379f, -0.08803544f, 
    -0.82276046f, -0.05824735f, 0.18216453f, 0.09801110f, 0.03477701f, 0.09756245f, 0.08062010f, -0.14961118f, 
    -0.02716636f, 0.02425092f, 0.21744573f, -0.06266096f, 0.92350626f, 0.08034755f, 0.24453019f, 0.11767904f, 
    0.08962302f, 0.11932290f, -0.05788580f, -0.20054424f, -0.04643223f, 0.01524544f, 0.07156633f, 0.01860692f, 
    -0.06379019f, -0.04021868f, 0.04418920f, 0.16975193f, -0.08163953f, -0.08992784f, -0.05967192f, -0.00288847f, 
    -0.10292256f, 0.05280861f, -0.08139520f, 0.08530255f, -0.01744545f, -0.29542813f, 0.18909647f, -0.11037719f, 
    -0.13423513f, -0.11266753f, -0.16366622f, -0.06056740f, -0.02121023f, -0.10582410f, -0.20221859f, -0.15564376f, 
    -0.03004923f, -0.17208147f, -0.04939352f, 0.16559474f, 0.05064855f, 0.09817991f, 0.10521875f, 0.01728515f, 
    0.10365107f, 0.00979666f, -0.01574055f, -0.07277971f, -0.30359679f, -0.20126337f, -0.13957557f, 0.03995063f, 
    0.08528711f, -0.01432477f, -0.01184896f, -0.00178934f, 0.07437193f, -0.11486799f, 0.01893310f, -0.14665075f, 
    0.05763658f, -0.27856988f, 0.53634548f, 0.33209288f, 0.01046510f, 0.17725366f, -0.11886932f, 0.11277986f, 
    0.04714806f, 0.07682528f, 0.01474256f, 0.01171955f, 0.10595556f, -0.12457603f, -0.05789822f, 0.15621606f, 
    0.18405931f, 0.03027009f, 0.07116391f, 0.01368483f, -0.06413002f, 0.00024521f, -0.01756126f, 0.07904189f, 
    0.05687382f, 0.05724271f, -0.11267734f, -0.01195897f, 0.07553246f, -0.05067192f, -0.09286519f, -0.03956374f, 
    -0.11824059f, 0.03809306f, 0.00674469f, 0.03399441f, -0.62860435f, -0.15000558f, -0.11985687f, -0.11670033f, 
    -0.04289533f, -0.03598034f, -0.18298380f, -0.13465139f, -0.00196238f, 0.05530229f, -0.04047424f, -0.04055865f, 
    -0.23022811f, -0.10434987f, 0.14543265f, 0.10170612f, -0.06827170f, 0.10944849f, -0.00265223f, 0.03559356f, 
    0.12455168f, -0.06228697f, 0.03712304f, -0.00840957f, 0.15888725f, 0.55497384f, -0.13006227f, -0.11795491f, 
    0.20081072f, -0.10948169f, 0.10024744f, 0.00810784f, -0.02169731f, 0.07909027f, -0.09489065f, -0.08640624f, 
    0.03582405f, 0.01771741f, -0.11471934f, 0.08848348f, -0.00106163f, -0.06602836f, 0.03880959f, 0.07617477f, 
    0.05693993f, 0.08165222f, 0.00545686f, 0.01034554f, -0.26291892f, 0.66516316f, -0.30075765f, -0.06736845f, 
    0.11302830f, 0.08750230f, -0.06209337f, -0.12666398f, -0.18480723f, 0.02675138f, 0.06241758f, 0.05958692f, 
    -0.34016192f, 0.09873325f, -0.05104104f, 0.12198163f, 0.08509009f, 0.05769733f, -0.12090744f, -0.04951383f, 
    -0.02961360f, 0.13655461f, -0.07933229f, -0.12488861f, 0.09307358f, -0.08700619f, -0.02253745f, 0.10245637f, 
    0.12840295f, 0.00920825f, 0.00421906f, -0.12755388f, -0.04282796f, 0.13442634f, -0.00259874f, 0.12542094f, 
    -0.61723775f, -0.06473970f, -0.04749737f, -0.10981012f, -0.14695939f, -0.11783971f, -0.10891126f, -0.09476002f, 
    -0.09389435f, -0.00045597f, 0.01568988f, -0.06209002f, 0.06376830f, -0.06925372f, -0.04290985f, 0.10303495f, 
    0.05086692f, 0.00803253f, 0.07798892f, 0.04096486f, 0.02085978f, 0.02214563f, -0.00839602f, 0.07393133f, 
    -0.17000556f, 0.55562377f, -0.19657469f, 0.35148376f, 0.06990992f, -0.23414707f, 0.15750532f, -0.09944688f, 
    -0.08872303f, -0.01719754f, -0.20511319f, -0.00149868f, 0.08170670f, 0.10172765f, -0.00287274f, -0.23224941f, 
    0.25930363f, 0.07389460f, -0.03724135f, -0.03381796f, 0.03166978f, 0.10048990f, 0.04681874f, 0.05540729f, 
    0.32206294f, 0.01085011f, 0.02093441f, 0.22844216f, -0.01066060f, -0.06763614f, -0.13561237f, 0.03507340f, 
    -0.02256778f, -0.05345811f, 0.18457446f, 0.16607444f, 0.31603935f, -0.14343759f, 0.04997958f, 0.05184758f, 
    0.14396043f, -0.06623202f, -0.05232333f, 0.04059673f, -0.03910829f, 0.00424703f, -0.00662608f, 0.02417203f, 
    -0.00423143f, -0.08802228f, -0.09699471f, 0.03300018f, 0.03311251f, 0.01437528f, -0.00015953f, -0.00028319f, 
    -0.00989660f, -0.03634694f, 0.04301733f, -0.06774829f, -0.03230841f, 0.10412037f, 0.15870421f, 0.35157073f, 
    0.03646073f, -0.27967381f, 0.14020038f, -0.09925406f, -0.14623578f, -0.13762747f, 0.04238068f, -0.13290028f, 
    0.16307960f, -0.04917971f, 0.00177824f, 0.01235679f, -0.04367286f, -0.01301888f, -0.09129789f, -0.10781929f, 
    -0.09081088f, -0.10444166f, -0.10671187f, -0.10691567f, 0.05401812f, -0.09690104f, -0.12470212f, -0.00158930f, 
    0.01816723f, -0.03476323f, -0.03672922f, 0.07191163f, -0.11023393f, 0.01045275f, 0.08262902f, -0.19523051f, 
    0.47334832f, 0.16378844f, 0.11900950f, 0.29299906f, -0.09649312f, 0.09584901f, -0.03989274f, 0.03311275f, 
    -0.21154878f, 0.04124417f, -0.04133940f, 0.05043750f, 0.19607851f, 0.11191972f, 0.20007797f, 0.39365992f, 
    -0.17842489f, 0.01089467f, 0.12013923f, 0.09351476f, 0.11631461f, 0.15240283f, -0.06646445f, 0.12733655f, 
    -0.12338418f, 0.01800024f, 0.03980057f, -0.02285574f, 0.02275354f, -0.15910915f, -0.26571354f, -0.10464587f, 
    -0.04777756f, 0.02149124f, 0.12848616f, -0.15589300f, 0.00641649f, -0.06786267f, 0.10006049f, 0.15263055f, 
    -0.07718150f, -0.10694079f, 0.04950995f, 0.01264742f, -0.02072024f, 0.05964711f, -0.13193379f, -0.06278503f, 
    -0.04128094f, -0.07978734f, -0.11316967f, 0.03024986f, 0.05604377f, -0.20240200f, -0.01739346f, -0.11133368f, 
    0.00475531f, 0.06667033f, -0.02015013f, -0.00149269f, -0.06502541f, 0.03053530f, -0.15100393f, 0.03941886f, 
    -0.00394023f, 0.00788746f, -0.02945482f, -0.01907419f, -0.08155633f, 0.06282535f, 0.01555826f, -0.00272742f, 
    -0.11370970f, -0.14518018f, -0.05724567f, -0.20128952f, -0.42704755f, -0.19261980f, -0.02748383f, 0.04064232f, 
    -0.02157687f, -0.09631239f, 0.19422649f, -0.13416104f, -0.09574278f, 0.07361243f, 0.13932975f, -0.05432266f, 
    0.22927880f, 0.11308797f, -0.04400992f, 0.02540945f, -0.06864496f, 0.05200377f, 0.01386108f, -0.08986007f, 
    0.10860996f, 0.20176210f, -0.13516067f, 0.16008355f, 0.12295666f, -0.00250913f, 0.03144231f, -0.14760950f, 
    0.05109436f, 0.02249253f, -0.05725823f, 0.13783418f, 0.16282965f, -0.12476786f, 0.09194811f, 0.17839640f, 
    0.08585842f, -0.00220818f, -0.02493689f, 0.01110594f, -0.01216946f, -0.02011881f, -0.02704396f, 0.15076122f, 
    -0.09237316f, -0.01218678f, 0.02043150f, 0.19060507f, -0.06102978f, -0.10001435f, -0.12006982f, -0.00266834f, 
    -0.11163003f, 0.11544241f, -0.08844341f, 0.00254283f, 0.13857678f, -0.14211613f, -0.11501160f, -0.04159263f, 
    0.01548928f, -0.08008561f, -0.01479300f, -0.03464195f, -0.02150744f, 0.00125429f, 0.05675195f, 0.09806848f, 
    0.13853951f, 0.11914920f, -0.26876765f, 0.05148724f, 0.15354107f, -0.15618901f, 0.00490648f, -0.08518547f, 
    0.04946811f, 0.12323884f, -0.01034586f, -0.05091503f, 0.04450931f, 0.02919117f, 0.05562954f, -0.04379193f, 
    0.06666087f, 0.06947159f, 0.01972742f, 0.14779145f, 0.05005260f, -0.15302925f, -0.10647984f, 0.12577933f, 
    -0.11958902f, -0.13389124f, -0.12784514f, 0.21032029f, 0.07400902f, 0.00883671f, -0.09738198f, 0.00807297f, 
    -0.03151361f, 0.03754608f, -0.03165286f, 0.03722191f, -0.05262020f, -0.02656226f, 0.10158721f, 0.20505452f, 
    0.00986397f, 0.01674997f, 0.01934090f, -0.08767004f, -0.04198922f, 0.16592824f, 0.05236813f, 0.08186502f, 
    0.71608901f, -0.24843077f, -0.05308404f, -0.47533721f, -0.15193854f, -0.06350370f, -0.00380919f, -0.07457166f, 
    -0.07358246f, 0.03842574f, -0.05657576f, -0.07351827f, -0.35846716f, 0.32490271f, -0.18784218f, 0.11674329f, 
    0.01015500f, 0.09965336f, -0.05514673f, 0.00019853f, -0.05847731f, -0.16367312f, 0.11079540f, 0.10099453f, 
    0.04357478f, 0.59596968f, 0.05661846f, 0.01158535f, -0.08578324f, 0.00216902f, -0.10539070f, -0.19161311f, 
    -0.25263780f, -0.24128099f, 0.00669122f, 0.00103998f, -0.07526641f, 0.05643478f, -0.20318985f, -0.31171736f, 
    -0.01245929f, 0.01801954f, 0.07074463f, -0.02779635f, 0.04181924f, 0.11923093f, 0.02320921f, -0.19668348f, 
    -0.17417681f, 0.62987906f, -0.17091855f, -0.64593047f, 0.28910735f, 0.17300498f, 0.02290788f, 0.03870479f, 
    -0.43015888f, 0.02083963f, 0.00895219f, 0.04988708f, -0.16263603f, 0.07750213f, -0.03039623f, -0.40017822f, 
    0.11811987f, -0.05676137f, -0.02746420f, -0.05910641f, -0.19860512f, 0.05278740f, 0.04404530f, -0.21119398f, 
    0.01595452f, 0.25910643f, 0.12250955f, 0.18239012f, 0.08347018f, 0.16362040f, 0.12491684f, 0.00669378f, 
    0.00114312f, 0.08625165f, -0.04379029f, 0.00857293f, 0.53442925f, 0.01047137f, -0.00612957f, 0.15683982f, 
    0.03514799f, 0.01133187f, 0.10149928f, -0.00131619f, -0.04449200f, 0.07611915f, 0.27466416f, -0.08686052f, 
    -0.11574776f, -0.11653194f, -0.07520884f, 0.17909588f, 0.00150630f, -0.02521165f, 0.04130603f, -0.06174306f, 
    -0.02088827f, -0.05979529f, 0.13669915f, 0.12442815f, -0.17157882f, -0.19034426f, 0.38562927f, -0.06559215f, 
    -0.14523180f, 0.00452864f, -0.28681469f, 0.09615858f, 0.04218800f, 0.09807977f, 0.09312259f, -0.00309005f, 
    -0.03625119f, 0.26980180f, -0.00850840f, 0.08399279f, -0.05965293f, 0.07893857f, 0.00324623f, 0.21129033f, 
    -0.03491550f, -0.07826902f, 0.01419743f, -0.11709694f, 0.00076086f, 0.00809308f, 0.16355596f, -0.02188520f, 
    0.08621342f, -0.08913449f, 0.05229949f, -0.14467935f, -0.06302812f, -0.09975082f, -0.04815749f, 0.07388072f, 
    0.05409608f, 0.23291984f, 0.27601400f, 0.21784763f, -0.13720387f, -0.06911954f, -0.08376666f, 0.18998615f, 
    -0.02589964f, -0.03734355f, -0.02384561f, 0.02354183f, 0.04833049f, 0.36577109f, -0.40043765f, -0.10363499f, 
    0.13013190f, 0.09962916f, -0.18153574f, -0.08138730f, -0.08008953f, -0.09646519f, -0.00586751f, -0.02949210f, 
    0.12137702f, 0.00651836f, -0.19323742f, 0.13166460f, 0.06583849f, -0.09435879f, -0.03823039f, -0.16180089f, 
    0.16169420f, 0.00157166f, 0.18252143f, 0.16534752f, -0.26346475f, -0.16921383f, -0.16548905f, 0.02794982f, 
    0.04648133f, -0.04635292f, -0.08437694f, 0.04131676f, -0.01899749f, -0.06399876f, 0.13042060f, 0.04989453f, 
    -0.04591104f, -0.20167047f, -0.13134782f, 0.02128401f, 0.06196276f, -0.09873336f, 0.07527757f, -0.27104276f, 
    -0.03766860f, -0.06503163f, 0.02824578f, -0.08769672f, 0.04007852f, -0.07912759f, -0.13816947f, 0.04968020f, 
    0.04311806f, -0.01934441f, 0.12608807f, -0.08949759f, 0.10312030f, -0.01206523f, 0.02063828f, 0.04800601f, 
    -0.01284933f, -0.04176635f, 0.04027333f, 0.08676910f, 0.05609813f, 0.05177721f, 0.01954923f, 0.01701423f, 
    0.10943644f, -0.02050482f, 0.07351926f, 0.07565704f, 0.03676613f, -0.05680153f, 0.05168533f, -0.00520947f, 
    -0.01803916f, -0.07609988f, -0.06497604f, -0.06815193f, 0.02191252f, 0.03097194f, 0.03166081f, -0.07315200f, 
    0.13941839f, -0.07061212f, -0.14308308f, 0.06287599f, -0.08340319f, -0.07755737f, -0.02909978f, -0.11063996f, 
    -0.32926387f, 0.07021642f, -0.14022015f, -0.01463225f, -0.00225951f, -0.09243151f, -0.10947921f, 0.04602212f, 
    0.02996168f, -0.04694913f, -0.00243835f, 0.12092088f, -0.10519452f, -0.17199562f, 0.01815105f, -0.22322761f, 
    -0.06591649f, -0.15081370f, -0.04978149f, 0.03891210f, 0.05197751f, -0.09151583f, -0.07663999f, -0.07200481f, 
    -0.06750688f, -0.16790332f, -0.07210527f, 0.06343646f, -0.16253303f, -0.15417352f, -0.17559028f, -0.04375475f, 
    -0.17023559f, -0.05397809f, 0.13807273f, -0.11112731f, 0.06474152f, 0.05794526f, 0.10582386f, 0.22865565f, 
    0.03610473f, 0.08305230f, 0.12628311f, 0.07595656f, 0.05726660f, 0.05469062f, 0.05529474f, -0.07041980f, 
    0.07186085f, -0.04381834f, 0.20475216f, 0.07604255f, 0.05161143f, 0.12764160f, -0.09656191f, 0.10185849f, 
    -0.01991905f, -0.00310355f, -0.05000766f, 0.07107361f, -0.05746051f, -0.04245920f, -0.03701698f, -0.13561913f, 
    0.17398973f, 0.18659256f, 0.33570942f, 0.16433796f, 0.00333805f, -0.02024049f, 0.02713479f, 0.20470959f, 
    0.07996157f, 0.02254999f, 0.03293089f, -0.02500271f, 0.07095492f, 0.15915532f, 0.01978207f, 0.13850051f, 
    -0.05683787f, -0.06393045f, -0.06714095f, -0.03715437f, -0.01279943f, 0.06562249f, -0.02742815f, 0.03387143f, 
    0.02643006f, 0.51038027f, -0.22902563f, -0.11264606f, -0.07254738f, 0.00989216f, -0.02414571f, 0.16469382f, 
    0.05893405f, -0.01626496f, -0.00105845f, -0.02952592f, -0.06939375f, 0.04262806f, 0.13915968f, 0.10111171f, 
    -0.16349092f, -0.04413672f, -0.03102087f, 0.00601831f, 0.01294753f, 0.05162253f, -0.04874244f, 0.04123583f, 
    0.11983942f, 0.07505715f, 0.13359451f, 0.03232558f, -0.10305528f, -0.02644220f, 0.03569629f, -0.08610449f, 
    0.06021663f, -0.11781767f, -0.07195581f, 0.05150329f, 0.00618747f, -0.02828907f, -0.14625803f, -0.03891082f, 
    0.08577504f, 0.04290980f, 0.04636371f, 0.04431789f, 0.08862866f, 0.05127714f, 0.03654430f, 0.01356406f, 
    0.04922822f, 0.16490659f, -0.09573033f, 0.20620857f, -0.01070124f, -0.09123663f, 0.15676050f, -0.10543597f, 
    0.03486989f, 0.15766804f, 0.05252880f, 0.13804665f, -0.43047184f, -0.28990927f, -0.08872039f, -0.42036167f, 
    0.05328954f, 0.08047330f, -0.03574325f, 0.04069900f, 0.00055304f, -0.06083860f, 0.01667691f, 0.02561810f, 
    -0.04949984f, 0.01767673f, 0.15709035f, 0.07712987f, 0.00906461f, 0.05456401f, -0.06620061f, -0.13123968f, 
    -0.08848720f, 0.14847593f, 0.13602602f, 0.04148825f, 0.11228740f, -0.49661186f, 0.22604628f, 0.04676012f, 
    0.14036198f, 0.05392612f, -0.13565749f, -0.13003546f, 0.05230440f, -0.03976631f, 0.02664656f, -0.03104676f, 
    -0.07371648f, -0.08212267f, -0.07096398f, -0.07804370f, -0.08175129f, -0.06452017f, 0.04654116f, 0.05847181f, 
    -0.11639845f, -0.09964391f, -0.11212198f, 0.14825584f, -0.21030185f, -0.10487299f, -0.09830578f, 0.15782629f, 
    -0.08129159f, -0.11314844f, 0.00663578f, -0.06024260f, -0.04107395f, -0.03520274f, 0.07091489f, 0.03365743f, 
    -0.18452860f, -0.33450663f, -0.18166719f, -0.40083903f, -0.01137673f, 0.04617615f, -0.05595923f, 0.11459212f, 
    0.02715213f, 0.01527121f, -0.01873212f, -0.08073578f, 0.06273623f, 0.12940922f, 0.12971523f, 0.04438918f, 
    -0.03185748f, -0.09894347f, -0.01068715f, -0.01722749f, 0.08054429f, -0.01145600f, 0.06097885f, 0.07681209f, 
    -0.02412334f, -0.13620912f, -0.01141900f, -0.32208928f, 0.10941464f, 0.16989289f, -0.01893214f, 0.05577415f, 
    -0.04100061f, 0.03570221f, 0.06379255f, -0.12739791f, 0.03510422f, 0.01055788f, -0.21294843f, -0.04999455f, 
    -0.07404161f, -0.06585807f, 0.08074952f, -0.03799725f, -0.08008020f, -0.20034872f, -0.08974046f, -0.17334017f, 
    -0.26286969f, -0.05114013f, -0.15208375f, -0.00033899f, 0.06859697f, -0.19457525f, -0.03541690f, -0.05350297f, 
    -0.05856256f, -0.05879533f, -0.00452401f, -0.06397504f, 0.01848464f, 0.22311553f, -0.01608067f, 0.16160794f, 
    -0.04257325f, -0.11492796f, 0.00384795f, -0.15597381f, -0.08840674f, -0.19261745f, -0.03534132f, 0.00585741f, 
    -0.06370079f, 0.13386779f, 0.00626263f, 0.09772730f, -0.08783577f, -0.02872209f, -0.05463755f, -0.04284429f, 
    0.00080438f, 0.00729034f, -0.05962541f, 0.07329864f, 0.04477959f, 0.01888482f, -0.09915389f, 0.10162114f, 
    -0.04744739f, -0.04217863f, -0.08525415f, -0.01408092f, -0.02353850f, -0.05884958f, 0.00438723f, -0.26301256f, 
    -0.16598244f, 0.08015784f, -0.06477814f, 0.15629394f, -0.16629326f, -0.07243057f, -0.07525428f, -0.17599547f, 
    0.09776096f, 0.00645322f, -0.01615378f, -0.18076667f, -0.03010247f, 0.03910047f, 0.09052293f, 0.02377467f, 
    -0.01710069f, -0.02885525f, -0.08887868f, 0.00996198f, -0.00485741f, -0.10390178f, -0.00830335f, -0.03860893f, 
    0.22840445f, -0.10034961f, -0.22125714f, 0.00008842f, 0.01883540f, 0.03098845f, 0.10028704f, 0.01275676f, 
    0.15542011f, -0.09658496f, 0.09367381f, -0.20868720f, 0.12752415f, 0.09942400f, 0.16242859f, 0.15284079f, 
    0.17492247f, 0.05069648f, 0.09453899f, 0.23256166f, -0.01726194f, -0.10338830f, 0.04872613f, -0.01944945f, 
    -0.07649060f, 0.16778150f, -0.14485715f, -0.10818674f, -0.11339752f, 0.02391805f, 0.00301125f, 0.03945557f, 
    0.05630806f, -0.01864934f, -0.12752450f, -0.13053200f, -0.00684425f, 0.00407123f, 0.14846084f, 0.10952494f, 
    -0.02408261f, 0.03951526f, 0.01164801f, 0.02238934f, 0.04145348f, 0.00346172f, -0.04421134f, -0.01550735f, 
    0.18713450f, -0.14807855f, 0.13750134f, -0.00648551f, 0.04179310f, -0.12369090f, 0.05463310f, 0.04077314f, 
    -0.00651085f, -0.07364967f, -0.04167792f, -0.07199491f, -0.08420754f, 0.03552549f, 0.06751402f, 0.02667464f, 
    0.02459123f, 0.00004935f, 0.01643643f, -0.05909550f, -0.03084186f, -0.05516488f, 0.12475908f, 0.08158346f, 
    -0.23786929f, -0.17541769f, -0.04852549f, -0.01592209f, -0.00056590f, 0.08173888f, -0.05544483f, -0.05933958f, 
    -0.10806321f, 0.11288350f, -0.14825432f, 0.08359741f, 0.22807421f, -0.11171941f, 0.04284188f, 0.12234589f, 
    -0.10922511f, -0.01566808f, 0.04278148f, 0.00407604f, 0.11282085f, 0.08261705f, -0.05507445f, 0.06394552f, 
    -0.13664208f, 0.06392545f, 0.29121956f, 0.30267292f, 0.01626881f, -0.07555223f, 0.04707034f, 0.08652442f, 
    -0.02550825f, -0.02363012f, -0.06616334f, 0.01560924f, -0.23211978f, 0.11731598f, -0.01686723f, -0.16239986f, 
    0.01625642f, -0.17321356f, 0.01743807f, 0.01201795f, 0.13155562f, 0.04917486f, 0.04143855f, 0.07427417f, 
    -0.03472231f, -0.03277269f, -0.03020669f, -0.02300190f, -0.07090944f, -0.09643232f, -0.00932749f, -0.19137189f, 
    -0.01110086f, 0.02784030f, 0.05925962f, -0.10622848f, -0.08532274f, 0.08169568f, 0.03843012f, 0.00026345f, 
    -0.04279526f, 0.18218863f, 0.03262939f, 0.00983728f, 0.00207362f, 0.04131801f, -0.01253324f, -0.00529120f, 
    -0.12247228f, -0.06950618f, 0.07590753f, -0.09086858f, -0.04305969f, -0.02348765f, -0.09141099f, 0.03739878f, 
    -0.08945800f, -0.10343359f, -0.15288654f, 0.05807412f, 0.07504880f, 0.02103007f, 0.09788201f, 0.29636988f, 
    -0.07240228f, -0.08855085f, 0.10041212f, -0.07594177f, -0.07856373f, -0.03731428f, 0.03007749f, -0.12217332f, 
    0.11928529f, 0.08458444f, 0.22001128f, 0.04478797f, -0.11769040f, -0.11848123f, 0.04345119f, -0.01071474f, 
    0.06240184f, -0.02519493f, 0.01963398f, -0.03216854f, -0.23221579f, 0.03792041f, 0.10329001f, 0.14522652f, 
    0.03191097f, 0.12401880f, 0.04251748f, 0.03944145f, 0.09373660f, -0.10272197f, -0.11832076f, 0.14392905f, 
    -0.04617676f, 0.08028693f, 0.04983948f, -0.03957037f, 0.03528794f, -0.05446051f, -0.11517702f, -0.13531467f, 
    0.04189269f, -0.27709731f, 0.07118119f, -0.06048292f, -0.11398957f, -0.23330095f, 0.27370614f, 0.18957615f, 
    -0.01914395f, -0.05924379f, -0.01432781f, -0.23705882f, -0.10237244f, 0.02666374f, -0.08352946f, 0.03792117f, 
    0.03764727f, -0.04502264f, 0.05704758f, -0.02603468f, -0.08135817f, -0.10189337f, 0.20323302f, -0.02303477f, 
    -0.03017775f, 0.06755913f, -0.05778519f, -0.01305236f, 0.07562549f, -0.06605070f, -0.01923486f, 0.10520490f, 
    0.05825455f, 0.01311182f, -0.01975097f, 0.06654398f, -0.08505959f, 0.00916244f, -0.03027774f, 0.07074039f, 
    0.10703748f, -0.09771547f, 0.03499489f, 0.00223259f, -0.01951541f, -0.02118460f, 0.05212020f, 0.04552343f, 
    0.16047822f, 0.03022049f, -0.01535734f, -0.15092224f, 0.17717275f, -0.10985615f, -0.04187392f, -0.07774799f, 
    -0.11944700f, -0.08490018f, 0.02966021f, 0.05092631f, -0.27422521f, 0.03201380f, -0.07579507f, -0.05389033f, 
    0.03687843f, -0.13212721f, 0.03723250f, 0.25910518f, 0.04599060f, 0.02195276f, 0.02229488f, -0.09649987f, 
    0.00448509f, -0.05588109f, 0.01231676f, 0.06084997f, -0.00833003f, 0.00031816f, -0.06031835f, -0.07381941f, 
    0.12258303f, -0.00036727f, 0.01110518f, 0.11633854f, 0.09115327f, -0.07907000f, -0.08636033f, -0.14905348f, 
    -0.09621529f, -0.02838339f, 0.07595845f, 0.09822091f, -0.00066707f, -0.03243295f, -0.16595039f, -0.02514655f, 
    0.03515757f, 0.01556104f, -0.07808104f, 0.05635796f, 0.33383781f, 0.05966000f, -0.07095040f, 0.07772757f, 
    0.03072901f, 0.01678166f, 0.12739365f, -0.18698038f, 0.14777529f, -0.02143321f, 0.04930049f, -0.01053092f, 
    0.17332517f, 0.14571400f, -0.13125305f, -0.01117533f, 0.25489631f, 0.15320478f, -0.15635145f, 0.00105619f, 
    0.03480145f, 0.09179618f, 0.06542652f, 0.00699600f, 0.15548426f, -0.05425882f, -0.20880868f, -0.20290163f, 
    0.13637826f, 0.01851983f, -0.02233546f, 0.00505351f, -0.01406485f, 0.04965229f, -0.02517539f, -0.21293174f, 
    -0.04767543f, 0.04077087f, 0.03892097f, -0.18693885f, 0.11191761f, 0.06870566f, -0.03826939f, -0.26141360f, 
    -0.09384462f, -0.00814980f, -0.07900302f, 0.02767668f, -0.21581247f, 0.16006072f, -0.69639254f, 0.09523990f, 
    0.05981297f, -0.01651023f, -0.09278408f, -0.02280530f, 0.00300916f, -0.07579017f, 0.09288948f, 0.07534442f, 
    -0.20199379f, 0.07245447f, -0.03695932f, 0.02900293f, -0.10235947f, -0.03709800f, 0.05395577f, 0.19764376f, 
    -0.18137307f, -0.08257727f, -0.13807487f, -0.08523387f, 0.12316331f, 0.14446308f, -0.18159850f, -0.06470658f, 
    0.02791882f, -0.00465995f, -0.05581723f, -0.05327359f, 0.12703054f, 0.04067057f, -0.11198751f, -0.08133620f, 
    -0.39832124f, 0.11582530f, 0.16756169f, 0.08684158f, -0.09067472f, 0.06946285f, 0.04608525f, 0.13049166f, 
    0.03733730f, -0.05557669f, 0.02431789f, 0.00948267f, -0.11338828f, -0.17747785f, -0.21833222f, 0.22673918f, 
    0.02718691f, -0.00571643f, 0.08761674f, 0.01383068f, -0.10417724f, -0.12020193f, 0.06682333f, 0.01988168f, 
    -0.14932482f, -0.17852671f, -0.07909302f, 0.15802480f, 0.02576487f, 0.00315379f, -0.00352854f, -0.00762437f, 
    -0.03466447f, -0.08128539f, 0.02267993f, -0.04806365f, 0.04138349f, -0.02586131f, -0.04573976f, 0.01135752f, 
    0.00342820f, 0.32676098f, -0.07827055f, -0.01541814f, 0.11677946f, -0.02187743f, 0.08657286f, 0.04383672f, 
    -0.38702321f, 0.07512679f, 0.34552452f, -0.03510497f, 0.12762490f, -0.11882169f, -0.14771663f, 0.24497697f, 
    0.24846594f, 0.02914292f, -0.06867035f, 0.08959953f, -0.12364765f, 0.13710429f, 0.02878171f, 0.16898723f, 
    -0.08277500f, 0.01050225f, -0.01698139f, -0.10595855f, 0.02099659f, 0.04677045f, -0.02111683f, 0.01348990f, 
    -0.03989783f, -0.03931903f, -0.32622418f, -0.23047556f, 0.03906078f, 0.16595536f, -0.13870084f, -0.00453339f, 
    0.09858732f, -0.10682712f, -0.07085859f, -0.14710310f, -0.52559030f, -0.16471349f, 0.10278608f, 0.04973122f, 
    0.04369554f, -0.00040990f, 0.06683372f, 0.04314383f, -0.09499416f, -0.11526426f, -0.09866469f, -0.27872375f, 
    0.20023067f, -0.03282711f, 0.05356348f, -0.00018203f, 0.00241351f, 0.03245708f, -0.00768220f, -0.09692287f, 
    0.06356028f, -0.13375309f, -0.02949940f, -0.16827883f, -0.14033478f, 0.00176047f, -0.09425567f, 0.02999618f, 
    0.10685648f, 0.00233727f, -0.02037636f, 0.04690246f, 0.08082674f, -0.13265456f, 0.12351172f, 0.19291995f, 
    0.03032670f, 0.11079971f, 0.04612428f, -0.18051289f, 0.22940916f, 0.07209370f, 0.01419794f, -0.20875236f, 
    -0.02429488f, 0.03435221f, -0.00443741f, 0.00087478f, -0.00761782f, 0.00507250f, -0.06412076f, -0.17893340f, 
    0.06023442f, 0.05558304f, 0.03195890f, 0.05597730f, 0.07156657f, 0.19571634f, -0.10678937f, -0.01695377f, 
    0.09361387f, -0.15902486f, -0.17303953f, -0.11554078f, 0.11579736f, 0.04030248f, -0.11335397f, -0.01044880f, 
    0.00177719f, 0.01920133f, 0.05140820f, 0.02954821f, -0.19898155f, -0.18931459f, -0.19216111f, -0.26241478f, 
    0.03516702f, 0.00887145f, -0.02026312f, 0.07428306f, 0.10391937f, -0.10309989f, 0.05651803f, -0.03336171f, 
    -0.13943143f, 0.07132501f, -0.02089019f, 0.05391271f, 0.07577924f, -0.06528504f, -0.07235180f, 0.01469183f, 
    0.24713409f, 0.03723643f, 0.00417079f, -0.07718700f, -0.16414206f, -0.10213450f, -0.17354906f, 0.01293228f, 
    0.06998647f, -0.04331990f, -0.03049025f, 0.02556081f, 0.10078891f, -0.05347561f, -0.04818499f, 0.09301044f, 
    -0.04868742f, -0.00312195f, -0.15899774f, 0.01036275f, 0.08018798f, 0.07244540f, -0.03218776f, 0.05740271f, 
    -0.14698434f, -0.08815297f, -0.32392779f, -0.52712655f, -0.36617920f, -0.28281805f, -0.21922319f, 0.01786988f, 
    0.03761689f, -0.02260265f, 0.03798427f, 0.05954710f, -0.00611087f, -0.24817504f, -0.01755521f, 0.02187990f, 
    0.12395908f, 0.02406962f, 0.11445948f, 0.05329052f, -0.02602539f, -0.01360445f, 0.05813575f, -0.15795510f, 
    0.00107415f, -0.21914260f, -0.07245203f, -0.14553025f, 0.05328681f, 0.15626675f, 0.10578077f, -0.14500034f, 
    -0.19715206f, -0.23414329f, 0.03891999f, 0.02297512f, -0.00775881f, 0.09699494f, -0.05137561f, -0.02897931f, 
    0.05388034f, -0.27981761f, 0.02550388f, -0.12552379f, -0.02266636f, -0.00366597f, -0.14254223f, 0.17947359f, 
    0.01744968f, -0.13505499f, -0.15267041f, -0.11218043f, -0.69594240f, -0.05095340f, 0.15460567f, -0.45696276f, 
    -0.01034088f, -0.02292570f, -0.07650878f, 0.00359686f, 0.03187500f, -0.04589313f, -0.11921733f, -0.01988217f, 
    0.31418142f, -0.09712898f, 0.05358370f, 0.13932301f, 0.12704933f, -0.04523081f, -0.08022345f, 0.04857451f, 
    0.08178020f, -0.01027950f, -0.06864432f, 0.08023637f, -0.04873597f, 0.22917739f, 0.11371206f, -0.10664244f, 
    0.08726756f, -0.02160943f, -0.10531154f, -0.14101397f, -0.05133251f, -0.14697756f, -0.03917986f, -0.08706887f, 
    -0.30145651f, 0.01159925f, -0.14087813f, -0.42714339f, -0.08510179f, -0.03517631f, -0.11858017f, 0.03792989f, 
    -0.04442916f, 0.04101583f, -0.00022064f, -0.08216088f, -0.13037491f, -0.37127313f, 0.17468770f, 0.23698559f, 
    -0.05801466f, 0.01140959f, -0.06523129f, 0.03489775f, 0.03843352f, 0.08548115f, -0.09644935f, -0.00449179f, 
    0.35463139f, 0.06843056f, -0.27087244f, -0.02998059f, -0.07126498f, 0.00881151f, 0.08935220f, 0.18555735f, 
    0.13525243f, -0.00628235f, -0.22424172f, 0.16267610f, -0.39839438f, -0.32294190f, -0.08212010f, -0.01791580f, 
    -0.05429460f, 0.02108260f, -0.03279542f, -0.11747301f, 0.20887646f, 0.04833012f, 0.06753141f, -0.06151107f, 
    -0.08515968f, 0.05966260f, 0.05828404f, -0.07480894f, 0.06469965f, 0.11916292f, -0.11349160f, -0.06722718f, 
    0.00542854f, 0.15410684f, -0.03122627f, -0.03152359f, -0.06162120f, 0.04835941f, -0.11079802f, -0.17740154f, 
    -0.05138880f, 0.08729316f, -0.08650465f, -0.01157944f, 0.04774280f, -0.03431588f, 0.04618212f, 0.15546262f, 
    -0.13780351f, 0.18027411f, -0.27277848f, 0.04616442f, 0.16806090f, -0.06308008f, 0.11884801f, 0.37563807f, 
    0.02863709f, 0.01178722f, 0.11035895f, 0.01337616f, 0.24717829f, 0.01815753f, 0.23645243f, 0.17872770f, 
    -0.04125581f, 0.09502561f, 0.05137879f, 0.02667542f, 0.07698827f, -0.00538691f, -0.00739237f, 0.13319381f, 
    -0.28042039f, 0.30387074f, -0.25948250f, -0.02845581f, 0.27214450f, -0.26240158f, 0.05755702f, -0.08768175f, 
    0.17964751f, 0.14118369f, -0.09649025f, 0.05914281f, 0.01739887f, -0.23946956f, -0.02063794f, 0.00761887f, 
    0.01302459f, 0.01503079f, -0.14289542f, -0.15207653f, -0.17523953f, 0.07920262f, 0.18027103f, -0.08113343f, 
    -0.10831156f, -0.07245871f, -0.31229258f, 0.22143374f, 0.08693979f, -0.00720407f, 0.03918382f, -0.00361974f, 
    0.04851368f, 0.01653232f, 0.13398223f, 0.21194984f, 0.11821541f, 0.07484966f, 0.03392486f, 0.11905856f, 
    -0.13423502f, 0.26307201f, 0.09625789f, 0.00446022f, 0.05718141f, 0.04634587f, 0.15054335f, 0.05077478f, 
    -0.02081745f, -0.02124294f, 0.18618084f, -0.08822050f, -0.04263937f, 0.04907122f, 0.08935332f, -0.06624088f, 
    0.09655709f, -0.08554623f, 0.13312186f, 0.08933426f, 0.13795559f, 0.13163470f, 0.32293370f, -0.01114924f, 
    -0.03675196f, 0.03471775f, 0.08976223f, 0.10217265f, 0.10138811f, -0.00901820f, -0.03735248f, 0.04306992f, 
    0.24215172f, -0.10632470f, 0.11991878f, 0.14012823f, -0.02563916f, 0.03030184f, 0.02277190f, 0.07463965f, 
    -0.02561880f, 0.13836133f, 0.00178780f, 0.04463244f, -0.50228071f, 0.04017838f, -0.11342573f, -0.02201992f, 
    -0.00321082f, 0.05773967f, -0.06139277f, 0.10437405f, -0.03864343f, -0.17474838f, -0.09332399f, 0.06104371f, 
    0.25290599f, -0.23480347f, 0.15060273f, -0.29749769f, 0.08189275f, 0.09138428f, 0.11281287f, 0.10675386f, 
    0.13078764f, 0.01544137f, 0.01566918f, 0.03725158f, 0.03348520f, -0.08622000f, -0.30628076f, 0.03958411f, 
    0.01428087f, -0.02100853f, 0.08002292f, 0.13094857f, -0.15491174f, -0.06773015f, 0.26060998f, -0.28554627f, 
    -0.00097904f, -0.01124950f, 0.09687915f, -0.03377995f, 0.15364696f, 0.08023371f, -0.14599270f, 0.05516053f, 
    0.00701481f, 0.01193331f, 0.02670979f, 0.17718738f, 0.04301197f, -0.00250888f, 0.15455882f, 0.01405623f, 
    -0.01673155f, -0.20648780f, -0.17927179f, 0.18488052f, -0.01885506f, -0.05564392f, 0.02158138f, -0.21521299f, 
    0.05404281f, -0.19775085f, 0.05416440f, 0.03203351f, -0.11816980f, 0.02042172f, -0.03823105f, -0.09361574f, 
    0.14154810f, -0.04639618f, 0.20282647f, 0.09154651f, 0.07193470f, 0.28168231f, 0.25673807f, -0.23084304f, 
    0.17607541f, 0.03300552f, -0.08894182f, -0.30965889f, -0.00112759f, -0.04454553f, 0.03786553f, 0.10518067f, 
    0.12097677f, -0.01935209f, 0.03702617f, -0.01037233f, 0.25406912f, 0.12029272f, 0.18848318f, 0.12236527f, 
    -0.03516107f, -0.02080476f, 0.06183918f, 0.06504502f, 0.20903513f, -0.22294571f, -0.05790082f, -0.26007637f, 
    -0.06494855f, -0.05691289f, -0.00342525f, 0.02518940f, 0.05423978f, -0.05696267f, 0.12088962f, -0.26542392f, 
    -0.10173815f, 0.24136738f, 0.09930012f, 0.43368271f, 0.01388722f, -0.15626198f, 0.03553665f, 0.14304996f, 
    -0.04356851f, -0.04911032f, 0.15725072f, 0.12698275f, -0.00483166f, 0.17647085f, 0.00443391f, -0.05269959f, 
    -0.00193041f, -0.16805793f, 0.03645628f, 0.05909209f, -0.00658321f, 0.03227567f, -0.12088877f, -0.11290709f, 
    -0.02036024f, -0.07555515f, -0.09474311f, -0.05700464f, -0.00028497f, 0.00536226f, 0.12576877f, 0.12167826f, 
    -0.04198959f, -0.03664360f, 0.07475427f, 0.05732175f, -0.12961487f, -0.03259750f, 0.00283399f, 0.04062687f, 
    0.10052466f, -0.13703460f, -0.09079868f, 0.05616562f, -0.20684367f, -0.01800931f, -0.07496207f, 0.04420982f, 
    -0.17093551f, -0.01623015f, -0.14393172f, -0.01128098f, 0.08339797f, -0.11244591f, -0.11018298f, -0.02167816f, 
    0.05064230f, 0.01283069f, 0.06926417f, 0.13800029f, 0.05253119f, -0.36467367f, -0.12928803f, 0.25343981f, 
    0.05373586f, -0.01554772f, -0.00961039f, 0.12606643f, 0.01998656f, 0.13315074f, 0.00597550f, 0.13386767f, 
    -0.04711629f, -0.06455057f, 0.20960085f, 0.22359693f, -0.11673051f, -0.05509450f, -0.09609987f, 0.07050266f, 
    -0.07025129f, 0.06318580f, 0.02516891f, -0.08011463f, -0.15005775f, -0.01498056f, -0.16463372f, 0.10250045f, 
    0.18266636f, -0.14652933f, -0.07973032f, -0.06825715f, 0.00865190f, 0.07616246f, -0.01340629f, 0.37618470f, 
    -0.02807725f, 0.00452760f, 0.03340057f, -0.25506577f, 0.02739528f, 0.00903148f, 0.06547444f, 0.17601663f, 
    -0.14570339f, 0.06188052f, 0.04431257f, 0.00147883f, -0.02790215f, 0.01308015f, -0.34708902f, 0.16380888f, 
    0.05451765f, 0.09983610f, -0.03176597f, 0.13715643f, 0.05425009f, -0.01794259f, -0.05595336f, -0.09409097f, 
    -0.19558954f, -0.63522410f, 0.05114631f, -0.36479846f, 0.07651865f, -0.02643151f, 0.11274769f, -0.09875508f, 
    0.04811340f, 0.00667150f, -0.04694175f, 0.08543187f, 0.26458409f, 0.33844191f, -0.06793367f, -0.02265603f, 
    -0.01326006f, 0.05300840f, 0.05763286f, 0.05494283f, 0.10237174f, -0.00684711f, 0.09744653f, 0.06539966f, 
    -0.45210364f, -0.17491210f, -0.39907297f, -0.08185394f, -0.07639333f, -0.05402424f, -0.38555452f, -0.09883155f, 
    0.10344512f, -0.02166530f, -0.01843549f, 0.01533576f, 0.17956081f, -0.05913208f, 0.14336954f, -0.12617619f, 
    0.02700285f, 0.08830255f, 0.14047292f, -0.14800948f, 0.01107267f, 0.02655232f, -0.00575016f, 0.05170247f, 
    0.11792272f, -0.15215251f, -0.05850719f, 0.03810600f, -0.09638160f, 0.02313170f, 0.12696123f, 0.00955510f, 
    0.12426300f, 0.21407565f, 0.04588101f, 0.08315676f, 0.37649360f, 0.24084088f, -0.16954984f, -0.04301378f, 
    0.00892429f, -0.01314980f, 0.02149336f, 0.07492946f, -0.01393920f, 0.07123482f, 0.11573683f, -0.08930860f, 
    0.02866913f, -0.12908523f, 0.11465515f, 0.03563996f, 0.02353777f, 0.11021904f, -0.17473455f, -0.14897865f, 
    0.00346066f, 0.00167036f, 0.09992094f, -0.08778763f, -0.01775206f, -0.04492750f, 0.02629005f, 0.10929532f, 
    0.01493669f, 0.06444149f, 0.12271778f, -0.06236250f, -0.03659696f, -0.07536869f, 0.01467347f, 0.07685547f, 
    -0.05180289f, -0.09889985f, -0.03609382f, 0.04213903f, 0.04114235f, 0.06903413f, 0.01418525f, 0.01219100f, 
    -0.01420648f, -0.07440737f, -0.05472591f, -0.05129780f, -0.13686194f, 0.13558568f, 0.00119076f, -0.25801286f, 
    -0.15790519f, -0.33268777f, 0.03362406f, 0.06894267f, 0.03563269f, -0.02203226f, -0.02830197f, -0.08002666f, 
    -0.00233365f, -0.22368650f, 0.06294454f, 0.03003448f, 0.09974393f, -0.03698740f, 0.03067304f, 0.12139471f, 
    -0.05830696f, 0.03922657f, 0.16039672f, -0.06685076f, -0.04036678f, 0.17287138f, 0.04670777f, 0.05173895f, 
    -0.05275228f, -0.05957446f, -0.04977020f, 0.17729034f, -0.08000677f, 0.09546340f, 0.09646276f, -0.29557854f, 
    0.06544165f, 0.31838763f, -0.02500218f, 0.13162145f, -0.02564835f, -0.01605006f, 0.02049620f, 0.04020898f, 
    0.02568753f, 0.00755138f, 0.01222511f, -0.09053354f, 0.02332358f, -0.10139351f, 0.03143219f, 0.01312223f, 
    -0.03835538f, 0.06070544f, -0.00805873f, 0.06180726f, 0.03501269f, 0.17104027f, 0.04718173f, 0.01159435f, 
    -0.41667360f, -0.26136693f, -0.18079896f, -0.34366304f, -0.02578119f, -0.04199303f, -0.03304906f, 0.03715862f, 
    -0.05990874f, 0.03885840f, 0.06508725f, -0.06679135f, 0.04185886f, -0.11427545f, 0.12934117f, -0.08902393f, 
    -0.00192354f, 0.06572108f, 0.02463161f, 0.07802631f, -0.02685264f, -0.10104125f, 0.06090585f, 0.05279547f, 
    -0.66843110f, -0.49638388f, -0.36651978f, -0.33698454f, -0.19866852f, -0.15436836f, -0.29099694f, -0.38969815f, 
    0.01657565f, 0.02267656f, -0.04218559f, -0.06748576f, -0.18724227f, 0.23474924f, 0.28228700f, 0.02676258f, 
    -0.05170475f, -0.10015028f, -0.02596847f, -0.07768027f, -0.10408718f, 0.00768882f, -0.09673763f, 0.09473676f, 
    -0.07943922f, -0.18201226f, -0.00460658f, -0.40044510f, 0.05018583f, 0.10123978f, 0.20269299f, -0.09611621f, 
    0.02662125f, 0.01784554f, 0.00794511f, -0.02157187f, -0.48848543f, 0.46286005f, 0.00875422f, 0.15621930f, 
    -0.04682242f, -0.01573644f, -0.01566426f, 0.04244572f, 0.01145300f, -0.00769992f, 0.09552231f, 0.08007697f, 
    -0.48354334f, 0.21916729f, 0.29884350f, 0.08320213f, -0.18192749f, 0.09852606f, -0.10511823f, -0.05417658f, 
    -0.05724191f, 0.13420781f, 0.08916258f, 0.04833253f, -0.00168820f, -0.05688474f, -0.11695492f, -0.03678771f, 
    0.02857812f, 0.02361873f, -0.00468596f, 0.02847293f, -0.10181542f, -0.03640807f, -0.03027164f, -0.08197022f, 
    0.16677010f, 0.00540584f, -0.09781593f, -0.03666095f, -0.02039081f, 0.03691230f, 0.08341119f, 0.10604563f, 
    0.01285825f, 0.05493549f, -0.04591044f, 0.22166294f, -0.21891901f, 0.11736640f, -0.06232302f, -0.10410330f, 
    0.00049443f, 0.00957488f, -0.02600363f, -0.00837237f, -0.03633141f, 0.04758054f, 0.13644023f, 0.13126241f, 
    -0.07855242f, -0.02651183f, -0.07412608f, -0.10288585f, -0.14720759f, 0.07826454f, -0.02081755f, -0.00743996f, 
    0.13338016f, -0.05224712f, 0.03513644f, -0.01101878f, -0.24137580f, -0.08451983f, 0.13431753f, 0.18527608f, 
    0.15915751f, 0.09312305f, -0.07347602f, -0.13854890f, -0.07343554f, 0.02586848f, 0.00622484f, 0.00562809f, 
    -0.03000347f, 0.33624622f, -0.08691306f, 0.01931217f, -0.08847798f, 0.05004631f, 0.07687240f, 0.05525985f, 
    0.16163525f, 0.07522079f, 0.11857402f, 0.06357904f, -0.31858161f, -0.78143853f, -0.01991175f, -0.06258050f, 
    -0.04856025f, -0.04441578f, 0.03879275f, -0.01402983f, -0.07896998f, 0.10279747f, 0.08919134f, 0.02786854f, 
    0.03190864f, 0.01734963f, -0.16725904f, -0.06052857f, 0.01978193f, 0.01377425f, 0.06193299f, 0.04797383f, 
    -0.08410687f, 0.03194427f, 0.03779623f, -0.01279594f, -0.46002707f, -0.42461109f, -0.18909882f, -0.25458452f, 
    -0.00019896f, 0.05124545f, 0.13057044f, -0.17430556f, -0.06794414f, -0.02085962f, 0.00923788f, 0.07035088f, 
    -0.35419819f, -0.09312307f, 0.15157500f, 0.11455557f, 0.16527371f, 0.01298308f, 0.04187511f, -0.04062901f, 
    -0.01060196f, -0.03921535f, -0.02472725f, 0.04011263f, -0.00391137f, -0.11567197f, 0.16278291f, 0.36430219f, 
    -0.05930126f, -0.03953926f, -0.04811827f, 0.10178227f, -0.12001058f, -0.03301057f, 0.07517050f, 0.14550951f, 
    0.13881096f, 0.11418802f, 0.12897103f, 0.44117877f, 0.02575095f, 0.07822549f, 0.08733518f, 0.06427786f, 
    0.02349964f, 0.02158458f, 0.16064119f, -0.23237863f, -0.20398343f, 0.13139446f, 0.42143753f, 0.46940765f, 
    -0.02546793f, -0.16435914f, -0.11893030f, 0.13025303f, -0.07560501f, 0.07010210f, 0.08689279f, 0.07948976f, 
    -0.40195754f, -0.04237602f, 0.45308286f, 0.16802645f, -0.12816772f, 0.02213110f, -0.19319509f, -0.20105156f, 
    -0.07971898f, 0.02384806f, -0.10819878f, 0.09135734f, -0.04767144f, -0.00741159f, 0.07375923f, -0.14537714f, 
    -0.00428703f, -0.09916852f, -0.01977949f, -0.00555061f, 0.01019721f, 0.02857783f, -0.14590853f, -0.02930004f, 
    0.55369294f, -0.37764299f, -0.30995926f, -0.06967950f, -0.22363971f, -0.02418792f, 0.17194514f, 0.08562871f, 
    0.07032407f, 0.11821512f, -0.07808771f, -0.20744526f, -0.27491906f, -0.49196321f, -0.25507712f, -0.26939619f, 
    -0.19436593f, -0.24889131f, 0.10469195f, -0.10923827f, -0.02618689f, -0.06135760f, 0.07458777f, -0.07481662f, 
    0.12315439f, -0.03221644f, 0.08231878f, -0.18298373f, 0.02751001f, 0.05047715f, -0.03174866f, 0.00782499f, 
    -0.02445629f, 0.05990353f, 0.07326057f, -0.05085459f, -0.08730435f, -0.12809314f, -0.08058567f, 0.16039370f, 
    0.09425162f, 0.16746689f, 0.18705295f, -0.26379478f, 0.01026838f, -0.19052294f, -0.05212304f, 0.09371825f, 
    -0.04760924f, 0.00358470f, 0.03463436f, -0.10476153f, 0.06193602f, 0.00128890f, 0.06760580f, -0.01425108f, 
    -0.00169067f, -0.01992333f, -0.05317894f, -0.00430298f, -0.30805191f, -0.71129435f, -0.31953168f, -0.24314912f, 
    -0.02097139f, -0.26015386f, -0.04541234f, -0.29898641f, -0.04407282f, -0.01759077f, -0.05245161f, -0.10888258f, 
    -0.16794065f, -0.14466289f, -0.02340456f, 0.06492122f, 0.05608355f, -0.04147207f, -0.00480806f, 0.10835383f, 
    -0.03013414f, -0.07502116f, -0.01824550f, 0.02129045f, 0.14660384f, -0.46268266f, -0.33514974f, -0.19630449f, 
    -0.08183961f, -0.03014240f, -0.06918144f, -0.07464274f, -0.02560657f, 0.11531711f, 0.04871510f, 0.16140522f, 
    0.14559765f, 0.05768429f, -0.14684545f, -0.02656282f, -0.07352798f, 0.05913701f, 0.08355331f, 0.08852454f, 
    -0.01279077f, 0.02097774f, 0.05754354f, 0.03675442f, -0.50829524f, 0.22665773f, 0.37216485f, 0.03092148f, 
    -0.02308038f, -0.03097253f, 0.06919295f, -0.08480296f, 0.02108157f, 0.11930998f, 0.03819061f, 0.07590405f, 
    -0.27150968f, -0.47337672f, -0.47520980f, 0.15966894f, 0.06255627f, 0.16962256f, -0.05033045f, -0.13166170f, 
    0.05806164f, 0.05165105f, -0.06787544f, 0.00336232f, 0.08508442f, 0.00797896f, 0.15286049f, 0.07369881f, 
    0.00822621f, 0.06838809f, 0.03602406f, 0.01156822f, -0.03463669f, 0.05089892f, 0.01800835f, 0.21007022f, 
    -0.30744731f, -0.12683281f, -0.16742486f, -0.05773767f, -0.03786045f, -0.23227753f, 0.11079662f, -0.26199040f, 
    -0.04807907f, 0.01919297f, 0.00278741f, -0.03708569f, -0.04150711f, -0.15290304f, -0.20953330f, 0.09178813f, 
    -0.16318275f, 0.18748829f, 0.13636646f, 0.05032145f, 0.03228407f, 0.00644820f, 0.00736097f, 0.10694546f, 
    -0.21988270f, 0.23313722f, -0.13579832f, 0.18035972f, -0.04899184f, 0.00778543f, -0.13023169f, 0.27195314f, 
    0.02136767f, -0.05594594f, 0.09516091f, 0.10037760f, -0.62500727f, -0.49341682f, -0.52503252f, 0.06672304f, 
    0.00278948f, 0.14155933f, -0.09512731f, -0.38328955f, -0.01794495f, -0.06141094f, -0.01964749f, 0.01256509f, 
    -0.43417236f, 0.01607923f, 0.11621352f, -0.25485715f, -0.07851346f, -0.09217421f, 0.04341151f, -0.11493824f, 
    0.02788269f, 0.02616124f, -0.06311421f, -0.05597239f, -0.32309270f, -0.07431673f, -0.46369845f, 0.44083077f, 
    -0.05517760f, -0.00732229f, 0.00321980f, 0.05432240f, 0.05340325f, -0.00162383f, 0.10283487f, 0.16588803f, 
    -0.14964138f, -0.03380410f, 0.03708230f, -0.21186273f, -0.04049351f, 0.08522069f, 0.05012283f, 0.03119050f, 
    -0.06912662f, 0.01038408f, 0.04784052f, -0.04135234f, -0.45836323f, -0.45095751f, -0.22308668f, 0.42797631f, 
    0.11283486f, 0.05982184f, -0.01030468f, -0.26599193f, -0.00608043f, 0.00796859f, 0.04707552f, 0.14686996f, 
    -0.04834680f, -0.08019238f, -0.01312549f, 0.06482806f, 0.03597399f, 0.10654283f, -0.00613768f, 0.18133269f, 
    -0.02853705f, -0.02393297f, -0.04684246f, 0.05979323f, -0.01414475f, 0.06554813f, 0.04249714f, -0.01330933f, 
    0.07674121f, -0.00415877f, -0.02766274f, 0.09446345f, -0.15924715f, -0.14409912f, 0.00305115f, 0.01093124f, 
    -0.12337899f, -0.11858203f, 0.30047756f, -0.18613902f, -0.03823922f, -0.07992861f, -0.02492725f, -0.04816777f, 
    -0.01578160f, 0.05776661f, -0.00634325f, -0.15676014f, -0.14908451f, 0.09961794f, 0.05676043f, 0.16969323f, 
    -0.10112634f, 0.04841934f, -0.04380961f, 0.05985811f, 0.00682656f, -0.04601878f, 0.19925570f, -0.05049364f, 
    -0.22984104f, -0.33176875f, -0.37516811f, 0.34253275f, -0.10561993f, 0.25307262f, 0.03548524f, -0.31857467f, 
    -0.02814257f, 0.01375176f, 0.09384783f, 0.06351850f, -0.08270925f, -0.01609131f, -0.05863257f, -0.02478063f, 
    0.01022043f, -0.04936651f, 0.02793164f, 0.01015137f, -0.07355344f, -0.03492055f, -0.02224147f, 0.08383036f, 
    -0.25469711f, -0.08134108f, -0.19454512f, 0.07361329f, -0.05534295f, 0.29622471f, 0.04359017f, 0.03316905f, 
    0.05044400f, 0.05737661f, -0.05954803f, 0.04225982f, 0.14445029f, -0.09744532f, -0.15383136f, -0.35444996f, 
    0.03208438f, 0.06514190f, 0.08015902f, -0.04079885f, -0.03853757f, 0.03127352f, 0.00709166f, 0.01711717f, 
    -0.33072296f, 0.73153812f, -0.07186075f, 0.32790777f, 0.09212863f, 0.04380543f, 0.13100320f, 0.02076756f, 
    0.00316934f, -0.10032499f, -0.08932238f, -0.06371269f, -0.09500047f, 0.03302389f, -0.04437482f, 0.02025547f, 
    0.01775621f, -0.00885116f, 0.13216668f, -0.03744889f, -0.18887603f, 0.04296514f, 0.09743533f, 0.04543015f, 
    -0.19395013f, -0.18558906f, -0.03763651f, 0.27225175f, 0.08316248f, 0.16553852f, -0.02327553f, 0.03401371f, 
    -0.03570135f, 0.01770023f, -0.01356663f, -0.00337331f, -0.22678389f, 0.34164292f, -0.20464174f, 0.31908789f, 
    -0.02928606f, 0.17644450f, 0.08465696f, 0.01714865f, -0.01999229f, -0.00358310f, -0.00306226f, 0.04516066f, 
    0.10951883f, -0.06848660f, -0.00385659f, -0.04212683f, -0.01809740f, 0.02299200f, 0.04099783f, -0.00870689f, 
    0.10684965f, 0.00087068f, 0.05065498f, 0.05098670f, -0.26285118f, 0.00980217f, -0.05017128f, 0.11442397f, 
    -0.02529114f, -0.01474383f, 0.00472731f, -0.06664243f, -0.11847788f, -0.09782136f, 0.02180360f, -0.04700290f, 
    0.11578465f, -0.23927215f, 0.00365819f, -0.00304742f, -0.16818978f, 0.03141698f, -0.15395230f, 0.13168637f, 
    0.02231293f, -0.09836473f, 0.11221753f, -0.17328306f, -0.03155379f, 0.11244472f, -0.01692511f, -0.09190750f, 
    -0.00680255f, -0.05798615f, 0.03685214f, -0.01519954f, 0.03797113f, 0.05632881f, 0.04645279f, -0.05516398f, 
    0.07383601f, 0.04115554f, -0.01855774f, 0.01215527f, -0.02213565f, -0.07894769f, -0.00270042f, -0.03168346f, 
    0.00008749f, -0.00613936f, -0.00379201f, 0.00065131f, -0.09042981f, 0.08531110f, -0.00571725f, 0.03717839f, 
    -0.10413717f, -0.05072083f, 0.18536319f, 0.02754237f, 0.05269205f, -0.00098328f, 0.05534982f, 0.04938182f, 
    0.16159905f, -0.03907995f, 0.08570645f, -0.18978323f, -0.02800665f, 0.12091014f, -0.08218323f, -0.06455211f, 
    0.01579647f, 0.14828663f, -0.06432277f, 0.00413265f, 0.11422345f, 0.04028486f, -0.04617180f, -0.00542554f, 
    0.01170852f, 0.03841564f, 0.01791917f, -0.02096635f, -0.08286215f, -0.12426632f, -0.22525306f, -0.21901785f, 
    -0.12192850f, 0.00336342f, 0.12312707f, -0.05914347f, -0.03931788f, 0.00201276f, 0.06968465f, -0.01196032f, 
    -0.18962418f, -0.08197442f, -0.02251456f, 0.00964496f, 0.31784707f, 0.07894108f, 0.04307520f, -0.03547884f, 
    -0.08385953f, 0.08211518f, -0.03624548f, -0.02237879f, 0.03359792f, -0.06464860f, -0.14526911f, 0.06361354f, 
    -0.21819195f, 0.09025127f, -0.26956782f, 0.25671455f, -0.02208789f, -0.00033233f, -0.04581491f, -0.09948111f, 
    0.06667950f, 0.09157726f, 0.07154541f, -0.02604281f, -0.07928839f, 0.13066784f, -0.04759184f, -0.07925287f, 
    0.01853378f, 0.00037756f, 0.08686639f, 0.00858004f, -0.02823848f, -0.01009692f, -0.05608095f, -0.08713049f, 
    -0.33046660f, -0.28704029f, -0.13005573f, 0.17568073f, 0.13049442f, 0.00071522f, 0.03815905f, 0.01612389f, 
    0.07854925f, 0.03769032f, -0.00566731f, 0.00011995f, 0.08230247f, -0.17228734f, 0.02195069f, -0.12017672f, 
    -0.00198559f, -0.01199188f, -0.03138376f, 0.05819628f, 0.07364739f, -0.10720672f, 0.06019406f, 0.04721778f, 
    -0.06771231f, 0.27318621f, -0.11983532f, -0.03974114f, -0.00330817f, -0.11284299f, 0.05881504f, -0.02945593f, 
    0.02931246f, 0.03815986f, -0.01150780f, 0.04337641f, -0.07991417f, -0.56468731f, -0.28153732f, -0.14582063f, 
    -0.04649736f, -0.18241280f, 0.01302474f, -0.07837311f, 0.13388954f, 0.00319894f, 0.04450057f, -0.00878047f, 
    0.57061768f, -0.26221254f, -0.36551115f, -0.07307958f, 0.02579207f, -0.10974465f, -0.10242410f, -0.00314925f, 
    0.01572083f, 0.07525408f, 0.03760818f, 0.04442995f, -0.05786640f, 0.06075275f, 0.08288299f, -0.06207655f, 
    0.00475013f, 0.03765684f, -0.00301627f, -0.04118406f, 0.04984473f, -0.02028767f, 0.02003759f, -0.08519942f, 
    -0.07425071f, 0.17354536f, -0.21833652f, -0.01700227f, -0.05785367f, 0.08689769f, -0.00582897f, 0.05709868f, 
    0.14352687f, 0.14705619f, 0.22018209f, 0.06399788f, -0.03001074f, -0.12165493f, 0.00426704f, 0.04677869f, 
    0.04086211f, 0.00524036f, 0.05165457f, -0.06186836f, 0.00968974f, 0.01923703f, -0.07948104f, -0.13750842f, 
    -0.15354921f, -0.40218878f, -0.08966523f, 0.13979252f, 0.00055012f, 0.09904921f, 0.04015739f, 0.04355370f, 
    0.07814742f, 0.03617597f, 0.04135621f, -0.05624398f, 0.15922116f, -0.16959825f, 0.02993229f, -0.36003691f, 
    -0.00104114f, -0.14757486f, 0.04908629f, 0.09893642f, 0.00782432f, -0.03285364f, 0.06896250f, -0.12717238f, 
    0.08313216f, -0.24176593f, -0.07691874f, -0.03238871f, -0.02475867f, 0.02340599f, 0.07592455f, -0.10462319f, 
    -0.05437543f, 0.09567689f, 0.06550859f, -0.03382168f, 0.41287708f, -0.49956363f, 0.09518476f, -0.34328705f, 
    -0.03489076f, 0.00603724f, -0.07463243f, 0.30055505f, 0.06533594f, -0.01963367f, 0.04234057f, 0.03653559f, 
    -0.09016171f, -0.04958790f, -0.07257847f, 0.00883600f, 0.00855652f, 0.02201229f, 0.01349956f, -0.07103427f, 
    -0.00768619f, 0.04884205f, -0.06143359f, -0.05091615f, -0.25156736f, -0.17513826f, -0.02989379f, 0.09766226f, 
    0.07021587f, 0.03587333f, 0.04533012f, 0.05792995f, 0.08349392f, -0.05027957f, -0.02152474f, -0.05171989f, 
    0.09389161f, 0.04429631f, 0.19630550f, -0.03274144f, 0.04789452f, -0.00524183f, 0.11018386f, 0.05469083f, 
    -0.09441098f, 0.00978398f, 0.00372578f, -0.01007824f, 0.47314513f, -0.19770837f, -0.43569106f, -0.23366268f, 
    0.09203500f, 0.04827775f, -0.02978071f, 0.04221365f, -0.08842694f, 0.09858783f, 0.08348201f, -0.09121300f, 
    -0.46680316f, 0.37035879f, -0.25748754f, 0.29002199f, 0.08149195f, 0.02519025f, 0.09841216f, -0.02031217f, 
    -0.07489071f, -0.01692464f, -0.01579940f, 0.04396233f, 0.46955508f, -0.58247322f, -0.48042732f, -0.39063534f, 
    -0.18597922f, 0.06543687f, -0.03357879f, 0.11483479f, 0.06321865f, -0.05713167f, 0.04843053f, 0.05053655f, 
    0.07815174f, -0.23098192f, -0.19057095f, -0.18146570f, 0.08311950f, -0.03997612f, -0.04759627f, 0.15518495f, 
    0.05884465f, -0.00371402f, -0.01655619f, 0.03216968f, 0.03158669f, 0.14071861f, 0.14798647f, 0.10360551f, 
    0.07784380f, -0.05460615f, 0.02405569f, -0.01328812f, 0.03266411f, -0.05981856f, 0.01092213f, -0.02580920f, 
    -0.45885241f, -0.03424215f, -0.07955965f, 0.23363765f, -0.25420341f, -0.00465937f, -0.11189530f, -0.05695310f, 
    -0.01216015f, -0.04631524f, 0.05790807f, -0.00167757f, -0.13834034f, -0.17071325f, -0.10537116f, 0.26032460f, 
    0.06849315f, -0.17957510f, -0.10480108f, -0.04124148f, -0.01539615f, 0.00770904f, -0.08690649f, -0.07716615f, 
    -0.12339897f, 0.24253084f, 0.01812191f, 0.09917776f, -0.17842063f, 0.05426612f, 0.07741125f, 0.01364305f, 
    -0.13176370f, -0.01205400f, 0.01500545f, 0.00912676f, 0.12344982f, 0.01873978f, 0.02249186f, -0.12491492f, 
    -0.11692303f, -0.03268143f, 0.04185529f, 0.03922930f, -0.05023564f, -0.02164689f, 0.05635393f, 0.00719219f, 
    -0.07756143f, 0.11025655f, -0.04909791f, 0.02430710f, -0.00340103f, 0.01623947f, 0.01248667f, -0.03858622f, 
    -0.03487602f, -0.01846589f, -0.02441678f, -0.10007837f, -0.38298798f, -0.36931536f, -0.10752083f, 0.44846192f, 
    -0.07846863f, -0.01596973f, -0.07589669f, 0.02981751f, 0.03391906f, -0.02818367f, -0.08070027f, -0.03392866f, 
    -0.06522223f, -0.11774933f, 0.15765221f, -0.09222789f, 0.01541796f, -0.01195916f, -0.00555067f, 0.01286391f, 
    0.02117889f, 0.02575928f, -0.02079115f, -0.07620631f, 0.02446471f, -0.36767837f, 0.00437042f, 0.09291412f, 
    -0.06362697f, -0.10541382f, -0.15261793f, 0.00526992f, -0.01315006f, -0.10521837f, -0.04105578f, -0.08242273f, 
    0.05926778f, -0.13268802f, 0.08827233f, -0.04900673f, -0.07123987f, 0.01173294f, -0.08548645f, -0.08102649f, 
    -0.02800587f, -0.10641195f, -0.07286999f, -0.11703861f, 0.43809414f, -0.02803376f, -0.18647403f, -0.19020051f, 
    -0.00181436f, -0.04064067f, -0.02675029f, 0.05945509f, 0.11403542f, 0.11256350f, -0.01424039f, -0.04645542f, 
    -0.18038593f, -0.14313805f, 0.11437088f, 0.03319686f, -0.02473633f, -0.02295999f, 0.03468426f, -0.00757204f, 
    0.04372331f, 0.03839932f, 0.00174595f, 0.01497217f, -0.11858532f, -0.09754477f, -0.09468985f, 0.10134903f, 
    -0.07361636f, 0.00844672f, -0.01774099f, 0.02358012f, 0.09699007f, 0.02286417f, -0.09027164f, -0.03712466f, 
    -0.32600531f, -0.26013926f, -0.17859778f, -0.04808741f, -0.06106770f, -0.08750369f, -0.01139167f, 0.00202957f, 
    -0.00500050f, 0.07359944f, 0.00490747f, -0.02885647f, -0.09836838f, -0.22470205f, -0.15893549f, -0.22016335f, 
    0.02486012f, 0.05436554f, 0.07238781f, 0.09387391f, -0.01749086f, -0.08578931f, -0.04631686f, 0.07135154f, 
    0.26749909f, -0.33579987f, -0.17675878f, -0.24356195f, -0.06689774f, -0.07863057f, -0.04335378f, 0.00682429f, 
    -0.07410023f, 0.02848227f, -0.01779104f, -0.07581271f, -0.26419514f, -0.04851864f, 0.17294338f, 0.31955224f, 
    0.09019633f, 0.00814193f, -0.00007255f, 0.10581037f, -0.00053436f, -0.08872999f, 0.02757339f, -0.07542001f, 
    -0.32840335f, -0.28129929f, -0.06839620f, -0.13213000f, 0.06773655f, 0.00585614f, -0.00803149f, -0.06113457f, 
    0.02282596f, -0.01720464f, 0.01639795f, 0.04811041f, -0.43385705f, -0.33163640f, -0.37758365f, -0.17862608f, 
    -0.03748292f, -0.07373522f, 0.12764683f, -0.09355387f, 0.01720827f, -0.01124337f, 0.05459420f, 0.04688730f, 
    0.45487219f, 0.19337115f, 0.01110411f, 0.25196406f, 0.03176643f, 0.03368007f, 0.16336408f, -0.13778903f, 
    -0.08790477f, 0.01069018f, -0.00545975f, -0.00554301f, 0.02547543f, -0.20977506f, -0.04473647f, -0.08604002f, 
    -0.09725667f, -0.06995097f, -0.07370563f, 0.16819818f, -0.09138084f, 0.02627940f, 0.00286986f, -0.07839657f, 
    0.14159663f, -0.02292724f, 0.01585237f, -0.07271758f, -0.11926217f, -0.02530716f, -0.09099754f, -0.14433350f, 
    -0.08257762f, 0.01853003f, -0.00343238f, -0.04809192f, 0.03699974f, 0.12472572f, 0.04760858f, -0.12815100f, 
    -0.04620328f, 0.06254360f, -0.02453917f, -0.06406318f, -0.20924406f, 0.09031940f, 0.01010313f, -0.05879830f, 
    0.19541883f, 0.20888433f, -0.09421751f, -0.14996642f, 0.02585751f, 0.00587564f, -0.03970556f, -0.03335133f, 
    -0.10937308f, -0.00927139f, -0.08831843f, -0.06634650f, 0.24367085f, -0.03097142f, -0.09925900f, -0.12644374f, 
    0.05183929f, -0.00190801f, -0.00342979f, -0.05278358f, -0.02908913f, 0.18070512f, -0.02746576f, -0.19870692f, 
    0.12826039f, -0.28183579f, 0.05641256f, 0.09319449f, 0.05557966f, 0.05634253f, 0.02921376f, 0.08807419f, 
    -0.02631269f, -0.00959156f, 0.02288816f, 0.08165792f, -0.01444870f, 0.08772785f, -0.11708160f, 0.03877694f, 
    0.06661780f, 0.10038688f, -0.00499710f, 0.04152083f, -0.02023846f, -0.03620503f, 0.01255102f, -0.03198133f, 
    -0.33598867f, -0.14503124f, -0.04687064f, -0.19927497f, -0.09771093f, 0.13096772f, 0.21623646f, 0.11119942f, 
    -0.02582183f, -0.07030186f, -0.07889594f, 0.01589774f, -0.07023814f, 0.11961877f, -0.12286977f, 0.00752570f, 
    0.01953306f, -0.03910083f, -0.05251550f, -0.04020252f, 0.03218626f, 0.01504463f, 0.05079887f, 0.02221122f, 
    -0.64599013f, -0.06521074f, -0.06625255f, 0.13365772f, 0.09280565f, -0.04169997f, -0.22113781f, -0.14560905f, 
    0.03709264f, 0.00016679f, 0.03620264f, 0.08915862f, -0.22966781f, -0.23977655f, 0.05726301f, 0.04900816f, 
    -0.01875085f, 0.08935518f, -0.10631689f, 0.09413707f, -0.03884786f, -0.10607509f, -0.08250315f, -0.09322056f, 
    0.05308594f, -0.13352878f, -0.08991705f, -0.08914936f, 0.06938084f, -0.00920223f, -0.00408203f, 0.01155583f, 
    0.04311740f, -0.04508691f, 0.00534646f, -0.00023818f, -0.53323823f, -0.11568790f, 0.11449213f, 0.31904593f, 
    -0.12070376f, -0.02223299f, -0.07242580f, 0.11385197f, -0.08017640f, 0.00723908f, 0.12030929f, 0.03376949f, 
    -0.08077455f, -0.12962313f, 0.07477799f, 0.01026489f, 0.02087754f, -0.02173495f, -0.05539127f, 0.04068203f, 
    -0.26390839f, 0.05851261f, -0.24855912f, -0.32055739f, -0.50419217f, -0.03431141f, 0.09909559f, 0.01961965f, 
    0.00450366f, 0.05564660f, 0.02506630f, 0.05735577f, -0.00573294f, 0.06662321f, 0.06231811f, 0.05153194f, 
    0.20107979f, 0.23953040f, -0.15279771f, 0.00945061f, 0.09186246f, 0.07744116f, 0.01943157f, 0.13945299f, 
    0.00139793f, 0.09586604f, -0.05090668f, 0.06473504f, -0.09434531f, 0.05369069f, 0.07269552f, 0.03842299f, 
    -0.03990375f, 0.02552587f, -0.09196651f, -0.04374744f, -0.12403455f, 0.03308668f, -0.05870787f, -0.05000988f, 
    -0.19207978f, 0.07350220f, 0.08184603f, -0.02689328f, -0.06403339f, -0.02143380f, -0.02036582f, -0.06168034f, 
    -0.07591709f, -0.02131751f, -0.06851988f, -0.01917421f, -0.20190211f, -0.16712925f, -0.07542688f, 0.05700935f, 
    0.17465781f, -0.03739063f, 0.05201975f, 0.07580709f, 0.10003853f, 0.08423587f, 0.01881838f, 0.11959948f, 
    0.19113426f, -0.10529630f, 0.03907386f, -0.14878778f, -0.19034281f, -0.02707730f, 0.02676971f, -0.00976917f, 
    0.21243465f, -0.00016311f, 0.12992823f, -0.09662051f, 0.16829437f, 0.01908773f, -0.06114030f, -0.05436660f, 
    0.08898688f, 0.02276237f, 0.01520153f, -0.04212112f, 0.16008881f, 0.16077448f, 0.07335308f, 0.19159281f, 
    -0.42905775f, -0.03722352f, 0.25303861f, 0.16084027f, 0.01585478f, 0.00594023f, 0.05360344f, -0.01473601f, 
    0.14159219f, 0.07607064f, -0.00233971f, 0.05132557f, -0.03164061f, -0.09810648f, -0.04515953f, -0.12943354f, 
    0.01948611f, 0.03714462f, 0.06856937f, 0.12511954f, -0.07337523f, 0.05522869f, 0.01284216f, -0.15552092f, 
    -0.00283603f, -0.13459837f, -0.43848127f, -0.14702612f, 0.05807615f, 0.05217924f, 0.10492064f, 0.06220048f, 
    0.02359702f, 0.03288205f, -0.12904347f, -0.33599848f, -0.19438489f, -0.02655268f, 0.04316454f, 0.09443098f, 
    0.06810834f, -0.00839453f, -0.02661174f, 0.08291756f, 0.21305230f, 0.02060592f, 0.08537393f, 0.10186568f, 
    -0.39242500f, -0.42309552f, -0.40635875f, 0.00737019f, -0.14926702f, 0.01462085f, 0.00801007f, 0.11379229f, 
    -0.05422402f, 0.05638696f, -0.02308858f, 0.01200319f, -0.02880803f, -0.21236576f, -0.14246328f, 0.02881478f, 
    -0.02671541f, 0.02431813f, 0.08673521f, 0.05023036f, 0.04185052f, -0.14149170f, 0.01444069f, -0.07100493f, 
    -0.84782076f, 0.08288724f, 0.15348051f, 0.28973553f, 0.04120043f, -0.04709907f, -0.06846213f, -0.12326381f, 
    -0.07198335f, -0.06955497f, 0.01943949f, -0.09776489f, -0.09894072f, -0.52236819f, -0.27047569f, 0.19606662f, 
    0.06679118f, 0.04209793f, 0.20602161f, 0.08159610f, -0.05871822f, -0.04337531f, 0.05861065f, -0.02881766f, 
    -0.00661047f, -0.40763897f, -0.53428549f, -0.11619128f, 0.00195073f, 0.11802326f, 0.08882838f, 0.01298323f, 
    0.08009244f, -0.08661120f, -0.08025283f, -0.11346723f, -0.04730999f, 0.07541026f, -0.00064701f, -0.12168961f, 
    -0.11685074f, -0.04972912f, -0.03444136f, 0.01275986f, -0.00266991f, -0.05496511f, 0.03594239f, -0.01307046f, 
    -0.09430987f, -0.03899960f, 0.09559265f, 0.10482118f, 0.04057454f, 0.00142677f, -0.06684901f, 0.04810902f, 
    -0.24579005f, -0.04765801f, -0.08624215f, -0.17022140f, -0.15792491f, -0.11959618f, 0.09698124f, -0.11040461f, 
    -0.07002570f, -0.04119627f, -0.05743329f, -0.12378803f, 0.03651296f, 0.05748003f, -0.12583461f, -0.05444494f, 
    0.21580476f, -0.05346501f, -0.08058993f, -0.03100003f, 0.06875016f, 0.01878032f, -0.00674704f, 0.01203536f, 
    -0.12991653f, -0.06761883f, -0.17041034f, -0.14928302f, 0.19083282f, 0.14688820f, -0.06042835f, -0.19304761f, 
    -0.07643207f, -0.20857029f, -0.00968060f, -0.05294498f, -0.02076034f, 0.03176406f, 0.01269034f, 0.12380145f, 
    0.06830018f, -0.27271390f, -0.06248243f, -0.06178471f, 0.00695412f, 0.11053570f, 0.01660993f, 0.11555694f, 
    -0.04052649f, -0.02300574f, -0.05671616f, -0.04259291f, -0.16731581f, -0.27618405f, -0.36603871f, -0.19416119f, 
    -0.02075978f, 0.01147882f, 0.20514932f, -0.06059587f, -0.03120694f, -0.02250187f, -0.03126704f, -0.11285541f, 
    0.18258113f, 0.08251656f, 0.08827583f, 0.00840044f, 0.01470814f, -0.07412419f, -0.05180107f, -0.02941664f, 
    0.06411590f, -0.06747694f, 0.07915875f, -0.01128122f, -0.13362801f, -0.25561100f, -0.30483595f, -0.31628469f, 
    -0.09609380f, -0.05480597f, 0.00912680f, -0.01013270f, -0.08394997f, -0.03061878f, -0.05445640f, -0.09526729f, 
    -0.13035570f, -0.02166769f, 0.05440784f, 0.13700247f, -0.14295128f, 0.04592207f, 0.05633117f, -0.05357705f, 
    0.02128170f, -0.11182934f, 0.06876651f, 0.01366977f, 0.17629544f, 0.03639852f, -0.17825864f, 0.01534229f, 
    0.04351330f, -0.09268282f, -0.02336415f, 0.03730291f, 0.27322510f, -0.01838585f, 0.10527553f, 0.10945322f, 
    -0.17509548f, -0.32312348f, 0.22682378f, 0.15238459f, -0.06871437f, 0.15281032f, -0.04548785f, -0.06062217f, 
    -0.01473184f, -0.05467337f, 0.16977650f, -0.16963471f, -0.30122682f, -0.26411682f, -0.26464975f, 0.32729617f, 
    0.05058023f, 0.10792441f, 0.04739541f, 0.13462606f, 0.11096703f, -0.00175891f, 0.09538934f, 0.03187304f, 
    -0.01494630f, -0.25560701f, -0.32671231f, 0.18625088f, -0.08330643f, -0.01492962f, 0.21723837f, 0.13036472f, 
    0.03344220f, -0.11122476f, 0.03186918f, -0.00612373f, -0.25007924f, -0.09501410f, -0.01483553f, -0.08481539f, 
    0.01721977f, -0.03313911f, 0.06462169f, 0.04859332f, 0.14644636f, 0.16517507f, 0.14824824f, 0.18567897f, 
    -0.06310814f, -0.01426784f, 0.07745694f, 0.20882687f, 0.20164335f, -0.04863916f, -0.17375919f, 0.12596931f, 
    -0.03651598f, 0.11037698f, 0.16341776f, 0.06569327f, 0.29076463f, 0.04931559f, -0.34542975f, -0.20691270f, 
    0.02805598f, -0.11077985f, -0.08077769f, 0.03075496f, 0.08869355f, 0.11772612f, 0.03528452f, 0.11256555f, 
    -0.25735545f, 0.03806109f, 0.08781791f, 0.06345484f, 0.01748884f, 0.00965708f, -0.18638483f, 0.13699053f, 
    -0.03716677f, 0.17821690f, 0.04297863f, 0.05651276f, -0.19405633f, 0.08843012f, -0.03084435f, 0.00327879f, 
    0.00015086f, -0.02143239f, 0.02757104f, -0.23804408f, 0.09108990f, -0.08562233f, -0.10395656f, -0.03306381f, 
    -0.10821647f, 0.11221654f, -0.02301864f, 0.13871789f, -0.06780169f, -0.00451020f, -0.01730599f, -0.00888004f, 
    -0.02545277f, 0.02560934f, 0.05495480f, 0.00330851f, -0.19334662f, -0.27565339f, -0.46917865f, -0.22422032f, 
    0.25596544f, -0.03673710f, -0.08582527f, -0.04865359f, 0.00014305f, -0.00376978f, 0.05580591f, 0.10275723f, 
    0.00195825f, -0.07107199f, -0.01901649f, -0.17838007f, 0.04720176f, 0.11020915f, -0.08985012f, -0.09627691f, 
    0.09527615f, 0.16376780f, 0.05514709f, 0.11812624f, 0.31811112f, -0.10574616f, -0.22637835f, -0.18596968f, 
    0.08841373f, 0.02994326f, 0.07152001f, 0.05643301f, 0.10135529f, 0.04876210f, -0.04125934f, -0.05170171f, 
    0.21155040f, 0.19799261f, -0.02071698f, -0.09350254f, 0.13808601f, 0.05511668f, -0.01036089f, -0.03841410f, 
    -0.02518978f, -0.01760811f, 0.08098439f, -0.05161220f, -0.05575527f, -0.15186577f, -0.10255519f, 0.02745958f, 
    -0.11106107f, 0.03274840f, 0.09008151f, -0.00844947f, 0.04701636f, -0.10477703f, -0.00437844f, -0.15363516f, 
    0.52922416f, 0.04420201f, -0.03079059f, -0.08378085f, -0.12426769f, -0.03388171f, -0.07179058f, -0.30551469f, 
    0.10648180f, 0.17332108f, 0.01482266f, -0.03408958f, -0.14910395f, 0.03206105f, 0.04359927f, 0.13027938f, 
    0.02980773f, 0.06188421f, -0.02114382f, 0.11772726f, -0.20017625f, 0.02705648f, -0.15938751f, -0.24398133f, 
    -0.20474085f, -0.34119663f, -0.12655875f, 0.28770986f, 0.03035897f, 0.14542010f, 0.01616370f, -0.02579349f, 
    0.02906504f, -0.00654930f, 0.04839068f, 0.02984011f, 0.14990254f, -0.04677949f, -0.04280672f, 0.09154772f, 
    0.25140044f, 0.01760671f, 0.03238858f, 0.03699378f, -0.01990620f, -0.05457467f, -0.09199470f, -0.14948961f, 
    -0.01498658f, -0.11536676f, 0.00994381f, -0.05754498f, 0.06004668f, 0.05647377f, 0.17795138f, 0.06706293f, 
    0.08312454f, 0.01733765f, 0.06684783f, 0.08647384f, 0.22127478f, 0.20203027f, -0.23340927f, -0.13151194f, 
    -0.00773372f, -0.13790745f, -0.09794223f, 0.07192975f, 0.08621415f, 0.10827728f, -0.00093974f, 0.05733029f, 
    -0.02030198f, -0.21202840f, -0.37949646f, 0.19986963f, 0.04476178f, -0.06654862f, 0.01570286f, 0.10563102f, 
    -0.06707490f, -0.02538274f, -0.04932745f, -0.07443841f, -0.13911600f, -0.33122328f, 0.09363557f, 0.19187617f, 
    0.05716916f, -0.05693102f, 0.05022625f, -0.03417999f, 0.01652219f, 0.08452530f, -0.10416551f, 0.00113746f, 
    0.59896004f, 0.17884710f, -0.21350171f, -0.18783970f, 0.11148003f, 0.05688776f, 0.08016917f, -0.09931631f, 
    0.15091713f, 0.11691901f, -0.02856082f, 0.19350067f, 0.45896971f, 0.30552912f, -0.06765953f, -0.30873248f, 
    -0.06465391f, -0.05927197f, -0.06731753f, 0.05349730f, 0.02588334f, -0.02299181f, -0.01050039f, 0.10072181f, 
    -0.01503317f, -0.03213245f, 0.00111102f, -0.00655801f, 0.04271979f, 0.00924670f, 0.06647784f, 0.06704704f, 
    0.02371479f, 0.00263261f, 0.02827461f, 0.04008151f, 0.05435986f, 0.02294923f, -0.07207722f, -0.18414931f, 
    -0.01645121f, 0.01122972f, 0.02896303f, 0.00649833f, -0.00248826f, -0.03978016f, 0.07426987f, -0.05655579f, 
    -0.11113072f, -0.14792664f, -0.24532671f, -0.26285511f, -0.13269754f, 0.01614957f, 0.03249589f, 0.02391100f, 
    0.11791724f, 0.06366184f, 0.06590559f, 0.04871412f, 0.06645671f, 0.18735436f, -0.03098879f, -0.25481993f, 
    -0.09869393f, -0.00809689f, -0.00291507f, 0.03140446f, 0.20390621f, -0.09233353f, 0.11792725f, -0.04245003f, 
    0.12719880f, 0.26105052f, 0.10725785f, -0.23272166f, 0.07996245f, -0.07819016f, -0.00645011f, -0.24465054f, 
    -0.05370385f, 0.02016124f, -0.05551619f, -0.00304830f, 0.00553439f, 0.07191882f, 0.08035569f, 0.12334908f, 
    -0.18092608f, -0.10041205f, -0.06623492f, -0.03127288f, 0.02768893f, 0.16634277f, 0.13922076f, -0.06980033f, 
    -0.00265185f, -0.23914896f, -0.13798162f, 0.15853265f, 0.11637343f, 0.00567457f, 0.01922105f, -0.09033944f, 
    -0.09971765f, -0.12486963f, -0.01442578f, -0.10518453f, -0.30855393f, 0.17915824f, 0.03960397f, 0.10651120f, 
    -0.02281715f, -0.02575972f, -0.11045232f, -0.06267057f, -0.18344839f, -0.05449621f, -0.10773084f, -0.06902961f, 
    0.02100988f, 0.29557648f, -0.26165679f, 0.12509936f, -0.09424338f, -0.05450822f, 0.09951455f, 0.03476625f, 
    0.08211962f, 0.08341583f, 0.05267208f, -0.02469571f, 0.08036368f, 0.02207366f, 0.42821729f, -0.35481256f, 
    0.05520295f, -0.16669400f, -0.07581479f, -0.08646560f, 0.00146456f, 0.07468837f, 0.04908516f, 0.08724501f, 
    0.15273102f, -0.09623894f, 0.12671696f, 0.02722805f, 0.09584694f, -0.14622816f, 0.01031946f, 0.20101053f, 
    -0.11972062f, 0.04170473f, -0.01865554f, -0.04056653f, -0.53857988f, -0.00330118f, -0.35057148f, -0.28025487f, 
    -0.05594432f, -0.04459955f, 0.15560935f, 0.02014217f, 0.01295277f, -0.01639143f, 0.02214269f, 0.04066842f, 
    -0.05339294f, 0.07504383f, 0.01712347f, -0.05393630f, -0.14303181f, -0.00096280f, -0.04407676f, -0.05880836f, 
    0.00171096f, 0.00491423f, 0.02455863f, 0.03907443f, -0.03398686f, 0.11422815f, 0.33919621f, -0.34222409f, 
    0.00580276f, -0.10831908f, 0.00715412f, -0.14699398f, -0.00546810f, 0.11431724f, 0.08418307f, 0.10805143f, 
    -0.34237924f, -0.06892323f, 0.07082471f, 0.08431494f, -0.05326508f, 0.07824834f, -0.11981075f, -0.00124362f, 
    0.12324535f, -0.04094417f, -0.00442714f, 0.13042836f, -0.02109132f, -0.07697409f, -0.24302739f, -0.16706258f, 
    0.16184500f, 0.07591139f, 0.04451399f, 0.06409706f, 0.13576047f, -0.04449925f, -0.06669193f, -0.03690032f, 
    -0.03364886f, -0.19625370f, -0.07346104f, -0.13950075f, 0.17245032f, 0.15417138f, 0.09088824f, 0.07669324f, 
    0.09641170f, -0.01278821f, 0.04572820f, 0.11500719f, 0.16901504f, -0.04087799f, -0.12353989f, -0.18173528f, 
    0.17111249f, -0.07458181f, -0.02369783f, 0.13881937f, -0.09836363f, -0.12036671f, -0.01279419f, -0.05926707f, 
    -0.03374490f, -0.48668593f, 0.20524171f, 0.10735170f, 0.00105482f, 0.21146813f, -0.23557770f, -0.08993053f, 
    -0.07420168f, -0.09378171f, -0.11963501f, -0.09811271f, -0.12803005f, 0.02717024f, -0.00917311f, 0.15769784f, 
    0.08956158f, -0.11378643f, 0.04085190f, -0.14169943f, 0.03442898f, -0.00720120f, 0.01179167f, -0.02340945f, 
    0.15434524f, -0.08578835f, 0.33030322f, -0.32829216f, 0.12292775f, -0.06454659f, -0.14912225f, 0.05695451f, 
    -0.22400470f, 0.07080434f, 0.05186515f, 0.01156869f, -0.27865389f, 0.23228051f, -0.27757278f, 0.28265122f, 
    -0.03350209f, -0.09609761f, -0.13200849f, -0.16204016f, 0.12509167f, -0.11651208f, 0.11401183f, 0.14591950f, 
    -0.11916119f, -0.02320079f, -0.04300880f, 0.03494960f, 0.02563819f, 0.01811174f, 0.11227265f, -0.01411829f, 
    0.14565009f, 0.17494869f, 0.08789693f, 0.10882071f, -0.22462697f, -0.03181436f, -0.05725336f, -0.03263055f, 
    0.02336022f, -0.00040641f, -0.02408586f, 0.14977618f, -0.04873072f, -0.10969388f, -0.09666067f, -0.06890440f, 
    -0.05023685f, 0.32570726f, 0.18979704f, -0.29771090f, -0.05361458f, -0.01621596f, 0.21024999f, 0.21296328f, 
    -0.02184513f, 0.01109813f, -0.00197219f, -0.00195844f, 0.20233724f, 0.11182709f, 0.08767688f, -0.11074544f, 
    -0.03738637f, 0.00205168f, -0.20405619f, -0.14792687f, -0.01752730f, -0.06324123f, 0.06097374f, 0.08046295f, 
    -0.32382587f, 0.00388911f, -0.56092364f, 0.19122902f, 0.18945989f, 0.03352572f, 0.11198960f, 0.06767791f, 
    -0.04601822f, -0.02588251f, -0.03522010f, -0.02030829f, 0.32755652f, -0.20145826f, 0.31478226f, -0.22092940f, 
    0.11956275f, -0.18013085f, -0.07819122f, 0.04373263f, 0.01126452f, -0.03486405f, 0.04218430f, 0.06734726f, 
    -0.09089396f, 0.15771052f, 0.11036020f, 0.26281390f, -0.03961110f, -0.10144629f, -0.33963996f, -0.04624216f, 
    0.08275273f, -0.15078916f, 0.09986343f, 0.01113355f, -0.10463505f, -0.26725289f, -0.18712574f, 0.04560265f, 
    -0.01290230f, 0.06721099f, 0.16375557f, -0.09484415f, 0.05217988f, 0.07166739f, -0.01628582f, -0.12381125f, 
    0.04744772f, 0.16272140f, -0.10354543f, -0.10079958f, 0.00764113f, 0.03262165f, 0.20204988f, 0.02750244f, 
    0.02496202f, 0.02488425f, 0.06877251f, 0.18020323f, 0.07785291f, -0.13064404f, 0.12104231f, -0.00326536f, 
    0.06162053f, -0.01756836f, 0.05583217f, 0.05435135f, -0.12959823f, 0.04507837f, 0.03756955f, 0.06049678f, 
    0.04376452f, 0.10424116f, 0.11989311f, 0.06656384f, 0.03761578f, -0.09463057f, 0.00351394f, 0.00649289f, 
    -0.03042825f, 0.06895056f, -0.01173107f, 0.07623637f, -0.01704205f, -0.39331073f, 0.21296903f, 0.03594635f, 
    0.02635777f, 0.14956070f, -0.19774356f, 0.15209298f, 0.08254427f, -0.01385199f, 0.07709309f, 0.06043096f, 
    0.20191061f, 0.00361192f, 0.19748759f, 0.18451130f, -0.01468884f, -0.24148811f, -0.11318741f, -0.00217820f, 
    -0.05256421f, 0.04348166f, 0.02348957f, 0.07296830f, -0.14003189f, -0.31143278f, -0.16708487f, -0.34751606f, 
    -0.24981557f, 0.12084456f, 0.02389582f, -0.04247873f, 0.18845735f, 0.06256565f, 0.04890759f, -0.02796790f, 
    -0.27502790f, -0.13829468f, -0.14877786f, 0.01465322f, 0.17078783f, 0.01418265f, 0.10101131f, -0.03561728f, 
    -0.10043804f, -0.00709463f, 0.07433385f, -0.09348029f, -0.24087694f, 0.25499046f, 0.08223609f, -0.24244890f, 
    -0.21165673f, -0.03924778f, 0.04480913f, 0.10954170f, 0.02023755f, 0.04063779f, 0.08762934f, 0.01369025f, 
    0.12285253f, -0.47521895f, 0.07814186f, -0.19951722f, 0.01272536f, 0.02705135f, 0.04464756f, 0.11964849f, 
    -0.04746406f, 0.06174768f, -0.00325448f, 0.07787611f, -0.16342646f, 0.15495059f, -0.01501973f, 0.14870365f, 
    -0.08333195f, -0.05614188f, -0.05772441f, 0.01874995f, -0.02933859f, -0.11346837f, -0.06824787f, -0.01392876f, 
    -0.48997548f, -0.09933081f, -0.05603568f, -0.66273022f, 0.03509574f, -0.17047210f, 0.06269310f, -0.04425477f, 
    -0.10979095f, 0.07769176f, 0.05982265f, 0.03796171f, 0.15417451f, 0.06636360f, 0.17853829f, -0.30853751f, 
    -0.04639524f, -0.19764103f, -0.09589063f, -0.10014789f, -0.04814829f, -0.05745905f, 0.00068198f, 0.10467235f, 
    -0.18071592f, 0.03700598f, 0.09664831f, -0.37833118f, -0.03979870f, -0.21432601f, 0.02010305f, 0.18548718f, 
    0.07145217f, -0.10850160f, 0.08508305f, 0.08753121f, 0.09425426f, -0.03495928f, 0.09128407f, -0.09382851f, 
    0.09131806f, -0.15556470f, 0.03547893f, -0.03010128f, 0.06083451f, -0.03337842f, -0.08964340f, -0.05386230f, 
    0.19253802f, 0.34905291f, -0.47897196f, -0.07490887f, -0.09548464f, 0.04335593f, 0.00066282f, -0.02570311f, 
    0.14590400f, -0.10998142f, -0.09079500f, 0.04974008f, -0.27454901f, -0.18457447f, -0.05337071f, 0.04828568f, 
    0.15130281f, -0.17269902f, -0.11016548f, 0.15544181f, -0.03008673f, 0.06816748f, -0.02985011f, -0.12434954f, 
    -0.27974206f, 0.22021763f, -0.35348889f, -0.03414061f, -0.13199438f, 0.05102911f, -0.05764422f, -0.12415820f, 
    0.21837683f, 0.04018416f, 0.05793151f, -0.14358205f, 0.10269885f, -0.11733769f, -0.15617216f, -0.07120223f, 
    0.06844690f, 0.05926026f, 0.20165288f, 0.19521287f, -0.17359379f, -0.00214812f, -0.10546963f, -0.11360426f, 
    -0.27206910f, 0.12703377f, -0.29539350f, -0.08951152f, 0.07062569f, -0.01705217f, 0.00321830f, -0.02319529f, 
    0.06390234f, -0.02360676f, -0.13088876f, -0.05829538f, -0.10394872f, -0.05358168f, -0.00944316f, -0.02473964f, 
    -0.02988943f, -0.19652076f, -0.06373165f, 0.04600760f, 0.06317557f, 0.03419337f, 0.03898480f, -0.06204689f, 
    0.11195606f, -0.34656653f, 0.00927305f, -0.09660423f, 0.12645744f, -0.02556306f, 0.10499156f, -0.01376524f, 
    -0.01017776f, -0.11434720f, -0.08375841f, -0.15528470f, -0.28605270f, -0.13018431f, -0.02242124f, 0.09118412f, 
    0.04309709f, 0.06759808f, 0.05031449f, -0.09821859f, 0.06858686f, 0.06092984f, 0.01987211f, 0.07748082f, 
    0.03926146f, 0.17098619f, -0.18311450f, 0.05266088f, 0.11730020f, -0.01504512f, 0.02248578f, 0.00018029f, 
    0.10781298f, -0.00163149f, -0.00725431f, 0.05594610f, -0.11857729f, 0.10794011f, 0.20071787f, 0.26605219f, 
    0.01036460f, 0.02757230f, -0.13186939f, -0.08154807f, 0.03585521f, 0.04244287f, 0.00054569f, 0.14591795f, 
    0.17079520f, -0.58578712f, -0.17766547f, 0.10398719f, 0.07703350f, 0.22816174f, 0.00767282f, 0.10750652f, 
    -0.00787876f, -0.06751829f, 0.00158280f, -0.12175851f, 0.05600929f, 0.21243328f, 0.05799466f, -0.08867969f, 
    -0.08731289f, -0.06657185f, -0.05533881f, -0.04614982f, 0.14338751f, 0.01894149f, -0.02006016f, 0.09299588f, 
    -0.17159107f, 0.08476068f, -0.13309836f, -0.38815036f, -0.08618442f, -0.18406205f, -0.13699561f, 0.18505417f, 
    -0.01350247f, -0.03479812f, -0.03175404f, -0.02119579f, -0.03667022f, -0.03065059f, 0.07398868f, -0.18245396f, 
    0.02512913f, -0.16885951f, -0.06012375f, -0.00034356f, -0.00429528f, 0.01275114f, 0.03363690f, 0.06760053f, 
    0.19622527f, 0.00341473f, 0.34947330f, -0.09607129f, 0.16358529f, -0.18102908f, 0.04828531f, -0.06919345f, 
    -0.11920714f, -0.18660279f, 0.03631284f, 0.11009720f, -0.10969603f, -0.34681153f, -0.34176922f, -0.02288959f, 
    -0.02767428f, -0.02292175f, 0.11948475f, 0.17575999f, 0.01509377f, -0.00384436f, -0.00106476f, -0.04888739f, 
    -0.13412695f, 0.12846899f, 0.18235964f, -0.13666040f, -0.06809993f, -0.11294676f, 0.09479947f, 0.18713962f, 
    0.01272248f, 0.05124926f, 0.04003213f, -0.00999611f, 0.35206956f, -0.20296356f, 0.46146044f, -0.15823947f, 
    0.08375485f, -0.09929779f, -0.00127059f, -0.00976816f, -0.08278735f, 0.04348851f, 0.12785277f, -0.07538432f, 
    -0.78186876f, -0.07244595f, -0.42525899f, 0.18136691f, 0.10734975f, -0.18222646f, -0.03003377f, -0.24506170f, 
    0.07679112f, -0.04323326f, -0.18865909f, -0.18710154f, -0.61826301f, -0.38704348f, 0.28596461f, -0.21783765f, 
    0.00453043f, 0.12102076f, -0.38170397f, 0.20238329f, 0.06074065f, -0.02729907f, 0.05297104f, 0.07088366f, 
    0.09165275f, -0.05071810f, -0.05692259f, -0.07293975f, -0.09360423f, -0.06650720f, -0.13524857f, 0.01346638f, 
    0.20445456f, -0.04029229f, -0.00257292f, -0.01557989f, -0.15342054f, -0.26629174f, 0.07874970f, 0.14070462f, 
    0.00759287f, 0.13359375f, 0.07797897f, -0.03967107f, 0.07250171f, 0.06856880f, -0.02698378f, -0.01337426f, 
    -0.12206056f, 0.31474823f, 0.05626515f, 0.60359144f, 0.02996410f, 0.09763095f, -0.13847171f, 0.00136675f, 
    0.11552082f, 0.08977228f, -0.03602761f, -0.06519718f, 0.00656674f, 0.15830149f, 0.19888502f, 0.20603734f, 
    0.01614190f, -0.10348071f, -0.05842535f, -0.04384949f, -0.02637013f, 0.00660990f, 0.11512069f, 0.00966944f, 
    -0.20084327f, -0.29436260f, -0.05517565f, -0.05275560f, 0.01933635f, -0.01367597f, -0.06388611f, 0.07872008f, 
    0.05075166f, -0.02172935f, -0.01548496f, 0.01344510f, -0.04406630f, -0.16760617f, -0.13067816f, 0.01581438f, 
    0.02937697f, 0.02575282f, 0.11846617f, -0.03744695f, 0.00196715f, 0.06997532f, -0.08684058f, -0.18059102f, 
    0.05145246f, 0.05251650f, 0.39402938f, -0.45598552f, -0.00868607f, -0.10429174f, -0.00372800f, -0.01716070f, 
    0.04208447f, 0.01533736f, 0.06967131f, 0.05742483f, -0.20215558f, -0.01143462f, -0.35332963f, 0.11332007f, 
    0.13588215f, 0.01735407f, 0.16812146f, -0.00547464f, 0.08988180f, 0.04368047f, -0.00026537f, 0.00905517f, 
    0.02109686f, -0.24427438f, -0.14597927f, 0.14016803f, -0.02927669f, 0.13837142f, 0.22718161f, -0.05529702f, 
    0.07542544f, -0.01488664f, 0.00611648f, 0.01624963f, -0.06907456f, -0.22877792f, -0.13139538f, 0.23350614f, 
    -0.02176964f, -0.23252706f, 0.05429560f, 0.23931754f, -0.11992647f, 0.03801887f, -0.21986595f, -0.19354643f, 
    -0.35143322f, -0.00768450f, -0.41577253f, 0.26926410f, -0.02213855f, 0.03288678f, 0.00326046f, 0.07966331f, 
    0.01570783f, 0.05029371f, -0.01040776f, 0.03121463f, 0.23897451f, -0.55196232f, 0.28671780f, 0.20818570f, 
    -0.13095486f, 0.09496079f, 0.02729577f, 0.03254041f, -0.08373598f, -0.06277689f, 0.03071005f, 0.00342849f, 
    0.14554450f, 0.01119419f, 0.13746944f, -0.07680987f, -0.03557484f, -0.10543209f, 0.02708647f, 0.05392533f, 
    0.00411968f, -0.15001920f, -0.15053532f, -0.13745143f, 0.11515350f, 0.14649905f, -0.01285344f, -0.03143910f, 
    0.08160929f, 0.15378761f, 0.12210038f, 0.01713415f, 0.01115766f, -0.02875158f, -0.08912236f, -0.05077605f, 
    0.13624932f, -0.23601045f, -0.04380044f, 0.16318770f, 0.10725046f, -0.10654256f, -0.00939684f, -0.08057413f, 
    -0.07951736f, -0.05652019f, -0.04955685f, -0.06489849f, -0.15654404f, 0.21707472f, 0.17208566f, 0.01174986f, 
    -0.01289816f, -0.13278364f, 0.11892418f, 0.11494940f, -0.05163796f, 0.02267991f, 0.16045037f, -0.04311706f, 
    -0.10901837f, -0.36260602f, -0.01037270f, -0.31295252f, -0.19990735f, -0.26758546f, 0.02249570f, -0.11174398f, 
    -0.06243734f, -0.00887897f, -0.00863985f, -0.06798347f, 0.10652189f, -0.13588008f, 0.08239780f, 0.17187653f, 
    -0.09627654f, -0.00705733f, -0.03040591f, 0.06091233f, 0.17474654f, -0.02687749f, 0.19364873f, 0.30025777f, 
    -0.45649865f, 0.11392397f, 0.08163234f, -0.03685006f, 0.04480084f, 0.07504044f, 0.06124175f, 0.03734380f, 
    -0.04426934f, 0.17750192f, 0.00909221f, 0.08342471f, 0.12891424f, 0.27420467f, -0.00164314f, -0.16963962f, 
    -0.16422375f, 0.07417618f, 0.10889300f, 0.04310696f, 0.07380662f, 0.06831361f, 0.04582247f, 0.14388581f, 
    -0.06203299f, 0.00818004f, -0.12183804f, 0.17192937f, -0.00789412f, 0.10456027f, -0.06134013f, 0.01746922f, 
    -0.03812804f, 0.06412405f, 0.00590806f, 0.04552330f, 0.36496106f, 0.24345264f, -0.05343072f, -0.27044210f, 
    -0.04694419f, -0.26527038f, 0.01913365f, 0.15464590f, -0.15450320f, -0.06033645f, -0.20423456f, -0.19965300f, 
    -0.09664939f, -0.15766333f, -0.15856731f, 0.00533566f, 0.06236746f, 0.08946237f, 0.04678792f, 0.06143592f, 
    0.02332052f, -0.07448091f, -0.11688911f, -0.22336027f, 0.03909475f, 0.08774069f, 0.05116314f, -0.01773172f, 
    -0.06253271f, -0.03060644f, 0.01931199f, 0.06691473f, 0.05269221f, 0.12630247f, 0.15281022f, 0.11022316f, 
    -0.16001108f, -0.40661508f, -0.05852894f, 0.24050510f, -0.05598002f, -0.00634328f, -0.02998775f, -0.06142664f, 
    0.05710968f, 0.05253730f, 0.07791491f, 0.06386648f, -0.12355618f, 0.14452650f, 0.12222238f, 0.09926113f, 
    0.00987513f, 0.08500295f, -0.06475759f, -0.04588503f, -0.14309725f, 0.10520001f, -0.04659236f, 0.00799682f, 
    -0.06264193f, -0.55048215f, 0.07029581f, -0.19338626f, -0.13048798f, -0.07063069f, 0.05380351f, -0.15001042f, 
    -0.18034099f, -0.01897413f, -0.07723052f, -0.00645319f, 0.01967672f, 0.02854717f, -0.00223569f, 0.13950802f, 
    -0.08095477f, -0.04967096f, -0.06267513f, 0.00001949f, -0.01646402f, 0.11968181f, 0.02276154f, -0.23026067f, 
    0.11839707f, -0.07407174f, 0.18899801f, 0.00531797f, -0.00615656f, 0.11498351f, 0.00059065f, 0.18345462f, 
    -0.12270164f, 0.01945206f, -0.04492755f, 0.13010435f, -0.03629681f, -0.24127324f, -0.46562648f, 0.07059352f, 
    -0.20950603f, -0.02701818f, 0.05888547f, -0.01608738f, -0.00894204f, 0.10911839f, -0.15594429f, 0.03488134f, 
    0.08875975f, -0.06468997f, 0.11506901f, 0.24135430f, -0.09216467f, -0.06301258f, -0.06139425f, -0.04159665f, 
    -0.11080445f, -0.06146684f, -0.25050521f, -0.27605122f, -0.42748708f, 0.18765420f, 0.05652147f, 0.01625368f, 
    -0.03790596f, 0.01720304f, -0.12091252f, -0.02221615f, -0.00165170f, -0.20409177f, 0.07187796f, -0.03634979f, 
    -0.27997565f, 0.21266752f, -0.13974938f, -0.05293475f, -0.00013006f, 0.03736677f, -0.03353968f, 0.02344928f, 
    -0.11361964f, -0.06448869f, -0.31393448f, -0.00407140f, -0.24689822f, 0.01151219f, -0.09467889f, 0.09732204f, 
    -0.04914932f, 0.01971394f, 0.03407883f, -0.02959033f, -0.08846015f, -0.12327874f, -0.01855759f, 0.02654853f, 
    -0.48697728f, 0.21658295f, 0.03936917f, 0.00439620f, 0.08634295f, -0.01953942f, -0.04999234f, 0.14795057f, 
    -0.02752909f, -0.01693067f, 0.01934963f, -0.04824381f, -0.00984590f, -0.03871408f, -0.35407794f, 0.01563520f, 
    0.14794444f, -0.11332892f, 0.02805071f, 0.10067244f, -0.03460712f, -0.00182544f, 0.00364152f, -0.17193426f, 
    -0.17118289f, 0.03512379f, 0.02870267f, -0.14087829f, -0.11130193f, -0.00691826f, -0.18345390f, 0.05001358f, 
    -0.02846139f, 0.00119576f, 0.02884221f, 0.01199627f, 0.07251833f, -0.20293230f, -0.00231795f, -0.10193028f, 
    -0.01562609f, 0.02029258f, 0.06553176f, 0.00301746f, -0.02394841f, -0.06614933f, -0.10593143f, -0.01674465f, 
    -0.02811783f, 0.40582818f, 0.16673560f, 0.02842011f, 0.02368101f, 0.01766157f, -0.21636191f, 0.13123257f, 
    -0.03671154f, -0.09380178f, 0.05027252f, 0.04513989f, -0.11632817f, 0.00640374f, 0.28644538f, -0.02360673f, 
    -0.02986265f, -0.01575337f, 0.08046171f, 0.02332486f, 0.02745471f, -0.01608541f, 0.05110759f, 0.07071951f, 
    -0.01126459f, -0.09523410f, 0.36899200f, 0.14077258f, 0.01777371f, 0.08413773f, 0.10048016f, -0.17958784f, 
    0.14142108f, -0.06039280f, -0.22310007f, -0.09142310f, 0.13020283f, 0.03093593f, 0.02467619f, 0.10635502f, 
    0.02262076f, -0.08464901f, 0.06844009f, 0.00992278f, -0.05812063f, 0.07273598f, -0.00460739f, 0.05473588f, 
    -0.08260308f, 0.03319066f, 0.16251731f, -0.08197391f, 0.01784614f, -0.01981902f, 0.03129459f, 0.00064276f, 
    -0.03760767f, -0.00355885f, -0.03011996f, -0.08010332f, 0.10832637f, 0.07293180f, 0.24543786f, -0.02137758f, 
    -0.02251033f, 0.12864040f, -0.01409113f, 0.05448644f, 0.01826831f, 0.10176670f, 0.26650876f, 0.15214097f, 
    -0.01371797f, -0.07480597f, 0.23825319f, 0.03249699f, 0.01616379f, 0.06000907f, 0.13698691f, -0.27733135f, 
    -0.09342185f, 0.01534534f, 0.03946515f, 0.20774592f, -0.21006614f, -0.00958436f, 0.00623544f, 0.14621529f, 
    -0.00043974f, 0.11119835f, -0.03281784f, 0.09615480f, -0.04470202f, 0.09253025f, 0.01369913f, 0.07509051f, 
    0.42526546f, -0.31352177f, 0.07112216f, -0.15693451f, -0.16299269f, -0.01762978f, 0.12018152f, 0.02496404f, 
    -0.15560354f, 0.05218215f, -0.18457085f, 0.19908170f, -0.29694009f, -0.01555727f, -0.05074046f, -0.11154414f, 
    -0.01104270f, 0.10916768f, -0.40623090f, -0.10549145f, -0.26979080f, 0.03816132f, 0.05333449f, -0.19233844f, 
    -0.00527677f, -0.25232968f, 0.34338057f, 0.03860317f, -0.02330865f, -0.00613155f, 0.10057952f, 0.04494764f, 
    0.06127720f, -0.10873755f, 0.21304600f, 0.13931696f, -0.11902285f, -0.19035071f, -0.10292894f, -0.02088790f, 
    -0.00099561f, 0.05889794f, 0.00016766f, -0.07311039f, 0.05730710f, 0.01766316f, 0.06372419f, 0.06128160f, 
    -0.37498677f, 0.28595120f, 0.01262805f, 0.22528519f, 0.02416615f, -0.00377789f, -0.08774612f, -0.11053871f, 
    0.00296532f, 0.14170308f, 0.16617735f, 0.10692312f, -0.19541524f, 0.05264473f, 0.00346092f, 0.07624266f, 
    -0.01072382f, 0.13467571f, 0.11136575f, 0.05346964f, -0.03952974f, 0.00556009f, -0.06947424f, -0.01946889f, 
    -0.23097545f, 0.23554866f, 0.14159538f, -0.05615780f, -0.05132330f, -0.07954840f, 0.07451954f, -0.02525859f, 
    -0.13686159f, 0.03648257f, -0.39121374f, -0.02764870f, 0.11522759f, 0.08780856f, 0.22205684f, -0.09623232f, 
    0.06361903f, 0.12572385f, -0.22421387f, -0.01978545f, -0.06050875f, -0.16195762f, -0.11525846f, -0.14430426f, 
    -0.50472790f, -0.35624015f, -0.03957492f, -0.09609644f, -0.06708047f, 0.17023036f, -0.11632863f, 0.04582207f, 
    0.05089349f, 0.07007167f, 0.00604415f, 0.06909985f, 0.09901123f, -0.08203438f, 0.13647708f, -0.02341193f, 
    0.00867259f, -0.08176050f, -0.00028362f, 0.07062791f, -0.22001669f, -0.08874161f, -0.15519296f, -0.27784026f, 
    0.00704814f, -0.09327827f, 0.23645528f, 0.12873639f, -0.06359404f, 0.17426069f, 0.02778842f, 0.15063569f, 
    0.08043309f, 0.01257565f, 0.17482263f, 0.07932451f, -0.04754202f, 0.08641993f, 0.11858138f, -0.06673685f, 
    -0.03174632f, -0.03694285f, -0.02804255f, 0.01447721f, -0.03644304f, 0.12085595f, -0.06555380f, -0.07337692f, 
    -0.05509125f, 0.20075054f, -0.01227883f, -0.00887194f, -0.03782803f, 0.11661901f, -0.01562726f, 0.06911597f, 
    0.11225974f, 0.11967483f, 0.09678557f, 0.01177304f, -0.21953742f, -0.30034208f, 0.21646442f, 0.01196323f, 
    -0.09148178f, 0.05800827f, 0.04346102f, 0.08207570f, -0.00958153f, 0.14923657f, 0.07002723f, -0.07775761f, 
    -0.12755598f, -0.11538047f, 0.00800260f, 0.08478877f, 0.00986839f, -0.04287429f, 0.02204577f, -0.08494031f, 
    0.00969999f, -0.10776064f, -0.06167091f, -0.00960157f, -0.36102891f, 0.02179012f, -0.26139617f, -0.17589334f, 
    -0.02297768f, -0.00975488f, 0.04278557f, 0.02113092f, 0.03482620f, 0.00692706f, -0.23170368f, -0.36315614f, 
    0.25035688f, 0.11453058f, 0.31946430f, 0.33547550f, -0.26440397f, 0.12593575f, 0.19011822f, -0.01805312f, 
    0.00310200f, -0.09398706f, -0.10375362f, 0.13884899f, -0.07906005f, -0.00439414f, 0.11051044f, 0.10000333f, 
    -0.07068669f, 0.01463998f, -0.00976513f, 0.06179132f, 0.00997343f, -0.08700509f, -0.20569968f, -0.02946457f, 
    -0.08843719f, 0.05019477f, 0.05709275f, -0.04743179f, 0.10624900f, 0.19935185f, 0.04439832f, 0.10570717f, 
    -0.02667073f, 0.04485724f, 0.14730172f, 0.03594650f, -0.35265151f, -0.11617022f, -0.00926834f, -0.21309765f, 
    -0.14892562f, -0.07676443f, -0.04559895f, -0.15043402f, 0.10978924f, 0.05516511f, -0.15558013f, -0.09219846f, 
    0.04113223f, 0.29551205f, -0.21151349f, -0.43134287f, 0.03687386f, -0.05564261f, -0.13746834f, -0.02654474f, 
    0.03836857f, 0.07597392f, 0.13044392f, 0.00351962f, -0.26697546f, 0.07541668f, 0.15090057f, -0.10715376f, 
    0.00670927f, 0.11038198f, -0.03056115f, 0.02943241f, 0.00694732f, -0.02648635f, -0.18602839f, -0.10959753f, 
    0.10227894f, -0.23475222f, -0.17886014f, -0.12353123f, -0.16478534f, 0.16879535f, -0.13570927f, -0.14775549f, 
    -0.04428360f, 0.05245226f, 0.03300567f, -0.12308220f, 0.19356646f, -0.07431696f, 0.12916037f, -0.03687269f, 
    -0.18105444f, 0.01143494f, 0.03991950f, 0.10753254f, 0.22194487f, -0.05433465f, 0.06214714f, 0.18583645f, 
    -0.06537224f, -0.00954391f, -0.24403885f, 0.02348213f, 0.13001342f, -0.04402321f, -0.12000080f, -0.04479822f, 
    -0.02380329f, -0.12323671f, -0.08096468f, -0.21683007f, 0.02046534f, -0.00184329f, -0.23971792f, 0.07789871f, 
    -0.17027463f, -0.21882319f, 0.04471745f, 0.06930916f, -0.07874407f, 0.15537791f, -0.16882886f, -0.07955452f, 
    0.04033221f, -0.30450863f, 0.32649940f, -0.16535707f, -0.16486491f, -0.11403194f, -0.11802966f, -0.07324937f, 
    0.02641277f, 0.10995854f, 0.08424082f, 0.08139490f, -0.44629470f, -0.22387873f, -0.03599813f, 0.28158885f, 
    -0.17301568f, 0.12331249f, 0.00809543f, 0.17045100f, -0.13413966f, 0.04026743f, 0.07912472f, 0.05406522f, 
    0.05212038f, -0.18734369f, 0.13926737f, 0.00609474f, -0.02482701f, 0.15689026f, -0.18738449f, -0.04390885f, 
    0.07783668f, -0.05012875f, -0.05172561f, 0.01625391f, -0.11016686f, -0.02051129f, 0.38064030f, -0.20853654f, 
    -0.03605212f, -0.02199547f, 0.00236388f, 0.07652119f, 0.02513706f, -0.02027328f, 0.07249010f, 0.01161111f, 
    -0.02791036f, 0.09774389f, -0.09481766f, 0.03357911f, 0.05716341f, 0.13823763f, 0.07178596f, 0.04759150f, 
    -0.02695393f, 0.06498712f, -0.01720434f, 0.02192833f, -0.02443089f, -0.11954880f, 0.08669857f, -0.02711206f, 
    -0.11178145f, 0.05645831f, -0.03689775f, 0.17729649f, -0.10525039f, 0.12573884f, 0.04399106f, 0.03466280f, 
    -0.39440048f, 0.09057686f, 0.02229926f, 0.12440001f, -0.07044674f, 0.09856430f, 0.12209441f, -0.27518561f, 
    -0.02423231f, 0.01516069f, 0.11754997f, -0.00015211f, 0.21114400f, 0.08743546f, 0.12793858f, -0.01999502f, 
    -0.14972807f, 0.16137041f, -0.04879545f, 0.04198090f, -0.01154439f, -0.01469276f, -0.05368326f, 0.04296261f, 
    0.17722788f, 0.30079111f, -0.10970281f, -0.24772371f, -0.06300347f, 0.08540975f, -0.05386249f, 0.05693215f, 
    -0.04318802f, -0.01178344f, 0.03602424f, -0.01872591f, -0.12244423f, 0.08190533f, 0.12910615f, -0.11435964f, 
    -0.12604527f, -0.02684084f, -0.05333365f, 0.17507580f, -0.23137443f, -0.07122620f, -0.19453752f, -0.32354668f, 
    -0.44506821f, 0.38079324f, -0.18593808f, 0.22907807f, 0.08168621f, -0.14504594f, 0.16463475f, -0.03716134f, 
    0.04341171f, -0.01432418f, 0.11607351f, 0.11604468f, 0.14280373f, -0.32925197f, 0.18052153f, -0.06435616f, 
    0.08849682f, 0.07811534f, -0.18459107f, 0.11975928f, -0.04033598f, 0.00609956f, 0.13014337f, -0.11946950f, 
    -0.32606497f, -0.05058158f, -0.03075515f, 0.28629145f, -0.05349215f, 0.01605457f, 0.18369098f, 0.30236784f, 
    -0.18677686f, 0.02575082f, 0.02358852f, 0.03891303f, 0.10772619f, -0.18559432f, 0.13704000f, -0.09537949f, 
    0.05465110f, 0.01969314f, 0.29830754f, -0.05537124f, 0.09323848f, 0.08583641f, 0.15148443f, 0.14158107f, 
    -0.32177508f, -0.38894609f, 0.05270587f, -0.15182012f, 0.05617274f, -0.01223651f, -0.19821201f, -0.16215436f, 
    -0.08075513f, -0.01237079f, -0.00841631f, 0.03267992f, 0.14135063f, 0.07262634f, 0.02071255f, -0.06164656f, 
    -0.00261400f, 0.08607555f, -0.14393935f, 0.03767502f, -0.00690397f, -0.04580908f, -0.08832414f, -0.00559539f, 
    -0.06152610f, -0.24886371f, 0.05826990f, -0.16132519f, -0.09347034f, -0.15915595f, -0.17734940f, -0.05488808f, 
    -0.05055447f, -0.02400024f, -0.10378161f, -0.06816234f, -0.25036836f, -0.02988487f, -0.13763531f, 0.27700913f, 
    -0.01333491f, -0.09798793f, 0.00880955f, -0.09485883f, 0.05532023f, 0.08161418f, -0.10910609f, 0.01873549f, 
    0.68225807f, 0.04728199f, 0.19766703f, -0.19385408f, -0.09657439f, 0.06138946f, -0.26673776f, 0.17633805f, 
    -0.11121192f, -0.01511924f, 0.00508874f, -0.00911780f, -0.00473929f, -0.06634774f, 0.20380762f, -0.22248977f, 
    -0.02160480f, -0.00365768f, 0.05083072f, 0.03489498f, -0.16778319f, -0.00098948f, -0.03192689f, -0.11793520f, 
    -0.32896829f, -0.13263889f, 0.00112557f, 0.05930630f, -0.01134090f, -0.04290601f, 0.03288260f, -0.14806372f, 
    -0.08339217f, -0.02098670f, 0.06283518f, -0.11103182f, 0.15290707f, 0.10076151f, 0.13640904f, -0.01238224f, 
    -0.08583683f, 0.00618984f, -0.07132465f, 0.02802512f, -0.14893447f, 0.00565069f, 0.06025136f, -0.04366280f, 
    0.32792032f, -0.06209509f, 0.24180673f, -0.12264419f, 0.00920047f, -0.01586419f, -0.08104961f, -0.00812855f, 
    0.03668899f, 0.14410308f, 0.16208173f, 0.14748910f, -0.12880808f, 0.00601324f, -0.21071152f, 0.32498997f, 
    -0.08697048f, -0.01341010f, -0.03852047f, 0.07805466f, -0.07931903f, -0.04120930f, 0.14177899f, 0.07562471f, 
    -0.04497712f, -0.25656667f, -0.00966797f, -0.02499199f, 0.11565971f, -0.01860600f, 0.00521427f, 0.03712218f, 
    0.05241799f, 0.02316817f, 0.15488194f, 0.12361053f, -0.51037246f, 0.25858670f, -0.14929578f, 0.14348763f, 
    -0.00236571f, 0.14259209f, 0.23919436f, -0.09820796f, -0.04793901f, -0.04716460f, 0.14869869f, 0.04294776f, 
    -0.20001639f, 0.00724374f, -0.05871544f, 0.01996030f, 0.02797507f, -0.08136360f, 0.11649589f, 0.24294411f, 
    -0.05567826f, -0.06490760f, 0.08476899f, 0.03839262f, -0.44676784f, 0.54240316f, -0.46220136f, 0.15513435f, 
    -0.15124142f, -0.05790164f, 0.17484459f, -0.02791695f, 0.00084288f, 0.01747264f, 0.01787750f, 0.11469667f, 
    0.26951689f, -0.12446960f, 0.07990640f, 0.04954256f, -0.05061189f, -0.04241970f, 0.06462683f, 0.10048701f, 
    -0.02827573f, 0.03301907f, -0.08160417f, -0.07019681f, -0.35354552f, -0.23250465f, -0.00766126f, -0.16590783f, 
    -0.12013895f, -0.12148920f, -0.12891184f, -0.05610099f, 0.03403285f, 0.09999526f, -0.01343078f, -0.00700858f, 
    -0.43436912f, 0.18629014f, -0.15560307f, 0.15323913f, -0.13487095f, 0.04912345f, 0.05118174f, 0.12832995f, 
    -0.17257686f, -0.00168079f, -0.05636761f, 0.04380174f, -0.15980630f, -0.03156670f, -0.03414574f, -0.25127199f, 
    0.16362634f, 0.07296515f, 0.08296692f, -0.12630913f, -0.00778327f, 0.04105402f, 0.06075076f, -0.01418807f, 
    0.10345203f, -0.07974426f, 0.15214017f, -0.00041872f, 0.03221521f, 0.04410257f, 0.03693731f, 0.06150629f, 
    0.12480661f, 0.05439178f, 0.15666716f, 0.02561171f, -0.22169606f, 0.05035228f, -0.21377361f, -0.06434410f, 
    0.02824418f, -0.04857290f, 0.16665015f, -0.01613574f, -0.10328935f, 0.01062533f, -0.13588421f, -0.18257369f, 
    0.23465468f, -0.38649490f, -0.21464552f, -0.14192818f, -0.00664297f, -0.01865185f, 0.03797843f, -0.04124352f, 
    0.06096938f, 0.05913361f, -0.05611111f, 0.07893435f, 0.17993790f, -0.00660967f, -0.13141027f, 0.01764027f, 
    -0.07885252f, 0.14010318f, -0.13064584f, 0.16296351f, -0.15308073f, 0.01703100f, -0.12268427f, -0.20303306f, 
    0.01166148f, 0.25066999f, 0.26727796f, 0.02097991f, 0.12456611f, 0.12096899f, 0.21909934f, -0.10522868f, 
    -0.16693859f, 0.02855743f, 0.00600273f, -0.00346700f, 0.07419644f, -0.24144737f, 0.31296608f, 0.11051718f, 
    -0.12984082f, -0.00980416f, -0.24088563f, -0.00375696f, 0.03838848f, -0.05371617f, 0.09717482f, -0.03315979f, 
    -0.11983039f, -0.01360013f, 0.07236850f, -0.23906001f, -0.18664934f, 0.05965538f, 0.09483045f, -0.09486025f, 
    0.09065315f, 0.00318236f, 0.01508620f, 0.09059647f, 0.21033999f, 0.16373748f, 0.18010195f, 0.00732756f, 
    0.04161682f, -0.13424413f, -0.08436373f, 0.11751838f, 0.15462554f, 0.00674936f, 0.01633835f, 0.02280790f, 
    0.14702575f, -0.02659883f, 0.38643253f, -0.28124592f, 0.00134627f, 0.01006143f, -0.17082393f, 0.02241855f, 
    -0.03059612f, 0.15731059f, -0.05768720f, -0.12918556f, 0.09564463f, -0.18592618f, -0.27506843f, 0.10037986f, 
    -0.09503973f, -0.25125220f, -0.14787886f, -0.07483132f, -0.00307287f, -0.02950582f, -0.14266887f, -0.08105200f, 
    0.12374678f, 0.27897179f, -0.19471394f, 0.15111162f, -0.07077168f, 0.07489604f, -0.06377459f, 0.14531061f, 
    -0.11566620f, -0.02871317f, -0.07803128f, -0.08429414f, -0.20744789f, -0.28714615f, -0.11113193f, 0.10527607f, 
    -0.01734701f, -0.11582370f, -0.00149983f, 0.01470631f, 0.04035192f, -0.08975985f, 0.09488343f, 0.02699676f, 
    0.34571746f, -0.23793736f, 0.22202587f, 0.14487791f, 0.15011261f, -0.06181365f, -0.02481265f, 0.14490181f, 
    -0.04614253f, 0.14334376f, 0.11396872f, 0.11443980f, -0.34857979f, -0.23209210f, -0.13215758f, 0.01224017f, 
    0.08251406f, -0.09369533f, 0.00485094f, -0.10436207f, -0.05611386f, 0.01516695f, 0.08603722f, -0.04280783f, 
    0.12741539f, 0.25324979f, 0.03837579f, -0.06851538f, -0.00002441f, -0.21535985f, -0.01011057f, -0.19964817f, 
    -0.15973793f, -0.10007022f, -0.07788565f, -0.03134919f, -0.02068448f, 0.18894833f, -0.14982617f, -0.20251936f, 
    -0.04525846f, 0.00386816f, 0.08878826f, 0.01616481f, 0.02913077f, 0.00065528f, 0.01291639f, 0.07956605f, 
    0.04524015f, 0.13753684f, 0.05121167f, -0.09495537f, -0.06171776f, -0.17552918f, -0.16620293f, 0.16062100f, 
    -0.00021513f, -0.06156075f, -0.09359952f, -0.10227579f, 0.08328847f, -0.17787263f, 0.01536875f, -0.27986944f, 
    -0.01665485f, -0.15286280f, 0.13941294f, 0.05496450f, 0.12583037f, 0.16942514f, 0.09897157f, 0.04268228f, 
    -0.09146114f, -0.32029581f, 0.06779227f, 0.05925328f, 0.04630969f, 0.11438760f, 0.01448764f, 0.06565372f, 
    -0.09946728f, -0.06096545f, -0.04262548f, -0.18391286f, 0.14258306f, -0.24340464f, 0.34091079f, 0.03234977f, 
    -0.07174227f, 0.00722511f, -0.07526243f, -0.11707065f, 0.07799349f, 0.04126698f, -0.11840211f, 0.08102005f, 
    0.04081780f, -0.08589345f, 0.12167613f, 0.11214539f, -0.14947730f, -0.01379967f, 0.08141058f, -0.04185848f, 
    0.04629428f, 0.09018499f, -0.00016666f, -0.15357488f, 0.08267234f, -0.42973104f, -0.17409939f, -0.36013636f, 
    0.12531380f, 0.08918385f, -0.02014677f, -0.00933138f, -0.10362770f, 0.00181573f, 0.13720554f, 0.02608963f, 
    0.23465359f, 0.03738628f, -0.02358092f, -0.25834218f, 0.04928235f, -0.07679258f, -0.25493377f, 0.38114312f, 
    -0.13367829f, 0.02112015f, -0.01975311f, -0.23934738f, -0.45288575f, -0.03006678f, -0.12789644f, 0.15001810f, 
    0.01740707f, 0.08976427f, 0.11823387f, -0.11999153f, 0.05957074f, 0.05233212f, 0.03933531f, 0.12214045f, 
    -0.07101394f, 0.04957804f, -0.07429754f, 0.05047872f, 0.06381808f, -0.01082915f, -0.02017399f, -0.02899494f, 
    0.00979775f, -0.00737047f, -0.12717713f, -0.01013001f, -0.02010875f, 0.00924574f, 0.06514581f, 0.00782416f, 
    -0.04210887f, -0.04335408f, 0.15682580f, 0.02893460f, 0.13806826f, 0.05623429f, 0.05123953f, 0.02008360f, 
    -0.41657823f, -0.14249487f, -0.18115222f, 0.04623851f, 0.09963644f, 0.03022855f, 0.08974168f, -0.00400168f, 
    -0.02226540f, 0.10002529f, 0.10206369f, 0.04263596f, -0.01124407f, -0.25237554f, -0.08378668f, 0.03844737f, 
    0.10846749f, -0.00144226f, 0.07544005f, -0.09916155f, 0.12149245f, 0.01052656f, 0.13314117f, -0.02867664f, 
    -0.21307208f, -0.18997523f, 0.01916707f, -0.13657187f, 0.02619760f, -0.14723852f, 0.18317734f, 0.00663921f, 
    0.11277571f, 0.08982731f, -0.04088363f, 0.03808644f, -0.00856185f, -0.04041005f, -0.04143474f, -0.15099670f, 
    -0.02096206f, 0.05719199f, -0.12879840f, 0.08710611f, -0.17585775f, -0.13924526f, -0.13164057f, -0.06061782f, 
    -0.05178479f, -0.07912727f, -0.18794009f, -0.23018247f, -0.05685412f, -0.07454635f, 0.15329891f, -0.05228789f, 
    0.01492991f, 0.18387832f, -0.01089928f, -0.04817492f, 0.37446064f, 0.01583396f, 0.27928078f, -0.14058574f, 
    0.02486148f, 0.04411944f, -0.18258733f, 0.06973638f, -0.14197251f, -0.04055813f, 0.11277104f, 0.06302196f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18948430f, 0.10342085f, 0.08880238f, -0.06008368f, -0.09538721f, 0.07118527f, 0.01073089f, -0.11336610f, 
    0.08445863f, -0.00617871f, 0.01667061f, -0.04382765f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
