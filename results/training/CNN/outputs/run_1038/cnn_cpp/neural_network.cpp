#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00133905f, -0.18647763f, 0.35761169f, 0.59428543f, 0.73815793f, 0.05212082f, -0.30206037f, -0.57606953f, 
    -0.37846613f, -0.07065455f, -0.30166289f, -0.21158621f, 0.22470759f, 0.03643427f, -0.13551962f, 0.12952894f, 
    -0.21722899f, -0.11980471f, 0.29945371f, -0.09269485f, -0.16386157f, 0.12863652f, -0.09559024f, 0.14968999f, 
    -0.23130342f, -0.65063745f, -0.03203880f, -0.09096739f, 0.72804475f, 0.40991440f, 0.30087277f, 0.00065377f, 
    -0.33732197f, 0.02359751f, 0.41180760f, 0.27662662f, -0.14870737f, -0.11095194f, 0.13687322f, 0.19016166f, 
    -0.15282820f, -0.18295893f, 0.06827817f, -0.09603268f, 0.06985699f, -0.23197307f, -0.04590353f, -0.13451563f, 
    0.08276471f, -0.11027747f, 0.59917206f, 0.20271303f, 0.26861754f, -0.18690592f, -0.78707373f, 0.49861351f, 
    -0.37898073f, -0.40380737f, -0.02376260f, -0.14503400f, 0.42106673f, -0.47581482f, 0.13467914f, 0.34106079f, 
    0.22250989f, -0.35341260f, 0.14620788f, -0.06572335f, 0.11191940f, 0.05146148f, -0.03092280f, -0.05766108f, 
    0.17601660f, -0.12640944f, -0.12612393f, -0.72808319f, 0.40555817f, 0.58822268f, -0.66868877f, -0.56125909f, 
    -0.58216530f, -0.01142643f, 0.40344769f, 0.06039252f, -0.23350966f, -0.16726044f, -0.02851369f, -0.12920830f, 
    0.15470731f, 0.09231742f, -0.28929362f, -0.16026355f, -0.03903903f, -0.28101787f, -0.45694998f, 0.24316920f, 
    -0.10712706f, 0.15539087f, -0.08104810f, -0.37691349f, -1.18106997f, 0.52908385f, 0.03844991f, -0.72622615f, 
    -0.39467177f, 0.17563124f, 0.09820296f, 0.18094489f, 0.43594757f, 0.50501436f, -0.30225116f, -0.21081346f, 
    0.13729635f, -0.22873896f, 0.30285388f, 0.09490099f, 0.12021228f, -0.10190376f, 0.31212443f, 0.10518625f, 
    -0.18963653f, 0.24926834f, -0.05770106f, -0.07808065f, -0.24002095f, 0.32333943f, 0.23539402f, 0.34718207f, 
    -0.00106196f, 0.06751037f, 0.09439991f, 0.26717216f, 0.13321152f, -0.15242270f, 0.14299105f, 0.11317227f, 
    0.19712843f, 0.01715859f, -0.19778924f, 0.17845400f, 0.05184986f, -0.07062863f, -0.01933970f, -0.12033138f, 
    -0.08849850f, -0.11271229f, 0.21492064f, 0.25838789f, 0.08864461f, 0.25077510f, -0.27598703f, -0.45505375f, 
    -0.74877942f, -0.62136698f, -0.50925922f, 0.29511464f, 0.17580047f, 0.06569938f, 0.01516202f, 0.42667505f, 
    0.16610210f, 0.19565687f, -0.26825854f, -0.05103222f, -0.16497815f, -0.17876224f, -0.36336690f, 0.10083599f, 
    -0.32375473f, -0.38053086f, -0.03031268f, -0.12462383f, -0.24512085f, 0.20058091f, 0.07524761f, 0.05195585f, 
    -0.25246072f, 0.32519156f, 0.51636738f, 0.24026014f, -0.73243034f, -0.36235240f, -0.04502425f, 0.10926284f, 
    -0.01499906f, -0.02381471f, -0.30211875f, -0.18969756f, 0.03846205f, 0.15619735f, 0.05502955f, -0.22784597f, 
    0.21421072f, -0.07327798f, -0.40205681f, -0.15688477f, 0.10131964f, 0.08669541f, 0.27619386f, 0.17147724f, 
    -0.41622305f, 0.27731982f, -0.12016815f, 0.44835445f, 0.08332493f, -0.12675855f, -0.50169468f, -0.08821569f, 
    0.47513142f, 0.26204243f, 0.43045110f, -0.12949163f, -0.33302864f, -0.02763532f, 0.12388644f, -0.09008157f, 
    -0.01101575f, 0.01625296f, -0.31837472f, 0.32919911f, -0.20524345f, -0.07490677f, 0.11139309f, 0.04104042f, 
    0.01579365f, -0.27336112f, 0.38062617f, 0.22714825f, -0.16529070f, 0.12788375f, -0.24067681f, -0.09532204f, 
    0.42964268f, -0.20350271f, -0.17862357f, -0.41219303f, 0.15714259f, 0.03165782f, -0.09128191f, -0.04756435f, 
    0.17387214f, 0.21446864f, -0.14009580f, -0.05533464f, 0.21192783f, 0.14282937f, -0.18208501f, -0.42200124f, 
    0.23188436f, 0.31263217f, -0.38505790f, 0.67417109f, 0.25031483f, -0.67960519f, -0.40736482f, 0.02410652f, 
    0.03024024f, 0.00881425f, -0.03530316f, -0.05954330f, 0.03671730f, 0.24118280f, -0.25184593f, 0.13485605f, 
    -0.14094540f, 0.27605253f, -0.39843264f, -0.31021762f, 0.04467517f, -0.32594284f, 0.20723017f, 0.29518881f, 
    0.26094949f, 0.31897515f, 0.14263606f, 0.27026477f, 0.17577466f, -0.08390845f, -0.30060539f, -0.54853374f, 
    0.29210591f, -0.49550468f, -0.40038615f, -0.49232551f, -0.35941410f, -0.04529328f, -0.16217850f, -0.06587881f, 
    -0.05583957f, -0.22990972f, -0.23146155f, 0.07807655f, 0.20229973f, -0.13659513f, 0.05159614f, 0.14833945f, 
    -0.15620492f, -0.24418776f, 0.10383199f, 0.18064566f, -0.13586287f, -0.67918360f, -0.53886765f, -0.32828358f, 
    -0.24591134f, 0.44937098f, 0.40513229f, 0.25210136f, 0.25281489f, 0.45441017f, 0.03353120f, 0.23232661f, 
    0.11386506f, 0.26488492f, -0.13783972f, -0.01122750f, -0.03839852f, 0.05270849f, -0.14705501f, -0.00809748f, 
    -0.06147601f, -0.00232638f, 0.23811209f, 0.10376951f, -0.18370128f, 0.25328055f, -0.05479562f, -0.24681596f, 
    0.36371067f, -0.20788471f, -0.17382585f, 0.13449226f, -0.04628878f, -0.06606830f, -0.23585936f, 0.26975375f, 
    -0.25522527f, 0.36284703f, -0.06299904f, -0.00502158f, -0.34167162f, -0.08822691f, -0.28588557f, 0.06370261f, 
    0.17957149f, 0.36289117f, -0.01878012f, 0.13523304f, 0.27781758f, 0.31016397f, 0.65233654f, 0.21380545f, 
    -0.33855391f, 0.02078738f, 0.57017565f, -0.16333669f, 0.16205645f, -0.24508283f, -0.22168705f, 0.02799017f, 
    -0.20187293f, 0.07993636f, -0.04951274f, -0.12574756f, 0.09420820f, -0.00700584f, -0.03649751f, -0.09906496f, 
    0.29306942f, -0.19234465f, -0.08229969f, 0.19587065f, -0.27210182f, 0.00296110f, -0.15075780f, -0.38546473f, 
    -0.27519384f, -0.55740088f, -0.11587097f, 0.44531658f, 0.14769109f, 0.18504809f, 0.27382401f, 0.30732009f, 
    0.33124804f, 0.32250360f, 0.03377755f, 0.01713201f, -0.16840819f, 0.28253618f, -0.16146232f, 0.10943232f, 
    0.11893664f, -0.13729776f, -0.40600568f, -0.15902863f, 0.26011166f, 0.07145650f, -0.20440465f, 0.24999018f, 
    0.51698703f, -0.48813656f, -0.61571383f, -0.38149494f, -0.60347474f, -0.11097534f, -0.26316607f, 0.33769822f, 
    0.29587525f, -0.37997398f, -0.07529074f, 0.31664082f, 0.40557221f, -0.11976547f, -0.13963632f, 0.21223955f, 
    -0.20848142f, -0.08094912f, 0.06835116f, -0.01753572f, -0.05244727f, -0.11063883f, -0.20195767f, -0.14765425f, 
    -0.15564936f, -0.43294424f, -0.72220695f, -0.02601147f, 0.69375700f, 0.66835761f, 0.82694691f, -0.42242053f, 
    -0.58086926f, -0.17958435f, 0.21657193f, -0.43074632f, -0.01974721f, -0.28322846f, 0.12506475f, -0.30027133f, 
    -0.26039821f, 0.16096079f, 0.27989936f, 0.09817544f, 0.00035098f, 0.20119914f, 0.09006984f, -0.39119518f, 
    0.02568965f, -0.05844946f, -0.63085532f, -0.69011325f, -0.36757097f, 0.57887882f, -0.15075263f, -0.25293505f, 
    -0.44399115f, 0.18219696f, 0.36357012f, -0.16938096f, 0.46819079f, 0.47915205f, 0.08110423f, 0.18992150f, 
    -0.12207090f, 0.30364802f, 0.15376201f, -0.02909451f, 0.01509855f, 0.22260705f, 0.05106147f, -0.00457786f, 
    0.00732763f, -0.10489630f, 0.04296560f, 0.03518695f, 0.56701010f, 0.18450910f, -0.41019830f, 0.19431920f, 
    -0.24704060f, -0.32368478f, -0.23741744f, 0.22842444f, -0.23695828f, -0.46060655f, 0.43578050f, -0.13957086f, 
    0.23798124f, -0.19818199f, 0.16055989f, 0.24155317f, -0.17109269f, -0.01665065f, 0.10735255f, -0.16834050f, 
    0.21426569f, -0.00545257f, -0.04607248f, 0.22655384f, -0.66927367f, -0.54068917f, -0.54946202f, -0.17342673f, 
    -0.43509954f, -0.03777279f, 0.42266333f, -0.14122340f, -0.12227314f, -0.22291413f, -0.28970349f, -0.03366228f, 
    -0.36539599f, -0.28884107f, -0.01548036f, 0.20700389f, -0.23170877f, -0.02539310f, 0.34021011f, 0.21541484f, 
    -0.00141551f, -0.05011118f, -0.28031489f, -0.46068603f, -0.08215804f, 0.64019442f, -0.08429302f, -0.49767664f, 
    -0.37769625f, -0.68355227f, 0.86210614f, 0.08992762f, 0.41257057f, -0.39821106f, -0.10591877f, 0.04221678f, 
    0.36149490f, -0.24216169f, -0.13577828f, 0.06541631f, -0.16899431f, 0.31831658f, 0.28723165f, -0.37097809f, 
    0.02145138f, -0.25858361f, 0.03255285f, -0.01128409f, -0.05440446f, 0.25538605f, -0.05221698f, -0.78339708f, 
    -0.18967210f, 0.61585826f, 0.55587804f, 0.24638669f, 0.72612768f, 0.18777110f, -0.40205660f, -0.52353394f, 
    -0.15292184f, 0.08392865f, -0.04955332f, -0.38898638f, 0.14874141f, 0.28226498f, -0.06377678f, 0.04487389f, 
    -0.08722069f, -0.15166858f, 0.05036089f, -0.09923683f, -0.16275968f, 0.09283420f, 0.18787655f, 0.13944332f, 
    0.19134471f, -0.47354412f, -0.26843286f, 0.23960140f, -0.70134598f, -0.15648505f, -0.47892016f, -0.68297100f, 
    -0.80989099f, 0.14510319f, -0.01146621f, 0.27129984f, 0.19064777f, 0.01591994f, -0.00824780f, -0.06642963f, 
    0.10365348f, 0.00378715f, 0.14025705f, -0.27309367f, 0.08657128f, 0.07616230f, -0.21986665f, -0.07919809f, 
    -0.26700452f, -0.27178097f, 0.04704069f, -0.15194699f, -0.48419183f, -0.44357425f, -0.35143939f, -0.56377804f, 
    -0.41736352f, -0.17723937f, 0.36718607f, 0.49965313f, -0.04004175f, -0.03399286f, 0.15972179f, 0.01374187f, 
    0.12614198f, 0.05779926f, -0.32908058f, -0.24393570f, -0.04426453f, 0.19060279f, 0.24427885f, 0.13486722f, 
    -0.07322249f, 0.20345409f, -0.15774921f, 0.05907710f, -0.03254692f, -0.17926589f, -0.13570523f, 0.03229708f, 
    -0.07823513f, -0.07060923f, 0.17613131f, -0.16441250f, 0.06382004f, 0.06310917f, -0.09748173f, 0.28210589f, 
    -0.17297532f, 0.13024271f, -0.04058212f, -0.20858698f, 0.01385687f, 0.23104988f, 0.36886013f, 0.27639255f, 
    0.21507028f, -0.31307593f, 0.13807674f, -0.48112598f, -0.26167250f, 0.44231227f, 0.42127210f, 0.25559339f, 
    0.28777292f, 0.09623217f, 0.17422645f, -0.07249348f, -0.13020284f, -0.35737148f, -0.28033182f, -0.19426785f, 
    -0.00008657f, -0.17002459f, 0.09685958f, 0.01191552f, 0.02065314f, -0.27899241f, -0.24921916f, -0.37228999f, 
    -0.42781410f, -0.46572429f, -0.20885973f, -0.08197343f, 0.40923655f, -0.38562170f, -0.17592554f, 0.39475659f, 
    -0.18891591f, 0.06742984f, -0.45453537f, 0.17956108f, 0.32554939f, -0.30846414f, -0.11937770f, -0.25682688f, 
    -0.17367491f, -0.16523829f, 0.38072017f, 0.08247509f, -0.09251482f, -0.03517897f, 0.33994943f, -0.09455791f, 
    -0.01554133f, -0.12969689f, -0.25025535f, -0.28224975f, -0.55000687f, 0.24226169f, -0.06913491f, -0.38037100f, 
    -0.11767973f, -0.05652811f, 0.09684700f, 0.15756391f, 0.06188210f, -0.02933073f, 0.14894643f, 0.02321256f, 
    0.20992300f, 0.32551691f, -0.07144108f, -0.07626019f, -0.14818126f, 0.02058261f, -0.28245029f, 0.21223871f, 
    0.17463490f, 0.41192949f, -0.07943638f, -0.11930049f, -0.25017348f, 0.01917347f, -0.33178359f, 0.11475365f, 
    0.29396427f, 0.12561765f, -0.05807035f, 0.26922128f, -0.06485809f, -0.33494848f, 0.22309996f, 0.44919431f, 
    -0.24107891f, -0.11872773f, 0.01845816f, 0.12616652f, 0.08106343f, -0.00186174f, -0.02998371f, 0.19767827f, 
    -0.05604467f, -0.11355945f, 0.00327854f, 0.07406690f, 0.32504204f, -0.23963934f, -0.44008145f, -0.23968194f, 
    -0.51194406f, 0.00249671f, 0.00800076f, -0.11397272f, 0.21295646f, -0.04312194f, 0.42071307f, -0.38505012f, 
    -0.02994082f, -0.08913992f, 0.11227634f, -0.23520035f, -0.03280161f, -0.04303658f, -0.08343529f, -0.22132079f, 
    -0.44086432f, -0.11496286f, -0.24614054f, -0.01522432f, 0.08120801f, 0.07698490f, 0.53107041f, -0.57908237f, 
    0.26723719f, 0.15914257f, 0.40888005f, -0.00213349f, -0.46968997f, -0.64198184f, 0.47928885f, 0.45224887f, 
    -0.07092883f, 0.23541495f, -0.18256454f, 0.14418438f, 0.12426039f, -0.13169740f, -0.15439408f, -0.04954152f, 
    0.20176655f, -0.09157611f, -0.14612573f, -0.08837681f, -0.04736410f, 0.31208801f, 0.14625013f, -0.07171968f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04333694f, -0.05292471f, 0.02718420f, 0.23971151f, -0.00474959f, -0.09310173f, 0.06983570f, 0.22849771f, 
    0.17534916f, 0.22787572f, -0.11005318f, -0.24227026f, -0.03957285f, 0.14732924f, 0.23162651f, 0.10345705f, 
    0.05681051f, 0.02514976f, 0.10444793f, 0.06385441f, 0.21660738f, 0.42932457f, 0.24843079f, -0.03101106f, 
    -0.09621846f, 0.04632040f, -0.08658461f, -0.07029346f, 0.10670006f, 0.00894480f, 0.13183057f, 0.06478476f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11963315f, -0.39577290f, -0.17526257f, 0.08229034f, 0.14907146f, 0.07597405f, -0.12616001f, 0.02059508f, 
    0.03760703f, 0.01154264f, -0.08005401f, 0.04234261f, 0.04205888f, -0.10916387f, 0.18409891f, -0.06716965f, 
    -0.02678860f, -0.01603862f, -0.02436341f, 0.08163898f, 0.10503465f, -0.05329927f, 0.03169930f, -0.10878415f, 
    0.19138633f, 0.02687149f, -0.04155385f, -0.01068648f, 0.00665329f, -0.03184710f, 0.09737871f, -0.23424843f, 
    0.14431900f, -0.31862289f, 0.02724139f, 0.01345198f, -0.07693798f, -0.04028074f, -0.04906182f, -0.04666551f, 
    0.15862504f, 0.10797055f, 0.10515264f, 0.07256127f, 0.08141230f, -0.00188147f, 0.08021621f, 0.02074387f, 
    -0.18098660f, -0.26228473f, -0.12713979f, -0.11932926f, -0.02597209f, -0.01840303f, 0.12663142f, 0.23651876f, 
    0.08162221f, -0.08614806f, 0.07582260f, 0.03531672f, -0.02923822f, 0.02809116f, -0.04408909f, -0.07534939f, 
    -0.06738371f, -0.00403952f, -0.10830709f, -0.02711360f, 0.04731123f, -0.06782957f, -0.02561507f, -0.07380000f, 
    -0.21943507f, 0.05095169f, 0.14429517f, -0.10331485f, -0.01473152f, -0.01842871f, 0.07596809f, 0.11536175f, 
    0.17168558f, 0.24496569f, -0.02545733f, -0.07039292f, 0.34060207f, -0.18097298f, -0.22668341f, -0.02518831f, 
    0.15578321f, 0.06604278f, 0.00796841f, 0.05307040f, -0.03081117f, 0.05478641f, 0.07262624f, 0.04446795f, 
    0.21749207f, -0.00502961f, 0.01032822f, 0.31968430f, 0.07184158f, -0.00262455f, 0.01754632f, 0.02746181f, 
    0.04202502f, -0.01451760f, 0.20953235f, -0.14118150f, 0.04441216f, 0.06273061f, -0.07242798f, -0.04375783f, 
    0.03752334f, -0.00635894f, 0.21000057f, -0.17629579f, 0.00344030f, -0.00332881f, 0.07068729f, 0.09893563f, 
    -0.28369677f, -0.09655061f, -0.11571693f, -0.35665560f, -0.01913358f, -0.19532049f, 0.11807323f, 0.11769453f, 
    0.08943803f, 0.21184760f, 0.10204705f, 0.00634999f, -0.05230708f, 0.05255834f, 0.19792704f, -0.08577079f, 
    0.09964009f, 0.00141137f, 0.20117331f, -0.07550452f, 0.03982729f, -0.02447252f, 0.06835304f, 0.10199956f, 
    -0.20532575f, 0.17363034f, 0.11569896f, -0.14904511f, -0.07947981f, -0.03560493f, -0.16109350f, -0.11409707f, 
    0.03105197f, 0.02592462f, 0.01785478f, -0.06180178f, -0.01443784f, -0.16692095f, -0.00378991f, -0.05744732f, 
    -0.06547027f, -0.00677022f, 0.27020988f, 0.00658182f, 0.06119218f, 0.02728114f, 0.04033038f, 0.16042380f, 
    0.29136372f, -0.12361168f, 0.16275075f, 0.08770896f, 0.08085722f, 0.14110649f, 0.04655555f, 0.00430313f, 
    0.08686974f, -0.00866716f, -0.01744397f, -0.07031420f, -0.16598460f, -0.00401852f, 0.26874101f, -0.02554725f, 
    -0.00032409f, -0.12848958f, -0.05261990f, -0.02915689f, 0.09228665f, 0.10661086f, 0.13499258f, 0.09847043f, 
    -0.07724503f, 0.31660780f, -0.17276402f, -0.20947567f, -0.04017955f, 0.19451691f, 0.08593071f, 0.21161816f, 
    0.02320160f, 0.06075944f, -0.27225485f, 0.00986253f, -0.12070384f, -0.08287387f, 0.07567595f, 0.15180056f, 
    0.19184591f, -0.04790977f, 0.10021140f, -0.05516000f, -0.01354935f, 0.23355305f, 0.04019400f, 0.05297113f, 
    -0.23097724f, -0.12695433f, -0.00730719f, 0.09232273f, -0.11269790f, -0.00332407f, 0.00005544f, -0.01042007f, 
    -0.01218667f, 0.07047547f, 0.03717923f, 0.02742420f, -0.08083104f, -0.01902830f, -0.17131980f, 0.03701465f, 
    0.23682824f, 0.22818021f, 0.13641424f, 0.01190591f, 0.09121006f, 0.01143799f, 0.03178099f, 0.02092103f, 
    -0.25045866f, -0.02506134f, 0.00542809f, 0.00915057f, 0.10313496f, 0.13102666f, 0.21177372f, 0.13025346f, 
    0.07150856f, 0.14282516f, 0.13472268f, -0.05535346f, 0.01310635f, 0.33447146f, 0.13925695f, -0.10576491f, 
    0.01711364f, 0.07473392f, 0.20031765f, 0.22954816f, 0.22853728f, 0.01779777f, 0.15063518f, 0.15702237f, 
    -0.17268167f, -0.05368748f, 0.22366118f, -0.05759422f, 0.14021319f, -0.07383565f, -0.00803553f, 0.02557609f, 
    0.05862759f, 0.07543635f, 0.02249017f, -0.11226305f, -0.37981462f, -0.15575644f, -0.08388032f, -0.00803490f, 
    0.13009028f, 0.16079433f, 0.03882726f, -0.13868503f, 0.05489968f, 0.08140007f, -0.06259382f, 0.03998823f, 
    -0.29303983f, -0.19204839f, -0.03912499f, 0.00370944f, -0.10880216f, 0.06025141f, 0.04193466f, -0.20172189f, 
    0.01684308f, 0.00965842f, 0.05555814f, 0.03607843f, -0.04098918f, -0.01171129f, -0.02191099f, 0.01046974f, 
    -0.02273440f, -0.00428824f, 0.02335481f, -0.07858609f, 0.10385137f, 0.02118065f, 0.11399744f, 0.07255539f, 
    -0.02973110f, 0.10797220f, 0.22091365f, 0.01780628f, -0.00629561f, -0.03093148f, 0.00813325f, 0.07339530f, 
    0.02031270f, -0.02187346f, 0.14269967f, -0.07610113f, 0.08448969f, -0.18331416f, 0.08808172f, 0.08323650f, 
    0.00078103f, 0.05556913f, 0.18486497f, -0.04428388f, 0.08980361f, -0.02994984f, 0.18111177f, 0.05509366f, 
    0.07412818f, 0.10266407f, -0.01724867f, -0.06956650f, 0.01827326f, 0.02619048f, 0.06744037f, -0.19899698f, 
    0.01984437f, 0.05075407f, 0.01034194f, 0.04155849f, -0.02068062f, -0.12519000f, 0.01147193f, -0.04069736f, 
    0.01558556f, 0.01349245f, -0.06031058f, 0.04561519f, -0.03843544f, -0.04676430f, 0.02530872f, -0.21110868f, 
    -0.16899277f, -0.14543469f, 0.03649577f, 0.03421170f, 0.02631272f, -0.03369177f, 0.01302612f, 0.18528017f, 
    0.14125496f, 0.12304844f, 0.08081336f, 0.06183551f, 0.12733319f, 0.09551234f, -0.20717937f, 0.33600068f, 
    0.00990644f, 0.02762491f, -0.06327814f, 0.05499810f, -0.10593942f, 0.30981031f, 0.05280190f, -0.00329191f, 
    -0.19029222f, -0.05918238f, -0.08223095f, 0.13901217f, -0.11603617f, 0.16349177f, 0.06187508f, 0.21172620f, 
    0.06110217f, -0.00398952f, 0.09623947f, -0.02640427f, -0.17117158f, 0.07078276f, 0.04029689f, 0.23491389f, 
    -0.07282712f, 0.04581124f, -0.01260221f, 0.04873349f, -0.22628556f, -0.03794242f, -0.26817524f, 0.02586272f, 
    -0.13634406f, 0.14654970f, -0.09641886f, 0.00755419f, -0.01563430f, -0.01554549f, -0.16045196f, -0.02598569f, 
    -0.05295455f, 0.09541427f, -0.06477782f, 0.08091927f, 0.10387195f, 0.08250196f, 0.10351453f, -0.03679464f, 
    -0.13331488f, 0.03664819f, -0.11698272f, -0.09053417f, 0.04542053f, -0.02128688f, 0.01454888f, 0.10453013f, 
    -0.17497359f, 0.26454720f, 0.30218667f, 0.31700638f, -0.00477044f, -0.05542074f, -0.05972870f, -0.00959429f, 
    0.02637441f, 0.16094905f, -0.01920022f, 0.00186038f, -0.03627360f, -0.10499600f, -0.05345900f, -0.07899566f, 
    0.03350143f, 0.02403786f, 0.09197288f, 0.00557682f, 0.04652621f, 0.04767074f, 0.04929682f, 0.03813711f, 
    0.34698695f, 0.21854392f, 0.13057891f, 0.01824773f, 0.00395441f, 0.15041958f, -0.01029445f, -0.12362960f, 
    0.03614464f, -0.19622529f, 0.03400882f, 0.02416881f, -0.31159970f, -0.04933893f, 0.10931411f, 0.12866177f, 
    -0.01984954f, 0.09640250f, 0.08053311f, 0.09386706f, 0.01425291f, -0.01349451f, 0.00770939f, 0.03064455f, 
    -0.30538774f, 0.16649562f, -0.07866465f, 0.06701713f, -0.00458030f, -0.00627351f, 0.05748570f, 0.02773256f, 
    0.01600492f, 0.01049731f, -0.04110719f, 0.11091121f, 0.01074504f, 0.02379267f, 0.01444167f, 0.08180652f, 
    0.04482144f, 0.04774410f, 0.03258279f, 0.17473303f, 0.06104254f, 0.05547287f, -0.02638837f, -0.09056823f, 
    0.31766468f, -0.02456466f, 0.10922293f, -0.09780585f, 0.02110317f, -0.02722355f, -0.09851188f, -0.02086639f, 
    0.05718606f, -0.16453487f, -0.07964690f, 0.01694168f, -0.06536654f, -0.06150426f, -0.16113032f, 0.02586383f, 
    0.21010867f, 0.01302155f, 0.00165942f, 0.27470255f, 0.03132801f, 0.00982155f, -0.02629485f, -0.01985749f, 
    0.03614338f, 0.01955946f, 0.11800512f, 0.19956294f, 0.04252752f, -0.08394656f, 0.07144775f, -0.02269840f, 
    0.06075467f, -0.01661209f, 0.03405382f, 0.01425519f, -0.01565967f, 0.06299493f, 0.04061406f, -0.06075420f, 
    -0.00732742f, 0.18244739f, -0.20713434f, 0.18247959f, 0.00774675f, -0.04489087f, 0.03139522f, 0.04388997f, 
    0.02803997f, -0.04123440f, -0.00114635f, -0.20475353f, -0.06146668f, 0.09602392f, 0.07584590f, 0.04494220f, 
    -0.04404209f, -0.02190007f, 0.00708655f, -0.00530579f, -0.18549302f, -0.03074694f, 0.03995932f, 0.20643368f, 
    0.02802512f, 0.08676771f, 0.05064922f, 0.13472040f, -0.03278838f, 0.00380991f, -0.08194939f, -0.05349410f, 
    0.05005798f, 0.09710132f, 0.12617245f, 0.15001291f, -0.03155390f, -0.01495138f, -0.01282109f, -0.07475647f, 
    0.07558586f, 0.00911966f, -0.01843101f, -0.10353415f, -0.16353807f, -0.20332836f, 0.12153494f, 0.30847150f, 
    -0.20714155f, 0.22860602f, -0.07440362f, 0.00902032f, 0.18107545f, -0.09296960f, 0.11729816f, -0.05808756f, 
    -0.06004839f, 0.28303006f, -0.05956387f, -0.04193556f, -0.09163492f, 0.07204232f, 0.07000341f, -0.11983372f, 
    -0.02177879f, 0.09392444f, 0.05119660f, 0.04624821f, 0.08433462f, 0.04763810f, -0.00064900f, 0.12878509f, 
    0.00164527f, -0.04102653f, 0.01903015f, 0.00965373f, 0.09312176f, 0.07502577f, -0.04644925f, 0.03561338f, 
    -0.17781903f, -0.01576986f, 0.19844249f, 0.01246341f, -0.03811581f, 0.03269045f, -0.15883568f, 0.16862269f, 
    0.01983094f, -0.00768179f, -0.02644223f, -0.02108241f, 0.40295100f, -0.10926096f, 0.10595897f, -0.04774230f, 
    0.16543496f, 0.07090608f, -0.26751974f, -0.23491529f, 0.00940139f, -0.03690332f, 0.01861218f, -0.07681018f, 
    -0.01522837f, -0.27609128f, 0.27123442f, 0.02969338f, -0.10313034f, 0.05538758f, -0.15352529f, 0.18594001f, 
    0.01031004f, -0.15914126f, 0.03760849f, -0.03272425f, -0.01787439f, 0.01995986f, -0.04498292f, -0.04454064f, 
    0.10321639f, 0.02921820f, 0.16637258f, 0.05667012f, 0.02585253f, -0.00720763f, 0.09640627f, 0.00133726f, 
    -0.18240821f, -0.01683971f, -0.00878080f, 0.00068234f, -0.04870004f, 0.05528556f, -0.03121855f, 0.05186141f, 
    0.07141449f, 0.00221075f, 0.00948819f, 0.11403804f, 0.09023710f, -0.03073866f, -0.04051409f, 0.06375466f, 
    -0.00276691f, 0.03964865f, -0.06966557f, -0.00543309f, -0.08914582f, -0.04580019f, 0.05549663f, 0.03255488f, 
    0.03593433f, 0.01708981f, -0.00185304f, 0.06083746f, -0.06198735f, 0.06609786f, -0.10164177f, 0.04747511f, 
    0.11174955f, -0.02255133f, -0.13731200f, 0.03782768f, -0.12814775f, -0.07177567f, -0.00436821f, 0.17310263f, 
    0.11780576f, 0.07534458f, 0.04108171f, -0.03342669f, -0.05107535f, 0.09269303f, -0.19926958f, -0.03700300f, 
    -0.08572792f, 0.11679669f, -0.01412476f, -0.03479009f, 0.08314438f, -0.01464687f, 0.05808156f, 0.05786342f, 
    -0.02681201f, 0.00436661f, -0.00692798f, 0.05904565f, -0.01653845f, -0.07149856f, 0.04942287f, 0.08345129f, 
    0.02177613f, -0.00914270f, 0.03507134f, 0.04117930f, -0.17694083f, -0.10859165f, -0.01617292f, 0.11886875f, 
    0.10767192f, 0.25822708f, -0.07060352f, 0.09437290f, -0.04668522f, -0.07087795f, 0.05528932f, 0.02333548f, 
    -0.08346139f, -0.03269221f, -0.03230267f, -0.09349131f, -0.43651846f, 0.18103638f, -0.12263416f, -0.14160070f, 
    -0.24864992f, 0.02405214f, 0.11660531f, 0.02945653f, 0.17211160f, -0.02840154f, 0.06814945f, 0.12974615f, 
    -0.05485772f, -0.02217343f, -0.11012787f, -0.03333832f, 0.10795614f, 0.01135852f, -0.04272370f, -0.06327452f, 
    -0.03103045f, -0.00220212f, -0.01885418f, -0.05273911f, -0.05884814f, -0.23705325f, -0.01785673f, -0.14651953f, 
    0.07634381f, 0.03462856f, -0.15209541f, -0.03598117f, 0.17433070f, 0.03287223f, 0.07548970f, 0.04408901f, 
    0.19431077f, 0.21315171f, 0.29966486f, -0.05631414f, 0.07452840f, 0.11892128f, 0.00128748f, -0.05873301f, 
    0.12680398f, -0.06262303f, 0.05711499f, -0.06299485f, -0.00058897f, 0.14690618f, -0.14026946f, 0.10704182f, 
    0.02120892f, -0.12171703f, 0.09361425f, -0.08057736f, -0.05424552f, 0.12416805f, 0.10317616f, 0.12233981f, 
    0.52556145f, -0.02505463f, -0.17752960f, 0.05624897f, 0.04307068f, 0.01693349f, 0.05595251f, 0.03760753f, 
    0.00073909f, -0.15695640f, -0.02795187f, 0.26568186f, -0.05544748f, -0.02326490f, -0.08082451f, -0.16416276f, 
    -0.02698560f, 0.05176084f, -0.07406303f, 0.04596872f, -0.12301629f, 0.01880100f, -0.03269594f, -0.14567259f, 
    -0.22998232f, 0.01736240f, 0.23505817f, 0.05899886f, 0.01750791f, -0.14628699f, 0.10665882f, 0.12564564f, 
    -0.09387012f, 0.20010222f, 0.03231969f, 0.14240868f, 0.25299391f, -0.11770378f, -0.19158772f, 0.13298973f, 
    0.05359027f, -0.12312555f, -0.02634439f, -0.03028736f, -0.12702569f, 0.00681980f, -0.03817037f, -0.09639073f, 
    0.23157842f, -0.24543637f, -0.06461138f, -0.02131799f, -0.07255702f, 0.08631259f, -0.04053501f, -0.02006654f, 
    0.23569946f, 0.00597844f, -0.00863947f, -0.13597074f, -0.06847428f, 0.09199429f, -0.15887460f, -0.11527994f, 
    0.04758696f, -0.07692757f, 0.02111206f, -0.00844940f, -0.08289885f, -0.06087871f, -0.18713836f, 0.07013496f, 
    -0.09386940f, 0.24948840f, -0.18235281f, 0.04440200f, 0.04290586f, -0.09989785f, -0.03603004f, -0.15811242f, 
    -0.00739584f, 0.14367653f, -0.07414787f, -0.14724669f, -0.20228507f, -0.09340994f, 0.20569819f, 0.10165750f, 
    -0.14595802f, -0.10173856f, 0.22370133f, 0.13215768f, -0.01912676f, 0.10714408f, 0.02081687f, -0.01953141f, 
    -0.07466535f, 0.08328276f, 0.17669871f, 0.05199436f, -0.02061661f, 0.03220217f, 0.06087744f, 0.09627877f, 
    -0.03358708f, 0.04237655f, 0.00964843f, 0.05778174f, 0.18533039f, -0.05078850f, 0.02028822f, -0.01488196f, 
    0.08395759f, -0.02627991f, 0.00413115f, -0.03875503f, -0.15033419f, -0.12862165f, -0.34538010f, -0.20794283f, 
    0.28747165f, -0.12094457f, 0.16784213f, 0.00061120f, -0.01017430f, -0.01152845f, -0.08372467f, 0.16557533f, 
    0.06396068f, 0.09323174f, 0.02831385f, 0.02521991f, 0.18186538f, 0.01913471f, 0.19414110f, -0.01316192f, 
    0.22120662f, -0.12849085f, -0.02790270f, 0.09163784f, -0.09164166f, 0.11928923f, 0.16385174f, -0.01465447f, 
    -0.27277657f, 0.09831283f, 0.13914408f, 0.03153285f, 0.01064351f, -0.09905094f, 0.16840008f, 0.10314951f, 
    -0.07103255f, 0.05156552f, 0.10736424f, 0.01458691f, -0.05606544f, -0.08859196f, 0.21032652f, 0.00587402f, 
    -0.07267376f, -0.01977234f, 0.06044389f, 0.07319209f, -0.05710862f, 0.09253350f, 0.04159003f, 0.05268042f, 
    0.09676268f, -0.12078044f, 0.18283840f, 0.27065000f, 0.11745945f, -0.09076282f, 0.02851394f, -0.00176018f, 
    0.18240082f, 0.03232918f, -0.08631357f, -0.21576761f, 0.08267365f, -0.10216208f, -0.10030290f, -0.05845732f, 
    0.16995895f, 0.08453512f, -0.15136395f, 0.07180160f, 0.06548243f, -0.12805364f, 0.01730657f, -0.21685168f, 
    -0.18186587f, -0.15594853f, 0.00323750f, 0.04571050f, -0.02551665f, -0.04951594f, 0.00114579f, 0.15371230f, 
    0.07266788f, -0.12214269f, 0.14694375f, 0.30492491f, -0.20947666f, 0.26344505f, 0.21053000f, -0.03592809f, 
    0.00436404f, 0.08658247f, 0.13323948f, 0.12849142f, -0.01255223f, -0.02129786f, 0.09294902f, 0.03429180f, 
    -0.33552241f, 0.21835281f, -0.16580686f, 0.07555280f, 0.11473568f, 0.05621881f, 0.03162133f, -0.09081822f, 
    -0.07859671f, 0.09763531f, 0.00622452f, -0.04333392f, -0.27305567f, -0.06195515f, 0.12169529f, 0.14682904f, 
    -0.01521170f, 0.11348287f, -0.10982362f, 0.04763940f, 0.10069543f, 0.07149495f, -0.00013490f, -0.06773288f, 
    -0.19155867f, -0.13095416f, -0.15611058f, 0.13275278f, -0.08226222f, -0.08932767f, 0.08493408f, -0.12366038f, 
    -0.01991775f, -0.04184781f, -0.07596777f, -0.12766415f, 0.07107986f, 0.15824033f, -0.11933500f, -0.04265277f, 
    0.03016005f, 0.01953742f, 0.12361454f, -0.09288299f, -0.00410753f, -0.06160493f, -0.20117593f, -0.14018086f, 
    -0.00032744f, -0.03652006f, 0.07971730f, 0.08668987f, 0.01285568f, -0.04619598f, 0.07493759f, 0.12535484f, 
    0.12245459f, 0.23563989f, 0.17783162f, 0.11124017f, 0.19517963f, -0.34237275f, -0.00931782f, -0.01760356f, 
    0.11395824f, -0.04332225f, -0.00361933f, 0.19605640f, 0.04144435f, 0.14740185f, 0.28950828f, 0.25317007f, 
    0.01156552f, 0.21035227f, 0.14162576f, 0.08088642f, 0.09800085f, -0.06009960f, 0.00647793f, -0.09485664f, 
    0.01805574f, 0.06053564f, 0.02381370f, -0.03470440f, -0.04409195f, -0.11779718f, -0.13749981f, -0.11218827f, 
    0.07062371f, 0.02841615f, 0.00161167f, 0.03740039f, 0.20282735f, -0.01309162f, -0.01097411f, -0.22943728f, 
    -0.14197472f, -0.15585415f, 0.03020032f, 0.07245266f, 0.03797673f, -0.14875592f, -0.06706848f, 0.09393453f, 
    -0.02785506f, 0.11685036f, -0.02978497f, -0.03284970f, 0.27729496f, -0.05776513f, -0.20697153f, 0.04301949f, 
    0.08292016f, 0.06874173f, 0.05289711f, -0.09532679f, 0.08081420f, -0.12762517f, 0.01682161f, -0.16240250f, 
    0.24925527f, -0.06604576f, 0.00643185f, -0.06037214f, -0.00929264f, -0.30883139f, 0.10671365f, 0.06576840f, 
    -0.03857702f, 0.00955716f, 0.01017663f, -0.09955709f, -0.17547685f, -0.07233505f, -0.01191317f, 0.35155267f, 
    -0.02580719f, -0.10734239f, -0.07802974f, 0.02831076f, -0.00536611f, -0.08992230f, 0.08074514f, 0.12343159f, 
    0.07187179f, 0.01793883f, -0.15094990f, -0.16625783f, 0.09457058f, 0.10438138f, 0.11753683f, -0.01854328f, 
    0.17810835f, -0.07904798f, -0.02652640f, -0.05982649f, -0.18268909f, 0.03747122f, 0.04555102f, -0.11715253f, 
    0.20242171f, -0.09395094f, 0.14041299f, 0.07049671f, 0.14264759f, 0.01845503f, -0.04731045f, -0.07336722f, 
    -0.83686274f, 0.10871015f, -0.06034942f, -0.09361516f, 0.11946473f, -0.10208901f, -0.08185627f, 0.09694330f, 
    -0.01462155f, -0.05609659f, 0.06007359f, 0.06803596f, -0.02298429f, 0.01988581f, -0.12903695f, 0.13274209f, 
    -0.00463800f, 0.01634449f, -0.10891855f, -0.09999276f, 0.11761227f, -0.02009779f, -0.13268235f, -0.04733523f, 
    -0.06814438f, 0.12444004f, 0.11812229f, -0.11526493f, -0.09914739f, -0.05382573f, 0.03355094f, 0.10533556f, 
    0.00957223f, -0.04322106f, -0.03124743f, 0.01142424f, 0.31724370f, 0.06364732f, 0.01116916f, 0.10985821f, 
    -0.07315715f, -0.09088145f, 0.02861745f, -0.01825738f, 0.08273762f, -0.08518466f, 0.00160164f, -0.00735836f, 
    -0.03081656f, 0.09117681f, -0.04401428f, 0.34229600f, 0.21155113f, -0.03103379f, -0.09524304f, 0.05861250f, 
    0.15039237f, 0.00968159f, 0.05370111f, 0.13536988f, 0.03700718f, 0.12021516f, -0.01207993f, -0.02963934f, 
    0.18144642f, 0.02006012f, 0.00020926f, 0.17429687f, 0.07776400f, -0.10465642f, 0.04264116f, 0.20454596f, 
    -0.26950899f, -0.03314510f, 0.00651885f, -0.30015010f, 0.15850756f, -0.05729744f, 0.00638183f, 0.00869209f, 
    0.16894276f, 0.10276821f, -0.10161326f, -0.06278692f, 0.10612193f, 0.18394844f, 0.19765687f, -0.23749872f, 
    -0.00669300f, -0.12967308f, -0.11337722f, 0.03176412f, -0.02991631f, 0.00136581f, 0.02600311f, 0.08242778f, 
    -0.16265564f, -0.06478968f, 0.07687493f, -0.13054921f, -0.08496705f, -0.05740368f, -0.21322456f, -0.12765166f, 
    -0.06573670f, 0.05004850f, 0.10247556f, 0.09284478f, 0.08080203f, -0.06836634f, -0.13332504f, 0.02137248f, 
    -0.06479990f, 0.00950862f, 0.04340063f, 0.01915298f, 0.13970806f, -0.00964006f, 0.00388335f, 0.10164837f, 
    0.38856295f, -0.01292933f, -0.08501577f, 0.02385422f, 0.01629015f, 0.14424190f, 0.04049363f, 0.14460285f, 
    0.05804203f, -0.11114376f, 0.06246658f, -0.01804458f, -0.29671821f, 0.01392848f, 0.16009204f, 0.20137033f, 
    -0.06013416f, 0.00266840f, -0.16780485f, 0.01227248f, -0.05199691f, 0.03624127f, 0.07741036f, 0.13496980f, 
    0.24211471f, 0.26152194f, 0.10188784f, -0.13408929f, 0.05946071f, 0.15656170f, 0.00198292f, 0.15822802f, 
    -0.02892311f, -0.07775873f, -0.04841153f, -0.05506881f, -0.12586106f, 0.08130381f, 0.06681212f, 0.14306869f, 
    -0.00689839f, 0.00833708f, 0.06449285f, 0.03746961f, 0.17039157f, 0.02077165f, 0.05894738f, -0.04080993f, 
    -0.20074274f, -0.22745042f, -0.05998585f, 0.08643037f, 0.16509964f, 0.08426858f, 0.09553524f, -0.06176171f, 
    0.08134469f, -0.05422866f, -0.05234824f, -0.00691412f, 0.14826384f, 0.06601167f, -0.15906890f, 0.00399529f, 
    0.20222865f, 0.10486279f, -0.02121085f, 0.10525464f, -0.05040187f, 0.01072041f, -0.07683541f, 0.15095933f, 
    0.04708938f, 0.24218491f, 0.09699922f, 0.07867427f, 0.07649148f, 0.14251834f, 0.10524384f, 0.13343744f, 
    0.04278151f, 0.06086274f, 0.02726453f, -0.04017882f, 0.17525961f, 0.27829003f, -0.08819699f, -0.20631199f, 
    0.08043661f, 0.08571888f, 0.05379658f, 0.17137675f, 0.15458140f, 0.09301500f, 0.12526992f, 0.16068256f, 
    0.00980380f, -0.18774724f, 0.25432444f, 0.20093156f, 0.06716914f, 0.11490165f, 0.00033111f, 0.15792076f, 
    0.20915531f, 0.03405083f, -0.06484779f, 0.01429783f, -0.11023987f, -0.03455284f, -0.08464243f, -0.39267063f, 
    -0.10882830f, -0.07594818f, 0.03561978f, -0.06488425f, -0.11886359f, -0.07452869f, -0.03897697f, -0.02335589f, 
    -0.03728333f, 0.10164476f, 0.09478249f, -0.03310952f, -0.13887431f, 0.01802329f, -0.04042337f, -0.11747850f, 
    -0.14397749f, -0.16174774f, -0.11620346f, -0.06846666f, 0.14662577f, -0.12667865f, -0.11753772f, 0.04866518f, 
    -0.00621690f, 0.05132998f, 0.05121984f, 0.07524179f, 0.18655530f, 0.08004478f, 0.04311631f, -0.03750994f, 
    -0.06388003f, -0.04339915f, -0.07005174f, 0.04124413f, 0.04587790f, -0.05122132f, -0.05076789f, -0.01672286f, 
    -0.06679486f, -0.23442730f, -0.04440494f, 0.02871666f, -0.04032089f, -0.05181906f, 0.04437985f, -0.05283659f, 
    0.03256080f, -0.03839049f, -0.11557763f, 0.15261382f, 0.09852115f, 0.06737458f, -0.11522920f, 0.02690251f, 
    -0.28740421f, -0.00713239f, -0.06538915f, 0.04725138f, -0.01026360f, 0.04723543f, -0.03066927f, 0.06815573f, 
    0.19054560f, 0.01520798f, 0.17315380f, 0.15478033f, 0.01741459f, 0.02124127f, -0.17798218f, 0.08470549f, 
    0.22556487f, -0.03599301f, 0.00938887f, -0.01070533f, 0.18562782f, -0.05337210f, -0.00946622f, -0.01902828f, 
    -0.08981098f, 0.02894094f, 0.08171431f, 0.09441920f, 0.08954749f, 0.06831007f, 0.07467604f, -0.00631862f, 
    0.06669289f, -0.12424766f, -0.04191901f, 0.02595204f, -0.10800190f, -0.00402257f, -0.20520088f, 0.21556979f, 
    0.30035111f, -0.03296686f, 0.08186253f, 0.02932007f, 0.22956666f, 0.09817837f, 0.03958937f, -0.08034083f, 
    0.04615855f, 0.28775617f, 0.15764457f, -0.11107986f, 0.02947744f, -0.20656230f, -0.04495815f, -0.02561744f, 
    -0.03903767f, -0.01173220f, 0.15385233f, -0.15559886f, -0.13765275f, -0.27230778f, -0.00264983f, 0.03361789f, 
    0.15813306f, -0.20885329f, -0.13573803f, -0.12207110f, 0.07484319f, 0.06119126f, 0.09339404f, 0.20815027f, 
    -0.53806216f, -0.20940889f, -0.06360432f, -0.47303376f, -0.00665565f, 0.05598278f, -0.17533417f, 0.00263830f, 
    0.04651055f, 0.05267505f, -0.02565876f, 0.05419914f, 0.13639678f, 0.34558237f, 0.08777463f, 0.30954930f, 
    -0.03719273f, 0.01054592f, 0.00800690f, -0.00341494f, 0.06034355f, 0.08445504f, -0.07240618f, 0.09795956f, 
    0.14180401f, 0.07621079f, 0.17336860f, 0.27777490f, 0.05415453f, 0.12011845f, 0.01140582f, 0.04089284f, 
    0.07330923f, -0.05881956f, -0.03406832f, 0.16890225f, -0.32178062f, -0.38491893f, -0.39155340f, 0.10423219f, 
    -0.03061943f, -0.10134242f, -0.15155487f, 0.07559308f, -0.23413129f, -0.03556836f, -0.05491981f, -0.12611751f, 
    0.30598423f, 0.12092887f, 0.04628133f, 0.05835269f, 0.16267636f, 0.00691149f, 0.07430232f, -0.06237068f, 
    -0.08591308f, -0.03693344f, 0.02068480f, 0.16112350f, -0.28274086f, -0.02870276f, 0.54180151f, 0.23482455f, 
    -0.02756475f, 0.05283016f, -0.12208725f, -0.03092468f, -0.04825016f, -0.03502427f, -0.01703819f, -0.20227703f, 
    -0.30886716f, -0.16909412f, 0.20540333f, -0.26524001f, 0.00335427f, -0.07454651f, -0.11052948f, -0.07364345f, 
    -0.01908188f, 0.12290773f, -0.00417896f, 0.04638780f, -0.16747966f, 0.03361789f, -0.11072384f, -0.02673534f, 
    -0.13266899f, -0.11170875f, -0.19343713f, 0.16854164f, 0.09352694f, 0.05860890f, -0.15117784f, 0.01791552f, 
    0.04863507f, 0.22298199f, -0.05524615f, 0.05221874f, 0.14678638f, 0.08888400f, -0.00806521f, -0.02540925f, 
    -0.05567297f, -0.21326949f, -0.33775470f, -0.10638992f, 0.14436835f, 0.29767519f, -0.07213438f, -0.04620861f, 
    -0.05211186f, 0.03231135f, -0.16484839f, 0.22195347f, 0.08671124f, 0.16346553f, 0.00460202f, 0.04409430f, 
    0.10706463f, -0.29571971f, -0.03285961f, 0.19713046f, 0.02327900f, -0.02532480f, 0.12722525f, -0.09976843f, 
    0.03626173f, -0.04922396f, 0.03301004f, 0.06749202f, 0.03233632f, 0.16047899f, -0.10618290f, -0.17658935f, 
    0.05368073f, 0.00546885f, 0.06062660f, 0.10048424f, 0.01425646f, -0.09431389f, -0.33942777f, -0.51274061f, 
    -0.17225030f, -0.10337228f, -0.06195135f, -0.16750990f, -0.08823788f, -0.25532576f, -0.03447142f, -0.02944365f, 
    -0.04653612f, 0.03479443f, -0.09969276f, 0.05570369f, 0.06892034f, 0.04704620f, -0.19676536f, 0.05660680f, 
    0.20422447f, -0.03256004f, 0.04649126f, -0.03498494f, -0.02190903f, -0.01157597f, 0.01412317f, -0.01668157f, 
    0.15852503f, 0.03847510f, 0.10874689f, 0.22414936f, 0.06751912f, 0.02168018f, 0.10947401f, 0.00751914f, 
    -0.02235332f, 0.09177890f, 0.04323702f, 0.14803769f, 0.11149747f, 0.06581613f, 0.37913761f, -0.29200053f, 
    -0.01223123f, -0.09351233f, 0.10729539f, 0.06052374f, 0.12947935f, 0.07057982f, 0.08813778f, -0.09021746f, 
    0.64370418f, 0.07915331f, 0.06146653f, -0.14436883f, 0.14012165f, -0.07565615f, 0.13949260f, 0.01034572f, 
    0.04977559f, 0.05928838f, -0.11669929f, -0.04250637f, -0.25072107f, -0.10338574f, -0.11167762f, -0.16181348f, 
    -0.04246910f, 0.03714622f, -0.11198401f, 0.17336665f, 0.05213077f, -0.08860884f, -0.13728710f, -0.01092814f, 
    0.29313385f, 0.19832280f, 0.14612812f, -0.03464861f, 0.13666092f, 0.12277291f, -0.05484487f, 0.09005004f, 
    0.06349029f, -0.02170020f, 0.10726437f, 0.16686736f, -0.02359383f, -0.05078149f, -0.20978527f, -0.33174288f, 
    0.03313112f, -0.04875506f, -0.05864191f, 0.00248665f, -0.11185598f, 0.01779837f, 0.06636170f, -0.05229562f, 
    0.10319796f, -0.02856255f, -0.26885027f, -0.11152037f, 0.08119979f, -0.20092045f, 0.05618772f, -0.05013530f, 
    0.02456218f, 0.05895936f, -0.08847396f, 0.08749423f, 0.21961413f, 0.30995768f, 0.12847696f, -0.08031257f, 
    0.12759386f, -0.09072583f, 0.11849137f, 0.18964778f, 0.16976993f, 0.14939193f, 0.10761625f, -0.00914112f, 
    0.34261262f, 0.27515364f, 0.11511896f, -0.14582649f, 0.18338428f, 0.18637227f, 0.13148555f, 0.09150809f, 
    0.11327812f, -0.04385283f, 0.04593136f, 0.03789534f, 0.02722031f, -0.20308034f, -0.00641248f, 0.09338912f, 
    0.10439274f, 0.06511670f, 0.08583793f, -0.00332222f, 0.10273749f, -0.09790704f, -0.14432168f, -0.15750816f, 
    0.16202870f, -0.22090028f, -0.08897606f, -0.00012523f, -0.02115545f, -0.04042655f, 0.22654498f, 0.08929224f, 
    0.22770485f, 0.20733894f, -0.10763309f, 0.13378230f, 0.05452438f, 0.02865288f, 0.14369792f, -0.06584220f, 
    -0.01100847f, 0.07288726f, 0.04214288f, 0.12029459f, 0.03649736f, 0.04588464f, 0.04039846f, 0.00925584f, 
    0.00377676f, -0.02429010f, -0.07603479f, 0.31097576f, -0.10094634f, -0.08990984f, -0.11880729f, 0.01360528f, 
    0.14149845f, 0.05575097f, -0.03634671f, 0.19314097f, -0.10764619f, -0.29455575f, 0.00844051f, 0.11997458f, 
    0.15078805f, -0.27731973f, -0.07524135f, -0.08045384f, 0.03923276f, 0.01467156f, 0.06529509f, -0.00212747f, 
    0.32275462f, 0.26315981f, -0.01037241f, 0.06578339f, 0.12488592f, 0.02875658f, 0.05691329f, -0.10106385f, 
    -0.01337906f, -0.00179762f, -0.23274240f, -0.11750920f, -0.36297569f, -0.14113946f, 0.15712778f, -0.01371706f, 
    -0.00652840f, 0.12849796f, -0.04281127f, -0.06563625f, 0.02336236f, -0.10904510f, 0.07922807f, -0.12554473f, 
    0.23270924f, -0.07615582f, 0.38948601f, -0.01895072f, 0.25571030f, 0.23461936f, -0.06121259f, -0.13225016f, 
    -0.13257292f, -0.06695412f, 0.00734334f, 0.01824423f, 0.23191379f, -0.06814257f, 0.24142385f, 0.03894027f, 
    -0.09469406f, 0.05020821f, -0.13631737f, -0.32698664f, 0.13730219f, 0.09603079f, 0.01059540f, 0.02144837f, 
    0.04795571f, 0.07292775f, -0.10979554f, -0.02700104f, -0.06329432f, 0.00833376f, -0.05410210f, 0.08004367f, 
    -0.00879048f, -0.04769787f, -0.09443987f, -0.12064700f, -0.22071804f, 0.22175387f, -0.12721346f, 0.24774314f, 
    0.00099113f, -0.02821231f, 0.01502313f, -0.01352620f, 0.12777722f, 0.06556395f, 0.02787293f, 0.15345433f, 
    0.04119361f, -0.07864945f, -0.23149809f, -0.23441975f, -0.03255245f, -0.05393400f, 0.00718565f, -0.22896603f, 
    0.09373384f, 0.03167094f, 0.02148676f, 0.20149606f, -0.02918432f, -0.05389738f, 0.13639253f, 0.08760022f, 
    0.03692981f, -0.03444578f, -0.07339736f, -0.19978485f, -0.17379540f, -0.14998372f, -0.00755265f, -0.18427801f, 
    0.16526163f, -0.23160420f, 0.01749544f, 0.02813561f, 0.00264868f, 0.01381373f, 0.04033868f, -0.02806921f, 
    0.06222777f, 0.06385382f, 0.08613669f, 0.16711944f, 0.00706331f, -0.05133339f, 0.42892319f, 0.10908882f, 
    0.04496801f, 0.03555493f, -0.12217181f, -0.21253604f, -0.14928968f, 0.07485974f, -0.08743619f, -0.24668862f, 
    0.00273906f, -0.23544748f, 0.20594709f, -0.20140673f, -0.12414621f, 0.12445138f, -0.02836958f, -0.22261563f, 
    -0.00687030f, 0.08828363f, -0.00307459f, -0.10740984f, -0.30841902f, 0.05376536f, -0.12339524f, -0.14020902f, 
    0.10384391f, 0.01084294f, -0.02067729f, -0.12656914f, -0.12201916f, 0.01499208f, -0.20379411f, -0.22078839f, 
    -0.10197511f, 0.16256632f, -0.15867995f, 0.24179572f, -0.00842975f, 0.03393311f, 0.19980960f, -0.02607886f, 
    -0.10384794f, -0.17938982f, -0.14111695f, -0.04764481f, 0.15248691f, 0.29200149f, 0.06600196f, 0.25048140f, 
    -0.15937781f, 0.12921701f, 0.09766349f, 0.22950649f, 0.01119186f, 0.12413927f, 0.10774059f, 0.07232929f, 
    0.35714996f, -0.22655948f, -0.11144929f, -0.03314095f, 0.01978080f, -0.13216639f, 0.00526294f, -0.15327321f, 
    0.08491219f, -0.04876445f, -0.02952367f, 0.15076029f, 0.11470491f, 0.00221201f, 0.11360078f, -0.14268903f, 
    0.07506695f, -0.00665563f, -0.09613102f, 0.03639102f, -0.13750271f, 0.00000529f, -0.37319061f, -0.40190470f, 
    0.07872251f, -0.03271738f, 0.06536674f, -0.09117924f, 0.16882141f, -0.10742705f, 0.03221138f, -0.06835955f, 
    -0.07801401f, 0.05895292f, -0.14743078f, 0.04085227f, 0.48525253f, -0.06073747f, -0.04459999f, 0.01545587f, 
    0.06330748f, -0.20038371f, -0.02879681f, -0.30839860f, 0.10160186f, -0.08215585f, -0.01338601f, -0.08950349f, 
    -0.09909434f, -0.15228245f, 0.27396941f, 0.00784713f, 0.03463000f, -0.13219112f, 0.09929058f, 0.22336560f, 
    0.03827894f, 0.10151602f, 0.10455421f, 0.05106049f, 0.31015769f, -0.26117131f, 0.31149283f, -0.20238641f, 
    -0.05769885f, 0.05929001f, -0.00106828f, -0.06117082f, -0.05044384f, 0.09286936f, 0.06865719f, -0.06565581f, 
    0.45168188f, -0.08404922f, 0.21410061f, -0.18076788f, -0.00219139f, 0.00493540f, -0.06363447f, 0.00495466f, 
    0.09891324f, -0.02727739f, -0.10806456f, -0.14004225f, -0.40472314f, 0.03171334f, -0.37642804f, -0.06533863f, 
    -0.04577408f, 0.02410754f, 0.05744074f, 0.03779965f, -0.05648852f, -0.15496716f, 0.00898699f, -0.29679298f, 
    0.05399673f, -0.02589104f, -0.15206224f, -0.08344586f, 0.17982809f, -0.08858158f, -0.08459659f, 0.05650691f, 
    0.21182315f, -0.02530667f, 0.08092947f, 0.27327830f, 0.01733130f, -0.29346025f, -0.00804742f, -0.15088928f, 
    0.01969566f, -0.16195646f, -0.03773472f, 0.07833530f, -0.04936427f, -0.06983247f, 0.06967837f, -0.07713310f, 
    0.00495192f, -0.05014715f, 0.04579651f, -0.19153516f, 0.07564209f, 0.01115364f, -0.12805893f, -0.10568876f, 
    -0.03725815f, 0.00819433f, -0.03426445f, 0.01477703f, 0.22244902f, 0.39059719f, 0.18071605f, 0.23940575f, 
    0.14912872f, -0.05072982f, 0.18320954f, 0.36010665f, 0.07223836f, 0.06836257f, 0.05041650f, 0.07011449f, 
    0.31305900f, 0.28540283f, 0.14278902f, 0.22955510f, 0.18188226f, 0.04119682f, 0.19885351f, 0.22369188f, 
    -0.02780452f, -0.02487837f, 0.02248790f, 0.07677378f, -0.09911713f, 0.07265455f, -0.06630972f, -0.08340362f, 
    0.07355509f, -0.06106110f, -0.00107319f, -0.01294192f, -0.14306538f, -0.26812756f, -0.17953448f, -0.22732589f, 
    0.31243059f, -0.15090348f, 0.24915354f, 0.27096581f, -0.05180979f, -0.00726408f, 0.11024895f, 0.25116339f, 
    0.06323750f, 0.26483071f, 0.11403111f, 0.17324148f, -0.01719300f, 0.07302385f, -0.05412405f, -0.10277375f, 
    0.14492086f, 0.11297078f, 0.09286214f, 0.03667044f, 0.10166799f, 0.06718410f, 0.18545173f, 0.12188219f, 
    0.05540467f, 0.31520036f, -0.01998241f, -0.07640818f, 0.09496148f, -0.15554258f, -0.06717766f, -0.02673449f, 
    0.11067311f, -0.10381268f, -0.06947330f, 0.13300399f, 0.11035338f, -0.30205998f, 0.04812973f, -0.08277456f, 
    0.04804436f, -0.01962577f, -0.07819472f, -0.09203795f, -0.10397698f, 0.04272620f, -0.19557366f, -0.21134540f, 
    0.17879325f, 0.05364180f, 0.04710048f, 0.03879929f, -0.07671324f, -0.06293611f, -0.03945723f, 0.07379705f, 
    -0.01682630f, 0.00336239f, -0.01018862f, -0.06729391f, -0.28618890f, -0.17828235f, 0.15404813f, -0.00875410f, 
    -0.09146169f, 0.10262968f, 0.05030351f, -0.14316539f, 0.03444277f, -0.08083656f, 0.04664065f, -0.01250597f, 
    0.28370181f, 0.52227926f, -0.19422875f, -0.00786156f, 0.11902334f, -0.08514058f, -0.09237352f, 0.00839970f, 
    -0.12373247f, -0.06989448f, 0.14619043f, -0.07254905f, -0.03029126f, 0.08660007f, -0.13737996f, -0.03736339f, 
    -0.02251171f, -0.07537361f, 0.16246611f, 0.00680355f, -0.01207644f, 0.15737037f, 0.05912406f, -0.04159578f, 
    -0.02831563f, -0.11708924f, 0.48582023f, 0.00682415f, 0.03063195f, -0.03737865f, -0.09191884f, -0.20244385f, 
    0.00163952f, 0.06248903f, 0.06855068f, 0.22295095f, 0.19535434f, -0.17789200f, 0.05424768f, -0.15558870f, 
    0.04615925f, 0.07966379f, 0.01087133f, -0.05206751f, -0.00806298f, -0.05190906f, 0.25160247f, 0.32094291f, 
    0.72047162f, 0.25930068f, 0.13258766f, 0.16184932f, 0.02145609f, 0.33029437f, 0.04815415f, -0.09776414f, 
    -0.22466365f, -0.09163077f, 0.08200276f, 0.19518165f, 0.25348413f, 0.12728728f, 0.05859237f, -0.04970499f, 
    0.04643012f, 0.10386632f, 0.02569220f, 0.12172771f, -0.25058711f, -0.03404869f, -0.14631888f, -0.13546570f, 
    -0.05443252f, 0.19379303f, 0.05559239f, 0.53010154f, -0.06116907f, -0.08054300f, 0.03014060f, -0.03969327f, 
    -0.09092531f, 0.28431693f, 0.14798446f, 0.19684424f, 0.15657510f, 0.35428748f, -0.19619703f, -0.05215713f, 
    -0.14098024f, -0.23071837f, -0.04090479f, -0.05336502f, -0.06928583f, -0.04459203f, 0.07454080f, -0.08673178f, 
    0.27803507f, 0.09539741f, 0.01216215f, -0.06581283f, -0.10813251f, 0.03261091f, 0.08271798f, -0.01057277f, 
    0.05174311f, 0.00643137f, -0.06522150f, -0.12982909f, 0.25286439f, 0.04184787f, 0.06974335f, -0.15180504f, 
    -0.19369067f, -0.11843110f, 0.15904143f, -0.02905179f, 0.10561204f, 0.08794839f, -0.16200323f, -0.13432099f, 
    0.08207500f, -0.25037637f, -0.07338936f, 0.29550299f, 0.14788440f, 0.11890244f, -0.08544496f, -0.00880399f, 
    -0.11620892f, -0.09262394f, -0.22549799f, -0.24759640f, -0.18334638f, -0.18751298f, 0.07895475f, -0.12778133f, 
    -0.09124485f, -0.09105357f, 0.07321326f, -0.01045220f, -0.03810750f, -0.11192834f, -0.10970228f, 0.01053504f, 
    -0.04185351f, 0.50907016f, 0.23833510f, 0.23072948f, -0.04131616f, 0.07831218f, 0.10494211f, 0.09332386f, 
    -0.11309928f, -0.07042950f, -0.13164560f, 0.01877331f, -0.09248760f, 0.09741758f, -0.05768275f, -0.03601553f, 
    0.26530743f, -0.17867172f, 0.20285970f, 0.08354952f, -0.24891840f, -0.04898527f, -0.08520623f, -0.32700509f, 
    0.15111133f, 0.10319557f, -0.04941532f, 0.36741483f, 0.03418086f, -0.09295527f, -0.12647445f, 0.06133239f, 
    -0.02466463f, 0.09896813f, 0.26185459f, 0.12532048f, -0.20990627f, 0.06964369f, 0.02156499f, 0.06532040f, 
    0.09329680f, 0.15098391f, -0.03230743f, 0.15330462f, -0.04206523f, 0.08182267f, -0.01712006f, 0.00185531f, 
    -0.16485216f, 0.00898279f, 0.01785468f, 0.17345461f, -0.16815098f, 0.04639511f, 0.11098552f, -0.17848378f, 
    0.11105415f, 0.12861988f, 0.27347699f, 0.08188710f, 0.06175968f, 0.00511714f, -0.19962487f, 0.16248332f, 
    0.13629977f, 0.01569598f, 0.25027737f, -0.02042682f, -0.16382523f, -0.01330629f, 0.01932077f, 0.11629437f, 
    -0.09458441f, 0.01329893f, 0.11634710f, 0.08654251f, -0.01326600f, -0.13556661f, 0.18336521f, 0.04879200f, 
    0.03377042f, 0.01591836f, -0.20329551f, -0.11768321f, 0.41943124f, -0.24360164f, 0.11285469f, -0.11133244f, 
    -0.10173960f, 0.01587444f, -0.19706033f, 0.06953724f, -0.18611011f, -0.15475744f, -0.07652619f, -0.16042456f, 
    0.16181943f, -0.20349234f, 0.05130901f, 0.12133520f, -0.08573730f, 0.12037703f, 0.06190608f, -0.09019858f, 
    0.09112281f, -0.11497606f, 0.04808619f, 0.00368631f, -0.13270904f, 0.22851655f, 0.14778382f, 0.17022668f, 
    -0.07038757f, -0.10498406f, -0.01347209f, -0.04971188f, -0.18140925f, 0.09231361f, -0.20351401f, -0.07465120f, 
    -0.02254077f, 0.03113599f, -0.29916659f, 0.38258645f, 0.20127815f, 0.01121940f, 0.33478284f, -0.03069992f, 
    0.08082304f, 0.23605494f, -0.00178821f, -0.08047058f, -0.03458335f, -0.28795165f, -0.04196146f, 0.11990847f, 
    -0.13299875f, 0.12590288f, -0.18590254f, 0.00398485f, 0.01733649f, -0.11543022f, 0.04679104f, -0.14565285f, 
    -0.12535498f, -0.16921465f, -0.23243518f, 0.03143873f, -0.14246210f, -0.07353660f, -0.11882544f, -0.08542322f, 
    0.02255290f, -0.00919629f, -0.14018279f, -0.10988029f, -0.03792464f, 0.07997216f, 0.08065078f, -0.06982100f, 
    0.01822413f, 0.04137298f, 0.02625549f, -0.03830295f, -0.13260059f, -0.18661548f, -0.16771235f, -0.04603619f, 
    -0.02608060f, 0.20905030f, -0.07240002f, 0.08047231f, 0.02961237f, -0.04159057f, -0.00487292f, -0.07338106f, 
    0.21041813f, 0.32197329f, 0.38232151f, 0.41530237f, 0.14832386f, -0.20470026f, -0.06389172f, 0.13631053f, 
    -0.13011798f, 0.06975991f, -0.13638350f, 0.29511279f, 0.07636315f, 0.11954180f, 0.11635673f, 0.03098055f, 
    -0.15928140f, -0.18159461f, 0.10412704f, 0.09668104f, -0.11195603f, 0.16541745f, -0.06978720f, 0.07776047f, 
    0.12140393f, 0.15904847f, -0.04165165f, -0.00770804f, 0.00765259f, 0.24130817f, -0.11810434f, -0.00383886f, 
    -0.15850469f, -0.00060998f, 0.08807312f, 0.01102601f, -0.00562145f, -0.06568006f, 0.14831769f, -0.14084801f, 
    -0.06128911f, -0.09562346f, -0.07901878f, -0.08226555f, 0.11892799f, -0.12150460f, 0.07168313f, -0.06679644f, 
    -0.11209350f, 0.11460412f, 0.02504321f, -0.22525223f, 0.20152870f, 0.08480004f, 0.04227822f, -0.14512184f, 
    0.01876105f, 0.12705745f, -0.04726744f, 0.19374090f, -0.11562230f, 0.06635025f, 0.08377237f, 0.03070059f, 
    0.01697281f, 0.14093889f, 0.22022137f, -0.08825083f, -0.18845519f, -0.08062170f, 0.07420180f, -0.12457501f, 
    0.00115978f, -0.02943582f, -0.10905154f, 0.03551147f, 0.40359202f, 0.16644959f, 0.11267991f, -0.20216873f, 
    -0.05317780f, 0.05189858f, -0.08300428f, -0.02822167f, 0.12671562f, 0.03317213f, 0.12094595f, -0.01909718f, 
    -0.18832698f, -0.13175625f, -0.09477476f, -0.13045360f, -0.01133840f, 0.03297311f, 0.02928475f, 0.11650232f, 
    0.14758369f, -0.02175481f, -0.00379082f, -0.09510165f, -0.03802701f, 0.12875415f, 0.00108990f, 0.29750952f, 
    0.08275262f, 0.15190189f, 0.09244079f, 0.16895184f, -0.01826175f, 0.07909925f, -0.13607122f, -0.19343391f, 
    0.11576657f, -0.06096005f, -0.11498693f, -0.15086257f, -0.01270938f, -0.03199838f, -0.06713061f, 0.09263491f, 
    0.02802820f, -0.02169836f, -0.01944870f, -0.06268159f, -0.13517538f, -0.00354787f, 0.06909191f, -0.02761060f, 
    -0.17763932f, -0.13198648f, -0.13235651f, -0.00584045f, 0.03300437f, -0.08481488f, -0.06227478f, 0.04874329f, 
    -0.23986302f, -0.31343386f, -0.24335472f, -0.13940427f, 0.07325073f, 0.09953533f, -0.02023774f, 0.07408228f, 
    0.13819787f, -0.04279217f, -0.05849282f, -0.05348039f, 0.22037353f, 0.04069340f, 0.33979261f, 0.12175141f, 
    -0.02522163f, 0.09971254f, -0.06699724f, -0.01552399f, 0.06728490f, -0.00483816f, 0.04207193f, 0.04506090f, 
    0.29676551f, -0.05894916f, 0.27033648f, -0.09173164f, 0.05871295f, 0.08597445f, -0.11505691f, 0.00897768f, 
    -0.01243739f, 0.13664609f, -0.07877076f, -0.00752425f, -0.04536303f, 0.08954317f, 0.02342709f, 0.08354186f, 
    0.09491308f, 0.08462580f, -0.04047515f, 0.02389219f, -0.14116473f, 0.05439438f, 0.03390323f, 0.28465697f, 
    -0.20061736f, 0.07836551f, -0.14028037f, -0.02579710f, -0.08024119f, -0.06839895f, 0.08711506f, 0.01827246f, 
    0.01882761f, 0.18909186f, 0.05714251f, 0.12994434f, 0.12374634f, 0.06822622f, 0.09182813f, -0.11622373f, 
    -0.02582063f, 0.10742152f, 0.07433512f, -0.00753356f, -0.06387292f, -0.04019078f, 0.03964055f, 0.07873838f, 
    0.01866128f, -0.32287315f, -0.22459085f, -0.18446274f, -0.06106002f, -0.02759037f, -0.09212704f, -0.03746425f, 
    0.04280065f, 0.01957708f, 0.01879656f, -0.04633577f, -0.03269298f, -0.04585617f, -0.01761589f, 0.04254618f, 
    -0.10267337f, 0.03521612f, 0.03975262f, -0.01996777f, 0.08890981f, 0.12827574f, 0.06559456f, 0.12599228f, 
    -0.02349677f, 0.13410285f, 0.10093115f, 0.07695553f, -0.05459420f, -0.20512851f, 0.05766660f, -0.01336708f, 
    0.08567812f, -0.09928077f, -0.12420837f, -0.15344507f, 0.22595429f, -0.19604868f, -0.14189447f, -0.18565717f, 
    -0.12432736f, -0.01065922f, 0.04863172f, -0.06190021f, 0.08647567f, -0.02502074f, -0.02332341f, 0.06026834f, 
    0.06450004f, -0.26792458f, -0.19092467f, 0.00311776f, 0.08445708f, 0.12110253f, -0.01936268f, 0.15616427f, 
    -0.03169740f, -0.14298815f, 0.00491391f, 0.05321119f, 0.12350344f, 0.43325335f, 0.21472317f, -0.33770707f, 
    0.04617041f, -0.10455593f, -0.03514300f, 0.07959694f, -0.11324334f, 0.10283216f, 0.09764618f, 0.05696313f, 
    0.24967349f, -0.30872688f, -0.09911093f, -0.12782249f, 0.11029479f, 0.03767590f, -0.09962778f, 0.05964466f, 
    -0.08189776f, -0.11019507f, 0.05228457f, 0.06966950f, -0.28108665f, 0.15836661f, 0.10172777f, -0.04955677f, 
    0.00966795f, -0.00767617f, 0.14140160f, 0.04959926f, -0.02075310f, 0.13819548f, 0.12116862f, 0.13421823f, 
    0.19776998f, 0.10548674f, -0.22064924f, -0.00326662f, 0.14091128f, 0.02860558f, 0.09448371f, 0.08896925f, 
    -0.13527095f, -0.03699978f, -0.03104453f, -0.00929828f, -0.22875924f, -0.00915558f, -0.16150889f, -0.10086673f, 
    -0.06870110f, -0.01093008f, -0.01013192f, 0.00617208f, 0.09769870f, -0.11215623f, 0.07724316f, 0.11350082f, 
    0.15790226f, 0.24970716f, -0.12363762f, -0.20242539f, 0.00366971f, -0.14718322f, 0.06545068f, -0.11885162f, 
    -0.15477772f, 0.03036242f, -0.02514316f, 0.05612266f, 0.06146056f, 0.08032112f, 0.01801171f, 0.02495931f, 
    0.18849599f, 0.02322970f, 0.12676060f, 0.01356748f, -0.10415636f, -0.02613697f, -0.00289382f, 0.13168839f, 
    0.16921990f, 0.03265414f, 0.08658887f, 0.06954668f, 0.22983994f, 0.19403191f, 0.04814009f, 0.11670354f, 
    -0.06112744f, -0.09779141f, 0.06800164f, -0.02122694f, -0.11896273f, -0.12189316f, 0.04538978f, 0.00195701f, 
    -0.00253243f, -0.12834650f, 0.10086776f, 0.09483480f, -0.01804832f, 0.09872229f, 0.01522135f, 0.05551116f, 
    0.17641744f, -0.05295887f, -0.08424700f, -0.06907191f, 0.03878964f, 0.03046267f, 0.12808740f, -0.05149878f, 
    -0.16623288f, -0.04910716f, -0.07155682f, -0.34123501f, 0.04744203f, 0.12775207f, 0.07203749f, -0.03955568f, 
    0.08620245f, -0.02539555f, 0.22882263f, 0.04199545f, -0.06391105f, -0.09656190f, -0.16322963f, -0.09291688f, 
    0.10567833f, -0.03022413f, -0.08872993f, 0.01418663f, 0.03194391f, 0.00645055f, 0.01526064f, 0.01476781f, 
    -0.14131027f, 0.07742597f, 0.05234959f, -0.02150711f, 0.06236606f, -0.07385560f, 0.05806027f, -0.17783116f, 
    -0.03150758f, -0.08948941f, -0.03904508f, -0.03194898f, 0.05598323f, 0.10813621f, -0.02052017f, 0.03873628f, 
    0.09102806f, -0.02220317f, -0.09894873f, 0.01861211f, 0.00262530f, 0.20112075f, 0.00622695f, 0.00456822f, 
    0.16216376f, -0.00251264f, -0.08806687f, 0.14950788f, 0.22818151f, -0.03821117f, 0.19186006f, 0.23255487f, 
    0.10915289f, 0.02999814f, -0.01062783f, -0.15908153f, -0.03952792f, 0.05570211f, -0.05818699f, -0.11764932f, 
    -0.25853646f, 0.39548442f, -0.16778290f, -0.00899785f, -0.17104162f, 0.08775710f, -0.16509096f, -0.22331081f, 
    -0.06240732f, -0.10214645f, 0.05755938f, -0.00421114f, 0.22128671f, 0.24217232f, -0.28038532f, -0.49948770f, 
    -0.11352294f, 0.04619453f, 0.01722423f, -0.00561343f, 0.12767978f, 0.05607453f, 0.14155345f, -0.02486687f, 
    -0.41210827f, -0.09802551f, 0.20510195f, 0.00355260f, -0.04935508f, 0.00598352f, -0.05215192f, -0.04280492f, 
    -0.01100047f, 0.05739342f, 0.08950075f, 0.03134180f, 0.31227249f, 0.02294783f, 0.01824564f, 0.26823407f, 
    0.03908129f, 0.05821925f, 0.08426976f, 0.02127558f, 0.00019906f, 0.08145494f, 0.09415326f, 0.06709278f, 
    1.03214073f, -0.20590225f, -0.03792810f, 0.23145944f, 0.11738446f, 0.07137872f, 0.05432032f, -0.04864201f, 
    -0.16049214f, 0.06775242f, 0.06063260f, 0.13330674f, -0.25880837f, -0.03978225f, 0.06904776f, -0.29147792f, 
    -0.15495045f, -0.16237657f, -0.12003095f, -0.03217297f, -0.04215200f, 0.01389006f, -0.09883910f, 0.01438282f, 
    -0.23722181f, -0.10093708f, -0.05494757f, 0.23851521f, 0.09059996f, 0.05795101f, 0.09338537f, 0.01421267f, 
    0.07251680f, 0.03252282f, 0.01016553f, -0.00611726f, 0.12960429f, 0.18096587f, -0.11636610f, 0.16981192f, 
    0.01830911f, -0.08818644f, 0.01564174f, -0.00874676f, -0.01296362f, 0.06985628f, 0.07024577f, 0.10371806f, 
    0.43590936f, 0.08694638f, -0.01837963f, -0.33581147f, 0.00005800f, 0.03057815f, 0.07134468f, -0.12382770f, 
    0.10512194f, 0.02080113f, -0.01880139f, -0.06838178f, 0.16782917f, 0.00185115f, 0.23109545f, -0.01814860f, 
    -0.12799747f, 0.01472786f, 0.02463201f, -0.01720749f, -0.03377818f, 0.10966053f, 0.00267841f, 0.00970844f, 
    0.09941833f, -0.08624644f, -0.00141873f, 0.35434124f, -0.09202684f, 0.01960022f, 0.03947434f, 0.06782893f, 
    0.00078623f, 0.20767406f, 0.13532881f, 0.16532229f, -0.24644566f, -0.32597989f, 0.11933916f, 0.23569643f, 
    -0.00551968f, -0.00978029f, 0.20700072f, 0.00419530f, 0.04325056f, -0.03277397f, -0.11557362f, -0.03582067f, 
    -0.38336530f, 0.00684126f, 0.05072295f, 0.06352129f, -0.05589537f, 0.07587805f, 0.10486622f, -0.01038236f, 
    0.04629438f, 0.11535162f, 0.03143157f, 0.04768147f, -0.12828377f, 0.04522585f, -0.09231775f, 0.11073735f, 
    0.00576538f, 0.01126561f, 0.14032175f, 0.00297930f, -0.05509662f, 0.19221896f, 0.17641684f, -0.01148848f, 
    -0.11667646f, 0.16366459f, 0.33823818f, 0.30577198f, -0.07518897f, -0.10746490f, -0.06477403f, -0.05736275f, 
    0.03348968f, -0.05449023f, 0.00679662f, 0.01801075f, -0.02691991f, -0.09716512f, -0.14947154f, -0.24198565f, 
    -0.03951218f, 0.05054987f, -0.02389171f, 0.01817658f, 0.00458218f, 0.11976850f, 0.10158715f, 0.15840808f, 
    -0.16380657f, -0.14876637f, -0.09825693f, 0.19081210f, 0.09061382f, 0.10132556f, 0.07587726f, -0.01820596f, 
    0.01910547f, -0.02581727f, 0.06451765f, 0.05972502f, -0.01668436f, 0.55902898f, -0.08308508f, -0.08225990f, 
    -0.01092077f, -0.12180483f, 0.06781370f, 0.10667241f, -0.08283220f, 0.09131553f, 0.06762817f, 0.13592021f, 
    0.01008589f, -0.06284139f, -0.17997684f, -0.07184148f, 0.05300732f, 0.07997276f, -0.08634771f, 0.02935462f, 
    -0.17520860f, -0.09658547f, -0.04098711f, 0.01761413f, 0.05854337f, -0.15752600f, 0.39137301f, -0.24863689f, 
    -0.00015819f, -0.03841960f, 0.01576686f, -0.00965375f, -0.08512790f, -0.03932159f, 0.14107372f, 0.15253191f, 
    -0.02296946f, -0.20498967f, -0.11018247f, 0.13577923f, -0.05426305f, -0.06125395f, -0.00876663f, -0.01303680f, 
    -0.10829004f, -0.01491192f, 0.00807854f, -0.09016665f, -0.32153091f, 0.14493576f, 0.36378914f, 0.40347430f, 
    -0.02628983f, 0.05226279f, 0.07443059f, -0.09799871f, 0.01450232f, 0.01497885f, 0.04927045f, 0.15535651f, 
    0.06198725f, 0.60149109f, -0.34478658f, -0.15476459f, -0.04655784f, -0.04816449f, 0.03908433f, -0.01741114f, 
    -0.12576361f, -0.00776607f, -0.02132484f, 0.04590156f, -0.19595508f, -0.29572707f, 0.12821639f, 0.23446737f, 
    0.05907277f, 0.16194390f, -0.10129912f, -0.01567434f, -0.01399186f, 0.02494516f, 0.01815499f, 0.04151166f, 
    -0.11784784f, -0.36207411f, -0.19768228f, 0.15039438f, 0.17256311f, -0.01143498f, 0.00541648f, 0.05049260f, 
    0.00418715f, 0.04318200f, 0.02461718f, 0.03747135f, -0.21844356f, -0.09046508f, 0.08182812f, -0.16262908f, 
    -0.00231792f, -0.04537471f, -0.03995465f, -0.12885727f, -0.04420435f, 0.17200136f, -0.06658120f, 0.11895040f, 
    0.03659036f, 0.29347295f, -0.13834292f, -0.07344614f, 0.05212645f, 0.00426390f, -0.03673576f, -0.12169738f, 
    -0.05746455f, 0.08219206f, 0.05355203f, -0.15448855f, 0.24202237f, -0.16350546f, -0.01557056f, -0.03672702f, 
    -0.05615321f, -0.07604938f, 0.11986576f, 0.09425876f, -0.07646848f, -0.00202531f, -0.12458799f, -0.06078272f, 
    0.33302853f, -0.08665662f, 0.12273891f, 0.08949157f, -0.02071559f, -0.01993208f, -0.01867961f, -0.01110185f, 
    -0.19026507f, 0.16440839f, -0.07342146f, -0.09725293f, -0.03447049f, -0.04447400f, 0.00494481f, -0.38916495f, 
    -0.18137497f, -0.12388354f, -0.15353040f, -0.03881145f, 0.06192755f, 0.09576412f, -0.05998553f, -0.02935417f, 
    0.02337085f, -0.16525218f, -0.06259175f, 0.03277170f, -0.05208562f, 0.02453966f, 0.02879974f, 0.04361628f, 
    0.12475345f, 0.18451200f, -0.02869325f, 0.04945492f, 0.64270753f, 0.20416448f, -0.01865366f, -0.21818419f, 
    -0.04566021f, 0.02720727f, -0.01331794f, -0.10886405f, -0.04958031f, 0.02034051f, -0.04737542f, -0.00054706f, 
    -0.30680624f, 0.25844607f, -0.26629990f, 0.09566366f, -0.19348030f, -0.06554317f, -0.15753953f, -0.08205937f, 
    -0.00574181f, -0.02998305f, 0.03948784f, -0.14212912f, -0.39700711f, 0.19328500f, -0.29311028f, -0.05907204f, 
    -0.00397372f, -0.07259126f, 0.02519957f, 0.01576693f, 0.10282768f, 0.06356700f, -0.07307492f, -0.03273018f, 
    -0.18968530f, -0.01248342f, 0.11600383f, 0.18053715f, 0.03227375f, 0.00342718f, 0.07476359f, -0.18593366f, 
    0.04154629f, 0.05601111f, 0.02760923f, 0.16926165f, 0.46360341f, -0.24424343f, 0.25336903f, -0.21061751f, 
    0.12463515f, -0.05025301f, 0.17981763f, -0.03108613f, 0.04236683f, 0.01555734f, 0.10203592f, 0.12535229f, 
    0.38254172f, 0.10934099f, 0.19167502f, 0.20185354f, 0.13619252f, -0.01033399f, 0.03529821f, 0.02806393f, 
    -0.04143337f, 0.07056524f, -0.04262976f, 0.01807567f, 0.02601947f, -0.06139633f, -0.16406111f, -0.16707060f, 
    -0.05088753f, -0.10036938f, -0.06507364f, -0.06460083f, -0.18546712f, -0.00885597f, -0.07822821f, -0.07699789f, 
    -0.08564167f, 0.40263236f, 0.05158117f, 0.23472948f, -0.02687797f, -0.02603240f, 0.03998454f, 0.06330930f, 
    0.07130464f, 0.06232934f, 0.07255945f, -0.06470712f, -0.02711046f, 0.12989461f, -0.36044270f, 0.01621790f, 
    -0.05821148f, -0.03828947f, -0.02105143f, -0.04400074f, -0.09736560f, -0.02353161f, 0.08537519f, 0.12358892f, 
    -0.02488003f, 0.22343692f, -0.29015493f, 0.22066991f, 0.00177931f, -0.02655681f, 0.08320583f, 0.03897338f, 
    0.04292827f, 0.00330380f, -0.00082075f, 0.14614965f, 0.37637794f, -0.28795081f, 0.17559928f, -0.04106455f, 
    -0.05416713f, 0.05470215f, -0.04754614f, 0.13801166f, 0.06520690f, 0.12794150f, 0.04787866f, -0.04348862f, 
    0.34513709f, -0.10652528f, 0.22146741f, -0.10046515f, 0.08306842f, -0.07066747f, -0.11810568f, 0.12719773f, 
    -0.10058815f, 0.07389659f, 0.02626386f, -0.10395496f, -0.17255817f, -0.31517550f, 0.16604325f, 0.18594556f, 
    0.20223154f, -0.05857356f, -0.00540999f, -0.03421803f, 0.03889731f, -0.03685743f, -0.09448101f, 0.00037800f, 
    -0.39885077f, 0.21171653f, 0.14640100f, 0.00816977f, -0.14890420f, -0.11497632f, -0.04327644f, 0.05215042f, 
    0.04339648f, -0.00087565f, -0.00767907f, -0.14974654f, -0.17250854f, 0.03204133f, -0.01315207f, 0.03297995f, 
    -0.01168374f, 0.11251875f, 0.16413082f, 0.03550489f, -0.06666719f, -0.14523418f, 0.12836833f, -0.04577310f, 
    0.03753150f, 0.30749565f, 0.00362005f, 0.29899490f, -0.07666250f, 0.14469106f, -0.17663279f, 0.04890886f, 
    0.02126152f, 0.01084653f, 0.14569502f, 0.01446209f, -0.36772957f, 0.16861051f, -0.05638365f, 0.02390591f, 
    -0.05012365f, 0.03012333f, -0.07784636f, 0.16019635f, -0.02676097f, 0.13528478f, 0.07191867f, 0.08071806f, 
    0.04063653f, 0.27282876f, -0.05528783f, 0.23558484f, 0.06217679f, 0.11461113f, 0.07880350f, -0.03756547f, 
    0.19244215f, 0.11360470f, 0.03293265f, 0.04629194f, -0.51002318f, 0.28353432f, -0.22629312f, 0.42292580f, 
    0.10393336f, 0.00776692f, 0.13573363f, 0.00061351f, 0.15199646f, -0.05553727f, -0.00648205f, 0.10246591f, 
    -0.43513179f, 0.02795510f, -0.25126407f, 0.01076672f, -0.07800154f, 0.06356126f, 0.06969761f, 0.02903677f, 
    -0.12993245f, 0.04571302f, 0.01896696f, -0.09191532f, 0.46000713f, -0.23070683f, 0.37842625f, -0.00059415f, 
    0.07553969f, 0.14056851f, -0.03359618f, 0.05264198f, -0.06228908f, 0.00970955f, 0.03416229f, 0.00038868f, 
    -0.14262961f, -0.01481732f, 0.22517842f, 0.28130123f, -0.06639954f, 0.15134817f, -0.01616342f, -0.04244453f, 
    0.02596694f, 0.08144015f, 0.02021761f, -0.15053393f, 0.02040866f, 0.39898872f, 0.24236523f, 0.37639686f, 
    0.12193042f, 0.06420963f, 0.06931411f, -0.06364843f, 0.03407884f, 0.08964507f, 0.03066371f, 0.08446988f, 
    -0.19923413f, 0.18081714f, -0.04357671f, 0.13650559f, 0.07666734f, 0.02591187f, 0.03377109f, 0.11726318f, 
    0.05914921f, 0.07193426f, -0.02627729f, 0.15209144f, -0.27157620f, -0.48620301f, 0.05526533f, 0.07797140f, 
    -0.07690556f, 0.10882413f, -0.16230556f, -0.19105156f, -0.00286196f, -0.06908505f, 0.07326914f, -0.00723765f, 
    -0.27168018f, -0.37609559f, -0.06363498f, 0.05160018f, -0.08629949f, -0.06241846f, -0.02762742f, -0.28075209f, 
    0.01641064f, 0.02399942f, -0.05374734f, 0.00636673f, 0.00669881f, 0.02328668f, -0.06583154f, -0.11229989f, 
    -0.00431278f, 0.05024810f, 0.11614857f, -0.00390852f, -0.06735070f, 0.10881381f, 0.05510547f, -0.10540166f, 
    -0.30063155f, 0.32683766f, -0.21525721f, -0.20796172f, 0.07291325f, -0.00150642f, -0.15794817f, -0.11418969f, 
    0.06773932f, -0.07286981f, -0.05228829f, 0.06510487f, 0.37786695f, -0.12772913f, 0.03992367f, 0.19628605f, 
    -0.12207320f, -0.02270151f, -0.19413047f, 0.17265324f, -0.07059522f, 0.09040812f, 0.00547065f, 0.02586216f, 
    0.14000554f, -0.23567009f, 0.10296657f, 0.04903002f, -0.13405633f, -0.00612370f, 0.04159967f, 0.04134101f, 
    0.03884298f, 0.07023056f, 0.08393714f, -0.11102785f, -0.28916919f, 0.14054616f, -0.11668807f, 0.00702435f, 
    -0.05964334f, 0.02641447f, 0.00291358f, -0.07998842f, 0.04069453f, -0.01456455f, -0.04102098f, 0.06245179f, 
    -0.07137649f, 0.02991081f, 0.16137005f, 0.22503874f, -0.00814153f, 0.13130651f, 0.09759612f, 0.02092863f, 
    0.05961137f, 0.12585914f, -0.01237456f, -0.01782071f, 0.11288659f, 0.18977018f, -0.04884211f, -0.10046776f, 
    0.04041076f, 0.04247332f, 0.04088300f, 0.11662157f, -0.10433560f, 0.04279361f, 0.04778383f, -0.02077624f, 
    -0.08445252f, -0.10089374f, 0.11061563f, -0.17992666f, 0.02376760f, 0.06671129f, -0.01102673f, 0.01379646f, 
    -0.00960796f, -0.02439503f, -0.12536240f, 0.00615824f, -0.09344765f, -0.04936302f, -0.18478976f, -0.04485719f, 
    0.10653871f, -0.06477258f, -0.05288034f, 0.03413780f, 0.11474990f, 0.01810667f, 0.06191913f, 0.04836731f, 
    -0.27346924f, 0.17569748f, 0.06267642f, 0.21215276f, 0.12664945f, 0.08389702f, 0.05520004f, -0.00783105f, 
    0.11714187f, 0.02058466f, -0.18698560f, -0.05195016f, 0.06672270f, 0.19810921f, -0.08516469f, 0.15238874f, 
    0.08535659f, -0.12021004f, 0.13500071f, -0.02913356f, 0.04716918f, 0.03848371f, -0.00351382f, -0.05429245f, 
    0.27805722f, -0.04662214f, -0.20046513f, -0.04647417f, -0.04053302f, -0.26741067f, 0.10518809f, 0.16075154f, 
    0.20712087f, -0.04338033f, 0.07132826f, 0.05938389f, -0.19879404f, -0.04511195f, -0.09776824f, -0.06141672f, 
    0.00682556f, 0.07127289f, -0.05090751f, 0.00104809f, 0.11713046f, 0.09020963f, 0.02354179f, 0.02085553f, 
    -0.26620254f, 0.04047816f, -0.02777082f, -0.02393493f, 0.02395411f, -0.07043047f, 0.06770270f, 0.00773051f, 
    0.05073429f, -0.01385491f, 0.00607782f, -0.03726448f, 0.35928345f, -0.22070493f, 0.02671345f, 0.36146238f, 
    0.14361079f, -0.02546646f, -0.04613227f, 0.12485567f, 0.02934596f, -0.04601213f, -0.07269333f, -0.02774310f, 
    0.27627096f, -0.07891323f, -0.18361665f, 0.14971408f, -0.08129960f, -0.03256512f, 0.01381938f, 0.00208340f, 
    0.05293170f, 0.03088218f, 0.04099886f, 0.03139136f, 0.14967106f, -0.04475709f, -0.04800642f, -0.06921291f, 
    0.11578649f, 0.08554859f, -0.12492900f, 0.25704470f, -0.16486643f, -0.08046442f, -0.00278611f, 0.19899164f, 
    -0.06622401f, 0.22241297f, -0.18390608f, -0.19221102f, -0.00593367f, -0.09373480f, -0.07111311f, -0.04329126f, 
    0.06224828f, 0.16069935f, -0.01475360f, 0.05621475f, -0.14404133f, 0.10628493f, 0.21587269f, 0.08672979f, 
    -0.09535884f, 0.01287521f, 0.12193334f, 0.07059590f, -0.06486532f, 0.05430467f, -0.08970205f, -0.07990626f, 
    -0.39895767f, 0.07981617f, 0.05579978f, -0.02140793f, -0.02414831f, -0.05435519f, 0.00141054f, 0.01190097f, 
    0.01824174f, -0.04223566f, -0.00976250f, -0.01117571f, 0.09254352f, -0.08508646f, 0.02095607f, 0.01762970f, 
    -0.15532164f, 0.09296884f, 0.03142175f, 0.04464987f, 0.13325819f, 0.05951540f, -0.02105765f, -0.06046238f, 
    0.27480289f, -0.01202290f, 0.18762490f, -0.25632253f, -0.02443159f, 0.09925244f, 0.02149655f, 0.22948635f, 
    -0.03105172f, -0.10371812f, -0.15254827f, -0.03686993f, -0.02388765f, -0.04858451f, 0.01934496f, 0.03331590f, 
    0.02538062f, -0.06836060f, -0.04293304f, 0.01848788f, 0.07209507f, -0.04356375f, 0.09918565f, 0.03531145f, 
    0.00847842f, -0.01639823f, 0.21599838f, 0.00396940f, 0.13079569f, -0.11667030f, 0.03451982f, 0.15199113f, 
    -0.06985737f, -0.03051515f, -0.03476200f, -0.12934504f, -0.42205134f, 0.18146205f, 0.36175629f, 0.04225133f, 
    -0.08308284f, -0.07879716f, 0.03930607f, 0.00693512f, -0.10888348f, 0.01011715f, 0.02257342f, -0.00622063f, 
    0.36745310f, -0.17704368f, 0.00688061f, 0.25072750f, 0.15749069f, 0.01578258f, -0.06092408f, 0.05380088f, 
    0.18781848f, 0.05223671f, 0.03035856f, -0.05274947f, -0.01720743f, -0.09913470f, 0.11993684f, 0.08281974f, 
    0.19505884f, 0.14423327f, 0.16558312f, 0.07007176f, 0.09243561f, 0.05271925f, 0.07534976f, 0.06006277f, 
    -0.16161902f, -0.05564104f, 0.09062650f, 0.09388237f, 0.04075095f, 0.02246182f, 0.04055662f, 0.04980860f, 
    -0.00541442f, 0.06043087f, 0.06308641f, 0.07348561f, -0.45823646f, 0.40902382f, 0.11970033f, -0.00106320f, 
    -0.09697535f, 0.03932580f, 0.01049483f, 0.01842927f, -0.01535431f, -0.17850646f, 0.19052906f, 0.01569864f, 
    -0.35818729f, 0.26810372f, -0.20796783f, -0.16851620f, 0.05459474f, 0.13955943f, -0.11037654f, 0.11639620f, 
    -0.14661786f, -0.06260190f, -0.01501806f, 0.02701978f, -0.25575584f, 0.06945036f, 0.16372184f, -0.02756976f, 
    0.02531226f, 0.01042388f, -0.13612835f, -0.06464545f, -0.05080414f, 0.03573146f, -0.03524251f, -0.12066388f, 
    -0.11433825f, -0.01091867f, 0.15187159f, 0.15708363f, 0.00368439f, 0.03540115f, 0.27515551f, -0.20175257f, 
    0.01444748f, -0.07458567f, 0.03136875f, -0.06545561f, -0.04340360f, 0.01886734f, -0.15367560f, -0.06406152f, 
    0.08470666f, -0.01769502f, 0.16194220f, -0.04745211f, 0.14339335f, 0.12234869f, 0.03180818f, -0.07468258f, 
    -0.17958182f, -0.08927211f, -0.08618885f, -0.08004863f, -0.01580770f, -0.00356162f, 0.08431611f, 0.08669419f, 
    -0.12165304f, 0.08228737f, -0.05835538f, -0.07617083f, 0.25622272f, -0.16328767f, 0.14631893f, -0.08041611f, 
    0.09061429f, -0.04611948f, 0.05692897f, 0.20509413f, -0.11112167f, -0.00476338f, 0.00500246f, 0.00278957f, 
    0.13347965f, 0.04225613f, 0.04493049f, 0.17966519f, 0.03179048f, -0.07055356f, 0.04480872f, -0.10427563f, 
    0.05653637f, 0.01325917f, -0.08601844f, -0.02327662f, -0.12249278f, -0.06085839f, -0.01888304f, 0.04084951f, 
    0.22496261f, -0.06047599f, -0.00222526f, 0.04438735f, 0.13786750f, 0.06060566f, -0.03784445f, 0.01949313f, 
    -0.06756286f, -0.12777494f, 0.03732571f, 0.14890864f, -0.04223710f, 0.01897690f, -0.05518333f, -0.00057805f, 
    0.07406272f, 0.04254481f, -0.12166949f, 0.08730792f, 0.43119714f, -0.11387359f, -0.15446885f, 0.37012610f, 
    0.03823447f, 0.01734772f, 0.05761526f, -0.06459720f, -0.01395826f, -0.12722695f, 0.06897885f, 0.00486534f, 
    -0.19146207f, 0.23880099f, -0.15049271f, 0.01644775f, -0.14955540f, -0.20612255f, 0.06520804f, -0.08766089f, 
    -0.04765152f, -0.06843217f, 0.01268082f, -0.11346090f, 0.14869620f, 0.14153273f, -0.03961902f, -0.03625506f, 
    -0.16126950f, -0.08327471f, -0.07398164f, -0.02578975f, 0.01806061f, -0.10303406f, 0.08640633f, 0.16484571f, 
    -0.33160293f, -0.16783403f, -0.29668149f, -0.30255935f, -0.15463519f, -0.03867893f, 0.00265709f, 0.05269270f, 
    0.13585955f, 0.01750268f, -0.02062330f, 0.00321445f, 0.13520120f, 0.05024379f, 0.20216608f, 0.12247794f, 
    0.18628356f, 0.09330689f, 0.03577711f, 0.20821938f, 0.00856369f, 0.03369886f, -0.11474098f, -0.15184888f, 
    -0.05446415f, 0.00402732f, 0.05691672f, 0.12995790f, 0.05194552f, -0.01413926f, -0.10413163f, 0.12898551f, 
    -0.10298997f, 0.12587008f, -0.01789195f, 0.03685651f, -0.18368059f, -0.10695201f, -0.03940874f, -0.07026152f, 
    -0.17589633f, -0.23890531f, -0.17372146f, -0.20208856f, 0.05758972f, 0.01040946f, -0.03541336f, 0.09192406f, 
    -0.02639740f, -0.08208337f, -0.09233376f, -0.03555670f, 0.05476214f, 0.10414216f, 0.04010886f, 0.05466632f, 
    0.04620026f, -0.11342077f, -0.08655934f, -0.04891460f, -0.04972330f, 0.11705316f, 0.19975315f, 0.15242459f, 
    0.01881625f, -0.01450174f, -0.08995471f, 0.01844239f, 0.04580921f, 0.00613670f, 0.02289673f, 0.22808187f, 
    0.08647194f, 0.17140840f, 0.11290667f, 0.07273442f, 0.18002076f, -0.01787787f, -0.07182136f, -0.01501767f, 
    0.01829621f, 0.06851370f, -0.06432493f, 0.17297693f, -0.03579499f, -0.03770931f, 0.03281153f, 0.21424104f, 
    0.07226039f, 0.04044015f, 0.04571542f, 0.09821490f, 0.07145382f, 0.04490817f, 0.15381323f, 0.14101277f, 
    -0.10519649f, -0.13805534f, 0.11874903f, 0.03849805f, 0.02147849f, 0.08619998f, -0.04957661f, 0.03101976f, 
    0.08435814f, 0.06364063f, -0.05267647f, 0.11144239f, 0.11967929f, 0.03258395f, -0.00098418f, -0.08098590f, 
    0.11515065f, 0.09821824f, -0.04161950f, -0.09122200f, -0.03134522f, -0.01668330f, -0.01948680f, 0.02242981f, 
    -0.06299188f, -0.14098901f, -0.03604410f, -0.07232399f, -0.08709064f, -0.08172624f, -0.15506595f, -0.09460616f, 
    0.08674914f, 0.17380230f, 0.11425222f, 0.06320371f, -0.17121632f, -0.00279383f, -0.17742351f, 0.00510786f, 
    0.00395006f, 0.09343017f, 0.13795149f, -0.01745593f, 0.09091915f, 0.06336128f, 0.27858600f, 0.21891209f, 
    -0.13260487f, 0.12570634f, 0.07945579f, 0.12346420f, -0.11729971f, -0.03285692f, 0.02087040f, -0.08199221f, 
    0.00874487f, -0.20769463f, -0.00328361f, -0.09807567f, -0.16879502f, 0.00792098f, -0.03132913f, -0.05950499f, 
    -0.08832565f, 0.04401171f, -0.11115777f, -0.04990934f, 0.08719832f, -0.01864650f, -0.00907654f, 0.18881191f, 
    0.22066790f, -0.03551608f, -0.22303213f, 0.12169278f, 0.10377169f, 0.25282717f, -0.01292317f, -0.04496954f, 
    0.00549480f, -0.11739331f, -0.10412898f, 0.04566241f, -0.04475771f, 0.62406248f, -0.12434193f, -0.15905590f, 
    0.06730058f, -0.17160930f, -0.05731278f, 0.07778329f, 0.10933504f, 0.00463409f, -0.01660222f, 0.04115669f, 
    -0.18923745f, -0.10109137f, -0.42895749f, -0.19881643f, 0.10270994f, 0.14239612f, 0.02011903f, 0.01255858f, 
    -0.06380874f, -0.12384174f, -0.04534699f, 0.17232779f, -0.11081471f, 0.04118061f, 0.23691586f, -0.15642253f, 
    0.06006779f, -0.02383640f, 0.04652683f, 0.13871007f, -0.06638594f, 0.16563551f, 0.00757963f, 0.27772483f, 
    0.28944203f, 0.24677084f, 0.06542058f, 0.07168529f, 0.11149619f, 0.11322160f, -0.02473061f, 0.03391223f, 
    -0.15988180f, 0.07005297f, -0.10864080f, -0.19103923f, 0.13486764f, 0.08241896f, -0.02982025f, -0.01989087f, 
    0.00148777f, 0.04852022f, 0.03985433f, -0.08575941f, 0.12790506f, 0.01595305f, 0.07057602f, 0.19550066f, 
    0.24244823f, 0.20004040f, 0.07440589f, -0.10031460f, -0.15370104f, -0.11308929f, -0.06458666f, 0.07157631f, 
    0.15358841f, 0.01387205f, 0.01641586f, 0.14489409f, 0.11668711f, -0.10149667f, -0.07309866f, -0.15262496f, 
    0.07369097f, 0.02246316f, 0.15121990f, 0.00172420f, -0.01462237f, 0.01786557f, 0.00507048f, 0.04418877f, 
    0.13154684f, -0.04190514f, -0.00897824f, -0.08326504f, 0.15317254f, 0.14711396f, 0.00804163f, 0.15441987f, 
    0.00716973f, -0.01750035f, -0.05063903f, 0.06780584f, -0.05212488f, -0.17261894f, 0.07443388f, 0.05836489f, 
    0.02278921f, 0.07210512f, -0.09201105f, -0.00772327f, -0.01968149f, 0.13537657f, 0.13777274f, 0.20254390f, 
    -0.04313268f, 0.15516484f, -0.13299316f, -0.05786026f, -0.02852694f, -0.04424565f, -0.06597983f, -0.22022110f, 
    -0.14300808f, -0.18444793f, -0.21505237f, -0.27797785f, 0.03071674f, 0.10254528f, 0.08564908f, 0.03417722f, 
    -0.03988907f, -0.09745426f, 0.01996928f, 0.00279735f, -0.07943895f, -0.07320242f, -0.32350791f, -0.12807845f, 
    0.01266901f, -0.09507344f, -0.20701107f, 0.08960921f, -0.01380090f, -0.01604206f, -0.05796852f, 0.07745010f, 
    -0.06938447f, 0.12812191f, 0.15086022f, -0.01575517f, 0.03692624f, 0.03912996f, 0.06379128f, -0.09921115f, 
    -0.06868434f, -0.06288069f, 0.00176022f, -0.10898428f, 0.04454716f, 0.04232950f, 0.01965586f, 0.14622393f, 
    0.11852042f, 0.14931801f, -0.04191704f, -0.01559104f, 0.09052535f, 0.28061152f, 0.15714526f, 0.07255415f, 
    0.10582239f, 0.01853808f, -0.05414478f, 0.11335327f, 0.11600605f, 0.19518539f, -0.05285914f, -0.01429185f, 
    0.06237508f, -0.05965000f, -0.07249880f, -0.05097052f, 0.08686148f, 0.08604173f, -0.08497177f, -0.04618995f, 
    0.03256905f, -0.04435627f, 0.01499856f, -0.04064941f, -0.03818933f, 0.01233309f, -0.04381295f, -0.02966399f, 
    -0.03578003f, 0.06155533f, -0.04733506f, 0.04297888f, 0.00977244f, 0.01012049f, 0.02834113f, -0.02218059f, 
    0.00118107f, -0.00592329f, -0.01980028f, -0.01000457f, -0.01467299f, 0.00439258f, 0.04076105f, -0.02122612f, 
    -0.04851967f, 0.01353633f, -0.03441454f, -0.01236321f, -0.04572451f, 0.02960844f, 0.05101589f, 0.00515934f, 
    -0.01210496f, 0.00649429f, 0.00954889f, -0.03990608f, -0.03126948f, 0.02002285f, 0.00205154f, -0.01343562f, 
    -0.03927403f, 0.02074786f, -0.00312636f, -0.00629188f, -0.01483612f, -0.05054849f, 0.02035294f, 0.02781045f, 
    0.04454597f, -0.04174897f, -0.02606454f, 0.02097781f, -0.00621017f, 0.03053650f, -0.04740878f, -0.00939574f, 
    -0.04097402f, -0.02995504f, 0.00115705f, -0.05179529f, 0.02887891f, -0.04117009f, 0.00782834f, -0.01876808f, 
    -0.03753255f, -0.03689221f, 0.01381702f, -0.03139623f, 0.03259315f, 0.04967924f, -0.02271999f, -0.02613577f, 
    0.00998675f, -0.04312402f, 0.01660145f, 0.03137396f, 0.02013835f, -0.01548285f, 0.02902758f, -0.04654652f, 
    0.00517492f, 0.01957468f, -0.04485069f, -0.00624768f, 0.00711422f, 0.01876129f, 0.03604817f, -0.05046308f, 
    0.03523182f, -0.01301125f, -0.02634979f, 0.01663176f, 0.00326446f, 0.02358860f, -0.05092806f, -0.00801880f, 
    -0.04069156f, -0.03965732f, 0.02239699f, 0.00334463f, 0.01628814f, -0.04123389f, -0.03435697f, 0.03422601f, 
    -0.02552400f, -0.05284676f, -0.02756255f, -0.00971469f, -0.04121492f, -0.00279492f, -0.01682284f, -0.01117210f, 
    0.01849800f, 0.00186500f, -0.03532529f, -0.05964894f, -0.03884132f, 0.01912506f, 0.03511529f, 0.04486577f, 
    -0.01976983f, 0.03760121f, 0.02624427f, -0.03935379f, -0.00250638f, -0.00372679f, 0.03251909f, -0.04094102f, 
    0.04468625f, -0.02162667f, -0.04032520f, -0.05324044f, 0.04398427f, -0.04788093f, 0.01272420f, -0.00334003f, 
    -0.05983585f, 0.03835696f, -0.01460586f, -0.01468695f, 0.03352347f, -0.04492058f, 0.04661435f, 0.00977987f, 
    -0.02182472f, -0.01218238f, -0.03204473f, -0.01866641f, -0.04553907f, 0.00382080f, -0.03929686f, 0.01480203f, 
    0.02186823f, -0.02790008f, 0.00015221f, 0.01743924f, -0.05717479f, -0.00446894f, -0.04823923f, -0.04215794f, 
    0.00697810f, -0.05824210f, -0.00751150f, 0.02613667f, 0.04312691f, -0.01858671f, 0.00735838f, -0.00079375f, 
    0.01055111f, -0.00194986f, 0.00670180f, 0.00607796f, -0.03717143f, 0.01169948f, 0.02832353f, 0.03756287f, 
    0.01733348f, 0.00306031f, 0.01130220f, -0.04750641f, -0.00937102f, 0.04714482f, 0.01585820f, -0.02606838f, 
    -0.05183214f, 0.03998673f, 0.01177864f, 0.03167029f, -0.01981742f, -0.03407929f, -0.02062182f, -0.00427406f, 
    0.04777327f, -0.04204939f, 0.04468616f, 0.00162834f, 0.01960558f, 0.01380029f, -0.03874107f, -0.00767017f, 
    -0.01211898f, 0.00835174f, 0.02342886f, -0.00651672f, -0.00948663f, 0.03937656f, 0.02397949f, -0.02096454f, 
    -0.01692735f, 0.03082379f, -0.04636237f, 0.01852764f, -0.04363952f, -0.00629704f, 0.02194797f, 0.05829545f, 
    0.01817922f, 0.01223792f, -0.03735157f, 0.04673175f, -0.03413824f, -0.04331958f, 0.04279780f, -0.00984662f, 
    0.03686461f, -0.01988629f, 0.00725411f, 0.01490516f, -0.01636928f, 0.02133100f, 0.01129468f, 0.01427277f, 
    -0.05978471f, 0.01863605f, 0.04019778f, -0.02103917f, -0.04095256f, 0.02469330f, -0.02716565f, 0.01400882f, 
    -0.04829544f, 0.01377883f, -0.02201266f, -0.02865413f, -0.00625991f, 0.01239543f, -0.04776777f, -0.02113226f, 
    0.03781811f, 0.00327592f, 0.02350737f, -0.05205105f, -0.01630309f, -0.02591195f, -0.03661568f, -0.03865883f, 
    0.03902368f, -0.02924863f, -0.02164018f, -0.00775875f, 0.04206910f, 0.01294404f, 0.04173013f, 0.03757150f, 
    0.00848373f, 0.03676650f, -0.04705935f, -0.00492426f, -0.05284184f, -0.04947587f, 0.02309068f, -0.02866335f, 
    -0.02757017f, 0.04337769f, -0.00520801f, 0.01586648f, 0.02195139f, -0.04458446f, 0.03711685f, 0.01058728f, 
    -0.05006722f, -0.03407612f, -0.00463908f, -0.00227821f, 0.01456229f, 0.00082778f, -0.04496684f, 0.05060207f, 
    0.02357551f, 0.02748589f, -0.05227050f, 0.03123920f, -0.00972869f, -0.01904254f, -0.04666219f, 0.03035763f, 
    -0.04266615f, -0.00442124f, -0.04353314f, 0.02227443f, 0.03341151f, -0.03466442f, 0.02095540f, -0.02831241f, 
    -0.03333976f, 0.01804514f, -0.03839102f, -0.04209941f, -0.01399149f, 0.00937309f, 0.00458441f, 0.04524221f, 
    -0.04032008f, 0.02756389f, 0.00842503f, 0.04426825f, -0.02637859f, 0.05195892f, -0.03509323f, -0.02866059f, 
    -0.00344787f, -0.03852279f, 0.02621143f, 0.02820455f, -0.02428731f, -0.05784834f, -0.02814537f, -0.03722166f, 
    -0.05807133f, -0.01410459f, 0.03700907f, 0.05083039f, 0.04541519f, -0.02760766f, -0.02328569f, -0.03009137f, 
    -0.00791787f, -0.05847188f, -0.03306838f, -0.03118232f, 0.03631183f, -0.01056994f, -0.03493933f, -0.02918059f, 
    0.02691343f, -0.00193651f, 0.03177665f, -0.00609031f, 0.00253420f, -0.02143868f, -0.02944800f, 0.05529677f, 
    0.03716388f, -0.02226592f, 0.00354129f, -0.05174427f, 0.00597750f, -0.01513412f, -0.05106580f, 0.01669430f, 
    0.00112919f, 0.01723343f, -0.04321380f, -0.00901954f, -0.05300637f, 0.00656800f, 0.03971060f, 0.04310384f, 
    -0.02810840f, -0.00289333f, -0.00258811f, -0.02672273f, -0.00231814f, -0.03737953f, 0.01675340f, -0.00976946f, 
    0.02577450f, 0.04549013f, 0.02012623f, -0.01091887f, -0.00962304f, 0.02601979f, 0.00828073f, 0.03688253f, 
    -0.00797946f, 0.01662968f, 0.08228865f, 0.11460806f, 0.01015369f, 0.20852707f, -0.03314985f, 0.07852942f, 
    -0.00996825f, -0.00416787f, -0.05937089f, -0.06943140f, -0.47088835f, -0.09144439f, -0.26597258f, 0.18319829f, 
    0.10217612f, 0.01457743f, -0.07266486f, -0.05707384f, 0.07363404f, 0.07817885f, -0.10630373f, 0.00845933f, 
    -0.02030205f, 0.17027904f, -0.01387055f, 0.43242434f, -0.01171615f, -0.07830539f, 0.04245962f, -0.14604716f, 
    -0.17097925f, 0.17658578f, -0.13134429f, 0.04868197f, 0.13642865f, -0.07632746f, 0.03521076f, -0.16128795f, 
    0.00561568f, -0.13241678f, 0.05045944f, -0.02700702f, 0.05154647f, -0.06040530f, 0.12410299f, 0.19792040f, 
    0.28537548f, -0.04675519f, 0.00970267f, -0.16345249f, 0.03284439f, -0.18084995f, 0.17814623f, -0.08085173f, 
    0.05227332f, 0.09308084f, -0.04483686f, -0.02426834f, 0.18570137f, 0.01873151f, -0.09326513f, -0.09812289f, 
    -0.02510799f, 0.01639717f, 0.09710781f, -0.05986771f, -0.07964852f, 0.10167219f, 0.06710237f, -0.12308816f, 
    0.09218538f, 0.27846766f, 0.05162137f, 0.08126616f, -0.06267802f, -0.11351663f, 0.03248257f, -0.04936037f, 
    0.00033144f, -0.08522064f, 0.00197710f, 0.03714123f, -0.08447397f, -0.03970458f, -0.14259750f, 0.17363158f, 
    -0.05299314f, -0.02765761f, -0.08484553f, 0.00846199f, -0.08694935f, -0.01148434f, -0.07909989f, -0.17189345f, 
    -0.21274175f, 0.03639737f, -0.28194809f, 0.13363419f, -0.19397275f, -0.01843315f, 0.19752291f, -0.03499289f, 
    -0.07005736f, -0.04885448f, 0.02494865f, 0.07827847f, 0.15445876f, -0.22137587f, 0.06843745f, -0.13824429f, 
    -0.08754344f, 0.12046081f, -0.07819743f, 0.04458958f, -0.00609719f, 0.02134830f, -0.05984673f, -0.31538841f, 
    0.35058174f, 0.08578011f, 0.15608960f, -0.09039818f, 0.05056050f, 0.09421387f, 0.05606013f, 0.00804145f, 
    -0.14446443f, -0.15935794f, -0.06938257f, -0.05694102f, -0.06338116f, -0.01913075f, -0.05213429f, 0.37312084f, 
    0.02589027f, -0.08621937f, 0.05959159f, 0.12620574f, 0.10446011f, 0.07143562f, -0.08199190f, -0.02601518f, 
    -0.15141372f, 0.27291423f, 0.01246733f, -0.01436222f, 0.03051742f, -0.16496176f, -0.01617990f, 0.03439643f, 
    -0.02518035f, -0.01418288f, -0.01849013f, -0.04841892f, 0.09073877f, 0.03600548f, 0.06317771f, -0.03697287f, 
    0.00432185f, 0.15207490f, -0.01954488f, 0.15802617f, -0.05683029f, -0.13239734f, -0.17137639f, -0.17555395f, 
    0.24228168f, 0.15364589f, 0.05545895f, -0.04028601f, -0.02627537f, 0.08685718f, 0.01246060f, 0.07046425f, 
    0.00395851f, 0.03750992f, -0.01054891f, 0.00142785f, 0.02938890f, 0.15616885f, -0.02152307f, 0.05994594f, 
    0.07598707f, -0.01886038f, -0.06897429f, -0.05769263f, 0.01571921f, 0.04139703f, 0.08939391f, -0.08975154f, 
    -0.14018835f, 0.02725008f, 0.20902756f, 0.03655253f, -0.04422936f, -0.15584360f, 0.07387442f, 0.04914546f, 
    0.09294964f, 0.12192300f, -0.02411896f, -0.00872810f, -0.30508095f, -0.31837168f, 0.02124698f, 0.53098536f, 
    0.07419168f, 0.20701885f, 0.13529292f, -0.11636520f, -0.07384420f, -0.12784390f, -0.02261750f, -0.10673427f, 
    -0.20006210f, 0.17584318f, 0.01383436f, 0.00678921f, 0.05241150f, 0.13125128f, -0.12472013f, 0.03503310f, 
    -0.03680652f, 0.13953495f, 0.04767703f, -0.11974894f, 0.28082407f, -0.11701936f, 0.10340104f, 0.17834832f, 
    0.04126419f, 0.07924280f, 0.11459335f, -0.00747954f, -0.08168173f, -0.03694779f, -0.00085208f, -0.20789059f, 
    -0.13584790f, -0.05707703f, 0.19341548f, 0.09175522f, 0.00216193f, 0.01691297f, -0.04279006f, 0.03149694f, 
    0.06759489f, -0.02129871f, -0.00579649f, 0.09387910f, 0.01518204f, 0.08463055f, 0.30484724f, 0.22771618f, 
    0.00053750f, 0.02889920f, 0.03614996f, 0.06901322f, -0.12183241f, 0.08206972f, 0.03528674f, -0.08187527f, 
    -0.38321722f, 0.00379573f, 0.11280207f, 0.05671092f, 0.20013775f, 0.24971604f, -0.16116673f, 0.05369423f, 
    0.05873404f, -0.05736313f, 0.04413712f, 0.10563265f, -0.05278527f, -0.03292482f, 0.21473190f, 0.19681485f, 
    -0.07426912f, -0.02588264f, -0.10025043f, 0.02696544f, -0.01040176f, -0.02334191f, 0.05938853f, -0.06906597f, 
    -0.04604047f, 0.08804204f, 0.14409150f, 0.11944310f, -0.03422734f, -0.11229213f, 0.15006231f, -0.13537979f, 
    -0.01179398f, 0.03042661f, 0.04892933f, -0.03208335f, 0.01144576f, 0.18802774f, -0.02021543f, -0.02717593f, 
    0.13309827f, 0.11760883f, 0.08812055f, -0.02371460f, -0.07262728f, -0.03459536f, -0.05560604f, -0.20464534f, 
    -0.14546381f, 0.12947248f, -0.06058434f, 0.09760148f, 0.01046826f, 0.02645524f, -0.07552923f, 0.08488680f, 
    0.13306241f, 0.13801175f, -0.03064978f, 0.26037854f, 0.16863750f, -0.12732758f, 0.01103858f, 0.14154737f, 
    0.00308928f, -0.00021359f, -0.04743297f, 0.02043423f, -0.03678454f, 0.10631850f, 0.20354350f, 0.06929820f, 
    -0.00444339f, 0.00709679f, 0.05973622f, -0.00126440f, -0.02685889f, -0.00023512f, 0.11008604f, -0.10539518f, 
    0.07478501f, -0.08280238f, -0.05598896f, -0.07969663f, -0.09345666f, 0.00776480f, 0.02172635f, 0.17727050f, 
    0.17591958f, 0.09503138f, -0.08773133f, 0.00829003f, 0.01874807f, 0.10521902f, -0.15904790f, -0.06552868f, 
    0.04464002f, 0.08688816f, 0.15435383f, 0.16443342f, 0.02023098f, -0.14139998f, -0.00727595f, 0.03338507f, 
    -0.05495789f, -0.00454148f, 0.04239368f, -0.04233515f, -0.11562396f, 0.03034057f, 0.01245042f, 0.01746102f, 
    -0.04747634f, 0.06368732f, -0.00252564f, 0.00828384f, -0.12904403f, -0.07780334f, 0.09212561f, 0.10914813f, 
    0.26527628f, -0.21262582f, -0.27732384f, -0.16559966f, 0.01316138f, -0.42367491f, 0.18250757f, 0.02419575f, 
    -0.05655742f, 0.04578646f, -0.09322257f, -0.13582607f, -0.24182886f, -0.19916277f, -0.16037451f, 0.05380445f, 
    -0.11543772f, 0.00029584f, -0.00738340f, -0.10038943f, -0.02272172f, -0.01285763f, 0.04288048f, 0.04499592f, 
    0.27676070f, -0.38050190f, 0.02453349f, -0.53332341f, -0.25074458f, -0.23803626f, 0.17284472f, 0.17200157f, 
    -0.09066203f, 0.05541169f, 0.07156397f, 0.12013771f, -0.10831001f, -0.09656923f, 0.05935915f, -0.07734287f, 
    0.07325392f, 0.20070419f, -0.10613534f, 0.15499084f, 0.02309201f, -0.02962040f, -0.02336648f, -0.04616010f, 
    -0.32100385f, 0.23166119f, 0.18077220f, -0.05644321f, -0.00141074f, 0.24327135f, -0.03466589f, -0.18221107f, 
    0.07009427f, 0.21776089f, -0.04692127f, -0.06397475f, -0.06042466f, -0.52007478f, -0.41805777f, -0.30569670f, 
    -0.06506198f, 0.04319701f, 0.07745129f, -0.09827562f, -0.02655646f, 0.09534911f, -0.02212760f, -0.01033812f, 
    0.29781726f, 0.05957177f, 0.06639962f, -0.04806188f, -0.00235007f, 0.17787421f, -0.10617953f, 0.02152407f, 
    -0.03346564f, 0.02561479f, 0.02685646f, 0.08908969f, -0.31383795f, 0.09651181f, -0.03544591f, -0.53696334f, 
    -0.09417605f, -0.09396995f, -0.05750071f, -0.18192668f, 0.08755941f, -0.03553358f, 0.02530367f, 0.00268370f, 
    -0.40805221f, -0.00174132f, 0.18235619f, -0.03098911f, 0.16488031f, -0.04881831f, -0.08713692f, -0.03433260f, 
    0.09998517f, -0.08086778f, -0.00931751f, -0.10509336f, -0.26218045f, 0.06406922f, -0.14541484f, -0.04506677f, 
    0.06917177f, -0.00804830f, 0.13711046f, -0.15176228f, 0.19118284f, 0.10353130f, 0.06080300f, 0.02299391f, 
    -0.15382770f, -0.16173038f, 0.15454289f, 0.15104607f, -0.17242296f, 0.26331899f, 0.07795008f, 0.14838517f, 
    -0.12807491f, 0.03306943f, 0.12247565f, 0.16630064f, 0.18000561f, 0.10638054f, -0.02689706f, -0.17686927f, 
    -0.03426543f, -0.04444028f, -0.07456093f, -0.16953382f, 0.04554332f, -0.02649579f, 0.04245222f, 0.11499468f, 
    0.27340487f, -0.19111598f, -0.13395827f, -0.00060309f, 0.11879762f, 0.02117719f, 0.02674215f, -0.00771024f, 
    0.00571871f, 0.09254212f, 0.07298712f, 0.06470130f, -0.03884208f, 0.03088214f, -0.12408642f, -0.08137891f, 
    0.09014242f, -0.07744578f, 0.07605953f, 0.07736218f, 0.01134365f, -0.05974690f, 0.18023872f, 0.24473289f, 
    -0.31019750f, -0.27016038f, -0.55666596f, -0.08043239f, -0.00733012f, -0.09678659f, -0.12323672f, -0.13840443f, 
    -0.12332991f, -0.02424383f, 0.06742935f, -0.06885651f, -0.33802116f, -0.06523535f, -0.21144110f, 0.15696162f, 
    -0.07165819f, 0.08163717f, -0.07325344f, -0.16692351f, 0.04322438f, 0.12913015f, -0.07979043f, -0.08360258f, 
    0.20946051f, 0.09890025f, -0.06304511f, 0.01652226f, 0.05616486f, 0.14643748f, 0.00156997f, -0.14165120f, 
    0.06426352f, -0.04546134f, -0.05945246f, 0.11063416f, 0.27381513f, -0.09543802f, -0.24502197f, -0.12534037f, 
    0.04287986f, -0.14058270f, 0.05211191f, 0.05245280f, 0.16732475f, -0.15531208f, -0.03373024f, 0.08627167f, 
    -0.25809753f, 0.08277792f, -0.09609835f, -0.00602798f, -0.01478659f, 0.07485498f, 0.14460066f, -0.03738879f, 
    0.03561131f, -0.00157995f, 0.14606921f, 0.12880170f, -0.15278579f, -0.03265751f, -0.15673719f, 0.03569880f, 
    -0.10036868f, -0.05810928f, -0.00702894f, 0.00525674f, -0.10722096f, 0.05043557f, -0.10706872f, 0.07231378f, 
    0.31906059f, 0.17717506f, 0.04710739f, -0.01434392f, 0.01864530f, 0.00940312f, 0.05354758f, 0.04141318f, 
    0.02956167f, -0.06764771f, -0.06831638f, -0.09303159f, 0.47699881f, -0.07051495f, -0.19274949f, -0.27602348f, 
    -0.09832710f, 0.03912185f, 0.12081008f, 0.05718712f, 0.01388067f, 0.13366625f, -0.13791861f, -0.00628330f, 
    0.18132433f, -0.51266128f, 0.24049620f, 0.18634729f, -0.05115651f, -0.25905707f, 0.23725648f, 0.08123074f, 
    0.31797129f, 0.15448101f, 0.10624066f, 0.02436745f, 0.29458055f, 0.13627087f, -0.09356953f, -0.11562552f, 
    -0.12611385f, -0.11079605f, 0.15165657f, 0.00651278f, -0.19328506f, -0.02164522f, -0.03580109f, -0.00545454f, 
    0.12534630f, 0.15394528f, 0.04800497f, 0.01085898f, -0.10711701f, 0.06747538f, -0.18885453f, 0.22391896f, 
    -0.03603504f, 0.02115988f, 0.01551204f, 0.10163915f, -0.00592112f, 0.00268873f, 0.08159366f, 0.00122603f, 
    0.03209459f, -0.01849540f, -0.08252660f, -0.01393338f, -0.14990081f, -0.01550960f, 0.09372369f, 0.12114532f, 
    0.08068141f, -0.19741727f, 0.03617529f, 0.14623810f, -0.06574283f, -0.07607995f, -0.05063750f, -0.20202467f, 
    0.09267259f, -0.11987219f, 0.04163989f, 0.02403253f, -0.22894479f, 0.23336546f, 0.02183709f, 0.15398833f, 
    0.08569025f, 0.05412020f, -0.12038494f, -0.14808504f, 0.00950518f, 0.04719868f, -0.11981820f, -0.06924131f, 
    -0.27622375f, -0.04743746f, -0.08464099f, 0.08198127f, 0.01635676f, 0.16515689f, -0.10041661f, -0.10801393f, 
    -0.09667642f, -0.04278846f, 0.19248047f, 0.08728398f, -0.10558368f, 0.16270030f, -0.38015696f, -0.12023472f, 
    -0.34178919f, 0.09027510f, 0.04986082f, -0.06746119f, -0.00077621f, -0.01413558f, 0.22837682f, 0.00166767f, 
    0.09831490f, 0.15600754f, 0.02339786f, -0.09170469f, 0.12456327f, 0.11825112f, 0.13833915f, 0.04275810f, 
    -0.12352975f, -0.02725627f, 0.11594342f, -0.01972964f, -0.37261045f, 0.12750497f, 0.02606818f, 0.02096149f, 
    0.20787463f, 0.09928801f, -0.02443220f, -0.03282530f, 0.16517304f, 0.22336230f, -0.03910760f, -0.02038659f, 
    0.35579231f, 0.27991584f, 0.19464597f, -0.24839137f, -0.10923455f, -0.28957322f, 0.03667027f, -0.07102932f, 
    0.13252634f, 0.05818339f, -0.01558526f, 0.06111445f, 0.08869305f, 0.12270004f, -0.19416693f, -0.16357233f, 
    0.05656754f, 0.00384628f, 0.06225695f, -0.10251334f, 0.16442531f, -0.12210885f, 0.11147659f, -0.01689223f, 
    -0.22368146f, -0.08163271f, 0.26624817f, 0.31503630f, -0.11379848f, 0.10506274f, 0.18546408f, 0.05263585f, 
    -0.06657173f, 0.08474209f, 0.01905995f, -0.03350971f, 0.03258963f, -0.04929841f, 0.05590072f, 0.23722731f, 
    -0.01346262f, -0.03653076f, 0.16617946f, 0.02071654f, -0.10833704f, 0.09497118f, -0.05327652f, 0.05529973f, 
    0.36992255f, -0.23947161f, -0.09784541f, -0.28521299f, 0.01857261f, 0.08415566f, 0.08060320f, -0.11622128f, 
    -0.11649578f, -0.05184821f, -0.00264334f, -0.06527728f, 0.00694882f, 0.25130275f, 0.08774534f, -0.01712915f, 
    -0.05073183f, 0.05212855f, -0.08953577f, -0.02596736f, 0.05377476f, -0.04071216f, 0.02474927f, 0.00487812f, 
    -0.47973570f, -0.26435679f, -0.37299153f, 0.00720186f, 0.05693933f, -0.04899407f, 0.02029818f, -0.07892405f, 
    0.02529238f, 0.01319078f, 0.12456489f, 0.02554212f, 0.36007819f, 0.18698289f, 0.09802371f, 0.07527679f, 
    0.00030926f, -0.23888090f, -0.10666560f, -0.07029156f, 0.01340972f, 0.04212893f, 0.10297455f, -0.01700527f, 
    0.26212400f, 0.07241670f, 0.04808016f, -0.12763581f, 0.04705162f, 0.01394474f, 0.04836446f, -0.03158364f, 
    -0.00303737f, 0.02509214f, 0.05802014f, -0.07436982f, 0.24557991f, 0.02921043f, 0.16075864f, -0.08907387f, 
    -0.05970556f, -0.03324044f, -0.28657296f, 0.05351394f, -0.07916783f, 0.00472448f, -0.05496624f, 0.07168964f, 
    -0.13833185f, 0.03807389f, 0.08422947f, 0.10632048f, -0.08182193f, 0.17499456f, 0.03964148f, -0.01533218f, 
    -0.13303964f, 0.13582833f, 0.12704398f, 0.11723697f, 0.04175581f, -0.04762875f, 0.07554719f, 0.09766689f, 
    -0.11715119f, 0.03076327f, 0.17166620f, 0.01241715f, 0.01755186f, -0.03404272f, -0.00724396f, -0.11714774f, 
    -0.24789868f, -0.18914932f, -0.25925624f, -0.16962855f, 0.08004798f, 0.12543176f, 0.04191396f, 0.06316150f, 
    -0.01137387f, -0.02974029f, -0.01650277f, 0.01007993f, 0.00208667f, 0.01047582f, 0.08310918f, 0.07154384f, 
    -0.07454317f, -0.06522306f, 0.04550894f, -0.12827262f, 0.00481475f, 0.01391340f, -0.07514566f, -0.09696804f, 
    0.08989159f, 0.28432626f, 0.16308464f, 0.17736207f, -0.11030854f, 0.01181436f, -0.10660151f, 0.11796940f, 
    0.11948022f, 0.08877184f, -0.00940233f, -0.03636076f, 0.17230238f, -0.08095793f, -0.35475898f, -0.17605560f, 
    0.06081305f, -0.01514749f, 0.06300095f, -0.03743980f, 0.02635472f, -0.04411659f, 0.01546460f, 0.06409016f, 
    -0.04963537f, -0.47327369f, 0.02986238f, -0.00671780f, 0.08897762f, 0.03971807f, -0.04071876f, 0.05191050f, 
    -0.01900148f, 0.01517837f, 0.04582746f, 0.05919219f, 0.21454269f, 0.46858254f, -0.11822568f, -0.06618692f, 
    -0.06937613f, -0.36532387f, 0.14814478f, 0.11082317f, -0.09664468f, 0.00919452f, -0.04782116f, -0.06332766f, 
    0.27750883f, -0.09707520f, -0.00084330f, 0.03978159f, 0.17487516f, -0.10714362f, 0.05677646f, 0.10871450f, 
    0.02280629f, -0.09941430f, -0.00809623f, 0.03199066f, 0.14305203f, 0.09351005f, 0.33149880f, 0.01129837f, 
    -0.13811725f, -0.07331797f, -0.17192014f, -0.04199201f, -0.02178803f, 0.11734024f, 0.07884561f, -0.00098250f, 
    0.26278883f, -0.03013020f, -0.17989135f, -0.00005795f, 0.08625079f, -0.00632905f, 0.10394776f, 0.04207702f, 
    -0.04653448f, -0.02273170f, 0.07381453f, 0.03525356f, -0.67554516f, 0.10328529f, -0.11068195f, 0.28543255f, 
    -0.20987593f, 0.12022990f, 0.10409518f, 0.02374275f, -0.09971534f, -0.08115568f, 0.12628151f, -0.00110401f, 
    0.05613811f, 0.41884977f, -0.33399338f, -0.08729620f, -0.08021885f, 0.06607711f, 0.10917756f, 0.00012984f, 
    -0.07237841f, -0.03352641f, -0.02725511f, 0.05660648f, 0.16436243f, 0.04466570f, 0.19131969f, 0.20748840f, 
    0.00343549f, 0.04658132f, -0.13905121f, 0.03123312f, -0.01740074f, 0.08842927f, -0.00818539f, -0.02870612f, 
    0.04559652f, -0.04912048f, -0.11410736f, 0.14961982f, 0.13913807f, -0.02240709f, 0.18369658f, 0.05145906f, 
    0.04255777f, 0.04405276f, 0.10564101f, -0.01623701f, -0.21188857f, 0.16079925f, 0.11181239f, -0.03679311f, 
    -0.00449009f, -0.02408493f, 0.09362348f, -0.14391026f, -0.00297777f, 0.14727972f, -0.10171966f, 0.02057383f, 
    -0.06101940f, -0.13379021f, -0.23354842f, -0.09261274f, -0.01751877f, 0.04891741f, 0.02558821f, -0.11448859f, 
    0.01311715f, 0.01955288f, -0.05141881f, -0.09392574f, 0.15834309f, 0.22108790f, 0.15399505f, -0.02741492f, 
    -0.04687264f, -0.05115518f, 0.07844373f, 0.03959735f, -0.10726909f, -0.12364511f, 0.09821598f, -0.00746794f, 
    0.16276148f, -0.27695262f, 0.00072139f, 0.04689506f, 0.00452639f, 0.05588547f, 0.00530915f, 0.05756228f, 
    -0.12924571f, 0.13004190f, -0.01677065f, -0.11597107f, -0.02861680f, 0.19056661f, -0.06219511f, -0.03160764f, 
    -0.01510904f, -0.03969423f, 0.07728717f, 0.03362685f, 0.25797173f, 0.05914196f, 0.01482866f, 0.06702262f, 
    0.07462030f, -0.34975657f, -0.05275235f, -0.09951404f, 0.07119305f, 0.10870495f, -0.02834693f, -0.09974955f, 
    0.16774024f, 0.08438678f, -0.01426712f, 0.08410673f, 0.52540064f, -0.19699314f, 0.29244030f, 0.05355429f, 
    0.28007004f, -0.16722704f, 0.09249789f, -0.07301321f, -0.09792314f, 0.01064978f, -0.01889000f, 0.00761840f, 
    -0.00852014f, -0.01657443f, 0.02478908f, -0.03901663f, 0.02859851f, 0.03886436f, -0.01647442f, -0.02202875f, 
    -0.00934348f, 0.03522304f, -0.05058970f, 0.03593500f, 0.01203405f, -0.05586083f, -0.04938674f, -0.03080846f, 
    0.03833627f, 0.02076188f, -0.00616775f, -0.03241206f, -0.04132213f, -0.00118339f, 0.01908151f, 0.00265536f, 
    -0.02780743f, -0.00366518f, -0.00098172f, -0.01418294f, -0.01923682f, 0.02712367f, -0.02078957f, 0.03486689f, 
    -0.01927360f, -0.03422410f, 0.03556219f, -0.03775059f, -0.02491165f, 0.01712747f, -0.04388325f, 0.04193372f, 
    0.03654025f, -0.03181708f, -0.04966133f, -0.04633841f, -0.05973709f, 0.01109336f, 0.00112249f, -0.02682238f, 
    0.02649909f, 0.03582657f, 0.02010168f, -0.04966253f, -0.01176039f, -0.02022885f, -0.01724781f, -0.04605918f, 
    0.00770610f, 0.00176702f, 0.03988221f, 0.03111932f, -0.05168981f, -0.03714319f, -0.05180934f, -0.00312667f, 
    -0.03245646f, -0.03955359f, -0.01971457f, -0.01342821f, 0.02551508f, -0.03867412f, 0.02804820f, -0.03077073f, 
    0.00119752f, -0.00662900f, -0.01199240f, -0.02848680f, -0.01525122f, -0.05059256f, 0.01680067f, -0.02863508f, 
    -0.02466793f, 0.04377906f, 0.01877866f, 0.04195369f, 0.00664244f, -0.02077164f, -0.05377944f, -0.02557844f, 
    0.02877730f, -0.05173629f, 0.03226222f, 0.00775513f, 0.00225988f, -0.04894993f, 0.04139881f, 0.00667333f, 
    0.02675423f, -0.00719443f, 0.00842982f, -0.03233207f, -0.05492270f, 0.00461932f, -0.01736283f, -0.05726964f, 
    -0.05463980f, 0.01263453f, -0.05081772f, 0.01322338f, 0.04282362f, -0.01256422f, 0.03541513f, -0.02406531f, 
    0.03462252f, 0.04214423f, -0.03336801f, 0.00343045f, 0.04479045f, -0.01769759f, -0.02320316f, -0.05021982f, 
    0.02986020f, -0.03075853f, 0.03219920f, -0.03792292f, 0.03698997f, -0.03703866f, 0.03764870f, -0.01572828f, 
    0.00111935f, -0.04357109f, 0.01263167f, 0.03846580f, 0.01640805f, 0.03729544f, -0.00274997f, -0.01093421f, 
    0.02356851f, 0.02123840f, -0.02088931f, 0.01657978f, -0.01775488f, -0.01720013f, -0.00499354f, -0.03620604f, 
    0.03875347f, 0.03280126f, 0.04237378f, -0.03534282f, 0.01436880f, -0.05697709f, -0.00469826f, 0.02375096f, 
    0.00868740f, 0.02030881f, 0.00767538f, -0.04776021f, -0.03985132f, -0.05077403f, -0.04927665f, -0.05484137f, 
    -0.04463186f, 0.03807438f, -0.05742348f, -0.04944014f, 0.01474710f, 0.02834078f, 0.03751860f, -0.04734467f, 
    -0.03811303f, 0.02691829f, 0.03692461f, -0.05054559f, -0.05349771f, -0.01803438f, -0.05793787f, -0.00330942f, 
    -0.03510143f, -0.05304328f, -0.02851745f, -0.03227014f, 0.01288287f, 0.03668238f, -0.03852898f, -0.05073174f, 
    -0.04415783f, -0.03372395f, -0.02112618f, 0.02456440f, 0.01823622f, 0.04047074f, 0.00714426f, 0.02191584f, 
    0.02886998f, -0.00322697f, -0.01600377f, 0.03446980f, 0.01072787f, 0.00911717f, -0.01365075f, 0.04183720f, 
    0.01979229f, 0.02573168f, -0.03873131f, 0.03921627f, 0.02172439f, -0.02309866f, 0.04252889f, -0.00217014f, 
    -0.01902110f, 0.03995893f, -0.05602710f, 0.00792259f, 0.00582434f, -0.04459419f, -0.04566422f, -0.02875269f, 
    -0.02580473f, 0.01983711f, -0.02192463f, -0.01407882f, 0.03299119f, -0.00982218f, 0.02232686f, 0.00537301f, 
    0.01143109f, -0.05366575f, -0.00030232f, -0.03061356f, -0.00078969f, 0.02392544f, -0.03021592f, 0.02251883f, 
    0.03454095f, -0.01955152f, -0.05286333f, 0.01034659f, -0.03798677f, -0.04985910f, 0.01117532f, -0.05452627f, 
    0.03387702f, 0.03337817f, 0.01853715f, 0.01205878f, -0.03550353f, -0.05520055f, -0.02735190f, -0.01373986f, 
    -0.03211737f, 0.01425175f, -0.04712116f, -0.04095758f, 0.04148717f, 0.02424800f, 0.00484069f, -0.00867800f, 
    -0.05670087f, 0.01186110f, -0.02500198f, 0.03635526f, -0.00630225f, -0.03174444f, -0.03243840f, 0.00595996f, 
    -0.02342398f, -0.00763852f, 0.01038052f, 0.02380021f, 0.03949248f, 0.00136494f, -0.04839312f, 0.03612089f, 
    0.00098745f, -0.05464506f, 0.03734508f, 0.03919513f, -0.02353733f, -0.04084682f, -0.05277358f, 0.03828303f, 
    -0.01810730f, -0.00455208f, 0.01042902f, 0.00569861f, 0.03957710f, -0.04217043f, -0.00862574f, 0.01582416f, 
    0.02549548f, 0.02382073f, 0.02701543f, 0.00484256f, -0.03684795f, 0.03951323f, 0.04679728f, -0.02254144f, 
    -0.05403793f, 0.01005141f, 0.02515194f, -0.05849136f, -0.03097010f, -0.05340686f, -0.05060732f, -0.04329611f, 
    0.03598291f, 0.02594565f, -0.02139726f, 0.01763454f, -0.00832070f, -0.03185127f, 0.03892932f, -0.04791349f, 
    -0.01097629f, 0.02492418f, -0.00285201f, 0.04068751f, -0.04646036f, 0.01514301f, 0.00355851f, -0.03072868f, 
    0.00442102f, 0.01785909f, -0.00049493f, 0.02649070f, -0.02341823f, 0.02546476f, 0.02796483f, -0.04648487f, 
    -0.03443342f, -0.05576752f, -0.03874535f, -0.01866710f, -0.02415445f, 0.00118906f, 0.00447693f, -0.01609271f, 
    0.03657050f, 0.00097551f, -0.03420769f, 0.04185700f, 0.02857275f, -0.05500795f, -0.03551439f, -0.02133567f, 
    -0.05116357f, -0.01356469f, -0.02317978f, -0.05556503f, -0.01843983f, 0.03687301f, -0.00388326f, 0.03020928f, 
    -0.01997287f, 0.03546394f, -0.03630944f, -0.02118703f, -0.03624513f, -0.00266488f, -0.05966372f, -0.04564805f, 
    -0.03889175f, -0.00609499f, -0.03894013f, 0.00022373f, -0.04874666f, 0.03813208f, 0.00512759f, 0.01800278f, 
    0.04308474f, 0.00185862f, -0.04344007f, -0.05597011f, 0.01626173f, 0.04444317f, -0.03600436f, -0.04473879f, 
    -0.05019772f, -0.01166459f, -0.04307823f, 0.02176488f, -0.05267610f, 0.02307871f, -0.00998191f, -0.01308050f, 
    0.33318785f, 0.14809507f, 0.04111921f, -0.07165249f, -0.05686691f, 0.10589134f, -0.05715973f, 0.02717487f, 
    -0.10497084f, -0.02692461f, -0.01631688f, 0.12544067f, 0.11140032f, 0.14554061f, -0.03130123f, -0.06106809f, 
    -0.13533077f, 0.05078284f, 0.06313950f, 0.01450820f, 0.09129321f, 0.13342889f, 0.15501714f, 0.12442884f, 
    0.38265219f, -0.07566296f, 0.01850553f, 0.33133212f, 0.13505614f, 0.12663741f, -0.02724561f, 0.05444379f, 
    0.07266475f, -0.08862793f, 0.02046576f, 0.08663914f, -0.10889771f, -0.57739490f, 0.09394778f, -0.39053324f, 
    0.07327113f, 0.10188735f, 0.09558626f, 0.04255080f, 0.09918951f, 0.04567456f, 0.17386392f, 0.18069439f, 
    -0.38300920f, -0.24106026f, -0.19123407f, -0.43837231f, 0.07050306f, 0.10183856f, 0.12391098f, 0.06452336f, 
    -0.10084848f, 0.01578994f, -0.05123737f, -0.06593309f, 0.22933584f, 0.15309453f, 0.12686336f, 0.02214183f, 
    0.03848434f, -0.03280319f, -0.00001750f, 0.03711284f, -0.00312455f, -0.04202450f, -0.09421413f, -0.02297186f, 
    -0.60236228f, -0.20606476f, -0.22043687f, 0.12984754f, -0.04479621f, -0.05779999f, 0.02885220f, -0.02203550f, 
    0.12796026f, 0.06122168f, 0.08798700f, -0.09551689f, 0.38986015f, 0.20061938f, -0.14231214f, -0.12254050f, 
    0.04279310f, -0.05887735f, -0.05231365f, -0.03524089f, -0.03259585f, 0.06458165f, 0.08119506f, 0.02261461f, 
    0.26446429f, 0.20337251f, 0.08069882f, 0.14019874f, -0.05611298f, 0.06257649f, 0.00846877f, 0.02426390f, 
    -0.00538517f, -0.04636902f, 0.09643281f, -0.02421275f, 0.19818762f, -0.04720543f, 0.20241396f, 0.00388592f, 
    0.02640008f, -0.04965346f, 0.21789482f, 0.10886929f, 0.01192247f, -0.11624693f, 0.11766092f, -0.00161594f, 
    -0.09286856f, -0.18090655f, -0.05651905f, -0.04404421f, 0.13852262f, 0.02584510f, -0.02140717f, -0.00851369f, 
    0.05852104f, 0.03450757f, 0.03635982f, -0.27590525f, -0.22461417f, -0.59105062f, -0.08414771f, 0.18591423f, 
    0.05340827f, -0.07333273f, -0.00325130f, -0.06347483f, 0.03587550f, 0.01223470f, 0.05700645f, 0.07607979f, 
    -0.09644759f, 0.04870079f, -0.11970134f, -0.16386348f, -0.08614544f, 0.02194706f, -0.04054962f, 0.07982818f, 
    0.11715648f, 0.09914859f, -0.07645271f, -0.15318760f, -0.01577566f, 0.03347482f, 0.05791450f, 0.06682970f, 
    0.15852952f, -0.06469150f, 0.07015682f, -0.08911630f, -0.11189564f, -0.01829083f, -0.02703133f, -0.00177038f, 
    0.16273445f, 0.34018677f, 0.00754800f, 0.22952849f, 0.03701792f, 0.13608956f, 0.06536298f, -0.06172754f, 
    0.00068147f, 0.03546041f, 0.12198768f, 0.01365321f, -0.10334737f, -0.02472885f, 0.05495981f, -0.17248082f, 
    -0.14464578f, -0.02894040f, -0.02417752f, 0.08797123f, 0.08245043f, -0.02915864f, 0.07466345f, 0.03256015f, 
    -0.01793096f, -0.04725998f, -0.12227494f, -0.17875949f, 0.02089056f, 0.12177041f, -0.02942428f, 0.01761966f, 
    0.15353052f, 0.12565985f, 0.05424381f, 0.04705686f, 0.11023524f, -0.04472300f, -0.11723914f, 0.11739666f, 
    0.00809347f, 0.13910905f, 0.11060400f, -0.10882217f, 0.05895066f, 0.04339581f, 0.01469836f, 0.04919577f, 
    -0.28506353f, -0.03708497f, 0.26653105f, 0.06243839f, 0.02712198f, 0.19450210f, 0.23869494f, 0.03217892f, 
    -0.03313565f, -0.14208837f, -0.02281370f, -0.24151096f, 0.30137226f, 0.06269311f, 0.09774314f, -0.04071580f, 
    0.08585794f, 0.02162908f, 0.19016513f, -0.05190321f, -0.09864038f, -0.00659379f, 0.08801723f, -0.14038281f, 
    -0.12396821f, -0.50239241f, -0.32941857f, -0.08857913f, 0.03071457f, -0.09780450f, 0.15677367f, -0.13930374f, 
    -0.00251357f, 0.04973877f, 0.13692853f, 0.01718877f, -0.10735394f, 0.00386926f, 0.07086042f, 0.49967065f, 
    -0.01986578f, -0.06786857f, -0.01229551f, 0.05776077f, 0.05019265f, 0.03338964f, 0.03762526f, 0.03768698f, 
    -0.03597419f, -0.08546506f, -0.08676095f, 0.10837184f, 0.09767022f, 0.10394260f, 0.03691903f, -0.07260898f, 
    0.02891026f, 0.06286838f, 0.10286798f, -0.01312823f, 0.18084125f, -0.20567834f, 0.04637094f, -0.02506411f, 
    -0.08552010f, 0.09543628f, -0.07139634f, 0.01238422f, 0.08195720f, -0.04326063f, 0.00501394f, -0.04387657f, 
    -0.34430435f, -0.27770239f, -0.33783945f, -0.04058154f, -0.12721814f, -0.14713317f, -0.02204436f, -0.17442499f, 
    -0.04857785f, 0.00207365f, -0.04980321f, -0.14346954f, -0.05691967f, 0.06387664f, 0.01298887f, 0.05415103f, 
    0.16670714f, 0.08558858f, -0.07737187f, 0.01657120f, -0.05132352f, -0.02062839f, -0.04529046f, -0.03134291f, 
    0.02513875f, 0.19150783f, 0.05772045f, 0.04574751f, -0.10060968f, -0.05773880f, 0.00218802f, -0.03620762f, 
    -0.11197986f, -0.13244595f, 0.09496119f, 0.12852012f, 0.04488041f, -0.03359201f, -0.04455132f, 0.08889768f, 
    -0.15000321f, 0.15979363f, 0.07727743f, 0.00477883f, 0.15768191f, 0.06675381f, 0.18972115f, -0.05439494f, 
    0.00292629f, -0.15121704f, 0.12073144f, -0.20900925f, -0.07801103f, 0.18780413f, 0.01849300f, 0.04457412f, 
    0.14290693f, 0.17739978f, -0.10467470f, -0.12643260f, 0.05597220f, 0.21495731f, -0.04639047f, -0.01384926f, 
    0.01327324f, 0.10346761f, 0.12496226f, 0.06382889f, 0.11533988f, 0.09281739f, 0.06866851f, -0.05321418f, 
    -0.40965557f, -0.47682911f, 0.09369182f, -0.09045158f, -0.01102083f, -0.03758985f, 0.07388411f, 0.08552508f, 
    0.14354512f, 0.02655170f, 0.10423587f, 0.03344933f, 0.32347062f, -0.15385443f, 0.17848152f, -0.07066572f, 
    0.01015436f, 0.06990237f, -0.05394766f, 0.19532622f, -0.06647702f, 0.17051777f, 0.03796329f, 0.08472719f, 
    0.12317920f, 0.22146671f, 0.04974537f, -0.06810314f, -0.00399925f, -0.11507832f, -0.04755313f, -0.11902978f, 
    0.02441907f, 0.03074411f, -0.10767747f, 0.05334112f, -0.16421637f, 0.15354623f, -0.10444113f, 0.01280405f, 
    -0.12497785f, -0.07085889f, 0.03248240f, -0.00392410f, 0.15527210f, -0.04530102f, 0.07941394f, 0.08871321f, 
    0.07059680f, -0.18394098f, -0.18402998f, 0.14794539f, -0.15168065f, 0.00638929f, 0.11574005f, 0.07921091f, 
    0.00326122f, -0.09010410f, 0.09539524f, -0.04419212f, -0.00594459f, -0.11586028f, 0.15040800f, -0.11916690f, 
    0.07937590f, 0.08832134f, 0.12635726f, 0.23227613f, 0.01340119f, 0.05843747f, -0.12006582f, -0.05544246f, 
    -0.50779188f, -0.10636207f, 0.06760986f, -0.13735521f, 0.15740466f, 0.23416619f, 0.00415738f, 0.10382480f, 
    -0.01508184f, 0.13463069f, -0.10520920f, -0.20396893f, -0.08246307f, -0.03525040f, -0.15579320f, 0.03005994f, 
    -0.13787262f, -0.11501991f, -0.11841762f, -0.09989017f, -0.02948917f, 0.00930988f, 0.00540747f, 0.08966725f, 
    -0.11873028f, -0.02640698f, -0.16635926f, -0.12596722f, 0.12035156f, 0.17399374f, 0.04982323f, 0.05566913f, 
    0.08774474f, -0.02825705f, 0.03687307f, -0.01377944f, 0.19664887f, 0.16917773f, 0.06584700f, -0.04769845f, 
    0.04343288f, 0.00546690f, -0.07782329f, -0.03312190f, 0.00372284f, -0.02947907f, -0.01699090f, 0.17978984f, 
    0.02375442f, 0.28827530f, 0.08182193f, 0.16808209f, 0.09548540f, -0.07326881f, -0.02551429f, 0.00371620f, 
    0.00702134f, -0.03966325f, 0.03653997f, 0.09843879f, 0.04557110f, -0.04264012f, 0.17516477f, 0.12531061f, 
    0.19306082f, -0.02179659f, 0.01417767f, 0.00255701f, 0.01761206f, 0.01514573f, 0.17575121f, 0.12525198f, 
    -0.32627916f, -0.21170287f, 0.06958112f, -0.09865756f, -0.06799675f, 0.11618824f, -0.08870801f, 0.07192834f, 
    -0.03613664f, 0.14872058f, 0.08364809f, -0.06873066f, 0.26872459f, 0.02844387f, -0.11806081f, -0.06587403f, 
    0.09800141f, 0.02420976f, -0.03233549f, -0.17151009f, -0.01121500f, -0.01773696f, 0.11242951f, 0.12549171f, 
    -0.29717350f, -0.18889287f, -0.19232818f, -0.07383689f, 0.04075293f, 0.07529434f, -0.13060373f, -0.04822118f, 
    0.07765853f, 0.19128564f, -0.00867593f, -0.12772207f, -0.22972496f, -0.05932114f, -0.09237000f, 0.10287596f, 
    0.03839562f, 0.02278903f, 0.03125485f, -0.12827615f, -0.00462106f, 0.01625121f, 0.10606648f, 0.15831192f, 
    -0.13357724f, 0.19711334f, -0.18103111f, 0.14532754f, 0.07005583f, 0.09315852f, 0.06610607f, -0.07669028f, 
    -0.12372615f, -0.09859929f, 0.01369062f, -0.04782566f, -0.44493616f, -0.13604601f, -0.15978633f, 0.09701367f, 
    -0.21541941f, 0.06235092f, -0.00927570f, -0.05737927f, 0.08879781f, 0.09444766f, 0.00536462f, 0.11517724f, 
    0.31142503f, -0.05490567f, -0.15444860f, -0.00335681f, 0.12252990f, 0.20907542f, -0.09361674f, 0.07326902f, 
    0.07444620f, 0.00411605f, -0.06067439f, 0.06639823f, -0.01401102f, 0.43395168f, -0.17070162f, 0.04578942f, 
    0.05404988f, -0.08183432f, 0.05635359f, -0.03369346f, 0.12762292f, -0.04925128f, -0.04759360f, 0.03346183f, 
    -0.03415386f, 0.03406378f, 0.03733438f, -0.08431810f, 0.09574627f, 0.09773435f, 0.24108151f, 0.01524389f, 
    0.00612374f, -0.11227944f, -0.03014312f, -0.06570446f, 0.07247066f, 0.13454700f, 0.14482626f, 0.07245024f, 
    0.13463971f, 0.10258083f, 0.03054246f, -0.04883868f, -0.05789338f, 0.09603173f, 0.03485477f, 0.14372836f, 
    0.31452057f, 0.15944977f, -0.06967867f, -0.07779370f, 0.16344889f, 0.17621244f, 0.09986616f, 0.00503739f, 
    -0.12291591f, 0.04682150f, 0.02090116f, -0.08676504f, 0.11604396f, -0.02064931f, -0.30089861f, 0.10647871f, 
    0.01044155f, 0.01227358f, 0.01557357f, 0.12053176f, 0.09395245f, -0.00992126f, 0.14859833f, 0.09565259f, 
    -0.00339598f, 0.03879074f, 0.06230808f, -0.12631768f, -0.06451634f, -0.20163395f, 0.13746113f, -0.02934717f, 
    0.06015860f, 0.03255332f, 0.10883556f, 0.18444514f, 0.33684912f, 0.10081958f, -0.12482160f, -0.09802701f, 
    -0.03599644f, 0.03268564f, 0.05625362f, 0.00237409f, -0.10262799f, 0.03095190f, 0.00515595f, 0.02604344f, 
    0.13226615f, 0.11638419f, 0.06860403f, -0.06589266f, -0.01125142f, 0.08555985f, -0.02768735f, -0.00343197f, 
    -0.05856967f, 0.01971436f, -0.06905080f, 0.04672962f, -0.21820322f, -0.13706665f, -0.03645765f, 0.05137540f, 
    0.01416548f, 0.06109620f, -0.05991341f, -0.07525506f, -0.14647160f, 0.03359086f, 0.07877010f, 0.04914561f, 
    -0.11648436f, -0.01409818f, -0.11969011f, -0.09072347f, -0.05348031f, -0.02856619f, 0.06889816f, -0.10603568f, 
    -0.11897191f, -0.25456619f, 0.00427637f, -0.08746473f, -0.04599000f, 0.27490637f, 0.09086753f, -0.00368241f, 
    -0.07560857f, 0.09244768f, 0.09492742f, 0.02688374f, 0.02790654f, -0.08603928f, -0.08846175f, -0.09135153f, 
    -0.05216619f, -0.08204287f, 0.00412254f, -0.01020208f, -0.10244606f, 0.09839275f, 0.06146611f, 0.03351712f, 
    -0.08490508f, 0.06378348f, -0.00712861f, -0.08585976f, -0.06240572f, 0.08120243f, -0.03777221f, -0.00686287f, 
    -0.18418175f, 0.00742223f, 0.04357236f, -0.01243581f, 0.14278704f, 0.03207532f, 0.07191814f, 0.11027432f, 
    0.08520250f, 0.02131170f, -0.00449759f, -0.04508682f, 0.10182821f, 0.17101191f, 0.02345287f, 0.02882558f, 
    0.12990354f, 0.00433632f, 0.04815493f, 0.07292010f, 0.11122297f, -0.02093606f, 0.22511654f, 0.16878696f, 
    0.07254891f, -0.04590728f, -0.02424807f, 0.01273500f, 0.08202191f, 0.24404711f, -0.10282912f, 0.05118815f, 
    0.18363747f, -0.21699047f, 0.36096457f, -0.04228747f, 0.21576439f, 0.09870408f, 0.09816994f, 0.09136937f, 
    -0.07155243f, -0.10028955f, -0.03948516f, -0.01215505f, 0.22467951f, -0.21147816f, 0.17116809f, -0.02567674f, 
    0.00234488f, -0.13262038f, -0.13395843f, 0.07074903f, 0.08069213f, 0.11388084f, 0.08268893f, 0.11084124f, 
    -0.02802086f, 0.18702877f, 0.00237115f, -0.15659328f, 0.22209194f, 0.11063137f, -0.17136960f, 0.04087126f, 
    0.14883199f, -0.15446036f, 0.03905656f, -0.19301695f, -0.23710278f, 0.34669316f, -0.26967525f, 0.21686940f, 
    0.11902162f, -0.03797502f, 0.01104483f, -0.02556753f, 0.06250365f, 0.06919331f, 0.07353317f, -0.04204354f, 
    -0.36252487f, -0.13155374f, -0.25090778f, 0.12396527f, 0.01373838f, -0.05823072f, 0.07301968f, 0.27044284f, 
    0.07862477f, -0.19112132f, 0.03739252f, 0.03669906f, -0.26617220f, -0.10017673f, -0.09669499f, 0.03610110f, 
    0.03304389f, 0.01181407f, -0.17317627f, -0.04532679f, 0.02475344f, -0.07371727f, -0.01109662f, -0.03684802f, 
    -0.15354714f, -0.10671804f, 0.01855903f, -0.01027928f, 0.02760708f, 0.00955418f, 0.07492582f, 0.01750572f, 
    0.12978655f, 0.12141011f, 0.02536271f, 0.05167045f, 0.34277487f, -0.09206326f, 0.32328621f, 0.25205463f, 
    0.23786746f, 0.02054587f, 0.00666385f, 0.08729712f, -0.00854946f, -0.06467255f, -0.04248832f, -0.06855541f, 
    0.29296064f, -0.21174477f, 0.15567696f, 0.05117063f, 0.07277469f, -0.02183215f, -0.02423308f, 0.04024164f, 
    0.11931876f, 0.03606524f, 0.04132705f, 0.08703732f, -0.04277367f, 0.24238874f, -0.24372613f, 0.04921521f, 
    0.16019592f, -0.04323500f, -0.08888607f, 0.18787165f, -0.21884370f, -0.08326316f, -0.03154084f, 0.06118352f, 
    -0.33555719f, 0.16617474f, -0.35654843f, -0.19955680f, 0.19051571f, -0.08175848f, 0.05682610f, -0.18589392f, 
    -0.00626355f, -0.02022186f, -0.03617589f, -0.09351242f, -0.06921834f, 0.37025973f, 0.24260533f, -0.19692159f, 
    -0.05800037f, 0.02619576f, 0.00430652f, 0.16610725f, -0.10175527f, 0.02968432f, 0.08446003f, -0.03191663f, 
    0.01537867f, -0.11578178f, 0.14590417f, 0.09036809f, -0.02858093f, 0.09105708f, -0.01521621f, -0.03903433f, 
    0.16754100f, -0.03102507f, 0.06764544f, 0.08664777f, 0.11331742f, -0.08553259f, 0.01860134f, -0.09278398f, 
    0.02046616f, 0.05914500f, -0.06754767f, -0.07642414f, -0.08875268f, -0.04718960f, -0.23400360f, -0.10141346f, 
    0.22809707f, -0.25104937f, 0.14288300f, -0.14774464f, 0.08946094f, 0.07360455f, 0.08057252f, 0.12713851f, 
    0.01334555f, -0.01800306f, -0.14512797f, -0.04288237f, 0.25724217f, -0.14731324f, 0.07626610f, -0.00912843f, 
    -0.01855664f, -0.05247384f, 0.04865772f, 0.07354052f, 0.01027384f, -0.04076831f, 0.06889250f, 0.02332579f, 
    -0.01665270f, -0.00398784f, 0.10716226f, -0.08413656f, 0.01516466f, 0.07918614f, 0.08743764f, 0.21378434f, 
    -0.13349503f, -0.06398806f, 0.04117054f, -0.03850942f, 0.21118777f, -0.06062898f, 0.60477364f, -0.18991956f, 
    -0.13438939f, -0.03925231f, -0.03258051f, 0.12570544f, 0.04347171f, 0.10188775f, 0.02487319f, 0.07341132f, 
    0.55009890f, -0.27655354f, 0.08362986f, 0.25486258f, 0.06463131f, -0.03996744f, 0.10864914f, 0.00416679f, 
    0.17240305f, -0.00143223f, -0.08282379f, -0.13429162f, -0.32145280f, 0.08507723f, -0.27048895f, 0.02811316f, 
    0.15776351f, 0.13795376f, 0.06720339f, 0.07227630f, -0.03081504f, -0.11658382f, -0.00843694f, -0.03504752f, 
    -0.14110917f, -0.00645196f, -0.09609651f, -0.02751088f, 0.00059599f, -0.06425136f, 0.04449728f, 0.05207248f, 
    0.00613743f, -0.05303051f, 0.05677686f, 0.23482883f, -0.22913237f, 0.17414932f, -0.02731846f, -0.28184435f, 
    0.02606345f, 0.04054037f, 0.08585490f, 0.13430353f, 0.11465748f, -0.13016212f, 0.24148089f, 0.05534548f, 
    0.00135728f, -0.17327283f, -0.10938293f, -0.05825715f, 0.06118289f, -0.00527108f, 0.05498986f, 0.02089118f, 
    -0.06933701f, -0.01234868f, -0.02541606f, 0.02171736f, -0.14566995f, 0.40192854f, 0.10658718f, -0.05446750f, 
    0.07142447f, -0.01343879f, 0.00193828f, 0.04861060f, 0.00823719f, -0.01543870f, -0.06226709f, 0.02879312f, 
    -0.03225913f, 0.08121232f, 0.07200812f, 0.06510587f, 0.08205927f, 0.16254479f, 0.23795134f, -0.08931746f, 
    -0.06236067f, -0.12043926f, -0.01891213f, -0.09616621f, 0.03098790f, -0.07282691f, -0.08088302f, -0.00659780f, 
    0.05693536f, 0.01167228f, 0.14046034f, -0.01978567f, 0.03017220f, -0.10524932f, -0.08634038f, -0.08444399f, 
    0.09507265f, -0.37978783f, 0.09340914f, 0.02945409f, -0.02495119f, -0.10070464f, 0.10190837f, 0.16436303f, 
    0.07307511f, 0.30407062f, 0.14659891f, 0.07084697f, -0.09518222f, -0.11885680f, 0.08010862f, -0.10947262f, 
    0.12397424f, -0.05346556f, 0.12001634f, 0.11172594f, 0.02564560f, 0.06837138f, 0.19101250f, 0.10591117f, 
    0.01400658f, 0.21972205f, 0.03833536f, 0.10438079f, 0.08375914f, -0.07124568f, -0.00264320f, -0.01763328f, 
    0.20256422f, 0.08554662f, -0.00717131f, 0.13799784f, 0.06032546f, -0.19254246f, -0.07036178f, 0.01539857f, 
    0.24081598f, -0.07880879f, 0.06219299f, 0.11857496f, 0.08970455f, -0.03739518f, -0.07739558f, -0.12653232f, 
    -0.08814767f, -0.15964124f, 0.00156737f, 0.05276237f, -0.02344410f, 0.03232837f, -0.10192617f, -0.05348032f, 
    0.09889880f, 0.00445395f, -0.09276959f, 0.10991787f, 0.24980383f, -0.04760849f, -0.09143832f, 0.30903220f, 
    0.12745431f, -0.01211473f, 0.07249416f, -0.01860314f, 0.18049218f, -0.07633521f, 0.03935460f, -0.06803874f, 
    0.50521415f, -0.01647307f, 0.10167110f, -0.25839481f, 0.06806419f, -0.04526408f, -0.03403395f, 0.01052500f, 
    0.01329680f, -0.02412757f, -0.06022128f, -0.07245873f, 0.09710146f, 0.00455852f, -0.02752008f, 0.07721819f, 
    -0.04320894f, -0.06027441f, 0.00742378f, -0.04046736f, -0.01037893f, -0.02072434f, 0.03316043f, 0.09148522f, 
    0.09366233f, 0.05951504f, 0.04970099f, 0.07986478f, 0.11532035f, 0.01812918f, 0.09262189f, 0.00889564f, 
    0.07966390f, -0.07716936f, 0.09126346f, 0.07595719f, -0.29582587f, -0.04346198f, -0.02584819f, -0.11961599f, 
    0.18299392f, 0.09484956f, 0.09993818f, -0.05254872f, 0.12656303f, 0.04686547f, 0.15773039f, 0.07512397f, 
    -0.72705281f, -0.08412275f, -0.18041095f, -0.27941456f, -0.11579321f, -0.16465065f, 0.02331577f, 0.10703112f, 
    -0.10857356f, 0.06188908f, 0.01155702f, -0.08252344f, 0.02449410f, 0.12926197f, 0.01554634f, -0.01099907f, 
    -0.10719645f, 0.01735811f, -0.04131444f, 0.04346371f, 0.10368375f, 0.01428792f, -0.10969250f, -0.09778174f, 
    -0.13165799f, 0.03642941f, -0.00518135f, -0.07006229f, -0.17732906f, -0.10780995f, 0.09619723f, 0.03315148f, 
    0.13437131f, -0.01310129f, -0.06267641f, 0.00814173f, 0.38260949f, 0.17695993f, -0.05749356f, 0.00137291f, 
    0.01900602f, 0.02308572f, -0.00474578f, 0.07669457f, 0.04903265f, 0.07271308f, -0.00011364f, -0.15334713f, 
    0.18786864f, -0.03122780f, -0.07789870f, 0.39558908f, 0.03133803f, 0.00063826f, 0.00933793f, -0.04667353f, 
    0.03521244f, -0.01585927f, 0.14703090f, -0.04985264f, 0.11236077f, 0.10901164f, -0.01855218f, -0.06486621f, 
    0.03349167f, 0.03929076f, 0.18549076f, -0.00542086f, 0.01272854f, 0.01638813f, 0.03070057f, 0.08980682f, 
    -0.29187226f, -0.08293971f, -0.10980356f, -0.17206670f, 0.09639416f, 0.08568906f, 0.24019845f, 0.26835507f, 
    0.05899428f, 0.02330189f, -0.00637697f, 0.10763852f, 0.04544672f, 0.16198511f, 0.17176519f, -0.11654680f, 
    0.06318668f, -0.08820572f, -0.08761077f, 0.08481894f, 0.08772200f, -0.00305171f, -0.02748400f, 0.08965018f, 
    -0.15119067f, 0.10226907f, -0.02882832f, -0.17111906f, -0.13059199f, -0.07358459f, -0.05606509f, -0.16379826f, 
    0.00390274f, -0.01270398f, -0.01993159f, -0.08356252f, 0.07757661f, -0.13396525f, 0.04051377f, -0.01690850f, 
    -0.04242774f, 0.09721650f, 0.24193302f, 0.17005400f, -0.03404741f, 0.06597156f, -0.05877679f, 0.02569588f, 
    0.46271256f, 0.17576045f, -0.01734968f, -0.10997304f, 0.00453130f, 0.16616988f, -0.04888650f, 0.10313410f, 
    0.08336753f, -0.03115579f, 0.08964261f, 0.00681263f, -0.12788974f, -0.10468550f, 0.00186260f, -0.07300635f, 
    -0.17140177f, -0.03429218f, -0.14265977f, -0.00857193f, 0.07339199f, -0.03043299f, 0.08377204f, 0.02370733f, 
    0.14509194f, 0.10333924f, 0.13827559f, -0.14534408f, -0.09063946f, 0.09552176f, 0.02122079f, 0.08286905f, 
    0.03147312f, -0.08130898f, -0.01234740f, 0.04062311f, 0.05919088f, -0.03084502f, 0.07704718f, 0.20421448f, 
    0.14717177f, 0.08248346f, -0.03476869f, 0.00966358f, 0.14620915f, 0.06204558f, -0.00008484f, 0.05076300f, 
    -0.12198269f, -0.21096350f, -0.03512022f, 0.17565677f, -0.03890052f, 0.00315127f, 0.06696189f, -0.04150751f, 
    0.07918137f, -0.13967724f, -0.04797459f, 0.02366809f, 0.05660491f, 0.00246113f, -0.01426300f, 0.04639588f, 
    0.10456458f, 0.03033376f, 0.14900246f, 0.04319898f, -0.04906327f, -0.02334287f, 0.03173991f, -0.00487941f, 
    -0.07534216f, -0.01182145f, 0.02333596f, 0.01504132f, -0.09655654f, 0.05446669f, 0.09570281f, 0.02285843f, 
    0.08662733f, 0.06132004f, -0.07873218f, -0.03838121f, -0.08062853f, 0.22695465f, 0.10370909f, -0.05895290f, 
    -0.12135483f, -0.00804532f, 0.17438598f, 0.30180806f, 0.13683848f, -0.09965044f, -0.08886362f, 0.17401913f, 
    0.02879927f, -0.32578570f, 0.11800385f, 0.11420064f, 0.02152066f, 0.17440808f, 0.12918057f, 0.04160312f, 
    0.17442772f, 0.08636199f, -0.05386810f, -0.03249084f, -0.20049390f, 0.05205012f, 0.07689841f, -0.14503127f, 
    -0.08444801f, 0.03155147f, -0.07299146f, 0.02136835f, 0.03529913f, -0.02617885f, -0.09580585f, 0.00233271f, 
    -0.12925230f, 0.03766319f, 0.06307314f, 0.11144903f, -0.11594870f, 0.01556763f, 0.00724572f, -0.04284669f, 
    -0.04247198f, 0.00725467f, 0.02506555f, -0.01751356f, -0.00923830f, 0.02451618f, -0.08213829f, 0.00304014f, 
    0.03382080f, 0.03998050f, 0.12763287f, 0.13647525f, 0.03314239f, -0.03242112f, 0.13397817f, 0.05699732f, 
    0.01038473f, -0.16710944f, 0.10535927f, 0.12674662f, 0.10095517f, 0.00440428f, -0.02300684f, -0.00291070f, 
    0.09582982f, -0.16866116f, 0.07847955f, 0.02991255f, -0.20777717f, -0.10609492f, 0.05089345f, 0.15036228f, 
    0.13420966f, 0.14091405f, -0.16478321f, -0.12041236f, 0.24262722f, 0.02996871f, 0.00781923f, 0.07010860f, 
    -0.16905229f, -0.08025858f, -0.09731760f, -0.03485371f, -0.04022459f, 0.09686112f, 0.00092686f, -0.09671964f, 
    0.06119411f, -0.02848785f, 0.10851777f, 0.24569464f, 0.07601656f, 0.10961858f, -0.08284179f, 0.09870379f, 
    0.05107787f, 0.05585837f, 0.12010283f, 0.00584586f, 0.04039082f, 0.05804195f, 0.00561233f, -0.10837677f, 
    -0.20001675f, -0.21076342f, 0.03836066f, 0.06325115f, 0.00220659f, 0.06629407f, 0.09183592f, 0.02209912f, 
    0.15882878f, 0.05402804f, -0.03426998f, -0.00389540f, 0.13418756f, -0.14039446f, 0.04626830f, 0.30993769f, 
    0.14206383f, -0.00116830f, 0.03455569f, 0.00325512f, 0.02311110f, 0.08808979f, 0.15610614f, 0.07965272f, 
    -0.01947926f, -0.03203872f, 0.03805495f, -0.01861818f, -0.04397250f, -0.02714766f, -0.00793030f, -0.01805552f, 
    -0.00567097f, -0.05422293f, 0.00022397f, -0.04535848f, 0.03368567f, -0.05614782f, -0.04388463f, -0.03047827f, 
    -0.00012114f, -0.04028594f, 0.01457759f, -0.03519110f, 0.00679267f, -0.03810667f, -0.02239391f, -0.00858135f, 
    0.02393238f, 0.04022606f, 0.01312875f, -0.02274833f, 0.01430717f, -0.04674903f, -0.00393237f, 0.03088163f, 
    0.00884937f, -0.03423921f, 0.00864668f, -0.00483767f, 0.04955079f, -0.01694678f, -0.03913497f, 0.04620773f, 
    0.02766171f, -0.00947982f, -0.05212517f, 0.04231819f, -0.03038539f, 0.02639807f, -0.02616914f, -0.00548014f, 
    0.02253444f, -0.04382603f, -0.04065491f, 0.01768445f, 0.02338949f, -0.05003440f, 0.02471615f, 0.01851043f, 
    0.01597854f, 0.02751813f, -0.00857176f, 0.04371346f, 0.03438574f, -0.01318387f, 0.01347339f, -0.04608085f, 
    -0.00322999f, -0.01237342f, -0.04792230f, 0.02188575f, -0.03007636f, -0.02156463f, -0.02415157f, 0.04290931f, 
    -0.03339190f, 0.00152806f, -0.04098145f, -0.00095691f, -0.03648955f, -0.04816103f, -0.03770974f, 0.00966723f, 
    -0.03593681f, -0.04834844f, 0.02598337f, -0.01551123f, 0.02567255f, 0.02905384f, -0.04056614f, 0.03409759f, 
    0.01124632f, -0.01196625f, 0.00139269f, 0.00583012f, 0.04132071f, -0.02418419f, 0.01517430f, 0.01535871f, 
    0.01254814f, 0.03990051f, -0.04362457f, 0.02386521f, -0.05368193f, -0.05360169f, 0.02863438f, 0.02216700f, 
    -0.00994771f, 0.03486868f, 0.02624882f, -0.02322571f, -0.02796776f, -0.02515052f, 0.00436697f, -0.04046891f, 
    0.01789910f, 0.00645080f, -0.03308127f, 0.02683799f, -0.05074279f, -0.03380599f, 0.01905022f, -0.01195309f, 
    -0.04796017f, -0.03600767f, 0.00997159f, -0.01467958f, 0.04658712f, -0.01002420f, 0.00579675f, 0.04170936f, 
    0.00094230f, 0.04448992f, -0.02663225f, -0.01886697f, -0.01735453f, 0.04466102f, 0.00505982f, -0.03958716f, 
    -0.01719972f, 0.01492890f, -0.00925959f, 0.04681356f, -0.05355555f, 0.04119688f, -0.01834084f, -0.04767790f, 
    0.03223538f, 0.00873430f, -0.00782907f, 0.01127899f, -0.02607862f, -0.03361675f, 0.00718806f, 0.03264870f, 
    0.00047584f, -0.03118003f, -0.03763671f, -0.01906593f, -0.04662239f, -0.05607073f, 0.03153579f, 0.00863586f, 
    -0.03884400f, -0.03371337f, -0.03023745f, -0.05055624f, -0.03019342f, 0.02811891f, -0.02355099f, 0.02946338f, 
    0.00476942f, 0.03448115f, 0.01060961f, 0.02838193f, -0.01246085f, 0.00906015f, 0.04358748f, -0.05196918f, 
    0.04442769f, 0.03475895f, 0.03143280f, -0.00337427f, 0.01580621f, -0.04263872f, -0.04731500f, -0.04896571f, 
    0.04110775f, 0.02465712f, -0.01741558f, -0.05062697f, 0.03077760f, -0.01421595f, -0.00030406f, 0.01350347f, 
    -0.02936314f, 0.00069209f, 0.03404133f, 0.03743009f, 0.02085622f, -0.05226599f, -0.02094040f, -0.03150293f, 
    -0.04302261f, 0.02599707f, -0.04913119f, -0.04987806f, 0.00937342f, -0.05017713f, 0.05014378f, -0.04301937f, 
    0.00316530f, -0.02117785f, -0.00303983f, -0.01044560f, -0.05079767f, -0.02223923f, -0.00229014f, 0.04148220f, 
    -0.03860969f, 0.00142526f, 0.00308843f, 0.02926537f, 0.04171613f, 0.01010597f, -0.03966324f, -0.04968413f, 
    0.03235001f, -0.00563087f, -0.00395227f, -0.03249974f, 0.00115517f, -0.01343075f, -0.05385827f, 0.00408437f, 
    0.01730797f, -0.03160855f, 0.00757670f, 0.03803710f, -0.03597130f, -0.02344499f, -0.00309180f, 0.00846658f, 
    -0.01608775f, 0.04150381f, -0.03263773f, 0.02760884f, 0.00513693f, -0.03326426f, 0.03294352f, -0.05006324f, 
    -0.00002066f, 0.02500774f, -0.01176439f, 0.02969390f, 0.01172607f, 0.02432504f, -0.03544880f, 0.00557469f, 
    -0.04674418f, -0.04737824f, -0.01803458f, -0.04797959f, 0.03030059f, -0.01287006f, -0.02617419f, 0.01613901f, 
    0.02135172f, 0.04200151f, 0.03816004f, -0.01480775f, -0.04026447f, -0.01662451f, 0.02039312f, -0.00589199f, 
    0.00750552f, -0.01335215f, -0.02047656f, -0.02220770f, -0.04541466f, 0.03792603f, -0.03771406f, 0.03228709f, 
    -0.04674508f, 0.03964069f, 0.04579809f, 0.04813384f, 0.01851098f, -0.01283251f, -0.00625421f, 0.03907089f, 
    0.02776760f, -0.01927617f, 0.02210273f, 0.02936928f, 0.01170972f, 0.00136574f, -0.00742582f, -0.04134988f, 
    -0.02673339f, -0.02118530f, -0.05029009f, 0.03473367f, 0.00632029f, 0.04293219f, -0.02438390f, -0.02550490f, 
    0.02314887f, -0.03091432f, -0.01328729f, 0.00375627f, 0.02197783f, -0.01456174f, -0.05339032f, 0.00313654f, 
    -0.01132699f, -0.01826802f, -0.01826894f, -0.04478250f, 0.02554848f, 0.03795921f, 0.02464651f, 0.03270602f, 
    -0.00053285f, -0.01323060f, 0.03856840f, 0.01451958f, 0.04121110f, -0.03307988f, -0.03515008f, 0.00483283f, 
    -0.00157796f, 0.00878697f, 0.00166025f, 0.04174443f, -0.04593334f, 0.03086230f, -0.05465655f, -0.02137967f, 
    0.00485240f, 0.01627828f, -0.04439753f, -0.03120376f, -0.02660237f, -0.02331780f, -0.03336993f, -0.04985129f, 
    -0.03825714f, 0.02012072f, 0.04165969f, -0.02970445f, -0.02979545f, -0.00781750f, 0.03401508f, -0.01385602f, 
    -0.03058999f, 0.02221665f, -0.03688459f, 0.02246376f, 0.00621347f, -0.00305909f, -0.03808151f, 0.03213847f, 
    -0.00591036f, 0.03694293f, -0.01826628f, -0.01642302f, -0.04196277f, 0.01319024f, -0.04221298f, -0.01856991f, 
    -0.00748470f, -0.04739925f, -0.05145334f, -0.02374065f, -0.04958858f, -0.04596046f, -0.02308128f, -0.03451465f, 
    0.00308319f, -0.04484423f, 0.00546251f, -0.00779597f, 0.02063278f, -0.00293431f, -0.00930637f, 0.00202337f, 
    -0.02008523f, -0.18469819f, -0.16964598f, 0.21012564f, 0.05783306f, -0.02450965f, 0.01888544f, 0.08120098f, 
    -0.11246412f, -0.04379733f, 0.05067360f, -0.03416365f, 0.23180094f, -0.08625664f, 0.28026325f, 0.11209450f, 
    -0.01419007f, -0.01911442f, -0.03169638f, 0.02730709f, 0.01265844f, 0.05758656f, 0.01134488f, -0.10662524f, 
    0.28984764f, 0.06959905f, -0.09269042f, -0.26446590f, 0.12000133f, -0.02104803f, 0.03549640f, -0.01499813f, 
    0.17603271f, 0.05481872f, 0.08063698f, -0.03266171f, -0.03899972f, -0.06796262f, -0.20488082f, -0.12111919f, 
    -0.02119758f, 0.03160932f, -0.07451966f, 0.00653244f, 0.06772664f, 0.05223410f, 0.12947164f, 0.02846625f, 
    -0.02319019f, 0.13723508f, -0.03801657f, 0.14025155f, -0.18013380f, -0.14531110f, -0.10105837f, 0.15790510f, 
    0.05827334f, -0.11106891f, 0.15122612f, 0.10986094f, 0.18901511f, 0.05955409f, 0.10444533f, 0.14161955f, 
    -0.01445167f, -0.03775069f, 0.02186733f, 0.04549835f, 0.02821748f, -0.08500925f, -0.08454693f, -0.06889766f, 
    0.20390508f, -0.07215238f, 0.45900232f, 0.03871123f, -0.06388378f, -0.17698751f, -0.00634799f, 0.17943150f, 
    0.02300102f, 0.17847359f, 0.11455186f, -0.02458858f, 0.03872332f, -0.06889883f, -0.08295210f, -0.01953948f, 
    -0.09714688f, 0.03591561f, 0.04992816f, -0.01735196f, -0.09727217f, -0.06571566f, 0.01168185f, -0.03513821f, 
    0.06746691f, -0.08789675f, 0.03199801f, -0.02929107f, -0.01994680f, 0.06486967f, -0.02153840f, 0.04182234f, 
    0.03745586f, 0.05208545f, 0.00924368f, -0.01665826f, -0.19046807f, 0.15157554f, -0.22377510f, 0.08067705f, 
    0.00649081f, 0.07358589f, 0.27156460f, -0.18088549f, 0.04625112f, -0.05496614f, -0.07326216f, -0.01240879f, 
    0.14814480f, -0.01585586f, -0.01418598f, -0.05630229f, -0.00643758f, -0.24864508f, 0.09469427f, -0.02042211f, 
    0.15283664f, 0.05206005f, -0.13672338f, -0.08715390f, -0.28656155f, -0.02455601f, -0.12824553f, -0.25629476f, 
    0.00156661f, -0.01094200f, 0.06348814f, -0.03674961f, -0.07965553f, -0.06944025f, -0.03039955f, -0.04262835f, 
    0.29694733f, 0.31808206f, 0.39140141f, -0.01060214f, -0.09359385f, -0.14842084f, -0.11277105f, -0.08124424f, 
    -0.06643182f, -0.02974666f, 0.13338751f, 0.08311642f, 0.11024500f, 0.01310677f, -0.06552792f, -0.00955741f, 
    0.06502401f, -0.13887291f, 0.00100305f, 0.00073849f, -0.02340382f, -0.08108247f, -0.10394298f, 0.00058687f, 
    0.06738816f, -0.18472874f, 0.09482624f, 0.12736291f, 0.05296766f, -0.12283841f, 0.09298833f, 0.02281253f, 
    0.12108187f, 0.00797496f, 0.07637787f, 0.06700571f, 0.26948419f, 0.19655906f, 0.48953027f, 0.09628812f, 
    0.07056618f, -0.05897048f, -0.03299662f, -0.04803143f, -0.08028935f, -0.01148201f, -0.00405851f, 0.02749731f, 
    -0.23953412f, 0.40050954f, -0.04936723f, -0.17773730f, -0.10535713f, -0.03837545f, 0.09939104f, 0.04288108f, 
    -0.07449269f, -0.01514158f, 0.08605615f, 0.04289705f, 0.32393190f, -0.30195549f, -0.05422650f, -0.08804817f, 
    0.13921858f, 0.17582297f, -0.05377463f, -0.10526323f, -0.03594358f, 0.12616251f, 0.13816683f, 0.05341184f, 
    -0.23404372f, -0.05075402f, 0.06722107f, -0.07081658f, -0.03013892f, -0.03295561f, -0.12542361f, -0.00317388f, 
    -0.13791235f, -0.11950747f, 0.01659408f, 0.02127905f, -0.17311087f, 0.08974966f, -0.25631994f, -0.06784140f, 
    -0.02530057f, -0.03173360f, 0.05788938f, 0.01411320f, 0.02855120f, -0.05061894f, -0.02197629f, -0.05205392f, 
    -0.26001036f, -0.16526030f, 0.00431706f, -0.12793407f, 0.02367821f, -0.03882275f, 0.07964264f, -0.03850283f, 
    -0.04656216f, -0.10443572f, 0.08427370f, 0.00985229f, 0.21232408f, 0.01993853f, 0.14978819f, -0.10418282f, 
    0.26276231f, -0.10472354f, -0.03452463f, 0.10281944f, 0.13256454f, 0.21687685f, -0.07415462f, 0.13169962f, 
    0.21483319f, -0.14422460f, 0.20326048f, 0.19054657f, 0.09508395f, 0.12450266f, -0.09729755f, -0.03210071f, 
    0.17622656f, 0.10494415f, 0.10674485f, -0.13556224f, -0.36475959f, -0.47989827f, -0.34980130f, 0.09147026f, 
    0.17971770f, 0.04637457f, 0.22126788f, 0.01793067f, -0.03830624f, -0.06466256f, -0.07182726f, 0.07975616f, 
    -0.33397064f, -0.36611369f, -0.49016467f, -0.38548148f, -0.00235710f, -0.07677943f, -0.19645202f, 0.00782622f, 
    -0.08422713f, -0.05200676f, -0.05391848f, -0.03744205f, 0.21346341f, -0.03558410f, -0.02344568f, -0.02211628f, 
    -0.03646582f, -0.04197980f, -0.00459554f, 0.08529713f, 0.06826568f, -0.17100957f, -0.04671843f, -0.01795667f, 
    0.08021513f, 0.04145938f, 0.25571516f, 0.04509015f, -0.03266542f, -0.08183834f, -0.05978303f, -0.03913198f, 
    0.04543339f, 0.14820820f, 0.26093039f, 0.14637432f, 0.06140128f, -0.22907774f, -0.16974117f, -0.09769041f, 
    -0.07083035f, -0.01246645f, 0.16205527f, -0.06956831f, -0.02488427f, 0.03806185f, 0.11205758f, 0.22551639f, 
    -0.17684589f, 0.38965032f, 0.00079652f, -0.09033951f, 0.06317570f, 0.00828130f, -0.11469569f, 0.03687707f, 
    0.11073297f, 0.03614965f, 0.17065929f, 0.13947895f, 0.19326077f, -0.07521701f, 0.05713703f, 0.02559902f, 
    0.02050324f, 0.06490905f, -0.06230767f, 0.01112720f, -0.00041484f, -0.04826690f, 0.03558967f, -0.08214811f, 
    -0.26733744f, -0.00784532f, -0.05438253f, -0.13393481f, -0.08734820f, 0.02872576f, 0.05092622f, 0.12011594f, 
    -0.09569479f, -0.06576570f, 0.10089780f, -0.02410384f, -0.11980532f, 0.17429417f, -0.14631277f, -0.08263815f, 
    -0.07853687f, 0.16379932f, 0.05812408f, 0.04283315f, 0.02308534f, -0.11556073f, -0.04912093f, -0.12318528f, 
    0.00355964f, -0.00894779f, 0.00425595f, 0.02439442f, 0.02045922f, 0.01191578f, 0.01466680f, 0.00083067f, 
    -0.01894430f, 0.00664883f, 0.00567337f, -0.05100779f, -0.04825956f, -0.02245679f, -0.05831470f, 0.03053225f, 
    0.02517128f, 0.02553341f, -0.02537897f, -0.01854182f, 0.02840195f, -0.00976191f, -0.01747127f, 0.03583825f, 
    0.00964488f, -0.05502835f, 0.00752493f, 0.03196258f, 0.03215544f, -0.04317230f, 0.00825646f, -0.01924891f, 
    -0.01086812f, 0.01189999f, 0.00877306f, 0.00772120f, -0.04261093f, 0.04253574f, 0.03869645f, 0.02280169f, 
    0.02209863f, -0.01252394f, 0.03841755f, -0.03904526f, 0.03174711f, -0.05729435f, -0.04144117f, -0.04947020f, 
    0.03984169f, -0.02190708f, -0.00962000f, 0.03487966f, 0.01741792f, -0.01580848f, 0.01519511f, -0.01388494f, 
    -0.04258680f, -0.00708771f, -0.01922536f, 0.00865011f, -0.03417604f, 0.01388468f, 0.02136925f, 0.04056419f, 
    0.04483386f, -0.04853227f, -0.03300311f, 0.00248544f, 0.03890928f, 0.02199119f, -0.02624375f, 0.02143093f, 
    -0.02407347f, 0.00418058f, 0.02003299f, -0.04872889f, 0.02073068f, -0.02335979f, -0.04341557f, 0.01857250f, 
    -0.02979303f, 0.01980669f, -0.02281474f, -0.02213465f, 0.04166770f, 0.01955424f, 0.00724673f, 0.02922030f, 
    0.00963467f, 0.00376868f, -0.05082905f, -0.00741149f, -0.02464147f, 0.02743226f, -0.04380418f, -0.05275601f, 
    -0.00507915f, 0.02263610f, 0.00794046f, -0.02715310f, -0.04814115f, -0.03291248f, -0.01741182f, -0.00472861f, 
    0.01406449f, 0.01207261f, -0.03353437f, 0.01303129f, -0.03918919f, -0.04198540f, 0.03640225f, -0.01145947f, 
    -0.01630091f, 0.01543747f, -0.03975801f, 0.02467736f, -0.05287849f, -0.03173461f, -0.05280582f, 0.03128550f, 
    -0.03074064f, 0.04149958f, 0.02996063f, 0.00635052f, 0.03392030f, -0.02412409f, 0.03114737f, -0.02733521f, 
    0.03218194f, -0.05601902f, 0.01006365f, 0.02796427f, -0.05302139f, -0.00045390f, -0.04448340f, -0.02075045f, 
    0.00399609f, -0.04339441f, -0.01274628f, -0.03320972f, 0.04224197f, 0.02261391f, 0.03128689f, -0.00309952f, 
    0.03089191f, -0.00837440f, -0.01944586f, -0.04140258f, -0.05255593f, 0.04254287f, -0.03284411f, 0.00737376f, 
    -0.03248901f, -0.00732175f, 0.01699039f, -0.03337613f, -0.02261164f, 0.01877842f, -0.03081323f, 0.02716683f, 
    0.00869988f, -0.01496780f, 0.00570808f, -0.05040364f, -0.03757809f, -0.04108005f, -0.02543837f, 0.00348165f, 
    -0.02767032f, 0.03549503f, -0.02672588f, -0.05717625f, 0.00683475f, 0.00202745f, -0.04266966f, -0.03328993f, 
    0.02110712f, -0.01032468f, 0.00861101f, 0.02278936f, 0.00628882f, -0.01947662f, -0.02871955f, -0.01248837f, 
    0.00741069f, -0.03538516f, 0.02866026f, 0.02741007f, -0.00182880f, 0.02200510f, 0.02843644f, -0.00987118f, 
    -0.01281540f, -0.05236608f, -0.02740146f, -0.02296459f, -0.03423872f, -0.05386890f, -0.00655764f, 0.03587665f, 
    0.02137846f, 0.03049125f, -0.01850793f, -0.02198001f, 0.01290181f, -0.00563887f, -0.02732214f, -0.00001198f, 
    -0.04496272f, -0.04139807f, 0.02803877f, -0.03581421f, -0.02449542f, 0.04538763f, 0.02140968f, -0.00134044f, 
    0.01817308f, -0.01398483f, 0.03351526f, -0.03856334f, 0.03282484f, -0.03171063f, -0.00089027f, -0.05307546f, 
    -0.03855855f, -0.00026637f, 0.00045871f, -0.03766384f, -0.05450888f, 0.02803310f, -0.04131376f, 0.04357524f, 
    -0.00002909f, -0.02271305f, -0.03012767f, 0.00631700f, -0.05056319f, 0.00773872f, -0.04493278f, -0.00964482f, 
    -0.00397589f, -0.04752856f, 0.01761579f, 0.01854011f, -0.04997537f, -0.05482696f, 0.01037168f, -0.03315442f, 
    -0.03412855f, -0.02433547f, -0.02968138f, -0.03408086f, -0.03565866f, -0.00271101f, -0.00660178f, -0.04517217f, 
    0.03222175f, 0.05372340f, 0.01383736f, 0.03294498f, -0.02520710f, -0.04548468f, 0.04233962f, 0.00663521f, 
    -0.00239366f, -0.03765931f, 0.03855122f, -0.00140940f, 0.01212191f, -0.04276541f, -0.00659143f, -0.03549758f, 
    -0.02494592f, -0.05314239f, 0.02712960f, 0.03112184f, 0.01410423f, 0.04251004f, -0.02016379f, -0.04954041f, 
    -0.01497123f, 0.01553028f, 0.03706291f, -0.02775490f, 0.01139759f, 0.00109255f, -0.02482623f, 0.01205871f, 
    0.02445972f, 0.03703821f, 0.02788096f, 0.02859524f, 0.00246507f, 0.01611236f, 0.00254874f, 0.03193122f, 
    -0.00355107f, 0.00765597f, 0.02711171f, -0.04321420f, -0.01413529f, 0.01507992f, -0.02004778f, 0.03317644f, 
    -0.04065302f, -0.03045648f, -0.00707377f, -0.05847168f, 0.04233648f, 0.01163736f, -0.04974462f, 0.03858549f, 
    -0.00439087f, -0.03575449f, -0.03629144f, 0.03009979f, 0.01654409f, 0.02881495f, -0.03116826f, -0.04655455f, 
    0.02027899f, 0.03798769f, 0.00586745f, -0.03783002f, 0.05582243f, -0.03793287f, -0.04155893f, 0.02413784f, 
    -0.03747224f, -0.01335707f, -0.00439498f, 0.00745424f, 0.01770370f, 0.05172765f, -0.05702792f, -0.04117144f, 
    -0.04581317f, -0.01027339f, -0.02174343f, -0.00975330f, -0.01536195f, -0.05306489f, -0.05616930f, -0.01860985f, 
    -0.05141178f, 0.00076600f, 0.01065676f, -0.02157988f, -0.03280549f, 0.00169389f, 0.00274766f, -0.04558741f, 
    0.02096809f, 0.01391407f, -0.00820889f, -0.02946313f, -0.04019459f, -0.03284315f, 0.03432915f, 0.04040578f, 
    -0.03708438f, 0.01175614f, -0.02704569f, 0.01480423f, -0.03175830f, -0.03926813f, -0.00830020f, -0.05029717f, 
    -0.02003935f, 0.03334115f, 0.00017587f, 0.00478421f, 0.00379072f, 0.02354236f, -0.03999720f, -0.00746462f, 
    -0.03028120f, -0.02217341f, 0.03848836f, 0.04274014f, -0.00943612f, 0.02159578f, 0.04917528f, 0.01031790f, 
    -0.29473603f, -0.43817982f, 0.17568952f, 0.23061928f, 0.01200656f, 0.13812622f, -0.04934719f, 0.06584210f, 
    -0.00873024f, -0.04197123f, -0.03882247f, 0.02752453f, -0.17641449f, -0.12303708f, -0.09088066f, 0.05360955f, 
    -0.02247146f, -0.10963229f, -0.07951431f, -0.08900157f, -0.03940234f, 0.12649971f, -0.14813748f, 0.06210342f, 
    -0.01931868f, 0.05858533f, -0.32263246f, 0.04872443f, 0.06783348f, 0.20335823f, 0.02272880f, 0.01116317f, 
    0.00213723f, 0.08911387f, -0.06209435f, -0.17203139f, 0.14064550f, 0.04503795f, 0.07639761f, 0.04081649f, 
    0.06514772f, -0.01450753f, -0.08649033f, 0.12587856f, 0.14469665f, -0.02881895f, 0.22535713f, 0.08425122f, 
    -0.04522900f, 0.12264049f, 0.12621209f, -0.00117546f, 0.07006464f, -0.18607391f, 0.08508557f, 0.27706212f, 
    0.03410851f, -0.05473465f, -0.07671070f, -0.07336523f, -0.01974021f, -0.21196717f, -0.09969561f, 0.00012884f, 
    0.10852771f, -0.09384403f, -0.09174354f, -0.13436782f, 0.01794473f, 0.01161878f, 0.00085683f, -0.00599334f, 
    0.42071328f, 0.14334106f, 0.16523486f, 0.13008142f, 0.08804463f, 0.14506428f, 0.18141694f, 0.11694679f, 
    0.14470705f, -0.08065549f, 0.06903239f, -0.01547165f, -0.32817975f, -0.15386063f, 0.28925657f, 0.02128985f, 
    -0.02078797f, 0.08958846f, -0.00738076f, 0.07491288f, -0.09956688f, 0.00357262f, -0.07306551f, 0.07471009f, 
    -0.31366697f, -0.07966313f, -0.16306032f, -0.14231223f, -0.08361875f, -0.03798262f, 0.01764938f, 0.08038095f, 
    -0.04205004f, -0.08999155f, -0.00469362f, 0.23644938f, -0.12221533f, -0.05343327f, -0.10097265f, 0.05907989f, 
    -0.02300538f, 0.01346831f, -0.01790903f, 0.01804600f, 0.11209601f, 0.03538734f, 0.01349546f, -0.13414922f, 
    0.36969292f, 0.30130091f, 0.29354998f, 0.06653962f, 0.10787129f, -0.07512079f, 0.02569450f, -0.07704955f, 
    0.05312896f, 0.04426658f, 0.13160992f, -0.00855879f, 0.22761525f, 0.37637469f, 0.07229533f, 0.38874564f, 
    0.10816931f, -0.01367921f, 0.00203629f, 0.19068195f, 0.03346639f, -0.04890779f, -0.04369427f, 0.00306532f, 
    0.27048022f, -0.02337560f, -0.00096638f, -0.06077718f, -0.00052144f, -0.05183948f, -0.01022400f, 0.05989881f, 
    0.04255142f, 0.01725025f, 0.05424363f, 0.07873353f, 0.06173577f, 0.09414113f, 0.12648788f, -0.00803279f, 
    -0.07593679f, 0.25801244f, -0.02457841f, -0.04385709f, 0.00033849f, -0.12763523f, -0.02831833f, 0.00270840f, 
    -0.18855807f, -0.12362567f, -0.11765985f, -0.17156276f, -0.04731804f, 0.01173617f, 0.01055370f, -0.09638980f, 
    0.03538859f, 0.00648191f, -0.01535464f, 0.12755126f, 0.15442067f, 0.18044773f, -0.02671506f, -0.01944082f, 
    -0.00111455f, -0.02470791f, -0.04261166f, -0.02822526f, 0.08797915f, 0.04059691f, 0.06558126f, 0.00755290f, 
    0.26832083f, 0.16683169f, 0.29994938f, 0.11741327f, 0.14748159f, 0.03237643f, 0.16949362f, 0.08504794f, 
    0.01973206f, -0.03022453f, -0.07304401f, -0.04217419f, 0.08187037f, -0.37756479f, 0.35364991f, 0.21542083f, 
    -0.05020187f, 0.14863294f, -0.08167997f, 0.00664804f, 0.17315257f, 0.07862680f, -0.05343915f, 0.02096713f, 
    -0.16701873f, 0.17029898f, -0.03070616f, -0.16068546f, 0.09461848f, 0.12849142f, -0.11358560f, 0.07128020f, 
    0.01847888f, 0.09511412f, -0.03269246f, -0.02979678f, -0.14989468f, 0.06361219f, -0.19977853f, 0.06588542f, 
    0.02185195f, 0.03650071f, 0.01062227f, -0.05011101f, 0.15731496f, -0.04935002f, 0.00465342f, -0.04227107f, 
    -0.09429727f, 0.13152108f, 0.31118095f, 0.19946624f, 0.02843992f, 0.05465678f, -0.08014191f, -0.02809997f, 
    -0.01075707f, -0.01433051f, -0.06878418f, 0.03461022f, 0.67757243f, -0.10162799f, 0.22044456f, 0.21020269f, 
    0.26696849f, 0.14108798f, 0.07133650f, 0.08699923f, 0.01881386f, 0.10077102f, 0.17645794f, 0.02102799f, 
    -0.03477879f, -0.12596488f, 0.12567076f, -0.04684864f, 0.08319195f, 0.01632506f, -0.24019489f, 0.04048728f, 
    0.20816129f, -0.01271609f, 0.00526947f, 0.06240798f, 0.26430246f, 0.39596486f, 0.36222929f, 0.32113084f, 
    0.07862423f, -0.02398826f, 0.13289680f, 0.00168939f, -0.02693568f, 0.03631684f, 0.06517042f, 0.05914478f, 
    0.23888083f, 0.41204128f, 0.49997655f, 0.30512923f, 0.11794814f, 0.09904443f, 0.08607161f, 0.13299744f, 
    0.00026544f, 0.10506994f, 0.04768284f, 0.00330872f, 0.11965745f, 0.05326593f, -0.01489192f, -0.03311202f, 
    0.06526983f, 0.07545146f, 0.05315588f, 0.04634988f, 0.03757753f, 0.02677469f, 0.06113990f, 0.02116154f, 
    -0.04752994f, -0.05920851f, 0.15417562f, -0.02967746f, -0.04368772f, -0.00617390f, -0.03508440f, 0.00434973f, 
    -0.04800506f, -0.10914695f, -0.18741478f, 0.00177830f, 0.06268831f, 0.15794753f, 0.21557549f, 0.03823142f, 
    -0.07710426f, -0.06392005f, 0.00519142f, 0.03891671f, -0.10135975f, 0.07117967f, 0.11726144f, -0.06186180f, 
    -0.04544450f, 0.18172196f, 0.05228410f, -0.11976112f, 0.02092137f, -0.00312293f, -0.06225048f, 0.13337858f, 
    0.04785421f, -0.09167470f, 0.07507068f, 0.11176852f, -0.01814618f, -0.16607113f, 0.07399163f, 0.01424936f, 
    0.10379124f, 0.01173960f, -0.16465490f, -0.01871092f, -0.08875658f, 0.03110120f, -0.09130199f, 0.00245569f, 
    0.25929350f, 0.38050386f, 0.10953595f, 0.19791286f, 0.01026637f, 0.13545184f, 0.21230750f, 0.18464820f, 
    0.08066469f, 0.08040751f, 0.14093384f, 0.13320492f, -0.39955455f, 0.11522985f, -0.02584622f, -0.21922311f, 
    -0.10542554f, 0.00795447f, -0.01604777f, 0.13036239f, 0.17805371f, -0.17242803f, 0.10300044f, 0.10633636f, 
    -0.09515264f, 0.05926862f, -0.23749988f, 0.15588148f, -0.20891951f, -0.15072900f, -0.02470024f, 0.00970839f, 
    -0.06515218f, 0.00083651f, 0.06268499f, -0.05797785f, -0.27908149f, 0.04351025f, -0.05896455f, 0.05367504f, 
    -0.04752903f, -0.04712320f, -0.08506928f, 0.09109464f, -0.05543809f, 0.05305309f, -0.04647831f, -0.03280369f, 
    0.13500115f, -0.02735755f, -0.04292328f, 0.00461028f, -0.03513850f, -0.03169135f, 0.06052100f, -0.13753358f, 
    0.01425965f, 0.05507478f, 0.02049479f, 0.08888539f, -0.00113834f, -0.19054881f, 0.25586337f, -0.27799368f, 
    0.03787949f, 0.04953004f, 0.07857110f, 0.05784029f, 0.09476798f, 0.03980010f, 0.14481388f, 0.07899497f, 
    -0.32113263f, 0.04515259f, 0.20156989f, 0.01689227f, 0.10090116f, -0.04700989f, -0.04918562f, -0.01810190f, 
    -0.10905543f, 0.10437535f, -0.11305065f, -0.11369520f, 0.16865635f, 0.00425312f, -0.01773131f, 0.01514983f, 
    -0.06145054f, -0.08716781f, 0.01374633f, -0.09915477f, 0.02616371f, 0.08996595f, -0.10752933f, -0.07399544f, 
    0.12083290f, 0.25014406f, 0.21354085f, -0.07096739f, -0.07896437f, 0.03616554f, 0.06271965f, 0.11984556f, 
    0.00957333f, -0.00536847f, -0.07954758f, -0.02638514f, -0.11343797f, 0.13884199f, -0.33178818f, -0.00668752f, 
    -0.12824284f, 0.00617732f, -0.01669297f, -0.02820064f, 0.02039715f, -0.02754889f, -0.05968071f, 0.05891011f, 
    -0.21778832f, 0.13675763f, -0.05448594f, 0.31043437f, 0.04049517f, -0.04673386f, 0.02760580f, -0.00583427f, 
    0.12255396f, 0.03323576f, -0.01599605f, -0.01137919f, 0.10439164f, -0.05235959f, -0.05961361f, 0.10679977f, 
    0.06631977f, 0.00722444f, 0.21413359f, -0.09674976f, 0.04967177f, 0.08959164f, 0.08443417f, 0.00600209f, 
    0.18279643f, -0.24880563f, 0.27264541f, -0.21715964f, -0.06981964f, 0.01854914f, 0.04292658f, 0.18984085f, 
    0.01283714f, -0.07000212f, -0.09765866f, 0.01020262f, 0.00778749f, -0.12893005f, 0.05810098f, -0.14547293f, 
    0.22616777f, -0.00863208f, -0.04639505f, -0.05148999f, 0.01974317f, 0.01545913f, 0.02083030f, 0.01192857f, 
    -0.05300021f, 0.17688909f, 0.04996414f, -0.19715248f, -0.08496516f, -0.12735166f, -0.04941095f, 0.00726529f, 
    -0.05578061f, -0.00437458f, 0.01491682f, -0.08850314f, 0.01006875f, 0.03701569f, -0.06421898f, 0.03115594f, 
    -0.02263164f, 0.04831857f, 0.11672967f, 0.00916438f, 0.00553649f, -0.14121334f, 0.02807527f, 0.09271671f, 
    0.25094682f, 0.17804453f, -0.02785265f, 0.14756882f, -0.02166265f, -0.01345627f, -0.07315409f, 0.03660748f, 
    0.00153193f, -0.00462696f, 0.12572126f, -0.04269827f, -0.32329831f, 0.07949489f, 0.06561822f, 0.02252930f, 
    -0.12788647f, -0.02047642f, -0.09804193f, 0.10143851f, -0.01184074f, -0.00160782f, 0.06082679f, -0.00990372f, 
    0.02095559f, 0.33140761f, -0.12585942f, 0.02236984f, -0.02130469f, 0.12549438f, 0.14486435f, -0.06949887f, 
    0.19469604f, 0.10256170f, -0.01327046f, 0.03569267f, -0.31435129f, -0.00436443f, -0.18855892f, 0.41287208f, 
    0.00787277f, 0.11241005f, 0.00294436f, 0.01742947f, 0.15412602f, 0.05323461f, 0.03115204f, 0.05633891f, 
    -0.59144247f, 0.05833227f, -0.21520631f, -0.04820193f, -0.01892608f, 0.25228530f, 0.10285209f, 0.00186501f, 
    -0.19806021f, -0.10002750f, -0.10067604f, 0.01065104f, 0.33187574f, -0.04522428f, 0.05606508f, 0.01833257f, 
    0.11316667f, 0.04682406f, 0.04052649f, -0.13426611f, -0.06704291f, -0.00354252f, -0.08681767f, 0.02260302f, 
    -0.19274139f, 0.00698224f, 0.22614168f, 0.06296462f, -0.06755538f, 0.09430111f, 0.04784546f, 0.00695225f, 
    -0.00211181f, 0.01589531f, -0.01443205f, -0.19422582f, 0.44226956f, 0.23080102f, 0.24243981f, 0.05006739f, 
    0.15589175f, 0.11498982f, 0.06090005f, 0.10272081f, 0.03791028f, 0.08574571f, -0.06909628f, 0.00750779f, 
    0.04834620f, -0.14768031f, 0.24245523f, 0.26341465f, -0.00828392f, -0.00133436f, -0.07189112f, 0.11505792f, 
    0.31751460f, 0.11825754f, 0.13028860f, 0.04718352f, -0.09358551f, -0.23765641f, -0.14093894f, -0.12600827f, 
    -0.05693613f, -0.01076052f, 0.02093131f, -0.14176629f, -0.05415763f, -0.09761469f, 0.01534191f, 0.06488348f, 
    -0.34332022f, -0.16168666f, -0.01853256f, -0.00250287f, -0.13642216f, -0.07091976f, -0.15098529f, -0.02229146f, 
    -0.04240067f, -0.01920707f, -0.00010567f, -0.02348021f, 0.09077331f, 0.03080105f, -0.07791087f, -0.01838335f, 
    -0.02050203f, -0.01483810f, -0.03635702f, 0.07450721f, -0.05770829f, -0.02020416f, 0.07651109f, -0.06131965f, 
    -0.08046678f, 0.24560037f, -0.03225604f, 0.03292277f, 0.01648814f, -0.01742073f, -0.08985635f, -0.09144218f, 
    0.08393726f, -0.23273319f, -0.04421469f, -0.00193525f, -0.07985876f, -0.02451758f, -0.00623898f, 0.26805454f, 
    -0.08073696f, 0.03344375f, -0.12746646f, -0.05207100f, 0.08284929f, 0.01664636f, 0.02584635f, 0.03652210f, 
    -0.07701109f, -0.05528018f, -0.06869685f, -0.01817561f, -0.00470287f, 0.01141621f, -0.00101382f, 0.09789318f, 
    -0.07508636f, -0.04735615f, 0.09715664f, 0.00203773f, -0.04541062f, -0.00183365f, -0.05792338f, -0.02363668f, 
    0.00519038f, 0.04877147f, 0.05005741f, -0.05732260f, -0.02923445f, -0.09043224f, 0.03853507f, -0.01900674f, 
    -0.17756082f, 0.12992093f, 0.15401268f, 0.09050880f, 0.08168629f, 0.10116103f, 0.19025463f, 0.08719579f, 
    -0.03058494f, -0.00970307f, 0.07859658f, -0.00329759f, -0.25844055f, 0.14725596f, -0.07223571f, -0.07236560f, 
    -0.03757105f, 0.03399720f, 0.05264751f, 0.04655218f, -0.04299627f, 0.10282001f, 0.04760080f, -0.06928626f, 
    0.00836112f, -0.04441339f, 0.03151838f, 0.00605834f, 0.03176000f, 0.00139173f, 0.01516190f, -0.03298673f, 
    0.00429552f, 0.02906513f, 0.02573978f, 0.00062892f, -0.01286088f, -0.04625648f, 0.01676410f, 0.01181305f, 
    0.02922008f, -0.03969376f, -0.05249318f, 0.03148105f, 0.03851321f, -0.02253424f, -0.01055114f, 0.01632870f, 
    0.03250071f, 0.03351879f, -0.05003080f, 0.01478432f, 0.02891637f, -0.01799975f, 0.02845328f, 0.02918949f, 
    -0.00364157f, -0.00368771f, -0.02055706f, 0.02372982f, -0.02087360f, 0.03644332f, -0.04521752f, 0.01276408f, 
    0.03295590f, -0.05721347f, -0.00664454f, -0.01665554f, -0.01201326f, -0.00478228f, -0.00129969f, -0.04957714f, 
    -0.03391788f, 0.03557606f, -0.02633779f, -0.05797311f, 0.00965112f, -0.01427093f, -0.01374920f, -0.01221729f, 
    -0.02435344f, -0.05529274f, -0.05686130f, -0.01560754f, 0.04215571f, -0.03606032f, 0.00398355f, -0.01977268f, 
    -0.02971653f, -0.02349877f, -0.02736236f, 0.03762989f, 0.02900801f, -0.00868883f, -0.05073408f, -0.00115161f, 
    0.01961840f, -0.04499168f, 0.04045556f, -0.01994411f, -0.02613880f, -0.05205696f, -0.01781941f, -0.02760766f, 
    -0.02602942f, -0.00629658f, 0.04280995f, 0.02034212f, 0.01766159f, 0.03688813f, 0.01002679f, -0.03273391f, 
    -0.04257244f, -0.05633538f, 0.04194797f, 0.02566274f, -0.05905095f, -0.03132942f, -0.00834344f, -0.03913284f, 
    0.01437695f, -0.03266460f, -0.03840410f, -0.00537599f, 0.00037293f, -0.01487729f, 0.01860891f, 0.03769517f, 
    0.00212590f, -0.04228623f, -0.04349330f, -0.05027574f, -0.05466139f, -0.02199683f, -0.00155459f, 0.00928959f, 
    -0.04372109f, -0.00732996f, -0.04578585f, -0.04688342f, 0.03391930f, -0.03868790f, 0.03362366f, 0.03597809f, 
    -0.04972007f, -0.02450940f, -0.05109801f, -0.03769619f, -0.03501576f, -0.00372684f, 0.04890127f, 0.02036411f, 
    0.00597921f, -0.04129944f, -0.02165207f, 0.03304661f, 0.04856152f, 0.01655535f, -0.04948256f, 0.03467892f, 
    -0.03391879f, 0.02175382f, -0.04378929f, 0.04129257f, -0.00411715f, -0.02503374f, 0.02994142f, -0.04827636f, 
    0.00779024f, -0.00481249f, 0.01755936f, 0.02974134f, 0.03394301f, -0.04979081f, -0.01461825f, 0.02962076f, 
    0.01656184f, 0.00379276f, -0.04357047f, 0.03635213f, -0.03341359f, -0.01550162f, 0.03955969f, -0.04629137f, 
    0.01600129f, -0.05119289f, -0.04925275f, 0.03265032f, -0.01595811f, -0.01916632f, 0.03835277f, -0.03991906f, 
    -0.01425586f, -0.00156207f, -0.00534973f, -0.05813249f, 0.00590283f, 0.00060553f, -0.03453325f, -0.01428386f, 
    0.03990329f, -0.05644181f, 0.02961879f, 0.01866109f, -0.05378539f, -0.00806826f, 0.01528803f, 0.02320758f, 
    0.03288782f, -0.00411611f, -0.00956175f, 0.01249295f, -0.04341177f, 0.01839778f, 0.04312528f, 0.04129697f, 
    -0.02135043f, 0.00434691f, -0.05312426f, 0.03338746f, -0.03598146f, -0.01998856f, 0.01906174f, -0.04495624f, 
    0.02321136f, 0.03227448f, -0.00005612f, 0.01001783f, -0.01993196f, 0.02394113f, -0.00216448f, 0.01988396f, 
    0.00844537f, -0.04176139f, -0.02713927f, 0.00776728f, -0.06168870f, -0.05211231f, -0.05392915f, -0.02261979f, 
    -0.00749410f, -0.00798557f, -0.05980557f, -0.01722416f, 0.02957953f, 0.00941472f, -0.02823802f, -0.02412313f, 
    -0.01412225f, -0.00764271f, -0.04512285f, -0.05133137f, 0.03045153f, -0.00610193f, -0.05065979f, 0.00403904f, 
    0.03223091f, -0.02030910f, -0.05416051f, -0.01861550f, 0.02688842f, 0.00493425f, 0.02034064f, 0.00131760f, 
    -0.00130820f, -0.01334708f, 0.03049841f, -0.01538040f, -0.05080008f, -0.02683656f, 0.02794591f, -0.01251113f, 
    0.04483078f, -0.05129962f, 0.00590539f, 0.03332457f, 0.03169719f, 0.02415804f, -0.03307407f, -0.04008913f, 
    0.00745333f, 0.01124482f, -0.02648898f, -0.05384672f, -0.02502533f, 0.00385975f, -0.02168394f, 0.02076251f, 
    -0.02699482f, -0.05644901f, 0.00905272f, 0.03999084f, 0.02167472f, 0.00975485f, 0.04247482f, 0.02656247f, 
    0.04037569f, -0.05194981f, -0.05532185f, -0.01748411f, -0.01717466f, -0.00798030f, -0.02861761f, 0.01729828f, 
    0.00631270f, 0.02797961f, 0.00490849f, 0.01591124f, -0.00072764f, 0.02377450f, -0.01302553f, 0.01709195f, 
    0.03851540f, -0.03577844f, 0.01737435f, 0.03149624f, -0.05094827f, -0.03881136f, -0.02938676f, -0.05470794f, 
    -0.00170385f, -0.01191098f, -0.03350084f, -0.03984036f, -0.03992780f, -0.05039000f, -0.04134516f, 0.01246475f, 
    0.02088504f, -0.03742877f, 0.04277196f, 0.04167958f, -0.03058239f, 0.00830712f, 0.03133579f, -0.02332544f, 
    0.01524382f, -0.03342824f, 0.03711063f, -0.02250738f, -0.03463792f, -0.05060553f, -0.03298123f, -0.00329723f, 
    -0.03579247f, -0.03616032f, -0.01915664f, -0.01548724f, -0.02579669f, 0.02168239f, -0.04515230f, 0.00032177f, 
    -0.01773694f, -0.01105147f, -0.02823376f, 0.04330315f, -0.00794918f, -0.05677456f, 0.03198998f, 0.00122269f, 
    -0.02415226f, 0.00185593f, -0.03971380f, 0.02584707f, -0.01675487f, 0.00584971f, 0.02792344f, 0.01646205f, 
    -0.02465346f, -0.03169946f, -0.04300726f, -0.01063296f, -0.02639035f, -0.03998753f, 0.03129297f, -0.05828739f, 
    0.00929037f, -0.05366988f, 0.00057436f, 0.03855144f, -0.01739727f, -0.03040069f, 0.01686535f, -0.01947959f, 
    -0.03513482f, -0.01664152f, 0.01362979f, -0.01219326f, -0.02058078f, -0.03720650f, -0.04794190f, -0.03924312f, 
    0.00480927f, 0.02978428f, 0.03843037f, -0.03510017f, -0.03399760f, -0.04533779f, 0.02027699f, 0.02759364f, 
    0.02152713f, -0.03052401f, -0.05540631f, -0.00904939f, 0.00317945f, -0.01295007f, -0.03866628f, -0.02732750f, 
    -0.02805386f, -0.01032892f, 0.01596048f, 0.04532891f, 0.01879599f, 0.00201707f, -0.04418327f, 0.00427843f, 
    -0.03589895f, 0.04213047f, -0.02849150f, -0.04294024f, 0.03212271f, -0.04064135f, 0.02980115f, -0.02250641f, 
    0.02358695f, -0.00290229f, -0.05212044f, -0.02841327f, 0.00842259f, -0.01309692f, -0.04822555f, -0.00328773f, 
    -0.04153461f, 0.03286363f, 0.00468010f, -0.03741687f, -0.00227367f, 0.02195118f, -0.04884076f, -0.03134716f, 
    -0.00309150f, 0.01134865f, -0.03995919f, -0.03651885f, -0.04556080f, -0.01010431f, -0.02519764f, 0.01495127f, 
    -0.05212604f, 0.03644875f, -0.05142636f, -0.05286120f, -0.05278032f, -0.03471434f, 0.00967611f, 0.01479885f, 
    -0.02976476f, -0.02919647f, -0.00447999f, -0.04173126f, -0.04054768f, 0.01419241f, -0.03935752f, -0.02117604f, 
    0.01066984f, -0.04405344f, -0.00109688f, -0.02663700f, 0.01847460f, -0.00727199f, -0.04932337f, 0.03002295f, 
    0.00852672f, 0.03368753f, 0.04392384f, -0.00265692f, -0.03963126f, 0.02809813f, 0.00568715f, -0.05100708f, 
    0.03076476f, -0.04512629f, -0.03119474f, -0.05511950f, -0.00748291f, 0.02305280f, -0.05127834f, -0.04051069f, 
    -0.04800835f, -0.04052907f, -0.00904881f, 0.01455363f, -0.02946248f, -0.03700420f, -0.05384873f, 0.00121450f, 
    -0.03880216f, -0.02124959f, -0.05605193f, -0.01507510f, -0.04511030f, 0.02821844f, -0.00801265f, -0.00312372f, 
    0.00792339f, 0.04011875f, -0.00543729f, -0.04518214f, -0.05118751f, 0.01838794f, -0.01032082f, -0.01949989f, 
    -0.01297673f, -0.03787225f, -0.02551922f, -0.03942307f, -0.01674229f, -0.00640716f, -0.01158911f, 0.01054529f, 
    -0.03463079f, 0.01440671f, 0.03788175f, 0.04242170f, -0.00350074f, -0.02392453f, -0.00121922f, -0.04023015f, 
    0.02596659f, 0.01432261f, 0.02612592f, 0.04945797f, -0.00725122f, -0.04690279f, -0.00201225f, 0.02544338f, 
    -0.01208303f, 0.02373917f, -0.04218949f, 0.02272378f, 0.01421274f, -0.01181582f, 0.04597448f, 0.00616072f, 
    -0.05012355f, 0.03239498f, 0.03325599f, 0.01783387f, -0.00153588f, 0.04354192f, -0.00159368f, -0.00098092f, 
    -0.04412441f, 0.02437790f, 0.04397620f, 0.02872264f, -0.00936180f, -0.02246819f, 0.01089996f, 0.03972831f, 
    -0.03209394f, 0.00759396f, -0.03226800f, -0.04817479f, -0.03261680f, 0.00210172f, -0.03382639f, -0.03831269f, 
    0.00308300f, 0.01571853f, -0.04368220f, 0.02256710f, 0.02474017f, -0.02710884f, -0.04410686f, 0.01883404f, 
    0.02716643f, 0.04302809f, 0.02145843f, 0.00035237f, -0.05020007f, -0.04063479f, -0.05337453f, -0.01946134f, 
    -0.04803646f, -0.05056020f, -0.03154763f, -0.01149963f, -0.03583553f, -0.05011607f, -0.01141297f, 0.03269782f, 
    0.00919597f, 0.04297609f, -0.04147583f, -0.03786547f, 0.04500647f, 0.03545392f, -0.04675816f, -0.03012397f, 
    0.01086766f, -0.05473132f, -0.03019958f, 0.01544173f, -0.02731512f, -0.01853265f, -0.03970202f, 0.03091387f, 
    0.00141495f, -0.03283062f, 0.00228573f, 0.01931813f, 0.00614967f, 0.01477815f, -0.05018868f, 0.02640181f, 
    0.03256042f, -0.03367262f, 0.00719973f, 0.03282755f, -0.03418360f, 0.03173783f, -0.01711426f, 0.01511164f, 
    0.02403562f, 0.00620627f, 0.03339543f, -0.00492889f, 0.03496464f, 0.02772174f, 0.03833744f, -0.00266367f, 
    0.01963877f, 0.03884221f, 0.02705084f, -0.01937648f, 0.01173565f, -0.00302488f, 0.04504107f, -0.04535156f, 
    -0.02750769f, 0.04484900f, -0.03792985f, 0.02160837f, -0.05431481f, -0.01041001f, 0.03537688f, 0.01510097f, 
    -0.02834852f, 0.01049699f, 0.00572180f, 0.02606111f, 0.03853957f, -0.04235317f, 0.01601836f, -0.05427094f, 
    0.03473371f, 0.01463544f, -0.03084786f, 0.01573927f, 0.03183691f, 0.00910933f, -0.05435316f, -0.01037485f, 
    -0.00965036f, 0.01392072f, 0.04460147f, -0.04172518f, 0.03172963f, -0.01418950f, 0.02316150f, -0.02005527f, 
    -0.04766543f, -0.04762232f, -0.02173534f, 0.02278874f, -0.03228908f, 0.03089547f, -0.04482313f, -0.04581448f, 
    0.01341983f, -0.05217901f, 0.04068126f, -0.00688897f, -0.04927712f, -0.04221039f, 0.02937088f, -0.00300035f, 
    -0.01427812f, -0.00579107f, -0.04662969f, -0.04006682f, 0.04399446f, 0.02578166f, -0.02869837f, -0.05519326f, 
    -0.00657716f, -0.00271822f, -0.03035667f, -0.01339475f, -0.04836006f, 0.00100421f, 0.01870957f, -0.05394175f, 
    -0.04090056f, 0.03056209f, 0.03204749f, -0.00146034f, 0.03461792f, -0.03922947f, -0.04729899f, 0.00605526f, 
    -0.00672983f, -0.02205161f, -0.01789089f, 0.04467211f, -0.03214515f, -0.02948602f, 0.03801146f, -0.01670570f, 
    0.03230122f, -0.02525135f, 0.00520966f, -0.04283511f, -0.02848749f, 0.00622741f, -0.01977157f, 0.02792668f, 
    -0.00573460f, -0.00440941f, -0.02763604f, -0.04792829f, 0.01690142f, -0.03907494f, -0.00888720f, 0.01607327f, 
    0.03460158f, -0.04892775f, -0.04055469f, -0.01848737f, 0.02186613f, -0.03194186f, -0.01009852f, 0.03665430f, 
    0.02603920f, 0.02602175f, -0.03464214f, -0.02165678f, 0.04169489f, 0.03003605f, 0.01095345f, 0.04116888f, 
    -0.00856915f, -0.00072317f, -0.01377396f, -0.01380715f, 0.00326824f, 0.03429008f, 0.04033409f, -0.00457184f, 
    -0.01368774f, -0.04321892f, 0.02420823f, 0.04389108f, 0.02148479f, 0.02352241f, 0.00960802f, 0.03535045f, 
    -0.04286991f, 0.04058420f, 0.04480312f, -0.02602841f, -0.00844962f, 0.01259628f, 0.04414724f, -0.04765155f, 
    -0.05069838f, -0.00811367f, 0.02278460f, 0.04426424f, -0.00325121f, -0.01908572f, -0.03741662f, -0.03319269f, 
    -0.03654629f, 0.00769626f, 0.00530881f, -0.03659475f, 0.01454050f, -0.05167252f, -0.04553028f, -0.04871728f, 
    0.18338208f, 0.17831631f, 0.05884601f, 0.08218122f, -0.19367863f, -0.16711694f, 0.06362594f, 0.06944538f, 
    -0.02274914f, 0.01240726f, 0.10732512f, -0.00363443f, 0.10405957f, 0.06522976f, 0.03733998f, 0.01923190f, 
    -0.05160188f, 0.02818405f, 0.01252173f, -0.04071813f, -0.10155138f, 0.04329672f, -0.00518469f, 0.02371207f, 
    -0.04755941f, -0.01040565f, -0.04013105f, -0.18092394f, 0.00803993f, 0.00509688f, 0.10317595f, 0.30696014f, 
    -0.07921558f, 0.26054919f, 0.10826536f, -0.00231167f, -0.03254379f, -0.05721208f, 0.13120979f, -0.01382848f, 
    0.05503652f, 0.22883122f, -0.00901526f, 0.10881852f, 0.05711049f, 0.02963574f, 0.04804478f, -0.05918305f, 
    -0.04891001f, 0.12540907f, 0.04956429f, -0.06386400f, -0.02212782f, -0.01564498f, -0.00090849f, 0.02854121f, 
    -0.25600374f, -0.02454901f, -0.11408094f, -0.14203010f, 0.19002877f, 0.09465003f, 0.12696092f, 0.08125161f, 
    0.01464248f, 0.01801628f, 0.05700958f, -0.03409602f, 0.05093870f, 0.07480592f, 0.00610777f, 0.10573038f, 
    0.27758116f, -0.20935339f, -0.13752414f, -0.10841632f, -0.09917658f, 0.10986322f, -0.05646537f, 0.13324900f, 
    0.09637069f, -0.15844283f, -0.02380567f, -0.05756515f, -0.19959635f, 0.20362888f, 0.19543095f, -0.07304510f, 
    -0.18003842f, -0.00224942f, -0.02626136f, -0.07577483f, 0.00809214f, -0.04623410f, 0.03154743f, 0.03091522f, 
    -0.02301599f, 0.07445772f, 0.15534645f, 0.01634629f, 0.00519217f, 0.11638397f, 0.03665404f, -0.03039359f, 
    0.01447884f, 0.16544177f, -0.05870108f, 0.05678285f, -0.02140128f, -0.01087776f, -0.00406621f, 0.22331977f, 
    0.02843701f, 0.03066493f, 0.13466898f, -0.20754001f, 0.13185543f, 0.12667356f, 0.03246493f, 0.03495483f, 
    0.22004393f, -0.13103384f, 0.29419684f, 0.11896825f, -0.18809383f, 0.11805707f, 0.23069483f, 0.02419492f, 
    0.03636159f, 0.00659388f, 0.04607344f, 0.15832612f, 0.14343993f, -0.08069199f, -0.08592873f, -0.07509338f, 
    0.12289200f, 0.05843642f, -0.05717023f, 0.00345189f, -0.03096289f, -0.00566918f, -0.02840577f, 0.01316890f, 
    0.38156241f, -0.24861085f, -0.19916877f, -0.09812212f, -0.05244034f, -0.07959458f, -0.01377390f, 0.08390957f, 
    -0.02422094f, 0.06492884f, 0.00134900f, -0.03384968f, 0.02118781f, 0.08917985f, -0.04441639f, 0.09735044f, 
    -0.06625551f, -0.02068593f, 0.01379840f, 0.04173296f, -0.03653385f, 0.00748010f, 0.10643066f, 0.14404924f, 
    -0.04293049f, 0.22033568f, 0.00277969f, 0.15198082f, -0.05637949f, -0.10721729f, 0.02193315f, -0.04567210f, 
    0.04165994f, 0.05317665f, 0.02539916f, 0.01481825f, 0.09165782f, 0.01116633f, -0.17294660f, -0.05280819f, 
    -0.04218168f, 0.09855806f, 0.05139013f, -0.01564109f, 0.01267516f, -0.01446910f, -0.06171726f, -0.06241461f, 
    0.01870568f, -0.19926773f, -0.15628378f, -0.01268594f, -0.07597548f, 0.10024069f, -0.01921748f, -0.11067387f, 
    0.05004379f, -0.12563418f, 0.04482235f, -0.05439507f, 0.29190460f, 0.16020353f, -0.12111557f, -0.00437406f, 
    -0.09576268f, 0.07381375f, -0.01182517f, 0.15345977f, 0.05646728f, -0.02389110f, -0.02235820f, -0.02603743f, 
    -0.25220829f, -0.01299088f, -0.09090080f, -0.11873363f, 0.04404190f, 0.21353191f, 0.05423081f, 0.01281951f, 
    -0.28338262f, -0.19511607f, 0.02177574f, 0.04490369f, -0.08279910f, 0.10191307f, 0.03441155f, -0.03667969f, 
    -0.17122790f, -0.21994369f, -0.02752084f, -0.08923333f, -0.11700770f, 0.08586796f, 0.06132028f, 0.04346339f, 
    0.16396828f, 0.08469158f, -0.10132397f, -0.17068030f, 0.04066652f, -0.06808902f, -0.08061703f, 0.00721877f, 
    -0.09517189f, -0.13500087f, -0.19183254f, -0.17694207f, 0.48504928f, -0.27020657f, -0.00289917f, 0.01529024f, 
    0.04519247f, -0.02902591f, 0.01702648f, 0.15953584f, 0.08687551f, 0.23015523f, -0.14344817f, -0.03018526f, 
    0.35910943f, -0.08872771f, 0.15832144f, 0.11630256f, -0.10548691f, 0.03529167f, -0.02691348f, 0.06922043f, 
    0.33397418f, 0.07076769f, 0.08208093f, 0.12090547f, 0.26385808f, 0.01104867f, -0.09354417f, 0.04451647f, 
    0.08338033f, -0.11151215f, 0.28398964f, 0.09914383f, -0.17222963f, 0.03582384f, 0.04166008f, 0.03457260f, 
    0.10587996f, 0.02162097f, 0.04050628f, -0.03270750f, 0.07964700f, 0.05269663f, -0.22615780f, 0.25737864f, 
    -0.05949499f, -0.04370526f, 0.00175964f, 0.04309159f, 0.03521167f, 0.04593027f, 0.04937413f, 0.04200361f, 
    0.05258984f, -0.00333251f, 0.00202578f, 0.12030528f, -0.17246033f, -0.00392785f, 0.08623652f, 0.01842862f, 
    0.16896079f, 0.04918440f, -0.03976873f, -0.09607750f, -0.04641254f, 0.05639385f, -0.08027542f, -0.09746618f, 
    -0.03420385f, -0.32928273f, -0.12933113f, -0.20721215f, -0.19073284f, 0.28798839f, -0.07031347f, 0.06444783f, 
    -0.04428382f, -0.04167725f, -0.01014938f, -0.13522898f, -0.01447353f, 0.00127100f, -0.16418305f, -0.03096314f, 
    -0.03752308f, -0.06373033f, -0.18066536f, -0.05198259f, -0.00110533f, 0.03055594f, -0.03178429f, 0.18655787f, 
    -0.22882627f, 0.04706633f, 0.15332381f, 0.02716884f, 0.12735407f, 0.10349543f, 0.02306104f, 0.02403123f, 
    -0.05783547f, 0.06044963f, 0.06191111f, -0.00707345f, -0.03014333f, 0.04116778f, 0.11240359f, 0.07667800f, 
    0.11178481f, 0.04689274f, -0.12199491f, -0.12331366f, 0.09196138f, 0.28055790f, 0.13696638f, 0.09246924f, 
    0.10613537f, -0.01696417f, -0.03335813f, -0.01409896f, -0.24809371f, 0.15201628f, 0.20393890f, -0.11918338f, 
    0.10310652f, 0.03839918f, 0.07231493f, -0.02978305f, 0.12258497f, 0.00953976f, 0.04123319f, -0.02773415f, 
    -0.02917142f, -0.02369823f, -0.05050101f, 0.02103539f, -0.04513556f, 0.01201291f, 0.03512899f, 0.02802950f, 
    -0.01914742f, -0.02157479f, -0.03605469f, -0.00600218f, 0.00689961f, -0.05231100f, -0.02462000f, -0.03432439f, 
    -0.04885004f, 0.02185003f, -0.04577119f, 0.03024088f, -0.03668233f, -0.01483515f, 0.00963436f, -0.05344723f, 
    0.01841551f, 0.02460379f, -0.04008324f, 0.03771717f, -0.00331657f, -0.04508584f, 0.03914085f, 0.02517032f, 
    -0.04754183f, 0.03806901f, -0.02432947f, 0.03908599f, 0.01910645f, -0.04449657f, -0.04551091f, -0.02062065f, 
    -0.03531497f, -0.05616467f, 0.01390217f, -0.04861987f, -0.00243949f, -0.00991928f, 0.03051176f, -0.05415577f, 
    -0.03523685f, 0.02220364f, -0.00019916f, -0.01608188f, -0.02740100f, 0.02515027f, -0.05723536f, -0.02837483f, 
    0.04078161f, -0.01940366f, 0.03620347f, -0.01292158f, -0.04562193f, 0.00743442f, -0.04095814f, -0.02182433f, 
    0.00808244f, 0.02957930f, -0.04102831f, -0.02091561f, 0.01186314f, -0.03773728f, 0.03501733f, 0.02972175f, 
    0.02655309f, -0.03811675f, 0.01121862f, 0.03224528f, -0.00772950f, -0.02737762f, 0.01419637f, -0.03249737f, 
    -0.04504796f, 0.03556839f, -0.05048478f, -0.03057812f, -0.02120315f, -0.00280595f, -0.00923986f, -0.02851253f, 
    0.03712594f, 0.03045443f, 0.01070335f, -0.01187664f, 0.02471770f, 0.02795965f, 0.01701226f, -0.03987271f, 
    -0.02664789f, -0.02461767f, 0.03539623f, 0.03740296f, 0.00390602f, 0.04218426f, 0.01832834f, -0.02300247f, 
    0.02905752f, 0.02634152f, 0.03825229f, -0.03424658f, -0.05163462f, -0.05506863f, -0.04019876f, 0.03861038f, 
    0.00097678f, -0.05522631f, 0.00045576f, 0.03403497f, -0.05129436f, 0.02888070f, -0.03317304f, -0.01004425f, 
    -0.05670372f, 0.00622123f, -0.00446932f, -0.01212059f, 0.02049560f, 0.00517543f, -0.03019363f, -0.01696725f, 
    0.03553561f, -0.02783159f, 0.01339116f, -0.02437664f, -0.02847386f, -0.04565911f, 0.03680382f, -0.01502007f, 
    -0.01846313f, 0.01344693f, 0.01400818f, -0.03125897f, -0.01663865f, -0.03479895f, -0.01571539f, -0.00755193f, 
    -0.05739522f, -0.01064612f, 0.04210756f, 0.03916251f, -0.02668903f, -0.00093677f, -0.05514726f, 0.04025764f, 
    -0.03856435f, 0.01822306f, -0.02282644f, -0.03143924f, -0.02508779f, -0.04899060f, -0.02768426f, 0.01932427f, 
    -0.03147924f, 0.01031349f, 0.03683516f, 0.00576515f, -0.03514243f, 0.03739176f, -0.02496472f, -0.01614501f, 
    -0.01511396f, -0.01862349f, 0.03642926f, 0.02735722f, -0.03255964f, -0.04336683f, -0.04825611f, 0.01716062f, 
    -0.04500946f, -0.05313624f, 0.04170865f, -0.05409570f, 0.00318190f, 0.00977722f, -0.05150684f, 0.03188874f, 
    -0.01679947f, -0.01146067f, 0.02054014f, 0.03842786f, -0.04544970f, -0.01748347f, -0.03367809f, -0.00601132f, 
    -0.00302662f, 0.01668665f, -0.00402801f, 0.03983467f, -0.01948376f, -0.00422924f, -0.02322153f, -0.03447613f, 
    -0.01993005f, 0.03102568f, -0.02509340f, -0.04818763f, -0.00730303f, 0.00875490f, -0.05526004f, -0.01851745f, 
    -0.02730849f, 0.04187766f, -0.03753724f, -0.05299655f, 0.01634197f, 0.04294262f, 0.00393305f, -0.03531170f, 
    0.00088303f, 0.01680695f, 0.00571218f, -0.03376315f, 0.04500976f, -0.02253048f, 0.02357231f, 0.03602058f, 
    0.01311947f, -0.04455847f, -0.04375836f, 0.00995360f, 0.01804803f, 0.02185279f, 0.00687759f, 0.01682972f, 
    -0.02483307f, 0.02686507f, 0.03475682f, -0.00633622f, 0.01331547f, 0.03329956f, -0.05113453f, -0.04259875f, 
    -0.02417533f, 0.00998705f, -0.01180720f, -0.02621089f, 0.02662567f, -0.00875814f, -0.00447199f, -0.02047121f, 
    -0.03336014f, -0.05291049f, -0.04333416f, 0.02893018f, 0.03131902f, -0.04198145f, -0.03441396f, 0.01867942f, 
    0.03430161f, 0.02730836f, 0.03411146f, -0.04149327f, -0.00348025f, -0.01041430f, -0.05662922f, 0.00277122f, 
    0.00765011f, 0.01380712f, 0.02206613f, 0.03782838f, -0.05239025f, -0.01388444f, -0.05556285f, 0.02510767f, 
    0.01425127f, 0.03121508f, -0.04188359f, -0.02206063f, -0.01554117f, -0.05607549f, 0.01627772f, 0.01435191f, 
    -0.04777070f, 0.01204662f, -0.02032202f, 0.00491518f, -0.01641606f, -0.00834012f, -0.00799931f, -0.04441343f, 
    0.02366206f, -0.03973309f, 0.01785178f, 0.04121925f, -0.01417766f, -0.02475366f, -0.00035873f, -0.03708851f, 
    -0.04951267f, -0.04340332f, -0.01864187f, 0.01355810f, 0.01051467f, 0.02703906f, -0.05356574f, -0.00270162f, 
    0.03698122f, 0.03491801f, -0.02684838f, -0.05403722f, 0.01165779f, 0.01585972f, 0.00269617f, -0.05134304f, 
    -0.05510539f, 0.02718181f, -0.02004603f, 0.01973011f, -0.04518052f, 0.00794932f, -0.03269864f, -0.01724122f, 
    0.01033975f, -0.00921086f, 0.03702599f, -0.02428844f, 0.00535351f, -0.05407988f, -0.03772249f, -0.02912496f, 
    -0.01085366f, -0.01137902f, -0.02591509f, 0.03968021f, 0.03091905f, -0.01025200f, -0.05593185f, -0.03432417f, 
    -0.00315265f, 0.01817832f, -0.03923974f, 0.03358421f, -0.03736508f, -0.01538606f, 0.04371299f, 0.03414213f, 
    0.01450010f, -0.03347400f, -0.00545326f, 0.02664574f, 0.01809896f, 0.00254442f, 0.03674977f, 0.00795974f, 
    0.03555427f, 0.03441669f, -0.02028529f, 0.01413442f, -0.00994037f, 0.03502217f, -0.01091037f, -0.00270240f, 
    0.03898655f, 0.01905137f, -0.04731909f, -0.00431537f, 0.00700639f, 0.03857254f, -0.02924401f, -0.04544038f, 
    -0.04749702f, -0.00859746f, 0.03993288f, -0.02567969f, -0.04953427f, -0.03835862f, -0.02796373f, -0.03700364f, 
    -0.04716272f, -0.05419925f, -0.00008760f, -0.02326281f, -0.02256316f, -0.05043952f, -0.02990890f, 0.03622151f, 
    0.02098389f, 0.03854696f, -0.00954065f, -0.03403274f, 0.04351475f, -0.00662376f, -0.05668730f, 0.04272320f, 
    0.01899179f, 0.01359567f, -0.03262226f, -0.04266483f, 0.03534797f, 0.04143891f, -0.01549472f, -0.05093595f, 
    0.02074226f, 0.01178969f, 0.02294226f, -0.04305450f, -0.03425879f, -0.01435516f, -0.04950652f, -0.05220441f, 
    -0.00812545f, 0.03698609f, -0.03043497f, -0.00620110f, 0.03467308f, 0.02105528f, -0.02841692f, 0.00518758f, 
    -0.01080803f, -0.04759898f, -0.04973781f, 0.03208941f, -0.00667210f, -0.05122138f, 0.02767336f, 0.02056307f, 
    -0.04091909f, -0.02346962f, -0.03040601f, -0.01637921f, 0.02566575f, -0.04008774f, -0.05798472f, 0.04593248f, 
    -0.01297965f, -0.03699094f, -0.02552635f, -0.00314004f, 0.02216845f, 0.03587952f, -0.05401572f, 0.00206099f, 
    0.02508193f, -0.02882244f, -0.04996394f, -0.03652012f, -0.01636333f, 0.00253695f, -0.02293264f, -0.04140618f, 
    0.03467096f, -0.04227166f, -0.00251461f, -0.01557493f, -0.04934169f, -0.01420310f, -0.03658109f, 0.04105866f, 
    0.02962494f, -0.01789882f, 0.03767533f, 0.04161300f, -0.05780778f, 0.01501571f, 0.01040378f, 0.00822565f, 
    0.02962071f, -0.02195881f, 0.02555426f, 0.03051773f, 0.02481772f, -0.05026933f, 0.00635041f, 0.02845647f, 
    0.00766967f, 0.04350537f, -0.02870082f, -0.01318941f, -0.05301509f, -0.01780038f, -0.03598149f, 0.02525690f, 
    -0.00633098f, -0.03548819f, -0.00072638f, 0.02686703f, -0.02707321f, -0.02339863f, 0.03486734f, -0.01661400f, 
    -0.01417508f, -0.01486835f, -0.02278385f, 0.01418812f, 0.04395560f, 0.01902540f, -0.02578233f, -0.01954215f, 
    0.04380668f, 0.01838419f, 0.04346947f, -0.01155578f, -0.02950641f, -0.04051901f, 0.04472068f, -0.02734731f, 
    0.03156487f, 0.01714951f, 0.04221703f, -0.04903120f, -0.05527697f, -0.01384806f, 0.00082823f, -0.00142770f, 
    -0.03481532f, 0.03690197f, -0.02379649f, -0.01892017f, -0.04224102f, 0.03686295f, -0.00394399f, 0.02003821f, 
    0.03168735f, 0.03752843f, -0.00943023f, 0.00528011f, 0.00157561f, 0.02848104f, 0.00763673f, 0.03139598f, 
    0.02927795f, 0.01862515f, 0.02867162f, -0.01376166f, -0.05680584f, -0.00451306f, 0.01197233f, -0.04016103f, 
    -0.02509244f, 0.03054461f, -0.03492716f, -0.00602705f, -0.03194254f, -0.01600557f, -0.04414884f, 0.01568904f, 
    0.03055339f, 0.00949460f, 0.04635630f, 0.00066093f, -0.02403183f, -0.02690456f, -0.05102635f, 0.01953487f, 
    -0.00585878f, 0.00603888f, 0.00696712f, 0.00252155f, 0.01362367f, -0.00149022f, 0.03520307f, -0.03932679f, 
    -0.02663913f, -0.02204350f, -0.03322610f, -0.01233229f, -0.04672501f, 0.00408130f, -0.02951023f, -0.03236841f, 
    -0.00851248f, -0.04748700f, 0.00434430f, 0.03952784f, 0.01047949f, 0.00889419f, -0.04510232f, -0.04507636f, 
    -0.02166211f, 0.02538046f, 0.03381029f, 0.00410856f, 0.04236421f, 0.03004361f, 0.02789709f, -0.02921270f, 
    0.02362474f, -0.03307714f, 0.00800808f, -0.00847662f, -0.01077868f, -0.05445530f, 0.04273978f, 0.01773625f, 
    0.00592630f, 0.01034982f, 0.02044239f, -0.05049339f, -0.01450069f, -0.05591322f, 0.00577959f, -0.05076357f, 
    0.03236544f, -0.03308334f, -0.05387423f, -0.01259059f, 0.03619577f, 0.00349699f, 0.03752027f, 0.00700266f, 
    -0.00250001f, 0.01384478f, -0.05450357f, -0.00230450f, -0.00939432f, 0.04323123f, 0.01567807f, 0.01521945f, 
    -0.03360027f, -0.01164638f, -0.04207855f, -0.00748092f, 0.02301181f, -0.01226593f, -0.03936989f, -0.01303262f, 
    -0.02699979f, 0.00242807f, -0.04142092f, -0.04467811f, -0.04653394f, 0.02393571f, 0.02337108f, 0.00137058f, 
    -0.02723455f, 0.00653770f, -0.02407364f, 0.01653586f, -0.04224706f, -0.02464897f, -0.03567636f, 0.01076998f, 
    0.03286415f, -0.01303937f, 0.03201133f, -0.04808677f, -0.05189983f, 0.03492616f, 0.04859146f, -0.01128306f, 
    -0.03962320f, 0.04318629f, -0.00768629f, -0.03383460f, -0.02724508f, -0.02425795f, 0.03536171f, -0.05028264f, 
    0.02901501f, 0.00580390f, -0.04009198f, 0.01380052f, 0.01502676f, -0.03129096f, -0.04098170f, -0.02623813f, 
    0.03766196f, -0.03741566f, -0.03034982f, 0.03983398f, -0.05067087f, 0.01945691f, 0.00774607f, -0.00559552f, 
    -0.02559324f, 0.02017560f, -0.04170445f, 0.04222915f, 0.00411647f, -0.04430284f, -0.04819976f, -0.00617104f, 
    0.02534425f, -0.01566533f, -0.00864878f, -0.01216797f, -0.04511851f, -0.02572834f, 0.02127989f, 0.02036688f, 
    0.01416587f, -0.01906560f, 0.00817522f, 0.03693720f, 0.02336469f, -0.04859939f, -0.01492099f, -0.05602217f, 
    -0.02185127f, -0.01124614f, -0.02739548f, -0.01689470f, -0.01583397f, 0.02662658f, 0.00426565f, -0.04713200f, 
    0.04006412f, 0.03150778f, 0.03217759f, 0.02298330f, -0.00591279f, 0.01510095f, 0.01754631f, 0.04502188f, 
    0.00259174f, 0.01036871f, 0.04225114f, -0.01951883f, 0.02269772f, 0.03394869f, -0.01501837f, -0.00645989f, 
    -0.04143431f, 0.01754986f, 0.00584842f, 0.01341654f, -0.01970967f, -0.05939652f, 0.01016005f, -0.03028441f, 
    -0.01938537f, 0.01775296f, -0.03608064f, 0.02067103f, 0.03559591f, -0.06063163f, -0.02646166f, -0.02615074f, 
    0.04111991f, -0.05694497f, -0.05425561f, -0.03430510f, -0.00650306f, 0.02081258f, 0.04207568f, 0.02687860f, 
    -0.05115920f, 0.04308525f, 0.01078660f, -0.00455607f, -0.00054012f, 0.01869967f, 0.00822493f, 0.00584348f, 
    -0.01546224f, 0.00317889f, 0.04084891f, -0.05733969f, -0.00609387f, 0.03978359f, -0.04457283f, -0.01709893f, 
    0.01046251f, 0.04450724f, 0.02383375f, -0.03107177f, -0.04625583f, -0.01087986f, 0.04294266f, 0.02001417f, 
    0.32142749f, 0.47780669f, 0.04154351f, -0.00985461f, -0.19968387f, -0.25082964f, 0.03815936f, 0.16807717f, 
    -0.10125981f, -0.07737473f, 0.05490460f, -0.00902951f, -0.09227163f, 0.20724304f, 0.02602981f, 0.15113199f, 
    0.01829522f, 0.01698486f, 0.05758429f, -0.06860922f, 0.03273388f, -0.04511070f, 0.01793548f, 0.01855468f, 
    0.02868081f, -0.24924272f, 0.11974224f, 0.23753610f, -0.16551118f, 0.07452239f, 0.04824436f, -0.02410126f, 
    -0.00483433f, 0.03991701f, -0.02493951f, 0.13861924f, 0.03386758f, -0.17318161f, 0.28483137f, -0.09136953f, 
    -0.06452309f, 0.10057902f, 0.10800086f, 0.00937226f, -0.01483648f, 0.07085100f, 0.05929554f, 0.11105800f, 
    0.13830437f, 0.11321775f, 0.10460388f, -0.24696232f, -0.11043662f, 0.11339407f, 0.07353162f, -0.16001509f, 
    0.07550327f, 0.05575713f, -0.04837516f, -0.06533715f, 0.27163297f, 0.10521941f, 0.05903221f, 0.08763966f, 
    -0.05342098f, -0.00524647f, -0.08023852f, -0.01799101f, -0.07737510f, -0.00252231f, -0.14545605f, -0.10411765f, 
    -0.09072831f, 0.00001265f, -0.19777656f, 0.01303907f, 0.03122092f, -0.00997390f, -0.03808510f, 0.04178603f, 
    -0.09694496f, 0.04786068f, 0.17438316f, 0.15926866f, 0.16518459f, 0.13717796f, 0.12531543f, 0.00070697f, 
    -0.10346236f, -0.06689709f, -0.04741657f, -0.06750914f, -0.04679909f, -0.07681748f, 0.01017662f, 0.00233308f, 
    -0.01116679f, 0.13455519f, 0.27661517f, 0.13593657f, -0.04691466f, 0.04855479f, -0.06715003f, 0.01020874f, 
    -0.00276399f, 0.06291062f, -0.08767893f, -0.05506541f, 0.02316471f, -0.06416976f, 0.09860299f, 0.02182490f, 
    0.03754481f, -0.13792655f, 0.18585464f, -0.04445783f, 0.05039509f, 0.00092553f, -0.07231908f, 0.00544514f, 
    0.12226494f, -0.15956110f, 0.11073755f, -0.06395519f, -0.16877081f, 0.10693552f, 0.09278590f, 0.00209469f, 
    -0.04231942f, -0.07197767f, -0.26881200f, -0.04894407f, 0.04071965f, -0.17300998f, -0.10077236f, -0.08475331f, 
    -0.06582523f, -0.00893500f, 0.02387061f, -0.03104146f, 0.00101242f, 0.05014819f, 0.01219608f, 0.00231111f, 
    0.08143313f, -0.04229326f, -0.23888771f, -0.14346308f, -0.02772841f, -0.03477821f, -0.00807355f, -0.04724447f, 
    -0.20648731f, -0.03573510f, -0.08197353f, -0.17110151f, 0.02570141f, 0.08297634f, -0.02923114f, -0.04176271f, 
    -0.06760421f, -0.14815731f, 0.02755172f, 0.06322134f, -0.06925078f, -0.14740999f, -0.14596581f, -0.12633060f, 
    0.23484562f, 0.51708490f, -0.09705990f, 0.31374744f, -0.08857961f, -0.05437628f, -0.06206620f, 0.09211411f, 
    0.00147286f, 0.07406732f, 0.11488406f, -0.01234891f, -0.16177428f, 0.09042333f, -0.10843305f, -0.04132940f, 
    -0.01671038f, 0.01044431f, -0.07906629f, 0.03433050f, -0.09793191f, -0.07972829f, -0.04929188f, -0.03769923f, 
    0.04428365f, -0.11961713f, 0.01969639f, 0.04315815f, -0.00082513f, -0.09307526f, 0.02653545f, -0.08439738f, 
    0.19619842f, 0.21625942f, 0.12427162f, 0.22614074f, -0.07621423f, 0.29572377f, -0.27396968f, 0.22719727f, 
    0.05059249f, 0.12239545f, 0.14522845f, -0.00174199f, 0.01066187f, -0.02676567f, 0.04814284f, 0.07216796f, 
    -0.20299543f, -0.03110611f, 0.03401811f, -0.11700992f, 0.09661902f, 0.08860131f, 0.04606802f, -0.01958145f, 
    -0.09511694f, -0.02334906f, -0.07386662f, 0.03733348f, 0.31376833f, -0.01326674f, 0.15512022f, -0.02227318f, 
    -0.28073257f, 0.02103123f, -0.02009077f, 0.07084852f, -0.12462262f, -0.01996971f, -0.13892607f, -0.03737704f, 
    0.27114740f, 0.10190771f, 0.06803089f, -0.07567604f, -0.04160542f, -0.08833871f, 0.11550399f, 0.02329609f, 
    0.01078961f, 0.00872117f, 0.09190421f, 0.05855763f, 0.02684379f, -0.12413117f, -0.15426216f, 0.00869866f, 
    -0.05535174f, -0.08109813f, -0.15072295f, -0.00171272f, -0.11416425f, 0.11671200f, -0.13499191f, -0.10580941f, 
    0.08623146f, 0.11614046f, -0.10816523f, 0.21510653f, 0.20285660f, -0.07569902f, 0.16896898f, 0.04617417f, 
    0.04033353f, 0.03567765f, 0.00833685f, 0.11982762f, 0.16041791f, -0.05856936f, -0.02209663f, 0.01512954f, 
    -0.00823211f, -0.03426310f, 0.00432344f, 0.11593155f, -0.07210200f, -0.05248831f, -0.04644447f, -0.04781947f, 
    0.09104937f, 0.05216229f, -0.05059193f, -0.13465700f, 0.03252502f, 0.02569302f, -0.06766510f, 0.08659635f, 
    -0.04680926f, -0.04188597f, -0.08002624f, -0.07872840f, 0.11856665f, 0.02787542f, -0.03083158f, -0.06936412f, 
    0.01217272f, -0.10742188f, -0.09986271f, 0.01172843f, -0.10861876f, -0.15603839f, -0.22488047f, -0.10650539f, 
    0.23685843f, 0.27017295f, -0.06057092f, 0.14882438f, -0.01420072f, 0.05485423f, 0.10930606f, 0.00863123f, 
    0.10112430f, -0.09896309f, 0.07818411f, 0.18316768f, 0.00583857f, 0.27473032f, 0.00761208f, 0.33270746f, 
    -0.15213539f, 0.10635771f, -0.04791039f, 0.04738192f, 0.06983819f, -0.05708276f, 0.08112060f, 0.08282104f, 
    -0.07031602f, -0.28248736f, -0.12595247f, 0.02961695f, -0.16786271f, 0.04196776f, -0.11671468f, 0.11756741f, 
    -0.00805308f, 0.09771424f, 0.11275815f, -0.02703965f, 0.00252616f, 0.10240386f, 0.03634672f, 0.10029018f, 
    -0.04159839f, -0.08997937f, 0.00384439f, -0.03238341f, 0.03587087f, -0.12535641f, 0.03089374f, 0.07958158f, 
    -0.03670420f, -0.10797543f, 0.02049172f, -0.03102500f, 0.11761831f, 0.02959108f, 0.06113743f, -0.04209791f, 
    -0.15255101f, -0.03754016f, 0.00098410f, -0.04498212f, -0.14802445f, -0.14098428f, 0.50628126f, 0.10993099f, 
    0.14328478f, 0.02294339f, 0.03177970f, 0.05550627f, -0.16589303f, 0.03294032f, -0.13219143f, 0.00114406f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14603680f, -0.01955954f, 0.08714031f, 0.24152207f, 0.03139757f, -0.08333056f, 0.03895513f, -0.05447834f, 
    0.00462714f, 0.16963321f, 0.09606727f, 0.09357496f, 0.04475309f, 0.09322697f, -0.08188266f, -0.03665020f, 
    0.03608831f, 0.07799943f, 0.06445271f, 0.05017329f, 0.19135579f, -0.05350342f, 0.16900106f, -0.03560980f, 
    0.11772163f, 0.22700436f, 0.02681504f, -0.02812918f, 0.06731589f, 0.03406396f, -0.03207339f, -0.04441356f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06560715f, -0.25292811f, -0.07735315f, 0.21020027f, 0.27814353f, 0.03075002f, 0.38029036f, 0.01167281f, 
    -0.30318815f, 0.13946404f, -0.38102540f, 0.06364832f, -0.03802539f, -0.14875700f, 0.57013768f, -0.05227762f, 
    0.04643811f, 0.14800379f, 0.13261718f, -0.13537383f, 0.11269867f, -0.10329758f, 0.18449047f, 0.15958314f, 
    -0.08598353f, 0.19157413f, 0.15910999f, 0.11412667f, 0.09662851f, 0.02701556f, -0.13143747f, 0.41509017f, 
    0.07261498f, -0.06012439f, 0.24216941f, 0.03895018f, -0.06383505f, 0.16547900f, 0.21184677f, -0.22936018f, 
    -0.37449241f, -0.02964568f, 0.32400158f, -0.23574829f, -0.08792388f, 0.25540856f, -0.38285288f, -0.26388302f, 
    -0.01314826f, 0.03966259f, -0.15167046f, 0.23307520f, 0.24547181f, -0.10761989f, -0.16482230f, 0.12403790f, 
    0.20436502f, -0.03994746f, -0.11364990f, 0.05341308f, -0.24397531f, 0.08660981f, -0.03838364f, -0.08675029f, 
    0.13097028f, -0.19886051f, -0.11366080f, -0.09202364f, -0.30691457f, 0.53092903f, -0.03960948f, 0.40516254f, 
    -0.01567299f, -0.49867380f, -0.16226169f, 0.08566916f, 0.09449304f, -0.28026402f, -0.14589150f, 0.24988376f, 
    -0.16535836f, 0.19164062f, -0.27338788f, 0.19589901f, 0.17703196f, 0.06214184f, 0.29921362f, -0.06644690f, 
    -0.05984902f, 0.13050570f, 0.08246569f, -0.15652706f, 0.38240537f, 0.11931994f, 0.08045667f, 0.12312678f, 
    0.04701378f, 0.04522772f, 0.40886921f, -0.01734530f, -0.25806648f, 0.08049954f, 0.06169423f, -0.06561702f, 
    0.33770296f, 0.07810811f, -0.05293906f, -0.21392125f, 0.14739814f, 0.27456591f, 0.09337823f, -0.15915038f, 
    0.01005508f, -0.00056839f, -0.30306870f, -0.28697023f, 0.05882298f, 0.04756172f, 0.32061934f, -0.12828419f, 
    0.21841808f, 0.22074792f, -0.02472224f, -0.05089463f, 0.23681141f, 0.10692369f, 0.02524723f, -0.09981506f, 
    0.36832279f, 0.04458213f, 0.01856082f, 0.37072441f, -0.05973858f, -0.19660403f, 0.05961328f, -0.17750555f, 
    -0.30008030f, 0.00153010f, 0.16522852f, 0.03258209f, 0.07922530f, -0.10165330f, 0.40992168f, -0.41544554f, 
    -0.03818103f, -0.00396283f, -0.02176670f, 0.20796250f, 0.28750488f, 0.11869876f, 0.30346945f, -0.09369896f, 
    0.06224202f, 0.10872844f, -0.01013100f, 0.01064894f, -0.10369515f, -0.00382203f, 0.02232512f, -0.42190477f, 
    0.16084757f, 0.01466916f, 0.34277892f, 0.14361566f, 0.10489471f, 0.30553675f, -0.13329121f, -0.00707091f, 
    -0.19680583f, -0.08171237f, 0.17765066f, -0.13509318f, -0.09569158f, -0.06295035f, -0.12737004f, -0.09154314f, 
    0.07820691f, -0.23547621f, 0.11005251f, 0.23607509f, -0.03794984f, 0.09480601f, 0.38408199f, -0.05554615f, 
    -0.01792638f, -0.01435061f, -0.00442965f, -0.15955336f, -0.00391265f, -0.00375667f, -0.12794192f, -0.07570270f, 
    0.05551051f, -0.08329098f, -0.18777251f, -0.17994429f, -0.29685476f, -0.33198050f, -0.13349232f, 0.02728212f, 
    0.10273722f, 0.17664933f, 0.07402279f, 0.10909083f, 0.15570869f, 0.12062539f, 0.13504100f, -0.03382163f, 
    0.01475517f, -0.16744548f, -0.03199435f, -0.41177371f, -0.02129005f, 0.00758921f, 0.19477694f, -0.11836641f, 
    0.12782598f, 0.17096460f, 0.13969888f, -0.06471115f, 0.40878657f, 0.04097307f, 0.17165504f, -0.11848021f, 
    -0.15593937f, -0.08874055f, -0.02707394f, -0.00404513f, -0.09541446f, -0.07688376f, -0.03700233f, -0.17064498f, 
    0.00265544f, 0.13203061f, 0.02275725f, -0.16415302f, 0.10310637f, -0.01233969f, -0.05454248f, -0.13194516f, 
    -0.16934724f, -0.08482624f, -0.17662504f, -0.15575291f, -0.03256952f, -0.12959050f, -0.03053271f, -0.10410290f, 
    -0.11457326f, 0.00176425f, -0.16179690f, -0.15215406f, -0.11046069f, 0.14802317f, -0.16408861f, 0.04299356f, 
    0.21444181f, -0.00635526f, 0.32825172f, 0.32765540f, -0.07897072f, -0.11569794f, -0.22576860f, -0.07592440f, 
    -0.23798485f, 0.05417930f, 0.22573641f, 0.04253219f, -0.01358644f, -0.17630869f, 0.17751358f, -0.53223008f, 
    0.17518388f, -0.21191275f, -0.18224527f, 0.34594914f, 0.13543224f, -0.06428704f, 0.46367222f, 0.00182121f, 
    0.13015094f, 0.04377761f, -0.08784923f, -0.03009760f, -0.16636871f, -0.00975493f, -0.09131960f, -0.07712582f, 
    -0.16143970f, -0.25885689f, -0.31838000f, 0.25347266f, 0.04697548f, -0.12758873f, -0.00584001f, 0.27007434f, 
    -0.01948535f, -0.03575274f, 0.03057044f, 0.26243684f, 0.11058498f, -0.27794781f, 0.55870956f, 0.21878354f, 
    -0.13767006f, 0.36261204f, 0.34832978f, 0.02144863f, -0.07472695f, -0.12776154f, -0.11943733f, -0.16247396f, 
    0.14123888f, -0.02387626f, -0.05314678f, -0.10324750f, 0.04675621f, -0.09356552f, -0.03981905f, 0.34613809f, 
    0.09379255f, -0.35717380f, 0.11728732f, 0.17549230f, -0.45428759f, 0.05371574f, 0.15219186f, 0.13343194f, 
    0.23115292f, -0.04552716f, 0.20749769f, -0.01737016f, -0.14799124f, -0.12945476f, -0.22140430f, 0.27893487f, 
    -0.09605622f, 0.48803711f, 0.03933423f, -0.06128363f, 0.26149777f, -0.07905381f, 0.03167275f, 0.06245209f, 
    -0.30541968f, 0.00129201f, -0.07065090f, 0.00740942f, -0.03564230f, 0.14132278f, 0.00854961f, -0.31965467f, 
    0.31942984f, 0.04053309f, 0.05165601f, 0.23347984f, -0.20480660f, -0.38310075f, -0.11413131f, -0.26276648f, 
    0.10783720f, 0.47531542f, 0.23285857f, -0.05891817f, -0.12589252f, 0.43545395f, -0.24574260f, 0.00560692f, 
    0.06937613f, 0.19609694f, 0.12758094f, 0.12616450f, 0.25471196f, -0.04800434f, -0.24386497f, -0.13599381f, 
    0.10160887f, 0.42271262f, -0.07700805f, 0.08735853f, -0.23155795f, -0.04503722f, -0.05748022f, -0.01070538f, 
    -0.15915203f, 0.27115414f, -0.16359481f, -0.05117637f, 0.14717841f, -0.05480896f, 0.27049524f, -0.18600707f, 
    0.08343597f, 0.29966769f, -0.22590144f, 0.13775156f, -0.05349179f, 0.08385333f, 0.17684242f, -0.26429445f, 
    -0.15043682f, 0.16475317f, -0.15913203f, -0.08264208f, -0.10546392f, -0.16540864f, 0.13572744f, 0.05364721f, 
    0.26648208f, 0.22551805f, -0.08799699f, -0.04572912f, 0.23785786f, -0.13552076f, 0.10827983f, 0.09929542f, 
    -0.11637259f, -0.09370162f, 0.02986593f, -0.08857915f, 0.26349035f, 0.55493981f, 0.15738320f, 0.12769756f, 
    -0.32097000f, -0.07040886f, 0.08734200f, -0.23720627f, 0.12121731f, 0.16416116f, 0.15049516f, 0.35818231f, 
    -0.01447372f, 0.05210151f, 0.19451909f, 0.16853265f, -0.07956679f, -0.10855171f, -0.46156529f, 0.09553377f, 
    0.20840827f, -0.26778668f, -0.06854299f, 0.00691586f, -0.24430212f, -0.11449933f, -0.11513047f, 0.29077297f, 
    -0.23207963f, 0.20739052f, -0.15710939f, 0.16354342f, 0.41835392f, 0.15800877f, 0.06356820f, 0.02917719f, 
    -0.33485615f, -0.01131368f, -0.25585774f, 0.13205773f, -0.07773602f, 0.18494205f, 0.38989222f, -0.12446602f, 
    0.07015955f, -0.15970999f, 0.19667928f, 0.00836355f, -0.08976491f, -0.02965989f, -0.09742452f, 0.18241149f, 
    0.28085536f, 0.16173171f, -0.09297903f, 0.13236783f, 0.30857414f, 0.13024847f, -0.11051253f, 0.18163037f, 
    0.32170728f, -0.19202600f, 0.33337244f, -0.04563623f, -0.29309380f, 0.18718265f, -0.05108109f, -0.04157576f, 
    -0.33811390f, 0.03222224f, -0.05403318f, -0.43093821f, -0.10202878f, 0.04572935f, 0.18832532f, -0.04155060f, 
    -0.13657837f, 0.34228614f, 0.24052528f, 0.25251636f, -0.01097202f, 0.15639147f, 0.11883838f, -0.09231867f, 
    -0.05618704f, 0.21724042f, 0.08279528f, 0.05786631f, -0.14000812f, 0.04712488f, -0.12786709f, 0.21604966f, 
    0.01535465f, -0.15853183f, 0.26665026f, -0.12517025f, 0.13360903f, 0.01026305f, 0.09263957f, 0.30793953f, 
    0.71547312f, 0.10398401f, 0.31566492f, 0.25467402f, 0.13431285f, -0.17551787f, -0.44540152f, 0.30920890f, 
    0.15790904f, -0.32585260f, -0.11258361f, 0.08909439f, -0.08850069f, -0.07897352f, -0.22028728f, -0.03941093f, 
    0.01581915f, -0.02373756f, 0.15883270f, -0.12668358f, -0.10439773f, -0.05698732f, -0.16988243f, 0.04272300f, 
    0.06077362f, 0.01611566f, 0.47287863f, 0.05035278f, 0.36096090f, 0.59867454f, 0.27470046f, -0.02708280f, 
    0.26220939f, -0.05242979f, -0.20089230f, -0.22954109f, -0.13923800f, 0.11355168f, -0.44993013f, -0.26331049f, 
    0.01487720f, -0.08327558f, -0.34884059f, 0.29850653f, -0.13588640f, -0.05473246f, 0.22120097f, -0.13353521f, 
    0.17146985f, -0.27727285f, 0.16736285f, 0.15342148f, -0.15927503f, 0.01853572f, -0.04659026f, -0.12015745f, 
    -0.08841909f, 0.12138281f, 0.02347986f, 0.09467620f, 0.33859605f, -0.00599502f, -0.04711202f, 0.00787026f, 
    0.25615972f, 0.38821280f, 0.24318346f, 0.34161350f, -0.13015302f, 0.31902814f, -0.18219407f, -0.06482789f, 
    0.05844897f, -0.39728513f, -0.00541167f, -0.14596982f, -0.14848039f, 0.02974870f, -0.34535268f, -0.15291050f, 
    0.12070582f, 0.10172226f, 0.10932164f, 0.17582275f, 0.06820522f, -0.07277814f, 0.05311717f, 0.22711733f, 
    0.06436904f, -0.20805496f, 0.46662271f, 0.00597758f, 0.05110787f, -0.10348947f, 0.46475208f, -0.27762267f, 
    0.50782752f, 0.18083844f, 0.31417990f, -0.14545162f, -0.13561556f, 0.17279698f, -0.28846404f, 0.25633037f, 
    0.00944538f, -0.03296525f, -0.21338774f, 0.10045306f, 0.01562412f, -0.01332290f, -0.21763641f, -0.09615114f, 
    -0.01984854f, -0.14066149f, -0.06019088f, 0.12283134f, -0.20973852f, 0.10904425f, -0.12828028f, -0.03174131f, 
    0.03920411f, 0.01611529f, -0.11363097f, -0.04471634f, 0.03905944f, 0.23487677f, -0.12669224f, 0.51970768f, 
    0.48319292f, -0.12911946f, 0.04721700f, 0.24469215f, -0.07230915f, -0.14995475f, -0.14013220f, 0.53424126f, 
    -0.15760948f, 0.14835267f, 0.29876906f, 0.10459398f, 0.01630221f, -0.15241985f, -0.46883336f, -0.15548517f, 
    0.16145690f, -0.23064834f, 0.11755250f, 0.06415274f, 0.22435406f, 0.13873439f, -0.01490001f, 0.02153182f, 
    -0.14581749f, -0.08432312f, -0.05078222f, 0.21534853f, -0.11522632f, 0.05395360f, 0.05845104f, 0.29216403f, 
    -0.09611923f, -0.07579932f, 0.27231899f, -0.16695246f, 0.08445183f, 0.10941479f, -0.24618371f, 0.35257879f, 
    0.13522753f, 0.19925182f, -0.05799217f, 0.04685650f, 0.29517910f, -0.12796293f, -0.09864134f, 0.13494527f, 
    -0.31404799f, 0.06593270f, -0.07519219f, -0.04711074f, 0.16949059f, 0.13367470f, -0.09278724f, 0.45146817f, 
    -0.09078331f, 0.10587721f, 0.07615554f, 0.11646777f, -0.05144214f, -0.44374999f, 0.35434136f, -0.03029253f, 
    0.37410703f, 0.29093760f, -0.05210040f, 0.20580819f, -0.16709945f, -0.11553246f, 0.22109403f, 0.07967541f, 
    0.13435574f, 0.33119628f, 0.20177919f, 0.14927225f, 0.21010904f, -0.05522498f, -0.28103134f, -0.12390818f, 
    -0.23492548f, -0.04349770f, 0.08950488f, -0.11529021f, -0.00932849f, 0.04581115f, -0.02794892f, 0.27422443f, 
    0.31355119f, -0.09709048f, 0.09955044f, 0.25307044f, -0.31640106f, -0.53524405f, -0.05314384f, 0.14578396f, 
    -0.03593484f, 0.40402716f, 0.17155518f, 0.30525130f, 0.12180366f, 0.11855587f, 0.09572943f, 0.11323699f, 
    0.12483063f, 0.30699384f, 0.29772800f, -0.21757501f, 0.02234120f, 0.02819042f, -0.36394039f, -0.04912383f, 
    0.07057034f, 0.28852040f, -0.05798232f, -0.00953583f, -0.04870119f, -0.12796727f, -0.09862462f, 0.20665109f, 
    -0.26412749f, -0.16505222f, -0.01268063f, -0.08458275f, 0.14673766f, -0.15002608f, 0.03949942f, -0.05818284f, 
    -0.03813517f, -0.10513269f, 0.06367087f, -0.12424638f, 0.11715236f, -0.18410391f, 0.09080999f, 0.13557994f, 
    -0.02933106f, 0.32618448f, 0.16900386f, -0.06966256f, -0.22094031f, -0.13819043f, 0.12998646f, 0.04534401f, 
    0.08193270f, -0.36956513f, 0.10319574f, -0.08935709f, 0.18316756f, -0.14692964f, 0.05561782f, -0.07764661f, 
    -0.02903100f, 0.12133545f, -0.19546475f, -0.17376523f, 0.01637605f, 0.39551964f, -0.33004388f, 0.31998727f, 
    0.17414524f, -0.22400309f, -0.14679389f, -0.04990162f, 0.15369673f, -0.53358006f, -0.08019532f, 0.37184915f, 
    0.04308031f, 0.23186608f, 0.02341191f, 0.33938789f, 0.20931935f, -0.10031672f, 0.14828670f, 0.07349743f, 
    -0.02653799f, -0.26379457f, -0.16899945f, -0.01429101f, 0.39013168f, -0.16162843f, 0.15774341f, -0.20746376f, 
    0.21840771f, -0.00902886f, 0.03997938f, 0.17865074f, -0.21916355f, -0.32900679f, -0.11947414f, 0.25412658f, 
    0.07449492f, -0.05259914f, -0.17648576f, 0.19926938f, 0.00106710f, -0.32739097f, 0.45636794f, -0.33313540f, 
    -0.00645039f, 0.05648418f, 0.29660228f, 0.22672437f, 0.15017807f, -0.14663494f, 0.08992086f, -0.08718383f, 
    0.07038740f, 0.07128800f, 0.05760009f, 0.11892977f, 0.13057423f, -0.07250581f, -0.17379577f, -0.24188225f, 
    0.13381007f, -0.15375319f, -0.00154717f, 0.05599928f, -0.22412199f, -0.25221214f, 0.27471089f, -0.13938276f, 
    0.41825292f, 0.19007155f, -0.21130556f, 0.20220505f, -0.10042097f, 0.01276625f, 0.47790277f, -0.11814301f, 
    -0.13119467f, 0.31563661f, 0.23457922f, -0.33423436f, -0.12400190f, 0.04289031f, 0.10409769f, -0.03934025f, 
    0.10646872f, 0.17926647f, -0.17613798f, 0.04089675f, 0.11573696f, -0.13474952f, -0.16891499f, 0.26512271f, 
    0.05720863f, -0.08853371f, 0.02705129f, 0.24740450f, 0.23598765f, 0.19900529f, -0.54107338f, 0.15613183f, 
    -0.27257293f, -0.07576500f, 0.35142344f, 0.06339684f, 0.17838614f, 0.13351659f, -0.36204198f, -0.27042142f, 
    -0.04770642f, -0.24202427f, 0.10820908f, 0.16946165f, 0.10140161f, -0.11312755f, -0.12771323f, -0.11181894f, 
    0.21744297f, 0.01245457f, 0.06617299f, -0.17002511f, 0.01131449f, -0.08449294f, -0.02632269f, -0.31733531f, 
    0.15514803f, 0.12372831f, 0.48730713f, 0.03278123f, 0.06214447f, -0.08930589f, 0.37331221f, -0.12433138f, 
    0.33233595f, 0.12734720f, 0.09951125f, -0.26084855f, 0.01102901f, 0.08184887f, -0.64344239f, -0.03906305f, 
    0.14631750f, -0.23188631f, -0.27637842f, -0.02077789f, 0.05975880f, 0.17264369f, 0.17848241f, 0.11028413f, 
    -0.21654947f, 0.28041866f, -0.08147059f, 0.17500508f, -0.23926999f, 0.09167105f, 0.12067224f, 0.08456220f, 
    0.08927783f, -0.08592514f, 0.19019417f, 0.24581136f, 0.14935778f, -0.14596319f, 0.10585882f, 0.33359730f, 
    0.16830938f, 0.13864657f, 0.33235654f, 0.18615955f, 0.06938668f, -0.31373063f, -0.24263850f, -0.12735483f, 
    0.09626663f, -0.55081934f, 0.05463821f, 0.32922515f, -0.04335391f, 0.01301467f, 0.04868538f, -0.10107537f, 
    -0.13273716f, 0.05753601f, 0.13431826f, 0.17842194f, -0.13136524f, 0.13292927f, 0.12855747f, -0.34206271f, 
    0.07902561f, 0.14957854f, 0.09209896f, 0.33121279f, 0.26636863f, 0.16664629f, -0.06934396f, 0.08532784f, 
    -0.78858101f, -0.27533522f, -0.20711343f, 0.14807713f, 0.02864360f, 0.04583824f, 0.51952869f, 0.00051116f, 
    0.01041432f, 0.05140734f, -0.07952531f, 0.14213215f, 0.16725948f, 0.15622179f, 0.02191211f, -0.16662128f, 
    0.09837397f, 0.04195051f, 0.06728757f, 0.14324376f, 0.11415157f, 0.05053372f, -0.10657410f, 0.33694220f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02213428f, -0.11533589f, 0.28460947f, -0.06995508f, 0.39009330f, -0.07034190f, 0.19250694f, 0.13899952f, 
    0.21844210f, -0.05939355f, -0.14645970f, 0.10686071f, 0.13965811f, 0.01071871f, 0.08953770f, 0.06064119f, 
    -0.12318379f, 0.05235765f, 0.21350065f, -0.22462972f, 0.09563298f, -0.02181725f, 0.10974190f, -0.03417899f, 
    0.07364362f, 0.05099384f, 0.03650819f, 0.17916048f, 0.04427695f, -0.09628791f, 0.05350801f, -0.02816555f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.35826546f, -0.22989397f, -0.64482337f, -0.29665756f, -0.39839870f, -0.15086670f, -0.48012048f, 0.04784062f, 
    -0.30844274f, 0.23568682f, -0.21083364f, -0.58186930f, 0.20906189f, 0.34837881f, 0.27160543f, -0.16027972f, 
    -0.35862744f, 0.02462102f, 0.05127052f, -0.41128588f, 0.06910218f, -0.21773766f, -0.03695837f, -0.31458029f, 
    0.18373686f, 0.14479326f, -0.22235657f, -0.06944797f, -0.09519120f, 0.00515093f, -0.28539881f, 0.23749517f, 
    0.40417042f, -0.42994285f, 0.25120211f, 0.02846669f, 0.17084867f, -0.23190747f, 0.03564016f, 0.07359650f, 
    0.07771949f, 0.25110844f, 0.03137540f, -0.08017636f, 0.20937993f, -0.26231605f, 0.18703409f, -0.10078921f, 
    -0.56945348f, -0.69200546f, 0.09527718f, -0.52812785f, -0.05991436f, 0.06086143f, -0.07392654f, 0.14700492f, 
    0.00673507f, 0.04818309f, 0.18362996f, 0.34577996f, -0.16282073f, -0.25779611f, -0.18951498f, 0.11286831f, 
    0.19444607f, 0.03425966f, -0.28413829f, -0.01882140f, 0.24205603f, -0.00861982f, -0.15660213f, 0.05467888f, 
    0.29392037f, -0.37330881f, -0.39439899f, -0.01643958f, 0.14634752f, -1.00066924f, 0.06440247f, -0.58145195f, 
    0.39121535f, 0.02019832f, 0.18737248f, 0.11478600f, -0.39165735f, -0.18472245f, 0.00609546f, 0.02718065f, 
    -0.18079118f, -0.07623976f, 0.06803548f, -0.12802488f, -0.23313986f, 0.30807701f, 0.41509953f, -0.13298425f, 
    -0.08467295f, -0.28836507f, -0.18278207f, 0.17382371f, -0.62074399f, -0.04540621f, 0.14234947f, -0.09029377f, 
    -0.20346315f, 0.10310665f, -0.40703994f, -0.27799207f, 0.04813341f, 0.03340677f, -0.16737986f, -0.22312818f, 
    0.51994693f, 0.18721573f, 0.24711531f, 0.30210099f, 0.20501041f, -0.34526178f, -0.04165177f, 0.01474265f, 
    0.09521937f, -0.11782568f, -0.25859961f, -0.00812033f, -0.08111732f, 0.07801297f, 0.02214479f, -0.43931338f, 
    -0.09598932f, 0.41684327f, 0.08654771f, 0.01879946f, -0.03175557f, -0.06388883f, -0.10250651f, 0.01196211f, 
    -0.06455307f, -0.03456548f, -0.24156615f, 0.01776164f, 0.17650837f, 0.24821335f, 0.03802570f, -0.71228969f, 
    -0.17478399f, 0.14136107f, 0.09951098f, 0.12643032f, 0.04149241f, 0.30867526f, -0.26166910f, -0.22084500f, 
    -0.05731477f, 0.25638840f, -0.54985887f, -0.57200074f, 0.16043866f, -0.27049032f, -0.10935538f, -0.00921049f, 
    -0.07536356f, -0.10276403f, 0.08564696f, -0.33406082f, 0.04561235f, 0.07849772f, -0.35176674f, -0.08952767f, 
    0.22953089f, 0.26872480f, -0.26832715f, 0.07295761f, -0.20674357f, -0.05930113f, -0.05387491f, 0.15617917f, 
    -0.03378812f, -0.28784966f, 0.14775452f, -0.39571828f, 0.24140196f, -0.22006659f, -0.14398411f, 0.25633389f, 
    -0.42151892f, 0.18910322f, 0.04579204f, -0.33244202f, 0.38966194f, -0.27307633f, 0.26287556f, 0.07480413f, 
    0.10068236f, 0.04022793f, -0.31327510f, 0.13711102f, 0.29541647f, -0.00048208f, 0.02363775f, -0.08863162f, 
    0.26638258f, -0.18672821f, -0.00171152f, 0.13777733f, 0.05055646f, -0.63139349f, -0.56870103f, 0.26728198f, 
    -0.42467964f, -0.02065030f, -0.63964158f, 0.06882420f, -0.65583867f, -0.55845445f, -0.12085426f, 0.16976675f, 
    -0.04041687f, -0.20709021f, 0.19701272f, 0.32935601f, -0.71827340f, 0.17414764f, 0.00119746f, -0.08446798f, 
    -0.13840888f, 0.03350004f, 0.35683411f, 0.07575358f, -0.23950475f, 0.07404798f, 0.19945261f, 0.11851607f, 
    0.01436941f, -0.17557442f, 0.09956949f, -0.41795349f, -0.45936024f, 0.01065448f, -0.22966050f, 0.13110985f, 
    0.37154937f, 0.20405939f, -0.36404818f, -0.01308425f, 0.18202886f, 0.03840689f, -0.23365924f, -0.20065695f, 
    -0.29931283f, 0.33047283f, 0.05159761f, -0.26818526f, 0.05505932f, 0.04319948f, 0.08926921f, -0.14137305f, 
    -0.12284742f, -0.36668307f, -0.05634169f, -0.19954784f, 0.14124681f, -0.40400854f, -0.12724468f, 0.10073525f, 
    -0.19190687f, 0.26530060f, 0.26268569f, -0.05138017f, -0.21235092f, -0.46315262f, -0.46386752f, -0.32122418f, 
    0.24246337f, -0.20014106f, -0.31764749f, 0.13985130f, 0.23424493f, -0.16080828f, 0.22672647f, 0.09564923f, 
    0.05125774f, 0.23793116f, 0.35859796f, 0.22873741f, -0.14088258f, -0.29717854f, 0.21484600f, -0.48614565f, 
    -0.03627969f, 0.23031482f, 0.03061795f, 0.19232281f, 0.23249114f, 0.29607531f, 0.28703699f, 0.11389197f, 
    0.33717987f, -0.18529472f, -0.05892293f, -0.24257542f, -0.18554059f, -0.14849582f, -0.05707609f, 0.08657094f, 
    -0.51975030f, 0.29259697f, -0.25360969f, -0.04471600f, -0.48176187f, -0.21346082f, -0.60229337f, -0.23487844f, 
    0.33511832f, -0.12474519f, -0.04252727f, -0.35495096f, 0.14685483f, -0.01382816f, -0.01768873f, 0.30807590f, 
    -0.51054907f, -0.13858458f, -0.50737631f, 0.29865119f, -0.35416824f, -0.37141001f, 0.58937579f, 0.04912630f, 
    -0.33700764f, -0.07401308f, -0.20600562f, 0.35084134f, 0.18454883f, -0.56642216f, -0.04203292f, -0.21323444f, 
    0.02375313f, -0.47315258f, 0.26823094f, -0.17976795f, 0.02274524f, -0.51616234f, -0.13969308f, 0.37554175f, 
    -0.56214511f, -0.53378886f, -0.01540461f, 0.35539338f, -0.00822420f, -0.08293249f, -0.26204798f, -0.67352968f, 
    0.22146988f, 0.20235859f, -0.36576951f, -0.16125076f, -0.07132477f, -0.22278304f, -0.06657851f, 0.11398584f, 
    -0.10311307f, 0.16390109f, 0.17849448f, 0.24144492f, -0.35100380f, 0.27942932f, -0.31507394f, 0.15139341f, 
    -0.08518410f, -0.49544790f, 0.00139708f, 0.29364064f, -0.14294954f, 0.33063018f, 0.25924128f, 0.26419923f, 
    -0.45036179f, -0.49841821f, -0.26689950f, 0.07941248f, -0.38629371f, 0.13299569f, -0.09014440f, 0.00720181f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.06401808f, -0.09975128f, 0.19348973f, 0.06180152f, -0.14660697f, 0.10320888f, -0.15461540f, 0.00457113f, 
    -0.18869013f, -0.11023368f, 0.13692082f, -0.12802881f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
