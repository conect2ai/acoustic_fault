#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62444240f, -1.00068712f, -0.37903905f, 0.16578321f, 0.40547860f, 0.17705156f, 0.02577646f, 0.42139664f, 
    0.28615239f, -0.49721664f, -0.29165325f, -0.18266621f, -0.41143018f, 0.26866037f, 0.04479190f, 0.26755241f, 
    0.00451565f, 0.05901683f, -0.10488918f, -0.07836780f, 0.27978927f, 0.22979935f, 0.22679166f, 0.10358182f, 
    -0.01081136f, 0.62516153f, -1.11379290f, -0.24193692f, -0.57066739f, 0.40827894f, 0.60873002f, -0.14672349f, 
    -0.27690545f, -0.24788532f, 0.31896645f, -0.27924347f, 0.45294994f, -0.12968127f, 0.47801691f, 0.16718140f, 
    -0.02619779f, -0.00789874f, 0.17841570f, 0.29456824f, -0.12078558f, 0.08301982f, 0.08650181f, -0.16695510f, 
    -0.07577896f, 0.06737677f, -0.24771719f, 0.72772759f, -0.36010325f, -0.03505185f, 0.03202339f, -0.14922106f, 
    -0.36095339f, -0.07536522f, 0.08197934f, 0.30762076f, -0.03755405f, -0.37874082f, -0.28338137f, -0.13176011f, 
    0.25135261f, 0.63430756f, 0.18359095f, -0.17334071f, -0.21445577f, 0.24014005f, -0.45583713f, 0.40820819f, 
    0.37548062f, -0.50965434f, 0.22441807f, -0.31055185f, 0.11541708f, 0.34006017f, 0.66271675f, 0.86040974f, 
    0.67147207f, 0.30293384f, 0.65879232f, -0.07846888f, 0.04653351f, -0.50391650f, 0.23987032f, 0.15917674f, 
    0.40965372f, 0.27132240f, 0.08535957f, 0.16527915f, 0.27168149f, 0.25144511f, 0.32268977f, -0.10006528f, 
    0.03769243f, -0.14941171f, 0.03811691f, 0.22335562f, 0.31180385f, 0.56613392f, -0.54701006f, -0.78187340f, 
    -0.67668152f, 0.72766954f, -0.02090183f, 0.19341098f, -0.38720226f, -0.23900981f, 0.46760032f, -0.00061029f, 
    0.09622726f, 0.40914395f, 0.35977563f, -0.16267021f, -0.17265320f, -0.03513582f, -0.38767692f, -0.10462943f, 
    0.26173091f, 0.41215593f, -0.04956845f, 0.14668851f, 0.17653430f, 0.36280340f, -0.24199226f, -0.81434995f, 
    -0.74902970f, 0.56281710f, -0.04647662f, -0.81025958f, 0.37488756f, 0.48352614f, 0.18686721f, -0.46136922f, 
    -0.21402131f, 0.02915219f, -0.30227780f, -0.36131462f, -0.03581334f, 0.13721466f, 0.20852469f, 0.20018829f, 
    -0.20913568f, 0.21593814f, -0.05435884f, 0.12399738f, -0.02196485f, -0.28876451f, 0.57966179f, -0.25054935f, 
    -0.76829875f, -0.10940553f, 0.25786749f, 0.80843890f, 0.01204610f, -0.58256537f, -0.09851082f, -0.42578441f, 
    -0.38246667f, 0.27196345f, -0.15920293f, 0.46631962f, -0.11663293f, 0.11933116f, -0.07385970f, -0.14724387f, 
    0.29535696f, 0.41165614f, -0.05443117f, 0.18771550f, -0.32615626f, 0.04436981f, 0.19408244f, 0.88919657f, 
    0.51778007f, 0.12727268f, 0.33770874f, 0.14415383f, -0.40736595f, -0.28023729f, 0.03577444f, 0.52132714f, 
    0.69445157f, 0.26043245f, -0.12620519f, 0.02358739f, -0.10006848f, -0.47368440f, -0.15591682f, 0.14398512f, 
    0.18479379f, -0.17607471f, 0.16641366f, 0.25047567f, 0.11896350f, 0.20139064f, 0.05666458f, 0.05441986f, 
    -0.10494671f, 0.05892121f, -0.54423219f, -0.21487460f, 0.78722358f, 0.35411105f, -0.39435306f, -0.66342348f, 
    0.21961278f, 0.23142372f, 0.22878696f, 0.21575586f, -0.06118039f, -0.48822379f, -0.26256120f, -0.37936917f, 
    -0.24027777f, -0.09139148f, -0.53425997f, -0.38102856f, 0.09801793f, -0.00350302f, -0.10484428f, 0.19940360f, 
    -0.12332447f, 0.32063398f, 0.68600512f, 0.74088925f, -0.30848753f, 0.64374942f, -0.12023868f, 0.30041087f, 
    0.32471353f, -0.18010704f, 0.45835769f, -0.31390706f, 0.36010334f, -0.13590130f, 0.25765345f, 0.16534814f, 
    0.30942798f, -0.02903514f, -0.17630884f, -0.16277549f, 0.37159097f, -0.33484992f, -0.01489472f, 0.40377676f, 
    0.12671140f, -0.32541648f, 1.05638552f, 0.78414118f, 0.04197719f, -0.09405182f, 0.70283896f, 0.32050648f, 
    0.07072125f, -0.25247559f, 0.46756583f, 0.04579981f, 0.52174056f, 0.41695699f, -0.14452177f, 0.06388384f, 
    -0.05800597f, -0.05144217f, -0.36753547f, 0.14193220f, 0.05229253f, 0.00464391f, -0.13619956f, 0.37219885f, 
    0.26042375f, 0.11984807f, 0.31136537f, -1.12806213f, 1.38395369f, 0.41078195f, -0.93199366f, 0.55440933f, 
    -0.14583686f, 0.18082041f, 0.03707396f, -0.25560787f, -0.78792393f, -0.16717656f, 0.11944935f, -0.01366839f, 
    0.06700241f, 0.03134653f, -0.09298460f, 0.09014693f, -0.09283623f, 0.03078865f, 0.14021723f, 0.15092792f, 
    -0.09623278f, 0.06568915f, 0.16927566f, 0.04222734f, 0.47381854f, -0.07178561f, 0.42766580f, 0.66016990f, 
    -0.73639309f, -0.42429954f, -0.24275905f, -0.01549436f, 0.46356389f, -0.23681118f, -0.46663818f, -0.24321476f, 
    0.08501369f, -0.56095523f, 0.20633622f, -0.70626158f, -0.33395955f, -0.48469564f, -0.18743402f, -0.19367069f, 
    0.15586556f, 0.07831770f, 0.10097944f, -0.34887800f, 0.11294720f, 0.49521160f, -0.30854174f, -0.21067366f, 
    0.87511861f, -0.00214616f, 0.30899322f, 0.66882646f, 0.01688903f, 0.03424742f, 0.09702825f, -0.48623088f, 
    -0.39817417f, -0.35136315f, -0.25452253f, 0.07181568f, 0.05237679f, 0.29706004f, -0.26583707f, -0.24911569f, 
    -0.40994042f, 0.09401052f, -0.12475421f, -0.46844119f, -0.21959588f, 0.29623443f, 0.58828616f, 0.16978268f, 
    0.83949536f, 0.01102353f, -0.35479775f, -0.16892876f, -0.58057535f, -0.09904196f, -0.18958427f, 0.39034605f, 
    -0.28709742f, -0.00224247f, -0.23664089f, 0.41678378f, 0.22692737f, 0.11391130f, 0.45812827f, 0.22512087f, 
    -0.16264324f, -0.03307552f, -0.41750789f, -0.04076687f, -0.08155198f, -0.03128467f, 0.19572857f, 0.08766995f, 
    0.31818128f, 0.71622014f, 0.23571523f, -0.33744714f, -0.80501026f, 0.63701183f, -0.36193115f, -0.55628067f, 
    -0.55792767f, -0.02953587f, 0.39618349f, 0.05628382f, 0.04040253f, 0.38776231f, 0.30658385f, 0.25958648f, 
    0.09901445f, 0.12360915f, -0.09482098f, -0.24849427f, -0.29804906f, 0.24915019f, 0.25734922f, 0.17797564f, 
    0.40768835f, -0.40234131f, 0.42089200f, -0.55747467f, 0.66087210f, 0.56400937f, -0.01108657f, 0.58833879f, 
    -0.11056837f, 0.17433317f, -0.39382109f, -0.07007423f, -0.22426361f, 0.12034617f, -0.22126344f, 0.09905507f, 
    -0.03303029f, 0.21710138f, -0.30871409f, -0.38601872f, -0.11644676f, 0.00455400f, -0.13214225f, -0.47474653f, 
    -0.26391727f, 0.94507784f, 0.38451982f, 0.00396589f, 0.56815910f, -0.33158517f, -0.33569315f, -0.67032379f, 
    0.43340504f, -0.62493598f, -0.34406000f, 0.14442343f, -0.10115153f, 0.02003847f, 0.53090852f, -0.23487374f, 
    -0.05228877f, 0.26012284f, 0.12372532f, 0.08840379f, -0.17648609f, 0.02114908f, -0.10513062f, 0.02511781f, 
    0.26064113f, 0.04098187f, -0.49531144f, -0.50969577f, -0.36318702f, -0.43606555f, -0.57011700f, -0.16461964f, 
    -0.01262751f, -0.19943301f, 0.62765706f, 0.27306470f, 0.28918520f, 0.25650764f, 0.14214718f, -0.06174850f, 
    -0.22177899f, 0.30150732f, -0.01671349f, 0.17117003f, 0.59026110f, 0.00845389f, 0.32755074f, -0.33889320f, 
    0.19772080f, 0.06493190f, -0.00092306f, -0.22939330f, 0.01934185f, -0.52853489f, -0.91579974f, -0.01146552f, 
    -0.14523810f, -0.25383759f, -0.06638866f, 0.24166057f, -0.01417276f, -0.48393148f, -0.49618581f, -0.42744353f, 
    0.15689832f, -0.51532447f, -0.19577767f, 0.39119402f, -0.15395601f, 0.20642573f, 0.44963834f, -0.07889619f, 
    0.27928764f, -0.10204237f, 0.15565184f, 0.25892225f, 0.42530036f, 0.36450952f, 0.48514754f, 0.48954791f, 
    -0.18897614f, 0.54431951f, 0.48591915f, -0.02305911f, -0.50825709f, -0.04525275f, 0.20291543f, 0.44187778f, 
    -0.38015261f, 0.03567154f, 0.36133590f, -0.07854232f, -0.21439590f, -0.05968402f, -0.12451082f, -0.32471913f, 
    0.13616845f, -0.24261095f, -0.10527991f, -0.17389250f, -0.02838045f, 0.70515710f, 0.17606236f, 0.42715093f, 
    0.59750289f, 0.51394701f, -0.36892879f, 0.02148223f, 0.15870419f, 0.62112457f, -0.16342042f, -0.43665785f, 
    -0.23419279f, -0.24839436f, -0.02589094f, -0.19909616f, 0.01320266f, -0.11931314f, 0.14461514f, 0.24418096f, 
    0.23573516f, 0.20977578f, -0.15531930f, 0.06225138f, 0.08794450f, -0.04019824f, -0.71615821f, 0.09529879f, 
    0.68470842f, 0.30480948f, -0.33478600f, -0.84587687f, -0.65579379f, -0.03701714f, 0.02927570f, 0.30661708f, 
    0.02998824f, 0.36650372f, -0.42072567f, -0.27060929f, 0.17986897f, 0.12235627f, 0.19727463f, -0.31862617f, 
    -0.11747099f, -0.02887242f, 0.02201301f, -0.13245051f, -0.05956285f, -0.12404712f, -0.19085152f, -1.07536387f, 
    0.17675380f, -0.61032689f, -0.78397143f, -0.31589240f, 0.44307983f, 0.85775411f, 0.15655307f, 0.56121916f, 
    0.67400193f, -0.20167379f, -0.19357492f, 0.05754674f, -0.25452071f, 0.03368059f, 0.29351756f, 0.08934251f, 
    0.16355528f, 0.21867803f, -0.45322800f, -0.00110737f, -0.11389104f, -0.14562504f, -0.00703569f, 0.28935775f, 
    -0.02664108f, -0.66081172f, 0.07469850f, 1.05896389f, 0.28367761f, -0.78076136f, 0.01999637f, -0.68275177f, 
    0.12549436f, -0.11413248f, 0.18768936f, -0.08502444f, -0.00906006f, -0.09592204f, -0.10470903f, -0.17305876f, 
    0.28564686f, 0.12249534f, 0.00267541f, -0.19553389f, -0.20449665f, 0.18758896f, -0.15553258f, 0.09014910f, 
    -0.02456540f, 0.21471959f, 0.54575467f, -0.43557069f, 0.15459333f, -0.60739571f, -0.23310450f, 0.05948734f, 
    -0.49694330f, 0.41506752f, -0.44042176f, -0.04286319f, -0.01536663f, -0.26841405f, 0.31838536f, 0.42426559f, 
    0.03729295f, -0.23653272f, 0.33499295f, -0.27819061f, -0.29936230f, 0.08166996f, 0.60878289f, -0.18773805f, 
    0.08465618f, -0.28045249f, 0.73377943f, 0.86524916f, 0.91736144f, 0.53739882f, 0.23659132f, -0.52831429f, 
    0.37213269f, -0.51060921f, -0.36857191f, 0.36606303f, 0.35369959f, 0.07813983f, -0.07388581f, 0.15039466f, 
    0.14458822f, 0.03351806f, 0.06245679f, 0.05624857f, 0.25976762f, -0.03955195f, 0.20699885f, 0.13427146f, 
    0.07013269f, 0.11363964f, 0.13238597f, 1.16005385f, 0.20518823f, 0.07379187f, 0.91338563f, 0.79322350f, 
    0.14780021f, 0.35237545f, -0.35389432f, 0.26324913f, 0.24638008f, -0.38913906f, 0.07240526f, -0.22934990f, 
    -0.25744948f, -0.22008234f, -0.08498169f, 0.04229791f, 0.04438922f, -0.01024448f, 0.01664088f, 0.22283748f, 
    -0.02262663f, 0.22187820f, -0.00907102f, 0.18029192f, 0.99115461f, 0.18440172f, -0.42619979f, -1.03713107f, 
    -0.48300448f, -0.08288060f, 0.41267911f, -0.05794356f, -0.29882419f, -0.48349711f, -0.18168172f, 0.23740275f, 
    0.38980329f, 0.25253162f, -0.14771247f, 0.09719744f, 0.10878494f, 0.19552350f, 0.08108550f, -0.12130044f, 
    0.10387436f, 0.03790595f, -0.00465739f, -0.13706337f, 0.30845222f, -0.38102856f, -0.18351875f, 0.15541014f, 
    -0.34671736f, -0.56746095f, -0.45994624f, 0.11849657f, 0.09763979f, -0.56052828f, 0.26868871f, 0.50056511f, 
    0.29242805f, 0.15158004f, -0.24933559f, -0.25814489f, -0.44902921f, -0.39760903f, -0.16300365f, 0.03001175f, 
    0.37092379f, 0.25311086f, 0.48158568f, 0.20883492f, 0.28697598f, -0.09779022f, 0.85741359f, 0.09655838f, 
    -0.48778367f, -0.51106536f, -0.07492189f, -0.19571161f, -0.37980580f, 0.02158583f, 0.09466700f, 0.26065695f, 
    -0.36800942f, 0.14884447f, -0.01407520f, -0.20629489f, -0.40864453f, 0.28788370f, 0.00094969f, 0.09817611f, 
    0.19160278f, 0.54419750f, -0.38082778f, -0.03543811f, -0.31905413f, -0.19978331f, 0.25463578f, -0.66413850f, 
    -0.38776481f, -0.30178976f, -0.40355933f, -0.22559780f, -0.71267873f, -0.02591864f, 0.82777494f, 0.30531630f, 
    -0.08533366f, -0.02084523f, 0.17783606f, 0.48623732f, -0.17410134f, -0.32504013f, 0.23107603f, -0.10299119f, 
    0.04353964f, -0.07753462f, -0.09701515f, -0.12960939f, -0.38165432f, 0.08271033f, -0.32221967f, -0.20055729f, 
    -0.36073941f, 0.74170387f, -0.49755475f, -0.65846050f, -0.57905561f, 0.95222372f, -0.58050978f, -0.68032932f, 
    0.01795411f, 0.04395467f, 0.11228095f, -0.12021542f, 0.42665327f, 0.18791236f, -0.16261865f, 0.17966294f, 
    0.02051680f, 0.11748853f, -0.04467463f, 0.33379209f, -0.18420959f, -0.25712091f, 0.36000586f, 0.14671466f, 
    -0.30922857f, 0.82425112f, -0.35753179f, -0.11577346f, -0.43426126f, 0.67457050f, 0.30249688f, -0.45898440f, 
    0.33821958f, 0.51405025f, 0.00032633f, -0.39925578f, 0.21695042f, 0.01063540f, -0.17290582f, -0.16682771f, 
    0.40961108f, -0.03933325f, 0.07472109f, -0.43664318f, -0.01391612f, -0.04181618f, -0.09155221f, -0.00691789f, 
    0.39080083f, 0.01248368f, -0.43797064f, -1.09247410f, -0.71349728f, -0.16106418f, -0.17247367f, -0.64847112f, 
    0.38881931f, 0.66369534f, -0.62437856f, 0.06800970f, 0.35747546f, 0.00911546f, -0.06128117f, -0.26203379f, 
    0.29159337f, -0.26557618f, 0.05031848f, -0.05063995f, -0.26449642f, -0.24315578f, -0.15988743f, -0.32746005f, 
    -0.02741351f, 0.07442939f, 0.09739529f, 0.55051684f, 0.41429946f, -0.45518705f, 0.21824567f, 0.95294690f, 
    0.29981041f, 0.38714197f, 0.50146437f, 0.05847307f, -0.39090922f, -0.34500709f, -0.44486475f, 0.29080555f, 
    0.22308029f, 0.42695898f, -0.00785070f, -0.18494973f, 0.09509594f, -0.10695089f, 0.02108818f, 0.43215671f, 
    -0.19600491f, 0.22211254f, 0.19713053f, 0.03604733f, 0.61255121f, -0.32219827f, 0.21258268f, -0.22064556f, 
    0.39389059f, 0.12304003f, 0.21434373f, -0.64139169f, -0.41465941f, -0.55143815f, -0.07670648f, 0.21288538f, 
    0.03057303f, -0.00459904f, 0.17356253f, -0.10014705f, 0.27685669f, -0.53526384f, -0.10076413f, -0.12977427f, 
    -0.38590226f, 0.45704788f, 0.38257599f, 0.00167841f, -0.49658629f, 0.74580097f, -0.16767147f, -0.68215048f, 
    0.11421198f, 0.34120825f, 0.21865940f, 0.25770614f, -0.23407072f, 0.49721694f, 0.45631358f, 0.16461013f, 
    0.34683236f, -0.22088391f, -0.04376807f, 0.14889328f, -0.12294993f, -0.47739831f, -0.33312103f, -0.06875291f, 
    -0.24906747f, 0.20632221f, 0.27299500f, 0.36271819f, 0.12954792f, -0.13613541f, 0.13757636f, 0.75502104f, 
    0.67791259f, 0.48358738f, 0.41557342f, 0.79686159f, 0.05762376f, -0.68772346f, 0.33925390f, -0.45972544f, 
    0.00152444f, 0.10821862f, -0.33759657f, 0.23863021f, -0.24187720f, -0.02668229f, -0.07825998f, 0.00958116f, 
    -0.14147417f, 0.01090876f, 0.11923950f, 0.04745964f, 0.05735233f, 0.08817890f, 0.23348311f, -0.54837829f, 
    -0.91159177f, -0.66577876f, -0.07296253f, 0.14188927f, 0.19724712f, -0.39274788f, -0.06880563f, -0.39245996f, 
    0.37047076f, 0.29487911f, -0.24102770f, 0.18049905f, 0.13036856f, 0.16924632f, 0.04593625f, 0.38710508f, 
    0.22649811f, 0.32112637f, -0.14053926f, -0.05314687f, -0.49848959f, -0.15999328f, 0.07572548f, -0.08719812f, 
    0.14395162f, 0.65990120f, -0.57719868f, 0.69402665f, -0.40066996f, 0.62976819f, -0.19321159f, 0.11770399f, 
    0.07713142f, 0.47994626f, -0.04218791f, -0.11616065f, -0.33848986f, 0.06514177f, -0.32001773f, 0.01189857f, 
    -0.23346956f, 0.02513328f, -0.19998385f, -0.09325938f, -0.27912977f, -0.23217238f, -0.42321590f, -0.24596290f, 
    -0.33519191f, -0.47034779f, -0.51595777f, -0.61795056f, -0.19863488f, 0.05371173f, -0.13745432f, 0.80691284f, 
    0.52793515f, -0.01266544f, 0.58787924f, -0.18199368f, -0.20015059f, -0.22377796f, 0.11713929f, 0.27506730f, 
    0.21209519f, -0.09899292f, -0.08158744f, 0.36780083f, 0.20814842f, -0.08628528f, 0.18255463f, 0.20015647f, 
    -0.50485903f, -0.20200485f, -0.62492663f, 0.08451814f, -0.63833749f, 0.49003002f, 0.75404412f, 0.26576987f, 
    0.15959597f, 0.36824191f, 0.16576508f, -0.25141197f, 0.03775173f, -0.11601525f, -0.25398082f, 0.01033754f, 
    0.13260731f, -0.20617193f, -0.06680222f, 0.01189615f, 0.32576740f, 0.04980519f, -0.08601189f, 0.25073457f, 
    0.10027849f, 0.35325313f, -0.50465626f, 0.36168572f, 0.12040271f, 0.03844881f, -0.82371831f, -0.58761853f, 
    0.24405685f, 0.32968223f, 0.50710100f, 0.49810496f, 0.29188782f, -0.40453643f, 0.34924653f, -0.28778315f, 
    -0.02220495f, -0.16019839f, 0.24970491f, 0.15236840f, -0.51835710f, 0.17197096f, 0.19475766f, -0.37113824f, 
    -0.26273137f, -0.04369933f, -0.24235807f, -0.30747932f, 1.10250914f, 0.22374357f, -0.08439606f, 0.94399577f, 
    0.96014464f, 0.62827450f, -0.19441678f, -0.41768518f, 0.35011640f, 0.04945507f, -0.11314077f, 0.13722214f, 
    -0.05996421f, 0.15517366f, -0.02923074f, 0.07236903f, -0.05779856f, 0.06146903f, -0.06169227f, -0.03815380f, 
    0.21641944f, 0.05790009f, 0.05372074f, -0.30487844f, 0.06564276f, -0.89184564f, -0.16882847f, -0.07345826f, 
    0.25113636f, 0.65805274f, -0.71572506f, 0.31642094f, -0.32935131f, -0.90124547f, -0.49361238f, 0.12467915f, 
    0.10500909f, 0.30866632f, 0.19283313f, 0.26481369f, -0.01652764f, -0.28503907f, 0.18617088f, -0.18171044f, 
    -0.40776262f, -0.26122859f, 0.08832933f, 0.38558081f, 0.11629270f, -0.02999803f, -0.47528541f, 0.58092850f, 
    0.54590094f, -0.71343094f, 0.44212469f, 0.58940339f, -0.13957117f, 0.03521405f, -0.08247935f, -0.51717305f, 
    0.15873629f, -0.07665580f, 0.14736561f, 0.15116154f, -0.47869796f, 0.27238467f, 0.22275883f, 0.29947543f, 
    -0.06798629f, 0.24016511f, -0.42157191f, -0.25005850f, -0.11856986f, -0.22277996f, 0.41929215f, 0.30571964f, 
    -0.82509816f, -0.45176286f, 0.11771745f, -0.54061168f, 0.60491836f, 0.58491403f, 0.55079269f, 0.02936341f, 
    0.40548861f, -0.29373592f, -0.02272069f, -0.33291772f, -0.01755202f, -0.37461221f, -0.09973798f, 0.04033627f, 
    -0.08132315f, -0.27011627f, 0.13189343f, -0.05079206f, 0.12689546f, 0.13883825f, 0.44699705f, -0.30950171f, 
    -0.66272098f, 0.69225037f, 0.79496402f, 0.32332283f, 0.13547456f, 0.16936900f, 0.53657842f, -0.71153867f, 
    -0.26675591f, 0.00477383f, 0.36565387f, -0.25011197f, -0.00776851f, -0.00826850f, -0.19018644f, -0.02229056f, 
    -0.12805471f, 0.13872142f, -0.03811104f, 0.16523728f, -0.07063171f, -0.04877454f, 0.11668646f, -0.17738710f, 
    -0.31621408f, 0.40212196f, 0.65773147f, 0.38364547f, 0.33381194f, -0.02140179f, -0.07827739f, 0.14811078f, 
    -0.39649034f, 0.27034670f, 0.61873645f, -0.18699785f, -0.18185350f, 0.14537421f, -0.04677714f, 0.05349497f, 
    0.38871521f, 0.03820683f, 0.38928410f, 0.44368279f, -0.01149141f, -0.48060372f, -0.34473079f, -0.26162630f, 
    -0.36085486f, -0.03252754f, -0.65437418f, 0.16788934f, 0.43996093f, -0.74638951f, -0.30106950f, -0.60734826f, 
    0.03993088f, -0.47593632f, -0.66364032f, -0.35681006f, -0.14996716f, 0.38529876f, 0.29519901f, 0.41155294f, 
    0.07827812f, -0.36939603f, 0.09985898f, -0.03493635f, 0.12279789f, -0.28306812f, -0.19041480f, 0.22714733f, 
    -0.01064126f, 0.34221727f, 0.48936945f, -0.47262546f, -0.35813776f, -0.52573001f, 0.19519268f, -0.26401708f, 
    -0.27934381f, 0.59376729f, 0.53009099f, -0.13793671f, 0.46299109f, -0.18612640f, -0.21653013f, -0.41739419f, 
    -0.32054472f, -0.30711892f, 0.05494151f, 0.17843229f, 0.16376498f, 0.13179021f, 0.06743002f, -0.23044020f, 
    -0.27457869f, -0.01957834f, -0.14455090f, 0.04805584f, 0.17648463f, 0.09738278f, 0.32178465f, 0.66105413f, 
    -0.35372278f, -0.03709174f, -0.69237715f, -0.36053085f, 0.16756646f, -0.13918915f, 0.41849220f, 0.42460865f, 
    0.31398433f, 0.10919568f, -0.02680000f, 0.00839463f, -0.14212415f, 0.26628244f, 0.33413461f, 0.36176246f, 
    -0.19882625f, -0.11045337f, -0.29079992f, 0.21637194f, 0.41612679f, -0.92339885f, -0.80155641f, -0.37053746f, 
    0.71115404f, 0.15952364f, 0.54362339f, 0.22255118f, -0.45865208f, 0.41110891f, -0.40612474f, 0.14092501f, 
    0.11087465f, -0.20288910f, 0.38363454f, -0.22765800f, -0.39271429f, 0.29754156f, -0.18065649f, -0.43506819f, 
    0.19671398f, -0.17083210f, 0.08625448f, 0.13357206f, -0.00692796f, -0.18657586f, -0.29406199f, -0.27147171f, 
    0.49635410f, 0.31970340f, 0.37059373f, 0.65833062f, 0.49543032f, -0.32627159f, -0.46733531f, -0.71978521f, 
    0.30952048f, 0.31006500f, 0.15180415f, 0.10567595f, -0.16750181f, 0.05936975f, -0.28136727f, 0.22518513f, 
    -0.39365521f, 0.15805745f, 0.12892251f, 0.29244837f, 0.05338187f, -0.05837927f, 0.25950104f, 0.00388593f, 
    -0.20954958f, 0.29985538f, 0.23170877f, 0.60886502f, 0.01447780f, 0.10645904f, 0.23911460f, 0.29716378f, 
    0.12594502f, 0.07405232f, -0.14636077f, 0.25489900f, -0.33001500f, -0.30175817f, 0.32324085f, -0.69435233f, 
    -0.12408259f, 0.30169722f, 0.05648151f, 0.35905403f, 0.33895150f, -0.03410364f, -0.19833019f, -0.43756378f, 
    -0.44410959f, -0.33736548f, 0.40481496f, 0.87498975f, 0.49052358f, 0.50834805f, 0.88679725f, 0.66007489f, 
    0.03704390f, 0.25156373f, -0.01090043f, -0.12615870f, 0.19664204f, -0.32864591f, -0.43226051f, -0.61112839f, 
    -0.08612521f, -0.13555056f, 0.01713238f, -0.21666478f, 0.15387203f, -0.17092945f, -0.23787065f, 0.21460205f, 
    -0.20676482f, 0.19394828f, -0.77706027f, -0.02085223f, 0.11746441f, 0.02850707f, 0.54306281f, 0.39540565f, 
    0.05205430f, 0.45993447f, -0.13700251f, -0.07558364f, 0.49648613f, 0.06870870f, 0.30244753f, 0.46748424f, 
    -0.39304093f, 0.31175157f, -0.11459045f, -0.14463584f, 0.44089758f, -0.00990446f, -0.10695900f, -0.12879360f, 
    -0.16129726f, 0.23203428f, 0.59551215f, 0.70307970f, 0.60492367f, 0.75823683f, 0.00352857f, -0.18566911f, 
    -0.48416904f, -0.42976901f, -0.34342632f, 0.46858433f, 0.02514468f, 0.27858499f, 0.21295722f, -0.08919530f, 
    -0.19692402f, -0.34282479f, -0.43616387f, 0.30638507f, -0.35191235f, -0.21532795f, -0.10504369f, 0.10694597f, 
    -0.16523641f, 0.01714001f, -0.07175688f, -0.45246935f, -0.27079031f, 0.58532196f, 0.33332101f, -0.72206736f, 
    -0.05640898f, 0.05901585f, -0.59354895f, -0.67070407f, -0.38647479f, 0.13884547f, 0.11149310f, -0.03233112f, 
    -0.04353628f, 0.19257236f, -0.41404158f, -0.55503434f, 0.16947363f, 0.11890517f, -0.60529661f, 0.30893299f, 
    0.25030050f, -0.04171840f, 0.32135659f, -0.16780761f, -0.71459341f, -0.74922842f, -0.52772409f, -0.14300667f, 
    -0.44703811f, -0.02539817f, 0.90323621f, 0.37824988f, -0.18246399f, 0.48910239f, -0.13111748f, 0.23935047f, 
    -0.00758047f, -0.24046557f, 0.03018158f, -0.28929588f, 0.10879602f, -0.05321278f, -0.00009660f, -0.15798287f, 
    0.31577870f, 0.35150737f, -0.38449109f, -0.01898886f, -0.14601330f, 0.46867096f, 0.80954546f, -0.72411025f, 
    0.28234085f, -1.09080803f, 0.23019697f, 0.46871045f, -0.42177665f, 0.16459735f, -0.11222681f, 0.15259731f, 
    0.10579154f, 0.24836788f, 0.16802576f, 0.12585677f, 0.11342177f, -0.22596164f, 0.30669588f, 0.29604280f, 
    -0.12448311f, 0.16541994f, -0.02587109f, 0.18846476f, 0.09073777f, 0.00178957f, 0.67501795f, 0.69450581f, 
    0.01679302f, 0.56043047f, 0.76463252f, 0.12067185f, 0.20287091f, 0.22712229f, 0.31967148f, 0.24904577f, 
    0.12178744f, -0.02065473f, 0.37220672f, -0.14121090f, 0.23875023f, 0.30234319f, 0.13754380f, 0.08808616f, 
    -0.10863408f, 0.42577270f, -0.18990003f, -0.21199661f, -0.13920799f, 0.03493027f, 0.16510272f, 0.41398951f, 
    0.64758825f, 0.47241902f, 0.61425906f, -0.04764702f, -0.88436347f, -0.32622227f, 0.06523758f, -0.24189021f, 
    -0.21851650f, 0.06347398f, -0.01249031f, -0.38144177f, 0.33184662f, 0.14533100f, -0.00581243f, -0.37751520f, 
    -0.01919917f, 0.00198404f, 0.30750445f, 0.22962645f, 0.33205709f, 0.16528197f, 0.33528066f, 0.22512415f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03448912f, 0.40405649f, 0.27724600f, 0.05698742f, -0.10030707f, 0.16494904f, 0.26282665f, 0.11893042f, 
    0.12096270f, 0.10385376f, -0.03710110f, 0.03006608f, 0.05167943f, -0.12097925f, 0.02297582f, 0.15463209f, 
    0.02174483f, 0.02516478f, 0.02399269f, 0.02993268f, 0.25012910f, 0.15336309f, 0.16656724f, 0.12590703f, 
    0.15025455f, 0.11525597f, 0.11963914f, 0.14786966f, 0.02601600f, 0.14350940f, 0.02408739f, 0.13946205f, 
    0.12236723f, 0.15748611f, 0.23140596f, 0.04341123f, 0.31542188f, 0.19525355f, 0.31594780f, 0.18649571f, 
    0.06780078f, 0.02428609f, 0.26646167f, 0.17019567f, 0.20095310f, 0.10699842f, 0.08909375f, 0.11320354f, 
    -0.22204423f, 0.10528311f, 0.13856027f, -0.02987483f, 0.25389618f, 0.33798999f, -0.01936985f, -0.05354945f, 
    -0.07241158f, 0.05853214f, 0.16357382f, 0.01579017f, 0.09195924f, 0.04827051f, 0.25399211f, 0.04040381f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27402574f, 0.14571807f, -0.00831596f, 0.03353229f, 0.15263066f, 0.04220789f, 0.00149793f, 0.14410380f, 
    0.03540823f, -0.03039627f, 0.11526237f, -0.05178209f, 0.10763268f, -0.22257796f, 0.13134220f, -0.19953185f, 
    -0.09546863f, -0.02945979f, 0.01827910f, -0.12723626f, -0.06959331f, 0.01354962f, -0.06057938f, 0.03468231f, 
    0.10467821f, -0.04759724f, -0.01604946f, -0.08584619f, -0.04245646f, -0.14273098f, 0.01631549f, -0.01771629f, 
    0.04983482f, 0.13306826f, -0.00941920f, -0.01190673f, -0.32371181f, -0.02844365f, -0.04162724f, 0.10776319f, 
    0.04843140f, -0.05344196f, -0.02642509f, -0.04966304f, 0.03682231f, -0.13859661f, -0.01793705f, -0.00265729f, 
    -0.09966538f, -0.14188573f, -0.03197887f, -0.23416765f, -0.15314648f, 0.06718981f, 0.16356106f, 0.00568642f, 
    -0.03112681f, 0.00195859f, -0.03445364f, 0.20470913f, 0.10255152f, 0.02204032f, 0.15203311f, -0.11265898f, 
    -0.00539237f, 0.18806837f, 0.09178944f, -0.02085161f, -0.05138752f, 0.07829454f, -0.01522803f, 0.01664902f, 
    -0.08190160f, -0.13629223f, 0.07087342f, -0.10675754f, 0.07505916f, -0.13776867f, 0.12066844f, -0.04745816f, 
    0.05493709f, -0.08858453f, -0.02255715f, 0.05165225f, 0.12309690f, -0.06793968f, 0.02614452f, 0.14761886f, 
    -0.00525910f, -0.08522831f, -0.02319829f, 0.02194140f, 0.00002400f, 0.07698630f, 0.00935158f, -0.06941179f, 
    0.05971891f, -0.09227885f, 0.23906131f, 0.07098370f, -0.06801182f, 0.00527644f, 0.04378865f, -0.09830903f, 
    0.01968900f, 0.01082584f, 0.00406787f, -0.09663769f, -0.02324107f, -0.02625498f, -0.09048087f, -0.25149950f, 
    0.03020171f, -0.03733812f, -0.00765789f, 0.11516516f, 0.06648514f, -0.16796561f, 0.02956913f, 0.06520376f, 
    0.15325856f, 0.04218723f, 0.07324810f, -0.08530939f, -0.05068754f, 0.07225458f, -0.00889397f, 0.18310772f, 
    0.11098408f, 0.02072077f, 0.03178557f, 0.03522528f, -0.45395869f, 0.08457574f, 0.24312498f, -0.15324083f, 
    -0.06554366f, 0.04583400f, 0.08384990f, -0.02701832f, -0.06252671f, -0.19394352f, 0.04350355f, 0.02090050f, 
    0.04301482f, -0.06721447f, -0.27840406f, 0.28926352f, 0.02804768f, -0.05468181f, -0.03265269f, -0.13476549f, 
    0.03922172f, 0.02513845f, 0.05737472f, 0.08502733f, -0.03431271f, 0.05816015f, 0.00660940f, 0.27520069f, 
    -0.12702788f, 0.00000975f, 0.05383850f, -0.02545138f, 0.09188183f, -0.01584717f, -0.01272869f, 0.02541262f, 
    0.00314146f, 0.12847438f, -0.18206637f, -0.00312305f, -0.11629596f, -0.18706824f, 0.08728954f, 0.13241500f, 
    -0.02364388f, 0.07498559f, -0.09396249f, 0.10388483f, -0.00578263f, 0.10983288f, -0.05922526f, 0.10488299f, 
    0.02445477f, -0.02224186f, -0.03107018f, -0.02191800f, -0.03400033f, 0.04101830f, 0.00556561f, -0.15071926f, 
    0.15194806f, -0.01456463f, 0.23802598f, -0.14702474f, -0.03757847f, -0.00408888f, 0.07355902f, -0.06574382f, 
    0.01342947f, 0.06385577f, -0.02742650f, -0.04145529f, 0.27305064f, 0.08641129f, 0.01884793f, -0.03606907f, 
    -0.05809531f, -0.16598570f, -0.13970755f, -0.01178939f, -0.11579365f, 0.04784088f, -0.00370066f, -0.03077351f, 
    0.14702319f, 0.03672189f, -0.25911283f, -0.22796912f, 0.10588340f, -0.02943217f, 0.11716386f, 0.04772906f, 
    0.00327063f, -0.15418693f, -0.00921842f, -0.10215836f, -0.11245511f, -0.04318490f, 0.03405750f, -0.31638241f, 
    0.07077096f, -0.03627469f, 0.15995312f, 0.02879381f, -0.00855537f, 0.04683960f, 0.11582769f, -0.06818803f, 
    -0.12412329f, 0.06273605f, -0.03178770f, -0.01402911f, -0.17956027f, -0.07313783f, 0.04627132f, -0.00260308f, 
    -0.01847525f, 0.01691713f, 0.01318911f, -0.09948254f, 0.20957804f, -0.03232983f, -0.06020310f, 0.15157615f, 
    -0.12671043f, -0.02887952f, -0.03568767f, 0.03116076f, 0.03872145f, -0.04923525f, 0.01255864f, 0.02549377f, 
    -0.22038075f, 0.04514095f, -0.20801991f, 0.25467044f, -0.05406391f, -0.02252125f, -0.00291317f, -0.01962540f, 
    0.04628394f, 0.04241435f, 0.04941412f, -0.01281142f, 0.48268771f, 0.18387087f, 0.06938495f, -0.26540443f, 
    0.10824930f, -0.02131233f, 0.02087649f, -0.01210547f, 0.02982416f, -0.03537746f, -0.15141952f, 0.11547417f, 
    0.13874866f, -0.19007118f, -0.27141896f, 0.33489767f, -0.01222762f, -0.05946175f, 0.06793787f, -0.00803487f, 
    0.01690825f, -0.11956485f, -0.12504089f, 0.09931805f, -0.19529893f, 0.14488149f, -0.17861068f, -0.09088652f, 
    0.03919802f, 0.04369584f, 0.01253318f, -0.05524407f, 0.03346796f, -0.02159573f, -0.14874971f, -0.07331242f, 
    0.12431636f, 0.10672696f, -0.09538086f, -0.03092025f, -0.11247680f, -0.07260196f, -0.00900885f, 0.01923091f, 
    0.02835540f, 0.01432614f, -0.13500273f, -0.01086953f, 0.17696394f, -0.09136020f, 0.06545229f, 0.31483668f, 
    -0.09706673f, -0.07647616f, -0.06165534f, 0.08449759f, -0.08626308f, 0.00441627f, -0.04649549f, -0.06296384f, 
    -0.41174001f, 0.12484901f, 0.05348735f, -0.28984016f, 0.02718873f, 0.02569723f, 0.04218005f, -0.00047182f, 
    -0.00055452f, 0.04121253f, -0.09864267f, 0.04673498f, -0.26959991f, -0.10819187f, 0.08008796f, -0.00250067f, 
    0.01877746f, 0.02698146f, -0.01780573f, -0.01079516f, 0.03998404f, -0.00569527f, 0.01384343f, 0.04923232f, 
    0.15970610f, -0.09839387f, 0.07018563f, -0.04258277f, 0.05532315f, 0.02783725f, -0.02381308f, 0.13394727f, 
    0.01089389f, -0.04870640f, -0.00947408f, 0.05729907f, -0.09129502f, 0.15306959f, -0.13917626f, -0.04446542f, 
    -0.01469056f, 0.01236109f, -0.01744934f, 0.05863581f, 0.08526155f, 0.08931692f, 0.03015658f, -0.10056534f, 
    0.28620002f, -0.13636087f, -0.03701967f, -0.24874774f, -0.11647020f, -0.07519627f, -0.02223513f, -0.02335900f, 
    -0.05869971f, -0.10185818f, -0.13580489f, 0.04337598f, 0.22226790f, -0.07847639f, 0.08769919f, -0.10256629f, 
    0.06656992f, 0.04846191f, -0.01457692f, 0.02458030f, -0.01790573f, -0.00403448f, 0.03664478f, -0.05293486f, 
    -0.50757790f, 0.08788986f, -0.07088289f, -0.06348071f, 0.05459944f, -0.02088990f, -0.10157529f, -0.04044831f, 
    0.04083668f, 0.02717418f, -0.07682621f, 0.07218066f, 0.03483212f, 0.07760103f, 0.00929962f, -0.06892140f, 
    -0.14448227f, -0.04923671f, -0.09150638f, -0.09406307f, 0.03703005f, 0.10687471f, 0.00127713f, 0.01484902f, 
    0.15968411f, 0.03044725f, -0.01661389f, -0.11881427f, -0.04208841f, -0.07731757f, -0.10822167f, -0.04606538f, 
    -0.14272709f, -0.02988629f, 0.04455102f, -0.09412631f, 0.03951547f, 0.05649213f, 0.10862865f, 0.04517265f, 
    0.06862117f, -0.02987264f, 0.06959131f, -0.05400480f, -0.08243299f, 0.05189544f, 0.13536085f, -0.04503633f, 
    -0.08037916f, 0.06755608f, -0.08899463f, 0.03962414f, -0.16687478f, -0.22740173f, -0.00389198f, 0.00939552f, 
    -0.09460651f, -0.01970010f, -0.09763652f, -0.02817470f, -0.18422557f, -0.24780320f, 0.11828609f, 0.07008830f, 
    0.06184863f, 0.03436499f, -0.04633965f, 0.00968540f, -0.01258788f, 0.07898275f, -0.07723903f, 0.00060690f, 
    0.17363924f, 0.03237950f, -0.10774630f, 0.04862455f, -0.14076230f, 0.05947313f, 0.06183603f, -0.08845832f, 
    0.00084894f, 0.01066904f, -0.06068805f, -0.02315614f, -0.08106125f, 0.15396667f, 0.11183884f, -0.28430432f, 
    0.01694397f, 0.02666052f, 0.04326328f, -0.04412352f, 0.06563847f, -0.07941683f, 0.02696801f, 0.10081587f, 
    -0.07586299f, 0.12501888f, 0.15232423f, 0.01239688f, 0.04299491f, 0.01090059f, -0.04163979f, -0.06002021f, 
    -0.00417770f, -0.09809033f, 0.04501526f, -0.04201442f, 0.14087155f, -0.00396810f, -0.10242228f, -0.29182276f, 
    -0.03478343f, 0.11051925f, -0.00261173f, 0.06037894f, -0.07555767f, -0.08612458f, -0.01580418f, -0.03914191f, 
    0.19103800f, -0.13538831f, -0.04369308f, 0.31455508f, -0.11182459f, 0.04130227f, -0.06173034f, 0.03575849f, 
    0.01297406f, 0.05757671f, -0.04728866f, -0.10748661f, -0.17560755f, -0.03267195f, -0.14634535f, 0.03625169f, 
    0.13934124f, -0.11482675f, -0.06244560f, -0.03564475f, 0.02696308f, 0.05096948f, -0.07562803f, 0.00180153f, 
    -0.19061747f, 0.03307150f, 0.13172112f, -0.20398253f, 0.09820348f, -0.01120489f, 0.06235713f, 0.02595839f, 
    0.10920966f, 0.00992722f, 0.03161897f, -0.01045472f, 0.11124595f, 0.17223109f, -0.13376848f, -0.06279038f, 
    -0.01018876f, 0.04834936f, -0.11314248f, -0.06693842f, -0.04982622f, 0.02283587f, 0.08353385f, -0.00322440f, 
    -0.07392897f, -0.04876693f, 0.10425980f, -0.05004783f, 0.02257809f, 0.00217004f, 0.10052003f, 0.03088944f, 
    0.11058400f, 0.11309075f, 0.12983355f, 0.00916702f, -0.00678061f, 0.06529958f, -0.01790252f, 0.04313561f, 
    -0.10292306f, 0.02575590f, -0.03460249f, -0.06074794f, 0.12144137f, 0.11704814f, -0.01248112f, -0.03689521f, 
    -0.57505900f, -0.02504345f, 0.12851691f, 0.10018782f, 0.00119286f, 0.14705628f, 0.00564008f, -0.05024218f, 
    0.01035591f, -0.03463856f, -0.10869016f, 0.04732751f, 0.02349800f, 0.22749527f, 0.03582258f, -0.10608887f, 
    0.05666256f, 0.06637968f, -0.03012029f, 0.08119249f, 0.08038976f, 0.01207003f, 0.06610379f, 0.04860405f, 
    -0.03840506f, 0.01107890f, -0.04679260f, 0.15724820f, -0.06401283f, -0.04887302f, -0.07935612f, -0.00824876f, 
    0.07270972f, 0.01112232f, -0.09726326f, 0.08364833f, -0.35209173f, -0.03907813f, -0.19348030f, 0.04979611f, 
    0.07936698f, -0.05745868f, -0.10180818f, 0.07728801f, -0.07901593f, -0.00959300f, -0.05397495f, 0.00931014f, 
    -0.23426212f, 0.00700295f, 0.10195351f, 0.01693127f, -0.08292653f, -0.00296423f, 0.05248578f, 0.00379600f, 
    -0.11518952f, 0.01752694f, 0.01451063f, -0.05973915f, -0.12929496f, 0.02508199f, -0.00269243f, -0.00222580f, 
    -0.05474319f, 0.04249961f, -0.07854632f, 0.01352236f, -0.12556966f, -0.03479779f, 0.00225066f, 0.04428893f, 
    -0.21625262f, 0.15684159f, 0.04710676f, 0.18751694f, 0.03051969f, 0.08594859f, 0.05696827f, 0.10827947f, 
    -0.03571423f, -0.12083398f, -0.10276177f, -0.03045091f, -0.18108428f, 0.00437792f, -0.07399429f, -0.10069487f, 
    0.04881759f, -0.07814728f, -0.14890206f, -0.03640562f, 0.11291750f, -0.01291087f, 0.02867969f, 0.15307021f, 
    0.11726159f, 0.05381123f, -0.14327812f, -0.00492582f, -0.25860974f, -0.08900486f, 0.02083434f, 0.01784098f, 
    -0.08156767f, 0.07927803f, -0.08309288f, -0.01365640f, -0.34620699f, 0.09016484f, -0.01870992f, 0.18653236f, 
    0.12670131f, 0.07879757f, 0.05901261f, -0.03313888f, -0.00806538f, 0.10977037f, -0.06570961f, -0.04487215f, 
    0.11318043f, 0.14878774f, 0.05837767f, -0.23186433f, -0.00137412f, 0.02663004f, -0.02122971f, 0.01612171f, 
    0.03380990f, -0.08767320f, -0.07880133f, 0.10101305f, 0.03742965f, 0.25252575f, 0.02999992f, -0.20136566f, 
    -0.03883289f, -0.03345930f, -0.03522055f, -0.07950434f, -0.02573144f, -0.05356185f, 0.01805546f, 0.03326088f, 
    0.09949658f, -0.09668943f, -0.04484849f, 0.08995941f, -0.12682389f, 0.02101753f, 0.01874166f, 0.09801871f, 
    0.09919966f, 0.01368701f, 0.01059015f, -0.04821243f, 0.15869328f, 0.08525448f, -0.03590655f, 0.08455130f, 
    -0.08372675f, 0.00825632f, -0.13572784f, -0.00893911f, 0.01084764f, -0.09721585f, 0.01042624f, -0.12397877f, 
    0.19941640f, 0.02784698f, -0.15836482f, 0.00761893f, -0.07826331f, 0.02068476f, 0.01920189f, 0.01677143f, 
    0.02777752f, 0.04576537f, -0.08743977f, 0.04993709f, 0.31232321f, -0.12325762f, 0.15148081f, -0.06155745f, 
    0.04328400f, 0.06416169f, 0.08109172f, 0.10360542f, -0.07787741f, 0.02596261f, 0.05841994f, -0.03636413f, 
    -0.03901811f, -0.03568383f, -0.12490138f, -0.05918328f, 0.11322974f, 0.02262227f, 0.04256520f, 0.00646495f, 
    0.09518558f, -0.11522886f, 0.04730568f, 0.04682123f, 0.35289001f, 0.09395257f, -0.17580304f, 0.14031482f, 
    -0.13394083f, 0.05557918f, -0.09422880f, -0.00758343f, 0.01013078f, 0.14525193f, 0.01518115f, 0.02532822f, 
    0.20984994f, -0.14802665f, -0.05303929f, -0.09785327f, -0.02153368f, 0.02182106f, -0.10498103f, 0.04160760f, 
    -0.09634551f, -0.08722619f, -0.09033629f, -0.13364391f, -0.07748719f, -0.13593307f, 0.14564407f, -0.40567854f, 
    0.02074441f, -0.06684008f, 0.03743923f, 0.12833346f, 0.08821127f, -0.07337315f, 0.01243884f, 0.03216470f, 
    0.25519395f, -0.30987915f, -0.00740819f, -0.23452686f, -0.09831646f, 0.03539155f, -0.07341808f, 0.01445377f, 
    -0.12754887f, 0.12433148f, -0.04339650f, -0.09121980f, 0.17983112f, 0.00808943f, 0.07879797f, 0.11712418f, 
    -0.14936863f, -0.12056645f, 0.11118009f, 0.01281529f, -0.02467839f, -0.08432359f, -0.05158918f, -0.00472268f, 
    -0.01565563f, -0.00329442f, -0.07866652f, -0.12950903f, -0.06716906f, -0.03887049f, 0.04116608f, 0.10664374f, 
    0.06632332f, -0.21278587f, -0.25296396f, -0.06048389f, 0.06556661f, 0.19324026f, 0.05774742f, -0.01324745f, 
    0.01718368f, -0.04528559f, 0.06132489f, -0.13661085f, -0.01777223f, 0.08869137f, -0.04573726f, 0.05920727f, 
    0.10991131f, -0.14361686f, 0.14634317f, 0.17525673f, -0.10169317f, -0.08787093f, 0.04590446f, -0.04351195f, 
    -0.11185651f, 0.02152490f, -0.05507240f, 0.00131123f, -0.21952663f, 0.12463777f, -0.33827093f, -0.37142423f, 
    -0.02253339f, 0.09027558f, 0.01567606f, -0.06106736f, 0.02934158f, 0.22510210f, -0.02241809f, 0.03091665f, 
    -0.11892337f, 0.02361386f, -0.12058195f, 0.00317989f, -0.04698450f, 0.03058664f, 0.05919870f, 0.06252699f, 
    -0.11770191f, -0.19862714f, -0.01870315f, -0.30573550f, 0.20067561f, -0.14289273f, -0.12471002f, 0.05661888f, 
    -0.06039344f, 0.11384264f, -0.05869622f, -0.04413082f, -0.07580895f, 0.01716729f, 0.08026294f, -0.23748684f, 
    -0.01975473f, 0.12694140f, -0.08873175f, 0.05239769f, -0.08314169f, 0.10097176f, 0.01351110f, -0.04303512f, 
    0.03332309f, -0.13676000f, 0.08971396f, -0.11943377f, -0.26952484f, 0.05493221f, -0.17795379f, -0.08434986f, 
    -0.01517420f, 0.09275466f, -0.01496358f, -0.04522883f, 0.17829637f, 0.00239518f, 0.02577104f, 0.14781798f, 
    0.01455214f, -0.09258896f, -0.05643313f, -0.16537619f, 0.08675834f, 0.03097366f, -0.07306939f, 0.10963026f, 
    0.11091008f, -0.00002314f, 0.01336861f, -0.10874029f, -0.11337708f, -0.06947631f, -0.04627664f, 0.18447195f, 
    -0.04303147f, -0.01924870f, 0.04558149f, -0.03078218f, 0.10138534f, 0.03332955f, -0.03117733f, 0.10709694f, 
    -0.01987742f, -0.25828752f, 0.04983569f, 0.04609848f, -0.09257080f, 0.09477790f, -0.02906178f, 0.12284123f, 
    0.07520527f, 0.02126589f, 0.03111939f, 0.10944875f, -0.08735073f, -0.00787396f, 0.03980675f, -0.27079821f, 
    -0.05388484f, 0.06329351f, -0.00111139f, 0.11929627f, -0.00928774f, 0.12487544f, 0.02668907f, 0.02540178f, 
    0.08061720f, 0.08004434f, 0.11016655f, 0.04649834f, -0.08211072f, -0.01437263f, -0.00638209f, -0.04302966f, 
    -0.05447287f, -0.09012765f, -0.11437979f, 0.02139384f, 0.13643743f, -0.00462624f, 0.00423528f, 0.22850119f, 
    -0.14156894f, -0.07385800f, 0.00815296f, 0.02578066f, -0.06704917f, -0.06782836f, -0.08425058f, -0.03927723f, 
    -0.27401611f, -0.10381594f, -0.05836209f, -0.08526537f, 0.01448626f, -0.12550643f, -0.08649649f, -0.11659283f, 
    -0.09505136f, -0.03387367f, -0.04461014f, -0.02320087f, -0.17315055f, -0.06655613f, -0.14233644f, -0.21096753f, 
    0.01592985f, -0.01907342f, -0.11010781f, 0.16028145f, 0.06162236f, 0.02727247f, 0.05947002f, -0.10223502f, 
    -0.02325178f, -0.40805843f, -0.24138582f, -0.12349755f, 0.00844028f, 0.03014348f, -0.00463593f, 0.06807956f, 
    0.04864596f, 0.03255646f, 0.13863266f, -0.04163093f, 0.14579965f, -0.28711811f, -0.08184559f, -0.01498257f, 
    -0.00079329f, -0.13019583f, -0.06931118f, 0.13903221f, -0.07776485f, -0.08018231f, -0.08935456f, 0.15138885f, 
    0.19929682f, 0.02224828f, 0.01874320f, 0.12075132f, -0.12513041f, -0.02537223f, 0.07368837f, -0.01220131f, 
    0.06571057f, 0.03535284f, 0.06804183f, -0.02717596f, 0.30210814f, -0.07538456f, 0.04102743f, 0.10955797f, 
    -0.12513153f, 0.05411815f, 0.00759278f, 0.00776643f, -0.02584490f, 0.02083412f, 0.04080657f, -0.00906045f, 
    0.35002011f, -0.14615220f, 0.07459789f, -0.29209498f, 0.01008616f, -0.11204956f, -0.12641394f, 0.08809142f, 
    -0.10740427f, -0.02076793f, 0.12899508f, 0.00304662f, -0.00096230f, -0.00921785f, -0.19740973f, -0.02036652f, 
    -0.00813854f, -0.07658838f, -0.00117045f, 0.06835812f, 0.03630567f, 0.00318183f, -0.01431159f, -0.09131911f, 
    0.21201922f, -0.15970726f, 0.05532687f, -0.16627863f, 0.06049014f, -0.08107896f, 0.07448992f, -0.09921318f, 
    -0.09392633f, -0.15359613f, 0.07358640f, -0.04800785f, -0.04202317f, -0.11929011f, -0.01014649f, -0.11387420f, 
    0.02329280f, -0.07947344f, -0.05597135f, 0.04048648f, -0.05238658f, -0.16711441f, 0.01852104f, -0.01702659f, 
    -0.41196722f, -0.35466266f, 0.10829889f, -0.22620265f, 0.10975198f, -0.00074598f, 0.09286556f, -0.05734343f, 
    0.03067686f, 0.07553021f, 0.09485434f, -0.03866476f, 0.01015522f, -0.12731048f, 0.13911173f, -0.06994519f, 
    -0.01773783f, 0.06823776f, -0.10029886f, -0.09934871f, 0.10793734f, -0.12733486f, -0.02690876f, 0.04052878f, 
    0.30560052f, -0.01150692f, -0.03510656f, 0.13916171f, -0.10908104f, 0.05508133f, -0.09443826f, 0.00978963f, 
    -0.04497779f, -0.14045011f, 0.08297791f, 0.04352444f, -0.01057710f, 0.07989369f, -0.00126908f, 0.08966520f, 
    -0.02720299f, -0.07493268f, -0.08581499f, 0.04003081f, -0.01164554f, 0.06395521f, -0.16008955f, 0.09556564f, 
    -0.02773901f, -0.15657359f, -0.03419934f, -0.06120872f, 0.02961280f, -0.09779691f, 0.12532283f, 0.01878128f, 
    0.08555564f, 0.04071853f, -0.00711016f, -0.03740016f, 0.23763052f, -0.14923224f, 0.16273211f, -0.03006568f, 
    -0.01856846f, 0.05862158f, -0.11912261f, -0.07486151f, 0.00139978f, -0.02510936f, -0.24920692f, 0.07160857f, 
    0.11263891f, -0.07606239f, 0.21271732f, 0.13064146f, -0.13177723f, 0.08124271f, 0.03275647f, 0.03062740f, 
    -0.09051946f, 0.10750324f, 0.08977512f, -0.05188343f, 0.23147215f, 0.14094085f, -0.07910542f, 0.07010361f, 
    0.08448628f, 0.04039045f, 0.02547835f, -0.06610661f, -0.04157386f, -0.04683856f, 0.04360524f, 0.14542896f, 
    -0.22904116f, -0.13847549f, 0.00155099f, 0.05038975f, 0.06148468f, -0.14955470f, -0.04230861f, -0.03347233f, 
    0.15836792f, -0.03354916f, -0.08329646f, 0.03988987f, 0.09587995f, -0.05001114f, -0.10386523f, -0.02633484f, 
    -0.01687478f, -0.00247473f, 0.07080621f, 0.12578133f, 0.02633270f, 0.11443084f, -0.08236298f, -0.03301316f, 
    -0.01087989f, 0.11367431f, -0.17346276f, 0.02930093f, 0.02528642f, 0.00959468f, -0.00672740f, 0.04506778f, 
    0.04885076f, 0.06694770f, 0.06627966f, 0.06880786f, 0.06704719f, 0.00475117f, 0.02827218f, -0.06446429f, 
    0.12960649f, -0.15998955f, 0.04888474f, -0.17014879f, -0.07788677f, 0.11687341f, 0.00053509f, -0.09113371f, 
    0.07492194f, -0.11984845f, 0.18858141f, 0.06385651f, -0.08631085f, -0.04641888f, -0.12514192f, 0.04107030f, 
    -0.03456952f, 0.02793922f, -0.04565080f, 0.01066392f, -0.04524532f, -0.00659059f, 0.01434582f, -0.18369690f, 
    -0.01356613f, 0.10259499f, 0.01332304f, 0.00572047f, -0.03231969f, -0.05883691f, 0.10166888f, -0.07215360f, 
    -0.02167659f, 0.00382972f, -0.04432522f, -0.11292016f, -0.00952676f, 0.17541315f, -0.10950756f, -0.08461584f, 
    -0.06398296f, 0.11858889f, -0.02547348f, 0.15852095f, 0.16355333f, -0.25108686f, -0.01129578f, 0.04420419f, 
    0.00039206f, -0.00547767f, -0.02282064f, -0.11229274f, 0.18894470f, -0.00367679f, -0.04496374f, 0.08923205f, 
    -0.00502352f, -0.14425416f, -0.05766907f, -0.02317671f, -0.19863516f, 0.01353535f, 0.03884003f, -0.16005610f, 
    -0.10979544f, -0.13902128f, 0.09056199f, -0.09171715f, 0.22373199f, -0.03852385f, -0.03387232f, -0.01231119f, 
    0.10480224f, -0.10166630f, 0.00364853f, -0.03106659f, -0.01777324f, -0.11093879f, 0.01705165f, 0.02829300f, 
    -0.18845731f, 0.13110319f, -0.09048487f, -0.07255358f, -0.05796805f, 0.04504294f, 0.02872819f, 0.11358394f, 
    0.15935808f, 0.06610093f, 0.01634808f, -0.06657527f, 0.09233365f, -0.24433123f, -0.13624395f, 0.01306514f, 
    -0.03647877f, -0.05193089f, -0.08925829f, -0.15787521f, 0.08606898f, -0.00902828f, -0.07775182f, 0.03358420f, 
    -0.12365174f, -0.03600983f, -0.06362241f, 0.00806810f, -0.03745446f, 0.01942959f, -0.05823780f, 0.00681550f, 
    0.01892644f, 0.15369122f, 0.01859745f, 0.01795563f, 0.05774506f, 0.07880393f, -0.35446826f, 0.08346788f, 
    0.13887237f, 0.05932806f, 0.04562362f, 0.02050757f, -0.05084100f, -0.06936987f, 0.10340008f, -0.01101713f, 
    0.01554252f, -0.02907744f, 0.03313987f, -0.03645481f, -0.24610379f, 0.07810629f, 0.01373642f, -0.01613570f, 
    0.01728032f, -0.05684227f, -0.04095935f, -0.04075287f, 0.05823085f, 0.00750439f, 0.07393701f, 0.19240044f, 
    0.09976764f, 0.03620498f, 0.10838707f, -0.01087494f, 0.08864151f, 0.03872070f, -0.04087826f, 0.04187882f, 
    0.12648804f, 0.11616535f, -0.06289747f, 0.16530040f, 0.02085625f, 0.08443510f, -0.08250019f, -0.02370404f, 
    0.01134362f, 0.01663822f, 0.02437213f, -0.08362969f, 0.25545949f, -0.10881883f, 0.02916087f, 0.07214804f, 
    -0.00044222f, 0.05126771f, 0.04773685f, 0.06110561f, -0.10944615f, 0.02526315f, 0.04829490f, -0.10667645f, 
    0.09931262f, 0.06786594f, 0.07917266f, 0.14669365f, -0.05118428f, 0.00649123f, 0.08206777f, -0.01152339f, 
    0.02264563f, -0.15607853f, 0.05591033f, -0.02015986f, -0.23464096f, -0.05012305f, -0.35607499f, 0.06584478f, 
    -0.13183959f, 0.06789446f, 0.07457355f, -0.01858140f, -0.06387147f, -0.09248622f, 0.01766516f, 0.01765314f, 
    0.05429233f, -0.01176371f, -0.17077710f, 0.03656659f, 0.15831125f, -0.04219672f, -0.03992573f, -0.01378756f, 
    0.07427289f, 0.01725621f, -0.07060644f, -0.01304789f, 0.31534085f, -0.39740482f, -0.00161121f, -0.08615799f, 
    -0.03472486f, -0.01417158f, 0.03192558f, 0.17472078f, -0.04397214f, 0.05249416f, -0.09979865f, 0.15519358f, 
    0.19417188f, 0.00740221f, 0.11663333f, 0.16138458f, -0.11566206f, -0.07469284f, -0.04219807f, -0.00277007f, 
    -0.03416268f, 0.00623224f, -0.08487339f, 0.04262035f, -0.15289266f, 0.00543135f, -0.11557866f, 0.22837876f, 
    -0.05476493f, -0.01074176f, 0.12758331f, 0.10164612f, 0.02383321f, 0.06466147f, -0.10410110f, 0.19534418f, 
    -0.14369352f, -0.19111681f, -0.13597795f, 0.09610634f, -0.05409058f, 0.09562682f, -0.08398084f, 0.00382239f, 
    0.04011838f, -0.08416816f, -0.01069747f, 0.03568017f, -0.25407836f, -0.14934938f, 0.09055464f, -0.16867080f, 
    -0.02690961f, -0.04304488f, -0.01334618f, -0.01074583f, -0.11170923f, -0.04470240f, -0.07141620f, -0.00052402f, 
    -0.07588268f, -0.06328778f, -0.10293833f, -0.00261318f, 0.01065757f, 0.02106801f, -0.07967269f, -0.01440827f, 
    -0.09111574f, -0.09095054f, -0.07491153f, 0.00435946f, -0.01465164f, -0.04924048f, 0.08537278f, 0.10905740f, 
    -0.07975133f, -0.01457368f, -0.04240763f, -0.03164155f, 0.02474615f, -0.10836446f, -0.04902510f, 0.07608836f, 
    -0.12441228f, 0.06617586f, 0.04386950f, -0.11240519f, -0.08750498f, -0.07095517f, 0.06607594f, -0.02635887f, 
    -0.00085751f, -0.11446618f, 0.00098064f, -0.00796677f, -0.30124822f, -0.06682999f, -0.11432712f, 0.12257906f, 
    0.07500803f, 0.11533959f, 0.04211624f, -0.06341575f, 0.06466123f, -0.00255845f, -0.12623556f, 0.00082676f, 
    -0.33728582f, -0.19639438f, 0.06788176f, -0.17211033f, -0.05472333f, -0.13128985f, 0.02424256f, -0.05954323f, 
    -0.07719743f, -0.00730251f, -0.05464072f, 0.06308486f, 0.07835143f, 0.08455610f, -0.01991049f, 0.03255450f, 
    -0.00326481f, -0.03999765f, 0.06848060f, 0.06951699f, -0.15634921f, 0.04164803f, 0.02590065f, 0.07741947f, 
    -0.00816714f, -0.29145023f, -0.01510568f, -0.14565507f, -0.03644733f, 0.06882154f, -0.04918578f, -0.05663572f, 
    -0.01271599f, 0.12442587f, 0.06656493f, 0.00629725f, 0.10687224f, 0.00318921f, -0.24645355f, 0.03009783f, 
    0.01858272f, 0.11827109f, 0.04659241f, -0.03330418f, 0.00476169f, -0.07317525f, 0.01175666f, -0.09926617f, 
    0.19640160f, 0.03542257f, 0.00223476f, -0.08681896f, 0.09165683f, 0.01312809f, 0.02650082f, -0.04290692f, 
    0.00055316f, 0.07577566f, 0.21242826f, 0.02923176f, 0.26641443f, 0.00754625f, -0.31686980f, -0.21404627f, 
    0.02329527f, 0.05449430f, 0.04725306f, -0.07372343f, -0.11211963f, 0.02114681f, 0.00666481f, 0.00521672f, 
    -0.21318662f, 0.08268840f, -0.15689291f, -0.05255284f, -0.09271678f, 0.04171436f, -0.04689154f, -0.07509173f, 
    0.08666325f, 0.15487295f, 0.07982291f, -0.00832964f, -0.05924300f, -0.07741094f, -0.04497046f, -0.08698398f, 
    0.14424498f, -0.00679453f, -0.03185828f, 0.04721167f, 0.12427646f, 0.07817116f, -0.01010028f, -0.07574470f, 
    -0.20206118f, 0.04048228f, -0.14366767f, -0.03637676f, 0.07797632f, 0.11554085f, 0.07942564f, 0.09510335f, 
    -0.02070612f, 0.06063423f, -0.08513606f, -0.10048787f, 0.26682040f, 0.11987413f, -0.27602139f, -0.16399702f, 
    0.00200895f, 0.00436840f, -0.02154101f, 0.04835965f, -0.05842756f, -0.06041600f, -0.13559920f, -0.16499518f, 
    -0.15043513f, -0.05948488f, 0.02571456f, -0.01516301f, -0.00837210f, 0.01383463f, 0.03630593f, 0.02180350f, 
    -0.04691570f, 0.05977825f, -0.11234543f, 0.09151006f, -0.35500044f, 0.01328514f, -0.15291074f, -0.13370179f, 
    0.03571666f, 0.01996671f, 0.07653742f, 0.05592044f, -0.19202679f, 0.06152024f, -0.01992627f, 0.01300687f, 
    -0.11797073f, 0.04045286f, 0.14515464f, 0.08253670f, -0.16725068f, 0.05029661f, -0.01792195f, 0.03118016f, 
    0.04716169f, 0.10739815f, -0.04361866f, -0.12775284f, -0.26826587f, -0.18195678f, -0.12327530f, 0.15108700f, 
    0.05301476f, 0.01400889f, 0.01038339f, -0.10648178f, -0.07013036f, -0.05212852f, 0.09202631f, 0.04012526f, 
    -0.03814173f, -0.00593770f, 0.00731381f, -0.12525122f, 0.10406946f, 0.03297572f, 0.02701760f, -0.00805228f, 
    0.03042333f, 0.01761369f, 0.05299178f, -0.05905842f, -0.17754529f, 0.13129131f, -0.13675122f, -0.01606991f, 
    0.10649558f, -0.01793958f, 0.01306838f, 0.06358778f, 0.02815708f, -0.04470135f, -0.00674572f, -0.02433472f, 
    0.21424697f, -0.24485675f, -0.07483536f, -0.01688425f, -0.03348900f, 0.06521578f, 0.05214404f, 0.16253692f, 
    -0.01780440f, -0.02199727f, 0.07995164f, -0.04488043f, 0.28166702f, 0.13211417f, 0.02941033f, 0.34677407f, 
    -0.09188450f, -0.06420796f, 0.03190799f, 0.09128612f, -0.07445552f, 0.04742500f, -0.02413205f, -0.04853424f, 
    0.25942868f, -0.16723785f, -0.24644311f, 0.00401376f, -0.01472263f, 0.08753974f, -0.08267324f, 0.04962592f, 
    -0.01036270f, 0.07320563f, -0.01968050f, -0.00343982f, -0.00336106f, -0.10596503f, -0.08823282f, -0.14178362f, 
    0.01340791f, -0.04414006f, 0.03353499f, -0.19563259f, -0.06178140f, -0.00483169f, -0.06208576f, -0.02288325f, 
    0.06126454f, 0.15254374f, 0.06542648f, 0.08285785f, 0.05063207f, 0.09779407f, -0.01696233f, -0.06231682f, 
    -0.01369881f, -0.02992821f, 0.00863695f, 0.00726742f, 0.02314363f, 0.00505315f, 0.02068182f, -0.10595652f, 
    0.12560812f, 0.04164388f, 0.00605692f, -0.00421635f, -0.01611372f, 0.10252571f, -0.00357924f, 0.01832981f, 
    -0.43785542f, 0.07142940f, -0.12112311f, -0.13472262f, -0.06316104f, -0.11277096f, 0.09444077f, -0.10042263f, 
    -0.01428226f, 0.00349466f, -0.12247614f, 0.04916183f, 0.07344057f, 0.07621159f, 0.10835400f, -0.15247925f, 
    -0.13866413f, -0.01674537f, 0.00272631f, -0.08531857f, -0.05288411f, -0.04718643f, 0.02151802f, -0.01704744f, 
    -0.12720868f, 0.02653471f, 0.03174013f, -0.01151239f, -0.03549034f, -0.02404262f, 0.06608790f, 0.03744107f, 
    -0.08767998f, 0.03762434f, 0.00410296f, -0.06408873f, 0.17608057f, 0.15158625f, -0.17738666f, 0.12790664f, 
    -0.04761674f, -0.01119122f, -0.02637090f, 0.04122455f, -0.01752861f, 0.07756016f, -0.09362835f, -0.05649017f, 
    -0.13600816f, 0.29137132f, 0.07923789f, -0.18210715f, 0.02978637f, 0.13136026f, 0.00128304f, 0.06751671f, 
    -0.10777067f, -0.02678312f, 0.01042584f, -0.02283502f, -0.26110670f, 0.06875211f, -0.07433670f, 0.00963480f, 
    0.10345278f, -0.03867371f, 0.02538303f, -0.00920306f, -0.07237888f, 0.01186389f, -0.05205424f, -0.04934692f, 
    0.48842743f, -0.00689918f, -0.02260144f, 0.18702838f, -0.09696605f, -0.07638431f, -0.07974471f, 0.01633980f, 
    0.01624988f, 0.08457366f, 0.02719886f, -0.01897877f, -0.14022624f, -0.08138711f, 0.09587178f, -0.11133420f, 
    0.00594735f, -0.08027545f, 0.07551456f, -0.08502208f, 0.07404490f, -0.06110344f, 0.00571597f, 0.07456954f, 
    -0.16585784f, 0.07283886f, 0.03787659f, -0.22972624f, 0.01283581f, 0.03613060f, 0.04995556f, -0.14798750f, 
    -0.06188355f, -0.04547190f, -0.06089177f, -0.08582126f, 0.13068591f, -0.03208454f, 0.05656720f, -0.00631244f, 
    -0.05800098f, 0.03367744f, 0.02954274f, -0.02923021f, 0.06456240f, -0.04065734f, 0.10208728f, -0.04230429f, 
    0.10361940f, -0.09717452f, -0.06005533f, 0.11107967f, 0.10769612f, 0.05493226f, 0.04534102f, -0.05453217f, 
    0.07190106f, 0.05601297f, 0.00478971f, 0.08282752f, 0.14119872f, -0.15244257f, 0.05378002f, 0.06481368f, 
    -0.12383351f, -0.10106520f, -0.06962293f, 0.02775693f, -0.07502530f, -0.07603569f, 0.03070661f, 0.02552574f, 
    0.18487725f, -0.04590367f, -0.02955262f, -0.05075276f, 0.00983015f, 0.03338036f, 0.00979044f, 0.03616735f, 
    -0.00518104f, 0.04435375f, 0.07633407f, -0.06884598f, 0.25044736f, 0.10705319f, 0.02806601f, 0.21372925f, 
    -0.09871209f, 0.04755432f, -0.05559066f, 0.11186407f, -0.08264845f, -0.04108262f, 0.01469210f, 0.14278288f, 
    -0.03595687f, -0.08095506f, 0.03510295f, 0.10575026f, -0.11188369f, 0.08529019f, -0.10238058f, -0.10689999f, 
    -0.03193665f, -0.10519747f, 0.02498008f, 0.05392659f, 0.04027701f, 0.17028108f, 0.03991536f, 0.09241788f, 
    -0.08434677f, -0.08001212f, 0.04487912f, 0.12610069f, -0.04537125f, -0.07394282f, 0.04157170f, -0.08739473f, 
    0.13050698f, -0.00375560f, -0.02831466f, -0.02961514f, 0.11005396f, -0.01623368f, 0.00613387f, -0.04377154f, 
    0.05838038f, 0.01685633f, -0.01961537f, -0.05232898f, 0.33707434f, -0.10173753f, -0.17212608f, -0.15455104f, 
    0.08490552f, 0.11624493f, -0.07883776f, -0.03983810f, 0.01846216f, 0.04115631f, -0.07022895f, -0.17398533f, 
    0.08860476f, -0.08890786f, -0.01229522f, 0.11480823f, -0.00702727f, -0.08305266f, 0.02456082f, -0.08435263f, 
    -0.13531688f, -0.02562442f, -0.10855702f, -0.07816043f, 0.06248040f, 0.02465998f, 0.12827156f, 0.10290755f, 
    -0.01397095f, -0.07993882f, -0.06120261f, 0.06442677f, -0.01409558f, -0.01333184f, 0.02575820f, -0.03894943f, 
    0.25293261f, 0.04897263f, -0.00288716f, 0.07976176f, 0.09425810f, 0.00366797f, -0.01028486f, 0.00125273f, 
    0.00911152f, -0.01361775f, 0.01469872f, -0.02799947f, 0.07565840f, -0.04806830f, -0.00906973f, 0.03990813f, 
    -0.03403166f, 0.08225667f, -0.01761710f, -0.00836217f, -0.10425648f, 0.00134627f, -0.04501655f, -0.04651724f, 
    0.18512718f, -0.00618403f, -0.39475322f, -0.31978413f, 0.07607182f, -0.00288888f, -0.13159077f, -0.04069761f, 
    -0.03387197f, 0.04307539f, -0.04985654f, -0.01051176f, 0.16121171f, -0.00438732f, -0.01302486f, 0.11996196f, 
    -0.07560558f, -0.00488041f, -0.03175776f, 0.02470808f, -0.05326092f, -0.00720724f, 0.04446858f, 0.00177678f, 
    -0.04662242f, 0.03525778f, -0.04929728f, 0.05200554f, 0.05980366f, -0.02103297f, 0.01396927f, -0.03683872f, 
    -0.05841701f, -0.03121240f, -0.04987158f, -0.05907195f, 0.27536106f, -0.19308005f, -0.07917689f, -0.03464165f, 
    -0.07069789f, 0.02059698f, -0.19816256f, -0.06020067f, 0.03634347f, -0.00081619f, -0.07237615f, -0.01817440f, 
    0.13021170f, -0.20918816f, 0.02389145f, 0.04734017f, -0.02539967f, -0.09848960f, 0.01527419f, -0.01319561f, 
    0.06633054f, -0.05844747f, -0.03731655f, -0.02967506f, -0.02565724f, 0.00573575f, -0.12723659f, 0.07233074f, 
    -0.00720490f, 0.03480168f, 0.09742397f, -0.13967624f, -0.04777799f, -0.04224665f, -0.02205438f, -0.02930852f, 
    0.14659879f, -0.05890706f, 0.03364293f, 0.01754850f, -0.01186066f, 0.01717494f, 0.00796428f, 0.01035734f, 
    0.06438746f, 0.09211061f, 0.03401987f, -0.00491473f, 0.09942479f, 0.15327244f, 0.08166965f, -0.10750508f, 
    -0.08827929f, -0.03470567f, -0.08239049f, 0.07846289f, 0.00707861f, -0.08618441f, -0.02940590f, -0.02872249f, 
    -0.13316754f, 0.11111273f, -0.04040413f, -0.04864585f, 0.03413113f, 0.07938150f, 0.00573774f, -0.01376025f, 
    -0.02036441f, 0.11519749f, -0.10054827f, -0.04491916f, 0.09171410f, -0.10998191f, -0.14205986f, -0.36033151f, 
    -0.07088015f, 0.04784847f, 0.05371913f, 0.04561436f, 0.10068128f, 0.04946943f, -0.02826541f, -0.03107499f, 
    0.33908480f, 0.05915556f, 0.12515591f, 0.12677868f, -0.15545650f, -0.17076537f, 0.04442059f, 0.06604148f, 
    0.04723312f, -0.00017595f, -0.08048530f, -0.00242237f, 0.19012095f, 0.01670144f, -0.04504550f, -0.09009673f, 
    0.03007239f, -0.10685374f, 0.04245440f, -0.07951979f, -0.00902230f, -0.06315454f, 0.08703293f, -0.02163267f, 
    0.13176110f, -0.06775256f, -0.02520167f, 0.06640773f, 0.07266657f, -0.05050219f, -0.00459243f, -0.05020777f, 
    -0.03413147f, -0.05269822f, 0.07362998f, 0.01589760f, -0.11437146f, 0.13838466f, -0.28151047f, -0.05359225f, 
    0.00500036f, 0.10399862f, -0.00922791f, -0.08007929f, -0.05519580f, 0.01147308f, 0.04760874f, 0.01351367f, 
    0.12597607f, 0.02806435f, -0.01546881f, 0.18225320f, -0.13601655f, -0.08652077f, -0.01249162f, -0.10489684f, 
    -0.12127677f, -0.04908145f, -0.03187488f, -0.02138471f, 0.03219502f, 0.10927585f, -0.08107381f, 0.14456530f, 
    -0.02083988f, 0.09481707f, -0.01545264f, -0.10929213f, -0.03596111f, -0.00979677f, 0.00023025f, 0.01771856f, 
    0.08308735f, 0.13547251f, -0.02842384f, -0.04739131f, -0.01082066f, 0.05046597f, -0.06302184f, 0.12307832f, 
    0.07353876f, 0.04100029f, -0.01274644f, -0.10069850f, -0.39639372f, -0.14541814f, -0.07901607f, -0.00378351f, 
    -0.01376457f, -0.10294478f, 0.09108304f, -0.10389654f, 0.03660004f, -0.10876489f, -0.06742016f, 0.03171883f, 
    0.06026683f, 0.05709807f, 0.11349448f, 0.01167370f, -0.02811607f, -0.14141956f, 0.06005039f, 0.02404231f, 
    -0.04516171f, 0.03044893f, -0.08746643f, -0.08509329f, 0.08097812f, 0.12094713f, 0.05887603f, 0.01893872f, 
    -0.12807292f, -0.00963720f, -0.01651035f, -0.03032632f, -0.00883910f, 0.06504421f, -0.07309914f, 0.04763948f, 
    0.03297505f, -0.01737712f, 0.03778405f, 0.10875490f, 0.02498100f, -0.09741164f, 0.00988884f, 0.05680716f, 
    -0.03918078f, -0.08507744f, 0.05588632f, -0.02583999f, -0.18874462f, -0.03593772f, -0.38985932f, -0.00521745f, 
    -0.00530523f, 0.14655387f, -0.04882805f, -0.10562548f, 0.02668911f, 0.02354967f, -0.13324451f, 0.06382050f, 
    0.30436972f, 0.19567436f, -0.00786886f, 0.06397355f, 0.00668881f, 0.10914656f, -0.00026726f, -0.07582191f, 
    -0.04258060f, 0.15607318f, 0.04453278f, 0.05426768f, -0.51695073f, -0.20203228f, -0.06927440f, -0.03265714f, 
    0.00742445f, -0.02092596f, 0.00166595f, 0.05465750f, -0.00567004f, -0.07740454f, -0.08916524f, 0.06982106f, 
    -0.12104986f, -0.16848803f, -0.09822475f, -0.12880738f, -0.05907159f, -0.02650853f, 0.00003122f, 0.09450722f, 
    -0.10301423f, 0.00029537f, -0.06300423f, -0.04592559f, 0.40970546f, 0.27931744f, 0.13809118f, -0.15157525f, 
    0.00953453f, 0.07287537f, 0.08021744f, 0.12624079f, -0.00045419f, -0.08179950f, -0.00481069f, -0.07159930f, 
    0.19091819f, -0.09772035f, -0.03975226f, -0.08571938f, -0.06913733f, 0.01342243f, -0.02679324f, -0.02840503f, 
    0.04222567f, 0.06147212f, 0.03635716f, 0.05589752f, -0.11394560f, -0.27271098f, -0.09330352f, 0.01346531f, 
    -0.05839525f, -0.07514254f, 0.13444990f, -0.03790047f, -0.03200091f, 0.04924342f, 0.05919972f, 0.01032099f, 
    -0.10598090f, -0.12481967f, 0.00981637f, 0.11194306f, -0.03773678f, -0.01403308f, 0.08074367f, 0.04499946f, 
    -0.03565453f, -0.08106014f, 0.01409343f, 0.11281702f, -0.41508213f, 0.23056993f, 0.03510031f, 0.04955202f, 
    0.04567475f, 0.03509559f, 0.01125940f, 0.02825616f, -0.03951560f, -0.05199825f, -0.05882447f, -0.05152331f, 
    -0.20237547f, -0.12673828f, -0.05110040f, 0.10533410f, -0.00617251f, 0.01464248f, 0.00410204f, 0.00508290f, 
    0.01080402f, 0.02352194f, -0.02017195f, -0.06186635f, 0.26302803f, -0.53059262f, 0.07533383f, 0.09205925f, 
    -0.07528953f, 0.05786260f, 0.07964829f, 0.05307231f, 0.08156891f, -0.11084247f, -0.01405948f, 0.08829328f, 
    0.01249859f, -0.03304664f, -0.02460358f, -0.23387787f, -0.13230123f, -0.08690706f, -0.02834554f, 0.03882780f, 
    -0.00473322f, -0.07394507f, 0.02988109f, 0.02695699f, 0.12946370f, 0.10313721f, -0.02585976f, -0.13375390f, 
    -0.06018171f, -0.05795094f, 0.01937103f, -0.02411661f, 0.04827407f, -0.00031805f, -0.01602967f, 0.11737105f, 
    -0.22612922f, -0.08447273f, 0.06716332f, 0.04890529f, -0.07153072f, -0.02292730f, 0.01149283f, -0.04640874f, 
    -0.00850825f, -0.02687602f, 0.05510375f, -0.00326872f, -0.08791599f, -0.23837812f, -0.04921114f, -0.09542094f, 
    0.01505119f, -0.01317782f, 0.02020968f, -0.09926132f, 0.05272643f, 0.03137063f, 0.01520487f, 0.01452913f, 
    -0.30960369f, 0.18372506f, 0.03140856f, 0.10285185f, 0.04622906f, -0.00580419f, 0.00398367f, 0.02545305f, 
    -0.05711805f, -0.04768991f, 0.04492521f, 0.06086742f, -0.30577326f, 0.23995656f, -0.04216314f, -0.25693053f, 
    -0.08856799f, -0.09082750f, 0.01741755f, 0.00031057f, -0.05871654f, -0.05487828f, -0.03736224f, -0.03200737f, 
    -0.05436428f, 0.04835590f, 0.08886053f, 0.17577174f, -0.05459810f, 0.06856967f, 0.14916998f, -0.00053551f, 
    0.00040906f, 0.02886178f, -0.12089298f, -0.08090388f, 0.18485551f, 0.01499242f, -0.02632977f, -0.06677710f, 
    0.02408219f, 0.07743301f, -0.02519746f, 0.03590633f, 0.02366372f, -0.01481922f, 0.09389549f, -0.13690777f, 
    -0.68779343f, -0.34305939f, -0.02132836f, 0.20951557f, -0.06328310f, 0.01847717f, 0.00045581f, -0.05610323f, 
    -0.05967114f, -0.04841772f, 0.09985657f, -0.16061027f, -0.18754561f, -0.40577191f, -0.05718783f, -0.03975794f, 
    -0.00605208f, -0.02409931f, -0.03533548f, -0.02075327f, 0.03285545f, -0.03346230f, 0.00305090f, 0.12372361f, 
    -0.02351191f, -0.14896020f, -0.02252733f, -0.01426085f, -0.04372328f, -0.05075208f, 0.01786204f, 0.06842898f, 
    -0.10199036f, 0.07959249f, -0.12592602f, 0.07051271f, 0.04469783f, 0.14984691f, 0.12803379f, 0.00254697f, 
    0.06995846f, 0.02000253f, -0.09101560f, 0.06839558f, 0.03035071f, -0.07769562f, 0.04076898f, 0.08464531f, 
    0.05903845f, 0.04557231f, -0.06866275f, 0.03922297f, -0.06340211f, 0.07616097f, 0.04192618f, 0.04676221f, 
    -0.00065364f, 0.06794133f, -0.05938579f, 0.05687495f, -0.00413739f, 0.02182867f, -0.02977891f, 0.05755375f, 
    -0.05486422f, -0.08099546f, -0.02451723f, -0.06662297f, -0.06521741f, 0.05538373f, -0.03764037f, 0.08346306f, 
    0.32173949f, 0.13647039f, -0.14358442f, 0.03676447f, 0.00107627f, 0.05412911f, 0.01598814f, 0.12274342f, 
    0.00949981f, -0.11452645f, -0.09753750f, -0.02073702f, -0.06619237f, 0.03376058f, -0.01695691f, 0.10928093f, 
    -0.08838626f, -0.01108677f, 0.00984774f, -0.05879068f, -0.00860824f, 0.14685604f, 0.01613527f, -0.09321554f, 
    0.20018364f, -0.11055633f, 0.03139080f, -0.04027366f, -0.02128775f, -0.09293478f, -0.01960337f, 0.00259339f, 
    -0.03488771f, 0.01039539f, -0.03691756f, 0.05749391f, -0.26345459f, 0.03146359f, -0.10202453f, -0.14681758f, 
    0.02867264f, 0.07851260f, 0.02416541f, -0.06061880f, -0.00330445f, -0.10459068f, 0.10256234f, -0.02607353f, 
    -0.01958867f, -0.02334230f, 0.13681445f, 0.09123667f, -0.08395596f, 0.08967127f, -0.12086111f, 0.11458049f, 
    0.02849995f, -0.04201544f, 0.02619933f, -0.07862080f, 0.12815605f, -0.03917893f, -0.03518259f, -0.02955644f, 
    0.03259146f, 0.06268425f, -0.04848036f, -0.02579607f, -0.02041445f, -0.01151404f, 0.13208073f, -0.02143308f, 
    0.39488661f, -0.40804857f, -0.25352305f, 0.18753408f, -0.02230410f, -0.10931788f, -0.04537308f, 0.01241733f, 
    -0.04867417f, 0.07862970f, -0.04428247f, -0.03431096f, 0.16110328f, -0.00809685f, -0.11691064f, -0.04138678f, 
    -0.14229071f, 0.02104894f, 0.04891133f, -0.05874655f, 0.01381893f, -0.08654371f, 0.02068061f, 0.04549015f, 
    0.08833259f, 0.14796908f, -0.17418644f, 0.11122090f, -0.05615658f, 0.12032915f, 0.18330264f, 0.07985204f, 
    0.03141193f, -0.00035989f, 0.06541954f, -0.02817927f, -0.09968649f, -0.03768138f, -0.04536654f, -0.07673012f, 
    -0.01325649f, -0.09791156f, 0.01850947f, -0.03949163f, -0.02812628f, -0.05216617f, 0.00251884f, -0.09306566f, 
    -0.09012688f, 0.12943847f, -0.08925211f, -0.03055716f, -0.01254176f, -0.00175455f, 0.08820592f, 0.04436049f, 
    0.01221952f, -0.06346095f, 0.04715249f, 0.06728358f, -0.08985877f, -0.11723059f, -0.02125213f, -0.09477053f, 
    -0.03838851f, -0.02807873f, -0.06995918f, 0.05034941f, -0.03552693f, 0.11739725f, 0.08051928f, 0.01282295f, 
    0.13985731f, -0.15321688f, -0.03833273f, 0.08530018f, 0.04019805f, 0.08117855f, 0.05040777f, -0.08976638f, 
    0.03533828f, -0.13333495f, -0.02265711f, 0.04633605f, -0.11160315f, 0.17226779f, 0.22492382f, 0.03592077f, 
    0.07152060f, 0.00529332f, -0.08633260f, -0.00677774f, 0.00689661f, 0.01840495f, -0.12116367f, -0.02423421f, 
    0.16302142f, 0.00602081f, -0.00826666f, 0.08093926f, 0.04872380f, -0.12309530f, -0.01971403f, 0.10343626f, 
    0.03205879f, -0.00214207f, 0.02849485f, -0.06046472f, 0.04675046f, -0.08790498f, -0.08660179f, -0.01052025f, 
    -0.06902350f, -0.01992722f, 0.07127390f, 0.05767054f, -0.11407451f, -0.00990091f, 0.07257903f, 0.00401985f, 
    0.15131670f, 0.17310457f, 0.20863588f, 0.20836845f, 0.02536541f, -0.01157879f, -0.06646860f, 0.04574332f, 
    0.04118295f, -0.00319240f, 0.02852437f, -0.04824939f, -0.20352176f, -0.09963609f, -0.14158940f, 0.08258372f, 
    -0.09479781f, 0.04303719f, 0.04841201f, -0.02079038f, -0.05164442f, 0.01995811f, 0.02637513f, 0.04706976f, 
    0.08070278f, 0.20344040f, 0.14851783f, 0.01513507f, 0.00571914f, -0.06373705f, -0.04256322f, -0.00472477f, 
    -0.01454397f, 0.06788193f, -0.02419317f, 0.02892820f, -0.12472023f, 0.06866533f, 0.08668803f, -0.12866394f, 
    -0.08970600f, 0.00188905f, 0.05821236f, -0.04246758f, -0.06339271f, 0.03510842f, 0.01629525f, -0.05529154f, 
    0.12046468f, -0.09148041f, -0.08768532f, 0.09462120f, 0.05430308f, -0.00663634f, 0.13395038f, 0.03121362f, 
    -0.04127917f, -0.00567251f, -0.08295475f, -0.08592625f, 0.21818990f, 0.08362955f, -0.03871036f, -0.02504194f, 
    -0.02903511f, -0.06565382f, 0.07746750f, 0.08372617f, -0.03065167f, -0.00262835f, 0.10781931f, -0.01213934f, 
    -0.18965246f, -0.10832252f, 0.19740772f, 0.16428964f, 0.00955436f, -0.03395990f, -0.11160520f, 0.03133677f, 
    0.02255332f, -0.00616032f, -0.05806088f, 0.06619242f, -0.10721080f, 0.09580765f, 0.07512841f, 0.12396045f, 
    -0.17512299f, 0.08871175f, 0.00966406f, -0.06656066f, -0.04908396f, 0.10489846f, 0.07984149f, -0.10749274f, 
    -0.34422308f, -0.06012691f, -0.16218448f, -0.13561669f, 0.02614558f, -0.00325685f, 0.04981487f, 0.07169887f, 
    0.02823134f, 0.12242474f, 0.06572761f, -0.02500469f, -0.02024755f, -0.02982099f, -0.18997708f, -0.07392653f, 
    -0.11650895f, -0.01541520f, -0.07593871f, -0.17365955f, 0.04224150f, -0.10249965f, 0.01913991f, 0.11992707f, 
    0.09277882f, -0.33851844f, -0.23056771f, 0.21059094f, 0.03948743f, 0.03174723f, 0.01703201f, 0.02095759f, 
    0.08954980f, -0.00860086f, -0.06900446f, 0.03187403f, 0.05083189f, 0.15724668f, 0.13698027f, 0.04661373f, 
    0.08723199f, -0.00089166f, -0.16056690f, 0.00598741f, 0.01819571f, 0.05491256f, -0.01514911f, 0.03366728f, 
    -0.01390789f, 0.02162438f, -0.03922452f, -0.12164427f, -0.08583801f, -0.02731679f, -0.05866873f, 0.04729009f, 
    -0.09536565f, 0.01810667f, -0.09868344f, 0.12737051f, 0.11511873f, -0.11864057f, -0.04654356f, -0.02765452f, 
    0.04464364f, 0.04190568f, 0.00948029f, 0.03814282f, -0.02394463f, 0.00711639f, -0.04592022f, 0.10541914f, 
    -0.27873132f, -0.00721716f, -0.19738401f, -0.10469439f, -0.09205620f, -0.03315751f, 0.00614609f, -0.00110655f, 
    0.03023884f, -0.03970563f, 0.03586739f, -0.01700602f, -0.27658278f, -0.26045766f, -0.02106961f, 0.02493812f, 
    0.07064836f, 0.04852569f, -0.04298349f, -0.06452439f, -0.04283456f, -0.09748325f, 0.06507785f, -0.10876743f, 
    -0.18126741f, -0.15867139f, -0.22241634f, -0.21020170f, 0.03545539f, 0.07123117f, 0.06545267f, 0.01488756f, 
    0.03548525f, -0.10255270f, 0.06752183f, -0.00631291f, -0.30214369f, 0.17482828f, 0.05250083f, 0.08087815f, 
    0.13318796f, -0.06218900f, 0.00046522f, -0.04419925f, 0.13343005f, -0.05949184f, -0.10045193f, -0.02739482f, 
    0.18004318f, -0.01925515f, -0.03473146f, -0.02150012f, -0.09886672f, -0.05461478f, -0.03569815f, -0.06296229f, 
    0.03780184f, -0.04109578f, 0.01328695f, -0.04949115f, -0.02619483f, -0.00199044f, -0.18671459f, 0.01311698f, 
    0.01984025f, -0.05708186f, 0.11428297f, 0.05531132f, -0.02985821f, 0.05319099f, -0.03614796f, -0.02557575f, 
    -0.06101739f, -0.17628458f, -0.15024501f, 0.01259542f, 0.20094989f, -0.01541506f, -0.01244437f, -0.01747455f, 
    -0.06487302f, 0.03291855f, -0.00778779f, -0.05085215f, 0.01304263f, -0.24642055f, -0.21965198f, 0.10706162f, 
    0.04157870f, -0.01610529f, 0.02517037f, -0.00793843f, -0.12345807f, -0.02020361f, 0.02309783f, 0.06405632f, 
    -0.05629978f, 0.24820079f, 0.01329689f, 0.18844831f, -0.02340157f, -0.02729300f, 0.10538521f, 0.08989911f, 
    -0.02384971f, -0.03871944f, -0.01117763f, -0.03959678f, -0.06958205f, -0.20001593f, 0.09682215f, 0.07067542f, 
    -0.10075829f, 0.04183271f, -0.03942177f, -0.02594074f, 0.06009247f, 0.07071062f, -0.03620158f, -0.02154633f, 
    -0.07357692f, -0.01715714f, -0.06843428f, -0.00936098f, 0.06143035f, 0.02253349f, -0.02695327f, -0.01523559f, 
    -0.15238596f, -0.08360900f, 0.04447164f, 0.04247301f, -0.08550954f, 0.12446672f, -0.04598262f, -0.01062520f, 
    -0.09317166f, -0.06014689f, -0.03851826f, 0.06797843f, 0.02115637f, 0.06399818f, 0.06256374f, -0.06480848f, 
    -0.09488244f, -0.11537415f, -0.10612967f, -0.00269278f, -0.11522581f, -0.06837433f, 0.02041494f, 0.04937054f, 
    -0.02755988f, -0.05708164f, -0.07706015f, -0.02795824f, 0.26281345f, 0.28128198f, 0.01090443f, -0.04387737f, 
    0.04061542f, -0.13785909f, 0.10864270f, -0.13045514f, -0.01752766f, -0.08271068f, -0.01733250f, -0.02393074f, 
    -0.04145694f, 0.02031312f, 0.09804691f, -0.03710601f, 0.07127869f, 0.09706911f, -0.05648116f, -0.09065945f, 
    -0.09558079f, 0.08404358f, 0.05063090f, -0.00061265f, -0.05097311f, 0.16902715f, -0.01746669f, -0.05511734f, 
    0.04570892f, -0.01058422f, 0.02261426f, 0.06018753f, -0.12922426f, 0.03687030f, 0.04319491f, 0.15813513f, 
    0.00425287f, -0.16923356f, 0.11295416f, -0.07018162f, 0.04211058f, 0.16222121f, -0.04260600f, -0.01926418f, 
    0.15513614f, 0.22365527f, 0.08743882f, 0.04596843f, -0.19166747f, -0.06051093f, 0.22120991f, -0.08563602f, 
    0.06926897f, -0.00433584f, -0.06292322f, -0.00126021f, -0.09142120f, 0.04690016f, -0.01589409f, -0.05179720f, 
    0.01312996f, -0.13661559f, -0.09059370f, 0.03712212f, 0.08592849f, 0.02120448f, 0.06211099f, -0.01766607f, 
    -0.01380649f, 0.02234653f, -0.09137616f, 0.08216958f, -0.10023123f, 0.02894543f, 0.07587719f, -0.03054437f, 
    -0.24098048f, 0.08587071f, 0.01360591f, -0.10824266f, 0.00857326f, 0.05583966f, -0.02319007f, -0.04746556f, 
    0.11881438f, 0.10001360f, 0.00042384f, 0.20113124f, 0.02597669f, 0.01878843f, 0.04186620f, 0.09132050f, 
    -0.04911509f, 0.11520109f, -0.06091959f, -0.07092378f, 0.18927434f, -0.03109792f, -0.06347077f, 0.28521147f, 
    -0.07471580f, -0.10428910f, 0.02209935f, 0.05242775f, -0.00566832f, -0.16793291f, 0.01083356f, 0.06050199f, 
    -0.23252667f, 0.02041472f, -0.01352975f, -0.17982338f, 0.07642612f, 0.03988661f, 0.00806175f, 0.06741223f, 
    0.02088524f, 0.01187497f, -0.02982936f, 0.04645193f, 0.22900467f, 0.10195046f, -0.01178796f, 0.08897924f, 
    0.09425583f, -0.01736708f, 0.07461184f, -0.03055377f, 0.00171793f, 0.02349695f, 0.03002419f, 0.02868111f, 
    0.10976717f, -0.12514587f, 0.01136083f, -0.06044567f, -0.07795278f, 0.10690074f, -0.07560957f, -0.00317418f, 
    -0.00874551f, 0.05547092f, -0.02342074f, 0.14915919f, -0.17677593f, -0.12707838f, 0.05427245f, 0.17418511f, 
    0.06758217f, -0.03697385f, 0.12780885f, 0.03845185f, -0.04098909f, 0.07837706f, 0.00621312f, 0.05200675f, 
    -0.10104346f, 0.05743803f, 0.10471967f, 0.16310076f, 0.02433007f, 0.15769140f, -0.08185053f, -0.12343839f, 
    0.07199122f, -0.00101070f, -0.09021414f, 0.04554837f, 0.04072232f, -0.01650584f, 0.01351284f, -0.16240130f, 
    -0.00718914f, -0.03199138f, 0.10901976f, -0.04134011f, 0.01281194f, -0.07126039f, 0.03577381f, 0.15045314f, 
    -0.50193661f, -0.05206843f, 0.06228244f, 0.06889369f, -0.07046200f, -0.04183795f, -0.01717799f, 0.02814531f, 
    0.13224865f, -0.01064933f, -0.01338856f, -0.08788790f, 0.30128720f, 0.16467254f, 0.02509173f, 0.08695479f, 
    -0.06056105f, 0.02193355f, 0.02819846f, 0.01337492f, -0.05139787f, -0.00697797f, -0.05363968f, -0.00200156f, 
    0.04432696f, -0.09343809f, 0.20276055f, -0.06010645f, -0.08241146f, 0.18391430f, 0.07544584f, 0.01253618f, 
    0.08243589f, 0.03571531f, -0.03785558f, 0.02988046f, -0.12562257f, -0.13355240f, 0.05165999f, -0.17084084f, 
    0.02571938f, 0.00893784f, 0.12339289f, 0.05042374f, -0.15299782f, 0.00888270f, 0.04231982f, -0.05327610f, 
    -0.05645734f, -0.10944305f, -0.00886881f, 0.15689473f, -0.06235280f, -0.00501808f, 0.12655342f, 0.01407677f, 
    -0.00942701f, 0.06190078f, 0.04989490f, -0.08167887f, 0.08060654f, 0.07676546f, 0.00762227f, 0.15200257f, 
    0.06234585f, 0.08883825f, -0.00352883f, 0.06388991f, -0.00153445f, 0.03919790f, -0.06013668f, 0.13379395f, 
    0.02930687f, -0.07794712f, -0.05412734f, 0.12681699f, -0.00456980f, 0.07520700f, 0.10218292f, -0.03471636f, 
    -0.07554976f, 0.03212296f, -0.05158992f, 0.04017031f, 0.09265874f, -0.10515783f, -0.23125596f, -0.00064669f, 
    -0.08515909f, -0.02543418f, 0.03974647f, -0.05801245f, -0.03452076f, -0.02499466f, -0.04381468f, 0.03003555f, 
    -0.34969571f, 0.02830729f, -0.07780790f, 0.01623723f, 0.08037608f, -0.03017540f, 0.10597970f, 0.13564593f, 
    -0.01902936f, -0.05905684f, 0.01660315f, 0.08858237f, 0.59320521f, -0.27495441f, -0.17095967f, -0.03135540f, 
    0.01592865f, -0.03522161f, 0.00154520f, -0.01625274f, -0.04041342f, -0.02991086f, 0.11448907f, -0.04950399f, 
    -0.12879016f, 0.04133776f, 0.11949618f, 0.02221635f, 0.07746964f, 0.00964453f, -0.13624543f, -0.02447250f, 
    0.02051337f, 0.09036196f, -0.05742996f, 0.10667302f, -0.04659503f, 0.02066542f, -0.12382112f, -0.00864885f, 
    0.05469095f, -0.03287536f, -0.01559754f, -0.00717031f, -0.15794080f, 0.04256379f, -0.09357316f, -0.00537025f, 
    0.04723004f, 0.26546761f, 0.07375169f, -0.05752327f, -0.06083199f, -0.03116343f, -0.00077987f, -0.01596283f, 
    0.05235614f, -0.03654103f, 0.00484559f, -0.04136458f, -0.14486746f, 0.05438946f, -0.06373878f, 0.21450967f, 
    0.06707130f, -0.06196710f, 0.02772269f, 0.09634484f, 0.11376040f, 0.09672066f, 0.02974516f, -0.04558446f, 
    -0.09678835f, -0.16207615f, 0.01889988f, 0.13362242f, 0.00538424f, 0.11495364f, -0.00401787f, 0.03205774f, 
    0.00448518f, -0.03566035f, 0.05644334f, 0.01890999f, -0.20365484f, 0.05658034f, 0.01826524f, 0.15331502f, 
    -0.04678202f, 0.09929223f, -0.00215920f, -0.03480424f, 0.03969411f, -0.03680267f, 0.05088173f, 0.06709571f, 
    0.16233431f, -0.14845116f, -0.16287705f, -0.10928837f, 0.00753201f, 0.22992347f, -0.02309384f, -0.12674405f, 
    0.08545019f, -0.04081252f, 0.01245296f, -0.05300095f, -0.06951813f, -0.06316507f, 0.19710676f, 0.14661498f, 
    -0.02135847f, 0.09882518f, -0.05414061f, -0.03473428f, 0.06810829f, 0.11235946f, 0.10838524f, 0.03363351f, 
    0.24287485f, 0.00377542f, -0.03069512f, 0.13675401f, -0.02942173f, 0.02280568f, 0.11042311f, 0.05324012f, 
    0.01462774f, -0.11621357f, 0.00456058f, 0.03194619f, -0.42759386f, 0.02674256f, 0.23777322f, 0.08537412f, 
    -0.01081084f, -0.09420846f, -0.00676570f, -0.01237645f, -0.04689391f, -0.08859295f, -0.02505939f, 0.18917669f, 
    0.14446954f, 0.27166861f, -0.15791465f, -0.27311730f, 0.03089448f, -0.07436060f, 0.00912478f, 0.05257637f, 
    -0.04697523f, 0.02871643f, 0.06281173f, -0.05740186f, -0.56844616f, 0.02639424f, 0.07409590f, 0.17524393f, 
    -0.00113568f, 0.04292350f, -0.12249105f, -0.00530504f, -0.12398780f, 0.04025541f, -0.01864486f, -0.01929905f, 
    -0.41143534f, 0.15563078f, -0.05336257f, -0.09441422f, -0.10990987f, 0.07457826f, 0.02975969f, -0.03186460f, 
    -0.02655608f, 0.13262659f, -0.04428356f, 0.04009176f, -0.21442395f, -0.02903427f, -0.01897736f, -0.13882023f, 
    -0.07821690f, 0.07801948f, 0.08782957f, 0.05789599f, 0.02787816f, -0.04250364f, -0.00758449f, -0.03787374f, 
    0.07626253f, -0.11367100f, 0.15084326f, -0.03496267f, 0.00206383f, -0.04611555f, -0.00386488f, 0.03417258f, 
    -0.02163825f, -0.11445158f, -0.00630496f, -0.03695999f, -0.27788597f, -0.11249007f, 0.02489465f, 0.26875946f, 
    0.00717459f, 0.04288824f, -0.00163828f, 0.09469789f, -0.13495021f, 0.12165716f, 0.06580699f, -0.00357947f, 
    -0.18281540f, -0.13430014f, 0.07564840f, 0.02532387f, -0.03826720f, 0.13246331f, -0.09117696f, -0.05047104f, 
    0.06801660f, -0.21600601f, -0.03963071f, -0.15469953f, -0.18934862f, 0.13165607f, -0.00651316f, -0.31214958f, 
    -0.09214520f, 0.00559062f, -0.00471035f, 0.00223723f, 0.08186082f, -0.10026462f, -0.06751058f, 0.06874238f, 
    -0.17594858f, 0.23877652f, -0.02562183f, -0.36802369f, 0.09377130f, -0.00810067f, -0.03118740f, -0.11677894f, 
    -0.09938695f, -0.09944014f, 0.02886214f, 0.00802615f, -0.04373490f, 0.04704228f, -0.11313333f, -0.07198483f, 
    -0.00473016f, -0.01959863f, 0.13318296f, 0.07851949f, 0.06018043f, 0.05763092f, 0.04339926f, -0.07544993f, 
    -0.14128947f, 0.13054700f, -0.07929554f, 0.01881275f, 0.00978447f, -0.03853305f, 0.11749152f, 0.08420344f, 
    0.02925516f, -0.02983687f, 0.05307581f, -0.06616738f, -0.36843979f, 0.18442982f, -0.02969034f, -0.10342894f, 
    0.01517065f, -0.03201171f, -0.08934455f, -0.00613293f, -0.10690152f, -0.09147219f, -0.12981576f, -0.03574188f, 
    -0.28345519f, -0.08958802f, 0.13869815f, 0.08881453f, -0.15129088f, -0.01067504f, 0.00688671f, 0.03206029f, 
    0.13999325f, -0.08488148f, -0.02436539f, 0.06308225f, -0.20149522f, -0.20687161f, 0.20883541f, -0.26844531f, 
    0.02995288f, -0.02054369f, -0.14519122f, 0.07104899f, -0.02647024f, -0.12754241f, -0.03039977f, 0.08094557f, 
    -0.51968521f, 0.11697634f, 0.16252860f, 0.14337185f, 0.07411647f, -0.00137420f, 0.04343311f, 0.01127218f, 
    0.03676218f, 0.05456334f, 0.11324013f, -0.07202271f, -0.29879498f, -0.22523390f, -0.06736913f, -0.22156219f, 
    0.06894518f, 0.01804994f, -0.04663593f, -0.23500587f, 0.06166872f, -0.02194422f, -0.09513697f, -0.14377809f, 
    0.24282710f, -0.12193608f, -0.22730817f, -0.01975325f, -0.02499630f, 0.00115071f, 0.03943432f, 0.02540314f, 
    -0.06158593f, -0.05756021f, 0.04195139f, -0.12301751f, -0.18180564f, -0.14024353f, 0.21356001f, 0.20703483f, 
    -0.06716989f, -0.10161841f, 0.07227354f, -0.11464415f, -0.03040431f, -0.01051390f, -0.04174434f, -0.12498238f, 
    -0.26682177f, 0.19239442f, -0.03444720f, -0.17567946f, 0.08918601f, 0.07551496f, 0.15461712f, -0.01703391f, 
    0.10283417f, 0.12105778f, -0.22477859f, -0.13563293f, -0.25877833f, -0.02794574f, -0.08729757f, 0.02371394f, 
    0.02309640f, -0.01350084f, -0.07149334f, 0.20524828f, 0.16555884f, 0.03647561f, 0.11540955f, 0.01166072f, 
    -0.01563278f, 0.01908271f, 0.10312769f, 0.13873176f, 0.00709197f, 0.01912093f, 0.18214224f, -0.13341875f, 
    -0.10311621f, 0.22335449f, -0.19965371f, 0.20332073f, -0.20561612f, 0.15761751f, 0.32069623f, -0.12692280f, 
    0.16962151f, 0.05490036f, 0.09620259f, -0.11008508f, -0.03905256f, 0.05616727f, 0.09674010f, -0.02772670f, 
    -0.26080605f, 0.01381881f, -0.03636285f, 0.04446330f, 0.01083593f, 0.06746446f, 0.04790896f, 0.07160199f, 
    0.23940057f, 0.24103424f, 0.02187032f, -0.01278120f, 0.10315255f, -0.21747524f, -0.00983789f, -0.09675469f, 
    0.04247172f, -0.06282454f, -0.10751325f, -0.03799937f, -0.01197056f, -0.10936669f, 0.10774221f, -0.17421526f, 
    -0.02651137f, 0.04009303f, -0.05456272f, -0.06998743f, -0.01492345f, 0.04679021f, -0.04736710f, -0.05062025f, 
    0.04413679f, 0.05662405f, 0.12543429f, 0.14486310f, -0.03902202f, 0.00376304f, -0.09455780f, -0.09698784f, 
    0.00646597f, -0.04570495f, -0.06330610f, 0.05454591f, 0.05700177f, -0.01404803f, 0.13691549f, 0.05710353f, 
    -0.05174708f, -0.10981187f, -0.00997258f, -0.01217308f, -0.05228181f, 0.07683177f, -0.01443627f, 0.00594408f, 
    -0.02054015f, -0.03075783f, 0.02057576f, -0.14213534f, 0.08413086f, 0.01414141f, 0.21036655f, -0.01620698f, 
    -0.10000988f, -0.04376710f, 0.08734721f, -0.06710201f, 0.01355057f, 0.00109824f, -0.05134188f, -0.05411280f, 
    -0.01619762f, -0.00326707f, 0.01492855f, -0.11193046f, -0.10091107f, 0.00439449f, -0.01543368f, -0.05581176f, 
    -0.06733473f, -0.13399380f, -0.01140610f, -0.02550904f, -0.27046636f, -0.34394851f, 0.23314513f, 0.24606001f, 
    0.02113369f, -0.06032126f, -0.01644293f, 0.04441027f, 0.10177942f, 0.13352625f, -0.05166484f, -0.02564256f, 
    0.20121756f, 0.02354789f, 0.07369599f, 0.12952481f, -0.09292233f, 0.03534842f, 0.07278820f, 0.24498883f, 
    -0.09205323f, -0.07773680f, -0.17539290f, -0.17073891f, 0.05674063f, 0.20586593f, 0.14426322f, -0.08099839f, 
    -0.07262395f, 0.03145208f, -0.16047984f, 0.02889694f, 0.02545955f, -0.08125152f, -0.27756140f, -0.02699436f, 
    0.04845324f, 0.06303970f, 0.03349701f, -0.00335958f, 0.01218239f, -0.09333709f, -0.02677264f, -0.06133078f, 
    0.00353882f, -0.05547117f, 0.08443405f, 0.08587215f, 0.09972323f, 0.09659081f, 0.03722506f, 0.05228809f, 
    -0.07650433f, 0.10211392f, 0.05824567f, 0.04071030f, 0.01457994f, -0.11628839f, 0.13076246f, 0.13821736f, 
    0.02219863f, 0.21774094f, 0.14900652f, 0.02213219f, -0.03910005f, -0.11143602f, -0.00244869f, -0.10368333f, 
    0.05854245f, -0.22649923f, -0.02280484f, 0.06376996f, 0.08882599f, 0.10152874f, -0.05002744f, -0.03217489f, 
    -0.00008582f, 0.02600470f, -0.06079153f, 0.06761487f, 0.01380557f, -0.16918463f, 0.09670004f, 0.08067540f, 
    -0.15536003f, -0.08435288f, -0.08979195f, 0.02649393f, 0.12583205f, -0.13418230f, 0.03219020f, -0.17695034f, 
    0.02810444f, -0.02400640f, 0.06188241f, 0.09858231f, 0.31853566f, -0.18019231f, 0.17982620f, -0.01218403f, 
    0.10546285f, -0.00730048f, -0.02580195f, -0.04955027f, -0.01929001f, -0.02013717f, -0.03069455f, -0.06736208f, 
    -0.00256652f, 0.01056390f, 0.05740436f, 0.04496408f, -0.02559694f, 0.12721826f, -0.09300816f, 0.09146782f, 
    -0.03618148f, -0.02355371f, 0.00651914f, -0.08772659f, -0.03002755f, -0.03581480f, 0.08103040f, -0.00413858f, 
    0.07448746f, -0.00981758f, 0.00008739f, -0.06199551f, 0.08005220f, 0.06403594f, 0.10081989f, 0.02037778f, 
    0.10589223f, 0.03067250f, -0.02033581f, -0.08508352f, 0.02005397f, -0.16078748f, 0.05352682f, 0.14691269f, 
    0.05628996f, -0.05027386f, -0.19882284f, 0.07011160f, -0.19525318f, -0.12174817f, -0.09463801f, -0.17018858f, 
    0.11678058f, 0.13602598f, -0.06920043f, -0.23794264f, 0.07018323f, -0.09136641f, 0.08299056f, 0.05698159f, 
    -0.06985425f, 0.13993667f, 0.10599023f, -0.24165635f, -0.02431516f, 0.03000643f, -0.03117990f, 0.06911572f, 
    -0.00379734f, 0.05662273f, 0.18219988f, 0.01995689f, -0.05944143f, 0.03474266f, -0.00412007f, -0.01913513f, 
    -0.01434755f, -0.03672048f, -0.08610698f, 0.17956936f, -0.01142809f, 0.13185897f, 0.08058591f, -0.19775310f, 
    -0.00651020f, -0.08523799f, 0.10489881f, 0.00992576f, -0.06119218f, 0.02652137f, 0.03367905f, 0.00615215f, 
    -0.05554541f, 0.01062778f, 0.04335852f, 0.06864601f, -0.06964460f, -0.14757079f, 0.08195739f, -0.20997159f, 
    0.02357909f, -0.06141821f, -0.05220646f, 0.03043661f, 0.18306692f, -0.02309357f, -0.04355540f, 0.02243230f, 
    0.07091513f, 0.05711956f, -0.03589196f, 0.12968294f, 0.05969799f, 0.06890671f, 0.07039716f, -0.03743133f, 
    0.06084965f, 0.03609070f, 0.06425929f, 0.03522902f, -0.12683380f, -0.12543491f, -0.04721178f, 0.16652532f, 
    0.02204661f, -0.23915689f, 0.06947462f, 0.08445220f, 0.11749845f, 0.08166173f, 0.03104573f, -0.01729745f, 
    0.02704655f, 0.04410619f, -0.00458979f, -0.08051288f, -0.16496573f, 0.02484982f, -0.16275363f, -0.02903965f, 
    0.01800805f, -0.01120029f, 0.00256789f, 0.06656422f, -0.18202366f, -0.42377016f, -0.13188340f, 0.04433429f, 
    0.02658276f, -0.00609575f, 0.04338684f, -0.15370645f, 0.04867893f, -0.05469286f, 0.01793221f, 0.14133035f, 
    -0.26191762f, -0.06367166f, 0.04760773f, 0.01954260f, -0.02653141f, -0.18317762f, -0.01058521f, -0.03596998f, 
    0.04557224f, -0.04259636f, -0.04726186f, -0.14602610f, -0.00724603f, 0.08088413f, 0.12363110f, -0.01434652f, 
    0.08160663f, -0.00099319f, 0.03850431f, -0.03844916f, 0.03026343f, -0.05783211f, -0.02090729f, -0.13559616f, 
    -0.53782147f, -0.05281789f, -0.15293829f, -0.17925596f, 0.18660657f, 0.01858120f, 0.07418229f, 0.09742019f, 
    -0.00525973f, -0.01868375f, -0.01391070f, -0.07781205f, 0.00009014f, 0.17066754f, 0.19915259f, -0.11305077f, 
    -0.01642076f, 0.09565575f, 0.07198852f, -0.00732533f, 0.15532115f, 0.05739880f, 0.07508694f, -0.05943326f, 
    0.14864349f, 0.13328813f, 0.10115953f, 0.23106165f, -0.03766472f, 0.05698531f, 0.13400099f, 0.03735330f, 
    0.12473211f, -0.04043351f, -0.04675103f, 0.02151002f, -0.02038768f, -0.10478918f, -0.11994232f, -0.17196561f, 
    -0.05292891f, -0.19899127f, -0.02862162f, 0.10865127f, 0.11138539f, -0.05513043f, -0.11238462f, -0.09427227f, 
    -0.05538624f, -0.11713406f, 0.12808453f, 0.12155078f, 0.02923516f, 0.01742156f, -0.05206556f, 0.04660570f, 
    -0.00151409f, 0.04732898f, -0.11466128f, 0.05069556f, -0.43705118f, -0.08418372f, -0.11577034f, -0.10947833f, 
    0.11615862f, 0.05364268f, -0.16688876f, 0.02327376f, 0.04138540f, 0.01536814f, 0.13285084f, -0.01531983f, 
    0.24585252f, 0.17101748f, 0.06977368f, -0.12899534f, 0.05814596f, 0.01125637f, -0.06864835f, 0.00809318f, 
    -0.16555722f, -0.04788330f, -0.01989114f, -0.06272738f, -0.25643182f, 0.01962959f, -0.11944882f, -0.12240310f, 
    0.10403945f, -0.03693442f, 0.00176765f, -0.21629889f, -0.04719063f, 0.06260152f, -0.01580546f, -0.07809943f, 
    -0.15133661f, 0.12377136f, 0.08400771f, -0.36531636f, -0.01646322f, -0.18007481f, 0.09029691f, -0.03151073f, 
    -0.01989183f, 0.03798760f, -0.11447714f, 0.05694956f, 0.10357686f, -0.12138902f, -0.12058056f, -0.01772390f, 
    -0.06120841f, -0.11003940f, -0.18815716f, -0.21867241f, -0.11113156f, 0.04494202f, -0.09805135f, 0.03648738f, 
    -0.00476023f, -0.04888237f, -0.06494087f, -0.22979064f, 0.04716346f, -0.01337897f, 0.04107680f, -0.02864769f, 
    -0.02785825f, 0.05174885f, -0.01747527f, 0.16626248f, 0.13505873f, 0.01236116f, 0.02581989f, -0.08286816f, 
    -0.06171359f, -0.08278208f, -0.04735629f, 0.00584710f, 0.05388902f, 0.03150247f, 0.17309882f, 0.03628890f, 
    -0.10597911f, -0.21220885f, 0.21379532f, 0.16258991f, 0.00478647f, -0.03734751f, 0.00584201f, -0.12570608f, 
    0.02361598f, -0.01259444f, -0.02222135f, 0.08537077f, -0.09140057f, 0.08983959f, -0.13524415f, -0.16866405f, 
    0.04580110f, -0.14366183f, 0.08584632f, -0.03826302f, -0.03539483f, 0.00389220f, -0.04987493f, -0.11794244f, 
    -0.20175634f, 0.01047826f, 0.13324074f, 0.03976280f, -0.03579780f, -0.11063033f, 0.01544597f, -0.01660128f, 
    0.02117343f, 0.03647194f, -0.21073799f, 0.05895432f, 0.04385855f, -0.05269153f, 0.02526397f, -0.04082946f, 
    0.07328990f, -0.00664745f, -0.04707210f, -0.06592675f, -0.09389311f, 0.02935215f, 0.14226019f, 0.06644031f, 
    -0.08010082f, 0.06180999f, -0.00062500f, 0.23455100f, 0.07325128f, -0.07430227f, 0.04302457f, -0.01422491f, 
    -0.11147969f, -0.00453487f, 0.15764783f, 0.09829290f, -0.01034370f, 0.29342750f, -0.16870250f, -0.23144282f, 
    0.01343145f, -0.00548671f, 0.02724031f, 0.10863247f, -0.03612188f, -0.04357002f, -0.08729845f, -0.11207518f, 
    0.05599737f, 0.03950063f, -0.03292711f, -0.04486145f, -0.12003132f, 0.06662283f, 0.04424378f, 0.02175795f, 
    -0.09966467f, -0.07294475f, 0.16474944f, 0.15985207f, -0.27482074f, -0.03255515f, 0.10637324f, -0.13613248f, 
    -0.00523630f, 0.06963295f, 0.12503409f, -0.19078827f, -0.07058854f, 0.11189298f, -0.05911733f, -0.03814406f, 
    -0.06108060f, -0.06605412f, 0.14900976f, 0.13946272f, 0.02224966f, 0.08272141f, -0.03764328f, 0.02536393f, 
    0.03983801f, 0.01589546f, 0.01362900f, 0.04426759f, -0.00105445f, 0.06938884f, 0.00031719f, -0.32250512f, 
    0.10874487f, -0.26907918f, -0.06848341f, 0.09102849f, 0.12417021f, -0.00005295f, -0.15440911f, -0.03439219f, 
    -0.11449240f, 0.20219563f, 0.27444178f, -0.24562585f, 0.00640711f, -0.01030906f, -0.04021286f, -0.01817780f, 
    -0.07428248f, 0.00858295f, -0.02534666f, -0.24540912f, -0.37782550f, 0.09628741f, -0.01120447f, 0.06131400f, 
    -0.11052161f, 0.03923479f, 0.03298679f, -0.08876520f, -0.09449045f, -0.00266887f, 0.05155720f, 0.07846735f, 
    -0.00454937f, -0.08027697f, 0.01140085f, 0.08014286f, 0.00386198f, 0.04049331f, -0.00457630f, 0.03545871f, 
    -0.12662643f, -0.08837056f, 0.02895999f, -0.02467059f, -0.00962278f, 0.00791454f, 0.02095962f, 0.14076811f, 
    -0.08164908f, -0.06766793f, -0.00351362f, 0.13238727f, -0.03893208f, 0.02159843f, 0.08039811f, -0.11996393f, 
    -0.50208855f, -0.06528151f, -0.31721959f, -0.07609489f, 0.09397698f, 0.06646874f, 0.04442468f, 0.17498827f, 
    0.07806279f, -0.09692343f, 0.02988870f, -0.08683024f, -0.01132283f, 0.21678846f, -0.00576785f, -0.08481422f, 
    -0.06477258f, -0.02790884f, -0.09453417f, -0.00414470f, 0.07926103f, -0.05498227f, 0.09987501f, -0.07555009f, 
    0.01064076f, 0.09387523f, 0.13189350f, -0.22350208f, 0.09051563f, 0.04864047f, 0.03170976f, -0.09547864f, 
    -0.05133433f, 0.06080806f, -0.02215705f, 0.16011652f, 0.12632082f, 0.10979836f, 0.05587912f, 0.08345065f, 
    -0.10262228f, 0.04577878f, -0.05067683f, 0.02183846f, -0.10451218f, 0.00707389f, 0.10988961f, 0.07327204f, 
    -0.11586708f, -0.19882581f, 0.15173659f, -0.15985776f, 0.04046484f, -0.11205360f, -0.05541681f, -0.13352346f, 
    -0.10273198f, -0.02031708f, 0.01105023f, -0.05998599f, 0.08231711f, 0.00902543f, 0.03051008f, -0.10922688f, 
    -0.01849613f, -0.06206058f, -0.01081209f, -0.08263751f, -0.08883639f, -0.04297941f, -0.10681342f, 0.03598837f, 
    -0.11736432f, 0.11845100f, 0.01170505f, 0.05341402f, -0.03835749f, 0.08025626f, -0.00893035f, 0.20622422f, 
    -0.07820082f, -0.08250107f, 0.13782766f, -0.19696370f, -0.06478580f, -0.25023499f, 0.04403615f, -0.02582081f, 
    -0.04702534f, 0.02135368f, -0.08450720f, 0.06635420f, 0.09173543f, -0.06967405f, -0.10503226f, -0.17536044f, 
    0.03866505f, 0.09514990f, -0.30218259f, 0.25186127f, -0.00715226f, 0.02166439f, -0.11061892f, -0.07370073f, 
    -0.17624968f, -0.06466471f, -0.02870385f, -0.04569476f, -0.19843641f, -0.02993747f, 0.09927694f, -0.13337810f, 
    0.06343348f, -0.04219056f, 0.04245388f, -0.05023189f, -0.04360753f, 0.11553158f, -0.01411212f, 0.01398221f, 
    -0.01311943f, -0.21500705f, -0.15032613f, -0.10275932f, 0.04955718f, -0.02988864f, -0.00396725f, -0.01322328f, 
    0.16528776f, -0.09283230f, 0.06860486f, -0.06587470f, -0.21424393f, 0.24233910f, 0.14874005f, 0.01127603f, 
    -0.04528172f, 0.11895078f, 0.00282948f, -0.04724258f, -0.06635492f, 0.09290405f, 0.01569342f, -0.04139429f, 
    -0.07252198f, -0.04369652f, -0.10743130f, 0.01055901f, -0.00433860f, -0.01022960f, -0.03435424f, -0.08158205f, 
    -0.09654011f, 0.17669734f, 0.03309352f, 0.18060835f, -0.17007330f, 0.16231655f, 0.11525594f, 0.18805093f, 
    -0.09980154f, 0.14752924f, 0.03777070f, 0.11794417f, 0.03224709f, -0.03541183f, -0.01645025f, 0.00968027f, 
    -0.37459484f, 0.15979461f, 0.03925860f, 0.00981564f, 0.04516798f, -0.06680005f, -0.03845059f, 0.11588068f, 
    0.06820730f, 0.08846731f, 0.02415508f, 0.05480799f, 0.00910783f, -0.16966119f, -0.02924589f, 0.14445990f, 
    0.06765921f, -0.01484132f, -0.02201832f, -0.00804107f, 0.01884041f, -0.04940791f, -0.07534569f, 0.07177355f, 
    -0.11791866f, 0.00020137f, 0.12009101f, -0.17458947f, 0.07073966f, -0.13702735f, 0.02621274f, -0.04899898f, 
    -0.04152020f, 0.07064168f, 0.04689810f, 0.11374609f, 0.11205593f, -0.25380319f, -0.04148279f, -0.09714543f, 
    0.06357148f, 0.10876829f, 0.03410181f, 0.03031135f, -0.03838813f, -0.02872704f, 0.08033766f, -0.02420664f, 
    0.03433533f, 0.08674462f, 0.04143193f, 0.11038497f, 0.05393542f, -0.09684047f, 0.02656877f, 0.04053483f, 
    0.05175721f, 0.02897888f, -0.23426810f, -0.18306884f, 0.09718001f, -0.11645981f, 0.02556782f, -0.04045016f, 
    0.03454782f, -0.09646846f, 0.01691398f, -0.04104779f, -0.08621690f, 0.06305140f, -0.04989281f, -0.12493832f, 
    -0.14848576f, -0.10887209f, 0.05508670f, 0.32472375f, 0.03233802f, 0.11400957f, 0.01505321f, 0.00625212f, 
    -0.04828374f, 0.10415849f, 0.03379791f, 0.09643344f, 0.13979027f, -0.06241338f, 0.13526869f, -0.11430845f, 
    0.12712207f, -0.05234706f, 0.02774683f, -0.04967109f, -0.02128951f, 0.01023141f, -0.11935148f, -0.02926535f, 
    -0.39792624f, -0.00880327f, -0.27523500f, -0.01325399f, -0.01729412f, -0.06415150f, -0.13011463f, -0.06451150f, 
    -0.14027669f, 0.06521662f, 0.03251174f, -0.16040319f, -0.31182924f, 0.13086283f, -0.13532415f, -0.07483501f, 
    -0.19381948f, -0.07521859f, 0.15476526f, -0.05454425f, 0.08460677f, 0.02556655f, -0.06662001f, -0.05028801f, 
    0.16836920f, 0.01971985f, 0.08856278f, -0.00537531f, -0.05443611f, 0.00742342f, -0.01685899f, 0.03100320f, 
    -0.05475479f, 0.02884652f, 0.03957407f, 0.05242305f, -0.12654375f, 0.13943052f, 0.18218076f, -0.20666085f, 
    0.01743210f, 0.11436176f, 0.03092962f, 0.08799987f, -0.12401070f, -0.02555047f, -0.02659836f, -0.01274874f, 
    0.04290539f, 0.06577398f, -0.12107742f, -0.13757323f, 0.03794645f, 0.14789052f, 0.05533420f, 0.01396253f, 
    0.07335609f, 0.08703499f, 0.10336807f, -0.09355063f, -0.18637811f, -0.24715310f, -0.22268435f, -0.01453664f, 
    -0.03198970f, 0.05496538f, 0.03211331f, -0.01471450f, -0.09177382f, 0.09029146f, -0.11751173f, 0.11024220f, 
    0.36247918f, 0.09628766f, -0.11587421f, -0.23538196f, 0.05353272f, 0.04209908f, 0.10588605f, -0.08380131f, 
    -0.01241348f, -0.06241467f, -0.03674984f, -0.02952423f, -0.11706727f, 0.16084790f, 0.00602137f, 0.27244508f, 
    0.08890410f, 0.12052252f, -0.04415858f, -0.07220273f, -0.05652776f, 0.04287475f, -0.05540972f, 0.06614800f, 
    0.05990264f, 0.23520716f, 0.21455379f, -0.18268691f, 0.07096511f, -0.01944707f, -0.03770939f, 0.01219487f, 
    -0.02238590f, -0.03778391f, -0.06311113f, 0.03920022f, -0.12558246f, 0.13132781f, 0.16987009f, -0.37128562f, 
    -0.16912889f, 0.04004653f, 0.06846528f, 0.08275793f, -0.08421434f, -0.04039782f, 0.03381788f, -0.00172162f, 
    0.05961115f, -0.32437122f, -0.26428375f, 0.19655330f, 0.06931456f, -0.08913533f, -0.04764418f, -0.06979395f, 
    0.02981599f, -0.11272527f, -0.01512130f, -0.08952313f, -0.01000235f, 0.04895803f, -0.28260198f, 0.01386359f, 
    0.02799711f, 0.20698562f, -0.07869352f, -0.13711153f, -0.01931380f, -0.09455043f, -0.10429882f, -0.02838523f, 
    -0.09667609f, 0.05092710f, -0.05069438f, 0.06419436f, 0.02508803f, 0.05768808f, 0.06904625f, 0.04461050f, 
    0.04247516f, -0.12044051f, 0.01510329f, -0.00960947f, -0.20453531f, -0.18644664f, -0.01652213f, -0.19279222f, 
    0.10473565f, -0.03576851f, -0.03669995f, 0.04279939f, 0.00350026f, 0.07486530f, 0.03427028f, 0.01128891f, 
    0.23996815f, 0.03046705f, -0.07214003f, 0.28929836f, -0.07435116f, 0.12920770f, -0.02131041f, 0.03312108f, 
    -0.06974795f, -0.05795489f, -0.03079790f, 0.14777419f, -0.13359345f, 0.03381348f, 0.22464393f, -0.02589720f, 
    -0.14837888f, 0.05214815f, 0.03696416f, 0.00792728f, 0.08207838f, 0.06731822f, -0.06884243f, -0.03696823f, 
    0.05734404f, -0.10266045f, -0.05881698f, -0.19622022f, -0.02899325f, -0.00420797f, -0.00446474f, -0.05479521f, 
    0.04767128f, 0.12794830f, 0.04002318f, 0.05201307f, -0.33107474f, 0.01840284f, 0.06799345f, 0.11683785f, 
    -0.03083234f, -0.00857913f, -0.07671884f, 0.02031120f, -0.08112372f, -0.16690116f, 0.02308427f, -0.03875749f, 
    0.06621281f, -0.02318194f, -0.02831042f, -0.26902658f, 0.00117308f, -0.13465190f, -0.06187271f, 0.01668775f, 
    -0.03435875f, 0.02656030f, 0.05266356f, 0.02706441f, -0.13733029f, -0.03873087f, 0.10879984f, 0.05059187f, 
    -0.06861566f, -0.01134606f, -0.03615165f, -0.04304040f, 0.00776827f, 0.03503886f, 0.05834478f, 0.13974351f, 
    -0.00545221f, 0.10077484f, 0.07204951f, -0.09133901f, 0.04281292f, -0.00166272f, 0.09189420f, 0.06216665f, 
    0.07189178f, -0.05360304f, 0.10005683f, 0.07152601f, -0.17675172f, -0.09086516f, -0.05210126f, -0.25620502f, 
    -0.05831469f, 0.04913573f, -0.01530950f, 0.05046770f, -0.04146455f, 0.02336743f, -0.17456335f, 0.03837133f, 
    0.02841019f, 0.09764446f, 0.07213278f, 0.14647734f, -0.05023610f, -0.01330913f, -0.04035729f, 0.09027714f, 
    0.01527924f, 0.10325801f, 0.08981406f, 0.09469876f, -0.11764905f, -0.22254133f, -0.01797097f, -0.13853562f, 
    -0.03343979f, 0.05589817f, 0.03057367f, 0.15128690f, 0.03671347f, -0.12946121f, 0.12089810f, -0.02682650f, 
    0.05779794f, -0.13851343f, 0.01685842f, 0.10192748f, 0.02479914f, 0.08268809f, -0.03603262f, 0.06316363f, 
    0.02371430f, 0.10846101f, -0.01794326f, 0.01304297f, -0.20549135f, -0.02158817f, -0.13475077f, 0.18760054f, 
    0.06444141f, 0.09779803f, 0.02962282f, 0.05330641f, 0.17007469f, 0.00539507f, 0.06468182f, 0.12714340f, 
    -0.10242809f, 0.16377923f, 0.14155819f, -0.32049686f, -0.20982136f, 0.03903539f, 0.00017311f, 0.07464677f, 
    0.03014747f, -0.02221534f, 0.04750508f, -0.10732791f, -0.00325775f, -0.00001411f, -0.05809911f, -0.07726829f, 
    0.03816906f, -0.00130723f, 0.01929004f, 0.07834716f, -0.05413118f, 0.00926371f, -0.12614861f, -0.17556690f, 
    0.12760273f, -0.09304740f, -0.32712623f, 0.09491376f, -0.12775543f, -0.09962834f, 0.13954411f, -0.07634541f, 
    0.15075126f, -0.00528739f, -0.12236062f, -0.16445993f, 0.05774365f, -0.17583010f, 0.15713608f, -0.08107736f, 
    -0.01080006f, 0.07407571f, 0.02878121f, -0.00751213f, 0.01965220f, 0.08091334f, 0.01989608f, 0.08268931f, 
    0.42423871f, -0.10511492f, 0.15061842f, -0.20614095f, 0.01191810f, -0.13526793f, 0.06814762f, 0.10022531f, 
    0.02135948f, -0.09722054f, 0.00752828f, -0.12351040f, -0.03725067f, 0.22553536f, 0.14903304f, 0.04553917f, 
    -0.03481170f, 0.02099407f, 0.10338115f, 0.02625386f, 0.12806237f, 0.03717412f, -0.14779814f, -0.11450706f, 
    -0.02223955f, -0.09035461f, -0.07352675f, -0.10990014f, -0.12576544f, -0.05839896f, 0.01790671f, -0.02803317f, 
    -0.04315423f, -0.01402050f, -0.02319636f, -0.00803518f, -0.09479942f, -0.30736721f, -0.11666660f, -0.15484074f, 
    0.03281149f, 0.02905190f, 0.04405620f, 0.01712869f, -0.07428056f, -0.07009897f, 0.08536163f, 0.12063742f, 
    0.02032887f, -0.00320305f, 0.12641610f, -0.07898752f, 0.09463349f, -0.03771997f, 0.11752485f, -0.03630107f, 
    0.02445260f, -0.09140142f, -0.13583483f, -0.14306816f, 0.31889027f, -0.11805812f, 0.07558812f, -0.03061105f, 
    -0.02291277f, -0.04667447f, -0.00598240f, 0.01843200f, 0.09428177f, -0.12654941f, 0.00009285f, -0.01590354f, 
    0.19607837f, -0.26746809f, -0.17600527f, 0.07852592f, 0.14095138f, 0.05597629f, 0.11633363f, -0.00014300f, 
    -0.02855908f, -0.00447858f, 0.08860864f, -0.19957615f, 0.16946277f, -0.12619430f, 0.10998902f, -0.16196316f, 
    -0.13213049f, 0.08643150f, -0.01603909f, 0.01869596f, -0.10728756f, -0.13060589f, 0.08916529f, 0.15512350f, 
    0.29404891f, -0.52647376f, -0.03578953f, -0.03471800f, -0.04062197f, 0.02890449f, 0.01152057f, -0.03793193f, 
    0.13425055f, 0.00454380f, 0.08351572f, 0.31452852f, 0.02703032f, -0.29078618f, 0.02655957f, -0.02613971f, 
    -0.02899910f, -0.15791039f, 0.02099397f, -0.05665993f, 0.04779356f, -0.04504614f, -0.05936980f, -0.14026725f, 
    0.06254492f, 0.18759814f, 0.04831063f, -0.14022598f, -0.04908756f, -0.07826944f, -0.04956808f, 0.01452065f, 
    -0.00213634f, 0.11246581f, -0.02767005f, 0.14636372f, 0.04411167f, -0.04699581f, 0.08690214f, -0.31030995f, 
    0.06909056f, -0.11809021f, -0.01485511f, -0.02099396f, 0.00838782f, 0.06696157f, -0.01289618f, 0.05018489f, 
    0.04282350f, -0.22045390f, -0.01796298f, -0.15091361f, -0.08591408f, 0.01177552f, 0.03934304f, -0.16133842f, 
    -0.16124067f, 0.00231209f, 0.16067906f, 0.12846027f, -0.05114786f, 0.11558463f, 0.21505281f, 0.40635100f, 
    0.09624229f, 0.13518681f, 0.00829057f, 0.08532375f, -0.07877220f, 0.04080503f, -0.07844992f, 0.00087500f, 
    -0.26229343f, 0.29962158f, 0.13347915f, -0.14908059f, -0.04100296f, -0.02108401f, 0.03341698f, 0.02449606f, 
    0.14113395f, -0.01890468f, 0.06787995f, -0.22039416f, -0.15032054f, 0.12797457f, 0.04457288f, -0.25478652f, 
    0.11329073f, 0.01623965f, 0.03121907f, 0.05075632f, -0.02733082f, 0.05624835f, -0.03363426f, -0.08501083f, 
    0.00868110f, 0.05904317f, 0.16604453f, 0.03715464f, 0.06233792f, 0.05194975f, -0.06548094f, 0.04264208f, 
    -0.02817742f, -0.01648127f, 0.07302239f, 0.04969427f, -0.12182975f, -0.06061736f, 0.00395197f, 0.03281725f, 
    -0.02815122f, 0.00374469f, 0.02940071f, -0.04883562f, -0.01014340f, -0.00634816f, -0.08176403f, 0.00681364f, 
    -0.20676091f, -0.02359417f, -0.01437284f, -0.05015898f, 0.07454158f, -0.06009918f, -0.18155196f, 0.02696794f, 
    -0.05519434f, -0.02208897f, 0.03520590f, -0.01114289f, 0.04921115f, -0.00617957f, -0.03270105f, -0.11460213f, 
    -0.10087271f, 0.00140968f, -0.04354707f, -0.07095964f, 0.06026449f, 0.01004216f, -0.05743033f, -0.01759042f, 
    -0.07289055f, 0.10716790f, -0.02699281f, 0.12760235f, -0.00955232f, 0.00243119f, 0.00567029f, 0.03848753f, 
    -0.01055335f, -0.00078558f, 0.03023249f, -0.04397967f, 0.25818196f, 0.15087092f, 0.03384556f, 0.18624863f, 
    -0.01163698f, 0.02205870f, -0.02073838f, -0.03864872f, -0.12979043f, -0.04780788f, -0.00927786f, 0.01526948f, 
    0.06302942f, 0.11964000f, -0.01637078f, 0.02660834f, -0.09236469f, 0.06212321f, 0.01234262f, -0.02900809f, 
    -0.01369683f, 0.02369898f, -0.07582972f, -0.01550851f, -0.22588322f, 0.01064257f, -0.05895597f, -0.25078937f, 
    0.04554349f, 0.01983628f, -0.10601005f, -0.05888980f, -0.04831162f, 0.02865604f, 0.05556386f, -0.07786341f, 
    -0.23979549f, 0.08520323f, -0.06658246f, -0.01005393f, 0.00394050f, -0.05404880f, -0.04251376f, 0.00457424f, 
    -0.01275259f, -0.04451540f, 0.00780031f, -0.06349248f, 0.06876265f, -0.24502042f, 0.00270873f, -0.01491982f, 
    -0.07045615f, 0.05127036f, 0.00959228f, -0.03876013f, -0.09414499f, 0.00509212f, -0.00835434f, -0.07808929f, 
    -0.29481465f, 0.10527699f, -0.08249605f, -0.00179566f, 0.01037449f, 0.02036715f, -0.05210761f, -0.05284386f, 
    -0.02511702f, -0.00937428f, 0.02460312f, 0.01551918f, 0.10501522f, -0.04892972f, 0.20468429f, 0.24998534f, 
    0.07990376f, -0.06357432f, -0.03434462f, -0.00948590f, -0.04422532f, -0.07627106f, -0.12582634f, -0.08932905f, 
    0.10289668f, 0.04383514f, -0.08269940f, -0.05057311f, -0.01508258f, -0.06605322f, 0.05173367f, -0.09672149f, 
    0.00518108f, 0.00170445f, 0.00208216f, 0.03282915f, 0.01182742f, 0.12074047f, 0.04487893f, -0.09182632f, 
    -0.13536441f, -0.00368532f, 0.04446825f, -0.08520775f, 0.04411401f, 0.07139856f, -0.03876442f, 0.04025542f, 
    0.00738659f, -0.06133646f, -0.03773731f, -0.02508164f, 0.00921983f, -0.10201053f, 0.04457674f, 0.05449809f, 
    -0.05751429f, 0.04380416f, 0.00250603f, 0.00668442f, 0.19046690f, -0.24414968f, 0.10683892f, 0.04704496f, 
    -0.01624612f, -0.08290831f, 0.00452950f, 0.03082400f, -0.00966656f, 0.03763305f, 0.02292975f, -0.04247495f, 
    0.11506760f, -0.10113438f, -0.04630260f, 0.02128566f, -0.03807654f, -0.03924062f, 0.02271825f, -0.05037932f, 
    -0.05488838f, -0.05613237f, -0.01557407f, 0.01503270f, -0.05513873f, 0.16709815f, -0.01238636f, 0.01418730f, 
    -0.04255893f, -0.04732898f, -0.03261452f, -0.00959124f, -0.05168042f, 0.02760265f, 0.06130388f, -0.05083236f, 
    0.10485055f, 0.26372135f, 0.11125259f, 0.15975201f, 0.05793203f, 0.06765073f, 0.10872663f, -0.05920545f, 
    -0.02620421f, 0.06904770f, -0.06425320f, -0.15918060f, 0.07253674f, 0.16902554f, 0.07362131f, 0.27253422f, 
    0.04995843f, 0.00327614f, 0.06068424f, 0.03690139f, -0.03868626f, -0.04252102f, 0.00804548f, 0.00537506f, 
    -0.02897183f, -0.09019355f, -0.08525161f, -0.08076466f, 0.00411846f, -0.07776518f, 0.02609525f, -0.03912147f, 
    0.04426048f, -0.03836598f, -0.06435683f, 0.02426578f, 0.05108813f, -0.07345165f, -0.07246300f, -0.09451807f, 
    0.00306489f, 0.05699708f, 0.00665506f, -0.10380417f, -0.04540078f, -0.01505318f, -0.01113544f, -0.00244325f, 
    0.19648300f, -0.12138683f, -0.04395186f, 0.06793010f, 0.11060952f, -0.03852367f, 0.00860000f, -0.11016437f, 
    -0.00737904f, 0.01334391f, -0.06217237f, -0.01471205f, -0.09107305f, 0.11281423f, 0.15181489f, 0.13154042f, 
    0.14112671f, -0.04319103f, 0.08636718f, -0.03108475f, -0.02988360f, -0.02271896f, 0.08517006f, -0.04302759f, 
    0.14993800f, 0.03012626f, 0.11229908f, -0.08684063f, -0.02422768f, 0.01273557f, 0.00431158f, -0.06723534f, 
    -0.12087079f, -0.03334788f, 0.00273902f, -0.07719928f, -0.08797053f, 0.10230076f, -0.05175142f, 0.13061938f, 
    -0.03394601f, -0.06910793f, 0.04603427f, -0.05038214f, -0.05207720f, 0.01715801f, 0.05254781f, -0.05190247f, 
    0.00478421f, -0.29322454f, -0.15440594f, -0.23413970f, 0.04507121f, -0.01461567f, -0.03414362f, -0.00309045f, 
    -0.04443732f, -0.10948551f, 0.01098112f, 0.05022433f, -0.30977994f, 0.15494253f, -0.12699875f, -0.05707972f, 
    -0.03918208f, -0.04845922f, -0.07180384f, -0.03158263f, 0.03363435f, -0.04541729f, -0.06113565f, -0.13119359f, 
    0.06594182f, 0.12105746f, -0.06453583f, 0.11565901f, -0.02354105f, -0.02012258f, -0.00920013f, -0.01049597f, 
    0.03314431f, -0.03324052f, 0.02654351f, -0.05522621f, 0.21635623f, 0.05478418f, 0.07677200f, 0.11762888f, 
    -0.00406050f, 0.00175832f, 0.04284242f, -0.02974459f, -0.06908604f, 0.05311980f, -0.01560873f, -0.06282014f, 
    0.03921951f, 0.03941416f, -0.05408252f, 0.10190981f, -0.03341475f, -0.01717028f, -0.01304671f, 0.04075199f, 
    -0.00757618f, -0.03491173f, -0.05021588f, -0.00744358f, 0.17166345f, -0.07143848f, 0.13797599f, 0.11814257f, 
    0.08117120f, 0.03418428f, 0.04242639f, -0.02522095f, -0.03188422f, 0.08872120f, -0.02702549f, -0.01817143f, 
    0.06972278f, 0.17763415f, 0.00743056f, 0.30208942f, 0.06836989f, -0.14260508f, -0.04747754f, 0.06372538f, 
    -0.02373024f, 0.08155161f, 0.03845216f, -0.05586258f, 0.21840817f, -0.04011260f, -0.24442118f, -0.02367776f, 
    -0.00280712f, -0.02068556f, -0.07947863f, -0.03538981f, -0.07396726f, -0.06691706f, -0.03306167f, -0.01593241f, 
    0.22433408f, 0.04195535f, 0.19623317f, 0.10202974f, 0.01723292f, 0.01614032f, 0.00579387f, -0.01576582f, 
    -0.05141101f, 0.08045699f, -0.06913766f, -0.04944010f, -0.11709583f, 0.04994393f, -0.04891592f, -0.02269057f, 
    -0.03412964f, 0.05792626f, -0.04272836f, -0.01671730f, -0.03828559f, -0.04757838f, -0.07044047f, -0.05902988f, 
    -0.12753154f, -0.14545417f, -0.04144409f, 0.08343624f, -0.09594622f, -0.00900969f, 0.01739950f, -0.05879030f, 
    0.00077795f, 0.01292824f, 0.00101836f, -0.01927100f, -0.24587083f, -0.02005672f, -0.17894217f, -0.01390006f, 
    -0.04530373f, -0.01058433f, -0.02344134f, -0.03003397f, -0.01194539f, 0.01320286f, 0.03093756f, -0.08213536f, 
    -0.29681209f, 0.17408006f, -0.10879453f, -0.14327787f, -0.05168380f, -0.05609471f, 0.02474883f, -0.07417081f, 
    -0.08293098f, -0.00843886f, 0.00898794f, 0.06952398f, -0.09722914f, 0.00721708f, 0.13177034f, 0.01587384f, 
    0.01569545f, 0.04900371f, 0.01328305f, -0.05136719f, -0.05911830f, -0.08476236f, -0.03513996f, -0.12669159f, 
    -0.00954029f, 0.03647366f, -0.00720135f, -0.05102643f, -0.16754426f, -0.08027661f, 0.00834263f, -0.07153531f, 
    0.00089675f, -0.02832423f, 0.02532515f, -0.06260148f, 0.04927020f, -0.02416218f, 0.17174198f, -0.00847580f, 
    0.06219674f, 0.05756677f, -0.04632814f, -0.08018914f, -0.07214172f, -0.00008848f, 0.01983769f, -0.00580245f, 
    -0.18131080f, -0.08878590f, 0.01409908f, -0.13654082f, 0.03205322f, -0.03542480f, -0.03937682f, 0.00600405f, 
    0.01404420f, -0.02435157f, 0.00103648f, -0.04852898f, 0.00615361f, 0.04320374f, -0.04561356f, 0.07093827f, 
    0.03901210f, 0.00369850f, 0.01012841f, 0.03779755f, 0.06038137f, -0.00067525f, -0.10149282f, -0.02517131f, 
    -0.24729647f, 0.21811475f, -0.03838408f, -0.06837181f, -0.05817198f, 0.01735654f, 0.00510021f, -0.09325013f, 
    -0.10436574f, 0.01556765f, -0.01520134f, -0.06668926f, 0.10284055f, -0.24908142f, 0.14756660f, 0.06733232f, 
    -0.06131028f, -0.06643699f, -0.04272500f, -0.03628613f, -0.06703271f, 0.10542342f, -0.04805938f, 0.02034763f, 
    -0.02553258f, 0.11241172f, 0.05203062f, 0.10675856f, 0.03653270f, -0.04697421f, 0.02129917f, 0.05778472f, 
    0.00508224f, -0.03997555f, -0.00076056f, -0.05044606f, -0.04217988f, 0.01036863f, 0.03694255f, 0.02668338f, 
    -0.08932161f, 0.07898291f, -0.06187747f, 0.08383480f, -0.05293361f, 0.02595483f, -0.01002078f, -0.07798155f, 
    0.11536696f, -0.05292816f, 0.08191878f, 0.06777747f, -0.04858701f, 0.07743488f, 0.01179091f, -0.01378667f, 
    -0.10057440f, 0.06306028f, 0.03570432f, -0.00227437f, -0.16500357f, 0.03380297f, -0.06080831f, -0.10931163f, 
    0.00973358f, 0.02172316f, -0.01810375f, 0.00922525f, -0.04544863f, -0.04135787f, -0.03482041f, -0.05432848f, 
    0.23431712f, -0.01019788f, 0.12560493f, 0.17626435f, 0.12513565f, -0.01406591f, -0.01921266f, -0.04691458f, 
    -0.03404934f, -0.04171094f, -0.05282785f, -0.05035913f, 0.22905287f, 0.03726509f, 0.15432703f, -0.04720052f, 
    0.03845957f, 0.00481626f, -0.00578863f, -0.01291066f, -0.03656360f, 0.08820774f, 0.00803283f, -0.01393510f, 
    -0.13806157f, 0.04626010f, -0.12359130f, -0.06092709f, -0.07136942f, -0.02694114f, -0.03724988f, 0.00846447f, 
    -0.02680216f, -0.05171024f, -0.07195862f, -0.06675519f, -0.12226094f, 0.02119140f, 0.10826077f, 0.00869863f, 
    0.07301646f, -0.03610371f, -0.05941645f, 0.05146150f, -0.09314509f, -0.05414863f, 0.02692777f, -0.09025963f, 
    -0.03985083f, -0.13981360f, -0.03173255f, -0.03439990f, -0.05901010f, -0.02876802f, -0.05784467f, -0.03951377f, 
    -0.00932521f, -0.02024324f, -0.00751601f, 0.00778426f, -0.01660929f, -0.05007323f, -0.08598594f, -0.07701445f, 
    -0.01826289f, 0.03231876f, -0.05708843f, -0.08910985f, -0.05485271f, -0.09266740f, 0.03280395f, -0.07262575f, 
    -0.09014016f, -0.18126184f, -0.02085401f, -0.14761166f, -0.03487173f, -0.02315868f, -0.03572070f, -0.12926534f, 
    0.00444206f, 0.04989298f, -0.02410016f, 0.02011847f, 0.01520749f, 0.07135161f, -0.01878412f, 0.03960095f, 
    0.01110971f, -0.10379808f, -0.02784140f, 0.03068042f, 0.05912144f, -0.00290076f, -0.08033182f, -0.02916100f, 
    -0.31825486f, -0.14402726f, -0.12368073f, -0.18036507f, 0.03733679f, -0.04606873f, -0.01282111f, -0.05269865f, 
    -0.18198219f, 0.04471232f, 0.04525102f, -0.00524017f, 0.13980196f, 0.02096266f, 0.05587475f, 0.17332558f, 
    0.05046617f, -0.00394026f, 0.07206144f, -0.08616377f, -0.01589679f, 0.03504029f, -0.04181413f, -0.13920683f, 
    0.13761292f, 0.10002799f, 0.26328605f, 0.16915694f, 0.09217107f, 0.03516436f, 0.10512704f, -0.05595674f, 
    -0.03518316f, 0.03819577f, 0.03927167f, 0.02055416f, -0.33910426f, 0.11655541f, -0.02982996f, -0.02374933f, 
    -0.19159859f, -0.03971808f, 0.03735609f, 0.03248838f, -0.00089196f, 0.01354313f, -0.01591312f, 0.01915183f, 
    -0.20469974f, 0.23813830f, 0.12274080f, -0.09065902f, 0.07601094f, 0.00291733f, -0.04575665f, -0.00811412f, 
    -0.02802749f, -0.09643861f, -0.00174404f, -0.10203535f, 0.11444351f, -0.22794935f, -0.15014513f, -0.11176687f, 
    -0.07260584f, -0.09687758f, -0.03883469f, -0.07230345f, -0.05114875f, -0.01122195f, 0.04150552f, -0.00731964f, 
    -0.18784305f, -0.06025993f, 0.15039694f, -0.11769962f, 0.01318149f, 0.00699373f, 0.01802250f, 0.04341411f, 
    -0.03427584f, 0.06096796f, -0.09677929f, 0.05289348f, -0.22978927f, 0.18308890f, -0.10525601f, -0.12819481f, 
    -0.11466379f, -0.01669792f, -0.04961187f, -0.09591302f, 0.05775127f, -0.03972838f, 0.09208965f, -0.00900696f, 
    -0.13026366f, -0.00708503f, -0.08998899f, 0.02381651f, 0.06290884f, 0.01379855f, -0.08797338f, 0.01131302f, 
    0.04211088f, 0.02983502f, -0.18365772f, 0.05697222f, 0.12065309f, 0.00660402f, 0.04934477f, 0.04772757f, 
    -0.01921313f, -0.06371092f, -0.04587913f, -0.03327337f, -0.06143311f, 0.08167454f, -0.00234563f, 0.00861290f, 
    0.09670386f, 0.25013250f, -0.09891143f, -0.10186418f, -0.00008811f, -0.04977836f, 0.01104547f, -0.00306906f, 
    0.06119099f, -0.00033811f, -0.00559895f, 0.06244389f, -0.26043430f, 0.12006417f, 0.06309392f, 0.03869876f, 
    -0.06316588f, -0.00799831f, -0.12641524f, 0.11307359f, 0.01057547f, -0.03791498f, 0.05586390f, -0.06385665f, 
    -0.08074918f, 0.11489864f, -0.10211436f, -0.05182576f, -0.06494597f, -0.00579455f, -0.00356299f, -0.00523548f, 
    -0.02187184f, 0.01443781f, 0.04189640f, 0.00085073f, 0.04787103f, -0.05850283f, 0.01719528f, 0.07389463f, 
    0.13106689f, -0.02180084f, 0.01017540f, 0.03337985f, 0.03903842f, -0.01026839f, 0.07220174f, -0.05613973f, 
    -0.12999815f, 0.02341639f, 0.04722138f, 0.07478310f, 0.05482264f, 0.05782410f, -0.08097453f, 0.02013516f, 
    0.04131227f, -0.03903121f, -0.11032706f, 0.01806473f, 0.14980999f, 0.05182064f, -0.10625648f, 0.16414766f, 
    0.05200194f, -0.08893871f, -0.06464233f, -0.06645158f, -0.04649254f, 0.02976641f, -0.13301712f, 0.12524243f, 
    0.08896400f, 0.06986015f, -0.04670883f, 0.12475601f, 0.13576330f, 0.11699744f, -0.02888708f, -0.05631956f, 
    -0.05941842f, -0.04816164f, 0.00817312f, 0.12748760f, 0.05209357f, -0.01591963f, 0.00848466f, -0.18615076f, 
    0.08694674f, -0.04250376f, -0.21482287f, -0.02745215f, -0.03384140f, 0.05026610f, -0.02133893f, -0.06282188f, 
    -0.14559674f, -0.23385355f, 0.05921293f, -0.09154539f, -0.01353503f, -0.00720847f, -0.03437206f, 0.06518269f, 
    0.11154591f, 0.00962199f, -0.08526464f, -0.08983649f, 0.23831514f, 0.06364552f, 0.08162213f, -0.09520553f, 
    0.01195973f, -0.05612949f, -0.07896467f, 0.11148563f, -0.00722600f, 0.05071767f, -0.15327924f, 0.06295865f, 
    -0.06958378f, -0.24530351f, -0.17884295f, -0.13081786f, -0.02185664f, 0.00752346f, -0.10409952f, -0.12171607f, 
    0.10371337f, -0.06625941f, 0.08874872f, 0.06843437f, 0.15353024f, -0.19527736f, -0.18542212f, 0.00050507f, 
    0.00279282f, -0.02880050f, 0.06667443f, -0.16069588f, 0.01430640f, 0.04848016f, -0.00619585f, 0.07197283f, 
    0.03168773f, 0.19315240f, 0.05140441f, -0.07894423f, 0.00218639f, -0.08781409f, -0.16073027f, -0.13141769f, 
    0.05027458f, -0.02292487f, 0.03413315f, -0.11958098f, -0.21066758f, -0.02202132f, -0.12860301f, -0.02191006f, 
    0.02607331f, 0.07364938f, -0.00185767f, 0.03282072f, 0.10246401f, -0.05369330f, 0.09429960f, 0.04028498f, 
    -0.01193552f, 0.03882276f, 0.09149707f, 0.04654577f, -0.08020119f, 0.02448549f, -0.07332770f, 0.04226820f, 
    -0.02002689f, -0.17353280f, 0.04149968f, 0.10697425f, -0.21204828f, 0.03222028f, -0.12682168f, -0.21878272f, 
    0.07208107f, 0.05536945f, -0.12669997f, 0.01992460f, 0.02959605f, -0.00901058f, 0.07274735f, -0.16654056f, 
    0.11603804f, -0.01188029f, -0.16500008f, 0.07380059f, -0.00859139f, -0.04101589f, -0.00793248f, 0.02096285f, 
    0.08769125f, 0.05664617f, -0.08121902f, 0.05277807f, 0.05452750f, -0.16474059f, 0.05446585f, 0.05389506f, 
    0.03325438f, -0.01232543f, -0.01372333f, 0.00006187f, -0.05484094f, 0.04500026f, 0.01453728f, -0.01351805f, 
    -0.05094108f, -0.12894638f, -0.03929450f, -0.28769937f, 0.02501085f, -0.01894712f, 0.08506775f, 0.00415047f, 
    0.08378819f, 0.04697708f, -0.15514256f, 0.09157121f, -0.04625130f, 0.08158516f, 0.08526036f, 0.22119829f, 
    -0.16067348f, 0.00810715f, -0.14067753f, -0.00688024f, 0.00249774f, -0.05901801f, 0.03335198f, -0.10156377f, 
    -0.25953540f, -0.14927864f, -0.10184816f, 0.01029643f, -0.04397112f, -0.08652309f, 0.00242112f, 0.01669206f, 
    0.04275559f, -0.01866034f, -0.02076097f, 0.01828628f, 0.12120707f, 0.06015847f, -0.08075985f, -0.14472465f, 
    -0.00247100f, -0.12013514f, -0.09218381f, 0.15570739f, 0.06236864f, -0.07328334f, 0.03497139f, -0.07125954f, 
    0.06025191f, -0.06181460f, -0.24141681f, 0.13258950f, 0.12492698f, 0.01980318f, -0.04000370f, -0.01566948f, 
    -0.03217326f, 0.02066491f, 0.13108198f, 0.05987253f, 0.11875324f, 0.01299510f, 0.09096665f, 0.15702291f, 
    0.12212989f, -0.03772822f, -0.03286415f, -0.05733927f, -0.07009873f, -0.01781623f, -0.00310679f, 0.00427696f, 
    0.02538737f, 0.21551102f, -0.23004836f, -0.13466205f, -0.03550655f, 0.04147991f, -0.11786415f, -0.01948855f, 
    0.11351334f, -0.00704954f, 0.02962198f, -0.07460498f, 0.09568847f, 0.00868617f, 0.03179934f, -0.12724002f, 
    0.03814597f, 0.00561885f, 0.14773215f, 0.00767099f, -0.06344445f, -0.00138611f, 0.00914446f, 0.06149025f, 
    -0.19023009f, 0.08225833f, -0.16389553f, -0.07648739f, -0.00698503f, 0.03491176f, -0.21919093f, -0.08923241f, 
    0.07711109f, 0.06581075f, 0.04019127f, 0.05826456f, -0.08398180f, -0.08025261f, 0.20343553f, -0.03917030f, 
    0.05419583f, -0.11473766f, -0.01031765f, -0.07262940f, -0.02950356f, -0.09243158f, 0.12479675f, 0.08047850f, 
    -0.05146499f, 0.22412902f, -0.22810599f, -0.16994433f, 0.07740313f, -0.16517800f, -0.07636116f, -0.04015382f, 
    0.09154430f, -0.03615106f, 0.01498709f, 0.06532604f, -0.18727878f, 0.02432992f, 0.05629597f, -0.00055810f, 
    -0.08420085f, -0.07919946f, -0.02576365f, -0.07743383f, 0.05477077f, 0.00396103f, -0.05074248f, 0.09348520f, 
    -0.20365506f, -0.08712867f, 0.12169889f, -0.16322696f, -0.02186041f, -0.02528352f, 0.06340863f, -0.14863504f, 
    0.03121681f, 0.04659988f, -0.10104705f, 0.00182600f, 0.15920162f, -0.05806762f, -0.10616194f, 0.06057712f, 
    -0.03513797f, 0.01517864f, -0.05748081f, -0.01559520f, -0.06821791f, 0.06220036f, 0.06851819f, -0.17599581f, 
    -0.01914388f, -0.02658390f, -0.15412249f, -0.07887797f, -0.02614498f, -0.01751124f, 0.06777523f, -0.08898295f, 
    -0.00720451f, -0.07935987f, -0.09918403f, 0.01916797f, 0.05721025f, 0.13563167f, -0.02039286f, 0.11752498f, 
    0.03216293f, -0.02751980f, 0.07828962f, 0.02970074f, 0.02059629f, 0.03902109f, -0.06425670f, -0.05006024f, 
    0.14195395f, -0.08679794f, 0.03485337f, 0.15908954f, 0.06989227f, 0.01091021f, -0.09696823f, 0.02523899f, 
    0.14535622f, -0.03120770f, 0.02122608f, -0.02304132f, -0.39450863f, -0.02369422f, 0.21299267f, -0.07684622f, 
    -0.19376503f, -0.01072496f, 0.03760054f, -0.11730663f, -0.04133629f, 0.01934788f, 0.01275724f, -0.01784945f, 
    0.07004222f, -0.10691141f, 0.04251420f, -0.03568465f, 0.02592685f, -0.11645517f, -0.19204418f, 0.00777244f, 
    -0.08171219f, 0.09004319f, 0.03191654f, -0.14828075f, -0.02432439f, 0.02831253f, 0.09030218f, 0.12389253f, 
    0.02128469f, -0.03550819f, -0.02344052f, -0.05731277f, -0.00661172f, 0.02490618f, 0.12268175f, -0.01737558f, 
    0.00948193f, -0.05189105f, -0.02492771f, 0.17479017f, -0.05138383f, -0.07188575f, 0.05679862f, 0.10114264f, 
    0.03840901f, -0.00821789f, -0.05119044f, 0.05032477f, 0.17237400f, 0.11877671f, -0.09335423f, 0.06590972f, 
    -0.02889569f, -0.00129746f, 0.03708330f, -0.01561233f, -0.01925167f, -0.09319816f, -0.08933125f, 0.10728272f, 
    0.00236439f, -0.04617318f, 0.15318197f, 0.22266725f, 0.02756223f, 0.01029908f, -0.02250680f, 0.00993340f, 
    -0.02872290f, 0.03425140f, -0.00672251f, -0.12058024f, -0.20367552f, -0.13285212f, -0.12471657f, -0.05124936f, 
    -0.11044279f, -0.03531395f, 0.11078904f, -0.19758540f, -0.05123115f, 0.01654631f, -0.00320066f, -0.03408279f, 
    0.12158646f, 0.17214833f, -0.01814344f, -0.03823006f, 0.00772314f, -0.02147430f, -0.24377686f, -0.02159115f, 
    0.01306022f, -0.01674069f, 0.08507621f, 0.00463000f, 0.14476186f, -0.00610886f, 0.03892957f, 0.00850656f, 
    -0.12755013f, -0.06296917f, 0.05777249f, 0.01101034f, 0.03521308f, -0.11906850f, -0.12018941f, 0.03246765f, 
    0.06385029f, 0.03147877f, -0.20081659f, 0.16198836f, 0.15572676f, -0.06563624f, 0.00204695f, 0.02761835f, 
    0.04657119f, 0.03220849f, 0.01323558f, 0.02994736f, 0.09662572f, 0.05767024f, -0.09464772f, 0.09765614f, 
    0.05750702f, 0.01044649f, -0.10032649f, -0.04980731f, -0.01431069f, 0.00389775f, 0.10758495f, -0.07485771f, 
    0.14561242f, -0.04892941f, -0.17600250f, -0.24583305f, 0.07927013f, 0.04954417f, 0.06248475f, -0.18188298f, 
    0.07692909f, -0.02117893f, 0.07031278f, 0.01490634f, -0.07864767f, -0.05804699f, 0.03614643f, 0.06671655f, 
    -0.03643044f, -0.16363999f, 0.03106152f, -0.17523929f, 0.02282236f, 0.04115188f, -0.07195440f, 0.01849136f, 
    0.13293353f, -0.05048439f, 0.00115585f, -0.01556852f, 0.05682886f, -0.05337097f, -0.03471130f, -0.04051301f, 
    -0.18524826f, 0.03776242f, 0.10937317f, 0.00281416f, -0.22300975f, -0.19660495f, 0.16595592f, -0.10084746f, 
    -0.06151159f, -0.04948388f, 0.00231117f, -0.03320453f, -0.04671739f, 0.01097518f, -0.12239660f, -0.00770501f, 
    0.08259982f, -0.03338480f, -0.14227484f, 0.06298117f, 0.08211838f, 0.04861126f, -0.02378585f, 0.08458583f, 
    0.06914514f, -0.01697363f, -0.03098647f, 0.08048891f, 0.08540870f, -0.01506725f, 0.06969142f, 0.14025716f, 
    -0.06706048f, -0.09932207f, -0.01844589f, 0.11047608f, -0.01444593f, -0.02895866f, -0.03269780f, -0.09565920f, 
    0.27883980f, -0.05622189f, 0.10345875f, 0.06351732f, -0.10407329f, -0.05150740f, 0.00770405f, -0.10682297f, 
    -0.05277907f, -0.11001200f, -0.08535728f, -0.14419232f, 0.09695933f, -0.04645906f, 0.05328165f, 0.01163807f, 
    -0.11630484f, 0.00111539f, 0.03249402f, 0.02050765f, 0.01231733f, 0.09144224f, -0.01176033f, 0.05035550f, 
    -0.02117971f, -0.18672426f, -0.08584557f, 0.07393697f, 0.09970847f, -0.02425885f, -0.03274395f, 0.01208124f, 
    0.05463166f, 0.00616766f, 0.26041803f, -0.18907376f, 0.06657785f, -0.18336506f, -0.07746341f, -0.23930761f, 
    -0.09293240f, -0.06034641f, 0.04280471f, 0.06108020f, 0.05507233f, 0.04664745f, 0.00583290f, -0.04079939f, 
    -0.09181969f, -0.04664721f, 0.09657726f, 0.16097786f, -0.09610806f, -0.05194249f, -0.08431711f, 0.11565156f, 
    0.05212984f, -0.03426792f, -0.05459062f, -0.02745175f, 0.15548469f, 0.09019937f, -0.27923349f, -0.02294056f, 
    0.02028243f, -0.06120779f, -0.06655253f, -0.03467354f, 0.04656329f, -0.03254960f, 0.14878370f, -0.02392515f, 
    0.10547148f, -0.06840388f, 0.04902982f, 0.12810840f, 0.07296620f, -0.00036130f, 0.00624462f, -0.12301069f, 
    -0.10261626f, 0.06872641f, 0.03238943f, 0.07628403f, -0.09020087f, -0.35588923f, -0.04219231f, 0.02831145f, 
    0.03358601f, -0.00726245f, 0.04565194f, -0.03328395f, 0.11138952f, 0.07665856f, -0.00098038f, 0.11610666f, 
    0.39832360f, -0.02425427f, -0.20632763f, 0.35178933f, -0.05029594f, -0.05235321f, -0.08325350f, -0.06192680f, 
    -0.08246742f, -0.09730144f, -0.07761064f, 0.16620414f, 0.20007838f, 0.23883207f, -0.28476003f, 0.03676517f, 
    -0.00030394f, 0.09805929f, 0.00829479f, -0.08583326f, -0.03482589f, 0.04984427f, -0.04572625f, 0.06623013f, 
    0.08676773f, -0.17678535f, 0.13396542f, -0.02371564f, -0.10591693f, 0.04532915f, -0.00289840f, -0.00216897f, 
    -0.01526759f, -0.11371208f, 0.02728781f, -0.03746499f, 0.23884588f, 0.15038642f, -0.32765320f, -0.12331875f, 
    0.04050376f, -0.00022906f, -0.02383782f, 0.01963996f, -0.00616752f, -0.06929243f, -0.11702500f, -0.05916560f, 
    -0.15723445f, 0.03444669f, 0.51444751f, 0.08796446f, 0.08201808f, 0.07074665f, 0.01707098f, -0.09843904f, 
    0.07085879f, -0.08051695f, 0.06404038f, -0.00936387f, 0.03240393f, 0.14156303f, -0.05615220f, 0.11853998f, 
    -0.17361645f, 0.13716453f, -0.01345672f, 0.06576807f, 0.05803728f, 0.06047190f, 0.10063568f, 0.04532887f, 
    -0.24089532f, 0.45013520f, 0.06585242f, 0.18171854f, 0.19326894f, 0.06165137f, -0.06726518f, 0.04621499f, 
    -0.06466054f, 0.02683438f, -0.07479380f, 0.04056004f, -0.02234139f, 0.02742487f, 0.20578286f, -0.10229634f, 
    -0.02320194f, 0.01063288f, 0.04797936f, -0.08130395f, -0.03087419f, -0.08639884f, -0.13050112f, -0.05210539f, 
    -0.32505402f, 0.20276959f, 0.04819449f, -0.00874807f, 0.03242975f, 0.01209563f, -0.03181801f, -0.01538920f, 
    0.10435668f, -0.02227003f, 0.09415749f, -0.02243486f, 0.17919634f, -0.21686120f, -0.02692211f, -0.07924592f, 
    0.11027128f, 0.03598050f, -0.07882357f, -0.13265300f, -0.05161723f, -0.04582705f, 0.04879461f, -0.06151045f, 
    -0.13354620f, 0.38041547f, 0.05105996f, -0.24583450f, 0.10247877f, 0.03905946f, -0.04607490f, -0.07498424f, 
    -0.02864780f, -0.02323648f, -0.06626599f, -0.08039345f, 0.30147710f, -0.51511574f, -0.16026600f, -0.14117131f, 
    -0.14530729f, -0.02210293f, 0.00193401f, 0.02116353f, -0.07542434f, -0.12899059f, 0.12780182f, -0.06214001f, 
    0.04869145f, 0.08458662f, 0.00073442f, -0.04070092f, -0.04093072f, -0.02136536f, 0.09515771f, -0.11215259f, 
    0.10243746f, -0.03472732f, 0.02104642f, 0.15266305f, -0.23842874f, 0.07756992f, -0.04436253f, 0.00871787f, 
    0.10588320f, -0.19821045f, 0.05121930f, -0.07277832f, 0.05196164f, -0.02467338f, 0.11327779f, 0.03565644f, 
    0.20267363f, -0.09403123f, 0.11546040f, -0.15850778f, 0.04280031f, -0.00611019f, -0.02631900f, 0.04501374f, 
    -0.10998345f, -0.06019751f, -0.01032329f, -0.05657370f, -0.00338231f, -0.01986442f, 0.05270328f, 0.04604839f, 
    -0.04797957f, -0.03560784f, -0.09439014f, 0.05615395f, -0.05743527f, -0.02019415f, -0.06562962f, -0.04944396f, 
    0.23060283f, 0.12925108f, -0.32420325f, -0.11179057f, -0.03826553f, 0.05666361f, -0.01543429f, -0.00589769f, 
    -0.01655873f, 0.08192215f, 0.13614824f, 0.05665506f, -0.13148344f, -0.01828321f, 0.04053712f, -0.09317117f, 
    0.06622287f, -0.05717947f, 0.04476355f, 0.04621256f, 0.04252825f, 0.02964455f, 0.00516932f, -0.16679932f, 
    -0.21734029f, -0.35877419f, -0.05574139f, -0.20344314f, 0.06939299f, 0.04923406f, 0.00166033f, 0.05725268f, 
    -0.00883369f, 0.05628334f, -0.09403360f, 0.00961942f, -0.22886333f, -0.07549244f, 0.03409626f, -0.06831060f, 
    0.05044440f, 0.05759490f, -0.17154555f, 0.06985915f, -0.05265267f, -0.02720483f, 0.05510934f, 0.05050838f, 
    -0.06245672f, 0.02654116f, -0.11175516f, 0.00677830f, 0.10089137f, 0.02523724f, -0.00959898f, -0.07191910f, 
    0.00305090f, 0.15147333f, 0.11344239f, 0.03641988f, -0.03386142f, -0.07870571f, -0.01531770f, 0.00891909f, 
    -0.06940586f, 0.01875923f, -0.02372885f, -0.13110787f, 0.09720104f, -0.02120015f, -0.03264255f, -0.00665847f, 
    -0.06462344f, -0.17612126f, 0.15031108f, 0.01848109f, -0.00023688f, 0.01464480f, 0.03694816f, -0.05688486f, 
    0.05314841f, -0.03926665f, 0.15492849f, -0.14715801f, 0.05531492f, -0.45370317f, 0.19971089f, -0.02530234f, 
    0.07138991f, -0.03001402f, 0.05055746f, 0.06767035f, 0.01580848f, -0.01809695f, 0.05302687f, 0.05528925f, 
    -0.39573547f, 0.02407293f, -0.01468294f, -0.10998435f, -0.10448241f, -0.17383954f, -0.00392854f, -0.00250848f, 
    -0.02308736f, 0.01720391f, -0.02722085f, 0.04242333f, -0.27060914f, -0.03434934f, 0.17815621f, 0.13199240f, 
    -0.02442111f, 0.09615935f, 0.12043515f, -0.07083324f, 0.07603737f, -0.13092256f, -0.03994735f, -0.03654968f, 
    -0.08324254f, -0.05294678f, -0.00735072f, -0.16283001f, 0.01811551f, 0.05771081f, -0.10301612f, 0.02624151f, 
    -0.03327769f, -0.09677130f, -0.11976866f, -0.16402042f, -0.57562315f, 0.25783601f, -0.17352620f, -0.12964450f, 
    0.10394792f, -0.05868960f, 0.01948778f, -0.07524051f, 0.00885903f, -0.06904881f, 0.01988551f, -0.04755498f, 
    -0.15115805f, 0.17339359f, 0.03111623f, 0.10668270f, 0.10235535f, 0.04987273f, -0.03783679f, 0.00855899f, 
    -0.10032054f, -0.03635017f, -0.15096830f, 0.00840210f, -0.00739060f, -0.09116909f, 0.06578963f, -0.06334002f, 
    -0.06403847f, 0.03740058f, -0.08447450f, -0.05402965f, -0.15024523f, -0.00546822f, -0.07308886f, 0.17791148f, 
    0.00290286f, 0.13629140f, 0.11501383f, -0.00170471f, 0.03503238f, -0.02946910f, 0.05313746f, 0.02487974f, 
    -0.03224223f, 0.08753340f, -0.03681827f, 0.04583187f, 0.11221806f, -0.22980554f, -0.11493570f, 0.16561189f, 
    0.03765934f, 0.01961055f, 0.02731204f, 0.08800422f, -0.01346192f, 0.01755728f, 0.05584142f, -0.16340330f, 
    -0.39638886f, -0.10333968f, 0.26765087f, -0.21613188f, -0.03088140f, 0.02924161f, -0.03256572f, 0.09620499f, 
    0.03894233f, -0.01223421f, 0.06488980f, -0.05701526f, 0.12896751f, 0.25465795f, -0.24343838f, 0.03662325f, 
    -0.05341708f, -0.07286564f, -0.16393058f, 0.13202947f, -0.00946571f, 0.00634712f, 0.11689412f, 0.02116191f, 
    -0.06723769f, -0.16072947f, -0.01663919f, 0.09295329f, -0.05789230f, 0.06870778f, 0.05696728f, -0.04273724f, 
    0.02207037f, 0.05284462f, 0.08375125f, -0.11079413f, -0.08570684f, 0.07474337f, -0.20872144f, 0.03771244f, 
    0.13812199f, 0.10716566f, 0.01849622f, 0.05404185f, -0.01161218f, 0.01275428f, -0.02890481f, -0.04788538f, 
    -0.10193478f, 0.14677562f, -0.23710862f, 0.07808669f, -0.00280362f, 0.11601561f, -0.10964017f, 0.05052264f, 
    -0.05700095f, 0.02286104f, 0.07242114f, 0.05033202f, -0.20304969f, 0.37453666f, -0.03089902f, 0.07080842f, 
    0.00801709f, 0.15471582f, -0.07584955f, -0.11469977f, 0.15400472f, -0.06389549f, 0.14384651f, 0.03306824f, 
    -0.21904850f, 0.17711946f, -0.05314080f, -0.27395454f, 0.03517479f, 0.00694473f, -0.03384400f, -0.05925163f, 
    -0.12734121f, -0.05208359f, 0.04299461f, -0.10163565f, 0.13493022f, -0.07919085f, -0.02085210f, -0.17109488f, 
    0.00275308f, 0.03911972f, 0.09946628f, -0.06058034f, -0.02363873f, -0.00912487f, 0.03931003f, -0.06738098f, 
    -0.21611640f, 0.00423107f, 0.06737337f, -0.14259328f, -0.05119798f, -0.00945274f, 0.08231848f, 0.06223445f, 
    0.10401818f, 0.00106614f, -0.00859072f, 0.01039512f, 0.12655750f, -0.18512595f, -0.04426684f, -0.01058470f, 
    0.01282430f, -0.02356957f, -0.11650869f, -0.11295152f, -0.01298043f, -0.09673562f, 0.06815914f, -0.03734235f, 
    0.08642320f, -0.03023374f, -0.09950293f, 0.13689260f, 0.00500498f, -0.03780743f, -0.01986954f, 0.10341325f, 
    -0.11293360f, -0.06221604f, 0.10328925f, -0.02414828f, 0.03036673f, 0.03983645f, 0.05173752f, 0.07755382f, 
    0.10255016f, 0.02398366f, 0.02997665f, 0.23208839f, 0.06977980f, -0.07332596f, 0.05751004f, -0.02955620f, 
    -0.41890353f, 0.43823007f, -0.22848997f, -0.24915883f, 0.08465872f, 0.00074799f, 0.03495264f, -0.01822660f, 
    -0.04099740f, -0.05909581f, 0.03492340f, 0.08837827f, 0.18691489f, -0.10707258f, -0.23112632f, 0.11678454f, 
    -0.11984404f, 0.10543215f, 0.00006356f, 0.02818721f, 0.09717467f, 0.00041394f, 0.11729751f, -0.00174193f, 
    -0.04982550f, -0.13795555f, -0.03122217f, -0.19752349f, -0.09405905f, 0.05009812f, 0.09157198f, 0.12868634f, 
    0.04540867f, -0.00782205f, 0.02583945f, -0.00079079f, -0.07942372f, 0.16242920f, -0.00070889f, 0.01654130f, 
    0.23154661f, 0.08095090f, -0.08781622f, 0.08552163f, 0.03862135f, -0.02418256f, 0.04045600f, 0.02904263f, 
    -0.12823373f, -0.00847340f, -0.03225887f, -0.13865890f, -0.02964809f, 0.11450651f, -0.12982251f, 0.09544721f, 
    -0.03749587f, -0.00605018f, -0.16464174f, 0.05793777f, 0.01998015f, -0.06568019f, 0.16086690f, -0.04804970f, 
    -0.03535128f, -0.08976302f, -0.01385421f, 0.19952056f, 0.03890245f, 0.06565417f, -0.14400657f, 0.00452113f, 
    -0.02604412f, -0.25236240f, -0.02473320f, -0.07730522f, 0.13082880f, 0.00137237f, -0.04834303f, -0.05972448f, 
    -0.18232100f, -0.01453401f, 0.01670736f, 0.00126056f, 0.08934066f, -0.20610079f, -0.01883808f, 0.06068014f, 
    0.00495079f, 0.01725105f, 0.01721924f, 0.00738306f, 0.08822928f, -0.06072214f, 0.08689388f, -0.01763402f, 
    0.07160065f, 0.24686079f, 0.02485107f, -0.18531719f, -0.04093732f, -0.12114883f, -0.04615797f, -0.06533177f, 
    -0.03305726f, 0.03191457f, -0.04575325f, -0.07965937f, -0.14309354f, -0.09748770f, 0.07868293f, 0.33507130f, 
    0.01109267f, 0.00071481f, -0.07023530f, 0.06466148f, -0.00178059f, 0.10297009f, 0.01369406f, -0.01744227f, 
    0.04189307f, 0.28288963f, -0.25772661f, -0.07135668f, 0.06098291f, -0.06416354f, 0.00016256f, 0.01964657f, 
    0.06715006f, 0.14457358f, -0.09372611f, 0.02025395f, -0.03789755f, 0.01239461f, 0.15957218f, 0.17810868f, 
    0.04674503f, 0.04473924f, -0.01638356f, -0.20671622f, -0.03904566f, 0.08411467f, 0.11677274f, 0.01560877f, 
    0.09278992f, -0.08093902f, -0.02758550f, 0.04679192f, 0.09896177f, 0.08881982f, -0.06902771f, 0.03002633f, 
    -0.16718230f, 0.00136506f, 0.02925000f, 0.13774095f, 0.19685887f, 0.10393827f, -0.06852457f, 0.01498823f, 
    0.16101716f, -0.04641438f, 0.11889245f, -0.02473171f, 0.06725513f, 0.09693410f, 0.07394903f, 0.09271513f, 
    -0.09656389f, 0.04226414f, -0.00175430f, -0.33026990f, -0.02347304f, 0.09445763f, -0.08929656f, -0.07363528f, 
    -0.05467781f, -0.01740225f, 0.03260713f, -0.05821583f, 0.00214236f, -0.03738933f, -0.22533683f, -0.00398886f, 
    0.06502700f, 0.03035271f, 0.03132042f, -0.09020086f, 0.00314552f, 0.00189284f, 0.01469628f, 0.09498399f, 
    -0.04971188f, -0.35438675f, -0.07139967f, -0.07834741f, -0.02314431f, 0.06671157f, -0.10615225f, -0.09870163f, 
    0.05130443f, 0.05184502f, -0.07728966f, 0.03577426f, -0.49626747f, 0.09541880f, 0.27301964f, -0.02588030f, 
    0.02979274f, 0.06568002f, 0.10710942f, 0.00594629f, 0.08720646f, -0.02048997f, 0.04984990f, 0.00441262f, 
    -0.15811294f, 0.04254049f, -0.09127279f, -0.09226672f, -0.00415917f, 0.03131718f, 0.00053276f, 0.02733122f, 
    0.09443784f, -0.10224974f, -0.01900635f, -0.04497537f, 0.02648716f, -0.10956745f, 0.07891104f, -0.19591679f, 
    0.01012248f, 0.01945498f, 0.06371541f, -0.09092610f, -0.03937196f, -0.12740099f, 0.02714252f, -0.05855871f, 
    0.18303892f, -0.06736203f, -0.00408649f, -0.08228741f, -0.01203564f, -0.10527329f, 0.01734881f, 0.09390557f, 
    -0.00312531f, 0.07239051f, 0.08242673f, -0.05222675f, 0.08972909f, 0.00290551f, -0.00804169f, 0.05928147f, 
    0.07781200f, -0.00108575f, 0.08149823f, 0.05239075f, 0.01100354f, 0.07476112f, 0.09663032f, 0.03681365f, 
    -0.09864151f, 0.09018004f, -0.00719539f, 0.13404202f, 0.09221592f, 0.01711635f, 0.09342293f, -0.10330559f, 
    0.04682060f, 0.06823779f, 0.07645191f, 0.12696835f, -0.16136621f, 0.01859106f, -0.11243016f, -0.14194435f, 
    0.05063592f, 0.00358058f, -0.03557581f, 0.07164092f, -0.05074675f, 0.08151585f, 0.13363928f, -0.00414667f, 
    0.00845796f, -0.14809036f, -0.10612942f, -0.05561564f, -0.10193155f, -0.02740000f, -0.07636507f, 0.07712164f, 
    0.09801506f, 0.00778846f, 0.04168304f, 0.03875227f, -0.05871821f, -0.01973647f, 0.10656250f, 0.09223836f, 
    0.08372954f, -0.03353943f, -0.03768164f, 0.05373681f, 0.03370105f, -0.01708963f, 0.04033342f, -0.04521662f, 
    -0.00314599f, -0.05705519f, -0.03419537f, 0.10722455f, -0.03671130f, 0.13704196f, -0.02882498f, 0.07670479f, 
    0.10441215f, 0.06693773f, 0.00221489f, 0.02266218f, -0.37280789f, -0.27551052f, -0.04736925f, 0.03305580f, 
    0.16105637f, -0.02570813f, 0.04874079f, 0.00567011f, 0.04200049f, 0.03389697f, 0.09294529f, 0.08591984f, 
    0.17779991f, -0.05160026f, 0.00562330f, 0.06067413f, -0.00114736f, -0.12917386f, 0.04688729f, 0.05854135f, 
    0.03779023f, -0.25448996f, 0.01199676f, -0.08817073f, -0.36587587f, -0.14330848f, -0.07907190f, -0.09490766f, 
    0.04287411f, -0.10027083f, -0.03204097f, -0.06232889f, 0.05963797f, 0.09841560f, 0.02941463f, 0.12502573f, 
    -0.31300208f, -0.40243217f, -0.14751872f, 0.01078330f, -0.01516477f, 0.12511116f, 0.03331142f, -0.07341584f, 
    0.13270004f, 0.10703108f, 0.03734792f, 0.06017907f, -0.23876111f, -0.04847550f, -0.21369855f, -0.12073256f, 
    0.09954807f, 0.04403640f, -0.11411526f, 0.01340746f, 0.10698572f, 0.15654117f, -0.06102876f, 0.01520874f, 
    -0.19043703f, -0.04513487f, 0.09086570f, 0.04882069f, 0.14264029f, 0.06630240f, -0.02506503f, -0.04252458f, 
    0.04677656f, -0.07288969f, -0.17034544f, -0.03857782f, -0.08372115f, -0.17497791f, -0.13113773f, -0.03973730f, 
    0.03308301f, 0.00504916f, -0.10789655f, -0.02020169f, -0.00646347f, -0.10417242f, -0.02202760f, -0.05373922f, 
    -0.41512954f, 0.05749532f, 0.06808251f, 0.12570716f, 0.08307859f, 0.04941177f, -0.07830780f, -0.14358298f, 
    -0.11805064f, 0.01157760f, 0.05055546f, 0.04912177f, -0.20613167f, -0.08818061f, -0.01541198f, 0.02330398f, 
    -0.07249772f, 0.06762862f, 0.00049379f, -0.02393103f, 0.07794715f, 0.03595608f, 0.07935172f, 0.09625152f, 
    -0.09384093f, 0.26168895f, 0.09862506f, -0.03695139f, -0.05517653f, -0.08934083f, -0.01329135f, 0.05450907f, 
    0.02454058f, -0.13157418f, -0.07433435f, -0.02255659f, -0.33630681f, -0.06419685f, -0.01454776f, -0.00106207f, 
    0.07052342f, 0.02895942f, 0.00452546f, -0.03885512f, 0.07492380f, 0.11192071f, 0.01813973f, 0.06150354f, 
    0.09262013f, 0.06788959f, 0.03621857f, -0.11474837f, -0.00002763f, -0.00681322f, -0.03264671f, -0.12210181f, 
    0.03374294f, -0.04641068f, 0.05461529f, 0.00914027f, -0.08306952f, -0.00885093f, 0.03886379f, 0.04267826f, 
    0.08773495f, 0.12023754f, -0.06654572f, 0.01898205f, 0.09400060f, 0.04772953f, -0.08742071f, -0.10205082f, 
    -0.26351035f, -0.12914819f, -0.09503310f, 0.00575770f, 0.05298503f, -0.02947174f, -0.04463817f, -0.00716232f, 
    0.05891180f, -0.04665738f, 0.00178915f, 0.02840040f, -0.39986038f, -0.23221260f, 0.01209627f, -0.11001233f, 
    0.05644986f, 0.03638222f, 0.03330732f, 0.05532233f, -0.03754838f, 0.03981822f, -0.00868362f, 0.02748518f, 
    0.14928283f, 0.26762915f, 0.10731778f, 0.04717234f, 0.05296313f, -0.02260486f, 0.04907839f, -0.16269368f, 
    -0.03311826f, -0.06181553f, -0.01366041f, 0.01497298f, 0.12283927f, 0.09836686f, -0.00328183f, -0.00537592f, 
    -0.15899944f, 0.00964884f, -0.00913685f, -0.05087227f, -0.04140555f, -0.00838193f, -0.00822602f, -0.06724912f, 
    0.25248760f, 0.15996213f, 0.08491682f, 0.05166211f, 0.05433327f, -0.03911515f, -0.04257157f, 0.15126298f, 
    -0.10833678f, -0.05262131f, 0.04263782f, 0.07346659f, -0.09122941f, -0.04798614f, 0.21582493f, 0.06768309f, 
    -0.02037258f, -0.04220363f, 0.04024807f, 0.01614190f, -0.06021115f, 0.00535588f, 0.05604674f, 0.07742823f, 
    -0.38574997f, -0.10145043f, -0.04240755f, -0.18242814f, 0.06206542f, 0.04278528f, -0.05066865f, -0.03020569f, 
    0.03052015f, 0.13359408f, -0.02732941f, 0.10030564f, -0.38450256f, -0.36537543f, -0.14551964f, -0.07469509f, 
    0.02270405f, 0.04789625f, 0.05181821f, 0.02057804f, -0.01694726f, 0.10913126f, 0.09791458f, -0.00557189f, 
    -0.21966331f, -0.08217294f, 0.15004505f, 0.00166009f, -0.03777420f, 0.06000933f, -0.07179115f, -0.02801774f, 
    -0.02208363f, -0.01290511f, 0.10503294f, -0.06925891f, 0.07707877f, 0.07726721f, -0.01747134f, -0.00249956f, 
    -0.00247823f, -0.02653978f, 0.07297391f, 0.00648115f, 0.14366221f, 0.09026691f, 0.04309268f, -0.00112998f, 
    -0.27844468f, -0.07709936f, 0.07848863f, 0.02746703f, 0.09808967f, -0.00674101f, -0.04943579f, -0.13843806f, 
    0.05537512f, -0.12488563f, -0.01921592f, 0.02193728f, 0.04723370f, 0.14302367f, 0.13856886f, -0.22462979f, 
    -0.03957114f, -0.01736523f, 0.01129225f, -0.02765841f, -0.04834681f, -0.10108476f, 0.04415800f, -0.08893108f, 
    -0.09059707f, -0.07334804f, -0.10527892f, 0.03952599f, 0.16474098f, -0.03092720f, 0.04678044f, -0.06074772f, 
    0.02607051f, 0.15089953f, 0.08494738f, 0.02333993f, -0.23380952f, -0.16924302f, 0.13283724f, 0.02721649f, 
    -0.01845908f, 0.08423486f, -0.02436110f, 0.05301291f, 0.05426355f, -0.05692122f, 0.02633187f, 0.08047161f, 
    0.04464453f, 0.09446488f, -0.00181003f, -0.00596588f, -0.04455788f, 0.08157741f, -0.05885707f, -0.04885438f, 
    0.01145417f, -0.06626989f, -0.07957043f, 0.00413243f, -0.03597997f, -0.12145126f, -0.06662291f, 0.00765254f, 
    -0.13728251f, -0.07412013f, -0.01685930f, 0.05004538f, -0.05491241f, 0.15122193f, -0.02292300f, 0.04024066f, 
    -0.11266568f, 0.07315660f, -0.00874354f, -0.04952943f, 0.05839863f, -0.06354612f, 0.15492091f, -0.00505809f, 
    0.03528438f, 0.06398010f, -0.05665578f, -0.02188933f, -0.08422485f, -0.26677975f, -0.07791650f, 0.07105715f, 
    -0.00375652f, -0.02322659f, 0.11477388f, 0.07289090f, 0.07291452f, 0.04011823f, -0.04476870f, 0.06871365f, 
    -0.63281703f, -0.08575289f, -0.07840287f, -0.34110153f, 0.10663980f, 0.10537401f, 0.02507893f, 0.06853968f, 
    0.08464169f, -0.07024749f, 0.06006750f, 0.01188765f, 0.14219387f, 0.15974946f, -0.00914046f, 0.03574681f, 
    -0.06476193f, -0.06805431f, -0.01403947f, -0.09190495f, -0.11469714f, 0.04808165f, 0.03216708f, 0.06437296f, 
    -0.31531683f, -0.10669502f, -0.12247574f, -0.07214587f, 0.09618545f, -0.05741708f, -0.14058641f, -0.06198023f, 
    -0.05670619f, -0.10715783f, -0.16969909f, 0.05212682f, 0.29581028f, -0.08725515f, -0.03537721f, 0.00329418f, 
    -0.15618959f, -0.08109039f, -0.01385773f, 0.06880318f, -0.00905478f, 0.09762254f, -0.04433517f, 0.05720569f, 
    0.20157783f, -0.08657219f, -0.02729740f, 0.07994629f, 0.03674001f, -0.19191919f, -0.01043298f, 0.05715385f, 
    0.02373027f, 0.08945058f, 0.00560644f, 0.03882287f, -0.05306742f, 0.02262200f, -0.00523109f, -0.02837775f, 
    -0.06972449f, 0.07101557f, 0.12785487f, -0.08527053f, -0.02307807f, -0.12454470f, -0.11470792f, -0.03821235f, 
    -0.40863129f, -0.35408869f, -0.13022108f, -0.11647081f, 0.02781319f, -0.13915901f, -0.02353015f, 0.02698016f, 
    0.01133899f, 0.02260169f, -0.00569072f, 0.05871556f, 0.28313124f, 0.13924882f, -0.11226477f, 0.06300138f, 
    -0.01882087f, 0.09450765f, 0.12529178f, 0.04905146f, 0.05595019f, 0.02491606f, -0.03589677f, -0.02121410f, 
    -0.17331116f, 0.01286540f, -0.00104793f, -0.20170900f, 0.01768217f, 0.04808607f, -0.07323720f, 0.03477192f, 
    -0.00801857f, 0.03994179f, -0.01820561f, 0.02700587f, 0.07403161f, 0.00476888f, -0.09083156f, -0.01726214f, 
    -0.07283368f, -0.05475428f, 0.11221482f, -0.05439102f, 0.10467458f, -0.02737928f, 0.00431671f, 0.04990207f, 
    -0.47498742f, 0.05269302f, -0.23018876f, -0.13060433f, 0.07296915f, -0.14094177f, -0.11012415f, -0.07339266f, 
    -0.00556790f, -0.04963373f, -0.01550908f, 0.00638980f, -0.30974647f, -0.02912923f, -0.00701559f, -0.00815581f, 
    0.12578313f, 0.02936309f, -0.18150736f, -0.11827392f, 0.01281343f, -0.04546190f, 0.09989926f, -0.04534550f, 
    0.01579839f, 0.05542371f, -0.15952316f, 0.00553566f, -0.03980392f, 0.08505374f, -0.00468746f, 0.00644773f, 
    0.08531331f, 0.00800057f, -0.01285734f, -0.14162195f, 0.03115808f, -0.00576270f, 0.02234437f, 0.03303530f, 
    0.01059064f, -0.04062700f, -0.10489559f, -0.08538072f, -0.00251469f, -0.05881801f, -0.01664924f, 0.08580392f, 
    0.06974898f, 0.01636523f, 0.11129740f, -0.05307228f, 0.02076262f, -0.00919064f, -0.01128729f, -0.01208776f, 
    -0.02195948f, 0.11951096f, 0.06511428f, 0.15179451f, 0.27672988f, 0.09677567f, -0.03440344f, 0.20549573f, 
    -0.05306189f, -0.01115920f, -0.00324846f, 0.08420581f, 0.08458273f, -0.00402088f, -0.05454580f, -0.00473556f, 
    0.01398328f, 0.18455428f, -0.09214191f, -0.08329741f, 0.07293761f, 0.01330475f, 0.02729779f, 0.04289962f, 
    0.02690342f, -0.04485706f, 0.02079636f, -0.01766454f, 0.03442620f, -0.05377510f, -0.11578584f, -0.17736800f, 
    0.05807561f, -0.10203937f, -0.07761464f, 0.02837755f, -0.01126896f, -0.01227059f, -0.01874298f, 0.12477805f, 
    0.21297759f, 0.13882646f, -0.10724529f, -0.04799179f, -0.00217620f, -0.12731381f, -0.15754466f, -0.04082265f, 
    0.02498362f, -0.22805165f, -0.11100148f, -0.14016894f, 0.08018003f, -0.00507927f, -0.02877037f, 0.06690523f, 
    0.05675171f, 0.11825821f, 0.09089364f, 0.16069567f, 0.11863777f, 0.11326587f, 0.02726906f, -0.04564200f, 
    -0.13910231f, -0.04241670f, 0.10776996f, -0.10500968f, 0.05312734f, -0.00851305f, -0.07296760f, -0.05011938f, 
    0.00708321f, 0.00501387f, 0.01076831f, -0.04301006f, 0.09157868f, 0.16259550f, -0.00208203f, 0.09169295f, 
    0.03538347f, 0.09421271f, 0.11604531f, -0.04357103f, -0.06422028f, -0.03298762f, 0.03149060f, -0.08047679f, 
    0.19027922f, 0.03002819f, -0.05730663f, 0.01181811f, -0.19771528f, -0.11642735f, -0.04547604f, -0.02166381f, 
    0.06352374f, 0.02412171f, 0.02266454f, -0.04838926f, -0.32016382f, 0.00473468f, -0.03594989f, 0.05961818f, 
    -0.00032232f, 0.00505087f, 0.06729998f, 0.05109856f, 0.06883933f, -0.00440992f, 0.11680505f, 0.01080053f, 
    -0.38115728f, -0.22952375f, -0.16946237f, -0.05038918f, 0.04374359f, -0.03699622f, -0.06996934f, 0.09417718f, 
    -0.01461432f, 0.06863602f, 0.05881310f, 0.10430817f, -0.21118833f, 0.27820447f, 0.02566644f, -0.10416003f, 
    0.00936635f, -0.04963138f, -0.01882097f, 0.06748208f, 0.05152548f, 0.10540447f, -0.02019400f, 0.11817269f, 
    0.01909044f, 0.11672290f, 0.16542462f, -0.04515098f, -0.09874168f, -0.02479850f, -0.09637573f, -0.08230609f, 
    -0.01084579f, -0.07481120f, 0.06446318f, -0.02516264f, 0.05329192f, -0.12545829f, -0.12571880f, 0.13368930f, 
    -0.01254722f, -0.12445070f, 0.03684369f, 0.06491718f, -0.10205222f, 0.01463644f, -0.00522163f, -0.00403424f, 
    0.11575068f, 0.00055036f, -0.02089294f, 0.04660657f, 0.00650530f, 0.07278067f, -0.05104402f, 0.02283899f, 
    0.01327867f, -0.05934039f, 0.04737635f, -0.03421897f, -0.10647288f, -0.10308485f, 0.08827532f, -0.03015286f, 
    -0.07155042f, 0.05209204f, 0.02978712f, 0.05758727f, -0.08889734f, -0.01032317f, 0.03365938f, 0.00376414f, 
    0.08634257f, -0.35062382f, -0.02572735f, -0.01423196f, 0.03274454f, 0.01925323f, -0.09444018f, -0.02617248f, 
    0.07965308f, -0.10225422f, 0.08793479f, 0.06859588f, 0.02258070f, 0.22976775f, -0.22271371f, 0.14195494f, 
    0.03859628f, -0.13443170f, -0.02983866f, -0.11465968f, 0.05207309f, 0.09988836f, 0.04755368f, 0.05827102f, 
    0.02447610f, -0.15886897f, 0.13852665f, 0.10699130f, -0.02105678f, -0.03126626f, -0.05466644f, -0.08446987f, 
    -0.00339470f, -0.07857898f, -0.15402330f, -0.10376709f, 0.36252153f, 0.18060836f, -0.21577016f, -0.22684808f, 
    0.07070918f, 0.06992537f, 0.01157066f, 0.14750621f, 0.03038347f, 0.03539151f, 0.03400768f, 0.01916122f, 
    0.15154143f, -0.13161619f, -0.03464263f, 0.17791785f, 0.14344683f, 0.01664433f, 0.11421229f, 0.07318249f, 
    0.08454312f, 0.10578865f, 0.02063806f, 0.08607268f, 0.09170943f, -0.02939157f, -0.09198155f, 0.03568422f, 
    -0.02964484f, -0.06831535f, -0.06548916f, 0.14218120f, -0.03218237f, -0.05172232f, 0.04132332f, -0.05499874f, 
    0.28971535f, -0.26638040f, -0.11418703f, 0.14625789f, 0.06709798f, 0.13919631f, -0.01189128f, 0.01984306f, 
    0.06917261f, -0.02924043f, 0.00633345f, -0.14466976f, -0.33198091f, -0.04922709f, 0.16757141f, 0.38261041f, 
    -0.08264861f, 0.00556187f, -0.11926394f, 0.11378025f, -0.01386706f, -0.09598465f, 0.05350960f, 0.01885400f, 
    0.00206036f, 0.17715083f, 0.05060425f, -0.11307652f, 0.06798203f, -0.08428260f, -0.14205262f, 0.09161510f, 
    0.12616558f, -0.01653674f, 0.14114742f, 0.06867517f, -0.08608145f, -0.16285370f, 0.10894430f, -0.00759861f, 
    0.04654301f, -0.03826637f, 0.07341965f, -0.03580144f, -0.00176929f, -0.05326496f, 0.01470339f, 0.05848473f, 
    0.23294376f, -0.02553815f, 0.00650547f, -0.05640124f, -0.03563870f, -0.03882180f, 0.04126219f, -0.02406843f, 
    -0.04337690f, -0.05157878f, -0.03021444f, 0.01486029f, 0.22341244f, -0.06157829f, 0.05272928f, 0.15631957f, 
    0.04526270f, -0.20804805f, -0.00119981f, 0.02370615f, -0.13682550f, 0.05398419f, -0.11460101f, -0.07442972f, 
    -0.23042417f, -0.08304393f, -0.17090262f, -0.00478924f, -0.08883578f, 0.00062007f, 0.08472601f, 0.04169210f, 
    -0.09950946f, 0.07093427f, 0.10330675f, -0.02616301f, 0.23239031f, 0.12207438f, -0.16314410f, -0.06067213f, 
    0.20503999f, -0.02646975f, -0.02860913f, -0.01109934f, -0.01671402f, 0.00692152f, -0.04433973f, -0.05277159f, 
    0.14981584f, 0.05689806f, 0.03939636f, -0.12575622f, -0.16815975f, 0.09959971f, -0.04057608f, -0.07219826f, 
    0.00196272f, 0.02875506f, -0.15915708f, -0.03845013f, 0.16104667f, 0.09524566f, -0.11262764f, 0.17509864f, 
    -0.08525520f, -0.11375014f, -0.12808637f, -0.07462523f, 0.06770605f, -0.03117518f, -0.09484518f, 0.01719795f, 
    0.37470961f, -0.15625051f, -0.01987225f, -0.07083184f, 0.00498326f, -0.08313547f, 0.01239692f, -0.06348125f, 
    0.04935956f, 0.01405668f, -0.01195493f, 0.07961567f, -0.19372940f, 0.07945786f, -0.16393894f, -0.24538358f, 
    0.00359150f, -0.00128407f, -0.01774807f, 0.03551408f, 0.06639259f, -0.06803712f, -0.08096716f, -0.03878072f, 
    0.02092419f, 0.10484263f, 0.00225414f, -0.11838027f, -0.11318242f, 0.14068393f, 0.00796226f, 0.07206443f, 
    -0.00857567f, -0.03034977f, 0.00442251f, -0.01724631f, -0.05915644f, -0.09926589f, 0.02816075f, 0.05122804f, 
    -0.15118206f, 0.01627811f, 0.02592077f, 0.07162970f, -0.06919336f, -0.00320789f, 0.04919863f, -0.07427868f, 
    -0.22288749f, 0.11281386f, -0.07683243f, -0.24568872f, 0.23045166f, -0.12048555f, 0.07192285f, -0.05768748f, 
    0.02491301f, 0.03258639f, 0.09024696f, -0.06005577f, 0.15706822f, -0.04226328f, 0.00889446f, 0.01221408f, 
    -0.12946059f, 0.02810497f, -0.07181039f, -0.15761402f, -0.01927874f, 0.05716954f, 0.02912758f, 0.03653052f, 
    0.52663481f, -0.00391843f, -0.36583003f, -0.02324849f, 0.06892730f, -0.06755325f, -0.01075257f, -0.01752092f, 
    -0.00563502f, 0.02192577f, 0.04594890f, 0.06202842f, -0.03436487f, -0.01354529f, -0.18918699f, -0.02710051f, 
    0.02640483f, 0.07972365f, 0.01358151f, 0.02866376f, 0.03225205f, -0.02109375f, -0.08293790f, -0.05737676f, 
    0.02660165f, 0.11016791f, -0.18653145f, 0.07427862f, -0.04876536f, -0.02020313f, 0.01052414f, -0.08172714f, 
    -0.11681684f, 0.02851229f, -0.08620548f, -0.03111479f, -0.00293143f, 0.01606997f, -0.04556909f, 0.01707193f, 
    -0.03650662f, 0.09393469f, -0.04073969f, 0.01792200f, 0.00614504f, -0.02890278f, 0.04281029f, -0.19707778f, 
    -0.01791559f, 0.14578399f, -0.11590547f, 0.09640998f, 0.03345703f, -0.04274766f, -0.01218073f, -0.18433702f, 
    0.02249425f, 0.15350153f, -0.08189794f, 0.02648626f, -0.26879692f, 0.33021420f, 0.04500675f, -0.17677602f, 
    -0.08595914f, 0.13618177f, 0.05782167f, -0.10945518f, 0.09899493f, 0.07724821f, -0.00307665f, -0.15840821f, 
    0.15127055f, -0.24120119f, -0.24215135f, 0.03562810f, 0.01674172f, 0.03475616f, -0.21780813f, -0.06776461f, 
    0.05502453f, -0.07882316f, -0.14716284f, 0.09686656f, -0.07767446f, 0.04756866f, -0.09967761f, 0.07508182f, 
    0.05170017f, -0.07928430f, 0.03000631f, 0.16182643f, -0.09076761f, 0.13322918f, -0.02291818f, -0.06003368f, 
    -0.10726403f, 0.12479820f, 0.06436376f, 0.00005681f, 0.03286039f, -0.11202984f, 0.03062047f, -0.09649795f, 
    -0.01356681f, 0.00687455f, 0.05804338f, -0.02550788f, -0.17542499f, -0.20783411f, 0.14293629f, 0.14533994f, 
    0.13706581f, -0.01793388f, 0.04878018f, -0.02962009f, -0.01876838f, -0.11512858f, -0.05014504f, 0.12328083f, 
    0.07468966f, -0.08358932f, -0.13684806f, 0.22724788f, 0.03899485f, -0.05758203f, 0.11948267f, -0.08118565f, 
    0.00988506f, -0.02464443f, -0.04787512f, -0.08801503f, -0.04662962f, -0.03634335f, 0.03059491f, 0.05149058f, 
    0.05659116f, 0.05396170f, 0.01314587f, 0.02097912f, 0.05875155f, -0.00560759f, 0.02828671f, -0.02528997f, 
    0.17398618f, -0.18598963f, -0.13838528f, -0.03022245f, -0.06163936f, -0.03666009f, 0.01672595f, -0.04583026f, 
    0.10206572f, 0.04178095f, -0.01529961f, -0.02885696f, 0.31756297f, 0.06342503f, 0.03187761f, 0.09563147f, 
    -0.13849601f, -0.05991019f, 0.09320363f, -0.02809368f, -0.05108478f, -0.10703524f, -0.06581921f, -0.09481081f, 
    -0.02186964f, -0.18752742f, 0.03888183f, -0.20862265f, 0.03824803f, -0.03050979f, 0.01779748f, -0.03173124f, 
    -0.01074824f, 0.07949355f, 0.12049732f, 0.00440951f, -0.12646791f, 0.10646681f, 0.00250717f, 0.15305024f, 
    0.13667503f, -0.01343414f, -0.04348932f, 0.08797496f, -0.03570390f, -0.00796442f, -0.04653912f, -0.08402432f, 
    -0.16726896f, 0.01860820f, 0.11442953f, 0.06855213f, 0.04942609f, 0.04565381f, 0.04296890f, -0.03615534f, 
    -0.08518918f, 0.01064176f, -0.07157114f, -0.04094101f, -0.26627368f, -0.01373903f, 0.02196432f, -0.04668118f, 
    -0.02709596f, -0.03198591f, -0.06819465f, -0.04582317f, 0.03777317f, -0.00147710f, -0.02969731f, -0.13564584f, 
    0.09333586f, -0.19635595f, 0.01543780f, -0.00788257f, 0.01863453f, 0.02827394f, -0.02088078f, -0.00839110f, 
    0.05174979f, 0.05318411f, -0.00571256f, -0.02689336f, -0.26881289f, 0.00951571f, -0.10330151f, 0.02112250f, 
    0.10530088f, -0.02504856f, 0.05564054f, 0.04669036f, -0.12985720f, -0.04606428f, 0.07197356f, 0.08178814f, 
    -0.12465383f, -0.18427612f, 0.09877915f, 0.25308385f, 0.10724094f, 0.10195903f, 0.04733264f, 0.06907839f, 
    -0.14803068f, -0.03345295f, -0.03111355f, -0.00898113f, -0.13823302f, -0.11102039f, -0.01909617f, -0.13945316f, 
    0.06685166f, -0.04658621f, 0.07373317f, 0.01332048f, -0.01376972f, 0.04926022f, -0.01957030f, -0.04993893f, 
    0.19439769f, -0.07526293f, -0.21387281f, 0.09025194f, 0.04669813f, 0.10966241f, -0.09933864f, 0.03362596f, 
    -0.08639314f, 0.03814933f, 0.10176022f, 0.03484359f, 0.07113788f, 0.00360490f, -0.04421692f, 0.02619135f, 
    -0.10932972f, -0.06368256f, -0.00099648f, 0.03341555f, -0.04127016f, -0.03803730f, -0.06910206f, 0.00963129f, 
    -0.05110991f, -0.07723530f, -0.10280518f, 0.16665949f, -0.19728957f, -0.07052987f, 0.09206006f, 0.12783793f, 
    0.08767398f, -0.08053596f, -0.06679858f, 0.03844745f, -0.09467835f, 0.09564403f, -0.08393150f, 0.04813137f, 
    -0.01152393f, -0.04218984f, 0.01660754f, 0.07939415f, 0.01963267f, 0.01558456f, -0.17711519f, -0.14240865f, 
    0.07882859f, -0.02228713f, -0.07332925f, -0.05351172f, 0.12339102f, -0.08351650f, -0.09063451f, 0.05362169f, 
    0.02870902f, -0.00946856f, -0.01711583f, -0.02770695f, 0.17861356f, 0.03769860f, 0.07759215f, -0.05578161f, 
    0.02467890f, -0.08509964f, 0.13259576f, -0.05166657f, 0.01824551f, 0.04522697f, 0.03926622f, 0.09298756f, 
    0.15819056f, -0.16460901f, 0.10067496f, 0.14196691f, -0.02631075f, 0.00581938f, -0.03404537f, -0.05498748f, 
    -0.10039971f, 0.01357732f, 0.08227443f, 0.00644656f, -0.04306665f, 0.03015145f, -0.20185290f, -0.14561911f, 
    -0.09671313f, 0.00476400f, -0.01465713f, 0.10840314f, 0.04365951f, -0.04876888f, 0.06425452f, 0.06320023f, 
    -0.41851908f, -0.32997313f, -0.16220891f, -0.30808294f, 0.04232047f, -0.04230748f, 0.03179673f, -0.05802158f, 
    0.04535401f, 0.05533512f, -0.00231635f, 0.03245752f, -0.03284530f, -0.30054238f, 0.06454689f, 0.10898875f, 
    0.01047844f, 0.07241277f, -0.06239767f, -0.01840881f, -0.04762945f, -0.02409549f, -0.05005323f, -0.05574604f, 
    0.41246852f, 0.07120794f, -0.09510335f, -0.16400388f, 0.16472112f, -0.13371392f, 0.07108152f, -0.01920771f, 
    0.10242363f, 0.08090337f, 0.05830239f, 0.02609836f, 0.17027314f, -0.10974366f, 0.01484436f, 0.07013579f, 
    -0.08007951f, -0.03338310f, -0.08140197f, -0.13025531f, 0.12573868f, -0.05316541f, 0.08214183f, -0.08087860f, 
    -0.13026150f, -0.00945167f, 0.06327653f, 0.09684114f, 0.03494064f, 0.02481494f, -0.04279526f, -0.10225440f, 
    -0.05540809f, -0.11177664f, 0.06918919f, -0.07942714f, 0.14144449f, -0.25187415f, -0.21662389f, 0.03884075f, 
    -0.01508562f, -0.06292471f, -0.13704230f, 0.00433997f, -0.10768688f, 0.04834044f, -0.11834574f, -0.01601295f, 
    -0.09958842f, -0.18187353f, -0.01733439f, 0.01895761f, 0.04495422f, 0.03626797f, -0.00144971f, 0.06140736f, 
    -0.04585662f, 0.06301654f, -0.12705086f, 0.01722185f, 0.41599408f, 0.03340201f, -0.10991902f, -0.11523127f, 
    0.03553521f, 0.04880430f, -0.00897683f, 0.07098460f, 0.08369426f, -0.10193900f, -0.01941349f, -0.09287493f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04124700f, 0.01191414f, -0.04810661f, 0.00107604f, 0.03311024f, -0.00190919f, 0.03138510f, -0.06521987f, 
    -0.02337245f, 0.01425870f, 0.08464754f, 0.01734598f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
