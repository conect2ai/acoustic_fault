#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.99063456f, -0.29930213f, 1.09050000f, -0.69220835f, -0.40793628f, 0.83166444f, -0.68334258f, 0.10593634f, 
    0.25115368f, 0.54757273f, 0.80041659f, 0.34326419f, -0.02511744f, -0.30824396f, -0.09400920f, 0.08284514f, 
    0.12523405f, 0.45434514f, 0.29991832f, -0.53671455f, 0.51669472f, 0.77232778f, 0.16527641f, 0.10387534f, 
    0.28231853f, 0.06770066f, -0.99768090f, 0.49594605f, 0.31024632f, 0.80874634f, -0.15056099f, -0.64128685f, 
    -0.63147509f, -0.96454066f, -0.75139958f, 0.18254349f, 0.47665191f, 0.16645144f, 0.66832638f, 0.53460723f, 
    0.30344343f, 0.31533217f, -0.19572166f, 0.44937870f, 0.42851388f, 0.32989919f, 0.14658386f, -0.30578572f, 
    0.42588037f, 0.00599511f, -0.30136803f, -0.29757890f, -1.36556816f, -1.49051142f, -0.19588073f, 0.74897021f, 
    -0.82113725f, -0.41604429f, -0.51409829f, -0.52579492f, 0.12174781f, 0.36766404f, 0.21766846f, 0.37404412f, 
    -0.04537082f, 0.12995498f, -0.27040184f, -0.22537777f, -0.10267708f, 0.15238319f, 0.44386378f, 0.04639439f, 
    0.43974760f, -0.12473360f, 0.44560423f, 0.64694589f, 1.74163783f, 1.14865756f, 0.17783554f, 0.28320077f, 
    -1.67561781f, -0.12417080f, -0.09152569f, -0.49805611f, -0.08070412f, 0.02187095f, -0.15624411f, -0.29631132f, 
    0.06022937f, 0.27600229f, -0.06825301f, -0.16487460f, 0.19982827f, -0.07824235f, -0.19858871f, 0.05665543f, 
    0.16388951f, 0.07523958f, 0.13458987f, 0.34369886f, -1.28481042f, 0.27558434f, -0.13360238f, 0.25274581f, 
    -0.32073835f, 0.77955830f, -0.48468128f, -0.94184798f, -0.32455653f, -0.86325866f, -0.02618501f, 0.64822561f, 
    -0.79798079f, 0.40713480f, -0.62428784f, -0.43174487f, 0.28220811f, 0.03543665f, 0.01079580f, -0.07219942f, 
    -0.26841587f, -0.07061686f, -0.03710566f, 0.14218926f, -0.01392679f, -0.52647173f, -1.26149869f, -0.09266846f, 
    0.58750749f, -0.39288253f, 0.69998616f, 1.84351456f, 0.36973521f, 0.80635035f, 0.87159079f, -0.38888168f, 
    0.40948835f, -0.03772766f, 0.20624925f, -0.42802203f, -0.36192927f, -0.21062258f, 0.08240954f, -0.28395501f, 
    -0.03567723f, 0.12413688f, -0.35603431f, 0.31196615f, -0.33991572f, -0.24499466f, 0.88000029f, 0.58675343f, 
    1.24630284f, -0.60698110f, -0.45435143f, -0.22249182f, -0.46971965f, 0.46303436f, 0.70805359f, 0.62672246f, 
    -0.62134796f, 0.05376218f, -0.01818279f, -0.15696415f, -0.63151485f, -0.01419029f, 0.46531734f, -0.14296024f, 
    -0.21484372f, -0.35332090f, -0.21282475f, -0.11317169f, 0.13180551f, -0.16191152f, -0.28245074f, 0.43561527f, 
    -0.36833495f, 0.33197340f, 1.08947241f, -0.80803257f, -0.17967182f, -0.76746756f, 0.10394812f, -0.91646326f, 
    0.39105102f, -0.05676856f, 0.15985604f, 0.54373479f, -0.30498087f, 0.34798914f, -0.80405164f, -0.45411405f, 
    0.09610588f, -0.10079009f, -0.44122657f, 0.43774381f, -0.02307734f, -0.29733410f, -0.25251210f, -0.51432347f, 
    0.04654805f, -0.96066558f, -0.87535036f, 0.79921538f, -0.53074205f, -1.25486541f, -0.28054386f, 0.24991889f, 
    -0.55800313f, -0.25052553f, -0.69113177f, 0.04313506f, -0.02095903f, -0.07150278f, 0.08975476f, 0.40830854f, 
    0.17150344f, -0.33691961f, -0.58245969f, -0.25336614f, 0.00216984f, -0.02436569f, 0.24116355f, 0.20489782f, 
    0.68138617f, 1.22092080f, 0.86283565f, -0.20206387f, 1.71497810f, 1.39911473f, 0.09536310f, -0.83750021f, 
    0.06377286f, 0.15401138f, 0.35519728f, 0.07319751f, 0.19269747f, -0.29887795f, -0.02203023f, -0.07190252f, 
    0.28343156f, 0.01735632f, 0.49964920f, -0.00566709f, 0.30895066f, 0.22038797f, 0.12834074f, -0.02716303f, 
    -0.20961393f, -0.05870653f, -1.23176098f, -0.54220301f, 1.33155215f, 1.02165842f, -0.54145044f, -0.11502431f, 
    0.26269946f, 0.99265784f, -0.36734769f, -0.44399026f, -0.01499428f, -0.08506288f, 0.16157322f, 0.12355619f, 
    0.33312419f, 0.32263803f, 0.61106783f, 0.01118556f, -0.05917720f, 0.10408621f, -0.26771617f, 0.03464019f, 
    -0.52538359f, 0.14614381f, -0.38160047f, 1.75136232f, 0.54244983f, -0.63436902f, 1.04218733f, 0.41661727f, 
    0.68544251f, 0.59535235f, 0.43812665f, 1.17243838f, 0.48906720f, -0.72228849f, -0.10924307f, 0.27154738f, 
    -0.20166747f, -0.01306230f, -0.39615989f, -0.38477692f, -0.06603780f, 0.32155874f, 0.20277257f, 0.26929748f, 
    -0.01528072f, 0.06068907f, 0.05531143f, 0.22482726f, -1.04447174f, -1.49132323f, -1.14663815f, -0.99306828f, 
    -0.61840397f, -0.93095469f, 0.52194983f, 0.97498834f, 0.09453417f, 0.19126458f, -0.21371832f, -0.19063018f, 
    0.07351118f, -0.08381138f, -0.01872375f, -0.03382990f, 0.27159232f, 0.15589608f, -0.09508428f, -0.24907525f, 
    -0.23108502f, 0.04320034f, -0.18512958f, -0.22619706f, -0.13298564f, 1.01838982f, 1.36385393f, 1.32604873f, 
    0.62420446f, 0.37721306f, 1.05978370f, 0.32557058f, -0.84324044f, 0.01186310f, -0.25986147f, 0.36117464f, 
    0.69297397f, -0.06889620f, 0.29826215f, -0.07139698f, 0.24852042f, -0.05352353f, 0.14985949f, -0.02753760f, 
    -0.20054720f, 0.19135353f, -0.12868470f, -0.04001290f, -0.18311235f, 0.35224974f, -0.71827060f, -0.67474103f, 
    -1.28945053f, 0.41808802f, 0.82760596f, -0.20022084f, 1.29947615f, 1.04790759f, -0.68160212f, -0.21013252f, 
    -0.26788801f, -0.46647131f, -0.28910756f, -0.09351518f, 0.08533189f, -0.00250345f, 0.15857381f, -0.13722715f, 
    -0.08609864f, -0.16912591f, 0.68777835f, 0.40076748f, 0.23872016f, 0.51709354f, -0.11189795f, -1.96821725f, 
    1.32046008f, 1.29460132f, -1.05206180f, 0.25347194f, 0.77194679f, 0.79005766f, 0.18832909f, 0.76126748f, 
    -0.02121231f, 0.21486883f, -0.06937550f, -0.13329102f, -0.36077875f, -0.19916818f, 0.09991998f, -0.19693935f, 
    -0.21714212f, -0.53254414f, -0.24716969f, 0.00268176f, -0.06276165f, 0.03314253f, 0.01527594f, -0.15095630f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38392845f, 0.34138766f, 0.52134329f, 0.40302271f, 0.40557548f, 0.33016646f, 0.17430097f, 0.19703193f, 
    0.30517069f, -0.09739604f, 0.12714668f, 0.23175313f, 0.23814388f, 0.35760221f, 0.02441636f, 0.07957879f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09527999f, -0.21079268f, -0.07823037f, -0.48902002f, 0.03027907f, 0.21736954f, 0.10318036f, -0.31263438f, 
    -0.02766582f, 0.27173868f, -0.20000751f, -0.04320569f, 0.24992116f, -0.33236212f, 0.10741781f, -0.11555871f, 
    0.09743436f, 0.11119278f, 0.02914415f, -0.13233796f, -0.03574953f, -0.00274166f, 0.00479029f, -0.15307166f, 
    -0.28330326f, -0.43422052f, 0.21516447f, -0.35361367f, -0.25143254f, 0.07066108f, 0.25417328f, 0.01012786f, 
    -0.09075726f, -0.06716642f, -0.03288551f, -0.02102665f, 0.16762584f, 0.15127125f, 0.00094234f, -0.11783668f, 
    -0.17177601f, -0.27822283f, -0.02459148f, -0.04509185f, -0.13646783f, -0.14561307f, -0.22561955f, -0.13988332f, 
    -0.97784477f, 0.18187760f, -0.17723119f, 0.09239582f, 0.12286956f, -0.18410438f, -0.11990373f, 0.09083042f, 
    -0.08890042f, 0.11657974f, 0.01033778f, -0.18629649f, -0.09249654f, 0.44766611f, -0.05145147f, -0.03661447f, 
    -0.05901483f, 0.00658597f, 0.05662539f, -0.10384221f, -0.10109617f, 0.07711802f, 0.03267188f, 0.02280977f, 
    0.07840586f, 0.09060868f, -0.44651517f, -0.02203950f, -0.25626937f, -0.28675094f, -0.18095201f, -0.04888463f, 
    0.02160042f, -0.03403978f, 0.01486891f, -0.00001965f, -0.13990739f, -0.06346497f, -0.43554798f, 0.16376373f, 
    -0.07881839f, 0.05299591f, 0.03723980f, -0.21374360f, -0.29058135f, 0.03006530f, -0.10234661f, -0.01784998f, 
    -0.04131842f, -0.56092906f, 0.03439711f, 0.53739572f, -0.02981909f, -0.01845493f, -0.06896544f, -0.13531823f, 
    0.10995908f, 0.13543034f, 0.13342808f, -0.18632239f, 0.72743273f, 0.00696237f, 0.33263841f, 0.42642352f, 
    -0.42684859f, 0.13792683f, -0.01061187f, 0.13131455f, 0.04646017f, 0.12924883f, 0.07406498f, -0.07968041f, 
    -0.81814343f, 0.47440857f, 0.04688176f, 0.67020428f, 0.07094783f, 0.08988152f, 0.24822238f, 0.16000532f, 
    -0.00024685f, -0.19057713f, 0.03451338f, -0.12935767f, 0.22729695f, -0.15519929f, -0.36616796f, 0.29726532f, 
    0.10500649f, -0.00520162f, -0.22747084f, 0.05852548f, -0.05871793f, 0.16070579f, -0.00795562f, 0.14436145f, 
    -0.30266041f, 0.18886501f, -0.14215770f, -0.37625143f, 0.13271624f, 0.11537605f, -0.03844627f, 0.09520919f, 
    0.20670713f, -0.11559197f, -0.08120407f, 0.33125052f, -0.02596849f, -0.02494357f, -0.08823388f, -0.19917774f, 
    -0.21677648f, -0.20508753f, 0.12956175f, 0.08681056f, 0.00077796f, -0.02511312f, -0.08714550f, -0.00861713f, 
    -0.81331438f, 0.62522173f, 0.21430923f, -0.10627636f, 0.04744682f, 0.19394106f, -0.24146639f, -0.02015419f, 
    0.01900453f, 0.12014493f, 0.12375179f, 0.08770222f, 0.45012507f, -0.22025478f, 0.33111584f, 0.08227436f, 
    -0.04169180f, -0.03757589f, 0.10267219f, -0.17995463f, 0.03025463f, -0.18832834f, 0.10250403f, -0.08590879f, 
    -0.16474128f, 0.17544289f, 0.19053730f, 0.16133612f, -0.20594987f, -0.02572730f, -0.11722833f, 0.11705697f, 
    0.12215422f, -0.08019151f, 0.18271531f, 0.08506513f, -0.42306468f, 0.10858931f, -0.01666414f, -0.22106963f, 
    -0.06265888f, 0.10041067f, -0.13564853f, -0.05468629f, -0.07441496f, 0.11920442f, -0.07774527f, 0.24291600f, 
    0.12557665f, -0.01286505f, 0.11144611f, -0.35314283f, 0.09213907f, -0.04167764f, 0.22982118f, 0.12214536f, 
    0.00208461f, 0.25101542f, 0.06809475f, -0.03838325f, 0.02059198f, 0.25050980f, -0.44933885f, 0.01582429f, 
    0.06520474f, 0.12739502f, 0.17006221f, 0.00503800f, 0.04176451f, -0.02300735f, -0.13171364f, 0.37543273f, 
    0.03708080f, -0.10480516f, -0.95342100f, -0.07820923f, 0.17288299f, 0.16997811f, 0.07634342f, 0.06623376f, 
    -0.05627645f, 0.03251356f, -0.01677290f, 0.01390090f, 0.34161162f, -0.08021422f, -0.11309265f, 0.07179862f, 
    0.05919644f, 0.19999094f, 0.10475249f, -0.13443279f, 0.02955327f, -0.00435525f, 0.09556395f, 0.11806250f, 
    0.08089103f, 0.27881035f, -0.06554490f, 0.14769688f, -0.00118058f, -0.42716712f, 0.21907252f, 0.03399881f, 
    0.05544740f, -0.37354010f, 0.00430039f, -0.20442168f, -0.51430726f, 0.07839049f, -0.11196433f, 0.30356506f, 
    -0.06802963f, -0.04179509f, -0.10340670f, -0.03581974f, 0.21802366f, 0.02851816f, -0.00841522f, -0.09000356f, 
    -0.38064295f, -0.29411027f, -0.21095490f, -0.06470396f, -0.16486354f, 0.01900497f, -0.17867659f, 0.13281338f, 
    -0.22396050f, -0.15572055f, 0.07360795f, -0.07720101f, 0.07322055f, -0.31804144f, 0.01667218f, 0.36799347f, 
    -0.00204408f, -0.10254838f, -0.16768645f, 0.00040581f, 0.07495622f, -0.08958257f, -0.05232362f, 0.06414805f, 
    -0.36945665f, 0.03839646f, -0.23323135f, 0.26595962f, -0.13705514f, 0.01381839f, -0.21441510f, -0.36674783f, 
    -0.16305836f, -0.06357461f, -0.05810908f, 0.05326981f, 0.66080868f, -0.16731100f, 0.28337398f, 0.25464538f, 
    -0.01448208f, -0.03182402f, -0.09357974f, 0.04881289f, 0.04957239f, 0.11758669f, -0.08108900f, 0.06965826f, 
    0.41118121f, 0.00022983f, 0.10623299f, -0.13292669f, -0.12123155f, -0.33811900f, 0.11908292f, 0.02580252f, 
    0.01806257f, 0.06075658f, -0.05867731f, -0.09940460f, 0.25393695f, -0.13984258f, 0.50193614f, 0.18719958f, 
    -0.23564732f, -0.18419704f, -0.08446481f, 0.03133622f, -0.02111703f, -0.05721835f, -0.00517707f, 0.06023195f, 
    0.12519608f, 0.09799434f, -0.36735585f, -0.07448727f, -0.07318762f, 0.11411683f, -0.11418961f, -0.13113287f, 
    0.38130826f, 0.04575278f, -0.15004577f, 0.07633188f, -0.89497513f, -0.05417596f, -0.08873149f, -0.33323750f, 
    -0.03105165f, 0.06925418f, 0.02521123f, -0.08914889f, 0.01845496f, -0.04742496f, -0.02648642f, -0.05452390f, 
    -0.33930367f, -0.03966664f, 0.30498546f, -0.31801978f, -0.24193951f, 0.07987808f, 0.05141260f, -0.14893429f, 
    -0.17270812f, -0.05763431f, 0.00334162f, 0.06343126f, 0.41540974f, -0.09024031f, 0.06991740f, -0.06524810f, 
    -0.04017393f, 0.01828505f, 0.22098777f, -0.05453373f, -0.18636557f, -0.37471393f, -0.08822116f, -0.22335859f, 
    -0.79816884f, -0.18325813f, -0.05843452f, -0.38983533f, -0.14300993f, -0.38285187f, -0.13096492f, -0.09699926f, 
    -0.08344903f, 0.09498908f, -0.14765854f, 0.02737541f, -0.23359102f, 0.14282276f, -0.60945815f, -0.15091719f, 
    0.19066831f, 0.10164077f, 0.03512235f, -0.23853375f, -0.09145251f, -0.06683072f, -0.04820028f, -0.05981199f, 
    0.18060751f, -0.31996804f, -0.01975125f, -0.49994785f, -0.15497769f, -0.06213796f, -0.03771025f, -0.07269815f, 
    -0.27225354f, -0.05386344f, -0.00092991f, -0.26773751f, 0.53085041f, -0.02136602f, 0.28753367f, 0.16341685f, 
    -0.15528302f, 0.11573633f, 0.08509903f, 0.06714099f, 0.12133070f, 0.19001746f, -0.19651683f, -0.15112352f, 
    -0.15932815f, 0.16804311f, -0.03438728f, -0.01658637f, -0.08930174f, -0.04229106f, 0.29074872f, -0.09268446f, 
    0.02226792f, 0.10242455f, 0.06287704f, -0.08760499f, -0.11910174f, -0.10727970f, -0.02630354f, -0.48772725f, 
    -0.21108679f, 0.02939759f, -0.07156014f, 0.01666337f, 0.05428256f, 0.11471336f, 0.02895585f, -0.17206360f, 
    0.96175987f, -0.29180285f, -0.60458958f, -0.09857888f, -0.18659796f, 0.06416958f, -0.19990495f, -0.09010573f, 
    0.11488514f, 0.05232351f, 0.07797817f, -0.08315980f, 0.10492070f, -0.05443026f, -0.09777852f, 0.19577834f, 
    0.08173027f, -0.00492544f, 0.03269777f, -0.12215734f, -0.11132339f, -0.07744006f, 0.11318393f, -0.09588618f, 
    0.28643811f, -0.14346874f, -0.55190051f, -0.11637703f, -0.29362196f, 0.18753742f, -0.01477438f, -0.01675485f, 
    0.21739636f, -0.19050354f, -0.06299222f, -0.13116607f, 0.38395765f, -0.04019165f, -0.05434433f, -0.01684784f, 
    -0.13173786f, -0.13459674f, 0.14925911f, 0.13999203f, -0.09840875f, 0.05482007f, -0.00089888f, 0.08612540f, 
    0.39303321f, 0.26833621f, -0.22783116f, 0.71166015f, -0.62765938f, -0.27056968f, 0.26122847f, 0.33316708f, 
    0.09020088f, -0.12793761f, 0.04001485f, 0.09364399f, 0.23377086f, -0.24786185f, -0.10033308f, -0.07561378f, 
    0.37535411f, 0.18309517f, 0.10720947f, -0.16589461f, -0.08470150f, 0.06923020f, -0.14639688f, 0.10842269f, 
    0.21618585f, -0.12912859f, 0.01744277f, 0.39900386f, -0.06748516f, -0.17947233f, -0.17353976f, 0.04489525f, 
    0.01634549f, -0.07546203f, 0.03811048f, 0.17667033f, 0.80231565f, -0.15185499f, -0.37144095f, -0.05536698f, 
    0.01357652f, 0.18021691f, 0.14511690f, 0.02130168f, -0.25771493f, 0.00961049f, 0.05642907f, -0.00396654f, 
    -0.31421164f, -0.33270344f, -0.14201501f, 0.13325484f, -0.07759590f, -0.04866225f, -0.01676913f, 0.01402385f, 
    0.02953511f, 0.08999972f, -0.07866465f, -0.00530098f, -0.06168622f, 0.21125329f, 0.17900489f, 0.37477192f, 
    0.17416276f, 0.25724202f, 0.15257569f, -0.17818812f, -0.11025979f, -0.30063072f, -0.20460518f, -0.17551152f, 
    0.28558886f, 0.07268841f, -0.01629134f, -0.11240833f, -0.21515360f, -0.10628709f, 0.19393173f, 0.09044341f, 
    -0.09986506f, -0.00183854f, 0.04530718f, -0.19139102f, -1.02307987f, -0.27924526f, -0.31487390f, 0.16341282f, 
    -0.07478117f, 0.08516472f, 0.06637925f, 0.00533477f, -0.02741955f, 0.11807291f, 0.12648973f, -0.23158696f, 
    0.84210491f, 0.33333495f, 0.14697917f, 0.19538654f, 0.13973421f, -0.04352010f, 0.06819081f, 0.24718145f, 
    -0.13414346f, -0.00268899f, 0.09954728f, -0.02582314f, -0.33927482f, -0.02190671f, -0.11939383f, -0.21950737f, 
    -0.23894328f, -0.07715361f, -0.06715857f, -0.11321374f, -0.26668185f, -0.02128823f, -0.00760584f, -0.10214537f, 
    -0.61670280f, -0.14469840f, -0.22658904f, -0.04529502f, 0.07594301f, 0.03608520f, -0.02536230f, 0.04649345f, 
    -0.09023249f, 0.35753495f, -0.13522890f, 0.24299073f, 0.61766851f, -0.07284915f, 0.04194901f, 0.24952918f, 
    0.03751405f, 0.17232002f, 0.00479586f, -0.04645429f, 0.12436579f, 0.18086387f, 0.07348017f, -0.02375007f, 
    0.56687522f, -0.14404051f, 0.14445835f, 0.04761346f, 0.10530850f, -0.01431735f, -0.16311601f, -0.02247622f, 
    0.06709433f, 0.09293155f, -0.06151681f, 0.00186277f, 0.20604669f, -0.20925200f, -0.46500203f, 0.54926556f, 
    0.02350247f, 0.10848457f, 0.14395508f, -0.23506124f, 0.07219437f, -0.10030066f, -0.02342345f, -0.05236397f, 
    0.07775478f, 0.03072786f, 0.22616594f, -0.35820931f, 0.17849319f, -0.30928516f, 0.12340946f, -0.00563647f, 
    -0.08008611f, -0.18794975f, 0.04750623f, 0.06330425f, -0.28466353f, -0.36524943f, -0.58180428f, -0.51485246f, 
    0.04894594f, -0.25789183f, -0.03962198f, -0.09092575f, 0.14153901f, -0.10529149f, -0.01013901f, 0.03566247f, 
    0.24551745f, -0.29647738f, -0.05966898f, -0.30391404f, -0.34259117f, -0.30414200f, 0.00136605f, -0.00284378f, 
    -0.17696899f, -0.10010684f, 0.00504306f, 0.09416989f, 0.43161541f, -1.20612156f, -0.37341589f, 0.40613306f, 
    -0.30509490f, -0.02137016f, 0.08823067f, 0.11400860f, 0.15858233f, -0.01983951f, -0.21167137f, 0.02159426f, 
    -0.43992379f, 0.17423566f, 0.13759567f, 0.21181968f, -0.10408854f, 0.00950556f, 0.24071379f, 0.18326585f, 
    -0.11487079f, 0.12874375f, -0.25028637f, 0.05041798f, -0.07912677f, 0.56496000f, 0.23237726f, -0.07073087f, 
    -0.02577784f, 0.17590055f, -0.04370982f, 0.20866553f, 0.26828730f, 0.04013744f, -0.13038209f, 0.04529767f, 
    -0.07016174f, 0.03178021f, -0.14884786f, -0.23641776f, 0.11720956f, -0.00316190f, -0.00723348f, -0.11845638f, 
    -0.08334637f, -0.00339012f, -0.37078589f, -0.03987530f, -0.64414036f, 0.02263488f, 0.29348424f, 0.21865214f, 
    0.15102397f, -0.20907848f, -0.26137745f, 0.07879307f, 0.18642142f, 0.02774044f, -0.08801726f, -0.16603675f, 
    0.04611753f, 0.06023984f, -0.26479104f, 0.17356940f, 0.08830919f, -0.03773947f, 0.12297323f, 0.17871651f, 
    -0.04958159f, -0.21707103f, 0.22703621f, -0.20735374f, -0.35829422f, -0.17321762f, 0.44672900f, 0.23676392f, 
    -0.14529912f, -0.15474677f, 0.02518133f, -0.21423994f, 0.29259405f, -0.07065471f, 0.02590657f, -0.10486643f, 
    0.31642285f, -0.03702497f, 0.36537686f, -0.47537968f, -0.04879918f, 0.02734056f, 0.08735431f, 0.25494817f, 
    0.10648171f, -0.15783679f, 0.12897889f, 0.06407202f, -1.25026417f, 0.08168737f, 0.11275467f, 0.24566193f, 
    0.23140283f, -0.14108859f, -0.03729065f, 0.06301835f, -0.16568372f, 0.17745370f, -0.06185377f, 0.03530886f, 
    0.07294612f, -0.43041122f, 0.26794091f, -0.31001917f, 0.08401948f, 0.22156785f, -0.12729535f, 0.00983625f, 
    0.08679551f, 0.06426539f, 0.11748381f, 0.05739444f, -0.29432520f, -0.29231974f, 0.22215761f, -0.28023711f, 
    -0.10296827f, 0.00696133f, -0.17501391f, -0.25987780f, -0.02264882f, -0.07201263f, -0.14341035f, 0.10497249f, 
    -0.10024070f, 0.11314987f, -0.18366581f, 0.05606256f, 0.13839866f, 0.00793283f, -0.04562631f, 0.14085308f, 
    -0.14581716f, 0.07190602f, -0.05566408f, -0.00122593f, 0.19420868f, -0.05905588f, 0.02701281f, 0.14864965f, 
    0.00421235f, 0.22260232f, 0.21737313f, -0.03370367f, 0.15117738f, -0.07421322f, -0.06577467f, -0.17211553f, 
    -0.24197640f, -0.12211102f, -0.22060670f, -0.58261698f, -0.06242126f, 0.10047709f, 0.02579074f, 0.03322950f, 
    -0.11521957f, 0.15696378f, 0.03356984f, 0.08611204f, -0.03494496f, -0.02654742f, -0.02550749f, 0.24016641f, 
    -0.24219473f, 0.00308762f, 0.13528894f, -0.05111352f, -0.15762064f, 0.17102624f, -0.00215236f, 0.03239980f, 
    -0.43460637f, 0.01683388f, 0.06408777f, 0.31210220f, -0.06298658f, 0.00363214f, -0.00205346f, 0.20376556f, 
    0.04615550f, -0.05504581f, 0.16804713f, 0.05122148f, -0.38867849f, 0.48178586f, -0.08830305f, -0.13182665f, 
    -0.04759946f, -0.00423885f, -0.05721259f, 0.18256500f, 0.12282600f, -0.10538663f, -0.00512778f, -0.17035849f, 
    -0.15959431f, -0.29206279f, -0.20264295f, -0.29065678f, -0.01310921f, -0.00222620f, 0.08976178f, -0.10051648f, 
    -0.15643473f, -0.30282640f, 0.18525039f, 0.06093464f, 0.61030030f, 0.75544363f, -0.36219659f, -0.25076959f, 
    0.15582292f, 0.12166616f, 0.14446339f, 0.13973178f, -0.04509476f, 0.23452032f, -0.00102178f, 0.17058207f, 
    0.03070846f, -0.21310867f, -0.04361207f, 0.22063242f, -0.04667471f, -0.19101512f, -0.01539432f, 0.30098167f, 
    0.38058302f, -0.25588742f, 0.04442196f, 0.00555500f, -0.01129350f, -0.00224295f, 0.22850198f, 0.06153256f, 
    -0.04752365f, -0.15447758f, -0.18420215f, 0.04308856f, -0.13691767f, 0.09329490f, 0.30349261f, 0.32922426f, 
    -0.43896514f, -0.37518781f, -0.09603583f, 0.26735282f, 0.06871624f, 0.12894395f, -0.27053949f, 0.07482236f, 
    0.17117570f, 0.19736099f, 0.24944904f, 0.07201768f, 0.20113750f, -0.03637139f, 0.14774223f, 0.28101796f, 
    -0.31966510f, -0.22014503f, -0.06481273f, 0.25329635f, -0.03654216f, 0.00426812f, 0.11366105f, -0.02000515f, 
    -0.39858481f, -0.03319702f, 0.12891912f, -0.06080801f, 0.06805132f, 0.08026978f, 0.09229691f, -0.13651609f, 
    -0.07782926f, -0.00846517f, -0.16963111f, 0.05214544f, -0.52493495f, 0.21202852f, -0.12574102f, -0.36061484f, 
    0.15782996f, -0.17131959f, -0.02753563f, -0.12206746f, -0.06834830f, -0.30390325f, 0.12876402f, -0.17903708f, 
    0.10591901f, 0.05496286f, 0.02444872f, 0.00594765f, 0.21501389f, -0.07059151f, -0.22253123f, -0.14003412f, 
    -0.02263191f, -0.25154576f, -0.10253370f, 0.02992161f, 0.22066006f, 0.06182544f, 0.11494240f, 0.15425903f, 
    0.21826969f, -0.01340834f, -0.20466638f, 0.38427874f, -0.27362803f, -0.28184748f, 0.13120948f, -0.43425664f, 
    -0.19404864f, 0.10357415f, 0.03956149f, -0.08324641f, -0.05064605f, 0.15441537f, 0.22445174f, 0.08986158f, 
    0.11260843f, -0.07340464f, -0.27914980f, 0.24386169f, -0.09330917f, 0.06023854f, 0.09322666f, -0.63924128f, 
    0.00703890f, -0.05846768f, 0.11545519f, -0.02350015f, -0.07073133f, 0.12694478f, 0.12672685f, 0.26441291f, 
    -0.07862499f, -0.07117674f, -0.03729859f, -0.03895270f, 0.23198029f, 0.01602945f, 0.04484586f, 0.17923842f, 
    0.16843358f, 0.13613662f, -0.01799173f, 0.05297185f, 0.34386176f, 0.00727054f, 0.28944215f, -0.58533412f, 
    -0.29525360f, -0.00168311f, -0.17186756f, -0.21985278f, 0.02253798f, -0.03809453f, 0.03789116f, -0.15181164f, 
    -0.55706507f, -0.37303463f, -0.62492573f, 0.04684271f, 0.36140737f, 0.28820053f, -0.15749125f, -0.13623916f, 
    0.04823517f, 0.01424224f, -0.09936381f, 0.09617309f, 0.12091362f, -0.17335962f, 0.19745968f, 0.20140180f, 
    0.13994293f, 0.36831003f, -0.00316968f, -0.14569335f, -0.15435347f, 0.01488859f, 0.02114220f, 0.14729358f, 
    -0.32966843f, 0.44182935f, 0.24211039f, -0.43198964f, 0.11186441f, 0.10838552f, 0.24554154f, 0.17912231f, 
    0.09806024f, 0.07068624f, -0.01533887f, -0.27655268f, -0.43499187f, -0.61724156f, 0.38339943f, 0.36459568f, 
    -0.22219814f, -0.28474933f, -0.14263563f, -0.17084008f, 0.05128339f, -0.06886967f, -0.11606740f, -0.03762819f, 
    -0.16892694f, 0.41621250f, -0.06587178f, 0.42018327f, 0.01676706f, -0.14522721f, -0.15106943f, -0.15377629f, 
    -0.26893148f, 0.10219353f, 0.16616651f, -0.36765948f, 0.24654622f, -0.08811062f, -0.12074955f, -0.26922992f, 
    0.02256971f, 0.03397102f, 0.10897209f, 0.00778576f, -0.06576278f, -0.17380086f, -0.18738508f, -0.28356740f, 
    0.27910694f, 0.04488766f, -0.43126577f, 0.12456941f, -0.15233144f, 0.04714086f, 0.02661253f, -0.37666318f, 
    -0.14194897f, -0.19264515f, -0.17259715f, -0.05652103f, -0.30802429f, 0.34669363f, 0.08233096f, -0.19030839f, 
    0.09577304f, 0.02532852f, 0.18337515f, 0.02825662f, -0.07989484f, -0.02952026f, -0.20153470f, -0.06179902f, 
    0.26455694f, -0.14988716f, 0.29212457f, 0.07372066f, -0.12255629f, 0.12690376f, 0.07387464f, 0.07003872f, 
    0.15554465f, 0.21024832f, 0.13467960f, 0.16803946f, 0.35915583f, -0.90494198f, 0.10659579f, -0.01071039f, 
    -0.07516754f, 0.13869315f, -0.06786761f, 0.13234122f, -0.01113664f, 0.07460139f, 0.11068247f, 0.21121210f, 
    -0.52410358f, 0.41594848f, 0.12652101f, 0.48849490f, -0.09034808f, 0.14805800f, 0.15308067f, 0.21105751f, 
    0.06399966f, 0.15998241f, 0.23386547f, 0.02250769f, -0.09648333f, -0.15411443f, 0.14139089f, -0.14663032f, 
    0.09228066f, -0.04337824f, -0.05519932f, -0.01317753f, 0.00587802f, -0.18135236f, -0.17013030f, 0.31530347f, 
    0.06445278f, 0.04699946f, -0.09281395f, -0.32082215f, 0.13021466f, -0.27818507f, 0.07569589f, -0.18949500f, 
    0.03344815f, 0.01353159f, 0.24611540f, -0.20689166f, 0.16604310f, 0.42772856f, 0.30707186f, -1.06423247f, 
    -0.28065634f, 0.18009737f, -0.05445792f, -0.01721594f, 0.08903817f, 0.00312250f, 0.00026542f, -0.13700666f, 
    0.38443688f, -0.63667119f, 0.12357525f, -0.26354471f, 0.13768418f, -0.02055793f, 0.09656046f, 0.10714656f, 
    0.13096920f, 0.04249865f, 0.08881865f, -0.27352077f, -0.69225550f, 0.09623059f, 0.07754891f, -0.11994960f, 
    -0.24556257f, -0.03579598f, 0.16939242f, 0.11283421f, -0.08448315f, -0.09899956f, -0.06603800f, 0.21226855f, 
    -0.44454992f, -0.16833349f, -0.26862857f, -0.48743156f, -0.03411487f, -0.06676830f, -0.01203257f, -0.20724192f, 
    -0.04737945f, -0.07463219f, 0.17352137f, 0.20434844f, -0.23328204f, 0.32088405f, 0.06999495f, 0.07959276f, 
    -0.12033071f, -0.15823795f, -0.03259751f, 0.09103142f, 0.17909688f, -0.02590112f, 0.04434024f, -0.15544945f, 
    0.05894611f, -0.40690744f, -0.03258197f, -0.01622288f, 0.23144558f, -0.01913578f, -0.00990423f, -0.09936724f, 
    -0.13311240f, -0.04573860f, 0.02507664f, 0.12098659f, 0.19720115f, -0.38505754f, -0.11298680f, 0.36054742f, 
    0.07149120f, -0.06548385f, 0.02368701f, 0.09023089f, -0.08624984f, 0.09767041f, -0.02896747f, 0.08146604f, 
    -0.69248515f, -0.14033209f, -0.16493182f, -0.19322814f, 0.06798603f, 0.07309662f, -0.05153526f, -0.05870512f, 
    -0.08361896f, -0.07841935f, -0.11051297f, -0.19888709f, 0.09937232f, -0.08651577f, -0.07778119f, 0.01672905f, 
    -0.12592633f, -0.08488559f, -0.01584400f, -0.08413621f, 0.32406479f, -0.06074565f, -0.02317147f, -0.19350113f, 
    -0.17155369f, 0.36652836f, 0.09341688f, 0.41528958f, 0.00192008f, -0.13041121f, -0.14883824f, -0.04807025f, 
    0.03113702f, -0.17424676f, -0.28773966f, -0.16770843f, -0.01911760f, -0.53685778f, 0.20747389f, -0.13080129f, 
    0.14259297f, -0.09599681f, -0.12755813f, -0.09202911f, -0.15607782f, 0.08975528f, 0.09335063f, 0.05808092f, 
    0.00161830f, 0.04143865f, 0.24390784f, 0.47284752f, 0.09747633f, -0.16052151f, -0.06659295f, -0.07076404f, 
    0.00995059f, -0.05307150f, -0.05413602f, -0.34816328f, -0.13705753f, 0.22951774f, 0.01073427f, 0.02521029f, 
    0.00027622f, 0.02665093f, -0.10796326f, 0.08938443f, -0.00932939f, 0.04206216f, -0.18608820f, -0.09730660f, 
    0.14328149f, -0.31409532f, -0.19965859f, -0.37443325f, -0.10480706f, -0.14896719f, -0.02249135f, -0.03499900f, 
    -0.01255591f, 0.07533612f, -0.25466365f, -0.00350305f, 0.23206146f, 0.17047600f, -0.08786630f, -0.03865439f, 
    -0.29536551f, -0.27616167f, 0.16938502f, -0.12563680f, -0.25199923f, -0.18760800f, -0.13455327f, -0.02345369f, 
    0.42079562f, 0.37593859f, 0.37989783f, -0.15815309f, -0.56448334f, 0.12074161f, 0.05290135f, -0.04756870f, 
    -0.06184357f, 0.05314678f, -0.00464628f, -0.01028749f, -0.80831414f, 0.50268674f, -0.15750815f, -0.37679204f, 
    0.07486350f, 0.09352469f, -0.12643220f, -0.17225237f, -0.02730599f, -0.03090711f, 0.03621531f, -0.24055648f, 
    0.53774399f, -0.42847463f, 0.13153365f, 0.08768587f, 0.14648043f, 0.02155101f, 0.12640673f, 0.02452864f, 
    -0.00222481f, 0.09347016f, 0.11209429f, -0.09634236f, -0.30372062f, 0.34446535f, -0.07816506f, -0.15455775f, 
    -0.10620342f, 0.07508080f, -0.11689345f, -0.10183059f, -0.04744213f, 0.01163430f, 0.05906248f, -0.44467491f, 
    0.20301214f, 0.13460055f, 0.30206925f, 0.24937963f, 0.21961598f, 0.33955199f, 0.23027748f, -0.23650785f, 
    -0.12114567f, 0.08601034f, -0.17296106f, -0.08116952f, -0.63057083f, 0.34350049f, -0.03249437f, -0.34749445f, 
    0.01757241f, -0.06228578f, 0.17596641f, -0.07756185f, -0.09850447f, -0.00621490f, 0.02777294f, -0.10262109f, 
    0.48304912f, -0.60187423f, 0.30524433f, -0.14030072f, 0.00869435f, 0.03850777f, -0.02147404f, 0.35251790f, 
    0.03216325f, 0.22076003f, -0.03733665f, 0.02312059f, 0.13590421f, -0.18871935f, 0.06594478f, 0.05982305f, 
    0.22939773f, 0.10190382f, 0.04320179f, -0.18617450f, 0.01723627f, -0.03623129f, -0.10012335f, -0.11813973f, 
    0.24082723f, 0.40887746f, -0.01833780f, 0.15453503f, 0.12654671f, 0.04837741f, -0.02187743f, 0.02516219f, 
    0.10410697f, -0.11732610f, 0.09959816f, 0.28870282f, -0.26493502f, -0.09878244f, -0.34813139f, -0.09696367f, 
    -0.30342662f, -0.10900708f, 0.08480379f, -0.19790667f, 0.18982111f, 0.23146269f, 0.22291145f, 0.08009358f, 
    -0.30942100f, 0.51835155f, 0.24147472f, -0.39338544f, 0.23513472f, -0.02275367f, -0.24261938f, 0.04541946f, 
    0.18637602f, 0.03645677f, 0.24084993f, 0.07118289f, -0.10828573f, -0.36120102f, 0.13952149f, 0.04317170f, 
    0.02737205f, -0.01997541f, -0.10128609f, -0.02981194f, 0.21345527f, 0.15314092f, 0.25818589f, -0.12785649f, 
    -0.43244359f, -0.70923144f, -0.11991536f, -0.37355262f, -0.27089998f, 0.03842933f, -0.19128771f, -0.38850239f, 
    0.14715506f, -0.24736118f, -0.24727862f, 0.24772006f, 0.33349445f, -0.41510409f, 0.31413636f, 0.23809515f, 
    -0.31436914f, 0.03140952f, -0.01604126f, -0.17571041f, 0.03985487f, -0.25417763f, 0.08825036f, -0.04272682f, 
    0.33026913f, -0.06990856f, -0.14620134f, -0.25048149f, -0.04717662f, 0.04787813f, -0.21829240f, -0.15096673f, 
    0.05328194f, -0.13638268f, -0.25931606f, 0.11046071f, 0.34721401f, -0.04512502f, -0.29396361f, -0.51124048f, 
    -0.17743728f, -0.05588004f, -0.01843323f, 0.31913254f, 0.23366298f, 0.30140391f, 0.14633608f, -0.34927922f, 
    -0.26226532f, -0.09286043f, 0.02824058f, -0.67334580f, 0.05812614f, -0.03904395f, -0.00177909f, 0.26139081f, 
    0.11027686f, 0.02158712f, -0.24570881f, 0.19393721f, -0.19333164f, -0.36430264f, 0.05175244f, 0.43769741f, 
    0.29809090f, -0.15453689f, -0.04632441f, -0.06946214f, -0.03401050f, 0.29621685f, -0.01473559f, -0.00320034f, 
    -0.10657912f, -0.52661121f, 0.26713991f, -0.29968262f, -0.17143135f, -0.32546312f, -0.07721029f, -0.14914826f, 
    -0.03223733f, 0.05469530f, 0.13676649f, 0.20889063f, 0.51682144f, -0.06954159f, -0.08398695f, 0.15979174f, 
    0.01911866f, -0.09930788f, -0.09633368f, 0.00644504f, -0.09190004f, -0.09172939f, 0.06545951f, -0.33643323f, 
    -0.77662164f, -0.08749362f, 0.61353528f, -0.22494370f, 0.02156138f, -0.10768913f, -0.18167131f, -0.14075424f, 
    0.03030394f, 0.01632692f, -0.24420895f, -0.11457652f, 0.22416551f, -0.06682803f, -0.11570839f, 0.29549071f, 
    0.09763874f, 0.06898281f, -0.25273606f, -0.08962372f, -0.03164419f, -0.04940213f, 0.04075021f, 0.04509407f, 
    0.12735118f, 0.15328640f, -0.05381441f, 0.14477383f, -0.17203359f, -0.16665941f, 0.09119616f, 0.07771097f, 
    0.08507533f, -0.09614227f, -0.26515996f, 0.06101748f, 0.15439478f, 0.24673000f, -0.04649626f, 0.22365032f, 
    0.15123133f, -0.25714639f, -0.31345814f, -0.03431861f, 0.01171811f, 0.05694819f, -0.23926951f, -0.07120115f, 
    0.66741240f, 0.26546511f, 0.10760084f, -0.50219929f, -0.15201823f, -0.01366740f, 0.17285518f, -0.13592324f, 
    -0.21368414f, -0.02929084f, -0.08833450f, -0.08660959f, 0.10419282f, 0.39948389f, -0.60632402f, -0.27946126f, 
    -0.08206538f, -0.08653598f, -0.05463198f, 0.08668568f, 0.00636413f, -0.02710498f, -0.16381289f, -0.14258531f, 
    -0.56305051f, 0.06906626f, 0.33441183f, 0.29343966f, 0.09741439f, 0.14508153f, -0.19852927f, 0.03388005f, 
    0.20641112f, 0.08803079f, -0.12424294f, 0.27094790f, 0.31014493f, -0.74080753f, 0.27211320f, -0.32572567f, 
    0.05499671f, 0.19811788f, -0.42330056f, -0.10504653f, -0.26387516f, -0.09801771f, 0.05500760f, -0.15208136f, 
    -0.29415306f, -0.03649472f, -0.05018496f, 0.14906202f, -0.02228975f, 0.01003709f, -0.02346834f, -0.08815170f, 
    0.08993932f, 0.03464580f, 0.24538992f, 0.13428529f, -0.11208210f, -0.12766252f, 0.12589596f, 0.04849396f, 
    0.06807967f, 0.07497254f, 0.02820324f, -0.06254441f, 0.22641531f, 0.27899879f, -0.00742298f, 0.07644951f, 
    0.66554165f, -0.16957162f, 0.43856040f, 0.09556023f, -0.07127156f, 0.19647852f, -0.08034722f, 0.20989341f, 
    -0.11679722f, 0.12396665f, 0.05035761f, 0.06190111f, -0.38847411f, 0.11512648f, -0.18883951f, -0.39498249f, 
    0.11129884f, 0.18437375f, 0.30377194f, -0.22366253f, -0.17892900f, 0.08096838f, 0.17347018f, 0.15471511f, 
    -0.44296715f, 0.17217517f, 0.08357112f, 0.08617576f, 0.01047895f, -0.07822931f, 0.07320587f, -0.17502479f, 
    -0.18401310f, -0.02301796f, -0.00525262f, 0.14181183f, -0.72513461f, 0.16125980f, -0.06006946f, -0.34842646f, 
    -0.07963034f, -0.17209078f, -0.02772953f, -0.03081340f, -0.13066125f, -0.16443151f, 0.00035401f, -0.12597032f, 
    0.68987375f, 0.36456397f, -0.25378123f, 0.04029158f, 0.11330651f, 0.00470992f, 0.13290124f, 0.00668541f, 
    0.09097993f, -0.01760266f, -0.16656920f, 0.24656668f, -0.83857381f, 0.59113348f, 0.09206209f, 0.07821166f, 
    0.27294132f, -0.06326924f, 0.00115176f, -0.13949361f, 0.13794041f, -0.12191455f, 0.04967284f, 0.07057508f, 
    0.02470492f, -0.52194375f, -0.30512366f, 0.26456398f, 0.01384727f, 0.18685983f, 0.05015593f, 0.25438416f, 
    -0.19092345f, 0.03382570f, -0.08125357f, -0.11701912f, -0.34346551f, 0.49519607f, 0.02864017f, -0.68117499f, 
    0.14070767f, -0.01133007f, -0.02400334f, 0.11149962f, -0.18003242f, 0.05182940f, -0.00939470f, -0.20071183f, 
    0.48665816f, -0.53198206f, -0.42117119f, 0.36710709f, 0.01281317f, 0.10532735f, -0.15584220f, -0.09171573f, 
    -0.35148689f, -0.05667003f, 0.02270496f, -0.18922499f, -0.10671922f, -0.69324499f, -0.06582665f, -0.13329919f, 
    -0.00201836f, -0.00413952f, 0.06146136f, -0.02070148f, -0.04469670f, -0.05806528f, 0.27685156f, 0.11912176f, 
    -0.53565395f, -0.17294848f, 0.04933652f, 0.33046192f, 0.22574879f, 0.10994378f, 0.18826203f, -0.01495989f, 
    0.07666948f, 0.29151461f, 0.21962962f, 0.33767664f, 0.37180638f, 0.13727498f, -0.08758157f, -0.15714934f, 
    0.07252485f, 0.01375819f, -0.11334279f, 0.14517306f, -0.07229619f, 0.24716012f, 0.22337195f, 0.31022292f, 
    0.25830880f, -0.18537858f, -0.07139592f, -0.34893236f, 0.06459751f, 0.02641620f, -0.04569237f, -0.02620728f, 
    0.00288448f, 0.09623623f, -0.00305808f, 0.05600776f, -0.71726596f, 0.35973412f, 0.08254944f, -0.15985820f, 
    0.20478188f, -0.08358376f, -0.01524030f, 0.10281159f, 0.04369630f, 0.19488546f, -0.08389874f, 0.29809871f, 
    -0.05202382f, 0.11916878f, -0.09198655f, 0.27764013f, 0.06947372f, -0.00903680f, 0.20341313f, -0.04222109f, 
    0.11280818f, -0.05212569f, -0.19315775f, -0.02682745f, 0.70708287f, 0.32967213f, -0.32394698f, -0.03412548f, 
    -0.23144953f, -0.10985167f, 0.06292222f, 0.06237181f, 0.10054716f, -0.05541529f, 0.15671106f, -0.17060624f, 
    -0.82636815f, -0.19074108f, 0.34450933f, 0.20451115f, 0.12134624f, 0.07710043f, -0.09892880f, -0.28058490f, 
    -0.13374703f, -0.32788202f, -0.08091679f, -0.22972037f, 0.00025635f, -0.02384950f, 0.29190913f, 0.37485284f, 
    0.01779495f, 0.12355436f, 0.09325713f, 0.07153437f, 0.14066400f, 0.16409683f, -0.15877396f, -0.04465989f, 
    -0.19836596f, -0.33810642f, 0.14104488f, 0.10886913f, 0.20402004f, 0.11597142f, 0.20004213f, 0.09984762f, 
    0.23619308f, -0.14638655f, -0.10408645f, 0.21826935f, -0.64650708f, -0.42114022f, -0.28504220f, -0.37137774f, 
    0.15947631f, -0.14728817f, 0.00605110f, 0.18804082f, -0.11315902f, 0.14381213f, 0.03582581f, 0.13573565f, 
    -0.36810806f, -0.01809215f, -0.01682027f, 0.18355650f, -0.21469800f, 0.06977360f, -0.08238859f, -0.05605378f, 
    -0.35420886f, -0.11015409f, -0.02449617f, 0.13039362f, -0.74725640f, -0.77712554f, -0.22507778f, -0.22838460f, 
    0.07701898f, 0.22907652f, 0.07181115f, 0.15940575f, 0.37686840f, 0.12461201f, 0.00009990f, 0.11431517f, 
    0.23969728f, 0.04559519f, 0.09250658f, -0.48493820f, -0.01327554f, 0.04162864f, -0.06843433f, -0.21389438f, 
    -0.14901844f, -0.09891996f, -0.01057464f, -0.24125284f, -1.28458607f, -0.50998408f, -0.29786709f, -0.56659806f, 
    0.13535269f, 0.07130764f, -0.08435562f, -0.12729780f, 0.19227475f, 0.01676002f, 0.31140494f, 0.18034145f, 
    0.39618057f, -0.22959687f, -0.03417792f, 0.13162884f, -0.22927466f, -0.21136400f, -0.10633151f, -0.07685057f, 
    0.10927437f, 0.20597549f, -0.12056378f, -0.05138033f, -0.48249543f, 0.39328924f, -0.30699742f, -0.32108536f, 
    0.02823217f, 0.04676622f, -0.24317423f, -0.23781233f, -0.10127461f, -0.04506593f, -0.20794401f, 0.11894055f, 
    0.59818268f, -0.34779945f, 0.07395578f, -0.26453781f, 0.09395672f, 0.06557481f, -0.09118896f, -0.02950768f, 
    -0.11329182f, 0.01016593f, 0.00816388f, -0.03680138f, -0.16726995f, -0.34062642f, 0.29163924f, 0.39144272f, 
    0.00794907f, -0.14928246f, 0.15251999f, 0.25960803f, -0.08419703f, -0.04709728f, -0.28531644f, -0.15421550f, 
    0.33676690f, -0.37282014f, -0.48996475f, 0.21822819f, -0.10334970f, -0.06126715f, -0.13533077f, -0.10225841f, 
    -0.11786684f, -0.23214574f, -0.21816596f, 0.05273280f, 0.95073068f, 0.25591171f, -0.24350420f, -0.07844048f, 
    0.02274262f, 0.05093981f, 0.10753813f, 0.12705469f, 0.06479535f, -0.12167915f, -0.02453248f, 0.04497207f, 
    -0.10517910f, 0.01115944f, 0.05021889f, 0.02157342f, -0.13367966f, 0.00701295f, 0.03077269f, -0.21865350f, 
    -0.21059658f, 0.11541066f, 0.15922350f, -0.02740294f, -0.61434877f, -0.18512629f, -0.18773662f, -0.22862527f, 
    0.07891396f, 0.12988070f, 0.06692319f, 0.02865586f, -0.13251714f, -0.11608648f, -0.41943580f, -0.01790034f, 
    0.10430523f, 0.05331207f, -0.09776372f, -0.29716936f, -0.10520136f, 0.06135257f, -0.18055078f, 0.05565475f, 
    0.11399126f, 0.14029169f, 0.21317965f, 0.03517673f, 0.06242709f, 0.22755346f, 0.07466559f, -0.04579059f, 
    0.22924297f, -0.18186535f, 0.23369822f, 0.05646387f, 0.36636955f, -0.00334912f, 0.13942827f, 0.06199717f, 
    -0.11448008f, 0.46275219f, 0.02003871f, 0.02262051f, 0.13875453f, -0.07315943f, 0.16832274f, 0.22705708f, 
    0.00705087f, 0.10115079f, 0.00582372f, 0.02144785f, -0.10050357f, 0.20499192f, -0.13556436f, -0.16574793f, 
    0.27625424f, 0.00983367f, 0.04965104f, 0.00146143f, -0.18457127f, 0.09949630f, -0.17628568f, 0.08273172f, 
    -0.93478721f, 0.57226229f, 0.29843846f, -0.16197354f, -0.14194231f, 0.08503758f, -0.29250798f, -0.00908038f, 
    0.02000800f, 0.11519320f, 0.03158423f, -0.06824458f, -0.69444829f, -0.25738704f, -0.26799038f, -0.06477711f, 
    0.16171056f, 0.10012776f, 0.02200323f, 0.12667796f, 0.33921397f, -0.23222350f, -0.12540840f, 0.00153773f, 
    -0.43600404f, 0.39535284f, -0.13905446f, -0.08477544f, -0.35791439f, -0.21081766f, -0.02050556f, -0.36064509f, 
    0.07259340f, 0.19172297f, 0.24453504f, -0.38179418f, 0.72650260f, -0.43961519f, -0.32186812f, 0.00260771f, 
    0.07058064f, -0.16405421f, -0.05335528f, -0.08798940f, 0.08718339f, 0.13897517f, -0.12280441f, 0.22003637f, 
    -0.29253894f, -0.03279706f, 0.26577517f, 0.06932810f, 0.28812113f, -0.22376907f, 0.03223389f, -0.23011327f, 
    0.00180157f, -0.22017990f, 0.01938017f, -0.09929017f, -0.81554997f, 0.23551725f, -0.01768537f, 0.17185189f, 
    -0.05377145f, 0.24433984f, -0.20544772f, 0.20079350f, 0.01108667f, 0.23188639f, 0.07649019f, 0.07633106f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13665646f, 0.17904963f, -0.11923958f, 0.02185393f, 0.10702030f, -0.04268498f, 0.04243034f, -0.24754223f, 
    0.00683624f, 0.04461395f, 0.14086114f, 0.00556112f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
