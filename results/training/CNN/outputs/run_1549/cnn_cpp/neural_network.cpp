#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.70000124f, 0.48338190f, 0.56130415f, 0.15935622f, 0.38305575f, 0.05110488f, 0.57585102f, -0.19666883f, 
    0.28380382f, -0.03207289f, -0.13632590f, 0.08956470f, -0.37793091f, 0.01980783f, 0.49440068f, -0.18258305f, 
    -0.66121179f, 0.81915140f, 0.41746786f, -0.12305126f, -0.59174401f, -0.54833180f, -0.50216520f, -0.25737152f, 
    0.41871786f, 0.63303792f, 0.83287406f, 0.56052816f, -0.95433432f, -0.86874825f, -0.70238793f, -0.33232611f, 
    -0.94755065f, -0.09083094f, -0.41223067f, 0.50071269f, -0.79057074f, -0.40040293f, -0.59555948f, -0.38071677f, 
    1.36022747f, -1.37381566f, 0.30837044f, -0.11002745f, -0.23237026f, 0.46223336f, 1.08771777f, -0.33296719f, 
    -0.61957389f, -0.09745716f, 0.47089788f, -0.10270957f, 0.45585704f, -0.32805267f, -0.52320200f, 0.01825137f, 
    -0.28189021f, -0.75513744f, -0.77948028f, -0.67647141f, -0.26805997f, -0.70752436f, 0.03831999f, -0.87609905f, 
    -0.13384549f, 0.83132219f, -0.13561606f, -0.20081402f, 0.42515478f, -0.44440472f, -0.76431870f, 0.91950351f, 
    -1.34232736f, 0.33136949f, 0.83813536f, 0.34418619f, 0.30820918f, -0.03452291f, -0.76720661f, 0.72498345f, 
    -0.46576941f, 0.17154628f, -1.10377789f, -0.89761293f, 0.80083781f, -0.14306922f, 1.07399154f, 0.32614371f, 
    0.06149618f, 0.16063482f, -1.25193024f, -0.45336142f, 0.36751455f, -0.14823627f, -0.36529160f, -0.67167610f, 
    -0.31075889f, -0.15265799f, -0.51222217f, -0.31740132f, 1.20078945f, -0.22268391f, -0.12807976f, -0.18861306f, 
    0.05219553f, -0.11773916f, 0.16385719f, 0.37057117f, -0.34153405f, 0.41535944f, -0.11681561f, 1.09568369f, 
    0.27819020f, 0.52165449f, -0.29156134f, 0.42849514f, -0.37984967f, 0.75304663f, 0.89102709f, -0.76235408f, 
    0.06824908f, 0.05800173f, -0.52989572f, -0.05813556f, 0.15416317f, 0.55000484f, 0.79979187f, 0.14047870f, 
    -0.19579853f, -0.61814785f, -0.43753016f, 0.66809034f, 0.25123841f, 0.05380291f, -0.19891399f, -1.30416560f, 
    1.41338360f, -0.35788611f, -0.58267528f, 0.17527848f, 0.36227643f, 0.39226735f, 0.02077157f, 0.25195500f, 
    -1.25049317f, -0.86613607f, -0.68378985f, 0.92128462f, 0.82183105f, 0.54009736f, -0.27739665f, 0.49647489f, 
    0.06089916f, -1.06062472f, -0.69300818f, -0.75388211f, 1.25338924f, 0.06200258f, -0.44010800f, -0.70479751f, 
    -0.66966653f, 0.06744054f, -0.38652703f, 0.20927484f, 0.67280698f, 0.29954967f, -0.29240322f, 0.25933707f, 
    -0.24378549f, 0.01847469f, -0.25101075f, 0.59786719f, 0.53042400f, 0.45954409f, -0.30478495f, 0.40721411f, 
    0.09011417f, -0.24218084f, 0.81179714f, -0.55167538f, 0.20165725f, -0.53802449f, -0.20169632f, -0.46697670f, 
    -0.29054663f, 0.64866459f, 0.48899633f, -0.15756790f, 0.84588653f, -0.33784595f, -0.64174312f, 0.27562600f, 
    -0.46139097f, -0.90034145f, -1.21801805f, 0.51737213f, 0.55606645f, 0.11776479f, 0.45739013f, 0.61325806f, 
    0.27179924f, -0.66905546f, -0.39389041f, -0.52091587f, -0.35814255f, -0.84012890f, -0.68560296f, -0.76467758f, 
    -0.74518073f, -0.69032156f, 0.65953189f, 0.53683722f, 0.01924951f, 0.65138572f, 0.39019009f, 0.72382742f, 
    -0.03907379f, 0.12639432f, 0.37366351f, -1.10023928f, -0.60692537f, -0.13618241f, -0.04533338f, 0.38778824f, 
    0.71792519f, 0.22015503f, 0.04034295f, 0.66529447f, -0.41960841f, -0.24600768f, 0.71658128f, 0.16443808f, 
    0.29701045f, 0.27956066f, -0.42252821f, 0.10064836f, 0.33281776f, 0.54948246f, -0.99876815f, -1.25151920f, 
    -0.72111106f, -0.13909748f, -0.49412608f, 0.63887948f, -0.01098748f, 0.94624573f, -1.01494920f, 0.13264377f, 
    -0.89213085f, 0.30671561f, -0.19248027f, 0.61199737f, 0.79665560f, 0.06222836f, 1.16709793f, -0.47990239f, 
    -0.13130179f, 0.31620538f, 0.33148131f, 0.39977336f, -0.03791057f, -0.25285441f, 0.35104984f, 0.39184248f, 
    0.83739138f, -0.20459202f, -1.20459485f, -0.23826963f, 0.51567650f, -0.47906920f, -0.15539882f, 0.51230645f, 
    -0.09397034f, 0.76811773f, 0.79592419f, 0.69660652f, 0.27683842f, -0.86270541f, -0.17902684f, -0.82746434f, 
    1.22556579f, -1.12593722f, -0.14722598f, 0.06262986f, -0.32242525f, 0.65403152f, -0.56830889f, 0.41178495f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.50320101f, 0.58149642f, -0.00239251f, 0.41450697f, -0.05502980f, 0.34026018f, -0.47061041f, 0.45095551f, 
    0.07568371f, -0.05796948f, 0.01723907f, 0.51099670f, -0.00168479f, 0.60526627f, 0.39246789f, -0.13713007f, 
    0.18396623f, 0.14270885f, 0.46512049f, -0.23680024f, 0.38318461f, -0.00048594f, -0.13767336f, 0.11575229f, 
    0.20667742f, 0.66421926f, 0.28191602f, -0.03992199f, 0.25393698f, 0.14943926f, -0.08866023f, 0.16398370f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01887606f, 0.06157512f, 0.12545605f, 0.21345234f, -0.15211952f, -0.11510593f, 0.06646924f, 0.05267508f, 
    -0.15331869f, 0.11956093f, -0.13329154f, 0.28204975f, 0.22707286f, -0.02820655f, -0.02002070f, -0.14850017f, 
    -0.15252529f, -0.22947082f, 0.29828572f, 0.01458879f, 0.01598007f, -0.20576052f, -0.28371963f, -0.14556326f, 
    0.09574862f, 0.10715297f, -0.06417000f, 0.34044775f, 0.17019455f, 0.07090934f, -0.04809679f, -0.00341114f, 
    -0.01044235f, 0.03406541f, 0.08724226f, -0.02626706f, 0.39001200f, 0.26165810f, -0.01894667f, 0.00107471f, 
    -0.02248492f, -0.09032252f, 0.16390254f, -0.06903737f, 0.22333084f, 0.13720489f, 0.00507750f, -0.16174676f, 
    -0.00619592f, 0.00771059f, -0.13759996f, -0.04975786f, 0.05126135f, 0.07880981f, 0.28701591f, 0.11729153f, 
    0.29349220f, 0.02949052f, 0.06745732f, 0.01910478f, -0.10441801f, 0.07082548f, -0.12016837f, 0.36780539f, 
    -0.42804602f, 0.54349554f, -0.01356115f, -0.08631673f, -0.02768777f, -0.04396059f, -0.19911538f, -0.22495477f, 
    0.07452501f, 0.03319960f, 0.02524218f, 0.12767939f, 0.08895494f, 0.15102668f, 0.26784170f, -0.19404683f, 
    -0.24434982f, 0.22210896f, -0.11878562f, -0.13640571f, -0.36660296f, -0.03149481f, 0.34169483f, 0.06400533f, 
    -0.01143836f, -0.14334407f, 0.20885727f, 0.11982136f, -0.06762209f, 0.03933088f, -0.02294379f, -0.00102121f, 
    0.22022103f, 0.07833005f, 0.03109961f, 0.02520622f, -0.21192303f, -0.08297892f, 0.00086005f, -0.01080767f, 
    0.00050227f, 0.10492660f, 0.28572202f, -0.02113975f, 0.07185606f, 0.12301971f, -0.20834583f, 0.05198497f, 
    0.04242050f, 0.03890678f, 0.14099729f, -0.04777379f, 0.04191249f, 0.07517422f, -0.00943076f, -0.06818623f, 
    0.06304426f, -0.08233664f, -0.04284737f, 0.07995360f, 0.08910885f, -0.17674220f, -0.06058523f, -0.15365601f, 
    -0.29522684f, -0.12156581f, -0.10437171f, 0.02833158f, 0.13387729f, 0.27416310f, 0.08122893f, 0.08574169f, 
    -0.18803361f, -0.02444509f, 0.11692043f, -0.06658535f, 0.19197544f, 0.25767764f, 0.29043871f, 0.06836718f, 
    0.15925311f, 0.05807215f, -0.34943157f, -0.20584786f, -0.21394694f, 0.03982648f, 0.05718755f, -0.01649832f, 
    -0.09710498f, 0.17738496f, -0.02891524f, -0.56672347f, -0.12635568f, -0.25246826f, 0.05450046f, -0.00278192f, 
    0.12057824f, -0.03381510f, 0.00567122f, -0.02603429f, -0.04620614f, -0.00334847f, -0.02799729f, -0.02610479f, 
    -0.13053320f, -0.52837497f, -0.36259255f, 0.03179827f, 0.13985531f, -0.06295042f, 0.05694738f, 0.04803852f, 
    -0.14525314f, -0.03852043f, -0.00272060f, -0.15546867f, 0.13443491f, 0.06457786f, 0.04781020f, 0.02397401f, 
    -0.22715308f, -0.40312949f, -0.00922567f, 0.06412097f, -0.02283819f, 0.73923916f, 0.28565010f, 0.16868219f, 
    0.10721526f, -0.02227931f, 0.05899495f, -0.00638327f, 0.02096089f, 0.06519945f, -0.13677311f, 0.15357661f, 
    0.16741431f, 0.02265023f, 0.12609629f, 0.01200471f, -0.15479015f, -0.18556823f, -0.15364243f, 0.10128941f, 
    0.10949402f, -0.12804715f, 0.00335804f, -0.18306760f, -0.19751483f, 0.17487140f, 0.13695896f, 0.00270893f, 
    0.16107741f, -0.08317658f, 0.40916568f, 0.01794286f, 0.09271774f, -0.05760990f, -0.10018283f, -0.06375249f, 
    -0.09125119f, 0.08471829f, 0.01559629f, 0.08155102f, 0.10453140f, -0.04509716f, -0.06018617f, 0.08298791f, 
    0.15175980f, -0.05695656f, -0.28378963f, 0.21474895f, -0.04453597f, 0.08275393f, -0.01342434f, -0.00916968f, 
    0.04084554f, 0.09850021f, 0.21813434f, 0.03925085f, -0.47231919f, 0.13476543f, 0.05072653f, -0.08914138f, 
    -0.18771178f, 0.05348624f, -0.10566019f, -0.13698207f, 0.22003482f, 0.05204162f, 0.00485592f, 0.01472466f, 
    -0.00580838f, -0.18596236f, 0.09678110f, 0.00835743f, -0.17253257f, -0.33196583f, 0.01535934f, 0.06549919f, 
    -0.05290968f, -0.17524362f, -0.05813544f, 0.20433706f, 0.09747306f, -0.33373860f, 0.10765241f, 0.06542270f, 
    -0.06979910f, 0.03496430f, -0.06924255f, 0.12186077f, -0.01742797f, -0.13866973f, 0.02968926f, 0.09525939f, 
    -0.00052396f, 0.01697448f, 0.27213755f, -0.05323514f, -0.13899054f, -0.04457881f, 0.03951718f, -0.18713823f, 
    0.13602294f, 0.08441562f, -0.00456156f, -0.12388036f, -0.05648515f, -0.02194386f, 0.14732000f, -0.11232608f, 
    0.10566655f, 0.22242498f, -0.11826749f, 0.05466957f, 0.15533611f, 0.06437299f, 0.09888922f, -0.06145041f, 
    0.15577824f, 0.34125623f, 0.06933137f, -0.02979911f, -0.43292540f, 0.01273757f, -0.08126142f, 0.01569260f, 
    0.01565765f, -0.00261922f, 0.06255426f, 0.07234943f, 0.08691059f, -0.11908437f, -0.04148883f, 0.12162803f, 
    -0.02654357f, 0.03177558f, -0.00583834f, 0.15109967f, -0.32115665f, -0.67143148f, -0.07141341f, -0.11663501f, 
    -0.19855849f, -0.11792716f, -0.16416949f, -0.05232227f, -0.16208835f, -0.04202019f, -0.06941156f, -0.02458790f, 
    0.01796151f, 0.07055092f, -0.02156634f, 0.14761265f, -0.08903242f, 0.23485547f, -0.52334750f, -0.55942428f, 
    -0.27384067f, -0.09754223f, -0.05000829f, -0.12229322f, -0.00663667f, -0.13084738f, -0.03339357f, 0.54341978f, 
    0.04507168f, 0.19643189f, 0.15583086f, -0.07333397f, 0.14051858f, 0.07284563f, -0.05033401f, 0.29085585f, 
    0.14929101f, 0.06937692f, 0.04132650f, 0.21293631f, -0.39294547f, 0.01613940f, -0.03020689f, -0.01144982f, 
    0.09810116f, -0.00484433f, 0.14537255f, 0.04928578f, -0.32177472f, -0.08638681f, -0.04142992f, 0.09564491f, 
    0.01369409f, -0.04109959f, 0.41001013f, -0.29035932f, 0.16375285f, -0.13874334f, -0.16277435f, -0.04949383f, 
    -0.15150158f, 0.11428671f, -0.15655887f, 0.22795263f, -0.13953307f, 0.09462596f, 0.03069310f, -0.06424668f, 
    0.08825492f, 0.15064456f, -0.07232038f, 0.04230201f, -0.00497725f, 0.00479480f, -0.00859628f, -0.36528489f, 
    -0.13337423f, -0.18983366f, 0.14965703f, 0.02823577f, 0.17399405f, -0.08022304f, 0.07297108f, -0.05935216f, 
    0.06507529f, -0.13522045f, 0.09735160f, 0.09159035f, -0.07158485f, 0.04251289f, -0.17508554f, 0.04654273f, 
    -0.02726167f, 0.10044845f, 0.19115680f, -0.11950964f, 0.26290506f, 0.06460571f, 0.02310591f, 0.33908051f, 
    -0.11766515f, -0.38965482f, -0.30688632f, -0.20183253f, -0.04845361f, 0.03849139f, -0.15752144f, 0.13266802f, 
    0.05784089f, 0.24357013f, 0.45087427f, 0.00252226f, -0.05163224f, 0.06228603f, 0.09570336f, 0.10671155f, 
    0.09402543f, -0.04510389f, -0.30185980f, 0.35332012f, -0.09061310f, -0.13099432f, -0.00538206f, -0.12936418f, 
    0.16136248f, -0.01375580f, 0.09159257f, 0.09702775f, -0.03769067f, 0.07922687f, -0.11273587f, -0.03374638f, 
    0.13889018f, 0.03370903f, 0.06565648f, -0.26991710f, -0.07563814f, -0.12933025f, -0.02560570f, -0.14212793f, 
    -0.10655563f, -0.01386261f, -0.07908123f, 0.06834180f, 0.17061570f, -0.01945638f, -0.19058487f, -0.00306686f, 
    -0.00275069f, 0.11847429f, 0.09941214f, 0.06740993f, 0.15470321f, -0.17886141f, -0.40208849f, -0.10517821f, 
    -0.21097220f, 0.02699296f, -0.17796105f, -0.04349296f, 0.04780239f, -0.02529210f, -0.39729166f, -0.10278309f, 
    0.01305587f, 0.02232474f, 0.12881087f, -0.04183513f, 0.20186146f, -0.04721791f, 0.26193750f, 0.04130549f, 
    0.14925312f, 0.24608885f, -0.06814448f, -0.33786026f, -0.02715103f, 0.16383913f, 0.05091318f, 0.07943385f, 
    0.29116973f, -0.65402371f, -0.38717443f, -0.09276182f, 0.07506277f, -0.05785058f, -0.01387084f, -0.07615781f, 
    0.07081861f, 0.03108433f, -0.14883979f, -0.07016981f, 0.01242662f, 0.08630180f, 0.02416784f, 0.03209858f, 
    0.09767280f, 0.03180313f, -0.05857363f, -0.26535884f, 0.08976608f, 0.07486616f, 0.03957130f, -0.04474387f, 
    0.08876772f, 0.18157780f, 0.05462894f, -0.07023273f, -0.69373077f, -0.20475963f, 0.07454386f, -0.05946046f, 
    -0.19208562f, 0.01965001f, -0.28932288f, -0.16315146f, -0.03549087f, -0.08280029f, 0.01357276f, 0.09148676f, 
    -0.09079079f, -0.04160655f, 0.09359264f, -0.04869013f, -0.15568838f, -0.13235153f, -0.19344927f, 0.25431094f, 
    0.21312073f, -0.20168416f, -0.07702291f, 0.02002180f, 0.08717932f, 0.00855015f, -0.10898290f, 0.05679369f, 
    0.05968298f, -0.30566671f, -0.27638566f, -0.21381703f, 0.20678461f, 0.11289144f, 0.18370339f, 0.93821675f, 
    -0.02480772f, -0.61087698f, 0.21166919f, 0.20868440f, -0.26285443f, 0.02744491f, -0.05774561f, -0.03095195f, 
    -0.04256282f, 0.03468793f, -0.01959222f, 0.04719173f, -0.04778448f, 0.02525498f, -0.04435188f, -0.03657861f, 
    -0.02159567f, -0.04353993f, -0.02288087f, -0.04414803f, -0.01743425f, -0.06249414f, -0.04522613f, -0.06259909f, 
    -0.02660700f, -0.02921349f, 0.04426796f, 0.00163344f, 0.04952087f, 0.03382928f, -0.06462875f, -0.02212909f, 
    0.00170172f, -0.03838955f, -0.05293122f, 0.04242043f, -0.03906589f, -0.02529049f, -0.00838990f, -0.00296761f, 
    -0.02129102f, 0.01877047f, -0.00676378f, 0.03401989f, -0.05159728f, 0.01049902f, -0.06025970f, 0.02307230f, 
    -0.02526302f, 0.05205232f, -0.05609010f, -0.03603591f, -0.00088458f, -0.06428029f, -0.01212437f, -0.03368238f, 
    -0.05392775f, -0.01487263f, -0.03652031f, 0.05073955f, 0.01326687f, 0.01558268f, 0.01955422f, -0.01069484f, 
    -0.00004034f, -0.06345758f, -0.01034665f, -0.03046076f, -0.05047866f, -0.02333394f, 0.04599438f, -0.00036065f, 
    -0.05771049f, -0.05938417f, -0.02619187f, -0.04145542f, -0.03709627f, 0.05115427f, -0.01613631f, 0.05185655f, 
    0.01747826f, 0.04929135f, 0.04601286f, 0.01689982f, -0.01712240f, -0.01915943f, -0.00332586f, 0.02770033f, 
    -0.00003583f, -0.01926037f, 0.00958279f, 0.01836231f, -0.02625487f, -0.03451651f, -0.05197701f, 0.01533241f, 
    -0.00420549f, 0.04651398f, 0.03777099f, 0.04916420f, 0.03873573f, 0.00697946f, -0.02868587f, 0.00954472f, 
    -0.01516723f, -0.02268447f, 0.01645349f, -0.05419845f, 0.04497141f, -0.03177036f, 0.03298203f, 0.01750845f, 
    0.02492012f, 0.03915705f, -0.01950679f, 0.05071373f, -0.00836888f, 0.04926984f, -0.05333800f, 0.00661261f, 
    -0.02625208f, 0.00146412f, 0.00725506f, -0.04595871f, -0.01609988f, -0.03596435f, -0.03669406f, -0.04700456f, 
    0.04916197f, 0.00242120f, -0.05602744f, 0.05150996f, -0.01195402f, 0.01693917f, 0.03525979f, -0.03816997f, 
    0.03287054f, -0.04016470f, 0.01216889f, 0.00906836f, 0.04439592f, -0.00757859f, -0.04212186f, -0.05329843f, 
    0.04722381f, 0.02218409f, 0.04921990f, -0.05670214f, -0.02555230f, -0.02755021f, -0.05685021f, -0.05338371f, 
    0.04086826f, -0.01382834f, 0.05153853f, -0.01089657f, 0.04643805f, -0.03869839f, -0.04634487f, -0.03722766f, 
    -0.01079723f, 0.01747114f, -0.06270386f, -0.03509108f, 0.04011859f, -0.04989355f, -0.02054517f, -0.03575519f, 
    -0.05553403f, 0.02394067f, 0.03955406f, -0.05557229f, 0.02055401f, -0.01911957f, 0.02835767f, -0.03207991f, 
    -0.02039238f, -0.06010733f, 0.04019056f, -0.02310508f, -0.05749507f, 0.03257624f, 0.01126720f, 0.04639083f, 
    -0.03131645f, 0.04278989f, 0.01147190f, -0.03235387f, -0.00661169f, 0.04393597f, -0.04738911f, -0.00437356f, 
    -0.01027380f, -0.03714585f, -0.03702643f, -0.04785072f, -0.02403221f, 0.04868051f, 0.04026504f, -0.01506820f, 
    0.02841768f, 0.01600723f, -0.04727559f, 0.03072235f, -0.03924629f, 0.01650087f, 0.02875133f, -0.01353804f, 
    -0.06274841f, -0.04423960f, 0.04214980f, -0.05193621f, 0.01972184f, 0.00400475f, -0.05887225f, 0.02133905f, 
    -0.05832312f, 0.02898946f, -0.00130071f, -0.05265189f, 0.00915277f, -0.05839914f, -0.01885943f, 0.02652189f, 
    -0.06174957f, 0.04706141f, -0.00140765f, 0.04544581f, -0.05688303f, -0.01507617f, -0.06242670f, -0.03683518f, 
    -0.00935350f, -0.01905782f, 0.02335438f, -0.02850140f, -0.04875150f, 0.00604708f, 0.00989652f, 0.03530758f, 
    -0.01905355f, -0.00150906f, -0.02783380f, -0.00016294f, 0.01016713f, -0.05675394f, 0.01624706f, -0.03504738f, 
    0.04833249f, -0.04084746f, 0.00530568f, -0.01952907f, -0.06492566f, 0.01869269f, -0.06284330f, -0.01067983f, 
    0.02790236f, -0.01340111f, -0.00152051f, 0.02716581f, -0.02810344f, 0.00972854f, -0.02754948f, -0.05698358f, 
    -0.05477350f, -0.00785471f, -0.05927326f, 0.01101037f, -0.01986391f, 0.02446292f, 0.00088052f, -0.04061987f, 
    -0.04669484f, 0.01262860f, 0.05069399f, -0.03628356f, -0.05587382f, -0.01206284f, 0.01437797f, -0.00795312f, 
    0.04416930f, 0.04232002f, -0.02683504f, -0.02729044f, 0.04020238f, -0.02725558f, 0.02578562f, 0.00506074f, 
    0.01209999f, -0.03938029f, -0.01212803f, -0.03222492f, -0.02492728f, -0.02091811f, -0.05564284f, -0.00109783f, 
    -0.25369078f, -0.07310476f, 0.22813629f, 0.42664036f, -0.05725956f, -0.00634172f, 0.05720818f, 0.17212799f, 
    -0.01567018f, -0.11175766f, 0.08382751f, 0.48857087f, 0.18077594f, 0.18568964f, -0.13134359f, 0.11791457f, 
    0.23086463f, 0.14146179f, 0.47011027f, 0.17500862f, 0.03632013f, -0.37567237f, 0.07378299f, -0.12296178f, 
    -0.03017937f, -0.01254859f, -0.02255091f, 0.23791833f, 0.34516707f, 0.16135666f, -0.04146060f, 0.03967500f, 
    -0.17797296f, 0.11076305f, -0.12975499f, 0.24931554f, 0.22640626f, 0.15634434f, 0.05196366f, -0.05382064f, 
    -0.16816635f, 0.26534244f, 0.02685337f, 0.04895074f, -0.26555711f, 0.05711910f, -0.64718634f, -0.54285783f, 
    -0.26230171f, -0.26750943f, 0.09357221f, 0.01565068f, 0.18262519f, 0.03634649f, 0.10353403f, 0.42860079f, 
    0.24333267f, -0.00568370f, -0.05988944f, -0.14486188f, -0.00978177f, -0.04016229f, 0.10479671f, -0.36026949f, 
    0.03191515f, 0.18211526f, 0.23328526f, 0.12073837f, -0.05770299f, 0.15615961f, 0.26462418f, 0.02059471f, 
    -1.06646013f, -0.33836383f, 0.08721091f, 0.05056409f, -0.01572753f, 0.00158397f, 0.11707076f, 0.14967883f, 
    0.25618768f, 0.72823572f, -0.77741790f, -0.55344748f, 0.14439730f, 0.06818309f, 0.12705512f, 0.05286260f, 
    -0.00520497f, -0.13343780f, 0.36156988f, 0.13155439f, 0.19089541f, 0.03872501f, 0.10293125f, -0.03493749f, 
    0.07273719f, 0.05883663f, 0.05131392f, -0.19701584f, -0.65032828f, -0.51324892f, -0.02760765f, 0.08221371f, 
    0.15012042f, 0.00029516f, 0.22773170f, -0.02359877f, 0.14341018f, -0.32715556f, -0.86360216f, -0.13160108f, 
    -0.19334053f, -0.43546963f, 0.16196443f, -0.06887567f, 0.26676336f, 0.14432935f, -0.46338791f, -0.86986423f, 
    -0.13937649f, 0.01475766f, 0.23694341f, 0.07976185f, 0.10317618f, 0.08790310f, 0.09754482f, -0.16523550f, 
    -0.05911044f, -0.17269987f, -0.28603017f, 0.09185588f, 0.08790812f, 0.12903892f, -0.06196357f, -0.79602963f, 
    -0.20822744f, 0.22118242f, -0.03566412f, -0.17965192f, 0.00559954f, 0.18503565f, 0.30783156f, -0.31105003f, 
    -0.03225331f, -0.22702916f, -0.74741912f, 0.24556851f, -0.00173354f, -0.04233618f, 0.09470468f, -0.07410521f, 
    0.27574396f, 0.33325854f, 0.13468678f, -0.10155886f, -0.06248912f, 0.01851386f, -0.07275448f, 0.10592675f, 
    -0.07148585f, 0.13990796f, -0.81458300f, -0.27443224f, -0.11814140f, -0.07965169f, -0.05556764f, 0.08658791f, 
    -0.02807757f, 0.02322967f, -0.10643972f, -0.03541358f, -0.30430192f, -0.07762623f, 0.20998141f, -0.05081734f, 
    -0.02377035f, -0.28220645f, 0.01821906f, -0.08669722f, -0.05542085f, 0.12242255f, 0.14984249f, 0.02634986f, 
    -0.05877339f, -0.24415122f, -0.15062998f, 0.20491217f, -0.07575329f, 0.30837876f, 0.32266480f, 0.56181800f, 
    -0.25955689f, 0.03816799f, 0.00024170f, -0.00945934f, 0.00988364f, 0.24463958f, -0.28306112f, 0.14681043f, 
    0.22214933f, 0.18722202f, -0.22899151f, 0.07134812f, -0.01941545f, 0.00054763f, 0.05500390f, -0.16026089f, 
    -0.02981357f, -0.50071752f, 0.15719487f, -0.15625051f, 0.20260045f, 0.22206497f, 0.07158359f, 0.17897187f, 
    0.24426164f, 0.04112783f, 0.17300965f, -0.08385276f, 0.10351627f, -0.06692029f, -0.03758552f, 0.09441677f, 
    0.10249089f, -0.03139243f, -0.24613646f, 0.31684104f, -0.09692826f, 0.05848949f, 0.02675765f, 0.02863290f, 
    0.14813744f, 0.10030048f, -0.08993813f, 0.21587901f, -0.05562740f, 0.00733030f, 0.11236866f, -0.06807102f, 
    0.10434244f, 0.05419393f, 0.12323523f, -0.46743882f, -0.28053993f, -0.17242748f, -0.21628049f, 0.00552947f, 
    -0.00768289f, -0.37401530f, -0.04861818f, 0.05804058f, -0.14539555f, -0.54875630f, -0.13892870f, -0.04943213f, 
    0.12728001f, 0.29788843f, -0.17845201f, -0.03299046f, 0.02162824f, -0.55242199f, 0.09714384f, -0.11028688f, 
    -0.11898538f, 0.07630750f, -0.02430935f, -0.06456069f, 0.19623452f, 0.02388569f, 0.11721776f, -0.07308184f, 
    -0.26743090f, -0.18134639f, -0.39177823f, -0.29085279f, 0.19004735f, 0.01102592f, -0.11066604f, -0.03106387f, 
    0.33698806f, -0.13756894f, -0.11068835f, -0.08395284f, 0.14271919f, 0.03295865f, 0.00051112f, -0.10577992f, 
    0.22870265f, 0.04636164f, 0.04683962f, 0.05774690f, 0.11547197f, 0.00984555f, -0.01360071f, -0.16641660f, 
    -0.05041493f, -0.08035510f, 0.15050903f, 0.14778288f, 0.15898345f, 0.22600232f, -0.01876631f, -0.01673622f, 
    -0.02436914f, 0.10869118f, -0.57416648f, -0.36118984f, 0.03551127f, 0.33597392f, -0.14340501f, 0.17113204f, 
    0.22431685f, 0.18388772f, 0.11459791f, -0.46398938f, -0.88194221f, -0.48724756f, -0.15978861f, 0.05450694f, 
    0.16116759f, -0.02706761f, -0.05950282f, 0.09970425f, 0.32592180f, -0.86181188f, -0.31074658f, -0.24850591f, 
    0.23303752f, -0.23031637f, -0.02433333f, -0.10959091f, -0.14586639f, 0.18950920f, 0.24959809f, 0.15447801f, 
    -0.06952032f, -0.01473754f, -0.01312678f, 0.14100167f, -0.07952393f, 0.07689859f, -0.71962482f, -0.60833967f, 
    -0.43760616f, -0.09809074f, 0.04818107f, -0.01714944f, 0.02927981f, 0.01670910f, 0.02851279f, 0.16684568f, 
    0.01502282f, 0.26943111f, 0.18229596f, 0.16452467f, -0.04344713f, 0.27780506f, 0.00318809f, 0.06188992f, 
    0.22164077f, 0.07766832f, 0.08860403f, -0.05103748f, 0.13480014f, 0.11697717f, 0.09289512f, -0.20116657f, 
    0.01003552f, -0.10815674f, -0.76057398f, -0.41474310f, -0.07902677f, -0.17579879f, -0.02304163f, -0.08717990f, 
    -0.06815308f, 0.08851856f, 0.05149006f, -0.72403288f, -0.66920561f, 0.00053846f, 0.12283669f, 0.01816955f, 
    -0.01191799f, -0.05208036f, -0.01314259f, 0.29923454f, 0.14722283f, 0.01018292f, 0.02431514f, 0.04051488f, 
    0.05852406f, 0.08727763f, 0.17056088f, 0.00648496f, 0.08278869f, 0.06833052f, 0.07587359f, -0.07545345f, 
    0.02905558f, -0.01420646f, 0.01874691f, -0.40151066f, -0.04873206f, 0.13190995f, 0.12589377f, 0.10529509f, 
    -0.00553778f, -0.03131068f, 0.12431895f, 0.25065506f, 0.07769354f, 0.00145335f, 0.17094782f, 0.24563701f, 
    0.12568779f, 0.00044667f, 0.02010677f, 0.02931775f, 0.09791999f, 0.05540391f, -0.00388019f, 0.38007745f, 
    -0.14004837f, -0.34577838f, 0.04094738f, 0.11063262f, 0.00261123f, -0.12598777f, 0.14701919f, -0.18858299f, 
    0.03257420f, -0.40666106f, -0.63505805f, -0.17983229f, -0.17955883f, -0.17663248f, 0.02656689f, -0.31418797f, 
    0.05829198f, 0.00434283f, -0.78041536f, -0.78585619f, -0.18528269f, -0.08548585f, -0.10212829f, 0.15385258f, 
    -0.15187442f, -0.00733820f, 0.12406594f, 0.17272581f, 0.19691618f, -0.07884668f, -0.02172626f, 0.10334229f, 
    0.05572925f, 0.07195363f, 0.12998134f, 0.13285482f, 0.19072750f, 0.21380439f, -0.15719923f, -0.12561195f, 
    -0.06476654f, 0.16350849f, -0.09560867f, 0.06871267f, -0.30396906f, -0.12753884f, -0.09773213f, 0.30171028f, 
    0.12866639f, 0.16425745f, 0.01377302f, 0.13161671f, 0.11699107f, 0.00922585f, -0.28290257f, 0.29640162f, 
    -0.01762417f, -0.02454869f, -0.10335466f, -0.11543460f, -0.11382971f, 0.00226999f, 0.29788774f, 0.15608884f, 
    0.00097937f, -0.24375023f, -0.21760319f, -0.13040064f, -0.09216047f, -0.00267665f, 0.09387285f, -0.06319690f, 
    -0.29165190f, -0.30129826f, -0.07626829f, 0.01801115f, 0.07212920f, 0.07044824f, -0.04184081f, 0.08026734f, 
    -0.25839755f, -0.15989073f, -0.03204910f, 0.05750395f, -0.19046061f, -0.17878865f, -0.03927276f, 0.12032181f, 
    0.11187631f, 0.14160560f, 0.11656098f, 0.07861284f, -0.01578130f, 0.01537586f, 0.07796506f, 0.15680271f, 
    0.08000206f, 0.10603027f, -0.29056731f, -0.14945832f, 0.06472874f, 0.13944457f, -0.12946601f, 0.21561754f, 
    0.02782479f, 0.02167185f, -0.00949144f, 0.08370862f, 0.05802728f, 0.25145829f, -0.24136980f, -0.09651417f, 
    -0.24331428f, -0.05586118f, 0.11213184f, 0.01641165f, 0.11788519f, 0.18375099f, 0.10023476f, -0.04401658f, 
    -0.01273508f, 0.00030686f, 0.12395576f, 0.02402960f, 0.04621612f, 0.14134295f, 0.09866499f, 0.36699295f, 
    -0.01757756f, -0.09527748f, 0.21931130f, 0.21971074f, -0.02746540f, 0.15273595f, -0.04038253f, 0.06601008f, 
    0.07623440f, -0.04487855f, -0.04030912f, 0.03377575f, 0.01827034f, -0.32605553f, -0.08450094f, 0.24871910f, 
    -0.85337508f, -0.63013315f, 0.08110628f, 0.24680218f, 0.02978023f, -0.07317218f, 0.15199877f, -0.09728828f, 
    -0.09523027f, -0.08715687f, -0.23244266f, -0.13434528f, 0.01623029f, 0.02011803f, -0.05838574f, -0.11678992f, 
    0.19617008f, -0.08285840f, 0.20482042f, -0.02517306f, -0.00058607f, 0.11330058f, -0.34493831f, 0.03608129f, 
    -0.15698440f, 0.01152669f, 0.05270649f, 0.15178731f, 0.04296445f, 0.17420402f, -0.00952888f, -0.03064494f, 
    -0.04917246f, 0.08965336f, 0.16786313f, 0.05332809f, 0.43088263f, 0.11095014f, -0.15298772f, 0.11589791f, 
    0.00779737f, 0.03142049f, -0.05411045f, -0.10799276f, 0.39172298f, -0.22477315f, 0.22954416f, 0.04804533f, 
    -0.04681263f, -0.17361356f, 0.10299426f, -0.01952015f, -0.08634348f, -0.58664864f, 0.14076433f, 0.01548527f, 
    0.01324214f, -0.01266773f, 0.08624593f, 0.00593175f, -0.04533200f, 0.10717568f, 0.15931050f, 0.35503945f, 
    0.07393533f, -0.07810477f, 0.22842290f, -0.06805040f, 0.12292708f, 0.09181282f, 0.01243499f, -0.13008374f, 
    0.00827389f, -0.32804930f, -0.04500733f, 0.31593329f, -0.05933034f, 0.11551815f, 0.10747670f, -0.19514336f, 
    -0.89233702f, -0.24223645f, -0.12665863f, -0.25084388f, 0.08756049f, -0.04736830f, 0.03742652f, -0.19716950f, 
    -0.07198418f, 0.71071768f, -0.21961938f, 0.25651947f, -0.07657381f, 0.00652541f, 0.03026549f, 0.09648670f, 
    -0.04012248f, 0.02568233f, 0.31187570f, 0.38040224f, 0.06482057f, 0.05162287f, 0.01169659f, 0.12389310f, 
    -0.03099985f, 0.00949229f, 0.01336981f, -0.39007688f, -0.49724618f, -0.28685445f, -0.07232894f, -0.23818466f, 
    0.15685694f, 0.03215293f, 0.11919395f, 0.06207648f, 0.07684420f, 0.03587820f, 0.25211456f, -0.22664127f, 
    -0.00215906f, 0.10418367f, 0.03137369f, -0.01033355f, -0.16859646f, -0.21221061f, -0.33555451f, 0.00756252f, 
    0.13406248f, -0.10399004f, 0.00336445f, -0.02375713f, 0.20311646f, -0.10520774f, -0.05835629f, 0.24334157f, 
    -0.43441960f, -0.13507864f, -0.12282138f, 0.06134642f, -0.04239585f, 0.01855948f, 0.00551100f, -0.51880765f, 
    -0.26906174f, -0.37199238f, 0.09084316f, -0.12106345f, 0.07096837f, 0.25196281f, 0.02646095f, 0.08671791f, 
    0.19965912f, 0.08923478f, 0.29957953f, -0.10197805f, 0.05543560f, -0.01260446f, 0.03649300f, 0.09744883f, 
    -0.00852127f, 0.50012010f, 0.48452830f, 0.46229964f, -0.13713649f, 0.06546903f, 0.10707828f, 0.17652515f, 
    0.03435919f, -0.07712173f, -0.29578328f, -0.28771329f, -0.35932526f, -0.21948761f, -0.04155078f, 0.02915088f, 
    0.08256684f, -0.02665075f, -0.09968153f, -0.18091792f, -0.48576233f, -0.12159522f, 0.13374768f, 0.03477379f, 
    0.07408509f, 0.28648925f, -0.01470303f, 0.07000895f, -0.12195962f, 0.00207984f, -0.12152368f, 0.05425767f, 
    0.14170036f, -0.16840543f, -0.02869491f, -0.16296585f, 0.04095099f, 0.04861606f, 0.44489738f, 0.41218132f, 
    -0.25386634f, -0.17707933f, 0.17879225f, -0.09052604f, -0.03690035f, 0.15733400f, -0.04252089f, -0.11180268f, 
    -0.27763119f, 0.05166018f, -0.04441436f, -0.07392683f, 0.07350226f, -0.03506890f, 0.03804377f, 0.00678892f, 
    -0.07457943f, 0.02150308f, 0.09181120f, 0.15458247f, 0.00130356f, -0.02835247f, 0.19954503f, 0.19541584f, 
    -0.04053444f, -0.04285282f, 0.01716765f, 0.09403968f, -0.22185063f, -0.09477545f, -0.04387399f, 0.11844140f, 
    0.19032131f, 0.01007915f, 0.04994080f, -0.31575289f, 0.07013869f, 0.00984297f, -0.00697900f, 0.29992524f, 
    0.00621913f, 0.13623406f, 0.02443920f, 0.04884382f, -0.13280429f, -0.11111935f, -0.10180821f, -0.05305680f, 
    0.09019101f, 0.03722101f, 0.10045647f, 0.43483537f, -0.21685585f, -0.10217165f, -0.13637958f, -0.01603687f, 
    -0.27489477f, 0.04076270f, -0.02734466f, 0.01761438f, 0.19602449f, -0.16602100f, -0.42785585f, -0.05006624f, 
    -0.10733951f, 0.00563398f, 0.36300686f, 0.02810313f, 0.03616223f, -0.07773200f, -0.32738391f, 0.15914802f, 
    -0.25375071f, -0.18323901f, -0.12881903f, -0.09471484f, -0.12517262f, -0.02461769f, 0.10616688f, -0.11698458f, 
    0.34636825f, -0.28409079f, -0.07329960f, 0.02993076f, -0.00802811f, -0.04527402f, 0.26992592f, -0.18543184f, 
    -0.08826493f, 0.10190718f, -0.02135837f, -0.15053694f, -0.22071309f, 0.05911464f, 0.06155353f, -0.26284313f, 
    -0.20928743f, -0.23872314f, 0.17544755f, 0.12270167f, -0.01574491f, 0.01555767f, 0.10860272f, 0.24033242f, 
    0.10025224f, 0.18388964f, -0.22414535f, 0.11607989f, -0.03200291f, -0.04952928f, -0.06260321f, 0.05816897f, 
    0.01420593f, 0.24111588f, 0.15450469f, 0.43831277f, -0.00060633f, -0.15893407f, -0.05863357f, 0.19435117f, 
    -0.12696388f, 0.04416128f, -0.11445351f, 0.15268883f, 0.26316226f, 0.05242957f, -0.13717169f, -0.44825155f, 
    0.02633448f, 0.03180120f, 0.03229595f, -0.07108264f, 0.14747261f, 0.27154756f, 0.13228543f, 0.08010640f, 
    0.15260193f, -0.16289112f, -0.02849602f, 0.09604936f, -0.19902840f, -0.19705051f, -0.18463111f, 0.02654877f, 
    -0.07912834f, 0.10476522f, -0.34812644f, 0.08338934f, 0.15905820f, 0.10606354f, 0.38436398f, 0.10003206f, 
    0.09521974f, -0.06304048f, -0.09787707f, -0.16856217f, -0.04967924f, -0.03752190f, 0.14893919f, 0.37453762f, 
    -0.05346168f, 0.41928837f, 0.13686554f, -0.17900428f, -0.05090399f, -0.07256048f, -0.00688223f, 0.19700247f, 
    0.15396762f, 0.73440075f, -0.42646053f, -0.10469179f, -0.07764794f, 0.26734164f, -0.28450668f, 0.13128747f, 
    -0.04243274f, -0.45329413f, -0.35962775f, 0.11864652f, 0.14492579f, 0.06289922f, -0.10182354f, -0.20212597f, 
    0.25898904f, 0.00693459f, 0.20206171f, 0.48061594f, 0.02483388f, 0.16886516f, -0.09129907f, -0.00787583f, 
    -0.02362174f, 0.08038179f, 0.00326318f, -0.28903791f, 0.22835702f, 0.12795742f, -0.23314439f, 0.06378077f, 
    0.07343744f, 0.00582398f, 0.07058796f, -0.05785095f, -0.06402756f, -0.56589329f, -0.28081596f, -0.00823155f, 
    0.05850255f, 0.02813364f, -0.02732686f, 0.11586211f, -0.13063009f, -0.28855082f, -0.00255123f, -0.06701238f, 
    -0.08469974f, -0.00643384f, -0.05966873f, 0.15272456f, 0.00860886f, 0.00661004f, -0.11033799f, -0.32208923f, 
    0.18081829f, -0.14629394f, 0.03902745f, -0.26164344f, 0.00737525f, 0.16128825f, -0.08171999f, -0.14292279f, 
    0.08649778f, 0.12605566f, 0.22327732f, -0.09700865f, 0.50588351f, -0.21106900f, 0.11232128f, 0.00983016f, 
    -0.64379364f, -0.32603508f, -0.37355995f, 0.14567776f, 0.15314823f, 0.00249046f, -0.01518485f, 0.24780351f, 
    0.12477590f, 0.11996832f, 0.39660570f, -0.25847849f, 0.24122146f, 0.16100359f, 0.06957323f, -0.11627585f, 
    0.06205916f, 0.07257523f, -0.13390303f, 0.10895306f, -0.08924666f, -0.03405938f, -0.01703338f, 0.07562039f, 
    -0.04181201f, 0.04894680f, 0.01451405f, -0.11252627f, -0.09174975f, 0.17300570f, -0.20334458f, 0.18609643f, 
    -0.11713672f, 0.02947644f, 0.08716036f, 0.28781894f, -0.01934046f, 0.06040068f, 0.09400241f, 0.02072475f, 
    -0.07317021f, 0.19378328f, -0.06940531f, 0.26991686f, 0.04880668f, 0.28640267f, 0.12356723f, -0.20624645f, 
    0.05840489f, -0.33214390f, 0.06830513f, -0.01573097f, -0.16151582f, 0.09957522f, 0.09554482f, -0.32362014f, 
    0.14318019f, -0.16891666f, -0.10442617f, -0.07300977f, -0.02116029f, -0.09583189f, 0.11269279f, -0.61965811f, 
    -0.24346945f, -0.10134352f, 0.16019775f, 0.15989575f, 0.05108328f, -0.00154322f, 0.29207143f, 0.07005739f, 
    0.25896311f, 0.20452699f, -0.01453386f, -0.20618682f, -0.24649060f, -0.07041805f, -0.06970201f, -0.06148556f, 
    0.17525893f, -0.33616826f, -0.23464394f, -0.05425446f, 0.08400838f, -0.12218800f, 0.02229179f, -0.01472571f, 
    0.13388327f, 0.10588527f, 0.09400998f, 0.18996119f, 0.02297560f, -0.25373873f, -0.08430358f, -0.01380441f, 
    -0.11891498f, -0.11288132f, 0.17911890f, -0.16992541f, -0.34113878f, 0.15894711f, -0.30515695f, -0.45400098f, 
    0.09122293f, -0.07856692f, 0.01240154f, 0.30698624f, -0.53795147f, -0.27678692f, -0.03585977f, -0.08840645f, 
    0.01356419f, -0.07481872f, 0.01186942f, 0.16234408f, 0.31016591f, -0.22139791f, 0.31736398f, -0.10887526f, 
    -0.56653786f, -0.07988472f, 0.06825157f, 0.00499882f, -0.08513040f, 0.18508948f, -0.29730353f, -0.61604434f, 
    0.09058917f, -0.03523846f, 0.10639793f, 0.00985803f, 0.05147291f, -0.29489669f, -0.19116415f, 0.09396031f, 
    0.07472774f, -0.07769241f, -0.02674462f, 0.04477137f, 0.05966529f, -0.01762679f, 0.03828338f, 0.17665420f, 
    -0.01783347f, 0.00364180f, 0.05157366f, -0.03562461f, 0.01409040f, 0.00837442f, -0.05235329f, 0.04324175f, 
    -0.04885551f, -0.05016671f, -0.00958297f, 0.01217641f, 0.02805070f, 0.03209336f, -0.02184345f, 0.03302210f, 
    -0.00645071f, 0.03183138f, -0.05292043f, -0.04207639f, 0.05251157f, 0.01960441f, -0.03447380f, -0.02639264f, 
    0.01636374f, -0.04151251f, -0.03675779f, 0.00078046f, 0.01870841f, -0.03824447f, -0.01980865f, 0.01966140f, 
    -0.02790261f, -0.00031821f, -0.05639818f, -0.04391291f, 0.04610607f, -0.03720834f, -0.00623019f, 0.03397697f, 
    0.04869571f, 0.01557054f, -0.04532403f, -0.01980649f, 0.03106683f, 0.01692963f, 0.01327012f, -0.03253244f, 
    -0.03944921f, -0.04372331f, 0.01320376f, -0.01543351f, 0.01924910f, -0.05578371f, 0.03436806f, 0.03281154f, 
    -0.03326466f, -0.01499440f, 0.00843686f, 0.02171245f, -0.01792161f, 0.03574789f, -0.04987013f, -0.00370439f, 
    0.02548092f, -0.02167461f, -0.00391022f, -0.04361116f, 0.00286792f, 0.02780873f, -0.00379688f, -0.06079279f, 
    0.01991645f, -0.00365745f, 0.00646186f, -0.00962078f, 0.01894766f, -0.04587498f, 0.03045000f, -0.00754054f, 
    0.05197244f, 0.02829351f, 0.04678823f, 0.01607994f, -0.04803576f, 0.01426337f, 0.00470227f, 0.03838990f, 
    -0.05649273f, -0.04886224f, -0.02336307f, 0.00146729f, 0.01313726f, -0.04109412f, 0.04482525f, -0.00138132f, 
    0.03163872f, -0.02375060f, -0.01623578f, 0.03167831f, -0.05205455f, -0.01262912f, -0.00317240f, -0.00722917f, 
    -0.01848941f, 0.02137027f, 0.04873125f, 0.03421255f, -0.00896710f, -0.02002523f, -0.06036391f, 0.05572299f, 
    0.03636653f, 0.00033311f, -0.04123017f, 0.02422163f, 0.01449905f, -0.00992639f, 0.01203410f, -0.04519905f, 
    0.04598161f, -0.03551963f, -0.03024117f, -0.06038305f, 0.02260938f, -0.01639445f, -0.02680375f, 0.02131181f, 
    -0.04266392f, -0.03747343f, 0.03862334f, -0.03720254f, -0.00858523f, -0.04501545f, -0.04537763f, -0.01052125f, 
    0.02723695f, -0.01999819f, -0.02982474f, -0.01416203f, -0.04384877f, -0.03718212f, 0.03992428f, -0.03013411f, 
    -0.00867583f, -0.03147731f, -0.06482924f, -0.02459742f, 0.00714551f, 0.00522114f, -0.02406039f, -0.02901614f, 
    -0.01445182f, -0.03949842f, -0.04123374f, 0.03533442f, -0.01791259f, 0.00127392f, 0.02940479f, 0.04852938f, 
    0.03639771f, -0.00609420f, 0.04257468f, 0.00540796f, -0.04361764f, 0.05005153f, -0.02018720f, -0.04409644f, 
    -0.03493757f, -0.03478187f, -0.05464114f, -0.02686547f, -0.00949763f, 0.01897370f, -0.00767011f, -0.03312654f, 
    -0.03337874f, 0.01350806f, 0.03888686f, -0.01753639f, 0.00042049f, 0.00306634f, -0.00711326f, 0.01052111f, 
    -0.04940534f, -0.06332105f, 0.02547616f, 0.01811352f, -0.03072485f, -0.03770004f, 0.02230297f, -0.00777485f, 
    0.01818030f, -0.02456569f, -0.03922415f, 0.02077327f, -0.04901647f, 0.05752848f, -0.02862354f, 0.02118980f, 
    -0.01986575f, -0.02707296f, -0.03824668f, 0.01099914f, 0.04614776f, -0.02837072f, -0.01000728f, -0.01517739f, 
    0.02557185f, 0.04217870f, -0.00145085f, 0.05222537f, -0.03010256f, -0.02638261f, -0.00517588f, -0.05515628f, 
    0.02289590f, 0.02475347f, -0.04734441f, 0.05867116f, 0.00947924f, 0.00509047f, -0.06269880f, 0.01932135f, 
    -0.05587610f, 0.04705838f, 0.00781030f, -0.04205974f, -0.04419426f, 0.03198147f, -0.02605811f, -0.03622558f, 
    -0.04220006f, 0.05332841f, 0.01959337f, 0.03839434f, 0.04814569f, 0.03865103f, -0.05769391f, -0.02669482f, 
    0.01337582f, -0.00806129f, -0.02244522f, -0.00063201f, 0.00604112f, 0.05423999f, -0.04909442f, 0.03714607f, 
    -0.02439911f, 0.01785733f, 0.04005801f, 0.03791231f, -0.04658472f, -0.00207996f, -0.05754511f, -0.00109551f, 
    0.00117808f, -0.00296069f, 0.03798793f, -0.05441509f, 0.01860304f, -0.05690884f, -0.03712204f, 0.05601821f, 
    -0.02647939f, -0.02735217f, 0.04037908f, -0.01874873f, 0.04137199f, 0.01119835f, -0.05962399f, -0.04275504f, 
    0.02311602f, 0.00077043f, 0.02062778f, -0.00597957f, -0.04591471f, 0.04975751f, -0.01074231f, 0.04936938f, 
    -0.03896212f, -0.04435354f, -0.01460606f, -0.06007275f, 0.04789741f, 0.02099758f, 0.01365983f, 0.01252368f, 
    0.03581359f, 0.04503971f, 0.05192186f, 0.04416279f, 0.08869274f, 0.08718825f, 0.12585087f, 0.06310783f, 
    0.04936965f, 0.11598334f, 0.36521146f, 0.29177505f, 0.19474420f, -0.01610342f, 0.23910162f, 0.42295742f, 
    0.09505939f, 0.05860407f, 0.10217115f, 0.05064093f, -0.23262103f, 0.17875779f, -0.15980145f, -0.00051914f, 
    -0.18569326f, -0.08561848f, -0.00050618f, 0.04742366f, 0.00991967f, -0.25282660f, 0.07914259f, 0.00363478f, 
    -0.04638368f, 0.15923430f, 0.04373923f, 0.18137832f, -0.29277536f, -0.33135831f, 0.08942986f, 0.30455682f, 
    0.14858776f, 0.02475364f, -0.02841366f, 0.08814712f, -0.00945823f, 0.32649413f, 0.03099075f, -0.09519803f, 
    0.05231104f, -0.08110811f, 0.08813183f, 0.09721232f, -0.02167790f, 0.16554540f, 0.02792799f, -0.19138828f, 
    -0.31466421f, -0.17807969f, -0.26962128f, -0.10307258f, 0.06323764f, 0.10953427f, -0.00444534f, -0.34933379f, 
    0.18143305f, 0.35266849f, 0.24405175f, 0.03950655f, 0.25901332f, 0.23074555f, 0.01004432f, 0.05652772f, 
    -0.56574315f, 0.15017632f, 0.09723435f, 0.06730501f, 0.12681343f, -0.10862970f, 0.35030204f, -0.33724034f, 
    0.15788396f, -0.17241901f, 0.01170879f, 0.43185836f, -0.00678986f, -0.12079302f, -0.14444333f, -0.17366557f, 
    0.02856326f, 0.01672961f, -0.16434295f, -0.14871341f, -0.05356080f, -0.24507146f, -0.14963344f, 0.26996246f, 
    -0.02908048f, 0.04083059f, -0.04780649f, -0.13641018f, 0.05260570f, -0.02076999f, 0.09050411f, 0.13633229f, 
    0.16504872f, 0.06414211f, 0.16209124f, -0.02475769f, -0.31173888f, 0.01735849f, -0.02441097f, 0.06914011f, 
    -0.06805691f, -0.19909340f, 0.27542946f, 0.11450041f, 0.07786834f, 0.27221307f, -0.05640842f, -0.02722008f, 
    -0.00353877f, 0.07422231f, 0.10383896f, -0.04932170f, 0.15559667f, -0.02518897f, 0.53575486f, 0.01912032f, 
    -0.06719660f, 0.02745222f, 0.14590557f, 0.11606274f, 0.18395364f, 0.07738534f, 0.27264494f, -0.61498046f, 
    -0.10581908f, -0.34140670f, 0.09599137f, -0.18811023f, -0.18971317f, 0.12058753f, -0.08572415f, -0.24017403f, 
    -0.11768503f, 0.09175332f, 0.28063932f, 0.09358370f, -0.03624935f, -0.18910992f, -0.06762592f, -0.04365785f, 
    0.21328741f, -0.02831898f, 0.01982999f, 0.03879015f, -0.27915663f, -0.17868915f, -0.12417203f, -0.00971105f, 
    0.02020120f, 0.08273191f, -0.16652776f, 0.15094014f, 0.15607455f, 0.05440008f, 0.09248254f, 0.01201895f, 
    0.05718019f, 0.07183254f, 0.14004748f, 0.04115795f, -0.30270654f, -0.18328732f, -0.09765987f, -0.04463466f, 
    -0.13205540f, -0.02521671f, -0.01011284f, 0.04845015f, 0.07815728f, 0.22625510f, 0.24367918f, 0.01666050f, 
    -0.04623380f, 0.21214345f, 0.01344735f, 0.11076850f, 0.01544083f, -0.46025693f, -0.28787667f, -0.15763989f, 
    -0.02507866f, -0.20391656f, -0.13568710f, -0.11134420f, -0.01909515f, 0.08480987f, -0.56416249f, -0.53549492f, 
    -0.44161966f, 0.09612264f, -0.00355214f, 0.07899266f, -0.06423301f, -0.08390057f, -0.04493489f, -0.26325068f, 
    0.02961100f, 0.27997077f, -0.01280603f, -0.05940684f, -0.13593641f, -0.03006218f, -0.05830733f, -0.01653022f, 
    0.21488515f, 0.00764382f, -0.59048879f, 0.12221839f, 0.07292590f, 0.15788548f, -0.01822949f, 0.04762280f, 
    0.18324564f, 0.20338804f, 0.10573575f, -0.05937661f, 0.09650467f, 0.08391923f, 0.15900974f, 0.02111175f, 
    -0.00505101f, 0.10516863f, -0.20932239f, -0.50157851f, -0.29554686f, 0.09053853f, 0.13113953f, 0.31608272f, 
    0.17240180f, 0.03160569f, 0.01713211f, 0.21378176f, -0.41054797f, -0.74926865f, -0.06228937f, -0.13747586f, 
    0.18835828f, -0.10933115f, 0.05703465f, 0.06815775f, 0.28446943f, -0.07091941f, -0.15034695f, -0.00524531f, 
    -0.00033469f, 0.10122167f, -0.00476507f, -0.08918358f, 0.07981465f, -0.38325021f, -0.79926032f, 0.23290631f, 
    0.20064802f, 0.08786185f, 0.06688897f, 0.19931379f, 0.20184559f, 0.13537319f, -0.20601597f, 0.14956804f, 
    0.01651925f, -0.10972669f, -0.12979622f, -0.04568497f, 0.22575323f, -0.00559335f, 0.15493171f, -0.83075577f, 
    -0.01774980f, -0.14370739f, 0.62990493f, 0.03009997f, 0.05815916f, 0.17384078f, -0.06233032f, -0.07170819f, 
    0.07457835f, 0.11989501f, 0.00171425f, -0.04210563f, -0.23464897f, -0.04991301f, 0.08418343f, -0.10089141f, 
    -0.05060710f, 0.00828427f, -0.01089455f, 0.00113664f, 0.16452512f, 0.02640381f, 0.24155700f, 0.11013070f, 
    0.06945842f, 0.10817778f, 0.29460296f, 0.09791333f, 0.14894009f, 0.19943295f, 0.01967587f, 0.04954691f, 
    -0.00312186f, -0.09685341f, -0.01748393f, -0.24701384f, -0.54504257f, 0.00162176f, 0.00944840f, -0.05606419f, 
    0.05300295f, 0.05009384f, -0.07513735f, 0.10028634f, -0.22393313f, 0.25436503f, 0.33283672f, -0.00094301f, 
    0.06338334f, -0.12463548f, 0.02196827f, 0.04874059f, -0.17273992f, 0.18877690f, -0.08714400f, -0.08200172f, 
    -0.05869995f, 0.07648090f, 0.07185680f, 0.36327338f, 0.11391374f, -0.14607164f, -0.58883107f, -0.21829785f, 
    0.10227955f, 0.04185577f, 0.00670663f, -0.05204891f, 0.00202264f, -0.15950491f, -0.14382623f, -0.42786232f, 
    0.16379547f, 0.12381628f, 0.16201958f, 0.15179540f, -0.01706523f, 0.21690153f, 0.16198744f, 0.32997465f, 
    -0.25609270f, -0.01873520f, 0.27409655f, 0.02183178f, -0.08390972f, -0.25877294f, 0.20762807f, 0.00332041f, 
    0.03861533f, 0.30541924f, -0.17373288f, -0.75786334f, -0.04794194f, 0.06177865f, 0.15753259f, 0.04662029f, 
    0.01685216f, 0.01636826f, -0.68086255f, -0.56577665f, 0.02276769f, -0.01512356f, 0.07021487f, -0.21668056f, 
    0.03530313f, -0.09424526f, -0.07239987f, -0.14614812f, 0.18308392f, -0.07681613f, 0.01204130f, 0.19389942f, 
    0.13434109f, 0.06340965f, 0.04390819f, 0.02501531f, 0.10259026f, 0.16352822f, 0.02882065f, -0.03267945f, 
    -0.18639286f, 0.06159398f, -0.02037452f, -0.11271855f, -0.08828808f, 0.29909256f, 0.11026481f, 0.01309290f, 
    -0.06682736f, 0.10033181f, 0.16320710f, -0.01724140f, -0.19234377f, 0.01776473f, 0.41762543f, -0.27831796f, 
    -0.21076772f, -0.06890360f, 0.03154503f, 0.09926344f, 0.31219473f, 0.14893782f, -0.17763132f, -0.17940181f, 
    0.22037539f, -0.10146352f, -0.16526787f, -0.35434091f, 0.08586444f, 0.19579731f, -0.05817485f, -0.06883863f, 
    0.01710127f, -0.02956227f, -0.50048029f, -0.03451561f, 0.05075471f, -0.20798716f, 0.07692798f, 0.00290160f, 
    -0.03375179f, -0.22915067f, -0.08001380f, -0.32515812f, 0.01241580f, 0.00174680f, -0.14881118f, 0.05516141f, 
    -0.00107707f, 0.12820289f, 0.02240972f, 0.02491014f, 0.06403944f, 0.02275166f, -0.04005567f, -0.13004552f, 
    -0.06002323f, 0.00043639f, -0.08789332f, 0.07096220f, -0.12332366f, 0.09391373f, 0.00895920f, -0.03642698f, 
    -0.11801495f, 0.07614177f, 0.27687186f, -0.03056976f, 0.20354763f, -0.00483555f, -0.02231834f, -0.07308280f, 
    -0.19619639f, -0.02801210f, 0.03298976f, 0.03732357f, -0.05606521f, -0.70644420f, 0.20823400f, 0.06890443f, 
    0.00560599f, 0.06380272f, -0.05255670f, -0.01182228f, -0.09584794f, 0.14175215f, 0.06064629f, -0.06939071f, 
    -0.05961271f, 0.04827347f, 0.16405261f, -0.02358501f, -0.01627068f, 0.25087658f, 0.03252671f, 0.22662528f, 
    0.04674312f, -0.43694392f, -0.16106427f, -0.12129869f, -0.02840558f, 0.09565096f, -0.01955024f, 0.02866139f, 
    -0.70335251f, -0.12285697f, -0.13602543f, 0.04556148f, 0.07562061f, 0.07036546f, 0.02848475f, -0.05976517f, 
    0.19047083f, 0.00928235f, -0.06183745f, -0.04700963f, -0.06303544f, -0.00680820f, 0.06187052f, 0.02256861f, 
    0.09105822f, -0.02339329f, -0.62255657f, -0.03916188f, 0.24807613f, 0.03606635f, 0.05686540f, -0.03200725f, 
    0.00036044f, 0.00931471f, 0.05119858f, -0.34807733f, -0.00057556f, 0.33296365f, 0.02176556f, 0.13578743f, 
    -0.08974402f, -0.07684846f, -0.39140883f, 0.10753870f, 0.06531122f, -0.16560265f, -0.05046120f, -0.02175047f, 
    0.01939233f, -0.05870468f, -0.13115834f, 0.02442538f, -0.06335048f, -0.33340076f, -0.12199125f, 0.33219990f, 
    0.14018729f, -0.11467130f, -0.12381005f, -0.00035373f, 0.25883695f, 0.52266657f, 0.21197295f, 0.16039489f, 
    -0.02286013f, -0.04399291f, -0.27798524f, 0.01124070f, 0.08201110f, -0.01966779f, 0.03752040f, -0.84230584f, 
    0.42256057f, 0.08508757f, -0.09251373f, -0.01132679f, 0.09457730f, -0.05319919f, 0.13685775f, 0.05501675f, 
    0.03367374f, 0.00873940f, -0.00036960f, 0.03534615f, -0.04223472f, -0.01190301f, 0.04193052f, -0.05627048f, 
    0.02398439f, -0.01079642f, -0.05655993f, 0.02408921f, -0.06359274f, 0.02910154f, -0.01807921f, -0.04575742f, 
    -0.06443357f, 0.01744274f, 0.05313791f, -0.01391194f, 0.01128233f, -0.05305165f, -0.02408823f, -0.03281997f, 
    0.02720812f, -0.04919226f, 0.03598093f, 0.01726555f, 0.02691214f, -0.00804390f, 0.01011043f, -0.05638424f, 
    0.05577119f, 0.04219452f, 0.02946265f, 0.00032900f, 0.04841483f, 0.04223697f, 0.03876958f, 0.01443704f, 
    0.00956518f, -0.06055013f, 0.02057171f, 0.00691899f, 0.04606699f, -0.00264190f, 0.02080736f, -0.00838863f, 
    -0.02407387f, -0.03402208f, 0.00005040f, -0.06273715f, -0.00701607f, -0.05905821f, -0.02940886f, -0.02802192f, 
    -0.03033656f, -0.05159210f, -0.02010038f, -0.04906612f, 0.02139998f, 0.02617340f, 0.00491344f, -0.00612780f, 
    0.02405929f, -0.01755297f, -0.02521445f, 0.02027421f, -0.02650906f, 0.02389562f, 0.01767501f, -0.00593933f, 
    -0.01212050f, 0.02740692f, -0.04453005f, -0.00149950f, 0.04819473f, 0.04681585f, -0.00793428f, 0.04599547f, 
    -0.04368221f, -0.01009822f, -0.01012345f, -0.04155848f, -0.05070517f, -0.01779907f, -0.00338294f, 0.00232332f, 
    -0.05260442f, -0.03981276f, 0.00452978f, 0.04769662f, 0.01579322f, 0.02361904f, 0.01163121f, -0.04827045f, 
    -0.06234939f, 0.01879488f, -0.02999700f, -0.03800326f, 0.03455344f, -0.01271018f, -0.01146956f, -0.02435275f, 
    0.03290279f, -0.03464551f, 0.02977641f, 0.02199753f, -0.04554713f, 0.03950702f, -0.06538066f, -0.02723810f, 
    0.00108654f, 0.03844400f, -0.05792915f, -0.01109289f, 0.03855612f, -0.06157626f, -0.04479953f, -0.04336595f, 
    -0.00648240f, -0.00418533f, 0.03786749f, 0.03942332f, -0.03683677f, -0.01480908f, -0.05397765f, -0.06316807f, 
    0.00245321f, 0.04695705f, 0.03793765f, -0.01762155f, -0.02577081f, 0.02455248f, -0.02089056f, 0.00844260f, 
    -0.01400252f, -0.00322448f, 0.04618040f, -0.05797617f, 0.00579518f, 0.00133277f, 0.03889602f, -0.00507000f, 
    0.03434158f, 0.02317079f, 0.01185625f, -0.05222397f, 0.00458415f, -0.03234324f, -0.01174479f, 0.02911151f, 
    0.05253546f, -0.03479522f, -0.06101982f, -0.05264007f, -0.01931908f, -0.03688949f, 0.01599761f, -0.04402569f, 
    0.04562028f, -0.01832451f, 0.00416966f, 0.04883832f, -0.06817681f, -0.04248534f, -0.06047956f, 0.00373300f, 
    -0.00699411f, -0.03205509f, 0.00141928f, 0.01261727f, -0.05023725f, 0.01312403f, -0.05621779f, -0.01370838f, 
    0.03506295f, -0.01700216f, 0.04758758f, 0.04231455f, 0.03389396f, -0.00047017f, -0.05114220f, -0.01718890f, 
    0.02898299f, -0.01359876f, -0.04759221f, -0.05035415f, 0.00970207f, 0.04453335f, -0.01319973f, -0.03069376f, 
    -0.01599069f, -0.01592949f, 0.04663151f, -0.05585008f, 0.02951400f, -0.01086636f, -0.02095818f, 0.00427803f, 
    -0.03591831f, 0.02610764f, 0.01704719f, -0.00243595f, -0.00127695f, -0.01759893f, 0.01516402f, -0.05507401f, 
    -0.00718039f, -0.00385269f, -0.03314394f, -0.02403184f, -0.03016690f, 0.00112316f, -0.03115128f, -0.06572621f, 
    0.00304641f, 0.04132776f, -0.04150390f, -0.06257104f, -0.00417308f, -0.03422299f, -0.04581340f, -0.02279872f, 
    -0.05169073f, -0.03480753f, 0.00956951f, -0.02478698f, -0.02355496f, 0.04081516f, 0.00512488f, 0.00486633f, 
    0.03822542f, 0.02445228f, -0.02223303f, 0.03252493f, 0.02471976f, -0.03742580f, -0.04656828f, -0.05902022f, 
    0.01637041f, -0.05950740f, -0.06409669f, 0.01899088f, 0.04645626f, 0.02947464f, -0.04047776f, -0.05164652f, 
    0.02113612f, 0.02025169f, -0.05871565f, -0.00698936f, -0.05760207f, -0.03206084f, 0.01458303f, 0.02792052f, 
    0.00663607f, -0.01485134f, -0.04571357f, 0.00665049f, -0.02668299f, -0.06215896f, -0.00546062f, -0.05400427f, 
    -0.00507041f, -0.04779194f, -0.01234653f, -0.03278721f, 0.01500672f, -0.00759906f, 0.02848204f, 0.01992053f, 
    -0.01082084f, -0.05951377f, -0.04387935f, -0.04081893f, 0.03920859f, -0.00989218f, 0.00755055f, -0.01207189f, 
    -0.02588068f, 0.02918241f, -0.01312232f, 0.03600353f, 0.04063703f, -0.05643954f, 0.04343415f, -0.02080076f, 
    -0.01469906f, 0.01324545f, -0.03905515f, -0.03600480f, -0.06581376f, -0.03213879f, -0.00575070f, 0.04233428f, 
    -0.03881906f, -0.01039033f, -0.04483610f, 0.02286878f, -0.07037511f, 0.04221396f, -0.06303937f, -0.02404323f, 
    -0.03409891f, 0.03058289f, -0.06250170f, -0.05679380f, -0.01951935f, -0.02485654f, 0.03992111f, 0.00880812f, 
    -0.04256488f, -0.05861003f, -0.05107919f, -0.04117807f, -0.01280416f, -0.00526862f, -0.01267599f, -0.05596369f, 
    0.01111045f, -0.03192073f, 0.02629568f, -0.07080296f, -0.02192446f, -0.06184173f, -0.01282517f, 0.04175817f, 
    -0.05391078f, 0.00603643f, 0.00803869f, 0.01148949f, -0.04110007f, -0.05542103f, -0.04189399f, -0.05662927f, 
    0.05165866f, -0.00651063f, -0.05928155f, 0.04765832f, 0.04218011f, 0.00386629f, -0.02957560f, -0.03585138f, 
    0.03322243f, 0.04893002f, -0.04151083f, 0.03186534f, -0.02982613f, -0.06831865f, -0.01230206f, -0.02743393f, 
    -0.05176492f, 0.03979912f, -0.03486727f, 0.01739445f, -0.05708921f, -0.05608990f, -0.03019264f, 0.03879714f, 
    0.04413087f, -0.05901010f, 0.02065373f, -0.05946697f, -0.02248896f, -0.01669206f, -0.00510680f, 0.03947846f, 
    -0.01604823f, 0.02337851f, -0.00320095f, -0.00555777f, 0.00212794f, -0.00527555f, -0.01971093f, -0.00133982f, 
    -0.03652358f, -0.00993364f, 0.01438789f, 0.01653362f, -0.01066893f, -0.05106619f, 0.01049699f, 0.03941149f, 
    0.02965843f, -0.01920752f, -0.05843388f, -0.04445228f, -0.05932695f, 0.03026675f, -0.00164225f, -0.06448197f, 
    0.04107625f, -0.02933319f, -0.03654129f, -0.05074934f, -0.03053309f, 0.03311035f, 0.04266232f, -0.01138686f, 
    0.02743887f, -0.01897005f, 0.01584674f, 0.01284529f, 0.00345079f, 0.00380249f, -0.06409344f, 0.04119550f, 
    0.04355649f, -0.02304156f, 0.02649632f, -0.06002591f, 0.03336002f, -0.02437066f, 0.01141679f, -0.05702706f, 
    0.03097584f, 0.04578097f, 0.03507096f, 0.03989125f, -0.00760232f, -0.05008940f, 0.04238082f, 0.03406844f, 
    0.02614778f, -0.00404460f, 0.02506568f, -0.03902884f, -0.05912619f, 0.01457620f, 0.03707793f, 0.02901033f, 
    0.00678312f, -0.06505850f, -0.02590941f, 0.01929889f, -0.02284640f, -0.05311706f, -0.02631007f, 0.03699554f, 
    -0.06150346f, 0.00713477f, 0.01553040f, 0.03228057f, -0.04204781f, -0.01781940f, 0.00090679f, -0.05099834f, 
    -0.02900202f, 0.04491314f, -0.02370292f, -0.03438252f, 0.03109497f, -0.05987699f, 0.01353733f, 0.01337656f, 
    -0.04064038f, 0.02316232f, -0.04364854f, -0.03899553f, -0.00991456f, -0.05679859f, 0.05233037f, -0.05980778f, 
    -0.06128183f, -0.03922930f, 0.04070907f, 0.00992868f, -0.00706277f, 0.01169964f, 0.00619575f, 0.01477719f, 
    -0.06797443f, -0.06520312f, -0.04315447f, 0.01684054f, -0.01725557f, -0.00478176f, -0.01775356f, -0.06847292f, 
    0.02768977f, 0.02232892f, -0.06190653f, -0.06314310f, -0.05620708f, -0.03850362f, 0.03517660f, 0.04185744f, 
    0.01660838f, 0.04251470f, -0.00488440f, -0.04836109f, 0.03714878f, 0.05262978f, -0.04273453f, -0.03741010f, 
    0.02224914f, 0.03427856f, 0.04186410f, 0.04120065f, -0.03368714f, -0.06825081f, 0.02398640f, 0.02418192f, 
    -0.06082404f, -0.01670019f, 0.04047757f, -0.04430282f, -0.03495283f, -0.01297141f, -0.03493794f, -0.05903821f, 
    0.04407502f, -0.01063985f, 0.01496980f, 0.02514989f, 0.04312173f, 0.02518808f, 0.04489643f, -0.06186046f, 
    -0.02178123f, -0.00145929f, 0.03904717f, -0.05010341f, 0.04101219f, 0.02860777f, -0.04652172f, 0.01036305f, 
    0.04129467f, 0.04339404f, -0.04562474f, 0.00256693f, -0.04032471f, 0.02057056f, -0.00970563f, -0.03567935f, 
    0.03893550f, 0.00838772f, -0.03326131f, -0.01325820f, 0.02922314f, -0.00565013f, 0.04161117f, -0.01022608f, 
    0.01317773f, -0.04069639f, -0.02511130f, 0.01973057f, -0.05771368f, 0.03651327f, 0.04679259f, -0.04325106f, 
    -0.00662034f, 0.01378399f, 0.02473729f, -0.05453475f, 0.04565191f, -0.00021515f, 0.01638872f, -0.06455791f, 
    -0.05182511f, -0.04695880f, -0.00578265f, -0.06688257f, -0.01132959f, -0.04862577f, -0.01284027f, 0.02787437f, 
    -0.05213029f, -0.05514317f, -0.04178933f, -0.00691931f, 0.02506849f, 0.01064318f, 0.00508965f, 0.01277262f, 
    0.01757911f, -0.28401318f, -0.09304597f, 0.07674259f, -0.13077746f, 0.11196770f, 0.04706726f, 0.17578667f, 
    0.06418889f, -0.05232938f, -0.04769652f, -0.44031230f, 0.02732777f, 0.10045343f, -0.12484263f, -0.09211553f, 
    0.01574005f, 0.17696860f, 0.11224595f, 0.36952737f, 0.09108242f, 0.02126012f, -0.06035540f, -0.24101952f, 
    0.02748086f, -0.19842468f, -0.23108555f, -0.02359957f, 0.31850064f, 0.13077341f, 0.21700691f, 0.09753066f, 
    -0.15012106f, -0.07663797f, -0.04001299f, 0.10750476f, -0.43106300f, 0.25257978f, 0.37305078f, -0.04277932f, 
    -0.30579221f, -0.13982262f, 0.01128983f, 0.07298973f, 0.11318081f, 0.12104640f, -0.46239430f, -0.33530295f, 
    0.11657190f, 0.07631988f, -0.13597970f, 0.05243983f, 0.25086132f, 0.01550751f, 0.04134700f, 0.19654223f, 
    0.53603935f, 0.13688359f, -0.05655018f, 0.12113683f, 0.05496975f, -0.08841283f, 0.08864475f, -0.03143553f, 
    0.00503444f, -0.12157647f, 0.07771597f, -0.01367609f, -0.09937615f, -0.06716589f, 0.08644735f, 0.06395946f, 
    -0.77989846f, -0.14857414f, -0.09055274f, -0.27506512f, 0.03248508f, -0.06842238f, -0.00511442f, -0.07848597f, 
    -0.01313392f, -0.85328108f, 0.57348567f, 0.54263812f, 0.05116877f, -0.20435771f, -0.19668692f, -0.14828475f, 
    -0.16298646f, 0.24902815f, -0.45843050f, 0.22963051f, 0.26609129f, 0.08090885f, -0.01099915f, 0.19880968f, 
    0.12898494f, 0.01055336f, 0.21894579f, 0.32858232f, -0.15411073f, -0.01197874f, 0.04607868f, 0.00635050f, 
    0.06369934f, -0.03402327f, 0.03334739f, -0.01354763f, -0.05171316f, -0.00093942f, -0.16342936f, -0.01963656f, 
    0.04969507f, -0.07188375f, 0.03226138f, 0.13159490f, 0.24338438f, 0.01011286f, -0.00200165f, -0.11135340f, 
    0.10268982f, 0.01267577f, -0.26912668f, 0.10063939f, 0.09928985f, -0.00600796f, 0.13454022f, 0.03816075f, 
    -0.69620162f, 0.13112646f, -0.05495900f, -0.09564012f, -0.05217418f, 0.16758072f, 0.07254402f, 0.40736493f, 
    -0.34139097f, -0.33827090f, -0.05621693f, -0.11107811f, 0.14901736f, -0.31522661f, -0.01727729f, -0.01601467f, 
    -0.44454309f, 0.49065346f, 0.40872586f, -0.10809901f, -0.07034273f, -0.04150621f, 0.03500853f, -0.08481668f, 
    0.20509145f, -0.50778478f, -0.04362858f, 0.34914041f, 0.03620113f, -0.02751428f, -0.13222744f, -0.05476518f, 
    0.16388620f, 0.14726923f, -0.37492177f, -0.47701892f, 0.05881034f, -0.06409566f, 0.05641986f, -0.08299122f, 
    -0.04604317f, 0.16944297f, 0.03994146f, -0.62335062f, -0.24774478f, 0.22558811f, 0.05331404f, -0.00661069f, 
    0.02013641f, 0.29891574f, 0.16729848f, 0.06571397f, -0.18115665f, 0.24711660f, -0.02968473f, 0.03434822f, 
    -0.03521163f, -0.20508614f, 0.06041105f, 0.05576069f, -0.11884397f, 0.23795845f, 0.41769150f, 0.40704778f, 
    0.14686385f, -0.09674432f, 0.04856587f, 0.08329217f, -0.06966110f, -0.14203292f, 0.66761357f, -0.58457160f, 
    0.41785708f, -0.04365743f, -0.04961485f, 0.06600731f, 0.13451722f, 0.12627406f, 0.07267566f, -0.02700266f, 
    0.20841758f, 0.45479435f, -0.09734540f, -0.07947139f, -0.13027528f, 0.30359226f, -0.09118821f, 0.08183007f, 
    0.14292350f, 0.17629607f, 0.14117582f, -0.04122206f, -0.04951646f, -0.05689020f, -0.19451034f, -0.17180838f, 
    -0.45498493f, -0.15461968f, -0.17472386f, -0.42242017f, -0.07847400f, -0.05561347f, -0.13661629f, -0.13566901f, 
    0.12565856f, -0.14825717f, -0.19328821f, 0.04474099f, 0.57567888f, -0.01135717f, 0.14103532f, 0.14442167f, 
    0.03838012f, -0.00497981f, -0.08038486f, -0.21161228f, -0.02605943f, 0.31045198f, 0.09323595f, -0.10914047f, 
    -0.24675877f, -0.22482993f, -0.23372027f, -0.23628314f, -0.02072188f, -0.11703345f, -0.00827670f, 0.06911241f, 
    -0.04700614f, -0.14545260f, -0.01689300f, 0.10282812f, -0.21594958f, -0.40782776f, -0.32442033f, 0.37457731f, 
    -0.13048214f, -0.18733408f, -0.20154452f, 0.17676246f, 0.05812651f, -0.00495819f, 0.16804077f, -0.26668939f, 
    -0.21119215f, 0.17710610f, -0.06026888f, 0.03418893f, 0.06512307f, 0.25384727f, 0.47325391f, 0.31410316f, 
    -0.00194234f, 0.25315872f, 0.01440215f, 0.16892578f, -0.31265786f, 0.05368625f, -0.04021381f, -0.08511112f, 
    -0.01980162f, 0.03068464f, -0.06191582f, 0.00077834f, 0.00794222f, 0.00430104f, -0.01331047f, 0.00790341f, 
    0.00945004f, 0.02763636f, -0.01967338f, 0.03135714f, -0.01436998f, -0.02579485f, -0.02155610f, -0.04756091f, 
    0.03913646f, -0.02737816f, 0.03873046f, 0.00094424f, -0.05888832f, -0.04725797f, -0.05961808f, 0.03668903f, 
    0.02467909f, -0.03447926f, 0.00610051f, -0.01146269f, -0.00945342f, -0.00441819f, 0.03814825f, -0.05574554f, 
    0.02755801f, 0.01410933f, 0.00112440f, 0.04682382f, -0.00195345f, -0.03245418f, 0.01222612f, -0.05905769f, 
    -0.02139318f, 0.04125616f, -0.04798950f, 0.04258675f, -0.05835163f, 0.03535555f, -0.03770455f, -0.04729716f, 
    0.02909345f, -0.01911132f, -0.01253565f, 0.01931557f, 0.04545439f, -0.05583380f, 0.03016966f, -0.03941929f, 
    -0.02003935f, -0.01780108f, -0.06435501f, 0.05171349f, -0.01017283f, -0.01050531f, -0.03606495f, 0.02516750f, 
    0.05059689f, 0.00521624f, 0.04009483f, 0.03179269f, -0.06629970f, 0.00670099f, -0.05551628f, -0.04491943f, 
    -0.04642835f, -0.01166457f, 0.01345222f, -0.01580680f, -0.02227001f, -0.00455632f, -0.00405885f, -0.03110426f, 
    -0.06109129f, -0.00039457f, -0.02898838f, -0.05496348f, 0.01403967f, -0.06518531f, 0.02577710f, -0.02144777f, 
    -0.02581664f, 0.04294912f, 0.02376684f, -0.06665152f, -0.00067246f, 0.03751409f, 0.00902253f, 0.02571831f, 
    0.02531842f, 0.03032169f, 0.02905402f, 0.00969124f, 0.00058065f, -0.04004439f, -0.06791187f, -0.02351533f, 
    -0.02490539f, -0.03397258f, 0.01217842f, -0.03963600f, 0.01900130f, 0.03278924f, -0.03839201f, -0.02459902f, 
    0.01341006f, 0.01680288f, 0.02817552f, 0.01726162f, 0.02203720f, 0.04224919f, 0.00301555f, -0.05423440f, 
    -0.01707925f, 0.00715823f, -0.04591598f, -0.04549329f, -0.05375350f, 0.02983118f, -0.00100708f, 0.00849233f, 
    0.03390666f, -0.06087065f, 0.04284290f, -0.02986017f, 0.01821117f, -0.03028633f, 0.00651508f, -0.03006798f, 
    0.02228748f, -0.05139426f, -0.00564765f, -0.03920341f, 0.02556524f, -0.00344226f, 0.02922433f, -0.04341742f, 
    -0.06541973f, 0.04629262f, -0.05952308f, -0.06658839f, 0.00369152f, -0.06260835f, -0.00921569f, -0.05951326f, 
    0.05086201f, 0.03980723f, -0.00927437f, -0.01095882f, -0.06179081f, 0.02952510f, 0.03907213f, -0.02695760f, 
    -0.01254526f, 0.01586833f, 0.00540090f, -0.05602462f, 0.02167821f, 0.04531857f, -0.04205934f, -0.05330757f, 
    -0.00719358f, -0.05704787f, -0.05822128f, -0.01485419f, 0.01141071f, -0.02066812f, -0.02125234f, -0.05768515f, 
    0.04814646f, 0.02132010f, 0.00919415f, -0.03393381f, 0.02348813f, -0.04220568f, -0.06327280f, 0.04872926f, 
    0.00240703f, 0.00472695f, 0.02476290f, 0.00221024f, 0.00246022f, -0.01045212f, 0.04725115f, 0.02232277f, 
    0.04140586f, -0.03075065f, 0.04374460f, -0.01216863f, -0.03739696f, -0.01410580f, 0.02703545f, 0.04061195f, 
    0.02379182f, 0.00806996f, -0.04365593f, 0.03424972f, 0.02601186f, -0.03964670f, -0.00366858f, -0.03556303f, 
    -0.01078882f, 0.01478253f, -0.02152448f, 0.01002479f, 0.03639944f, 0.01495342f, -0.06463849f, 0.01933385f, 
    0.00612628f, -0.04006798f, 0.03231506f, -0.01623894f, -0.04452380f, 0.03175805f, -0.00955112f, -0.03605691f, 
    0.04099716f, -0.03070783f, 0.03464526f, 0.00665138f, -0.04873252f, -0.02519593f, -0.05315809f, -0.02896953f, 
    -0.06135019f, 0.02394095f, -0.04209526f, -0.02010617f, 0.02611265f, -0.06839854f, 0.03127367f, -0.04840986f, 
    -0.07230851f, 0.03227407f, -0.01163891f, -0.05559441f, -0.05010613f, -0.01257074f, 0.02177910f, -0.06124772f, 
    -0.00266002f, 0.03766948f, 0.01237853f, 0.01493953f, 0.02364115f, 0.00986923f, 0.00359350f, -0.05116690f, 
    -0.00046961f, 0.01038480f, -0.00085798f, -0.04959253f, -0.03332581f, -0.03833501f, -0.01691766f, 0.03209778f, 
    -0.06747575f, 0.00492111f, -0.00218148f, 0.01990554f, -0.05607568f, 0.00968007f, 0.00151159f, 0.02538099f, 
    0.00881786f, 0.03891340f, -0.02557617f, 0.04201396f, -0.01887165f, -0.03037733f, -0.05466293f, -0.01588122f, 
    0.04029936f, 0.03187682f, 0.03212679f, 0.00547491f, -0.05676747f, 0.00892414f, -0.01168374f, 0.03589690f, 
    0.20022897f, 0.17881389f, 0.12908404f, -0.00881864f, 0.05179482f, -0.22847395f, 0.14515035f, 0.01412274f, 
    0.03244685f, 0.05798843f, -0.05029705f, -0.19447041f, 0.19215883f, 0.26583242f, 0.05591845f, 0.13534617f, 
    -0.10410123f, 0.14203262f, 0.05645768f, -0.13169527f, -0.18353233f, -0.12928823f, -0.07929225f, 0.04055011f, 
    0.16416740f, -0.03430189f, 0.10967558f, 0.34494144f, -0.19963555f, -0.28146201f, -0.05384081f, -0.02593479f, 
    0.13497679f, -0.01026689f, 0.10247543f, 0.04725285f, 0.21140851f, -0.27088916f, -0.18843433f, 0.05452802f, 
    0.00705134f, 0.04052648f, 0.00115925f, 0.02191877f, 0.07038391f, -0.67959934f, -0.07677066f, 0.60561675f, 
    -0.11464820f, 0.03222599f, 0.17775361f, -0.02604195f, -0.07784379f, 0.02053375f, 0.20591305f, -0.16560012f, 
    -0.12448464f, -0.05264812f, -0.22005066f, -0.24184023f, 0.03363723f, 0.09067614f, 0.00199888f, 0.38432911f, 
    -0.04003403f, -0.10151176f, 0.02974187f, 0.01958370f, -0.05482327f, 0.19987203f, 0.11894851f, 0.18634690f, 
    0.84366298f, 0.33819216f, -0.78231043f, -0.27187681f, -0.13566832f, -0.14747588f, -0.07970309f, -0.04989639f, 
    -0.19114181f, -0.14261575f, -0.73179150f, -0.29726887f, 0.00272155f, 0.25594917f, 0.15481167f, 0.04120087f, 
    0.15210250f, -0.06332082f, 0.40211162f, 0.08694299f, -0.05836102f, 0.14326885f, -0.20187794f, -0.00207853f, 
    -0.00068305f, 0.14675175f, -0.10277434f, 0.20216987f, -0.22634435f, 0.31469226f, -0.05311004f, -0.06980565f, 
    0.03383534f, 0.17333490f, -0.00133581f, -0.07140444f, -0.60892826f, -0.27117613f, 0.10869301f, -0.24742506f, 
    -0.06428774f, 0.06050086f, 0.14958489f, -0.10566664f, -0.17251819f, -0.63306397f, -0.23370580f, 0.15876321f, 
    -0.10106886f, -0.01602251f, 0.04797433f, 0.21192846f, -0.02075753f, -0.03322844f, -0.36202222f, 0.07652640f, 
    0.35958987f, -0.05874126f, -0.10994989f, 0.07678024f, 0.24469201f, 0.05504904f, 0.00559213f, 0.63186383f, 
    -0.68103111f, -0.66518801f, -0.04809241f, -0.26415449f, -0.11802371f, 0.26066768f, -0.20919150f, -0.08446735f, 
    -0.13660944f, -0.38859922f, -0.05566865f, -0.13874759f, 0.18454476f, 0.16717035f, 0.21747185f, -0.09575482f, 
    -0.01318916f, 0.29805318f, 0.04565847f, -0.08329122f, -0.02400271f, 0.02684796f, -0.03446003f, 0.01107891f, 
    0.22678240f, 0.08961903f, 0.26655802f, 0.22271946f, 0.04305150f, 0.06713945f, 0.08902650f, -0.00594181f, 
    -0.00133103f, 0.15960285f, 0.03264001f, -0.84369689f, 0.19966489f, 0.12278979f, -0.17023340f, 0.08377715f, 
    -0.16464221f, -0.21092917f, -0.16672976f, -0.09448636f, 0.13289697f, -0.09574458f, -0.06441386f, 0.18075578f, 
    0.14918286f, 0.05932877f, 0.01109677f, 0.33961952f, 0.08475334f, 0.61372703f, -0.26687488f, -0.22083817f, 
    -0.19216195f, 0.11542974f, -0.10446408f, 0.13229416f, -0.29710144f, -0.12862661f, -0.44881326f, -0.17761706f, 
    0.25595382f, -0.07292687f, -0.08357516f, -0.12741657f, 0.13081428f, 0.10441535f, 0.03196415f, -0.31151360f, 
    -0.40912837f, -0.12034835f, 0.00677968f, 0.20586324f, 0.04595590f, 0.21450724f, -0.06068932f, 0.11341679f, 
    0.31812516f, -0.08547040f, -0.02886134f, -0.07020640f, -0.04896496f, 0.06892538f, -0.05908227f, -0.06593525f, 
    0.17852621f, 0.09591725f, 0.23528484f, -0.18211915f, 0.10483593f, -0.00853119f, -0.03579729f, 0.19930111f, 
    0.18344642f, 0.00759644f, 0.08030140f, -0.00359993f, 0.40801495f, -0.04848207f, -0.25825146f, 0.00108468f, 
    0.06811997f, 0.16854675f, 0.13346276f, 0.47798505f, -0.41760671f, -0.30177203f, -0.20460813f, 0.05677083f, 
    -0.00061103f, -0.20898442f, 0.10319706f, 0.08628383f, -0.07275035f, 0.21508600f, -0.18117927f, 0.04295735f, 
    0.02897880f, -0.10502370f, 0.03391908f, 0.01731913f, 0.10243724f, 0.04926331f, 0.28887656f, 0.34297550f, 
    -0.02159438f, -0.04291529f, -0.01035917f, 0.05391169f, -0.06656270f, 0.13583095f, -0.61442727f, -0.08764308f, 
    0.16932847f, -0.04646374f, 0.02844849f, -0.12862779f, 0.00841951f, -0.34061798f, 0.09427243f, -0.02166542f, 
    -0.32400954f, -0.52277303f, 0.18979627f, -0.01818366f, -0.05109140f, -0.06307803f, 0.18357883f, -0.08434337f, 
    0.09581795f, -0.05886078f, 0.16775133f, 0.10699127f, 0.08463775f, 0.04418680f, 0.00777988f, -0.05924630f, 
    -0.01772753f, -0.09275685f, 0.05369293f, 0.08886054f, -0.00999787f, 0.01763195f, -0.10316002f, 0.37725902f, 
    0.24924275f, 0.12450469f, 0.32447517f, 0.29531673f, -0.14220455f, -0.04573496f, 0.12132204f, 0.11303686f, 
    0.01031185f, -0.14711529f, 0.08406975f, -0.21387801f, 0.35811669f, -0.88356346f, -0.14306448f, 0.08652172f, 
    0.05195698f, 0.04599856f, 0.05032063f, -0.16379215f, -0.23383078f, 0.35516635f, -0.47859061f, -0.05324034f, 
    -0.17855589f, -0.03377643f, 0.03121578f, -0.16599673f, -0.23788035f, 0.08090303f, -0.09232062f, 0.15636449f, 
    -0.01537109f, 0.18128155f, -0.05851382f, 0.20533921f, 0.01070126f, -0.10833771f, 0.53976744f, -0.15464357f, 
    0.11321139f, -0.01391966f, 0.01580535f, -0.11470471f, 0.10822975f, 0.22336598f, 0.23230556f, -0.39579448f, 
    0.03333063f, 0.45037365f, 0.09064703f, -0.06644487f, -0.00372124f, -0.05872212f, 0.09305521f, 0.01306608f, 
    0.01950919f, 0.14773670f, 0.37689206f, -0.01479792f, -0.23471074f, -0.11724392f, -0.03364439f, -0.00258370f, 
    -0.01820133f, 0.21804152f, 0.02090513f, -0.48652300f, -0.14078075f, -0.03593094f, -0.21816190f, 0.05716761f, 
    0.00033098f, -0.02266651f, -0.01315054f, 0.26375753f, -0.06926454f, -0.08303869f, -0.10342913f, 0.02603744f, 
    -0.06511489f, 0.12381876f, -0.09049315f, 0.10158011f, -0.18744119f, 0.00399991f, -0.06815142f, 0.17811976f, 
    0.18366098f, 0.03044852f, -0.12729904f, -0.07679221f, 0.24219912f, 0.13208784f, 0.10503933f, -0.03332945f, 
    0.14124389f, -0.21944663f, -0.06504869f, -0.01654523f, -0.05935423f, 0.27176896f, 0.04292792f, -0.05966414f, 
    -0.02861125f, -0.01485853f, 0.27508545f, 0.10510030f, -0.04888907f, -0.08563804f, -0.13497534f, -0.24442519f, 
    0.03289604f, -0.10145213f, 0.17065817f, -0.07363109f, 0.10131747f, 0.14764532f, -0.03311852f, -0.18446194f, 
    -0.29486960f, 0.19650930f, -0.35597333f, 0.13704973f, -0.00086462f, -0.01680883f, -0.11858066f, -0.01103740f, 
    0.25021300f, -0.00327140f, 0.01364344f, -0.17343381f, -0.23674865f, -0.02551728f, -0.03370518f, 0.01931017f, 
    0.04827992f, 0.03960940f, -0.13166714f, -0.39627770f, -0.12593728f, -0.20846270f, -0.02497074f, 0.21073039f, 
    0.12991506f, 0.11416990f, 0.05883718f, 0.00021077f, 0.09465606f, 0.01843092f, 0.14562708f, -0.08351217f, 
    0.15611868f, 0.05415957f, 0.06311908f, 0.05818214f, -0.11267322f, 0.02519001f, 0.04467339f, -0.06043645f, 
    -0.07131805f, 0.07438333f, 0.15055104f, 0.01354214f, 0.06884423f, 0.13897906f, -0.23112188f, -0.03076486f, 
    0.23676459f, -0.09459750f, -0.00242716f, 0.04174480f, -0.00121470f, -0.57868898f, 0.24187562f, 0.26505566f, 
    -0.28921828f, -0.03623487f, -0.04311670f, -0.01455198f, 0.00935427f, -0.06383263f, -0.16999975f, -0.34241864f, 
    0.05659524f, -0.10518595f, 0.06257636f, -0.07883032f, -0.04334674f, 0.00688267f, 0.16336676f, 0.09015518f, 
    0.17257093f, -0.10615589f, 0.02983175f, -0.04173795f, -0.03028487f, 0.05625467f, 0.10123143f, 0.05401881f, 
    0.04281179f, -0.60874969f, 0.20530003f, -0.14198218f, 0.17673095f, 0.01386398f, 0.00568307f, -0.10913219f, 
    0.14789690f, -0.02210453f, -0.11621447f, 0.12392619f, 0.12424374f, 0.08747399f, -0.01392034f, 0.06193049f, 
    0.08627044f, 0.00220500f, -0.45807794f, -0.06055061f, -0.03148348f, 0.14453417f, 0.10597061f, 0.03899832f, 
    -0.14548008f, -0.11621974f, -0.12858702f, 0.10507556f, -0.62926912f, 0.15976721f, 0.04239859f, 0.08754500f, 
    0.16441604f, 0.00048680f, -0.00678303f, -0.09039334f, 0.01513922f, -0.27906209f, 0.04099965f, 0.10312904f, 
    0.00144867f, 0.06427451f, 0.02471438f, 0.06976131f, -0.05383471f, -0.63040233f, 0.01353003f, 0.26758805f, 
    0.12445471f, -0.03497555f, 0.10371038f, 0.01235994f, -0.07972643f, 0.22320925f, 0.07317606f, 0.09563369f, 
    0.26145801f, -0.09616111f, 0.08870378f, -0.36319038f, 0.07633405f, -0.12650082f, -0.07979888f, -0.11670478f, 
    0.04974741f, -0.34687412f, 0.08572558f, 0.38513768f, -0.00112820f, -0.16314517f, 0.14881125f, -0.00617753f, 
    -0.00737571f, 0.15981887f, -0.07946148f, -0.02744189f, 0.12364157f, 0.03690340f, -0.16769876f, 0.09817433f, 
    -0.26398376f, 0.17672515f, 0.15463385f, -0.09723450f, 0.23297009f, -0.08380964f, 0.01901760f, -0.22910039f, 
    0.09562365f, -0.08212452f, -0.22590360f, -0.04856797f, -0.04198958f, 0.02895114f, 0.16367340f, -0.01075896f, 
    0.12261742f, -0.27662101f, -0.18482523f, -0.24486968f, -0.34104949f, 0.00381980f, -0.12208331f, -0.06563374f, 
    0.17262021f, 0.02778587f, -0.03113297f, -0.10376856f, 0.26252604f, -0.48336416f, 0.27161649f, 0.05155853f, 
    0.26340911f, -0.20117389f, -0.16145806f, 0.04994589f, -0.00161653f, 0.14506112f, 0.22927564f, 0.07430658f, 
    -0.11803816f, -0.09955156f, -0.13887656f, 0.00188748f, 0.16821231f, 0.02311905f, 0.01345369f, 0.19313808f, 
    0.02838440f, -0.14782956f, -0.26874867f, 0.19668268f, 0.08736356f, -0.12277348f, 0.13477291f, 0.13864058f, 
    0.19648278f, -0.02764504f, 0.21450150f, 0.04278314f, 0.19713821f, -0.08561720f, -0.07410929f, 0.10385679f, 
    -0.26310757f, 0.11588375f, -0.29158360f, 0.05172411f, 0.27836189f, -0.17907181f, 0.11884191f, -0.00671012f, 
    -0.21946795f, -0.17231832f, -0.21060169f, -0.11329980f, -0.13405272f, -0.14878803f, 0.11806256f, -0.04637253f, 
    -0.13675097f, 0.01528719f, -0.01476128f, 0.06168912f, -0.00625858f, -0.12629770f, 0.14440069f, 0.06658535f, 
    0.04022146f, -0.03924421f, 0.28921145f, 0.15679085f, 0.17278410f, -0.24983640f, -0.01060288f, 0.15494646f, 
    0.02566991f, 0.07877605f, 0.11852407f, -0.21664320f, -0.09602640f, 0.09825747f, 0.00136703f, -0.02453465f, 
    0.07161746f, -0.00601453f, 0.14195564f, -0.05121300f, -0.00564213f, 0.08572672f, 0.18439713f, 0.10929143f, 
    -0.06731337f, 0.21416871f, 0.08288768f, 0.09032199f, 0.07753275f, -0.17615834f, 0.29522941f, -0.01190175f, 
    0.11614965f, -0.12804814f, -0.10882383f, 0.04467224f, 0.03131221f, 0.18671849f, 0.22817543f, 0.25397694f, 
    0.01763120f, -0.26995549f, -0.06914689f, 0.09776311f, 0.17615475f, 0.03927494f, -0.05302075f, -0.09925263f, 
    0.19858035f, -0.11423723f, -0.21476738f, -0.00439071f, 0.02495115f, -0.16848625f, -0.02349588f, 0.03355848f, 
    -0.08868443f, 0.12184383f, -0.43894911f, -0.19822405f, 0.04654157f, 0.33591387f, 0.24994901f, 0.02618194f, 
    0.02788548f, 0.15598063f, 0.06325294f, 0.14090218f, -0.09962030f, -0.05516739f, 0.09534348f, -0.00939753f, 
    -0.02625036f, -0.00254816f, -0.11587006f, 0.03527770f, 0.27973476f, 0.19909330f, -0.06008304f, -0.09791917f, 
    -0.14025016f, -0.10749563f, 0.23051441f, -0.09810079f, -0.12923636f, 0.09886381f, 0.08683500f, 0.11905633f, 
    -0.02723252f, 0.00606048f, 0.07565483f, -0.00984420f, -0.04523076f, -0.60534346f, -0.15185876f, 0.13915977f, 
    -0.17494705f, -0.06335153f, -0.03213444f, -0.00479911f, -0.10738139f, 0.02548245f, 0.21798809f, 0.20336880f, 
    0.21337228f, -0.29548001f, -0.14710242f, -0.14776877f, -0.07246991f, 0.03116325f, 0.18807890f, -0.12049736f, 
    -0.07614145f, -0.06661332f, -0.02137979f, 0.10639095f, -0.05799038f, 0.09922639f, 0.01641033f, -0.05707341f, 
    -0.21252225f, -0.05080688f, -0.33135280f, 0.09611114f, 0.09410444f, 0.01598562f, 0.15789874f, 0.06003772f, 
    -0.08154424f, 0.08797778f, 0.10083862f, -0.14745983f, 0.07230365f, 0.12276591f, 0.05888667f, -0.02546828f, 
    0.06408044f, 0.06727186f, -0.06366317f, -0.02893746f, 0.33651972f, -0.05214949f, -0.03802877f, -0.06362326f, 
    0.02818232f, -0.06355305f, 0.10854138f, 0.19247425f, 0.02518972f, -0.01617273f, -0.07526036f, -0.05210212f, 
    0.09179286f, 0.14489189f, -0.02926294f, -0.14700171f, 0.21184538f, 0.11528321f, -0.03369350f, -0.05685214f, 
    0.11597566f, 0.02727962f, 0.03479244f, 0.15382458f, -0.08199705f, -0.45564595f, 0.14510041f, 0.21849638f, 
    -0.14147691f, 0.02161662f, -0.01364911f, 0.07165536f, 0.18603972f, -0.03852281f, -0.15310338f, 0.14955628f, 
    -0.01467466f, -0.05425512f, 0.00851730f, 0.03105534f, 0.01032178f, -0.06155216f, 0.20487203f, -0.02009388f, 
    -0.40934536f, -0.03871475f, -0.07390759f, -0.01182559f, 0.47186780f, 0.09143644f, -0.01964381f, -0.18477154f, 
    0.19921090f, -0.02285614f, 0.00768350f, 0.07342769f, 0.08198739f, 0.07855842f, -0.08814532f, -0.22023229f, 
    -0.12008037f, -0.05226636f, -0.48363611f, 0.02373221f, 0.07300887f, -0.33518291f, -0.03354983f, -0.26009971f, 
    -0.12388511f, -0.09481452f, 0.24238177f, 0.27200100f, 0.06456082f, -0.06585199f, 0.06677363f, -0.02191198f, 
    -0.06646927f, 0.03834223f, -0.02523603f, 0.13798028f, 0.22651576f, -0.12012423f, 0.28494030f, -0.11636981f, 
    0.07577664f, -0.02665166f, 0.04042652f, -0.23053138f, 0.08810888f, 0.14650942f, 0.02526380f, 0.04772498f, 
    -0.01296980f, 0.36260813f, -0.03006115f, 0.00729269f, -0.16375791f, 0.10913695f, -0.12007835f, -0.38233396f, 
    0.09168221f, -0.01206029f, 0.03906883f, 0.06459687f, 0.08318899f, 0.06226018f, 0.34313732f, 0.27967462f, 
    0.31043339f, 0.29586208f, 0.05009301f, -0.31904241f, -0.12228631f, -0.04713836f, 0.03509920f, 0.25082156f, 
    -0.51068968f, 0.04758182f, -0.04166343f, -0.19757606f, -0.13918281f, -0.25909609f, -0.12011138f, 0.03079780f, 
    0.04212378f, 0.11804810f, -0.06343943f, 0.03140430f, -0.21453814f, 0.12591974f, 0.01113966f, -0.02317894f, 
    0.09144878f, 0.23976782f, -0.21564801f, -0.12120755f, 0.18917492f, 0.07912478f, 0.13294613f, 0.02915681f, 
    0.06677084f, 0.03402606f, 0.38452911f, 0.19395711f, 0.07264058f, 0.39553526f, 0.05165322f, -0.18947472f, 
    -0.13600989f, 0.06373208f, -0.14621466f, -0.14507344f, -0.07341446f, -0.05327365f, -0.20607269f, 0.02746131f, 
    0.13442178f, 0.09607352f, 0.02998664f, 0.00308882f, 0.34229991f, 0.13257958f, -0.04212556f, 0.05056851f, 
    0.03744546f, 0.15215093f, -0.08266830f, -0.10449027f, -0.00457434f, -0.03160661f, 0.08403984f, -0.06095614f, 
    -0.00398743f, 0.12450488f, 0.00547725f, 0.08467769f, -0.17657992f, -0.10570672f, -0.35407111f, -0.12576362f, 
    -0.44881698f, 0.05109441f, -0.21826030f, -0.31836978f, 0.08516417f, 0.16368578f, -0.01244552f, -0.02970937f, 
    0.10249868f, 0.12386234f, -0.01519160f, -0.01947482f, 0.11923576f, -0.17424327f, -0.07404188f, 0.12138767f, 
    -0.09412958f, -0.38366890f, -0.50060612f, 0.13611284f, 0.01346804f, 0.04143036f, 0.05400708f, 0.20538479f, 
    0.09165826f, 0.13820882f, 0.00832432f, -0.32736152f, -0.06305248f, -0.11136517f, -0.04510763f, -0.11952356f, 
    0.02316192f, -0.07712455f, 0.05583240f, -0.20119670f, 0.00199135f, -0.00842053f, 0.00511362f, 0.01191786f, 
    -0.02027971f, -0.00271531f, -0.01603344f, 0.04091084f, 0.01037936f, -0.02075399f, 0.15619271f, 0.10785558f, 
    0.17524958f, 0.07956471f, 0.06608151f, 0.15181753f, 0.03909488f, -0.04983737f, -0.01974251f, -0.04904735f, 
    -0.11264457f, 0.12412298f, -0.12803265f, -0.32837376f, -0.16698705f, 0.44912475f, 0.47414142f, 0.15542692f, 
    0.25628704f, 0.03514604f, -0.21881536f, 0.04658803f, 0.01399121f, 0.01535110f, -0.15803340f, 0.15782844f, 
    0.37340805f, 0.07461520f, 0.02878238f, -0.14727634f, -0.07018354f, 0.11013932f, 0.19741341f, 0.06001058f, 
    -0.08314504f, -0.10002852f, 0.10637043f, 0.13301310f, 0.08618414f, 0.00979176f, -0.08691409f, -0.00312940f, 
    0.06297307f, 0.01444734f, 0.16166663f, 0.08467399f, -0.14412357f, 0.11866082f, -0.05313120f, 0.02080924f, 
    -0.00357192f, 0.02985328f, -0.14862342f, 0.02280797f, 0.04447523f, -0.13319629f, 0.15328507f, -0.12367561f, 
    0.02178317f, -0.06224137f, -0.11081448f, 0.10685524f, 0.03903233f, -0.40420273f, -0.03192658f, -0.30720893f, 
    -0.08731576f, -0.02096069f, 0.04918141f, 0.03724826f, -0.15116329f, 0.09416468f, 0.12741631f, -0.14717893f, 
    0.24068566f, 0.23537521f, 0.19973551f, 0.06832066f, 0.10662905f, -0.01856425f, -0.02599071f, 0.11578958f, 
    -0.04168769f, 0.09005516f, 0.09055683f, 0.10836313f, 0.11326464f, -0.25962389f, -0.14867119f, -0.10471666f, 
    -0.43300858f, -0.43768221f, 0.00654016f, 0.14623964f, -0.13711306f, -0.08520553f, 0.22301456f, 0.27056625f, 
    0.06795330f, 0.00515412f, 0.02200213f, 0.03578199f, -0.05021286f, -0.24810714f, 0.12094890f, 0.07063165f, 
    0.06374227f, -0.15777048f, -0.04058093f, -0.25523335f, -0.01261092f, 0.03329497f, -0.17821433f, 0.01276461f, 
    -0.23015982f, -0.09244574f, -0.12939592f, -0.03415052f, -0.17533123f, 0.00362042f, 0.04793858f, 0.17846482f, 
    0.22709952f, -0.09645147f, 0.15311977f, -0.11216747f, -0.07908226f, 0.07898442f, -0.16059542f, 0.37053189f, 
    0.09593064f, 0.11197075f, 0.11982670f, -0.20232719f, 0.01123903f, 0.06332295f, 0.15461028f, -0.03805461f, 
    0.04159174f, 0.01144877f, 0.10915184f, 0.28363323f, 0.11283434f, 0.05978642f, -0.02644227f, 0.10149268f, 
    0.04149925f, 0.09254758f, 0.01075017f, -0.23604375f, 0.21823823f, 0.28131428f, 0.06288423f, -0.08899408f, 
    -0.02472170f, 0.04562007f, 0.08044109f, -0.14145583f, -0.00036361f, -0.25569668f, -0.15442510f, 0.13153842f, 
    -0.07824140f, 0.08482429f, 0.02220898f, -0.13167183f, -0.26495716f, 0.17066985f, 0.26200405f, -0.13932453f, 
    0.13277850f, 0.04765256f, 0.04366438f, -0.04598175f, 0.11110900f, 0.10715574f, -0.25793496f, -0.12573221f, 
    0.13864130f, -0.11506019f, 0.02598631f, 0.00653689f, -0.13858740f, 0.10680790f, 0.20755057f, -0.06971154f, 
    -0.01182911f, -0.04321708f, 0.09997937f, -0.03048013f, -0.19576009f, -0.05115752f, -0.01838575f, 0.04093654f, 
    -0.23971948f, 0.22146808f, 0.06831641f, 0.08929151f, 0.27334443f, 0.12271915f, -0.31098378f, -0.04242631f, 
    0.04863720f, -0.15560068f, 0.42798159f, 0.06833087f, 0.08101738f, 0.09383250f, -0.01431907f, 0.01188236f, 
    0.03705376f, 0.13091293f, -0.03722332f, -0.17039350f, -0.18010631f, 0.18095399f, -0.08433377f, 0.06632585f, 
    0.10332421f, 0.08561250f, -0.11818101f, 0.05089140f, -0.03660931f, -0.11450335f, 0.07783913f, 0.30436480f, 
    0.11093728f, -0.26641938f, 0.02094599f, -0.09035826f, -0.13515829f, -0.19955742f, -0.38049382f, 0.04905109f, 
    -0.11444757f, 0.03635469f, -0.03721034f, 0.15087083f, -0.16723816f, 0.22247979f, -0.20749409f, -0.06682673f, 
    0.06297848f, -0.00184977f, -0.02695314f, 0.14004605f, -0.25729373f, -0.15386426f, 0.04650152f, 0.12582628f, 
    0.06854067f, 0.07296153f, 0.03336511f, -0.02560496f, -0.01241329f, 0.10081925f, 0.14197983f, 0.10316428f, 
    0.14569901f, 0.09989403f, 0.23601122f, 0.16632371f, -0.12554665f, -0.18401150f, 0.03208927f, -0.00605194f, 
    0.00007032f, 0.38080096f, 0.16339286f, 0.34532329f, -0.00541127f, 0.02268145f, -0.32421172f, -0.04043254f, 
    -0.03929930f, 0.00321032f, -0.16040576f, -0.13618064f, -0.02173695f, -0.01380640f, 0.09521336f, 0.02011066f, 
    0.00682938f, -0.00460306f, -0.09113051f, -0.28426966f, -0.09862253f, 0.05368123f, -0.05145257f, 0.11610686f, 
    -0.03605627f, 0.16543156f, -0.14987992f, -0.13400283f, 0.06210006f, 0.09200431f, -0.04236134f, -0.05190657f, 
    0.11640681f, -0.18617709f, -0.03522829f, 0.03741752f, 0.03523601f, 0.19948603f, -0.16656107f, 0.14391941f, 
    0.03040034f, 0.10958531f, 0.08601210f, 0.16143158f, 0.05994555f, 0.01126225f, -0.24154092f, -0.23234580f, 
    -0.07595193f, 0.01533021f, 0.08988553f, 0.00713840f, -0.19592281f, -0.26732132f, -0.07781394f, 0.06932708f, 
    0.10524198f, 0.09387943f, 0.12563072f, -0.06206225f, 0.02759997f, 0.01939331f, 0.17122242f, 0.13840339f, 
    -0.13640496f, -0.11317492f, 0.33608603f, -0.03451351f, 0.16569400f, 0.00461281f, 0.06407396f, 0.07767784f, 
    0.33872107f, -0.34486291f, -0.08341347f, -0.08710226f, -0.03199986f, 0.05979656f, 0.00384319f, -0.00198009f, 
    0.21049801f, 0.16984609f, 0.23229852f, -0.06459112f, 0.02125091f, 0.03055701f, 0.04948327f, 0.02980326f, 
    -0.09257746f, -0.14349696f, -0.21334733f, -0.43656340f, -0.03441091f, 0.02158249f, -0.02582493f, 0.17424342f, 
    0.03432541f, -0.04909941f, 0.07260810f, 0.21143386f, -0.46599838f, -0.18258740f, -0.10487397f, -0.02381033f, 
    -0.08970785f, 0.05003994f, -0.13435864f, 0.14786197f, 0.04862541f, 0.12780261f, 0.25875938f, 0.28043732f, 
    -0.07309094f, 0.17069581f, 0.09486950f, -0.13659172f, 0.06690346f, -0.09173366f, -0.17443071f, -0.11550676f, 
    0.12103269f, 0.33772728f, -0.07074460f, -0.40913856f, -0.12357493f, -0.33858910f, -0.04884785f, 0.56871736f, 
    0.16834804f, 0.06625353f, -0.03116881f, -0.03913100f, 0.03442878f, 0.17547590f, 0.09689791f, 0.03721691f, 
    0.08018547f, -0.02138485f, -0.15509738f, 0.17954594f, -0.19598067f, 0.12823264f, 0.10767595f, 0.10280549f, 
    0.12187304f, 0.20909101f, -0.07537992f, -0.10039528f, 0.22944818f, 0.21646303f, 0.04667486f, 0.10066656f, 
    0.09473172f, 0.18842210f, -0.38331062f, -0.41292283f, -0.15282592f, -0.30453801f, 0.14561798f, 0.00427859f, 
    0.08979500f, 0.15221174f, 0.20319650f, 0.02409860f, -0.25365686f, 0.31511933f, -0.07507128f, 0.08105601f, 
    -0.07450555f, 0.10734750f, 0.19435140f, 0.08188486f, -0.44789425f, 0.03093804f, 0.66706181f, 0.05525254f, 
    -0.19861418f, 0.08209774f, 0.06258725f, 0.17208301f, 0.06394210f, -0.06445869f, -0.10591061f, 0.09084472f, 
    -0.04025759f, -0.17604540f, -0.17540237f, 0.01234173f, 0.13516395f, 0.04183816f, -0.22794467f, -0.18820006f, 
    -0.01232410f, -0.03327196f, -0.00022657f, -0.05527430f, 0.13465337f, 0.08799125f, 0.16151544f, 0.35373306f, 
    0.19380213f, 0.04593891f, 0.04377864f, 0.17160885f, 0.00041073f, 0.15326598f, -0.08211862f, 0.16689517f, 
    0.25752044f, -0.11753599f, 0.04544453f, -0.07049530f, 0.13231763f, -0.05878672f, -0.19277270f, -0.07019337f, 
    -0.16738446f, -0.28647476f, -0.53427786f, -0.21562713f, -0.02716753f, -0.01389169f, 0.01339864f, -0.10795845f, 
    -0.11488658f, 0.15656520f, -0.35717830f, -0.16007608f, 0.28061208f, -0.03884961f, 0.10518830f, -0.10450121f, 
    -0.01155407f, 0.08614863f, 0.04981342f, 0.11509307f, 0.16090265f, -0.04722971f, -0.09079493f, 0.18282583f, 
    0.06825633f, -0.02312878f, 0.15649126f, 0.02055909f, 0.12557854f, 0.06015022f, -0.08404604f, -0.03607554f, 
    -0.12208701f, 0.01772657f, 0.02602703f, -0.04577458f, -0.05884735f, 0.01934106f, 0.00632857f, -0.09412136f, 
    0.06984159f, 0.24262109f, 0.02880918f, 0.12735333f, 0.23547536f, 0.15448825f, 0.16309735f, -0.12248511f, 
    -0.08566648f, 0.02333278f, 0.02034020f, -0.12696788f, 0.16147952f, 0.12712485f, 0.13444805f, 0.26529363f, 
    -0.08374460f, -0.35345891f, -0.04321418f, -0.03057891f, 0.11667170f, -0.01972441f, 0.22808410f, 0.22426817f, 
    0.13502572f, -0.19380781f, -0.32071626f, 0.00089713f, -0.14340441f, 0.02613656f, 0.01389537f, -0.15688194f, 
    0.04562930f, -0.24084604f, 0.00205365f, 0.00676089f, 0.00257174f, -0.11808213f, -0.03950065f, -0.07740447f, 
    -0.07085976f, -0.02533246f, -0.07433005f, 0.01879668f, 0.07616097f, -0.07393640f, -0.00551030f, -0.07331309f, 
    -0.04915678f, 0.02369151f, -0.14192940f, -0.29645357f, -0.09712607f, 0.14222109f, -0.14265724f, -0.15656739f, 
    -0.16936480f, 0.02807586f, 0.04446002f, 0.04281653f, -0.09205978f, -0.35881162f, -0.05518507f, 0.18835673f, 
    0.15693170f, 0.07865220f, 0.26205322f, 0.15927587f, 0.23570988f, -0.31607258f, -0.49985334f, -0.01743480f, 
    0.00477140f, 0.10530749f, -0.34412536f, -0.01747911f, 0.16340113f, 0.20643179f, -0.06663471f, -0.34540102f, 
    0.09407750f, 0.04852052f, -0.11726770f, -0.02180086f, 0.00348223f, 0.03353391f, -0.12420454f, 0.00952003f, 
    -0.32358858f, -0.21346244f, -0.01871503f, -0.05406188f, -0.11622539f, 0.19905734f, 0.14300773f, 0.12530172f, 
    -0.17481762f, -0.24989966f, 0.06744695f, 0.01660998f, 0.01385106f, -0.05274419f, 0.10792101f, 0.13377710f, 
    0.12215258f, -0.09707393f, -0.12519878f, -0.13168420f, 0.03808028f, -0.10696805f, -0.03998071f, 0.16329500f, 
    0.18586431f, 0.16416320f, -0.03887140f, -0.06459445f, 0.75419575f, -0.13721599f, 0.23412837f, -0.13705590f, 
    0.15756084f, -0.01527877f, 0.00739566f, -0.61532444f, -0.18554711f, 0.33416235f, 0.06447530f, -0.11532068f, 
    -0.10852119f, 0.16862635f, 0.30055985f, 0.06593772f, -0.15614620f, -0.11970202f, 0.03640702f, -0.03705977f, 
    -0.20272146f, -0.14754809f, 0.12025121f, 0.17904657f, 0.07070140f, 0.06642495f, -0.05718981f, 0.55482227f, 
    -0.02427111f, 0.28329012f, -0.45713106f, 0.12016802f, 0.04413005f, 0.05341534f, -0.08852620f, -0.01859084f, 
    -0.06377487f, 0.01440034f, -0.08081034f, 0.08420501f, 0.02653064f, -0.06582511f, -0.27260366f, 0.05385644f, 
    -0.10190953f, -0.01788354f, 0.09993052f, -0.00593213f, 0.52929640f, -0.00748445f, 0.09697633f, 0.23852912f, 
    0.10514565f, 0.21046765f, 0.04089684f, -0.22024828f, -0.14106247f, -0.06944861f, -0.02247844f, -0.00948740f, 
    0.01456905f, -0.01905721f, 0.02310251f, -0.48585016f, -0.03346317f, 0.11727817f, -0.07768079f, -0.29822707f, 
    0.04134312f, -0.18546049f, -0.25412408f, -0.05886518f, 0.51287299f, 0.21921510f, 0.06810422f, 0.10087231f, 
    -0.03244882f, -0.05398188f, 0.12296426f, -0.68771917f, -0.38648897f, -0.11884067f, -0.09593713f, 0.07617506f, 
    -0.02468835f, -0.13486603f, -0.04334223f, -0.15675065f, 0.98986310f, 0.07967462f, -0.13868442f, -0.10445371f, 
    -0.18324992f, -0.09310230f, -0.01485253f, 0.03116579f, -0.15274405f, -0.05831397f, 0.04829518f, 0.01429454f, 
    0.11777385f, -0.00677458f, 0.16702558f, -0.18235822f, 0.03305846f, 0.00627917f, -0.84358811f, -0.54532063f, 
    0.40598932f, -0.04023481f, -0.02414320f, -0.10637543f, -0.08746191f, -0.09939605f, -0.08345413f, 0.37102485f, 
    0.21838567f, -0.50706136f, 0.12674861f, 0.15907419f, -0.08369612f, -0.04813705f, 0.19066091f, -0.12928168f, 
    0.27737457f, 0.19666034f, 0.10463209f, 0.14061287f, -0.06555979f, -0.14583096f, 0.08443493f, -0.08852329f, 
    0.02030317f, 0.31993118f, -0.10873213f, -0.25602725f, -0.10786904f, -0.16563363f, -0.08788443f, 0.08206598f, 
    0.06148601f, -0.02024560f, 0.49456900f, -0.28701138f, 0.30876014f, -0.13340759f, -0.03625631f, -0.19910116f, 
    0.17786793f, 0.15374734f, -0.16668810f, 0.09674910f, 0.16485351f, -0.00144128f, 0.07870422f, 0.00690431f, 
    0.04142746f, -0.01449404f, -0.03654214f, 0.02456567f, 0.21235529f, 0.15858167f, 0.10033236f, -0.47873434f, 
    -0.18494216f, -0.40500185f, -0.06005770f, -0.19675738f, -0.08535324f, -0.17512764f, 0.11828578f, 0.21745928f, 
    0.08267192f, -0.14309058f, -0.01826377f, -0.02056230f, 0.03868009f, 0.05997152f, -0.09382244f, -0.05575518f, 
    -0.07380117f, 0.10270038f, 0.09841518f, -0.02899575f, -0.20965789f, 0.12951274f, 0.25915930f, 0.66987920f, 
    0.24824221f, -0.10561008f, -0.12729295f, -0.07546704f, 0.05779234f, 0.06561226f, 0.06240924f, 0.09664264f, 
    0.39895821f, 0.10012836f, -0.25018752f, -0.50570744f, 0.03222360f, -0.26908121f, 0.09524609f, -0.07486203f, 
    0.03711233f, 0.83837509f, -0.05764439f, 0.61992401f, -0.07464371f, 0.02969891f, -0.17431383f, -0.06963333f, 
    -0.15339677f, 0.12464916f, 0.06285664f, 0.05167138f, 0.09800542f, -0.09126126f, 0.02469034f, -0.04228988f, 
    -0.07077058f, -0.04053148f, -0.05298337f, -0.07382819f, 0.08090843f, 0.12580752f, 0.15260167f, 0.01792178f, 
    0.16606653f, -0.14067650f, 0.01211705f, 0.02774595f, 0.03151996f, -0.12122411f, -0.19705066f, 0.14346555f, 
    0.26143515f, -0.10584812f, -0.07356157f, -0.01838206f, -0.21760675f, -0.23898098f, -0.15154164f, 0.37348312f, 
    0.02605114f, -0.04769298f, 0.05563445f, -0.06689109f, -0.02496387f, 0.04637838f, -0.24572174f, -0.01724331f, 
    -0.05236729f, -0.00684353f, 0.13559154f, 0.03517790f, 0.11813748f, -0.01064947f, 0.00771494f, 0.38126218f, 
    0.07474048f, -0.15409178f, -0.33406469f, -0.11846109f, 0.02394359f, 0.07612256f, 0.07312587f, -0.03615253f, 
    -0.56794941f, -0.25330311f, -0.09579750f, 0.14516871f, 0.02498996f, 0.00162590f, 0.04094171f, -0.14052826f, 
    0.29533431f, -0.01251855f, 0.05430957f, 0.01079755f, 0.01404208f, -0.01909994f, -0.00415596f, 0.03792981f, 
    0.06712350f, -0.03656596f, 0.06810846f, -0.50746387f, 0.23365483f, 0.00389849f, 0.07151397f, -0.01581090f, 
    0.07117149f, 0.02490005f, 0.03859526f, -0.30065739f, -0.00904802f, 0.25356722f, 0.05555718f, 0.10867640f, 
    0.05617458f, 0.03978836f, 0.24036512f, 0.08519422f, -0.04412606f, -0.01750027f, 0.08337675f, 0.04896412f, 
    0.05349293f, 0.11358453f, -0.03687635f, 0.11746112f, 0.01354505f, -0.06203951f, -0.28577855f, 0.05481089f, 
    0.04346904f, 0.06620507f, 0.01694386f, -0.08361419f, -0.05435047f, 0.04936575f, 0.10085494f, 0.18174450f, 
    0.11330834f, -0.54790008f, -0.19515608f, -0.24253727f, -0.09335269f, -0.19151023f, -0.05252765f, 1.11789632f, 
    -0.34753862f, -0.11610889f, -0.00427617f, 0.06240262f, -0.12933658f, -0.00969019f, -0.07091372f, 0.02008281f, 
    0.03383350f, 0.02858301f, -0.05606375f, 0.04084643f, -0.01398926f, 0.04791006f, -0.03111668f, -0.03326385f, 
    -0.05426294f, -0.05850851f, 0.03406562f, -0.04083133f, 0.02377306f, 0.01175378f, -0.04943776f, 0.04849032f, 
    -0.05668048f, -0.05313195f, -0.04197516f, 0.00715905f, -0.02501548f, 0.01974003f, -0.00803401f, -0.01438199f, 
    -0.01640607f, 0.05002300f, 0.04340741f, -0.05586179f, -0.00378094f, -0.01755342f, -0.04131194f, 0.05392750f, 
    -0.03224034f, -0.06314581f, -0.00666686f, 0.05153959f, 0.04139753f, -0.04569741f, 0.01622399f, 0.04342590f, 
    -0.03299512f, -0.04741253f, -0.02767078f, -0.06394009f, -0.04672177f, 0.03849166f, -0.03353060f, -0.05971887f, 
    -0.01601459f, -0.04037536f, -0.00398411f, -0.03812042f, -0.06072028f, -0.03268334f, 0.03301555f, 0.05166699f, 
    0.04787971f, -0.02359509f, -0.02063935f, 0.03731879f, -0.03825614f, 0.01193951f, 0.02902918f, -0.01021892f, 
    0.02674675f, -0.05568997f, -0.03076343f, 0.03182048f, 0.04010658f, -0.04373369f, -0.05233376f, 0.04441344f, 
    0.03844399f, -0.02827645f, -0.06139190f, 0.01347505f, -0.03672274f, 0.03582162f, 0.01764472f, 0.00570682f, 
    0.00141567f, 0.00365160f, -0.02842419f, -0.04924807f, 0.04897774f, -0.03888572f, -0.06380282f, -0.05238472f, 
    -0.01828276f, 0.00550588f, 0.03122420f, -0.03594409f, -0.02161889f, 0.01672504f, 0.01029956f, -0.02275923f, 
    -0.04885970f, 0.02395440f, -0.05307250f, -0.04032368f, 0.00618188f, -0.01560931f, 0.02644865f, 0.03101142f, 
    -0.02808313f, 0.00447404f, -0.03338131f, -0.06271563f, 0.04608674f, 0.02145633f, 0.04197282f, -0.01145337f, 
    -0.03523278f, 0.00808079f, 0.04198548f, 0.02018770f, 0.01431157f, -0.03282878f, 0.05164403f, -0.01948249f, 
    -0.02735257f, 0.00648619f, -0.01993780f, -0.03027424f, -0.02403442f, -0.00781234f, -0.02329810f, 0.02962346f, 
    0.00771062f, -0.02954371f, 0.04183590f, 0.04602359f, 0.02892036f, -0.05516553f, 0.03118144f, -0.05078730f, 
    -0.03386261f, -0.05201147f, 0.05411325f, -0.05737297f, -0.03089560f, -0.01807894f, -0.02149992f, 0.01870783f, 
    0.05363467f, 0.00957612f, -0.06311141f, -0.01682885f, -0.03770704f, -0.05125213f, -0.02940891f, 0.00538615f, 
    -0.06234628f, 0.04525680f, 0.04300782f, -0.04165535f, -0.02256136f, -0.05830690f, -0.03447518f, -0.04006057f, 
    -0.01426168f, -0.01693323f, 0.03559465f, -0.05464366f, -0.04659292f, -0.02388966f, 0.02118163f, 0.01379043f, 
    0.00019780f, -0.02107061f, -0.04373555f, 0.04587628f, 0.03972519f, 0.04339307f, 0.03520921f, -0.01484864f, 
    0.00597649f, -0.01087337f, 0.02552447f, -0.04876630f, 0.04210733f, 0.03071406f, 0.04339543f, 0.00885722f, 
    -0.03810472f, -0.05919936f, -0.02271864f, 0.00361938f, 0.03504437f, 0.02308210f, 0.03730944f, -0.01809472f, 
    -0.06112074f, -0.02098036f, -0.04218850f, -0.06136979f, 0.02360842f, -0.01095598f, 0.03786410f, 0.00161063f, 
    -0.05384584f, -0.03512517f, 0.03133733f, -0.04620223f, -0.05648468f, -0.00284978f, -0.02978210f, -0.04648317f, 
    0.01413561f, -0.03758152f, 0.03364735f, -0.04475680f, -0.05958177f, -0.04079914f, -0.06492636f, 0.00650422f, 
    -0.05145664f, -0.00883274f, -0.03925546f, 0.01400389f, -0.04360753f, 0.04479270f, -0.02497477f, -0.02288883f, 
    -0.00568734f, -0.01767736f, 0.04906918f, 0.02837007f, 0.04836508f, -0.04938248f, 0.02660706f, -0.04421939f, 
    -0.00789938f, -0.06214535f, 0.04580843f, -0.06060863f, -0.04321786f, -0.06341598f, 0.04445649f, -0.03879956f, 
    0.02091871f, -0.00161237f, -0.04486973f, 0.04852808f, 0.00471947f, -0.00775737f, -0.02812747f, -0.04915190f, 
    -0.06434580f, -0.04571114f, -0.02755783f, 0.02990143f, -0.01084894f, 0.00804415f, -0.01890206f, -0.00118717f, 
    -0.06129011f, 0.00024792f, -0.00819742f, 0.04464678f, -0.06112785f, 0.04126310f, -0.04383003f, 0.02668256f, 
    0.04444202f, -0.02366790f, 0.04918142f, -0.05062459f, -0.01358649f, -0.02262516f, -0.06067513f, 0.01274996f, 
    -0.01062523f, 0.03664342f, -0.04760960f, 0.01269553f, 0.02524545f, -0.00720597f, 0.01049100f, 0.04790220f, 
    -0.00663219f, 0.01956137f, 0.04970403f, 0.03118998f, -0.03276371f, 0.04582473f, 0.01541551f, -0.00922938f, 
    0.04956239f, -0.09725692f, 0.00261869f, 0.08707353f, -0.06158715f, 0.21415618f, -0.03167044f, 0.06412195f, 
    0.01086481f, -0.14641640f, -0.03807091f, 0.01848854f, -0.03839703f, -0.05612622f, -0.02502372f, 0.01418345f, 
    0.01500198f, -0.08896549f, -0.16779701f, -0.34879273f, -0.18955870f, -0.04871931f, -0.02926097f, -0.18138678f, 
    0.19515735f, 0.16131757f, 0.12765552f, 0.07265802f, 0.09448468f, 0.06244296f, 0.03037935f, -0.04351201f, 
    -0.04680835f, 0.07641985f, -0.03988725f, 0.14739786f, -0.08818383f, 0.34773168f, 0.32507539f, -0.03142381f, 
    -0.11249248f, 0.00211391f, -0.02783973f, 0.07255615f, 0.35408357f, 0.12034609f, 0.12008168f, 0.09337874f, 
    0.01656807f, 0.01907994f, 0.12844221f, -0.06583541f, 0.12382864f, -0.17403676f, -0.00677454f, 0.18796915f, 
    0.00702426f, 0.10096927f, 0.02235318f, 0.16552135f, 0.09534881f, 0.02540479f, -0.09171122f, -0.06192267f, 
    -0.12247731f, -0.16267414f, -0.11200163f, -0.11660761f, -0.01926983f, -0.23879901f, -0.10001450f, -0.22958991f, 
    0.22933400f, -0.05888055f, 0.03533120f, -0.11673626f, -0.03231129f, -0.20997280f, -0.20369010f, -0.02061636f, 
    -0.11351039f, 0.25022489f, 0.12339292f, 0.06303432f, 0.34500217f, 0.03441266f, -0.20920286f, -0.02754502f, 
    -0.10833476f, 0.01498174f, -0.26457122f, 0.09625833f, -0.11610962f, -0.07421106f, -0.08365399f, -0.01918912f, 
    -0.01592078f, -0.01254138f, -0.14711122f, -0.01704831f, 0.07183328f, 0.15343447f, 0.09766357f, -0.03713325f, 
    -0.09164722f, -0.08918643f, 0.05508771f, -0.06850354f, 0.02466797f, 0.04680775f, 0.00093635f, 0.33698484f, 
    0.11945698f, 0.15563579f, -0.15881214f, -0.01013530f, -0.14146949f, -0.10161808f, 0.01202553f, -0.08032379f, 
    0.00383892f, 0.14589961f, -0.05777625f, 0.05819472f, 0.11532998f, 0.10132550f, -0.05140646f, 0.20663695f, 
    -0.03819462f, 0.05584548f, -0.06024320f, -0.12054539f, -0.23701507f, -0.07294464f, -0.07396893f, 0.12951711f, 
    0.21243998f, 0.13937482f, 0.02919983f, 0.08693907f, -0.01276033f, 0.18972015f, 0.27514976f, 0.17209102f, 
    0.15454800f, 0.18931003f, 0.13426562f, 0.30602539f, -0.06869564f, -0.20330600f, -0.07744269f, -0.10353774f, 
    -0.09182899f, -0.53766155f, 0.27968368f, 0.01813330f, 0.13779829f, -0.20421387f, -0.16678141f, -0.26007405f, 
    -0.25470209f, -0.25765383f, -0.00168317f, -0.14514440f, -0.00722223f, -0.08919442f, -0.11248796f, 0.10655788f, 
    -0.08347863f, -0.05534088f, -0.23722290f, 0.14486800f, 0.06497818f, 0.06431790f, 0.02375754f, 0.00860125f, 
    0.04073183f, 0.05189870f, 0.19754952f, -0.31444287f, 0.07528540f, -0.08639561f, -0.00813832f, -0.13874467f, 
    -0.04982946f, -0.17462483f, 0.16308913f, 0.07562949f, 0.07726838f, 0.18568568f, -0.05529995f, 0.16949442f, 
    0.04077983f, 0.11822537f, 0.10510638f, 0.14579354f, 0.10157323f, 0.07857367f, 0.06360630f, -0.07999790f, 
    -0.04741150f, 0.04754405f, -0.00825022f, 0.06313016f, -0.22568071f, -0.06285593f, -0.33853441f, 0.13412167f, 
    0.12380558f, 0.17325841f, 0.12424943f, 0.00182582f, -0.12421024f, 0.01255970f, 0.05577155f, 0.17293029f, 
    -0.07502818f, -0.09167807f, 0.22599585f, -0.01549682f, 0.07612333f, -0.08508527f, 0.15495284f, 0.03669837f, 
    0.10007788f, -0.00427623f, -0.06702361f, 0.03748956f, 0.02241275f, 0.04366527f, 0.02228841f, 0.05254409f, 
    0.16379711f, 0.17865981f, 0.05793397f, 0.09572221f, -0.18041460f, 0.04013586f, -0.07567985f, -0.04476330f, 
    -0.13604920f, -0.34809303f, -0.39404902f, 0.06917568f, -0.04307766f, 0.31300706f, 0.09291956f, 0.05115970f, 
    0.03711021f, 0.12997255f, 0.16911389f, 0.02533162f, -0.05416843f, 0.00665043f, 0.11150762f, 0.07120307f, 
    0.02577736f, 0.01761820f, 0.02720402f, 0.06901618f, 0.09601314f, 0.22790073f, 0.33303666f, 0.02647637f, 
    0.10705226f, -0.02710597f, 0.06661272f, -0.02234792f, -0.30594552f, -0.04408850f, 0.05051300f, 0.02129593f, 
    -0.02121726f, 0.27314544f, 0.00991768f, 0.09864274f, -0.27015996f, -0.10638860f, -0.29928511f, 0.16539416f, 
    0.56191260f, 0.55273098f, -0.05572852f, -0.09351097f, 0.04112591f, 0.02941780f, 0.28142390f, 0.17339221f, 
    -0.04170341f, -0.15761594f, 0.11437777f, 0.15546906f, -0.09921494f, -0.05500012f, 0.05318529f, 0.03212327f, 
    0.10156427f, -0.03864655f, 0.15002224f, 0.44928050f, -0.21324992f, -0.01644493f, 0.12174281f, 0.09774294f, 
    -0.07905047f, 0.21397991f, -0.07232443f, -0.10709718f, -0.27656406f, 0.07213882f, -0.09546898f, -0.00568798f, 
    0.14345579f, 0.07903601f, 0.02718240f, -0.00610564f, 0.25858721f, -0.05263200f, 0.12505071f, -0.00801321f, 
    0.09062525f, 0.04020239f, -0.13268326f, -0.06356641f, -0.31463996f, 0.26112273f, 0.12117393f, -0.07709161f, 
    -0.09442718f, -0.00591815f, -0.08808934f, 0.07874430f, -0.00708192f, 0.23729247f, -0.13652229f, -0.05880848f, 
    -0.04756891f, 0.19647703f, 0.11907463f, -0.20157151f, -0.08320379f, 0.15824147f, -0.17009792f, 0.20607565f, 
    -0.07743075f, 0.02896636f, 0.08722969f, 0.10599194f, 0.20549594f, 0.20307167f, -0.22612250f, -0.22246484f, 
    0.02661379f, 0.32812342f, -0.16417684f, 0.01467693f, 0.08105310f, -0.18875192f, -0.07885858f, 0.11299539f, 
    -0.45084947f, -0.43011382f, 0.30944046f, 0.28631136f, -0.08457785f, 0.15821540f, 0.06543974f, -0.02447704f, 
    -0.15688005f, -0.08904776f, 0.07025040f, -0.12087451f, -0.12272213f, -0.28514415f, 0.02668338f, -0.00876157f, 
    -0.10906709f, -0.12930317f, -0.24547997f, -0.11729059f, -0.00189506f, 0.02487869f, 0.00280832f, 0.16738139f, 
    0.03653293f, -0.09123623f, -0.29395440f, 0.21440059f, -0.29779780f, 0.12189265f, 0.10524262f, 0.23592062f, 
    0.07663287f, -0.09511144f, 0.06292803f, 0.18799885f, -0.12388205f, -0.10113703f, 0.03820970f, 0.28023395f, 
    0.09214433f, -0.09040044f, 0.15765758f, -0.08847871f, -0.07886919f, 0.12229544f, -0.20840003f, -0.08230150f, 
    0.02853395f, 0.16180950f, 0.27224526f, 0.16178596f, 0.15724202f, 0.26120803f, 0.17596839f, 0.06028717f, 
    -0.30999836f, 0.17456160f, -0.00271423f, 0.04280921f, -0.00629159f, -0.13433835f, -0.02422399f, -0.16328071f, 
    -0.17988022f, 0.10817605f, 0.22026922f, 0.02802490f, 0.00506941f, 0.12720947f, -0.04811592f, 0.18721053f, 
    -0.08509634f, 0.19216031f, 0.13262938f, 0.07923415f, 0.02167453f, -0.07282432f, 0.03876870f, 0.01457884f, 
    0.00903396f, -0.36507568f, -0.06804971f, 0.25429860f, -0.11883012f, 0.03775271f, -0.07841659f, 0.08824228f, 
    -0.21642722f, -0.19190453f, -0.18046066f, -0.14532447f, 0.14067052f, 0.16912094f, -0.03068909f, 0.06753203f, 
    -0.16971177f, -0.01768065f, -0.05653732f, 0.00893314f, 0.08614983f, 0.03565330f, -0.03770098f, 0.02724414f, 
    -0.08498459f, 0.17266890f, -0.03401588f, 0.16184655f, 0.03754493f, 0.07014088f, 0.08541152f, -0.01219210f, 
    -0.11864025f, -0.02199981f, 0.06750845f, -0.06504886f, -0.00249486f, -0.31999859f, 0.32632965f, 0.06074459f, 
    -0.01654984f, -0.08606522f, 0.12792476f, 0.04492981f, 0.24397156f, -0.12041276f, 0.47051415f, -0.18656768f, 
    -0.32697481f, 0.00639215f, 0.11183096f, -0.04628150f, -0.15230925f, 0.13786551f, -0.54835290f, -0.01782512f, 
    0.18056299f, -0.02892618f, -0.15231182f, -0.07054427f, -0.02114360f, 0.16523291f, 0.14758569f, 0.04315506f, 
    -0.23837303f, -0.00470734f, 0.14619181f, 0.09469005f, -0.02371231f, 0.02867267f, 0.06067625f, 0.23090099f, 
    0.13522805f, -0.14553855f, 0.04364544f, 0.09741531f, 0.04431499f, -0.10868898f, 0.15544729f, 0.01889104f, 
    0.10394011f, 0.10798485f, 0.14444350f, -0.05978405f, -0.04411804f, 0.04132180f, -0.03672052f, 0.06912650f, 
    0.05924275f, -0.16420664f, -0.24774216f, -0.34771520f, -0.47052044f, -0.07428514f, 0.03584426f, -0.06493904f, 
    -0.06926038f, -0.00173443f, 0.10221612f, 0.19297609f, -0.17733434f, -0.03400410f, 0.03889654f, 0.07714741f, 
    -0.01228545f, 0.09268393f, 0.06184516f, 0.02168380f, 0.13995010f, -0.08304986f, -0.29635060f, 0.17869051f, 
    0.12395418f, -0.22844951f, -0.09950618f, 0.14522956f, -0.03026077f, -0.03840316f, -0.00456862f, -0.11216284f, 
    0.03317630f, 0.11148781f, -0.21102400f, -0.32993746f, 0.01250941f, -0.18913855f, -0.13666438f, -0.14298506f, 
    0.35571939f, 0.30640841f, 0.19129035f, -0.10992978f, -0.02635146f, 0.01261069f, -0.06535283f, 0.01387986f, 
    -0.08387235f, 0.14457357f, -0.14998212f, 0.05546658f, 0.11579112f, -0.01667287f, -0.01459812f, -0.19461828f, 
    0.07691201f, -0.01183655f, 0.48235175f, -0.02062514f, -0.09151179f, -0.01124838f, -0.03923868f, -0.29059643f, 
    0.13075842f, -0.12125508f, -0.03119299f, 0.01040748f, -0.18995744f, 0.08895990f, -0.19320525f, -0.11201303f, 
    -0.04137269f, -0.05700385f, -0.03934838f, 0.03328667f, 0.00699615f, 0.04304969f, -0.13259213f, -0.02581558f, 
    0.24208404f, -0.03006638f, -0.01543189f, -0.00126617f, 0.15766238f, 0.45129326f, 0.56540298f, -0.30026674f, 
    -0.12452889f, -0.02385221f, 0.11126706f, 0.06065350f, 0.01330564f, -0.20808344f, 0.08717479f, -0.11556032f, 
    0.00429452f, 0.10147896f, -0.00516974f, -0.07255155f, 0.04822350f, 0.07006714f, -0.14836530f, -0.04771968f, 
    -0.18258615f, -0.01506598f, 0.04418185f, 0.15486996f, -0.02565272f, -0.02777371f, -0.14225203f, -0.16588940f, 
    0.38483375f, -0.30983657f, -0.01717039f, 0.03097755f, -0.00180610f, -0.25335631f, 0.11359273f, -0.14737245f, 
    -0.42792317f, 0.22377707f, -0.01529656f, 0.16921775f, 0.28490314f, -0.13330060f, -0.14586626f, 0.30513048f, 
    0.18569307f, -0.04983196f, 0.47392964f, 0.34796411f, -0.22578181f, -0.22156809f, 0.02798462f, 0.12882429f, 
    -0.06471574f, 0.14034057f, 0.07033005f, -0.21301572f, -0.09242734f, 0.00796661f, 0.08620613f, -0.00986698f, 
    0.06120552f, 0.05313496f, 0.02579753f, -0.19404727f, -0.14264299f, -0.12467279f, 0.14350705f, 0.11268370f, 
    0.05486762f, 0.00541991f, -0.09587319f, -0.07152300f, -0.21498972f, -0.24625263f, 0.15318696f, 0.00507696f, 
    0.12357602f, -0.01826617f, -0.14109987f, 0.01468428f, 0.08225421f, -0.23535104f, -0.00674798f, -0.08768465f, 
    0.10636024f, 0.05030115f, 0.02177612f, 0.12022185f, -0.00085408f, 0.04349937f, -0.18626437f, 0.04204150f, 
    -0.25491861f, -0.19057493f, 0.00061651f, 0.07570299f, -0.01292457f, 0.03213127f, 0.04833447f, -0.18196516f, 
    0.27336165f, -0.21687731f, 0.21765456f, 0.51621616f, 0.21284105f, 0.09033313f, -0.48979664f, -0.23879351f, 
    -0.11965200f, 0.11705647f, 0.19427399f, -0.16156060f, -0.12997887f, 0.04696290f, 0.03706261f, 0.10973548f, 
    0.21773964f, -0.21489537f, -0.01821802f, 0.33034003f, -0.08808994f, 0.06632078f, 0.10511801f, 0.10048337f, 
    0.21630520f, -0.05370328f, -0.16894293f, 0.01523956f, -0.04552498f, 0.06234773f, 0.10102737f, -0.07643428f, 
    -0.02203137f, 0.06360824f, -0.06080177f, -0.15570888f, 0.35353920f, 0.03726235f, -0.09442694f, -0.04524354f, 
    -0.01076137f, 0.09827029f, 0.21197636f, 0.00478745f, -0.07734933f, 0.34089670f, 0.13642156f, 0.00280608f, 
    -0.05203862f, -0.00402580f, -0.28744048f, 0.02962717f, 0.10627508f, -0.03951885f, -0.14710331f, -0.19574116f, 
    0.02053377f, -0.25307158f, 0.03282353f, 0.15794858f, -0.03298673f, 0.07775904f, 0.10036141f, -0.22174056f, 
    -0.13584742f, 0.16019189f, 0.02892202f, -0.22548404f, -0.08188217f, -0.04825476f, 0.03498553f, 0.14100736f, 
    0.15734263f, 0.08289257f, -0.04855970f, -0.04492466f, -0.00535847f, 0.03873664f, -0.07048736f, 0.05274432f, 
    -0.31447932f, 0.09921373f, -0.01836035f, 0.14962302f, -0.16937055f, -0.08493444f, -0.03746677f, -0.04216955f, 
    0.00495351f, -0.11760018f, 0.20069352f, -0.11166830f, 0.02008970f, 0.03133423f, 0.01887566f, 0.09511179f, 
    -0.16039833f, -0.07527213f, -0.07288823f, -0.11182467f, 0.04291953f, 0.05030792f, -0.18162411f, -0.26004124f, 
    0.06213808f, 0.16955335f, 0.01894562f, -0.53182513f, 0.31516311f, 0.17259353f, 0.04123684f, -0.07552224f, 
    -0.05185292f, 0.01456793f, 0.00310954f, 0.06732131f, -0.14845242f, -0.01183923f, -0.16479291f, 0.01429080f, 
    0.17510852f, 0.00006384f, 0.14187704f, 0.05354057f, -0.02588619f, -0.17888582f, 0.39222911f, 0.13261364f, 
    -0.00539458f, -0.17978150f, -0.10746543f, -0.02089675f, 0.10477218f, 0.08250435f, -0.28042582f, -0.18467164f, 
    -0.14130564f, 0.07014446f, 0.03355647f, 0.00479363f, -0.11230921f, -0.22143704f, 0.32789326f, -0.27426857f, 
    -0.10190064f, 0.26358637f, 0.06117666f, 0.50421345f, 0.19797900f, 0.07456788f, -0.08216052f, 0.00172130f, 
    0.09346529f, 0.15240714f, -0.03304540f, 0.04274765f, -0.00103468f, 0.14469926f, -0.00800382f, 0.15674624f, 
    0.23209371f, -0.05106784f, 0.21398658f, 0.31875172f, 0.10915536f, 0.20584193f, -0.17532754f, 0.16118078f, 
    0.33907861f, 0.08533262f, -0.04956377f, -0.50645614f, -0.24805662f, 0.16343296f, -0.20229997f, -0.22139378f, 
    -0.07963832f, -0.11820631f, -0.04289233f, 0.05306029f, -0.10707553f, -0.01049410f, 0.12191421f, -0.06412818f, 
    -0.18625966f, 0.12672813f, 0.05246140f, -0.04697605f, -0.28357574f, 0.36911055f, -0.20951642f, -0.06011423f, 
    0.13644454f, 0.11653762f, 0.29724783f, -0.09393312f, -0.14677913f, -0.32703289f, -0.09730802f, 0.13533610f, 
    0.09174099f, -0.15299822f, -0.22781968f, 0.20680018f, 0.00714289f, 0.08613529f, -0.03967443f, 0.07264264f, 
    -0.02736386f, -0.14627782f, -0.10032360f, -0.10871682f, 0.03284242f, 0.04970714f, 0.19879943f, -0.07676391f, 
    0.09464667f, 0.09452541f, 0.02967465f, 0.01811337f, -0.09613289f, 0.13376790f, 0.23857346f, -0.02224324f, 
    0.17038669f, -0.12603711f, 0.55214906f, -0.11707234f, -0.08706205f, 0.26978898f, 0.09003079f, 0.00354295f, 
    -0.00335217f, 0.44428214f, 0.09157766f, -0.06062967f, -0.09111182f, 0.12148400f, -0.00195714f, -0.07484689f, 
    0.13214184f, 0.07176802f, 0.21316859f, 0.26641205f, 0.14399353f, -0.05059635f, 0.03335555f, 0.21443731f, 
    0.03812440f, -0.05735811f, -0.07265928f, -0.33173010f, 0.02609517f, -0.07446855f, 0.08626880f, 0.03337732f, 
    0.24869658f, 0.16213708f, 0.07681783f, -0.02454210f, -0.07590854f, 0.07610034f, 0.04473143f, -0.01751973f, 
    -0.23058008f, -0.54631722f, 0.04562813f, -0.05878818f, -0.08304954f, -0.11436971f, -0.13616282f, -0.26871487f, 
    -0.09107780f, 0.05055269f, 0.22108507f, 0.07435279f, -0.09570361f, -0.13099156f, 0.27402037f, 0.10653042f, 
    0.39684665f, 0.23803453f, -0.16160519f, -0.25088996f, -0.01049577f, -0.04769422f, 0.01736582f, -0.52043420f, 
    -0.41299322f, -0.30792218f, -0.08418752f, 0.01667883f, 0.17653970f, 0.07147528f, 0.02940444f, 0.00526670f, 
    0.02906032f, 0.33667335f, 0.10565996f, 0.02643792f, 0.06893440f, 0.12628697f, 0.13907893f, 0.21204609f, 
    -0.11776733f, 0.11656308f, 0.63337630f, 0.33545658f, 0.18587165f, 0.11706188f, 0.03804032f, 0.12929408f, 
    0.09582484f, -0.08693974f, 0.01818088f, -0.08535223f, 0.04496261f, 0.06134278f, -0.02694421f, 0.03326719f, 
    0.00909175f, -0.05456101f, 0.06927030f, -0.42756209f, 0.06163621f, -0.13418354f, -0.08933686f, -0.13194992f, 
    -0.20298769f, 0.10647512f, 0.03600300f, -0.00184104f, 0.06524616f, -0.27051416f, 0.27015099f, 0.19943060f, 
    0.07827121f, -0.10853261f, 0.02445168f, 0.20833459f, 0.05623029f, -0.44180632f, -0.00920634f, -0.29018703f, 
    0.15818253f, -0.23650569f, -0.20651565f, -0.16084154f, -0.07901320f, 0.09054481f, -0.23882613f, 0.24109697f, 
    -0.20448968f, -0.21603996f, -0.33266062f, -0.02988622f, -0.08778598f, -0.06509136f, 0.13910550f, -0.30073437f, 
    0.01071732f, 0.04466749f, -0.35452703f, -0.01579585f, 0.23108543f, -0.06726264f, 0.18264450f, 0.02285342f, 
    -0.33715892f, -0.33758384f, -0.04943150f, 0.04935189f, -0.24664411f, -0.47221148f, -0.02113177f, 0.03206730f, 
    -0.03101095f, -0.05913401f, -0.02246849f, 0.35513651f, 0.20736258f, 0.08977792f, -0.16565967f, 0.09738176f, 
    -0.01604489f, 0.02389415f, -0.03088617f, 0.11492361f, -0.19876423f, -0.05960100f, -0.12719443f, 0.13057762f, 
    0.25255767f, 0.01201342f, 0.17331670f, -0.67535520f, 0.05597659f, -0.48186839f, -0.25246012f, -0.27182835f, 
    -0.02323591f, -0.16477990f, -0.04003407f, 0.12327933f, -0.22831070f, -0.07179172f, -0.12943602f, 0.10935606f, 
    -0.18313627f, -0.00736101f, -0.02018924f, 0.05026054f, 0.16355141f, -0.24910551f, 0.14088832f, -0.22493409f, 
    -0.30820170f, -0.19901182f, 0.22008789f, 0.12933059f, -0.12425889f, 0.08864382f, -0.31378412f, -0.01766845f, 
    0.21323363f, -0.00104202f, -0.39771315f, -0.24240065f, 0.07019910f, 0.00711467f, -0.08230361f, -0.21232152f, 
    -0.07507674f, -0.25056884f, -0.09534138f, 0.20970152f, 0.34562343f, 0.04602528f, 0.01260181f, 0.04178710f, 
    0.15890856f, 0.03574101f, 0.04747593f, 0.11435098f, -0.22331879f, 0.35812974f, 0.14592350f, -0.02554100f, 
    0.00542277f, 0.07927638f, 0.10668906f, 0.01128720f, -0.07726431f, 0.04655686f, 0.11233223f, -0.16367252f, 
    0.03648594f, 0.04682337f, 0.06979363f, 0.00253346f, -0.77421838f, -0.34274948f, -0.14811575f, -0.07926098f, 
    0.03880451f, -0.11682595f, -0.15423447f, -0.55600399f, -0.17247635f, -0.40977019f, 0.17768466f, 0.01575946f, 
    -0.01409856f, 0.10516720f, -0.04677871f, -0.01636381f, -0.58456194f, -0.08337784f, -0.08296011f, 0.03162878f, 
    0.13595262f, 0.07505378f, -0.09536408f, -0.01661634f, 0.08170119f, 0.45998502f, -0.10025309f, -0.15714873f, 
    0.06928011f, -0.15746722f, 0.18474147f, 0.09660386f, 0.10669184f, 0.15864725f, -0.70856357f, -0.48377031f, 
    -0.19907713f, -0.00506703f, -0.14291111f, -0.08462489f, -0.13368620f, -0.27882847f, 0.11895404f, 0.21627012f, 
    0.13980885f, -0.20353915f, 0.07211835f, 0.01422617f, -0.04226207f, -0.05314014f, 0.18553033f, 0.18487394f, 
    0.12106259f, 0.08621154f, 0.15714528f, 0.00141729f, 0.12642862f, 0.24263610f, 0.01228971f, -0.08089557f, 
    0.16667221f, -0.54686671f, 0.40067050f, 0.17745523f, -0.32935810f, 0.29173982f, -0.00553300f, 0.13479990f, 
    0.00420536f, 0.01284706f, -0.35132316f, 0.34560123f, -0.05363750f, -0.08554389f, -0.03554191f, -0.00602905f, 
    -0.12417018f, -0.08579915f, 0.03003038f, 0.05260711f, -0.11812082f, 0.13074258f, 0.19095512f, -0.19352317f, 
    0.16400452f, 0.07905880f, 0.15657531f, -0.15711510f, -0.16848433f, -0.24454984f, -0.09141668f, 0.08763738f, 
    -0.01874500f, 0.17669995f, 0.06953788f, 0.00377351f, 0.09196705f, 0.29407969f, -0.13820262f, 0.10702515f, 
    0.16379450f, 0.01611162f, 0.22021292f, -0.05428531f, -0.03358540f, -0.13536465f, 0.72711068f, 0.09742817f, 
    -0.05842973f, 0.00837643f, 0.06604134f, 0.05346575f, 0.28024158f, 0.18233317f, 0.22868878f, -0.06525805f, 
    -0.18782754f, -0.06360191f, -0.22592971f, -0.15246740f, -0.13938276f, 0.15785615f, -0.14415780f, -0.10393173f, 
    -0.43693632f, 0.03841566f, 0.34979352f, 0.15142637f, 0.24477564f, 0.13471811f, -0.03317323f, 0.05831309f, 
    0.04903662f, -0.41308987f, -0.16365759f, 0.27725515f, 0.03987889f, -0.03847978f, 0.07608800f, -0.17766967f, 
    -0.04089338f, 0.06165991f, 0.13232869f, 0.17074639f, 0.05024933f, -0.04688499f, 0.06381112f, 0.09047605f, 
    0.06005384f, -0.02445001f, 0.11119641f, 0.22207278f, 0.01541199f, 0.00159903f, 0.01015768f, 0.01789765f, 
    0.12887625f, -0.27558976f, -0.30421793f, 0.13112079f, -0.02054757f, 0.29158670f, 0.05122895f, -0.14922011f, 
    -0.04053290f, -0.03126896f, 0.00581608f, 0.04301903f, -0.07047930f, -0.89720827f, -0.75534260f, -0.53485590f, 
    0.03775305f, 0.12155961f, -0.30049586f, 0.01086329f, -0.11823434f, 0.02018865f, -0.26392525f, 0.16657372f, 
    -0.01875542f, -0.09698950f, -0.01589218f, 0.07250390f, 0.06546772f, -0.07737993f, 0.25606534f, -0.36749628f, 
    0.27734801f, 0.29122666f, -0.16347094f, -0.17112939f, -0.04134594f, 0.04277001f, -0.01768598f, -0.10245088f, 
    -0.05807352f, -0.50120294f, -0.57588291f, -0.07377160f, 0.08651344f, 0.02144746f, -0.05064885f, 0.05509120f, 
    0.10134331f, 0.38329944f, -0.05062957f, -0.14068185f, -0.03694020f, -0.04069364f, 0.15568715f, 0.04614401f, 
    0.13564016f, 0.10121861f, 0.11967752f, -0.32720265f, -0.68385720f, -0.07888050f, 0.03177352f, -0.05396456f, 
    0.19833000f, -0.05830665f, 0.20788629f, 0.41994879f, -0.82200539f, -0.61768198f, 0.10917091f, 0.10485137f, 
    -0.01317635f, 0.04008212f, 0.08003876f, -0.21010464f, 0.41672978f, 0.01220165f, -0.08839753f, 0.00642061f, 
    0.18032278f, 0.11907732f, 0.08555386f, -0.04715751f, -0.07486022f, -0.24887879f, -0.17247099f, -0.14831167f, 
    0.15240139f, 0.07862868f, 0.10891435f, 0.02981123f, -0.07212077f, 0.28312629f, -0.08958521f, 0.04208113f, 
    -0.02623552f, 0.02745057f, -0.14005382f, 0.02034280f, 0.08297052f, -0.01390297f, 0.31307587f, 0.16893741f, 
    -0.65272349f, 0.54467177f, 0.14446047f, -0.01088840f, 0.07594018f, 0.10999987f, -0.11985603f, 0.17319041f, 
    0.11347593f, 0.01328385f, -0.08899553f, 0.11719298f, 0.19747347f, 0.12087256f, -0.01741077f, 0.02785519f, 
    -0.05576053f, -0.10006031f, 0.11271825f, -0.23641597f, 0.12945823f, 0.22482522f, -0.01558770f, 0.12472323f, 
    -0.01525533f, -0.14709665f, -0.17651984f, 0.09087001f, 0.09028085f, 0.31889576f, 0.10384274f, -0.30328086f, 
    -0.23793125f, -0.48895618f, -0.34010431f, -0.25040892f, 0.10551640f, 0.18089440f, 0.19703238f, 0.07999618f, 
    0.03913819f, -0.07828706f, 0.07339656f, 0.02472548f, 0.11076685f, -0.25290745f, 0.02519730f, -0.08755870f, 
    0.17102663f, 0.24237484f, 0.08495015f, 0.12428266f, 0.30643192f, 0.02268673f, 0.17490187f, -0.09829418f, 
    0.11402673f, -0.01516078f, -0.00544950f, 0.10171000f, -0.06652684f, -0.07429527f, 0.00653037f, -0.05327290f, 
    0.23319493f, 0.07157139f, -0.03271971f, 0.11525259f, -0.11181656f, -0.00946052f, 0.08309586f, 0.28636637f, 
    0.10811423f, -0.24400508f, -0.07333030f, 0.04418503f, 0.08485875f, 0.14674453f, 0.16230930f, -0.00573894f, 
    0.44442552f, -0.10341401f, -0.27813956f, 0.07443116f, -0.06488708f, 0.14084430f, -0.06034937f, 0.11595055f, 
    0.12484799f, 0.02806248f, -0.03183492f, 0.23471051f, -0.02718293f, 0.01520816f, 0.03342558f, -0.01718925f, 
    0.10789174f, 0.11419287f, 0.04833119f, 0.03135805f, 0.20944227f, -0.01490293f, -0.11732482f, 0.20657939f, 
    -0.00402589f, 0.08736648f, 0.15487604f, 0.06322823f, 0.12005255f, -0.03678792f, 0.06875326f, 0.05998221f, 
    0.08534260f, 0.21926357f, -0.05495615f, -0.15885800f, 0.18302251f, 0.01842084f, -0.04756916f, 0.18644609f, 
    0.00531576f, 0.12745371f, -0.01187150f, -0.25667834f, -0.16408890f, -0.01526730f, 0.16069989f, 0.02344255f, 
    0.13257231f, 0.08964726f, -0.08834468f, 0.14972539f, 0.00991115f, -0.16964936f, 0.22377498f, 0.34930232f, 
    0.05337331f, 0.22751050f, -0.08944520f, -0.09499344f, 0.16553868f, 0.11625195f, 0.01517188f, 0.11118620f, 
    -0.12990372f, -0.12577626f, 0.13496581f, 0.03598130f, 0.08151335f, -0.08818622f, -0.54020458f, -0.02695670f, 
    0.18726923f, -0.03997782f, 0.23063467f, -0.04668240f, -0.03915679f, 0.05933063f, 0.06965144f, -0.14249761f, 
    0.23937365f, 0.11634844f, 0.05689691f, -0.09612813f, 0.11667901f, 0.02782495f, 0.23242655f, 0.11961757f, 
    0.29454231f, 0.30561697f, 0.36194170f, 0.05384767f, -0.17475000f, 0.01675168f, 0.09254641f, 0.08524154f, 
    0.16026461f, 0.18536729f, -0.18605484f, 0.05051380f, 0.08876631f, -0.26253104f, -0.10279907f, 0.00510392f, 
    0.10853586f, 0.16708297f, -0.08380049f, 0.02544218f, 0.00136233f, 0.03230330f, 0.06513692f, 0.19725050f, 
    0.20848584f, -0.03175554f, -0.05597254f, 0.02018947f, -0.31324136f, -0.23320173f, -0.37477586f, -0.19052160f, 
    0.10518648f, 0.12919807f, 0.15408665f, -0.03288877f, -0.09752803f, -0.21982063f, 0.12426398f, 0.19256385f, 
    0.33263394f, 0.10734996f, -0.01289121f, 0.14017911f, 0.21107478f, 0.21933596f, 0.10713544f, -0.02922182f, 
    -0.14854677f, 0.14674324f, 0.11516053f, -0.00511643f, -0.04976857f, -0.19999082f, -0.41413838f, -0.23394279f, 
    -0.08624108f, 0.16339374f, -0.07288663f, 0.06577027f, 0.02793916f, 0.14585844f, -0.02610325f, -0.37649328f, 
    -0.23085693f, 0.21898338f, 0.12151175f, -0.07871679f, 0.04607999f, 0.12474476f, -0.08386726f, 0.10764179f, 
    -0.13385375f, -0.31457803f, 0.48659134f, 0.08308061f, 0.46074522f, 0.03898136f, -0.04945772f, 0.17479950f, 
    0.16569722f, 0.13364054f, 0.18731348f, 0.20079035f, 0.20137718f, -0.02898373f, 0.18967554f, -0.01439956f, 
    -0.06460255f, 0.13877133f, -0.17226796f, -0.18033834f, 0.20235492f, 0.18552811f, -0.10536622f, -0.01707563f, 
    0.07453687f, -0.00083497f, 0.12282526f, -0.04738298f, -0.12384351f, 0.53967994f, -0.09994118f, 0.00995859f, 
    0.03407440f, 0.10269938f, 0.32934725f, -0.02283910f, 0.13004351f, 0.05908534f, 0.03934669f, -0.03880329f, 
    -0.12783211f, 0.11696506f, 0.23989980f, -0.00720704f, -0.04259126f, -0.14256433f, 0.00803479f, 0.01407279f, 
    0.01048107f, -0.05669801f, 0.12398353f, -0.01710655f, 0.06776663f, -0.00427346f, -0.09970924f, 0.15348196f, 
    -0.03470524f, 0.00294978f, 0.03468091f, -0.00379108f, -0.02000212f, -0.02003445f, 0.03970718f, 0.02997248f, 
    0.00958141f, -0.00976074f, 0.00003206f, 0.04331904f, -0.01182701f, -0.06026736f, 0.00912586f, -0.05693677f, 
    -0.03577950f, -0.01252029f, 0.00812099f, -0.05192453f, 0.04420935f, -0.03327546f, -0.01706525f, -0.01689790f, 
    -0.01727894f, 0.00558631f, 0.02387971f, -0.05381400f, -0.03779006f, -0.03384647f, -0.06556277f, -0.03546800f, 
    -0.04163278f, 0.03634056f, 0.04802248f, -0.04472283f, 0.00464191f, -0.04924067f, -0.02722474f, -0.03276173f, 
    -0.02548439f, -0.05285512f, -0.03021507f, -0.00474915f, -0.05222831f, -0.03688502f, 0.04518140f, -0.02319336f, 
    -0.02077091f, -0.05739059f, -0.00853964f, -0.04840079f, -0.00962377f, -0.05972841f, 0.01036889f, 0.05061609f, 
    0.02391466f, -0.05165226f, -0.02406415f, 0.03925379f, -0.06551021f, -0.02531762f, 0.00983903f, -0.06479566f, 
    -0.04586191f, 0.00465256f, -0.00091184f, -0.04759626f, -0.05854890f, 0.04462133f, 0.00604360f, -0.03047495f, 
    0.03064977f, 0.03871149f, -0.05080026f, 0.02839995f, -0.05112819f, -0.00385045f, -0.03522835f, -0.02484614f, 
    -0.02306419f, 0.01378574f, -0.02244901f, -0.00853362f, 0.02690202f, 0.02005907f, -0.06587293f, 0.05048465f, 
    0.01034179f, 0.03555027f, 0.02397923f, -0.02442197f, 0.02721070f, -0.06375749f, 0.04399459f, 0.00977147f, 
    -0.03465920f, -0.01897199f, -0.05169911f, -0.00681029f, 0.03814093f, 0.04160434f, -0.01697700f, 0.02197565f, 
    -0.00719182f, -0.00554500f, -0.00455411f, 0.03555115f, -0.04017766f, -0.01063314f, -0.02303377f, -0.03204409f, 
    -0.00694131f, 0.00642272f, -0.04267680f, -0.04508977f, -0.01066741f, -0.04443073f, 0.01787581f, -0.03618498f, 
    -0.05752643f, -0.03888591f, 0.02921715f, -0.04057265f, -0.00870495f, 0.02174763f, 0.04951016f, 0.03129782f, 
    0.04712620f, 0.01094192f, -0.04377627f, -0.04948806f, -0.06558777f, 0.00192159f, -0.03554066f, -0.02482354f, 
    0.01419288f, 0.05028408f, -0.01812121f, 0.04605840f, 0.04398930f, 0.02179002f, -0.03549363f, 0.00468210f, 
    0.00001435f, -0.03904312f, -0.01289248f, 0.03041268f, -0.01782735f, -0.05295122f, -0.03247204f, 0.02566997f, 
    -0.06030779f, -0.05601070f, 0.04058322f, 0.00282682f, -0.01105099f, 0.03653693f, -0.01938919f, 0.01440458f, 
    -0.05648300f, 0.00450436f, -0.06121848f, 0.01633659f, -0.01702066f, -0.06115769f, 0.03705195f, 0.04812183f, 
    0.02267657f, 0.04653129f, 0.00683185f, 0.03297238f, -0.02300302f, -0.02082087f, -0.02134969f, -0.01285988f, 
    -0.05712023f, 0.00823068f, 0.04474190f, 0.03245791f, -0.06252936f, -0.04343135f, 0.00343015f, 0.01366152f, 
    0.03241788f, -0.06246204f, -0.04374031f, 0.02762158f, -0.02763695f, -0.05118947f, -0.05947866f, -0.04647936f, 
    -0.03123173f, 0.02673952f, 0.04002644f, -0.01345423f, -0.00064408f, 0.01526543f, -0.02521481f, -0.06395140f, 
    0.02550937f, 0.01436033f, -0.01694517f, 0.02937755f, 0.00717491f, -0.00156022f, -0.02577989f, -0.00685249f, 
    0.03156945f, -0.05322579f, -0.03933746f, -0.02840590f, 0.02585554f, -0.02341989f, -0.02677517f, 0.00717394f, 
    -0.02527042f, 0.04423487f, 0.05096186f, -0.01670464f, 0.01904935f, -0.01250103f, -0.01669873f, -0.00388248f, 
    -0.00274373f, -0.05696819f, 0.00279738f, -0.01724472f, 0.00698109f, -0.05855335f, -0.00287559f, -0.04704239f, 
    -0.04142270f, -0.05644320f, -0.00167341f, 0.00905485f, -0.00680080f, -0.06554887f, 0.01370493f, 0.03850754f, 
    -0.00817396f, 0.02869187f, -0.04454440f, -0.05201263f, -0.02156727f, 0.00010626f, 0.01633386f, -0.06531764f, 
    -0.04987578f, -0.06591474f, -0.00997862f, -0.04071052f, 0.00842531f, -0.02648019f, 0.01003443f, -0.02720324f, 
    0.02188666f, 0.01750052f, -0.03228228f, -0.00839834f, 0.04937094f, 0.04885396f, 0.02043744f, 0.04173234f, 
    0.04536876f, -0.02682306f, 0.00071826f, 0.02237462f, -0.00755246f, -0.05215886f, -0.01155011f, -0.04690621f, 
    -0.03504663f, -0.02155771f, -0.04197028f, 0.02088359f, 0.03704871f, -0.00802928f, -0.04321472f, -0.00077803f, 
    -0.03098810f, -0.03627131f, -0.03108124f, -0.01961585f, 0.03658805f, -0.01738091f, -0.04070058f, -0.03982912f, 
    0.00839644f, 0.17539360f, -0.02110945f, -0.10677978f, 0.02036369f, -0.12142284f, 0.14833674f, 0.08666524f, 
    -0.02746087f, -0.43059191f, 0.20734322f, -0.10273799f, 0.10613561f, -0.04692470f, 0.00701556f, -0.14153036f, 
    0.03531815f, -0.09729017f, 0.33381042f, 0.36861888f, 0.26130062f, -0.11470630f, 0.04791645f, -0.03422736f, 
    0.09888339f, -0.00907819f, -0.31877303f, 0.17195086f, 0.07524092f, 0.31591943f, -0.07976624f, -0.03899150f, 
    0.00176370f, -0.15803717f, -0.10917649f, -0.10398081f, 0.18051003f, -0.01631676f, 0.43467927f, -0.08592905f, 
    -0.01203639f, -0.13762657f, -0.06178998f, 0.13353780f, 0.15960863f, -0.21854900f, 0.00571317f, -0.00232663f, 
    0.07758995f, 0.09292436f, 0.01538376f, -0.15219863f, 0.11613640f, 0.05084605f, 0.19886288f, 0.28324685f, 
    0.21789901f, -0.03346219f, 0.03456094f, -0.06595176f, 0.01691790f, -0.14818396f, 0.25631085f, -0.23283508f, 
    0.24034531f, -0.34433737f, -0.10434753f, 0.10607464f, -0.20023511f, 0.01188817f, -0.09969384f, -0.09269832f, 
    -0.02696110f, 0.28109288f, -0.09286050f, -0.35617125f, 0.17262007f, -0.22404946f, -0.05798766f, 0.11480836f, 
    0.04003024f, 0.09925725f, 0.07201952f, 0.41923919f, -0.16350237f, -0.47603437f, -0.11807898f, 0.04493086f, 
    -0.02749587f, 0.04572241f, 0.45934427f, -0.01670635f, -0.03113444f, 0.00123169f, -0.01100694f, -0.12802838f, 
    0.11793778f, -0.15502204f, 0.29979128f, -0.08152626f, 0.20515773f, -0.24068823f, 0.08645940f, 0.04182608f, 
    0.08893657f, 0.07474296f, -0.03051108f, 0.04098390f, 0.11762641f, 0.12079784f, 0.21495885f, -0.52011991f, 
    -0.39650682f, -0.34210539f, 0.08529675f, -0.00352973f, 0.04023302f, -0.04882833f, 0.25224328f, 0.07288311f, 
    0.16376972f, 0.00877957f, -0.04876333f, 0.01845874f, 0.15396912f, 0.11510686f, -0.64887911f, -0.16445574f, 
    -0.13302001f, -0.06896474f, -0.02328319f, 0.15666699f, -0.17637812f, 0.22177778f, -0.15897653f, -0.03996678f, 
    0.40068722f, -0.09802295f, -0.24782377f, 0.07135053f, 0.03280097f, 0.06359456f, 0.08156313f, -0.04375653f, 
    -0.00229057f, -0.01654055f, 0.08816051f, -0.08047595f, -0.25592029f, -0.15240487f, 0.11810400f, -0.06548563f, 
    0.01711559f, 0.13145854f, -0.34804714f, -0.21289663f, -0.17635421f, 0.11848008f, -0.41106287f, 0.02392646f, 
    -0.04264420f, 0.08789352f, -0.07715375f, 0.13141628f, 0.04764649f, -0.03069590f, -0.02016595f, -0.09237035f, 
    -0.03358258f, 0.11038351f, 0.02036276f, -0.08453342f, 0.21245359f, 0.15777570f, 0.10290438f, 0.04701484f, 
    0.07290076f, 0.01485167f, 0.04785566f, -0.12382130f, -0.18200706f, 0.31675899f, 0.14609049f, -0.07978894f, 
    -0.29958367f, -0.04355603f, -0.05189430f, 0.13632071f, -0.01342253f, 0.52171081f, 0.04315047f, 0.36907485f, 
    -0.17039834f, -0.09638640f, -0.04796972f, 0.09261550f, -0.14142218f, -0.02585253f, -0.10989988f, 0.04105007f, 
    0.16038898f, 0.11771357f, -0.02942669f, -0.02802465f, 0.04260853f, 0.00691068f, -0.00863718f, 0.17067002f, 
    -0.08803869f, 0.13523264f, -0.15711592f, -0.06324206f, -0.22266500f, 0.10484084f, -0.10143258f, 0.02978715f, 
    -0.11151013f, 0.52973640f, -0.09047717f, 0.04247933f, -0.11964459f, 0.02493278f, -0.01997162f, -0.16372347f, 
    -0.03513955f, -0.12013160f, 0.21955977f, -0.16019052f, -0.05954745f, -0.05250515f, 0.08123960f, 0.20513944f, 
    -0.06168805f, -0.11087495f, 0.02206954f, 0.15232708f, 0.06227188f, -0.03638503f, 0.14112495f, -0.14795494f, 
    -0.01510164f, 0.23734663f, -0.00643811f, -0.66472596f, 0.54474550f, 0.19128729f, 0.15274754f, 0.23372453f, 
    0.19832626f, -0.00423955f, -0.17000484f, -0.08377828f, -0.11460497f, 0.19627818f, -0.03790629f, 0.04623875f, 
    0.22477533f, 0.08132109f, 0.23133120f, -0.08428544f, -0.09154733f, 0.03130892f, 0.14108948f, 0.19161884f, 
    -0.14922729f, 0.10007970f, -0.22616638f, -0.04492510f, 0.29909489f, -0.00007127f, 0.04688882f, 0.11349011f, 
    0.14506741f, -0.61619973f, -0.30319440f, -0.25026578f, 0.10681915f, 0.10569865f, 0.11687416f, 0.03561986f, 
    0.13842808f, 0.02810287f, -0.16711986f, 0.23858917f, -0.12764820f, -0.18726864f, -0.04750557f, -0.01303497f, 
    -0.01999074f, 0.09840970f, 0.13895935f, 0.08960699f, -0.00148525f, 0.10948185f, -0.06142344f, 0.10427053f, 
    0.10762271f, -0.01444784f, 0.58797508f, -0.02551073f, -0.08068276f, 0.02828135f, 0.12514307f, 0.03280138f, 
    0.08240362f, -0.02482800f, -0.09000901f, -0.07504809f, -0.35851413f, 0.33620083f, -0.06051107f, -0.06432876f, 
    0.06126336f, -0.07878330f, -0.03698131f, 0.09646599f, 0.12301469f, -0.34689522f, -0.15921234f, -0.05748020f, 
    0.04039981f, -0.04064703f, 0.04650050f, -0.04350674f, -0.14945987f, -0.04561835f, 0.59294921f, 0.17326912f, 
    0.01671805f, -0.08619287f, -0.06133758f, 0.13353601f, -0.16828644f, -0.05789872f, -0.01572160f, 0.34159496f, 
    0.01197215f, -0.18333980f, 0.03632711f, -0.02809302f, 0.09123345f, 0.11963588f, -0.21321811f, -0.06748805f, 
    -0.24470825f, -0.60785699f, -0.06153696f, 0.08158582f, 0.11636700f, 0.08357953f, 0.04430569f, -0.66172081f, 
    0.39368856f, 0.04965858f, 0.01907416f, 0.11102671f, 0.09314160f, 0.13505107f, -0.04874853f, 0.00167275f, 
    -0.45146403f, -0.33870885f, -0.06117930f, 0.08487613f, 0.08435819f, -0.01957412f, -0.21217892f, -0.01883219f, 
    0.04835902f, -0.23911229f, -0.00585259f, 0.02951547f, -0.07816181f, 0.00338241f, 0.04027174f, -0.01154051f, 
    0.13600917f, -0.22031748f, -0.41690612f, 0.07634055f, 0.21588030f, -0.09494483f, 0.08034253f, 0.09846015f, 
    -0.03516287f, 0.21250762f, -0.05432651f, -0.11560647f, 0.07033554f, -0.10217065f, 0.14611726f, -0.12496976f, 
    0.16874968f, 0.08153810f, -0.04054435f, 0.26088652f, -0.09638416f, -0.33571896f, 0.03081674f, 0.06984178f, 
    -0.13196540f, -0.02666329f, -0.16563305f, 0.04890505f, 0.20311952f, 0.14308450f, 0.05606814f, -0.10779948f, 
    0.17873502f, -0.07212976f, 0.02276928f, 0.04871141f, -0.17108102f, 0.03029297f, -0.08346847f, 0.16381030f, 
    0.26328468f, 0.07018490f, 0.07749782f, 0.24121109f, -0.03093013f, -0.01557486f, 0.16234419f, -0.53015012f, 
    0.01891300f, -0.10926252f, 0.03966189f, -0.09114870f, 0.19285966f, -0.19149962f, -0.14563285f, -0.09752524f, 
    -0.27360144f, -0.33486587f, -0.06446299f, 0.03360825f, 0.01426916f, -0.04949130f, 0.01822680f, -0.12384924f, 
    0.01122650f, -0.06821470f, 0.28966981f, 0.34005612f, -0.04151477f, 0.11562318f, -0.13718463f, 0.04484296f, 
    0.02540342f, -0.12450725f, -0.03631023f, 0.10752742f, 0.17448792f, 0.23323494f, 0.06677449f, 0.02897939f, 
    0.01689158f, 0.07924522f, 0.07186683f, 0.14400186f, 0.12425487f, 0.48369572f, 0.14565454f, -0.13304769f, 
    -0.00038855f, -0.00026329f, 0.16753235f, 0.11646929f, -0.06496387f, 0.43657094f, -0.08313699f, 0.06594487f, 
    -0.01254295f, -0.13357708f, 0.10575814f, 0.07831136f, -0.05526049f, -0.14403121f, 0.03907055f, 0.05361548f, 
    -0.18899247f, -0.04234989f, -0.26068330f, -0.03446339f, 0.11775606f, -0.03310137f, 0.11024992f, -0.03833689f, 
    0.09777892f, -0.04199573f, 0.08361510f, -0.01149768f, 0.04250905f, -0.02655531f, -0.09017920f, 0.00159731f, 
    -0.17034195f, 0.22137524f, -0.04841968f, 0.09293474f, 0.05253443f, -0.10398717f, -0.05273920f, -0.12717998f, 
    -0.03539532f, 0.08002097f, -0.16985339f, 0.23369315f, 0.02618963f, -0.10560347f, 0.18944241f, 0.08551043f, 
    0.19653027f, 0.13264446f, 0.22420111f, 0.16695145f, 0.13417099f, 0.03473980f, -0.02332133f, 0.04261312f, 
    0.12944229f, -0.04561009f, -0.31464246f, -0.00328059f, 0.29758263f, 0.05878042f, 0.02114755f, 0.10937241f, 
    0.01373143f, 0.04513576f, -0.02573824f, -0.10838299f, 0.20399517f, -0.22404531f, -0.22229354f, -0.04581647f, 
    -0.27035260f, -0.04177235f, -0.17013811f, -0.03504386f, 0.16556385f, 0.19732267f, 0.19925669f, 0.07544057f, 
    0.02987576f, -0.01523045f, 0.01773697f, 0.11018855f, -0.09515146f, -0.10432582f, 0.05924014f, 0.38562390f, 
    0.17706944f, -0.16217120f, -0.26033118f, -0.05626418f, 0.01702590f, 0.05608886f, -0.02288328f, -0.21587519f, 
    -0.05101771f, -0.01839405f, -0.04632783f, -0.06873631f, -0.01993969f, 0.05785032f, 0.14577806f, -0.44868755f, 
    -0.12409633f, -0.39860699f, -0.17705184f, -0.26976639f, 0.21208687f, -0.02623289f, 0.02590992f, -0.25235999f, 
    -0.03169655f, 0.13965398f, 0.13080299f, 0.20027745f, 0.01616601f, -0.16706081f, 0.10608932f, 0.07294010f, 
    0.09628695f, 0.31935313f, 0.04174255f, 0.22226141f, 0.23989113f, 0.04688232f, -0.03048795f, 0.29155523f, 
    -0.01256068f, 0.11252126f, 0.07358603f, 0.08256810f, 0.40068135f, -0.15561175f, 0.09683181f, 0.07695509f, 
    0.11823958f, 0.16734770f, 0.28790337f, -0.00069171f, -0.47528544f, 0.01952752f, -0.00202664f, -0.05323141f, 
    0.06979509f, 0.11749905f, 0.13328311f, 0.29247245f, -0.00963543f, 0.29326871f, 0.11872368f, -0.00169089f, 
    -0.22159770f, 0.02025613f, 0.05702603f, 0.13096863f, 0.31543243f, -0.09133659f, -0.09912108f, 0.08275041f, 
    0.10430068f, 0.16809662f, -0.03432248f, -0.08884886f, -0.22308432f, 0.04159384f, 0.06893291f, -0.33251968f, 
    -0.28646913f, 0.09117349f, 0.03817629f, 0.07916993f, 0.07528906f, 0.19032432f, -0.15835212f, -0.10790968f, 
    0.12017875f, 0.13937239f, 0.19462414f, 0.00252348f, 0.08447313f, 0.20380990f, 0.03905658f, -0.01657439f, 
    -0.18134968f, 0.05095836f, -0.08577251f, 0.06164388f, -0.01654788f, 0.08607890f, 0.07099023f, 0.01938068f, 
    -0.11901037f, 0.03362723f, -0.17839737f, -0.03852711f, -0.06666357f, 0.13018082f, 0.09190663f, -0.18157594f, 
    -0.04423757f, 0.12903160f, -0.16436681f, -0.11223508f, -0.18501405f, 0.10852904f, 0.06017398f, 0.02735583f, 
    -0.01039516f, 0.07419319f, -0.23175332f, 0.02047002f, 0.17049921f, 0.13192503f, 0.13028078f, 0.13351341f, 
    -0.01040305f, 0.12096019f, 0.24957727f, 0.00949901f, -0.15942240f, 0.11410064f, -0.11558175f, 0.04126653f, 
    -0.05271480f, 0.17146026f, -0.11481006f, 0.08008678f, -0.05288403f, 0.07275996f, 0.14310601f, 0.06871436f, 
    0.00776451f, 0.11243860f, -0.03274301f, -0.01734501f, 0.25579250f, 0.19488280f, -0.03970662f, -0.13510416f, 
    0.26387680f, 0.11172600f, 0.19562805f, 0.09640510f, -0.28077695f, 0.11304928f, 0.05952990f, -0.24847510f, 
    0.08248638f, 0.05533830f, 0.26240411f, -0.10003803f, -0.05371013f, 0.06378915f, 0.22651953f, 0.05244179f, 
    0.09174127f, -0.05067570f, -0.40027836f, 0.05461705f, -0.15545100f, 0.00451765f, -0.09434567f, -0.14277524f, 
    -0.04646954f, 0.03238423f, -0.14941548f, -0.37163073f, -0.01108642f, -0.12852548f, -0.07206362f, -0.26927543f, 
    -0.23044269f, -0.07082807f, -0.06959909f, 0.12684664f, 0.03647009f, -0.03274015f, 0.10868001f, 0.05111570f, 
    -0.05307010f, -0.02374712f, -0.20263101f, -0.09924581f, -0.00339799f, -0.00508134f, -0.06886055f, 0.17922671f, 
    0.04704671f, 0.06876983f, 0.05014087f, 0.14736056f, 0.08090854f, 0.01018101f, 0.23972122f, 0.19425195f, 
    0.14474735f, 0.15791057f, 0.15058473f, 0.22513044f, 0.16777097f, 0.10366192f, -0.10913730f, -0.21970098f, 
    -0.06791402f, 0.05628592f, -0.01954755f, 0.09345607f, 0.18624492f, 0.15696968f, -0.17299499f, -0.40189201f, 
    -0.15597771f, -0.00944309f, 0.12887257f, 0.11562253f, -0.24863720f, -0.12794200f, -0.60368222f, 0.02669777f, 
    0.02261725f, -0.11827843f, 0.10245947f, -0.02983171f, 0.06176805f, -0.03993164f, -0.01639698f, -0.01232148f, 
    0.13051377f, 0.08865669f, -0.16585845f, 0.24669589f, 0.15252686f, 0.04702619f, 0.13024186f, 0.05954677f, 
    0.06929111f, 0.01407459f, 0.06910794f, 0.03553160f, 0.19477542f, 0.24092101f, 0.01383139f, 0.06026778f, 
    0.31468254f, 0.08661754f, -0.33412781f, -0.24630994f, 0.03069159f, 0.10403433f, 0.07506271f, 0.08157435f, 
    0.02388685f, -0.14209938f, -0.15000440f, -0.26008525f, 0.21753879f, 0.22817244f, 0.12166533f, 0.17750534f, 
    0.02133811f, 0.20238453f, 0.23927355f, 0.30974782f, -0.08385166f, 0.05113119f, 0.01174243f, 0.01666865f, 
    0.23755008f, 0.01793951f, -0.04432262f, 0.21767114f, 0.10656834f, -0.42894247f, 0.13185906f, 0.32976934f, 
    0.12682232f, 0.08497294f, -0.02353820f, 0.01958934f, 0.05433518f, 0.12827887f, -0.13610923f, 0.02408413f, 
    -0.04642412f, -0.07768996f, 0.17041512f, -0.07046796f, 0.01896533f, 0.01234967f, -0.02742016f, -0.20294179f, 
    0.29391509f, 0.13086583f, -0.28396097f, -0.10953225f, 0.10323864f, 0.01946959f, 0.21140915f, 0.12474900f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10331010f, 0.21339309f, -0.00296787f, 0.15575401f, 0.31920379f, -0.01163205f, -0.04271233f, -0.04140662f, 
    0.44627610f, 0.03791552f, -0.04426312f, -0.06436240f, 0.08043198f, -0.03031621f, 0.16396821f, 0.28164059f, 
    -0.02114436f, -0.24128608f, 0.04933903f, 0.14446111f, -0.12992597f, -0.03721869f, -0.02704442f, 0.24923068f, 
    0.02576992f, 0.21139582f, 0.10707180f, 0.02751315f, -0.04210370f, -0.03033540f, 0.24329923f, 0.12917325f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.45469138f, 0.11018495f, -0.03896767f, 0.57159644f, -0.37307563f, 0.35576272f, 0.07946859f, -0.12755632f, 
    -0.19557571f, 0.09640051f, 0.04352800f, -0.07974230f, -0.65814686f, 0.10711943f, 0.03736981f, 0.11142616f, 
    -0.25915983f, 0.38926655f, 0.20473446f, -0.82073158f, 0.00867796f, 0.14696313f, 0.00756430f, -0.21154210f, 
    0.09313389f, 0.16287446f, 0.01318728f, -0.20206995f, -0.09073678f, 0.25984764f, -0.07865433f, -0.25898293f, 
    -0.29724497f, -0.23864594f, 0.08139794f, 0.26984397f, 0.56687850f, 0.62879521f, 0.05208490f, 0.05830525f, 
    0.03027767f, 0.11739528f, -0.14175749f, -0.07216285f, -0.45000848f, -0.08351503f, -0.00813469f, 0.25081226f, 
    -0.02655913f, -0.15330656f, 0.25703907f, -0.21941230f, 0.11150032f, -0.09380351f, 0.13277142f, 0.11553416f, 
    -0.10959883f, 0.42639592f, -0.02858081f, -0.27226326f, -0.03462792f, -0.38904944f, 0.18330459f, 0.02428096f, 
    -0.31584695f, 0.45203421f, -0.11513903f, -0.47200212f, -0.53126955f, -0.41925523f, -0.47412124f, -0.16562414f, 
    -0.01856403f, -0.34903783f, 0.03570125f, 0.08615676f, 0.28042573f, 0.15686336f, 0.13444053f, -0.34952566f, 
    -0.34885496f, 0.14423221f, -0.09549839f, 0.07726416f, -0.00205697f, -0.07716943f, 0.04535158f, 0.07671765f, 
    0.12988539f, 0.92129767f, 0.27360794f, 0.19255547f, -0.00020654f, -0.16308869f, 0.02123736f, -0.22841524f, 
    -0.11345635f, -0.38620219f, -0.06336308f, -0.43850926f, -0.40459874f, -0.31102103f, 0.49401465f, 0.14432637f, 
    -0.50740862f, -0.55570757f, -0.16419894f, 0.13085815f, 0.08184005f, 0.12907054f, 0.81607527f, 0.30937913f, 
    -0.59626508f, 0.24417368f, 0.22549267f, 0.11433287f, 0.21329448f, 0.08900242f, 0.15663341f, -0.97884667f, 
    -0.29091084f, -0.13552719f, -0.70538020f, 0.28423563f, 0.15387447f, 0.49848372f, -0.49475366f, 0.10042254f, 
    0.13364156f, -0.18410333f, -0.03777717f, 0.07771438f, 0.00924965f, 0.32926542f, -0.23042460f, 0.14941597f, 
    -0.23898260f, -0.11911024f, 0.07254704f, 0.00535862f, 0.71512544f, -0.06337470f, -0.31149766f, -0.01226142f, 
    0.19649059f, 0.09307148f, -0.08345278f, -0.24845670f, 0.10762678f, -0.05510191f, 0.10086745f, 0.18995583f, 
    0.08796155f, -0.42785910f, -0.00153198f, 0.05800138f, -0.11685400f, 0.24433100f, -0.05532642f, -0.28263074f, 
    0.40306976f, -0.25893837f, -0.14760517f, 0.44382682f, -0.27871624f, -0.58276790f, 0.22153722f, 0.15313213f, 
    -0.10241028f, 0.28852430f, -0.00878671f, -0.00682480f, 0.23896296f, -0.15757963f, -0.53726071f, -0.16166571f, 
    -0.22145551f, 0.26945859f, 0.00496959f, 0.30842698f, -0.13288510f, 0.13645898f, 0.20166808f, 0.19850750f, 
    -0.57896364f, 0.14975578f, -0.24220833f, -0.20863511f, 0.03615351f, -0.22850882f, 0.14059263f, 0.24571876f, 
    0.07951714f, 0.25500762f, -0.12668699f, -0.89673454f, -0.90079296f, -0.93220806f, -0.21104553f, 0.09250862f, 
    0.43524840f, 0.40141228f, 0.06686334f, 0.01928521f, -0.12063263f, 0.16460453f, -0.47139528f, 0.00248162f, 
    0.18631402f, -0.33105558f, -0.51458669f, -0.03838795f, -0.33076966f, -0.15412265f, -0.08297770f, 0.06784365f, 
    0.06378325f, -0.22242597f, 0.68020821f, 0.15862802f, -0.17612551f, -0.60805887f, -0.16666101f, -0.16173540f, 
    -0.02226579f, 0.19455200f, 0.15704237f, -0.52080864f, 0.31849924f, 0.60067123f, -0.36800146f, -0.06461541f, 
    -0.33760202f, 0.18188129f, -0.03995659f, 0.05167414f, 0.34446067f, -0.05699850f, -0.13412213f, -0.10462905f, 
    0.24218453f, 0.06751898f, -0.25585678f, 0.32983196f, 0.50993782f, 0.17357519f, -0.12189857f, -0.07733862f, 
    -0.12121202f, -0.14621408f, -0.09176292f, -0.01675148f, 0.07142369f, -0.07123714f, -0.38819468f, -0.05816029f, 
    0.21360509f, 0.02087322f, 0.03382297f, -0.39309910f, 0.28570241f, 0.12257022f, -0.57335627f, -0.08135724f, 
    0.08103412f, -0.40692404f, 0.02388538f, 0.04798168f, -0.52594513f, 0.13159068f, 1.22701752f, -0.27507761f, 
    0.25838718f, -0.02714838f, 0.27910987f, 0.07605990f, -0.27500507f, 0.02714350f, 0.40744019f, 0.24425536f, 
    -0.10914093f, -0.61402309f, 0.12982415f, -0.42877579f, -0.02249139f, -0.44504261f, -0.22810096f, 0.09773912f, 
    0.12029314f, 0.43294507f, -0.10057744f, -0.16031668f, -0.40044823f, 0.50520700f, -0.62747973f, -0.07507171f, 
    0.43432358f, -0.26695547f, 0.01020224f, -0.01093813f, 0.03654033f, -0.10775109f, -0.12755856f, 0.74404019f, 
    0.16440180f, -0.27643898f, -0.48437938f, -0.32552740f, -0.45769861f, 0.11142892f, -0.31816128f, -0.03532008f, 
    -0.27015144f, -0.21787880f, -0.65273929f, 0.35754341f, 0.12803784f, 0.16807766f, -0.13500324f, 0.06564958f, 
    -0.44462416f, -0.52871525f, 0.13318276f, -0.44072139f, -0.42338619f, -0.57831532f, 0.08341008f, -0.03710901f, 
    -0.13914895f, -0.08444759f, -0.05797416f, -0.07735027f, -0.44300777f, 0.06702852f, -0.68894458f, -0.04548420f, 
    0.04170025f, -0.52728260f, 0.31485951f, 0.35385099f, -0.35188782f, -0.03264953f, 0.34254831f, 0.32903796f, 
    0.78811204f, 0.20453846f, -0.32759315f, -0.40156901f, -0.05942687f, 0.52198827f, -0.30931160f, 0.27078447f, 
    0.33679169f, -0.63646823f, -0.14714353f, -0.49028176f, -0.08782870f, -0.30291730f, -0.01696986f, -0.05032238f, 
    0.22654980f, -0.25711465f, -0.11657072f, 0.11640534f, -0.07971435f, -0.11752157f, -0.07362502f, -0.76411265f, 
    0.32556245f, -0.50246280f, -0.54215306f, 0.05711078f, -0.33961537f, -0.03255365f, -0.17831460f, -0.11804958f, 
    0.32554477f, -0.72804475f, -0.07738198f, 0.10483030f, 0.07636287f, 0.00519015f, 0.87093455f, 0.28816307f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38179693f, -0.09890106f, 0.25710395f, 0.12122916f, -0.08877492f, 0.08310694f, 0.07196672f, -0.24540932f, 
    0.02766255f, 0.29758447f, 0.13339768f, 0.06475876f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
