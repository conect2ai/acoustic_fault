#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53226131f, 0.28652719f, -0.52035868f, 0.65780580f, 0.73522949f, 1.02577269f, -0.02642781f, -0.75987750f, 
    0.24736752f, -0.53720814f, -0.00171278f, 0.11227681f, -0.20665713f, 0.22029981f, -0.05782422f, 0.04320804f, 
    -0.00517270f, 0.17059511f, 0.03543835f, 0.14022057f, 0.20876539f, -0.08388327f, -0.11430318f, -0.11394368f, 
    -0.19985215f, -0.80651927f, 0.37128928f, 0.72891784f, 0.18534163f, 0.40662694f, 0.55674839f, 0.53998315f, 
    0.33623967f, -0.33706781f, 0.38915062f, -0.22521132f, 0.13118492f, 0.46881244f, -0.07091846f, -0.16896856f, 
    -0.43857387f, -0.03658658f, -0.12868473f, -0.08345256f, -0.20498072f, 0.15311602f, 0.25991949f, 0.17218019f, 
    0.17911345f, -0.01111933f, 0.20623648f, -0.32029447f, -0.75173378f, -0.67269957f, 0.21570024f, 0.76178658f, 
    -0.43532369f, -0.10768796f, -0.32048929f, -0.06157971f, -0.33322316f, 0.30009335f, 0.36755109f, -0.04495716f, 
    0.10284309f, -0.21396483f, -0.18648602f, 0.12004680f, -0.09596171f, -0.47660708f, 0.09715492f, 0.09284333f, 
    0.12786946f, 0.09092210f, 0.17395712f, 1.05847657f, 0.56767237f, 1.18017483f, -0.14615846f, -0.33496919f, 
    -0.10704021f, -0.11612123f, 0.08558389f, -0.03522085f, 0.04031833f, -0.11219460f, -0.13083215f, -0.15927869f, 
    0.31727716f, 0.16198210f, 0.16375364f, -0.04418198f, 0.15018055f, -0.00633820f, -0.19553678f, 0.04169522f, 
    -0.08603273f, -0.07366657f, -0.11974853f, 0.09988951f, 1.11708307f, 0.34661266f, 0.44549313f, 0.96133912f, 
    0.36183828f, -0.04709797f, 0.42535135f, -0.21607034f, 0.44317368f, 0.07470311f, -0.03278125f, -0.13060820f, 
    0.06889808f, -0.12085711f, -0.41157386f, -0.05737741f, -0.16987853f, -0.01113837f, -0.34750804f, -0.18682708f, 
    -0.23217015f, 0.00260854f, 0.03454839f, 0.21364968f, -0.14773619f, -0.78221565f, 0.00848847f, 0.13909210f, 
    -0.24709234f, 0.70608306f, -0.73580664f, -0.04712057f, -0.11987364f, -0.43042827f, -0.28269830f, 0.49642709f, 
    0.53526968f, 0.14874935f, 0.05831901f, 0.02508273f, -0.02597474f, 0.04376342f, -0.03644679f, 0.23051420f, 
    0.47585863f, -0.12899430f, -0.14156675f, 0.05700264f, 0.16588020f, 0.01275731f, -0.44737607f, -0.57035661f, 
    -0.07812352f, -0.13045876f, -0.48477969f, -0.90086108f, 0.75700867f, 0.29901916f, -0.26389596f, -0.41147998f, 
    -0.44120178f, 0.24663441f, -0.26408681f, -0.03125328f, -0.02624763f, -0.26959264f, -0.07760599f, -0.21086045f, 
    0.02565942f, -0.18379979f, 0.07942630f, 0.04464545f, 0.07719714f, -0.27489701f, -0.03520002f, 0.79524374f, 
    0.55118287f, 0.28406811f, 0.63079059f, 0.88446432f, 0.13029629f, -0.29630938f, -0.44205418f, 0.24534927f, 
    -0.06598461f, -0.11465686f, 0.22507749f, -0.01677586f, 0.11599451f, 0.25532547f, 0.23088618f, -0.01701627f, 
    0.29269928f, 0.24377514f, 0.42271948f, 0.25312492f, 0.42003858f, 0.06550623f, -0.11018044f, 0.43594450f, 
    -0.81546915f, -0.03190105f, 0.56631702f, 0.91525668f, 0.07658375f, 0.13925813f, 0.00722468f, 0.18074846f, 
    0.19879408f, 0.27529213f, -0.49334538f, -0.15299183f, -0.42875025f, 0.48880965f, 0.11074404f, 0.09721808f, 
    -0.01921878f, -0.06241471f, 0.12453036f, 0.00980328f, 0.09653392f, -0.05415386f, -0.07798176f, 0.16260016f, 
    -0.41971442f, 1.06173968f, 0.15402243f, -0.63016897f, 0.37693343f, 0.48378167f, -0.29842651f, -0.50275278f, 
    0.55768049f, 0.30832013f, 0.35759270f, -0.57268769f, -0.28356114f, 0.02242903f, -0.32150578f, -0.03736012f, 
    0.16596569f, -0.00284574f, 0.11830716f, 0.21234255f, 0.06976012f, 0.29042813f, -0.01561509f, -0.13126126f, 
    -0.26607609f, -0.03427325f, 0.17305121f, -1.09598327f, 0.44898224f, 0.85629612f, -0.21557610f, -0.86999077f, 
    -0.27288544f, 0.49452922f, -0.48131225f, -0.45343676f, 0.10587573f, -0.23055194f, -0.15712449f, -0.02990251f, 
    -0.05783297f, 0.26762870f, 0.29654518f, -0.11618005f, -0.33020988f, -0.21065336f, -0.00946608f, -0.00569460f, 
    0.08723718f, 0.21973862f, 0.03596797f, 0.34791842f, 0.37910536f, 0.86268353f, 0.19089398f, 0.29732168f, 
    0.24203058f, -0.32434759f, -1.00531721f, -0.35420549f, -0.28325579f, 0.16227290f, 0.50234324f, 0.29533499f, 
    0.07873628f, 0.23027004f, -0.19559710f, 0.04370112f, -0.24356635f, -0.28107211f, 0.02349662f, 0.12868264f, 
    -0.02030558f, 0.24858549f, 0.06253719f, -0.14786711f, 0.61031747f, 0.09290413f, -0.76456112f, 0.29138905f, 
    -0.52361268f, -0.46808001f, 0.46153179f, 0.33380270f, -0.23225242f, 0.08892358f, 0.57691580f, 0.04113697f, 
    -0.13549614f, -0.07903455f, -0.23651707f, -0.05621895f, 0.39916283f, 0.35482508f, 0.39048341f, -0.04896970f, 
    0.30186442f, 0.19664718f, -0.22948034f, 0.19788414f, -0.26439205f, -0.33166441f, -0.78376228f, -0.51411527f, 
    -0.16463375f, 0.36154205f, 0.18442917f, 1.07009482f, 0.55855131f, 0.61837214f, 0.59323502f, 0.11594322f, 
    -0.04900208f, -0.13460240f, -0.30583894f, -0.25951567f, -0.05452855f, 0.06650498f, 0.03608167f, -0.05497929f, 
    -0.13710825f, 0.05280381f, -0.05769377f, -0.11519666f, 0.08924106f, 0.00562328f, -0.06303836f, -0.69216967f, 
    -0.85949957f, -0.76623350f, -0.29376724f, 0.02340260f, 0.08810347f, 0.16211765f, -0.17571640f, -0.07089896f, 
    0.12572104f, 0.20571843f, -0.13013296f, -0.06150392f, -0.09275240f, 0.43603271f, 0.16322659f, -0.27404925f, 
    0.13763118f, 0.29538220f, 0.00875658f, -0.08647297f, -0.12624474f, -0.24651483f, 0.37538886f, -0.35123077f, 
    -0.24324669f, 0.65104055f, 0.65107059f, 0.19766104f, 0.47365999f, 0.55142981f, 0.62352085f, -0.10225430f, 
    -0.25072351f, 0.51191819f, 0.16855948f, 0.36344972f, 0.39201811f, 0.09655868f, -0.13105926f, 0.34420949f, 
    0.44040045f, -0.16969000f, 0.34412047f, 0.05153855f, -0.09319195f, -0.26081765f, -0.01590745f, -0.17016183f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13237908f, -0.06664104f, 0.19890188f, 0.35182673f, 0.13581428f, 0.11308844f, 0.16138716f, 0.15488060f, 
    0.03508941f, -0.10522045f, 0.27924079f, -0.03074200f, -0.11384441f, 0.02992448f, 0.17338462f, -0.02616149f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00405536f, 0.00875633f, 0.03985605f, 0.01472620f, -0.04040763f, -0.07617158f, 0.04281184f, -0.04478141f, 
    0.06743117f, 0.06046526f, -0.05427948f, 0.03961948f, -0.00005730f, 0.05015502f, 0.02195921f, -0.02846205f, 
    -0.08654580f, 0.05076176f, 0.04212048f, 0.04661999f, -0.06034381f, 0.04055674f, -0.06251188f, 0.05693179f, 
    -0.00410355f, -0.04122385f, 0.05303334f, 0.01513073f, 0.00302019f, -0.02315210f, 0.05754994f, 0.06581512f, 
    0.03877033f, 0.02958896f, -0.02503275f, 0.03551139f, 0.00007936f, 0.00688518f, -0.05136197f, -0.02139055f, 
    0.02353623f, 0.04492218f, -0.02145449f, -0.00841358f, -0.06943713f, -0.05311955f, -0.01356487f, -0.02911317f, 
    -0.02355343f, -0.05673025f, 0.01229597f, -0.00897236f, 0.01570418f, -0.03632500f, -0.07265665f, 0.01654444f, 
    -0.02004879f, -0.07912566f, 0.00956004f, -0.07145178f, -0.03229902f, -0.00858498f, 0.04602430f, -0.01627140f, 
    0.04708614f, -0.05918442f, -0.06122588f, -0.03862498f, 0.00633690f, -0.00857808f, 0.00556170f, -0.01275549f, 
    -0.01733567f, 0.00840999f, 0.03515588f, 0.03063406f, -0.01665097f, 0.01080251f, -0.05410573f, 0.02263236f, 
    0.05192930f, -0.06462290f, -0.01722093f, 0.02610349f, -0.00983813f, -0.00042645f, -0.07674260f, -0.06507586f, 
    0.01629272f, -0.03432849f, -0.02932248f, -0.03498090f, -0.02655577f, -0.06083831f, 0.02361387f, 0.05559575f, 
    -0.04977737f, -0.06766696f, -0.04619848f, -0.05320806f, -0.02375497f, 0.05513291f, -0.07182718f, -0.07505158f, 
    -0.02463285f, -0.02760870f, -0.02693255f, -0.05482583f, -0.06370783f, 0.02676927f, -0.00105153f, -0.04804920f, 
    -0.00254900f, -0.03917002f, -0.03578419f, -0.04187328f, 0.04683214f, -0.02892764f, 0.03156656f, -0.01605840f, 
    -0.01293299f, 0.01695367f, -0.05358237f, -0.01549106f, 0.01519423f, 0.01957811f, 0.01493613f, -0.03741464f, 
    0.04546552f, -0.01286858f, 0.01482533f, 0.00157909f, -0.05358219f, 0.06299350f, -0.04535159f, 0.02518587f, 
    0.01343312f, 0.03075523f, 0.02595739f, -0.01149531f, 0.04028556f, -0.05397414f, 0.00848812f, 0.04250049f, 
    0.00389999f, 0.02529382f, -0.01519930f, -0.07996406f, -0.05736037f, -0.04602651f, -0.07157750f, -0.00234962f, 
    -0.05143949f, -0.03008601f, -0.03200400f, 0.06797204f, 0.02339305f, 0.01515215f, -0.02640577f, -0.03336941f, 
    -0.01469949f, 0.01489045f, -0.01437269f, -0.06393553f, 0.05519606f, -0.01495503f, 0.00236991f, -0.04771297f, 
    -0.02894066f, 0.04184673f, -0.00071894f, 0.01782631f, 0.03982189f, -0.05405014f, -0.01208910f, 0.01017873f, 
    0.06337138f, 0.04762723f, 0.05707636f, -0.00854848f, 0.02314371f, -0.04127712f, 0.02321179f, 0.04904252f, 
    -0.00139383f, -0.06260424f, -0.08054947f, 0.05294413f, -0.05887304f, -0.08220586f, 0.02310487f, -0.03679669f, 
    0.38192308f, -0.14189446f, -0.26107323f, 0.00280784f, 0.02949758f, -0.00335882f, 0.10172769f, 0.04063334f, 
    0.07476522f, -0.04161035f, -0.03615888f, 0.00515574f, 0.44017774f, -0.01380182f, 0.00437290f, 0.11057374f, 
    -0.14818387f, 0.16606331f, 0.00331520f, 0.03632313f, 0.03519797f, -0.00982885f, -0.00404478f, 0.01804534f, 
    0.22223915f, -0.01143021f, -0.27242056f, -0.18227127f, -0.16935036f, -0.09880313f, -0.03378814f, -0.01647874f, 
    -0.15024722f, -0.00057338f, -0.23755634f, -0.03124661f, -0.35371214f, 0.02784266f, -0.09276223f, 0.00236516f, 
    0.11858484f, 0.01553596f, 0.17401648f, 0.06603263f, 0.01383048f, 0.04277622f, -0.08177247f, -0.01027105f, 
    0.07554048f, 0.11334185f, 0.19448756f, 0.17167637f, 0.01034771f, 0.10941103f, 0.11132219f, 0.20192131f, 
    -0.09061952f, 0.14982544f, 0.05229172f, 0.09370148f, -0.01146781f, 0.24215576f, -0.01348888f, 0.13380910f, 
    -0.11432084f, 0.17286099f, -0.01373421f, 0.07593520f, 0.03377165f, 0.11785283f, -0.06946604f, -0.22978136f, 
    0.22919875f, 0.17800745f, 0.26618859f, -0.24522331f, -0.08047076f, -0.09244017f, 0.06079462f, -0.06417821f, 
    -0.01688553f, 0.07956406f, 0.13396285f, 0.27089909f, -0.00894034f, 0.01685478f, 0.12388238f, 0.18981329f, 
    -0.03072143f, 0.07831278f, -0.11208180f, -0.07257331f, -0.04857512f, -0.30447730f, -0.14538117f, -0.15214534f, 
    0.21477585f, -0.06263389f, -0.15947108f, 0.00359528f, -0.03980860f, 0.01742313f, -0.09169879f, -0.04361423f, 
    -0.01169620f, -0.01623128f, 0.08797244f, -0.01156167f, 0.04560088f, -0.13430335f, -0.03038890f, 0.07012820f, 
    -0.15440971f, 0.12937820f, 0.24054410f, 0.03980067f, 0.04528140f, -0.02177493f, -0.00699542f, 0.11857333f, 
    -0.02764138f, -0.12898584f, 0.21184897f, -0.19792441f, 0.11598668f, 0.02671111f, 0.11771718f, 0.05534403f, 
    0.05143826f, 0.12705395f, 0.00008498f, 0.00354533f, -0.17721307f, -0.20031168f, 0.09573839f, -0.17173418f, 
    0.13128978f, -0.00117801f, -0.09907766f, 0.00361919f, 0.20291388f, 0.02050223f, -0.15876251f, -0.12854296f, 
    0.06492216f, -0.28912887f, -0.19153956f, 0.00272869f, 0.03941655f, 0.05454521f, 0.19118579f, 0.06444283f, 
    -0.05703776f, 0.12058137f, 0.08462363f, 0.17889768f, 0.06275040f, -0.22223799f, 0.05393538f, 0.27280331f, 
    -0.06836961f, 0.02341740f, 0.01964557f, 0.12484931f, -0.09737287f, -0.08213922f, 0.05000748f, 0.19325082f, 
    0.19018731f, 0.07952341f, -0.02848496f, 0.02091638f, -0.22671749f, -0.08013270f, -0.05185166f, 0.00199936f, 
    -0.03595645f, 0.00146089f, 0.21240449f, 0.03272644f, 0.03453796f, -0.25614238f, -0.01045650f, 0.01735663f, 
    -0.22163665f, -0.08040371f, -0.03458240f, -0.00203536f, -0.03565008f, -0.12244791f, -0.05215176f, -0.12346340f, 
    0.20607793f, 0.36515263f, -0.08203106f, -0.15727800f, 0.13297468f, 0.06367315f, 0.14751069f, 0.19771069f, 
    -0.03341816f, 0.02996071f, 0.11217966f, -0.09572519f, -0.40200716f, 0.03840644f, -0.11753885f, -0.24509746f, 
    0.06216333f, -0.04487341f, 0.03359023f, 0.05223075f, 0.11887213f, -0.01201272f, 0.09354132f, -0.04719687f, 
    -0.00277530f, 0.13240096f, 0.02403880f, 0.34958035f, -0.00937131f, 0.05308139f, -0.09183668f, -0.00803684f, 
    0.27227417f, -0.06956483f, 0.11212981f, -0.00153538f, -0.03027266f, -0.36192983f, 0.21685331f, 0.07817172f, 
    -0.06991930f, -0.00455728f, -0.03137030f, 0.00347941f, -0.08791065f, -0.00944054f, 0.08551361f, 0.21120939f, 
    -0.44275436f, -0.35406861f, -0.00928257f, -0.30785871f, -0.18202819f, -0.09328680f, 0.05405300f, -0.08270202f, 
    0.22698465f, -0.12351794f, -0.06729741f, 0.06652611f, 0.17475170f, 0.23109366f, 0.10509086f, 0.04456117f, 
    0.07059442f, -0.08199570f, 0.11814377f, -0.07432202f, -0.11712211f, 0.12220653f, 0.01308178f, 0.11504317f, 
    0.09400191f, 0.24373643f, -0.00439867f, 0.04188431f, 0.21055940f, 0.00892223f, 0.02491940f, -0.01072884f, 
    -0.05776307f, 0.13191722f, -0.19447593f, 0.07818853f, -0.23232144f, -0.05018269f, 0.03643116f, 0.06695557f, 
    0.02342503f, -0.12041226f, 0.07170413f, 0.06239566f, -0.01060379f, 0.16819113f, 0.00897588f, 0.18851928f, 
    -0.20840287f, 0.15568304f, 0.12887056f, -0.17489241f, 0.00077674f, -0.12482793f, 0.10403147f, 0.11982217f, 
    -0.01347428f, 0.16682228f, -0.03223445f, 0.05738575f, 0.02369054f, 0.04565870f, 0.07245902f, -0.12337244f, 
    0.06543143f, -0.18434052f, -0.15231523f, -0.14365621f, 0.05508080f, 0.09873036f, -0.00064263f, -0.17622633f, 
    -0.09211742f, 0.27955380f, 0.36995918f, 0.04915529f, 0.07246825f, -0.02955179f, 0.02174739f, 0.10934903f, 
    0.01653249f, 0.02881494f, 0.09746905f, 0.05202049f, -0.19925928f, 0.03438577f, 0.11803369f, 0.23515508f, 
    0.06743856f, 0.00563915f, -0.01936125f, 0.06498586f, -0.00659020f, -0.15788919f, -0.02008543f, 0.14699164f, 
    -0.25042367f, -0.13309991f, 0.09428672f, 0.01461688f, -0.15366332f, -0.03577638f, -0.09689768f, -0.01183988f, 
    0.07925815f, 0.01055070f, -0.01797109f, -0.02569485f, -0.14017467f, -0.04753840f, -0.08524175f, -0.04113031f, 
    0.17258327f, -0.04520163f, 0.13464414f, -0.07006389f, 0.09071098f, -0.10246445f, -0.03369887f, -0.10087348f, 
    0.16360877f, 0.12731338f, -0.04417964f, 0.24069901f, 0.22762010f, 0.11178917f, -0.08503424f, 0.05718092f, 
    -0.02365573f, 0.09263626f, -0.24484949f, -0.03148082f, -0.29515159f, 0.13540179f, -0.04861849f, -0.10173502f, 
    0.18675560f, -0.07154569f, 0.05690664f, 0.15924726f, -0.15553947f, -0.02814549f, 0.07593133f, 0.04131620f, 
    -0.04397468f, 0.00169146f, 0.04406366f, 0.05850624f, -0.01386754f, 0.03390360f, -0.02087429f, 0.04207389f, 
    0.00303183f, 0.01176534f, -0.02656412f, 0.02977709f, 0.00915852f, 0.03389286f, -0.02299255f, -0.03227996f, 
    0.00503811f, 0.04227848f, -0.02072787f, 0.06409469f, 0.05033883f, 0.05606299f, -0.00975748f, 0.04532882f, 
    -0.02615678f, 0.01145987f, 0.00326561f, 0.03832441f, -0.03486348f, -0.00628407f, -0.08128177f, 0.00985053f, 
    0.02573743f, 0.06083383f, -0.01786813f, -0.00580217f, -0.04290939f, 0.04534103f, -0.02421884f, -0.01673459f, 
    -0.02322582f, -0.04458047f, -0.06062400f, -0.05152270f, -0.02307875f, 0.02467721f, 0.03245993f, 0.04563967f, 
    -0.00272794f, -0.07993324f, -0.01882373f, 0.01226141f, -0.04732839f, 0.02264069f, 0.00238181f, 0.01209161f, 
    0.01647795f, -0.03540903f, -0.06602977f, -0.07325236f, -0.03808905f, -0.06449289f, -0.01737644f, 0.05076940f, 
    -0.04713719f, 0.05578559f, 0.03102104f, 0.01657547f, -0.05308622f, 0.02641215f, 0.01706681f, -0.06437220f, 
    -0.06225370f, -0.06320060f, 0.03445588f, 0.03962003f, -0.03672487f, 0.00490242f, 0.03504491f, -0.07830003f, 
    -0.00159739f, -0.05818072f, -0.02416044f, -0.05448097f, 0.01116177f, -0.06804528f, -0.03267333f, -0.03961052f, 
    0.05358147f, 0.00043088f, -0.03454961f, 0.03435235f, -0.03334022f, -0.01495058f, 0.00335587f, 0.01725343f, 
    0.03678175f, 0.04876783f, 0.03359601f, -0.02462897f, -0.05447505f, -0.05501295f, 0.05500885f, -0.01271787f, 
    -0.03794742f, 0.03590166f, -0.00874545f, 0.06101872f, 0.02630864f, 0.03209324f, -0.04845802f, -0.07352408f, 
    0.01767049f, -0.00809043f, -0.03811139f, 0.04830328f, -0.04512629f, -0.03964148f, 0.05415073f, 0.02537766f, 
    -0.06641667f, -0.04918538f, -0.01243696f, -0.07433768f, -0.01418787f, 0.01945800f, -0.02256347f, -0.05583259f, 
    -0.06805409f, -0.03561734f, -0.05128062f, -0.00521622f, -0.05119762f, -0.03484264f, -0.01702439f, 0.00218301f, 
    -0.06475281f, 0.04838392f, -0.00277420f, -0.00799018f, -0.00513398f, 0.00696545f, -0.02277522f, -0.01680245f, 
    -0.07292935f, 0.03756628f, -0.03316879f, -0.05180166f, -0.04168710f, -0.00755865f, 0.01265995f, -0.04972102f, 
    0.03701123f, 0.04479766f, 0.05571530f, -0.07616723f, -0.01354494f, -0.04879012f, -0.02747249f, -0.01171638f, 
    -0.02724362f, 0.03333078f, -0.04318948f, -0.07167925f, 0.05676194f, -0.02360922f, 0.03077480f, 0.01649765f, 
    0.03589936f, 0.06300855f, -0.03480384f, 0.05743057f, 0.06360315f, -0.07508945f, 0.01585906f, 0.02444842f, 
    -0.05669894f, -0.05968377f, -0.00491719f, -0.00820003f, -0.07483166f, -0.02228845f, -0.07157207f, 0.00228928f, 
    -0.06672902f, 0.01832876f, 0.02951329f, -0.03882091f, 0.04162498f, 0.04693948f, -0.03986654f, 0.04292659f, 
    -0.37235343f, 0.31885359f, -0.04008909f, -0.19449857f, -0.03685197f, -0.07635772f, -0.01228925f, 0.10124803f, 
    0.01252293f, 0.08488172f, -0.01329859f, 0.04992772f, 0.49018088f, -0.26222548f, -0.13141549f, -0.01641294f, 
    -0.00659928f, 0.01418926f, -0.02087767f, -0.02411400f, 0.02734848f, 0.11996752f, 0.04708354f, -0.10242708f, 
    -0.23394828f, 0.19444278f, -0.18375547f, 0.10040810f, 0.07409046f, 0.03437916f, 0.03809011f, 0.08960170f, 
    0.12474434f, 0.17005956f, 0.09637487f, -0.05979292f, -0.09776936f, -0.09168530f, 0.39900437f, 0.19488283f, 
    0.13347071f, 0.16996570f, -0.01026579f, -0.01633815f, 0.07487591f, 0.00343403f, 0.02659191f, 0.00033638f, 
    -0.18007952f, 0.22729422f, 0.38360900f, -0.20047754f, 0.08141377f, -0.02772345f, 0.02614671f, -0.09847908f, 
    0.06599706f, -0.11128807f, -0.00766218f, 0.14352615f, 0.17892754f, -0.11713926f, 0.06245117f, 0.01997446f, 
    0.04198577f, -0.03021386f, 0.04111819f, 0.01509016f, -0.03922245f, 0.14698350f, -0.01678691f, 0.14485347f, 
    0.26483339f, -0.43754247f, 0.18810122f, -0.09475928f, 0.06952694f, 0.05630292f, 0.10694726f, 0.01289647f, 
    0.01172705f, -0.03388164f, 0.12230977f, 0.15395249f, -0.40756917f, 0.26936004f, 0.12951639f, -0.14240175f, 
    -0.10585313f, 0.10333524f, -0.10087451f, 0.01464653f, 0.07718489f, 0.03583396f, 0.07719431f, 0.02703819f, 
    0.24758396f, -0.11399881f, 0.07053223f, -0.29663005f, 0.12115087f, 0.05975585f, -0.03402694f, 0.09291680f, 
    -0.05820215f, 0.16183187f, 0.01653877f, -0.03638739f, -0.12622923f, 0.12091707f, 0.23516169f, -0.21013455f, 
    -0.17367141f, 0.04879560f, 0.01388589f, -0.00122214f, -0.01249949f, 0.00348805f, -0.00582685f, -0.01938608f, 
    0.19229232f, -0.10340482f, 0.23410562f, -0.41431397f, 0.12566841f, -0.04574186f, -0.01380612f, 0.05222392f, 
    0.04201561f, 0.06429984f, -0.11557573f, 0.05530653f, -0.27949065f, -0.05687522f, -0.02515695f, 0.04759122f, 
    0.07459683f, 0.13284138f, -0.11115444f, 0.02003878f, -0.10376283f, 0.05698635f, 0.04577388f, 0.14174090f, 
    -0.06767599f, 0.03381520f, 0.14360924f, -0.07182208f, -0.05814109f, 0.03929672f, 0.01946927f, -0.03812835f, 
    -0.07024945f, 0.07878882f, -0.06600120f, -0.21259072f, 0.02093387f, -0.34874055f, 0.07671993f, 0.08709262f, 
    0.02149371f, -0.00201124f, -0.01846273f, -0.07525525f, 0.05749940f, 0.03609558f, 0.22976695f, -0.02056026f, 
    -0.12821230f, 0.17655902f, -0.06452800f, 0.26493388f, 0.13389786f, 0.19322416f, -0.14485930f, 0.03442214f, 
    0.13374394f, 0.12012666f, -0.04849707f, 0.02345591f, 0.32953995f, -0.23341560f, 0.01355164f, -0.08784375f, 
    0.04017337f, -0.11637474f, -0.13853940f, 0.11858507f, -0.03230295f, 0.03055480f, -0.01636188f, 0.07822544f, 
    0.44777626f, 0.18795522f, 0.18623069f, -0.28861549f, 0.00532363f, 0.03547926f, 0.06613634f, 0.09777735f, 
    -0.04069024f, 0.01706818f, 0.04660581f, -0.00285410f, -0.24770014f, 0.07118004f, -0.12030793f, -0.15656036f, 
    0.19112785f, 0.01591106f, 0.10730098f, 0.00689271f, -0.06184591f, -0.05307100f, 0.00466597f, 0.05621680f, 
    -0.11746316f, -0.03830180f, -0.30685925f, 0.25581881f, 0.08678155f, 0.01045313f, -0.10992705f, -0.05604795f, 
    0.04403608f, -0.04781761f, -0.11007253f, -0.07180805f, 0.23771705f, -0.04989178f, -0.11426654f, -0.10941489f, 
    0.14854656f, 0.04026971f, 0.11354013f, -0.08969934f, 0.06820690f, 0.12526415f, 0.11654069f, 0.02582590f, 
    0.18393452f, -0.07641222f, -0.06990157f, -0.04199108f, -0.02000256f, -0.08251555f, -0.01292545f, 0.10893961f, 
    0.19883639f, 0.06541605f, 0.09277585f, 0.07404555f, -0.19100291f, 0.11769179f, 0.13940519f, 0.25382498f, 
    0.00044371f, -0.12293448f, 0.03098761f, 0.00490986f, -0.20500830f, 0.10001386f, -0.18396367f, 0.04152576f, 
    -0.31608760f, 0.31032512f, 0.06961681f, 0.12153450f, 0.23503284f, 0.00184332f, -0.03242502f, 0.09085172f, 
    0.00279604f, 0.09260714f, -0.05242025f, 0.05657443f, 0.15472141f, -0.13650860f, -0.10902908f, 0.42706519f, 
    0.11109485f, 0.01226626f, -0.05463357f, -0.10795602f, 0.06072376f, -0.27958363f, -0.05553320f, -0.08176092f, 
    -0.18038432f, 0.12973090f, -0.05985139f, -0.34991947f, -0.21643072f, 0.12261000f, 0.16878179f, 0.06708182f, 
    0.02785284f, 0.10254471f, -0.01348157f, 0.06652517f, 0.26232389f, 0.08116338f, -0.19680299f, -0.02467237f, 
    0.02292277f, -0.03683449f, 0.05705022f, -0.18987192f, 0.06516545f, 0.06938628f, 0.03367400f, -0.10968215f, 
    -0.27646911f, -0.09324249f, 0.27560529f, -0.03834804f, 0.04585141f, -0.00325819f, -0.05891182f, 0.12625396f, 
    0.04122982f, 0.04372553f, -0.11691067f, -0.02568303f, 0.06670538f, -0.17040174f, 0.02605872f, 0.46364123f, 
    0.10513575f, -0.00867893f, 0.08900427f, 0.06802951f, -0.07417616f, 0.02590843f, 0.04488545f, 0.12228043f, 
    -0.13101462f, 0.10651804f, -0.10390650f, -0.15192847f, -0.10348097f, 0.02727722f, 0.11218905f, -0.06941830f, 
    -0.04623522f, -0.00778032f, -0.11588234f, 0.01618672f, -0.58056152f, 0.13265769f, -0.01211630f, 0.06947646f, 
    -0.02535844f, -0.04152501f, 0.06994320f, -0.14320435f, 0.00685768f, 0.00484822f, 0.12680502f, -0.11665163f, 
    -0.04821853f, 0.12763339f, -0.13062893f, 0.39551184f, -0.05388521f, -0.03961261f, -0.02096205f, 0.07742991f, 
    0.01254492f, 0.07565197f, -0.03968776f, -0.10021329f, -0.02702363f, 0.15878333f, 0.15385433f, -0.12310187f, 
    0.08242053f, 0.01015005f, 0.00376345f, 0.05168005f, -0.10111127f, 0.15689759f, 0.12029019f, 0.04485402f, 
    -0.32782337f, -0.01012460f, 0.07687143f, 0.12010403f, 0.10214104f, -0.10214927f, -0.11865326f, -0.09356214f, 
    -0.06660212f, 0.05604814f, -0.06370817f, -0.02478162f, 0.33614740f, -0.02904487f, 0.11492277f, 0.06001959f, 
    -0.08529880f, 0.06020344f, -0.09535918f, -0.04151246f, -0.13460977f, 0.00416843f, 0.11129804f, 0.10240491f, 
    -0.35599023f, 0.34698230f, 0.53548193f, 0.03357808f, 0.05181210f, 0.10330486f, -0.05206297f, -0.02037088f, 
    0.13030924f, 0.08764569f, 0.09454851f, -0.01094608f, 0.21855208f, -0.04275580f, -0.08102388f, 0.08036930f, 
    -0.12891737f, 0.19139655f, -0.00846065f, 0.05946970f, -0.20065460f, -0.03434160f, -0.04641505f, -0.01359233f, 
    0.08103151f, 0.01218325f, -0.02841237f, 0.22771725f, 0.12511975f, -0.14427637f, -0.06240309f, -0.09159416f, 
    -0.17091671f, -0.13335218f, -0.04287113f, -0.06679300f, 0.21931255f, -0.34245193f, 0.00841645f, -0.18595839f, 
    0.05690550f, -0.01438414f, -0.12345999f, -0.16179693f, -0.07057108f, -0.00977060f, 0.27747402f, 0.11468548f, 
    0.51299870f, -0.18745393f, -0.08535670f, 0.04395933f, -0.01993617f, 0.13822468f, 0.01098907f, 0.04878479f, 
    -0.02638439f, -0.01683882f, -0.12386247f, -0.18289390f, -0.06812307f, -0.03831173f, -0.00778117f, -0.00003393f, 
    0.18709826f, 0.02813498f, -0.00176228f, -0.14763898f, -0.13376229f, 0.23128811f, 0.18353890f, 0.13104357f, 
    0.07852471f, -0.18022588f, 0.02884010f, 0.07218321f, 0.04694121f, -0.12318400f, 0.00929821f, -0.21729890f, 
    0.01307517f, 0.06270269f, -0.04226593f, -0.01121666f, 0.14018637f, 0.10726153f, 0.14984144f, -0.14045539f, 
    0.04522602f, -0.01160617f, -0.15873913f, 0.19887903f, -0.06767304f, 0.03046776f, -0.05052561f, 0.06057394f, 
    0.32559052f, 0.02559456f, -0.34017968f, -0.02837599f, -0.20072322f, 0.04323056f, -0.05126004f, 0.00980794f, 
    0.07258043f, -0.00876275f, 0.02836360f, 0.02814568f, 0.19319823f, 0.19791050f, -0.12202191f, -0.13188335f, 
    0.00430053f, 0.05095135f, 0.16705576f, -0.13743238f, -0.05928338f, 0.00745554f, 0.05165182f, -0.07946625f, 
    0.31063598f, -0.02538048f, 0.13110526f, -0.00427028f, -0.12520882f, -0.31879905f, -0.03447726f, 0.15097439f, 
    0.11511911f, -0.02162303f, 0.03363196f, 0.05909159f, 0.44893122f, 0.01268125f, 0.19028480f, 0.06466196f, 
    -0.03095393f, -0.07962381f, -0.18631485f, -0.00512388f, 0.21151300f, 0.02762484f, -0.07974490f, 0.09316039f, 
    -0.13420339f, -0.07358332f, 0.29967678f, 0.02609695f, 0.09174160f, 0.05906333f, -0.06259418f, -0.01441696f, 
    0.08419938f, 0.04695441f, -0.16015139f, 0.14157094f, 0.27139789f, 0.05617221f, 0.04086082f, 0.15977211f, 
    0.03460575f, 0.02564590f, -0.08289965f, 0.05972416f, 0.01972727f, -0.01081084f, 0.06378689f, 0.03271046f, 
    -0.19983277f, 0.25865230f, -0.22909883f, 0.19487807f, 0.06440990f, 0.03887399f, 0.00996013f, 0.03140273f, 
    0.06407521f, 0.04860195f, 0.13562205f, -0.15463945f, -0.05832268f, 0.13759419f, 0.11826517f, -0.06297041f, 
    0.03553486f, 0.01513996f, -0.10640305f, -0.02990783f, -0.05204906f, 0.03937541f, 0.03664505f, 0.09502954f, 
    0.28840199f, 0.02192796f, 0.35807753f, 0.03931556f, -0.06926290f, 0.07887112f, 0.19410060f, -0.01007530f, 
    -0.02331005f, -0.07983048f, 0.04119264f, 0.04507437f, -0.13920721f, -0.32321286f, -0.12122761f, -0.15526465f, 
    -0.01825421f, -0.18439671f, 0.16431679f, 0.06296849f, 0.02200323f, -0.07265341f, -0.09485928f, 0.02461354f, 
    -0.20422544f, -0.10774776f, -0.16647790f, 0.08915466f, -0.17948812f, 0.13674493f, -0.03334174f, -0.00725715f, 
    -0.00811899f, -0.10653855f, -0.20552637f, 0.07106198f, 0.08811426f, -0.02797795f, 0.04668240f, -0.11611241f, 
    0.09608421f, 0.00530745f, -0.07879046f, -0.00655339f, 0.04252474f, 0.01037172f, 0.18837580f, -0.06365682f, 
    0.33181927f, -0.01376710f, 0.10236200f, 0.10088561f, -0.05908787f, 0.15347934f, 0.00970550f, 0.03047289f, 
    0.00373572f, 0.03967370f, -0.19027014f, -0.10935508f, -0.16416565f, 0.04146660f, -0.06637192f, -0.03031266f, 
    0.00803898f, -0.10638134f, 0.04395006f, 0.02688666f, -0.11335967f, 0.10475359f, 0.01369403f, 0.03356819f, 
    -0.05067698f, 0.02367298f, -0.04067040f, 0.39909673f, 0.16768906f, -0.12143371f, -0.01327365f, -0.10064948f, 
    0.09199054f, -0.04079251f, 0.03318029f, 0.02539940f, -0.02452107f, -0.13213342f, -0.05144205f, 0.08186509f, 
    0.03343786f, 0.14733912f, -0.03143609f, 0.07365510f, -0.04387995f, 0.05691852f, -0.09416861f, 0.10022564f, 
    0.33601159f, 0.25086814f, -0.22107047f, 0.35424760f, -0.13900550f, 0.11640105f, 0.03152866f, -0.17250338f, 
    0.00688949f, 0.02130461f, 0.20679697f, -0.06653097f, -0.12770246f, 0.16458730f, 0.11207158f, -0.15020773f, 
    0.02227191f, 0.01624773f, -0.06074954f, -0.02938546f, 0.01373765f, -0.06800450f, -0.02427032f, -0.11624613f, 
    0.12067615f, -0.13874306f, 0.22283083f, 0.11162031f, -0.01477949f, -0.02764440f, -0.16058728f, -0.12898512f, 
    0.05151642f, 0.07925710f, 0.13662535f, 0.17523851f, 0.19063480f, 0.35928074f, -0.05257822f, -0.14357604f, 
    0.18256703f, 0.07262529f, -0.02500580f, 0.15480068f, -0.08391473f, 0.14286053f, -0.02581072f, 0.08159158f, 
    0.39648172f, -0.11276396f, 0.17110896f, -0.11085255f, 0.01622668f, -0.01021701f, 0.13857535f, 0.08502768f, 
    -0.13722442f, 0.05164730f, -0.11173705f, -0.01956529f, -0.14669169f, 0.33003250f, 0.04836803f, 0.10937122f, 
    0.04778295f, -0.04676106f, 0.14482413f, -0.05092863f, 0.01825175f, -0.11973042f, -0.01005583f, 0.00374355f, 
    -0.17690676f, -0.27946794f, -0.38566795f, 0.02065797f, 0.12957372f, -0.00923744f, -0.05753789f, 0.13616718f, 
    0.06192531f, 0.05019943f, -0.05660301f, -0.03209766f, 0.35586733f, 0.03647454f, -0.26475200f, 0.02944753f, 
    0.00615548f, 0.08969642f, 0.11684565f, 0.01512195f, 0.07123729f, 0.14483945f, 0.11312938f, -0.20102020f, 
    -0.10529158f, 0.10236239f, -0.17080635f, -0.15420373f, 0.11139358f, 0.00163128f, 0.05462341f, 0.11531926f, 
    -0.01890674f, 0.03995414f, 0.03750484f, 0.14366020f, -0.35065606f, 0.07299028f, 0.33504263f, 0.15735677f, 
    0.15935840f, 0.09963772f, -0.05224371f, 0.03231679f, 0.13915032f, 0.06847987f, 0.00112360f, 0.11420799f, 
    0.01405136f, 0.07403459f, 0.22187778f, -0.10138970f, 0.15104502f, 0.05450179f, 0.04098531f, -0.04201636f, 
    0.05733630f, -0.00968430f, 0.10777336f, 0.03554373f, 0.27736780f, 0.12064807f, -0.15154582f, -0.09887774f, 
    -0.09472518f, 0.05148529f, 0.09201599f, 0.06705514f, 0.06746069f, -0.05566905f, 0.04920950f, -0.09074365f, 
    0.10891893f, -0.09943781f, -0.10666242f, -0.16904522f, -0.04301742f, -0.05931725f, 0.16202366f, -0.08316555f, 
    0.06755301f, -0.00374106f, 0.02660993f, 0.11168664f, -0.20375457f, 0.02383251f, 0.17885931f, 0.02212387f, 
    -0.01667324f, 0.02020298f, 0.11318642f, 0.07505089f, 0.11476231f, 0.07266393f, 0.11304430f, -0.10907255f, 
    0.42254841f, 0.01349074f, -0.22769976f, -0.17174409f, 0.02359290f, 0.00343418f, -0.26813740f, 0.07137302f, 
    0.04076793f, 0.03548682f, 0.02364640f, 0.06820821f, -0.36482522f, -0.10667320f, 0.09314026f, -0.01130863f, 
    -0.01950935f, -0.21337478f, 0.02701231f, 0.15112877f, 0.05871865f, -0.06006060f, 0.02718426f, 0.09323201f, 
    -0.36790481f, 0.09108254f, 0.12484768f, -0.19737130f, 0.11426315f, 0.07781980f, 0.00585328f, -0.00946840f, 
    0.02849214f, 0.14700949f, 0.08455095f, 0.10879847f, -0.22275287f, 0.12358965f, -0.01832652f, -0.28422150f, 
    0.11894253f, 0.10070860f, -0.07913798f, -0.03275760f, 0.17116289f, -0.01952272f, 0.00869990f, 0.00400688f, 
    0.09062755f, -0.17867222f, -0.22532098f, 0.25507614f, 0.11673810f, -0.06594853f, 0.11455493f, -0.02087462f, 
    -0.00240529f, -0.05828138f, -0.03578663f, -0.00239894f, 0.37130868f, -0.49527994f, -0.07793047f, 0.22208340f, 
    0.01544555f, -0.12695542f, -0.03665650f, 0.10349450f, 0.10913406f, -0.13700721f, -0.03241704f, 0.16821802f, 
    -0.03035195f, 0.06423412f, 0.06529791f, -0.01661301f, 0.03166638f, 0.05024372f, -0.02959337f, 0.08580708f, 
    0.05089148f, 0.04815900f, -0.01998015f, 0.07949968f, 0.12841496f, -0.09950133f, -0.07057806f, 0.05858369f, 
    0.01115676f, -0.07294036f, -0.14521605f, 0.15635341f, -0.00250793f, 0.00755808f, 0.18892065f, -0.06879459f, 
    -0.03797098f, -0.05362752f, -0.02486318f, 0.04906134f, -0.08154959f, 0.02011367f, 0.02353898f, -0.01423401f, 
    -0.07993659f, 0.03539968f, -0.00562346f, -0.05549975f, 0.02530753f, -0.00328678f, -0.04588443f, -0.01696103f, 
    -0.04923309f, 0.03344543f, -0.01469600f, -0.01094182f, 0.03905162f, 0.01366755f, -0.02454358f, -0.07107820f, 
    0.02754618f, -0.03836143f, 0.02265126f, 0.02938703f, -0.03555229f, 0.06132197f, -0.05019160f, -0.01612465f, 
    -0.03922676f, 0.05408442f, -0.00023080f, -0.03298500f, 0.02587157f, 0.00516715f, 0.00140383f, 0.03332307f, 
    -0.03948021f, -0.02083809f, 0.05072500f, -0.06962406f, 0.02097095f, -0.07135278f, 0.01313860f, 0.00568645f, 
    0.00091410f, 0.00303079f, 0.05710311f, 0.03745587f, 0.04464502f, 0.03076293f, 0.03780377f, 0.06172597f, 
    -0.04701128f, 0.05817020f, -0.06801659f, 0.02155541f, 0.00959197f, 0.05464505f, -0.06144320f, 0.04085205f, 
    -0.05734070f, 0.02764886f, -0.02932865f, 0.05521360f, -0.07587186f, 0.03616270f, -0.06756230f, 0.06019541f, 
    0.04559590f, -0.05803870f, 0.04679715f, -0.03211832f, -0.05081839f, -0.01724347f, -0.02584962f, -0.03988463f, 
    0.05929177f, 0.03764196f, -0.03690535f, 0.01252686f, 0.03070051f, -0.00124027f, -0.02557957f, 0.00645198f, 
    -0.05146306f, 0.03068309f, -0.07502062f, -0.00970898f, -0.07422528f, -0.03236489f, -0.02676958f, 0.03515372f, 
    -0.06106644f, -0.02658810f, -0.03061504f, 0.00028534f, -0.03300811f, -0.04908519f, -0.07371434f, -0.00894567f, 
    -0.03741804f, -0.02469910f, 0.04094581f, 0.05891432f, -0.02021652f, 0.05046249f, -0.02382448f, -0.04315780f, 
    -0.05490427f, 0.00507412f, -0.03040420f, -0.01171397f, -0.05668044f, -0.01108095f, -0.04258509f, 0.06218552f, 
    -0.04578412f, 0.05653379f, 0.02256178f, -0.00069943f, 0.05968300f, -0.02742876f, 0.01910078f, 0.00575771f, 
    0.00567888f, -0.04541031f, -0.05406829f, -0.03703443f, -0.07655615f, -0.02067896f, -0.05284835f, -0.03518579f, 
    -0.05189217f, 0.00095439f, -0.06298522f, 0.04792293f, -0.05665426f, 0.04000386f, 0.06033413f, 0.00774452f, 
    -0.06164045f, -0.07746545f, 0.04425703f, 0.01267830f, 0.00533776f, 0.01735339f, -0.03193413f, -0.07707696f, 
    -0.00155452f, 0.03496655f, -0.06310773f, 0.05351053f, 0.00662314f, 0.00360418f, -0.03574788f, -0.00664788f, 
    -0.05127581f, 0.02078840f, 0.01076066f, -0.03703741f, -0.03963302f, 0.03519124f, 0.01834316f, 0.05177271f, 
    0.02657347f, -0.02198017f, -0.04383055f, 0.04905033f, -0.06056352f, -0.07561933f, -0.06308744f, -0.05819289f, 
    -0.02570606f, -0.02057405f, -0.04410396f, -0.04613924f, -0.06306533f, -0.03077351f, 0.06166182f, 0.00104905f, 
    0.02808804f, 0.03350660f, 0.04428192f, -0.00784488f, 0.02515682f, -0.03821761f, -0.01353428f, 0.02992527f, 
    0.02101450f, 0.13572864f, -0.32571176f, 0.03405242f, 0.15516675f, 0.07299402f, 0.07579814f, 0.12705912f, 
    -0.13125554f, 0.05766438f, 0.03957874f, -0.14136341f, 0.33196712f, 0.00326653f, -0.18904576f, -0.06094160f, 
    0.06287432f, 0.04115238f, -0.09423221f, -0.03806832f, 0.11412545f, 0.12456801f, -0.04103819f, 0.20386463f, 
    0.28606874f, 0.25650251f, -0.03043373f, 0.13092603f, 0.04534232f, 0.00615743f, 0.10285437f, 0.09772754f, 
    -0.06079995f, -0.07156344f, -0.11885833f, 0.11359806f, -0.48056474f, -0.29265568f, 0.20808569f, -0.21135843f, 
    0.08457627f, 0.10589566f, 0.04919942f, -0.01907696f, 0.13688633f, 0.01603497f, -0.04423377f, 0.18783791f, 
    -0.38914290f, -0.06778304f, -0.00504127f, -0.31555271f, -0.03888585f, 0.14194967f, -0.06544811f, 0.08794809f, 
    -0.00829994f, 0.01638988f, -0.08604465f, 0.11974139f, 0.27333125f, 0.28023919f, -0.06601042f, 0.02019894f, 
    -0.02322215f, 0.02412328f, 0.01503561f, 0.05185416f, 0.01590678f, -0.01995378f, -0.08077119f, -0.14458688f, 
    0.50765091f, 0.19577284f, 0.20779817f, 0.04816615f, -0.03307080f, -0.00682293f, 0.17667727f, 0.10257783f, 
    -0.06126020f, 0.07579274f, 0.11071721f, 0.25276244f, -0.44541714f, -0.11470661f, -0.04220245f, -0.21097231f, 
    0.05363345f, -0.04319244f, 0.10030603f, -0.01063255f, -0.03328684f, -0.13862878f, 0.02375782f, -0.18681529f, 
    0.06174218f, -0.11141933f, -0.11881022f, 0.04097814f, 0.01781018f, -0.01091442f, -0.15909573f, 0.00056590f, 
    0.07448178f, 0.06715894f, 0.03541293f, 0.20899387f, -0.27839831f, -0.08762082f, -0.05998673f, 0.05825123f, 
    -0.03152784f, 0.04871693f, 0.27659494f, -0.06381778f, -0.00190644f, -0.13180546f, -0.08431450f, 0.07587726f, 
    0.18491925f, 0.21073279f, 0.08484400f, -0.14059915f, 0.06788591f, 0.11168395f, 0.03522691f, 0.14502823f, 
    -0.08592147f, 0.13512833f, 0.03903634f, -0.00185759f, -0.41210333f, -0.15398224f, -0.01931195f, -0.28446922f, 
    0.24470614f, 0.15199387f, -0.10863948f, 0.13195832f, 0.07237824f, -0.14986318f, 0.03717577f, -0.03952478f, 
    0.01075882f, -0.33804372f, -0.06706416f, 0.21965009f, 0.12594195f, 0.13017476f, 0.12149920f, -0.06788538f, 
    -0.14640442f, 0.12824860f, 0.09112864f, 0.01032122f, -0.00465076f, -0.25994506f, -0.00641341f, 0.22358529f, 
    -0.03908624f, -0.11712965f, -0.06023389f, 0.14596629f, -0.01345341f, 0.08007134f, 0.17217261f, 0.03286272f, 
    0.43351585f, 0.13638104f, 0.22003265f, 0.29635540f, -0.01206391f, 0.11636631f, 0.03588897f, 0.06590366f, 
    -0.08566212f, 0.10287184f, 0.10008415f, 0.05019457f, 0.07307762f, 0.02029933f, -0.07242525f, 0.01384147f, 
    0.04600486f, -0.13357188f, -0.14441641f, 0.03598614f, 0.02710225f, 0.15871586f, -0.21409966f, -0.02615877f, 
    0.04678448f, -0.03571880f, 0.04199526f, -0.05317047f, 0.01803002f, -0.03582836f, 0.03120627f, 0.02551531f, 
    -0.04368358f, -0.03243736f, 0.00911808f, -0.06426596f, -0.03782989f, -0.01847867f, -0.05530198f, 0.03875429f, 
    0.03743901f, 0.03765292f, -0.03446507f, -0.02447751f, 0.01746474f, 0.04328201f, 0.03651438f, -0.02213319f, 
    0.04133065f, -0.05984958f, -0.04492997f, 0.03230172f, -0.07165260f, -0.07926413f, -0.00632351f, -0.03072605f, 
    -0.00377611f, -0.07082263f, -0.01335232f, 0.03565576f, 0.01966230f, 0.03619091f, 0.05096451f, 0.00044038f, 
    0.03064240f, -0.07608019f, -0.06181248f, -0.06588256f, 0.03965555f, 0.01954540f, -0.00411431f, -0.00431275f, 
    -0.05670280f, 0.02792477f, 0.03357457f, -0.04068597f, 0.05532971f, 0.04621998f, 0.00315199f, 0.02819926f, 
    -0.06982998f, -0.05455558f, 0.02412408f, 0.02823729f, 0.04781903f, 0.03719176f, -0.04686238f, -0.04650009f, 
    0.00620994f, -0.01197481f, 0.04474616f, 0.05039015f, -0.00481242f, -0.01182177f, 0.04641459f, -0.00359604f, 
    0.04423311f, 0.01201218f, -0.03791907f, 0.02801599f, -0.07322745f, 0.01699549f, -0.04096891f, -0.01182059f, 
    -0.05907258f, -0.03702819f, 0.04976095f, 0.04789494f, 0.01698386f, 0.01334333f, 0.03206493f, 0.01840769f, 
    -0.06880686f, 0.02880975f, 0.03963296f, -0.06243827f, 0.01319000f, 0.04040077f, -0.06091783f, 0.03347871f, 
    0.03325166f, 0.02744882f, -0.03539194f, -0.04271092f, -0.03321281f, 0.03008560f, -0.06201099f, -0.06443901f, 
    0.05131771f, -0.08121807f, -0.00434020f, -0.01599644f, -0.08268762f, 0.05841698f, -0.04268813f, -0.05886362f, 
    -0.02869774f, 0.01744464f, -0.01343298f, -0.07049857f, -0.06493568f, -0.08740444f, 0.04301717f, -0.06743939f, 
    0.02167029f, -0.01553017f, -0.02112452f, -0.05369816f, 0.00949415f, 0.04907788f, 0.06269488f, -0.06534500f, 
    -0.04639051f, -0.00051581f, -0.00171619f, 0.01002320f, 0.02498589f, -0.05449842f, 0.00125360f, -0.05323603f, 
    -0.04166696f, -0.02173419f, -0.03427882f, -0.04737642f, 0.04475072f, -0.05265302f, -0.03076128f, -0.04139765f, 
    -0.02179388f, -0.01547640f, -0.04225932f, 0.02585608f, 0.04376408f, -0.03859190f, 0.06350314f, 0.01162251f, 
    -0.05090207f, -0.00698900f, -0.04923541f, -0.00806440f, -0.02997304f, -0.06151133f, -0.07153397f, -0.06484441f, 
    0.02951961f, -0.04414994f, -0.01984793f, 0.06106987f, -0.06991359f, 0.00463186f, -0.08046940f, 0.05347752f, 
    0.01032827f, -0.02199468f, 0.03318265f, -0.02189893f, 0.00497103f, 0.05386244f, 0.01834653f, 0.04104254f, 
    -0.05565410f, 0.02880446f, 0.03546491f, -0.02557967f, -0.07493023f, -0.06373926f, 0.07255007f, 0.07191556f, 
    -0.07625890f, -0.02291347f, 0.02133105f, 0.04800674f, -0.02269180f, 0.01524189f, -0.05515103f, 0.06398423f, 
    0.02866977f, -0.00391086f, -0.09783038f, 0.02523923f, -0.02457925f, 0.00106497f, -0.05898533f, 0.02948286f, 
    -0.06124313f, -0.04334972f, -0.05374677f, -0.03784763f, -0.02888314f, -0.00973434f, 0.02679409f, -0.09687739f, 
    -0.07379077f, 0.04936513f, -0.04093855f, -0.04619555f, -0.08446232f, 0.03426395f, -0.02893486f, 0.01505057f, 
    0.02106835f, -0.03800300f, -0.06386258f, -0.02805602f, 0.00811010f, -0.09179892f, 0.02904442f, -0.09000372f, 
    -0.00263799f, -0.03063421f, -0.04520984f, 0.05804303f, 0.04157133f, -0.08261973f, -0.07081825f, -0.01612472f, 
    0.03512389f, -0.07843948f, 0.03010050f, -0.03812997f, -0.01206052f, 0.02642746f, 0.00091922f, -0.06031550f, 
    -0.04123168f, 0.05931060f, -0.01656191f, -0.01079203f, -0.05645189f, -0.05100650f, -0.08043645f, -0.05586352f, 
    -0.04726074f, 0.01426929f, 0.03181152f, -0.02185764f, -0.08694196f, 0.03436195f, -0.09823970f, 0.02257544f, 
    -0.10588156f, 0.05495064f, 0.03902858f, 0.01032352f, -0.06201142f, -0.07858127f, 0.04119937f, -0.05684533f, 
    -0.00433916f, -0.05082619f, 0.00274972f, 0.01539304f, -0.05625924f, -0.08824825f, 0.00814632f, 0.02736394f, 
    -0.07463231f, 0.01158141f, 0.01422984f, -0.06588080f, -0.07525226f, -0.04760722f, -0.08742540f, -0.00316622f, 
    -0.07524107f, -0.01461025f, 0.01384147f, 0.04312551f, -0.03342019f, -0.03455676f, -0.06408525f, -0.03967836f, 
    -0.08949576f, 0.01457378f, 0.02667123f, -0.06900671f, -0.00749562f, 0.04949936f, -0.00324410f, -0.01984403f, 
    -0.05199406f, -0.03533110f, -0.02953350f, -0.01393493f, -0.07598568f, 0.00743136f, -0.05392912f, 0.06808756f, 
    -0.00745559f, -0.03985834f, 0.02758095f, 0.04602583f, -0.06014708f, -0.03573828f, -0.05696160f, 0.02409156f, 
    -0.02363110f, 0.03368458f, -0.01709700f, -0.05059918f, -0.07175620f, -0.05114093f, 0.03919416f, -0.00790838f, 
    0.03673491f, -0.01595885f, 0.00186554f, 0.01236650f, -0.02922390f, -0.08503451f, -0.05201922f, 0.03672421f, 
    -0.05502736f, 0.03590327f, 0.04227461f, -0.02481877f, -0.02153712f, -0.07367377f, -0.04367691f, -0.09301296f, 
    -0.05672884f, -0.06457908f, -0.07964167f, -0.07977413f, 0.03380462f, 0.00442071f, -0.04473799f, -0.06064747f, 
    0.02613648f, -0.02504372f, -0.05334109f, -0.08905677f, 0.03051588f, -0.02192278f, -0.04900558f, 0.03566858f, 
    -0.06840906f, -0.02673664f, -0.05870074f, -0.08785535f, 0.02452490f, -0.07675163f, -0.04724924f, 0.00984704f, 
    -0.06062398f, -0.01632093f, 0.02011652f, -0.07448959f, -0.06574454f, -0.02438768f, -0.00195902f, -0.07687569f, 
    -0.01167095f, -0.03435261f, -0.00720120f, -0.05466984f, -0.06469338f, 0.04003494f, 0.04342365f, 0.03529315f, 
    -0.02309110f, -0.07952838f, 0.02106481f, -0.08961823f, -0.05337948f, 0.03348343f, -0.08821239f, 0.00273879f, 
    0.46345839f, 0.09303176f, 0.03866239f, 0.04479245f, -0.00902147f, 0.04195350f, 0.06250179f, 0.08132798f, 
    -0.02457775f, -0.13565670f, -0.04139085f, 0.06616760f, 0.03187105f, -0.16754606f, 0.00659631f, -0.11178903f, 
    0.10401171f, -0.05052922f, 0.04104727f, 0.03886176f, 0.03603386f, -0.08133251f, 0.09484473f, 0.10699223f, 
    -0.23665695f, 0.34996384f, -0.20293514f, 0.41203156f, 0.10025594f, 0.13064234f, -0.09840479f, -0.05551286f, 
    0.13719240f, 0.07026779f, -0.02628472f, 0.07749984f, 0.01774172f, -0.18554758f, 0.11870334f, -0.06450519f, 
    0.13599540f, 0.23041274f, 0.00877138f, -0.07617781f, 0.04230044f, 0.22336170f, 0.09233689f, 0.08604379f, 
    -0.46532166f, -0.13593595f, -0.09654063f, -0.47100666f, 0.13627823f, -0.00857549f, 0.00952561f, 0.05097534f, 
    0.09529605f, -0.03768265f, -0.01247791f, 0.03833247f, 0.05454214f, 0.17493276f, 0.07782511f, 0.17640346f, 
    -0.02064865f, 0.03547297f, 0.03426097f, 0.02402561f, -0.00164575f, 0.02495232f, 0.01105830f, -0.07904159f, 
    -0.16558538f, 0.15573657f, 0.07138430f, 0.10041107f, -0.01887739f, -0.09034242f, 0.00145949f, 0.03306434f, 
    -0.09352730f, 0.13843161f, 0.13237596f, 0.28272155f, -0.19278371f, -0.03516266f, -0.01856053f, -0.11934547f, 
    0.02751832f, 0.14640909f, -0.02825893f, -0.00517087f, -0.04161001f, -0.11100388f, -0.04005338f, -0.02521077f, 
    -0.26635250f, -0.03551532f, 0.16888586f, -0.17375432f, -0.06373674f, -0.08324228f, 0.07157464f, 0.07141895f, 
    0.10575277f, 0.13365859f, -0.07942374f, 0.20064811f, -0.31544861f, 0.22770876f, -0.16075341f, -0.00420113f, 
    0.01154548f, -0.07422450f, -0.02452753f, -0.13447900f, 0.08532304f, 0.06545511f, 0.03272180f, 0.02515336f, 
    0.04647638f, 0.09130149f, 0.30643332f, -0.29248342f, 0.20354487f, -0.02952038f, -0.02973218f, 0.19931145f, 
    -0.04135608f, -0.03102064f, 0.00363572f, 0.08972428f, 0.18114269f, -0.16700059f, -0.17615905f, 0.12831649f, 
    0.25004414f, 0.10559760f, 0.00569567f, 0.11352164f, 0.13527821f, -0.00937421f, 0.07468408f, 0.09209699f, 
    -0.33555675f, 0.03627899f, -0.00994092f, 0.10439499f, 0.10171608f, 0.08322272f, 0.05503567f, 0.04146766f, 
    -0.10225707f, 0.03569730f, 0.04027162f, -0.12111505f, -0.26416248f, -0.14501780f, 0.09277962f, 0.15730627f, 
    -0.05285060f, -0.20075706f, 0.07259060f, -0.15227225f, -0.03113358f, 0.00026284f, 0.04388917f, -0.11034156f, 
    -0.01063976f, -0.06457879f, -0.08653943f, 0.25409567f, 0.03861249f, -0.08027606f, -0.03214325f, -0.09199759f, 
    0.07732955f, 0.06649910f, 0.00971132f, -0.03817740f, 0.31451669f, 0.06706502f, 0.03403322f, -0.13364179f, 
    0.06580746f, -0.00210763f, -0.05580793f, 0.20188551f, 0.08986203f, 0.25161350f, 0.00673744f, 0.09264282f, 
    -0.02607789f, -0.21632954f, 0.18390468f, -0.04681820f, -0.01276842f, -0.06436404f, -0.05131128f, 0.00218022f, 
    0.13268149f, 0.03881219f, 0.27490807f, 0.24145763f, -0.38890934f, 0.01803623f, 0.02825982f, 0.09557147f, 
    0.10674881f, 0.15932035f, 0.07073673f, -0.07760497f, -0.03552429f, -0.03845683f, -0.07234853f, -0.20171931f, 
    0.36641988f, -0.02595970f, -0.14667453f, 0.01609976f, 0.08089540f, 0.00558133f, 0.12739074f, 0.05625141f, 
    0.02180285f, -0.00234200f, 0.19428851f, -0.10966599f, 0.11164872f, 0.31042475f, -0.01202574f, 0.05374790f, 
    -0.00030239f, -0.10376009f, -0.10047875f, -0.03503447f, 0.16681947f, -0.05436067f, 0.08843456f, 0.02255917f, 
    0.27420950f, -0.31943378f, -0.02173104f, 0.11050122f, 0.06334596f, 0.03792151f, 0.00522088f, -0.08298935f, 
    0.03218383f, -0.18152258f, 0.04372507f, -0.05826908f, -0.01963633f, 0.20449567f, -0.09173083f, -0.13971068f, 
    0.02096146f, 0.09191237f, -0.02437711f, 0.10731239f, 0.17112532f, 0.15015708f, -0.01232292f, 0.33069897f, 
    0.12452027f, -0.16964468f, 0.08327534f, -0.26258272f, 0.13158977f, 0.05924914f, -0.06111059f, -0.09186671f, 
    0.21958153f, -0.00278002f, -0.03526336f, -0.22071359f, 0.10896024f, -0.00111749f, -0.04475867f, 0.18873355f, 
    0.03561510f, 0.01230375f, -0.08964937f, 0.25917983f, 0.11730014f, 0.20739904f, 0.08209360f, 0.10460508f, 
    -0.11981892f, 0.00387083f, 0.11880390f, 0.05084107f, 0.08462268f, -0.16647968f, -0.00040624f, 0.18645692f, 
    -0.15553303f, -0.12166084f, 0.02860017f, 0.10439736f, -0.23160666f, -0.07620661f, -0.10145488f, 0.10553540f, 
    -0.00490414f, -0.07711634f, -0.18258700f, 0.13889661f, 0.11201586f, -0.03053203f, 0.01619294f, -0.03189012f, 
    -0.48809943f, -0.06758019f, 0.06872036f, 0.14836696f, 0.19187449f, -0.02850075f, 0.15306105f, -0.22685304f, 
    0.11575857f, -0.14166938f, 0.02020068f, 0.26327723f, 0.23822252f, 0.03851928f, -0.04230693f, 0.14638269f, 
    -0.00324050f, -0.09404376f, 0.04277525f, -0.05070657f, 0.13307990f, 0.16802634f, -0.09977884f, 0.05214362f, 
    0.00873655f, 0.41785246f, -0.19206212f, 0.05737888f, 0.01970876f, 0.12132724f, 0.16063136f, -0.24704511f, 
    0.10580952f, -0.04019862f, -0.02860006f, -0.02811570f, 0.00911020f, 0.11541184f, -0.08344465f, -0.16809402f, 
    0.04993536f, 0.11532579f, -0.03377614f, 0.04459127f, -0.03528696f, -0.18808205f, -0.11864527f, 0.06943494f, 
    0.15817180f, 0.39909163f, 0.11782658f, -0.28893599f, -0.08752849f, 0.10212475f, -0.07607085f, -0.22661528f, 
    0.04276881f, -0.09367571f, -0.07311311f, 0.03842997f, -0.16307993f, -0.22069843f, 0.08121504f, 0.06607692f, 
    0.05504488f, -0.08708020f, -0.09311536f, -0.07402911f, -0.12578051f, -0.11231764f, 0.24217023f, -0.02369683f, 
    0.12395129f, -0.15891767f, 0.04570013f, -0.03889401f, 0.01774849f, 0.00891547f, -0.05638560f, 0.07266646f, 
    -0.05609737f, -0.05154308f, 0.19215433f, -0.12979451f, 0.46905878f, 0.40097088f, 0.02587276f, 0.19757028f, 
    0.12187572f, -0.10467333f, -0.10526690f, -0.10852156f, -0.01704516f, -0.01947012f, 0.17329246f, -0.09006096f, 
    -0.21730776f, 0.24607249f, -0.07985021f, -0.38386789f, -0.00628273f, -0.00640715f, -0.09155186f, 0.08171337f, 
    0.03361061f, -0.06019166f, -0.14750102f, -0.06784793f, 0.00442468f, -0.04437354f, -0.03344773f, -0.18503405f, 
    0.17463703f, 0.07867327f, 0.07808926f, -0.15127645f, 0.02038147f, 0.07589039f, -0.13299206f, -0.06554808f, 
    0.55736512f, -0.01863703f, 0.21935150f, 0.50957531f, 0.08871678f, 0.06742007f, 0.08631933f, -0.03882029f, 
    -0.17919636f, -0.04768607f, 0.00958983f, -0.16664159f, -0.00988172f, 0.03641418f, -0.26963568f, -0.09695204f, 
    -0.17900945f, -0.04739185f, -0.00219721f, -0.17787190f, -0.06923552f, 0.18353806f, 0.04610012f, -0.08945428f, 
    -0.02152413f, 0.07153632f, -0.12985693f, -0.45489010f, -0.04144994f, -0.08878225f, 0.10668398f, 0.02145371f, 
    -0.07023541f, 0.10156906f, -0.02827197f, 0.20752870f, -0.03843533f, -0.19716650f, 0.02002668f, 0.54945600f, 
    0.13136733f, -0.00252580f, 0.02806739f, -0.08724738f, 0.00121978f, 0.03174313f, 0.15566148f, -0.15611742f, 
    0.10995585f, -0.01032877f, -0.23067336f, 0.26275063f, -0.13969958f, 0.05629769f, -0.14942391f, -0.12720993f, 
    0.07602837f, 0.03046397f, -0.08003471f, 0.04873652f, -0.10179918f, -0.03113388f, -0.13574167f, 0.20610876f, 
    0.02737435f, -0.03823799f, 0.06660190f, 0.07713606f, 0.15191899f, 0.12080109f, -0.04192107f, -0.04492682f, 
    -0.34099817f, -0.14890309f, -0.30142710f, -0.20852406f, -0.08278533f, 0.14034122f, -0.06590277f, 0.02627907f, 
    0.05261737f, 0.12395857f, 0.00389528f, 0.18458645f, -0.05572901f, 0.00678811f, -0.06521873f, -0.09723001f, 
    0.20664217f, 0.11082461f, 0.02425977f, -0.20553346f, 0.06279702f, 0.11538330f, -0.07715283f, -0.19172350f, 
    0.13779034f, -0.11000387f, -0.20317914f, -0.21429171f, -0.12923658f, 0.06724955f, 0.02424624f, 0.06089743f, 
    -0.05917861f, -0.00292957f, 0.04003800f, -0.01359871f, 0.24346560f, 0.24265142f, 0.14084949f, 0.52578574f, 
    -0.10111694f, -0.08954976f, -0.08638157f, -0.03146004f, -0.08980718f, -0.12798388f, 0.05101714f, -0.05695929f, 
    -0.16477045f, 0.17786466f, 0.22258461f, -0.08593582f, -0.30337998f, -0.13429880f, -0.04999085f, 0.17214783f, 
    -0.06758203f, -0.01397276f, 0.08648449f, 0.00787390f, 0.37098444f, 0.39113754f, 0.16558687f, 0.29389641f, 
    -0.01602643f, -0.01709377f, -0.04515462f, 0.00487366f, -0.14390968f, 0.05690211f, 0.15787025f, -0.16956672f, 
    0.26486886f, -0.07955377f, -0.06194022f, 0.40238109f, 0.02051852f, 0.10665596f, -0.08631028f, -0.01975100f, 
    -0.03158243f, 0.16374224f, -0.04814119f, -0.11776388f, 0.03951954f, -0.40621048f, 0.20188902f, 0.06840611f, 
    -0.01710210f, 0.17332235f, 0.01934134f, -0.12681507f, -0.05930874f, -0.08752153f, -0.04446663f, 0.00123365f, 
    0.16329777f, 0.29233131f, -0.01021748f, 0.02680995f, -0.15095659f, 0.13177364f, -0.03578727f, 0.07356325f, 
    0.15534218f, 0.07345306f, 0.14982669f, -0.01581123f, 0.35784528f, 0.00017351f, 0.03041371f, 0.40983298f, 
    -0.09277888f, 0.00227186f, -0.05961013f, 0.10645893f, 0.01220623f, 0.01276988f, 0.04049522f, -0.09541771f, 
    -0.11751934f, -0.01950039f, 0.17812811f, -0.02038439f, 0.14020540f, -0.05883585f, 0.05236825f, -0.07809637f, 
    -0.00907909f, -0.04948119f, 0.00363697f, 0.05613325f, -0.12479226f, -0.02385482f, 0.08012211f, -0.02331878f, 
    0.13947250f, 0.10166895f, -0.03257509f, -0.04693803f, 0.02253599f, -0.15291153f, 0.03266973f, -0.08622120f, 
    -0.09643724f, 0.12010095f, -0.14070265f, 0.03753919f, 0.03053585f, -0.02004500f, 0.06454273f, 0.08301682f, 
    0.06006863f, -0.11803249f, 0.08267167f, 0.12895964f, 0.00088761f, 0.12325966f, 0.00222808f, -0.05818248f, 
    -0.03238678f, 0.19275600f, -0.05988607f, -0.05568459f, -0.14482456f, -0.01593758f, -0.09090827f, -0.06643210f, 
    -0.03507221f, 0.06956953f, 0.27864057f, -0.15934473f, -0.02546185f, -0.15911919f, 0.02738507f, -0.23931976f, 
    -0.04985626f, 0.06262010f, -0.01425816f, 0.06056375f, 0.03048142f, 0.24393952f, 0.11580674f, -0.26012468f, 
    0.05298004f, 0.08545201f, -0.13051842f, -0.02644863f, -0.02745203f, 0.00405509f, -0.06406546f, 0.03069178f, 
    -0.05503740f, -0.07751046f, 0.18002850f, -0.15980418f, 0.25023443f, -0.16189454f, 0.09371775f, 0.08198296f, 
    0.03771721f, -0.06918640f, -0.06585447f, 0.06409615f, 0.53033489f, 0.01705811f, -0.18151291f, -0.00709700f, 
    -0.04562385f, 0.05653868f, 0.21830976f, 0.07904127f, -0.07406351f, 0.04740048f, 0.10432103f, -0.03583702f, 
    0.43895224f, -0.17607354f, -0.02506062f, 0.15817027f, 0.01723748f, 0.07738689f, 0.03005929f, 0.27499071f, 
    0.04896867f, 0.10411374f, -0.16734527f, 0.01945623f, 0.24253599f, -0.32827401f, 0.01577376f, -0.21475892f, 
    0.03087081f, -0.03072660f, -0.04787377f, -0.07616165f, 0.12237129f, -0.05881740f, -0.01302945f, 0.15632123f, 
    -0.05406896f, -0.24240361f, -0.32501718f, -0.19999437f, -0.18822587f, -0.03404984f, -0.02182457f, -0.08965256f, 
    -0.00433502f, -0.06100433f, 0.04589991f, -0.06417139f, 0.23899490f, -0.20542283f, 0.20467699f, 0.06304129f, 
    -0.06964843f, 0.06263252f, -0.04925599f, 0.04775425f, 0.19534864f, 0.04325930f, -0.02345673f, -0.21476577f, 
    -0.27139744f, -0.02779031f, 0.15620352f, -0.12352084f, 0.09646759f, -0.04605271f, 0.05701076f, 0.18799946f, 
    -0.00490141f, -0.10674120f, -0.15924445f, -0.00037541f, 0.40840629f, -0.02858795f, -0.05208639f, -0.05785566f, 
    -0.10826836f, -0.06640371f, 0.02993711f, -0.04337804f, 0.06350019f, 0.06662917f, 0.20556991f, 0.05195843f, 
    -0.50287670f, -0.05101616f, 0.37964788f, 0.11201748f, 0.07311051f, 0.11057948f, -0.13684502f, 0.03046058f, 
    0.08087754f, 0.19399577f, 0.14939116f, 0.04307069f, -0.38683942f, -0.06012321f, 0.12315090f, -0.01035456f, 
    -0.00105711f, 0.23069678f, 0.02802101f, 0.09955715f, -0.22127077f, 0.03659956f, -0.14544475f, 0.06233035f, 
    -0.29982275f, 0.19497330f, 0.09348927f, -0.30621260f, 0.13457453f, 0.06902408f, -0.01317042f, -0.02550323f, 
    -0.01950403f, 0.00423237f, -0.02758554f, 0.07758633f, 0.50098854f, -0.16580938f, -0.15230642f, -0.03816733f, 
    0.03432927f, -0.08384462f, 0.07685547f, -0.04634475f, -0.08375064f, 0.08614032f, 0.12126373f, 0.12523501f, 
    0.39824352f, -0.20029688f, -0.27540925f, -0.03864655f, -0.04540081f, 0.12327930f, 0.15299492f, 0.05496023f, 
    0.03287890f, 0.13545577f, 0.09127781f, 0.05933897f, -0.28391472f, -0.00949951f, 0.08677101f, -0.28694850f, 
    0.07835506f, 0.07426310f, 0.12287331f, -0.06955312f, 0.02253339f, 0.24111992f, 0.10585231f, 0.04859126f, 
    0.18544616f, -0.11352856f, -0.19614914f, -0.02718253f, 0.05256956f, 0.13554427f, -0.01570711f, 0.05497659f, 
    0.05178961f, 0.09901319f, 0.00116082f, -0.09991349f, -0.19920631f, 0.04229472f, 0.01376962f, -0.12811217f, 
    0.05515371f, -0.00557062f, 0.06278519f, 0.07241114f, 0.08356861f, -0.04388442f, 0.00251312f, 0.03978168f, 
    0.44652820f, 0.12114634f, -0.20579417f, -0.14549060f, 0.01398170f, 0.12528467f, -0.06577401f, -0.00442912f, 
    0.06035018f, 0.08302084f, 0.10868235f, 0.06102434f, -0.11789048f, 0.15629555f, -0.06290336f, -0.18700138f, 
    -0.01794495f, 0.13922472f, -0.03232964f, 0.06213694f, 0.04298856f, -0.11897907f, 0.17348757f, -0.04978951f, 
    -0.08428240f, 0.01559759f, 0.12771523f, -0.02060999f, 0.05750760f, -0.20288232f, -0.05565602f, 0.19576372f, 
    -0.08258492f, -0.10475126f, 0.00027760f, -0.10108989f, 0.36080018f, -0.20294370f, -0.00101022f, -0.02677739f, 
    -0.09948093f, -0.15529847f, -0.12004353f, 0.03119224f, 0.01577817f, -0.03123126f, 0.09009182f, -0.12336452f, 
    -0.18392071f, -0.18728134f, 0.10353758f, 0.17373259f, 0.28238219f, 0.02835430f, 0.04866478f, 0.13456950f, 
    0.01439849f, 0.08714455f, -0.16834526f, 0.08330915f, 0.08295982f, 0.08161867f, 0.00085729f, -0.12618928f, 
    0.09244183f, 0.10289036f, -0.08082858f, 0.00361588f, 0.15408716f, 0.04836500f, -0.09011584f, -0.02707300f, 
    0.02904480f, 0.47910500f, 0.08931147f, -0.02064156f, -0.00693043f, 0.07840958f, -0.03158126f, -0.05492825f, 
    -0.06651153f, 0.00628540f, 0.02767178f, -0.02584752f, -0.40291989f, 0.15643990f, -0.03032922f, -0.32487118f, 
    0.16086225f, -0.18377744f, -0.01775955f, -0.18563789f, -0.12646984f, -0.05595714f, 0.10323605f, -0.00090178f, 
    -0.19734852f, 0.20769764f, 0.10286248f, 0.34646112f, 0.06791609f, 0.06577152f, 0.18238671f, -0.01515880f, 
    0.11374602f, 0.11199687f, 0.01413688f, 0.18009268f, 0.01737475f, -0.22588642f, 0.15662952f, -0.22833012f, 
    0.06597035f, -0.06941326f, 0.06301895f, -0.22642815f, -0.10465498f, 0.07326009f, 0.02695495f, 0.16844958f, 
    -0.17348777f, -0.10835354f, -0.23576960f, -0.00312609f, -0.18384147f, 0.00128622f, -0.29523477f, -0.07442787f, 
    0.07726283f, -0.16416252f, -0.12741077f, -0.05390045f, -0.14791302f, -0.06665122f, 0.07770996f, -0.05890860f, 
    0.04000469f, -0.09024961f, 0.01784822f, -0.00037962f, 0.09342492f, -0.01030329f, 0.12636033f, -0.02025078f, 
    -0.19535592f, 0.00964709f, 0.21359256f, 0.31891009f, 0.16148834f, 0.24487296f, 0.00352306f, 0.26233804f, 
    -0.01595895f, 0.04101884f, 0.03445047f, 0.17276739f, -0.06172116f, 0.00109170f, -0.10465318f, -0.00741057f, 
    -0.04382921f, -0.20816223f, -0.10899343f, -0.05859970f, -0.02093032f, -0.04043228f, -0.25681835f, 0.00237042f, 
    -0.29073197f, 0.03288363f, 0.12210981f, 0.24358356f, 0.01486233f, 0.00434502f, 0.11588323f, -0.02208083f, 
    0.15413861f, -0.11434032f, 0.09154747f, 0.15708977f, 0.17106125f, -0.07623793f, -0.09647163f, 0.09253215f, 
    0.05310714f, -0.03422406f, -0.04833428f, -0.12054274f, 0.02577201f, 0.10653719f, 0.15098865f, -0.06769459f, 
    0.19830793f, 0.15607503f, 0.19577929f, 0.30256811f, -0.02354821f, 0.05060693f, 0.00171895f, 0.13408622f, 
    -0.03119541f, 0.02295131f, 0.21998547f, 0.17336181f, -0.11697760f, 0.05553041f, 0.06505476f, -0.06912225f, 
    0.07014050f, -0.19019374f, -0.13340220f, -0.02174594f, -0.11621918f, -0.07978371f, -0.03089754f, 0.12018429f, 
    -0.49347216f, 0.16298538f, 0.11905141f, -0.21955422f, -0.02721028f, 0.07649834f, 0.00868526f, -0.00785508f, 
    0.10929277f, -0.11884012f, 0.18913373f, 0.06977629f, -0.28687099f, 0.53074783f, -0.20964549f, -0.34084812f, 
    0.25292143f, 0.19229926f, 0.03683209f, 0.03198373f, -0.08612631f, 0.01212163f, 0.05347512f, -0.03119965f, 
    0.00693956f, 0.00630476f, 0.12047845f, 0.21808748f, 0.34339130f, 0.15220287f, 0.05468998f, 0.21142322f, 
    0.05907996f, 0.16729584f, 0.11965868f, 0.08956788f, -0.22603577f, 0.26768988f, -0.25549719f, -0.21508066f, 
    0.15159848f, -0.21966016f, 0.21168114f, -0.27453962f, -0.04345591f, 0.02978141f, -0.18786667f, 0.08178546f, 
    -0.09600051f, 0.19325563f, -0.04762566f, -0.05934508f, 0.00309355f, 0.12450887f, -0.01427284f, -0.06536775f, 
    -0.00934038f, 0.04603553f, 0.04585452f, 0.02830573f, -0.17844512f, 0.17565762f, -0.03859594f, 0.01746725f, 
    0.07455265f, -0.10929252f, 0.11421473f, 0.09340653f, -0.16261207f, 0.05933553f, -0.01704932f, 0.05545359f, 
    -0.14463657f, -0.16745314f, 0.03796352f, -0.11726302f, 0.03568278f, 0.04541243f, 0.03942053f, 0.06008241f, 
    0.18282385f, -0.04107956f, -0.03103787f, 0.11711545f, 0.55831409f, 0.08734302f, 0.18977410f, 0.09126808f, 
    -0.07870552f, -0.00959028f, -0.08043614f, 0.03289101f, -0.02109946f, 0.08229421f, -0.00923434f, 0.04424304f, 
    0.20436361f, 0.17957421f, 0.03370650f, 0.25323567f, -0.19340689f, -0.02809000f, 0.11689898f, 0.14701393f, 
    0.12441977f, -0.04023498f, -0.01898118f, 0.08497256f, -0.17803387f, -0.25463659f, -0.01567840f, -0.03476235f, 
    0.04951198f, -0.05067251f, 0.06538668f, 0.03776293f, 0.00124095f, -0.03199736f, 0.01868640f, 0.02425684f, 
    -0.66390920f, 0.08922291f, -0.17246477f, 0.23297447f, 0.10309469f, -0.04898976f, -0.06273291f, 0.13446839f, 
    -0.01037255f, 0.12873940f, 0.09003547f, 0.14624488f, 0.29757518f, 0.20486653f, 0.00145655f, 0.01699430f, 
    -0.11901721f, 0.04395189f, 0.11013389f, -0.04477106f, -0.01880329f, -0.17170940f, -0.10009795f, -0.03504261f, 
    -0.02818167f, 0.33192426f, 0.08200693f, 0.09605378f, -0.01358077f, 0.16955663f, 0.14738178f, 0.06835774f, 
    0.10549241f, 0.00327314f, -0.06660097f, 0.04890967f, 0.37414366f, -0.10657557f, 0.03530255f, -0.03023313f, 
    -0.12989993f, 0.01159864f, -0.01209132f, -0.00230410f, 0.01084149f, 0.07978398f, 0.01841212f, -0.07936128f, 
    -0.29491493f, 0.06671904f, 0.12119124f, 0.10559395f, 0.12066931f, 0.05101407f, -0.03336952f, 0.15071431f, 
    -0.03267653f, 0.05245085f, 0.08049089f, 0.06730744f, -0.13684873f, 0.10867661f, 0.23094346f, -0.13993812f, 
    -0.02142600f, 0.06239250f, -0.06427470f, 0.10130514f, -0.21306561f, -0.23383401f, -0.06110803f, 0.11407692f, 
    0.02436565f, -0.09803641f, 0.08288547f, -0.07153033f, 0.02660349f, 0.11009526f, -0.16352563f, 0.11942197f, 
    0.01223952f, -0.02571669f, -0.08746119f, 0.06147259f, -0.17537124f, -0.01606939f, -0.15052366f, -0.07200314f, 
    0.28246662f, 0.04048954f, 0.11349585f, 0.11842272f, 0.12506789f, 0.09370309f, 0.08320080f, -0.01110365f, 
    -0.21595719f, -0.16021723f, -0.26026380f, 0.02915968f, 0.10110064f, 0.04836944f, 0.09956481f, 0.08518857f, 
    0.04329560f, 0.18385810f, 0.07581414f, 0.08271752f, -0.09719381f, 0.27899897f, -0.20711425f, 0.01789092f, 
    0.08232721f, 0.06989668f, 0.14869618f, -0.01952590f, 0.10409385f, 0.10553605f, -0.06359913f, -0.02018782f, 
    0.13430053f, 0.11204269f, -0.01341892f, 0.02207672f, -0.15897624f, 0.06886102f, 0.03440992f, 0.02664111f, 
    0.18831705f, 0.09908734f, -0.01514148f, 0.04768137f, 0.18837000f, -0.28308392f, 0.08702971f, 0.15623923f, 
    0.00760363f, 0.00769519f, 0.01393475f, 0.09594193f, 0.05027565f, -0.02407326f, -0.06485821f, -0.11460843f, 
    -0.08253210f, 0.23497260f, -0.22827548f, -0.12576868f, -0.12669791f, -0.05396996f, 0.02189012f, 0.09880164f, 
    -0.04509223f, 0.05555131f, -0.03370119f, -0.00413664f, 0.00447921f, 0.17049691f, 0.06888872f, 0.17286089f, 
    0.07274035f, 0.09387547f, 0.03573180f, -0.00632675f, 0.05627506f, 0.00215309f, 0.17787258f, -0.01108224f, 
    0.00014973f, 0.14735493f, 0.20237139f, 0.16845940f, 0.01819545f, -0.03876280f, 0.02458527f, 0.00525657f, 
    0.09143395f, 0.06321586f, 0.17460784f, 0.02781207f, -0.25589725f, 0.07361507f, 0.29282746f, 0.16879492f, 
    -0.04354059f, 0.09672534f, 0.04310308f, 0.07933890f, 0.10686782f, 0.03813532f, -0.14236447f, 0.06731474f, 
    -0.11861587f, -0.12280165f, 0.24232394f, -0.16619743f, 0.07617202f, 0.04157061f, -0.08092167f, -0.09752458f, 
    -0.11943612f, -0.04283942f, 0.18271983f, 0.25218523f, -0.09088488f, 0.19050695f, 0.04219956f, 0.00692085f, 
    -0.04864546f, 0.11577924f, -0.02276492f, 0.02124568f, 0.05637568f, -0.19049323f, -0.09694896f, -0.11241645f, 
    -0.01669899f, 0.02832370f, 0.30820754f, -0.03519906f, -0.06328162f, -0.04033444f, 0.12811992f, 0.04603142f, 
    0.05410528f, -0.00185711f, -0.01728438f, -0.08346795f, 0.20420063f, 0.03506119f, 0.21015923f, -0.04789234f, 
    -0.23157802f, 0.15102881f, 0.20562002f, -0.02959014f, -0.01226396f, 0.03696979f, 0.04189449f, -0.10839268f, 
    0.09392726f, -0.31817585f, 0.26522365f, -0.21856445f, 0.19195090f, -0.13445742f, 0.14392668f, -0.06485260f, 
    -0.11427920f, 0.02125233f, -0.17496239f, -0.00240705f, -0.09517265f, -0.23988806f, 0.00992666f, 0.07144492f, 
    -0.05849110f, -0.10402934f, -0.00879507f, 0.03373137f, -0.02994250f, 0.08256698f, 0.03197607f, -0.00197571f, 
    -0.19131328f, 0.16252159f, -0.01051792f, 0.00527205f, -0.08107933f, 0.21015655f, 0.04656732f, 0.15284972f, 
    -0.05304530f, 0.05356861f, -0.01739861f, 0.01175722f, -0.22263195f, -0.05592614f, 0.13904582f, 0.12388176f, 
    -0.07666519f, 0.08070672f, -0.03452957f, -0.08050326f, -0.12131824f, 0.00292242f, 0.02203155f, 0.03291728f, 
    -0.31320158f, 0.26589772f, -0.23914587f, 0.01276165f, 0.02145715f, -0.07381457f, 0.01022157f, 0.07345285f, 
    0.12904246f, -0.12327397f, 0.16804434f, 0.05389047f, 0.24547781f, -0.31795746f, -0.00367545f, -0.04586943f, 
    -0.02038168f, -0.01759333f, 0.00802179f, 0.05774903f, 0.06067019f, 0.01756832f, -0.03772245f, 0.04109919f, 
    -0.12802882f, -0.12839974f, 0.17543091f, 0.14015725f, -0.06322052f, 0.03060139f, 0.03123481f, 0.01791009f, 
    -0.07707676f, -0.24750637f, -0.11568586f, 0.06391975f, 0.05899356f, -0.22683191f, -0.03703935f, 0.12102762f, 
    -0.06888702f, 0.13568808f, -0.03136478f, -0.05627929f, -0.11436732f, 0.02137601f, 0.03862919f, 0.19865131f, 
    -0.01631488f, 0.06273377f, 0.22253351f, 0.03057093f, 0.11553448f, 0.03042646f, -0.08628566f, -0.05458306f, 
    0.11554544f, 0.13336898f, -0.05164949f, 0.06060514f, 0.48890603f, -0.01677266f, -0.00905259f, -0.19563106f, 
    -0.00624281f, 0.02019914f, 0.01653515f, -0.10094772f, 0.07742951f, 0.02221159f, -0.04922905f, -0.05781206f, 
    -0.00268029f, 0.18595245f, -0.13111283f, -0.24340719f, 0.15692678f, 0.08337910f, -0.13695437f, -0.03911976f, 
    -0.05492978f, 0.00797928f, 0.03425124f, -0.04491539f, 0.08828069f, -0.16639613f, -0.20116337f, 0.21356876f, 
    0.04876348f, 0.07240172f, -0.04110456f, 0.05218150f, 0.00335032f, 0.03049004f, -0.04604369f, -0.28359786f, 
    -0.02964530f, 0.05985668f, -0.00956180f, 0.03155293f, -0.11589620f, -0.13199666f, -0.03762643f, -0.05301564f, 
    0.09369416f, 0.09727256f, 0.06376671f, -0.00166157f, 0.04557012f, 0.14206752f, -0.09760636f, -0.09340645f, 
    0.09440868f, 0.05630875f, -0.00972793f, -0.12541331f, -0.14173038f, -0.13806708f, 0.00948477f, -0.07374262f, 
    -0.13334398f, -0.15579453f, 0.06567839f, 0.05945972f, -0.02149973f, 0.05581073f, 0.05956312f, -0.01326030f, 
    -0.03641015f, -0.08949837f, -0.00786692f, 0.18206020f, -0.44384152f, 0.31794414f, -0.17781408f, 0.20650162f, 
    0.06412718f, 0.05598342f, -0.16226691f, 0.13708435f, 0.13333419f, 0.06962844f, 0.02003980f, 0.18487361f, 
    0.25559375f, 0.10873110f, -0.13786338f, -0.16035976f, 0.02799051f, -0.04825838f, -0.04843516f, -0.01332688f, 
    0.00008133f, -0.07922409f, -0.00649976f, -0.11623967f, 0.40326053f, -0.02219548f, -0.39420468f, 0.04956232f, 
    0.03570513f, -0.05077979f, 0.04660143f, -0.01419997f, 0.08891440f, 0.04846115f, 0.17098996f, 0.09648696f, 
    0.09773565f, 0.24850070f, 0.06618161f, 0.05427821f, 0.20937124f, -0.18905422f, 0.04537296f, -0.09745534f, 
    -0.06680769f, -0.00341256f, 0.03316459f, -0.06252676f, 0.18372457f, 0.02555956f, 0.28472871f, 0.10460448f, 
    0.02674075f, -0.09880397f, 0.01776619f, 0.06332044f, -0.11246869f, 0.14288789f, 0.00852964f, 0.11219653f, 
    -0.02407151f, -0.12642667f, 0.06610683f, 0.11600500f, 0.04934515f, 0.03581225f, 0.11186481f, -0.21672115f, 
    0.11840442f, -0.09399583f, -0.07218193f, -0.09235416f, 0.32843846f, 0.14802940f, 0.14624134f, -0.01344229f, 
    -0.14491121f, 0.07431777f, 0.02548317f, -0.03623343f, 0.09150966f, 0.05563078f, -0.13871682f, 0.04338616f, 
    -0.01996101f, 0.04261621f, -0.01105606f, -0.02060267f, 0.02974245f, -0.03957465f, -0.05649734f, -0.05569479f, 
    -0.01745377f, -0.02298173f, -0.02493840f, -0.06109640f, 0.04468609f, -0.04864703f, 0.04734774f, -0.01430780f, 
    -0.04354639f, 0.05962126f, -0.06193982f, 0.05313142f, -0.06029186f, 0.03392336f, 0.02760205f, -0.04774125f, 
    -0.06768674f, -0.01055611f, -0.01999272f, 0.04231076f, -0.00644176f, -0.01901446f, -0.06437709f, 0.04969097f, 
    0.04947686f, -0.07056308f, -0.01504466f, 0.04879734f, 0.05541217f, -0.07386053f, 0.00658905f, -0.07061594f, 
    -0.01262653f, -0.07860533f, -0.02806914f, 0.05323560f, -0.03567634f, 0.02553460f, 0.05209408f, -0.04122982f, 
    -0.07280264f, 0.04300336f, 0.06344853f, 0.03226722f, -0.04568305f, 0.03995605f, -0.02980697f, -0.05419726f, 
    0.02619754f, 0.04448318f, -0.06160224f, -0.05239829f, -0.07395407f, -0.00796795f, -0.00643803f, -0.06349804f, 
    -0.00627559f, 0.01969935f, -0.03169701f, 0.00544826f, -0.01731303f, 0.05328616f, 0.04862417f, 0.05478990f, 
    -0.01383569f, 0.02484691f, 0.02870545f, -0.05797613f, -0.05967416f, 0.05918679f, -0.03732613f, 0.00472182f, 
    -0.06327049f, -0.03692700f, -0.06709832f, 0.00604417f, -0.03756582f, -0.05300407f, -0.01050785f, 0.00072641f, 
    0.03404652f, 0.02289193f, -0.02363086f, -0.02517560f, 0.02436581f, -0.05265975f, 0.05929567f, 0.02604078f, 
    -0.04260904f, 0.01318163f, -0.00830910f, -0.01852248f, -0.00127852f, 0.05796737f, -0.00635256f, -0.05539021f, 
    0.03909375f, -0.03186889f, 0.02634182f, 0.02918531f, -0.04010445f, 0.02543374f, -0.02981544f, -0.06620553f, 
    0.01106818f, -0.00321594f, 0.00932004f, 0.01161945f, -0.07159497f, -0.07748471f, 0.02564073f, 0.04386640f, 
    0.01278395f, 0.01274925f, 0.04754109f, -0.02534715f, -0.05337451f, 0.03813153f, -0.07451937f, -0.01901024f, 
    -0.07414673f, 0.00719433f, 0.00285708f, -0.05084536f, -0.00637140f, 0.04566115f, 0.05376186f, 0.01341341f, 
    -0.06188818f, -0.07089547f, -0.03215682f, -0.00425739f, -0.00785518f, -0.05954986f, -0.03927113f, 0.00194672f, 
    0.06731105f, 0.04426895f, 0.03219609f, -0.07221542f, 0.03502942f, -0.03852578f, 0.04412327f, 0.06277611f, 
    -0.06158673f, -0.06339620f, -0.00085334f, 0.03815385f, -0.02787748f, 0.03671038f, 0.01178532f, -0.03439314f, 
    -0.01252066f, -0.04640521f, -0.04933227f, 0.03068865f, 0.05340247f, 0.02147477f, -0.02445685f, -0.06425175f, 
    -0.02274424f, 0.01007670f, 0.02498753f, 0.00802578f, 0.06980156f, -0.05631969f, 0.02624045f, 0.02272165f, 
    0.00083688f, -0.03369902f, -0.02697863f, 0.02238008f, 0.04493557f, 0.03238209f, -0.06072753f, -0.03008751f, 
    -0.04187138f, -0.02038457f, -0.02715955f, 0.06699482f, 0.01630894f, 0.03473906f, -0.08147595f, -0.07364796f, 
    0.42630571f, -0.32682958f, 0.16320755f, -0.05501596f, 0.16195638f, -0.09731638f, -0.02093735f, -0.02113519f, 
    0.02165339f, -0.09096488f, 0.08884348f, 0.08014137f, 0.01583256f, 0.29178783f, 0.09150789f, -0.08002953f, 
    0.07651762f, -0.06087473f, -0.08136497f, 0.03669037f, 0.14274557f, -0.01672898f, 0.13643457f, -0.11401480f, 
    -0.21217677f, 0.00876797f, 0.20446134f, 0.00043511f, 0.05912318f, 0.04433117f, 0.00136007f, 0.00326489f, 
    -0.08910426f, -0.08554421f, 0.05645259f, -0.01350124f, -0.44841230f, 0.04452453f, -0.28076932f, -0.13337308f, 
    0.08802789f, 0.12593409f, 0.00386952f, -0.07678887f, -0.13798831f, -0.07951658f, 0.04605484f, 0.09243283f, 
    0.20352973f, -0.35055965f, -0.08339774f, 0.28912249f, 0.13355866f, -0.13132991f, 0.01819153f, -0.05845692f, 
    -0.03627734f, 0.06853952f, 0.02703820f, -0.24237980f, 0.11069241f, 0.30672881f, 0.00845515f, -0.18537642f, 
    0.11618738f, 0.01788537f, -0.03277352f, -0.03582791f, -0.18186495f, 0.22179799f, 0.15615971f, 0.31593761f, 
    0.48208883f, 0.13067606f, -0.19447875f, -0.13351788f, -0.04721947f, 0.05225827f, 0.18432119f, 0.09403292f, 
    0.05963500f, 0.14549915f, -0.06084824f, -0.12266737f, -0.02723495f, -0.42207849f, 0.02543491f, 0.37986687f, 
    0.17258464f, -0.00454362f, -0.03909493f, -0.05706785f, 0.15441929f, 0.25355986f, 0.23416254f, 0.23730005f, 
    -0.11677942f, 0.02696255f, -0.21427864f, 0.12903211f, -0.06833559f, -0.09130163f, -0.14545606f, 0.15151985f, 
    0.03917659f, 0.06602266f, 0.03737066f, -0.10063557f, 0.05394254f, -0.23906437f, -0.07268763f, 0.08841044f, 
    0.13421889f, -0.14109935f, 0.01447962f, 0.13116859f, 0.09215664f, 0.05258653f, -0.12310390f, -0.04414495f, 
    -0.04674241f, 0.05429214f, -0.28376889f, 0.09341443f, -0.03518704f, 0.14370202f, -0.05353948f, -0.03975778f, 
    0.08371861f, 0.01364776f, -0.02572432f, 0.11274724f, 0.06851066f, -0.07293337f, -0.04408105f, 0.14061873f, 
    0.07139327f, 0.06426791f, 0.05256969f, -0.13595444f, 0.13345587f, 0.05598630f, -0.10034413f, -0.09769259f, 
    -0.02783147f, 0.01468371f, -0.11515475f, 0.02235870f, -0.16176558f, -0.04312772f, 0.11179533f, -0.05361255f, 
    0.07971773f, -0.17579360f, 0.04649597f, 0.09015899f, 0.24093451f, 0.29572585f, 0.02606509f, 0.11841217f, 
    -0.15875068f, 0.00582667f, -0.01068550f, -0.07457431f, 0.08350103f, -0.13008514f, -0.08963090f, -0.08470511f, 
    -0.01207460f, 0.07200757f, 0.35075417f, 0.01132283f, -0.09640592f, -0.15510720f, 0.01034102f, 0.06850758f, 
    -0.08715055f, -0.09402975f, -0.06014105f, 0.10646551f, -0.15798724f, 0.04882997f, 0.03518485f, 0.11285901f, 
    0.05363748f, 0.07835905f, 0.03813643f, -0.02602373f, -0.11700245f, -0.01334592f, 0.21478640f, 0.07434755f, 
    0.29887801f, 0.01273883f, -0.28621891f, -0.13750763f, 0.00219882f, 0.12108899f, -0.06025279f, 0.03113069f, 
    0.03780442f, 0.07953383f, 0.07372009f, -0.08854622f, -0.25066769f, 0.35868883f, -0.02655384f, -0.05251138f, 
    0.08405853f, -0.08589809f, 0.05421685f, 0.01441994f, 0.11475838f, -0.00368151f, -0.01799529f, -0.06469005f, 
    0.16411716f, -0.15597360f, -0.10867918f, -0.09617762f, -0.07770563f, -0.16885553f, 0.02897340f, 0.00030325f, 
    -0.14166814f, -0.11679085f, -0.12309181f, -0.02536787f, -0.11141362f, 0.09366289f, -0.18417205f, 0.00135757f, 
    -0.00236458f, -0.05796391f, 0.05778288f, 0.10710654f, -0.00442842f, 0.08408426f, 0.01928926f, 0.00432276f, 
    0.26703429f, -0.04764407f, 0.00012922f, 0.46370181f, -0.29408950f, 0.01801392f, 0.14489284f, 0.19519636f, 
    0.06818014f, 0.14284910f, -0.01511516f, 0.04916092f, -0.21636824f, 0.24832223f, 0.24504282f, -0.01303327f, 
    0.02370611f, -0.03366086f, 0.04763220f, 0.07986278f, -0.06031920f, 0.04224734f, 0.01015610f, -0.01857308f, 
    -0.12307336f, 0.31007078f, 0.21593718f, -0.00463343f, 0.00459686f, -0.02935208f, 0.04845463f, 0.08870863f, 
    -0.00952489f, 0.04252950f, -0.06918802f, 0.01842068f, 0.29300687f, -0.31662762f, 0.04667978f, 0.40239543f, 
    -0.00846876f, -0.17708188f, -0.00839034f, 0.01937181f, 0.07523777f, -0.09623051f, -0.00736908f, 0.02943773f, 
    0.11875769f, 0.20313448f, -0.23983368f, 0.11825157f, -0.07035405f, 0.03085659f, -0.03963903f, 0.03196352f, 
    0.05491692f, -0.02961668f, -0.04443847f, 0.02421296f, 0.48687902f, -0.36609468f, -0.02751064f, 0.19255990f, 
    -0.07171399f, 0.01587643f, 0.09430341f, -0.10349636f, -0.05042823f, 0.09085836f, -0.11917860f, -0.08317613f, 
    -0.29857823f, -0.09365875f, 0.06355756f, 0.24704269f, -0.00581178f, 0.03043039f, -0.01906694f, -0.02642443f, 
    -0.02190438f, 0.10102022f, 0.00797103f, -0.00184207f, -0.39505273f, -0.10645229f, 0.25461793f, 0.04575923f, 
    -0.10968089f, 0.04035744f, -0.05160008f, -0.03132527f, -0.00453677f, 0.08478812f, -0.15409920f, -0.06738656f, 
    0.11717294f, -0.32530528f, -0.08388583f, -0.03990998f, -0.08850489f, 0.17690668f, -0.06776681f, 0.10836187f, 
    0.07533496f, 0.06858464f, -0.03769552f, 0.14088829f, -0.16329503f, 0.23773664f, -0.20037834f, 0.01528728f, 
    0.07731058f, 0.19287331f, -0.04952664f, 0.00847339f, 0.14224620f, -0.05569032f, 0.12007100f, 0.11984218f, 
    0.20928204f, 0.06955182f, 0.05236914f, -0.01041666f, -0.14250307f, 0.01637150f, 0.09869646f, 0.23766991f, 
    -0.10539331f, 0.11010054f, 0.22863956f, 0.09714828f, -0.38561457f, 0.04450330f, -0.02218474f, 0.14489868f, 
    0.08392785f, -0.11624889f, 0.12609847f, -0.09302964f, -0.03236490f, -0.04461185f, 0.03343758f, -0.07083338f, 
    0.05132092f, 0.04026668f, -0.03654867f, 0.04607613f, -0.01953235f, 0.03287739f, 0.00013176f, 0.05460464f, 
    0.04094794f, 0.00211923f, 0.03266884f, 0.04355701f, 0.00675531f, -0.03537837f, 0.00151730f, -0.07028781f, 
    0.04599509f, -0.04662117f, 0.04778904f, -0.06017479f, 0.02210196f, -0.05573364f, 0.02602540f, 0.00539583f, 
    -0.06763979f, 0.03953275f, 0.00729368f, 0.03547317f, 0.02810237f, -0.03023519f, -0.08269183f, -0.03998944f, 
    0.00991839f, -0.04063304f, 0.00523211f, 0.05908775f, 0.03351472f, -0.02719515f, -0.00309428f, -0.05412338f, 
    -0.00802554f, -0.05261620f, 0.02177680f, -0.03053243f, -0.00443288f, -0.01687858f, 0.01576761f, 0.04706316f, 
    -0.01323745f, -0.03415071f, -0.04165847f, -0.02499036f, -0.06221078f, -0.06436209f, 0.05832646f, -0.05313263f, 
    -0.03525189f, -0.05555546f, -0.02979202f, -0.05234543f, -0.05316795f, 0.00719957f, -0.02375431f, 0.05975463f, 
    -0.03531411f, -0.02818891f, 0.03403226f, -0.07557648f, 0.03361027f, -0.01980956f, 0.03918708f, -0.07480210f, 
    -0.01927628f, 0.01362506f, -0.07663648f, 0.02697914f, 0.02949548f, -0.01004136f, -0.07583164f, -0.02439330f, 
    -0.04191148f, -0.06770419f, -0.03935195f, 0.01030067f, -0.01268223f, 0.05204022f, 0.00188246f, -0.05276420f, 
    0.00328718f, 0.06226319f, -0.00646612f, 0.04483208f, 0.01366038f, 0.04387357f, -0.03274291f, 0.00630820f, 
    0.04636993f, -0.07083535f, -0.06640960f, 0.05704052f, -0.07200770f, -0.07269411f, -0.07409637f, -0.03282893f, 
    -0.07837125f, -0.03835347f, 0.04807535f, -0.06587964f, 0.02452339f, 0.02197369f, -0.02517742f, 0.00320436f, 
    -0.03462116f, -0.00317981f, 0.05928248f, -0.00200582f, -0.03756313f, -0.01307227f, -0.04259449f, -0.07592274f, 
    0.04841710f, -0.03798175f, -0.03066044f, 0.02615036f, -0.02255324f, -0.00793460f, 0.00179519f, 0.05419474f, 
    -0.05446525f, -0.04024699f, 0.05738666f, -0.02153420f, -0.07429615f, -0.06920853f, 0.04545291f, 0.05208927f, 
    0.03900280f, 0.04544523f, -0.03705011f, -0.06417903f, -0.07566722f, -0.04696441f, 0.04860790f, 0.04745060f, 
    -0.00952945f, -0.04216732f, 0.01559304f, 0.01237484f, -0.05351982f, 0.01867808f, -0.06779213f, 0.01117590f, 
    0.00162871f, 0.03462723f, -0.07151207f, -0.03566266f, -0.02907473f, -0.07506297f, 0.01429757f, 0.01975417f, 
    0.05635300f, -0.02587907f, -0.02319298f, -0.07101128f, 0.06098547f, 0.03550263f, 0.03828032f, 0.04476640f, 
    -0.04047617f, 0.00095303f, -0.00497110f, -0.07101487f, -0.05042651f, -0.02527281f, -0.07719503f, -0.06497126f, 
    -0.06590202f, 0.00747913f, 0.04769617f, -0.05023319f, -0.01124484f, -0.02055053f, -0.06650650f, -0.01080687f, 
    0.03732327f, 0.05004748f, 0.02038251f, 0.00764750f, -0.00179311f, -0.00877966f, -0.00488330f, 0.01657136f, 
    -0.40266186f, 0.05909831f, -0.11122785f, 0.01963587f, 0.02118904f, 0.01043194f, 0.08473572f, 0.01200083f, 
    -0.14619589f, -0.02134809f, -0.09797679f, -0.03600578f, 0.38155970f, -0.06691597f, -0.18118954f, 0.03348120f, 
    0.09490504f, 0.24540795f, 0.07312622f, -0.01695398f, -0.15491733f, 0.09909984f, 0.01316084f, 0.08566852f, 
    -0.03965007f, -0.02492505f, -0.20671454f, -0.07166126f, 0.18974474f, -0.07934746f, -0.10358714f, 0.03184139f, 
    -0.02502395f, 0.08053245f, -0.19887936f, 0.07368611f, 0.32695401f, 0.06890713f, 0.13466516f, -0.24224849f, 
    0.18811360f, 0.00634794f, -0.05763830f, -0.04489724f, 0.16070011f, -0.00934177f, -0.06761038f, -0.02239620f, 
    0.02629670f, 0.31364495f, 0.14654100f, -0.17863470f, 0.15036210f, 0.10080957f, -0.05618559f, 0.01965958f, 
    -0.07611504f, 0.04713958f, -0.03430991f, -0.02787152f, 0.18284923f, -0.08025253f, -0.19807422f, 0.16055675f, 
    -0.09492387f, -0.02705290f, -0.08328459f, 0.02356874f, -0.08547053f, -0.05253874f, -0.07188756f, -0.25315234f, 
    -0.00319178f, 0.02438662f, 0.14418437f, -0.01709385f, -0.04515915f, -0.08700980f, 0.05750223f, 0.00099563f, 
    -0.05600619f, -0.00370444f, 0.15920877f, -0.01298922f, 0.05078796f, 0.26542139f, -0.04158288f, 0.16882709f, 
    0.10949135f, -0.05371072f, -0.05783048f, -0.09145741f, 0.09869915f, -0.09358885f, -0.09303387f, -0.17698196f, 
    0.28405192f, -0.06573708f, -0.10168402f, -0.13352197f, 0.04957581f, 0.20795597f, -0.12727755f, 0.04378060f, 
    -0.01944392f, 0.14846337f, -0.12017577f, 0.02876467f, -0.32907864f, 0.23293597f, -0.02059975f, 0.09574046f, 
    0.04927213f, 0.00467074f, -0.07628280f, -0.01960717f, 0.00174069f, 0.00865374f, 0.02393283f, 0.07387626f, 
    -0.01470086f, 0.26860851f, -0.01223184f, -0.25806737f, -0.05409427f, 0.06616799f, -0.11216338f, 0.06033180f, 
    0.05032356f, 0.09866755f, 0.16932730f, -0.09005292f, -0.10674933f, 0.11008727f, -0.10073593f, -0.17730017f, 
    0.07270773f, -0.01581521f, -0.24674724f, -0.01429779f, 0.04299212f, 0.03161283f, 0.03587305f, 0.10066719f, 
    0.14213751f, -0.05546091f, -0.00979053f, 0.13276373f, 0.16381802f, -0.04136109f, 0.16648215f, -0.11184432f, 
    -0.09066563f, 0.07254846f, -0.04277931f, -0.09704388f, 0.01291051f, -0.30835196f, 0.10549550f, 0.24574131f, 
    0.16848570f, -0.00395433f, 0.13729800f, 0.17920913f, -0.00431477f, 0.03523477f, 0.12303281f, 0.06762663f, 
    0.17703466f, 0.04930693f, 0.05144883f, 0.40657479f, 0.06732628f, 0.18486103f, -0.15995489f, -0.08155455f, 
    0.00585939f, 0.03189227f, 0.05708627f, -0.12254194f, 0.32652989f, 0.17618395f, -0.01704029f, 0.03497800f, 
    -0.00421678f, 0.14982039f, -0.11367267f, 0.03660714f, 0.03027859f, 0.05642442f, -0.05975153f, -0.02643362f, 
    0.28090554f, -0.05221596f, -0.01311667f, 0.22959693f, 0.02217120f, -0.02144233f, 0.06479601f, 0.04291976f, 
    -0.10474522f, 0.05129364f, 0.00707568f, -0.11951863f, -0.26549619f, 0.00163940f, 0.12452585f, -0.08484349f, 
    -0.02036268f, 0.04680811f, -0.03226315f, -0.02703837f, -0.12418172f, -0.02855273f, 0.06447897f, 0.26041150f, 
    0.30746967f, -0.06788522f, 0.20940998f, 0.05596931f, -0.01500862f, 0.03686265f, 0.04119032f, 0.08726206f, 
    0.04775792f, 0.04673056f, -0.00809338f, 0.01287052f, 0.35900551f, 0.03279519f, -0.20236744f, -0.03017925f, 
    -0.21997532f, -0.30958053f, 0.02073236f, 0.02769510f, 0.10692089f, 0.13207370f, 0.00102101f, -0.04743764f, 
    0.02958769f, 0.02373263f, -0.23215732f, 0.05800018f, -0.01794886f, 0.12504405f, -0.11242484f, 0.07598349f, 
    -0.11775647f, 0.10781337f, 0.01323401f, 0.04830905f, -0.15410480f, -0.00641622f, -0.07818449f, 0.05885847f, 
    0.18672977f, 0.16848733f, -0.04453153f, 0.11079631f, 0.06860458f, -0.05537032f, 0.07274734f, -0.34128991f, 
    -0.14081894f, 0.37462196f, 0.01362910f, 0.23481256f, -0.16557492f, -0.04195542f, 0.05021756f, 0.06096078f, 
    0.13252473f, 0.13315164f, 0.01456534f, 0.04743442f, 0.20380452f, 0.09398787f, -0.13797855f, 0.01753480f, 
    -0.03977858f, 0.04429043f, 0.06010645f, -0.05517994f, -0.18431747f, -0.28422442f, -0.08181139f, -0.13044333f, 
    -0.14078152f, 0.06029901f, -0.00489149f, 0.16349573f, 0.06145610f, 0.06815904f, 0.05208617f, -0.26847067f, 
    0.00552118f, -0.06149603f, 0.02614375f, 0.21544766f, -0.00051309f, 0.16227293f, -0.09760667f, 0.16844741f, 
    0.08849964f, 0.18620205f, -0.01929501f, -0.02599865f, 0.01874580f, -0.11104748f, -0.03486250f, 0.15194426f, 
    0.01962116f, 0.11307387f, -0.15952107f, 0.22151804f, 0.02630573f, 0.05016844f, 0.04020289f, 0.03044763f, 
    0.07710940f, -0.04914575f, 0.16771057f, -0.03647803f, 0.46774358f, -0.07003780f, -0.05252166f, 0.01969483f, 
    -0.16575490f, -0.04184238f, 0.02821235f, 0.05409148f, 0.08686725f, -0.02331355f, -0.01220321f, -0.07253838f, 
    0.25857648f, -0.21060404f, -0.02080341f, 0.07015888f, 0.08673927f, 0.02043471f, -0.04813006f, -0.02226586f, 
    0.10173089f, -0.01350256f, -0.07537886f, 0.14256386f, 0.19225934f, 0.15522234f, -0.09317349f, -0.20318297f, 
    -0.00388424f, -0.06998097f, 0.11684166f, 0.13137084f, -0.05057342f, 0.20228031f, -0.09500881f, -0.01507969f, 
    0.24091735f, -0.32055518f, -0.14926928f, -0.14468171f, -0.04375515f, -0.24424525f, 0.19740759f, 0.03997508f, 
    -0.06858030f, 0.02640431f, 0.07043186f, -0.15478763f, -0.18098299f, 0.20329911f, 0.11894087f, 0.04248068f, 
    -0.12828402f, 0.07203806f, 0.08565849f, -0.13001710f, 0.08382633f, -0.04189679f, 0.02657930f, -0.07972910f, 
    -0.09179536f, 0.23055714f, 0.14874794f, -0.00739046f, 0.05085829f, -0.06034680f, 0.00907715f, 0.08879162f, 
    -0.13956368f, 0.08693878f, 0.11944089f, 0.02466867f, -0.40252811f, 0.19977883f, 0.00824786f, -0.20172004f, 
    0.15676633f, -0.13029589f, 0.05537267f, 0.08430775f, 0.00671586f, 0.04951149f, 0.06372550f, -0.05467386f, 
    0.13952988f, 0.06717670f, 0.30477223f, 0.12583230f, 0.00885616f, 0.17594437f, 0.15847601f, 0.00277503f, 
    0.12218270f, 0.06255842f, 0.20250307f, 0.01655482f, -0.07307239f, -0.21663707f, -0.00587201f, 0.03235398f, 
    -0.08899321f, 0.02905176f, 0.04747611f, -0.04427696f, -0.15005274f, -0.07763701f, 0.02776850f, 0.05987116f, 
    -0.10248323f, -0.18229784f, -0.08579092f, -0.02806013f, 0.09664086f, 0.03711668f, -0.06142969f, -0.08695028f, 
    0.01919617f, -0.09060058f, -0.14690700f, -0.04571814f, 0.19228792f, -0.12234312f, 0.04621404f, -0.14132993f, 
    0.13225447f, -0.14598219f, -0.04248029f, -0.09729055f, -0.03799158f, 0.10404278f, 0.14478862f, 0.35045892f, 
    0.31320274f, -0.11209720f, -0.06618646f, 0.13587233f, -0.01516903f, 0.13075270f, 0.04691193f, 0.11742838f, 
    0.05898562f, 0.07307182f, -0.19116959f, -0.18518865f, -0.07673132f, -0.16960797f, -0.18651368f, -0.08495352f, 
    0.08122727f, -0.05221428f, 0.10516580f, 0.03936592f, -0.00965222f, 0.32723957f, 0.10891486f, 0.25448814f, 
    -0.20168091f, 0.15411367f, -0.08511785f, 0.12745602f, 0.06125874f, -0.17763439f, -0.01337260f, 0.05401419f, 
    -0.03625138f, -0.06889372f, -0.01338303f, 0.06471923f, 0.08341639f, -0.05468919f, 0.03277301f, -0.13815381f, 
    0.17264667f, -0.03317475f, -0.16212681f, -0.01804872f, -0.21357092f, 0.08827684f, -0.06622795f, -0.02239492f, 
    0.15078737f, 0.24993993f, -0.20624882f, 0.29376510f, -0.04873701f, 0.07750573f, -0.03664391f, -0.03326483f, 
    -0.01410444f, 0.01083169f, 0.06719058f, 0.03621459f, -0.00072535f, 0.17522140f, 0.13964528f, 0.15980168f, 
    -0.03950954f, 0.04942470f, 0.09409465f, -0.10767304f, -0.14364521f, -0.07364537f, -0.06310271f, -0.04269150f, 
    -0.01665671f, 0.09264578f, 0.27676770f, -0.03246011f, -0.06936140f, -0.11597592f, -0.18016186f, -0.04232721f, 
    0.03015905f, 0.03774357f, 0.00820134f, -0.04156602f, 0.08380882f, 0.29862416f, -0.14924550f, -0.26516157f, 
    0.08450716f, 0.00318413f, -0.06066487f, -0.00343550f, 0.01625681f, -0.00249679f, -0.17436957f, -0.14309080f, 
    0.29575023f, -0.00932070f, 0.19649571f, -0.04765604f, 0.20830394f, 0.15094307f, 0.02382449f, 0.08652974f, 
    -0.02950292f, 0.01710198f, -0.11253980f, 0.15214179f, -0.20083785f, 0.25699309f, 0.05902448f, 0.01537777f, 
    0.21247903f, -0.04560408f, -0.01185331f, -0.05865303f, 0.02767627f, 0.01315235f, 0.06542281f, 0.07037698f, 
    -0.18357000f, 0.16745079f, 0.19213833f, -0.25360268f, -0.00833383f, 0.10884877f, 0.03430332f, -0.01976069f, 
    -0.04205638f, 0.01476069f, 0.13608328f, 0.13015509f, -0.50440776f, 0.10054397f, -0.08204718f, -0.09962770f, 
    0.13775995f, -0.03950918f, 0.13331592f, 0.15021732f, -0.11084423f, 0.07749671f, 0.04197907f, -0.05840859f, 
    -0.02033066f, -0.25703731f, -0.06874073f, 0.13824162f, 0.07880653f, 0.06000746f, 0.11076736f, -0.03942217f, 
    0.18176563f, 0.08067276f, 0.07894420f, 0.02912476f, 0.30935416f, -0.05999574f, 0.17400666f, -0.18558697f, 
    0.06127027f, 0.05309616f, -0.01670365f, -0.05679340f, -0.01132421f, 0.04401550f, -0.00982209f, -0.03305588f, 
    -0.13190602f, 0.01744084f, -0.17391135f, -0.28619194f, 0.01178127f, -0.00234502f, -0.03152936f, 0.01581617f, 
    0.10392161f, -0.04915506f, -0.07129107f, 0.06959516f, 0.06638177f, -0.14076452f, -0.14186461f, 0.12383885f, 
    0.00601947f, -0.08267763f, 0.09304906f, 0.05169112f, -0.03379150f, 0.04665490f, 0.04007884f, 0.15476884f, 
    -0.40810424f, 0.09760047f, -0.00940850f, 0.13957681f, 0.11451604f, 0.05444464f, -0.09632598f, 0.01438223f, 
    0.02962745f, 0.10787715f, 0.02418299f, -0.14118664f, 0.06314334f, 0.07547745f, -0.03962598f, -0.01799184f, 
    0.03686788f, 0.01762228f, 0.04532938f, 0.13475490f, 0.01301051f, 0.04782576f, -0.11081134f, 0.05901004f, 
    -0.30858451f, 0.07045116f, -0.01012616f, -0.06166181f, 0.02977911f, 0.10126295f, 0.15078010f, 0.33508745f, 
    0.00855221f, -0.02341896f, -0.11531536f, 0.16478659f, -0.06859899f, 0.07019594f, -0.03872808f, 0.12016166f, 
    0.04807341f, -0.09966820f, -0.10604193f, -0.09516040f, 0.01522167f, 0.04519602f, 0.15512529f, -0.11764061f, 
    -0.12462636f, 0.17928356f, 0.01472904f, 0.08386422f, -0.00667844f, 0.16604899f, -0.03327243f, 0.13753821f, 
    0.01782225f, -0.04637770f, 0.01724312f, 0.00954611f, -0.06484398f, 0.10587397f, 0.06667305f, 0.21050599f, 
    0.08538188f, -0.10291507f, -0.12938321f, 0.09902981f, -0.11332358f, -0.05239872f, 0.01032819f, 0.24549556f, 
    -0.38061920f, 0.38390556f, 0.14874944f, -0.12563315f, 0.01833061f, -0.02918638f, -0.05307913f, -0.16656849f, 
    -0.00827970f, 0.01711502f, -0.01629774f, -0.15094371f, -0.42159373f, 0.16912283f, -0.12002694f, -0.07494978f, 
    0.19534564f, 0.06438810f, 0.18262722f, -0.09750102f, -0.08163960f, 0.05367952f, -0.00081685f, -0.15942590f, 
    0.04586495f, 0.05997102f, -0.05162289f, 0.09786274f, 0.12562408f, 0.11308993f, 0.06968082f, -0.08005523f, 
    0.15140124f, 0.15109628f, -0.02354435f, -0.03080828f, -0.27345085f, 0.20661637f, -0.10769603f, -0.14133342f, 
    0.13176948f, 0.03732451f, 0.04244031f, 0.02974718f, -0.04133999f, 0.03836171f, 0.01681345f, 0.19829918f, 
    0.26245859f, -0.16242741f, -0.17363916f, -0.00554658f, 0.18342912f, 0.13874383f, 0.14402278f, 0.08305040f, 
    -0.05154859f, -0.08643772f, -0.06397058f, 0.00487425f, 0.06294980f, 0.18007018f, -0.17926283f, -0.05047635f, 
    -0.02127099f, 0.09636307f, 0.03519614f, 0.02719674f, 0.05467255f, 0.08871838f, 0.05493900f, 0.08929290f, 
    0.13626698f, -0.18217438f, -0.19322881f, 0.07663099f, 0.20213342f, -0.16824743f, 0.01238774f, 0.01140446f, 
    -0.16607685f, -0.10220395f, -0.20485723f, 0.10972523f, -0.09494948f, 0.03276319f, -0.08657642f, -0.26014838f, 
    0.13107960f, 0.05430465f, 0.03481874f, -0.06567663f, 0.18507873f, 0.10476882f, -0.13020062f, 0.04476769f, 
    -0.00284189f, 0.05931463f, 0.04657430f, -0.35291687f, -0.00388342f, 0.11185734f, 0.04088328f, 0.19502175f, 
    -0.00610782f, 0.12063931f, 0.01179960f, 0.11671387f, 0.16498213f, 0.25964227f, -0.13312565f, 0.14517662f, 
    -0.05374989f, 0.04602266f, 0.01621265f, 0.09658770f, -0.03575735f, -0.01159186f, -0.13159508f, -0.31037593f, 
    0.27551964f, 0.32092333f, 0.18057971f, 0.05351242f, -0.04750283f, -0.16653000f, 0.13638651f, 0.13000084f, 
    0.05170608f, 0.14157166f, 0.03459749f, -0.03835744f, 0.01337299f, -0.03798986f, -0.04263550f, 0.31464738f, 
    0.04759260f, -0.01108534f, 0.01948691f, -0.14162523f, 0.09043049f, -0.09215261f, -0.10122108f, -0.06068846f, 
    0.21550360f, 0.03765491f, -0.37733376f, -0.17345680f, -0.05228958f, 0.22265199f, -0.15723233f, 0.12067480f, 
    0.08376859f, 0.13812980f, 0.02949764f, 0.08960327f, -0.18980148f, 0.12848298f, -0.16019161f, 0.12951899f, 
    0.01922212f, -0.05845061f, 0.16082464f, 0.00395473f, 0.01468272f, 0.02687148f, -0.16419958f, 0.11409149f, 
    -0.21261741f, 0.18100022f, 0.02950934f, -0.19101737f, -0.12156465f, 0.15991454f, -0.00408506f, 0.16346774f, 
    0.09940515f, 0.10268522f, 0.06525061f, -0.04072601f, -0.10646517f, -0.03912018f, 0.00070041f, 0.05448890f, 
    0.12525991f, 0.00854486f, -0.11176847f, -0.04211106f, 0.15318283f, 0.06471941f, -0.01554382f, 0.00557417f, 
    0.23609722f, -0.22718468f, -0.12190121f, 0.10267387f, 0.10216663f, -0.02371483f, 0.09346461f, -0.18907863f, 
    -0.04591142f, -0.06296588f, 0.00876614f, 0.00544240f, 0.07617363f, -0.16643116f, -0.02325222f, 0.20953634f, 
    0.04007568f, -0.06770504f, 0.16206780f, 0.09302112f, 0.05525708f, 0.07934529f, 0.15522790f, 0.01444957f, 
    0.37520924f, -0.06110182f, 0.13096355f, 0.33886418f, -0.09016921f, -0.04628763f, -0.07438780f, 0.06403463f, 
    -0.01868187f, 0.02764264f, 0.07625467f, -0.20588434f, -0.09866387f, 0.08087004f, 0.07951535f, -0.07382257f, 
    -0.04486051f, 0.06911056f, -0.11509244f, -0.02160682f, 0.00398371f, -0.01069059f, 0.02318546f, -0.04968577f, 
    0.28535661f, -0.14103667f, 0.20203599f, -0.04509579f, 0.03177293f, 0.03349085f, 0.11525861f, -0.00186727f, 
    0.05309026f, 0.02224043f, 0.00941114f, 0.12458526f, -0.01059806f, -0.17085427f, 0.09525868f, 0.12930070f, 
    0.05083333f, -0.07172284f, 0.01054754f, 0.08086853f, 0.26950186f, 0.16491473f, -0.05503574f, -0.08715655f, 
    0.14095698f, -0.40792820f, -0.23064326f, -0.10749651f, -0.11359902f, -0.18433864f, -0.06602962f, 0.08657964f, 
    -0.07898104f, 0.09313765f, 0.18486607f, -0.11325701f, -0.43782273f, 0.36012748f, 0.04779774f, 0.31882581f, 
    0.07128759f, 0.06225829f, 0.11415687f, -0.09226371f, -0.08538876f, 0.01993045f, -0.05966698f, 0.02675321f, 
    -0.06704085f, 0.17318471f, 0.11077733f, -0.12995180f, 0.12847641f, 0.04325234f, -0.01511527f, 0.06724519f, 
    0.08762545f, 0.17021531f, 0.20100538f, 0.04877621f, 0.11969920f, 0.15168013f, 0.09635936f, 0.14554857f, 
    0.07309999f, 0.01505995f, 0.07177152f, 0.08211447f, 0.06758039f, 0.07341486f, -0.14779176f, 0.13948150f, 
    0.45899817f, -0.01097426f, -0.03341108f, -0.22778609f, -0.10983531f, 0.14446375f, -0.00987482f, 0.06613351f, 
    0.03591890f, 0.00590385f, -0.02964843f, 0.04356191f, -0.02768206f, 0.07544805f, 0.10531811f, -0.24815941f, 
    -0.01037922f, 0.04133705f, -0.15374397f, -0.07311675f, 0.11554608f, 0.05794698f, 0.02848118f, 0.17834415f, 
    0.19340345f, -0.04544804f, 0.07416373f, -0.31470028f, -0.01632435f, 0.11834949f, -0.15660155f, 0.03102649f, 
    -0.13442457f, 0.06181585f, 0.03543005f, -0.19767258f, 0.24499573f, -0.07320683f, 0.26757804f, -0.31109813f, 
    0.00122337f, 0.06098446f, 0.20987867f, 0.00332652f, -0.05680595f, -0.12300653f, 0.06039228f, -0.00098859f, 
    0.23203827f, -0.14272462f, 0.16018043f, -0.04343961f, 0.03974954f, 0.07943743f, 0.10370223f, -0.01300475f, 
    0.04225899f, 0.09316749f, 0.02729478f, -0.06951556f, 0.13037698f, -0.06310176f, 0.16370648f, 0.37250102f, 
    0.02862317f, -0.03319313f, 0.11551672f, 0.01796185f, -0.11737658f, 0.06857908f, -0.01645519f, 0.01757744f, 
    0.19271305f, 0.00158840f, 0.10940041f, 0.08858033f, 0.06833586f, 0.07857794f, -0.06734297f, 0.18454446f, 
    -0.17410317f, 0.06723456f, -0.14943720f, -0.05391924f, -0.01648494f, -0.12069324f, 0.02297195f, -0.33353952f, 
    -0.06367981f, -0.03214914f, -0.08170690f, -0.04232107f, -0.01461286f, -0.06760493f, -0.02908909f, 0.10287131f, 
    -0.04250129f, -0.02446046f, -0.20015952f, -0.13419959f, -0.06688612f, -0.10926518f, 0.07258593f, -0.03558778f, 
    0.11282516f, -0.08074996f, 0.07600441f, 0.02027521f, -0.18232697f, -0.47063491f, 0.20309365f, -0.02789461f, 
    0.05254506f, 0.08347446f, -0.02149921f, -0.00313007f, 0.14349046f, -0.04014049f, 0.05562387f, -0.02567101f, 
    -0.25059354f, -0.35158294f, 0.03467114f, 0.13378312f, -0.05048188f, -0.08710634f, 0.00182366f, 0.06855812f, 
    0.10682141f, -0.13092358f, 0.13182664f, 0.10970335f, 0.02946406f, 0.24988651f, -0.06039893f, 0.10190202f, 
    -0.06323973f, 0.01750985f, -0.02654229f, -0.03550595f, -0.00374268f, 0.07955948f, 0.07217224f, -0.03187538f, 
    0.06287854f, -0.00750216f, 0.05157258f, -0.18414479f, 0.08476093f, 0.03718844f, 0.03818804f, -0.00578188f, 
    0.02668606f, -0.05511542f, -0.01512531f, 0.12547359f, -0.06575228f, 0.12991889f, -0.07530136f, -0.17659630f, 
    0.07019747f, -0.07372411f, -0.07896520f, -0.06293326f, 0.13693747f, 0.00130621f, -0.02842313f, -0.07824241f, 
    0.36540624f, -0.03312876f, -0.01733666f, 0.22751676f, 0.05245586f, 0.11896219f, 0.05753061f, 0.03026268f, 
    -0.11623558f, 0.03867796f, 0.15475664f, -0.03826410f, 0.10049132f, 0.11617250f, -0.15216918f, -0.10197777f, 
    -0.05813633f, 0.09201501f, 0.06092055f, 0.13469915f, 0.11846024f, 0.07351140f, 0.03220806f, -0.01482125f, 
    -0.00465243f, -0.12689848f, 0.03458640f, -0.19137616f, 0.03202026f, -0.01139666f, 0.09061944f, -0.15991956f, 
    0.25029799f, 0.03122708f, 0.19521900f, -0.11172380f, 0.06029120f, -0.07328121f, 0.18763562f, 0.12419453f, 
    -0.00958979f, -0.04586678f, -0.03692628f, 0.11335310f, 0.20647217f, 0.08919036f, -0.00008170f, -0.09027007f, 
    0.02865406f, -0.09905916f, -0.10848384f, 0.23386618f, 0.00335921f, 0.02270958f, -0.05991316f, 0.14554214f, 
    0.07845684f, -0.15023285f, 0.08210313f, 0.07925063f, -0.32041755f, -0.16799995f, -0.10042718f, 0.42909989f, 
    -0.02219516f, -0.07172850f, 0.01946577f, 0.24603668f, 0.19123891f, 0.03933875f, 0.10072173f, 0.02689323f, 
    -0.21558058f, -0.08211016f, -0.02349040f, 0.09013148f, 0.06570778f, -0.02283398f, 0.09078797f, -0.18768263f, 
    0.03548032f, 0.03146487f, -0.06980348f, 0.13788661f, -0.09054664f, 0.07384461f, -0.17023310f, -0.34675720f, 
    0.08057501f, -0.03523846f, -0.04157268f, -0.06941119f, 0.17102788f, 0.03639006f, 0.06563950f, -0.07842068f, 
    -0.16324176f, 0.26199177f, -0.19320400f, 0.16823062f, 0.07229517f, 0.12565896f, 0.11211885f, -0.16116402f, 
    0.06339931f, -0.09938150f, 0.02689273f, 0.05638837f, 0.11614215f, 0.04174659f, 0.02523448f, 0.24811743f, 
    -0.01669796f, -0.03232144f, 0.04586031f, 0.18614325f, -0.03000627f, 0.02890692f, -0.08605288f, 0.17912127f, 
    -0.02283198f, 0.25328559f, 0.17133862f, -0.07503247f, -0.05146234f, 0.03124924f, -0.05324639f, -0.05661245f, 
    -0.01721703f, -0.11955020f, 0.00760150f, 0.09099990f, 0.12869950f, -0.15405208f, -0.19709487f, 0.10001415f, 
    -0.10547204f, -0.04590837f, 0.02769276f, -0.00527779f, -0.05672496f, -0.11171261f, 0.06170039f, 0.04240160f, 
    -0.00132826f, 0.04555993f, -0.05684256f, 0.00783013f, -0.07611544f, -0.07952411f, -0.03964293f, 0.00614677f, 
    -0.02054567f, 0.05050262f, -0.07056185f, 0.02314590f, -0.05827258f, -0.04700452f, -0.04034100f, 0.00019670f, 
    0.03929804f, 0.03278853f, -0.05777922f, -0.06140718f, -0.02927328f, -0.04428235f, 0.04574413f, 0.05273535f, 
    0.02034665f, -0.00176196f, 0.03178567f, -0.06648648f, 0.01904109f, 0.04642324f, 0.04820403f, 0.03735538f, 
    -0.00760095f, -0.06205541f, -0.06096695f, -0.04014735f, -0.02336332f, 0.02495528f, 0.03561911f, -0.04017768f, 
    0.00843815f, 0.01171163f, -0.01424463f, -0.04069776f, 0.01415786f, 0.05626830f, -0.06668938f, -0.03848669f, 
    0.05610695f, 0.05974537f, -0.02817327f, 0.03635235f, -0.01619269f, 0.04142716f, -0.05857405f, 0.02731674f, 
    0.06581726f, 0.01302223f, -0.01518646f, 0.03550998f, -0.03208329f, -0.04878806f, -0.06907417f, -0.02346309f, 
    -0.01279456f, -0.01631647f, 0.06348246f, -0.06843680f, -0.02631544f, 0.03390080f, 0.03631486f, 0.04862424f, 
    -0.04054628f, 0.01709967f, 0.04367993f, -0.08107638f, -0.02379747f, -0.06939442f, -0.07503637f, -0.00089393f, 
    0.00338499f, 0.03105268f, 0.02767371f, 0.02200061f, -0.01908046f, -0.07060663f, -0.01496381f, -0.02470902f, 
    -0.06310861f, -0.05842726f, -0.08112018f, -0.04695229f, 0.03089322f, -0.07676843f, 0.05338939f, 0.01011696f, 
    0.00179001f, 0.06026339f, -0.03897779f, 0.03161984f, 0.03732178f, 0.03391452f, -0.02868452f, 0.05766848f, 
    -0.06895241f, 0.03104479f, -0.02080963f, 0.02522463f, 0.05995101f, 0.02832562f, 0.05392224f, 0.02976440f, 
    -0.07366110f, -0.02199710f, -0.02672327f, -0.03684393f, -0.01625163f, 0.01855023f, -0.02995973f, -0.06158261f, 
    -0.05780951f, -0.03556722f, -0.06417964f, -0.01741610f, -0.01682010f, -0.01471498f, 0.05951185f, -0.03895937f, 
    0.02449660f, 0.05059631f, 0.05132503f, 0.04156284f, 0.04622104f, 0.05591656f, -0.04350945f, -0.00038472f, 
    -0.04296457f, 0.00494853f, 0.01904837f, -0.00678431f, 0.04326275f, -0.00822277f, -0.00121444f, 0.00919384f, 
    -0.00622559f, 0.00001888f, -0.06733226f, -0.00867417f, -0.00338117f, 0.01839924f, -0.01168103f, 0.00943836f, 
    0.02380052f, -0.03225235f, 0.06515375f, -0.07670253f, 0.01931991f, -0.06178637f, 0.01293304f, -0.05734158f, 
    -0.06324497f, -0.05803597f, 0.02962912f, -0.07400640f, -0.05743119f, -0.04252812f, 0.05240238f, -0.07368176f, 
    -0.05872682f, 0.02026561f, -0.06295911f, 0.02156183f, -0.05349568f, 0.02113943f, -0.00935150f, 0.02113285f, 
    -0.05523647f, 0.03639415f, -0.06013834f, -0.05896283f, -0.04331330f, -0.05911307f, 0.00223780f, -0.01540680f, 
    -0.01691145f, 0.05872336f, 0.01862409f, 0.05059181f, -0.07163919f, -0.05502719f, -0.03615898f, -0.03357730f, 
    0.34420809f, -0.08460458f, 0.20213440f, 0.18490593f, 0.01833351f, 0.00321106f, 0.09422370f, -0.02704822f, 
    -0.01350947f, -0.11778929f, -0.19147107f, 0.08004267f, 0.13100700f, -0.31769881f, 0.11098213f, -0.02066801f, 
    -0.04280243f, -0.04762624f, 0.02404853f, 0.08343335f, 0.14300343f, 0.09935841f, -0.00061852f, 0.27259207f, 
    -0.02310397f, -0.01640692f, -0.05982102f, 0.13007572f, -0.18815833f, -0.06413329f, -0.04508514f, 0.02716841f, 
    -0.07684009f, 0.23616503f, 0.00943293f, 0.06802535f, -0.35743746f, 0.03853619f, -0.02293949f, 0.15898065f, 
    -0.05258981f, -0.01544452f, 0.18158323f, -0.04122645f, -0.02087159f, 0.11019994f, -0.08655559f, -0.02781440f, 
    -0.45811179f, 0.05395498f, -0.01287850f, -0.42601329f, 0.16067117f, 0.08898947f, -0.07808740f, 0.07498091f, 
    -0.08629941f, 0.14429326f, 0.07833795f, 0.02616941f, 0.16303477f, 0.21331848f, -0.03104609f, 0.28071931f, 
    0.08016684f, 0.15755908f, 0.07951705f, 0.05809740f, 0.07689474f, -0.12472601f, -0.03063259f, -0.14267927f, 
    0.43993261f, 0.18527652f, -0.09279311f, -0.09307420f, -0.23047769f, 0.02057617f, 0.07065234f, 0.08434060f, 
    -0.09702783f, 0.06376351f, 0.18782014f, 0.03119644f, -0.07556693f, 0.19274881f, 0.01207180f, -0.36122486f, 
    0.04456204f, 0.17775583f, -0.09270961f, -0.03424859f, -0.05174825f, -0.10529749f, -0.01941306f, -0.07545157f, 
    -0.09341192f, -0.18857208f, 0.25857699f, -0.07525494f, -0.01766732f, 0.11514748f, -0.03623723f, -0.01333312f, 
    0.04796134f, 0.03773422f, 0.10495459f, -0.13724276f, -0.02365613f, 0.28375614f, 0.02126347f, -0.10842256f, 
    0.07429767f, 0.18306655f, 0.24150936f, 0.01015987f, -0.02669314f, 0.00237300f, 0.02771588f, 0.16656572f, 
    0.67989796f, -0.03220161f, -0.00747787f, -0.15804414f, 0.06670094f, 0.03526478f, 0.02323115f, 0.11384304f, 
    -0.02854058f, 0.01538737f, -0.01491733f, -0.19157949f, 0.34540677f, -0.00145319f, -0.04141293f, 0.14756474f, 
    0.06644030f, 0.05216000f, 0.01911865f, 0.01371919f, -0.01826622f, -0.00971826f, 0.04097916f, 0.02717241f, 
    0.10507652f, -0.04469731f, 0.19871673f, 0.15539250f, 0.02470976f, 0.08476000f, 0.09330968f, 0.03497352f, 
    -0.18898360f, 0.11414374f, -0.01967828f, -0.08545918f, 0.12743902f, -0.16128886f, 0.12351869f, -0.13091969f, 
    -0.17784783f, -0.02099994f, 0.10677729f, -0.02115189f, -0.13407065f, 0.13686736f, -0.02594475f, 0.02737713f, 
    0.09734473f, -0.17185648f, -0.07546332f, -0.01686839f, -0.02966572f, -0.24986321f, 0.06562852f, -0.13808309f, 
    0.06565841f, -0.12544337f, 0.05963323f, -0.14806455f, 0.09060603f, -0.23756234f, 0.24092415f, -0.02641329f, 
    -0.09997460f, 0.13389820f, 0.00600230f, 0.00951668f, 0.22396302f, -0.00087158f, -0.13916470f, 0.05298987f, 
    -0.04869222f, 0.27494109f, 0.01917171f, 0.10666212f, 0.13945447f, 0.09486220f, 0.10999645f, -0.09112181f, 
    0.01960720f, -0.12999016f, -0.01084430f, 0.01395330f, 0.08611007f, -0.09056471f, 0.02303254f, -0.11774363f, 
    0.14362557f, -0.05536975f, -0.04532409f, -0.01966255f, 0.05761315f, 0.06650979f, 0.00485933f, 0.18299702f, 
    -0.05714507f, 0.16958368f, -0.22134857f, 0.12487245f, 0.11496274f, 0.00554972f, 0.03730391f, -0.07149785f, 
    0.04175184f, 0.26230431f, -0.11373945f, 0.12414681f, -0.00110592f, 0.07932862f, 0.26389644f, -0.02328664f, 
    0.02691249f, 0.03198641f, -0.11382604f, -0.12020455f, 0.10443696f, 0.06924628f, -0.00765051f, 0.10575690f, 
    -0.19381896f, 0.14661527f, -0.02590087f, -0.17070326f, -0.01862335f, 0.07523468f, -0.19525084f, -0.05835495f, 
    0.01217079f, -0.00717164f, 0.06786171f, 0.04115504f, -0.12088326f, 0.04501041f, -0.02365395f, 0.10229835f, 
    0.00817052f, 0.08436190f, 0.04005535f, 0.02859135f, 0.20265433f, -0.06547213f, -0.13556707f, -0.29987365f, 
    -0.09838419f, 0.05749076f, 0.11808324f, 0.19221005f, 0.02662605f, 0.21380909f, 0.03145036f, 0.10410251f, 
    -0.09903527f, 0.01115787f, 0.34905279f, 0.33934197f, -0.12176016f, 0.36496377f, 0.01751593f, -0.33431193f, 
    0.07628795f, 0.14128384f, -0.04696368f, -0.09754063f, 0.13206771f, -0.18298832f, -0.25630662f, -0.28119114f, 
    -0.03156137f, -0.16564682f, 0.40580955f, 0.18313181f, -0.02753559f, 0.03861390f, 0.06675763f, 0.17633304f, 
    0.04635782f, -0.25262070f, 0.07333759f, 0.13744095f, -0.12409382f, 0.09656791f, -0.05378177f, 0.14543398f, 
    -0.05297299f, 0.15738471f, 0.18893816f, -0.21092294f, -0.05652124f, 0.12492476f, 0.28935534f, -0.00717605f, 
    0.48749992f, 0.10758855f, 0.15972333f, -0.09723063f, 0.16289601f, -0.27400002f, 0.00611137f, 0.16321996f, 
    -0.13824357f, 0.01980481f, 0.12767234f, 0.08456968f, -0.13420106f, -0.01780799f, -0.22535649f, -0.24175805f, 
    0.08284186f, -0.08740897f, -0.18438604f, 0.00621778f, -0.02043339f, -0.13001111f, -0.03128120f, 0.01180030f, 
    -0.34945554f, 0.19514446f, 0.07342392f, 0.00756977f, 0.08573793f, 0.15687381f, 0.02468345f, -0.01784316f, 
    -0.03873948f, 0.18652579f, 0.01043948f, -0.09269871f, -0.22165659f, 0.09392282f, 0.11847779f, -0.01424406f, 
    0.03234472f, 0.05943569f, 0.23685160f, 0.09992323f, -0.09512585f, 0.07301272f, 0.05520173f, 0.01580976f, 
    -0.14469790f, 0.13203622f, -0.17857137f, 0.14026083f, 0.15163904f, -0.02198784f, 0.03523724f, -0.05476285f, 
    0.03637857f, -0.17784265f, -0.08196027f, -0.25845459f, 0.30261478f, 0.04817819f, -0.07855618f, -0.18488559f, 
    0.02122664f, -0.04450160f, 0.19391234f, 0.03943824f, 0.10972763f, 0.06438221f, -0.33233064f, -0.06747641f, 
    -0.45850772f, 0.12209666f, 0.23753908f, -0.39521998f, 0.04351472f, -0.11342007f, -0.16570528f, -0.05486211f, 
    -0.08213719f, 0.15407051f, 0.00934892f, 0.04824065f, 0.19263318f, 0.13059428f, 0.03806993f, 0.14935243f, 
    -0.05825837f, -0.07564392f, 0.03521039f, -0.01106100f, -0.06051950f, 0.04524692f, -0.08768279f, -0.11353327f, 
    -0.18104181f, -0.05747674f, 0.26969227f, -0.14592128f, 0.15584941f, 0.00634277f, -0.04800751f, 0.12335314f, 
    0.03243655f, 0.02462173f, 0.04436212f, -0.05112035f, 0.44367215f, 0.07758325f, -0.00875480f, -0.05958202f, 
    -0.02066204f, 0.03263722f, -0.06820990f, 0.01973950f, -0.11180017f, -0.14219040f, 0.01115361f, -0.00049814f, 
    0.41845241f, 0.20604987f, 0.15956986f, 0.38904738f, -0.03577163f, -0.14929734f, 0.03708178f, 0.00508211f, 
    -0.09680548f, -0.10656093f, -0.03221314f, -0.01676432f, -0.05315047f, -0.38646406f, 0.06079948f, -0.13166383f, 
    0.03266468f, -0.25344920f, 0.00472103f, -0.25766701f, -0.08817722f, 0.14424555f, 0.10542142f, 0.21349844f, 
    0.23295094f, -0.09996570f, 0.01854615f, 0.07069375f, 0.20572045f, 0.16873933f, 0.03305128f, 0.00808785f, 
    0.01620628f, 0.05743073f, -0.11930871f, -0.17406970f, 0.21227708f, -0.04769507f, -0.01693917f, 0.16587232f, 
    0.16510111f, -0.09581022f, -0.05220101f, -0.14867167f, 0.00736982f, 0.20908566f, 0.14072435f, 0.22474411f, 
    0.16033858f, 0.07514238f, -0.15540272f, -0.14369157f, 0.13054276f, 0.15482594f, -0.04665805f, -0.08274329f, 
    0.04653523f, 0.09575055f, -0.12287770f, -0.19191086f, 0.57219487f, 0.03786371f, 0.18314143f, -0.23894599f, 
    -0.01936462f, 0.04500168f, -0.16623536f, 0.10906904f, -0.02993337f, 0.08209047f, -0.08381566f, -0.16184573f, 
    0.17462613f, -0.06525905f, -0.15363644f, 0.03418588f, -0.19522463f, 0.05446779f, -0.05348262f, -0.16006087f, 
    0.10234497f, 0.04914213f, -0.08516148f, 0.07626402f, -0.25810111f, 0.10886315f, 0.09257351f, 0.00730193f, 
    -0.23011085f, -0.09354389f, -0.06280229f, -0.09684328f, -0.17384823f, 0.08928226f, 0.04122894f, 0.01879012f, 
    0.32043627f, 0.16742460f, 0.07185333f, -0.23912464f, -0.12760554f, -0.23987912f, 0.04117477f, 0.14994074f, 
    0.07491902f, 0.04038919f, 0.00935200f, -0.04483865f, 0.09437451f, 0.13376406f, -0.01163643f, 0.00629438f, 
    0.03955391f, 0.08715896f, -0.18195736f, -0.09833868f, 0.23754500f, -0.04694794f, 0.09522516f, 0.14214085f, 
    -0.00301079f, 0.25984800f, 0.15507814f, 0.19548236f, 0.32259053f, 0.19147837f, -0.01772572f, 0.09794576f, 
    0.08513325f, 0.06504380f, -0.11407170f, 0.15944625f, -0.00244841f, 0.08408444f, -0.00126097f, 0.17760316f, 
    0.00593650f, 0.12173463f, 0.03180991f, -0.02690190f, -0.03099577f, -0.14283273f, 0.01665132f, -0.00191844f, 
    -0.18998195f, -0.32899731f, 0.37808830f, 0.02575271f, 0.02377236f, -0.08517678f, -0.03165514f, -0.10704108f, 
    0.02543659f, 0.00119457f, 0.02959270f, 0.11545904f, -0.33782259f, -0.05452745f, 0.13001406f, 0.23226240f, 
    -0.04407667f, 0.08054224f, 0.03441152f, 0.02355135f, 0.07892735f, 0.07972939f, 0.02045788f, -0.08042630f, 
    0.32907167f, -0.26696345f, 0.09260672f, -0.19088276f, 0.07247438f, 0.01864403f, 0.10191657f, 0.03443693f, 
    0.02563971f, 0.08982307f, 0.27220783f, -0.05005769f, 0.16398706f, 0.47933927f, 0.02627637f, 0.21452764f, 
    -0.10818206f, -0.13868922f, -0.13345651f, -0.05040227f, 0.03725555f, -0.14612103f, -0.10064471f, -0.01397705f, 
    0.21063051f, -0.00036007f, 0.03961790f, 0.06457154f, 0.25460580f, 0.02150325f, 0.07818945f, -0.14340442f, 
    -0.11214036f, -0.05944250f, 0.09480761f, -0.01380597f, 0.14702742f, -0.08239168f, -0.28589624f, -0.14356634f, 
    0.04425232f, 0.05522055f, -0.06509159f, 0.03026391f, 0.09002377f, 0.04325869f, 0.10682338f, 0.19651067f, 
    0.21974604f, -0.10876784f, -0.25618061f, -0.11244593f, -0.05048301f, 0.03469088f, -0.03550324f, -0.08023397f, 
    0.28310132f, 0.00596872f, 0.02483492f, -0.20214809f, 0.21255413f, 0.13951747f, 0.06193590f, -0.25109151f, 
    0.00931608f, 0.09612179f, 0.02249292f, -0.00363954f, 0.10636337f, 0.19462135f, 0.12406755f, 0.24954535f, 
    0.16227214f, -0.03131647f, 0.03473717f, -0.02197058f, -0.00214002f, 0.05490610f, -0.12563400f, 0.03220727f, 
    -0.10868894f, -0.01638087f, 0.06201071f, -0.14285065f, -0.10864867f, -0.02888398f, 0.16273321f, -0.07421625f, 
    0.15818168f, -0.06531708f, -0.15168285f, 0.25120831f, -0.04805911f, -0.06810988f, 0.00716196f, 0.04532126f, 
    -0.15519603f, 0.00671723f, -0.17999656f, 0.07458895f, 0.10419226f, 0.08987128f, 0.05578475f, -0.00314005f, 
    0.21986905f, -0.00157170f, 0.13538943f, -0.08142108f, 0.39544049f, 0.20996469f, -0.05041049f, 0.02900036f, 
    -0.10915301f, -0.09259316f, 0.07647572f, -0.04332673f, -0.04415463f, 0.05351109f, 0.02395223f, 0.04961068f, 
    0.33200747f, 0.18493415f, -0.11991595f, 0.01146181f, 0.06195976f, -0.19478145f, 0.04482582f, 0.00368761f, 
    -0.03089430f, -0.01296234f, -0.03542872f, -0.01340296f, 0.39969945f, -0.09468349f, 0.03547871f, -0.38744047f, 
    -0.03102078f, -0.03754306f, 0.03172844f, 0.14996848f, 0.03795347f, -0.05574478f, -0.15355389f, 0.05549242f, 
    0.12821639f, 0.00421839f, 0.00859307f, -0.37211350f, -0.05051222f, -0.00151860f, 0.14502613f, -0.19007891f, 
    0.11986337f, -0.05705412f, -0.05398458f, 0.09645507f, -0.29145998f, -0.25386631f, 0.21754541f, 0.14165510f, 
    -0.06300448f, 0.09048691f, -0.15918605f, -0.03638869f, 0.04199097f, -0.02099766f, 0.14661694f, 0.00752320f, 
    0.07414241f, 0.03039310f, -0.15099426f, -0.14111117f, 0.20763908f, 0.01095682f, -0.16661130f, 0.03819644f, 
    0.04298195f, 0.11397436f, 0.08273844f, -0.12758645f, -0.00059599f, 0.28950110f, 0.01102713f, 0.07189644f, 
    0.05052384f, -0.08096152f, 0.07200841f, -0.03302062f, 0.01896461f, -0.05859883f, -0.01431980f, -0.34530696f, 
    -0.05597762f, 0.11731195f, 0.11283617f, -0.06373939f, 0.10378135f, 0.04393483f, 0.02569937f, 0.07531948f, 
    0.09188850f, -0.11217257f, 0.15177637f, -0.03947116f, -0.11496331f, 0.01851007f, -0.03410206f, 0.12464588f, 
    0.01358581f, 0.09059478f, -0.09705729f, 0.07620085f, 0.00916757f, -0.07116731f, 0.18573444f, -0.02153269f, 
    0.28004396f, -0.25166854f, 0.14296374f, 0.44956899f, -0.02148862f, -0.05608824f, 0.02959941f, -0.04410150f, 
    0.11695717f, -0.12041654f, -0.03513387f, -0.01311756f, 0.06807888f, 0.08314392f, 0.07745705f, -0.26771766f, 
    -0.08371825f, -0.11691245f, -0.10423021f, -0.13268878f, -0.14779712f, 0.06379382f, 0.09817868f, 0.28951129f, 
    -0.01615440f, -0.03053745f, 0.00757513f, -0.03139308f, 0.11780106f, 0.02075678f, 0.06447134f, 0.05386624f, 
    0.04631308f, 0.05330462f, -0.13901585f, -0.02904428f, 0.09274402f, -0.24951179f, -0.00775472f, 0.26239604f, 
    0.00629545f, -0.05961367f, 0.04870725f, 0.09542356f, 0.06356388f, 0.12796947f, 0.19800186f, 0.22974132f, 
    0.13802016f, 0.23696941f, -0.09364142f, 0.04194259f, -0.00964797f, -0.16658339f, -0.00500527f, 0.03539351f, 
    -0.02982211f, 0.01467617f, 0.04093364f, 0.00985178f, 0.30655280f, -0.23857652f, 0.06628142f, -0.11096148f, 
    0.02910634f, -0.18248346f, -0.12465922f, 0.00278791f, 0.05247700f, 0.03524430f, -0.07683193f, -0.11169454f, 
    -0.45723367f, -0.15979388f, 0.09508936f, 0.13513987f, 0.00826843f, 0.08846906f, -0.08962341f, -0.02856555f, 
    0.06898108f, 0.00538842f, 0.00631559f, 0.14519905f, -0.13698815f, 0.07616992f, 0.17397621f, -0.05967516f, 
    0.01046466f, 0.07948554f, 0.07758890f, -0.09507864f, -0.03791625f, 0.04690124f, -0.05263193f, -0.14948995f, 
    0.18579775f, -0.28215510f, -0.13457000f, -0.02834256f, -0.11220945f, -0.04471458f, -0.06511913f, 0.18529786f, 
    0.21131438f, -0.11344574f, 0.00851522f, 0.15909846f, 0.20669802f, -0.00702831f, -0.15068938f, 0.09581843f, 
    -0.00325683f, -0.00017088f, -0.18520941f, -0.01528071f, 0.22181596f, -0.25802317f, -0.02157572f, 0.04961376f, 
    -0.02422410f, 0.10991574f, 0.14613900f, 0.02257552f, -0.03546982f, 0.04813538f, -0.02307495f, 0.21773005f, 
    -0.09562735f, 0.15872817f, 0.08529184f, 0.14845179f, -0.05161576f, 0.04903799f, -0.01961339f, 0.05620458f, 
    0.07833616f, -0.16092141f, 0.06570027f, -0.05351233f, -0.15626669f, -0.03976202f, 0.18885665f, -0.05717861f, 
    0.26528257f, 0.13634953f, -0.04978029f, 0.21888007f, -0.08215555f, -0.07144244f, 0.05460660f, -0.01493281f, 
    0.11134130f, 0.07711635f, 0.07344121f, -0.02850276f, -0.05882410f, -0.11050665f, 0.14196697f, -0.14219114f, 
    -0.05986806f, -0.05024027f, -0.08311489f, -0.05213086f, 0.03164002f, -0.13157989f, 0.00403840f, -0.02119964f, 
    0.28619033f, 0.22554304f, 0.06057426f, 0.10044669f, -0.19017141f, 0.13957869f, 0.11185662f, 0.09365342f, 
    -0.03067325f, 0.03253554f, 0.03371695f, -0.00917391f, -0.40416804f, -0.13654691f, -0.22814217f, -0.02336648f, 
    -0.00278738f, -0.04396106f, 0.02350003f, -0.02114369f, 0.04486425f, 0.03931344f, 0.01484815f, -0.02817876f, 
    -0.22692776f, -0.12939520f, -0.14686987f, 0.06962518f, -0.10008943f, 0.09255923f, -0.08666472f, -0.02205827f, 
    -0.00954042f, 0.00243409f, -0.04068504f, 0.01883724f, -0.14154007f, 0.18921278f, 0.08357928f, 0.07859524f, 
    0.03187198f, 0.08084213f, -0.03444848f, 0.15504462f, 0.17360719f, -0.05638969f, 0.13233355f, 0.01278993f, 
    0.18586901f, -0.00353001f, 0.22791389f, -0.01451506f, -0.03412685f, 0.04245260f, 0.08326698f, -0.09330019f, 
    0.09782242f, 0.01472442f, 0.00620994f, 0.04143770f, -0.20516872f, -0.06499307f, 0.03854508f, -0.14109458f, 
    -0.05599684f, -0.01539911f, 0.06453741f, 0.03506698f, -0.00614177f, -0.07030713f, 0.01345509f, -0.02920746f, 
    -0.18820177f, -0.11435678f, 0.19017662f, 0.30894312f, 0.08672317f, -0.19960076f, 0.05271953f, -0.03442400f, 
    -0.02802928f, -0.11133529f, 0.10813798f, 0.06712271f, -0.11312772f, -0.03861251f, -0.01023556f, 0.05431109f, 
    -0.05832065f, 0.08358459f, 0.08684199f, -0.01465373f, -0.05004176f, 0.00377927f, 0.00347700f, 0.06945612f, 
    0.36412525f, 0.01846914f, 0.01044478f, 0.19774084f, 0.13125047f, 0.00290574f, 0.13061585f, -0.02094445f, 
    -0.04830376f, 0.04666782f, 0.07252868f, 0.10994508f, 0.02007210f, -0.14244181f, 0.12057652f, 0.02339499f, 
    -0.03613619f, -0.07399365f, 0.05871413f, 0.10835072f, 0.15686932f, 0.13168876f, -0.00309302f, -0.07138789f, 
    -0.18435307f, 0.13373160f, 0.13794655f, 0.01018861f, -0.05774864f, 0.13895376f, 0.03942165f, -0.00937916f, 
    -0.05838195f, 0.19533713f, 0.10971332f, -0.03031793f, -0.03238592f, 0.36957109f, 0.07324292f, 0.01618036f, 
    -0.11237780f, 0.01250186f, 0.00398031f, -0.00726093f, -0.09303608f, 0.08819960f, -0.05954051f, 0.08815331f, 
    0.09195554f, 0.09519996f, 0.18818429f, -0.20700887f, -0.00462417f, -0.00453017f, 0.09030426f, 0.03731358f, 
    0.04113702f, -0.03146841f, 0.06437048f, 0.06200932f, -0.02635849f, -0.05659913f, 0.01137151f, 0.01503059f, 
    -0.07181977f, -0.17613035f, 0.17194620f, 0.04458089f, 0.09796007f, 0.04989943f, -0.08765113f, 0.07845566f, 
    -0.18212819f, 0.16001911f, -0.07440134f, 0.14185439f, -0.01342607f, 0.03598825f, -0.04567850f, 0.08873644f, 
    0.24802744f, 0.12722491f, 0.03449856f, 0.08750392f, -0.30217120f, -0.05040365f, -0.05065468f, 0.04034055f, 
    -0.03547853f, 0.17201935f, 0.05819074f, 0.03247969f, -0.04781246f, 0.08287118f, 0.10349602f, 0.03855892f, 
    0.41007355f, -0.33078465f, -0.14415286f, -0.30623543f, 0.10070724f, 0.04653186f, 0.16209529f, 0.04010691f, 
    0.12751296f, -0.12662101f, 0.17314090f, 0.06745552f, -0.02468490f, 0.25219366f, 0.47498006f, 0.26648095f, 
    -0.05283016f, -0.03136641f, -0.03705862f, 0.11679249f, 0.15199925f, -0.05486316f, 0.00372768f, 0.00039060f, 
    -0.21067630f, 0.15851589f, 0.04377121f, -0.12521468f, -0.09437580f, 0.01348172f, -0.05140753f, -0.09036026f, 
    0.09589721f, -0.14880851f, -0.03912980f, 0.27595726f, 0.04722252f, -0.18032284f, -0.09280830f, 0.01209350f, 
    0.00096648f, 0.18636608f, -0.03596858f, 0.19407392f, 0.17674193f, 0.05568182f, 0.12315138f, 0.10205864f, 
    -0.34131876f, -0.20013547f, -0.10931914f, 0.04358252f, 0.13974372f, 0.16163126f, -0.03958268f, 0.00385162f, 
    0.02343089f, -0.07624403f, -0.07970610f, -0.04920018f, 0.02337390f, 0.25839752f, 0.13923666f, -0.18437810f, 
    -0.12381154f, -0.04394718f, 0.11398932f, 0.01592962f, 0.01898723f, 0.16097820f, 0.04371182f, 0.01159027f, 
    0.30535910f, 0.19729675f, 0.03539403f, 0.02123321f, 0.24367997f, 0.00140391f, -0.11222767f, 0.02138882f, 
    -0.04843919f, 0.12483459f, -0.05912252f, 0.14070167f, -0.40844455f, -0.15925838f, 0.21169324f, -0.05513169f, 
    -0.04416396f, -0.11759110f, -0.09430535f, 0.03382000f, -0.02505024f, -0.05773747f, 0.02829628f, 0.06315246f, 
    -0.34782946f, 0.10584479f, 0.13099267f, 0.04942261f, 0.16198808f, 0.10098764f, -0.05282618f, -0.04335639f, 
    0.12547892f, 0.11309646f, 0.11920920f, 0.04573186f, -0.20834185f, 0.33521453f, 0.28532025f, -0.02239285f, 
    -0.16143194f, -0.06172508f, 0.01126882f, -0.06166121f, 0.01429514f, -0.11087725f, 0.05969502f, 0.01562796f, 
    -0.35410583f, -0.21076123f, 0.22929552f, -0.00202852f, 0.07932942f, 0.14386378f, 0.00772617f, 0.00786185f, 
    0.11249338f, 0.07122257f, -0.05243893f, -0.08661167f, -0.00894340f, -0.22495535f, -0.46430805f, -0.33675414f, 
    0.30121037f, -0.04237680f, -0.01251222f, 0.24933161f, -0.02983586f, 0.00719464f, 0.02859475f, -0.02768957f, 
    0.05520369f, -0.32617953f, -0.33105853f, -0.37211028f, 0.20945410f, 0.18301724f, 0.07555383f, -0.03388286f, 
    0.12617150f, 0.08631426f, -0.08360535f, -0.09387773f, -0.21492361f, 0.13626742f, -0.15068522f, 0.06925222f, 
    0.03091641f, 0.13677357f, -0.08289753f, 0.04306686f, 0.03461327f, 0.06146155f, 0.14316621f, 0.13464239f, 
    -0.05743753f, -0.00456622f, 0.05104346f, -0.05792368f, 0.02946969f, -0.04483653f, 0.06020532f, -0.04907580f, 
    -0.06971668f, 0.01352354f, 0.03241226f, 0.01782307f, -0.04933986f, 0.05260750f, -0.04994223f, 0.06150980f, 
    0.04414995f, -0.05978880f, 0.01293162f, -0.05094780f, -0.00914568f, 0.01725669f, -0.08263145f, -0.06506702f, 
    0.02900020f, -0.01324866f, 0.00282147f, -0.04796739f, 0.04853369f, -0.02812787f, -0.02435771f, -0.03385566f, 
    -0.06879245f, 0.00377482f, -0.03046014f, 0.02265765f, 0.03586433f, 0.00499153f, -0.05867936f, -0.00102091f, 
    0.04327460f, -0.07731565f, 0.02228475f, -0.00276187f, -0.04811549f, -0.08133228f, -0.08207042f, -0.07757562f, 
    0.00716782f, -0.02685661f, -0.08065640f, -0.08314259f, -0.00453752f, -0.05089962f, -0.00516297f, -0.00035562f, 
    0.04606149f, 0.05228034f, -0.00985143f, 0.02764790f, -0.01381806f, -0.02188687f, 0.04268885f, 0.02123436f, 
    -0.05850505f, 0.05830473f, 0.05277536f, 0.01285322f, -0.00243905f, 0.02149078f, -0.03006674f, 0.05264256f, 
    0.05503219f, -0.04473106f, -0.07637972f, -0.06004831f, 0.04388149f, -0.00760595f, -0.08516328f, 0.04457386f, 
    0.00790866f, -0.03705850f, -0.05506456f, 0.04405437f, 0.02143017f, -0.02333986f, -0.07410810f, 0.00829507f, 
    -0.01119192f, -0.04293477f, -0.07850315f, -0.01503073f, 0.00187073f, -0.00798349f, 0.02664155f, 0.05667175f, 
    -0.06485790f, -0.06915285f, 0.02173648f, 0.06003493f, -0.02503402f, 0.06518252f, -0.02504824f, 0.06502452f, 
    0.01697478f, -0.05271297f, 0.02489060f, -0.01773797f, -0.07683068f, -0.08012279f, -0.06331232f, -0.02233246f, 
    0.04795808f, 0.06035544f, 0.05729946f, 0.04103938f, -0.06739211f, 0.04629891f, -0.07265984f, -0.06835351f, 
    -0.05209024f, -0.00561867f, -0.02478140f, -0.00470706f, 0.05055381f, -0.07354017f, -0.01024250f, -0.04208810f, 
    0.01543805f, 0.06037572f, 0.05268136f, -0.05729478f, -0.02286779f, -0.02613188f, -0.03895236f, 0.01037647f, 
    -0.02239903f, -0.01307515f, -0.00979819f, -0.05144561f, -0.00091415f, -0.07123373f, 0.01039906f, -0.00032611f, 
    -0.00979577f, 0.02137706f, 0.03516600f, 0.03749678f, -0.03113190f, -0.04970580f, 0.04979911f, -0.04282097f, 
    -0.02581618f, 0.01525887f, -0.01307164f, 0.01111731f, 0.01455992f, -0.03858054f, -0.04346775f, 0.05103077f, 
    0.05669510f, 0.02543420f, -0.06362907f, 0.04431643f, 0.01302381f, -0.03549520f, 0.05307849f, -0.04571550f, 
    -0.02177601f, 0.03887302f, -0.02257757f, -0.07942408f, -0.03312301f, -0.01938397f, -0.06699000f, 0.02079888f, 
    -0.05299209f, -0.01438134f, -0.07570000f, 0.00708922f, 0.02570332f, 0.02454888f, -0.04153756f, 0.01634421f, 
    -0.06355315f, 0.03580351f, -0.02105715f, -0.02264212f, 0.04633746f, 0.06019867f, 0.02271186f, -0.02409140f, 
    -0.16687818f, 0.14987981f, -0.07886434f, -0.21830158f, -0.10687468f, 0.07459812f, -0.10143959f, -0.10645837f, 
    0.02928835f, 0.06115210f, 0.08725304f, 0.02856381f, -0.02944268f, 0.25160408f, 0.03540047f, 0.04539420f, 
    0.02146670f, 0.00038631f, 0.07037169f, -0.00665738f, -0.10159749f, -0.03876343f, -0.08572917f, 0.01488878f, 
    0.09185810f, -0.22978547f, -0.12214093f, -0.20048742f, 0.03925507f, -0.08999441f, 0.01036044f, -0.01687590f, 
    -0.11927624f, -0.12173119f, -0.12611164f, -0.01328068f, 0.00951594f, 0.16506998f, -0.04333648f, -0.18221833f, 
    0.01483624f, -0.05139492f, 0.11335749f, -0.04799043f, 0.02711767f, 0.01686352f, -0.02322051f, -0.10264700f, 
    0.33745596f, 0.29870960f, 0.03512105f, 0.43810442f, -0.25068918f, 0.02984300f, -0.04634036f, 0.15243836f, 
    0.02376051f, 0.11900400f, -0.02533562f, 0.06450626f, -0.26820645f, -0.05197855f, 0.19863378f, 0.11117840f, 
    -0.01260789f, -0.05756576f, 0.00071291f, -0.03873931f, 0.04106702f, 0.00862419f, -0.11738361f, -0.02999164f, 
    -0.34350216f, 0.05438464f, 0.23507620f, 0.11663631f, 0.17250286f, 0.03039659f, 0.03011624f, -0.07702120f, 
    0.00008001f, 0.10176942f, 0.07824433f, 0.12972593f, 0.21490750f, 0.02296048f, 0.12070953f, 0.13847817f, 
    -0.14424761f, -0.15071869f, -0.00254832f, 0.07220418f, 0.05041539f, -0.18378305f, -0.16095150f, -0.05603688f, 
    0.10068535f, 0.16615757f, -0.06009475f, 0.14702538f, 0.06778110f, 0.15638906f, 0.00874417f, 0.10847048f, 
    0.10405400f, -0.05446021f, -0.02139273f, -0.08473200f, 0.41293815f, -0.17748761f, 0.06510052f, 0.03972256f, 
    -0.11857814f, 0.16297875f, 0.18729156f, 0.01674086f, -0.02984613f, 0.07719437f, 0.11845133f, -0.07939834f, 
    -0.04944818f, -0.06330127f, 0.10742620f, 0.33404180f, -0.01395420f, 0.08301812f, 0.08335976f, -0.07681170f, 
    0.03780482f, 0.08944017f, -0.04233880f, -0.00516250f, -0.43991727f, -0.00679251f, 0.31547439f, -0.07494888f, 
    -0.10662404f, -0.07401396f, -0.18509851f, 0.09201059f, -0.02580690f, -0.04331192f, 0.03260982f, 0.06330543f, 
    -0.11651029f, 0.01847215f, 0.06504823f, -0.17179066f, -0.15186469f, 0.17638005f, 0.00494330f, 0.05575811f, 
    0.06330240f, 0.05241686f, -0.02108264f, 0.02032522f, -0.31259221f, 0.30149230f, -0.01463379f, 0.09276070f, 
    -0.01148548f, 0.25122672f, 0.04011574f, 0.04224699f, -0.01844108f, 0.13928103f, 0.16601296f, 0.11952171f, 
    -0.03396810f, 0.06148465f, -0.05287345f, 0.04474802f, 0.05378638f, 0.08971073f, 0.09693333f, 0.19447492f, 
    0.01219825f, 0.08240903f, 0.11056272f, -0.04776276f, -0.20414530f, 0.09084114f, -0.27619797f, 0.05114208f, 
    0.02517256f, -0.03519719f, 0.16630857f, -0.11319260f, 0.06482099f, -0.03422701f, -0.04672717f, -0.02978779f, 
    0.73479372f, -0.35322955f, 0.15840127f, 0.02907887f, 0.01548768f, 0.02912208f, -0.02004015f, -0.01686617f, 
    0.10413195f, 0.04643416f, 0.11625689f, 0.01837431f, -0.39600033f, 0.05486144f, 0.09107112f, -0.05592602f, 
    0.02498137f, 0.06712978f, -0.03891234f, 0.00468440f, 0.16970444f, 0.00792340f, 0.03391905f, -0.19211315f, 
    0.27904812f, 0.02926308f, -0.17875466f, -0.02633037f, -0.04994920f, 0.00338921f, 0.03204766f, 0.07779352f, 
    0.02583544f, 0.03915920f, 0.27618662f, -0.03854878f, -0.29026783f, 0.24049373f, -0.23007946f, 0.17895652f, 
    -0.01204247f, -0.07979454f, 0.04328390f, -0.01499736f, 0.10661627f, 0.03030214f, 0.14410844f, 0.08221071f, 
    0.26844487f, -0.39634961f, -0.09374691f, 0.02789546f, 0.20986758f, -0.11772351f, 0.01903655f, -0.08491442f, 
    0.12442265f, 0.05984038f, 0.15947513f, 0.01593850f, 0.01446460f, 0.42544100f, 0.00757089f, -0.14172128f, 
    0.07785557f, 0.08972169f, 0.06807595f, 0.19197068f, 0.03188044f, 0.10733332f, -0.00274418f, 0.26304907f, 
    0.22359759f, 0.28165445f, -0.11008463f, -0.13111508f, -0.00236571f, -0.06805666f, 0.08694045f, 0.04265401f, 
    0.14020912f, 0.08512162f, 0.01659494f, 0.00295703f, 0.16155092f, -0.31355748f, -0.02187878f, 0.30636582f, 
    -0.00584116f, 0.09548888f, -0.09703603f, 0.01932854f, 0.08559288f, 0.06093186f, 0.09004609f, 0.24493404f, 
    -0.02534688f, 0.13341498f, -0.05490931f, -0.02482748f, -0.12874268f, -0.20903605f, -0.02120654f, 0.09275847f, 
    -0.10307004f, 0.02785172f, 0.12687947f, 0.05418299f, 0.12402441f, -0.08426162f, 0.02044851f, 0.01054622f, 
    0.18880296f, -0.14293529f, 0.09512939f, -0.02337054f, 0.10664446f, -0.05306751f, -0.08616201f, 0.05213667f, 
    -0.38154382f, -0.15804985f, 0.11316326f, 0.13414811f, 0.18568546f, 0.06969635f, 0.08227236f, 0.06178820f, 
    0.17679106f, 0.00114436f, 0.00224027f, 0.06400551f, 0.38669759f, -0.09915084f, 0.05863495f, 0.27064347f, 
    0.00145956f, -0.01660160f, 0.19940396f, -0.11433455f, 0.19271204f, 0.08724772f, -0.15426958f, -0.08499833f, 
    0.15841760f, -0.09085529f, -0.22972129f, 0.05593198f, -0.02759115f, 0.11440070f, 0.03167032f, -0.03962417f, 
    0.16613168f, -0.06830122f, -0.03276554f, 0.15706019f, 0.11732433f, 0.09580316f, -0.23000012f, -0.14356318f, 
    -0.17140473f, -0.09414862f, -0.08554874f, -0.00476638f, -0.00359819f, -0.21281070f, -0.08436635f, 0.03947163f, 
    0.08601052f, 0.13520066f, -0.05624887f, -0.22275242f, -0.31502846f, -0.20936581f, 0.07434729f, 0.04470180f, 
    -0.03434453f, -0.05579155f, 0.10612041f, 0.05345885f, -0.31585526f, -0.22773439f, 0.20075966f, 0.01185261f, 
    -0.06336652f, -0.00503968f, -0.10547934f, -0.02200487f, -0.07670711f, -0.02990832f, 0.33564624f, -0.01768613f, 
    -0.36735183f, 0.05688699f, -0.08971399f, 0.21713358f, -0.04188725f, -0.13544011f, -0.02883508f, 0.03740005f, 
    0.11221948f, -0.03138328f, 0.04394271f, 0.08192078f, 0.40228039f, 0.13624063f, -0.03273783f, 0.02490202f, 
    0.01222896f, 0.05478118f, -0.03305957f, -0.19191214f, 0.00361182f, 0.03785221f, 0.10079753f, 0.04316531f, 
    -0.35808668f, 0.37430742f, 0.30301630f, 0.01511787f, 0.06472049f, 0.10757629f, 0.01097531f, 0.10190751f, 
    0.16011949f, 0.05954415f, 0.05559931f, 0.03347487f, 0.02690844f, -0.15076146f, 0.00071463f, -0.11247990f, 
    0.01149971f, 0.09274846f, 0.00113002f, 0.01138658f, -0.04982811f, -0.03631586f, 0.06797892f, -0.09866135f, 
    -0.01052564f, -0.05211007f, -0.07056824f, 0.21419214f, -0.00414572f, 0.07664642f, -0.00846598f, -0.09936898f, 
    -0.01046405f, -0.12671025f, -0.01187052f, -0.11144368f, -0.02721658f, -0.04348167f, -0.05678758f, -0.14874290f, 
    -0.00027207f, 0.03693087f, 0.05697203f, -0.06965733f, 0.11684884f, 0.03568447f, 0.05939221f, 0.07670185f, 
    0.09372562f, -0.50803727f, -0.03483633f, -0.09571403f, -0.04974041f, -0.04344259f, -0.02904224f, -0.07130378f, 
    -0.01583967f, -0.08019043f, -0.10103085f, 0.06799940f, -0.12878624f, 0.17191243f, 0.08647818f, -0.17247495f, 
    -0.02072317f, 0.06869350f, 0.10940892f, 0.06360906f, -0.06212580f, 0.29448214f, 0.09699203f, -0.00093535f, 
    -0.16731851f, -0.15955704f, 0.02243210f, 0.30352163f, 0.18329230f, -0.11334617f, -0.02831256f, -0.06331287f, 
    -0.02974171f, 0.06199241f, -0.04019859f, 0.07790338f, -0.38535711f, 0.01899855f, -0.08485133f, 0.19871023f, 
    0.03039201f, -0.02769785f, -0.06042839f, 0.13961001f, 0.16223003f, 0.06299623f, 0.13973223f, 0.00780222f, 
    0.01866772f, -0.01785843f, -0.24801719f, -0.08533479f, -0.03814317f, -0.12478139f, -0.03078901f, -0.16859660f, 
    -0.01780031f, -0.08385634f, 0.05572829f, 0.18228830f, -0.03928085f, 0.13576567f, -0.17679447f, -0.45181754f, 
    0.13797034f, -0.00656753f, 0.10682316f, 0.03481128f, 0.13559014f, 0.02156696f, 0.03319708f, -0.01103588f, 
    -0.25845048f, 0.29899862f, -0.07118945f, 0.00192604f, 0.09224048f, -0.00814286f, 0.19177885f, -0.03975653f, 
    0.05230526f, -0.02876630f, 0.17610514f, -0.00009138f, 0.32072100f, 0.17102946f, 0.08871008f, 0.12243174f, 
    0.00810205f, 0.00454348f, -0.07806788f, 0.07835951f, -0.01691516f, 0.07740281f, -0.00138783f, 0.05991904f, 
    -0.07583122f, 0.15891200f, 0.29039919f, -0.11323683f, 0.10445752f, 0.08546209f, -0.11013466f, 0.06104776f, 
    -0.03895842f, -0.14057598f, -0.03488494f, 0.14237748f, 0.33834046f, 0.19127759f, -0.05311663f, 0.11897600f, 
    0.09080884f, -0.07429501f, 0.01842778f, 0.00778179f, 0.02876730f, 0.02727030f, -0.08632694f, 0.13388047f, 
    -0.04797274f, -0.03188540f, 0.05497368f, -0.00923358f, -0.07765208f, 0.02376338f, 0.04787246f, 0.04717360f, 
    -0.00711519f, -0.05161266f, -0.01176983f, 0.04087491f, -0.05191758f, -0.05767322f, -0.08072516f, -0.04492810f, 
    0.04290094f, -0.03336281f, -0.06524904f, 0.00531064f, 0.05719090f, -0.05415870f, -0.04114944f, -0.06153109f, 
    -0.01392244f, 0.01724549f, -0.01653740f, 0.00980216f, -0.00602082f, 0.04942533f, -0.02986844f, -0.06446437f, 
    -0.01909203f, 0.01012614f, 0.00119328f, 0.02848430f, 0.05526116f, 0.04784032f, -0.03348275f, 0.01885834f, 
    0.00107457f, -0.02830282f, 0.00231849f, 0.03724938f, -0.00347646f, 0.01016439f, -0.08018920f, 0.06281765f, 
    0.03117785f, -0.02570927f, -0.05282012f, -0.04077912f, -0.05246342f, -0.02816336f, -0.07254001f, 0.03638259f, 
    -0.07968009f, 0.01480810f, -0.06115508f, -0.02929700f, -0.01853387f, -0.00758928f, -0.02458285f, -0.03865517f, 
    0.05617268f, 0.02276968f, 0.01601169f, -0.01261932f, -0.05758807f, -0.05550165f, 0.01513931f, 0.03990267f, 
    -0.07305747f, -0.03191231f, -0.06696115f, 0.02327015f, 0.04506015f, -0.06436970f, 0.02530292f, -0.06480873f, 
    0.01382719f, 0.04533176f, 0.04611231f, 0.02411507f, -0.00489650f, -0.02791254f, -0.05669453f, -0.06845944f, 
    0.01479307f, 0.03278743f, -0.04771314f, 0.03711896f, -0.07188115f, 0.04632210f, 0.06684764f, -0.05123089f, 
    -0.00047319f, -0.00976542f, 0.00841984f, 0.05398804f, 0.02443115f, -0.04747316f, -0.06523987f, 0.04552003f, 
    0.06490825f, 0.05418810f, -0.08006144f, -0.06159326f, 0.04755154f, 0.03410183f, -0.04430621f, 0.03334571f, 
    0.04637593f, -0.00303828f, -0.05436454f, 0.05105656f, 0.06037420f, -0.03072969f, -0.01005864f, 0.03666719f, 
    0.02779525f, -0.03119868f, 0.01665246f, -0.04887202f, -0.02170159f, -0.03271893f, -0.01429915f, -0.06982441f, 
    -0.07547878f, -0.01849078f, 0.00556069f, -0.05418936f, -0.08492240f, 0.04953602f, -0.06488405f, -0.03232610f, 
    0.00144867f, -0.05118888f, -0.04397933f, -0.02534580f, -0.03790459f, 0.03288100f, 0.01278017f, -0.05636697f, 
    -0.05268506f, 0.04133873f, -0.02991375f, 0.00897297f, -0.07574214f, 0.03756429f, -0.03487464f, 0.01159437f, 
    0.04143482f, 0.04474768f, -0.05298243f, -0.06608028f, 0.01739562f, 0.01532413f, -0.01911134f, 0.05950250f, 
    -0.06269012f, -0.04395621f, 0.01441725f, -0.00186595f, 0.01471012f, -0.00223045f, 0.02864194f, -0.07004756f, 
    0.02757390f, -0.05506676f, -0.05052904f, -0.03662127f, -0.06414770f, 0.02740362f, 0.04838829f, 0.05921874f, 
    -0.03830435f, -0.03478457f, -0.00957486f, 0.01115068f, -0.05682057f, 0.03737986f, -0.00113950f, -0.01533752f, 
    -0.04416450f, 0.03173175f, 0.04549334f, 0.03174166f, -0.04966221f, 0.00157332f, 0.02381316f, 0.05071078f, 
    -0.02349165f, 0.00628740f, -0.06755782f, -0.01738185f, -0.05515134f, 0.03759908f, -0.05077697f, 0.01135915f, 
    -0.05059816f, -0.04921325f, -0.08816449f, -0.01515003f, 0.06537242f, 0.06094678f, 0.05551775f, -0.02506155f, 
    0.05221273f, -0.00483525f, -0.09095160f, 0.03510833f, 0.03907577f, -0.06165334f, -0.05602961f, 0.03317497f, 
    0.01179275f, -0.01552576f, 0.05537372f, -0.01023325f, -0.06635512f, 0.02945962f, -0.03265059f, 0.00399589f, 
    -0.07294779f, -0.01113896f, -0.08948209f, -0.00013363f, -0.00136826f, -0.00253873f, 0.02391905f, -0.07387887f, 
    -0.04091964f, 0.05002142f, 0.06699554f, -0.00935406f, -0.02970895f, -0.03878803f, -0.06582365f, -0.04465405f, 
    -0.03493894f, 0.03093038f, -0.08497480f, -0.08716367f, 0.03739540f, 0.01131343f, -0.00622731f, 0.07587457f, 
    -0.01215730f, -0.04471861f, 0.07042697f, 0.02958241f, 0.01453861f, -0.03183793f, -0.01381455f, -0.06097403f, 
    -0.07387145f, -0.01955153f, -0.06959014f, 0.05744217f, -0.09718642f, -0.07536515f, 0.01714052f, -0.00943185f, 
    -0.01315382f, -0.00724999f, -0.00989816f, -0.08220456f, -0.05378674f, -0.01923404f, 0.01213995f, 0.05139532f, 
    -0.05502335f, -0.05208407f, 0.06209081f, 0.01978539f, -0.03209386f, -0.01107446f, -0.03726995f, -0.00193233f, 
    0.01622794f, 0.01997659f, 0.00993839f, -0.01294764f, -0.06109309f, 0.01159392f, 0.04252852f, -0.00389950f, 
    0.06220094f, -0.01077755f, -0.02159259f, 0.04809836f, 0.02255273f, -0.05580129f, -0.02442964f, 0.04220339f, 
    -0.04580560f, 0.05594609f, 0.04249141f, 0.05673371f, 0.00127434f, 0.01425846f, 0.02017496f, -0.04667611f, 
    -0.05955543f, 0.05692644f, -0.02467280f, -0.01946628f, -0.05634237f, 0.01169225f, 0.06176860f, 0.00056818f, 
    0.02589524f, 0.02991674f, -0.00043679f, -0.01714840f, 0.01392479f, -0.04330795f, -0.02487186f, -0.00221954f, 
    0.00127393f, 0.06005901f, -0.01720068f, 0.01349929f, -0.02846156f, 0.04825633f, -0.04475951f, 0.00981396f, 
    -0.03002503f, 0.06499618f, -0.01229052f, -0.00183200f, 0.01497517f, 0.04302735f, -0.00537527f, 0.04615103f, 
    -0.01255509f, -0.00107698f, -0.03287151f, 0.04828915f, -0.01669370f, -0.04341192f, 0.06662868f, -0.02310665f, 
    -0.03877291f, 0.03700291f, -0.06097183f, -0.01102487f, -0.00640700f, -0.07587932f, -0.04948036f, -0.05949670f, 
    0.01034464f, 0.06728103f, -0.08251560f, -0.04754451f, -0.08454517f, 0.02252545f, -0.01315100f, -0.03406291f, 
    0.03030710f, 0.03918314f, -0.00215323f, -0.04587463f, -0.07560582f, -0.08432653f, 0.03586210f, -0.05239336f, 
    -0.01869188f, 0.02103367f, -0.02422627f, 0.00084481f, -0.02711895f, -0.03976441f, -0.05630073f, -0.04737256f, 
    0.03106829f, 0.03667312f, 0.03429399f, -0.03068806f, -0.04460018f, -0.06020157f, -0.04084148f, -0.08408161f, 
    -0.06362547f, -0.03293759f, 0.01187266f, 0.02718997f, -0.04753805f, 0.01626236f, -0.06273975f, 0.03659761f, 
    0.00501215f, 0.01156030f, -0.07670062f, -0.02441609f, -0.01307043f, -0.06020309f, 0.06564543f, -0.02995025f, 
    -0.01106662f, 0.01535119f, -0.05710995f, 0.03108868f, -0.00351258f, -0.01463785f, 0.03660570f, -0.07287876f, 
    -0.04144358f, -0.00371602f, -0.07337210f, -0.02754018f, -0.03080886f, -0.06112542f, -0.01392257f, -0.02727258f, 
    0.03970413f, -0.02079472f, -0.02682644f, -0.00456180f, 0.00613582f, 0.05702313f, 0.05954645f, -0.05980496f, 
    -0.06886136f, 0.02509901f, -0.06605082f, 0.01235495f, -0.01881589f, 0.00968449f, -0.04557075f, 0.03355626f, 
    0.04718989f, -0.05979903f, -0.06260876f, 0.01148388f, 0.04384513f, 0.00040979f, 0.05261227f, -0.05443322f, 
    0.01469052f, 0.01808410f, -0.05515798f, -0.00002868f, -0.05601897f, -0.06149009f, -0.05499422f, -0.02136672f, 
    -0.00616447f, 0.04369407f, 0.03949736f, -0.04144809f, 0.01720189f, 0.01017122f, -0.05258290f, -0.00750882f, 
    -0.02968857f, -0.03722870f, 0.02218430f, 0.05708172f, -0.07517999f, -0.01009332f, 0.00616965f, -0.02845885f, 
    0.00387188f, 0.00156692f, -0.04980456f, 0.05836914f, 0.05544711f, -0.07114362f, 0.04653464f, -0.05334114f, 
    -0.07627723f, -0.03159633f, 0.06205475f, 0.03489708f, 0.04772279f, -0.05616501f, 0.06240395f, -0.05059331f, 
    0.05577749f, -0.00072205f, -0.05760815f, 0.02057865f, 0.04656223f, -0.06050637f, -0.05433308f, 0.01830643f, 
    0.02982568f, 0.04215933f, -0.01916807f, -0.01783052f, -0.05596502f, 0.05423046f, -0.00993456f, -0.07094028f, 
    0.04714477f, 0.02057970f, -0.04017474f, 0.04360753f, -0.03333835f, -0.02288108f, -0.00682932f, -0.07059578f, 
    -0.02458904f, 0.00494076f, -0.02960362f, 0.00344332f, -0.02476232f, 0.00606280f, -0.07157408f, 0.01524951f, 
    0.02013323f, -0.03848151f, 0.05309654f, -0.01616272f, -0.01386419f, 0.02570481f, 0.01957693f, -0.03706782f, 
    -0.07612684f, -0.03073014f, 0.04961951f, 0.04948641f, 0.03898671f, 0.02807696f, 0.00728552f, -0.04962444f, 
    -0.07117274f, -0.05706619f, -0.03051437f, 0.02441945f, 0.01381402f, 0.02550680f, 0.01250419f, -0.05534994f, 
    -0.05132904f, -0.06494450f, -0.04996960f, 0.00104465f, -0.06465768f, 0.02203736f, 0.05292365f, 0.03977758f, 
    -0.03750212f, -0.05122700f, -0.00864098f, -0.05874559f, 0.00673042f, 0.01772010f, -0.08011195f, -0.01166839f, 
    -0.06315604f, 0.04891371f, 0.01892787f, -0.07148912f, 0.02142039f, 0.04700056f, 0.04450556f, -0.01815900f, 
    -0.07117049f, -0.06002304f, 0.01622028f, 0.05838165f, -0.04548231f, -0.05352781f, -0.06607740f, -0.01324303f, 
    0.03550755f, -0.02471884f, 0.05785891f, -0.05783680f, -0.05094428f, 0.04097511f, -0.07134470f, 0.05995071f, 
    -0.02919818f, 0.05657186f, -0.03865348f, -0.02242711f, 0.05407314f, 0.05269047f, -0.03843481f, 0.05081562f, 
    -0.04743993f, -0.03241333f, 0.01732399f, 0.02313993f, -0.07346414f, -0.06397300f, -0.07653932f, 0.05902737f, 
    -0.01448556f, -0.05919369f, -0.00726565f, 0.03883406f, -0.02859186f, -0.03877428f, -0.02359013f, -0.05427244f, 
    -0.00747246f, -0.01448579f, -0.03372529f, 0.01330656f, -0.08129092f, -0.02094624f, 0.04763818f, -0.04088119f, 
    -0.01325525f, -0.02497813f, -0.05941907f, 0.05519397f, -0.07366432f, -0.02984992f, -0.06453249f, 0.04073684f, 
    0.04661182f, 0.05453419f, 0.02070079f, 0.00702185f, -0.05612166f, -0.04131452f, 0.04669177f, 0.02759631f, 
    0.04692606f, -0.01974869f, -0.02764713f, -0.00765110f, 0.05594670f, -0.00380923f, 0.01418491f, -0.07198905f, 
    -0.00143933f, -0.03108911f, 0.05139489f, -0.03841763f, 0.02228379f, 0.00653291f, -0.00922346f, 0.00011116f, 
    0.05264255f, 0.01373081f, 0.00782514f, -0.01139067f, -0.06628119f, -0.08362053f, -0.00452624f, -0.04776929f, 
    -0.00124651f, -0.08009090f, -0.00605125f, 0.02787358f, 0.01307161f, -0.01424602f, -0.07226238f, -0.01837864f, 
    -0.06885064f, 0.00502464f, -0.03227513f, 0.02998983f, 0.03174244f, -0.02188207f, 0.05458030f, -0.07523300f, 
    -0.01809692f, 0.04291838f, -0.01172357f, -0.00388507f, -0.00914943f, 0.06168843f, 0.02447821f, -0.00951524f, 
    0.00848173f, -0.01541685f, 0.04876359f, 0.00257302f, 0.02577593f, 0.05461055f, 0.03707995f, 0.02712645f, 
    -0.07135978f, -0.03143340f, 0.04965469f, -0.02043741f, 0.00525696f, -0.03952107f, -0.00196364f, -0.05078471f, 
    -0.06401234f, 0.01363660f, -0.05598741f, -0.01773588f, 0.02168855f, -0.07608411f, -0.02720623f, -0.06527747f, 
    0.03895332f, 0.01140146f, -0.04073590f, -0.05597834f, -0.07172260f, -0.08412643f, -0.00722649f, -0.00748119f, 
    0.04312756f, -0.02303550f, -0.02180715f, 0.02426108f, -0.07419121f, 0.04840909f, 0.04389971f, -0.05567302f, 
    0.00225138f, 0.02452475f, 0.06251036f, -0.04788132f, -0.03339570f, -0.02764845f, -0.03142989f, -0.04496964f, 
    0.04683281f, -0.07000946f, 0.04219256f, -0.05400252f, -0.06500130f, 0.02989019f, -0.07058019f, 0.04326113f, 
    0.00314197f, 0.05421988f, 0.02804404f, -0.02663326f, 0.04327294f, -0.01516958f, -0.06040481f, 0.00679117f, 
    -0.07366005f, 0.02518927f, 0.04648669f, 0.01741681f, -0.06283799f, -0.02447844f, -0.07063791f, 0.01616950f, 
    -0.00603525f, -0.05995788f, 0.00079366f, 0.05302076f, 0.01629433f, 0.05562622f, -0.04498042f, -0.00171085f, 
    -0.01953101f, -0.05852332f, 0.00068101f, 0.00972360f, 0.04636903f, 0.00136955f, -0.01897811f, -0.06643551f, 
    0.02305946f, -0.06091939f, -0.07483857f, -0.06675680f, 0.04157239f, 0.00180487f, -0.01697080f, -0.01202235f, 
    -0.07053252f, -0.02734060f, 0.01338709f, -0.07343995f, 0.00017196f, 0.01041454f, -0.08010207f, 0.05002762f, 
    -0.05366983f, -0.07768241f, -0.03118496f, -0.04793482f, 0.02209520f, 0.04600264f, 0.03624897f, -0.00132064f, 
    -0.04094119f, -0.04775627f, -0.00923261f, -0.00534494f, -0.07212425f, -0.02208335f, -0.03520708f, 0.04374716f, 
    -0.06140739f, 0.03990856f, -0.08021601f, 0.03394868f, 0.06130543f, -0.07657096f, -0.04848208f, -0.07602781f, 
    -0.05508285f, 0.00967986f, -0.01525067f, 0.02437487f, -0.00434909f, 0.01903401f, 0.03616001f, -0.00679709f, 
    -0.00728252f, -0.05839030f, 0.03303030f, -0.02653176f, -0.07266242f, 0.00792229f, -0.03484140f, -0.06770429f, 
    0.02365690f, -0.05794787f, 0.03453180f, -0.07999341f, 0.06513482f, 0.03839571f, 0.03546042f, 0.01144210f, 
    0.02737089f, -0.02488063f, 0.02416868f, -0.05572317f, -0.03511476f, 0.00246233f, -0.00444243f, 0.03614921f, 
    0.02232139f, 0.02443626f, -0.05229851f, 0.01686225f, 0.05469646f, 0.04200896f, -0.07489675f, -0.01700511f, 
    -0.05351043f, 0.00003002f, 0.05189335f, -0.06888842f, -0.00482675f, 0.03704035f, 0.02334340f, 0.05141434f, 
    0.02204706f, -0.04541323f, 0.01875814f, 0.02533489f, 0.05936302f, -0.01375415f, -0.05855847f, -0.00210137f, 
    -0.03357992f, 0.03631478f, -0.06011508f, -0.08245677f, 0.00897307f, 0.03518150f, -0.00792345f, 0.00625600f, 
    -0.02784663f, 0.02179611f, 0.04974014f, -0.02027818f, -0.00557684f, -0.03712034f, -0.03569341f, 0.05863355f, 
    -0.07781473f, 0.03460311f, 0.04048406f, 0.04575923f, 0.03189961f, 0.05276127f, 0.04447339f, -0.06048156f, 
    -0.00154198f, -0.03394111f, -0.00978325f, 0.03734591f, -0.00404232f, -0.05476277f, -0.06212300f, -0.00153392f, 
    0.04794134f, -0.03191033f, -0.07111307f, -0.00904986f, 0.04356339f, -0.07719932f, -0.00982598f, -0.04527521f, 
    0.01354629f, -0.07822626f, -0.06219061f, -0.04002590f, 0.03773698f, -0.05333459f, -0.08228081f, -0.02976293f, 
    -0.07014440f, -0.04545358f, 0.00911500f, 0.03388476f, 0.03460131f, 0.01061301f, -0.05381745f, 0.04384950f, 
    0.00092803f, -0.04802886f, 0.02834265f, -0.00080304f, 0.00327524f, 0.01246910f, -0.00414667f, -0.02562571f, 
    0.02560975f, 0.01566540f, 0.04986389f, -0.03405938f, -0.05128739f, 0.00199905f, 0.02206193f, 0.04361034f, 
    0.03567203f, -0.02015209f, 0.01780450f, 0.00345291f, -0.03158437f, -0.03890029f, -0.02446893f, -0.07145038f, 
    0.00500610f, 0.06122218f, -0.06849062f, 0.05047427f, 0.01830044f, 0.00028624f, -0.07632206f, 0.04754075f, 
    0.04815861f, -0.05995367f, -0.05877798f, -0.00662038f, 0.04017291f, -0.03558737f, 0.02061801f, 0.04767292f, 
    -0.00003362f, -0.04296815f, -0.07453471f, -0.03051589f, 0.03610787f, -0.00184132f, -0.06822678f, 0.01126779f, 
    -0.05396410f, 0.01422691f, 0.03594220f, -0.01187833f, -0.01014189f, -0.01281674f, -0.07571732f, -0.03621915f, 
    -0.03898794f, -0.06740110f, -0.07345653f, -0.01627889f, -0.00247662f, 0.00314638f, 0.02662518f, -0.01672667f, 
    -0.05919164f, -0.04954103f, -0.04301101f, -0.07082184f, -0.06475689f, -0.01978858f, 0.03354399f, 0.04433676f, 
    0.01375510f, -0.00691772f, 0.02972333f, 0.02250823f, -0.05912968f, -0.06649784f, -0.03324457f, -0.06903473f, 
    -0.06694831f, -0.04998311f, 0.04301444f, 0.02007245f, -0.01186093f, -0.07709084f, -0.03361036f, -0.02335652f, 
    -0.07134534f, -0.05808385f, 0.02631000f, 0.00151748f, -0.01932672f, -0.01503580f, 0.04573220f, -0.06402267f, 
    -0.01069409f, 0.06096230f, 0.05694898f, 0.06780326f, -0.01440160f, 0.00458777f, 0.02947757f, -0.06005963f, 
    -0.05860629f, -0.01515948f, 0.05865971f, -0.05966737f, -0.06116204f, -0.03156709f, -0.01329549f, 0.03455764f, 
    -0.03686102f, -0.06239228f, -0.01357103f, -0.02858588f, 0.03519495f, 0.03855271f, -0.02100553f, -0.02463720f, 
    -0.03957748f, 0.02299264f, -0.01206092f, -0.07539126f, -0.02855514f, -0.05607638f, -0.05872616f, -0.04811373f, 
    -0.02627964f, 0.03684269f, 0.00501244f, -0.00829542f, -0.00552389f, 0.00886343f, -0.05643323f, 0.01377512f, 
    -0.01962902f, -0.05674909f, 0.02715740f, -0.04074499f, 0.05362377f, 0.06274511f, 0.05530124f, 0.03997434f, 
    0.06688710f, -0.01125745f, 0.00738572f, -0.02471381f, -0.06304102f, 0.03566275f, 0.05569166f, -0.06274661f, 
    -0.00960718f, 0.03183169f, -0.06121422f, -0.05982345f, -0.07640613f, 0.00638708f, 0.00720282f, -0.04916255f, 
    -0.01705986f, -0.04799370f, -0.03903170f, 0.03205632f, 0.02335264f, 0.02381626f, 0.04978706f, 0.00015463f, 
    0.04111416f, 0.05406285f, -0.01194259f, 0.04302872f, 0.00125521f, 0.03556207f, 0.02265557f, -0.03761871f, 
    0.00616146f, 0.03011824f, -0.06355591f, -0.07315876f, -0.06976707f, 0.05970928f, -0.03055429f, -0.01763736f, 
    0.01636147f, -0.04631998f, 0.01837775f, -0.07672493f, 0.00712853f, 0.01262722f, -0.06957553f, 0.02903428f, 
    -0.07338063f, -0.06752619f, 0.01735043f, 0.05386610f, -0.02298222f, 0.01155761f, 0.06154737f, -0.01212131f, 
    -0.01613854f, 0.04540807f, 0.03287677f, -0.06797985f, 0.03398588f, -0.00237128f, -0.06403224f, -0.01414533f, 
    -0.05019889f, -0.01429651f, -0.05057196f, 0.03039101f, -0.04124942f, -0.05674806f, 0.00761355f, -0.01181521f, 
    -0.01240706f, -0.05555531f, -0.04952711f, -0.00312169f, -0.04515509f, -0.06789200f, -0.02325265f, -0.00651713f, 
    -0.02650626f, -0.05294847f, -0.00375151f, 0.01289907f, -0.04309343f, -0.06584876f, -0.07034654f, -0.02653412f, 
    -0.06375463f, -0.04597822f, 0.02212603f, -0.01748058f, -0.00072623f, -0.02469942f, 0.01362830f, 0.01865429f, 
    -0.43310976f, 0.32902253f, 0.23351832f, -0.36184883f, -0.08368863f, 0.03506381f, 0.02334408f, 0.00660986f, 
    -0.14264792f, 0.01418951f, -0.05867614f, 0.05144879f, -0.07801718f, -0.15615961f, -0.05022551f, -0.02935240f, 
    0.13654435f, 0.02098801f, 0.10977843f, -0.00473119f, -0.06630599f, 0.04902266f, -0.06143036f, -0.00687340f, 
    0.09707426f, -0.20565321f, -0.12140232f, -0.03335817f, 0.11384492f, -0.00444996f, 0.00080473f, 0.09308603f, 
    0.06583311f, 0.04456044f, -0.07436643f, -0.09416147f, 0.58558774f, 0.03971180f, 0.20122074f, -0.08483851f, 
    0.06372272f, 0.05629339f, -0.02867430f, -0.12122356f, -0.01606064f, -0.04552960f, -0.05763284f, 0.01559112f, 
    0.08443093f, 0.40801820f, 0.10342757f, -0.21888436f, -0.01917952f, 0.01327620f, -0.00005012f, 0.02395006f, 
    0.07602338f, -0.03770040f, -0.10596694f, 0.02788720f, -0.03735190f, -0.26355287f, 0.05634214f, 0.21269658f, 
    -0.02476610f, -0.12814789f, 0.02189895f, 0.04102819f, -0.03429882f, 0.07350276f, -0.11125260f, 0.01019786f, 
    0.02716652f, -0.05693886f, 0.15835170f, 0.19930857f, 0.18941593f, 0.09900692f, -0.08875558f, 0.14041458f, 
    0.03733352f, -0.04966125f, -0.08094622f, -0.01523110f, 0.05545724f, 0.23977284f, -0.12160317f, 0.02060877f, 
    0.05742692f, -0.05219946f, -0.10684791f, -0.05115628f, 0.10336095f, -0.07079744f, -0.04023758f, -0.00843209f, 
    0.04110806f, 0.08933192f, 0.13506839f, -0.29500225f, 0.13487510f, 0.22936000f, 0.13278753f, 0.04900904f, 
    -0.02465408f, 0.11393642f, -0.07341561f, -0.06966200f, 0.26227289f, 0.24848109f, 0.08296827f, -0.20742737f, 
    -0.05180817f, 0.04329769f, -0.05917265f, -0.03674958f, -0.16195205f, 0.06005467f, 0.04873550f, 0.00180090f, 
    0.01608292f, 0.10307370f, 0.08725793f, -0.12296069f, -0.14402226f, 0.08044735f, 0.02867723f, 0.05031312f, 
    0.00387142f, -0.03106987f, 0.02300314f, -0.05186784f, -0.12038229f, 0.03370982f, 0.09121089f, 0.25586903f, 
    -0.02918506f, -0.10797756f, -0.13599287f, -0.04614408f, -0.19001459f, 0.03326408f, 0.05005406f, 0.12101967f, 
    0.17093650f, 0.19415933f, 0.15025905f, -0.11772164f, 0.02115402f, -0.13451274f, 0.02473222f, 0.05983971f, 
    0.00497470f, 0.21090704f, -0.11636834f, -0.15139334f, -0.30799583f, -0.03327857f, 0.08380266f, -0.14460267f, 
    0.10854326f, 0.02243320f, 0.02514965f, -0.05135293f, 0.13489722f, 0.10038835f, 0.11621494f, -0.00969350f, 
    0.11820970f, 0.18591814f, -0.07669044f, 0.32205877f, 0.22375560f, 0.23712775f, -0.09639466f, -0.01599928f, 
    0.08011131f, 0.12290719f, -0.12726833f, -0.09341093f, -0.07907423f, 0.04007892f, 0.05254477f, -0.02307618f, 
    0.11797376f, 0.08825625f, -0.01170263f, -0.03380135f, 0.01498127f, 0.03204274f, 0.01844915f, 0.03736851f, 
    -0.13262329f, -0.00104571f, -0.36198297f, -0.00232264f, 0.10439456f, -0.01268158f, -0.08301856f, 0.08576066f, 
    0.02315211f, 0.07642105f, -0.08041736f, -0.07554833f, 0.33474109f, 0.16832945f, -0.09077333f, 0.07813210f, 
    -0.11737257f, 0.02937982f, 0.08188836f, 0.05130683f, 0.03518225f, 0.17133771f, -0.01750619f, 0.06873167f, 
    0.10874568f, -0.08333567f, 0.03224292f, -0.24850631f, -0.06717605f, -0.03259790f, 0.13949527f, 0.03109472f, 
    -0.14815916f, -0.07205741f, -0.01940093f, 0.07830707f, -0.27544752f, 0.05035448f, 0.21337822f, 0.12081456f, 
    -0.03827674f, -0.03582081f, 0.05477152f, 0.16028881f, 0.05463544f, 0.02566277f, -0.03549845f, 0.04176553f, 
    0.04079811f, 0.22725874f, 0.12842344f, 0.20629433f, -0.16200447f, 0.16003385f, 0.12238715f, 0.17925543f, 
    -0.01461810f, 0.10060849f, -0.07978171f, 0.07207435f, 0.06508967f, 0.03900053f, 0.04378106f, -0.09627188f, 
    0.08528458f, -0.01627856f, -0.09819638f, -0.06589413f, 0.10567065f, -0.10040402f, 0.04433550f, -0.13596474f, 
    0.04892367f, -0.04595995f, 0.04618499f, 0.00135741f, -0.10302643f, 0.03957917f, 0.08852626f, -0.07899445f, 
    -0.10433233f, -0.01727458f, -0.00482295f, 0.11099610f, -0.02006262f, 0.03381706f, 0.16886890f, -0.11478098f, 
    -0.16173606f, -0.02467507f, 0.01452239f, 0.04758499f, -0.01314957f, -0.00651401f, -0.08511393f, -0.03288937f, 
    0.47751695f, 0.16458809f, -0.22149916f, 0.21950436f, 0.04724515f, 0.13049488f, -0.02766213f, -0.00821475f, 
    0.09791782f, -0.00133344f, 0.07865116f, 0.00621345f, 0.24836233f, -0.20202057f, 0.18321460f, -0.05431133f, 
    -0.10085493f, 0.10203996f, 0.09252137f, 0.04191914f, -0.05643248f, -0.08475112f, -0.03812222f, -0.02988352f, 
    0.02789951f, -0.04136739f, -0.01681779f, 0.15332344f, -0.07702785f, 0.08452568f, -0.04621625f, -0.05525692f, 
    0.07413088f, 0.09465888f, 0.01667584f, -0.00780453f, -0.40906173f, 0.13181962f, 0.26666456f, -0.35940179f, 
    -0.06047771f, 0.05893717f, -0.12547943f, 0.03045574f, 0.03658114f, -0.08272425f, -0.13577090f, -0.05981988f, 
    0.22730646f, -0.44912609f, -0.02256846f, 0.11737972f, 0.03512210f, 0.01962730f, -0.04772098f, 0.12968692f, 
    0.02184404f, 0.08395703f, 0.05074557f, 0.16720471f, 0.17141359f, -0.26719260f, -0.07716882f, 0.01837355f, 
    0.08803167f, 0.19039284f, -0.09417161f, 0.13421182f, 0.04830026f, 0.01639176f, 0.06779524f, 0.23290357f, 
    0.19471209f, -0.15310836f, -0.07164567f, -0.11541472f, -0.01922561f, 0.10611429f, 0.04510359f, 0.21445999f, 
    -0.02105945f, 0.08700105f, 0.12225579f, 0.00595562f, -0.04459159f, -0.02070330f, -0.17594467f, 0.12367769f, 
    0.03743493f, -0.01766959f, -0.00539142f, 0.05890627f, 0.07498059f, -0.10188704f, -0.09888195f, -0.07002417f, 
    -0.12140042f, -0.15377386f, 0.19144183f, 0.06230036f, -0.07337165f, 0.04784648f, -0.01674332f, -0.06543193f, 
    -0.03248235f, -0.11801394f, -0.07667219f, 0.06292689f, -0.02565744f, 0.20061895f, 0.05340657f, 0.06544024f, 
    0.05688374f, 0.00946550f, -0.02673670f, 0.00295857f, -0.13415530f, -0.01248202f, 0.00349577f, 0.26373640f, 
    -0.17220701f, -0.39159119f, 0.15795204f, -0.20437263f, 0.03419133f, -0.06214490f, -0.02586338f, 0.02112293f, 
    0.03730528f, -0.05225220f, -0.16338731f, 0.20912716f, 0.64404857f, 0.26507342f, -0.11570713f, -0.24901667f, 
    -0.06741371f, -0.07273663f, 0.11919618f, -0.04529862f, 0.04624603f, 0.03334916f, -0.00808403f, -0.06527893f, 
    0.42321157f, 0.34348658f, -0.19911650f, 0.11287344f, -0.10591412f, 0.07767536f, -0.11191904f, 0.20404032f, 
    -0.02594758f, 0.22251703f, -0.00537180f, 0.05743675f, -0.13122131f, -0.22232921f, -0.08679233f, 0.14822520f, 
    0.10547580f, 0.05221659f, -0.07725406f, 0.10536390f, -0.07631051f, 0.04019647f, 0.04426975f, -0.30365953f, 
    -0.49569190f, 0.20544183f, -0.12846334f, 0.24671456f, 0.03369478f, -0.03638389f, -0.01034661f, 0.03172591f, 
    0.01019689f, 0.16279317f, 0.03358271f, -0.09187885f, 0.45484862f, 0.14174268f, 0.08593615f, 0.25567466f, 
    0.02228809f, -0.05156153f, -0.03241524f, -0.09586081f, 0.02856729f, -0.26910827f, -0.09356496f, -0.14165282f, 
    -0.08630871f, 0.03295017f, -0.08064426f, 0.17483877f, -0.04943185f, 0.21076435f, 0.04980995f, 0.10330933f, 
    0.11431915f, -0.07873680f, 0.01857558f, 0.08760250f, 0.09881935f, 0.03321885f, -0.18213879f, 0.30967829f, 
    0.05509455f, 0.20064715f, 0.07105302f, 0.06840838f, 0.18235669f, 0.09703548f, 0.02123051f, 0.08265825f, 
    -0.06189778f, 0.15343250f, -0.20304586f, 0.15212435f, -0.06971756f, 0.06921358f, -0.12999679f, 0.08196288f, 
    0.06863918f, 0.01107786f, 0.05371846f, -0.09086952f, 0.06782064f, 0.10959602f, 0.06906562f, -0.09060573f, 
    -0.07059850f, -0.10506333f, -0.02949320f, -0.00019942f, -0.08234513f, -0.04945887f, 0.06161462f, 0.13070175f, 
    0.03629796f, 0.04893455f, 0.09249873f, 0.00802060f, 0.01462751f, 0.10810432f, -0.06379311f, -0.00586294f, 
    -0.03414261f, -0.06894581f, -0.09159321f, 0.09273333f, -0.11637257f, 0.15596791f, 0.06351767f, 0.08721180f, 
    0.04737775f, 0.02899758f, 0.23615432f, 0.10506376f, 0.03628828f, 0.23833382f, 0.08616875f, 0.06176926f, 
    -0.15057719f, -0.26551592f, -0.03146454f, 0.10472820f, 0.10445917f, -0.06077558f, 0.18266267f, -0.00778816f, 
    -0.01414553f, 0.07650045f, 0.14107887f, -0.03072117f, -0.08780541f, 0.25068572f, -0.11219748f, 0.08146319f, 
    -0.10700973f, 0.18567196f, 0.07499541f, -0.08851388f, 0.05714629f, 0.08280627f, -0.09462298f, -0.05845337f, 
    0.06149511f, -0.05266072f, -0.05986575f, -0.02970843f, -0.03994177f, -0.06541610f, -0.03856964f, -0.00236756f, 
    0.01299342f, 0.03466115f, 0.03569304f, -0.04255909f, 0.01545273f, 0.01163438f, 0.03553551f, 0.02504548f, 
    -0.04495184f, -0.04643863f, 0.02576519f, 0.05459530f, 0.00773452f, -0.00764640f, 0.00891990f, -0.02284271f, 
    0.02236951f, 0.02918341f, 0.03721927f, -0.05034977f, -0.02513084f, -0.00971227f, -0.04973846f, 0.02416383f, 
    -0.00021452f, 0.00639182f, 0.01216822f, 0.01124766f, -0.04761159f, 0.01820545f, -0.02274857f, 0.04190034f, 
    -0.01636254f, -0.06011404f, 0.05840502f, 0.02911984f, -0.05190397f, 0.06176613f, 0.04922167f, 0.04480090f, 
    0.02129258f, -0.02176699f, 0.07823296f, -0.03545885f, -0.01161243f, -0.04236446f, -0.01619941f, -0.02068754f, 
    0.02713997f, -0.05571068f, -0.04203220f, -0.04899943f, 0.00996767f, -0.00344835f, 0.05279202f, -0.03296295f, 
    -0.00292525f, -0.01270367f, 0.04364650f, -0.06940658f, -0.00608170f, -0.07287090f, 0.06058937f, -0.06417745f, 
    0.05154474f, 0.02606414f, -0.04442748f, 0.06276181f, -0.05905731f, -0.02384753f, -0.05509791f, -0.05610497f, 
    -0.04106745f, -0.02082106f, 0.01857146f, 0.03273170f, -0.03161808f, -0.02449262f, 0.06272901f, -0.01668178f, 
    -0.06424560f, -0.04727183f, 0.02001954f, 0.05817279f, 0.00821662f, 0.03588575f, -0.00147113f, -0.07197667f, 
    0.02463972f, -0.00567518f, -0.00973423f, 0.06308244f, -0.05330521f, 0.06285003f, -0.02990082f, -0.07324157f, 
    0.04991124f, 0.02962524f, 0.00535187f, 0.00329251f, 0.02056356f, -0.07022260f, -0.07207149f, -0.04016180f, 
    -0.03341853f, -0.08292688f, -0.01907134f, 0.02983619f, -0.06206053f, -0.07064936f, 0.06173915f, 0.00307028f, 
    -0.02956708f, -0.03202432f, 0.01349405f, 0.04446943f, 0.01962645f, -0.01861581f, -0.06062405f, 0.05556080f, 
    -0.00281134f, -0.03060223f, -0.07935528f, -0.01635550f, -0.05099891f, 0.03734476f, -0.03145403f, 0.01217615f, 
    0.06032951f, 0.00057394f, -0.08176849f, 0.02832009f, 0.00135640f, -0.02651094f, -0.00133590f, 0.04994700f, 
    0.01680780f, -0.05130326f, -0.03728887f, -0.06012421f, 0.05754289f, 0.04123735f, 0.03214884f, -0.04395281f, 
    0.00224362f, 0.06162871f, 0.01027731f, -0.07567848f, -0.07940209f, 0.06271954f, 0.02655811f, -0.00319493f, 
    -0.07288377f, -0.03269762f, 0.05163194f, 0.03251364f, 0.01518996f, -0.01764720f, -0.02488607f, 0.03240145f, 
    -0.03555366f, -0.04854753f, -0.02371613f, -0.01806150f, 0.06678689f, -0.03262760f, -0.05880713f, 0.06140766f, 
    -0.06413472f, -0.02382585f, -0.06024894f, 0.02466649f, -0.03475020f, 0.04450347f, -0.07626496f, -0.00548438f, 
    -0.04987029f, 0.02089338f, -0.06740728f, -0.00142312f, -0.07591169f, 0.02900257f, -0.06000596f, -0.00247231f, 
    -0.01459447f, 0.03764562f, 0.06191839f, 0.05631902f, 0.06094588f, -0.04018423f, -0.01550303f, -0.07398038f, 
    -0.05782001f, -0.06842439f, -0.07876949f, 0.05383516f, 0.05935866f, 0.06237615f, -0.01033931f, -0.05333047f, 
    -0.07574388f, -0.02014103f, -0.04476359f, 0.00448474f, 0.02819754f, 0.03280431f, -0.02565864f, -0.01373612f, 
    0.03042223f, -0.03607722f, -0.02106169f, 0.04476963f, -0.01479158f, 0.02807517f, 0.02650025f, -0.07577168f, 
    0.04807974f, 0.05814258f, 0.01809797f, 0.00142087f, -0.02182416f, -0.02326388f, -0.07150658f, -0.03681250f, 
    -0.03483664f, -0.07191159f, -0.00371957f, -0.04213943f, 0.03790757f, -0.07393449f, 0.05771036f, 0.02798226f, 
    0.05881279f, -0.02261980f, -0.05591546f, 0.05696031f, 0.06332163f, -0.05342480f, 0.04045800f, -0.05940612f, 
    -0.01615882f, -0.01043073f, 0.05501534f, -0.01842402f, 0.02497182f, -0.06913097f, -0.02351771f, -0.00500859f, 
    0.03725486f, -0.05391631f, 0.00314383f, 0.03406456f, 0.02501683f, -0.02862037f, 0.00525747f, 0.00413013f, 
    0.05423391f, -0.02299669f, -0.06428201f, -0.05562161f, -0.05896116f, -0.06193928f, 0.03604959f, -0.03005872f, 
    0.02021954f, 0.05473998f, -0.04420502f, 0.01540740f, 0.00391723f, -0.03729932f, -0.07807688f, 0.03688677f, 
    0.04128002f, -0.04140411f, -0.03307707f, -0.07364356f, 0.06358142f, -0.06243646f, -0.07286371f, 0.01050316f, 
    -0.04715842f, 0.04328612f, -0.06161125f, -0.00507716f, 0.03702202f, -0.07448700f, -0.07845001f, -0.03317612f, 
    -0.04842352f, 0.06067314f, 0.01088550f, -0.05347859f, -0.07887835f, -0.03022734f, 0.00374410f, 0.04738032f, 
    -0.07816021f, 0.05585080f, 0.00755535f, 0.04681633f, -0.00003068f, 0.04736899f, -0.07160672f, 0.02421760f, 
    -0.03895555f, -0.03691439f, -0.00959585f, 0.00124545f, 0.03767596f, 0.05712690f, -0.02631212f, -0.06701387f, 
    -0.04985026f, 0.02494032f, -0.00244799f, 0.02459291f, -0.00107776f, 0.02142742f, -0.00232755f, 0.02429057f, 
    -0.07672042f, -0.04332003f, -0.05179743f, 0.00976543f, -0.00565714f, 0.01142520f, -0.04947940f, -0.07292365f, 
    -0.05895281f, 0.05237092f, -0.07661977f, 0.00670019f, 0.05042222f, -0.03847743f, -0.06820864f, -0.01009057f, 
    -0.00450508f, 0.01167148f, -0.00347290f, -0.01131469f, -0.02764522f, -0.05239824f, 0.06111043f, -0.05774167f, 
    -0.04715849f, 0.02478695f, -0.06965012f, 0.02921389f, -0.01388533f, -0.02426418f, -0.06426413f, 0.05859801f, 
    -0.07151901f, 0.01823350f, -0.03936284f, 0.04576877f, -0.03539376f, -0.03319898f, -0.06985062f, 0.00312187f, 
    0.01155727f, -0.05721675f, -0.07615016f, -0.06694109f, -0.04484984f, 0.04852857f, -0.07150443f, -0.07978769f, 
    -0.04674101f, -0.00315144f, -0.02376972f, 0.02612612f, 0.04278145f, -0.01429381f, -0.06223666f, 0.02132341f, 
    0.15445557f, -0.01963049f, -0.00594250f, 0.11531851f, 0.04037263f, -0.12065784f, -0.00481987f, 0.07414956f, 
    0.06514829f, -0.21635281f, -0.03481182f, 0.04699435f, 0.23432292f, 0.07981501f, -0.05393162f, -0.30023429f, 
    -0.21421787f, -0.02704568f, -0.23817912f, -0.10055927f, 0.01656494f, 0.13753927f, -0.09606756f, 0.34367949f, 
    -0.04584813f, 0.07951618f, 0.11985326f, -0.13610148f, 0.08967633f, -0.13952743f, -0.00117714f, -0.11590687f, 
    -0.00327699f, -0.00520152f, -0.14330803f, 0.14317916f, 0.08859137f, -0.07508536f, -0.20595786f, -0.13890450f, 
    -0.06669005f, 0.13228960f, -0.01391648f, -0.30710250f, -0.06871220f, 0.03617489f, -0.04650607f, 0.03804327f, 
    0.06080822f, 0.07008258f, -0.23737888f, 0.13438058f, 0.07536135f, 0.04381187f, -0.35135004f, -0.02998536f, 
    -0.15982357f, 0.21953739f, 0.05474745f, 0.03818992f, 0.18427706f, 0.03590907f, -0.07805258f, 0.00833240f, 
    0.02313474f, -0.00743184f, -0.10842083f, 0.04842574f, 0.18985990f, -0.15791431f, -0.09901971f, -0.34789360f, 
    0.13468735f, 0.21576534f, 0.08656904f, 0.02152928f, 0.04466597f, 0.03358305f, 0.01482578f, 0.08168714f, 
    0.00245717f, 0.12331419f, 0.25633755f, 0.14535241f, 0.25972152f, 0.10849433f, 0.17388819f, 0.02302883f, 
    0.02770049f, -0.11795096f, -0.21971707f, -0.10843377f, 0.05652069f, -0.29758218f, -0.09749711f, 0.01608491f, 
    0.00844121f, -0.18203609f, -0.18429811f, 0.47657180f, 0.02314930f, -0.00816302f, -0.13078590f, 0.09110294f, 
    0.08804456f, -0.20279601f, 0.22183788f, 0.03730119f, 0.28101400f, -0.10116965f, -0.26586413f, 0.41848364f, 
    0.09945257f, 0.20762798f, 0.16037969f, -0.09714533f, 0.07861115f, 0.19455592f, 0.17450489f, 0.11073631f, 
    0.52258915f, -0.00299507f, -0.17518145f, 0.36295673f, 0.01190345f, -0.14700507f, -0.18175732f, -0.09738400f, 
    -0.16880639f, 0.23999785f, 0.08968158f, -0.04690859f, 0.01951143f, -0.09481009f, -0.10543803f, -0.27552509f, 
    -0.05492933f, -0.14576450f, -0.09355222f, -0.05295322f, 0.02732447f, -0.04010208f, -0.14215542f, -0.02766678f, 
    -0.11522051f, 0.25109711f, 0.27883679f, -0.09878765f, -0.00559638f, 0.15829745f, 0.12860361f, -0.24164917f, 
    -0.18932754f, -0.06709328f, 0.13398178f, -0.00437913f, -0.03332512f, 0.30675551f, 0.11882851f, 0.19244930f, 
    -0.04041129f, 0.05715086f, 0.19312683f, 0.11553628f, -0.08142201f, 0.20980607f, 0.12314425f, 0.23315495f, 
    0.00726090f, 0.13670458f, 0.13011651f, 0.03438971f, 0.06286955f, -0.31250402f, 0.09968618f, 0.06008711f, 
    0.13980688f, -0.27019638f, 0.09648250f, -0.21676248f, 0.09824353f, 0.16013390f, -0.21181639f, -0.11448992f, 
    -0.17927633f, 0.06253273f, 0.30637819f, -0.02153263f, 0.00213754f, -0.08597795f, -0.28154385f, -0.24458350f, 
    -0.01299284f, -0.04338534f, 0.00486854f, -0.02825345f, -0.07504915f, -0.04283651f, 0.02753407f, -0.07613181f, 
    -0.00298486f, -0.03175876f, 0.01698023f, -0.00768044f, 0.06118610f, -0.01387511f, -0.06638423f, 0.01195475f, 
    -0.05771161f, -0.07529484f, -0.00512384f, -0.01063984f, -0.01005251f, 0.02248310f, 0.01782658f, -0.06857533f, 
    -0.07752771f, -0.01579905f, 0.06067278f, -0.05819338f, -0.07391381f, 0.02392705f, 0.02181720f, 0.02748833f, 
    -0.05383823f, 0.04928972f, -0.04597809f, 0.00151977f, 0.00432860f, -0.04344821f, -0.03031415f, -0.05845205f, 
    -0.00639296f, -0.07154694f, -0.01053590f, -0.05845420f, -0.05853232f, 0.03838491f, -0.01981750f, 0.01257918f, 
    -0.00370731f, -0.07603732f, 0.02810468f, -0.04677944f, -0.07686022f, -0.04891594f, -0.05314704f, -0.01992341f, 
    0.04524795f, 0.03007927f, -0.06318372f, -0.04899911f, 0.04741306f, -0.01870595f, 0.06296257f, -0.04438113f, 
    -0.03454104f, 0.02654161f, -0.06981861f, 0.01348603f, -0.05363887f, 0.00053071f, 0.01822138f, 0.05510700f, 
    0.05434371f, -0.04732796f, -0.01980895f, 0.04981135f, -0.00148122f, -0.02526144f, 0.06250104f, -0.00555499f, 
    -0.04564167f, 0.01247523f, 0.02953235f, -0.06498282f, -0.02670560f, 0.05693458f, -0.06255732f, -0.05967132f, 
    -0.04657999f, 0.02358356f, -0.04608624f, 0.03003879f, -0.01167715f, 0.05870503f, -0.07211763f, 0.01293989f, 
    -0.05835777f, -0.04107869f, -0.01021117f, -0.06210979f, 0.05106339f, -0.04632910f, 0.01014948f, 0.00836855f, 
    -0.02423852f, 0.03642153f, 0.03645629f, -0.04003564f, 0.01925959f, -0.02372978f, -0.06504299f, 0.02248577f, 
    0.01254177f, 0.04664942f, 0.00762430f, -0.05260997f, 0.00055631f, 0.01950244f, -0.00008935f, -0.00090456f, 
    -0.04582587f, -0.03496245f, -0.06712876f, -0.02344238f, -0.07789505f, 0.04739475f, 0.05586244f, -0.02899930f, 
    0.00320575f, -0.03248035f, -0.06747654f, 0.02299250f, -0.06144654f, -0.04344387f, 0.02164057f, -0.04308277f, 
    -0.07711794f, 0.03953167f, -0.06312293f, -0.01524332f, -0.05032322f, -0.01710199f, -0.03893298f, 0.00299081f, 
    0.02112553f, -0.07527884f, 0.02387183f, 0.04783588f, -0.04538035f, -0.04254402f, 0.04512620f, -0.00546218f, 
    -0.00740376f, 0.04187082f, -0.04314666f, 0.01838863f, 0.06439074f, 0.06464788f, -0.06149623f, -0.00528141f, 
    0.01874539f, -0.07216106f, -0.05906881f, 0.00633539f, 0.01275841f, 0.03380714f, 0.03451964f, -0.05656053f, 
    -0.02243493f, -0.07528544f, -0.00617255f, 0.05460929f, -0.06103064f, 0.00711190f, -0.06104181f, -0.03343347f, 
    -0.02528885f, 0.00760678f, 0.04387842f, 0.04735586f, 0.01490534f, 0.03913975f, 0.04672232f, 0.05618428f, 
    0.06392425f, 0.04259792f, 0.03191301f, -0.06142712f, -0.01832415f, -0.06594319f, -0.07666422f, 0.05087656f, 
    -0.03101030f, -0.03979534f, 0.06434403f, 0.04223612f, 0.03420445f, 0.04035399f, 0.03607120f, 0.02254757f, 
    0.04697612f, 0.02550711f, -0.03087624f, -0.01675348f, 0.03478528f, -0.02421522f, -0.05611565f, -0.00670435f, 
    -0.08179925f, -0.07197744f, -0.07420521f, -0.07851660f, -0.07391571f, -0.07612938f, -0.00642803f, 0.01705703f, 
    -0.07532288f, -0.03321318f, -0.04049985f, -0.05609649f, -0.06719791f, -0.05712318f, -0.05377046f, -0.04688198f, 
    -0.00394111f, -0.05567189f, -0.03392228f, -0.05232823f, 0.05249301f, -0.02717833f, 0.05080051f, -0.06121726f, 
    0.01193536f, 0.05188234f, -0.03995698f, 0.02695397f, -0.06083998f, -0.05422583f, -0.02642042f, -0.07344086f, 
    0.04867491f, -0.03268046f, -0.06807445f, -0.07110424f, -0.06817979f, -0.05378605f, 0.04071347f, 0.02320656f, 
    -0.03394267f, -0.01651227f, -0.05106307f, -0.03187018f, -0.00498112f, -0.02639369f, -0.00129202f, -0.05985698f, 
    0.02852498f, -0.00037527f, -0.03847050f, -0.01675425f, -0.05021268f, -0.03326469f, 0.01829815f, -0.05549482f, 
    0.06056891f, 0.05955227f, -0.06680518f, 0.00859144f, 0.03584971f, -0.06016143f, -0.03607906f, -0.06758408f, 
    0.02551695f, -0.08169010f, -0.06937370f, 0.05466247f, -0.00889210f, 0.03243218f, 0.04985663f, 0.05204024f, 
    0.00421953f, -0.02318692f, -0.05270236f, -0.01137630f, -0.03342290f, -0.01346996f, -0.06752001f, 0.00910945f, 
    0.03090439f, -0.02291860f, -0.04097363f, -0.02139015f, 0.01664942f, -0.07896722f, 0.03928438f, -0.05225325f, 
    -0.08243486f, 0.04320063f, 0.01651265f, 0.05465256f, 0.00366593f, 0.03684855f, 0.00383977f, 0.03902546f, 
    0.00336796f, -0.07435365f, 0.00758506f, -0.01270931f, -0.04508745f, -0.01778864f, 0.02351614f, -0.04321033f, 
    0.03629439f, 0.05946140f, -0.06059536f, 0.05324155f, 0.05453898f, -0.03121952f, -0.06779413f, 0.03523368f, 
    0.04895638f, -0.05546533f, -0.00494213f, 0.05111196f, 0.04563741f, -0.01773497f, -0.06654274f, -0.01865089f, 
    -0.05400309f, -0.03602856f, -0.06326108f, -0.05717881f, 0.02857431f, 0.02495557f, -0.05339160f, 0.00211916f, 
    -0.08013053f, 0.05223111f, 0.05878073f, -0.00821021f, -0.03887161f, 0.01748870f, 0.01429702f, -0.01019660f, 
    -0.00223003f, -0.00369475f, 0.05084797f, 0.02261664f, 0.05878327f, 0.05709083f, 0.01016680f, -0.07484372f, 
    0.00172085f, -0.02740901f, -0.04233753f, -0.01843627f, -0.06648741f, -0.07438541f, -0.03462080f, -0.07316613f, 
    -0.06856119f, -0.02889203f, 0.02358239f, 0.03729048f, 0.05173150f, 0.00688287f, -0.00515847f, 0.00689291f, 
    -0.07927153f, -0.04772127f, -0.06780382f, -0.07733573f, 0.04943187f, -0.04493664f, 0.06539938f, -0.02557464f, 
    0.00802565f, 0.03836837f, -0.06964805f, -0.01175504f, -0.06549308f, -0.01605567f, -0.02402933f, 0.04308827f, 
    -0.06098271f, -0.12937109f, -0.02202062f, 0.23997143f, -0.07390904f, 0.04033487f, -0.01717789f, 0.00809585f, 
    -0.02000418f, -0.00984740f, -0.01220795f, 0.09776251f, 0.01170205f, -0.13780501f, 0.16312818f, 0.14707449f, 
    -0.04346132f, 0.12461406f, 0.05297132f, -0.09866765f, -0.14336282f, 0.05682190f, -0.02513736f, 0.06592254f, 
    -0.09723977f, -0.06584582f, 0.16157362f, -0.13670838f, 0.00727649f, 0.09803779f, -0.04180593f, 0.01809232f, 
    0.23641157f, 0.06263891f, 0.07175256f, 0.07559028f, 0.71218568f, 0.32596037f, 0.13139734f, 0.30491564f, 
    -0.11917493f, -0.06394053f, 0.01567282f, 0.05715971f, -0.00076558f, -0.00419340f, -0.00618513f, -0.01153180f, 
    0.17286263f, 0.20779282f, 0.15623797f, 0.20233293f, 0.09524060f, -0.02211496f, 0.06971553f, -0.05233692f, 
    0.02958760f, -0.01327701f, 0.07749411f, 0.08905513f, -0.18045869f, -0.18799327f, -0.04594781f, 0.05139805f, 
    0.10910981f, 0.10164547f, -0.09122025f, -0.00100305f, 0.04628158f, -0.06477553f, 0.00425503f, -0.05589345f, 
    -0.29849148f, -0.03025850f, -0.12540703f, -0.00843386f, -0.05177648f, 0.03371836f, 0.02185781f, 0.05389800f, 
    0.03102043f, 0.01076082f, 0.09680709f, 0.08231407f, 0.29798150f, 0.16012296f, 0.09208626f, -0.14541450f, 
    0.03671486f, 0.07977094f, 0.07725035f, -0.02541230f, -0.09922311f, -0.06006521f, -0.07980791f, -0.06178292f, 
    0.12275916f, 0.05012808f, 0.24968332f, 0.02437451f, 0.05762624f, 0.03534443f, 0.01351998f, -0.07195940f, 
    -0.09110397f, 0.05633643f, -0.00513503f, 0.09152888f, 0.19089229f, 0.24500813f, 0.07976791f, -0.06468259f, 
    -0.05340872f, 0.00165925f, -0.10657896f, 0.10220093f, -0.00504613f, -0.02146043f, 0.03621311f, 0.01431840f, 
    -0.21191178f, -0.04246783f, -0.00074199f, -0.02106910f, 0.03596965f, 0.00634519f, 0.02000057f, 0.05893883f, 
    0.10984574f, -0.10384215f, 0.09771378f, 0.05247246f, 0.43979168f, 0.15496854f, -0.06488489f, -0.02016783f, 
    -0.00409001f, 0.00682424f, 0.19750911f, 0.06504833f, -0.05566773f, 0.00565092f, 0.07314704f, -0.00803782f, 
    0.35778922f, -0.09354794f, -0.02435416f, 0.11617317f, 0.10636806f, -0.07461251f, 0.00368309f, 0.27239004f, 
    0.03134079f, -0.00932004f, -0.10747033f, 0.03225254f, 0.25574887f, -0.11622311f, -0.02025035f, -0.16668856f, 
    0.07036464f, -0.01517249f, -0.02273733f, 0.13036518f, 0.02161230f, 0.02186792f, -0.02548384f, 0.12852749f, 
    -0.11542777f, -0.28901437f, -0.31331694f, -0.18447900f, -0.03891654f, -0.08289949f, 0.06092598f, -0.12391677f, 
    0.05765701f, 0.08835889f, 0.06400285f, 0.07226411f, 0.16674936f, 0.02483976f, 0.09340966f, 0.06483593f, 
    -0.03023385f, 0.15325885f, -0.02096429f, 0.00728075f, 0.07174873f, 0.05785878f, 0.05148748f, -0.08523454f, 
    -0.20681506f, 0.11639679f, -0.09629687f, -0.02207821f, 0.12600279f, 0.08202200f, -0.04315078f, 0.05052681f, 
    -0.03861919f, -0.09439382f, -0.10811324f, -0.05306881f, 0.38929355f, 0.15555491f, -0.18228489f, -0.14540686f, 
    -0.00870372f, -0.11627834f, 0.03356465f, 0.09035776f, -0.03870841f, 0.04060347f, 0.15208802f, 0.01390032f, 
    -0.45591336f, 0.09540891f, 0.21037751f, 0.08983446f, 0.08906284f, 0.17937006f, 0.02010579f, 0.04229391f, 
    0.27633631f, 0.08792835f, 0.06126538f, 0.07130313f, -0.14141135f, -0.15987310f, 0.23990692f, 0.03833054f, 
    0.18256643f, 0.30662897f, -0.00043824f, 0.06867052f, -0.08991206f, -0.00504208f, -0.09391595f, 0.09815377f, 
    -0.14518416f, 0.21546002f, 0.19739744f, -0.18830805f, 0.04377279f, 0.00912428f, 0.06682502f, -0.03699816f, 
    -0.01155705f, -0.13587303f, -0.15367252f, 0.08357476f, 0.47650692f, -0.18703823f, -0.16887079f, -0.12644064f, 
    0.11302986f, -0.16610551f, -0.01938608f, -0.09502207f, -0.08824223f, -0.00242008f, 0.02479893f, 0.15814656f, 
    -0.02904101f, -0.11178068f, -0.24280319f, -0.00916892f, -0.06037083f, -0.00747311f, 0.10360672f, 0.04304479f, 
    -0.05859239f, 0.09526319f, 0.03548585f, 0.12462316f, -0.17779329f, 0.09652612f, 0.06981909f, -0.20847838f, 
    0.11810537f, 0.02765614f, 0.19133733f, -0.02600114f, -0.04304637f, 0.21752922f, -0.08818469f, 0.03681189f, 
    0.13181864f, 0.02134021f, -0.08953286f, -0.03863969f, 0.00008085f, 0.05463332f, -0.10110129f, 0.00927525f, 
    -0.05774986f, 0.07834323f, -0.05335942f, 0.05770163f, -0.30677125f, -0.08371800f, 0.06534758f, -0.13150643f, 
    0.01022790f, -0.02881613f, -0.00966581f, 0.05403698f, 0.10731100f, 0.03055142f, 0.02930395f, -0.02358647f, 
    0.06535541f, 0.21709944f, -0.15683396f, -0.22429058f, 0.08095838f, 0.05013892f, -0.04183784f, 0.08318861f, 
    -0.00973478f, 0.09406383f, 0.02672964f, 0.12665017f, -0.16416238f, 0.28024918f, 0.07897977f, -0.17929353f, 
    0.19388613f, 0.23350994f, -0.03813922f, 0.09183595f, -0.00801798f, -0.12681744f, 0.06232760f, 0.02351572f, 
    -0.17953059f, -0.02344113f, 0.10287698f, -0.03570928f, 0.08527590f, -0.18262352f, -0.09357293f, 0.10428529f, 
    0.05124905f, -0.08674673f, 0.10375064f, -0.07548792f, 0.26436388f, -0.24068592f, -0.03936268f, 0.15550934f, 
    0.04015420f, -0.21720065f, -0.04076290f, 0.12105002f, 0.08136047f, -0.07794265f, 0.03810636f, -0.11263739f, 
    -0.22655788f, -0.30553749f, -0.05508532f, 0.16724832f, 0.13896510f, 0.09245869f, -0.00115533f, 0.18121560f, 
    0.02857009f, 0.11708949f, -0.08525939f, 0.19245476f, 0.20982727f, 0.22126953f, -0.16891077f, -0.13347413f, 
    0.10373919f, 0.01399813f, -0.06204068f, 0.08328973f, 0.08003924f, 0.08268260f, -0.01059956f, 0.06928603f, 
    0.19071817f, 0.24287508f, -0.14882025f, 0.07495416f, -0.04897489f, -0.02119392f, 0.14091057f, 0.16342387f, 
    -0.00214272f, 0.00962685f, 0.21085103f, -0.11120527f, -0.19233942f, -0.15382482f, -0.04525309f, -0.13614385f, 
    0.03111566f, 0.24188006f, 0.00715351f, 0.04515186f, -0.01581140f, 0.08932483f, -0.05842429f, -0.21846773f, 
    0.17345184f, 0.44239771f, 0.01350657f, 0.43556195f, 0.12105504f, 0.15213108f, -0.04747690f, 0.08393561f, 
    0.20437020f, 0.05549401f, 0.20018561f, -0.00392519f, 0.39660528f, -0.27662301f, -0.10900783f, -0.04291511f, 
    -0.01466853f, 0.05855586f, -0.05406815f, -0.04705387f, 0.11516674f, 0.04068696f, 0.19442832f, 0.16658631f, 
    0.00165639f, -0.55190557f, -0.19536385f, -0.39157945f, 0.04003462f, 0.01926124f, -0.05448074f, -0.14647250f, 
    0.12044877f, -0.22877961f, -0.04605239f, -0.20804042f, -0.05566916f, 0.13910718f, 0.09645885f, 0.05912885f, 
    -0.02351158f, -0.08221048f, -0.09867284f, 0.03497061f, -0.12059233f, 0.20878941f, -0.02879734f, 0.15067944f, 
    0.39381388f, 0.10828725f, 0.14901055f, 0.15879582f, 0.17736825f, -0.10885694f, 0.05446592f, 0.18238501f, 
    0.05211945f, 0.23160930f, -0.19473639f, -0.01830271f, -0.18155661f, -0.17763811f, -0.25258482f, 0.16162288f, 
    0.09144229f, 0.00172584f, -0.01572485f, 0.02082201f, 0.02238506f, 0.08297513f, 0.01241024f, -0.00844574f, 
    -0.26446593f, -0.14827134f, -0.08896003f, -0.14700972f, 0.09313040f, -0.13814345f, 0.00261081f, 0.00094567f, 
    0.03206347f, -0.02447543f, -0.11340295f, 0.06806130f, -0.15763590f, 0.15032242f, -0.19125724f, -0.03023121f, 
    0.10797306f, -0.18228891f, -0.13422871f, -0.08838713f, 0.03917959f, 0.06050047f, -0.03384504f, -0.04472131f, 
    -0.20793891f, 0.03608210f, 0.29633537f, -0.09635960f, 0.03514321f, -0.07756364f, -0.06378534f, 0.10301439f, 
    -0.09151429f, -0.03963583f, 0.07979505f, 0.16159585f, 0.27183783f, -0.20328556f, -0.38415220f, 0.20054261f, 
    0.14087427f, -0.06326397f, 0.02414974f, -0.04424623f, 0.18327367f, 0.01416175f, -0.06166156f, 0.01510069f, 
    -0.00832420f, 0.16148651f, 0.05496198f, 0.17173964f, 0.06593890f, 0.05360283f, 0.13840127f, -0.10730473f, 
    -0.00889137f, 0.02377851f, 0.03302629f, -0.01055991f, 0.03898024f, 0.03814413f, 0.11020579f, 0.10920174f, 
    0.07235533f, -0.15555564f, 0.00276156f, -0.01162297f, 0.14245036f, -0.20287222f, -0.08232485f, -0.11829393f, 
    0.33693638f, 0.29211605f, 0.30551195f, 0.21315350f, -0.07981924f, -0.00449377f, -0.05078414f, -0.15230046f, 
    -0.04078140f, 0.04432170f, -0.05245689f, -0.09003688f, 0.03083975f, -0.02180255f, 0.04112601f, 0.03047289f, 
    -0.10448058f, -0.14319237f, 0.08960447f, 0.05074781f, -0.10930980f, 0.13506490f, 0.29446214f, -0.06260271f, 
    0.19613899f, 0.25728470f, 0.31236732f, -0.23516548f, -0.08919808f, 0.09528884f, 0.11318435f, -0.09371374f, 
    0.14427504f, -0.01484309f, 0.02190142f, 0.13540840f, -0.13897513f, -0.16134027f, 0.02788205f, -0.08864865f, 
    0.06664320f, -0.15769753f, 0.04571547f, 0.10111505f, 0.15420054f, -0.04354807f, -0.08099092f, 0.08367404f, 
    -0.00921349f, -0.36054108f, -0.24875547f, 0.10502398f, -0.03316490f, 0.04283823f, -0.06198144f, 0.02524365f, 
    0.00412436f, 0.07312316f, -0.00675073f, -0.00910606f, -0.19918554f, 0.04422235f, 0.04324595f, 0.13842344f, 
    0.02232056f, 0.11939866f, 0.13490544f, -0.07527097f, -0.10191540f, -0.02508749f, -0.03559128f, 0.01709885f, 
    -0.32229897f, 0.14301261f, 0.01739827f, -0.23674552f, -0.03289249f, -0.01179777f, -0.00676465f, 0.04857511f, 
    0.01873584f, 0.15078583f, 0.04475917f, 0.00785408f, -0.20395114f, 0.08617193f, 0.04225807f, 0.19181737f, 
    -0.04415213f, -0.06377123f, 0.14041382f, -0.03153409f, 0.00467188f, 0.00930204f, -0.11329969f, 0.18028750f, 
    -0.00623815f, 0.02206875f, 0.13287066f, -0.04852270f, 0.06227788f, 0.13300009f, -0.09558050f, 0.01020638f, 
    -0.08491065f, 0.05148468f, 0.14581090f, 0.13878213f, -0.06186191f, 0.21409529f, 0.02504536f, -0.24329881f, 
    -0.08845601f, 0.05930867f, -0.07537498f, -0.06795765f, 0.04320077f, 0.00596562f, 0.01499232f, 0.00561674f, 
    -0.21195814f, 0.09959600f, 0.17652351f, -0.24741097f, -0.06308705f, 0.14426678f, 0.14463620f, 0.06759809f, 
    -0.01071362f, 0.08948842f, -0.03009846f, -0.06988046f, 0.17644723f, 0.06342645f, 0.05489276f, -0.21770589f, 
    0.00910681f, 0.12223345f, 0.15173250f, -0.06855540f, -0.11829482f, 0.07108128f, 0.07890235f, 0.00693259f, 
    0.37599513f, -0.13062061f, 0.21677998f, -0.02102151f, 0.08079464f, 0.00475511f, 0.11435815f, 0.03996192f, 
    -0.08435902f, 0.02270623f, -0.07089246f, -0.13698678f, -0.07017167f, -0.01709159f, 0.21820450f, 0.42258358f, 
    -0.02973272f, -0.02171158f, 0.00902931f, 0.11719128f, -0.13191141f, -0.01306462f, 0.07086495f, 0.06872940f, 
    -0.30807784f, 0.28491327f, 0.30353317f, -0.17769517f, -0.08825784f, 0.14530109f, -0.00333452f, 0.04123347f, 
    -0.08717806f, 0.14207263f, -0.07753384f, -0.08259905f, -0.53842252f, 0.20063975f, 0.02164982f, -0.22785616f, 
    -0.08172969f, 0.09883921f, 0.08864950f, -0.11288036f, -0.14469548f, 0.06847655f, 0.05877874f, -0.14616425f, 
    -0.05312158f, 0.11873522f, -0.14424624f, 0.11676044f, 0.18398663f, -0.05073865f, -0.01842564f, 0.00813908f, 
    0.21357453f, 0.07851539f, 0.00437381f, -0.06188454f, -0.16556309f, -0.23806459f, 0.03628251f, -0.14820023f, 
    0.10571559f, 0.09745312f, 0.06907432f, 0.13951410f, 0.16742486f, 0.11844222f, -0.20236413f, 0.20933037f, 
    0.09951907f, -0.09200290f, 0.17046782f, 0.11696845f, 0.06258648f, -0.02938018f, -0.03817017f, -0.05699728f, 
    -0.02100686f, 0.03468391f, 0.08310281f, 0.07882638f, -0.40236998f, 0.02864981f, 0.07333087f, -0.02903693f, 
    0.07769652f, -0.04282338f, 0.00734988f, 0.00852297f, -0.08325353f, -0.07777517f, 0.03083966f, -0.21543774f, 
    -0.02924326f, -0.00143886f, 0.18367226f, -0.04010823f, 0.04958559f, 0.16911705f, 0.04503551f, 0.01324545f, 
    0.25811902f, 0.09354812f, 0.33788222f, -0.04574788f, 0.27860242f, 0.14414747f, -0.00895158f, 0.24923100f, 
    -0.09622899f, 0.04279647f, -0.14832427f, 0.04974749f, -0.02558498f, 0.07089966f, 0.04003707f, 0.02002351f, 
    0.11955200f, -0.17967217f, 0.04792032f, 0.19423661f, 0.10426060f, 0.02794131f, 0.12062137f, -0.11419347f, 
    0.14159192f, -0.16089274f, 0.08890197f, 0.00686179f, -0.17062576f, -0.00091703f, 0.06007462f, -0.16157696f, 
    0.07256036f, -0.10634542f, -0.00250984f, 0.07129630f, -0.04504153f, 0.06474603f, 0.07471210f, 0.22687641f, 
    -0.25454131f, 0.06301083f, -0.27240905f, 0.09345423f, -0.01921248f, 0.06981665f, -0.01319239f, 0.12870874f, 
    0.17243035f, 0.11380284f, 0.06525068f, 0.00369448f, 0.22557807f, -0.04968860f, -0.01812184f, -0.02811687f, 
    0.10455292f, 0.05560930f, 0.06093717f, 0.15640882f, 0.04080654f, 0.21828800f, 0.01624975f, 0.23713128f, 
    -0.23189339f, 0.11805232f, 0.19166675f, 0.16645847f, -0.02702671f, -0.15443796f, 0.09312710f, 0.00696635f, 
    -0.02357639f, -0.07737446f, 0.00874553f, 0.16217941f, 0.04264821f, -0.09838288f, 0.00630565f, -0.05132215f, 
    0.14726219f, -0.12978858f, -0.17768215f, 0.10726786f, 0.08234812f, -0.08245930f, 0.10504861f, -0.12657689f, 
    -0.25264820f, -0.00685049f, 0.05886617f, 0.26859602f, 0.21631090f, -0.07969798f, -0.03230739f, 0.05099455f, 
    0.01927424f, -0.09064671f, 0.06615334f, 0.12189659f, 0.37006912f, 0.15040717f, 0.01639126f, 0.08437545f, 
    0.00869970f, 0.05204435f, 0.16304001f, 0.02836444f, 0.03611130f, -0.03253007f, 0.03376364f, -0.02886302f, 
    -0.00688016f, 0.08400849f, -0.01197368f, -0.04216943f, -0.01779868f, -0.02595048f, -0.12999117f, 0.14991188f, 
    0.16748758f, -0.13521713f, -0.05148587f, 0.09401966f, 0.21336365f, 0.12022781f, -0.14270307f, -0.21372510f, 
    0.13080649f, 0.01624336f, -0.01210404f, 0.04674817f, 0.02398778f, -0.02526901f, -0.18251173f, -0.01312011f, 
    -0.15573129f, -0.13068236f, -0.15384941f, -0.32691035f, -0.11633360f, -0.00128368f, 0.18131401f, -0.07861996f, 
    0.07883207f, 0.08980304f, -0.00290294f, 0.10428673f, -0.11511749f, 0.02813555f, -0.02416660f, 0.11674694f, 
    0.04130492f, 0.02512998f, 0.07221597f, 0.02295410f, -0.06012794f, 0.03739921f, 0.23410958f, 0.01212197f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04739577f, -0.01228856f, 0.14815211f, -0.00708323f, -0.03106016f, 0.09965041f, -0.04119837f, 0.03478034f, 
    0.17924422f, 0.04241509f, 0.07671700f, -0.00535059f, 0.00296051f, 0.10353926f, 0.04615165f, -0.03874638f, 
    -0.00437416f, 0.03487663f, 0.11831441f, 0.09448389f, -0.00328981f, -0.08438699f, -0.04474997f, -0.01661384f, 
    0.07640862f, 0.03357859f, -0.02028023f, 0.04501460f, 0.06479775f, 0.04410363f, 0.13258958f, -0.03234529f, 
    0.04355440f, -0.07824720f, -0.09219491f, -0.03466986f, -0.08869659f, 0.12323127f, 0.12788805f, -0.06588478f, 
    0.23693302f, -0.05374392f, 0.04459182f, 0.08889498f, 0.01672489f, 0.03822855f, 0.00143318f, -0.07962152f, 
    -0.07915329f, 0.00888200f, 0.01997608f, 0.04837486f, 0.04498557f, -0.00708100f, -0.05265727f, -0.04498816f, 
    -0.00340312f, 0.04206476f, -0.03268781f, -0.04231120f, 0.03453725f, 0.16102876f, -0.09092752f, 0.03334691f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08296450f, -0.13403527f, -0.55876613f, -0.04169936f, -0.67141819f, -0.32497463f, -0.02088073f, 0.23546442f, 
    -0.33593521f, 0.04893212f, -0.61975944f, -0.03348856f, -0.01907048f, -0.50095689f, 0.17118634f, -0.30385187f, 
    -0.20825239f, -0.30234775f, 0.28329191f, 0.17617431f, -0.02444214f, -0.03213271f, -0.03599773f, 0.00453792f, 
    0.15733378f, 0.11086882f, -0.35713628f, 0.23956783f, 0.12318595f, 0.13544400f, -0.39119002f, -0.11327925f, 
    0.19567971f, -0.10857356f, -0.15181094f, 0.05780967f, 0.05113929f, 0.18928635f, -0.05777811f, 0.17214397f, 
    0.09845699f, -0.10331593f, 0.30689761f, -0.05470432f, 0.03721124f, 0.08370046f, 0.03615141f, -0.02560868f, 
    -0.10583590f, 0.06325459f, 0.02668705f, -0.12234604f, 0.05036017f, 0.24043484f, 0.09101545f, 0.04225305f, 
    0.56361729f, -0.10377710f, -0.11872197f, 0.09025767f, -0.36525053f, -0.76720786f, 0.08191267f, 0.18250836f, 
    0.02453276f, 0.15343395f, -0.12776305f, -0.03385020f, -0.21010773f, -0.14940529f, 0.09528186f, 0.09230148f, 
    0.13795127f, -0.04228744f, 0.05789220f, 0.09699178f, -0.00508882f, -0.41309452f, 0.03051819f, 0.13049136f, 
    0.10326095f, -0.17558718f, -0.55578411f, 0.14753905f, -0.19534157f, -0.20025118f, 0.02994701f, -0.02183471f, 
    0.33112445f, -0.10331751f, 0.10092817f, 0.14162658f, 0.01364139f, -0.24344012f, 0.06902604f, -0.12686332f, 
    -0.00648575f, 0.04066892f, -0.51506400f, -1.05283427f, 0.17972752f, 0.13122031f, 0.34471482f, -0.24004832f, 
    0.33171299f, -0.03029302f, 0.07829230f, 0.07875731f, -0.13435023f, 0.01917543f, -0.15652107f, -0.03646688f, 
    0.08520461f, -0.05384885f, 0.03693128f, -0.02013243f, 0.26894432f, 0.02743189f, 0.03486736f, 0.03870321f, 
    -0.53969938f, 0.05424356f, 0.06112340f, 0.16135292f, 0.00101117f, 0.10999975f, -0.51351875f, 0.07316015f, 
    -0.00988001f, 0.20019814f, -0.54458082f, 0.05241387f, -0.03860599f, -0.20077127f, 0.29806232f, -0.08706284f, 
    0.09333833f, 0.10557324f, 0.13329057f, 0.11685812f, 0.01281913f, -0.08094060f, -0.43453461f, 0.23679331f, 
    -0.19729456f, 0.46703079f, -0.70961368f, -0.19851999f, -0.23403309f, 0.13667624f, -0.05372163f, 0.31766158f, 
    -0.15006150f, 0.04672121f, 0.16764636f, -0.00731232f, -0.12264451f, -0.42069107f, 0.22324549f, 0.16607197f, 
    0.05429900f, -0.01956449f, 0.39496377f, -0.24381201f, 0.08261424f, 0.04638954f, -0.07677021f, -0.21863094f, 
    -0.65276289f, -0.00726663f, -0.21821789f, -0.05645235f, -0.04918426f, 0.04238609f, 0.07403301f, -0.10287239f, 
    0.04542178f, 0.07990164f, -0.03379022f, -0.22426724f, 0.05584735f, 0.12112864f, -0.09739224f, 0.02770708f, 
    0.49645081f, -0.12418074f, 0.10005911f, -0.04129870f, 0.19245590f, -0.37056565f, -0.05197402f, -0.19841184f, 
    0.00216574f, 0.24196105f, 0.23795417f, 0.06163500f, -0.35516182f, 0.26500103f, -0.24175648f, 0.09540091f, 
    -0.31744120f, 0.02032010f, 0.10577065f, -0.02836639f, -0.08178020f, 0.25363278f, -0.21865837f, -0.68855119f, 
    0.25854304f, -0.43132028f, 0.17960268f, -0.07535693f, 0.11047762f, -0.25060377f, -0.05640223f, 0.12658237f, 
    0.32232371f, 0.08782012f, -0.57142365f, 0.31483057f, -0.00249081f, -0.26365510f, -0.05065917f, 0.08697767f, 
    -0.40265974f, 0.00526256f, 0.28888866f, 0.07991649f, -0.56767523f, -0.46103814f, 0.06313417f, 0.30257574f, 
    -0.47275123f, 0.01415734f, -0.12173784f, 0.29813418f, -0.35117882f, -0.07825049f, -0.04856836f, -0.09970000f, 
    -0.02000888f, -0.00407378f, 0.00360419f, -0.41381636f, -0.08419235f, -0.21335128f, 0.10040253f, 0.08717579f, 
    0.27769351f, 0.09237733f, 0.08241644f, -0.08734205f, -0.37179601f, 0.15276636f, 0.16461441f, 0.04957438f, 
    0.03001314f, 0.26308268f, 0.17553373f, -0.10170694f, 0.09340627f, 0.40923214f, -0.49056557f, -0.23794012f, 
    0.02520559f, 0.10441753f, 0.12266219f, -0.00863906f, -0.00062003f, 0.04467985f, -0.09793855f, 0.43800193f, 
    -0.50782937f, -0.20138639f, 0.35477763f, 0.19109683f, 0.18970190f, -0.33265871f, -0.04963551f, -0.17138430f, 
    0.34137908f, -0.02257617f, 0.16328640f, -0.32137167f, -0.27989948f, 0.28491807f, 0.13007972f, -0.07088915f, 
    -0.00503480f, 0.03703747f, -0.36461568f, 0.20780008f, 0.00786580f, -0.43667153f, 0.07702092f, -0.15017079f, 
    -0.03349763f, -0.09909926f, 0.38112950f, -0.17061549f, -0.27947795f, -0.02361560f, -0.12193201f, -0.08225031f, 
    0.00344074f, -0.04209085f, -0.11260746f, 0.14724369f, 0.05399124f, 0.07033745f, 0.09927576f, -0.11145632f, 
    0.11759282f, 0.06482647f, -0.11096466f, -0.20065865f, -0.03579486f, -0.07483494f, 0.26589152f, -0.20538296f, 
    0.10349861f, -0.58479863f, 0.21850719f, -0.03949051f, 0.12905543f, 0.08645708f, 0.13108738f, -0.17855781f, 
    -0.16413842f, 0.08488183f, -0.69310433f, 0.01884083f, -0.06142296f, -0.06968014f, -0.02868410f, -0.59091759f, 
    0.13888898f, 0.20292191f, 0.16565709f, 0.21559566f, 0.00624824f, -0.16311537f, 0.09668943f, -0.05575730f, 
    -0.14558382f, -0.03311625f, -0.19830072f, -0.13352905f, 0.28797659f, 0.25198340f, -0.39336184f, 0.18612878f, 
    -0.29745969f, 0.08481573f, -0.07861956f, -0.20774536f, 0.20985940f, 0.18631084f, 0.15260968f, -0.23832963f, 
    0.10551870f, 0.00013637f, -0.08190884f, 0.00879658f, -0.16700900f, 0.02069234f, -0.11792741f, -0.07892634f, 
    0.01241322f, -0.08537411f, -0.07852101f, 0.18001416f, -0.12903403f, -0.07788029f, -0.04671794f, 0.08617464f, 
    -0.74717593f, -0.09445096f, 0.11136141f, 0.16395871f, 0.19445354f, -0.10258015f, 0.27295694f, 0.27391019f, 
    -0.13836055f, 0.38688505f, -0.37882584f, 0.06137446f, 0.33192968f, -0.38374552f, -0.15364203f, -0.30199540f, 
    0.15822093f, -0.07937079f, 0.11488909f, -0.09281535f, -0.04776322f, -0.03744684f, -0.07615057f, -1.01695907f, 
    0.29935247f, 0.07283185f, -0.70300794f, 0.01475041f, 0.34377927f, -0.03289756f, -0.07144447f, -0.56272316f, 
    -0.27344900f, -0.14029896f, 0.09915309f, -0.08133905f, -0.58337396f, -0.31881922f, -0.08958519f, 0.43193763f, 
    -0.01485318f, -0.00297551f, 0.40737629f, 0.22898397f, -0.22140829f, 0.16450395f, -0.31319493f, -0.01284619f, 
    0.22027409f, 0.10692049f, -0.05385769f, -0.09608816f, -0.17899877f, 0.01316387f, 0.01826970f, 0.04424062f, 
    0.08358199f, 0.04534114f, 0.05584774f, -0.02796080f, 0.19136995f, -0.11847702f, 0.07116478f, -0.04948115f, 
    -0.09653906f, -0.11922520f, 0.09545276f, 0.17088898f, -0.00387529f, -0.51777363f, 0.19711347f, -0.09910511f, 
    -0.01095486f, -0.04397732f, 0.11990676f, -0.01536733f, 0.35782120f, -0.01173039f, 0.19952284f, 0.26447880f, 
    -0.40347901f, -0.06777086f, 0.18530039f, -0.04819756f, 0.04849752f, -0.03507785f, -0.11234164f, 0.17863639f, 
    -0.20447056f, 0.03372882f, 0.15831947f, -0.47442532f, -0.00830557f, 0.08902588f, 0.02622463f, -0.18122751f, 
    -0.29347232f, -0.11021807f, 0.22145383f, -0.10232010f, 0.24583641f, -0.04269570f, -0.04697361f, -0.03291917f, 
    -0.33521587f, -0.00307225f, 0.14676748f, 0.27950469f, 0.26136851f, -0.14697474f, -0.29893011f, 0.21803614f, 
    -0.60158479f, 0.06915969f, -0.06012182f, -0.41977525f, 0.11362106f, 0.04563638f, -0.09387641f, 0.00173721f, 
    -0.03862983f, -0.01805222f, -0.04182663f, 0.32535699f, -0.15903096f, -0.27823776f, -0.00764952f, 0.05201478f, 
    0.28308362f, 0.10669386f, -0.09471912f, -0.31441492f, -0.37267146f, 0.20680167f, 0.20633614f, -0.54242814f, 
    0.09961888f, 0.05590734f, -0.24716017f, -0.07056594f, 0.23226991f, -0.01263946f, 0.24337701f, -0.41503569f, 
    0.12942620f, 0.04522457f, -0.33137891f, 0.10599405f, -0.01783087f, 0.07035654f, 0.33637860f, 0.42573231f, 
    0.17104702f, -0.16195941f, -0.13474253f, -0.18446632f, 0.28173739f, 0.05461771f, -0.06216915f, 0.22096156f, 
    -0.27304915f, 0.05127463f, -0.05695295f, -0.39841869f, -0.30723840f, -0.39749062f, -0.33125183f, -0.34046671f, 
    0.27836511f, 0.05396348f, -0.42607367f, 0.05513716f, 0.06568339f, 0.01619333f, 0.30367449f, 0.02488435f, 
    -0.55940741f, -0.09138933f, -0.24376298f, 0.16718997f, 0.36249280f, -0.08885550f, -0.12526301f, -0.00123052f, 
    0.03062252f, -0.10321222f, -0.00811102f, -0.29692107f, -0.28610608f, -0.23869877f, 0.05502534f, 0.02221770f, 
    -0.17001727f, -0.06247571f, -0.04225567f, 0.08423334f, -0.04516635f, 0.28533202f, -0.29876953f, 0.18693373f, 
    -0.00486589f, -0.16542982f, 0.24185179f, 0.04176109f, 0.12480042f, -0.25703546f, 0.10435487f, 0.10655374f, 
    0.07129277f, -0.12035792f, 0.21121103f, -0.06377293f, 0.03336092f, 0.24364747f, -0.55680007f, 0.03743144f, 
    0.06276755f, 0.24358606f, 0.15819938f, 0.17663017f, -0.13722596f, 0.24337998f, 0.03203128f, -0.55001038f, 
    -0.59199941f, -0.05065404f, 0.29576379f, 0.05498846f, -0.07516911f, 0.13473731f, -0.05991020f, -0.60382515f, 
    -0.05860253f, -0.11609703f, -0.01410389f, 0.31244284f, -0.22259337f, -0.30794609f, -0.29992551f, -0.09845840f, 
    0.12577651f, 0.10238021f, -0.16418935f, -0.65882009f, 0.28105834f, -0.08602941f, -0.02950981f, 0.08074263f, 
    -0.03666343f, 0.11184471f, -0.11759587f, -0.03138327f, 0.02426380f, 0.08409046f, 0.03721018f, -0.02704692f, 
    0.07950100f, 0.09148361f, 0.09669617f, 0.10487678f, 0.40446398f, -0.11203781f, -0.10597283f, -0.04985011f, 
    0.02738481f, -0.03313639f, 0.28094158f, 0.01218378f, 0.07036036f, -0.34609881f, -0.17535359f, 0.16808192f, 
    0.26745746f, 0.05985562f, 0.33594412f, 0.04564310f, -0.09565442f, 0.03867166f, 0.28241664f, 0.09786952f, 
    -0.32749802f, 0.29472506f, 0.02953037f, -0.42807949f, -0.33094108f, -0.30949992f, 0.06538314f, 0.22648612f, 
    -0.14292935f, -0.02546724f, -0.19659026f, -0.27530599f, 0.34535393f, 0.07102782f, 0.05894935f, 0.13224174f, 
    0.14567439f, 0.01696929f, -0.03188248f, -0.21899368f, -0.44325283f, 0.17164782f, 0.13010454f, 0.14890587f, 
    0.10695104f, -0.03713786f, -0.46151313f, 0.21618935f, 0.08259086f, 0.05466541f, -0.08839366f, 0.09405689f, 
    0.05919226f, 0.04419873f, -0.08064540f, -0.38572359f, -0.01479627f, -0.54979843f, -0.06133133f, 0.07403357f, 
    -0.27712846f, -0.09566331f, -0.04446803f, -0.38425145f, 0.19880794f, 0.22235528f, -0.06968835f, 0.01766280f, 
    -0.08144226f, -0.06362369f, 0.05354393f, 0.00634934f, -0.31713012f, 0.37120694f, -0.43911093f, -0.26257402f, 
    -0.12300578f, 0.06598793f, -0.20579115f, 0.09523258f, 0.04906540f, 0.22717427f, 0.26822901f, -0.17835033f, 
    0.16870977f, -0.58549190f, -0.11771169f, -0.04677379f, -0.17305949f, 0.38369533f, -0.02977822f, -0.11012631f, 
    -0.28414604f, 0.01943057f, 0.24420029f, 0.38195983f, -0.17586316f, 0.33351079f, 0.27354631f, -0.06437130f, 
    0.00994015f, -0.09338372f, 0.12631981f, 0.07202076f, -0.43537176f, 0.23583199f, -0.38826016f, -0.17032701f, 
    -0.06644123f, 0.10264044f, -0.32247782f, 0.21254195f, -0.39893916f, -0.02566182f, -0.06217764f, -0.03662514f, 
    0.05809995f, 0.12469383f, 0.05137183f, 0.13608062f, -0.59308147f, 0.18988504f, -0.03617786f, 0.10434502f, 
    0.02668483f, -0.03314500f, -0.06285510f, 0.12561883f, -0.43768182f, 0.29336375f, 0.03620379f, 0.08791628f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13038734f, 0.09863239f, -0.09917962f, 0.03534488f, 0.02643998f, -0.04128014f, 0.11190755f, -0.21921970f, 
    -0.08244289f, -0.06866664f, 0.14771788f, 0.14278212f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
