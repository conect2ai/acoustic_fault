#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23740737f, -0.03893941f, 0.18443941f, -0.23814575f, -0.50196528f, -0.20867036f, -0.27041829f, -0.45959729f, 
    -0.09034885f, -0.33182824f, 0.30535525f, -0.21483754f, -0.13580438f, -0.04720508f, -0.21856050f, -0.18804285f, 
    0.07895859f, -0.19021426f, -0.33838961f, -0.31081545f, -0.11799009f, 0.09218942f, 0.03499714f, 0.35420263f, 
    0.28751671f, 0.09560705f, -0.24552032f, -0.36575451f, -0.48337635f, -0.65743315f, 0.38213548f, 0.25977463f, 
    0.11424892f, 0.33414021f, -0.02623896f, -0.12390051f, 0.02541646f, -0.14008000f, -0.14882505f, -0.22191308f, 
    0.03507080f, -0.12264716f, -0.27967376f, -0.23192713f, 0.03025344f, -0.15102272f, -0.22437426f, 0.19946438f, 
    -0.31435940f, -0.20239940f, 0.19301429f, 0.85775697f, -0.37931901f, -0.30955848f, -0.36243024f, -0.24663787f, 
    -0.17850092f, 0.20647165f, -0.00311009f, 0.14488278f, 0.01046581f, -0.27721772f, 0.15655157f, -0.22907625f, 
    -0.06445087f, -0.07642177f, 0.04080858f, -0.08044743f, -0.12612696f, -0.23905997f, -0.40484992f, -0.19867991f, 
    -0.51805538f, -0.32734445f, -0.54490286f, -0.50575769f, 0.74962002f, 0.33045933f, -0.40729305f, -0.00104301f, 
    -0.08792954f, -0.33906415f, 0.35579911f, -0.30687594f, -0.26850963f, 0.01285095f, 0.33049810f, -0.27800703f, 
    0.11521759f, -0.08600962f, -0.03850547f, -0.10914595f, -0.13471323f, 0.13063920f, 0.09529749f, 0.24436934f, 
    0.32827607f, -0.06479196f, -0.24107118f, -0.54257017f, -0.42935571f, -0.33027512f, 0.01436715f, 0.07683579f, 
    0.01355668f, -0.27684239f, -0.64714915f, 0.33759934f, 0.21912333f, 0.55469888f, 0.30036908f, 0.06879214f, 
    -0.44592044f, -0.06401180f, -0.08970843f, -0.14355823f, 0.16849853f, 0.27814662f, 0.22410829f, 0.16800986f, 
    -0.09678498f, -0.41380081f, -0.39025649f, 0.32646713f, -0.23121807f, -0.73936838f, -0.70275104f, 0.07866436f, 
    0.23484544f, 0.59521025f, -0.36095148f, -0.38391289f, -0.54124135f, -0.30333039f, -0.38528478f, 0.13186891f, 
    0.33249596f, -0.21865886f, -0.39254424f, -0.38773927f, 0.05969118f, 0.01768446f, 0.12220673f, -0.23692891f, 
    0.05271684f, -0.35943508f, 0.17967358f, 0.12744530f, -0.40043083f, -0.05297796f, -0.73609042f, 0.30090275f, 
    0.67023480f, -0.74695796f, -0.06190582f, 0.00392222f, -0.18051684f, 0.29263029f, 0.54932201f, 0.13368832f, 
    -0.32820651f, -0.32336149f, -0.20244011f, -0.19071670f, -0.12834947f, 0.33176142f, -0.12470410f, 0.13410644f, 
    0.10392001f, 0.34143892f, -0.02610519f, 0.05634734f, -0.06811911f, -0.27663842f, -0.10320514f, 0.32482582f, 
    0.00726415f, 0.07044394f, -0.09030040f, -0.09281015f, -0.39449215f, -0.14161494f, -0.05580570f, 0.26577950f, 
    0.29292536f, 0.00307264f, 0.02332275f, -0.16155258f, -0.13898632f, 0.25440362f, 0.06393518f, 0.23050044f, 
    -0.39015856f, -0.12329568f, 0.25299492f, 0.00262338f, 0.07181002f, 0.04569460f, 0.22617841f, -0.28906989f, 
    0.21085517f, 0.15919983f, 0.16209809f, 0.08092664f, 0.27826157f, 0.27162957f, 0.13554840f, -0.01481150f, 
    0.05396768f, -0.01690375f, 0.14652914f, 0.15846747f, -0.13689561f, -0.20141663f, -0.08095482f, 0.10161471f, 
    -0.16553921f, 0.02358704f, 0.14663312f, 0.00214604f, 0.02834762f, 0.02455202f, -0.13495219f, -0.19738334f, 
    -0.00974498f, -0.18149036f, -0.21971069f, -0.27842686f, -0.43162405f, -0.13021554f, 0.32666719f, 0.00189324f, 
    -0.12692071f, 0.08464789f, -0.30161440f, 0.15883324f, 0.64812857f, -0.28829414f, -0.12440864f, -0.02466527f, 
    -0.39135796f, 0.11891749f, 0.01470049f, -0.18255122f, -0.12289608f, 0.11768511f, 0.31463555f, 0.25795701f, 
    0.14227216f, 0.04437466f, -0.61027086f, -0.33520567f, -0.33394700f, -0.44682413f, -0.03122735f, 0.10647974f, 
    -0.14335077f, 0.37520558f, -0.41678092f, 0.40606761f, 0.13335675f, 0.13396718f, -0.00670504f, -0.02564370f, 
    -0.13555089f, 0.24145377f, -0.13338542f, -0.05569435f, 0.10767529f, -0.05145851f, -0.04181185f, 0.37868384f, 
    0.12385383f, -0.00028052f, 0.11340200f, -0.32199720f, -0.44058430f, 0.11763658f, -0.00980992f, 0.27405640f, 
    0.53421181f, 0.29775357f, -0.40520370f, -0.23181768f, 0.43477118f, 0.45456204f, -0.11916748f, 0.02082027f, 
    -0.13408150f, -0.34253865f, -0.19393268f, 0.35930517f, -0.03346569f, -0.28742546f, -0.03207756f, -0.02241328f, 
    -0.21993959f, 0.07074881f, -0.16166936f, 0.21723618f, -0.23893635f, -0.37311980f, -0.03234367f, 0.40861052f, 
    0.35105482f, 0.33824146f, -0.16056181f, -0.17014202f, 0.24164072f, 0.29600722f, 0.51806438f, -0.27831182f, 
    -0.15103951f, -0.20487575f, 0.10240664f, -0.14316601f, 0.01346319f, 0.10141037f, -0.15886368f, 0.06565518f, 
    0.05826151f, -0.00430524f, 0.21794666f, 0.02691921f, -0.31341890f, 0.08764362f, -0.23023255f, -0.33363149f, 
    -0.12142660f, -0.29072675f, -0.19465093f, 0.09092559f, -0.12261299f, -0.27758372f, -0.46966219f, 0.09972052f, 
    -0.20125912f, 0.16648471f, 0.29676288f, 0.04766607f, -0.03845351f, -0.12426718f, 0.14518107f, -0.12865405f, 
    -0.15051435f, -0.07276528f, -0.00924316f, -0.05477527f, -0.04208503f, 0.29296952f, -0.34590098f, -0.04988614f, 
    -0.23013714f, -0.30543908f, -0.36592984f, -0.02513809f, 0.09460570f, -0.50497854f, -0.47990882f, 0.00422066f, 
    0.16149412f, 0.14722803f, 0.26442826f, 0.16157687f, 0.44002265f, -0.18261720f, -0.16274142f, -0.22447920f, 
    -0.16832231f, -0.24201599f, 0.08387085f, -0.05550553f, -0.18778409f, 0.22268313f, 0.20377587f, -0.50343144f, 
    0.10964235f, -0.42757574f, -0.31327915f, -0.54575771f, -0.23762085f, -0.02853354f, -0.05328819f, 0.51846027f, 
    0.38833702f, 0.07806341f, 0.20576222f, -0.14618145f, 0.11654981f, 0.12617554f, 0.03134071f, -0.02558185f, 
    -0.09703755f, 0.11520672f, 0.11652445f, 0.09349786f, -0.10305098f, -0.17276400f, -0.03472595f, 0.05288103f, 
    -0.17769203f, -0.57518631f, -0.45917219f, -0.36203456f, -0.38568982f, 0.37151125f, 0.21699157f, 0.21890345f, 
    0.29732686f, 0.36270323f, 0.14145268f, 0.08840863f, 0.18425639f, 0.03690496f, 0.28106663f, -0.15412012f, 
    -0.01913347f, -0.14315596f, -0.20421746f, -0.14195436f, -0.21864000f, 0.20095831f, -0.18343331f, 0.10422305f, 
    0.29932034f, 0.16809598f, 0.13278550f, -0.27060118f, -0.00670520f, 0.19787504f, -0.08437952f, 0.18363012f, 
    -0.11258524f, -0.12188333f, 0.10222698f, 0.19724776f, -0.18642427f, 0.19817926f, 0.01875274f, 0.10105727f, 
    -0.00600520f, 0.01117262f, -0.07908736f, 0.07971095f, 0.10988311f, -0.10325755f, 0.19070080f, 0.19009760f, 
    -0.19324394f, 0.27523214f, -0.11704029f, -0.32765222f, -0.72604054f, 0.24581949f, 0.22791384f, -0.23265880f, 
    0.31738985f, -0.29930830f, -0.34449255f, 0.19048585f, -0.25609368f, 0.28390849f, 0.13675559f, -0.19603240f, 
    0.37567085f, 0.07332414f, -0.21591586f, 0.24400084f, -0.65386081f, -0.22896005f, -0.15292974f, -0.27103615f, 
    -0.03546363f, 0.32986650f, 0.18561958f, -0.62495452f, -0.57234460f, -0.09902246f, -0.30246425f, -0.53548265f, 
    0.18660945f, 0.45867208f, -0.29099268f, -0.27420786f, 0.14299150f, -0.17683120f, -0.26401702f, -0.33345968f, 
    -0.11095347f, 0.16546252f, -0.01507398f, 0.49316293f, -0.40944988f, -0.46988285f, 0.11468611f, -0.10648128f, 
    -0.25061718f, -0.02502162f, 0.24335472f, -0.21890107f, 0.21300301f, 0.43932033f, 0.11061289f, -0.34505764f, 
    -0.19137323f, -0.18361324f, -0.17647067f, -0.43907788f, -0.42885214f, -0.52373290f, 0.27724648f, -0.04603925f, 
    0.03544018f, 0.17824550f, 0.00071671f, 0.39045322f, -0.25869972f, 0.17860982f, -0.18095705f, 0.03274523f, 
    -0.16778935f, 0.27206588f, 0.13845605f, -0.04950280f, 0.08919544f, 0.41833338f, 0.38521156f, 0.31013548f, 
    0.32510391f, 0.08620065f, -0.16962518f, -0.45159039f, -0.25839671f, 0.05800641f, -0.29036283f, 0.14193287f, 
    -0.13474180f, 0.03222283f, -0.15668896f, -0.29677925f, 0.14712311f, 0.08363715f, -0.02128401f, 0.02923236f, 
    0.02436727f, 0.14850913f, -0.22289237f, 0.01014819f, -0.09246568f, 0.15714955f, 0.11471723f, 0.13796680f, 
    -0.06618183f, 0.38620976f, 0.30262342f, 0.16331631f, 0.20447823f, -0.19754753f, -0.02264144f, 0.13344224f, 
    0.16432424f, -0.11756558f, -0.24232143f, -0.43014419f, 0.06400309f, -0.12401416f, 0.26136982f, -0.05183225f, 
    0.08855003f, 0.15312065f, 0.13297154f, -0.19527315f, -0.31947836f, -0.21175179f, -0.29393744f, 0.59278798f, 
    -0.66151482f, -0.54243404f, -0.57971889f, -0.41445476f, 0.01435236f, -0.04848596f, 0.38647580f, 0.10240681f, 
    0.01745373f, 0.00587497f, 0.40185827f, 0.39274520f, -0.25224149f, -0.06990179f, 0.07809691f, -0.05397783f, 
    0.20800084f, -0.12734458f, 0.02601306f, -0.04651060f, -0.32231835f, -0.18684946f, 0.21593781f, -0.29713655f, 
    0.41661552f, 0.15464316f, -0.01815545f, -0.05075016f, 0.14719534f, -0.45236191f, -0.45732114f, 0.22597919f, 
    0.25526735f, 0.15757623f, 0.01830927f, 0.03452507f, -0.01668316f, -0.10674124f, 0.06713464f, 0.14522314f, 
    -0.19877154f, -0.10221688f, -0.14408413f, -0.18243314f, -0.44479728f, 0.23570849f, -0.03771056f, -0.03267472f, 
    0.10231818f, 0.26349962f, -0.39749622f, -0.69444448f, 0.29611677f, 0.50184071f, 0.36573085f, 0.74927479f, 
    0.24705893f, -0.45201030f, -0.42177564f, -0.26680809f, 0.16769221f, -0.18139985f, -0.27952337f, -0.15501134f, 
    -0.05095789f, -0.05679810f, 0.04775906f, 0.10844775f, 0.07279097f, 0.31887758f, 0.00800323f, -0.12827702f, 
    -0.25303403f, -0.27149630f, 0.15564558f, 0.01345199f, 0.18827458f, -0.03751794f, 0.09439550f, -0.26806960f, 
    0.02202588f, 0.09862011f, -0.27466136f, -0.23044692f, 0.21578701f, -0.31170121f, -0.11796638f, 0.20159459f, 
    0.10624451f, 0.09094100f, 0.18270923f, -0.30054379f, -0.08981791f, -0.30725083f, 0.05953897f, 0.15919396f, 
    0.24674171f, 0.14141966f, -0.22705320f, 0.38886306f, 0.39876604f, -0.57563514f, 0.07166560f, -0.29505455f, 
    -0.53130227f, -0.41799116f, -0.05997992f, 0.36177906f, 0.33983415f, 0.01770700f, 0.06983470f, 0.22892918f, 
    -0.27682233f, 0.01799709f, -0.12345862f, -0.13928053f, 0.15964568f, 0.16235980f, -0.33162010f, -0.13005631f, 
    0.02506355f, 0.02132121f, 0.10816605f, 0.23016454f, 0.34078863f, 0.15350471f, 0.24870147f, 0.14570639f, 
    -0.23295031f, -0.21409042f, 0.12526903f, 0.11462715f, 0.09025573f, -0.20326468f, -0.22006699f, -0.21373850f, 
    0.12470105f, -0.06880646f, 0.00896374f, 0.29768372f, 0.17743547f, -0.06686424f, -0.27939454f, -0.06330852f, 
    0.21511741f, -0.19818415f, -0.27330193f, 0.18971729f, -0.35467684f, -0.46610597f, -0.07299773f, 0.53233898f, 
    -0.19363569f, -0.27152595f, 0.04832652f, -0.21395867f, -0.10710815f, 0.20844077f, 0.33136013f, -0.16410206f, 
    -0.05524657f, 0.09079969f, 0.00917970f, 0.13933894f, 0.01626033f, -0.05019478f, -0.09856984f, -0.33065820f, 
    -0.30405998f, 0.34051317f, 0.26933828f, 0.36088359f, 0.00705580f, -0.05345488f, 0.20675634f, -0.01321649f, 
    -0.34182531f, -0.24354090f, 0.13594332f, -0.09731544f, 0.32283756f, 0.17208934f, -0.11624333f, -0.14464004f, 
    0.19001204f, 0.05104717f, -0.36148554f, 0.32732880f, -0.26764354f, 0.11540893f, 0.01511353f, -0.33610150f, 
    -0.09017790f, 0.19460148f, 0.30775514f, -0.15891515f, -0.39841366f, 0.29110277f, 0.39158964f, -0.35620010f, 
    0.34212518f, 0.50228000f, -0.70437175f, 0.15135799f, 0.53792816f, -0.07617483f, -0.38188103f, -0.55935001f, 
    -0.20519267f, -0.04991373f, 0.32295722f, -0.01408609f, 0.12860365f, 0.15212730f, 0.15810530f, -0.06650092f, 
    -0.12094800f, 0.02472761f, -0.32505649f, -0.22116892f, 0.40330353f, 0.00440799f, -0.03690140f, 0.46786752f, 
    -0.05111320f, 0.05836169f, -0.20485839f, -0.14419453f, 0.30066991f, 0.28753746f, 0.18183476f, 0.37258390f, 
    -0.26061305f, -0.28298619f, -0.12945956f, 0.12973030f, 0.07684883f, -0.27783647f, 0.17351815f, -0.22923772f, 
    0.29179099f, 0.06805481f, -0.36305574f, 0.03777155f, -0.02503609f, -0.24321577f, -0.08957765f, 0.19638771f, 
    0.28312013f, -0.28780583f, 0.12132025f, 0.48160106f, -0.50398278f, -0.49831948f, 0.14695728f, 0.21298870f, 
    -0.19466555f, -0.00360989f, 0.61148030f, 0.12481259f, 0.55600041f, -0.39916942f, -0.33109564f, 0.14545871f, 
    -0.22142966f, 0.04739540f, 0.03909770f, -0.21677050f, -0.02594593f, -0.09595992f, 0.27401456f, 0.38335153f, 
    0.05316950f, -0.11495982f, 0.24803399f, 0.12939577f, 0.07995550f, -0.14376643f, -0.28564075f, 0.32109332f, 
    0.25511605f, 0.01918731f, 0.16513915f, 0.23788245f, -0.22500826f, 0.02114576f, -0.20139273f, 0.16107817f, 
    -0.26278111f, -0.04034084f, -0.28184256f, 0.18779835f, -0.01624900f, -0.30178371f, 0.18438751f, -0.05388187f, 
    0.32427427f, 0.16003105f, 0.31221548f, 0.19943097f, -0.32146981f, -0.50061578f, -0.61624199f, -0.70052749f, 
    0.25377941f, 0.27155763f, 0.23012048f, 0.13326621f, 0.34183180f, -0.10026953f, 0.38185030f, -0.11366118f, 
    0.08399362f, -0.22989294f, -0.20239998f, -0.19292228f, -0.08980527f, 0.32541892f, 0.08102914f, 0.42889351f, 
    0.02321643f, -0.06330807f, -0.22885706f, -0.01615733f, 0.07411485f, 0.14257444f, -0.33625022f, -0.12210330f, 
    0.29492566f, 0.14838107f, 0.03136529f, 0.05713576f, 0.26936668f, -0.06364167f, 0.27032503f, -0.19946052f, 
    0.04663406f, 0.07921787f, -0.14473727f, -0.08266977f, -0.04656225f, 0.20932259f, -0.19988364f, -0.28780654f, 
    0.03004573f, -0.03740978f, 0.32613745f, 0.14262342f, -0.05145547f, -0.47825962f, -0.51863497f, 0.08835922f, 
    0.40831649f, 0.10800844f, -0.53165752f, -0.22049309f, -0.44679129f, -0.12823446f, 0.54724050f, -0.17171964f, 
    -0.43908128f, 0.25230864f, 0.21737947f, -0.24297637f, -0.08998249f, -0.29855308f, 0.12969044f, -0.12540874f, 
    -0.45759830f, 0.01459118f, -0.13678138f, -0.40112206f, -0.17361048f, -0.31767386f, -0.69048023f, -0.29525924f, 
    -0.45164803f, -0.44759545f, -0.22999665f, 0.69402659f, -0.00229597f, -0.05435725f, 0.21675882f, 0.46039528f, 
    -0.29486477f, -0.38672072f, -0.12965058f, -0.07885753f, -0.14383496f, 0.21311913f, 0.17269433f, 0.32735524f, 
    -0.02209979f, -0.10998193f, -0.05930369f, 0.21817185f, 0.21667689f, -0.03512692f, 0.23975153f, 0.30925632f, 
    0.02194270f, -0.30053401f, 0.01863662f, 0.23497535f, 0.41441619f, 0.21515298f, -0.03552867f, -0.36694700f, 
    0.37565815f, -0.31832504f, -0.15688570f, -0.09390654f, 0.02813976f, 0.36859801f, -0.13130257f, 0.11478073f, 
    -0.04570150f, -0.15331584f, -0.17872082f, -0.02801977f, -0.09227157f, -0.10011185f, 0.03043773f, 0.13919692f, 
    -0.82664710f, 0.24359004f, 0.35936099f, 0.30642074f, 0.36968699f, -0.07611825f, 0.07554810f, -0.21650822f, 
    0.08207904f, -0.07149149f, -0.38112727f, -0.16223854f, -0.18919811f, 0.26662394f, 0.29867053f, 0.17374851f, 
    -0.14903155f, -0.00893991f, 0.12861660f, -0.20021750f, -0.21476330f, -0.22577797f, 0.29989558f, 0.17926918f, 
    -0.41329771f, 0.37561700f, 0.38198394f, 0.17631455f, -0.18766861f, 0.14115027f, 0.20779392f, -0.39571920f, 
    -0.26657009f, -0.08792058f, -0.06242566f, -0.15361169f, 0.20941174f, 0.19896924f, -0.19475028f, -0.09096994f, 
    -0.10767543f, -0.08882605f, 0.01203755f, 0.12697625f, -0.22192678f, -0.10432030f, 0.17862909f, -0.24770479f, 
    0.25953013f, -0.18279020f, -0.48063752f, -0.20361294f, -0.07325220f, -0.23334843f, -0.18073727f, -0.02535383f, 
    0.12942214f, -0.46245587f, -0.62241763f, 0.04621273f, -0.10335838f, -0.18854530f, -0.13066562f, -0.26544023f, 
    -0.18308562f, -0.01556824f, -0.09026641f, -0.19979200f, -0.12061111f, -0.14989066f, -0.02058779f, -0.09757597f, 
    -0.02138554f, -0.12127697f, 0.11793631f, 0.41736606f, 0.87063873f, 0.38843834f, -0.44024947f, -0.61761522f, 
    -0.01107464f, -0.29565942f, -0.23325601f, -0.19979110f, 0.17415896f, 0.16146490f, -0.19988725f, 0.02677787f, 
    -0.02880842f, 0.20594491f, 0.05903113f, 0.16135810f, 0.12929194f, 0.11724538f, -0.50851774f, -0.19997202f, 
    0.11842396f, 0.18362238f, -0.14457907f, -0.31189549f, -0.80852515f, -0.16080247f, -0.11031969f, 0.16164191f, 
    -0.07948767f, 0.33122414f, 0.27439490f, 0.20241603f, 0.27060822f, 0.33973172f, 0.38707513f, -0.28762400f, 
    -0.06600732f, 0.02268649f, 0.08647051f, -0.27581218f, -0.06629353f, -0.03064775f, -0.03505569f, 0.20869412f, 
    -0.10851845f, -0.00183300f, 0.13646972f, 0.15554012f, -0.33972248f, 0.00164593f, 0.11937744f, -0.46816400f, 
    -0.17498110f, 0.04589324f, 0.05663049f, -0.17398140f, 0.50277007f, 0.00756180f, -0.06832408f, 0.11818794f, 
    0.36553019f, 0.12200957f, 0.05838432f, -0.41927934f, 0.17744018f, 0.16728330f, -0.25595486f, -0.36473206f, 
    0.25745448f, 0.02336165f, -0.00442039f, -0.02325540f, 0.25533459f, 0.02392184f, -0.26700577f, -0.10191078f, 
    0.02060629f, 0.88628471f, -0.36663359f, 0.01892096f, 0.01135803f, -0.14238952f, -0.39462009f, -0.20253521f, 
    -0.05351936f, 0.09835953f, -0.01526848f, 0.10681718f, 0.18178456f, -0.25106588f, 0.17801572f, 0.10254252f, 
    -0.22038826f, -0.12197205f, 0.31239825f, -0.14255460f, 0.03889905f, 0.24995136f, -0.06407415f, 0.67205858f, 
    -0.53625983f, -0.35055095f, 0.66897660f, -0.04863516f, 0.18547025f, 0.19856846f, -0.04895524f, -0.24107639f, 
    -0.38273105f, -0.14157613f, 0.37610981f, -0.26776206f, -0.19831647f, 0.12029360f, -0.00269776f, 0.08016466f, 
    0.03789872f, -0.20811574f, 0.00714306f, 0.15554672f, -0.10372388f, -0.00360383f, 0.18073481f, -0.18806228f, 
    0.87182510f, -0.50658226f, -0.33593008f, -0.34219614f, -0.10980859f, 0.26476651f, 0.37241498f, 0.32993579f, 
    -0.24821910f, -0.21879263f, 0.07256232f, 0.41516185f, -0.34448418f, 0.09725186f, -0.30255657f, 0.20089252f, 
    -0.17156896f, -0.08799034f, -0.08492169f, 0.03599653f, -0.05534542f, 0.05249911f, -0.17555889f, 0.16308938f, 
    0.09677364f, -1.16829443f, 0.20396158f, 0.10421745f, -0.53147012f, 0.13070735f, -0.02599002f, -0.38487759f, 
    0.27506372f, 0.74476659f, 0.43406546f, -0.30914041f, 0.14035386f, -0.27380070f, 0.37538499f, -0.07536303f, 
    0.18903632f, 0.02187869f, 0.06511661f, 0.11679121f, -0.18423024f, -0.04194636f, 0.14755401f, 0.06660420f, 
    -0.12939908f, -0.09817567f, -0.64551747f, 0.25057822f, 0.36751205f, -0.25668463f, 0.12408355f, -0.24920438f, 
    0.22547664f, -0.28250858f, 0.52163768f, -0.06248070f, -0.18726873f, -0.01436210f, 0.35729396f, -0.38216957f, 
    0.05139669f, -0.19486009f, 0.22304647f, -0.09639870f, -0.08450838f, 0.16792132f, 0.00446850f, 0.19606690f, 
    -0.15006791f, 0.00416859f, -0.06027018f, 0.18754686f, -0.25611770f, -0.12732910f, -0.21770646f, -0.21913144f, 
    -0.28856605f, -0.52462775f, -0.49934992f, -0.23501784f, -0.60007101f, -0.05461517f, -0.15524873f, 0.10380612f, 
    0.76355737f, -0.05217561f, -0.15882523f, -0.11449195f, -0.12407796f, -0.18412504f, -0.11792399f, -0.29200983f, 
    0.11731422f, -0.01267266f, 0.02122391f, -0.05957163f, -0.11998039f, 0.29688844f, -0.37474334f, -0.45837513f, 
    0.47791058f, -0.03661044f, 0.20145920f, 0.28631738f, -0.09000561f, -0.30116245f, -0.18911742f, -0.25870442f, 
    0.28213084f, -0.40166581f, 0.06437712f, 0.23634431f, -0.08816805f, -0.32336494f, -0.11380079f, -0.15706889f, 
    0.09061801f, -0.13124762f, -0.33895969f, -0.12905873f, -0.26936790f, 0.63262004f, -0.10012880f, 0.22011396f, 
    0.05935784f, 0.59882063f, 0.45080009f, -0.22897257f, -0.47177914f, -0.67533576f, -0.48741046f, -0.09554528f, 
    -0.03214948f, 0.28868088f, -0.32754338f, -0.12545228f, 0.08569644f, -0.13918819f, 0.30931899f, -0.01730862f, 
    0.11135454f, -0.23787698f, 0.20015429f, -0.08831558f, -0.01651785f, -0.06895849f, 0.21514572f, -0.16822149f, 
    -0.19335949f, -0.12361199f, 0.30711469f, -0.08658504f, 0.17367819f, 0.07349685f, -0.25379503f, 0.19142652f, 
    -0.05214539f, 0.46500251f, -0.01285075f, -0.26074895f, -0.24663684f, -0.12162206f, 0.17423086f, -0.25740281f, 
    0.18128225f, 0.01207965f, 0.19288854f, -0.20530903f, -0.13739751f, 0.36602095f, -0.23300977f, 0.58483380f, 
    -0.14183773f, -0.46197274f, -0.16272368f, -0.20355698f, -0.14331058f, 0.05576239f, -0.05475059f, 0.38648322f, 
    -0.43921301f, 0.11786388f, 0.04628447f, -0.19188187f, 0.39252359f, -0.20333391f, -0.02902403f, -0.24214314f, 
    0.28193521f, -0.01388467f, -0.29857674f, 0.07166128f, -0.25331879f, -0.07448319f, -0.35330251f, -0.21421985f, 
    0.28280744f, 0.52513540f, 0.14158253f, -0.29884163f, 0.33410817f, -0.44143546f, -0.32981145f, -0.11361316f, 
    0.31946352f, -0.04608889f, -0.33887121f, 0.04361525f, -0.33235741f, -0.09197342f, 0.26018894f, 0.15694383f, 
    0.22542717f, 0.06699097f, -0.11854015f, 0.17175877f, -0.12031306f, -0.00129124f, -0.32256672f, -0.20207550f, 
    0.06927634f, -0.86824638f, 0.39454141f, 0.46535486f, 0.51404572f, -0.06634941f, 0.12028177f, 0.03377610f, 
    -0.23919769f, -0.16665016f, 0.02338693f, -0.20880692f, 0.00795131f, 0.08965889f, -0.04667356f, -0.12143650f, 
    -0.12423001f, 0.26835668f, -0.25200570f, 0.01304709f, 0.14393105f, -0.06059934f, -0.07110383f, 0.29565614f, 
    0.11760473f, -0.25116858f, 0.23957710f, -0.73213881f, -0.12372386f, -0.27546835f, 0.46561047f, -0.32877198f, 
    -0.02506021f, -0.11422678f, 0.19444388f, -0.06357609f, 0.08598357f, -0.24429657f, 0.07880814f, 0.00527132f, 
    -0.13345656f, 0.12187630f, 0.02230677f, -0.25622573f, 0.11089787f, -0.03112342f, -0.13002270f, 0.15728022f, 
    0.07696809f, 0.09262550f, 0.22430740f, 0.38301292f, -0.60217887f, 0.20501761f, -0.19759108f, 0.00395987f, 
    0.12182081f, 0.11364143f, 0.20921780f, -0.24434870f, -0.27778777f, 0.46328977f, -0.21386899f, -0.30810380f, 
    -0.08211429f, -0.19749671f, -0.27406707f, -0.13373855f, 0.23293708f, 0.17814764f, 0.07634038f, 0.12469858f, 
    0.07756517f, -0.20256366f, -0.30312869f, -0.49960941f, 0.01749541f, -0.36493424f, -0.39470294f, -0.27246669f, 
    -0.40823498f, -0.09503747f, -0.08154317f, -0.19875011f, 0.03336651f, -0.23631750f, 0.08724338f, -0.31642246f, 
    -0.17145717f, -0.23037931f, 0.38629338f, -0.24739525f, -0.03509145f, -0.27276668f, 0.12090243f, -0.53278553f, 
    -0.19820301f, -0.17209738f, 0.02306570f, 0.25440714f, -0.43912265f, -0.27796835f, -0.04599687f, -0.20832424f, 
    -0.45395961f, -0.31093010f, -0.35294390f, -0.29927689f, -0.18547760f, -0.41165611f, -0.30417114f, 0.34608990f, 
    0.25575757f, 0.20680350f, -0.21046342f, -0.07660063f, 0.20055723f, 0.09566126f, 0.20126091f, 0.17479964f, 
    0.12744766f, 0.28813618f, 0.04817256f, -0.18311512f, -0.07286005f, -0.00181807f, -0.60729408f, 0.13834807f, 
    0.36254391f, 0.21478513f, -0.31049252f, -0.43902430f, 0.02165649f, -0.02338910f, -0.20374684f, 0.08836085f, 
    -0.16797702f, 0.53490412f, -0.45016870f, -0.20269288f, 0.27619207f, 0.14932087f, -0.35741767f, -0.10648689f, 
    0.02101005f, -0.04599935f, 0.00254556f, -0.11334440f, -0.05228256f, -0.00953652f, 0.11976466f, -0.32430974f, 
    -0.03766791f, -0.04464812f, 0.21913163f, 0.19824120f, 0.22084270f, 0.03324369f, -0.21154523f, -0.14090689f, 
    -0.24157690f, 0.16051465f, -0.20384851f, 0.12014813f, 0.20961089f, 0.04419520f, -0.09017764f, 0.13855934f, 
    -0.30854961f, 0.09372494f, -0.11927636f, 0.29578999f, -0.10752165f, 0.06779964f, -0.09445126f, 0.02950003f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17359042f, -0.14923052f, -0.23101597f, 0.12846355f, -0.07467715f, -0.11425013f, -0.01488385f, 0.15087385f, 
    -0.33271706f, 0.00139103f, -0.42864886f, 0.12090717f, 0.17840619f, -0.19056942f, 0.08265460f, 0.04044287f, 
    0.08636113f, 0.08490280f, 0.12007276f, -0.18093577f, 0.02197227f, -0.01449878f, 0.02801378f, -0.19608603f, 
    0.19433211f, 0.07037128f, -0.17802717f, 0.26658782f, -0.14528728f, -0.03798269f, -0.16194622f, -0.14799540f, 
    0.21184474f, 0.13457754f, -0.22644971f, 0.23472965f, -0.10325923f, -0.12615192f, -0.35824555f, 0.01832881f, 
    -0.02420810f, 0.17207296f, -0.22445679f, 0.00074632f, -0.12747899f, -0.17432509f, -0.10568187f, 0.00834499f, 
    0.10360830f, -0.00436049f, 0.05821871f, -0.19742288f, -0.02840147f, 0.08979300f, 0.13731474f, -0.11987153f, 
    -0.22884753f, -0.03586657f, 0.08154467f, 0.00078749f, -0.27914178f, -0.23461595f, 0.17637208f, -0.29365242f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01704378f, -0.03028610f, -0.04188268f, 0.01239429f, 0.05882122f, 0.06694636f, -0.02476658f, -0.01793390f, 
    0.03270674f, -0.07407831f, -0.06936127f, -0.07904656f, -0.20081142f, 0.04253403f, 0.12132171f, 0.23844975f, 
    -0.02995395f, 0.04295155f, 0.11296974f, -0.00725643f, 0.14931849f, 0.16173840f, 0.10848638f, 0.22518830f, 
    -0.05430498f, -0.17489618f, 0.08559736f, -0.07088034f, 0.01232044f, 0.11860090f, -0.11650178f, -0.00856294f, 
    0.23177820f, 0.20759933f, 0.21602930f, 0.30229121f, 0.11919209f, 0.17289291f, -0.06157381f, -0.05117360f, 
    0.10028645f, 0.05274654f, 0.02150472f, 0.04564502f, 0.15577972f, -0.17529279f, -0.08162356f, 0.26457915f, 
    0.35112327f, 0.09101671f, -0.05081395f, 0.03376591f, 0.04942403f, 0.01641697f, 0.25525242f, 0.10387260f, 
    0.05844269f, 0.14072840f, 0.06954177f, 0.27835467f, -0.04333630f, -0.02873185f, -0.18371338f, 0.03586278f, 
    0.03735887f, 0.01751752f, -0.12453666f, 0.02598356f, 0.08263056f, -0.04826931f, -0.02122608f, -0.12124250f, 
    0.40412292f, -0.11077485f, 0.05209725f, -0.07339191f, 0.04898240f, 0.22121483f, 0.03423302f, 0.03530894f, 
    0.02334342f, 0.04593416f, 0.22756657f, 0.22072411f, -0.02133935f, -0.15453716f, 0.11950292f, -0.06786265f, 
    -0.01558776f, 0.06498825f, -0.01098954f, -0.10300788f, 0.02723247f, -0.01818366f, -0.28591532f, 0.20684300f, 
    -0.00271548f, 0.07189222f, -0.01118694f, -0.12975912f, -0.18445548f, 0.07774049f, -0.01333591f, 0.13653027f, 
    -0.00502753f, 0.05064476f, 0.07536458f, 0.06026101f, -0.06797144f, -0.07655028f, -0.17095934f, -0.03305179f, 
    0.04497584f, 0.02965382f, -0.03140018f, -0.00979012f, -0.01090895f, -0.09656944f, -0.23629466f, -0.10506611f, 
    0.05243422f, 0.08686236f, -0.07460900f, -0.01757350f, 0.10407574f, -0.06651781f, -0.10644884f, -0.04840912f, 
    -0.05538669f, -0.15367103f, -0.02820957f, -0.15657447f, -0.14851339f, 0.13039453f, 0.00430693f, 0.05859977f, 
    0.15739967f, 0.02188666f, -0.14676793f, -0.09186789f, -0.02942385f, 0.14004186f, 0.02940035f, 0.09170234f, 
    0.02373211f, -0.00240813f, 0.12994012f, -0.29212090f, -0.05165429f, 0.04477385f, 0.09577128f, -0.05022001f, 
    0.05788162f, 0.08362623f, 0.15911230f, 0.02127011f, -0.05456073f, -0.05644827f, -0.03722768f, -0.05916378f, 
    -0.03457061f, -0.03581524f, 0.01080970f, 0.11702584f, -0.05611611f, -0.00373658f, -0.02814991f, -0.08471249f, 
    0.00158525f, -0.05342532f, -0.13877288f, -0.02044676f, 0.02925700f, -0.05388938f, 0.06863703f, -0.07117704f, 
    0.06299669f, 0.00657918f, -0.14835599f, -0.01919452f, 0.54278761f, 0.25041413f, 0.13518141f, 0.23574571f, 
    0.00069438f, 0.05884651f, 0.04066365f, -0.17467758f, -0.01712449f, 0.02870957f, -0.09017791f, 0.04206494f, 
    -0.07447425f, 0.12767728f, 0.20607726f, 0.27135321f, -0.07699981f, -0.04093316f, 0.01168554f, 0.04129408f, 
    0.00440040f, -0.02400958f, -0.21686323f, -0.04767292f, -0.02965759f, 0.01070758f, 0.02190300f, -0.06294612f, 
    0.00328373f, 0.07247010f, -0.18493296f, 0.02098431f, -0.07221434f, -0.10683178f, -0.19260736f, -0.22019807f, 
    -0.00172151f, -0.18237364f, -0.04412536f, -0.04321874f, 0.02723203f, -0.04600686f, -0.02904293f, -0.00995193f, 
    -0.02457539f, 0.06222305f, 0.05819950f, -0.14602393f, -0.04355052f, -0.07285538f, 0.11245524f, -0.00861530f, 
    0.03727464f, -0.11227259f, -0.05577036f, 0.05510548f, 0.05140446f, -0.04130967f, -0.02340827f, 0.29599786f, 
    -0.05280621f, 0.00758725f, 0.07443554f, 0.03409704f, 0.09958583f, 0.06486810f, -0.09814322f, 0.01212896f, 
    -0.00852021f, -0.10373560f, 0.03337707f, -0.16600482f, 0.00447859f, 0.04452507f, 0.30782935f, -0.02927645f, 
    0.05731025f, -0.01395863f, 0.04271166f, 0.05259114f, -0.10598905f, -0.04673011f, -0.10692289f, -0.07838497f, 
    -0.04602045f, 0.08991035f, -0.09290083f, -0.02839854f, -0.13859780f, 0.08942346f, 0.12523893f, 0.11918732f, 
    0.25359949f, 0.24486779f, -0.03771259f, 0.20702651f, -0.36292171f, 0.23859026f, 0.11179785f, 0.29104167f, 
    -0.13042034f, -0.02135673f, 0.34297398f, -0.09897043f, -0.08140756f, 0.20128340f, 0.14472353f, -0.01683813f, 
    0.15678868f, -0.13823022f, 0.00105780f, -0.02845158f, 0.01609576f, 0.08267418f, -0.17769964f, -0.01622328f, 
    -0.10331879f, 0.05041156f, -0.00309790f, 0.07147518f, 0.21316434f, 0.23803844f, -0.18764408f, 0.24729289f, 
    0.01335737f, 0.04882107f, 0.11302304f, 0.01392824f, -0.00888945f, -0.03017448f, 0.05238642f, 0.10662317f, 
    0.05200366f, -0.01657971f, 0.10155842f, 0.16351438f, 0.01900316f, 0.03140130f, -0.01669015f, -0.15396684f, 
    -0.15419975f, -0.23600630f, -0.13652366f, -0.08266643f, -0.10961870f, 0.02598369f, 0.03930645f, 0.08190201f, 
    0.05802739f, 0.01398591f, -0.08315473f, 0.04646329f, -0.16049251f, 0.07632385f, -0.02205436f, -0.12161655f, 
    -0.12867968f, 0.05253136f, 0.01471302f, 0.03880012f, -0.14313544f, -0.14768945f, 0.20814604f, 0.06583113f, 
    0.04182895f, 0.20696573f, 0.13705909f, 0.12514901f, 0.08949337f, -0.01128541f, -0.05959019f, 0.04185839f, 
    0.02004304f, 0.25174791f, -0.01596589f, -0.22665010f, 0.11262720f, -0.14237326f, -0.33853102f, 0.02754391f, 
    -0.14762881f, -0.05189257f, -0.22534317f, 0.14951520f, 0.07597023f, 0.00247767f, 0.11144143f, 0.13173085f, 
    -0.17019254f, -0.12843865f, -0.12309641f, -0.12044991f, -0.20134555f, 0.16073741f, -0.18006283f, -0.02118800f, 
    0.08009359f, 0.13842058f, -0.18925735f, -0.04977415f, -0.10265671f, -0.12740371f, -0.19797865f, -0.15136491f, 
    -0.02487141f, 0.03762317f, 0.09909373f, -0.12557197f, 0.02473166f, -0.01129429f, -0.04381969f, 0.04459143f, 
    -0.12600985f, 0.01512857f, -0.10221189f, -0.07114469f, -0.02099058f, -0.10328365f, 0.07551622f, 0.10277765f, 
    0.15159066f, 0.10313910f, -0.08494008f, -0.07239103f, -0.03468586f, 0.11143281f, 0.02308456f, 0.11733167f, 
    -0.11716520f, -0.12297889f, -0.09619922f, -0.09441825f, 0.09740226f, 0.07224129f, -0.03977880f, -0.07894755f, 
    -0.26773670f, -0.17552933f, 0.03450803f, -0.04429324f, 0.00875251f, 0.07327030f, 0.11360069f, 0.24716845f, 
    -0.03702303f, 0.04009270f, 0.12531003f, -0.08124401f, -0.08499195f, 0.01009832f, 0.07005952f, -0.04278652f, 
    0.03015372f, -0.19291997f, 0.10661750f, -0.19989677f, -0.06373887f, 0.03105329f, -0.09151273f, -0.04513252f, 
    -0.16464095f, 0.05306782f, 0.03290264f, -0.13724862f, 0.04733086f, -0.11910145f, -0.12600003f, 0.06043274f, 
    0.11981841f, 0.03447064f, -0.06069401f, 0.18983841f, 0.01630123f, 0.06867324f, 0.20775543f, 0.13995980f, 
    0.05063440f, -0.11615584f, 0.23359270f, 0.11375253f, 0.04339582f, 0.01650509f, -0.12375934f, -0.10026617f, 
    0.03951178f, 0.01071227f, 0.03361630f, 0.23836848f, 0.11701938f, -0.21165617f, -0.07566976f, 0.03044770f, 
    -0.05661125f, -0.10604394f, -0.04547885f, -0.02805956f, 0.02748309f, 0.05103525f, 0.02325923f, 0.00834028f, 
    0.25331414f, 0.35633752f, -0.25256580f, 0.14082772f, -0.12330972f, -0.00383563f, 0.14736010f, -0.08323719f, 
    0.03465418f, 0.18698153f, 0.20914334f, 0.17542376f, 0.07548711f, 0.16664150f, 0.44223469f, -0.08450587f, 
    0.01650766f, -0.13617676f, -0.06824279f, 0.06117031f, -0.22759140f, -0.06422102f, -0.02741949f, -0.04990847f, 
    -0.02530102f, -0.13409036f, -0.12031100f, -0.06009781f, 0.01459906f, -0.04292502f, -0.02760022f, -0.11721044f, 
    -0.00332689f, 0.00038209f, 0.00492561f, -0.00816604f, -0.04633387f, -0.02615691f, 0.28390637f, -0.19654368f, 
    -0.07329109f, 0.14939468f, -0.07013111f, -0.00625770f, 0.00265941f, 0.06367575f, 0.03945719f, 0.11594527f, 
    0.12767509f, 0.02821431f, 0.18045895f, -0.06839389f, 0.08095598f, -0.03233380f, 0.17281559f, 0.07352442f, 
    0.05285168f, -0.02369745f, 0.08589277f, -0.04265476f, -0.08186018f, 0.09239776f, 0.01677383f, -0.02621444f, 
    -0.12399843f, -0.08494419f, 0.07977951f, 0.28685194f, -0.01627319f, 0.14154084f, -0.15487115f, -0.16761972f, 
    0.08621559f, 0.24516946f, -0.07887104f, 0.23800689f, 0.01210265f, -0.22083668f, 0.01814895f, 0.04875159f, 
    -0.09181400f, 0.02303362f, -0.19090277f, 0.05959785f, -0.01576195f, 0.14685349f, -0.11670918f, 0.29053310f, 
    -0.13723919f, -0.09931208f, 0.17554204f, 0.02771402f, -0.04872992f, -0.07828184f, -0.21438952f, 0.05308950f, 
    -0.44108763f, 0.13979830f, -0.15777186f, 0.19282688f, -0.10160258f, -0.14519614f, -0.02944033f, -0.02813760f, 
    -0.10756575f, 0.03180396f, 0.10973243f, -0.00796013f, 0.60622621f, -0.04796655f, -0.10484875f, 0.13179727f, 
    0.06599079f, 0.12693794f, 0.02573835f, -0.19128045f, 0.01994488f, -0.08658814f, -0.04652092f, 0.09034994f, 
    0.30221578f, -0.06192724f, -0.18844897f, -0.24495162f, 0.12515885f, 0.06567831f, -0.07710466f, -0.03301417f, 
    0.04981735f, -0.07281035f, -0.06823178f, 0.17467205f, -0.07068275f, -0.26392105f, 0.04253526f, -0.04435677f, 
    -0.02329067f, 0.02412483f, 0.02297489f, 0.09526084f, 0.06258160f, -0.06924292f, 0.06763552f, -0.03445094f, 
    0.04385114f, 0.03411144f, -0.05121077f, 0.06596208f, -0.00380802f, 0.05594738f, 0.07154837f, 0.02443028f, 
    0.00401338f, 0.20992637f, 0.27009976f, 0.18199968f, 0.01150770f, 0.36755800f, 0.29110581f, 0.07888503f, 
    0.01905999f, -0.02049471f, -0.13361017f, -0.08757342f, -0.03117310f, -0.01665190f, 0.01356256f, -0.17172073f, 
    -0.06723820f, 0.08297632f, -0.14390627f, 0.13129924f, 0.00873832f, -0.12791331f, 0.16461909f, -0.00812078f, 
    -0.03819310f, 0.11984378f, -0.14564803f, -0.04858615f, -0.12903257f, -0.06779624f, -0.09013291f, 0.16363437f, 
    0.05842387f, 0.15208298f, 0.09106810f, 0.02036463f, -0.04717290f, 0.18427794f, 0.30933210f, 0.15158117f, 
    0.11186215f, -0.31842351f, 0.23815684f, -0.08216748f, -0.05574367f, 0.15785001f, -0.09457585f, 0.04795517f, 
    0.09060585f, 0.04071620f, -0.17356020f, 0.00542717f, 0.02530667f, 0.55106449f, -0.03495977f, -0.26421645f, 
    0.07315525f, -0.08948673f, 0.01010669f, -0.08377012f, -0.20728117f, -0.11310184f, 0.06843805f, 0.05209178f, 
    -0.18588394f, -0.00750530f, -0.01657889f, -0.01562368f, 0.04306546f, -0.01424805f, -0.11150620f, -0.12656565f, 
    -0.08307949f, -0.05719974f, 0.03847095f, -0.17836702f, -0.20073284f, 0.16943644f, 0.14473405f, -0.00038454f, 
    -0.07406179f, 0.17192125f, 0.00380087f, -0.00477842f, 0.25762385f, 0.08461329f, 0.14857589f, 0.41298226f, 
    -0.17542218f, -0.07184125f, -0.00083860f, 0.03400204f, -0.02021442f, 0.01510201f, 0.10694412f, -0.03688661f, 
    0.01418045f, 0.04047984f, 0.07125173f, 0.20700589f, 0.07926010f, 0.09738948f, -0.05213352f, -0.08070804f, 
    0.08005685f, -0.06581733f, -0.08745263f, -0.10922522f, 0.16874260f, 0.02625947f, 0.01168560f, -0.04698013f, 
    0.10473431f, 0.17551354f, -0.23857020f, 0.01247132f, 0.08837304f, -0.11642991f, 0.06402993f, -0.17654191f, 
    0.13118891f, 0.01794113f, -0.08665866f, 0.05146983f, -0.02838329f, 0.11814662f, -0.12448650f, -0.09235357f, 
    0.14656806f, -0.04425610f, 0.06741251f, 0.04279407f, -0.16398968f, -0.08823740f, 0.08264727f, -0.05070269f, 
    -0.19048339f, -0.11385093f, -0.04379543f, 0.29569349f, 0.06923842f, 0.07641899f, 0.01859989f, 0.11676677f, 
    -0.05702556f, 0.06438511f, 0.10972646f, 0.12206265f, -0.01487969f, -0.23211989f, -0.33042800f, -0.38040587f, 
    0.06127330f, -0.04284182f, 0.03302386f, 0.26388913f, 0.05201098f, -0.10959186f, -0.06297503f, -0.20639624f, 
    -0.01971549f, 0.16832224f, 0.03550003f, 0.04881503f, -0.02646458f, 0.02828829f, 0.17985104f, 0.04525707f, 
    -0.07009005f, -0.33916786f, -0.09255680f, -0.05302001f, -0.11496805f, 0.17329551f, -0.11595348f, 0.16935964f, 
    0.10001972f, 0.07876562f, 0.07638341f, 0.06082319f, 0.12576796f, -0.07756484f, 0.15086716f, 0.01675713f, 
    -0.26766643f, -0.07686539f, 0.20968930f, -0.09744053f, -0.24424304f, -0.23932123f, -0.16895729f, -0.07000436f, 
    0.02203598f, -0.11263789f, 0.00439010f, 0.05365987f, -0.13702434f, -0.08481338f, -0.03686067f, -0.31801468f, 
    0.08685961f, -0.01765358f, 0.16950753f, 0.17087200f, 0.05044584f, 0.05538389f, -0.02427334f, 0.10164827f, 
    -0.29431850f, 0.07139059f, -0.03386320f, 0.02236760f, -0.09100697f, -0.04567285f, -0.05711855f, 0.06175021f, 
    -0.00763868f, -0.02798721f, -0.09971178f, 0.02927341f, -0.08059904f, 0.11560938f, 0.01378838f, -0.00607342f, 
    0.07124339f, 0.07516038f, 0.08013441f, 0.01669165f, 0.04485242f, -0.03070650f, 0.06658139f, 0.04354483f, 
    0.05204217f, 0.04646469f, 0.06990673f, 0.12423638f, -0.04560600f, 0.01314084f, -0.05181965f, -0.03926205f, 
    0.09282400f, 0.02866084f, -0.01281109f, 0.05013053f, -0.10266828f, -0.15026766f, -0.24122810f, -0.22044620f, 
    0.19812004f, -0.03828011f, -0.05655012f, 0.11798126f, 0.00448146f, 0.07230054f, 0.05359893f, 0.05399756f, 
    -0.25909373f, -0.20846908f, -0.33261493f, -0.14994761f, -0.00432632f, 0.05288621f, 0.03540883f, -0.16494718f, 
    -0.08693476f, -0.06868613f, -0.08716057f, -0.00472490f, 0.31157964f, 0.01654320f, 0.10299593f, 0.03643063f, 
    -0.15205447f, 0.05950297f, -0.02303061f, -0.03292217f, 0.21170230f, 0.01633010f, 0.02915016f, 0.04629236f, 
    0.14396478f, 0.01876070f, 0.11490820f, 0.07540460f, -0.00918276f, 0.02840151f, 0.04259290f, 0.03177698f, 
    0.05913124f, 0.02149967f, 0.02199575f, 0.18594074f, -0.01007623f, -0.23426306f, -0.28557494f, -0.08365530f, 
    0.00779987f, 0.02163804f, 0.06945931f, 0.11749291f, 0.05998241f, 0.05395635f, 0.03000368f, 0.00378617f, 
    -0.19874948f, -0.02536961f, -0.11747141f, -0.09220409f, 0.03493661f, 0.17025124f, 0.01119260f, 0.13642691f, 
    0.12648727f, 0.03934100f, -0.10079436f, -0.05806239f, -0.33072948f, -0.12271903f, -0.01729465f, -0.09447879f, 
    -0.09848443f, 0.02970765f, -0.05905546f, -0.13094461f, -0.05153937f, -0.00163157f, -0.03917305f, 0.00099603f, 
    0.18317933f, -0.18814902f, -0.04981014f, -0.19063795f, -0.09028264f, -0.03252546f, -0.00056857f, -0.15860391f, 
    0.10298412f, 0.05892487f, 0.08172204f, -0.08347685f, -0.02469222f, 0.01666294f, 0.05722010f, -0.01885956f, 
    0.07890962f, -0.00301100f, 0.02583916f, -0.06218057f, -0.01755110f, -0.06114420f, -0.01368570f, -0.05933813f, 
    0.15892494f, -0.39218199f, 0.00926956f, -0.32410526f, 0.02734431f, -0.05292343f, -0.00000349f, -0.08448707f, 
    0.13987523f, 0.03637618f, -0.11108760f, 0.16452198f, -0.15653574f, -0.15004779f, -0.49312469f, -0.05847163f, 
    0.03821331f, -0.16162093f, -0.15797633f, 0.00234489f, 0.16865778f, 0.04985581f, 0.04511872f, -0.08176042f, 
    0.09721805f, 0.21301964f, -0.19578119f, 0.07569104f, -0.02110869f, 0.07372700f, 0.26593891f, 0.05362291f, 
    -0.07250459f, -0.02329626f, 0.01429681f, -0.05553883f, 0.17889518f, 0.13773049f, 0.05135583f, 0.23705237f, 
    -0.05467001f, 0.01740258f, 0.01347428f, -0.15846491f, -0.00776367f, -0.02085574f, -0.04201930f, 0.05389125f, 
    0.12909223f, -0.03464942f, 0.16152693f, 0.10771626f, -0.04773156f, 0.07882947f, -0.00863856f, 0.04132976f, 
    0.14559661f, -0.02363204f, 0.07690523f, 0.23486879f, 0.01832757f, -0.31649521f, 0.18691416f, -0.27019110f, 
    -0.03220055f, -0.06645103f, -0.08933724f, -0.23395178f, 0.24656364f, -0.03637712f, 0.05498054f, 0.02511201f, 
    0.00206160f, 0.10829470f, 0.15000382f, 0.12926561f, 0.02306799f, -0.03184767f, 0.01528420f, -0.01861091f, 
    0.04693645f, 0.03437825f, 0.11529280f, -0.00635182f, 0.26920810f, -0.03766398f, 0.22077931f, -0.09385473f, 
    0.03010213f, 0.17730370f, 0.00276975f, 0.06214409f, 0.17332570f, 0.09467907f, 0.13137591f, -0.01930279f, 
    0.04460632f, -0.01651956f, -0.00649557f, 0.13430060f, 0.11173054f, 0.03836445f, 0.08131037f, 0.04199437f, 
    -0.14326921f, -0.01464841f, -0.04642604f, -0.04768421f, -0.28923902f, 0.22211245f, 0.00630787f, -0.05054181f, 
    0.01437884f, 0.18103129f, -0.03789654f, -0.08123104f, 0.07914332f, 0.01415709f, 0.14006822f, 0.05553531f, 
    0.03094822f, 0.08998427f, 0.07334413f, 0.12244499f, -0.02524211f, -0.03590941f, 0.02597808f, -0.00381581f, 
    0.09219366f, -0.02214159f, -0.05297159f, 0.13632260f, -0.00477483f, -0.00127229f, 0.02802519f, 0.08371948f, 
    0.03326952f, 0.16304693f, -0.11151706f, 0.01909225f, 0.09645832f, -0.11699939f, -0.09795239f, 0.07825188f, 
    -0.04652915f, 0.14285979f, -0.05466378f, -0.09966503f, 0.10597731f, -0.14326915f, 0.20312844f, -0.11341639f, 
    -0.08045758f, 0.05292884f, -0.13925560f, 0.03292945f, 0.05980203f, -0.14644586f, -0.07340822f, 0.07121944f, 
    -0.02722909f, -0.08182266f, -0.06766788f, 0.00434151f, 0.10016504f, 0.00805655f, -0.09085296f, -0.00217946f, 
    0.14893135f, -0.05393482f, -0.04632266f, 0.17489788f, 0.13167074f, -0.05542174f, 0.05927898f, -0.05977364f, 
    0.19435988f, 0.00987917f, -0.04069754f, 0.03805366f, 0.08795115f, 0.09642704f, 0.23930770f, -0.18970840f, 
    0.00305880f, -0.04453308f, -0.10447035f, 0.05911113f, 0.17120992f, 0.04112140f, -0.00336835f, 0.09810430f, 
    0.18110538f, 0.08911911f, 0.08661345f, 0.10320714f, 0.00706327f, -0.07519814f, -0.02567570f, -0.06452735f, 
    -0.00090195f, -0.04765617f, -0.12090232f, -0.02694795f, -0.04304830f, -0.23016523f, -0.25937065f, -0.72452158f, 
    -0.05927917f, -0.07098185f, -0.08592784f, 0.00864133f, 0.13348636f, 0.06747647f, -0.05321293f, 0.02261676f, 
    0.06675538f, 0.06926642f, 0.05888636f, 0.11431582f, -0.00011692f, -0.03385552f, -0.00123251f, -0.13187507f, 
    0.04007960f, 0.04205443f, 0.03121619f, 0.06381293f, -0.04936524f, 0.02897927f, 0.16941410f, 0.08431467f, 
    0.12308117f, 0.02752918f, 0.20085354f, 0.03698028f, -0.07540991f, -0.14289448f, -0.13079642f, -0.00293733f, 
    -0.27938464f, -0.33510986f, -0.30925608f, -0.31915253f, -0.11548651f, -0.05572656f, -0.14511524f, 0.00708494f, 
    -0.04854162f, -0.12800768f, 0.02331929f, -0.05092553f, 0.29114804f, 0.10141519f, 0.19780418f, 0.14184551f, 
    -0.02531852f, -0.09907705f, -0.01277056f, -0.04919337f, 0.02564966f, 0.18573847f, 0.05481100f, -0.04137787f, 
    -0.01717691f, 0.20302883f, 0.20806436f, 0.05288248f, -0.04096287f, 0.09629992f, 0.02761784f, 0.01002417f, 
    -0.09832615f, -0.09203438f, 0.10335211f, -0.19934818f, 0.28749937f, 0.16750440f, 0.02560090f, 0.15138607f, 
    -0.01770435f, -0.06359836f, -0.01710533f, -0.07836693f, 0.01745210f, -0.03001107f, 0.06072957f, 0.07573190f, 
    -0.26463878f, -0.14776933f, -0.02965353f, -0.35304067f, 0.11398342f, 0.04685383f, 0.01387414f, 0.23087092f, 
    0.15874659f, 0.04209865f, 0.08928286f, 0.11010066f, -0.02204131f, 0.17826556f, -0.10454696f, 0.08290968f, 
    0.04339222f, 0.15313224f, 0.15327296f, 0.14030506f, -0.04156226f, 0.03279274f, 0.04638026f, -0.02038094f, 
    0.12776113f, 0.08110759f, 0.01411244f, 0.00412559f, -0.03733249f, 0.01573930f, -0.08782604f, 0.01691235f, 
    -0.01580962f, 0.03330287f, 0.04442345f, 0.06656882f, 0.00615983f, 0.05694522f, -0.08622131f, -0.04654121f, 
    0.13136569f, -0.05561147f, 0.06293393f, -0.30035758f, 0.03481505f, 0.09631639f, -0.13508624f, -0.00210085f, 
    0.34130818f, -0.35281166f, 0.14303237f, 0.03766065f, -0.03657994f, 0.19197591f, -0.11577483f, 0.20474818f, 
    -0.12563729f, -0.08221955f, -0.03950429f, -0.05503803f, 0.49239790f, 0.11057301f, 0.09593216f, -0.19588400f, 
    0.03768266f, 0.11221319f, 0.04733199f, 0.11520723f, -0.12167165f, 0.08441983f, 0.03618160f, -0.07998528f, 
    0.47928101f, -0.00245123f, 0.05469329f, -0.11627042f, 0.01878719f, -0.10600150f, 0.06480622f, -0.01044253f, 
    0.15955614f, 0.30798152f, -0.07926754f, -0.02497645f, -0.42736569f, 0.14010802f, -0.01991420f, -0.12952279f, 
    -0.04906430f, -0.01988487f, -0.17655173f, -0.00330881f, 0.08208454f, -0.10168186f, 0.03312879f, 0.00234014f, 
    -0.25183228f, 0.04041500f, -0.10404857f, 0.06937800f, -0.05289832f, -0.00663416f, -0.05071275f, 0.09794165f, 
    -0.14719623f, -0.04461687f, -0.06311655f, -0.00747375f, 0.33062318f, 0.34046775f, -0.03500495f, -0.03035981f, 
    -0.10355841f, -0.00175608f, 0.07770588f, 0.19984892f, -0.03610793f, 0.04291255f, 0.06297988f, -0.02247631f, 
    -0.05822936f, -0.08474226f, -0.01437298f, 0.22786835f, -0.04944574f, 0.05381400f, 0.07827457f, -0.01843036f, 
    -0.05473896f, -0.30510080f, -0.14578244f, 0.01928785f, 0.46444011f, 0.05246664f, 0.05691504f, -0.00216969f, 
    0.07577085f, 0.00677157f, 0.10823300f, 0.17364372f, 0.01401234f, -0.07234009f, 0.01092086f, 0.00184156f, 
    0.05684686f, 0.11731089f, 0.16702217f, -0.02452221f, 0.00819281f, -0.12290464f, 0.00827213f, -0.07856484f, 
    0.08662632f, 0.03519666f, 0.12720406f, 0.30123436f, 0.18643525f, -0.03192010f, 0.03130059f, -0.13841163f, 
    -0.18212473f, -0.06303759f, -0.04490380f, 0.02306068f, 0.06854101f, -0.03239997f, -0.24247833f, -0.01679779f, 
    -0.10776090f, 0.13153435f, 0.04147962f, 0.01412879f, 0.00248154f, -0.10182548f, 0.09865904f, 0.02482557f, 
    -0.00358307f, -0.02592292f, -0.03620018f, 0.00232458f, 0.23305783f, -0.05344312f, 0.08715831f, 0.27710170f, 
    -0.12779319f, 0.05776227f, 0.04090554f, -0.06260885f, -0.05606294f, -0.05241824f, 0.04678700f, -0.02938816f, 
    -0.38913643f, -0.05164156f, -0.04632569f, -0.28662264f, -0.04513488f, -0.00068863f, 0.09038816f, -0.15181944f, 
    -0.00506426f, -0.00027186f, 0.00793964f, -0.00560040f, 0.18087636f, -0.00630051f, -0.10231090f, -0.09579827f, 
    -0.00047673f, 0.07597063f, 0.04369089f, 0.05776297f, 0.05956254f, -0.11122096f, 0.05255336f, -0.07531654f, 
    0.01397450f, -0.19865201f, -0.07616592f, 0.05443488f, -0.03165217f, 0.09000391f, 0.14514107f, 0.14178644f, 
    0.06160712f, 0.04361198f, -0.00248544f, 0.04124434f, 0.16501318f, 0.34436578f, -0.06573153f, -0.24293338f, 
    0.09222788f, 0.11389285f, -0.11262362f, 0.12017816f, -0.15106227f, -0.01482090f, -0.05500058f, -0.07411908f, 
    -0.46433929f, -0.19402385f, 0.07093277f, -0.25113520f, -0.08256757f, -0.03587937f, 0.03594942f, 0.06486420f, 
    0.03546552f, -0.04693624f, -0.07782441f, 0.05296419f, 0.06958857f, -0.03394315f, 0.13972406f, -0.00201705f, 
    -0.07075268f, 0.06975961f, -0.06647423f, 0.04987991f, -0.01361984f, -0.09562714f, 0.02886062f, -0.04073305f, 
    -0.01691941f, -0.00279884f, 0.03106681f, 0.00742571f, -0.00260752f, 0.03116229f, 0.01341855f, -0.03482292f, 
    0.00394056f, 0.01707732f, 0.00669878f, -0.01703774f, 0.03416507f, 0.01227642f, -0.01731855f, 0.01755548f, 
    -0.01989691f, -0.03236845f, -0.03104467f, -0.01783495f, -0.00497513f, 0.00170892f, -0.01487412f, 0.00278785f, 
    0.01944344f, -0.01853607f, -0.02663376f, -0.01131224f, -0.02878252f, -0.01548715f, 0.01008783f, -0.03834581f, 
    -0.03094828f, 0.00462270f, 0.00317024f, -0.04080736f, -0.02962868f, -0.00285210f, -0.04059717f, 0.00658081f, 
    -0.02541376f, -0.02487120f, 0.00898003f, 0.02686606f, 0.02732054f, 0.00087666f, -0.00835259f, -0.00051306f, 
    0.02761715f, -0.00690717f, 0.02682541f, 0.00244282f, -0.01281244f, -0.02105964f, -0.03142986f, -0.01197832f, 
    0.02090512f, -0.00467006f, 0.01978522f, -0.01216585f, -0.00591868f, -0.00175918f, 0.01308614f, 0.03893846f, 
    0.00179796f, -0.01912828f, -0.00752024f, 0.02566104f, -0.00226598f, 0.01959015f, -0.01302471f, -0.02436452f, 
    -0.01939886f, -0.01073139f, -0.00228589f, -0.03541077f, -0.01031558f, 0.02151595f, -0.00628406f, 0.00874376f, 
    0.02428560f, 0.00823076f, -0.03115304f, 0.02987852f, -0.02191847f, 0.01048723f, -0.03087178f, -0.00630592f, 
    0.00502234f, 0.00884337f, -0.01416953f, -0.03203521f, 0.02143966f, 0.02548798f, 0.03066400f, 0.01833356f, 
    -0.03203057f, -0.01006902f, 0.01620612f, 0.01013498f, 0.01714244f, -0.00501006f, -0.03398522f, -0.02691030f, 
    0.00202463f, -0.01728409f, 0.00292828f, 0.00638116f, -0.03793962f, -0.02974327f, 0.01829623f, -0.00076438f, 
    0.00357746f, 0.00779977f, -0.03007602f, 0.01907282f, 0.02824840f, 0.01576633f, -0.01156809f, -0.01825658f, 
    0.00531998f, 0.01242500f, -0.01651358f, -0.02117020f, 0.01756105f, 0.03793122f, 0.01238553f, 0.00613078f, 
    0.02058833f, -0.00037162f, -0.01050182f, -0.00259395f, -0.01773857f, -0.02925008f, 0.01119994f, -0.02347116f, 
    0.00753656f, 0.02608375f, 0.01904045f, -0.03297057f, -0.02198729f, -0.02583436f, 0.01965538f, 0.02365712f, 
    -0.00525123f, -0.02817808f, 0.00020609f, 0.02580720f, -0.01780717f, -0.01684078f, 0.00297178f, -0.01976230f, 
    -0.01670426f, -0.03000563f, 0.00092779f, -0.02017087f, -0.02944826f, -0.02774603f, -0.01367841f, -0.02030103f, 
    -0.03005148f, 0.00732192f, -0.00102167f, 0.00003843f, -0.01438624f, -0.00743504f, -0.03338836f, 0.02711731f, 
    0.00191055f, -0.01213237f, 0.00831057f, -0.04254677f, 0.00563489f, -0.00395158f, -0.01987704f, -0.02343001f, 
    -0.02556395f, -0.01446955f, -0.02280342f, 0.02043031f, -0.02674788f, 0.04078997f, -0.00387510f, -0.02123480f, 
    0.01168759f, -0.01417868f, -0.02151993f, 0.01907728f, 0.00054921f, -0.02190574f, 0.00474214f, -0.01713588f, 
    0.01368262f, 0.00167418f, -0.03351790f, -0.02821842f, -0.03504954f, 0.01338480f, 0.00660487f, -0.00287090f, 
    -0.03213333f, -0.00641191f, 0.01787662f, 0.00079976f, -0.00603805f, 0.01490394f, 0.00140402f, -0.03652179f, 
    0.02152561f, 0.01352968f, 0.00895196f, -0.03915374f, 0.00691665f, -0.01806147f, -0.01095918f, -0.01353039f, 
    -0.00840895f, -0.03298944f, -0.01573059f, -0.02567755f, -0.01119798f, 0.00416971f, 0.00884475f, -0.00600670f, 
    -0.00783968f, 0.01034492f, -0.02966516f, 0.03229769f, 0.02493611f, -0.04057499f, -0.01991014f, 0.00438175f, 
    0.00133742f, -0.00433792f, -0.01134577f, 0.01872550f, -0.03146068f, -0.03232957f, 0.01710141f, -0.03772029f, 
    0.02847472f, 0.01352772f, -0.01598414f, -0.00416277f, -0.01617458f, -0.00708291f, -0.02422416f, -0.00903701f, 
    0.00854014f, -0.00675797f, -0.02145250f, -0.00387056f, -0.01063994f, -0.03087281f, -0.00506435f, -0.02051742f, 
    0.00352941f, -0.02864462f, -0.02216164f, -0.02022994f, -0.00695610f, -0.03728117f, -0.03797594f, 0.01568370f, 
    0.00281545f, -0.01012224f, -0.03114903f, -0.03783434f, -0.03475685f, 0.01154328f, 0.01976035f, -0.04105291f, 
    -0.02815216f, -0.02815258f, 0.02604746f, 0.00834687f, -0.00279435f, 0.00916087f, 0.02499984f, -0.00797302f, 
    0.01002787f, -0.01408267f, -0.02975174f, -0.01881996f, -0.02947983f, 0.01770487f, -0.01209460f, 0.01078918f, 
    0.00624611f, 0.02747037f, 0.00328814f, -0.02511827f, -0.03436375f, -0.02005156f, 0.02032342f, -0.02669055f, 
    -0.02750731f, -0.03803945f, 0.01518471f, 0.00155294f, -0.03385033f, 0.02651106f, -0.00279334f, -0.00679300f, 
    0.01259589f, 0.03181232f, -0.00989422f, -0.01428679f, -0.03391936f, 0.00173261f, -0.01179514f, 0.02420859f, 
    0.00342561f, 0.01153470f, 0.00673565f, -0.00220154f, -0.02379099f, 0.00708038f, -0.03606131f, 0.01779543f, 
    -0.04054536f, 0.01561916f, 0.02427685f, 0.01785740f, -0.00858916f, 0.02073512f, 0.02977050f, 0.01184923f, 
    0.02794755f, 0.00482100f, -0.02913178f, -0.03257286f, -0.02229786f, -0.01092336f, 0.01469266f, -0.00602811f, 
    0.01215225f, 0.01042216f, -0.03809229f, 0.02639121f, 0.01344642f, -0.02724173f, 0.00943876f, 0.00396740f, 
    0.00860763f, -0.04006455f, -0.02938424f, -0.01575865f, -0.03147771f, -0.01285590f, -0.02157727f, 0.02248572f, 
    -0.00793736f, -0.03011223f, 0.00796687f, -0.00800050f, -0.03030700f, -0.02033690f, -0.01538509f, -0.02710841f, 
    -0.03698519f, 0.01242536f, 0.02246310f, -0.00917091f, 0.02068094f, 0.00040724f, 0.00383411f, 0.00067605f, 
    0.00917336f, 0.02367964f, 0.02315429f, -0.02684711f, -0.03175600f, 0.02167518f, -0.02263595f, -0.01551111f, 
    0.01462291f, -0.02974722f, -0.00389400f, 0.00315736f, 0.01009532f, 0.02226762f, 0.00273255f, -0.03157536f, 
    -0.01235423f, -0.00144792f, 0.02469063f, 0.00572650f, 0.00881164f, 0.01139760f, 0.02299139f, 0.00731185f, 
    0.01544075f, -0.00453713f, -0.01444186f, -0.03887299f, -0.01743270f, 0.00835983f, -0.00738339f, -0.02816410f, 
    -0.00642022f, -0.00555256f, -0.03448988f, 0.02404766f, 0.01098395f, 0.02434063f, -0.04296349f, -0.02387099f, 
    0.01158466f, -0.03793445f, -0.00513389f, 0.01856645f, 0.00412817f, 0.00705440f, -0.01609425f, 0.02830544f, 
    -0.01275811f, -0.01020510f, 0.01793847f, -0.04099542f, -0.02327071f, 0.02680840f, 0.01176619f, 0.00213653f, 
    0.03339238f, -0.00799952f, -0.01528226f, -0.02744051f, -0.02566216f, -0.02880649f, 0.03186668f, -0.01929460f, 
    0.02347640f, -0.03588840f, -0.00696517f, -0.04291206f, -0.00217835f, -0.03902204f, -0.00463582f, -0.02797417f, 
    -0.01614899f, -0.01134407f, -0.02130735f, -0.00155656f, -0.00504855f, 0.02654443f, -0.01590925f, 0.03365181f, 
    0.01490375f, -0.03360353f, 0.02253507f, -0.02652112f, 0.02147319f, -0.03251066f, 0.00524434f, -0.00967613f, 
    0.02510752f, 0.03998599f, -0.02228513f, 0.02468847f, -0.02029501f, 0.00738367f, 0.02552303f, -0.01542161f, 
    -0.03754711f, -0.00630659f, -0.01965578f, -0.01300914f, 0.00994599f, -0.02958824f, -0.02445437f, 0.00304727f, 
    -0.03945803f, -0.00901460f, -0.01839568f, 0.02541338f, 0.00629479f, -0.03411664f, -0.02094085f, 0.01924635f, 
    -0.01605333f, 0.02650777f, 0.01378205f, 0.02424135f, 0.01026446f, 0.00339086f, 0.02231937f, 0.02642600f, 
    0.01429264f, -0.01954665f, -0.02604657f, -0.02517861f, -0.02631224f, -0.00851478f, 0.01520355f, 0.02530069f, 
    0.02577254f, 0.01879332f, 0.01997695f, 0.00710972f, 0.00095009f, 0.00036758f, -0.04000300f, -0.01971026f, 
    -0.00355812f, 0.00892870f, 0.00900123f, -0.01759935f, -0.03777720f, -0.04091636f, -0.00476792f, -0.00555481f, 
    0.01283247f, 0.03636661f, -0.01695080f, 0.02365664f, -0.03848793f, 0.02219969f, -0.03609432f, -0.01049359f, 
    0.01592149f, -0.00139020f, -0.01841201f, -0.02187275f, -0.02559681f, -0.04065853f, -0.03313182f, -0.03469738f, 
    -0.02341677f, 0.02177034f, 0.00072763f, -0.04290718f, 0.01406373f, 0.01100432f, 0.00239947f, -0.02366378f, 
    -0.00314582f, -0.03278147f, -0.02792940f, 0.01113189f, 0.02321072f, -0.01699714f, -0.01739272f, -0.01730883f, 
    -0.01089866f, -0.01450456f, 0.01533630f, 0.01716307f, 0.00022708f, -0.01201796f, -0.00738439f, 0.01894844f, 
    -0.01004864f, 0.02498063f, -0.03012187f, -0.00221478f, 0.02575973f, -0.04251777f, -0.01448417f, 0.00070675f, 
    -0.02657917f, 0.02880504f, -0.02142839f, 0.01196801f, -0.02756939f, -0.03824890f, -0.01997257f, -0.01822513f, 
    -0.01135065f, -0.04331038f, 0.02198445f, -0.00874326f, 0.02744576f, -0.00782755f, -0.01026787f, 0.02598411f, 
    0.01131755f, -0.01000457f, 0.02534715f, 0.00547095f, 0.00345147f, -0.00329060f, -0.01756116f, -0.03963030f, 
    -0.02838070f, 0.01852817f, 0.01895680f, -0.00678407f, 0.00629452f, 0.00075689f, -0.00557159f, -0.02579405f, 
    0.00395826f, -0.00672477f, 0.01093671f, -0.02958368f, -0.00160228f, 0.01035788f, -0.01844946f, 0.01035386f, 
    -0.00461450f, -0.03653913f, -0.00953048f, -0.00535957f, 0.01329293f, 0.00018781f, 0.00502477f, 0.02849073f, 
    -0.03835702f, -0.01990995f, 0.00613796f, -0.00671909f, 0.02646662f, -0.01119298f, -0.03910977f, -0.00607676f, 
    -0.04163281f, 0.01070861f, 0.00328887f, 0.01122357f, -0.02498355f, -0.00582565f, -0.00235671f, 0.00783355f, 
    -0.00462822f, 0.00870358f, -0.02983675f, 0.01522169f, -0.03534006f, 0.00711301f, 0.00961160f, 0.02384641f, 
    -0.03934592f, 0.01687501f, 0.01288682f, -0.03429190f, 0.02269457f, -0.01420443f, 0.02550617f, 0.01318022f, 
    -0.02175300f, 0.01005078f, -0.03411759f, -0.03706682f, 0.00195635f, 0.00757785f, 0.02559080f, -0.03106098f, 
    -0.00538614f, -0.00009518f, -0.00269712f, -0.01578913f, 0.01284620f, -0.00283245f, -0.03511989f, -0.02291269f, 
    -0.02906196f, 0.00582497f, -0.04032109f, -0.03654486f, 0.01492478f, 0.02314466f, -0.00422103f, -0.02608435f, 
    0.02143409f, -0.00008010f, -0.03417367f, 0.03785216f, 0.00155003f, 0.01169547f, 0.02969896f, -0.00162968f, 
    -0.01392248f, -0.00751376f, 0.02645231f, -0.02922774f, 0.00883429f, -0.00817843f, 0.02448759f, 0.00500457f, 
    0.01279586f, 0.01966324f, 0.01141768f, -0.03487037f, -0.04045153f, -0.00892963f, -0.00932111f, -0.01743079f, 
    -0.03239754f, -0.02098142f, 0.02001820f, -0.03148020f, -0.00534863f, 0.01704121f, 0.00638547f, 0.01918898f, 
    -0.01589959f, 0.02610669f, 0.01006629f, -0.02113925f, 0.01416421f, 0.01114067f, -0.01111282f, -0.01027468f, 
    -0.01365532f, -0.03173592f, 0.02242909f, -0.00643409f, 0.03051872f, -0.02173778f, 0.01925713f, -0.03260429f, 
    -0.01270334f, -0.00069259f, -0.03876675f, -0.01666154f, 0.00873073f, 0.03496675f, 0.00151950f, -0.00476981f, 
    0.03580171f, -0.01493280f, -0.00723359f, 0.01139812f, -0.02790430f, 0.01464098f, -0.02653811f, -0.00708769f, 
    0.02291253f, -0.01787628f, 0.02536631f, 0.02455219f, -0.01063037f, -0.02395931f, -0.02630266f, 0.00154167f, 
    -0.02088003f, 0.02243866f, -0.01587137f, -0.00120964f, 0.00515150f, -0.02495530f, -0.00799744f, 0.01363411f, 
    -0.03229493f, 0.00318039f, -0.00774702f, -0.02805962f, -0.02735711f, 0.01053654f, -0.03166930f, 0.02054715f, 
    -0.01735937f, -0.01165452f, -0.02929055f, 0.02150310f, -0.00382941f, -0.03802126f, 0.01714941f, -0.01552176f, 
    -0.02467940f, -0.03725145f, -0.01966272f, -0.02147959f, 0.02718054f, -0.03810788f, 0.01838592f, 0.01376458f, 
    0.10632367f, 0.00848060f, -0.01200072f, -0.22957510f, -0.03439024f, 0.01964742f, 0.01633809f, 0.04739296f, 
    0.01386139f, 0.05303345f, 0.07313016f, 0.06142477f, 0.25426200f, 0.02515066f, -0.07993289f, -0.17775562f, 
    0.06690293f, 0.15623555f, -0.05007697f, 0.06191624f, -0.10593774f, -0.11151168f, -0.06496067f, -0.19992469f, 
    -0.06341543f, 0.01814234f, -0.04878284f, 0.06130895f, 0.03784164f, -0.00930366f, 0.03669626f, 0.11899972f, 
    -0.26834229f, -0.20682608f, -0.27298760f, -0.40112734f, -0.18076615f, -0.06382455f, 0.06632322f, 0.14182791f, 
    -0.10839741f, 0.09380729f, 0.00014789f, 0.14995588f, -0.21293560f, 0.19918850f, 0.00883482f, -0.12396581f, 
    -0.15559438f, -0.01327753f, -0.07334355f, -0.12199083f, 0.21375819f, 0.07331474f, -0.09277956f, -0.00178070f, 
    0.07105955f, -0.06228438f, 0.11615020f, -0.24397327f, 0.38931692f, 0.24684726f, 0.18823479f, -0.14107884f, 
    0.03592296f, 0.06076856f, 0.14687598f, -0.01614033f, 0.01289416f, -0.01110114f, 0.07799077f, 0.16686776f, 
    -0.46946475f, 0.18727759f, 0.07055924f, -0.04177751f, -0.03600519f, -0.22564332f, -0.01174197f, 0.06141603f, 
    0.13709421f, 0.06009529f, -0.10805567f, -0.18766089f, -0.05675735f, 0.14837891f, 0.06153447f, 0.05088408f, 
    -0.01585907f, 0.05393157f, 0.05555804f, 0.10709060f, 0.08485334f, 0.05661816f, 0.20708054f, -0.01733075f, 
    -0.13999507f, -0.09709945f, -0.04399148f, -0.01896763f, -0.03139846f, -0.09859779f, -0.01732763f, -0.06593146f, 
    -0.08847705f, -0.09609716f, -0.05480186f, -0.00698855f, 0.10761664f, 0.05889120f, 0.00995645f, -0.01981022f, 
    -0.06193392f, 0.12048182f, -0.04443466f, 0.06270731f, -0.04547128f, -0.01337215f, 0.08835007f, -0.05412937f, 
    -0.12998120f, -0.10036057f, -0.04565237f, -0.02902889f, -0.04539679f, 0.13996959f, 0.08365767f, 0.14370517f, 
    0.00399665f, -0.02661871f, -0.12980847f, 0.02622554f, 0.11466753f, -0.05300774f, 0.05687160f, -0.05781355f, 
    -0.23949543f, -0.01508908f, 0.11593314f, 0.14056039f, 0.18291135f, -0.15077308f, 0.06745531f, -0.03947649f, 
    0.04756917f, -0.01925572f, -0.04066132f, 0.27624181f, -0.05885763f, 0.05097921f, -0.00747705f, 0.00430552f, 
    0.11094437f, 0.01639655f, 0.08605953f, 0.18660456f, 0.20754947f, 0.14387603f, 0.06938808f, -0.03653431f, 
    0.17087300f, 0.05240987f, -0.02633943f, -0.12302276f, -0.07930436f, -0.08374539f, -0.07550264f, 0.11974236f, 
    0.10090490f, 0.10911346f, 0.07513381f, -0.17001116f, -0.00348144f, 0.03745265f, -0.01931034f, 0.07616184f, 
    0.01196981f, -0.10233655f, 0.07407360f, -0.09741718f, -0.30138505f, -0.17855017f, -0.04785798f, -0.13446395f, 
    0.09088246f, 0.12163061f, 0.14427583f, 0.25829738f, 0.02832662f, -0.10191884f, -0.00164655f, -0.17485191f, 
    -0.06719530f, -0.20626108f, -0.20620216f, -0.20000646f, 0.00263733f, 0.04485361f, -0.00244168f, -0.00766231f, 
    0.10275126f, 0.03060889f, 0.00985713f, -0.01306502f, -0.08651700f, -0.03581322f, -0.04325861f, -0.02612231f, 
    -0.02684213f, 0.04412702f, 0.14483081f, -0.00812380f, 0.10586005f, 0.15291765f, 0.10066009f, 0.21211216f, 
    0.16985305f, 0.15808795f, 0.14503823f, -0.01349037f, -0.00609499f, 0.17837459f, 0.07888851f, 0.08700109f, 
    0.12402243f, -0.07915296f, -0.06427972f, 0.13171142f, 0.26986992f, 0.14260490f, 0.02154723f, -0.02396953f, 
    0.04105040f, 0.17733112f, 0.09300506f, 0.00873752f, 0.02186893f, -0.03949597f, -0.00541593f, -0.18077590f, 
    0.01509083f, -0.08066632f, -0.10576016f, -0.08680837f, -0.03601176f, -0.12036242f, 0.06364379f, 0.04617296f, 
    0.03584478f, 0.08980907f, -0.06054373f, 0.15793052f, -0.18745334f, 0.12924613f, -0.05457195f, 0.08898783f, 
    0.02870002f, 0.01647575f, -0.00400882f, 0.00033844f, -0.01371384f, -0.04070586f, -0.04721117f, 0.02106450f, 
    -0.13268638f, -0.15790866f, -0.09225643f, -0.08316351f, 0.03216515f, -0.06165355f, -0.03408715f, -0.09173927f, 
    -0.33832675f, -0.30750507f, -0.09058649f, -0.23576784f, 0.26819542f, -0.19816025f, -0.22064696f, -0.11740261f, 
    0.14021382f, 0.04615357f, -0.20377679f, 0.27533072f, -0.03221530f, -0.15901689f, -0.06903975f, -0.01734305f, 
    -0.03487808f, 0.18409686f, -0.03984443f, 0.04443505f, -0.00106448f, 0.00638017f, 0.09553189f, -0.01511770f, 
    0.07642867f, 0.01067042f, -0.02223857f, 0.05245982f, -0.01973937f, -0.12930986f, 0.13230164f, -0.22002050f, 
    -0.11122136f, -0.14545794f, 0.02179988f, 0.01167960f, -0.05065817f, 0.16170037f, 0.07126042f, -0.05679874f, 
    -0.09247954f, -0.05636670f, -0.05629405f, -0.19925135f, 0.10038932f, -0.02444375f, 0.01286978f, 0.04993076f, 
    0.04995661f, 0.17733626f, 0.08302668f, 0.07367894f, 0.25275147f, -0.03619966f, 0.03252128f, 0.04451547f, 
    0.05647229f, 0.10224635f, 0.07250873f, 0.09372189f, 0.23700669f, -0.02455617f, 0.02429683f, 0.27679536f, 
    -0.14370619f, -0.09164001f, 0.05707358f, 0.07288183f, 0.06599079f, 0.04098491f, -0.06436346f, -0.01605505f, 
    -0.15404393f, -0.24794559f, -0.09843134f, -0.12891909f, -0.10008138f, -0.19237395f, 0.01829949f, -0.10836289f, 
    0.08386324f, -0.08827771f, -0.05258721f, 0.08880363f, -0.11982822f, 0.20664987f, 0.24709071f, 0.02632313f, 
    -0.17680557f, 0.00471838f, 0.14955345f, -0.23004480f, 0.02625925f, -0.00379592f, 0.08921098f, -0.10252880f, 
    0.14000525f, 0.03131889f, 0.19244379f, 0.14456709f, 0.08481629f, -0.09744956f, 0.07824748f, -0.05448294f, 
    -0.00971297f, 0.00234264f, 0.14866880f, 0.15049087f, 0.12504406f, 0.04602961f, -0.00108013f, 0.09334689f, 
    -0.02232754f, -0.09272146f, -0.07392254f, 0.09125703f, -0.02413999f, 0.06911412f, -0.02804217f, 0.02954182f, 
    0.18902633f, 0.01600317f, 0.15406847f, 0.20535126f, -0.09739718f, 0.00779957f, 0.02772277f, 0.18488787f, 
    -0.18258236f, -0.03695190f, 0.02111137f, 0.12918255f, 0.15933873f, 0.13085426f, 0.07427424f, 0.04876721f, 
    -0.14656186f, -0.01965678f, -0.00077710f, 0.09343865f, -0.12405293f, -0.12122668f, -0.13190961f, -0.08525456f, 
    0.20633402f, 0.13621208f, 0.03070086f, 0.16634317f, 0.11985984f, -0.19397160f, -0.08852091f, -0.15010723f, 
    0.09388706f, 0.11967346f, 0.00694713f, 0.20632921f, 0.01165441f, 0.04097982f, -0.08023698f, 0.01402894f, 
    -0.11498412f, -0.02553051f, -0.12227242f, 0.05357883f, -0.04235767f, 0.01837118f, -0.03951051f, 0.01302680f, 
    0.10700690f, 0.10178124f, 0.04463929f, 0.22338878f, 0.16732316f, 0.26405230f, 0.25505254f, -0.05421675f, 
    0.00434474f, 0.01780144f, 0.05966441f, -0.01279742f, 0.08597733f, -0.13056090f, -0.07195190f, -0.18302256f, 
    -0.07653844f, 0.10393539f, -0.09539811f, -0.07225911f, 0.01795080f, 0.02840999f, 0.05196817f, -0.03666634f, 
    -0.06637938f, -0.06047546f, -0.04180904f, -0.04367227f, -0.28688022f, 0.10639933f, 0.05185476f, -0.04660045f, 
    -0.14292355f, -0.04302669f, -0.03909357f, -0.04764125f, 0.06216950f, 0.01752476f, 0.02237035f, 0.13289878f, 
    -0.06378643f, -0.20626098f, 0.34644026f, -0.15800218f, 0.10437128f, -0.05025589f, 0.00113125f, 0.01368724f, 
    0.15591249f, -0.07993071f, -0.04915002f, -0.11359763f, -0.12688108f, -0.09052510f, -0.30843484f, 0.13590758f, 
    -0.06172054f, 0.15371260f, -0.05177229f, 0.02456469f, 0.04728254f, -0.02664020f, -0.01532080f, -0.02373100f, 
    0.22442028f, 0.20223919f, 0.00255195f, -0.11008655f, -0.03026037f, 0.02301016f, 0.03913160f, 0.04951042f, 
    0.03576460f, -0.00459791f, -0.07200915f, -0.01761263f, -0.07443071f, -0.02541690f, -0.14894401f, 0.10987438f, 
    0.02338667f, -0.13820837f, 0.04833990f, 0.24502613f, 0.02048641f, 0.02833034f, 0.00541715f, -0.05700725f, 
    -0.14812067f, -0.18294804f, -0.20828897f, 0.03503555f, -0.03802680f, 0.09096789f, -0.05552906f, -0.00297496f, 
    0.20598464f, 0.15278514f, 0.03745713f, 0.10909912f, -0.03186755f, -0.10039573f, -0.05872058f, 0.02802309f, 
    0.11875097f, 0.10200814f, 0.04667617f, -0.11518927f, 0.08488060f, -0.04305785f, 0.10340334f, 0.10206181f, 
    0.03430782f, -0.08566736f, 0.11821092f, -0.30068988f, -0.05124051f, 0.16798088f, -0.03620305f, 0.02844057f, 
    0.10032222f, -0.00570514f, 0.12592995f, -0.02655471f, -0.06338355f, -0.04303763f, 0.06381951f, -0.17681485f, 
    0.10807155f, 0.17890152f, -0.05704693f, -0.06201500f, -0.05216105f, 0.11593562f, 0.06158848f, -0.09031540f, 
    0.29038545f, -0.07711946f, 0.11708570f, -0.18855125f, -0.00583342f, 0.11561678f, 0.06792063f, 0.06020521f, 
    0.16982694f, 0.04821741f, -0.06965533f, -0.02585773f, -0.68253368f, -0.05643743f, 0.18336001f, -0.15686493f, 
    0.06406763f, 0.00608288f, 0.03248218f, 0.15607747f, 0.03263808f, 0.07714226f, 0.09095043f, 0.02019962f, 
    -0.26532459f, 0.24808551f, 0.13966355f, 0.19804400f, 0.00977807f, 0.11017000f, 0.01498048f, 0.17514232f, 
    -0.02694814f, 0.02424429f, 0.20135608f, -0.03232974f, 0.23751637f, 0.23722000f, -0.05953936f, -0.12570821f, 
    0.08669142f, -0.09286890f, -0.07260786f, -0.20209640f, 0.01099286f, 0.07400272f, -0.04360908f, 0.11580994f, 
    0.01157760f, 0.05467550f, 0.05069439f, -0.01557218f, 0.01020669f, 0.08063857f, 0.03627629f, 0.07844487f, 
    0.00285494f, -0.08164460f, -0.16508655f, -0.14890392f, 0.01065687f, -0.16205317f, -0.28787753f, -0.04785920f, 
    -0.00098685f, 0.13540342f, 0.07984058f, -0.01109900f, -0.04245826f, -0.02373972f, -0.06782572f, -0.01058139f, 
    0.05911363f, 0.01503753f, 0.12471984f, 0.07642444f, -0.04631169f, 0.09398314f, -0.03956521f, -0.02815754f, 
    0.05562725f, -0.14520931f, 0.31186619f, 0.11665867f, 0.19940123f, 0.03322487f, -0.06493697f, -0.14603758f, 
    0.03925214f, -0.01946586f, -0.04515941f, 0.05960127f, -0.01402659f, -0.09162565f, -0.31697837f, -0.13954979f, 
    -0.27001968f, 0.11168921f, -0.12922582f, 0.00362608f, 0.11513302f, -0.07598937f, 0.09013646f, 0.01982439f, 
    -0.00111440f, -0.10717020f, -0.08068154f, -0.14594486f, 0.00783993f, -0.24821268f, 0.02306899f, 0.20767105f, 
    -0.03161865f, -0.00982386f, 0.09996791f, 0.09328711f, 0.02266527f, -0.06960361f, -0.05401935f, 0.00726746f, 
    0.32454941f, 0.04125020f, 0.03218368f, -0.03507438f, 0.02598237f, 0.08377108f, 0.17343545f, 0.13746995f, 
    0.11153933f, 0.04587781f, -0.03342009f, 0.15467414f, 0.37420139f, -0.13052066f, -0.15173866f, -0.00801654f, 
    0.14358349f, -0.11035257f, 0.08045428f, 0.15094975f, -0.16960011f, 0.02012623f, -0.16083951f, -0.29105049f, 
    0.24346083f, 0.06475586f, 0.01273266f, -0.13557009f, 0.07515080f, 0.03036347f, -0.08208952f, 0.02269813f, 
    0.04475240f, -0.16519976f, -0.12061103f, -0.23634513f, 0.03513272f, -0.05828664f, -0.02907746f, -0.03010630f, 
    -0.06480627f, -0.00627568f, -0.00726566f, 0.20680992f, -0.23011124f, -0.08886572f, -0.06708230f, -0.02162742f, 
    0.07837266f, 0.07471249f, 0.32548204f, 0.03749615f, 0.09499386f, 0.23203674f, 0.01188993f, 0.33623910f, 
    0.03431317f, 0.04384416f, 0.12187096f, 0.09365234f, 0.08830386f, -0.02028730f, -0.08582843f, -0.12790653f, 
    -0.13136096f, -0.04687553f, 0.04519264f, -0.05143351f, 0.03321135f, 0.01095794f, 0.01638165f, 0.03934905f, 
    0.06106659f, 0.00459088f, -0.01779277f, -0.21808909f, -0.04155147f, 0.05112291f, -0.01999691f, 0.04858168f, 
    -0.01178772f, 0.00935707f, 0.07786765f, 0.11205658f, 0.10655145f, 0.03645227f, -0.02217706f, 0.00760703f, 
    0.00950710f, 0.19822641f, 0.00215556f, -0.03774163f, -0.03192106f, 0.01978328f, -0.05794436f, -0.10025361f, 
    -0.14502344f, -0.28322285f, 0.10756600f, 0.00084775f, 0.01678086f, 0.04508801f, -0.08461133f, 0.06710842f, 
    -0.24662009f, -0.12040632f, -0.18292157f, -0.23141895f, -0.02406960f, -0.01028968f, 0.07649241f, -0.02726878f, 
    -0.14237945f, 0.11559033f, -0.00644765f, 0.21831252f, -0.05926476f, 0.12688850f, -0.01870955f, 0.05874421f, 
    0.01103856f, 0.08055747f, -0.14108431f, -0.11623328f, 0.11425939f, 0.02618941f, -0.00343585f, 0.08240631f, 
    0.07610220f, -0.11134472f, 0.08010654f, 0.01903102f, 0.19412485f, 0.30012009f, -0.17038849f, -0.23678391f, 
    0.01372338f, 0.04153679f, 0.11736262f, 0.06297300f, -0.00335631f, 0.02383183f, -0.10538735f, 0.10228079f, 
    -0.03400364f, 0.21371746f, 0.15311286f, -0.07542443f, 0.05801003f, -0.03986968f, -0.15120868f, 0.10732350f, 
    0.08967709f, -0.01029862f, 0.08911503f, -0.13328686f, -0.11001359f, 0.07872761f, 0.13322906f, 0.03744873f, 
    -0.05266168f, -0.04298391f, 0.00189331f, 0.00372430f, 0.06187117f, 0.08417217f, -0.08920582f, 0.13073556f, 
    -0.08104476f, -0.01677808f, -0.02488106f, -0.00967255f, -0.11068314f, -0.08775073f, -0.21019410f, -0.14415319f, 
    -0.21487370f, -0.01482953f, -0.07212476f, 0.01517839f, -0.03701311f, -0.07222138f, -0.21430419f, 0.01811388f, 
    0.03940355f, 0.11607432f, 0.03353309f, 0.14388619f, 0.02208230f, 0.02113517f, -0.05015208f, 0.08869600f, 
    -0.06873915f, -0.12762631f, -0.29632089f, 0.04003390f, 0.12905970f, 0.19896235f, 0.00227576f, -0.00166933f, 
    -0.09084633f, 0.02358405f, -0.05649766f, 0.01883467f, 0.09782089f, -0.04939529f, 0.02063037f, -0.17321050f, 
    -0.10775685f, 0.03015654f, 0.01732440f, 0.06121995f, 0.16767623f, -0.06714626f, 0.02989334f, 0.01079774f, 
    0.06160727f, 0.01137797f, -0.08706162f, -0.13038144f, -0.05213501f, -0.01599965f, -0.00366679f, 0.05387646f, 
    0.03966273f, 0.09669854f, 0.07161549f, 0.03459018f, 0.10059629f, -0.05376993f, 0.00843979f, -0.13497561f, 
    0.03890343f, 0.02129290f, -0.02363306f, -0.15834978f, -0.06907116f, -0.05453626f, 0.00532625f, 0.00119668f, 
    -0.02162674f, -0.16418669f, -0.06577053f, -0.12736514f, 0.12390494f, 0.04549282f, -0.00855719f, 0.04012138f, 
    0.01226501f, -0.05903180f, 0.00266922f, -0.00932631f, 0.00236604f, -0.13648900f, -0.18016407f, 0.03247062f, 
    0.12901767f, 0.14112143f, -0.00562530f, 0.03938663f, 0.01113051f, -0.06199583f, 0.00066485f, -0.08057273f, 
    -0.29654893f, -0.15161994f, -0.23166397f, -0.01170583f, 0.05952736f, 0.08615729f, -0.02411427f, 0.00525632f, 
    0.04037189f, 0.00662604f, -0.00017902f, 0.01524893f, -0.19590257f, -0.04001804f, -0.09318624f, -0.10507238f, 
    -0.03450872f, 0.09860853f, -0.06118055f, -0.20373987f, -0.07450850f, 0.07754669f, -0.05774058f, -0.01159897f, 
    0.08334043f, -0.06809504f, 0.04920770f, -0.07610429f, -0.05974697f, 0.06320027f, 0.08396979f, 0.04748072f, 
    0.21220770f, 0.00081601f, 0.03297253f, 0.05775615f, 0.33229339f, -0.00758139f, 0.29948053f, -0.04515737f, 
    0.03322377f, 0.10889851f, -0.03103106f, 0.04587711f, 0.05258223f, 0.01398688f, -0.06033831f, -0.08584884f, 
    -0.01903922f, -0.23574153f, -0.09900354f, -0.12974149f, 0.03711567f, -0.11105663f, 0.03220788f, -0.08546661f, 
    -0.01008388f, 0.05261427f, 0.03843052f, 0.15643920f, -0.23115869f, 0.30951610f, 0.27215704f, 0.02352210f, 
    -0.06448266f, -0.09716214f, -0.11483527f, -0.18189155f, -0.02778455f, -0.01568493f, -0.04431646f, 0.09787762f, 
    -0.01380991f, 0.06468929f, -0.01961207f, 0.00676807f, -0.01803996f, -0.06694432f, -0.09070669f, -0.04547506f, 
    -0.12047861f, -0.03865981f, 0.01335022f, -0.09471807f, 0.08205923f, -0.17968935f, -0.18301222f, 0.08167616f, 
    0.02852003f, 0.10769947f, 0.15771194f, -0.00292175f, 0.11439351f, 0.02319751f, 0.21133697f, -0.00714428f, 
    -0.04057813f, 0.16288669f, 0.11044671f, 0.04943797f, 0.00921819f, -0.03758431f, -0.05473478f, -0.06624617f, 
    0.00350618f, 0.11108851f, -0.16484858f, 0.16823252f, 0.50875318f, 0.29333094f, -0.13974550f, 0.06124240f, 
    -0.05417187f, -0.11163010f, 0.02891057f, 0.00466896f, -0.01418584f, 0.15397114f, 0.11364546f, -0.10788198f, 
    -0.05773135f, 0.02940524f, 0.06271350f, -0.02135326f, -0.00920936f, -0.06039302f, 0.09921835f, -0.01992224f, 
    -0.04468337f, 0.01446137f, 0.02057745f, 0.13005945f, 0.00719027f, -0.02248437f, 0.04740604f, 0.11783220f, 
    0.12799528f, 0.15903884f, -0.10552022f, -0.02658756f, 0.06540911f, 0.03255872f, -0.01779833f, 0.19464581f, 
    -0.05051140f, -0.00570877f, 0.23920152f, 0.16286688f, 0.00842565f, -0.03220000f, 0.03996632f, -0.12256628f, 
    -0.12882586f, -0.07349280f, -0.02657555f, 0.04350384f, 0.07808070f, -0.14370953f, 0.08782364f, 0.00607569f, 
    0.01618631f, -0.04560136f, 0.03406489f, 0.15447216f, -0.08846176f, 0.21292630f, 0.13170201f, 0.12206542f, 
    -0.28880039f, 0.03494871f, -0.04533318f, -0.08336355f, 0.13052182f, 0.05660439f, 0.40519100f, -0.00630193f, 
    0.09653828f, -0.03893303f, 0.07390620f, 0.24888569f, -0.04036956f, -0.12263496f, -0.11274213f, 0.01136189f, 
    0.21711315f, 0.02348271f, -0.28537738f, 0.12298609f, 0.04079711f, -0.03619735f, -0.08864403f, 0.14021136f, 
    -0.09597810f, -0.10405522f, -0.01818502f, 0.11119827f, 0.04460034f, 0.05488914f, 0.07790697f, -0.06808429f, 
    0.12999578f, -0.06552486f, 0.03062589f, 0.20880778f, 0.16623072f, -0.20271522f, 0.18120117f, 0.18939228f, 
    -0.02649627f, -0.00125398f, -0.00492161f, 0.17953385f, 0.15500747f, 0.12582631f, -0.16344324f, 0.04317952f, 
    -0.18943615f, -0.06125020f, 0.02995574f, -0.01358404f, -0.15835044f, -0.00099717f, -0.07354914f, -0.08496932f, 
    -0.03199732f, -0.00159432f, -0.01453113f, 0.07291146f, 0.01384547f, -0.23937947f, -0.13818869f, 0.16286707f, 
    0.05304715f, 0.19282113f, -0.00340545f, 0.05574715f, -0.03393977f, -0.05221678f, 0.15144734f, -0.04114958f, 
    -0.13153309f, -0.08390904f, -0.00375280f, -0.12353749f, -0.09713255f, -0.03658193f, -0.01231648f, -0.11689668f, 
    0.05996502f, 0.08877814f, 0.04159748f, 0.03988883f, 0.12503241f, 0.10985404f, 0.14147620f, -0.06638693f, 
    0.05049290f, -0.04635176f, -0.00126369f, 0.15383372f, 0.04130968f, -0.09875298f, 0.08945529f, -0.22946626f, 
    0.06225978f, 0.17578302f, 0.13762985f, -0.06915575f, 0.17929125f, 0.11502560f, 0.00988184f, 0.01578650f, 
    -0.01079221f, 0.08068685f, -0.08051331f, 0.01026822f, -0.07022417f, -0.10526671f, -0.00523782f, 0.07792272f, 
    -0.01297971f, -0.03211805f, -0.04737091f, -0.05482537f, 0.16029568f, -0.12433726f, -0.19135436f, 0.02401522f, 
    0.18833938f, 0.07365313f, 0.19467536f, -0.13263097f, 0.06094019f, -0.08200950f, 0.02368686f, -0.06797903f, 
    0.01217937f, 0.02704718f, 0.11201570f, -0.17677543f, -0.12364531f, 0.21896315f, 0.05130071f, 0.02536966f, 
    0.04437610f, -0.03633348f, -0.12736632f, 0.02635122f, -0.03808879f, -0.06715240f, 0.05493240f, 0.11776906f, 
    0.16737448f, 0.09122948f, -0.02446763f, -0.11241245f, 0.01417376f, 0.02309186f, 0.00518320f, -0.04460717f, 
    -0.04489669f, -0.00299479f, -0.05914938f, 0.03026026f, -0.20371106f, -0.16525303f, 0.29781586f, -0.13288632f, 
    0.06022829f, 0.02871135f, -0.00685737f, 0.12579836f, 0.09402058f, 0.14963438f, 0.06123610f, 0.06201803f, 
    -0.08536568f, -0.25397035f, -0.17751089f, -0.15362507f, 0.05846728f, 0.01357253f, -0.06735562f, 0.01727095f, 
    0.03732500f, 0.09004646f, 0.04659245f, 0.02393087f, -0.17853862f, -0.12382746f, -0.24125722f, -0.04913099f, 
    0.13765278f, -0.04816206f, 0.18894365f, -0.18559474f, -0.02832098f, 0.00437580f, -0.04768619f, 0.21059775f, 
    -0.05469347f, 0.17078264f, 0.06571992f, -0.17502123f, -0.04457252f, -0.14132960f, -0.05255889f, 0.06156625f, 
    0.06768362f, -0.02752807f, 0.04680524f, 0.16194786f, -0.01601754f, 0.11279954f, -0.04113358f, -0.00788933f, 
    0.02535146f, -0.00924781f, 0.06256989f, -0.10985337f, 0.00397122f, 0.04703408f, 0.04280145f, -0.01821531f, 
    0.26097643f, 0.10974456f, -0.19346701f, -0.02766220f, -0.08057859f, -0.01305619f, 0.16157655f, -0.10192749f, 
    0.10910701f, 0.12688917f, 0.00599648f, 0.13940831f, -0.18247800f, -0.28390783f, -0.02439609f, -0.15245609f, 
    0.11092225f, 0.17720634f, -0.04247962f, 0.04021902f, -0.06556828f, 0.03147652f, 0.03360454f, 0.02360727f, 
    0.12786886f, 0.06277170f, -0.20768955f, -0.00869215f, 0.08958292f, 0.08278818f, -0.08394011f, 0.14699085f, 
    -0.02775518f, 0.06429348f, 0.05971826f, 0.08824415f, 0.10377602f, -0.26301178f, -0.08924005f, -0.06561229f, 
    0.06400383f, -0.02980215f, 0.00223714f, -0.14067110f, -0.08542319f, -0.13004121f, 0.03713482f, 0.00973300f, 
    0.16127449f, -0.05671572f, -0.02977030f, 0.15704200f, 0.01262095f, 0.04498896f, -0.00299053f, 0.05900115f, 
    -0.17889091f, 0.13815409f, -0.03192125f, -0.23758096f, -0.10093566f, 0.32121146f, -0.22061217f, 0.02148367f, 
    -0.02302314f, -0.00941991f, -0.08399799f, -0.15764214f, -0.05953065f, 0.02403156f, 0.02354882f, 0.00574699f, 
    0.11076102f, 0.02248940f, -0.18016818f, 0.25333560f, 0.01108922f, -0.01245308f, 0.06129137f, -0.04191467f, 
    0.15614298f, -0.04097109f, 0.15418462f, 0.23323317f, 0.16226323f, -0.06265047f, -0.21538545f, -0.03670126f, 
    -0.05273319f, 0.08447769f, 0.03053465f, 0.04964003f, -0.08537070f, 0.01050311f, -0.12180842f, -0.01853688f, 
    -0.19088477f, -0.16200075f, 0.25153112f, -0.05675554f, 0.11119310f, -0.09429839f, -0.12278570f, 0.03617843f, 
    -0.04246712f, 0.01702098f, -0.21595308f, 0.08512791f, -0.15018684f, 0.41634130f, 0.10516171f, -0.14875829f, 
    -0.01375650f, -0.19062005f, 0.08856674f, -0.02320806f, -0.04566665f, -0.03701220f, 0.00730156f, 0.10131004f, 
    0.13325651f, 0.09915002f, -0.12220286f, -0.06520073f, 0.00827280f, 0.01678219f, 0.12871800f, -0.06614395f, 
    0.02133060f, 0.05095312f, -0.03579271f, 0.08856153f, 0.11529478f, 0.09210680f, -0.07564699f, -0.05351578f, 
    -0.03644377f, 0.00486738f, -0.02621534f, 0.09988902f, -0.04950279f, 0.06509621f, 0.08942033f, -0.06503785f, 
    0.06222270f, -0.13176082f, 0.04248503f, -0.11826213f, -0.02889640f, -0.06575228f, 0.04859313f, -0.08578775f, 
    0.05633165f, -0.06722748f, -0.04523921f, -0.12053986f, 0.04000098f, -0.02593123f, -0.25066698f, -0.08284554f, 
    0.02614115f, 0.06243055f, 0.01466220f, 0.01062018f, -0.10795386f, -0.03048233f, -0.01094054f, 0.03228247f, 
    0.13596918f, 0.16560920f, 0.00337069f, -0.05639109f, 0.08833022f, 0.11457957f, -0.06292105f, 0.25545853f, 
    -0.00798618f, 0.04595134f, -0.06600006f, 0.03403717f, -0.04445016f, 0.13418952f, -0.06907054f, -0.21137191f, 
    0.00147446f, -0.08156547f, 0.09397545f, -0.03850482f, -0.01496424f, -0.05358066f, 0.18336156f, 0.11258683f, 
    0.08067250f, 0.15417752f, 0.09120296f, 0.13700861f, 0.13373227f, 0.05197538f, 0.10694256f, 0.11010475f, 
    -0.13285351f, -0.11382822f, -0.05217778f, -0.01294158f, 0.09543233f, 0.27327812f, 0.18702568f, 0.15811288f, 
    0.08773451f, -0.07182032f, -0.01222649f, 0.02017475f, -0.02868334f, 0.11880258f, -0.02037116f, 0.11788857f, 
    -0.28192937f, 0.19777082f, 0.06320738f, 0.05136606f, -0.04366773f, -0.00600933f, -0.04872010f, -0.28459892f, 
    0.16030936f, 0.14015426f, 0.11350501f, 0.46644422f, 0.05696307f, 0.09585643f, -0.24998085f, 0.22536311f, 
    0.10808409f, -0.10732120f, -0.03062104f, -0.16330156f, 0.13505323f, -0.09244283f, -0.04364285f, 0.08681429f, 
    0.02314598f, 0.22748306f, 0.18687336f, -0.05555841f, 0.10002705f, -0.12384893f, -0.05517358f, 0.05340830f, 
    0.14842542f, 0.08404781f, 0.04512721f, 0.11135178f, 0.00333397f, 0.03340141f, -0.11939934f, 0.14800137f, 
    0.03071474f, -0.00845520f, 0.05806168f, 0.13940264f, -0.00566365f, -0.01539626f, -0.08164828f, 0.00203851f, 
    0.16867104f, 0.02740327f, -0.21246278f, 0.03755791f, -0.05771386f, 0.07901683f, -0.02235798f, -0.04068050f, 
    0.16288581f, 0.18924889f, 0.20749883f, -0.03699749f, -0.26419193f, -0.12144434f, 0.02524452f, -0.11527735f, 
    0.00531093f, -0.09868889f, 0.10708106f, -0.05515367f, -0.06049251f, 0.02373391f, -0.19244777f, 0.32602617f, 
    -0.23591524f, -0.22225283f, -0.05066049f, -0.12690753f, -0.03984854f, 0.05836025f, 0.10272898f, 0.06803472f, 
    -0.01701976f, 0.04363458f, 0.06005799f, 0.07767423f, 0.29685828f, 0.15690887f, 0.11560453f, 0.10780311f, 
    0.09761373f, -0.03037839f, -0.05903193f, 0.14671238f, -0.08980884f, -0.04651067f, -0.18044196f, 0.05698502f, 
    0.36377674f, 0.32985556f, 0.15184850f, 0.16518767f, -0.14245825f, -0.06492629f, -0.11376703f, -0.01628091f, 
    0.03108343f, -0.07585967f, 0.03499908f, -0.00036984f, 0.32232720f, 0.07362478f, -0.14671803f, 0.15512075f, 
    -0.05047025f, -0.00926381f, -0.02429844f, -0.10778560f, -0.04173610f, 0.05686617f, -0.13034177f, -0.02008311f, 
    -0.19388287f, 0.03659174f, 0.07005980f, 0.01243658f, -0.07242136f, -0.08319207f, 0.07439340f, 0.00965100f, 
    -0.08648903f, 0.01716543f, -0.06930067f, -0.00515435f, 0.14234482f, 0.03291382f, 0.19856031f, 0.17550680f, 
    -0.08109836f, -0.03309660f, 0.10116350f, 0.21311697f, 0.02757546f, -0.02193057f, 0.05607425f, -0.07374168f, 
    0.22819209f, 0.11271899f, 0.08942170f, 0.23334059f, 0.03713961f, 0.07044632f, -0.01557106f, 0.08359168f, 
    -0.02851177f, -0.04015666f, -0.01287128f, 0.02362593f, 0.16257456f, 0.19659005f, 0.10500181f, 0.00264292f, 
    -0.02770353f, 0.02291141f, 0.02448454f, -0.13306426f, 0.07147591f, 0.19326185f, -0.01365813f, 0.17750733f, 
    0.37714976f, 0.23637818f, 0.27311206f, 0.19303890f, -0.00519873f, 0.04301585f, 0.02363760f, -0.05893803f, 
    -0.11570320f, -0.03034378f, 0.05816828f, 0.08564670f, -0.00226544f, -0.09249306f, 0.01568951f, -0.05040254f, 
    0.02387035f, 0.00253960f, 0.06121441f, -0.04334961f, 0.05258322f, 0.09227892f, 0.01425629f, -0.12742575f, 
    0.33533624f, 0.03623069f, 0.03389439f, 0.25595129f, -0.00831128f, 0.01003156f, 0.03351680f, -0.08755095f, 
    -0.08881354f, -0.17242777f, 0.11726820f, -0.02311876f, 0.22988912f, 0.12577149f, 0.19107735f, 0.13976865f, 
    0.19309606f, -0.01450095f, 0.03184650f, -0.03185372f, 0.01065596f, 0.04600358f, -0.01519599f, -0.00657844f, 
    0.25371206f, 0.07206041f, 0.03805417f, 0.14515007f, -0.17488959f, 0.19797945f, 0.04921379f, 0.08729647f, 
    0.07610944f, 0.08767375f, -0.03170612f, -0.10588629f, -0.31441376f, -0.21624576f, -0.23541631f, -0.02954768f, 
    -0.05816390f, 0.02527593f, 0.02326322f, 0.16354990f, 0.01677916f, 0.00597762f, 0.07534805f, -0.08694290f, 
    -0.12161243f, -0.21474874f, -0.03626989f, -0.08267462f, -0.03583234f, -0.01162742f, -0.05572902f, -0.00675761f, 
    -0.03892670f, 0.03804646f, 0.00989155f, 0.21983764f, 0.07009773f, -0.01668217f, 0.31276745f, 0.18752973f, 
    0.12387967f, -0.05810012f, -0.09544703f, -0.07934142f, 0.02857311f, 0.16179292f, 0.05676587f, 0.16824712f, 
    -0.48852736f, -0.33776242f, 0.05257379f, -0.13358559f, 0.06625242f, -0.07662868f, -0.04918314f, -0.23198789f, 
    -0.02520880f, 0.00135740f, 0.00396005f, 0.11583200f, 0.08172464f, -0.32678315f, 0.18744738f, -0.29666531f, 
    0.09547538f, 0.03291604f, -0.18559249f, -0.07980802f, 0.13124597f, -0.03488240f, -0.08084624f, 0.19485378f, 
    -0.06712848f, -0.08063721f, -0.12893301f, 0.07059068f, -0.07940333f, 0.09345205f, 0.19187370f, 0.01656467f, 
    -0.03996936f, 0.04730868f, -0.07434675f, -0.01509270f, -0.45356333f, 0.10595620f, 0.18092722f, -0.02594029f, 
    0.08154240f, -0.00353443f, -0.07624446f, -0.11376538f, -0.02536100f, -0.08314892f, 0.09263078f, -0.16662063f, 
    -0.48516726f, -0.13989535f, -0.28117752f, -0.23827414f, 0.09278481f, -0.09321344f, -0.04982350f, -0.00203945f, 
    0.07679295f, 0.02881170f, -0.01628279f, 0.05034110f, 0.09571275f, 0.20386590f, -0.01712683f, -0.00314290f, 
    0.08941187f, 0.24745485f, 0.00494652f, -0.00703470f, 0.02115456f, -0.28046498f, -0.10111366f, 0.00812294f, 
    0.14837243f, 0.01151505f, 0.09162965f, -0.04023569f, -0.09082214f, 0.14555588f, -0.12675154f, 0.07046286f, 
    -0.14363441f, -0.18817808f, 0.10437542f, -0.28688496f, 0.40073290f, -0.07049904f, -0.07636400f, 0.29431888f, 
    -0.05140723f, -0.08776855f, -0.08726510f, 0.15304932f, -0.02892224f, -0.05251906f, 0.02088961f, -0.13732107f, 
    0.22957548f, -0.06959309f, -0.17042236f, 0.08173730f, 0.09058798f, 0.01430051f, 0.07761703f, -0.08882634f, 
    -0.03842636f, 0.09928904f, 0.08212411f, -0.36780640f, 0.20206161f, 0.05783393f, 0.03792143f, -0.48069108f, 
    0.19050330f, 0.02091333f, -0.00925194f, -0.11263690f, -0.12862155f, -0.17646912f, -0.12559919f, 0.19977616f, 
    0.20042729f, -0.17194495f, -0.15116957f, -0.14431150f, 0.16559416f, 0.09998493f, 0.15957624f, 0.06506015f, 
    -0.06570841f, -0.02151713f, 0.16908152f, -0.17472981f, 0.16763198f, 0.35474303f, 0.12904939f, 0.06808193f, 
    0.02960095f, 0.05002677f, 0.00070483f, 0.05610265f, 0.02038809f, -0.01341553f, -0.02772357f, -0.06715568f, 
    -0.02054587f, -0.10938211f, -0.22543852f, -0.01861331f, 0.07761994f, -0.02277580f, 0.25178936f, -0.09692898f, 
    -0.04773989f, 0.02077081f, -0.04583002f, -0.00927501f, -0.06915955f, 0.11513836f, -0.13204108f, 0.10127524f, 
    0.00856959f, -0.03088316f, 0.05018203f, -0.08789639f, -0.12696679f, -0.03504226f, 0.10383873f, 0.16051629f, 
    0.36025825f, 0.36036572f, 0.27362174f, 0.27029175f, -0.11820365f, 0.13484548f, 0.05052206f, -0.05844457f, 
    0.10983918f, 0.06743566f, -0.04072254f, -0.01420948f, 0.36861518f, -0.30143112f, -0.18852098f, -0.05268080f, 
    0.08090561f, 0.02976377f, 0.07730869f, -0.11010007f, -0.19519772f, 0.12240691f, 0.20041949f, -0.09905928f, 
    -0.05495770f, 0.02817490f, -0.24014872f, 0.14135014f, 0.06957259f, 0.03535150f, -0.08379593f, -0.04107388f, 
    -0.11813266f, 0.06863929f, -0.02601960f, 0.11878626f, -0.28976423f, -0.17713352f, -0.07436624f, 0.14238025f, 
    0.08792819f, -0.07557125f, 0.04253331f, -0.04353396f, -0.03287098f, -0.05834024f, 0.04481692f, -0.02441081f, 
    0.22040848f, 0.05486865f, 0.04297592f, 0.16762121f, -0.00534295f, 0.05563934f, -0.04904845f, 0.07136827f, 
    0.02709603f, -0.08795992f, 0.03340692f, 0.04138936f, -0.21900666f, 0.05343148f, -0.09965138f, 0.16843510f, 
    -0.01508247f, 0.04646358f, -0.03690280f, -0.46930322f, 0.00756122f, 0.00332943f, -0.17053723f, 0.10490624f, 
    0.22021957f, 0.16737382f, 0.25187555f, 0.06892082f, 0.00587237f, -0.12707268f, 0.11610613f, 0.02253547f, 
    -0.08246552f, -0.02679474f, -0.10584158f, -0.05110718f, 0.13412343f, 0.03685379f, 0.04145950f, -0.08877178f, 
    -0.05600882f, 0.05309656f, 0.00858223f, 0.02966363f, -0.02239567f, 0.12121781f, -0.02901804f, -0.07013205f, 
    -0.17502554f, 0.04392232f, 0.09159590f, 0.01830922f, 0.01565992f, -0.16762541f, -0.03814515f, 0.09795921f, 
    -0.03859319f, 0.02020743f, 0.00481141f, -0.02725060f, 0.08338501f, -0.10861422f, -0.12962674f, -0.15778749f, 
    -0.04598272f, -0.09997271f, 0.02583188f, 0.14035006f, -0.08579410f, 0.00290099f, -0.10455664f, 0.01140221f, 
    0.13509709f, -0.13741282f, 0.09255885f, -0.07858988f, -0.18774201f, -0.00760060f, -0.17612401f, 0.00789309f, 
    -0.20159104f, -0.04381942f, -0.11905307f, -0.11600351f, 0.25771037f, 0.58271432f, -0.07602686f, 0.13507383f, 
    -0.01436676f, 0.02510407f, 0.07071119f, 0.03369675f, 0.07349557f, 0.01555898f, -0.02034037f, 0.13100427f, 
    0.12952121f, 0.09203962f, -0.11324900f, 0.04206289f, -0.04339082f, -0.16212314f, 0.14391886f, 0.01868401f, 
    0.08879057f, 0.03310250f, -0.13891146f, -0.08940150f, 0.08552669f, 0.23079723f, 0.07421052f, 0.05100422f, 
    -0.09019834f, 0.02323945f, 0.07028844f, 0.28820959f, -0.01053748f, 0.00050913f, 0.05770813f, -0.13875170f, 
    -0.00578657f, -0.10935521f, 0.06277543f, 0.20347336f, 0.02186243f, -0.01723200f, -0.14181632f, -0.07451531f, 
    0.17124359f, 0.00537815f, 0.08642813f, 0.20348762f, 0.11900678f, -0.10388496f, -0.05853121f, -0.06997677f, 
    0.02602439f, -0.03218499f, 0.12464276f, 0.07492803f, -0.04314287f, 0.00251459f, -0.01805823f, 0.02866538f, 
    -0.03237863f, -0.12571578f, -0.04715921f, -0.22331689f, 0.04552001f, -0.14753887f, -0.20378327f, 0.03509909f, 
    -0.07335754f, -0.03775351f, -0.22460043f, -0.03873992f, -0.10349353f, -0.05106524f, 0.12573941f, 0.02141814f, 
    -0.00670297f, -0.15442687f, -0.03187926f, 0.04332049f, 0.11907806f, 0.00865125f, 0.06913415f, 0.17763442f, 
    -0.27348816f, 0.09829649f, -0.10199142f, -0.09064414f, 0.08736324f, -0.03659117f, 0.02778589f, -0.16947830f, 
    0.05484917f, 0.06082296f, 0.02517013f, -0.03427221f, -0.15679990f, -0.37833083f, 0.05127656f, -0.08460058f, 
    0.10563647f, 0.05394307f, 0.06961527f, 0.02805734f, -0.06630799f, -0.01936197f, -0.01816317f, 0.07689562f, 
    -0.02902302f, 0.22306389f, 0.20415066f, 0.02506180f, 0.00192121f, -0.08653169f, 0.09281993f, -0.04233401f, 
    -0.17207585f, -0.08339530f, 0.10068183f, -0.17325599f, -0.05680799f, -0.06501569f, -0.00322018f, 0.00627732f, 
    -0.05347357f, -0.10505540f, 0.00256604f, 0.14930278f, 0.15183231f, 0.02281571f, -0.05987584f, 0.18626373f, 
    0.17156835f, 0.10964292f, 0.13973971f, 0.09553219f, 0.02481071f, -0.01097943f, 0.04514438f, 0.04913982f, 
    -0.21138623f, -0.03051360f, -0.08509492f, 0.16389616f, 0.11091482f, 0.20990914f, 0.20127247f, 0.29826841f, 
    -0.17213388f, 0.01767223f, 0.02212157f, 0.01494483f, 0.12553619f, 0.12908892f, 0.02283238f, 0.00287260f, 
    0.10714512f, 0.11815733f, 0.01321326f, -0.03200292f, -0.06007685f, -0.01259182f, 0.00806214f, 0.07177605f, 
    0.13653609f, -0.00820170f, -0.10786448f, -0.14482728f, -0.05669490f, -0.11964569f, 0.09612677f, -0.00287322f, 
    -0.00831279f, 0.09198238f, -0.05616310f, 0.08422831f, 0.03539380f, -0.01012074f, 0.09242105f, -0.14128225f, 
    -0.09551577f, -0.13138761f, -0.10869280f, -0.00442063f, -0.06886597f, -0.05593435f, 0.03694765f, 0.06818599f, 
    -0.03727067f, 0.08486681f, 0.10819883f, 0.17341116f, 0.07058520f, 0.25687751f, 0.21411313f, 0.11135338f, 
    0.01419108f, -0.00844186f, 0.06350734f, -0.04314645f, -0.08815771f, -0.04798161f, -0.18042311f, -0.22373889f, 
    -0.05030758f, -0.04982704f, 0.17171578f, 0.07846152f, -0.04179454f, -0.04383755f, 0.07514351f, -0.00389466f, 
    -0.18547350f, -0.00364768f, -0.31499001f, -0.22699410f, 0.14978290f, -0.31883860f, 0.31132534f, -0.18704528f, 
    0.11829155f, -0.09827729f, 0.01459107f, 0.15482165f, -0.18979464f, 0.08963989f, 0.01643065f, 0.08702000f, 
    -0.18091217f, 0.05757764f, -0.20989846f, -0.09682543f, 0.01120502f, -0.07475299f, -0.00952059f, -0.02872699f, 
    0.09563053f, -0.20682621f, -0.02095141f, -0.13750692f, -0.31319270f, -0.08888956f, -0.34389114f, 0.08154608f, 
    -0.16506346f, 0.02510779f, -0.02906414f, 0.09864214f, -0.00106746f, 0.14180040f, -0.08680667f, 0.13256429f, 
    0.38800606f, 0.11021827f, 0.04495016f, -0.00562990f, -0.02101664f, -0.15574151f, -0.09775520f, -0.04186394f, 
    -0.02461434f, 0.13370326f, -0.06596708f, -0.13204703f, -0.05279472f, 0.08079498f, 0.09157158f, 0.07725570f, 
    -0.02571481f, -0.02251645f, 0.03779811f, -0.05282791f, 0.01909418f, 0.17620459f, -0.05327914f, 0.10712597f, 
    -0.16183455f, -0.01176012f, -0.02754839f, -0.17669228f, -0.17424989f, -0.15791324f, -0.18964311f, -0.18799017f, 
    -0.20689622f, -0.13905148f, -0.16113070f, -0.16894704f, -0.10459345f, 0.06000451f, 0.10347986f, 0.23359114f, 
    0.01808096f, 0.01599163f, 0.09891189f, 0.22019675f, -0.06972606f, 0.07743590f, -0.04301374f, 0.09442056f, 
    0.06860729f, -0.14472267f, -0.04228260f, 0.26568517f, -0.17708310f, -0.02314634f, -0.03631480f, 0.04957628f, 
    -0.17339188f, 0.10676011f, 0.01029517f, 0.07756444f, 0.07345874f, -0.09106438f, -0.17702413f, 0.12515654f, 
    -0.07341796f, -0.06097258f, -0.02350146f, 0.05809880f, 0.12235541f, -0.13035576f, -0.06883665f, -0.03208818f, 
    -0.09459061f, 0.27747524f, -0.26383340f, -0.03768209f, -0.07130038f, -0.01335894f, 0.06006288f, 0.01058394f, 
    -0.02266669f, -0.04338464f, -0.02174674f, 0.09222443f, -0.16886126f, -0.06992185f, 0.11013471f, 0.04331500f, 
    -0.05965589f, -0.00911893f, -0.03335890f, 0.00437494f, 0.03224524f, -0.02003314f, 0.03957585f, -0.06439532f, 
    -0.18543507f, -0.22549404f, 0.13482751f, 0.02616403f, 0.19058444f, 0.15658776f, 0.00248968f, 0.07545918f, 
    0.00345345f, 0.05129578f, 0.08651501f, 0.04100297f, 0.00695742f, 0.02207065f, -0.14321925f, 0.02222415f, 
    0.02630971f, -0.02468500f, -0.07291585f, -0.00075965f, 0.10694028f, -0.00652935f, 0.00891022f, 0.01063377f, 
    -0.17110990f, 0.05185103f, -0.08193815f, -0.03898557f, 0.13880293f, 0.03218171f, 0.02924792f, 0.00663944f, 
    -0.04719766f, 0.06577161f, 0.09082113f, 0.04907227f, -0.10015146f, -0.09569465f, -0.11487373f, -0.11015507f, 
    -0.05615366f, 0.18615440f, -0.06380372f, -0.02580431f, -0.11890997f, 0.00806727f, 0.08175929f, 0.03966343f, 
    -0.05439097f, -0.01058727f, 0.13327676f, 0.13154303f, -0.05439135f, 0.22082908f, -0.07529257f, 0.09048530f, 
    0.14244455f, 0.07899047f, 0.14929764f, 0.03501267f, 0.19768849f, 0.10012931f, 0.35799643f, 0.14045146f, 
    -0.03759069f, 0.10224564f, -0.04225574f, -0.01392727f, -0.01436242f, 0.11359318f, -0.01186842f, -0.12124897f, 
    -0.07910801f, -0.48067984f, 0.08526479f, 0.01600984f, 0.01559381f, -0.04281182f, -0.15651521f, -0.01031549f, 
    -0.00891743f, 0.06738111f, 0.07049201f, 0.22248647f, -0.28007969f, 0.21397522f, 0.03535021f, -0.20219065f, 
    -0.21036087f, -0.16607372f, -0.11250599f, -0.12127882f, -0.03852480f, -0.02736278f, -0.02394560f, 0.00572355f, 
    0.00825112f, 0.07852583f, -0.04359619f, -0.09324491f, -0.05663276f, -0.07683521f, -0.11632799f, -0.17840157f, 
    -0.15979707f, -0.02969316f, -0.08885140f, -0.13310136f, -0.08122320f, -0.03228095f, -0.04267874f, 0.19733050f, 
    -0.04667228f, -0.00435285f, -0.01384277f, 0.08154548f, 0.16590688f, 0.00248160f, 0.03556623f, -0.03788934f, 
    -0.13185532f, 0.28373644f, 0.14140652f, -0.07601813f, -0.08493876f, -0.07823605f, -0.06092142f, -0.04245784f, 
    0.02369008f, 0.09399835f, -0.02098905f, 0.16062754f, 0.34562427f, 0.09405456f, 0.10969531f, -0.00983907f, 
    -0.09391634f, -0.09597998f, -0.07415364f, -0.10793623f, 0.04639414f, -0.02588659f, 0.01253081f, 0.04540933f, 
    0.00923913f, -0.01768809f, -0.01946520f, 0.00213949f, -0.14239156f, -0.07168665f, 0.09772415f, 0.02539151f, 
    0.02344549f, 0.02001233f, 0.04794408f, 0.18838149f, -0.21655969f, -0.00683022f, 0.10204415f, 0.18083675f, 
    0.09739950f, 0.19286855f, 0.03037763f, -0.08762767f, 0.06747699f, -0.07140724f, 0.13243762f, 0.02348643f, 
    0.07754325f, 0.09767668f, 0.21117511f, -0.01241590f, -0.00768769f, -0.08993392f, -0.15532902f, -0.09286413f, 
    -0.17308408f, -0.04784282f, -0.05937778f, -0.05549099f, 0.05702658f, 0.12922291f, 0.02527924f, 0.04119755f, 
    -0.01922782f, -0.07505637f, 0.12027168f, 0.07861574f, -0.12375773f, 0.00268269f, 0.20515078f, 0.09818461f, 
    -0.02725335f, -0.14897631f, 0.22362503f, -0.10349074f, 0.05720629f, 0.05980262f, 0.14450596f, 0.03473020f, 
    0.05844468f, 0.07373201f, 0.25986627f, -0.01217876f, 0.17382003f, -0.51649660f, 0.35298884f, 0.16567169f, 
    0.11955040f, -0.05732404f, -0.08413337f, 0.24953221f, -0.13000333f, 0.15882218f, 0.09706361f, 0.08617792f, 
    0.04875850f, -0.11687968f, 0.14037132f, 0.09881102f, 0.02492947f, 0.03516900f, 0.10699781f, -0.04489981f, 
    0.23935772f, 0.09870853f, 0.01535550f, 0.08851054f, 0.26595113f, 0.07084531f, 0.30651495f, -0.02000416f, 
    -0.04108341f, 0.02739133f, 0.00931268f, 0.06287555f, 0.00450021f, 0.10282771f, -0.09515031f, 0.03287753f, 
    -0.27001408f, -0.08343886f, 0.05063876f, -0.14740756f, -0.27156010f, -0.03055386f, -0.05448237f, -0.02709144f, 
    -0.08787232f, 0.12340311f, 0.10559977f, -0.07069309f, 0.03542251f, 0.02771594f, 0.11262820f, 0.21450937f, 
    -0.01364825f, 0.05101814f, 0.00636693f, 0.03521236f, -0.01076443f, -0.02902292f, 0.01631621f, 0.02728638f, 
    -0.15699755f, -0.07314165f, -0.06018162f, -0.04577946f, -0.06944411f, -0.07626053f, 0.06054718f, -0.03811992f, 
    0.08317650f, 0.07501428f, 0.14412512f, 0.08082975f, -0.13639160f, 0.00702194f, -0.17462264f, 0.10264196f, 
    0.02363018f, 0.11679220f, 0.00065021f, 0.07794791f, 0.03374359f, 0.05772665f, 0.04022808f, -0.27741054f, 
    0.01329688f, 0.24048370f, 0.09726788f, 0.35383523f, 0.02498661f, 0.01253278f, 0.05043508f, -0.03212425f, 
    0.02616563f, 0.02890966f, -0.07054546f, -0.13090672f, -0.00757362f, 0.00729661f, 0.04222004f, 0.16499437f, 
    -0.06606524f, -0.06364775f, -0.08412144f, -0.12570010f, -0.06561800f, -0.00175504f, -0.09551650f, -0.01399763f, 
    0.17974190f, 0.14012088f, -0.00738826f, -0.15444845f, 0.06878303f, -0.03657438f, 0.00609410f, 0.02519226f, 
    0.12655896f, 0.02707813f, -0.07053740f, -0.18246901f, -0.00438207f, 0.14212275f, 0.17975987f, 0.01730976f, 
    -0.00630535f, -0.12730640f, -0.01934065f, -0.01721488f, -0.01446361f, -0.08487872f, 0.10836510f, 0.03890966f, 
    -0.00568256f, -0.14446816f, 0.14869750f, 0.16061865f, -0.11273514f, -0.10586838f, -0.07240637f, -0.07830022f, 
    0.01915439f, 0.07421178f, -0.08072627f, -0.02940463f, -0.32403237f, -0.20639302f, 0.52129292f, -0.11682638f, 
    0.05607049f, -0.20857200f, -0.07112852f, -0.01607770f, 0.04668100f, 0.01334732f, -0.12063483f, 0.03043608f, 
    -0.12079134f, -0.01828538f, -0.07366429f, -0.14550918f, -0.00776281f, 0.01541738f, -0.00933170f, -0.09477317f, 
    -0.07501777f, 0.20094781f, 0.01832593f, 0.14058843f, -0.11863004f, -0.21254845f, -0.15518144f, -0.09881589f, 
    0.01826525f, -0.00499059f, 0.11803877f, -0.04032686f, -0.04977049f, 0.09963932f, -0.06424507f, 0.12284989f, 
    -0.52132297f, 0.29743075f, 0.11942390f, -0.07753621f, 0.09836992f, -0.02013222f, 0.05052298f, -0.01029207f, 
    0.07365067f, -0.04160186f, 0.07323277f, 0.19553231f, -0.07834171f, 0.36603248f, -0.07372401f, 0.03271392f, 
    -0.01711656f, 0.03471179f, -0.12606318f, 0.00714637f, -0.02058574f, 0.01477278f, -0.04243464f, 0.12669574f, 
    0.41973495f, -0.07485858f, 0.26641271f, 0.02624263f, -0.04279178f, 0.08005504f, 0.00005526f, 0.18211414f, 
    -0.01799544f, 0.09940740f, 0.06283089f, 0.17959544f, 0.10907634f, 0.25729418f, -0.20067652f, -0.02176388f, 
    0.08338696f, -0.03492652f, -0.00889574f, 0.03097119f, -0.17584755f, 0.08569767f, 0.00482404f, 0.16938135f, 
    0.31298441f, 0.07026656f, -0.04340409f, 0.03698846f, 0.09361745f, -0.04777379f, 0.07071047f, -0.04960543f, 
    -0.16417573f, 0.17010663f, -0.07914036f, 0.07730954f, -0.18867067f, -0.23939346f, -0.11683019f, 0.14813422f, 
    0.06942865f, 0.01142241f, -0.07426282f, -0.03763976f, 0.02222067f, -0.04993640f, 0.05409077f, 0.06813433f, 
    0.20525433f, -0.18089727f, 0.08987056f, 0.13690564f, 0.00535073f, -0.03697835f, -0.00168251f, 0.02266841f, 
    -0.09121072f, 0.03773692f, -0.16287549f, -0.21025027f, -0.13091446f, 0.08121340f, -0.30026919f, 0.05423980f, 
    -0.10175695f, -0.02522162f, -0.08050796f, 0.00489822f, 0.00603774f, -0.03066749f, 0.04504927f, 0.05405140f, 
    0.14899358f, -0.11517246f, 0.13203976f, 0.17790608f, -0.00626396f, 0.02999072f, -0.08172675f, -0.01519510f, 
    0.16277042f, -0.04364415f, 0.00396189f, 0.13101906f, 0.02644817f, 0.10522632f, 0.09197495f, 0.07402143f, 
    -0.06612892f, -0.01116939f, -0.07906009f, 0.15944609f, -0.03461066f, -0.11229578f, -0.10998432f, -0.12363786f, 
    -0.05381304f, -0.11744282f, 0.21658823f, -0.13655676f, -0.02632561f, -0.04441435f, -0.01080548f, 0.07742133f, 
    -0.20430003f, 0.02846846f, -0.16110837f, -0.02575408f, 0.13593647f, 0.22693035f, 0.02021017f, -0.36684686f, 
    -0.05030143f, -0.13542025f, -0.00609090f, -0.01660042f, 0.03636479f, 0.05362071f, 0.00839021f, 0.01744403f, 
    0.11678129f, 0.08331878f, -0.07634227f, 0.14634819f, -0.09104411f, 0.04175632f, 0.13929199f, 0.15773474f, 
    0.06140524f, 0.03914262f, 0.01784665f, -0.01207524f, 0.00323796f, 0.10623348f, 0.05821617f, 0.04738101f, 
    0.00886888f, 0.04256967f, -0.12145045f, 0.10586501f, -0.00238222f, 0.05562715f, 0.00774148f, -0.27748895f, 
    -0.14358743f, 0.03434176f, 0.14966486f, -0.00783999f, 0.00061846f, -0.07863938f, 0.07287795f, -0.03301934f, 
    0.05245375f, 0.08123955f, -0.07526687f, -0.13237295f, -0.17261046f, -0.33002076f, -0.01625545f, 0.09325325f, 
    -0.22588967f, 0.09213608f, 0.04461081f, 0.01512931f, -0.15879245f, -0.01192059f, -0.04915948f, 0.00883824f, 
    0.13528974f, -0.10754403f, 0.13877566f, -0.03753808f, 0.08896598f, 0.16414526f, -0.08693031f, 0.20606996f, 
    -0.01832498f, 0.08367939f, 0.08687317f, -0.00752907f, -0.19862282f, 0.16517210f, -0.16752587f, -0.26550639f, 
    -0.05204134f, -0.22359057f, 0.09813411f, -0.00019558f, 0.01423454f, 0.00794979f, 0.11667167f, 0.10113708f, 
    0.02200646f, -0.03963314f, 0.01979029f, 0.01525008f, 0.01056358f, 0.00550643f, 0.00191516f, 0.01831734f, 
    -0.00252400f, 0.00248696f, 0.02214614f, -0.00200262f, -0.01256874f, 0.02124172f, 0.02887191f, -0.02950557f, 
    0.00336104f, -0.02347092f, -0.02585096f, -0.01662928f, -0.03784031f, 0.01221017f, 0.00737311f, -0.03829147f, 
    -0.00396163f, -0.01421876f, 0.00549440f, 0.02312290f, 0.02145072f, -0.01081515f, -0.00140958f, -0.02079923f, 
    0.02627838f, -0.02880806f, 0.02750403f, 0.00608057f, -0.00526730f, -0.03954441f, 0.01241095f, 0.00173718f, 
    -0.01592442f, 0.01631868f, -0.03772176f, -0.01392827f, 0.01337237f, 0.02196544f, 0.00043392f, -0.04130286f, 
    0.00250258f, 0.01997370f, -0.01550846f, 0.00912735f, 0.01988292f, -0.00430410f, -0.01106854f, 0.02556722f, 
    0.00747033f, -0.03615762f, -0.04052588f, -0.00258382f, 0.01169264f, -0.01610554f, -0.00575415f, -0.01370749f, 
    -0.04055499f, 0.02362416f, 0.02101127f, 0.02139779f, 0.00686256f, 0.00721650f, 0.02189836f, -0.01618678f, 
    0.01499176f, -0.01888576f, 0.01476386f, 0.00090577f, 0.02419249f, 0.00097455f, 0.02953300f, 0.00886632f, 
    0.01952009f, -0.00493715f, -0.02621990f, -0.01788980f, 0.02012811f, 0.00828040f, 0.00459276f, 0.02718298f, 
    0.02602523f, -0.01825325f, -0.04087843f, -0.00138368f, 0.02288657f, -0.00862439f, -0.00255451f, 0.02248902f, 
    0.01390200f, 0.01942603f, -0.03334434f, 0.01094893f, -0.00499781f, -0.04252615f, 0.00779145f, -0.00581801f, 
    -0.00849713f, 0.00940509f, -0.03996640f, -0.03411427f, -0.01885417f, -0.00744996f, 0.00389511f, -0.03135131f, 
    -0.00395196f, -0.02624491f, -0.00695609f, -0.03995284f, 0.02674234f, -0.03739220f, -0.00146074f, 0.00376789f, 
    -0.00763919f, -0.00744120f, -0.01584030f, 0.01962499f, -0.01658170f, -0.00319598f, -0.03662694f, 0.00562678f, 
    -0.02664873f, 0.00916738f, -0.01531544f, -0.01746706f, -0.02115676f, 0.00975278f, -0.03450990f, 0.01127963f, 
    -0.00814404f, 0.00156964f, -0.03978834f, -0.00958376f, -0.02882078f, 0.02713850f, 0.02926904f, -0.01875084f, 
    -0.00891536f, -0.02973124f, -0.02858669f, 0.01968609f, 0.01006404f, 0.00473286f, 0.00505830f, 0.02104409f, 
    0.02104127f, 0.02167892f, 0.00231141f, -0.03930017f, -0.01628938f, 0.01360041f, -0.00600404f, -0.02993459f, 
    -0.02218854f, -0.03728725f, -0.03256453f, -0.00443096f, -0.02483784f, 0.01146950f, -0.02236796f, 0.01563136f, 
    -0.01673344f, 0.01651418f, 0.01747458f, 0.01854718f, 0.02705031f, -0.02184754f, -0.01941806f, 0.01568348f, 
    0.01946202f, 0.01483892f, 0.02192249f, 0.00275082f, 0.03029937f, -0.02389225f, -0.00660066f, 0.02875385f, 
    -0.02778393f, -0.02817573f, 0.01927175f, -0.02227474f, -0.02725939f, -0.00593356f, -0.01652353f, 0.01925347f, 
    0.01273967f, 0.02629830f, 0.02645202f, -0.00623373f, -0.04215861f, 0.00242802f, 0.00176676f, 0.01867492f, 
    -0.01223938f, -0.02702227f, -0.03205820f, -0.02933891f, -0.03332820f, -0.01117554f, -0.01866879f, -0.00796878f, 
    -0.00254448f, -0.02319696f, -0.03175154f, -0.00460834f, 0.00219096f, -0.01904647f, -0.00925290f, -0.03864137f, 
    -0.03780128f, 0.01863642f, 0.01177783f, -0.02142890f, -0.03270942f, 0.00440915f, 0.00070477f, 0.01176418f, 
    -0.01033812f, 0.00423105f, 0.01058378f, -0.02958282f, 0.00614882f, -0.01615421f, -0.02438738f, 0.02854733f, 
    -0.02529560f, -0.01804253f, 0.00356688f, -0.01919778f, -0.01588075f, -0.03971426f, -0.01555535f, -0.00048569f, 
    0.01948137f, -0.02237401f, -0.00904745f, -0.01541662f, -0.02662976f, 0.01633174f, 0.00902860f, 0.01951442f, 
    0.01417348f, 0.01898992f, -0.01211228f, -0.01610403f, 0.01215667f, 0.01867702f, 0.02347517f, -0.01499867f, 
    0.01532684f, 0.01151123f, -0.00783841f, -0.00320410f, -0.00365412f, 0.01286598f, -0.03940448f, -0.02591656f, 
    -0.03777393f, -0.00027679f, 0.00410486f, -0.00581483f, -0.02754142f, -0.03227897f, 0.02195444f, -0.02927781f, 
    0.00638825f, 0.02367420f, 0.01036043f, -0.01572287f, -0.01064421f, -0.02261150f, -0.00371653f, 0.00520116f, 
    0.01132983f, -0.00448988f, -0.01274910f, 0.00250344f, 0.01960259f, -0.00044510f, -0.01221762f, -0.00239080f, 
    0.02796119f, -0.03287720f, -0.01709434f, 0.02344636f, -0.03524230f, -0.01167160f, -0.03072623f, -0.00504019f, 
    0.02740435f, -0.01266277f, -0.04145618f, 0.00563597f, 0.01423273f, 0.01749064f, 0.02082611f, 0.01107977f, 
    -0.01953541f, -0.00205441f, 0.01477162f, -0.01406918f, -0.02509033f, -0.03970646f, 0.01962855f, -0.03547777f, 
    0.01732599f, -0.00105046f, -0.02366806f, -0.03646021f, -0.02911257f, -0.03394154f, -0.00100644f, 0.01553251f, 
    0.00034907f, -0.00893976f, -0.02195481f, 0.00460178f, -0.01488840f, 0.01588542f, -0.02626462f, -0.00923699f, 
    0.00387409f, -0.02721380f, -0.00597847f, 0.01747568f, 0.01636361f, 0.02810618f, 0.01845406f, 0.01753478f, 
    0.01823640f, -0.02762657f, -0.02803931f, 0.02316555f, -0.02390308f, 0.00379927f, 0.00495121f, 0.02976124f, 
    -0.01929579f, -0.02026423f, -0.01736800f, -0.00862969f, -0.03220846f, -0.03859568f, -0.00430340f, -0.01663406f, 
    -0.02029098f, -0.02041479f, -0.01461916f, -0.01416339f, -0.03758512f, 0.00013660f, -0.04131295f, 0.01790076f, 
    -0.00416260f, -0.00718562f, 0.00933669f, 0.00698231f, -0.02977954f, 0.00321226f, 0.01948079f, 0.02781794f, 
    -0.01999397f, 0.01530918f, -0.03713769f, -0.01329906f, 0.01486425f, -0.03394603f, 0.00631757f, -0.01644440f, 
    -0.00138142f, 0.01298403f, -0.02394875f, 0.01487546f, 0.00893442f, 0.01491632f, 0.01663131f, 0.00198085f, 
    -0.03819117f, -0.02025599f, -0.00000287f, -0.01743823f, -0.02176415f, 0.02666652f, -0.02826743f, -0.00511839f, 
    -0.00603563f, -0.00016881f, 0.02307091f, 0.01513682f, 0.02146952f, -0.04279374f, -0.00961671f, -0.01396365f, 
    -0.02592179f, -0.01895853f, -0.03881121f, -0.02469946f, -0.01365016f, -0.00412153f, -0.03041065f, 0.01092217f, 
    -0.00870976f, -0.01105560f, -0.01631975f, -0.00107562f, -0.03332745f, -0.02635303f, -0.01486536f, 0.01932076f, 
    -0.00342730f, 0.00870759f, 0.01626813f, -0.03925406f, -0.02879566f, 0.01567741f, -0.02834417f, -0.03040595f, 
    -0.01859591f, 0.01931904f, 0.00096063f, -0.01545913f, 0.01950404f, -0.01211253f, 0.00069605f, -0.01485181f, 
    0.00039255f, -0.01096512f, -0.01526630f, -0.03240703f, 0.01790173f, -0.00472077f, -0.04075441f, -0.03171793f, 
    -0.01414456f, 0.01094148f, -0.00907643f, -0.00245978f, -0.03340406f, 0.00056635f, -0.01350997f, -0.03253705f, 
    -0.01222831f, 0.01401840f, 0.02015872f, 0.01774697f, 0.00288288f, 0.00174641f, -0.02989952f, -0.00283210f, 
    -0.03590887f, 0.01071355f, 0.01556427f, 0.02767942f, -0.00186819f, -0.02540695f, -0.03269438f, -0.02730467f, 
    -0.02168593f, 0.01796082f, -0.04032112f, 0.00486933f, 0.01534751f, -0.03967294f, 0.00188570f, -0.01127836f, 
    -0.03085641f, -0.04223492f, 0.00493440f, 0.02995850f, -0.00133371f, 0.02386119f, 0.02422067f, 0.00906930f, 
    -0.04319455f, -0.02763066f, 0.00179064f, -0.02149413f, -0.03116943f, 0.02833151f, -0.00769623f, -0.01130555f, 
    -0.03944001f, -0.02469365f, -0.03512640f, 0.00310172f, -0.02444259f, 0.00397276f, 0.01146180f, 0.00993418f, 
    -0.00993187f, 0.01014892f, 0.01756602f, 0.02715651f, 0.02496759f, -0.02020119f, -0.03055109f, 0.00527057f, 
    0.00243062f, -0.01016086f, -0.01336511f, 0.00601110f, -0.01939609f, 0.00113951f, -0.03387195f, 0.01306032f, 
    0.00329456f, -0.01569058f, -0.00400241f, -0.02210245f, -0.02734548f, -0.01161517f, 0.00176507f, -0.02561853f, 
    -0.02747513f, 0.00205714f, 0.00927608f, -0.02413125f, 0.00714950f, 0.01299672f, -0.00785812f, -0.02177339f, 
    0.02141689f, -0.01876561f, 0.00733993f, 0.01157976f, -0.01855558f, -0.02532153f, -0.01315887f, -0.00212255f, 
    -0.02151291f, -0.00273164f, -0.01337150f, 0.02807937f, -0.02588674f, -0.01714585f, 0.01347103f, -0.00582352f, 
    -0.03204959f, -0.03994109f, 0.00824654f, -0.03729274f, 0.00200907f, 0.01616375f, 0.01225864f, -0.00453334f, 
    -0.00995403f, -0.02943452f, 0.02367053f, -0.01071186f, -0.01655200f, -0.00724893f, 0.02415008f, -0.04104738f, 
    0.01762239f, 0.02797507f, -0.01028930f, -0.00324747f, 0.00966132f, -0.00829566f, -0.00252766f, -0.04111739f, 
    0.01265701f, -0.00610493f, 0.00084270f, -0.03969154f, 0.00262638f, -0.00896942f, 0.01986588f, 0.02927560f, 
    -0.04553690f, -0.03333288f, -0.03087332f, -0.02315944f, -0.02369925f, 0.02301050f, 0.00329649f, 0.01829275f, 
    0.02606841f, 0.00551578f, -0.00340763f, 0.01425634f, -0.01118058f, 0.00848099f, 0.00318373f, 0.01852316f, 
    0.01602086f, 0.00619300f, 0.01325329f, -0.00214487f, 0.00558874f, -0.01804767f, -0.03475798f, -0.02372349f, 
    0.00891683f, -0.00657820f, -0.01594945f, -0.00597549f, 0.00778898f, -0.01196345f, 0.00373247f, -0.02942425f, 
    -0.03604423f, -0.03975658f, -0.03900800f, -0.02008848f, -0.03731362f, 0.01089251f, 0.01014064f, 0.00997363f, 
    -0.04223556f, -0.02886814f, 0.00333399f, -0.00626352f, 0.02574468f, -0.00495500f, -0.01745766f, -0.03260891f, 
    0.00342540f, 0.01591177f, -0.03978485f, -0.00607937f, 0.01607512f, 0.00824893f, 0.00432955f, 0.00012876f, 
    0.00657162f, -0.03620816f, 0.02938370f, -0.01592878f, 0.00820058f, -0.02238380f, -0.04589270f, 0.02568563f, 
    -0.00238301f, -0.00437421f, 0.00963970f, -0.02154293f, -0.03553746f, -0.04140920f, 0.01507775f, 0.01191556f, 
    -0.02954340f, -0.03742576f, 0.00447024f, -0.03823336f, 0.01029761f, 0.02007452f, -0.02700488f, -0.03967221f, 
    -0.00014727f, -0.03261288f, -0.02302541f, -0.00370266f, 0.01360407f, 0.01599324f, 0.01330336f, 0.00962886f, 
    -0.01753848f, -0.03377045f, 0.01156071f, -0.02763679f, -0.01028389f, 0.01143294f, 0.02229265f, 0.01223530f, 
    -0.02705120f, 0.01076961f, -0.04502391f, -0.03452983f, 0.03106860f, -0.03834109f, -0.00935945f, -0.00403845f, 
    -0.01380731f, -0.00749425f, 0.00117145f, -0.00153675f, 0.01124845f, -0.04293413f, 0.01628413f, 0.01369692f, 
    0.00959324f, -0.01770402f, -0.00745870f, -0.02520185f, -0.02960388f, 0.02611368f, -0.03601907f, -0.01048335f, 
    0.02688106f, 0.00141463f, -0.01764515f, -0.00092334f, 0.01063438f, -0.02083362f, 0.01500089f, -0.02876880f, 
    0.02576570f, -0.02179692f, 0.01540249f, 0.02841195f, -0.03336369f, 0.00839133f, -0.02882284f, -0.00803190f, 
    -0.01606596f, -0.02818559f, 0.02502063f, -0.01971794f, -0.02450854f, -0.00489426f, -0.03034516f, -0.02299857f, 
    -0.01826014f, 0.01564472f, -0.01939139f, -0.04347723f, -0.03816811f, 0.02496715f, -0.00052623f, 0.01488797f, 
    -0.00099218f, 0.00781788f, 0.01133660f, -0.00199440f, -0.02315168f, 0.01795472f, -0.01672796f, -0.01470362f, 
    0.00093265f, -0.00637794f, -0.02135564f, -0.01554580f, 0.01850474f, 0.01464419f, 0.00998051f, -0.03525269f, 
    0.01006097f, -0.03154912f, -0.01288495f, 0.01022853f, -0.01028660f, 0.00060573f, 0.02304376f, -0.01474526f, 
    -0.01616390f, -0.00282995f, 0.01945881f, 0.00103601f, -0.03779430f, -0.04053210f, -0.02981024f, -0.01305383f, 
    0.01414596f, -0.02292227f, 0.00281494f, -0.04080414f, 0.02618448f, 0.02049609f, -0.01239334f, -0.03195005f, 
    0.00583173f, 0.02920920f, 0.00524011f, -0.03740750f, 0.02266926f, -0.00893388f, 0.02463653f, 0.02140244f, 
    0.03007475f, -0.00008368f, 0.02051636f, 0.02577058f, -0.03613086f, 0.01516203f, -0.01614060f, -0.03177631f, 
    0.02187693f, -0.03943136f, -0.00390922f, -0.01855430f, -0.01132561f, -0.01900762f, -0.02304579f, 0.00016643f, 
    -0.02984125f, 0.02129050f, -0.02471351f, -0.02222263f, -0.01255435f, -0.03150097f, 0.02461212f, -0.02402311f, 
    -0.02980337f, 0.01158778f, 0.02562954f, -0.02994303f, 0.00056718f, 0.00822566f, 0.02597308f, 0.01145090f, 
    0.00014146f, 0.02503238f, -0.00422497f, -0.00190856f, 0.01929723f, 0.00487942f, 0.02003772f, -0.03799024f, 
    -0.04033620f, -0.02061272f, 0.00698034f, 0.01316414f, -0.01145655f, 0.01235641f, 0.02696287f, 0.00483680f, 
    -0.03708759f, 0.02577428f, -0.00899359f, 0.01476300f, -0.01054068f, 0.02902027f, 0.02062923f, -0.03114049f, 
    -0.00105402f, 0.02786573f, -0.00299014f, -0.02393511f, -0.03689027f, -0.02239879f, 0.02313568f, 0.02592187f, 
    0.02329770f, 0.02475264f, -0.01663659f, -0.03075773f, -0.01257934f, 0.00666083f, -0.03166224f, -0.00222723f, 
    0.02783707f, -0.01942192f, -0.01553311f, -0.00977115f, 0.00883510f, -0.03666519f, -0.01410019f, 0.01811988f, 
    -0.01652278f, 0.00170971f, -0.01234184f, -0.00640691f, 0.01385805f, -0.02248410f, -0.01665681f, -0.04101483f, 
    -0.03538798f, 0.00234680f, -0.02817968f, 0.01762099f, -0.01338858f, -0.02079263f, 0.00918865f, 0.01033036f, 
    -0.01384715f, 0.00784719f, -0.03816825f, -0.03001886f, -0.03594248f, 0.02600795f, -0.02597767f, -0.03033322f, 
    -0.01618236f, -0.03102220f, -0.00220319f, 0.02086314f, -0.03656180f, -0.02824065f, -0.04059367f, 0.02382238f, 
    0.01025735f, -0.03826459f, -0.01133030f, -0.02590779f, -0.03484050f, -0.04019509f, -0.01928425f, -0.03331526f, 
    -0.02803415f, -0.01985335f, 0.00441827f, -0.02073512f, 0.00596466f, 0.02268646f, -0.03072087f, 0.00829333f, 
    -0.02031430f, 0.00766096f, -0.02730254f, 0.00773682f, 0.02358809f, -0.01263412f, 0.00931296f, -0.03887063f, 
    -0.00875947f, -0.03698775f, -0.00829727f, -0.02650525f, 0.02850837f, -0.01174367f, -0.00945491f, -0.02183199f, 
    -0.03605342f, -0.01743018f, -0.00602013f, 0.01439601f, -0.01457791f, -0.01570323f, -0.04171760f, -0.02044214f, 
    -0.01599868f, -0.00371983f, -0.01710062f, 0.01339182f, 0.00808696f, -0.03068494f, 0.01266867f, 0.02673796f, 
    0.01103946f, 0.01195379f, 0.00066141f, -0.02451795f, -0.01899905f, -0.01309083f, -0.04053945f, 0.00489432f, 
    -0.00981233f, -0.03004696f, -0.02212981f, 0.01687537f, -0.00274124f, -0.00751541f, -0.03324601f, -0.01259310f, 
    0.02185526f, -0.03781645f, 0.02312099f, 0.00850330f, 0.00534324f, 0.00686555f, -0.01886782f, 0.01604876f, 
    -0.02004318f, 0.01470762f, -0.02518993f, -0.02647861f, -0.03693291f, 0.00265169f, -0.03778224f, -0.01120350f, 
    0.00544860f, -0.02443756f, -0.02351294f, -0.02833320f, 0.00841341f, -0.02688124f, 0.00833367f, 0.02879789f, 
    0.01011847f, -0.00120323f, -0.02128283f, -0.02330776f, -0.01821646f, -0.01084008f, -0.03271220f, -0.01856977f, 
    -0.01068192f, -0.03580453f, -0.02131558f, -0.00556902f, -0.00134137f, -0.02491851f, -0.02282087f, 0.02582503f, 
    0.00888469f, 0.00665703f, -0.01587296f, -0.02451724f, -0.01102812f, -0.01932221f, 0.02063343f, -0.03211663f, 
    -0.03765671f, -0.01239818f, -0.02136030f, -0.00971793f, -0.02675929f, -0.00815940f, 0.02980969f, -0.03083742f, 
    0.02105427f, -0.02892523f, 0.02755112f, -0.03597954f, 0.01216722f, 0.01648824f, -0.00605679f, -0.00580143f, 
    -0.02188087f, -0.02433774f, -0.03504182f, -0.01297722f, 0.02019204f, -0.01676106f, -0.03904657f, 0.01597412f, 
    0.01434322f, -0.03562324f, -0.03880420f, -0.01342109f, -0.01793509f, 0.00943940f, -0.01182368f, 0.00228943f, 
    -0.03654712f, 0.01849781f, 0.02242288f, 0.01879946f, 0.00669424f, 0.01510505f, -0.00707651f, 0.00917736f, 
    -0.01328909f, 0.01384191f, -0.01289961f, -0.03343601f, -0.00856445f, -0.04200738f, 0.00023760f, -0.00614937f, 
    -0.03941241f, -0.03136527f, 0.01000755f, -0.00906464f, 0.01454607f, 0.02191829f, 0.02185498f, -0.00048541f, 
    -0.01764165f, -0.04088010f, 0.01663521f, 0.01344891f, 0.01840750f, 0.01566332f, -0.00715125f, -0.03243964f, 
    0.00246368f, -0.00251087f, -0.03235410f, -0.00790433f, 0.02261544f, -0.02037817f, 0.01683698f, -0.00364618f, 
    -0.01414810f, 0.02074775f, -0.00238764f, -0.01027733f, -0.02976103f, 0.01540701f, -0.01705821f, -0.02113527f, 
    0.01042672f, 0.00178812f, -0.01501585f, -0.02841529f, -0.00964585f, -0.02606987f, 0.01928680f, -0.02438357f, 
    -0.01818976f, -0.01462782f, 0.01537453f, -0.03129205f, -0.04060703f, -0.01264216f, -0.02429162f, -0.03947472f, 
    -0.02537427f, -0.00409455f, 0.02012605f, -0.00301514f, -0.02792751f, -0.00587929f, -0.02535120f, -0.03640518f, 
    -0.03362595f, -0.02751563f, 0.02752042f, -0.01265078f, -0.02702649f, 0.01754889f, 0.02969715f, -0.03132464f, 
    0.02479619f, -0.02824017f, -0.01275292f, -0.03966704f, -0.01848385f, -0.00582196f, -0.01316801f, 0.00639299f, 
    -0.02914367f, -0.02887394f, 0.00232856f, -0.02647802f, 0.00298093f, 0.01275794f, -0.00041731f, 0.00448984f, 
    -0.00504921f, 0.00146304f, 0.01307026f, -0.01282990f, -0.00451151f, 0.02927637f, -0.00058520f, -0.03691232f, 
    -0.01385749f, -0.00049836f, 0.00315964f, -0.03316570f, 0.01717223f, 0.01969250f, -0.02376544f, -0.01572072f, 
    -0.02569094f, -0.02735386f, 0.02253391f, -0.02191385f, 0.00118090f, 0.02977397f, -0.04157396f, -0.00488170f, 
    -0.03984388f, -0.02070954f, -0.01167940f, -0.02388802f, 0.00134198f, -0.02627075f, -0.03949912f, 0.02172396f, 
    0.02502235f, 0.02279799f, -0.00763683f, 0.02032420f, 0.01432068f, 0.02394812f, 0.01169308f, 0.02788602f, 
    0.02398540f, 0.02978013f, -0.03256225f, 0.02000961f, 0.02354960f, 0.00314215f, -0.03173341f, -0.02194748f, 
    -0.03381524f, -0.00098264f, -0.03095629f, 0.01302108f, -0.00696044f, 0.02050815f, 0.01510197f, 0.00075156f, 
    -0.02121613f, 0.02180107f, 0.02799820f, -0.00473778f, -0.01357053f, -0.03078681f, 0.02609541f, 0.02393023f, 
    0.01110521f, 0.01676288f, 0.00176348f, 0.01924270f, 0.01662268f, -0.02925541f, -0.03638107f, -0.00669290f, 
    -0.02507166f, -0.03719618f, -0.02053574f, -0.01283083f, 0.01660432f, -0.03321991f, -0.00568940f, 0.01855055f, 
    0.01755724f, 0.02020934f, 0.00521057f, 0.02408905f, -0.01548223f, 0.02007421f, 0.02612540f, -0.00043395f, 
    0.02958396f, 0.00234402f, -0.02937477f, 0.00195036f, -0.02874956f, -0.03235030f, 0.02750815f, -0.02358589f, 
    -0.01036139f, -0.03662952f, -0.01190815f, 0.00848067f, 0.00834983f, -0.02932521f, 0.00704859f, -0.00113731f, 
    0.01113205f, -0.03195396f, 0.01312493f, 0.01512307f, -0.03411042f, -0.03055938f, -0.00116561f, -0.01346384f, 
    0.02412270f, 0.00828643f, -0.01460093f, -0.03943553f, -0.00385372f, 0.00934982f, 0.02673155f, 0.00473863f, 
    -0.00687867f, -0.03391993f, -0.03953045f, -0.00194806f, 0.02771284f, -0.01116820f, 0.01591340f, 0.02669154f, 
    -0.02530504f, -0.03612067f, 0.02755801f, 0.02155933f, -0.04180555f, 0.02860272f, -0.02651110f, 0.02449926f, 
    -0.04132976f, 0.01331412f, -0.03723092f, -0.00159638f, -0.04178701f, -0.00820718f, 0.01583035f, -0.03452011f, 
    -0.03213349f, 0.02782133f, 0.00195289f, 0.00945954f, -0.04054577f, -0.01602031f, -0.02863904f, -0.01838084f, 
    -0.03822889f, -0.03542215f, -0.00610200f, -0.00676628f, -0.01247351f, -0.03086207f, 0.01018044f, -0.03789364f, 
    -0.03060294f, 0.01690098f, -0.00678707f, 0.02882653f, 0.02718878f, -0.03062873f, 0.00412872f, -0.04178521f, 
    0.01108850f, -0.02762467f, -0.02495228f, 0.01514123f, -0.00539467f, -0.00549776f, -0.01246062f, 0.00932403f, 
    -0.02787095f, -0.01994552f, -0.01831070f, 0.00233122f, 0.01385278f, 0.00186037f, -0.01011942f, -0.02359655f, 
    0.00211559f, -0.02736199f, -0.00131377f, 0.01438593f, -0.01530012f, -0.01156688f, 0.01112729f, -0.03242241f, 
    -0.03784374f, -0.03656648f, -0.01743419f, 0.00538779f, 0.00260213f, 0.00832406f, 0.02430675f, 0.01765754f, 
    -0.00246891f, -0.03512960f, -0.01201630f, 0.00700730f, -0.00557631f, -0.03822406f, 0.00484419f, -0.00946565f, 
    -0.00564929f, 0.00024367f, -0.00875008f, 0.00835556f, 0.02528150f, 0.02655160f, -0.04058589f, 0.01135635f, 
    -0.00866307f, -0.00626678f, -0.00569776f, 0.01087759f, 0.01639379f, 0.02749724f, -0.00337081f, 0.00068447f, 
    0.02542196f, -0.00633445f, 0.00372944f, -0.02572104f, 0.00977430f, -0.00623633f, 0.00868855f, -0.02721880f, 
    -0.03054609f, -0.01957260f, -0.01743798f, 0.01039341f, 0.02465143f, -0.03262047f, 0.00226176f, 0.01006882f, 
    -0.01352454f, -0.02208077f, -0.01101312f, -0.04190993f, -0.02299187f, 0.01366713f, -0.00165432f, 0.02528964f, 
    -0.00091154f, 0.00376850f, -0.02338234f, -0.01568061f, 0.00258958f, 0.02484803f, 0.00101065f, -0.02274863f, 
    -0.01256299f, 0.02100429f, 0.01605254f, 0.01505097f, -0.04101792f, -0.02860275f, 0.02292755f, 0.01586770f, 
    0.00655890f, -0.02479731f, -0.00167832f, -0.03729150f, 0.02400864f, 0.02601908f, -0.01086794f, 0.01905443f, 
    0.01936517f, -0.01111153f, -0.00679523f, 0.01994678f, -0.02363560f, -0.03540466f, -0.02113051f, -0.00899849f, 
    -0.02789964f, 0.00000436f, 0.01281186f, 0.01995495f, -0.02231988f, 0.01945650f, -0.01189897f, -0.02633540f, 
    -0.02415270f, 0.02244572f, -0.01091828f, 0.02003328f, 0.00989514f, 0.00557400f, 0.01173324f, -0.00866007f, 
    -0.02100562f, -0.01471642f, -0.02179795f, -0.02471278f, -0.02947432f, 0.00642402f, 0.01948282f, 0.02879788f, 
    0.00854366f, 0.00407317f, 0.02111988f, -0.02932209f, -0.02811247f, -0.03745722f, 0.02792329f, -0.00234547f, 
    0.01861605f, -0.02971478f, -0.01666669f, -0.04005592f, -0.01591500f, -0.01641440f, 0.03338386f, -0.03738430f, 
    -0.02928964f, -0.00229512f, 0.02834743f, -0.01482202f, -0.03420372f, 0.02825347f, -0.03685575f, -0.00756049f, 
    0.00498561f, 0.02924706f, 0.02758243f, 0.02776832f, -0.01857825f, -0.01414394f, -0.00730725f, 0.01929028f, 
    -0.02236347f, -0.04024618f, 0.01682538f, 0.02954470f, 0.02322436f, -0.03976490f, -0.03391219f, 0.01830488f, 
    -0.02179254f, -0.01846303f, -0.01804249f, -0.00387378f, -0.04004970f, -0.02424042f, -0.00473869f, 0.02036943f, 
    0.00231078f, -0.03708225f, -0.02169297f, 0.01816818f, -0.02189287f, -0.00309486f, 0.00905981f, 0.02976189f, 
    0.02458328f, 0.02357156f, 0.01053760f, -0.00544717f, 0.02155570f, -0.00795590f, 0.01524376f, 0.02961103f, 
    -0.00436663f, -0.02308847f, -0.00837805f, -0.02168672f, 0.01580219f, -0.03058482f, 0.01077172f, 0.02198666f, 
    -0.00321801f, 0.02358905f, -0.04114712f, -0.00564550f, -0.00792083f, 0.02258423f, 0.02893582f, -0.00304395f, 
    -0.03627272f, 0.00117525f, -0.00207852f, 0.02523085f, -0.02968566f, -0.02898815f, -0.02011121f, 0.02470987f, 
    -0.03305293f, 0.01172145f, -0.02994091f, -0.03597932f, -0.03927826f, 0.01470821f, 0.01132248f, -0.03440800f, 
    -0.02206012f, -0.03520677f, 0.02627672f, 0.00370507f, 0.02682091f, 0.00998763f, -0.00251755f, 0.00744309f, 
    0.13602000f, 0.24539624f, 0.17049170f, -0.23421477f, 0.04940608f, 0.09658745f, 0.09799169f, 0.07334003f, 
    -0.07065991f, -0.10841692f, -0.05729737f, -0.08103422f, 0.23633218f, 0.06212669f, -0.01938665f, 0.01769270f, 
    0.13155273f, 0.17884201f, 0.03627497f, 0.12063469f, 0.08634280f, 0.00320819f, 0.07533272f, 0.17053707f, 
    -0.02556133f, 0.05598897f, -0.16868190f, 0.05626478f, 0.00882372f, -0.01322828f, -0.12490500f, -0.04585815f, 
    0.01318147f, -0.03213932f, 0.07125522f, -0.04690161f, -0.15080306f, 0.27407980f, -0.12029131f, 0.25464749f, 
    -0.02105379f, 0.13627432f, 0.01653032f, 0.06156228f, 0.19121166f, 0.04736084f, -0.03416158f, -0.06362221f, 
    0.00015453f, -0.03025742f, 0.00945615f, 0.06547588f, 0.29066831f, -0.01773421f, -0.04418854f, 0.10095572f, 
    -0.03629088f, 0.15243384f, 0.25224966f, 0.06863254f, 0.45194098f, 0.34225631f, 0.36990052f, -0.19565481f, 
    0.19050181f, 0.07751129f, 0.19737455f, -0.00728849f, -0.01651529f, -0.18964148f, 0.05019194f, 0.06174054f, 
    -0.36346635f, 0.16185057f, -0.04894591f, 0.05789291f, -0.03207979f, -0.07776151f, -0.00644806f, 0.13777402f, 
    0.07919048f, 0.01136077f, -0.01304861f, 0.10243208f, -0.14714476f, -0.09367647f, -0.07739631f, -0.03471560f, 
    0.14942786f, -0.01442005f, 0.02469968f, 0.13882945f, -0.00775537f, -0.01335232f, 0.04175152f, 0.04221660f, 
    -0.20009631f, -0.30919975f, -0.27037972f, -0.11279516f, 0.04408840f, -0.06124660f, -0.11284376f, -0.04764886f, 
    0.01852758f, 0.01383439f, 0.06910437f, 0.15701722f, 0.21967062f, 0.16317278f, 0.06984711f, -0.15043408f, 
    -0.01814603f, 0.06290183f, 0.00918212f, -0.06602738f, 0.12280436f, -0.06252819f, 0.04103155f, -0.07239468f, 
    -0.11147294f, 0.11673500f, 0.01400336f, -0.05380750f, 0.12627894f, 0.12335301f, 0.08285253f, 0.00286856f, 
    0.05815290f, -0.20135042f, -0.08096293f, -0.05438672f, 0.10920611f, -0.00329799f, 0.27676824f, -0.00031581f, 
    -0.01559419f, 0.09819431f, 0.00203610f, 0.11686073f, 0.06607141f, 0.07095125f, 0.14986147f, 0.17165101f, 
    -0.07384287f, -0.20648037f, 0.04737367f, 0.21369545f, 0.00796213f, -0.09502190f, 0.03100047f, 0.03657106f, 
    0.08504850f, 0.04197057f, -0.01672978f, 0.06985836f, 0.25035650f, 0.27022782f, 0.07156944f, -0.03159097f, 
    0.16454051f, 0.14345655f, -0.04101320f, -0.08819717f, -0.02816028f, -0.07326037f, 0.00735755f, 0.05100864f, 
    0.42067266f, 0.30558658f, 0.14903317f, -0.08224097f, -0.07341190f, 0.04653814f, 0.14341982f, 0.13128960f, 
    0.06512433f, -0.09496048f, -0.05601494f, -0.05171726f, 0.06190181f, 0.02177624f, 0.10483097f, 0.08963911f, 
    0.07068018f, 0.05420842f, 0.08983670f, 0.15518117f, -0.07521740f, 0.00777405f, 0.02525752f, 0.04122445f, 
    0.17713678f, 0.18476121f, 0.26060462f, 0.13392541f, -0.07503638f, 0.03018139f, -0.07965303f, -0.02578782f, 
    0.05360978f, -0.00135325f, 0.00023392f, 0.05480221f, -0.08682006f, -0.08887906f, -0.13613141f, -0.01183577f, 
    0.07435302f, -0.04326400f, 0.01138953f, 0.03527794f, 0.18716310f, 0.02135346f, -0.08547307f, 0.06829412f, 
    0.27796516f, 0.16456285f, 0.09220725f, -0.03223183f, 0.01249013f, -0.01964819f, 0.17065684f, 0.00722674f, 
    0.15503380f, -0.03084184f, -0.11104576f, 0.10275756f, 0.13386755f, 0.13565183f, 0.03074884f, 0.09667953f, 
    0.10755164f, 0.04049537f, 0.08720416f, 0.02593049f, 0.00906393f, -0.02528116f, -0.08914614f, 0.00829158f, 
    0.11504254f, 0.24292570f, -0.15873767f, -0.20906873f, 0.05385125f, 0.05556033f, 0.20770615f, 0.06821573f, 
    0.05395529f, -0.03079824f, -0.13012326f, -0.08415714f, -0.23054796f, -0.20878193f, 0.02275701f, 0.21632984f, 
    0.14111863f, 0.07975625f, -0.01199893f, 0.02260417f, -0.02763098f, -0.05184415f, -0.03135933f, -0.03919762f, 
    -0.14496985f, -0.28815770f, -0.13472420f, -0.05901224f, 0.01305727f, -0.13450874f, -0.09744743f, 0.08520944f, 
    0.11761577f, -0.05623395f, 0.12050565f, 0.19647293f, 0.23209204f, 0.09450038f, -0.00962728f, -0.09891894f, 
    0.08915204f, 0.05823092f, -0.05588199f, 0.05763979f, -0.13677150f, 0.02421096f, 0.10785301f, 0.01518480f, 
    -0.16364348f, -0.11442488f, -0.11972280f, 0.17992878f, 0.05758711f, 0.01869578f, -0.02209516f, -0.03324460f, 
    0.04774707f, -0.05758985f, -0.08827821f, 0.01549227f, -0.02811935f, 0.09648006f, -0.05010231f, -0.19211972f, 
    -0.05356538f, -0.14649169f, 0.03974540f, 0.15079145f, -0.06584910f, 0.10928304f, 0.02350439f, 0.03483462f, 
    -0.11702743f, -0.16463161f, -0.01333038f, -0.14041574f, 0.19740024f, 0.03570596f, 0.10808330f, 0.08640156f, 
    -0.02438874f, 0.00360693f, -0.00677365f, -0.06854808f, 0.27500609f, 0.15808406f, 0.12267946f, 0.05543574f, 
    0.06043338f, 0.01764711f, -0.04843082f, 0.06904993f, 0.13228236f, 0.04401645f, -0.04135301f, 0.13176291f, 
    -0.25588775f, -0.14276740f, -0.26195502f, -0.03406524f, 0.04262877f, 0.01660649f, -0.08223895f, -0.01467129f, 
    -0.09088063f, -0.07797916f, 0.01299641f, 0.03226776f, 0.05497930f, -0.22096437f, 0.10748937f, -0.04610378f, 
    0.08477999f, -0.00945735f, -0.03920585f, 0.00178695f, -0.00834484f, 0.12396968f, -0.10119263f, -0.01921070f, 
    0.00625468f, -0.03772536f, -0.22032146f, -0.05567197f, -0.01497883f, -0.07002509f, 0.01520249f, -0.19311173f, 
    0.04327858f, -0.11643884f, -0.21941772f, 0.13673729f, 0.08899495f, 0.32561165f, -0.33989394f, -0.13490823f, 
    0.13679372f, 0.06166618f, -0.03041779f, 0.20779704f, 0.20059714f, -0.17014746f, -0.10416253f, -0.02411065f, 
    0.06529208f, -0.00591653f, -0.17606841f, 0.05181158f, -0.03508715f, -0.00923324f, -0.13216838f, 0.07113610f, 
    -0.05991331f, 0.01298226f, 0.14942431f, 0.20454547f, -0.01099923f, -0.14684941f, -0.26537606f, 0.10147505f, 
    -0.01719598f, -0.15126108f, 0.05698713f, 0.00831179f, 0.23604922f, 0.08988638f, -0.00417848f, 0.08741324f, 
    -0.05474020f, -0.13733041f, -0.19311357f, -0.11559147f, 0.07317206f, -0.05378782f, -0.08036077f, -0.03692818f, 
    0.09975421f, -0.04409431f, -0.12908739f, 0.14569263f, 0.17510821f, 0.14049602f, 0.14880084f, 0.06500613f, 
    0.08671752f, 0.16308542f, -0.01850130f, 0.21225263f, 0.01290006f, -0.00102416f, 0.05545310f, 0.00949146f, 
    0.04971591f, -0.02765323f, -0.17168078f, 0.00818537f, -0.01505302f, -0.05984196f, -0.07159521f, -0.12144502f, 
    -0.01749254f, -0.05944095f, -0.02583687f, -0.02047134f, 0.16945279f, 0.22443154f, 0.46044174f, -0.02723085f, 
    -0.01607504f, -0.06480961f, 0.04025312f, 0.12226646f, 0.09604604f, -0.13826942f, 0.05935724f, 0.16470312f, 
    0.07775075f, -0.00161036f, 0.18684649f, -0.18176180f, 0.11275984f, 0.13357297f, 0.06970844f, -0.05952057f, 
    -0.05176227f, -0.13714784f, -0.08216311f, 0.01065874f, -0.00882961f, -0.12777296f, -0.03314937f, -0.20187131f, 
    -0.09942597f, -0.04514634f, -0.09277359f, 0.04482223f, 0.18875566f, -0.01534385f, -0.00369602f, 0.00553700f, 
    -0.26487294f, -0.00848638f, 0.14614154f, 0.20541614f, -0.00594469f, -0.03341173f, 0.02559836f, 0.02005629f, 
    0.05896408f, 0.01120811f, 0.04971192f, 0.12990597f, -0.26873302f, -0.10095522f, -0.18876517f, 0.02285757f, 
    0.00389332f, 0.13355091f, -0.03505183f, -0.02517631f, 0.02691631f, -0.08263279f, -0.01785348f, -0.03848593f, 
    0.10956579f, 0.32918647f, 0.01796817f, -0.15955786f, 0.11733462f, 0.18253334f, 0.09672503f, 0.11060981f, 
    -0.01129725f, -0.04228919f, -0.08245558f, 0.12758937f, 0.00215300f, 0.15031242f, -0.31544513f, -0.10637812f, 
    0.13075364f, 0.13690704f, 0.08844194f, 0.10859457f, -0.00381409f, 0.17479686f, 0.15939443f, 0.01641086f, 
    -0.26023480f, -0.19180804f, 0.01361105f, 0.25369009f, 0.04376998f, -0.01219806f, -0.02840873f, 0.07162622f, 
    0.08236095f, -0.07690407f, -0.00006717f, -0.04898640f, 0.02464261f, 0.08247745f, -0.01920674f, 0.04386425f, 
    0.06538729f, -0.03977649f, -0.04381242f, -0.12252393f, 0.00924513f, -0.08917796f, 0.04340374f, 0.05761167f, 
    0.35005796f, -0.21903816f, 0.00534774f, 0.00279392f, 0.03618284f, 0.05733415f, -0.01302944f, 0.26451734f, 
    -0.06386358f, -0.05522899f, -0.01167988f, -0.03441953f, -0.03479051f, -0.18229717f, 0.00194076f, -0.06111319f, 
    0.07696450f, -0.02261744f, 0.12249280f, -0.05031246f, 0.02076483f, 0.07687508f, 0.00586838f, -0.16544542f, 
    -0.05271745f, 0.15552031f, -0.09254964f, -0.14759348f, 0.04730170f, 0.04878064f, -0.08123968f, -0.07073122f, 
    0.19828038f, -0.01436896f, -0.08073115f, -0.02862958f, -0.33432397f, -0.14421862f, 0.29749322f, 0.31705195f, 
    -0.03272663f, -0.02035334f, 0.06252919f, 0.03761502f, 0.09825020f, -0.03365399f, -0.00840228f, 0.00713058f, 
    -0.25249600f, -0.00149439f, 0.12169413f, 0.11196542f, 0.11973239f, 0.08821470f, -0.12064923f, 0.26502174f, 
    0.09538611f, -0.01261130f, 0.12013683f, -0.00636915f, 0.19277872f, 0.22318177f, 0.08014074f, -0.17149882f, 
    0.05305439f, -0.01227380f, 0.09538824f, -0.03191490f, 0.01250283f, 0.01061844f, -0.02872905f, -0.08294816f, 
    -0.01276101f, 0.26202598f, 0.02754846f, 0.00571848f, -0.02813152f, 0.03082109f, 0.07052106f, -0.00219520f, 
    0.17378569f, 0.00002329f, 0.11622883f, 0.07457957f, 0.01892908f, 0.03776781f, -0.08358496f, -0.06702901f, 
    0.01746918f, 0.07431623f, 0.19304253f, -0.01277154f, 0.02760939f, 0.08151477f, -0.00621599f, -0.09694716f, 
    0.05532821f, -0.01298556f, -0.04346322f, -0.00972272f, -0.02753705f, -0.02612501f, -0.01106205f, 0.09142090f, 
    -0.01347053f, -0.13286082f, 0.07774848f, 0.07293046f, 0.02816631f, 0.11554094f, -0.06058613f, -0.06036061f, 
    0.02498872f, -0.02474308f, 0.03146111f, -0.04156629f, 0.18687896f, 0.00480995f, 0.10839880f, 0.12311307f, 
    -0.33475533f, -0.04322323f, -0.08177292f, 0.07040019f, 0.11892504f, -0.05776166f, -0.21231338f, -0.00689056f, 
    0.13833694f, 0.01158083f, -0.00943837f, -0.00260026f, -0.45333958f, -0.12005276f, 0.05612143f, 0.35351154f, 
    0.11879180f, -0.10093725f, -0.04771207f, 0.09311283f, -0.04938707f, -0.12089069f, -0.07380909f, -0.08083508f, 
    0.15380695f, 0.13302706f, 0.23476201f, -0.05936918f, 0.09934994f, 0.05988628f, 0.05933111f, -0.05332961f, 
    0.03917228f, -0.04097188f, -0.01684158f, 0.04978226f, 0.19468853f, -0.05789152f, -0.14136051f, -0.04572430f, 
    0.04700089f, -0.05929334f, 0.08781142f, 0.06642837f, 0.05751476f, 0.13154417f, 0.03283688f, 0.12622379f, 
    0.26746884f, 0.11239521f, 0.12762804f, 0.01905339f, 0.08204035f, 0.17634599f, 0.16786525f, 0.00886255f, 
    0.08818451f, -0.12804216f, 0.03972509f, 0.05936889f, 0.19123009f, 0.30111942f, -0.02423480f, -0.04345270f, 
    0.15301596f, 0.01098840f, 0.03576115f, 0.13824457f, 0.00266443f, 0.06117215f, 0.09167422f, 0.02098445f, 
    0.09840705f, 0.31182450f, 0.10344264f, 0.06010100f, 0.13253902f, 0.09735792f, 0.10912030f, 0.17266104f, 
    -0.05389602f, -0.04489936f, -0.12466739f, 0.19427311f, 0.04904678f, 0.03150474f, 0.02855423f, 0.03754151f, 
    0.09969807f, -0.06733370f, -0.03729372f, -0.01563446f, -0.04280436f, -0.07154141f, -0.08750688f, -0.00014644f, 
    0.01533766f, 0.01703187f, -0.00573672f, -0.02085378f, -0.02932463f, -0.01122357f, -0.02018585f, -0.00367783f, 
    -0.01193175f, -0.01457470f, 0.00373829f, -0.00773728f, 0.02085487f, 0.04040963f, -0.04152833f, 0.00873921f, 
    0.01285475f, -0.00127110f, 0.02305098f, 0.00007164f, -0.03583780f, -0.00584266f, 0.00387787f, -0.01400856f, 
    -0.01182487f, 0.01894017f, 0.01757736f, -0.01828555f, 0.02396258f, 0.00312951f, -0.00393527f, -0.02612268f, 
    0.00136066f, 0.02804166f, -0.02842788f, -0.01342617f, -0.01088058f, 0.00512381f, -0.01386758f, 0.01949213f, 
    -0.02104460f, -0.02450206f, -0.00007222f, 0.02262840f, -0.01699099f, -0.02433990f, 0.00488122f, -0.01474195f, 
    -0.00013233f, -0.01799550f, -0.02811275f, -0.04056744f, -0.03268646f, -0.01447347f, 0.01149378f, 0.00544245f, 
    -0.03131207f, 0.01434773f, 0.01462361f, -0.01249309f, -0.04060187f, -0.01913011f, -0.02050551f, -0.02511117f, 
    0.00226830f, -0.00922436f, 0.01759240f, 0.01543202f, -0.01781940f, 0.02281384f, -0.02236037f, 0.02634204f, 
    -0.01656784f, 0.00837577f, 0.00199401f, 0.02963768f, 0.02584138f, 0.02707423f, 0.00646583f, 0.00683975f, 
    0.01608622f, -0.03508812f, 0.00536441f, -0.03789099f, -0.00617644f, 0.01483425f, -0.00633468f, 0.00196558f, 
    -0.00093136f, -0.03076582f, 0.00629516f, -0.01574316f, -0.01906778f, 0.01108016f, -0.01387104f, 0.01684484f, 
    -0.01084071f, 0.00911113f, 0.01574398f, 0.00795291f, 0.03796229f, 0.01580990f, 0.02448163f, 0.02131160f, 
    -0.02256309f, 0.03088101f, 0.02532446f, 0.00257850f, -0.00944652f, 0.02780008f, -0.02419151f, 0.01219288f, 
    0.00288457f, -0.02151157f, -0.02740479f, 0.01309114f, -0.02386820f, -0.03009417f, -0.00059031f, -0.02150290f, 
    -0.02780640f, 0.01253518f, -0.03844461f, -0.02000055f, -0.00657679f, -0.03672696f, 0.02472178f, 0.03351154f, 
    0.02267776f, -0.00054796f, -0.02592816f, 0.02272552f, -0.00269872f, 0.02772123f, 0.03473792f, 0.01578083f, 
    -0.01134264f, -0.02722389f, 0.00543562f, 0.00007911f, 0.01125883f, -0.01124800f, -0.01024150f, -0.02414127f, 
    0.00867796f, 0.01409148f, -0.03237974f, -0.02735345f, 0.03042631f, -0.02734476f, -0.04241727f, -0.01587898f, 
    0.01564147f, 0.00361810f, 0.02687610f, -0.03687464f, -0.02434034f, -0.00191606f, -0.02794625f, -0.03118672f, 
    -0.00592852f, 0.02483361f, -0.03180280f, 0.00847410f, -0.02898517f, 0.00559750f, -0.00956483f, -0.01654790f, 
    0.02006292f, -0.00909856f, -0.01172422f, -0.00912560f, -0.00457342f, -0.02482973f, -0.00417135f, -0.01393458f, 
    -0.01288862f, -0.00182250f, -0.00692036f, 0.01552792f, -0.01585963f, -0.03994754f, 0.02926672f, -0.02783982f, 
    0.02533795f, -0.03669103f, 0.00183289f, -0.02243279f, 0.00864570f, -0.00512284f, 0.01317745f, -0.02482058f, 
    0.02771918f, -0.01001096f, -0.03754777f, -0.02739456f, 0.00716129f, 0.00817876f, -0.01268176f, -0.00484146f, 
    -0.00943420f, 0.02951320f, 0.00313302f, 0.02473191f, 0.01879963f, -0.01765919f, -0.02609520f, -0.03763290f, 
    -0.00546447f, -0.02459062f, -0.01616251f, -0.02119516f, 0.00894735f, -0.01283100f, 0.01165188f, 0.01335511f, 
    -0.02792795f, 0.02105273f, -0.03250016f, 0.02718670f, 0.00713235f, 0.01123683f, -0.02102910f, -0.00886662f, 
    -0.02446521f, 0.03390658f, -0.01442119f, -0.00277220f, -0.02488247f, -0.03109141f, -0.03582765f, 0.00415321f, 
    0.02614298f, 0.01422672f, 0.01483661f, 0.01457306f, -0.00531980f, 0.01714694f, 0.00389718f, -0.02469329f, 
    0.00058979f, 0.01419264f, 0.01764315f, -0.00013356f, -0.02296093f, 0.02348280f, -0.03497760f, 0.00713501f, 
    -0.01909011f, 0.01983958f, 0.02434734f, 0.02464560f, 0.01884572f, 0.02642586f, 0.01038398f, -0.03551452f, 
    -0.00037430f, -0.01437597f, 0.00387874f, -0.02330981f, -0.00605364f, -0.03886826f, -0.01968815f, -0.04170194f, 
    -0.02616491f, -0.02213847f, 0.01009601f, 0.01088331f, -0.03286621f, 0.00465322f, -0.01685682f, 0.00752545f, 
    -0.00378575f, 0.01672497f, -0.02168869f, -0.02354744f, -0.02479164f, 0.02736627f, 0.00978868f, -0.03215808f, 
    -0.04179401f, 0.01773879f, -0.02302853f, 0.01310840f, -0.00869004f, -0.02301513f, 0.01250814f, 0.02744049f, 
    -0.00493624f, 0.00525070f, 0.03031230f, -0.00714482f, -0.00584005f, 0.01609544f, -0.02083631f, 0.00237679f, 
    -0.03289084f, -0.02735560f, 0.01853999f, 0.02797214f, -0.03743937f, -0.01466577f, 0.00512262f, 0.01726094f, 
    0.02389205f, -0.03521644f, -0.00419407f, 0.02566211f, 0.02535508f, 0.02339449f, -0.00010867f, 0.03167355f, 
    -0.02845203f, -0.03999208f, 0.00183541f, 0.00303849f, -0.03043769f, 0.01466958f, 0.00646865f, 0.02239413f, 
    0.02570212f, 0.02525015f, -0.02649679f, -0.01659517f, -0.03534461f, -0.00479100f, 0.03084566f, 0.02674596f, 
    -0.03909621f, -0.00921882f, 0.00710815f, -0.01183697f, 0.00124571f, -0.02679840f, -0.01730018f, 0.02790865f, 
    -0.01621707f, 0.01599710f, 0.02073895f, -0.03182486f, 0.01166255f, -0.00974982f, 0.01693537f, -0.02048438f, 
    -0.00615713f, 0.01443206f, 0.00334128f, -0.01130059f, 0.02085704f, 0.02526255f, 0.02636128f, -0.03891870f, 
    -0.04174499f, -0.01648188f, -0.02363472f, 0.02730589f, 0.03004953f, -0.01485539f, -0.00577878f, 0.02493009f, 
    0.02379185f, 0.03802409f, -0.03552214f, -0.02806306f, -0.03000037f, 0.02397335f, 0.02584558f, 0.03047570f, 
    -0.02679886f, -0.03714795f, -0.03957374f, -0.00162202f, 0.02096016f, 0.02807867f, -0.02415927f, 0.02757879f, 
    -0.02525973f, -0.00810294f, 0.02944580f, -0.02998753f, -0.01033722f, -0.02356649f, -0.01599146f, 0.01956556f, 
    0.03238478f, -0.03851141f, 0.00834008f, 0.02664741f, -0.02049657f, -0.02065921f, 0.00878584f, 0.00100394f, 
    0.02384671f, -0.01616527f, -0.03193618f, 0.01562830f, 0.02196340f, -0.03511829f, 0.02029694f, 0.02307705f, 
    -0.01284167f, 0.00957920f, 0.01245704f, 0.00093924f, -0.03607146f, -0.02564030f, -0.01635626f, -0.00353845f, 
    -0.02587003f, -0.00443403f, -0.02810949f, 0.01996784f, -0.01466078f, -0.02561518f, -0.02098246f, -0.03260970f, 
    -0.02965310f, -0.02567552f, -0.02206390f, -0.00063085f, -0.02266638f, -0.01937707f, 0.00820458f, -0.03708874f, 
    -0.00572896f, -0.03110094f, 0.01722167f, -0.04003611f, -0.03720575f, 0.01855643f, -0.03889947f, 0.02171304f, 
    0.01404043f, 0.03476996f, 0.03026557f, -0.02476138f, -0.02802343f, 0.01271262f, 0.02211318f, -0.02425343f, 
    0.01383118f, -0.03731907f, -0.03546929f, 0.02982800f, 0.02958383f, -0.01080633f, -0.01728885f, 0.02220063f, 
    -0.02770869f, -0.01668226f, -0.02074217f, 0.01050014f, -0.02421157f, 0.00356171f, 0.02354288f, 0.02668540f, 
    -0.03423699f, -0.02634132f, -0.03075767f, -0.03408191f, -0.00101987f, 0.02223259f, 0.02262870f, -0.02565721f, 
    -0.00519133f, -0.03104782f, -0.02549548f, -0.00571505f, 0.02535738f, 0.02007821f, -0.00917552f, 0.02744184f, 
    0.00597695f, -0.02892189f, -0.03467982f, 0.01425595f, -0.02757539f, -0.00003718f, 0.02971563f, -0.00098422f, 
    -0.00940192f, -0.01724991f, -0.01680990f, -0.00131316f, -0.03026951f, 0.01727939f, -0.00643201f, 0.01156180f, 
    -0.03064610f, 0.00389126f, 0.00119534f, -0.01479275f, -0.01583298f, 0.00612786f, -0.01419532f, 0.00525704f, 
    0.02309177f, -0.03690272f, -0.03734270f, -0.03247043f, 0.02152713f, 0.01563932f, -0.01362294f, -0.02442175f, 
    -0.04214966f, -0.01266723f, 0.00119658f, -0.00380717f, -0.02729362f, -0.01635528f, 0.01857023f, 0.01949778f, 
    -0.03513954f, -0.02049978f, -0.02618903f, -0.02415131f, 0.02438505f, -0.00960209f, 0.00717121f, -0.00731220f, 
    -0.02121047f, 0.00331758f, -0.00973791f, 0.01785295f, -0.01309158f, -0.00334951f, 0.01395344f, 0.01780128f, 
    -0.03244634f, -0.03286808f, 0.00860496f, 0.02592094f, -0.00525995f, -0.00234930f, -0.03008563f, 0.02046419f, 
    -0.01810907f, 0.02847886f, -0.01224887f, 0.01740526f, -0.03193184f, 0.00605270f, -0.03052713f, 0.01494812f, 
    0.01223176f, -0.03897261f, -0.01390335f, 0.02762419f, -0.01858408f, -0.03199204f, -0.01887655f, 0.01525747f, 
    -0.02169712f, -0.00167099f, 0.01455320f, 0.01651886f, -0.00469600f, 0.02925784f, -0.00953846f, -0.03536157f, 
    -0.00926206f, -0.03167225f, 0.01500743f, 0.03039431f, -0.00742932f, -0.02809418f, -0.02469454f, 0.02952830f, 
    -0.02998332f, -0.03503568f, -0.03869160f, -0.03038269f, -0.00101704f, -0.03661780f, 0.01261153f, 0.01500388f, 
    -0.02764312f, -0.03154879f, -0.00858497f, 0.02136699f, 0.01345165f, -0.03951787f, -0.01384130f, 0.00948713f, 
    0.02013571f, 0.02696628f, 0.00196227f, -0.01926504f, 0.01728645f, -0.02789456f, -0.04219704f, -0.00643786f, 
    -0.02130931f, -0.03265686f, -0.03572068f, -0.02644750f, 0.01248536f, 0.00634854f, 0.02238563f, 0.01734401f, 
    0.01153340f, -0.00399014f, -0.03086584f, 0.01314058f, 0.02525251f, -0.02444312f, -0.03340209f, -0.01215245f, 
    0.00477751f, 0.02304077f, -0.01581104f, 0.02266296f, 0.00334937f, 0.00981095f, 0.00234850f, -0.03112465f, 
    -0.02955583f, 0.01732691f, -0.02903952f, -0.00877422f, -0.02560023f, 0.01877714f, -0.03819415f, 0.00188392f, 
    0.01767792f, 0.03333947f, -0.04231570f, 0.01006588f, -0.01807585f, 0.00082367f, -0.02817990f, 0.01269945f, 
    -0.02987392f, 0.01192260f, 0.03062862f, 0.03001220f, -0.02299358f, 0.00328089f, 0.02719058f, 0.00223487f, 
    -0.02121401f, 0.00732794f, 0.02230046f, -0.01622715f, -0.02829684f, 0.01971026f, -0.00647547f, 0.02874808f, 
    0.00743998f, -0.00363016f, -0.03715868f, -0.04045500f, 0.01016148f, -0.03444476f, 0.02548096f, -0.03376361f, 
    -0.02476767f, 0.00240258f, 0.02431105f, -0.01346666f, -0.00573657f, 0.02898883f, 0.01225147f, 0.02499849f, 
    -0.02916274f, -0.02560307f, -0.00528130f, 0.00291954f, 0.01865876f, -0.02532428f, 0.02314943f, 0.00333519f, 
    0.02972832f, -0.00501034f, 0.00517885f, -0.02278829f, -0.02654652f, 0.01718942f, 0.03251863f, 0.02454682f, 
    -0.00361504f, 0.01287578f, 0.02831622f, 0.01743180f, 0.01529391f, 0.00199162f, 0.00459331f, -0.04078990f, 
    -0.03700541f, -0.00096250f, -0.01462105f, -0.00585896f, -0.02610409f, -0.01423254f, -0.01803905f, -0.02747093f, 
    -0.02259047f, 0.02787817f, -0.03722317f, -0.00822862f, -0.01641687f, 0.02799591f, 0.02177023f, 0.00143109f, 
    -0.01137604f, -0.02868640f, 0.00157492f, 0.02696317f, 0.02625363f, -0.00198153f, -0.01341498f, 0.01606194f, 
    0.01150778f, -0.01783182f, 0.01644664f, 0.00975078f, -0.03483577f, 0.00898086f, 0.00720169f, 0.01413680f, 
    -0.00899888f, -0.01859632f, 0.03561242f, 0.00001564f, 0.01290799f, 0.00349052f, 0.00330260f, -0.01227410f, 
    -0.01918129f, 0.01498551f, -0.02353238f, -0.00175557f, -0.00892833f, 0.01686146f, -0.02475960f, -0.01384509f, 
    -0.00894719f, -0.02665283f, 0.02524334f, 0.00736541f, -0.04097089f, -0.00352403f, -0.03199643f, -0.00652259f, 
    0.01654719f, -0.00360483f, -0.00680839f, -0.00995797f, 0.00667982f, -0.01465914f, -0.03964794f, -0.03845387f, 
    0.02459380f, -0.01922906f, -0.00453917f, -0.02485932f, 0.02181388f, -0.02181628f, -0.02434922f, -0.01135561f, 
    0.01903740f, -0.00932288f, 0.00653470f, -0.01892331f, -0.02911341f, 0.01535613f, -0.02470991f, -0.02042393f, 
    0.17631020f, 0.10743197f, 0.27858418f, 0.58599120f, 0.00120745f, 0.10805227f, 0.12856375f, 0.05018776f, 
    -0.04146210f, -0.02486575f, -0.05847105f, 0.11640747f, 0.00145699f, -0.11338882f, 0.03871993f, 0.18595140f, 
    0.05557835f, -0.10087364f, 0.07871713f, 0.06837401f, 0.13173102f, -0.06632639f, -0.17740650f, -0.07333322f, 
    0.13288830f, -0.04653054f, -0.00917673f, -0.02971598f, -0.10025317f, -0.06476071f, 0.12549964f, -0.11817630f, 
    0.19781290f, -0.17722677f, -0.09391234f, -0.03849738f, 0.17614123f, 0.02216409f, 0.16875054f, 0.10720670f, 
    0.10246707f, -0.14374109f, 0.06637233f, -0.04529785f, 0.09585761f, -0.04289698f, -0.19205758f, 0.09257457f, 
    0.03238009f, -0.29193327f, -0.01810597f, -0.12683050f, 0.00287563f, -0.03736743f, -0.07017109f, 0.10923391f, 
    -0.17317313f, -0.04685269f, -0.10013425f, 0.13953796f, -0.20739083f, -0.01915111f, 0.12599376f, 0.26609093f, 
    0.07351199f, 0.06729621f, 0.03463872f, 0.16364260f, -0.05349569f, -0.07954363f, -0.01987445f, -0.05376508f, 
    0.80792093f, -0.25135860f, -0.12746595f, -0.09666583f, 0.02402897f, -0.00828613f, 0.09650552f, -0.04841899f, 
    -0.09319310f, -0.05118823f, -0.08256245f, 0.07251213f, -0.01700385f, -0.21236511f, -0.04825160f, -0.21340683f, 
    -0.05076683f, -0.04132339f, -0.09600074f, -0.00497908f, -0.07564706f, 0.21653369f, -0.00427734f, -0.01658310f, 
    0.03338699f, 0.03136128f, 0.01692402f, -0.02218247f, -0.07940022f, -0.02988792f, -0.08999009f, -0.00105787f, 
    0.19827630f, 0.06897731f, -0.03963909f, 0.11094247f, 0.17326732f, 0.09163206f, 0.13977906f, 0.17594491f, 
    0.02800361f, -0.10789758f, 0.22662292f, 0.14842294f, 0.08739743f, 0.06688078f, 0.16137426f, -0.01640597f, 
    0.18356994f, 0.08012331f, 0.00314692f, 0.15608037f, 0.16530657f, 0.00892237f, 0.07812905f, -0.10738913f, 
    0.12394530f, -0.00019294f, 0.09744446f, 0.03440593f, -0.24794601f, 0.19073291f, -0.24362917f, 0.11796393f, 
    0.15430933f, 0.11061939f, -0.00726608f, -0.08134629f, -0.08349675f, -0.00214163f, -0.10008022f, 0.07140670f, 
    -0.08732164f, -0.06609393f, -0.02739226f, -0.32303813f, 0.05592092f, -0.04173042f, 0.01074138f, -0.10025945f, 
    -0.00559374f, 0.05218386f, -0.04699887f, 0.08592977f, 0.09187451f, 0.03587995f, 0.07237735f, 0.41590458f, 
    0.02186495f, 0.12037300f, -0.06076033f, 0.33650437f, 0.06199568f, 0.04641530f, 0.03770476f, -0.03460868f, 
    0.03686079f, 0.16365510f, 0.13840799f, 0.42728812f, 0.18350808f, 0.10292834f, 0.14005016f, 0.14407673f, 
    0.05992307f, 0.17384292f, -0.06511861f, 0.07191543f, 0.14461161f, -0.10054876f, -0.16614783f, -0.02088133f, 
    -0.02859074f, -0.16191071f, -0.05425564f, -0.05264717f, -0.05812905f, 0.00501474f, -0.10609069f, -0.02754496f, 
    0.06801783f, -0.07453944f, -0.02142733f, 0.01740940f, 0.03395632f, -0.06289459f, 0.04332858f, 0.05135450f, 
    0.02933220f, 0.00300650f, -0.12881373f, -0.06109333f, -0.03430494f, 0.02829568f, -0.08791117f, -0.08695928f, 
    0.02348949f, 0.06237899f, -0.07050207f, -0.10925610f, 0.13030240f, -0.03247647f, -0.02156929f, -0.03636019f, 
    -0.02405617f, 0.11118776f, 0.02772382f, 0.12704352f, 0.12813592f, -0.05499909f, -0.04577056f, 0.04083167f, 
    -0.00032182f, 0.01951140f, 0.13413827f, -0.07917534f, -0.10184594f, 0.12464218f, 0.07274606f, 0.16462880f, 
    0.10287812f, -0.09642769f, -0.14430638f, 0.09426879f, -0.08414882f, 0.13365909f, -0.14544688f, 0.05601819f, 
    -0.08999895f, 0.14379433f, 0.29734784f, 0.39933372f, 0.13205101f, 0.16416076f, 0.02177965f, 0.18253227f, 
    0.01806365f, -0.06383988f, 0.02518327f, -0.00506174f, 0.06952341f, -0.09416333f, 0.20863141f, 0.07678884f, 
    -0.15364751f, -0.06421559f, -0.05161758f, 0.06025882f, 0.03660388f, -0.01886477f, 0.01134352f, -0.06688833f, 
    -0.00655636f, 0.14089796f, 0.00486593f, -0.07273951f, -0.04136405f, 0.04884185f, -0.13944033f, 0.00828237f, 
    0.08296780f, 0.21722223f, 0.04212097f, -0.05605446f, -0.38342428f, -0.33571941f, 0.10838573f, 0.09687146f, 
    0.07529745f, -0.05405761f, -0.02741630f, 0.12527066f, -0.00421064f, -0.07363346f, 0.18372676f, -0.01536713f, 
    -0.19939429f, -0.03012836f, -0.02661021f, -0.11462486f, -0.14690334f, -0.04595549f, -0.06363302f, -0.11143194f, 
    -0.04372529f, -0.05055111f, 0.04800116f, -0.00860778f, 0.15554704f, 0.47958362f, -0.15106337f, 0.04805060f, 
    0.13529442f, 0.07171082f, -0.08936661f, 0.08066084f, -0.12966545f, -0.21102640f, -0.04191620f, 0.03705035f, 
    0.08128174f, 0.07041696f, 0.06091420f, 0.28713000f, -0.01637698f, 0.02517398f, 0.01904058f, 0.12124576f, 
    0.03526650f, -0.11754339f, -0.02276424f, -0.02301027f, -0.19989218f, 0.05179819f, 0.24075696f, 0.26690993f, 
    -0.08144790f, -0.04859356f, -0.08018579f, -0.02118494f, -0.08088779f, 0.07181706f, 0.06060477f, -0.14016411f, 
    0.11189213f, 0.04787219f, -0.00087219f, -0.06046627f, -0.10683271f, -0.01737625f, -0.08701528f, 0.11342617f, 
    0.03261758f, 0.13563292f, 0.20530136f, -0.09941625f, 0.37296346f, 0.15981098f, 0.13121299f, 0.07570840f, 
    -0.02882260f, -0.05639718f, 0.23957427f, -0.07057155f, 0.11417831f, 0.11108392f, -0.19116545f, 0.16576660f, 
    0.13647717f, 0.07918271f, -0.18617223f, 0.31848398f, 0.12728305f, 0.15915620f, -0.22183527f, 0.13986312f, 
    -0.15683712f, 0.12913354f, -0.24335268f, 0.07925733f, 0.10320876f, 0.27842513f, 0.04752579f, -0.02209720f, 
    0.06779545f, 0.25395736f, 0.22178529f, 0.13342275f, -0.08133184f, -0.01737897f, 0.18853173f, 0.08160292f, 
    0.03965072f, 0.20067671f, -0.00805452f, -0.10911686f, -0.02286006f, -0.00808762f, -0.10881526f, -0.05625890f, 
    -0.23650746f, -0.03716933f, 0.07269551f, -0.07772774f, 0.15360403f, 0.11313931f, 0.07626405f, -0.22546351f, 
    0.06326895f, -0.08088686f, 0.12561283f, -0.14241607f, -0.02673521f, -0.08887900f, -0.02186454f, 0.04231289f, 
    0.13310087f, -0.09168801f, -0.08085390f, -0.02234553f, 0.10174114f, 0.09783430f, -0.03253742f, -0.00970368f, 
    0.03509053f, -0.04945570f, -0.00979967f, 0.01331434f, -0.05944123f, -0.07207561f, 0.00651212f, 0.14905834f, 
    -0.00065298f, -0.10689501f, 0.03587370f, 0.02610403f, -0.03164528f, 0.13022658f, -0.01342950f, -0.17674617f, 
    0.17918512f, 0.04791540f, -0.05468816f, 0.10329954f, 0.02733934f, -0.00268464f, 0.06320726f, -0.09997527f, 
    0.07619052f, -0.23470546f, 0.05175636f, -0.03031289f, -0.18774204f, 0.08867398f, 0.08317322f, 0.26128563f, 
    0.00577245f, 0.01648669f, -0.09897131f, 0.01292910f, -0.04502264f, 0.06167739f, -0.01158141f, -0.10810885f, 
    0.21289524f, -0.14842895f, -0.08383606f, 0.21035604f, 0.19170004f, 0.08514084f, 0.04012850f, -0.10869226f, 
    -0.05616955f, -0.05162041f, 0.08352570f, 0.12714800f, 0.04057793f, 0.19508462f, -0.16064045f, 0.02986553f, 
    0.01692359f, 0.02100553f, 0.04454545f, -0.05879621f, -0.01803582f, -0.12359770f, -0.17351033f, -0.11309660f, 
    0.07883717f, 0.47023848f, -0.20798707f, -0.09894791f, -0.11936250f, 0.02107545f, 0.06166495f, -0.17397887f, 
    -0.13023430f, 0.08856536f, -0.16616824f, 0.08555595f, -0.09198762f, 0.10812458f, 0.25021797f, -0.05383685f, 
    -0.12668917f, -0.05991772f, 0.05933679f, -0.07579106f, 0.01909527f, 0.05881361f, -0.01742317f, -0.04632133f, 
    -0.07180157f, -0.02688741f, 0.15700619f, 0.31664711f, 0.09937619f, 0.00652624f, 0.00114031f, 0.03842520f, 
    0.01180736f, -0.03881114f, -0.02875840f, 0.09636401f, -0.41213438f, 0.32385185f, 0.15290311f, 0.20657508f, 
    -0.16813122f, 0.08017181f, 0.12031447f, -0.16926320f, -0.04952891f, -0.13264163f, -0.06315205f, 0.14382201f, 
    0.37262905f, 0.06338444f, -0.02225784f, -0.27849776f, 0.11744463f, -0.07175153f, 0.02545686f, -0.00912452f, 
    -0.10488931f, 0.08542409f, -0.09793915f, -0.15721230f, 0.01191201f, -0.15917499f, -0.01339734f, -0.09539504f, 
    0.17085810f, 0.02627396f, -0.10398626f, 0.02809174f, -0.02871040f, 0.20197868f, -0.14649065f, 0.10611100f, 
    0.25361004f, 0.35675001f, 0.00291675f, 0.31699309f, 0.13998869f, 0.07302850f, 0.12626354f, 0.25883570f, 
    -0.13070612f, 0.02066655f, 0.09706022f, 0.03297470f, -0.05275382f, 0.37893504f, 0.03766635f, 0.22093317f, 
    -0.00578653f, 0.04612400f, -0.13407750f, 0.34787393f, -0.01248825f, 0.01247655f, 0.02482586f, -0.06629088f, 
    -0.42078412f, 0.04354910f, 0.11286610f, 0.27463910f, 0.03266768f, 0.03867508f, 0.01848192f, 0.10867919f, 
    -0.06680489f, 0.09745952f, 0.14913678f, 0.08346134f, 1.07900500f, 0.16902433f, -0.26843807f, -0.06364352f, 
    -0.02700232f, -0.22031398f, 0.09693953f, -0.15943785f, -0.05090354f, -0.11136471f, -0.11787482f, 0.00415383f, 
    0.56843626f, -0.28552163f, 0.17462306f, -0.24246795f, 0.06992547f, -0.14773008f, 0.04593255f, -0.07797691f, 
    -0.13751519f, 0.04852614f, 0.07501103f, -0.00244897f, 0.02443000f, 0.08812389f, 0.16660351f, 0.42983815f, 
    0.04630512f, 0.18227200f, 0.12586235f, 0.31098634f, 0.04004237f, 0.06366755f, -0.04365223f, -0.08326463f, 
    0.15369551f, 0.03865267f, -0.05850139f, 0.06767417f, -0.03101460f, -0.07731999f, -0.03749608f, -0.02414096f, 
    0.05511294f, -0.20725204f, -0.08337560f, -0.01450609f, 0.06315845f, 0.37661153f, 0.37757623f, 0.11475386f, 
    -0.08872671f, 0.05787778f, 0.09793807f, 0.11733655f, 0.04744917f, -0.04589243f, 0.00697130f, 0.00680829f, 
    -0.30509561f, 0.11432816f, 0.15779540f, -0.11822301f, 0.01074442f, 0.09246397f, -0.20771213f, 0.03209384f, 
    -0.05324869f, 0.07479348f, -0.07312248f, -0.02813225f, -0.08943608f, -0.01713884f, -0.07926114f, 0.21505117f, 
    -0.08706327f, -0.06346495f, -0.00908779f, 0.16779193f, -0.08795886f, -0.20799616f, 0.23613591f, 0.02493713f, 
    0.14170037f, -0.14302015f, 0.08329997f, -0.05283153f, -0.32918456f, -0.06167329f, -0.03622051f, -0.01818352f, 
    0.04984743f, 0.15004422f, 0.04359549f, -0.05093186f, -0.00775483f, 0.21782534f, 0.22084148f, -0.09354147f, 
    -0.02920929f, 0.05133975f, -0.08871914f, -0.04152660f, 0.00369005f, -0.02162506f, -0.02198920f, -0.05026619f, 
    -0.13577329f, 0.19025891f, 0.09101421f, 0.27807346f, -0.08021431f, 0.18298815f, -0.09744013f, -0.11718991f, 
    -0.05698128f, -0.06232053f, -0.05038607f, 0.01234869f, -0.17916679f, 0.18660185f, -0.01363052f, 0.27246031f, 
    -0.13195784f, 0.06200548f, 0.02486961f, 0.00301166f, 0.01127583f, 0.02798511f, 0.00423839f, 0.04021477f, 
    -0.09960492f, 0.09934130f, 0.03541846f, 0.33813354f, 0.02994508f, 0.03249233f, 0.15848555f, 0.06645717f, 
    0.06207713f, 0.22793758f, -0.17863224f, 0.16009083f, 0.14581017f, -0.09399077f, 0.20534357f, 0.24134324f, 
    0.22910672f, 0.11935342f, 0.10067809f, 0.17484586f, 0.01102483f, 0.06504445f, 0.11491943f, 0.03426076f, 
    0.16426264f, 0.06249795f, 0.24357444f, 0.22234128f, 0.05126561f, -0.00115974f, 0.09335627f, -0.14292544f, 
    -0.11008255f, -0.06711605f, 0.05028010f, -0.03214690f, 0.14190945f, 0.30012584f, -0.08337416f, -0.06919877f, 
    0.02940222f, 0.10599862f, 0.00750927f, 0.00997204f, 0.04599125f, -0.05374174f, 0.00885622f, 0.02146732f, 
    0.03375258f, -0.00843516f, -0.08530082f, -0.03446856f, 0.00552634f, 0.04535155f, 0.12966082f, 0.14129722f, 
    -0.01293786f, 0.00079633f, -0.02225256f, -0.08656171f, 0.02230870f, -0.14152789f, -0.09073638f, -0.08142164f, 
    -0.00823003f, -0.13218315f, -0.08883017f, 0.17061852f, 0.03836181f, 0.05342105f, 0.04642044f, -0.01581029f, 
    -0.04282108f, 0.17420395f, -0.08708840f, 0.14602673f, -0.06007886f, -0.09933905f, 0.12668338f, -0.06144899f, 
    0.13640361f, 0.06110397f, 0.17405225f, 0.12784329f, -0.06129616f, 0.10126133f, -0.20707001f, 0.15922923f, 
    -0.10047935f, 0.06675696f, 0.03830677f, 0.00701920f, 0.02047115f, 0.13621148f, 0.11298398f, -0.05256907f, 
    -0.06010308f, -0.03174805f, 0.10232144f, 0.04628659f, 0.02829961f, 0.10280912f, -0.07156928f, -0.16559891f, 
    0.00180691f, -0.01406884f, -0.00593095f, -0.07260460f, 0.12754139f, -0.10091697f, 0.03856742f, 0.05165798f, 
    0.19021696f, -0.05466773f, 0.04443245f, -0.01143770f, -0.11806050f, -0.15391088f, 0.16476688f, -0.01394800f, 
    -0.26024574f, 0.16389818f, -0.01753676f, 0.14219619f, -0.04768214f, 0.04298884f, 0.05576655f, 0.03437035f, 
    0.10269484f, 0.03877720f, -0.06897496f, 0.12338764f, 0.04351180f, -0.01626203f, -0.10253485f, -0.14365804f, 
    -0.02505296f, -0.00111603f, 0.06615123f, 0.11003063f, 0.06649397f, -0.11041741f, 0.18390763f, -0.16397271f, 
    0.03864737f, -0.04965247f, 0.06934905f, 0.00779111f, 0.11246053f, -0.00247340f, 0.08025431f, 0.03015795f, 
    0.16502358f, 0.00897170f, 0.04939953f, -0.07137795f, 0.08326373f, 0.00302180f, 0.10439236f, -0.15569198f, 
    0.03955429f, -0.10087799f, -0.07075718f, 0.00250671f, 0.01741469f, -0.03821457f, 0.19069345f, 0.03822919f, 
    -0.01593968f, -0.12628135f, 0.07294019f, -0.19460408f, -0.05786088f, -0.12174077f, 0.01923600f, 0.07709242f, 
    0.10281322f, 0.02318710f, 0.03827687f, 0.00160772f, 0.29355845f, -0.03901552f, 0.11347014f, 0.07769445f, 
    0.02953091f, 0.03799753f, 0.05479285f, -0.02724525f, -0.02873159f, 0.13381366f, 0.01001430f, -0.05513810f, 
    0.15483586f, -0.12500457f, 0.20482971f, 0.08465174f, -0.00057477f, 0.03282404f, -0.06259198f, -0.06118087f, 
    0.06831784f, -0.05557949f, -0.11481386f, -0.14465506f, 0.06835464f, 0.05926903f, -0.11851493f, 0.02586492f, 
    0.00812217f, -0.03640058f, 0.06039061f, 0.00891311f, -0.04637861f, 0.05280676f, -0.03361279f, 0.07776853f, 
    0.11899976f, 0.17858715f, 0.00728456f, -0.04112436f, -0.16728142f, -0.07028332f, -0.01513286f, -0.02756572f, 
    -0.02484464f, -0.01949549f, 0.10552134f, -0.00514193f, -0.11698415f, -0.00497843f, 0.12521607f, -0.13684158f, 
    -0.04227705f, -0.09247451f, -0.04481396f, 0.03178730f, 0.10678813f, 0.03181597f, 0.05288187f, 0.01443085f, 
    0.35285777f, 0.15248874f, 0.12230078f, -0.01807238f, -0.01630657f, -0.04879933f, -0.07864609f, -0.00860018f, 
    -0.00216264f, 0.02859502f, 0.24684244f, 0.18110220f, 0.07811234f, 0.01474861f, 0.04076283f, 0.00919707f, 
    -0.00616710f, -0.16223797f, 0.07453067f, 0.01517909f, 0.06050933f, 0.05183410f, 0.03450602f, 0.05874209f, 
    0.08607847f, 0.13849203f, -0.06328199f, -0.10498221f, 0.09645663f, -0.08293417f, 0.01992415f, -0.04693653f, 
    -0.09383572f, 0.05944023f, 0.01372680f, 0.02049647f, -0.09781967f, -0.02205910f, -0.42106390f, -0.09033791f, 
    0.06234206f, 0.03718155f, 0.06938787f, 0.05906229f, -0.04564019f, -0.02883536f, 0.12992160f, 0.05922193f, 
    0.10193400f, 0.20091856f, -0.07002253f, 0.02344678f, -0.10776161f, 0.00830753f, 0.15125033f, 0.05176907f, 
    0.01849137f, 0.00554599f, 0.00660469f, -0.10346399f, 0.05170162f, -0.21231389f, -0.36690679f, 0.11493747f, 
    0.05879306f, 0.09019624f, 0.14593218f, 0.06283602f, 0.04927524f, 0.07309842f, -0.00679832f, -0.00088165f, 
    0.09241719f, -0.06433056f, 0.09460128f, 0.06923343f, 0.08837498f, 0.02026636f, 0.04885008f, -0.00590143f, 
    0.06573122f, -0.01973775f, 0.17128327f, 0.05609943f, -0.06302205f, 0.07275068f, 0.07842948f, -0.13016613f, 
    0.05281240f, -0.09906729f, -0.36801520f, 0.03323373f, -0.13106456f, -0.06322449f, -0.05241654f, 0.18484148f, 
    -0.06706820f, -0.02684165f, -0.13453683f, -0.02322991f, -0.04205547f, -0.07213691f, 0.09216071f, -0.00252696f, 
    0.03525390f, -0.10503166f, 0.00311814f, -0.14757502f, -0.25861400f, -0.38368639f, 0.36939502f, -0.06493259f, 
    0.06779402f, 0.03276055f, -0.04636572f, 0.08871540f, -0.01049919f, -0.03863135f, 0.03571795f, 0.08794650f, 
    0.02297408f, 0.03318626f, -0.11368638f, 0.03152031f, 0.07398543f, -0.00628474f, -0.00321513f, 0.13595901f, 
    0.04451475f, 0.02785857f, -0.03029162f, -0.09881430f, 0.00527968f, 0.08094401f, -0.20355326f, -0.24943852f, 
    -0.06443041f, -0.24788414f, 0.11272580f, -0.05443580f, 0.07214568f, -0.03549777f, -0.08077504f, -0.04072134f, 
    -0.19186746f, 0.11651461f, -0.18121895f, 0.02017655f, -0.01975788f, 0.06313917f, -0.02534962f, 0.03607555f, 
    0.06014943f, -0.04248885f, 0.02138568f, -0.02244027f, 0.15323156f, 0.01853731f, -0.04020682f, -0.04051686f, 
    -0.07068575f, 0.02108473f, 0.01260145f, -0.00443308f, -0.00281006f, -0.08472642f, 0.02157766f, -0.04226346f, 
    0.11686949f, -0.11904617f, 0.13708748f, -0.06550859f, -0.15395752f, 0.02938401f, -0.26482508f, -0.02424436f, 
    0.10370341f, 0.02960215f, 0.10010140f, -0.07899670f, 0.05305069f, -0.00853890f, -0.01205336f, -0.07798389f, 
    -0.25737044f, -0.05834978f, 0.23172119f, -0.02076637f, 0.05878171f, 0.02844562f, 0.07216576f, -0.11993754f, 
    0.08711307f, 0.04269755f, 0.02937088f, -0.00354104f, 0.04404090f, 0.00415447f, -0.08929463f, 0.04031285f, 
    0.02178325f, -0.02874584f, 0.03616905f, -0.16906174f, 0.01892858f, -0.06928569f, -0.09167263f, -0.12153649f, 
    0.01429118f, -0.00030116f, 0.02642730f, -0.06336606f, 0.01951262f, -0.07020379f, 0.12216892f, 0.02315830f, 
    0.16235541f, 0.03667663f, -0.04016743f, -0.02826175f, 0.05826849f, -0.00924693f, 0.08703122f, -0.01081684f, 
    0.10468659f, 0.08475538f, -0.10601591f, -0.10626840f, -0.00159060f, 0.12670875f, 0.08915231f, -0.29149094f, 
    0.03763013f, -0.13452610f, -0.10062357f, 0.13600351f, 0.04957779f, 0.13016482f, -0.05893166f, 0.11556239f, 
    0.05982476f, 0.15702334f, 0.01331046f, 0.07137603f, 0.11507849f, -0.03227052f, 0.05851604f, -0.01457583f, 
    0.07027536f, -0.13291207f, -0.10107268f, -0.06070504f, 0.10306834f, 0.06022602f, -0.03488935f, -0.10212472f, 
    -0.17962508f, 0.03137251f, 0.05080846f, -0.03746175f, 0.02064381f, 0.05429754f, -0.13983634f, 0.21849902f, 
    0.06294533f, -0.24867330f, -0.42057440f, -0.13182677f, -0.10230296f, -0.05312056f, 0.06949051f, 0.16761775f, 
    0.00706320f, 0.02798776f, -0.00631345f, 0.02806422f, 0.19105718f, -0.03382668f, 0.25630853f, 0.03093435f, 
    0.01256126f, -0.02334532f, 0.01844386f, -0.05484938f, -0.04185382f, 0.01300536f, 0.10085777f, -0.01417721f, 
    -0.09601796f, -0.11316341f, -0.02342533f, 0.12770921f, -0.05581499f, 0.12493488f, -0.07352911f, 0.07529008f, 
    -0.01369974f, -0.08157653f, -0.11038157f, 0.12867664f, -0.08368628f, -0.20837821f, -0.30502144f, 0.11758007f, 
    -0.02483982f, 0.05722022f, 0.10091689f, -0.05338606f, 0.07251050f, 0.07375184f, -0.04739648f, -0.07957840f, 
    0.03717729f, 0.02115162f, -0.17535464f, -0.16551226f, 0.06981396f, 0.10344912f, 0.08967654f, 0.21436737f, 
    -0.05302213f, -0.04345771f, -0.00475252f, 0.10999165f, 0.24781145f, 0.10728306f, -0.42756855f, 0.11341880f, 
    -0.22785525f, -0.01790231f, 0.06184123f, 0.06238388f, 0.02276550f, 0.01161230f, -0.08893607f, 0.11414937f, 
    0.22044078f, 0.10014340f, 0.19797395f, 0.10871006f, -0.12031958f, 0.00035698f, -0.08675717f, -0.06550356f, 
    -0.05172814f, -0.11018017f, -0.01378317f, -0.04218153f, 0.04978260f, 0.07778113f, 0.06357442f, -0.02609488f, 
    0.04419743f, 0.06609108f, -0.08041245f, -0.01777030f, 0.04499263f, -0.06564471f, 0.30759197f, -0.04190824f, 
    0.17704383f, -0.40072393f, 0.05933770f, -0.03233346f, -0.05399089f, 0.30454743f, 0.03979100f, 0.04556301f, 
    -0.04538777f, 0.07132699f, 0.01440866f, -0.16166112f, 0.04491371f, -0.28866503f, 0.27701893f, -0.14687710f, 
    0.08318973f, 0.13997601f, -0.00958668f, -0.02719133f, -0.00235245f, -0.01196363f, 0.14416799f, -0.10013783f, 
    -0.23617214f, -0.15209812f, 0.20549874f, 0.02800143f, 0.11273248f, 0.01764815f, -0.04824518f, 0.06377768f, 
    0.01761729f, -0.10148545f, 0.00791758f, -0.17991890f, 0.05068508f, 0.27536756f, 0.11829016f, -0.01895490f, 
    -0.15491785f, -0.15241632f, -0.02387699f, -0.04809977f, 0.21007979f, 0.10394926f, -0.00945612f, -0.17217381f, 
    -0.24124016f, 0.09129472f, 0.07737254f, 0.06228384f, -0.15259136f, 0.07449625f, 0.05795788f, 0.05606154f, 
    0.10241177f, -0.06473324f, -0.02220445f, -0.14122319f, 0.09593344f, 0.27995583f, -0.04265642f, -0.06127754f, 
    0.01900452f, 0.02297515f, 0.02425236f, 0.03381748f, -0.01296643f, 0.06346884f, -0.08562090f, -0.01983569f, 
    -0.13423805f, 0.03063396f, -0.03245583f, 0.09640314f, -0.06006670f, -0.06749147f, 0.04557725f, -0.00748214f, 
    0.19994366f, -0.11061805f, -0.04602712f, 0.17639092f, 0.12544456f, -0.53736442f, -0.04619025f, 0.06093587f, 
    0.22606055f, 0.15958975f, 0.20607598f, 0.28147009f, 0.07019217f, 0.00422254f, -0.02916480f, 0.06370097f, 
    -0.17573962f, 0.03765284f, 0.34796712f, -0.19361478f, 0.09842518f, 0.03274566f, -0.07886506f, 0.01884473f, 
    -0.05389786f, 0.04884537f, -0.05689696f, -0.16323994f, -0.03924449f, 0.04237457f, 0.10905339f, 0.02193887f, 
    -0.02250056f, -0.15571614f, 0.07795266f, -0.14246263f, 0.14862762f, 0.09522904f, -0.08642687f, 0.04416736f, 
    -0.04620172f, 0.21928304f, -0.26635215f, 0.00568544f, -0.03162768f, -0.08639463f, 0.20437469f, -0.05687660f, 
    0.02826460f, -0.02194757f, 0.12854689f, -0.00891717f, 0.24966255f, -0.43436059f, -0.17158814f, 0.35520333f, 
    -0.11481133f, 0.22540036f, -0.10063026f, -0.04081694f, 0.06664015f, 0.03027735f, -0.05450071f, -0.07850377f, 
    -0.09064116f, -0.14291501f, 0.01601838f, -0.04791100f, -0.01059199f, -0.12843525f, 0.09618861f, 0.10072598f, 
    -0.04006349f, -0.03244097f, -0.08334240f, 0.07818317f, 0.08026320f, -0.31247705f, 0.00828432f, 0.05680620f, 
    -0.00246673f, -0.07807954f, 0.08823349f, 0.05866472f, -0.01312562f, 0.04460083f, 0.00366425f, 0.01489011f, 
    0.16727610f, 0.09750737f, -0.13746589f, 0.05386489f, 0.12232604f, 0.08180710f, -0.05274877f, 0.13876309f, 
    -0.08325332f, -0.05450799f, 0.11631697f, 0.05841681f, -0.08709389f, 0.02105697f, 0.02166121f, -0.05525414f, 
    -0.03189526f, -0.07659321f, -0.05719288f, -0.03639967f, 0.07406519f, -0.03792183f, 0.02100757f, -0.02035121f, 
    -0.22011220f, -0.10738177f, 0.03224074f, -0.04636466f, -0.08737742f, 0.01570484f, 0.05960182f, -0.00014254f, 
    -0.02748332f, -0.05837415f, 0.08986054f, -0.12390918f, 0.11820754f, -0.20904820f, 0.17913483f, 0.10000916f, 
    0.02015319f, 0.15297207f, -0.00604468f, -0.05357192f, 0.06057757f, -0.01034235f, -0.07431833f, -0.16378707f, 
    0.02653441f, 0.01030283f, -0.00015620f, 0.00965164f, -0.03009877f, -0.19271535f, -0.01691562f, -0.04276840f, 
    0.01617315f, 0.03286057f, 0.02062590f, -0.00179826f, 0.01343143f, -0.02557900f, -0.00229869f, -0.14474413f, 
    0.09850520f, -0.12381182f, -0.04333827f, -0.02616435f, 0.00010657f, -0.04213064f, 0.06018242f, 0.01109439f, 
    0.02189883f, 0.12346711f, 0.15690461f, -0.22181275f, 0.02025461f, -0.02872980f, -0.00189383f, 0.08482540f, 
    -0.04090964f, 0.01277328f, 0.02008885f, 0.04338559f, -0.08905768f, -0.29353923f, 0.35902676f, -0.17696115f, 
    0.05577989f, -0.00962732f, 0.01030196f, -0.07302222f, -0.11166532f, 0.00111666f, 0.14093557f, 0.04207087f, 
    -0.01940004f, -0.10124233f, 0.00141040f, -0.00766561f, -0.03185600f, -0.01279938f, 0.05372264f, 0.10156658f, 
    0.09096584f, -0.02918894f, -0.11870657f, -0.01615152f, -0.09708474f, -0.17724115f, 0.08697086f, 0.07220359f, 
    -0.09009565f, 0.04696755f, -0.05655725f, -0.15158513f, -0.05279986f, 0.14670293f, 0.01692220f, -0.05098925f, 
    -0.02525974f, -0.28927386f, 0.13503154f, -0.15057099f, -0.09686241f, -0.10241751f, 0.30346256f, -0.03708846f, 
    0.06718487f, -0.00086586f, 0.06595974f, 0.08137444f, 0.29084855f, 0.01351865f, 0.10861403f, 0.05400831f, 
    0.03236958f, 0.03380610f, 0.06833252f, 0.08874553f, -0.00602759f, -0.01649312f, 0.07936402f, -0.14104632f, 
    -0.05953760f, 0.01364067f, -0.12082750f, 0.13816644f, -0.09775701f, 0.11362000f, -0.06680933f, -0.08644056f, 
    0.00318898f, -0.04543837f, 0.00790658f, -0.09852163f, 0.14596318f, 0.16265456f, -0.00223747f, 0.12931827f, 
    -0.02868701f, 0.05265504f, -0.03434919f, -0.11634764f, -0.12021334f, 0.05400856f, -0.05738305f, -0.06293733f, 
    0.02009542f, 0.16865982f, 0.22297831f, -0.04596849f, -0.16739395f, 0.00754306f, 0.01773909f, -0.08723991f, 
    -0.19916876f, -0.00187343f, -0.03550979f, -0.03929287f, -0.18334587f, 0.26880929f, -0.25138208f, 0.26839858f, 
    0.00494969f, -0.09558872f, 0.19931823f, -0.22796300f, -0.03575787f, -0.03364481f, 0.05163285f, -0.05817919f, 
    -0.14986378f, 0.22289969f, -0.24614030f, 0.46622497f, 0.00834906f, -0.13495699f, -0.05378999f, -0.07988314f, 
    -0.05653773f, -0.00279061f, 0.01927793f, 0.01036683f, 0.11675519f, 0.06047983f, 0.12947790f, 0.06513821f, 
    -0.06052592f, -0.04131180f, -0.12378456f, 0.03899329f, 0.04015100f, -0.02061259f, -0.03853700f, -0.07336889f, 
    -0.12934966f, 0.17347661f, -0.02205819f, 0.15547721f, 0.02373249f, -0.10977565f, 0.00984521f, -0.01158766f, 
    0.06236450f, -0.00150562f, 0.04290332f, -0.01350585f, -0.24261953f, -0.10305485f, 0.01752687f, -0.34206215f, 
    -0.03113153f, -0.23715787f, -0.06505017f, 0.05767548f, 0.09712926f, 0.06419586f, 0.04152967f, -0.04690483f, 
    0.07700581f, -0.08674370f, -0.09390783f, -0.23865625f, -0.01152781f, -0.19205865f, -0.02578163f, -0.03951012f, 
    -0.05842164f, -0.00393603f, 0.09029686f, 0.01288129f, 0.08051769f, 0.08460286f, -0.07552180f, 0.03132667f, 
    0.00064376f, 0.05198345f, 0.05071935f, 0.09759534f, -0.01451711f, -0.06033249f, 0.06281195f, -0.10833340f, 
    -0.21641827f, 0.20935988f, -0.08988252f, 0.46993512f, 0.10409353f, -0.00093985f, -0.08866969f, 0.03631205f, 
    -0.04182884f, 0.00466331f, 0.01103760f, 0.13755468f, 0.01114337f, 0.05567614f, -0.12349861f, -0.06592499f, 
    -0.01719162f, -0.00372044f, 0.10399779f, -0.10733179f, -0.04057336f, -0.02745912f, 0.01223559f, -0.02377109f, 
    0.33046916f, 0.14472106f, 0.05214179f, 0.05058798f, -0.06312295f, 0.07793942f, -0.16555943f, 0.10647564f, 
    0.00398298f, 0.11072244f, 0.07793496f, -0.03077128f, 0.51922643f, 0.09492132f, 0.06974471f, 0.03489248f, 
    -0.10888238f, -0.03210677f, -0.07003122f, 0.03343074f, -0.05201937f, -0.06382714f, -0.04450438f, -0.07234663f, 
    -0.04478109f, 0.13354908f, -0.07217264f, 0.15505745f, -0.07463393f, -0.02957205f, 0.04426143f, -0.09913248f, 
    0.10002637f, -0.03773232f, 0.03172734f, -0.03782735f, 0.21116780f, -0.22659430f, -0.00777526f, -0.12192611f, 
    0.05144113f, -0.17440876f, -0.15074319f, 0.04101889f, 0.10420106f, 0.13738573f, -0.12337328f, -0.10320357f, 
    0.30235302f, 0.11452039f, 0.14121129f, -0.07365606f, -0.00267009f, 0.13477811f, -0.02545840f, 0.15403715f, 
    -0.06287672f, 0.03506749f, 0.02218683f, -0.03694582f, -0.30342048f, -0.08548277f, -0.16625896f, 0.16983998f, 
    -0.01083459f, 0.20914468f, -0.04008600f, -0.06141621f, 0.03476389f, -0.01791935f, -0.01474061f, 0.11212644f, 
    0.11132734f, 0.03023215f, 0.08861355f, -0.09511425f, -0.05868027f, 0.17388800f, -0.01388691f, 0.08338924f, 
    -0.06268859f, -0.09693862f, 0.02105561f, -0.16009492f, 0.24061058f, -0.04877936f, 0.24526611f, 0.16893263f, 
    0.22575565f, 0.02471239f, 0.13406649f, 0.16868283f, -0.08560229f, -0.01781730f, -0.06282371f, 0.00650875f, 
    0.47111163f, 0.01392926f, 0.23274575f, -0.17676173f, -0.01079733f, -0.06290766f, -0.07993258f, 0.02790135f, 
    0.06473807f, 0.01032614f, -0.04643103f, -0.04767261f, -0.44828132f, 0.17181964f, 0.08270415f, -0.05118671f, 
    0.12582362f, -0.12039450f, 0.12959738f, -0.20985663f, -0.05640147f, 0.00466559f, 0.18290779f, -0.12379714f, 
    0.13135076f, -0.13502334f, 0.11561545f, -0.00100402f, 0.11412290f, 0.24735302f, -0.18184812f, 0.13683771f, 
    0.02123896f, -0.14542058f, 0.23952051f, -0.15026426f, 0.00425493f, -0.12985700f, -0.01239614f, 0.11438592f, 
    -0.03961200f, -0.00064806f, 0.38881549f, -0.07821880f, -0.12299762f, 0.13318136f, 0.12325910f, -0.01370127f, 
    0.00151430f, 0.02712183f, 0.18065009f, -0.00618658f, 0.09521856f, 0.07072311f, 0.01080519f, 0.03368286f, 
    -0.01996408f, 0.13301699f, 0.09186073f, -0.03093722f, -0.23976450f, 0.41875356f, -0.17189696f, -0.12852676f, 
    -0.02410752f, -0.04568732f, 0.07092427f, -0.20181368f, -0.13784951f, -0.06821080f, 0.03775370f, -0.00765638f, 
    0.08093334f, -0.00808745f, 0.07057690f, 0.06515109f, -0.12555979f, -0.15575661f, -0.10187571f, 0.02018146f, 
    -0.12789492f, 0.01594284f, -0.12371872f, -0.14006124f, 0.07828076f, 0.05718957f, -0.16572800f, -0.28500155f, 
    0.02192298f, -0.09670208f, -0.01452575f, 0.02998639f, 0.12100605f, 0.13376425f, -0.01981750f, -0.04045892f, 
    -0.03402883f, 0.01241826f, -0.02731800f, 0.27236825f, -0.01743355f, -0.01283618f, -0.19799948f, 0.16715568f, 
    -0.04138305f, 0.01392181f, -0.07374404f, 0.08066314f, -0.10915893f, 0.03065066f, -0.19715828f, 0.03200497f, 
    0.07141701f, 0.03813728f, 0.04456098f, -0.09693917f, -0.04558735f, 0.22212550f, 0.13355966f, 0.08560667f, 
    -0.15072571f, 0.22829196f, -0.04842307f, 0.00692149f, -0.04566267f, 0.00793836f, 0.03166153f, -0.00152528f, 
    -0.17810167f, -0.01159367f, 0.08754701f, -0.09909066f, -0.19621052f, 0.49182650f, -0.02127617f, 0.02777364f, 
    -0.00089197f, -0.06559125f, -0.01559274f, 0.01801123f, -0.06306431f, -0.01039082f, 0.11213972f, 0.02774992f, 
    -0.08755809f, -0.20366353f, 0.11541561f, 0.06667997f, 0.13427936f, 0.04422482f, 0.04184521f, 0.10889018f, 
    0.06031379f, 0.10050477f, -0.01742542f, 0.10254030f, 0.42596003f, 0.07873253f, 0.04882528f, 0.27722657f, 
    -0.01183828f, -0.02768134f, 0.12686537f, 0.04022279f, -0.03033637f, 0.11961973f, -0.04797270f, -0.00613475f, 
    -0.01590073f, -0.02148735f, -0.06150487f, 0.16700491f, -0.10301296f, 0.05315180f, 0.01342029f, -0.14443867f, 
    0.04958937f, 0.01744507f, 0.16591382f, -0.03521870f, 0.29162049f, 0.03130840f, 0.03507337f, 0.22246061f, 
    0.08301619f, 0.02287131f, 0.11848959f, -0.06746538f, -0.14680852f, 0.04039728f, 0.02109696f, -0.02500826f, 
    -0.21446629f, 0.11811343f, -0.18412971f, 0.14425559f, -0.01704401f, -0.04661794f, -0.02819376f, -0.10127567f, 
    -0.08453370f, -0.06666532f, 0.01762948f, 0.12233265f, -0.04481044f, -0.15880814f, 0.17597465f, -0.09755488f, 
    -0.08275887f, 0.09697899f, -0.02694398f, 0.12978895f, 0.05005103f, 0.04023293f, 0.05475465f, -0.21547528f, 
    -0.11114458f, 0.03734852f, -0.15477884f, -0.07085888f, 0.17165489f, -0.07212088f, 0.26624635f, 0.02248292f, 
    0.06961108f, -0.04903914f, 0.16317268f, 0.02440801f, 0.24260513f, 0.11793113f, -0.15861671f, 0.17247219f, 
    -0.02651147f, 0.01918775f, 0.02544835f, 0.24395370f, 0.01579476f, -0.02378016f, -0.00962984f, 0.03239234f, 
    0.27670756f, -0.24484868f, 0.04464999f, 0.13443780f, 0.02339914f, 0.20332952f, -0.02374437f, 0.30369824f, 
    -0.12336139f, -0.10262427f, 0.06019209f, -0.02367124f, -0.34497282f, -0.02393372f, 0.14828183f, -0.17987688f, 
    -0.00684267f, -0.09580531f, 0.07995801f, 0.04445820f, 0.03352299f, 0.13368544f, 0.12477686f, -0.00970117f, 
    -0.10871707f, -0.12774818f, 0.41873816f, -0.00735064f, 0.01608826f, -0.02892244f, 0.21106784f, -0.09635368f, 
    0.02767740f, 0.01930546f, -0.12569232f, -0.10451785f, 0.03433233f, 0.20353532f, 0.09124532f, 0.06570762f, 
    -0.07283428f, -0.12730572f, -0.10148912f, 0.02534322f, -0.00887256f, 0.02371853f, -0.03540058f, 0.11326799f, 
    -0.11535712f, -0.08144001f, 0.29773113f, -0.25865704f, -0.07659971f, 0.06832352f, -0.17448345f, 0.08376191f, 
    -0.02857007f, -0.04543551f, -0.01225385f, 0.02052506f, 0.34213325f, 0.06020713f, 0.01213715f, 0.01926344f, 
    -0.15065296f, -0.02174854f, 0.09071065f, 0.19545184f, -0.06569398f, -0.05031937f, 0.01391337f, 0.07733355f, 
    0.14043419f, 0.10775933f, 0.06455943f, 0.05701306f, 0.01609967f, 0.12495778f, -0.05775713f, 0.15694538f, 
    0.08651194f, -0.02489284f, 0.10035974f, -0.01507039f, 0.03332388f, -0.15851237f, 0.26486984f, 0.02889656f, 
    -0.01553261f, 0.09601880f, -0.10232486f, 0.06790210f, -0.08522708f, -0.01986875f, -0.09605197f, -0.11708735f, 
    0.40403643f, 0.14090924f, -0.18959741f, 0.14871539f, 0.09733903f, -0.03598182f, -0.00495285f, 0.06591430f, 
    -0.10599038f, -0.12450474f, -0.05924409f, -0.08631109f, 0.05458961f, -0.27618602f, 0.15230022f, -0.01746240f, 
    0.03861490f, 0.08053441f, -0.01387759f, -0.05255065f, -0.01003173f, 0.10272917f, -0.14204970f, -0.08672816f, 
    0.17243220f, -0.06294425f, 0.07856379f, 0.10206589f, 0.07236826f, 0.03186928f, -0.14568807f, 0.17680684f, 
    -0.02838679f, -0.04510818f, 0.10425156f, -0.01572783f, 0.02041272f, -0.06696123f, 0.05116341f, 0.07096555f, 
    -0.01872503f, 0.07169547f, 0.12724990f, 0.05051234f, -0.02203315f, 0.03765626f, 0.07363053f, -0.05774358f, 
    0.07778249f, 0.02149344f, -0.02114428f, -0.05521310f, -0.14742450f, -0.05142131f, -0.11124703f, 0.12848017f, 
    -0.06723707f, 0.12543981f, 0.02436722f, 0.09374347f, 0.01878861f, -0.01102835f, 0.29067540f, 0.02461192f, 
    -0.23032875f, -0.06698376f, 0.05243568f, -0.03790361f, -0.12783709f, -0.09007727f, -0.14431271f, -0.16494077f, 
    0.02857245f, -0.18188778f, 0.10082395f, 0.05185029f, -0.12551703f, -0.07986170f, 0.00179086f, 0.03347693f, 
    0.01399515f, -0.04636435f, 0.04876952f, 0.03806093f, -0.09046369f, -0.04699719f, -0.09839015f, 0.19848263f, 
    -0.11618691f, -0.09091508f, -0.11188900f, -0.08740517f, 0.09526043f, -0.00466862f, -0.04407880f, 0.00828490f, 
    -0.04310081f, -0.02694923f, -0.03117250f, 0.02125152f, -0.03289240f, 0.03151655f, -0.01633606f, 0.00079560f, 
    -0.01269626f, 0.02296653f, -0.01202587f, -0.02464647f, 0.01280172f, -0.02103369f, -0.03246759f, -0.04197421f, 
    0.00108839f, 0.02094765f, 0.00934614f, 0.02231294f, -0.00046812f, -0.01898090f, -0.04357718f, -0.03382680f, 
    0.02072138f, -0.02935379f, -0.00917200f, -0.01387985f, -0.01519307f, -0.00851578f, -0.00262097f, 0.02647437f, 
    0.01645408f, -0.00056616f, 0.01816823f, -0.01874381f, 0.02513538f, 0.02954484f, -0.02663884f, 0.00500353f, 
    0.00679782f, -0.03466428f, 0.02131979f, -0.00826739f, -0.04059966f, 0.00638706f, 0.01510723f, -0.02476693f, 
    0.01755368f, 0.01574211f, 0.02736606f, -0.00683821f, -0.00504620f, 0.00188622f, 0.01854171f, -0.00900798f, 
    0.03370587f, -0.01915809f, 0.00800743f, -0.01297246f, -0.04223212f, 0.02299134f, 0.01015890f, 0.02577361f, 
    0.02997586f, -0.00358323f, -0.03434229f, -0.03070339f, -0.01004732f, -0.01931338f, 0.00311761f, -0.01233089f, 
    -0.02720987f, -0.02459094f, 0.02412227f, 0.01754483f, 0.00902879f, -0.00524697f, 0.02683433f, 0.01256396f, 
    0.00174699f, 0.02871084f, -0.02983326f, 0.02404154f, 0.00952730f, 0.00444567f, 0.02064066f, -0.00806360f, 
    -0.03562319f, 0.03376902f, -0.02259473f, -0.02742510f, -0.02929482f, 0.03167362f, -0.00322855f, -0.02438732f, 
    -0.00312570f, 0.02486953f, 0.00513501f, -0.01441170f, 0.00246321f, -0.02301751f, -0.04103823f, -0.01651818f, 
    -0.01358631f, 0.01955608f, 0.02021721f, 0.00513838f, -0.01389621f, 0.00008675f, 0.00110936f, -0.03455140f, 
    -0.02061030f, -0.03496419f, -0.00034245f, 0.01197855f, 0.01196703f, -0.00549482f, -0.00650154f, 0.00767256f, 
    0.03020060f, 0.01981155f, 0.00484346f, 0.00276313f, -0.02199357f, 0.01976897f, 0.00935255f, 0.02961193f, 
    0.00695907f, -0.00841989f, -0.02939098f, -0.01136105f, -0.00287895f, -0.03199551f, -0.00098676f, -0.03680403f, 
    -0.02257357f, -0.02506823f, -0.04417312f, 0.01696273f, 0.02870051f, -0.00415223f, -0.02652763f, -0.04242301f, 
    -0.02696938f, -0.00104744f, 0.02911437f, -0.02345201f, -0.02398125f, -0.03567687f, -0.02933936f, -0.02214786f, 
    0.00511359f, -0.03775846f, 0.02780207f, -0.01288142f, -0.01207301f, -0.00710827f, 0.02001500f, 0.00393298f, 
    0.00435175f, -0.02286625f, -0.02454861f, -0.03103180f, -0.01625585f, -0.03379078f, -0.01528782f, 0.03194585f, 
    0.02345465f, 0.02845918f, 0.01353757f, -0.02021918f, -0.02705881f, -0.01011822f, -0.00010543f, 0.01233873f, 
    0.01465759f, 0.01978026f, 0.01719401f, 0.01346829f, -0.00210897f, -0.01203336f, -0.03416824f, 0.00805920f, 
    0.01341262f, -0.00498383f, -0.00802690f, 0.02744877f, 0.02392887f, 0.02662459f, -0.00893311f, -0.03471633f, 
    -0.02528997f, 0.00810242f, 0.00475478f, 0.03274388f, -0.01920165f, 0.00164532f, -0.00883533f, 0.02551338f, 
    -0.01133578f, -0.02915584f, -0.01875993f, -0.00264829f, -0.01924814f, -0.00726658f, -0.02652253f, -0.04192185f, 
    -0.03256595f, -0.03099537f, -0.01949318f, -0.01198546f, -0.01635649f, -0.00844422f, -0.03618282f, -0.02360354f, 
    0.02099635f, -0.03076199f, -0.02479479f, -0.01967716f, 0.01289843f, 0.00667360f, 0.00702348f, -0.02033707f, 
    -0.02706209f, -0.03040336f, -0.03285391f, -0.02460638f, -0.03355104f, -0.01577760f, -0.02670051f, -0.00125983f, 
    -0.01362549f, 0.01279059f, 0.00056025f, -0.01756723f, -0.02433377f, 0.01489321f, 0.01511430f, 0.02383738f, 
    0.01067931f, 0.00765137f, -0.01694062f, -0.02952163f, 0.00722816f, 0.00104936f, 0.02972561f, -0.03229231f, 
    -0.00855695f, 0.00492008f, 0.00782367f, -0.02903019f, -0.01758082f, 0.00223337f, -0.02146442f, 0.02226672f, 
    0.01348432f, -0.00520504f, -0.02348739f, -0.01043951f, -0.03418226f, -0.04083796f, 0.02355431f, 0.02052529f, 
    0.00067949f, -0.01998611f, 0.00237043f, 0.00226686f, 0.02604166f, -0.02239495f, -0.02174660f, -0.00078110f, 
    -0.01198645f, -0.00361042f, 0.01656841f, 0.00821441f, -0.01012711f, 0.02576836f, 0.01392158f, -0.02895550f, 
    0.01077822f, -0.01417062f, -0.01603026f, 0.01415208f, 0.03402082f, 0.02785064f, 0.01951167f, 0.00118948f, 
    0.03237690f, 0.01799574f, 0.01675825f, 0.00206739f, 0.02863466f, 0.02094568f, 0.00230616f, 0.00070041f, 
    0.01031638f, 0.00773176f, 0.02102089f, -0.00854311f, -0.01008882f, -0.00468051f, -0.03418015f, 0.03188410f, 
    0.01479494f, 0.02244693f, 0.00923008f, -0.01228581f, 0.00444391f, -0.02063560f, 0.00852326f, -0.00478050f, 
    -0.02351315f, 0.02103108f, -0.03183605f, 0.01091586f, -0.02452062f, -0.03579888f, 0.00285414f, -0.03066064f, 
    -0.04279047f, -0.02535125f, -0.02998604f, -0.01629981f, 0.00390587f, 0.02563380f, 0.03108259f, 0.00335143f, 
    0.00073745f, -0.01974872f, -0.02985019f, -0.02701413f, -0.01102696f, -0.03917275f, -0.02407218f, 0.01725434f, 
    -0.00079174f, 0.02005797f, -0.03769810f, 0.00070592f, -0.01728326f, -0.02393585f, 0.00617739f, -0.01848309f, 
    -0.02296595f, -0.02997118f, -0.02647614f, -0.01671718f, 0.02918256f, -0.00153651f, 0.00716477f, -0.00009074f, 
    0.01428545f, -0.02071575f, -0.00194365f, 0.01799789f, -0.01109964f, 0.01457814f, -0.02316706f, -0.03449359f, 
    -0.00147177f, 0.01885275f, 0.02795359f, -0.02276315f, -0.03389075f, 0.02845535f, 0.01305601f, 0.00870251f, 
    0.01895577f, -0.02259332f, 0.01607599f, -0.03265724f, 0.00189796f, -0.01961192f, 0.00629811f, -0.01012425f, 
    -0.03343736f, 0.01764730f, -0.01441831f, 0.00143194f, -0.01046453f, -0.02716199f, -0.00338837f, -0.01027549f, 
    -0.03578392f, -0.03049809f, -0.02121482f, 0.00430905f, -0.03773789f, -0.03057818f, 0.00546305f, -0.01673064f, 
    -0.01723832f, -0.02961807f, 0.02379504f, 0.02650587f, 0.00103757f, -0.02868954f, 0.03045667f, 0.01205678f, 
    0.00371502f, -0.01524008f, -0.00181770f, -0.00369541f, -0.00059450f, 0.00389163f, 0.01439132f, -0.03532421f, 
    -0.00231066f, -0.00267122f, -0.02049424f, -0.03572245f, -0.03387506f, 0.02029431f, -0.03769634f, 0.00176890f, 
    0.00715591f, 0.00845050f, 0.01476249f, 0.02303168f, 0.00820061f, -0.04402609f, 0.01124514f, 0.01824170f, 
    -0.04483374f, -0.03203841f, -0.02923569f, -0.00447177f, -0.00930614f, 0.01315316f, 0.02021959f, 0.00548443f, 
    0.01101857f, 0.01613294f, -0.03294557f, 0.00487369f, 0.03415560f, -0.01231121f, -0.01627608f, 0.00515327f, 
    -0.00255932f, 0.02132630f, -0.00948368f, -0.02521483f, -0.02282299f, -0.03609461f, -0.03955688f, 0.03261578f, 
    0.01966911f, -0.02291790f, 0.00644196f, -0.01403635f, 0.01787180f, -0.03977663f, 0.01489123f, -0.00283938f, 
    -0.01919216f, -0.03239412f, -0.03163535f, 0.01939072f, 0.02615216f, 0.00338362f, -0.01455570f, -0.02325344f, 
    -0.00046882f, -0.00160054f, 0.00879405f, 0.01177799f, -0.01881548f, -0.01278399f, 0.01031353f, 0.01832509f, 
    -0.00184966f, 0.00062620f, 0.03036899f, 0.01744516f, -0.01328116f, 0.02913855f, -0.03642477f, -0.03814340f, 
    0.02117317f, -0.00784520f, -0.02786489f, -0.00297407f, 0.00354759f, 0.02151180f, -0.01907062f, 0.01128359f, 
    0.01527250f, -0.03225514f, -0.03171134f, -0.02589666f, 0.01897968f, 0.00879926f, 0.00797982f, 0.01852623f, 
    0.03085334f, 0.02943131f, 0.02802530f, -0.03836375f, -0.02082966f, -0.03644294f, -0.03714567f, -0.01156549f, 
    -0.00443674f, -0.03666524f, 0.03670024f, -0.03534685f, -0.01074649f, -0.00225442f, -0.02007260f, -0.00970292f, 
    -0.03273293f, 0.01222585f, 0.03221059f, -0.00720979f, 0.00512689f, 0.02171480f, 0.03234431f, -0.02757265f, 
    0.02687771f, -0.00148873f, -0.01068257f, -0.01006153f, -0.02759285f, 0.01278440f, -0.02071796f, 0.00372663f, 
    0.01829752f, 0.01560988f, 0.01550389f, -0.00054499f, 0.01720686f, -0.03127803f, 0.01818381f, 0.00004253f, 
    0.02353637f, -0.00961744f, 0.02397819f, -0.00524511f, -0.02382411f, -0.02841345f, -0.02051350f, -0.03317574f, 
    -0.02701280f, -0.02573784f, 0.00776871f, -0.02788712f, 0.01456341f, 0.00404280f, -0.01141343f, -0.00461305f, 
    0.01886626f, 0.01015182f, 0.02231641f, 0.00685292f, -0.02008359f, 0.02661302f, 0.00697230f, 0.03294325f, 
    -0.01225415f, -0.02262429f, 0.03247378f, 0.00713200f, 0.02600271f, 0.02980050f, -0.00827930f, -0.02486578f, 
    -0.03645109f, -0.01723902f, 0.01285260f, 0.03330486f, -0.01995016f, -0.01164209f, 0.01877699f, -0.00671978f, 
    0.00054186f, 0.01365575f, -0.01578171f, -0.04004131f, 0.00593215f, -0.03127068f, -0.03660345f, 0.00569358f, 
    -0.03198435f, -0.00429284f, -0.02060191f, 0.00827369f, -0.01630504f, -0.02272293f, 0.01873566f, -0.00129506f, 
    -0.02519209f, -0.00088490f, -0.00591741f, 0.01886647f, -0.00808117f, 0.01464903f, 0.00664960f, -0.01459052f, 
    -0.00293677f, -0.02708373f, -0.02342929f, -0.04116508f, -0.03771860f, 0.01958967f, 0.00383223f, 0.00003417f, 
    -0.04218825f, 0.02739586f, 0.01345878f, -0.02646390f, -0.02699153f, 0.02530242f, 0.03027739f, -0.00480812f, 
    -0.01981581f, 0.03386384f, -0.01860349f, 0.02495430f, 0.01773361f, -0.02937714f, 0.00297702f, 0.02923495f, 
    0.02314347f, 0.02258326f, -0.03088932f, 0.02230086f, -0.03411926f, 0.00942010f, 0.00946411f, 0.00231453f, 
    -0.03071755f, -0.01316043f, 0.02747159f, 0.00707565f, 0.01184083f, 0.00875101f, 0.00206724f, -0.03342116f, 
    0.00482509f, -0.03581219f, 0.01705852f, 0.01058486f, 0.01889924f, 0.00285717f, -0.00471328f, -0.01936118f, 
    -0.01657737f, 0.03045878f, -0.02214267f, -0.01330268f, -0.01561999f, 0.01403039f, -0.00155583f, -0.03676692f, 
    -0.01447615f, -0.02193824f, 0.02007083f, 0.00539413f, 0.00694574f, -0.01136677f, 0.01756349f, 0.00212030f, 
    -0.01552827f, 0.02531578f, -0.03115453f, 0.02080643f, 0.03334698f, 0.02576865f, 0.01367390f, -0.01260144f, 
    0.01901595f, 0.00723292f, -0.00120701f, -0.00121890f, -0.01650041f, 0.01858031f, 0.02445816f, -0.04080034f, 
    -0.02491812f, 0.01700921f, 0.03838027f, -0.02624734f, 0.02431819f, 0.01836117f, 0.02436529f, 0.01912059f, 
    -0.03653331f, 0.00664060f, -0.03989643f, 0.01805443f, 0.03169210f, -0.01879373f, -0.03057047f, -0.02069724f, 
    0.02173686f, -0.00954542f, 0.01482634f, -0.02206143f, 0.00839282f, 0.03025031f, -0.00542171f, -0.01708353f, 
    -0.03827366f, 0.02004291f, -0.01398036f, -0.04087213f, -0.02866060f, 0.01478903f, 0.02228720f, -0.00802011f, 
    0.02409146f, 0.01402833f, -0.02836068f, 0.01044419f, -0.01605801f, 0.02534948f, 0.02588016f, -0.03198998f, 
    0.01201628f, -0.01314976f, -0.03688829f, -0.03491444f, -0.01653132f, -0.00520658f, -0.01236569f, 0.02243331f, 
    -0.02083971f, 0.00927043f, -0.00771308f, -0.01594704f, -0.02447033f, 0.02097663f, -0.01833848f, 0.01903834f, 
    0.01412877f, 0.02433113f, 0.01058167f, -0.01673440f, 0.01297586f, -0.01170443f, 0.02364992f, 0.00770546f, 
    -0.04411206f, -0.02252314f, 0.00943265f, 0.01303277f, 0.00807587f, 0.00253565f, 0.00732734f, 0.01696264f, 
    -0.01870627f, -0.00947248f, 0.02656155f, -0.01902598f, -0.01532742f, 0.00167725f, -0.00342886f, -0.03743360f, 
    -0.00004443f, -0.03821476f, -0.03556915f, -0.03694913f, -0.01679503f, -0.00178762f, -0.01509289f, -0.01644039f, 
    -0.10614181f, 0.08441508f, -0.02269097f, 0.07841548f, 0.05200826f, 0.03578117f, 0.06875865f, 0.06625855f, 
    0.07280744f, -0.07875354f, -0.02742068f, -0.13859314f, -0.23577382f, 0.02165377f, 0.02867960f, -0.08029165f, 
    0.01148672f, -0.11451524f, 0.01141185f, 0.01730891f, 0.04404214f, -0.06513453f, 0.13857061f, 0.16755974f, 
    0.00210727f, 0.13229662f, 0.03310472f, -0.09509376f, 0.08004870f, 0.00766731f, -0.00194896f, -0.06167100f, 
    0.15420809f, 0.05750534f, 0.15554318f, 0.34543952f, -0.14712173f, 0.28269079f, -0.28871500f, 0.01127270f, 
    0.16328815f, 0.07249629f, -0.02247780f, -0.10156105f, 0.26333109f, -0.07706178f, 0.00544924f, 0.09697682f, 
    0.11758222f, -0.03296076f, 0.12352380f, 0.07915189f, -0.16301677f, 0.01590924f, 0.11142356f, -0.08332220f, 
    0.17978126f, 0.14250508f, 0.01872412f, 0.26358426f, -0.07805033f, -0.18342292f, 0.07568537f, 0.09428000f, 
    0.02969357f, 0.00715554f, -0.07144190f, 0.03622265f, 0.10469945f, -0.07761969f, 0.00705282f, -0.12145074f, 
    -0.46398088f, -0.05204998f, -0.07099590f, 0.06512293f, 0.05610466f, 0.00950773f, 0.00500769f, -0.15410371f, 
    0.07773018f, 0.04001546f, 0.18408652f, 0.24400724f, 0.09347203f, -0.12099420f, -0.03036521f, -0.01033026f, 
    0.16168045f, 0.12989318f, 0.03957250f, 0.02256594f, 0.03374008f, -0.05921803f, -0.09717850f, -0.03529099f, 
    0.03160933f, -0.04002855f, -0.02934318f, 0.02475481f, -0.03907367f, 0.09756449f, 0.02448866f, 0.04337303f, 
    0.14926127f, 0.09948694f, 0.13080917f, 0.08545263f, 0.02626668f, -0.01454258f, 0.00128817f, -0.14527877f, 
    0.11505338f, 0.01941941f, -0.04135411f, 0.02162746f, 0.05335175f, -0.07245682f, -0.04314769f, -0.02056214f, 
    -0.07018656f, 0.05902128f, 0.07692142f, -0.14295094f, 0.03655972f, -0.04575553f, 0.10396453f, 0.02442505f, 
    0.05750875f, -0.21829706f, 0.04699446f, -0.07855095f, 0.09496622f, 0.15539777f, 0.04904371f, 0.11222894f, 
    0.01791145f, 0.04450191f, -0.14628500f, -0.14497189f, 0.04894202f, 0.16663285f, 0.06843030f, 0.02191530f, 
    0.05037764f, -0.04242700f, 0.18639344f, 0.16226430f, -0.03956633f, 0.03344694f, -0.07809067f, -0.04648017f, 
    0.12940258f, -0.03513569f, 0.09430525f, -0.05534854f, -0.08442314f, 0.11412980f, 0.04677933f, -0.05920918f, 
    -0.04734462f, -0.09664574f, 0.11094482f, 0.13424575f, -0.00148203f, 0.00017715f, 0.03134648f, -0.01526750f, 
    0.01619935f, 0.07986868f, -0.00339468f, -0.01011004f, -0.15243699f, -0.15420388f, -0.00618983f, -0.05234323f, 
    0.05522050f, 0.06300948f, -0.01218503f, 0.08444169f, 0.00105358f, 0.16869874f, 0.13881649f, -0.12057530f, 
    -0.09167564f, -0.13801222f, -0.00035717f, -0.15770346f, -0.04220550f, 0.13791683f, 0.05752521f, 0.12788028f, 
    0.32922536f, 0.08341403f, 0.23809282f, 0.04580554f, -0.15932979f, -0.11647443f, -0.06781438f, -0.03094219f, 
    -0.04810661f, -0.00729000f, 0.06684899f, 0.03682845f, 0.10241609f, 0.05374791f, 0.09791660f, -0.04473592f, 
    0.11388955f, -0.00387139f, 0.05907002f, 0.10877634f, 0.00478704f, -0.01811831f, -0.07270908f, -0.04481756f, 
    0.07437449f, -0.15632674f, -0.00047032f, 0.05048298f, 0.09607752f, -0.13204275f, -0.04988620f, -0.01366104f, 
    -0.11442600f, 0.01371209f, -0.02826607f, -0.00073604f, -0.22284284f, -0.14578421f, -0.17458355f, -0.04760234f, 
    0.06557510f, -0.09267714f, -0.10228398f, 0.07166197f, 0.14678937f, -0.00597217f, 0.02377894f, 0.07618970f, 
    0.18879981f, 0.42017633f, 0.00975260f, -0.00906066f, -0.11700226f, 0.10887494f, 0.06344967f, 0.05745042f, 
    0.02246015f, -0.09365977f, -0.03943665f, -0.21233787f, 0.34522673f, -0.08782768f, -0.06960026f, 0.08263636f, 
    0.04495346f, 0.02842749f, 0.06228273f, 0.16358408f, -0.04014486f, -0.02704516f, -0.07638210f, -0.05020169f, 
    0.05489634f, -0.12604739f, 0.06405735f, 0.12927172f, -0.07665443f, 0.05502789f, 0.00117372f, 0.09756663f, 
    0.27553442f, 0.12316547f, 0.06812412f, 0.26793566f, 0.05811988f, 0.11060303f, 0.40617728f, -0.25482017f, 
    -0.15531120f, -0.15122727f, 0.10639948f, -0.17574652f, -0.10506702f, 0.13729483f, 0.17599539f, 0.06242266f, 
    0.22776525f, -0.21292123f, 0.02931826f, -0.01407224f, 0.06354668f, 0.02276222f, -0.02685132f, -0.05653581f, 
    0.12588878f, -0.05348409f, 0.03671867f, -0.05123645f, -0.10818616f, -0.20258254f, 0.03173983f, 0.06362655f, 
    0.01182489f, 0.15500388f, -0.04086432f, 0.13972899f, 0.16634735f, 0.09162018f, 0.05295394f, 0.07932411f, 
    0.12250487f, 0.00190146f, -0.01720694f, 0.10878913f, 0.05837980f, 0.13891672f, 0.09136386f, 0.08896130f, 
    -0.09613834f, -0.16169475f, -0.05388264f, -0.20380621f, 0.08215641f, 0.13376762f, 0.15191862f, -0.08119678f, 
    0.04603675f, -0.03049512f, -0.01863363f, 0.05202681f, 0.02239366f, 0.04874761f, 0.00378792f, -0.15625294f, 
    0.07070759f, 0.01696831f, -0.25192326f, -0.07647347f, 0.04875534f, -0.10637553f, 0.07914046f, 0.03622982f, 
    0.12911466f, 0.02868292f, 0.02232957f, 0.08430994f, -0.11965420f, 0.10212712f, -0.13832313f, 0.09514406f, 
    -0.02118563f, 0.19656023f, 0.08300556f, -0.10365961f, 0.15696108f, -0.11465463f, -0.07611835f, -0.24027343f, 
    -0.00540651f, -0.08928815f, -0.08173477f, -0.01552858f, 0.06834280f, 0.16439311f, -0.22592650f, 0.07798345f, 
    -0.17901942f, -0.03955457f, -0.17859139f, -0.10040862f, -0.19036391f, 0.25105226f, -0.16478969f, -0.05722575f, 
    -0.16066706f, 0.05480527f, -0.01462515f, -0.04271331f, -0.11658135f, -0.06536471f, -0.05940741f, -0.15680271f, 
    0.17176874f, 0.02127481f, -0.04302671f, -0.05802934f, 0.01412795f, 0.08133413f, 0.03155724f, 0.00417799f, 
    -0.05886398f, 0.09719565f, -0.03455229f, -0.16200887f, -0.13570522f, 0.12474941f, -0.08572109f, -0.24701047f, 
    0.04470642f, 0.04540950f, -0.00740864f, -0.08834577f, -0.00084822f, 0.03198088f, 0.04863217f, 0.05879482f, 
    0.18048684f, -0.12665977f, -0.05524620f, -0.08904487f, 0.05948847f, 0.04041335f, 0.10063442f, 0.01973444f, 
    -0.04362560f, -0.10437570f, -0.11322495f, -0.17022328f, -0.00699351f, 0.18008612f, 0.12982117f, -0.36527136f, 
    -0.03892319f, -0.16314998f, 0.10850453f, -0.01224618f, 0.00148828f, -0.01660337f, 0.07909330f, 0.08770475f, 
    0.13932002f, -0.06464511f, 0.08549681f, 0.03920767f, 0.04702004f, -0.04843370f, -0.03268925f, -0.08321393f, 
    -0.07152379f, -0.04333790f, -0.00045380f, -0.07965039f, -0.05414746f, -0.10840210f, -0.11347523f, 0.13015425f, 
    0.13925974f, -0.01222980f, 0.08697384f, -0.02395730f, 0.05170634f, 0.12702231f, 0.08890963f, 0.15765825f, 
    -0.14066219f, -0.13395071f, 0.01697741f, -0.14647231f, -0.11679443f, 0.01648320f, -0.08240936f, 0.07365294f, 
    0.09283262f, -0.04843404f, -0.00715574f, -0.00027809f, 0.30231151f, -0.15989049f, -0.02800237f, 0.02296904f, 
    -0.02217334f, -0.05880044f, -0.10043666f, 0.01665316f, -0.05375379f, 0.11978851f, 0.07206319f, 0.00027005f, 
    -0.03909557f, -0.14255372f, -0.05594512f, 0.35775742f, 0.03844720f, 0.03794055f, -0.04252116f, 0.00172528f, 
    -0.00493109f, 0.06997963f, 0.15288682f, 0.08714068f, 0.37229553f, 0.01597128f, 0.02870784f, 0.00046367f, 
    0.00783171f, 0.00447840f, 0.08595153f, 0.02202022f, -0.05798876f, -0.01217169f, -0.02622136f, -0.08768141f, 
    -0.13349849f, 0.00730115f, 0.07503508f, -0.04987741f, 0.09724887f, 0.06680573f, -0.03083769f, 0.05264029f, 
    0.12651357f, 0.05976398f, 0.06952243f, -0.03261606f, 0.18692096f, 0.24453661f, -0.18603969f, -0.12992702f, 
    -0.08063798f, 0.17389479f, 0.01233962f, -0.04398442f, 0.02230660f, 0.03917520f, -0.01520021f, -0.03868884f, 
    0.14194028f, 0.23432253f, 0.07043962f, 0.18602823f, -0.12871312f, -0.09631928f, 0.00899634f, -0.06806051f, 
    0.06563111f, -0.15835711f, 0.06697984f, 0.04723585f, 0.01028857f, 0.09747222f, 0.11256317f, 0.00191191f, 
    -0.04030025f, 0.02781783f, 0.01885033f, 0.12972149f, -0.03208167f, 0.11203681f, 0.11751645f, -0.09223299f, 
    0.34794146f, -0.24555150f, -0.02462740f, -0.05402579f, 0.00029985f, -0.09414175f, 0.05333360f, 0.04993979f, 
    -0.10871171f, -0.06822627f, -0.02299849f, -0.11580027f, 0.48764190f, -0.25038847f, -0.11161037f, -0.09407015f, 
    -0.13795793f, -0.02768177f, 0.17526086f, 0.20776707f, -0.02935384f, -0.15477444f, -0.07816121f, -0.02166858f, 
    -0.06165493f, 0.02444764f, 0.02280776f, -0.13534257f, -0.05508475f, -0.02370992f, -0.06598521f, 0.10222349f, 
    -0.17809805f, 0.07968574f, 0.07316521f, -0.04243584f, -0.21022119f, 0.08049807f, -0.05363798f, 0.26618326f, 
    -0.09954018f, -0.06103787f, -0.01021214f, -0.17644773f, 0.27610764f, -0.03892954f, 0.09726949f, -0.05016606f, 
    -0.28404862f, -0.09916638f, -0.18715347f, -0.00972487f, 0.05476505f, 0.04665272f, 0.01785040f, 0.10720585f, 
    0.16564786f, -0.07257061f, -0.15984985f, -0.05457057f, -0.04383460f, 0.10191132f, 0.15531839f, -0.02707916f, 
    -0.14453863f, -0.04749617f, 0.13141480f, 0.17143780f, 0.07146965f, 0.07454697f, 0.03673167f, -0.10147385f, 
    -0.23422123f, 0.06758392f, 0.12021168f, 0.11116709f, 0.06926769f, -0.00852716f, 0.00278226f, -0.04811519f, 
    0.07994125f, 0.02744059f, 0.08309457f, 0.20975739f, 0.45370442f, -0.10802218f, 0.27039972f, -0.23820969f, 
    -0.01733951f, 0.02538650f, 0.24740048f, 0.12143824f, -0.07738061f, -0.09701376f, -0.03798627f, -0.03784300f, 
    0.06306675f, -0.00999425f, 0.10636535f, -0.09280870f, 0.06628585f, -0.04002168f, -0.01064570f, 0.07983556f, 
    -0.11785325f, 0.16211383f, -0.12404677f, -0.03016099f, -0.07668594f, -0.09378766f, 0.22154400f, 0.01060444f, 
    0.01333722f, -0.06955808f, 0.06753237f, -0.09471239f, 0.05172100f, 0.11919422f, 0.13164054f, 0.15317056f, 
    0.12875171f, 0.05971295f, -0.29196224f, -0.01513692f, 0.07310304f, -0.02487336f, -0.10759850f, -0.02188621f, 
    0.11967703f, 0.05148951f, -0.07708007f, 0.01072250f, 0.07051587f, -0.17213736f, -0.09215841f, 0.10006876f, 
    0.06765874f, 0.02528146f, 0.04790295f, 0.01848982f, -0.04084902f, -0.07802725f, 0.00940426f, -0.08497692f, 
    -0.24087945f, -0.13818133f, 0.24983305f, -0.04310920f, 0.09697991f, -0.09244086f, 0.03960675f, 0.02550329f, 
    -0.06330895f, -0.05705540f, 0.07167299f, -0.13818724f, -0.05499995f, -0.05874988f, 0.13648114f, -0.07120721f, 
    -0.00021454f, 0.06567965f, 0.04689607f, -0.02241254f, 0.23587179f, -0.03876990f, 0.13363510f, 0.27075738f, 
    0.04051448f, -0.03739700f, 0.09918521f, -0.01541616f, -0.07112343f, -0.02552221f, 0.02802170f, 0.08812986f, 
    -0.06690693f, 0.04701053f, 0.06635875f, 0.17560729f, -0.04911727f, 0.32211494f, 0.21987952f, -0.05561646f, 
    -0.02826826f, -0.07272933f, 0.00007575f, -0.04168001f, 0.13464095f, 0.03675548f, -0.00278599f, -0.05228082f, 
    -0.23993428f, 0.02426027f, -0.19714403f, -0.02175546f, -0.05038410f, -0.17558752f, 0.04002105f, -0.13879284f, 
    0.08632325f, 0.01494042f, -0.12014174f, 0.05376588f, 0.07451077f, -0.12940632f, 0.05779928f, 0.09015093f, 
    0.08464056f, -0.00302943f, -0.18299112f, -0.03666297f, -0.07664078f, -0.11586354f, -0.05509268f, -0.09143917f, 
    -0.03079967f, -0.02650880f, -0.01638418f, -0.00342624f, 0.00546836f, -0.01684592f, -0.03370901f, -0.03451956f, 
    -0.00480543f, 0.00554385f, 0.02539867f, 0.00390492f, 0.02553050f, -0.01257243f, -0.02621052f, -0.00025280f, 
    0.00791059f, -0.03406869f, 0.02518551f, 0.00797677f, 0.03391480f, -0.01734616f, 0.01225237f, 0.02746735f, 
    0.03009390f, -0.00318940f, -0.00750630f, -0.03637196f, 0.02744675f, 0.02563730f, 0.01878527f, 0.01765090f, 
    0.01673752f, -0.02205580f, 0.01186176f, 0.01312466f, 0.02658216f, 0.00605370f, 0.01521430f, -0.01511191f, 
    -0.01975093f, -0.03129749f, 0.00893342f, -0.04168944f, 0.01522874f, -0.01510278f, -0.02347850f, 0.02112253f, 
    -0.02445439f, -0.01770253f, 0.02062497f, 0.01951239f, -0.02508841f, -0.01101609f, -0.01383627f, 0.00491495f, 
    -0.02512529f, 0.00165789f, -0.00995245f, -0.00717915f, -0.00067176f, -0.00239210f, -0.01601365f, -0.01956453f, 
    0.00659112f, -0.02902937f, -0.00192249f, 0.00760649f, -0.01986299f, -0.01420029f, -0.00755760f, -0.00972291f, 
    -0.02783538f, -0.00995560f, -0.02806626f, -0.00633714f, 0.01451786f, -0.02178074f, 0.00667145f, 0.01761040f, 
    -0.02304367f, -0.01073916f, 0.02107454f, 0.02968965f, 0.00888182f, -0.03025940f, -0.03457155f, 0.02852549f, 
    -0.00447422f, 0.01157328f, 0.02150865f, -0.02766251f, 0.01197569f, -0.00625138f, 0.00996324f, 0.01843614f, 
    0.00488641f, -0.01207619f, -0.01752703f, -0.00718531f, 0.01340984f, -0.02554892f, 0.00141286f, -0.00393857f, 
    -0.02919435f, -0.02591977f, 0.02781373f, 0.01759944f, -0.00176509f, -0.03057037f, 0.01200970f, 0.00055116f, 
    -0.03097252f, 0.02472207f, -0.03694867f, -0.02146453f, 0.02814444f, 0.00207799f, -0.01840922f, -0.01485111f, 
    -0.04008128f, -0.02341068f, -0.02922358f, 0.01903581f, -0.02961878f, -0.01370827f, -0.03157732f, 0.02185305f, 
    0.00416323f, -0.01587801f, -0.00505318f, -0.00419560f, -0.02047934f, 0.00803973f, 0.00895329f, 0.00127732f, 
    0.02324204f, 0.02699743f, -0.03406874f, 0.00012618f, -0.03626237f, 0.02078852f, -0.01056892f, 0.00154398f, 
    0.00766030f, -0.01011324f, 0.01513457f, -0.02293466f, -0.01447175f, 0.02239564f, 0.01626094f, -0.02072970f, 
    -0.02052562f, -0.00217666f, -0.01552399f, -0.00525754f, -0.02306434f, 0.02150081f, -0.04012357f, 0.01916136f, 
    0.02976567f, -0.03520745f, -0.00445759f, -0.00331373f, -0.01884472f, -0.01630170f, -0.00778670f, -0.02437136f, 
    -0.03240898f, -0.03092293f, -0.02596940f, -0.00303812f, -0.01381211f, -0.02243391f, -0.01615807f, 0.00080630f, 
    0.02804964f, -0.00973467f, 0.00747129f, 0.01197977f, -0.02971003f, 0.02009246f, -0.01605651f, -0.02774234f, 
    -0.00221629f, 0.02521293f, -0.03292470f, -0.01362864f, 0.02383615f, -0.01677814f, -0.01029022f, -0.00799905f, 
    -0.01021685f, -0.00970670f, 0.00291515f, 0.00066509f, 0.00255807f, -0.02928130f, -0.01517328f, 0.01563770f, 
    0.00736972f, 0.00587344f, 0.00238315f, 0.00348375f, -0.00338805f, -0.01652362f, 0.01820149f, -0.01294900f, 
    0.00528222f, -0.02816885f, 0.02768359f, 0.01236430f, -0.02243741f, -0.01717213f, -0.00670977f, 0.00290153f, 
    0.00657698f, -0.03182966f, -0.01490036f, -0.01414060f, -0.00989653f, -0.03368651f, -0.01613015f, -0.03113013f, 
    -0.02100012f, 0.01139654f, -0.04386443f, -0.02056603f, -0.02304783f, 0.02608785f, 0.02622888f, 0.01026188f, 
    0.01681819f, -0.01750893f, 0.02623833f, 0.00948127f, -0.01490492f, -0.02895802f, 0.00866156f, 0.00952676f, 
    0.04002565f, -0.02162664f, -0.02428412f, 0.00552389f, 0.00645845f, -0.03627947f, -0.00483719f, 0.01348085f, 
    -0.01752451f, 0.00543515f, -0.00371315f, -0.03380370f, 0.02277547f, 0.02535435f, -0.03917468f, 0.01273154f, 
    0.00628149f, -0.01103754f, -0.02075622f, 0.01219775f, 0.02873025f, -0.01799588f, 0.00061690f, -0.00340123f, 
    -0.00854259f, -0.01719239f, 0.01039986f, 0.02696245f, -0.03127023f, 0.01985384f, -0.02818113f, 0.00338100f, 
    0.00344661f, 0.01093911f, 0.02136240f, -0.01584636f, -0.01616699f, 0.01749862f, 0.01648233f, 0.00868079f, 
    -0.01141309f, -0.01411668f, -0.03384979f, -0.03455133f, -0.03301509f, 0.00264289f, -0.00755284f, 0.02985783f, 
    -0.02164409f, 0.01870602f, -0.01643656f, -0.00827151f, -0.01015875f, -0.03842140f, -0.00758309f, -0.03509549f, 
    0.01060003f, 0.02647847f, 0.00135624f, -0.02185614f, -0.02500221f, -0.02486668f, -0.01836299f, 0.00123556f, 
    0.01316328f, 0.00982203f, 0.02037760f, 0.01837919f, -0.01449726f, -0.00360759f, 0.02896869f, -0.03444451f, 
    -0.03439763f, -0.03945458f, -0.00321952f, 0.03761068f, -0.03268714f, -0.03738972f, -0.00434478f, 0.01551529f, 
    0.02972928f, -0.02371343f, -0.03863161f, -0.02670385f, -0.02392129f, 0.00966866f, 0.00279609f, -0.02415293f, 
    0.00764414f, 0.01433590f, 0.01078234f, 0.01282755f, -0.01215762f, -0.01249738f, 0.01290759f, -0.01191853f, 
    -0.02989163f, 0.01723581f, 0.01601366f, -0.03381194f, 0.02617246f, -0.03130289f, 0.01861607f, -0.00944866f, 
    -0.01468176f, 0.01383258f, 0.02252618f, 0.00400270f, 0.01861939f, -0.02666873f, -0.01565771f, 0.00828383f, 
    0.00830698f, 0.01088726f, -0.03209627f, 0.03006096f, 0.01094827f, -0.01455666f, -0.03189863f, -0.00714364f, 
    0.02653132f, 0.01878371f, -0.02894223f, -0.00754556f, -0.04401219f, -0.03699029f, 0.00289736f, 0.01136197f, 
    -0.01076299f, -0.03531202f, 0.01002454f, -0.01867845f, -0.03864878f, 0.02803107f, -0.00698485f, -0.01370467f, 
    -0.00441534f, 0.00881215f, 0.02618092f, 0.01635998f, 0.01800243f, -0.00813233f, -0.03867223f, 0.00851849f, 
    -0.01315118f, -0.02768760f, 0.02447180f, -0.00346058f, -0.02918995f, -0.01665928f, -0.02637589f, -0.02340445f, 
    -0.02058898f, 0.02656580f, 0.01577270f, -0.02901487f, -0.03690220f, -0.00256511f, -0.01220481f, 0.02511507f, 
    -0.02439048f, -0.01824771f, 0.00981265f, 0.02142982f, -0.00583971f, -0.02330747f, 0.03096804f, 0.02805171f, 
    0.03526251f, -0.02610813f, 0.01611874f, 0.02614328f, 0.00710368f, 0.00700372f, 0.00549902f, 0.00964428f, 
    -0.00617166f, 0.01640744f, -0.00112309f, -0.04123488f, -0.03630453f, -0.01227236f, -0.04092517f, -0.00379451f, 
    0.01900461f, 0.00170438f, 0.00016836f, 0.00179186f, 0.00270458f, -0.04161713f, 0.01332380f, -0.03683170f, 
    -0.03128268f, -0.02265993f, -0.03451003f, -0.03587145f, -0.03539542f, 0.00862544f, 0.02151759f, -0.00895601f, 
    -0.03418603f, 0.00419555f, -0.02221593f, 0.02743546f, -0.00849527f, -0.03386104f, -0.03387986f, 0.02550214f, 
    -0.00992213f, -0.04240443f, 0.00405541f, 0.00717621f, 0.01910618f, -0.03107593f, 0.02311536f, -0.00745546f, 
    -0.00661224f, 0.00662630f, 0.02442069f, 0.03722377f, 0.00590393f, -0.04025256f, -0.03486333f, 0.03312583f, 
    0.00594969f, 0.00061017f, 0.03471505f, -0.03356062f, -0.00063366f, -0.00056919f, -0.03755983f, 0.01148870f, 
    0.02309878f, 0.02611847f, 0.01027249f, -0.00010379f, 0.00913409f, -0.03660436f, 0.02252924f, 0.02111021f, 
    -0.03889999f, 0.00482604f, -0.02121593f, -0.02644689f, 0.00407411f, -0.02089089f, 0.01122878f, -0.03446397f, 
    0.01120523f, -0.03368477f, -0.02787927f, -0.01551299f, -0.03035527f, 0.02586808f, -0.02392845f, -0.00549763f, 
    0.00806783f, 0.02760310f, 0.01406067f, 0.00576970f, -0.03730944f, -0.02639479f, 0.01823026f, 0.02625251f, 
    -0.00913436f, 0.01364635f, 0.01333145f, -0.03442410f, -0.00237091f, -0.02136808f, -0.00381629f, -0.03313186f, 
    -0.03455072f, 0.01825265f, 0.01923806f, 0.00644245f, 0.00162537f, 0.02807599f, -0.04040936f, -0.02781821f, 
    -0.03372337f, -0.01741491f, -0.02761870f, 0.03176800f, -0.04020936f, 0.01984549f, -0.01961633f, 0.04010413f, 
    -0.00776241f, -0.02867692f, -0.02047023f, -0.00898565f, 0.01067352f, 0.01975503f, -0.01930997f, 0.02414005f, 
    -0.00146644f, -0.01044781f, -0.00317820f, 0.00473766f, -0.01789971f, -0.02013836f, -0.00669102f, 0.01243632f, 
    -0.02451675f, 0.00000723f, -0.01154830f, 0.03745366f, -0.00493630f, -0.03973759f, 0.00828443f, -0.01180912f, 
    -0.02901269f, -0.03496960f, -0.00743969f, -0.02295368f, -0.00357930f, -0.02731400f, 0.01572277f, 0.01067914f, 
    -0.03730508f, -0.03678188f, -0.02649454f, -0.01874536f, 0.01258291f, -0.04205799f, -0.02626307f, -0.02979936f, 
    0.01185895f, 0.00268596f, 0.01742407f, 0.01448853f, 0.01456918f, -0.01909162f, -0.00568262f, -0.03348872f, 
    0.01936569f, 0.03031714f, 0.03389258f, -0.03367902f, 0.02159533f, -0.01889833f, 0.02481546f, -0.02401628f, 
    -0.01440134f, 0.01202169f, 0.02157096f, -0.01638797f, 0.00396597f, -0.02013887f, 0.00452745f, -0.02819145f, 
    -0.03356425f, -0.01277936f, -0.01514296f, -0.03894288f, -0.04000370f, 0.00049420f, -0.01957901f, 0.01679558f, 
    -0.01030377f, 0.02260814f, -0.04182660f, 0.03314603f, -0.01417105f, 0.02282976f, -0.01050157f, 0.00329606f, 
    0.00872411f, -0.02450455f, 0.02398014f, -0.01032877f, 0.01645729f, -0.01344001f, 0.01436178f, -0.01840633f, 
    -0.00800795f, 0.01617120f, -0.00483293f, -0.00783376f, 0.01111762f, -0.03072207f, -0.02090710f, -0.02947381f, 
    0.00117778f, -0.02632954f, 0.00787078f, 0.02421914f, 0.00961508f, -0.00096900f, 0.02854700f, 0.01127080f, 
    0.02261529f, 0.02388254f, 0.02700279f, -0.01586309f, -0.02542450f, -0.00263667f, -0.04412504f, 0.01398443f, 
    -0.00636964f, 0.01923057f, -0.01903014f, -0.03671100f, -0.02693900f, -0.01854239f, -0.03421596f, -0.03203471f, 
    0.01706882f, -0.03699156f, -0.02150939f, -0.03290571f, -0.02940005f, -0.00491294f, 0.01795571f, 0.00306632f, 
    0.00923805f, -0.04098498f, 0.00349618f, -0.03210561f, 0.00858357f, 0.02713716f, -0.03138300f, -0.02423416f, 
    0.03192766f, -0.03697226f, 0.01573868f, 0.01318551f, 0.02009953f, -0.03300297f, 0.01170450f, 0.01999692f, 
    0.02409624f, -0.00818302f, -0.03931203f, 0.01193346f, -0.02829613f, 0.01816222f, -0.03301243f, -0.02223842f, 
    -0.01901275f, 0.01542375f, -0.01652322f, -0.01476485f, -0.00949959f, 0.01368806f, -0.03767821f, -0.01184443f, 
    -0.00789389f, -0.01808382f, 0.02837942f, -0.00112807f, -0.02838338f, -0.01415555f, -0.03475587f, -0.00602902f, 
    -0.00210892f, 0.02975735f, -0.00000561f, -0.01032946f, -0.03700373f, -0.02940761f, -0.00784848f, -0.02234136f, 
    -0.02342348f, 0.02445968f, 0.01855445f, 0.00873230f, 0.01860203f, -0.01840427f, 0.01422430f, -0.00570268f, 
    -0.00842238f, 0.01918068f, -0.00852063f, -0.00785535f, -0.00622736f, -0.00185977f, 0.02305211f, -0.02702151f, 
    0.01516936f, -0.00445249f, -0.02133743f, -0.03578071f, -0.00768154f, -0.02252768f, 0.00295374f, -0.01874475f, 
    0.00805937f, 0.03165532f, -0.02647417f, -0.00695487f, -0.03783434f, -0.01023105f, 0.03578072f, 0.01178094f, 
    -0.03261431f, -0.01667615f, 0.00762382f, -0.00861683f, 0.01421255f, 0.02629734f, -0.02077510f, -0.02017148f, 
    -0.01751201f, 0.00096372f, -0.02332159f, 0.02752689f, 0.01967189f, 0.02750990f, 0.02226280f, -0.01692885f, 
    0.01614117f, 0.01299503f, -0.01303438f, -0.02844374f, 0.02631294f, 0.02419507f, 0.04000500f, -0.02522409f, 
    0.02087756f, -0.01787582f, -0.03888851f, 0.01583833f, -0.02062046f, -0.00919130f, -0.03466147f, -0.02427405f, 
    -0.16155811f, 0.02623851f, 0.12000266f, -0.01108745f, -0.02400406f, -0.09481299f, -0.12091859f, -0.16204551f, 
    0.05948888f, -0.00393866f, 0.06222287f, 0.12940772f, 0.08524261f, 0.33198014f, 0.30477095f, -0.04883820f, 
    -0.01159902f, 0.05718160f, 0.23316595f, -0.08353747f, -0.04381002f, -0.10834641f, -0.10568957f, -0.07971445f, 
    0.53447533f, 0.30603263f, -0.15771033f, -0.01966607f, 0.03832579f, -0.11310620f, 0.11144003f, -0.08568506f, 
    0.02952559f, 0.03696228f, -0.04403332f, -0.12895149f, 0.23079245f, -0.10804252f, 0.05668088f, -0.12868644f, 
    0.24181156f, -0.10915227f, -0.03900326f, 0.03849293f, 0.15197238f, -0.08346269f, 0.06517757f, 0.04872714f, 
    -0.16381334f, -0.10769418f, -0.01802035f, 0.23318981f, -0.12959374f, -0.13705608f, -0.08765455f, 0.10148669f, 
    -0.13877685f, 0.13085051f, -0.03260072f, -0.15092708f, -0.38334671f, -0.25720724f, 0.21444197f, 0.22242941f, 
    -0.20175594f, 0.02168735f, 0.00935936f, -0.01018279f, -0.01452667f, 0.02503888f, 0.14635694f, 0.02147385f, 
    -0.09668586f, -0.13413632f, -0.21333419f, 0.21586594f, -0.09440226f, -0.24841201f, -0.01470810f, -0.08515049f, 
    -0.07268349f, -0.00009320f, -0.33067685f, -0.08386296f, 0.08622573f, -0.05143896f, -0.08833589f, 0.13042362f, 
    -0.00521929f, 0.08525937f, 0.06339926f, 0.01325350f, -0.00105701f, 0.04445805f, 0.04178376f, -0.01007300f, 
    -0.00501922f, -0.05606579f, -0.13850771f, 0.01348112f, -0.00762519f, -0.04309712f, 0.00424652f, 0.02837184f, 
    -0.04801513f, -0.17555474f, -0.05230547f, -0.06093869f, -0.05750046f, 0.21687944f, 0.47633356f, -0.00813833f, 
    -0.07535687f, 0.02091562f, 0.12238664f, -0.15452951f, 0.05315061f, 0.03830907f, -0.04110753f, -0.00849138f, 
    -0.24924850f, -0.01694494f, 0.37253788f, -0.06169048f, -0.12303858f, -0.02734370f, 0.23384705f, 0.15657298f, 
    0.11061865f, 0.01416179f, -0.02355740f, -0.00391259f, -0.17856263f, -0.14596561f, 0.07759589f, 0.16802606f, 
    0.13224497f, -0.10931827f, 0.00262114f, 0.03914994f, -0.07377466f, -0.07840897f, -0.01574589f, 0.14654025f, 
    -0.09163446f, -0.03267770f, -0.16317642f, 0.35704592f, -0.02324879f, -0.11688518f, 0.05189519f, 0.00681032f, 
    -0.16405122f, -0.02399418f, -0.01308686f, 0.19487201f, -0.17179960f, 0.16772103f, 0.23634426f, 0.14713871f, 
    -0.05065592f, 0.07719193f, -0.03657408f, -0.03510261f, 0.14598425f, -0.01344145f, -0.01137317f, 0.01342762f, 
    -0.06439364f, 0.06933189f, 0.32443440f, 0.13348828f, -0.10173479f, 0.06948847f, 0.05063554f, 0.08770420f, 
    -0.07306419f, 0.03199599f, -0.07197718f, 0.03899005f, -0.14784284f, 0.05573809f, 0.04515937f, 0.09720195f, 
    -0.13236445f, 0.02338794f, 0.01250231f, 0.10051760f, 0.07661494f, 0.06939300f, -0.08478905f, 0.00762729f, 
    -0.02910384f, 0.29345319f, 0.19002207f, -0.07507531f, 0.01444968f, -0.02357936f, 0.01527002f, -0.03210089f, 
    0.01811355f, -0.04342512f, -0.07393740f, 0.03178354f, 0.02157761f, -0.06815284f, -0.01861534f, 0.06351771f, 
    0.00097197f, 0.01196158f, -0.04395291f, 0.07155862f, 0.06351470f, -0.05890730f, -0.01041651f, 0.04906845f, 
    -0.06861826f, 0.04643410f, 0.23005742f, 0.19765516f, 0.00794026f, -0.03800249f, -0.04066530f, 0.22769290f, 
    -0.02817040f, -0.00444389f, -0.03693220f, 0.06601961f, -0.25014934f, 0.14130317f, 0.18249631f, 0.25444847f, 
    -0.14821465f, -0.06781317f, 0.08018025f, -0.02293997f, 0.08427179f, -0.00710730f, 0.02498931f, -0.04546473f, 
    -0.11841290f, -0.07161137f, 0.09996248f, -0.17146353f, 0.13296206f, 0.08012118f, 0.06745099f, -0.01142577f, 
    0.10791674f, -0.12888749f, 0.01722859f, 0.07624227f, 0.09724302f, 0.00278700f, -0.09919163f, -0.12553142f, 
    0.02961061f, 0.10627431f, 0.04200011f, 0.02229379f, 0.05178699f, 0.00171053f, -0.02017037f, -0.02942108f, 
    0.05077427f, -0.05604751f, -0.05515178f, 0.04196797f, 0.02169332f, -0.04783412f, -0.02583947f, 0.05920709f, 
    -0.10161027f, -0.18064784f, -0.17153053f, 0.00994832f, 0.03447799f, 0.18472211f, 0.05924814f, -0.03125760f, 
    -0.06576699f, -0.12803391f, -0.13656990f, -0.08161902f, -0.00235544f, 0.01787665f, -0.26850900f, -0.13262878f, 
    0.03291366f, 0.01055772f, 0.09347972f, 0.20634088f, -0.07957594f, 0.04089686f, 0.04454935f, 0.00603699f, 
    0.03410301f, 0.05515911f, 0.14581659f, 0.02835340f, -0.43041506f, -0.13281557f, 0.11230370f, -0.31310117f, 
    0.03126102f, -0.09688003f, -0.00041751f, -0.00791248f, 0.08033253f, -0.13369028f, -0.08045364f, 0.01898773f, 
    0.00315188f, -0.13487151f, -0.06406938f, 0.05410707f, -0.04048919f, -0.08289496f, 0.04014159f, -0.08259316f, 
    0.05911219f, -0.02023088f, 0.06419395f, 0.07067237f, 0.25120929f, 0.04141599f, 0.25467539f, 0.19805290f, 
    0.05339876f, 0.10783740f, 0.12656404f, 0.00938920f, 0.10327783f, 0.13436356f, 0.10252068f, -0.00329399f, 
    0.17569172f, 0.03922916f, -0.18676823f, -0.02992157f, 0.04007925f, 0.04012528f, 0.00020242f, 0.00794181f, 
    -0.09686033f, -0.02699377f, -0.07481851f, -0.12280852f, -0.23915192f, -0.10818449f, -0.07476189f, 0.21926281f, 
    0.16636819f, -0.23362286f, -0.04444313f, -0.01197091f, -0.01709859f, -0.08155358f, 0.03489166f, 0.07306360f, 
    0.16356090f, -0.09405168f, 0.17599493f, -0.15875387f, -0.06642116f, -0.24500507f, -0.18274777f, 0.03853853f, 
    0.12699006f, 0.05150110f, 0.02543543f, -0.20860848f, 0.11664318f, -0.28416085f, 0.10499673f, -0.06986004f, 
    0.17647275f, -0.13495865f, 0.26340187f, 0.20728287f, 0.19477722f, -0.10056280f, 0.00615801f, 0.09033868f, 
    0.03156511f, -0.04513494f, -0.00030865f, 0.03346119f, -0.00023339f, -0.01245912f, -0.07886424f, 0.07466643f, 
    -0.06419934f, 0.19061869f, 0.05541179f, 0.15960783f, 0.00118125f, 0.30271265f, -0.13509220f, -0.00118112f, 
    -0.01970989f, -0.08574093f, -0.08858472f, -0.08668194f, 0.05902113f, -0.07268432f, 0.10484602f, 0.03974750f, 
    -0.06497072f, 0.03579145f, 0.01472157f, -0.06764780f, -0.02473679f, -0.06747649f, -0.06444830f, -0.01876000f, 
    0.00212734f, 0.04278397f, -0.06236509f, 0.01740376f, 0.12479318f, 0.36411816f, 0.26579320f, -0.10667265f, 
    0.00871069f, 0.00763872f, 0.10196856f, 0.01797724f, 0.17854252f, -0.02464606f, -0.17609312f, 0.02574517f, 
    -0.07461355f, -0.01042588f, -0.00477868f, 0.06686773f, -0.03402475f, -0.03042470f, -0.04030128f, 0.01735942f, 
    -0.10161281f, 0.12613626f, 0.13211833f, 0.09124106f, -0.32529032f, -0.17730433f, 0.06251250f, 0.15452248f, 
    -0.03088232f, -0.06429850f, 0.07266460f, 0.09942268f, -0.02462290f, -0.00179421f, -0.07075661f, 0.04414252f, 
    -0.47831690f, 0.02593911f, 0.26778176f, 0.32113007f, -0.11873286f, -0.03737299f, 0.07881729f, -0.06059675f, 
    -0.03588334f, -0.07638877f, -0.00242755f, -0.00257122f, -0.14609706f, 0.00673794f, 0.02823274f, -0.26737922f, 
    0.04484032f, -0.06089934f, -0.01811147f, 0.00431149f, -0.11574172f, -0.03339214f, 0.04199287f, 0.05493816f, 
    -0.36297619f, -0.30552757f, 0.20105253f, 0.28493086f, 0.06623162f, 0.06080653f, -0.07679235f, 0.11213330f, 
    0.09401389f, -0.17979980f, -0.18929723f, 0.00841419f, 0.17284620f, -0.05298330f, -0.16685061f, -0.08589595f, 
    0.00832613f, 0.07534715f, 0.01713325f, 0.00416920f, 0.03150572f, 0.02181686f, 0.02875539f, -0.05094236f, 
    -0.36839041f, -0.04419584f, 0.31915650f, 0.19187951f, -0.15941754f, -0.03732391f, -0.02809133f, 0.00672938f, 
    0.07123251f, 0.12663849f, 0.17176291f, -0.01369525f, 0.20707589f, 0.01703926f, -0.05121680f, 0.02778009f, 
    0.15962408f, -0.19524123f, -0.07488064f, -0.12900341f, 0.09153216f, -0.00849039f, -0.10441963f, -0.11126792f, 
    -0.35329393f, -0.10067448f, -0.03220726f, 0.24150343f, -0.00539462f, -0.02303889f, -0.00039477f, 0.02193211f, 
    0.07532579f, 0.06562779f, -0.05339868f, 0.04527304f, 0.11337904f, -0.06257456f, 0.01567222f, 0.04893583f, 
    0.08015283f, 0.03869294f, -0.21186808f, -0.13519417f, 0.01895690f, -0.14967662f, -0.15821332f, -0.12879223f, 
    -0.19132642f, -0.13410515f, -0.06931400f, 0.19001794f, 0.08389227f, 0.02515590f, 0.01020184f, -0.07787950f, 
    0.00111918f, 0.07555178f, 0.11315154f, 0.02799743f, -0.02006821f, 0.04229959f, 0.10194744f, -0.00571247f, 
    0.18366495f, -0.17588910f, 0.02141392f, -0.15116200f, 0.02374208f, 0.04554924f, 0.00406971f, 0.02250052f, 
    0.25750846f, 0.02978383f, 0.22751364f, -0.29180336f, 0.10471071f, 0.05276260f, -0.18048422f, 0.16637996f, 
    0.19726481f, -0.11304747f, -0.02307285f, 0.03843908f, -0.56293070f, 0.09592788f, -0.06245703f, 0.54234666f, 
    -0.07914907f, -0.14661056f, 0.04646357f, -0.00805139f, 0.04043868f, -0.04455093f, 0.03720263f, 0.12028252f, 
    -0.21617758f, -0.10536379f, 0.07432831f, 0.21650256f, 0.12993647f, -0.12895878f, 0.16167194f, 0.11576569f, 
    0.07979193f, -0.01402344f, -0.00968729f, -0.00230939f, -0.32292026f, 0.13016070f, 0.09727214f, 0.07584298f, 
    0.04292894f, -0.04697052f, -0.06663933f, -0.21347715f, 0.12093546f, 0.04401904f, -0.07924334f, 0.01435334f, 
    -0.00896803f, 0.05331800f, 0.12864961f, -0.23092638f, 0.02973726f, -0.10862257f, 0.13289626f, 0.05425283f, 
    0.07839727f, -0.10947517f, -0.15085575f, 0.03004101f, -0.05118111f, -0.15302347f, -0.09568120f, -0.20089276f, 
    0.09011028f, 0.12693916f, 0.05184032f, 0.07318405f, 0.06255960f, -0.04496867f, -0.02333049f, 0.01616976f, 
    0.31866491f, -0.31997567f, 0.04914463f, 0.02550975f, 0.00479828f, -0.03394746f, -0.07828418f, 0.21243536f, 
    -0.09382834f, -0.13184333f, 0.06276986f, -0.06964125f, -0.05327841f, 0.47317192f, 0.11014034f, -0.24659868f, 
    -0.02186039f, 0.09001421f, 0.08512336f, -0.05468032f, 0.12533630f, -0.12181515f, 0.12418390f, -0.04870207f, 
    0.04674248f, -0.06659587f, -0.02923981f, 0.06470218f, 0.04106954f, -0.02598810f, 0.14586040f, -0.03244732f, 
    0.01067656f, -0.05171483f, -0.01074434f, -0.04593618f, 0.03679471f, -0.40932015f, 0.03337636f, 0.17645171f, 
    0.14135674f, 0.07028170f, -0.06578642f, 0.05943025f, 0.10209228f, 0.00526491f, 0.01903834f, -0.03205673f, 
    -0.09049902f, 0.00260534f, 0.17376450f, 0.24133575f, -0.02293625f, 0.05594540f, -0.04182421f, 0.19086690f, 
    0.09915633f, -0.01566661f, 0.02775480f, 0.04051087f, 0.00476534f, 0.22098352f, 0.00194375f, -0.04646470f, 
    0.09140439f, 0.15224466f, -0.08548330f, -0.01532637f, -0.07668725f, -0.02211266f, -0.09502984f, -0.23557772f, 
    -0.22404552f, 0.18455683f, 0.26727158f, -0.03262433f, -0.11039038f, -0.00710721f, -0.00492292f, -0.05367904f, 
    0.03757463f, 0.13450521f, 0.00566394f, -0.25511390f, -0.25896269f, -0.22601815f, 0.14608136f, -0.08339215f, 
    -0.06641131f, 0.09751160f, 0.20453958f, 0.10911054f, -0.04209534f, 0.05476001f, -0.01603405f, -0.01844620f, 
    0.03987558f, -0.11069642f, 0.16140024f, 0.17112821f, 0.03617929f, 0.03621225f, 0.07696009f, 0.08177561f, 
    -0.05331821f, -0.06570257f, 0.08224517f, 0.16380806f, -0.12040896f, -0.11173617f, -0.10326737f, 0.12290821f, 
    -0.05663507f, -0.18658032f, 0.00240091f, 0.10778149f, 0.01443425f, 0.07511787f, 0.02291901f, 0.09014077f, 
    -0.04631024f, -0.00875865f, 0.08549421f, 0.25895357f, -0.00814437f, -0.04017155f, -0.04941038f, -0.04573477f, 
    0.15792219f, 0.01617222f, -0.03721250f, -0.07701043f, -0.09631918f, -0.13907681f, -0.00636748f, 0.13793458f, 
    -0.07364209f, 0.08105128f, 0.10361356f, 0.12019707f, 0.11240286f, 0.05177036f, 0.04087318f, 0.07434744f, 
    0.41040194f, -0.06119672f, -0.27178845f, 0.04990928f, 0.02846658f, 0.02387149f, 0.04111314f, -0.03441605f, 
    0.16740394f, 0.06518074f, 0.14857602f, -0.13853875f, 0.17680645f, 0.30432081f, 0.01839380f, 0.14995933f, 
    0.15252726f, 0.05750459f, -0.05327509f, 0.02499362f, 0.25375232f, 0.02813702f, 0.01092293f, -0.06188373f, 
    0.12412393f, -0.30712941f, -0.11526004f, 0.17839378f, 0.07403979f, 0.13911732f, 0.18235990f, 0.02848653f, 
    -0.05487720f, 0.21360616f, -0.11118571f, 0.03077484f, -0.09911760f, -0.01904560f, 0.25551057f, 0.16504502f, 
    -0.01176771f, -0.05510624f, -0.03689580f, -0.00736231f, 0.10985456f, -0.12333342f, 0.11323724f, 0.05133767f, 
    0.21083948f, -0.12879729f, -0.10109169f, 0.16741000f, 0.09908412f, -0.09367584f, -0.02161552f, 0.08913396f, 
    -0.20766158f, -0.00494150f, -0.08472385f, 0.16436201f, -0.01015912f, -0.05937690f, -0.18228514f, -0.05539085f, 
    0.05957485f, 0.07993907f, -0.02540628f, 0.10407852f, -0.04068740f, -0.04837450f, 0.02066219f, -0.11519800f, 
    -0.05781105f, -0.08719943f, -0.00251789f, -0.21307686f, 0.03883373f, -0.12234382f, -0.09230930f, 0.00527805f, 
    0.11696806f, 0.07495594f, -0.05316103f, -0.02098460f, -0.14923273f, -0.05937747f, 0.16605096f, -0.01880134f, 
    -0.04504245f, -0.01051704f, 0.11437817f, -0.15637971f, 0.10702184f, 0.01193236f, 0.08553638f, -0.05894033f, 
    -0.30177617f, -0.15665229f, 0.10850023f, 0.05139529f, 0.12395515f, -0.03675502f, 0.07038217f, 0.14336589f, 
    0.12948872f, -0.05297844f, -0.05968271f, -0.10379495f, -0.05723080f, -0.07642106f, 0.24060392f, -0.14451589f, 
    0.09967054f, 0.18265311f, -0.06300952f, 0.13876157f, -0.04855207f, 0.18891858f, 0.12511647f, 0.23477213f, 
    0.06925528f, -0.13198632f, 0.06446977f, -0.33712840f, 0.01211242f, 0.04306517f, -0.02595632f, -0.05559490f, 
    0.18572651f, 0.09195492f, 0.05448036f, 0.08305622f, -0.16462691f, -0.01880602f, -0.10772534f, 0.10840245f, 
    0.11293580f, 0.07576460f, 0.02233265f, 0.00755532f, -0.05909057f, -0.05873873f, 0.01165488f, 0.17058007f, 
    0.07606617f, 0.02812945f, 0.12086140f, 0.04376048f, -0.05284264f, 0.02331848f, 0.08206002f, 0.09662418f, 
    0.00758283f, 0.04000332f, -0.08648442f, -0.05919411f, 0.03616934f, 0.02596856f, 0.03445142f, 0.33479956f, 
    -0.07355408f, 0.03720136f, 0.11310377f, 0.27363715f, -0.04926151f, -0.07398288f, 0.00487460f, -0.04806127f, 
    -0.04240069f, 0.04140253f, 0.13892575f, 0.16552408f, -0.15698843f, -0.03973261f, -0.04257594f, 0.13590035f, 
    0.16615714f, 0.09367221f, 0.06237470f, 0.10497735f, -0.12504126f, -0.15179871f, -0.02521109f, -0.06484654f, 
    0.07848899f, -0.10533115f, -0.02257536f, -0.05340989f, 0.04157994f, -0.12372101f, -0.04843970f, 0.03328728f, 
    -0.04261714f, -0.06188892f, 0.09247616f, -0.20906781f, -0.01970476f, -0.00617229f, 0.14205940f, 0.13287963f, 
    0.11774879f, 0.08498051f, -0.05666051f, 0.06928135f, -0.40126181f, -0.14489502f, -0.21535037f, 0.16922820f, 
    -0.11065105f, -0.03091128f, -0.03249605f, 0.16143391f, -0.00388481f, -0.10293160f, 0.06454577f, 0.18651576f, 
    -0.32446280f, 0.26068261f, 0.14544620f, 0.04961945f, 0.27736229f, -0.02050730f, 0.14940523f, 0.05611251f, 
    -0.03963385f, -0.20849542f, -0.08526879f, -0.08310997f, -0.13710761f, -0.22621441f, -0.02038709f, 0.01138708f, 
    0.16149209f, 0.07611544f, 0.14502113f, -0.04035899f, 0.01399113f, -0.06407589f, 0.03878772f, -0.08512932f, 
    -0.02254864f, -0.10242533f, 0.01355581f, -0.19552743f, -0.02321231f, 0.00667793f, 0.01487982f, 0.11601382f, 
    0.09844629f, 0.22953773f, -0.01350280f, 0.03697482f, -0.18510808f, 0.14898475f, -0.11223948f, -0.10412200f, 
    -0.10621189f, 0.09295700f, 0.11446686f, 0.11810427f, -0.02613256f, -0.13037166f, -0.01927934f, -0.02158449f, 
    0.07416369f, -0.07853130f, -0.23916294f, 0.01783543f, 0.01191165f, -0.07893141f, 0.03249705f, -0.03299701f, 
    0.09808157f, -0.07473958f, 0.08467121f, -0.03105739f, -0.30785280f, 0.38967460f, 0.08200426f, -0.08475969f, 
    -0.09800651f, -0.03470378f, 0.00556965f, 0.03112283f, -0.11721040f, -0.05120137f, 0.08909702f, 0.00894266f, 
    -0.03682858f, 0.07510613f, -0.10432568f, -0.03622740f, 0.20197287f, -0.09276679f, -0.05824105f, -0.00302482f, 
    0.06753429f, -0.05925106f, -0.03537341f, 0.06126597f, 0.37207550f, 0.04433698f, -0.15093528f, 0.11105095f, 
    -0.00524985f, -0.07723770f, 0.11183152f, 0.06042680f, 0.00595854f, 0.12121943f, 0.04116236f, -0.06396592f, 
    -0.29081970f, -0.02183079f, -0.10823631f, 0.06237411f, -0.05109701f, 0.06825001f, -0.05597209f, -0.06863078f, 
    -0.08037025f, 0.00424417f, 0.03855549f, -0.11707525f, 0.18992624f, -0.11327531f, -0.12620044f, 0.14829955f, 
    0.02851261f, 0.01166836f, -0.07940942f, 0.03602117f, 0.19034998f, 0.19535533f, -0.21650632f, 0.00587827f, 
    0.01988032f, 0.04492198f, -0.13476306f, 0.12935665f, 0.03576476f, -0.28337812f, -0.21038255f, -0.04807679f, 
    -0.04954971f, 0.18347965f, -0.23163714f, 0.10128081f, -0.30591494f, 0.23472461f, 0.08968076f, -0.40165818f, 
    0.05389396f, 0.08770613f, 0.02696880f, 0.05916128f, 0.15258515f, -0.12778541f, -0.29752213f, 0.05844324f, 
    0.02328685f, 0.14174223f, -0.08013671f, -0.09855603f, -0.20198484f, -0.08220036f, -0.13032812f, 0.09594527f, 
    -0.17949572f, -0.02309929f, 0.04357028f, 0.18615410f, -0.13963349f, -0.01813873f, -0.19991323f, 0.35617933f, 
    -0.14661472f, 0.06008171f, 0.00204352f, -0.02014609f, 0.19498958f, 0.25920755f, 0.31825146f, 0.08631366f, 
    -0.24852082f, -0.04690085f, -0.08235740f, -0.02941482f, 0.06005564f, -0.09692314f, -0.14143509f, -0.11864114f, 
    0.04040194f, -0.06072721f, 0.00075732f, 0.07238115f, 0.00441996f, -0.02642795f, 0.27561432f, 0.24689469f, 
    0.03222828f, 0.05329689f, 0.00688549f, 0.06023232f, -0.02528698f, 0.07898635f, 0.07528890f, 0.13792533f, 
    0.06579150f, 0.01152358f, 0.02648856f, -0.27941144f, -0.10701247f, -0.07825629f, -0.10684291f, -0.12808958f, 
    -0.02718705f, -0.00991109f, 0.13665909f, 0.05897580f, -0.03873586f, -0.13457251f, 0.17379686f, 0.07222173f, 
    -0.03566407f, -0.00637498f, -0.00697571f, 0.04419514f, 0.18425882f, -0.01316145f, -0.08944704f, 0.12996887f, 
    -0.17162567f, -0.41728640f, -0.13855404f, -0.02281526f, 0.09963609f, -0.09739462f, 0.02258561f, 0.05334736f, 
    -0.10415908f, -0.26291662f, -0.02600577f, 0.24648175f, -0.16065916f, -0.20106655f, 0.03413244f, -0.28136075f, 
    -0.14016572f, -0.07220608f, -0.08394768f, 0.07379638f, -0.06071286f, 0.08461092f, -0.01623778f, 0.16053259f, 
    0.05915195f, 0.20296602f, -0.03047275f, 0.02577436f, -0.16058059f, -0.01767426f, 0.06221148f, 0.04093807f, 
    0.11713214f, 0.01623642f, 0.05719391f, 0.20580123f, -0.11748053f, -0.08523891f, 0.14284365f, -0.26715529f, 
    0.00737083f, 0.00769918f, -0.07581922f, -0.04578723f, 0.01832268f, 0.00990307f, -0.02162109f, -0.05588397f, 
    -0.39364418f, -0.05195615f, 0.04775698f, -0.07987449f, -0.03477655f, -0.05186375f, 0.03161565f, 0.13358414f, 
    0.01230719f, 0.02511321f, -0.09070668f, 0.08702298f, -0.03408862f, 0.13139060f, -0.18848932f, -0.03965909f, 
    0.10824756f, 0.01101725f, -0.08170998f, 0.11463042f, 0.04359423f, -0.01948296f, 0.14518754f, 0.03189555f, 
    -0.14602922f, -0.05369431f, -0.00781663f, -0.13110773f, 0.05422528f, -0.04327130f, -0.02256447f, 0.07811247f, 
    0.09200617f, 0.04575624f, 0.16430241f, 0.03138550f, 0.00777511f, 0.08917052f, -0.04656023f, 0.10227413f, 
    -0.09706592f, 0.00956235f, -0.22456460f, -0.03757878f, 0.09660818f, -0.01875877f, -0.06538921f, -0.04812589f, 
    0.33230537f, 0.01427140f, -0.00968159f, 0.37849927f, 0.05638811f, 0.17298447f, -0.05526745f, 0.02697712f, 
    -0.05550619f, 0.08936255f, -0.20318705f, -0.08392490f, -0.32186946f, 0.03981464f, 0.16413738f, -0.03053749f, 
    0.16017678f, 0.13782033f, -0.02633736f, -0.25850043f, 0.02707373f, -0.06370088f, 0.04040787f, 0.00329488f, 
    -0.51803118f, 0.24690507f, 0.08399481f, -0.00270572f, 0.30352700f, 0.00308427f, -0.06304462f, -0.15100427f, 
    0.22569686f, 0.00279843f, 0.13123943f, 0.10979182f, 0.51845479f, -0.14415459f, -0.10176561f, 0.31534952f, 
    0.09257422f, -0.15104710f, 0.09731834f, -0.02241199f, 0.16335939f, -0.04862142f, 0.00186932f, 0.07879689f, 
    0.01953729f, -0.12530005f, -0.01233284f, 0.13847582f, 0.17604852f, 0.07926975f, 0.04207407f, 0.12103114f, 
    0.00182170f, -0.13256629f, 0.12413970f, 0.03753966f, -0.19593029f, -0.05013135f, 0.08476824f, 0.16119903f, 
    0.14407375f, 0.14915426f, 0.04804289f, -0.10633700f, 0.03116370f, -0.02742300f, -0.08935913f, 0.00417285f, 
    0.01271628f, 0.36888337f, -0.22708310f, -0.11339638f, 0.01691900f, -0.04759935f, 0.11112174f, -0.00992494f, 
    0.14999811f, 0.04593245f, 0.00474168f, 0.11369730f, -0.23392108f, 0.05464099f, 0.51391578f, -0.00141062f, 
    0.21428020f, 0.18955943f, 0.04129747f, -0.05673641f, 0.05450112f, -0.00503595f, 0.05835325f, -0.04669017f, 
    0.17683187f, -0.07228528f, -0.01638414f, -0.06558408f, -0.12391789f, 0.05328813f, 0.11243057f, -0.00391973f, 
    -0.04778165f, 0.09692384f, 0.05731816f, 0.03447792f, -0.04767853f, 0.15872918f, -0.04807783f, 0.03511201f, 
    0.06811339f, 0.09927717f, 0.04868500f, -0.08298708f, 0.10165280f, 0.08110149f, 0.26235777f, 0.03777729f, 
    -0.24294561f, -0.31691593f, 0.02810359f, -0.00892617f, -0.03953698f, 0.02166825f, -0.10104591f, -0.03161125f, 
    0.05116962f, -0.09007335f, 0.09972993f, -0.08091442f, 0.14134608f, 0.15279834f, 0.01101416f, 0.22538108f, 
    -0.05284201f, -0.03683712f, -0.15666869f, -0.02427888f, 0.13607845f, -0.03731964f, 0.01504705f, -0.01615357f, 
    -0.01599900f, -0.12084667f, 0.10718302f, 0.10840195f, 0.05840006f, 0.06664152f, -0.09378359f, -0.01967453f, 
    0.13245615f, -0.04762246f, -0.09415390f, 0.15336458f, -0.13657148f, 0.27602053f, 0.12194484f, 0.02210137f, 
    0.00563585f, 0.14788531f, -0.02809463f, -0.11690843f, 0.04187147f, 0.04039706f, 0.05175785f, -0.01484302f, 
    -0.24299864f, -0.01442982f, -0.06125242f, 0.04528490f, -0.02949356f, 0.01247579f, 0.10057998f, 0.07999910f, 
    0.14962743f, -0.03440472f, 0.14595430f, -0.02770634f, -0.10497086f, -0.04154470f, -0.00787967f, 0.06504728f, 
    0.30222023f, 0.07548160f, 0.16171132f, 0.12479340f, -0.09875325f, -0.08256634f, 0.04678646f, 0.06471397f, 
    -0.00072759f, -0.00926769f, -0.06498700f, 0.32251108f, 0.21053274f, -0.01339260f, 0.19291158f, -0.07827818f, 
    0.03661808f, -0.05476150f, -0.02890520f, 0.07403796f, 0.15412427f, 0.08165715f, 0.01099208f, -0.12036373f, 
    0.06401382f, 0.01742418f, -0.09108052f, -0.05573305f, -0.09405307f, 0.20801125f, -0.18509902f, -0.02654602f, 
    0.02610748f, -0.02429551f, -0.04040325f, 0.00094525f, -0.00465276f, -0.00735078f, -0.03582350f, 0.00226128f, 
    -0.01323857f, -0.03673102f, 0.00651617f, -0.01871834f, -0.03908600f, -0.02253089f, 0.00866040f, -0.01567592f, 
    0.00936847f, -0.00416503f, -0.03431005f, -0.02268586f, -0.02467141f, 0.00487238f, -0.03508381f, 0.02846913f, 
    0.01696548f, 0.00616519f, 0.01154752f, -0.02098672f, -0.01605600f, -0.03232516f, 0.02548661f, -0.03882468f, 
    0.01096628f, 0.01911985f, -0.00251618f, -0.02481759f, 0.02909849f, -0.02491945f, 0.00724129f, -0.03958917f, 
    -0.00150049f, 0.01169533f, 0.00036285f, 0.00104222f, -0.02150161f, 0.02621806f, -0.01409714f, 0.00887782f, 
    -0.02307131f, 0.02887450f, -0.01234069f, 0.02732896f, -0.01183983f, -0.01463992f, -0.01407019f, -0.04186587f, 
    0.01344888f, 0.01456183f, -0.03571519f, -0.02511573f, 0.02428395f, -0.00883617f, -0.01073227f, 0.00783668f, 
    -0.00617992f, -0.03759678f, -0.01649839f, 0.01663795f, -0.01936382f, -0.01175922f, -0.03476952f, 0.00001319f, 
    0.02865624f, -0.01461447f, 0.02796143f, -0.00237067f, -0.01676441f, -0.02346918f, 0.01646297f, 0.01395809f, 
    -0.03501996f, 0.02370709f, 0.00826935f, 0.02167710f, -0.02438179f, -0.03322806f, 0.00989722f, -0.00583341f, 
    -0.02054203f, -0.00851163f, 0.01990809f, -0.00725300f, -0.01554541f, 0.00892388f, 0.01296202f, -0.01828437f, 
    0.02753652f, 0.01307025f, 0.02472609f, -0.03444788f, -0.01593673f, 0.00655375f, -0.03981499f, -0.01121653f, 
    -0.03125525f, -0.02986109f, -0.03779525f, -0.00748601f, -0.04071114f, -0.02983794f, 0.01665726f, 0.01710939f, 
    -0.01197746f, 0.02103574f, -0.01148680f, -0.00378242f, -0.02923965f, 0.00159572f, 0.01902391f, 0.01410693f, 
    0.00343079f, 0.00781423f, 0.01129945f, 0.01462238f, -0.00620915f, -0.02846033f, -0.00607486f, -0.03109798f, 
    0.02801967f, -0.03316491f, -0.02079816f, 0.01925863f, 0.00133741f, -0.02243676f, -0.00873101f, 0.01409637f, 
    0.01477969f, -0.01083369f, -0.03128620f, 0.00044170f, -0.01194722f, 0.00469626f, 0.01196740f, -0.00470180f, 
    -0.03091313f, 0.01396720f, 0.00443805f, -0.03404874f, 0.02826777f, 0.02931778f, -0.03716137f, 0.02456312f, 
    0.01822326f, -0.03491820f, -0.00821235f, 0.01390030f, 0.02332813f, 0.01145673f, 0.01664632f, 0.00384078f, 
    0.00309153f, -0.03185366f, -0.01372920f, 0.02687200f, 0.01864394f, -0.03718382f, -0.00709122f, 0.00030765f, 
    0.02881690f, 0.02218034f, 0.01499995f, -0.01706923f, 0.00754544f, -0.03907176f, 0.02775225f, -0.01014797f, 
    -0.02694169f, 0.01542118f, -0.02325345f, -0.01287088f, 0.00875867f, 0.02761886f, 0.00933934f, 0.02754874f, 
    0.02552861f, -0.00574966f, 0.02858937f, -0.01770263f, -0.03619402f, -0.03519963f, -0.01321814f, -0.02294530f, 
    -0.03879383f, 0.00102351f, -0.00303870f, -0.00051194f, -0.02246995f, -0.02621087f, -0.01799558f, 0.00105569f, 
    -0.00546379f, -0.02647968f, -0.03984122f, 0.02828084f, 0.02629375f, -0.01040992f, 0.00690009f, -0.00378041f, 
    0.02386730f, -0.03501208f, -0.00068955f, 0.00629101f, -0.02149996f, -0.01392147f, -0.02893512f, -0.03399266f, 
    -0.00627391f, -0.04025555f, 0.02708483f, -0.01736261f, 0.01784466f, 0.00723629f, 0.00561853f, -0.01424295f, 
    0.00911930f, -0.02763438f, -0.03588875f, -0.02987489f, 0.00031015f, -0.00028342f, -0.04141282f, 0.00619776f, 
    -0.02590988f, -0.01178235f, -0.00501457f, -0.03345906f, -0.02341422f, -0.02926484f, -0.01986642f, -0.02172989f, 
    0.02555257f, 0.02508972f, 0.00860170f, -0.01316296f, -0.00143405f, 0.00284558f, 0.02187627f, -0.03116414f, 
    0.00879806f, 0.00719259f, 0.01952878f, 0.02150857f, -0.01406991f, 0.00803121f, -0.00977247f, -0.03690413f, 
    -0.02477707f, 0.02484075f, -0.01027047f, -0.02718268f, -0.02060527f, -0.03372930f, -0.03119896f, -0.02703935f, 
    -0.01431000f, -0.01988357f, -0.01900436f, 0.01572990f, -0.02991452f, -0.01275392f, -0.03686246f, 0.02458782f, 
    0.02637883f, -0.02285264f, 0.00223248f, -0.02983391f, -0.00445071f, 0.02341363f, -0.00756335f, 0.02156781f, 
    0.00731939f, -0.01975364f, -0.01309388f, 0.01442584f, 0.01823238f, -0.03018616f, 0.01467873f, 0.02396935f, 
    -0.00974213f, -0.01973205f, -0.04088099f, -0.01494354f, -0.03837880f, 0.00652378f, 0.00897372f, -0.02231863f, 
    -0.01041655f, 0.02174103f, -0.00688202f, -0.04053920f, -0.00730831f, 0.01086197f, 0.01063124f, 0.02133154f, 
    -0.03558723f, 0.00031981f, 0.02009770f, 0.01060727f, -0.02435400f, -0.03892956f, 0.01021222f, -0.03594581f, 
    0.02763444f, -0.00366597f, -0.02509649f, -0.03230856f, 0.00066820f, 0.02907168f, 0.02390991f, -0.00871116f, 
    -0.02698631f, 0.01983961f, -0.00585463f, -0.00301796f, 0.00257550f, 0.01506243f, -0.01758087f, -0.04068478f, 
    -0.02093488f, 0.02844971f, 0.02434392f, -0.02900259f, -0.00768748f, 0.00020017f, 0.00155209f, -0.04080661f, 
    -0.02907967f, -0.00000238f, -0.03572479f, 0.00752611f, -0.01086456f, -0.02948076f, 0.02786173f, -0.02918907f, 
    0.02547535f, -0.02631826f, -0.03285644f, 0.01506722f, -0.00298344f, -0.02876301f, 0.02028882f, -0.01652842f, 
    -0.01889739f, -0.03126118f, -0.01065271f, 0.00556888f, -0.00722538f, 0.00994982f, -0.01593854f, 0.01790065f, 
    0.00758497f, -0.02355569f, -0.01492188f, 0.00775165f, -0.01026569f, -0.01514295f, 0.01046325f, -0.02045237f, 
    -0.03979966f, -0.03620602f, 0.00007252f, -0.01669653f, 0.00686416f, -0.02182715f, 0.00008981f, 0.01653111f, 
    0.00652518f, 0.00336600f, -0.01409998f, 0.00892427f, 0.00093326f, 0.02599304f, 0.01212145f, -0.02214410f, 
    0.00793078f, 0.01486831f, -0.01065216f, 0.01381515f, -0.02936858f, 0.00233119f, -0.03190945f, -0.01075274f, 
    -0.03334051f, -0.00932146f, -0.02266194f, -0.01460587f, -0.01996465f, 0.00829006f, 0.00560180f, -0.00887729f, 
    -0.02703735f, 0.02880890f, -0.03688014f, -0.03220083f, -0.02151324f, -0.02642408f, -0.02338971f, -0.01122342f, 
    -0.03326782f, -0.00259195f, 0.00509400f, -0.00494691f, -0.00922620f, 0.03094274f, 0.01543363f, 0.00448336f, 
    -0.01013588f, 0.02333628f, -0.01619812f, -0.00216060f, -0.02028246f, 0.02337341f, -0.01465659f, -0.00566034f, 
    -0.02943851f, -0.03176549f, -0.03375367f, -0.03424671f, 0.01384812f, -0.00838559f, -0.02387661f, 0.01893978f, 
    -0.04026050f, 0.01041560f, -0.02915968f, 0.00251979f, 0.02858143f, -0.02909886f, 0.00956310f, -0.03438006f, 
    -0.00442757f, -0.03813089f, -0.00240951f, 0.00766717f, 0.00025142f, -0.00926959f, -0.03545994f, 0.01392401f, 
    0.02383169f, -0.02911957f, 0.01634149f, -0.03763203f, -0.02431089f, -0.03122824f, 0.01760707f, -0.02418656f, 
    -0.02137345f, -0.01262758f, 0.00244365f, -0.02998786f, 0.00035910f, -0.02680769f, 0.02953577f, -0.00619162f, 
    0.01014734f, 0.00072647f, 0.01454796f, 0.03228154f, 0.01430594f, 0.01354221f, -0.03002009f, 0.00984011f, 
    0.00414603f, 0.00411811f, -0.02185029f, -0.00634716f, -0.02231567f, 0.02106300f, -0.01415850f, -0.03143975f, 
    -0.01117747f, 0.01036749f, 0.01085361f, -0.00574144f, -0.02575018f, 0.02291098f, 0.01278773f, -0.02239764f, 
    -0.00603923f, 0.01253000f, -0.02381994f, 0.00434983f, -0.01164167f, -0.03451351f, 0.02395591f, 0.01717202f, 
    -0.04102522f, -0.02903891f, -0.03263815f, 0.00487599f, -0.01008051f, 0.02018963f, -0.00184390f, 0.00283506f, 
    -0.02033518f, -0.04084260f, 0.02108688f, -0.04017580f, -0.02126638f, 0.01425664f, -0.01653433f, -0.00646300f, 
    0.00878881f, -0.03211895f, -0.01461669f, -0.02116323f, 0.01804901f, 0.00614971f, 0.00361740f, 0.02571248f, 
    0.03589848f, -0.00003702f, 0.01039332f, -0.01996782f, 0.00573999f, 0.00680154f, -0.00503770f, -0.02402838f, 
    -0.01950256f, -0.01499185f, -0.01459532f, -0.01434836f, 0.01538348f, 0.01931321f, 0.01309573f, -0.02731312f, 
    -0.03603148f, -0.03463617f, 0.02479594f, 0.01517890f, 0.01778955f, 0.01880748f, -0.03839677f, 0.00118537f, 
    -0.00143077f, -0.00702112f, 0.02525587f, -0.01042139f, -0.04039308f, -0.00668008f, 0.02338168f, -0.00381702f, 
    -0.01455082f, 0.01519635f, -0.01716575f, -0.01535073f, -0.00971478f, -0.04066436f, -0.01560911f, -0.03519383f, 
    0.00227015f, -0.02796080f, -0.00415066f, 0.01621111f, -0.01803498f, 0.01597140f, -0.00779465f, -0.02343769f, 
    -0.03709758f, 0.00167335f, 0.02918870f, -0.03166639f, -0.02194687f, -0.03435531f, -0.03845167f, -0.02877617f, 
    0.01743361f, -0.00752683f, 0.01179998f, -0.02626204f, -0.01475482f, -0.00238291f, -0.01694239f, 0.01367722f, 
    0.02012516f, 0.01026983f, -0.03592303f, 0.01271350f, 0.02722437f, -0.03266600f, -0.03376893f, -0.02432426f, 
    0.00044056f, 0.00725858f, -0.02660660f, -0.03527807f, 0.01790514f, 0.00911258f, 0.02131744f, -0.03521605f, 
    -0.01400931f, 0.02702241f, -0.00279620f, -0.01958382f, -0.01309961f, -0.00529812f, -0.01737759f, -0.00127096f, 
    -0.02349875f, 0.02695348f, -0.02264791f, -0.02104404f, -0.01510538f, 0.01518309f, -0.01854924f, 0.02371692f, 
    0.02070960f, -0.01439708f, 0.02373886f, -0.00428912f, -0.01133779f, -0.03058555f, -0.02754826f, 0.00111961f, 
    -0.02859083f, -0.02229411f, 0.02252162f, 0.01959253f, 0.00188885f, -0.00332542f, -0.01864323f, -0.03814672f, 
    -0.03547078f, -0.03371814f, -0.03480936f, 0.02661082f, 0.01591768f, -0.03920253f, 0.02056924f, 0.01235505f, 
    0.02407434f, 0.00755416f, -0.04077072f, -0.02348339f, 0.02422477f, -0.00605798f, -0.01673384f, 0.01007729f, 
    -0.01820457f, -0.03963271f, -0.00891306f, -0.02294565f, 0.01744514f, -0.02053808f, 0.01574369f, -0.01345452f, 
    0.01961461f, -0.00925844f, -0.00863273f, 0.01788059f, 0.02890011f, -0.02425500f, -0.02015804f, -0.03017775f, 
    -0.01310910f, 0.01352594f, -0.00809739f, 0.02559800f, -0.03485257f, 0.01890890f, -0.00525361f, -0.02050918f, 
    0.00030907f, -0.00785297f, -0.02437120f, -0.00373922f, 0.02750281f, 0.01966453f, -0.01609600f, 0.00155577f, 
    0.00234231f, -0.03456497f, -0.00909118f, -0.03069337f, -0.02040028f, 0.00647562f, -0.02669314f, -0.01200498f, 
    -0.02379002f, 0.01547350f, 0.02365363f, 0.01313524f, 0.03594593f, 0.02998520f, 0.01712925f, 0.00783164f, 
    -0.00183549f, 0.01759421f, -0.01443674f, -0.03815713f, -0.03129763f, 0.02865706f, -0.03962678f, -0.02156878f, 
    0.00550015f, -0.02399908f, 0.00684491f, 0.02803147f, 0.00201058f, 0.01586333f, -0.03925779f, -0.04182802f, 
    0.02218426f, 0.01657627f, 0.01524102f, -0.03208966f, 0.02067899f, 0.01152611f, -0.01932198f, -0.02313451f, 
    0.01646432f, 0.01839158f, 0.01010892f, -0.02884913f, -0.03573373f, -0.00245379f, -0.03288797f, 0.01375781f, 
    0.00852521f, 0.01469390f, 0.00576320f, -0.01199877f, -0.03117619f, -0.00757322f, -0.01219177f, 0.03523479f, 
    -0.01133087f, -0.01585783f, -0.01404012f, 0.01697508f, -0.00154909f, 0.01180722f, -0.00119427f, 0.01206995f, 
    0.01192202f, -0.01544720f, 0.01220091f, -0.01492928f, -0.00959200f, 0.02983900f, 0.02050849f, -0.01447713f, 
    -0.01025057f, -0.03214689f, -0.00943494f, -0.02667024f, -0.00239069f, 0.02517208f, -0.00434103f, -0.00111586f, 
    0.00747292f, -0.00941407f, -0.01048940f, -0.00287208f, -0.02695272f, 0.02454623f, -0.00020381f, 0.00602048f, 
    0.01083044f, 0.00679778f, -0.02593288f, 0.01889330f, -0.00917023f, -0.02280275f, -0.00215976f, -0.01470751f, 
    0.01547903f, -0.01133894f, 0.01076791f, -0.03808765f, -0.02852130f, -0.03816982f, 0.01377308f, 0.02893406f, 
    -0.00117485f, 0.00585506f, 0.00329089f, -0.00449396f, 0.00140377f, 0.01985956f, -0.02637793f, -0.02191206f, 
    0.01939958f, -0.02346688f, 0.02952057f, -0.01298111f, 0.02688276f, -0.02815361f, -0.01214760f, 0.02320612f, 
    -0.03762605f, -0.03684404f, 0.02787112f, 0.01983890f, -0.00586799f, -0.02886470f, -0.00003783f, -0.04246661f, 
    0.02683358f, 0.01255359f, 0.00879115f, -0.00388849f, -0.01441800f, -0.02996870f, 0.01827413f, 0.01770831f, 
    0.00113591f, -0.00037715f, 0.01002315f, 0.02759840f, 0.02532194f, -0.01299042f, -0.03312935f, -0.04114558f, 
    0.02598442f, 0.02348137f, 0.01553645f, 0.00865403f, -0.04016044f, -0.04139159f, -0.01410546f, 0.01392365f, 
    -0.03690084f, -0.01325821f, 0.01188844f, -0.04180641f, 0.00820980f, -0.02331193f, -0.01936516f, -0.01322479f, 
    0.01539472f, 0.01633785f, 0.01441348f, 0.00784081f, -0.04215139f, -0.00324515f, -0.01827064f, -0.02657742f, 
    -0.01791119f, -0.01287218f, 0.02597389f, 0.00382376f, 0.02903876f, -0.02762813f, -0.04095903f, -0.03473052f, 
    -0.02343576f, -0.01900070f, -0.00427874f, -0.01548515f, -0.00470078f, -0.01430404f, -0.00328299f, 0.02072948f, 
    -0.01045968f, -0.00470226f, -0.03654847f, -0.00836002f, -0.00009881f, 0.01854355f, -0.02891299f, 0.02243432f, 
    -0.03596007f, -0.03587314f, -0.00022813f, 0.01696187f, 0.02768999f, -0.04265424f, 0.01932864f, -0.00212012f, 
    0.00770762f, -0.01865555f, 0.01346227f, -0.02959740f, 0.00142973f, -0.03627922f, 0.00229079f, 0.00096563f, 
    -0.01308801f, 0.01319354f, -0.01374297f, 0.01413043f, -0.01005245f, 0.01922474f, -0.03541712f, -0.01701378f, 
    0.02242123f, 0.00159235f, -0.01970077f, 0.00000290f, -0.00927569f, 0.02338706f, 0.00942333f, -0.02197349f, 
    -0.01756257f, -0.01614309f, -0.03177448f, -0.01920324f, -0.03532080f, -0.03536056f, -0.00547077f, 0.00542060f, 
    0.02028075f, 0.02186626f, -0.02576559f, 0.01701461f, 0.00474674f, 0.01898665f, -0.00666311f, 0.01157622f, 
    -0.03317460f, -0.01160735f, -0.03274366f, -0.00304421f, 0.00991129f, 0.00581852f, -0.02641304f, 0.00035662f, 
    -0.00266795f, 0.02108537f, 0.01096112f, 0.02827807f, -0.02777360f, 0.00347538f, -0.01107477f, -0.01582782f, 
    -0.02857135f, -0.01589543f, 0.01980616f, -0.04185881f, -0.03368118f, -0.02832619f, 0.00960603f, 0.02752211f, 
    0.02762751f, 0.00558437f, -0.00466033f, 0.02062068f, -0.02681592f, 0.02038475f, -0.00722554f, 0.01216804f, 
    -0.01735009f, 0.00496286f, 0.02191911f, 0.02373901f, 0.01517528f, 0.02721267f, 0.01034298f, -0.00757173f, 
    -0.02536144f, 0.01210420f, -0.00252512f, -0.03467815f, 0.02517242f, -0.02577239f, -0.03160253f, 0.02541795f, 
    -0.03872355f, 0.02035155f, -0.03728682f, -0.03758145f, 0.02131343f, -0.03216023f, 0.00636048f, 0.01619193f, 
    -0.00048431f, -0.01237295f, 0.00297896f, -0.01062264f, -0.00294091f, -0.03607646f, 0.02604426f, -0.03937360f, 
    -0.00382983f, -0.04381523f, -0.01549384f, 0.01763137f, -0.02997046f, -0.00646679f, -0.02912834f, -0.01337638f, 
    0.00468010f, -0.01692620f, -0.03141851f, -0.01182327f, 0.00041285f, -0.00743128f, 0.01881090f, -0.00633922f, 
    -0.00180068f, -0.03177767f, -0.02838116f, 0.01701222f, 0.01951869f, -0.01156165f, -0.04226495f, -0.00780174f, 
    0.01175405f, 0.02003577f, -0.02780071f, 0.00021223f, -0.03837714f, 0.02765959f, -0.00096320f, 0.01053894f, 
    -0.02230496f, -0.02942142f, -0.03023085f, 0.02305617f, 0.02744340f, -0.04116650f, -0.03982003f, 0.01067747f, 
    -0.00529805f, -0.01869489f, 0.02238650f, -0.02000567f, 0.02833624f, 0.02749614f, 0.01885899f, -0.00119713f, 
    -0.02824442f, -0.04132012f, -0.04211281f, -0.01198172f, -0.03525896f, -0.02976932f, -0.01272451f, 0.00752160f, 
    0.01518938f, -0.02380585f, -0.02805140f, -0.03792400f, -0.01628907f, -0.00275387f, 0.02678931f, 0.00915755f, 
    -0.02048336f, -0.02601088f, -0.02510430f, -0.03702839f, 0.02134438f, -0.01048814f, -0.01792745f, 0.00326022f, 
    -0.00095185f, 0.00976214f, -0.01256002f, -0.01818852f, -0.04040704f, 0.00123522f, -0.03463605f, -0.01642288f, 
    -0.03977156f, -0.02011753f, -0.01091952f, 0.01455542f, -0.03523994f, -0.00636557f, -0.02114922f, 0.01646549f, 
    0.01334071f, 0.00519384f, -0.00665071f, -0.00310027f, 0.02111413f, -0.01322134f, -0.01655981f, -0.03700775f, 
    -0.01685448f, 0.00391989f, -0.00092505f, -0.02473420f, 0.01655928f, -0.03995570f, -0.03956342f, 0.01469041f, 
    -0.03253400f, 0.00829840f, -0.03405908f, -0.04218604f, -0.00084656f, 0.00372290f, -0.00346619f, -0.03431146f, 
    0.01637460f, 0.01495613f, -0.03688798f, -0.03556002f, -0.01580195f, 0.00467370f, -0.00294038f, -0.02747645f, 
    -0.00503468f, -0.02448621f, -0.00022699f, -0.00348768f, 0.00811717f, 0.02595367f, -0.00649566f, 0.01577686f, 
    -0.03127056f, 0.00646342f, -0.01450285f, -0.03008000f, -0.00716779f, -0.02202033f, -0.03652470f, -0.00352189f, 
    -0.02682837f, 0.01322147f, -0.04252861f, -0.03931865f, -0.03542867f, 0.00008206f, -0.02149861f, -0.00762749f, 
    -0.01898481f, 0.02766081f, 0.00206439f, 0.01507755f, -0.01859906f, 0.00924492f, 0.01808004f, 0.00282393f, 
    -0.02398850f, -0.02349760f, 0.00964522f, -0.02057581f, 0.02678756f, 0.02414159f, 0.00871819f, 0.00098620f, 
    0.00911283f, -0.00781738f, -0.00447964f, -0.01490493f, 0.00076611f, -0.03525724f, 0.01133529f, -0.01900761f, 
    -0.02302135f, -0.02818977f, -0.00902019f, 0.02182564f, -0.01287184f, -0.00425712f, -0.03421302f, -0.01902334f, 
    -0.00336183f, -0.00163084f, -0.04296239f, -0.02270650f, -0.02101840f, -0.00768979f, 0.02566691f, -0.03768600f, 
    -0.03169931f, 0.00964320f, 0.02446724f, 0.00711952f, -0.01188978f, -0.01054221f, -0.02162875f, -0.01866746f, 
    -0.03548970f, -0.01979386f, -0.02677411f, 0.02294111f, -0.02644327f, -0.03010541f, 0.02362525f, -0.00763477f, 
    -0.00542502f, 0.02057236f, -0.00335180f, 0.01238888f, -0.01381820f, -0.01657218f, -0.00248841f, -0.00159407f, 
    -0.00005642f, -0.01658535f, 0.00844826f, -0.03514058f, 0.00980357f, 0.02214468f, -0.01161530f, 0.01106449f, 
    -0.03330879f, -0.03956307f, 0.00227308f, 0.02040398f, -0.01404288f, -0.03051469f, -0.01515820f, 0.00588741f, 
    0.02519498f, 0.02652207f, -0.01753364f, -0.03054104f, -0.02941418f, -0.00467167f, -0.02186723f, -0.00706212f, 
    0.02082200f, 0.00703044f, -0.01030447f, -0.02412144f, 0.02849999f, -0.03489469f, -0.03112571f, -0.00065716f, 
    0.01711439f, 0.00453749f, 0.02788718f, -0.03774181f, 0.00853041f, 0.00516564f, -0.00950300f, -0.01731190f, 
    -0.02064626f, -0.00713708f, 0.02405000f, 0.02696695f, 0.00709866f, -0.01454671f, 0.00542689f, -0.01263130f, 
    0.01212117f, -0.01575889f, 0.01832678f, -0.04188039f, -0.00339388f, -0.02391827f, -0.00686522f, -0.02571707f, 
    -0.03393836f, -0.01702164f, 0.01503027f, -0.02194716f, 0.01253845f, 0.00684207f, -0.04123235f, -0.02348505f, 
    0.01957693f, -0.01835768f, -0.04388809f, 0.01093368f, -0.04097454f, -0.00643743f, 0.01641782f, -0.01682888f, 
    -0.02863022f, -0.00397743f, -0.02680671f, -0.01809402f, -0.00645700f, -0.02871930f, -0.04022565f, -0.00059019f, 
    -0.01601400f, -0.04383210f, -0.02674892f, -0.02053197f, -0.01968697f, -0.01429866f, 0.01509058f, 0.00212738f, 
    0.00259851f, 0.02824439f, -0.01901925f, -0.02892877f, 0.01522390f, -0.00078514f, -0.02823901f, -0.02216681f, 
    0.01731181f, -0.01864486f, 0.00574250f, -0.03170656f, -0.00268970f, -0.03589711f, 0.02177099f, -0.02207410f, 
    -0.00191951f, -0.01537336f, 0.02082093f, -0.02225468f, 0.00236674f, 0.00901182f, -0.03959438f, -0.02256563f, 
    -0.00195391f, -0.04040718f, -0.03274821f, 0.01330910f, -0.00019762f, 0.02148910f, -0.02711451f, -0.02924978f, 
    0.02459774f, 0.00606408f, -0.00407194f, -0.01648865f, -0.03853611f, -0.00276091f, -0.01624064f, 0.02759682f, 
    -0.03522593f, 0.00605069f, 0.00953448f, -0.03252861f, -0.04046253f, -0.03938965f, -0.01605766f, -0.00438150f, 
    -0.00084752f, 0.01655200f, -0.00536549f, -0.00827548f, -0.01251352f, -0.02889869f, 0.02496246f, -0.04109503f, 
    0.00567370f, -0.01508807f, 0.00407392f, -0.01586869f, -0.00238966f, -0.02415070f, 0.01268607f, -0.04055328f, 
    -0.00174883f, -0.02076501f, 0.00015670f, 0.00264762f, 0.00320058f, 0.00275895f, -0.01750312f, -0.00558144f, 
    0.01888683f, -0.04287042f, 0.01666489f, -0.00346089f, 0.02326275f, -0.02258959f, -0.03101668f, 0.01361097f, 
    0.01888129f, -0.02266252f, -0.01409616f, -0.01387089f, 0.02256860f, -0.03333376f, 0.02297129f, 0.02142709f, 
    0.02038864f, -0.01171468f, -0.00776786f, 0.00491013f, 0.01568567f, -0.02436265f, 0.01100156f, 0.00695284f, 
    0.02180483f, -0.00571638f, 0.02198851f, -0.01788546f, -0.01553983f, 0.01493078f, -0.01640393f, -0.03722676f, 
    -0.01640764f, -0.00247814f, -0.01009596f, -0.00982408f, 0.01823073f, -0.02723562f, -0.01902262f, -0.00072161f, 
    -0.01074962f, 0.02519875f, -0.04088981f, -0.00235147f, 0.01387597f, -0.02604402f, 0.02070055f, 0.00981419f, 
    -0.03549936f, 0.02144707f, -0.00481118f, -0.00020086f, 0.00078467f, -0.00614685f, 0.02412525f, 0.02787744f, 
    0.00195604f, -0.01231161f, -0.03347325f, -0.01480965f, -0.03976833f, -0.01401985f, -0.03986995f, -0.00731952f, 
    -0.02478736f, -0.03293243f, -0.03253207f, 0.01177218f, -0.02194768f, 0.02764193f, 0.02548390f, -0.01696287f, 
    -0.02010513f, 0.02077372f, -0.02265849f, -0.03711959f, -0.03643660f, -0.02173823f, 0.02236508f, -0.01602828f, 
    -0.02829502f, -0.01328906f, 0.02377116f, -0.03842885f, -0.03272417f, -0.04338063f, -0.01323936f, 0.00516997f, 
    0.00693338f, -0.02876174f, -0.00337826f, -0.00012852f, 0.02299825f, 0.02634192f, 0.02664502f, -0.00961039f, 
    -0.00128173f, -0.02574456f, 0.01186731f, -0.00550742f, -0.03622093f, 0.01118712f, -0.01401212f, -0.01149318f, 
    0.00241665f, -0.03433287f, 0.02244988f, -0.02422291f, -0.00464103f, 0.02221818f, -0.02610742f, 0.02412194f, 
    0.02231343f, -0.03331265f, -0.01832110f, 0.00203341f, -0.03454867f, -0.00967882f, -0.02803951f, -0.02275043f, 
    0.01983217f, -0.03478191f, 0.00704819f, 0.01338024f, 0.01824451f, 0.00587413f, 0.01358702f, -0.03684456f, 
    -0.01503329f, 0.00540340f, -0.02147302f, -0.02964911f, -0.02526903f, 0.00609914f, 0.00984379f, -0.03546214f, 
    0.01218405f, -0.00261536f, 0.02203884f, 0.02192549f, -0.00774078f, -0.02795821f, 0.01071983f, -0.00137899f, 
    -0.03652848f, -0.00392832f, 0.01305303f, 0.00537633f, 0.02871087f, -0.00147255f, 0.02015058f, -0.00207751f, 
    0.00884151f, -0.02610063f, 0.00254216f, -0.00415077f, 0.00870708f, 0.02292346f, -0.02241070f, -0.00527962f, 
    -0.01395453f, -0.01932852f, 0.01247178f, -0.03475779f, -0.03537881f, -0.00157525f, 0.01462339f, 0.00752515f, 
    -0.01373732f, 0.01825962f, -0.00403079f, -0.01712644f, -0.03446724f, 0.01820745f, 0.02681446f, 0.00230947f, 
    0.00406516f, -0.03455043f, 0.01285344f, 0.02481924f, 0.00750674f, -0.01310038f, -0.03261054f, 0.02444254f, 
    0.05232858f, 0.20020431f, 0.20688322f, 0.26924753f, 0.11039958f, 0.12304345f, 0.06753854f, 0.09708207f, 
    -0.09997381f, -0.05827380f, -0.07019297f, -0.08755036f, 0.08829498f, 0.21425416f, 0.05516375f, -0.04600899f, 
    -0.03339204f, -0.07563341f, -0.08121376f, -0.04158882f, 0.07665362f, 0.06924713f, 0.05223685f, -0.00073480f, 
    -0.28160244f, 0.01601199f, 0.14753997f, -0.04746841f, 0.08530124f, 0.03696777f, -0.13018230f, 0.02164810f, 
    0.08099611f, -0.11404075f, -0.02429510f, 0.20371369f, -0.21364939f, 0.05279864f, -0.17393930f, 0.14647292f, 
    0.04384217f, -0.03772734f, 0.03661216f, -0.13175113f, 0.02496358f, -0.17735048f, 0.05221108f, -0.01396390f, 
    -0.11339649f, 0.04490862f, 0.22020543f, -0.00952807f, -0.08574229f, -0.19311583f, -0.11105113f, 0.02476413f, 
    0.08552167f, -0.10631216f, 0.08254959f, -0.01984059f, 0.12625390f, 0.03197942f, 0.07058980f, 0.06798747f, 
    0.09574968f, 0.06182727f, 0.11061849f, 0.15617675f, 0.07939839f, 0.07932086f, -0.23792863f, 0.00426223f, 
    -0.54010248f, -0.10243953f, 0.08511728f, -0.04437635f, -0.07431664f, 0.03033662f, -0.02538673f, -0.13930501f, 
    0.05438068f, 0.06099073f, 0.08425684f, -0.02291176f, -0.09810483f, 0.03232561f, 0.06565017f, 0.00023123f, 
    0.02663874f, -0.02489942f, -0.05194813f, -0.04151193f, -0.00338423f, 0.01263374f, -0.01204479f, 0.04983329f, 
    -0.00370206f, -0.01695747f, -0.06431043f, 0.09976577f, -0.02555241f, 0.04892548f, -0.02472282f, -0.00888538f, 
    0.07386792f, 0.05652438f, 0.13220127f, 0.05380312f, 0.22786207f, 0.17751928f, -0.00719656f, -0.04668275f, 
    0.20303483f, 0.07260064f, 0.05884692f, 0.19608475f, -0.07502616f, 0.07347138f, -0.02172991f, -0.01007147f, 
    0.10533130f, 0.26076618f, 0.01040358f, 0.05032000f, 0.01499523f, 0.03208750f, 0.02831506f, -0.10717750f, 
    -0.11552001f, -0.14773767f, -0.08998137f, 0.04999379f, 0.31917956f, 0.06028735f, -0.09808178f, -0.00728323f, 
    -0.18461145f, -0.01587867f, -0.06957952f, -0.02825174f, 0.14285599f, 0.08231180f, -0.03894407f, -0.07469694f, 
    -0.03441115f, -0.02172170f, -0.00490128f, 0.14978246f, -0.03157147f, -0.05602306f, 0.00743335f, 0.06541315f, 
    -0.07769213f, 0.02827515f, -0.05101521f, -0.08074708f, 0.17971694f, 0.20505208f, 0.32137549f, 0.08609422f, 
    -0.00207208f, -0.02367653f, 0.15242429f, 0.24496865f, 0.03909184f, -0.02676580f, 0.01807576f, -0.04003296f, 
    0.06715146f, 0.11804971f, 0.14235769f, 0.23488484f, 0.04917307f, 0.02099539f, -0.00487160f, 0.01247140f, 
    0.09957277f, 0.02973203f, -0.02930836f, 0.01430492f, -0.15433674f, -0.08239785f, -0.00427106f, -0.12215181f, 
    0.02423090f, 0.06069788f, -0.00647199f, -0.16415611f, -0.11878850f, 0.01377753f, -0.02300959f, 0.02308971f, 
    0.20772912f, -0.16854720f, -0.17709205f, -0.12213042f, -0.03898194f, -0.00143320f, 0.01187007f, -0.06340839f, 
    -0.03100171f, 0.11451270f, 0.01168402f, -0.10882165f, 0.03434290f, 0.00468384f, 0.05771792f, 0.01709345f, 
    0.03284222f, -0.00488468f, 0.00642576f, -0.05410116f, -0.06794710f, 0.01655812f, 0.05188830f, -0.06181182f, 
    0.24128561f, -0.02671858f, 0.12365470f, 0.31714588f, -0.00587043f, -0.09267902f, 0.05425144f, -0.15979716f, 
    0.00805911f, -0.09522919f, -0.10696113f, -0.03964671f, 0.32653472f, 0.16267021f, 0.26312086f, 0.02864132f, 
    0.24327271f, -0.04938141f, 0.04329992f, 0.03387691f, 0.06495915f, 0.07469818f, -0.07952908f, -0.16916318f, 
    0.24650617f, 0.24471486f, -0.01704279f, 0.04075593f, -0.22264546f, 0.15407109f, 0.09143648f, 0.17173320f, 
    -0.07208949f, 0.11204586f, -0.03074654f, 0.01198505f, 0.12015983f, 0.03520354f, -0.14571229f, 0.03399114f, 
    -0.15953515f, -0.15232210f, -0.12424917f, -0.03517500f, -0.03053322f, 0.00189514f, -0.00458837f, 0.06533182f, 
    -0.02808642f, -0.05846380f, 0.04497444f, 0.07898004f, -0.03555067f, -0.00710239f, -0.04585850f, 0.03008315f, 
    0.10600381f, -0.14342728f, 0.07212993f, 0.13848498f, 0.16587764f, -0.21138613f, 0.19030106f, -0.09698045f, 
    0.13008353f, 0.03445261f, 0.02738688f, -0.20040460f, 0.15618424f, 0.15402828f, 0.01813547f, -0.04912640f, 
    -0.16617943f, -0.26451427f, 0.15738340f, -0.00214670f, 0.03447139f, -0.04096935f, -0.06981707f, -0.01327020f, 
    -0.02461252f, 0.09693072f, -0.00422846f, 0.07940193f, 0.16448866f, -0.29054588f, 0.05317969f, -0.12538253f, 
    -0.06347355f, 0.03995775f, -0.14214990f, 0.05530724f, 0.13077343f, 0.13561310f, -0.00588462f, 0.06438298f, 
    0.03781840f, -0.01469833f, 0.16803683f, 0.02711783f, -0.02972412f, 0.18804249f, 0.06768706f, 0.10122506f, 
    -0.14634663f, -0.03868445f, -0.00123983f, -0.08058002f, -0.29413533f, 0.14573002f, 0.21293987f, -0.04868042f, 
    0.10179610f, 0.05906396f, -0.20943601f, -0.11209651f, -0.05400767f, -0.01623732f, 0.00220303f, -0.02382011f, 
    0.03289068f, -0.03811161f, -0.01472375f, -0.11681879f, 0.00522266f, -0.05050441f, -0.00048109f, -0.01203158f, 
    0.11835151f, 0.08806282f, -0.16951458f, 0.12885194f, -0.10397758f, 0.17915283f, 0.13275988f, -0.00335063f, 
    0.01870397f, 0.16969100f, 0.11768827f, 0.03067946f, 0.01938017f, -0.14551000f, 0.07832192f, -0.15966310f, 
    0.09293842f, 0.18810530f, 0.01336955f, 0.05753492f, 0.10328738f, 0.14922307f, 0.12007559f, -0.10728303f, 
    -0.10356165f, -0.06774716f, -0.07756313f, 0.01982397f, 0.23095922f, -0.01398323f, -0.18337883f, 0.32078746f, 
    0.04744323f, -0.12361597f, 0.01349915f, 0.07893826f, -0.06729561f, -0.05551145f, 0.07761103f, -0.01817900f, 
    0.16257040f, -0.06936526f, -0.14070570f, 0.16718343f, 0.13224834f, 0.06604704f, 0.06334453f, -0.08767290f, 
    0.16097505f, 0.20240305f, 0.01801795f, -0.15090995f, 0.17934364f, 0.12159302f, 0.06800019f, -0.58549684f, 
    -0.02266518f, -0.02731916f, 0.06340337f, -0.05430639f, -0.06535076f, -0.18740207f, -0.14236060f, 0.00422801f, 
    0.25021216f, -0.02642214f, -0.03496043f, -0.03729591f, -0.03681752f, 0.00569403f, 0.08153408f, 0.00594087f, 
    -0.00139415f, 0.02119919f, 0.02911026f, 0.02133637f, 0.07789207f, 0.05637799f, -0.14604206f, -0.30621362f, 
    -0.01979732f, -0.05283983f, -0.02911921f, -0.03355325f, -0.02741311f, -0.06581242f, -0.05325996f, -0.03949343f, 
    0.08604135f, -0.00802557f, -0.00336754f, -0.02601664f, -0.02242466f, -0.08171901f, 0.06814408f, 0.01466773f, 
    0.08746130f, 0.06041073f, -0.09712531f, -0.05357393f, 0.07381324f, 0.06988328f, 0.00477711f, 0.15256573f, 
    0.08852006f, -0.02130986f, -0.06057109f, -0.12490696f, 0.00810945f, 0.06006796f, 0.19158866f, 0.01828006f, 
    0.06938230f, 0.33756918f, 0.23078968f, -0.09680539f, -0.08514180f, 0.10637552f, 0.02106843f, -0.01345393f, 
    0.00510047f, -0.01806405f, -0.00936797f, -0.24442664f, 0.38735050f, 0.06582524f, -0.00127095f, 0.04811152f, 
    0.00813612f, -0.00886622f, 0.04746871f, 0.03480532f, 0.13216023f, 0.24899110f, 0.11843979f, -0.06337718f, 
    -0.24322008f, -0.24537505f, -0.04220606f, 0.05205547f, 0.06594036f, -0.05283328f, -0.04537452f, 0.05822849f, 
    -0.07679772f, 0.12444227f, 0.07889282f, -0.18775129f, 0.26832819f, 0.05493638f, -0.13916153f, 0.11905908f, 
    -0.03678694f, -0.10266132f, -0.00248882f, -0.03432329f, -0.05350477f, -0.00645378f, -0.00146772f, 0.09220935f, 
    0.28308019f, 0.16996402f, 0.21490787f, 0.24186702f, 0.16442111f, 0.14776744f, 0.12318019f, 0.16425985f, 
    0.07824827f, -0.00139887f, -0.00464046f, 0.00716331f, -0.10619678f, 0.06334966f, -0.06818800f, -0.05361839f, 
    0.04085887f, 0.12671970f, -0.05540624f, -0.15144205f, -0.08195081f, 0.08702977f, 0.02445526f, -0.09998308f, 
    0.10733255f, 0.03499068f, -0.06978370f, 0.07209913f, -0.09347296f, -0.06261472f, -0.02170449f, 0.02284631f, 
    -0.09867474f, -0.00745855f, -0.01836756f, 0.09032149f, 0.05139295f, 0.00154780f, -0.07819211f, -0.11949756f, 
    0.09011694f, 0.00672043f, 0.09031188f, -0.07678118f, -0.04718139f, 0.10149697f, -0.11153883f, 0.01013422f, 
    -0.03939005f, -0.14647488f, 0.19484533f, -0.07464927f, -0.02371168f, -0.12364812f, 0.03200232f, 0.19667800f, 
    -0.03200731f, -0.09487909f, 0.00251377f, -0.04528348f, 0.63608974f, -0.09583561f, -0.18093853f, -0.20771414f, 
    -0.19892022f, -0.11148915f, -0.02302774f, 0.21150480f, -0.07680193f, 0.04539030f, -0.05900639f, -0.01930937f, 
    0.65819645f, 0.00658122f, -0.01475449f, -0.22475658f, -0.18494754f, -0.07810327f, 0.06252267f, -0.02768554f, 
    -0.09465056f, 0.17394489f, -0.10212725f, -0.03525497f, -0.52437270f, 0.06870964f, 0.05615042f, -0.02734490f, 
    -0.11410149f, 0.12578918f, -0.09223323f, 0.11256754f, 0.06666277f, -0.09085426f, 0.00756761f, -0.10110946f, 
    -0.20813121f, -0.03822431f, -0.05024149f, 0.14081757f, -0.01519732f, -0.05685447f, 0.07163484f, 0.01559333f, 
    -0.02638662f, 0.04915145f, -0.16112445f, 0.07830421f, 0.20064108f, 0.24950843f, 0.19476716f, 0.17124243f, 
    -0.09210539f, -0.04350630f, 0.09569777f, 0.28255901f, -0.03949686f, 0.00166346f, 0.03731631f, -0.02862611f, 
    -0.07953314f, -0.13455991f, 0.14498949f, 0.21449575f, 0.02453874f, 0.02469840f, -0.09338554f, -0.11821907f, 
    0.05929094f, -0.08767545f, 0.02276769f, 0.00437069f, 0.42681539f, 0.06310023f, -0.22806361f, -0.17148191f, 
    -0.22611046f, -0.19435456f, 0.10511071f, 0.07914788f, -0.09814109f, 0.00381758f, -0.01140476f, 0.07581101f, 
    -0.04943462f, -0.04321153f, -0.13973717f, -0.19423686f, 0.06106437f, -0.01936748f, -0.04761193f, 0.00168130f, 
    -0.03189066f, -0.00099255f, -0.01018291f, 0.10315702f, 0.09914868f, -0.21650340f, 0.07903448f, -0.08967841f, 
    -0.06959823f, -0.02106437f, -0.09247843f, 0.01301878f, 0.08417988f, -0.04376510f, -0.10132799f, 0.04726702f, 
    -0.00625799f, 0.11259587f, -0.05552299f, 0.03525319f, 0.06320030f, -0.17360197f, -0.17906746f, -0.09975616f, 
    0.04345230f, 0.07162502f, -0.02244147f, 0.05794535f, -0.11496806f, -0.20224515f, -0.01563320f, 0.10041861f, 
    -0.07477355f, -0.10990661f, 0.02550279f, 0.01839262f, -0.06083242f, -0.02629489f, 0.01286294f, 0.07518611f, 
    -0.09546733f, 0.16896756f, 0.23445065f, 0.05435690f, 0.07596882f, -0.05216184f, 0.17681780f, -0.01136815f, 
    -0.11100510f, -0.02597430f, 0.11375391f, -0.13520762f, 0.05769404f, -0.09354780f, -0.11451569f, -0.07096199f, 
    0.04028339f, -0.02462707f, 0.06028286f, 0.07104515f, 0.01779421f, -0.10308693f, 0.01954442f, 0.08740064f, 
    0.29800746f, 0.09692420f, 0.26306742f, 0.04925393f, -0.04671830f, -0.04908653f, 0.04251644f, 0.08654764f, 
    -0.05593326f, 0.02257712f, -0.04170782f, 0.13718246f, 0.15774801f, 0.29324234f, 0.17366192f, 0.13089961f, 
    -0.09115876f, 0.02020841f, 0.01108537f, 0.04179373f, -0.02998494f, 0.00801100f, 0.01067743f, 0.06643907f, 
    -0.09195468f, 0.10460193f, 0.08323524f, 0.04921054f, -0.11221682f, 0.01447427f, -0.03191846f, 0.14145562f, 
    0.03126697f, 0.01522043f, -0.17501014f, -0.00912994f, -0.06696207f, -0.20275505f, 0.11845494f, 0.08687402f, 
    -0.06181812f, -0.00581958f, -0.11288601f, 0.04231872f, 0.09389315f, -0.10837715f, 0.03787714f, 0.01320556f, 
    -0.02584138f, -0.04467776f, 0.03156140f, 0.19762510f, 0.09660978f, -0.01982024f, -0.05579925f, -0.07381257f, 
    -0.02789055f, -0.04354464f, -0.11587405f, 0.00085058f, -0.11218848f, 0.03829744f, 0.08907574f, 0.04344571f, 
    -0.00184979f, -0.08908672f, -0.04175043f, -0.15968129f, 0.00439977f, 0.08311660f, -0.01298696f, -0.00268560f, 
    -0.19306143f, -0.26513571f, 0.08499009f, -0.18533242f, -0.01559301f, 0.07557850f, -0.14714718f, -0.01227987f, 
    -0.10325871f, -0.11904680f, -0.07973494f, -0.02066582f, -0.03047591f, -0.01499186f, 0.12475630f, -0.08941553f, 
    -0.05302170f, -0.01151932f, 0.03988918f, -0.04246394f, -0.16078168f, 0.04924223f, -0.06553701f, 0.08490773f, 
    0.13758714f, 0.04891941f, -0.09406881f, -0.05157201f, -0.09819753f, -0.10022076f, 0.00179899f, 0.17991026f, 
    -0.02743066f, -0.16859622f, -0.01716595f, 0.01412839f, -0.04143052f, 0.07595886f, -0.03375075f, -0.02190561f, 
    -0.06146351f, 0.08514640f, -0.02444921f, 0.07668959f, -0.01800504f, 0.07132656f, -0.19579785f, -0.07176638f, 
    0.17685229f, -0.17827718f, 0.07990243f, -0.05326289f, 0.12383575f, 0.03028001f, -0.00626544f, 0.07018920f, 
    -0.06002880f, -0.07059466f, 0.09552334f, -0.00760830f, 0.00863292f, 0.12365051f, 0.19845276f, 0.07240021f, 
    0.12404457f, 0.07191148f, -0.17433669f, -0.06483585f, -0.04081072f, 0.13813385f, -0.00189653f, 0.05988155f, 
    -0.01160367f, 0.17318268f, 0.01989063f, 0.02116024f, -0.06147603f, 0.07253585f, -0.04501056f, 0.00323737f, 
    0.03618988f, 0.23098536f, 0.03551167f, 0.12181493f, -0.04539921f, -0.08862001f, -0.32054999f, 0.08214845f, 
    -0.01000003f, 0.19167578f, 0.10164324f, 0.06457372f, 0.01056780f, 0.04906613f, -0.03407566f, -0.06565225f, 
    0.20292531f, 0.08079516f, -0.19933811f, 0.05596080f, 0.09592021f, 0.14418642f, -0.00496909f, -0.07920770f, 
    -0.04186569f, -0.04232087f, 0.00027499f, -0.05884969f, -0.20730282f, 0.23890100f, -0.24012376f, -0.12469644f, 
    -0.04247505f, 0.09011768f, 0.01887859f, -0.02877342f, -0.04926836f, -0.08436403f, 0.04862479f, -0.04748467f, 
    -0.00631438f, 0.14517604f, -0.05655236f, -0.13179994f, 0.02649123f, 0.04036097f, 0.03759602f, -0.01676921f, 
    0.07108676f, 0.03101444f, 0.05615332f, -0.02034396f, 0.01400319f, 0.01254805f, 0.09476652f, -0.04637754f, 
    0.05724201f, -0.00323400f, -0.06501593f, 0.12086624f, -0.04056587f, -0.02792261f, -0.01675422f, -0.06423190f, 
    -0.30508357f, -0.17052785f, -0.13115114f, 0.09872636f, 0.23456240f, 0.05985523f, -0.01621771f, -0.00867062f, 
    0.05195927f, 0.08888536f, -0.07678269f, 0.02565457f, 0.02325079f, -0.10322238f, -0.13324760f, -0.02584959f, 
    0.07766178f, 0.02639629f, 0.06605792f, -0.08346206f, -0.08254132f, -0.01364082f, -0.07139838f, -0.07902054f, 
    -0.31448698f, -0.40063706f, -0.30304965f, -0.05436651f, 0.07654968f, 0.08772497f, 0.04218376f, 0.06853559f, 
    -0.00841021f, 0.05601373f, -0.15970473f, -0.20588852f, 0.00569283f, 0.06157997f, 0.03181298f, -0.02102859f, 
    0.04236924f, 0.23071228f, -0.04587983f, 0.00531252f, -0.03639344f, 0.04780420f, 0.03215503f, -0.02262206f, 
    -0.19514829f, -0.18180363f, 0.06737095f, 0.14950036f, -0.01742705f, 0.10441288f, -0.05683495f, 0.02030384f, 
    0.10424378f, 0.01730603f, 0.06396899f, -0.11274374f, 0.12591536f, -0.06228341f, 0.30909154f, -0.11819805f, 
    -0.03935163f, -0.00957824f, -0.05259706f, -0.00692893f, -0.03871502f, 0.03675308f, -0.15711214f, 0.00000671f, 
    -0.03671797f, 0.05010150f, 0.09287065f, 0.14662622f, 0.05584018f, -0.03138763f, -0.17613943f, -0.02280305f, 
    -0.01322005f, 0.07340775f, -0.00552754f, 0.09678920f, 0.15203415f, 0.18682006f, 0.28917280f, -0.02032172f, 
    -0.10040805f, -0.13431090f, -0.12110759f, -0.03406030f, 0.01589274f, 0.02926904f, 0.03823224f, 0.01341972f, 
    -0.08786657f, 0.16570090f, -0.06947354f, -0.01718752f, -0.01040077f, 0.00726880f, -0.02895782f, -0.00618622f, 
    0.01508613f, 0.07112747f, 0.00419298f, -0.08214557f, -0.04090932f, -0.19713542f, -0.07682767f, 0.08999448f, 
    -0.08264536f, 0.07941891f, 0.27154708f, -0.06995510f, 0.08067637f, 0.00856893f, 0.10406390f, -0.19622383f, 
    0.09803095f, 0.04401973f, 0.13608538f, -0.02915360f, 0.02779318f, 0.08382993f, -0.13784793f, -0.01270566f, 
    -0.00732804f, 0.07139384f, 0.04912723f, 0.17326543f, 0.26784924f, 0.19172904f, -0.23007670f, 0.22473770f, 
    -0.06083487f, 0.05927704f, -0.05613627f, 0.01357291f, -0.08664218f, 0.01241452f, -0.03099082f, -0.04245858f, 
    -0.01725812f, 0.24963692f, 0.17508267f, 0.04565453f, -0.11332066f, 0.05919941f, -0.08353916f, -0.09882803f, 
    0.02818398f, -0.03530227f, 0.00048142f, 0.03833652f, -0.03217372f, -0.19035597f, 0.15000239f, 0.20418541f, 
    0.12736936f, 0.08574390f, -0.22339374f, 0.04825503f, -0.12038627f, -0.00645557f, 0.08727600f, -0.02428190f, 
    0.19005923f, -0.06110073f, 0.28104123f, -0.01650000f, -0.02118439f, -0.02348110f, -0.02963805f, -0.01136374f, 
    0.11727430f, 0.15133743f, 0.10585553f, 0.03850247f, 0.05251200f, 0.09338600f, 0.12485640f, -0.00427020f, 
    0.04698974f, -0.06948563f, 0.14926946f, -0.03641724f, -0.10853791f, 0.15667991f, 0.06401481f, -0.04881846f, 
    -0.04599663f, 0.11191880f, -0.10241871f, 0.23715660f, 0.19491211f, 0.37314984f, 0.09108838f, 0.06243033f, 
    -0.12535329f, -0.01445438f, -0.13952491f, 0.32273749f, -0.20249487f, 0.30005658f, 0.00236282f, 0.04591668f, 
    0.08877159f, 0.08343357f, -0.07093519f, -0.09821101f, -0.15327129f, 0.04235021f, 0.01135386f, 0.06055951f, 
    0.02638683f, 0.08346683f, 0.04702805f, 0.04105628f, 0.01721882f, 0.10435893f, 0.05949869f, -0.00436954f, 
    0.13021381f, 0.04775263f, -0.04183992f, 0.03210663f, -0.09844330f, 0.16440457f, 0.03843477f, -0.08361301f, 
    0.05837847f, 0.05597553f, 0.05181221f, 0.04032305f, 0.00829624f, 0.08936293f, -0.07143404f, -0.05693761f, 
    0.04133100f, 0.03483184f, 0.07574993f, 0.00511742f, 0.05815886f, 0.11176873f, -0.03680502f, 0.00422679f, 
    -0.07737899f, -0.05291111f, 0.08998731f, 0.09418826f, -0.22457485f, -0.32286355f, -0.34719902f, 0.08111075f, 
    -0.04892425f, 0.05738785f, 0.09577443f, -0.01148987f, -0.10087692f, -0.08887046f, 0.08824869f, -0.09745412f, 
    0.06816680f, -0.02484543f, 0.03477739f, -0.04068838f, -0.00799907f, 0.08419809f, -0.03669855f, 0.10238771f, 
    0.07377321f, -0.05283450f, -0.01405963f, -0.04906479f, 0.07660747f, -0.02495805f, -0.09090781f, 0.09596664f, 
    0.12250639f, -0.05999249f, -0.11077762f, -0.02471942f, 0.02185784f, 0.07047207f, 0.23863076f, -0.15877299f, 
    0.05894112f, 0.23355272f, 0.11157624f, -0.10472912f, 0.11605471f, -0.00530350f, 0.01308891f, -0.08702543f, 
    -0.01043644f, -0.02993376f, -0.04051603f, -0.14332415f, -0.16218424f, 0.15385288f, -0.10036962f, 0.05995777f, 
    0.04485003f, 0.02144932f, 0.03636426f, 0.01364911f, 0.23817311f, -0.04568036f, -0.14501654f, 0.00176441f, 
    0.30370554f, -0.08680226f, -0.06735569f, -0.16545659f, 0.04731267f, -0.13234901f, 0.05021813f, -0.08094548f, 
    0.12648076f, 0.14302750f, 0.01127078f, -0.05211907f, 0.19927368f, 0.24420434f, 0.27633947f, 0.01373572f, 
    -0.05014949f, -0.03195990f, -0.08140650f, 0.08139285f, -0.02684913f, 0.02806711f, 0.06158808f, 0.00087112f, 
    0.02519920f, -0.03215736f, 0.13546048f, 0.15602212f, 0.07842297f, -0.01035603f, 0.02458898f, -0.11563808f, 
    -0.00710726f, -0.03379558f, -0.02226181f, 0.02747102f, -0.26339659f, 0.11401425f, 0.28781119f, -0.03435123f, 
    0.08867127f, 0.14798382f, -0.08599821f, 0.12704809f, -0.05317537f, 0.05136873f, 0.24175084f, -0.04569771f, 
    0.16501389f, -0.11864506f, -0.16286650f, -0.10624329f, 0.12153491f, -0.02754188f, 0.05383266f, 0.08358410f, 
    -0.00938734f, 0.09200288f, 0.04362883f, 0.04970915f, -0.06400996f, -0.01963014f, -0.03810510f, 0.08194593f, 
    0.04190506f, 0.08649696f, 0.12076290f, 0.09636705f, 0.01161989f, 0.11127371f, -0.11635219f, 0.10998777f, 
    -0.02460390f, 0.41654330f, 0.07491127f, 0.00180798f, 0.03620420f, -0.25583383f, 0.15497884f, 0.06624418f, 
    0.09662748f, -0.02408027f, 0.00670491f, 0.04645678f, 0.10690796f, 0.19622415f, -0.12283106f, 0.15111794f, 
    -0.15340705f, 0.03129364f, 0.03150357f, 0.23038799f, 0.08016261f, 0.01636906f, -0.06010916f, -0.01030498f, 
    0.07660522f, 0.05651892f, -0.16538151f, 0.14867502f, -0.09291363f, 0.13231385f, 0.11264978f, -0.00868982f, 
    -0.16747448f, 0.05074778f, 0.07468642f, 0.20990734f, 0.28138244f, -0.34184164f, -0.06776625f, -0.14922765f, 
    0.08473904f, 0.01828012f, 0.05404657f, -0.00985580f, -0.19613200f, 0.04544415f, 0.07597235f, -0.04531768f, 
    0.39363346f, -0.13762550f, -0.03774607f, -0.10027067f, 0.08344719f, -0.05993624f, 0.03490964f, -0.07613190f, 
    -0.08629279f, 0.01804510f, 0.03105050f, 0.00513360f, 0.02056573f, -0.27258343f, 0.15880354f, 0.11337245f, 
    0.04678331f, -0.00876394f, 0.06619503f, 0.06511205f, 0.00834680f, -0.01415228f, 0.00543230f, 0.00133911f, 
    0.07211917f, -0.10021196f, 0.13949691f, 0.03306425f, -0.03318694f, 0.07981408f, -0.14689541f, -0.05464655f, 
    -0.12833843f, 0.11858747f, 0.08631174f, -0.08935636f, 0.01999643f, 0.52463186f, 0.10533605f, -0.05972923f, 
    -0.36128229f, -0.21612875f, -0.05629795f, -0.06063179f, -0.05913778f, 0.03520359f, -0.03204333f, 0.01742340f, 
    0.09208532f, 0.11348631f, -0.16360791f, 0.15707137f, -0.00748317f, 0.18610825f, 0.02770798f, 0.01378805f, 
    0.06209934f, 0.03680655f, 0.04950310f, 0.12178037f, -0.04101288f, -0.24961452f, -0.15014736f, 0.01421409f, 
    -0.00342567f, 0.04497635f, -0.07344833f, 0.02380708f, -0.17217410f, -0.04932940f, 0.04269330f, 0.02086334f, 
    0.09660398f, -0.01650347f, 0.14891921f, 0.01572030f, -0.03730458f, 0.04836845f, -0.23239356f, 0.13009071f, 
    -0.05786248f, 0.13767232f, -0.03951536f, 0.01013811f, -0.07752473f, 0.37028900f, 0.01872676f, -0.19385299f, 
    0.07074463f, -0.17560028f, 0.04022923f, 0.02756848f, -0.04079938f, 0.05366836f, 0.02475796f, 0.01425501f, 
    0.10148683f, 0.07006453f, 0.00704241f, -0.06527328f, 0.03191903f, 0.13180460f, -0.04976536f, -0.14812467f, 
    0.00256807f, -0.04649600f, 0.02951336f, -0.09414304f, -0.08224566f, 0.10665375f, -0.00496884f, -0.05366598f, 
    -0.08075351f, -0.00971431f, 0.00186061f, 0.04038795f, -0.11712690f, -0.00599145f, 0.03832650f, 0.00484899f, 
    0.00745414f, -0.16549343f, 0.09728204f, -0.08002954f, -0.05169776f, -0.08899341f, 0.05108594f, -0.04223930f, 
    -0.00018332f, 0.07143078f, -0.10344534f, 0.04381477f, 0.10321786f, 0.12008648f, 0.03418926f, 0.07085908f, 
    0.01700717f, 0.04554281f, 0.03842060f, -0.03206677f, -0.04843633f, -0.05553621f, -0.03102762f, -0.01967380f, 
    0.19464314f, 0.12071349f, 0.00413383f, 0.14062835f, -0.01370006f, 0.02658429f, -0.05914525f, 0.03608830f, 
    -0.04042612f, 0.08067902f, -0.02681743f, 0.01183112f, 0.00804311f, 0.20516349f, 0.00466265f, -0.02523782f, 
    -0.05080223f, 0.07409012f, 0.01990191f, -0.00177423f, -0.00634347f, -0.01872755f, -0.00277924f, 0.12870444f, 
    0.01522622f, -0.02163056f, -0.00265159f, -0.02573279f, -0.01444496f, 0.02534410f, -0.04221351f, -0.01446297f, 
    -0.00024732f, 0.01300465f, 0.00250997f, -0.03194558f, 0.02745341f, -0.01206195f, 0.00162413f, 0.02023589f, 
    0.01464411f, 0.00742157f, -0.00915750f, -0.00841299f, 0.01435395f, -0.00991466f, -0.02694351f, -0.00869615f, 
    0.00357877f, -0.03309821f, 0.00062630f, -0.00898547f, 0.03026306f, -0.02343441f, 0.01149241f, 0.01869307f, 
    0.03589703f, -0.01847708f, 0.01024401f, 0.01490225f, -0.02649214f, -0.01659230f, -0.03823054f, 0.01535942f, 
    0.02159236f, 0.01012261f, 0.02216349f, -0.01212931f, 0.01311304f, -0.00561908f, 0.02107014f, -0.01611347f, 
    -0.02612585f, -0.03752047f, -0.01507206f, 0.00873331f, -0.03178699f, 0.02307173f, 0.00918796f, 0.02057557f, 
    0.00298467f, 0.01346048f, -0.01985485f, 0.02687941f, -0.00318202f, -0.02119092f, 0.01124546f, 0.00165938f, 
    0.01342650f, 0.01658463f, -0.00472631f, 0.02165642f, -0.03869697f, 0.01827305f, -0.04293419f, 0.02556338f, 
    -0.02843882f, -0.03198074f, 0.00319878f, -0.01839393f, -0.03938403f, -0.03749685f, -0.03312659f, -0.00919764f, 
    -0.02921522f, -0.04053004f, -0.01831644f, 0.00409941f, 0.01523762f, -0.03656963f, -0.00642379f, -0.03566919f, 
    -0.03310701f, 0.02661299f, 0.02432199f, -0.04382263f, 0.01655510f, 0.01688277f, -0.04369716f, -0.03007942f, 
    -0.01470382f, -0.01569537f, 0.01888655f, 0.00573593f, -0.03414604f, -0.02109052f, -0.00355411f, -0.00599677f, 
    -0.01235595f, 0.02854632f, 0.02719466f, 0.01579280f, -0.02462486f, 0.01332788f, -0.00889927f, -0.03796392f, 
    -0.02272369f, -0.02810043f, -0.01812802f, 0.02656972f, -0.00023921f, -0.00958759f, -0.04359854f, 0.00471208f, 
    -0.03288922f, -0.02658869f, 0.01563187f, 0.02140946f, 0.00412101f, -0.01562537f, -0.00338793f, 0.00740339f, 
    -0.02251533f, -0.02867008f, -0.01918681f, 0.01007865f, -0.00434441f, 0.00701712f, 0.00400672f, -0.00350792f, 
    0.02308616f, -0.02687884f, 0.00832004f, -0.03947111f, -0.00090901f, -0.02380322f, -0.04125455f, 0.02347756f, 
    0.01884724f, 0.02723724f, 0.00278677f, 0.00504215f, 0.00827964f, -0.03618222f, -0.01672568f, -0.02357335f, 
    -0.01725310f, -0.00152085f, -0.02293919f, -0.02110345f, 0.00304899f, 0.01633904f, -0.04364589f, -0.04162123f, 
    0.00776788f, 0.02602364f, 0.00225842f, -0.04267565f, -0.01532299f, 0.01019430f, 0.02029835f, -0.03840256f, 
    0.00079964f, -0.02305482f, 0.01169801f, 0.00920808f, -0.03180291f, -0.00939737f, -0.03523280f, -0.04365487f, 
    0.01336500f, 0.02804839f, -0.02499929f, 0.02022090f, 0.01915177f, -0.02770171f, -0.01704965f, 0.01931323f, 
    0.00568934f, -0.03271996f, 0.03412662f, -0.02677686f, -0.02109701f, -0.02027655f, -0.02653939f, 0.03707114f, 
    -0.00385854f, -0.01760730f, 0.01017152f, 0.00379439f, -0.02550285f, -0.01662528f, 0.01397672f, 0.01588994f, 
    -0.03540497f, -0.02251288f, -0.03324997f, 0.01977259f, -0.02490728f, -0.01593069f, -0.01881381f, -0.03398848f, 
    -0.01182767f, -0.03433486f, -0.01064654f, 0.01615547f, -0.00159382f, -0.01406253f, -0.03380631f, -0.01373778f, 
    -0.04253719f, -0.02254016f, -0.00142654f, 0.01782438f, -0.03178673f, 0.01160627f, -0.00562746f, -0.03357149f, 
    0.00935517f, -0.01161590f, -0.04412221f, -0.01074077f, -0.01263210f, 0.02041528f, 0.02130429f, -0.04215053f, 
    0.01730984f, -0.02303870f, -0.00074242f, 0.00715169f, -0.02581080f, -0.02494255f, 0.00865720f, -0.02857294f, 
    -0.02822325f, -0.04162246f, 0.02616145f, 0.02161147f, -0.00340728f, 0.00083394f, 0.01184819f, -0.02484523f, 
    -0.03600214f, -0.00478290f, -0.02440777f, -0.00776794f, -0.02303056f, 0.03241247f, -0.03085598f, 0.01369273f, 
    -0.00444214f, -0.02412972f, -0.02150571f, -0.04402724f, -0.00739536f, 0.02678207f, -0.03260050f, -0.01208186f, 
    0.01156559f, 0.02349115f, -0.01345056f, 0.00793945f, -0.01432239f, 0.00727407f, -0.01465293f, 0.02142619f, 
    0.01646023f, 0.02756134f, -0.00419377f, 0.02265893f, 0.01619506f, 0.00441178f, 0.01095422f, 0.02757612f, 
    0.01608334f, -0.00074365f, 0.01954952f, 0.01580832f, -0.03481772f, -0.04200386f, 0.01635855f, -0.01302841f, 
    0.03653386f, 0.00101316f, -0.01335062f, 0.01132442f, 0.01698920f, -0.02647316f, -0.03156885f, 0.00419266f, 
    -0.03369331f, -0.03252451f, 0.00204989f, -0.00986408f, 0.02386037f, 0.01549876f, 0.02154634f, -0.02011610f, 
    -0.00280582f, -0.01147480f, 0.00964610f, -0.00734627f, 0.00096328f, 0.02101591f, -0.02764304f, 0.01799238f, 
    -0.03868726f, -0.02443486f, 0.02013825f, 0.01834123f, 0.01644098f, -0.03212868f, -0.01061435f, -0.03866899f, 
    -0.01432273f, -0.01831016f, -0.02359827f, -0.02025735f, -0.02241234f, 0.00704124f, 0.01468916f, 0.01256490f, 
    0.02088806f, 0.02763941f, -0.00505899f, -0.00923501f, 0.02298675f, 0.00997722f, 0.00448641f, 0.02789959f, 
    0.00729893f, 0.03683025f, 0.00002077f, -0.01349453f, -0.01921812f, -0.03820705f, -0.02678625f, -0.01711193f, 
    0.00893875f, 0.03615995f, 0.02095691f, 0.02452807f, -0.02491308f, 0.00866131f, 0.01851285f, 0.01328009f, 
    -0.01566839f, -0.04159229f, -0.03066497f, -0.02891434f, 0.02160973f, -0.03255671f, 0.01526489f, 0.00078931f, 
    -0.00652344f, 0.02127755f, -0.02368163f, -0.03603078f, 0.00062113f, 0.01461015f, -0.00349580f, -0.00564979f, 
    -0.00329974f, -0.02468744f, 0.01890328f, 0.00078897f, -0.04215122f, -0.00945426f, -0.02669121f, -0.03669149f, 
    0.02663438f, 0.02228306f, -0.00131234f, -0.01575833f, 0.00776537f, -0.03803562f, 0.01564686f, 0.01046189f, 
    -0.01126270f, 0.01418032f, -0.01830796f, -0.01614161f, -0.00531818f, 0.02285528f, -0.03535465f, -0.01553113f, 
    -0.04237474f, 0.01135674f, -0.03813720f, 0.02523274f, 0.02345575f, 0.02722403f, 0.01163956f, -0.04290920f, 
    0.01115772f, -0.02724749f, -0.02214664f, 0.00902396f, 0.02491813f, -0.01732788f, 0.00904637f, 0.01634850f, 
    0.00571694f, -0.01938222f, -0.01823354f, -0.03445043f, -0.02717053f, -0.02867718f, -0.03194158f, -0.03304091f, 
    -0.00401205f, 0.01021144f, 0.01589824f, -0.00927553f, 0.00019562f, -0.04130819f, 0.02170596f, 0.02609877f, 
    0.01539886f, -0.02752640f, -0.00360501f, -0.02666101f, 0.02308764f, -0.03704868f, 0.02740268f, -0.01320782f, 
    0.02373972f, -0.00433406f, -0.03464968f, -0.02042236f, -0.02111523f, 0.01410447f, -0.02065085f, -0.02246176f, 
    -0.02390223f, 0.01084863f, 0.01342541f, 0.01121137f, 0.03276790f, 0.01679502f, -0.03973386f, -0.01816014f, 
    0.00997940f, 0.00956310f, 0.02633542f, 0.01797359f, -0.02457201f, -0.02701012f, 0.01501282f, 0.00078887f, 
    -0.04038667f, 0.00581197f, -0.01007644f, -0.03660658f, -0.04203937f, 0.00263333f, -0.02589957f, -0.01134216f, 
    -0.00216564f, -0.01982642f, -0.03447095f, -0.00865968f, -0.01938505f, 0.01889382f, 0.03121565f, -0.00450465f, 
    0.01507847f, 0.02399343f, -0.02697808f, 0.01276402f, 0.02154129f, -0.04179206f, 0.00312294f, -0.02485010f, 
    -0.03516020f, -0.02051359f, -0.03034468f, 0.01449030f, 0.00308148f, 0.02212289f, -0.04414612f, 0.02857525f, 
    -0.00272602f, 0.02207157f, 0.02211811f, 0.01791126f, 0.01857877f, -0.02099857f, 0.03065162f, 0.02621696f, 
    -0.02707828f, -0.04106807f, -0.00630333f, 0.02202689f, 0.00072249f, 0.02417289f, -0.02890600f, -0.00978262f, 
    -0.03954371f, -0.01988008f, 0.00383101f, 0.00501519f, -0.03285625f, -0.01861895f, -0.00886602f, 0.01412124f, 
    0.01889662f, -0.00138965f, -0.00661172f, 0.00275293f, 0.01927235f, -0.02990121f, 0.03490347f, 0.02788755f, 
    -0.03099034f, -0.01729493f, -0.02905460f, 0.00006363f, -0.00522153f, 0.00146477f, 0.02619541f, -0.04314019f, 
    0.03471581f, -0.00697364f, -0.01505665f, -0.01242577f, 0.02404157f, -0.00060229f, -0.01379126f, 0.01956295f, 
    -0.04107676f, 0.01549524f, 0.02279277f, 0.00358557f, -0.03457497f, -0.02738361f, 0.00656102f, -0.00065264f, 
    -0.00171918f, -0.02502822f, 0.01395844f, -0.00973805f, -0.03746602f, -0.01618063f, -0.00994086f, -0.00163764f, 
    -0.00111412f, -0.01516817f, 0.02864620f, -0.00076716f, 0.01278544f, 0.01409003f, 0.02738661f, -0.00625063f, 
    0.01379460f, -0.00387081f, -0.00776903f, -0.00103919f, 0.02003077f, -0.01346406f, -0.03720884f, 0.01506524f, 
    -0.02000182f, -0.02172394f, -0.04045950f, -0.00829444f, 0.02099070f, 0.01065948f, 0.00693591f, -0.01487915f, 
    -0.02934031f, 0.00966960f, 0.01610065f, -0.01813261f, 0.03312781f, 0.00259978f, 0.03004161f, 0.02244808f, 
    -0.00737550f, -0.04201427f, 0.00142614f, -0.02103110f, 0.01247589f, -0.02100717f, 0.01904974f, 0.00310015f, 
    -0.00800845f, 0.02615426f, 0.01155243f, 0.00254802f, 0.01274572f, -0.03360102f, -0.01398841f, -0.00671272f, 
    0.00584956f, -0.02123553f, 0.01016252f, -0.00637823f, 0.00252843f, 0.00299302f, -0.01218848f, 0.01882903f, 
    -0.04114625f, 0.00764539f, -0.00183846f, -0.01525751f, -0.01003286f, -0.00041581f, 0.03182483f, 0.02474784f, 
    -0.03395785f, -0.02340398f, 0.00345402f, -0.01618691f, 0.01969751f, -0.02401274f, -0.00658343f, 0.00792872f, 
    -0.03569790f, -0.03558118f, 0.02662054f, -0.00574446f, 0.00804881f, -0.01486807f, -0.01185892f, 0.01139077f, 
    -0.02866144f, 0.00049222f, -0.04108376f, -0.02437015f, 0.00997494f, -0.03123686f, -0.02979408f, 0.01719606f, 
    0.01475838f, 0.01193103f, -0.02681654f, -0.04071283f, 0.02205339f, 0.02229159f, 0.01891100f, -0.01418235f, 
    0.00508204f, 0.02554172f, -0.00342234f, -0.00204108f, 0.01808937f, 0.02154306f, 0.02558131f, 0.01091974f, 
    -0.02041554f, -0.01952696f, -0.04044721f, -0.03904411f, 0.00370446f, 0.01505240f, 0.02663500f, 0.02373971f, 
    -0.03054120f, -0.02873667f, 0.03067353f, -0.04260692f, -0.00902261f, -0.02507920f, -0.00136928f, 0.01497355f, 
    -0.03405019f, -0.03750824f, -0.00485669f, 0.01086610f, 0.02423622f, 0.02120166f, -0.03277560f, -0.03698292f, 
    -0.03605090f, -0.03836899f, -0.01877315f, -0.03536289f, 0.01513860f, 0.03884486f, 0.02493682f, 0.00118194f, 
    0.00586172f, 0.00992120f, 0.01149077f, 0.00765393f, 0.02405288f, 0.02553327f, -0.01182709f, -0.00331030f, 
    0.02340645f, 0.02394410f, 0.02604934f, 0.00539588f, -0.03100679f, -0.02543958f, 0.00857244f, 0.02507033f, 
    -0.01865598f, -0.02369437f, -0.01751131f, 0.00044460f, -0.02864433f, -0.01831367f, -0.00134535f, -0.01732157f, 
    0.00565278f, 0.03665395f, 0.01541775f, -0.01003836f, 0.02910263f, -0.03559108f, -0.02599474f, -0.02127651f, 
    0.01368213f, -0.04145795f, -0.02773242f, -0.01636480f, 0.02023214f, 0.02085863f, -0.01387398f, -0.03499246f, 
    -0.03741133f, -0.02557111f, -0.02392046f, -0.00126127f, -0.00565658f, -0.02372201f, 0.01166898f, 0.00305224f, 
    0.01526460f, -0.02826732f, -0.02554280f, -0.01954345f, -0.02813711f, -0.03491113f, 0.02349350f, 0.00111072f, 
    -0.02438443f, -0.01715591f, 0.00415530f, 0.01915877f, -0.01705535f, -0.01454415f, -0.01529278f, 0.00831118f, 
    0.02851610f, -0.02476965f, 0.00773241f, -0.01733940f, -0.00403214f, 0.00818967f, 0.00940997f, -0.02696127f, 
    0.00047898f, 0.02511013f, -0.03344139f, -0.01438305f, -0.03337368f, -0.04294402f, 0.01848736f, -0.02982065f, 
    0.01937223f, 0.02701062f, 0.02439895f, -0.01610067f, -0.02111646f, 0.01194728f, 0.00856447f, 0.03006157f, 
    -0.00531501f, -0.03807497f, 0.02686616f, 0.00069878f, -0.02944371f, -0.01465636f, 0.02689741f, 0.00731364f, 
    -0.00148240f, 0.00011833f, -0.01333504f, -0.03927446f, -0.01385586f, -0.03085799f, -0.03485451f, -0.02512964f, 
    0.03420772f, -0.03344061f, 0.03490721f, -0.02062356f, 0.03169468f, 0.02157805f, 0.00946368f, -0.01207042f, 
    -0.00784656f, -0.03827206f, 0.00125322f, -0.01857029f, 0.02655486f, 0.01116967f, -0.02035017f, -0.03249585f, 
    -0.02516052f, -0.00965868f, 0.01414543f, -0.01803457f, 0.01393991f, 0.02600082f, -0.01334575f, 0.00298314f, 
    -0.03603991f, -0.00131591f, -0.01922184f, -0.02011818f, -0.02305062f, -0.03338467f, -0.00864458f, 0.00328384f, 
    -0.03151337f, -0.02365701f, 0.03058098f, 0.02488148f, -0.02303863f, 0.01197528f, -0.02961771f, 0.01160083f, 
    -0.01225552f, 0.01788928f, 0.02509995f, -0.01248557f, -0.01540176f, 0.00766309f, -0.01832265f, -0.01647247f, 
    -0.01718219f, -0.03075254f, -0.02317714f, -0.01376023f, -0.03047703f, 0.03200108f, 0.03000161f, 0.03095273f, 
    0.02470338f, 0.01600983f, 0.01885006f, -0.01206953f, 0.01282758f, -0.02133709f, 0.01308340f, 0.02003836f, 
    -0.01258583f, -0.03916109f, 0.00621164f, -0.01934876f, 0.02107184f, -0.02962198f, 0.02744675f, 0.00660600f, 
    -0.00112158f, -0.01461484f, 0.01764886f, -0.03510278f, 0.01567071f, 0.00473466f, -0.01868877f, -0.00491562f, 
    0.00124874f, 0.01246281f, -0.03186816f, -0.03318824f, -0.01705930f, -0.02923796f, -0.00382096f, 0.01485966f, 
    -0.01893218f, 0.00434521f, 0.00066883f, -0.02414913f, 0.01519812f, -0.00025529f, -0.00399869f, 0.01968751f, 
    -0.00870522f, -0.00782339f, -0.02684007f, -0.01261760f, 0.03010863f, -0.01750739f, 0.03081142f, 0.02337574f, 
    -0.01961682f, -0.00189504f, -0.01830381f, -0.02319170f, -0.01416561f, 0.02543203f, 0.00942813f, 0.00095935f, 
    0.02407897f, -0.01009554f, 0.02385771f, 0.01397515f, -0.02749408f, 0.02476682f, -0.01483459f, 0.02878207f, 
    -0.03910781f, -0.03229035f, -0.01854941f, -0.04030375f, 0.00585939f, 0.00687175f, 0.00694044f, 0.00062148f, 
    0.02462460f, -0.00573475f, 0.00480940f, 0.01209715f, 0.02423043f, -0.01185421f, 0.01942435f, 0.02455797f, 
    0.01708682f, 0.03611214f, 0.00031429f, 0.00998075f, 0.02042489f, -0.02633082f, -0.02661823f, -0.00307765f, 
    -0.02918535f, 0.02347697f, -0.03072974f, -0.00250871f, -0.03497638f, 0.01104220f, -0.00233418f, 0.01961849f, 
    -0.00397903f, 0.01036271f, -0.03818475f, 0.00247808f, -0.02073052f, -0.02748878f, -0.01110326f, -0.00802809f, 
    0.01145754f, -0.01101242f, 0.01982390f, -0.03684043f, 0.03033240f, -0.03323559f, 0.01197817f, -0.01116814f, 
    0.02884666f, -0.02417664f, -0.00187943f, 0.00717861f, 0.02077806f, -0.04013566f, -0.01902026f, 0.01556627f, 
    0.01005932f, 0.00685393f, -0.01082829f, -0.00300732f, 0.00994632f, -0.04150483f, -0.02042342f, 0.00566131f, 
    0.02984395f, -0.01170567f, 0.02304003f, -0.03199915f, -0.00496659f, -0.03342659f, -0.00847521f, -0.00179572f, 
    -0.00892836f, 0.02342292f, -0.03391603f, -0.01209453f, 0.00215128f, -0.03333512f, -0.00818530f, -0.01219379f, 
    -0.01690363f, 0.00627915f, -0.03253222f, 0.00422015f, -0.00897644f, -0.00410368f, -0.02385431f, 0.00642773f, 
    0.02282274f, 0.02295527f, 0.02990180f, 0.03556771f, 0.02103258f, -0.03476195f, -0.03489942f, -0.02756905f, 
    -0.01992245f, 0.00865436f, -0.00200075f, -0.02009959f, -0.02835022f, 0.03088683f, 0.00430467f, -0.01973368f, 
    -0.00817429f, -0.03442948f, -0.02395180f, -0.01597114f, 0.01093404f, 0.02176124f, -0.00477627f, -0.03913222f, 
    -0.00306458f, 0.00678880f, -0.00289730f, 0.02646006f, 0.00652332f, 0.02884481f, 0.01159138f, 0.02540741f, 
    0.02258733f, 0.00747345f, -0.02201104f, -0.00234341f, -0.00122551f, -0.02119190f, 0.02186794f, 0.01772229f, 
    0.01510791f, -0.00009090f, -0.02608264f, 0.01982647f, -0.01453053f, 0.00444747f, -0.02922142f, 0.01912270f, 
    0.00751613f, 0.02250096f, 0.00775337f, -0.03315315f, 0.00760115f, 0.03829155f, -0.00530083f, 0.00574917f, 
    -0.04023661f, 0.01485721f, -0.01164018f, 0.00289760f, 0.01138900f, -0.03322855f, -0.01492584f, -0.00993521f, 
    -0.01747439f, 0.01894105f, -0.01599803f, 0.01123655f, 0.02050916f, -0.01408303f, 0.01214812f, -0.02739967f, 
    0.02482150f, -0.00020874f, -0.03174583f, 0.00208820f, 0.01670952f, -0.00829890f, -0.03600123f, -0.02234540f, 
    0.00507950f, 0.01445498f, 0.00679212f, -0.02004336f, 0.01991728f, -0.02354090f, -0.02342578f, -0.02958947f, 
    -0.00755321f, 0.00283622f, -0.04125022f, -0.00090841f, 0.02101194f, -0.00243499f, 0.02751068f, -0.00663411f, 
    -0.01191415f, -0.03390845f, 0.01704555f, 0.02792756f, -0.02691640f, 0.00202587f, 0.00503394f, 0.00917750f, 
    -0.03224724f, -0.02458920f, -0.03750088f, 0.01184877f, 0.01486502f, -0.00791582f, -0.00411215f, 0.02376800f, 
    0.01197962f, -0.03645075f, 0.01972890f, 0.00236270f, 0.02708736f, 0.01756924f, -0.02029196f, -0.01618059f, 
    -0.00145240f, 0.01222663f, -0.00193483f, -0.00068437f, -0.00506781f, -0.01409866f, 0.01412829f, 0.02992044f, 
    0.02851231f, -0.02735270f, -0.01976231f, -0.03376652f, -0.03980428f, 0.02266425f, 0.00709499f, 0.02614740f, 
    0.02593362f, 0.00485714f, -0.03956210f, -0.00720620f, -0.00233044f, 0.00068263f, 0.02996117f, 0.00273992f, 
    -0.02174334f, -0.03120169f, -0.01929187f, 0.00277929f, -0.01251988f, 0.01367100f, 0.00772369f, 0.00488228f, 
    -0.00947932f, -0.00327512f, -0.02400402f, -0.02351556f, -0.02163304f, 0.02101798f, 0.00357305f, -0.00993996f, 
    0.00279895f, 0.00972855f, -0.00516303f, -0.02753529f, -0.00064182f, -0.02994398f, 0.02882545f, -0.04210245f, 
    -0.03176009f, -0.02675540f, 0.00446236f, -0.03606760f, 0.02004158f, 0.01103876f, 0.02205091f, -0.01134081f, 
    -0.02497050f, 0.02923365f, 0.01050367f, 0.02434715f, -0.01362723f, -0.02094895f, -0.03407252f, -0.00175674f, 
    -0.00001884f, 0.02025999f, 0.00103727f, 0.01005718f, 0.03081223f, 0.01378511f, -0.00309984f, 0.00098553f, 
    0.00928465f, 0.02214381f, 0.01589180f, -0.03863522f, -0.01425567f, -0.02350512f, 0.01476940f, -0.03220847f, 
    -0.01879568f, 0.02213657f, -0.02217948f, -0.01097150f, 0.01031195f, -0.02214946f, -0.04111794f, -0.02128517f, 
    0.02875522f, 0.01923911f, -0.01094868f, -0.01710474f, 0.02252588f, 0.02702296f, 0.01722235f, 0.03303021f, 
    0.02666951f, 0.00685604f, -0.01421892f, -0.02810612f, -0.01773699f, -0.01277269f, -0.01038542f, -0.03453156f, 
    0.00331708f, 0.01332680f, 0.00485414f, -0.02117666f, -0.03230368f, 0.02898630f, 0.00984892f, -0.01303520f, 
    -0.02720267f, 0.01768488f, -0.03734688f, -0.03535759f, 0.01890341f, -0.00324803f, 0.01519488f, 0.01298684f, 
    -0.01875104f, -0.02790999f, 0.02124288f, -0.00239695f, -0.03572633f, 0.00919262f, -0.00983590f, -0.02043244f, 
    -0.01427305f, -0.03762863f, -0.01713899f, -0.03084225f, 0.01566278f, -0.01563726f, 0.01497073f, -0.03402122f, 
    -0.03954093f, -0.01351629f, -0.01367517f, -0.03698313f, 0.01710062f, 0.02161749f, -0.02342437f, 0.00267604f, 
    -0.01078278f, -0.00193878f, 0.00510474f, 0.02641900f, -0.00276662f, -0.00252629f, 0.02388671f, -0.01429952f, 
    0.02059194f, 0.03816291f, -0.01697384f, -0.00428365f, -0.01779621f, 0.02935832f, 0.00794061f, -0.02513013f, 
    0.02920160f, 0.02462812f, 0.00355653f, 0.02480863f, -0.00765336f, 0.02745923f, -0.02622263f, -0.00815965f, 
    -0.00950000f, 0.02346348f, 0.00200194f, -0.03744608f, 0.01586857f, -0.02282714f, -0.02132162f, -0.00404062f, 
    0.02571221f, 0.02791202f, -0.01599385f, -0.01201870f, 0.00955052f, 0.01696132f, 0.01013688f, -0.02127852f, 
    0.00242528f, 0.01678706f, -0.03457501f, -0.01602738f, -0.00249720f, 0.01363798f, -0.00403562f, -0.03373353f, 
    -0.03484604f, -0.00664590f, 0.00303459f, -0.01505333f, 0.03122507f, 0.00691835f, -0.01732733f, -0.00579886f, 
    -0.00876761f, 0.01218255f, 0.01238004f, 0.00885208f, 0.01318458f, -0.00320537f, 0.01267139f, -0.02567138f, 
    -0.00633308f, -0.02162562f, -0.00937297f, -0.02971313f, -0.01111887f, -0.01874316f, -0.03128841f, -0.00748383f, 
    0.01375649f, -0.03240727f, -0.03389842f, -0.02226425f, -0.01241642f, -0.02385733f, -0.02805571f, 0.01945049f, 
    -0.02063834f, -0.00048790f, 0.00279328f, 0.00758457f, 0.02517847f, -0.00291095f, -0.01095836f, 0.00859917f, 
    -0.03844936f, 0.03227027f, -0.01763864f, 0.00497064f, -0.00780261f, 0.01820176f, -0.01924604f, -0.00399486f, 
    0.01358255f, -0.03259603f, -0.02033292f, 0.02957718f, 0.02851087f, -0.02154739f, -0.00963725f, 0.02724614f, 
    -0.01195101f, -0.04078502f, -0.00447164f, -0.04239996f, 0.03073212f, -0.02909245f, -0.00855071f, -0.03092246f, 
    -0.01239449f, -0.01903818f, 0.00236376f, 0.01396392f, -0.00888739f, -0.00408565f, 0.02864808f, -0.00119648f, 
    0.02998304f, 0.03130772f, -0.00684763f, -0.02929907f, 0.01329626f, -0.02058427f, -0.03202486f, 0.01567028f, 
    0.02460688f, 0.00133999f, -0.00330669f, -0.02987160f, -0.03355917f, -0.00781398f, 0.02901622f, -0.02823581f, 
    -0.01423839f, -0.00548848f, -0.02813621f, -0.00535233f, -0.03162143f, 0.00192873f, -0.02710889f, 0.01906065f, 
    0.00742062f, 0.01428478f, -0.00402229f, 0.02177943f, -0.03788044f, 0.02374296f, 0.01781541f, -0.02509232f, 
    0.00969266f, 0.01154936f, -0.02642983f, -0.03268955f, 0.02880987f, 0.00499774f, -0.01181011f, -0.02025663f, 
    0.01853134f, -0.02023184f, -0.03852169f, 0.01645861f, 0.01072622f, -0.02225588f, 0.03161438f, 0.00782196f, 
    -0.02983647f, 0.01145294f, 0.01192961f, -0.02070794f, -0.00632938f, 0.02817609f, 0.03493433f, 0.00654748f, 
    -0.02942043f, -0.04127859f, -0.03086667f, -0.00569685f, 0.00352757f, -0.02058197f, -0.02422607f, -0.02861149f, 
    -0.00712684f, 0.00155843f, -0.02461215f, 0.01915498f, 0.02509320f, -0.00288765f, 0.00015317f, 0.01946093f, 
    0.00045602f, -0.03793030f, -0.00378122f, 0.00705047f, -0.02240873f, -0.02840510f, 0.01488299f, -0.00538272f, 
    -0.00338695f, -0.01538472f, 0.02338997f, 0.03743987f, 0.01715240f, 0.00018310f, -0.02737820f, -0.00372146f, 
    -0.01942139f, 0.00159033f, 0.02482369f, -0.03888394f, -0.03379986f, 0.02934400f, 0.02728858f, -0.00752507f, 
    -0.00594830f, 0.01723735f, 0.02442056f, -0.02633793f, -0.01779388f, -0.02563509f, -0.02168160f, -0.01715776f, 
    0.02486844f, 0.02180737f, 0.02826294f, -0.01676194f, -0.03491427f, 0.03267976f, -0.00482611f, 0.00493060f, 
    -0.01651097f, 0.01985559f, -0.00516939f, -0.03545289f, -0.02796772f, -0.01955500f, -0.02289344f, -0.01801780f, 
    0.02526894f, 0.01418738f, -0.00861046f, -0.03134773f, -0.00899154f, 0.01713893f, 0.00168227f, -0.04002686f, 
    0.01880576f, 0.01148929f, -0.01094728f, -0.00667791f, -0.00299976f, 0.01376283f, -0.01506520f, 0.02022510f, 
    -0.01956894f, -0.00272327f, 0.01578426f, 0.00581419f, -0.02458288f, 0.01529002f, -0.01237157f, 0.01257095f, 
    -0.02571176f, 0.01454869f, 0.02293290f, -0.03434394f, 0.01808116f, 0.00639498f, 0.02185210f, -0.00139249f, 
    -0.02975793f, 0.02735643f, -0.02336359f, 0.03267591f, 0.00706011f, -0.01186799f, 0.00474552f, 0.00803561f, 
    0.00555121f, -0.02554414f, -0.00817349f, 0.00198530f, -0.02139307f, -0.00507612f, -0.00191381f, -0.02987838f, 
    0.00550974f, 0.00846610f, -0.04419665f, -0.03401909f, 0.02835830f, -0.01695630f, -0.02440637f, -0.00858367f, 
    -0.02380741f, -0.02253820f, -0.00252277f, 0.02070753f, -0.02292151f, -0.01057442f, -0.03046019f, -0.03682705f, 
    0.03126061f, 0.03806812f, 0.02879339f, -0.02190526f, -0.01702807f, 0.03207329f, 0.01218230f, -0.00390058f, 
    -0.00017053f, -0.02904597f, -0.02360847f, -0.04495931f, 0.02113702f, 0.02545857f, 0.02377061f, 0.02661217f, 
    0.00387727f, 0.01758917f, -0.00885978f, 0.02015356f, -0.03605260f, -0.03625931f, 0.00669940f, -0.02062161f, 
    -0.01653835f, -0.03184312f, -0.02651755f, -0.02754269f, -0.03819027f, -0.04049178f, -0.01511573f, 0.00205180f, 
    -0.00498415f, 0.01425486f, 0.01902894f, 0.01728770f, -0.01119602f, -0.01977503f, -0.02659926f, 0.02587825f, 
    0.01538573f, -0.02869715f, -0.01887479f, 0.01395676f, 0.02695807f, 0.00872731f, -0.04087881f, -0.00038358f, 
    -0.01210971f, -0.00386494f, 0.01893009f, -0.02818955f, -0.03330118f, -0.00203139f, -0.00038014f, -0.02436396f, 
    0.01384374f, 0.03063134f, -0.02338477f, 0.00574174f, -0.02101023f, -0.04546363f, -0.01965266f, 0.01887857f, 
    -0.03718084f, 0.03370488f, -0.02440336f, -0.01468127f, 0.00865350f, -0.02514174f, 0.02486187f, -0.01525295f, 
    -0.00708293f, 0.01032280f, -0.02122874f, 0.00669606f, -0.03827338f, -0.00339624f, -0.01055081f, -0.04573511f, 
    0.02364092f, 0.02164857f, -0.01091193f, 0.02183880f, 0.00620230f, 0.02057886f, -0.01410567f, 0.02423464f, 
    -0.04332772f, 0.00610145f, 0.00617768f, 0.00937738f, 0.01624700f, -0.00497429f, -0.00788502f, 0.00422926f, 
    0.00345711f, -0.04218461f, -0.03080213f, 0.01546923f, -0.03123571f, -0.00374791f, 0.00721442f, -0.04187344f, 
    0.02134718f, -0.00391947f, 0.00992181f, -0.02226368f, -0.03663408f, 0.02696954f, 0.00637437f, 0.02943180f, 
    -0.00322185f, 0.01291569f, 0.00677026f, 0.00156882f, 0.02336647f, 0.00796033f, -0.04292870f, 0.00065695f, 
    0.00194590f, -0.00098199f, -0.02468912f, 0.00357213f, -0.01518014f, 0.01141030f, -0.00283191f, -0.03772596f, 
    0.01319947f, -0.02593243f, 0.02090904f, -0.01153006f, -0.03513209f, -0.03309651f, -0.04656681f, -0.00698864f, 
    -0.03970002f, 0.01037353f, 0.00601321f, -0.00805437f, 0.01480910f, -0.01361678f, 0.02980223f, 0.00719551f, 
    -0.00783194f, 0.01727448f, -0.03772951f, -0.02048621f, 0.00772057f, 0.00503584f, 0.02925754f, -0.03952274f, 
    -0.00173018f, 0.02477723f, -0.00709071f, 0.01653632f, 0.01539314f, -0.01395145f, 0.01911896f, -0.01121923f, 
    0.02403130f, 0.02508543f, -0.02260229f, -0.01295181f, 0.02670567f, -0.00420443f, -0.04240075f, -0.03241216f, 
    -0.02898355f, -0.00496984f, -0.03182974f, -0.00097893f, -0.02385211f, -0.04406288f, 0.02183712f, -0.00675137f, 
    0.02337174f, -0.01854396f, -0.00217580f, -0.02700771f, -0.02879133f, 0.01403022f, 0.01273800f, -0.03504166f, 
    0.00628813f, -0.00578689f, 0.00649583f, 0.02094697f, -0.00369904f, -0.03790514f, -0.03353636f, -0.00570034f, 
    -0.03538460f, -0.01453542f, -0.01931348f, -0.02105435f, 0.01012134f, -0.00227269f, 0.00745291f, -0.00194506f, 
    0.02032644f, -0.02608726f, 0.00108604f, 0.01393184f, 0.00165083f, -0.02030391f, -0.02742761f, -0.02255464f, 
    -0.03972325f, -0.00055403f, -0.00740719f, 0.00687495f, -0.03057113f, -0.02928802f, -0.00025375f, -0.02479899f, 
    0.02484114f, -0.02472626f, -0.04268423f, -0.03147514f, 0.02216873f, 0.00172241f, 0.01941090f, 0.01052479f, 
    0.02621872f, -0.01904889f, -0.00398214f, 0.01511927f, -0.03507047f, -0.01777220f, 0.00553421f, 0.01502740f, 
    -0.01305465f, -0.01888206f, -0.03485757f, -0.01934288f, 0.00085075f, 0.00561281f, 0.01108545f, 0.01693727f, 
    -0.02792655f, 0.00651082f, 0.00561327f, 0.00191487f, 0.02438846f, -0.03075111f, 0.00571864f, -0.01020184f, 
    0.01149737f, -0.03222959f, -0.01350452f, -0.00402866f, 0.01248767f, -0.00730019f, 0.02849521f, -0.01717513f, 
    0.03076562f, 0.01825694f, 0.00418432f, -0.00831809f, 0.00935682f, 0.01270278f, -0.00136742f, -0.01998910f, 
    0.00684349f, -0.02830119f, -0.03750369f, -0.03701372f, 0.00008173f, 0.01351548f, -0.01775626f, 0.01018454f, 
    0.02362128f, 0.01233841f, 0.01644117f, 0.01978504f, -0.01369124f, 0.02389520f, -0.02048852f, 0.00423231f, 
    0.02085466f, 0.02407749f, 0.01579827f, -0.02746294f, 0.01226562f, -0.00745127f, -0.03398879f, -0.02352500f, 
    0.01565318f, -0.04204985f, -0.03541365f, -0.04274661f, -0.01930697f, -0.02947408f, 0.02620706f, -0.02309683f, 
    0.01070166f, -0.02107679f, -0.00738208f, 0.02227139f, -0.01925149f, 0.00671602f, 0.02817192f, -0.03059496f, 
    0.00034214f, 0.02407294f, -0.00948109f, 0.02768276f, -0.02361956f, 0.01190666f, 0.01407883f, 0.00985506f, 
    0.00533724f, -0.00461703f, -0.04008231f, -0.01468568f, 0.00591092f, -0.04000720f, 0.00731610f, 0.01398295f, 
    -0.03342797f, 0.00257451f, -0.03216658f, 0.00428504f, 0.00528518f, -0.03772958f, -0.03561730f, -0.02394066f, 
    0.02006513f, -0.01745282f, -0.00271136f, 0.02273453f, 0.00138173f, -0.01750270f, -0.02700322f, -0.01732823f, 
    -0.03504108f, -0.03266281f, -0.02029503f, 0.02084615f, -0.04846036f, -0.00842696f, 0.00556080f, -0.03387009f, 
    -0.03676713f, 0.01721761f, -0.04134308f, 0.02143372f, 0.01674699f, 0.01793713f, -0.00908701f, -0.02728999f, 
    0.02487610f, 0.02937844f, -0.00016827f, -0.04211661f, -0.04145779f, 0.01517833f, 0.01906567f, -0.00414962f, 
    -0.02894028f, -0.02694713f, -0.00092963f, 0.01272078f, -0.03282301f, -0.04100171f, 0.00673971f, -0.01860280f, 
    -0.01141524f, -0.00311677f, -0.01579176f, -0.01986591f, 0.01713672f, -0.00424191f, -0.04058641f, -0.01320378f, 
    -0.02954343f, -0.00851286f, -0.00701118f, 0.00827380f, -0.03006009f, 0.00730781f, -0.01104337f, -0.03299829f, 
    -0.03484455f, 0.01479394f, -0.00619028f, -0.03111622f, 0.01793289f, 0.00889167f, 0.01807238f, -0.04661231f, 
    0.00106871f, 0.00649679f, -0.02757967f, 0.01522500f, 0.01850499f, 0.01498693f, -0.03395695f, 0.02893887f, 
    -0.02407192f, 0.02343340f, -0.00084105f, -0.02698393f, 0.01979769f, 0.00200857f, -0.02201920f, -0.00938122f, 
    0.01165592f, 0.01176390f, 0.00135952f, -0.01675618f, -0.00054871f, -0.00400462f, -0.00805367f, -0.00423100f, 
    0.00143968f, 0.02495476f, -0.00977260f, -0.00599073f, 0.02969692f, 0.02688587f, 0.00567448f, -0.00125496f, 
    -0.03291022f, -0.04566995f, 0.01800743f, 0.02132524f, 0.02165333f, -0.00437787f, -0.01885381f, 0.00900701f, 
    0.01852077f, -0.02482146f, 0.00217694f, -0.00056415f, 0.03152473f, -0.04096092f, 0.03129421f, -0.01681573f, 
    -0.00875279f, -0.04406873f, -0.01200811f, -0.00575250f, -0.02451375f, -0.00452256f, 0.03059745f, 0.00505489f, 
    0.01313098f, -0.02605265f, -0.03231934f, -0.02157347f, -0.02157354f, -0.04032566f, 0.01449351f, -0.03732199f, 
    -0.01995551f, 0.00184736f, -0.00296124f, -0.01296792f, -0.00493627f, -0.03179251f, 0.00269722f, -0.00386610f, 
    0.00856344f, -0.03832107f, 0.01905609f, -0.01258275f, 0.01678430f, -0.01910357f, 0.01422484f, 0.02868041f, 
    -0.00123244f, -0.03442767f, 0.02543673f, -0.02273641f, 0.01212001f, -0.00566723f, 0.01319725f, -0.01316289f, 
    0.01698062f, -0.00693494f, -0.01336446f, -0.03591246f, -0.01834257f, -0.00382850f, -0.00180378f, -0.00052843f, 
    -0.01605422f, -0.00619594f, -0.00768451f, 0.00043986f, -0.01128441f, 0.00400150f, -0.01418640f, 0.00958308f, 
    0.03426583f, -0.01824693f, 0.01475732f, -0.01167215f, 0.00463404f, -0.00431200f, -0.00509275f, 0.02335543f, 
    0.01231836f, 0.01931439f, 0.03085205f, -0.03259543f, 0.01402106f, 0.02087766f, -0.02657165f, 0.00417193f, 
    0.02197020f, 0.02061388f, -0.00196421f, -0.03077959f, -0.01878976f, -0.04322550f, 0.00536725f, -0.03356127f, 
    -0.03226247f, -0.02280475f, -0.01905221f, -0.03754039f, -0.02163231f, 0.02074574f, -0.01541886f, -0.01505758f, 
    0.00581327f, -0.01371965f, -0.03216730f, -0.02265164f, -0.00771246f, -0.02075192f, 0.01774157f, 0.02359924f, 
    -0.02157991f, -0.03778277f, -0.02854718f, 0.01263458f, -0.00019975f, -0.00769462f, -0.01661750f, -0.03848232f, 
    0.02095084f, -0.00457285f, 0.01912167f, -0.04334399f, 0.02837764f, -0.01824462f, -0.00911403f, -0.02260187f, 
    -0.01517703f, -0.02100240f, 0.01919307f, -0.01835116f, 0.02998822f, 0.02819757f, -0.01147578f, -0.01828263f, 
    -0.01969726f, 0.01909786f, 0.02809484f, -0.01459101f, -0.02367651f, 0.00962044f, -0.01638606f, 0.00390259f, 
    -0.03673014f, 0.00764796f, -0.02981620f, -0.00475158f, 0.02752983f, -0.02661534f, -0.00505923f, -0.01968256f, 
    -0.01248440f, 0.01852257f, -0.01714492f, -0.00184153f, 0.00150917f, 0.01091709f, -0.00987305f, -0.00532718f, 
    -0.00405071f, -0.01995458f, -0.01040548f, 0.03351665f, 0.01921416f, 0.00285302f, 0.01734943f, 0.00909274f, 
    0.01724578f, 0.00458129f, -0.04394167f, -0.03099149f, -0.00615073f, -0.02131303f, -0.00284587f, -0.00875256f, 
    -0.01354906f, 0.00323058f, 0.02551160f, 0.00438325f, -0.02672604f, 0.02932412f, -0.01966797f, -0.00399306f, 
    -0.01668530f, -0.03582005f, -0.01617757f, 0.01381116f, 0.00624651f, 0.02673145f, -0.01212173f, 0.00902226f, 
    0.02147293f, -0.03251833f, -0.00566698f, -0.02433180f, 0.00789250f, -0.04108818f, -0.01579520f, -0.01578676f, 
    0.01734056f, 0.03179611f, -0.03868921f, -0.01157248f, 0.01205737f, 0.03015778f, -0.00073970f, -0.04378098f, 
    -0.02962821f, 0.02172037f, -0.02542156f, 0.00890240f, 0.01637426f, 0.03651775f, 0.00747502f, -0.03181165f, 
    -0.01248505f, -0.00476163f, -0.03821126f, -0.02736956f, -0.00754282f, 0.01175807f, -0.02796617f, 0.02165133f, 
    0.01364420f, -0.03814179f, -0.02289242f, 0.00769091f, 0.00602505f, 0.03368772f, -0.02970482f, -0.00308239f, 
    -0.00655070f, -0.00187432f, -0.01711429f, 0.01915572f, 0.00758590f, -0.04245552f, 0.01337489f, 0.00444792f, 
    -0.01019709f, -0.03134055f, 0.02271956f, 0.02210297f, 0.02094625f, -0.00233856f, -0.02485185f, -0.02678898f, 
    0.02784105f, -0.00247060f, -0.01883885f, -0.03163224f, 0.02747341f, 0.02934251f, -0.03740203f, -0.03161828f, 
    -0.00878397f, 0.03227908f, 0.01209874f, 0.00220586f, 0.02832081f, -0.01751366f, 0.02939728f, -0.02781728f, 
    -0.03543608f, -0.04274197f, 0.03198363f, 0.00069015f, 0.00850031f, -0.01148215f, -0.02380781f, -0.04700766f, 
    0.01861130f, -0.00117786f, 0.01190680f, -0.00474681f, -0.02734479f, -0.00533537f, -0.01715668f, -0.01188607f, 
    0.03289870f, 0.01886678f, -0.02289097f, 0.02500625f, -0.02214642f, -0.03923727f, 0.00717054f, 0.02235844f, 
    -0.02837929f, -0.00181718f, -0.04033230f, -0.02045939f, -0.02685978f, -0.01935928f, 0.01391154f, -0.00743107f, 
    -0.02210947f, -0.02958559f, 0.02321958f, -0.01718371f, -0.00566010f, 0.02842840f, -0.01005692f, -0.04133159f, 
    0.01739502f, -0.00498017f, -0.02461204f, -0.04883553f, -0.03732455f, -0.03282782f, 0.00761968f, 0.01797930f, 
    -0.12226871f, -0.18855572f, -0.14962719f, -0.01763756f, 0.06731153f, 0.00934783f, -0.00566092f, 0.01668363f, 
    -0.01471661f, -0.06207922f, 0.06962913f, -0.06701253f, -0.16071482f, 0.12024477f, 0.09561194f, 0.21797444f, 
    -0.10648640f, 0.00543710f, 0.08757541f, -0.01680149f, 0.03682623f, 0.10461447f, 0.04046632f, 0.03074408f, 
    -0.08908014f, -0.14038137f, 0.07420357f, 0.11383809f, -0.00136339f, 0.01156095f, 0.07396842f, -0.03617663f, 
    0.02130839f, 0.14269198f, 0.03454789f, 0.14566362f, 0.23539573f, -0.05879796f, -0.01612845f, -0.06630857f, 
    0.06984779f, -0.02261772f, 0.08186878f, 0.03553050f, -0.01359943f, 0.03533284f, 0.06184182f, 0.17138374f, 
    0.00865023f, 0.27871490f, -0.18242240f, 0.00386158f, -0.10741981f, 0.13624841f, 0.14036350f, 0.06565534f, 
    0.02122326f, -0.10361386f, -0.00945037f, -0.02478718f, -0.14668727f, -0.11408398f, -0.35172707f, 0.02320263f, 
    -0.08087858f, -0.05635539f, -0.07133718f, 0.14937776f, 0.00089224f, 0.06137726f, -0.02131958f, -0.06105360f, 
    0.22531629f, 0.18002501f, 0.06807097f, 0.10889922f, 0.06695655f, 0.09170362f, -0.06778489f, 0.11510990f, 
    -0.01735578f, 0.08762126f, 0.19409041f, 0.11099924f, -0.14661680f, 0.04543744f, 0.05339310f, 0.04569998f, 
    -0.08314122f, 0.00883340f, 0.03658847f, -0.19901420f, 0.12868595f, -0.03819523f, -0.15434830f, 0.03920921f, 
    0.07313251f, 0.05243232f, 0.10909189f, -0.17765199f, -0.07272894f, -0.15475610f, -0.02532275f, -0.05772368f, 
    -0.07324231f, -0.05978798f, -0.07412431f, -0.10005637f, -0.19627939f, -0.15560867f, -0.13300538f, 0.06431670f, 
    0.08847278f, -0.00328231f, 0.11999393f, 0.18930478f, -0.03924624f, -0.08140844f, -0.10763042f, -0.01421323f, 
    0.16747402f, -0.17606157f, -0.16569476f, 0.02997656f, 0.02843771f, -0.07334226f, -0.08149231f, 0.04822184f, 
    -0.12305979f, 0.06483728f, 0.00213149f, 0.02100050f, 0.19003338f, -0.12918210f, 0.11920161f, 0.03901099f, 
    0.01930212f, 0.00349792f, -0.12130194f, 0.07185437f, 0.14718944f, 0.01716116f, 0.01792827f, 0.01552677f, 
    0.18318245f, 0.12028397f, 0.02353933f, -0.39612737f, -0.04237724f, 0.11860370f, -0.03156905f, 0.06730433f, 
    0.07159480f, 0.03165844f, 0.10121413f, -0.01310916f, -0.21982069f, -0.21055585f, -0.10271042f, -0.14184867f, 
    -0.04603639f, -0.03867625f, 0.17368703f, 0.04347783f, -0.09046285f, 0.07673956f, -0.10719933f, -0.03952254f, 
    -0.18848366f, -0.30635741f, 0.00972416f, -0.06579950f, 0.08812083f, 0.06823599f, 0.00259766f, -0.02263650f, 
    -0.00934710f, -0.03717481f, -0.04409201f, -0.01882328f, 0.26401260f, 0.15185772f, -0.10025667f, 0.15663780f, 
    -0.04427357f, 0.04973791f, 0.03494035f, -0.06830874f, 0.00186201f, 0.03846292f, 0.03267185f, 0.10207140f, 
    -0.12379913f, 0.08416762f, -0.03007121f, 0.11262686f, -0.03709283f, 0.03542211f, 0.04762856f, -0.03699701f, 
    -0.02449030f, 0.05076991f, -0.01162329f, 0.06579588f, -0.09832099f, -0.13032429f, 0.07462415f, -0.03871667f, 
    -0.02321991f, 0.04259469f, -0.14352225f, -0.08183517f, -0.12541808f, -0.00521364f, -0.09946511f, -0.10706105f, 
    -0.05235035f, -0.26559412f, 0.14360389f, -0.15977262f, -0.10970625f, 0.10294551f, -0.02966799f, 0.03444301f, 
    0.04889078f, 0.15191928f, 0.17493907f, -0.09484126f, 0.06905802f, -0.14563671f, 0.27968681f, 0.01210530f, 
    -0.09680971f, 0.10265612f, 0.05649660f, 0.08387402f, -0.00449131f, -0.01770302f, -0.02120287f, 0.09048521f, 
    -0.15358783f, -0.28391746f, 0.05019499f, 0.06690329f, 0.03854031f, -0.05562089f, -0.06711413f, -0.02690033f, 
    0.10040108f, -0.09742615f, 0.00902337f, 0.01233963f, -0.16815510f, 0.13546249f, 0.06440581f, -0.20044078f, 
    -0.10002822f, -0.11545461f, -0.00179791f, -0.02430910f, -0.04214040f, -0.01311425f, -0.06669001f, 0.03907242f, 
    0.05906365f, 0.09844618f, 0.03730944f, -0.11424977f, -0.03547993f, 0.03214645f, 0.00054515f, -0.09720901f, 
    0.08188296f, 0.11027461f, 0.04569754f, -0.00225250f, -0.27599609f, 0.17229971f, -0.17461249f, 0.19399297f, 
    -0.02511883f, 0.14214396f, 0.23757832f, 0.05573263f, 0.16363181f, 0.03606375f, 0.06177576f, 0.06067981f, 
    0.02946648f, 0.04532828f, -0.01801214f, -0.05967832f, -0.09357474f, -0.11761930f, -0.04426431f, -0.04904927f, 
    0.04148392f, 0.03769594f, -0.04306240f, 0.05647361f, 0.33497372f, -0.02294467f, 0.14227048f, 0.15730910f, 
    0.06879982f, -0.11147027f, 0.05805236f, -0.08207484f, 0.07206276f, -0.05181325f, 0.10433532f, 0.02480866f, 
    0.00039016f, 0.14294200f, -0.05702969f, 0.19771647f, -0.09850220f, -0.10244269f, -0.03144365f, -0.07430290f, 
    0.02402945f, -0.16136301f, -0.12594941f, 0.10111327f, -0.20262213f, -0.02100505f, -0.05278840f, -0.02840940f, 
    -0.01730267f, 0.10191523f, 0.03023449f, -0.01548368f, -0.03283093f, -0.01710972f, -0.01531637f, -0.02069280f, 
    -0.10137276f, 0.08716982f, 0.11007402f, 0.09541506f, -0.08622833f, -0.11487609f, -0.00787489f, -0.07647119f, 
    0.04984266f, 0.06199426f, 0.03186133f, 0.02410773f, 0.30818304f, -0.02597623f, -0.04070284f, 0.10134968f, 
    -0.08064657f, 0.05613547f, -0.05103629f, 0.03842257f, -0.03980638f, -0.13539954f, 0.01487513f, 0.09079339f, 
    -0.16215929f, 0.01029330f, 0.06793760f, -0.00275311f, 0.00959535f, -0.02544730f, 0.20992649f, 0.05306517f, 
    0.05698411f, 0.08297078f, 0.12483499f, -0.00823240f, -0.12813790f, -0.21697965f, 0.23711845f, 0.15353416f, 
    0.02038096f, -0.00518608f, -0.18137275f, -0.00745680f, -0.15986007f, 0.02285827f, -0.08712824f, -0.08651711f, 
    0.04171592f, 0.00594600f, 0.10388199f, 0.03430596f, 0.04859326f, -0.05247080f, 0.07930048f, -0.01822717f, 
    0.18300149f, 0.00584392f, -0.02166340f, -0.02173054f, 0.18418960f, -0.13877010f, 0.34879577f, 0.29542071f, 
    0.06661575f, 0.13054529f, -0.09216078f, 0.06830943f, -0.00454384f, 0.04759360f, 0.05658368f, 0.01711426f, 
    -0.16179414f, -0.01310355f, -0.03736049f, -0.13510962f, -0.06451125f, -0.02465443f, -0.09157266f, -0.00228334f, 
    -0.09048937f, -0.00580378f, 0.12028746f, -0.09239924f, -0.01657546f, 0.02262303f, 0.09112059f, 0.29166245f, 
    -0.07675730f, -0.04504139f, 0.06406037f, -0.03385629f, -0.05668028f, -0.09874788f, 0.00457244f, 0.01930855f, 
    -0.04359937f, -0.00266679f, 0.13303308f, -0.23970143f, -0.00981791f, 0.01252706f, -0.09166539f, -0.04254381f, 
    0.12502353f, 0.04728814f, 0.08174629f, -0.06549627f, 0.08371248f, -0.16572180f, -0.16622028f, 0.04195883f, 
    0.05132236f, 0.11498257f, 0.01868390f, 0.12672113f, 0.00886479f, 0.05031680f, 0.02238127f, 0.02301590f, 
    0.02555692f, -0.08799212f, 0.08629432f, 0.18626729f, 0.03087042f, -0.07455673f, -0.05267205f, 0.18059269f, 
    0.11466857f, 0.07599363f, -0.09810318f, 0.04899079f, 0.09772207f, -0.24017784f, 0.12855732f, 0.10606477f, 
    0.04095330f, -0.00439621f, -0.05202953f, -0.14874603f, 0.09289813f, 0.13795982f, 0.06236061f, 0.05036614f, 
    0.35148528f, 0.21291509f, -0.09514182f, -0.07443251f, -0.11667790f, -0.00654925f, 0.00966277f, -0.01885669f, 
    0.00274023f, 0.09358991f, 0.11543348f, 0.00801941f, 0.03074844f, 0.11095142f, 0.21203564f, -0.10865419f, 
    0.06576423f, -0.14533429f, -0.09001903f, 0.09025492f, -0.03378652f, -0.05281094f, 0.04205470f, 0.00976207f, 
    -0.04199727f, -0.18748763f, 0.01525850f, -0.02662857f, 0.01133701f, -0.06203252f, -0.00045411f, 0.02835087f, 
    -0.07596973f, 0.01716059f, 0.02535866f, -0.09432030f, -0.09380378f, -0.22860907f, 0.33190572f, -0.07149187f, 
    0.01612203f, -0.06795301f, -0.08653691f, 0.09482027f, 0.15068965f, -0.07888689f, -0.02761046f, 0.02590070f, 
    0.31470948f, 0.00288759f, 0.09038449f, -0.34354916f, -0.08314577f, -0.10680386f, 0.06015935f, -0.05243909f, 
    -0.03931912f, 0.06949192f, 0.02023645f, 0.11409543f, -0.12836073f, -0.02503107f, -0.14934717f, -0.06728166f, 
    -0.01789464f, -0.05661304f, 0.22179139f, 0.04910910f, 0.06999863f, -0.02921137f, -0.08476029f, 0.08065644f, 
    -0.22252516f, 0.26755893f, 0.13678770f, 0.03724467f, -0.03705767f, 0.02712126f, -0.00641258f, -0.04751123f, 
    -0.11940689f, -0.06326901f, -0.11506838f, 0.00290603f, -0.02919161f, 0.18564332f, 0.12873417f, 0.06968636f, 
    0.00111715f, 0.12330632f, 0.02329589f, -0.09423541f, 0.02005990f, -0.09451623f, -0.05627665f, 0.06387726f, 
    0.02328779f, 0.14392585f, 0.03714305f, 0.08479353f, 0.00428242f, -0.16951229f, 0.05842920f, 0.05074982f, 
    0.01232595f, 0.08288676f, 0.10644414f, 0.12015160f, 0.47732383f, 0.11751479f, -0.20705512f, -0.12492032f, 
    -0.04807062f, 0.11466124f, -0.05313994f, 0.03996868f, -0.08061833f, 0.07461536f, 0.04185589f, 0.16366786f, 
    0.32464918f, 0.15873064f, -0.28524572f, -0.14122772f, -0.02664679f, 0.05271978f, 0.03781551f, -0.03330461f, 
    -0.07372826f, 0.06458977f, -0.11154791f, 0.15580299f, -0.20331077f, -0.37625018f, -0.06412371f, 0.04076547f, 
    0.04519507f, 0.13333052f, -0.00235553f, 0.05233040f, -0.03408055f, -0.09365894f, 0.03003913f, 0.02399238f, 
    0.15559000f, -0.12490624f, -0.03461993f, 0.23291610f, -0.02242324f, -0.09336412f, 0.06436288f, 0.04538059f, 
    -0.07928750f, 0.23497064f, 0.07893287f, 0.03645483f, -0.13085541f, 0.07225548f, 0.01539166f, 0.09538119f, 
    0.03332704f, 0.05452035f, -0.13309194f, 0.04894735f, -0.03401581f, -0.06760679f, 0.01437105f, -0.05210297f, 
    0.04322954f, 0.04348091f, 0.01607272f, 0.19961272f, -0.01469318f, -0.07032409f, 0.04494149f, -0.07188900f, 
    0.13215952f, 0.13623478f, 0.03261936f, 0.00138672f, -0.04499336f, 0.11244115f, -0.06797351f, 0.11820148f, 
    0.05299428f, 0.05023600f, 0.03732404f, -0.00675227f, 0.02731318f, 0.16730681f, 0.06115805f, 0.15585166f, 
    -0.17724641f, -0.14410025f, 0.17019968f, -0.21085849f, -0.14741178f, 0.02798475f, 0.15768090f, 0.04004614f, 
    -0.06872719f, -0.00920028f, -0.12825426f, 0.01735510f, 0.31618014f, 0.44610649f, -0.10074776f, -0.27610704f, 
    -0.15942347f, -0.11245882f, 0.05481580f, 0.00027790f, -0.09414779f, -0.01131740f, 0.14501098f, 0.05833038f, 
    -0.04078215f, 0.00175080f, -0.18811159f, 0.04912866f, -0.05291819f, 0.05188416f, 0.14824507f, 0.02727822f, 
    -0.05172762f, 0.11922126f, -0.08098900f, -0.07525600f, -0.08991161f, 0.15246813f, 0.19107749f, -0.04234535f, 
    0.04431713f, 0.00746769f, -0.08337414f, 0.05147867f, 0.14728568f, -0.02753318f, 0.04258615f, 0.06456080f, 
    -0.22414929f, -0.01907724f, 0.07858431f, -0.04544188f, 0.03232792f, -0.07184178f, 0.07088476f, -0.00551114f, 
    0.05224192f, -0.02217098f, 0.04055326f, 0.03614262f, -0.11310735f, -0.15324274f, -0.27181464f, -0.13173664f, 
    0.05710573f, 0.04072534f, -0.01116375f, -0.11462911f, 0.05254252f, -0.05843941f, -0.05868547f, -0.03070675f, 
    0.01980239f, 0.02599543f, -0.08169874f, 0.04578659f, 0.07310662f, 0.07220864f, 0.02857248f, -0.05717622f, 
    -0.04866244f, 0.03410523f, 0.03305859f, -0.13503632f, -0.02027742f, 0.02381705f, -0.03651724f, -0.15483005f, 
    0.03507312f, -0.03400056f, 0.09570114f, 0.00287879f, -0.08457425f, -0.00173944f, 0.10200509f, 0.03341668f, 
    -0.24451187f, -0.16791093f, -0.22493993f, -0.23071750f, 0.02399692f, -0.08005186f, 0.04833665f, -0.03067005f, 
    -0.01648394f, -0.03142715f, -0.01541591f, 0.01301212f, -0.08824454f, 0.19349557f, 0.25075239f, 0.04452512f, 
    -0.12471170f, -0.14992954f, 0.06714085f, 0.04458582f, 0.02905097f, 0.06721581f, 0.03327584f, 0.00347675f, 
    0.19873360f, 0.18415040f, -0.09798224f, -0.13920648f, -0.01515060f, -0.18613258f, 0.10701172f, -0.04689566f, 
    0.02516531f, 0.19944961f, 0.00736087f, 0.04676892f, 0.24188282f, -0.21101616f, 0.22699186f, -0.19852313f, 
    0.18702812f, 0.09113710f, 0.08028773f, 0.03774926f, 0.01966857f, 0.00877543f, 0.18913873f, 0.23126699f, 
    -0.24591200f, 0.01238979f, -0.08827444f, 0.12839246f, -0.10939924f, 0.12745173f, 0.12337200f, -0.05724913f, 
    -0.02052867f, 0.03109792f, -0.03902296f, -0.16354261f, -0.40007550f, -0.34668863f, -0.14993653f, 0.13157053f, 
    -0.15457667f, -0.02575662f, -0.10438897f, -0.02601119f, -0.13716717f, -0.00561986f, -0.00185323f, 0.04940145f, 
    -0.00489937f, -0.00553319f, -0.11893095f, 0.20794724f, -0.13007887f, -0.16791001f, 0.01563731f, -0.06279490f, 
    -0.00946038f, 0.10119126f, -0.04319956f, 0.03921190f, 0.28784716f, 0.09642728f, -0.08314849f, 0.26240429f, 
    0.06642200f, 0.28678420f, 0.17149305f, 0.13144864f, 0.01098671f, -0.02128059f, 0.11015493f, -0.07323682f, 
    0.02029592f, -0.05266005f, -0.01568119f, -0.03367866f, -0.02346298f, 0.01320701f, 0.01827795f, 0.03609742f, 
    0.17452472f, -0.04043650f, 0.01060066f, -0.04825563f, -0.18948369f, 0.07703637f, 0.21557477f, 0.04839515f, 
    0.02289770f, -0.04673699f, -0.05510064f, 0.00939709f, -0.22253492f, -0.04763980f, -0.05735384f, 0.01215386f, 
    -0.11327075f, -0.02570996f, 0.28765494f, 0.02317646f, -0.22094567f, -0.10037669f, 0.04181637f, 0.20411325f, 
    -0.23940904f, -0.04160418f, -0.10929998f, -0.08449887f, 0.05956364f, -0.02366385f, 0.24253817f, 0.25380087f, 
    0.12162372f, -0.02306127f, 0.02819091f, 0.07936139f, 0.05042210f, 0.06638064f, 0.02563626f, 0.03493892f, 
    0.02243797f, 0.21071954f, -0.02041037f, 0.36593014f, 0.06233604f, 0.05591079f, -0.00698612f, 0.06242717f, 
    0.03014949f, 0.01693711f, 0.06558071f, 0.12782964f, -0.28608823f, -0.08892171f, -0.02260108f, -0.03485064f, 
    -0.13621117f, -0.06823219f, -0.02157492f, -0.11017930f, 0.03164887f, -0.02563730f, -0.06049826f, -0.02923747f, 
    -0.19582236f, -0.10229621f, 0.10062777f, -0.09705327f, -0.07076909f, 0.02014711f, -0.00850609f, 0.02636548f, 
    0.02217013f, 0.01447818f, 0.00235222f, -0.03251632f, -0.14598864f, 0.26241821f, 0.15634006f, 0.03519101f, 
    -0.12674792f, -0.01833467f, 0.03230728f, 0.07556310f, 0.04679574f, 0.01972706f, -0.00907390f, -0.02022846f, 
    0.07745541f, 0.36928746f, 0.27987632f, 0.05520895f, -0.08572081f, -0.07125159f, 0.00178487f, 0.03017952f, 
    -0.03589526f, 0.07036737f, 0.09434935f, 0.02911693f, 0.08506026f, -0.01802954f, 0.04339784f, 0.11128280f, 
    0.12912031f, 0.08771519f, 0.16880161f, 0.22479960f, -0.10564515f, 0.01399025f, 0.11546377f, 0.08436292f, 
    -0.13853133f, -0.00890934f, 0.14810535f, 0.07592419f, 0.03373856f, 0.05457703f, -0.08447816f, 0.19252083f, 
    -0.06933558f, 0.10317946f, 0.04149606f, -0.00161598f, -0.24724735f, -0.01374501f, -0.04443369f, 0.08115211f, 
    -0.11921132f, 0.15828197f, 0.11285633f, 0.00351521f, -0.07790402f, -0.04277706f, 0.01137871f, -0.04089056f, 
    -0.04814308f, -0.22522910f, -0.03341722f, -0.12041432f, 0.05464648f, 0.01371773f, -0.03442704f, -0.03473348f, 
    0.03053806f, -0.07724405f, 0.02596924f, 0.05346582f, 0.17087117f, 0.05299684f, -0.18908763f, -0.07935396f, 
    -0.04335114f, 0.06590462f, 0.08718693f, 0.06959378f, -0.00925568f, 0.03949438f, -0.04282804f, -0.05113326f, 
    0.08991903f, -0.04284583f, 0.00749325f, -0.04063333f, 0.00061898f, 0.05295089f, 0.03319252f, -0.02577588f, 
    0.21978834f, 0.12245698f, -0.01733158f, 0.09219649f, -0.15730502f, 0.32241011f, 0.12774661f, -0.08655595f, 
    -0.14000486f, -0.10167880f, -0.04914916f, 0.00449431f, 0.05168324f, 0.09423742f, -0.24938287f, -0.09916335f, 
    0.27922577f, 0.20629457f, -0.01018087f, 0.03019561f, -0.06450684f, -0.00213753f, 0.09962889f, 0.15927388f, 
    -0.00985880f, 0.04372664f, 0.19205916f, 0.02900733f, -0.24353637f, -0.11075573f, 0.31710407f, 0.00706942f, 
    -0.01795329f, -0.02541990f, 0.05681188f, 0.01746931f, 0.12395911f, -0.00774550f, -0.06252412f, 0.23834765f, 
    0.10609271f, -0.09439526f, -0.17476314f, -0.04366214f, 0.01753769f, 0.00419851f, 0.01558465f, -0.01380608f, 
    -0.05381640f, -0.09508061f, 0.03049535f, 0.04812416f, 0.17657056f, 0.02784455f, -0.02080104f, -0.06637918f, 
    0.14937022f, 0.10292947f, 0.21302824f, 0.09776114f, -0.04430183f, 0.01249142f, 0.12815730f, -0.07767583f, 
    0.22946498f, 0.15611172f, -0.04460678f, -0.10058313f, -0.11930002f, 0.00142353f, 0.02665545f, 0.01217416f, 
    0.08532815f, -0.15773399f, -0.00218239f, 0.04830697f, -0.06302372f, 0.02071343f, -0.13388458f, 0.14320879f, 
    0.20300338f, 0.07176794f, 0.06036403f, -0.04262824f, -0.11373325f, -0.32001117f, 0.06886365f, -0.05432131f, 
    0.19091152f, -0.13268490f, 0.23397523f, -0.10123468f, -0.01633850f, -0.03238345f, -0.17644309f, 0.13050945f, 
    0.16197154f, 0.01299846f, 0.20819879f, -0.27699408f, 0.02261162f, -0.55083275f, 0.27177671f, -0.13400260f, 
    -0.01753237f, -0.10776331f, 0.26015782f, 0.02689568f, -0.06622793f, 0.15801376f, -0.08316026f, 0.03053495f, 
    0.01074761f, -0.00509259f, 0.28324267f, 0.03353006f, 0.01329401f, 0.04875419f, 0.04345321f, 0.13949652f, 
    0.17283154f, 0.27885088f, 0.06753073f, 0.11993775f, 0.06054435f, 0.35264921f, 0.13993934f, 0.15950654f, 
    -0.02226747f, 0.14727694f, -0.01850077f, -0.06542998f, -0.05467203f, 0.15405217f, 0.15136135f, 0.10171160f, 
    -0.08923233f, 0.14490660f, 0.14102082f, -0.02142376f, -0.17103216f, -0.10006127f, -0.02426215f, -0.03766364f, 
    0.01888760f, 0.07162836f, 0.03744056f, -0.14432949f, 0.19518852f, 0.42088327f, 0.28354111f, -0.04469888f, 
    -0.05654157f, -0.15302679f, 0.02604915f, 0.05978331f, 0.08377600f, 0.08517206f, -0.14233434f, -0.00955922f, 
    -0.07479730f, 0.05723932f, 0.17851631f, -0.04875046f, 0.00756330f, -0.04199019f, 0.02223019f, 0.10979830f, 
    -0.02740725f, 0.25815520f, 0.09618814f, 0.19496946f, -0.15183304f, -0.18175775f, -0.26775336f, 0.04229738f, 
    0.00252238f, 0.12366144f, 0.09136067f, 0.01231250f, 0.11443958f, 0.21849303f, 0.11435078f, 0.12793213f, 
    -0.31278443f, -0.04396587f, 0.03845149f, 0.37099791f, -0.09664482f, -0.09950297f, 0.00405923f, 0.04390257f, 
    -0.23514426f, -0.15845458f, -0.08069947f, -0.14789538f, -0.07853117f, 0.16368763f, 0.31188136f, -0.02671355f, 
    -0.09129887f, -0.06829921f, -0.01017107f, -0.00930857f, -0.01512656f, 0.29880407f, 0.15302072f, 0.10205083f, 
    -0.00402229f, -0.16733803f, 0.06621741f, 0.06788895f, -0.02872776f, 0.11716639f, -0.02959164f, 0.17815083f, 
    0.17734751f, 0.02584155f, 0.08482067f, -0.01189482f, 0.49049786f, 0.00315772f, 0.11250547f, 0.04493877f, 
    -0.02199988f, -0.00714366f, 0.09869197f, 0.03195721f, -0.01032176f, 0.06124536f, 0.05826648f, -0.00014314f, 
    -0.29913414f, -0.22842504f, -0.05024403f, -0.05861405f, -0.17653474f, -0.08210643f, -0.00246802f, -0.00537596f, 
    0.00070011f, 0.04051368f, 0.05773887f, -0.05812455f, 0.43331191f, -0.12396365f, -0.02482447f, -0.05129296f, 
    0.09185809f, -0.12359818f, 0.09332289f, -0.01892567f, 0.01510614f, -0.03047737f, 0.02467121f, -0.05842950f, 
    -0.29007384f, 0.23802182f, 0.14460407f, 0.26938260f, -0.12755759f, 0.01263898f, -0.02090064f, -0.00721955f, 
    0.02950482f, 0.07027406f, 0.03223602f, 0.16755639f, 0.11209773f, 0.07373742f, 0.21487325f, 0.02498943f, 
    -0.10774687f, 0.07512282f, 0.05475968f, 0.15746170f, 0.13896443f, 0.02293686f, -0.05000690f, -0.11511898f, 
    -0.29921278f, -0.06881121f, -0.09347447f, 0.01892723f, 0.06767795f, 0.23837078f, 0.14553657f, -0.15875261f, 
    -0.04232100f, 0.02112703f, 0.07606300f, 0.07297575f, -0.09624906f, 0.08201289f, 0.00811827f, 0.02571546f, 
    0.16159028f, 0.18553440f, -0.02509704f, 0.00302382f, 0.02168685f, -0.02108926f, -0.04054806f, 0.18684366f, 
    0.38319129f, -0.05228258f, 0.37027094f, -0.10994838f, 0.12166324f, 0.02317628f, -0.03973385f, 0.25444031f, 
    0.13746567f, 0.04397351f, 0.06334522f, 0.09024356f, -0.30323049f, 0.37163636f, 0.05323077f, 0.32686174f, 
    0.00005533f, -0.03759106f, -0.02596438f, 0.01915584f, -0.05033082f, 0.07217006f, 0.09519880f, 0.13629740f, 
    -0.25441781f, 0.06321817f, 0.13432714f, 0.21494342f, 0.05779530f, 0.07589886f, 0.20521460f, -0.04127202f, 
    -0.04390344f, -0.08266437f, -0.11320600f, -0.06062296f, -0.29841387f, -0.02802325f, -0.08826254f, -0.06629153f, 
    0.03019696f, -0.06852508f, -0.11363158f, -0.18755901f, 0.04311828f, -0.00148213f, -0.06729429f, 0.04341056f, 
    0.05300259f, -0.01556845f, 0.20476379f, -0.08171096f, -0.08303718f, -0.12721150f, 0.05712356f, 0.04683691f, 
    0.10704672f, 0.10325219f, -0.05630362f, 0.08273972f, 0.06196489f, -0.44044444f, 0.07674842f, 0.02427488f, 
    0.17052774f, 0.09876662f, 0.02027207f, 0.18878959f, -0.00088758f, -0.01840916f, 0.03607273f, 0.01565214f, 
    0.36128020f, -0.11635128f, 0.29769817f, 0.02863885f, 0.07804608f, 0.07603950f, 0.04346015f, 0.11223029f, 
    0.11347371f, 0.07059687f, 0.05651972f, 0.08377672f, -0.13129649f, 0.32796541f, 0.28612474f, -0.04739689f, 
    -0.10806686f, 0.05759038f, -0.11218170f, -0.06874956f, 0.16553836f, 0.13862795f, -0.06226432f, -0.00628729f, 
    0.03001929f, 0.05348959f, -0.12375843f, -0.00630244f, -0.08214594f, 0.06319038f, 0.17157583f, 0.11007666f, 
    -0.07106619f, -0.07042847f, -0.00554261f, -0.06375653f, 0.44245687f, -0.38292089f, -0.01552523f, -0.04111842f, 
    -0.14685833f, 0.09341495f, 0.00052030f, -0.05414455f, 0.09996083f, 0.03065285f, -0.00905375f, -0.08492552f, 
    0.01417741f, -0.14715451f, -0.02477474f, 0.06053576f, 0.01505092f, -0.03453634f, 0.05664957f, 0.27347079f, 
    0.00610687f, 0.00514932f, 0.06201668f, -0.09303119f, 0.03270563f, -0.01604417f, 0.26979080f, -0.03207370f, 
    0.13106352f, 0.05522221f, -0.01638477f, 0.03588796f, 0.11741749f, 0.13595974f, 0.10422978f, -0.07627509f, 
    -0.23176453f, 0.10336170f, 0.02044783f, -0.09444011f, 0.00975468f, -0.01535622f, -0.03042421f, 0.12013807f, 
    0.06858348f, 0.08157184f, 0.19132243f, -0.00668097f, -0.33660775f, -0.23165420f, 0.07460783f, -0.17666952f, 
    -0.20364179f, -0.04136618f, -0.01263884f, -0.14075625f, -0.20146365f, -0.16802125f, -0.14273240f, -0.12296793f, 
    -0.09354673f, -0.31432173f, 0.01366957f, -0.04848343f, 0.04906039f, 0.06484933f, 0.05473348f, 0.04151915f, 
    0.08245753f, 0.00015542f, 0.15198793f, 0.00936990f, -0.09331792f, -0.07466175f, -0.04558875f, 0.15412894f, 
    -0.03331160f, -0.08640101f, -0.07727791f, 0.03387246f, 0.03257142f, 0.15146007f, 0.01772061f, 0.01459275f, 
    -0.07097878f, -0.16410200f, -0.05616615f, -0.04392597f, -0.17992102f, -0.17461188f, 0.04927225f, -0.01975423f, 
    0.09216250f, 0.12534128f, 0.09520017f, 0.03271019f, -0.10366226f, -0.20357899f, 0.00778244f, 0.00856997f, 
    0.04123133f, 0.06308161f, 0.10064208f, 0.04150837f, 0.06894024f, 0.02069849f, 0.10276484f, 0.04600534f, 
    0.31490836f, -0.02972205f, -0.03074140f, -0.08058237f, -0.04303706f, 0.01027772f, 0.00656428f, 0.21395706f, 
    -0.04809903f, 0.09417866f, -0.01133508f, -0.22768271f, 0.16968679f, -0.07791276f, 0.37537593f, -0.16331980f, 
    0.02481472f, 0.06515539f, 0.03927881f, 0.09127653f, -0.07663277f, 0.08631414f, 0.02557798f, -0.00511377f, 
    0.13754202f, -0.16445693f, -0.20346980f, 0.04378199f, 0.10091064f, 0.13363557f, 0.18918733f, 0.07555856f, 
    -0.02849390f, 0.03054268f, -0.08002388f, -0.03802438f, -0.22698730f, -0.04293166f, 0.11361054f, 0.05314790f, 
    -0.07415631f, 0.00332869f, -0.08327359f, -0.13033983f, -0.00307517f, 0.05002455f, 0.12658921f, 0.01804179f, 
    0.45022070f, -0.18141891f, 0.11729898f, -0.07930334f, 0.10329898f, -0.15273739f, 0.07440949f, 0.01790676f, 
    -0.03045600f, -0.04958611f, 0.00950628f, 0.07824636f, 0.26150954f, 0.02532536f, 0.00423052f, 0.02125777f, 
    -0.00270925f, 0.02509555f, 0.07038346f, 0.12036681f, 0.07448996f, 0.04430001f, 0.06657857f, -0.11364891f, 
    -0.07995608f, -0.01555768f, -0.04607230f, -0.11005978f, -0.04570284f, 0.03240252f, -0.05383635f, 0.01942766f, 
    -0.05740487f, -0.03929573f, -0.04112668f, -0.08955672f, -0.16253953f, -0.05166087f, 0.00123920f, 0.08629223f, 
    -0.14987464f, 0.03423533f, -0.01047219f, -0.15265343f, 0.04892123f, 0.00670567f, 0.04047855f, -0.08526018f, 
    -0.14513442f, -0.17602113f, -0.02388132f, 0.04194304f, 0.07928347f, 0.01889906f, 0.00021414f, 0.05400465f, 
    0.06268785f, 0.11612746f, 0.03626022f, -0.10978262f, -0.49421808f, 0.06197646f, -0.02267279f, 0.00788739f, 
    0.13918637f, 0.02638274f, 0.11532298f, 0.01447174f, -0.09115669f, -0.01098936f, 0.14298746f, 0.19312756f, 
    -0.04969899f, 0.02919139f, -0.09826754f, -0.07711942f, 0.02053452f, 0.08681591f, -0.01418326f, -0.06521428f, 
    0.18738033f, 0.05872294f, 0.12934513f, 0.15494825f, -0.14082614f, -0.15287429f, -0.17218588f, -0.04581467f, 
    0.02846444f, -0.02936335f, -0.15395519f, 0.00588301f, -0.01140492f, 0.00752235f, 0.02576936f, 0.00677923f, 
    -0.12055194f, -0.06607509f, -0.05989233f, -0.10532087f, 0.02357055f, -0.07184087f, 0.07054808f, 0.04225647f, 
    0.08106989f, 0.06194691f, 0.01768827f, -0.03910420f, -0.02058695f, -0.11341097f, -0.02917297f, 0.06623519f, 
    0.05996272f, -0.06559680f, 0.04778392f, 0.22959775f, 0.09463538f, -0.07671830f, 0.01960394f, -0.09794702f, 
    -0.36120632f, -0.04096730f, -0.00204585f, 0.03273867f, 0.04413728f, -0.02958625f, 0.00631136f, 0.10541523f, 
    0.09670073f, 0.05013463f, -0.01503744f, 0.01430968f, -0.04794453f, 0.03040465f, -0.09945949f, -0.03910537f, 
    0.08563311f, 0.08346454f, 0.04026895f, 0.10398953f, 0.08452483f, 0.01029029f, 0.06365721f, 0.06723556f, 
    -0.33347708f, 0.00626690f, -0.06494511f, -0.03780092f, 0.09148551f, 0.01667591f, 0.01437166f, 0.25594056f, 
    0.07561614f, 0.11283720f, 0.04483224f, 0.06824829f, -0.28185770f, -0.13260585f, -0.18435022f, -0.06491058f, 
    -0.17972563f, -0.02293956f, -0.03904698f, 0.06322634f, -0.02385092f, -0.03313049f, 0.10807849f, 0.12864318f, 
    -0.13177332f, -0.01458450f, 0.16435342f, -0.00542843f, 0.20211668f, -0.11268513f, -0.08368624f, -0.00600904f, 
    0.02403659f, -0.10940917f, 0.03071972f, 0.01617146f, 0.12642148f, -0.00419922f, 0.19065048f, -0.03816578f, 
    0.08074337f, 0.13350077f, 0.15738605f, -0.02440212f, 0.01509692f, 0.04640235f, -0.05523168f, -0.08695257f, 
    -0.09372254f, 0.09787776f, -0.14003788f, -0.15134394f, -0.00558591f, -0.01930213f, 0.08732819f, 0.01866281f, 
    -0.03859404f, 0.08913139f, -0.10372079f, -0.20471764f, -0.12893243f, 0.00877470f, -0.15243961f, -0.00980645f, 
    -0.05289220f, -0.03606866f, 0.10794929f, 0.22142957f, -0.02645115f, -0.00449147f, -0.01499791f, -0.08734624f, 
    0.28828245f, 0.15889281f, -0.13738981f, -0.04903194f, -0.03315499f, 0.05150970f, 0.02658133f, 0.11031301f, 
    -0.03807976f, -0.00916683f, -0.02934761f, -0.03957994f, -0.22778323f, 0.43729374f, -0.19989586f, 0.21600361f, 
    -0.03437551f, 0.00671366f, 0.10897136f, -0.11019970f, -0.15935585f, -0.09043462f, 0.08230817f, 0.01629997f, 
    0.05176602f, 0.10203989f, 0.01009613f, -0.08951228f, 0.05718469f, -0.01636611f, -0.15024325f, -0.01607793f, 
    0.08429887f, -0.05571265f, 0.09611820f, 0.02226494f, 0.51217622f, -0.09281959f, -0.05979217f, 0.25807363f, 
    0.00714095f, -0.03648379f, 0.14317827f, 0.18781486f, 0.00331064f, 0.12966840f, -0.13286807f, 0.08678839f, 
    0.14154054f, -0.01450941f, 0.04999570f, 0.03026808f, -0.08278181f, 0.01304025f, 0.02308135f, 0.03692969f, 
    -0.16707392f, 0.05402860f, 0.10871062f, -0.14598665f, -0.03244723f, -0.08991817f, 0.00035368f, -0.07005174f, 
    0.02886720f, -0.15199201f, -0.00259113f, -0.11267538f, 0.01509186f, 0.29483968f, -0.03586939f, 0.08026784f, 
    -0.05891897f, -0.05647066f, 0.01151027f, 0.03362357f, 0.14493671f, -0.13226965f, 0.04633745f, 0.07981420f, 
    0.06989750f, 0.06499375f, 0.12974171f, 0.05572620f, -0.30900675f, 0.13249326f, 0.21229388f, -0.27412072f, 
    0.07889299f, 0.16216221f, 0.13842694f, -0.06036359f, 0.04708182f, 0.00464529f, -0.04072321f, 0.02081523f, 
    -0.25640213f, 0.12176906f, 0.13408159f, -0.16935116f, -0.03773414f, -0.03120914f, -0.08933889f, 0.11407413f, 
    -0.11731249f, -0.09762661f, 0.08143324f, 0.26542893f, -0.26692030f, 0.01492789f, -0.24703921f, 0.50742412f, 
    -0.02410425f, 0.04780322f, 0.03499815f, -0.08015331f, 0.14852114f, 0.16061683f, 0.19018890f, -0.02687526f, 
    -0.29400125f, -0.06301260f, -0.05428803f, 0.03677228f, -0.05751336f, -0.02584564f, -0.13040408f, -0.04556778f, 
    0.01486456f, 0.04973526f, 0.00109986f, 0.11317386f, -0.07060443f, -0.19243802f, 0.04065588f, 0.21511556f, 
    0.05494864f, 0.04770986f, 0.07013799f, 0.00835108f, 0.02679434f, 0.12327791f, 0.08638947f, -0.00559806f, 
    -0.06540484f, -0.07144852f, -0.11189081f, -0.06955910f, -0.03975076f, 0.06296705f, -0.17818339f, 0.07577757f, 
    -0.02826361f, 0.05729995f, 0.17127264f, 0.15687338f, -0.10645030f, -0.09418676f, 0.00357675f, 0.03483051f, 
    0.04079555f, 0.10983026f, 0.01874142f, 0.11073277f, 0.19035672f, 0.19303159f, 0.09318223f, 0.00686139f, 
    -0.09820964f, -0.18419868f, -0.15790251f, -0.00464622f, 0.13562755f, -0.09605615f, -0.01784710f, -0.04855086f, 
    -0.09986288f, -0.06365543f, 0.03611475f, 0.13995206f, -0.47375891f, 0.18522756f, -0.13844647f, -0.14325017f, 
    -0.01360758f, 0.04666147f, -0.02001595f, -0.01800694f, -0.02139736f, -0.19659340f, -0.08183251f, 0.20849928f, 
    0.10967897f, 0.16865338f, 0.04610107f, -0.07010018f, -0.04815700f, 0.00244586f, 0.05318215f, -0.00850519f, 
    0.18796588f, 0.07046168f, 0.04216906f, 0.09556555f, 0.00139682f, -0.04494700f, 0.18677005f, -0.07382464f, 
    -0.05568733f, 0.08560578f, 0.04301498f, 0.04119424f, 0.00937724f, 0.08122930f, -0.08262782f, -0.02353422f, 
    -0.34791970f, -0.16627373f, -0.08098240f, -0.03308598f, -0.13535239f, -0.09393229f, 0.01578866f, -0.16501221f, 
    -0.03235429f, 0.05710322f, 0.05121094f, 0.04151317f, 0.15024948f, -0.00848794f, 0.15737398f, 0.01118812f, 
    -0.04231538f, -0.10490499f, 0.06896998f, 0.22458601f, 0.02916838f, 0.03297994f, 0.08289029f, -0.03473440f, 
    -0.31807116f, -0.09371489f, -0.13326854f, -0.04636449f, 0.15433376f, 0.12980750f, 0.02188355f, 0.00216308f, 
    0.20080101f, 0.09466225f, 0.11167619f, 0.05058449f, -0.08775396f, -0.13692445f, 0.01569108f, 0.08166347f, 
    0.03467000f, 0.02357037f, -0.03623978f, 0.13624267f, 0.12376326f, 0.09065641f, -0.00610413f, 0.00620376f, 
    0.14465505f, 0.29830655f, -0.15084182f, 0.12409297f, 0.06924281f, 0.03968349f, 0.10782517f, -0.10502182f, 
    0.06801888f, 0.03965513f, -0.05118460f, 0.07121231f, -0.39676762f, 0.17773683f, 0.02989578f, 0.28616598f, 
    0.09740421f, 0.17984536f, 0.01531760f, -0.01411980f, 0.03843155f, -0.03759637f, 0.02821263f, 0.02006494f, 
    -0.37875724f, 0.06880672f, -0.04329746f, 0.26104525f, 0.25648183f, 0.07633256f, 0.08819140f, 0.08138909f, 
    0.07278337f, 0.00654260f, 0.20453681f, 0.09396204f, 0.24136584f, -0.35500011f, 0.06298241f, 0.01105473f, 
    0.17226772f, -0.08304688f, 0.12328906f, -0.06649058f, 0.02279154f, 0.14305522f, 0.07097148f, 0.14356600f, 
    0.21160452f, -0.10370488f, 0.20694906f, -0.07733601f, 0.17412624f, 0.05041462f, -0.00370206f, 0.01377229f, 
    -0.05620461f, -0.02117510f, 0.11883126f, -0.00233860f, -0.11777943f, -0.24964397f, -0.08141623f, -0.01147728f, 
    0.11971214f, -0.05866574f, -0.00820799f, -0.17142753f, 0.05977623f, -0.01948623f, -0.00540545f, 0.13031782f, 
    0.06361939f, 0.23038577f, 0.03759010f, -0.18998978f, -0.01569545f, 0.05084430f, 0.05407950f, 0.14761764f, 
    -0.05033506f, 0.09209641f, 0.07386591f, 0.03288458f, -0.19626597f, 0.15831308f, 0.19307226f, 0.14637819f, 
    0.01928195f, 0.24250904f, -0.07307143f, -0.10015484f, 0.02410598f, 0.04937422f, -0.02200493f, -0.01912556f, 
    0.08995372f, 0.02566733f, 0.03683813f, 0.19500028f, 0.02177629f, 0.11158078f, 0.08079591f, -0.01260336f, 
    0.06528456f, 0.04130683f, 0.10814352f, -0.03198474f, 0.09614898f, 0.11104388f, 0.03897759f, 0.20061246f, 
    0.02032071f, 0.12208212f, 0.04219064f, 0.03057583f, -0.07016527f, -0.00592391f, 0.17483428f, -0.00154037f, 
    0.15993141f, -0.19860926f, 0.00088836f, -0.01934174f, -0.06584040f, 0.10430789f, 0.11017738f, 0.19187102f, 
    -0.05443091f, -0.11265307f, -0.03186704f, -0.06516317f, -0.06590690f, 0.18497182f, 0.09256831f, -0.06066084f, 
    0.02745599f, 0.11514600f, -0.06342851f, -0.06005087f, 0.06754546f, -0.02233028f, -0.07298633f, -0.03493692f, 
    0.11520276f, -0.12070657f, -0.11020830f, 0.03572512f, 0.02984613f, 0.08581312f, -0.13411480f, 0.05186847f, 
    0.06054018f, -0.00950405f, -0.06832366f, 0.14635840f, -0.00418202f, 0.17840299f, 0.15555966f, 0.18257684f, 
    0.01855247f, 0.18769453f, 0.03265252f, -0.02489449f, -0.06155948f, 0.18386103f, 0.15328841f, -0.01920903f, 
    -0.22679514f, -0.15385859f, -0.15977958f, -0.02768177f, -0.00359074f, -0.01838285f, 0.04169190f, 0.03994102f, 
    0.19876893f, 0.07333925f, 0.19160923f, 0.02952030f, -0.08814672f, -0.20219393f, -0.02838439f, -0.07030565f, 
    0.05079805f, 0.01537182f, 0.11180314f, 0.06584620f, -0.08752575f, -0.04624299f, -0.10181446f, -0.07886968f, 
    0.03269905f, -0.12337636f, -0.04035800f, 0.12045592f, 0.15111350f, -0.00192724f, 0.10237012f, -0.07454470f, 
    -0.04628489f, -0.00401108f, 0.10593025f, 0.14470384f, -0.01751514f, 0.21511151f, -0.12670535f, -0.13874927f, 
    -0.04710494f, -0.09150086f, 0.03564003f, -0.12388065f, -0.01633813f, 0.00717363f, -0.03823433f, 0.10882898f, 
    0.02004858f, 0.01636939f, 0.00221534f, -0.02652487f, 0.01862609f, 0.01462646f, 0.02612593f, -0.02374614f, 
    -0.04810021f, 0.00897964f, 0.00855601f, 0.00085989f, 0.00632649f, 0.01782651f, 0.01427678f, -0.02007568f, 
    -0.03602899f, -0.03467505f, -0.03112310f, -0.04117623f, 0.01558663f, 0.00305959f, 0.01709676f, 0.02761942f, 
    -0.01701866f, 0.01289695f, -0.00280027f, 0.02243131f, -0.03671186f, -0.03250175f, -0.01374764f, -0.02468541f, 
    -0.03664164f, 0.01586984f, 0.03018875f, 0.00575035f, 0.01656453f, 0.02485478f, 0.01102652f, -0.02811542f, 
    0.01571403f, -0.03638148f, 0.00248295f, 0.01512355f, 0.02199852f, 0.02428357f, 0.01264594f, -0.02561196f, 
    0.01186491f, 0.02579059f, -0.02639301f, 0.02712600f, -0.03268236f, -0.03039346f, -0.00838681f, 0.01390217f, 
    0.00086875f, -0.00215751f, 0.03359867f, 0.03124878f, 0.00018295f, -0.00573436f, -0.03307255f, 0.02971249f, 
    -0.00684984f, -0.01656558f, 0.01561951f, -0.01111470f, 0.00064924f, -0.02969733f, -0.01142091f, -0.03456665f, 
    -0.00941064f, -0.01307023f, -0.01050835f, -0.04202264f, -0.03304505f, -0.02903457f, 0.02499244f, -0.04091461f, 
    -0.01651590f, -0.03539993f, -0.00267754f, 0.01984798f, -0.02187339f, -0.01979088f, -0.01617064f, -0.01300025f, 
    -0.02341813f, -0.03431167f, -0.02560199f, -0.03598458f, -0.02093730f, -0.03703881f, -0.03549915f, -0.02484568f, 
    -0.02769980f, -0.02232151f, -0.02128883f, 0.00930897f, 0.02895801f, -0.01695523f, 0.01117633f, -0.03551040f, 
    -0.00168171f, -0.02954810f, 0.00823924f, 0.03332961f, -0.03014962f, 0.02526761f, 0.01834126f, -0.00857551f, 
    -0.01880248f, -0.02233657f, 0.02866643f, -0.01495086f, 0.02981803f, -0.03887812f, 0.02383481f, -0.00784790f, 
    -0.03179050f, 0.02074643f, -0.03884884f, 0.00262177f, -0.02739654f, 0.03327385f, 0.02764368f, -0.02828034f, 
    0.01000408f, -0.02170678f, -0.01659826f, 0.02169917f, 0.02770174f, -0.00704214f, 0.01707704f, 0.01120395f, 
    0.02054344f, -0.01536579f, 0.00022842f, 0.01216580f, -0.02403145f, -0.00484222f, -0.02398372f, -0.02506372f, 
    -0.01150757f, 0.00806035f, -0.04428905f, 0.00555482f, -0.02363152f, -0.00434819f, 0.02584920f, -0.01698264f, 
    0.00540666f, 0.02397539f, 0.02180409f, 0.02042613f, -0.02724943f, -0.02064139f, -0.03311321f, -0.01378453f, 
    -0.00951716f, 0.00016218f, -0.02405013f, -0.01215923f, 0.00045052f, -0.03037711f, -0.04046388f, 0.02302258f, 
    0.00045495f, 0.03490198f, 0.02245116f, 0.03345422f, -0.00933798f, -0.01677548f, 0.01531836f, 0.00347508f, 
    0.01650790f, -0.02241889f, 0.01910873f, 0.01637048f, -0.02627607f, -0.01808360f, -0.02377027f, 0.00615402f, 
    -0.02852133f, 0.01396257f, 0.00593509f, -0.02413900f, 0.00080661f, 0.01464141f, -0.02648786f, -0.03651731f, 
    -0.01405510f, 0.01249212f, 0.00612770f, 0.00704785f, 0.02534286f, -0.03663621f, -0.00224679f, -0.02595741f, 
    -0.02222060f, 0.01091630f, 0.01207172f, 0.00491536f, -0.00797500f, 0.00630900f, -0.01422158f, -0.03105029f, 
    0.02840625f, 0.03149631f, 0.02933882f, -0.00914425f, 0.01843686f, -0.03684321f, -0.02131298f, 0.01778662f, 
    -0.03428359f, -0.02681389f, -0.01340237f, 0.00189706f, -0.03829311f, 0.02545252f, 0.02268221f, -0.03260515f, 
    -0.01188938f, 0.02372173f, 0.02664200f, -0.01266790f, -0.02174996f, -0.01876948f, 0.02622662f, -0.03221397f, 
    -0.01589593f, -0.03731482f, -0.02835269f, -0.00247151f, 0.00598696f, -0.03355480f, -0.03012162f, 0.01077773f, 
    0.02254921f, 0.01268329f, -0.02896631f, 0.02641911f, -0.01459190f, 0.01060567f, -0.01201388f, 0.02690499f, 
    -0.00481437f, 0.01489908f, -0.04652081f, -0.01606373f, -0.00400612f, -0.03280905f, 0.00349386f, -0.00848167f, 
    0.00947793f, -0.03105007f, 0.00565517f, -0.00640348f, 0.01032105f, -0.01370518f, -0.03748063f, -0.02022728f, 
    -0.03994597f, 0.00898072f, -0.00805432f, -0.03801217f, -0.01413411f, -0.02510468f, -0.02174240f, -0.02401142f, 
    0.01359534f, -0.02797518f, -0.03236159f, -0.02195196f, -0.03610559f, 0.02398796f, -0.02488173f, -0.00702791f, 
    -0.02066747f, -0.02840035f, -0.02370692f, 0.02844461f, -0.00485667f, 0.02036183f, -0.01634937f, -0.00768295f, 
    0.01236027f, -0.00880341f, -0.02537969f, -0.00157825f, -0.02358355f, -0.01953521f, 0.02068343f, -0.02026347f, 
    -0.01388472f, 0.02996576f, -0.00135021f, 0.00064968f, -0.01777869f, 0.00226199f, 0.00204810f, 0.01133846f, 
    0.02724381f, -0.02644304f, -0.02201239f, 0.01951739f, 0.01972466f, 0.01485280f, 0.00438622f, -0.01417850f, 
    0.01419221f, 0.00395093f, -0.01466127f, -0.01260701f, -0.03388732f, 0.00180079f, 0.02152291f, 0.02330431f, 
    0.00293181f, 0.02749478f, -0.01469104f, -0.02669096f, 0.00693269f, 0.00939450f, -0.02934469f, -0.00746395f, 
    -0.04351444f, -0.03182646f, 0.02369903f, -0.02139670f, -0.02164293f, -0.02515496f, 0.00987893f, -0.00122123f, 
    0.02640069f, -0.00111388f, 0.00874349f, -0.01354995f, -0.02298080f, -0.02574977f, -0.04016894f, -0.00581673f, 
    -0.01154687f, -0.04020416f, -0.02322709f, -0.02727078f, 0.00756265f, 0.02366313f, 0.01953022f, 0.00156059f, 
    -0.01892311f, -0.00636908f, -0.04091704f, -0.00156971f, 0.00758673f, -0.04318774f, 0.00707474f, 0.00091901f, 
    0.02000636f, 0.01655493f, -0.03771781f, -0.02301525f, 0.00768856f, -0.03726255f, -0.03969778f, -0.01784689f, 
    -0.03260454f, 0.00774331f, 0.01851602f, 0.01817390f, -0.01040301f, -0.01550749f, -0.03952148f, -0.03121526f, 
    -0.02886438f, -0.02368529f, 0.02136124f, -0.01319444f, 0.03412764f, -0.00674132f, -0.01854997f, 0.02772032f, 
    0.01176288f, -0.01965834f, -0.01511222f, -0.00201060f, 0.01571858f, 0.03042235f, -0.03659924f, 0.02348781f, 
    -0.03244068f, -0.00928856f, 0.01709626f, -0.03644621f, 0.01737775f, -0.02749604f, 0.01397761f, -0.00082156f, 
    -0.01810358f, -0.02643087f, -0.00349814f, -0.00731002f, 0.01342100f, -0.01419795f, 0.00386074f, -0.00777012f, 
    -0.02814238f, 0.01864780f, -0.01932056f, 0.01082234f, 0.02630494f, -0.00343268f, 0.01216300f, -0.01751484f, 
    0.02669656f, -0.02633638f, 0.01704636f, 0.02220004f, 0.01473984f, -0.02644869f, -0.01170418f, -0.02897201f, 
    0.02840628f, -0.03052665f, -0.00277962f, -0.02684994f, -0.01943955f, 0.01302254f, -0.01943803f, 0.02899662f, 
    -0.00477829f, 0.01107010f, -0.01326778f, -0.02237958f, -0.01412141f, 0.01164258f, -0.01733126f, -0.03068125f, 
    0.02699416f, 0.02949062f, 0.00375610f, 0.00559472f, -0.03383365f, 0.00119452f, -0.03551915f, 0.00878155f, 
    -0.00782333f, 0.02690768f, -0.02556570f, 0.00683745f, -0.00089747f, 0.02026437f, -0.03824488f, -0.04553135f, 
    -0.03404661f, 0.00874600f, -0.03079456f, -0.03463247f, 0.01311054f, 0.02554460f, 0.01319715f, -0.03326047f, 
    -0.02467646f, -0.02270194f, 0.02925280f, -0.02205000f, 0.01603373f, -0.03633678f, -0.01275788f, -0.02613308f, 
    -0.03707753f, -0.01648076f, -0.03950974f, -0.00306547f, 0.02570871f, 0.00569829f, -0.02568689f, -0.00295651f, 
    -0.02553699f, 0.02162406f, -0.03232623f, 0.00086822f, -0.03039769f, -0.02295296f, -0.03137391f, -0.02525236f, 
    -0.02819981f, 0.02770648f, 0.01977408f, -0.01073211f, -0.04171694f, -0.00531605f, 0.00022200f, -0.04152693f, 
    -0.03854854f, -0.04622563f, 0.01148705f, -0.01381074f, -0.01684004f, 0.01220329f, -0.02726435f, -0.02792086f, 
    -0.01547596f, 0.00431498f, -0.03561395f, -0.01131433f, 0.00303254f, -0.02523314f, -0.03231351f, -0.02027866f, 
    0.00512363f, -0.00997225f, 0.01848641f, 0.00974886f, -0.00107098f, 0.00488101f, -0.03912051f, 0.00565818f, 
    -0.01983636f, 0.02017626f, 0.01849842f, -0.01195346f, 0.00619301f, 0.02705798f, 0.02509947f, 0.00881473f, 
    -0.03490335f, 0.00963216f, -0.00772737f, -0.00682686f, -0.02922299f, 0.01888329f, -0.02050699f, -0.01571749f, 
    -0.02520489f, 0.03378825f, 0.03375724f, -0.00871586f, 0.02510197f, 0.02438770f, 0.01046411f, 0.01877828f, 
    -0.03163348f, 0.00906615f, 0.01355618f, -0.01789893f, 0.01688058f, 0.02995108f, -0.01113619f, -0.00427142f, 
    0.02416816f, -0.01440585f, -0.01404790f, 0.00500004f, -0.00570770f, -0.00321577f, -0.03017830f, 0.01379530f, 
    0.02267089f, 0.01360830f, 0.03182288f, -0.03577437f, 0.00468731f, -0.02743001f, 0.01952000f, -0.02404416f, 
    0.03253195f, -0.03204971f, -0.03297680f, 0.00094866f, 0.01470660f, -0.03283584f, 0.02065800f, -0.01771489f, 
    -0.02708703f, -0.00990769f, 0.02069911f, -0.02889565f, -0.00710443f, 0.00433177f, -0.00272083f, -0.03145818f, 
    0.02265107f, -0.01677259f, -0.00456198f, 0.02546324f, -0.01103668f, -0.00800025f, 0.01871736f, 0.01526543f, 
    0.00691813f, -0.00414686f, 0.01027706f, -0.00003132f, -0.01981295f, -0.01536833f, -0.02746020f, -0.03193062f, 
    -0.00761133f, 0.01415238f, 0.00917099f, 0.01599983f, -0.01192247f, -0.01359411f, 0.01059816f, 0.02149854f, 
    -0.01687186f, 0.02225088f, 0.02289873f, -0.04366783f, -0.02685114f, 0.02718134f, 0.03627514f, -0.03707737f, 
    -0.00352330f, -0.00980211f, -0.02857375f, 0.01550908f, -0.03713552f, 0.00849508f, -0.01941252f, 0.00985676f, 
    -0.02193713f, -0.00976118f, -0.00509094f, -0.04004004f, 0.01632325f, 0.00073452f, -0.00033692f, -0.02088521f, 
    0.02013993f, 0.02903719f, -0.02246619f, -0.02461628f, -0.03503686f, 0.01804138f, 0.01453630f, -0.00760432f, 
    0.01965473f, 0.01078680f, 0.02913076f, 0.02774514f, 0.02309025f, -0.04283090f, -0.01331642f, 0.01037080f, 
    0.02021897f, -0.03550031f, -0.00906760f, -0.01330839f, 0.01430238f, 0.01212643f, 0.01193534f, 0.01059970f, 
    0.01267491f, 0.02872138f, 0.02742664f, -0.01067281f, -0.02544956f, -0.01320479f, -0.02090727f, 0.02769780f, 
    -0.00821292f, -0.03672052f, -0.03448404f, -0.01409387f, 0.01327434f, -0.02428246f, -0.04181271f, 0.02268317f, 
    -0.00565252f, 0.00578992f, 0.01408623f, -0.03308617f, 0.02337565f, 0.02212567f, -0.00697259f, 0.02978672f, 
    -0.03796031f, 0.00137759f, 0.02013141f, 0.00014128f, -0.03450752f, -0.01414657f, -0.03824907f, -0.00449733f, 
    -0.00411291f, 0.02368880f, 0.02263393f, -0.00651479f, -0.03445349f, 0.02625862f, -0.03389212f, -0.00100487f, 
    -0.01376048f, -0.02168567f, -0.02795121f, -0.00668260f, -0.01097838f, 0.02463137f, -0.03671106f, -0.02840663f, 
    0.01758780f, -0.00550113f, -0.01085453f, 0.02457916f, -0.02925326f, -0.02198407f, -0.02550539f, -0.03984858f, 
    0.02218751f, 0.01649932f, 0.01111452f, 0.00424408f, -0.03263558f, -0.02955261f, -0.02857479f, -0.01130316f, 
    0.03240741f, -0.00898439f, 0.03249883f, 0.01393400f, -0.03188954f, -0.03952673f, 0.00942443f, -0.04166675f, 
    -0.03373362f, 0.02570466f, 0.00205221f, -0.03129583f, -0.02669369f, -0.01787565f, -0.03993024f, -0.01891932f, 
    -0.00924951f, -0.00613310f, 0.00668470f, 0.00013826f, -0.00462891f, -0.03426629f, 0.00204895f, -0.02880348f, 
    -0.03467378f, -0.00872967f, 0.02490330f, -0.00834117f, -0.03813021f, 0.00902916f, -0.02363542f, -0.03753992f, 
    -0.02300639f, -0.02736518f, -0.02297444f, -0.02826009f, 0.01679390f, 0.02411192f, 0.00365513f, -0.00999017f, 
    -0.03558698f, -0.01984554f, 0.01020062f, 0.03029816f, -0.02729209f, -0.02980181f, -0.02605043f, -0.00851985f, 
    0.01822137f, -0.01613068f, -0.00286021f, -0.01048419f, -0.01350025f, 0.03231745f, 0.02761293f, 0.02678939f, 
    -0.03519912f, -0.01915572f, -0.03773291f, 0.02630018f, 0.03073712f, -0.00923311f, -0.01431247f, 0.02067605f, 
    0.02218275f, 0.02525752f, -0.03898615f, -0.00023533f, -0.00441924f, -0.00153853f, -0.00607470f, 0.01891644f, 
    -0.01601889f, -0.02033400f, -0.00307599f, 0.02121160f, 0.00442361f, 0.01530546f, -0.01203875f, 0.01464360f, 
    -0.03124194f, 0.03468658f, 0.02613072f, -0.01396842f, -0.00707109f, -0.00085844f, -0.04038054f, -0.00785477f, 
    0.01422624f, -0.00582536f, -0.01035050f, -0.00117579f, 0.02967443f, -0.00719659f, 0.02842026f, 0.00396941f, 
    0.02132186f, -0.02084330f, -0.01500317f, -0.01383704f, 0.01393730f, -0.00011602f, -0.03617624f, -0.00802957f, 
    0.01239298f, 0.01625277f, -0.00043943f, 0.01895147f, -0.00660745f, -0.04456631f, 0.02417673f, -0.00239409f, 
    -0.02624279f, 0.00372161f, -0.01078510f, -0.00613104f, -0.02628229f, -0.04093232f, -0.02269723f, 0.02165379f, 
    -0.02819004f, 0.02383278f, -0.01760644f, -0.01955866f, -0.01365447f, -0.01399960f, -0.00076174f, -0.02682996f, 
    0.00955768f, 0.00758438f, -0.03343567f, -0.00120472f, 0.01035627f, 0.01964596f, 0.02843200f, -0.04514959f, 
    0.00360020f, -0.02859480f, -0.04259116f, -0.00968322f, 0.02177618f, -0.02344957f, -0.00306026f, -0.04725723f, 
    -0.03241992f, 0.01847726f, -0.01092340f, -0.01952068f, 0.02236783f, 0.00455049f, -0.00036361f, -0.00221671f, 
    -0.03750449f, 0.00904059f, -0.00999742f, 0.02282395f, -0.03168450f, -0.02687524f, -0.02174183f, -0.03653907f, 
    -0.03736470f, 0.01129647f, -0.00816320f, 0.01988329f, -0.01073757f, -0.03898998f, -0.02958078f, -0.02718943f, 
    -0.00273727f, -0.04267486f, -0.04539022f, -0.03596806f, 0.00193753f, 0.02193454f, -0.00812045f, 0.00254049f, 
    -0.01134756f, -0.00589917f, 0.01525377f, 0.01392219f, 0.00614784f, -0.02164553f, 0.02089789f, 0.00302758f, 
    -0.04119407f, -0.02518826f, 0.00577097f, -0.00665319f, -0.03914507f, 0.00106664f, -0.00981653f, -0.03949342f, 
    -0.02858679f, 0.00830815f, -0.02391453f, -0.03659423f, 0.01244655f, 0.01617287f, -0.00099307f, 0.01721633f, 
    -0.01592420f, -0.02576252f, -0.00749636f, 0.00182669f, -0.03326625f, 0.01197053f, -0.02628779f, -0.04608718f, 
    -0.01240095f, -0.00410230f, -0.03238883f, -0.03194350f, 0.02881663f, 0.00593797f, 0.01789380f, 0.00290401f, 
    -0.04045108f, 0.01839077f, -0.03937249f, -0.00035725f, -0.01096635f, 0.00925981f, 0.01926659f, 0.01995982f, 
    0.01364424f, 0.02706736f, -0.00006875f, 0.02368056f, -0.03383330f, 0.00826402f, -0.03362601f, 0.01470529f, 
    0.02376155f, -0.02743337f, 0.01654518f, 0.02008158f, -0.04356901f, -0.04128401f, -0.03029948f, -0.00341326f, 
    0.02625693f, 0.01486859f, -0.01250758f, -0.02674756f, 0.01415462f, 0.01602203f, 0.01426500f, -0.00217595f, 
    -0.03604880f, -0.01312387f, -0.02711320f, -0.01955445f, 0.00270090f, -0.03971869f, -0.00638022f, -0.00818816f, 
    -0.00497845f, -0.03589344f, -0.01988689f, 0.01895066f, 0.01103946f, 0.02263948f, -0.00123930f, -0.02403987f, 
    -0.02589213f, 0.01031489f, 0.00860547f, -0.04116142f, 0.00200717f, 0.02374202f, -0.01721196f, -0.01448970f, 
    -0.03583538f, -0.03113597f, 0.01575473f, 0.02657408f, -0.02509397f, 0.03279268f, 0.01166189f, -0.04096503f, 
    0.02570851f, 0.00137807f, -0.02024793f, -0.03367374f, -0.03911800f, -0.01146110f, -0.01856909f, -0.02675081f, 
    -0.04421806f, -0.03760731f, -0.02575063f, -0.02518026f, 0.02445077f, 0.00877729f, -0.03955796f, 0.01129433f, 
    0.01807908f, 0.02358562f, 0.02308575f, -0.04047931f, -0.01455324f, 0.02851599f, -0.02735042f, 0.00086868f, 
    -0.01852071f, -0.00413057f, 0.00378637f, -0.00511819f, 0.00430987f, 0.02341863f, 0.02028077f, -0.01689355f, 
    0.01529397f, 0.01527920f, -0.01794966f, -0.02974066f, -0.01312983f, 0.01712434f, -0.00668394f, -0.01392998f, 
    -0.02461492f, -0.00411909f, -0.02335441f, 0.00912835f, 0.00322174f, -0.00560071f, -0.00414922f, -0.03831526f, 
    0.03091770f, -0.00501033f, -0.01658968f, 0.00324523f, -0.02571619f, 0.00843490f, 0.00159851f, -0.01443087f, 
    0.01392550f, 0.00755115f, -0.00463758f, -0.01716101f, 0.00227677f, -0.03884387f, -0.02004157f, -0.01685737f, 
    0.00519021f, -0.00011201f, 0.01664184f, -0.00159721f, -0.01047821f, 0.00479046f, 0.02628775f, -0.02145015f, 
    0.02009715f, -0.02939350f, -0.00382340f, -0.03070804f, 0.02560605f, 0.00385089f, 0.00401644f, -0.03103319f, 
    -0.02579211f, -0.04046365f, -0.02966213f, -0.03722924f, 0.02625134f, 0.01435201f, -0.00309640f, -0.03225090f, 
    -0.01475553f, -0.00968163f, 0.02361147f, -0.00477595f, 0.00899217f, 0.00747846f, 0.01888310f, 0.01166813f, 
    0.02674295f, 0.00303361f, 0.00501093f, -0.01003010f, -0.03742924f, -0.01336360f, 0.02407023f, 0.00786433f, 
    0.01851028f, 0.03165559f, -0.03512419f, 0.01716153f, 0.01579791f, 0.01228155f, -0.02130903f, -0.00816853f, 
    0.00554359f, 0.00348355f, -0.00983938f, -0.01888640f, 0.03814075f, -0.03168881f, -0.00358996f, -0.00685501f, 
    0.01667485f, 0.00914964f, -0.00115638f, 0.03749305f, 0.00053914f, -0.04351704f, -0.01032660f, 0.01902077f, 
    0.01714370f, -0.00934537f, -0.03228920f, 0.01884975f, -0.03832643f, -0.02573252f, -0.00714055f, -0.02640747f, 
    -0.03602989f, -0.00617448f, -0.03169699f, -0.02175606f, -0.00332235f, -0.04124914f, -0.00144841f, 0.00219656f, 
    0.00222921f, 0.00145941f, -0.04238927f, -0.03553098f, -0.01110894f, -0.00195585f, -0.03455334f, -0.01306046f, 
    -0.03031882f, 0.02940175f, -0.00114389f, 0.01223633f, -0.00897848f, -0.01558394f, -0.03134714f, 0.01255278f, 
    -0.03770924f, -0.03929897f, 0.00008859f, 0.02873327f, 0.00962026f, 0.01577421f, -0.00878817f, -0.01835281f, 
    0.01142706f, -0.02177016f, -0.00217484f, 0.00037690f, -0.01377418f, -0.00249290f, 0.02699047f, 0.01809217f, 
    0.03402895f, -0.02271630f, 0.00702004f, -0.01290793f, 0.01940737f, -0.02232616f, -0.03622085f, -0.00158039f, 
    -0.04509125f, 0.00489771f, -0.01946118f, -0.03172106f, 0.01739542f, -0.02089919f, -0.00915792f, -0.03140340f, 
    0.00798097f, -0.01134856f, -0.02036163f, -0.01197129f, 0.01661488f, 0.01594521f, 0.03060340f, 0.01073411f, 
    -0.00154470f, 0.03028788f, 0.01174794f, 0.01026131f, -0.03395379f, 0.00452579f, -0.03022189f, -0.02708629f, 
    -0.01410922f, -0.00766764f, -0.04549631f, -0.02480042f, 0.03638370f, -0.04063473f, -0.00811309f, 0.00689000f, 
    -0.02503297f, 0.00179360f, 0.01843633f, 0.00829514f, 0.01116205f, -0.01993899f, 0.02691263f, 0.00557390f, 
    -0.03875899f, -0.03682017f, -0.02480052f, -0.01336498f, 0.01124880f, -0.01865750f, -0.00472302f, 0.02187645f, 
    -0.02869030f, 0.01907146f, -0.04329568f, -0.01651834f, -0.03042827f, 0.00568020f, 0.02446291f, 0.02513007f, 
    0.02687071f, -0.03219446f, 0.01084444f, -0.03362842f, 0.01583616f, 0.00782970f, 0.01945396f, -0.00925274f, 
    0.01506153f, 0.02224886f, -0.01760710f, 0.01722465f, 0.00310458f, -0.00853831f, -0.00155637f, -0.02289734f, 
    -0.01585672f, 0.01511968f, 0.02294474f, -0.01419027f, -0.01958103f, 0.01437295f, -0.02543686f, 0.00876267f, 
    0.02675385f, -0.03059922f, -0.01180888f, 0.01017099f, -0.01644435f, 0.02492589f, -0.03366454f, -0.00206734f, 
    0.01869523f, 0.02412453f, 0.02983966f, -0.02820247f, 0.01275188f, -0.01878614f, -0.03458214f, 0.01429858f, 
    0.02982005f, 0.01867599f, 0.00176431f, -0.00287829f, -0.03901661f, -0.02108205f, 0.03055376f, -0.02011300f, 
    -0.01622099f, 0.00360891f, -0.03494250f, -0.01530087f, 0.01338933f, -0.01420212f, -0.01271426f, 0.01587656f, 
    -0.00824516f, 0.00092404f, 0.00788738f, -0.00859456f, -0.02082718f, 0.00998403f, -0.03889039f, -0.01770362f, 
    -0.01255443f, -0.04085410f, -0.03494162f, 0.02583746f, -0.01705346f, 0.02824106f, -0.01248022f, -0.00924136f, 
    -0.03166758f, -0.02840999f, -0.04105652f, -0.02364554f, -0.01533914f, -0.03878429f, -0.00450221f, 0.02042620f, 
    -0.03223121f, 0.00209137f, 0.02678593f, -0.00665015f, -0.00441866f, 0.00237926f, 0.02610734f, 0.01939837f, 
    0.02514461f, 0.01088522f, 0.01465769f, 0.02368878f, -0.00478132f, -0.00330052f, 0.02855997f, -0.04365034f, 
    0.00748203f, -0.02227180f, -0.00630254f, -0.00727026f, -0.01543861f, 0.01312281f, -0.02575659f, -0.04738404f, 
    0.01163630f, -0.00504384f, -0.02193241f, -0.02051116f, -0.02628832f, -0.04184743f, 0.01976811f, -0.01424236f, 
    -0.03462477f, 0.02705625f, -0.04040660f, -0.02892259f, 0.00964615f, 0.02774958f, -0.00453030f, -0.01950212f, 
    -0.00002154f, -0.00719452f, -0.02273533f, -0.00061304f, -0.02834941f, -0.02998309f, 0.01622916f, -0.01004419f, 
    0.00839394f, 0.01613758f, -0.01139944f, 0.02464705f, 0.00388703f, -0.03335078f, -0.01566690f, -0.03207060f, 
    0.02251396f, -0.01255265f, 0.01546288f, 0.00654961f, 0.00603497f, -0.03413176f, -0.02986250f, 0.03248027f, 
    -0.02546368f, 0.02728908f, 0.02055978f, 0.00821971f, -0.00670744f, -0.02553317f, 0.01666111f, 0.01125420f, 
    0.02300639f, 0.00744332f, -0.02804563f, 0.01658731f, -0.01442389f, 0.00260973f, 0.01309474f, 0.00829712f, 
    -0.01998101f, -0.02423435f, -0.02290163f, 0.01704855f, 0.01052801f, 0.01759836f, -0.00316400f, -0.01632973f, 
    -0.01051315f, -0.02810267f, -0.03855175f, 0.01869639f, 0.00521650f, -0.01230302f, -0.04030097f, 0.02082134f, 
    0.00449445f, 0.01216346f, -0.03890223f, 0.01380280f, -0.01179081f, -0.01129047f, -0.02099045f, 0.00764981f, 
    0.01753096f, 0.00203029f, -0.01267009f, 0.01384022f, -0.03470547f, -0.03437827f, 0.02208124f, -0.01073937f, 
    -0.00067830f, -0.01051759f, -0.01817071f, 0.02346999f, 0.02110089f, 0.00874395f, 0.01232882f, -0.02304816f, 
    0.01259923f, 0.00748681f, 0.01584317f, -0.03918044f, -0.00963365f, 0.01861621f, 0.01402497f, -0.00973726f, 
    -0.02165908f, -0.00953692f, 0.01654116f, -0.02480080f, -0.01555914f, 0.02544223f, 0.02868979f, 0.02186729f, 
    -0.00347613f, -0.01722362f, -0.02156529f, -0.02193005f, -0.02282496f, 0.02480245f, -0.01819157f, 0.00951143f, 
    -0.03387249f, -0.01855855f, -0.01522595f, 0.00449870f, 0.02104434f, -0.02865406f, -0.00787396f, -0.03145253f, 
    -0.01335565f, 0.01979014f, -0.02206933f, -0.00789391f, 0.00019983f, -0.02549738f, -0.02708792f, -0.02441350f, 
    0.00166179f, -0.03648720f, 0.01773555f, -0.00977858f, -0.01987966f, 0.00714879f, 0.01671865f, -0.01192825f, 
    -0.01375728f, -0.01341420f, 0.02655905f, -0.00990061f, -0.00621221f, 0.02367831f, -0.00088000f, -0.01292480f, 
    -0.02765997f, 0.01762370f, 0.02836544f, 0.00012556f, 0.01452702f, -0.02893112f, -0.00147747f, -0.03099143f, 
    0.02833462f, 0.02171323f, -0.02644874f, 0.00852010f, 0.02176917f, 0.02874176f, -0.04025481f, 0.00239544f, 
    -0.03035545f, -0.02480793f, -0.03535239f, -0.01668369f, 0.01202720f, 0.02850833f, -0.01673741f, 0.01372722f, 
    -0.02973440f, 0.00998206f, 0.00221051f, -0.00879015f, -0.01123885f, -0.00341129f, -0.03444345f, 0.01964407f, 
    0.00815824f, 0.01588200f, -0.02777405f, 0.00360264f, -0.04427660f, 0.02456054f, 0.00861817f, -0.00191200f, 
    -0.00218604f, 0.01071733f, 0.01294680f, 0.01672965f, 0.00935454f, 0.01303951f, -0.03319781f, -0.01696318f, 
    0.01881089f, -0.03010166f, 0.00010866f, 0.02225106f, -0.01016161f, -0.01516222f, -0.01442362f, 0.01768628f, 
    0.00493628f, 0.03268354f, -0.02220608f, -0.00401206f, 0.00596398f, -0.01213830f, 0.02963858f, 0.02596648f, 
    -0.03614854f, 0.02080135f, 0.01770599f, -0.02877356f, 0.01789239f, 0.00142543f, 0.02562967f, 0.02076439f, 
    0.03831257f, -0.02935441f, 0.03432006f, 0.03491138f, -0.01509215f, 0.00003583f, 0.02813904f, -0.00192539f, 
    -0.02293741f, 0.02472476f, -0.02741130f, 0.01978636f, -0.04174963f, -0.02035476f, -0.00904977f, 0.01432659f, 
    -0.01468776f, 0.01506569f, -0.02186841f, 0.00472133f, -0.02743177f, 0.01734379f, -0.01049109f, -0.00731685f, 
    0.02380783f, -0.03193234f, 0.00595122f, 0.00824416f, 0.04179288f, 0.00232116f, 0.03129345f, 0.00735778f, 
    -0.02414160f, -0.01458486f, 0.00621232f, 0.01214343f, -0.02994888f, -0.02753227f, 0.01483511f, -0.01988683f, 
    -0.01087191f, -0.00049125f, 0.02083221f, 0.00430098f, 0.02491960f, -0.02795204f, -0.03103096f, -0.00324410f, 
    0.00934753f, -0.00436717f, -0.01060538f, -0.00278207f, -0.01407338f, -0.02541870f, -0.03960658f, -0.01192386f, 
    0.01783765f, -0.01313464f, -0.01104246f, -0.02988319f, 0.00992029f, 0.03602472f, -0.02292955f, 0.00999312f, 
    0.01591114f, -0.00790180f, -0.02103020f, 0.01862759f, 0.01965115f, -0.04055216f, -0.03911671f, 0.02383716f, 
    0.01456973f, 0.02058916f, -0.00544770f, -0.02771003f, -0.01918049f, -0.01901816f, 0.00937316f, -0.03317437f, 
    0.00992661f, 0.00019204f, 0.00538822f, -0.00067315f, 0.00394463f, 0.00590316f, 0.02363847f, -0.04039288f, 
    0.03945280f, 0.03328224f, 0.01095831f, -0.00191123f, -0.01452440f, 0.02694876f, 0.02131928f, -0.01548635f, 
    0.03408835f, 0.01960721f, -0.01995851f, -0.03657951f, 0.01549807f, 0.00242168f, 0.02684558f, 0.00573140f, 
    -0.02762488f, -0.02422999f, -0.00189376f, -0.04017499f, 0.02747643f, -0.02153995f, 0.01700057f, -0.02238257f, 
    -0.02540281f, -0.02486072f, 0.03023364f, 0.01081636f, 0.01153925f, -0.01012337f, 0.02079783f, 0.02928501f, 
    0.01186071f, 0.01984880f, 0.02727045f, -0.01180636f, 0.00378245f, -0.03138537f, -0.02018088f, -0.02388368f, 
    0.01033457f, -0.01609442f, 0.01410889f, -0.02739660f, 0.00050364f, -0.00775628f, 0.02677877f, -0.03990941f, 
    0.03259226f, -0.01101878f, -0.02247437f, 0.00183511f, -0.02024002f, -0.02778431f, 0.00817773f, 0.00417868f, 
    0.00151978f, -0.03718548f, 0.01299561f, -0.02630293f, 0.01206789f, 0.01702345f, -0.02736682f, 0.01021576f, 
    0.01267040f, 0.01520129f, -0.01500844f, 0.00055452f, -0.03243311f, 0.01361475f, -0.00983404f, 0.02819585f, 
    -0.03807775f, 0.01106026f, -0.01933026f, -0.00135601f, -0.00988595f, -0.01944050f, -0.02529381f, -0.03146677f, 
    0.00899348f, -0.02860246f, -0.00807997f, -0.04065366f, 0.01324194f, -0.02031272f, -0.01472490f, 0.01968677f, 
    -0.00241343f, -0.03520143f, -0.01392739f, 0.02473101f, 0.00430170f, 0.00319303f, -0.00506054f, -0.03426181f, 
    0.03324502f, -0.01730789f, -0.03473664f, 0.03316233f, -0.02369973f, 0.00280910f, 0.00824404f, -0.01635832f, 
    -0.01996307f, -0.02238717f, -0.01814327f, -0.03179383f, -0.00266211f, -0.02642421f, 0.00753134f, -0.02453478f, 
    0.03168005f, -0.01206110f, -0.00443094f, 0.01947504f, -0.01077635f, 0.02930957f, 0.02170475f, -0.01910688f, 
    -0.02023851f, 0.03111766f, -0.01998547f, -0.02883846f, -0.02676013f, -0.02705292f, -0.01169423f, -0.01649603f, 
    -0.03935495f, 0.02915461f, -0.03121680f, -0.03309185f, 0.01848862f, -0.01704419f, 0.01021961f, 0.01655997f, 
    0.02083642f, -0.03939165f, -0.00175071f, -0.00715987f, -0.02873990f, -0.00633712f, 0.02511109f, -0.02210485f, 
    0.01724028f, 0.01032914f, -0.00351511f, -0.01911549f, -0.00492297f, -0.00824400f, -0.02495819f, -0.02212724f, 
    -0.02973568f, -0.02596393f, 0.02877313f, -0.03893750f, -0.01432067f, -0.02225678f, 0.01641217f, 0.01517600f, 
    -0.02561875f, 0.01950622f, -0.03257085f, -0.02232099f, 0.00834689f, -0.02327033f, 0.00788214f, 0.00619162f, 
    0.02369550f, -0.01305112f, -0.01110841f, 0.00459853f, -0.00076357f, 0.00439380f, -0.02965492f, -0.00143428f, 
    -0.03022793f, -0.04240433f, 0.00456989f, 0.03072964f, 0.02454439f, -0.01847903f, 0.01421335f, -0.04058886f, 
    0.00262208f, -0.00593462f, 0.00885514f, -0.03156152f, -0.00434689f, 0.03416695f, 0.03454742f, 0.00578113f, 
    0.02842735f, -0.03389569f, -0.02898632f, 0.02206167f, 0.01547019f, -0.04246467f, 0.00897364f, 0.03528360f, 
    -0.03883035f, 0.00774802f, -0.01386207f, 0.00105308f, 0.04014264f, -0.02252969f, 0.02048056f, -0.00310973f, 
    0.02274815f, 0.00595901f, 0.01625717f, 0.02404750f, -0.01159193f, -0.01420251f, -0.02416111f, 0.00051347f, 
    0.00437854f, -0.03645314f, 0.02200565f, -0.01627079f, -0.00445734f, 0.02213061f, -0.03479845f, 0.01393522f, 
    0.03012160f, 0.00756949f, -0.01651117f, 0.00928853f, 0.02178829f, -0.02445282f, -0.00396043f, -0.03355850f, 
    -0.02940505f, -0.03792342f, -0.03012602f, 0.01280004f, -0.03617337f, 0.02928622f, -0.02141026f, 0.00384346f, 
    -0.03485117f, -0.02653562f, 0.02826603f, 0.00051663f, -0.01992974f, 0.00298558f, 0.01426231f, -0.01539941f, 
    -0.01608006f, -0.00813074f, 0.00991157f, -0.00989450f, -0.01076199f, -0.01621386f, 0.01872696f, 0.01779344f, 
    -0.00288147f, 0.02680138f, 0.00674911f, -0.00838244f, -0.02966235f, -0.00369759f, 0.03138093f, 0.01337858f, 
    -0.02564859f, 0.02636428f, -0.00421871f, -0.00252694f, -0.01594537f, -0.01232147f, 0.01581722f, -0.00391932f, 
    0.01146627f, -0.03453435f, -0.02682201f, -0.02523874f, 0.00901098f, 0.02327573f, 0.02259620f, 0.02167303f, 
    0.01342053f, -0.03304028f, 0.01190036f, -0.00878540f, -0.01861836f, -0.02858370f, 0.02917913f, 0.00569267f, 
    -0.00644578f, 0.02957298f, 0.02952694f, -0.03691537f, -0.00414085f, -0.03429517f, -0.01336297f, -0.01645448f, 
    0.00570009f, -0.01408930f, -0.03286550f, 0.02566407f, -0.00807467f, 0.00657588f, -0.02878204f, -0.01406758f, 
    -0.00612275f, -0.02916424f, 0.00376598f, -0.03647723f, 0.00747684f, -0.02780442f, -0.00408098f, -0.01923262f, 
    0.01996127f, -0.03023414f, 0.00606997f, 0.00355815f, 0.01335786f, -0.01504178f, -0.00240633f, -0.02240768f, 
    -0.01309208f, -0.02145596f, -0.03062353f, -0.03586305f, 0.00691730f, 0.00876708f, -0.00548350f, 0.03017156f, 
    0.01081936f, -0.02752041f, -0.02549964f, -0.00847571f, -0.02986592f, 0.00983167f, -0.00714645f, 0.01061255f, 
    -0.01573330f, 0.02421832f, 0.00483017f, 0.01488857f, 0.01186488f, 0.00840254f, -0.03115683f, 0.03106057f, 
    0.01069241f, 0.01739882f, 0.01401138f, 0.00203065f, -0.00790968f, 0.01909013f, -0.03549618f, 0.00103760f, 
    -0.01191966f, 0.01015381f, -0.00275634f, -0.02151638f, 0.00843638f, -0.01309948f, 0.00803530f, -0.02995575f, 
    -0.00886237f, 0.00299287f, -0.00866306f, -0.03153542f, 0.02768239f, -0.01063119f, -0.01368337f, -0.01000667f, 
    -0.03717688f, -0.01193675f, -0.01854247f, -0.00020941f, -0.02859674f, -0.04004257f, -0.01385431f, -0.02797969f, 
    -0.02652767f, 0.02622424f, -0.00353169f, 0.00805095f, 0.02370577f, -0.04071501f, -0.00337010f, 0.00673340f, 
    -0.02279069f, -0.00674384f, 0.00251686f, -0.01220652f, -0.04170059f, -0.03864283f, -0.01213375f, 0.02531319f, 
    0.01458297f, -0.03633656f, -0.00358405f, 0.03578736f, -0.01622883f, -0.01627873f, 0.01425189f, -0.01519014f, 
    -0.01569863f, -0.02020816f, -0.00925873f, -0.00301419f, -0.00952973f, 0.01215265f, -0.03111828f, 0.01236755f, 
    -0.00852419f, 0.00757056f, -0.00641085f, 0.02247014f, 0.02612306f, 0.02181707f, -0.01549905f, -0.03212300f, 
    -0.00434601f, 0.00625052f, 0.01559510f, -0.03349646f, 0.02246395f, -0.00198223f, 0.02387122f, 0.02189771f, 
    0.01933866f, 0.04257020f, 0.01894342f, -0.01758212f, 0.03418208f, -0.02963937f, -0.02481331f, -0.02366644f, 
    -0.01938961f, -0.03126304f, -0.00457515f, 0.01260654f, -0.01644921f, -0.01708570f, 0.01886141f, -0.03983590f, 
    0.00057221f, 0.00587693f, 0.00237102f, -0.03157477f, 0.02099027f, 0.01345197f, 0.01418615f, 0.01902352f, 
    -0.03617404f, -0.04390811f, -0.03464670f, 0.02375230f, -0.03810116f, 0.02084522f, 0.01982279f, -0.01296583f, 
    -0.01999702f, -0.02162328f, 0.01050645f, -0.02457278f, -0.01101128f, -0.01955350f, -0.02549184f, -0.03209217f, 
    0.00136740f, 0.02969420f, -0.02258107f, -0.04216380f, -0.01306390f, 0.02651682f, 0.01282801f, -0.00874019f, 
    0.00920064f, 0.03843519f, 0.03343088f, 0.00982557f, -0.00967536f, -0.00757998f, 0.02750589f, 0.01092123f, 
    0.01786719f, -0.00847917f, 0.00761256f, 0.01370259f, -0.00877914f, 0.00505132f, -0.02705910f, -0.01549418f, 
    0.01171858f, 0.03743955f, 0.00594215f, -0.01702907f, -0.00596671f, -0.01261228f, -0.00212652f, -0.00805331f, 
    0.01421468f, -0.03913415f, 0.01179287f, 0.01943152f, 0.01766190f, 0.01696005f, 0.01798051f, 0.02657918f, 
    0.02009859f, 0.01027571f, -0.03736563f, 0.00544562f, -0.00300704f, -0.02363338f, -0.01602747f, 0.04217580f, 
    -0.01313354f, -0.00769200f, 0.03360633f, -0.00850145f, 0.01067841f, -0.01234900f, -0.03778398f, -0.03402423f, 
    0.00404021f, 0.02645580f, -0.03558770f, 0.02959147f, -0.02736528f, -0.02659946f, -0.00093070f, -0.01150531f, 
    -0.00301567f, -0.01056920f, -0.01515726f, 0.01954314f, -0.03935459f, -0.02273307f, 0.02952551f, 0.02082939f, 
    -0.00748290f, 0.01825447f, 0.01094934f, 0.01205732f, 0.00044244f, 0.00536307f, -0.02924536f, -0.01965339f, 
    0.00717631f, 0.04033983f, -0.02561424f, 0.01503425f, 0.00827892f, 0.01167021f, -0.00899835f, 0.00411072f, 
    -0.02469024f, -0.03685585f, 0.00856462f, 0.02721398f, -0.00738372f, -0.02740245f, -0.02407952f, -0.02652609f, 
    -0.01182461f, 0.00913005f, 0.02146933f, -0.01725995f, 0.02323317f, -0.03287853f, -0.03651456f, 0.01922627f, 
    0.00658267f, 0.01449752f, -0.02890225f, 0.00096346f, -0.03458123f, 0.02899177f, -0.00784037f, -0.02381130f, 
    0.03037333f, 0.00408164f, 0.03004263f, -0.02664228f, 0.00082749f, -0.03214909f, 0.02476467f, -0.01319863f, 
    -0.01071634f, 0.02011496f, 0.03484819f, -0.01133162f, -0.00886436f, 0.01624566f, 0.03116155f, 0.00654257f, 
    -0.03888780f, -0.00830991f, 0.01264732f, -0.00733159f, -0.00529145f, 0.02876687f, 0.00646359f, 0.00925297f, 
    0.00289473f, 0.02549903f, -0.00710340f, -0.02360236f, -0.00238125f, 0.01923031f, -0.00963332f, -0.03346168f, 
    0.00228539f, 0.01316077f, -0.01565121f, -0.01656984f, 0.02920156f, 0.01216306f, 0.02692441f, 0.01987594f, 
    -0.01860381f, 0.00516974f, 0.01491857f, -0.01872665f, 0.01298079f, -0.00490113f, 0.00727560f, -0.01295999f, 
    -0.02803102f, -0.01992544f, 0.02618864f, -0.02198070f, 0.00073506f, 0.02595899f, -0.00282913f, 0.01382726f, 
    -0.00128979f, -0.02647638f, -0.02678953f, -0.01404292f, -0.01334805f, -0.01339670f, -0.03442709f, 0.02542334f, 
    -0.00273672f, -0.00301091f, 0.00319154f, -0.00005597f, -0.03710468f, 0.01301870f, -0.00331785f, -0.02217704f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04254200f, 0.10168968f, 0.01774327f, 0.11612637f, 0.07519963f, -0.03915945f, 0.08130272f, -0.02166248f, 
    -0.02057151f, 0.12180642f, -0.03783061f, -0.03386854f, -0.00168645f, 0.06862587f, -0.02445259f, 0.03002019f, 
    -0.02622353f, 0.21194406f, 0.10034146f, -0.00296512f, -0.00381418f, 0.02352827f, -0.03116673f, -0.03929227f, 
    0.02519752f, 0.01271857f, 0.04286665f, 0.21918966f, 0.05788769f, -0.02438475f, -0.02675036f, -0.03250062f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.43860868f, -0.20835038f, 0.13833068f, -0.19270165f, 0.20684060f, -0.16798767f, 0.23458900f, -0.15299216f, 
    -0.08625315f, -0.01237309f, -0.01884553f, 0.06663346f, -0.06567273f, -0.22290726f, -0.14225698f, -0.09129335f, 
    -0.15433958f, -0.18319118f, 0.33561763f, 0.03540521f, 0.09526955f, -0.33639580f, 0.07003172f, -0.09920916f, 
    0.01982896f, 0.11299830f, 0.15884802f, 0.05381993f, 0.27124095f, -0.04851487f, 0.01603039f, -0.00989908f, 
    0.02281212f, 0.21754277f, 0.17547002f, -0.29846060f, 0.07811216f, -0.01477570f, -0.29065526f, -0.11365401f, 
    0.09260215f, -0.18621136f, -0.03275761f, 0.06939811f, -0.09766333f, -0.34721038f, 0.00389927f, 0.06162344f, 
    -0.09630487f, 0.03079073f, 0.02895061f, 0.05405095f, 0.05969178f, -0.06791220f, 0.23817809f, 0.13207179f, 
    -0.07003723f, 0.13959393f, 0.12972908f, -0.16700852f, 0.07927267f, 0.15502457f, -0.09745971f, 0.14627820f, 
    0.07125987f, 0.56983346f, 0.08718998f, 0.20574470f, 0.26352164f, -0.04785261f, -0.04673312f, 0.09006369f, 
    -0.14520000f, 0.18682373f, -0.00906967f, 0.00080824f, -0.09812979f, 0.12010070f, -0.15891159f, 0.24607457f, 
    -0.05007068f, -0.22080478f, -0.13651235f, 0.14115712f, 0.14217521f, 0.16111469f, -0.01814506f, 0.14600706f, 
    -0.14663641f, -0.12975354f, 0.00717444f, -0.21877040f, 0.03567402f, -0.14303248f, 0.12270169f, 0.09354503f, 
    0.22618523f, 0.01293536f, 0.16848962f, -0.19163331f, -0.02837510f, 0.31574383f, -0.16019294f, 0.01089534f, 
    0.00851579f, 0.18705884f, 0.02864411f, -0.22241922f, -0.17437935f, 0.46211016f, 0.07660650f, 0.28596193f, 
    -0.17437613f, 0.15930441f, -0.24423012f, -0.12569363f, 0.11291657f, 0.13352333f, 0.04762287f, 0.05185671f, 
    -0.04175055f, -0.03390915f, -0.20303892f, 0.15745218f, 0.05943592f, -0.07401644f, 0.01329568f, 0.14252427f, 
    0.00509740f, -0.02122765f, -0.00584234f, 0.47771880f, 0.39154324f, -0.16911803f, 0.43190181f, -0.17246479f, 
    0.05694985f, 0.18830097f, 0.15518928f, -0.15411666f, -0.03903364f, 0.13167575f, 0.15612032f, -0.04492107f, 
    0.00065421f, 0.03924564f, -0.14347887f, -0.12659290f, 0.10603275f, -0.11745933f, -0.25891706f, 0.13414451f, 
    -0.03669392f, 0.17010823f, 0.03505305f, 0.27444637f, 0.01311017f, 0.14757417f, 0.01996432f, -0.10353575f, 
    0.18774293f, -0.17409131f, 0.09786447f, -0.29700935f, 0.11051623f, -0.02856801f, 0.08764687f, 0.13563672f, 
    0.03305935f, -0.11597348f, -0.02968844f, 0.28908542f, -0.36336625f, -0.03235274f, 0.15513715f, 0.06320533f, 
    -0.10245577f, -0.00114045f, 0.25825703f, -0.06726928f, 0.08894332f, -0.08559420f, -0.03575081f, -0.09569132f, 
    0.09729782f, 0.02184217f, 0.16544637f, -0.06669665f, 0.17352840f, 0.05009565f, -0.11009104f, 0.11850018f, 
    0.22286080f, 0.27658081f, 0.14743386f, -0.12539373f, -0.15048151f, 0.16820191f, -0.16651842f, 0.14083426f, 
    0.04479247f, 0.16580343f, 0.16123268f, 0.04188486f, 0.09405532f, -0.43383214f, -0.02243548f, 0.35086590f, 
    0.12928057f, 0.00700046f, 0.34856567f, 0.00229991f, 0.07551528f, -0.06753706f, -0.43863416f, -0.12660846f, 
    0.03308927f, 0.01257085f, 0.12381573f, 0.06893025f, -0.19348876f, -0.06058584f, 0.16013920f, -0.01624557f, 
    0.05084108f, 0.14298250f, -0.10362934f, 0.12001472f, 0.01054237f, -0.41302451f, -0.16899860f, -0.09428012f, 
    0.15508489f, -0.23407260f, 0.00259926f, 0.15903465f, 0.13995616f, -0.05663526f, 0.08244526f, 0.15521084f, 
    -0.06617004f, -0.40887919f, 0.17147639f, -0.06055838f, 0.07763487f, -0.05966499f, 0.29537246f, -0.06454849f, 
    -0.11784602f, -0.10899754f, 0.28088033f, 0.03649892f, 0.14227626f, -0.08525633f, -0.08404472f, 0.11248014f, 
    0.49557331f, -0.04853954f, -0.00074382f, -0.29585156f, -0.32151520f, 0.06870607f, -0.27770957f, -0.00266944f, 
    -0.11624677f, 0.13368514f, -0.05990112f, -0.12368069f, 0.11794457f, 0.01907096f, -0.08591375f, 0.29804000f, 
    -0.10807880f, -0.27434006f, 0.24613860f, 0.17122868f, 0.01502046f, 0.03670210f, -0.34534743f, 0.09181015f, 
    -0.07025927f, 0.10001845f, 0.36659691f, 0.08786549f, -0.04993135f, 0.04385896f, 0.10981295f, 0.08965404f, 
    0.11824456f, -0.10506213f, 0.13357273f, -0.24512276f, -0.34865177f, 0.04261702f, -0.13616544f, 0.06640957f, 
    0.09769167f, 0.11584140f, -0.06474726f, 0.30965537f, 0.23872323f, 0.21747090f, 0.06748655f, -0.06175653f, 
    0.11998411f, 0.10495114f, 0.19603445f, 0.11710399f, 0.03811371f, -0.22646509f, -0.01526002f, -0.07682587f, 
    0.15420638f, 0.03030496f, -0.02534179f, 0.09779319f, 0.24389632f, -0.13668911f, 0.10167765f, 0.00361989f, 
    -0.09815682f, 0.27179849f, -0.13054678f, 0.20345603f, 0.46854153f, -0.12706995f, 0.53976744f, -0.06220324f, 
    0.07616569f, 0.08825691f, 0.06154189f, 0.10225968f, -0.31201118f, -0.32441515f, -0.02932372f, -0.28534937f, 
    -0.01534333f, 0.08191913f, 0.04470416f, 0.12550150f, 0.00128508f, -0.06247891f, 0.10035329f, 0.12161490f, 
    0.10921209f, 0.13336487f, 0.19474027f, 0.11765292f, 0.07566476f, -0.03243737f, 0.12960844f, 0.02588627f, 
    -0.08193786f, 0.27652499f, 0.06540632f, -0.10919855f, 0.00723844f, -0.34737486f, -0.37684235f, -0.05976020f, 
    -0.04907011f, -0.13374659f, -0.14235161f, 0.08570807f, 0.09586294f, 0.11021551f, -0.09210592f, 0.30302265f, 
    0.10378072f, -0.23272446f, -0.12377456f, 0.08506565f, 0.11204787f, 0.10532943f, 0.12687199f, 0.11419547f, 
    -0.08430465f, 0.16006565f, -0.09258799f, 0.17686661f, 0.06283602f, -0.15055341f, 0.11663590f, 0.05124827f, 
    -0.03058711f, 0.01469232f, -0.01754438f, 0.17477991f, 0.05242198f, -0.27725807f, 0.16677347f, -0.03277828f, 
    -0.16251256f, 0.14383623f, -0.10617920f, 0.13311401f, -0.38780877f, 0.33597064f, -0.07245024f, -0.17466156f, 
    0.06136613f, 0.25538877f, 0.22790666f, -0.13630529f, -0.17075258f, -0.12631516f, 0.07273599f, 0.09619139f, 
    -0.10263295f, 0.02580561f, -0.22462149f, 0.11206213f, 0.30998316f, 0.07283808f, 0.04601352f, 0.03643822f, 
    0.31651732f, -0.03183139f, -0.02881009f, 0.05658556f, 0.28905228f, 0.02004704f, -0.17688157f, 0.12539603f, 
    0.08863366f, 0.21253271f, 0.05076915f, -0.00764764f, -0.20560081f, -0.17439981f, -0.07142118f, -0.12086646f, 
    -0.11380287f, -0.20044062f, -0.06122572f, -0.07347190f, 0.11925244f, -0.28162742f, 0.07533102f, -0.17786804f, 
    -0.10952965f, -0.05352726f, 0.28774017f, 0.02066310f, 0.01638551f, -0.06143750f, -0.07197881f, 0.17028564f, 
    0.05005820f, -0.14138445f, -0.02670113f, 0.05517956f, -0.19643226f, 0.02523205f, -0.43634254f, -0.11549449f, 
    0.15667531f, 0.31334183f, 0.14657953f, 0.14025785f, 0.23073032f, -0.27132940f, -0.01033506f, 0.27865246f, 
    0.04293041f, 0.07895348f, 0.39592084f, -0.11362054f, -0.14116620f, -0.18279749f, -0.26301306f, 0.17400625f, 
    0.16626340f, 0.13174698f, -0.25982058f, 0.14543620f, -0.05220810f, 0.15675212f, -0.02285488f, 0.16860817f, 
    0.18267603f, 0.25552225f, 0.03874063f, -0.20774461f, 0.06386385f, 0.43071234f, 0.31153312f, 0.04087541f, 
    -0.14132513f, 0.00528304f, 0.09526689f, 0.31803203f, -0.20984066f, 0.06742453f, 0.12620215f, 0.24561600f, 
    -0.07886466f, -0.00721225f, -0.31069651f, -0.09869731f, 0.16497940f, 0.37532768f, 0.20071122f, -0.05824235f, 
    0.04092223f, 0.11820155f, 0.00937235f, -0.02248654f, -0.22560222f, 0.14911680f, 0.12834713f, -0.09848706f, 
    -0.54169273f, -0.31540599f, 0.00231875f, -0.11004861f, -0.06700562f, 0.47012451f, 0.00504635f, -0.06132265f, 
    0.15335880f, -0.47327009f, -0.15927777f, -0.23079872f, 0.08851772f, -0.00338500f, -0.11675437f, -0.26395965f, 
    -0.06578048f, 0.15199915f, -0.25591922f, -0.11290921f, -0.03838094f, 0.04191439f, 0.06571672f, -0.14282496f, 
    -0.01823731f, 0.01030455f, -0.24833778f, 0.11849403f, -0.08592248f, 0.07164606f, -0.09140192f, -0.14293918f, 
    0.11495621f, 0.27003726f, 0.15358342f, -0.02707087f, -0.08056401f, -0.38670892f, 0.06204366f, 0.01260009f, 
    0.02487722f, -0.15510443f, 0.02402391f, -0.09684040f, 0.15848307f, 0.07323902f, 0.16195270f, -0.13690473f, 
    0.01342017f, 0.01354588f, 0.02956811f, 0.16628717f, -0.13005856f, -0.01785106f, 0.16088791f, 0.05400405f, 
    -0.05251116f, -0.06728926f, 0.21567830f, 0.13100450f, -0.04294144f, 0.09785453f, -0.03761058f, -0.09024532f, 
    0.27995443f, -0.35084665f, -0.11501933f, -0.30387580f, -0.10456339f, -0.04941217f, 0.05086919f, -0.15531640f, 
    0.05361000f, -0.07186066f, -0.11730119f, 0.33153045f, -0.01413692f, 0.23930235f, -0.09260304f, 0.08449062f, 
    0.03267408f, -0.02170233f, -0.13001336f, 0.09322477f, 0.06362970f, -0.05551258f, 0.23245412f, 0.10472906f, 
    0.09551807f, -0.06753550f, -0.07957168f, -0.07467585f, 0.03362690f, -0.01110497f, -0.15184450f, 0.13470109f, 
    -0.05394811f, 0.23027650f, -0.16386499f, 0.17288791f, -0.11426228f, 0.17045681f, -0.11144204f, 0.15988098f, 
    0.04088232f, 0.16896571f, -0.07228187f, -0.25949755f, 0.40690207f, 0.12450670f, -0.11869857f, 0.27631602f, 
    0.06798039f, 0.21173325f, -0.06502010f, -0.11519832f, 0.09515101f, 0.05975145f, -0.17825934f, 0.17446767f, 
    0.10494184f, 0.06836767f, -0.21247913f, 0.26752466f, -0.10513470f, -0.13697426f, -0.14009079f, -0.05336299f, 
    -0.39269575f, 0.36040562f, 0.01718067f, 0.30117989f, 0.05782117f, 0.07842682f, 0.16094902f, -0.05734628f, 
    0.16060698f, 0.24681759f, -0.15193035f, 0.25201023f, -0.12601735f, 0.40269479f, -0.04461531f, -0.02916662f, 
    -0.04168345f, -0.11044186f, -0.19880202f, 0.06098415f, 0.11052919f, 0.18373202f, -0.26266259f, -0.06433981f, 
    0.15763630f, -0.03274826f, -0.25448075f, 0.18817973f, -0.18051343f, -0.10201363f, -0.03522477f, 0.07410366f, 
    0.27552238f, 0.22098172f, -0.07776507f, -0.32263717f, 0.13406037f, 0.25238535f, 0.20624202f, -0.08273963f, 
    0.07470337f, 0.07290527f, -0.05789578f, 0.23748323f, -0.09429785f, -0.35437486f, -0.01436049f, -0.16040179f, 
    -0.11595682f, -0.13553354f, 0.11262549f, -0.03624038f, -0.15492421f, 0.13174036f, 0.00255886f, 0.03385772f, 
    -0.00147255f, -0.14523230f, 0.33313188f, -0.11725305f, -0.29335523f, -0.03318352f, 0.09305250f, -0.08218673f, 
    0.21015657f, 0.14247949f, -0.09179851f, -0.24096206f, -0.05582956f, -0.22257802f, -0.09528294f, 0.01563814f, 
    -0.05270061f, -0.13069668f, -0.03325160f, 0.00187172f, 0.00952789f, 0.12284855f, 0.15896028f, 0.46620971f, 
    0.01761431f, -0.07176118f, -0.05987035f, -0.17543496f, 0.00491463f, -0.08323879f, -0.07686283f, 0.08258701f, 
    0.09391510f, 0.04962399f, 0.17059557f, 0.24177554f, 0.14816451f, -0.06501552f, -0.17362839f, -0.08728094f, 
    -0.22210371f, 0.07711469f, -0.01493223f, 0.03256271f, 0.18333824f, -0.23668136f, 0.08057528f, 0.15971717f, 
    -0.11909974f, 0.19380279f, 0.14254147f, -0.16199358f, -0.02638193f, -0.25989401f, -0.04501693f, 0.06332932f, 
    0.01702636f, 0.31019083f, 0.25536975f, 0.16549335f, -0.17560372f, 0.01752592f, -0.00200767f, 0.13721056f, 
    -0.02907394f, -0.16658880f, 0.03664196f, 0.13665584f, 0.02316611f, -0.16553181f, 0.05243802f, -0.08069780f, 
    0.28126529f, -0.01985474f, -0.00187395f, -0.03699432f, 0.31388271f, 0.20419794f, -0.22851366f, 0.00032649f, 
    0.13332605f, 0.26485917f, -0.04727922f, -0.04720751f, -0.20603301f, -0.17200693f, 0.11326242f, 0.08881915f, 
    0.14432940f, -0.01248901f, 0.01597065f, -0.01470811f, 0.12564500f, 0.13146569f, 0.27685395f, 0.06471200f, 
    -0.05670123f, 0.11645772f, 0.06124957f, -0.31133765f, 0.06882314f, -0.06726456f, -0.11071265f, -0.17556006f, 
    -0.03411661f, 0.27851233f, -0.13679649f, 0.03862877f, 0.05203540f, -0.08737093f, -0.58037198f, -0.07973764f, 
    0.08743109f, 0.34809816f, 0.14262868f, -0.05387622f, 0.04553584f, 0.05352091f, 0.11319119f, 0.18781573f, 
    0.06452006f, 0.05927894f, 0.27321625f, -0.11097933f, 0.00426996f, 0.23972781f, 0.09783501f, -0.11919135f, 
    -0.14689630f, 0.16339226f, -0.48098829f, -0.27467707f, 0.06200345f, -0.08174480f, -0.05044051f, 0.01832242f, 
    -0.37041244f, 0.11948589f, -0.04456431f, 0.22414197f, 0.25224701f, 0.23707481f, 0.26127112f, -0.11907902f, 
    0.11929436f, -0.00724057f, -0.06361771f, -0.07560416f, 0.09433223f, 0.03734909f, 0.15148284f, -0.34399500f, 
    0.02206888f, 0.09565277f, -0.40280288f, 0.12286756f, 0.08114234f, 0.11189690f, 0.04558846f, 0.02255187f, 
    0.06971229f, -0.11308057f, 0.19482231f, 0.08701537f, 0.04924807f, 0.02007349f, 0.07502002f, -0.11585072f, 
    -0.08707128f, 0.03074941f, -0.09561835f, -0.05308220f, -0.06619315f, 0.10678815f, -0.03070829f, 0.02808779f, 
    0.17848584f, -0.03725852f, -0.00540646f, 0.11376015f, -0.05331930f, -0.04387842f, 0.12649970f, 0.05079483f, 
    -0.10016298f, 0.06811857f, -0.17295252f, -0.09785780f, -0.10020044f, -0.11437149f, -0.14372198f, 0.14931875f, 
    -0.15827245f, 0.15391444f, -0.27867526f, -0.24501292f, 0.20697118f, -0.12342239f, 0.09065751f, 0.07852562f, 
    0.03604827f, -0.44294187f, -0.03147993f, 0.00396228f, -0.21594946f, 0.05232574f, 0.43218693f, -0.08190356f, 
    -0.09326187f, -0.08368520f, -0.01541754f, -0.02620591f, -0.09141406f, 0.26676688f, -0.11138601f, 0.07720660f, 
    -0.08311419f, 0.40948367f, 0.42753702f, 0.17650633f, -0.01785562f, -0.05280333f, -0.11060968f, 0.11236757f, 
    0.09552214f, -0.14865942f, 0.22086728f, 0.46211162f, 0.22204247f, 0.06178853f, -0.05138850f, -0.11668133f, 
    0.11565114f, 0.01307937f, -0.10569611f, 0.13053788f, 0.25753155f, -0.58279324f, -0.08289859f, -0.18087381f, 
    -0.10821075f, -0.05480524f, -0.06950932f, -0.28395015f, -0.04688779f, 0.33481777f, 0.01184204f, 0.03979585f, 
    0.11961126f, -0.12087011f, 0.03728823f, -0.00015276f, -0.05284226f, -0.32815003f, 0.02061397f, -0.02016559f, 
    0.15547295f, -0.05380448f, 0.07060394f, 0.21363154f, 0.32948110f, -0.17812744f, -0.16889526f, 0.09577620f, 
    -0.11518466f, -0.15772550f, 0.14939965f, 0.02141596f, -0.18425018f, -0.08457600f, 0.07425503f, 0.09335323f, 
    0.01938900f, -0.11627883f, -0.00745578f, 0.03597318f, 0.19012940f, 0.10632882f, 0.15410520f, -0.16135643f, 
    0.06106836f, -0.10046714f, -0.11460817f, -0.15939455f, 0.01994258f, -0.14214788f, -0.20361169f, -0.00777172f, 
    0.03988893f, 0.09246219f, 0.11520778f, -0.03101650f, -0.06463932f, -0.04849640f, 0.08480544f, 0.13752905f, 
    -0.18302020f, 0.36574432f, -0.06630851f, 0.28605050f, 0.04049259f, -0.05864577f, -0.09179124f, 0.13946390f, 
    0.11834668f, 0.25563926f, -0.15290216f, 0.35647181f, 0.10691524f, 0.12483986f, -0.13689606f, -0.26515335f, 
    -0.14439629f, -0.24890415f, 0.16304284f, 0.02243145f, 0.08070747f, 0.11550887f, -0.16594316f, 0.15331906f, 
    0.16010556f, -0.04478963f, -0.20386808f, -0.28442344f, 0.16675664f, 0.04532992f, -0.11505578f, 0.17646164f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02449044f, -0.06915948f, -0.08863446f, 0.01596627f, 0.02897563f, -0.19482315f, 0.06902997f, 0.11142237f, 
    0.09169795f, -0.10169170f, 0.18072136f, 0.04662341f, 0.01398054f, 0.14525920f, 0.07067177f, 0.08607052f, 
    0.11618934f, -0.08735105f, 0.04843970f, 0.14536241f, 0.05308251f, 0.10838506f, 0.14268628f, 0.00372461f, 
    -0.20023309f, 0.00856907f, -0.02649564f, 0.01445077f, 0.14241093f, -0.00597861f, -0.16892086f, -0.00680696f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.27511528f, 0.13173541f, 0.18283854f, 0.03356568f, 0.09509686f, -0.62530243f, 0.00229151f, -0.42514020f, 
    0.04085720f, -0.27494895f, -0.19256629f, -0.26282427f, -0.32989860f, 0.34753469f, 0.10669487f, 0.10913271f, 
    0.11159052f, -0.08873163f, -0.07263553f, -0.02893898f, -0.02726571f, 0.15241519f, -0.31938133f, -0.42789015f, 
    0.32167834f, 0.18219720f, 0.20639099f, -0.00681127f, -0.50396812f, 0.01516332f, -0.29174659f, 0.15682550f, 
    -0.47538415f, 0.09199384f, 0.16995724f, 0.04785181f, 0.18794110f, -0.33471942f, -0.34356150f, 0.02489091f, 
    -0.31289116f, -0.34892231f, 0.20482589f, 0.16726774f, -0.00275794f, -0.23278572f, -0.37607333f, 0.33131769f, 
    -0.05308624f, 0.10033234f, -0.18930526f, -0.00186286f, 0.10864909f, 0.07108720f, 0.14302357f, 0.14676435f, 
    0.00512097f, -0.12777089f, 0.15475091f, 0.07107528f, 0.04994509f, -0.03384984f, 0.08738495f, -0.05511925f, 
    0.16689171f, -0.20388922f, -0.45796117f, 0.03363045f, 0.13722011f, 0.01450388f, 0.14458491f, -0.34306708f, 
    0.03241626f, -0.09411797f, 0.20781823f, -0.55429769f, 0.01933827f, 0.32223147f, 0.19310708f, 0.17194740f, 
    0.23009486f, -0.19492579f, -0.15710649f, 0.01132752f, -0.21028320f, 0.24856633f, -0.02603103f, 0.15908052f, 
    0.02467633f, -0.53507292f, -0.10315186f, -0.12371775f, 0.20523240f, -0.46485028f, -0.12155677f, -0.96014857f, 
    0.22375031f, -0.40631920f, -0.08833656f, -0.14931947f, -0.29650539f, 0.39201894f, 0.04140868f, -0.15938297f, 
    -0.08008195f, 0.20702842f, -0.00395621f, -0.17332660f, -0.05735139f, 0.05858967f, 0.05926994f, 0.18744363f, 
    -0.69181955f, -0.71128619f, 0.17413704f, -0.30904081f, -0.16135703f, 0.33776841f, -0.39692059f, -0.33982450f, 
    0.15284961f, -0.09055033f, -0.10676628f, -0.09943481f, -0.17943215f, -0.36345965f, -0.22453849f, 0.19785796f, 
    -0.59663814f, -0.01862271f, -0.22091030f, -0.00320960f, -0.51533890f, -0.14003442f, 0.18095753f, 0.07497441f, 
    0.10358587f, 0.13877417f, -0.39026585f, 0.13126405f, 0.07965456f, -0.15103574f, 0.21861051f, 0.20154628f, 
    -0.17286581f, 0.09091107f, 0.06745491f, -0.00171269f, 0.04237870f, 0.10474852f, -0.78539342f, -0.15274157f, 
    -0.02212020f, 0.13235018f, -0.03573339f, 0.12555684f, 0.12062757f, -0.00760858f, -0.30663836f, -0.05887932f, 
    0.01273971f, 0.30138499f, 0.18394470f, -0.17444031f, 0.10374779f, -0.13170648f, -0.04814054f, -0.20929453f, 
    -0.51910275f, -0.05208128f, 0.05291514f, -0.10358795f, 0.22300199f, -0.06955417f, 0.25279647f, -0.22100796f, 
    0.02468394f, -0.06409529f, -0.15234956f, -0.06642215f, 0.03966301f, -0.19676000f, -0.29359424f, 0.27772626f, 
    0.10536215f, 0.27269608f, -0.14921525f, -0.21645693f, -0.00950746f, -0.12043678f, -0.18341632f, 0.27692518f, 
    0.12439760f, -0.13556920f, -0.52688318f, -0.03102958f, 0.22051193f, -0.08961652f, 0.11395440f, -0.05868364f, 
    0.25195628f, 0.09893185f, -0.18252313f, -0.08978496f, 0.02415807f, 0.10311687f, 0.16611786f, -0.84447587f, 
    -0.13643122f, -0.00997626f, -0.32923111f, 0.06517740f, -0.25322726f, -0.36573106f, 0.00554937f, 0.28601286f, 
    -0.47611633f, -0.46716070f, -0.01033073f, -0.14842691f, 0.23047353f, 0.31373408f, 0.20924397f, -0.42504621f, 
    0.12362733f, 0.17483334f, 0.02477026f, -0.50281990f, -0.24338979f, 0.07151606f, 0.15166709f, 0.30027273f, 
    0.12071345f, -0.10941691f, -0.06535099f, 0.11319449f, -0.19852677f, -0.17369097f, -0.04772197f, 0.09942860f, 
    -0.29370984f, 0.05616748f, 0.16058926f, -0.34670833f, -0.32234606f, 0.36048067f, 0.11359925f, -0.12197582f, 
    -0.04915850f, -0.15422244f, -0.02940203f, 0.02543546f, 0.00607117f, -0.04651616f, 0.01695914f, -0.00437665f, 
    0.30478317f, -0.12844983f, 0.00673937f, -0.58714867f, 0.18968305f, -0.02254298f, -0.25628603f, 0.27793580f, 
    -0.04388209f, -0.25064635f, 0.37675747f, -0.17820458f, 0.26794091f, 0.25459921f, -0.43047717f, -0.36868152f, 
    0.00893388f, 0.03024176f, -0.26756924f, -0.31743205f, -0.10373516f, -0.14307730f, -0.18262970f, 0.04742097f, 
    -0.02881752f, -0.38857782f, 0.09782977f, 0.10694545f, 0.10444218f, 0.32393447f, -0.18030934f, -0.08361096f, 
    -0.03648875f, -0.52735376f, -0.09947214f, 0.04950626f, -0.15228629f, -0.22854257f, 0.38195705f, -0.04374997f, 
    0.30401191f, 0.11070577f, -0.53409463f, 0.04879791f, -0.35624215f, -0.23514901f, 0.24307634f, 0.01108014f, 
    -0.09218856f, -0.27235955f, -0.39630181f, 0.20678373f, -0.00283522f, -0.11972274f, 0.00627394f, -0.06789801f, 
    -0.18875287f, 0.03683033f, -0.33919948f, 0.05555912f, 0.05559802f, -0.39220566f, -0.31754509f, -0.45275554f, 
    0.07744892f, -0.53275025f, -0.40722978f, -0.26944202f, 0.23287956f, -0.13938388f, -0.35769817f, -0.26794937f, 
    -0.52734590f, 0.24355462f, 0.12877944f, -0.42156234f, 0.09612700f, -0.43581924f, -0.04416616f, 0.05279652f, 
    -0.71316057f, -0.34119096f, -0.04600744f, 0.02290599f, 0.31887066f, -0.14645159f, -0.06866027f, -0.15252301f, 
    -0.89179993f, -0.66829354f, 0.22734576f, -0.17799424f, 0.30858517f, -0.36992687f, -0.17659716f, 0.20811342f, 
    0.19904500f, -0.28621945f, -0.00770719f, 0.29594389f, 0.09895436f, 0.21991971f, -0.56128311f, 0.03503323f, 
    -0.04962436f, 0.11244691f, -0.18019067f, -0.07455187f, 0.25190508f, -0.02290844f, -0.23156914f, 0.09624197f, 
    -0.71209413f, -0.08779442f, 0.29565543f, -0.17534295f, -0.06257216f, -0.41007188f, 0.16235361f, -0.26387367f, 
    -0.14775878f, -0.07934958f, -0.53632426f, -0.11493280f, 0.18061040f, 0.17565829f, -0.26831436f, -0.27721390f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.22180004f, 0.22672161f, -0.12135971f, -0.02548788f, -0.12142866f, 0.18013635f, 0.08773495f, 0.01993993f, 
    -0.04230260f, 0.01794497f, 0.05869927f, -0.10023767f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
