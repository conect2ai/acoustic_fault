#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64275372f, 0.91594535f, 0.08156496f, 0.61044759f, -0.36726505f, 0.46496990f, 0.56984138f, 0.13282543f, 
    -0.19100544f, 0.68191141f, 0.17504576f, -0.87995541f, -0.32564676f, 0.73537993f, -0.24528706f, 0.45260504f, 
    0.21063608f, 0.06886861f, 0.63336825f, -0.99871624f, -0.68263882f, -0.90538710f, 0.22554554f, -0.62475091f, 
    0.18972574f, 0.59607154f, 0.45335898f, 0.00448280f, -0.56362593f, 0.58339590f, -1.04772830f, -0.24548271f, 
    -0.39231345f, 0.23107442f, -0.24708249f, 0.11766645f, 0.11746071f, 0.67175967f, -0.44003165f, -0.86625165f, 
    0.64925814f, 0.72519034f, 0.49819475f, 0.56817591f, -0.55834055f, 0.26838467f, 0.98764157f, 0.66213596f, 
    -0.76516044f, 0.04710206f, 0.14112370f, -0.34794119f, -0.34591350f, -0.29674765f, -0.96103567f, 1.05620325f, 
    -0.00681898f, -0.28049472f, -0.50489265f, 0.58863515f, -0.41132927f, 0.32834992f, 0.15023202f, -0.65967214f, 
    0.47835177f, -0.20623846f, -0.65387261f, 0.58034748f, -0.50746864f, -0.42261267f, 0.19726399f, 0.00931596f, 
    -0.69709110f, -1.11357975f, -0.43309242f, -0.49050578f, 0.90782630f, 0.86846823f, 0.10721981f, -0.19169347f, 
    -0.17166860f, 0.43431175f, -0.88116431f, -0.19428520f, 0.85659850f, -0.37354547f, 0.52312380f, -0.54564941f, 
    -0.21448255f, -0.55883288f, 0.27638668f, 0.23584685f, 0.04514521f, 0.07031464f, -0.03076995f, 0.93655753f, 
    -0.04224365f, -0.76495004f, 0.33225930f, -1.11021805f, 0.59599149f, 0.69226372f, -0.45610833f, 0.31885359f, 
    -0.09258071f, -0.42459419f, -0.29657215f, -0.11134713f, 0.65703964f, 0.87461340f, 0.66292059f, -0.50540435f, 
    -0.69401890f, 0.30733755f, 0.46352741f, -0.38068327f, -0.28692010f, -0.50775647f, 0.07733917f, -0.87859541f, 
    0.64689142f, -0.51626223f, -0.33325723f, 0.42930308f, 0.30890223f, -0.15396981f, -0.79658657f, -0.78535849f, 
    -0.15247051f, -0.22096926f, -0.86508501f, 0.25289202f, -0.27270985f, 0.19576959f, 0.21266705f, 1.01663733f, 
    0.11106583f, 0.76343697f, -0.02415303f, -0.45652059f, -0.53985822f, -0.38642868f, -0.35980615f, -0.02961794f, 
    -0.24657875f, 0.92154658f, -0.71751827f, 0.01498212f, 0.53549916f, -0.77294821f, 0.20307277f, -0.31886804f, 
    -0.19576536f, -0.22356196f, -0.83646661f, -0.94583899f, -0.52663291f, 0.26824901f, 0.29066232f, -0.11818392f, 
    -0.01968443f, 0.23275240f, -0.27733961f, -0.05044787f, 0.71228069f, -0.85087770f, 0.80091578f, -0.62317407f, 
    0.19760539f, 0.25338593f, -0.00592794f, -0.59488237f, -0.77131969f, -0.39371085f, -0.15798733f, -0.70252377f, 
    -0.26712710f, 0.49359849f, 0.56413722f, -0.00998827f, 0.79182768f, -0.94653314f, -0.40823498f, -0.16226196f, 
    -0.17443980f, 0.63120937f, 0.21513788f, -0.36835632f, -0.06317597f, -1.10528934f, 0.09348298f, -0.62128836f, 
    0.77456206f, 0.24458197f, 0.43406898f, 0.35870558f, -0.24308877f, -0.23822457f, 0.76424527f, 0.63161200f, 
    -0.41571313f, 1.01287889f, 0.71328062f, -0.00798876f, -0.07275154f, -0.20856059f, -0.31600147f, -1.14854431f, 
    0.45323756f, 0.83306247f, 0.14562112f, 0.72900796f, -0.52756286f, -0.37380353f, 0.46057004f, -0.31561166f, 
    -0.87886059f, 0.25086331f, -0.65733224f, 0.42973530f, 1.03326547f, 0.35522908f, -0.28171679f, -0.34436658f, 
    0.01370547f, 0.57232571f, 0.01714733f, 0.61354399f, -0.79834938f, -0.84451455f, -0.69567692f, 0.58545363f, 
    0.41828379f, -0.28215855f, -0.55033135f, -1.30148530f, 0.64551926f, 0.43174461f, 0.08104452f, 0.15404095f, 
    -0.40027842f, -0.16356409f, -0.33020949f, -0.83810025f, -0.73369133f, 0.70436817f, 0.91749114f, 0.20265393f, 
    0.06571673f, -0.18723774f, 0.22246067f, 0.13826963f, -0.76226139f, -0.39737123f, -0.35487738f, -0.81218469f, 
    -0.55505985f, -0.78873199f, 0.38457465f, -0.20583095f, 0.11927327f, -0.47293606f, 1.00037551f, 0.14093331f, 
    -0.69994503f, 0.79813135f, 0.03118368f, 0.04187505f, -0.08550505f, 0.46289229f, 0.84597659f, -0.65533870f, 
    1.02523768f, -0.41915336f, -0.11725962f, -0.29365191f, 0.75348312f, -0.16911858f, -0.12198724f, -0.54290533f, 
    -1.01140738f, -0.65869129f, 0.46107242f, 0.71407700f, -0.03790032f, -0.35445932f, -0.37966186f, -0.04063407f, 
    -0.16254964f, -1.20430875f, -0.53090650f, -0.20515813f, 0.98849761f, 0.71390468f, -0.48931089f, 0.14283064f, 
    -0.59037459f, -0.24079078f, 0.92627341f, -0.25502688f, 0.86328107f, -0.96461582f, -0.83709460f, 0.36493170f, 
    -0.07666943f, 0.22796027f, 0.86631638f, -0.65850174f, 0.66609246f, -0.66324294f, -0.47550628f, -0.51333338f, 
    -0.44973728f, 0.38224557f, -0.38241246f, -0.66283911f, 0.06299564f, -0.07015392f, -0.65634686f, -0.57496369f, 
    -0.01205619f, 0.16934168f, 0.64495850f, -0.43788227f, -0.78748149f, 0.25002116f, -0.51159477f, 0.81862682f, 
    0.34994143f, -0.19290698f, -0.28645843f, 0.52129966f, 0.12182363f, 0.99379104f, 0.90425569f, -0.45780611f, 
    -0.69972956f, -0.25344995f, -0.52480471f, 0.33094645f, 0.25300428f, -0.15917684f, -0.83621997f, 0.33864841f, 
    -0.49615577f, -0.22447252f, 0.76291245f, 0.44387943f, -0.29930070f, 0.17867339f, 0.07937928f, 0.75211030f, 
    0.70165086f, 0.63391650f, -0.28377691f, -0.59715670f, -0.72238988f, 0.06647404f, 0.47061467f, 0.47032911f, 
    -0.85669059f, -0.43311971f, -0.06111042f, 0.05878365f, 0.26295069f, 0.52922285f, 0.06373082f, -0.19594121f, 
    0.67375350f, -0.37814161f, -0.78137815f, -0.87339938f, -0.45069483f, 0.15156363f, -0.01597843f, -0.33541307f, 
    0.29694748f, 0.09515401f, -0.33906430f, 0.82155538f, 0.87058800f, 0.52473772f, -0.11277727f, 0.70838237f, 
    -0.32512736f, -0.12616497f, -0.38781121f, 0.54694581f, 0.42857611f, 0.67459118f, 0.00866285f, -0.68952131f, 
    0.63602042f, 0.46730435f, 0.65626055f, 0.46944934f, -0.87196004f, 0.60063732f, -0.22066036f, -0.19357240f, 
    0.94411862f, -0.34185362f, -0.28804463f, 0.29518518f, 0.51615244f, 0.42825526f, 0.94046056f, 0.95888501f, 
    0.37652549f, -0.08635524f, 0.32016176f, -0.20686214f, 0.19770691f, 0.22548495f, 0.86159337f, -0.52328014f, 
    -0.97522718f, 0.63281602f, -0.72068292f, -0.21971910f, -0.46002409f, -0.16171165f, 0.35862878f, 0.63608402f, 
    0.92498755f, 0.70039284f, -0.48426551f, 0.38405305f, -0.37301210f, 0.46829927f, 0.36089405f, 0.04687364f, 
    -0.91989243f, 0.60790604f, 0.93985826f, 0.61280817f, 0.60107374f, 0.52706712f, 0.28107563f, -0.38419360f, 
    0.39760602f, 0.65941304f, 1.10361886f, -0.87614030f, -0.36610880f, 0.46697715f, -0.38230243f, -0.00803586f, 
    -0.29182884f, 0.76400447f, 0.57850844f, -0.19671725f, -0.51844281f, 0.92088664f, 0.56297386f, -0.47342739f, 
    0.43501800f, 0.55975217f, 0.13655299f, -0.54924792f, 0.73185956f, 0.26347169f, 0.52767146f, 0.83281142f, 
    0.09756801f, 0.21240421f, 0.06734812f, -0.46037585f, -0.63838726f, -0.15331852f, 0.52332479f, -0.87411308f, 
    -0.50393832f, -0.40924421f, -0.48961470f, 0.17844301f, 0.17929190f, 0.80624849f, -0.27592596f, -0.55672687f, 
    -0.68554676f, 0.05148425f, -0.67967522f, -0.52880996f, -0.22933671f, -0.19698401f, 0.56935561f, 0.63769329f, 
    -1.02967644f, -0.12412830f, -0.00329621f, 0.71003497f, -0.66506118f, -0.53310633f, -0.12967741f, -0.71973979f, 
    -1.06645358f, 0.31846866f, 0.07735577f, 0.06627774f, 0.29915163f, 0.60768116f, -0.21644779f, -0.49642009f, 
    -0.86456180f, 0.74408817f, -0.84101194f, 0.77105117f, -0.51009154f, -0.55322862f, -0.04250562f, -0.39653373f, 
    -0.25312656f, -0.70165968f, 0.53190535f, 0.53135526f, 0.27987367f, 0.64159340f, 0.58611554f, -0.34328026f, 
    -0.34166548f, -0.18165916f, 0.00937197f, -0.63189453f, 0.96315700f, 0.27461612f, -0.90100849f, -0.63084441f, 
    0.34321219f, 0.33245659f, -0.25976518f, -0.57153618f, -0.17780809f, 0.85411656f, -0.91282016f, 0.35531852f, 
    0.62928772f, 0.53345621f, -0.00467627f, 0.44221631f, -0.17268214f, -0.31490329f, 0.71779275f, -0.97209626f, 
    -0.77276945f, -0.26729459f, 0.00747776f, -0.12250093f, -0.50813383f, -0.71747690f, -0.97140986f, -0.26399004f, 
    0.63445312f, 0.26832354f, -0.29689437f, -0.31704220f, 0.27997088f, -0.00549598f, 0.92360765f, 0.67169064f, 
    0.54093868f, -0.77347839f, -0.34941980f, 0.38265678f, -0.11401035f, 0.27155620f, -0.53398085f, 0.63014007f, 
    0.31058758f, 0.68349224f, -0.31913650f, 0.76788276f, 0.15659556f, 0.07242227f, -0.46872908f, -0.24881908f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06090286f, 0.09175463f, 0.43455067f, 0.04031730f, -0.07724266f, 0.25154084f, 0.13606314f, -0.14033432f, 
    0.14598720f, 0.01565427f, 0.04199550f, -0.04668858f, 0.06127097f, 0.00950374f, -0.05702664f, 0.15479487f, 
    0.15919849f, 0.13268462f, 0.05763881f, 0.35998231f, -0.10004850f, -0.08731651f, -0.03133182f, 0.13447562f, 
    -0.17245534f, -0.07881435f, 0.09603550f, 0.18768349f, 0.25131419f, 0.23511736f, -0.11747774f, 0.30256811f, 
    -0.01268776f, -0.02487883f, -0.13821013f, 0.32948145f, 0.17329372f, -0.05390100f, -0.08027313f, -0.01638424f, 
    -0.15417010f, 0.29339623f, 0.03447289f, -0.07509327f, 0.22613084f, 0.35096100f, 0.17764412f, 0.25835922f, 
    -0.00202857f, -0.12156932f, -0.09106974f, 0.14818247f, -0.00597823f, -0.13220251f, 0.15991269f, 0.30139935f, 
    -0.16871896f, 0.10799728f, 0.09465566f, 0.00547694f, 0.10826197f, 0.31843576f, -0.01880262f, 0.14676529f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11149117f, -0.06577932f, 0.08535653f, -0.20860992f, 0.07578966f, -0.12375953f, 0.02225498f, 0.02141871f, 
    -0.02339842f, 0.03025685f, -0.02359194f, -0.00727621f, -0.00293869f, 0.00697559f, -0.01884276f, -0.01899736f, 
    -0.01301232f, -0.01360862f, -0.07305114f, 0.00359312f, -0.32622099f, 0.06178485f, 0.07709704f, 0.02092991f, 
    0.17247751f, -0.06942510f, -0.03527611f, -0.00962366f, 0.00843224f, 0.05813227f, 0.00695220f, 0.02195339f, 
    -0.00252307f, -0.00887827f, 0.04433662f, 0.00174009f, 0.01886269f, -0.00263606f, -0.05103878f, -0.07892371f, 
    -0.19000338f, -0.33836284f, 0.11453900f, 0.06894657f, -0.07628643f, -0.03595998f, -0.07971872f, 0.02395290f, 
    -0.01734292f, 0.03963220f, 0.05289621f, 0.08377538f, -0.05321551f, -0.04853900f, -0.03175604f, -0.01318041f, 
    -0.06013488f, -0.08123966f, 0.06542175f, 0.01719484f, 0.19913794f, -0.23884344f, -0.05390244f, 0.12454452f, 
    -0.17671897f, -0.05234794f, 0.00384303f, -0.01480986f, 0.04600133f, 0.00322888f, 0.02322114f, -0.03189621f, 
    -0.09428792f, 0.00184563f, -0.01562730f, 0.00840834f, -0.06422461f, 0.04690718f, 0.02625887f, 0.01693809f, 
    -0.34735933f, 0.10911510f, 0.02022973f, -0.04684688f, 0.16225119f, -0.08023547f, 0.00828263f, -0.03775232f, 
    -0.10630043f, 0.04108364f, -0.00063015f, -0.03377785f, 0.05643529f, 0.05002325f, 0.07210223f, -0.11410241f, 
    0.02972884f, -0.06241668f, -0.01255452f, -0.13106795f, 0.03542885f, 0.05437616f, -0.08963943f, 0.04841999f, 
    0.20720471f, -0.05999753f, -0.11357425f, -0.09220596f, -0.02138256f, 0.00976118f, -0.02743206f, 0.01231303f, 
    -0.00999343f, -0.02947748f, 0.01016965f, 0.04456945f, 0.03893581f, -0.04801182f, 0.01685227f, 0.04941252f, 
    -0.18062370f, 0.11061892f, 0.05800761f, 0.02401797f, 0.11150788f, 0.03253704f, -0.02140962f, -0.01594710f, 
    -0.10356443f, -0.05477591f, -0.04350876f, -0.04150019f, -0.07076480f, -0.01474327f, 0.01150201f, -0.13438009f, 
    -0.00174240f, 0.07238422f, -0.10817007f, 0.02630626f, 0.21506172f, -0.21329777f, 0.05450601f, 0.01114777f, 
    0.02507609f, -0.00324052f, 0.00237256f, 0.00435074f, -0.03773087f, 0.11837720f, -0.02620002f, 0.06529076f, 
    -0.09026965f, -0.07518075f, 0.00336755f, -0.04801556f, -0.02040334f, 0.11405868f, 0.02704242f, 0.01359965f, 
    -0.31761163f, 0.22100149f, -0.02106887f, -0.12858309f, -0.24334505f, 0.02162624f, 0.02715080f, 0.00956187f, 
    0.07365786f, 0.01676255f, 0.05236640f, -0.01724280f, -0.02469620f, 0.01263927f, -0.00154896f, -0.01434584f, 
    -0.07607523f, -0.03224921f, 0.04454799f, 0.00851051f, 0.29176959f, -0.01344559f, 0.04060739f, -0.01419868f, 
    -0.19121611f, 0.05780483f, 0.07068990f, -0.00207438f, -0.00027608f, -0.03692539f, -0.10354196f, -0.02857203f, 
    0.07683840f, 0.04624823f, 0.01608526f, 0.07627092f, 0.10125443f, 0.05121122f, 0.01288810f, 0.07101071f, 
    -0.11501747f, -0.06320271f, -0.02130045f, -0.03291883f, 0.02267315f, -0.03827409f, 0.07321893f, -0.13696240f, 
    -0.02728528f, 0.00741045f, -0.00645308f, 0.01426742f, 0.06119308f, -0.05747730f, 0.06134249f, 0.02617872f, 
    0.10204332f, 0.01786797f, -0.05159603f, 0.00588821f, -0.02262762f, -0.00741518f, 0.05217291f, 0.16849571f, 
    0.10142065f, -0.03009469f, -0.03295359f, 0.02276422f, 0.07243785f, 0.04491533f, 0.03738956f, 0.00648087f, 
    0.00506188f, 0.11172044f, -0.02921682f, 0.12085389f, -0.06818308f, 0.04220115f, 0.05522490f, -0.01344502f, 
    0.07939821f, 0.10858117f, 0.03310266f, -0.16784301f, 0.12795472f, -0.11340833f, -0.15230930f, -0.07301009f, 
    -0.02891388f, 0.00673725f, -0.03098643f, 0.00264063f, 0.04700104f, -0.08007041f, 0.06847757f, 0.02748208f, 
    0.05541387f, -0.02680409f, -0.01803703f, 0.00631104f, 0.24665864f, -0.31136858f, -0.00805738f, 0.02278464f, 
    0.01235680f, -0.09229065f, -0.05691359f, 0.00991482f, 0.02364886f, -0.00312366f, 0.03569240f, 0.01981283f, 
    -0.01521532f, 0.05212912f, 0.08315912f, -0.00400329f, 0.01986406f, 0.03276004f, 0.10693312f, -0.06110491f, 
    -0.24182004f, -0.26973155f, -0.15349479f, 0.09984291f, -0.12746677f, 0.02172096f, -0.01340823f, -0.06592295f, 
    0.05572316f, 0.00871973f, -0.01951241f, -0.03626012f, -0.04733725f, -0.06178512f, 0.08252167f, 0.02953483f, 
    0.00118726f, 0.02675964f, -0.04859856f, -0.03067014f, 0.18717346f, 0.00064764f, 0.05926705f, -0.04101878f, 
    -0.04008693f, -0.03744559f, -0.19874075f, -0.02502106f, 0.04473822f, 0.03990784f, -0.09661923f, 0.03139508f, 
    -0.06176686f, 0.04521920f, 0.02672018f, 0.03773580f, -0.02955929f, 0.04123246f, 0.03142826f, 0.04677255f, 
    0.29376924f, 0.01670711f, 0.09130958f, -0.09267864f, 0.15215778f, -0.00087020f, 0.06035650f, 0.03549950f, 
    0.00711083f, 0.01553912f, 0.02183752f, 0.01734670f, -0.00855167f, -0.01545956f, 0.00288821f, -0.02077037f, 
    -0.00713306f, 0.05628379f, -0.05077537f, -0.03127181f, -0.19960275f, 0.13830583f, -0.15409811f, 0.01794236f, 
    -0.24586703f, -0.00568200f, -0.05441729f, 0.06360510f, -0.01943072f, -0.00399060f, -0.01709378f, -0.04501247f, 
    0.02829827f, -0.00893600f, 0.01776698f, -0.03994102f, -0.04381862f, -0.02655627f, -0.00653244f, 0.00311715f, 
    -0.02353491f, -0.25297987f, 0.05039012f, 0.18520890f, -0.21289237f, -0.05695788f, -0.03924837f, -0.02863648f, 
    0.00872688f, 0.06330979f, 0.03983922f, 0.11225661f, -0.01135152f, 0.00515405f, -0.07277890f, 0.03805323f, 
    -0.11944138f, -0.02552558f, -0.09125356f, -0.07364594f, -0.17177066f, -0.38293090f, -0.01186176f, 0.02488602f, 
    -0.08593652f, 0.01326055f, -0.03817400f, -0.01146591f, -0.01401371f, -0.03013197f, -0.03672151f, -0.01846498f, 
    0.02128101f, -0.06071565f, 0.02864154f, 0.08173912f, 0.00520694f, 0.02202948f, 0.02868668f, -0.05891139f, 
    0.07710909f, -0.04906687f, 0.05130696f, 0.14387777f, -0.22795561f, 0.05683061f, 0.09799465f, -0.03323559f, 
    -0.03985485f, 0.08602160f, -0.10525846f, -0.02690488f, -0.03843137f, -0.09050645f, 0.01284815f, -0.03122216f, 
    -0.02657339f, 0.03790848f, 0.06476234f, -0.10258631f, 0.39146319f, -0.01279307f, 0.10168491f, -0.12473319f, 
    -0.27441779f, 0.02667288f, 0.05758238f, -0.02264114f, 0.06621411f, 0.02515977f, 0.00094432f, -0.04889754f, 
    -0.03198003f, 0.01144997f, 0.06623821f, 0.01517551f, 0.05704377f, -0.04114044f, 0.07546614f, -0.10021456f, 
    0.09870994f, -0.01591149f, 0.06239619f, -0.09529141f, 0.23794435f, -0.12641607f, -0.01471309f, 0.05737513f, 
    0.08944792f, -0.08932443f, 0.01687927f, 0.10879888f, -0.02104882f, -0.04375971f, -0.06916922f, 0.03121766f, 
    0.04091877f, 0.10654983f, -0.00321294f, 0.11678593f, -0.06589004f, -0.01002797f, 0.24529399f, 0.04509453f, 
    -0.03952761f, 0.04857535f, 0.01781525f, 0.02853344f, 0.01987011f, 0.04702228f, -0.04350254f, 0.07552468f, 
    0.03602421f, 0.01079414f, -0.06990039f, 0.07886017f, -0.08429687f, -0.01507929f, -0.05821587f, -0.08646525f, 
    0.40519607f, 0.25946176f, 0.12305187f, -0.15193854f, -0.11478379f, 0.14447515f, 0.07570945f, -0.11883149f, 
    0.08265001f, -0.09256453f, 0.03013731f, 0.00957938f, -0.09601157f, 0.02524470f, 0.03884885f, 0.04546443f, 
    0.09186528f, -0.02377313f, 0.07760303f, 0.01478629f, 0.03338071f, -0.08802415f, -0.00818692f, 0.12071948f, 
    -0.02422023f, -0.08879872f, -0.02491950f, -0.04819692f, -0.03139583f, -0.01736857f, 0.03744231f, -0.03831954f, 
    0.06484067f, 0.02509358f, -0.00667985f, 0.02534047f, -0.03029174f, 0.03210308f, 0.07667250f, -0.00434006f, 
    -0.16975795f, 0.01214673f, 0.01508076f, 0.06807087f, -0.36966792f, 0.04028410f, 0.00722799f, 0.05245122f, 
    0.04065138f, -0.00515368f, -0.03217209f, -0.00020255f, -0.09397169f, -0.03134599f, 0.02203988f, -0.03989474f, 
    0.00434475f, 0.04893896f, -0.04507706f, 0.00899237f, -0.24249175f, 0.10480028f, 0.20162968f, 0.08860899f, 
    -0.23755385f, 0.04095015f, 0.02055335f, 0.07939184f, 0.02339067f, -0.07864288f, -0.11876908f, -0.00618223f, 
    -0.02033299f, -0.08468626f, 0.02284263f, 0.01915694f, 0.04736745f, 0.02435408f, -0.01892347f, -0.01473247f, 
    -0.28072950f, -0.35014960f, -0.07786611f, 0.04597732f, -0.00358036f, -0.00649034f, -0.09009462f, -0.05147760f, 
    0.01228839f, -0.01760201f, 0.06618807f, -0.01992361f, -0.12323972f, -0.01895501f, -0.02821715f, 0.05642844f, 
    -0.02572688f, 0.04252140f, -0.03056507f, -0.01874709f, 0.08751315f, 0.03499794f, -0.00998504f, -0.15069750f, 
    0.13016888f, 0.02449645f, -0.03210602f, 0.01522161f, -0.04872881f, -0.03138478f, -0.01122763f, -0.06776591f, 
    0.06042787f, 0.03467071f, 0.04565203f, -0.12033579f, -0.00887253f, 0.12415954f, -0.04715283f, -0.08733577f, 
    0.31999630f, -0.02708243f, -0.10656983f, 0.10202494f, -0.27610049f, -0.12573215f, -0.06591132f, 0.01132814f, 
    0.06179587f, -0.02981083f, -0.05401922f, 0.02737635f, -0.09914491f, 0.04868711f, -0.03911873f, -0.11545943f, 
    -0.11099447f, 0.11346371f, 0.06464928f, 0.10036403f, -0.00887148f, 0.06052665f, 0.02127394f, -0.06699248f, 
    -0.24632077f, 0.03309083f, -0.00013932f, 0.02061629f, -0.00346464f, -0.06962333f, 0.02397829f, -0.03365918f, 
    0.02230352f, 0.04306329f, 0.00316608f, 0.03097098f, -0.00854416f, 0.06287830f, 0.00378623f, 0.00413380f, 
    -0.06726374f, 0.10553253f, -0.09010450f, -0.16663200f, -0.22610819f, -0.02191614f, 0.06090535f, -0.00358030f, 
    0.00621275f, 0.05563501f, 0.00847952f, 0.00440157f, 0.06826162f, -0.01790629f, -0.03868236f, 0.03634160f, 
    0.02238841f, 0.04676645f, -0.04193864f, 0.01032577f, -0.09381336f, 0.02431667f, 0.06993942f, -0.14288439f, 
    0.07858244f, -0.09029891f, -0.09789825f, 0.00484770f, -0.16097011f, 0.04829561f, 0.03685489f, 0.04586873f, 
    -0.06504905f, 0.10121014f, -0.03571332f, 0.04002433f, 0.02318456f, 0.07817955f, -0.12833236f, -0.15141776f, 
    0.21589839f, -0.14933623f, 0.05541825f, 0.11952230f, -0.28022078f, -0.00722359f, -0.00318196f, 0.04795467f, 
    0.04015308f, -0.03255107f, -0.12685388f, 0.03455518f, -0.01133584f, 0.03638595f, 0.06741049f, -0.02984089f, 
    -0.02344060f, -0.00499047f, -0.01030389f, -0.02511881f, -0.27923000f, -0.11773675f, 0.00518366f, 0.08698767f, 
    0.00486274f, 0.00168736f, -0.02987656f, -0.04208424f, -0.01287308f, 0.02180500f, -0.00574098f, -0.04604195f, 
    -0.00439933f, -0.06803802f, -0.05762769f, 0.02730821f, -0.01381354f, -0.05348362f, -0.02462039f, -0.08380364f, 
    0.26508510f, 0.07346109f, 0.00576198f, -0.07416712f, -0.09679939f, 0.07600583f, -0.05978843f, 0.05287301f, 
    -0.03147719f, -0.01296483f, -0.02111209f, -0.07837990f, -0.07413829f, -0.00414737f, 0.01522995f, -0.05260065f, 
    0.02003822f, -0.04289070f, 0.01126000f, 0.03375796f, 0.04039175f, 0.06582893f, 0.11777844f, -0.02759427f, 
    0.26330590f, -0.03534165f, 0.02408994f, -0.05801087f, 0.00114486f, 0.02890831f, -0.01540896f, 0.01479673f, 
    0.00568537f, -0.04564127f, 0.02395771f, -0.01305609f, 0.03729873f, 0.00630679f, 0.09865257f, -0.07090053f, 
    0.22688113f, 0.29811555f, 0.02775569f, -0.26287276f, -0.03126039f, 0.10311044f, 0.04149196f, -0.09037761f, 
    0.07714120f, -0.09505313f, 0.00643210f, -0.02878304f, -0.09259322f, -0.01383968f, 0.03274183f, 0.00527270f, 
    0.04442286f, 0.00601986f, 0.08908010f, 0.01445607f, 0.03776155f, 0.02393421f, 0.07138398f, -0.17754473f, 
    0.01664410f, -0.05255528f, -0.08773430f, -0.06171443f, 0.06129078f, -0.03962360f, 0.00549148f, -0.02218717f, 
    0.00821772f, -0.01744055f, -0.10084844f, -0.01034349f, -0.03152497f, 0.00364676f, 0.09172992f, -0.03894835f, 
    -0.03371688f, 0.05108437f, 0.01665087f, -0.01606792f, -0.09329665f, 0.04789322f, 0.06318138f, -0.09829780f, 
    0.02289757f, -0.08197352f, 0.09894437f, 0.02484722f, -0.00397748f, 0.05212995f, 0.01494909f, -0.00223351f, 
    -0.03455420f, 0.01493694f, 0.11364130f, -0.00539246f, -0.13688703f, -0.01517974f, -0.12786004f, -0.08715910f, 
    -0.13482338f, -0.00754006f, -0.01259929f, 0.03166203f, -0.00632820f, -0.02254098f, -0.00291411f, -0.04119543f, 
    0.04420703f, -0.02361525f, 0.02760421f, -0.03037930f, -0.05072180f, 0.00906277f, -0.02783135f, 0.03602809f, 
    -0.20157224f, 0.10796060f, 0.11609850f, 0.10629810f, 0.18532957f, -0.12571792f, -0.14653876f, 0.09413568f, 
    -0.05205835f, -0.00163931f, 0.03692761f, -0.03867526f, 0.01272367f, -0.03480110f, -0.00765036f, 0.05414673f, 
    0.00344075f, -0.18296804f, 0.01330442f, 0.02529805f, -0.06601691f, -0.02898389f, -0.07621042f, -0.09131457f, 
    -0.00672371f, 0.04512329f, -0.04197473f, -0.06245104f, -0.10086499f, -0.00094828f, 0.02231424f, -0.04129758f, 
    0.02477551f, -0.00038463f, -0.01857066f, -0.00485961f, -0.03888461f, -0.00124842f, -0.08888210f, 0.05361468f, 
    0.28367209f, 0.03262459f, 0.04165827f, -0.13012311f, -0.01749811f, 0.03724809f, 0.00025293f, 0.00274333f, 
    0.01626019f, 0.02051491f, 0.02432542f, -0.01763112f, -0.08138412f, -0.01005491f, 0.04513679f, -0.03203092f, 
    -0.04159740f, 0.05962428f, -0.01179936f, -0.01832549f, -0.07053228f, 0.09691751f, -0.06393339f, 0.00026158f, 
    0.10416707f, -0.01097851f, -0.11637064f, -0.01856149f, 0.00411215f, -0.05348686f, 0.02507073f, -0.04604425f, 
    -0.06323083f, 0.03572012f, -0.08140860f, -0.03360188f, 0.04415011f, -0.03026050f, -0.07935520f, 0.04695369f, 
    0.16043544f, -0.46332201f, 0.19470303f, 0.07343689f, 0.07462050f, 0.00896540f, 0.11745252f, 0.03833789f, 
    0.07715394f, -0.02825778f, -0.12326723f, 0.04683312f, -0.03390672f, 0.07678524f, -0.03263317f, 0.07747922f, 
    0.01168381f, 0.04500460f, -0.12203749f, -0.00603504f, 0.00538861f, 0.08095031f, -0.05907692f, -0.02975866f, 
    0.07022902f, -0.03900559f, -0.02233307f, -0.04664777f, 0.00848299f, -0.04224188f, 0.00253754f, 0.01604583f, 
    -0.00982189f, -0.03516750f, -0.02741563f, -0.04725259f, 0.02803291f, 0.05460643f, -0.01475612f, -0.02687356f, 
    0.11785776f, -0.06944117f, 0.13624452f, 0.06105402f, 0.08395863f, -0.03864870f, -0.05011653f, 0.04936715f, 
    -0.04139987f, 0.01230052f, 0.01471166f, -0.10603372f, 0.11222858f, 0.03124760f, 0.04960975f, 0.00298936f, 
    -0.04214375f, -0.05627349f, 0.04457023f, 0.04451510f, -0.07054041f, 0.03915579f, 0.07994088f, -0.22136636f, 
    0.17312111f, -0.14502379f, -0.03037874f, -0.01296615f, 0.06191001f, 0.10817239f, 0.02784656f, 0.00911405f, 
    0.11606338f, 0.04141567f, -0.00152034f, 0.05453686f, -0.14961253f, 0.07290433f, -0.12560040f, -0.06509526f, 
    -0.01852008f, -0.01070318f, -0.07891752f, -0.04846148f, 0.10868007f, -0.10647865f, -0.05184706f, 0.00022127f, 
    -0.03111505f, -0.01254753f, 0.02889108f, 0.12269162f, 0.06241524f, 0.01552009f, 0.03197837f, 0.11537550f, 
    0.04162796f, 0.03321471f, 0.03384799f, 0.02455392f, 0.14130569f, 0.04460596f, 0.17611873f, -0.10899244f, 
    0.05545488f, -0.00266077f, -0.04811217f, 0.08155577f, -0.00190611f, -0.05100190f, 0.00558944f, -0.03304293f, 
    0.00045992f, -0.00766000f, -0.02164985f, 0.03584362f, 0.02347718f, -0.03376936f, 0.04294514f, -0.02672285f, 
    -0.18328086f, -0.11456645f, -0.19458400f, 0.13079162f, 0.04834436f, 0.03718420f, 0.06582837f, -0.04104589f, 
    0.18189254f, 0.05558131f, 0.02572034f, 0.07299708f, -0.10179620f, -0.07910340f, -0.01281914f, 0.01869451f, 
    0.03612484f, 0.04127530f, 0.04402220f, -0.04573657f, 0.00755242f, -0.21511537f, 0.13037267f, 0.16848256f, 
    0.13373603f, 0.03308055f, 0.00701169f, -0.05079044f, 0.04761761f, 0.07726512f, 0.00280456f, 0.03059869f, 
    0.04493003f, 0.02088082f, -0.00107528f, -0.03529041f, 0.00050936f, -0.08220344f, 0.01646016f, -0.12367954f, 
    0.02388110f, 0.07263008f, 0.09956042f, -0.04543930f, 0.21239361f, -0.03662605f, 0.01182459f, -0.10378373f, 
    0.03361503f, -0.02696952f, -0.01735705f, 0.05317021f, 0.02471010f, -0.04751656f, 0.03556856f, 0.00676061f, 
    0.03273538f, -0.12094698f, -0.07055436f, -0.00078308f, -0.14621517f, -0.05715084f, 0.00007487f, 0.00027652f, 
    -0.25246584f, 0.02423782f, -0.01488829f, -0.01510168f, 0.05511627f, -0.01859261f, -0.01029043f, -0.05601041f, 
    -0.03801470f, -0.00747084f, -0.00574696f, -0.03957861f, -0.05231363f, -0.08145431f, 0.06641023f, -0.02677446f, 
    0.37656513f, -0.26425597f, 0.04375412f, 0.06778458f, 0.00514585f, -0.01784050f, -0.07990481f, 0.07256276f, 
    -0.05545444f, -0.03119268f, 0.05530353f, 0.02804344f, -0.00811529f, 0.06116052f, -0.03166948f, -0.04141614f, 
    -0.01963603f, 0.06102134f, -0.11182704f, -0.12741603f, 0.09730133f, 0.10578772f, 0.15356737f, 0.05566849f, 
    0.15765174f, 0.00529104f, -0.00511700f, 0.02175029f, 0.03254580f, -0.00771019f, 0.00233587f, -0.03598575f, 
    -0.00409789f, -0.02248238f, 0.02193330f, 0.09247123f, 0.00598858f, -0.11102339f, 0.05800957f, 0.06614248f, 
    -0.21350741f, -0.23101327f, -0.00110251f, 0.05474580f, -0.24176823f, -0.02790537f, 0.02402413f, 0.02972854f, 
    -0.11313578f, -0.08864446f, 0.00114365f, -0.01678992f, 0.03151430f, -0.06878654f, -0.03091204f, -0.05003473f, 
    -0.14406148f, 0.09484357f, -0.00460319f, -0.05441228f, -0.22605374f, 0.00621035f, -0.07752136f, 0.13605665f, 
    -0.00435809f, 0.00762670f, -0.07860064f, -0.03222682f, -0.03345650f, -0.06542224f, -0.00897316f, -0.11635363f, 
    0.10359430f, 0.02123384f, 0.01169475f, -0.10233852f, 0.00972854f, 0.00357674f, -0.01733247f, -0.03161318f, 
    0.06752592f, -0.09126329f, -0.17948180f, 0.10413557f, -0.05804392f, -0.01921352f, -0.01074246f, -0.02412525f, 
    0.00526543f, 0.01087203f, 0.03811425f, -0.02303263f, -0.00906370f, -0.01512590f, 0.03558043f, -0.00575410f, 
    0.00019616f, 0.05192135f, 0.00184377f, 0.02558280f, -0.16505095f, 0.00191972f, 0.05446706f, -0.05272773f, 
    -0.19312380f, 0.06450890f, -0.04160008f, 0.02967993f, 0.02138204f, -0.00186880f, -0.05593894f, -0.02234202f, 
    0.00344114f, -0.03232174f, 0.03633871f, 0.00267974f, 0.00813781f, -0.00196025f, 0.01229466f, -0.00852203f, 
    0.19885018f, 0.04545207f, -0.04298965f, -0.11384828f, 0.14424033f, -0.13459319f, -0.04455712f, -0.18114740f, 
    0.01883896f, 0.00125492f, -0.07621592f, -0.05357355f, 0.07187025f, 0.00130016f, 0.02044237f, 0.07641810f, 
    0.01943067f, -0.09600016f, 0.08779267f, 0.03918104f, 0.10299353f, 0.04497153f, -0.03501131f, -0.04244985f, 
    0.02970319f, -0.19460975f, -0.15429731f, 0.02366247f, -0.02387464f, -0.01224606f, 0.02451281f, -0.03206403f, 
    -0.04082616f, -0.08963588f, 0.01063164f, -0.05814787f, -0.02862923f, -0.05488541f, -0.01488717f, 0.03970854f, 
    0.05720762f, 0.06937612f, 0.19846633f, 0.12254723f, 0.24805108f, -0.07969226f, -0.11594571f, 0.01430164f, 
    -0.00744032f, -0.03589638f, -0.01244117f, -0.00414539f, 0.02007917f, 0.07990539f, -0.05262046f, -0.09685080f, 
    0.10930727f, -0.03836899f, 0.05938522f, 0.05122210f, 0.41054851f, -0.29198548f, -0.07572183f, -0.01653244f, 
    -0.05174913f, -0.01948220f, -0.02575712f, -0.03515276f, 0.05844183f, 0.01787257f, -0.00927328f, 0.02201283f, 
    0.00096047f, -0.02040562f, 0.04586088f, 0.03735089f, 0.01289705f, -0.05028660f, -0.02094890f, 0.03801430f, 
    0.19209622f, -0.32642075f, -0.05289867f, 0.05569494f, -0.00187467f, 0.03127108f, 0.02321169f, -0.00008669f, 
    0.09315305f, 0.05141817f, -0.04691667f, 0.02607608f, 0.05124363f, 0.02272628f, 0.06850538f, 0.12595725f, 
    -0.02417844f, 0.06122908f, -0.06137058f, -0.01763188f, -0.35351148f, -0.23009858f, -0.07720855f, -0.00966220f, 
    -0.22674209f, 0.14219804f, 0.02645912f, 0.00507456f, 0.03933053f, -0.05820348f, 0.01418720f, 0.04950141f, 
    0.01601399f, 0.01543886f, 0.03750760f, -0.05341106f, -0.07209585f, -0.08338315f, 0.02721198f, -0.12614146f, 
    0.24109083f, -0.02085944f, -0.01449925f, -0.00801926f, 0.05176214f, -0.15844940f, -0.03834171f, -0.01899143f, 
    0.05564114f, -0.06384122f, 0.06051449f, -0.01238160f, -0.06529922f, 0.11881059f, -0.07203710f, 0.06453703f, 
    -0.04111840f, 0.05643174f, -0.03757070f, 0.09696144f, 0.10399164f, 0.15688872f, -0.13605443f, -0.04064848f, 
    0.01566736f, 0.04736384f, 0.05685053f, 0.05593831f, 0.01794186f, 0.01239259f, 0.00014235f, -0.06243258f, 
    -0.07416459f, 0.03676580f, -0.08799443f, 0.06248143f, -0.01427299f, 0.03008104f, -0.07058985f, -0.03959297f, 
    -0.01045748f, -0.05657001f, -0.17173375f, -0.26261017f, 0.03466621f, 0.11772337f, 0.02015588f, -0.02771380f, 
    -0.02889596f, -0.01189866f, 0.03274801f, 0.05218197f, -0.00575204f, -0.06526572f, 0.08079659f, -0.07169750f, 
    0.01123570f, 0.01524103f, 0.09491894f, -0.10426731f, -0.08559091f, -0.00691679f, -0.23140799f, -0.31757823f, 
    0.01730517f, 0.03414051f, 0.05901209f, 0.02291581f, 0.00528156f, 0.16954494f, 0.08870106f, -0.03607576f, 
    0.07549040f, 0.03844660f, -0.01843300f, -0.04677214f, 0.01728866f, 0.00000289f, -0.07718022f, 0.02047230f, 
    0.24250871f, -0.06596798f, -0.05248579f, 0.06115822f, -0.15505025f, -0.08992775f, -0.00278066f, -0.04829405f, 
    0.05526765f, 0.05788079f, 0.03228123f, -0.05966690f, -0.00180568f, -0.03700126f, 0.05021967f, 0.05163056f, 
    -0.03714331f, -0.00580540f, -0.12514262f, 0.05957065f, 0.12091400f, -0.22901964f, 0.07522493f, 0.00661752f, 
    0.02845180f, 0.01519858f, 0.09843487f, -0.04428310f, 0.02858036f, 0.07790566f, 0.19949648f, 0.11083047f, 
    0.01900991f, -0.01144652f, -0.07373978f, -0.01431527f, -0.04362462f, -0.06492701f, 0.06234122f, -0.00414639f, 
    0.03400555f, 0.24814297f, 0.10165184f, 0.10012005f, 0.08420074f, 0.01188589f, -0.09004276f, 0.01193662f, 
    0.00469397f, 0.05072192f, 0.07039957f, 0.05383070f, -0.05407718f, 0.02769563f, -0.03916208f, -0.01569143f, 
    -0.02753887f, 0.07826608f, 0.11347889f, 0.06656002f, -0.33318457f, 0.00084181f, -0.20570964f, -0.31881717f, 
    -0.00433534f, -0.04688715f, 0.18489325f, -0.01048481f, 0.07942052f, -0.04478643f, -0.03052019f, -0.00728294f, 
    0.03725056f, -0.14582509f, -0.10660762f, 0.03249150f, -0.09388738f, 0.05047801f, -0.08309054f, -0.06157577f, 
    0.03833180f, 0.15508161f, 0.03013557f, 0.09760311f, 0.12165026f, 0.00357489f, -0.02280742f, 0.09074427f, 
    0.03019170f, 0.00738482f, -0.05650257f, -0.03606346f, -0.02854422f, 0.08300417f, -0.05689546f, 0.03025134f, 
    0.01565071f, 0.01509530f, -0.05003801f, -0.06023797f, -0.16529712f, 0.03447812f, -0.21363175f, -0.08246332f, 
    0.07090821f, 0.10403660f, -0.00508735f, 0.03592052f, -0.01456658f, 0.12950432f, 0.10341325f, -0.03649874f, 
    -0.02306117f, -0.02523503f, -0.04986696f, 0.00148802f, -0.00195550f, -0.04428786f, -0.07296404f, 0.02455891f, 
    0.09829912f, 0.10949121f, 0.08749660f, -0.01483763f, -0.17606682f, -0.06985968f, -0.11456839f, 0.06145592f, 
    0.03774087f, -0.05292033f, 0.01909641f, -0.03714692f, 0.00201522f, 0.08270720f, -0.00458047f, -0.06486523f, 
    -0.02836909f, -0.09426615f, 0.00348564f, -0.06142805f, 0.21086352f, -0.00212311f, 0.02572958f, 0.02010372f, 
    0.01710409f, -0.07398497f, -0.03569922f, 0.01942828f, 0.01017733f, -0.00631640f, 0.11912439f, -0.04877936f, 
    0.06240525f, -0.07023194f, 0.04701679f, -0.06988952f, 0.04448417f, -0.12324832f, -0.01214118f, 0.00993784f, 
    -0.08184414f, -0.09399263f, -0.23503958f, -0.15818806f, 0.03139068f, -0.01494547f, -0.04514499f, -0.04274055f, 
    -0.04206458f, 0.01513785f, 0.03803207f, -0.04332143f, 0.07575624f, -0.01467249f, 0.14110872f, -0.00234313f, 
    0.01039594f, -0.02025781f, 0.07096101f, -0.00059834f, 0.10840052f, -0.14711650f, 0.03679503f, -0.01275933f, 
    -0.03251912f, -0.05466247f, -0.00957374f, 0.10781195f, 0.04258696f, 0.11023462f, -0.03543748f, -0.06550826f, 
    0.05772112f, 0.01298881f, 0.05514262f, 0.06643104f, 0.02738227f, 0.06678513f, -0.02908344f, -0.10041337f, 
    -0.20766120f, 0.04399051f, -0.13110137f, 0.03268340f, 0.15396339f, -0.07339416f, -0.01223152f, -0.01422780f, 
    -0.04441288f, 0.03625844f, 0.11436850f, -0.08208955f, 0.06093679f, -0.03764566f, -0.08815411f, -0.09610874f, 
    0.07330707f, -0.01349655f, -0.14333326f, 0.09545794f, 0.06245847f, 0.05875207f, -0.02826601f, 0.00569690f, 
    -0.08621490f, 0.08567473f, 0.03944913f, 0.02694086f, 0.10525425f, 0.01366655f, -0.02812308f, -0.04712532f, 
    0.08191095f, 0.04238473f, -0.08774239f, 0.04518182f, 0.07798709f, -0.13105932f, -0.02485213f, -0.06801752f, 
    0.04577773f, -0.28927514f, 0.07719311f, -0.11640204f, 0.09051874f, -0.16404526f, -0.05536491f, -0.02041608f, 
    -0.02924847f, 0.10172670f, 0.11013055f, 0.02343371f, -0.00111854f, 0.06331446f, -0.11083224f, 0.06680660f, 
    -0.06283675f, -0.04717940f, -0.00320556f, -0.10234567f, -0.16781916f, 0.11817125f, -0.25980139f, 0.00762879f, 
    -0.07428698f, 0.04761023f, 0.00008877f, -0.06253424f, -0.05348984f, 0.00313296f, 0.09165607f, 0.01291228f, 
    -0.05606421f, -0.06167558f, 0.02985042f, 0.05675188f, 0.05127884f, -0.02925011f, -0.01228923f, 0.06594510f, 
    0.17719677f, -0.09494285f, 0.15718362f, -0.01031550f, 0.05690612f, -0.08560353f, -0.01218033f, -0.09436949f, 
    -0.04371662f, -0.01792780f, -0.10263040f, -0.04001037f, -0.10860752f, 0.04689320f, 0.02401292f, -0.08037111f, 
    0.00589455f, -0.04576474f, 0.06545633f, 0.00888411f, -0.32238093f, 0.09380495f, -0.13192999f, -0.07874002f, 
    0.13181855f, -0.10256466f, 0.04069127f, 0.04849267f, -0.08959032f, 0.16857928f, -0.01582258f, -0.00590379f, 
    0.02613572f, -0.12313297f, -0.12341762f, -0.13230468f, 0.00229023f, 0.09719802f, -0.00121690f, 0.12957238f, 
    -0.16877389f, 0.00236244f, -0.14026117f, -0.00957705f, -0.01452597f, 0.02000277f, 0.06168794f, -0.04620458f, 
    -0.04117033f, 0.04429233f, 0.08444223f, 0.02083238f, -0.01691060f, -0.10388438f, 0.09796791f, 0.03727056f, 
    -0.05979970f, 0.00567162f, 0.02625842f, 0.01592534f, -0.11265710f, -0.14361173f, -0.03122728f, -0.02476887f, 
    -0.13205299f, 0.06616584f, -0.04404918f, 0.02886603f, 0.04873949f, -0.06172945f, -0.00975172f, 0.00806647f, 
    0.04932337f, 0.04436831f, -0.03995440f, 0.00407091f, -0.01502438f, -0.08778952f, -0.05791240f, -0.03773467f, 
    0.12637833f, 0.04181975f, -0.01123227f, 0.08929751f, -0.43736702f, 0.03068335f, 0.03447517f, 0.01503543f, 
    0.00695293f, 0.02958716f, 0.03266129f, 0.00992356f, -0.01964795f, 0.03494211f, 0.05700325f, -0.03113586f, 
    0.07124734f, -0.01853469f, 0.00242209f, 0.01304433f, 0.06350593f, 0.06877282f, -0.12561291f, 0.03174370f, 
    -0.23068774f, -0.06558420f, -0.00065832f, 0.03740437f, -0.07362499f, 0.09532619f, -0.02914543f, -0.01886024f, 
    -0.02143608f, 0.06120503f, 0.01473809f, 0.03222250f, 0.03909428f, 0.02241335f, 0.01793600f, 0.05413371f, 
    0.07477119f, -0.00756089f, -0.00858974f, -0.00723979f, -0.13052124f, 0.09531203f, 0.04662593f, 0.06169151f, 
    0.03148631f, 0.06568207f, -0.03365076f, -0.05323656f, 0.04683875f, 0.06061258f, 0.08220045f, 0.02487907f, 
    0.02586832f, -0.13691244f, -0.13437128f, -0.18623406f, 0.02673109f, 0.14196260f, -0.08224149f, -0.15335514f, 
    0.06805928f, -0.00059936f, 0.06975300f, 0.01207235f, -0.00062008f, -0.03245248f, -0.01539407f, -0.07526340f, 
    -0.00732422f, 0.04362794f, 0.02470904f, -0.00692068f, 0.03043969f, 0.02243113f, -0.02360722f, 0.08809967f, 
    -0.09064104f, -0.07189850f, 0.03548751f, -0.06258168f, -0.08309962f, 0.10198101f, -0.05742929f, 0.01143988f, 
    0.01731325f, -0.04068098f, 0.11890923f, 0.04902546f, 0.08210406f, -0.06317394f, -0.02998001f, 0.02527720f, 
    -0.03422495f, -0.01630088f, -0.02532417f, -0.08064459f, 0.17220022f, -0.02070791f, -0.11555038f, -0.01040656f, 
    -0.18955965f, 0.05837023f, -0.03223887f, -0.01735727f, -0.00358531f, 0.08806176f, 0.02238925f, 0.06243813f, 
    -0.05007629f, -0.04444839f, 0.04265882f, 0.00365887f, 0.03510344f, -0.04770742f, -0.01364877f, -0.05628624f, 
    0.14994241f, -0.15482368f, -0.00019475f, -0.04344730f, -0.10908218f, 0.02918506f, -0.00995340f, -0.04062161f, 
    -0.02387807f, 0.00640151f, 0.05719152f, 0.01691939f, -0.01263919f, 0.02481992f, -0.03808848f, 0.08332501f, 
    -0.02610175f, -0.02301127f, -0.06472461f, 0.09977499f, -0.10999148f, -0.27313495f, 0.01850034f, -0.17073444f, 
    0.28123453f, 0.04854102f, -0.04663831f, 0.01193365f, -0.04478924f, -0.01752446f, -0.01014985f, 0.03447249f, 
    0.03641055f, -0.04257208f, -0.05934317f, -0.03310186f, -0.02584332f, -0.13830854f, 0.06435116f, 0.03600896f, 
    0.15206008f, -0.02279511f, 0.01977571f, 0.06933341f, 0.00748789f, 0.00583034f, 0.03273812f, -0.00998359f, 
    -0.00968209f, -0.01263139f, -0.03434606f, -0.08057274f, 0.01378815f, -0.03454463f, 0.03878037f, -0.02402708f, 
    -0.00429916f, -0.12274890f, -0.06600086f, 0.17274690f, -0.11313334f, -0.06182162f, -0.11662666f, -0.06905524f, 
    -0.08692555f, 0.08161058f, -0.03126951f, 0.01532422f, 0.02533763f, 0.03778587f, -0.00296243f, 0.04340986f, 
    0.00945548f, 0.03961020f, -0.06266615f, -0.06464493f, 0.04173521f, 0.04623882f, -0.02619656f, 0.00850109f, 
    -0.22364210f, -0.00203622f, -0.01902982f, -0.06689921f, 0.10121612f, 0.01185112f, -0.02078376f, -0.08257780f, 
    -0.04389791f, 0.05996739f, 0.04647986f, 0.05080974f, -0.03485736f, 0.02576111f, -0.08316421f, 0.07487069f, 
    -0.01229893f, -0.00251067f, -0.02751255f, -0.00504516f, 0.23606281f, -0.15201041f, -0.04620443f, -0.10716037f, 
    -0.12614171f, -0.03540731f, -0.14563502f, 0.03413361f, 0.00875968f, -0.01911818f, 0.05151428f, 0.03981836f, 
    0.04872486f, 0.09967847f, -0.02583950f, -0.00889874f, -0.07174373f, -0.15318911f, -0.07542890f, -0.03937386f, 
    -0.10819134f, 0.07160726f, -0.11996640f, -0.15238526f, -0.04140601f, 0.05932869f, 0.09680896f, -0.06858540f, 
    -0.04222007f, 0.01821858f, 0.04265150f, -0.04303306f, 0.01371437f, -0.03073028f, 0.05643512f, 0.01970496f, 
    0.01105362f, 0.06107457f, -0.05917088f, 0.01728266f, 0.01170372f, 0.01492214f, 0.00045720f, 0.05562649f, 
    0.08485306f, -0.03195996f, -0.06722408f, 0.04872525f, -0.04256174f, -0.00995847f, 0.02316365f, -0.01177851f, 
    0.02436256f, 0.03458008f, 0.06883647f, 0.00712937f, 0.07366570f, -0.09611553f, -0.08223613f, 0.00228241f, 
    -0.01829904f, 0.23717166f, -0.02182343f, 0.01985673f, -0.04392677f, 0.00742035f, -0.01136571f, 0.04454001f, 
    -0.02003357f, 0.02107221f, -0.10625584f, -0.04971160f, -0.09883276f, -0.03826672f, 0.05345406f, 0.09950563f, 
    0.04794468f, -0.00031325f, 0.08651335f, 0.05192465f, 0.03925498f, -0.11099528f, -0.01660361f, -0.00512988f, 
    -0.04782933f, 0.01585377f, 0.04622774f, 0.04988493f, 0.05101664f, 0.11344203f, -0.03956068f, -0.10936993f, 
    0.05133263f, 0.01515395f, -0.00198125f, 0.07477349f, 0.06997123f, 0.03505741f, -0.06595396f, -0.01318324f, 
    0.14905684f, 0.13366517f, 0.00130698f, 0.05217294f, 0.18541244f, 0.01515507f, 0.03934452f, 0.03775557f, 
    -0.03177892f, 0.07736808f, 0.00166026f, 0.07687814f, 0.03267720f, 0.03338634f, 0.02195085f, 0.04965699f, 
    0.02889266f, 0.12158395f, -0.02424113f, -0.01161722f, -0.11400456f, 0.12114290f, 0.11425176f, 0.00830389f, 
    0.02810670f, -0.09848931f, -0.09786678f, -0.01300678f, 0.00314364f, 0.01347023f, -0.05048675f, 0.05568625f, 
    0.05981060f, -0.04199820f, -0.01694508f, 0.02534600f, 0.01525365f, -0.02049318f, 0.04209340f, -0.01386052f, 
    -0.21743032f, 0.10063265f, -0.08171008f, -0.11573052f, 0.05381677f, -0.00608172f, 0.05875657f, -0.00417704f, 
    -0.02342600f, 0.04161591f, -0.00620211f, -0.02548267f, 0.10154210f, -0.01996184f, 0.02425691f, 0.02564428f, 
    -0.00763367f, 0.04013239f, 0.01389044f, -0.06493328f, 0.23526715f, 0.17487225f, 0.00259277f, 0.06803596f, 
    0.20784082f, -0.10437062f, -0.01004972f, 0.06802432f, 0.00966873f, 0.05572322f, -0.00285479f, 0.00975596f, 
    0.03962233f, 0.01305481f, 0.03928487f, 0.06129658f, -0.00839559f, 0.05183078f, -0.03544815f, 0.01601371f, 
    -0.04992107f, -0.20711021f, 0.07184584f, -0.19008374f, 0.03994809f, -0.07944649f, -0.09456604f, 0.03540315f, 
    -0.05817898f, -0.05105310f, 0.00826986f, -0.06540475f, 0.04523898f, -0.02676702f, -0.04871677f, -0.10818040f, 
    -0.00165341f, -0.24687973f, 0.09780424f, -0.16333401f, 0.10182825f, 0.12101456f, 0.04800003f, 0.03866280f, 
    0.08346466f, -0.06370903f, -0.05482560f, 0.01276541f, 0.00621708f, -0.01674274f, 0.05099769f, 0.01401927f, 
    0.03559342f, 0.02336552f, -0.00444359f, 0.04092601f, 0.10188867f, -0.00611715f, -0.08006234f, -0.01598650f, 
    -0.13704556f, 0.25291556f, -0.01502140f, 0.02357102f, 0.03667713f, -0.01526696f, 0.08923946f, 0.01526762f, 
    -0.03546022f, -0.00477547f, -0.10556576f, 0.03495179f, 0.05492932f, -0.03854812f, -0.01661866f, 0.12668297f, 
    -0.06944735f, 0.06546256f, 0.02931502f, -0.00626927f, 0.26594934f, -0.11121845f, 0.02235387f, -0.26873186f, 
    0.03789767f, 0.00553238f, -0.03779995f, -0.06358620f, 0.01639973f, -0.03988774f, -0.08661316f, 0.01977632f, 
    -0.04025255f, -0.07479034f, 0.22101843f, -0.17963855f, 0.02065467f, -0.01747174f, -0.04351435f, 0.00875279f, 
    0.20935941f, -0.34887913f, 0.13998450f, -0.02205272f, -0.05130308f, 0.04597184f, -0.05494257f, -0.07137728f, 
    0.04624894f, 0.02513604f, -0.11647212f, -0.07218061f, -0.08776071f, -0.00775648f, -0.01571175f, 0.06186286f, 
    -0.03097555f, -0.11274544f, -0.02468434f, 0.01536960f, -0.23428608f, 0.08993787f, 0.05272369f, -0.05196425f, 
    0.14872676f, -0.16445427f, 0.07682271f, -0.02068487f, -0.03340285f, 0.07738027f, -0.00650443f, 0.06635156f, 
    0.03567034f, -0.01130001f, 0.03187203f, 0.01509796f, -0.00810381f, 0.05175766f, -0.00585116f, -0.03464295f, 
    -0.23946282f, -0.08145586f, -0.03063965f, -0.19075836f, -0.26420942f, -0.00897141f, 0.04398971f, 0.01784715f, 
    -0.01169375f, 0.02160335f, -0.11146127f, -0.00666034f, 0.01944934f, 0.06025268f, 0.06872703f, -0.13017949f, 
    0.00436281f, -0.08379566f, -0.13525335f, 0.01223987f, 0.29173377f, -0.17439795f, -0.00592712f, -0.40884918f, 
    0.05847909f, -0.01763166f, -0.06319615f, 0.08581536f, -0.03528132f, 0.01858103f, -0.13658439f, -0.09276332f, 
    -0.03027704f, 0.00856027f, -0.08391391f, -0.14121933f, -0.03011348f, -0.03327956f, -0.02062203f, 0.09691253f, 
    0.00751021f, -0.20616463f, 0.12871771f, -0.09409677f, 0.09627604f, -0.07009471f, -0.07410088f, -0.08840188f, 
    0.12128530f, -0.03000932f, 0.04754668f, -0.01462335f, -0.05216104f, -0.01528253f, -0.01848520f, -0.05552353f, 
    -0.02593879f, 0.07496083f, 0.13981766f, -0.16096933f, 0.05057900f, 0.08840682f, -0.11148850f, 0.09606642f, 
    -0.23564133f, 0.00586466f, 0.06953844f, -0.04071238f, 0.06746743f, 0.00816792f, -0.06563400f, -0.04619316f, 
    -0.07516399f, 0.08540414f, 0.02107089f, 0.01033484f, 0.10850623f, 0.04446103f, -0.04069090f, -0.06156573f, 
    -0.33914354f, -0.03090867f, -0.18955831f, -0.29197907f, 0.15577446f, 0.13667412f, -0.09248454f, -0.01822438f, 
    -0.05164100f, -0.08850578f, 0.01382599f, -0.01544890f, -0.01660266f, -0.15812898f, 0.01444540f, -0.03109537f, 
    -0.06591909f, -0.08463226f, 0.04248857f, -0.06946465f, -0.09464000f, 0.06430895f, -0.05729982f, 0.00064638f, 
    0.11109065f, 0.02824197f, 0.08149671f, -0.01701605f, 0.01463108f, -0.05269637f, 0.01185455f, 0.06875504f, 
    0.09082311f, 0.03021732f, -0.00370119f, -0.01757903f, -0.06777926f, 0.09022228f, -0.01455874f, 0.00795822f, 
    -0.45271802f, 0.21137008f, 0.07840892f, -0.05655329f, -0.22674026f, -0.14125979f, 0.02885201f, -0.05635086f, 
    0.06356236f, 0.01138226f, 0.00328449f, -0.03734813f, 0.06184159f, 0.01818057f, 0.04073686f, -0.05383504f, 
    -0.01246905f, -0.11585012f, -0.02884690f, 0.14777756f, -0.18077832f, 0.03278988f, -0.01453783f, -0.06062365f, 
    -0.03261257f, 0.03416263f, -0.03220499f, -0.10256639f, 0.03387127f, -0.08894012f, 0.00240083f, -0.03904718f, 
    -0.07957803f, 0.03352498f, -0.01782058f, -0.00206506f, -0.12313597f, 0.03906115f, 0.00905252f, 0.05067044f, 
    -0.37762102f, 0.00397755f, -0.06375282f, -0.03063856f, -0.26473245f, 0.02757741f, 0.05388175f, 0.00454502f, 
    -0.00051074f, -0.00420197f, -0.07062788f, 0.00486016f, -0.01581514f, 0.01771894f, -0.04500224f, 0.02938595f, 
    -0.07392626f, -0.06162623f, -0.01043707f, -0.04272546f, 0.21103743f, 0.00021973f, -0.14650202f, 0.04579239f, 
    -0.14934558f, 0.01240981f, -0.01231419f, 0.05047043f, 0.01298745f, 0.06744106f, -0.01390363f, -0.03017417f, 
    0.00502353f, 0.05112097f, -0.00511591f, 0.05633713f, 0.04277014f, -0.01096138f, -0.04463638f, 0.04797356f, 
    0.11609684f, 0.11079444f, -0.05265452f, 0.18049884f, -0.01260353f, 0.04739536f, -0.09431732f, 0.04335888f, 
    0.01552651f, 0.02269352f, -0.01581663f, -0.00311338f, -0.18473020f, 0.14146034f, -0.15526247f, 0.10347656f, 
    -0.00793710f, 0.00597368f, -0.05155509f, -0.02303969f, 0.15887941f, 0.19741450f, 0.01802661f, 0.13852431f, 
    0.22919939f, 0.03967178f, -0.05214274f, 0.00265065f, 0.04674027f, -0.00391554f, 0.06114175f, 0.02872780f, 
    -0.06303404f, 0.04051789f, -0.11819721f, 0.06322350f, 0.04143067f, 0.08409839f, -0.06425684f, 0.05227611f, 
    0.07326888f, 0.01986718f, 0.08335896f, -0.07578705f, 0.01272023f, -0.03180258f, -0.05794458f, 0.11008643f, 
    -0.02528111f, -0.00317802f, -0.00018229f, -0.02112559f, 0.04849301f, 0.02034627f, -0.04238119f, 0.05537840f, 
    -0.08259228f, -0.04167832f, -0.06720182f, -0.06492240f, 0.10214228f, 0.03845249f, 0.08951126f, -0.06237283f, 
    -0.09041195f, -0.04732569f, -0.04740568f, 0.00035467f, -0.03596326f, -0.00056461f, -0.05575649f, -0.05097483f, 
    0.03193381f, 0.02401394f, 0.02482957f, 0.01007535f, -0.07809673f, 0.07532785f, 0.10495296f, 0.02088925f, 
    0.27872762f, -0.02900564f, 0.02495602f, -0.18662058f, -0.22361028f, -0.13045673f, 0.05084730f, 0.04154827f, 
    -0.08965744f, -0.00430586f, 0.02490715f, -0.04485531f, -0.02169259f, -0.10368367f, -0.07252319f, 0.02980560f, 
    0.05435982f, 0.09749752f, 0.03902534f, -0.01382726f, 0.16067009f, 0.00069267f, -0.18709452f, -0.09461704f, 
    -0.22960488f, -0.03994654f, 0.06487329f, -0.04506613f, 0.02627552f, -0.00686173f, -0.01481810f, -0.00569839f, 
    -0.01320315f, -0.01965117f, -0.07570434f, 0.04677937f, 0.05016271f, -0.01686984f, 0.06957625f, -0.06580320f, 
    0.10177742f, 0.11394334f, 0.08892456f, -0.03713299f, -0.10761609f, -0.03714082f, 0.03492668f, 0.05025845f, 
    -0.03865896f, 0.01674361f, -0.06958427f, -0.03859830f, 0.12886225f, 0.03068669f, -0.08166556f, -0.00564279f, 
    -0.11048806f, -0.09227701f, 0.05423579f, 0.00102614f, -0.03647541f, -0.02295281f, -0.18023376f, -0.04826197f, 
    0.01056150f, 0.03344698f, 0.03477465f, 0.04003046f, -0.04268665f, -0.05672182f, -0.02842324f, 0.01396531f, 
    -0.06422229f, -0.00083944f, 0.00470281f, -0.02745207f, 0.03324072f, 0.03811892f, -0.13412984f, -0.02020392f, 
    0.08151614f, 0.07576860f, -0.11741124f, -0.08078410f, -0.04295657f, 0.00287835f, 0.02620326f, 0.04046182f, 
    -0.00318834f, -0.02778360f, -0.05239350f, 0.03722043f, 0.04957878f, 0.04445242f, -0.05155635f, -0.00771298f, 
    0.02816319f, -0.02631737f, 0.03461708f, 0.07823246f, 0.07385997f, -0.07837008f, -0.22048225f, -0.26416329f, 
    -0.22264321f, -0.01802067f, 0.00099581f, -0.13908304f, -0.09694287f, -0.00096385f, -0.06450669f, -0.01303575f, 
    0.01646188f, -0.05737889f, 0.07649364f, -0.08715046f, 0.02484937f, 0.01208402f, -0.10494946f, -0.04272033f, 
    0.22658101f, -0.00594440f, 0.02513579f, 0.11547814f, 0.13023984f, -0.06972594f, 0.00503549f, -0.04721568f, 
    0.07692554f, 0.05933457f, -0.00302562f, 0.04303179f, 0.01568380f, -0.00429696f, -0.00566957f, 0.09664738f, 
    -0.11574914f, -0.02314215f, 0.08009396f, 0.00478966f, -0.29806161f, 0.06424063f, 0.11026692f, 0.11103299f, 
    0.03382355f, 0.03033385f, -0.00088381f, -0.11153120f, 0.04278485f, 0.05741375f, -0.03612702f, -0.06504148f, 
    -0.01628831f, -0.00543839f, 0.04854999f, -0.08002891f, 0.06697030f, -0.09386563f, -0.03859760f, 0.01594364f, 
    -0.05281038f, 0.08611364f, -0.04736838f, 0.06430371f, -0.01178692f, 0.08346239f, -0.06153818f, 0.00033130f, 
    0.03127316f, 0.05256735f, 0.04941319f, -0.02079667f, 0.00863788f, 0.02869194f, -0.02587580f, -0.13529512f, 
    -0.02489939f, -0.04245686f, -0.03475746f, 0.02116271f, 0.26251453f, -0.03042459f, -0.38692397f, -0.03663131f, 
    -0.15871465f, 0.00916044f, 0.00072137f, 0.09375052f, -0.01240174f, -0.01429424f, 0.03157251f, 0.02881879f, 
    0.05622709f, -0.03448503f, 0.02672824f, 0.02315748f, 0.05141813f, -0.02882030f, 0.04293262f, 0.02685607f, 
    -0.17418303f, 0.06641705f, -0.06957099f, -0.06578015f, 0.09857918f, 0.00606612f, 0.01777854f, 0.10313349f, 
    -0.02754273f, -0.05268162f, -0.03661550f, -0.00938459f, 0.02072088f, -0.01571278f, 0.01316931f, -0.02121701f, 
    -0.01324712f, -0.04004252f, -0.11941883f, -0.01346498f, -0.09047024f, -0.09039043f, 0.08939578f, -0.06640494f, 
    -0.03043409f, -0.00332119f, -0.09218957f, -0.03975030f, -0.04023227f, 0.06871685f, -0.07600375f, 0.01877975f, 
    0.01075022f, -0.05263789f, -0.02569335f, 0.02823691f, -0.02995122f, -0.00472375f, 0.05163436f, -0.00091001f, 
    -0.11758512f, -0.18561395f, -0.06398709f, -0.10859579f, -0.14816748f, -0.09369945f, -0.06602508f, -0.15459201f, 
    0.00831342f, -0.03775372f, 0.03181630f, 0.03734590f, 0.03005686f, -0.04564085f, 0.00537195f, -0.01464370f, 
    -0.04981472f, 0.00378237f, 0.06300388f, -0.02004669f, -0.24723437f, 0.02206086f, -0.02314317f, -0.14843526f, 
    0.05332712f, 0.06631587f, 0.09809189f, 0.04376893f, 0.04318469f, -0.04494236f, -0.09942026f, -0.02445758f, 
    -0.04692229f, -0.02972775f, -0.02500782f, -0.07134295f, 0.00083584f, 0.07383492f, -0.05980637f, -0.05564879f, 
    0.11877856f, -0.14950623f, -0.01647890f, -0.12618591f, -0.05440274f, 0.00575516f, -0.05411619f, 0.03430095f, 
    -0.07411813f, 0.02950225f, -0.04757715f, -0.04174823f, -0.02871627f, -0.01141419f, -0.00480893f, -0.00333139f, 
    -0.10584627f, 0.01740182f, -0.00209319f, -0.07406288f, 0.35496971f, -0.17080678f, -0.12835801f, 0.21979953f, 
    -0.14497682f, -0.08102456f, 0.01407880f, -0.05805055f, -0.02650409f, 0.01116591f, 0.03303903f, -0.01033617f, 
    0.00619844f, 0.03819020f, -0.01007781f, -0.02678917f, -0.04621987f, 0.03066606f, 0.00823239f, 0.00692624f, 
    0.27363646f, 0.15754704f, -0.09201760f, -0.08329527f, -0.18799488f, -0.04983936f, 0.07021695f, -0.04312737f, 
    -0.04699240f, 0.01900093f, -0.05918533f, -0.09235401f, -0.02403754f, -0.01926985f, -0.02933423f, 0.03314221f, 
    0.00863783f, -0.02825971f, 0.05153026f, -0.08427212f, -0.02549616f, -0.18118703f, 0.08576035f, -0.02002052f, 
    -0.14581124f, -0.06543558f, -0.07370218f, -0.09803768f, -0.00113758f, 0.02571531f, -0.01840393f, 0.00209096f, 
    0.03971395f, -0.12797143f, -0.00440658f, -0.01059975f, 0.00478706f, 0.00876355f, 0.04235644f, -0.01608022f, 
    0.20087127f, 0.10309271f, -0.11428601f, 0.07695205f, -0.27819321f, 0.00942718f, -0.12848906f, 0.08976744f, 
    0.11208905f, 0.12720664f, 0.00379818f, 0.00739435f, 0.01708637f, 0.00861685f, 0.00444080f, -0.06732111f, 
    -0.00479295f, 0.02653250f, 0.08999907f, 0.09401496f, 0.12538809f, 0.07103922f, 0.15352485f, 0.06755649f, 
    0.23098028f, -0.03029085f, -0.07305237f, -0.12763599f, 0.03040445f, 0.01250280f, 0.01090923f, -0.03101958f, 
    -0.04153461f, 0.03194769f, -0.05510132f, 0.02134767f, -0.00095251f, -0.01521250f, -0.00469727f, -0.02652335f, 
    0.26625276f, -0.21447845f, 0.12679699f, -0.06027287f, -0.00550392f, 0.03100590f, -0.09074576f, 0.06628365f, 
    0.05022418f, 0.09678033f, 0.02196197f, -0.01068480f, 0.06094844f, 0.01319830f, -0.05680278f, -0.00174140f, 
    -0.04929319f, -0.00598423f, -0.03773934f, -0.05423268f, 0.34818324f, -0.13856950f, -0.19599076f, -0.04250975f, 
    0.00290549f, -0.06150334f, -0.02612642f, 0.01129971f, -0.00712626f, 0.04348091f, -0.02741547f, 0.02796059f, 
    0.01424090f, -0.09774694f, 0.03724239f, -0.00775606f, -0.07390596f, -0.11304486f, 0.07220098f, -0.01149395f, 
    0.18665268f, 0.07883736f, 0.08233285f, 0.09362931f, 0.14961898f, 0.00728715f, -0.06703845f, -0.11117519f, 
    0.03624338f, 0.11478338f, 0.06699415f, -0.00924197f, 0.04320054f, 0.00048891f, 0.05105606f, 0.02977543f, 
    -0.04501732f, -0.00692591f, -0.08442779f, -0.03733501f, -0.05833865f, 0.08002470f, 0.03869249f, -0.05495629f, 
    -0.01911667f, 0.01937898f, 0.08368687f, 0.00762302f, -0.00020431f, -0.06496858f, -0.00539823f, -0.02170822f, 
    0.05395159f, 0.00657639f, -0.07034597f, 0.01920402f, -0.01088932f, -0.07807913f, 0.03277574f, -0.01159869f, 
    -0.01629531f, -0.15949920f, -0.02017260f, -0.04913275f, 0.06448434f, -0.11730368f, -0.03435319f, 0.03704233f, 
    -0.08035820f, -0.08109776f, 0.06330696f, -0.01559018f, 0.00106909f, -0.10647904f, 0.07027171f, -0.00434179f, 
    -0.04922023f, -0.02502507f, 0.01551736f, -0.00255864f, 0.17738850f, -0.03254028f, 0.05753710f, -0.02277829f, 
    0.11858599f, -0.19159976f, -0.04982677f, -0.00487928f, 0.00122187f, 0.02832613f, 0.00309464f, 0.00287593f, 
    -0.02477258f, -0.07726414f, 0.10343846f, -0.03964328f, 0.00266592f, -0.00087812f, 0.04725003f, -0.01191420f, 
    0.02227915f, -0.24699919f, -0.05940842f, -0.02795872f, -0.23796673f, -0.00550646f, -0.02514202f, -0.06755379f, 
    -0.03421766f, 0.01384184f, -0.05351770f, 0.03210589f, 0.02453615f, -0.04870510f, -0.05552468f, -0.02955492f, 
    -0.02398430f, 0.07322308f, 0.02128499f, -0.02490694f, 0.05024251f, 0.08899309f, -0.08342218f, -0.05832142f, 
    -0.09014685f, 0.00115738f, 0.03756164f, -0.03904829f, -0.06314643f, -0.03577330f, -0.02139056f, -0.03181207f, 
    0.01512696f, -0.06126844f, 0.05205059f, -0.04651682f, -0.03095435f, -0.05835270f, -0.05896860f, 0.02313389f, 
    -0.14984496f, 0.16445641f, -0.04064669f, 0.06762228f, 0.04741438f, 0.00203937f, 0.11047551f, 0.05855690f, 
    0.04765293f, -0.10782357f, -0.00916324f, -0.07075143f, -0.04760760f, 0.10058319f, 0.01950915f, 0.07454585f, 
    -0.00090933f, -0.02545225f, 0.02884098f, -0.02959731f, 0.08646839f, -0.13192195f, 0.12957034f, 0.01738865f, 
    0.13865295f, -0.10226844f, -0.06455839f, -0.10733578f, -0.00557863f, -0.00500879f, 0.08523268f, -0.01939676f, 
    -0.03848267f, 0.00494853f, 0.04723712f, -0.03741122f, -0.02553048f, 0.01171957f, 0.00949564f, -0.01075017f, 
    0.26408786f, 0.10841765f, 0.00264264f, 0.13322379f, 0.14151630f, -0.13387620f, -0.09785377f, 0.04178490f, 
    0.05150257f, 0.01173828f, -0.00259233f, 0.01819290f, 0.00217053f, 0.05344816f, -0.03358474f, -0.01315596f, 
    -0.06021851f, -0.01603898f, -0.05981494f, 0.01639375f, 0.00696166f, 0.13750264f, 0.00652779f, -0.10767527f, 
    -0.01726124f, 0.09561711f, 0.03898236f, 0.09686395f, 0.02538888f, -0.01435549f, -0.08334706f, 0.02164478f, 
    -0.03781027f, -0.04339042f, -0.05334656f, 0.08351317f, -0.02578222f, 0.04547821f, -0.03284191f, 0.00059175f, 
    -0.42874926f, 0.18425062f, -0.05704370f, -0.16534027f, 0.05271187f, 0.01955846f, 0.06952594f, -0.01405549f, 
    0.05874596f, -0.06412587f, 0.03367578f, 0.02809933f, -0.03845979f, -0.05865297f, -0.02394079f, 0.01827603f, 
    0.03584170f, 0.04154062f, 0.10243580f, -0.01098889f, 0.04216978f, -0.11182079f, 0.01643941f, -0.09922581f, 
    -0.13722268f, 0.01043460f, 0.00327986f, 0.00770349f, 0.01353973f, 0.00376879f, -0.05377729f, 0.02068899f, 
    0.04752906f, -0.02908017f, -0.04448916f, 0.03366475f, 0.01864240f, -0.06693205f, 0.04497619f, -0.05913090f, 
    0.14872931f, 0.00975129f, 0.10186574f, 0.00985583f, 0.04322654f, -0.01076275f, -0.03638234f, -0.07087763f, 
    0.06155388f, 0.00830718f, -0.06571978f, 0.02065980f, -0.01451123f, -0.01119654f, -0.00984082f, 0.00976978f, 
    -0.00676092f, 0.03235416f, 0.04167974f, 0.04732878f, 0.11803153f, 0.03619560f, 0.00225307f, -0.14470676f, 
    -0.09766617f, 0.04072133f, -0.01993338f, 0.10800045f, -0.02074765f, 0.03742979f, -0.01650566f, 0.05588986f, 
    0.04249024f, -0.12286247f, -0.04862669f, 0.06024407f, -0.00936511f, 0.06743915f, 0.08585069f, -0.02402532f, 
    0.16543904f, 0.07751716f, -0.11728132f, 0.03810704f, 0.06516460f, -0.09458392f, -0.03042981f, -0.04522916f, 
    0.00960694f, 0.03412288f, 0.01989672f, -0.04199878f, 0.08139712f, -0.04973148f, -0.04314449f, -0.01747479f, 
    -0.00459966f, -0.07442815f, -0.04392380f, 0.02559265f, -0.06223992f, 0.11040229f, 0.00151237f, -0.11775081f, 
    -0.01972355f, 0.03986712f, 0.11380332f, 0.05917948f, -0.04658025f, -0.07120784f, -0.03346932f, 0.07131693f, 
    -0.03457237f, -0.12351116f, 0.00128792f, 0.00425463f, -0.00529449f, 0.04922935f, -0.09718009f, -0.04970268f, 
    0.17403290f, 0.03792043f, 0.02786128f, 0.03223094f, 0.10615653f, -0.08774031f, -0.05491966f, -0.11364400f, 
    0.03106146f, 0.08861503f, 0.10744784f, 0.01871991f, 0.09186720f, -0.01385677f, 0.01280942f, -0.01739462f, 
    -0.05771798f, -0.04125570f, 0.10501816f, -0.02390541f, 0.23107690f, -0.10148916f, -0.02498773f, 0.06868676f, 
    -0.04718897f, -0.11338307f, 0.00910110f, -0.02797605f, -0.03143451f, -0.07344649f, 0.02848021f, 0.00251426f, 
    -0.02774626f, 0.01866310f, -0.02228349f, -0.02918307f, -0.01611499f, 0.03185429f, -0.01681580f, -0.01249398f, 
    0.12205185f, 0.02326418f, -0.10787383f, -0.05869874f, 0.02966280f, -0.03686225f, -0.00705613f, 0.05108965f, 
    0.05062569f, 0.01926224f, -0.00055046f, -0.03323482f, -0.00227737f, 0.01434589f, -0.04161803f, -0.05570729f, 
    -0.02501842f, -0.10118081f, -0.05703736f, 0.00062953f, -0.07373220f, 0.07358896f, 0.06323516f, -0.03072014f, 
    0.01272792f, -0.00166352f, 0.05415507f, 0.05312448f, -0.02309589f, -0.07686436f, -0.03241562f, 0.04942434f, 
    -0.00021977f, -0.07165632f, 0.02944816f, 0.01424758f, -0.15895331f, -0.06549948f, 0.02687723f, -0.04352651f, 
    0.13423946f, 0.01207619f, -0.05184978f, -0.07337650f, -0.04606718f, 0.02591145f, -0.01109816f, -0.02302641f, 
    -0.06516926f, -0.00272968f, 0.00556558f, 0.01554076f, 0.04731296f, -0.02310679f, -0.01862160f, -0.04988134f, 
    0.02607432f, -0.01311403f, -0.04494792f, 0.05449159f, -0.02297537f, 0.03417020f, -0.02518745f, 0.02495464f, 
    0.03617093f, 0.01905511f, 0.06920072f, 0.04978530f, 0.00415499f, -0.05577238f, -0.02422448f, 0.01372692f, 
    -0.04606618f, 0.03668540f, 0.00148936f, -0.04002957f, -0.06195361f, -0.00446836f, -0.06965569f, -0.00272086f, 
    -0.28251499f, -0.33692259f, 0.08705533f, -0.06046542f, -0.26490229f, 0.05225081f, -0.08398823f, -0.02818226f, 
    -0.01598801f, 0.04408142f, -0.12015900f, 0.03093594f, -0.06616945f, -0.03469764f, -0.01390945f, 0.03733149f, 
    0.01620600f, 0.04202201f, -0.07532308f, -0.02131193f, 0.04107497f, 0.08904875f, 0.01114949f, -0.06586377f, 
    0.00156136f, 0.02913017f, 0.06314652f, 0.02671026f, -0.03932465f, -0.07316847f, -0.01696950f, -0.04057817f, 
    -0.01655271f, -0.05027128f, -0.00037701f, -0.00667937f, -0.00026361f, -0.04286363f, -0.00236051f, -0.00770110f, 
    0.20959523f, 0.08010846f, -0.02593999f, 0.00776474f, -0.01203949f, -0.04823951f, 0.04188981f, 0.03794087f, 
    -0.00382471f, -0.05798335f, 0.06623664f, 0.05773579f, 0.01136033f, 0.01067963f, 0.07442584f, 0.01878470f, 
    -0.06357566f, -0.08687918f, -0.00419811f, -0.04401810f, 0.00622795f, 0.02933143f, -0.02695635f, -0.19219482f, 
    -0.09733841f, 0.05921976f, -0.05031041f, 0.06457237f, -0.09637199f, 0.04764671f, -0.09704436f, -0.02930286f, 
    0.06711074f, 0.01747540f, 0.02575802f, -0.04377791f, -0.08781999f, 0.08900763f, 0.01031474f, -0.06938716f, 
    0.00901151f, -0.15479456f, 0.15260503f, -0.07424796f, -0.02335091f, -0.04028507f, -0.02542160f, 0.01928941f, 
    0.06064023f, -0.01970406f, -0.00488756f, 0.02052234f, 0.08913407f, -0.01379359f, 0.03493425f, 0.01692283f, 
    -0.10957809f, 0.06948213f, 0.02774561f, 0.01688408f, 0.19172825f, 0.00696085f, 0.05767325f, -0.09908751f, 
    0.06705439f, -0.00511387f, -0.00696369f, 0.03663175f, -0.04633905f, 0.00636092f, -0.05432853f, -0.00469088f, 
    0.01362328f, -0.01945446f, -0.06619044f, -0.00367402f, -0.06971034f, -0.08909122f, -0.06051880f, -0.01181849f, 
    0.21026677f, -0.02736662f, -0.20748930f, -0.04118807f, -0.23529111f, -0.00429772f, 0.00823158f, -0.00897482f, 
    0.02034393f, -0.01684322f, 0.02778793f, 0.07581510f, 0.00756471f, -0.02043397f, -0.03442460f, 0.00117328f, 
    0.08984827f, -0.00088484f, 0.01806442f, -0.06125998f, -0.15056221f, -0.11604384f, -0.14373715f, -0.18838784f, 
    -0.15967569f, -0.07363515f, 0.02845758f, -0.01929007f, 0.04093129f, 0.02688420f, -0.01823352f, 0.03141326f, 
    -0.00294930f, -0.03060119f, 0.03387779f, 0.03834454f, -0.01978409f, 0.09466456f, 0.01145437f, -0.00873315f, 
    -0.01290355f, -0.17398977f, -0.17335133f, 0.08809221f, -0.20935512f, 0.00521005f, -0.06783543f, 0.07925700f, 
    0.08575122f, 0.11287812f, 0.02676796f, 0.01676420f, 0.04176741f, 0.04028522f, -0.00092798f, -0.05176716f, 
    0.04164165f, 0.04439108f, -0.07828221f, -0.11122837f, 0.01623534f, -0.14257291f, 0.02972315f, -0.01005829f, 
    -0.01148252f, -0.08287194f, -0.01215325f, 0.01268008f, -0.02406845f, -0.05745269f, 0.08194783f, -0.04561149f, 
    0.02441441f, -0.03322304f, 0.06306321f, 0.10087935f, -0.06872569f, -0.03803411f, -0.00144537f, -0.00725409f, 
    -0.12983537f, 0.08018084f, -0.04298964f, -0.00592522f, -0.00966295f, 0.01326310f, -0.03902677f, 0.10684539f, 
    -0.00994766f, 0.02794817f, -0.06474307f, -0.02375718f, -0.05880030f, 0.07397933f, -0.09219585f, 0.02830646f, 
    0.01494529f, 0.14672479f, 0.00546173f, 0.02228508f, 0.18703528f, 0.04011393f, -0.09929341f, -0.03173343f, 
    0.00630717f, -0.05181305f, -0.01440515f, -0.00505974f, 0.05879661f, 0.05788380f, -0.02043567f, 0.04718180f, 
    -0.00639806f, 0.02910513f, 0.02498173f, -0.00012815f, -0.02826742f, -0.12437057f, -0.03475857f, -0.01032658f, 
    0.13393386f, -0.17326826f, -0.14553942f, 0.01540172f, -0.11448424f, -0.04105137f, 0.08689258f, 0.00461687f, 
    0.03258872f, -0.06497562f, 0.08895365f, -0.10289012f, 0.03047528f, -0.05454646f, 0.02907257f, 0.06693169f, 
    -0.00339496f, 0.04399516f, -0.00013445f, 0.01940224f, 0.26195464f, 0.00013456f, -0.13808189f, 0.15555465f, 
    -0.22805084f, -0.10888514f, 0.01380672f, 0.04294925f, -0.05058775f, 0.02299350f, 0.01830076f, -0.01834962f, 
    0.01538651f, -0.06167528f, -0.00033697f, 0.09010760f, -0.01719013f, -0.07550741f, 0.09015208f, -0.05991922f, 
    0.00793081f, -0.16178766f, -0.12889425f, 0.01766558f, -0.12951924f, 0.01263193f, 0.05195470f, -0.02405265f, 
    0.02606829f, -0.08550354f, 0.00823188f, -0.04871858f, 0.02502520f, 0.00720599f, -0.03420683f, 0.03174094f, 
    0.01387744f, 0.02534061f, -0.00497639f, -0.06799423f, 0.15839620f, -0.17346561f, 0.10690536f, 0.00000587f, 
    0.13192452f, -0.10121679f, -0.07256977f, -0.10026807f, -0.00209921f, 0.02662003f, 0.04423109f, -0.00654008f, 
    -0.03825746f, -0.02597590f, 0.08666705f, -0.02079106f, 0.00542890f, -0.02946233f, 0.04004516f, -0.02450408f, 
    -0.15976514f, 0.10837743f, -0.04874212f, -0.16165601f, 0.10239094f, 0.02945453f, -0.00778005f, 0.07505012f, 
    0.02534367f, -0.03776456f, -0.02883852f, 0.02582685f, 0.04339175f, 0.01100033f, -0.03781197f, -0.00592157f, 
    -0.05092355f, -0.04350939f, 0.00515846f, -0.01673448f, -0.11615738f, 0.07155414f, 0.04807675f, -0.08145984f, 
    0.02366548f, 0.04920330f, -0.02681723f, 0.06447300f, 0.02777744f, -0.03120052f, -0.07234510f, 0.02467706f, 
    -0.01620237f, 0.02697959f, -0.02130089f, -0.04888440f, -0.02921917f, -0.00859770f, -0.05016732f, -0.10402644f, 
    -0.12563564f, -0.18942481f, -0.25715783f, -0.02519156f, 0.03995252f, -0.12702839f, -0.02153649f, -0.02894259f, 
    0.05879736f, -0.03583763f, 0.02331333f, -0.03428209f, 0.01035212f, -0.05981254f, 0.00677090f, -0.01052061f, 
    -0.03851570f, -0.03062223f, 0.02973038f, -0.08658692f, 0.09757941f, -0.07492016f, -0.01993939f, -0.03069608f, 
    -0.03285325f, -0.10064137f, -0.02893931f, 0.05279685f, 0.02757715f, 0.06203670f, -0.01549328f, 0.00991233f, 
    0.00098937f, 0.00940865f, -0.03046085f, -0.06231246f, 0.04382069f, -0.06754259f, -0.00220421f, -0.07041337f, 
    0.03475640f, 0.09367262f, 0.06979238f, 0.09159133f, -0.04179614f, -0.08034301f, -0.01402662f, -0.07275896f, 
    -0.02878181f, 0.04037751f, 0.04072077f, 0.03108632f, -0.00264882f, -0.07012330f, 0.00092047f, 0.00193442f, 
    0.00615299f, 0.05226129f, -0.02668820f, -0.01499576f, -0.13855794f, 0.30937034f, 0.06222641f, 0.17641543f, 
    0.07947136f, 0.05965659f, 0.07833111f, 0.00224407f, -0.01452134f, 0.03788840f, -0.04998438f, 0.00011834f, 
    0.01550067f, -0.06862947f, -0.01648914f, 0.05627196f, 0.04987858f, 0.05216111f, 0.02887350f, 0.03250979f, 
    -0.22286846f, -0.15738405f, 0.10754479f, -0.12600778f, 0.02850331f, 0.01910017f, 0.03157697f, 0.03156651f, 
    0.02509098f, -0.05192494f, 0.01230117f, 0.08643311f, -0.00964992f, 0.02526145f, 0.02965575f, -0.04608763f, 
    0.09188251f, -0.18870820f, 0.10382248f, -0.01091426f, -0.16487604f, -0.10027687f, -0.09037780f, 0.03007382f, 
    0.15912463f, 0.01004630f, 0.03396126f, -0.00298627f, -0.03077240f, 0.02363943f, -0.05401476f, 0.02565295f, 
    -0.00159364f, 0.05467308f, -0.04849894f, 0.03818040f, 0.02343377f, -0.00864775f, 0.04439885f, 0.01128741f, 
    0.01742519f, 0.03045301f, -0.00606567f, 0.05167407f, -0.01095470f, -0.07995355f, 0.05066033f, -0.02386462f, 
    0.05211112f, 0.01669287f, -0.00718739f, 0.10502603f, -0.06116569f, -0.00773639f, -0.00182522f, 0.01217063f, 
    -0.01298726f, -0.02573659f, 0.02016033f, 0.02514591f, 0.12154733f, 0.29302195f, 0.08781860f, 0.07692391f, 
    -0.01823717f, 0.01517426f, 0.03387195f, -0.02102619f, 0.01469688f, -0.01208269f, -0.10279262f, -0.03325801f, 
    -0.00647325f, 0.06272108f, -0.08064043f, 0.04242476f, -0.00311844f, 0.11212147f, 0.12361089f, 0.02852600f, 
    0.05923238f, -0.08303111f, 0.08356085f, 0.01190331f, -0.07226805f, -0.01487159f, -0.14290936f, -0.00204738f, 
    -0.05066354f, -0.08278485f, -0.01993671f, 0.03008357f, -0.03458039f, -0.02933352f, 0.05360298f, 0.04874550f, 
    0.04450576f, 0.04693158f, 0.07791506f, 0.04762852f, -0.08974992f, -0.00459949f, -0.15863815f, 0.05733180f, 
    -0.01988098f, -0.02485452f, 0.06856580f, 0.01108190f, -0.05632444f, 0.04844952f, -0.03261964f, -0.02409354f, 
    0.00055194f, -0.05127147f, 0.00088339f, 0.04862192f, 0.04032724f, -0.00527622f, -0.05205244f, 0.00404245f, 
    0.07236312f, -0.22532043f, 0.01214590f, -0.05418956f, -0.03407690f, -0.05133650f, 0.00761983f, 0.03006089f, 
    -0.01763807f, -0.04314365f, -0.04111074f, -0.00631744f, -0.01083298f, 0.08100274f, 0.02020006f, 0.03425374f, 
    0.10320714f, -0.00907415f, -0.05133824f, 0.02120189f, -0.06333232f, 0.29735923f, 0.07186770f, 0.02824229f, 
    -0.00130418f, -0.00458951f, -0.10217687f, -0.01627606f, 0.04826332f, -0.02600977f, 0.01666089f, -0.00903177f, 
    -0.01500700f, -0.01562028f, -0.09332335f, -0.09656579f, 0.04624499f, -0.03719006f, 0.03128491f, 0.00368460f, 
    -0.07604476f, -0.42358398f, -0.23002160f, 0.11550289f, 0.17477135f, 0.01038429f, 0.11579299f, -0.07122897f, 
    -0.02991329f, -0.03426046f, -0.01875221f, 0.01374093f, 0.00225765f, -0.07441659f, 0.00793160f, -0.04037328f, 
    -0.00935899f, 0.01124578f, 0.02330173f, -0.06770083f, 0.20797513f, 0.18908241f, -0.15568326f, -0.02578713f, 
    0.05724982f, 0.01184152f, -0.03232726f, 0.02341877f, 0.05572652f, 0.02228116f, -0.08404256f, -0.10597572f, 
    -0.06707750f, -0.03555218f, 0.06208429f, 0.01617008f, -0.01143577f, 0.14365706f, -0.05874931f, -0.01857645f, 
    0.09896549f, 0.05093365f, 0.08845798f, 0.05737405f, 0.03049644f, -0.06628970f, -0.03745699f, -0.04002850f, 
    -0.01181350f, 0.01540037f, -0.08221745f, -0.03051033f, -0.04529403f, 0.02558125f, -0.08012332f, -0.02117011f, 
    -0.02964298f, 0.08038729f, 0.02802860f, -0.04686575f, -0.01768839f, -0.21753813f, -0.13709159f, 0.02689142f, 
    0.08518481f, 0.01061790f, 0.06548851f, 0.03294792f, -0.06343535f, -0.00347081f, 0.00891476f, -0.00997150f, 
    -0.03440549f, 0.00805970f, -0.07596711f, 0.02215790f, 0.08380874f, 0.06461577f, 0.02226999f, -0.03057312f, 
    0.25129172f, 0.14650209f, -0.04037024f, -0.01703455f, 0.01964498f, 0.01054555f, 0.01092462f, -0.00417771f, 
    0.00996158f, 0.01897188f, -0.07951611f, -0.06511963f, -0.02263319f, 0.01069050f, -0.02370858f, 0.00434662f, 
    0.00934075f, -0.00639786f, 0.05299596f, 0.05832105f, 0.14081097f, -0.01456675f, -0.03264308f, 0.03849412f, 
    -0.14973244f, -0.07064126f, -0.09590019f, 0.06402973f, -0.02953817f, -0.00770202f, -0.03653697f, 0.02081054f, 
    -0.06072563f, -0.03817324f, 0.07629474f, -0.03211385f, 0.01040242f, 0.09462951f, 0.04380865f, 0.07088586f, 
    -0.44801843f, 0.30159664f, 0.00704351f, 0.05625060f, 0.06621492f, 0.05742867f, 0.05378788f, 0.01608286f, 
    0.04315301f, 0.00994835f, -0.03375256f, -0.07834682f, -0.03652205f, -0.03587469f, -0.06037739f, -0.01117319f, 
    0.00392650f, -0.04765683f, 0.11915524f, 0.06464676f, 0.01952384f, 0.06028771f, -0.02391545f, 0.04752484f, 
    0.01344223f, -0.04430022f, 0.02322866f, -0.04960347f, 0.02097143f, 0.02124867f, -0.03919416f, 0.03378063f, 
    0.02476870f, -0.02789496f, 0.04194352f, -0.02396008f, -0.02235720f, 0.03997444f, 0.02163669f, -0.00420226f, 
    0.08075185f, 0.08030096f, 0.08607683f, 0.06997845f, -0.07287879f, -0.10922517f, 0.10139058f, -0.03799485f, 
    0.04544891f, 0.02749964f, -0.03101740f, 0.12907785f, -0.13891450f, 0.02449873f, -0.01475873f, -0.10131469f, 
    0.09378707f, 0.03741116f, -0.03422863f, 0.08772134f, -0.13002598f, 0.14016277f, -0.11976262f, -0.12219831f, 
    -0.03831384f, -0.02059872f, -0.14298189f, 0.04232500f, -0.01964809f, -0.07089306f, -0.01597573f, -0.06073171f, 
    -0.01225505f, 0.03456856f, -0.00088080f, -0.04784651f, -0.00087131f, 0.03872315f, 0.03632494f, 0.03172096f, 
    -0.24513404f, -0.26119867f, -0.19274536f, 0.00787992f, -0.15431297f, -0.11337955f, -0.08099931f, -0.03701968f, 
    0.03102407f, 0.01045691f, -0.15433393f, -0.08172361f, -0.00356845f, 0.06281410f, 0.01804271f, 0.04656051f, 
    -0.02664096f, 0.00006978f, -0.04063447f, 0.07719607f, 0.02349460f, 0.15951411f, 0.02034654f, 0.04688944f, 
    -0.03970253f, -0.02988818f, -0.01511992f, -0.03569728f, 0.08720758f, 0.01969367f, 0.02725650f, 0.00225846f, 
    0.04614443f, -0.00650762f, -0.09588420f, -0.17617343f, -0.02837554f, 0.00018652f, 0.10066383f, 0.03902120f, 
    -0.33958447f, 0.14382897f, -0.12766264f, -0.11234647f, -0.13526335f, -0.05299438f, -0.03809765f, 0.04095455f, 
    -0.02016648f, 0.03521374f, -0.03663629f, -0.05731978f, -0.02683184f, -0.02218426f, -0.08211244f, 0.02240658f, 
    -0.02770137f, 0.00495955f, 0.11204431f, 0.04628374f, -0.08835205f, 0.04990856f, -0.08833867f, 0.22666225f, 
    0.17182909f, 0.05102169f, 0.11249027f, 0.04891907f, 0.01738230f, 0.04160870f, -0.03939671f, 0.03581602f, 
    0.01786185f, -0.19255319f, -0.05817119f, -0.04763179f, 0.03884887f, 0.06617012f, 0.03950699f, -0.10489118f, 
    0.14641851f, -0.17093028f, 0.01756216f, -0.08982813f, -0.11589073f, -0.03982796f, -0.09050902f, -0.05614444f, 
    -0.01556727f, -0.01524850f, 0.04647256f, -0.04493030f, 0.05992913f, -0.03709790f, 0.03575743f, -0.01169798f, 
    0.00801396f, 0.00049766f, 0.04227151f, 0.02434019f, 0.00292452f, -0.12228449f, -0.04094026f, -0.13651192f, 
    -0.06733438f, -0.02271071f, -0.09266814f, -0.04485590f, 0.04975887f, -0.13214757f, -0.02244055f, 0.00052491f, 
    0.01508603f, -0.02785765f, -0.04519077f, -0.03293550f, -0.01670035f, -0.04498754f, 0.04229428f, 0.04009917f, 
    -0.07745102f, 0.17539480f, -0.00031934f, 0.08347711f, -0.02330437f, -0.01954054f, -0.01162221f, -0.01736331f, 
    0.03094213f, 0.01007682f, -0.03313433f, -0.05905206f, -0.01267627f, -0.06445695f, -0.00744382f, -0.04563325f, 
    -0.00639282f, 0.11030659f, 0.06640106f, -0.01660714f, -0.24428257f, 0.21887329f, 0.05907140f, -0.11980808f, 
    -0.08399083f, 0.01251967f, -0.05245848f, -0.02225791f, 0.02286624f, -0.05457934f, -0.02151950f, 0.04344184f, 
    -0.08500607f, 0.01437728f, -0.06200714f, -0.06205888f, 0.02600327f, -0.06639815f, 0.07638529f, 0.00273897f, 
    -0.23921718f, -0.04434283f, -0.22072747f, 0.18219136f, 0.09453705f, -0.10604692f, 0.14383790f, 0.01136478f, 
    0.10276963f, -0.03380548f, -0.11465701f, 0.09020779f, 0.00346503f, -0.13092265f, 0.01250707f, 0.00598767f, 
    0.06704771f, 0.02250015f, 0.03309691f, -0.05137954f, -0.01411036f, -0.05230483f, -0.08110627f, -0.02520213f, 
    -0.06976011f, -0.03018294f, -0.12898479f, 0.03626185f, 0.03289354f, -0.00857774f, -0.02073842f, -0.01365082f, 
    0.00849226f, -0.03593818f, 0.01765336f, -0.02437840f, -0.04020769f, 0.00719857f, 0.00888402f, 0.01131811f, 
    -0.04584053f, -0.09693846f, -0.01107552f, -0.02893599f, -0.18455543f, -0.00015466f, -0.06493176f, 0.05724359f, 
    -0.04038210f, -0.03579842f, -0.09053514f, 0.05461127f, 0.01816864f, 0.01615663f, 0.01255257f, 0.01013633f, 
    0.03536046f, 0.01458007f, 0.04565550f, 0.10486372f, 0.45632356f, 0.22771758f, -0.09792435f, 0.19081973f, 
    -0.02853733f, 0.11401077f, 0.00972314f, -0.00507851f, 0.08271977f, -0.02621774f, 0.02509519f, -0.03877411f, 
    -0.08730242f, 0.01440398f, -0.02414886f, -0.04820369f, 0.00155674f, 0.08682388f, 0.03056902f, -0.06600884f, 
    -0.07774148f, 0.24775395f, 0.03653289f, 0.19247772f, 0.11594437f, 0.03458089f, 0.05338269f, 0.04304820f, 
    -0.00046491f, 0.04270905f, 0.13950294f, -0.01406729f, -0.07209440f, 0.04068645f, -0.11997902f, 0.02059796f, 
    -0.08710658f, 0.00337172f, 0.10136732f, -0.08856919f, -0.18503922f, 0.13231476f, 0.08997206f, 0.09116118f, 
    0.08355275f, 0.05632978f, 0.00209721f, -0.05124919f, -0.06533144f, -0.01541992f, -0.03381179f, -0.05120221f, 
    -0.00183489f, 0.01380581f, 0.00953716f, 0.00804686f, 0.03112308f, -0.00872333f, 0.06635009f, -0.00648029f, 
    0.10451903f, 0.09793420f, -0.08025723f, -0.07403652f, 0.03206000f, -0.01717652f, -0.02090567f, 0.00695697f, 
    0.03158446f, -0.03855475f, -0.08934470f, -0.07555972f, 0.00791125f, 0.07170458f, 0.04303451f, 0.01531919f, 
    -0.02760171f, -0.01081769f, 0.02380294f, 0.02554208f, 0.04035401f, -0.15222594f, -0.11814331f, -0.00234142f, 
    0.19635299f, -0.04408493f, 0.08618833f, 0.02694974f, 0.03650400f, 0.06747286f, 0.09822372f, 0.00940420f, 
    0.00716427f, -0.07260340f, 0.00453212f, -0.10424642f, 0.03850160f, 0.00343550f, -0.00623520f, -0.04662234f, 
    -0.33827215f, 0.21290796f, 0.02827490f, -0.05894228f, -0.07827652f, -0.10496918f, -0.06614561f, 0.08069365f, 
    0.00529666f, 0.00416487f, 0.00628468f, 0.06852436f, -0.08162145f, -0.00349456f, 0.00131031f, 0.00003789f, 
    0.01674580f, -0.00737447f, 0.10433076f, -0.02011216f, 0.02401714f, -0.24634156f, -0.12849392f, 0.13058089f, 
    0.17634937f, 0.02786639f, 0.03941069f, 0.08253109f, 0.00214883f, -0.08451949f, 0.06379983f, -0.02101200f, 
    -0.12841347f, -0.07302525f, -0.04563851f, 0.06630532f, -0.01882950f, 0.06802784f, -0.02507740f, -0.05093600f, 
    0.04145047f, 0.02481952f, 0.07360926f, -0.08495732f, -0.14554594f, -0.03618025f, -0.05628923f, -0.08682809f, 
    -0.08353218f, -0.01964664f, -0.07212240f, -0.03091993f, -0.06285590f, -0.02397011f, -0.01556555f, -0.01181062f, 
    -0.03800129f, -0.02159704f, -0.09799267f, -0.01626393f, 0.05014764f, 0.03538859f, -0.00707759f, 0.04950606f, 
    -0.04723251f, -0.05373032f, -0.09804866f, 0.00745943f, -0.04271112f, -0.01649157f, -0.04056234f, 0.03499739f, 
    0.01966626f, -0.00330461f, 0.06506613f, 0.00471809f, 0.00551086f, 0.06558396f, 0.03189773f, -0.07795358f, 
    -0.44250217f, -0.34395188f, -0.05224843f, 0.02829582f, -0.02037891f, -0.09333382f, -0.08050031f, 0.00553336f, 
    0.02821420f, -0.01279398f, -0.00025376f, 0.00176410f, -0.00579143f, 0.05873183f, -0.02726929f, 0.01932071f, 
    0.03810296f, -0.08824060f, 0.05322308f, 0.05418418f, 0.05573055f, -0.33155701f, -0.05563966f, 0.12730789f, 
    0.01752969f, -0.03010022f, -0.01692972f, 0.06559552f, -0.02613399f, -0.01862487f, -0.00084870f, 0.00631662f, 
    -0.00860213f, -0.10821372f, 0.03280024f, -0.00089292f, -0.05064308f, -0.02078914f, 0.01325582f, -0.01305340f, 
    -0.03862509f, 0.18703231f, 0.06917982f, 0.00930308f, -0.07154763f, -0.00225030f, -0.00638468f, -0.07214095f, 
    0.01412106f, -0.02936989f, -0.01235955f, 0.03086971f, -0.08001383f, 0.01153223f, -0.03414423f, -0.01344096f, 
    -0.01876072f, -0.01760894f, 0.05412283f, -0.01541967f, -0.13373905f, -0.51835918f, -0.17484227f, 0.00594808f, 
    -0.01564930f, -0.05218780f, -0.01791759f, 0.09674510f, 0.01455006f, -0.10375635f, -0.01688054f, 0.04222586f, 
    -0.04322471f, 0.02993055f, 0.01575942f, 0.05460114f, -0.00878625f, 0.03390419f, -0.03486675f, -0.01175268f, 
    0.09770821f, 0.13304567f, 0.01099193f, 0.10646699f, -0.14013217f, 0.02010817f, 0.07147467f, -0.03658435f, 
    0.02438955f, -0.00685421f, 0.00455636f, 0.04529082f, -0.05977536f, -0.01392427f, 0.01298670f, 0.01232713f, 
    -0.00312271f, -0.01849066f, -0.03917892f, -0.01947790f, -0.26192942f, -0.04136772f, -0.11065042f, 0.06160098f, 
    0.09859465f, -0.07256945f, -0.01452903f, 0.05585719f, 0.02660177f, -0.04729366f, -0.01439078f, -0.00257794f, 
    -0.04004440f, -0.11742472f, -0.01437961f, -0.02670111f, 0.01799452f, -0.03930633f, -0.02608746f, -0.02795563f, 
    -0.30619276f, -0.13381504f, 0.00797110f, -0.19824709f, -0.14894713f, -0.02296646f, -0.14717017f, -0.05800914f, 
    0.02634500f, -0.09577713f, 0.08471738f, -0.05661895f, -0.00498931f, 0.02519522f, -0.02129349f, 0.04874742f, 
    0.02976693f, -0.05909425f, 0.00728301f, -0.01581810f, 0.11631697f, -0.05379131f, -0.16131081f, -0.09220307f, 
    -0.00194857f, -0.02471601f, -0.00750386f, 0.01791283f, 0.03277165f, 0.05108582f, 0.02663207f, 0.03388852f, 
    -0.07009988f, 0.05310163f, -0.08986288f, -0.00150883f, -0.03161108f, 0.01970535f, 0.01240885f, 0.11375448f, 
    -0.00392216f, -0.01525666f, -0.09482840f, 0.03176651f, -0.04986769f, -0.04913323f, -0.05848272f, 0.10810865f, 
    0.08481328f, -0.11180457f, -0.11331102f, -0.04758732f, 0.00565289f, 0.02319537f, 0.01112296f, -0.00687145f, 
    -0.00958351f, -0.01153520f, -0.04944078f, -0.08171109f, -0.14314643f, 0.06492747f, 0.01771615f, -0.06368267f, 
    -0.14977074f, -0.08534788f, -0.08692898f, -0.07126963f, 0.05621517f, -0.01801491f, 0.02003798f, -0.07445926f, 
    -0.00566893f, -0.02519782f, -0.02100625f, -0.04790872f, 0.00197563f, -0.05273182f, 0.04263424f, 0.04094082f, 
    -0.23477118f, 0.28101668f, 0.17575571f, 0.20920822f, 0.07543777f, 0.02242918f, 0.05567513f, 0.00295959f, 
    -0.00761726f, -0.02042775f, 0.00597463f, -0.05302610f, -0.07313932f, 0.02990077f, -0.11588906f, 0.04693071f, 
    0.02767478f, 0.11806051f, 0.07207522f, -0.01915439f, 0.11368035f, 0.12173773f, 0.15865065f, -0.01836937f, 
    0.11610595f, -0.07980641f, 0.08248378f, -0.00729738f, -0.04217076f, 0.06410137f, 0.05825068f, 0.02115241f, 
    0.05138868f, -0.00055658f, -0.00833017f, 0.09602659f, -0.02470992f, 0.03817651f, 0.05518688f, 0.08920428f, 
    0.04973494f, -0.14483662f, -0.02467954f, 0.00964665f, -0.03142893f, -0.14623199f, 0.02409804f, 0.05464512f, 
    -0.02650474f, 0.05571754f, 0.00866655f, -0.04211314f, 0.01686547f, -0.00321862f, -0.04305371f, -0.01051334f, 
    -0.02707841f, -0.02593099f, 0.00518993f, 0.04982330f, 0.14380518f, -0.08306361f, 0.12626821f, 0.00181206f, 
    0.01164662f, -0.07110041f, -0.06175085f, -0.07633002f, -0.00698199f, 0.01023043f, 0.00770333f, -0.01089809f, 
    0.04280638f, -0.00379801f, 0.03138426f, -0.07061493f, 0.04233481f, -0.03353354f, 0.00569850f, -0.02832849f, 
    0.39310974f, 0.22621389f, -0.17030013f, 0.06454806f, 0.07438111f, 0.04044650f, -0.01126347f, 0.00278804f, 
    0.04925240f, -0.02091991f, -0.00189198f, -0.04001967f, -0.13375881f, 0.02547923f, 0.07833162f, -0.06802958f, 
    0.00682858f, 0.08268224f, 0.03241836f, -0.01518573f, -0.34732813f, -0.00086761f, 0.06141568f, -0.10572492f, 
    -0.14566725f, -0.02533381f, -0.10012306f, -0.00331249f, 0.03360443f, -0.02941544f, 0.01211840f, -0.07449531f, 
    -0.00701407f, 0.02046359f, -0.03916321f, 0.03452792f, 0.07000569f, -0.04439311f, 0.00604135f, 0.05368445f, 
    -0.04046669f, -0.04453234f, 0.06580357f, 0.14373198f, -0.00676563f, 0.07338616f, 0.06182665f, 0.06309201f, 
    -0.02075505f, 0.07256853f, 0.01899383f, 0.09960426f, -0.10590905f, -0.10801261f, -0.10430481f, -0.06120728f, 
    -0.01677541f, 0.08022109f, 0.04281790f, -0.10091228f, -0.09936109f, 0.12282690f, 0.08898394f, 0.10392626f, 
    -0.03376980f, 0.01070868f, -0.09661549f, -0.01024207f, -0.05855373f, -0.14172865f, -0.02115610f, -0.06955650f, 
    -0.02067547f, 0.02428783f, 0.07585207f, 0.02911046f, 0.06840626f, -0.16263485f, -0.01640896f, -0.06374910f, 
    -0.05933448f, 0.24271813f, 0.06588705f, 0.17900024f, 0.08311717f, 0.06812215f, 0.01263766f, 0.02762550f, 
    -0.04440547f, 0.03575372f, -0.06589440f, 0.00729622f, 0.00968432f, -0.06849201f, -0.06012722f, -0.02570035f, 
    0.01089938f, 0.01404567f, 0.07907270f, -0.02450083f, 0.01806025f, -0.01263925f, -0.06749285f, -0.07955643f, 
    -0.01015485f, -0.03586460f, -0.08736161f, -0.05316987f, 0.06096165f, -0.02626693f, 0.00741453f, 0.00033866f, 
    0.04101262f, -0.00708779f, 0.00348008f, -0.03694918f, -0.07952189f, 0.00591633f, -0.03388580f, 0.02524076f, 
    -0.09033564f, -0.24119444f, -0.18826382f, 0.01854760f, 0.23264946f, 0.00316879f, 0.12352882f, 0.04057012f, 
    -0.00217575f, -0.04328061f, -0.00950604f, -0.00946149f, -0.04057691f, 0.00315537f, 0.03166083f, -0.03464956f, 
    -0.11439057f, -0.08005913f, 0.05941813f, -0.05748839f, -0.41609678f, -0.04729371f, -0.08450835f, -0.02975629f, 
    -0.02600242f, 0.01790223f, -0.02475314f, 0.01395510f, 0.01291314f, -0.07562320f, -0.09523050f, -0.03026560f, 
    0.09513780f, -0.01328585f, 0.06888908f, 0.03994090f, -0.00394632f, -0.02905974f, -0.04432413f, 0.03544783f, 
    -0.17548212f, -0.03717195f, -0.06564346f, -0.00129346f, -0.04937413f, -0.04239688f, 0.00672343f, -0.04957398f, 
    0.00402303f, 0.01726567f, -0.01170410f, -0.12831584f, -0.06859864f, -0.07862025f, -0.07784734f, 0.11272598f, 
    -0.00935810f, -0.04060611f, 0.00582512f, 0.01593370f, -0.06398720f, -0.00426879f, 0.02850086f, -0.13106596f, 
    -0.00174876f, 0.02022413f, 0.08571796f, 0.01359772f, -0.05039506f, -0.11064882f, 0.02945847f, -0.01764697f, 
    -0.03095386f, 0.00883924f, -0.04068008f, -0.08009642f, -0.06253221f, 0.02896896f, -0.02276108f, -0.05019114f, 
    -0.16358264f, 0.09561812f, -0.11299807f, 0.09471805f, -0.05680280f, 0.05962676f, -0.01326328f, 0.01049890f, 
    0.05002102f, -0.19182763f, 0.00425869f, 0.03752196f, -0.00296465f, -0.03539611f, -0.01491020f, -0.05964196f, 
    -0.05402105f, -0.01479879f, 0.01075800f, -0.08437338f, -0.14234948f, -0.23977643f, 0.05157266f, 0.06771310f, 
    0.01893204f, -0.06446104f, -0.05178586f, 0.05450777f, -0.09914732f, 0.06774151f, -0.01710846f, -0.01283588f, 
    0.04691075f, -0.02988396f, 0.06186116f, -0.03124193f, -0.00756939f, 0.05793523f, 0.08896910f, -0.03517305f, 
    -0.12114861f, -0.13464299f, -0.04408198f, -0.02884520f, -0.05075069f, -0.06494316f, 0.05033549f, 0.11832070f, 
    -0.08568272f, -0.06572052f, -0.00414966f, -0.00162482f, -0.03844255f, -0.02578232f, 0.01389209f, 0.04992644f, 
    -0.07287453f, 0.03330211f, -0.13570330f, -0.08048557f, 0.00857026f, 0.04964776f, 0.11693309f, 0.06142964f, 
    -0.02591399f, -0.05466026f, -0.02578674f, 0.04604556f, -0.04065769f, 0.02397541f, 0.03279671f, -0.00293441f, 
    0.01843929f, -0.03252164f, 0.01328025f, 0.00325613f, 0.03127367f, 0.02805854f, -0.01569089f, 0.03587036f, 
    0.32967436f, -0.13012454f, 0.11740667f, -0.07391088f, 0.02377265f, -0.05779131f, -0.00624899f, 0.08375993f, 
    0.04660315f, -0.03021000f, -0.04058029f, -0.10245182f, 0.00620581f, -0.01972068f, 0.02364057f, -0.01477604f, 
    -0.06319193f, -0.00678228f, -0.06002451f, -0.03412731f, -0.20538378f, 0.12899560f, 0.30496886f, -0.03321605f, 
    -0.20489216f, 0.07867457f, -0.06485075f, -0.03872151f, -0.07467081f, -0.07231393f, 0.05901185f, -0.03099286f, 
    -0.05195163f, 0.02578258f, 0.07600455f, 0.02885808f, -0.01520569f, -0.01181088f, -0.07187247f, -0.02108063f, 
    -0.60953289f, -0.04747625f, 0.02553014f, 0.06363434f, 0.23413113f, 0.02555974f, 0.03522940f, -0.01394992f, 
    0.03820043f, 0.14917772f, -0.03681976f, -0.05336478f, 0.07097510f, 0.09541097f, -0.06068536f, -0.05903021f, 
    0.17654441f, 0.04092190f, 0.04078601f, -0.15094762f, -0.37318990f, -0.02850896f, -0.11572326f, 0.15286826f, 
    0.03397159f, 0.12201650f, -0.03257425f, 0.05947625f, -0.07429916f, 0.02191193f, 0.03914752f, 0.00710925f, 
    -0.02132980f, -0.04680504f, 0.00842130f, 0.00977430f, -0.00674877f, -0.06488285f, -0.05988982f, -0.00400282f, 
    0.29922011f, -0.11853375f, 0.01903279f, 0.02264236f, -0.03979031f, -0.05410549f, -0.06302631f, -0.12445987f, 
    -0.02313314f, 0.02687702f, -0.09821956f, 0.01612560f, 0.03453066f, 0.01523435f, 0.07674762f, -0.22516422f, 
    0.04187797f, -0.12387022f, -0.00140403f, -0.17667025f, 0.09162477f, 0.32141811f, -0.04166207f, -0.13327301f, 
    -0.15332021f, -0.00513754f, -0.06600093f, 0.07328769f, -0.08161836f, 0.02461418f, 0.00925990f, -0.01556791f, 
    -0.07026673f, 0.02392892f, 0.06607141f, -0.08033243f, 0.00937725f, -0.00626247f, -0.11444599f, -0.00517854f, 
    -0.08108413f, -0.22571841f, 0.11286805f, 0.07121662f, -0.00533535f, -0.11695156f, -0.06042595f, 0.05021571f, 
    -0.05218190f, 0.04495549f, -0.00220067f, 0.04999274f, -0.08607441f, -0.11422015f, -0.01193227f, -0.00948311f, 
    -0.05663006f, 0.00984601f, 0.08478642f, 0.06585103f, -0.02585721f, -0.08391099f, -0.02213700f, -0.01974012f, 
    -0.05636776f, 0.06338566f, -0.03889100f, 0.04942785f, 0.02417341f, -0.04146383f, -0.03550773f, -0.08985057f, 
    0.07612307f, -0.00792539f, 0.03087914f, -0.04061929f, -0.00181104f, -0.00866493f, -0.10106885f, 0.03454612f, 
    0.04041429f, -0.13314754f, 0.09099806f, -0.02345825f, 0.25762385f, -0.01516011f, 0.05827552f, -0.13716432f, 
    0.13970572f, 0.10898484f, 0.07981746f, 0.03690812f, -0.03345893f, 0.02538089f, -0.00239411f, -0.06535916f, 
    0.03058799f, -0.08080658f, 0.07759794f, 0.08027176f, -0.01978723f, 0.06387907f, 0.16042931f, 0.07156479f, 
    -0.04977087f, 0.02242863f, 0.05602749f, 0.01244811f, -0.02834985f, -0.01786903f, 0.07048760f, 0.01504758f, 
    -0.03177873f, 0.03262400f, -0.05737732f, -0.07578570f, 0.08934014f, 0.02700135f, -0.00633825f, 0.08143914f, 
    -0.20090370f, 0.01751258f, 0.04364160f, -0.09766556f, -0.07344638f, -0.01819959f, 0.01161508f, 0.03019688f, 
    -0.03285619f, -0.02216766f, -0.01185982f, 0.06968391f, 0.05781569f, -0.00269703f, -0.02637119f, -0.05948320f, 
    0.03992205f, -0.07725434f, -0.02599778f, 0.01256174f, -0.00577367f, 0.13129535f, -0.16051246f, 0.13269924f, 
    0.06979901f, 0.08704724f, -0.04964763f, -0.02557063f, 0.05026795f, 0.10064135f, -0.01741388f, 0.01534750f, 
    -0.03314601f, -0.02066566f, -0.04280304f, 0.05790571f, -0.04806700f, 0.02799136f, 0.08322329f, -0.14181660f, 
    -0.53437990f, -0.06402795f, 0.00539884f, -0.09183235f, 0.02865475f, 0.00161708f, -0.03193875f, -0.01058492f, 
    -0.02480320f, -0.08675676f, -0.04563768f, 0.00761063f, -0.03265582f, -0.03461580f, 0.02669692f, 0.05711956f, 
    0.02628400f, -0.03573881f, 0.03077457f, -0.11521859f, -0.05329406f, 0.03050146f, 0.01161036f, 0.02069885f, 
    0.08153845f, 0.07568894f, -0.00051933f, -0.02411522f, 0.07908794f, -0.00966610f, 0.06843954f, 0.04222159f, 
    -0.05263800f, 0.00962785f, -0.00080620f, -0.09063464f, -0.02921147f, -0.02354525f, -0.04237342f, 0.03706356f, 
    -0.18836777f, 0.13126275f, -0.15097301f, -0.10415517f, -0.32391897f, -0.00210644f, -0.08844779f, -0.09526755f, 
    -0.00565835f, 0.04524364f, -0.11517870f, -0.05633385f, 0.07176080f, -0.00701110f, 0.01362320f, -0.04490915f, 
    0.01227776f, 0.12182105f, -0.03799016f, -0.08042840f, 0.06547027f, -0.02244493f, -0.15961343f, 0.07835832f, 
    0.14656870f, 0.06012752f, 0.06728002f, 0.03137120f, -0.04025844f, -0.02992106f, -0.04944810f, -0.06940329f, 
    0.12324538f, -0.02009990f, -0.06358684f, 0.02562377f, 0.00971662f, -0.10242745f, 0.05565687f, -0.02027044f, 
    -0.17434694f, -0.04509743f, -0.13529684f, 0.13006951f, -0.03794243f, 0.11153818f, -0.03407371f, -0.00467868f, 
    0.06028620f, 0.04610742f, 0.01289084f, -0.05065639f, -0.00054276f, -0.01063298f, 0.03292532f, 0.04340047f, 
    0.07395547f, -0.02940952f, -0.05403614f, -0.02018584f, 0.08063427f, 0.31647831f, -0.06522400f, -0.27295694f, 
    -0.16243389f, -0.06100058f, -0.01547170f, -0.03140115f, -0.05999175f, -0.06729717f, 0.01887190f, 0.11115088f, 
    -0.10731301f, 0.05077753f, 0.07424764f, 0.02617016f, 0.05804615f, -0.03815334f, 0.01900253f, -0.02337963f, 
    -0.22508101f, -0.23819929f, -0.05247418f, 0.08598195f, 0.14076714f, 0.09732450f, -0.02746293f, 0.10538883f, 
    -0.03648013f, 0.00254630f, -0.01366618f, -0.01492143f, 0.01993413f, 0.09826370f, 0.00951690f, 0.02594604f, 
    0.05767643f, 0.02839426f, 0.08693063f, -0.02408786f, -0.22428800f, -0.26992485f, 0.15617180f, 0.18707724f, 
    -0.00630939f, -0.09553288f, -0.03379285f, -0.00613964f, -0.06567410f, 0.00837358f, 0.05383500f, 0.07037924f, 
    -0.05999979f, -0.03795234f, 0.12326026f, -0.05334205f, -0.17096518f, 0.06959049f, -0.01764069f, 0.04947585f, 
    -0.16635405f, 0.02924679f, -0.06022124f, -0.06355894f, 0.15820229f, -0.03125821f, -0.00201016f, -0.00885434f, 
    0.06079504f, -0.07934580f, 0.06785604f, -0.04484767f, -0.03924282f, 0.05836800f, -0.02240134f, 0.03770613f, 
    0.02773972f, -0.03430875f, 0.01524827f, 0.02456703f, -0.01892302f, 0.20544532f, -0.25219840f, -0.30479494f, 
    0.06375264f, -0.00276660f, -0.04670588f, -0.02673294f, 0.05613327f, -0.09816307f, 0.02235129f, -0.01900625f, 
    -0.03350818f, 0.03834337f, 0.00375706f, 0.03248451f, 0.00090239f, -0.05513468f, 0.03079486f, 0.00756745f, 
    0.06617592f, -0.03988982f, 0.01721775f, 0.05999667f, -0.03585269f, 0.09479111f, 0.05972248f, 0.01824823f, 
    0.04774076f, -0.00709576f, 0.11661679f, 0.07713342f, 0.00121470f, -0.03710182f, 0.07699721f, -0.02174356f, 
    -0.02627073f, 0.01296313f, 0.05251332f, 0.10559488f, -0.26996040f, 0.10061257f, 0.04112213f, 0.04012207f, 
    -0.02252266f, 0.08797051f, 0.00130686f, 0.14319229f, -0.05321056f, -0.00703528f, 0.06889396f, 0.02597789f, 
    -0.05393524f, 0.01150525f, -0.00303308f, 0.06506083f, 0.01210857f, -0.08452114f, -0.07699466f, -0.03933917f, 
    -0.26299676f, -0.13903432f, 0.25061136f, -0.10771134f, 0.01232409f, 0.01304891f, 0.03550345f, 0.01693728f, 
    -0.05014911f, 0.17973568f, 0.02492404f, -0.03173148f, -0.09371462f, -0.14209041f, 0.09525988f, -0.03325047f, 
    -0.10831063f, -0.01522241f, -0.00222717f, -0.01682492f, -0.45440784f, 0.01378848f, -0.00771806f, 0.10341447f, 
    0.11951212f, 0.01992894f, -0.02603787f, -0.02305006f, 0.10703005f, 0.03393354f, -0.00018108f, -0.02492568f, 
    0.07488596f, 0.10495894f, 0.02174053f, 0.02229175f, 0.03423207f, 0.05401720f, 0.05500897f, 0.02906594f, 
    -0.71559477f, 0.11876712f, 0.15497173f, 0.12747997f, 0.15262991f, 0.12046803f, -0.07314769f, -0.03296640f, 
    0.01672910f, 0.11151147f, -0.08073919f, 0.01241318f, 0.04348890f, 0.09555987f, 0.06278124f, 0.00917427f, 
    0.08229068f, 0.01029622f, 0.13171208f, -0.14030254f, -0.06674756f, -0.06074876f, 0.13624123f, -0.14758532f, 
    -0.13503015f, -0.05015888f, 0.05674751f, -0.08188505f, 0.09174087f, 0.03114042f, -0.07990131f, -0.12718953f, 
    0.00629508f, 0.05244248f, 0.07787964f, -0.11759423f, 0.05419477f, 0.01779273f, -0.03403636f, 0.08307375f, 
    -0.10180503f, -0.03444120f, 0.13536969f, 0.12903595f, -0.06560487f, 0.03695124f, 0.01547604f, -0.04276587f, 
    -0.03072272f, -0.05629585f, 0.08633962f, 0.09293775f, 0.03937747f, 0.02679498f, -0.08604119f, 0.01241257f, 
    -0.02830812f, 0.12782976f, 0.02770587f, -0.00527300f, 0.15088214f, -0.01590194f, 0.00463052f, 0.04432816f, 
    0.07184134f, -0.07890907f, 0.03345401f, 0.03035095f, 0.00916084f, -0.05817659f, 0.02490573f, 0.00290160f, 
    -0.00503060f, 0.02533230f, 0.08446521f, -0.05938588f, -0.05842516f, 0.07652676f, 0.03264720f, 0.01760435f, 
    -0.03325843f, 0.00823284f, 0.01454823f, -0.08276196f, -0.04473996f, 0.04031760f, 0.02704566f, 0.04627118f, 
    -0.00945448f, 0.08083316f, 0.08325092f, 0.05594215f, -0.03319275f, 0.00332671f, 0.10374642f, -0.00535810f, 
    0.02063700f, 0.02772033f, 0.10216795f, 0.02542932f, -0.15886933f, -0.19290525f, 0.07121321f, 0.04587041f, 
    -0.06988408f, -0.19066642f, -0.04398631f, -0.02138343f, -0.06241139f, 0.03842860f, -0.04533658f, 0.06115023f, 
    -0.02844240f, -0.06054654f, 0.03726568f, 0.00785210f, 0.02221534f, 0.08543340f, -0.10682040f, 0.11713459f, 
    -0.10065050f, -0.12759964f, 0.06749739f, 0.02070520f, 0.16196935f, -0.00254826f, -0.04034244f, 0.05007640f, 
    -0.02398046f, 0.05332380f, -0.04754795f, -0.08053225f, 0.00286531f, 0.04563304f, -0.00643666f, -0.00454749f, 
    -0.03365222f, 0.07974406f, 0.03828758f, -0.07467341f, -0.28631967f, -0.25216818f, 0.11688387f, 0.16033344f, 
    0.00777809f, -0.08998435f, 0.06204972f, -0.03760960f, -0.03356686f, -0.04034860f, 0.03854319f, 0.00253790f, 
    0.01559419f, -0.04597443f, 0.05495421f, -0.12705603f, -0.02057345f, -0.00556628f, 0.05991939f, 0.05468603f, 
    -0.19780402f, 0.13585785f, -0.06989436f, -0.06135957f, 0.14491262f, 0.01530029f, -0.03033642f, -0.02942816f, 
    0.04493481f, 0.11651963f, -0.03105573f, -0.01994376f, -0.03887607f, -0.05291610f, -0.10603195f, -0.08513435f, 
    0.00041067f, -0.03310354f, -0.02930905f, -0.06294002f, -0.03138788f, 0.12620553f, 0.02960441f, 0.09320034f, 
    0.03297738f, 0.11067007f, -0.00650939f, 0.01558683f, 0.09156888f, 0.09317430f, -0.00514745f, 0.03968636f, 
    -0.03558607f, -0.04987055f, -0.00117475f, -0.00655375f, -0.06942032f, -0.01197465f, 0.04637276f, -0.03482364f, 
    0.42780423f, 0.06154633f, -0.03000593f, -0.07794031f, 0.08321229f, -0.01896586f, -0.05430800f, 0.05564414f, 
    0.07908688f, 0.02181012f, -0.04530453f, -0.03307258f, 0.11418760f, 0.02977276f, -0.03935131f, -0.02988187f, 
    -0.00602847f, -0.01129507f, -0.03122006f, 0.07160879f, 0.02905848f, -0.27676210f, -0.08288481f, 0.05274356f, 
    0.08687209f, -0.06307176f, 0.00005619f, -0.13034067f, -0.05848885f, -0.03652805f, 0.02913669f, 0.02337263f, 
    -0.00983535f, 0.02129579f, 0.00691703f, -0.07015017f, -0.05117198f, -0.08613857f, 0.03008571f, -0.01145711f, 
    -0.21861947f, 0.07525188f, 0.09808005f, -0.06846831f, -0.05508097f, 0.08271569f, -0.01095139f, 0.03323088f, 
    -0.02039628f, 0.02314981f, -0.00681522f, 0.00048816f, -0.06506610f, 0.00472944f, 0.03028385f, 0.01317572f, 
    0.00466196f, -0.04229581f, 0.00562093f, -0.00608905f, 0.02453626f, 0.05653019f, 0.01933451f, -0.04039814f, 
    0.05463167f, 0.01774698f, -0.09918050f, 0.01110606f, 0.12130811f, 0.02338698f, 0.00641627f, 0.05927926f, 
    0.06263242f, 0.01709296f, -0.07437608f, 0.05764120f, -0.01831996f, 0.00709835f, 0.03536533f, 0.00662490f, 
    -0.03218749f, 0.15613200f, -0.21471356f, 0.18921706f, -0.31280348f, -0.12011489f, -0.03578205f, 0.07370280f, 
    -0.07251780f, -0.03195586f, 0.03377149f, 0.00004900f, -0.01639527f, 0.06466099f, -0.01574457f, -0.01899138f, 
    0.04810371f, 0.09142041f, -0.02588401f, 0.11875840f, -0.29562333f, -0.16746369f, 0.08502587f, 0.06413874f, 
    0.07010570f, -0.03740311f, -0.00029095f, 0.05200233f, 0.00925543f, -0.02587140f, 0.07397457f, 0.00565657f, 
    -0.04755150f, -0.06984562f, -0.01295084f, 0.01506576f, -0.00685456f, -0.04205975f, 0.04625437f, -0.01077154f, 
    0.10395698f, 0.28964266f, -0.21692650f, -0.05116835f, 0.02601975f, 0.11090643f, -0.05410845f, 0.06186886f, 
    0.08631475f, -0.00697307f, -0.05898509f, 0.04649979f, 0.01430453f, 0.00553358f, -0.06510798f, -0.01001885f, 
    0.03690737f, -0.16903348f, -0.03289584f, -0.02167602f, 0.16343519f, -0.14417760f, -0.05200634f, -0.08018149f, 
    -0.18929455f, -0.02445506f, 0.00363425f, 0.05706226f, -0.06548617f, -0.09367274f, 0.07163524f, -0.07470910f, 
    -0.04009637f, -0.09577727f, 0.00125585f, -0.07567935f, 0.09169418f, -0.09670812f, 0.02682133f, -0.09982301f, 
    -0.14542259f, 0.12028502f, -0.01699005f, 0.05341297f, -0.04801156f, 0.04311367f, 0.06100585f, 0.05116396f, 
    -0.09083632f, -0.11527405f, -0.00335215f, 0.04439918f, -0.01872632f, 0.05801361f, -0.00730752f, -0.02719460f, 
    -0.03016347f, 0.02020650f, -0.04107175f, 0.04107247f, 0.08633264f, 0.01091151f, -0.08879633f, 0.04837317f, 
    0.05948019f, -0.00998422f, -0.00082971f, 0.10378905f, -0.00241698f, 0.06465277f, 0.01782749f, 0.08261321f, 
    0.03116738f, 0.00047753f, -0.01315835f, -0.00223249f, 0.04372784f, -0.01158657f, -0.00484319f, -0.04256089f, 
    -0.00304961f, -0.13765825f, 0.11961097f, 0.10593500f, -0.01368266f, -0.08532463f, 0.03536108f, 0.01493133f, 
    -0.04442902f, -0.07646362f, 0.02535530f, -0.03253329f, 0.04866343f, 0.03823883f, 0.05794267f, -0.13590024f, 
    -0.04224678f, 0.03008871f, 0.04488639f, 0.02580674f, 0.02382958f, 0.13213480f, -0.00977882f, 0.10691321f, 
    -0.08979376f, -0.02704973f, -0.06720819f, -0.05995133f, 0.04674808f, -0.12601598f, 0.03624136f, -0.00994974f, 
    0.02246977f, 0.00216362f, 0.13471664f, 0.09677572f, 0.01940259f, -0.01491184f, 0.08391616f, 0.01490870f, 
    0.30634648f, -0.21841113f, -0.12391570f, 0.04001398f, -0.13165082f, 0.05887838f, -0.02873702f, 0.06155982f, 
    -0.05274622f, 0.07168828f, -0.01217565f, 0.02058632f, 0.02929620f, 0.01928076f, 0.06146738f, 0.02574291f, 
    -0.00673990f, 0.01692013f, -0.03482142f, -0.06770310f, -0.04361541f, 0.06745863f, 0.00650748f, -0.14450577f, 
    0.10245244f, 0.01117777f, 0.01680289f, -0.02014598f, 0.08331905f, -0.02744861f, -0.00371321f, -0.00195939f, 
    -0.00194152f, -0.04853230f, -0.02205081f, -0.05111355f, 0.08073878f, -0.10960934f, 0.02702565f, 0.01740482f, 
    0.22777477f, -0.16073766f, -0.01102870f, -0.03076829f, -0.13414800f, 0.01545530f, 0.11698631f, -0.00367387f, 
    -0.07111402f, 0.03384282f, -0.04834979f, 0.01460027f, 0.08216939f, -0.00209440f, 0.04079949f, -0.06459812f, 
    0.05473755f, -0.02463421f, 0.07171897f, 0.13537347f, 0.15918700f, 0.11090863f, -0.08268008f, 0.03696020f, 
    0.04377825f, 0.01149493f, -0.03414423f, 0.12860131f, 0.02589458f, 0.00964979f, -0.04441166f, -0.01019675f, 
    -0.02001882f, 0.02665692f, 0.03217338f, -0.01973063f, 0.02863350f, -0.02732394f, -0.01845410f, -0.04402637f, 
    0.05520704f, -0.05568567f, 0.12082189f, -0.13004528f, -0.04844119f, 0.11246672f, -0.04219326f, -0.13142590f, 
    -0.02558652f, -0.09082605f, 0.06994338f, -0.04755789f, -0.07335474f, 0.06233071f, -0.03219758f, -0.05172490f, 
    0.00147827f, -0.03396136f, 0.05300144f, -0.00798116f, -0.13333520f, -0.07486563f, -0.11859343f, 0.00813351f, 
    0.09965565f, -0.01019233f, -0.07744033f, 0.06704544f, 0.07658041f, 0.02951505f, -0.12244125f, 0.02563223f, 
    -0.09406203f, -0.00965966f, -0.01734266f, -0.03310723f, 0.03835516f, -0.16068953f, 0.02269887f, -0.08154420f, 
    -0.02108781f, -0.15741540f, 0.06930201f, 0.12606558f, 0.05289552f, 0.05600361f, -0.03360417f, 0.07021501f, 
    -0.09040760f, 0.01882065f, 0.05572676f, 0.06990357f, -0.05474385f, 0.03634777f, 0.05174720f, 0.02741699f, 
    -0.04466094f, 0.05519992f, 0.08575780f, 0.04701298f, -0.17967521f, 0.04039338f, 0.03725145f, -0.04565119f, 
    0.09507624f, 0.00464711f, 0.00216022f, -0.05278087f, 0.03640684f, 0.00387485f, 0.01783882f, 0.03576008f, 
    -0.05589183f, 0.03742655f, -0.00746201f, 0.04079422f, 0.00021176f, 0.01390679f, 0.08469543f, 0.05630812f, 
    -0.00196473f, -0.28777966f, 0.17230219f, 0.02389405f, -0.03393112f, -0.10287799f, 0.02015209f, 0.04691098f, 
    -0.07011225f, 0.05510402f, 0.06874027f, 0.02032764f, 0.04178875f, -0.10082883f, 0.00055054f, -0.00165344f, 
    -0.04813045f, -0.02702983f, -0.00671452f, -0.00828977f, -0.06565461f, 0.08688326f, 0.13366024f, -0.12238859f, 
    -0.06748042f, -0.09091633f, 0.09933970f, -0.07009465f, 0.08621892f, 0.08298054f, 0.05256465f, -0.10900674f, 
    0.07300438f, -0.03783532f, 0.09811639f, 0.01457774f, 0.09531465f, -0.08865827f, 0.07973059f, 0.03237840f, 
    0.02827747f, 0.06498265f, -0.02224641f, 0.03290318f, -0.14033738f, 0.04872351f, 0.05978506f, -0.06075276f, 
    -0.03536358f, 0.08264183f, -0.03658579f, 0.00444131f, -0.01889443f, -0.04468844f, 0.07044014f, 0.06481674f, 
    -0.02648761f, 0.06229625f, 0.07283691f, 0.02224972f, -0.08550802f, 0.00976712f, 0.09727322f, 0.04719829f, 
    0.02725319f, -0.07119550f, -0.16587217f, 0.02183547f, -0.02802181f, 0.03402902f, 0.00312464f, 0.00064796f, 
    -0.11190441f, -0.00173792f, 0.03747023f, -0.07940435f, 0.04074982f, -0.09703758f, 0.03855354f, 0.03242938f, 
    -0.22313900f, -0.13166933f, 0.01059220f, 0.08783834f, 0.07327463f, 0.04381686f, -0.11506109f, 0.07023041f, 
    -0.01926915f, 0.11725675f, 0.01615509f, -0.10477841f, -0.00774891f, 0.05334909f, 0.03909900f, -0.08431299f, 
    0.05253112f, -0.21179043f, -0.12113993f, 0.01315080f, 0.05415168f, 0.10249367f, 0.09917402f, -0.01411319f, 
    0.08383615f, -0.00663645f, -0.01235412f, -0.03010190f, 0.04603146f, 0.05868394f, -0.02401882f, -0.04683824f, 
    0.02149486f, 0.05714062f, 0.01167053f, 0.00397345f, -0.02379260f, -0.00003000f, -0.30995330f, 0.09305777f, 
    0.09376650f, 0.01067433f, 0.10491781f, 0.01978697f, 0.01622600f, -0.02882076f, -0.07814839f, -0.12116164f, 
    -0.02086447f, 0.03661562f, -0.01519152f, 0.06929116f, -0.13867372f, -0.03139652f, -0.02948161f, 0.02863289f, 
    -0.10102240f, 0.10884702f, 0.03155265f, 0.04963402f, 0.07973826f, -0.03666916f, 0.04588803f, 0.06188158f, 
    -0.09910422f, -0.08942015f, 0.00018766f, -0.03855088f, 0.02684695f, -0.02149555f, -0.04056811f, 0.05451547f, 
    0.10954639f, 0.06293616f, 0.08394910f, -0.09041824f, -0.09148388f, 0.01798137f, 0.09669381f, -0.05437841f, 
    -0.17084464f, -0.03479970f, 0.07601564f, 0.16220808f, -0.05238666f, 0.01879700f, 0.09465723f, -0.03785413f, 
    0.06243180f, 0.10158834f, -0.01690642f, -0.01900373f, -0.05307798f, 0.06823784f, -0.07145948f, 0.00370625f, 
    0.04906822f, -0.00564565f, 0.01393152f, -0.01774182f, -0.04427643f, -0.12714186f, -0.15265600f, 0.02672258f, 
    0.01569816f, 0.04378572f, 0.15196005f, 0.02361788f, 0.05257184f, 0.00274949f, 0.02411140f, 0.00285965f, 
    0.09914331f, 0.07446434f, -0.03375344f, -0.04081367f, -0.07642776f, -0.17442901f, -0.06675128f, -0.09387966f, 
    -0.34448740f, 0.02375569f, -0.25009280f, -0.18835989f, -0.14533006f, 0.11538277f, -0.00065707f, 0.05220537f, 
    -0.08228464f, -0.15094987f, -0.00691161f, 0.06522011f, -0.08005842f, -0.05343785f, -0.05788184f, 0.07557150f, 
    -0.04566105f, -0.01847186f, 0.04210894f, 0.02981307f, -0.05552202f, 0.09753323f, -0.04624258f, -0.06902733f, 
    -0.07667071f, 0.00149557f, -0.06902450f, 0.00920594f, -0.00848816f, -0.04272528f, 0.02610878f, 0.06842139f, 
    -0.00696995f, -0.06519369f, -0.01125919f, -0.02181427f, -0.06189619f, 0.02129299f, 0.01377250f, -0.12065661f, 
    0.18270443f, 0.04820498f, 0.06858873f, -0.03281145f, -0.03377196f, 0.03787248f, 0.02963060f, 0.02562553f, 
    -0.04262688f, 0.04109425f, -0.04287972f, -0.03468980f, -0.07932371f, -0.02572307f, -0.16502833f, 0.12799132f, 
    -0.03183760f, 0.07785656f, -0.00125537f, 0.08698538f, -0.16911858f, -0.07772542f, 0.06885747f, 0.15406232f, 
    -0.41857037f, 0.04762883f, -0.02781247f, -0.07450517f, -0.06768605f, -0.01775228f, -0.00396511f, 0.00378729f, 
    0.05528384f, 0.08948971f, 0.02931412f, -0.10654596f, -0.03785687f, -0.04413961f, -0.03879952f, -0.13978395f, 
    0.02934495f, -0.00814467f, 0.00951899f, 0.11741249f, -0.14864022f, -0.05560078f, 0.01720960f, -0.14029618f, 
    0.02335347f, -0.00550366f, 0.03616208f, -0.05348004f, 0.09278030f, 0.09810857f, 0.04603019f, 0.00689367f, 
    0.00668596f, 0.06965525f, 0.02633264f, 0.04979707f, -0.28340068f, 0.04888083f, 0.00609208f, -0.03506366f, 
    -0.08346010f, 0.01485710f, 0.06741953f, -0.00695416f, 0.00455379f, -0.03229297f, -0.04930290f, 0.08952279f, 
    -0.05113585f, 0.02442671f, -0.07546454f, 0.03222536f, 0.02916423f, -0.05982315f, 0.01418175f, -0.03061028f, 
    -0.19020049f, -0.10322580f, -0.17479630f, 0.05074771f, -0.02696273f, 0.14193760f, 0.12806749f, 0.10899563f, 
    -0.08161391f, 0.13452938f, -0.03435388f, 0.05500813f, 0.08259906f, 0.02667073f, -0.02043168f, -0.03659550f, 
    0.02515162f, 0.02431464f, -0.05342824f, 0.02385337f, 0.06745619f, -0.06907666f, 0.03772528f, 0.11233675f, 
    0.21030229f, -0.01985827f, -0.05501743f, 0.03017561f, -0.02250024f, -0.02539875f, -0.05108502f, 0.00750972f, 
    0.01154259f, 0.06028579f, 0.02849882f, 0.04842718f, -0.10314135f, -0.00395315f, -0.00824128f, -0.00772452f, 
    -0.06250726f, 0.01355759f, 0.14797467f, 0.05684464f, -0.06742439f, -0.02171911f, -0.01456996f, 0.03066451f, 
    0.02937919f, 0.06697971f, 0.05216322f, 0.01574899f, -0.06304737f, 0.00347577f, -0.10718625f, -0.02349772f, 
    -0.05353038f, -0.06981011f, 0.00347575f, 0.00474774f, -0.48430070f, -0.16207416f, -0.26195702f, -0.13138756f, 
    0.02213898f, 0.04396740f, 0.13348739f, -0.09363811f, 0.00966719f, -0.11797888f, 0.00454238f, 0.08656249f, 
    0.01553060f, 0.02132451f, -0.06955736f, -0.04424789f, 0.05258818f, 0.01845632f, -0.04552980f, 0.07911307f, 
    0.04326758f, -0.10636049f, -0.01906816f, -0.11192521f, -0.09978645f, 0.00207159f, 0.00777496f, 0.00360967f, 
    0.04746315f, -0.04784025f, -0.02741506f, 0.02727903f, 0.03452805f, 0.04327564f, 0.10719863f, -0.01598736f, 
    -0.06444620f, 0.03699551f, -0.09733085f, 0.00130848f, -0.16679865f, -0.14739890f, -0.13296892f, -0.02094576f, 
    0.07479235f, -0.04778295f, -0.03195864f, 0.00306073f, 0.02129244f, 0.06705784f, 0.03087059f, 0.05495442f, 
    0.04611060f, 0.15760416f, 0.09115796f, 0.10988676f, 0.00262807f, -0.00660180f, -0.03605746f, -0.01293783f, 
    -0.24897249f, -0.25326279f, -0.22039434f, -0.02888372f, 0.11573610f, 0.04455705f, 0.06558028f, -0.12818158f, 
    0.00574386f, -0.11917502f, 0.05254963f, 0.01635381f, -0.09059470f, 0.02557526f, -0.01955354f, 0.04198438f, 
    -0.01565140f, -0.03048117f, -0.09651947f, 0.03087740f, -0.28730962f, 0.02418367f, 0.14357422f, -0.15700839f, 
    -0.08064170f, 0.15004200f, 0.00689963f, 0.12015786f, -0.00693518f, -0.02372271f, 0.01574582f, -0.06413776f, 
    -0.01554109f, 0.00211559f, -0.02351085f, 0.04502180f, 0.03290731f, 0.08797772f, -0.08828239f, 0.05869395f, 
    0.17739938f, 0.15470064f, 0.02226750f, -0.05803167f, 0.00084089f, -0.00023611f, -0.06423043f, -0.03036964f, 
    -0.07617524f, -0.03676968f, 0.09336407f, 0.03417680f, 0.02536995f, -0.00269679f, 0.07787138f, 0.03775470f, 
    0.02282592f, -0.03680735f, 0.11790488f, -0.02335728f, -0.15229405f, -0.13801272f, 0.09118643f, 0.08327178f, 
    -0.19243456f, 0.06227478f, -0.04205357f, 0.01783378f, 0.08497030f, -0.19207782f, -0.02513833f, -0.05444941f, 
    -0.01970530f, 0.03756168f, 0.04853577f, -0.02135617f, 0.04613111f, 0.01252447f, 0.00442393f, -0.12761676f, 
    -0.26841614f, 0.19333047f, 0.00932686f, -0.09358121f, -0.01441658f, -0.04174210f, -0.01023496f, 0.09406915f, 
    -0.06650031f, -0.09003483f, 0.12570159f, -0.00361183f, -0.03370431f, -0.10465680f, -0.02159270f, -0.00196789f, 
    -0.08686958f, -0.06493784f, -0.02061858f, -0.00068413f, 0.04036634f, 0.03174398f, -0.03440834f, 0.02455850f, 
    0.15870175f, -0.09145219f, -0.04353892f, 0.01694874f, 0.04411220f, 0.09183326f, -0.00317421f, -0.12651514f, 
    0.02056646f, 0.08787406f, 0.10420971f, 0.03831560f, 0.11188995f, -0.03541248f, -0.06202213f, -0.00815723f, 
    -0.22648397f, 0.29734603f, -0.15252440f, 0.04953717f, -0.04120059f, 0.07641033f, -0.06126637f, 0.01389325f, 
    -0.11158858f, 0.07762901f, -0.01323858f, 0.05722661f, -0.03857684f, -0.07486457f, -0.09249749f, 0.00222451f, 
    -0.05818062f, 0.02214551f, 0.04195422f, -0.03876473f, -0.38221413f, -0.00043240f, 0.08755199f, 0.06660822f, 
    -0.12723719f, 0.07090380f, -0.02178427f, -0.03042474f, -0.08535480f, 0.04233833f, 0.06783849f, 0.02682011f, 
    0.09888602f, -0.03403084f, -0.02188373f, 0.03516808f, 0.01823009f, -0.03312108f, 0.02167897f, -0.02069490f, 
    -0.02155138f, 0.04186106f, -0.03758417f, 0.07951444f, 0.13028604f, 0.03834921f, -0.01449030f, -0.07955246f, 
    -0.03400889f, 0.02673759f, -0.02745587f, 0.10174619f, 0.11713964f, 0.10496776f, -0.01598619f, -0.04778109f, 
    -0.03902955f, 0.00366303f, -0.17246915f, 0.04723953f, -0.08121581f, -0.01963957f, 0.03917168f, 0.15883511f, 
    -0.13102777f, -0.09396797f, -0.04070132f, -0.03586300f, -0.01567892f, 0.10524196f, 0.11737206f, 0.09112605f, 
    0.08541159f, -0.01934722f, -0.03285613f, -0.02594092f, -0.04977694f, -0.02619086f, 0.04717693f, -0.04594667f, 
    0.01699394f, -0.01190910f, 0.06839845f, 0.08837545f, -0.01199134f, -0.09403391f, 0.09285381f, -0.01112544f, 
    0.02503145f, 0.05592220f, 0.05070981f, -0.17590730f, 0.11990994f, -0.00289854f, 0.01073544f, -0.02168216f, 
    0.16268478f, -0.08609408f, -0.07194805f, 0.03025616f, -0.18515533f, 0.06565373f, -0.29175758f, -0.14423798f, 
    -0.01061107f, 0.05002702f, 0.11378530f, 0.02475489f, -0.06775551f, -0.05777221f, 0.05019335f, -0.02779555f, 
    0.05374831f, -0.09758797f, 0.02300088f, 0.04441242f, 0.06435016f, -0.06768045f, 0.00157290f, -0.02321015f, 
    -0.17068291f, 0.22354184f, -0.24437666f, -0.08530959f, -0.04011003f, 0.01035375f, 0.04290760f, 0.05387321f, 
    -0.02290645f, -0.13991137f, -0.00117751f, -0.03946415f, -0.11908814f, -0.05152920f, -0.02764586f, -0.04998919f, 
    -0.00447324f, 0.04842074f, 0.02477418f, -0.01389476f, -0.15631589f, -0.05633477f, 0.03651337f, 0.15428725f, 
    -0.15066846f, -0.12532365f, -0.00086591f, 0.05415355f, -0.03924124f, 0.11649784f, 0.00896476f, -0.00787199f, 
    -0.06139112f, -0.03293857f, -0.00732784f, 0.01402325f, 0.00272206f, -0.08896447f, 0.08950837f, 0.01023721f, 
    -0.06636389f, -0.03734179f, -0.03923007f, 0.10142852f, 0.13443421f, 0.04045554f, -0.20321973f, 0.00780339f, 
    0.05369750f, 0.05354703f, -0.01796779f, -0.07088338f, 0.01237898f, -0.03964300f, 0.05151261f, -0.10411980f, 
    -0.04380622f, -0.08511078f, -0.04822145f, -0.21868882f, 0.05326159f, 0.02282220f, -0.10114137f, 0.06809580f, 
    0.14740527f, 0.01224580f, -0.07365961f, -0.01506732f, 0.06765164f, 0.02348975f, -0.01846790f, -0.01893768f, 
    -0.06994749f, 0.17022848f, 0.07721523f, -0.03030830f, -0.00902376f, 0.04439072f, -0.07811502f, 0.02934738f, 
    -0.25966331f, -0.08841455f, 0.03131071f, -0.03461507f, -0.03948439f, -0.01504753f, 0.12574568f, -0.02917246f, 
    -0.07522675f, -0.11596152f, -0.03416063f, 0.02525314f, 0.12485065f, -0.03543973f, 0.02901099f, -0.01961351f, 
    0.06765617f, -0.03921165f, 0.00908031f, -0.07120438f, 0.02468948f, -0.05514747f, 0.01456862f, 0.11411051f, 
    0.11473309f, -0.02473562f, 0.01340070f, -0.02033169f, -0.01361323f, -0.01100110f, -0.10636767f, -0.15485421f, 
    -0.02776157f, 0.03338852f, 0.10991655f, 0.07069547f, -0.00639372f, -0.10215195f, 0.02461407f, 0.01628367f, 
    -0.26331517f, -0.05844062f, -0.07932472f, 0.02040805f, 0.04802780f, 0.02973628f, 0.08573061f, 0.09136450f, 
    0.02027083f, -0.09524904f, 0.10907043f, 0.07379617f, -0.00874158f, -0.01421478f, -0.02311899f, 0.00439469f, 
    -0.06348400f, -0.01438886f, -0.04880428f, 0.06565681f, 0.16235380f, 0.02597582f, -0.00559709f, 0.17928024f, 
    -0.00039200f, -0.12484669f, -0.01039168f, 0.06736203f, -0.01788771f, 0.02502085f, -0.11591804f, -0.07286539f, 
    0.04076370f, 0.10832026f, 0.02838899f, 0.05345659f, -0.00173174f, -0.00415748f, 0.00858359f, -0.01625639f, 
    -0.45021042f, -0.31290591f, -0.17591880f, -0.03272634f, -0.10415222f, 0.05739549f, 0.11908092f, 0.02460878f, 
    -0.04048422f, -0.12369749f, 0.01706957f, -0.02282802f, 0.05820698f, -0.06219633f, -0.02073205f, 0.09435055f, 
    -0.02593243f, 0.02329248f, -0.12291383f, 0.08202830f, -0.29726979f, -0.14100437f, -0.14920682f, -0.05307217f, 
    -0.01493895f, 0.05088802f, 0.11359613f, -0.01968970f, -0.00412286f, -0.01420253f, 0.03382738f, 0.06511896f, 
    -0.02876129f, 0.03800356f, 0.01067989f, -0.01341665f, 0.01255626f, 0.06725924f, -0.06388005f, -0.03994224f, 
    -0.04094058f, 0.01817941f, 0.18062943f, 0.07512555f, -0.25825059f, 0.07901226f, -0.05184009f, -0.06291065f, 
    -0.00531814f, -0.04500303f, -0.00983429f, 0.00331685f, -0.03738646f, -0.05628759f, 0.00288027f, -0.02849553f, 
    0.03510306f, 0.12207101f, 0.06841931f, -0.03295343f, 0.10332954f, 0.03956371f, 0.05677189f, 0.09719026f, 
    -0.05183449f, -0.04878199f, 0.08150690f, 0.06657874f, 0.06801785f, 0.00505059f, 0.02556647f, -0.07678753f, 
    -0.09261323f, 0.06350508f, -0.00509826f, -0.00148719f, 0.06630762f, 0.09053501f, -0.05356679f, 0.11993011f, 
    -0.23879643f, -0.14198862f, -0.04650459f, 0.05046223f, -0.05382378f, -0.04893881f, 0.03909674f, 0.02043888f, 
    0.00511759f, 0.02271185f, 0.05318747f, 0.04479777f, 0.06405915f, 0.05088813f, 0.01644779f, 0.03325659f, 
    -0.04555171f, -0.07816131f, 0.02659436f, 0.03155416f, 0.03775904f, -0.06320932f, 0.12864232f, 0.10508766f, 
    -0.13692123f, 0.07346208f, 0.08369058f, -0.00657510f, 0.03495034f, -0.04316135f, -0.08396572f, -0.00418139f, 
    0.01455977f, 0.00577156f, 0.08577054f, -0.00444280f, -0.00289666f, 0.07802957f, 0.04497481f, -0.00485459f, 
    0.05328642f, -0.07153173f, -0.14571325f, -0.11047267f, 0.02834435f, 0.04351749f, -0.04614586f, -0.07917353f, 
    0.11050233f, 0.12582192f, 0.12533017f, 0.09423317f, 0.10518013f, -0.06843163f, -0.03345154f, 0.04261412f, 
    -0.06826376f, -0.06074835f, 0.09468511f, 0.03704084f, 0.07436650f, -0.04957972f, -0.01093563f, 0.05962441f, 
    -0.00619851f, -0.01089051f, 0.04261457f, 0.06577056f, -0.01065382f, 0.03114617f, -0.08080333f, -0.11675076f, 
    0.08129200f, 0.01013267f, 0.09030982f, -0.00262006f, -0.02036090f, -0.01085489f, 0.03189359f, 0.08716840f, 
    -0.26815572f, -0.06163519f, 0.19102061f, 0.06151593f, -0.20017497f, 0.03982733f, 0.00606631f, -0.02989823f, 
    -0.02864779f, -0.00138954f, 0.08170070f, -0.08471704f, -0.06710482f, -0.03500957f, -0.10023169f, -0.05501694f, 
    0.10320415f, 0.16211227f, -0.02880890f, 0.03031367f, -0.07936321f, 0.14086312f, 0.09581377f, 0.21006775f, 
    0.10592666f, -0.11960413f, -0.18889433f, 0.05867419f, -0.15579627f, 0.14070159f, 0.10251778f, -0.09647898f, 
    -0.03428661f, -0.02799379f, -0.12162846f, 0.12223534f, 0.04002545f, -0.22758032f, 0.11690275f, 0.08972869f, 
    -0.07112617f, 0.19622591f, -0.00649524f, 0.00844615f, 0.10112754f, -0.00893040f, -0.00865667f, 0.03155925f, 
    -0.02371066f, 0.06842710f, 0.08165625f, -0.09045433f, 0.02379525f, -0.03955404f, -0.01547766f, -0.10288006f, 
    0.09277771f, -0.14233989f, 0.03629808f, -0.05465940f, -0.03610065f, 0.04286019f, 0.07887904f, 0.11843251f, 
    -0.10378791f, 0.06266508f, -0.07013413f, 0.00441881f, -0.02849255f, -0.06916188f, 0.03234006f, -0.05307827f, 
    -0.07476721f, 0.01728652f, -0.01281754f, -0.05010314f, -0.00899570f, 0.10056008f, -0.01123016f, 0.09751434f, 
    0.23692699f, 0.10632446f, -0.00034115f, -0.07385109f, 0.00968701f, 0.09301965f, -0.09890194f, -0.01522865f, 
    -0.05464841f, 0.03584966f, -0.03194153f, -0.03936820f, 0.04759198f, 0.06620676f, 0.09202721f, 0.03166534f, 
    -0.04983548f, -0.01780806f, -0.12490574f, -0.02347062f, -0.06611774f, -0.16107766f, -0.01424474f, 0.05523872f, 
    0.17587185f, 0.06446767f, 0.02911036f, 0.06139592f, -0.00921633f, 0.03843156f, 0.05467767f, 0.00390301f, 
    0.08586913f, 0.03663418f, -0.04535702f, -0.14134902f, -0.05392900f, -0.05890322f, -0.05411319f, -0.01902313f, 
    0.07522771f, 0.19190253f, 0.08038852f, -0.06848104f, -0.04672366f, -0.02180051f, 0.12981227f, -0.03661552f, 
    -0.14210929f, 0.08238252f, -0.07868367f, 0.00274184f, -0.04507870f, 0.01436203f, -0.08418580f, -0.02856397f, 
    -0.01273296f, 0.05821486f, 0.04154020f, 0.10247689f, -0.25257316f, -0.02067801f, -0.17200491f, -0.07710987f, 
    -0.02622370f, 0.06211240f, -0.03351832f, 0.07595865f, -0.03212361f, 0.08253274f, 0.00637357f, 0.01071294f, 
    -0.03456392f, 0.01755584f, -0.05597792f, 0.03850345f, -0.06496743f, 0.01787305f, -0.00520592f, -0.03989327f, 
    -0.06651395f, 0.08477706f, 0.19645621f, 0.06316985f, -0.22683319f, 0.01951203f, 0.05366924f, 0.00903239f, 
    0.07053131f, 0.10563675f, -0.02516524f, 0.03274506f, 0.07281819f, -0.09110703f, -0.16514812f, -0.08671176f, 
    -0.00332358f, -0.11714643f, -0.04009920f, 0.09877675f, -0.05132106f, 0.04818086f, 0.12456688f, 0.03355319f, 
    -0.17117329f, -0.04090710f, -0.03143376f, -0.03754955f, -0.10060293f, 0.04063653f, 0.07100552f, -0.05007694f, 
    -0.05917091f, -0.01506348f, -0.08593609f, 0.02442775f, -0.01810432f, 0.09710466f, 0.08598175f, -0.06025595f, 
    0.04258756f, 0.03100881f, -0.08313300f, 0.18314709f, 0.18838051f, -0.02477624f, 0.00642139f, -0.01844573f, 
    0.08505722f, 0.07423733f, 0.11465763f, 0.03525659f, 0.02454752f, 0.11724931f, 0.16575286f, 0.07137038f, 
    0.09263295f, -0.08019709f, -0.04400707f, -0.19023877f, 0.07966682f, -0.06954943f, -0.05515773f, -0.14129220f, 
    -0.20662872f, 0.00186720f, 0.00698229f, 0.00732573f, -0.03325339f, 0.01594187f, 0.00294678f, 0.04461644f, 
    0.02063395f, -0.02235388f, -0.05082668f, 0.06180768f, -0.06150029f, 0.11506958f, -0.16252683f, 0.05034661f, 
    0.09942362f, 0.04617779f, 0.00628410f, -0.00229098f, 0.12120797f, -0.05270763f, -0.02869483f, -0.00089510f, 
    0.17325503f, 0.02000200f, -0.00599097f, -0.09511547f, 0.06234822f, 0.08602436f, 0.11773291f, -0.09244744f, 
    0.06798651f, -0.01078303f, -0.12950514f, -0.03988438f, -0.35332963f, 0.04911515f, -0.20929489f, -0.06574082f, 
    -0.03429344f, 0.02079429f, 0.08343218f, -0.00688871f, -0.11290421f, -0.03027944f, -0.00505859f, 0.09168010f, 
    0.03853231f, -0.07246310f, 0.05101588f, 0.07927509f, 0.03894334f, -0.00404515f, 0.05146807f, -0.07406509f, 
    0.03804351f, 0.06604490f, -0.00535408f, 0.08375061f, 0.07886274f, -0.13376313f, -0.00513108f, -0.07872564f, 
    0.02267589f, 0.03666417f, -0.00249480f, -0.00110632f, 0.05325243f, 0.05967900f, 0.03239168f, -0.05655557f, 
    -0.02022285f, 0.17730525f, 0.00489397f, -0.01503858f, 0.07256518f, -0.02874338f, 0.03543394f, 0.09912656f, 
    -0.03717000f, -0.15554902f, 0.09889729f, 0.03392547f, -0.03691616f, -0.01603096f, -0.03024093f, 0.07653050f, 
    0.09586825f, 0.00548619f, -0.00130695f, -0.07702012f, -0.04251498f, 0.09613267f, 0.09621995f, 0.01475533f, 
    -0.16189928f, 0.13156952f, -0.10988111f, 0.13533540f, -0.03789777f, -0.14295620f, 0.00040501f, 0.02396304f, 
    0.05482088f, 0.01071276f, 0.03673951f, 0.06054323f, 0.09218860f, -0.01100688f, 0.04058847f, -0.08272804f, 
    -0.02039234f, -0.01945464f, -0.10162764f, -0.01386623f, -0.13258804f, 0.02302996f, -0.12932682f, 0.18039186f, 
    0.02394928f, 0.02637028f, 0.09800765f, 0.02706540f, 0.08207653f, 0.01452000f, -0.07219600f, -0.04560656f, 
    0.04669216f, -0.02624879f, -0.08502474f, 0.08215700f, 0.00281065f, 0.05415513f, -0.02725091f, 0.04831466f, 
    -0.01178080f, 0.08340849f, 0.01435493f, -0.22272094f, 0.14210938f, -0.05427005f, 0.04164023f, -0.06890861f, 
    -0.10620190f, -0.02570025f, -0.00395203f, -0.06718911f, 0.00155258f, -0.04450949f, -0.11263788f, 0.01715064f, 
    0.03723243f, 0.12127455f, 0.04981586f, 0.04610959f, 0.12211106f, 0.06867518f, -0.09290189f, -0.13581641f, 
    -0.15987271f, -0.00189202f, -0.02502893f, 0.01875290f, -0.06790044f, 0.04368247f, 0.03226044f, -0.04089580f, 
    -0.06171532f, -0.01552680f, 0.04231873f, 0.05892140f, 0.00689965f, -0.05385297f, 0.12471517f, -0.00380887f, 
    -0.31579849f, -0.01893595f, -0.02447982f, 0.18500473f, 0.06037153f, 0.13443996f, -0.02670333f, 0.13858476f, 
    0.03045823f, -0.05095443f, -0.04576356f, -0.10467466f, 0.20092018f, -0.08944713f, -0.01002680f, -0.05536637f, 
    0.10961091f, -0.01092875f, 0.03234468f, -0.03674514f, -0.11624110f, 0.18091068f, 0.13337979f, -0.00543999f, 
    -0.18543619f, 0.09510422f, -0.04441014f, 0.07032473f, 0.02276603f, -0.01464092f, 0.04745517f, -0.00207514f, 
    -0.13470297f, 0.00454495f, -0.04720161f, 0.01469753f, -0.07209384f, -0.05665322f, 0.05778543f, 0.03955025f, 
    -0.05065236f, 0.19033705f, 0.06924411f, -0.07729927f, -0.06721409f, -0.12714081f, -0.09162819f, 0.09530205f, 
    0.03001675f, 0.07101153f, 0.02162077f, 0.03413567f, 0.05448305f, -0.01741350f, -0.06591043f, -0.00669208f, 
    -0.09246948f, -0.00186379f, 0.05993180f, -0.02559583f, -0.16262163f, -0.15341748f, 0.02652729f, -0.01881741f, 
    0.16615613f, 0.00401327f, 0.03174995f, 0.10349981f, 0.00194948f, -0.21676153f, -0.12726577f, 0.09568763f, 
    -0.11255651f, 0.00892703f, -0.01059774f, 0.06568281f, 0.03429940f, 0.16907735f, 0.15917209f, 0.11389925f, 
    0.13840485f, -0.33705482f, -0.04034431f, -0.23029043f, 0.03078860f, 0.00806047f, 0.00366821f, 0.03888552f, 
    -0.08718152f, -0.04903724f, -0.03351736f, -0.07490478f, 0.13030764f, 0.06973907f, 0.06016808f, -0.02201345f, 
    0.01082317f, -0.06110390f, -0.02126857f, 0.01253654f, -0.19613135f, -0.02348203f, -0.05249558f, -0.16784117f, 
    0.20228530f, -0.08477680f, -0.00638794f, 0.09405436f, 0.05453707f, -0.02915010f, -0.06136280f, -0.06242144f, 
    -0.07462084f, 0.11511732f, 0.08368247f, -0.02011398f, 0.09106298f, 0.06622870f, -0.02801638f, 0.07584585f, 
    -0.34647515f, -0.10817928f, -0.00767858f, -0.01803628f, 0.00962081f, 0.09332418f, 0.03948146f, -0.00779465f, 
    -0.06702620f, -0.00705357f, 0.02468482f, 0.01315158f, -0.03435611f, 0.14283524f, 0.09158979f, 0.05668833f, 
    -0.01349227f, -0.12678178f, 0.04054480f, -0.10140288f, 0.29322711f, -0.26248252f, -0.06593919f, -0.16211435f, 
    0.16199706f, 0.04155940f, -0.02962648f, 0.05733702f, 0.03526309f, 0.09132145f, -0.06982830f, -0.03502219f, 
    -0.08537982f, -0.14542833f, -0.00233518f, -0.00150024f, 0.11607946f, 0.05137257f, 0.13869174f, 0.09749051f, 
    -0.10479501f, 0.15703134f, 0.06310357f, 0.00524301f, -0.16903594f, 0.03729359f, -0.00676057f, 0.02470802f, 
    0.04290709f, -0.03907985f, 0.02867659f, 0.04801297f, -0.03641813f, -0.06392160f, -0.04651257f, 0.02120329f, 
    -0.00566183f, -0.08377953f, -0.00111570f, 0.05979704f, 0.19437923f, -0.02016481f, -0.06203297f, 0.00919804f, 
    0.03437883f, -0.08901242f, 0.00459248f, -0.07652374f, -0.01004819f, -0.07267925f, 0.05715286f, -0.04124295f, 
    -0.04599066f, 0.04809135f, 0.11678278f, -0.08298423f, -0.06568722f, 0.04336508f, -0.04503961f, 0.03644923f, 
    -0.32381827f, -0.10251431f, -0.00970751f, -0.22889617f, -0.06873898f, 0.09019334f, -0.06525130f, 0.05251171f, 
    -0.07382541f, -0.13943382f, -0.00468456f, 0.03513173f, -0.06719925f, 0.03158638f, -0.03047346f, -0.01312923f, 
    -0.10279134f, 0.05322681f, 0.10873619f, -0.11143579f, -0.20854561f, 0.24378614f, 0.06476336f, -0.01465991f, 
    -0.11519729f, -0.05253121f, 0.03816779f, -0.01773282f, 0.04255916f, 0.05663812f, -0.01989125f, 0.02918063f, 
    0.06137899f, -0.05825141f, 0.09637814f, 0.04922642f, -0.02526840f, 0.03582691f, 0.09724247f, 0.05826022f, 
    -0.05485230f, -0.00669806f, -0.03583854f, 0.19937567f, 0.02459417f, 0.07043160f, 0.06820807f, -0.01783818f, 
    0.08057328f, -0.05955701f, -0.01728139f, -0.01777912f, 0.00317294f, 0.03160382f, 0.05111336f, 0.08957633f, 
    -0.01168578f, 0.10294427f, 0.01876575f, 0.03024140f, -0.08966215f, -0.00863497f, -0.01876522f, -0.30243552f, 
    0.18588924f, -0.04119551f, -0.16781563f, 0.09535107f, -0.04028145f, -0.02181683f, 0.01303214f, -0.07043154f, 
    0.06924164f, -0.02439553f, -0.10444091f, 0.07093433f, -0.01322023f, -0.07713810f, 0.06447112f, 0.09618808f, 
    0.20311607f, -0.10021179f, 0.09556863f, -0.01041284f, -0.06137762f, 0.19677782f, 0.03062377f, 0.01947795f, 
    -0.06762931f, -0.06400776f, -0.05200890f, -0.01191006f, 0.01274338f, -0.02201588f, 0.00205952f, -0.02347995f, 
    0.04106519f, 0.05344491f, 0.02593375f, 0.04905494f, 0.02092232f, 0.03106559f, -0.07314958f, -0.12639949f, 
    0.02255381f, 0.02786808f, 0.02818852f, 0.04554774f, -0.07456065f, -0.05319547f, 0.01073867f, -0.04508505f, 
    -0.00476960f, -0.05182487f, 0.03788731f, -0.07251687f, -0.11309438f, 0.12579493f, -0.05390237f, 0.03392591f, 
    0.11076792f, -0.29903543f, 0.05864979f, -0.25501743f, 0.28550667f, 0.11680285f, -0.01184722f, 0.13496383f, 
    -0.09561034f, -0.05781168f, -0.00454440f, -0.01121797f, 0.08146134f, 0.05463788f, -0.01228613f, 0.05465531f, 
    0.04540504f, -0.02412926f, 0.13173264f, 0.03013027f, 0.07594270f, -0.13430701f, 0.01642946f, 0.07126012f, 
    0.00384917f, -0.11394638f, -0.00154487f, -0.16352268f, -0.04675220f, -0.00070879f, -0.00351418f, 0.09972385f, 
    0.00461484f, 0.08861460f, 0.08115089f, -0.13104710f, -0.07632513f, -0.04282805f, -0.05302356f, -0.04402233f, 
    -0.25492939f, -0.17698096f, -0.15324454f, 0.16604510f, -0.01390321f, -0.02010017f, 0.09125385f, -0.00498924f, 
    0.07572300f, 0.08388741f, -0.09137651f, -0.01407822f, 0.03586491f, -0.01683250f, -0.00876005f, -0.01130261f, 
    -0.05892996f, -0.00959611f, -0.24183495f, -0.05887865f, 0.24464002f, -0.36140910f, -0.08763693f, 0.12526162f, 
    0.09252699f, 0.06932778f, 0.04975811f, 0.02490536f, -0.03724631f, 0.05787731f, -0.00460605f, -0.01679619f, 
    0.02383932f, 0.02313559f, -0.03621140f, 0.02187951f, -0.01750547f, 0.06620253f, -0.05743713f, 0.06075421f, 
    0.01413971f, -0.24093542f, -0.04392330f, 0.03655173f, -0.00834510f, -0.07109839f, 0.00099927f, -0.05286397f, 
    0.02509140f, -0.04529059f, -0.08325297f, -0.04934099f, 0.05020738f, 0.12131950f, 0.01657053f, 0.03208606f, 
    -0.01117690f, -0.00470032f, -0.11888532f, 0.09113926f, -0.09683545f, 0.17673506f, 0.00229112f, -0.12999594f, 
    -0.06817749f, 0.01548039f, 0.08828694f, -0.00293014f, -0.06063359f, 0.08047502f, -0.01729399f, 0.03684065f, 
    -0.10523382f, 0.01384656f, -0.11112001f, -0.02769869f, -0.01351996f, 0.10363050f, 0.05417755f, 0.02129913f, 
    0.01481676f, -0.32361066f, -0.10846022f, -0.07258753f, 0.03284594f, -0.00166941f, 0.05228177f, 0.01270836f, 
    0.07080204f, 0.01240773f, -0.03283516f, 0.01447580f, 0.01959404f, 0.03030964f, 0.07077940f, -0.00385448f, 
    -0.03709364f, -0.01561454f, -0.03393447f, 0.02662396f, 0.14023200f, -0.41688734f, -0.10147288f, 0.07259893f, 
    0.00975943f, -0.02642752f, 0.09246875f, 0.05561203f, -0.00519017f, -0.03049599f, -0.02329177f, 0.04757585f, 
    -0.00088194f, 0.01645971f, 0.06969104f, -0.02804836f, 0.00769159f, -0.01561140f, -0.11265828f, 0.07079438f, 
    -0.04603795f, 0.00716263f, -0.11753893f, -0.23778555f, 0.11237974f, -0.06861898f, -0.00891414f, -0.02207203f, 
    -0.07989889f, -0.00202477f, -0.05825615f, -0.03346516f, -0.09649070f, -0.02521859f, 0.00100677f, 0.02365309f, 
    0.07602651f, 0.02764159f, 0.10739649f, -0.00643933f, -0.10356961f, -0.05053424f, 0.10152040f, 0.02775289f, 
    0.11759879f, 0.08800101f, -0.12497621f, 0.05489929f, 0.02079019f, -0.10689782f, -0.07548400f, 0.03835387f, 
    -0.15431701f, -0.04994065f, 0.02421429f, -0.06463815f, 0.00663814f, 0.07497723f, 0.00430689f, -0.04747937f, 
    0.15526566f, 0.19232167f, 0.05741260f, 0.01553400f, 0.12163923f, -0.11466233f, -0.04649811f, 0.01559944f, 
    -0.08107567f, -0.06318868f, -0.07264938f, 0.07581268f, -0.05236912f, 0.01550732f, 0.08011191f, 0.04182757f, 
    -0.13093707f, 0.05518966f, 0.13702674f, -0.02471087f, 0.10722978f, -0.19784236f, -0.00482774f, -0.29510090f, 
    0.10442330f, -0.03573272f, 0.00373787f, -0.06872270f, -0.00884735f, -0.02452581f, 0.01022897f, 0.08066459f, 
    0.06684782f, 0.11348537f, -0.01632731f, 0.07259363f, 0.00322046f, -0.03418050f, -0.02570727f, 0.09804327f, 
    0.12233555f, -0.42397174f, 0.00348943f, -0.33403608f, 0.14708576f, 0.03839543f, -0.02937629f, -0.06656118f, 
    0.01480357f, -0.11367738f, -0.03597219f, -0.01263173f, 0.06477149f, 0.00772763f, 0.05923142f, -0.01858933f, 
    -0.01507847f, -0.05489419f, -0.09246162f, 0.13424835f, 0.22072579f, 0.01159830f, -0.12780304f, 0.21791141f, 
    -0.05929038f, -0.01916542f, 0.09012698f, -0.02634963f, 0.04018767f, -0.08474601f, -0.08766513f, 0.06106614f, 
    -0.05689188f, 0.09065528f, -0.06588773f, -0.03984454f, 0.06150468f, 0.06864746f, -0.04795630f, 0.07439466f, 
    0.07431421f, 0.11660598f, -0.04827817f, -0.10015759f, -0.03169365f, -0.08788809f, 0.07338008f, 0.06708250f, 
    -0.05292249f, 0.03356387f, -0.05422976f, -0.03746565f, -0.02911291f, -0.00184125f, 0.01326002f, 0.09891342f, 
    -0.04381771f, 0.02083250f, -0.00136182f, 0.06414556f, -0.04367282f, 0.03599863f, 0.01460102f, -0.13031085f, 
    0.03298527f, 0.03575024f, 0.04028241f, 0.04410507f, -0.11240335f, -0.04672709f, -0.00003033f, -0.04481182f, 
    0.09935539f, -0.08550511f, -0.04098714f, 0.04793993f, 0.01490752f, 0.03603977f, 0.05665562f, 0.04175425f, 
    0.13029245f, -0.08229877f, 0.01065383f, 0.09710666f, 0.08518140f, -0.09149865f, 0.02037295f, -0.04801265f, 
    0.07532534f, -0.02522650f, 0.03953719f, 0.02356448f, -0.07741687f, 0.03165510f, 0.02023075f, -0.00339387f, 
    -0.02848441f, 0.06717683f, -0.12302442f, -0.00394636f, -0.09886803f, 0.17347328f, -0.11319625f, 0.09600434f, 
    -0.26909363f, 0.13561848f, 0.10706618f, 0.00456044f, 0.04133957f, 0.05349751f, 0.05769292f, 0.05554751f, 
    -0.02547020f, 0.02927375f, -0.13808739f, -0.00943598f, -0.00055235f, 0.08645113f, 0.01706054f, 0.03862239f, 
    -0.10548443f, -0.14197218f, -0.04826548f, 0.00317464f, -0.00643852f, -0.07714117f, -0.03938745f, 0.05746187f, 
    -0.06385212f, -0.01805324f, -0.11349699f, -0.06446185f, 0.01767918f, 0.10612671f, 0.00392874f, -0.01421613f, 
    -0.09714156f, -0.01722089f, -0.02121576f, 0.01025268f, -0.10443112f, 0.17128679f, 0.07116665f, -0.01013674f, 
    -0.18484834f, 0.04050024f, 0.08997317f, 0.00265530f, 0.02178683f, 0.07304385f, 0.01718614f, 0.03568732f, 
    -0.05474684f, -0.05090613f, -0.09820276f, 0.02734172f, -0.02528202f, 0.07850453f, -0.05989464f, -0.09056000f, 
    -0.00013627f, -0.36301467f, -0.06886797f, 0.02595853f, -0.01572957f, -0.08731881f, 0.04866100f, 0.05491869f, 
    0.00062236f, 0.10347140f, 0.00178410f, 0.01514786f, -0.08328900f, 0.10662056f, 0.04811549f, -0.13727140f, 
    0.04447203f, -0.05640302f, 0.06725443f, -0.13212593f, -0.09990051f, 0.09178004f, -0.01173515f, -0.23744598f, 
    0.11105150f, -0.03485949f, -0.04663632f, -0.01591917f, -0.03097243f, -0.03563570f, 0.00671041f, -0.09304472f, 
    0.00139139f, -0.03539286f, 0.00478199f, -0.00971242f, -0.00450429f, -0.01240262f, 0.07999330f, 0.08862352f, 
    -0.03088029f, 0.12652402f, -0.03754071f, 0.14764901f, -0.16301718f, -0.08625744f, -0.00062308f, 0.01626443f, 
    0.02826421f, 0.05937652f, 0.05281962f, -0.04504528f, -0.01358805f, 0.04053882f, 0.09271853f, 0.09439037f, 
    -0.00009277f, -0.16285917f, 0.02766839f, -0.04585747f, -0.13760944f, 0.08403713f, 0.00033396f, 0.07885753f, 
    0.03938911f, 0.00402978f, -0.00233402f, -0.01538915f, 0.03337213f, 0.04659283f, -0.01195789f, 0.02470503f, 
    0.03388796f, -0.04908696f, -0.02122989f, 0.00169822f, -0.00530728f, -0.01530806f, -0.06701895f, -0.19795898f, 
    -0.02497549f, -0.06759591f, 0.06306440f, 0.18494874f, 0.10579041f, 0.01686807f, 0.03744540f, 0.05303600f, 
    -0.06084817f, -0.11088739f, -0.06177967f, -0.02304710f, -0.08073180f, -0.01083352f, 0.01379998f, -0.03640543f, 
    -0.00395199f, 0.08855160f, 0.02865115f, 0.02439641f, -0.16446869f, 0.27318612f, 0.02744549f, 0.15982805f, 
    -0.18044433f, -0.10704703f, -0.10333709f, -0.03768804f, 0.05160011f, 0.11834148f, 0.01268141f, 0.07631703f, 
    0.02193857f, -0.02498073f, -0.02509987f, -0.09648424f, 0.00834951f, -0.14730430f, -0.03766710f, -0.10222710f, 
    0.07057334f, -0.14981569f, -0.19919695f, -0.14884594f, 0.19655876f, -0.10236295f, 0.07486376f, -0.02774164f, 
    -0.05339307f, 0.00984297f, -0.02825298f, -0.02927637f, -0.04269749f, -0.04804792f, -0.04949658f, -0.01671029f, 
    0.02864290f, 0.10302676f, 0.03705366f, 0.01331729f, -0.12209295f, 0.16557327f, 0.14083593f, -0.00216529f, 
    -0.14486675f, 0.06325605f, -0.02150236f, -0.05424561f, 0.04847581f, 0.06759517f, 0.02758454f, 0.00492665f, 
    -0.01566127f, 0.02616335f, -0.13776304f, 0.03490656f, -0.02164594f, -0.06555344f, -0.03993497f, -0.16464680f, 
    0.25259495f, -0.38263854f, -0.06628551f, 0.05594002f, 0.01357196f, -0.07371712f, -0.06128078f, -0.00166703f, 
    0.03460909f, 0.07998634f, 0.00893078f, 0.05153509f, -0.03826026f, -0.08587866f, 0.05517326f, 0.00225320f, 
    0.03272800f, -0.07556310f, -0.05232398f, -0.11766940f, -0.23488714f, 0.23196805f, -0.00801791f, 0.18882789f, 
    -0.10045905f, 0.12801020f, 0.07432318f, 0.00081461f, 0.09777632f, -0.04120930f, -0.09555589f, 0.07491421f, 
    -0.02135992f, -0.00221675f, -0.13580881f, 0.17078066f, -0.09887181f, 0.05163983f, 0.02050483f, -0.04418794f, 
    -0.05475444f, -0.21884504f, -0.10176379f, 0.05890466f, 0.11547728f, -0.09150590f, 0.06121285f, 0.02324015f, 
    0.00404706f, 0.04324907f, -0.13821809f, -0.01171741f, -0.05679651f, -0.01080169f, 0.03535349f, -0.01797506f, 
    -0.07234298f, 0.01413910f, -0.15185206f, -0.00911101f, 0.10421225f, -0.17103049f, -0.06290394f, 0.12845890f, 
    -0.14541885f, -0.03242081f, 0.00128406f, -0.05450002f, 0.04657358f, 0.01130184f, -0.05714977f, 0.00328668f, 
    0.04982778f, -0.01734343f, 0.00173821f, 0.04122174f, -0.03036323f, 0.02202403f, -0.05156224f, -0.07291558f, 
    0.00798347f, -0.08920941f, -0.18519698f, -0.16445653f, 0.02846926f, 0.03146303f, 0.05114197f, 0.03764103f, 
    -0.03251718f, -0.00536312f, 0.05428287f, 0.00824267f, 0.03484920f, 0.01911703f, -0.04769437f, 0.04076543f, 
    -0.00657082f, -0.00103623f, 0.07427616f, -0.01118218f, -0.17528714f, -0.10030545f, -0.22340795f, -0.01671757f, 
    -0.17199120f, 0.01348880f, 0.11658179f, -0.07874583f, -0.05485689f, -0.03648213f, -0.07310419f, -0.00681193f, 
    0.00787031f, 0.07149545f, -0.08366844f, 0.12260929f, -0.01319235f, 0.07574030f, 0.04263970f, 0.03422505f, 
    -0.21538734f, 0.07594746f, -0.07176081f, 0.21539076f, -0.01128665f, 0.04604729f, -0.08018761f, 0.05616090f, 
    -0.02982462f, -0.05463712f, 0.01615667f, -0.07514659f, 0.03451933f, 0.03765617f, -0.09226199f, 0.11392836f, 
    -0.06183966f, -0.12030596f, -0.08847240f, -0.06359145f, 0.11181792f, -0.03301501f, -0.03369559f, -0.01322237f, 
    -0.04150813f, -0.01567749f, -0.07131571f, 0.00164675f, -0.02143342f, -0.09335502f, -0.02838001f, 0.06151518f, 
    -0.05887526f, -0.05139224f, -0.01214538f, -0.03522161f, 0.01931909f, 0.12674651f, -0.04814301f, 0.09976487f, 
    0.03843282f, 0.06097161f, 0.09248202f, 0.06467017f, 0.16468880f, -0.06993204f, 0.03065371f, -0.08112741f, 
    0.00273743f, -0.02091519f, -0.04089439f, 0.03386395f, 0.04630667f, 0.09992128f, 0.12188823f, 0.06806041f, 
    0.04843379f, 0.03975303f, -0.01629133f, 0.01406810f, 0.13368876f, -0.18857773f, -0.05178842f, 0.00117324f, 
    -0.12608172f, 0.01769503f, 0.06184793f, 0.08706382f, -0.00911958f, 0.04626571f, -0.05914661f, 0.00312260f, 
    -0.01756750f, -0.01528170f, 0.07261513f, 0.04641855f, -0.06753340f, -0.05243709f, -0.10651255f, 0.01551178f, 
    -0.06226913f, 0.04591707f, -0.08795842f, -0.08311078f, -0.03238713f, 0.07169195f, -0.04776922f, 0.05784883f, 
    -0.05347891f, -0.00936082f, -0.04535219f, 0.07801786f, -0.01343176f, -0.04969104f, -0.09882994f, -0.00124229f, 
    -0.22335938f, 0.09491913f, 0.02487593f, 0.11880747f, 0.16288996f, -0.19634874f, 0.11985431f, 0.11844574f, 
    -0.09902198f, -0.00774805f, 0.03508311f, 0.08030019f, 0.00762739f, -0.02932288f, 0.08260687f, -0.08002605f, 
    -0.05699756f, -0.06256235f, 0.07616027f, -0.05232671f, 0.13934793f, 0.01065766f, 0.01249618f, -0.08099502f, 
    0.01312804f, 0.05562339f, -0.08808812f, -0.26653811f, -0.09872329f, 0.01518594f, 0.02123607f, 0.03154323f, 
    -0.06880362f, 0.05280869f, -0.04405415f, 0.03326049f, -0.10418727f, -0.08882712f, -0.00237936f, 0.02778488f, 
    -0.04729886f, -0.02421436f, 0.10002066f, 0.09342080f, 0.11149182f, -0.14300656f, 0.03688912f, -0.20326078f, 
    0.01753683f, -0.05679730f, 0.05905272f, -0.03048683f, 0.01336250f, -0.08428768f, 0.05758734f, 0.02185784f, 
    -0.00321619f, 0.02964765f, 0.03959841f, -0.00409620f, 0.02488096f, -0.06039844f, -0.04862045f, 0.09349994f, 
    -0.15422872f, 0.16120756f, 0.08049928f, 0.06013018f, -0.15482616f, 0.05961106f, -0.02752619f, 0.00380305f, 
    0.09641426f, -0.02443280f, -0.07489626f, 0.00849219f, -0.03412926f, 0.00780414f, -0.06559926f, 0.04206915f, 
    0.10057680f, -0.09091349f, 0.07462770f, 0.10115264f, 0.06794486f, 0.08122949f, 0.15946609f, 0.05983970f, 
    -0.08245679f, 0.09776679f, -0.08529022f, 0.03674619f, 0.00950124f, -0.02598492f, -0.00189880f, -0.05297235f, 
    0.02724121f, 0.09448424f, 0.03832955f, 0.03949997f, 0.08223601f, -0.14073826f, -0.06259296f, -0.11080424f, 
    -0.26244557f, 0.03361676f, -0.07074697f, -0.13227315f, -0.19688787f, 0.03830669f, -0.02516373f, -0.01328226f, 
    -0.01691450f, -0.06346470f, -0.02818343f, 0.00049973f, -0.04328993f, -0.02652819f, 0.00999286f, -0.01947062f, 
    -0.04382468f, -0.01280046f, 0.00813629f, 0.01169009f, -0.10976259f, 0.02721767f, -0.01491839f, -0.07691029f, 
    0.03441750f, -0.02109082f, 0.00978981f, 0.00352751f, -0.02435871f, -0.06529528f, 0.01063755f, 0.03290818f, 
    0.02088473f, 0.01753802f, -0.04852114f, -0.01829109f, 0.00124062f, 0.00374947f, 0.00859742f, -0.04215957f, 
    0.12462053f, 0.08550945f, 0.08446319f, -0.01237585f, 0.11003148f, -0.14457737f, 0.04787235f, -0.04487833f, 
    -0.01647221f, 0.03043820f, -0.03816334f, 0.03854481f, -0.06275569f, 0.02067317f, -0.01321144f, -0.06645776f, 
    -0.05536180f, 0.05637141f, -0.05024489f, -0.05317004f, 0.19391578f, -0.11423003f, -0.00488447f, -0.06774571f, 
    0.17789628f, -0.05152194f, -0.03673494f, -0.04405394f, -0.04570036f, 0.00261239f, -0.01252177f, 0.04366020f, 
    0.01025371f, 0.02973308f, -0.04508885f, -0.02863866f, 0.01582829f, 0.04467757f, -0.02984250f, -0.00163630f, 
    0.19994184f, -0.08943759f, 0.02141925f, -0.06795089f, -0.12423833f, 0.01460958f, 0.01073027f, -0.00735996f, 
    -0.03024746f, 0.02074958f, 0.02085437f, 0.02263718f, 0.05324832f, -0.02871304f, -0.07283075f, -0.02207916f, 
    0.07882432f, -0.02864002f, 0.03048171f, -0.06875576f, 0.02220175f, -0.18587390f, 0.03134228f, -0.00525135f, 
    -0.05002559f, -0.01471817f, -0.03021842f, -0.04853402f, -0.02533720f, -0.03176249f, -0.04697747f, -0.02124830f, 
    -0.05402850f, 0.00740115f, -0.00555414f, 0.01404227f, -0.00842107f, -0.01069269f, -0.01997842f, -0.04359829f, 
    0.04681833f, -0.07146045f, 0.04007836f, 0.02949061f, -0.09233060f, 0.01708068f, -0.12457701f, -0.04680701f, 
    -0.06187164f, -0.03572233f, 0.01596072f, -0.00774635f, -0.01646537f, -0.02228496f, -0.01770769f, 0.01244977f, 
    0.07849991f, -0.03346660f, -0.06976338f, -0.01389863f, -0.02577695f, -0.02933760f, 0.14036098f, 0.06938843f, 
    0.06158777f, 0.12117116f, -0.10064808f, -0.02693051f, 0.02174310f, 0.01886936f, 0.00449759f, 0.02200342f, 
    -0.03346188f, -0.02084114f, -0.03352127f, 0.00585446f, -0.05209095f, -0.07898789f, -0.01184480f, -0.03917713f, 
    0.13439339f, 0.03891847f, 0.16295074f, 0.03507917f, 0.11074260f, 0.03135277f, 0.06564452f, -0.03454972f, 
    -0.00506027f, -0.02053289f, -0.00882437f, 0.04850569f, -0.00221287f, 0.00663177f, -0.08763848f, -0.03510875f, 
    0.00188196f, 0.00549069f, 0.01453630f, -0.07324120f, 0.04475550f, 0.06911046f, 0.03202764f, 0.04358809f, 
    -0.01211021f, -0.03118021f, 0.04879905f, -0.04036496f, 0.02594056f, 0.00876915f, -0.05399318f, 0.02409012f, 
    -0.05104403f, 0.01142247f, -0.02179709f, -0.01499040f, -0.04121128f, 0.03197571f, -0.06569621f, -0.03177172f, 
    -0.06823273f, -0.06789409f, -0.08487322f, -0.12033658f, -0.12218549f, -0.07287041f, -0.02168175f, 0.00869893f, 
    -0.04722064f, 0.00080169f, 0.01237466f, -0.05961433f, -0.01400683f, -0.01242891f, 0.02599516f, -0.07205588f, 
    -0.04877932f, -0.02838312f, -0.00838557f, 0.01175579f, 0.15548781f, -0.23071727f, 0.12851085f, 0.12345263f, 
    0.00162728f, 0.12922233f, -0.01439399f, -0.04807908f, -0.07794212f, 0.02716444f, 0.00444226f, 0.03677078f, 
    -0.03027862f, 0.03929903f, 0.01553441f, 0.00630737f, 0.08151703f, -0.04535370f, -0.02273925f, 0.00025203f, 
    -0.15872201f, -0.11727734f, -0.19761850f, -0.12049128f, -0.07985635f, 0.01984495f, -0.01730942f, -0.03515983f, 
    -0.05254850f, -0.06030539f, -0.03589556f, -0.00034879f, -0.02640310f, -0.08626673f, 0.00878244f, -0.06608357f, 
    0.01715929f, -0.03678475f, 0.03359253f, 0.02917580f, -0.16902709f, 0.13386910f, 0.01474376f, 0.07294720f, 
    0.03430334f, -0.00329572f, -0.05824626f, 0.00753171f, 0.00255375f, 0.00818706f, 0.04952317f, 0.02805959f, 
    0.00746208f, -0.05249462f, -0.01864781f, 0.03018475f, -0.02040316f, 0.09493243f, -0.02336245f, -0.04529156f, 
    0.03713643f, 0.03809423f, 0.09279236f, 0.15137097f, 0.11368278f, 0.03660892f, 0.08110852f, -0.01446880f, 
    -0.01803915f, -0.03236146f, 0.02097846f, 0.02022569f, -0.05425163f, -0.04454282f, -0.03362408f, 0.00024735f, 
    0.10061399f, 0.02094598f, 0.10425424f, -0.05693477f, -0.11162507f, -0.02866962f, -0.19223791f, 0.01674129f, 
    0.03886547f, -0.06615848f, -0.06915576f, -0.01239254f, -0.00240549f, -0.02527196f, -0.09957708f, 0.03178256f, 
    0.00930670f, 0.02231171f, -0.04789842f, 0.01698426f, -0.03177666f, -0.09254755f, -0.02766363f, 0.00427517f, 
    -0.24746764f, 0.04013000f, -0.00675817f, 0.03923569f, 0.00385355f, -0.00934497f, -0.05535091f, -0.04868037f, 
    0.03901814f, -0.02946944f, -0.00715694f, -0.02164968f, -0.01977628f, -0.02470468f, -0.10967276f, 0.01979454f, 
    -0.06006256f, 0.03086760f, -0.01671413f, -0.00781441f, 0.13797259f, 0.08769637f, 0.21381539f, -0.06109641f, 
    0.13565014f, 0.01512032f, 0.12366159f, -0.04186272f, 0.00156910f, -0.04629130f, -0.03322595f, 0.02088361f, 
    -0.10307540f, -0.01673781f, -0.03986292f, -0.01544806f, 0.05303601f, 0.00039321f, 0.01983656f, -0.02602461f, 
    0.17536967f, -0.17899756f, 0.10011172f, -0.03612613f, -0.03846547f, -0.03456040f, 0.02871089f, 0.00594011f, 
    0.03440040f, 0.02480054f, -0.05045776f, -0.00394007f, -0.03065584f, 0.02169416f, -0.01263985f, 0.01837010f, 
    0.04660347f, 0.00956440f, 0.01051836f, -0.02903212f, 0.03213269f, 0.03594267f, 0.09240936f, 0.08980551f, 
    0.05006389f, -0.00842128f, 0.02893231f, -0.03486105f, -0.03864596f, -0.04525438f, -0.01318287f, 0.02808925f, 
    -0.04986747f, -0.03172832f, 0.02480955f, -0.05659068f, -0.07929059f, -0.00305276f, 0.01722986f, -0.04538957f, 
    0.01992333f, 0.15423436f, 0.10760219f, -0.09054414f, 0.13493095f, -0.07704156f, 0.06587930f, -0.04851113f, 
    -0.01064022f, 0.01368782f, -0.05071367f, 0.03452801f, -0.05418692f, -0.09152463f, -0.03005883f, 0.06206826f, 
    -0.03829295f, 0.06116351f, 0.04344189f, 0.01737742f, -0.15948968f, 0.05622168f, 0.16788900f, 0.06192448f, 
    0.01736521f, 0.09889225f, 0.00599549f, 0.02587728f, 0.05107913f, 0.01671860f, -0.02081990f, 0.02689818f, 
    0.07790055f, -0.02985948f, -0.04562147f, 0.04195935f, -0.00965523f, 0.01186493f, 0.00806700f, -0.04142808f, 
    -0.18500115f, 0.11575071f, 0.04291206f, -0.07419799f, -0.08001760f, -0.07403950f, -0.03617884f, -0.06141986f, 
    -0.02906932f, -0.07432839f, 0.07052851f, 0.03084325f, -0.05363397f, 0.00534809f, -0.02439049f, -0.00238408f, 
    0.03592922f, -0.00273262f, -0.01759349f, 0.00691054f, 0.14040624f, 0.02732323f, 0.03353133f, 0.05273063f, 
    -0.07174469f, 0.07398688f, 0.00756067f, 0.03582985f, 0.00385724f, -0.02683738f, 0.00357831f, -0.04961978f, 
    0.02059445f, -0.02564413f, 0.02891239f, 0.01458988f, 0.05016532f, -0.04373737f, 0.02517191f, -0.01338216f, 
    -0.12265431f, -0.06001176f, 0.11321980f, 0.01749297f, -0.00208776f, 0.08248484f, -0.02930444f, -0.01479197f, 
    0.06356262f, -0.01818576f, -0.03688614f, 0.03439768f, 0.05138121f, 0.05812791f, -0.09444778f, 0.04334351f, 
    0.03006212f, 0.00711695f, 0.00394645f, 0.00604912f, -0.00267058f, -0.07765254f, -0.15285714f, 0.04756053f, 
    0.10994940f, -0.05871241f, -0.07196808f, -0.05602922f, -0.04993083f, 0.00305996f, -0.04135388f, 0.08251189f, 
    0.03190376f, 0.01147489f, -0.01387925f, -0.02738434f, -0.01786884f, 0.04204854f, -0.05147973f, 0.07677735f, 
    -0.02316047f, -0.03951967f, 0.07311092f, 0.10193655f, 0.23230314f, 0.01694495f, 0.09996124f, 0.00957245f, 
    0.01967111f, -0.02810801f, -0.00090958f, -0.01198180f, 0.01086308f, -0.02639082f, -0.04576468f, -0.03984417f, 
    0.04519083f, -0.00759339f, -0.05813929f, 0.04599316f, 0.03182788f, -0.00736282f, 0.05647223f, 0.04123002f, 
    0.16135576f, 0.04559274f, 0.06624898f, -0.04188139f, 0.02313001f, -0.02841900f, 0.00543158f, -0.04080026f, 
    -0.00029587f, -0.04440301f, -0.01065377f, -0.00064786f, -0.01390715f, 0.03326482f, 0.00850072f, -0.02708323f, 
    -0.00268582f, 0.03617028f, 0.04996172f, 0.04199228f, 0.05120137f, 0.00346532f, -0.02897667f, -0.06272846f, 
    -0.03630590f, -0.00897042f, 0.01068729f, -0.02273315f, 0.00062800f, -0.07272501f, -0.01920668f, 0.00385010f, 
    -0.04142185f, 0.02332882f, 0.06687480f, 0.01557744f, 0.04255711f, -0.30665851f, 0.04846424f, 0.05389690f, 
    -0.11835974f, -0.00249729f, 0.01996908f, -0.05486479f, -0.01783075f, 0.03791226f, -0.03512983f, 0.00702976f, 
    -0.04545264f, 0.00794288f, -0.09548534f, -0.03202077f, -0.00043325f, 0.00877987f, -0.07439848f, 0.01861754f, 
    0.11621013f, -0.07576554f, -0.18699998f, -0.02941500f, 0.21013321f, -0.18245098f, -0.08382738f, -0.01923683f, 
    -0.02122082f, 0.02948746f, -0.03595559f, -0.03058157f, -0.11226807f, 0.03685761f, -0.01900834f, -0.01624117f, 
    -0.03708648f, -0.00630513f, -0.06519338f, 0.06363798f, -0.05260086f, 0.11719748f, 0.17443037f, 0.06844713f, 
    0.10153732f, -0.00244967f, 0.07418221f, -0.00046612f, 0.00781837f, -0.00847559f, -0.03184147f, 0.01105889f, 
    0.00292494f, -0.05958933f, -0.03834377f, 0.00360699f, 0.00465752f, -0.02551201f, -0.01426151f, -0.06175939f, 
    0.18405102f, -0.04904816f, 0.18753526f, 0.00733569f, 0.11530995f, -0.02079078f, 0.11207522f, -0.01243754f, 
    0.05328611f, 0.01593671f, -0.01014422f, 0.03217061f, -0.01369957f, 0.01433082f, -0.02246628f, -0.04248976f, 
    0.00971002f, 0.02835171f, 0.02378155f, -0.07332714f, -0.25825736f, 0.06678189f, -0.11877348f, 0.12757398f, 
    0.05271385f, 0.06252825f, -0.14707810f, -0.05396096f, 0.06034662f, 0.00042345f, -0.09361906f, 0.02518019f, 
    0.07834842f, -0.00203055f, 0.01374389f, -0.00462884f, -0.06363174f, 0.03741364f, 0.01961910f, 0.01598928f, 
    0.03060768f, 0.03739610f, -0.16032763f, 0.08580709f, 0.15298523f, -0.08778024f, -0.06132612f, -0.02152446f, 
    0.01479979f, -0.05009338f, -0.11153624f, 0.03652073f, 0.00548587f, 0.01033502f, -0.00779053f, -0.07399385f, 
    0.01730600f, 0.01516256f, -0.02437636f, -0.03105572f, 0.04557962f, -0.03693255f, 0.05320419f, -0.01458079f, 
    0.00228524f, 0.00446303f, -0.02644208f, -0.03685049f, -0.02383789f, -0.03073886f, -0.00600938f, 0.03841762f, 
    -0.02538376f, -0.04093452f, 0.00381325f, -0.03976527f, 0.01104529f, 0.00218221f, -0.00539537f, -0.00535405f, 
    -0.03793766f, 0.04585367f, 0.01646698f, 0.00794703f, 0.03810020f, -0.00567463f, -0.04724099f, 0.05018726f, 
    -0.00429900f, -0.04165703f, 0.03249300f, 0.02913118f, -0.00739508f, -0.02677025f, -0.07141595f, -0.01958989f, 
    0.04217587f, 0.02477392f, 0.00793815f, -0.03455982f, -0.25407350f, 0.03344070f, -0.17513497f, -0.03458472f, 
    0.02906011f, 0.03660094f, -0.00546639f, -0.04804501f, -0.00383779f, -0.05087484f, -0.01472619f, 0.01976087f, 
    -0.01148128f, -0.00320076f, -0.01310258f, 0.00299848f, -0.01117169f, 0.04895988f, 0.02925744f, 0.00551035f, 
    0.10063914f, -0.19933628f, 0.12677479f, 0.01344278f, -0.03223929f, 0.07586563f, -0.03653702f, -0.01897300f, 
    0.01322107f, -0.01365635f, -0.01020234f, 0.05716899f, -0.02208485f, 0.03255856f, -0.01956690f, 0.00677765f, 
    0.04500580f, 0.00840720f, -0.02134436f, 0.01581360f, -0.16125022f, -0.11048322f, -0.11881220f, 0.02374381f, 
    -0.03977895f, -0.00905880f, -0.04396074f, -0.07805012f, -0.00724035f, -0.03358630f, -0.08184823f, 0.00888848f, 
    0.01468884f, -0.01404203f, -0.02749940f, -0.00836136f, 0.05418593f, 0.00736063f, -0.00474709f, 0.08765667f, 
    0.04531110f, -0.17387226f, 0.05076434f, 0.08882775f, -0.03575378f, 0.12478305f, -0.01054118f, -0.01287811f, 
    -0.04226708f, -0.06808778f, 0.03641965f, 0.03208585f, -0.02322275f, 0.02923670f, -0.03752172f, -0.07234315f, 
    0.07982177f, 0.03691596f, 0.08352131f, -0.05224884f, 0.10571630f, 0.03595994f, 0.12718168f, -0.01666954f, 
    0.10265473f, 0.02288979f, 0.01934369f, -0.03972324f, 0.00141790f, -0.03552698f, -0.04301956f, 0.03567297f, 
    -0.03043112f, -0.01706813f, -0.01777406f, -0.04910846f, -0.02292884f, 0.01549969f, 0.04977569f, -0.02602489f, 
    0.02406820f, -0.09002076f, -0.11236808f, -0.12629274f, -0.14201990f, -0.01911118f, 0.02714015f, -0.03075420f, 
    -0.04882814f, -0.06931920f, 0.04937213f, -0.05058710f, -0.05812373f, 0.00705170f, -0.04733132f, 0.09590920f, 
    -0.03268198f, -0.00901230f, -0.05428464f, 0.02556854f, -0.15845482f, 0.01772141f, -0.13241903f, -0.08858261f, 
    -0.11287247f, 0.04437487f, -0.02324043f, -0.02818458f, 0.03345979f, 0.00814855f, -0.05267872f, -0.01809259f, 
    -0.00533799f, -0.01697809f, 0.00069644f, -0.06113236f, 0.02564511f, 0.00816583f, 0.03041336f, 0.05331023f, 
    0.00994483f, -0.13479979f, 0.06238680f, -0.00240015f, -0.06192289f, 0.02984892f, -0.05057850f, -0.00917741f, 
    0.00467559f, -0.05085544f, -0.01984989f, 0.04447146f, -0.01923368f, 0.00532494f, -0.05933740f, 0.00552536f, 
    -0.02098397f, -0.02996416f, -0.02186346f, -0.01841269f, -0.06040640f, -0.09700139f, -0.08120860f, -0.19812185f, 
    -0.16977148f, 0.01304994f, -0.09295587f, 0.01107404f, -0.01838516f, -0.09598787f, -0.03678161f, -0.02904624f, 
    -0.05709302f, -0.02297413f, -0.05617743f, 0.00319913f, 0.00662323f, -0.00955330f, -0.01907722f, 0.04642524f, 
    0.06716188f, 0.11872653f, 0.01376340f, 0.00863332f, 0.10041444f, -0.02845438f, 0.06146480f, -0.05575412f, 
    -0.02252141f, 0.02945419f, -0.14678574f, 0.02171455f, -0.07226924f, -0.00290741f, -0.05923255f, 0.03300547f, 
    0.01787324f, 0.09034103f, -0.03812954f, -0.03422652f, -0.06614584f, -0.18173319f, -0.09476855f, -0.03066536f, 
    -0.11297823f, -0.02989539f, -0.01896890f, -0.00042477f, 0.00121125f, -0.03896666f, -0.03370687f, -0.04642162f, 
    -0.01442128f, -0.04523670f, -0.02026759f, -0.00307286f, -0.01347049f, 0.02548674f, -0.00479449f, 0.01015773f, 
    0.07832033f, -0.16373026f, 0.02642387f, -0.01820594f, -0.04098592f, 0.07565416f, -0.04085173f, -0.04646245f, 
    -0.05392699f, 0.03216475f, -0.03653539f, -0.01052173f, -0.05146288f, -0.06627747f, 0.00748373f, -0.03088499f, 
    -0.05060193f, -0.00560715f, 0.01589497f, -0.01475597f, -0.20683149f, 0.06284636f, 0.15764339f, -0.02599674f, 
    -0.01090942f, 0.03048938f, 0.03357191f, -0.01142444f, 0.10212433f, -0.00657037f, -0.03297971f, 0.00631306f, 
    0.02740203f, -0.00469468f, -0.12054141f, -0.00843961f, -0.01082382f, -0.03423429f, -0.03568955f, 0.00388735f, 
    -0.18725401f, 0.09453303f, 0.03175325f, -0.05839749f, 0.02401727f, -0.08120248f, -0.00914540f, -0.09230398f, 
    -0.05632248f, -0.02694573f, 0.03117832f, 0.08448289f, -0.06804444f, -0.00556014f, 0.01400311f, -0.04101231f, 
    -0.01517680f, 0.06088573f, -0.04566310f, -0.01003603f, -0.06168644f, 0.01016674f, 0.00252933f, -0.00963476f, 
    -0.12378818f, 0.01491702f, -0.03977272f, 0.01681174f, -0.01121410f, -0.09917362f, 0.02832776f, -0.02824510f, 
    -0.02851923f, -0.02075935f, -0.02993212f, 0.02930672f, -0.00438173f, 0.03186432f, -0.03037341f, -0.03783760f, 
    0.06734779f, -0.14348197f, 0.02358004f, 0.04910637f, 0.03317121f, 0.04824953f, -0.05478351f, -0.03477183f, 
    -0.06368411f, -0.00014232f, -0.02343414f, 0.03324368f, 0.02673900f, -0.03123902f, -0.00506139f, -0.07738166f, 
    0.09556367f, 0.00613002f, 0.09870529f, -0.04724432f, 0.02852076f, 0.10105364f, 0.04115214f, 0.01499162f, 
    0.21201523f, 0.00541406f, 0.00867421f, 0.00080121f, 0.02402798f, -0.01724768f, 0.01115519f, 0.00732041f, 
    -0.07441486f, -0.02465851f, -0.00629339f, 0.04007974f, -0.04820095f, 0.01560768f, -0.05193195f, 0.00889284f, 
    0.02842270f, 0.12774968f, 0.00167602f, -0.08579998f, -0.00704588f, -0.00081251f, 0.02076831f, 0.00853053f, 
    -0.03301197f, 0.02487844f, 0.02147967f, -0.00912562f, 0.01561571f, 0.01209606f, 0.02003475f, 0.03950116f, 
    -0.01782122f, -0.03139239f, -0.00806718f, -0.02562724f, 0.00033897f, 0.05100672f, 0.11776388f, 0.07183319f, 
    0.16287413f, 0.02481226f, 0.05786713f, -0.07514951f, -0.00997185f, 0.00240051f, -0.01905995f, -0.01047298f, 
    0.00085277f, -0.07338478f, -0.01709832f, -0.03390353f, -0.03962138f, -0.06959481f, 0.03035019f, -0.04263905f, 
    -0.12320977f, 0.18049814f, 0.05173530f, 0.13937713f, 0.01013895f, 0.04268464f, -0.03937755f, -0.01860364f, 
    0.05921791f, 0.02520494f, -0.05653475f, 0.00720960f, 0.06716924f, 0.00242277f, -0.02448906f, 0.06803533f, 
    -0.02613967f, 0.03237870f, 0.02950107f, -0.01435658f, 0.01981097f, -0.16484554f, -0.00614850f, -0.01386933f, 
    -0.07871523f, 0.01394397f, -0.03084161f, -0.04611643f, -0.09581530f, -0.02058929f, -0.01259754f, -0.01299385f, 
    -0.04712382f, -0.00286437f, -0.02568946f, 0.03808549f, -0.00564263f, -0.06710685f, -0.03105100f, -0.02205602f, 
    0.04264761f, -0.05056872f, -0.09540022f, 0.07651296f, 0.19180931f, 0.01613452f, 0.00507590f, -0.06276074f, 
    -0.00484249f, 0.02307450f, -0.09332144f, 0.07526633f, -0.05993809f, -0.08502796f, -0.01413445f, -0.04616008f, 
    -0.09904329f, 0.01189122f, 0.01368348f, 0.00045830f, 0.18654749f, -0.13043445f, 0.07718970f, -0.00128122f, 
    0.07190121f, -0.04299472f, 0.00562585f, -0.03211435f, -0.03477357f, 0.04383084f, -0.04090387f, -0.02830296f, 
    -0.05172022f, -0.01153030f, -0.06028699f, -0.08614890f, 0.04893110f, -0.02683441f, 0.09936398f, -0.01318965f, 
    0.08520391f, -0.06210663f, 0.02289714f, -0.00540977f, 0.17763390f, 0.01056700f, -0.04032075f, -0.03141239f, 
    -0.02976462f, 0.01830630f, -0.02190945f, 0.06683282f, -0.02251718f, 0.02945393f, -0.03888238f, -0.01004195f, 
    -0.01531701f, 0.01191781f, 0.00540149f, 0.01788856f, -0.01454803f, 0.04152709f, 0.17651133f, 0.04961859f, 
    0.10732814f, 0.04378010f, 0.08803799f, -0.00633311f, 0.00470673f, -0.05859982f, -0.02749583f, -0.02907836f, 
    -0.01867956f, -0.03939672f, -0.00611204f, -0.05920146f, 0.04688819f, -0.00872539f, -0.01393891f, -0.00408555f, 
    -0.12312096f, -0.09388395f, -0.20015629f, -0.11421078f, -0.06978031f, -0.02672951f, -0.03377900f, -0.00535292f, 
    -0.04836031f, -0.05666263f, -0.05787366f, 0.00767918f, 0.01519025f, -0.05511224f, 0.00030673f, 0.01288571f, 
    0.04462968f, -0.04624796f, -0.01145566f, 0.03382403f, 0.10939164f, -0.23271148f, -0.01422366f, -0.08499241f, 
    -0.06965240f, -0.08830968f, -0.04760056f, -0.03106209f, -0.02034157f, 0.00021239f, 0.03353160f, 0.01222368f, 
    -0.03115699f, -0.01147259f, -0.01512636f, -0.00595606f, 0.00475325f, -0.05247156f, -0.01400522f, -0.01946766f, 
    0.04953758f, 0.14964770f, -0.08368496f, 0.04694730f, 0.01445493f, 0.08498432f, 0.00950341f, -0.07233316f, 
    0.00775038f, -0.03036848f, -0.01115044f, -0.00029711f, -0.01249154f, 0.06382000f, 0.03334105f, -0.04025557f, 
    0.00488402f, 0.06126026f, 0.08218898f, -0.04258841f, 0.02522982f, 0.14695901f, -0.22828282f, -0.01632557f, 
    -0.03867263f, 0.03520679f, 0.03410089f, -0.04055595f, -0.06825826f, 0.03442221f, 0.04904096f, 0.04334561f, 
    0.07162400f, 0.04344979f, 0.05477100f, -0.00865292f, -0.05693886f, -0.08008677f, 0.03862697f, 0.02971018f, 
    -0.07998025f, 0.16207190f, -0.07002209f, -0.11006030f, -0.14781274f, -0.08753804f, 0.04654145f, -0.01598789f, 
    -0.02708174f, 0.00083257f, 0.02752202f, -0.01271958f, 0.06680451f, 0.04744202f, -0.00561262f, -0.02323091f, 
    -0.01211824f, -0.17634691f, -0.03726140f, 0.09165015f, -0.17797939f, -0.11885361f, -0.13259700f, -0.21836542f, 
    -0.09931795f, 0.02543962f, -0.02715242f, -0.05640728f, -0.07445153f, -0.09785388f, 0.01574585f, 0.02507388f, 
    0.05525845f, -0.01901511f, -0.00212569f, -0.00372048f, 0.03656774f, 0.00120476f, -0.16610135f, -0.00332955f, 
    0.01496090f, 0.18213309f, -0.14465502f, 0.05347479f, 0.03505778f, 0.06820215f, -0.05569433f, 0.00962937f, 
    -0.07979525f, 0.03593093f, -0.01879241f, 0.03789289f, -0.01627370f, 0.10850548f, 0.00569592f, 0.06443027f, 
    -0.05008632f, 0.00808726f, 0.04763503f, 0.08036251f, -0.05386993f, -0.10080632f, 0.06509273f, 0.05392266f, 
    0.14207859f, 0.04994233f, 0.03201951f, -0.03691442f, -0.00245944f, -0.03946771f, 0.04677529f, 0.04954416f, 
    0.00750903f, 0.00647078f, 0.01594003f, -0.04208148f, 0.01637689f, 0.05804599f, 0.02874719f, -0.00803449f, 
    -0.06517344f, 0.01829945f, 0.00397555f, -0.01556326f, 0.01198069f, 0.02092134f, -0.03530246f, -0.10877588f, 
    -0.07181825f, 0.03424737f, 0.02234166f, -0.00881354f, -0.02614633f, -0.02053281f, 0.01725062f, 0.02172558f, 
    -0.00346919f, -0.05895871f, -0.05628064f, 0.09075490f, 0.01615684f, 0.06282829f, -0.25476044f, 0.00337021f, 
    -0.13796966f, 0.02093647f, -0.03913307f, -0.02908821f, -0.16163602f, -0.01581236f, 0.08195049f, -0.03576753f, 
    0.00328445f, 0.01873138f, 0.06026666f, -0.00191992f, -0.11305719f, -0.08905838f, 0.01550027f, -0.04722258f, 
    -0.04674417f, -0.10923444f, 0.14931247f, 0.08716632f, 0.15126787f, -0.07744627f, -0.02236317f, 0.05150820f, 
    -0.09783202f, 0.05199916f, 0.06874293f, -0.04082735f, -0.06524297f, -0.01372285f, 0.06370199f, -0.01065353f, 
    -0.03547496f, 0.04564021f, 0.04133675f, 0.02675562f, -0.04159427f, 0.15825552f, 0.01810361f, -0.08436617f, 
    0.00697084f, -0.04088083f, -0.02865111f, -0.00824525f, -0.03040945f, -0.08318301f, 0.03992226f, 0.04273416f, 
    0.01690626f, -0.03103165f, -0.01322835f, -0.11719801f, 0.05782653f, -0.03508339f, -0.01102574f, -0.09201472f, 
    0.12586278f, 0.12513697f, -0.02438068f, -0.06189950f, 0.07459901f, -0.00425122f, 0.07237374f, -0.09039287f, 
    0.01191822f, -0.06962379f, -0.01337234f, -0.05359982f, 0.01901084f, -0.07751922f, 0.02897373f, -0.05648745f, 
    -0.01995081f, 0.04227341f, -0.01430749f, -0.02568002f, -0.12540686f, 0.01199792f, 0.02151832f, -0.06731808f, 
    0.02816168f, -0.02596583f, -0.08500446f, -0.03517644f, -0.09848931f, 0.06542108f, 0.03899775f, 0.02451852f, 
    0.00699120f, -0.02008269f, 0.08202992f, -0.04401571f, 0.01728717f, 0.01831837f, 0.09413273f, -0.08924996f, 
    -0.04054602f, 0.01124259f, -0.01330209f, 0.03944583f, 0.11557987f, 0.09510918f, 0.04814055f, -0.03767579f, 
    0.01185580f, -0.06033235f, 0.02530647f, 0.02629153f, -0.00705253f, -0.00481704f, -0.03928528f, -0.03262565f, 
    0.02140115f, 0.06211467f, 0.06510078f, -0.09267118f, -0.09482113f, 0.04054638f, 0.13612917f, -0.00893515f, 
    -0.13463049f, -0.01125464f, 0.02170869f, -0.02909432f, 0.06690188f, -0.02569288f, 0.00324972f, 0.05534823f, 
    0.00120581f, 0.06881224f, 0.04494224f, 0.00825745f, 0.01568825f, -0.04413084f, 0.06888770f, 0.01472874f, 
    -0.20515251f, -0.12234704f, 0.17219803f, -0.06665735f, -0.02932538f, -0.01938927f, 0.05304521f, 0.05566287f, 
    0.00616761f, -0.09197233f, 0.03434182f, -0.01211038f, 0.09533824f, 0.03525747f, 0.03879440f, 0.07804137f, 
    0.06829283f, -0.01015176f, -0.26723206f, 0.02317946f, -0.10008458f, -0.06581590f, 0.02754174f, 0.05986734f, 
    0.10159385f, 0.00817749f, 0.03458505f, -0.02555696f, -0.05756123f, -0.02281489f, -0.00752978f, 0.03570889f, 
    0.03864704f, -0.00790913f, 0.02542093f, -0.03440121f, 0.05118763f, 0.07044928f, -0.00167737f, -0.03227046f, 
    0.02887760f, 0.08601079f, -0.19697930f, 0.05484687f, -0.07829236f, 0.06349616f, -0.04921961f, -0.06403273f, 
    -0.03256058f, -0.00939226f, 0.01548394f, -0.01199665f, 0.00008758f, 0.05646380f, 0.03177924f, 0.01404633f, 
    -0.04640660f, -0.13007161f, 0.08064789f, -0.02934163f, -0.24230817f, 0.12729563f, 0.12291498f, -0.14560118f, 
    -0.13565609f, 0.00469184f, 0.05444222f, 0.06675687f, 0.01489045f, 0.00201610f, 0.01572573f, -0.07160418f, 
    -0.01358756f, -0.00986731f, 0.00585281f, -0.01317334f, 0.01531913f, 0.01681980f, 0.04781611f, 0.01423971f, 
    0.05058772f, -0.11432736f, -0.14669299f, -0.04644669f, -0.04898648f, -0.05926500f, 0.04882559f, -0.02243526f, 
    -0.07408179f, -0.00241892f, 0.02848008f, 0.05240181f, 0.02997422f, 0.03970209f, 0.05032158f, 0.07078113f, 
    -0.04734782f, -0.07117541f, 0.06296804f, 0.01471070f, -0.07828583f, 0.02347679f, 0.12244307f, -0.08061343f, 
    -0.07808287f, -0.06159569f, 0.02542995f, 0.00973887f, -0.01314508f, 0.01063457f, 0.00323574f, 0.03268670f, 
    0.01653099f, 0.04356508f, -0.03071127f, 0.02731880f, 0.00419396f, -0.05085182f, -0.07153337f, 0.02170006f, 
    -0.21689959f, 0.22626144f, 0.06332029f, -0.15587890f, -0.13020141f, 0.02265140f, 0.04147889f, -0.04985252f, 
    0.03647566f, -0.13729036f, 0.04832053f, -0.03987204f, -0.02261493f, -0.01961513f, 0.07119465f, -0.11779035f, 
    0.07137565f, 0.04764865f, 0.05089672f, 0.00805779f, -0.13961831f, -0.04791252f, 0.14104503f, 0.03852934f, 
    0.04593586f, -0.05134322f, -0.04968087f, 0.04230762f, 0.01037849f, 0.02092983f, -0.09341202f, 0.01813652f, 
    -0.05512701f, 0.05233668f, 0.03821069f, -0.01555277f, 0.08243856f, 0.01132855f, -0.00597578f, 0.04936077f, 
    0.21467187f, 0.15445276f, -0.06326187f, 0.07118937f, 0.05821063f, -0.09785105f, -0.03505234f, -0.05051507f, 
    -0.04375638f, -0.06620974f, 0.02594982f, -0.00321914f, 0.01006187f, -0.07443585f, 0.07150999f, 0.00222996f, 
    -0.00435855f, 0.02112950f, 0.08177898f, -0.02873601f, 0.07953671f, -0.10061643f, -0.14013197f, 0.03532965f, 
    0.01300012f, -0.06303567f, -0.03888035f, -0.05408803f, -0.03910989f, -0.00967397f, 0.01313613f, -0.03697643f, 
    -0.04552528f, -0.02509661f, 0.10190293f, -0.00082717f, -0.01435717f, -0.01387276f, 0.03732497f, 0.06407750f, 
    0.09635021f, -0.00724334f, 0.02770871f, 0.08093053f, 0.12537025f, -0.08122197f, -0.08033665f, -0.04253163f, 
    -0.13511938f, 0.08099591f, -0.02689489f, -0.08932403f, -0.01974668f, -0.06944869f, 0.03067605f, 0.03142941f, 
    0.00498819f, 0.00876402f, 0.08366884f, -0.03362307f, -0.08544464f, -0.07467358f, -0.15671448f, -0.20156610f, 
    -0.03942868f, 0.07751130f, 0.00145138f, -0.02945411f, -0.00960083f, -0.02405409f, 0.03063663f, 0.01741871f, 
    -0.04237157f, -0.00514681f, -0.04778031f, 0.02849151f, 0.03428698f, 0.01632326f, -0.08400911f, -0.01701672f, 
    -0.11402851f, -0.10588670f, 0.16582373f, -0.06634458f, 0.02415796f, -0.04417034f, -0.01239522f, -0.02027567f, 
    0.01977434f, -0.02093377f, -0.02396617f, -0.00101336f, -0.00153732f, -0.03266704f, 0.02355959f, -0.03706535f, 
    -0.05362653f, 0.01766780f, 0.00068769f, 0.01348739f, -0.01135371f, -0.10589103f, 0.15584546f, -0.03471803f, 
    0.06037916f, -0.06802624f, -0.06239128f, 0.01378340f, -0.03421843f, -0.11883098f, -0.00822871f, -0.00504213f, 
    -0.01238962f, -0.08778627f, 0.02919673f, -0.02986002f, -0.07402452f, -0.00441513f, 0.06349207f, 0.02356723f, 
    -0.13976189f, -0.11039764f, 0.04811453f, -0.19782525f, -0.16527630f, 0.03365124f, -0.03450871f, -0.00515355f, 
    -0.02520182f, -0.02652144f, 0.01615747f, 0.06530319f, -0.00209327f, 0.03240271f, -0.03830326f, -0.02369485f, 
    -0.04589901f, -0.04619596f, -0.13574584f, -0.00667186f, 0.09638929f, 0.04400241f, -0.02066297f, 0.06077483f, 
    0.03765114f, -0.04951615f, 0.00931333f, -0.06234732f, -0.03560685f, 0.00987323f, -0.00373702f, 0.02256144f, 
    0.03415941f, -0.01175091f, -0.04939864f, 0.01668141f, -0.02002680f, -0.07345185f, 0.06389429f, -0.00435651f, 
    -0.05612662f, -0.02294226f, -0.10556719f, -0.04976825f, 0.01747026f, 0.11394945f, 0.02273774f, -0.06173774f, 
    -0.10258993f, -0.11007027f, -0.00889600f, -0.00077774f, 0.05264755f, -0.00073473f, -0.10377871f, 0.01690853f, 
    0.12053788f, 0.05117386f, -0.06530567f, -0.04122172f, -0.12458372f, -0.05947641f, 0.16263875f, -0.02571794f, 
    0.00085027f, -0.00434194f, -0.03745154f, 0.02741913f, -0.03283729f, 0.01608619f, 0.01991724f, -0.02352178f, 
    -0.04145943f, -0.06361274f, 0.03231319f, -0.00415926f, -0.05544463f, -0.00858402f, -0.02290784f, 0.01667865f, 
    -0.09089558f, 0.09892690f, 0.04508368f, 0.02698213f, 0.06885026f, -0.04478150f, -0.01896599f, 0.08717158f, 
    0.00524854f, 0.05394046f, 0.02834998f, -0.00538690f, -0.17080300f, -0.02187793f, 0.09787765f, 0.00812483f, 
    0.01417277f, 0.02835439f, 0.03817123f, -0.00954615f, -0.14478645f, -0.00369041f, -0.15130632f, -0.07583213f, 
    -0.13276966f, 0.03019861f, -0.03394977f, -0.09269577f, 0.03411583f, -0.05106781f, 0.10288183f, 0.07779320f, 
    0.03023968f, -0.05182276f, 0.03939501f, -0.06072536f, 0.01221696f, -0.05159821f, 0.08301631f, -0.04725633f, 
    -0.09108527f, -0.10622828f, 0.00721359f, -0.27230743f, 0.03464201f, -0.02106280f, 0.01659065f, -0.11445615f, 
    -0.06968241f, -0.00962564f, 0.09539776f, 0.00085468f, 0.04434988f, 0.02645036f, -0.03382554f, -0.03115595f, 
    0.05761579f, 0.04015923f, -0.09179877f, -0.00381166f, -0.11615497f, -0.08329032f, -0.00852528f, -0.07006477f, 
    -0.12437747f, 0.02094969f, 0.00980521f, 0.00197413f, -0.01115145f, -0.02689236f, 0.00161187f, 0.00511565f, 
    -0.01413889f, 0.09629624f, -0.01366793f, 0.03705100f, 0.01273784f, -0.04257396f, -0.12554869f, 0.07922970f, 
    0.03615839f, -0.03984757f, -0.04032525f, 0.08443195f, -0.01058661f, -0.00192425f, -0.05949651f, -0.02010785f, 
    0.01368166f, -0.03079219f, 0.02066690f, -0.08420011f, -0.02689835f, 0.00548736f, 0.01006805f, 0.00065675f, 
    0.01283244f, -0.03689461f, 0.02254403f, 0.04563674f, -0.06792960f, 0.05446989f, -0.21999164f, -0.06333300f, 
    -0.00363600f, 0.03631863f, 0.00047947f, -0.05886110f, -0.01858534f, -0.03413098f, 0.01235775f, -0.02740144f, 
    0.00774703f, 0.00540305f, 0.04232207f, 0.05389904f, -0.05767851f, -0.06460544f, 0.04473004f, 0.02344376f, 
    0.05696826f, 0.00964050f, 0.03067304f, 0.14828409f, 0.12176028f, -0.09356683f, -0.08969351f, -0.03443274f, 
    -0.10874201f, 0.05041609f, -0.01653560f, 0.00553558f, -0.03111784f, -0.03344036f, -0.00179765f, 0.06824402f, 
    -0.06987578f, 0.02566081f, 0.06586186f, -0.05362790f, 0.09445331f, -0.02106661f, -0.12073583f, -0.06912255f, 
    0.04307936f, 0.03087986f, -0.00359447f, -0.00227208f, -0.03440696f, -0.02124286f, 0.00363267f, 0.03070479f, 
    0.06904087f, 0.03813614f, 0.03484990f, 0.02630743f, 0.02868235f, 0.06393341f, 0.01845867f, 0.04542241f, 
    0.03769400f, -0.10475022f, 0.14699130f, -0.00131535f, 0.11145198f, -0.09742757f, 0.04276021f, 0.03582867f, 
    -0.05863878f, 0.06692252f, -0.01223669f, -0.04509836f, 0.02893934f, -0.04096240f, -0.05217095f, -0.00704268f, 
    -0.02352607f, 0.01615837f, -0.02290588f, 0.06983118f, -0.20129858f, 0.06312616f, 0.08555695f, -0.01872994f, 
    -0.11435219f, 0.02281080f, 0.02643185f, 0.00590901f, -0.02533641f, -0.06241158f, -0.01623572f, 0.01700079f, 
    -0.06679010f, 0.06230135f, -0.01881247f, 0.00513103f, 0.02548072f, -0.03481030f, -0.06413449f, 0.00287460f, 
    0.13927743f, 0.12776074f, 0.06847122f, 0.03297153f, 0.11456310f, 0.01792818f, -0.00249390f, -0.09021469f, 
    -0.00370340f, -0.06275543f, 0.02412363f, -0.03460544f, -0.05178661f, -0.04777205f, -0.00100409f, -0.07063821f, 
    -0.03696179f, 0.08364954f, 0.00824728f, -0.03116552f, 0.13638878f, 0.06733483f, -0.02865620f, -0.04713999f, 
    0.04043723f, 0.04049866f, 0.01138052f, -0.04614447f, -0.00751520f, 0.01963310f, 0.02274457f, 0.05029726f, 
    -0.00099308f, 0.03306622f, -0.04634254f, 0.05952537f, 0.01403588f, 0.05930672f, -0.02280506f, 0.01300357f, 
    0.04750684f, 0.01822483f, -0.00462880f, 0.06709862f, -0.01990074f, 0.02237857f, -0.00757337f, -0.07678772f, 
    -0.05484314f, 0.07091391f, 0.01245215f, -0.03805028f, -0.03038100f, 0.02212204f, -0.05976990f, 0.01571588f, 
    -0.00222769f, -0.03308311f, 0.02676501f, -0.03133863f, 0.13383697f, 0.02143929f, -0.01124418f, 0.02689751f, 
    0.16587190f, 0.06792609f, 0.03674349f, -0.07707313f, -0.03410988f, -0.04874370f, -0.01026974f, 0.00454156f, 
    -0.01140221f, -0.01812505f, 0.00786689f, -0.03981161f, 0.02054268f, 0.07654262f, 0.03992173f, 0.03465846f, 
    -0.17791346f, 0.11819097f, 0.06794146f, -0.07459630f, -0.27497020f, -0.08709481f, 0.02557809f, -0.03308451f, 
    0.00461750f, -0.06893684f, 0.08790141f, 0.05866593f, -0.00325271f, -0.02070969f, 0.07556957f, -0.07798274f, 
    -0.04412887f, -0.14642775f, 0.10691258f, 0.00842221f, 0.06743451f, -0.00532598f, -0.16204724f, -0.01660737f, 
    0.05409040f, 0.06895187f, 0.01819878f, -0.01495350f, -0.03832493f, -0.00938821f, -0.01378947f, 0.00271724f, 
    -0.01254284f, 0.02312662f, -0.00927035f, 0.05343929f, 0.01049191f, 0.02189975f, 0.01078462f, 0.00972994f, 
    0.10484575f, 0.06236296f, 0.05492801f, 0.04259179f, 0.17534672f, -0.02840315f, -0.03917698f, -0.05058084f, 
    -0.00979269f, -0.06803104f, -0.04351924f, 0.01390446f, 0.03206376f, -0.04490025f, -0.01558964f, 0.01143115f, 
    0.00762113f, 0.02517924f, 0.02964055f, 0.05083942f, -0.04138089f, 0.04310144f, -0.24313864f, 0.10206310f, 
    -0.06055565f, 0.00861651f, -0.01635696f, -0.05718264f, -0.08808126f, 0.02652756f, 0.07379426f, 0.07531828f, 
    0.07549805f, -0.05296395f, -0.03062136f, -0.01002204f, -0.06394373f, -0.09746917f, 0.06690089f, -0.00306906f, 
    0.08673779f, 0.12109183f, -0.06468502f, 0.05268342f, -0.01953424f, -0.09262180f, 0.00742230f, 0.03462935f, 
    -0.05412755f, 0.03951825f, 0.02808136f, -0.01354504f, 0.03973713f, 0.02919222f, 0.02154529f, -0.00379830f, 
    0.01928085f, -0.01304797f, 0.05402160f, 0.00778848f, 0.11904691f, 0.10685454f, -0.08079981f, 0.10293931f, 
    0.08554681f, -0.01197817f, -0.09927806f, -0.03128550f, -0.00191796f, -0.01355355f, -0.00308968f, -0.05584527f, 
    -0.01420222f, -0.03154857f, 0.02478743f, 0.05180598f, 0.03044951f, 0.01007977f, 0.03487296f, 0.04156345f, 
    -0.18378329f, -0.05511946f, 0.02685564f, -0.25814277f, -0.15065727f, -0.02864689f, -0.07000840f, 0.02046865f, 
    0.01083729f, -0.02570819f, 0.04395995f, -0.02258868f, 0.02992168f, 0.01047225f, 0.09062438f, 0.05610486f, 
    -0.07675232f, 0.07608653f, -0.11362783f, 0.00618700f, -0.02875445f, 0.13475370f, -0.10227340f, -0.09908651f, 
    -0.23605621f, -0.05906349f, 0.03446515f, -0.00495222f, -0.04149935f, -0.01534279f, 0.04006531f, 0.02355537f, 
    0.02888488f, -0.08234517f, 0.06725412f, -0.13879427f, -0.02738022f, -0.14268556f, -0.05075863f, -0.01107038f, 
    -0.04574906f, 0.09993451f, -0.12446292f, -0.06347223f, -0.04252158f, -0.00497320f, 0.07295436f, -0.01076411f, 
    0.01994903f, -0.06783795f, 0.01087604f, 0.02980857f, -0.02847286f, -0.10005581f, -0.01544229f, -0.03774666f, 
    0.00911379f, -0.07515813f, 0.08216911f, -0.01879803f, -0.14000547f, -0.14688031f, 0.15210223f, 0.01299866f, 
    0.02146206f, 0.04840336f, -0.04826191f, 0.01514554f, -0.06049087f, 0.05364802f, -0.02140650f, -0.00407839f, 
    -0.00270741f, 0.04646402f, -0.00458064f, -0.06696144f, -0.02804932f, 0.03824976f, -0.05744528f, 0.01150482f, 
    -0.16182071f, -0.00778134f, 0.01520075f, -0.14852314f, -0.20377675f, -0.02194082f, -0.06147412f, -0.13631171f, 
    0.04071638f, -0.00206136f, 0.06136997f, 0.03077176f, -0.01225960f, -0.10197540f, 0.10910114f, -0.09677532f, 
    0.03366859f, -0.14708424f, 0.06978823f, -0.04654475f, 0.12908621f, 0.04664592f, 0.00835524f, 0.06330755f, 
    0.11227056f, -0.03175056f, -0.01838419f, -0.04397053f, -0.03284622f, -0.05512172f, -0.05995592f, -0.01003311f, 
    0.00184549f, -0.08241959f, 0.03397194f, -0.00241481f, 0.02924997f, 0.04937103f, 0.06498088f, -0.03315030f, 
    -0.07363171f, -0.10001013f, 0.09593768f, -0.15006752f, -0.09406531f, -0.03603898f, -0.07123535f, -0.01281256f, 
    -0.10587637f, -0.01942116f, -0.03126496f, 0.00882329f, 0.01102197f, 0.03067209f, -0.10219842f, 0.05744708f, 
    -0.07060269f, 0.03808410f, -0.15840796f, -0.09960379f, 0.05823449f, -0.13293864f, 0.11320201f, -0.03112942f, 
    0.02920835f, -0.01624326f, 0.02322687f, -0.02161881f, -0.06282949f, -0.07605552f, -0.03843181f, 0.05307224f, 
    0.06259273f, 0.00572817f, 0.01747916f, 0.01869672f, 0.01002202f, 0.01417324f, -0.09927031f, 0.07325745f, 
    -0.13079736f, -0.12927671f, -0.04227713f, -0.23388688f, -0.07866931f, 0.00671173f, 0.01367370f, -0.03653807f, 
    -0.00119801f, -0.04676163f, 0.07161167f, 0.00977436f, 0.03960330f, 0.02189098f, -0.06800476f, 0.01984466f, 
    0.06527878f, 0.05068099f, -0.18433541f, -0.04480647f, -0.09049069f, -0.12514217f, 0.12679514f, -0.06550330f, 
    -0.03193194f, -0.04785719f, -0.03070152f, 0.05979871f, -0.03447707f, -0.06261745f, 0.03166467f, 0.01793905f, 
    -0.03241623f, -0.02281042f, 0.03446112f, -0.06118951f, -0.05342148f, -0.10322522f, 0.02566672f, -0.01165055f, 
    -0.05529015f, -0.16824573f, -0.05143375f, -0.05508399f, 0.11482219f, 0.11812055f, 0.05487300f, -0.05395143f, 
    -0.00089901f, 0.01725036f, 0.06346758f, 0.04647452f, -0.09873638f, 0.05364463f, -0.00223733f, -0.02838869f, 
    0.00586733f, 0.06535259f, 0.02644114f, -0.03932967f, 0.08634073f, -0.01996527f, -0.09788057f, 0.10292479f, 
    0.07616603f, 0.09079229f, 0.02142648f, -0.03658413f, -0.05672979f, -0.05458198f, 0.02100653f, 0.02654913f, 
    -0.03192635f, -0.01540342f, -0.01296862f, -0.00521898f, -0.02029006f, 0.07097090f, 0.04630904f, -0.02020626f, 
    0.11405134f, -0.02714308f, 0.13103837f, -0.15095863f, -0.08159739f, -0.00482068f, 0.07526939f, 0.02433144f, 
    0.05433485f, 0.00691714f, -0.00421316f, 0.04442444f, 0.02576481f, -0.07233583f, 0.13929479f, -0.02821115f, 
    0.04395238f, 0.01252931f, -0.14386047f, -0.06108159f, -0.25255030f, 0.09465241f, 0.15409236f, -0.01996793f, 
    -0.08587015f, 0.04263258f, 0.01419916f, -0.04253477f, 0.00713368f, -0.06872582f, 0.01576076f, 0.04493228f, 
    0.02475663f, 0.07698996f, -0.06266094f, 0.02732792f, 0.04974353f, 0.06170543f, -0.01874616f, -0.01852082f, 
    -0.27429631f, -0.01728656f, -0.18195379f, 0.06019729f, -0.07459694f, 0.02691877f, 0.06856391f, -0.01860168f, 
    -0.02339152f, -0.04116673f, -0.13020222f, 0.05933036f, -0.05827729f, 0.05727469f, 0.08063542f, 0.03469867f, 
    -0.03121225f, 0.03534911f, 0.02046514f, 0.06135184f, -0.09910178f, -0.06529807f, -0.05769011f, -0.08600869f, 
    -0.06703047f, -0.10761500f, 0.09218692f, 0.02270239f, 0.02505985f, -0.01232733f, 0.00727766f, 0.07409199f, 
    0.01873257f, -0.00932287f, -0.02232815f, 0.02131090f, 0.02063440f, 0.02283745f, 0.03796145f, 0.06469160f, 
    0.05400627f, -0.22075801f, 0.07792406f, 0.05047299f, -0.23671640f, 0.08099205f, -0.06943852f, -0.11972803f, 
    0.16050367f, 0.03204345f, -0.00253950f, -0.04728311f, 0.03708056f, -0.14127222f, 0.08343897f, -0.00025231f, 
    -0.01873885f, -0.16943762f, -0.05877373f, -0.03580679f, 0.08498084f, -0.30741689f, 0.08091857f, -0.01618568f, 
    -0.03501042f, -0.03844413f, 0.05998288f, -0.09145767f, -0.01068476f, 0.03210592f, -0.05958047f, -0.00106883f, 
    0.06928448f, -0.02484978f, -0.03608418f, -0.01292880f, 0.06359190f, 0.01011292f, -0.02457498f, -0.01681050f, 
    0.13964750f, -0.44315428f, -0.04032395f, 0.09651759f, -0.19612317f, -0.08045084f, 0.01331539f, -0.02463720f, 
    0.00783633f, -0.03257550f, -0.07404560f, -0.01457538f, 0.07390593f, -0.03315068f, 0.02804294f, 0.09693164f, 
    0.03325452f, -0.01600510f, 0.00055917f, -0.04935832f, 0.31279376f, -0.21355346f, -0.01111460f, -0.01531212f, 
    0.26842564f, -0.16955866f, -0.09690761f, 0.04979577f, 0.07452320f, -0.03678441f, 0.09335487f, -0.08311095f, 
    0.07277671f, 0.00591064f, -0.00883414f, 0.01064388f, 0.06192407f, 0.06039879f, 0.05860370f, 0.13474360f, 
    0.10104483f, -0.07920622f, -0.11307733f, 0.17059651f, -0.02356901f, -0.04517271f, 0.00791130f, -0.09333906f, 
    -0.00586296f, 0.08847791f, -0.02704730f, 0.06290774f, -0.00729487f, -0.03195136f, 0.04161150f, -0.02577908f, 
    0.02533995f, -0.03691436f, 0.04299965f, 0.00859244f, 0.32222834f, 0.15918480f, 0.00379729f, -0.00560431f, 
    0.08072418f, -0.00095433f, 0.01132452f, -0.02913157f, 0.02931764f, -0.00503353f, -0.05185896f, -0.03805291f, 
    0.02502960f, 0.07998956f, 0.04541689f, 0.08432057f, -0.00760523f, 0.11042402f, -0.02985122f, 0.00629804f, 
    -0.01887051f, 0.03554077f, -0.14364293f, 0.04657405f, -0.12279566f, -0.08275394f, 0.01880394f, 0.17570440f, 
    0.14895441f, -0.18365142f, 0.03831488f, -0.01600087f, 0.00452813f, -0.04288511f, 0.01368014f, 0.12142082f, 
    -0.07546257f, -0.00851010f, -0.10838575f, 0.02159664f, 0.20557939f, -0.37970215f, 0.13256288f, -0.04181996f, 
    0.16645128f, -0.06720471f, -0.00064634f, 0.02457974f, -0.00501409f, -0.10435300f, 0.04880154f, -0.02230068f, 
    0.01976670f, 0.03725154f, -0.00650732f, 0.02144442f, 0.03795193f, -0.08715930f, 0.02085778f, 0.02958559f, 
    0.03773565f, -0.06956576f, 0.14921497f, -0.02120727f, -0.26706129f, 0.03349588f, 0.05229006f, 0.03497364f, 
    -0.01236571f, 0.09725878f, 0.04084657f, -0.04935823f, -0.00111502f, -0.05278113f, -0.02012484f, -0.00501331f, 
    0.00487455f, -0.05849980f, -0.04223628f, -0.07542808f, -0.31369701f, -0.19443408f, 0.10038010f, 0.04679701f, 
    0.02308917f, -0.03467970f, 0.09006870f, 0.03660717f, 0.01551166f, -0.03614621f, -0.07307579f, 0.05186033f, 
    0.05344619f, -0.02815380f, -0.10037334f, 0.01582135f, -0.03417297f, -0.00183320f, 0.06168466f, -0.00371628f, 
    0.17696667f, 0.01467915f, -0.26459798f, 0.14224903f, 0.02229687f, -0.05183382f, -0.01617017f, -0.04212882f, 
    -0.03367831f, 0.05068105f, -0.06173923f, -0.04559035f, -0.02212507f, -0.04576531f, 0.09718265f, 0.17913547f, 
    0.04814124f, -0.00220548f, 0.01721951f, 0.17367041f, 0.05823950f, -0.06184436f, 0.00794080f, -0.12819575f, 
    -0.17368717f, -0.00729396f, 0.07848240f, -0.12815677f, 0.00601849f, -0.00745476f, -0.05980070f, -0.02316923f, 
    -0.06048053f, -0.01759635f, -0.04479630f, 0.04764451f, 0.01827778f, 0.02592595f, -0.02475356f, 0.00786147f, 
    -0.07771575f, -0.06287212f, 0.14581440f, -0.10697289f, 0.15111834f, 0.03341775f, 0.00223662f, -0.00949812f, 
    0.00400928f, -0.05768285f, 0.04147958f, 0.01043088f, -0.02578589f, -0.01106432f, -0.10156570f, 0.02332524f, 
    0.06111895f, 0.07808596f, -0.05982147f, 0.09400027f, -0.19179213f, -0.13457732f, -0.01261958f, 0.17468058f, 
    -0.04819763f, -0.03091492f, 0.10193300f, -0.08105514f, -0.01716679f, 0.06812650f, -0.06990631f, 0.04067915f, 
    -0.06529009f, 0.01265863f, 0.10801041f, -0.01810133f, -0.04150075f, 0.02864032f, -0.06942198f, 0.00824115f, 
    -0.05645563f, -0.14266886f, 0.16854081f, -0.09245592f, 0.04608658f, -0.00620454f, 0.01682984f, 0.04924707f, 
    0.05166926f, 0.00710275f, 0.10239805f, -0.00409483f, -0.05835240f, -0.02079008f, -0.01731150f, -0.12453105f, 
    -0.10804374f, -0.01328158f, 0.00221570f, 0.01225907f, -0.04350716f, -0.07124075f, -0.04622782f, 0.14395282f, 
    0.03862904f, -0.04988194f, 0.01937606f, -0.00697644f, -0.06572095f, -0.02543173f, 0.05082681f, 0.02619064f, 
    -0.03633007f, -0.06967499f, -0.02510827f, -0.04195296f, 0.01203899f, -0.02254878f, 0.13202332f, 0.05052706f, 
    0.30226043f, 0.13987254f, -0.14766116f, 0.29859838f, -0.07433970f, -0.08910669f, 0.01276921f, 0.07436121f, 
    0.03273918f, -0.11173905f, -0.04582509f, -0.05191069f, 0.11015821f, 0.01285218f, 0.07578234f, 0.03926764f, 
    -0.02339532f, -0.05279922f, -0.09402052f, 0.00475462f, -0.32020658f, -0.22776659f, -0.15908529f, 0.05337397f, 
    -0.05106651f, -0.16369388f, 0.08210076f, -0.00790463f, 0.07494970f, 0.11880178f, -0.09029104f, 0.01965271f, 
    0.06214020f, -0.03489922f, 0.00938760f, -0.07431091f, -0.00691904f, 0.02493524f, 0.01440507f, 0.08345573f, 
    -0.59268773f, 0.24661756f, 0.15687096f, -0.04981919f, 0.09893256f, 0.15746285f, 0.06351057f, 0.00380986f, 
    -0.07958275f, -0.10511007f, 0.03585416f, 0.01197997f, -0.01885628f, 0.04037112f, -0.01403935f, 0.11180645f, 
    -0.00900975f, 0.03278963f, -0.06583908f, 0.06912436f, 0.05150246f, -0.22828178f, 0.21017531f, 0.02075125f, 
    0.22612931f, 0.03643349f, -0.02998171f, -0.01130191f, 0.00041364f, -0.06470697f, 0.03216225f, -0.09495604f, 
    0.01182992f, 0.05917467f, -0.00285895f, -0.01273417f, 0.06358183f, -0.15453267f, -0.08308510f, 0.01244174f, 
    0.18979092f, -0.33047405f, -0.01346616f, 0.08813781f, -0.01302128f, -0.01607170f, 0.09868132f, 0.04180510f, 
    0.04407964f, 0.04537592f, -0.03422882f, 0.01439437f, -0.02690474f, 0.07629888f, -0.04661421f, -0.04161127f, 
    0.02903581f, 0.02518228f, -0.02705127f, 0.09713601f, 0.05731790f, 0.05277243f, 0.06796425f, -0.32526511f, 
    -0.26958883f, -0.03146282f, -0.04344361f, -0.01289568f, -0.04888058f, 0.02712673f, 0.00751022f, 0.00560222f, 
    0.03167258f, -0.08405112f, -0.03846952f, -0.04204544f, 0.01764917f, -0.00410499f, 0.10046776f, -0.03736967f, 
    0.45725128f, -0.04374748f, -0.03582838f, -0.11729720f, 0.11257514f, 0.03294533f, -0.01902597f, 0.03310846f, 
    -0.00966655f, 0.13615292f, -0.06500822f, 0.00012321f, 0.01597865f, 0.13362516f, -0.01612354f, 0.05994354f, 
    0.03731620f, 0.01444256f, 0.06718311f, -0.08729478f, 0.14717011f, 0.02397641f, -0.09468143f, -0.03729304f, 
    0.14360762f, 0.12160962f, -0.12331343f, 0.01420949f, -0.04695839f, 0.18993327f, 0.01692170f, 0.00292208f, 
    0.07340363f, 0.13751341f, -0.01470209f, -0.06682593f, -0.01413241f, -0.01444628f, 0.01654011f, -0.12368002f, 
    -0.05318443f, -0.12905064f, -0.00720950f, 0.07682696f, 0.05140664f, -0.13441484f, 0.04362810f, 0.02277828f, 
    -0.00014427f, -0.03207237f, 0.02452268f, 0.02450074f, -0.05269982f, -0.03523391f, -0.03284680f, -0.00399370f, 
    0.03241915f, 0.02009418f, 0.08537475f, 0.03288399f, 0.42087284f, -0.40345818f, 0.04502790f, -0.00699810f, 
    0.03413381f, -0.06161406f, 0.03446928f, -0.00760977f, 0.07499678f, -0.03352284f, -0.05201413f, -0.02979810f, 
    0.05442042f, -0.01851906f, -0.00720558f, 0.01245079f, -0.04047830f, 0.01661652f, 0.01879637f, 0.08893372f, 
    0.13414490f, -0.04237214f, -0.11608751f, -0.18403412f, -0.45035121f, 0.04614532f, 0.03138383f, -0.02460310f, 
    0.02643482f, -0.11223958f, -0.06694511f, 0.02378788f, -0.01521088f, 0.14563695f, -0.03432223f, 0.03448180f, 
    -0.01064632f, -0.04817317f, 0.07386298f, 0.08456790f, -0.07151651f, -0.09284472f, -0.07223663f, 0.13999018f, 
    0.07936387f, 0.05521008f, -0.05533559f, -0.03173799f, -0.04297150f, 0.14163697f, -0.05015299f, -0.01861101f, 
    -0.04550478f, 0.02313721f, 0.03381313f, -0.04443644f, -0.11100858f, 0.00827780f, -0.02999450f, -0.02257072f, 
    -0.09357442f, -0.01426680f, -0.10906563f, 0.08904786f, -0.10608817f, -0.04559226f, 0.10006358f, -0.06005152f, 
    -0.00980389f, 0.05792771f, -0.06884714f, -0.06571572f, 0.02950876f, 0.11153327f, 0.03502774f, 0.01806557f, 
    -0.05225072f, -0.03218081f, -0.02051441f, -0.02422115f, -0.30417427f, 0.04504230f, 0.16382374f, -0.38752329f, 
    -0.15927787f, -0.13094138f, 0.01688913f, 0.02732277f, -0.00379057f, 0.05856034f, 0.02340419f, -0.13260062f, 
    0.06331588f, -0.05992582f, 0.04021301f, 0.05023696f, 0.00026506f, 0.04260991f, -0.16100109f, -0.11525992f, 
    0.04997504f, -0.14264017f, 0.01949381f, -0.24166071f, -0.30985743f, -0.04180683f, 0.05683693f, -0.00587024f, 
    0.01968315f, -0.06129181f, 0.05107066f, 0.01156407f, -0.03823220f, -0.01016886f, 0.01327011f, -0.10367556f, 
    0.17878358f, 0.01204042f, 0.13498947f, 0.03887534f, -0.07266543f, -0.18893886f, 0.03655603f, 0.05867663f, 
    -0.03013868f, -0.08028865f, 0.06085718f, -0.04107355f, -0.02420303f, 0.01585993f, 0.03959591f, 0.01637668f, 
    0.04336398f, -0.11979700f, 0.01174103f, -0.02836845f, -0.02008923f, -0.08175847f, 0.09186590f, 0.04610215f, 
    -0.14426981f, -0.06047945f, 0.06623039f, 0.14436209f, 0.01914279f, 0.08332585f, -0.02569197f, 0.05259480f, 
    0.06476712f, 0.00337106f, -0.02257937f, 0.01361294f, 0.05892549f, 0.04351873f, -0.10190912f, 0.00764861f, 
    -0.05721864f, -0.05727311f, 0.03975404f, 0.04427749f, -0.27372745f, 0.04176101f, 0.19591109f, -0.08188490f, 
    -0.17181470f, 0.01010504f, 0.01816976f, -0.00597368f, -0.03646614f, 0.05617673f, 0.01816564f, -0.02122049f, 
    -0.00338462f, -0.07484099f, -0.08353846f, 0.00294037f, 0.01466853f, 0.05374109f, 0.04563210f, -0.07162813f, 
    0.35385153f, -0.33465168f, 0.04004874f, 0.08551671f, -0.13900094f, 0.02651604f, -0.03232751f, -0.00367469f, 
    0.12436583f, 0.04447975f, -0.00198999f, 0.10079280f, 0.05004639f, -0.03717885f, -0.04341897f, 0.00045043f, 
    0.01523777f, -0.02977688f, 0.02224663f, 0.05198579f, -0.04870099f, 0.04329396f, 0.11303468f, -0.33324063f, 
    -0.11805491f, -0.02193010f, 0.09185326f, -0.17738399f, -0.01200999f, 0.03832015f, -0.01935350f, -0.04892784f, 
    -0.05195321f, -0.08092294f, -0.01822745f, -0.05565742f, -0.03721767f, -0.01306266f, 0.03522258f, 0.02136566f, 
    0.31662253f, -0.02202146f, 0.01086252f, -0.00606103f, -0.05320383f, 0.02576776f, -0.12162598f, -0.05087547f, 
    0.10137844f, 0.03165852f, -0.04310833f, 0.06824337f, 0.01879506f, 0.02167171f, 0.13223596f, 0.01270763f, 
    -0.08821024f, 0.04810560f, -0.06509427f, 0.01596780f, -0.10910021f, -0.10933568f, -0.04941728f, 0.13273989f, 
    -0.00681705f, -0.06753906f, 0.02294799f, -0.07481901f, -0.02522187f, 0.08178061f, 0.02280067f, 0.05283059f, 
    -0.04975498f, 0.03908470f, 0.03073883f, -0.03578336f, -0.04375251f, 0.02987349f, 0.07600704f, 0.01325739f, 
    -0.09694154f, -0.21936963f, 0.03650977f, -0.07619943f, -0.07890305f, 0.08359973f, 0.08132248f, -0.09292049f, 
    -0.00633754f, -0.09150435f, -0.04134753f, 0.05163667f, 0.00794466f, 0.06096977f, -0.03856792f, -0.03842071f, 
    -0.03396692f, -0.19423276f, -0.08493271f, -0.08072761f, 0.13201408f, 0.04533089f, 0.02509267f, -0.22921503f, 
    -0.21146122f, -0.03164637f, 0.03925742f, 0.11635342f, -0.06317385f, -0.00074027f, -0.03814051f, -0.05025975f, 
    -0.10003912f, -0.07640489f, -0.01365631f, 0.03318930f, 0.03154803f, -0.14100167f, 0.07062918f, -0.03225248f, 
    0.34879789f, -0.26585934f, 0.00809980f, 0.00780072f, 0.07772713f, -0.06953022f, -0.05018500f, 0.00525400f, 
    0.05852651f, 0.01245377f, 0.01684519f, -0.01869616f, -0.02711540f, -0.00011606f, -0.04837282f, 0.01694787f, 
    -0.03755457f, 0.01339237f, -0.06804265f, 0.08405373f, 0.07589041f, -0.18680888f, 0.15596621f, -0.15361913f, 
    -0.11856105f, 0.02017133f, 0.10284968f, -0.09012496f, -0.05003314f, -0.09268420f, 0.00452737f, -0.02749445f, 
    -0.03165724f, -0.03811004f, -0.04448628f, -0.06549017f, -0.01493744f, -0.10777611f, -0.01237445f, -0.07480048f, 
    -0.25883287f, 0.22707599f, 0.15058838f, 0.08198966f, 0.01902414f, 0.17848481f, 0.02245354f, -0.01211632f, 
    -0.00972870f, -0.01473727f, -0.08620650f, -0.09311017f, -0.00087908f, 0.09640451f, 0.19724101f, 0.08842129f, 
    0.02640398f, 0.00330368f, -0.12692021f, 0.05333715f, -0.02062325f, -0.00823881f, 0.10552220f, -0.12849893f, 
    -0.09483108f, 0.04421164f, 0.01568328f, -0.07599142f, -0.05459072f, 0.05972008f, -0.06609056f, -0.02090851f, 
    0.01786289f, -0.02575969f, 0.02490086f, -0.03351871f, -0.03878054f, 0.09078824f, 0.03959199f, -0.00433758f, 
    0.01679516f, -0.07234938f, -0.02497016f, -0.09020005f, -0.12403146f, -0.00901425f, 0.07154941f, -0.05270890f, 
    -0.07993965f, -0.04247446f, 0.08309036f, 0.01512403f, -0.04824006f, 0.16233651f, -0.05341169f, 0.00126270f, 
    0.03230570f, -0.01365964f, -0.05646443f, -0.01010698f, -0.02189923f, -0.12474341f, 0.14231932f, -0.12236741f, 
    0.02008535f, -0.02470491f, 0.06791042f, -0.02586326f, 0.12766008f, -0.08476313f, -0.01312594f, 0.03251767f, 
    -0.01105949f, 0.02296484f, -0.04171849f, -0.00137120f, 0.04221716f, 0.21021755f, -0.13279295f, 0.05321856f, 
    -0.16597551f, 0.25262147f, 0.01898543f, 0.09301929f, -0.05871509f, 0.12074736f, 0.00531899f, -0.06126149f, 
    0.04980993f, -0.02417639f, 0.04114420f, 0.03036239f, 0.04226814f, -0.02124218f, -0.03654698f, 0.05457883f, 
    -0.05970695f, 0.15463316f, -0.11162173f, -0.01172062f, -0.05019416f, -0.09217688f, -0.03729575f, -0.11230934f, 
    0.10310310f, 0.15330622f, 0.05656273f, -0.03475641f, 0.01211066f, -0.04410959f, -0.04012782f, -0.08303591f, 
    -0.03051136f, 0.00465588f, -0.01130741f, -0.01635389f, 0.07420017f, -0.12158779f, -0.03874407f, 0.09651040f, 
    -0.00329759f, -0.12899581f, 0.07985291f, -0.03458044f, 0.09771176f, -0.10256466f, 0.02784534f, -0.00018127f, 
    -0.03140780f, -0.00461525f, 0.03035900f, -0.06461911f, -0.04295826f, -0.12161135f, -0.03723187f, 0.05101920f, 
    0.06171469f, 0.02303538f, -0.01547452f, -0.01210691f, -0.26963320f, 0.16352049f, -0.15491737f, 0.00845864f, 
    -0.18731086f, -0.02549851f, -0.07265221f, -0.03030687f, 0.01217882f, 0.09300452f, -0.00674423f, 0.05127838f, 
    0.02594063f, 0.09241228f, 0.09593284f, 0.02276087f, 0.07404947f, 0.04910595f, -0.02357549f, 0.03128187f, 
    -0.10010134f, 0.03642728f, 0.10490959f, -0.07232971f, 0.05656445f, -0.01883404f, -0.01221922f, 0.02789983f, 
    0.10351067f, -0.03300282f, -0.00795863f, 0.04423067f, 0.04557540f, -0.00418842f, 0.09258690f, 0.07262637f, 
    -0.01941938f, 0.01049174f, -0.05021903f, 0.09734827f, 0.27953163f, -0.06987468f, -0.11619550f, 0.06688371f, 
    0.08438307f, -0.01293418f, 0.01636340f, 0.10736617f, -0.07727157f, 0.05936012f, 0.09209900f, 0.05815105f, 
    0.04717600f, -0.00694280f, 0.03969897f, 0.04306848f, -0.06493852f, -0.03564540f, 0.08044107f, 0.02571869f, 
    -0.46150982f, -0.36574724f, 0.03591572f, -0.18246894f, -0.06463300f, -0.09391376f, 0.05773543f, 0.02710966f, 
    0.00350952f, 0.02717885f, -0.12908874f, -0.08948448f, -0.08873885f, -0.01594978f, 0.06567391f, 0.06843186f, 
    -0.02447628f, 0.02778873f, 0.01214607f, 0.01488022f, 0.07679202f, -0.17987391f, 0.03379384f, -0.04102095f, 
    0.02814552f, 0.03997810f, -0.02750936f, -0.01411335f, 0.01401276f, -0.01901608f, 0.01108356f, 0.04703940f, 
    0.03596553f, 0.05792563f, -0.04834698f, -0.02864109f, 0.01428501f, -0.09794772f, 0.00822236f, -0.00712534f, 
    0.23839717f, 0.10106961f, -0.16968887f, -0.31733114f, 0.05937649f, 0.00902287f, -0.04349983f, 0.11050968f, 
    0.01818869f, 0.01151832f, -0.14612594f, -0.01507245f, 0.04780518f, -0.02281675f, -0.06544134f, 0.08720606f, 
    0.08342757f, -0.01188961f, 0.06097591f, 0.00803515f, 0.11989001f, -0.09039058f, 0.03690623f, 0.00059603f, 
    0.00376377f, 0.00739353f, 0.02243882f, 0.02099838f, -0.00050630f, 0.05407219f, 0.06828929f, 0.05975872f, 
    0.02899626f, -0.00453362f, 0.00103723f, 0.06348503f, -0.10822047f, -0.01619785f, 0.11492570f, 0.05225343f, 
    0.03250986f, -0.11750264f, 0.06655379f, -0.09536100f, -0.10149553f, -0.11587334f, -0.00963067f, -0.04205006f, 
    -0.03112146f, 0.02580480f, 0.07456110f, 0.08727934f, 0.11910171f, -0.04579242f, -0.12239306f, 0.05017610f, 
    0.05824627f, 0.02152480f, 0.02166914f, 0.05597435f, -0.03496773f, -0.05070409f, -0.07524898f, 0.16341349f, 
    0.08909899f, 0.05449565f, -0.08105831f, 0.03219705f, -0.04926343f, 0.15502723f, -0.01195844f, 0.03222381f, 
    0.01010591f, 0.06284918f, -0.03420932f, -0.02495940f, -0.08251718f, 0.02411760f, 0.02041029f, -0.03285277f, 
    0.11002987f, -0.25638196f, 0.23349984f, 0.03559735f, -0.29446501f, 0.03610576f, 0.07273471f, 0.07713660f, 
    -0.17584112f, 0.03347140f, -0.05674357f, 0.03174692f, 0.03391816f, -0.19595134f, 0.04878626f, -0.10469587f, 
    -0.01910079f, 0.00432994f, -0.01746471f, -0.08748558f, -0.04517846f, -0.14504126f, -0.05631334f, 0.07216104f, 
    -0.13836135f, 0.11886341f, 0.02637755f, 0.00615151f, 0.00744637f, -0.01130963f, -0.01989353f, -0.00210574f, 
    -0.08971423f, -0.04100536f, -0.08083624f, 0.06827322f, -0.03094763f, -0.07415403f, -0.02148955f, 0.02760999f, 
    -0.36183980f, -0.28893951f, -0.10766866f, -0.10581804f, 0.04039595f, 0.13010994f, 0.00404712f, -0.01025532f, 
    -0.03769766f, -0.03130962f, -0.00848985f, 0.05586870f, -0.03886218f, 0.04823311f, -0.01643030f, 0.04067490f, 
    -0.00672721f, 0.09866517f, 0.06320143f, 0.07820076f, -0.10556197f, -0.15276459f, -0.02527178f, 0.02421493f, 
    -0.00255279f, 0.06929743f, 0.04294852f, 0.00017021f, 0.00734469f, -0.01489308f, 0.06120323f, 0.02573881f, 
    -0.00785211f, -0.06898253f, 0.05257590f, 0.00102350f, 0.03102225f, 0.04249691f, 0.07516087f, 0.06282576f, 
    0.00425096f, -0.04935573f, -0.02898766f, -0.02976856f, -0.04685507f, 0.05618212f, 0.04786447f, -0.00577661f, 
    0.07957943f, 0.01665410f, 0.04970405f, -0.01980105f, 0.02225397f, 0.05515028f, -0.02903285f, 0.05141784f, 
    0.09605552f, -0.10936899f, 0.04126996f, 0.02275379f, 0.13239230f, 0.15967228f, 0.14235033f, -0.04325153f, 
    -0.09991999f, 0.03289069f, 0.05524215f, 0.01704758f, 0.04049981f, 0.01080255f, -0.04609203f, 0.05131837f, 
    -0.01598050f, -0.00861024f, -0.00372477f, 0.10388820f, 0.04319541f, -0.10734113f, -0.09120446f, 0.01510384f, 
    -0.05405076f, -0.00092494f, -0.15678225f, 0.09187169f, 0.04307863f, 0.02722581f, 0.00502157f, -0.05502109f, 
    -0.01581642f, 0.01175451f, -0.02995386f, -0.03871964f, -0.09782439f, 0.04576829f, 0.04004721f, -0.00888568f, 
    0.10041939f, 0.16754879f, 0.04815327f, 0.05810767f, -0.25641844f, 0.02734181f, -0.01628067f, -0.04862805f, 
    -0.08846226f, 0.08873317f, 0.00572489f, -0.04092923f, -0.00992844f, -0.00387039f, -0.01285772f, -0.01311924f, 
    -0.04618047f, 0.05248662f, 0.04320654f, -0.01951608f, -0.07695965f, 0.02073485f, -0.02188604f, 0.02226491f, 
    -0.06516970f, 0.08799883f, -0.05190149f, 0.02786036f, 0.04114884f, 0.07185208f, 0.06178780f, -0.03667495f, 
    -0.05456058f, -0.01070754f, 0.04464607f, 0.05376765f, -0.03416682f, -0.02750614f, 0.07164757f, 0.01595911f, 
    0.04581309f, 0.01464419f, 0.01189429f, 0.05929382f, -0.08767573f, -0.08149515f, -0.10345115f, 0.15165128f, 
    0.08625683f, -0.06011478f, -0.08857815f, -0.00808284f, 0.01755624f, 0.08104125f, -0.00691022f, 0.07537781f, 
    0.00032803f, -0.07751222f, 0.04471923f, 0.04297031f, 0.03274726f, -0.14475030f, -0.16686966f, -0.08048674f, 
    0.18813099f, -0.04875885f, -0.03649028f, -0.04128121f, -0.01150912f, -0.08005646f, -0.06208287f, -0.04615805f, 
    -0.01378763f, -0.04563486f, -0.02191618f, 0.00450507f, -0.06550160f, -0.01032596f, -0.05043215f, -0.07247379f, 
    0.08594449f, 0.01142941f, -0.11735260f, 0.02766090f, -0.08256713f, 0.02507220f, 0.01407438f, 0.03428100f, 
    -0.00936434f, 0.00062648f, -0.02349314f, 0.06037058f, 0.04998616f, 0.02252338f, -0.01139696f, 0.04375793f, 
    0.04663805f, -0.07935852f, -0.03736485f, -0.04304427f, -0.04124074f, 0.01205265f, 0.05038615f, -0.00133811f, 
    -0.06007494f, -0.10664407f, -0.03442607f, -0.08868370f, 0.10049740f, -0.03174429f, -0.01159164f, 0.02549070f, 
    0.00119470f, -0.02986058f, -0.04228812f, -0.07210334f, -0.01294202f, -0.04485106f, 0.01727901f, -0.08205677f, 
    0.05883822f, 0.05598225f, 0.05068099f, 0.07610237f, -0.50222814f, 0.05436391f, -0.16685699f, -0.03489123f, 
    0.19005363f, -0.06530957f, -0.00171696f, -0.09883324f, 0.06299071f, -0.00244923f, 0.08711557f, 0.00047962f, 
    0.01381918f, -0.02679126f, 0.04709716f, 0.02038083f, -0.09758881f, -0.02683075f, -0.14435999f, -0.03192866f, 
    -0.32871684f, 0.03606851f, -0.01518926f, -0.08074483f, -0.05296746f, 0.10990690f, -0.01484476f, 0.07298038f, 
    -0.04949351f, 0.01482450f, -0.05358206f, 0.02462467f, -0.02705289f, 0.11656840f, 0.00144316f, -0.04291887f, 
    0.02541831f, 0.04899741f, -0.02155526f, -0.00527606f, 0.06024515f, -0.01019114f, -0.00110557f, -0.03200734f, 
    -0.02602554f, 0.03092081f, -0.05145057f, -0.00933537f, 0.05062115f, -0.00589836f, 0.04660016f, 0.00615225f, 
    0.00174764f, 0.10089310f, 0.00074507f, -0.05536765f, 0.01338112f, -0.04226440f, 0.10102598f, 0.07651480f, 
    0.20162247f, 0.12783447f, -0.09856091f, -0.13842088f, -0.13535908f, 0.05304429f, 0.05730551f, 0.14478832f, 
    -0.04169310f, 0.02925330f, -0.05107169f, -0.00744350f, 0.00712242f, -0.08355390f, 0.03849559f, -0.00340929f, 
    0.03463634f, -0.08910528f, -0.06637441f, -0.02606114f, -0.38477442f, -0.16098693f, 0.08319328f, -0.07441961f, 
    -0.21978118f, 0.08599645f, -0.03921189f, 0.01426690f, -0.05564058f, 0.03089634f, 0.00873407f, -0.03544560f, 
    -0.00312602f, 0.03175705f, -0.00356326f, -0.03464492f, -0.08767503f, -0.03559337f, -0.06704216f, -0.09805944f, 
    -0.09040097f, -0.01644384f, -0.04730997f, 0.10657978f, -0.01585880f, 0.02130862f, 0.04270442f, -0.00000011f, 
    -0.02267363f, 0.02719668f, 0.07848762f, 0.04159699f, 0.01863566f, 0.00666399f, 0.08635555f, 0.00912039f, 
    -0.00866390f, -0.05391276f, 0.01368999f, -0.03634867f, 0.08785328f, -0.07722007f, -0.01679745f, -0.05187052f, 
    -0.01766963f, 0.01108851f, 0.05514264f, -0.02286286f, 0.01706337f, -0.06723939f, -0.02813313f, 0.01241143f, 
    -0.04029565f, -0.00907222f, -0.02791053f, -0.03694287f, 0.00177056f, -0.11740463f, -0.13765141f, -0.00094328f, 
    -0.04263093f, 0.04621487f, -0.00025576f, 0.07968773f, 0.03732472f, -0.04556412f, 0.02542863f, 0.07340911f, 
    0.05508123f, 0.09145042f, 0.08188865f, 0.02012623f, 0.00242459f, 0.01338035f, -0.05657963f, 0.14423744f, 
    -0.02063549f, 0.05885377f, -0.01440470f, 0.09670370f, 0.17235200f, 0.10204484f, 0.03547291f, -0.05784002f, 
    -0.04364252f, 0.02767102f, -0.02056563f, 0.06933560f, 0.04699964f, 0.00775480f, -0.01687021f, -0.04184543f, 
    0.00585218f, 0.04766177f, -0.01786256f, 0.05812716f, 0.09856786f, -0.01201952f, 0.00077672f, 0.01002002f, 
    -0.10005617f, -0.21784900f, 0.03088196f, -0.02360130f, 0.13998386f, -0.06080201f, -0.02828350f, -0.00940642f, 
    -0.07996763f, 0.02037882f, -0.02096004f, -0.02941090f, 0.01744790f, -0.05765870f, 0.01948561f, -0.09414717f, 
    -0.00267904f, -0.11820440f, -0.01920517f, 0.00573973f, 0.19850594f, 0.00361896f, -0.00301829f, 0.01131309f, 
    -0.03875556f, -0.09165095f, -0.07765497f, -0.03180170f, 0.08521949f, -0.03004038f, 0.00012033f, 0.03056348f, 
    -0.11829508f, 0.01470446f, 0.02047975f, -0.01637222f, -0.01300605f, 0.04986065f, -0.00006371f, -0.06899607f, 
    -0.16189100f, -0.11072212f, -0.23854579f, -0.07179270f, -0.15401399f, -0.01470620f, 0.04072673f, 0.01019953f, 
    -0.07521126f, -0.02339553f, 0.12047805f, -0.06609598f, -0.04982821f, -0.08548278f, -0.00288330f, -0.04794237f, 
    -0.00373014f, 0.04647219f, 0.11663299f, -0.00098518f, -0.24560651f, 0.05981465f, -0.12945281f, 0.01305543f, 
    0.12732977f, -0.00098203f, -0.00621080f, -0.02781492f, 0.00331454f, 0.04895989f, 0.05144116f, 0.02925993f, 
    0.03497899f, -0.03882220f, 0.01053226f, 0.00180294f, -0.00151085f, 0.05403624f, -0.04372444f, -0.01798823f, 
    0.17361808f, 0.01017606f, -0.04559115f, 0.04997941f, -0.07640126f, -0.14929749f, -0.05853118f, -0.04218217f, 
    0.01912924f, -0.08740511f, -0.01811156f, 0.02403902f, -0.04944345f, -0.08178549f, 0.07299761f, -0.07807881f, 
    0.03617728f, -0.01716244f, -0.02812158f, -0.07525510f, 0.12372904f, 0.11689430f, 0.14552791f, -0.09927955f, 
    -0.14065699f, 0.11660009f, -0.04445479f, 0.03880277f, 0.03125235f, -0.00329021f, -0.05704152f, 0.00003687f, 
    -0.00767681f, 0.06357197f, -0.04894017f, -0.00588573f, 0.08563823f, -0.06089709f, -0.03414546f, -0.01353504f, 
    0.06112691f, 0.13008060f, 0.01325070f, 0.11050208f, 0.02463183f, -0.01057944f, -0.00933436f, -0.04670846f, 
    0.01049212f, -0.03533512f, 0.04018620f, 0.00931767f, -0.03218437f, -0.08095906f, -0.04549955f, -0.00440037f, 
    -0.06522329f, 0.00855680f, -0.03552322f, -0.02914463f, 0.06162702f, 0.14303827f, -0.02152044f, 0.11551228f, 
    -0.00217151f, -0.00165233f, 0.00847969f, 0.01858055f, 0.03277090f, 0.08577690f, 0.03531447f, -0.01599790f, 
    0.00592541f, -0.06416584f, -0.02612804f, -0.05848334f, -0.01690834f, 0.06933130f, -0.02098964f, 0.02680300f, 
    0.23799473f, 0.15103135f, 0.02619960f, 0.00312346f, -0.00061717f, 0.06789880f, 0.04345534f, 0.01232908f, 
    -0.02561104f, -0.04185406f, -0.01799603f, -0.02873166f, 0.00455917f, -0.00333345f, -0.01207033f, 0.03741540f, 
    0.02323987f, -0.06742018f, -0.10947869f, -0.03358921f, -0.19143222f, -0.07027580f, -0.15099540f, 0.00656914f, 
    0.05386787f, -0.01398343f, 0.03846111f, -0.08676285f, 0.06517892f, 0.02712878f, -0.00128755f, -0.02433942f, 
    0.04452769f, 0.03537442f, 0.06438934f, 0.08528900f, 0.05036330f, 0.12239866f, 0.01728240f, 0.05115478f, 
    -0.34745300f, -0.04897800f, 0.07823665f, -0.11392798f, -0.29583493f, 0.08473919f, -0.02352803f, -0.05824104f, 
    -0.00803331f, 0.05277620f, -0.04965623f, 0.04128251f, 0.03018769f, -0.02656882f, 0.04518027f, 0.04967723f, 
    0.03895872f, 0.04828797f, -0.00253229f, 0.02306268f, 0.19623910f, 0.07845110f, -0.02736040f, 0.06159706f, 
    -0.06826324f, -0.09590978f, -0.06684408f, 0.03958754f, 0.02493471f, -0.05947909f, 0.00831383f, 0.02065280f, 
    -0.02347022f, -0.07234183f, -0.09891047f, -0.03127157f, -0.01739916f, -0.03586053f, -0.02480472f, -0.04609962f, 
    0.22993419f, -0.08616835f, -0.07407924f, -0.04171173f, 0.06482049f, -0.13770764f, -0.05058243f, -0.06597568f, 
    0.02149194f, -0.03328123f, -0.02144681f, -0.00400826f, -0.09418542f, -0.12334074f, -0.02553598f, -0.11535805f, 
    -0.00365344f, -0.05167252f, -0.03457467f, 0.03891062f, -0.14019400f, -0.04251102f, -0.12912641f, -0.03494460f, 
    0.12304662f, 0.05764206f, -0.02475172f, 0.03096329f, 0.01938899f, 0.04455814f, 0.01820161f, 0.01599950f, 
    0.04656224f, -0.03437225f, -0.00098645f, -0.00631633f, -0.00945021f, -0.02359096f, 0.04356647f, 0.06271802f, 
    -0.17818625f, -0.07803391f, 0.09527028f, -0.09385242f, -0.27568817f, 0.05237761f, -0.00033589f, 0.02150103f, 
    -0.02515373f, 0.02060443f, -0.00746944f, 0.07191563f, 0.01326521f, -0.07659685f, 0.04520370f, -0.06343039f, 
    0.09850176f, -0.08181363f, -0.09923409f, -0.00597003f, 0.19628066f, 0.13570394f, 0.05000039f, -0.05261652f, 
    0.00503223f, 0.07105537f, 0.02940173f, 0.05300160f, 0.03743857f, -0.00152181f, -0.06646077f, 0.04882096f, 
    -0.01840545f, 0.02237729f, -0.00865043f, 0.03801863f, 0.06889463f, -0.05272513f, -0.08238116f, 0.08522674f, 
    0.03286641f, 0.07491072f, -0.01269105f, 0.08326086f, -0.02295244f, -0.04204568f, -0.01386344f, -0.00443205f, 
    -0.03695343f, 0.03802360f, 0.00725313f, -0.04203033f, 0.03834288f, -0.05097824f, 0.02067834f, -0.01137591f, 
    0.00585355f, 0.05997011f, 0.02981994f, -0.01319790f, -0.18603231f, -0.16934285f, 0.06649763f, 0.06958035f, 
    -0.01047866f, 0.08086668f, -0.00025221f, 0.01631485f, -0.00461984f, -0.07513246f, 0.02949408f, 0.02088362f, 
    0.02092857f, 0.06719355f, 0.00010322f, 0.01292221f, -0.01859123f, -0.03190793f, -0.00988938f, -0.04680627f, 
    0.09183691f, -0.07701102f, 0.04398663f, 0.03381829f, -0.03958552f, -0.09983808f, -0.00054337f, -0.04386503f, 
    0.00704120f, 0.01608986f, -0.02738391f, 0.03345119f, 0.00032108f, -0.01450533f, 0.06447709f, 0.00541251f, 
    0.01116917f, -0.00944183f, -0.05856112f, -0.03546549f, -0.08859465f, -0.08735708f, 0.07031476f, -0.10248816f, 
    -0.07075054f, 0.04880121f, -0.00407538f, -0.04329357f, 0.00713552f, 0.04882440f, 0.02953642f, 0.00178693f, 
    0.02237253f, 0.08588585f, -0.00237952f, 0.05492712f, 0.04723330f, -0.00594463f, -0.01397953f, -0.00926897f, 
    0.11185410f, 0.09154449f, -0.11037447f, -0.01132433f, -0.04079593f, -0.09549882f, 0.01013684f, 0.01922159f, 
    0.02167955f, -0.02850842f, 0.01981139f, -0.02926601f, 0.02291673f, -0.02643179f, 0.03138245f, 0.05956268f, 
    0.10300898f, 0.09337664f, -0.02328665f, 0.04449074f, 0.11264480f, 0.00277876f, 0.00306997f, 0.04387520f, 
    -0.04824068f, 0.02410379f, -0.01150617f, -0.00894943f, 0.01842757f, -0.02886964f, 0.00944294f, 0.01970512f, 
    -0.03606227f, 0.01762653f, -0.02719704f, -0.03953959f, -0.03053470f, -0.09314428f, -0.03796704f, -0.02196828f, 
    -0.41060433f, -0.13468903f, -0.15718146f, -0.21982400f, -0.10959768f, 0.08742130f, 0.01398026f, -0.08474052f, 
    -0.02129834f, 0.00684720f, -0.08869828f, -0.00093830f, -0.06289193f, -0.05641745f, 0.01691326f, -0.10802103f, 
    0.01152904f, 0.12406116f, 0.01377448f, 0.05237963f, -0.18928304f, -0.10777138f, -0.05332437f, -0.02643832f, 
    0.06616468f, 0.05035556f, 0.03478642f, -0.04618856f, 0.03791653f, -0.00535817f, -0.02887227f, 0.00190124f, 
    0.02563376f, 0.09183465f, 0.04496434f, 0.07647711f, 0.13047847f, 0.11425948f, 0.03473914f, 0.07543885f, 
    0.00951874f, -0.02093330f, -0.08414742f, 0.01942396f, 0.01135094f, -0.02938092f, -0.00674766f, 0.03529727f, 
    0.02863318f, 0.01177484f, -0.00111202f, 0.04868757f, 0.06969454f, -0.05374841f, 0.06527089f, 0.03448541f, 
    0.04818976f, 0.02192751f, -0.02317815f, -0.00082771f, -0.50899744f, -0.24042957f, -0.14927776f, -0.14212063f, 
    -0.09907577f, 0.11002672f, 0.00812932f, -0.12732738f, -0.05542501f, 0.07972988f, 0.01870600f, -0.07029632f, 
    -0.01541828f, 0.04304327f, 0.03012124f, -0.00344148f, -0.02782561f, 0.11195222f, 0.00993971f, 0.01613194f, 
    -0.17623834f, -0.08917910f, 0.01262667f, 0.03745340f, 0.18689260f, 0.09141121f, -0.03190136f, 0.08607773f, 
    -0.04499487f, 0.00359188f, 0.07010322f, -0.02314376f, 0.00779028f, -0.01676460f, 0.06208901f, 0.01500856f, 
    -0.07606594f, -0.07293283f, 0.09425970f, -0.02702226f, -0.21113516f, -0.15530489f, -0.03041522f, -0.07214927f, 
    -0.04339677f, 0.07552911f, 0.01965289f, -0.01882683f, -0.00220542f, 0.05199484f, -0.00005503f, 0.03648948f, 
    0.00296590f, 0.08571980f, -0.02169158f, 0.08767309f, 0.01993067f, 0.03768856f, 0.00033867f, 0.00764399f, 
    -0.23639302f, -0.00315851f, -0.13958050f, -0.12780271f, -0.00884289f, 0.06703105f, 0.01705559f, -0.08959759f, 
    -0.02805089f, 0.00565206f, 0.01762986f, -0.02409869f, 0.02238916f, -0.04061666f, 0.05675403f, -0.07122708f, 
    -0.01996429f, 0.10348167f, 0.07996009f, 0.08555900f, -0.34102342f, -0.22940023f, -0.05035092f, 0.02573936f, 
    0.13504069f, 0.04266537f, 0.07392394f, 0.02834982f, -0.02168565f, -0.08492461f, 0.01106303f, 0.07336562f, 
    0.00975146f, 0.00614375f, 0.10830865f, -0.03605472f, -0.01029629f, -0.01154855f, -0.01154032f, -0.06113800f, 
    -0.10189398f, -0.01316667f, -0.14600556f, -0.00559540f, -0.07068925f, -0.00566268f, -0.08501673f, -0.00558879f, 
    0.02165968f, 0.03880353f, 0.12504508f, -0.03215059f, -0.00256365f, -0.02798956f, 0.03756139f, 0.07605450f, 
    0.08806346f, 0.03460777f, 0.12257896f, 0.06052901f, -0.10219620f, 0.00317591f, -0.12993999f, -0.05698739f, 
    -0.09669072f, 0.04010926f, 0.01636189f, -0.05082030f, 0.01172088f, 0.02390417f, 0.01922587f, 0.01165910f, 
    -0.06058957f, -0.02295045f, 0.00993584f, -0.09091295f, 0.01715931f, 0.06145117f, 0.02393263f, -0.00207031f, 
    0.30954453f, 0.18842588f, -0.00037095f, -0.06522953f, 0.03484979f, 0.03229742f, 0.01562637f, 0.03535546f, 
    0.03773432f, 0.00458489f, -0.05055926f, 0.04688925f, 0.03844884f, -0.04057432f, 0.00510385f, 0.01218816f, 
    0.02802672f, -0.04550214f, -0.14336954f, 0.05738541f, -0.24878985f, -0.21967366f, 0.12784202f, 0.11110361f, 
    -0.05135142f, 0.00055838f, 0.08700917f, 0.00886299f, 0.02557814f, 0.02999788f, 0.01902036f, -0.03799914f, 
    0.03688890f, -0.12763257f, 0.01817288f, -0.07905453f, -0.01638058f, -0.15568390f, -0.06668032f, -0.10310298f, 
    -0.22663194f, -0.14883336f, -0.01378347f, 0.02700570f, 0.11941674f, 0.03158114f, 0.05849039f, -0.02468036f, 
    -0.04538475f, -0.11626551f, 0.00286702f, 0.01672716f, -0.05161750f, -0.00294093f, 0.05919834f, -0.00439545f, 
    -0.02245585f, 0.00131591f, 0.02776753f, 0.03543748f, 0.01597612f, 0.02410842f, 0.03505702f, 0.03548764f, 
    -0.01396685f, 0.05078698f, -0.01334910f, -0.00785740f, -0.00012615f, 0.02638547f, 0.00316712f, 0.01046464f, 
    -0.00731328f, -0.00053430f, 0.00703311f, 0.02577106f, 0.03132177f, 0.09601591f, -0.04270313f, 0.01765676f, 
    -0.16158274f, -0.06220578f, -0.06752904f, 0.04640350f, 0.05024949f, 0.02873436f, -0.02393213f, -0.01900576f, 
    -0.04616783f, -0.01162354f, -0.00169962f, 0.04240586f, -0.00741449f, -0.07061609f, -0.02215057f, 0.00414760f, 
    -0.14328493f, -0.10233306f, -0.03305622f, 0.00755062f, -0.11152764f, -0.01456850f, -0.17908764f, -0.07916284f, 
    -0.01596007f, 0.00605730f, 0.02886113f, -0.07691981f, 0.01880762f, -0.03115713f, 0.01183022f, 0.00661970f, 
    -0.00476048f, -0.05869403f, 0.05794159f, -0.04235941f, 0.01465727f, 0.10510837f, 0.04240684f, 0.02572900f, 
    0.06857955f, 0.20685992f, 0.18472713f, 0.07160219f, -0.11479697f, 0.05555189f, -0.02585063f, -0.02492161f, 
    0.00852371f, 0.03148441f, -0.03184607f, -0.02914736f, 0.11585960f, -0.00807975f, -0.00258204f, -0.02688212f, 
    0.11616292f, -0.06592632f, 0.02363231f, 0.05536544f, -0.16276488f, 0.11084726f, -0.03140152f, -0.17255978f, 
    0.02703022f, 0.00571343f, 0.08916686f, 0.00540675f, 0.08138166f, 0.06255786f, -0.01921309f, -0.00976344f, 
    -0.01472528f, 0.01088393f, 0.00043223f, 0.04483122f, 0.07460319f, 0.16469611f, -0.04401326f, 0.11449453f, 
    0.19321519f, 0.18269068f, 0.09045621f, -0.00190628f, -0.07133855f, 0.01188730f, -0.04593509f, 0.01934158f, 
    0.04131095f, -0.00408095f, -0.04790426f, 0.03927322f, 0.01259026f, 0.00094517f, -0.01910672f, 0.07384952f, 
    -0.01435733f, -0.13930710f, -0.07209472f, -0.08331075f, 0.14948170f, 0.11249270f, 0.01111251f, 0.07380591f, 
    -0.04351084f, -0.04986329f, -0.03095157f, 0.07585594f, -0.00888461f, -0.00360616f, -0.01427114f, -0.00917196f, 
    -0.01604622f, -0.01492147f, -0.06219572f, 0.02748846f, 0.01228472f, 0.02717319f, -0.05183084f, -0.03119409f, 
    -0.46895975f, -0.07487535f, -0.08061837f, -0.03373938f, -0.16689697f, 0.08847286f, -0.00629108f, -0.00292857f, 
    -0.07396467f, -0.01537024f, -0.05940585f, 0.01504877f, -0.05379448f, 0.10137995f, 0.00038987f, 0.00391442f, 
    0.06516138f, 0.00740407f, -0.06329973f, -0.01772947f, -0.17924654f, -0.22964668f, -0.13639754f, -0.08705867f, 
    -0.09857551f, -0.00792129f, 0.05596130f, -0.05053553f, -0.07005588f, 0.00626672f, -0.01827377f, -0.04028852f, 
    -0.06383493f, -0.07122082f, -0.00648837f, 0.02878396f, -0.02374382f, 0.10113461f, 0.01577329f, 0.12019013f, 
    0.30148464f, -0.24410062f, -0.04553541f, -0.01446031f, -0.12538490f, 0.14244492f, 0.07244284f, -0.04033846f, 
    0.00046426f, -0.00605533f, 0.08230259f, 0.02698128f, -0.03655925f, 0.03976724f, 0.01584082f, -0.02432893f, 
    -0.05942055f, -0.09614000f, -0.02966880f, 0.01674085f, 0.01493008f, 0.02034204f, 0.00952654f, 0.05569732f, 
    -0.04457063f, 0.08669845f, 0.06433003f, -0.00828464f, -0.01857505f, 0.02219644f, -0.01547085f, -0.01380489f, 
    0.05586697f, 0.04354776f, 0.00572181f, -0.03098457f, -0.02992642f, 0.02830413f, -0.00244787f, -0.02058258f, 
    -0.15033485f, 0.08115736f, -0.06316192f, -0.08061910f, 0.17418709f, 0.18510683f, -0.07560644f, -0.00874194f, 
    -0.02800286f, -0.05698155f, 0.00460590f, 0.07488200f, 0.02334054f, -0.03541581f, 0.05864669f, -0.00605795f, 
    -0.00590324f, 0.05467136f, 0.02321660f, -0.04245246f, -0.10177333f, 0.07278771f, -0.05896966f, -0.07977414f, 
    0.37043771f, 0.12343579f, -0.07158072f, -0.02256399f, 0.05892221f, -0.05049096f, 0.01309799f, -0.07068732f, 
    0.00034187f, 0.05871433f, -0.00632197f, -0.15693112f, 0.07592164f, 0.06855604f, 0.03115904f, 0.06345378f, 
    -0.04568237f, 0.11778753f, -0.07064094f, -0.07701074f, -0.11910044f, 0.03884307f, 0.13468176f, 0.09975391f, 
    0.05580453f, 0.11090703f, -0.01709424f, -0.04512643f, -0.09114688f, -0.08582971f, 0.05191796f, 0.03383427f, 
    -0.04616624f, -0.03030805f, -0.10504750f, -0.02662495f, 0.21728219f, 0.06406907f, -0.06617747f, -0.04690744f, 
    -0.12442337f, -0.07534324f, -0.01146020f, -0.03171890f, 0.04548312f, -0.01391313f, 0.08106197f, -0.04235057f, 
    -0.01639414f, -0.01672635f, 0.00750138f, -0.01981268f, -0.00175032f, -0.05959560f, -0.02411849f, 0.06771106f, 
    -0.35489872f, 0.17734766f, 0.07939412f, 0.04816951f, 0.02232260f, -0.01060634f, 0.03624989f, -0.02975197f, 
    0.03391971f, -0.04197364f, 0.07875866f, -0.01847671f, -0.01438744f, 0.00901507f, -0.06232643f, 0.05598692f, 
    0.00379973f, 0.01623201f, -0.04667048f, 0.07135814f, -0.05609272f, 0.11483927f, -0.17314665f, -0.00033283f, 
    -0.26804277f, -0.10565161f, -0.08959603f, -0.12158321f, -0.00858674f, -0.08972394f, -0.07557802f, 0.00558718f, 
    0.03585497f, -0.01681605f, 0.02198412f, 0.07182793f, 0.03585738f, -0.08464836f, -0.00366280f, -0.09732150f, 
    -0.28435007f, 0.19805920f, 0.06316015f, -0.03357304f, -0.02345303f, 0.03524090f, -0.02995054f, 0.03868749f, 
    -0.02351502f, -0.05152139f, 0.01932825f, -0.02285037f, 0.04952950f, -0.06746494f, -0.03717169f, -0.01710388f, 
    -0.00702084f, 0.00338428f, -0.05018923f, -0.02198288f, 0.05075515f, -0.17872433f, 0.05513008f, -0.03116932f, 
    -0.08473320f, -0.02860660f, -0.07116314f, 0.00759597f, 0.01851234f, -0.01991836f, -0.09603624f, -0.01299654f, 
    -0.02432039f, 0.00412149f, -0.05534086f, -0.04316895f, -0.03305811f, 0.02814647f, 0.00627167f, -0.02050482f, 
    -0.24921314f, -0.11704147f, -0.02307815f, 0.01650737f, -0.03427876f, -0.01162109f, 0.02019136f, 0.04523668f, 
    0.03617967f, 0.08665340f, -0.07945120f, -0.05395783f, 0.04282398f, -0.11703531f, -0.00613800f, -0.03325218f, 
    -0.11354288f, -0.03467356f, -0.05886421f, 0.02507861f, -0.45495459f, 0.07544695f, 0.05664047f, 0.01698546f, 
    0.05504335f, -0.09936726f, -0.00875083f, -0.09468570f, 0.02277415f, -0.06982892f, 0.01034593f, -0.05346372f, 
    0.02070930f, 0.15367781f, 0.04816452f, 0.12727220f, 0.04765764f, -0.09111483f, 0.04115230f, 0.10007752f, 
    0.41367793f, 0.03147921f, -0.14274992f, -0.10957459f, -0.11320656f, -0.01623961f, 0.08081568f, -0.00398086f, 
    0.07363404f, -0.00347778f, 0.05743282f, 0.01971427f, -0.05460530f, 0.01520093f, 0.03504541f, 0.03279582f, 
    -0.02188032f, -0.02711130f, 0.03039454f, 0.02577884f, 0.08454961f, -0.10908879f, 0.05264652f, 0.04705869f, 
    0.03899385f, -0.07010810f, 0.00895784f, 0.00428215f, -0.11421284f, -0.06396116f, -0.00838425f, 0.01966475f, 
    -0.00915307f, -0.07668621f, -0.10354096f, 0.00346516f, -0.02529706f, 0.04348951f, 0.00802227f, -0.09919891f, 
    0.02820304f, 0.21862471f, -0.17175849f, -0.25346690f, -0.01254894f, -0.20915163f, -0.05425003f, -0.03190366f, 
    -0.01173183f, -0.03455878f, 0.03285697f, 0.01131496f, -0.02084023f, 0.00667506f, 0.03246786f, 0.07785165f, 
    -0.10099528f, 0.01044174f, -0.07498769f, -0.01681422f, 0.25919992f, 0.14764392f, -0.17554198f, -0.14101304f, 
    0.02429090f, -0.10299459f, -0.07144371f, 0.05258960f, 0.01481512f, 0.03257787f, 0.03545086f, 0.00751083f, 
    0.00903073f, -0.01418161f, -0.01912849f, 0.04995271f, -0.02350545f, 0.01311023f, 0.04785489f, -0.02551706f, 
    0.09676925f, -0.08857778f, -0.11056505f, 0.11061894f, -0.16522063f, -0.08112758f, -0.00374617f, -0.02094481f, 
    -0.00493858f, 0.01168075f, 0.01568974f, 0.00825564f, 0.04920372f, 0.05015100f, -0.06904417f, 0.03706919f, 
    0.07363743f, 0.02670778f, -0.04079265f, -0.07737404f, 0.04224519f, 0.07718047f, 0.02871825f, 0.03716743f, 
    -0.05824940f, 0.01467521f, -0.09531872f, 0.01928131f, -0.12387692f, -0.09756251f, 0.05981621f, 0.00608541f, 
    0.05730392f, -0.02104975f, 0.01561576f, 0.05739713f, 0.07840954f, -0.06413996f, 0.03776776f, 0.00395075f, 
    0.27705640f, 0.17113948f, -0.07986185f, 0.12012655f, 0.17623198f, 0.03694855f, -0.02482291f, -0.05239093f, 
    -0.03570953f, 0.04217823f, -0.02505428f, 0.01895500f, 0.01757829f, -0.02505247f, -0.04329371f, 0.06365249f, 
    0.05854192f, 0.00180027f, 0.00968499f, -0.06311557f, 0.05671277f, 0.10627706f, -0.02124052f, -0.08052844f, 
    0.00243773f, -0.02674485f, -0.04001785f, 0.03211752f, -0.02690214f, -0.00676875f, -0.02415419f, -0.00493449f, 
    -0.05254252f, -0.02489679f, 0.07057329f, -0.00292060f, -0.02527789f, 0.02665592f, 0.04950003f, -0.03360829f, 
    -0.22325587f, 0.18241751f, 0.04622128f, 0.03067614f, 0.04262184f, 0.15356132f, -0.05678840f, 0.07773958f, 
    0.06383225f, 0.01714866f, -0.00722006f, 0.03725037f, -0.02648887f, -0.02869239f, -0.00987728f, -0.03814681f, 
    0.02440973f, -0.09608891f, -0.01894426f, 0.10190909f, 0.03150968f, -0.24692051f, 0.06396882f, -0.07110018f, 
    0.03494447f, -0.07414750f, 0.05834423f, 0.05364130f, -0.00784428f, -0.04234232f, -0.06843439f, 0.01655740f, 
    0.04982113f, 0.00629198f, -0.09817689f, -0.00255517f, -0.03595654f, 0.02777163f, -0.12303767f, -0.00654198f, 
    -0.08327006f, -0.33903354f, -0.16951291f, -0.06009150f, -0.22055365f, 0.02722504f, 0.06808518f, 0.07796855f, 
    0.00033661f, 0.02943305f, -0.00846315f, 0.05286114f, -0.01289876f, -0.01892830f, -0.11314126f, -0.10384364f, 
    0.01542481f, -0.09630149f, -0.16931917f, -0.04658014f, -0.05456040f, 0.12220070f, 0.01741797f, 0.01341077f, 
    -0.06529029f, -0.08232419f, 0.01623455f, 0.00237139f, 0.01694711f, -0.02396199f, 0.00392922f, -0.00903966f, 
    0.05809028f, 0.09108544f, 0.06039704f, 0.08949208f, 0.00387865f, -0.06959658f, -0.01282797f, 0.03769209f, 
    -0.11185649f, -0.25880498f, 0.02629077f, -0.04661648f, -0.16450886f, -0.06094052f, 0.01779036f, -0.04932652f, 
    0.04571662f, 0.05930570f, -0.15201765f, -0.01999855f, 0.01693739f, 0.00493642f, -0.06402155f, -0.16297841f, 
    0.01328239f, -0.04308607f, -0.12448635f, -0.06085159f, 0.26070660f, -0.03317255f, -0.13133767f, -0.09983971f, 
    0.13503845f, 0.07314034f, -0.06677692f, -0.03199420f, 0.10282879f, -0.03218473f, 0.08098976f, -0.04203863f, 
    0.02655588f, -0.03809928f, 0.03271126f, -0.01384372f, -0.05346401f, 0.02492848f, 0.00886035f, 0.06584062f, 
    -0.26211801f, 0.04902410f, 0.09477266f, -0.06762687f, 0.19633107f, -0.09933946f, -0.01682774f, -0.01070845f, 
    0.07525689f, -0.05703397f, -0.00863497f, -0.03974612f, 0.03585456f, 0.06124897f, -0.02477092f, -0.01265220f, 
    -0.05421263f, 0.03099515f, -0.07545354f, 0.00721307f, -0.16256811f, -0.05609589f, 0.07260964f, -0.00865253f, 
    0.13331525f, -0.09990343f, 0.07456575f, 0.06896890f, 0.07134801f, -0.04942521f, 0.01106879f, 0.02236793f, 
    -0.03838196f, 0.01976307f, -0.06324247f, -0.00022211f, -0.02655840f, 0.01665105f, -0.07113361f, 0.01211801f, 
    -0.08184192f, -0.00795847f, -0.03125630f, -0.11870750f, -0.01005230f, -0.10594464f, -0.05975480f, 0.05930570f, 
    -0.00041691f, -0.07593292f, 0.06773516f, -0.11167867f, -0.00832358f, -0.02146716f, -0.04133891f, 0.01117957f, 
    0.02698158f, -0.00385891f, 0.16997163f, 0.04175168f, -0.05645449f, 0.00880742f, -0.04115732f, 0.03285959f, 
    -0.07052042f, -0.03356912f, 0.02175771f, -0.02788916f, 0.02542846f, 0.03451131f, -0.07724999f, -0.01130956f, 
    0.00077230f, -0.02357138f, 0.05766201f, -0.00577897f, 0.03482379f, -0.05155730f, 0.04505346f, -0.04810340f, 
    0.20678324f, 0.15858029f, -0.07780544f, -0.06078414f, 0.34400567f, 0.10036618f, -0.14264780f, -0.04139876f, 
    0.03216272f, 0.01597511f, 0.05053044f, 0.02614184f, 0.09888946f, 0.07241765f, -0.00926958f, -0.03567796f, 
    0.06502629f, 0.06296762f, -0.10153659f, -0.06288040f, 0.09150992f, -0.00171395f, 0.11301357f, -0.03188426f, 
    -0.01813021f, -0.04363867f, 0.02268672f, 0.04822898f, -0.07325407f, -0.12370879f, -0.04348164f, -0.06115197f, 
    0.03057024f, -0.00815880f, -0.00364465f, -0.03365462f, -0.00539633f, 0.01395906f, -0.03409985f, 0.05166738f, 
    -0.23981749f, 0.11088684f, -0.05748584f, 0.05256186f, -0.08219398f, 0.01615600f, -0.08738154f, 0.06759971f, 
    0.03784232f, 0.02560024f, 0.03690726f, -0.06460410f, 0.01093537f, -0.06877389f, -0.03962213f, 0.02155301f, 
    -0.00281193f, -0.08486299f, -0.05303898f, -0.05752429f, 0.15163341f, -0.29460797f, -0.03893303f, 0.19526136f, 
    0.05806476f, 0.04099547f, 0.02679148f, -0.08796286f, 0.00777171f, -0.09172498f, 0.07960610f, 0.00108345f, 
    -0.04000135f, 0.06631923f, 0.03783088f, 0.07893602f, 0.00551288f, -0.03877198f, -0.01565768f, -0.03438432f, 
    -0.09128515f, 0.01416324f, -0.11138279f, -0.20437053f, 0.28762200f, 0.10536972f, -0.20339610f, -0.03232631f, 
    0.06378832f, -0.03408333f, 0.03218754f, -0.00345203f, -0.00496914f, -0.00056092f, -0.01892307f, 0.17634384f, 
    -0.01128121f, 0.10222360f, 0.01061316f, -0.00026446f, -0.03421188f, 0.09193187f, 0.01548007f, -0.06197407f, 
    -0.02276324f, -0.08355024f, 0.03742562f, 0.02651962f, 0.00778581f, -0.02768712f, -0.02067804f, 0.00819121f, 
    -0.03209466f, -0.07742451f, 0.05870730f, 0.08618006f, -0.05847934f, 0.00858218f, 0.08143478f, -0.02205514f, 
    0.03810783f, -0.00892313f, -0.02475733f, 0.04797811f, -0.06759736f, -0.01697768f, 0.04082094f, 0.01990843f, 
    -0.01279125f, -0.01717902f, -0.05889958f, -0.06782033f, -0.01285799f, 0.03248376f, -0.07241232f, -0.05479553f, 
    -0.07225351f, 0.02495958f, -0.08555875f, -0.04306421f, 0.27629393f, 0.16956225f, -0.14082931f, 0.05279538f, 
    0.04931773f, 0.03659786f, 0.04699551f, 0.02110789f, 0.00668490f, -0.01477272f, 0.07625119f, 0.06596116f, 
    -0.01471827f, -0.01666557f, -0.02726408f, -0.06880453f, -0.05755033f, 0.00242771f, -0.00755059f, 0.09157160f, 
    -0.15607835f, -0.00308290f, 0.01675393f, 0.01610386f, -0.08610189f, -0.00027409f, -0.05060836f, -0.07090619f, 
    -0.01979367f, 0.01816228f, -0.13102494f, -0.03860524f, 0.02367928f, -0.06077893f, -0.01337108f, -0.04873249f, 
    0.00744087f, -0.03368515f, -0.13121158f, -0.06858882f, 0.31213704f, 0.15414815f, -0.23785798f, 0.02009539f, 
    0.00904444f, 0.06230677f, -0.07417341f, -0.02503797f, 0.00859336f, -0.01290901f, 0.08704150f, 0.05045518f, 
    0.01719011f, 0.02490407f, 0.01178438f, 0.01726547f, -0.03538653f, 0.03524771f, 0.04121686f, 0.08486205f, 
    -0.20668603f, 0.01734639f, 0.11065676f, -0.05571291f, 0.12987141f, -0.03853099f, -0.03331810f, 0.02441740f, 
    -0.06841779f, -0.09673727f, 0.01210913f, 0.00171177f, 0.02576221f, -0.06031862f, -0.10777592f, -0.11665832f, 
    -0.05422134f, -0.04425828f, -0.06212056f, -0.05569922f, 0.06378487f, 0.12089849f, -0.06295767f, -0.06501081f, 
    -0.03468120f, -0.04895486f, -0.12062432f, -0.00791172f, -0.08687419f, -0.12561779f, 0.02788414f, 0.07174454f, 
    0.04985911f, -0.02303713f, -0.00840316f, 0.04874556f, 0.02647534f, -0.03559177f, 0.00874208f, -0.03428245f, 
    -0.22311683f, -0.32424897f, 0.00118483f, -0.14967072f, -0.15453444f, -0.01984794f, 0.07471576f, 0.03945697f, 
    0.03764817f, 0.01228543f, -0.02236520f, -0.04017897f, 0.03013530f, -0.02578851f, -0.00093164f, -0.06187924f, 
    -0.02092839f, -0.08128256f, -0.03513552f, 0.01280896f, 0.10509596f, -0.00296172f, -0.06556193f, -0.09401210f, 
    -0.00950531f, 0.08139439f, 0.03358470f, -0.05776456f, 0.02770171f, 0.03674193f, 0.09979660f, -0.00424891f, 
    0.02673490f, -0.03979753f, 0.04819334f, -0.04938107f, -0.07041700f, 0.01535027f, -0.03352049f, -0.02370791f, 
    -0.09576505f, 0.06089730f, -0.01038865f, 0.01855944f, -0.10277073f, 0.01784613f, -0.00395720f, -0.05545624f, 
    -0.00357062f, 0.00598911f, -0.07154860f, -0.05168789f, 0.03534629f, 0.02328098f, -0.00272456f, 0.04238162f, 
    -0.01123324f, 0.00032618f, -0.05491930f, -0.05595786f, 0.27814355f, -0.11287314f, -0.07354413f, -0.04880330f, 
    -0.08823872f, -0.05329917f, 0.03726685f, -0.00814470f, -0.02265919f, 0.00948091f, 0.11404313f, -0.06271799f, 
    0.00344131f, -0.03501204f, 0.06376629f, 0.01991671f, -0.01903154f, -0.08584709f, -0.00169091f, 0.01496319f, 
    0.15582506f, 0.11189679f, -0.08003706f, 0.07174006f, 0.10352737f, 0.03648647f, -0.17429307f, -0.03080242f, 
    0.07874028f, 0.00930668f, 0.02224922f, 0.02029445f, 0.01240959f, -0.00188585f, 0.04710727f, -0.03516086f, 
    0.10041841f, 0.03362821f, -0.10434340f, 0.02413006f, 0.40739793f, 0.00789460f, -0.13107337f, 0.07308714f, 
    -0.04071970f, -0.02462634f, 0.00915160f, -0.00866636f, -0.01532898f, 0.08209897f, 0.07445171f, 0.01104774f, 
    -0.01450466f, 0.02463522f, 0.04688146f, 0.00720941f, -0.01604923f, -0.05286743f, 0.02865761f, 0.02746816f, 
    -0.42137364f, -0.22384287f, -0.03357048f, -0.03659259f, 0.04142739f, -0.03272393f, 0.03565557f, -0.01761579f, 
    0.04903691f, 0.00036303f, -0.07791846f, 0.08454719f, 0.03919951f, 0.05147816f, 0.02574675f, -0.00065567f, 
    -0.05774574f, -0.07703430f, -0.06894357f, -0.04350589f, 0.11230992f, 0.07443554f, -0.20007080f, 0.11393908f, 
    -0.17337613f, 0.05184432f, 0.05152054f, -0.03465885f, -0.00621191f, -0.01884093f, -0.07498634f, 0.01455271f, 
    -0.03283138f, 0.09303687f, 0.11698496f, -0.01719886f, 0.10070462f, 0.08648128f, -0.08676825f, -0.00346309f, 
    0.03148592f, -0.22960266f, 0.02430546f, -0.01536131f, -0.08152322f, 0.10145348f, 0.04828845f, -0.00634542f, 
    -0.09777320f, 0.01923740f, 0.01874894f, -0.04958787f, -0.05449196f, -0.02433838f, -0.13882567f, -0.05977230f, 
    -0.05904301f, -0.03186144f, -0.03932529f, -0.00223576f, -0.05352942f, -0.09993482f, -0.15323329f, -0.03979861f, 
    -0.11733194f, 0.03931359f, 0.03753600f, 0.06791443f, 0.04570898f, -0.01193146f, -0.07926703f, 0.05986422f, 
    0.06392615f, -0.01305634f, 0.03331570f, -0.00459570f, 0.00902318f, 0.01329836f, -0.10714606f, -0.04746269f, 
    -0.28671667f, 0.03292855f, -0.03910125f, -0.06434776f, 0.06071911f, -0.13884018f, -0.06360704f, -0.07722132f, 
    0.03906187f, -0.01424227f, 0.09476250f, 0.01682758f, -0.04561035f, 0.02168510f, -0.04858864f, 0.10705420f, 
    -0.04500513f, -0.05578834f, 0.09725473f, 0.08474280f, -0.10819791f, 0.19463333f, -0.09207052f, -0.03340859f, 
    0.00684161f, 0.10746558f, -0.01627865f, 0.00495085f, -0.05656299f, -0.13527817f, 0.05092480f, 0.04315755f, 
    -0.12641582f, -0.08517479f, -0.04045905f, 0.02906090f, 0.07905240f, -0.04086785f, 0.06557545f, 0.01626422f, 
    -0.16536768f, 0.21293704f, -0.04281894f, 0.11328476f, -0.12852086f, 0.16418518f, 0.04760476f, 0.02045859f, 
    -0.03828291f, 0.01159557f, -0.01560521f, -0.05436416f, 0.02019419f, 0.01071279f, 0.08464479f, -0.04889298f, 
    0.07390608f, -0.02972937f, 0.00482820f, 0.06778874f, -0.25572130f, 0.12001695f, 0.01137649f, -0.08685939f, 
    0.05947589f, 0.03095455f, 0.00308390f, -0.03022506f, 0.00898844f, -0.05129834f, -0.04710703f, 0.04059973f, 
    0.02935132f, 0.04294161f, 0.03775486f, -0.00907202f, -0.03640525f, 0.00185419f, -0.02728888f, 0.01307205f, 
    -0.06918403f, -0.27796581f, -0.09013864f, 0.06933716f, 0.11154101f, -0.09285067f, 0.07150878f, -0.06651867f, 
    -0.01606060f, -0.10198350f, 0.07627237f, -0.09067769f, 0.01572263f, 0.09985103f, -0.02403892f, 0.07446945f, 
    0.01482254f, 0.00072141f, -0.03608488f, -0.00863926f, -0.39980140f, -0.13754833f, -0.03930817f, -0.10379864f, 
    -0.05113858f, -0.02429356f, 0.01360173f, -0.05066683f, 0.05539230f, 0.02536566f, -0.08417957f, 0.03252023f, 
    0.01564978f, 0.02183115f, 0.00987680f, -0.02450673f, -0.00201015f, -0.04079245f, -0.04455817f, -0.01743450f, 
    0.09517032f, -0.20957085f, -0.00722824f, 0.13107744f, 0.26142636f, 0.00818726f, 0.01728552f, 0.02422552f, 
    0.00898459f, -0.00500587f, -0.01646031f, -0.06067434f, -0.03559217f, 0.03809832f, 0.14455143f, 0.08727916f, 
    0.09942481f, -0.06020031f, 0.01489163f, 0.00496819f, -0.31714490f, 0.22918132f, 0.00587796f, 0.04056961f, 
    0.23343880f, -0.03708202f, 0.02598485f, 0.01839251f, 0.00864523f, 0.13909726f, 0.03265359f, 0.10328160f, 
    0.04092298f, -0.00162124f, -0.00243064f, -0.05888189f, 0.01778303f, -0.01259803f, -0.00325063f, -0.12025718f, 
    0.06178401f, -0.04587984f, -0.04163640f, -0.12913007f, 0.24689031f, 0.05267693f, -0.01969135f, 0.03135377f, 
    0.06747114f, -0.02511308f, 0.04732050f, -0.06846367f, 0.01058058f, 0.09500119f, 0.03912631f, 0.02905202f, 
    -0.00478488f, 0.01825078f, 0.02512132f, 0.03044071f, 0.07574264f, 0.02589170f, 0.05721089f, -0.01434900f, 
    0.03452670f, -0.05604784f, 0.03655035f, 0.05664745f, 0.01545422f, -0.12977700f, -0.02532189f, -0.03538585f, 
    -0.00781860f, 0.01414992f, -0.04441623f, -0.03319665f, -0.04756388f, 0.00527564f, -0.05784660f, -0.05115552f, 
    0.25373915f, 0.18255353f, -0.12238447f, -0.22406553f, -0.05641066f, 0.05355804f, 0.05835541f, 0.03290210f, 
    0.08897427f, 0.00090799f, 0.15326925f, -0.02220731f, -0.01060230f, -0.04917984f, 0.06822761f, 0.00413145f, 
    -0.07620617f, 0.00747940f, -0.00781065f, 0.11195936f, 0.08213249f, 0.00606700f, -0.12914041f, -0.06183720f, 
    -0.08572150f, 0.10649551f, -0.03622226f, 0.07185271f, 0.01771916f, 0.11096289f, 0.01301218f, -0.01440950f, 
    -0.00942186f, 0.02791139f, 0.05044279f, 0.00525052f, -0.07162196f, -0.02172294f, 0.01216868f, -0.09628563f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03144118f, 0.00709041f, -0.01000610f, -0.01946909f, 0.00746916f, 0.03209590f, -0.00770549f, -0.04797199f, 
    -0.00725481f, -0.01443407f, 0.01445261f, 0.01031001f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
