#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.55803859f, -0.25418338f, 0.08537462f, 0.19676575f, 0.78312236f, -0.16915919f, -0.68405032f, -0.46262738f, 
    -0.86404181f, -0.16667035f, 0.52723980f, 0.39310223f, 0.70199931f, -1.01124454f, -1.06049860f, 0.12610753f, 
    0.27661207f, 0.77422082f, -0.23796490f, -0.10866177f, -0.18381956f, 0.86448783f, 1.71720290f, 0.67244029f, 
    0.11949880f, 0.23785022f, 0.05702441f, 0.40140936f, -1.14489496f, 0.28682342f, -0.83243471f, -0.63444310f, 
    -0.85046601f, -0.42133480f, 0.76907510f, -0.54167873f, 1.04818273f, 0.92180395f, 0.88839734f, -0.87890297f, 
    0.22777314f, -0.30250865f, 0.53097850f, 0.08595329f, 0.45079646f, -1.42653537f, -0.12845880f, -1.01230419f, 
    1.28644264f, -0.36463058f, -0.80648589f, -0.42847809f, -0.54042894f, 0.02407113f, -0.17999820f, -0.91172117f, 
    -1.61893356f, 0.17306454f, 0.12272394f, 0.14661098f, -0.19893107f, -0.03636896f, -0.70487916f, 0.79216599f, 
    0.36925006f, -0.04759502f, 0.61944187f, -0.32670000f, -1.05212247f, -0.17772590f, -0.31374779f, 1.22190368f, 
    -0.06258947f, 1.05922818f, 0.75635445f, -0.08247302f, 0.45588192f, 0.29378346f, -0.23868223f, -0.75815570f, 
    -0.37579489f, 1.08846581f, -1.09398508f, -0.32319552f, 0.30635354f, -0.49771780f, -0.97184610f, -0.45325002f, 
    -0.79177266f, -0.36076206f, 0.11623304f, 1.17461407f, -0.83717197f, 0.05291200f, 1.17716801f, -0.17002706f, 
    0.12725952f, 0.09091854f, -0.01274626f, -0.63011754f, -0.02297628f, 0.19574377f, -1.00977504f, -1.64372325f, 
    -1.29475260f, 0.02225837f, -0.50221586f, -0.71104157f, -0.50365007f, -0.78837657f, -1.27345085f, -0.31368485f, 
    1.11526597f, 0.16991509f, 0.78404337f, 0.14982550f, 0.71515691f, 0.84834629f, 0.98795366f, -0.67954087f, 
    -0.31542152f, -0.08030257f, 0.12969494f, -0.24054167f, 0.25438905f, 0.56830502f, 0.39393130f, -0.17844798f, 
    0.76242644f, 0.09886646f, -0.11455854f, 0.52276278f, -0.21959057f, -0.10019879f, 1.15572453f, -1.49852800f, 
    0.93747252f, 0.42927212f, -1.31520391f, 0.08445352f, 0.58595079f, -0.11870674f, 0.02997543f, 0.92932349f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02664061f, 0.74095732f, 0.11892837f, 0.73644799f, -0.06910150f, 0.12557529f, 0.80555338f, 0.11974008f, 
    0.41756824f, 0.28456405f, 0.78477627f, -0.18247706f, 0.30710354f, 0.96466708f, 0.83282900f, 0.49517271f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.27446610f, -0.63605815f, -0.30287024f, -0.23182413f, -0.06010512f, 0.04728324f, 0.11091942f, 0.03942717f, 
    0.39589319f, -0.22694427f, 0.08198153f, 0.03992493f, 0.14044274f, -0.02423878f, -0.14725149f, 0.16702659f, 
    -0.01289329f, 0.15152253f, -0.28386700f, -0.00831454f, -0.16982490f, -0.14535359f, -0.28473303f, -0.12966374f, 
    -0.23529471f, -0.13008013f, -0.12830636f, -0.08278018f, -0.27679881f, -0.35473946f, 0.26393163f, 0.15544321f, 
    0.16062903f, 0.07145676f, -0.01398015f, -0.10867161f, 0.78055960f, -0.03454889f, -0.32491755f, -0.21725745f, 
    -0.09455600f, -0.11774098f, -0.05717103f, 0.02163768f, -0.28507152f, -0.28534710f, -1.36048067f, -0.68780375f, 
    -0.05070978f, -0.17686751f, 0.07874900f, 0.08194426f, 0.04084568f, 0.03139971f, -0.23011644f, -0.36061049f, 
    -0.42771283f, -0.10496330f, 0.03050305f, 0.05211222f, 0.08076959f, -0.04001104f, 0.22802418f, 0.33203858f, 
    0.22098760f, 0.12418456f, 0.30650359f, -0.24260806f, 0.01146405f, 0.21634538f, 0.01436721f, -0.19161014f, 
    0.10339938f, 0.32705209f, 0.26004770f, -0.14091480f, -0.07737608f, -0.01717840f, 0.05192029f, 0.23440789f, 
    0.26883560f, -0.24187453f, -0.40625083f, -0.26634163f, -0.06158378f, 0.15726246f, -0.07015450f, 0.03948848f, 
    0.05565780f, 0.05766758f, 0.00576954f, 0.14041086f, 0.18395142f, -0.04514149f, -0.00935544f, 0.02428614f, 
    0.05704889f, 0.06905936f, 0.17963329f, -0.59122264f, 0.31724274f, -0.21486291f, -0.22245061f, -0.00820097f, 
    -0.22106351f, 0.00137409f, -0.17476921f, 0.03755337f, -1.06752801f, -0.02929723f, -0.04824550f, 0.05551954f, 
    0.21287225f, 0.15147389f, 0.21474765f, 0.04909788f, -0.22520055f, 0.43549582f, 0.22276950f, -0.00490665f, 
    0.18368898f, -0.10978380f, 0.24595459f, 0.16738786f, 0.11030525f, 0.08767596f, 0.26686224f, 0.04117468f, 
    -0.00479449f, 0.09141897f, -0.04082410f, 0.02568870f, 0.02870726f, 0.02694875f, -0.12824890f, -0.13484515f, 
    -0.16498812f, -0.24867904f, 0.12077356f, 0.35407645f, 0.12593840f, 0.26229134f, -0.00519342f, 0.03172874f, 
    -0.71758181f, 0.00824155f, 0.12375867f, 0.10662691f, 0.16276655f, -0.19873312f, -0.26759246f, -0.27044842f, 
    -0.26783684f, -0.15966952f, -0.35674301f, -0.26899007f, 0.03671810f, 0.00389020f, 0.18647067f, 0.30853727f, 
    0.17732175f, 0.13556620f, 0.09935284f, -0.08768383f, -0.21639167f, 0.26121366f, 0.23694593f, 0.23448132f, 
    -0.11276851f, 0.08799631f, -0.01482940f, 0.06953758f, -0.12170700f, 0.31124857f, 0.33853891f, 0.22258408f, 
    0.22888182f, 0.19910558f, 0.00433544f, -0.00692196f, -0.04867669f, -0.01543128f, 0.11432029f, -0.18797603f, 
    -0.13109539f, -0.07401931f, -0.42200863f, 0.07306583f, -0.28463101f, -0.55670989f, 0.30861658f, 0.40767670f, 
    0.06080933f, -0.08888981f, -0.03185044f, -0.13825153f, -0.29836681f, 0.05265467f, -0.30076084f, 0.21970177f, 
    -0.03250767f, 0.02791874f, 0.16571349f, -0.38148320f, -0.29832211f, -0.20804586f, 0.02743856f, -0.06855650f, 
    -0.12643564f, 0.13520561f, -0.09499735f, 0.20889854f, 0.01206232f, 0.18668522f, -0.02116083f, 0.21988477f, 
    0.14529465f, -0.10083217f, -0.11373438f, 0.01768540f, -0.34540346f, 0.01839486f, 0.00289769f, -0.22641069f, 
    -0.74293870f, 0.25506055f, 0.35972857f, -0.14323963f, 0.05621767f, -0.06198138f, -0.06773029f, 0.06310160f, 
    -0.27631480f, -0.09369428f, 0.21520138f, 0.03167405f, 0.03918839f, 0.03356962f, -0.10495058f, 0.46463773f, 
    -0.18495806f, -0.04724834f, 0.12905782f, -0.22976093f, -0.51988471f, -0.48617321f, 0.15643239f, 0.06224891f, 
    0.31575671f, 0.16202824f, -0.14693882f, -0.10318006f, 0.23232214f, 0.27340749f, 0.20169546f, 0.09327004f, 
    -0.01541769f, -0.33490852f, 0.14499228f, 0.20844190f, -0.00380790f, 0.21848230f, 0.19962852f, 0.07826180f, 
    0.13233747f, 0.10119574f, 0.09540461f, -0.02948775f, 0.09611653f, 0.04406686f, 0.02665145f, -0.15192254f, 
    0.31688946f, -0.15879087f, 0.22056170f, 0.01310724f, -0.11407428f, -0.21567354f, 0.26018092f, 0.38417110f, 
    0.08065397f, 0.47153279f, -0.00582358f, 0.09260976f, -0.06446817f, 0.17823853f, 0.23398958f, 0.43745372f, 
    0.56931388f, 0.03954892f, 0.23296328f, 0.01939874f, -0.20314795f, -0.25451657f, 0.25764582f, 0.16155314f, 
    0.00855745f, -0.17130286f, 0.23751989f, 0.06016337f, -0.34332421f, -0.07629371f, -0.00750273f, 0.13252884f, 
    -0.05987883f, 0.02685137f, 0.22069551f, -0.69509035f, -0.06982353f, 0.03158396f, -0.16206695f, -0.15148939f, 
    0.26171526f, 0.08513533f, 0.31160966f, 0.09217560f, 0.00254787f, 0.03966567f, -0.02816342f, 0.22796726f, 
    0.11505812f, 0.16759306f, -0.14321668f, -0.00779793f, -0.37559247f, -1.24543238f, -0.40493339f, 0.24140483f, 
    -0.37391603f, -0.01524954f, -0.10167819f, -0.16747813f, 0.18719216f, 0.25867936f, 0.15566367f, 0.13329111f, 
    0.28992507f, -0.11886995f, 0.05238401f, 0.03955599f, -0.03892449f, 0.21692827f, 0.39134538f, 0.20667733f, 
    0.16679239f, 0.04413013f, -0.06575648f, 0.10475505f, 0.04124004f, 0.09664806f, 0.00324249f, -0.53498954f, 
    -0.22824427f, -0.17161886f, -0.23737410f, 0.09698065f, -0.09244497f, 0.06918644f, -0.05445359f, 0.13594124f, 
    -0.43087637f, 0.07485060f, -0.16093323f, 0.39226028f, 0.14113574f, 0.13063885f, 0.05992073f, 0.02101575f, 
    0.06146390f, -0.01459157f, -0.10956720f, 0.00108096f, -0.03302301f, 0.02250221f, -0.02817857f, 0.34640217f, 
    -0.06378471f, 0.02338607f, -0.19299047f, -0.70620924f, -0.89776176f, 0.14314555f, 0.22521800f, -0.30623731f, 
    0.39964479f, -0.17475246f, 0.07551053f, -0.06812821f, -0.03193340f, 0.08892824f, -0.22469543f, -0.26643959f, 
    -0.03224422f, 0.03059238f, -0.04970772f, 0.06295997f, -0.01635346f, -0.52302974f, -0.12375619f, 0.16650498f, 
    -0.05505459f, 0.31680122f, -0.14340238f, 0.09052169f, -0.04481227f, 0.10053973f, -0.29720134f, 0.03118416f, 
    -0.03453234f, 0.25413260f, -0.06035500f, 0.09777282f, -0.00083776f, 0.07153413f, -0.30988941f, -0.38823512f, 
    -0.35396752f, 0.22432086f, 0.15206073f, 0.07251037f, -0.05697277f, 0.11435099f, 0.04645050f, 0.12672047f, 
    -0.53689551f, -0.50501490f, 0.04919499f, -0.23564366f, -0.11892680f, 0.20013089f, 0.12310077f, 0.18400241f, 
    -0.04460313f, 0.23240709f, 0.01230150f, -0.09276660f, -0.13006623f, -0.38920429f, -0.04352989f, -0.08370893f, 
    -0.15709700f, 0.50200939f, 0.30084750f, -0.24983877f, -0.05565420f, -0.00248284f, -0.17484988f, 0.24668258f, 
    0.01949642f, -0.04657505f, 0.32991180f, 0.28202829f, 0.38086107f, -0.58822250f, -0.39352122f, -0.25522193f, 
    0.14837767f, -0.01330594f, -0.06290660f, 0.03766103f, 0.35452431f, 0.51974201f, -0.02520534f, -0.11165377f, 
    0.21287036f, 0.15031363f, -0.12108736f, -0.19449458f, -0.38650280f, 0.07349255f, -0.30284759f, 0.29226890f, 
    0.20534191f, 0.18265414f, -0.01734534f, -0.09828798f, 0.06405715f, -0.22655144f, -0.47185948f, -0.12666048f, 
    -0.34118369f, 0.02886224f, -0.11275887f, 0.11761903f, -0.00367204f, 0.17014885f, -0.01185251f, -0.19246025f, 
    0.44893596f, -0.07156797f, -0.14627078f, -0.14802690f, -0.01632901f, -0.18516624f, 0.12068369f, -0.69279099f, 
    0.16214448f, -0.19077173f, 0.17652455f, 0.19757129f, -0.09053064f, -0.01185592f, 0.01553742f, 0.14729783f, 
    -0.14182794f, -0.25120932f, -0.17319512f, 0.14050132f, 0.09154179f, 0.22156493f, -0.11483886f, 0.11946858f, 
    0.35972142f, 0.14540142f, 0.06197294f, -0.00069598f, -0.00826190f, 0.05367675f, 0.01786343f, 0.03091009f, 
    -0.16431041f, 0.13672926f, -0.03898141f, -0.00607920f, 0.13257352f, -0.22784758f, 0.19099537f, -0.06695471f, 
    0.04622463f, 0.23812708f, -0.04778513f, 0.09286187f, 0.20296790f, 0.57935506f, -0.01190398f, -0.12681071f, 
    -0.00982470f, 0.17071614f, -0.00696680f, 0.14386706f, -0.11429209f, 0.21967949f, 0.88630944f, 0.32184473f, 
    -0.32642385f, -0.50116980f, 0.09530514f, 0.13160858f, 0.13000131f, -0.42644450f, 0.24261810f, -0.22590248f, 
    0.29725802f, 0.00935688f, 0.09291936f, 0.00294201f, 0.19110762f, 0.00412138f, -0.45826358f, -0.20222883f, 
    -0.14481023f, 0.19383277f, 0.15544239f, 0.22663619f, 0.23199035f, -0.09531774f, 0.02670114f, -0.32451978f, 
    0.45099202f, -0.44608271f, 0.02790065f, -0.09820691f, -0.12147165f, -0.10684516f, -0.07287193f, 0.08528887f, 
    -0.47951573f, -0.22159265f, 0.42021409f, 0.03924410f, 0.03617752f, -0.14559554f, 0.16422923f, 0.09707335f, 
    -0.11635748f, -0.39332724f, -0.36875916f, -0.16488913f, -0.03759457f, -0.04590286f, 0.04117385f, 0.08482359f, 
    0.24364023f, 0.18788342f, -0.09195349f, -0.83177161f, 0.30957395f, -0.30933040f, -0.06222079f, -0.23529220f, 
    0.18221465f, 0.07123262f, -0.02366121f, 0.10327402f, 0.23733322f, 0.74488956f, -0.27412644f, -0.11201287f, 
    -0.00901812f, 0.11236992f, -0.17863533f, 0.26091468f, -0.33641729f, -1.37060714f, 0.31140578f, -0.17225994f, 
    -0.01631941f, 0.12473434f, -0.14641804f, 0.02988636f, -0.09487846f, 0.08148298f, 0.19874619f, 0.17823742f, 
    -0.01072222f, 0.18063341f, 0.19459647f, 0.21571261f, -0.09080464f, -0.07292534f, 0.00439483f, -0.15234649f, 
    -0.14445232f, 0.04105944f, 0.09647371f, -0.18440068f, 0.16433939f, -0.09019580f, -0.37184921f, -0.04043094f, 
    -0.46343413f, 0.01156078f, -0.41528076f, -0.04795832f, 0.12019955f, 0.08200180f, -0.02255748f, 0.28237700f, 
    -0.10375547f, -0.07455175f, -0.33261403f, -0.06868041f, -0.22935474f, 0.05057140f, 0.19742833f, -0.00564191f, 
    -0.33708185f, 0.47068825f, 0.25014916f, -0.05772452f, 0.07254177f, -0.08376148f, 0.19367160f, 0.27508664f, 
    -0.16412383f, -0.06793847f, -0.26417944f, -0.69623435f, 0.37349555f, -0.11642832f, -0.20891643f, 0.70183063f, 
    0.08552729f, 0.11729953f, 0.02690755f, 0.09975311f, 0.15144545f, -0.03496301f, -0.29439780f, -0.27767873f, 
    0.04908592f, 0.02748226f, 0.06049794f, 0.23010762f, -0.15357539f, -0.44981185f, 0.21766715f, -0.20368715f, 
    0.05765190f, -0.07374486f, 0.15855990f, 0.12855582f, 0.31508744f, -0.03848435f, -0.65343821f, -0.92593467f, 
    -0.12812892f, 0.27608171f, 0.30394238f, -0.02313821f, 0.02361999f, 0.39019108f, -0.31182459f, -0.45619777f, 
    0.05447877f, 0.02238452f, -0.04866143f, -0.14423579f, 0.14198998f, -0.07022594f, 0.12054662f, -0.50106287f, 
    -0.16430400f, 0.08756364f, 0.27830827f, -0.05860972f, 0.21654247f, 0.11617731f, 0.07942789f, 0.21496691f, 
    0.08253950f, 0.04330261f, 0.08547823f, 0.01382846f, 0.21171059f, -0.25896201f, 0.06528396f, 0.06635307f, 
    0.08341958f, -0.02955649f, -0.24240753f, 0.12116804f, 0.02407181f, 0.04930197f, 0.28164101f, -0.18955280f, 
    -0.02061650f, -0.08927736f, -0.02429457f, 0.11375634f, 0.12217055f, -0.22774129f, -0.34498516f, -0.06321818f, 
    0.12621094f, -0.02883637f, -0.19142008f, -0.32338053f, -0.30385154f, -0.45316717f, 0.01660696f, -0.05160939f, 
    0.26117852f, -0.05433936f, 0.01978486f, -0.14092836f, 0.03307344f, 0.01605859f, 0.01147836f, 0.08756956f, 
    0.15945129f, 0.08900816f, 0.03236756f, -0.35239157f, 0.03824637f, -0.45765474f, -0.06225447f, 0.06130932f, 
    -0.08351052f, -0.03969016f, -0.28266075f, 0.04882078f, 0.07675558f, -0.11892198f, -0.10299245f, 0.35189289f, 
    -0.12463193f, 0.17098255f, 0.03112073f, -0.44062704f, 0.15457855f, -0.27267423f, 0.10368720f, -0.10045025f, 
    -0.17230833f, -0.08708716f, 0.00453127f, 0.21746267f, 0.32848552f, 0.20268093f, 0.14130175f, 0.11394610f, 
    0.18630429f, 0.00864502f, -0.00816982f, 0.01276502f, -0.08215973f, 0.02569448f, 0.36270687f, 0.03514427f, 
    0.41535202f, -0.08531168f, -0.30593726f, -0.83608961f, 0.04770463f, 0.06832177f, 0.05222807f, 0.13658184f, 
    0.10230125f, -0.00988584f, -0.12605534f, 0.08032984f, 0.19788645f, 0.14209440f, 0.13625483f, 0.30933329f, 
    0.00622088f, -0.11811157f, 0.05434494f, -0.21581908f, -0.23014504f, -0.49795377f, -0.13629018f, 0.08630884f, 
    0.05198170f, -0.10136289f, -0.02183524f, 0.04491067f, -0.38288313f, 0.55825800f, -0.16842559f, -0.08664475f, 
    -0.04263794f, 0.11774307f, 0.06554606f, -0.06908911f, -0.08989075f, 0.27436829f, -0.12254445f, 0.02988135f, 
    0.29020700f, 0.11569133f, 0.30798519f, 0.12584141f, 0.13158005f, 0.00380524f, 0.08291461f, 0.18057390f, 
    0.05563120f, 0.21670522f, 0.27500245f, -0.06778089f, 0.05549021f, 0.33010241f, 0.24321929f, -0.45723954f, 
    0.01217238f, 0.05783669f, 0.32926193f, 0.18028305f, -0.04784579f, 0.06295007f, 0.00596912f, 0.01344106f, 
    -0.15948297f, 0.01667574f, -0.07345002f, 0.12807831f, 0.14022776f, 0.06160815f, 0.03869838f, -0.02725382f, 
    -0.24673143f, 0.10267599f, -0.52974397f, 0.29801396f, 0.03518784f, 0.15904355f, -0.16439697f, 0.16434374f, 
    0.04468243f, 0.01898348f, -0.36851519f, -0.35224575f, 0.33380637f, -0.33324936f, 0.08868068f, -0.16450299f, 
    0.14194980f, -0.04290428f, 0.02635991f, 0.22245891f, -0.12973887f, -0.45820013f, -0.06082218f, 0.18799788f, 
    -0.05474971f, -0.08392169f, 0.08450508f, -0.09841438f, -0.71316624f, -0.57997411f, 0.12649049f, -0.15841378f, 
    -0.35749325f, -0.40956387f, -0.26697505f, -0.13748658f, 0.18531491f, -0.11920686f, 0.14236306f, 0.67251951f, 
    0.12557942f, -0.16527991f, -0.01974302f, 0.06730656f, 0.04729912f, 0.14338139f, 0.20334575f, 0.19809949f, 
    0.59871626f, -0.03674323f, 0.13995740f, 0.00279566f, 0.15666763f, 0.09613237f, 0.16796391f, -0.56506145f, 
    -0.49606189f, 0.07131421f, -0.22798979f, -0.36559477f, -0.18140863f, 0.10286320f, 0.06548312f, 0.30161789f, 
    -0.08225442f, -0.17792402f, 0.12077165f, 0.29093844f, -0.21526651f, -0.46774578f, 0.09078849f, -0.00955134f, 
    0.02379350f, 0.13245969f, 0.29198372f, -0.08546428f, -0.03928530f, -0.01992130f, -0.10980701f, 0.25801191f, 
    0.08055662f, 0.18156627f, 0.64122671f, -0.65235579f, -0.23219323f, 0.04106176f, -0.41770756f, -0.29362935f, 
    0.13860968f, -0.00960467f, 0.04527018f, -0.67880452f, -0.34282735f, 0.07248474f, -0.27412939f, -0.09896092f, 
    -0.14620569f, -0.09126705f, -0.11162866f, 0.17603216f, -0.69119632f, -0.43364477f, 0.65016162f, -0.09712778f, 
    0.12917943f, 0.12366064f, 0.02125772f, -0.09557318f, 0.14924093f, 0.29046261f, 0.07291618f, 0.27300644f, 
    0.29433572f, 0.26979116f, 0.29291216f, 0.06284663f, 0.07825995f, -0.01750422f, 0.49008662f, 0.05828739f, 
    -0.28540865f, -0.06051922f, -0.00134085f, 0.18274830f, 0.11136343f, 0.16726182f, 0.46110687f, 0.59087712f, 
    -0.24132447f, -1.12846851f, 0.10229617f, 0.06295752f, -0.08984759f, 0.02488322f, 0.17347270f, 0.26880535f, 
    0.22157983f, 0.03949200f, -0.01278664f, 0.09099032f, 0.11849394f, -0.29399234f, 0.00966801f, -0.00656889f, 
    -0.18983613f, 0.13112333f, -0.19064884f, -0.16440777f, -0.24612367f, 0.11910141f, 0.24063087f, 0.14707665f, 
    0.18851691f, 0.27986693f, 0.14297639f, -0.07501908f, 0.29483843f, -0.11177330f, 0.01214874f, -0.91061592f, 
    -0.05601037f, -0.11911307f, -0.04815784f, -0.00950062f, -0.10547154f, -0.16730772f, -0.04017395f, 0.03855798f, 
    0.10102344f, 0.07402995f, -0.20099074f, 0.10280478f, -0.08139442f, 0.08001445f, 0.17569572f, 0.00067231f, 
    0.04019706f, 0.09591133f, -0.24073441f, -0.01463752f, 0.14237407f, 0.50311136f, 0.09064005f, -0.22521599f, 
    0.11992433f, 0.07916429f, -0.16396366f, 0.00223452f, 0.10823273f, -0.10850497f, -0.04707073f, -0.00462893f, 
    -0.09091327f, 0.01843011f, 0.18108770f, -0.09257296f, 0.07626851f, 0.02479059f, -0.21839698f, -0.09031828f, 
    -0.70492572f, 0.14433436f, -0.06016552f, -0.01866663f, 0.03158080f, 0.28634492f, -0.07912514f, 0.12663271f, 
    -0.09035336f, -0.19584231f, 0.01947868f, 0.00420823f, 0.00260521f, 0.09112895f, -0.44306359f, 0.14792737f, 
    -0.18669496f, 0.01797683f, -0.05436734f, -0.52729636f, -0.09501925f, -0.01524268f, 0.00426927f, -0.12390045f, 
    0.00175441f, 0.12447440f, 0.05990433f, 0.14078143f, 0.36729485f, -0.23911412f, -0.09348803f, 0.22885956f, 
    0.01668789f, -0.32993233f, -0.15711296f, 0.60882717f, 0.38144991f, -0.70901126f, 0.04647149f, 0.02437541f, 
    0.14933366f, 0.00591861f, 0.05890996f, 0.17940935f, 0.11234093f, -0.37571600f, 0.23026718f, 0.31877717f, 
    0.00948010f, -0.15753278f, -0.01739632f, 0.08634725f, -0.10577852f, -0.30294368f, -0.10845451f, -0.02068282f, 
    -0.32055143f, 0.10575826f, 0.23592225f, -0.02680452f, -0.06234890f, 0.26825857f, -0.00128517f, 0.05491734f, 
    0.15787065f, 0.19617599f, 0.06350936f, -0.12269239f, 0.04253065f, -0.03987306f, 0.11969215f, 0.18085897f, 
    0.57926691f, 0.13422060f, 0.04828374f, -0.26372606f, 0.05334922f, 0.02736822f, 0.07501452f, -0.09708502f, 
    -0.13639350f, 0.17001589f, -0.56259412f, -0.34444520f, 0.00572880f, 0.04360086f, -0.09852500f, 0.00886414f, 
    -0.24295034f, -0.17282933f, -0.24662153f, -0.10284553f, -0.10669613f, -0.06482509f, -0.03249959f, 0.20204166f, 
    0.06704413f, -0.05273544f, -0.05641437f, -0.11068939f, 0.25741553f, -0.11434038f, 0.08892804f, 0.05640467f, 
    0.14587951f, 0.09463704f, 0.23559423f, 0.47433239f, 0.04999467f, 0.24043100f, 0.36780608f, -0.03110213f, 
    0.16160959f, 0.10516246f, 0.15273687f, 0.09246290f, -0.33748099f, 0.39279658f, 0.15391557f, 0.16127260f, 
    0.01620299f, -0.05190966f, -0.17402597f, 0.02063951f, 0.20421897f, -0.12940128f, -0.25221571f, -0.68737096f, 
    0.05779838f, -0.03221061f, 0.10137587f, -0.05495954f, -0.04549751f, 0.03855507f, 0.03449339f, -0.25048000f, 
    -0.31165853f, 0.02042504f, 0.13942629f, 0.30207875f, -0.09928409f, -0.23725212f, 0.10062341f, -0.64114696f, 
    -0.27100763f, -0.38538548f, 0.18968712f, 0.14093783f, -0.09549727f, 0.25462687f, -0.12430761f, -0.05128575f, 
    0.01910544f, 0.27703941f, 0.27928534f, 0.17121677f, 0.01850861f, 0.09729632f, -0.28065938f, -0.31485599f, 
    0.14193669f, 0.43433726f, 0.36424837f, -0.38869861f, 0.12035140f, -0.14722954f, -0.07606943f, 0.32808688f, 
    0.13204224f, -0.06034200f, -0.08184330f, 0.05205133f, 0.01926554f, -0.07533735f, -0.00462619f, -0.07652432f, 
    -0.00754906f, 0.18406127f, 0.01836080f, 0.17578872f, 0.39586455f, 0.46625519f, -0.15704750f, -0.27258107f, 
    -0.29094085f, 0.20452866f, 0.13019489f, 0.10391857f, 0.04801013f, -0.78991210f, -0.23358932f, 0.13454348f, 
    -0.02291373f, -0.07699579f, 0.07975969f, -0.11410086f, -0.00366829f, -0.31514838f, -0.03404042f, -0.20420274f, 
    -0.05556492f, 0.14493610f, 0.12226735f, 0.18134946f, 0.26118961f, -0.10760503f, -0.10121477f, 0.03048224f, 
    -0.14694303f, 0.16242380f, 0.02168834f, 0.03004394f, 0.06651402f, -0.05942054f, -0.06885891f, 1.01690555f, 
    -0.36388430f, -0.55928928f, 0.03619423f, -0.19607642f, -0.08147647f, 0.06808489f, -0.04695309f, -0.02292221f, 
    0.24322429f, 0.12520802f, 0.32108766f, -0.07422395f, -0.09930536f, 0.04008558f, 0.20835556f, -0.01121612f, 
    0.04394923f, -0.09687443f, -0.33944476f, -0.18619449f, -0.11909528f, -0.00681142f, -0.04395498f, 0.09964059f, 
    0.15000580f, 0.29994482f, 0.10088692f, 0.33588475f, 0.27461883f, -0.25157663f, -0.39064479f, -0.30220896f, 
    0.21034954f, 0.10012331f, 0.00584735f, 0.41699773f, 0.35852998f, 0.12860256f, -0.03680767f, -0.05184611f, 
    -0.15250130f, 0.02090383f, -0.17824022f, -0.26389980f, -0.38974661f, -0.36150894f, 0.24950193f, 0.15994388f, 
    0.02218577f, 0.03460452f, 0.03012137f, 0.01910667f, 0.09907905f, 0.18091488f, 0.42582172f, 0.08599415f, 
    -0.14658950f, 0.06157451f, 0.14319384f, 0.11959860f, 0.13972478f, -0.11496002f, 0.47125760f, -0.12877029f, 
    -0.08073656f, 0.13237110f, 0.19963266f, 0.05915568f, 0.07427571f, -0.03633598f, 0.05208890f, -0.42825928f, 
    -0.36545101f, -0.13078508f, 0.20488061f, 0.01103324f, -0.02743920f, 0.06666153f, 0.03970722f, -0.07942878f, 
    -0.50264674f, -0.08451586f, 0.00359305f, 0.08787284f, -0.20387520f, 0.08821329f, 0.00094260f, -0.10936186f, 
    -0.02081369f, 0.47436196f, 0.19675981f, 0.19855866f, -0.08498678f, -0.06245942f, -0.00023195f, -0.06207558f, 
    -0.24746826f, -0.20797686f, -0.00308514f, -0.06941658f, -0.12788531f, 0.21421155f, -0.31138486f, 0.06361267f, 
    0.05449612f, 0.04347406f, -0.19804515f, 0.03433941f, 0.45567822f, 0.19330901f, -0.25094247f, -0.23054858f, 
    -0.28559265f, -0.04234932f, -0.02135557f, -0.00846026f, 0.32209897f, 0.36432931f, 0.07489859f, -0.18947686f, 
    -0.05525729f, 0.30173644f, -0.03522393f, 0.02104625f, -0.04955088f, -0.23327343f, -0.41343573f, -0.61548954f, 
    0.17012465f, -0.01103622f, 0.05403780f, 0.04622851f, 0.17955914f, -0.10795236f, -0.42216143f, -0.00861670f, 
    0.05478416f, -0.17066942f, 0.25892398f, -0.09431472f, 0.17390217f, 0.34619385f, -0.13654308f, -0.80448633f, 
    -0.28543213f, 0.73574048f, -0.03863026f, -0.02800541f, -0.15139209f, -0.17550950f, 0.20416236f, -0.04013868f, 
    0.12336086f, -0.01345473f, -0.49413788f, 0.01608454f, -0.02290706f, -0.08614331f, -0.04227532f, -0.19505967f, 
    0.03989709f, -0.07949532f, -0.10009021f, 0.40166479f, -0.07824485f, -0.03374564f, -0.14728263f, 0.19286132f, 
    0.23046702f, 0.31848538f, -0.27559236f, -0.18030895f, -0.69813251f, -0.07851780f, -0.10938905f, -0.13645120f, 
    0.04275196f, -0.01579920f, 0.06659451f, 0.34183574f, -0.33663604f, 0.05907810f, 0.19543210f, 0.28371614f, 
    0.29044461f, 0.00402770f, 0.09821349f, 0.16957855f, 0.41031858f, 0.36494023f, 0.24289082f, -0.18458402f, 
    -0.04885808f, -0.35034350f, -0.13067354f, 0.07833211f, 0.04910750f, -0.35867369f, -0.07072879f, -0.45375580f, 
    -0.25823423f, -0.23664854f, 0.26409376f, -0.02412453f, -0.16517507f, -0.12303525f, -0.00962068f, -0.16040675f, 
    -0.53014225f, -0.01656110f, -0.11676174f, -0.05647226f, 0.08534800f, -0.29227999f, 0.11686146f, -0.01372318f, 
    -0.10565199f, 0.64398623f, -0.19019258f, -0.11985222f, -0.09551868f, 0.03653217f, 0.15394200f, 0.13932313f, 
    -0.08483952f, -0.46449912f, -0.07069121f, -0.21486214f, -0.15318486f, -0.32851270f, -0.38317606f, -0.03777910f, 
    0.07710467f, -0.43125060f, -0.11377882f, -0.16366035f, -0.00838269f, 0.01935209f, 0.07537734f, 0.00355981f, 
    -0.06175132f, -0.11372188f, 0.11069144f, -0.06349745f, -0.28802577f, -0.00544647f, 0.03301580f, -0.16248421f, 
    0.09131304f, 0.11231994f, -0.15271668f, -0.04537327f, -0.04773546f, 0.15386085f, -0.42155117f, -0.30081671f, 
    -0.21703789f, 0.12429007f, 0.02756423f, 0.32633939f, -0.15789571f, -0.84209734f, 0.16753027f, -0.06159221f, 
    0.09117900f, 0.03662928f, 0.14535461f, 0.14396648f, -0.03927546f, 0.54226071f, 0.04997317f, 0.39816540f, 
    0.19187818f, 0.22236831f, 0.23247196f, 0.07047624f, 0.47754052f, -0.00094594f, 0.21250054f, 0.16371211f, 
    0.47887868f, -0.03978040f, 0.21320294f, 0.06909195f, 0.17301558f, 0.03382801f, 0.38932267f, 0.30777165f, 
    -0.33915636f, 0.55827522f, 0.26289654f, 0.25756669f, 0.00250551f, 0.25133097f, 0.26619118f, 0.38621297f, 
    -0.38815185f, -0.19276561f, 0.07523697f, 0.02178406f, -0.25035545f, -0.02421582f, -0.08415936f, -0.16898116f, 
    0.26668811f, -0.15478858f, -0.64508873f, -0.10825727f, 0.20595300f, 0.29998845f, -0.01113109f, 0.54267591f, 
    0.16196665f, 0.19293571f, -0.11997002f, -0.06623147f, 0.04624680f, -0.05895726f, -0.22367620f, -0.15777741f, 
    0.02481949f, 0.04831712f, 0.12237875f, -0.09676511f, -0.19069400f, -0.59246254f, 0.21867359f, 0.06132953f, 
    -0.03741871f, -0.03568738f, -0.10293871f, -0.02619361f, 0.21408662f, -0.51648921f, -0.17725593f, -0.28910005f, 
    -0.02074658f, -0.01203054f, 0.00530134f, 0.00759863f, -0.09600110f, -0.31254235f, 0.00343673f, -0.01010160f, 
    -0.17932218f, -0.28496763f, -0.23903911f, 0.22185858f, 0.07610287f, -0.07652377f, -0.16064030f, 0.43682325f, 
    0.60859406f, -0.10927288f, -0.08823080f, -0.04266342f, -0.02657992f, 0.18819685f, 0.16575679f, 0.17944796f, 
    -0.82569027f, -0.18968128f, -0.00275461f, 0.09330882f, -0.02011255f, 0.29148951f, -0.10753083f, -0.12666440f, 
    -0.15628862f, 0.03158521f, 0.05309523f, 0.00023951f, -0.03113144f, -0.02430207f, -0.05800583f, 0.02260905f, 
    0.22810899f, 0.07315025f, -0.33271068f, -0.71334690f, 0.01263097f, 0.07333408f, 0.07723393f, 0.09306184f, 
    -0.06132695f, 0.19157292f, 0.22244607f, -0.02270342f, 0.20305282f, 0.11663419f, -0.04641083f, 0.29365531f, 
    0.17498811f, 0.20311141f, 0.10006582f, -0.52911109f, -0.32688189f, -0.53482431f, -0.09463661f, -0.00451036f, 
    -0.09663762f, 0.03933404f, -0.00738637f, 0.15356721f, -0.44264308f, 0.38760069f, 0.19097485f, -0.07554403f, 
    0.07707237f, -0.07732512f, 0.03749910f, 0.01524944f, 0.13388826f, 0.47245583f, 0.04177156f, -0.25124574f, 
    0.16524792f, 0.05745289f, 0.49417520f, 0.23414707f, 0.06005790f, 0.18572702f, 0.25692815f, -0.18993776f, 
    0.02427488f, 0.11036772f, 0.05331681f, 0.15749186f, 0.21375108f, 0.24296102f, 0.14371264f, -0.45212665f, 
    -0.13466740f, -0.25189477f, -0.16501790f, 0.20090939f, 0.12080607f, 0.22286549f, 0.25071889f, 0.18325381f, 
    -0.48749894f, -0.11113702f, -0.26056328f, -0.07690527f, -0.45475131f, 0.00624913f, -0.07611255f, -0.25263920f, 
    -0.08817475f, 0.55014127f, 0.68155515f, -0.07199819f, 0.20683339f, 0.12039970f, 0.18549104f, -0.22829762f, 
    0.19203351f, 0.18853000f, 0.44793427f, 0.00222740f, 0.18164651f, -0.55361116f, -0.51770550f, -0.73604262f, 
    0.03366122f, -0.11847743f, -0.01717734f, -0.15972506f, 0.58739614f, -0.10853539f, -0.20096858f, 0.18946338f, 
    -0.15800768f, 0.00927082f, -0.09591042f, -0.03180784f, 0.02962829f, 0.06031543f, 0.13059522f, -0.01769866f, 
    -0.05618715f, 0.10829952f, 0.16994254f, 0.17395940f, 0.01452592f, -0.33569106f, -0.02729000f, -0.51638138f, 
    -0.19989152f, 0.01382631f, -0.05509889f, 0.10264453f, -0.14109312f, -0.19431591f, -0.19585188f, -0.74144679f, 
    -0.95803267f, -0.32155475f, -0.04902811f, -0.08600207f, -0.03251342f, -0.03952147f, -0.06949062f, 0.53802258f, 
    0.41012138f, -0.07999396f, -0.11239689f, 0.10876749f, 0.23022987f, 0.06633292f, 0.28602824f, -0.01914103f, 
    0.26421708f, 0.16584045f, 0.19031610f, 0.18948439f, 0.22458705f, 0.04180194f, 0.15984862f, 0.17073064f, 
    0.16763498f, -0.46353677f, 0.42546469f, -0.45435145f, -0.01640014f, 0.12792374f, 0.17877966f, 0.16924021f, 
    -0.01829834f, 0.00191733f, 0.23710251f, -0.07878507f, 0.05607880f, -0.38015896f, -0.13245186f, -0.67942941f, 
    -0.17982130f, 0.08217448f, 0.05592289f, -0.27704680f, 0.46074411f, 0.94134074f, -0.03436728f, -0.17600946f, 
    -0.01930159f, 0.01398956f, 0.23226395f, 0.14153232f, -0.01364419f, -0.53221476f, -0.01453019f, -0.22706127f, 
    0.05038434f, 0.14649445f, 0.22360128f, 0.12655334f, 0.05675605f, -0.04532190f, 0.06370074f, 0.12930471f, 
    -0.13563536f, 0.27600390f, 0.02491099f, 0.09639148f, 0.01678341f, -0.09539063f, 0.00987843f, -0.00883854f, 
    0.13254631f, 0.06579763f, 0.13768026f, -0.26019192f, 0.04225259f, 0.20781982f, -0.07462841f, 0.11611582f, 
    -0.08064170f, 0.44246057f, -0.12499118f, 0.23876689f, -0.34095845f, 0.03280809f, 0.21380958f, 0.12948939f, 
    0.68322462f, 0.02969383f, 0.04767774f, -0.12803984f, -0.07508484f, 0.04657914f, -0.07802624f, 0.31157038f, 
    0.32188407f, 0.07027810f, 0.35323751f, 0.34786138f, -0.10678744f, -0.13108510f, -0.27500415f, 0.35562161f, 
    0.01720954f, 0.13451429f, 0.09707072f, 0.08083358f, -0.13148335f, -0.67574412f, -0.79930526f, -0.38239837f, 
    0.00570986f, 0.17456126f, 0.11071136f, -0.42213771f, -0.01354460f, 0.27769214f, -0.13974315f, -0.00818061f, 
    0.02617120f, -0.01545704f, 0.05916729f, 0.10926685f, -0.13879655f, -0.04978815f, 0.03386715f, 0.06901813f, 
    0.08338323f, -0.08264121f, -0.27094990f, -0.10965367f, -0.08154758f, -0.02654939f, -0.84602249f, -0.43694139f, 
    -0.10659658f, 0.06448410f, 0.06844962f, -0.09946796f, 0.08779383f, -0.22361991f, 0.15779138f, -0.00870638f, 
    0.09254607f, 0.12100346f, 0.15611553f, 0.16290238f, 0.04350297f, 0.17769262f, -0.03523959f, 0.06375513f, 
    0.16509974f, 0.31546438f, -0.01050080f, -0.03319817f, -0.02624284f, -0.15572134f, 0.26019916f, 0.00628593f, 
    -0.11066378f, 0.08132929f, 0.01534643f, -0.01254190f, -0.05907236f, -0.16709204f, 0.03316172f, 0.21779379f, 
    0.41775256f, -0.28170088f, -0.11341093f, 0.36858001f, -0.00335875f, -0.09072796f, -0.22205427f, -0.03926180f, 
    0.03830579f, -0.19636551f, -0.05161944f, 0.02071194f, -0.02773488f, -0.17343983f, 0.14778119f, -0.06796782f, 
    0.05823155f, 0.29250956f, -0.00186110f, 0.05326721f, 0.03113692f, 0.14147353f, -0.18738464f, -0.14762987f, 
    -0.25275639f, 0.12604487f, 0.00962298f, -0.16740187f, 0.29750997f, 0.21409640f, 0.22213788f, 0.35932615f, 
    -0.29490092f, 0.10608229f, 0.08936349f, -0.03756307f, 0.01519102f, 0.09300351f, 0.22234045f, 0.15621971f, 
    0.07923727f, 0.04787756f, -0.08947147f, 0.04511997f, 0.32194310f, -0.10334363f, -0.07959231f, 0.05904020f, 
    -0.03092262f, 0.01318170f, -0.13685459f, -0.11180478f, -0.11402567f, -0.10420514f, 0.00037532f, 0.63645059f, 
    0.45500138f, -0.26975095f, -0.17998151f, 0.10110949f, -0.10048239f, 0.16162886f, 0.01505507f, 0.10743607f, 
    0.43034562f, 0.48367867f, -0.28820410f, -0.11170974f, 0.10955875f, 0.15511203f, -0.14872782f, 0.00687621f, 
    -0.20285662f, -0.17425671f, 0.26223844f, 0.29428393f, -0.17387272f, -0.12448623f, 0.08028834f, 0.12035126f, 
    -0.08918923f, 0.02475769f, -0.54010648f, -1.00389159f, -0.05430540f, 0.06023935f, -0.11195327f, -0.25768599f, 
    0.04620589f, 0.14642605f, -0.19576587f, 0.07639235f, -0.01907259f, -0.14493112f, 0.07731156f, -0.17527509f, 
    -0.03698260f, -0.08268137f, 0.02313626f, 0.14472057f, 0.02557841f, -0.38722792f, -0.16247861f, -0.18102513f, 
    0.05384615f, 0.27534544f, -0.08060744f, 0.18284239f, 0.12276001f, 0.42198133f, 0.30307841f, -0.24338056f, 
    0.29517838f, 0.10465956f, 0.02814237f, -0.00542942f, 0.02918110f, -0.23744984f, 0.47262621f, 0.24239151f, 
    -0.05363284f, 0.09112591f, -0.02163338f, 0.02446105f, -0.02890215f, 0.00994390f, 0.09973895f, -0.27268896f, 
    -0.03884510f, -0.02293775f, -0.27176651f, -0.11449908f, -0.13277742f, -0.01233790f, 0.45948106f, 0.04297782f, 
    0.16748011f, -0.32597998f, 0.16185182f, -0.24691202f, 0.17255612f, -0.00483562f, -0.10791837f, -0.08182418f, 
    -0.03952371f, 0.11750092f, 0.06189946f, -0.32731995f, -0.34194157f, 0.02322965f, 0.04520080f, 0.20759778f, 
    -0.19873087f, 0.02155023f, -0.36626580f, -0.33800077f, -0.79098892f, 0.06742787f, -0.01244129f, -0.01230979f, 
    -0.05380860f, -0.21648151f, -0.10914825f, 0.10759494f, 0.24978694f, 0.00882607f, -0.27249947f, -0.43325785f, 
    -0.10255918f, 0.09665393f, -0.15346201f, 0.13466245f, -0.59885019f, -0.02560358f, 0.00329447f, 0.28735998f, 
    -0.02533736f, 0.19802725f, -0.12281418f, 0.15596759f, 0.24829105f, 0.04436800f, 0.15883519f, 0.25606942f, 
    -0.33595663f, -0.17773768f, 0.00486641f, 0.12665327f, 0.11060968f, 0.08913028f, 0.03200610f, -0.19542333f, 
    -0.10549948f, 0.27875474f, 0.09505568f, -0.29655060f, 0.32299200f, 0.07288527f, 0.14224787f, 0.22536521f, 
    0.20402278f, -0.00982072f, 0.01254199f, -0.43257812f, 0.17716613f, 0.11170490f, 0.20155798f, -0.02974325f, 
    -0.42215788f, 0.02109910f, 0.05918569f, -0.14894408f, 0.17495413f, 0.18192331f, -0.01160230f, 0.07936247f, 
    0.38273442f, 0.04143003f, -0.01576403f, -0.25728863f, 0.04634350f, -0.11359234f, 0.08358371f, -0.38708854f, 
    0.10635549f, -0.25433287f, -0.01579529f, -0.20028593f, -0.19945303f, -0.02175623f, 0.11394120f, 0.14870985f, 
    0.21876810f, 0.05104533f, 0.03644671f, 0.26952493f, -0.19343974f, 0.04636735f, 0.30003825f, -0.10406799f, 
    -0.19560611f, 0.22795285f, -0.14766245f, 0.11674505f, 0.41567042f, 0.49049544f, 0.16731259f, -0.09370876f, 
    -0.44591668f, -0.16083734f, 0.05600389f, -0.11091907f, -0.02498826f, -0.13553746f, 0.04323360f, -0.02261588f, 
    0.10100095f, -0.27114847f, -0.04333410f, -0.05165750f, 0.18481506f, 0.15179169f, 0.10646266f, 0.15452369f, 
    0.11992146f, -0.12763777f, 0.03019158f, 0.17504078f, 0.00136713f, 0.19313937f, 0.21425365f, 0.55200446f, 
    0.10634939f, 0.17784573f, -0.00681916f, 0.05875299f, 0.22578561f, -0.35606626f, -0.01558867f, -0.66481727f, 
    0.60298133f, 0.41070536f, 0.14742473f, 0.04193429f, 0.01005690f, -0.09545564f, 0.06855378f, 0.07037903f, 
    0.01636654f, 0.25318140f, 0.53664654f, 0.63169509f, -0.11290366f, 0.00469154f, -0.14231534f, 0.19236071f, 
    0.14521658f, 0.13596347f, 0.30918911f, -0.14860758f, -0.26182443f, 0.19239943f, 0.03806601f, -0.03114978f, 
    0.01807445f, -0.00371732f, 0.11703312f, 0.24608840f, 0.22650672f, 0.16669776f, 0.22021911f, 0.01608334f, 
    0.06960528f, 0.07955199f, -0.09368770f, 0.02417205f, 0.24991904f, -0.10101242f, 0.04685998f, -0.05077232f, 
    -0.15060037f, 0.07226477f, -0.27751824f, -0.35949785f, -0.15543027f, 0.28392020f, 0.15747093f, 0.07315475f, 
    0.18308654f, 0.02807837f, -0.12618884f, -0.02101704f, -0.15538760f, -0.05257650f, 0.27212691f, 0.23413320f, 
    0.10753595f, 0.07625255f, 0.11500117f, 0.19228002f, -0.07785170f, -0.25636464f, -0.57129729f, -0.21755697f, 
    0.01865820f, -0.21882980f, 0.18273659f, 0.08821494f, 0.14356661f, 0.06135916f, -0.27259976f, -0.33656615f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.40040159f, 0.09730893f, 0.22537874f, 0.06312159f, 0.05991260f, 0.34514466f, 0.55777055f, -0.11102185f, 
    0.13439098f, 0.08052642f, 0.19305743f, 0.59679854f, 0.11391887f, 0.06641104f, 0.01101506f, 0.09928539f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51468557f, -0.05825740f, 0.31958199f, -0.27424768f, 0.02411200f, 0.00963599f, -1.37786603f, 0.88399559f, 
    -0.21029040f, 0.70074809f, -0.49740639f, -0.18491133f, 0.17046946f, -0.17405136f, 0.17950936f, 0.01932968f, 
    0.47151154f, 0.22091457f, 0.47276324f, -0.41725284f, 0.42648703f, 0.24225706f, 0.25885010f, 0.19117114f, 
    -0.66259927f, -0.04729437f, -0.03415271f, 0.06603108f, 0.23068011f, -0.62993383f, 0.44050914f, -0.19626452f, 
    -0.65242058f, 0.20305325f, -0.52533585f, -0.30496651f, -0.74860132f, 0.11361888f, 1.52487540f, -0.06499081f, 
    -0.17789361f, 0.20994614f, -0.68283403f, 0.40088600f, -0.03297644f, 0.09970773f, -0.91911632f, -0.07416612f, 
    -1.33956504f, -0.45575243f, 0.46740410f, 0.42950216f, -0.65751022f, -0.00550649f, -0.03357577f, 0.17606673f, 
    0.51301259f, -0.37997329f, -0.04595929f, -0.72922152f, 0.10243218f, 0.58929288f, 0.58026367f, -0.03141006f, 
    -0.17506494f, -0.20683914f, 0.07823494f, 0.58461362f, 0.66050905f, 0.23307566f, -0.46721923f, -0.47987995f, 
    -0.03420328f, 0.24256267f, -0.39880675f, -0.40129593f, -0.01645916f, -0.13563563f, -0.56154656f, 0.34311157f, 
    -0.48606780f, 0.39710641f, 0.23731951f, -0.30140221f, 0.37780827f, -0.24018596f, -0.00328792f, -0.40664914f, 
    0.25788340f, 0.16026863f, 0.26209426f, 0.03023279f, 0.30224460f, -0.30966890f, 0.15445788f, 0.11729543f, 
    0.51833498f, 0.02292477f, -1.61389744f, -0.61127573f, -1.02690601f, 0.42018011f, -0.08414154f, -0.59231383f, 
    -0.29842368f, -1.00270593f, -0.81054497f, 0.80347413f, -0.79346079f, 0.30796260f, -0.01544372f, 0.32224756f, 
    0.19719175f, -0.14492033f, -0.30838236f, -0.22931974f, 0.13762616f, -0.63049668f, -0.28099370f, 0.08238329f, 
    0.19535287f, -0.40831235f, -0.07047867f, -0.15477237f, 0.72754967f, 0.57057351f, 0.32265505f, -0.17495896f, 
    0.53470546f, 0.55743885f, -0.00476299f, -0.09773135f, -0.51868135f, -0.40675169f, 0.10415335f, 0.21405022f, 
    1.45791578f, -0.23783465f, 0.28498134f, 0.03986309f, -0.50630641f, -0.32594091f, -0.40584451f, -0.50429612f, 
    -0.24601106f, -0.70580530f, 0.28522024f, 0.39937842f, -0.21549933f, 0.07341555f, -0.30157074f, -0.16986178f, 
    -0.22082485f, -0.28059214f, -0.36935228f, 0.43713349f, -0.25943729f, 0.28865752f, -0.83016002f, 0.51806951f, 
    -0.65002412f, 0.84345901f, -0.98372579f, 0.00182675f, 0.77480835f, -0.16229752f, -0.14496900f, 0.43604279f, 
    -1.10211563f, 0.00378027f, 0.29550955f, 0.08928390f, -0.70688027f, 0.54841477f, -0.65621400f, -0.57564712f, 
    0.11948136f, 0.07809467f, -0.90145940f, -0.20680757f, -0.30389932f, 0.11984377f, 0.24170533f, -0.29268834f, 
    -0.57642990f, -0.61667895f, 1.10575104f, -0.53036159f, -0.66266930f, -0.20907323f, 0.18457416f, 0.34157133f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.72095782f, -0.17494626f, 0.23942341f, 0.15903993f, -0.06063004f, -0.05652491f, -0.26459584f, -0.31475607f, 
    -0.12189891f, 0.48997200f, -0.15999700f, 0.26246458f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
