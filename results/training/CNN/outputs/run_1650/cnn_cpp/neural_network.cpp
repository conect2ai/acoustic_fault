#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.38802257f, -0.76797235f, -0.45855656f, -0.24761866f, -0.32565910f, 0.07672445f, 0.30524921f, 0.76267308f, 
    0.31181186f, 0.52143425f, 0.05224141f, 0.23839730f, 0.16571341f, 0.23980266f, 0.07652783f, -0.12672457f, 
    -0.17219132f, 0.22697307f, -0.37230930f, 0.20312785f, -0.00881831f, -0.15760887f, -0.07930726f, 0.11459260f, 
    0.02594541f, -0.51661253f, 0.70673960f, 0.09052274f, 0.18269475f, 0.04339534f, -0.77765417f, -0.46737283f, 
    0.54842025f, 0.45826781f, -0.22847788f, 0.22323917f, -0.01286671f, 0.43556300f, -0.43752226f, -0.20062695f, 
    0.26675692f, -0.08298511f, 0.10799123f, -0.24958608f, -0.10641845f, -0.00236764f, 0.12195081f, -0.13697740f, 
    0.32921720f, 0.01588421f, 0.65699148f, 0.10177471f, 0.58373755f, 0.42710918f, 0.47639585f, 0.62183774f, 
    0.35132718f, -0.01589802f, -0.19079413f, 0.07011877f, -0.02204559f, 0.28102523f, 0.28592473f, 0.02579116f, 
    -0.11583892f, 0.14420618f, 0.07010592f, -0.17227799f, -0.12940387f, -0.20285311f, 0.12666503f, -0.07984305f, 
    -0.04222994f, -0.17884813f, -0.14554323f, 0.34987402f, -0.15109508f, -0.08340383f, 0.60246992f, 0.09528094f, 
    -0.13822338f, -0.21213722f, -0.38103151f, -0.08043662f, 0.24093381f, 0.68964583f, -0.55567533f, -0.17921408f, 
    0.35621205f, 0.17412685f, 0.08755522f, 0.23874894f, 0.21323769f, -0.43779412f, -0.14598717f, 0.15145621f, 
    0.38844979f, 0.31115374f, 0.37882426f, 0.22115281f, 0.39542568f, 0.32674429f, 0.73752981f, 0.30123127f, 
    0.18915057f, -0.00340288f, -0.11902849f, -0.24959014f, -0.11010813f, 0.35784647f, 0.16592504f, -0.24984302f, 
    -0.00707932f, 0.35526407f, -0.01086276f, -0.17011297f, -0.27733785f, -0.27982190f, -0.08468054f, 0.24013248f, 
    -0.11256183f, 0.07519632f, 0.00674071f, 0.04704043f, 0.35860264f, 0.48778582f, 0.85307747f, -0.09468465f, 
    -0.27438498f, 0.00482529f, -0.55082673f, -0.52796859f, 0.02775429f, -0.47107977f, -1.01555312f, -0.08708276f, 
    0.05896002f, -0.04494778f, -0.04360480f, 0.29115778f, 0.37109020f, 0.33290064f, 0.17395024f, -0.03586920f, 
    0.09471425f, -0.17520432f, -0.14566827f, 0.29488316f, 0.29561985f, 0.25252551f, -1.01451063f, -0.53850603f, 
    -0.44179884f, -0.19381987f, -0.33009303f, 0.83975607f, -0.23256835f, -0.38372350f, 0.11061648f, 0.59535044f, 
    -0.39345789f, -0.32518947f, -0.33772922f, -0.01798540f, -0.37200701f, 0.01176968f, 0.26230368f, 0.04811047f, 
    0.15716304f, -0.12464673f, -0.09528516f, -0.12228210f, -0.16321018f, -0.16118930f, -0.11306723f, -0.34952700f, 
    -0.50695884f, -0.53025109f, -0.46089962f, -0.29871035f, -0.28336298f, -0.32646757f, -0.60456973f, -0.55335355f, 
    -0.51289058f, 0.22503026f, -0.23386016f, -0.17235041f, 0.33102933f, -0.07756212f, 0.08394223f, -0.23190008f, 
    0.09299317f, -0.00658729f, -0.28711703f, -0.21995966f, 0.05921656f, 0.03955084f, 0.27915964f, 0.31434113f, 
    0.57607025f, -1.40006483f, 0.12166806f, -0.07568863f, 0.95787609f, -0.69701427f, -0.28953204f, -0.19883807f, 
    -0.15089570f, -0.30594638f, 0.01703941f, -0.17295019f, 0.21443859f, -0.40450737f, 0.09407350f, -0.16299194f, 
    -0.13540184f, -0.14632078f, 0.10655910f, -0.04391646f, -0.29880759f, -0.28758112f, -0.08922261f, -0.18215084f, 
    0.15576667f, 1.06808877f, 0.37457982f, -0.12489668f, -0.53529370f, -1.00733340f, 0.47075510f, 0.31333539f, 
    -0.11082292f, -0.16229671f, 0.08108306f, 0.03687962f, -0.36327553f, 0.06264754f, 0.13615599f, -0.09278648f, 
    0.24171937f, -0.06642474f, -0.19504239f, 0.23314792f, -0.48839730f, -0.32144219f, -0.12657560f, -0.25501320f, 
    -0.00891883f, -0.27685511f, -0.88316846f, -0.50948560f, 0.04504514f, 0.32161897f, 0.66044432f, 0.18595123f, 
    0.46307468f, -0.31588385f, 0.20183137f, 0.09104335f, 0.12945184f, 0.33132529f, -0.32296062f, 0.43789080f, 
    -0.45957270f, -0.02384835f, -0.32667866f, 0.19185187f, -0.26075196f, 0.17223100f, -0.29477239f, 0.36214459f, 
    0.36426494f, -0.10987245f, 0.06697738f, 0.15052234f, -0.78758687f, 0.10824559f, 0.29478157f, 0.64998364f, 
    0.28385115f, -0.66538459f, -0.22364254f, 0.50637031f, 0.64983928f, -0.07416869f, 0.05754529f, -0.16865316f, 
    0.09507954f, 0.42013282f, -0.22842853f, -0.16499783f, 0.14109892f, -0.11965539f, -0.30136293f, -0.17999500f, 
    -0.17265324f, 0.34815413f, 0.16331060f, -0.16392803f, 0.39470619f, -0.33637071f, -0.20677808f, -0.27045831f, 
    -0.42216727f, -0.43289283f, -0.52268553f, 0.08142364f, -0.16681609f, 0.13487543f, -0.02223096f, 0.27488619f, 
    -0.13197082f, -0.47308448f, 0.23781195f, -0.18112306f, 0.44465420f, 0.09882941f, -0.10560870f, 0.20558703f, 
    -0.15291685f, -0.26321080f, -0.06441197f, -0.36554042f, -0.49914595f, 1.01055396f, -0.86634433f, -0.68791562f, 
    0.38457245f, -0.87120378f, 0.29056704f, 0.83388555f, 0.43595776f, -0.37939876f, -0.27399752f, 0.26681656f, 
    -0.10992049f, -0.11968064f, -0.43324724f, 0.03686718f, 0.08889495f, 0.22028002f, 0.08873183f, -0.22588794f, 
    -0.02513635f, 0.01637676f, -0.08257735f, -0.14497079f, 0.13786896f, -0.08828646f, -0.16553994f, 0.00391880f, 
    0.97870910f, 0.12497094f, -0.76077408f, -0.23577319f, -0.58113420f, -0.48261985f, -0.12074783f, 0.35283074f, 
    0.22418334f, 0.11613682f, -0.13675395f, -0.00598585f, 0.57432705f, 0.25285253f, 0.12790436f, 0.12209911f, 
    -0.09341794f, -0.11650901f, 0.00412555f, -0.02743781f, -0.36746910f, -0.33147267f, -0.31842023f, 0.21928717f, 
    -0.67165053f, -0.78800035f, -0.58854491f, 0.83662200f, 0.25504687f, 0.24445742f, 0.23751962f, -0.21627706f, 
    -0.35089409f, -0.28164500f, 0.12579206f, 0.09086427f, -0.06085006f, 0.26970473f, -0.36164862f, -0.08177984f, 
    -0.15612230f, -0.24635410f, 0.17774479f, 0.35723031f, 0.08771432f, -0.25429147f, 0.01588959f, 0.27368176f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19887210f, 0.26671439f, -0.18438451f, 0.37116924f, 0.24314021f, 0.05431623f, -0.19266495f, 0.01914600f, 
    0.16766907f, 0.30833003f, 0.18503374f, 0.47657225f, -0.04679878f, 0.26414138f, 0.24503717f, 0.14698593f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26473147f, 0.32983267f, 0.09702574f, 0.11804941f, 0.15356949f, -0.10947495f, -0.14388640f, -0.07142279f, 
    0.12573047f, 0.11860193f, 0.07070801f, -0.02506982f, 0.07475483f, -0.05145838f, -0.39785329f, 0.11702108f, 
    -0.04145894f, -0.06908945f, -0.09726958f, 0.02043983f, -0.08080582f, 0.02829007f, -0.10082497f, -0.21128803f, 
    -0.16154858f, -0.09782461f, -0.01209680f, -0.17986734f, 0.09419441f, 0.05483546f, -0.06770566f, -0.02986378f, 
    0.07140579f, 0.18479107f, 0.02280719f, 0.20351666f, 0.17033441f, -0.51041955f, -0.03497677f, -0.13054299f, 
    0.01819096f, 0.08239044f, -0.12037856f, 0.08380887f, -0.08995333f, -0.15957755f, -0.39605358f, -0.42285791f, 
    -0.00672493f, -0.08554121f, 0.07537296f, -0.21164526f, 0.04826494f, 0.17749840f, -0.07562946f, -0.25978312f, 
    -0.26458099f, -0.18731387f, -0.04280468f, -0.18953878f, -0.16900527f, 0.20686546f, 0.30167523f, 0.26343474f, 
    0.08808361f, -0.15702644f, 0.21220432f, 0.27448443f, -0.10094691f, -0.12045092f, -0.16570778f, -0.30330589f, 
    0.16547440f, -0.29168251f, 0.03651195f, 0.07049975f, -0.01012633f, 0.09299129f, 0.02873682f, 0.07661832f, 
    0.15671735f, 0.15733592f, -0.02617191f, 0.34672454f, -0.22275138f, -0.11466502f, -0.09440135f, 0.26528680f, 
    -0.06225147f, -0.06009618f, 0.02374844f, 0.18998766f, 0.11015053f, 0.02999843f, 0.06573545f, -0.08498480f, 
    -0.14833525f, 0.11306758f, -0.01496140f, 0.23063587f, 0.04448622f, -0.04252505f, 0.15221378f, 0.08703844f, 
    0.15574773f, 0.04969265f, -0.03709861f, -0.01329878f, -0.07820855f, 0.20850436f, 0.02313737f, 0.28510368f, 
    -0.05858407f, -0.02586231f, 0.21486133f, 0.28777999f, 0.05498108f, 0.19818529f, 0.11960731f, 0.13705716f, 
    0.18381096f, 0.15734440f, -0.03475313f, -0.15798417f, -0.10122521f, 0.00298939f, -0.37010655f, -0.05300516f, 
    0.00142915f, 0.03445875f, 0.04911659f, -0.20743895f, 0.03484845f, -0.20020112f, -0.06547040f, -0.40120068f, 
    -0.21485572f, 0.07719284f, -0.21623518f, -0.23657662f, -0.05794543f, 0.14542322f, 0.00996610f, -0.01729396f, 
    -0.14890130f, -0.15703459f, -0.05182951f, 0.11028564f, 0.08631262f, 0.08113277f, 0.16691202f, 0.07318646f, 
    0.10224777f, -0.01688053f, 0.04823154f, 0.11703242f, -0.42735749f, 0.16078576f, 0.44337311f, 0.05861485f, 
    0.13837887f, 0.07278036f, 0.08980117f, 0.11190026f, -0.02762377f, -0.08299675f, 0.06116066f, -0.08234262f, 
    0.11436342f, 0.02772696f, 0.04140502f, 0.46609655f, -0.03617472f, 0.21782683f, 0.12633866f, 0.00723876f, 
    0.14685443f, 0.14710659f, -0.05907987f, 0.19849944f, -0.09399754f, 0.21433760f, 0.29811090f, -0.08082740f, 
    0.04000206f, 0.02562177f, 0.09810462f, 0.04750036f, 0.15047351f, -0.12761559f, -0.04340233f, -0.20495960f, 
    0.08882747f, 0.05298160f, 0.22006665f, 0.14612025f, -0.18526734f, -0.22547463f, -0.16971412f, -0.30629191f, 
    0.18561751f, 0.05943093f, -0.05832411f, 0.08953393f, -0.22013351f, 0.00415040f, 0.31557453f, -0.03518993f, 
    -0.26296017f, -0.00113834f, -0.03702565f, -0.04617429f, -0.00196046f, -0.14965069f, 0.06211445f, -0.28534815f, 
    -0.33061776f, -0.51035845f, -0.08249433f, 0.17820278f, 0.39451325f, -0.01599118f, -0.17442587f, -0.13851541f, 
    0.06079322f, -0.00993169f, -0.00883852f, 0.34807709f, -0.22919753f, -0.29178795f, 0.16987894f, -0.37062052f, 
    0.28543103f, 0.07067452f, -0.14193162f, -0.03329161f, -0.35681507f, -0.07444558f, -0.36780259f, -0.61740643f, 
    -0.29451519f, -0.55767053f, -0.10359264f, 0.32833391f, 0.25266165f, 0.19219485f, -0.00109672f, 0.05964820f, 
    -0.40058154f, -0.35442188f, -0.06367002f, -0.22657228f, 0.16847786f, 0.20601471f, -0.28154036f, 0.03194579f, 
    0.03686886f, 0.02543803f, -0.00504871f, 0.37001985f, 0.01686913f, -0.10590611f, -0.15556902f, -0.61021692f, 
    0.39714915f, 0.18680060f, 0.04261833f, -0.05631939f, -0.09642757f, 0.13753720f, 0.18234158f, -0.02779821f, 
    0.16964628f, 0.11021592f, 0.18787119f, 0.20502105f, 0.40359491f, 0.27379507f, 0.04064930f, -0.03337514f, 
    0.05161057f, 0.07316950f, 0.00951093f, -0.02633743f, -0.07356841f, -0.02060115f, 0.10530217f, -0.06935316f, 
    0.37975723f, 0.01087632f, 0.26693568f, -0.24769311f, -0.01368138f, -0.04031834f, -0.00119431f, 0.02433056f, 
    -0.02424222f, 0.00851770f, 0.04971940f, 0.02171965f, -0.39795324f, -0.04445964f, -0.13008453f, 0.17172225f, 
    -0.06712101f, 0.05916841f, -0.14533119f, -0.11755588f, -0.06385165f, 0.17955376f, 0.17975436f, 0.37484410f, 
    0.37678456f, 0.16390692f, 0.04561149f, -0.04665834f, -0.13022059f, 0.02017623f, -0.02053989f, -0.15322173f, 
    0.14423853f, -0.08350918f, -0.11119997f, -0.21405450f, -0.08543774f, 0.04266876f, 0.24887578f, -0.18857829f, 
    -0.10595043f, -0.06655248f, -0.09020045f, -0.42197400f, 0.05813511f, -0.28405893f, -0.06007178f, 0.28044176f, 
    0.31328475f, 0.13609923f, 0.12195344f, -0.02856415f, -0.03782327f, 0.02619184f, -0.01619189f, 0.09495439f, 
    0.18040860f, 0.02576138f, 0.22033872f, 0.23757683f, 0.08295607f, -0.31006223f, -0.43367431f, -0.12063108f, 
    0.21706681f, -0.01767419f, 0.06803074f, 0.14899112f, 0.04439924f, 0.02743478f, -0.05289045f, 0.03296768f, 
    0.22606201f, 0.18846484f, -0.23751117f, -0.00090380f, 0.09124824f, 0.06399922f, -0.04044192f, 0.05229408f, 
    0.15292670f, 0.07874086f, 0.23254743f, 0.39296564f, 0.39402288f, -0.20546336f, -0.30432463f, -0.13018017f, 
    -0.02698990f, 0.02276743f, 0.08444323f, -0.06670531f, 0.08900784f, -0.24009398f, -0.20675614f, -0.33020553f, 
    0.38532534f, 0.28244835f, 0.14658196f, 0.07023469f, -0.06292085f, -0.25735065f, -0.06126828f, -0.21473362f, 
    -0.01632461f, -0.02131225f, 0.10303457f, 0.15579230f, -0.73958170f, 0.14543644f, -0.01641853f, 0.08371035f, 
    0.30139610f, -0.00449992f, 0.00497457f, -0.12372430f, 0.08475662f, 0.03888968f, -0.19153662f, -0.04686811f, 
    0.09814269f, 0.12182198f, 0.09956378f, 0.01739025f, -0.01725798f, 0.06538478f, -0.01414403f, -0.03557641f, 
    0.01196324f, 0.04889629f, 0.13631475f, 0.15601173f, -0.04448595f, 0.01097524f, -0.04039128f, 0.03042629f, 
    0.13717847f, 0.14731428f, -0.04839874f, 0.18567759f, 0.00947989f, -0.18026489f, -0.00974145f, -0.15315561f, 
    0.28400660f, 0.01532277f, 0.08260148f, 0.06759410f, -0.09756322f, 0.09567234f, 0.00592052f, 0.00800274f, 
    0.02288824f, -0.03497202f, 0.00839634f, 0.02923959f, 0.32197845f, -0.02366574f, -0.09509244f, -0.22645193f, 
    -0.04313068f, -0.20084769f, -0.02327473f, 0.01416525f, -0.24386415f, 0.02417426f, -0.11493207f, -0.01461173f, 
    0.41492644f, 0.11048245f, 0.00879053f, 0.01521686f, -0.04735641f, -0.10577731f, 0.04031721f, -0.02255391f, 
    0.38518369f, -0.00211163f, 0.15796693f, 0.19443567f, 0.05688553f, -0.07386830f, 0.00371036f, -0.15058598f, 
    -0.01564161f, -0.15707548f, 0.04061975f, 0.26793417f, 0.02959912f, 0.03950186f, 0.13501889f, -0.17394564f, 
    -0.15534113f, -0.39599895f, -0.18465914f, -0.20114952f, 0.15107416f, 0.04390649f, 0.03584329f, -0.14738201f, 
    0.13677415f, 0.05748594f, 0.06912947f, -0.18713567f, -0.01275487f, -0.10778186f, 0.44379959f, -0.47856691f, 
    -0.09170515f, 0.04412462f, 0.09948839f, 0.21203636f, 0.01632966f, 0.17977659f, 0.21872512f, 0.22722162f, 
    -0.19320704f, -0.15516989f, -0.20698400f, 0.43400991f, 0.41134977f, 0.07369597f, -0.22640175f, -0.01722338f, 
    -0.05275634f, -0.22921665f, -0.09007519f, 0.01631760f, 0.23010059f, 0.18106858f, 0.23163289f, 0.18798719f, 
    0.13558747f, -0.01006585f, -0.02121287f, -0.31725422f, -0.01403266f, 0.05927322f, 0.10042007f, -0.11118001f, 
    -0.13204454f, 0.19240129f, 0.21556810f, -0.30108145f, 0.02791965f, -0.22393253f, -0.00543103f, 0.08187387f, 
    0.06445459f, 0.25078917f, -0.15986197f, 0.22265109f, 0.28210998f, -0.14332204f, -0.07700366f, -0.37467560f, 
    -0.07622879f, 0.00414939f, -0.03390810f, 0.24722663f, -0.02761297f, -0.12435860f, 0.06390020f, -0.01111354f, 
    -0.03274253f, 0.33570451f, 0.05341053f, -0.37877694f, -0.01992532f, 0.07758242f, 0.06240450f, 0.02931349f, 
    0.18638875f, 0.14695385f, 0.08487266f, 0.00573238f, -0.10678457f, -0.18994765f, -0.09287294f, -0.10935416f, 
    0.12305363f, -0.15877223f, 0.07585508f, 0.13355407f, -0.05859873f, -0.14316425f, -0.15474384f, 0.06570087f, 
    0.02841428f, 0.11610841f, 0.15322830f, -0.06828819f, -0.09399227f, -0.21077526f, -0.19860624f, 0.17588298f, 
    -0.04002967f, -0.07185383f, 0.07822040f, 0.06973233f, 0.10899472f, 0.07497131f, -0.21814704f, 0.23244561f, 
    0.04467158f, 0.31672299f, 0.08417317f, 0.02730991f, 0.06308885f, -0.10627245f, 0.00783898f, -0.01848478f, 
    -0.17958736f, -0.14348975f, -0.20396781f, -0.39447150f, 0.01605861f, -0.13344602f, -0.20837490f, -0.00557182f, 
    0.26758051f, 0.09526946f, 0.03923557f, 0.05507593f, 0.25733408f, -0.17190839f, -0.08288971f, 0.08942620f, 
    0.24060580f, 0.00322383f, 0.07757973f, 0.05068918f, 0.15768963f, -0.11181869f, -0.13172728f, -0.09677473f, 
    -0.23960304f, 0.08991990f, 0.05552019f, 0.01683449f, -0.01153792f, -0.04144292f, -0.13263540f, -0.03455811f, 
    -0.00543218f, 0.05259260f, -0.21850957f, 0.11320279f, -0.19432905f, 0.31769773f, -0.16190106f, -0.04573306f, 
    0.09200460f, 0.13814332f, 0.12015707f, 0.15028635f, -0.13597316f, -0.12574075f, 0.04605065f, -0.23343287f, 
    -0.40975377f, -0.24252024f, 0.19743416f, 0.19173549f, -0.15763818f, -0.14264289f, -0.08447414f, 0.15377304f, 
    -0.06310831f, -0.09574148f, 0.00369681f, 0.20546433f, -0.20512076f, 0.16736715f, 0.29326546f, 0.02258324f, 
    0.04227266f, -0.06230887f, 0.09533048f, 0.09838952f, 0.03467885f, -0.13313769f, -0.18198699f, 0.03356576f, 
    0.14132178f, -0.08840856f, 0.39577678f, 0.04365238f, 0.06709615f, 0.23302393f, -0.01873064f, 0.18014438f, 
    -0.05076860f, 0.06100687f, -0.15273559f, 0.09583888f, 0.28003696f, 0.39421993f, -0.23207022f, -0.35113746f, 
    0.05554305f, 0.04347221f, 0.07645197f, 0.21425022f, 0.16402422f, -0.09442654f, -0.04559715f, 0.05200377f, 
    -0.20403878f, -0.38493833f, 0.41893625f, 0.25494683f, -0.12145297f, 0.01998761f, -0.19374256f, -0.28832024f, 
    0.21287301f, -0.06126646f, 0.13816573f, 0.04228803f, 0.02070556f, -0.11743475f, 0.03998107f, 0.28876242f, 
    -0.21022186f, 0.03994438f, -0.18397890f, 0.18492337f, 0.16585355f, 0.06614765f, 0.02981768f, 0.14748923f, 
    0.06945638f, -0.03769713f, 0.06752560f, 0.14891283f, 0.04915954f, 0.20426534f, 0.15495569f, 0.01262237f, 
    -0.05392785f, -0.08641299f, 0.22450180f, -0.16943619f, -0.21690729f, 0.14882247f, 0.35594288f, -0.25722814f, 
    0.10249110f, 0.25372198f, -0.05576900f, 0.09811208f, 0.05054244f, -0.02984618f, -0.04661014f, 0.01590261f, 
    0.09090912f, -0.04819868f, -0.12241625f, 0.22047153f, 0.01811177f, 0.06762742f, 0.06987900f, -0.02048394f, 
    0.03737316f, -0.03405452f, -0.06138542f, -0.02019690f, -0.10630878f, -0.17725468f, 0.30542520f, -0.03039122f, 
    0.15376602f, 0.06259483f, -0.08071145f, 0.24468738f, 0.12078707f, 0.08124079f, -0.05255344f, 0.09088228f, 
    0.06719238f, 0.01528128f, -0.06079367f, 0.01995587f, -0.07604599f, -0.04547669f, -0.05697047f, 0.04158304f, 
    -0.00812568f, -0.05021945f, 0.02779153f, -0.04691744f, 0.03606950f, -0.01834493f, 0.05646211f, 0.03568469f, 
    0.02673604f, -0.05091186f, 0.01393036f, 0.01107805f, -0.07367989f, -0.02267009f, -0.04785995f, -0.01768946f, 
    -0.04395524f, -0.04482311f, -0.00630578f, 0.01612067f, -0.04335302f, -0.06016639f, 0.00679607f, -0.05645109f, 
    0.04981127f, -0.06429831f, 0.04380714f, 0.07194984f, -0.03106721f, -0.07778457f, -0.04279053f, 0.00550324f, 
    -0.00478996f, -0.06405202f, -0.03735821f, -0.05206706f, -0.03260035f, 0.04071779f, 0.03385784f, -0.00759266f, 
    0.00303475f, 0.02466069f, -0.06674780f, -0.02632531f, -0.00842494f, 0.06026984f, -0.01580808f, -0.06240830f, 
    0.04703362f, -0.03437265f, -0.01165494f, -0.06743991f, 0.01947887f, -0.05623148f, -0.04386483f, 0.01540734f, 
    0.01474119f, -0.02711948f, 0.05378106f, -0.00771355f, 0.03254693f, -0.00001485f, -0.01700878f, 0.05772021f, 
    0.04174853f, 0.04347935f, -0.02321105f, 0.00178952f, 0.01025651f, -0.01020703f, 0.05935937f, 0.02349031f, 
    -0.06993761f, 0.02938487f, 0.05566858f, 0.05885479f, 0.01523148f, -0.04653049f, -0.00775040f, 0.02479918f, 
    -0.05408475f, -0.00089041f, -0.02760362f, 0.02844208f, 0.05347477f, -0.06893677f, 0.06105601f, -0.04242023f, 
    0.02346933f, -0.03482015f, -0.03240453f, 0.04103448f, 0.01009599f, -0.06642558f, 0.06623136f, 0.04111322f, 
    -0.07162313f, -0.06174410f, -0.00804589f, -0.06213897f, -0.02829668f, 0.02153666f, -0.06007683f, 0.01646172f, 
    -0.01269226f, -0.02139564f, -0.07149278f, -0.05872713f, -0.07445914f, -0.07873698f, 0.01626359f, 0.04056355f, 
    -0.06136500f, 0.03521616f, 0.00792498f, 0.04829700f, -0.04282038f, -0.05831698f, 0.01688450f, 0.01823544f, 
    0.01310531f, 0.02676115f, -0.07012422f, 0.03716847f, -0.07014232f, -0.00689461f, -0.02579067f, -0.06512234f, 
    -0.05888397f, -0.00320939f, 0.02127297f, 0.04402476f, -0.05305628f, 0.04795532f, 0.01895661f, -0.03526865f, 
    0.06185698f, -0.04052510f, -0.01362275f, -0.07133952f, 0.02601614f, 0.03382826f, 0.05042079f, 0.04339880f, 
    -0.07178889f, 0.02233662f, 0.01924264f, 0.05235989f, -0.06193451f, -0.05941633f, -0.07471003f, 0.03439952f, 
    0.02993372f, -0.00995687f, 0.06294683f, -0.02275688f, -0.00719854f, -0.05902864f, -0.00631967f, -0.02166726f, 
    0.01373914f, -0.06811496f, 0.02407111f, -0.01222541f, -0.07434189f, -0.06135507f, -0.02978929f, -0.01859273f, 
    0.01224690f, -0.06632178f, 0.05691652f, 0.02524176f, -0.03977021f, -0.01679695f, -0.07189737f, 0.01318323f, 
    0.02668568f, -0.06843468f, -0.01297067f, -0.02578946f, 0.00727742f, -0.01719018f, -0.06948274f, 0.02550137f, 
    0.17862992f, 0.26924151f, 0.34075144f, -0.02184657f, -0.02752706f, -0.23127940f, -0.10098532f, 0.04549577f, 
    -0.13244128f, -0.00491946f, 0.02495871f, -0.08666881f, -0.68889564f, 0.19113988f, 0.33779168f, 0.06949984f, 
    0.04872822f, 0.02460228f, -0.03836377f, -0.14989175f, 0.03613701f, -0.04553934f, 0.00033838f, -0.04601277f, 
    0.10774923f, -0.15714765f, -0.05214310f, -0.03532404f, 0.16038215f, 0.08132806f, -0.04654825f, -0.09565375f, 
    0.05945664f, 0.03073373f, 0.13568476f, 0.10696839f, -0.17471190f, -0.00336378f, -0.10133687f, -0.01022361f, 
    0.10787977f, 0.09073319f, -0.07329113f, -0.04214257f, -0.11971431f, 0.00601556f, -0.17827107f, -0.20825969f, 
    0.00962466f, -0.24124837f, -0.07171037f, 0.20131259f, 0.03100391f, 0.16874330f, 0.08053355f, -0.06858975f, 
    -0.00619249f, -0.03283625f, -0.16304636f, -0.08342171f, 0.38871756f, -0.01906797f, -0.09826474f, -0.07068427f, 
    0.01733737f, 0.15195227f, 0.17269091f, 0.02446772f, -0.14030673f, 0.10233016f, -0.04488856f, -0.21745065f, 
    0.03968687f, 0.22239053f, -0.02904280f, 0.03877737f, 0.05740441f, 0.04715122f, 0.06917557f, -0.06142421f, 
    0.18487655f, 0.11532514f, 0.06679174f, 0.16073760f, 0.27688366f, 0.29056099f, 0.15167268f, 0.08814609f, 
    -0.07052416f, 0.03968748f, -0.08963511f, 0.16702491f, -0.04583554f, 0.10364273f, 0.04962617f, -0.04210635f, 
    -0.24261227f, -0.01439279f, 0.11509822f, -0.22681853f, 0.06001112f, 0.19447020f, 0.07132819f, 0.08883641f, 
    -0.06815731f, 0.03179204f, -0.00132780f, -0.06827410f, 0.07956001f, 0.00945195f, 0.01231016f, -0.11217141f, 
    -0.12754880f, -0.03431038f, 0.21100152f, 0.15059100f, -0.01208037f, 0.20246291f, 0.05087206f, 0.24371962f, 
    -0.35081574f, 0.17302780f, 0.08770529f, 0.30637014f, 0.23956636f, 0.06187129f, 0.00920174f, -0.23504537f, 
    -0.15229866f, -0.04765841f, -0.05318669f, -0.00578593f, -0.23122708f, 0.09991646f, -0.03911107f, 0.28605020f, 
    0.09618665f, -0.04308510f, 0.00900733f, -0.24287896f, -0.16346079f, -0.01440102f, -0.05510742f, 0.02062113f, 
    0.01983411f, 0.22935551f, 0.36133751f, -0.11401979f, 0.19166334f, -0.02188918f, -0.08729260f, 0.17170379f, 
    0.04359678f, 0.28598085f, 0.09681271f, 0.30839640f, 0.40579939f, 0.08475847f, -0.01815263f, -0.03428032f, 
    0.08433583f, -0.01049003f, -0.23409520f, 0.46642262f, -0.00746159f, 0.02860100f, 0.12000298f, 0.06539466f, 
    0.13286193f, 0.34831357f, -0.20368956f, -0.37918323f, 0.10116006f, 0.01937625f, 0.11486230f, 0.18962592f, 
    0.09946439f, 0.17211533f, 0.08573238f, 0.30208752f, 0.08602358f, -0.01558908f, -0.09583357f, 0.04983426f, 
    0.07832689f, 0.11276900f, -0.03655865f, -0.00254766f, -0.05253219f, -0.09209698f, -0.09383568f, -0.06930420f, 
    0.24373367f, -0.03800657f, -0.10025586f, 0.19884501f, 0.10533695f, 0.07700665f, 0.09070661f, 0.04018630f, 
    0.06220108f, 0.01420786f, 0.11388216f, 0.06484552f, 0.28221381f, -0.30929330f, -0.36563957f, 0.12295724f, 
    -0.02644026f, -0.13129462f, -0.12755255f, -0.05587828f, 0.07097342f, -0.04344462f, -0.08823189f, -0.01836847f, 
    -0.25474569f, -0.22946867f, -0.06247700f, -0.14232367f, -0.05543734f, 0.05979511f, 0.00701007f, -0.11372641f, 
    0.03554810f, 0.06754257f, 0.02142363f, 0.07916816f, 0.29898429f, -0.21687630f, 0.27412072f, -0.18622299f, 
    0.08598247f, 0.01667159f, -0.09454286f, 0.24068324f, -0.02105639f, -0.21769069f, -0.12670197f, -0.17058852f, 
    -0.17528673f, -0.08982268f, 0.19896118f, -0.10470933f, 0.05266749f, -0.05448493f, -0.02830830f, -0.07250998f, 
    -0.04636621f, -0.19423869f, 0.05187929f, 0.06891779f, -0.11527371f, 0.19808152f, 0.11368291f, 0.27314624f, 
    0.07145423f, -0.13114084f, -0.15725496f, 0.09100784f, 0.11667126f, -0.18074116f, 0.04066390f, -0.12030795f, 
    0.07768680f, -0.18665329f, 0.36047697f, -0.06806877f, 0.00242858f, -0.06834366f, -0.01159141f, 0.03694265f, 
    0.00041119f, -0.10640745f, 0.14839920f, 0.39631143f, -0.00469814f, -0.05808671f, 0.03844390f, 0.06977642f, 
    0.14209394f, 0.02617028f, 0.15548253f, -0.02117377f, 0.02723759f, 0.00210880f, -0.04572403f, -0.10013425f, 
    0.25844529f, -0.15383644f, 0.09127329f, 0.00336593f, 0.03742813f, 0.06635803f, -0.04210978f, -0.11067929f, 
    0.18053301f, 0.17384693f, 0.02896058f, -0.08523665f, -0.22792946f, 0.06087252f, -0.07814474f, -0.09515179f, 
    -0.18200806f, 0.28373811f, 0.00675675f, 0.00624111f, 0.19000071f, 0.20277767f, 0.25791091f, -0.02117378f, 
    0.15053740f, -0.11971478f, -0.13916306f, -0.07414144f, 0.12347271f, 0.11898582f, -0.21387662f, 0.05714437f, 
    0.17624336f, -0.15664856f, 0.08116922f, -0.05105446f, 0.40095687f, -0.41468728f, 0.49095356f, -0.23519935f, 
    -0.00471395f, -0.11297940f, -0.06743410f, -0.03987630f, 0.17533965f, 0.15474764f, 0.13308720f, 0.14951685f, 
    0.12448198f, -0.15112044f, -0.09389392f, 0.14363435f, -0.03794254f, 0.17918767f, 0.13475436f, 0.01707295f, 
    0.07532846f, -0.17544311f, 0.13686885f, 0.14509293f, -0.39548197f, 0.18656817f, -0.05319777f, -0.16689470f, 
    0.21693669f, 0.07017910f, 0.26179010f, -0.09760795f, -0.15006883f, -0.05605048f, -0.03616915f, 0.00526007f, 
    0.10068128f, 0.02898961f, 0.11079944f, 0.47943488f, 0.00938143f, 0.22431497f, -0.01005999f, -0.05234591f, 
    0.00624624f, 0.14596140f, 0.07976449f, 0.18756804f, 0.14790314f, 0.10927797f, 0.15039679f, -0.10483031f, 
    0.12072378f, -0.03028759f, 0.17849086f, 0.01436787f, 0.19319479f, -0.06325031f, 0.04603042f, 0.09203002f, 
    -0.02865225f, -0.06295337f, 0.00829062f, 0.00149831f, -0.07614556f, -0.03863144f, 0.01147322f, -0.01315332f, 
    0.00238856f, 0.02366368f, -0.05889722f, 0.05291905f, 0.05374822f, 0.04650896f, -0.05045879f, -0.01932128f, 
    0.05040609f, -0.03278740f, -0.04067085f, -0.01356791f, 0.01077726f, 0.01403453f, -0.05707903f, -0.03972796f, 
    0.03400106f, -0.00481889f, 0.03308710f, 0.00397101f, -0.05084983f, -0.05839124f, -0.03786978f, -0.05524203f, 
    0.04637628f, -0.07455879f, -0.05163253f, 0.02163839f, 0.02114488f, -0.07116172f, -0.07277296f, 0.05523770f, 
    -0.07595167f, 0.00734698f, -0.07097679f, -0.02093042f, -0.05169100f, 0.01854622f, 0.01005908f, 0.00591129f, 
    0.03789343f, 0.05006599f, -0.03956138f, -0.05483085f, -0.02685317f, 0.05578005f, -0.03571112f, -0.06769691f, 
    0.03372842f, 0.04091378f, 0.02325349f, -0.00601327f, 0.04794268f, -0.02652847f, -0.00754191f, 0.03057674f, 
    0.00800063f, 0.05208129f, -0.05358322f, -0.06449614f, -0.05863124f, -0.03906127f, -0.01737364f, 0.05499034f, 
    -0.00203281f, 0.00716863f, 0.03924141f, -0.02801437f, -0.03655572f, -0.06186667f, 0.01952943f, -0.04980640f, 
    -0.05113180f, 0.02444052f, 0.04658886f, -0.04773622f, 0.05591705f, -0.03364120f, -0.00269172f, -0.02704697f, 
    0.04381598f, -0.05840993f, -0.07686859f, -0.01721215f, -0.04778660f, -0.00849387f, -0.04618015f, 0.06592818f, 
    -0.05043586f, -0.06537922f, -0.01821566f, 0.01325360f, 0.03996747f, 0.03355690f, -0.05234091f, -0.02722313f, 
    -0.03251421f, -0.01595936f, -0.06364082f, 0.06308702f, 0.04685221f, -0.01512859f, 0.02846656f, 0.02025414f, 
    0.03021369f, 0.00860896f, -0.05079613f, -0.07611704f, 0.01397242f, -0.07163434f, -0.06833825f, 0.02040530f, 
    0.01014018f, 0.03322227f, 0.01350614f, 0.01980636f, 0.06548706f, 0.05792113f, 0.06036109f, 0.02518713f, 
    0.05600722f, -0.03955612f, -0.03928953f, -0.07394591f, -0.07168552f, -0.03274953f, -0.06613860f, -0.02055492f, 
    0.06271606f, 0.00318520f, -0.02860835f, 0.05206868f, -0.02263610f, 0.06371663f, -0.05757255f, 0.04615744f, 
    -0.01054467f, -0.05673174f, -0.04476949f, -0.07647701f, -0.00787398f, -0.01998252f, -0.02874758f, 0.02473214f, 
    -0.02924466f, 0.03339555f, -0.03056424f, -0.04888334f, -0.01090643f, -0.02596470f, -0.06640999f, 0.03853538f, 
    -0.00394005f, 0.00550012f, 0.05604573f, 0.02212442f, 0.02892790f, 0.05182207f, -0.00368183f, -0.05392765f, 
    -0.07777282f, 0.03493635f, -0.04003615f, -0.00322139f, -0.04498157f, 0.01338256f, 0.01714314f, -0.02094649f, 
    -0.02994825f, 0.05900207f, -0.02400567f, 0.01830717f, -0.03997767f, -0.03965975f, 0.02703591f, 0.02221284f, 
    0.04686048f, 0.04081917f, 0.03584450f, -0.05574160f, -0.01034890f, -0.05792032f, -0.04023683f, -0.06483602f, 
    -0.07406758f, -0.02357224f, -0.05262866f, 0.02283635f, 0.02479284f, 0.00063369f, -0.01673527f, 0.01443337f, 
    -0.01789664f, -0.01224313f, -0.07799825f, 0.04984681f, 0.03466690f, -0.05274661f, -0.06762878f, -0.00354977f, 
    -0.00882143f, -0.08303661f, -0.02526545f, -0.03500382f, 0.01584755f, 0.00916946f, 0.00925139f, -0.07890000f, 
    0.02363546f, -0.04903794f, 0.05997820f, 0.04365697f, -0.02766380f, 0.03376430f, -0.01935016f, -0.04159364f, 
    0.01689328f, -0.04623843f, 0.02909302f, 0.00973522f, 0.00487875f, -0.05622860f, 0.04412832f, 0.05069351f, 
    -0.06673174f, 0.03060723f, 0.04549930f, 0.05641233f, -0.03246386f, -0.02369460f, 0.04427018f, -0.07353636f, 
    -0.00603395f, -0.03271947f, -0.04968310f, -0.03324971f, -0.04314862f, -0.07203359f, 0.04162312f, 0.03212563f, 
    -0.00971332f, -0.01432964f, 0.02959464f, -0.08242387f, -0.05398853f, 0.01061143f, -0.04041198f, 0.00795841f, 
    0.05459465f, -0.01432685f, -0.02173234f, -0.01060323f, -0.00479279f, -0.02941057f, 0.04884287f, -0.03367045f, 
    -0.00798039f, 0.02449087f, -0.07830285f, -0.01445732f, 0.03686539f, 0.00825044f, 0.01867678f, 0.04714693f, 
    0.05349177f, -0.05799926f, 0.05602511f, -0.04716104f, -0.03271499f, -0.07447709f, -0.00036393f, 0.05636067f, 
    0.05448189f, -0.05352100f, 0.01666542f, 0.04262258f, -0.01193541f, -0.00539422f, -0.08117978f, 0.02816329f, 
    -0.03617248f, -0.05923819f, 0.01150948f, -0.04417927f, -0.07786631f, -0.01769057f, 0.04392652f, -0.05726830f, 
    -0.06318743f, -0.06205217f, 0.03930684f, 0.04600791f, 0.02562628f, 0.05776406f, 0.05205909f, -0.01895454f, 
    -0.01422735f, -0.06357180f, -0.06210158f, 0.01402412f, 0.02466650f, -0.01686880f, 0.06068533f, -0.02873193f, 
    -0.07983166f, -0.02764392f, 0.01220898f, -0.04844154f, -0.05571932f, -0.05277545f, 0.05007554f, -0.02088988f, 
    -0.06256216f, 0.01512536f, -0.07721359f, -0.01251971f, -0.04769761f, -0.00925802f, -0.05161058f, -0.01258209f, 
    -0.05732019f, -0.05682383f, -0.04898027f, -0.04934133f, 0.00479666f, -0.04791857f, -0.05224872f, 0.04403750f, 
    -0.02403261f, 0.05674644f, 0.02558181f, 0.00941254f, 0.05781720f, 0.03011996f, -0.01127411f, 0.06307401f, 
    0.00486188f, -0.03397577f, 0.03391899f, 0.03832809f, -0.04433114f, -0.02864825f, 0.01421527f, 0.00410278f, 
    -0.05224980f, -0.02524009f, 0.00331197f, 0.00782450f, -0.04861960f, -0.07926722f, -0.07032514f, 0.04262368f, 
    0.04788120f, 0.05906987f, 0.05302006f, -0.06762093f, 0.00743180f, 0.02239898f, -0.02580971f, 0.04902012f, 
    -0.00903508f, -0.03378282f, 0.02718295f, -0.00115668f, 0.00743451f, 0.05289588f, -0.00516758f, 0.00950111f, 
    0.02481566f, -0.03706877f, 0.02225456f, -0.04230665f, -0.02827520f, -0.06534360f, -0.00948271f, -0.02225527f, 
    -0.01639088f, -0.24454527f, -0.20240241f, -0.29776868f, 0.00715338f, 0.10445467f, 0.07487734f, -0.10445399f, 
    0.17788561f, 0.06594024f, 0.01344037f, 0.03921821f, 0.31391564f, 0.13050099f, 0.26189584f, -0.17594510f, 
    0.28437328f, 0.07859287f, -0.00846742f, -0.11790165f, -0.06397039f, 0.13586509f, -0.10148422f, -0.02430883f, 
    -0.01576079f, 0.24860865f, 0.13029541f, 0.07535583f, -0.13118030f, -0.08568521f, 0.06461596f, -0.04834472f, 
    -0.10929517f, 0.08842677f, -0.04022022f, 0.09843387f, -0.05117244f, 0.28191319f, -0.00211977f, -0.12789336f, 
    0.00116185f, -0.02968550f, 0.01794532f, 0.07265348f, -0.07709241f, 0.06774050f, 0.13297275f, 0.08521247f, 
    0.10935268f, 0.23653378f, 0.05429525f, -0.07738712f, -0.06291984f, -0.02982804f, -0.07698352f, -0.09746478f, 
    -0.00858572f, 0.01411568f, 0.14768830f, -0.10982621f, -0.00942001f, -0.05890232f, -0.00639892f, -0.06937524f, 
    -0.14105588f, -0.06025668f, -0.00409127f, 0.05734848f, 0.08515286f, -0.00302951f, 0.03913848f, 0.08102709f, 
    0.29745495f, 0.10020429f, -0.29198086f, 0.09155836f, 0.04568037f, 0.05705740f, 0.02106350f, -0.08609182f, 
    -0.08610068f, -0.02393453f, 0.01861058f, -0.27248928f, -0.01417774f, -0.19806559f, -0.15437841f, -0.01019253f, 
    0.03740785f, -0.07800046f, 0.02972641f, -0.01387542f, 0.02951729f, 0.11509144f, -0.03035501f, 0.06514485f, 
    0.39643392f, -0.13931867f, -0.32302368f, 0.01190560f, -0.00598367f, -0.19153333f, 0.12286140f, -0.12507367f, 
    0.14169174f, -0.02407414f, 0.03767560f, 0.12764297f, -0.11523554f, -0.23157921f, 0.29573020f, 0.20031194f, 
    0.09997725f, 0.04511563f, 0.08707090f, 0.15901247f, -0.03035346f, 0.04247084f, -0.09080824f, -0.11613870f, 
    0.27370575f, -0.05467556f, -0.16919240f, -0.20583653f, -0.15100251f, -0.00713009f, 0.08468010f, 0.18963309f, 
    -0.02759539f, 0.21517938f, 0.02371758f, 0.27096328f, 0.31190678f, 0.05448617f, -0.11161590f, -0.32521838f, 
    0.18268597f, -0.06929564f, -0.02426950f, -0.01630422f, 0.11720981f, -0.06055635f, 0.25372413f, 0.05947528f, 
    -0.25155672f, -0.04256318f, -0.09973931f, 0.04804483f, -0.10517721f, -0.09394923f, 0.12850372f, 0.00938557f, 
    0.08505782f, -0.16448735f, -0.15134695f, 0.04313261f, 0.44227067f, -0.38594097f, 0.03234681f, 0.30307427f, 
    -0.12516612f, 0.12522891f, 0.29778546f, -0.01519667f, 0.02467503f, -0.09375312f, 0.08303258f, 0.13772233f, 
    -0.25988847f, -0.06439680f, 0.06529997f, -0.13259411f, 0.07021564f, 0.07019781f, 0.09147269f, 0.21078183f, 
    -0.09674937f, 0.02798992f, 0.20687103f, -0.29504129f, -0.00287163f, -0.06757940f, -0.18625878f, 0.05703129f, 
    -0.14269777f, 0.05115914f, 0.11819429f, 0.06360415f, -0.21188633f, 0.16089304f, -0.00875489f, 0.10989612f, 
    0.34149602f, 0.12301811f, 0.20278659f, -0.28688484f, -0.25004885f, -0.02733242f, 0.12997858f, -0.02116177f, 
    -0.00581688f, 0.07641499f, -0.17672710f, -0.03907385f, -0.38304231f, 0.07507446f, 0.01949982f, -0.06785239f, 
    0.14857703f, -0.03515580f, -0.12929945f, -0.00530550f, 0.06713270f, -0.04483845f, -0.04555086f, 0.03881088f, 
    0.23201555f, 0.05079705f, -0.15214643f, 0.01524398f, -0.06093970f, -0.12164038f, -0.10288298f, -0.00255409f, 
    -0.00580334f, 0.05768276f, -0.01000787f, 0.25227940f, -0.39453849f, -0.08512476f, -0.00179683f, -0.09870749f, 
    0.00274973f, -0.02637256f, 0.10369360f, 0.18946157f, -0.24960184f, -0.06082567f, 0.02322805f, -0.17911118f, 
    -0.23749337f, -0.26121721f, -0.38572136f, 0.14632820f, 0.02148071f, 0.11857058f, -0.13866141f, 0.13400143f, 
    -0.00059446f, 0.10161240f, 0.10588288f, -0.08816297f, -0.17065893f, 0.50302064f, -0.00164053f, 0.07332485f, 
    -0.09265567f, 0.13310599f, 0.18489103f, -0.02307550f, -0.03294352f, 0.16049464f, 0.04382436f, -0.10490248f, 
    -0.10980374f, -0.03499091f, 0.13577312f, 0.19669972f, -0.07330113f, 0.14197943f, -0.08531588f, -0.00157693f, 
    0.12197735f, 0.02552915f, -0.06892981f, -0.09376980f, 0.06755240f, 0.05628936f, 0.32056671f, 0.22774181f, 
    -0.06984671f, -0.03739474f, -0.00492409f, 0.28328198f, 0.06808547f, 0.00601253f, -0.00154061f, -0.03807553f, 
    -0.04247886f, 0.02422866f, 0.02851208f, 0.08355712f, -0.17144030f, 0.08088548f, -0.13239007f, -0.04580081f, 
    -0.03753499f, 0.08171289f, -0.04637112f, 0.01867656f, 0.05137459f, 0.27166963f, 0.15310760f, 0.21221638f, 
    0.33950201f, 0.02424898f, -0.13171729f, 0.01434479f, -0.16485412f, -0.01187507f, -0.04944562f, 0.22486213f, 
    0.28480816f, -0.30214158f, -0.08751085f, 0.01914871f, -0.11509287f, -0.01638454f, 0.06235931f, -0.01408786f, 
    -0.03858409f, -0.13043362f, -0.05225151f, -0.08674020f, -0.35737059f, -0.21641199f, -0.25454685f, -0.00608928f, 
    -0.07525844f, 0.01684069f, 0.10018717f, -0.14446469f, -0.23407362f, -0.24322118f, -0.14180392f, 0.01080308f, 
    -0.03115869f, 0.15259941f, 0.08659486f, 0.08733109f, 0.14630561f, 0.15969716f, 0.15649065f, -0.15520424f, 
    0.20324233f, 0.13735892f, 0.04445760f, 0.18256159f, 0.41863748f, 0.03110882f, 0.47553810f, 0.10451107f, 
    0.00174868f, -0.19864391f, 0.07368420f, 0.13382441f, 0.00855473f, -0.13989845f, -0.02593370f, 0.11714110f, 
    -0.04602429f, 0.10488275f, -0.04682462f, 0.00197428f, 0.14682637f, -0.05054650f, -0.04121038f, -0.03291539f, 
    0.12751941f, 0.13395137f, 0.13818382f, 0.35342008f, 0.21230751f, -0.17419074f, 0.30647773f, 0.26622361f, 
    -0.07757317f, 0.08775835f, 0.10095327f, 0.22670557f, 0.25730279f, 0.13835861f, -0.15931053f, -0.26483113f, 
    -0.19898847f, -0.10483893f, -0.29589149f, -0.06410607f, -0.00684699f, 0.03061342f, -0.13883361f, 0.04714342f, 
    0.17614523f, -0.08753975f, 0.07517494f, 0.13464308f, 0.20463122f, -0.13672954f, -0.32267272f, 0.38791969f, 
    0.03082014f, 0.11437437f, 0.08782305f, 0.00722411f, -0.06717253f, 0.13606350f, 0.16541529f, -0.01747858f, 
    0.09281332f, 0.02805878f, 0.19135763f, -0.03444512f, 0.01214604f, 0.06151286f, -0.02418869f, -0.06424785f, 
    -0.00231906f, -0.20136766f, -0.08511592f, -0.22348717f, 0.19569267f, -0.00957906f, 0.04441999f, -0.08107769f, 
    0.04912550f, 0.07529043f, -0.02996456f, -0.04335665f, 0.09200174f, 0.01248443f, -0.03037321f, 0.04663749f, 
    0.08004472f, 0.18421966f, 0.29290816f, -0.00940753f, -0.00986777f, -0.00873245f, 0.05816307f, -0.12633452f, 
    -0.11594385f, -0.02308217f, -0.09397528f, 0.03828298f, -0.18713042f, -0.06224528f, -0.16971712f, -0.07610030f, 
    0.27902079f, 0.15235510f, 0.03275655f, 0.20670685f, 0.19401501f, -0.12675135f, 0.12340456f, 0.12851559f, 
    -0.39199433f, -0.30071101f, -0.19054896f, -0.33078283f, 0.02265199f, -0.14204349f, 0.06197976f, 0.13646847f, 
    -0.07464356f, -0.07152115f, 0.05981909f, 0.01069940f, -0.19014803f, -0.06970644f, -0.14301464f, -0.10544340f, 
    0.14952843f, 0.00521983f, 0.07659173f, -0.18252115f, 0.08884340f, 0.06467183f, -0.02704241f, 0.08216219f, 
    0.21645920f, -0.13488412f, 0.13264874f, -0.04330117f, 0.21135421f, -0.12626481f, 0.09433821f, 0.12165067f, 
    0.09676299f, 0.12853967f, 0.01665721f, 0.04260527f, 0.55559272f, 0.24986619f, -0.35935137f, -0.10466807f, 
    -0.11772793f, 0.10902136f, 0.34664315f, 0.17639938f, 0.06052409f, -0.14551128f, -0.11979605f, -0.33427125f, 
    -0.06988215f, -0.00834787f, 0.28636709f, -0.05772820f, -0.03096593f, -0.10797983f, -0.07121379f, 0.02929015f, 
    0.26436391f, 0.02047625f, 0.23455380f, 0.15119192f, 0.28595862f, -0.13472010f, 0.32583997f, 0.03346255f, 
    -0.05421777f, -0.02328664f, 0.02567657f, 0.10974889f, 0.12780371f, 0.26159957f, 0.18408009f, 0.13050435f, 
    0.13561919f, -0.12793450f, -0.16131790f, -0.02287331f, -0.03455162f, 0.03933818f, 0.13824730f, 0.13749075f, 
    0.03760488f, -0.25111660f, 0.13664405f, -0.26698178f, -0.16820641f, -0.14635152f, -0.42750466f, -0.03543790f, 
    0.19050832f, 0.17063357f, 0.09585121f, -0.02191061f, 0.21544291f, 0.08263300f, 0.06528855f, -0.00451391f, 
    0.08064666f, -0.43587413f, -0.16185409f, 0.19314808f, -0.10174166f, 0.02428408f, 0.21367864f, 0.10130796f, 
    -0.05955809f, -0.08785795f, 0.20478678f, -0.14090733f, -0.35423616f, 0.11597763f, 0.00614551f, -0.34287059f, 
    0.16611069f, 0.02703665f, 0.03820380f, -0.14267512f, 0.18211840f, 0.27446881f, 0.12903796f, 0.19207592f, 
    0.00463018f, 0.03811005f, -0.00859923f, 0.01924041f, -0.00424076f, -0.03834614f, -0.05446632f, -0.05488260f, 
    -0.02951423f, -0.04753159f, 0.00935715f, 0.01902270f, 0.02508539f, -0.03870350f, 0.03853806f, 0.00178670f, 
    0.04644719f, -0.00434332f, -0.06904119f, 0.03632941f, 0.06682155f, -0.05506375f, -0.06516887f, -0.04348846f, 
    -0.02462464f, 0.06109820f, 0.00532631f, -0.06679735f, 0.03450046f, -0.06354795f, -0.02954509f, 0.05242670f, 
    0.00946833f, -0.07051510f, -0.00764164f, 0.00039130f, 0.00905206f, -0.05910674f, -0.05840660f, -0.04473183f, 
    -0.04815495f, 0.02714004f, 0.03879958f, -0.04400719f, -0.03509675f, 0.01964796f, -0.00769923f, 0.02679845f, 
    0.00708085f, -0.06756633f, -0.00188645f, -0.07219213f, -0.03305364f, -0.07449132f, 0.05627704f, -0.02969408f, 
    -0.05626394f, -0.02038887f, 0.02145959f, -0.03809838f, -0.07409295f, 0.05803755f, -0.03190864f, -0.01498256f, 
    0.02017369f, 0.01486139f, 0.04547711f, 0.05814211f, 0.00185891f, -0.07350327f, -0.00802489f, -0.05650600f, 
    -0.02508133f, -0.00461640f, 0.04730126f, 0.05580473f, -0.01365470f, -0.01459344f, -0.02069967f, -0.03642752f, 
    0.03296347f, -0.00506899f, 0.02849917f, -0.02573561f, 0.01654896f, 0.06303530f, -0.04184576f, -0.02275191f, 
    0.03676282f, -0.03036986f, 0.02226494f, -0.07565998f, 0.01408445f, 0.03356612f, -0.05326760f, 0.03648635f, 
    0.02501503f, 0.03256646f, -0.07069294f, -0.03810557f, 0.02148158f, -0.00160986f, -0.04929090f, -0.04051962f, 
    -0.03581411f, 0.00478891f, 0.03721539f, 0.06906154f, -0.05967681f, -0.04035473f, -0.02018155f, 0.04355699f, 
    -0.04226746f, 0.02900582f, 0.00428579f, -0.03115098f, -0.01746242f, 0.00556337f, -0.01996610f, 0.03529775f, 
    -0.03319899f, -0.05448355f, -0.03461158f, 0.00874580f, 0.06364442f, 0.00759070f, -0.04706536f, 0.03937736f, 
    0.00962208f, 0.04504867f, 0.00278022f, -0.03212461f, -0.01934265f, 0.04374880f, -0.05104777f, 0.03411928f, 
    0.00682471f, 0.01197202f, 0.02196172f, -0.00691556f, -0.04683627f, -0.02163699f, -0.00948032f, 0.00656604f, 
    -0.00853078f, 0.04321919f, 0.06072789f, -0.06227038f, -0.06727955f, 0.02619456f, 0.02139720f, 0.04944605f, 
    -0.07054190f, -0.02609115f, 0.00146795f, 0.00121288f, 0.02230345f, -0.05235310f, 0.04369286f, -0.01458065f, 
    0.04311281f, -0.00070922f, -0.05526118f, -0.07011110f, -0.05114099f, -0.04585100f, 0.01413834f, -0.06196631f, 
    0.00052248f, -0.02683628f, 0.01749334f, -0.01232938f, 0.03527499f, 0.01696058f, 0.00464705f, 0.03883294f, 
    0.02903229f, -0.07235020f, 0.05906776f, -0.07217918f, 0.06555341f, -0.05968615f, -0.01640749f, 0.02612853f, 
    -0.05356039f, 0.01110363f, 0.03636440f, -0.01974131f, -0.05615733f, -0.05747784f, -0.03645884f, 0.01301911f, 
    -0.10925215f, -0.41516986f, -0.04316609f, 0.01021835f, 0.07702536f, 0.02562690f, -0.05614895f, 0.08029740f, 
    -0.08304516f, 0.11694834f, -0.01675006f, -0.26182291f, -0.22668765f, 0.06693464f, 0.52000076f, 0.34213173f, 
    0.01790600f, -0.06309549f, -0.11771704f, 0.05566681f, 0.08371734f, 0.09157275f, -0.00563104f, 0.15216623f, 
    -0.10081520f, -0.10216122f, -0.14302042f, -0.06151389f, 0.01652399f, 0.00658257f, -0.12468354f, -0.04543039f, 
    -0.16723867f, -0.03304678f, 0.13695338f, 0.08219842f, -0.07369244f, 0.07811815f, -0.08467828f, 0.05052393f, 
    -0.17045648f, 0.04346553f, 0.00343295f, -0.14259675f, 0.02451903f, 0.06497207f, 0.08632931f, 0.18388312f, 
    -0.08673626f, -0.20634067f, -0.08069071f, 0.06846035f, 0.02941083f, -0.05173740f, -0.05168034f, -0.04389977f, 
    0.10748097f, 0.03090872f, -0.08561170f, 0.07280838f, 0.36543527f, -0.04866924f, 0.17489834f, 0.04456909f, 
    0.03409766f, 0.09222831f, 0.04454833f, -0.10544801f, -0.19398625f, 0.16531253f, 0.01765688f, -0.02806862f, 
    0.21106367f, 0.41856101f, 0.10724019f, 0.01028420f, 0.18272360f, 0.08257483f, 0.08943276f, 0.08708427f, 
    -0.14697637f, -0.11130706f, -0.09595274f, -0.05100334f, 0.24818182f, 0.25413457f, 0.12324705f, 0.15893149f, 
    0.18058780f, 0.32334971f, 0.15717933f, 0.07684848f, 0.05893111f, -0.01068727f, -0.08525277f, -0.01692502f, 
    -0.10464467f, 0.31420261f, 0.21899702f, 0.04640482f, 0.08602140f, 0.16917254f, 0.03660004f, 0.02865565f, 
    0.02702128f, -0.02656949f, -0.13353741f, -0.11367455f, -0.13109876f, -0.31023595f, -0.06887950f, 0.03430660f, 
    -0.12870312f, 0.23924693f, 0.03499560f, -0.10025639f, -0.15575825f, 0.00247962f, -0.07457308f, 0.00100204f, 
    -0.23414105f, 0.41643101f, -0.21537107f, 0.06463355f, 0.12705518f, 0.17463771f, 0.18999097f, 0.02891973f, 
    -0.12043462f, 0.10817247f, -0.01429096f, 0.07856657f, -0.28955418f, 0.15148425f, 0.07805866f, 0.13254456f, 
    -0.00351326f, -0.02699986f, 0.09863060f, -0.08065520f, 0.08739184f, 0.02253636f, 0.03456550f, 0.01717152f, 
    0.01782084f, 0.09648027f, 0.22604623f, -0.08056874f, 0.18547317f, -0.16853961f, -0.23065944f, 0.15140536f, 
    -0.01491756f, -0.00308817f, -0.08718173f, 0.08766934f, 0.39548677f, 0.14238641f, -0.17193273f, 0.16035555f, 
    0.08124734f, 0.05112398f, -0.00221277f, 0.17873293f, -0.24596272f, 0.16894804f, 0.16935459f, -0.02979119f, 
    -0.06555487f, 0.38145646f, 0.17694016f, -0.16253144f, 0.06067171f, -0.03249319f, -0.05671870f, 0.09098806f, 
    -0.07153486f, 0.05409940f, 0.02617398f, 0.10774563f, 0.16508302f, 0.32192713f, -0.20575292f, 0.19302860f, 
    0.14636157f, 0.14813173f, 0.09303185f, 0.12780449f, -0.00557008f, -0.10607763f, 0.06520781f, -0.11973365f, 
    -0.07523727f, 0.43029130f, 0.34136450f, -0.01497226f, -0.03461579f, -0.13628495f, 0.02236405f, 0.20614541f, 
    0.06297917f, 0.06498256f, -0.06817079f, 0.10859863f, 0.17177458f, -0.00845436f, 0.03748597f, -0.31760967f, 
    -0.14951144f, 0.08906917f, 0.13502324f, 0.08680165f, -0.03049594f, 0.03403079f, 0.03304397f, -0.08319418f, 
    0.04870153f, 0.07204141f, -0.32590201f, -0.14237994f, 0.07016747f, -0.02243601f, 0.10058706f, 0.09753864f, 
    0.10735386f, 0.23594178f, 0.00163081f, 0.21205932f, 0.01383333f, -0.13651955f, 0.00356271f, 0.19142646f, 
    0.16358213f, -0.00332842f, 0.11994799f, 0.16966507f, 0.00185736f, -0.19593813f, -0.20680314f, -0.17985661f, 
    0.13138457f, 0.01360763f, -0.04033076f, 0.02097927f, -0.00680235f, 0.05212902f, -0.00327069f, 0.15286013f, 
    -0.10806338f, -0.13314749f, 0.00381656f, -0.09242041f, 0.21839106f, 0.12430546f, 0.15847412f, -0.10528688f, 
    -0.00437002f, -0.07009608f, -0.04836548f, -0.06709754f, -0.20797373f, -0.15050571f, -0.12930612f, -0.26901510f, 
    -0.29727882f, -0.11970349f, -0.09008541f, 0.29493502f, -0.05322130f, -0.08673599f, 0.08391713f, -0.08246515f, 
    -0.11250395f, 0.05132195f, 0.21568216f, 0.18574323f, -0.17968076f, -0.00564129f, 0.05877792f, 0.16071767f, 
    -0.17069882f, -0.17897157f, -0.23279051f, -0.12365007f, -0.00740006f, -0.02637901f, -0.09235744f, -0.17570205f, 
    -0.20749083f, 0.01963111f, 0.17997120f, 0.15233186f, -0.03815834f, -0.00234726f, 0.03458871f, 0.18128546f, 
    -0.04171360f, 0.00948221f, -0.00200690f, 0.13501562f, 0.31999451f, 0.16795014f, -0.09483558f, -0.23033608f, 
    0.18943459f, -0.01915224f, 0.01764683f, -0.00334986f, 0.02317778f, 0.07418320f, 0.20808993f, 0.13150904f, 
    -0.14841974f, -0.06834913f, 0.30219224f, 0.37231904f, 0.02926562f, 0.09417869f, -0.16226016f, -0.06285449f, 
    -0.04938633f, -0.01430506f, 0.04072709f, 0.04838325f, -0.15868582f, 0.20486116f, -0.42631978f, 0.40912917f, 
    0.02164221f, 0.12925194f, 0.07364082f, 0.20977621f, -0.11115265f, 0.10620008f, -0.06952037f, 0.09437232f, 
    0.00910128f, -0.00576070f, -0.10973906f, 0.14330180f, -0.02121396f, 0.10405331f, 0.18074828f, -0.06304713f, 
    0.08987685f, 0.08635601f, 0.03753400f, 0.03367913f, -0.40692991f, 0.42923903f, 0.21989839f, 0.06021338f, 
    0.00917109f, 0.00322848f, 0.03950578f, -0.04179408f, -0.13051209f, -0.03788648f, 0.01228987f, -0.03491112f, 
    -0.01972455f, -0.08579703f, -0.22419915f, 0.18680595f, 0.00257639f, 0.18697043f, 0.12133896f, -0.12592568f, 
    0.13839896f, 0.06058144f, -0.00455857f, 0.20171377f, -0.18710059f, -0.15864417f, 0.33063969f, 0.22648357f, 
    0.03180693f, -0.05730777f, -0.06971202f, -0.11726667f, 0.06039482f, -0.01053562f, -0.09472667f, -0.16501777f, 
    0.32730675f, 0.24229057f, 0.04619160f, 0.10159213f, 0.09856402f, 0.00283567f, 0.01370993f, 0.01479238f, 
    -0.18188129f, -0.05158577f, 0.03008601f, 0.10419562f, -0.44214261f, 0.16627435f, -0.12126552f, 0.03220144f, 
    -0.15847355f, -0.25432548f, 0.18377338f, 0.02984932f, 0.17715403f, 0.08182757f, -0.26172042f, 0.16434088f, 
    0.16020912f, -0.03501068f, 0.14386451f, 0.12869768f, 0.11455946f, 0.08187618f, 0.04045071f, 0.00928466f, 
    0.33023083f, 0.14889762f, 0.13367265f, 0.10817874f, 0.11449406f, 0.10286048f, 0.12661901f, 0.07446311f, 
    0.01381267f, -0.00781756f, 0.11493077f, 0.03879585f, 0.00473838f, -0.08255406f, 0.04655828f, 0.03477281f, 
    0.14897558f, 0.05992807f, 0.05911672f, 0.23922008f, 0.06853284f, 0.16338035f, 0.05318277f, 0.08294570f, 
    0.20558539f, 0.17429754f, 0.00008189f, 0.10851035f, 0.26819253f, 0.01784408f, -0.11112350f, -0.06038642f, 
    -0.10841867f, -0.31968448f, 0.22479282f, -0.16984051f, 0.00550807f, 0.12542759f, -0.00469149f, 0.08351035f, 
    0.19288023f, -0.12204837f, 0.09838732f, -0.13919857f, -0.05460395f, 0.22209299f, -0.10858585f, -0.04797804f, 
    0.17324691f, -0.10129094f, -0.13604791f, -0.08251888f, 0.03197012f, 0.09867389f, 0.27737617f, 0.27572849f, 
    -0.07014538f, 0.04298288f, -0.09839810f, 0.12899388f, -0.11966979f, -0.05541745f, -0.09648679f, -0.03773150f, 
    -0.55417395f, -0.06300142f, -0.22263977f, -0.20215364f, 0.05242568f, -0.19977713f, -0.05762671f, -0.13324481f, 
    -0.12624869f, -0.18851963f, -0.03471707f, -0.08982882f, 0.09841508f, -0.00587411f, -0.08645767f, -0.15999432f, 
    0.19219777f, -0.00534062f, 0.04086746f, 0.03373912f, -0.11281373f, 0.02980561f, 0.01988447f, 0.12206382f, 
    0.19978552f, 0.01356129f, 0.12603836f, 0.12293213f, 0.01621099f, -0.04822232f, -0.08773762f, 0.09781579f, 
    -0.10809036f, 0.01805314f, -0.04003378f, -0.00747457f, 0.06450468f, 0.00231743f, -0.04535697f, 0.05855263f, 
    0.08200663f, 0.12371311f, 0.10784730f, 0.02226960f, 0.00476254f, -0.19236888f, -0.11362998f, -0.33561748f, 
    -0.11405476f, 0.27063379f, 0.18365398f, -0.28532118f, 0.05091976f, -0.11223463f, 0.00396224f, -0.09834276f, 
    -0.19129616f, 0.07850122f, 0.03334292f, 0.04119468f, 0.53634727f, -0.11027538f, 0.18065366f, -0.31570283f, 
    -0.23668221f, -0.14796630f, -0.12782979f, -0.16053541f, -0.07250185f, 0.19163945f, -0.10967834f, -0.12083081f, 
    0.06367882f, 0.15413405f, 0.06250262f, -0.33528721f, -0.06532529f, 0.01713284f, -0.17566714f, -0.20058872f, 
    0.18558048f, 0.34031895f, -0.06952672f, -0.04689926f, -0.11909616f, -0.07290979f, 0.18889947f, 0.24503326f, 
    -0.10215990f, -0.22642815f, -0.12511912f, 0.09050734f, 0.02546128f, -0.12604274f, 0.13849394f, -0.06823628f, 
    -0.09661906f, 0.19883141f, 0.30637527f, 0.24958375f, -0.16192314f, 0.00592002f, 0.02952148f, -0.12651736f, 
    0.14310271f, 0.05008304f, 0.19375937f, 0.13197458f, 0.40000412f, -0.10803197f, 0.21808028f, -0.32567549f, 
    0.20090577f, 0.21869431f, 0.13323106f, 0.28486225f, 0.03022742f, -0.04191238f, 0.06969853f, -0.03394276f, 
    -0.02362573f, 0.27533558f, -0.08568215f, 0.16157562f, -0.12267736f, -0.08561895f, 0.01293935f, 0.09025053f, 
    -0.33368769f, -0.16077264f, -0.22208610f, -0.10644817f, -0.18757452f, 0.10253462f, -0.17143902f, 0.14804305f, 
    0.01094348f, -0.24436243f, 0.20691340f, 0.14067914f, 0.03487121f, 0.11202686f, 0.08323324f, 0.13920285f, 
    0.21675816f, 0.27872524f, 0.00754759f, -0.02021260f, -0.07525603f, -0.05175220f, 0.00054484f, 0.08549469f, 
    0.05973314f, 0.01291972f, 0.09609347f, -0.11602300f, -0.17379415f, -0.37844715f, 0.25390249f, -0.07255799f, 
    -0.12133549f, -0.01467852f, -0.19552501f, -0.18137325f, 0.07184315f, -0.15061302f, -0.06898142f, 0.12268207f, 
    -0.06833468f, 0.34165275f, 0.12915565f, 0.43675169f, 0.08024100f, 0.06091708f, 0.00029611f, -0.12519646f, 
    -0.06932221f, 0.11483005f, 0.12720853f, -0.12104878f, -0.20723827f, -0.36714312f, -0.09668364f, -0.22589374f, 
    0.01974406f, -0.00596577f, 0.02004268f, -0.15218380f, 0.01407153f, -0.01317563f, 0.08205394f, -0.10857184f, 
    -0.06982756f, 0.17852777f, -0.53475046f, 0.18765821f, -0.15659873f, -0.01924324f, -0.03890680f, -0.14212690f, 
    -0.08414712f, -0.08782170f, 0.05927187f, -0.02535531f, 0.05675753f, 0.09220640f, 0.32807639f, -0.05306633f, 
    0.16014199f, -0.15881228f, -0.20091860f, -0.35358134f, 0.12880367f, 0.04792279f, 0.10627094f, 0.05393448f, 
    -0.24812362f, -0.10750618f, -0.07502633f, -0.00704723f, 0.17564529f, -0.07183049f, 0.20216550f, 0.23840719f, 
    -0.18358064f, -0.08245873f, 0.17328003f, 0.05516160f, -0.02864033f, 0.29411238f, -0.29125240f, 0.28213987f, 
    0.05566159f, -0.08188377f, 0.08886014f, 0.10226158f, -0.09956575f, 0.03178845f, 0.15933187f, -0.00057793f, 
    -0.25167674f, -0.09690657f, -0.24608862f, 0.02907849f, -0.12635203f, 0.33617300f, 0.09031250f, -0.20633264f, 
    0.10173627f, 0.10732126f, -0.13983564f, 0.09165333f, 0.04097270f, 0.35065791f, 0.35098493f, 0.33554611f, 
    -0.17865846f, 0.03886382f, 0.09317142f, -0.17555809f, 0.10882423f, -0.02401369f, 0.07430241f, 0.13894235f, 
    0.00569789f, -0.16920376f, 0.03279414f, -0.31078103f, 0.22458917f, 0.03095521f, -0.19179003f, -0.05894161f, 
    0.03548503f, 0.01604625f, -0.11054502f, -0.07500948f, 0.00631880f, 0.16284785f, 0.01969267f, 0.34084338f, 
    -0.17468561f, -0.01402939f, 0.18176641f, 0.06086284f, 0.05323524f, 0.12705472f, -0.01832732f, -0.15363097f, 
    -0.21502484f, -0.01659879f, 0.10518608f, 0.01694085f, 0.03294236f, 0.06711161f, -0.03818368f, 0.14202780f, 
    -0.05597856f, 0.06424341f, -0.01829442f, -0.11178618f, 0.06241558f, 0.24279292f, 0.35388055f, 0.20067059f, 
    -0.47199363f, 0.09484170f, 0.03364216f, -0.03918467f, -0.05849943f, 0.00613306f, 0.06271951f, 0.09277826f, 
    -0.22107032f, -0.13210055f, -0.08733588f, -0.05849215f, -0.07813698f, -0.02348186f, -0.08424058f, -0.07574973f, 
    0.01074665f, 0.00012999f, 0.16915590f, -0.04916012f, -0.11185189f, -0.01283441f, -0.14403950f, 0.08843639f, 
    0.11217253f, 0.06467996f, -0.02862878f, -0.29306361f, 0.05296322f, 0.08376620f, 0.05610014f, 0.31527981f, 
    -0.29492798f, -0.17646030f, -0.23600787f, 0.06232170f, 0.02230871f, -0.05255258f, -0.08740684f, -0.05024377f, 
    0.06932863f, 0.19366747f, 0.06605792f, 0.17165647f, -0.18668595f, -0.40979257f, 0.10387591f, 0.03982319f, 
    0.01782984f, 0.12593186f, 0.05038492f, 0.05236473f, 0.02980211f, 0.19014423f, 0.16710590f, 0.06824426f, 
    0.18848562f, 0.22115940f, 0.00163763f, -0.01464632f, 0.22173353f, 0.09471299f, -0.01634212f, 0.05248696f, 
    -0.08193561f, 0.18392147f, -0.04535750f, -0.28421110f, 0.19947860f, 0.12017214f, -0.24466857f, -0.02221917f, 
    0.01144803f, 0.02678596f, -0.12579212f, -0.01156867f, -0.09162161f, 0.00899819f, 0.00674710f, 0.00738085f, 
    -0.15681383f, 0.33168674f, -0.08284634f, 0.12127178f, 0.00685802f, 0.21402670f, 0.12654693f, 0.21760726f, 
    -0.14927892f, 0.05368109f, -0.04967594f, 0.01282873f, -0.38964239f, -0.29419103f, -0.14914049f, 0.22209616f, 
    -0.13875434f, -0.00816452f, -0.01045662f, -0.09176330f, -0.01111899f, -0.02683832f, -0.17827290f, -0.01667989f, 
    0.05039123f, 0.84254801f, 0.09021873f, -0.20713440f, -0.05390492f, 0.12709275f, 0.13884228f, -0.12244160f, 
    -0.08188026f, 0.25421011f, -0.06834166f, -0.03102652f, -0.38256165f, 0.40608984f, -0.16317128f, -0.23096745f, 
    -0.04680823f, 0.05247132f, 0.01460830f, 0.06867533f, 0.04805982f, 0.03270278f, 0.03317154f, 0.10644469f, 
    -0.03250950f, 0.00533108f, 0.05190280f, -0.02057806f, 0.21614562f, -0.03322405f, -0.12698342f, 0.14839131f, 
    -0.09150366f, 0.04167307f, -0.02959377f, -0.00171784f, -0.18215060f, 0.08839975f, 0.11176575f, 0.16235960f, 
    0.12813586f, 0.05809442f, -0.14908016f, 0.04279125f, 0.02380202f, 0.06122099f, -0.06650592f, -0.07773273f, 
    0.07121011f, 0.07285275f, 0.08977187f, -0.05134637f, 0.09448428f, 0.02063073f, 0.00753305f, 0.03537063f, 
    0.03522046f, -0.05080017f, -0.04752033f, -0.04961926f, 0.25207290f, 0.45923623f, -0.35231838f, 0.16167170f, 
    0.07934405f, -0.04200476f, 0.00297931f, -0.12112617f, -0.16456002f, -0.13486870f, 0.01923243f, 0.01493865f, 
    -0.23348486f, -0.32186744f, -0.15371856f, -0.30236742f, -0.17043668f, -0.04762798f, 0.05878918f, -0.22046682f, 
    0.11952055f, -0.12531425f, -0.00957752f, -0.01125021f, -0.20005742f, 0.14817783f, 0.04513621f, 0.24902244f, 
    0.30584747f, 0.22785939f, 0.22886485f, -0.11965591f, -0.05308573f, 0.07905950f, -0.13318835f, 0.19972733f, 
    0.01476634f, 0.11821448f, 0.17053810f, 0.07146246f, -0.11540049f, -0.09297407f, -0.06096514f, -0.15748808f, 
    0.03733118f, -0.08319871f, -0.10978068f, -0.18096505f, 0.09110175f, 0.18324868f, -0.19218002f, -0.10606235f, 
    0.01717073f, 0.10637321f, 0.10030550f, -0.07033632f, -0.06371658f, 0.09547687f, 0.10036781f, 0.19009727f, 
    0.18507916f, 0.18036965f, -0.03486605f, 0.03229721f, -0.14839652f, -0.00412429f, -0.09861329f, -0.09063105f, 
    0.02306791f, 0.12168200f, -0.12644880f, -0.01907218f, -0.03500805f, 0.16215475f, -0.26897836f, -0.30705991f, 
    -0.08764044f, 0.02091068f, 0.24542749f, -0.10311755f, -0.16136122f, -0.01891352f, 0.02461419f, 0.19982490f, 
    -0.16945539f, -0.03613557f, -0.04313728f, 0.09569140f, 0.00331099f, -0.02342627f, -0.09440412f, -0.00628426f, 
    0.04668426f, -0.12638949f, -0.14098473f, -0.19216585f, 0.02909328f, 0.06941579f, 0.19543757f, -0.08466044f, 
    0.01163970f, -0.00195421f, 0.14653713f, 0.07339936f, -0.00234953f, -0.04426003f, -0.01553231f, 0.19491841f, 
    0.27098760f, -0.12256124f, 0.08862934f, -0.04092237f, 0.07194668f, 0.04188030f, 0.09569865f, 0.04515006f, 
    0.01990378f, -0.08723594f, -0.04067004f, 0.00087713f, 0.52626693f, -0.03648913f, 0.01615826f, -0.04697262f, 
    0.15465212f, -0.10565761f, 0.00375447f, 0.13840447f, 0.05607753f, -0.16709045f, -0.27283156f, -0.13504013f, 
    -0.04764782f, -0.38829711f, 0.16892728f, -0.01871279f, -0.07849091f, -0.14228505f, 0.12776735f, 0.06745502f, 
    0.11454874f, 0.19224858f, 0.11145014f, 0.23894566f, 0.26689082f, 0.18947740f, 0.11754236f, 0.24041887f, 
    -0.05319182f, 0.00900668f, -0.01328759f, 0.02568115f, 0.12138217f, -0.00984500f, 0.08684457f, -0.05315971f, 
    0.01602063f, 0.08519701f, 0.06571661f, 0.06312126f, 0.07901435f, -0.04415073f, -0.09655884f, -0.09265567f, 
    -0.05391051f, -0.08138931f, -0.06641904f, -0.15014486f, 0.68266368f, -0.48900235f, 0.05636450f, 0.12629794f, 
    0.05104044f, 0.11781753f, 0.00302719f, 0.18387559f, 0.15292400f, 0.01186157f, 0.14376335f, 0.07736155f, 
    -0.20411722f, 0.03803935f, -0.01557655f, -0.08037826f, 0.06286374f, 0.04404915f, 0.05473654f, 0.08511323f, 
    -0.17337246f, -0.02046607f, 0.09933983f, -0.25186718f, -0.07095341f, -0.28144902f, 0.09277865f, 0.03266810f, 
    0.10604741f, 0.08901831f, 0.10787280f, 0.18902048f, 0.02073884f, 0.23600036f, 0.04986158f, 0.19265303f, 
    -0.05050016f, -0.03222975f, 0.02744744f, -0.00427780f, 0.04745475f, 0.05488367f, -0.02966161f, 0.01141592f, 
    -0.05153709f, -0.05809898f, -0.04593772f, 0.04327848f, -0.07112673f, 0.01788712f, -0.07731719f, -0.04440608f, 
    0.07198901f, 0.05911341f, 0.00838314f, 0.00012300f, -0.00732967f, 0.05627282f, 0.03825259f, 0.03893957f, 
    -0.00114013f, -0.05045634f, 0.06411599f, -0.06030737f, -0.07097567f, 0.02110623f, -0.06966060f, -0.06888868f, 
    -0.00632334f, -0.04227960f, -0.02518268f, -0.05101329f, -0.02727740f, -0.01222472f, -0.06109489f, 0.04162502f, 
    0.05708883f, -0.06201489f, -0.00063840f, -0.04150994f, 0.03300770f, 0.06777032f, -0.01456545f, 0.02678129f, 
    -0.02062775f, 0.04402136f, -0.04655600f, -0.01374676f, 0.03671532f, -0.00250856f, -0.00059937f, -0.00522006f, 
    0.01255352f, -0.07405666f, -0.01670604f, -0.04779892f, -0.06201045f, -0.04519276f, -0.02524430f, -0.01954217f, 
    -0.05598700f, -0.03180120f, -0.03568731f, -0.00435170f, 0.05970388f, 0.05995069f, -0.04279798f, -0.07439039f, 
    -0.07324526f, -0.05121904f, -0.06610237f, 0.06188667f, 0.00655276f, -0.05055835f, -0.02194276f, 0.05853769f, 
    -0.06928430f, -0.02306688f, 0.00642255f, -0.03349548f, 0.03989508f, 0.02344048f, -0.05211256f, 0.00249962f, 
    0.01680859f, -0.02576633f, 0.00565442f, -0.02684529f, 0.03817165f, -0.01889477f, 0.02596672f, -0.06161531f, 
    0.00845685f, -0.03108057f, 0.00815634f, 0.00757072f, -0.00367329f, -0.05312387f, 0.03753895f, -0.03468969f, 
    0.00438721f, -0.07042187f, -0.03878254f, -0.05541282f, 0.01347349f, -0.00067923f, 0.04486608f, -0.06642521f, 
    -0.02534454f, 0.01036793f, 0.04526821f, -0.07455861f, -0.02226021f, -0.03065526f, -0.04282160f, -0.03976313f, 
    -0.02428612f, 0.05938406f, -0.07142356f, 0.02457362f, -0.04653847f, -0.02360188f, -0.01821589f, 0.02705310f, 
    0.01043503f, 0.01283919f, 0.03821414f, 0.05400456f, 0.05496146f, -0.04870576f, -0.04579187f, -0.03429991f, 
    -0.01500289f, 0.04000415f, 0.02617557f, 0.05608203f, 0.05616465f, -0.03065182f, -0.06981282f, -0.05392676f, 
    0.04858415f, -0.06107286f, 0.06242721f, 0.03747327f, -0.04725245f, 0.04495881f, 0.06426352f, -0.02044872f, 
    -0.06237478f, -0.01652164f, 0.01116021f, -0.07425390f, 0.01620522f, -0.02223768f, -0.02804564f, 0.03126395f, 
    -0.04589211f, 0.02830573f, -0.05955219f, -0.00995222f, -0.05939468f, 0.04534990f, -0.04667279f, -0.07772698f, 
    -0.00314893f, -0.06076840f, 0.05043823f, -0.04417982f, -0.03253883f, -0.06358419f, -0.07221378f, -0.02277548f, 
    0.05920121f, 0.02792547f, 0.03590140f, -0.07338959f, -0.05854977f, -0.07616612f, 0.06563619f, -0.00373304f, 
    0.06169991f, 0.00413404f, 0.00916754f, 0.04097325f, 0.01253112f, 0.03450539f, 0.02961730f, 0.01040633f, 
    -0.18248825f, -0.30125093f, -0.12972119f, -0.00218049f, -0.04282465f, 0.10105420f, -0.07398884f, -0.06284518f, 
    -0.08508249f, 0.14292546f, 0.05870704f, -0.03734415f, 0.06556592f, 0.04652998f, 0.31227982f, 0.01012644f, 
    -0.00184515f, 0.09841685f, 0.05312406f, 0.09520239f, 0.17805515f, 0.02334244f, 0.02726262f, 0.21684137f, 
    -0.12945364f, -0.13526809f, -0.06840267f, -0.09630824f, -0.11279284f, -0.18049492f, -0.15050168f, -0.21741536f, 
    0.07737759f, 0.04115363f, 0.21629445f, 0.09370439f, -0.10716513f, 0.10992897f, -0.04416469f, -0.11215428f, 
    -0.06438503f, -0.09710766f, 0.03819573f, -0.06898445f, -0.03999086f, 0.10664631f, 0.20269801f, 0.34484726f, 
    -0.18928750f, -0.18651550f, -0.16844861f, 0.09774590f, -0.10042843f, -0.26720202f, -0.09906843f, -0.08531377f, 
    0.16069672f, 0.12527488f, -0.01783679f, 0.19366439f, 0.14927126f, -0.01752175f, 0.15187155f, 0.05151396f, 
    0.05103871f, 0.05491100f, 0.23215571f, -0.08829241f, -0.08889803f, 0.16803616f, 0.14936894f, 0.14892647f, 
    0.11878216f, 0.37843314f, 0.29377851f, 0.18805982f, 0.13488001f, 0.08690741f, -0.04887929f, 0.07916216f, 
    -0.12840721f, -0.17602831f, -0.12177991f, -0.22081982f, 0.07891046f, 0.17470999f, 0.33976966f, 0.27832782f, 
    0.24153662f, 0.22107847f, 0.19611047f, 0.15247981f, -0.10474764f, -0.04535601f, -0.06734604f, 0.08961061f, 
    -0.06851736f, 0.55563110f, 0.14405420f, 0.30765459f, -0.02010746f, 0.08219639f, 0.00749131f, -0.05522608f, 
    -0.25236380f, -0.00809855f, -0.14000128f, 0.02403866f, -0.38236341f, -0.15065305f, 0.03267156f, 0.18618912f, 
    -0.05927172f, -0.03370582f, -0.13770381f, -0.18139444f, 0.17718351f, -0.02636258f, -0.09157766f, -0.04175974f, 
    -0.19418345f, 0.17107515f, -0.15234847f, -0.12062147f, 0.09000901f, 0.18040881f, 0.15884607f, 0.03884398f, 
    -0.19279288f, 0.17615174f, 0.07609790f, 0.21574619f, -0.28566530f, 0.19692537f, 0.06379459f, -0.13178428f, 
    -0.16700877f, -0.11502346f, -0.06347535f, -0.13074869f, 0.06950589f, -0.08315005f, -0.04011069f, 0.09247384f, 
    -0.11531708f, 0.01946236f, 0.13424115f, 0.13301197f, 0.07002691f, -0.10057023f, -0.18999007f, -0.10975182f, 
    -0.15401140f, 0.03776180f, -0.16607432f, 0.02638344f, 0.58227181f, 0.11643480f, 0.17144468f, 0.10328429f, 
    0.18559559f, 0.06867704f, -0.05581545f, -0.07313733f, 0.02963705f, 0.17498372f, 0.02931589f, 0.02645972f, 
    -0.00846046f, 0.45378089f, 0.32086474f, 0.01748679f, 0.05142879f, -0.05464521f, -0.04034496f, 0.14766057f, 
    -0.14516725f, -0.00174434f, -0.01088088f, 0.02660381f, 0.54569209f, 0.30386716f, -0.11176086f, 0.30936190f, 
    -0.03879096f, 0.11967486f, 0.02298124f, 0.09059005f, 0.00522059f, 0.10910968f, 0.01024731f, -0.15514030f, 
    -0.16684322f, -0.55318075f, -0.23829174f, 0.10446643f, 0.08849081f, 0.26056191f, 0.09947307f, 0.10095715f, 
    0.20333342f, 0.08502170f, 0.02654856f, -0.23171224f, 0.65440536f, -0.03085323f, 0.14726907f, -0.06881077f, 
    0.29850909f, -0.08209646f, -0.21684696f, 0.13923509f, 0.07992537f, -0.04274638f, 0.25089896f, 0.06481136f, 
    -0.16348463f, 0.10119762f, -0.13958886f, -0.04317816f, -0.07888832f, -0.07482640f, -0.10280707f, -0.04505521f, 
    -0.16893682f, -0.20095150f, -0.06311771f, -0.03400530f, -0.17438164f, 0.06226811f, 0.00786218f, -0.00968397f, 
    0.09874446f, -0.08685643f, 0.04777476f, 0.11723505f, 0.14086388f, 0.25517565f, 0.20151217f, 0.22098450f, 
    -0.26164910f, 0.09984638f, -0.02696344f, 0.08996486f, 0.02259040f, -0.10785671f, -0.17599140f, 0.08332967f, 
    0.08886890f, -0.02780568f, 0.08772174f, 0.11926880f, -0.36713928f, 0.27221742f, 0.26490995f, 0.19882165f, 
    0.07530866f, 0.23672840f, -0.16844364f, 0.13249309f, 0.19755675f, -0.02058187f, 0.14478116f, 0.06501313f, 
    -0.28536931f, 0.13532527f, 0.50866997f, 0.11648538f, -0.02873266f, -0.23058347f, -0.11289725f, -0.01503429f, 
    0.07896797f, -0.07549260f, -0.05399257f, -0.07504301f, 0.07704666f, 0.13680837f, 0.24283680f, -0.03807800f, 
    0.32022786f, 0.26942244f, 0.14914566f, -0.20073518f, 0.09376707f, 0.02764531f, 0.07563051f, 0.13669455f, 
    0.76873726f, 0.09203225f, 0.29554144f, 0.18527491f, -0.06383922f, 0.29478383f, -0.28198797f, -0.23918819f, 
    0.22403739f, 0.12110314f, -0.07466706f, 0.31801298f, -0.25846040f, 0.14454375f, 0.09756299f, -0.04444364f, 
    -0.03238183f, 0.07679421f, -0.25197411f, -0.42883959f, 0.11402179f, -0.02783456f, 0.03162364f, -0.11823950f, 
    0.12898527f, -0.33341333f, -0.16911954f, -0.17077066f, -0.10353577f, -0.08763298f, 0.34363294f, 0.05552783f, 
    0.38090664f, 0.07387867f, 0.05821028f, 0.00582846f, -0.14070871f, -0.21796601f, 0.01820636f, -0.07415009f, 
    -0.05918723f, -0.27374163f, -0.12974240f, -0.05521514f, 0.07760105f, 0.09443649f, 0.12683079f, 0.22975606f, 
    0.12360331f, -0.20535012f, -0.05379939f, 0.33612552f, 0.08716632f, 0.24532133f, -0.07732810f, -0.15944162f, 
    0.10454462f, -0.03654838f, -0.02287043f, -0.03146971f, -0.07212710f, 0.28361416f, -0.00048978f, -0.10020106f, 
    -0.11920286f, 0.11196036f, 0.11829316f, -0.17894676f, 0.04705284f, -0.16110386f, -0.08840589f, 0.20584989f, 
    -0.19390713f, 0.11132482f, 0.10617831f, 0.11428995f, 0.15754712f, -0.37279233f, -0.13107389f, 0.00687826f, 
    -0.12048021f, -0.01052134f, -0.17639573f, -0.08257035f, 0.35082573f, -0.23710831f, -0.03187646f, 0.18772106f, 
    -0.02145707f, 0.29379180f, 0.16404422f, 0.13258976f, 0.15555389f, 0.10407470f, -0.14041202f, -0.13981350f, 
    0.10021394f, -0.16940612f, -0.08430472f, 0.15661222f, -0.02449539f, -0.04964469f, -0.09147355f, -0.06406176f, 
    -0.02952698f, -0.11747597f, 0.10583052f, 0.10799139f, -0.35473144f, -0.07679870f, -0.29643771f, 0.38270691f, 
    0.16051951f, 0.12975973f, -0.01841908f, -0.10636184f, 0.05023316f, -0.03493695f, -0.05853444f, -0.06577166f, 
    -0.14310285f, -0.23430483f, 0.20615996f, -0.01161621f, 0.02332681f, 0.12188328f, -0.08379000f, -0.19358976f, 
    0.03420657f, -0.10203494f, 0.05748083f, -0.02542991f, 0.25330469f, -0.14129885f, 0.05621612f, -0.04523601f, 
    0.21883003f, 0.14980768f, -0.00884169f, 0.07226508f, 0.06988440f, 0.04094142f, -0.06194377f, -0.05360032f, 
    -0.21270223f, -0.07146243f, 0.24753354f, 0.14450845f, 0.12950683f, 0.03931186f, 0.14823128f, -0.17673963f, 
    -0.11051267f, -0.24180830f, -0.14310731f, 0.00132207f, -0.11034943f, 0.20458548f, -0.30894819f, 0.02219790f, 
    0.20071369f, 0.06293166f, 0.07725606f, 0.25862718f, 0.04328791f, -0.00989272f, 0.09832897f, 0.03279418f, 
    -0.16391015f, -0.18283246f, 0.10843987f, -0.20101158f, -0.03947692f, -0.10880608f, 0.00085621f, 0.15874837f, 
    -0.01280502f, -0.19637111f, 0.04916209f, 0.23726548f, 0.12483335f, 0.23552838f, 0.12136593f, -0.19488548f, 
    0.09331256f, 0.05757298f, 0.11249281f, 0.03845305f, -0.07804610f, -0.11132479f, 0.06729299f, 0.18217352f, 
    0.42793143f, -0.33443683f, 0.39806700f, -0.28475538f, 0.28725705f, 0.09853911f, 0.01514070f, 0.10439473f, 
    0.13909711f, 0.04540706f, -0.07172319f, 0.03134773f, 0.11234443f, -0.05305821f, -0.21961428f, -0.45005968f, 
    -0.20820168f, 0.09072717f, 0.22790655f, 0.13651221f, 0.13066825f, 0.11891708f, -0.03486852f, -0.03539439f, 
    -0.23546825f, -0.35920015f, 0.15796879f, 0.29328954f, 0.13561811f, 0.02233077f, -0.06582224f, -0.19360960f, 
    0.28194094f, -0.07729006f, 0.04865377f, -0.09788905f, 0.37654623f, -0.14009261f, 0.58353162f, 0.25479063f, 
    -0.00503942f, -0.02884352f, -0.17646159f, -0.18609920f, 0.21359637f, 0.05151923f, 0.18771976f, 0.11143988f, 
    0.29400802f, -0.04151701f, 0.16636059f, -0.03375352f, 0.16327941f, 0.08028426f, -0.00045647f, 0.20888259f, 
    -0.00667927f, 0.01025021f, 0.30776593f, -0.09141826f, -0.02317545f, -0.27298716f, -0.43107244f, -0.47082168f, 
    0.15929770f, 0.13265932f, 0.06753574f, 0.16353644f, -0.03357739f, 0.02567123f, 0.12573554f, -0.09301626f, 
    -0.03949086f, 0.23502360f, -0.19503370f, 0.17501444f, -0.07895679f, 0.18503566f, 0.05447791f, 0.04193535f, 
    -0.03221675f, 0.16955015f, 0.09014577f, 0.09442516f, -0.00993318f, -0.13557297f, 0.01166287f, -0.29024386f, 
    0.27010414f, 0.04934332f, -0.09295212f, 0.04059070f, -0.04018845f, -0.10797573f, 0.01719162f, 0.21423911f, 
    -0.01993131f, 0.35544398f, 0.21269213f, 0.17699735f, -0.16814564f, 0.02010038f, 0.03250828f, 0.01510751f, 
    0.03639315f, 0.04133985f, 0.06843330f, 0.11933113f, -0.43949300f, -0.08960947f, -0.31644222f, 0.06060989f, 
    -0.17567095f, 0.15046471f, 0.18894206f, -0.16695336f, -0.02294188f, 0.14293224f, 0.04355127f, 0.17075358f, 
    -0.08548648f, -0.19870479f, 0.01345743f, -0.08926083f, -0.39891568f, -0.21508953f, -0.21658549f, -0.08060452f, 
    0.07597709f, -0.09824411f, 0.12400343f, 0.02290211f, -0.24290241f, -0.21200638f, -0.12448984f, -0.20362516f, 
    0.03112044f, 0.01404957f, 0.12922944f, 0.00947595f, -0.01028039f, 0.02263080f, 0.06080866f, 0.08669650f, 
    -0.26260567f, -0.12228376f, -0.30367896f, 0.16137147f, -0.21524304f, -0.14783964f, -0.13034976f, -0.01146937f, 
    -0.04365558f, 0.05717679f, 0.06442969f, 0.04795491f, -0.44173434f, -0.39539641f, -0.41868013f, -0.34535182f, 
    0.04966148f, 0.05681196f, 0.13123730f, -0.23733203f, 0.13153388f, 0.09532639f, -0.03228370f, -0.02172126f, 
    0.02690316f, -0.01710429f, 0.21749899f, 0.09451182f, -0.02608785f, 0.12646160f, -0.27509600f, 0.07601928f, 
    0.08545689f, 0.06458811f, 0.03084846f, -0.06576561f, -0.23947431f, -0.03043464f, -0.02519980f, -0.22082271f, 
    -0.02418801f, 0.01613181f, 0.03895099f, -0.12437993f, -0.05872403f, -0.05181120f, 0.00918908f, 0.11242466f, 
    -0.33300188f, -0.01577368f, -0.66310257f, 0.02972043f, 0.03153331f, -0.11495624f, 0.06462730f, 0.20085986f, 
    -0.00077787f, -0.10158613f, 0.11374240f, -0.02001355f, 0.48379728f, 0.18948798f, -0.11567261f, -0.14668198f, 
    0.16739009f, -0.14991526f, 0.07748083f, -0.09585617f, 0.14253831f, 0.12009638f, 0.08986429f, 0.14807566f, 
    0.14446568f, 0.07403734f, 0.52050579f, -0.28161424f, -0.06457527f, -0.11215635f, 0.12697615f, 0.26582813f, 
    0.06685577f, 0.14597456f, 0.03514704f, -0.02251128f, -0.12428758f, 0.02128487f, 0.05589354f, 0.05270560f, 
    -0.09604857f, 0.12370139f, 0.00146782f, 0.13366787f, 0.10415404f, 0.08002528f, 0.24242352f, -0.05151055f, 
    -0.22464715f, 0.05127709f, -0.13348225f, 0.04349521f, 0.04496099f, 0.36118108f, 0.11613780f, 0.04023099f, 
    0.03206338f, 0.17761001f, 0.11421443f, 0.20340823f, 0.91320688f, 0.19834188f, 0.26174593f, -0.04045171f, 
    0.04571545f, -0.16771692f, 0.03094139f, -0.21534218f, 0.25527367f, 0.13851109f, 0.07043058f, 0.02044135f, 
    0.29625288f, -0.56228155f, 0.00759879f, -0.25370437f, 0.13557373f, 0.17721930f, -0.02623844f, 0.08375399f, 
    0.13123044f, 0.04935120f, 0.18609859f, 0.13091126f, 0.40066212f, 0.18516725f, 0.08829110f, 0.30582210f, 
    0.13438331f, -0.18179843f, 0.12587337f, 0.09910883f, 0.06393605f, 0.18172696f, -0.10119132f, -0.06435882f, 
    -0.26205057f, -0.24813400f, -0.10335834f, -0.29275873f, 0.01060181f, 0.04014807f, 0.06278453f, 0.14555208f, 
    0.11091112f, 0.04797356f, 0.02120339f, -0.03283593f, 0.55272913f, 0.13884455f, 0.32552838f, -0.21248876f, 
    0.17216712f, 0.05017332f, 0.09144029f, 0.23170626f, -0.13536231f, 0.18420155f, 0.16929254f, 0.05553366f, 
    -0.00484369f, 0.18115623f, -0.15000126f, -0.14237794f, -0.14899009f, -0.22935683f, -0.12637648f, -0.01459354f, 
    -0.31467456f, 0.00029448f, -0.06300469f, -0.06941783f, -0.20303620f, 0.10980532f, -0.19624478f, 0.11044203f, 
    -0.04637944f, -0.12216058f, 0.16093703f, -0.12123273f, -0.00668635f, 0.07012226f, 0.06194897f, 0.12715870f, 
    0.26814225f, 0.31615183f, -0.08667026f, -0.22172612f, -0.16798151f, -0.07896940f, -0.06496183f, -0.05787001f, 
    0.03105930f, -0.01383697f, -0.01884069f, 0.01248439f, 0.14054362f, -0.32970423f, 0.30742666f, -0.14030725f, 
    -0.12394946f, 0.04645181f, -0.16290574f, -0.00668786f, -0.05870814f, -0.06395923f, 0.00718219f, -0.04103497f, 
    -0.05543358f, 0.16641697f, -0.36072797f, 0.22449735f, 0.16945253f, -0.09228868f, 0.10229070f, -0.06268408f, 
    -0.11845528f, 0.13672644f, 0.08181476f, -0.12727754f, -0.08129404f, -0.26867938f, -0.25574401f, -0.00045759f, 
    -0.03447974f, -0.09114195f, -0.04944585f, -0.09925517f, 0.03650676f, 0.11800804f, -0.03191311f, 0.00601393f, 
    -0.13179162f, 0.32167703f, -0.09688581f, 0.31771752f, 0.02586273f, -0.00254356f, 0.12695807f, 0.10433605f, 
    -0.00218821f, -0.02724211f, 0.12887730f, 0.13561314f, 0.08274670f, -0.12776315f, 0.14677182f, 0.40603054f, 
    0.13641360f, -0.01926685f, -0.04246172f, 0.12109756f, -0.04211815f, -0.06817841f, -0.02553948f, -0.12945098f, 
    -0.09042167f, 0.16478583f, -0.05634097f, -0.03090665f, -0.01851806f, 0.06903260f, 0.13894293f, 0.04161102f, 
    -0.04816812f, 0.29750642f, 0.12122568f, 0.34019601f, 0.07264742f, 0.30647400f, -0.45860866f, 0.16063480f, 
    -0.06342445f, -0.04463648f, 0.16437319f, 0.15177809f, -0.00773169f, 0.14470069f, 0.10097295f, 0.07363029f, 
    -0.12768720f, 0.00560307f, -0.15708518f, 0.13185893f, -0.08448017f, -0.03853945f, -0.05722834f, -0.03574678f, 
    -0.02874795f, -0.03665818f, -0.17081633f, 0.00710091f, -0.02353898f, 0.21715900f, 0.09586345f, 0.59665310f, 
    -0.15965189f, 0.09959151f, 0.05705911f, 0.15619218f, 0.09821753f, -0.01272605f, 0.17743789f, 0.04306112f, 
    -0.25084347f, -0.10823980f, 0.12896773f, -0.01087909f, 0.11950071f, -0.05637912f, 0.13453560f, 0.02211316f, 
    -0.02726772f, -0.08521385f, 0.12234551f, -0.15131481f, -0.17372690f, 0.23748423f, 0.11087503f, 0.26543233f, 
    -0.07789855f, 0.04570696f, 0.08956888f, 0.02381256f, -0.02081498f, 0.03724932f, -0.00158559f, 0.03310240f, 
    -0.08836191f, -0.38207415f, -0.36365393f, -0.29359996f, -0.06228049f, 0.01493562f, 0.02535886f, -0.12299901f, 
    -0.12869595f, -0.06552837f, -0.20624168f, 0.15842623f, 0.08266344f, -0.02357960f, 0.34546360f, -0.31497416f, 
    0.00242570f, 0.05084530f, -0.03508203f, 0.06918564f, -0.28788781f, 0.09259547f, -0.01003684f, -0.15948306f, 
    0.22967885f, 0.24562769f, -0.03507125f, 0.09376714f, 0.01484801f, 0.03665774f, 0.07930405f, 0.08063038f, 
    0.09626182f, 0.19032370f, 0.09656698f, 0.01622442f, -0.01054996f, 0.09787768f, 0.12459397f, 0.06987480f, 
    -0.02860588f, 0.01463499f, 0.02364758f, 0.12208182f, -0.21158437f, -0.22956182f, -0.15976335f, -0.33385161f, 
    0.48099270f, 0.30161205f, 0.04923900f, 0.09404817f, -0.12105173f, -0.12248734f, -0.01990927f, -0.00644431f, 
    -0.02823664f, -0.07360075f, -0.01615444f, -0.10164529f, 0.52387488f, 0.22804144f, 0.01388005f, -0.12881549f, 
    -0.08004024f, -0.14501740f, -0.13238636f, -0.20803984f, -0.17688516f, -0.01032178f, -0.21878210f, -0.13158947f, 
    -0.13943675f, 0.04259889f, -0.13187844f, -0.04774158f, -0.17740510f, 0.04079124f, 0.15113424f, 0.06516996f, 
    -0.10699686f, 0.03143978f, 0.17990264f, 0.10783327f, 0.01148900f, -0.18689859f, 0.01914254f, 0.08855410f, 
    0.01931112f, 0.04906929f, 0.06584692f, -0.01862817f, -0.11607303f, 0.06182519f, 0.07829960f, -0.06748191f, 
    -0.32896215f, -0.08145324f, 0.17494202f, -0.09261802f, -0.09913036f, 0.02581211f, -0.08717819f, 0.18204673f, 
    -0.10865491f, -0.02708884f, 0.03304840f, 0.08535082f, 0.31073198f, -0.05842939f, -0.04075117f, 0.00389288f, 
    0.03894636f, -0.00636397f, -0.09262162f, 0.04631257f, -0.07958113f, -0.08259895f, 0.22184081f, 0.12238329f, 
    -0.12539659f, -0.13432233f, -0.05338017f, 0.09011117f, -0.03364177f, 0.08608555f, -0.12918022f, 0.22638631f, 
    -0.11505327f, 0.02209153f, 0.03193481f, -0.10170530f, 0.10776313f, -0.00317850f, 0.01029478f, 0.43461868f, 
    -0.09099958f, 0.08397604f, 0.02490249f, 0.15032043f, -0.00897409f, -0.04373398f, 0.06507661f, -0.00122476f, 
    0.10398649f, 0.11908208f, 0.06553593f, -0.03919490f, -0.07206362f, -0.09380627f, 0.13090619f, 0.05155982f, 
    0.28638077f, 0.21489708f, 0.09120115f, 0.06866144f, 0.16089842f, -0.33173528f, -0.57610458f, 0.06213177f, 
    0.18903981f, -0.02923603f, 0.21414846f, 0.17200811f, -0.05065934f, 0.06278970f, 0.10053851f, -0.09251413f, 
    -0.33351144f, 0.00067258f, 0.07029628f, 0.10449385f, 0.01039241f, 0.10114913f, 0.27530482f, -0.16688442f, 
    0.11294476f, 0.09395053f, 0.31078994f, 0.07811590f, -0.40300849f, -0.12863730f, 0.26954928f, 0.06798318f, 
    0.06726842f, 0.15325503f, 0.14408205f, 0.05469884f, 0.09699511f, 0.02085509f, 0.03289111f, 0.14317438f, 
    -0.07905609f, -0.01354520f, -0.03608322f, -0.00722934f, -0.04073974f, 0.01769616f, -0.01016080f, 0.01102721f, 
    -0.06333815f, -0.00353012f, 0.02798801f, -0.03058234f, -0.01903112f, -0.03767641f, -0.07360665f, -0.10090186f, 
    -0.01681065f, -0.06929241f, -0.04138232f, -0.06717173f, -0.00551645f, -0.02122814f, 0.03226600f, 0.03256118f, 
    -0.05639279f, -0.05918005f, -0.00939011f, 0.04183456f, 0.01853609f, -0.01955973f, -0.05451846f, -0.00450619f, 
    0.04470676f, 0.00129845f, -0.05910884f, 0.01321525f, -0.05303358f, -0.02640685f, -0.07468747f, -0.04640013f, 
    -0.01335979f, -0.07932237f, 0.04669148f, -0.07783381f, -0.05515160f, -0.06286124f, -0.06591881f, 0.02144490f, 
    0.06310837f, -0.04033536f, 0.00872598f, -0.05719071f, -0.00449203f, -0.01594280f, 0.06758869f, -0.08938871f, 
    -0.04979208f, -0.06826890f, -0.08854214f, -0.02424752f, -0.05964775f, -0.00394105f, -0.00730725f, -0.08399400f, 
    -0.02996384f, 0.00239842f, -0.07595413f, -0.05651730f, 0.01491027f, -0.08331893f, -0.06483360f, 0.00703628f, 
    0.03493923f, -0.09305397f, -0.04492449f, -0.06054122f, -0.00347718f, 0.00249923f, -0.02056380f, -0.06546593f, 
    0.01292478f, -0.04225200f, -0.06530619f, 0.03277940f, -0.03327268f, -0.02768397f, 0.02505300f, 0.04257199f, 
    -0.02769724f, -0.03131904f, -0.02627953f, 0.03525620f, -0.05108666f, 0.01989783f, -0.08998799f, -0.02007322f, 
    -0.01013797f, -0.04875603f, -0.09099086f, 0.00424686f, -0.06821436f, -0.03437731f, -0.08064530f, -0.06818614f, 
    -0.05957037f, -0.08275086f, -0.09877652f, -0.07932061f, 0.00332909f, 0.04345672f, -0.07873008f, 0.00730782f, 
    -0.03294939f, 0.00912464f, 0.02645121f, -0.07047438f, -0.01634147f, 0.00011959f, -0.03349763f, 0.01828136f, 
    -0.06049932f, 0.01952573f, -0.05935989f, -0.09153175f, 0.03292726f, -0.06873685f, -0.00882587f, -0.01611046f, 
    -0.10262843f, 0.00591500f, -0.06948476f, -0.04413789f, 0.07650714f, -0.03602129f, -0.00757432f, 0.04487535f, 
    -0.02826940f, -0.02110246f, 0.01948299f, -0.07622921f, -0.09686157f, -0.07523044f, -0.06562608f, -0.05850988f, 
    -0.03181508f, -0.02905350f, 0.02856000f, -0.02177566f, -0.06309020f, 0.00498347f, -0.05020658f, -0.03460281f, 
    -0.05681873f, -0.04111329f, -0.05958953f, -0.06018981f, 0.00137510f, -0.04387546f, 0.04711004f, -0.00028838f, 
    0.02362147f, 0.03827439f, -0.03410026f, -0.01011993f, -0.05165663f, -0.01702332f, 0.01725733f, 0.02919721f, 
    -0.04539194f, 0.01036563f, -0.04210417f, -0.08417785f, -0.04146410f, 0.01690806f, 0.00716903f, -0.04932131f, 
    0.01925824f, 0.00043592f, -0.05946380f, -0.04127619f, -0.07801688f, 0.02549056f, 0.02763042f, 0.03833012f, 
    -0.01878766f, -0.01684169f, 0.03126343f, -0.06542120f, -0.02970547f, -0.05499041f, -0.10291144f, -0.03741162f, 
    0.17121787f, -0.25473601f, -0.48611662f, -0.05553454f, 0.12076825f, 0.09628409f, -0.00854835f, -0.26479429f, 
    0.10286018f, 0.06169667f, 0.00673397f, -0.04754939f, 0.28377664f, -0.19288421f, -0.00094853f, -0.00389340f, 
    -0.07966968f, -0.24084565f, -0.07334828f, 0.11047225f, -0.00133136f, 0.06797237f, -0.06986023f, -0.05467741f, 
    0.20746882f, 0.22845182f, 0.19551225f, 0.26358747f, -0.31814906f, -0.32034945f, 0.07394068f, -0.29641831f, 
    0.01962038f, -0.02000043f, 0.01613406f, -0.02534341f, 0.03902354f, -0.27836379f, 0.16296470f, -0.22923763f, 
    -0.06756293f, 0.09553348f, -0.09913271f, 0.05632917f, -0.09279813f, -0.10307784f, 0.11472036f, 0.13688938f, 
    0.10430294f, 0.16544977f, 0.12013546f, -0.19133478f, -0.19277434f, -0.42013630f, -0.14899215f, -0.11523092f, 
    0.02789234f, -0.09438386f, 0.12328245f, 0.02362860f, -0.06778593f, -0.10881866f, 0.23792800f, 0.36402357f, 
    0.03962215f, 0.02296053f, 0.04237099f, 0.15509085f, 0.11924113f, -0.02322780f, -0.11810054f, 0.00401877f, 
    0.37654918f, 0.04568582f, 0.01971653f, -0.14246918f, 0.09635667f, 0.09214292f, -0.03916454f, 0.11538015f, 
    0.01814482f, 0.02892914f, 0.08893158f, 0.01503518f, -0.00861234f, -0.15108840f, -0.11098079f, 0.12228489f, 
    0.20773844f, 0.17603385f, 0.12622689f, 0.01627014f, 0.09894279f, 0.06993112f, 0.08054971f, -0.05854125f, 
    -0.18387941f, 0.21748361f, -0.15425603f, 0.27626002f, -0.02908304f, 0.01172428f, 0.11890405f, -0.06892699f, 
    -0.07038289f, 0.13525888f, 0.02924487f, 0.02780871f, -0.41509202f, -0.17759457f, 0.19178909f, 0.26277184f, 
    -0.19050194f, 0.10085358f, 0.11073447f, -0.11731790f, -0.00196884f, -0.01472189f, 0.07325976f, -0.06669134f, 
    0.29114404f, 0.26836815f, -0.32738182f, -0.51034057f, 0.00395933f, 0.11388415f, -0.15519726f, 0.21331523f, 
    -0.02536690f, -0.03748725f, -0.01395337f, -0.06011133f, 0.16443296f, -0.07067767f, 0.33175015f, -0.35083500f, 
    0.02273527f, -0.08858054f, -0.10878174f, -0.39605367f, -0.06238399f, 0.08386604f, 0.10101453f, -0.09012959f, 
    -0.27689999f, -0.28919259f, -0.12569131f, 0.18888612f, 0.07727224f, -0.01323492f, 0.09045231f, 0.11576083f, 
    0.04370113f, -0.05294590f, -0.12539348f, 0.10859494f, -0.23731643f, -0.01063466f, -0.00612785f, 0.07668349f, 
    0.04935532f, -0.09030349f, 0.22444189f, 0.01299665f, -0.02988596f, 0.03639738f, -0.12203734f, 0.03819400f, 
    -0.17157786f, 0.00998976f, 0.31886229f, 0.17266387f, 0.03619673f, 0.03421626f, 0.18075325f, 0.12183642f, 
    -0.00027529f, 0.24170384f, 0.08756346f, 0.04610318f, 0.13059622f, 0.36497679f, -0.08393683f, 0.01447836f, 
    0.09914896f, 0.00639444f, 0.20907325f, -0.02908691f, 0.00723464f, -0.14653324f, -0.05951366f, -0.04332700f, 
    0.13302587f, -0.07017908f, -0.11355820f, -0.35397345f, -0.08576488f, 0.04096248f, 0.05404780f, -0.12092696f, 
    0.13158566f, 0.09359231f, -0.02409287f, -0.24630390f, 0.09973194f, 0.14462601f, 0.49037293f, 0.06419940f, 
    0.31265670f, 0.30635384f, 0.03571508f, -0.14593990f, -0.10851005f, -0.05103935f, -0.07439782f, 0.13809659f, 
    0.16854253f, 0.23793657f, 0.01448810f, 0.02199061f, -0.04100562f, -0.03683843f, 0.00992503f, -0.11176484f, 
    -0.04463146f, 0.21194503f, 0.17317733f, 0.17473014f, -0.09826571f, 0.16217020f, -0.04993901f, 0.06326795f, 
    -0.06429855f, 0.18102416f, 0.22594076f, 0.06304295f, -0.15615325f, 0.09683950f, 0.10945760f, 0.07595053f, 
    0.23890412f, 0.18278195f, 0.09604348f, -0.07010607f, -0.04968365f, -0.02006227f, 0.03293455f, -0.02563342f, 
    0.07629742f, 0.04416240f, 0.05575445f, -0.09931494f, 0.10468052f, 0.01269216f, 0.03399844f, -0.13849474f, 
    -0.05855654f, 0.03067748f, 0.03520219f, -0.08325914f, -0.14920469f, -0.01752322f, -0.00198782f, -0.09926145f, 
    0.17842855f, 0.29522875f, -0.17307091f, 0.13126922f, 0.19589701f, 0.00851126f, 0.04896941f, 0.07623935f, 
    -0.09502354f, 0.04371703f, -0.11818123f, -0.19883621f, -0.05353472f, -0.06134402f, -0.15750310f, 0.05556661f, 
    -0.02408313f, 0.02412404f, -0.00975780f, 0.20581675f, -0.08958375f, 0.01668387f, -0.08746801f, -0.05521594f, 
    -0.02195488f, 0.23141025f, -0.10915165f, 0.12684897f, -0.02598049f, 0.05023515f, 0.15617105f, 0.08108814f, 
    0.05436159f, 0.00414293f, -0.12819673f, -0.05108249f, -0.16632044f, -0.27385396f, 0.25909650f, 0.17662750f, 
    -0.01731296f, -0.00583779f, 0.15264663f, 0.26180503f, -0.03131292f, -0.03836513f, -0.10776932f, 0.03454707f, 
    0.06106744f, 0.36693156f, 0.00290733f, 0.02809338f, 0.06590299f, 0.18077834f, 0.29959983f, -0.03514210f, 
    -0.28998134f, 0.40103489f, 0.11559928f, 0.04598946f, 0.12725560f, 0.26090807f, -0.06871292f, 0.10113957f, 
    0.08539381f, 0.08610133f, 0.00706282f, -0.08017397f, 0.01431295f, 0.01261596f, 0.20618127f, 0.16704080f, 
    -0.27753466f, -0.09903144f, -0.02351362f, -0.13801214f, 0.17042364f, -0.17713462f, 0.01686446f, -0.00456726f, 
    -0.06266609f, -0.13648784f, -0.29097727f, -0.17439772f, 0.21268998f, -0.08914763f, 0.05900841f, 0.30661762f, 
    -0.09398899f, 0.04435438f, 0.30205223f, 0.37580425f, 0.03378850f, -0.05699926f, 0.03850758f, 0.12429867f, 
    -0.29459855f, 0.01008426f, 0.02281361f, -0.15512925f, 0.31786862f, 0.12806280f, 0.10695713f, 0.22984540f, 
    0.15790863f, -0.13302372f, 0.06289765f, 0.15078993f, -0.14017911f, 0.04749257f, 0.09329661f, 0.06935271f, 
    -0.09820856f, 0.22099023f, 0.25822124f, 0.16779082f, 0.02061002f, 0.04664163f, 0.02093630f, -0.08730311f, 
    -0.05188706f, -0.05213895f, -0.01931235f, -0.05131751f, 0.04018588f, -0.03921066f, 0.00849115f, 0.03162729f, 
    -0.06581237f, -0.04308697f, -0.00305712f, -0.01003387f, -0.01292267f, -0.01637179f, 0.01202681f, 0.05538930f, 
    -0.00659377f, -0.05201330f, 0.02447770f, 0.02037283f, -0.07565832f, -0.05586459f, -0.00364637f, -0.00858494f, 
    -0.05792752f, -0.04887145f, -0.02879798f, 0.01699421f, -0.05988294f, -0.07218151f, -0.01376555f, -0.03826886f, 
    -0.02602783f, 0.03553853f, 0.05268525f, -0.00993711f, 0.05280458f, -0.05928657f, 0.05961882f, -0.06862764f, 
    -0.01772287f, 0.02263119f, -0.06034305f, -0.01821795f, -0.02197465f, 0.03611903f, 0.01600174f, 0.01437411f, 
    0.04176318f, -0.00054651f, 0.01012347f, 0.02484883f, -0.03518296f, -0.02915660f, 0.03576866f, -0.05281517f, 
    -0.00937956f, -0.02588170f, 0.00013554f, 0.04427019f, -0.05753351f, -0.05265274f, -0.04794136f, -0.00781028f, 
    0.03772373f, 0.02974915f, -0.03304765f, -0.06623735f, -0.00065722f, -0.04038369f, -0.06801966f, -0.05357719f, 
    0.01224918f, 0.04876180f, -0.01616501f, -0.03663208f, -0.06634840f, -0.06122971f, -0.04138240f, -0.05530062f, 
    0.01502059f, -0.04017184f, -0.00958457f, -0.03227792f, -0.01086082f, -0.02756966f, -0.00801668f, -0.01919294f, 
    0.05069003f, 0.00000629f, 0.04172631f, -0.01453449f, -0.02581335f, 0.03371540f, 0.05521152f, 0.03046839f, 
    -0.02696235f, -0.00149897f, 0.00878301f, -0.04161412f, 0.02332975f, -0.02660586f, 0.01288764f, -0.06185839f, 
    -0.01015351f, -0.06267681f, 0.01530605f, -0.07294895f, -0.01849171f, -0.04545123f, -0.02522154f, 0.00681219f, 
    -0.04297521f, -0.04352102f, -0.02632348f, 0.03764104f, -0.01100800f, -0.07015785f, 0.01579487f, 0.01652594f, 
    -0.04447344f, 0.03613450f, -0.04941176f, -0.04582776f, 0.05327407f, 0.00024544f, -0.02915029f, 0.06177303f, 
    -0.01365557f, -0.05696179f, -0.07747953f, -0.01117293f, 0.01331661f, 0.00114326f, 0.01023517f, -0.00717954f, 
    -0.04448192f, -0.03850111f, -0.04127284f, 0.03411494f, -0.01948622f, -0.01611293f, 0.04794390f, -0.00945144f, 
    -0.04545838f, 0.00560260f, -0.04316546f, 0.01248608f, -0.04507944f, 0.01313615f, 0.04082337f, 0.05766585f, 
    -0.05719913f, -0.07852600f, -0.05949412f, -0.02126746f, 0.00422427f, -0.07678279f, -0.02247124f, 0.00828118f, 
    -0.07375526f, -0.06410384f, -0.04991834f, 0.01376226f, -0.01077871f, 0.05834815f, 0.01079267f, -0.07572667f, 
    -0.07089304f, -0.06635480f, 0.04625737f, -0.02741471f, -0.07771549f, -0.06326852f, 0.06007656f, 0.06415576f, 
    0.06238963f, -0.05806000f, -0.01287082f, 0.05431752f, -0.00593293f, 0.01454623f, -0.07096203f, 0.00847063f, 
    0.04118724f, 0.02374417f, -0.01710431f, -0.02849722f, 0.04488719f, 0.02294911f, -0.01063585f, -0.06619474f, 
    -0.10940766f, 0.28156143f, 0.20278746f, 0.09167755f, -0.00683423f, -0.18061964f, 0.07043198f, 0.18054752f, 
    0.05711601f, 0.12411810f, 0.10137805f, -0.00227883f, 0.73098916f, -0.03849413f, -0.00719654f, -0.11667712f, 
    -0.01283105f, 0.11604474f, 0.07185335f, 0.10531170f, -0.07949784f, -0.05323121f, 0.14854504f, -0.04421680f, 
    -0.11189736f, 0.01809905f, -0.25987029f, -0.25533363f, -0.05826795f, 0.00165957f, 0.07357120f, 0.14395748f, 
    -0.18727852f, 0.12349749f, 0.10158592f, 0.09213853f, 0.09761055f, -0.18637241f, -0.08607983f, 0.19721204f, 
    0.03935212f, -0.01150541f, 0.02436225f, -0.03164965f, 0.12504750f, -0.05945588f, -0.08899993f, 0.01805514f, 
    0.17653310f, 0.11428117f, 0.01827483f, -0.19580230f, 0.00710966f, -0.05986587f, 0.08642986f, -0.03171498f, 
    -0.07912540f, -0.05908534f, -0.10715340f, -0.10012584f, 0.03040931f, -0.23190702f, 0.28552756f, 0.12495925f, 
    0.06685010f, 0.09324858f, -0.23545703f, 0.12971494f, 0.01132698f, -0.16538751f, 0.02233289f, -0.20614043f, 
    -0.23549114f, -0.16479917f, -0.02268268f, 0.23830731f, -0.00898978f, 0.04089421f, 0.19933923f, -0.01774742f, 
    -0.11463913f, 0.07153203f, 0.12872493f, 0.27709725f, -0.30715448f, -0.34408787f, -0.18930922f, -0.01222002f, 
    -0.19218220f, -0.13678916f, -0.13942979f, 0.11579109f, -0.02797974f, 0.07736484f, -0.02522617f, -0.13495795f, 
    -0.29373977f, -0.00650259f, 0.12262819f, 0.27092716f, 0.12327708f, 0.16948508f, 0.13001898f, 0.13931990f, 
    0.16673684f, 0.13497627f, 0.09595386f, 0.04401168f, -0.23212317f, 0.25246704f, 0.23581649f, 0.12134953f, 
    -0.07384771f, 0.02247635f, 0.11071958f, 0.20953453f, 0.05766216f, 0.16432363f, 0.14000480f, 0.09619344f, 
    -0.04485769f, 0.30185992f, -0.08133852f, 0.22722696f, 0.17548023f, 0.14398400f, -0.25480819f, -0.16454311f, 
    0.03427289f, -0.04744191f, 0.11718757f, -0.12158725f, 0.02578392f, 0.22854580f, -0.16620126f, 0.04792792f, 
    0.06405309f, 0.09319962f, 0.11221593f, 0.13935933f, -0.11824431f, 0.14863861f, 0.04037642f, 0.16118580f, 
    -0.12909098f, -0.10437598f, -0.19627139f, -0.01140669f, 0.07773548f, 0.02696171f, 0.20514919f, 0.13991463f, 
    0.09487308f, 0.13044724f, -0.00208796f, 0.02190781f, -1.06068110f, 0.68962991f, 0.33220109f, 0.16613141f, 
    0.05439113f, 0.15313220f, 0.18940651f, 0.16430607f, -0.17100868f, 0.07631244f, 0.07271659f, 0.02437284f, 
    0.15966506f, -0.10544828f, -0.08883022f, 0.33291909f, 0.07594938f, 0.12951653f, 0.15076053f, -0.08326069f, 
    0.18597968f, -0.00657978f, -0.04233967f, 0.23554695f, -0.20685491f, 0.18310720f, 0.06336189f, 0.06642678f, 
    -0.01726972f, 0.04648033f, -0.04266048f, 0.01466134f, -0.01460178f, 0.13610816f, -0.09015431f, -0.13308962f, 
    0.00442536f, 0.02927709f, 0.03029868f, -0.05335927f, -0.01203045f, -0.04016243f, -0.04788029f, 0.04930037f, 
    0.03017347f, -0.03239698f, -0.07702062f, -0.06558690f, -0.07927036f, -0.06846171f, -0.00763898f, 0.04847633f, 
    -0.03241913f, 0.05418668f, 0.05332319f, -0.01805897f, 0.04623243f, 0.02857354f, 0.03356536f, 0.03952885f, 
    0.04972548f, 0.03043074f, -0.03472299f, -0.02440774f, 0.04358571f, 0.00556954f, 0.05719048f, -0.06476102f, 
    -0.00210137f, -0.01812453f, 0.03597854f, 0.00217598f, 0.00898858f, -0.07582876f, 0.00009680f, 0.04397551f, 
    -0.01124550f, -0.05138190f, -0.05735540f, -0.03946546f, 0.00097847f, 0.01164150f, 0.01926733f, 0.06111071f, 
    -0.04323195f, 0.04463891f, 0.02777915f, -0.06818368f, -0.00770173f, 0.02349168f, 0.04409430f, -0.04084344f, 
    -0.08292573f, -0.00382761f, -0.03808370f, -0.05386613f, -0.05975447f, -0.06672660f, -0.05911471f, 0.02605624f, 
    0.02353515f, -0.06651706f, 0.00379893f, -0.06515507f, 0.01934815f, -0.07204073f, -0.03011592f, -0.01878351f, 
    0.04309542f, -0.05467188f, -0.07044920f, -0.01972141f, -0.00516034f, 0.03838118f, -0.02303708f, -0.01681314f, 
    -0.01993802f, -0.04001340f, -0.04872864f, -0.02507805f, -0.06069462f, -0.06759947f, -0.00594070f, -0.03563336f, 
    0.01595402f, 0.03790449f, -0.04977590f, -0.04376153f, -0.00548350f, 0.04595589f, -0.00512126f, -0.00904303f, 
    -0.04101138f, -0.07202542f, 0.05474158f, -0.00181900f, -0.04750440f, -0.00752666f, -0.07642286f, -0.00847213f, 
    -0.02664360f, 0.01224808f, 0.02029487f, -0.00468975f, -0.06098123f, 0.02136249f, -0.01293409f, -0.07844301f, 
    -0.05985777f, -0.02724840f, -0.02796602f, -0.07292740f, -0.07725076f, -0.04093310f, 0.03234506f, 0.05804127f, 
    -0.04545929f, -0.08324629f, -0.03934956f, -0.02302993f, -0.08537646f, 0.03848913f, -0.08027571f, -0.00508286f, 
    -0.04535664f, 0.04381477f, -0.07934695f, 0.00668205f, 0.01532027f, -0.05080186f, -0.04777834f, -0.02792185f, 
    0.01987904f, 0.03783206f, -0.07105625f, -0.05504172f, 0.02699366f, -0.05630128f, 0.01980971f, 0.04571383f, 
    -0.04318320f, -0.06766460f, -0.04703014f, -0.06291357f, -0.07374220f, 0.02773415f, 0.02718328f, 0.04159078f, 
    -0.01658989f, -0.06549530f, -0.02980464f, 0.00789245f, 0.05095341f, 0.04794102f, 0.01873344f, 0.02530109f, 
    0.04626851f, 0.03351826f, 0.02499415f, 0.05995979f, 0.03957936f, -0.07311489f, -0.05560854f, -0.06664477f, 
    -0.03128660f, 0.01774059f, -0.00590030f, 0.03018350f, -0.03005718f, 0.00517784f, 0.05749573f, 0.01875161f, 
    -0.03468408f, 0.04850034f, -0.02977120f, 0.05607593f, -0.04615220f, -0.02075837f, 0.04864229f, 0.05110013f, 
    0.04372089f, 0.02297785f, 0.05365029f, -0.03035738f, -0.06655850f, -0.03994801f, 0.04314392f, -0.01497142f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00893100f, -0.04780997f, 0.18372716f, 0.24520747f, 0.01393929f, 0.03163762f, 0.05956170f, 0.03872646f, 
    0.02483670f, 0.03689000f, -0.06821530f, 0.19791846f, -0.02417784f, 0.07710145f, 0.06530948f, -0.19726719f, 
    0.17247599f, -0.10672692f, 0.19564693f, -0.05321629f, 0.10810532f, 0.07150952f, 0.19520871f, 0.21504076f, 
    0.16276705f, 0.08836714f, -0.05321186f, -0.10268069f, 0.11185742f, 0.06487909f, 0.16615629f, -0.04594809f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15191209f, -0.46775034f, 0.12514447f, 0.24297537f, 0.12035248f, -0.18684323f, -0.14334898f, -0.09302948f, 
    0.00796290f, 0.04097929f, 0.12992093f, -0.23924948f, -0.10703319f, -0.00220599f, 0.17908792f, -0.47794670f, 
    0.53491795f, -0.08467668f, 0.26769540f, 0.14431103f, 0.28602138f, 0.18982032f, -0.03018628f, -0.08208455f, 
    0.41256309f, -0.11025960f, -0.10328378f, -0.35438910f, 0.10782398f, 0.17582563f, 0.19265214f, 0.03243025f, 
    -0.60915577f, 0.13946354f, 0.15199932f, -0.30008885f, -0.05871018f, 0.32469001f, -0.37042579f, -0.12568231f, 
    -0.16412058f, 0.20897742f, 0.11925375f, -0.20406254f, -0.06847833f, 0.11316034f, 0.16134426f, 0.16989827f, 
    0.01281446f, 0.20526987f, 0.24084449f, 0.01669215f, 0.25119734f, -0.14072956f, -0.19049108f, 0.09089281f, 
    0.09782992f, 0.25152722f, -0.13818483f, 0.03529743f, 0.23688205f, -0.10753346f, -0.39343423f, -0.01692221f, 
    0.42607778f, -0.36220840f, -0.30722305f, 0.38067716f, 0.10111294f, -0.08192976f, 0.14520156f, 0.08552080f, 
    0.14322700f, -0.24228497f, -0.05280800f, 0.49019623f, 0.00824008f, -0.11130084f, -0.01596264f, -0.33370471f, 
    -0.33694786f, 0.01484334f, 0.23439129f, 0.09901417f, 0.03129699f, 0.00366742f, 0.47419047f, 0.24951363f, 
    -0.19812483f, -0.43066385f, 0.10861856f, -0.34389096f, -0.00474435f, -0.03488905f, 0.22149776f, 0.09122440f, 
    -0.55613589f, -0.03039444f, 0.33598509f, -0.20670584f, -0.17250612f, 0.16161868f, -0.02167075f, 0.03496930f, 
    0.03241043f, 0.19148277f, -0.35731873f, -0.07269713f, 0.11233396f, 0.28622282f, -0.22756132f, -0.45734328f, 
    0.29685014f, -0.06321697f, 0.13181449f, -0.12321885f, 0.09247960f, 0.12976269f, 0.15484039f, -0.09344149f, 
    0.35851088f, -0.00097910f, 0.12347114f, -0.09737746f, 0.24141407f, 0.12974346f, -0.15546088f, 0.08771379f, 
    0.26344639f, 0.38699213f, 0.29631400f, 0.03000199f, -0.00075346f, 0.16394445f, 0.16626498f, -0.01578188f, 
    -0.04687448f, -0.41044542f, -0.22800800f, -0.03861615f, 0.01304586f, 0.09524980f, 0.30507886f, -0.13820748f, 
    -0.01997439f, 0.40788639f, -0.24824034f, -0.12288763f, -0.13633718f, -0.24164174f, 0.19744985f, 0.41882509f, 
    -0.07123316f, -0.19906552f, -0.08461539f, -0.32139713f, 0.25431806f, 0.03724090f, 0.51739287f, 0.11806098f, 
    -0.01041384f, -0.19869687f, -0.03158430f, -0.19328246f, 0.00930012f, -0.17175893f, 0.01939384f, 0.07890933f, 
    -0.00002678f, -0.18259765f, 0.04417906f, 0.03796788f, 0.02501226f, -0.06665339f, 0.05448506f, -0.01766696f, 
    -0.11059427f, 0.07629760f, -0.07087497f, -0.01094598f, 0.05794482f, -0.12299118f, 0.00372529f, 0.06185934f, 
    -0.11983719f, 0.03977320f, 0.11127035f, -0.19204883f, -0.11989078f, 0.09350272f, 0.04414472f, -0.04888638f, 
    0.53787827f, -0.03310679f, 0.27029836f, 0.27986676f, -0.17576361f, -0.03471383f, 0.22693844f, -0.07512547f, 
    -0.07769752f, -0.08606128f, 0.02533435f, 0.08340921f, 0.08881553f, -0.51525074f, 0.29186618f, 0.01806569f, 
    -0.13241585f, -0.06212423f, 0.07122353f, -0.11658704f, -0.25307384f, -0.47038233f, 0.07795557f, 0.46348539f, 
    -0.24157113f, -0.16052446f, 0.17359525f, 0.00747755f, 0.00411295f, 0.11870540f, 0.17793670f, -0.01617767f, 
    -0.18885487f, 0.29852277f, -0.08627019f, 0.23693007f, -0.10946620f, 0.12304507f, -0.27471054f, -0.10212698f, 
    0.09610508f, -0.16055599f, 0.34221515f, -0.08388372f, -0.08619883f, 0.13293178f, -0.20080294f, 0.01968203f, 
    -0.41752878f, 0.17550902f, 0.54740131f, 0.08598179f, 0.24735202f, -0.11498272f, 0.03173719f, 0.01407646f, 
    0.16591614f, 0.21835059f, -0.13343526f, -0.40652654f, 0.19717439f, -0.08574361f, -0.30980727f, 0.02679665f, 
    0.01541669f, 0.03897490f, -0.51182401f, 0.01314289f, -0.15613127f, -0.16630606f, -0.14866377f, 0.10581017f, 
    -0.04346929f, 0.20758247f, 0.04898498f, -0.02375321f, 0.08682341f, -0.03266830f, -0.14706717f, 0.13455907f, 
    0.35450625f, -0.01363047f, 0.27422136f, -0.14908034f, 0.04073717f, -0.16393459f, -0.72636014f, -0.05664717f, 
    -0.21355987f, -0.14518651f, 0.17470072f, -0.20527345f, -0.05516736f, -0.08541568f, 0.26265913f, 0.16215624f, 
    -0.05089995f, -0.12940840f, 0.11465230f, -0.15946369f, -0.12207521f, -0.16223423f, -0.09414510f, -0.01677763f, 
    -0.00020292f, -0.08951931f, 0.10874277f, -0.13167340f, -0.02473097f, 0.06374022f, -0.01125721f, -0.12818521f, 
    0.04417576f, -0.08304756f, -0.01262612f, -0.15285030f, -0.10978832f, 0.09988112f, -0.09136415f, -0.10359821f, 
    0.06889126f, 0.08232734f, -0.08090199f, 0.05836280f, -0.15572175f, 0.09336650f, -0.14371036f, -0.14868605f, 
    -0.44564334f, -0.44540453f, 0.10779645f, -0.11632386f, -0.14877388f, 0.26798904f, -0.32875401f, 0.05328645f, 
    -0.06072803f, -0.02519092f, 0.35469273f, 0.00605212f, -0.10067390f, 0.32249224f, 0.17324427f, 0.02324842f, 
    -0.25507632f, -0.05508217f, 0.35612351f, -0.15695326f, 0.08400679f, -0.45514444f, -0.11201105f, 0.34828100f, 
    0.27452353f, 0.51407635f, 0.10576569f, 0.15162812f, 0.21705423f, -0.15879090f, -0.14635694f, -0.09521642f, 
    0.35509282f, 0.24122538f, -0.17670761f, 0.07654319f, -0.04780237f, -0.08635261f, 0.12465730f, -0.11086868f, 
    0.06629012f, 0.25718486f, 0.22474977f, -0.00959665f, 0.01322637f, -0.26744273f, 0.52806014f, -0.17243761f, 
    0.23749277f, 0.04028951f, -0.24002624f, 0.11879765f, 0.04190645f, -0.19073461f, -0.19459872f, -0.01931118f, 
    0.32022843f, -0.06459264f, 0.01496322f, -0.34409165f, 0.08371241f, 0.09838355f, 0.54622608f, -0.12192997f, 
    -0.07071685f, -0.37154520f, -0.31855047f, 0.08945189f, 0.11974401f, -0.01141918f, -0.04011447f, 0.07852957f, 
    0.02537609f, -0.10880961f, -0.46288520f, 0.36990097f, -0.11161885f, 0.31185794f, -0.11086694f, -0.43505394f, 
    -0.13831317f, 0.38976014f, -0.00922785f, -0.15766661f, 0.23125707f, -0.00147095f, -0.00771763f, -0.35113817f, 
    0.55223805f, -0.11263367f, 0.12831971f, 0.24115743f, 0.05934195f, 0.00010020f, 0.29563820f, 0.00764850f, 
    -0.19341217f, 0.10920560f, -0.05833877f, 0.21411061f, 0.06004223f, 0.16206890f, -0.00020352f, -0.10867853f, 
    0.09016058f, -0.21188530f, 0.15970008f, 0.13297455f, 0.14940459f, -0.09026561f, 0.55087596f, -0.05339262f, 
    0.08824703f, -0.15460549f, 0.07437190f, -0.04289002f, -0.14505798f, 0.04054196f, 0.25810504f, -0.13869199f, 
    0.19448511f, 0.53769636f, -0.10186122f, -0.78410292f, 0.02882071f, 0.00225060f, 0.12803902f, 0.06035443f, 
    -0.47636357f, -0.18509413f, 0.02844272f, 0.02325443f, 0.06664374f, -0.04129177f, -0.00653618f, 0.15506390f, 
    -0.10066344f, 0.16314425f, -0.06695054f, -0.23594116f, 0.00524286f, 0.08878943f, -0.32812282f, -0.40193072f, 
    0.27895162f, 0.12957218f, 0.27881888f, -0.04525447f, 0.44453520f, 0.20715189f, 0.12996931f, 0.59002143f, 
    0.01692080f, -0.19921894f, -0.01105524f, 0.16978367f, 0.02343213f, 0.02718639f, -0.10481331f, -0.13283938f, 
    0.02973474f, -0.26560438f, -0.11143281f, -0.16215664f, 0.14078259f, 0.01987816f, -0.03774094f, 0.15699670f, 
    0.05121441f, 0.22394343f, -0.30501807f, 0.32982209f, -0.12047799f, -0.33525842f, 0.26517242f, -0.15358725f, 
    -0.02188133f, -0.26056224f, -0.21954411f, 0.02696589f, -0.34614268f, -0.10038392f, 0.03466014f, 0.01256691f, 
    0.33887455f, 0.34379631f, 0.00023961f, 0.18448940f, 0.05090695f, 0.02410772f, 0.29679161f, -0.05411804f, 
    0.25498134f, 0.70173848f, 0.26800096f, 0.11217976f, -0.05253659f, 0.38867241f, -0.13088553f, 0.01731601f, 
    0.03480929f, -0.10557389f, -0.11234202f, 0.12870327f, -0.10170099f, 0.15291269f, -0.29335457f, 0.15117376f, 
    -0.16051462f, 0.12371822f, 0.09319695f, -0.11284697f, 0.26499242f, -0.15657599f, 0.43406090f, -0.15519747f, 
    -0.54433668f, -0.36737046f, -0.11528971f, -0.02984113f, -0.09936894f, 0.15710156f, -0.24430048f, -0.08620273f, 
    0.45897609f, -0.16913286f, 0.11906214f, 0.03175660f, 0.07631886f, 0.19351561f, 0.09169791f, 0.05354292f, 
    -0.15012556f, -0.19383430f, 0.13424288f, -0.33781865f, 0.12192196f, 0.18318415f, 0.35605913f, -0.00763665f, 
    0.41168761f, 0.01509577f, -0.46117789f, 0.10406698f, 0.15353368f, -0.10778260f, -0.41512945f, -0.33144221f, 
    0.33273327f, 0.28748667f, 0.06161275f, 0.32042477f, 0.00104006f, 0.00064341f, 0.54574245f, -0.04736986f, 
    0.40035105f, -0.01808814f, 0.50988102f, 0.04745004f, 0.07604776f, 0.06937273f, 0.22746047f, -0.04014287f, 
    -0.01434665f, 0.13866444f, -0.22003026f, 0.08151894f, -0.02561948f, -0.21991467f, 0.04248143f, -0.02634828f, 
    0.02749609f, -0.35242820f, 0.17672567f, -0.08413951f, -0.11942805f, -0.34245116f, 0.25122616f, -0.36926121f, 
    0.11272162f, 0.45388269f, -0.01090867f, 0.37098980f, 0.11340202f, -0.16666572f, 0.22989334f, -0.10108674f, 
    0.20164441f, -0.16584770f, 0.10963623f, -0.08088273f, -0.06776849f, -0.29984638f, 0.29336271f, 0.15660147f, 
    0.10948171f, 0.32262403f, -0.36491901f, 0.24699086f, -0.11392156f, 0.11000039f, -0.22328874f, -0.04581257f, 
    -0.14272517f, -0.12280355f, 0.24636334f, -0.07861689f, -0.18583553f, -0.01706228f, 0.39694366f, -0.31012660f, 
    0.02835073f, -0.00113228f, 0.04856238f, 0.37611255f, 0.20940509f, -0.14918235f, 0.24811850f, -0.16174369f, 
    -0.24215293f, -0.04049841f, 0.53202486f, 0.21457237f, 0.04890391f, 0.32667294f, -0.40905577f, 0.10100997f, 
    0.07811458f, -0.08409345f, 0.14452673f, -0.09320150f, 0.04518950f, 0.13990638f, 0.40438738f, 0.05892008f, 
    0.27569994f, -0.10307205f, 0.22535765f, -0.13033496f, -0.10562526f, -0.19737752f, -0.12213497f, 0.08557110f, 
    0.22059825f, 0.18304946f, -0.04455223f, -0.62146747f, 0.07208778f, 0.07149366f, 0.21269991f, -0.12715386f, 
    -0.01443648f, -0.00866073f, 0.02730998f, 0.10183649f, -0.02114385f, 0.18522388f, 0.13409075f, -0.16127750f, 
    -0.10644118f, -0.32564077f, 0.31533051f, -0.29998174f, -0.12548846f, 0.41600353f, -0.20923413f, 0.10977839f, 
    -0.01430177f, 0.05553484f, -0.05700762f, 0.13179028f, 0.34775573f, 0.22116829f, 0.19257516f, 0.54185051f, 
    -0.40102759f, -0.38680035f, 0.01567380f, 0.36515549f, -0.05622423f, -0.11873657f, -0.19968927f, -0.17996988f, 
    0.26440546f, 0.26848364f, -0.27734590f, 0.25947696f, 0.17470537f, 0.30903983f, 0.02024193f, 0.08500727f, 
    -0.01306506f, -0.20463103f, 0.17752101f, 0.14633599f, -0.11586045f, -0.15659820f, 0.33695641f, 0.08234351f, 
    0.25733489f, 0.19375971f, -0.37392253f, -0.12378016f, 0.04560525f, 0.16856545f, -0.23338850f, 0.60614055f, 
    0.06605950f, -0.43776295f, 0.10769668f, -0.24873507f, -0.26606223f, -0.11086530f, 0.21964432f, -0.01804106f, 
    -0.27982420f, -0.36953413f, 0.29421532f, 0.31336954f, 0.03053459f, 0.04558338f, 0.34114698f, -0.11870185f, 
    -0.16801052f, 0.04812165f, 0.10088857f, 0.34888089f, 0.16015241f, -0.01021698f, 0.11876222f, -0.03142169f, 
    0.10888008f, -0.40166005f, 0.43416411f, 0.11306303f, 0.07236460f, 0.01136239f, 0.58328450f, 0.25739914f, 
    -0.07775943f, 0.19554214f, 0.07638676f, -0.58066750f, -0.21529704f, 0.03058487f, -0.35824624f, -0.05247846f, 
    -0.26572111f, 0.14537658f, -0.14418060f, -0.11055131f, 0.13936341f, -0.21396124f, 0.05043944f, 0.02960148f, 
    -0.16971800f, 0.40081117f, 0.09040366f, 0.03136900f, -0.12067555f, 0.22455695f, -0.29312995f, -0.18942794f, 
    -0.23603533f, 0.27097532f, 0.13071458f, -0.13727655f, 0.13160197f, 0.45624352f, -0.11676126f, -0.09831613f, 
    0.41946492f, 0.12965149f, 0.14681275f, 0.56167620f, 0.33098325f, 0.11876733f, -0.01930850f, -0.00040532f, 
    0.05321327f, 0.45146504f, 0.38369712f, -0.26314011f, -0.09131552f, 0.28666440f, 0.26272473f, -0.01318526f, 
    -0.00751310f, -0.00858525f, 0.30159724f, -0.24054568f, 0.11227843f, 0.19291721f, -0.25309217f, -0.02738885f, 
    -0.25842515f, 0.01243728f, -0.43909889f, 0.07756698f, 0.14046519f, -0.11983515f, 0.15134561f, 0.17267929f, 
    -0.29231188f, -0.03257676f, -0.10619685f, 0.37580651f, 0.03305194f, 0.07573004f, -0.12696892f, 0.08911928f, 
    -0.04941713f, -0.03011091f, 0.09779819f, 0.09868671f, -0.12438325f, -0.05383646f, 0.00764395f, -0.02741180f, 
    0.08027910f, -0.12873633f, 0.12530737f, -0.09951641f, 0.11548638f, -0.06293217f, -0.08047407f, -0.16012323f, 
    -0.07367318f, -0.12111880f, 0.02629187f, 0.01175178f, -0.16690212f, -0.04024420f, -0.14405246f, -0.17738512f, 
    0.07851855f, 0.14215715f, -0.05917565f, -0.17873490f, 0.02385247f, -0.02083921f, -0.08809405f, 0.07823145f, 
    0.04500151f, 0.07498801f, 0.15856914f, 0.18796170f, 0.00894398f, 0.01904347f, 0.27756521f, -0.01410692f, 
    -0.10799012f, -0.17825402f, 0.44484994f, -0.31287190f, -0.13575467f, 0.03279945f, 0.03403251f, -0.03811995f, 
    -0.24058652f, -0.19638512f, 0.04647932f, 0.14820151f, 0.20396851f, 0.19886734f, -0.03133808f, -0.06077669f, 
    -0.56928068f, -0.03395351f, 0.17452215f, -0.50104809f, 0.06216236f, -0.12819433f, 0.13598725f, 0.03931237f, 
    0.30331048f, -0.55298251f, -0.03359100f, 0.44005567f, 0.10855696f, -0.15549776f, 0.19297004f, 0.07295509f, 
    -0.03732314f, -0.03552826f, 0.11571420f, 0.24788846f, 0.13353817f, -0.19983917f, 0.01378175f, -0.07178474f, 
    0.25080770f, -0.08579703f, 0.16205318f, 0.14903437f, -0.06025946f, 0.23574045f, 0.05808663f, 0.26314905f, 
    0.14239323f, -0.26466414f, 0.04281459f, 0.22197314f, 0.34294555f, -0.01921153f, 0.02217625f, 0.11789748f, 
    0.18559712f, 0.44715884f, -0.07026167f, 0.22998188f, 0.14886333f, 0.08744915f, 0.41833168f, -0.05704167f, 
    0.02746916f, -0.44696528f, 0.19768615f, -0.15448664f, 0.13793422f, 0.15491262f, 0.21305519f, -0.09848055f, 
    -0.49734229f, 0.04190703f, -0.20597555f, -0.03524454f, 0.27320611f, 0.28018418f, 0.13167903f, -0.19108948f, 
    -0.17728613f, 0.50331879f, -0.00790255f, 0.69508171f, 0.05328930f, 0.08717741f, -0.10424834f, -0.01796968f, 
    0.19487460f, -0.56403941f, -0.07434177f, -0.11551426f, 0.08964435f, -0.32774064f, 0.05961598f, -0.14127795f, 
    0.09512284f, 0.15999623f, 0.20143577f, 0.01526629f, -0.10251182f, 0.04164362f, -0.10463554f, -0.17334998f, 
    0.28303501f, 0.09289156f, 0.11019296f, 0.12546547f, 0.34146699f, -0.07949810f, -0.34212592f, 0.20347232f, 
    0.38684082f, 0.05198662f, -0.12932104f, 0.73556119f, 0.16745742f, 0.10486906f, 0.02436176f, 0.13248883f, 
    0.00536385f, 0.20436510f, 0.09126222f, 0.08258536f, 0.06309114f, 0.39503640f, 0.02729566f, -0.07713206f, 
    -0.10863335f, -0.24353595f, 0.09796454f, -0.09735781f, 0.09171396f, 0.36871830f, 0.18226938f, -0.05629768f, 
    -0.35696998f, 0.03943825f, -0.07891463f, 0.12830938f, 0.27569291f, 0.14090027f, 0.24392551f, -0.42502365f, 
    -0.09918389f, 0.01955453f, -0.15962122f, -0.07997494f, -0.00292585f, -0.04289287f, 0.11304787f, 0.05397741f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20484182f, -0.21575919f, 0.16579293f, 0.14524896f, 0.27763480f, -0.08786572f, -0.09233892f, -0.08778940f, 
    -0.03923952f, -0.03696559f, -0.09969086f, 0.09414469f, -0.01144356f, 0.12802763f, 0.01118533f, -0.02073208f, 
    -0.08808345f, -0.07637953f, 0.16273263f, -0.00708082f, 0.04347890f, 0.11017087f, 0.03487458f, 0.38299891f, 
    -0.06281358f, -0.23712182f, 0.10643101f, -0.04995790f, 0.45907804f, 0.01525503f, 0.14226767f, 0.12497449f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.45832011f, 0.21804151f, -0.69225085f, 0.22621182f, 0.19554861f, -0.05909031f, -0.04616478f, 0.24709868f, 
    -0.01300367f, 0.08265445f, -0.04348145f, -0.21387468f, -0.21790831f, -0.31229788f, 0.15417573f, -0.28811470f, 
    0.31888485f, -0.26812556f, -0.63159835f, -0.62008923f, 0.00346046f, 0.24763519f, 0.00081556f, -0.30853611f, 
    0.10592730f, 0.47558430f, 0.01255996f, -0.11093747f, -0.73684061f, 0.06065304f, -0.48185393f, 0.01369187f, 
    0.11041905f, 0.30920827f, -0.49584100f, 0.19058183f, -0.59421438f, -0.01926222f, 0.02279631f, 0.21463770f, 
    -0.17188223f, -0.03619053f, 0.65853316f, -0.34409577f, -0.41941220f, -0.09257320f, 0.28874025f, 0.09033308f, 
    -0.23760585f, -0.45092905f, 0.17080115f, -0.21525361f, 0.10099484f, 0.24016263f, -0.03396624f, 0.20624685f, 
    0.16844028f, -0.03468753f, 0.16409357f, 0.05153700f, -0.03406405f, -0.16836841f, 0.17540447f, -0.16793610f, 
    0.33719152f, -0.16771239f, 0.15397148f, 0.00321250f, 0.35315293f, -0.14952423f, 0.03127944f, -1.07503128f, 
    -0.01309967f, 0.06604262f, -0.56073642f, 0.05718889f, -0.69347614f, -0.05067722f, 0.40225947f, -0.76899385f, 
    -0.27173382f, 0.34822527f, -0.20047927f, -0.34703246f, 0.31275427f, 0.16389388f, 0.16228108f, 0.00152361f, 
    -0.05572142f, -0.30429068f, 0.11449626f, -0.04475050f, 0.17255922f, -0.28535503f, 0.12034317f, -0.32754070f, 
    -0.05690972f, -0.24825054f, -0.27762568f, -0.10688383f, 0.13650401f, -0.10948534f, -0.24121840f, -0.36479056f, 
    -1.21485054f, 0.15310782f, -0.18428582f, 0.13680190f, 0.30086413f, -0.53550994f, 0.10090264f, -0.47884497f, 
    0.00155148f, 0.43136585f, 0.07779750f, -0.09587891f, -0.29656112f, 0.14699653f, 0.10435373f, -0.48883566f, 
    -0.01328213f, 0.15659186f, 0.01714609f, -0.18394147f, -0.20863912f, 0.20913193f, 0.31556183f, 0.08258960f, 
    -0.03173630f, 0.01266857f, -0.15909392f, -0.41393507f, -0.02559233f, 0.15050821f, -0.46452552f, 0.23675179f, 
    0.08883829f, 0.03960227f, -0.16755438f, 0.26066864f, -0.50272048f, 0.33514094f, -0.10632981f, -0.87589902f, 
    0.12241437f, 0.07202588f, -0.54293734f, 0.01818079f, 0.01883363f, -0.07540134f, 0.12608787f, -0.09951551f, 
    -0.11071192f, 0.00401123f, 0.10658562f, 0.42829394f, -0.16627716f, 0.30662686f, -0.35304075f, 0.20513856f, 
    -0.00952655f, -0.38761654f, 0.42934754f, 0.09003036f, -0.18925612f, -0.04608149f, -0.67810655f, 0.05012206f, 
    -0.15451856f, 0.01518410f, -0.01886412f, -0.46733004f, 0.32741150f, 0.12450491f, 0.17496832f, 0.00458119f, 
    0.22763473f, -0.56661355f, -0.29997402f, 0.14951359f, -0.16977882f, 0.17382999f, -0.05263658f, 0.30879015f, 
    0.00996158f, -0.35266626f, 0.08072177f, -0.06723143f, -0.03817672f, 0.17860235f, -0.19945076f, 0.14905904f, 
    -0.13432695f, -0.20385194f, 0.20622674f, -0.24408428f, 0.31356132f, 0.11383611f, 0.30312529f, -0.26550782f, 
    0.01251201f, -0.02397519f, -0.09493537f, 0.37398633f, -0.33194169f, 0.29572067f, -0.37164998f, 0.23816760f, 
    -0.66281003f, -0.29979989f, -0.07844120f, -0.06796070f, 0.09277805f, -0.65095645f, 0.41834572f, 0.25926840f, 
    -0.62069207f, -0.71078259f, -0.03879798f, -0.87677801f, 0.10762395f, -0.75208724f, -0.18444785f, -0.65442449f, 
    -0.53046292f, -0.07017475f, 0.11597863f, -0.46031901f, -0.12360676f, -0.11930384f, 0.22079372f, -0.21956299f, 
    0.07395998f, -0.11922064f, -0.01236054f, -0.01222058f, -0.27559528f, -0.48444784f, -0.40017241f, 0.07268880f, 
    -0.10900457f, -0.10091961f, 0.21566544f, 0.23842283f, -0.35209936f, -0.31023881f, -0.78216064f, -0.05093956f, 
    0.06953148f, 0.13084018f, 0.02545777f, -0.47229323f, 0.17170759f, 0.36787853f, 0.35297641f, -0.38095382f, 
    0.31430086f, -0.17120090f, 0.15756717f, 0.33298117f, -0.62128019f, 0.18611352f, -0.15665275f, -0.14104407f, 
    -0.40391022f, 0.05440549f, -0.62258351f, 0.22661699f, 0.34278533f, -0.43415689f, 0.25931552f, -0.01585662f, 
    -0.88655382f, -0.37017629f, -0.08825055f, 0.28996626f, -0.42106166f, -0.70548397f, -0.29538533f, -0.17584965f, 
    0.40100062f, -0.47082102f, 0.06643626f, -0.34586301f, 0.16108084f, -0.56313562f, 0.11336902f, -0.37066469f, 
    -0.22968954f, -0.33763629f, 0.13814752f, -0.14125378f, 0.31548378f, 0.00746257f, 0.23795769f, -0.58394468f, 
    -0.21003798f, 0.10547459f, -0.14496776f, -0.10456631f, -0.46446839f, -0.15173101f, -0.23128919f, -0.31388149f, 
    0.42772588f, -0.22049823f, 0.25709367f, 0.11219567f, 0.28961852f, -0.11813475f, -0.09887727f, 0.25843382f, 
    -0.87401283f, 0.27985033f, 0.11060290f, 0.09257366f, -0.06515209f, -0.22365807f, -0.57557005f, 0.30965194f, 
    0.18607214f, 0.19809540f, -0.02112545f, 0.03431408f, 0.13592233f, 0.14650282f, -0.12668037f, 0.33122927f, 
    -0.60851109f, -0.13049690f, 0.53965521f, 0.12840134f, 0.44101402f, -0.22533807f, 0.04464942f, -0.53291702f, 
    -0.13409761f, 0.14383936f, -0.65445542f, -0.44328451f, 0.36128986f, -0.18891227f, 0.04399278f, -0.54891199f, 
    0.10788316f, -0.55656159f, -0.02731605f, -0.64959395f, -0.15874402f, -0.49476153f, 0.09796279f, -0.00447534f, 
    0.26104537f, -0.19765419f, -0.34719089f, 0.38528773f, -0.07274844f, 0.03743098f, -0.36609930f, -0.43214017f, 
    -0.90341723f, 0.05292165f, -0.16887601f, 0.07539060f, 0.19798534f, 0.28457025f, -0.36593419f, 0.05348167f, 
    -0.34904069f, 0.44410518f, 0.27754354f, 0.06489463f, 0.30902854f, -0.59925061f, -0.37510630f, -0.09649374f, 
    0.00390310f, -0.34243864f, -0.06495162f, 0.07667075f, -0.06212855f, -0.05134152f, -0.17731002f, 0.26723498f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.41298184f, -0.08723861f, 0.27157897f, 0.06139437f, 0.08569445f, 0.09672204f, 0.11023989f, -0.08923259f, 
    0.11949641f, -0.03840793f, -0.00539567f, 0.11467921f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
