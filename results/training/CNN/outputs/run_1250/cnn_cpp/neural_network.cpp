#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30426630f, 0.33653292f, 0.20668341f, -0.54719967f, -0.27458569f, 0.10476407f, 0.37022662f, 0.31861669f, 
    -0.20986487f, -0.31879953f, 0.09858233f, 0.46053171f, 0.06172722f, 0.23218577f, -0.55060661f, -0.27867624f, 
    -0.01369855f, -0.48736942f, 0.13373160f, -0.15095380f, 0.26872122f, 0.17974101f, 0.21590820f, 0.24182740f, 
    -0.04565879f, -0.75684392f, -0.10207088f, -0.48524851f, -0.49203330f, 0.19061731f, 0.30256665f, -0.00714000f, 
    0.16137663f, 0.44094512f, 0.52806461f, 0.10914078f, -0.07862245f, -0.10639629f, -0.12432225f, -0.21541530f, 
    -0.15525888f, -0.13190840f, 0.31180224f, 0.15263699f, 0.26933178f, -0.02096608f, -0.06876741f, -0.23607852f, 
    0.02249861f, 0.21918021f, -0.97876579f, 0.43755376f, 0.36804083f, 0.26463401f, 0.27711964f, -0.34268874f, 
    -0.43026954f, 0.15384161f, 0.39376646f, 0.07174180f, 0.20814015f, 0.03338065f, -0.08134960f, -0.16552532f, 
    -0.01396846f, -0.00334601f, -0.06580655f, -0.06481881f, -0.20178266f, -0.23148105f, -0.09073225f, -0.39723685f, 
    -0.02705975f, -0.05715282f, 0.00284032f, -0.66541392f, -0.71121907f, -0.74354589f, -0.40207437f, -0.40861756f, 
    0.60381871f, 0.34293166f, 0.19201852f, 0.15526769f, 0.18919779f, 0.19905597f, 0.18154621f, -0.06709578f, 
    0.20698811f, 0.05436258f, -0.17591771f, -0.04619597f, -0.01382650f, 0.13479427f, -0.28849533f, -0.11294693f, 
    -0.08370309f, -0.01190208f, -0.21432061f, 0.01349027f, -0.06315843f, 0.15078348f, -0.46718633f, -0.35717252f, 
    0.15219505f, -0.12317727f, -0.16366169f, -0.20372178f, -0.17056970f, -0.49166051f, 0.37333459f, 0.22523464f, 
    0.43853015f, -0.24406713f, -0.26037967f, 0.16597438f, -0.22250952f, 0.18644765f, -0.05386819f, 0.08921275f, 
    -0.17080338f, -0.21481860f, 0.22191827f, -0.06880876f, -0.35836282f, 0.46949351f, 0.58969647f, 0.29510731f, 
    -0.18859512f, -0.63594836f, -0.24107958f, 0.09873147f, 0.19112328f, -0.03114162f, 0.14898977f, 0.11370178f, 
    -0.02308787f, 0.04637988f, -0.00749775f, -0.34091789f, 0.22697733f, -0.19921835f, -0.33934614f, 0.15547310f, 
    -0.06984832f, -0.22699286f, 0.20005697f, 0.03019772f, 0.00123971f, 0.22434226f, 0.25228104f, 0.21948379f, 
    -0.13254677f, -0.48801413f, 0.02045191f, -0.32723123f, -0.49759042f, -0.41010365f, -0.60220993f, -0.50825161f, 
    0.17880383f, -0.09635148f, -0.20031853f, 0.17950270f, 0.04455824f, -0.20814545f, -0.28217095f, -0.27349994f, 
    0.16034462f, 0.04289328f, 0.01041392f, -0.12118470f, -0.03644972f, -0.44021189f, -0.36234200f, 0.43223813f, 
    0.55095375f, -0.21856591f, -0.39812055f, 0.18665139f, -0.12603155f, -0.16623469f, 0.05750176f, 0.30826879f, 
    -0.03700059f, 0.07960148f, -0.25649962f, 0.10867752f, 0.12085082f, 0.05077532f, 0.05730649f, 0.34333608f, 
    -0.28170824f, -0.35893571f, 0.21300972f, 0.08560590f, -0.07763810f, -0.05276029f, 0.13415869f, 0.05824459f, 
    0.41940284f, 0.17959967f, -0.22566004f, -0.25714967f, -0.50126511f, 0.40856037f, 0.29556665f, 0.28306469f, 
    -0.46874464f, -0.22393703f, 0.02978686f, 0.16537972f, 0.11164817f, -0.29029855f, 0.19495200f, 0.07118177f, 
    0.27572837f, 0.05981488f, -0.01881548f, -0.04519403f, -0.05745371f, 0.06867055f, -0.32788196f, 0.18077363f, 
    0.14930022f, -0.27253824f, -0.43193266f, -0.47642207f, -0.44198897f, -0.02565812f, -0.42277855f, -0.41517496f, 
    -0.64250016f, -0.36957303f, -0.44840425f, 0.44803315f, 0.34298542f, 0.69228673f, 0.12972653f, -0.04642918f, 
    -0.27724677f, -0.32846394f, -0.06954536f, -0.09137531f, -0.06040221f, 0.34167984f, -0.15798457f, -0.08539589f, 
    -0.03416676f, 0.22263311f, -1.12158108f, 0.26712239f, 0.22501259f, -0.71649802f, 0.01131767f, -0.00452581f, 
    -0.00478268f, 0.24600226f, 0.32632864f, 0.17153502f, 0.12675117f, 0.13493052f, 0.36941159f, -0.43719137f, 
    -0.19917136f, 0.38588408f, -0.33153331f, -0.20895982f, -0.19384743f, -0.16444980f, 0.02810258f, 0.15835452f, 
    -0.13263932f, -0.21789648f, -0.23334405f, 0.53089046f, 0.54324836f, -0.25965530f, -0.21101029f, -0.23267274f, 
    0.01779390f, 0.10935744f, -0.00605685f, -0.03367736f, 0.13151142f, -0.03197326f, -0.13495408f, -0.02169917f, 
    -0.31820384f, -0.12187628f, 0.16022526f, 0.16472059f, -0.12135901f, -0.04095949f, -0.19279078f, -0.41226876f, 
    -0.25366372f, -0.32559955f, -0.44330108f, -0.67933935f, -0.80913037f, -0.41515285f, -0.51932091f, -0.35011119f, 
    -0.62952089f, 0.26334855f, -0.06470692f, -0.33985624f, -0.24029620f, 0.23385355f, -0.19700696f, -0.40187526f, 
    -0.27219850f, -0.37262115f, -0.23692243f, -0.02065851f, 0.07447810f, -0.01891167f, -0.01638968f, -0.21889873f, 
    -0.07425615f, -0.06037834f, -0.10302494f, -0.28783372f, 0.00719579f, -0.23258461f, 0.13177305f, 0.12693125f, 
    -0.04305296f, 0.17365301f, 0.27610523f, 0.29858842f, -0.16016872f, -0.14134645f, -0.16392282f, 0.08026747f, 
    0.40708804f, -0.16834927f, -0.15786512f, -0.18346450f, -0.25731093f, -0.15758547f, 0.12277873f, 0.11473171f, 
    0.16305345f, 0.24525711f, -0.10741176f, 0.10072304f, -0.09796999f, -0.24926333f, -0.27581412f, -0.27633229f, 
    -0.38220659f, -0.64434522f, -0.47790512f, 0.36886445f, 0.37981769f, 0.16567777f, 0.25374663f, 0.49327070f, 
    -0.11709245f, 0.16558275f, -0.09301101f, 0.22209977f, -0.24978045f, -0.25070482f, -0.11990891f, -0.06220314f, 
    0.05975360f, -0.18956992f, -0.02815159f, -0.17594449f, 0.36387071f, 0.26115653f, 0.04485723f, 0.53196657f, 
    0.12890345f, -0.15980577f, 0.14018813f, -0.06109647f, 0.17002556f, 0.10355784f, 0.08021376f, -0.20471001f, 
    -0.23919266f, -0.12858313f, 0.17698455f, 0.21871369f, -0.33695412f, -0.25736699f, 0.05819652f, 0.13746369f, 
    -0.07413775f, -0.04133187f, -0.09653132f, -0.12594238f, -0.20087883f, -0.05482216f, 0.09597068f, -0.21531588f, 
    -0.87784863f, 0.13202013f, 0.50989878f, -0.64063567f, -0.20331015f, -0.17728895f, -0.50992090f, -0.59819216f, 
    -0.19560896f, -0.17503014f, -0.07863947f, -0.26203176f, -0.22703089f, -0.38367134f, -0.17609397f, -0.10410648f, 
    -0.04062747f, -0.10212332f, -0.40223494f, -0.32975399f, -0.07815419f, 0.10274155f, -0.03950678f, -0.15470608f, 
    0.00301456f, -0.20002513f, 0.11026958f, 0.11639272f, 0.13819206f, 0.07197785f, 0.06258094f, 0.35127324f, 
    -0.33622640f, -0.04190919f, 0.29613343f, 0.14120640f, 0.06770923f, 0.34011829f, -0.29749599f, -0.22903299f, 
    -0.29151654f, -0.03258694f, -0.11971724f, 0.05734348f, 0.15234815f, 0.19179282f, -0.00441831f, -0.23887077f, 
    -0.18355958f, 0.28456619f, -0.32770455f, 0.59014940f, 0.74258614f, -0.66046482f, -0.63407964f, 0.19644397f, 
    0.36833376f, -0.29418752f, 0.11361084f, -0.13374752f, -0.22872669f, -0.32429683f, 0.20201369f, -0.15887280f, 
    0.10085512f, 0.29769289f, 0.15839459f, -0.46631691f, 0.07551644f, 0.25733712f, -0.38632360f, -0.16317606f, 
    0.36096612f, -0.00868444f, 0.03304264f, -0.93291366f, -0.38717839f, 0.45848846f, 0.29991144f, -0.12820724f, 
    -0.30345148f, 0.02293534f, -0.36658642f, 0.17835894f, 0.11774831f, -0.17318095f, -0.58652151f, -0.13193892f, 
    0.41689134f, -0.06100931f, -0.21196018f, -0.19141759f, -0.18281271f, -0.06095242f, -0.12112323f, -0.13692740f, 
    -0.25850621f, -0.12773700f, 0.05136605f, -0.46108067f, 0.92361975f, 0.37474021f, -0.34423083f, -0.37808177f, 
    -1.04351044f, 0.58326995f, 0.22254857f, -0.24692357f, -0.04503063f, -0.03108192f, 0.06853038f, -0.14657108f, 
    0.17805392f, -0.13265252f, -0.00233102f, 0.06318197f, 0.04475669f, 0.20479846f, 0.09485757f, -0.38412061f, 
    -0.06056633f, 0.02036100f, -0.19698755f, -0.00201790f, 0.12881258f, -0.32104364f, 0.39753398f, 0.51671588f, 
    -0.33593217f, -0.10867675f, -0.27245989f, -0.68206722f, 0.23461738f, 0.53855419f, 0.25347582f, -0.10690697f, 
    -0.30002177f, -0.21420249f, 0.36893338f, -0.51659042f, -0.19428957f, 0.04278736f, 0.26780212f, 0.30073649f, 
    -0.00659154f, -0.19827063f, 0.09307173f, -0.27070481f, 0.04665221f, -0.13932107f, -0.04924859f, 0.42137119f, 
    -0.33465639f, -0.38039964f, -0.26367629f, 0.30365673f, 0.31982058f, 0.03159314f, -0.44859645f, 0.20469232f, 
    -0.24554415f, 0.49970445f, -0.17980850f, 0.09379378f, 0.03784389f, -0.01491697f, -0.43895480f, -0.02427793f, 
    0.08868136f, -0.25576714f, 0.38442048f, -0.08592616f, -0.17884761f, 0.21314190f, 0.27218384f, -0.27157390f, 
    -0.43911827f, -0.13406265f, 0.28744873f, 0.26343486f, 0.22361058f, 0.05889224f, 0.05791293f, 0.35209078f, 
    0.54893851f, 0.03462192f, -0.06637650f, -0.03141955f, 0.18370239f, 0.15479788f, -0.33940101f, -0.01051630f, 
    -0.03438444f, -0.21555732f, -0.20348766f, 0.18552755f, 0.35648149f, 0.20862031f, -0.06455667f, 0.14432086f, 
    -0.45904130f, 0.26560733f, 0.29111874f, -0.27854964f, 0.03111815f, 0.19200568f, 0.38245869f, 0.46344030f, 
    0.30178794f, -0.43963489f, -0.58363783f, -0.37043938f, 0.33961591f, -0.22641797f, -0.08956388f, 0.43991005f, 
    -0.22341311f, -0.21679682f, -0.15718804f, -0.21027690f, -0.09638455f, 0.21606624f, 0.18670900f, 0.11131348f, 
    0.17499880f, -0.80925632f, -0.34073848f, 0.18729508f, 0.04557018f, 0.10749070f, 0.16843383f, -0.43985930f, 
    -0.09905445f, -0.05053663f, 0.29601139f, -0.32363391f, 0.03008259f, 0.09198780f, 0.14376748f, 0.14288050f, 
    -0.05742148f, -0.25110662f, -0.15236241f, 0.02303278f, 0.02733073f, 0.24066073f, 0.20005852f, 0.08964034f, 
    0.12396944f, 0.36240572f, -0.82553172f, 0.28344870f, 0.38266900f, 0.11089101f, 0.02600089f, -0.31735146f, 
    0.28960043f, -0.04624607f, -0.12737252f, 0.17108382f, -0.20394252f, 0.18810423f, -0.22342883f, 0.15288003f, 
    -0.20153543f, 0.28228721f, 0.09370099f, -0.25363809f, -0.08346322f, 0.13598506f, 0.25685176f, -0.33356777f, 
    -0.23814236f, 0.28408232f, 0.01940740f, 0.47212946f, 0.48042563f, 0.68733692f, 0.01343661f, 0.13700397f, 
    -0.41479558f, -0.40700966f, 0.02168596f, -0.34445107f, -0.46062928f, -0.15854979f, -0.16585228f, 0.46576795f, 
    -0.21779126f, 0.01707008f, -0.13434064f, -0.11014635f, -0.07886194f, 0.07681345f, 0.18321265f, -0.00949724f, 
    0.23305829f, -0.10943823f, -0.07391391f, 0.04996427f, 0.28923818f, -0.21840765f, -0.36093232f, -0.09055538f, 
    -0.20919356f, -0.18210693f, -0.09597374f, 0.63416439f, -0.71818918f, -0.05221929f, -0.39474016f, 0.40353107f, 
    -0.01600637f, 0.02533843f, -0.34193394f, 0.23301208f, 0.35961953f, -0.16739456f, -0.37096775f, 0.14992794f, 
    -0.06714197f, -0.16550483f, -0.19264951f, 0.26625460f, 0.29765821f, -0.11382573f, -1.19945693f, -0.30145398f, 
    0.49155489f, 0.51493430f, 0.66956609f, 0.84049481f, -0.54337382f, -0.41791615f, 0.12461437f, 0.13654043f, 
    -0.12339893f, -0.08388482f, -0.29345953f, -0.07291752f, 0.19612747f, -0.03599406f, 0.27149200f, 0.07556391f, 
    -0.05828976f, -0.18625201f, -0.13387862f, -0.23362337f, 0.08554249f, 0.15497044f, 0.67240459f, 0.90023667f, 
    -0.51919442f, -0.20888092f, -0.21562190f, -0.25053760f, -0.14656658f, 0.08214834f, -0.24015661f, 0.05713634f, 
    -0.19892131f, -0.05918770f, 0.44368920f, 0.05292083f, -0.21001983f, -0.09060509f, 0.23041448f, -0.04932176f, 
    0.12713796f, -0.26074371f, 0.05015442f, -0.05461438f, -0.14591844f, 0.33487409f, -0.29875281f, 0.74741596f, 
    -0.10573556f, -0.44079325f, 0.18018764f, -0.03523864f, 0.15180524f, -0.19065903f, -0.23543607f, 0.22364692f, 
    -0.09272578f, -0.02092089f, 0.17450292f, -0.07555293f, -0.07305504f, 0.23870789f, -0.10947630f, 0.00494843f, 
    -0.25125283f, -0.05724903f, 0.09672850f, 0.06955969f, -0.05819804f, -0.05609392f, -0.12432279f, -0.35433239f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10257391f, -0.04723360f, 0.07268866f, 0.04113791f, -0.02060666f, 0.27966762f, -0.20137094f, -0.07832906f, 
    0.18596607f, 0.07185148f, 0.00790711f, -0.07241088f, -0.02262970f, 0.08833800f, 0.19070995f, 0.06518342f, 
    -0.04796410f, 0.26155391f, 0.00947583f, 0.19775452f, 0.23816158f, 0.01953072f, 0.17361823f, -0.17892964f, 
    0.00989819f, 0.21600981f, 0.11598120f, 0.17810553f, 0.09052844f, 0.16265255f, 0.09176316f, -0.09206224f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01413370f, 0.15179017f, -0.00126121f, 0.03727997f, 0.03096716f, 0.04932225f, 0.22432077f, 0.07236038f, 
    -0.06218003f, -0.06164394f, 0.12822166f, 0.22755629f, 0.28055498f, -0.14936113f, -0.06520881f, -0.24296461f, 
    -0.09723251f, -0.05731370f, -0.10654237f, -0.01806558f, 0.04793154f, -0.11967929f, -0.09024552f, 0.00023429f, 
    0.29526076f, 0.06569014f, 0.07765161f, 0.00273175f, 0.00742814f, 0.05307997f, 0.02626203f, -0.03084548f, 
    0.03773871f, 0.01565658f, 0.08028012f, -0.02766939f, 0.11363205f, -0.32156208f, -0.25498125f, -0.21969627f, 
    -0.04973387f, -0.11039095f, -0.10450337f, 0.02222823f, 0.14981984f, -0.14153844f, 0.10809153f, 0.02268140f, 
    -0.10847223f, -0.09443654f, -0.00031542f, 0.02251701f, -0.02525564f, 0.14493220f, -0.01468015f, 0.00288943f, 
    -0.08803885f, -0.17748901f, -0.19659585f, 0.03348808f, -0.10500188f, 0.27759153f, -0.14511400f, 0.19114603f, 
    0.02833764f, 0.01070758f, 0.05550744f, -0.05720130f, 0.07913104f, 0.04483993f, 0.01877964f, 0.03204016f, 
    -0.03153465f, 0.10325157f, -0.10277378f, 0.08143794f, 0.11193649f, -0.07316345f, 0.07978847f, -0.00520463f, 
    0.02338303f, -0.00174342f, -0.00132571f, 0.00271762f, -0.06758121f, 0.17321330f, 0.03129223f, 0.07838924f, 
    0.10858630f, -0.05637576f, 0.01851880f, -0.07360630f, 0.06298363f, -0.07703515f, 0.11383466f, -0.04514108f, 
    -0.08184395f, 0.08811351f, -0.02688249f, 0.01470193f, 0.05870033f, 0.19928940f, 0.20573509f, -0.00914238f, 
    0.05691013f, 0.03742501f, 0.01480552f, 0.00867948f, -0.16693273f, -0.01486853f, 0.16341341f, 0.17301776f, 
    -0.13734974f, 0.15473588f, 0.01443446f, 0.01797651f, -0.05392627f, 0.06050215f, 0.03072270f, 0.09426268f, 
    -0.11458234f, -0.11369824f, -0.00442498f, -0.01291697f, -0.06136772f, -0.03735087f, -0.13466872f, -0.05201212f, 
    0.15216096f, -0.01198307f, -0.20720696f, -0.15287910f, -0.02661265f, 0.10596039f, 0.01153137f, -0.05356331f, 
    -0.05361053f, -0.07535160f, 0.03119082f, 0.04719421f, -0.15972465f, 0.01195930f, -0.02956957f, -0.23313190f, 
    -0.07818782f, -0.13171768f, -0.12992790f, -0.11246650f, 0.04645998f, -0.12342054f, 0.00029980f, -0.02293826f, 
    0.01997163f, -0.00409397f, -0.11459187f, -0.10174812f, -0.01381548f, 0.13699637f, 0.15326646f, 0.01076071f, 
    0.00761360f, 0.07825217f, -0.04924656f, -0.06226301f, 0.04248444f, 0.10599013f, -0.02414088f, 0.07896968f, 
    0.16644353f, -0.36895093f, -0.15530436f, -0.20362787f, -0.08916186f, -0.07606156f, -0.01063833f, 0.30145746f, 
    0.03264664f, 0.15370491f, 0.09180807f, 0.04735382f, 0.10754916f, 0.15098977f, 0.12329413f, 0.01491159f, 
    0.02501919f, -0.05024048f, -0.05624076f, -0.04956991f, 0.08265480f, -0.01423234f, 0.02118767f, -0.01370461f, 
    -0.13364254f, -0.13082910f, 0.11220294f, 0.27219200f, 0.08590136f, 0.02781384f, 0.02644682f, 0.08286946f, 
    0.02461682f, -0.00636504f, -0.00621209f, 0.03661764f, 0.23075940f, 0.16969839f, 0.00677612f, 0.08907383f, 
    0.05143815f, -0.02639474f, 0.01151100f, 0.01357527f, -0.03800708f, 0.13667563f, 0.00554120f, 0.08136360f, 
    -0.08374491f, 0.36979607f, -0.21165371f, 0.31195077f, -0.03466986f, 0.13283096f, -0.03670257f, 0.09838448f, 
    0.00761171f, -0.14057527f, -0.03391364f, -0.10285136f, -0.01158515f, -0.14598441f, -0.08366575f, -0.03022407f, 
    -0.00341500f, 0.02445348f, 0.01335796f, 0.06676282f, 0.15975343f, 0.18797295f, -0.04635262f, -0.01283154f, 
    0.13535474f, 0.23206753f, 0.09134578f, 0.11535990f, -0.03016524f, -0.04213562f, 0.35011265f, 0.18555863f, 
    0.13546869f, -0.00867780f, -0.05113802f, -0.00104997f, 0.01723341f, 0.10533492f, -0.03804854f, -0.07134442f, 
    0.02390018f, -0.01581765f, -0.12114946f, -0.16981260f, -0.15831226f, -0.00731886f, 0.03051315f, 0.20228845f, 
    0.07730170f, 0.06756584f, 0.18417694f, 0.01139356f, -0.13430546f, 0.05716126f, 0.19327505f, -0.01177640f, 
    0.01132770f, 0.26951364f, 0.15523285f, 0.06703379f, 0.22869505f, 0.03683054f, 0.07638866f, -0.14955114f, 
    0.02033067f, -0.00442686f, -0.00350812f, 0.01492630f, 0.01323197f, 0.12561803f, 0.08924561f, 0.12759942f, 
    -0.22273193f, 0.42045343f, -0.16418096f, 0.30287415f, -0.01260178f, 0.01211830f, 0.03316908f, 0.03467528f, 
    0.00851432f, 0.11430227f, -0.05597223f, 0.06854049f, 0.13766521f, -0.13481826f, -0.11232527f, -0.06653285f, 
    -0.03910940f, -0.02988827f, -0.06090886f, 0.03337526f, 0.08730265f, 0.01431895f, 0.10234308f, -0.01693011f, 
    0.08185764f, 0.13397028f, -0.08404379f, 0.13059682f, -0.00975042f, 0.14191644f, -0.10260437f, -0.00789541f, 
    -0.04270266f, 0.04217334f, -0.02391825f, -0.02422081f, 0.03311866f, 0.14351062f, -0.37927520f, 0.18107562f, 
    0.01187334f, -0.00807118f, 0.02901176f, -0.17261702f, 0.03131956f, 0.03416774f, 0.00010355f, -0.05013123f, 
    -0.28725561f, -0.07672136f, -0.12188984f, 0.18129905f, -0.08501095f, 0.06005116f, 0.03805711f, -0.06383137f, 
    0.04128995f, 0.04913807f, -0.00931344f, 0.05960280f, 0.33040509f, -0.21102594f, 0.42755708f, 0.01700314f, 
    0.10755096f, -0.03592361f, -0.05940341f, -0.06927635f, 0.10782543f, 0.01131527f, 0.02743792f, 0.02642496f, 
    -0.15661561f, 0.37145281f, -0.21347144f, 0.22973022f, -0.11410902f, -0.03145601f, -0.01339783f, 0.18438402f, 
    0.10525545f, -0.04980361f, 0.08341319f, 0.01635143f, 0.03747485f, -0.06545164f, 0.04036347f, -0.24160336f, 
    0.03942547f, 0.04952614f, -0.04655343f, 0.01144120f, 0.19838092f, -0.00683039f, 0.08462980f, -0.19518583f, 
    -0.07026992f, 0.02114861f, 0.19302192f, -0.02270992f, -0.05659308f, 0.01525627f, -0.04503806f, -0.08479470f, 
    0.02756727f, 0.05633409f, 0.18479645f, 0.01748698f, -0.28593385f, -0.01023909f, 0.10694867f, -0.08028387f, 
    -0.12903400f, -0.10848283f, -0.12756363f, -0.09833718f, 0.08872604f, 0.07569892f, 0.17059606f, 0.24611592f, 
    -0.30209100f, -0.04406461f, -0.15091144f, 0.29406539f, 0.05856510f, 0.02924724f, 0.04586438f, -0.06392931f, 
    0.09628459f, 0.05880049f, -0.09950864f, -0.06911233f, -0.03811045f, 0.06625465f, -0.01390099f, -0.16751766f, 
    -0.17010339f, -0.15972877f, -0.15631467f, -0.05018191f, 0.02027183f, 0.05650472f, 0.04122058f, -0.07491638f, 
    -0.12935492f, -0.07442116f, 0.11830595f, -0.15944675f, 0.01373248f, 0.04161891f, 0.01441615f, 0.11305334f, 
    0.02321113f, -0.15528157f, -0.00718204f, -0.04698760f, 0.25729191f, 0.09314273f, -0.09208693f, -0.16937143f, 
    0.03582089f, -0.15474106f, 0.00902119f, -0.02698516f, 0.09128638f, 0.11517233f, 0.00218782f, 0.17338008f, 
    0.01968081f, -0.12456509f, -0.05377310f, -0.13050739f, 0.02933303f, -0.03935803f, 0.00914878f, 0.06652848f, 
    0.10770983f, 0.11168842f, -0.08832452f, -0.10876231f, 0.08192070f, 0.00829294f, -0.08484528f, -0.14803365f, 
    -0.05143071f, -0.04019087f, -0.10647612f, -0.05963658f, -0.08042764f, 0.04044863f, -0.05523671f, 0.14912628f, 
    -0.05449483f, -0.03770612f, 0.01585728f, -0.13467008f, 0.06462568f, 0.25639439f, 0.12555753f, 0.22756706f, 
    0.01206997f, 0.01237691f, 0.07036527f, -0.00106216f, -0.11230946f, -0.01369462f, 0.22924559f, -0.01950487f, 
    -0.01465082f, 0.18994504f, -0.05794110f, -0.00990629f, 0.04925853f, 0.00882500f, 0.00198186f, -0.05069267f, 
    -0.40930927f, 0.07056057f, 0.22597176f, -0.21840566f, -0.08352848f, -0.15394714f, -0.08215535f, -0.03502776f, 
    0.02257568f, -0.07714083f, -0.01193820f, -0.09987695f, 0.15581211f, -0.03868995f, 0.00290635f, -0.17851236f, 
    0.06494950f, -0.03443677f, -0.01641710f, -0.04030156f, 0.03430435f, -0.22677495f, -0.14070962f, -0.24437854f, 
    -0.03245533f, 0.12683368f, 0.10867724f, 0.01187439f, -0.05859591f, -0.02092493f, 0.09832098f, 0.06117668f, 
    0.17121482f, 0.07294004f, 0.05542624f, -0.04741555f, -0.03061007f, -0.12037323f, 0.14353850f, 0.03701936f, 
    -0.06167676f, 0.06958991f, -0.02129773f, 0.07998674f, 0.12771146f, 0.07129725f, 0.08186660f, -0.04482919f, 
    -0.15893988f, 0.11815636f, 0.15494028f, -0.20613064f, -0.06569537f, -0.17844868f, -0.03334289f, 0.04160427f, 
    0.03264252f, 0.12840006f, 0.16998026f, 0.01589594f, 0.24794322f, -0.10395829f, -0.00344238f, -0.01030474f, 
    -0.05350163f, 0.04104891f, -0.05552078f, 0.04783571f, -0.07289060f, -0.20311092f, 0.05788716f, -0.12426938f, 
    -0.21168457f, 0.03673026f, 0.01878359f, -0.00118604f, -0.05023255f, -0.07551456f, 0.14270894f, 0.00686403f, 
    0.15540832f, 0.15508389f, 0.04763081f, 0.07096488f, -0.03977871f, -0.10280355f, 0.19435163f, 0.32432929f, 
    -0.07368298f, 0.04280545f, -0.04257755f, 0.04916110f, -0.03628758f, 0.04220812f, 0.08364763f, 0.12553576f, 
    -0.28510311f, -0.07699173f, -0.08628339f, -0.21052179f, 0.17691034f, -0.21414965f, 0.11786910f, 0.02545252f, 
    0.24319579f, 0.13507140f, -0.06151278f, 0.23673812f, -0.06164866f, -0.02262875f, 0.04649425f, 0.31589064f, 
    0.20323204f, 0.14059789f, 0.14224079f, 0.10428614f, 0.09273444f, 0.11730178f, -0.08762021f, -0.21368036f, 
    0.45074800f, 0.17444287f, 0.06716097f, -0.19973369f, 0.07402065f, 0.04170905f, 0.01440342f, 0.14556837f, 
    0.10854863f, -0.04869236f, 0.00028439f, -0.05102205f, -0.16100016f, 0.09264383f, -0.13291208f, 0.13057391f, 
    0.12719837f, -0.13626032f, 0.10446574f, -0.05407757f, -0.02594990f, 0.19138075f, -0.07658222f, 0.10212924f, 
    0.00167190f, 0.08780253f, 0.29100797f, -0.25754088f, -0.06020333f, 0.06888102f, -0.10773714f, -0.03217826f, 
    0.06700045f, 0.19997568f, 0.12732366f, 0.08989223f, -0.13088411f, 0.08094597f, 0.07203702f, 0.31689841f, 
    -0.13987419f, -0.14055628f, -0.13247208f, -0.10700762f, 0.02884284f, 0.00572307f, 0.12259755f, 0.12804341f, 
    -0.23829043f, -0.01486258f, 0.23159443f, 0.06844112f, 0.00742902f, -0.16331516f, -0.08196133f, -0.10578211f, 
    0.07217883f, -0.01175645f, -0.05516237f, 0.20319879f, -0.19747721f, -0.04712823f, -0.01247249f, 0.07578588f, 
    0.25409406f, 0.19308406f, 0.21810219f, 0.12683123f, 0.04340577f, 0.07952856f, -0.00377030f, 0.01132422f, 
    -0.22072400f, -0.11678245f, 0.14824405f, 0.19474824f, 0.14200041f, 0.06505238f, 0.02507311f, 0.19095136f, 
    0.16862181f, -0.00687185f, 0.22105740f, -0.00194454f, 0.05303251f, -0.18457657f, -0.12576722f, -0.06156267f, 
    0.00982074f, 0.02882311f, 0.02235771f, 0.05944439f, -0.17862575f, 0.02803718f, -0.05986159f, 0.00132242f, 
    -0.05084009f, 0.09981988f, 0.22024743f, 0.10182220f, 0.20691600f, 0.16512211f, -0.09977162f, 0.19128861f, 
    0.08600094f, 0.03763874f, 0.10205571f, 0.16423905f, -0.05256507f, -0.08130309f, 0.31728464f, 0.29132476f, 
    -0.12142614f, 0.01319212f, -0.05424759f, -0.00300829f, 0.21443875f, -0.03680886f, -0.00713416f, 0.17661385f, 
    0.38865498f, -0.05106004f, -0.10610317f, -0.20542663f, 0.14548649f, 0.17566197f, -0.01135941f, 0.12844400f, 
    -0.08185056f, -0.08528251f, 0.07692414f, -0.14257979f, 0.12518030f, 0.05954643f, 0.00011880f, -0.07349492f, 
    0.01075790f, 0.05317558f, -0.03001480f, 0.01837197f, -0.05450075f, -0.13388719f, -0.06356525f, -0.44432098f, 
    -0.00511325f, -0.02154382f, 0.01467959f, -0.00785879f, 0.02426380f, -0.02544209f, -0.00156327f, -0.05143951f, 
    0.04561670f, -0.03351273f, -0.05560216f, 0.02048740f, -0.02413700f, 0.00921493f, -0.02710950f, 0.02911369f, 
    0.00723917f, -0.00860793f, 0.03671478f, -0.03166642f, -0.05169060f, 0.00262309f, 0.00601051f, -0.05135037f, 
    0.02435447f, 0.03819353f, -0.03359560f, -0.03390018f, -0.00445592f, 0.03776506f, 0.01086522f, 0.02532231f, 
    -0.00647714f, -0.05776013f, -0.05197251f, 0.01315127f, -0.04468352f, 0.02253663f, -0.00548909f, 0.01079984f, 
    -0.02673773f, -0.04036023f, 0.03024892f, 0.00602512f, 0.04131329f, -0.03378877f, 0.03180773f, -0.02774908f, 
    -0.01169474f, 0.00661451f, 0.01391095f, -0.01482218f, 0.04023802f, 0.04012887f, 0.01236206f, 0.01231146f, 
    0.04619354f, -0.01053336f, 0.02256627f, -0.04983899f, -0.00260529f, -0.05149220f, 0.02501366f, 0.01842534f, 
    -0.05337378f, -0.00448856f, 0.02543642f, -0.03446610f, 0.04628218f, -0.02237380f, -0.00239266f, -0.03223480f, 
    0.00495212f, 0.00917212f, -0.03205963f, 0.05397853f, -0.04701420f, -0.03118253f, 0.01555575f, -0.04816458f, 
    -0.02674770f, -0.02279099f, -0.01939086f, 0.00330486f, -0.00073972f, -0.01830847f, -0.04379540f, 0.03363232f, 
    0.03131134f, -0.03045700f, -0.02908454f, 0.03682048f, -0.02681085f, 0.00637110f, 0.03055847f, -0.01163089f, 
    0.02116174f, 0.01945262f, -0.03752219f, -0.02384425f, -0.01431514f, -0.01654406f, -0.05529112f, -0.03496158f, 
    -0.01089009f, -0.03702669f, -0.02301456f, -0.01873011f, -0.03127021f, 0.00370460f, 0.00384733f, -0.04595070f, 
    0.00434866f, 0.00381395f, -0.03639358f, 0.02881459f, 0.02468319f, -0.02785524f, 0.00090419f, 0.02807457f, 
    -0.04606821f, 0.00276599f, -0.00377844f, 0.02744073f, 0.02205314f, -0.04674731f, -0.05651667f, 0.03784817f, 
    -0.01843913f, 0.03739469f, -0.00126436f, -0.01678426f, 0.02492219f, 0.00934421f, -0.02666729f, -0.01729644f, 
    -0.04554279f, 0.03193730f, 0.02428298f, -0.00243724f, -0.04763079f, 0.03914736f, 0.01469101f, -0.03813585f, 
    -0.05010452f, 0.02162908f, 0.01755209f, 0.04074313f, -0.02095558f, -0.02819877f, 0.02709462f, -0.03384456f, 
    -0.00190068f, 0.04473132f, 0.01013183f, -0.00281584f, 0.03557190f, -0.02916671f, -0.04363407f, -0.00361491f, 
    -0.01214392f, -0.04821441f, -0.02544132f, -0.05607138f, 0.01647495f, 0.03026891f, 0.01365124f, -0.00443806f, 
    0.02434940f, 0.01031608f, -0.05556206f, -0.02940537f, 0.03821111f, -0.00572738f, -0.03883747f, 0.02045044f, 
    0.02302357f, 0.04036605f, 0.01903491f, -0.01251075f, -0.03577052f, -0.00664230f, 0.01234042f, -0.02731460f, 
    0.04297886f, 0.00268439f, -0.03374866f, 0.03531456f, 0.03591074f, -0.03924698f, -0.01199138f, -0.03652795f, 
    -0.01796942f, -0.04984894f, -0.01002359f, 0.01957675f, 0.01436789f, -0.02998848f, -0.04329086f, -0.03336260f, 
    -0.02896179f, -0.03651936f, 0.02582809f, -0.03584255f, -0.02889663f, -0.02409690f, -0.04864749f, 0.00310087f, 
    0.04747284f, -0.04083174f, -0.03724125f, -0.03381873f, 0.04896408f, -0.00035209f, -0.01323925f, -0.04183289f, 
    -0.00580626f, 0.01794737f, 0.00510680f, 0.02869145f, -0.04223431f, 0.00794755f, -0.03114601f, -0.01404598f, 
    0.00649682f, 0.03342131f, -0.03382136f, 0.02438359f, -0.03163012f, -0.04224375f, 0.03959604f, -0.04428162f, 
    -0.04466072f, 0.01557253f, -0.02993988f, -0.03883995f, 0.03201717f, -0.03869697f, -0.02292347f, -0.00358452f, 
    -0.04000527f, -0.03430723f, -0.02365542f, 0.00342271f, 0.02859021f, -0.00045468f, 0.01699579f, -0.01931457f, 
    -0.04538942f, 0.02333545f, -0.05240520f, -0.05369233f, -0.00843911f, 0.01819869f, -0.01078089f, 0.00371876f, 
    -0.02331956f, 0.03245929f, -0.01776350f, -0.00889742f, -0.01219057f, 0.04165240f, -0.00039925f, -0.05189380f, 
    -0.00179955f, 0.03789381f, 0.01378106f, -0.00353158f, 0.02674542f, 0.03343146f, -0.04953231f, -0.00326735f, 
    -0.05333322f, 0.02516416f, 0.02684569f, -0.03695208f, -0.04435190f, -0.05870414f, -0.01138090f, -0.01911435f, 
    0.02093828f, -0.02147859f, 0.00678414f, -0.02084098f, -0.03043179f, -0.05673847f, -0.01095624f, 0.01734545f, 
    -0.02528127f, 0.00918299f, 0.04958201f, 0.04602860f, -0.01583776f, 0.04001150f, 0.01458768f, 0.03661771f, 
    0.04639015f, 0.00530350f, 0.00668026f, -0.01873590f, -0.01931701f, 0.02659127f, -0.05220752f, 0.04096438f, 
    -0.01949993f, 0.03816568f, 0.00080565f, -0.01475724f, 0.02309315f, -0.03802527f, -0.05130151f, -0.02732966f, 
    0.01108570f, 0.01555264f, -0.00034916f, 0.01484845f, 0.00664721f, 0.00138630f, 0.00559888f, -0.03236041f, 
    -0.01936248f, 0.01894883f, -0.00342273f, 0.03508418f, -0.01687943f, 0.04195277f, -0.04891879f, 0.04917661f, 
    0.04354784f, -0.04381711f, -0.02021307f, -0.05088425f, -0.05273406f, -0.04185650f, -0.01737634f, 0.02637455f, 
    -0.02242832f, -0.04539762f, 0.02269161f, 0.01742831f, 0.02416962f, 0.01131556f, 0.02507772f, 0.02187803f, 
    -0.01176637f, -0.00160415f, -0.04075897f, -0.02091590f, 0.02721782f, -0.00646205f, -0.02792626f, 0.01246706f, 
    -0.03982455f, -0.04846357f, -0.00457887f, -0.05173809f, -0.01484222f, -0.01383962f, -0.01233365f, -0.01727224f, 
    0.00155923f, 0.02500429f, 0.02171510f, -0.03888625f, -0.04605450f, -0.02954964f, 0.00490966f, -0.03451379f, 
    0.04414340f, -0.01740602f, -0.02831293f, 0.03341104f, -0.00326036f, 0.01962242f, -0.01259060f, -0.05347279f, 
    -0.01543793f, -0.03740270f, 0.01818208f, 0.03942634f, -0.00181916f, -0.02841327f, -0.02395687f, -0.00730482f, 
    0.09124960f, 0.00501235f, -0.22575746f, -0.06420579f, 0.00441690f, 0.03530879f, 0.09387152f, -0.09557009f, 
    0.05754773f, 0.05767985f, 0.01965318f, 0.01863688f, -0.13781789f, 0.12121760f, -0.21512344f, 0.12813887f, 
    -0.00113313f, 0.07626373f, -0.07659462f, 0.06213545f, -0.09903701f, -0.00382175f, 0.00891546f, -0.05515737f, 
    0.35540235f, -0.08563177f, -0.06141300f, -0.00347566f, 0.04021813f, -0.03746535f, 0.03545374f, 0.00667005f, 
    0.05359977f, -0.10658145f, 0.18320771f, 0.24249990f, 0.05935769f, 0.00111184f, 0.06055142f, 0.17354950f, 
    -0.12560272f, -0.01547500f, 0.08205612f, 0.06834111f, 0.04560693f, -0.08162297f, 0.00309446f, -0.07519415f, 
    0.16092011f, -0.00232724f, -0.03548004f, -0.12399228f, 0.12054713f, -0.12346021f, 0.06459015f, 0.06648415f, 
    -0.01371152f, 0.05023170f, 0.08143407f, -0.00859271f, -0.39914671f, 0.21734488f, 0.04443145f, 0.28073362f, 
    0.01098686f, -0.06710131f, -0.13295770f, -0.02862759f, 0.08803836f, -0.06494736f, -0.03154719f, 0.13716824f, 
    -0.07206994f, 0.25808409f, 0.07243490f, -0.04313678f, 0.07312854f, -0.01457016f, -0.03275574f, -0.05140689f, 
    0.02808626f, 0.02677764f, 0.03020927f, -0.12288772f, -0.33933479f, -0.01201192f, 0.09254778f, 0.03266292f, 
    -0.01963376f, -0.04012031f, -0.16005191f, -0.10015172f, -0.12111048f, -0.08777791f, -0.05545652f, 0.13288492f, 
    -0.21262772f, -0.23622647f, -0.00658366f, -0.09550929f, -0.00565883f, 0.08998305f, 0.02757005f, 0.05761779f, 
    0.03343941f, -0.05395872f, 0.00162583f, 0.01413790f, 0.41223493f, 0.02938320f, -0.23606423f, -0.21998359f, 
    0.06857038f, 0.01447506f, 0.14328949f, 0.11749116f, 0.06674718f, 0.06725600f, 0.09917134f, -0.00101751f, 
    0.16443117f, 0.14305536f, -0.23184900f, 0.19901776f, 0.02704922f, 0.04627165f, 0.03159004f, -0.05545488f, 
    0.02455003f, -0.10279945f, 0.00482988f, 0.15695789f, -0.19023068f, -0.07736813f, 0.01005197f, 0.01748417f, 
    0.02811293f, 0.00845086f, -0.01776369f, -0.13374625f, 0.06855316f, -0.00252314f, -0.05266468f, 0.01790853f, 
    -0.14302708f, 0.10886974f, 0.08195239f, 0.14015324f, 0.03644064f, 0.00658646f, 0.05299286f, 0.04555145f, 
    -0.02395112f, -0.08209537f, -0.05923953f, 0.03567633f, 0.17215946f, 0.07733136f, 0.03144667f, -0.06811150f, 
    -0.06092768f, -0.26330605f, 0.01379313f, 0.01514857f, 0.00799106f, 0.08078407f, -0.09497103f, -0.01836471f, 
    -0.16204281f, 0.19604671f, 0.20286345f, 0.27846196f, -0.11929608f, -0.03233105f, -0.00133939f, -0.10752994f, 
    0.07570153f, -0.11411101f, 0.17175888f, 0.01862856f, -0.16305721f, -0.14157064f, 0.00456971f, 0.09152960f, 
    -0.05942296f, -0.07915116f, -0.03678835f, -0.07326538f, 0.06452319f, -0.03960378f, 0.03845569f, -0.09356359f, 
    0.00723996f, 0.04420913f, -0.12544890f, -0.20620912f, 0.19140151f, 0.01872509f, 0.00536303f, 0.14159560f, 
    0.00358431f, 0.07918907f, 0.04015378f, 0.06141669f, 0.13383700f, 0.13794684f, -0.02298705f, 0.01785173f, 
    -0.11423583f, -0.03729720f, -0.03082165f, 0.07853698f, -0.01419180f, 0.10217936f, 0.04121767f, 0.07117519f, 
    -0.18859628f, -0.17921649f, -0.14989281f, -0.10363007f, 0.09840823f, -0.18848857f, 0.00719198f, 0.10802789f, 
    -0.11031823f, 0.07955813f, 0.10303966f, -0.01961120f, 0.09983229f, 0.06955365f, 0.09128836f, 0.03930713f, 
    0.12956925f, -0.04546070f, 0.13362294f, 0.07904057f, 0.17933042f, -0.01440487f, -0.00143208f, -0.06338752f, 
    -0.68301475f, 0.06106559f, 0.02669931f, 0.11837464f, 0.19046728f, 0.16568723f, -0.23975272f, -0.07000459f, 
    0.03629564f, 0.11481094f, 0.05359800f, 0.20752114f, -0.27617347f, 0.17635262f, -0.07054346f, 0.02076236f, 
    0.08739451f, -0.16179359f, -0.06016945f, 0.15694231f, 0.11414039f, -0.14634366f, 0.13705249f, -0.02504673f, 
    0.01175701f, -0.17242505f, 0.08622057f, -0.05155867f, 0.03598911f, 0.06628958f, -0.09959386f, -0.02985185f, 
    0.14827932f, 0.04113896f, 0.08721171f, 0.00853832f, -0.08345412f, 0.02017075f, -0.04340122f, 0.04372672f, 
    -0.14885199f, -0.01923466f, -0.04119517f, -0.09111127f, 0.03469735f, 0.01566772f, 0.07266216f, 0.11814564f, 
    0.07382561f, 0.05766252f, -0.09639933f, 0.27593517f, -0.07857771f, -0.09635419f, 0.02397447f, -0.05881354f, 
    0.15333106f, 0.09561707f, -0.03153516f, 0.01806624f, 0.16291355f, 0.01889492f, -0.11990834f, -0.10437109f, 
    -0.00605692f, 0.05413555f, 0.18322164f, 0.12371331f, -0.07532245f, 0.04891628f, 0.05123632f, -0.02615766f, 
    0.29398361f, -0.09992106f, -0.04328023f, 0.02542033f, 0.02911544f, -0.00675215f, -0.18221265f, 0.12942745f, 
    0.14003792f, 0.02972760f, -0.00249086f, 0.06206757f, -0.16922432f, 0.27098554f, 0.16382341f, 0.16942747f, 
    0.00427431f, -0.16140695f, -0.04301046f, -0.04236504f, -0.01512220f, -0.01250006f, 0.02665384f, -0.15292935f, 
    0.21460037f, -0.15072718f, -0.21992411f, 0.09782393f, 0.12695853f, 0.17345788f, -0.02372611f, -0.02007316f, 
    0.12856822f, -0.11375409f, 0.03901612f, 0.09944653f, 0.22244523f, -0.25233915f, 0.10978089f, 0.01473626f, 
    -0.12456782f, 0.03041095f, -0.07783980f, 0.02396533f, 0.01807522f, 0.00322897f, -0.08786674f, -0.01605746f, 
    -0.55251533f, -0.24728644f, 0.12951922f, 0.23303796f, 0.13693018f, 0.12489939f, -0.12717797f, -0.23457417f, 
    0.01801940f, -0.06642329f, 0.03471896f, 0.05776541f, -0.24187987f, -0.01982168f, 0.03607149f, -0.03200951f, 
    -0.04838018f, -0.02740881f, -0.06070147f, -0.03724136f, 0.14725821f, 0.18079810f, -0.02011112f, 0.15602446f, 
    -0.06852280f, -0.14367902f, 0.14647220f, -0.14582279f, 0.06270938f, -0.02529891f, -0.01552918f, 0.14762798f, 
    0.05266949f, -0.09984078f, -0.17131996f, 0.06595294f, -0.20505951f, 0.33151209f, 0.18837474f, 0.07422812f, 
    0.03307916f, -0.00726971f, -0.02181030f, 0.12931396f, 0.04938516f, 0.29036754f, 0.15989929f, 0.12047912f, 
    -0.36319634f, -0.02747853f, -0.00494653f, 0.24875289f, 0.00506762f, 0.06892483f, -0.09189025f, 0.04637801f, 
    -0.11412586f, -0.07596227f, 0.08031898f, 0.08376183f, -0.05025624f, 0.19548991f, 0.27444443f, 0.15365051f, 
    -0.06575202f, -0.09033849f, -0.00833412f, -0.14906304f, -0.06761459f, 0.05278228f, 0.14058062f, 0.20696555f, 
    -0.09322027f, -0.03563360f, 0.14913815f, -0.04705577f, -0.10433962f, -0.01762998f, -0.00169140f, -0.10027783f, 
    -0.01956425f, 0.09406409f, 0.09269150f, -0.01065803f, 0.27891296f, -0.24528599f, 0.25257489f, -0.28673950f, 
    0.01005799f, -0.00294348f, 0.03311842f, 0.12442726f, -0.08452204f, -0.05453030f, -0.01629330f, -0.12231693f, 
    -0.03533703f, -0.17092015f, -0.08063663f, -0.21150342f, 0.04443209f, 0.02894528f, -0.10070874f, 0.02260667f, 
    0.03338591f, 0.00077488f, 0.09329302f, 0.07674101f, 0.25508690f, -0.09934558f, 0.06636758f, -0.11952633f, 
    0.00749799f, 0.03688028f, 0.11031292f, 0.06975473f, 0.00447603f, 0.09183240f, -0.11638306f, -0.04622041f, 
    0.12872341f, 0.02963053f, 0.08874373f, -0.12023397f, -0.03954820f, 0.06330373f, 0.05875843f, 0.06215902f, 
    0.10421994f, 0.04312351f, 0.00820493f, 0.00958319f, -0.08923092f, -0.06505950f, -0.11434845f, -0.16728154f, 
    0.02225759f, -0.18328294f, -0.12775454f, -0.15192755f, -0.07911450f, -0.02562119f, -0.05206295f, -0.04228713f, 
    -0.39043620f, 0.21227105f, -0.13396515f, 0.07784773f, 0.00664208f, -0.01205931f, 0.00073400f, -0.05650549f, 
    0.04014646f, 0.08523878f, 0.16872093f, 0.01889076f, 0.01020388f, -0.02172216f, 0.04167252f, -0.06423806f, 
    0.03941514f, -0.05543558f, -0.04710845f, -0.09313631f, 0.05921376f, 0.19945621f, 0.20208064f, 0.29802689f, 
    0.06624806f, 0.25362378f, 0.09324819f, 0.01634141f, -0.06282916f, 0.02959527f, -0.06239800f, -0.09182956f, 
    0.01811724f, 0.05468897f, -0.00252064f, -0.08930062f, 0.06974276f, -0.12825677f, -0.04607053f, 0.10559899f, 
    0.04575532f, 0.04504308f, 0.02110037f, 0.05491444f, 0.07144208f, -0.01540881f, 0.05557255f, 0.04507995f, 
    0.02560275f, 0.28949812f, 0.08607059f, 0.02263440f, -0.01292486f, 0.01286997f, -0.04978401f, -0.00564349f, 
    -0.10187845f, 0.03842222f, 0.03232331f, -0.02465799f, -0.01469428f, -0.07633311f, 0.00803142f, -0.06244697f, 
    0.00669598f, 0.02188128f, 0.02710340f, 0.11724171f, -0.04895446f, 0.09377129f, -0.05847624f, 0.04280894f, 
    -0.22830573f, 0.10483854f, -0.26874000f, -0.13425165f, -0.08077239f, 0.02520328f, -0.05201978f, -0.01731819f, 
    -0.01046057f, -0.10118327f, -0.08110737f, -0.09581525f, -0.02876927f, -0.03473690f, 0.16775237f, 0.23076931f, 
    0.00875959f, 0.09459853f, 0.08178423f, -0.00354923f, 0.12924090f, 0.01333643f, 0.01612897f, -0.15326409f, 
    -0.07242590f, 0.02745235f, -0.09041347f, -0.18611677f, -0.03715514f, 0.16542527f, 0.13365427f, -0.09608245f, 
    0.04872189f, 0.06839407f, -0.05908793f, 0.14386034f, 0.12968181f, -0.31914967f, -0.12809615f, 0.07923590f, 
    -0.06244008f, -0.04997221f, 0.01289569f, 0.02996168f, 0.02190798f, 0.08889197f, 0.13350156f, 0.32808918f, 
    0.38912785f, 0.10993434f, 0.12957577f, -0.44987860f, 0.14666861f, -0.19959916f, 0.08113127f, 0.11769898f, 
    -0.03294777f, 0.31999016f, 0.15132737f, 0.00152893f, -0.10144769f, 0.09348828f, -0.02973956f, 0.08391763f, 
    0.01961651f, 0.10609684f, 0.11783730f, 0.06748853f, 0.12627614f, -0.08362607f, 0.10752837f, 0.03318859f, 
    0.08046423f, -0.21129878f, -0.01536717f, -0.05913454f, 0.08520947f, -0.01489212f, -0.01718478f, 0.02443596f, 
    0.13211036f, 0.10518926f, -0.26084244f, 0.15214902f, -0.20691033f, -0.12443928f, 0.03688173f, 0.24755533f, 
    0.11129935f, 0.00532082f, -0.02333314f, 0.03841544f, 0.06221075f, -0.08599499f, -0.07714433f, -0.11421964f, 
    -0.34945685f, -0.21731222f, 0.07647856f, -0.16935395f, -0.03572967f, -0.05464655f, 0.03641297f, 0.06195908f, 
    0.05499426f, 0.11863799f, -0.00818527f, -0.07276843f, -0.01631151f, 0.05372665f, 0.09199037f, 0.19505045f, 
    0.11669239f, 0.04037099f, 0.12821759f, 0.10012045f, -0.05078114f, -0.07040102f, -0.09464903f, -0.04289415f, 
    -0.11028788f, -0.30805972f, 0.01867092f, 0.24069111f, -0.09955826f, 0.14434981f, 0.18838176f, -0.00277682f, 
    0.31441870f, -0.05172419f, 0.05328212f, 0.03267245f, 0.28322703f, 0.11203551f, -0.07467939f, -0.38426560f, 
    0.01042307f, 0.17972401f, 0.05738681f, 0.07800741f, -0.07233144f, -0.04180398f, -0.03239842f, -0.04752810f, 
    0.11418343f, 0.08511767f, 0.00985088f, -0.37033582f, -0.02642160f, -0.00574711f, 0.20750226f, 0.02175034f, 
    0.07296607f, -0.01657872f, -0.01199661f, -0.07216903f, 0.07104840f, -0.50132769f, 0.02221793f, 0.35386142f, 
    0.07316696f, 0.01308898f, 0.10336737f, 0.27886960f, 0.24662200f, 0.18781605f, 0.26423123f, 0.06501484f, 
    0.16234988f, -0.07652722f, 0.22037214f, -0.35812807f, 0.04986312f, -0.17803052f, 0.08832157f, 0.09218630f, 
    -0.07889523f, 0.02220994f, -0.02444395f, 0.06600330f, 0.07151052f, 0.00406783f, 0.04273464f, 0.04453611f, 
    -0.07998869f, -0.04765217f, 0.09087674f, -0.00970992f, 0.06479869f, -0.01051592f, 0.15337187f, 0.17550284f, 
    -0.01568352f, -0.08006261f, 0.05694953f, -0.14039648f, 0.07140466f, -0.05535965f, -0.06786250f, 0.09451364f, 
    -0.05383650f, -0.30049407f, -0.24614923f, 0.11227822f, 0.03829074f, 0.14842083f, -0.03810123f, 0.07596197f, 
    -0.15057248f, -0.09083697f, -0.02385877f, 0.06537934f, -0.03190128f, 0.07467201f, -0.07333978f, -0.00304360f, 
    0.03231788f, -0.04136826f, -0.19748643f, 0.03256734f, -0.07404510f, -0.02169038f, -0.04186460f, 0.07033698f, 
    0.00577847f, 0.09216859f, 0.04189864f, 0.12956014f, 0.07038616f, 0.08677728f, 0.17919797f, 0.06029832f, 
    -0.16577683f, -0.06673950f, -0.00840764f, -0.08014062f, 0.13242541f, 0.03007533f, 0.03966670f, 0.11728872f, 
    -0.16411409f, -0.04856144f, 0.03731315f, 0.17404626f, -0.09749163f, 0.01747108f, 0.03416580f, -0.11760943f, 
    0.09585372f, 0.18788461f, 0.01696538f, -0.06159531f, 0.32895753f, -0.04458776f, 0.46009639f, -0.20037135f, 
    0.03135077f, 0.03541031f, 0.03488857f, 0.06238446f, -0.06526592f, -0.14309719f, 0.05353336f, -0.12410132f, 
    -0.08888715f, -0.04056663f, 0.01521306f, -0.04942302f, 0.18734467f, -0.00660994f, -0.09189679f, 0.00103611f, 
    0.00502090f, -0.04583475f, 0.06992810f, 0.15998863f, 0.27231088f, 0.02475224f, 0.20400181f, 0.12605512f, 
    0.02903694f, 0.02226309f, 0.06584352f, 0.07810613f, -0.01003853f, -0.01088808f, -0.01887222f, -0.06982107f, 
    0.11137559f, 0.12707902f, 0.03952681f, -0.07764214f, 0.04924316f, 0.00487411f, 0.04336818f, -0.12501039f, 
    -0.07134939f, -0.06849865f, -0.12793769f, -0.03667511f, -0.15668085f, -0.06391013f, 0.10687099f, 0.11448290f, 
    -0.11545686f, -0.05857031f, -0.04720376f, -0.09534851f, -0.06844074f, 0.06214533f, -0.09890382f, -0.00963239f, 
    0.07289276f, 0.07390746f, -0.26988533f, 0.16769183f, -0.06992656f, -0.13196646f, -0.06794742f, -0.03126646f, 
    -0.00415436f, 0.04900431f, 0.20299013f, 0.06791455f, 0.09743573f, 0.03641867f, -0.00680281f, -0.04047500f, 
    0.01652635f, -0.07632322f, -0.12922031f, -0.13592835f, 0.12257646f, 0.11447599f, 0.13462593f, 0.34437445f, 
    -0.04089618f, 0.06556907f, 0.13714382f, 0.20966092f, -0.10989219f, 0.06654335f, -0.00417253f, -0.05151349f, 
    -0.08350124f, -0.00849457f, 0.02438193f, -0.07143941f, 0.15197635f, 0.10047816f, -0.05445137f, 0.17704314f, 
    0.09908052f, -0.00676604f, -0.08626677f, 0.05320010f, -0.04041167f, 0.00639147f, 0.01000903f, 0.04686930f, 
    0.05081096f, 0.20092432f, -0.05753347f, -0.08806399f, -0.09175412f, -0.09639614f, -0.01759981f, 0.02396114f, 
    -0.06693887f, -0.18501185f, -0.00615241f, -0.06204137f, 0.19326450f, 0.12943052f, 0.15386385f, -0.09484760f, 
    0.01548056f, -0.08426956f, 0.06197739f, 0.04081057f, -0.04630738f, 0.17659140f, 0.05141606f, 0.06751890f, 
    -0.03807855f, -0.05705831f, -0.13687998f, 0.17912567f, 0.04496677f, -0.03303193f, -0.15791610f, -0.05381695f, 
    -0.01469142f, -0.05680736f, 0.05359301f, 0.00272595f, 0.16861805f, 0.26677999f, 0.11349504f, 0.14069735f, 
    0.00319257f, 0.02342390f, -0.04234573f, -0.00057472f, -0.02299022f, 0.01807306f, -0.07165711f, -0.16618861f, 
    0.21406688f, 0.26601604f, 0.22309031f, -0.13077973f, 0.10459780f, 0.11354144f, -0.13073519f, -0.03944210f, 
    -0.16871336f, 0.02125847f, -0.02188302f, 0.03989286f, 0.08137482f, -0.25605887f, -0.11512791f, 0.04836129f, 
    -0.05881827f, -0.04017842f, -0.04215621f, -0.09336933f, 0.09179622f, 0.09801459f, 0.18401502f, 0.29213417f, 
    0.31786084f, 0.17325687f, 0.37296429f, -0.30487558f, 0.14001857f, 0.03085847f, -0.08728251f, -0.00681177f, 
    -0.16254081f, 0.23818858f, 0.19433065f, 0.10072108f, 0.15716568f, -0.13214630f, 0.12555893f, -0.05774922f, 
    0.01094885f, 0.11431796f, -0.01613168f, 0.14586623f, 0.02792723f, -0.08433761f, 0.04080433f, 0.09155614f, 
    0.05624112f, -0.14082536f, -0.07243207f, 0.08397017f, 0.00643614f, -0.05359019f, -0.09285831f, 0.09982711f, 
    -0.05431070f, -0.11791056f, -0.11464126f, 0.01058888f, 0.11535268f, -0.01877329f, -0.02888865f, 0.06599751f, 
    0.03094103f, 0.05735739f, 0.06505517f, 0.10127240f, -0.05497690f, -0.12729058f, -0.16582888f, -0.15185992f, 
    -0.17665899f, 0.01856034f, -0.06907762f, -0.04844774f, -0.03535948f, -0.05185197f, -0.03368986f, -0.03595802f, 
    -0.02596189f, 0.09270237f, -0.07100162f, -0.14035295f, -0.02403438f, 0.02236489f, -0.01091700f, 0.18619904f, 
    -0.09816459f, -0.05739524f, 0.04336297f, 0.04247061f, -0.14975637f, -0.09920009f, -0.03237585f, -0.07873075f, 
    0.01043006f, -0.19830112f, -0.08622016f, 0.11337850f, -0.04608228f, 0.03201409f, 0.10405695f, -0.09632060f, 
    0.16115339f, 0.01678276f, -0.03710832f, 0.07574364f, 0.52668732f, 0.44534361f, 0.13616456f, -0.24151792f, 
    -0.05943896f, -0.10050846f, -0.07535630f, -0.10753781f, 0.04215239f, -0.02637672f, 0.01364736f, 0.05044332f, 
    0.07866319f, 0.05704109f, 0.04597593f, -0.15888347f, -0.06649674f, 0.06344052f, 0.16046490f, 0.02288304f, 
    0.03146616f, -0.02460618f, -0.13827680f, -0.14218886f, 0.06708811f, -0.38121396f, 0.00985673f, 0.23664075f, 
    0.00402602f, -0.06220693f, 0.08624966f, 0.19054498f, 0.04974211f, 0.13792142f, 0.20765571f, -0.00060740f, 
    0.07939631f, -0.09371647f, 0.23707883f, -0.22038133f, 0.08119554f, -0.16056278f, -0.18833958f, 0.21991386f, 
    -0.03985719f, -0.11038896f, 0.10021044f, 0.09188519f, 0.15568642f, -0.01785533f, -0.00813216f, 0.05850395f, 
    -0.02247336f, -0.01910495f, 0.09656744f, -0.04161421f, 0.17374706f, 0.00156892f, 0.19065550f, 0.20988905f, 
    -0.02071900f, -0.02247743f, -0.02708754f, 0.03928334f, 0.01841570f, -0.04203299f, -0.02530258f, -0.06043995f, 
    0.00559531f, -0.03100862f, -0.01043095f, -0.03182999f, -0.03683982f, 0.01099218f, -0.01511517f, -0.01960712f, 
    0.04035236f, -0.04711448f, -0.01177613f, -0.00894616f, -0.00497478f, -0.04604890f, -0.02719644f, -0.05570755f, 
    -0.03565557f, -0.04187828f, 0.00123172f, -0.02646262f, 0.00305008f, -0.02450367f, -0.04524202f, -0.05897394f, 
    -0.01755855f, -0.03151171f, -0.00753707f, 0.03125901f, -0.00490857f, -0.03704494f, 0.01709380f, -0.02066448f, 
    0.03626102f, 0.04656329f, 0.05149991f, 0.04389787f, 0.03354638f, 0.00385607f, 0.00199543f, 0.02316943f, 
    0.01819257f, -0.03879534f, -0.04780507f, 0.01724063f, -0.01960220f, -0.03218807f, -0.01725988f, 0.02561616f, 
    -0.02904765f, -0.03433318f, -0.04493683f, 0.00840706f, 0.00382888f, -0.01589181f, 0.00007592f, 0.00926760f, 
    -0.02882585f, 0.02052265f, -0.06149379f, -0.00000184f, -0.03833139f, -0.01930359f, -0.02674663f, -0.04807469f, 
    0.02002368f, 0.01715753f, -0.06053227f, -0.04733713f, 0.02006488f, -0.02954215f, -0.04052242f, -0.06593006f, 
    -0.04821652f, 0.03564037f, -0.06070815f, -0.05465413f, 0.02533969f, -0.05480647f, 0.00636572f, 0.01722147f, 
    -0.03631229f, 0.02695381f, -0.01911525f, -0.00073268f, -0.06793296f, -0.04848597f, 0.03022363f, -0.03663711f, 
    0.00979366f, 0.02973934f, -0.01789057f, -0.02708223f, -0.06028986f, -0.00738284f, -0.03092414f, -0.02552302f, 
    -0.02995899f, -0.03293964f, -0.05275851f, 0.00954622f, -0.04030500f, -0.05429299f, -0.03346834f, -0.01788711f, 
    -0.05784712f, -0.06074499f, -0.04358419f, 0.02696601f, -0.03456661f, 0.00229523f, -0.01777618f, 0.02739580f, 
    -0.05544153f, -0.00411659f, -0.02377643f, 0.01057650f, -0.00795766f, -0.01582306f, -0.00925633f, -0.03864203f, 
    0.01172582f, -0.03724980f, -0.01663563f, -0.01158508f, -0.05020191f, -0.00319636f, -0.04137083f, -0.04515830f, 
    0.02231563f, 0.02162037f, 0.00213134f, 0.02899697f, 0.03267926f, 0.02077013f, 0.00625937f, 0.03439659f, 
    -0.04411517f, -0.05273509f, -0.04443159f, -0.06182429f, 0.02063117f, -0.04465527f, -0.04684861f, -0.03230111f, 
    -0.02209713f, -0.04193511f, 0.02288617f, -0.00194952f, -0.00271496f, -0.01013109f, 0.03034721f, -0.00881364f, 
    -0.06430145f, 0.03841604f, -0.04295235f, 0.00376427f, -0.01933016f, -0.01873325f, -0.04131925f, -0.03803195f, 
    -0.04373921f, -0.00593413f, -0.02924800f, 0.03861821f, 0.01013770f, -0.01388444f, 0.00173108f, -0.06334252f, 
    0.03756946f, -0.03786468f, 0.01802702f, -0.05870462f, -0.06030605f, -0.01977767f, -0.02996155f, -0.06284944f, 
    -0.02590842f, -0.02332844f, -0.00043902f, 0.02216415f, -0.03649545f, 0.00602479f, 0.00869616f, -0.01557958f, 
    -0.04585415f, 0.02340790f, -0.01667380f, 0.03819369f, 0.01976816f, 0.02441635f, -0.00838743f, -0.06612329f, 
    0.02604118f, -0.01527800f, -0.03198313f, 0.02508861f, -0.06311429f, 0.02729375f, -0.02249846f, -0.05994875f, 
    0.03476560f, -0.02270484f, 0.01502593f, -0.05427222f, -0.03066079f, -0.02084984f, -0.03135379f, 0.02420278f, 
    -0.06263428f, -0.00251384f, -0.00945722f, 0.02313031f, 0.03480351f, 0.03444187f, -0.02760594f, 0.00140613f, 
    -0.06189661f, -0.03496734f, 0.00416402f, -0.02442547f, -0.05578290f, 0.00817634f, 0.01405869f, -0.01587203f, 
    -0.00334577f, 0.03386146f, -0.00704863f, 0.01918387f, -0.00013050f, -0.03013817f, -0.00348192f, 0.02658374f, 
    -0.03661428f, -0.00540766f, 0.03578929f, -0.04611977f, -0.02674961f, -0.02080699f, 0.01960948f, -0.02005135f, 
    0.02065755f, -0.03170110f, -0.02715448f, -0.04672583f, 0.04252185f, 0.02863670f, -0.03095492f, -0.04240512f, 
    -0.04955358f, -0.04502885f, -0.01740001f, -0.03257665f, 0.02677143f, -0.05486933f, -0.02953062f, 0.01948817f, 
    -0.05551977f, 0.00529913f, -0.05155394f, -0.03053607f, -0.01174747f, -0.03098466f, -0.05970151f, 0.00636848f, 
    -0.06031151f, 0.03007803f, -0.05292997f, 0.01819491f, -0.02446537f, -0.06329805f, -0.03361993f, 0.00773073f, 
    -0.00192116f, -0.05830413f, 0.01802405f, -0.03842680f, -0.04511781f, 0.01192634f, 0.03209797f, 0.02623396f, 
    0.00160955f, 0.00947912f, 0.00450935f, 0.02063151f, -0.02377665f, -0.02406988f, 0.00175933f, 0.01067027f, 
    -0.03344822f, -0.00410184f, -0.03477770f, -0.05875284f, 0.00667728f, 0.00898152f, 0.02208051f, -0.02995831f, 
    0.00711389f, -0.00611454f, -0.01702484f, -0.02970219f, -0.00690369f, -0.05500480f, -0.00645212f, -0.01342585f, 
    -0.03270056f, 0.01858222f, -0.02315644f, 0.00736705f, 0.01018695f, 0.01750001f, -0.02033527f, -0.01914345f, 
    -0.03735816f, -0.06447081f, -0.00329344f, -0.00437664f, 0.01055771f, -0.01478124f, -0.04233624f, -0.05523315f, 
    0.00457672f, 0.02614745f, -0.00314655f, -0.03452457f, 0.00475616f, -0.02587277f, -0.05537751f, 0.00735820f, 
    -0.02016328f, 0.01516261f, 0.04402046f, -0.04965141f, 0.02164442f, 0.00929322f, -0.02409137f, -0.00395433f, 
    -0.03389970f, -0.06478462f, -0.03113380f, 0.01465958f, -0.01973940f, -0.06285733f, 0.01532916f, 0.02347334f, 
    0.03493354f, -0.01059400f, -0.00851104f, 0.02846318f, -0.00085971f, -0.03868970f, 0.04038248f, -0.05585426f, 
    0.03494899f, 0.02242804f, 0.03558769f, -0.02051925f, -0.00313511f, -0.02479946f, 0.01545313f, -0.01605072f, 
    0.00061256f, -0.00462201f, -0.02930334f, -0.02217394f, -0.00663484f, -0.03878246f, -0.06274521f, -0.04337394f, 
    -0.02475872f, -0.05226943f, -0.00426088f, -0.01004509f, -0.04412119f, -0.01661354f, -0.00363966f, -0.03759987f, 
    0.09661693f, 0.14625801f, -0.02681712f, -0.12881246f, 0.15893134f, -0.17579052f, -0.11276272f, -0.22324972f, 
    -0.08917478f, -0.13643524f, -0.14403611f, -0.32226521f, 0.10732261f, 0.07636416f, -0.00380348f, 0.30452400f, 
    -0.10690680f, -0.04731624f, 0.03308929f, 0.09482732f, -0.04987563f, 0.04659832f, -0.06732692f, -0.03124373f, 
    0.38007095f, 0.06037105f, -0.12050156f, 0.02873021f, -0.10940152f, -0.02440152f, 0.01140594f, -0.18961853f, 
    0.14162007f, 0.15220702f, 0.16810618f, 0.25299472f, 0.05600657f, 0.21141376f, 0.44286516f, 0.14541516f, 
    -0.23081292f, -0.12205003f, 0.09805951f, 0.20620637f, 0.22182202f, 0.09131148f, 0.13340469f, 0.17423843f, 
    -0.11493155f, 0.17046872f, 0.16683474f, 0.10467182f, 0.10226481f, 0.09005781f, 0.06112201f, 0.00578015f, 
    0.24357592f, 0.00044737f, 0.24468283f, 0.01349490f, 0.01397507f, -0.06269786f, -0.24959910f, 0.03520032f, 
    0.09525636f, 0.10593771f, -0.17392202f, -0.11888804f, 0.00585748f, -0.02808243f, 0.04776255f, -0.13143283f, 
    -0.26282644f, 0.14073586f, 0.25850889f, 0.44536173f, 0.18798244f, 0.10123624f, 0.04078617f, -0.12132562f, 
    0.17409505f, -0.05719613f, 0.06871172f, 0.23704244f, -0.11351208f, -0.10686171f, 0.01625707f, -0.00752219f, 
    0.06265428f, -0.03973339f, -0.17975330f, -0.00886617f, -0.13067740f, -0.14905575f, -0.12586153f, -0.16169441f, 
    -0.02076421f, 0.39117920f, 0.17563051f, -0.20902696f, 0.01015543f, -0.18543710f, 0.16147278f, -0.08918426f, 
    -0.05870532f, -0.08844549f, -0.11328515f, -0.00377957f, -0.13318565f, -0.11443804f, 0.15365608f, 0.10689312f, 
    0.00506629f, -0.05318933f, -0.10772146f, 0.03636781f, 0.04558874f, 0.10057209f, 0.00966673f, 0.03220769f, 
    0.43571061f, 0.14340018f, -0.09629185f, 0.22157271f, -0.05872647f, -0.11263909f, 0.08487428f, 0.04958669f, 
    0.36569679f, -0.03083855f, 0.17533180f, 0.10342245f, 0.11314335f, -0.04230582f, -0.26268864f, -0.04699160f, 
    0.05958165f, -0.01756546f, 0.25827745f, 0.01139460f, 0.28612056f, 0.16282935f, 0.20291469f, 0.26748413f, 
    -0.36475873f, -0.30854988f, 0.02359521f, 0.13979423f, -0.16813713f, -0.08422249f, 0.07604713f, 0.08801149f, 
    0.10554154f, -0.02778217f, 0.03823182f, 0.16918916f, 0.02827716f, 0.08531338f, -0.12043988f, 0.02508536f, 
    0.16170666f, -0.02547695f, 0.07342090f, -0.03880848f, 0.07314617f, -0.10551983f, 0.03283434f, -0.02917938f, 
    0.03037287f, 0.25141543f, 0.11070524f, 0.20687470f, -0.17558932f, -0.06722244f, -0.00115946f, -0.01105531f, 
    0.00912011f, -0.05694842f, -0.04368088f, 0.00608052f, -0.07723276f, 0.04772566f, 0.03294151f, -0.11381631f, 
    -0.02772839f, -0.05478102f, -0.01343056f, -0.02351485f, 0.07107083f, 0.18189481f, 0.16669585f, -0.07850241f, 
    0.01332395f, -0.25609609f, 0.00954050f, 0.29449606f, 0.06875873f, -0.04477330f, 0.08187557f, -0.07531122f, 
    0.04720348f, -0.07192147f, 0.09866760f, -0.04228691f, 0.02894644f, 0.11711791f, 0.05307043f, -0.10323301f, 
    0.13290361f, 0.00359328f, -0.05384229f, 0.13597436f, -0.16130286f, -0.02202089f, -0.17415000f, -0.07947936f, 
    0.03725139f, 0.22120772f, -0.13380854f, 0.27803433f, 0.08896725f, 0.09832498f, -0.14168037f, 0.08423157f, 
    -0.18061498f, 0.06724402f, -0.05343909f, 0.16029237f, -0.09317624f, -0.08811903f, 0.05346949f, 0.01848086f, 
    -0.09364042f, 0.03977392f, 0.07728411f, -0.03798438f, 0.09903094f, 0.15246429f, 0.07229058f, 0.36933154f, 
    0.00561135f, 0.38036215f, 0.07284402f, -0.14843884f, 0.19060379f, -0.11835938f, 0.03458059f, 0.11107947f, 
    0.11113194f, 0.12972139f, 0.09500168f, 0.14971183f, 0.29046810f, -0.05582220f, -0.03744916f, 0.00782514f, 
    -0.01538563f, 0.07034040f, -0.08240917f, 0.00961471f, 0.05317910f, 0.13611832f, 0.14732616f, 0.10827111f, 
    0.10343317f, 0.03632838f, -0.02447186f, -0.05364540f, 0.14841963f, -0.26482368f, -0.10763402f, -0.18674751f, 
    -0.07764567f, 0.02021713f, -0.04644608f, -0.08918387f, 0.08700710f, -0.21929130f, -0.02491482f, -0.35200992f, 
    -0.09982248f, -0.00609023f, -0.12338338f, -0.14914323f, 0.04988863f, 0.03689622f, -0.05607480f, -0.06173165f, 
    0.17566586f, 0.16496024f, -0.28520906f, -0.03793555f, 0.09504803f, 0.05656532f, -0.31817979f, -0.13836195f, 
    -0.02519643f, 0.03872425f, 0.15732284f, 0.07976900f, 0.14634456f, -0.10260484f, -0.05835276f, 0.10586660f, 
    0.07568741f, 0.01763998f, -0.15163922f, -0.06509335f, -0.04022846f, -0.20885353f, -0.27063543f, -0.11094762f, 
    0.24177122f, 0.01600643f, -0.18715963f, 0.23916344f, -0.00203396f, -0.16462065f, 0.00192839f, -0.09170531f, 
    -0.15669690f, 0.02556828f, -0.15869102f, 0.13938592f, -0.23482445f, 0.23056036f, 0.06367642f, 0.13456579f, 
    0.14990166f, 0.08233937f, 0.04263003f, -0.04326019f, -0.09420602f, -0.30372879f, -0.20262107f, -0.10009655f, 
    -0.10903646f, 0.07435334f, -0.01701646f, 0.00297084f, -0.07810514f, -0.04138760f, 0.03553910f, 0.01529628f, 
    -0.10279448f, 0.03973206f, -0.09288608f, -0.00391384f, -0.17656298f, -0.00234644f, 0.26288044f, -0.23570167f, 
    -0.07636663f, -0.01506988f, -0.04767782f, 0.05811043f, -0.03008430f, 0.19707553f, 0.05816724f, -0.00669553f, 
    0.00121952f, -0.00167536f, -0.24954771f, -0.13514124f, 0.03986163f, -0.03057646f, 0.11756533f, -0.09075502f, 
    -0.06056597f, 0.21258730f, -0.03501783f, -0.28125706f, -0.09266200f, 0.11285314f, -0.02002046f, -0.17742446f, 
    -0.01970260f, -0.01473536f, -0.07228626f, -0.17640172f, 0.08755720f, 0.01616835f, 0.22462861f, 0.32551670f, 
    -0.01090058f, -0.03990111f, -0.00843691f, -0.05574412f, -0.05078947f, -0.02779923f, 0.04416639f, 0.02336166f, 
    -0.01440394f, -0.03357962f, -0.04566669f, -0.01263577f, 0.00836099f, 0.00882436f, 0.00054247f, -0.04119896f, 
    -0.05530595f, 0.02863235f, -0.00989220f, -0.03814956f, -0.03041217f, -0.00467509f, -0.03301999f, -0.04015190f, 
    -0.02779012f, 0.04079572f, 0.02713652f, -0.02240165f, -0.02945810f, 0.04959275f, -0.01458770f, 0.04675065f, 
    0.03191503f, -0.02636982f, -0.02260991f, 0.01291485f, -0.03278307f, 0.03089286f, -0.03872287f, -0.01936217f, 
    -0.00957575f, -0.01639398f, -0.03372228f, -0.02443726f, 0.00157579f, 0.00251412f, -0.04024873f, -0.00291219f, 
    0.01598616f, -0.05139037f, 0.03694282f, 0.03661923f, 0.03445075f, 0.01554493f, 0.04786491f, 0.03400455f, 
    -0.01858991f, -0.02873473f, -0.02087015f, -0.00560832f, -0.00925749f, 0.00416506f, -0.02763462f, -0.03000133f, 
    -0.03841338f, 0.01885749f, 0.03006156f, 0.00372991f, -0.04420781f, 0.01668543f, -0.04440993f, -0.01841649f, 
    -0.02062331f, 0.01925199f, 0.01710197f, 0.01695263f, -0.01313443f, -0.04787462f, 0.04212357f, -0.03460455f, 
    0.00257646f, 0.00917977f, -0.04175259f, -0.03034725f, -0.05275135f, -0.03327516f, -0.04829335f, 0.00284206f, 
    0.03281722f, -0.02516774f, -0.04264625f, 0.01778652f, -0.02995012f, -0.05112521f, -0.02699818f, -0.03518034f, 
    -0.00112466f, -0.04559562f, 0.03798747f, -0.01305054f, -0.03561977f, -0.01825758f, 0.01519862f, -0.03236367f, 
    -0.01696643f, 0.02876759f, 0.03479210f, -0.04977698f, 0.03059749f, -0.01536658f, -0.05158410f, -0.04790631f, 
    -0.00961574f, 0.03376960f, 0.03552928f, -0.00312217f, -0.02172711f, -0.02454292f, -0.05428833f, -0.01147291f, 
    0.03584362f, -0.04427590f, -0.04712680f, -0.04215999f, 0.02429463f, 0.01221969f, 0.01489196f, -0.00995238f, 
    -0.01399411f, 0.04659822f, 0.00701385f, -0.01529475f, -0.02020742f, -0.00689547f, 0.00853154f, -0.03717907f, 
    -0.03279142f, -0.00083051f, 0.01169107f, 0.02919645f, 0.04109022f, -0.01729801f, -0.05922246f, -0.00230423f, 
    -0.04771563f, 0.04891287f, -0.04911628f, -0.04593745f, -0.04729353f, -0.02011279f, 0.04591132f, -0.01192022f, 
    -0.01322480f, -0.00406279f, 0.04773637f, 0.04359044f, -0.05128942f, -0.04913013f, -0.03937159f, -0.04224792f, 
    -0.00401168f, -0.00774441f, 0.02064471f, 0.02283977f, -0.00153397f, -0.01317045f, -0.04980700f, -0.01691289f, 
    -0.01722108f, -0.04101498f, -0.01698416f, -0.04900245f, -0.02427753f, -0.03313402f, -0.04619665f, -0.05039475f, 
    -0.05413822f, 0.03023284f, -0.02424577f, 0.01940331f, -0.04986493f, -0.02422032f, 0.01092564f, -0.04734704f, 
    0.04784933f, 0.03345205f, -0.03839307f, 0.02145683f, 0.02513194f, -0.04491901f, -0.01898152f, 0.02114662f, 
    0.02283369f, 0.03412382f, -0.00708886f, 0.00178425f, -0.00886220f, 0.03086947f, 0.00053456f, 0.01449140f, 
    -0.04233731f, 0.02776776f, -0.02253430f, 0.00130635f, -0.04269929f, -0.01967573f, -0.01823347f, 0.03645213f, 
    0.02784013f, -0.00765955f, -0.01373263f, -0.00300236f, 0.03762823f, -0.02049558f, 0.00130128f, 0.00687349f, 
    -0.02760744f, 0.05060387f, 0.03702904f, 0.03356436f, -0.00393512f, 0.03898723f, 0.05426712f, 0.00515196f, 
    -0.01463139f, -0.02954644f, 0.03832690f, 0.00898393f, 0.01675765f, -0.00922887f, -0.04420843f, 0.03090742f, 
    -0.02132723f, -0.00331176f, 0.03934252f, -0.04350746f, 0.00275387f, -0.01024538f, 0.03906498f, -0.03959949f, 
    -0.02542734f, 0.00707589f, 0.01375615f, -0.04120110f, -0.03136817f, -0.04564082f, 0.04434378f, 0.01402105f, 
    -0.02779481f, 0.02209089f, 0.01943467f, -0.02224662f, 0.04165859f, 0.02952254f, 0.01627776f, -0.03194947f, 
    -0.05343759f, 0.03371423f, 0.04874782f, -0.00603917f, -0.04019448f, -0.02797350f, 0.00053203f, -0.02265090f, 
    0.03028910f, -0.03686622f, -0.00639381f, -0.02261562f, -0.01332559f, 0.00405746f, -0.03804760f, 0.00732393f, 
    0.02764161f, 0.01433910f, -0.00930275f, -0.04320332f, -0.02773977f, -0.03831216f, 0.02020608f, 0.02290289f, 
    -0.02976334f, -0.02959096f, -0.00637447f, -0.05086349f, 0.03767263f, 0.01338039f, 0.02662970f, -0.04622021f, 
    -0.03064714f, 0.01918613f, -0.03358447f, 0.02503780f, 0.04073560f, 0.03038452f, 0.02093676f, 0.00511150f, 
    -0.02993519f, 0.03666463f, 0.05099054f, 0.00270533f, -0.02808846f, -0.02988955f, -0.03921106f, -0.01882251f, 
    0.02867524f, -0.04491898f, -0.05111834f, -0.03694097f, -0.05606940f, 0.03853197f, -0.05126565f, 0.01640982f, 
    0.01287869f, -0.03762783f, 0.01176304f, 0.00399739f, -0.02498088f, 0.00829099f, 0.00949017f, 0.03283447f, 
    0.00360269f, 0.00625871f, 0.00237620f, -0.05754500f, -0.04599878f, 0.02618289f, 0.00866618f, -0.00736651f, 
    -0.05156266f, -0.01471174f, 0.03664526f, 0.01063664f, 0.02153616f, 0.02462164f, 0.05222222f, 0.00257448f, 
    0.00754370f, 0.03974989f, 0.03268510f, -0.02010100f, -0.00176490f, 0.01754788f, -0.04413129f, -0.04263426f, 
    0.04266859f, 0.01227643f, -0.04465183f, -0.00965304f, -0.03484619f, -0.04438033f, 0.01406650f, 0.02279764f, 
    0.03951684f, -0.01998862f, -0.05257659f, -0.01758708f, -0.00278472f, 0.01750948f, -0.01498727f, 0.00945135f, 
    -0.04131393f, 0.04057080f, -0.02126195f, 0.01840839f, -0.01874705f, -0.04485581f, -0.04281877f, -0.02403608f, 
    0.03249139f, 0.00795919f, -0.02686926f, -0.03592248f, -0.01526340f, 0.03354932f, 0.02246551f, 0.02254908f, 
    -0.00256850f, 0.01043201f, -0.00501768f, -0.04558236f, -0.04742154f, 0.00286080f, -0.03460932f, -0.01933130f, 
    -0.01209489f, -0.06970287f, -0.07634185f, -0.01132680f, -0.14839831f, 0.09292196f, 0.13454939f, -0.18452992f, 
    0.07221024f, 0.01769236f, 0.05253736f, 0.00994901f, -0.12237626f, 0.07049496f, -0.17852625f, 0.06530135f, 
    -0.06759791f, 0.07601978f, 0.06581248f, 0.11860188f, 0.12776747f, 0.11105260f, 0.14583248f, -0.00267091f, 
    0.21360856f, -0.20609497f, -0.05091602f, 0.12844072f, -0.02896798f, 0.01583216f, 0.14005272f, -0.03003044f, 
    -0.09244262f, -0.01216205f, 0.04307382f, 0.14389345f, 0.07839420f, 0.11365601f, -0.05211131f, -0.00879769f, 
    -0.12623189f, 0.02518247f, 0.02681083f, 0.19504717f, 0.04682955f, -0.04743011f, -0.04951157f, -0.09382609f, 
    0.26051417f, 0.15342201f, 0.12983964f, -0.05424203f, 0.05126669f, 0.05472664f, -0.00194327f, 0.10478778f, 
    -0.10071430f, -0.13955505f, -0.11558183f, -0.06721308f, 0.04232176f, 0.00714053f, -0.41911390f, 0.22048263f, 
    0.03900559f, -0.10564155f, -0.04814186f, 0.06848986f, 0.15227637f, 0.04732476f, -0.01438158f, 0.12936467f, 
    0.02767737f, 0.29581770f, 0.02445445f, 0.08762568f, 0.06800505f, -0.10230660f, -0.02041386f, -0.00746458f, 
    -0.08107899f, 0.01861455f, -0.03841105f, -0.13946629f, -0.04009474f, -0.04072914f, -0.03593286f, -0.08835477f, 
    0.01999274f, 0.12705912f, -0.20676559f, 0.13469307f, 0.02609711f, -0.01210845f, 0.06928312f, 0.15956749f, 
    -0.13346578f, 0.04957985f, 0.00073376f, -0.05139975f, -0.00314523f, 0.08004487f, -0.01130847f, 0.10193009f, 
    0.05556078f, -0.02708889f, 0.12067125f, 0.08795392f, 0.30935696f, 0.12673675f, 0.19051543f, 0.01137740f, 
    0.05681253f, 0.12170336f, -0.11170404f, -0.02262965f, 0.00696514f, -0.06826573f, -0.05434597f, -0.10260308f, 
    -0.12178257f, -0.02646258f, -0.06362210f, -0.16254339f, -0.00357412f, 0.02351896f, 0.19127056f, 0.00405788f, 
    0.26586053f, -0.22793531f, -0.02039661f, -0.09247907f, -0.03402130f, -0.26571676f, -0.26040840f, -0.07377166f, 
    -0.06311722f, -0.04913877f, 0.13246612f, -0.08124676f, -0.07419539f, -0.30034316f, -0.05267458f, -0.17258155f, 
    -0.05414132f, 0.13145341f, 0.02466302f, -0.00204961f, 0.02208154f, -0.05904215f, 0.07849783f, 0.07803116f, 
    -0.12720892f, -0.21187595f, -0.05483080f, -0.09192236f, -0.09999144f, -0.08305903f, -0.05537397f, 0.04366234f, 
    -0.12746929f, -0.12088840f, 0.11026493f, 0.04661034f, 0.15751761f, 0.11398344f, 0.03905792f, -0.06806251f, 
    -0.28285342f, 0.11562624f, 0.07132024f, 0.10057370f, -0.07635859f, -0.02567939f, 0.00467659f, 0.09159500f, 
    0.04478879f, 0.04907567f, 0.04123033f, -0.06000963f, -0.08671084f, -0.26477757f, -0.18025517f, -0.07624821f, 
    -0.07079960f, 0.01460073f, -0.03767505f, 0.10601151f, 0.06332010f, -0.18999591f, 0.06146121f, -0.14609973f, 
    -0.03067094f, 0.15500154f, 0.16766284f, -0.06003116f, 0.08008433f, -0.03339397f, 0.17597826f, -0.03433295f, 
    -0.03931523f, -0.00060728f, 0.00669826f, -0.07284821f, -0.00809288f, -0.08030457f, -0.01514229f, 0.25879911f, 
    -0.06276386f, -0.08965155f, 0.09984238f, 0.01888621f, 0.06225761f, 0.04733865f, 0.05670333f, 0.04613305f, 
    -0.42501062f, -0.22035542f, -0.38358393f, -0.02477103f, 0.12255459f, -0.13581167f, 0.25931534f, 0.05132404f, 
    0.04471562f, 0.02691942f, -0.14970715f, 0.15750001f, 0.07149947f, 0.02172336f, 0.19124937f, 0.06440737f, 
    0.00047812f, 0.10210031f, 0.10859469f, 0.11475033f, 0.10851728f, -0.04954440f, -0.24682286f, -0.09942938f, 
    -0.08202454f, -0.19128583f, -0.03918147f, 0.16367966f, 0.14326531f, 0.02740600f, 0.01402839f, -0.01127410f, 
    0.10662312f, -0.18412818f, 0.01119337f, 0.08210339f, -0.30220243f, 0.28090897f, -0.05347628f, 0.10037520f, 
    0.10688135f, -0.10669120f, 0.00683916f, 0.03231671f, -0.09836926f, 0.12554938f, -0.04558071f, 0.04057864f, 
    -0.18157929f, 0.11615934f, -0.01678924f, -0.05698885f, 0.01962864f, 0.02820684f, -0.02365474f, 0.02679378f, 
    0.07080522f, 0.10525375f, 0.00701446f, 0.00445238f, -0.23681886f, -0.13058355f, -0.12061852f, 0.08526473f, 
    -0.09772912f, -0.07071800f, -0.06845935f, -0.05064562f, 0.11537156f, 0.04644603f, 0.07415558f, 0.13024384f, 
    -0.10692121f, -0.26153174f, -0.19387093f, -0.19459419f, 0.05012048f, -0.06824425f, 0.01656653f, -0.07410065f, 
    0.19351184f, 0.04255395f, -0.08434300f, 0.13614790f, 0.03917226f, 0.04814464f, 0.02277181f, 0.06533344f, 
    0.10334421f, 0.03537253f, 0.12627716f, -0.00810289f, 0.14951159f, 0.05727543f, -0.08244852f, 0.02301879f, 
    0.23832737f, -0.24804138f, 0.14391004f, 0.31049630f, 0.12463116f, -0.02727181f, -0.00103434f, 0.30780959f, 
    0.05215621f, -0.00137792f, 0.02349505f, -0.05874262f, -0.16089894f, 0.14063455f, 0.12393339f, 0.08131444f, 
    -0.20717168f, -0.06514964f, 0.08629134f, 0.23349705f, -0.05943695f, -0.03902913f, 0.03287452f, -0.12271773f, 
    0.13761319f, 0.13901225f, 0.16742462f, 0.18781689f, 0.25109592f, 0.20049275f, -0.11372323f, 0.13727663f, 
    0.01266566f, -0.01776824f, 0.08621313f, 0.09029985f, 0.05065554f, -0.16235927f, 0.13016081f, 0.02120624f, 
    -0.12904939f, 0.04920594f, -0.02888040f, 0.01696907f, -0.02439357f, 0.01768081f, -0.13276385f, 0.13924819f, 
    0.15343072f, -0.07120080f, -0.12965047f, 0.05586737f, 0.00411082f, 0.23905511f, 0.06777353f, 0.02569800f, 
    -0.08302739f, -0.05717926f, 0.12345632f, -0.26976407f, -0.19472274f, -0.05921641f, 0.03642873f, -0.10216931f, 
    -0.04211076f, 0.01186643f, -0.08812764f, 0.03844546f, -0.02274038f, -0.01701503f, 0.05301655f, -0.07013068f, 
    -0.18278696f, 0.03022219f, -0.16382983f, 0.09026091f, 0.01673097f, -0.01067449f, 0.14756753f, -0.00814105f, 
    0.07005905f, 0.11583741f, 0.16484813f, 0.09986851f, 0.15216467f, -0.06747457f, 0.00637700f, -0.26746875f, 
    0.10557049f, -0.05292378f, 0.03526558f, -0.08175569f, 0.10996285f, -0.12579821f, 0.02616067f, 0.25511608f, 
    -0.00887163f, 0.02132300f, 0.16560429f, 0.08449163f, -0.00608830f, 0.01079614f, 0.01705507f, -0.06589988f, 
    -0.03743190f, 0.01742599f, 0.01635870f, -0.15232995f, 0.13175961f, -0.16968630f, -0.20427930f, -0.17047919f, 
    0.03327266f, -0.03412350f, -0.08944011f, 0.04241307f, -0.04679370f, -0.11258622f, 0.06137155f, -0.00275993f, 
    0.07900068f, -0.01474126f, -0.05622396f, -0.17428474f, 0.05098352f, 0.03993512f, 0.02104970f, 0.09867793f, 
    -0.12834656f, -0.05371553f, -0.09577042f, 0.00473484f, -0.20195232f, 0.26416767f, -0.03592539f, 0.22732562f, 
    -0.00683646f, -0.00388809f, 0.06297151f, -0.00306256f, -0.02823160f, -0.00748460f, -0.03413182f, 0.02109511f, 
    0.05975281f, 0.06655835f, -0.00121792f, -0.15143137f, -0.00483637f, -0.11493002f, 0.06594864f, 0.14527664f, 
    -0.05479611f, 0.01523457f, -0.06140691f, -0.06527708f, -0.15209629f, 0.11342041f, -0.03863004f, 0.01334456f, 
    0.01260218f, -0.14222631f, 0.05610555f, -0.06092180f, 0.00769080f, -0.01491789f, -0.00329349f, 0.05569495f, 
    -0.13688734f, 0.01232589f, -0.15406868f, 0.01055159f, 0.06901930f, 0.11086246f, -0.00607109f, 0.12112617f, 
    0.08184883f, 0.07755991f, -0.08820084f, 0.03391166f, 0.00946171f, 0.14097184f, -0.00974552f, -0.13841987f, 
    0.14004804f, 0.05585271f, 0.12099503f, 0.04075182f, -0.03062626f, -0.03033184f, 0.02499450f, 0.00050467f, 
    -0.36710474f, 0.02995924f, 0.00774984f, 0.03723865f, -0.08348709f, 0.09894722f, -0.06134563f, -0.02578607f, 
    0.05956396f, 0.17607111f, -0.10716693f, -0.03500200f, -0.09553557f, -0.05786649f, 0.00789170f, 0.00361079f, 
    0.00379586f, 0.02088818f, 0.03301451f, -0.03755462f, -0.05762914f, -0.07735832f, -0.06722315f, -0.12304644f, 
    0.19122483f, 0.10001031f, 0.10715302f, -0.10519480f, 0.15816578f, 0.04183353f, -0.07043263f, 0.05307329f, 
    0.03140048f, -0.03585334f, -0.02613097f, 0.04991262f, -0.00466368f, 0.07345171f, 0.10881065f, -0.10097669f, 
    -0.07654491f, 0.15580934f, -0.04064379f, -0.03573008f, 0.06986970f, 0.05283120f, 0.06368563f, -0.05997219f, 
    0.17145398f, -0.28465876f, -0.06943253f, -0.11607377f, 0.05243668f, -0.04344375f, 0.04024199f, 0.00336488f, 
    -0.03013376f, 0.10947593f, 0.10162321f, 0.03435084f, -0.00043269f, 0.06020131f, -0.05043111f, 0.15519571f, 
    -0.00639365f, -0.01793551f, -0.04258038f, 0.05368944f, 0.03766403f, -0.11271220f, -0.00767547f, 0.03694858f, 
    0.00591617f, 0.24806292f, 0.18835551f, 0.04698955f, -0.02248355f, 0.12647627f, 0.03449540f, 0.18690437f, 
    -0.03670025f, 0.08562828f, -0.05747035f, 0.08052909f, 0.01985586f, 0.02302925f, -0.04214091f, 0.10157263f, 
    -0.02489315f, 0.01039978f, -0.03874896f, -0.04033195f, 0.00837301f, 0.04693773f, 0.01209558f, 0.10239781f, 
    -0.18579842f, 0.30110005f, -0.32925147f, -0.01787990f, -0.09262118f, 0.00170498f, -0.09626482f, 0.07678227f, 
    0.13123378f, 0.01577278f, 0.05090423f, 0.04430937f, 0.08711064f, 0.04190642f, 0.11384235f, 0.13498603f, 
    0.11269739f, -0.00776791f, -0.09424475f, 0.05562513f, -0.02045712f, -0.00800677f, -0.00486051f, -0.20909336f, 
    -0.00003048f, -0.04085908f, -0.14827353f, -0.07478579f, -0.17182122f, 0.05867149f, 0.11899171f, 0.20253164f, 
    0.15480830f, 0.08913432f, -0.08699057f, 0.01256447f, -0.29332212f, 0.11358421f, -0.01371334f, -0.11605668f, 
    0.00821552f, -0.09359322f, -0.03671648f, -0.10722987f, -0.05199054f, 0.01728623f, -0.08000357f, 0.06658033f, 
    -0.15512028f, 0.06183707f, 0.03417896f, -0.17365809f, -0.04760725f, 0.02018016f, 0.03700460f, -0.13060842f, 
    0.02507221f, 0.19172487f, 0.04886242f, 0.02860365f, 0.17126095f, -0.05551464f, 0.03650296f, -0.05601986f, 
    0.00634479f, -0.05919750f, -0.08088333f, -0.01651989f, -0.05805115f, 0.08306641f, 0.16944794f, 0.09397013f, 
    -0.18685609f, 0.33335394f, -0.10184592f, 0.34147736f, 0.00117326f, 0.01502784f, -0.02956901f, -0.03426824f, 
    -0.07580382f, -0.00700753f, 0.08081108f, 0.03950288f, -0.03147462f, -0.15176660f, 0.00670218f, -0.17520408f, 
    0.16474529f, 0.09700883f, -0.03339819f, 0.02383048f, 0.13966723f, -0.01080733f, -0.09565049f, -0.04456055f, 
    -0.18807293f, 0.35496724f, -0.07636647f, -0.11089460f, 0.09635016f, 0.02331255f, 0.06504392f, 0.09086826f, 
    0.04637260f, -0.09396751f, 0.01576562f, -0.03835904f, -0.12657605f, -0.05755512f, -0.33907211f, 0.02512139f, 
    0.06854247f, 0.02520805f, -0.06069994f, -0.04553806f, -0.04835408f, 0.00869177f, -0.02797072f, 0.00140267f, 
    -0.04080722f, 0.09266846f, -0.23716301f, 0.06954636f, 0.03798755f, -0.00706035f, 0.11263128f, 0.02894204f, 
    -0.06527978f, -0.03939610f, -0.03303250f, 0.04714606f, 0.30846500f, 0.08424404f, 0.03760529f, -0.07188489f, 
    -0.08440308f, -0.10421088f, 0.00444145f, 0.09554236f, 0.12082998f, -0.04087491f, 0.01883094f, 0.00275926f, 
    -0.13327530f, 0.36425945f, 0.07529350f, 0.19197594f, 0.06922792f, -0.10768751f, 0.00225075f, 0.04381563f, 
    0.10353284f, -0.10425074f, 0.07955961f, 0.06364366f, 0.05000509f, -0.24953531f, 0.02803206f, -0.10767543f, 
    0.02936230f, -0.07049798f, -0.02662530f, 0.01258510f, -0.08932672f, 0.05572950f, -0.04354380f, -0.11597230f, 
    0.22965091f, -0.02776184f, 0.15706456f, -0.13002850f, -0.07410468f, -0.15391015f, -0.09002874f, 0.08413433f, 
    0.02113056f, 0.07633742f, 0.04926789f, -0.03082479f, -0.02840873f, 0.07496230f, -0.09093201f, 0.15832202f, 
    -0.00096892f, -0.06858605f, 0.00405524f, -0.00951386f, 0.00183504f, 0.03430481f, -0.06001043f, -0.02226822f, 
    0.29395360f, 0.16764809f, -0.18819505f, -0.15869205f, -0.03608594f, -0.06828189f, -0.04220351f, 0.03863915f, 
    -0.01356663f, -0.03697170f, -0.19111489f, -0.05298232f, -0.24144424f, 0.15649700f, 0.21726072f, 0.05855823f, 
    -0.06969884f, -0.11661458f, -0.03067501f, 0.03990970f, 0.00106741f, 0.17439687f, 0.02414836f, -0.07218178f, 
    -0.24079901f, -0.07591735f, 0.04103542f, 0.12913799f, 0.04504410f, 0.15886414f, 0.11192194f, 0.03442523f, 
    0.13569079f, -0.02350278f, 0.02961813f, 0.09858863f, 0.25076950f, -0.09745310f, 0.09838277f, -0.25588322f, 
    -0.10371950f, -0.05462884f, -0.13601825f, -0.09424757f, -0.01617480f, -0.03007410f, -0.08350478f, -0.00774618f, 
    -0.21720828f, -0.23031057f, 0.08499374f, 0.15704626f, 0.17893782f, 0.20355703f, 0.02267909f, -0.16397332f, 
    0.09899904f, 0.04644426f, 0.01059479f, 0.16379738f, 0.00116451f, -0.15675206f, 0.00721761f, -0.05306185f, 
    -0.19251922f, -0.08702681f, -0.12140889f, -0.04553294f, -0.14503731f, -0.11297439f, -0.02640729f, -0.05114033f, 
    0.02869870f, -0.08439521f, 0.18173812f, 0.01530553f, -0.05044228f, -0.09942847f, 0.16649123f, -0.04820546f, 
    -0.04543751f, -0.03229893f, 0.02541151f, -0.06381619f, -0.37512255f, -0.36005875f, 0.11255683f, 0.11098828f, 
    0.03008108f, 0.06942776f, 0.02225772f, -0.03990697f, 0.03059393f, 0.07612173f, -0.01688533f, -0.01153958f, 
    0.68631661f, 0.08465746f, 0.06101706f, 0.14799881f, 0.09352934f, -0.16496016f, -0.00171449f, 0.06494970f, 
    -0.00970350f, -0.03516196f, 0.00792772f, 0.07994489f, 0.14150396f, 0.10666745f, -0.08704565f, -0.05292790f, 
    -0.06810040f, -0.09734489f, 0.01472449f, 0.01685951f, 0.13072512f, 0.10687896f, 0.02566035f, -0.11933536f, 
    -0.24612805f, -0.29694781f, 0.02545764f, 0.23692207f, -0.14510573f, -0.03491328f, 0.00900358f, -0.00644494f, 
    -0.03708733f, 0.03978547f, -0.00212351f, -0.03842218f, 0.07263591f, 0.08608477f, 0.02006782f, -0.07944843f, 
    0.10330349f, -0.10818706f, 0.03293055f, 0.03220659f, 0.07325397f, -0.10423812f, -0.04828550f, -0.05398015f, 
    -0.06369177f, 0.31530988f, 0.24821037f, 0.11429539f, -0.10835214f, -0.02456912f, 0.00589121f, 0.03550727f, 
    0.13036081f, 0.09859594f, -0.06185952f, 0.03329341f, -0.01515668f, 0.18405373f, 0.01930140f, -0.07116249f, 
    -0.05000555f, -0.09936717f, -0.11131599f, -0.05789010f, -0.00962963f, 0.01002538f, -0.02155389f, -0.04147674f, 
    0.04287381f, -0.36211276f, 0.08171577f, 0.05717284f, 0.09041284f, 0.02649319f, -0.01654159f, -0.05922417f, 
    0.02463239f, -0.02335458f, 0.00826623f, -0.03132423f, 0.13613802f, 0.10646450f, 0.19173619f, -0.15808423f, 
    0.01004989f, -0.09890665f, -0.13683899f, 0.07014450f, -0.08500525f, -0.05269398f, -0.02106981f, 0.00558848f, 
    0.65059859f, -0.12515996f, 0.62727785f, 0.16713123f, -0.01751237f, 0.11166459f, -0.04139522f, -0.01656003f, 
    -0.02415473f, 0.07676298f, -0.00106039f, 0.11924913f, -0.09920201f, 0.17027707f, 0.11426076f, -0.06395421f, 
    -0.02835882f, 0.14576651f, -0.01501288f, 0.07451449f, -0.02559055f, 0.09954661f, 0.13621636f, 0.01871785f, 
    0.22635695f, 0.29888284f, 0.28949809f, 0.09446145f, 0.06982995f, 0.02719553f, -0.03272754f, 0.03004405f, 
    0.19984199f, -0.00207745f, 0.07532790f, 0.00896032f, 0.30437541f, 0.09761693f, 0.05746327f, 0.05315818f, 
    -0.17555641f, -0.06305453f, -0.04906232f, -0.04763712f, -0.04608785f, 0.16810757f, 0.06783327f, -0.06700131f, 
    0.26455805f, 0.09327813f, 0.33593512f, 0.10913328f, 0.04755351f, -0.13529323f, 0.10313474f, 0.09147254f, 
    0.12294827f, -0.02517290f, 0.13533261f, 0.08225972f, -0.19828176f, -0.01355852f, -0.14138526f, -0.25122294f, 
    -0.09347297f, -0.06210110f, -0.12863897f, -0.06515191f, -0.05152517f, 0.04419753f, 0.02828232f, 0.03689928f, 
    0.52689612f, -0.03706523f, 0.05099555f, -0.15063758f, -0.02422119f, 0.01282318f, 0.02976380f, -0.01295095f, 
    0.01430133f, -0.14269008f, 0.07766178f, 0.16487505f, -0.12109049f, -0.09596271f, 0.03322439f, 0.18324389f, 
    0.03676239f, 0.02797951f, -0.03142922f, 0.16300704f, -0.14717567f, 0.15363874f, 0.06915643f, 0.06069443f, 
    0.22893026f, -0.02255163f, 0.07555678f, -0.01976936f, -0.08488730f, -0.07383648f, 0.01515501f, -0.03245206f, 
    -0.11806980f, 0.02170741f, 0.21165274f, 0.15590075f, -0.07159323f, -0.09963916f, 0.20570813f, 0.01887416f, 
    -0.12645833f, -0.04871902f, -0.05137879f, -0.05636337f, -0.07489473f, -0.02812708f, 0.03219994f, 0.04401634f, 
    -0.06603863f, -0.14623716f, 0.13065000f, 0.20030330f, -0.02491372f, 0.25765309f, -0.06908881f, -0.06157031f, 
    -0.06169882f, 0.06469926f, -0.07741376f, 0.01249403f, -0.30617195f, 0.41532108f, 0.29627454f, -0.15528123f, 
    0.10053454f, -0.04997700f, -0.00878749f, -0.00230898f, -0.04822356f, 0.11052591f, 0.04483028f, -0.04373974f, 
    0.09882116f, -0.27409029f, -0.04047124f, -0.17810142f, -0.16033816f, 0.07441575f, 0.08603477f, -0.01047902f, 
    -0.00129083f, 0.02215056f, 0.01256335f, -0.09736921f, -0.07483037f, 0.27797517f, -0.02459638f, 0.08015369f, 
    -0.04645762f, -0.05569434f, -0.05297137f, -0.11468551f, 0.00570367f, 0.00029215f, -0.01876033f, -0.02567817f, 
    0.07438128f, 0.00066280f, 0.02120061f, 0.00384609f, 0.08024469f, -0.02105175f, 0.00991792f, -0.09427960f, 
    0.05995169f, -0.08980611f, -0.11739341f, 0.04477133f, -0.46296740f, 0.08994941f, 0.08232601f, 0.12536371f, 
    -0.29944628f, -0.04335564f, 0.00230110f, 0.02453388f, -0.05459834f, 0.04207032f, -0.07803153f, -0.04708428f, 
    -0.43778878f, -0.07260489f, 0.11229048f, 0.20127507f, 0.00374600f, 0.04223792f, 0.04139911f, 0.13731337f, 
    0.08239333f, 0.04300706f, 0.02882791f, 0.14079979f, -0.01065073f, 0.19169515f, -0.00582818f, -0.06147104f, 
    0.02380559f, 0.07717548f, 0.02098607f, -0.03436538f, 0.12064283f, 0.13516454f, -0.04260428f, -0.09596869f, 
    -0.08057918f, 0.16927885f, -0.07407653f, 0.07913729f, -0.07590681f, -0.10410760f, -0.02224147f, -0.03529223f, 
    0.00740509f, -0.00465292f, 0.01404716f, 0.10485372f, 0.55792040f, -0.03304195f, -0.04580714f, -0.07488483f, 
    0.05104290f, -0.03914050f, 0.05354933f, 0.05582442f, -0.00156495f, 0.01976674f, -0.07604221f, 0.04983182f, 
    0.20893940f, 0.17132181f, -0.17844611f, -0.01572991f, 0.04634206f, -0.07137091f, -0.03618437f, -0.02822549f, 
    0.02189929f, -0.04697035f, 0.02788160f, -0.03000610f, 0.20586978f, 0.01031582f, -0.01396176f, 0.11607510f, 
    -0.02835897f, 0.06806748f, 0.04219348f, 0.00626976f, -0.00535606f, -0.00465608f, 0.01943478f, 0.03278210f, 
    0.30979228f, -0.07180999f, -0.12198213f, -0.02035228f, 0.22434723f, -0.00347876f, -0.07758954f, -0.12812547f, 
    -0.05455931f, -0.00335314f, -0.03605024f, 0.01458153f, 0.27169529f, 0.34130755f, 0.27249223f, 0.13824639f, 
    0.03780090f, 0.05336942f, -0.09261514f, -0.08936121f, 0.11139236f, 0.01596461f, 0.00656898f, 0.07520769f, 
    -0.32113540f, 0.00295089f, 0.05488748f, -0.08793774f, -0.03381893f, 0.01671234f, -0.00133533f, 0.14827915f, 
    0.00539260f, -0.10424618f, 0.02707803f, 0.05132114f, 0.15626688f, -0.03202146f, -0.05368828f, -0.01739637f, 
    0.06313212f, 0.07978798f, 0.03113302f, 0.07995206f, 0.02519022f, -0.16417101f, 0.01396748f, 0.22204667f, 
    0.04633589f, 0.23569487f, 0.04726879f, -0.03047190f, 0.05232980f, 0.03624238f, 0.04275319f, -0.07658850f, 
    0.01785089f, -0.02833133f, 0.02821613f, -0.02209610f, 0.05910148f, -0.14150280f, -0.00276744f, 0.18920174f, 
    0.05596611f, -0.00869887f, -0.02973123f, 0.03522085f, -0.02118124f, 0.00390528f, 0.09022331f, 0.06502984f, 
    0.02678179f, 0.23239885f, -0.01678170f, -0.15804160f, -0.02636244f, -0.04240509f, -0.08964176f, 0.02545675f, 
    -0.01144272f, -0.02610448f, -0.03424834f, -0.08047377f, 0.21154760f, -0.12840210f, -0.03083940f, -0.07549258f, 
    0.06239811f, 0.03964175f, 0.00642921f, -0.04636992f, -0.04958049f, 0.14874975f, 0.09837274f, 0.04361964f, 
    -0.01401707f, 0.17965558f, 0.01775727f, 0.09334893f, 0.01793223f, -0.00381661f, 0.11666676f, -0.01810202f, 
    0.01003302f, -0.00305141f, 0.15928777f, -0.00114490f, -0.00215951f, -0.01168706f, 0.09379075f, 0.11698287f, 
    0.02526706f, -0.01921054f, 0.01505273f, -0.07157419f, 0.07330193f, 0.11938305f, 0.06723688f, 0.08414436f, 
    -0.04038543f, -0.14188823f, -0.12801351f, -0.21199933f, -0.02089219f, -0.05672105f, 0.10344650f, -0.12742633f, 
    0.05818631f, -0.04145722f, -0.16232948f, -0.00951444f, -0.01625207f, -0.05938806f, 0.01893817f, -0.09292271f, 
    -0.07136124f, -0.02835098f, 0.06434461f, -0.00913114f, 0.00248843f, -0.06538283f, -0.10276722f, 0.05126414f, 
    0.72914088f, -0.22644374f, -0.29084197f, -0.25306302f, 0.18320537f, -0.08100656f, -0.04417498f, -0.14314440f, 
    0.02162146f, -0.05451408f, 0.01330341f, -0.06309488f, -0.10697210f, 0.06262500f, 0.17466541f, 0.13562463f, 
    -0.01534853f, -0.01140849f, 0.04340887f, 0.09145715f, 0.12702903f, -0.02814060f, -0.02949843f, 0.05567598f, 
    0.09853739f, 0.09923098f, -0.00058850f, 0.07969891f, 0.02785499f, -0.10263839f, -0.06643108f, -0.02100165f, 
    0.08955753f, 0.05383597f, -0.08459634f, -0.09869401f, 0.06392399f, 0.05043134f, 0.16167493f, 0.11007176f, 
    -0.04969857f, -0.01661828f, 0.02205336f, 0.09450165f, -0.06063329f, -0.03740898f, -0.07977990f, -0.12671973f, 
    0.05102301f, -0.17981814f, 0.40262663f, 0.04230061f, 0.06187113f, -0.07311255f, 0.04671888f, 0.05122830f, 
    0.10740402f, 0.13291425f, 0.01438717f, 0.02436213f, -0.19315115f, 0.08166639f, 0.12956654f, 0.16038209f, 
    -0.03834467f, 0.00672553f, 0.19908147f, -0.07117432f, -0.06001046f, -0.03225240f, 0.05853253f, 0.00633198f, 
    -0.16805694f, -0.19526961f, 0.21650298f, 0.29767263f, 0.04829015f, 0.09394226f, 0.11006737f, 0.09677341f, 
    0.07369878f, 0.01852045f, 0.13373363f, -0.00124160f, 0.21991651f, -0.02843884f, -0.12557930f, 0.06792282f, 
    -0.09859966f, -0.08491385f, 0.00950958f, -0.10270427f, 0.03222141f, 0.01015371f, 0.03245069f, 0.07129723f, 
    0.24453914f, 0.12429912f, 0.11811849f, -0.04949386f, 0.05139228f, 0.08607139f, 0.04929980f, 0.00944892f, 
    0.00181644f, 0.02133393f, -0.00818878f, 0.06064931f, 0.28511122f, -0.29939994f, 0.07640761f, 0.18678495f, 
    -0.01038214f, 0.07776927f, -0.04266498f, -0.04644629f, -0.05336517f, -0.14609799f, -0.14338346f, 0.05940604f, 
    0.33309120f, -0.00314900f, -0.30026063f, -0.10063116f, 0.10699870f, 0.02216059f, -0.10332547f, -0.09289813f, 
    -0.05355351f, 0.10147557f, -0.04153352f, 0.10324372f, 0.16718461f, -0.00685120f, -0.10611150f, 0.00078109f, 
    0.07981779f, 0.06553275f, 0.10435821f, 0.07187649f, 0.11079231f, 0.02084866f, 0.18617645f, -0.02131477f, 
    0.01798911f, -0.05458224f, 0.03305866f, -0.05581436f, 0.00937670f, -0.04285672f, 0.02748554f, 0.02649204f, 
    0.02513352f, 0.01258774f, 0.01332212f, -0.05341883f, 0.03508725f, 0.03425129f, 0.00697568f, -0.00745960f, 
    -0.04968197f, 0.03748179f, 0.03287295f, -0.03265854f, -0.01742917f, 0.02124412f, 0.00712985f, 0.03416930f, 
    -0.02914049f, -0.01174046f, -0.03769739f, 0.02114445f, -0.05933503f, -0.00287006f, -0.03693684f, -0.02146018f, 
    -0.02777710f, -0.02621420f, -0.03110194f, 0.03121513f, 0.03682353f, 0.03495318f, -0.01586397f, 0.01946048f, 
    -0.04105556f, -0.01648382f, 0.01415329f, -0.03856819f, 0.03921751f, -0.03911252f, 0.02470083f, -0.03320277f, 
    -0.05728901f, -0.02115217f, 0.02298137f, 0.03032238f, -0.01312321f, -0.03604467f, 0.04457136f, 0.02757985f, 
    -0.02452367f, -0.01759964f, 0.03431913f, 0.02030771f, 0.02871001f, -0.00074141f, -0.03695263f, 0.01218331f, 
    0.01809767f, -0.04706102f, -0.04884260f, 0.00584500f, -0.01563475f, -0.02337595f, -0.00573782f, -0.03643779f, 
    0.03911461f, 0.02630614f, -0.02665469f, -0.01972886f, -0.01537861f, -0.00699491f, -0.05177454f, -0.02533061f, 
    0.02867592f, 0.04389913f, -0.00218087f, -0.04881039f, -0.03171536f, 0.00048406f, -0.00598477f, -0.02373154f, 
    0.01199271f, -0.00968533f, 0.03615009f, -0.03724734f, -0.03700066f, 0.03018261f, -0.01967433f, 0.00536604f, 
    0.03768781f, -0.04517452f, -0.00302500f, -0.04202604f, 0.03544068f, 0.00943269f, 0.02858569f, -0.03444885f, 
    0.02916748f, 0.03196905f, -0.06199037f, -0.00275998f, -0.00958963f, 0.03829476f, 0.03960259f, 0.03872481f, 
    -0.03901292f, -0.05037660f, -0.02540108f, 0.01966992f, -0.04052862f, 0.03001181f, -0.04032171f, 0.04376903f, 
    -0.01126704f, -0.02466782f, -0.04689161f, 0.00490054f, -0.02287034f, -0.00714816f, 0.03496741f, -0.04846730f, 
    0.01308405f, 0.04090157f, -0.02908047f, 0.01902016f, 0.02000297f, -0.03177888f, 0.03105371f, 0.04271791f, 
    -0.03613176f, 0.00580869f, -0.02383489f, -0.00274478f, -0.01779504f, -0.00686052f, 0.02403300f, -0.01951715f, 
    0.04834579f, -0.03536733f, -0.03065970f, -0.03031169f, -0.03630323f, 0.01306562f, 0.02695717f, 0.02525636f, 
    -0.05440566f, 0.01592283f, 0.04213384f, 0.00240934f, -0.05480345f, 0.02546428f, -0.01054256f, -0.05947486f, 
    -0.00784502f, 0.00448404f, 0.02021033f, -0.01507552f, -0.02490649f, 0.01134289f, -0.05888545f, -0.01728038f, 
    -0.02687289f, -0.04240988f, -0.00092600f, 0.03590222f, 0.03463594f, 0.01075294f, -0.01651630f, -0.04476837f, 
    0.03625485f, -0.02183862f, -0.04383609f, 0.01393992f, -0.04748966f, -0.01007476f, 0.04056810f, -0.03333759f, 
    -0.05457566f, 0.04153156f, -0.05935257f, -0.00335413f, -0.03114424f, -0.03822326f, -0.05502064f, 0.04592070f, 
    -0.00457150f, -0.04672116f, 0.01996518f, 0.05299539f, -0.02814264f, -0.02649887f, -0.01299129f, -0.01371875f, 
    -0.00641661f, 0.02898652f, -0.03312052f, 0.02133089f, 0.00362489f, -0.01456005f, -0.00143612f, -0.04688668f, 
    -0.00711936f, -0.00518915f, -0.05079025f, -0.06144124f, 0.01872579f, 0.00574527f, -0.01698177f, -0.03518647f, 
    0.00653576f, 0.02383708f, -0.01547245f, 0.02074911f, -0.02928719f, 0.01927493f, -0.03301503f, -0.03018949f, 
    0.04172698f, -0.02317076f, 0.02977717f, 0.00742734f, 0.03519075f, -0.02341979f, -0.04597162f, 0.01873867f, 
    -0.04067969f, 0.02805680f, -0.05706457f, 0.01306288f, -0.02561081f, 0.00536802f, 0.00530465f, 0.03074958f, 
    0.00141429f, -0.05644931f, 0.01190209f, -0.02964814f, 0.01940786f, 0.02591386f, 0.02469685f, -0.02020168f, 
    0.01370683f, 0.03392594f, -0.03499813f, -0.01274869f, -0.00966963f, -0.03026195f, -0.01813401f, -0.05029046f, 
    -0.00714415f, -0.02000497f, 0.03637256f, -0.05588797f, 0.01058454f, -0.02126282f, 0.04704300f, -0.01044105f, 
    -0.00077118f, 0.02425986f, -0.04832500f, -0.04723576f, -0.04766182f, 0.00241039f, 0.01491063f, -0.05305824f, 
    -0.00821349f, -0.04469008f, -0.00459205f, -0.01147009f, 0.00108303f, 0.02704445f, -0.04869547f, -0.04224977f, 
    0.03621108f, -0.05033987f, -0.01782969f, -0.04912724f, -0.05848419f, -0.06146478f, 0.01565071f, -0.01884757f, 
    -0.01579398f, 0.04581018f, -0.00516608f, -0.03133300f, -0.01801480f, 0.03389133f, -0.02460948f, 0.00491483f, 
    -0.03272737f, 0.02971424f, -0.01500695f, 0.01094462f, 0.00133320f, -0.00951866f, 0.01505482f, -0.06079856f, 
    0.03294761f, 0.03051209f, 0.04051295f, -0.02511972f, -0.01254316f, -0.05372754f, -0.03583717f, 0.02409801f, 
    0.03122024f, 0.03089942f, 0.02008608f, 0.03508269f, 0.00191342f, -0.02388048f, -0.01873510f, -0.04775799f, 
    0.03400533f, -0.03724785f, -0.06029538f, -0.00186546f, 0.01428367f, -0.03291547f, -0.02202780f, -0.04378107f, 
    0.01460179f, -0.01871140f, -0.04350407f, -0.02766209f, -0.03915845f, -0.02667003f, -0.01802074f, 0.03185356f, 
    -0.05998115f, 0.01997568f, -0.02826788f, 0.00787209f, 0.03110053f, -0.03770298f, 0.04535061f, -0.00018973f, 
    -0.00392127f, 0.00632330f, -0.04427079f, 0.02238476f, -0.02655880f, 0.05063711f, 0.01266959f, 0.00660739f, 
    0.04569452f, -0.04342776f, 0.03412233f, -0.00084089f, -0.03851542f, 0.00149107f, 0.02499111f, 0.02253643f, 
    0.03497002f, 0.02462242f, 0.01310862f, -0.03129691f, -0.00582017f, -0.03227653f, -0.05004907f, -0.05268162f, 
    0.03991389f, -0.03565834f, -0.01371245f, 0.01220821f, -0.03745338f, 0.03137267f, -0.02967600f, 0.04827372f, 
    -0.03002999f, 0.02243811f, 0.01422132f, -0.02423260f, 0.03540271f, -0.02372406f, -0.04041420f, -0.02521859f, 
    0.00782504f, -0.02015762f, 0.02879731f, 0.04434664f, -0.04058729f, 0.01290624f, 0.04066137f, -0.04154713f, 
    -0.04048163f, -0.03963461f, 0.02362657f, -0.03720389f, -0.04147843f, 0.04889657f, -0.04144368f, -0.00460151f, 
    0.03364097f, -0.05589190f, -0.02874116f, 0.02551545f, -0.04977207f, -0.00453346f, 0.04096967f, 0.04078728f, 
    -0.03158036f, -0.02849743f, 0.04883875f, -0.02751672f, -0.01196476f, -0.03872659f, -0.02870371f, 0.02484447f, 
    0.00303690f, -0.01180721f, -0.04617107f, -0.01064027f, -0.03547404f, -0.03657802f, -0.01266349f, -0.00857425f, 
    0.01290126f, -0.02387539f, -0.00414436f, -0.03583765f, -0.05427433f, -0.04843508f, -0.02430336f, 0.01292311f, 
    -0.02885428f, 0.01221320f, -0.02433597f, -0.00134428f, 0.02854123f, -0.04477467f, -0.03548692f, -0.00593925f, 
    -0.04469302f, -0.02727856f, -0.03525166f, -0.03355229f, 0.01282885f, -0.03181685f, 0.00882709f, -0.01386047f, 
    -0.02900169f, -0.04135590f, -0.00720571f, -0.04942775f, 0.02942935f, 0.04193637f, 0.03835832f, 0.03589797f, 
    -0.04635640f, 0.02481411f, -0.00068465f, -0.04618256f, 0.00044051f, -0.00727278f, 0.00133091f, 0.00877078f, 
    0.04125436f, -0.02341776f, 0.00724913f, 0.01833638f, 0.02611797f, -0.01696621f, 0.00773513f, -0.01930159f, 
    0.04476874f, -0.05581141f, -0.02065209f, 0.02531523f, 0.01989709f, -0.01361119f, 0.01309802f, 0.01146641f, 
    0.01277722f, -0.04135280f, 0.04200150f, -0.02747594f, 0.03826465f, -0.02094128f, -0.01167704f, -0.05240526f, 
    -0.02695314f, -0.02304668f, -0.03082407f, -0.03739998f, -0.02057730f, -0.03906399f, -0.00644603f, 0.02768572f, 
    -0.04282811f, 0.03809733f, 0.00021012f, -0.02716278f, 0.04010455f, -0.05686190f, 0.02284914f, 0.00081851f, 
    0.03594337f, 0.04044535f, 0.01467534f, -0.02564508f, -0.00035298f, -0.02253794f, -0.03091361f, 0.04336671f, 
    -0.05624147f, -0.05193026f, 0.04486250f, 0.00529574f, -0.02992519f, -0.03183921f, -0.01025657f, -0.05358426f, 
    0.04522564f, 0.00379711f, -0.03159803f, -0.02511779f, -0.04792438f, -0.04009978f, 0.03177351f, 0.03531189f, 
    -0.01319108f, 0.04044708f, -0.04488003f, -0.02091315f, 0.03933161f, 0.00980311f, -0.01995544f, 0.03886557f, 
    0.00530305f, -0.02380767f, 0.00614498f, -0.03679933f, -0.01671440f, 0.02249660f, 0.01169831f, -0.01275948f, 
    0.01070704f, 0.01009323f, -0.03338263f, 0.01517176f, -0.00829462f, -0.00392527f, 0.00085796f, 0.01854238f, 
    -0.01007705f, -0.02340228f, -0.01371723f, 0.01437989f, -0.01896724f, 0.01033140f, 0.04484533f, 0.01833184f, 
    0.02414438f, -0.03580746f, 0.01656659f, -0.01270525f, -0.05227293f, -0.02737140f, 0.03616166f, -0.01521486f, 
    -0.03354300f, 0.02144770f, 0.02554128f, 0.01311800f, 0.02211037f, -0.01743893f, 0.01473888f, -0.03907077f, 
    0.01504405f, 0.04431086f, -0.02640584f, -0.04842905f, -0.01470481f, -0.03598733f, -0.04402186f, 0.02682967f, 
    -0.05078155f, 0.00396193f, 0.00441363f, -0.02830211f, -0.01446626f, -0.01504915f, 0.02739936f, -0.04665917f, 
    -0.05481629f, -0.03983153f, -0.03320032f, 0.00707967f, 0.00046508f, -0.05668867f, 0.01528812f, -0.05320393f, 
    0.00182140f, 0.02772879f, -0.03813468f, -0.02523980f, 0.04319048f, -0.05366611f, 0.00969854f, -0.04991938f, 
    0.00956083f, 0.00018489f, -0.02032565f, 0.03435900f, 0.02037002f, -0.01033708f, -0.03770766f, -0.00455294f, 
    -0.00695796f, 0.00485146f, 0.04504244f, 0.01348923f, 0.02858081f, -0.04044117f, -0.05004608f, 0.04326220f, 
    0.01444074f, -0.03921989f, 0.04717350f, 0.03913859f, -0.02272744f, 0.01153007f, 0.04033263f, 0.00434372f, 
    0.01092364f, -0.02847894f, -0.04546445f, -0.03877433f, -0.02513087f, 0.03643675f, -0.04137122f, -0.02733069f, 
    -0.02837895f, -0.03612667f, -0.04950019f, -0.03323482f, 0.03375132f, 0.04350651f, -0.05235832f, 0.02492256f, 
    -0.04141922f, 0.02000494f, 0.01688188f, 0.00369671f, -0.00735290f, 0.02948898f, 0.02636677f, 0.04314995f, 
    -0.02074043f, -0.01135793f, -0.03457068f, 0.04175429f, 0.02202566f, -0.04525635f, 0.00128927f, -0.00513157f, 
    0.00080658f, 0.00839343f, -0.00336724f, 0.02757977f, -0.03004531f, -0.03544154f, -0.02638877f, -0.05245535f, 
    0.01989434f, -0.01610891f, -0.03363957f, 0.00701772f, -0.03358227f, 0.03027599f, 0.03497665f, -0.01474531f, 
    -0.04205462f, -0.04766714f, -0.01152923f, -0.05204630f, -0.00904747f, 0.02418209f, 0.03314874f, -0.00664256f, 
    0.03248066f, -0.04327925f, 0.01461494f, 0.00936843f, -0.03546099f, 0.04096737f, -0.04512984f, 0.03308317f, 
    -0.03058453f, 0.04541643f, -0.03436100f, -0.00896554f, -0.03350484f, 0.00443777f, -0.05080979f, 0.00997561f, 
    0.01116451f, -0.05063045f, 0.00864582f, 0.03363722f, -0.00130530f, 0.00728673f, -0.04748986f, -0.05045364f, 
    -0.04048885f, 0.02449948f, -0.02257874f, 0.04929639f, -0.03921897f, -0.05614410f, -0.04329460f, 0.04126194f, 
    0.04236097f, -0.01261507f, 0.01674667f, 0.01025161f, -0.02494063f, -0.02484312f, 0.02931969f, -0.01868390f, 
    -0.05140715f, -0.00239838f, 0.00620793f, -0.00876138f, -0.01563840f, -0.00471889f, -0.04991654f, 0.01637550f, 
    0.02683312f, 0.04107263f, -0.02479109f, 0.00352322f, 0.01753272f, 0.00835690f, -0.02791174f, -0.03195278f, 
    0.01984738f, 0.03474043f, -0.02626587f, 0.02842544f, -0.02597798f, -0.02793596f, -0.01986142f, 0.01040040f, 
    -0.05536463f, 0.01954361f, 0.00036665f, -0.04539053f, 0.00548110f, 0.00119535f, -0.05068052f, 0.03238935f, 
    0.02730430f, -0.00987030f, 0.03747018f, -0.01588961f, 0.01086929f, -0.01679103f, -0.00503706f, -0.04164917f, 
    0.00047830f, 0.02385497f, 0.00544420f, -0.04374386f, -0.01866359f, 0.00575926f, 0.03353369f, 0.01113383f, 
    -0.00114770f, -0.03373209f, 0.01307787f, -0.02006093f, -0.04570430f, 0.00533977f, 0.04018109f, 0.04363925f, 
    -0.04570672f, 0.02058072f, 0.02918390f, -0.04360113f, -0.05701748f, -0.01136257f, -0.03188407f, -0.05926259f, 
    -0.04969203f, 0.03217408f, -0.03869814f, 0.01739836f, -0.03585269f, 0.02830306f, 0.00521424f, 0.02604720f, 
    0.00303011f, 0.01597732f, -0.01161024f, -0.01259524f, -0.05630888f, 0.00708221f, 0.01661566f, 0.00425708f, 
    -0.03324948f, 0.03130341f, -0.03736292f, 0.03019743f, -0.02034630f, -0.05784726f, 0.01999547f, 0.02124901f, 
    -0.00637517f, 0.02830916f, -0.04538452f, -0.05134147f, 0.01198430f, -0.03159230f, -0.02906304f, 0.01615577f, 
    -0.03807105f, 0.03699560f, 0.03924287f, -0.01960300f, -0.00939375f, 0.02176495f, -0.04425561f, 0.01497926f, 
    0.00844361f, 0.00442038f, -0.04209083f, -0.05155924f, 0.02882134f, 0.00883127f, 0.03339431f, -0.04419000f, 
    0.02700118f, 0.00819366f, -0.05769161f, 0.01930145f, -0.05230265f, -0.00962264f, -0.04855034f, -0.05137718f, 
    0.00123046f, 0.03432379f, 0.01453053f, -0.03276053f, 0.02965701f, -0.01084853f, -0.02881233f, -0.03885364f, 
    0.03569892f, -0.01832585f, 0.01692502f, -0.02533862f, -0.04434866f, 0.03333930f, -0.01586470f, 0.03604608f, 
    -0.04941889f, 0.03029408f, -0.03801885f, -0.00665479f, 0.00509417f, -0.03853109f, -0.05315713f, 0.03198598f, 
    -0.02200110f, -0.05512413f, 0.02467478f, 0.03746478f, -0.02745528f, 0.02596379f, 0.03493334f, -0.01276218f, 
    0.04076928f, 0.00862406f, -0.01007694f, 0.00423740f, 0.03988003f, -0.01775331f, 0.01270401f, -0.03986332f, 
    -0.00179764f, 0.03927849f, 0.03731511f, 0.01388334f, 0.02872745f, -0.02088932f, -0.02371773f, -0.03485536f, 
    0.02056990f, 0.02163514f, -0.03399598f, -0.05168948f, -0.04485739f, 0.03254377f, -0.01522046f, -0.03076755f, 
    -0.01733001f, -0.04360117f, -0.04153370f, -0.04441792f, -0.00847327f, 0.02236682f, -0.04535954f, -0.01723907f, 
    0.02654043f, -0.04371455f, 0.01210655f, 0.03758355f, 0.04154289f, -0.01138475f, -0.02690650f, 0.01159120f, 
    0.01039239f, 0.02606377f, -0.02459692f, 0.04180630f, -0.01750509f, 0.05377522f, 0.00901562f, -0.05410184f, 
    -0.05642710f, 0.03196245f, -0.00613988f, 0.02469904f, -0.03044758f, -0.01598629f, 0.02281855f, 0.02968762f, 
    0.02547598f, -0.02237833f, -0.04806180f, -0.03969456f, -0.01202664f, 0.01335969f, 0.01716954f, 0.02251055f, 
    -0.01935479f, 0.03558887f, 0.03899466f, -0.03501054f, -0.05589264f, -0.00649098f, 0.01186038f, 0.03200021f, 
    0.02648737f, -0.03097131f, 0.01937668f, -0.00480528f, -0.05139413f, -0.03433107f, -0.04023431f, -0.03265210f, 
    0.01273460f, -0.01187793f, 0.01835369f, 0.02525967f, 0.04246955f, -0.00700366f, 0.01865336f, 0.00391230f, 
    -0.03665490f, -0.00429523f, -0.01258186f, -0.00039243f, 0.02571413f, -0.00954332f, -0.02522340f, -0.00505913f, 
    -0.02234143f, -0.04795324f, -0.04911184f, -0.02355344f, -0.04026359f, 0.03823159f, -0.04384692f, -0.01868981f, 
    0.01163786f, -0.01199097f, -0.01784125f, 0.01105173f, -0.05146432f, 0.00392971f, 0.04176434f, 0.03705031f, 
    -0.05023714f, 0.02596261f, 0.00048060f, 0.01928448f, -0.00038026f, 0.02491627f, -0.02124535f, -0.02748064f, 
    -0.05664052f, -0.03896553f, -0.03403440f, -0.01788077f, 0.00214422f, -0.05413803f, -0.00746824f, -0.03284449f, 
    -0.04466639f, 0.04845657f, 0.02573803f, -0.03757579f, -0.04559427f, -0.05315503f, -0.02458407f, -0.00961754f, 
    -0.02790420f, 0.00198250f, 0.00491298f, 0.03031081f, -0.02852127f, 0.01616557f, -0.04968684f, -0.04387835f, 
    -0.00540998f, -0.05722034f, 0.00326026f, 0.00150490f, -0.03847576f, 0.00635470f, 0.02748629f, -0.03324590f, 
    0.01528360f, 0.04704680f, 0.01414920f, -0.04874957f, 0.00829535f, 0.04087899f, -0.03963665f, 0.00713445f, 
    0.03283321f, -0.02442567f, 0.04070452f, -0.01164000f, -0.03795431f, -0.01271911f, 0.02857334f, 0.02485098f, 
    -0.05054036f, 0.00928004f, 0.02384860f, -0.00555592f, 0.03667200f, -0.00620749f, -0.05470008f, 0.02473702f, 
    -0.04381321f, 0.02995748f, -0.03469450f, 0.03955364f, 0.01568755f, -0.00986770f, -0.01465756f, -0.02465241f, 
    0.01801176f, 0.02895227f, -0.01775947f, -0.02595513f, -0.04130783f, 0.04229409f, 0.03625595f, -0.05263384f, 
    -0.03135748f, -0.05852854f, 0.01698990f, 0.03627580f, -0.00829571f, -0.04853198f, -0.03286393f, -0.01201388f, 
    -0.03942312f, 0.05099184f, 0.02374692f, 0.04225766f, -0.02454900f, -0.01701850f, 0.01899850f, -0.03694140f, 
    -0.04815952f, -0.00803210f, -0.02589159f, 0.02750663f, 0.05156211f, -0.00822451f, -0.03128805f, 0.00089024f, 
    -0.01012838f, -0.02392896f, -0.05169624f, -0.05487941f, 0.01281417f, -0.00789327f, 0.01611477f, 0.04102406f, 
    -0.03656812f, 0.00923224f, 0.00691618f, 0.03213962f, -0.00372096f, -0.05096515f, -0.04679745f, -0.05149484f, 
    -0.00342139f, -0.02355628f, -0.05872376f, -0.03867347f, 0.02518525f, -0.05840513f, 0.00912945f, -0.05473696f, 
    -0.02551455f, 0.01338341f, -0.02951328f, -0.00655835f, 0.02899620f, -0.01851001f, -0.04184754f, -0.02199880f, 
    0.04741552f, 0.00363251f, -0.03882358f, 0.03038404f, 0.04081210f, -0.04547815f, -0.03790916f, 0.02289580f, 
    -0.03857081f, -0.04227860f, -0.01500581f, 0.03088050f, -0.03585522f, -0.01931636f, -0.03348586f, 0.03658932f, 
    0.02795890f, -0.02443017f, -0.01732334f, 0.01303042f, 0.02894492f, -0.03175057f, -0.03866027f, 0.02797602f, 
    -0.13401078f, -0.05940951f, -0.14080639f, 0.10051646f, -0.07219104f, 0.07292663f, -0.04709657f, 0.04082072f, 
    -0.03521673f, 0.21026665f, 0.04848063f, -0.10210121f, 0.18351905f, -0.10162583f, -0.03940186f, -0.03178041f, 
    0.17379326f, 0.08576789f, 0.11860668f, 0.05178554f, 0.11900513f, -0.03533138f, 0.04951584f, 0.13065544f, 
    0.32824770f, -0.00795407f, 0.00457655f, -0.17873073f, 0.01759336f, 0.00213631f, 0.02935042f, -0.05079643f, 
    -0.00904085f, 0.06148436f, 0.12591536f, 0.01312351f, -0.12794895f, -0.16206217f, -0.05855585f, 0.01034121f, 
    0.09629487f, 0.09626921f, 0.10703091f, 0.06965239f, 0.02400296f, -0.13704535f, -0.03118171f, 0.00617509f, 
    0.21412665f, -0.00200756f, -0.06355952f, -0.12497275f, 0.11959517f, 0.08336563f, 0.06729503f, 0.14072400f, 
    -0.01314973f, 0.01314846f, -0.05253834f, -0.07485924f, -0.32306653f, 0.12527634f, -0.03895949f, 0.25039843f, 
    -0.00417361f, 0.05574169f, -0.04461946f, -0.00720412f, -0.01265452f, -0.02459268f, 0.04627742f, -0.01935765f, 
    -0.10828168f, 0.05780176f, 0.19136961f, -0.06040631f, -0.02801387f, -0.01876364f, 0.13222328f, 0.06741723f, 
    -0.07207117f, -0.00148669f, 0.00521767f, -0.05942510f, -0.09565096f, 0.05989227f, 0.14958377f, 0.00241204f, 
    0.14824553f, 0.01235966f, -0.04141841f, -0.03544013f, 0.02062366f, -0.03806683f, -0.00786106f, 0.07996602f, 
    -0.20242691f, 0.06292590f, 0.06208241f, 0.05032654f, -0.07161045f, -0.04077028f, -0.05148947f, 0.12997605f, 
    0.03015502f, -0.05045496f, -0.00333969f, 0.04277448f, 0.02235884f, -0.04953227f, -0.27611175f, -0.27033326f, 
    0.11502958f, 0.11208404f, 0.16016611f, 0.00774234f, -0.05473478f, -0.05763838f, 0.04613842f, -0.10394042f, 
    0.08111055f, 0.11371391f, -0.16675875f, 0.10431353f, 0.09907341f, 0.03173940f, 0.01041799f, -0.06598426f, 
    0.16086598f, 0.08958475f, -0.02869961f, 0.05022506f, -0.13137926f, -0.07290304f, -0.03210213f, 0.02859599f, 
    -0.04098731f, 0.08497672f, 0.03172249f, -0.02402856f, 0.11629826f, 0.08996738f, 0.01184539f, -0.07615069f, 
    0.08328929f, -0.07207885f, -0.01260110f, -0.08479279f, 0.14707516f, -0.01847982f, 0.04603953f, 0.12939921f, 
    -0.03687508f, -0.02059594f, 0.02542161f, 0.12859581f, -0.03514288f, 0.21139951f, -0.06080277f, -0.09191377f, 
    -0.04788329f, 0.07306101f, -0.00072222f, -0.00369799f, 0.06782668f, -0.00484561f, 0.07989211f, -0.03435570f, 
    -0.11730421f, -0.25480601f, -0.00131519f, 0.19825195f, 0.07710931f, 0.15465437f, -0.03604419f, -0.08490746f, 
    0.09257129f, 0.02910998f, 0.06659064f, 0.00176792f, -0.24348029f, 0.08946639f, -0.05094643f, 0.05479960f, 
    -0.00230843f, 0.05572096f, 0.01380077f, -0.02498051f, 0.03441332f, -0.12317969f, -0.05623297f, -0.02212339f, 
    0.02724108f, 0.05437082f, 0.12053571f, -0.18897678f, -0.03628021f, 0.13313498f, -0.04502559f, 0.10751026f, 
    -0.09081914f, -0.04656860f, -0.03019533f, -0.00518820f, -0.00644588f, 0.01513084f, -0.17722718f, -0.04607291f, 
    0.01060787f, 0.00118293f, 0.03226834f, 0.03585040f, -0.07563241f, 0.00361282f, 0.08094436f, 0.06875572f, 
    -0.21604949f, 0.10088873f, -0.12657881f, 0.08917985f, 0.01489350f, 0.06465513f, -0.15111667f, 0.07823849f, 
    -0.04250359f, 0.00713062f, 0.07705291f, 0.16984539f, 0.16701430f, 0.08838667f, 0.13471001f, 0.04060101f, 
    -0.07024094f, -0.03522702f, -0.06953001f, 0.00285095f, 0.04375738f, -0.03000136f, 0.05195820f, -0.04942090f, 
    -0.46120936f, 0.08654625f, -0.16577083f, 0.13216895f, -0.05646214f, 0.06056267f, -0.02257597f, 0.18304357f, 
    0.13171452f, -0.09240699f, -0.06772491f, 0.05700742f, -0.07256944f, -0.03455526f, 0.07906000f, -0.01377967f, 
    0.07308470f, -0.02809539f, -0.03947147f, 0.07627891f, -0.04803568f, 0.08775590f, 0.03068193f, 0.00575092f, 
    -0.15726621f, -0.07026225f, -0.07730367f, -0.06646837f, 0.07463477f, 0.11388591f, -0.06724484f, -0.01828753f, 
    -0.06242453f, -0.08858110f, -0.00660076f, 0.04279121f, -0.00988596f, -0.04794163f, -0.01870723f, -0.04383891f, 
    0.10461915f, 0.02281187f, 0.01110863f, -0.03314171f, 0.13620466f, -0.00815115f, 0.00889484f, 0.12389258f, 
    -0.03636414f, 0.10759196f, -0.48703223f, -0.04844717f, 0.07078826f, 0.03201504f, -0.04585294f, -0.04381337f, 
    0.03942927f, -0.00356738f, 0.12016498f, 0.05072642f, 0.13274489f, -0.04532860f, 0.05815315f, -0.14881882f, 
    0.12276563f, -0.00628967f, -0.10987568f, -0.04471603f, 0.03921670f, 0.03093489f, -0.02904826f, 0.00143364f, 
    0.26662523f, 0.20021690f, -0.14472407f, -0.17630461f, -0.01732791f, -0.07544332f, -0.04787553f, 0.07863872f, 
    -0.15041491f, 0.00168617f, -0.07037830f, 0.03296256f, -0.31825554f, 0.02498258f, 0.00876907f, 0.11636999f, 
    0.16580893f, 0.04972272f, 0.03174275f, 0.03940695f, 0.03370570f, 0.01375948f, 0.01368850f, -0.00175568f, 
    -0.10697792f, -0.05029346f, -0.21801226f, 0.02329927f, 0.04204531f, -0.10087400f, -0.02815599f, 0.05210374f, 
    0.01895851f, 0.00877460f, 0.10454389f, 0.07362516f, -0.05045052f, 0.22525142f, -0.05279077f, -0.22086015f, 
    -0.06464864f, -0.05871447f, 0.10876372f, 0.10746115f, 0.10670093f, 0.13768166f, -0.00791631f, -0.01360219f, 
    -0.15870099f, -0.03975501f, 0.24861823f, 0.15260215f, 0.00785683f, 0.19841880f, 0.05966303f, -0.00739722f, 
    0.06151144f, -0.05993231f, -0.01169129f, -0.07683910f, -0.13259986f, -0.08611982f, 0.05437708f, -0.01443038f, 
    -0.03524633f, -0.04529337f, -0.02739807f, -0.07586046f, -0.06869125f, 0.04562549f, -0.08940084f, 0.05255383f, 
    -0.02856760f, 0.00324275f, 0.02169403f, 0.03712819f, 0.00029660f, -0.05272217f, -0.02571533f, 0.01286945f, 
    -0.00010653f, -0.03608236f, -0.01571011f, -0.04418392f, -0.00250694f, -0.03679466f, -0.05781120f, -0.03863312f, 
    0.03220157f, -0.02797475f, -0.03031000f, 0.03134559f, -0.05982478f, 0.02006436f, 0.00009586f, -0.00855012f, 
    0.00300564f, -0.04412538f, 0.04223509f, 0.01488798f, -0.04478377f, -0.03216175f, -0.02593942f, -0.00139054f, 
    0.02510003f, 0.00150821f, 0.01797244f, -0.04137388f, -0.00627769f, 0.03742715f, -0.01904763f, 0.00885652f, 
    -0.04522038f, -0.05249209f, 0.03152435f, -0.04219680f, -0.00508611f, 0.03176713f, 0.01197928f, 0.00491265f, 
    -0.00496253f, -0.05992205f, -0.03160742f, -0.02331849f, -0.02627680f, 0.02732138f, -0.01752103f, -0.02269559f, 
    -0.02607458f, 0.01455646f, -0.03480498f, 0.01424263f, -0.00184126f, -0.02671998f, 0.02367389f, -0.04626428f, 
    0.02164030f, -0.00628783f, 0.03286790f, -0.01569328f, 0.02245842f, 0.01799196f, 0.02314072f, -0.05045135f, 
    0.03043506f, 0.01071885f, -0.03832639f, -0.04311295f, -0.03816748f, -0.03616787f, 0.02609407f, -0.05469816f, 
    -0.01691114f, 0.02458508f, -0.00875831f, -0.00665705f, 0.01494686f, 0.02126225f, 0.00477487f, 0.00822491f, 
    0.02670242f, 0.03310576f, 0.02270935f, 0.00069147f, 0.02108932f, -0.03937948f, -0.02774426f, -0.02746942f, 
    -0.01575023f, -0.05020211f, -0.04143175f, -0.04584936f, -0.01050475f, -0.04249678f, -0.05517798f, 0.02080513f, 
    0.00572708f, -0.01106075f, 0.02354502f, -0.02101625f, -0.00542847f, -0.02283890f, -0.03790262f, 0.03385753f, 
    0.02970519f, 0.03430119f, -0.03573932f, 0.03644297f, -0.04154328f, -0.01330578f, -0.03250378f, -0.03533736f, 
    -0.02327458f, -0.03554329f, 0.02829884f, -0.03069473f, 0.01040037f, 0.03378677f, 0.00545163f, 0.02818654f, 
    -0.01220755f, 0.02237868f, -0.04163504f, 0.02122766f, 0.05084318f, 0.00993117f, -0.05355182f, 0.00070697f, 
    -0.04991677f, -0.05052345f, 0.02790174f, -0.03558503f, 0.03205641f, -0.02204293f, -0.04263239f, -0.02970893f, 
    -0.00257388f, 0.02214936f, -0.03886549f, 0.00526827f, 0.02028352f, 0.02158020f, 0.01432358f, -0.00079434f, 
    -0.03746443f, -0.03733629f, -0.02411488f, -0.01371823f, -0.03957533f, -0.03917160f, -0.00430959f, -0.01409953f, 
    -0.02912979f, -0.01784276f, -0.02369581f, -0.03594088f, 0.00107647f, 0.00475396f, -0.02794575f, -0.02571619f, 
    -0.05283587f, -0.02036946f, -0.05690514f, 0.01003202f, -0.00760427f, -0.01736674f, 0.03588168f, 0.02902982f, 
    -0.01860424f, 0.00230558f, -0.03130849f, -0.02769685f, -0.01096225f, 0.00766872f, 0.00139643f, 0.01107764f, 
    -0.05557365f, -0.04046626f, 0.01268321f, -0.01111921f, 0.03258212f, -0.05570901f, -0.04682250f, -0.01111160f, 
    0.03021205f, 0.02970872f, 0.02228022f, -0.04746821f, 0.00170843f, -0.01730362f, 0.01946601f, -0.01137636f, 
    -0.01692645f, 0.03931057f, 0.04471390f, 0.02313253f, 0.02112291f, -0.03000513f, -0.00554912f, 0.03955304f, 
    -0.05133817f, 0.00076007f, -0.02375204f, -0.05629105f, -0.00137588f, 0.00353722f, 0.01332334f, 0.01028103f, 
    0.02264216f, 0.01950229f, 0.03284790f, -0.00709333f, -0.00236349f, 0.01626197f, -0.04516024f, -0.03082064f, 
    0.03229841f, 0.00912915f, -0.00318110f, -0.05302991f, 0.00389832f, 0.01265972f, 0.02377327f, -0.05676083f, 
    0.03202044f, -0.00738046f, -0.00269754f, 0.02095127f, 0.01793778f, 0.00281760f, -0.04433443f, 0.03621466f, 
    -0.04431818f, -0.01746255f, -0.05492204f, -0.03916585f, 0.02531156f, 0.03366039f, 0.03708353f, -0.06045928f, 
    -0.02034844f, -0.01198008f, -0.05627215f, -0.00114110f, -0.03610383f, -0.02013387f, 0.00045053f, 0.01215841f, 
    0.04453745f, -0.00889022f, -0.05761446f, 0.00997592f, 0.00725867f, 0.01597564f, -0.05121050f, 0.01246902f, 
    -0.04725318f, -0.02633043f, -0.01684804f, -0.04251485f, -0.02220199f, -0.02708882f, 0.03371544f, -0.02366642f, 
    -0.01990714f, 0.03000552f, -0.01412849f, 0.01185370f, 0.01300179f, 0.01138598f, 0.04178490f, -0.00174313f, 
    0.02348332f, -0.02657551f, 0.01224811f, 0.02205844f, -0.02441365f, -0.00167931f, 0.02573987f, 0.03418808f, 
    -0.04337145f, 0.00227149f, -0.02013591f, 0.02940772f, 0.02906770f, 0.01847261f, -0.05581677f, 0.03684853f, 
    -0.00564841f, -0.01008771f, 0.04408821f, 0.02829362f, -0.05195668f, 0.03655206f, -0.00875271f, 0.02294928f, 
    -0.01994228f, -0.02541275f, -0.06291497f, 0.00144049f, -0.01269986f, -0.02616417f, -0.01906006f, 0.00236199f, 
    0.03494015f, -0.05601623f, -0.02507213f, 0.03695770f, 0.02808262f, -0.02934504f, -0.01595819f, 0.02563700f, 
    0.02595577f, 0.00147705f, 0.03578148f, 0.03821661f, -0.00525245f, -0.03654959f, 0.01520735f, 0.02476510f, 
    -0.02158911f, -0.01785538f, 0.01248190f, 0.01720099f, -0.02801696f, -0.04259180f, 0.01208843f, -0.04576593f, 
    -0.01315688f, 0.01714538f, -0.04525416f, 0.03958368f, -0.00584707f, 0.02591625f, 0.01198694f, 0.01502234f, 
    -0.03461998f, -0.01497111f, -0.02780132f, 0.03826655f, -0.04051111f, -0.01106630f, 0.02651883f, 0.03974194f, 
    -0.00653728f, 0.03389398f, 0.01526683f, -0.01813031f, 0.00672076f, -0.00721126f, 0.03105298f, -0.01328284f, 
    -0.01170389f, 0.03899361f, 0.03473739f, -0.02031625f, -0.02509221f, -0.00955355f, 0.01412032f, 0.02140046f, 
    0.03348547f, -0.04081771f, 0.00280051f, -0.05544362f, -0.00090270f, -0.02329479f, -0.00429320f, -0.00085363f, 
    -0.03547813f, 0.00796285f, 0.03490954f, -0.05358513f, 0.02417428f, -0.03232445f, 0.02298117f, -0.00523130f, 
    -0.01825350f, 0.04477048f, 0.02118313f, -0.02043754f, -0.04903285f, 0.01604339f, -0.04110564f, -0.00810237f, 
    0.03066717f, 0.01012593f, 0.02466865f, 0.03022289f, 0.03588764f, 0.04926499f, -0.01897794f, -0.01990055f, 
    0.02171915f, 0.01296542f, -0.04233529f, -0.04342949f, 0.00750764f, 0.01130267f, -0.03194926f, -0.00783279f, 
    0.02767043f, 0.01441526f, -0.02572242f, 0.03004049f, -0.03958234f, 0.04062781f, -0.05599847f, 0.04722700f, 
    -0.03464158f, -0.01036405f, 0.01203267f, 0.01708821f, 0.00589543f, -0.05348847f, -0.06249953f, 0.01839952f, 
    0.03381030f, -0.01522747f, -0.03607809f, -0.00625972f, 0.02182543f, -0.03283784f, -0.01914142f, -0.02801563f, 
    0.01582231f, -0.02003328f, -0.01988458f, 0.03892921f, 0.01783643f, -0.00365492f, 0.01927696f, -0.06124273f, 
    -0.05330844f, -0.05592614f, -0.00978607f, -0.01005305f, -0.02749651f, -0.02740087f, -0.03216930f, 0.04700638f, 
    -0.04207976f, 0.04368040f, 0.02917375f, -0.03366129f, -0.01095725f, -0.03304236f, -0.02262080f, -0.05220108f, 
    -0.02480826f, -0.05107352f, 0.02883228f, -0.05338331f, -0.06208126f, 0.00298431f, -0.03736423f, 0.03266554f, 
    -0.03910669f, -0.00210955f, 0.00574522f, -0.04231104f, 0.02226421f, -0.03786394f, -0.03642735f, 0.01349908f, 
    0.02405400f, -0.03901676f, -0.03032592f, 0.02762952f, -0.05484576f, 0.03343308f, 0.02415287f, 0.00550318f, 
    -0.01872856f, 0.03719421f, -0.01998876f, 0.01061819f, 0.03885519f, -0.04103727f, -0.03560293f, -0.00720797f, 
    0.01742105f, -0.03417294f, 0.02049641f, -0.03138787f, -0.02035326f, -0.02842361f, -0.04209728f, -0.04865902f, 
    -0.05117980f, 0.01833858f, 0.02392388f, 0.02649217f, 0.02800870f, -0.00540256f, -0.02323599f, -0.03663666f, 
    -0.05252571f, -0.01567039f, -0.04497724f, 0.03377029f, -0.02015424f, -0.03307552f, 0.02238327f, 0.01895578f, 
    -0.02005347f, 0.02889558f, -0.00712851f, -0.03821540f, 0.03495618f, -0.00543450f, -0.03604993f, -0.03636257f, 
    -0.02805461f, -0.01872471f, -0.02312731f, 0.01629079f, -0.00048013f, 0.01767219f, -0.05908766f, 0.00221019f, 
    -0.04665740f, -0.02889870f, -0.05105315f, 0.01598050f, -0.02858377f, -0.00047337f, -0.01359606f, -0.00064873f, 
    -0.01685141f, 0.03045582f, -0.03062195f, -0.00211167f, -0.00807605f, 0.00659787f, 0.03302373f, 0.04434797f, 
    -0.03868948f, 0.03618266f, -0.05403481f, -0.04583283f, 0.04185772f, -0.00955949f, -0.00053221f, -0.05058292f, 
    -0.04889365f, -0.03742297f, 0.00914203f, 0.02722721f, -0.02655236f, -0.06087583f, -0.03438366f, 0.02579804f, 
    0.03911614f, 0.03935283f, -0.04844122f, 0.02203349f, 0.03346025f, 0.00623851f, 0.04654887f, 0.03773635f, 
    0.01459547f, -0.05130524f, -0.05754384f, -0.03967087f, -0.00046210f, 0.03964714f, -0.00980327f, 0.00305100f, 
    0.04156177f, 0.02169747f, -0.02761272f, -0.05101723f, 0.02700240f, 0.02873944f, -0.00175230f, 0.01522277f, 
    0.02101635f, -0.00721044f, 0.01804973f, -0.02331172f, -0.00595460f, 0.01632264f, -0.02537739f, -0.01349340f, 
    -0.00552069f, -0.01560828f, 0.02326706f, -0.03737149f, -0.02241071f, -0.03179270f, 0.02650402f, -0.04161515f, 
    0.05079925f, 0.01630665f, -0.01315923f, -0.01719990f, -0.04762683f, 0.03803642f, -0.05257202f, -0.00545158f, 
    -0.05300222f, 0.02888047f, 0.01121581f, -0.06039155f, 0.01015503f, -0.01938487f, -0.05602552f, 0.00087350f, 
    -0.04857582f, 0.03756860f, -0.04064164f, -0.04983854f, -0.03328795f, 0.03107074f, -0.05485167f, -0.04529677f, 
    0.02135563f, -0.01196983f, -0.04746206f, 0.00116550f, -0.02409414f, -0.02462171f, -0.01390066f, 0.01906319f, 
    0.03499572f, 0.04200251f, -0.01592367f, 0.03468100f, -0.03838830f, -0.04877776f, 0.03168512f, 0.02260079f, 
    -0.02688135f, -0.03544754f, 0.01056606f, 0.03966302f, 0.00637802f, -0.05504226f, -0.04033827f, -0.06045976f, 
    -0.02996658f, 0.00807619f, 0.04047785f, 0.01855924f, 0.02113429f, -0.01717021f, 0.02408470f, -0.00588473f, 
    0.02189845f, 0.01450712f, -0.00732431f, -0.03247143f, -0.04370289f, 0.04295432f, 0.03109908f, -0.02720457f, 
    0.01773910f, 0.04948740f, 0.02000470f, -0.02870227f, -0.01016377f, -0.03152962f, -0.04832460f, -0.03452951f, 
    -0.01386874f, -0.04686721f, -0.04877779f, 0.00597237f, -0.00031453f, 0.02705002f, -0.00668598f, -0.03426369f, 
    -0.06439582f, -0.04372749f, 0.02024875f, -0.06194896f, 0.02321333f, 0.00200639f, 0.03305291f, -0.00966056f, 
    -0.02948216f, 0.00195162f, 0.03764182f, 0.03448853f, -0.05166223f, -0.01431156f, 0.01684081f, 0.02586642f, 
    -0.01615268f, -0.03902842f, -0.03975212f, 0.01718016f, 0.01759347f, -0.00867103f, -0.01199571f, -0.03675134f, 
    -0.00990324f, -0.01959393f, 0.03651680f, -0.03740098f, 0.03596884f, 0.01044746f, 0.03890913f, 0.04550805f, 
    -0.03335402f, 0.01001887f, 0.01919645f, 0.03707914f, -0.00977291f, -0.01288896f, 0.03390672f, -0.05338032f, 
    -0.03368492f, 0.03560338f, 0.02162948f, 0.02932515f, -0.05107610f, 0.02816591f, -0.05716274f, -0.01019220f, 
    -0.04173176f, -0.03014537f, -0.00165163f, 0.03816935f, -0.00683930f, 0.04920764f, 0.00576984f, -0.00141462f, 
    0.01678645f, 0.03111424f, 0.01668922f, -0.01232876f, 0.03307546f, -0.06098754f, 0.01471032f, -0.01471747f, 
    0.05611787f, 0.04518457f, -0.02701635f, -0.00914514f, -0.03761487f, 0.04017158f, -0.03427668f, -0.03284623f, 
    -0.01874786f, -0.04346459f, -0.02102304f, -0.03606613f, 0.03594186f, 0.03554812f, -0.02898940f, -0.03876675f, 
    0.04719092f, -0.04811215f, -0.04546399f, -0.02558864f, -0.03797036f, -0.03484987f, -0.04235025f, 0.00587303f, 
    -0.03561248f, 0.04112007f, -0.04609874f, -0.05523452f, -0.03705131f, 0.00881246f, 0.03405217f, 0.01036067f, 
    0.03801018f, 0.01950477f, 0.03622873f, -0.04662050f, -0.03702182f, -0.04519660f, 0.01617700f, 0.01824895f, 
    -0.03281917f, -0.03691775f, -0.05841143f, 0.04046836f, 0.01465635f, -0.00512452f, -0.01060687f, 0.03596834f, 
    -0.00350552f, -0.05535339f, 0.03341594f, 0.03437310f, -0.00034178f, -0.04232558f, -0.01339895f, 0.01138307f, 
    -0.01088964f, -0.03085358f, -0.04303186f, 0.02689864f, 0.03342534f, 0.02409508f, -0.04047132f, -0.04065164f, 
    0.03936876f, -0.03869514f, -0.04212991f, -0.03299351f, 0.00419813f, -0.00511712f, -0.05543424f, -0.06389308f, 
    -0.00525170f, 0.01927550f, 0.02762644f, -0.02548624f, -0.05601414f, 0.03567237f, -0.04825529f, 0.03044252f, 
    0.03135839f, 0.01997090f, -0.01298355f, 0.04583019f, 0.01495319f, -0.00703380f, -0.03545012f, 0.01772616f, 
    0.03541434f, 0.00263242f, -0.00573966f, -0.00901912f, -0.00592708f, -0.03764608f, -0.04563490f, 0.03358823f, 
    0.01679354f, 0.00376367f, 0.02802017f, 0.03995322f, 0.01666521f, 0.01710858f, 0.01779016f, -0.00587269f, 
    0.04140846f, 0.01995558f, -0.03816544f, 0.00839202f, -0.02606471f, -0.04718675f, -0.04717789f, -0.04049563f, 
    0.03243309f, 0.02270056f, -0.03683590f, 0.02871595f, -0.02270699f, -0.04025076f, 0.03126163f, 0.00101360f, 
    0.01286281f, -0.04177941f, -0.03546801f, -0.00904202f, 0.01082370f, 0.00986057f, -0.04756036f, -0.00957187f, 
    -0.02192385f, 0.03655625f, 0.00381097f, -0.04004272f, -0.04039684f, 0.00365345f, -0.01412023f, -0.03666567f, 
    -0.04824145f, 0.01948429f, 0.02850829f, 0.03352315f, -0.00586695f, -0.04179970f, 0.02144424f, -0.05721116f, 
    -0.04266519f, -0.05148129f, 0.02101680f, 0.03776792f, 0.01890202f, -0.01781827f, -0.00616870f, -0.03729668f, 
    0.01849616f, -0.06666166f, 0.01874149f, -0.03677881f, 0.00491890f, -0.00597420f, -0.01915104f, -0.01950244f, 
    -0.00092764f, -0.00220686f, 0.02890262f, 0.03896826f, 0.00249269f, -0.05823173f, -0.04392105f, -0.03775573f, 
    0.01428504f, -0.04087126f, 0.00610813f, -0.05252013f, 0.02683816f, -0.03455031f, 0.03433704f, -0.01741862f, 
    0.00361817f, 0.02614251f, -0.00053989f, -0.01552892f, 0.01467749f, -0.00891775f, 0.02454717f, 0.03005520f, 
    -0.02981550f, -0.01571334f, 0.01246255f, -0.01241640f, -0.04589465f, -0.03300229f, 0.01551192f, 0.00243027f, 
    0.01778925f, -0.00952084f, 0.03507747f, 0.03846184f, 0.03267991f, -0.04700141f, 0.00284227f, 0.00264816f, 
    0.03070491f, -0.03454886f, -0.02901634f, -0.01430972f, -0.01344136f, -0.00701974f, -0.01858582f, -0.03019436f, 
    -0.02273309f, 0.02339521f, -0.01385005f, -0.05901638f, -0.00928840f, -0.01117758f, 0.02361792f, -0.03387460f, 
    0.01513142f, 0.03909642f, -0.03979702f, 0.04170884f, 0.03690908f, -0.02426310f, 0.03981917f, -0.04144059f, 
    -0.00443444f, -0.00799135f, -0.02910132f, 0.01957407f, -0.03868566f, 0.03918197f, 0.02712780f, 0.01418485f, 
    0.03464222f, 0.02211384f, 0.01576415f, 0.00031772f, 0.03668222f, 0.01522048f, 0.03114000f, -0.00078237f, 
    -0.00011135f, 0.03506368f, 0.03579937f, 0.00468537f, -0.00795245f, 0.02849324f, 0.03747781f, 0.02075703f, 
    0.00592202f, -0.00438777f, -0.01258915f, -0.02699923f, -0.05738664f, -0.02604464f, -0.04041180f, 0.00963003f, 
    0.00332301f, 0.02944730f, 0.00031799f, 0.00255242f, 0.00173288f, 0.02264264f, -0.00253799f, -0.06085364f, 
    -0.01537420f, -0.02267734f, 0.00671683f, -0.03915073f, 0.02935252f, 0.02499468f, -0.04345983f, -0.03960793f, 
    -0.06362172f, -0.02185125f, 0.03647948f, 0.02881377f, -0.02890649f, -0.00150351f, -0.00958375f, 0.00434810f, 
    -0.00153352f, -0.04410248f, -0.00516386f, 0.02281383f, -0.00311844f, -0.00544849f, -0.02037416f, -0.05413922f, 
    -0.05994026f, -0.00185252f, -0.02949482f, -0.02711410f, -0.00938566f, 0.03684805f, -0.05433046f, 0.04421765f, 
    -0.01046370f, -0.02252047f, -0.03291292f, 0.01601891f, 0.00097021f, -0.01159193f, -0.02460122f, -0.00969923f, 
    0.03165271f, 0.01852216f, -0.05300828f, 0.02059538f, -0.00878779f, -0.02945970f, -0.00659387f, 0.03645537f, 
    -0.02730351f, 0.04085596f, -0.00225511f, -0.04109345f, -0.04538586f, -0.05013039f, 0.02463109f, 0.03381734f, 
    0.01265446f, 0.00888414f, 0.03539224f, -0.05487297f, -0.05124318f, -0.00079693f, -0.04425295f, -0.02953862f, 
    -0.00537972f, -0.02130512f, -0.04180578f, -0.04347577f, 0.03496978f, 0.01294215f, -0.01540722f, 0.00468933f, 
    0.01456675f, -0.05311396f, 0.01136341f, -0.03899961f, 0.00331171f, -0.02503021f, 0.00978723f, -0.03316250f, 
    -0.00411572f, 0.01154241f, -0.04272153f, 0.03242007f, -0.02797016f, -0.02953551f, -0.05541914f, -0.03585855f, 
    0.02931990f, -0.05661660f, -0.02177067f, -0.04213440f, 0.02264572f, -0.00925899f, 0.00473846f, 0.02135219f, 
    -0.01836300f, 0.02912411f, -0.03671987f, -0.04409163f, 0.00796963f, -0.01288682f, -0.00585750f, 0.00700763f, 
    0.03353162f, 0.03486491f, 0.00256592f, 0.03119922f, -0.04936976f, -0.05313293f, -0.02005628f, -0.01906871f, 
    -0.05464825f, -0.01598112f, -0.00393581f, 0.01314054f, 0.02942763f, -0.03502746f, -0.03699115f, -0.02450623f, 
    -0.03475870f, -0.06249585f, -0.02462245f, -0.03148489f, -0.04375404f, -0.04386902f, 0.00249217f, 0.00965835f, 
    0.00249957f, 0.03721448f, -0.03228646f, -0.02024581f, -0.01938950f, 0.04439230f, 0.01534756f, 0.02335867f, 
    -0.02478275f, 0.00440418f, -0.05045122f, 0.02089077f, 0.00616073f, 0.04108290f, 0.02911472f, 0.00494128f, 
    -0.03458453f, 0.02828533f, 0.13241735f, 0.10195710f, 0.03961845f, -0.00396582f, -0.08870181f, -0.15585631f, 
    0.04285241f, 0.06203332f, -0.04766409f, -0.03747526f, -0.11636775f, -0.07758293f, 0.03600048f, 0.05512251f, 
    0.02365995f, -0.05114266f, 0.05994629f, 0.07711595f, -0.19193541f, -0.02878944f, 0.07932595f, 0.05238128f, 
    -0.02620545f, 0.22728723f, 0.16386051f, 0.01854786f, -0.10229671f, -0.02280802f, 0.03261079f, 0.05040846f, 
    0.06223454f, 0.12125164f, 0.14720376f, 0.01446663f, -0.29104301f, 0.02732085f, -0.06683839f, -0.28009588f, 
    0.00416308f, -0.10058969f, -0.00785869f, -0.11174453f, 0.04094032f, 0.16552252f, 0.00839173f, 0.02700883f, 
    -0.13052206f, -0.01995313f, -0.05666273f, -0.18279180f, -0.02080472f, 0.19598292f, 0.02244125f, -0.07923672f, 
    0.18172689f, 0.02488161f, -0.01499195f, 0.04107228f, 0.51224661f, 0.25603575f, 0.11389877f, 0.10777941f, 
    -0.01498478f, -0.03179313f, 0.06647009f, -0.03540928f, -0.07139359f, -0.00520480f, 0.00112958f, -0.12819120f, 
    0.16503872f, -0.40001529f, -0.23310195f, 0.18380509f, 0.15497571f, 0.19806691f, 0.13599777f, 0.17813112f, 
    -0.00889122f, -0.13804890f, 0.05952206f, 0.06679377f, 0.21482490f, 0.18889265f, 0.01988469f, -0.00248313f, 
    -0.02107564f, -0.07349464f, 0.04123391f, 0.02373027f, -0.00130001f, -0.02679206f, -0.06675564f, -0.07967515f, 
    0.16888648f, -0.04329616f, -0.15764691f, 0.09658769f, 0.20653766f, 0.03584944f, 0.02662819f, -0.07884344f, 
    0.03295816f, -0.05475483f, -0.13534506f, -0.13186805f, -0.59912443f, 0.04136030f, -0.05299188f, -0.31180558f, 
    0.06013032f, 0.01627531f, -0.18349467f, -0.15120636f, 0.01254235f, 0.01158104f, -0.05329875f, -0.02914477f, 
    -0.27762926f, -0.15197688f, 0.10632624f, -0.33471024f, -0.07935284f, 0.01038429f, 0.09958815f, -0.02621259f, 
    -0.00652956f, 0.16098838f, 0.05907755f, -0.07537159f, 0.00215693f, -0.11553630f, -0.12533449f, -0.09523232f, 
    -0.15183896f, -0.03733315f, 0.09224380f, 0.12148745f, -0.01731137f, 0.17429666f, 0.07617230f, -0.00047882f, 
    -0.20529003f, -0.70913410f, -0.54671311f, -0.53166282f, 0.08540196f, -0.00629358f, 0.12142117f, 0.02111197f, 
    -0.10520548f, 0.04251261f, 0.04172475f, 0.10327722f, 0.09427043f, 0.03885495f, 0.19365087f, 0.22744654f, 
    0.00774931f, 0.20416774f, 0.01979972f, -0.15929762f, 0.12384047f, -0.05834138f, 0.01072025f, 0.07612335f, 
    -0.13559163f, -0.24426171f, -0.12400329f, -0.23336437f, 0.05752168f, -0.14412424f, -0.08114317f, 0.04287053f, 
    -0.01332116f, 0.15497069f, -0.01080920f, 0.01835974f, 0.13823657f, -0.02818859f, 0.20166206f, 0.06107531f, 
    0.00536699f, 0.04132825f, 0.08400706f, 0.00020721f, 0.12912282f, 0.18164518f, 0.08206464f, 0.11340544f, 
    -0.51896536f, -0.68702853f, -0.55038142f, -0.58975267f, 0.06193397f, 0.06060458f, 0.11513298f, -0.03835325f, 
    -0.01752987f, -0.03458983f, 0.13979881f, 0.07982459f, 0.17392431f, 0.08259209f, 0.21096942f, 0.36721197f, 
    0.00194461f, 0.09680764f, 0.15702792f, -0.05362397f, 0.08523298f, -0.00778994f, 0.00294322f, 0.08991316f, 
    0.18026577f, -0.02674409f, 0.20703487f, 0.16440155f, -0.15858872f, 0.17077710f, -0.03313727f, -0.04519619f, 
    0.35596323f, -0.04808971f, -0.00829617f, -0.04276224f, -0.04401184f, -0.17560464f, -0.17460190f, -0.40481395f, 
    -0.00462764f, 0.11430763f, 0.02450907f, -0.10547561f, 0.00810506f, 0.06711439f, 0.14238088f, 0.22036953f, 
    0.55766147f, -0.23210381f, -0.22923063f, 0.16041414f, 0.16634582f, -0.18175891f, 0.17266442f, 0.14045127f, 
    0.22718932f, 0.26630983f, 0.05754501f, -0.08220907f, 0.12220783f, 0.10252110f, -0.06203448f, -0.12726146f, 
    -0.18007432f, 0.00033425f, 0.02728305f, 0.29205716f, 0.04529110f, 0.27222547f, 0.00561468f, -0.01585515f, 
    0.05064290f, 0.05432263f, -0.08461066f, 0.26099548f, 0.04712531f, -0.14742038f, 0.07820319f, -0.04343868f, 
    0.09026094f, 0.20009598f, -0.15502016f, 0.02778269f, 0.11459643f, 0.13773888f, 0.13732046f, 0.01806130f, 
    -0.00145403f, -0.02803954f, -0.06592321f, 0.03250497f, -0.03675856f, 0.00588125f, 0.05983664f, -0.00776936f, 
    -0.03585199f, 0.01341332f, 0.58105129f, -0.15669255f, -0.04885541f, -0.10578770f, -0.10978492f, 0.01025272f, 
    -0.07915007f, 0.17274106f, 0.03045509f, 0.05539110f, -0.20920865f, -0.07118738f, -0.00767755f, 0.04351247f, 
    0.03052646f, -0.15650055f, 0.01442352f, -0.20923881f, -0.22018957f, -0.20204045f, -0.09994164f, -0.03318917f, 
    -0.05878126f, -0.13789290f, 0.17797521f, 0.21791144f, -0.20397869f, 0.02773426f, 0.30095309f, -0.21083118f, 
    0.10702191f, -0.11242749f, 0.26719695f, -0.07160147f, 0.41860035f, 0.06575255f, 0.09249654f, 0.19017613f, 
    0.12375926f, 0.19027366f, 0.08776345f, -0.16351373f, -0.13521887f, -0.10492729f, -0.00547899f, 0.10465186f, 
    -0.55585533f, -0.30887118f, -0.22357836f, -0.23856929f, -0.14225069f, -0.02613950f, -0.00275158f, -0.02772538f, 
    -0.01970225f, 0.01269332f, -0.18740998f, -0.04634808f, 0.15630235f, 0.15393187f, -0.11833562f, -0.15766001f, 
    -0.06429163f, 0.07957408f, 0.05294972f, 0.03711158f, 0.05486759f, 0.03140263f, 0.16273285f, 0.09808683f, 
    0.34130323f, 0.23253928f, -0.16294773f, -0.03470860f, 0.06628006f, -0.14031138f, 0.27520180f, 0.05641336f, 
    -0.00037791f, 0.07745598f, -0.00031860f, 0.12496969f, 0.17520261f, 0.04706568f, -0.04008120f, -0.00025704f, 
    0.02288509f, 0.00860902f, 0.09602805f, -0.02968511f, 0.15972817f, 0.03153243f, 0.22294421f, 0.17332193f, 
    0.06653742f, -0.00295325f, 0.06447633f, -0.02741707f, 0.12245278f, -0.03937488f, -0.10235163f, 0.06239440f, 
    0.06539584f, -0.02884066f, -0.03520343f, -0.09196933f, 0.01003347f, 0.02296999f, 0.17021556f, 0.22335140f, 
    0.24724998f, 0.06895095f, -0.00351699f, 0.05335188f, -0.03773101f, 0.06827933f, 0.05578522f, 0.10195439f, 
    -0.39949468f, -0.00223868f, -0.22679864f, 0.31859758f, -0.01098546f, -0.01260572f, -0.12994878f, -0.14750297f, 
    0.02782954f, 0.12746128f, 0.01998285f, 0.10526556f, 0.04500453f, 0.24603821f, 0.35590971f, 0.27504417f, 
    0.00019321f, -0.10021265f, -0.19426133f, -0.09618696f, -0.12283709f, 0.02152537f, 0.08361112f, 0.04324734f, 
    -0.15848997f, -0.10019141f, 0.20548588f, 0.03321253f, -0.05794985f, 0.00113943f, 0.04812549f, -0.00963073f, 
    -0.00684890f, -0.00668191f, 0.16507125f, -0.08839427f, 0.08964409f, -0.17912064f, -0.03393856f, -0.19947781f, 
    -0.02203344f, 0.00080107f, -0.01089369f, 0.05992155f, -0.02932668f, 0.03965502f, -0.02646086f, -0.03870464f, 
    0.03403642f, -0.07125338f, 0.20114163f, 0.06889661f, 0.01790546f, 0.19079424f, -0.00183107f, 0.04876531f, 
    0.10918903f, 0.00402401f, -0.03638135f, 0.07573265f, 0.20715043f, -0.17269494f, -0.14021491f, -0.17784490f, 
    -0.03206568f, 0.05099811f, 0.02983134f, 0.04904560f, 0.00137921f, 0.02201734f, -0.07123951f, -0.09929460f, 
    0.09085649f, 0.09800027f, 0.05607021f, -0.08520439f, 0.08391764f, 0.09497538f, 0.04879719f, 0.10776556f, 
    -0.00170105f, 0.06746669f, -0.00231174f, -0.09342337f, -0.07483845f, 0.15412207f, 0.16630131f, 0.07256246f, 
    -0.01733145f, -0.08036298f, -0.01784413f, 0.09962886f, -0.06681675f, 0.01558077f, -0.11218569f, -0.12917039f, 
    -0.02049172f, 0.16799986f, 0.09131695f, 0.18350209f, 0.01183038f, -0.09263171f, -0.11943335f, -0.13874140f, 
    -0.01415096f, 0.01820994f, 0.15273745f, 0.21988040f, -0.02826439f, -0.03785813f, -0.10333779f, -0.13735244f, 
    -0.04344751f, -0.02539658f, -0.05267387f, -0.10487851f, 0.20450212f, 0.16589621f, 0.09970375f, 0.32195023f, 
    -0.11832555f, -0.17735817f, 0.09326864f, 0.16048494f, -0.14117827f, 0.05881492f, 0.10386032f, 0.04159348f, 
    0.03942864f, 0.02545064f, 0.04979750f, 0.08767839f, -0.18992890f, -0.15015748f, -0.07184392f, -0.00260584f, 
    0.09872817f, 0.12959066f, -0.08068651f, 0.05180810f, -0.03028261f, 0.06814606f, -0.04937820f, 0.14697254f, 
    0.21929225f, 0.38186708f, 0.29606238f, 0.15058178f, 0.14365770f, -0.13139367f, 0.09255224f, -0.10774419f, 
    -0.11030853f, -0.05233368f, 0.06611066f, 0.12699318f, 0.01934274f, -0.23349087f, -0.00903883f, -0.02191395f, 
    0.01718093f, 0.01026672f, 0.03238244f, 0.07130894f, 0.02309784f, 0.13102591f, 0.03850030f, 0.09190725f, 
    0.07274561f, -0.16167748f, -0.07083505f, 0.00789144f, 0.00530202f, -0.12486248f, 0.16169094f, -0.05776921f, 
    -0.01515833f, -0.02369124f, -0.10227289f, 0.12043851f, -0.14547786f, -0.19886254f, 0.05933564f, 0.03409963f, 
    0.14456850f, 0.07798524f, -0.06305668f, -0.01822138f, 0.05861455f, -0.00806687f, -0.13698590f, 0.01651314f, 
    0.05169042f, -0.07227796f, 0.06300309f, -0.21086907f, -0.04591932f, -0.07617583f, 0.13539121f, -0.01065389f, 
    0.02162037f, 0.05266626f, 0.13843921f, 0.17330383f, -0.28016520f, 0.05715943f, 0.00797439f, 0.30499762f, 
    -0.06575313f, 0.05631756f, -0.02844010f, -0.14968510f, 0.00746409f, 0.06917286f, 0.09954920f, 0.09135662f, 
    -0.13535093f, 0.25168896f, -0.06120705f, -0.30948767f, -0.02297327f, -0.01694389f, -0.07562700f, 0.11135703f, 
    -0.08652182f, 0.06822080f, 0.06194226f, -0.01342991f, 0.35290253f, -0.28466293f, -0.28635594f, 0.05203906f, 
    -0.03938983f, -0.04201289f, 0.12504624f, -0.10221877f, 0.17175651f, 0.05773020f, 0.04200057f, -0.10942705f, 
    0.17849852f, 0.04858378f, 0.01590860f, -0.10412083f, 0.03247048f, 0.02182056f, -0.07609316f, -0.03703777f, 
    0.04101015f, 0.08548065f, 0.02170999f, 0.08770290f, -0.02416274f, 0.07463684f, 0.03620989f, 0.32378966f, 
    0.13494821f, -0.00854231f, -0.04515488f, -0.07744966f, 0.09000919f, 0.05533486f, 0.07834858f, 0.02000313f, 
    0.06932651f, -0.04094743f, 0.07740532f, -0.03147599f, 0.05959639f, -0.01769970f, -0.08327764f, -0.03044254f, 
    -0.12959942f, -0.14478613f, 0.09837501f, -0.03692695f, -0.08239461f, 0.12428460f, -0.03311782f, 0.10733329f, 
    -0.01521434f, 0.13993803f, 0.10967063f, 0.03465661f, -0.02056180f, -0.08977119f, -0.13347244f, -0.16346569f, 
    -0.19251750f, -0.16055453f, -0.07044414f, -0.03139056f, 0.08545022f, 0.00111960f, -0.00338498f, -0.08030243f, 
    0.12812348f, 0.02145904f, -0.06307799f, -0.03642384f, 0.21271725f, 0.00415428f, 0.14818142f, -0.09938715f, 
    0.00034008f, 0.22082679f, 0.13196081f, 0.12790753f, 0.02161430f, -0.10303286f, -0.02865417f, -0.11000676f, 
    0.02051541f, 0.03837155f, 0.24195048f, -0.13821650f, -0.03529278f, -0.08556849f, 0.00844284f, 0.00602192f, 
    -0.11099665f, -0.05422001f, -0.15827587f, -0.13939615f, -0.35195023f, -0.03577414f, -0.15870608f, 0.18844496f, 
    0.17053860f, 0.15301424f, -0.11122885f, 0.08702010f, -0.06841518f, 0.08822553f, 0.08934330f, 0.10336627f, 
    0.18249147f, 0.12267853f, 0.06455138f, -0.20405163f, -0.06875007f, 0.11792567f, -0.05068234f, 0.02445479f, 
    -0.00586858f, 0.05698336f, -0.03469416f, -0.04888385f, 0.01097777f, 0.02570456f, -0.03418765f, 0.12722225f, 
    -0.06066356f, -0.01947878f, -0.07608331f, -0.04854386f, 0.07831096f, -0.06221756f, 0.02498915f, 0.24646258f, 
    0.00684788f, -0.02289936f, 0.04672062f, -0.00376815f, -0.01552845f, 0.02702659f, -0.02717485f, 0.01610364f, 
    -0.03089730f, 0.02272765f, -0.04468600f, 0.01564914f, -0.01932680f, -0.01381857f, 0.03913767f, 0.00119404f, 
    0.03443133f, 0.04740987f, -0.01503970f, 0.00179129f, -0.04354152f, -0.02224904f, 0.00109566f, -0.03030256f, 
    0.04026778f, 0.05706070f, 0.00900877f, -0.01408312f, 0.00108630f, -0.02146586f, -0.03402777f, -0.03544004f, 
    -0.00594410f, -0.00220984f, -0.01924522f, 0.00075625f, 0.00131565f, -0.03576736f, 0.00491887f, -0.00916551f, 
    0.01948544f, -0.02130967f, 0.02515832f, -0.05034420f, -0.01281499f, -0.03347963f, 0.01549063f, -0.01540596f, 
    0.04007129f, 0.02558860f, -0.02172608f, 0.00589921f, 0.01219436f, 0.03964164f, -0.05669255f, -0.01347297f, 
    0.03322615f, -0.04276074f, 0.02290652f, -0.00718888f, -0.00346408f, 0.00377039f, 0.03893412f, 0.02283130f, 
    -0.01771670f, 0.00377962f, -0.00041148f, 0.02933452f, -0.03595807f, -0.04595160f, -0.05013137f, -0.01671046f, 
    0.01930582f, 0.01868836f, -0.01773045f, -0.02310879f, -0.00964116f, -0.04994557f, 0.00590395f, 0.01141062f, 
    -0.01524126f, 0.04580700f, -0.05582101f, -0.03050782f, -0.05029167f, 0.02746735f, -0.05718672f, -0.01970046f, 
    -0.02123212f, 0.02230560f, -0.04017517f, -0.03156909f, 0.00906674f, 0.01520836f, -0.00004270f, -0.01984235f, 
    -0.05186954f, -0.03488798f, -0.01350120f, -0.01812665f, 0.03321941f, 0.03679357f, -0.02075287f, -0.01131686f, 
    -0.04330568f, 0.03773373f, -0.04042866f, -0.02618480f, -0.06057216f, -0.03070359f, 0.00636580f, -0.04418633f, 
    0.02687027f, 0.01669427f, -0.04920153f, 0.01730976f, -0.04990792f, 0.03108021f, -0.05308710f, -0.00541067f, 
    -0.01771218f, 0.00187122f, 0.04993371f, -0.01056733f, -0.00617768f, 0.01066855f, 0.02498430f, 0.02369805f, 
    -0.01990036f, -0.00591903f, 0.03054056f, 0.02524516f, -0.04107045f, 0.02309444f, 0.02400161f, 0.02939759f, 
    0.02364118f, -0.04979927f, -0.02671102f, 0.02130121f, -0.00117791f, 0.02563893f, 0.01976528f, -0.03015745f, 
    0.02134588f, 0.01262165f, 0.00755603f, 0.01973524f, -0.00190728f, -0.02728140f, 0.02699197f, 0.02832246f, 
    -0.01954276f, -0.01211285f, -0.02065256f, -0.02822446f, 0.04515285f, 0.01942702f, 0.05046613f, -0.02885310f, 
    -0.03583732f, 0.02745178f, -0.03061769f, 0.03252638f, -0.02814930f, -0.01370505f, 0.03693923f, -0.03648752f, 
    0.01406846f, -0.00512198f, 0.02375397f, 0.00071878f, 0.01298426f, -0.03410412f, 0.00041720f, -0.04286795f, 
    -0.04148183f, -0.02001450f, -0.00221611f, -0.03463141f, 0.00539336f, -0.01821720f, 0.00051393f, -0.02745003f, 
    -0.00586591f, 0.03874091f, -0.00133754f, -0.02699281f, -0.00182609f, 0.03452158f, -0.02006602f, -0.05702822f, 
    0.02844208f, -0.03011250f, 0.02351253f, -0.02378381f, -0.00237396f, 0.02591013f, 0.02244427f, -0.02639251f, 
    -0.05045916f, -0.05305721f, 0.02291178f, -0.03459166f, -0.04624945f, 0.01021905f, -0.03990254f, 0.00368830f, 
    0.02638351f, -0.01163258f, 0.03135090f, 0.02675174f, -0.03885839f, -0.03889329f, 0.00507531f, 0.00973162f, 
    0.01345996f, -0.04529289f, -0.02813360f, 0.05136174f, -0.05569018f, -0.04105908f, -0.04005309f, 0.01539824f, 
    0.04045676f, 0.02929244f, -0.00971593f, -0.04845506f, -0.00425215f, 0.01879948f, -0.00165536f, 0.00926347f, 
    -0.01287616f, -0.00336802f, 0.00059808f, -0.04584045f, -0.03264150f, -0.03460769f, 0.02712225f, 0.01691241f, 
    -0.04228060f, 0.03950858f, 0.01726804f, 0.01594360f, -0.05958972f, -0.04786954f, -0.04909249f, 0.00170578f, 
    0.02654126f, -0.03795487f, -0.03066562f, 0.01106008f, 0.02956671f, 0.04587520f, -0.04635976f, 0.01266956f, 
    -0.05389660f, -0.03450732f, -0.03496761f, -0.05082292f, 0.00152227f, -0.00528672f, -0.01297225f, -0.02121135f, 
    0.01592833f, 0.01887419f, -0.03445632f, -0.03212108f, 0.04523033f, 0.05657619f, -0.00230564f, -0.01052440f, 
    -0.05562987f, -0.00932323f, 0.01142478f, -0.03630614f, 0.00909893f, -0.01153216f, -0.01511930f, -0.04200528f, 
    -0.01677355f, -0.01034973f, 0.01490912f, 0.05073857f, 0.02743275f, -0.02933804f, 0.04465471f, 0.00213121f, 
    -0.02915205f, -0.04198250f, -0.01702085f, -0.03273569f, 0.02233689f, -0.02651663f, 0.01783765f, -0.04259263f, 
    -0.02912318f, 0.01169995f, -0.01409856f, 0.01757331f, 0.03469633f, 0.00911624f, 0.04132532f, -0.03632572f, 
    -0.05174432f, -0.00490080f, -0.01616873f, -0.01481091f, 0.03535978f, 0.01469974f, 0.01866122f, 0.01216807f, 
    0.00370834f, -0.04489490f, 0.00128586f, 0.01472164f, -0.00362377f, 0.02372085f, -0.00892842f, -0.01305329f, 
    -0.01485585f, -0.01876049f, -0.05656903f, 0.02881632f, -0.04395326f, 0.01778039f, 0.00346662f, -0.02819577f, 
    -0.03968268f, -0.00582687f, -0.03133010f, 0.00211814f, -0.02325200f, 0.01493568f, -0.04141313f, 0.00323206f, 
    -0.04935475f, -0.01865561f, 0.04708771f, 0.03707442f, -0.00870294f, 0.01186003f, -0.01653562f, -0.04430746f, 
    0.04003982f, -0.00790299f, 0.00950250f, 0.01001793f, -0.03471128f, 0.00666396f, -0.02260167f, 0.02534379f, 
    -0.04467625f, 0.01935725f, -0.01566234f, 0.01585448f, -0.04413053f, -0.05916820f, 0.04390985f, 0.02662752f, 
    0.02322603f, 0.01717081f, -0.03847059f, -0.01804710f, -0.04053428f, 0.04943066f, 0.01708546f, 0.00935759f, 
    -0.05424166f, 0.04407962f, 0.04157459f, 0.00997604f, 0.00181911f, 0.03307587f, -0.02471912f, 0.03059178f, 
    -0.02431685f, 0.01233572f, -0.04078826f, 0.00892990f, -0.00596503f, -0.04542147f, -0.03992863f, 0.01604166f, 
    0.00899654f, -0.02921672f, -0.05517804f, -0.02444628f, 0.00564370f, -0.01434652f, 0.02688874f, -0.02331910f, 
    -0.02569654f, -0.01337346f, -0.03605093f, -0.02219521f, 0.04246199f, 0.03236885f, 0.02134172f, -0.04661493f, 
    -0.04998273f, -0.05432162f, -0.02525203f, 0.03385044f, 0.03917218f, 0.02117709f, 0.03376323f, -0.00568926f, 
    -0.00793231f, -0.00445680f, 0.04679214f, -0.04690062f, -0.00612146f, -0.02977240f, -0.02582305f, 0.03030696f, 
    0.01819311f, 0.01326186f, -0.00580758f, -0.01450615f, -0.02427091f, 0.03534921f, -0.04682316f, -0.03640686f, 
    -0.01793235f, 0.02860322f, -0.00078608f, 0.01712476f, -0.04225430f, 0.00544997f, 0.02421953f, 0.00157397f, 
    0.01356293f, -0.00144068f, 0.02177745f, -0.03854734f, 0.01219977f, -0.04885869f, 0.01342011f, -0.05124774f, 
    0.02002486f, -0.02526096f, 0.03806151f, -0.00595610f, -0.03971058f, -0.01200322f, 0.03002646f, 0.00348108f, 
    -0.00863934f, -0.04964901f, -0.03552219f, 0.01523668f, -0.00245564f, 0.03641343f, -0.05075300f, 0.01237508f, 
    0.04883891f, -0.01215024f, -0.02810255f, -0.02879424f, 0.04039451f, 0.03155151f, -0.03780330f, -0.05699047f, 
    0.01905253f, 0.01780395f, -0.03317903f, 0.01615000f, -0.02802054f, -0.04917713f, -0.03755974f, -0.01185294f, 
    0.02751044f, -0.05678551f, -0.01960757f, -0.03859865f, -0.02361526f, -0.04570207f, -0.04465802f, -0.03596362f, 
    0.01820030f, 0.02301858f, -0.04187428f, -0.02078240f, 0.01190152f, -0.03936141f, -0.04671444f, -0.03934892f, 
    -0.00020587f, 0.01534972f, -0.01139125f, 0.02938736f, 0.03235276f, -0.04403034f, 0.04536506f, -0.02695375f, 
    -0.05820962f, -0.01271637f, 0.02002770f, 0.03648332f, 0.00302433f, 0.04416688f, 0.01979575f, 0.00905037f, 
    -0.03700481f, -0.04818600f, -0.03546410f, 0.00125027f, -0.01942276f, -0.04449350f, 0.03231287f, 0.03570081f, 
    0.00707986f, -0.02156335f, -0.04056260f, -0.03977894f, -0.01439462f, 0.02194607f, -0.00106494f, 0.01200965f, 
    0.03200500f, -0.01960646f, 0.02890951f, -0.02148345f, 0.00958501f, 0.03878821f, -0.04437538f, -0.03077548f, 
    0.01938699f, -0.04767356f, -0.00142155f, -0.04531865f, -0.04130336f, -0.02429479f, 0.00195655f, -0.00445867f, 
    -0.03115624f, -0.04738352f, -0.01540321f, -0.03083712f, -0.03691700f, -0.03699220f, -0.01136190f, 0.03436736f, 
    0.02850710f, 0.00080581f, -0.03257771f, -0.00451570f, -0.02739890f, 0.04027490f, 0.03187737f, -0.03521842f, 
    -0.02003785f, -0.03038727f, -0.02639399f, 0.03146949f, 0.04183055f, -0.03196428f, 0.03587719f, 0.03403324f, 
    -0.01336136f, 0.04076665f, 0.02184301f, 0.02229050f, -0.03045678f, 0.01769651f, -0.05570330f, 0.01921958f, 
    -0.03624253f, -0.04857474f, 0.04180035f, 0.00563456f, 0.01570698f, 0.02704034f, -0.03203583f, -0.01912159f, 
    0.01335957f, -0.00383514f, 0.03947048f, 0.05079235f, 0.02028174f, -0.04104069f, 0.04228782f, 0.00406642f, 
    0.00019235f, 0.02110579f, -0.01189215f, -0.01567303f, -0.02590685f, -0.04829312f, -0.03941570f, -0.01522565f, 
    -0.01157568f, -0.05651873f, 0.04079887f, 0.02524420f, -0.05755058f, 0.02198595f, -0.03099360f, -0.03311760f, 
    -0.04000828f, 0.03690301f, 0.03076775f, 0.02692021f, -0.00380205f, 0.01828190f, 0.02612510f, 0.03706325f, 
    -0.00290314f, -0.00778704f, -0.02916629f, -0.03566157f, 0.01820159f, -0.01168951f, 0.01408994f, 0.00594989f, 
    -0.05412550f, -0.04996341f, -0.03750364f, -0.03676977f, 0.00017125f, 0.03389107f, -0.03417208f, -0.01153385f, 
    0.00174637f, -0.04999297f, 0.03340667f, -0.05627545f, -0.03703019f, -0.04764115f, -0.00634046f, 0.03364907f, 
    -0.04570451f, 0.01795836f, -0.01484603f, -0.02029387f, -0.03909276f, 0.01865075f, -0.00605999f, -0.03805938f, 
    -0.00874473f, 0.02210762f, 0.00513542f, -0.02949304f, -0.01194658f, -0.00680911f, 0.02098906f, -0.03627705f, 
    0.00243837f, -0.02403411f, -0.02369761f, -0.00393350f, 0.02991531f, -0.00090246f, -0.03428819f, -0.03009234f, 
    -0.05723165f, -0.03133317f, -0.05324707f, -0.00866089f, 0.05605151f, 0.02817039f, 0.02649132f, -0.01834005f, 
    -0.00699946f, -0.00697384f, 0.00865938f, -0.00878544f, 0.00803455f, -0.04401439f, -0.03361335f, -0.00287078f, 
    -0.05181407f, -0.02840555f, -0.00023143f, -0.04641022f, -0.02446386f, -0.04084095f, -0.01367433f, 0.01022528f, 
    -0.01928747f, 0.03072020f, 0.02548161f, -0.05357581f, -0.03607665f, -0.00301299f, -0.04843240f, 0.03398615f, 
    -0.02197119f, -0.03157996f, -0.01508969f, -0.02415133f, -0.02083224f, -0.00557353f, -0.05437929f, -0.05903585f, 
    -0.02360524f, -0.04326600f, 0.00207187f, -0.04931320f, 0.03826400f, -0.05402556f, 0.00181383f, 0.02463438f, 
    -0.02803518f, 0.02923697f, 0.04269055f, -0.05371262f, -0.04262264f, -0.01114892f, -0.05583132f, -0.00473671f, 
    -0.02472036f, 0.00271166f, 0.01815460f, 0.03816401f, -0.02145339f, -0.00752960f, -0.04847952f, 0.00697789f, 
    0.01066768f, 0.00674733f, -0.05373470f, 0.00835931f, 0.01062201f, 0.01430002f, -0.00492914f, -0.00509860f, 
    -0.04576412f, -0.04218495f, -0.03259139f, -0.00059508f, -0.01629276f, -0.01242467f, -0.01746047f, 0.02907790f, 
    0.00341302f, 0.02019357f, 0.01763436f, -0.00723658f, -0.02687251f, -0.05063000f, -0.01545413f, 0.04186655f, 
    -0.01193344f, -0.02350741f, 0.04906635f, 0.02162417f, -0.00309659f, -0.00435099f, 0.03937815f, 0.04348508f, 
    0.02789896f, -0.04175412f, -0.02655772f, 0.03985020f, 0.04173246f, -0.02596528f, 0.02554192f, -0.05590993f, 
    0.03713290f, -0.03976844f, 0.04348290f, -0.04442576f, 0.03135962f, 0.03615177f, -0.02615001f, -0.00387367f, 
    -0.04505946f, -0.12064939f, -0.10328398f, 0.22963536f, -0.08060510f, -0.03735466f, 0.08317535f, -0.06214578f, 
    -0.05747489f, 0.03088026f, 0.08214974f, 0.04468410f, 0.19020344f, 0.09177122f, -0.16513397f, -0.07739173f, 
    0.10295901f, 0.13874471f, 0.15556030f, -0.01365444f, 0.02950440f, -0.13955399f, 0.05797599f, -0.07757247f, 
    0.10289695f, 0.09528171f, 0.20906171f, -0.20602344f, -0.04563029f, 0.01483669f, 0.13166603f, 0.01045620f, 
    -0.02517937f, 0.16417792f, -0.06940208f, -0.07052880f, 0.04420235f, -0.12271912f, -0.25779203f, -0.01125737f, 
    0.11539686f, 0.18262710f, 0.18086520f, 0.06107865f, 0.09564102f, 0.02366432f, -0.11522946f, -0.11919878f, 
    0.20510618f, 0.14803508f, -0.27225342f, -0.01165874f, 0.24399439f, 0.10699242f, 0.11663110f, 0.12591216f, 
    0.00371520f, -0.07072322f, -0.06093261f, 0.08118527f, -0.13240658f, 0.14270020f, -0.09675401f, 0.21551263f, 
    -0.03428981f, -0.09208939f, -0.08379364f, -0.00750445f, -0.01173508f, 0.01349168f, 0.05520517f, 0.10962851f, 
    0.07169065f, 0.14361632f, -0.06493361f, 0.04565129f, 0.08748478f, 0.08245017f, 0.09580510f, 0.16736300f, 
    0.01296122f, -0.01120697f, -0.03086275f, -0.13418110f, -0.29019347f, 0.09132544f, -0.05490356f, 0.14344846f, 
    -0.01928413f, -0.06489503f, -0.01033060f, -0.07443231f, -0.00566404f, -0.02350329f, 0.14197491f, 0.08988176f, 
    -0.07113934f, -0.20113879f, -0.08604879f, 0.14312035f, 0.07799389f, -0.04883486f, -0.14084537f, 0.03782490f, 
    0.01041107f, -0.12237514f, 0.02548849f, 0.05912949f, 0.11686318f, 0.08113267f, -0.18972495f, 0.00518461f, 
    0.23096047f, 0.29050124f, 0.15897748f, 0.09358107f, 0.09974712f, -0.04400633f, 0.05797943f, -0.03248477f, 
    0.19563696f, -0.02545410f, 0.00258355f, -0.02209666f, 0.10812581f, 0.02918807f, 0.10081581f, 0.14071268f, 
    -0.05211788f, 0.02609228f, -0.10828764f, 0.16638499f, -0.19643191f, -0.10401877f, -0.05990858f, 0.06118223f, 
    0.03169882f, 0.07217164f, -0.07525703f, 0.01113309f, 0.03503028f, -0.13137662f, -0.12665601f, -0.20958994f, 
    0.24853297f, 0.12542465f, 0.06309918f, -0.07958068f, 0.26717243f, 0.03127879f, 0.00960400f, 0.14334299f, 
    -0.02968235f, -0.03371949f, -0.07904338f, 0.07449165f, -0.01216479f, 0.13815594f, -0.02686779f, -0.00700673f, 
    -0.04925277f, -0.12102658f, -0.01630731f, 0.03781522f, 0.11270450f, -0.03964403f, 0.06628989f, -0.11093703f, 
    0.03875501f, -0.26630500f, -0.04235494f, 0.04245321f, 0.00545496f, 0.16128474f, -0.02108123f, 0.03959256f, 
    0.22883418f, 0.07514426f, 0.02157306f, -0.11721796f, -0.15703452f, 0.00104772f, -0.10201152f, 0.07075700f, 
    -0.02860706f, -0.02486613f, -0.03219596f, -0.07829054f, 0.10370605f, -0.01933787f, 0.03775555f, 0.12977915f, 
    0.20282282f, 0.19044723f, 0.21049461f, -0.07458773f, 0.13626511f, 0.25090861f, 0.06488706f, 0.32173103f, 
    -0.05811588f, 0.01222746f, -0.06126101f, -0.01968641f, 0.09933343f, 0.01832662f, -0.17837125f, -0.10055936f, 
    -0.02053984f, -0.07260597f, 0.00460381f, 0.03673536f, 0.01826101f, -0.04007309f, 0.12289725f, 0.17605317f, 
    0.15983541f, 0.10415763f, -0.03951631f, 0.11850007f, 0.01285376f, -0.01307567f, -0.03504463f, 0.03923957f, 
    -0.04188887f, 0.05126411f, 0.05148789f, -0.10840441f, 0.24576874f, 0.32939875f, 0.32012683f, -0.18462785f, 
    -0.05379679f, -0.02634696f, -0.09689811f, -0.03748720f, -0.00978546f, -0.09872073f, -0.00202524f, -0.14566933f, 
    0.00775976f, -0.27544090f, -0.22714518f, 0.29206434f, -0.02423224f, 0.08403765f, -0.06766430f, -0.01742486f, 
    0.19797722f, -0.04852775f, -0.03445505f, 0.04856110f, -0.37138188f, 0.35727766f, 0.07897169f, -0.10882128f, 
    -0.06184909f, 0.01933452f, -0.23827374f, 0.13499333f, -0.01655282f, 0.09581739f, 0.05052297f, -0.01325775f, 
    0.07746476f, 0.04448253f, 0.04994841f, 0.14047731f, -0.06684662f, -0.03449704f, 0.10000972f, -0.10858633f, 
    0.11350570f, -0.05246983f, 0.06154903f, -0.11617228f, -0.00949815f, -0.05972447f, -0.01095826f, -0.18519986f, 
    -0.08757925f, -0.07060491f, -0.02353034f, -0.00744453f, -0.15298061f, 0.00738795f, 0.06062879f, -0.07240785f, 
    0.30242100f, 0.14230883f, -0.05500137f, 0.21693262f, -0.07737119f, 0.00945851f, 0.04305158f, -0.01568764f, 
    -0.01105375f, 0.13909565f, 0.16921508f, 0.19153273f, 0.09156562f, 0.12071985f, 0.17618901f, -0.04990758f, 
    -0.03977324f, -0.03618903f, -0.09836048f, -0.04674287f, -0.09214880f, 0.13125181f, 0.03781582f, 0.03083234f, 
    0.16612159f, 0.20234442f, 0.02767554f, -0.07077200f, -0.00882630f, -0.18326722f, 0.00524495f, 0.13396689f, 
    -0.13365255f, 0.00464507f, -0.01864865f, -0.05542499f, -0.20680773f, -0.08035253f, -0.07402031f, 0.26311108f, 
    0.06139936f, -0.11256281f, -0.16773391f, -0.05317472f, -0.05218521f, 0.05415564f, 0.07539202f, 0.08021319f, 
    0.11449730f, -0.05633616f, -0.30811444f, 0.29420826f, 0.12067959f, 0.14459844f, 0.07342028f, -0.04230781f, 
    -0.02145354f, 0.03211877f, -0.00470280f, 0.17871389f, 0.37603378f, 0.34939215f, 0.04611135f, -0.43606412f, 
    -0.06049408f, -0.06625216f, 0.09934295f, -0.11631627f, 0.14467017f, -0.09410191f, -0.20244995f, 0.00836014f, 
    -0.28283641f, -0.02245174f, -0.27162611f, 0.23610394f, 0.02890081f, 0.10902487f, 0.08967507f, -0.22448878f, 
    0.00555697f, -0.08649987f, 0.07800025f, 0.08864974f, -0.15601911f, -0.05520128f, -0.06039936f, -0.00781449f, 
    -0.01738500f, -0.04246637f, -0.09531257f, -0.01685888f, -0.00170520f, 0.07512290f, -0.04330726f, -0.14253156f, 
    -0.06687961f, -0.17807978f, -0.02343773f, -0.02300288f, -0.08298589f, -0.00142213f, -0.01452698f, 0.12867248f, 
    -0.01036611f, 0.14564204f, -0.01388664f, 0.07582914f, -0.00513344f, 0.14746135f, 0.05351747f, 0.06862959f, 
    0.14903715f, -0.02501279f, 0.09849951f, 0.11257879f, 0.04404286f, 0.11690750f, 0.08047363f, -0.06858316f, 
    0.07556722f, 0.10652097f, 0.09968219f, -0.30852076f, 0.06615718f, -0.01394782f, -0.03668259f, 0.06410722f, 
    0.07399385f, 0.04070152f, -0.08393960f, 0.02163887f, -0.28705508f, 0.07768942f, -0.02058247f, 0.14537154f, 
    0.06944814f, 0.12367021f, 0.07012334f, -0.01175177f, -0.12058721f, 0.03788750f, 0.06501358f, 0.05846810f, 
    -0.02813392f, -0.06312367f, -0.14046583f, 0.07702008f, -0.09485498f, 0.10793685f, 0.09342941f, -0.10932802f, 
    0.02064549f, 0.20166658f, -0.04230136f, -0.00385037f, 0.06027887f, -0.00813684f, 0.47651353f, -0.04952429f, 
    -0.07007716f, 0.01963134f, -0.04830013f, 0.03981832f, -0.15668327f, -0.08993711f, 0.13751996f, -0.10434884f, 
    -0.04484457f, -0.24124794f, 0.09882537f, -0.14221652f, -0.04419600f, 0.06108310f, 0.00621509f, 0.03213554f, 
    -0.05228182f, -0.10267678f, 0.05688161f, 0.04810670f, 0.11433025f, -0.10825953f, 0.26561508f, -0.07315066f, 
    0.05159760f, 0.00403786f, 0.07290284f, 0.14915222f, -0.05946544f, 0.04857026f, -0.08828068f, -0.00865093f, 
    -0.01246435f, -0.05860041f, 0.05234778f, 0.01253732f, -0.10441738f, -0.11740371f, 0.00753247f, 0.02438714f, 
    -0.00731491f, 0.00213596f, -0.05128546f, 0.04083632f, -0.12375917f, -0.17518902f, -0.28308821f, -0.07490651f, 
    0.03466196f, -0.04923810f, 0.06779464f, -0.02005963f, -0.08761504f, -0.03968722f, -0.05558821f, 0.05427567f, 
    0.06992552f, 0.10926567f, -0.02242994f, 0.04169071f, 0.07185929f, 0.02444470f, -0.08937720f, -0.02969195f, 
    -0.16475791f, 0.29534540f, 0.14586718f, 0.06523725f, -0.08667794f, -0.11178686f, 0.05566907f, 0.02623768f, 
    0.00107144f, 0.01532635f, -0.14246002f, 0.07149492f, -0.12147535f, 0.17373016f, 0.08310195f, 0.03849660f, 
    0.22120528f, 0.05819982f, 0.05256012f, 0.11309908f, 0.06000070f, 0.04942257f, -0.02381442f, -0.09842315f, 
    -0.03814487f, 0.08431850f, -0.04571439f, -0.04035146f, -0.05863532f, 0.00841878f, -0.06271401f, 0.07009701f, 
    -0.09777170f, -0.01111832f, 0.02293078f, -0.00974637f, -0.04359931f, 0.02116613f, 0.01670283f, 0.19053537f, 
    0.01460190f, -0.00389472f, -0.02808976f, 0.09359474f, 0.10305714f, 0.17361465f, 0.01024563f, -0.01708535f, 
    -0.01309422f, 0.05923464f, -0.07670183f, -0.05093366f, -0.13553996f, 0.07845717f, 0.07216968f, 0.03389399f, 
    -0.09504652f, 0.04267498f, 0.04364267f, -0.02627802f, -0.09409706f, 0.14034075f, -0.08721630f, 0.14446525f, 
    0.09252958f, -0.00873961f, -0.01848303f, -0.12597676f, 0.04452585f, 0.02225892f, -0.18893886f, 0.00936758f, 
    -0.04439157f, -0.02506475f, -0.08473123f, -0.10462303f, -0.00248918f, 0.01710273f, -0.00656175f, 0.01047056f, 
    -0.05213903f, 0.03595483f, 0.00438960f, 0.04032818f, 0.00437301f, -0.06328253f, 0.07381335f, -0.09823964f, 
    0.39204106f, -0.24072666f, 0.37597376f, -0.09364453f, -0.04961121f, 0.13532314f, -0.06824131f, -0.01037136f, 
    0.14375196f, 0.16087411f, 0.14240928f, -0.13999170f, 0.18026008f, 0.01019726f, -0.01745137f, -0.02997160f, 
    0.04227134f, -0.02628451f, -0.06266841f, -0.06843806f, -0.01904333f, 0.00651808f, 0.24503794f, 0.11878515f, 
    -0.13409874f, -0.15104458f, 0.05644582f, 0.10328361f, -0.09187362f, 0.01926415f, -0.01384145f, -0.00040557f, 
    -0.08254650f, 0.28195447f, 0.06123950f, 0.04676552f, 0.19693506f, -0.27056286f, 0.15697461f, -0.18334126f, 
    -0.09132321f, 0.05790483f, -0.05491384f, 0.17689003f, 0.12209240f, -0.19353195f, 0.24741943f, -0.06125139f, 
    -0.11374883f, -0.15246940f, -0.20151003f, 0.20249356f, 0.06795742f, -0.11510594f, 0.02943092f, 0.02701096f, 
    0.12032624f, -0.04081521f, -0.14241849f, 0.06852366f, -0.31119436f, -0.01579051f, -0.01539441f, -0.02342379f, 
    0.09098768f, 0.05660582f, 0.00385211f, 0.04249429f, 0.00114249f, 0.03437673f, 0.11446086f, -0.06925166f, 
    0.05614528f, -0.30552733f, 0.17796600f, -0.14334381f, -0.08708499f, 0.04733963f, 0.02926426f, 0.02473487f, 
    -0.05772050f, 0.01530225f, 0.05392163f, -0.04111591f, -0.07555643f, 0.03528520f, -0.00722263f, 0.09181646f, 
    0.13694476f, -0.11357090f, -0.10435681f, 0.04969201f, -0.05366917f, -0.10118808f, -0.08947254f, -0.02140287f, 
    -0.01636132f, 0.14992163f, -0.01993941f, -0.15583409f, -0.03254084f, -0.04600579f, 0.25789136f, -0.11644035f, 
    0.22924832f, -0.04690945f, 0.06496421f, 0.15722689f, 0.26881748f, 0.06049704f, 0.17508982f, -0.32377362f, 
    0.04205735f, 0.08704446f, -0.19184294f, -0.09554714f, -0.02528653f, -0.04015046f, 0.01375102f, 0.01883358f, 
    0.17675136f, -0.06508787f, -0.04189324f, -0.06547848f, -0.09480343f, -0.04237498f, 0.18446997f, -0.04140503f, 
    0.06467481f, -0.04179748f, -0.04874508f, -0.03083015f, -0.17857091f, 0.38436595f, -0.48373505f, 0.21788806f, 
    0.13497026f, -0.16243222f, 0.18534778f, 0.01385586f, 0.13564503f, 0.00238726f, 0.25555447f, -0.00622399f, 
    -0.01752130f, -0.21708357f, 0.53597283f, -0.07675194f, 0.11419737f, -0.21616092f, 0.02977661f, 0.07393508f, 
    -0.11225073f, -0.01021100f, 0.01035423f, 0.10874977f, -0.01904405f, -0.02571476f, -0.06670038f, 0.26444015f, 
    -0.02240325f, -0.07495730f, -0.02004339f, 0.02698152f, -0.08454098f, 0.02863483f, -0.09248285f, 0.20429447f, 
    -0.09060354f, 0.12205669f, -0.00053358f, 0.02967576f, 0.11723835f, 0.02943529f, -0.03313788f, -0.16636607f, 
    -0.00119850f, 0.08427668f, 0.10350554f, -0.03598922f, -0.07452306f, -0.15196542f, 0.07971793f, -0.00202597f, 
    -0.04170840f, -0.06886542f, 0.04341771f, -0.03779193f, 0.05812903f, -0.05098779f, -0.04388687f, 0.17174336f, 
    0.14937156f, -0.00517650f, -0.05255980f, 0.29954195f, -0.06014241f, 0.02978649f, 0.01446477f, -0.06941738f, 
    0.03961939f, 0.06652109f, 0.12510952f, -0.02333874f, 0.02330943f, 0.01929347f, 0.20028596f, -0.14707395f, 
    -0.06392635f, -0.08578116f, -0.01121587f, -0.00982437f, 0.11929078f, 0.05622284f, 0.06975194f, 0.11295621f, 
    -0.11237263f, 0.09963191f, 0.14435475f, -0.16790785f, 0.06532521f, 0.03399268f, -0.03466431f, 0.12501693f, 
    0.06775297f, -0.08848626f, -0.01764505f, -0.03682814f, 0.03362086f, 0.14947049f, -0.57809991f, 0.09380209f, 
    -0.00092478f, -0.07473148f, -0.03606474f, -0.01427151f, 0.06533290f, 0.06315522f, -0.03947136f, -0.01463809f, 
    -0.10439017f, 0.17833726f, 0.09990933f, 0.15747918f, 0.08778016f, -0.03494716f, 0.08870897f, -0.06586065f, 
    0.05061222f, 0.05953431f, 0.02063930f, 0.05058285f, 0.00449071f, 0.01141671f, -0.10192177f, -0.02924405f, 
    0.01961957f, -0.04236246f, -0.05381579f, -0.11013594f, 0.00177673f, -0.04682785f, 0.03280196f, -0.05573792f, 
    -0.06367091f, 0.14383306f, -0.12230633f, -0.09391713f, -0.03614941f, 0.10332057f, 0.06062004f, 0.05100228f, 
    0.09527726f, 0.04407644f, 0.05506996f, 0.01916315f, -0.00543697f, 0.08680201f, 0.31546330f, -0.07503535f, 
    0.02516107f, 0.11936378f, -0.03887949f, -0.04593011f, -0.00113609f, 0.10174726f, -0.04589697f, 0.05349563f, 
    -0.19666742f, 0.10277254f, 0.05849480f, 0.04616831f, -0.02322746f, -0.09686755f, 0.00327113f, -0.05391347f, 
    0.38349000f, 0.01478473f, 0.00042613f, -0.07922576f, 0.17260869f, 0.07927607f, -0.04629581f, -0.02794478f, 
    -0.03328995f, 0.00774819f, 0.08381724f, 0.05057456f, 0.09304236f, 0.16651885f, 0.15427533f, -0.01847102f, 
    -0.29552034f, -0.16936214f, -0.10482695f, -0.08846523f, -0.10764427f, -0.12621155f, 0.05789902f, 0.10269533f, 
    -0.02611921f, -0.05304141f, 0.12595144f, 0.09949429f, -0.03696227f, 0.00982281f, 0.07215512f, -0.07768449f, 
    0.02786949f, 0.08622421f, -0.06052132f, -0.03236537f, 0.05901885f, 0.02820889f, -0.03322178f, -0.03210092f, 
    -0.04074176f, -0.00238458f, 0.18047884f, 0.05117375f, -0.06754175f, -0.10599231f, -0.06840272f, 0.06614345f, 
    0.06908412f, 0.21916436f, 0.08424480f, 0.11409000f, -0.02871023f, 0.01335644f, 0.03365108f, -0.02437053f, 
    0.04368050f, 0.02204649f, -0.01601834f, 0.07507002f, 0.07943197f, -0.12717551f, 0.09927015f, -0.16382086f, 
    -0.18995126f, -0.07670260f, 0.04753335f, 0.08297774f, -0.09648418f, 0.04029001f, 0.20349732f, -0.01884394f, 
    0.02695196f, -0.07677764f, 0.09288922f, -0.01921642f, -0.00566236f, -0.10022964f, -0.00983138f, 0.13291086f, 
    0.06786051f, -0.09484245f, -0.02539012f, -0.07823256f, -0.02701475f, 0.02313307f, -0.06809907f, 0.07188753f, 
    -0.36478558f, 0.12794268f, -0.36089256f, 0.30184832f, 0.00996837f, 0.03118454f, -0.06304189f, 0.16050777f, 
    0.04563177f, -0.16791189f, -0.02652817f, 0.24458961f, -0.17520326f, -0.18140183f, 0.01856651f, 0.18902472f, 
    -0.03360078f, 0.10532843f, 0.07926494f, 0.11076436f, 0.16560976f, 0.09271209f, -0.04743130f, 0.12380003f, 
    0.15729240f, 0.44020540f, -0.25442576f, -0.19932570f, -0.04090463f, -0.09175696f, 0.20726597f, 0.07590118f, 
    0.18067710f, -0.09658524f, -0.04228043f, -0.04534885f, 0.10128331f, -0.04323092f, -0.24104288f, 0.11348453f, 
    0.05365180f, -0.03815253f, -0.00401854f, -0.06604346f, -0.16588461f, 0.27804938f, -0.12852980f, 0.20398396f, 
    0.00510075f, 0.11579113f, 0.11240745f, -0.20463319f, 0.02421054f, -0.07334566f, -0.02550228f, -0.12348778f, 
    -0.03153563f, 0.24774955f, 0.08012731f, 0.06775299f, 0.12197252f, -0.01446847f, 0.05083551f, -0.03150314f, 
    0.05326781f, -0.07111111f, -0.09540245f, -0.09414131f, 0.08607563f, -0.00111456f, 0.10745477f, 0.11807270f, 
    -0.27049196f, 0.34198040f, -0.24631344f, -0.07994965f, 0.04230880f, 0.03467561f, -0.12322201f, 0.01645325f, 
    0.03348481f, -0.09181876f, 0.03484666f, 0.17025118f, 0.01740723f, -0.19201325f, -0.04155313f, -0.08040499f, 
    0.14223722f, 0.05313691f, -0.07403143f, -0.02477762f, 0.15021586f, -0.03160858f, -0.04170790f, -0.00273229f, 
    0.06049320f, -0.05812056f, -0.00458677f, 0.07832585f, 0.00186770f, 0.09494045f, -0.17764035f, 0.11741684f, 
    -0.12089522f, 0.05991172f, 0.01093039f, -0.13467784f, -0.31927985f, -0.08922873f, -0.40098342f, 0.28842175f, 
    0.09309804f, 0.15202209f, 0.31652907f, 0.05256303f, -0.02996669f, -0.05135823f, -0.02882342f, 0.02802091f, 
    -0.22874446f, 0.06396183f, -0.05135700f, 0.06588740f, 0.11618836f, -0.01247755f, -0.05659036f, 0.08111528f, 
    -0.09406013f, 0.03672581f, 0.06922123f, 0.09177675f, 0.05222092f, -0.29255477f, 0.45176643f, -0.17627442f, 
    -0.05475345f, 0.01652974f, -0.04769589f, 0.10126822f, -0.06639443f, 0.17298059f, -0.01802650f, 0.01649203f, 
    0.20976460f, 0.31766197f, -0.52900177f, 0.01715765f, -0.09241502f, 0.13254198f, 0.06357597f, 0.09914607f, 
    0.10902328f, 0.02767111f, -0.11166926f, -0.14722224f, 0.15857522f, -0.08064760f, 0.03378514f, -0.18112893f, 
    0.00317283f, -0.01571983f, 0.01432342f, -0.04136661f, 0.14678873f, -0.15892605f, 0.17103209f, -0.10521320f, 
    0.03546938f, 0.10568766f, -0.08484417f, 0.01276092f, 0.10313141f, -0.04625858f, 0.12341978f, 0.11518841f, 
    -0.01787289f, -0.11273663f, 0.02174155f, 0.12532419f, 0.34665683f, 0.03001757f, -0.03216271f, -0.02601269f, 
    -0.00964264f, 0.03743111f, -0.05677629f, 0.07763246f, -0.00315189f, -0.01589748f, -0.12178781f, 0.08847219f, 
    0.31089643f, -0.11993290f, -0.13151276f, 0.10016946f, 0.02281050f, 0.02042685f, -0.09982280f, -0.02308935f, 
    0.08447649f, -0.04556129f, -0.00708901f, 0.02914581f, 0.07913464f, -0.21298280f, 0.02402497f, -0.09254733f, 
    -0.13052450f, -0.02020761f, 0.07490323f, 0.08003500f, 0.18614480f, -0.15830767f, 0.06926522f, -0.04221538f, 
    -0.19886148f, -0.03415372f, 0.30602726f, -0.02971710f, 0.05473439f, 0.02326862f, 0.03613662f, -0.10036963f, 
    -0.09804554f, 0.08858325f, 0.07056108f, -0.00682986f, -0.13971169f, 0.05451345f, 0.25845525f, 0.15154240f, 
    -0.01915219f, 0.07119785f, -0.04472587f, 0.02563398f, 0.02186854f, -0.03869443f, -0.02151096f, 0.02188572f, 
    -0.23381619f, 0.08865966f, 0.22380893f, -0.06224241f, 0.08859003f, -0.06318109f, -0.07502937f, 0.01155853f, 
    -0.00896535f, -0.07060368f, -0.13008706f, 0.09729541f, 0.02671364f, -0.01178145f, 0.16696572f, 0.12305108f, 
    0.11573579f, -0.00844826f, 0.02225530f, 0.02069808f, 0.08840955f, 0.02254832f, 0.06139881f, 0.01009055f, 
    -0.05528073f, 0.21882187f, 0.00728261f, -0.05371263f, -0.04948286f, 0.09330222f, 0.17589229f, 0.00324771f, 
    0.08394617f, 0.06170346f, -0.03274569f, 0.02707457f, -0.10440604f, -0.14942385f, 0.13443263f, 0.09994500f, 
    0.06124960f, 0.01178711f, 0.05315119f, -0.00422579f, 0.03619633f, 0.04287011f, -0.05692592f, -0.01482762f, 
    -0.04675004f, 0.07848206f, -0.35648778f, 0.38871744f, -0.00198811f, -0.09249745f, -0.05019874f, -0.13662827f, 
    0.09214412f, 0.03072975f, -0.01178258f, -0.06918501f, 0.04536190f, 0.05706181f, 0.02100425f, -0.04536541f, 
    0.01519689f, -0.08576407f, -0.06859960f, -0.11863953f, 0.11832853f, -0.06494502f, -0.00377198f, 0.09673497f, 
    -0.10871499f, 0.06828896f, 0.15511781f, 0.13312846f, -0.15358639f, -0.13630055f, -0.12945473f, -0.03295057f, 
    0.01544477f, -0.04775689f, -0.07158993f, -0.04930902f, 0.13949087f, 0.15710646f, -0.06344346f, -0.05321791f, 
    0.00387938f, 0.01385691f, 0.06065775f, 0.04539826f, 0.06397536f, 0.05982681f, 0.03678705f, -0.02800999f, 
    0.01902250f, -0.08101425f, -0.05814501f, -0.05911030f, -0.08809185f, -0.02344449f, 0.09790052f, 0.03209085f, 
    -0.05071672f, -0.11413441f, -0.01390040f, 0.00292074f, 0.18518093f, 0.13490756f, 0.19229887f, -0.00042023f, 
    0.05784224f, -0.01847392f, -0.02188815f, 0.00571910f, 0.03161491f, 0.01991047f, 0.08481981f, -0.00380092f, 
    -0.22219068f, -0.07353883f, 0.13292521f, 0.35678294f, 0.12092212f, -0.09742671f, -0.07947484f, 0.01946291f, 
    -0.07155792f, -0.04937618f, -0.01801064f, -0.04837628f, 0.32188651f, 0.32053545f, 0.03024443f, 0.20142961f, 
    0.08864985f, 0.05168133f, -0.03543433f, 0.02161964f, -0.02402752f, 0.03530124f, 0.02813856f, -0.15355025f, 
    -0.03307240f, 0.49929285f, -0.32848701f, 0.04709816f, 0.03930575f, 0.06656320f, 0.02697175f, 0.01579458f, 
    -0.07249682f, 0.07861896f, -0.06587955f, 0.02642927f, 0.02795208f, -0.25256732f, -0.03390358f, 0.26058426f, 
    0.08029887f, -0.03256016f, -0.07824458f, -0.03815643f, 0.09781018f, 0.04543856f, 0.04568954f, 0.07852430f, 
    -0.04809584f, 0.47145042f, 0.30670369f, -0.35869423f, 0.03905044f, 0.03471362f, 0.08891154f, 0.17585814f, 
    0.09048507f, 0.19143464f, 0.01576769f, -0.06640153f, 0.01574614f, -0.12765461f, 0.08132722f, 0.08363379f, 
    0.04314614f, 0.09266599f, -0.04843074f, 0.01947123f, -0.22926605f, -0.00493762f, 0.21840051f, 0.04854441f, 
    0.08138826f, 0.01374773f, -0.00785538f, -0.04112660f, 0.03756170f, 0.09490420f, -0.05998877f, 0.02880022f, 
    0.02919956f, -0.02370426f, -0.12937643f, 0.30990380f, 0.17643125f, -0.08937991f, 0.07905537f, 0.10199972f, 
    0.09373398f, 0.05869893f, 0.00964373f, 0.00592686f, -0.04974015f, 0.04475175f, 0.00209797f, 0.01732341f, 
    0.00098490f, 0.14530222f, -0.52485991f, 0.25366816f, 0.06192004f, 0.07620649f, 0.03621748f, -0.03417157f, 
    -0.03310948f, -0.03446171f, -0.08633623f, -0.01790287f, 0.13520256f, -0.13772197f, -0.04535014f, 0.10146767f, 
    0.08279500f, 0.00729682f, 0.01952868f, 0.06257015f, 0.03656847f, -0.00101452f, 0.00350926f, 0.05237355f, 
    0.21137160f, 0.01608449f, -0.23342264f, 0.21012595f, 0.08211944f, 0.07230689f, -0.03507202f, -0.10913434f, 
    0.12343676f, -0.02562611f, -0.06118369f, 0.08699240f, 0.16435638f, 0.37341529f, -0.24593844f, -0.09123350f, 
    0.05395124f, 0.11714230f, -0.06429750f, -0.03447226f, -0.00339534f, -0.02498291f, -0.00206694f, -0.06188598f, 
    0.06629690f, 0.13332741f, -0.21514748f, -0.12908731f, 0.01484654f, 0.01397396f, 0.03952275f, -0.07870518f, 
    0.00530959f, -0.00980052f, -0.10862874f, -0.04370741f, 0.19640873f, -0.40780985f, 0.30893901f, -0.11436073f, 
    0.16330139f, -0.06160463f, -0.05945088f, 0.30832988f, 0.15860769f, 0.07530741f, 0.04799787f, -0.04689399f, 
    -0.10629956f, 0.14603145f, 0.21704073f, 0.06140219f, 0.07341688f, -0.16909091f, 0.04708918f, 0.20649552f, 
    0.07037827f, -0.07482264f, 0.20916215f, -0.05425641f, 0.12766393f, -0.01005630f, 0.04497112f, -0.08311792f, 
    0.03717165f, 0.00913352f, 0.02626305f, -0.04960703f, 0.24321726f, -0.01393694f, -0.01714569f, -0.01638641f, 
    -0.01607037f, 0.03037961f, -0.04654391f, 0.00362442f, 0.02303670f, -0.01963261f, -0.04294282f, -0.05258770f, 
    -0.05529993f, -0.03539525f, 0.01993130f, -0.01462348f, 0.01325126f, 0.01852044f, -0.04057699f, 0.01364512f, 
    -0.00920027f, -0.03584008f, -0.03528631f, -0.04167168f, 0.03745649f, -0.02416437f, -0.02448920f, 0.02663089f, 
    -0.02866080f, 0.01659211f, 0.02444290f, -0.01981909f, 0.01286341f, -0.05421473f, 0.01479281f, -0.01793174f, 
    0.02559274f, -0.04384549f, -0.01412234f, 0.03828536f, 0.00794294f, -0.03085338f, 0.00749756f, -0.01873722f, 
    -0.00882392f, 0.01524000f, -0.03269788f, -0.00399801f, 0.02133699f, -0.04015325f, -0.03883228f, -0.04674389f, 
    0.04309943f, -0.02746672f, 0.01449970f, 0.01440667f, 0.03970859f, -0.02190629f, -0.01013721f, -0.05678662f, 
    -0.01732036f, 0.03641281f, -0.00162008f, 0.01084059f, -0.02371325f, -0.01243069f, -0.01641402f, 0.03565782f, 
    0.04291162f, 0.00024562f, -0.01032731f, -0.01866944f, -0.01150205f, 0.02618537f, -0.00335843f, -0.04443341f, 
    0.00153861f, 0.00473988f, 0.01492763f, -0.03928574f, -0.02055795f, -0.00308130f, -0.05647900f, -0.00648820f, 
    -0.04201920f, -0.05520353f, 0.01742143f, 0.00679724f, 0.02482769f, -0.05305716f, -0.02611999f, 0.00702839f, 
    -0.05121043f, -0.01363132f, 0.00370016f, -0.04846153f, -0.05282703f, -0.03292081f, -0.04026926f, -0.00632622f, 
    0.00391194f, -0.03589721f, -0.01490869f, -0.02731144f, 0.03741588f, -0.02960923f, 0.03580520f, -0.03726752f, 
    0.02446153f, 0.00024871f, 0.03247993f, 0.00730666f, -0.01449931f, 0.00964832f, -0.01930975f, 0.01125097f, 
    -0.00520321f, -0.02250001f, -0.04074461f, -0.04197778f, 0.01917899f, 0.01753380f, -0.05711967f, 0.00878838f, 
    -0.04617981f, -0.00703198f, 0.03577401f, -0.02771374f, -0.00449653f, 0.04188704f, 0.02012897f, 0.03191394f, 
    -0.00849962f, -0.03061073f, 0.02837989f, -0.00076541f, -0.00770422f, -0.00631546f, 0.02746532f, 0.02270539f, 
    0.03924582f, -0.00963370f, 0.00861581f, 0.01940546f, -0.00446085f, 0.03343628f, -0.02779538f, -0.01654388f, 
    0.00046465f, 0.01165139f, -0.02175880f, 0.01451254f, -0.04981642f, -0.05210146f, 0.03741230f, -0.02871384f, 
    -0.00709262f, -0.03174793f, 0.02996819f, 0.01843826f, -0.01266818f, -0.02668612f, 0.03479962f, 0.00659239f, 
    0.01094133f, 0.03503569f, -0.02145219f, -0.03748886f, -0.01098725f, 0.02113388f, -0.01511839f, 0.03318510f, 
    -0.04242371f, -0.02208199f, -0.02710463f, 0.01314021f, 0.00914988f, -0.05043894f, 0.03668275f, 0.00747783f, 
    -0.01265050f, -0.01928866f, -0.02220658f, 0.01035394f, 0.03728880f, -0.01395786f, -0.02832562f, 0.03346678f, 
    -0.03183006f, 0.00708565f, -0.05460804f, 0.02134149f, 0.03864584f, -0.03391977f, -0.04243031f, -0.03864802f, 
    0.02374437f, -0.04492135f, -0.01186229f, 0.01515299f, 0.01940145f, 0.01845396f, -0.01877092f, -0.05366833f, 
    -0.01385208f, -0.02617748f, -0.04797205f, -0.01061759f, -0.00442421f, -0.00131303f, -0.04953117f, 0.01665761f, 
    -0.01141656f, -0.05204223f, 0.01875141f, -0.05477451f, 0.04024597f, -0.01828153f, -0.03865823f, -0.05637923f, 
    0.01065980f, -0.01455243f, 0.02996292f, 0.00039243f, -0.03061657f, -0.05435343f, 0.02910483f, -0.01986713f, 
    -0.02637752f, 0.03908820f, -0.00424980f, -0.03445224f, 0.01060967f, -0.04136058f, 0.02249623f, -0.03775377f, 
    -0.01873823f, -0.04932283f, -0.00169251f, 0.03730964f, 0.01874850f, -0.03138748f, 0.00758389f, -0.03102455f, 
    0.03338879f, 0.02764286f, -0.02676434f, 0.04563615f, 0.00166241f, 0.01023121f, -0.05034548f, -0.04566585f, 
    -0.04896025f, -0.03655428f, -0.02489355f, 0.03806584f, -0.02135244f, 0.03053589f, -0.03842735f, 0.03473603f, 
    -0.03273538f, 0.01682796f, -0.03867411f, -0.04556557f, -0.00290301f, -0.05716454f, -0.04920964f, 0.02377046f, 
    0.03528905f, 0.02093809f, 0.03202315f, 0.03787590f, -0.05360968f, -0.04491972f, -0.04829299f, 0.01724951f, 
    -0.05497857f, -0.05345463f, 0.00320842f, 0.00661827f, -0.03424759f, -0.04712278f, 0.04058856f, 0.00806916f, 
    0.02626002f, 0.02675361f, 0.04163184f, 0.01617278f, 0.00349924f, 0.01240241f, -0.03323952f, 0.01791375f, 
    -0.03622668f, -0.02020898f, 0.03986366f, 0.02842088f, 0.02637485f, -0.00596076f, -0.00395416f, -0.00125470f, 
    -0.05901465f, -0.00765569f, -0.02353306f, 0.01882434f, -0.01303946f, 0.03789930f, -0.00189803f, 0.01873649f, 
    0.04167941f, -0.02948729f, -0.00700534f, 0.03571048f, 0.04210571f, 0.01368295f, -0.04075589f, -0.02777573f, 
    -0.02673870f, 0.02078680f, -0.04616759f, -0.05450215f, -0.02766898f, -0.03232835f, -0.03927349f, -0.03227266f, 
    -0.04608049f, 0.03753230f, 0.01465903f, 0.01625420f, 0.02619195f, -0.05684505f, -0.00061149f, -0.04676683f, 
    0.00784864f, 0.00323849f, -0.03498295f, 0.03333013f, 0.02667225f, -0.05489988f, -0.00322071f, 0.03127173f, 
    0.04153351f, -0.01039214f, -0.01613955f, -0.00651634f, 0.01866144f, -0.00958744f, -0.02631946f, 0.04142047f, 
    0.02238000f, 0.03176671f, 0.02605551f, 0.03568547f, -0.03443896f, -0.00387038f, 0.00949773f, 0.03570982f, 
    -0.00207684f, -0.04440749f, 0.01655808f, -0.02728311f, 0.03766299f, -0.02557858f, 0.00601369f, -0.02155515f, 
    -0.03615760f, 0.01098928f, -0.00760985f, 0.04317281f, -0.01737848f, -0.05353386f, -0.01519351f, 0.00403693f, 
    -0.02206098f, 0.01823989f, -0.04047655f, 0.01407703f, 0.02735600f, -0.03409408f, -0.00410480f, 0.00008358f, 
    -0.02794607f, 0.03203564f, -0.03943953f, -0.05268191f, -0.05377182f, -0.02240986f, -0.00572619f, 0.01348062f, 
    -0.00742418f, 0.07786867f, 0.09136679f, 0.01475389f, -0.06521450f, 0.04582152f, 0.11973283f, -0.07832401f, 
    0.02535577f, -0.04961127f, -0.17434350f, -0.00139061f, -0.04842258f, -0.13238573f, -0.14120410f, -0.11959052f, 
    0.00143587f, -0.15397139f, -0.09794463f, -0.03224411f, -0.08747217f, -0.01016390f, 0.08482974f, 0.03641988f, 
    -0.11184805f, 0.06638251f, 0.08310844f, 0.17608868f, -0.00963602f, 0.00820244f, -0.06884376f, 0.03393855f, 
    0.01318489f, 0.18475987f, 0.07411662f, 0.09595308f, 0.13266174f, -0.32681558f, -0.40803024f, -0.15857781f, 
    -0.09874158f, -0.17807795f, -0.07726771f, -0.04064065f, -0.05962929f, 0.09911001f, 0.05279333f, -0.02249217f, 
    -0.01218952f, -0.12374674f, 0.30392671f, -0.06738178f, -0.01794049f, 0.00175961f, -0.00983781f, 0.02600507f, 
    0.05783636f, 0.16251883f, -0.05764065f, -0.10300909f, 0.26851314f, 0.11223813f, 0.37533122f, 0.07118505f, 
    0.04112078f, 0.04431652f, 0.03405572f, 0.02676404f, 0.03624652f, 0.01438955f, 0.06106064f, 0.00688696f, 
    0.24703175f, 0.04795015f, -0.05901304f, -0.13578402f, -0.21119760f, -0.07719790f, -0.05601002f, 0.16110395f, 
    -0.05249028f, 0.04098538f, -0.01602936f, 0.03564846f, 0.31614745f, 0.08223227f, 0.12044150f, 0.02802909f, 
    -0.05198982f, 0.02643220f, 0.01191421f, 0.02351054f, 0.01856170f, -0.04261982f, -0.02427347f, -0.08705644f, 
    -0.13718539f, 0.01473262f, -0.08620103f, -0.05612817f, 0.15700571f, 0.18386464f, 0.01501428f, 0.06895605f, 
    -0.03258241f, 0.01224145f, -0.20624548f, -0.07969749f, -0.10639501f, 0.09723923f, 0.14419864f, 0.01011865f, 
    -0.08149304f, -0.08365775f, 0.05217506f, 0.15787750f, -0.01017704f, 0.01504190f, -0.13679643f, -0.07139505f, 
    -0.23112467f, -0.28605530f, -0.09431007f, -0.34001392f, -0.08961348f, 0.01545224f, -0.05668542f, -0.13110588f, 
    0.03006927f, 0.10443082f, 0.12683488f, 0.01007376f, -0.04327794f, 0.06931660f, 0.04777678f, -0.08747888f, 
    -0.07534967f, 0.01715326f, -0.07905374f, 0.03867437f, -0.00336042f, -0.07745712f, 0.06975888f, 0.16256906f, 
    0.14022344f, 0.11187487f, -0.13553971f, -0.10753051f, -0.00777612f, 0.11326051f, 0.04155748f, 0.06058059f, 
    0.08158360f, 0.00926013f, 0.04570387f, 0.02583628f, 0.10669039f, 0.05978868f, 0.05064195f, 0.18025035f, 
    -0.01514502f, 0.20711167f, -0.08732010f, 0.03034026f, 0.00760827f, 0.02016570f, -0.02209515f, 0.02549678f, 
    -0.04405854f, -0.11997093f, -0.28140944f, -0.41191706f, 0.07613074f, -0.13216220f, -0.00320833f, -0.04454201f, 
    -0.12250298f, 0.00634907f, 0.01482444f, 0.04253893f, 0.31801382f, 0.10842626f, 0.19593613f, 0.05908519f, 
    0.01828942f, 0.02113341f, 0.03383822f, 0.19013509f, 0.06422857f, 0.05221999f, 0.12115557f, 0.09452070f, 
    -0.14146061f, -0.09630220f, -0.10480946f, 0.05529499f, 0.04111104f, -0.08935614f, 0.06596663f, -0.00521403f, 
    -0.02813394f, 0.00856703f, 0.16182633f, 0.04259675f, -0.02438247f, 0.17759718f, 0.15920670f, 0.29084909f, 
    -0.06757291f, -0.00430664f, -0.03405373f, -0.00500178f, 0.05721172f, -0.05690179f, 0.00137071f, -0.06012459f, 
    -0.17684393f, 0.17853680f, -0.00216047f, -0.19915254f, -0.01361133f, 0.04239486f, 0.00058494f, -0.10824990f, 
    0.13096637f, 0.02784852f, 0.02354296f, 0.00519910f, -0.03737789f, -0.10806195f, -0.28337297f, 0.20100874f, 
    0.05769033f, -0.01234800f, 0.08842531f, 0.03366112f, 0.01930799f, 0.05811861f, 0.00585809f, 0.03534149f, 
    -0.23822817f, -0.12089471f, 0.20705098f, -0.00734319f, -0.01110582f, 0.10781780f, 0.02522094f, 0.05860011f, 
    -0.05780447f, 0.00651612f, 0.03621981f, 0.05264018f, 0.17713025f, -0.29813585f, -0.01483282f, 0.04711838f, 
    -0.09787393f, -0.11596267f, 0.14663303f, -0.00579683f, 0.14281756f, 0.02270701f, -0.05510302f, 0.10543776f, 
    -0.08884940f, 0.12716085f, -0.10219973f, 0.00733227f, -0.09092320f, 0.03641685f, -0.02616570f, -0.02124445f, 
    0.00532869f, -0.01569710f, -0.21131775f, 0.21696077f, 0.14717628f, 0.10287903f, 0.10483824f, 0.21492292f, 
    0.06635987f, -0.02793603f, -0.06370401f, -0.00863408f, 0.01951825f, -0.13246869f, -0.13087520f, -0.13122877f, 
    -0.12226801f, -0.04468598f, 0.24416381f, 0.21882926f, -0.00565453f, -0.07243301f, -0.09369455f, -0.11191423f, 
    -0.05538876f, -0.00597751f, -0.03594272f, -0.13093480f, -0.16729231f, 0.03488862f, -0.04165802f, -0.13899004f, 
    -0.00707308f, 0.10606359f, 0.06477551f, 0.01554610f, -0.07211988f, -0.16622168f, -0.19386157f, -0.13482521f, 
    -0.24927162f, 0.10661608f, -0.06775366f, 0.07344890f, 0.07953153f, -0.01066728f, 0.10864624f, -0.00159822f, 
    0.09260573f, 0.03989362f, -0.02760806f, -0.05268215f, 0.61220306f, 0.39105859f, 0.37031868f, 0.02842311f, 
    -0.05152155f, -0.02495965f, -0.05135005f, -0.01558344f, -0.02924391f, -0.00412582f, -0.02513932f, 0.04263523f, 
    -0.13720371f, 0.00342768f, 0.08291246f, -0.23134075f, 0.07474142f, -0.17495388f, -0.00839203f, 0.23093234f, 
    -0.02441365f, -0.07147188f, -0.11365604f, -0.08636935f, -0.12248430f, -0.08127504f, -0.22528544f, 0.18602836f, 
    -0.09148663f, 0.10626102f, 0.02739397f, 0.11973949f, -0.09417916f, 0.08664625f, 0.15649995f, 0.11024605f, 
    0.07948493f, 0.29582462f, 0.40724275f, 0.13184883f, 0.06085651f, -0.07575022f, 0.00839906f, 0.18110608f, 
    -0.06689554f, 0.02729060f, 0.10602198f, 0.09688402f, 0.14566590f, -0.05461254f, 0.15348779f, 0.06035269f, 
    -0.00520963f, -0.01713796f, -0.00040882f, 0.13135622f, 0.13150452f, 0.07670420f, 0.05560984f, 0.11435506f, 
    -0.14387533f, 0.00872523f, 0.11897124f, -0.07327011f, -0.13025454f, 0.12030238f, -0.02898872f, -0.10792361f, 
    0.01090716f, 0.19877481f, 0.21520166f, 0.10256576f, -0.32806093f, -0.22457211f, 0.00081592f, -0.09491304f, 
    0.01467004f, -0.11607885f, 0.05253787f, -0.10769138f, 0.05855579f, 0.01612164f, 0.08119154f, 0.15054266f, 
    0.07463005f, -0.02789208f, 0.03295344f, 0.10002299f, -0.01765080f, -0.04298168f, -0.00851238f, -0.08341110f, 
    0.13718462f, 0.02646250f, 0.00943195f, -0.15286224f, -0.25325564f, -0.06607755f, -0.13139999f, -0.22516477f, 
    -0.06509099f, -0.03884026f, -0.10129520f, 0.02970820f, -0.02491361f, -0.00598064f, 0.00274058f, -0.05050560f, 
    -0.03924197f, -0.03041807f, 0.20595731f, -0.08738493f, -0.00697459f, 0.18031597f, 0.02002778f, 0.05359039f, 
    -0.06696443f, -0.00808428f, -0.16675642f, -0.02971207f, 0.33784750f, 0.26225799f, -0.03197667f, 0.10892901f, 
    0.05800595f, -0.13586095f, 0.10286337f, -0.00795543f, 0.08427759f, 0.09523801f, 0.03850407f, 0.12270043f, 
    0.04199548f, -0.13971251f, -0.04574940f, -0.13991885f, 0.01013224f, -0.02972323f, 0.04890830f, 0.07528239f, 
    -0.01716493f, 0.04740063f, 0.04876099f, 0.06572026f, 0.17406991f, 0.10233421f, -0.01037491f, -0.08976260f, 
    -0.00288935f, -0.03215149f, -0.02354864f, 0.02706338f, 0.04781098f, -0.07087703f, 0.16439715f, 0.00528318f, 
    -0.09564214f, -0.00957871f, -0.10411914f, -0.04942982f, 0.01577346f, 0.18260343f, 0.16936825f, 0.33236256f, 
    0.01568840f, -0.00084079f, -0.00001896f, -0.04175740f, -0.09265285f, -0.09957702f, 0.17928079f, -0.00431664f, 
    -0.00684565f, 0.22040431f, 0.04583396f, -0.11117769f, -0.08348938f, -0.06180171f, 0.01170584f, 0.06455196f, 
    -0.39928663f, -0.09695250f, 0.18466389f, -0.24517976f, -0.00771153f, -0.09420831f, 0.00246725f, 0.04261889f, 
    0.01678513f, 0.02383590f, -0.04649743f, -0.22854748f, -0.08187948f, -0.10986586f, -0.12193924f, -0.19854923f, 
    -0.11232623f, -0.03094509f, 0.05564541f, 0.09082170f, -0.13590488f, -0.10950673f, -0.24586014f, -0.44641507f, 
    0.03459525f, 0.11157636f, -0.01831300f, -0.07494312f, 0.03709149f, 0.00513759f, 0.12279683f, 0.02361969f, 
    0.02177634f, 0.01178771f, 0.05949311f, 0.02363225f, -0.10621317f, -0.08759288f, 0.09836353f, -0.02598568f, 
    -0.06247171f, 0.05867409f, -0.01382762f, -0.09927472f, 0.16837692f, 0.14637128f, 0.06677143f, 0.04952473f, 
    -0.21300793f, -0.10870435f, 0.01736000f, -0.09248565f, -0.03267943f, -0.12124772f, -0.08703510f, 0.14228818f, 
    0.09418482f, 0.16439036f, 0.03343184f, 0.02327687f, 0.11158196f, -0.05450331f, 0.01321981f, 0.01506148f, 
    -0.07336224f, 0.03142407f, -0.00907722f, -0.03657183f, -0.04836097f, -0.09317800f, -0.03642814f, -0.08599137f, 
    -0.09203760f, 0.05172237f, 0.16125898f, -0.06373286f, -0.03364777f, -0.00365707f, 0.12516634f, 0.02209024f, 
    0.09285456f, 0.12419826f, 0.04633973f, 0.09165460f, -0.06347425f, -0.05162163f, 0.11929530f, 0.31074107f, 
    -0.13772625f, -0.01038774f, 0.01258270f, -0.03473661f, 0.06474774f, 0.00223429f, 0.10293494f, 0.20314546f, 
    -0.22442357f, -0.12320726f, 0.02436253f, -0.04080406f, 0.03976662f, -0.15410747f, 0.11741196f, 0.03160897f, 
    0.26446778f, 0.08744648f, -0.03473207f, 0.16310576f, -0.08735871f, -0.02016480f, 0.03826266f, 0.15456133f, 
    0.12174980f, 0.09909292f, 0.18206874f, 0.10756342f, 0.14889358f, 0.06687961f, 0.04771202f, -0.14559850f, 
    0.30506867f, -0.00204240f, -0.03817904f, -0.02143050f, -0.00991918f, -0.02016425f, 0.33913743f, 0.17679878f, 
    0.19942921f, -0.05259933f, -0.08008287f, -0.09428550f, 0.00031492f, -0.03099926f, -0.13860781f, 0.02407033f, 
    0.04909905f, -0.15513974f, -0.02117172f, -0.03324810f, -0.02091052f, 0.23464060f, -0.11027075f, -0.00520863f, 
    -0.20399834f, 0.12392624f, 0.25200811f, -0.08621211f, -0.07105397f, 0.00102595f, 0.07379534f, 0.01514907f, 
    0.11769985f, 0.27020293f, 0.12361114f, 0.17013097f, -0.29792154f, 0.01612028f, -0.07962754f, 0.11427806f, 
    -0.11684930f, -0.12174802f, -0.11115415f, -0.10326064f, 0.11412326f, 0.17488812f, 0.28700078f, 0.28915051f, 
    -0.15722869f, -0.03050528f, 0.26829010f, -0.04190367f, -0.05132645f, -0.15908188f, -0.08078785f, -0.14645894f, 
    0.06771719f, 0.06992055f, -0.06077406f, 0.30732206f, -0.24151994f, -0.12859033f, -0.06361330f, 0.03607909f, 
    0.24887010f, 0.04100791f, 0.10688697f, -0.02368807f, 0.08424900f, -0.07156144f, -0.06227955f, 0.00140229f, 
    -0.11387401f, -0.02098016f, 0.10347622f, 0.15476766f, 0.05177067f, 0.06171175f, 0.09398451f, 0.12717001f, 
    0.14099535f, -0.03213210f, 0.26102641f, -0.06683166f, 0.09198777f, -0.14932984f, -0.11384331f, 0.08380289f, 
    0.01168160f, 0.07438440f, 0.06204275f, -0.05164512f, -0.24052517f, -0.01756485f, -0.09574213f, 0.01961071f, 
    -0.00528695f, -0.00201880f, 0.26620811f, 0.21101366f, 0.13971868f, 0.09900956f, -0.02607640f, 0.16088763f, 
    0.04004126f, -0.09589253f, 0.06030608f, 0.10849307f, -0.12189266f, 0.11022089f, 0.11869293f, 0.10541378f, 
    -0.14485350f, -0.02220465f, 0.01437340f, 0.11199573f, 0.14363155f, -0.03298142f, 0.11006639f, 0.11370503f, 
    0.43019691f, 0.05314276f, -0.00252630f, -0.10882817f, 0.08455461f, 0.15364419f, 0.13107869f, 0.21935393f, 
    -0.03482154f, -0.05322149f, 0.06151682f, -0.05760741f, 0.11589973f, -0.06462703f, -0.02502699f, -0.07657482f, 
    0.00351911f, -0.08132423f, -0.05966975f, -0.05324226f, -0.03179878f, -0.12286315f, -0.01097904f, -0.41235536f, 
    -0.04506304f, 0.03383507f, 0.01856821f, 0.02243147f, -0.02367600f, -0.02964726f, -0.02638562f, 0.03032685f, 
    -0.02229870f, -0.03223129f, -0.03326823f, -0.02403940f, -0.02181294f, 0.02048329f, -0.02378804f, 0.03001307f, 
    -0.01093646f, -0.03503003f, -0.04777575f, -0.04549712f, -0.01185235f, -0.05718302f, -0.03608913f, 0.01036262f, 
    -0.06464543f, -0.03958311f, -0.03476184f, 0.03172024f, -0.06037277f, -0.02683403f, 0.03058331f, -0.03506039f, 
    -0.04759711f, 0.04455171f, -0.01450740f, -0.04687344f, 0.01062768f, 0.00307495f, -0.03228337f, -0.02224915f, 
    0.01019521f, -0.03307169f, -0.04202059f, -0.05991330f, -0.03609009f, -0.04307921f, -0.01200724f, -0.02533333f, 
    0.01937578f, 0.01378616f, -0.01911332f, 0.00468202f, -0.03934213f, -0.03318068f, 0.03088762f, -0.02517665f, 
    -0.05505035f, -0.01448375f, 0.02212707f, -0.05364808f, -0.04342985f, 0.00569864f, 0.01675056f, 0.02525279f, 
    0.03175721f, -0.03194781f, -0.01931522f, 0.00719067f, -0.05143023f, -0.03923899f, -0.04594920f, -0.03342558f, 
    0.03298033f, -0.04022911f, 0.03333258f, -0.01773474f, -0.03635298f, -0.03979984f, 0.02699713f, -0.01089283f, 
    -0.04002843f, -0.03960381f, -0.04308503f, 0.00451597f, -0.05640845f, -0.00627635f, -0.04142057f, -0.05620980f, 
    -0.05498769f, -0.01453756f, -0.01436405f, -0.05253521f, -0.02802205f, 0.01865366f, -0.04993595f, 0.01138437f, 
    0.00517044f, 0.00376811f, -0.04271669f, 0.03504394f, -0.03103928f, -0.06150278f, -0.00978093f, -0.02569365f, 
    -0.01517290f, -0.01527907f, -0.02828734f, 0.02113487f, 0.03486596f, -0.01945917f, -0.04809779f, 0.03425168f, 
    -0.04120616f, -0.02361682f, -0.02988403f, 0.01023678f, -0.03589060f, -0.01060104f, -0.03116098f, 0.02223357f, 
    -0.04258633f, -0.01385024f, -0.04443644f, 0.02890653f, -0.06369560f, 0.00853871f, -0.00253464f, -0.04023631f, 
    -0.05179250f, -0.05975249f, 0.03337733f, -0.00686370f, 0.02940309f, -0.05338190f, 0.03243838f, -0.03279588f, 
    0.00497183f, 0.02898940f, -0.04434001f, -0.06222508f, -0.02454177f, -0.00998088f, 0.00189076f, -0.03747847f, 
    -0.01597860f, -0.02538259f, -0.02078124f, -0.05114795f, -0.02826913f, -0.05654568f, -0.06449838f, 0.02448956f, 
    0.01426611f, 0.00661849f, -0.01974687f, 0.03117080f, -0.04599641f, 0.02099446f, 0.01922419f, -0.06328472f, 
    -0.03792316f, -0.05952588f, 0.00926674f, -0.00292122f, -0.06431297f, -0.05601552f, -0.02804953f, -0.05561998f, 
    0.02567298f, 0.03310568f, -0.00124796f, -0.04803498f, -0.03750943f, -0.05879061f, -0.05342600f, -0.00876131f, 
    0.02945519f, 0.00150738f, 0.01101461f, 0.01494099f, -0.03744685f, -0.03117266f, -0.05078944f, -0.06317534f, 
    -0.01116564f, -0.01261997f, -0.05227831f, 0.02775420f, -0.02418878f, -0.04691000f, -0.01289451f, -0.02239646f, 
    -0.04293311f, -0.01036309f, -0.03343157f, -0.06616885f, -0.01704896f, -0.05973754f, -0.03195390f, -0.05327487f, 
    -0.04782494f, -0.02504140f, -0.01037253f, -0.06085252f, -0.00882189f, -0.03054274f, -0.00511629f, -0.00261185f, 
    -0.06093264f, -0.03605820f, -0.02483509f, 0.00959037f, -0.02695886f, -0.00764480f, -0.00499570f, 0.01095449f, 
    -0.03372363f, -0.06428623f, 0.00867543f, 0.00655833f, -0.05609222f, -0.05326283f, -0.05635867f, -0.00723285f, 
    0.01714033f, -0.02989975f, -0.00980410f, -0.00235382f, -0.03519097f, -0.01759057f, -0.06215674f, -0.00298099f, 
    0.02355722f, -0.05264542f, 0.01012617f, 0.02073279f, -0.02866739f, -0.01868878f, 0.01646626f, -0.00341080f, 
    -0.04818385f, -0.00800396f, -0.06366730f, -0.03609658f, -0.00046341f, 0.02315106f, 0.03464997f, 0.01132140f, 
    0.05084939f, -0.00060507f, 0.01964351f, 0.00362504f, -0.03339873f, -0.01692573f, 0.01532378f, -0.04343056f, 
    -0.03568408f, 0.02857018f, -0.00968986f, 0.01299094f, -0.05113262f, -0.06615765f, 0.00120309f, -0.04741237f, 
    0.02282397f, -0.02745791f, 0.01355794f, 0.00288371f, -0.04878235f, -0.05546943f, -0.06046715f, -0.03013229f, 
    0.00260224f, -0.02977144f, -0.01629405f, -0.03669049f, 0.02635554f, 0.00684012f, 0.01066369f, -0.04478251f, 
    -0.00207085f, -0.04339201f, -0.00506459f, -0.02872597f, 0.02060919f, 0.00562476f, 0.04233354f, -0.04463978f, 
    0.01683468f, -0.03211855f, -0.05403533f, -0.03760367f, 0.02462650f, -0.03696451f, -0.05565822f, -0.01700730f, 
    -0.04018264f, -0.02215514f, -0.02252721f, -0.00244741f, 0.01360761f, -0.03455394f, 0.00907794f, -0.01817762f, 
    -0.05133172f, 0.00942483f, 0.01522406f, -0.01395911f, -0.01003524f, -0.00814388f, -0.05585682f, -0.06120570f, 
    -0.00436825f, -0.01254126f, -0.05024182f, -0.01256765f, -0.05166390f, 0.01307513f, 0.00836454f, -0.03810985f, 
    -0.00687010f, -0.03162221f, -0.05917044f, 0.02415063f, -0.06430964f, 0.01955999f, -0.04125648f, 0.00979839f, 
    0.01727932f, 0.02532975f, 0.00864856f, -0.04231920f, -0.04415678f, -0.00544645f, 0.02188567f, -0.01831852f, 
    -0.03670157f, 0.02495952f, 0.02096509f, -0.01271643f, 0.00636261f, -0.01051369f, -0.04648107f, 0.00838638f, 
    -0.03850457f, 0.01295535f, 0.00364053f, -0.04212409f, -0.00200074f, -0.01064789f, -0.00016874f, -0.05220895f, 
    0.00655107f, -0.00881463f, 0.03240708f, -0.02282736f, -0.01335666f, 0.02412971f, -0.05934080f, -0.06288734f, 
    -0.02871245f, 0.01886957f, -0.01355575f, -0.05125581f, -0.02895892f, 0.01641085f, 0.01045045f, -0.03210292f, 
    -0.02810691f, 0.01299596f, -0.05913201f, -0.01669356f, 0.01716960f, -0.03821496f, 0.02963563f, -0.06007538f, 
    -0.05296801f, -0.02416955f, -0.05237582f, 0.00041638f, -0.03884844f, -0.02603636f, 0.03372648f, -0.01509741f, 
    0.05584711f, 0.03324826f, 0.05022328f, 0.10517612f, 0.21202190f, -0.00128323f, -0.13850485f, -0.13419592f, 
    0.02353804f, -0.05955823f, 0.09451375f, -0.19081411f, -0.09204923f, -0.01340801f, 0.10846921f, 0.10434475f, 
    0.04119419f, 0.13622299f, 0.00496812f, -0.02973942f, 0.11936803f, -0.07515455f, 0.11502348f, 0.25054449f, 
    -0.45586297f, -0.01960153f, -0.06107812f, 0.20400806f, -0.10284822f, -0.01128160f, 0.08558267f, 0.01468019f, 
    -0.10843500f, -0.08116723f, -0.04976062f, 0.02072981f, 0.30987352f, 0.16892935f, 0.16784996f, 0.11180528f, 
    0.15823920f, 0.04569510f, -0.02416476f, 0.00280303f, 0.11210819f, 0.08626858f, 0.05979224f, 0.02050208f, 
    0.17056827f, 0.10244706f, -0.03115912f, -0.04815345f, 0.13211854f, -0.10563219f, 0.01999657f, 0.14074047f, 
    0.01726577f, -0.11881480f, 0.18119885f, -0.02602522f, 0.05388060f, -0.09807110f, -0.29982617f, 0.03077996f, 
    0.03366706f, -0.01245312f, 0.05678954f, -0.03096654f, 0.07817335f, 0.10856651f, -0.13179447f, 0.10409214f, 
    0.17412646f, 0.36860856f, -0.07883808f, 0.11696017f, 0.02404516f, 0.06810493f, 0.10560801f, 0.07661872f, 
    0.05145837f, 0.11136862f, -0.02377083f, -0.08568119f, -0.06837767f, -0.00497379f, -0.26279929f, -0.05997907f, 
    -0.07446491f, -0.00532634f, -0.02327504f, -0.03136512f, 0.03624500f, 0.02026371f, -0.05334010f, 0.03814397f, 
    0.15552597f, -0.01878091f, -0.09958848f, 0.02036486f, 0.12296601f, 0.04020558f, -0.11776204f, -0.09368863f, 
    0.00473144f, 0.02812141f, 0.14331301f, -0.03615846f, 0.22923395f, 0.44111612f, 0.22643043f, 0.01218297f, 
    0.20708613f, 0.04995095f, 0.00027364f, 0.15391755f, 0.02332549f, 0.03432554f, 0.02707603f, -0.06357417f, 
    0.00028843f, 0.12807949f, 0.09307122f, 0.04468298f, -0.07836120f, 0.02740371f, 0.04742647f, 0.01667905f, 
    0.16216233f, -0.14442179f, -0.05360819f, 0.21913962f, 0.01651612f, 0.00202474f, -0.02495628f, 0.02453047f, 
    0.03105700f, 0.03446681f, 0.05721948f, -0.07336577f, 0.16861716f, -0.05968529f, 0.10322710f, 0.18331271f, 
    -0.00133272f, 0.04507906f, 0.08658810f, -0.02789818f, -0.02154013f, 0.06448395f, 0.02157607f, 0.11702514f, 
    -0.03984634f, -0.08134733f, 0.00019316f, 0.09238835f, -0.07946237f, -0.20094499f, -0.00597809f, 0.00038647f, 
    0.10464013f, -0.01524157f, -0.05394879f, 0.01641782f, 0.02074359f, 0.00154625f, 0.06823587f, -0.08742572f, 
    0.20472808f, 0.07503203f, 0.09231405f, -0.02436357f, 0.07057837f, -0.02112019f, 0.04004887f, -0.19532546f, 
    0.00686719f, -0.02794375f, 0.13602436f, 0.14207938f, 0.00652312f, -0.20359801f, -0.19167006f, -0.07313658f, 
    0.08733974f, 0.09303050f, -0.02052171f, 0.03991998f, 0.13764015f, -0.11546803f, 0.12090258f, 0.03477152f, 
    0.11341163f, 0.17709661f, 0.02096916f, 0.03080595f, 0.02559575f, 0.12564516f, 0.21936552f, 0.13517490f, 
    -0.01508045f, -0.10607228f, 0.06365601f, 0.07985555f, -0.16206557f, -0.19218506f, -0.06878439f, -0.02972535f, 
    0.05243746f, 0.03916892f, 0.05784541f, 0.05220880f, 0.03860475f, 0.06273714f, -0.08968364f, 0.12831058f, 
    -0.10377617f, -0.00147856f, -0.25083867f, 0.01181478f, -0.02877821f, -0.12804368f, 0.08768994f, -0.03336583f, 
    -0.03047211f, -0.09497651f, 0.04797657f, 0.24120426f, -0.02085809f, 0.14634277f, 0.21315521f, 0.12633237f, 
    -0.13772681f, -0.11644699f, -0.07511479f, -0.13015516f, -0.16700903f, -0.02284102f, -0.21521235f, -0.05596477f, 
    0.23088104f, 0.07241078f, -0.37263891f, 0.00241807f, 0.02292226f, -0.03359662f, -0.24881534f, -0.03146429f, 
    -0.00123600f, -0.13276094f, -0.04825558f, 0.07505468f, -0.20579079f, 0.24701458f, -0.11627242f, 0.14630170f, 
    0.01721492f, 0.00085651f, 0.11921500f, -0.08831996f, 0.09035989f, 0.20677711f, -0.22054203f, 0.00297626f, 
    0.08336877f, 0.11713471f, 0.07687690f, -0.21829739f, 0.04425015f, 0.11159887f, -0.08055777f, -0.11540798f, 
    -0.10520820f, 0.04624113f, 0.16312164f, -0.13527645f, 0.13860740f, 0.12212975f, 0.02081198f, 0.09256031f, 
    -0.01692942f, -0.01698256f, 0.00381215f, -0.07769381f, 0.02715223f, -0.01651116f, -0.05645144f, -0.13082193f, 
    0.16376552f, 0.07205141f, 0.07334952f, 0.07847012f, 0.11653327f, -0.03180426f, 0.07538287f, -0.01606668f, 
    0.09530148f, -0.03956093f, 0.18844546f, 0.00366447f, 0.01136563f, 0.14464280f, 0.15270944f, -0.03022895f, 
    -0.13826452f, 0.13290572f, 0.06572986f, 0.06341236f, 0.04390794f, 0.01423934f, -0.02903313f, 0.01250336f, 
    -0.14226072f, -0.09445514f, 0.12412046f, 0.00705948f, -0.01073653f, -0.02557378f, -0.09604768f, 0.11588287f, 
    -0.05236838f, -0.03920292f, 0.03408694f, -0.09335787f, -0.26986000f, -0.27002650f, -0.18875113f, 0.10289985f, 
    -0.03695939f, 0.02628091f, 0.25550357f, 0.22794519f, 0.07837286f, 0.03320359f, 0.01066126f, 0.00186033f, 
    -0.00356707f, 0.11269039f, 0.01435303f, 0.01007765f, 0.05968874f, 0.03791662f, -0.07993129f, 0.08280102f, 
    -0.09156381f, 0.06831443f, 0.07864775f, 0.04066977f, 0.20162378f, -0.13638586f, 0.10612307f, -0.18615302f, 
    -0.11025395f, 0.16623171f, -0.14487506f, -0.08226945f, -0.04662526f, 0.04018547f, -0.24398673f, 0.07451840f, 
    0.02073935f, 0.15038362f, -0.49573863f, -0.02499479f, -0.06080621f, 0.17611049f, -0.07179694f, -0.19698630f, 
    0.01363080f, 0.12741683f, -0.08098032f, 0.00608867f, -0.02625965f, -0.02348210f, 0.05839270f, -0.00867523f, 
    -0.00506270f, 0.04342203f, -0.00893835f, 0.05430703f, 0.00634038f, 0.07624535f, 0.04111182f, -0.05363443f, 
    0.00684350f, 0.09311212f, 0.12794662f, -0.11949229f, 0.00303548f, -0.05819231f, -0.06208855f, 0.04012185f, 
    -0.08351384f, -0.28684902f, -0.15316206f, -0.20411842f, 0.18354046f, 0.18899105f, 0.13963470f, 0.06640180f, 
    0.02069847f, 0.07660212f, -0.08095916f, -0.01083949f, 0.05369850f, 0.00749182f, 0.00936603f, -0.19930963f, 
    -0.05817812f, 0.15629528f, 0.08705702f, 0.14773691f, -0.07519855f, -0.06112563f, -0.05349112f, -0.12106150f, 
    -0.06837884f, 0.12876830f, 0.17314762f, 0.13838872f, 0.31649297f, 0.14629088f, 0.10565032f, 0.30789354f, 
    -0.08269973f, -0.01074493f, -0.16236743f, 0.00355445f, 0.06797994f, 0.12671696f, 0.02080575f, 0.20225422f, 
    0.17542836f, 0.08081739f, -0.05484876f, 0.17631377f, -0.07583064f, -0.13297838f, 0.01526607f, 0.11922242f, 
    0.22645472f, 0.11586738f, 0.15881851f, -0.08455139f, -0.35440055f, -0.14907254f, -0.06790504f, -0.05795610f, 
    0.03674922f, 0.19274214f, -0.22669794f, -0.06054654f, -0.20985174f, -0.16340330f, 0.08341697f, -0.05994594f, 
    0.13770822f, 0.15575707f, -0.00574657f, 0.23591243f, -0.01202449f, 0.13515525f, 0.06754325f, 0.05813914f, 
    0.18589023f, 0.01258741f, -0.07182175f, -0.02889386f, -0.17625453f, -0.03721796f, -0.41649270f, -0.13355462f, 
    -0.01857058f, 0.07999817f, 0.04842075f, -0.11706927f, -0.24937415f, -0.15139195f, -0.07889179f, -0.20242912f, 
    -0.03814377f, -0.13345677f, -0.01254276f, 0.07108586f, 0.01020925f, -0.06721783f, 0.06406385f, 0.05874115f, 
    -0.06997136f, -0.09323526f, -0.28423789f, -0.01410902f, 0.11169428f, 0.18799596f, -0.03063947f, 0.03710713f, 
    -0.15843137f, -0.19865920f, -0.01994535f, 0.11897634f, 0.13343109f, 0.15890190f, 0.01927452f, -0.13907230f, 
    0.34484902f, 0.08720064f, 0.18221331f, 0.10476082f, -0.08042629f, -0.04591713f, -0.08920600f, -0.19183642f, 
    0.13300765f, 0.00483447f, 0.17547704f, 0.21127473f, -0.10803998f, 0.12849872f, -0.02816455f, 0.16305402f, 
    0.01510251f, -0.05933426f, 0.01657181f, -0.12382425f, 0.13692458f, 0.24539827f, 0.26426983f, 0.43420625f, 
    0.01716511f, -0.09238185f, -0.06561524f, 0.09276502f, 0.06562786f, 0.08356959f, 0.07475967f, 0.12197943f, 
    0.12290761f, 0.03798016f, -0.01474991f, 0.09148712f, -0.02809140f, -0.00273362f, 0.05805352f, 0.00823993f, 
    0.03739552f, 0.02046884f, -0.06512132f, 0.01661023f, -0.18945046f, -0.19145474f, -0.17023143f, 0.04814703f, 
    0.16135271f, 0.21491908f, -0.00734739f, 0.11484119f, -0.11998954f, -0.05965638f, 0.00730231f, -0.17064044f, 
    -0.04315360f, -0.12415396f, -0.03157125f, 0.08265661f, -0.13583881f, 0.04180951f, 0.04291470f, 0.13061441f, 
    -0.00753572f, -0.04948438f, -0.03834560f, 0.15082404f, -0.01440591f, 0.02491825f, 0.05978225f, 0.07754644f, 
    0.21305999f, 0.06898827f, -0.11699914f, 0.05082601f, 0.00545338f, 0.09073119f, 0.10244252f, -0.07243787f, 
    -0.06854588f, -0.01258977f, -0.00311011f, 0.10741775f, -0.05890127f, -0.08418883f, 0.19967034f, -0.22813652f, 
    0.09423918f, 0.02521412f, -0.08392451f, -0.01010455f, -0.00503276f, -0.06599769f, -0.12419216f, -0.11338626f, 
    0.01441388f, -0.11550800f, 0.19872262f, 0.03872905f, 0.09003776f, 0.07138717f, -0.06660254f, 0.14556175f, 
    -0.23358510f, -0.16935667f, 0.07541415f, 0.03610187f, -0.01993090f, 0.16390732f, 0.02702647f, 0.11543689f, 
    -0.01361973f, 0.06782764f, 0.04672437f, -0.00437478f, -0.04123365f, 0.01159974f, 0.08280675f, 0.22725970f, 
    -0.38918513f, 0.05901732f, 0.12063198f, 0.31700411f, -0.02135333f, 0.03443198f, -0.03018634f, 0.02717685f, 
    -0.08323865f, 0.11317000f, -0.07064638f, 0.25310358f, 0.27198526f, 0.16913070f, -0.02097563f, 0.12305699f, 
    -0.10307205f, 0.12645257f, 0.16923186f, -0.24144478f, 0.25082198f, -0.04954361f, 0.08621878f, 0.07824799f, 
    0.15754637f, 0.01980214f, -0.00668934f, 0.09742455f, -0.11902552f, -0.09752256f, -0.03015494f, -0.14026433f, 
    -0.10240234f, -0.06245883f, 0.02843806f, -0.14650266f, 0.03827571f, 0.20307197f, 0.18344991f, 0.00126136f, 
    0.07385014f, -0.02038144f, -0.08841002f, -0.44502267f, -0.05358914f, -0.08209316f, -0.11721702f, -0.06717443f, 
    -0.15806037f, 0.14789484f, 0.18868519f, 0.15311483f, -0.09421546f, -0.03094715f, -0.12758620f, -0.01077224f, 
    -0.16274692f, -0.12413504f, 0.11575338f, -0.07566132f, 0.07843395f, 0.23907894f, -0.07382655f, -0.19713038f, 
    -0.20510167f, 0.03645940f, 0.00463734f, 0.00329805f, -0.11823689f, -0.19522536f, -0.11031029f, -0.22722980f, 
    -0.05397666f, 0.08616256f, -0.14609934f, -0.19507323f, 0.00199176f, -0.09467796f, -0.10191531f, -0.17834723f, 
    -0.09531692f, 0.04234092f, -0.11679261f, -0.10465875f, 0.01281061f, 0.15144311f, 0.46641701f, 0.08512286f, 
    0.00882693f, -0.00099586f, 0.11991095f, 0.03098948f, 0.06955761f, -0.20965011f, -0.12931682f, -0.21183541f, 
    -0.06417797f, 0.04266223f, 0.07718594f, -0.12943187f, -0.05029931f, -0.09129725f, 0.00561397f, 0.17033677f, 
    -0.09284937f, 0.01011269f, -0.10743738f, -0.23266594f, -0.03513352f, -0.02224132f, 0.01833052f, -0.04009287f, 
    0.19095396f, 0.06233452f, -0.07293485f, -0.08909021f, -0.07059742f, 0.14893973f, 0.12307818f, -0.06013189f, 
    -0.29945937f, 0.17355525f, -0.05624538f, 0.28271604f, 0.09445336f, 0.05547711f, 0.11311767f, -0.00953035f, 
    -0.10477999f, -0.00578013f, -0.18504202f, 0.02118944f, -0.08822402f, 0.22621587f, 0.01663220f, 0.06722359f, 
    -0.16577610f, 0.08271420f, 0.01755407f, -0.02878402f, 0.05986456f, -0.05416879f, -0.03943213f, 0.46199426f, 
    -0.00072358f, -0.15093048f, 0.03752797f, -0.02554243f, -0.09553191f, 0.00795276f, 0.10160662f, 0.02148790f, 
    -0.02278607f, -0.15918681f, -0.04971293f, 0.08832132f, -0.30740264f, 0.18794656f, 0.02569026f, 0.02762339f, 
    -0.20735268f, 0.01233240f, -0.01782468f, -0.06816851f, 0.01161152f, 0.12037563f, 0.08796564f, 0.07208721f, 
    -0.35744411f, -0.04608455f, 0.13822201f, 0.15952353f, 0.00113315f, 0.07822300f, 0.04686486f, 0.11841439f, 
    -0.00765348f, 0.01672524f, -0.05408362f, -0.06623773f, 0.00405814f, 0.22198330f, -0.04463264f, -0.19871622f, 
    -0.10045991f, 0.05334434f, 0.01396595f, -0.05386476f, -0.00145036f, 0.06256598f, -0.07180307f, -0.18502797f, 
    -0.07228491f, 0.02137800f, -0.10241351f, -0.11316444f, 0.04934624f, -0.06679951f, 0.08520431f, 0.09559684f, 
    -0.07499073f, -0.03315130f, -0.03794593f, 0.09039909f, 0.31269583f, -0.09008575f, 0.05702438f, -0.05224216f, 
    -0.07586405f, -0.05333161f, 0.06888124f, 0.08778881f, 0.02271969f, 0.01896211f, -0.09314632f, 0.15644005f, 
    0.11055612f, 0.03764424f, -0.15736756f, -0.22098362f, 0.12236624f, 0.01456870f, -0.00659266f, -0.00091441f, 
    -0.06496668f, 0.02020980f, -0.12425625f, -0.08268810f, 0.10012157f, -0.04429891f, -0.04147005f, 0.01491169f, 
    -0.08731446f, 0.07179347f, 0.06881037f, -0.00017037f, -0.06252511f, -0.00090808f, -0.01876326f, 0.12133337f, 
    0.16541228f, -0.07189725f, -0.11884172f, -0.11208120f, 0.05700957f, 0.05862646f, 0.03201034f, 0.10242882f, 
    -0.04638011f, -0.10625836f, -0.00251351f, -0.01672473f, 0.11996151f, 0.14860547f, 0.14482331f, 0.04321464f, 
    0.07479005f, 0.16289911f, -0.04373211f, -0.12381244f, 0.06011101f, -0.08591495f, -0.08658078f, 0.01256793f, 
    -0.32686231f, 0.10265951f, 0.10676020f, -0.12317748f, 0.01979310f, -0.04776557f, 0.04732871f, 0.08828330f, 
    -0.05319994f, -0.11697105f, -0.00476932f, 0.06959529f, -0.02718128f, -0.10423509f, -0.08356236f, -0.07787541f, 
    0.04893408f, -0.02335152f, -0.02531132f, -0.05754206f, 0.02683445f, -0.24470581f, -0.06183656f, -0.12315824f, 
    0.14629135f, 0.35309374f, 0.15645289f, -0.06637470f, 0.15030372f, 0.11664671f, 0.02430418f, 0.02885020f, 
    -0.05330158f, -0.08427319f, -0.07754315f, -0.10847916f, -0.01070887f, -0.04091221f, 0.00971199f, 0.15055008f, 
    -0.02614404f, -0.10672496f, 0.00920281f, 0.12894177f, 0.14346017f, 0.02696595f, 0.05946925f, -0.05505547f, 
    -0.09472937f, 0.19948548f, 0.10835053f, -0.10092094f, -0.09588698f, -0.04640129f, 0.02877492f, 0.02554823f, 
    -0.03282396f, 0.00139203f, -0.02015117f, -0.14034747f, 0.08601708f, -0.04233937f, -0.08340907f, -0.08121371f, 
    -0.08086500f, -0.07303070f, -0.09801327f, -0.01073747f, -0.03557125f, -0.11673348f, 0.06639621f, -0.03679842f, 
    -0.09904239f, 0.31471971f, 0.04058185f, -0.18589413f, 0.04152016f, 0.09040786f, -0.00575727f, 0.13426550f, 
    0.00648293f, -0.00226669f, 0.00613446f, -0.04983548f, 0.05203728f, 0.04048553f, 0.08819646f, 0.24033320f, 
    -0.01564028f, 0.02284910f, 0.02748332f, 0.04758046f, 0.14926070f, 0.05137392f, 0.07840722f, 0.08875010f, 
    -0.08129564f, -0.12744723f, -0.06446667f, -0.21430151f, 0.03247014f, -0.18459743f, 0.12788758f, 0.00053144f, 
    0.01497460f, 0.15399918f, -0.17299135f, 0.09705371f, 0.13733906f, 0.00061148f, 0.17853183f, -0.01298589f, 
    0.08201476f, 0.04673027f, -0.01277617f, 0.08005407f, 0.02256256f, -0.00526770f, -0.07962966f, -0.07389746f, 
    0.71175337f, -0.18989883f, -0.09455117f, -0.33857891f, 0.08574467f, 0.01093046f, -0.00553469f, -0.04171726f, 
    0.03109474f, -0.03734582f, 0.04037138f, -0.03861266f, -0.36022693f, 0.21125218f, 0.09983791f, 0.12797940f, 
    -0.08269670f, -0.01606690f, -0.05948266f, 0.05811734f, 0.03780960f, 0.08150483f, -0.00655333f, -0.06101041f, 
    0.09719185f, 0.02048925f, 0.14459553f, -0.04557843f, -0.09342879f, 0.04001096f, 0.00171184f, 0.07399013f, 
    0.12029999f, -0.02168961f, -0.11456115f, 0.01530593f, -0.14578781f, 0.04925903f, 0.08231606f, 0.20461373f, 
    -0.15272440f, -0.10330267f, -0.10314234f, 0.03063205f, -0.08770361f, -0.00569531f, -0.06731159f, -0.17836583f, 
    -0.07185079f, -0.20985214f, 0.32181117f, 0.05170799f, -0.07824906f, -0.12453291f, 0.00873924f, -0.08800178f, 
    0.07866589f, 0.08100418f, -0.11481180f, 0.14196864f, -0.15999648f, -0.00858417f, 0.03426681f, 0.13645731f, 
    0.04814266f, 0.09953976f, 0.26267070f, 0.10248527f, 0.00108073f, 0.02406927f, 0.02614794f, -0.00132683f, 
    -0.11476894f, -0.18893969f, 0.23926553f, 0.25697890f, 0.01643558f, 0.03043287f, 0.07594346f, 0.20763235f, 
    0.20836863f, -0.03753434f, 0.12383202f, -0.06235777f, 0.04188962f, -0.12818104f, -0.10012154f, -0.04845529f, 
    -0.06666767f, -0.01221391f, -0.02561857f, 0.04993824f, -0.16110948f, -0.02004200f, -0.02604295f, -0.01300805f, 
    0.24359219f, 0.04166168f, 0.14337631f, 0.01797463f, 0.14518127f, 0.26593071f, 0.09711237f, -0.02096609f, 
    0.04773270f, -0.00099722f, -0.01612832f, 0.07430153f, 0.24432346f, -0.23292167f, 0.23194839f, 0.12420516f, 
    -0.04919543f, -0.03752879f, 0.07730407f, 0.04343930f, 0.19377653f, -0.12624346f, 0.01070744f, 0.18113665f, 
    0.26954648f, -0.18322645f, -0.12662680f, -0.01888765f, 0.00508464f, 0.11406622f, 0.01908555f, 0.05412669f, 
    -0.15083152f, -0.11693542f, 0.06054287f, 0.11095899f, 0.04663263f, 0.09207223f, -0.11370594f, 0.03280675f, 
    0.02964445f, -0.07750244f, 0.08310439f, -0.00709722f, 0.07028831f, 0.03709301f, 0.03989065f, -0.25224811f, 
    0.00234267f, -0.03603521f, -0.05685927f, -0.05498959f, 0.03088745f, 0.01898005f, -0.00122139f, -0.05707080f, 
    0.03537086f, 0.02564819f, -0.02680364f, -0.02554532f, 0.04306278f, -0.01004874f, 0.00354166f, 0.03448182f, 
    -0.02702875f, 0.00348922f, -0.03373224f, 0.03555375f, -0.02171995f, 0.02756019f, -0.01155782f, 0.01947453f, 
    0.01953370f, 0.03123392f, -0.00818213f, 0.02764807f, -0.04273102f, 0.03957732f, 0.01678720f, 0.03342761f, 
    -0.02769460f, 0.02062981f, 0.03456615f, -0.01486463f, -0.01949954f, -0.05328809f, -0.02877204f, -0.02953616f, 
    0.01792321f, -0.02862098f, -0.03705798f, -0.02685341f, -0.00146005f, -0.00271641f, -0.04292662f, 0.03199776f, 
    -0.01393284f, -0.04001409f, 0.04428141f, -0.03924935f, -0.03599519f, -0.05470059f, 0.03607241f, 0.02448873f, 
    0.04223349f, 0.04057758f, -0.00578462f, -0.04692063f, 0.01762942f, 0.02206147f, 0.00914610f, -0.04651916f, 
    -0.03935776f, -0.03474958f, 0.03251357f, 0.00489165f, 0.02929768f, 0.01451977f, 0.03001961f, 0.01317324f, 
    -0.04557307f, 0.01496075f, -0.02318534f, -0.03287419f, 0.00516723f, 0.00119861f, 0.00523668f, -0.00955193f, 
    -0.05788388f, -0.02113337f, -0.00682713f, -0.02341080f, 0.02982743f, 0.01401263f, -0.02578216f, 0.01018448f, 
    0.01938473f, 0.02105030f, 0.03031906f, -0.02487685f, -0.01964742f, -0.04935341f, -0.03146049f, -0.02080684f, 
    -0.00420017f, -0.03834666f, 0.03452007f, 0.01012010f, -0.02681536f, -0.00933815f, -0.01645130f, -0.05926706f, 
    0.01552173f, -0.02321047f, 0.05140866f, -0.03635412f, -0.02005677f, 0.04042720f, -0.01909497f, 0.02490530f, 
    0.02828385f, -0.05894818f, 0.02302391f, 0.04492719f, -0.04000507f, 0.02470918f, -0.04770057f, -0.03565234f, 
    0.00026791f, 0.03764500f, -0.01541840f, 0.03437127f, 0.00331266f, -0.03690977f, 0.03158475f, 0.04513348f, 
    -0.03889960f, -0.00336681f, -0.02283643f, -0.00339862f, -0.03379121f, 0.01507457f, 0.01164240f, -0.03893574f, 
    -0.03164000f, 0.02015709f, -0.04511878f, -0.04069326f, 0.01181590f, -0.00960650f, -0.05721415f, 0.01382061f, 
    0.05175965f, 0.00476187f, -0.02221728f, 0.00005241f, -0.03811106f, -0.00547211f, -0.03412469f, -0.04453145f, 
    -0.06136488f, -0.04276354f, 0.02465687f, 0.04843590f, -0.03142582f, -0.05044030f, 0.02389139f, -0.05717082f, 
    0.00685002f, 0.04623891f, 0.00951474f, 0.02515022f, 0.03085968f, -0.03982587f, 0.01061359f, -0.04313182f, 
    -0.01679645f, -0.00306851f, -0.01706607f, -0.00925000f, 0.03095244f, 0.01803612f, -0.05399130f, 0.03208330f, 
    -0.02185800f, -0.03953277f, -0.03014011f, -0.01287531f, -0.03671744f, -0.04456819f, -0.04065372f, 0.00122445f, 
    0.00606849f, 0.00240552f, -0.05623565f, 0.03718777f, -0.03624194f, 0.03671976f, -0.02965784f, -0.03569056f, 
    0.04845115f, 0.05312695f, -0.03829355f, -0.02294362f, -0.03232990f, -0.03085179f, 0.03186174f, 0.02186649f, 
    -0.03040252f, 0.03463127f, -0.00448118f, -0.03224425f, 0.02874180f, -0.04121019f, 0.00182093f, 0.01125432f, 
    -0.03071075f, 0.03033614f, 0.00430415f, -0.03552550f, -0.03759784f, 0.02031998f, 0.02206479f, -0.04723617f, 
    -0.03371350f, -0.03220270f, -0.04981010f, -0.00089112f, 0.00363029f, -0.04920928f, 0.03409616f, 0.03687737f, 
    -0.01479053f, 0.02210940f, 0.01418324f, -0.01928825f, -0.01324748f, 0.04140642f, -0.02986710f, -0.00037581f, 
    -0.01541372f, -0.03655002f, -0.04557432f, -0.04308399f, 0.03095417f, 0.02815678f, -0.03745817f, -0.01788484f, 
    -0.02265750f, 0.00087262f, -0.02849616f, 0.03550394f, -0.01916380f, 0.03902679f, -0.02426300f, 0.00927061f, 
    -0.01297439f, -0.00113505f, -0.00805175f, -0.03391821f, -0.05621579f, 0.02196606f, -0.02294116f, -0.05511463f, 
    0.05135940f, -0.04812831f, 0.03638088f, -0.02298403f, 0.02191568f, -0.02451765f, -0.00832293f, 0.02192109f, 
    -0.01572175f, -0.03159190f, 0.00416018f, -0.05684543f, -0.01904589f, -0.04529755f, 0.00369719f, -0.00134755f, 
    0.02650492f, 0.00954496f, -0.00336757f, -0.01265910f, 0.02345404f, -0.00983553f, -0.04259094f, -0.03432840f, 
    0.04255737f, 0.01432890f, 0.00894797f, -0.03820042f, 0.02414169f, -0.03993480f, -0.03045885f, -0.00591141f, 
    -0.03922878f, -0.01071631f, -0.05885717f, -0.05368365f, 0.01222589f, 0.00384884f, -0.02159096f, 0.03137609f, 
    -0.02480803f, 0.03465005f, -0.05635183f, -0.00538951f, 0.02720519f, -0.02593594f, 0.02959524f, 0.04427228f, 
    0.04489196f, 0.00730323f, -0.01283568f, -0.00957190f, -0.04675562f, 0.03980878f, -0.04617795f, -0.00565626f, 
    0.01654929f, -0.04113896f, 0.02968353f, -0.04179303f, 0.00529386f, 0.03238199f, -0.01445185f, 0.04137302f, 
    0.04574926f, -0.00721783f, -0.02274159f, 0.03438942f, -0.02914348f, 0.01132619f, -0.00273370f, 0.01097950f, 
    0.03403063f, -0.02957413f, 0.03619293f, 0.03667866f, 0.03734085f, -0.00143819f, -0.01766824f, 0.00626114f, 
    -0.04305266f, -0.00201293f, -0.02993700f, -0.03872098f, -0.00220939f, 0.03410359f, 0.02600714f, -0.02739893f, 
    -0.02448536f, -0.01254976f, 0.01813345f, 0.04516364f, 0.00185647f, 0.01650735f, -0.04102256f, -0.05644459f, 
    -0.01063709f, -0.00817350f, -0.03900424f, -0.02939384f, -0.02507154f, -0.00390120f, 0.02420897f, 0.00782027f, 
    0.02391571f, -0.02799327f, 0.01967440f, 0.00803315f, 0.01543062f, 0.04341535f, -0.02162239f, -0.04206105f, 
    -0.05496848f, -0.01455758f, -0.03104214f, -0.00799364f, -0.02754779f, -0.04043426f, -0.02618543f, -0.05088888f, 
    0.00953409f, -0.04377096f, -0.03719780f, -0.03271637f, -0.00435684f, 0.03557282f, -0.04935920f, -0.00604338f, 
    0.12090243f, -0.00622294f, -0.10373153f, -0.14118592f, 0.11944260f, 0.12441560f, -0.00354231f, 0.09538617f, 
    0.04738679f, -0.03055387f, 0.01772643f, 0.08752507f, -0.09746724f, -0.03363039f, -0.00472151f, 0.11536378f, 
    -0.08171081f, -0.02705841f, 0.04747603f, 0.10679331f, 0.12958640f, 0.11622088f, -0.07592058f, -0.00098131f, 
    0.36491564f, -0.08485505f, -0.14066529f, -0.08806347f, 0.00386696f, -0.03201367f, -0.03736944f, -0.04131784f, 
    0.18129595f, -0.16392021f, 0.09935860f, 0.18340273f, -0.07412737f, 0.08762752f, 0.24807501f, 0.08401997f, 
    -0.09095209f, -0.00452097f, -0.00588691f, -0.00546792f, 0.00180311f, -0.02429550f, -0.09583192f, 0.13023871f, 
    -0.21844532f, -0.16195537f, 0.12426028f, 0.26212257f, -0.01456372f, 0.05745394f, 0.07059379f, -0.05146500f, 
    0.03921023f, -0.01433624f, 0.03902707f, 0.02552275f, -0.02612602f, 0.25710624f, 0.19587232f, -0.11198787f, 
    -0.05346391f, 0.04713059f, -0.00838745f, 0.07249708f, 0.07269922f, 0.06516901f, 0.01574399f, -0.00833655f, 
    -0.12744425f, -0.07511963f, -0.11919937f, -0.01480497f, 0.18558000f, -0.03227039f, -0.08772582f, -0.21610366f, 
    -0.12748632f, 0.01438930f, 0.10464959f, -0.03256078f, -0.06626615f, 0.10307720f, 0.04475500f, 0.09455178f, 
    0.02378647f, -0.13226020f, 0.12811099f, -0.01149476f, 0.04380224f, 0.07477227f, -0.00679668f, 0.08266579f, 
    0.10554695f, -0.02499471f, 0.12942311f, -0.03326742f, 0.14976113f, 0.09369772f, 0.14685649f, 0.12040393f, 
    0.07005314f, 0.01879331f, 0.04353040f, 0.04367539f, -0.11664394f, -0.07627508f, -0.04216119f, 0.10779350f, 
    -0.16489524f, -0.04969314f, -0.03409246f, -0.16501944f, -0.03902042f, -0.07353937f, 0.06023673f, 0.06607489f, 
    -0.02755139f, 0.09621044f, -0.16957621f, 0.24997690f, -0.02887749f, 0.00773744f, -0.05516163f, -0.02643503f, 
    -0.09383884f, -0.04588759f, -0.08597136f, -0.10230433f, -0.10067477f, -0.04997104f, 0.01686575f, -0.02693645f, 
    -0.01202018f, -0.07489511f, -0.08853558f, -0.09900679f, 0.01888220f, 0.18250602f, 0.06709886f, 0.03833650f, 
    -0.14910741f, 0.01641605f, -0.08006287f, 0.06763297f, 0.01611607f, 0.06029673f, 0.03455349f, -0.12848960f, 
    0.02556995f, -0.03268440f, -0.09156512f, -0.06343995f, 0.21575928f, -0.14547306f, 0.11007863f, 0.01151084f, 
    -0.04061536f, -0.06084110f, -0.01963774f, 0.05137861f, 0.01697459f, 0.00237525f, -0.01910219f, 0.22039643f, 
    -0.00419905f, 0.17229185f, 0.32934612f, 0.16965406f, -0.03211364f, 0.00733991f, 0.02576803f, -0.03100906f, 
    0.09691277f, -0.13417052f, 0.02511661f, 0.10495828f, -0.13524444f, -0.04726781f, 0.07863844f, 0.01023142f, 
    -0.00488833f, 0.04025361f, 0.06090037f, -0.01871949f, -0.00279887f, 0.04737406f, -0.11307552f, 0.05091003f, 
    -0.11782662f, -0.17286412f, -0.28791943f, -0.11330058f, 0.14524542f, -0.16609694f, -0.25282013f, -0.05748514f, 
    -0.04862008f, -0.00117774f, -0.01726080f, 0.05146491f, 0.28418925f, 0.11004388f, 0.06566867f, 0.08918285f, 
    -0.04008889f, 0.09834886f, 0.01549374f, 0.01764396f, 0.05066632f, 0.00317145f, 0.11211915f, 0.05215916f, 
    0.07503403f, -0.11269249f, 0.29196429f, -0.09079281f, -0.14440259f, 0.01042841f, -0.06209473f, 0.11116793f, 
    0.03506098f, -0.00308555f, -0.01369159f, -0.13646127f, 0.07255738f, -0.14641891f, -0.20803212f, -0.14352258f, 
    0.04915936f, -0.01407454f, 0.14842422f, 0.06349963f, 0.12749009f, 0.03594039f, 0.10278945f, -0.01084746f, 
    0.03671931f, 0.16278431f, 0.26502234f, -0.06146409f, 0.14808488f, -0.17496032f, 0.09530877f, -0.14427567f, 
    0.00912102f, 0.34659287f, 0.07884730f, 0.14332716f, -0.05734076f, 0.08144791f, -0.18063508f, -0.13552615f, 
    0.00409057f, -0.13988870f, 0.02150607f, -0.02513370f, 0.02306760f, -0.24497575f, 0.04462036f, 0.01608934f, 
    0.19016783f, -0.32125911f, 0.21492809f, -0.05524539f, 0.01295357f, 0.06407315f, 0.02279389f, 0.09878048f, 
    0.14659829f, 0.06098302f, 0.11752986f, 0.11452888f, 0.04581858f, -0.00120626f, -0.05626446f, 0.03605301f, 
    0.04637339f, 0.07138537f, 0.09101332f, 0.00129497f, 0.02509055f, 0.08174920f, 0.04508553f, 0.35287079f, 
    0.02092100f, -0.01736512f, 0.20086429f, 0.18595059f, -0.11107610f, -0.06928989f, -0.07289810f, -0.03291081f, 
    0.06368232f, 0.12403963f, -0.12564728f, -0.18646687f, 0.06195643f, -0.14439091f, -0.13646892f, 0.11983296f, 
    -0.02467466f, -0.04417149f, 0.11151154f, 0.08379397f, 0.01849809f, 0.00153932f, 0.03862223f, 0.05530638f, 
    0.31074893f, -0.27093047f, 0.03270752f, -0.01055131f, -0.09451518f, 0.36082426f, 0.04180354f, -0.11019035f, 
    0.23339647f, -0.07065833f, 0.09547430f, -0.00389933f, 0.01226162f, 0.24760891f, -0.15422480f, 0.03244461f, 
    -0.04090398f, -0.00409999f, 0.11442811f, 0.04188578f, -0.01767348f, -0.06566513f, -0.01771754f, -0.02398967f, 
    -0.05508394f, -0.15236038f, -0.03866269f, -0.03952043f, -0.11223107f, 0.14544795f, 0.02114895f, -0.24308690f, 
    0.08738897f, -0.06842574f, 0.07766116f, -0.07822645f, 0.39160833f, -0.40696543f, 0.05985742f, 0.22169966f, 
    0.00178201f, 0.14326864f, -0.05951208f, -0.01369976f, 0.26007679f, 0.06060972f, 0.05762561f, 0.03565582f, 
    -0.29335552f, 0.11641482f, 0.02169541f, 0.07902255f, 0.02965243f, -0.30946594f, 0.08846062f, -0.08681417f, 
    0.03844667f, 0.01320305f, -0.06786285f, 0.05099229f, -0.10554245f, 0.06233706f, -0.01129516f, -0.07788756f, 
    -0.07742697f, -0.06506220f, -0.02377476f, -0.05492029f, 0.10241738f, 0.17159231f, 0.04121888f, 0.17168762f, 
    -0.14699668f, -0.02533527f, -0.22371523f, 0.00778379f, 0.15698539f, 0.02925112f, 0.04974974f, 0.04216669f, 
    -0.01546038f, -0.12515725f, -0.10215584f, 0.01345203f, 0.17315257f, 0.01424153f, -0.07040000f, 0.01768439f, 
    0.00914058f, 0.14970297f, 0.04110903f, 0.04542483f, 0.02741211f, 0.00472419f, -0.10765453f, -0.08147131f, 
    -0.31961313f, -0.11975601f, -0.08220167f, -0.21616143f, -0.02618117f, -0.05184827f, -0.05820572f, 0.04224566f, 
    0.05524624f, -0.00551987f, 0.17344992f, 0.08142717f, 0.24723834f, 0.09889212f, -0.03375519f, 0.20723860f, 
    0.12074983f, 0.06414513f, 0.05269519f, -0.15021913f, 0.19479345f, 0.10739477f, 0.05215826f, 0.13571186f, 
    0.20649327f, 0.15516409f, -0.00360658f, 0.29511145f, -0.05039211f, -0.03046300f, 0.06545348f, 0.08743121f, 
    -0.04714002f, 0.14450637f, 0.11346062f, 0.01857914f, -0.41447911f, -0.49030912f, -0.00578601f, -0.25137475f, 
    -0.05497891f, 0.00006827f, -0.09251346f, -0.05750602f, -0.00068870f, -0.05629566f, -0.05257635f, -0.09363443f, 
    0.24817879f, 0.17710602f, 0.03113298f, 0.16430414f, 0.02786556f, -0.03133482f, -0.00770695f, 0.25184718f, 
    -0.04281767f, -0.03162846f, 0.12972346f, 0.12816001f, -0.24353814f, -0.36746821f, -0.36933854f, -0.19743502f, 
    0.03473388f, -0.01058484f, -0.05336795f, -0.16301575f, 0.08175628f, -0.03436571f, -0.05736468f, -0.08031012f, 
    0.15513051f, -0.00306203f, -0.04125958f, -0.04276375f, 0.18399698f, 0.02243588f, 0.12571333f, -0.11394994f, 
    0.01682480f, 0.00493375f, -0.07894075f, -0.03923861f, 0.33726454f, 0.44787636f, 0.22863013f, 0.35286686f, 
    -0.06378718f, 0.01094350f, 0.14985096f, 0.13670798f, -0.05640293f, 0.04060004f, -0.06257544f, 0.07943963f, 
    0.03009618f, -0.01433748f, 0.03173526f, 0.25172082f, -0.00776115f, 0.05083840f, 0.01660044f, 0.01000304f, 
    -0.01951734f, 0.23337036f, 0.15643403f, 0.12437232f, -0.11826070f, -0.08348797f, -0.07369859f, 0.05327576f, 
    -0.04947440f, -0.05655509f, -0.12646811f, -0.02580575f, -0.13361824f, 0.07013252f, 0.12809664f, 0.29132476f, 
    0.40651992f, 0.26251423f, 0.22157696f, 0.17150173f, 0.15974557f, 0.14903527f, -0.03937625f, -0.08017106f, 
    0.07790849f, 0.01726048f, 0.05748714f, 0.16920038f, -0.14943418f, -0.23427163f, -0.42039382f, -0.16593324f, 
    0.03494863f, -0.07920524f, -0.01666336f, -0.00980623f, -0.14550519f, 0.01381221f, -0.03333258f, 0.02326313f, 
    0.35525593f, 0.02723985f, -0.03672164f, 0.23274043f, 0.09441893f, 0.06308307f, 0.01511964f, 0.01359142f, 
    0.08758359f, -0.01247965f, 0.05684187f, 0.11906112f, -0.12462594f, -0.22641176f, -0.20937656f, -0.24912161f, 
    0.02298059f, -0.07863519f, -0.06190116f, -0.07747587f, -0.02962489f, 0.02494810f, 0.00687539f, 0.05685059f, 
    0.19555108f, 0.23253587f, 0.11117166f, 0.37331611f, 0.13544561f, -0.00938259f, -0.00488013f, 0.15121958f, 
    0.02590653f, 0.02427557f, 0.11243139f, 0.09005418f, -0.23806611f, -0.15653594f, -0.46647754f, -0.37341923f, 
    -0.06044779f, -0.06172904f, 0.00585058f, -0.11730677f, 0.00825839f, 0.07686979f, -0.09008062f, -0.02905727f, 
    0.05760229f, 0.24034117f, -0.01140264f, -0.22442862f, 0.08268102f, -0.01261222f, -0.17010248f, 0.01414346f, 
    0.04606592f, -0.05537499f, -0.03174217f, -0.20790452f, 0.16728386f, 0.04615090f, 0.06996915f, 0.05611909f, 
    -0.05754216f, -0.03164379f, -0.01577382f, -0.10182549f, 0.04438898f, 0.07894544f, 0.06925347f, 0.20485957f, 
    0.00826778f, -0.29074997f, -0.12457335f, -0.16019760f, 0.08326676f, -0.10083340f, -0.10973921f, -0.21716492f, 
    -0.10263307f, 0.09485728f, 0.15350600f, 0.18763989f, -0.05134097f, -0.31169599f, -0.00606306f, -0.34805909f, 
    0.01906468f, -0.00319208f, -0.06625601f, 0.05635922f, 0.10098791f, -0.09914677f, -0.02734119f, 0.04589886f, 
    -0.07787048f, -0.13484086f, -0.24941698f, 0.16908982f, -0.00617660f, -0.06589705f, -0.09612993f, -0.06620999f, 
    -0.08992033f, -0.08660615f, 0.06842832f, -0.04820810f, -0.14235051f, -0.35346437f, -0.21639426f, -0.12425393f, 
    0.08084463f, 0.07384107f, 0.05598922f, 0.10106017f, 0.08143099f, 0.02701886f, -0.03408806f, 0.01574157f, 
    -0.22139724f, -0.06054818f, -0.16278023f, 0.11088970f, 0.06427624f, -0.02037194f, 0.05686819f, 0.14096783f, 
    -0.03785121f, 0.06595536f, 0.00677084f, -0.14846474f, 0.01048674f, 0.12371892f, 0.08333411f, 0.02647378f, 
    -0.08194254f, -0.06690147f, 0.11601604f, -0.01219160f, -0.08248907f, 0.00022476f, -0.02362951f, -0.05196679f, 
    -0.27364036f, -0.09195694f, -0.16543365f, -0.09736673f, 0.02370325f, -0.10980589f, 0.00211181f, -0.11806297f, 
    0.09011741f, -0.01010566f, -0.05034856f, -0.16090079f, 0.12605001f, -0.16722642f, -0.36790320f, -0.21177469f, 
    0.06826437f, 0.02149684f, -0.06377374f, -0.00881532f, 0.03450803f, -0.00505515f, -0.04915925f, 0.01282267f, 
    0.34721515f, 0.14896269f, 0.15006594f, 0.10082865f, -0.08697803f, -0.10248640f, 0.32021460f, -0.08437815f, 
    0.03978698f, -0.05150853f, -0.08644066f, -0.05623988f, 0.20832807f, -0.13023740f, -0.33942220f, 0.09473057f, 
    0.02254731f, -0.02163645f, 0.07483882f, 0.01828902f, 0.12943082f, 0.02395028f, 0.12557602f, 0.09004138f, 
    -0.38382465f, -0.33942208f, -0.33985269f, -0.06262127f, 0.04833467f, -0.12584534f, -0.13434629f, -0.04570892f, 
    0.05892819f, -0.10865407f, -0.05288001f, 0.09908184f, 0.02663336f, -0.24404728f, -0.14763756f, 0.00433693f, 
    -0.04012160f, -0.05210176f, 0.03392224f, -0.04093092f, 0.10732237f, 0.08984778f, 0.11816074f, 0.10162056f, 
    -0.15792951f, -0.18831499f, -0.09430158f, -0.12357076f, -0.01941648f, -0.05059462f, 0.11255562f, 0.09823458f, 
    0.08691464f, 0.11629813f, 0.04612903f, 0.20918822f, -0.06666045f, 0.07165053f, 0.09241655f, 0.06474850f, 
    -0.00847947f, -0.00470139f, -0.03871493f, 0.04849475f, 0.19617800f, 0.10990424f, -0.05146769f, 0.06352398f, 
    0.14101607f, 0.11918380f, 0.03602800f, -0.03423393f, 0.05438721f, -0.05029927f, 0.01563754f, 0.06347627f, 
    0.05293849f, -0.11547542f, 0.04630173f, -0.03786272f, -0.04966486f, 0.20975490f, 0.23189676f, 0.06825083f, 
    -0.10577021f, 0.06340326f, -0.01974873f, -0.05207584f, -0.16541885f, -0.06814443f, -0.00550927f, 0.01435136f, 
    0.04455608f, -0.13220970f, -0.14820607f, 0.01032204f, -0.05496152f, 0.05727939f, 0.20285746f, -0.02414432f, 
    0.04196918f, 0.07201163f, 0.05158397f, 0.03794648f, -0.15409982f, 0.23960532f, 0.25154108f, -0.15081181f, 
    -0.08010236f, -0.05949783f, 0.00414759f, 0.03435156f, -0.03322103f, -0.04320017f, 0.02331826f, -0.00779912f, 
    -0.03297400f, -0.29016322f, -0.25696418f, -0.25648129f, 0.11315876f, 0.02305150f, 0.02122856f, -0.00885408f, 
    0.02449759f, 0.00165525f, 0.11271717f, -0.00113028f, -0.27275676f, 0.12541308f, 0.01333445f, -0.11375730f, 
    -0.08495750f, -0.14778715f, 0.05799146f, -0.08874330f, -0.08276453f, 0.04088501f, -0.11765785f, 0.01227044f, 
    0.01315137f, -0.20298590f, -0.03373708f, -0.07237774f, -0.12571087f, 0.14834946f, 0.02143816f, 0.03697327f, 
    0.10215436f, 0.00792681f, 0.02727026f, 0.04284549f, -0.11038512f, -0.06469145f, -0.37421629f, -0.23854613f, 
    0.02297646f, 0.03595301f, 0.13128133f, -0.12994042f, 0.01142553f, -0.08486196f, 0.12319446f, 0.07561439f, 
    -0.16888706f, 0.28442720f, 0.05945887f, 0.22107378f, 0.05162820f, 0.00307081f, 0.07475968f, 0.09143551f, 
    -0.23129311f, 0.14858457f, -0.07084840f, 0.06497479f, -0.15433529f, -0.13665305f, 0.11462768f, -0.00201689f, 
    -0.04437950f, -0.01928999f, -0.03852596f, -0.07614929f, -0.02606849f, 0.23500378f, 0.02616549f, -0.08297712f, 
    0.11932155f, 0.26309901f, 0.11188018f, 0.04561848f, 0.17028332f, 0.14013749f, 0.01679502f, 0.08956125f, 
    0.05014777f, 0.10629972f, -0.07179011f, -0.06303608f, 0.03494795f, -0.04890127f, 0.13062394f, -0.11951131f, 
    -0.13189641f, -0.04558019f, 0.00034315f, 0.02432381f, -0.04801796f, 0.04053817f, 0.03081181f, 0.06588725f, 
    0.03844285f, 0.10534578f, 0.24856047f, 0.18977782f, -0.11957541f, 0.10224485f, -0.08957231f, -0.02602463f, 
    0.06776749f, -0.03365657f, 0.04589588f, 0.01723989f, -0.20715001f, -0.01550479f, -0.01919399f, 0.04486088f, 
    -0.04405196f, -0.09294505f, 0.00995159f, -0.15492161f, -0.14514866f, -0.05597796f, -0.14200306f, 0.02515443f, 
    -0.15720581f, 0.07169671f, -0.22651552f, -0.32290658f, 0.07735338f, 0.07627644f, -0.15629880f, 0.17804955f, 
    -0.01125704f, 0.14850160f, 0.04582544f, 0.05982107f, 0.05925343f, 0.01225128f, 0.00565338f, 0.15548511f, 
    -0.05014176f, 0.03126019f, 0.06183721f, 0.00544151f, -0.02668776f, -0.00413519f, 0.21164301f, 0.00532648f, 
    0.01490528f, -0.11160041f, 0.12509273f, -0.21843681f, 0.08668687f, -0.11734182f, -0.10835108f, 0.13166930f, 
    0.02546607f, 0.14630187f, 0.13932113f, -0.12397971f, 0.33560669f, 0.08760789f, -0.02020365f, -0.06933374f, 
    0.24361993f, 0.09171063f, 0.01307381f, 0.20577484f, 0.10682338f, -0.09368879f, 0.20550323f, -0.03219321f, 
    0.11523778f, -0.06966761f, 0.08327774f, -0.10149469f, -0.00824759f, -0.02458095f, 0.10392182f, 0.01202735f, 
    0.01018689f, 0.23453625f, 0.05729683f, 0.16890472f, -0.39288127f, 0.26953080f, -0.07333831f, -0.05460697f, 
    0.07100244f, -0.04686504f, -0.11978963f, -0.03577743f, 0.14997196f, -0.11415449f, 0.09459184f, 0.01569111f, 
    0.00710035f, -0.40256548f, 0.28893256f, -0.05017892f, 0.00576520f, 0.10085198f, 0.01199507f, 0.07674230f, 
    0.15347667f, 0.00152778f, -0.03756249f, 0.15835199f, -0.31893167f, -0.15020342f, -0.06952696f, 0.07180306f, 
    -0.12690476f, -0.02977966f, -0.04787042f, -0.03588579f, -0.09692977f, 0.07161666f, -0.02304904f, -0.00182185f, 
    -0.32450381f, -0.01188202f, 0.18008326f, 0.00870944f, -0.10652334f, -0.12434703f, 0.04619221f, 0.00575037f, 
    0.04601878f, 0.28052679f, 0.06662651f, -0.00284741f, -0.07357568f, -0.11041735f, -0.09763493f, 0.06488653f, 
    0.04576342f, 0.00187165f, 0.09051538f, 0.12207510f, -0.01117934f, 0.01720055f, 0.10240078f, 0.01373445f, 
    0.04942218f, -0.11111706f, 0.01136970f, -0.03800196f, 0.01191719f, 0.06581162f, 0.05523916f, 0.04003830f, 
    0.28633249f, -0.01449236f, 0.10143881f, -0.02335590f, -0.20763437f, -0.04775463f, -0.16306122f, -0.18261655f, 
    0.09486112f, 0.03013186f, -0.09252516f, -0.08186180f, -0.07793733f, 0.02467179f, -0.02055488f, -0.08893728f, 
    0.11884490f, -0.09878341f, -0.20401874f, -0.10462673f, 0.04438185f, 0.06290895f, 0.21763317f, -0.12743351f, 
    0.11828292f, 0.01628516f, 0.10467938f, 0.09789245f, 0.46395802f, -0.36651084f, 0.02731658f, 0.20230675f, 
    -0.05918117f, -0.07169168f, -0.01930331f, 0.08248208f, 0.41715312f, 0.02239186f, 0.14125519f, 0.13943307f, 
    -0.36787653f, -0.20262320f, 0.15990324f, -0.07279777f, 0.11007142f, -0.12495630f, 0.01363346f, -0.16000398f, 
    -0.04663606f, -0.19758305f, -0.06278343f, 0.22884621f, -0.10543545f, 0.03801372f, -0.01281608f, 0.05603615f, 
    -0.08816103f, -0.06300668f, -0.01856876f, -0.06853297f, -0.02666931f, 0.11923402f, -0.15576795f, 0.07727267f, 
    0.21243255f, 0.07301038f, -0.01170979f, -0.09370682f, 0.12402177f, 0.01392045f, 0.10670577f, 0.10355916f, 
    0.07496486f, -0.07393831f, 0.03489199f, 0.08477787f, 0.16727172f, 0.16434453f, -0.11637872f, 0.03339875f, 
    0.09830914f, 0.05332588f, 0.11097223f, 0.14717075f, -0.02032656f, -0.02379450f, 0.00323813f, -0.14133339f, 
    -0.48209634f, -0.22296010f, -0.13095923f, -0.12144984f, -0.06411602f, -0.02629761f, -0.06164613f, -0.00939596f, 
    -0.00816229f, -0.11233490f, -0.19340244f, 0.14174330f, 0.25285503f, 0.16305648f, 0.00403368f, 0.11763597f, 
    0.10656185f, 0.12707193f, 0.03723534f, -0.04472413f, 0.09902586f, 0.09101393f, 0.08393264f, -0.05895506f, 
    0.24432482f, 0.15529639f, 0.07898478f, 0.42536375f, -0.02911662f, -0.03229178f, 0.15018268f, -0.03740759f, 
    0.01982844f, 0.11150125f, 0.15396106f, 0.03829348f, -0.23647250f, -0.32941911f, 0.09791761f, -0.18690322f, 
    -0.05756746f, -0.10786927f, -0.11780444f, -0.02039311f, 0.01514896f, -0.00659837f, 0.03570801f, 0.00570155f, 
    0.28890640f, 0.21877654f, 0.04371411f, 0.04519136f, -0.07263656f, 0.03471559f, -0.10200582f, 0.14148141f, 
    -0.00136794f, -0.00764084f, 0.01806794f, 0.05158099f, -0.15581504f, -0.25578499f, -0.23381156f, -0.13167012f, 
    -0.06621855f, -0.04811884f, -0.06202243f, 0.02704965f, -0.01896628f, 0.05982412f, 0.08281574f, -0.03965522f, 
    0.08279373f, -0.11780182f, 0.01820429f, 0.04446194f, 0.14409232f, 0.09852456f, 0.21181419f, -0.03559591f, 
    -0.00181903f, 0.01741656f, 0.02451654f, -0.02611389f, 0.25003749f, 0.31473947f, 0.25798044f, 0.40369055f, 
    0.11343139f, 0.02461145f, 0.11251769f, 0.29065838f, 0.06772417f, 0.01236054f, 0.01893391f, -0.01366074f, 
    0.23975958f, 0.07388722f, 0.13752840f, 0.11764377f, 0.02042568f, 0.04998959f, -0.02711832f, 0.12321970f, 
    -0.25379398f, 0.00505760f, 0.04158348f, 0.16951433f, -0.09519147f, -0.10445654f, -0.02161309f, -0.07191566f, 
    -0.04705193f, -0.03109609f, -0.06285825f, 0.01228221f, -0.12137919f, -0.07020358f, 0.05232129f, 0.15095462f, 
    0.23784353f, 0.22665885f, 0.21663846f, 0.30526629f, -0.06210693f, 0.04585738f, -0.07296795f, -0.04209850f, 
    0.03574587f, 0.04116736f, 0.05381361f, 0.07649809f, -0.15573697f, -0.20802642f, -0.21424115f, -0.16330621f, 
    -0.06517799f, -0.10482924f, -0.05796648f, 0.03028973f, -0.02367689f, 0.03191838f, -0.05273142f, 0.00390321f, 
    0.37070051f, 0.26993743f, 0.05378105f, 0.01428100f, 0.13362233f, 0.08956489f, 0.10408645f, 0.09974006f, 
    0.14383329f, -0.07085196f, 0.09209409f, -0.02790826f, 0.02070008f, -0.20696002f, -0.22461970f, -0.20287044f, 
    -0.07609329f, -0.01721688f, 0.00205337f, -0.06692439f, 0.01354922f, 0.07271230f, 0.01079464f, 0.04619022f, 
    0.27855623f, 0.12777591f, 0.03435651f, 0.31721354f, 0.04039430f, -0.13384181f, -0.00094898f, 0.06462165f, 
    -0.01127229f, 0.04746680f, 0.09518729f, 0.07861302f, -0.19051059f, -0.22843376f, -0.18635102f, -0.23334262f, 
    -0.07801967f, -0.01469197f, -0.07366271f, -0.07579976f, 0.02640854f, 0.04856971f, -0.05832632f, -0.00301935f, 
    0.42744797f, 0.05507322f, 0.21010849f, -0.24339473f, 0.02600100f, -0.08976597f, -0.00760623f, -0.03642814f, 
    -0.04126053f, 0.16669580f, 0.01876730f, -0.18116814f, -0.04568256f, 0.24895942f, 0.03797673f, 0.14752071f, 
    0.01062175f, -0.04522276f, 0.02081950f, -0.08349545f, -0.18048120f, -0.13702893f, 0.08446796f, -0.07615810f, 
    -0.13162465f, -0.11760878f, -0.02010581f, 0.15817901f, -0.05294237f, 0.12159910f, -0.13880137f, -0.09930697f, 
    -0.06263532f, 0.06757018f, 0.14569049f, 0.06030498f, 0.04826723f, -0.23791580f, 0.09405431f, -0.20792352f, 
    -0.07198633f, -0.03420905f, 0.02251711f, -0.04745135f, 0.09697659f, -0.18527250f, 0.08134036f, -0.10444149f, 
    0.09639955f, -0.00503538f, -0.07606261f, 0.14706497f, -0.00254127f, -0.00258248f, 0.06774851f, 0.04320555f, 
    0.00232931f, -0.05281264f, 0.23194839f, 0.03699442f, -0.10420749f, -0.08007667f, -0.13882743f, -0.07768052f, 
    -0.01856608f, 0.06575492f, 0.02617203f, 0.06020903f, 0.02555701f, 0.10928395f, 0.12726149f, 0.03375402f, 
    0.26383585f, -0.05734964f, 0.12254401f, 0.23032445f, -0.00496713f, -0.05086620f, 0.06072723f, 0.03379366f, 
    -0.06473503f, -0.06482812f, 0.12801410f, -0.04980591f, 0.05070414f, 0.19574708f, 0.12607574f, 0.13640709f, 
    -0.06025255f, 0.12736645f, 0.10803597f, 0.21753734f, 0.00526013f, 0.03912984f, 0.08031250f, -0.02746262f, 
    -0.23063575f, 0.06200494f, -0.04870490f, -0.09549679f, 0.00862448f, -0.05397085f, 0.00113642f, -0.09575482f, 
    0.05697713f, -0.04446480f, 0.01692626f, -0.00161956f, 0.36163154f, -0.06258754f, 0.00498007f, -0.19034432f, 
    -0.10443334f, -0.10538284f, -0.16136701f, -0.01516077f, 0.08473311f, 0.05369356f, 0.00655648f, -0.07364146f, 
    0.36281818f, 0.18153924f, 0.28094107f, 0.12589937f, -0.05578024f, -0.00869008f, 0.08530885f, -0.07595111f, 
    0.02167254f, -0.02123793f, -0.06553750f, -0.11259186f, -0.16816884f, 0.28347945f, -0.16377991f, 0.19166708f, 
    0.09420443f, 0.02564116f, 0.03576479f, -0.10532770f, 0.01784438f, -0.14417811f, -0.04531299f, 0.15480877f, 
    -0.17734239f, -0.25257647f, -0.08289665f, -0.18244115f, 0.03951566f, -0.13916807f, -0.13342789f, -0.05746858f, 
    -0.00940366f, 0.04474820f, 0.07938010f, 0.04602979f, -0.11316849f, -0.04896002f, -0.11570129f, 0.04915755f, 
    -0.06212610f, 0.00617169f, -0.02749156f, 0.03040384f, -0.11458474f, 0.07431586f, -0.02686820f, 0.11920030f, 
    -0.13057819f, 0.11192141f, 0.12000792f, 0.07266051f, 0.19522671f, -0.02287200f, -0.09207062f, -0.00169395f, 
    -0.01338226f, -0.26426220f, -0.25185609f, -0.09869500f, 0.17972969f, 0.08395922f, 0.20116560f, -0.03984232f, 
    -0.04490908f, 0.10304576f, 0.00964377f, 0.00444308f, 0.07659048f, 0.08427823f, -0.03177893f, -0.12108864f, 
    -0.09552494f, 0.03060818f, 0.02069290f, 0.31453884f, -0.07612307f, 0.04082391f, -0.07014334f, -0.04675499f, 
    -0.03047578f, 0.16822618f, 0.36006200f, 0.09088282f, 0.38903582f, -0.00270487f, 0.06402521f, 0.16505443f, 
    -0.11678690f, -0.06807420f, -0.17164126f, -0.06228295f, 0.18161441f, 0.08037955f, 0.02840214f, 0.17593698f, 
    0.20889288f, 0.10729999f, 0.00626111f, 0.12192439f, -0.04367593f, -0.08854410f, -0.01350475f, 0.15344410f, 
    0.07259895f, 0.03581674f, 0.11555865f, -0.02008759f, -0.34975410f, -0.06369765f, -0.16408601f, 0.19366583f, 
    0.09487531f, 0.13380584f, 0.01337312f, 0.00866577f, -0.17488524f, -0.09098835f, 0.02634763f, -0.10205165f, 
    0.19601555f, 0.22613342f, -0.01596664f, 0.09184825f, 0.06220486f, 0.07433642f, 0.04761900f, 0.09057359f, 
    0.04305974f, -0.02582988f, -0.05609558f, -0.00147801f, -0.18815926f, 0.14112096f, -0.41372579f, -0.08737537f, 
    0.08475232f, 0.13561803f, 0.09390464f, -0.17619568f, -0.04632290f, -0.10467093f, -0.10804932f, -0.22244191f, 
    0.01398299f, 0.10701728f, -0.15641652f, -0.09372614f, 0.03500910f, -0.02578775f, -0.02669140f, 0.02259870f, 
    0.00389814f, -0.01932145f, -0.17166477f, -0.02048202f, 0.29284465f, 0.36222103f, -0.00942452f, -0.03507318f, 
    -0.07763080f, -0.13699128f, 0.02955553f, 0.11251216f, 0.05685180f, 0.09505175f, -0.02289726f, -0.05665138f, 
    -0.04747304f, 0.14188154f, 0.04628938f, 0.11735065f, -0.22185211f, 0.07522900f, -0.04525042f, -0.17312935f, 
    0.24868354f, 0.02652950f, 0.05903409f, 0.15911794f, -0.14221302f, 0.01875842f, 0.06173090f, 0.22873765f, 
    -0.01476558f, -0.07197361f, 0.16246480f, -0.02870135f, 0.15038653f, 0.23433349f, 0.32961568f, 0.54510856f, 
    0.02774097f, 0.07082589f, -0.07699803f, -0.07406274f, 0.05140003f, 0.06742004f, 0.02937549f, 0.08056631f, 
    0.09905747f, 0.07148117f, 0.05240366f, 0.16665809f, -0.06592669f, -0.02581213f, 0.11449645f, 0.05025869f, 
    0.03716275f, 0.03921305f, -0.12967755f, -0.01700609f, -0.12503408f, -0.07695825f, -0.04833954f, 0.00862163f, 
    0.29378623f, 0.10107921f, 0.01362979f, 0.08465652f, 0.01593589f, -0.08632185f, -0.12031518f, -0.10650558f, 
    0.01093376f, -0.07279480f, 0.00815132f, 0.01943134f, -0.20814255f, -0.13714343f, -0.02589324f, 0.03341247f, 
    0.14360206f, 0.07387927f, -0.03749034f, 0.07600855f, 0.00154543f, 0.03073560f, 0.08796709f, 0.13245721f, 
    0.07688277f, 0.19047779f, -0.15173633f, 0.03101663f, -0.00935378f, 0.09092356f, 0.10791876f, -0.01352342f, 
    -0.03413485f, -0.07091797f, 0.04640509f, 0.06344070f, -0.05876976f, -0.13924615f, 0.06071238f, -0.02823790f, 
    0.15143639f, 0.08921502f, 0.10935455f, -0.08642802f, 0.02392163f, 0.02406887f, -0.16946323f, -0.11734093f, 
    -0.54679233f, 0.02393942f, -0.45361224f, 0.01015139f, 0.04838628f, 0.04464003f, -0.08163187f, 0.13973796f, 
    -0.21391965f, -0.16429794f, -0.07526169f, 0.09185721f, -0.03496216f, -0.01988483f, -0.04115541f, 0.08648435f, 
    -0.09245376f, -0.06599193f, -0.01079569f, -0.04026283f, 0.07554121f, 0.06255922f, -0.01515369f, 0.25423622f, 
    -0.21681604f, -0.04211820f, -0.02260837f, 0.03844638f, 0.05685110f, -0.04467372f, 0.01472944f, 0.03685464f, 
    -0.17029166f, 0.13901775f, -0.06112511f, 0.20102343f, 0.06419949f, 0.07756818f, -0.13980193f, 0.02232146f, 
    0.00325415f, 0.17019376f, 0.15534589f, -0.20084369f, 0.23564605f, -0.17653228f, -0.03182422f, 0.18813340f, 
    0.18404230f, 0.01947515f, -0.12587225f, 0.05695803f, -0.15563495f, -0.08470861f, -0.09718441f, -0.22567543f, 
    -0.12738384f, 0.08143108f, -0.17620289f, -0.26440755f, 0.37140873f, 0.15901685f, 0.30427957f, 0.16424046f, 
    0.01569530f, 0.02061693f, -0.02093956f, -0.24162650f, 0.14156714f, -0.14690101f, -0.10065752f, -0.16424194f, 
    -0.42165965f, 0.29885748f, 0.13159147f, 0.28506365f, 0.03442437f, -0.10648814f, -0.12519492f, 0.09367133f, 
    -0.07516292f, 0.03574389f, 0.05817600f, -0.16573378f, 0.10639523f, 0.20701267f, -0.07550398f, -0.23212804f, 
    -0.21137185f, 0.02242609f, -0.01448961f, -0.02467582f, -0.01191241f, -0.30049014f, -0.22072281f, -0.26322696f, 
    -0.26857236f, -0.04848785f, -0.29754695f, 0.09125227f, -0.02983331f, -0.00494153f, -0.03227723f, -0.32011357f, 
    -0.03067555f, 0.11556732f, -0.18673402f, -0.17390223f, -0.00563891f, 0.06251668f, -0.05697055f, -0.01254404f, 
    0.14653435f, 0.07257996f, 0.23516656f, 0.02472606f, 0.11452552f, -0.32528248f, -0.19014494f, -0.12797929f, 
    0.02152038f, 0.13159633f, -0.01623084f, -0.20941301f, 0.01330650f, -0.18884587f, 0.04015874f, 0.12203596f, 
    -0.08442023f, 0.06625935f, -0.00841953f, -0.15652364f, 0.29224741f, -0.53656876f, -0.01410349f, 0.08991287f, 
    0.01112889f, 0.01316307f, -0.12708172f, 0.04853722f, 0.02174291f, 0.06100029f, 0.09128594f, -0.05856019f, 
    -0.36127320f, 0.35974061f, -0.20880468f, 0.20479813f, 0.18325067f, -0.01275580f, -0.04776642f, -0.15748608f, 
    0.06050086f, -0.01352799f, -0.08426255f, 0.10205687f, 0.05364029f, -0.16123258f, 0.04789769f, -0.16426173f, 
    -0.07253525f, -0.02103890f, -0.02998870f, -0.07157592f, 0.07123240f, 0.01123371f, 0.15775752f, 0.38229549f, 
    0.00544827f, -0.00548339f, -0.04037403f, -0.01088913f, -0.02092144f, -0.02525119f, -0.00446998f, -0.02477632f, 
    -0.02204108f, 0.03313563f, -0.02413771f, 0.02729702f, 0.03630171f, -0.00317398f, 0.00354067f, -0.04448299f, 
    0.01755764f, -0.01836320f, 0.00624936f, 0.00904527f, 0.03322606f, -0.01781794f, -0.05199343f, -0.03317649f, 
    -0.03023587f, 0.01619888f, -0.01323948f, -0.01379299f, 0.02911267f, -0.00108786f, -0.02762510f, -0.01249734f, 
    -0.03474082f, -0.05064149f, -0.03406952f, -0.05671006f, -0.00411665f, 0.03385903f, 0.00209031f, 0.03257694f, 
    -0.01103015f, -0.00736847f, -0.01140405f, -0.00113426f, 0.02694088f, 0.02990827f, -0.05359941f, -0.00363230f, 
    -0.04519049f, -0.01814466f, -0.01891780f, -0.04555644f, -0.02005520f, -0.03400628f, 0.00642886f, -0.02295783f, 
    0.02879400f, 0.00650699f, -0.02497232f, 0.02959865f, -0.00421609f, -0.02644833f, 0.03299007f, -0.03733905f, 
    -0.00357941f, -0.01533301f, -0.03252436f, -0.02506599f, -0.02245876f, 0.03359678f, -0.03305645f, -0.03143681f, 
    0.02339195f, 0.00568865f, -0.02451552f, -0.04796964f, -0.03364225f, -0.01332786f, -0.03375589f, 0.04316602f, 
    -0.03132565f, -0.03391877f, -0.03989669f, -0.02632502f, 0.00642506f, 0.00143356f, 0.03217951f, -0.01137001f, 
    -0.04572950f, -0.04376524f, 0.01528574f, 0.01670592f, 0.02085920f, 0.03208141f, 0.00966821f, -0.02921683f, 
    0.04760907f, -0.00011325f, -0.03250742f, -0.01667660f, -0.02665184f, -0.04627858f, -0.03849721f, -0.05195215f, 
    0.00736604f, -0.06037891f, -0.01514912f, 0.03894457f, -0.03169579f, -0.00142767f, 0.00827091f, -0.01885191f, 
    0.03737322f, -0.05072036f, 0.03374854f, 0.01310156f, -0.04003230f, -0.00749929f, -0.04654163f, 0.04827734f, 
    -0.01922676f, -0.00999498f, -0.02044744f, -0.03738745f, -0.00196383f, 0.00386441f, 0.01104694f, -0.04066188f, 
    -0.04134995f, 0.03905436f, 0.02790681f, -0.00043447f, -0.03012306f, 0.03309508f, -0.02787957f, -0.02997353f, 
    0.04476334f, -0.02823529f, 0.02416902f, 0.01331029f, 0.04833000f, -0.00696623f, -0.01978457f, 0.01138764f, 
    0.00649130f, -0.00708780f, -0.00122865f, -0.03198827f, 0.01686570f, -0.01275358f, -0.03012113f, 0.04003263f, 
    0.00570814f, 0.01197726f, 0.03406155f, -0.04394927f, -0.03080864f, 0.05273633f, 0.03488789f, 0.04171297f, 
    0.01706226f, -0.00490011f, -0.05319007f, 0.01837110f, -0.01728008f, -0.03421034f, 0.01241357f, 0.00730226f, 
    -0.02943479f, 0.04127979f, -0.02663824f, -0.00937090f, -0.04740829f, -0.01022797f, -0.02531035f, 0.01100773f, 
    -0.04952084f, -0.05324351f, -0.02685640f, 0.04618618f, 0.03552552f, 0.03457862f, 0.03179611f, -0.03768168f, 
    0.03704147f, -0.02444522f, -0.04148376f, -0.04315651f, -0.00995489f, -0.02045630f, -0.05063933f, 0.02669089f, 
    0.00367090f, -0.04753292f, -0.05304642f, -0.02629966f, 0.04603224f, -0.04440442f, -0.03799121f, -0.04649625f, 
    0.02473960f, -0.02126525f, -0.05159583f, -0.00586767f, -0.01575427f, -0.04282061f, -0.01455013f, 0.04546627f, 
    0.04049424f, -0.04685848f, 0.04051875f, -0.02119984f, 0.02240026f, -0.03298705f, 0.02427864f, 0.01690538f, 
    0.01133482f, -0.02894908f, 0.03078977f, -0.01629092f, -0.04427614f, -0.03117950f, 0.01934191f, 0.00214845f, 
    0.04248465f, 0.00583180f, -0.04618509f, -0.00352721f, 0.03584397f, 0.04105445f, 0.02290372f, 0.01092784f, 
    -0.04511495f, -0.04542423f, 0.00650064f, 0.01317910f, -0.00992232f, 0.00111559f, 0.02920689f, -0.00544255f, 
    -0.02171439f, 0.03021616f, 0.01715359f, -0.00484220f, -0.05242312f, -0.02749984f, -0.01829480f, 0.02345054f, 
    0.02343475f, -0.00988696f, -0.00970836f, -0.03103362f, -0.04559546f, 0.05933824f, 0.01066117f, 0.05105120f, 
    0.00641156f, 0.02698991f, 0.04177839f, 0.03465382f, -0.01444927f, 0.01641303f, -0.05304487f, 0.00273560f, 
    -0.00930871f, 0.04143577f, 0.01932149f, 0.03902284f, 0.00378761f, -0.04615638f, -0.04159569f, -0.03703329f, 
    -0.03111347f, -0.01214739f, -0.02660176f, 0.03953613f, 0.01422122f, -0.01049258f, -0.01748876f, 0.02840537f, 
    -0.04482109f, 0.03526533f, -0.05067021f, -0.02330289f, -0.00377612f, 0.02008880f, -0.02718066f, -0.03006813f, 
    0.03669407f, 0.03375877f, -0.01560620f, -0.02125678f, 0.00414715f, -0.03390572f, -0.04093165f, -0.01079286f, 
    0.02729589f, -0.05709050f, -0.00789920f, 0.02002668f, 0.04531849f, -0.01653976f, -0.00510753f, 0.05079086f, 
    0.00212585f, -0.01961552f, 0.01679274f, 0.04144011f, -0.01204772f, -0.04602886f, -0.04546854f, 0.02144099f, 
    0.03423914f, 0.00710432f, -0.02978168f, -0.04010990f, 0.04823770f, -0.01820150f, -0.03827221f, 0.03384122f, 
    -0.03618535f, -0.03625572f, -0.03479135f, 0.04145966f, -0.03490235f, 0.00371216f, -0.05480052f, 0.02923070f, 
    -0.00236548f, -0.02101295f, 0.02637197f, -0.03308201f, 0.03888810f, -0.03935719f, -0.03664111f, 0.01579842f, 
    -0.03480526f, -0.04399473f, 0.00619504f, 0.01030338f, -0.05320216f, -0.02982676f, -0.03196369f, -0.00048389f, 
    -0.04075607f, -0.02004872f, -0.05258191f, 0.01445229f, -0.04208654f, 0.01495063f, -0.01805638f, 0.01809991f, 
    -0.03043252f, -0.04349663f, -0.03069655f, -0.05197353f, -0.01397537f, 0.01203207f, 0.03852846f, 0.00558384f, 
    0.04583211f, 0.01226765f, 0.00531338f, 0.02926619f, -0.01510332f, -0.02100743f, -0.01668447f, 0.01782284f, 
    0.03713013f, -0.01301000f, 0.02260078f, 0.02643869f, 0.02786092f, 0.02374846f, 0.01919575f, -0.01366130f, 
    0.01761144f, 0.02910297f, 0.00749940f, 0.00661820f, -0.00313832f, -0.02997632f, 0.00351946f, -0.01960150f, 
    -0.11093555f, 0.06222594f, -0.08861100f, 0.09221788f, -0.01124675f, -0.07542636f, 0.04406919f, -0.00074961f, 
    0.00873789f, -0.13513964f, 0.03118287f, -0.01386470f, 0.19402549f, -0.16348976f, 0.05608958f, -0.19943443f, 
    -0.16232508f, -0.20885266f, -0.18787326f, -0.12826183f, 0.03088833f, -0.04831951f, -0.02247120f, 0.08831859f, 
    -0.09950098f, 0.17668705f, 0.17644466f, 0.35541043f, 0.00877559f, 0.03622460f, -0.02929559f, -0.12656440f, 
    0.06155652f, 0.10962094f, 0.08251588f, -0.01795626f, 0.36393115f, -0.29167488f, -0.19760571f, -0.10813044f, 
    0.04015583f, -0.19194075f, -0.16290279f, -0.04317528f, 0.15896335f, 0.08027630f, 0.06288165f, 0.10480487f, 
    0.06210511f, -0.07374866f, 0.07966793f, -0.09186299f, 0.05625986f, 0.03311278f, 0.04645317f, 0.09307443f, 
    0.00362666f, 0.08221046f, 0.07195456f, 0.03464071f, 0.07778729f, 0.02093290f, 0.11878289f, 0.09673619f, 
    0.04551272f, -0.00287127f, 0.02597525f, -0.00124460f, -0.03925260f, 0.01581423f, 0.00661818f, -0.11919869f, 
    0.13529700f, 0.05240109f, -0.16239068f, -0.08435202f, -0.02328307f, -0.06009561f, 0.07308768f, 0.16997911f, 
    0.01497687f, 0.10744631f, -0.01383622f, 0.09395712f, 0.07523965f, 0.02572424f, -0.09264813f, -0.03115170f, 
    0.04062866f, -0.07738248f, 0.02771034f, -0.09101554f, -0.04414697f, -0.05118235f, -0.13994144f, -0.17657556f, 
    -0.11892424f, 0.04566891f, -0.23078725f, -0.05435649f, 0.12568584f, 0.12556636f, 0.01194552f, 0.10974311f, 
    0.04804279f, 0.00451064f, -0.10689144f, -0.08209374f, -0.23004881f, 0.06454995f, 0.04252798f, -0.15304707f, 
    -0.02769650f, 0.00899258f, -0.03892522f, 0.14436859f, 0.05100229f, 0.10826236f, 0.06894056f, 0.00040600f, 
    -0.15128855f, -0.06705846f, 0.08512011f, -0.09039002f, -0.10937256f, -0.00397458f, -0.09371894f, -0.01755852f, 
    0.15070835f, 0.14939715f, 0.06688838f, 0.03573614f, 0.08306286f, 0.08057672f, 0.09806684f, 0.07170543f, 
    0.04772683f, 0.01023595f, 0.07809903f, 0.08630694f, 0.17911223f, 0.03367005f, 0.02992678f, 0.15467204f, 
    0.07319894f, -0.13321325f, -0.15409403f, -0.22892153f, -0.10895543f, -0.02739894f, -0.09665716f, 0.12294469f, 
    0.11177924f, 0.06147413f, 0.12152799f, 0.08066845f, 0.04214894f, -0.00677833f, 0.12832566f, 0.03757573f, 
    -0.07777467f, 0.14692307f, -0.11021492f, 0.00597138f, -0.02857193f, -0.00098846f, 0.01977781f, -0.13223948f, 
    0.27768674f, -0.24010670f, -0.22875449f, -0.44368452f, -0.02261542f, -0.26784542f, -0.00831277f, -0.03113758f, 
    -0.02681490f, 0.03880335f, -0.01374563f, -0.02911646f, 0.28354749f, 0.07779118f, 0.11315448f, 0.14011087f, 
    0.10493062f, -0.02518025f, 0.09254619f, 0.21086785f, 0.05064380f, -0.07049078f, 0.10282612f, 0.03053192f, 
    -0.23500659f, -0.04824615f, -0.14814633f, 0.16563532f, -0.10143081f, 0.11825942f, 0.13312913f, 0.11673364f, 
    0.02682625f, 0.02689029f, 0.11830329f, 0.11230714f, 0.01619881f, 0.06709128f, 0.06494157f, 0.13470541f, 
    -0.08858962f, 0.00884069f, -0.09018151f, -0.04434293f, 0.07545985f, -0.02356530f, -0.12686895f, -0.06204487f, 
    -0.19982071f, 0.25985605f, -0.22615777f, -0.04133292f, -0.11230195f, 0.09658689f, 0.04416419f, -0.04142178f, 
    0.07646396f, 0.06123714f, 0.05533884f, 0.07883122f, -0.12790357f, 0.02143686f, -0.09562794f, 0.27440137f, 
    -0.01178158f, 0.08678562f, 0.01732432f, -0.03551117f, -0.05873216f, -0.02573723f, -0.00699031f, 0.06244034f, 
    0.09402920f, -0.03936829f, 0.02050476f, -0.15781005f, -0.03705012f, -0.01820041f, 0.17642669f, 0.13218139f, 
    0.04610158f, 0.11292779f, -0.00132099f, 0.00128933f, -0.07823920f, 0.06415211f, -0.08390170f, 0.08577058f, 
    -0.03609205f, -0.02990412f, 0.17902251f, -0.36895961f, 0.03263699f, 0.08847413f, -0.07367527f, 0.01856508f, 
    -0.01928118f, 0.08796877f, -0.05669236f, -0.20126697f, -0.15635620f, -0.04198405f, 0.00634710f, -0.14088520f, 
    -0.01688940f, 0.09096025f, -0.07047781f, -0.00888621f, 0.24081710f, 0.07484986f, 0.03937859f, -0.02006732f, 
    -0.02791767f, -0.09958698f, -0.05945618f, -0.12026271f, -0.02551097f, -0.10333950f, 0.01039926f, -0.08360957f, 
    0.01875273f, 0.29003415f, -0.07942482f, 0.31157562f, -0.04571846f, -0.08585951f, -0.07919526f, -0.00861368f, 
    -0.11580893f, -0.12857789f, 0.05488804f, -0.05400792f, -0.15942997f, -0.06872144f, -0.04643171f, -0.33433419f, 
    -0.09517143f, 0.15099184f, -0.02316038f, -0.03627577f, 0.04223344f, -0.16708858f, -0.08680212f, -0.04652536f, 
    -0.35272485f, 0.34775698f, -0.08844365f, -0.10199916f, 0.10269012f, -0.03158870f, 0.08125967f, -0.04465267f, 
    -0.09841137f, -0.08164032f, -0.00983428f, -0.01006481f, 0.24939340f, 0.01086897f, -0.10839485f, 0.00970481f, 
    0.11491848f, 0.02178043f, 0.10063393f, 0.15799969f, -0.04882260f, -0.07460912f, -0.12104601f, -0.05252784f, 
    -0.23813701f, 0.06295961f, -0.07257795f, -0.29683635f, 0.11964932f, -0.05305293f, 0.11786585f, 0.24965084f, 
    -0.10496505f, 0.12733090f, -0.04833199f, -0.10505604f, 0.14177489f, -0.00326254f, -0.06471258f, -0.05365898f, 
    -0.01004127f, -0.07728979f, -0.08038151f, 0.12495657f, -0.03381491f, 0.11095323f, 0.06466469f, -0.03436856f, 
    0.12463953f, 0.45847526f, 0.03893134f, 0.14240742f, 0.12318482f, -0.11817767f, 0.05790005f, 0.09681008f, 
    0.00565362f, -0.07601152f, 0.03959075f, 0.00611428f, 0.25025633f, -0.08442658f, 0.10156345f, -0.03281148f, 
    0.00428438f, -0.08085591f, -0.08774904f, 0.02168995f, 0.05034545f, 0.03743589f, 0.16410270f, 0.02726454f, 
    0.14690104f, 0.03675485f, 0.18828006f, -0.05663253f, -0.10036628f, 0.15353653f, -0.00209974f, -0.05085158f, 
    -0.02880810f, 0.09972846f, 0.10270943f, -0.12560737f, -0.05502102f, -0.17087489f, -0.25118414f, -0.01491272f, 
    0.07519820f, 0.06055222f, 0.11343139f, 0.07013616f, 0.04588286f, 0.00520991f, 0.15689187f, -0.19692305f, 
    0.25953931f, -0.01232685f, -0.03145484f, -0.21746196f, 0.01938436f, -0.08754679f, -0.04093993f, -0.07361937f, 
    0.01072889f, 0.02820710f, 0.08134498f, 0.09950098f, -0.14148968f, 0.06918727f, -0.16086242f, 0.12165304f, 
    0.08029414f, 0.06715727f, 0.02909111f, 0.09323596f, -0.10417376f, 0.06786560f, -0.08533584f, -0.11105404f, 
    0.07215460f, -0.05296773f, 0.20442602f, 0.16939448f, 0.08600018f, 0.03400932f, -0.02116118f, 0.02371624f, 
    0.07218803f, 0.02011434f, -0.00662711f, -0.06152307f, 0.00451032f, -0.01507378f, 0.06030842f, 0.07176370f, 
    -0.05734636f, -0.03593884f, -0.10125624f, 0.00134532f, -0.07478359f, 0.07100823f, 0.04492898f, 0.09855609f, 
    0.16544469f, 0.04253454f, 0.16851030f, 0.19982067f, -0.15830688f, 0.06245071f, 0.01471531f, -0.04188339f, 
    0.01403169f, -0.00901117f, 0.00452805f, 0.03638896f, 0.18380912f, -0.11488485f, 0.09772928f, -0.03824375f, 
    0.00832003f, 0.00368743f, -0.14922871f, 0.13794881f, -0.05252205f, -0.03649688f, 0.13305986f, -0.03855313f, 
    -0.08643084f, -0.09684819f, 0.16338073f, 0.10585380f, -0.07582885f, 0.02209489f, 0.03806546f, 0.15319711f, 
    -0.14217043f, -0.02308960f, 0.11588794f, -0.01603490f, 0.14959575f, -0.04400636f, 0.13084701f, 0.19232810f, 
    -0.06353851f, -0.08499879f, -0.01545248f, 0.13046105f, -0.02830376f, 0.00460950f, -0.06925216f, -0.07721035f, 
    0.34858513f, -0.30038992f, 0.28006801f, -0.34176454f, 0.03328235f, 0.02114172f, 0.14400581f, 0.02690918f, 
    -0.03355005f, -0.12734655f, 0.04819016f, -0.08564781f, -0.07014935f, -0.00207599f, -0.09773233f, -0.06868633f, 
    -0.03433859f, -0.04118675f, 0.03113545f, 0.04294563f, -0.05029190f, 0.02154478f, -0.09525415f, -0.12574096f, 
    -0.06475918f, -0.27612263f, -0.32085630f, -0.02147630f, -0.05170781f, -0.01753289f, 0.08318791f, -0.07144249f, 
    -0.04870111f, 0.05613049f, 0.10771788f, 0.11929168f, -0.14024082f, -0.05138329f, 0.04411681f, -0.00179867f, 
    -0.04661390f, -0.04821750f, 0.06267115f, -0.11755395f, 0.04306621f, -0.00713871f, -0.04420109f, 0.07505680f, 
    -0.17078359f, 0.10603233f, 0.10511602f, 0.13782451f, 0.11607733f, 0.01559751f, 0.07155606f, 0.15644664f, 
    0.13110206f, 0.05916969f, -0.01242623f, 0.10519192f, -0.06612562f, -0.04151699f, 0.04647504f, 0.07117086f, 
    -0.12815481f, 0.05367647f, 0.00147934f, 0.11491457f, 0.00771843f, 0.06773205f, -0.11680129f, -0.06565493f, 
    0.27491558f, -0.15711163f, -0.03922675f, -0.12319303f, 0.01588129f, -0.23711868f, 0.18501367f, -0.24703629f, 
    0.03691823f, 0.01593414f, 0.03963833f, 0.03518468f, -0.09231133f, -0.07342686f, 0.03666145f, -0.07875238f, 
    -0.07137997f, -0.03192229f, 0.04773939f, 0.00043349f, -0.04120380f, -0.06993251f, 0.03712118f, 0.10823170f, 
    0.05737492f, -0.44716629f, 0.43524012f, 0.11687108f, 0.08982316f, -0.05445541f, 0.08150117f, 0.08636221f, 
    0.03627074f, -0.02575579f, 0.05879562f, 0.00306099f, -0.21611917f, 0.22192888f, -0.06633777f, -0.10715564f, 
    0.04573916f, 0.12455026f, 0.19667912f, -0.00438164f, 0.13132645f, 0.13148534f, -0.03122950f, 0.01476982f, 
    -0.55321503f, -0.16320103f, 0.19166553f, 0.56551754f, -0.01872386f, 0.09116980f, 0.04491826f, 0.05065063f, 
    -0.16144510f, -0.14150482f, 0.06632550f, 0.08691250f, 0.46452057f, -0.18641925f, -0.00741861f, -0.01770238f, 
    -0.04897615f, -0.13102698f, 0.09126943f, 0.05466240f, 0.04552820f, 0.07385944f, -0.04115571f, -0.06788141f, 
    -0.08750569f, 0.27418453f, 0.02829357f, 0.23388632f, -0.02331101f, -0.02202236f, 0.05824003f, 0.07881988f, 
    -0.01981121f, 0.03504694f, 0.25996491f, -0.00000267f, -0.24829707f, 0.06922870f, -0.16344935f, -0.13253196f, 
    0.05845880f, -0.01327459f, 0.00415165f, -0.07698341f, 0.17265344f, 0.15765943f, 0.08628640f, 0.25590900f, 
    0.27313954f, -0.30594575f, 0.33939257f, -0.20364025f, 0.01801457f, -0.03468930f, -0.09769122f, -0.07610650f, 
    0.03052512f, -0.07263963f, 0.00972551f, 0.14749089f, -0.03698689f, 0.13957854f, -0.08330945f, -0.10805294f, 
    0.08913030f, -0.01281381f, -0.00746094f, -0.13777606f, 0.01176819f, 0.03970363f, -0.02188051f, -0.06113582f, 
    0.13552323f, -0.04082428f, 0.16159031f, -0.16239254f, 0.08426692f, 0.07962612f, 0.03438191f, 0.04380739f, 
    0.00105925f, 0.04648820f, 0.11690222f, -0.01256532f, 0.08658681f, -0.00175477f, 0.59288776f, 0.18290289f, 
    -0.07056213f, -0.01247064f, 0.12863335f, 0.05622626f, 0.03687477f, -0.01405921f, 0.03296496f, -0.05483987f, 
    0.03516886f, -0.07308902f, 0.43074417f, 0.30075419f, 0.07066111f, 0.03156180f, -0.21844195f, 0.15329979f, 
    -0.03898588f, -0.09495641f, 0.00663531f, -0.10242960f, -0.56501967f, 0.64466727f, -0.26732510f, 0.21750638f, 
    0.10780489f, 0.07421333f, 0.03208109f, -0.17395560f, -0.15628985f, -0.01182933f, 0.07059301f, 0.08155060f, 
    0.18433054f, -0.21815965f, 0.27190199f, 0.10584211f, -0.03295359f, 0.13855682f, 0.09562496f, 0.17903222f, 
    -0.06698715f, 0.14013591f, -0.05193324f, -0.10193355f, -0.08143084f, 0.12165022f, -0.03922159f, 0.19284602f, 
    -0.02945368f, 0.04819438f, -0.04613202f, 0.04552890f, -0.07938977f, 0.02478039f, 0.01217057f, 0.02170964f, 
    0.09195432f, -0.06138983f, -0.20944759f, 0.02847051f, -0.02596506f, -0.02716924f, 0.09385706f, 0.03319456f, 
    -0.02096378f, 0.05386380f, 0.03855048f, 0.13191059f, 0.15697527f, -0.21526143f, -0.32880068f, -0.19969432f, 
    0.03452428f, -0.10350189f, -0.04320068f, -0.05466905f, 0.02980464f, -0.13882415f, 0.06819445f, 0.04823364f, 
    0.18740402f, -0.00584776f, 0.13794200f, -0.12767586f, 0.01932310f, 0.00104651f, -0.05662417f, -0.05205163f, 
    0.15918787f, -0.02557341f, -0.15271679f, 0.04142535f, -0.10531596f, -0.32053271f, -0.29960632f, -0.12870355f, 
    0.05433097f, 0.08723907f, 0.02273799f, 0.06136573f, 0.08121710f, 0.00452085f, -0.02321558f, -0.12388027f, 
    -0.02772877f, -0.05885483f, 0.04480496f, -0.02747881f, -0.01296412f, 0.07862545f, 0.02333130f, -0.02125927f, 
    -0.00603252f, 0.02517799f, -0.06722280f, -0.02427936f, 0.02669103f, 0.23686950f, 0.44130355f, 0.15822139f, 
    -0.11610754f, -0.03497660f, -0.07214421f, -0.10533667f, -0.04607147f, -0.02210886f, 0.05634880f, 0.02195255f, 
    0.04343111f, -0.05664190f, 0.14685944f, -0.02875933f, 0.04122636f, -0.04434359f, -0.00178186f, 0.11620819f, 
    -0.04224161f, 0.00264595f, -0.04342853f, 0.03480681f, -0.10271087f, 0.03428557f, 0.19579507f, 0.04584077f, 
    0.02176696f, -0.09792810f, -0.10632076f, -0.02323557f, -0.06641898f, -0.01504002f, -0.04605214f, 0.00723750f, 
    -0.11354399f, -0.09259266f, -0.14840589f, 0.02107090f, 0.04083459f, 0.07589334f, 0.07162670f, 0.11856776f, 
    0.06498486f, 0.03942564f, -0.01785321f, -0.00358780f, -0.06191690f, -0.09166399f, -0.08083842f, 0.17510170f, 
    0.06998421f, 0.23827067f, 0.22722107f, 0.12392381f, 0.03669090f, -0.03156376f, 0.01457569f, 0.03014907f, 
    0.09705570f, -0.14649716f, -0.10275894f, 0.05161500f, 0.05157159f, -0.04376712f, -0.06927156f, 0.05001971f, 
    -0.13090214f, 0.02633941f, -0.06821129f, -0.01982682f, -0.00916006f, -0.02875260f, 0.02897136f, 0.06293716f, 
    0.00936092f, 0.03126617f, -0.03808454f, 0.02415706f, -0.07705500f, -0.18811342f, -0.23425247f, -0.29323700f, 
    0.22361420f, 0.08225489f, 0.17909360f, 0.12241286f, 0.15840888f, 0.06018901f, -0.09267626f, 0.02805685f, 
    0.03111118f, 0.04475362f, 0.00876023f, -0.01593788f, 0.11499394f, 0.13517697f, -0.03742854f, -0.09141123f, 
    -0.15547976f, -0.08440577f, -0.03870649f, 0.02134437f, 0.08427159f, 0.02286931f, 0.01171568f, 0.05186183f, 
    -0.01028228f, -0.22132491f, -0.18480307f, -0.14798808f, -0.02997841f, 0.08596820f, 0.02771927f, 0.02254509f, 
    0.18337610f, 0.00367955f, 0.07605612f, 0.01396190f, 0.20178302f, 0.18658899f, 0.13861282f, 0.14807501f, 
    -0.10780145f, -0.04925767f, -0.05016060f, -0.07410528f, -0.00515850f, 0.03461014f, -0.05172744f, 0.10521768f, 
    0.09588256f, 0.00019409f, 0.28215209f, 0.21041979f, 0.14857709f, 0.01346729f, -0.00664174f, 0.18745327f, 
    0.00329177f, 0.12185247f, -0.00028542f, 0.09480342f, 0.16919440f, 0.25398922f, -0.10668740f, -0.00755188f, 
    -0.08894076f, -0.00090348f, -0.13379574f, -0.05579658f, 0.04346922f, -0.00751942f, 0.07960854f, 0.01097674f, 
    0.31099483f, 0.30069894f, 0.07505254f, -0.07016452f, -0.04992283f, 0.03392716f, -0.10349313f, -0.00459533f, 
    0.12382441f, 0.24190383f, 0.11058317f, -0.10673369f, 0.04717023f, 0.07836653f, 0.10572278f, 0.13381332f, 
    0.17629966f, 0.03353980f, -0.03364852f, 0.00731310f, 0.01634964f, 0.08316896f, 0.08311068f, -0.26613161f, 
    -0.17566052f, -0.07695431f, 0.09845993f, 0.09820838f, -0.10808291f, 0.17867664f, -0.12566550f, 0.12347998f, 
    0.11550405f, 0.08591671f, -0.00348507f, -0.04189243f, 0.04103380f, -0.22034539f, 0.15596433f, -0.08009263f, 
    -0.01920853f, -0.13310330f, -0.11315098f, 0.07017127f, -0.02645358f, -0.11172040f, 0.10673454f, -0.05675930f, 
    -0.06213162f, -0.04746525f, -0.05417258f, 0.13625303f, -0.06080725f, 0.07415078f, 0.02248169f, 0.03525000f, 
    0.09515538f, -0.05736799f, 0.08497912f, 0.19593748f, 0.04081168f, -0.11642078f, -0.03124045f, -0.13346498f, 
    -0.05018397f, -0.03473639f, -0.00066111f, -0.02526795f, 0.01446417f, 0.12144308f, 0.16902326f, 0.11448689f, 
    0.39685348f, -0.02042175f, -0.04526030f, 0.43043575f, -0.09797312f, 0.01791304f, -0.04524825f, -0.01772973f, 
    -0.04037499f, -0.02352553f, -0.01896801f, -0.00104343f, -0.12090848f, -0.12513232f, -0.02312716f, -0.08142448f, 
    0.13936317f, 0.09010523f, -0.03751378f, 0.13609488f, 0.00728708f, 0.05927090f, -0.01673963f, 0.08228851f, 
    -0.02150402f, 0.28699440f, -0.09166749f, -0.09352920f, 0.19016980f, -0.05998734f, 0.01581396f, 0.00652292f, 
    0.00950804f, -0.02396506f, 0.00628126f, 0.15483761f, 0.37210014f, 0.27864411f, 0.01053550f, 0.06874880f, 
    -0.00665067f, -0.14626810f, -0.36045399f, -0.11357390f, -0.06586052f, 0.04986094f, 0.04802353f, -0.00986786f, 
    0.14204435f, -0.08223765f, -0.07702389f, 0.16177876f, 0.08885458f, 0.06453582f, 0.13673130f, -0.01420550f, 
    0.06347817f, -0.05140232f, -0.11345244f, 0.03475330f, -0.02020955f, 0.38074958f, -0.21689402f, -0.15922773f, 
    0.01281858f, -0.10292044f, 0.07641207f, -0.04131171f, 0.12712625f, -0.11127650f, -0.02431951f, 0.04341868f, 
    -0.10827843f, 0.02782414f, 0.34964609f, 0.23712909f, 0.01779932f, -0.03286654f, -0.03715428f, 0.02793460f, 
    0.06504996f, -0.22429334f, 0.18566090f, -0.02188138f, 0.00408314f, -0.10103880f, 0.07236918f, 0.04826269f, 
    0.04412350f, -0.01245519f, -0.06230997f, -0.01943790f, 0.03790520f, 0.16467901f, -0.06228650f, -0.18153726f, 
    0.00347170f, 0.17555845f, -0.29256085f, 0.13711904f, -0.11108035f, -0.12605418f, -0.04143443f, -0.00504915f, 
    0.04913412f, 0.03864004f, -0.11721591f, -0.25841546f, 0.16557287f, -0.10454299f, -0.08791023f, -0.17677735f, 
    0.20292528f, 0.13316421f, -0.01132212f, 0.05801456f, 0.05344188f, -0.04338087f, 0.08625338f, 0.11609041f, 
    0.06978720f, -0.00883426f, 0.35700125f, 0.00674849f, -0.06671245f, 0.04745880f, 0.04894588f, -0.00136171f, 
    -0.04590967f, 0.06857688f, 0.04619140f, 0.03434164f, 0.03037788f, -0.07946625f, -0.16416632f, -0.07026798f, 
    0.19906920f, 0.00566365f, 0.00689176f, 0.16166458f, -0.04712927f, -0.05288669f, 0.03335721f, 0.07349404f, 
    0.21344388f, 0.13223097f, -0.12833929f, -0.15991625f, 0.22057766f, 0.05770789f, -0.01271529f, 0.20545517f, 
    -0.14750588f, 0.04763101f, 0.05164131f, -0.02817110f, -0.12214807f, -0.00298252f, -0.09037839f, 0.25215665f, 
    -0.01413400f, -0.04748649f, -0.07988341f, -0.06802714f, -0.04661740f, 0.03157540f, 0.01007864f, 0.03595359f, 
    -0.06345423f, 0.17966911f, 0.14296439f, 0.05681679f, -0.11830536f, -0.00551954f, 0.04311678f, 0.05968567f, 
    0.06908930f, 0.07553665f, -0.07071017f, -0.03963681f, -0.04115652f, -0.26626396f, 0.06066553f, -0.10458086f, 
    -0.05845635f, 0.04206822f, -0.18784583f, -0.02257346f, 0.04428221f, -0.10576888f, -0.14686231f, -0.01813946f, 
    -0.40464282f, 0.03650826f, -0.17549793f, -0.02120578f, 0.01282507f, -0.10159550f, -0.17970355f, 0.08273458f, 
    -0.04374885f, -0.01677490f, -0.01437914f, 0.00417382f, 0.19679925f, 0.09881622f, -0.21379924f, -0.20349558f, 
    0.26078117f, 0.02730510f, 0.06605493f, 0.02889276f, -0.01480524f, -0.03634007f, 0.07372678f, -0.10280136f, 
    0.21985735f, 0.06604116f, -0.01553019f, -0.02108533f, 0.01331723f, 0.15391254f, -0.02457910f, 0.02139643f, 
    0.26278710f, -0.01330126f, 0.05691159f, 0.09205098f, -0.11343284f, -0.13721655f, -0.04735126f, 0.15874599f, 
    0.02814952f, 0.13736884f, 0.05080884f, 0.08809847f, 0.09846998f, 0.01811367f, 0.03628859f, -0.00577567f, 
    0.03500365f, 0.05768105f, 0.00958683f, -0.14678112f, 0.14805277f, -0.00501432f, 0.01176230f, 0.20626046f, 
    -0.00518152f, -0.00750159f, 0.07612829f, 0.04013461f, -0.11490346f, 0.23251654f, -0.10825691f, -0.14539787f, 
    -0.08659796f, 0.06071809f, 0.14079686f, 0.01906727f, 0.14320193f, -0.01839562f, 0.09616275f, -0.06114482f, 
    -0.09600171f, -0.24050535f, -0.16808943f, -0.00460179f, 0.10188991f, 0.06818678f, 0.04933287f, -0.13015157f, 
    0.01158128f, 0.00960908f, -0.10041084f, -0.02186825f, -0.11041688f, 0.08076104f, -0.11668321f, 0.20173697f, 
    0.00921109f, 0.01397234f, -0.03745064f, 0.16536555f, 0.06700806f, 0.06791768f, 0.03945022f, 0.00479222f, 
    0.14164509f, 0.14968817f, 0.18834133f, -0.05202822f, -0.05834284f, 0.22290829f, 0.05504609f, 0.01916366f, 
    0.04510618f, -0.03908859f, -0.03972443f, -0.11441169f, -0.06455330f, 0.07353064f, 0.02503728f, -0.13823217f, 
    0.04230953f, -0.18438254f, -0.03309298f, 0.02630284f, 0.10196792f, -0.13226038f, 0.06723721f, -0.00651928f, 
    -0.13728946f, 0.08236825f, -0.25932351f, 0.07739677f, -0.11809444f, 0.09946271f, -0.04035424f, 0.13274579f, 
    -0.00599743f, 0.10006522f, 0.04550165f, 0.23732425f, 0.15975693f, 0.12277190f, 0.22683130f, 0.10746498f, 
    0.03995446f, 0.10077313f, 0.04960676f, 0.16771783f, -0.04178622f, -0.03113361f, -0.07867057f, -0.06771269f, 
    -0.31767023f, -0.02784282f, 0.02427255f, 0.15171379f, -0.11134394f, 0.17631178f, -0.07098161f, 0.09967120f, 
    0.08935931f, 0.01239190f, -0.04502527f, 0.04525875f, -0.08693717f, 0.07713759f, 0.23888284f, 0.19349742f, 
    -0.08098929f, 0.02527684f, 0.01431939f, -0.01522833f, -0.01626956f, 0.04352271f, 0.10579746f, 0.05104047f, 
    -0.17979933f, 0.18378469f, -0.35271135f, -0.04166983f, 0.15911503f, 0.02447409f, -0.07598316f, -0.21972057f, 
    -0.07619531f, 0.01271463f, -0.08444154f, -0.03200283f, 0.00954763f, -0.08745757f, -0.01535485f, -0.05596396f, 
    -0.02615546f, -0.22095224f, -0.08022793f, -0.11850102f, 0.10450719f, 0.08699639f, 0.10397524f, -0.06995598f, 
    0.24437684f, 0.12628148f, -0.32775643f, 0.03270082f, 0.04757094f, 0.10266652f, -0.07996009f, 0.01428058f, 
    0.00638710f, -0.15831557f, 0.03558212f, 0.13789977f, 0.15790200f, 0.05670208f, 0.23282726f, -0.27536929f, 
    0.20891693f, 0.13346648f, -0.08281708f, -0.02292769f, 0.07427469f, 0.01173723f, -0.26692331f, -0.07682535f, 
    0.14235584f, 0.44975084f, -0.06264914f, -0.08397681f, 0.09197659f, -0.06310959f, 0.00963812f, 0.31388968f, 
    -0.19170530f, -0.06161059f, -0.06968405f, 0.10333467f, -0.37864906f, 0.04668612f, 0.22821182f, 0.05259994f, 
    0.04105722f, -0.03100877f, -0.16840461f, 0.13725744f, 0.07037422f, 0.01011205f, 0.01928423f, -0.10541204f, 
    -0.02023551f, 0.18617417f, -0.06783071f, 0.08740993f, 0.13925509f, 0.00556488f, -0.03102907f, 0.14681572f, 
    -0.12428872f, 0.13900676f, 0.00687438f, 0.08929477f, -0.11097105f, 0.40135288f, -0.08064975f, -0.29590821f, 
    0.04347380f, -0.11159678f, 0.13992478f, -0.08072171f, -0.09266366f, 0.08047654f, 0.03125732f, -0.00337997f, 
    0.04386274f, 0.06069919f, 0.24921282f, 0.18244207f, 0.03554132f, 0.07571149f, 0.02702899f, -0.01128655f, 
    0.02916368f, 0.04604491f, -0.01776942f, -0.14919196f, -0.18749346f, -0.13722587f, 0.03987538f, 0.13872682f, 
    -0.09338699f, -0.05513559f, -0.08078945f, 0.00835384f, -0.03319372f, 0.15264794f, -0.03594655f, 0.05911455f, 
    -0.01686205f, -0.00081595f, 0.02171493f, -0.06215950f, -0.00661378f, -0.03402113f, -0.01443934f, 0.00513066f, 
    -0.03714564f, -0.02333556f, -0.05203500f, 0.00731565f, -0.02415315f, -0.06696248f, -0.06627449f, -0.05760952f, 
    0.00583940f, -0.02126228f, -0.03955304f, -0.07793611f, -0.00918026f, 0.00337470f, -0.05806784f, -0.06965304f, 
    -0.04217295f, 0.04750428f, -0.06208823f, 0.00148814f, 0.00965981f, 0.02502333f, -0.05977725f, -0.03477939f, 
    -0.01242262f, 0.00809900f, -0.07264592f, -0.01866193f, -0.04277928f, -0.02950396f, -0.06956899f, -0.06211973f, 
    -0.07057641f, -0.07853766f, -0.06880906f, -0.01351206f, -0.00385438f, -0.06039301f, -0.02714810f, 0.02055376f, 
    -0.04460225f, -0.02936726f, -0.05597919f, 0.01031260f, -0.04172485f, -0.07635674f, 0.00405770f, -0.03342960f, 
    0.03128987f, -0.00533764f, -0.00846702f, -0.04036982f, -0.00979164f, -0.02292711f, -0.05114925f, -0.01213502f, 
    0.01716798f, -0.06347480f, -0.07311761f, -0.06562959f, -0.04111934f, -0.02018001f, -0.05546281f, 0.01570600f, 
    -0.03603494f, -0.00031892f, 0.03673108f, 0.02887912f, 0.05965255f, 0.00557557f, -0.02545759f, 0.01337522f, 
    0.02452991f, 0.00007553f, -0.01697315f, -0.03301352f, -0.05922268f, -0.01659981f, -0.00205778f, 0.02095469f, 
    -0.03809716f, -0.04723616f, -0.04754610f, -0.01707330f, -0.07011773f, -0.01328824f, -0.03395797f, 0.00403906f, 
    -0.00335731f, 0.01984784f, -0.07115034f, 0.02144573f, -0.01619032f, 0.01239848f, -0.06588281f, -0.00363394f, 
    0.05850815f, -0.05568872f, 0.01644326f, -0.03826641f, -0.06257743f, -0.07390386f, -0.06169976f, 0.01320125f, 
    -0.03887897f, -0.04606162f, 0.00169307f, -0.01673672f, 0.02551700f, 0.02870470f, 0.03623006f, -0.05818940f, 
    -0.03184839f, 0.02203871f, -0.01140026f, -0.02199500f, -0.05068127f, -0.04933284f, -0.06704398f, -0.06773883f, 
    -0.05349043f, -0.03721824f, -0.05852112f, -0.00818078f, 0.01111047f, 0.01085978f, -0.02219222f, -0.01869333f, 
    -0.03347029f, -0.02003527f, 0.02132355f, -0.05453002f, -0.00976693f, -0.03583428f, -0.01032729f, -0.02139398f, 
    -0.03973802f, 0.03496997f, -0.05423628f, -0.05944039f, -0.00240361f, 0.05604175f, 0.03330498f, 0.00998068f, 
    -0.03770072f, 0.02472570f, -0.01864893f, 0.00926510f, -0.06039738f, 0.00482655f, -0.07464348f, 0.00040069f, 
    -0.07601773f, -0.05602347f, -0.07121120f, 0.01186532f, -0.05990724f, -0.07405932f, -0.03853082f, -0.00269191f, 
    -0.06393930f, -0.04022092f, 0.00196339f, -0.05093968f, -0.00682756f, -0.07029270f, -0.02297452f, -0.00985117f, 
    -0.04400060f, -0.02493879f, -0.07253718f, -0.03958435f, -0.02275555f, -0.07160363f, -0.07500449f, -0.05150868f, 
    -0.01851113f, -0.04646057f, -0.01756165f, -0.01469233f, -0.01485805f, -0.07974679f, -0.06248688f, -0.01088295f, 
    -0.03901725f, -0.00548043f, -0.04709336f, 0.00262117f, -0.01367214f, 0.03419791f, 0.02532506f, 0.00636606f, 
    0.04509458f, 0.01872846f, -0.04174597f, 0.02708204f, -0.01330125f, -0.02907584f, -0.03595673f, -0.02814779f, 
    -0.02986238f, -0.05490619f, -0.07185547f, -0.03430989f, -0.00562853f, -0.02069109f, -0.02269316f, -0.01442915f, 
    0.01641748f, 0.01418088f, -0.05514679f, -0.07373480f, -0.02670929f, -0.05080123f, 0.01430102f, 0.01705301f, 
    -0.07033830f, -0.02851476f, 0.00266992f, -0.05106368f, -0.02700342f, -0.05475188f, -0.02954787f, -0.06577808f, 
    -0.05137380f, 0.05513029f, 0.04854766f, 0.03598789f, -0.00603610f, -0.01674089f, -0.04159846f, -0.00397692f, 
    -0.06896167f, -0.00778197f, -0.05909332f, -0.00205481f, 0.01850791f, -0.03447002f, -0.05358262f, 0.00306256f, 
    0.01218518f, -0.08087824f, -0.02726604f, 0.01100044f, -0.07043201f, -0.07545071f, -0.07677932f, -0.06864806f, 
    -0.05737372f, -0.07332350f, 0.02273845f, -0.03098442f, 0.01839141f, -0.06445725f, 0.01533932f, -0.01019833f, 
    -0.06234856f, -0.06895336f, 0.01469882f, -0.03743773f, -0.04305367f, -0.01445510f, -0.07152412f, -0.01314049f, 
    0.02274307f, -0.06130677f, -0.07533897f, -0.07603779f, -0.05980648f, -0.04358677f, 0.01299779f, -0.00159846f, 
    -0.07135116f, -0.04241419f, -0.04726092f, -0.03893340f, -0.03616116f, -0.02476663f, -0.03976431f, -0.07919673f, 
    -0.01923871f, -0.05028678f, -0.06007553f, -0.01589526f, -0.01839577f, -0.01936792f, -0.07833902f, -0.04486280f, 
    -0.01295846f, -0.06848744f, -0.06312817f, -0.02387943f, -0.07826904f, -0.00324516f, -0.06030986f, -0.05871798f, 
    -0.01194416f, -0.02212712f, 0.01574793f, -0.07095680f, -0.05741988f, 0.00437242f, -0.00138974f, -0.01339410f, 
    0.02309015f, 0.01576361f, -0.07104620f, 0.00185723f, -0.01213046f, 0.01226073f, -0.00027964f, -0.01096032f, 
    -0.03026781f, 0.00959802f, -0.06776161f, -0.02424977f, -0.01225105f, 0.01735176f, 0.02180312f, -0.01447103f, 
    -0.06752445f, -0.01910684f, 0.05054140f, -0.04116758f, -0.06855608f, -0.04300201f, -0.05326179f, -0.03654601f, 
    -0.04198980f, -0.00088144f, 0.00285721f, 0.00063271f, 0.01427983f, -0.03009168f, -0.02856005f, -0.04980716f, 
    0.03579016f, -0.03673496f, 0.01202176f, -0.01400287f, -0.00252245f, -0.06110536f, -0.01703953f, -0.02330035f, 
    -0.01280505f, -0.00120780f, -0.01834328f, -0.03057871f, 0.00833234f, 0.00840028f, 0.00827294f, -0.04679412f, 
    -0.06544749f, -0.04270870f, -0.02248631f, 0.02368254f, -0.03691688f, -0.05151145f, -0.04021950f, -0.03972546f, 
    -0.03372027f, -0.07274672f, -0.03598339f, -0.02485438f, -0.01624125f, -0.00409781f, 0.05304851f, -0.05680524f, 
    0.02286157f, -0.06809226f, -0.06942400f, -0.06609720f, 0.01970317f, -0.03799792f, -0.05606425f, 0.00275471f, 
    0.18165426f, 0.02661398f, -0.07537277f, -0.11674985f, -0.06045210f, 0.00575366f, -0.09505032f, -0.07141324f, 
    0.02077505f, 0.05413863f, 0.00532867f, -0.13462768f, -0.14027500f, 0.08807163f, -0.00112908f, 0.22296530f, 
    0.14472309f, -0.06291737f, -0.04854147f, 0.03276738f, -0.10407050f, -0.02206988f, 0.10325024f, 0.15362720f, 
    0.13552012f, -0.06035779f, -0.13787019f, -0.05525988f, -0.02261533f, -0.11264457f, -0.05003307f, -0.11530337f, 
    0.07548171f, 0.06090328f, -0.07047968f, 0.05315214f, -0.33118883f, 0.18730181f, 0.32624167f, 0.15396801f, 
    -0.06401489f, -0.08896054f, -0.01421344f, 0.09932763f, 0.00459456f, -0.03349531f, 0.13298735f, 0.05437914f, 
    -0.10413207f, -0.00663037f, 0.11372073f, -0.10327405f, 0.07846847f, 0.05173382f, -0.00022674f, 0.00128451f, 
    0.05628354f, 0.00367890f, 0.15359722f, 0.01233296f, 0.26745993f, -0.06023479f, 0.09423066f, -0.02676070f, 
    0.13958307f, -0.02692132f, -0.15230897f, -0.02131260f, 0.10074795f, -0.05772476f, 0.05074766f, -0.05456240f, 
    -0.13604498f, -0.10934992f, 0.29188070f, 0.10331921f, 0.09686925f, 0.07990122f, -0.06170233f, -0.16464700f, 
    0.11548262f, -0.02901528f, 0.04674466f, 0.16319089f, 0.29289925f, -0.30914295f, 0.44609755f, -0.08217097f, 
    0.09825741f, 0.09661459f, -0.41592690f, 0.02894397f, -0.00671425f, -0.10061833f, -0.11507878f, -0.02369142f, 
    -0.24416243f, 0.14258848f, 0.00430671f, -0.19342162f, -0.01790494f, -0.08754071f, 0.06470499f, 0.03594802f, 
    -0.00775188f, -0.03801896f, 0.05691921f, 0.02847379f, -0.07554156f, -0.20701744f, 0.06243876f, -0.03087212f, 
    0.07608359f, 0.02856185f, -0.03386973f, -0.05327047f, -0.10304783f, -0.07830868f, 0.00703561f, 0.04408738f, 
    0.19586189f, 0.13880116f, -0.05781384f, 0.21036880f, 0.02273165f, -0.14965230f, -0.10322738f, 0.01800450f, 
    0.15110569f, 0.06455970f, 0.19564231f, 0.02465244f, 0.22384155f, -0.18842222f, -0.18190527f, -0.18451709f, 
    0.04107453f, 0.10936063f, 0.06834343f, 0.04425973f, 0.20413874f, 0.01435811f, 0.06757931f, 0.04247218f, 
    -0.19789566f, -0.14208764f, 0.14054398f, 0.21011603f, -0.10004304f, -0.05260535f, 0.00230255f, 0.00613550f, 
    -0.10101639f, -0.02621648f, -0.03110215f, -0.02395109f, -0.14839378f, 0.09881574f, -0.23326838f, 0.07961229f, 
    0.10124163f, -0.02519005f, 0.02037123f, -0.08515108f, 0.13975210f, 0.00742548f, 0.04894504f, 0.12803194f, 
    -0.15199098f, 0.21135317f, 0.19891073f, 0.19275877f, -0.00962540f, -0.05814360f, 0.00575333f, 0.01856220f, 
    -0.01841358f, -0.01544899f, -0.01130158f, 0.08089080f, -0.00405234f, 0.02642581f, -0.02924961f, -0.05435318f, 
    -0.02048578f, -0.01115806f, -0.05504568f, 0.05406392f, 0.11824694f, 0.09032105f, 0.07704122f, -0.07106545f, 
    0.05127014f, -0.17823488f, 0.21532834f, 0.04943572f, -0.00985755f, -0.05922623f, 0.04666358f, -0.10094516f, 
    0.07230615f, 0.00885597f, -0.08646961f, -0.12652236f, 0.04532594f, -0.04195084f, 0.03976677f, 0.05476856f, 
    0.14391573f, -0.11038099f, -0.23165278f, 0.10543092f, -0.00482236f, -0.01835996f, -0.01976370f, -0.03114198f, 
    0.23799388f, 0.00519145f, 0.02944372f, 0.01017324f, 0.09383021f, 0.07248599f, 0.01725204f, -0.09247112f, 
    0.05581595f, 0.08038341f, 0.09990221f, 0.21020818f, -0.10858998f, -0.05609959f, 0.10354283f, 0.14472422f, 
    -0.04761888f, 0.03349810f, 0.02968931f, -0.11305619f, -0.00846208f, 0.05086212f, 0.09246512f, 0.04838525f, 
    -0.06694606f, 0.37756726f, 0.03406032f, -0.17290583f, 0.06926186f, 0.17027931f, -0.14544801f, 0.13791750f, 
    0.14238361f, 0.00629839f, 0.07956722f, 0.06914505f, 0.42355248f, -0.38164485f, 0.12336123f, 0.02541846f, 
    -0.00717274f, -0.11532129f, -0.01616573f, 0.14989498f, -0.14320315f, 0.14943902f, 0.23127595f, -0.03348224f, 
    -0.18300186f, 0.12113097f, -0.20979419f, -0.07673424f, 0.17871998f, -0.12810089f, -0.07467902f, -0.04040715f, 
    0.04794837f, -0.03153965f, 0.00814468f, 0.10055540f, -0.20152511f, -0.22012638f, -0.02863709f, 0.12259312f, 
    -0.05006177f, -0.19336803f, -0.12194913f, 0.07411718f, 0.04851105f, 0.04802612f, 0.00374935f, -0.01555215f, 
    0.30809775f, -0.07556610f, -0.27819702f, -0.24344781f, 0.19791672f, 0.03598958f, -0.20614560f, -0.07882570f, 
    -0.07304794f, -0.18820912f, -0.01123789f, 0.04774374f, -0.12447648f, -0.10428575f, -0.09042573f, 0.10440858f, 
    0.18418953f, 0.07406612f, -0.07598419f, -0.04067428f, -0.03080146f, -0.05869810f, -0.29982212f, -0.07405664f, 
    0.28685129f, 0.07023413f, -0.05027198f, 0.10241891f, 0.05966448f, -0.17007947f, -0.00796587f, 0.09885863f, 
    0.00954212f, -0.01420945f, -0.01700930f, 0.14738254f, -0.01067964f, 0.23653096f, 0.26610780f, -0.00172872f, 
    -0.02039090f, 0.19928221f, -0.19392613f, -0.02620265f, -0.13323806f, -0.07619796f, -0.07918581f, -0.00248055f, 
    -0.02922462f, 0.15727203f, -0.00694224f, 0.10685154f, 0.07646528f, 0.05867791f, -0.05187441f, 0.01768821f, 
    -0.10923137f, -0.01486170f, -0.09646379f, 0.11884769f, -0.51844287f, 0.48941296f, -0.03493667f, -0.07669748f, 
    0.10547160f, -0.02326578f, 0.06302302f, -0.01486736f, -0.07715724f, 0.13342687f, -0.02987121f, 0.04142086f, 
    0.57218653f, -0.30585396f, 0.30888918f, -0.28896269f, -0.00112950f, 0.08814177f, -0.10322306f, 0.00552673f, 
    -0.04425379f, 0.10807764f, 0.10087750f, -0.24918310f, -0.09075949f, 0.01133332f, -0.03168535f, 0.22931182f, 
    0.02847376f, -0.00536968f, -0.11404376f, -0.04305742f, 0.17137475f, 0.01444751f, 0.06422082f, 0.12378140f, 
    -0.03381244f, -0.09167820f, -0.03455876f, 0.01915717f, -0.17337094f, 0.04637555f, 0.22258426f, 0.05267533f, 
    -0.07276768f, -0.03814176f, -0.06371052f, 0.13317826f, -0.01999913f, 0.15417294f, -0.10488224f, -0.13510545f, 
    -0.09712165f, 0.13274641f, -0.02375643f, 0.01803677f, 0.09899557f, -0.03680991f, 0.08745897f, -0.13797554f, 
    0.02146163f, 0.17755514f, 0.32674700f, -0.22773467f, -0.08078172f, 0.02555687f, 0.01260448f, 0.12658690f, 
    0.04794319f, 0.04094006f, -0.08461668f, -0.03379076f, 0.05819696f, -0.05064137f, -0.33361399f, -0.17764044f, 
    -0.00141051f, 0.10179524f, 0.02629057f, -0.01208522f, 0.05006949f, 0.11341993f, -0.08334660f, -0.17690551f, 
    0.15073881f, -0.11872191f, -0.19985498f, 0.07482656f, 0.08150645f, 0.06369703f, 0.08471595f, 0.12387375f, 
    -0.11531521f, 0.07997053f, -0.09100837f, 0.07291460f, 0.20080650f, 0.10414750f, 0.23696928f, 0.08659615f, 
    -0.10097042f, -0.03160306f, 0.03694174f, -0.03850943f, -0.02676184f, -0.06698190f, -0.00104009f, 0.09079773f, 
    0.28066254f, 0.01721562f, -0.14764477f, -0.15187347f, 0.04401559f, -0.02138896f, 0.03679628f, 0.19081321f, 
    -0.15988137f, -0.08508973f, 0.00683178f, -0.15940808f, -0.02258903f, 0.05180743f, 0.07328010f, 0.04718366f, 
    -0.03056675f, 0.04035536f, 0.12486137f, 0.01140420f, -0.02347951f, -0.01868541f, 0.11276573f, 0.01069785f, 
    0.02598278f, -0.15585369f, -0.12611742f, 0.04520885f, 0.03814979f, 0.01145681f, -0.04839509f, 0.02305872f, 
    -0.08125489f, -0.04299112f, -0.03396782f, -0.00365270f, 0.18029416f, 0.06800079f, -0.17743734f, 0.01715444f, 
    0.06913263f, 0.06483455f, 0.06365518f, -0.01409025f, -0.00363988f, -0.08114295f, 0.03122961f, 0.01321533f, 
    -0.17935254f, -0.06245136f, 0.08850467f, -0.22580007f, 0.01621215f, 0.12029899f, 0.08202192f, 0.02141264f, 
    -0.11319240f, -0.09305923f, -0.01562859f, -0.05640481f, -0.20318694f, -0.14228438f, -0.05209709f, 0.00497879f, 
    -0.00973072f, -0.10021429f, -0.10752560f, 0.02185194f, -0.17791523f, -0.10435641f, -0.13600773f, -0.08652778f, 
    0.25537121f, 0.33994609f, 0.05148404f, -0.13819538f, 0.26266843f, 0.18411389f, 0.02397958f, 0.03527939f, 
    -0.05853146f, -0.04072782f, -0.11552719f, -0.08133727f, 0.08273629f, 0.00387051f, 0.08413005f, 0.05726424f, 
    -0.13488032f, -0.05488030f, 0.08091651f, -0.01809291f, 0.00425564f, 0.00481325f, 0.06264760f, -0.07834800f, 
    -0.05932658f, -0.08485541f, -0.17311421f, -0.13834444f, -0.06792019f, 0.06564116f, -0.00718475f, 0.06747680f, 
    0.07039237f, 0.07560720f, -0.11291200f, -0.20740730f, -0.02437302f, 0.03470137f, -0.03536639f, 0.12550420f, 
    -0.07531900f, -0.11635794f, -0.04632002f, -0.03237472f, -0.01338757f, -0.03805929f, -0.08622545f, 0.08324075f, 
    0.11525021f, 0.25853071f, 0.00493830f, -0.16027723f, 0.05898110f, 0.17462146f, -0.05136068f, 0.16962793f, 
    -0.02161605f, -0.07120117f, -0.01104761f, 0.08697195f, 0.14374988f, 0.30480841f, 0.05201200f, 0.07627844f, 
    -0.08665927f, 0.05640171f, 0.12702426f, -0.01466446f, 0.08177835f, -0.02410029f, 0.05446638f, 0.08451393f, 
    0.12779555f, -0.10139824f, 0.13775378f, -0.09842144f, -0.13001962f, 0.03323344f, 0.06596596f, -0.08411271f, 
    0.18338051f, 0.07897968f, -0.10970853f, -0.18232720f, 0.26661518f, 0.11111147f, 0.08442777f, -0.28860384f, 
    0.03321980f, -0.03005487f, -0.00389009f, 0.11080059f, 0.01253398f, -0.03970464f, -0.08283347f, -0.09465515f, 
    0.31846741f, -0.61937392f, 0.00443186f, 0.20786154f, 0.04215975f, -0.00392528f, 0.16702709f, 0.05454665f, 
    -0.02158388f, 0.11801850f, 0.09115814f, 0.05295241f, -0.40056565f, 0.28589818f, 0.16731994f, -0.14281458f, 
    -0.09341497f, 0.03367840f, -0.14777555f, 0.11690173f, 0.11034179f, -0.07940003f, 0.02855899f, 0.01340151f, 
    0.07882544f, -0.03585618f, -0.03617387f, 0.16133408f, -0.09690038f, 0.03799064f, 0.05352979f, 0.02919309f, 
    0.01644585f, -0.02248734f, -0.03613030f, -0.03214868f, -0.10899694f, 0.09353774f, -0.02623579f, -0.00417307f, 
    -0.05755057f, -0.01549649f, 0.02890677f, 0.01832398f, 0.02919644f, 0.03349037f, -0.06795470f, -0.06472783f, 
    -0.08662160f, -0.20705481f, 0.35047778f, 0.07160237f, -0.19237484f, -0.11168801f, 0.08990388f, -0.05389957f, 
    0.04200932f, 0.22168426f, -0.08363546f, 0.15213791f, -0.01222980f, 0.08952805f, 0.05520637f, -0.07150119f, 
    0.04189011f, -0.02189790f, 0.11455998f, 0.05601248f, -0.08524396f, -0.02580700f, 0.05806319f, 0.02090839f, 
    0.00927643f, -0.05637141f, 0.21720932f, 0.10564855f, -0.03063003f, 0.03278869f, 0.14960173f, 0.10776885f, 
    0.19852649f, -0.06160957f, 0.10431395f, -0.00973850f, 0.10262195f, 0.07763935f, 0.16420910f, 0.06701850f, 
    -0.05778024f, -0.20136118f, -0.08289220f, -0.08811354f, -0.05340151f, 0.03206451f, 0.02947711f, 0.00567019f, 
    0.21134260f, 0.01228301f, 0.12862955f, 0.10667444f, 0.15751943f, 0.13540994f, 0.13344887f, 0.09093396f, 
    0.06406808f, -0.02378739f, -0.00876607f, 0.05927600f, 0.45513785f, 0.07144076f, -0.02573167f, 0.12655427f, 
    0.02477486f, -0.06788979f, 0.17826116f, -0.16726184f, 0.20303634f, -0.12146309f, 0.04524763f, 0.11752538f, 
    -0.12071790f, -0.16287544f, 0.02245745f, 0.14581506f, 0.13993551f, -0.09249327f, 0.18681614f, 0.03039436f, 
    -0.12439393f, -0.12675661f, 0.07967700f, 0.15471706f, -0.03085417f, 0.02053786f, -0.13012552f, 0.11975275f, 
    -0.07112021f, -0.06331153f, 0.00790644f, 0.05672677f, -0.04605205f, 0.07216513f, 0.00263921f, -0.09503198f, 
    0.13762684f, 0.02840187f, 0.03201955f, -0.12514251f, -0.01050374f, -0.01282420f, -0.11038598f, 0.01836501f, 
    -0.01586093f, -0.05625554f, -0.01846360f, -0.09643186f, -0.15047972f, -0.03544781f, -0.07601455f, 0.17893454f, 
    0.03271065f, -0.00685389f, -0.07418426f, 0.08409704f, -0.15858252f, 0.05048053f, 0.01117454f, -0.01035641f, 
    -0.05524455f, -0.03664699f, -0.16335720f, 0.16669151f, -0.02282963f, -0.02182563f, -0.13403979f, -0.06453446f, 
    0.01596167f, 0.10522477f, -0.07806670f, 0.18839678f, -0.26461345f, 0.17832358f, 0.30605924f, 0.08573143f, 
    -0.03986934f, -0.08861866f, -0.04733381f, 0.00926227f, -0.02323413f, 0.02951264f, 0.10377713f, 0.05718839f, 
    -0.13159975f, 0.11539877f, 0.27068302f, 0.01573228f, -0.04290795f, -0.04371325f, 0.02985363f, -0.11924957f, 
    0.11062682f, 0.11400677f, 0.14972429f, 0.05503954f, 0.34460372f, -0.14757495f, 0.20096928f, -0.03390259f, 
    0.04055499f, -0.00341635f, -0.12495383f, -0.06326901f, 0.00266867f, -0.00178928f, -0.04021293f, -0.05824136f, 
    -0.04814537f, -0.11188881f, 0.19079255f, 0.09763400f, 0.07667092f, 0.02232292f, -0.04639392f, -0.12878384f, 
    0.09250305f, 0.00367215f, 0.10143300f, 0.16105483f, 0.19336571f, -0.30403441f, 0.04430449f, -0.08273923f, 
    0.00038300f, -0.01471233f, -0.21816984f, -0.00203341f, -0.04503493f, -0.02055553f, -0.01849850f, -0.09673402f, 
    -0.02839692f, 0.07486930f, 0.04152848f, -0.15535603f, 0.04362423f, 0.02807217f, 0.10563040f, 0.09631634f, 
    0.02775407f, -0.04535917f, -0.05299471f, -0.08081102f, -0.04875665f, -0.05619997f, 0.23248453f, 0.14596958f, 
    -0.02091981f, -0.00306387f, -0.04995374f, -0.05440649f, 0.02648747f, 0.11721537f, -0.01360720f, 0.05763777f, 
    0.12249881f, 0.09018539f, -0.02262804f, 0.22270708f, 0.06869376f, -0.16372243f, 0.00679195f, -0.00650623f, 
    0.03866885f, 0.06225277f, 0.15696128f, 0.11541205f, 0.25185737f, -0.02182380f, -0.10955378f, -0.18267098f, 
    -0.02086865f, -0.02143946f, -0.00668758f, 0.01286655f, 0.12600440f, -0.00023657f, 0.07108586f, 0.12314765f, 
    -0.17792991f, -0.16824874f, 0.03386858f, 0.22167517f, -0.14475353f, 0.00948938f, 0.02790127f, -0.09101070f, 
    0.04220026f, 0.06661228f, 0.08801477f, 0.04247099f, -0.04718228f, -0.12928441f, -0.27779707f, 0.02104663f, 
    0.08257180f, -0.01821906f, 0.01734651f, -0.01981899f, 0.08366583f, -0.04317600f, -0.02610620f, 0.18321809f, 
    -0.03915420f, 0.34766638f, 0.13136674f, 0.10670158f, 0.03514136f, -0.08552686f, 0.05146205f, 0.02416184f, 
    -0.02147599f, 0.00585585f, 0.00589233f, 0.07906172f, 0.18384953f, -0.06534390f, 0.14902493f, -0.08138562f, 
    -0.10927831f, 0.04453773f, -0.00196795f, -0.02326611f, 0.11169709f, 0.11039845f, 0.02457896f, 0.01998317f, 
    0.01989725f, -0.14011760f, 0.12820111f, 0.05666598f, 0.05370187f, -0.10730506f, 0.10234169f, -0.04801288f, 
    0.01555394f, 0.06961013f, 0.04403709f, 0.05309682f, 0.00370985f, -0.17758936f, -0.03595350f, 0.03875927f, 
    0.09027868f, -0.00274003f, -0.13283725f, 0.02015212f, -0.02128065f, -0.03775248f, -0.13259619f, -0.03852038f, 
    0.20601398f, -0.20147392f, 0.15571338f, -0.13422626f, 0.14255646f, -0.09976593f, 0.02916786f, -0.09127519f, 
    0.11050766f, 0.01900848f, 0.03187204f, 0.10100155f, -0.18496867f, -0.03781921f, 0.01396594f, 0.18589731f, 
    -0.02220372f, 0.15020825f, 0.08927383f, -0.03890514f, 0.07149158f, 0.12764665f, 0.14976352f, 0.05744067f, 
    -0.03153816f, 0.39555985f, 0.09497316f, -0.28670987f, 0.12946482f, 0.01303753f, -0.17798685f, -0.09598435f, 
    0.17368168f, -0.00175922f, 0.09216985f, -0.02804500f, 0.54411262f, -0.42390400f, -0.06759308f, 0.13747251f, 
    -0.06799449f, -0.05554434f, 0.01639346f, 0.09510809f, -0.01811223f, 0.14128835f, 0.18293384f, -0.09009083f, 
    -0.02693759f, 0.10126000f, -0.10739397f, -0.00555788f, 0.06419808f, -0.09952279f, -0.08064874f, 0.03658799f, 
    0.14759272f, 0.05767996f, -0.04991960f, 0.14995730f, -0.07929963f, -0.09320506f, -0.08417498f, 0.14042500f, 
    0.00300401f, -0.02788977f, -0.12643096f, 0.04707544f, 0.08924213f, 0.00791590f, 0.04215585f, 0.02018716f, 
    0.37029102f, -0.24438678f, -0.00218269f, -0.27440467f, 0.10156003f, -0.02535035f, -0.05239918f, 0.02334950f, 
    -0.03383236f, -0.23672889f, -0.04316571f, -0.05242922f, -0.18716194f, 0.03011463f, -0.12060089f, 0.19891030f, 
    0.16996761f, 0.05113687f, 0.09024598f, 0.01144606f, 0.01495073f, 0.04241464f, -0.12034691f, -0.01224992f, 
    0.04091263f, -0.12354369f, 0.02921882f, 0.06029907f, 0.03786618f, -0.06626825f, 0.01402050f, -0.07138680f, 
    -0.00080724f, 0.00394408f, 0.05885098f, 0.06435496f, 0.42106521f, 0.11602172f, 0.27746701f, -0.00132632f, 
    -0.13515368f, 0.12421097f, -0.06237156f, -0.02949258f, -0.05525315f, -0.09267989f, -0.00580725f, -0.03876145f, 
    0.05832475f, 0.05939210f, 0.16392283f, 0.01279882f, 0.04688748f, 0.11823119f, -0.00521658f, -0.08716662f, 
    0.01995676f, -0.07615405f, -0.12203571f, -0.02783888f, -0.43332791f, 0.24463618f, -0.11854340f, 0.06716560f, 
    0.16476656f, 0.00316939f, -0.04622997f, 0.08251430f, -0.10319246f, -0.01845910f, 0.02052165f, 0.02262228f, 
    0.43213448f, -0.20218183f, 0.16068678f, -0.33882809f, -0.08356215f, 0.12952612f, -0.13299666f, 0.00317418f, 
    -0.01305450f, 0.04546955f, 0.04830182f, -0.13129899f, -0.00238816f, 0.04760060f, -0.04849182f, 0.19965971f, 
    0.04104647f, -0.02106673f, -0.01707036f, -0.08861023f, 0.23132434f, -0.01000561f, 0.06795961f, 0.13021375f, 
    -0.02201149f, -0.01535895f, 0.00777613f, -0.00855224f, -0.01484462f, 0.00244842f, 0.00738167f, -0.00200310f, 
    0.01148044f, 0.01359814f, -0.05614660f, -0.01224100f, 0.04050084f, -0.01058498f, -0.04256610f, 0.01407793f, 
    0.02798475f, 0.02654999f, 0.02902441f, 0.03918337f, 0.04102322f, -0.05317072f, -0.04989306f, 0.03975484f, 
    0.00331317f, -0.04185908f, -0.02801462f, 0.01045747f, -0.03286925f, -0.04139331f, -0.04876507f, 0.00851156f, 
    -0.05132816f, -0.04221705f, -0.02444514f, -0.03757094f, -0.04985554f, 0.02242419f, -0.01386065f, 0.00536681f, 
    0.03185627f, -0.05176625f, 0.03085115f, -0.03760368f, 0.01427198f, -0.01094869f, 0.01629323f, 0.03598459f, 
    -0.00619747f, -0.05669713f, 0.00504859f, -0.03536274f, 0.03714880f, 0.03677788f, 0.02889004f, -0.05092916f, 
    0.00044412f, -0.02880727f, 0.02561626f, 0.02953760f, -0.02895335f, 0.03909021f, -0.00320999f, -0.04907736f, 
    0.01748038f, -0.05035070f, -0.03776120f, -0.04369497f, -0.01244496f, 0.01231905f, -0.05692479f, 0.02107016f, 
    -0.01305262f, 0.00854215f, -0.04623248f, 0.00934308f, -0.04882514f, -0.00161345f, 0.02106290f, 0.00907840f, 
    -0.01847985f, 0.04473980f, -0.02399392f, -0.00509861f, 0.02535202f, -0.00487867f, 0.01362734f, -0.03726838f, 
    0.00532531f, -0.05456394f, -0.03073966f, 0.03747906f, -0.00410852f, 0.02525693f, -0.05379045f, 0.01868616f, 
    0.02133357f, 0.00328899f, -0.04642695f, -0.03435582f, -0.04503328f, 0.00657799f, -0.00685085f, -0.01048287f, 
    -0.04472672f, 0.00981455f, -0.04126202f, -0.01882784f, 0.01124632f, 0.03540410f, 0.04422953f, 0.02460261f, 
    -0.02809356f, 0.01218601f, 0.04325879f, 0.00178484f, -0.03763886f, -0.00480398f, -0.02986442f, 0.00142671f, 
    -0.04265353f, -0.04254720f, 0.02222585f, -0.01805818f, -0.02894687f, 0.03857746f, 0.01699772f, 0.03650199f, 
    -0.00520828f, 0.02961391f, -0.04943103f, -0.05141613f, 0.04097081f, 0.01769647f, -0.00348989f, 0.01387845f, 
    -0.01471786f, -0.05581260f, 0.03944140f, -0.03359761f, 0.02256831f, -0.02579174f, -0.03099564f, -0.04420730f, 
    -0.03291720f, -0.02240250f, -0.01326935f, -0.00630827f, -0.01282123f, -0.00357972f, 0.00231741f, 0.01169512f, 
    0.04405770f, -0.04019558f, -0.05430550f, -0.02271629f, -0.00913382f, 0.03450450f, 0.01212463f, -0.02732563f, 
    0.03896788f, 0.00532389f, 0.00022063f, 0.02110298f, -0.01511721f, -0.02654109f, -0.01867309f, -0.03433555f, 
    -0.05067316f, -0.01204182f, -0.02170345f, -0.03899072f, 0.00543724f, -0.01210539f, -0.02671107f, 0.02824949f, 
    0.02748404f, -0.04319582f, -0.02105501f, -0.00559194f, -0.02672362f, -0.00411249f, -0.03379181f, -0.02935001f, 
    -0.04253756f, 0.00993409f, 0.00370616f, -0.01506840f, 0.03787086f, -0.01271708f, -0.04531267f, -0.00120076f, 
    -0.00105108f, 0.02797968f, 0.02251159f, -0.01763520f, -0.02868318f, 0.00327434f, 0.01720438f, 0.00340572f, 
    0.00543010f, -0.05080481f, -0.02465767f, 0.00546905f, 0.03181320f, -0.02942771f, -0.05006781f, 0.00826523f, 
    -0.00132950f, -0.00703259f, -0.01564533f, -0.02733624f, -0.01983113f, -0.00748358f, 0.03858992f, -0.00787646f, 
    0.01690481f, 0.02145135f, 0.00063797f, -0.02134779f, -0.04182062f, -0.03947544f, 0.02049519f, -0.02686612f, 
    0.01592879f, 0.00016512f, -0.04265341f, -0.02492327f, 0.00729406f, -0.04387046f, 0.02225407f, 0.03791205f, 
    0.00587588f, 0.02087550f, 0.00016188f, 0.00762798f, -0.02233563f, -0.02425490f, -0.01183211f, -0.02257856f, 
    -0.02487687f, -0.00749088f, -0.00439832f, -0.03062264f, 0.01030000f, -0.01608971f, -0.05283919f, 0.02103205f, 
    -0.00195600f, 0.00831408f, -0.01200856f, -0.02239558f, 0.02069765f, -0.05028591f, -0.03022061f, -0.00388404f, 
    0.00423775f, -0.01900901f, -0.00331425f, 0.01556507f, -0.01770341f, 0.03613614f, -0.00865424f, -0.05325300f, 
    -0.03130097f, -0.05010713f, 0.03138544f, 0.02770278f, -0.03161621f, -0.01162544f, 0.01091473f, -0.00071265f, 
    0.01046648f, 0.00912915f, -0.05476252f, 0.01327010f, 0.01686915f, -0.03904215f, 0.03351555f, 0.00401093f, 
    0.03502993f, -0.04582499f, -0.00978810f, -0.02037130f, -0.01074485f, -0.01151093f, -0.05571428f, 0.00243472f, 
    -0.03151885f, 0.00283962f, 0.00417978f, 0.03141639f, 0.04155701f, 0.03139722f, -0.01833337f, -0.05285220f, 
    -0.05457236f, 0.00679176f, -0.02923420f, -0.05458512f, 0.00581542f, -0.04783956f, 0.01720051f, 0.01428976f, 
    -0.02931479f, -0.03309287f, -0.03752419f, 0.03402123f, -0.04450758f, 0.04479193f, 0.01110209f, -0.01287149f, 
    -0.02985748f, -0.02611101f, -0.02363512f, 0.03228815f, -0.05656563f, 0.03783933f, 0.01145605f, -0.00510748f, 
    -0.05237699f, -0.05407184f, 0.02665593f, -0.00471488f, 0.00603704f, -0.04115948f, -0.03893581f, -0.01344392f, 
    0.02470955f, -0.01404335f, -0.04923402f, 0.03936914f, 0.01840170f, -0.04258589f, -0.01039412f, 0.04247886f, 
    -0.03176442f, -0.02115410f, 0.01911662f, 0.04301786f, 0.03034100f, -0.03974485f, 0.01476385f, -0.04653544f, 
    -0.03519048f, -0.00969869f, -0.04015441f, -0.03438305f, 0.02169373f, -0.02897400f, -0.05549532f, 0.03917272f, 
    -0.02863435f, 0.02992074f, 0.02560877f, -0.00537661f, 0.02016024f, -0.00775044f, 0.02614532f, -0.03014977f, 
    -0.00971006f, 0.05102527f, -0.00995281f, 0.04426064f, 0.03218243f, -0.03485706f, 0.01840674f, 0.00787561f, 
    -0.02728527f, -0.00935680f, 0.00152945f, -0.01316178f, 0.00078521f, -0.03138428f, -0.00768908f, -0.03591197f, 
    0.02640790f, 0.02855163f, -0.04759030f, 0.01796398f, 0.02846687f, 0.03344588f, -0.01739705f, -0.03368581f, 
    -0.07277894f, -0.07008884f, -0.29427198f, -0.04982257f, 0.00836329f, 0.05077122f, 0.04572660f, 0.09729796f, 
    0.11266866f, -0.01647565f, 0.04066694f, 0.18272553f, -0.05691460f, 0.01920328f, -0.00011674f, -0.12689365f, 
    0.04977821f, 0.06150516f, -0.05021607f, -0.07879920f, 0.04252488f, -0.03890894f, 0.11806668f, 0.21136519f, 
    -0.35598737f, 0.00709430f, 0.17424646f, 0.14637505f, 0.05914741f, -0.03913176f, -0.05511587f, -0.04352626f, 
    0.04380770f, -0.02026933f, -0.14759396f, -0.08822022f, 0.06544737f, -0.02683991f, -0.13916825f, -0.07191392f, 
    0.01075173f, 0.02126938f, -0.07523780f, -0.07066296f, 0.01886928f, -0.03173340f, 0.01080872f, -0.06273231f, 
    0.10675465f, 0.02567105f, -0.04579321f, -0.17091741f, 0.04120082f, 0.02932917f, 0.09083298f, 0.07048839f, 
    -0.16999957f, 0.13690288f, 0.08806279f, 0.05717451f, -0.01103869f, 0.03023940f, 0.20242284f, 0.15483838f, 
    -0.04064510f, -0.06461507f, -0.01532326f, 0.04082732f, 0.08940411f, -0.06263591f, -0.15585534f, 0.10384487f, 
    0.13431925f, 0.00013283f, 0.01083796f, -0.27358460f, 0.06026486f, -0.05556801f, 0.09358299f, 0.20337905f, 
    -0.03001465f, 0.01355309f, -0.07754209f, -0.17171377f, -0.10396806f, 0.03456114f, -0.05777442f, 0.09947333f, 
    -0.08889851f, -0.08040908f, 0.04175467f, -0.10709216f, 0.08033288f, 0.05970103f, -0.10219008f, 0.11891146f, 
    0.00398375f, -0.18309909f, -0.20550384f, -0.13693333f, 0.09232935f, 0.11157188f, -0.05534064f, 0.19254285f, 
    0.15687002f, 0.00634676f, 0.01395200f, -0.02638904f, 0.17873947f, 0.22053036f, -0.02833907f, -0.05509653f, 
    0.15357845f, 0.14040092f, 0.18772541f, 0.02716269f, 0.04066025f, -0.02628854f, 0.02964807f, -0.04784695f, 
    -0.43782219f, 0.12569144f, 0.08733220f, 0.22643194f, -0.01956900f, 0.07605914f, -0.14792834f, -0.03197675f, 
    -0.02496737f, 0.09945685f, -0.02232622f, 0.17032026f, -0.10597432f, -0.10384010f, 0.04618296f, -0.05053140f, 
    -0.01678821f, 0.00156259f, -0.08481238f, -0.14289621f, 0.03568905f, -0.11810473f, -0.11304884f, -0.16387689f, 
    0.30203322f, 0.36101413f, 0.31040034f, 0.01209735f, 0.19162685f, 0.20704263f, -0.08129596f, 0.10462745f, 
    -0.01706306f, -0.06940566f, -0.06479795f, 0.00360143f, 0.11290190f, -0.00610977f, -0.09578108f, -0.07932859f, 
    -0.02790760f, -0.03046231f, -0.06226920f, 0.08853801f, 0.05148162f, 0.08433656f, 0.02462705f, -0.01674720f, 
    0.10519566f, -0.17584674f, -0.08110821f, -0.13170096f, 0.04512161f, 0.00313186f, -0.02822926f, -0.12251446f, 
    0.06938516f, -0.00129945f, 0.10631501f, -0.01852671f, 0.08854341f, -0.02938311f, -0.00887254f, 0.08680114f, 
    -0.06322304f, 0.00237702f, -0.07217567f, 0.02138106f, -0.03791857f, -0.10524903f, -0.02422134f, -0.03828923f, 
    0.04761780f, 0.23897125f, 0.17008564f, 0.00312335f, 0.11899640f, 0.21405503f, -0.01392164f, 0.27419460f, 
    -0.01543590f, 0.06584412f, 0.02552766f, 0.04695830f, 0.06830776f, 0.02050895f, -0.05391138f, 0.15781729f, 
    -0.08352967f, -0.01487487f, -0.07924771f, 0.03022117f, 0.16479704f, 0.04619612f, 0.02403428f, 0.16443950f, 
    -0.01475167f, 0.12131134f, -0.33710152f, -0.28069025f, -0.05501380f, -0.11650929f, 0.02913754f, 0.02241954f, 
    0.06018637f, 0.18604517f, 0.04166789f, -0.03654119f, 0.22477095f, 0.18353917f, 0.22914225f, 0.18822479f, 
    0.19761570f, 0.06538175f, -0.00612294f, 0.07115461f, -0.01121509f, 0.01443943f, 0.02534161f, -0.26611027f, 
    0.10365166f, -0.07185857f, -0.20167522f, -0.39854804f, -0.07153378f, 0.19807105f, -0.14709961f, -0.00978957f, 
    0.17132632f, 0.09521995f, 0.01200654f, -0.00756860f, -0.57382464f, 0.13204129f, 0.01867461f, -0.00214399f, 
    0.04204304f, -0.11740948f, -0.04926138f, 0.06377909f, 0.12022223f, -0.06118333f, 0.08685835f, -0.08360419f, 
    -0.04232140f, -0.19609652f, 0.02817650f, -0.18847869f, -0.02636000f, 0.12209632f, -0.03311821f, -0.03329365f, 
    0.11578687f, 0.04396794f, 0.03409614f, 0.06859326f, -0.06027156f, -0.03989564f, 0.01892166f, 0.11973576f, 
    -0.16056360f, -0.02438323f, -0.03433608f, -0.09015704f, 0.01028309f, 0.05003931f, 0.14063750f, -0.01450028f, 
    -0.07255448f, 0.06127440f, -0.03621046f, 0.32305562f, -0.04818492f, -0.04539644f, 0.09139176f, -0.07881784f, 
    -0.03036935f, 0.02015361f, 0.01209660f, 0.01140059f, -0.12600586f, -0.06809645f, -0.00899156f, -0.11783689f, 
    0.16493589f, 0.13534701f, 0.17498189f, 0.24613510f, 0.12395430f, 0.05584515f, 0.03432001f, 0.03369920f, 
    -0.20758045f, 0.13014852f, 0.10122310f, -0.07598510f, 0.24916573f, -0.02776706f, 0.02900636f, 0.10344090f, 
    0.15092809f, 0.01139522f, -0.02288629f, 0.10631041f, 0.06558320f, 0.03483925f, -0.30553851f, 0.02648376f, 
    -0.02994760f, -0.06243852f, -0.13153151f, 0.06859715f, 0.02612609f, -0.03827137f, -0.03069955f, -0.06460432f, 
    0.29700863f, 0.08675256f, -0.22018096f, 0.04872019f, 0.18067454f, 0.13883732f, 0.24034943f, 0.03591976f, 
    -0.00437481f, 0.03598193f, -0.11105911f, 0.04514151f, 0.30138114f, -0.07955839f, -0.07836895f, -0.01254313f, 
    0.02298828f, -0.03788984f, -0.00771991f, 0.14815815f, 0.19310531f, -0.09007663f, -0.00811774f, 0.14062889f, 
    -0.12313916f, 0.07905333f, 0.12346683f, 0.12041022f, 0.08119863f, -0.07582586f, -0.13588426f, 0.03505383f, 
    0.05690463f, -0.10199485f, 0.05850258f, 0.13178152f, -0.07008775f, -0.17486098f, 0.02743784f, 0.11369602f, 
    -0.06604143f, -0.10250266f, -0.04547055f, -0.07379363f, 0.06987596f, 0.08322322f, -0.11868478f, -0.18187337f, 
    0.13391431f, 0.02053353f, 0.06853648f, -0.10264659f, 0.02788416f, -0.11281474f, 0.09564684f, 0.19875966f, 
    -0.02234827f, -0.21525039f, -0.03213656f, 0.19467726f, 0.20111179f, 0.17823859f, 0.10331481f, -0.00160404f, 
    0.01772722f, -0.08347080f, -0.17721301f, -0.08055638f, 0.00349398f, 0.04224455f, -0.12856178f, -0.03803010f, 
    -0.09318662f, 0.06339294f, -0.07673682f, 0.10977973f, -0.01688449f, 0.01767092f, -0.09295857f, 0.02887207f, 
    0.12585758f, -0.08188240f, -0.12932201f, -0.02505232f, 0.29254887f, 0.10377353f, 0.14514102f, 0.06846832f, 
    -0.07184684f, -0.09855235f, -0.11943996f, 0.00901614f, 0.04740651f, 0.08703610f, 0.05210319f, 0.01565866f, 
    -0.19455096f, -0.11766247f, 0.17851910f, 0.24052413f, -0.06296223f, -0.04873536f, 0.08706694f, -0.06476015f, 
    -0.04142751f, 0.13322973f, 0.05909442f, 0.08007699f, 0.01107864f, -0.23744957f, 0.26255420f, -0.36541030f, 
    -0.09176673f, -0.00551273f, 0.06295713f, 0.03590716f, -0.01485117f, -0.00671763f, 0.02853688f, -0.05958978f, 
    -0.02275376f, -0.10583978f, -0.13018605f, -0.14604007f, 0.10820560f, 0.05934965f, -0.01741960f, -0.02222098f, 
    0.08803283f, 0.07592724f, 0.02145608f, 0.03968890f, 0.07785135f, -0.11016032f, -0.12296264f, 0.00953391f, 
    -0.06824689f, -0.11562555f, 0.07487560f, -0.05008058f, 0.01912532f, 0.05103682f, -0.04323272f, -0.00737225f, 
    0.02797584f, 0.02406732f, 0.06664851f, -0.09681191f, -0.05273613f, 0.03399964f, 0.11082161f, -0.09696915f, 
    -0.00084168f, -0.00242145f, -0.03135506f, -0.02538506f, -0.35980937f, -0.15401566f, 0.15818797f, 0.22087172f, 
    -0.07580749f, -0.00630482f, -0.02211874f, 0.01137285f, -0.01800488f, -0.00791460f, -0.02515092f, -0.00592916f, 
    0.12631594f, 0.03229561f, 0.06963045f, 0.19769564f, -0.05466669f, -0.04356238f, -0.06585973f, -0.05749513f, 
    -0.06231876f, -0.04596705f, 0.03914361f, 0.00903201f, 0.10325151f, 0.14611539f, 0.08969494f, -0.05554893f, 
    0.05017205f, -0.06479232f, -0.11287536f, -0.00902947f, 0.03925180f, 0.08986386f, 0.07268441f, 0.16840011f, 
    -0.09177728f, 0.01077526f, 0.04063664f, 0.14696860f, -0.12348454f, 0.00448693f, 0.00641296f, 0.00622304f, 
    0.08643699f, 0.06360283f, -0.08940845f, -0.14233296f, 0.06386629f, -0.00023074f, 0.05106286f, -0.00425286f, 
    0.01435577f, -0.07297946f, -0.04929631f, 0.01501522f, 0.01329008f, 0.01798798f, -0.02988819f, -0.05340851f, 
    0.28997299f, 0.25007570f, 0.02278657f, -0.16755514f, -0.10885347f, -0.05669601f, -0.00068747f, 0.01318571f, 
    -0.11353811f, -0.14848287f, -0.00996645f, -0.00462060f, 0.14199099f, 0.02645264f, 0.06753291f, -0.07274564f, 
    -0.00255612f, -0.02547301f, -0.03159131f, 0.03639346f, -0.03447717f, 0.01188598f, -0.01053862f, 0.08032318f, 
    -0.19415243f, -0.18912621f, -0.17504071f, 0.22065412f, 0.06329095f, -0.09705268f, -0.14971974f, 0.06342487f, 
    0.06851905f, -0.01321822f, -0.02441580f, 0.07948122f, 0.09671484f, 0.15257385f, 0.14446658f, 0.11923138f, 
    -0.00506104f, 0.07943410f, -0.10353615f, -0.02209454f, 0.10228611f, 0.03653321f, -0.01466753f, -0.14765656f, 
    0.22919209f, 0.22681296f, 0.25035429f, -0.09114918f, -0.05181720f, 0.08803602f, 0.06060656f, -0.06286963f, 
    -0.01010270f, 0.19859833f, -0.06427790f, -0.04084780f, -0.02672996f, -0.10015284f, -0.12000228f, 0.17487109f, 
    0.06964998f, 0.06503191f, 0.02855004f, 0.04827971f, -0.06515855f, 0.06596243f, 0.14085659f, 0.09143109f, 
    0.18585296f, 0.17820084f, 0.53018183f, -0.29276502f, 0.00815345f, -0.03599350f, 0.06659152f, 0.09414337f, 
    -0.17373401f, 0.18056725f, 0.05047682f, 0.01398751f, 0.06255225f, 0.09091097f, 0.02206244f, -0.05107265f, 
    -0.06832960f, -0.00503144f, 0.03111060f, -0.24296777f, 0.02573841f, -0.09284069f, 0.16636808f, -0.00765875f, 
    0.30228686f, -0.05062922f, 0.17749573f, 0.00061398f, -0.12931156f, 0.04561821f, -0.02585838f, 0.09758020f, 
    0.08119611f, 0.00966142f, -0.09237386f, 0.18088889f, 0.05520124f, 0.00057126f, 0.00232490f, -0.00616172f, 
    -0.02296241f, -0.05737072f, -0.05038555f, -0.00023275f, -0.05656302f, 0.02992438f, -0.05693838f, -0.15353172f, 
    -0.01421927f, 0.07394060f, 0.06468033f, 0.21677172f, -0.02590466f, -0.05585585f, 0.04282486f, -0.03590093f, 
    -0.06344197f, -0.04677717f, -0.07564338f, -0.09398846f, 0.01453421f, -0.02075426f, 0.04778265f, 0.11996280f, 
    -0.12483992f, 0.05583337f, 0.12973815f, 0.15766490f, -0.00513430f, 0.01839519f, 0.00055875f, -0.01717209f, 
    -0.11420601f, -0.06387874f, -0.14941284f, 0.09476694f, -0.09145165f, 0.15847841f, 0.06124099f, -0.14311670f, 
    0.18434834f, -0.03563907f, 0.00807607f, 0.07119930f, 0.30786294f, 0.20482698f, -0.13856041f, -0.25444010f, 
    -0.06783872f, -0.09362049f, -0.01862046f, 0.03447459f, -0.01577550f, -0.00937899f, -0.02130110f, 0.00214262f, 
    0.00776201f, -0.02890681f, 0.09138747f, -0.12737337f, -0.12735504f, 0.08593554f, 0.08678541f, 0.05004400f, 
    0.03805187f, 0.02063503f, -0.09719686f, -0.10984030f, 0.14557096f, -0.34091693f, 0.08989688f, 0.28743392f, 
    0.19182360f, -0.00443371f, -0.07974154f, 0.06822485f, 0.14710933f, -0.05834511f, 0.13924603f, 0.05430625f, 
    -0.07978336f, 0.12210671f, 0.08792882f, -0.17053998f, 0.06874910f, -0.22977947f, 0.00181613f, 0.13549758f, 
    0.05317754f, -0.06704444f, 0.12903878f, 0.02959018f, 0.05277038f, 0.04888870f, 0.01462589f, -0.07964698f, 
    0.01327207f, -0.00915468f, 0.01871535f, 0.01804153f, 0.06838842f, 0.00516121f, 0.00901686f, 0.04976377f, 
    0.01382938f, -0.03060305f, -0.03556865f, 0.04047802f, -0.03472324f, -0.03951672f, 0.01405341f, -0.02511855f, 
    -0.02196255f, -0.05383216f, -0.02988493f, -0.03529960f, 0.03453636f, 0.00700369f, 0.00504716f, -0.03960122f, 
    0.00693584f, -0.01463988f, -0.03608635f, 0.02433277f, 0.00247096f, -0.02574572f, 0.03904063f, -0.00139355f, 
    0.00256297f, 0.02581473f, -0.03534317f, 0.01204945f, 0.00615306f, -0.01721061f, 0.04832887f, -0.01215075f, 
    -0.04347231f, 0.01944624f, -0.01737106f, 0.01659907f, 0.03963034f, -0.02649751f, -0.04103745f, -0.00421404f, 
    -0.04078327f, 0.01977028f, -0.02315289f, 0.03508586f, 0.03458228f, -0.00037940f, 0.01933301f, -0.02024296f, 
    0.00555422f, -0.03466273f, -0.01000519f, -0.00749182f, 0.02182091f, -0.04781564f, -0.00995637f, 0.01565730f, 
    0.03149563f, 0.02830947f, -0.01819201f, 0.00614487f, 0.00519860f, 0.00545372f, 0.04171408f, -0.00506001f, 
    -0.03505930f, 0.04546766f, -0.04242412f, -0.02055818f, 0.01115678f, 0.03291820f, 0.03159386f, -0.02446898f, 
    -0.01042055f, 0.02937974f, 0.03375041f, 0.03951341f, 0.00146102f, 0.03545593f, -0.03810243f, -0.03213245f, 
    -0.00423732f, -0.00594402f, -0.00426976f, -0.04394749f, 0.04411370f, 0.00887348f, 0.01690337f, 0.01896306f, 
    -0.04810705f, 0.00986668f, -0.04958281f, 0.04304464f, -0.02172308f, 0.01336504f, 0.03749479f, 0.01096341f, 
    0.04282876f, 0.00536948f, -0.03802119f, -0.03600231f, -0.01486105f, 0.01951561f, -0.03797183f, 0.02248637f, 
    0.01143968f, 0.00601395f, 0.01523954f, 0.04431595f, 0.04291608f, -0.01395370f, -0.00322981f, -0.00192464f, 
    -0.05106051f, 0.01027525f, -0.01295549f, -0.01329225f, 0.02004470f, -0.01187318f, -0.00955493f, 0.01682393f, 
    -0.01034590f, -0.03739065f, -0.01540372f, -0.00217432f, -0.03774163f, -0.03254281f, -0.02556531f, 0.04120918f, 
    -0.00839129f, -0.00278440f, -0.03588419f, 0.01984593f, 0.01963472f, 0.03056482f, -0.01790539f, 0.03783006f, 
    0.01301566f, 0.04901883f, 0.01566830f, 0.00904723f, -0.02919358f, 0.04325423f, -0.03834210f, -0.04911743f, 
    0.01859090f, 0.01385435f, -0.02057432f, 0.00730772f, 0.02314067f, -0.05613993f, -0.00796474f, -0.03649131f, 
    0.00979908f, -0.03181991f, -0.01500753f, -0.04766750f, 0.03652576f, -0.04747378f, 0.03858537f, -0.01217399f, 
    -0.03146653f, -0.03955881f, 0.01252774f, -0.01296457f, -0.00756722f, -0.04776271f, -0.03178462f, 0.01498569f, 
    -0.04730467f, -0.01231578f, 0.04083501f, 0.00379101f, -0.00438576f, 0.00104150f, -0.02427094f, -0.00799329f, 
    0.03574980f, 0.04179140f, -0.00433560f, -0.00226417f, -0.02814253f, -0.02750385f, -0.02434460f, 0.02241122f, 
    -0.02441822f, 0.01511900f, -0.04769478f, -0.02110224f, -0.00797566f, 0.01702580f, -0.02024885f, -0.04389795f, 
    -0.05397790f, -0.02748796f, 0.04037545f, 0.00362954f, 0.00556670f, 0.03359985f, 0.03438059f, -0.03189303f, 
    0.02515226f, 0.02533666f, -0.03702567f, -0.05179304f, -0.01287813f, 0.01242951f, 0.02731162f, -0.03502271f, 
    -0.02328538f, 0.03374567f, 0.02289954f, -0.05144242f, -0.05153912f, 0.01131336f, 0.02603241f, 0.01052920f, 
    -0.01092337f, -0.03684552f, -0.04278473f, 0.03784456f, -0.03967264f, 0.02174841f, -0.01194273f, -0.01889374f, 
    0.02645436f, 0.02169864f, 0.02274075f, -0.04759609f, -0.04886218f, -0.04155679f, -0.00210502f, -0.01837092f, 
    0.03563980f, -0.04203579f, -0.03534442f, -0.00268800f, -0.02976835f, 0.02830672f, 0.02910191f, 0.03608887f, 
    0.02064692f, 0.03693933f, -0.02979352f, -0.05049540f, -0.03501551f, -0.03361233f, -0.02443734f, -0.03482811f, 
    -0.03408823f, 0.03175684f, -0.03616318f, 0.01535406f, -0.03409173f, -0.03268301f, -0.03324579f, 0.01318032f, 
    0.01795965f, -0.05228464f, -0.02787754f, -0.03191147f, -0.03160787f, 0.01324383f, -0.03994624f, -0.01243325f, 
    0.05029375f, -0.02261470f, -0.01070853f, 0.01583294f, 0.03078370f, -0.03672468f, -0.01167809f, -0.00961971f, 
    0.02742869f, -0.04844850f, -0.01211144f, -0.03531945f, -0.02103450f, -0.02539940f, -0.01412138f, -0.03226516f, 
    0.04027961f, 0.04818283f, -0.05290248f, -0.00269464f, -0.01604152f, 0.02648405f, 0.02455091f, 0.02919489f, 
    0.00311223f, -0.04562374f, -0.05018855f, 0.03789425f, 0.01491567f, -0.00096572f, 0.03604518f, 0.02021925f, 
    -0.03227659f, 0.02407597f, -0.02094305f, -0.03085304f, 0.02219932f, -0.01289941f, -0.03412306f, -0.05600776f, 
    -0.03576215f, 0.00731684f, -0.02598356f, 0.03425610f, -0.05035053f, -0.04285411f, -0.05366996f, 0.03044957f, 
    -0.00553036f, 0.04690678f, -0.00569712f, 0.00041253f, 0.02430573f, -0.02529504f, 0.03499236f, -0.01948350f, 
    -0.00470218f, -0.02325666f, -0.03288992f, -0.03510804f, -0.02848833f, -0.03834756f, -0.03208948f, -0.02633910f, 
    0.02305507f, 0.03539906f, -0.05094206f, -0.02697437f, -0.03596796f, -0.04861812f, 0.00068703f, -0.04649592f, 
    -0.01682076f, -0.05206263f, 0.03905999f, 0.03408400f, -0.03834753f, -0.02041150f, 0.02243685f, -0.05593516f, 
    -0.02614102f, -0.04408881f, 0.00400490f, 0.01648626f, -0.02609736f, -0.02925454f, -0.04938954f, 0.04201705f, 
    0.02952702f, -0.01561922f, 0.01800238f, 0.01668929f, 0.00749601f, -0.03763188f, -0.04988408f, -0.00633649f, 
    -0.04078173f, 0.03732885f, -0.04170454f, -0.01048005f, -0.04796813f, 0.00451293f, -0.00379525f, 0.02545809f, 
    -0.01016927f, 0.03949241f, 0.04134635f, 0.02282845f, -0.04838150f, 0.00396486f, 0.03859351f, -0.03430951f, 
    -0.03163383f, -0.00129278f, -0.03259164f, 0.01970500f, -0.00504985f, -0.02183431f, 0.03024508f, 0.04006919f, 
    -0.05431464f, -0.02850687f, 0.04047804f, -0.05156377f, -0.22655977f, 0.22906928f, -0.00922418f, -0.08351140f, 
    -0.06756724f, 0.07093790f, 0.06327032f, -0.05833086f, -0.10583732f, -0.18185626f, -0.19315436f, -0.03777133f, 
    -0.01011370f, 0.07508329f, 0.08078744f, 0.09164231f, 0.00464400f, 0.05317928f, 0.14481685f, -0.09162413f, 
    0.48893514f, -0.01310793f, 0.04242785f, -0.10571527f, 0.05383140f, -0.04266971f, 0.00547672f, 0.03962908f, 
    0.04374712f, 0.05611645f, 0.02774414f, -0.01352823f, -0.33138567f, -0.09674392f, -0.20011556f, -0.11423818f, 
    -0.04841771f, 0.04793137f, 0.09857182f, 0.15375789f, 0.06317428f, 0.03417844f, -0.01914630f, -0.12830919f, 
    0.00566691f, -0.00371466f, 0.18481866f, -0.01010959f, 0.07048979f, 0.09506505f, -0.04622466f, 0.11454463f, 
    0.07847206f, 0.04017216f, -0.09904032f, -0.10292540f, 0.10406686f, 0.08936783f, -0.05133143f, 0.17500536f, 
    0.04387491f, -0.01939349f, -0.10008933f, -0.00829067f, -0.03206176f, 0.03603797f, 0.01487803f, 0.06795734f, 
    -0.09231951f, -0.05335344f, 0.14078844f, 0.16403903f, 0.01314573f, 0.08782235f, -0.03845965f, -0.01052244f, 
    0.05915374f, 0.06187973f, -0.00233195f, 0.15340908f, 0.12918310f, -0.12389448f, 0.13458461f, -0.04771308f, 
    0.02158143f, 0.05838287f, -0.14977726f, 0.08033635f, -0.04368595f, -0.10777489f, 0.15894693f, 0.05084733f, 
    -0.13379940f, 0.00527342f, 0.00942741f, 0.07181685f, -0.03583764f, -0.00882655f, 0.06500275f, 0.18625481f, 
    -0.11119021f, -0.05466007f, 0.01672292f, 0.01963901f, 0.03967313f, -0.30197352f, 0.00843527f, 0.09023608f, 
    -0.13422261f, 0.02861631f, -0.06301785f, -0.11902665f, 0.06514729f, 0.16207255f, -0.03205597f, -0.00784887f, 
    0.26903480f, -0.23583373f, 0.06145608f, -0.24985471f, 0.04091793f, -0.01710347f, 0.17719375f, 0.05361713f, 
    0.16781904f, -0.09365568f, 0.03842727f, -0.20021509f, 0.04028267f, 0.00180380f, -0.11036994f, -0.00982448f, 
    -0.09101072f, -0.06687738f, 0.02860126f, 0.03846897f, 0.02959696f, -0.01787740f, -0.05306939f, -0.16925481f, 
    -0.23133516f, -0.20889466f, -0.27542636f, -0.11741759f, -0.06017223f, -0.02409146f, 0.18080938f, -0.03150720f, 
    -0.03434642f, -0.01229130f, 0.13984962f, 0.07331295f, -0.04525812f, 0.00856614f, 0.00895129f, -0.01610572f, 
    -0.07743551f, 0.02526761f, 0.06580950f, -0.02387751f, 0.06121480f, -0.04609558f, 0.00164441f, 0.05680436f, 
    -0.42744547f, -0.06841500f, -0.04813369f, 0.09541540f, 0.08768865f, 0.05305196f, 0.01217764f, 0.14844847f, 
    0.18548918f, 0.17287573f, -0.06751864f, -0.02770793f, -0.06258999f, 0.11763909f, 0.06859487f, 0.00049509f, 
    -0.02500286f, -0.03068370f, -0.05576651f, 0.08587032f, -0.00227132f, 0.02095933f, -0.04635918f, -0.18098626f, 
    -0.03296647f, -0.16040906f, 0.12875946f, -0.14289956f, 0.03545357f, -0.10354523f, 0.10969633f, -0.18109541f, 
    0.06389716f, 0.05575342f, 0.13177946f, -0.05154280f, 0.00292731f, 0.09604637f, 0.08307119f, 0.05420982f, 
    -0.02395274f, -0.11325225f, 0.12180915f, -0.00995759f, -0.05309839f, -0.08420589f, 0.00182035f, 0.03956098f, 
    -0.14444734f, -0.19212024f, 0.08326332f, 0.20921770f, 0.11530606f, 0.07498196f, 0.01273584f, 0.16063850f, 
    0.02788006f, -0.17066601f, -0.05047818f, 0.24009763f, -0.10740802f, -0.10351111f, 0.01489083f, -0.06965687f, 
    -0.02118145f, 0.14222714f, 0.13050348f, 0.16324665f, 0.26950470f, 0.20881674f, -0.00377043f, 0.01957593f, 
    -0.24132967f, 0.02775136f, 0.15408716f, 0.36676463f, 0.07119454f, 0.05400055f, 0.16785385f, 0.01680770f, 
    0.08682636f, -0.12562664f, 0.07331341f, 0.04738200f, 0.20498359f, -0.08965682f, 0.09887148f, 0.17588209f, 
    0.03538080f, -0.06755166f, -0.01539242f, 0.09337979f, -0.15830652f, 0.26223788f, -0.02839913f, 0.12891889f, 
    -0.28374380f, 0.12788013f, 0.00102363f, 0.04469634f, 0.06124739f, 0.00747347f, 0.04181826f, 0.12956251f, 
    0.04177019f, -0.01036748f, 0.15486535f, -0.02577704f, -0.26789543f, -0.11353174f, -0.20491919f, -0.17858157f, 
    0.03302655f, 0.00855226f, -0.06723372f, -0.04594587f, 0.04773243f, 0.02533399f, 0.03526825f, 0.27097422f, 
    0.15753858f, -0.14718343f, -0.08431431f, -0.33052450f, 0.03856414f, 0.04442685f, -0.09872162f, -0.09660956f, 
    0.07562936f, -0.12248765f, -0.12329213f, 0.28807390f, -0.02039240f, -0.09314289f, -0.12068333f, -0.03627041f, 
    0.14473034f, 0.00327309f, 0.03385626f, -0.09356766f, 0.00346963f, 0.08993261f, -0.06502572f, 0.02056992f, 
    0.20547143f, 0.02301040f, 0.13775012f, 0.04600777f, -0.01906206f, 0.03872700f, 0.01705060f, 0.17732790f, 
    -0.09823911f, 0.09856550f, 0.11863876f, -0.01588742f, 0.07926530f, 0.11456009f, 0.45823547f, 0.17742747f, 
    -0.09164201f, 0.00470374f, 0.14822087f, 0.07258073f, -0.06070453f, 0.01044780f, -0.00692621f, -0.00880483f, 
    -0.08351140f, -0.05529900f, 0.37672994f, 0.30871594f, 0.12510671f, 0.07850371f, -0.16194603f, 0.15001622f, 
    0.08018328f, -0.04728557f, 0.10990471f, 0.04364237f, -0.39829963f, 0.37062404f, 0.04425014f, 0.09267617f, 
    0.08048618f, -0.03005362f, 0.16723362f, 0.11362019f, -0.14171599f, 0.02549675f, 0.06318735f, 0.09742874f, 
    0.31426242f, -0.18883607f, 0.15918922f, 0.10855416f, -0.13472943f, 0.24854951f, 0.06482793f, 0.28454801f, 
    -0.02083999f, 0.08694559f, 0.08180153f, -0.13705005f, -0.02134467f, 0.06148562f, 0.01294235f, 0.02506305f, 
    0.02550389f, 0.05216169f, 0.00750298f, -0.08290732f, -0.04511977f, -0.07842290f, -0.00325199f, -0.17942201f, 
    -0.03524991f, 0.00112425f, -0.08725601f, 0.21540472f, -0.01574143f, 0.07385311f, 0.06327748f, -0.07929675f, 
    -0.15405871f, 0.07579796f, -0.01913848f, -0.09768079f, 0.27698421f, -0.11560118f, -0.20431158f, -0.20768560f, 
    0.15590578f, 0.12673615f, 0.06894393f, 0.09127934f, 0.01652296f, -0.12765507f, 0.13287033f, 0.14764905f, 
    0.11531583f, -0.09794235f, 0.09450227f, -0.27973643f, -0.02594218f, -0.04696677f, 0.06894450f, 0.02914288f, 
    0.11606552f, 0.18811280f, 0.13038424f, 0.04653478f, -0.01281553f, -0.21254744f, -0.27910763f, -0.00509917f, 
    0.19263421f, 0.13794225f, 0.08217502f, -0.00221862f, 0.04344534f, -0.01121394f, 0.02154244f, 0.08090304f, 
    0.23454998f, 0.11461621f, -0.19281207f, -0.03492984f, 0.09513336f, 0.08255619f, -0.03334653f, 0.06308956f, 
    0.04260893f, 0.02472121f, -0.05158432f, -0.06466570f, -0.25086090f, 0.09971394f, 0.35855460f, 0.41538271f, 
    0.07512150f, 0.00160240f, -0.09252045f, -0.02399363f, -0.01818031f, -0.02484395f, 0.08048587f, -0.01613172f, 
    0.05619940f, 0.09284415f, 0.13024224f, 0.00845185f, -0.13363384f, -0.11021613f, -0.05000083f, 0.20011920f, 
    -0.03829471f, 0.01281187f, 0.11038701f, -0.03848115f, 0.06839939f, -0.03552297f, 0.25910836f, 0.08755081f, 
    0.11745678f, 0.08184084f, -0.11480401f, 0.05052274f, 0.07035551f, -0.05519716f, 0.00869282f, -0.05182204f, 
    -0.14165729f, -0.01275078f, -0.06536926f, 0.15774941f, 0.03368440f, 0.05806429f, -0.11803454f, -0.07806379f, 
    -0.04403032f, 0.01546545f, -0.08793942f, 0.00939851f, 0.16315176f, 0.13219269f, -0.21428922f, 0.02426334f, 
    0.19942427f, -0.04694591f, 0.11649861f, 0.09769030f, 0.07017959f, -0.05144932f, -0.02350278f, -0.06117927f, 
    -0.05003080f, -0.12104163f, -0.06602731f, -0.10153240f, 0.00010387f, 0.12850329f, -0.02924287f, 0.00341408f, 
    0.14243479f, 0.13976192f, 0.13446109f, 0.01727783f, -0.19962646f, -0.02649476f, -0.01893073f, 0.10896740f, 
    -0.04456161f, 0.06452117f, -0.04642436f, 0.01508657f, -0.06608240f, -0.07346854f, -0.00323050f, 0.05950872f, 
    0.22927621f, 0.11632377f, 0.04674426f, -0.11122181f, 0.18385163f, 0.04863492f, -0.03674681f, 0.04767918f, 
    0.02312710f, 0.04183786f, -0.04318110f, 0.22071883f, -0.00307355f, 0.23192018f, -0.22143060f, 0.01372940f, 
    -0.10761511f, 0.10744761f, -0.00737186f, -0.03023181f, -0.08883668f, 0.08970354f, 0.04661480f, 0.01288653f, 
    -0.02760083f, -0.32524011f, -0.30115491f, -0.01149947f, 0.15017058f, 0.17404303f, 0.05608968f, -0.02748080f, 
    0.12311809f, 0.00517927f, 0.02704155f, 0.01943588f, -0.01668500f, 0.20204341f, 0.07082427f, 0.13290851f, 
    -0.03597036f, 0.04567599f, 0.03674003f, -0.02203067f, 0.07955220f, 0.08307824f, 0.09727584f, 0.09457955f, 
    0.17276046f, 0.19282906f, 0.17452042f, 0.01360151f, 0.01213462f, 0.08534759f, -0.04681675f, -0.00926781f, 
    -0.00072588f, 0.02917139f, -0.03782560f, 0.03050148f, -0.02751992f, 0.09652028f, -0.27342051f, -0.09389930f, 
    -0.01863404f, 0.01953479f, -0.03140230f, 0.02025554f, -0.01880201f, 0.04090178f, -0.02138167f, 0.10737360f, 
    -0.12324329f, 0.27856195f, -0.27013764f, 0.13385890f, 0.12906529f, 0.03770547f, -0.08634867f, -0.03809755f, 
    0.03908966f, -0.00761996f, 0.21717781f, -0.14821593f, 0.13677260f, 0.09450798f, -0.00960328f, 0.07217538f, 
    -0.01306827f, -0.07265507f, -0.04149151f, -0.13919917f, 0.02826285f, 0.07325356f, 0.05515265f, 0.10544985f, 
    -0.48457801f, -0.25805765f, -0.03344983f, 0.25786576f, -0.10327300f, 0.17390037f, -0.16147910f, 0.04393502f, 
    -0.09857418f, -0.02158305f, 0.02774884f, 0.08794733f, 0.22064267f, -0.09099601f, 0.21007502f, -0.20200802f, 
    0.10448766f, 0.05499819f, -0.07816719f, 0.17052713f, 0.04601119f, 0.06751102f, 0.06961162f, -0.00100601f, 
    -0.33599383f, 0.04475103f, -0.38893217f, 0.06734230f, 0.02582565f, 0.02012913f, -0.01207854f, -0.09512098f, 
    -0.23115957f, -0.10313152f, 0.12013478f, 0.07593820f, 0.08381497f, -0.08857424f, -0.04614897f, -0.05952711f, 
    0.06014430f, 0.06492435f, 0.01579193f, 0.00448195f, 0.10734946f, 0.01529776f, -0.02786831f, -0.05708433f, 
    -0.00783004f, 0.04630981f, -0.21413361f, 0.04274775f, 0.11853033f, 0.04745171f, -0.00701021f, -0.05469228f, 
    -0.08135188f, 0.05691353f, 0.21735327f, -0.06737652f, 0.16298693f, 0.12897463f, 0.06011501f, -0.24268393f, 
    0.09246708f, -0.05265732f, -0.05745734f, -0.11519144f, 0.01656514f, -0.05034632f, -0.16706294f, -0.12341674f, 
    0.04900160f, 0.37601304f, -0.07220838f, -0.17097040f, 0.15494290f, -0.11325332f, -0.03352527f, -0.01513781f, 
    -0.13767006f, 0.01424722f, -0.12712744f, 0.10196801f, 0.15052229f, 0.27028045f, 0.33411857f, 0.00752498f, 
    -0.05868784f, -0.13988553f, -0.29725718f, -0.02667212f, 0.07680643f, 0.05770528f, -0.05354243f, 0.00260156f, 
    0.08087686f, 0.14102089f, -0.05543705f, -0.00629155f, 0.03212044f, -0.05526745f, 0.06720067f, 0.07322804f, 
    -0.08811386f, -0.05261170f, -0.06527114f, 0.05561700f, -0.07413505f, 0.35918069f, -0.47124201f, -0.06713786f, 
    -0.06144967f, -0.00494952f, 0.15732701f, -0.14043067f, 0.00048382f, -0.11434076f, -0.00876233f, 0.01328807f, 
    0.00505251f, -0.08504100f, 0.48979983f, 0.16535443f, -0.04754124f, 0.00868681f, -0.19136694f, 0.05790351f, 
    0.09302759f, 0.02172204f, 0.07157166f, 0.07927631f, -0.09109356f, -0.18126586f, 0.02468717f, 0.26128891f, 
    -0.04906883f, -0.04126615f, -0.04417856f, 0.08708288f, 0.06953047f, 0.18203287f, 0.01806140f, 0.09388342f, 
    -0.06230517f, 0.16013813f, 0.06367527f, 0.11981224f, 0.02521597f, -0.08281321f, -0.02544476f, -0.11896263f, 
    0.05933986f, 0.11018202f, 0.11412886f, -0.07364886f, 0.08891399f, -0.14823262f, 0.08994540f, 0.14076674f, 
    0.04420240f, -0.14573380f, 0.06545676f, 0.10821782f, -0.07062140f, -0.07045213f, -0.14521393f, 0.06458627f, 
    0.41411510f, -0.04617900f, -0.26583254f, 0.09858741f, -0.05476195f, -0.02738488f, 0.08885475f, -0.12329370f, 
    0.05264089f, 0.03181810f, 0.17493540f, 0.16011286f, 0.05521854f, -0.03358158f, 0.22066331f, 0.14550669f, 
    -0.10187455f, -0.14616878f, -0.05249224f, 0.10423061f, 0.16971995f, 0.03330864f, 0.02981553f, 0.12500277f, 
    -0.06198681f, 0.08606245f, 0.25026476f, 0.04798261f, 0.06369554f, 0.07356004f, -0.09088238f, 0.05296268f, 
    0.12743767f, -0.09141178f, 0.02456318f, -0.01522745f, -0.17265570f, 0.16067760f, -0.56727427f, 0.08033211f, 
    0.02339567f, -0.05106238f, 0.01762106f, -0.01298050f, 0.06479686f, 0.09506870f, 0.00088856f, -0.09276889f, 
    -0.07262466f, 0.09772802f, 0.13311604f, 0.32449898f, 0.05949565f, 0.06406210f, 0.08839190f, -0.07019300f, 
    0.02921526f, 0.03738556f, 0.00432019f, 0.01003246f, -0.22885852f, 0.12546811f, -0.15999509f, -0.14158963f, 
    0.03555525f, -0.08889317f, -0.11485693f, -0.16127858f, -0.05263275f, -0.06786469f, 0.00173493f, -0.10788314f, 
    -0.13811933f, 0.18675141f, 0.07805199f, -0.00937552f, 0.02533509f, -0.03658723f, 0.18347660f, 0.01560600f, 
    0.00813742f, 0.00927877f, -0.02781272f, 0.00365957f, -0.00356679f, -0.00690559f, 0.19654837f, 0.15881324f, 
    -0.12584417f, 0.02394677f, 0.03602971f, 0.09448040f, -0.03440209f, 0.07036301f, -0.00449379f, 0.05477065f, 
    0.10021466f, 0.02194672f, -0.00666601f, 0.12579592f, -0.05654579f, -0.06000687f, 0.00159568f, 0.03099097f, 
    0.16333003f, 0.05957227f, -0.05536430f, 0.00752570f, -0.00021166f, -0.04280966f, -0.12657167f, -0.13423216f, 
    -0.03266035f, -0.06055080f, 0.17785946f, 0.04688491f, 0.14346726f, 0.25705850f, 0.14797291f, 0.07318537f, 
    -0.26649427f, -0.34120914f, -0.17912355f, 0.11358110f, -0.12319073f, -0.14835438f, 0.12507288f, -0.02884954f, 
    0.07366442f, -0.01861063f, 0.04353295f, 0.12675799f, -0.15257239f, -0.12653556f, 0.06631835f, -0.02166741f, 
    0.00551783f, -0.01396960f, -0.07555077f, -0.09275221f, 0.05210671f, 0.02537504f, -0.04188436f, 0.01274215f, 
    0.10446975f, 0.12809378f, 0.21299809f, 0.15471750f, -0.03923469f, -0.15715402f, 0.03427785f, 0.07213340f, 
    0.05189821f, 0.07663709f, 0.07155609f, 0.17500576f, -0.15333451f, -0.16464233f, 0.05600853f, -0.11768144f, 
    0.02626178f, 0.07061651f, 0.04705972f, 0.00679799f, 0.01037567f, 0.01999937f, 0.02998606f, -0.06045646f, 
    0.00299980f, -0.22142358f, -0.03171701f, 0.15025541f, -0.02589970f, -0.06253743f, 0.12832655f, -0.02959464f, 
    0.09478605f, 0.06852373f, 0.03460328f, 0.09743669f, -0.04601937f, -0.13354185f, 0.00571817f, -0.02794671f, 
    0.02974509f, 0.05042329f, -0.01569805f, -0.01523510f, -0.06270938f, 0.07570583f, -0.08548774f, 0.00100757f, 
    -0.19556652f, 0.24227037f, -0.14850186f, 0.26740369f, 0.10174474f, 0.00384549f, -0.00967119f, 0.03054225f, 
    -0.00903714f, -0.04473430f, 0.12740253f, 0.11698383f, -0.22802769f, -0.13228969f, -0.04315396f, 0.13005084f, 
    -0.02104663f, 0.04085264f, 0.12283395f, -0.10218330f, 0.11783623f, 0.02814688f, 0.01352983f, 0.12351958f, 
    -0.31721416f, 0.38862801f, 0.00501344f, 0.05197464f, 0.11129737f, -0.18321681f, 0.07423609f, 0.06415525f, 
    0.05485614f, -0.00468796f, 0.01542773f, 0.04700714f, 0.40754551f, -0.07239332f, -0.28361806f, -0.06127290f, 
    0.06959196f, -0.02289071f, 0.06155724f, -0.13633890f, -0.00122501f, 0.11328758f, 0.04444925f, 0.07782426f, 
    0.03093687f, 0.20286582f, 0.11610880f, 0.04485169f, -0.01371046f, -0.13269757f, -0.06685522f, -0.08850908f, 
    0.03271465f, 0.22432755f, 0.06515543f, 0.00006012f, 0.17069380f, -0.04411838f, 0.08666121f, -0.24052718f, 
    0.00030632f, 0.04613728f, -0.07335809f, -0.05678093f, 0.09496461f, 0.03383587f, 0.12195131f, 0.21655492f, 
    0.01969562f, 0.27710083f, -0.20866694f, -0.06283873f, 0.00541842f, -0.05185355f, -0.15777490f, 0.05582310f, 
    0.01754441f, 0.04871310f, 0.06393363f, 0.08034939f, 0.03486442f, -0.01997012f, -0.08787663f, 0.03051191f, 
    -0.02374923f, -0.06018950f, -0.08933040f, -0.04167819f, 0.04972388f, -0.00605726f, -0.01193058f, 0.05001146f, 
    0.16136818f, -0.05831277f, -0.19357297f, 0.06916375f, -0.07211678f, 0.02615551f, -0.08991126f, -0.15621801f, 
    -0.04218237f, 0.09090807f, -0.14875071f, -0.01376085f, -0.15995543f, -0.01756624f, -0.20967902f, 0.27948359f, 
    0.14262611f, 0.15671462f, 0.25170887f, 0.05287671f, -0.00456241f, -0.13691938f, -0.04577732f, -0.01175967f, 
    -0.25516644f, -0.05350772f, 0.00125597f, 0.03937678f, -0.07931503f, -0.06340362f, -0.03709406f, 0.00426823f, 
    -0.01459563f, -0.00538066f, 0.06325338f, 0.03736642f, -0.06172258f, -0.17996162f, 0.16819216f, -0.12171657f, 
    -0.03602568f, 0.08245770f, -0.10824324f, 0.11924340f, -0.05211974f, 0.10664126f, -0.00694022f, -0.07631566f, 
    -0.17263345f, 0.39202505f, -0.25121197f, -0.12483744f, -0.03960663f, 0.18670928f, 0.00693515f, -0.10247325f, 
    0.01174539f, -0.01649201f, -0.04351896f, -0.20945460f, -0.07858098f, -0.04828211f, 0.04128438f, -0.29902545f, 
    0.10398120f, 0.10591420f, -0.01933053f, -0.04038519f, 0.08655568f, -0.15180257f, 0.20700784f, 0.23594421f, 
    0.17406352f, -0.06208253f, 0.12000022f, -0.09879313f, -0.08786518f, -0.04959109f, -0.08303217f, 0.07505172f, 
    0.00971652f, 0.18048002f, 0.00990716f, -0.07201866f, 0.14831251f, -0.02031923f, -0.05875460f, 0.03619226f, 
    0.15871400f, -0.02371084f, 0.04750428f, 0.00055532f, 0.00181346f, 0.00039698f, 0.11648192f, -0.14477929f, 
    0.37836340f, 0.20176233f, -0.03665167f, -0.35874987f, -0.05756288f, -0.08874891f, -0.04126522f, -0.02417294f, 
    -0.02030901f, -0.00063882f, -0.07820018f, 0.01430623f, -0.14701369f, 0.08879462f, 0.13187906f, 0.10695959f, 
    0.06831425f, 0.03565782f, 0.05640336f, 0.09633142f, -0.11913338f, 0.08898484f, 0.02242173f, 0.04616833f, 
    -0.16675261f, -0.23474856f, -0.10443576f, 0.13806394f, 0.04304475f, 0.08232765f, 0.11150218f, 0.06049474f, 
    0.05135623f, 0.05957286f, 0.07763483f, 0.02370573f, -0.12669218f, 0.01190915f, 0.30292222f, -0.12298154f, 
    -0.13481997f, 0.02368313f, -0.16923068f, -0.11584335f, -0.07426615f, -0.05153279f, 0.07572376f, -0.08203106f, 
    -0.10864063f, -0.27101594f, 0.10377622f, 0.14944227f, -0.05481293f, 0.12999712f, 0.02187138f, -0.00227832f, 
    0.01448603f, -0.08552932f, 0.05847124f, 0.12880507f, -0.00056492f, -0.14682829f, 0.15689825f, -0.00911837f, 
    -0.08206023f, -0.16331279f, -0.05645208f, 0.11646298f, -0.11451122f, 0.01015688f, -0.06519087f, -0.10656602f, 
    -0.06499253f, -0.12385242f, 0.17021108f, 0.23327796f, -0.09491437f, -0.10575046f, 0.05349973f, -0.03569886f, 
    -0.10494641f, -0.00023097f, -0.07468650f, -0.05340558f, -0.30737129f, -0.34726363f, -0.17957760f, 0.00149518f, 
    -0.00158336f, -0.10437231f, 0.07543946f, 0.01717436f, -0.01502708f, 0.00843499f, 0.01165227f, -0.12573829f, 
    0.61459476f, 0.09830409f, 0.14198758f, 0.02786387f, 0.10755779f, -0.04649135f, 0.00519207f, 0.00401379f, 
    -0.15415332f, 0.17166162f, 0.07802138f, 0.10288107f, -0.06227682f, 0.10279373f, 0.06871225f, -0.01325885f, 
    -0.11512131f, 0.00482634f, -0.11957847f, 0.04772492f, 0.01622071f, 0.21375003f, 0.06208696f, -0.01373901f, 
    -0.06143152f, -0.23280551f, -0.05281616f, 0.10492119f, -0.06895950f, -0.02418345f, 0.06108003f, 0.05062541f, 
    0.01688718f, 0.05630584f, 0.03158741f, 0.04836505f, -0.03000607f, 0.08420645f, 0.07338640f, -0.05599344f, 
    0.00688667f, -0.00657205f, -0.04991022f, -0.07345980f, -0.07364505f, -0.10646750f, -0.14932995f, 0.08641586f, 
    -0.02233399f, 0.12114791f, 0.14662942f, 0.19656509f, -0.04125795f, 0.09020285f, 0.04612571f, 0.01262467f, 
    0.03241966f, 0.10232126f, 0.02603661f, 0.07459508f, -0.08174798f, 0.24602957f, 0.11520154f, 0.10668213f, 
    -0.10320386f, -0.08821253f, -0.00834067f, -0.01080421f, 0.07948303f, 0.13701071f, -0.09546635f, 0.08031833f, 
    0.06648829f, -0.37031984f, -0.05859830f, -0.08817520f, 0.01886150f, -0.03346068f, -0.16003013f, -0.04667211f, 
    -0.00277395f, -0.00861124f, -0.06246838f, 0.02476606f, 0.09369984f, 0.06235077f, 0.08531324f, -0.26756951f, 
    -0.01768214f, -0.03521499f, -0.08353290f, -0.02063308f, -0.15291911f, -0.04595706f, 0.01813527f, -0.04075773f, 
    0.52793199f, -0.21162558f, 0.66892290f, 0.13112941f, -0.04733143f, 0.14470367f, -0.10579310f, 0.05248585f, 
    -0.00148906f, 0.07972314f, 0.21175873f, -0.03930396f, -0.00305329f, 0.18243600f, 0.03942551f, -0.07458632f, 
    -0.03889646f, 0.09699289f, -0.06239129f, 0.04741420f, 0.04913479f, 0.02825358f, 0.25581884f, 0.08824380f, 
    -0.35079286f, 0.20395684f, 0.29837868f, 0.51083356f, 0.00666325f, 0.04399941f, -0.04171763f, 0.07339538f, 
    0.05911704f, 0.19077122f, 0.13808882f, 0.14232676f, 0.36060554f, -0.07266014f, 0.09293118f, -0.08729549f, 
    -0.11364764f, 0.07763520f, 0.02078856f, 0.10435948f, 0.04951245f, 0.02036193f, 0.06450289f, -0.02421300f, 
    0.04418379f, -0.03511053f, 0.09925856f, 0.22122456f, 0.06897837f, -0.13846414f, 0.08616675f, 0.13567387f, 
    -0.04372355f, -0.05610773f, 0.15141587f, 0.10099537f, -0.27060467f, 0.00578364f, -0.22086132f, -0.29642299f, 
    0.02765755f, -0.07855310f, -0.07954010f, -0.10702455f, -0.11121586f, -0.03628493f, 0.05180916f, 0.05102317f, 
    0.34728569f, -0.08260675f, 0.16374341f, -0.14200015f, -0.09141538f, 0.00214187f, -0.08001366f, -0.02283312f, 
    -0.00189239f, 0.01288111f, 0.15373944f, 0.11026612f, -0.02782767f, 0.03958951f, -0.08009140f, 0.01307255f, 
    -0.02198485f, -0.02585509f, -0.11955322f, 0.01734934f, -0.16404656f, 0.03560913f, -0.00068258f, -0.05087142f, 
    0.23556267f, 0.19446310f, 0.08359435f, -0.37096256f, -0.07113503f, -0.00027797f, 0.03670115f, -0.04257162f, 
    0.01855555f, 0.05279564f, 0.15972807f, 0.11500967f, 0.00532999f, 0.09022256f, 0.44353750f, -0.05600487f, 
    -0.06140178f, -0.03105717f, -0.11933322f, -0.08338490f, 0.02084075f, 0.01301091f, -0.01359613f, 0.03762139f, 
    -0.14558208f, -0.19161436f, 0.08559842f, 0.10517422f, -0.03716374f, -0.02675050f, 0.06968006f, -0.05691870f, 
    -0.04768988f, 0.04286601f, -0.06918029f, -0.05147844f, -0.30851793f, 0.61366105f, -0.10731027f, 0.02504654f, 
    0.22428182f, 0.00186905f, 0.04184013f, -0.03506450f, 0.00253290f, 0.09614448f, 0.16262661f, -0.00651174f, 
    -0.04015248f, -0.20354134f, 0.37962171f, 0.10714596f, -0.07771378f, -0.10539307f, 0.12150249f, 0.07973789f, 
    0.04600548f, 0.07597028f, -0.09544872f, 0.13521162f, -0.23550577f, 0.22920902f, -0.08512469f, 0.18425438f, 
    -0.10843083f, 0.00594540f, -0.03539755f, -0.05345388f, -0.00489815f, 0.13393864f, -0.11860970f, 0.20367871f, 
    -0.24052100f, -0.08810057f, -0.02812012f, -0.09191694f, -0.08348256f, 0.08009849f, -0.01424043f, 0.05811550f, 
    0.00045164f, 0.09966061f, 0.01840894f, 0.06438029f, -0.02738451f, -0.05948025f, 0.01833034f, 0.02106035f, 
    0.04038077f, -0.05546738f, 0.09938411f, 0.09791623f, 0.12382928f, 0.18107095f, 0.02163704f, 0.02568901f, 
    0.49773335f, 0.08534573f, -0.03980441f, 0.12882331f, 0.13111949f, 0.01518415f, 0.00174656f, 0.07040431f, 
    0.08656140f, 0.22231853f, 0.28913063f, 0.05719711f, -0.31381080f, -0.01806454f, 0.06279140f, -0.07064281f, 
    -0.13036464f, -0.02141108f, 0.02042962f, -0.01308058f, -0.05500931f, -0.08632733f, -0.06855343f, 0.05135769f, 
    -0.03294976f, -0.02964843f, 0.13125196f, -0.15292352f, -0.19530359f, 0.07167656f, -0.03584798f, -0.03878838f, 
    0.06291587f, 0.15182936f, -0.10377513f, -0.10656312f, 0.02081397f, 0.19371729f, 0.09854643f, 0.07478926f, 
    0.00100496f, 0.04361421f, -0.06652711f, 0.00300700f, -0.04505647f, -0.01155589f, 0.05926923f, -0.04628200f, 
    -0.28582561f, -0.35105276f, 0.03968661f, -0.34416622f, 0.10402694f, 0.05185027f, 0.01316349f, -0.06250221f, 
    0.09975297f, 0.03080476f, 0.08303180f, 0.06524581f, 0.00431727f, 0.02450565f, 0.10235352f, -0.09781252f, 
    0.01771148f, 0.04912649f, -0.00796699f, 0.01411958f, -0.13063793f, -0.07240643f, -0.03187869f, -0.00116595f, 
    -0.16103350f, 0.08101030f, 0.01890553f, -0.08088555f, -0.22109573f, 0.01643086f, 0.01948655f, 0.25097108f, 
    -0.03373245f, -0.09583170f, -0.11552598f, -0.02222667f, -0.12069120f, -0.40744978f, -0.40181220f, -0.35878423f, 
    -0.18722735f, -0.08003377f, -0.01035695f, -0.08650075f, 0.03231477f, 0.08989785f, -0.01406279f, 0.01992224f, 
    -0.28458107f, 0.07557544f, -0.02155679f, 0.08821307f, 0.12449839f, -0.00476853f, -0.00569111f, -0.03884185f, 
    0.09163417f, 0.19636415f, 0.04152847f, -0.19233494f, -0.00837693f, 0.05879803f, -0.01160398f, 0.01947534f, 
    -0.00639171f, 0.01952715f, -0.00981317f, -0.01772325f, -0.03599253f, 0.23087537f, 0.11574260f, -0.14819448f, 
    -0.21934196f, -0.05526863f, -0.13698985f, -0.19752304f, -0.08331788f, -0.06606991f, -0.03631405f, -0.02388567f, 
    0.11505581f, 0.14021628f, 0.10752278f, -0.10594495f, 0.02012889f, 0.07066426f, 0.04978774f, -0.08840257f, 
    -0.02915066f, 0.05093436f, -0.02692062f, -0.02049334f, -0.06631263f, -0.05972094f, -0.04343603f, 0.13761461f, 
    -0.22274257f, -0.00573262f, 0.16481183f, 0.19777434f, 0.01475381f, 0.09197405f, -0.00525879f, 0.15539794f, 
    0.06660166f, 0.10107329f, 0.00378845f, 0.04316938f, -0.07431764f, 0.12815687f, 0.04705786f, 0.03622957f, 
    -0.05738146f, -0.00007139f, 0.00078093f, -0.00683813f, -0.05091196f, -0.04096913f, -0.05668980f, -0.03878555f, 
    -0.26530448f, -0.02853710f, -0.15797153f, -0.41314948f, -0.06774238f, -0.08991595f, -0.11244835f, -0.06643685f, 
    0.11865281f, 0.12383458f, 0.09602049f, -0.02199061f, 0.09138218f, 0.10389519f, 0.03862500f, 0.01792804f, 
    -0.02219785f, 0.00677796f, 0.01854399f, -0.00253492f, -0.14216037f, -0.02489265f, 0.09448453f, -0.02937629f, 
    -0.30389914f, -0.02647582f, -0.05953040f, 0.01432169f, 0.14311907f, 0.17077683f, -0.18632460f, 0.26658693f, 
    0.06630471f, -0.10631405f, 0.06534622f, 0.15268581f, 0.15272230f, -0.24873751f, -0.16840775f, 0.01731897f, 
    0.20163514f, 0.15180534f, 0.11910182f, 0.24400012f, 0.35044596f, 0.17682700f, 0.25719896f, 0.17003298f, 
    -0.18185672f, 0.18886220f, 0.10273572f, -0.09265478f, -0.00551716f, 0.05766445f, 0.16074392f, 0.10399412f, 
    0.05311824f, 0.08207978f, 0.02861663f, 0.05463856f, 0.15365826f, -0.18593842f, 0.10628811f, 0.12807584f, 
    0.11184797f, 0.01760718f, -0.01701870f, 0.20746690f, -0.03132503f, 0.08184639f, 0.09712417f, 0.17719944f, 
    -0.09882574f, -0.15751782f, 0.01484361f, 0.05173934f, 0.03195171f, 0.03462017f, 0.02006742f, 0.08473738f, 
    0.09018150f, -0.02101133f, -0.03813450f, 0.17100446f, -0.29942906f, -0.15497732f, -0.12094991f, 0.00274959f, 
    0.02321022f, -0.05646120f, -0.03472731f, -0.10046726f, 0.02029110f, -0.02422831f, 0.00199542f, 0.14164315f, 
    -0.40294075f, 0.12815112f, -0.12008084f, -0.02380273f, 0.00703337f, 0.02430268f, -0.09334777f, -0.06029167f, 
    0.08388039f, 0.01787466f, 0.00970068f, 0.19042026f, -0.10208701f, -0.17757866f, -0.12099271f, 0.02570624f, 
    0.30165559f, -0.05281417f, -0.00038660f, -0.02037706f, 0.08444320f, 0.02508399f, -0.04793842f, 0.01141492f, 
    0.04033323f, -0.00717343f, -0.07770897f, 0.10903049f, 0.06620718f, -0.08378154f, 0.07746862f, 0.16227417f, 
    0.08413533f, 0.08971331f, 0.08449141f, -0.11069005f, 0.07950547f, 0.17330956f, 0.02866488f, -0.05546737f, 
    0.22370079f, 0.15005639f, -0.04623384f, -0.03721940f, -0.05202147f, -0.03805681f, -0.09594645f, 0.00007916f, 
    -0.01622828f, 0.06420156f, -0.11704237f, -0.04447553f, 0.03136591f, -0.09919109f, 0.03240991f, 0.10399496f, 
    0.18301451f, 0.03813011f, 0.01779454f, 0.10552958f, -0.05154473f, -0.11703192f, 0.14367056f, 0.12984146f, 
    0.02649222f, -0.12693243f, 0.12709826f, 0.21171786f, 0.24989066f, 0.23027007f, 0.29627997f, 0.07618745f, 
    0.17751814f, -0.17094809f, 0.33091992f, 0.01794327f, 0.03246758f, 0.07016195f, 0.04311384f, 0.22618009f, 
    -0.02106862f, -0.00469602f, 0.00634099f, 0.02209752f, 0.01419132f, 0.01538850f, -0.03000467f, -0.00725894f, 
    0.03953853f, 0.04809190f, -0.00270779f, -0.07356581f, -0.15155838f, -0.00598783f, 0.04293960f, 0.09556846f, 
    -0.14371225f, 0.15173855f, -0.20763807f, 0.08961097f, -0.06659407f, 0.08603499f, -0.02420961f, -0.22665505f, 
    0.03584007f, 0.19857784f, 0.00288030f, -0.14152573f, -0.15740153f, -0.29346851f, 0.12079383f, 0.01945038f, 
    0.28114557f, 0.06819585f, 0.00958103f, -0.09199076f, -0.18434398f, -0.09162199f, 0.10051087f, 0.15641764f, 
    -0.17524910f, -0.04347932f, 0.17956650f, 0.23301372f, 0.03013137f, 0.07342306f, 0.05759889f, -0.06556176f, 
    -0.00339093f, 0.15421185f, 0.17613435f, 0.12598373f, -0.14792165f, 0.10669282f, 0.08994169f, 0.04332749f, 
    0.05953186f, -0.03091241f, 0.00268625f, 0.04385067f, -0.06420640f, -0.00212706f, 0.07631151f, 0.07395798f, 
    0.18665542f, 0.20918952f, 0.10471426f, -0.18527627f, 0.06935851f, 0.03777635f, -0.04107650f, 0.06189033f, 
    -0.05852113f, -0.02351112f, 0.00131111f, -0.01202936f, 0.05846112f, 0.23379068f, -0.41957381f, 0.34389955f, 
    0.10659420f, -0.03671290f, -0.01069507f, -0.01204479f, -0.03027026f, 0.04383364f, 0.00138834f, -0.04886422f, 
    0.09026553f, 0.08627211f, 0.21539091f, 0.08931237f, -0.04272946f, 0.05027921f, 0.15439881f, 0.01292008f, 
    -0.00456685f, 0.00075875f, 0.01854615f, 0.00617585f, 0.03899035f, 0.03686745f, -0.04159767f, -0.11779945f, 
    0.06477088f, 0.09936942f, -0.22668625f, -0.04942149f, 0.00371436f, -0.16661420f, -0.10882860f, -0.04164112f, 
    -0.20863137f, 0.08068570f, -0.18095276f, -0.08603784f, 0.08886976f, -0.03458780f, -0.05163345f, 0.07394291f, 
    0.05518670f, -0.02092045f, 0.04622864f, 0.06253182f, 0.27965090f, 0.26704034f, -0.02492054f, -0.21654594f, 
    0.02255083f, -0.03068241f, -0.01948872f, -0.04752560f, -0.04780823f, -0.01811203f, 0.02088594f, -0.04568260f, 
    -0.34459448f, 0.11808873f, 0.15930843f, 0.03264999f, -0.08484893f, 0.05379233f, -0.00943926f, -0.00378259f, 
    0.21504286f, 0.12846030f, 0.07824863f, 0.08547602f, -0.11182568f, -0.29331580f, -0.24374472f, -0.11538203f, 
    -0.03848393f, 0.09638817f, 0.08364548f, 0.01996193f, 0.11554296f, 0.20071465f, 0.07840411f, 0.08007673f, 
    -0.01948222f, -0.04810776f, -0.07480059f, -0.16430680f, 0.12535456f, -0.01611976f, 0.13008128f, 0.12384183f, 
    -0.05935537f, 0.00252669f, 0.05156457f, 0.18960401f, -0.34872806f, 0.01317525f, -0.06249394f, -0.01483847f, 
    -0.02371454f, 0.07296561f, 0.07018756f, -0.08297979f, 0.16418022f, 0.03845612f, 0.00664367f, 0.09812579f, 
    -0.17645819f, -0.07615614f, 0.10895733f, 0.31138837f, 0.13650681f, -0.01548120f, -0.02745678f, -0.03558220f, 
    -0.00462790f, 0.09641583f, 0.00929931f, 0.09250480f, -0.19202912f, -0.17862646f, -0.04106827f, 0.04282368f, 
    0.10041229f, 0.14256462f, 0.07387735f, 0.10602573f, 0.08812944f, 0.00370510f, -0.08788361f, 0.02846378f, 
    0.14377171f, 0.23090328f, 0.11647841f, -0.21678281f, -0.10660810f, 0.18026008f, 0.23983620f, 0.02091944f, 
    -0.02974585f, 0.02756731f, -0.03687328f, -0.04464326f, -0.12315203f, -0.32784203f, -0.02316923f, 0.22795148f, 
    0.06493589f, -0.12166204f, 0.10964084f, -0.05591962f, 0.04695689f, -0.00633312f, -0.04888728f, 0.08969384f, 
    -0.44016635f, -0.20070076f, -0.49434274f, 0.08347365f, 0.05615632f, -0.10122784f, -0.01156715f, 0.10778857f, 
    0.09214617f, -0.08446497f, 0.03096204f, 0.20961684f, -0.02143229f, 0.12634590f, 0.12498367f, 0.15405032f, 
    0.01733362f, 0.10676787f, 0.05624909f, 0.04647371f, 0.04026114f, 0.03458023f, 0.15549918f, 0.05169490f, 
    -0.23674150f, 0.08018051f, -0.41112629f, -0.03527136f, -0.07624424f, 0.00131167f, -0.01942251f, 0.11892001f, 
    0.29938981f, 0.02166952f, -0.04008726f, 0.08617798f, 0.15507568f, -0.13470289f, -0.26261410f, 0.06905235f, 
    0.02595015f, -0.09314671f, 0.01212902f, 0.08680145f, 0.02193808f, 0.11366984f, 0.08655503f, -0.00708826f, 
    -0.27132446f, 0.11127861f, -0.30275998f, -0.13336675f, 0.16416334f, -0.10610075f, -0.05674971f, -0.24085839f, 
    -0.08051982f, 0.17456546f, -0.10509769f, -0.03690140f, -0.08849929f, -0.07108628f, 0.24618778f, 0.26068041f, 
    0.02856469f, -0.19959770f, -0.16332264f, -0.05539697f, 0.08204452f, 0.01940818f, 0.10924333f, 0.03507075f, 
    -0.06135630f, 0.03476010f, 0.01075163f, -0.14582114f, 0.11952729f, -0.00214842f, -0.22771402f, 0.00622431f, 
    0.00713856f, -0.04495820f, 0.08166700f, 0.07465435f, -0.02212552f, -0.04583723f, -0.04409580f, -0.24440014f, 
    0.12234715f, 0.02292695f, 0.00306608f, -0.14808084f, 0.18867011f, -0.05329891f, -0.25209978f, -0.12505311f, 
    0.09493917f, 0.00354727f, 0.03728929f, 0.12705091f, 0.06638446f, -0.00585264f, 0.06218695f, 0.07087494f, 
    -0.00772330f, -0.01173509f, -0.05884071f, -0.08077651f, -0.26049301f, -0.12974116f, 0.06647445f, 0.26552424f, 
    0.20415996f, 0.25515568f, 0.11569098f, 0.12948553f, -0.00039874f, -0.05480344f, -0.05690553f, -0.08048670f, 
    -0.10748463f, 0.12373840f, -0.10356753f, 0.13576570f, 0.12901266f, -0.14767016f, -0.07191037f, 0.08852011f, 
    -0.12924655f, 0.02847426f, 0.01927658f, 0.07414801f, -0.16995233f, 0.26943013f, -0.08994059f, -0.17767063f, 
    0.06848478f, -0.05645343f, -0.04517280f, 0.01075916f, -0.12061200f, -0.02212876f, -0.02518183f, 0.02815304f, 
    0.28914741f, 0.22705801f, -0.05896711f, -0.02436576f, 0.01033742f, 0.20825563f, -0.02615128f, -0.11307680f, 
    0.09538408f, 0.06533512f, -0.04161934f, -0.13467641f, -0.05591023f, -0.11808106f, 0.07331221f, 0.10139413f, 
    0.00856869f, 0.09147958f, 0.03211175f, -0.10516398f, 0.05389391f, -0.00821033f, 0.07710967f, 0.02991112f, 
    -0.02114443f, -0.07056516f, -0.04073608f, -0.00387259f, 0.02355925f, -0.07630897f, -0.04799228f, -0.07512267f, 
    0.01901338f, -0.00607709f, 0.00355734f, -0.05844938f, -0.05038332f, -0.02877134f, 0.00246736f, 0.04281138f, 
    0.00366245f, -0.01460083f, -0.00926126f, 0.01169919f, -0.01268037f, 0.00152993f, -0.01394418f, -0.03572478f, 
    -0.01738087f, 0.00450221f, -0.07277130f, 0.04579864f, -0.06094471f, 0.00104629f, -0.07757648f, 0.01510142f, 
    -0.02402730f, -0.07246777f, -0.04154341f, -0.03451371f, -0.03273106f, -0.02838020f, -0.01815817f, 0.01403234f, 
    -0.03538257f, -0.00454404f, -0.04997208f, -0.00871924f, -0.05384025f, -0.05037743f, 0.01698995f, 0.00840855f, 
    0.03670046f, 0.02762658f, 0.02633971f, 0.01056922f, -0.04294346f, -0.01461836f, -0.03854319f, -0.04716826f, 
    -0.01838102f, 0.04493299f, 0.02122338f, 0.01234705f, -0.00215789f, 0.00872116f, -0.03902970f, -0.01812579f, 
    0.01544127f, 0.00310388f, -0.07283124f, -0.02576572f, -0.03613999f, -0.04334486f, -0.06340402f, -0.02069124f, 
    -0.04395502f, -0.01592125f, -0.00614134f, -0.04999870f, 0.03700424f, 0.04126718f, -0.03777143f, 0.01748219f, 
    0.00152709f, -0.03946013f, -0.00212080f, -0.03646706f, -0.00854796f, -0.06154747f, -0.00462199f, -0.01741066f, 
    -0.07220449f, -0.02636037f, -0.05803523f, 0.00794563f, -0.02937074f, -0.06204570f, -0.05115346f, -0.06862540f, 
    -0.07882308f, -0.06549647f, -0.00818901f, -0.00382783f, -0.07720492f, -0.02228460f, -0.06669536f, -0.05387422f, 
    -0.03444448f, -0.02198045f, 0.01232203f, -0.04646377f, 0.01341307f, -0.02116036f, -0.03916643f, 0.00093637f, 
    -0.00195936f, 0.02548319f, 0.03549847f, 0.00339132f, -0.06902511f, -0.02868178f, -0.04539166f, -0.04209664f, 
    0.04033827f, 0.00945709f, -0.02052743f, -0.04493141f, -0.03369851f, 0.04802673f, 0.05078217f, -0.02574740f, 
    0.00312773f, -0.06137886f, -0.02789181f, -0.04868382f, -0.02428303f, 0.02725948f, 0.00792508f, -0.02129139f, 
    -0.03976740f, -0.05643958f, -0.01133204f, -0.04401995f, -0.04693803f, 0.01081420f, -0.02081891f, -0.02997068f, 
    0.00394279f, 0.01651680f, 0.00873381f, -0.01057630f, 0.01546409f, -0.02537373f, 0.01757457f, -0.04878541f, 
    -0.04145629f, 0.01133799f, -0.00051457f, 0.04766492f, -0.00877065f, -0.05429008f, -0.07889047f, -0.03822578f, 
    -0.02130789f, -0.00177290f, 0.01244824f, -0.04133572f, -0.06317908f, -0.03320179f, -0.04505727f, -0.00399781f, 
    -0.03892947f, 0.02484671f, -0.00619913f, -0.05068209f, 0.04946539f, -0.03590357f, -0.06180045f, -0.04286761f, 
    -0.07189748f, -0.06740905f, -0.06002846f, -0.06924290f, -0.03399981f, -0.03737427f, -0.03441554f, -0.02345442f, 
    -0.04425281f, -0.03150612f, 0.00018334f, -0.01509832f, 0.01295756f, -0.06480336f, 0.01486273f, -0.02238153f, 
    -0.03339087f, 0.03665343f, 0.02065717f, -0.03386316f, -0.02455128f, 0.04695262f, -0.03197482f, 0.03929098f, 
    0.01476723f, 0.00809046f, -0.03406559f, -0.03011339f, -0.03506721f, -0.07031928f, 0.01787516f, -0.01317131f, 
    -0.00573999f, 0.00550837f, -0.08034798f, -0.07347183f, 0.00952160f, -0.06962153f, -0.04540390f, 0.00481889f, 
    0.00013568f, 0.01631424f, 0.01814920f, 0.03579455f, 0.00825692f, 0.01315173f, 0.04377991f, -0.00881108f, 
    -0.00558914f, -0.00562437f, -0.04635832f, 0.03112886f, -0.01194509f, 0.01087227f, 0.00431458f, -0.00297747f, 
    -0.02166878f, 0.00597606f, 0.00997215f, 0.02002542f, 0.01172115f, 0.00385735f, -0.01026058f, 0.02024612f, 
    -0.03914945f, -0.01932809f, 0.00636907f, -0.07435375f, 0.00718198f, 0.01939315f, -0.07228003f, -0.07507496f, 
    -0.02507089f, -0.06957114f, -0.01185704f, -0.00938801f, 0.02709500f, 0.00753974f, -0.02737129f, 0.01486467f, 
    0.02168706f, 0.01061949f, -0.04217256f, -0.03212943f, -0.02751075f, 0.02238632f, -0.06039906f, -0.03289916f, 
    0.03809815f, -0.02280356f, -0.00825649f, 0.02043380f, 0.02182299f, 0.01993950f, -0.02111501f, -0.03744495f, 
    -0.01007424f, -0.07247266f, -0.06072268f, -0.06896742f, 0.00494432f, -0.06231996f, 0.01491940f, -0.06628577f, 
    -0.04626979f, -0.08113640f, -0.01172500f, 0.01334740f, -0.02688399f, -0.06039661f, -0.06345249f, -0.01969804f, 
    -0.04132839f, -0.06964352f, -0.04827039f, -0.02979126f, -0.00168460f, -0.05042749f, 0.00695979f, -0.00220296f, 
    0.04050019f, -0.05605514f, 0.01526415f, -0.03504752f, -0.07776359f, -0.06358702f, -0.03537556f, -0.00130101f, 
    -0.03198605f, 0.04711889f, -0.01217109f, -0.02259240f, -0.02996089f, -0.01272235f, -0.00745955f, -0.07687803f, 
    -0.02863651f, -0.07069604f, -0.02611425f, 0.01685160f, 0.01057028f, -0.02691453f, 0.00054806f, -0.07572412f, 
    -0.05113025f, -0.01993733f, 0.02508537f, -0.00712995f, -0.03285074f, -0.01297936f, -0.04251651f, -0.04406049f, 
    -0.04467655f, -0.02625542f, -0.05258487f, -0.06652925f, -0.04777157f, -0.00214284f, 0.01575578f, -0.02875945f, 
    -0.01994471f, -0.03304179f, -0.02614278f, -0.02812823f, 0.01017441f, 0.04244990f, -0.00167343f, -0.00622065f, 
    0.00348082f, -0.01689461f, -0.04213591f, -0.00399264f, 0.00396296f, 0.02123672f, -0.02610718f, -0.01795616f, 
    -0.05504308f, -0.04681560f, -0.05276210f, -0.06870291f, -0.05491695f, -0.01842374f, -0.03954808f, 0.01347795f, 
    -0.02336621f, -0.07313310f, 0.03836115f, -0.04918573f, -0.04615834f, -0.04779312f, -0.06864011f, -0.06011719f, 
    -0.02143177f, -0.07722044f, -0.00992679f, -0.02318607f, 0.02273161f, -0.06538294f, -0.04775343f, -0.01357471f, 
    -0.02803340f, 0.00651201f, -0.04250392f, -0.00085797f, -0.07313836f, -0.01719392f, -0.03513059f, -0.04287129f, 
    -0.01611707f, 0.04286832f, 0.02800147f, 0.00370361f, -0.03548202f, -0.00462903f, 0.02072758f, 0.01825467f, 
    0.03713600f, 0.00481142f, 0.00620791f, 0.00859413f, 0.03856542f, -0.03289559f, 0.02477166f, -0.03831896f, 
    0.01652102f, 0.02487032f, 0.02665669f, -0.00633000f, 0.01628423f, -0.02303774f, -0.01626383f, 0.01001456f, 
    0.00733102f, -0.04099709f, -0.02421823f, -0.02191016f, 0.00220777f, 0.01310210f, -0.04690543f, 0.00128029f, 
    -0.03736738f, -0.00030913f, -0.04386055f, 0.01088230f, 0.02494398f, 0.01941841f, -0.00918783f, -0.05440713f, 
    0.03189576f, -0.00476471f, 0.01123053f, 0.03353252f, 0.03786569f, 0.03348998f, -0.02902981f, -0.02342622f, 
    0.03627384f, -0.00131152f, 0.01308061f, 0.00691188f, -0.03612821f, -0.03979869f, -0.04914611f, -0.02887999f, 
    -0.01680197f, 0.04057312f, 0.00366955f, -0.02338065f, -0.04089542f, 0.02511793f, 0.02187443f, -0.01571367f, 
    -0.02095606f, -0.05471723f, 0.02304254f, 0.04219372f, -0.01079089f, -0.04649473f, 0.03801209f, 0.03803594f, 
    -0.00478809f, -0.04471720f, -0.03317859f, -0.05051606f, 0.03390896f, -0.01557371f, -0.02276906f, -0.01163745f, 
    0.03967290f, 0.02109361f, 0.03142032f, -0.01774315f, -0.02722337f, 0.00353271f, 0.04375057f, -0.04486129f, 
    -0.04610596f, 0.01957919f, 0.02169400f, 0.00959787f, -0.03274133f, 0.02296304f, -0.00238039f, 0.00015649f, 
    0.00791523f, -0.01526820f, 0.04067569f, 0.02828417f, 0.01921562f, -0.02868759f, 0.00329182f, 0.02442985f, 
    0.01284577f, -0.04940004f, -0.01891210f, 0.01443947f, -0.04664498f, -0.04581237f, -0.01733471f, 0.02875122f, 
    0.02756152f, -0.04094553f, 0.04241469f, -0.00740140f, -0.04234016f, 0.01613649f, 0.03310281f, -0.05742358f, 
    -0.00104575f, 0.00923799f, -0.03989269f, -0.01378004f, -0.02390333f, -0.00088429f, -0.02293184f, -0.03853579f, 
    -0.03319172f, -0.04200834f, -0.01396902f, -0.02751049f, 0.00432153f, 0.03660744f, -0.01074933f, 0.01466409f, 
    -0.00010501f, 0.03089887f, 0.03209940f, -0.02022258f, -0.04374923f, 0.01356259f, -0.04725860f, 0.01181942f, 
    0.01411705f, -0.03811954f, -0.02745152f, -0.02182171f, 0.00337808f, -0.04660815f, -0.02198946f, -0.01649892f, 
    -0.05310576f, 0.03125979f, -0.04160970f, -0.04130154f, -0.03158970f, 0.03941108f, -0.00954757f, 0.03786333f, 
    -0.04206670f, -0.03877278f, 0.02250957f, -0.03733313f, 0.02151817f, -0.01629161f, -0.02360855f, -0.01669184f, 
    -0.00794838f, 0.03388963f, 0.00535724f, -0.04501709f, -0.05671563f, -0.01808850f, -0.05035137f, 0.04371757f, 
    -0.04799142f, 0.00447794f, 0.03513582f, -0.03736003f, 0.00848041f, -0.04117291f, 0.04438264f, -0.02043252f, 
    -0.00909964f, 0.00161638f, -0.01037508f, -0.04597058f, 0.01190874f, -0.01459340f, 0.02234046f, 0.02124570f, 
    -0.03080632f, -0.03780868f, -0.01391911f, 0.01648428f, -0.04364650f, -0.01864889f, -0.01374253f, -0.03563847f, 
    -0.02154030f, 0.01985787f, 0.02494453f, 0.04094477f, -0.01556699f, -0.02720362f, -0.05544318f, 0.00297455f, 
    0.03149181f, -0.04701030f, 0.04251031f, 0.02700845f, -0.00862950f, -0.00289900f, 0.00492096f, 0.01659852f, 
    -0.04182098f, -0.05164491f, -0.05137210f, 0.03595941f, -0.01848361f, 0.04245948f, -0.01015030f, -0.04811976f, 
    -0.04463778f, 0.01464549f, 0.00065310f, -0.00746544f, 0.00846768f, -0.05469885f, -0.02101795f, -0.01936096f, 
    0.00666428f, -0.00393686f, -0.04049377f, 0.00843754f, 0.03568807f, 0.03935058f, -0.00698561f, -0.02370089f, 
    0.02670842f, -0.02992252f, -0.04353632f, 0.01594413f, -0.01690197f, -0.00372293f, -0.00100933f, -0.01223243f, 
    -0.05294013f, -0.00715459f, -0.00761101f, 0.01067613f, 0.01204018f, -0.02353371f, -0.00773037f, 0.02662191f, 
    0.02835634f, -0.04256932f, 0.02836319f, -0.04031014f, 0.00341925f, -0.04032300f, -0.04995065f, -0.03137647f, 
    -0.01774474f, 0.01944568f, 0.00538297f, 0.00428102f, -0.03845666f, 0.02070571f, 0.03660458f, -0.03281154f, 
    -0.03708469f, -0.02321821f, 0.04126495f, -0.00139233f, 0.02248099f, -0.02816790f, -0.04270437f, -0.02279664f, 
    -0.00042358f, -0.01026130f, 0.02331978f, -0.03800291f, 0.01398748f, -0.00122971f, -0.04094657f, 0.01291546f, 
    0.02712325f, -0.01219633f, 0.01012226f, 0.04445904f, -0.05029275f, 0.03910862f, -0.04454513f, -0.04217356f, 
    -0.01813789f, -0.05045417f, -0.05066311f, 0.00148661f, -0.02851493f, -0.05604327f, 0.04152884f, -0.03361748f, 
    0.02050024f, -0.02856278f, -0.04737015f, -0.03809703f, 0.00204191f, -0.01684907f, 0.01282209f, -0.01989383f, 
    -0.00551679f, 0.00584399f, 0.02091992f, -0.05305704f, 0.01889139f, -0.02898718f, 0.00778777f, 0.00378079f, 
    -0.00741641f, -0.00223186f, -0.02274782f, 0.00941629f, 0.00565690f, -0.05466345f, 0.00834482f, -0.03131842f, 
    0.02334297f, -0.03724929f, -0.00675329f, -0.00143091f, 0.02801177f, -0.04012521f, -0.04713194f, -0.04635844f, 
    -0.04586527f, 0.01079140f, 0.00877340f, 0.01185687f, 0.00633488f, 0.03306295f, -0.01119407f, -0.05189361f, 
    0.02445713f, -0.04386932f, 0.02653733f, 0.00494170f, -0.03366345f, -0.02480183f, 0.03965497f, -0.02240171f, 
    -0.01073556f, -0.03185117f, 0.02072262f, 0.02349079f, -0.02474361f, -0.01373036f, -0.03309574f, 0.03885113f, 
    -0.01781636f, -0.02176132f, -0.02595777f, 0.00732705f, -0.01714724f, -0.00440907f, -0.01278228f, -0.00876795f, 
    0.04148125f, 0.01073641f, -0.04886111f, 0.00366068f, -0.02176833f, -0.03530008f, 0.00112178f, -0.02620878f, 
    0.00470750f, -0.04991733f, -0.04383317f, -0.02977727f, -0.01300613f, -0.02324169f, -0.04234519f, -0.00143397f, 
    -0.02477501f, -0.03211007f, 0.02686745f, 0.03087214f, 0.01925195f, 0.00321229f, -0.04284401f, 0.01517816f, 
    -0.06197974f, 0.01836584f, 0.01445952f, -0.00687292f, -0.04855728f, -0.00172057f, -0.00039839f, -0.00475962f, 
    -0.02226392f, -0.03985126f, 0.01493871f, 0.00584171f, -0.01407081f, 0.03550760f, -0.03346534f, -0.03094349f, 
    0.04214219f, -0.04652106f, -0.01054846f, -0.00196801f, 0.05016285f, -0.02096398f, -0.03846167f, 0.02355812f, 
    -0.04971520f, 0.00068588f, 0.03237899f, -0.02002985f, -0.04887019f, -0.03320938f, -0.04497803f, 0.00444576f, 
    -0.00733156f, 0.04619079f, -0.01172078f, -0.03833740f, -0.00817303f, -0.05039198f, 0.00041830f, 0.04203065f, 
    -0.00551321f, 0.04642267f, 0.00763199f, 0.03429751f, -0.01541986f, -0.00348451f, -0.06046378f, -0.03661472f, 
    -0.02776342f, -0.03440512f, 0.02741656f, -0.00629850f, 0.03528122f, -0.04352420f, -0.00325690f, 0.00665130f, 
    -0.02836089f, -0.05120927f, 0.01866269f, -0.00878996f, 0.03977545f, 0.00539415f, -0.02689649f, -0.02243684f, 
    -0.02725958f, -0.04840522f, -0.01622409f, 0.00083011f, -0.05179308f, -0.02155414f, 0.02645157f, 0.01000740f, 
    0.01682772f, -0.04306016f, 0.02194638f, 0.03996417f, 0.01573404f, 0.04123013f, -0.01865838f, -0.05773761f, 
    -0.02441211f, 0.04053376f, 0.00186269f, 0.02554294f, 0.01802258f, -0.01659582f, -0.05572470f, 0.04107301f, 
    -0.00539835f, -0.02087555f, -0.03173811f, 0.02671475f, -0.05770142f, 0.04287429f, -0.03884515f, -0.03342057f, 
    -0.05133020f, -0.03373411f, -0.01601709f, 0.03107747f, -0.04941458f, 0.00812572f, 0.03015701f, -0.00434703f, 
    -0.00274821f, 0.01240970f, -0.02377994f, 0.02766919f, 0.02188283f, 0.01861574f, -0.03820053f, 0.00726319f, 
    0.01753801f, 0.03342087f, -0.02634943f, -0.00517476f, -0.01898149f, 0.03103716f, 0.01361214f, -0.01284546f, 
    0.01899172f, -0.02979675f, -0.02508266f, -0.04966242f, -0.02989435f, -0.03980577f, -0.01651689f, 0.00018469f, 
    -0.04089307f, -0.00039878f, -0.00310171f, -0.02598704f, 0.03569869f, 0.02584667f, 0.04148304f, 0.01350105f, 
    0.00537445f, -0.03772791f, 0.02905972f, -0.03631011f, 0.00660610f, -0.04724307f, 0.02936299f, 0.03566140f, 
    0.01644637f, 0.03294736f, 0.00021661f, 0.02637566f, 0.02497810f, 0.03285601f, 0.03915231f, 0.00680059f, 
    -0.04285752f, -0.03268932f, 0.03068586f, 0.03869379f, -0.04203507f, -0.05788556f, -0.05662716f, 0.01077142f, 
    -0.01963826f, 0.04044462f, 0.03012052f, -0.01941116f, -0.00816851f, -0.02250888f, -0.00256183f, -0.01340742f, 
    0.02070601f, 0.01333663f, 0.01722081f, -0.03831451f, 0.01644345f, 0.02815716f, 0.02160629f, -0.02874649f, 
    0.02556575f, -0.04207396f, -0.02226265f, 0.01989598f, 0.03591823f, 0.01498857f, 0.02973510f, 0.00116663f, 
    -0.04161832f, 0.01620419f, 0.00588543f, 0.00768440f, 0.02945000f, -0.03134509f, -0.00070826f, 0.00348499f, 
    -0.00675797f, -0.01504172f, 0.02213235f, 0.01922150f, 0.03371971f, -0.00884947f, 0.03118839f, -0.02775202f, 
    0.03262288f, -0.04401267f, 0.01663794f, -0.05208087f, -0.00233800f, 0.02362140f, -0.00228027f, -0.02812657f, 
    0.02477646f, 0.02748747f, -0.02816707f, -0.01371710f, 0.01193298f, 0.00280729f, 0.00662890f, 0.02345663f, 
    0.00706340f, -0.03225049f, -0.03099746f, 0.02055021f, -0.02602649f, -0.01370484f, 0.00853601f, 0.03982231f, 
    0.00593734f, -0.03484755f, -0.03358682f, -0.03463231f, -0.03755720f, -0.01837809f, 0.00204303f, -0.00992393f, 
    0.02853074f, 0.03145468f, -0.02418777f, -0.01407616f, 0.00781421f, -0.04757975f, -0.00436535f, -0.00230692f, 
    -0.03562351f, 0.01453917f, -0.05564708f, 0.02554010f, -0.01941719f, -0.04970768f, 0.02577046f, 0.02581519f, 
    -0.01918614f, -0.03810512f, 0.03026952f, -0.05361304f, -0.03387962f, -0.03928256f, 0.03741485f, -0.02104723f, 
    0.03303009f, -0.03193577f, 0.00325606f, 0.00847835f, 0.03301229f, 0.02565064f, 0.01582117f, 0.02095382f, 
    -0.05737352f, -0.00181379f, 0.01680053f, -0.02197745f, -0.04569544f, -0.00341773f, -0.05409972f, -0.02579117f, 
    -0.00496794f, -0.05552686f, -0.04103788f, -0.04079933f, -0.00766471f, -0.03552563f, -0.05173464f, -0.00681944f, 
    -0.04780480f, -0.00265927f, -0.04632194f, -0.00215574f, -0.04778501f, 0.04983650f, 0.02517487f, -0.01455338f, 
    0.00520246f, 0.01256282f, 0.00298371f, -0.05279417f, -0.02654853f, -0.05439964f, -0.02521301f, -0.04725716f, 
    -0.05218548f, 0.01509098f, -0.03036351f, -0.05635734f, 0.03519382f, -0.00257354f, 0.01181956f, 0.03070657f, 
    0.01574967f, 0.03826001f, -0.00169105f, 0.02132919f, -0.01358136f, -0.03765995f, 0.00124847f, 0.00987941f, 
    0.03777480f, 0.02840240f, -0.00573940f, -0.02604628f, -0.05483561f, 0.01010704f, 0.00149426f, 0.04180593f, 
    -0.05018505f, 0.01602867f, -0.03479196f, -0.05369503f, 0.03816209f, -0.01223384f, 0.02339039f, 0.03168438f, 
    -0.02477922f, -0.04942875f, 0.00267818f, -0.04707836f, -0.01427269f, -0.04463944f, 0.01027393f, 0.03478365f, 
    -0.01721761f, -0.04430128f, -0.01341504f, -0.04284310f, 0.00985672f, -0.04713122f, -0.02390395f, 0.00066827f, 
    0.03294210f, 0.04250421f, -0.04126161f, -0.02926247f, -0.04150826f, -0.04155650f, -0.05903232f, 0.04366682f, 
    0.02575928f, 0.00358652f, -0.05793231f, 0.01933365f, -0.03460214f, -0.01636894f, -0.03353548f, -0.01918203f, 
    -0.06581275f, 0.03232234f, 0.01744128f, -0.05147677f, 0.04345032f, -0.05264674f, 0.02376362f, -0.04253340f, 
    -0.04111603f, 0.04791961f, -0.04447272f, -0.00956677f, 0.01337335f, -0.02022401f, -0.02140081f, -0.01113856f, 
    0.14215469f, 0.00877414f, 0.14623144f, 0.05479342f, 0.05405420f, -0.08113834f, 0.12457260f, 0.10553481f, 
    0.12041337f, 0.05511535f, 0.16993818f, 0.19807468f, 0.33895102f, 0.00915221f, -0.07004389f, -0.14383428f, 
    0.12327459f, -0.03420753f, -0.00953109f, -0.14851902f, -0.05981985f, -0.07499372f, -0.05610656f, -0.05916016f, 
    0.15761377f, 0.21629949f, -0.05517558f, -0.19931380f, -0.07249922f, 0.03953381f, -0.12075838f, -0.05808065f, 
    0.07961468f, 0.01691592f, -0.11688115f, -0.14865412f, 0.08073564f, -0.10134253f, -0.01773231f, -0.01424967f, 
    0.00838480f, -0.05239724f, -0.02059079f, 0.01613611f, -0.01890302f, 0.11280045f, 0.06995497f, -0.08219740f, 
    -0.21744454f, -0.21790814f, -0.08081060f, 0.15608360f, -0.02854543f, 0.09287753f, 0.09916741f, 0.00115260f, 
    -0.04274865f, 0.01693798f, 0.01518696f, 0.07125483f, -0.08773553f, 0.13701263f, 0.25466961f, -0.11571822f, 
    -0.14577429f, -0.02214307f, -0.05513962f, -0.04385976f, -0.01092788f, -0.05384194f, 0.03791810f, -0.03460610f, 
    -0.02866034f, -0.17833884f, -0.01110010f, 0.13596103f, 0.06922168f, 0.11611472f, 0.05355852f, 0.06494429f, 
    -0.05991741f, 0.00093159f, 0.00207031f, -0.04527986f, -0.12610252f, 0.11946175f, -0.11771810f, 0.01105858f, 
    -0.10489669f, -0.23453550f, 0.12134130f, -0.10362661f, -0.00744426f, 0.00245489f, 0.01953340f, -0.02351849f, 
    0.05594913f, -0.04348907f, 0.01848454f, 0.09115018f, 0.09667176f, -0.03633109f, 0.14531948f, -0.05327106f, 
    -0.02328297f, 0.01069777f, -0.07726890f, 0.08010478f, -0.29740641f, -0.21916132f, -0.08314525f, 0.07876872f, 
    -0.00423127f, 0.04179361f, 0.15984067f, 0.11184479f, -0.10928170f, 0.02469293f, 0.05928671f, 0.04601220f, 
    0.36037964f, -0.07635419f, 0.05322126f, 0.14479195f, -0.02878186f, -0.12636560f, -0.14545360f, -0.00442639f, 
    -0.22095470f, 0.14784849f, -0.12261544f, 0.13691247f, -0.07990400f, 0.08068863f, 0.09173954f, -0.08547390f, 
    -0.08077012f, -0.06577293f, -0.08882435f, -0.01987091f, -0.00999968f, 0.07166068f, -0.10793064f, -0.18969584f, 
    0.01361070f, -0.20000295f, 0.00370515f, 0.10817614f, 0.09218854f, 0.03962161f, -0.02802096f, 0.04405695f, 
    -0.03435791f, -0.00579037f, -0.05905458f, 0.01645685f, 0.06396022f, 0.04590487f, 0.14411464f, -0.15138900f, 
    0.01118964f, -0.03112952f, -0.10754289f, -0.02494778f, -0.02645441f, -0.05410750f, -0.04948724f, 0.04067810f, 
    0.36131939f, -0.02023349f, 0.08464677f, -0.08464786f, -0.03058591f, 0.00400707f, 0.03182143f, 0.04489686f, 
    0.12298709f, 0.09767903f, 0.06145600f, 0.08982522f, 0.00002093f, 0.12447179f, 0.18014851f, 0.00930043f, 
    -0.07897393f, -0.08689938f, -0.01074810f, -0.08960587f, -0.01470425f, 0.02658024f, -0.09314081f, 0.05585391f, 
    0.11966393f, -0.22411278f, -0.07421844f, 0.20875311f, 0.07709572f, 0.02360868f, -0.11279167f, 0.14115731f, 
    -0.06816223f, 0.04672784f, -0.11342924f, 0.14582300f, 0.18437770f, 0.15586400f, 0.13075535f, -0.19319032f, 
    -0.08217169f, 0.03991082f, -0.06203640f, -0.05731242f, 0.02703789f, 0.03170083f, -0.00358711f, -0.01764230f, 
    0.62378573f, 0.20656741f, 0.51522899f, 0.11260986f, -0.15316568f, 0.15526101f, -0.09129118f, -0.00469451f, 
    0.09302716f, 0.08935872f, 0.10095971f, -0.11097371f, -0.06844699f, 0.18467648f, 0.00872063f, -0.05185359f, 
    -0.04829431f, 0.04318962f, -0.06759188f, -0.04076974f, -0.07199044f, 0.05331334f, 0.14573066f, -0.15536328f, 
    0.11070155f, 0.12095024f, 0.27759236f, 0.12313374f, -0.09648396f, 0.00706569f, 0.14109974f, 0.12363602f, 
    0.12820701f, 0.26490691f, -0.00389246f, -0.01805833f, 0.21497457f, 0.16975386f, -0.14615160f, -0.19673821f, 
    -0.15053943f, 0.00677037f, -0.03990121f, -0.17236635f, 0.00781589f, 0.06101763f, 0.02355700f, -0.04486276f, 
    0.26024190f, -0.00721046f, 0.31115291f, 0.18159600f, -0.10857244f, -0.00286741f, 0.20525920f, 0.06359571f, 
    0.13968648f, 0.08330438f, 0.12996688f, 0.09016253f, 0.12929720f, 0.05966737f, 0.08086056f, -0.19649731f, 
    -0.00412988f, 0.02791154f, -0.02138141f, -0.01665763f, -0.09731507f, 0.10470256f, 0.15463783f, 0.15856466f, 
    0.29574895f, 0.30149913f, 0.17049140f, 0.36085472f, -0.15147075f, 0.03034240f, -0.01538470f, -0.00851502f, 
    -0.10921430f, 0.01166212f, 0.14439778f, 0.11973961f, -0.01496560f, 0.02917797f, -0.00499834f, -0.05134091f, 
    -0.13169295f, 0.06519623f, -0.09285906f, 0.22176082f, -0.10875177f, 0.08838560f, 0.13790227f, 0.08932299f, 
    0.01642156f, 0.26118913f, 0.02195811f, -0.27181026f, -0.03204413f, 0.05172745f, 0.00283860f, -0.22161496f, 
    0.04446345f, -0.01520043f, 0.10036317f, 0.10032666f, 0.07729252f, -0.05850211f, -0.13062561f, 0.03145760f, 
    -0.06947787f, -0.19531582f, -0.15164398f, -0.14489073f, -0.05575716f, 0.04294001f, 0.00781040f, 0.04670981f, 
    -0.11397528f, -0.15647472f, -0.12358856f, 0.09821708f, -0.03292030f, 0.04607852f, 0.13532168f, -0.06099562f, 
    0.04109652f, -0.02505506f, -0.12190992f, -0.08399533f, 0.04506693f, 0.24813816f, 0.11430024f, -0.15205278f, 
    0.22074363f, -0.03562991f, -0.04400191f, 0.04666603f, 0.01901695f, -0.00845179f, 0.09833815f, -0.06630257f, 
    -0.29503337f, 0.17266947f, 0.03660988f, 0.13039792f, -0.10536587f, -0.23922417f, 0.09617498f, -0.05058602f, 
    0.08809310f, -0.01789591f, 0.02649722f, 0.12431459f, -0.08062887f, 0.06443151f, -0.06909151f, -0.09456164f, 
    0.04312719f, -0.01089898f, -0.10572808f, -0.07952367f, 0.00772317f, -0.02836266f, -0.12479577f, -0.07752871f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06340692f, 0.25503343f, 0.00328969f, 0.11777159f, 0.13014448f, 0.06768347f, -0.03776199f, -0.02394084f, 
    -0.01127720f, 0.08842517f, 0.07881793f, 0.03243476f, 0.08346099f, -0.04961329f, 0.02822590f, -0.02615622f, 
    -0.05691632f, -0.05299143f, -0.04531281f, -0.02947688f, 0.10962532f, 0.06847213f, -0.01241361f, 0.01683263f, 
    0.04936037f, -0.00490917f, 0.11306936f, 0.12886269f, 0.03763884f, 0.07946667f, 0.22596395f, -0.02039197f, 
    -0.04294406f, -0.04742288f, 0.16365802f, -0.04340548f, 0.13379978f, -0.06493317f, 0.16850959f, -0.07356085f, 
    -0.09957515f, 0.01450771f, 0.00077437f, -0.05164650f, 0.05138512f, 0.01318311f, -0.04381289f, 0.06907695f, 
    0.03822849f, 0.08003002f, 0.01651242f, 0.18167070f, 0.02160994f, 0.00551300f, 0.04909218f, -0.09230748f, 
    0.05071302f, 0.04883571f, 0.18064974f, 0.05207140f, -0.01876415f, 0.03566952f, -0.02691547f, -0.00856041f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24906293f, -0.31271192f, -0.01204311f, 0.09282818f, 0.01444361f, -0.27367967f, 0.03234746f, -0.23524001f, 
    0.09086210f, 0.04886860f, 0.04270568f, -0.46456397f, 0.05117501f, -0.00405663f, -0.04454464f, -0.02937038f, 
    0.08464961f, -0.01713716f, -0.08271967f, 0.00155751f, -0.22822650f, -0.10711111f, -0.04857283f, 0.00489626f, 
    0.18280983f, 0.04628268f, -0.31307104f, -0.23935840f, -0.01781053f, -0.18798020f, -0.33603793f, -0.08069589f, 
    0.12860635f, 0.21916862f, 0.07654972f, 0.02138121f, -0.02389928f, 0.15269403f, 0.02224444f, 0.06290815f, 
    0.30680537f, -0.09246540f, -0.31465012f, -0.08542706f, -0.11159255f, 0.30891690f, 0.06596188f, -0.38677841f, 
    0.26625013f, -0.29483500f, -0.11136677f, 0.18799923f, -0.18832180f, -0.00534333f, -0.34367242f, 0.22300401f, 
    -0.43447071f, -0.23280756f, -0.26644292f, 0.22144149f, 0.07248956f, 0.09652795f, -0.12465964f, -0.32186484f, 
    0.02028437f, 0.04987520f, 0.02807315f, -0.07090873f, 0.01883951f, 0.22921796f, -0.11330590f, -0.44597915f, 
    -0.12253857f, -0.16812317f, 0.05169749f, -0.08289271f, 0.12871040f, -0.01480260f, -0.01584968f, 0.08865981f, 
    -0.16849022f, -0.03999029f, 0.08530451f, 0.08661694f, 0.51346773f, -0.10584827f, 0.04803648f, -0.02012138f, 
    0.10907903f, 0.10409632f, -0.24229179f, 0.02675591f, 0.01844488f, 0.34501955f, 0.10967610f, -0.09580063f, 
    -0.07227193f, -0.39692852f, 0.18648323f, 0.07309853f, -0.02180479f, 0.36390603f, 0.07843830f, 0.17125911f, 
    -0.49820641f, 0.05824477f, 0.22356640f, -0.23755662f, 0.26917055f, -0.43425953f, 0.06900593f, -0.34304860f, 
    0.19501254f, -0.01396548f, 0.09820449f, 0.32172924f, 0.08162361f, 0.10978737f, -0.17764495f, 0.00567751f, 
    -0.43522277f, -0.20546104f, -0.01822997f, -0.57594621f, 0.05088474f, -0.05856828f, -0.07988500f, 0.08617552f, 
    -0.17888670f, -0.00432995f, -0.07479512f, 0.24776709f, 0.22342883f, 0.20699885f, 0.03745725f, 0.34930524f, 
    -0.10746681f, -0.11464637f, -0.19060740f, 0.23752117f, -0.02848452f, -0.02503479f, -0.12040696f, 0.01036416f, 
    0.05796166f, 0.03485919f, 0.05334059f, 0.11124971f, -0.69893664f, 0.09691189f, -0.04256687f, 0.09226651f, 
    -0.06884947f, 0.10442130f, -0.08910498f, 0.15177663f, -0.03471436f, -0.46763653f, -0.26075363f, 0.03156162f, 
    -0.01466686f, 0.11680501f, 0.09750992f, -0.05620281f, 0.15879396f, -0.59383905f, 0.17783526f, -0.08426659f, 
    -0.26532105f, 0.03502686f, -0.38674453f, -0.32707188f, -0.07012188f, 0.03198700f, 0.00265920f, 0.39730725f, 
    -0.25785959f, 0.12310141f, -0.11583265f, 0.07929198f, 0.13592266f, -0.05363170f, -0.17683463f, -0.23300424f, 
    -0.13575055f, 0.22725552f, 0.07395898f, -0.24061941f, 0.01022869f, 0.02561594f, -0.05022375f, -0.05383736f, 
    -0.08583914f, -0.36510527f, 0.07212222f, -0.04085803f, -0.59963167f, -0.24437749f, 0.06889228f, 0.03776050f, 
    -0.07009273f, -0.26658997f, -0.06038204f, 0.14992295f, -0.22586082f, 0.11654204f, 0.11692619f, 0.06324691f, 
    0.15857001f, 0.03124250f, 0.11411605f, 0.01444801f, -0.45389321f, 0.05700737f, -0.07900922f, 0.08115795f, 
    0.15098524f, 0.28583142f, -0.24151324f, -0.11360087f, 0.06830383f, -0.25482246f, -0.24963169f, -0.07858748f, 
    -0.02264680f, 0.15162705f, -0.34945905f, 0.06906272f, -0.23443210f, 0.09910817f, -0.36050108f, 0.14226341f, 
    -0.20917334f, -0.00888691f, 0.07828504f, 0.18614598f, 0.25878522f, 0.14081150f, -0.04293242f, 0.18592644f, 
    -0.26845056f, 0.14825124f, -0.03128156f, -0.05690479f, -0.11197181f, -0.01065935f, -0.06116574f, 0.21357904f, 
    0.10702583f, 0.46813425f, -0.25459096f, 0.12924828f, 0.03995480f, 0.03000673f, -0.06937623f, 0.31193691f, 
    0.05803194f, -0.15544079f, -0.11904760f, 0.09184466f, -0.09022444f, 0.09729234f, -0.10672235f, 0.23648939f, 
    -0.07503876f, 0.14583346f, -0.24843536f, -0.15319745f, 0.20649898f, 0.01559396f, 0.07010768f, 0.02077282f, 
    -0.11606121f, -0.05281739f, 0.03782162f, -0.08223738f, -0.07335702f, 0.08329453f, -0.11105731f, 0.02175334f, 
    -0.09013887f, -0.32118043f, 0.05546499f, 0.02912493f, 0.08338600f, -0.05581883f, -0.27888891f, -0.03811999f, 
    0.12775528f, 0.22354086f, -0.04095235f, -0.06466893f, 0.18252534f, 0.17328693f, -0.39208850f, 0.10601631f, 
    0.30508375f, -0.06824052f, -0.65486741f, 0.06254341f, -0.15570739f, -0.15939565f, -0.09286322f, -0.00205824f, 
    -0.18899199f, 0.15494798f, 0.00546286f, -0.17165974f, 0.02488532f, 0.10197923f, 0.07862631f, 0.02946824f, 
    0.25337958f, -0.34154066f, -0.23975141f, 0.07534043f, 0.09835928f, 0.08011916f, -0.05893331f, -0.28112176f, 
    0.03016645f, 0.19534329f, 0.08615870f, -0.01924361f, -0.09553919f, -0.39120629f, -0.01586803f, -0.09502191f, 
    0.08259191f, 0.31449777f, 0.12485413f, -0.12551340f, 0.09886143f, -0.09757295f, 0.10249739f, 0.10405033f, 
    0.13538985f, -0.09960999f, 0.04175424f, 0.08767059f, -0.28590795f, -0.09498597f, -0.07320729f, 0.07388928f, 
    0.16377394f, -0.25908577f, 0.21912785f, 0.02021368f, -0.05358831f, -0.18955435f, 0.31689757f, -0.02555837f, 
    0.06327007f, -0.50761503f, 0.19162869f, 0.09157678f, -0.22867018f, -0.11256748f, -0.17616653f, -0.10780770f, 
    -0.50748968f, -0.02574633f, 0.03720262f, -0.09596519f, 0.08725696f, 0.21464665f, 0.07015625f, 0.14912103f, 
    -0.01722421f, -0.01386181f, -0.06883150f, 0.22259462f, -0.14595439f, -0.01728871f, 0.08756335f, 0.04497289f, 
    0.00358495f, -0.60894793f, 0.06390566f, 0.35506633f, 0.04856869f, 0.07285846f, 0.05964829f, -0.27449146f, 
    0.04060418f, -0.03368806f, 0.11489428f, -0.53044921f, 0.22940381f, 0.10453349f, 0.00262648f, 0.22160767f, 
    -0.11367054f, -0.47521773f, -0.27074277f, 0.25346363f, 0.12170229f, 0.01772633f, 0.00054114f, 0.11301302f, 
    -0.17355679f, 0.04555553f, 0.06297327f, -0.02485215f, 0.46945038f, 0.00328928f, 0.09414995f, 0.03494808f, 
    -0.29172912f, 0.10880762f, 0.17263053f, -0.08842532f, 0.00263886f, -0.38170415f, 0.17935078f, -0.02225930f, 
    -0.08489314f, -0.12069451f, 0.01830451f, -0.07273144f, 0.10170161f, -0.34785834f, 0.00042451f, -0.72256523f, 
    -0.19423448f, 0.10738910f, -0.22199324f, -0.08817679f, -0.62503594f, -0.59683335f, -0.06968804f, 0.10898811f, 
    -0.15736599f, 0.11731157f, 0.07544653f, -0.70714206f, 0.08368004f, -0.05070170f, 0.03867601f, -0.63637286f, 
    0.16444196f, 0.22716953f, 0.14952965f, 0.15294622f, 0.10337634f, -0.01198804f, 0.09681928f, 0.01773839f, 
    0.24714485f, -0.21937262f, -0.03945810f, -0.21691039f, -0.15051669f, 0.08101837f, -0.12063549f, 0.38123757f, 
    -0.06487717f, -0.22065639f, 0.11412039f, 0.03085977f, -0.17317235f, 0.08789004f, -0.00124129f, 0.02484411f, 
    0.16756341f, -0.13195659f, -0.00499540f, -0.01768856f, -0.13599026f, -0.50577205f, -0.03264611f, 0.07021771f, 
    0.09803482f, -0.22016585f, 0.06135773f, 0.27781928f, -0.01884443f, -0.01562496f, -0.15536517f, 0.10117950f, 
    -0.08933198f, 0.03941784f, -0.20266250f, -0.10474077f, 0.03354638f, -0.35078508f, -0.34102198f, -0.51471353f, 
    0.08559275f, 0.03889555f, 0.26663548f, -0.22456224f, 0.15138206f, 0.32698080f, -0.05684199f, -0.23318054f, 
    -0.06021129f, -0.54007202f, 0.06322701f, -0.25220171f, 0.20092601f, 0.03124073f, -0.03093670f, 0.12665719f, 
    0.13061605f, 0.05307108f, -0.07359207f, -0.55532223f, 0.10461274f, 0.03034981f, -0.07984868f, 0.23644347f, 
    0.13163722f, -0.10870355f, 0.05620172f, 0.39082476f, -0.35102123f, -0.32553568f, -0.05905099f, -0.27115473f, 
    -0.06416593f, 0.12018409f, 0.08385531f, -0.14185217f, -0.39026734f, 0.01686748f, 0.03277037f, -0.09618923f, 
    0.28614947f, 0.01314445f, 0.01751676f, 0.01592784f, -0.10166244f, -0.54162318f, -0.08615674f, -0.08125540f, 
    0.10038704f, 0.09485707f, -0.06657895f, -0.00495255f, 0.03213887f, -0.14164342f, 0.18656303f, -0.03873678f, 
    -0.44566324f, -0.30578208f, -0.27800462f, -0.03329411f, 0.25320795f, -0.21809629f, 0.29449925f, -0.32387203f, 
    -0.23402408f, 0.07413629f, -0.35110116f, 0.14998807f, 0.20740606f, -0.11331606f, -0.02965847f, -0.28698060f, 
    0.04936516f, -0.32426631f, -0.04737907f, -0.07366383f, -0.20295919f, 0.09292819f, 0.24056181f, 0.06961314f, 
    0.11686905f, 0.19200628f, 0.27562308f, 0.04201931f, -0.12153836f, 0.01096140f, -0.05114035f, 0.04347648f, 
    0.09109076f, 0.24084964f, -0.06910919f, -0.18901141f, 0.17150770f, -0.05802947f, -0.06524452f, -0.06084099f, 
    0.11273542f, -0.28807047f, 0.24350774f, -0.36000603f, -0.00261352f, -0.07395837f, 0.10804451f, -0.09513400f, 
    -0.12521715f, 0.11089660f, 0.05803151f, 0.01875014f, -0.09763625f, 0.21964087f, 0.05474537f, 0.03166229f, 
    -0.36745894f, -0.37855819f, 0.15626991f, -0.00977393f, 0.05609369f, 0.18498850f, 0.07323775f, -0.03330938f, 
    0.16020286f, 0.28740206f, -0.09484851f, -0.11044221f, 0.09090061f, -0.09290418f, 0.12417527f, -0.08083054f, 
    0.48655832f, -0.06227443f, 0.32858106f, -0.38062549f, -0.35771731f, -0.16028768f, -0.07075901f, -0.30741486f, 
    -0.46493256f, -0.10265424f, 0.11326183f, 0.13437878f, 0.21470577f, 0.05052994f, -0.49941939f, -0.34392080f, 
    0.24197797f, -0.36509371f, 0.05237912f, 0.25267941f, -0.05080767f, 0.05396768f, -0.05804732f, 0.06397914f, 
    -0.03279398f, 0.21447642f, 0.00820331f, 0.01189530f, -0.30225837f, -0.32204947f, -0.10805658f, -0.20280148f, 
    0.09860130f, 0.12696131f, -0.30117616f, 0.38734138f, 0.02021632f, 0.03947772f, 0.08886807f, 0.06887878f, 
    -0.39502501f, -0.10352702f, -0.05970070f, 0.10429283f, -0.24619867f, -0.00806670f, 0.09733365f, -0.04598470f, 
    0.11963278f, -0.27973962f, -0.14278938f, -0.34551132f, 0.10374092f, -0.23491953f, 0.16715632f, -0.04112622f, 
    0.11056919f, 0.24987502f, 0.13105096f, 0.10432654f, 0.01732070f, -0.45922697f, -0.07538293f, 0.12794606f, 
    -0.40488344f, 0.04792698f, -0.20059440f, 0.37204003f, -0.05625857f, -0.14676625f, 0.09830447f, -0.27224648f, 
    0.12735756f, -0.02575257f, 0.00938729f, -0.14300390f, 0.11847568f, 0.01543101f, 0.23887666f, -0.58998519f, 
    -0.06597404f, 0.40146270f, -0.14195405f, -0.57276207f, -0.01376955f, -0.05812242f, -0.06881060f, 0.26756749f, 
    -0.14617777f, 0.08280902f, 0.07055640f, -0.27466774f, 0.18405882f, 0.20294993f, -0.07023335f, -0.23312980f, 
    0.02567552f, -0.04181271f, -0.20314653f, -0.09170585f, -0.18782964f, -0.10903366f, -0.06202023f, 0.10614193f, 
    -0.04986901f, 0.11086595f, 0.02391076f, 0.02554693f, -0.06656764f, 0.13710496f, -0.00547158f, -0.08575130f, 
    -0.64212894f, 0.38749442f, -0.23737408f, -0.00586555f, 0.10115536f, 0.45688021f, 0.17395811f, -0.07574566f, 
    -0.37859070f, -0.13314477f, -0.10194831f, 0.01570207f, -0.12465480f, -0.26289198f, -0.28766036f, 0.03543722f, 
    -0.48509118f, -0.10805396f, -0.04505507f, 0.32159582f, -0.03026485f, 0.06928431f, -0.03540368f, 0.34223637f, 
    -0.06465977f, 0.26137653f, -0.02284727f, -0.24177885f, 0.06715190f, -0.06098600f, 0.29242438f, 0.22998577f, 
    -0.33431458f, 0.19917049f, 0.18191829f, -0.02116311f, -0.03418183f, -0.04554404f, -0.07220007f, -0.33433563f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13952649f, -0.06180671f, 0.20096947f, 0.01587062f, 0.08818796f, 0.08948332f, 0.02486008f, -0.13671245f, 
    -0.05580007f, -0.02219982f, 0.14617601f, -0.02990457f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
