#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08030856f, -0.29818833f, 0.32638401f, -0.02675032f, 0.27190939f, 0.49561551f, 0.12093432f, -0.44450951f, 
    -0.19766180f, -0.28287613f, 0.32783321f, -0.32946658f, 0.53799963f, -0.37745926f, -0.41889963f, -0.07782555f, 
    -0.12311899f, -0.24909520f, 0.37624002f, 0.21614058f, 0.24587204f, 0.57718772f, 0.14116421f, 0.00110984f, 
    0.35513240f, -0.13298124f, -0.12536973f, -0.08002350f, -0.50479573f, 0.17232659f, 0.03326799f, 0.09452050f, 
    -0.40495056f, 0.04215124f, -0.18735877f, -0.45695603f, 0.29148862f, 0.54989052f, -0.62671268f, 0.21882497f, 
    -0.10927715f, -0.10873475f, 0.20521352f, 0.07527047f, -0.05319911f, 0.22733453f, 0.45836103f, 0.47259802f, 
    -0.51709664f, -0.47690856f, -0.56334543f, 0.01242746f, -0.06778729f, 0.20063406f, -0.62675613f, -0.49364161f, 
    -0.40265864f, -0.39825001f, -0.22325225f, 0.33556274f, 0.31750232f, -0.16202274f, -0.00802275f, 0.53010583f, 
    0.49928054f, 0.17313431f, -0.56494850f, 0.36119154f, -0.11895427f, 0.09142860f, 0.13068967f, 0.20805399f, 
    -0.15787672f, -0.66274774f, -0.37230203f, -0.54316050f, 0.05009134f, -0.02525229f, 0.15803169f, 0.28299454f, 
    0.12931636f, -0.16075513f, 0.03995037f, -0.28325278f, 0.49268126f, 0.62764299f, 0.24865638f, -0.00905910f, 
    0.34967014f, -0.16824423f, -0.56255698f, -0.44914669f, -0.48244652f, 0.18900996f, -0.12841704f, 0.13343631f, 
    -0.02082061f, 0.08202402f, 0.17716253f, -0.37841168f, -0.33626726f, -0.44401610f, -0.22275999f, 0.64677817f, 
    0.31674173f, -0.08360932f, -0.22628921f, -0.08794455f, -0.27589497f, -0.18416522f, -0.34986404f, -0.08256326f, 
    -0.05949401f, -0.39093629f, -0.19899291f, 0.22600660f, -0.24126199f, -0.40483809f, -0.43411016f, -0.41897765f, 
    0.31464559f, 0.05583698f, 0.25648084f, -0.25969988f, -0.09421824f, -0.31209022f, 0.36892650f, -0.60837787f, 
    -0.06118556f, -0.06474134f, -0.72018594f, -0.21143126f, 0.00977833f, -0.02609768f, -0.04716796f, 0.35400441f, 
    -0.14702596f, -0.32328290f, -0.63605994f, -0.18702446f, -0.46467111f, -0.24790077f, 0.28870690f, -0.00878326f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.41147289f, -0.15324880f, 0.05140362f, -0.05480411f, 0.16190025f, -0.09935585f, -0.14753948f, -0.18695188f, 
    0.03208958f, -0.17369758f, 0.03543509f, -0.20087200f, 0.16778949f, -0.17891102f, -0.21877007f, -0.30208176f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01960297f, -0.08436548f, -0.07728085f, 0.05318808f, -0.04879402f, -0.14218366f, -0.05821282f, 0.15389343f, 
    0.03169651f, 0.23063807f, -0.02757696f, -0.12070007f, -0.07358177f, -0.02908202f, 0.05287010f, 0.03940109f, 
    0.02272197f, -0.14249758f, -0.29069442f, -0.04763393f, -0.08529174f, 0.15722926f, 0.04181315f, -0.11868363f, 
    0.05320166f, 0.05062213f, 0.15759203f, 0.05095862f, 0.20439921f, -0.10970162f, -0.05137783f, -0.05994912f, 
    0.12738557f, -0.08417650f, -0.04449680f, -0.00242819f, -0.29356223f, -0.23525673f, -0.07849348f, 0.00490454f, 
    0.04698341f, -0.01254479f, 0.02090479f, -0.14924175f, -0.05944960f, -0.02662048f, -0.02814795f, -0.01310318f, 
    0.01138885f, 0.13467476f, 0.15974127f, -0.22094552f, 0.07857411f, -0.06562031f, -0.00664546f, -0.00436707f, 
    0.07030152f, 0.00781799f, -0.00349016f, -0.09881923f, -0.01402684f, 0.05983423f, 0.16051812f, -0.62310183f, 
    -0.34253204f, -0.11216845f, 0.05813463f, 0.04964855f, 0.02042997f, 0.09174433f, -0.11249219f, 0.14706783f, 
    -0.01665052f, 0.14135557f, 0.04209252f, 0.11387088f, -0.13600896f, -0.01326587f, 0.06803934f, -0.01993378f, 
    -0.11897580f, 0.32231587f, 0.08512905f, -0.09559666f, -0.02197013f, 0.03626047f, -0.07448801f, 0.10464717f, 
    0.09525353f, 0.05556123f, 0.11795623f, 0.10848083f, 0.08528628f, -0.10389343f, -0.03737403f, 0.06152242f, 
    -0.00845550f, 0.15208735f, 0.15189306f, 0.13090344f, 0.01648447f, -0.08546279f, -0.05161316f, -0.10013597f, 
    0.01761949f, 0.25626451f, -0.01705583f, -0.17222509f, -0.04180251f, -0.12469649f, -0.09501327f, -0.09656338f, 
    0.01347691f, 0.06758236f, 0.03452719f, -0.02190927f, -0.19157059f, 0.29702988f, 0.11153708f, 0.04998073f, 
    0.02759906f, 0.03644626f, -0.06876242f, 0.14174688f, 0.06630577f, 0.10026577f, 0.15646818f, 0.06148588f, 
    0.06107942f, 0.05159506f, -0.19582920f, 0.13536298f, -0.20086236f, 0.05755353f, -0.06149061f, 0.22205499f, 
    0.03650014f, 0.25120077f, 0.11562495f, 0.12428883f, 0.12896910f, -0.18064706f, -0.16446146f, -0.00153627f, 
    0.06606544f, 0.02664436f, 0.07673516f, 0.01196459f, -0.04054299f, -0.03379313f, -0.12738092f, 0.24664082f, 
    0.05412718f, -0.26052877f, -0.20566267f, -0.22118750f, -0.19846055f, -0.00606862f, 0.00715338f, 0.06348339f, 
    -0.03117503f, -0.03318574f, 0.19978355f, 0.07771992f, -0.04753663f, -0.05176048f, 0.10783091f, 0.00288512f, 
    0.09750552f, -0.06877228f, 0.20091861f, -0.11706035f, -0.11615407f, -0.00400539f, 0.09218667f, -0.16281107f, 
    -0.05618230f, 0.07442871f, 0.07706254f, 0.09724874f, 0.05685611f, -0.01686573f, -0.12260829f, -0.03270297f, 
    0.05289442f, -0.08894142f, -0.10333500f, 0.00241031f, -0.03296253f, -0.21872187f, 0.04882898f, -0.18982686f, 
    0.20585680f, 0.10245195f, -0.08158027f, 0.04020789f, -0.07284910f, -0.06704729f, 0.01068060f, -0.19147515f, 
    0.29577243f, -0.12441307f, -0.05189782f, -0.02851531f, -0.19788793f, -0.01558143f, 0.08729279f, 0.08625362f, 
    0.25277880f, -0.15903169f, 0.07845790f, 0.16304660f, 0.03482872f, -0.02258073f, -0.09771481f, -0.15656504f, 
    0.28715861f, 0.08979177f, 0.02842949f, 0.01252481f, 0.05096411f, -0.04399969f, -0.07187692f, -0.03842129f, 
    -0.08162282f, 0.23673129f, -0.02517571f, -0.03579902f, -0.14413893f, -0.10315272f, 0.13340038f, -0.00588699f, 
    0.05787753f, -0.09109957f, -0.12430251f, -0.11257008f, 0.37522131f, 0.09590793f, -0.02232408f, -0.09475189f, 
    0.02158363f, 0.10885618f, 0.08174706f, 0.03578555f, 0.07886399f, 0.25336543f, -0.29418835f, -0.00179624f, 
    0.03399921f, 0.04864572f, -0.01313662f, 0.13648319f, -0.04835944f, -0.18013117f, 0.05280491f, -0.12089412f, 
    0.20372131f, -0.08347657f, 0.16971067f, -0.01894324f, 0.06727420f, -0.06644315f, 0.03457945f, 0.20239010f, 
    -0.02115613f, -0.05820964f, 0.07512852f, -0.03332574f, 0.01391112f, 0.10928222f, 0.02958670f, -0.02514200f, 
    -0.22970173f, 0.04891611f, 0.06228990f, 0.06209468f, 0.04662409f, 0.15280551f, -0.04500817f, 0.00319538f, 
    0.27188104f, -0.13970600f, 0.01607735f, 0.04716878f, -0.13412505f, -0.04872340f, 0.03889788f, -0.11369342f, 
    -0.30776927f, 0.14894880f, -0.23599981f, 0.10301386f, -0.15376773f, -0.04088876f, -0.07949280f, 0.10862307f, 
    0.07352849f, -0.07399671f, -0.29383811f, -0.05786478f, 0.01614062f, 0.10085732f, 0.04047084f, -0.08865661f, 
    -0.00795276f, -0.07399239f, -0.07468903f, -0.14742926f, 0.24016166f, 0.04053033f, 0.01409274f, -0.09382016f, 
    0.01919274f, 0.04572800f, -0.08054341f, -0.13945976f, -0.39460602f, -0.10048307f, -0.15315935f, 0.04320999f, 
    0.06109014f, 0.05963628f, 0.05884011f, -0.11127707f, 0.21014436f, -0.34276298f, 0.02500522f, -0.01424203f, 
    0.00846133f, 0.01577635f, 0.03060844f, 0.04904854f, 0.15220352f, 0.06375195f, 0.01611383f, -0.10781906f, 
    0.04441294f, -0.01261812f, 0.02541297f, 0.04597681f, 0.02711348f, 0.09784818f, 0.31219211f, 0.19552480f, 
    -0.14165312f, 0.08194222f, -0.04819541f, -0.02505863f, 0.08765811f, -0.06385005f, 0.08436459f, 0.25443268f, 
    0.23547952f, -0.25110066f, -0.09640960f, 0.02528009f, 0.08994327f, 0.03739957f, -0.02968834f, -0.09287035f, 
    0.47164732f, -0.19962455f, -0.08102816f, 0.03489939f, 0.07149249f, -0.02307694f, -0.01724555f, -0.03529705f, 
    -0.00613106f, 0.32379565f, 0.00464221f, 0.00260581f, -0.10934751f, -0.02134259f, 0.15542069f, -0.07116760f, 
    -0.04035534f, 0.05491611f, -0.07989597f, 0.03231195f, 0.02968432f, 0.00275323f, -0.05033772f, 0.06827348f, 
    -0.07103106f, 0.06072147f, 0.00712890f, 0.21521626f, -0.01238606f, -0.26071873f, 0.05824831f, 0.11056755f, 
    -0.02322381f, -0.08163156f, 0.00920064f, -0.07134183f, -0.23580508f, -0.17891234f, -0.13780765f, 0.03358860f, 
    0.04231872f, -0.05262886f, 0.08796100f, -0.09222908f, -0.03452764f, 0.13274616f, -0.06382443f, 0.11715281f, 
    0.11936667f, -0.11972155f, -0.13225664f, -0.00743426f, 0.06217115f, 0.05990992f, -0.58721346f, 0.01850475f, 
    -0.01062256f, 0.08580349f, 0.11928751f, -0.03304154f, 0.00341185f, 0.05053888f, 0.03717845f, -0.00867984f, 
    0.22022983f, -0.03623785f, 0.10768168f, 0.01881160f, 0.10069156f, -0.19135736f, -0.06899654f, 0.03172807f, 
    -0.01711892f, -0.06647471f, 0.03000973f, -0.07353657f, 0.10700084f, -0.16598460f, 0.03814073f, 0.23097093f, 
    0.14862305f, 0.24744859f, -0.08561094f, -0.06341350f, -0.02106579f, -0.15548262f, 0.10979092f, -0.00945850f, 
    -0.03868986f, -0.00441559f, -0.18325639f, -0.07601633f, -0.25804392f, 0.10778387f, -0.11360861f, 0.19461787f, 
    0.08047812f, 0.02627916f, -0.04860136f, -0.28741008f, 0.07996132f, 0.20370133f, -0.13514651f, 0.01872470f, 
    0.01238198f, -0.15403499f, -0.04613683f, 0.00456112f, 0.27408272f, 0.09516426f, -0.02810336f, -0.01647725f, 
    0.15559387f, -0.11135255f, -0.04602431f, -0.02470673f, -0.06410860f, 0.26282272f, -0.05853375f, 0.14688398f, 
    0.28637117f, 0.00294542f, -0.09587441f, 0.00225432f, 0.00015287f, -0.02504796f, 0.07832339f, 0.11244342f, 
    -0.20162007f, -0.18443628f, 0.11912125f, 0.01169761f, -0.06762230f, 0.05314709f, 0.14525802f, 0.08201707f, 
    -0.05670529f, -0.17347488f, 0.10544496f, 0.03470467f, 0.12200226f, 0.01695421f, -0.03827124f, 0.07975394f, 
    0.05325403f, 0.10904196f, 0.06905182f, -0.12945385f, -0.12704724f, -0.15097089f, 0.04228006f, 0.11433678f, 
    -0.06782593f, 0.01462835f, -0.05138760f, 0.05707902f, -0.06736244f, 0.02067834f, -0.14201231f, -0.22343834f, 
    0.07299756f, -0.01045689f, 0.09150141f, 0.02105511f, -0.02367393f, -0.08089854f, 0.02346508f, 0.07527038f, 
    0.02586547f, 0.04889273f, 0.06067689f, 0.05290665f, -0.10060624f, -0.00442035f, -0.29819939f, -0.13008513f, 
    -0.12338294f, 0.10660865f, 0.09832869f, -0.11539225f, 0.06921138f, 0.09467778f, -0.23516111f, 0.18204306f, 
    -0.07707375f, -0.01515352f, -0.00521677f, 0.03628850f, 0.05422269f, -0.04629664f, 0.08019308f, 0.04871205f, 
    -0.13177806f, -0.00407570f, -0.00657542f, -0.02089118f, 0.00569068f, 0.04024584f, 0.26226804f, 0.13683832f, 
    -0.22124150f, -0.13858834f, -0.00066628f, -0.04256503f, -0.02233422f, 0.00389165f, 0.01557823f, 0.25894642f, 
    0.42721814f, -0.36331913f, 0.05698670f, -0.07770722f, -0.10350331f, 0.00401735f, -0.32185343f, 0.04618344f, 
    0.07610919f, -0.09778339f, -0.07438538f, 0.04295705f, 0.05863902f, 0.04617308f, 0.11183570f, 0.03241435f, 
    -0.01939902f, 0.05817635f, 0.01854588f, -0.33967048f, -0.08998176f, 0.10260151f, 0.09239592f, -0.12516485f, 
    0.09353196f, 0.07733870f, -0.08650304f, -0.01111493f, 0.00632151f, 0.01297818f, 0.12655403f, -0.08166716f, 
    -0.13859387f, -0.09017135f, -0.09501763f, 0.20495696f, -0.00493781f, -0.15053684f, -0.00550171f, -0.11653683f, 
    -0.00783856f, -0.05626865f, 0.02499690f, 0.06039286f, 0.05642784f, 0.40942448f, 0.01771778f, -0.02140504f, 
    -0.12718512f, -0.02723798f, 0.00270366f, 0.07922409f, -0.00167814f, -0.09264588f, -0.01237563f, -0.25074151f, 
    0.04495431f, -0.02028751f, -0.06568114f, -0.01827368f, 0.04170197f, -0.02099342f, -0.09308467f, -0.19964163f, 
    0.05036774f, 0.03366897f, 0.22586699f, 0.08902191f, -0.06206841f, 0.10478993f, -0.07454089f, -0.29445329f, 
    0.16528414f, -0.08290908f, -0.00907129f, -0.02629499f, -0.22997241f, -0.10978531f, -0.00296050f, -0.13815814f, 
    0.02104697f, -0.24141605f, 0.21000539f, 0.10202627f, -0.03833575f, 0.01962867f, -0.11925298f, -0.06190839f, 
    -0.11973982f, 0.10914417f, 0.00029685f, 0.12805898f, 0.10531593f, -0.17650487f, 0.20239539f, 0.07598124f, 
    -0.00885301f, -0.04611711f, -0.10889558f, -0.27605596f, 0.45574704f, 0.01743943f, 0.09524418f, -0.01483899f, 
    0.04490950f, -0.08398794f, 0.05963341f, -0.03654555f, -0.06862044f, 0.09284363f, 0.02352841f, -0.01748772f, 
    -0.18405613f, -0.03885233f, 0.07199639f, 0.09747817f, -0.07156135f, -0.06744798f, 0.27561364f, 0.01790527f, 
    -0.17077158f, -0.06228425f, 0.01177233f, -0.12528335f, 0.00810304f, -0.00601002f, -0.10817826f, 0.36882848f, 
    -0.04829296f, 0.12319262f, 0.16633178f, -0.09860818f, 0.04810108f, 0.18364321f, 0.21115243f, -0.04850931f, 
    0.07876635f, -0.10408960f, -0.12025735f, -0.09831841f, 0.11010543f, 0.01548360f, 0.00296901f, 0.43646857f, 
    -0.14634410f, -0.20414427f, 0.00706996f, 0.01978875f, -0.16872928f, 0.06623784f, -0.00098069f, 0.02431666f, 
    0.06451187f, 0.21681795f, -0.18952911f, 0.08641452f, 0.04371239f, 0.09835362f, -0.13273484f, 0.03421701f, 
    0.10398721f, 0.24206546f, -0.10905474f, -0.03695852f, -0.07042979f, 0.00736519f, -0.07624169f, 0.16664688f, 
    -0.08867765f, -0.04910809f, 0.03354837f, -0.05687295f, -0.13804045f, 0.32187259f, 0.03340111f, -0.01845082f, 
    0.14821921f, -0.19527414f, -0.02632392f, -0.24211623f, -0.14668281f, 0.00529101f, -0.08245065f, 0.04783012f, 
    0.00768907f, 0.00356325f, -0.00415090f, 0.14566395f, 0.05312844f, 0.04312878f, -0.01391909f, 0.03552137f, 
    -0.07238229f, 0.01902222f, -0.00536791f, 0.05258990f, -0.03729545f, 0.05307843f, 0.00463838f, -0.15200756f, 
    0.09470929f, 0.12027032f, 0.17597762f, 0.05730113f, -0.00080668f, 0.14655164f, -0.18722314f, -0.01762430f, 
    -0.35079184f, 0.00221301f, -0.04145272f, -0.17399821f, 0.04683952f, 0.03613200f, 0.03912637f, -0.19355592f, 
    0.05049091f, -0.09103879f, 0.18437240f, 0.14574288f, 0.24037483f, -0.02118734f, -0.00018151f, 0.04907124f, 
    -0.31523395f, 0.05302182f, -0.17145504f, 0.05047064f, -0.10726436f, -0.11288976f, 0.19654651f, 0.03902774f, 
    0.02510252f, 0.11413080f, 0.22094280f, 0.16260888f, 0.25852528f, 0.08790515f, -0.18232462f, 0.00962481f, 
    0.05113995f, 0.13052920f, 0.06990656f, -0.11775398f, -0.05524839f, -0.11659957f, 0.06904253f, -0.11503894f, 
    -0.10369224f, 0.01468288f, 0.02876595f, -0.12801567f, -0.05732439f, 0.06610943f, -0.02734948f, -0.06587999f, 
    -0.12929597f, -0.06523027f, 0.12094240f, -0.01640377f, 0.05858615f, -0.10200775f, -0.13587511f, -0.04654634f, 
    0.05495357f, 0.00324862f, -0.09021748f, 0.07694351f, -0.09395484f, 0.24443352f, 0.04328028f, -0.10901058f, 
    0.00158105f, -0.05852421f, -0.06229588f, -0.06554107f, 0.04757255f, 0.08212235f, 0.09548805f, -0.24970829f, 
    -0.02034047f, 0.00123908f, -0.08289719f, -0.09694085f, 0.12282404f, 0.14251465f, -0.23907821f, 0.24657866f, 
    0.01974227f, 0.08889253f, 0.02659057f, -0.03463108f, 0.03146819f, -0.05130475f, -0.04344725f, -0.00541603f, 
    -0.00190562f, -0.01244111f, 0.05231272f, -0.05449064f, -0.03211481f, -0.03047999f, -0.05315906f, 0.03234919f, 
    -0.07644986f, 0.02485095f, -0.06242558f, -0.00359393f, 0.01334562f, -0.07445233f, -0.00312474f, 0.04472724f, 
    0.01178186f, -0.01883411f, -0.04311897f, 0.06344859f, -0.09217928f, -0.05099683f, 0.04303216f, -0.07933152f, 
    -0.08892825f, -0.01800938f, -0.03984972f, -0.02051340f, -0.09067429f, 0.02396297f, 0.04594325f, -0.05779949f, 
    -0.00062022f, -0.05599073f, 0.05040766f, -0.07157485f, 0.06399789f, -0.09380236f, -0.07076878f, 0.04897506f, 
    -0.07818193f, 0.05983693f, -0.05390618f, 0.03044867f, 0.04042703f, 0.04754218f, -0.05409828f, 0.02193900f, 
    0.00079743f, 0.03467815f, -0.07892766f, 0.00911160f, 0.02170060f, -0.04118863f, -0.08357996f, 0.00623152f, 
    -0.03770020f, 0.03887500f, -0.06148159f, 0.00063575f, -0.05949119f, -0.04913430f, -0.09319721f, 0.00978963f, 
    -0.10507388f, -0.05674541f, 0.00632455f, -0.04546015f, -0.06334770f, 0.01714763f, -0.00175772f, -0.07845680f, 
    0.01307026f, -0.04842869f, -0.05690047f, 0.02005094f, 0.01850829f, 0.03882369f, -0.02602617f, -0.08033271f, 
    -0.08065876f, 0.04213968f, -0.08560407f, 0.04467192f, -0.05265293f, -0.10277619f, -0.02945838f, -0.04600647f, 
    -0.09545816f, -0.08118736f, 0.05263284f, 0.01594051f, -0.06487150f, -0.02895986f, -0.09413853f, -0.09484960f, 
    -0.07922471f, -0.06255852f, -0.00873450f, -0.02357655f, -0.08805090f, -0.05491056f, 0.04910794f, 0.06606627f, 
    0.00899640f, -0.07682662f, 0.04424116f, -0.09041268f, -0.00683633f, -0.08447972f, -0.00003888f, 0.04722722f, 
    -0.07055492f, -0.05184775f, 0.03466816f, -0.01492395f, -0.09354103f, -0.06099813f, 0.05864200f, 0.03948602f, 
    -0.05726864f, 0.04321587f, -0.02458404f, 0.04015049f, 0.01182992f, -0.05038546f, 0.04159038f, 0.00152949f, 
    -0.00269813f, 0.04573053f, -0.00153925f, 0.02247511f, 0.04553954f, -0.10246277f, -0.01158261f, 0.02461425f, 
    -0.07003236f, -0.02108911f, -0.00133398f, 0.04389550f, 0.04192868f, 0.02001211f, -0.00307007f, -0.01470214f, 
    -0.08759179f, -0.02915251f, -0.28891304f, 0.19432776f, -0.03664536f, 0.10955106f, -0.04663555f, -0.06607890f, 
    -0.19628523f, 0.00822088f, -0.04916538f, 0.05509005f, 0.17203075f, -0.09955532f, 0.26965341f, 0.02373873f, 
    0.22335458f, 0.04649512f, -0.09111104f, -0.21519713f, -0.17096575f, 0.10536406f, 0.06501117f, 0.05333741f, 
    -0.04528843f, 0.14476749f, -0.05448468f, -0.16351032f, -0.05075810f, -0.06172896f, -0.22166820f, -0.22354369f, 
    -0.01755188f, -0.05871804f, 0.02766223f, 0.22794431f, 0.03644389f, -0.11026905f, 0.16162772f, 0.13163020f, 
    0.03962799f, -0.00541730f, 0.00102214f, 0.11780319f, 0.13749243f, 0.29621327f, -0.13610546f, 0.04889271f, 
    0.01780568f, -0.04275021f, -0.10719702f, 0.19571052f, 0.08941715f, 0.06895132f, -0.04057188f, 0.09179953f, 
    -0.14649783f, -0.04620211f, 0.13976134f, 0.00257616f, -0.10040933f, 0.02415061f, -0.03600143f, 0.00049962f, 
    0.07032771f, 0.08781066f, 0.01858388f, 0.09318962f, -0.12446410f, 0.01341357f, -0.03037413f, -0.16757846f, 
    -0.10242345f, 0.24021991f, 0.09407661f, 0.22189799f, 0.06125631f, 0.03586937f, -0.09751254f, 0.15370080f, 
    -0.13493375f, 0.01886157f, 0.06449026f, -0.01106500f, -0.00248587f, 0.21359190f, 0.11698994f, -0.04788480f, 
    0.13610573f, -0.07599348f, 0.23019943f, 0.04148872f, 0.05377649f, -0.04233311f, -0.04022847f, -0.07658546f, 
    0.20520647f, -0.06911895f, -0.03595783f, -0.33796501f, 0.00292801f, 0.16432834f, 0.08714825f, -0.15264080f, 
    0.10740855f, -0.20599228f, -0.08633215f, 0.03596983f, 0.03523712f, 0.01299564f, 0.21498321f, -0.12118927f, 
    0.18190652f, -0.17038547f, 0.04624326f, -0.00594740f, 0.26983592f, -0.14425677f, -0.16013584f, 0.11043662f, 
    -0.14545856f, -0.01289805f, 0.06617869f, -0.01449793f, 0.04328757f, 0.12323820f, -0.15867233f, -0.09310923f, 
    -0.12322034f, -0.09065500f, -0.08660880f, -0.01639778f, 0.01519198f, 0.07340160f, 0.03114228f, -0.12863694f, 
    -0.05497366f, 0.04431536f, -0.00223403f, -0.07836547f, -0.12355959f, 0.09782085f, -0.04125193f, 0.00313081f, 
    -0.24952932f, 0.27418575f, -0.17790516f, -0.14072829f, -0.20850472f, 0.00236693f, 0.15150376f, -0.12171906f, 
    0.08048457f, 0.12768330f, -0.01765220f, 0.13772792f, 0.13623112f, 0.01548406f, 0.07470287f, 0.06383689f, 
    0.06529948f, 0.00715211f, -0.15575217f, 0.08697407f, 0.13271746f, -0.03119885f, 0.06197111f, 0.03957085f, 
    0.05635930f, 0.14340924f, -0.01999467f, -0.21094748f, -0.16334930f, -0.14138159f, 0.12766016f, 0.09594668f, 
    0.03532192f, 0.08735934f, 0.02413966f, -0.10884664f, 0.04285577f, -0.10215040f, 0.12269393f, -0.17285524f, 
    -0.15784991f, 0.05036618f, -0.08425134f, -0.04884469f, -0.04171316f, -0.02227079f, 0.16015933f, 0.17949075f, 
    -0.12083977f, -0.14801520f, 0.00650856f, 0.00429054f, 0.03394924f, 0.15356323f, -0.34415570f, -0.02159015f, 
    -0.09623878f, -0.06232020f, -0.00817203f, -0.05213121f, -0.09408393f, -0.01321284f, 0.00573463f, 0.06441377f, 
    0.12300621f, -0.09914250f, -0.07775030f, -0.04202272f, 0.04414032f, -0.24194647f, 0.02237354f, -0.06530222f, 
    -0.34279463f, 0.04922731f, -0.14480023f, 0.02508789f, -0.04291219f, -0.02626537f, 0.07243791f, 0.00546356f, 
    -0.04842435f, 0.16547850f, 0.07596446f, -0.09048814f, 0.17302066f, 0.03201967f, -0.00472838f, -0.02972403f, 
    0.00673797f, 0.11075119f, -0.16028301f, 0.21820568f, -0.31256875f, 0.07990627f, 0.14182656f, 0.04395350f, 
    0.01380905f, 0.10955556f, -0.02202030f, 0.03537139f, 0.30509275f, -0.22511022f, 0.10757117f, 0.28433463f, 
    0.13966939f, -0.15421900f, -0.06064626f, -0.16099907f, -0.25393578f, -0.16999188f, -0.02679387f, 0.05426176f, 
    0.05091496f, 0.13703735f, -0.04360590f, -0.03552882f, -0.15474465f, 0.17471842f, 0.24081963f, -0.30197400f, 
    0.04202582f, -0.09897510f, 0.15069473f, 0.09604174f, -0.03021331f, 0.01155875f, -0.22129880f, -0.30647835f, 
    0.08609232f, -0.01037891f, 0.01340609f, -0.04526193f, -0.12387356f, 0.06051165f, 0.24820352f, 0.26868716f, 
    -0.31280333f, 0.11799703f, 0.00486600f, 0.05131982f, -0.13096806f, -0.05661841f, 0.04657718f, 0.00517472f, 
    -0.00373826f, -0.13719349f, 0.04813324f, -0.04561810f, 0.06173953f, -0.13685232f, -0.07834160f, 0.12571104f, 
    0.00085319f, 0.03842176f, 0.02841201f, -0.01569963f, 0.04776290f, 0.16187310f, -0.01939285f, -0.02117257f, 
    -0.12423363f, 0.10932150f, -0.06898693f, 0.09279608f, -0.10855749f, 0.26068035f, 0.05848833f, -0.02393961f, 
    -0.04300096f, -0.12447619f, 0.01354604f, -0.04912110f, 0.04303595f, 0.26975918f, -0.19727007f, 0.03435723f, 
    -0.03591836f, -0.00147731f, 0.04931206f, 0.02579664f, -0.14027160f, -0.00790804f, -0.00402714f, -0.07586550f, 
    -0.03684659f, -0.07611580f, 0.26346675f, 0.10200629f, 0.04087204f, -0.25447837f, -0.10893071f, -0.23010154f, 
    -0.08568488f, -0.20348348f, -0.07395353f, -0.13174063f, 0.02955182f, -0.01302180f, 0.38670418f, -0.01545340f, 
    0.05331806f, 0.04135388f, -0.01438027f, -0.10740545f, 0.08614738f, -0.06286467f, 0.01063989f, -0.16145678f, 
    0.05783386f, -0.05240858f, -0.00767400f, 0.09755319f, -0.03385895f, -0.08820613f, -0.12564051f, -0.02169556f, 
    0.10851978f, -0.15322615f, -0.01015226f, 0.15654960f, 0.07426413f, -0.02683915f, 0.03163313f, 0.17832690f, 
    -0.04988627f, 0.07055169f, 0.15357411f, 0.14368871f, 0.06891182f, 0.10907135f, -0.00484171f, -0.04639291f, 
    0.08583365f, 0.05404039f, 0.30088431f, 0.25311542f, 0.19643375f, -0.04511346f, 0.00396792f, 0.12785281f, 
    0.07556292f, -0.09757553f, -0.07917742f, 0.17643481f, 0.01696089f, 0.16618375f, -0.01023043f, -0.12349524f, 
    -0.01426385f, -0.04972624f, 0.00240556f, 0.02834024f, 0.10085847f, -0.02437864f, 0.03367349f, -0.07116851f, 
    -0.14937021f, -0.12830634f, -0.09113721f, 0.15276003f, -0.11509486f, 0.33624604f, 0.11937323f, 0.26285949f, 
    0.01298492f, -0.01194605f, 0.12390336f, 0.11767273f, -0.02612494f, 0.02337399f, -0.21349816f, -0.02697824f, 
    -0.15877569f, -0.07805651f, -0.05251956f, -0.16699524f, -0.05075934f, 0.01597219f, 0.12397739f, -0.24088669f, 
    -0.04350188f, -0.02646768f, -0.08380242f, 0.04213224f, 0.04198289f, -0.09492625f, -0.10467219f, 0.02553268f, 
    -0.12155335f, 0.02874943f, 0.12343862f, 0.10132526f, -0.16485345f, -0.16509190f, 0.09650252f, -0.12476172f, 
    -0.11722420f, -0.43711218f, -0.08423984f, -0.25196654f, -0.04413989f, -0.17083661f, -0.00400088f, 0.22582722f, 
    -0.15688960f, 0.00533886f, 0.23431025f, 0.04671519f, 0.31279081f, 0.07444350f, -0.05609195f, -0.07143856f, 
    0.07157575f, 0.15501350f, 0.02515622f, 0.02106423f, 0.13498239f, -0.03117805f, -0.00091671f, 0.04950615f, 
    -0.11220616f, -0.01255267f, -0.06146750f, 0.20020421f, 0.33467069f, -0.04601736f, -0.11185890f, 0.08884918f, 
    -0.03810948f, -0.18884394f, 0.01044811f, -0.01842712f, 0.06343143f, -0.40248019f, -0.27616245f, 0.00078669f, 
    0.02361116f, -0.07540966f, -0.06444097f, 0.04095180f, -0.07630079f, 0.10927732f, -0.20049486f, 0.21017472f, 
    0.09645919f, 0.13041927f, -0.12150942f, 0.04203151f, 0.07637467f, 0.03066383f, 0.02107882f, 0.08826443f, 
    -0.28074050f, -0.07875965f, 0.02492612f, -0.13158144f, 0.09320737f, 0.07687559f, -0.00333804f, 0.04817488f, 
    0.00898475f, 0.13171107f, 0.03254539f, -0.19887263f, 0.07313265f, 0.11939519f, -0.01802792f, 0.01419289f, 
    0.18056922f, -0.07867484f, -0.16288069f, 0.06784932f, -0.18002668f, 0.00462461f, 0.01678810f, -0.01926201f, 
    0.10477082f, 0.02120392f, 0.06193979f, 0.30092001f, -0.01010617f, -0.05418608f, 0.06686086f, 0.00792747f, 
    0.08226022f, 0.04435975f, -0.08525951f, -0.17567372f, 0.28175202f, -0.04898494f, 0.14069225f, -0.05171430f, 
    0.11474556f, 0.12530659f, 0.08163698f, -0.18216476f, -0.02953145f, -0.03506226f, -0.26151484f, 0.10856202f, 
    -0.08657824f, 0.16061307f, -0.02590411f, 0.00610822f, -0.12525351f, 0.17633855f, 0.23658907f, -0.17143469f, 
    0.06584833f, -0.02291975f, 0.05771733f, -0.05246059f, 0.12225045f, -0.03893869f, 0.01000439f, 0.03954135f, 
    -0.08075630f, -0.07473557f, -0.08249672f, 0.02143471f, -0.06788796f, 0.11012380f, -0.05071412f, 0.07889303f, 
    -0.30068025f, -0.39875314f, -0.04237856f, -0.06855850f, 0.03253837f, -0.17271604f, -0.05213911f, -0.06072787f, 
    -0.05048389f, -0.05400995f, 0.04545468f, -0.03652291f, -0.06043163f, 0.04933904f, -0.01219155f, -0.03177420f, 
    -0.04295101f, 0.01186955f, -0.05354556f, 0.06407624f, -0.08716690f, 0.07209919f, 0.00174446f, -0.01496902f, 
    0.05395610f, -0.06373720f, -0.02527706f, -0.02015909f, -0.05332460f, -0.02429423f, -0.09597052f, -0.03573423f, 
    -0.06426142f, -0.05275084f, -0.04320834f, 0.05541684f, -0.06538235f, 0.06181955f, 0.00563965f, -0.03985354f, 
    0.06415015f, -0.02438906f, 0.02587275f, 0.05221415f, 0.01343074f, -0.02264219f, -0.08256994f, -0.07836217f, 
    -0.07741667f, -0.00257554f, -0.04989906f, 0.02158831f, 0.00042164f, -0.03690384f, -0.06360481f, -0.07109097f, 
    -0.07113042f, -0.06728135f, 0.04373169f, -0.08607982f, -0.07955175f, 0.03809212f, -0.01068742f, -0.03624127f, 
    -0.09268578f, 0.05112379f, -0.00814890f, 0.00555028f, -0.03174042f, -0.01839251f, 0.07231773f, 0.05190439f, 
    -0.02734842f, 0.02401456f, -0.07826315f, 0.01381801f, 0.04433482f, 0.01032289f, 0.04101408f, 0.07045050f, 
    0.00848969f, -0.04840023f, -0.03324030f, -0.04182922f, -0.01699125f, -0.01654022f, -0.00437637f, -0.02116076f, 
    -0.04633253f, 0.05673870f, 0.01550473f, 0.07624541f, -0.04618588f, -0.01117132f, -0.02232884f, 0.06987797f, 
    0.02082476f, -0.00100626f, 0.00575967f, 0.02367676f, -0.06119003f, 0.03625698f, -0.06651361f, 0.00089786f, 
    -0.07679282f, -0.03287110f, -0.05644610f, -0.02606476f, -0.06519265f, 0.03648880f, 0.06271663f, 0.02709479f, 
    0.05065016f, -0.01773380f, -0.06202274f, -0.07517207f, -0.09755900f, 0.06318659f, -0.00945590f, -0.04190116f, 
    0.00474011f, -0.03476404f, -0.05683839f, -0.01042584f, 0.01496171f, 0.01421820f, 0.03654900f, -0.07430374f, 
    -0.05974388f, 0.07321129f, -0.05051759f, -0.01216083f, -0.01479855f, -0.03575528f, -0.05768612f, -0.04890980f, 
    -0.01171976f, -0.08727740f, 0.00083180f, 0.07664542f, -0.00275729f, 0.06270020f, -0.08235452f, 0.04506923f, 
    0.07171690f, 0.07987631f, 0.06462335f, -0.06654316f, 0.06972248f, -0.07257362f, 0.06871554f, 0.06598878f, 
    0.10129344f, -0.20161480f, 0.09460852f, -0.03245047f, 0.10520746f, 0.00181073f, 0.06301217f, 0.10703716f, 
    0.09445220f, -0.24431998f, 0.03335607f, 0.12823835f, 0.02587822f, 0.04129994f, -0.03263974f, 0.17876846f, 
    0.08202405f, -0.02403863f, 0.20298004f, 0.12581716f, -0.00824017f, 0.09259292f, -0.02807041f, -0.00939726f, 
    0.13745958f, 0.01927425f, 0.01844949f, 0.16048998f, 0.03896306f, -0.37526432f, 0.07253146f, -0.04517917f, 
    0.05818151f, 0.04284652f, 0.10376707f, 0.09623326f, -0.16616152f, -0.01663925f, 0.19038749f, -0.00333779f, 
    -0.04903922f, -0.16867256f, -0.10321219f, -0.04855662f, -0.03153689f, 0.25128233f, 0.31679341f, 0.22688666f, 
    0.02083212f, 0.06167449f, -0.02847699f, 0.05894670f, 0.11357889f, 0.19546603f, -0.25755882f, -0.03191525f, 
    -0.23560822f, 0.11964822f, 0.02338014f, 0.04556367f, 0.03354606f, -0.11967465f, -0.03049429f, 0.24166289f, 
    0.21372069f, 0.23464924f, -0.02944243f, -0.14841770f, 0.07783580f, 0.06550729f, 0.11325281f, -0.01847616f, 
    -0.04397243f, 0.21083432f, -0.12097930f, 0.15142618f, 0.03172505f, 0.06362484f, -0.04866182f, 0.00803917f, 
    -0.03235269f, -0.43445998f, -0.23801003f, -0.00539986f, 0.19538671f, 0.16195279f, -0.09468661f, 0.05280986f, 
    -0.04181395f, -0.15256214f, -0.22396323f, -0.11680616f, 0.03593221f, 0.04583874f, -0.03755056f, 0.04438614f, 
    0.00927380f, 0.07265045f, -0.10219838f, -0.23814867f, -0.39602000f, -0.14589329f, 0.09303019f, 0.14855988f, 
    0.08257878f, -0.16545197f, -0.27583465f, -0.08477157f, -0.03547542f, 0.16007291f, 0.00454133f, 0.10301337f, 
    0.04846296f, -0.04892777f, 0.15784994f, -0.06041436f, 0.02441365f, -0.04259061f, -0.01040198f, -0.20063935f, 
    0.06628793f, 0.03912155f, 0.05342223f, -0.03712926f, -0.00979340f, 0.04190379f, -0.04008017f, -0.21026850f, 
    -0.20396009f, -0.03666719f, 0.07286961f, -0.03491172f, 0.02687656f, 0.04020134f, -0.05309183f, 0.06500431f, 
    -0.09407013f, -0.22251187f, -0.09451974f, -0.03788089f, 0.16681916f, -0.02251829f, -0.07967255f, 0.03822586f, 
    0.33243158f, -0.21748446f, 0.02716374f, -0.22719201f, -0.21143173f, -0.29293382f, 0.12432620f, 0.14010365f, 
    -0.06465107f, -0.41172865f, -0.20952874f, -0.13478249f, -0.06569690f, -0.03736976f, -0.08053328f, -0.09776750f, 
    0.00555421f, -0.01201034f, -0.15087759f, 0.30434644f, 0.05184630f, -0.04247837f, 0.05853575f, -0.04980770f, 
    0.15620248f, 0.02065342f, 0.16668180f, -0.17064998f, -0.22789241f, -0.08983944f, 0.16207418f, 0.12488946f, 
    0.08773573f, 0.13147657f, 0.06254181f, 0.11474768f, -0.23322511f, -0.03061941f, 0.04219172f, 0.01665455f, 
    0.17052586f, 0.18229002f, -0.04060844f, 0.07822606f, 0.16420446f, -0.00384526f, -0.17866583f, 0.11186954f, 
    0.05930059f, 0.05214715f, 0.05670954f, 0.11626267f, 0.20095295f, 0.03883318f, -0.17474110f, 0.00922987f, 
    0.06522822f, -0.10073876f, 0.02275656f, 0.02161757f, 0.11001326f, 0.01788710f, 0.11508768f, 0.09361847f, 
    0.00944705f, 0.03504707f, 0.07253160f, 0.04737027f, 0.03234180f, 0.00904354f, -0.06121815f, 0.12627874f, 
    -0.40573680f, -0.13430426f, 0.01825992f, 0.08025277f, 0.16445224f, 0.05344106f, 0.02919011f, 0.03393310f, 
    0.11531727f, -0.04276126f, -0.01002435f, -0.24606211f, 0.21876432f, -0.13511819f, -0.03447363f, 0.05419854f, 
    -0.01137164f, 0.06538980f, -0.42885131f, -0.12522388f, 0.13268490f, 0.04421316f, 0.15201695f, 0.06852273f, 
    -0.07340083f, 0.14183447f, 0.03177994f, -0.18371299f, -0.36843944f, -0.17693129f, -0.02932532f, -0.07055383f, 
    -0.00363637f, -0.09969758f, -0.11488636f, -0.13781872f, -0.25729439f, -0.10617741f, 0.13009597f, 0.04472149f, 
    -0.00116525f, 0.02628132f, -0.05369749f, 0.18965958f, 0.04244804f, -0.00077431f, 0.19666187f, 0.12418282f, 
    -0.09724186f, -0.05481244f, -0.19591627f, 0.06165913f, -0.16579042f, -0.16143821f, 0.24475840f, -0.04172305f, 
    -0.00423646f, 0.13408576f, -0.12330496f, 0.04281226f, 0.01859113f, -0.20337756f, 0.09691554f, -0.38464150f, 
    0.05877003f, 0.00349201f, 0.12289368f, 0.05397470f, 0.10613000f, -0.10769197f, 0.00546288f, -0.04185191f, 
    0.12145590f, -0.14967693f, -0.08205916f, 0.01394897f, 0.11517063f, 0.11629580f, 0.08210900f, -0.17156671f, 
    -0.16359651f, 0.44145134f, 0.10520181f, 0.09055012f, 0.02764786f, 0.06296965f, 0.08290975f, 0.10787840f, 
    0.03045202f, 0.01318441f, -0.11715063f, -0.04989634f, -0.04447749f, -0.05086623f, -0.11570392f, 0.11426809f, 
    -0.10407828f, 0.04088978f, -0.28922772f, -0.00447004f, 0.04696224f, 0.02989256f, 0.01124179f, 0.08730060f, 
    -0.22913998f, -0.04658384f, 0.01161188f, 0.08029683f, -0.17803688f, -0.17297217f, -0.16323806f, -0.05844596f, 
    -0.10823289f, 0.06113986f, -0.19225217f, 0.14235856f, -0.12251588f, -0.11694713f, -0.30989152f, 0.15313552f, 
    0.10349292f, 0.10948650f, 0.06148022f, 0.05401905f, -0.24802613f, 0.06484742f, 0.18128522f, 0.01974867f, 
    0.10560367f, 0.02962550f, 0.03683057f, -0.06316487f, -0.03532822f, -0.15997373f, -0.02152149f, -0.39570269f, 
    0.09935743f, 0.03177402f, -0.26806191f, -0.05493262f, 0.02383045f, -0.05236909f, 0.07323310f, -0.04931990f, 
    0.05090542f, 0.08656724f, 0.16384731f, -0.07922699f, 0.17080481f, -0.00922175f, 0.05071440f, -0.07966706f, 
    -0.01363810f, 0.19497861f, 0.00745072f, 0.04799495f, -0.02886835f, -0.16908605f, -0.03392678f, 0.06680178f, 
    0.02767067f, 0.08633173f, 0.18736449f, -0.15050131f, -0.00970084f, 0.01559452f, -0.13312329f, -0.03453421f, 
    0.06263112f, 0.00199306f, 0.04981649f, 0.12954693f, 0.16034362f, 0.15890740f, -0.15266529f, -0.16840701f, 
    0.04290095f, 0.17051415f, 0.01141827f, 0.02331249f, 0.13791215f, -0.06522410f, 0.05495561f, 0.01370160f, 
    -0.14731912f, -0.01372653f, 0.04660115f, -0.00734326f, 0.09052879f, 0.01862384f, -0.16669972f, 0.04665632f, 
    0.10574036f, 0.00708816f, 0.18814105f, -0.09398414f, 0.04473145f, 0.03528364f, 0.16361828f, -0.13139832f, 
    -0.07659537f, -0.26152065f, 0.10179204f, -0.14269680f, -0.03405954f, 0.03945894f, 0.02218148f, -0.01075456f, 
    0.14485119f, 0.05494078f, -0.11829856f, 0.25459665f, 0.10854086f, 0.12927359f, -0.04720553f, 0.03131332f, 
    0.02662369f, -0.07745937f, -0.00393801f, 0.05176124f, 0.03537079f, 0.01384032f, 0.03873922f, -0.00492926f, 
    -0.03581721f, -0.08480085f, -0.07729082f, -0.04490408f, 0.01040769f, 0.03695837f, 0.06591382f, -0.03925664f, 
    0.01109964f, 0.02467852f, 0.00168891f, -0.09745643f, -0.09145451f, -0.00973929f, 0.04838569f, 0.02210102f, 
    -0.07716604f, -0.01005992f, -0.05807894f, -0.08731616f, -0.00187819f, 0.02589412f, -0.05711398f, 0.05005608f, 
    0.06259546f, -0.00436161f, -0.06735512f, -0.05803676f, -0.07850656f, 0.01503949f, -0.08703802f, 0.00394026f, 
    -0.04363137f, 0.00469983f, -0.00601010f, -0.02497275f, -0.09223889f, -0.09403420f, 0.06885742f, -0.02720329f, 
    -0.04021782f, -0.09900855f, 0.06185074f, 0.04957052f, 0.06712120f, -0.09365680f, -0.04215264f, 0.03555724f, 
    0.04448403f, 0.05230922f, 0.04584457f, 0.05471836f, 0.03055525f, -0.00119123f, -0.05273910f, -0.06315596f, 
    0.02265542f, 0.01718444f, -0.05697316f, -0.04330175f, -0.08772898f, 0.04893493f, 0.02193599f, 0.04246055f, 
    -0.03396730f, -0.06349134f, -0.01506892f, -0.00574338f, -0.08693091f, -0.09034124f, 0.06160493f, 0.05674261f, 
    -0.03311022f, 0.02788975f, 0.00208047f, 0.03717633f, -0.03446652f, 0.03369526f, 0.05781480f, -0.00798045f, 
    -0.08155122f, 0.03476489f, -0.08974615f, 0.00118553f, -0.08233393f, -0.01291507f, -0.02775448f, 0.04995317f, 
    -0.05476297f, -0.00502478f, -0.04265492f, -0.03436432f, 0.04333307f, 0.05078902f, 0.03428885f, -0.05441757f, 
    -0.05467995f, -0.04015233f, 0.04468483f, -0.04512672f, -0.05357170f, -0.03886179f, -0.05554937f, -0.06981299f, 
    -0.04602078f, -0.02276107f, -0.01498873f, -0.03474880f, -0.08457585f, 0.04016255f, -0.00725400f, -0.07393010f, 
    -0.08084572f, -0.02996611f, -0.03938159f, -0.04590257f, -0.05058756f, -0.00241513f, -0.07867368f, -0.10649544f, 
    0.06701852f, -0.07668292f, -0.07338642f, -0.07469554f, 0.05846950f, -0.00526067f, -0.02199888f, 0.03771095f, 
    0.03820156f, -0.07853457f, 0.02618134f, -0.00220656f, 0.08184849f, -0.00529395f, 0.06388792f, -0.06550584f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04336739f, 0.07909261f, -0.01967181f, 0.08756118f, -0.00924312f, 0.03478890f, 0.02946570f, 0.16141926f, 
    0.09342086f, -0.05119888f, 0.04999650f, -0.00919402f, 0.01979041f, 0.23792645f, -0.08912725f, 0.01422837f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19579993f, -0.20498963f, -0.07854852f, -0.17074353f, -0.04728830f, -0.09320095f, -0.14156599f, -0.04795977f, 
    0.22063957f, 0.02653918f, 0.48422265f, -0.02852276f, 0.39780325f, -0.03884000f, 0.06026340f, 0.21148098f, 
    -0.28045601f, 0.14217432f, 0.36285886f, 0.11032556f, 0.23072156f, -0.11852130f, -0.01582478f, -0.10457819f, 
    0.09476361f, 0.04108239f, 0.45847332f, -0.04632285f, -0.03724063f, 0.20251901f, 0.26979384f, 0.17177951f, 
    0.06170969f, 0.43925247f, -0.39215153f, 0.27406707f, 0.32914051f, -0.17431881f, -0.22482419f, -0.08973429f, 
    0.28110850f, -0.13923557f, 0.15353203f, -0.15078185f, 0.07779703f, 0.03769173f, -0.00162690f, -0.04193028f, 
    -0.22807874f, 0.22298571f, -0.11940674f, 0.12706125f, 0.25445214f, 0.16660267f, 0.25710389f, 0.27897763f, 
    0.01091103f, -0.27415305f, -0.38136211f, 0.01332269f, 0.23434176f, -0.32247227f, 0.22416770f, -0.15196173f, 
    0.01637860f, 0.07596280f, -0.08188251f, 0.15658121f, 0.44113371f, 0.32071954f, -0.20947829f, 0.28782943f, 
    -0.20051511f, -0.11173920f, -0.45666221f, 0.07205460f, -0.32039687f, 0.22807463f, 0.25205874f, -0.04928157f, 
    -0.20322417f, -0.10372825f, -0.11071716f, -0.28652102f, 0.19377583f, 0.09635531f, -0.03627551f, -0.24511972f, 
    0.32680312f, 0.09783217f, -0.07338632f, -0.19439313f, -0.14862829f, 0.33888805f, -0.27232972f, -0.11678329f, 
    -0.08153233f, -0.33952072f, -0.01014479f, -0.13603023f, 0.28776431f, 0.09436154f, 0.03214402f, 0.10424805f, 
    0.29149872f, -0.23179246f, -0.42022038f, -0.09138684f, 0.37820229f, 0.29091221f, -0.03172473f, 0.19022280f, 
    -0.17441380f, -0.03965205f, 0.34225628f, 0.07064829f, 0.27772328f, -0.42779189f, -0.05933543f, -0.13257135f, 
    0.31076139f, -0.32643694f, -0.30230561f, 0.22127935f, 0.24131010f, 0.49804017f, 0.06016831f, -0.01090705f, 
    -0.37773365f, -0.14604336f, 0.35238910f, 0.03166869f, -0.83593899f, 0.35582975f, -0.08918060f, -0.28895199f, 
    0.05286065f, 0.18202846f, -0.23495303f, -0.03652406f, 0.31237274f, 0.25843477f, -0.08873157f, -0.21056667f, 
    0.05423477f, -0.13958211f, -0.01002796f, 0.02157271f, 0.25699914f, 0.12590413f, 0.04991310f, 0.22951111f, 
    0.23941022f, -0.08787376f, -0.01540259f, -0.15033875f, -0.14852411f, -0.37864465f, 0.33630440f, -0.00406321f, 
    0.04867026f, -0.38763839f, 0.43644252f, -0.23462349f, -0.26020649f, -0.17298840f, -0.18842383f, -0.00294787f, 
    0.30017525f, 0.15256263f, 0.03721359f, 0.03035718f, 0.31476140f, 0.04544542f, -0.01969742f, -0.09204083f, 
    -0.19854359f, -0.05740011f, 0.23438814f, -0.21458612f, 0.15309379f, -0.32439977f, -0.00626107f, 0.29342124f, 
    0.19609192f, -0.09507550f, 0.37108445f, -0.22261761f, 0.27381220f, -0.30397934f, -0.12000097f, -0.00133034f, 
    0.28254402f, -0.10876255f, -0.16723347f, 0.44304302f, -0.03464256f, 0.44659159f, 0.01324835f, 0.05992051f, 
    -0.03214063f, 0.09440573f, -0.34531868f, -0.14997463f, -0.23282856f, -0.04529777f, 0.28779247f, 0.19526897f, 
    0.18182412f, 0.31830913f, 0.43594077f, -0.19625005f, -0.10749149f, -0.02726435f, -0.15213299f, 0.01000242f, 
    -0.12923265f, -0.18129256f, -0.27548227f, 0.22161596f, 0.09467904f, 0.23512141f, -0.09236950f, -0.03542471f, 
    0.03040806f, 0.39105898f, 0.29095286f, 0.20803197f, 0.01975192f, 0.09885148f, 0.16928186f, -0.15540403f, 
    -0.08472328f, 0.29815602f, 0.49525642f, -0.12548585f, -0.07151982f, -0.09736421f, -0.08048394f, 0.18008552f, 
    0.20769994f, -0.57171863f, 0.44839123f, 0.34503299f, -0.06704543f, 0.10351650f, 0.12786794f, -0.18736200f, 
    0.09324447f, -0.61240262f, -0.23595908f, 0.18183860f, 0.13004409f, 0.24043640f, -0.08311500f, -0.05761722f, 
    -0.22599307f, 0.62677038f, -0.20530801f, -0.15015151f, 0.61082977f, -0.16939825f, 0.02453958f, -0.26603401f, 
    0.04581418f, 0.02183052f, 0.30319533f, -0.11869478f, -0.41181290f, -0.01841646f, -0.03937549f, 0.14495456f, 
    0.16075779f, -0.16068776f, -0.00944245f, -0.28411824f, 0.23727278f, 0.05530193f, 0.10629611f, -0.29149318f, 
    0.35848325f, 0.36205575f, 0.06348090f, 0.12701938f, 0.30310988f, 0.03342441f, 0.02155666f, 0.12541655f, 
    0.29223475f, -0.16147877f, -0.42549482f, 0.24611172f, -0.16461575f, 0.23416726f, -0.08929508f, -0.15517978f, 
    0.11333685f, 0.07171886f, -0.42889881f, 0.20164303f, 0.09430251f, 0.29848760f, 0.00070257f, 0.24833281f, 
    0.21426331f, 0.25948700f, -0.23727988f, 0.18943015f, -0.23558216f, -0.11153555f, 0.01949627f, 0.05938224f, 
    -0.36070797f, -0.21489231f, 0.30125916f, -0.19648902f, -0.13594477f, 0.25192949f, 0.10897579f, -0.00438520f, 
    -0.07481536f, -0.34245473f, 0.17669255f, 0.11820227f, -0.22496869f, 0.32195926f, 0.02821019f, -0.16794917f, 
    0.45029256f, 0.08106641f, 0.01394032f, 0.22731200f, -0.19445738f, 0.52577877f, 0.00061846f, -0.13672033f, 
    0.41255260f, 0.29067379f, 0.06507941f, 0.04003037f, -0.25036076f, 0.16593367f, -0.14343308f, -0.12874471f, 
    0.39224282f, 0.08118970f, 0.29367590f, -0.17366362f, -0.26381683f, 0.45111841f, -0.13310023f, -0.21407236f, 
    0.11898346f, -0.19314139f, 0.12993284f, -0.04892932f, -0.16384989f, -0.26335192f, -0.10897866f, 0.32951286f, 
    -0.10863651f, 0.36051655f, 0.15517545f, -0.16032524f, -0.45596108f, 0.34092191f, 0.20408100f, 0.02687472f, 
    -0.01752347f, 0.10819672f, -0.35036907f, -0.09949875f, 0.53962678f, 0.09880477f, 0.18824384f, -0.23624426f, 
    -0.24709377f, 0.21971308f, 0.06808392f, -0.17000306f, 0.11266659f, 0.53076762f, 0.06843688f, 0.05611999f, 
    0.21598773f, -0.25413668f, 0.26683643f, -0.20660064f, -0.45124635f, -0.18827115f, 0.11218861f, 0.09795303f, 
    0.38886449f, -0.16529669f, 0.09531964f, 0.22971012f, 0.26738831f, -0.09104116f, 0.32482287f, 0.22893763f, 
    -0.21640904f, 0.00981091f, 0.03411371f, 0.35057756f, 0.17309442f, -0.18798131f, -0.20458058f, 0.36075488f, 
    0.08860669f, -0.27240276f, -0.43527630f, -0.03642529f, 0.15117930f, -0.13213076f, 0.16649950f, -0.18560609f, 
    -0.33726445f, 0.08954007f, -0.10764534f, 0.05289101f, -0.15007274f, -0.07125325f, -0.23839045f, 0.25166422f, 
    0.30350086f, 0.37822843f, 0.40775552f, -0.20819442f, 0.41011426f, -0.32643756f, -0.38295078f, 0.16317347f, 
    -0.24689114f, 0.02111846f, -0.01348821f, 0.40477470f, 0.32399851f, -0.03624672f, -0.21369874f, 0.41863459f, 
    -0.25467694f, -0.22032198f, -0.41822344f, 0.17708816f, -0.12336649f, 0.00243726f, 0.18361877f, 0.03683019f, 
    -0.20619801f, 0.47672790f, -0.19630067f, 0.01014599f, -0.01537713f, -0.05668198f, 0.08186036f, 0.03094211f, 
    -0.22555387f, -0.04257565f, 0.37975737f, 0.19320670f, -0.17162712f, 0.65893221f, -0.25548795f, -0.09818473f, 
    0.15439551f, -0.01881405f, 0.29974884f, -0.06104676f, 0.18170938f, 0.19770287f, 0.14599206f, -0.35047933f, 
    -0.34833297f, -0.21099432f, 0.15895037f, -0.13579029f, 0.15427846f, 0.43303466f, 0.29918483f, 0.05916435f, 
    -0.52271295f, -0.04598559f, 0.14008954f, 0.18504719f, 0.17525269f, -0.07093256f, -0.04122660f, 0.27608681f, 
    -0.03343440f, -0.29194799f, 0.43858102f, -0.08632394f, -0.06255393f, 0.16819385f, 0.12678455f, 0.19190744f, 
    -0.13667116f, -0.08344061f, 0.58202946f, -0.18158224f, -0.10669191f, -0.42318764f, 0.12359498f, -0.26181510f, 
    -0.23903041f, 0.07501999f, 0.40684301f, 0.16639344f, -0.00110380f, 0.24281546f, 0.04883523f, -0.01172372f, 
    0.03664692f, 0.21417056f, 0.38480851f, -0.05848725f, -0.35668287f, -0.12050362f, 0.19835117f, 0.33129531f, 
    0.03404511f, -0.39169201f, 0.49941024f, 0.20169935f, -0.14564809f, 0.24470703f, -0.25021514f, 0.09740774f, 
    0.15626590f, -0.08735442f, 0.33634576f, -0.37931913f, -0.02922005f, 0.10529128f, 0.00793247f, 0.04450656f, 
    0.37592891f, 0.17451787f, -0.26855698f, 0.15544927f, -0.32702729f, 0.33299968f, -0.14728642f, -0.22132839f, 
    0.38129842f, -0.35982659f, -0.24649692f, -0.21884352f, 0.13202152f, -0.07584920f, 0.03265776f, -0.23358315f, 
    -0.17080560f, 0.43630475f, -0.20578842f, 0.22219799f, 0.24209103f, -0.04187182f, 0.09421610f, 0.23094888f, 
    0.13852692f, 0.24422449f, 0.49464145f, -0.04028113f, -0.24046180f, -0.01085270f, -0.21579354f, 0.09825672f, 
    -0.44414371f, 0.38332558f, -0.36770090f, 0.09081668f, -0.16265745f, -0.03259934f, -0.00891055f, 0.03543603f, 
    0.02443596f, -0.09334802f, -0.07311810f, 0.11606941f, 0.01077827f, -0.26303658f, 0.21757546f, 0.14035325f, 
    -0.04652079f, -0.12699288f, -0.04179537f, -0.17233387f, -0.07033372f, 0.23980559f, -0.08131143f, -0.23378658f, 
    -0.06982639f, 0.12294806f, 0.37830892f, -0.07022855f, 0.22658296f, -0.14103840f, -0.03229085f, 0.19859369f, 
    0.25464848f, 0.30724004f, -0.64688838f, 0.05138053f, -0.48627758f, 0.05166500f, 0.13901041f, -0.07849607f, 
    -0.09740704f, 0.22892985f, 0.19406161f, -0.24208404f, 0.09728903f, -0.29867417f, 0.18325882f, 0.13618873f, 
    0.48087606f, -0.28228828f, 0.44242358f, 0.13907173f, -0.12890168f, 0.18201530f, -0.25984293f, 0.16182774f, 
    0.12029278f, -0.00024547f, -0.13385879f, 0.07075439f, 0.19932601f, 0.13074321f, -0.02485477f, 0.21480244f, 
    -0.01504811f, 0.21078095f, -0.45031163f, 0.11201574f, -0.34923273f, 0.00236914f, 0.32341325f, -0.11782658f, 
    -0.53453124f, 0.32621798f, 0.42193639f, 0.12719233f, 0.03040622f, -0.24977989f, 0.11101437f, 0.20995171f, 
    -0.12311292f, -0.26272663f, 0.09458509f, 0.19955096f, 0.16980921f, -0.04049025f, 0.01574912f, -0.01462179f, 
    -0.06033999f, -0.23793082f, -0.03207451f, -0.05849842f, 0.12981048f, -0.20964934f, -0.00513751f, -0.21206175f, 
    -0.20517568f, -0.02378790f, 0.07946370f, 0.21831709f, -0.06248380f, 0.07916360f, -0.22551969f, 0.14138624f, 
    0.06801984f, 0.34619889f, 0.03220496f, 0.26591173f, -0.38317290f, 0.08012253f, -0.02804896f, -0.18286279f, 
    -0.10160084f, 0.23050886f, 0.05275489f, 0.02436417f, -0.42226392f, -0.65693033f, 0.29155463f, 0.18994153f, 
    0.00518024f, -0.12056929f, -0.38346848f, -0.18321520f, 0.22433804f, 0.26531225f, 0.04001660f, 0.12009504f, 
    0.27823052f, 0.13525192f, -0.11912747f, 0.01301942f, 0.06167653f, -0.10808602f, 0.25846526f, -0.10135207f, 
    -0.04448700f, 0.06045720f, -0.15651616f, -0.03309112f, 0.11304814f, -0.09217490f, -0.02878103f, -0.21778139f, 
    0.12129485f, -0.02902938f, -0.18971163f, 0.17039672f, -0.22042495f, -0.01597133f, -0.21619272f, 0.16925862f, 
    0.03521218f, 0.03508884f, -0.19303961f, -0.05646095f, -0.13903597f, -0.10351576f, -0.07384163f, -0.04382375f, 
    -0.01367964f, -0.13641223f, 0.07091270f, 0.07945764f, 0.00726079f, -0.01687557f, -0.01432295f, 0.14692131f, 
    -0.20041671f, -0.12536138f, -0.02955390f, 0.21268032f, 0.00043950f, 0.30905142f, 0.07317828f, 0.26568967f, 
    0.15796255f, -0.24228752f, -0.22901484f, -0.16893774f, 0.19437821f, -0.19437470f, 0.21392314f, -0.05546454f, 
    0.37291107f, 0.47266838f, -0.50872904f, -0.38139954f, -0.32939193f, 0.00091825f, 0.18307082f, -0.32329664f, 
    0.32205802f, -0.12659281f, 0.18509130f, 0.22993529f, 0.25975543f, -0.10194916f, 0.10252019f, -0.16337840f, 
    0.11499424f, 0.17568539f, 0.34653181f, 0.27887011f, -0.08964548f, 0.09130292f, -0.09657757f, -0.24971104f, 
    0.30867612f, 0.06442288f, -0.37896758f, 0.00782669f, -0.28524047f, 0.06156226f, 0.35233730f, 0.20321603f, 
    -0.25512508f, 0.03407621f, 0.41594896f, 0.30259758f, -0.38956493f, -0.27484316f, 0.14171815f, 0.18243442f, 
    -0.20490043f, 0.19599605f, 0.16721846f, 0.19910139f, 0.21642570f, -0.22737817f, -0.17391591f, -0.16905954f, 
    -0.07380162f, -0.02549819f, -0.20159024f, 0.38988715f, 0.29043758f, -0.09590641f, 0.08121878f, -0.12063728f, 
    0.56284863f, 0.16560194f, -0.01092402f, -0.10057824f, -0.22627175f, -0.08767004f, 0.37433079f, 0.04037724f, 
    -0.50484955f, 0.26001036f, -0.28939900f, 0.00875214f, 0.38775948f, 0.16629456f, 0.06350871f, 0.18638761f, 
    -0.01193748f, 0.04912462f, 0.07298683f, -0.14759822f, 0.20873705f, -0.14728627f, -0.03541008f, -0.22004284f, 
    0.24035934f, -0.24697670f, 0.01371037f, -0.13770607f, -0.41716763f, 0.32386258f, -0.13464624f, 0.35850698f, 
    -0.23476319f, 0.30559510f, 0.33214331f, -0.23344138f, -0.05908388f, -0.25712010f, 0.00282466f, 0.16722320f, 
    0.10113668f, -0.26579323f, -0.24884331f, 0.03446662f, 0.57867599f, -0.19152762f, -0.15601799f, 0.19469166f, 
    0.35747331f, -0.06386350f, 0.04654150f, 0.23887815f, 0.10628381f, -0.13747452f, 0.33187518f, -0.20172176f, 
    -0.05394466f, -0.03838478f, 0.15249939f, 0.19297709f, -0.02878846f, -0.06156397f, 0.06847243f, -0.05787852f, 
    -0.16562156f, 0.16084245f, -0.39325932f, 0.13392918f, 0.33376938f, -0.33629751f, -0.38409299f, 0.14198323f, 
    0.20102726f, -0.33803883f, -0.09064869f, 0.23280352f, 0.11586219f, -0.37199420f, -0.00465212f, 0.01893025f, 
    0.37250841f, 0.41301236f, -0.11340673f, 0.08810914f, -0.18300444f, -0.36696532f, 0.25042245f, 0.12129407f, 
    0.25007072f, -0.03812815f, -0.10011805f, 0.25017449f, 0.11722814f, -0.16942823f, 0.20856714f, -0.26781777f, 
    0.53451645f, 0.19601567f, -0.15147334f, 0.19444618f, 0.02899997f, -0.25664943f, 0.16974322f, 0.19113527f, 
    -0.30758294f, 0.06221483f, -0.24408226f, 0.06573961f, 0.24156688f, 0.24531107f, -0.04542463f, 0.33998242f, 
    -0.14304897f, -0.18972439f, -0.01219742f, -0.11819600f, 0.03841841f, -0.12184361f, 0.13350096f, -0.16324820f, 
    0.29637671f, -0.01932802f, 0.38228571f, 0.10466672f, 0.13429596f, -0.30440277f, 0.02301115f, -0.27303329f, 
    0.01909015f, -0.12840869f, -0.30206418f, 0.15355691f, 0.18253538f, 0.40213275f, -0.25309896f, -0.07297755f, 
    0.19230992f, -0.06182946f, -0.08012915f, 0.21167570f, -0.15817063f, -0.38559198f, -0.17635895f, 0.24338065f, 
    -0.02566914f, -0.25678301f, -0.56722635f, -0.13956931f, 0.33504644f, 0.28065625f, -0.23026597f, -0.19449955f, 
    0.25925624f, -0.21923546f, 0.05928379f, -0.22813170f, -0.49895570f, 0.09143008f, -0.24279483f, 0.16259435f, 
    0.27032968f, 0.32547280f, 0.25773829f, 0.22256604f, -0.00458938f, -0.06413222f, -0.39676538f, 0.19168457f, 
    -0.02212932f, 0.15762389f, -0.30625242f, 0.10846519f, -0.53582311f, 0.13004780f, -0.10722156f, -0.05824732f, 
    -0.28220436f, -0.44843864f, 0.23521605f, 0.04059682f, 0.33226117f, 0.63430738f, -0.12551983f, -0.15748231f, 
    0.04764546f, 0.18597840f, -0.07086094f, 0.00504350f, -0.14681105f, 0.30964267f, 0.06940384f, 0.19036686f, 
    -0.39553207f, -0.12402897f, -0.49761954f, 0.23479281f, 0.34278059f, -0.33658835f, 0.14638343f, -0.15185046f, 
    0.06970701f, -0.09620959f, 0.29986438f, -0.20502920f, 0.35657233f, 0.02343529f, 0.07854269f, -0.11319288f, 
    0.24979876f, 0.12445976f, -0.01555094f, -0.11745210f, -0.21371225f, 0.20203097f, 0.25536355f, -0.03996529f, 
    0.37465888f, -0.29826495f, 0.26380700f, -0.36462364f, 0.07585757f, -0.01305906f, 0.00164251f, 0.08235426f, 
    0.17270030f, 0.08750550f, -0.21332328f, 0.19572912f, 0.04912158f, 0.31366992f, -0.27975911f, 0.00241770f, 
    -0.10139624f, 0.00581756f, -0.38274515f, -0.21871343f, -0.11149818f, -0.01081124f, -0.16276065f, -0.10700875f, 
    -0.01216434f, 0.30656308f, 0.21619467f, -0.08939677f, 0.28315359f, 0.44871846f, 0.11999480f, -0.01368707f, 
    0.33634740f, -0.00486543f, 0.15867679f, -0.03828480f, 0.22922942f, 0.16608667f, -0.04420081f, 0.18082039f, 
    -0.44256020f, 0.14572625f, -0.14665279f, 0.09392305f, -0.16488771f, -0.03718620f, 0.15693849f, -0.16028200f, 
    0.32930458f, 0.21137238f, 0.07317523f, 0.28712896f, -0.38950285f, -0.25505483f, -0.25865221f, 0.24389568f, 
    -0.31747425f, 0.22264098f, 0.36239621f, -0.06499618f, -0.15890001f, -0.00743591f, -0.25767359f, 0.21416195f, 
    0.32333124f, -0.34946981f, -0.35244837f, -0.11748973f, -0.31202269f, 0.30984038f, 0.20188625f, 0.14347741f, 
    0.21724774f, 0.10017720f, 0.09505526f, 0.04267945f, 0.08624893f, 0.24625552f, 0.02847566f, 0.23591904f, 
    0.09187482f, -0.16309284f, -0.12312826f, 0.00844089f, 0.08245663f, 0.33424118f, 0.16389512f, 0.29323024f, 
    0.00459183f, -0.04260971f, -0.24469607f, -0.10177948f, -0.01069135f, -0.28321961f, 0.13688418f, -0.09299253f, 
    -0.18174562f, 0.37902972f, -0.08293834f, -0.29889172f, 0.16536723f, 0.34104717f, 0.07491530f, -0.06707383f, 
    -0.19758104f, -0.47541150f, -0.54560804f, -0.24934156f, 0.22526780f, 0.32830799f, -0.37246820f, -0.03105037f, 
    -0.21351869f, 0.28522429f, 0.45422962f, 0.29671815f, 0.16272296f, -0.00490386f, 0.19368707f, 0.33186603f, 
    0.11863144f, -0.21869616f, -0.59203917f, -0.24604453f, -0.16032811f, 0.17776811f, -0.11452293f, 0.04154345f, 
    -0.09200177f, 0.15487015f, 0.07188605f, -0.26800144f, -0.30059999f, -0.53611684f, 0.21807629f, 0.15186653f, 
    0.21284610f, -0.05811988f, 0.18884322f, -0.05070844f, 0.40621212f, -0.24519111f, 0.33537701f, 0.23595883f, 
    0.29485959f, 0.19369574f, 0.17857158f, -0.08686064f, 0.09831988f, -0.22884582f, -0.10091954f, 0.23430459f, 
    -0.60606766f, 0.38047618f, -0.43988091f, 0.20918930f, -0.10088785f, 0.17956991f, -0.09000067f, 0.15257218f, 
    0.23886725f, 0.23383830f, 0.36226884f, -0.09113850f, 0.06772403f, -0.33499175f, -0.06729782f, -0.05193427f, 
    -0.14328486f, -0.40319452f, 0.29817134f, 0.00532584f, -0.03214753f, 0.29858211f, 0.03581858f, -0.10976925f, 
    -0.08916084f, -0.35642979f, -0.14520951f, 0.08458131f, 0.12323093f, 0.02755806f, 0.20049320f, -0.04222918f, 
    0.31956857f, 0.03061372f, -0.44722548f, 0.00521621f, 0.23940122f, 0.35055089f, 0.13012850f, 0.05709463f, 
    0.10543513f, 0.02978770f, -0.25113246f, 0.14668824f, 0.11316167f, 0.37642696f, -0.13277434f, 0.02884855f, 
    -0.45907438f, 0.18786632f, -0.26073307f, -0.20947765f, -0.00719079f, -0.14175399f, 0.24674979f, 0.17734076f, 
    -0.43012112f, 0.39709476f, 0.04870688f, -0.23877329f, 0.22848029f, -0.00364799f, 0.21985078f, 0.01184255f, 
    -0.09688199f, 0.03454222f, -0.43318528f, -0.08370455f, 0.39920864f, 0.24365640f, 0.17239811f, 0.08810447f, 
    -0.29753917f, 0.16312942f, -0.05388074f, -0.06828529f, 0.32250667f, 0.00552197f, -0.21965975f, 0.34205848f, 
    -0.25760674f, -0.08064441f, -0.02624544f, -0.12498061f, 0.14738277f, -0.14925756f, -0.08967774f, -0.00954416f, 
    -0.14074469f, -0.09793088f, -0.11805023f, 0.32686797f, 0.04481988f, 0.21437187f, 0.05561962f, 0.06959750f, 
    -0.15820859f, -0.23995957f, 0.20867793f, -0.16296649f, 0.43130547f, -0.21803878f, 0.41226730f, 0.21997142f, 
    -0.27842391f, 0.22603768f, 0.42567775f, 0.21478201f, -0.19920151f, 0.23592031f, 0.18959290f, 0.23966666f, 
    -0.04786408f, -0.14815156f, -0.41902134f, 0.13542372f, -0.07120371f, -0.14958684f, -0.11584906f, 0.03272838f, 
    -0.33459091f, 0.01958250f, -0.47353858f, 0.19657947f, 0.14620331f, 0.01686402f, -0.15123753f, 0.32878146f, 
    0.26383224f, -0.09970713f, -0.40887365f, -0.05931177f, -0.00015676f, 0.06202375f, -0.06086501f, 0.14020328f, 
    -0.01889626f, 0.20589665f, 0.52889270f, -0.02605288f, -0.10022314f, -0.41338053f, 0.06360214f, -0.25509223f, 
    0.29441503f, -0.13134342f, -0.05887978f, -0.22222708f, 0.21009319f, 0.07208381f, 0.25531954f, -0.11444362f, 
    0.18960863f, 0.05823349f, -0.03100052f, 0.20142207f, -0.35830066f, 0.28530470f, -0.09549687f, 0.35659572f, 
    -0.34093925f, -0.22846226f, 0.20026597f, -0.15631515f, -0.10873339f, -0.31730253f, -0.36096379f, 0.17056558f, 
    0.17991950f, 0.15233798f, -0.30822739f, 0.06961980f, 0.34923828f, -0.01780683f, -0.07290633f, 0.13684975f, 
    0.18232921f, 0.13747089f, 0.31547230f, -0.23677546f, -0.10294647f, -0.10811494f, 0.06757476f, -0.13722472f, 
    0.44364995f, 0.35639244f, 0.13534278f, 0.19485684f, -0.33591241f, 0.21232818f, 0.16703221f, 0.01734538f, 
    -0.26845056f, 0.29139918f, 0.03767060f, -0.13512287f, -0.27331161f, -0.26391321f, 0.16950530f, 0.01870896f, 
    0.05784008f, -0.11500943f, 0.30483368f, -0.00599232f, -0.24474224f, 0.20451914f, -0.22882321f, -0.17339288f, 
    0.44067734f, -0.22181188f, -0.40872648f, -0.06928098f, -0.29500517f, 0.36313719f, 0.29489574f, 0.02668428f, 
    0.16885000f, -0.33288425f, -0.17072706f, 0.43732134f, 0.10879759f, 0.09737241f, -0.20452128f, 0.08190784f, 
    -0.18058629f, -0.18712023f, 0.28798696f, 0.16368048f, 0.05899426f, 0.06641020f, 0.16699083f, -0.07979757f, 
    -0.15669745f, -0.35742080f, 0.15121055f, 0.02722769f, 0.11765695f, 0.00235837f, 0.10805441f, -0.04132580f, 
    0.46528447f, 0.35841808f, -0.00315224f, -0.07366209f, 0.04855257f, 0.00357629f, -0.04847655f, -0.13721117f, 
    0.24864206f, -0.17840257f, -0.13611743f, 0.04642760f, 0.45569250f, 0.18528713f, 0.19826536f, 0.32236153f, 
    -0.22439793f, 0.07769588f, -0.08711033f, 0.20775643f, -0.18392755f, -0.16460775f, 0.14923151f, -0.00665134f, 
    -0.03671197f, -0.14289942f, -0.19625343f, -0.01113507f, 0.34154510f, 0.04119262f, -0.09691638f, 0.06576891f, 
    -0.42320657f, 0.40277654f, -0.42015392f, 0.17780678f, 0.20762578f, 0.21863560f, -0.15757395f, -0.06288875f, 
    -0.18713033f, 0.25298983f, -0.01966928f, 0.32450557f, -0.26669839f, 0.32023317f, -0.08496188f, -0.39303672f, 
    0.06228463f, -0.13195483f, -0.10519183f, 0.20460793f, 0.17688386f, -0.28168735f, 0.46578929f, 0.07574722f, 
    0.49843374f, -0.14810301f, -0.30357972f, 0.01739555f, 0.06917671f, -0.25454450f, 0.05279481f, -0.01142196f, 
    -0.15150578f, 0.01994338f, 0.01729911f, 0.23514965f, 0.02562449f, 0.44507656f, -0.13113755f, 0.07289867f, 
    0.04739602f, 0.35020301f, 0.40373388f, -0.12476756f, 0.24691378f, 0.16235806f, 0.09367753f, -0.27614394f, 
    0.04681784f, 0.27586824f, -0.20331286f, -0.18116046f, 0.08546176f, 0.21402934f, -0.30911773f, 0.13993441f, 
    -0.09423596f, 0.18500333f, 0.34361020f, 0.01031808f, 0.10426818f, -0.03360401f, -0.23575300f, -0.11618053f, 
    0.30825457f, -0.21950693f, -0.46506649f, 0.01611001f, 0.09734897f, 0.07357032f, 0.07989987f, -0.22279398f, 
    0.30899024f, -0.22365758f, 0.12897229f, -0.13308725f, 0.12227035f, -0.07816591f, -0.05342123f, 0.11528584f, 
    0.21136113f, 0.54344088f, 0.11506493f, 0.02800947f, -0.01107344f, -0.42690733f, -0.19484918f, 0.09293669f, 
    0.22936901f, 0.05939191f, -0.08141182f, 0.24156176f, -0.14818133f, -0.53727454f, 0.06646381f, -0.03304815f, 
    0.00237738f, -0.21119244f, -0.30930525f, 0.13337602f, 0.38182467f, 0.19013751f, -0.07745901f, -0.24033473f, 
    0.11810347f, -0.25357249f, -0.00892696f, 0.31299844f, 0.09507383f, -0.11696336f, 0.00921496f, 0.19176494f, 
    0.39179620f, -0.28067544f, 0.19880345f, 0.22168316f, 0.05421318f, -0.30113724f, -0.05532160f, 0.18134341f, 
    -0.22016294f, 0.23329116f, 0.52964705f, 0.32474557f, -0.03468130f, -0.23107892f, 0.23322710f, -0.08268001f, 
    -0.07025375f, 0.08089397f, 0.01346247f, -0.12424014f, 0.01083813f, -0.10134555f, -0.05587972f, 0.05948316f, 
    -0.12195362f, -0.03074659f, 0.12441666f, -0.15253974f, -0.48801804f, -0.35908166f, 0.15700838f, 0.05550333f, 
    0.33330515f, -0.01628353f, 0.45445785f, -0.08718422f, -0.25789249f, -0.44182688f, 0.38308492f, 0.17523792f, 
    -0.15229127f, 0.22075135f, -0.38400245f, -0.16290510f, 0.13067451f, -0.16992018f, -0.11158917f, -0.04538130f, 
    -0.54807192f, 0.23150234f, -0.08173804f, -0.08294451f, 0.28184611f, 0.13516591f, 0.16463557f, 0.03123955f, 
    0.28514102f, -0.19042686f, 0.01421818f, -0.23462725f, 0.13755435f, -0.24543230f, 0.02090871f, 0.00603087f, 
    -0.20539883f, 0.36960995f, 0.08877785f, -0.05913475f, 0.11774599f, 0.10112994f, -0.26063502f, 0.07773705f, 
    0.02890461f, 0.19098753f, 0.05998497f, -0.21384843f, 0.44606209f, 0.06206727f, -0.01720139f, 0.01990550f, 
    0.19375551f, 0.45743543f, 0.11708635f, -0.20640856f, -0.15467092f, -0.61477852f, -0.11509605f, 0.00839046f, 
    0.20388234f, 0.33268893f, 0.34053972f, 0.21165568f, -0.35112596f, 0.23217078f, 0.12916973f, -0.05898304f, 
    -0.18085031f, -0.03620560f, -0.17785847f, 0.00460468f, -0.11598147f, -0.27481803f, 0.06890792f, 0.08498360f, 
    -0.27549481f, -0.21517263f, 0.05790073f, -0.34589848f, 0.38553450f, 0.13066649f, -0.14847393f, 0.02739500f, 
    0.51520622f, -0.29783395f, -0.38355738f, -0.16125254f, 0.31136605f, 0.50070530f, 0.11328214f, -0.12502477f, 
    0.01155236f, -0.23429285f, -0.11290313f, 0.18417902f, 0.47495252f, -0.11296438f, 0.05605885f, 0.14298446f, 
    0.27155918f, -0.40518698f, -0.53149039f, -0.14926331f, 0.32023203f, 0.32403076f, -0.02522268f, -0.18000178f, 
    0.38879767f, 0.01071264f, -0.07585039f, 0.04449593f, 0.00290128f, 0.06126542f, 0.16036448f, 0.20124926f, 
    0.24268574f, 0.01638373f, -0.09216550f, 0.01416229f, -0.35965946f, -0.34940171f, 0.30629051f, -0.08280382f, 
    0.29434696f, -0.13175020f, 0.34143567f, -0.00304608f, -0.60791463f, -0.07796903f, 0.16879338f, 0.03354016f, 
    0.08259268f, 0.11895242f, -0.14144489f, 0.17251888f, 0.18761390f, 0.13381629f, -0.29826641f, -0.06729154f, 
    -0.11900929f, -0.26669744f, 0.27877194f, -0.25934845f, -0.02245369f, 0.17294654f, 0.21891941f, 0.23462780f, 
    -0.26855692f, 0.38846883f, 0.00519870f, 0.24863787f, 0.23935720f, -0.06393620f, 0.02241418f, -0.00532316f, 
    0.38530600f, 0.16551889f, 0.20175292f, 0.28079635f, 0.04442027f, 0.30229491f, 0.02633614f, -0.19161268f, 
    -0.24111389f, 0.00330000f, 0.30561525f, -0.18130198f, -0.10749701f, -0.12778942f, -0.02929186f, -0.11966254f, 
    -0.01393902f, -0.23279020f, -0.21028267f, 0.19039281f, 0.22144563f, 0.07910534f, -0.18010396f, 0.10059436f, 
    -0.26284263f, -0.13761593f, -0.25632587f, -0.17316532f, 0.34972021f, -0.05437819f, 0.22526126f, 0.10258003f, 
    -0.25928587f, 0.06362045f, 0.41173181f, 0.29156217f, -0.27344155f, -0.01491843f, -0.11883385f, 0.09966730f, 
    0.03931900f, -0.00937514f, 0.15763147f, 0.10198104f, 0.01808220f, -0.04938566f, 0.18075311f, 0.21055831f, 
    -0.08703145f, 0.15950593f, -0.46891168f, -0.10394684f, 0.55263227f, -0.39706931f, 0.21079862f, 0.10304500f, 
    -0.64102328f, 0.29521239f, -0.06765805f, -0.08756065f, -0.13123383f, -0.04030858f, 0.11415292f, -0.16466507f, 
    -0.10525624f, -0.01118286f, -0.12591572f, -0.46393248f, -0.50044596f, 0.07423066f, 0.00080152f, 0.20549025f, 
    0.21084762f, 0.29112965f, 0.19295232f, -0.19619502f, -0.03791471f, 0.21521039f, 0.27648255f, 0.19891207f, 
    0.23340103f, 0.22313216f, 0.01090389f, -0.26452005f, 0.01674896f, 0.49237180f, 0.14562285f, -0.07399958f, 
    -0.41328618f, 0.20754406f, 0.11290565f, 0.00109553f, 0.19280134f, -0.47381699f, -0.32814649f, -0.21618767f, 
    -0.05476450f, -0.18372038f, -0.22841924f, -0.10513959f, -0.26146260f, -0.09030968f, 0.12367013f, -0.10274480f, 
    0.14246631f, 0.13109474f, -0.00829391f, 0.12935862f, -0.26512510f, 0.16022946f, -0.22683650f, 0.07538190f, 
    -0.34998333f, -0.16285206f, 0.09394980f, 0.22902183f, 0.30092090f, 0.12853144f, 0.19736467f, 0.26217854f, 
    -0.03277436f, -0.12995175f, -0.04260979f, 0.19655807f, 0.17195342f, -0.30287820f, 0.25097793f, 0.06911942f, 
    0.19185519f, 0.07102647f, -0.02964054f, 0.43625495f, 0.02898241f, 0.15734212f, 0.12829383f, 0.14667013f, 
    -0.21804029f, 0.27377564f, 0.38562578f, 0.15779221f, -0.29058063f, -0.09634113f, 0.01482196f, 0.07679436f, 
    -0.18684331f, 0.22714601f, 0.18827659f, -0.04937709f, -0.33462924f, -0.37551147f, 0.08529182f, -0.10806519f, 
    0.48661336f, 0.13616146f, -0.10717322f, -0.01510508f, 0.26641715f, -0.20444442f, 0.24735051f, 0.21544488f, 
    -0.12926434f, 0.23242813f, 0.50649190f, 0.31466314f, 0.08950196f, -0.19684513f, 0.06356096f, -0.06670560f, 
    0.20611088f, -0.23857129f, -0.29744092f, -0.17792937f, 0.12721451f, -0.09257120f, -0.18317188f, 0.17712082f, 
    -0.33642069f, -0.45212778f, -0.07712987f, 0.12717520f, 0.29749128f, 0.04817481f, 0.20886773f, -0.11910263f, 
    0.38207507f, 0.31767794f, -0.05086609f, 0.02618161f, -0.21531634f, 0.28408459f, 0.00016264f, 0.03039804f, 
    -0.15601400f, 0.28409547f, -0.37776351f, -0.52603889f, -0.29033065f, 0.00891236f, 0.12428781f, 0.32655585f, 
    -0.17384622f, -0.07176152f, -0.71470106f, -0.06502221f, 0.24447916f, -0.09961207f, 0.06783181f, -0.22650564f, 
    -0.40386623f, -0.14334941f, -0.01525491f, -0.36728841f, -0.07320701f, -0.20608078f, 0.15578668f, 0.34350762f, 
    0.37496737f, 0.26831737f, 0.22795850f, 0.12932879f, 0.03865928f, -0.20888931f, 0.11843413f, -0.10735183f, 
    0.12965344f, 0.37872645f, -0.20298430f, -0.38496161f, -0.41298202f, -0.20295100f, -0.05227754f, 0.03170242f, 
    0.08997981f, 0.01918740f, 0.62831831f, -0.11091461f, -0.00460859f, -0.04441829f, 0.06391621f, 0.10232844f, 
    0.09520672f, 0.23847876f, -0.07130037f, -0.06319372f, 0.10286520f, -0.20978227f, -0.17868561f, -0.07070139f, 
    -0.21775308f, 0.20510133f, 0.38167596f, -0.06547348f, 0.05251713f, 0.30792880f, -0.25659862f, -0.20287566f, 
    -0.02982558f, 0.33438063f, -0.22197911f, 0.06206256f, -0.50669640f, 0.29943642f, -0.00744652f, -0.05511558f, 
    0.12205140f, 0.44126648f, -0.12900075f, -0.23061326f, -0.36015931f, -0.61020899f, 0.05034881f, 0.14364320f, 
    0.16210940f, -0.26756528f, -0.05316585f, -0.08000524f, 0.17196096f, -0.26804450f, -0.06976414f, -0.27411494f, 
    0.14029615f, 0.63941884f, -0.07749213f, 0.13681056f, 0.32780379f, -0.29104847f, 0.12075840f, 0.20928366f, 
    -0.22622079f, 0.27851018f, -0.03695567f, 0.27905649f, 0.35545221f, 0.13671619f, -0.03308309f, 0.31700167f, 
    -0.06122683f, -0.34115618f, 0.04905026f, 0.20191979f, 0.11646310f, -0.03613643f, -0.19933833f, -0.06132238f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.32341981f, -0.27646953f, -0.05247432f, 0.22303739f, 0.00268065f, -0.03740298f, 0.05480701f, 0.05789457f, 
    0.11343633f, 0.29543036f, -0.12981987f, 0.52800065f, 0.27378890f, 0.48279721f, -0.27921876f, 0.05947702f, 
    0.17326014f, -0.21763517f, 0.15925859f, 0.58321804f, 0.12915802f, -0.18757662f, 0.07532135f, 0.03601844f, 
    0.06124334f, -0.06974337f, -0.12088767f, 0.42067271f, -0.03913221f, -0.35673121f, 0.15509541f, 0.35903978f, 
    0.09803839f, 0.41011298f, -0.09399836f, -0.34091857f, -0.07939318f, -0.02913290f, 0.54164094f, -0.09849975f, 
    -0.17804839f, 0.06850845f, -0.16230088f, -0.13516556f, -0.08233069f, -0.20543386f, -0.02830527f, -0.17608704f, 
    -0.07991786f, 0.32887796f, -0.23888288f, 0.22632121f, -0.13247885f, -0.03775497f, 0.37296751f, 0.06240781f, 
    -0.17624272f, 0.22784063f, 0.30394247f, 0.50528669f, 0.38365492f, 0.10373183f, -0.13737428f, -0.19679460f, 
    0.49642754f, 0.30238187f, -0.30089962f, -0.15831137f, 0.08528637f, 0.30305937f, 0.16538016f, -0.04052490f, 
    0.06190403f, -0.40172985f, 0.39067227f, -0.00613884f, 0.18934174f, 0.04115038f, 0.19706747f, -0.01800993f, 
    -0.00632354f, 0.33568069f, -0.06474420f, 0.52960104f, -0.27792114f, -0.03669430f, -0.21700652f, 0.12993293f, 
    0.11786880f, -0.23918709f, 0.20633802f, 0.05172671f, 0.37734571f, -0.26544160f, 0.40870970f, -0.28772315f, 
    0.45837063f, 0.43227887f, -0.10222566f, -0.22121070f, 0.02117987f, 0.33925042f, -0.12650380f, 0.23076849f, 
    0.11826631f, -0.18858807f, 0.17742953f, 0.02880163f, 0.03524613f, 0.18321036f, -0.03417190f, -0.26454955f, 
    -0.22051023f, 0.06095178f, -0.20147230f, -0.01121512f, 0.19981247f, -0.38596949f, 0.23275065f, 0.18011047f, 
    -0.18336916f, 0.44346377f, 0.27979213f, 0.19590972f, -0.00401198f, 0.07389276f, -0.29370162f, 0.16023171f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00095202f, -0.11894891f, -0.05356032f, -0.04882633f, 0.14499770f, -0.31815198f, 0.24701296f, 0.21691991f, 
    0.14324903f, 0.13135162f, 0.08052365f, -0.05956603f, 0.14874303f, 0.01025864f, -0.30641466f, 0.61317074f, 
    0.11992931f, -0.00630659f, 0.28995702f, 0.00242801f, 0.27182749f, 0.11798627f, -0.22380245f, 0.00442189f, 
    0.19673559f, 0.13330425f, -0.11863098f, -0.05772590f, 0.18239988f, 0.26259670f, -0.02075546f, -0.25204244f, 
    -0.02280681f, 0.13192789f, 0.00170192f, -0.26639077f, -0.06663387f, -0.24244726f, 0.05200521f, -0.07068925f, 
    -0.11773218f, 0.06388140f, 0.16517533f, 0.07065106f, 0.04226722f, 0.02642614f, 0.11708188f, -0.32817400f, 
    0.12131157f, -0.27224630f, 0.32249120f, -0.11747354f, 0.06129057f, 0.27102610f, -0.05136675f, 0.35474876f, 
    0.42436373f, 0.02908058f, 0.24921815f, -0.00911484f, 0.02758379f, 0.22927712f, -0.03730229f, -0.00023294f, 
    0.15868364f, -0.09114880f, 0.00131717f, -0.19447869f, 0.06169055f, -0.00390630f, 0.32905895f, -0.07662786f, 
    -0.18786095f, -0.30475977f, 0.13251837f, 0.23280764f, 0.02801983f, -0.02669283f, -0.29468057f, 0.08934983f, 
    -0.15134403f, -0.03705000f, 0.03648574f, -0.05027094f, -0.09296203f, -0.20341729f, 0.34610781f, 0.35221672f, 
    0.03694136f, 0.01452842f, -0.11480118f, 0.27175394f, -0.00087086f, -0.07205289f, 0.07447867f, 0.03325623f, 
    0.19774932f, 0.23860601f, -0.07399788f, -0.00580668f, -0.39828870f, -0.17900878f, -0.07546988f, -0.06282001f, 
    0.29343814f, 0.23799780f, 0.12453186f, 0.03229318f, -0.07664902f, 0.10618819f, 0.06217184f, -0.03908665f, 
    -0.22173066f, -0.07461621f, -0.02977511f, 0.00898241f, 0.09120174f, -0.17011687f, -0.12094146f, 0.08401127f, 
    0.09167580f, -0.38306358f, -0.14365499f, -0.07873201f, -0.13191868f, -0.11555529f, -0.13751954f, -0.06896828f, 
    -0.00806093f, -0.05630881f, 0.26139131f, 0.10986073f, 0.33000118f, 0.41166362f, 0.11289774f, -0.26493481f, 
    -0.16256689f, 0.04295618f, -0.33363044f, -0.09651607f, -0.06569728f, -0.08861972f, -0.06989136f, -0.29371622f, 
    0.50388163f, 0.00842496f, 0.02816459f, 0.12288294f, -0.40001929f, -0.12148279f, 0.01757096f, 0.34405383f, 
    -0.23962148f, 0.07737239f, -0.01703943f, 0.08038025f, 0.00488690f, 0.14933644f, 0.00919821f, -0.14014083f, 
    -0.55100489f, -0.21822496f, 0.06167785f, 0.03200272f, 0.18895572f, 0.07882460f, 0.01485694f, 0.20560899f, 
    -0.02683025f, 0.04496641f, 0.11929897f, 0.13075839f, -0.05461040f, 0.03909104f, -0.14128608f, 0.15441456f, 
    -0.15187499f, -0.27652597f, -0.01942315f, 0.15041053f, 0.06389099f, 0.15127617f, -0.27334765f, -0.02060950f, 
    -0.14409181f, 0.16592593f, -0.41855991f, -0.19840546f, -0.23361443f, -0.04177751f, 0.16058868f, 0.08652604f, 
    -0.24296702f, 0.13829985f, 0.26515982f, 0.07202440f, -0.05108134f, 0.05391579f, 0.72394997f, -0.05199768f, 
    0.00575874f, 0.28731787f, -0.00132624f, -0.13722743f, 0.15761775f, 0.29270244f, 0.19368204f, 0.14692804f, 
    -0.53079724f, 0.18971327f, -0.07383130f, -0.80058086f, 0.24801949f, 0.12394735f, -0.41901731f, -0.01025549f, 
    -0.27491885f, 0.24025437f, 0.30365291f, -0.11974730f, 0.03678216f, 0.08068572f, -0.10227902f, 0.13040727f, 
    -0.13121353f, -0.33278909f, -0.18604991f, -0.21833791f, 0.53720045f, 0.03541484f, 0.16591664f, -0.32716846f, 
    0.08777036f, 0.03870298f, -0.06278150f, -0.32078016f, 0.06954014f, -0.14476059f, 0.21289602f, -0.41577655f, 
    0.80015302f, 0.05080463f, 0.15802592f, 0.10882106f, -0.05201486f, 0.09793441f, -0.23180856f, -0.73893416f, 
    -0.13112938f, 0.27844524f, -0.06359336f, -0.00426521f, 0.15395606f, -0.69459355f, 0.16341652f, 0.13458426f, 
    0.03830034f, -0.00405784f, 0.07347098f, 0.16934171f, 0.10581692f, 0.12967949f, 0.19875920f, 0.05978055f, 
    -0.04570424f, 0.08524182f, -0.01821546f, 0.07267188f, 0.10699949f, -0.04366776f, -0.15790769f, 0.36149976f, 
    0.08049612f, -0.07040876f, 0.08490617f, 0.06300326f, 0.17662273f, 0.03883884f, -0.12377566f, 0.11341204f, 
    0.09433142f, 0.16693266f, 0.01876239f, 0.18176891f, -0.10272253f, 0.13661046f, 0.01416589f, -0.29707950f, 
    -0.23510562f, -0.05893699f, -0.27045599f, -0.19865777f, -0.03614096f, -0.04993118f, 0.16163985f, 0.11905965f, 
    -0.23281479f, -0.02986321f, 0.25382701f, 0.09700879f, 0.04820418f, -0.06449046f, 0.19435903f, -0.27932185f, 
    0.06342082f, -0.12016158f, 0.27443713f, 0.04362782f, 0.00348003f, 0.21162039f, -0.18092337f, 0.06173626f, 
    0.14454664f, 0.06879720f, -0.11563272f, 0.05755034f, -0.12186003f, -0.10957820f, -0.09441699f, 0.06605092f, 
    -0.08025815f, 0.02444171f, -0.02694432f, -0.14644413f, 0.08122090f, 0.13390891f, 0.04812019f, 0.05206002f, 
    -0.10460340f, -0.15207015f, -0.07962245f, 0.11096174f, 0.06550004f, 0.09466287f, 0.00666984f, 0.26426151f, 
    -0.28416350f, 0.17402276f, -0.12279980f, -0.27581024f, 0.07205728f, -0.07717051f, 0.34708822f, 0.29218721f, 
    0.04017223f, 0.04875920f, 0.01256437f, 0.03610071f, 0.03078876f, -0.11203697f, 0.02677884f, 0.00757904f, 
    0.08085840f, 0.28976682f, -0.18766046f, 0.00569043f, -0.01085571f, -0.19786587f, -0.08743052f, -0.04218530f, 
    0.29542860f, 0.28409046f, 0.14314359f, -0.20349380f, 0.03934389f, 0.06754038f, 0.09889839f, -0.05880871f, 
    0.13870071f, -0.17511551f, -0.19007066f, -0.03670936f, 0.18593949f, 0.01355588f, -0.09238301f, -0.15472838f, 
    0.31201711f, -0.25690931f, 0.08597036f, -0.16400699f, -0.07974920f, -0.25359082f, -0.28205591f, -0.05017056f, 
    -0.01822427f, 0.01386252f, -0.06302180f, -0.05857387f, 0.02294952f, 0.03306104f, 0.03448224f, 0.06590012f, 
    -0.05222898f, -0.03239475f, 0.05414145f, -0.05419555f, 0.02022704f, -0.00040268f, -0.03026600f, 0.06074689f, 
    -0.00052557f, -0.08328024f, 0.05399648f, -0.07447343f, -0.04877697f, -0.07562385f, -0.00567536f, 0.06529463f, 
    -0.01376231f, 0.05187333f, -0.00428012f, -0.06777834f, -0.04267594f, -0.00402969f, -0.03807906f, 0.05665741f, 
    -0.08465146f, -0.06281026f, 0.01357535f, 0.03536890f, 0.02554961f, 0.05835210f, -0.08082895f, -0.01424118f, 
    0.05760316f, -0.04671854f, 0.07409323f, -0.01874000f, 0.04444806f, 0.06136556f, -0.07639419f, -0.03929361f, 
    0.03808534f, -0.02614947f, 0.06268197f, 0.00499186f, 0.02092098f, 0.07831448f, -0.04746164f, 0.04741562f, 
    -0.05699310f, -0.01659584f, 0.06233854f, 0.02020749f, -0.04077248f, -0.04756735f, -0.06405511f, -0.03696141f, 
    -0.05447693f, -0.09121406f, 0.02881577f, 0.02487937f, -0.05635365f, 0.04782448f, 0.03237896f, -0.01308658f, 
    0.04379909f, -0.03635576f, -0.06705616f, -0.08612438f, 0.05388222f, -0.05045301f, -0.02127157f, 0.00135334f, 
    -0.06363838f, 0.07989509f, 0.02117630f, 0.03987382f, -0.08990259f, -0.03880765f, -0.06609483f, -0.05706798f, 
    0.03580757f, -0.02282509f, -0.08790781f, -0.02372748f, 0.02392522f, -0.07332403f, -0.04575082f, -0.06748503f, 
    0.00701375f, -0.03367463f, -0.06682830f, -0.03881214f, -0.02807780f, -0.02136915f, -0.08065136f, -0.06319992f, 
    0.08054899f, -0.03279891f, 0.00519945f, 0.07911044f, -0.04362994f, -0.09113251f, 0.07351508f, 0.02250874f, 
    -0.00677679f, -0.00149564f, -0.00161214f, 0.01955917f, -0.06300254f, -0.04061057f, 0.02116898f, -0.07282240f, 
    -0.00525364f, 0.07759439f, 0.06144242f, 0.04513920f, -0.00509501f, -0.09284102f, -0.08983229f, -0.00990534f, 
    0.08674350f, -0.04584315f, 0.03195486f, -0.01276115f, -0.01505018f, -0.00648285f, 0.02107746f, -0.03546056f, 
    0.03411250f, -0.03309808f, -0.00355720f, -0.00851601f, -0.03261264f, -0.04063209f, -0.06035677f, -0.06754412f, 
    -0.00462295f, -0.03624691f, 0.04846783f, -0.04689763f, 0.06517249f, 0.06552892f, -0.03497180f, -0.09474318f, 
    -0.08600578f, -0.04095936f, -0.01141720f, -0.07736817f, -0.01541152f, -0.07123236f, -0.07916809f, 0.02431815f, 
    0.05678256f, -0.02889620f, -0.01444834f, 0.02450199f, 0.01343524f, 0.06094992f, 0.04906163f, 0.05283321f, 
    -0.08439033f, 0.03364702f, 0.00561871f, 0.01819823f, 0.05305970f, 0.08670852f, -0.05889368f, 0.03433864f, 
    0.00554638f, 0.04910241f, -0.08431159f, -0.09837705f, -0.06903751f, -0.02396565f, -0.03174447f, 0.00453095f, 
    0.02922888f, 0.05807434f, -0.04992686f, -0.01164845f, -0.10692163f, -0.06975962f, -0.04842285f, -0.03905265f, 
    0.02230161f, -0.07202292f, -0.05725563f, -0.09982519f, 0.01342388f, -0.03817926f, -0.00284295f, -0.02411548f, 
    -0.09392070f, -0.07216150f, -0.05430768f, -0.07282259f, -0.02510639f, 0.03715180f, 0.01260847f, -0.00478960f, 
    -0.01533703f, 0.03032546f, -0.10187823f, -0.07850364f, -0.09635261f, -0.06011452f, -0.07995611f, -0.09859398f, 
    -0.08682636f, -0.08477321f, -0.06058970f, 0.01275719f, -0.04421171f, -0.06389599f, -0.01298126f, 0.06770301f, 
    0.06360834f, -0.04301472f, -0.10099135f, -0.02056283f, 0.01796340f, 0.02537376f, 0.08406202f, 0.00017302f, 
    -0.10643741f, 0.05855021f, -0.00699000f, 0.06414001f, -0.07594291f, 0.06311635f, -0.02810920f, 0.05567229f, 
    0.00646186f, -0.02758945f, 0.04559082f, -0.06037375f, 0.00246066f, -0.02156421f, -0.08588938f, -0.06717405f, 
    -0.00706657f, 0.06395038f, 0.03823896f, 0.05534388f, -0.03025004f, -0.02771772f, -0.03723810f, -0.09955689f, 
    -0.06324618f, -0.00423770f, 0.00831235f, 0.04505596f, 0.00237448f, 0.08309641f, -0.00525323f, -0.06477860f, 
    0.01048237f, -0.07479509f, 0.04516844f, -0.03730388f, -0.01662647f, 0.01659366f, -0.09908395f, -0.06226418f, 
    -0.03162966f, 0.01872685f, 0.03351605f, -0.03752071f, -0.06379739f, -0.02466010f, -0.04867324f, 0.00668145f, 
    -0.02433633f, -0.05393015f, 0.06997176f, -0.07778382f, 0.06217295f, -0.08859407f, 0.04059479f, -0.04437801f, 
    -0.03447977f, -0.00509574f, -0.00919735f, 0.05059792f, 0.08484811f, 0.04091226f, -0.06795346f, 0.04613758f, 
    0.08680811f, -0.09616756f, -0.03176137f, 0.05569813f, 0.04199393f, 0.05063741f, -0.01284021f, 0.02746447f, 
    -0.04434099f, 0.00246135f, 0.05230799f, -0.06332990f, -0.06922425f, -0.01554170f, 0.03718624f, -0.03657187f, 
    -0.06985472f, 0.04969802f, 0.06437613f, -0.03309520f, 0.04472024f, -0.08231154f, -0.06506343f, -0.05587222f, 
    -0.00874359f, -0.05907876f, 0.01938856f, -0.07395164f, -0.01773440f, -0.09614557f, -0.05967384f, -0.02833549f, 
    -0.09117325f, 0.05894714f, -0.09162293f, -0.00332179f, -0.08238151f, -0.07531686f, -0.02586914f, -0.08214814f, 
    -0.01792990f, -0.01127654f, -0.05863180f, -0.06981407f, -0.04520784f, 0.04214949f, -0.01617581f, -0.06065007f, 
    0.06024101f, 0.03540757f, -0.05977245f, 0.07743168f, -0.04287206f, 0.03261148f, 0.06350751f, 0.03871537f, 
    -0.07249732f, -0.09186511f, 0.02912608f, 0.03936258f, -0.00215974f, 0.01617554f, 0.03434635f, -0.04269606f, 
    0.03822173f, 0.02932133f, 0.02017821f, 0.01214260f, -0.01921688f, -0.01053604f, -0.06734551f, -0.02275741f, 
    -0.02896785f, 0.00822905f, -0.03143436f, 0.04342974f, -0.09339231f, -0.09623954f, -0.01847351f, -0.05545016f, 
    0.07979096f, -0.05682317f, 0.06692147f, -0.01098941f, 0.06583755f, -0.05839181f, -0.03853962f, -0.10277177f, 
    0.23995952f, -0.02920125f, 0.34213588f, 0.08130635f, -0.21592553f, -0.04428189f, 0.08498295f, 0.13115928f, 
    -0.07334410f, -0.07761763f, -0.01725352f, -0.06938150f, 0.13661560f, -0.01690775f, 0.05028193f, -0.29909253f, 
    -0.04167629f, 0.24232359f, 0.24283075f, 0.31025213f, -0.02616175f, -0.01309413f, -0.08074745f, 0.30772364f, 
    -0.05538880f, -0.15537363f, 0.06744398f, -0.08342745f, 0.26065969f, -0.14768192f, 0.08967172f, -0.57978582f, 
    0.07814014f, -0.00965553f, 0.55630934f, -0.20279157f, 0.07723231f, -0.29957610f, 0.17253073f, -0.05249771f, 
    0.00963083f, -0.02182573f, 0.22285306f, 0.02508369f, 0.00563781f, 0.01105721f, -0.03781752f, -0.07819755f, 
    -0.08857859f, 0.10682207f, -0.11728123f, 0.10692150f, -0.12558851f, 0.04738039f, -0.06553395f, -0.01500782f, 
    0.10401376f, 0.02930284f, -0.12140252f, 0.15453751f, 0.15606004f, 0.37916952f, 0.05947397f, -0.14171880f, 
    0.10379780f, 0.45387173f, -0.07863541f, -0.02461983f, 0.16552283f, 0.08505483f, 0.06521644f, -0.06337424f, 
    0.26129484f, -0.14912929f, -0.06751496f, 0.30198693f, 0.07499306f, 0.21967822f, 0.08630134f, -0.08392932f, 
    -0.22373378f, 0.19617531f, 0.03057812f, 0.03424795f, 0.00732346f, -0.06885417f, -0.48494190f, -0.00758431f, 
    -0.02537559f, -0.26384598f, 0.09222808f, -0.09276152f, 0.32152501f, -0.12146802f, 0.03723890f, 0.06009238f, 
    0.34233853f, 0.01898180f, -0.09323458f, -0.51339227f, 0.41774487f, 0.08470255f, -0.29027995f, -0.00797676f, 
    0.21922107f, 0.17846031f, -0.09796271f, -0.07906498f, 0.00810242f, 0.03914060f, -0.03332781f, 0.08326858f, 
    0.13639323f, 0.15365526f, 0.02511775f, 0.01958307f, -0.06633251f, -0.10977869f, 0.19455250f, -0.03590469f, 
    -0.36750248f, 0.32453990f, 0.12612541f, 0.32537949f, 0.04397372f, 0.17166971f, 0.54265851f, 0.10115916f, 
    0.18844318f, 0.14121500f, -0.02488258f, 0.11657493f, -0.22119854f, -0.31888333f, 0.03413896f, 0.19485450f, 
    -0.19399303f, -0.09169943f, 0.09115270f, 0.17310035f, -0.17033200f, 0.18822251f, 0.12721555f, -0.19688812f, 
    -0.55769944f, 0.07692717f, -0.07014153f, 0.15709256f, -0.12286988f, -0.10010988f, -0.08912445f, 0.08009803f, 
    -0.00985892f, -0.15233348f, 0.13743283f, -0.07222956f, 0.13285220f, 0.08624645f, 0.05266632f, 0.02251271f, 
    0.29374564f, 0.13736187f, 0.26587346f, -0.06934995f, 0.08141901f, -0.06705409f, 0.30088115f, -0.11662766f, 
    0.15321913f, -0.00726634f, 0.18194382f, 0.01141589f, 0.08459653f, 0.03081084f, -0.13271579f, -0.35155833f, 
    0.05705755f, 0.30208358f, -0.10407483f, 0.10357325f, 0.07708260f, -0.01904063f, 0.44890895f, 0.02270481f, 
    0.02129385f, 0.08985225f, 0.22788666f, 0.02958817f, 0.28303391f, 0.01648667f, -0.06084028f, -0.09434107f, 
    0.23366253f, 0.16235049f, -0.07267539f, 0.06251027f, -0.04390644f, -0.06832396f, 0.21993661f, -0.00605307f, 
    0.08904134f, -0.11067487f, 0.04888986f, -0.08209483f, -0.00147926f, 0.10676423f, 0.10729083f, -0.18762499f, 
    0.14579292f, 0.00787271f, 0.28801697f, 0.17226616f, -0.12699917f, 0.00889571f, -0.02677227f, -0.07625694f, 
    0.19226585f, -0.04626840f, 0.07833035f, -0.07447769f, 0.01192933f, 0.01046341f, 0.02499073f, 0.21214393f, 
    0.19990192f, -0.01872125f, 0.22879569f, 0.06012939f, 0.07378727f, 0.13101277f, -0.09757070f, 0.05109720f, 
    0.19896463f, -0.10127940f, -0.06619710f, -0.04635954f, 0.07912716f, 0.07943745f, -0.06870386f, 0.03182418f, 
    -0.26823735f, -0.01404248f, 0.15269229f, -0.06526762f, 0.01354973f, -0.03615092f, 0.25929657f, 0.23452704f, 
    -0.43325725f, 0.24658409f, 0.16151735f, 0.22014402f, 0.06733961f, 0.31521857f, 0.31023979f, 0.14565881f, 
    0.22288321f, -0.03579126f, 0.16079830f, 0.08074049f, -0.17978044f, -0.28381756f, 0.17065001f, 0.32983375f, 
    -0.05410209f, -0.00336885f, 0.05381925f, 0.22934048f, -0.12886776f, 0.18442145f, -0.06781971f, 0.09976085f, 
    -0.23599131f, 0.04710433f, 0.07322874f, 0.21817437f, -0.28561866f, 0.01531166f, -0.00438507f, 0.14650127f, 
    0.00644354f, -0.14493486f, 0.06845841f, -0.19925727f, -0.15362622f, 0.21803434f, 0.09000644f, 0.45494005f, 
    0.29434451f, 0.21488729f, 0.18028851f, -0.31746259f, 0.03044051f, -0.17549248f, 0.49449411f, -0.04767977f, 
    0.11386346f, -0.06257530f, 0.38966766f, -0.01735129f, 0.08037521f, -0.04689435f, -0.19797598f, -0.51502526f, 
    0.02000415f, 0.18180121f, -0.16708386f, 0.01686084f, 0.01840889f, -0.01949566f, 0.01653940f, -0.04675268f, 
    0.04872352f, 0.10017885f, 0.16616744f, 0.23323545f, 0.25334778f, 0.06558431f, -0.21850951f, 0.05646736f, 
    0.19317189f, 0.28739512f, -0.03788472f, 0.04272336f, -0.01465385f, 0.07897790f, -0.32653907f, -0.19797264f, 
    0.14660671f, -0.23238534f, 0.27499640f, 0.11452047f, 0.02965720f, 0.12805013f, 0.11553458f, -0.17819080f, 
    -0.20184663f, 0.09552768f, 0.07194669f, 0.25884402f, -0.04862156f, 0.00818061f, -0.03067170f, 0.10172813f, 
    0.11282426f, -0.14444897f, 0.07335617f, 0.02578181f, 0.28888270f, -0.22733147f, -0.05342882f, 0.13689746f, 
    0.30589369f, -0.02237839f, -0.17294922f, 0.01528388f, 0.03800401f, 0.31215498f, -0.06767450f, -0.02274420f, 
    0.18455011f, 0.20230581f, -0.03605606f, -0.06288300f, 0.02424971f, 0.05777933f, 0.04284984f, -0.09526502f, 
    -0.28348809f, 0.13978592f, 0.00121600f, -0.00559612f, 0.09329948f, -0.03480168f, 0.11099084f, -0.03510174f, 
    -0.47970521f, -0.03435881f, 0.14277230f, 0.40253109f, 0.16077097f, 0.31417501f, 0.13590756f, 0.09525543f, 
    0.12715220f, 0.04533854f, 0.29889530f, 0.07502235f, -0.21602380f, 0.37134194f, 0.11873949f, 0.19904920f, 
    0.26220658f, -0.26428816f, 0.23205844f, 0.17277096f, -0.13533680f, 0.11741778f, 0.11527193f, -0.03856601f, 
    0.44308764f, -0.08044227f, -0.03132327f, -0.06147389f, -0.20050676f, -0.16118887f, -0.40348765f, -0.13124578f, 
    0.04903710f, 0.24618134f, 0.14756306f, 0.00658818f, -0.07673795f, -0.23946896f, 0.09989162f, 0.14445692f, 
    -0.02395873f, -0.34762511f, -0.02763685f, 0.08628277f, -0.06905226f, -0.14453861f, 0.06769168f, -0.29401386f, 
    0.43675673f, -0.04083412f, 0.12983459f, -0.21805522f, 0.01282085f, -0.05030158f, 0.00886767f, -0.07205845f, 
    0.07215104f, 0.39192069f, -0.29562655f, 0.08489201f, -0.25982851f, -0.11247269f, 0.32814032f, -0.17584814f, 
    -0.29726037f, -0.10087962f, 0.18756028f, 0.21312103f, -0.08633655f, 0.06216532f, 0.02418552f, -0.23831819f, 
    -0.03549927f, -0.09109806f, -0.17050655f, 0.22476296f, -0.11314993f, -0.15203466f, -0.28642294f, 0.24097490f, 
    0.09828862f, 0.01586305f, 0.01696446f, 0.02223546f, -0.20677862f, 0.18410075f, 0.10021601f, 0.22725086f, 
    0.14475894f, -0.13606898f, 0.16782743f, 0.10746913f, -0.11537288f, 0.03442214f, -0.36795923f, -0.01031928f, 
    0.03128504f, -0.21926711f, -0.12246401f, -0.08564872f, -0.01834581f, 0.23069759f, 0.12288095f, -0.19506076f, 
    0.32702667f, 0.09295970f, 0.39118657f, -0.11298178f, -0.05267074f, -0.02084136f, -0.24958752f, 0.19787687f, 
    -0.14725637f, -0.01450283f, -0.29737559f, 0.41919932f, -0.09686050f, -0.00043670f, 0.00506883f, 0.14172417f, 
    -0.42390782f, -0.21066563f, -0.18204372f, -0.05320991f, 0.18163630f, -0.01793928f, 0.30177569f, 0.36561430f, 
    -0.02632533f, 0.01307828f, -0.08867125f, -0.11053460f, 0.01018523f, 0.09001429f, 0.01178490f, 0.13982856f, 
    0.32358578f, 0.17469193f, -0.09926004f, 0.00434499f, -0.09373391f, -0.23105802f, 0.23668800f, 0.44204164f, 
    0.21407363f, -0.06426529f, 0.24810408f, 0.44306982f, -0.32883123f, 0.07438154f, -0.14116330f, 0.55609024f, 
    -0.03024983f, -0.04158227f, 0.04647461f, 0.12682152f, -0.01009753f, -0.23605539f, 0.01569769f, 0.33063918f, 
    0.02624758f, 0.14225931f, 0.08519997f, 0.07355503f, 0.04138383f, 0.35537782f, 0.40751329f, 0.83231735f, 
    0.37131634f, -0.00922047f, 0.47839490f, -0.64279187f, 0.05227055f, -0.34917083f, 0.41037959f, -0.13929906f, 
    0.44318318f, -0.06888179f, -0.18619217f, -0.13542038f, 0.07522411f, 0.02370271f, -0.10742547f, -0.51738375f, 
    -0.29339460f, 0.26942161f, -0.43307906f, -0.04664533f, -0.30715230f, 0.16619211f, 0.15771121f, -0.32563305f, 
    -0.49775872f, 0.14583571f, 0.42769367f, 0.34580800f, -0.07918988f, 0.35784453f, -0.21701699f, 0.05656353f, 
    0.28165978f, 0.11484364f, -0.12294213f, -0.05511162f, -0.03945808f, -0.11197072f, 0.13324074f, 0.05776642f, 
    0.12769786f, -0.07030027f, 0.55241531f, 0.09898956f, -0.30163941f, 0.14946991f, 0.20432168f, 0.04832159f, 
    0.09042075f, -0.08756971f, 0.01445607f, 0.01394997f, -0.18600911f, -0.55205899f, -0.09915320f, 0.22068682f, 
    -0.04337326f, -0.07351689f, 0.07753407f, -0.35893431f, 0.37137702f, -0.00658936f, 0.08805533f, 0.14454751f, 
    0.21916780f, 0.11325629f, 0.21731518f, 0.83603054f, 0.15971407f, 0.33041298f, -0.03804476f, -0.19198690f, 
    0.26892111f, 0.38588023f, -0.37604114f, 0.14921686f, 0.11776488f, -0.06811432f, 0.08034611f, 0.18360725f, 
    0.30422154f, -0.04381768f, -0.52168155f, 0.07253152f, 0.10379291f, -0.34443489f, -0.02355568f, 0.24993087f, 
    -0.38334930f, -0.04134655f, 0.30659288f, 0.21235017f, 0.22869226f, -0.78525817f, 0.15174973f, 0.19277215f, 
    -0.28010982f, -0.04836889f, -0.22243606f, -0.35556188f, 0.12025624f, -0.00771795f, -0.34684861f, -0.03099121f, 
    -0.29777321f, 0.01677147f, 0.08905046f, -0.86098635f, 0.04423906f, -0.60975635f, 0.07980189f, 0.04250887f, 
    -0.49982545f, 0.10714161f, 0.17109415f, -0.07352190f, -0.29371530f, 0.07861167f, 0.26827124f, 0.04631915f, 
    -0.25503108f, 0.02395409f, -0.03839472f, -0.07916845f, 0.01458838f, 0.18001112f, -0.01652984f, -0.07531923f, 
    -0.21996862f, -0.44672951f, 0.28311202f, 0.24363269f, -0.05072374f, 0.15004942f, -0.41231480f, 0.15971458f, 
    -0.14480677f, 0.05923666f, 0.22325385f, 0.06665289f, -0.08124196f, 0.00403788f, -0.14812841f, 0.01093160f, 
    0.20336299f, -0.20288719f, 0.33481041f, -0.31966227f, 0.16641667f, 0.12097149f, -0.18545668f, 0.36208895f, 
    0.32688996f, -0.12438823f, -0.43572137f, -0.55780578f, -0.13758872f, -0.00774026f, -0.19680580f, 0.13739525f, 
    -0.32018012f, -0.19481188f, 0.08372875f, 0.11461987f, 0.02415528f, -0.07051380f, 0.06940807f, -0.27132422f, 
    -0.40134034f, 0.16381961f, -0.44352192f, 0.04953557f, 0.15304907f, -0.49407908f, -0.38483468f, 0.06598068f, 
    -0.05136064f, -0.17502466f, -0.10777212f, -0.18879770f, 0.08724647f, 0.19203375f, -0.03574394f, 0.22582938f, 
    0.21555422f, 0.11459134f, 0.10886107f, -0.01765729f, -0.05909094f, -0.32071847f, -0.71845073f, 0.46638119f, 
    -0.53011876f, -0.08521941f, 0.05483622f, 0.33512813f, -0.03708265f, 0.02351176f, 0.13190043f, -0.01782772f, 
    -0.37357780f, -0.17420118f, 0.03228629f, 0.16550066f, -0.01562693f, 0.07223959f, -0.00008967f, -0.04309358f, 
    0.30375391f, -0.03773583f, -0.06202323f, 0.04609543f, -0.05399285f, 0.30146542f, -0.02643325f, -0.79731220f, 
    0.01189755f, -0.61334944f, -0.42240211f, -0.42768443f, -0.22435622f, 0.08500299f, 0.39697942f, -0.27731332f, 
    -0.05190413f, -0.07735413f, 0.01631050f, -0.03161470f, 0.00716395f, -0.05555790f, -0.07201068f, 0.00474940f, 
    0.03893507f, -0.08614722f, -0.03791066f, -0.02119597f, 0.03198684f, -0.03739105f, -0.09918683f, 0.06788015f, 
    -0.04115644f, 0.02443801f, -0.08845957f, -0.08585234f, 0.03483148f, 0.02041064f, -0.02255476f, 0.00949350f, 
    -0.05151414f, 0.03933183f, -0.06422866f, -0.06981622f, -0.04385153f, -0.00235754f, 0.02918672f, 0.01282479f, 
    -0.02537498f, -0.02951809f, 0.06035934f, 0.00953728f, 0.08814546f, 0.00222203f, -0.03669462f, -0.00379865f, 
    0.01034663f, 0.08555061f, -0.01855363f, -0.09667289f, -0.08588771f, 0.06957910f, -0.05097499f, 0.05559307f, 
    0.02841048f, -0.08441657f, 0.04803519f, -0.06342227f, -0.09326237f, -0.00877347f, -0.10371270f, -0.05533831f, 
    -0.09249030f, -0.03441377f, -0.08676317f, -0.07539504f, -0.04530416f, -0.07083751f, 0.04185579f, -0.02822043f, 
    -0.02624954f, -0.02319136f, 0.05504573f, 0.03536791f, -0.07379601f, -0.04013105f, -0.02219096f, 0.08012162f, 
    -0.09457435f, 0.01762955f, -0.05601668f, 0.00074841f, -0.07507958f, 0.00423993f, 0.04572337f, 0.03907286f, 
    -0.03518724f, 0.08597384f, 0.02636059f, -0.08548988f, 0.05404308f, 0.02661501f, -0.08208589f, -0.05891632f, 
    0.02225231f, -0.03669830f, 0.01745202f, -0.09920789f, 0.00852013f, -0.08347479f, -0.07138401f, 0.03478196f, 
    0.01374919f, -0.07135867f, 0.04971024f, 0.06965225f, -0.00980908f, -0.01359622f, 0.02476480f, 0.03529280f, 
    -0.03159731f, 0.03387915f, -0.02104804f, 0.05753140f, 0.02412549f, 0.01727915f, 0.06921127f, -0.06494141f, 
    0.05606299f, 0.04708377f, 0.00063420f, 0.04463502f, -0.03506039f, -0.10800624f, 0.05392671f, 0.05955280f, 
    -0.05593481f, -0.02134529f, -0.02174857f, 0.06609267f, -0.03455738f, -0.05551732f, 0.00475319f, -0.03159175f, 
    -0.09097882f, -0.10931495f, -0.12724261f, -0.05547788f, -0.04665807f, 0.02556982f, -0.10641208f, -0.08969612f, 
    -0.02098572f, 0.02786615f, -0.06020869f, -0.11382420f, 0.00186095f, -0.09278957f, 0.02950281f, 0.01290048f, 
    -0.00320111f, -0.09870574f, -0.11433547f, 0.04497293f, -0.06961863f, -0.06094385f, -0.12324626f, -0.05598316f, 
    -0.11149532f, -0.02604363f, -0.09179091f, 0.00639404f, -0.05891271f, -0.06847870f, -0.05203312f, 0.01793440f, 
    -0.09250636f, -0.13695435f, 0.00620102f, 0.05876954f, 0.04046747f, -0.11640475f, 0.01021684f, -0.02003334f, 
    -0.05528509f, 0.02326768f, 0.04030687f, 0.02458956f, -0.05781528f, -0.04455189f, 0.02928361f, 0.02567369f, 
    0.03377737f, -0.06604946f, -0.10877800f, -0.13889535f, -0.06862681f, -0.07681261f, -0.07676000f, 0.03304477f, 
    -0.04552652f, -0.06804516f, 0.00795395f, -0.09635845f, 0.00882829f, -0.05458054f, -0.05689668f, -0.11636824f, 
    -0.13143289f, 0.01938248f, -0.09399781f, 0.03055085f, -0.02545808f, -0.06709516f, -0.05302752f, -0.04640142f, 
    -0.12027846f, 0.03285298f, -0.08277173f, -0.02015541f, 0.05720140f, -0.01151235f, -0.06724463f, 0.03010190f, 
    -0.05204846f, -0.09053735f, 0.04194025f, -0.04045002f, -0.09737905f, 0.05864927f, 0.01709565f, -0.05280871f, 
    -0.06304173f, -0.05051983f, 0.00379073f, -0.04396589f, -0.00733945f, 0.03832205f, -0.01704513f, -0.09555200f, 
    -0.06076874f, -0.07967259f, 0.05354095f, 0.07093894f, -0.13440815f, -0.07750585f, -0.06162369f, 0.02005608f, 
    -0.07241795f, 0.01659433f, -0.05491927f, -0.05265643f, 0.03471388f, -0.00504227f, 0.04866618f, 0.01064281f, 
    -0.07925762f, -0.10789864f, 0.05802801f, 0.07635763f, -0.01392156f, 0.02057441f, -0.09559914f, 0.03977012f, 
    0.02500533f, -0.03224070f, -0.13553873f, -0.06118915f, -0.06898708f, 0.00875496f, -0.05651332f, 0.00910854f, 
    -0.06049668f, -0.06614499f, 0.01060763f, -0.18117473f, 0.07927787f, -0.48163304f, 0.01391408f, 0.22382359f, 
    0.00804064f, -0.05344469f, 0.11562306f, 0.14897105f, -0.02009358f, 0.10637143f, -0.07961976f, 0.24474274f, 
    0.15523158f, 0.09087548f, -0.03467810f, 0.10399156f, -0.01312125f, 0.07496382f, 0.13722138f, 0.09933315f, 
    -0.11495461f, -0.14300910f, 0.05147374f, -0.06817275f, 0.21880327f, 0.21062872f, -0.01413547f, 0.22523947f, 
    0.30123231f, 0.31502616f, 0.04853087f, -0.27711114f, 0.08519193f, 0.06949735f, 0.30349547f, 0.04968660f, 
    -0.14819366f, -0.07537545f, 0.08588874f, 0.01534639f, -0.02451134f, 0.00742382f, -0.24954113f, -0.20297700f, 
    0.09702011f, -0.19024874f, 0.10351850f, -0.11495089f, 0.06961557f, 0.09447763f, 0.11315340f, 0.27055806f, 
    0.19914685f, -0.04616095f, 0.26483485f, -0.04226680f, 0.20668234f, 0.26172873f, -0.34632927f, 0.10334911f, 
    0.25951949f, 0.06016158f, -0.00725792f, -0.07666348f, 0.03991563f, -0.04039018f, 0.43563551f, -0.07802764f, 
    -0.27399552f, -0.15022948f, 0.14310281f, -0.05436559f, -0.04255520f, 0.02888394f, -0.06369895f, -0.35923427f, 
    -0.09942573f, -0.09042281f, -0.09087467f, 0.16354688f, 0.08312315f, -0.01427699f, 0.17847449f, 0.01680600f, 
    0.11097039f, 0.06470535f, -0.05302618f, 0.19684812f, 0.18704547f, 0.01131407f, -0.09048543f, 0.29150763f, 
    0.07067288f, 0.09193726f, -0.23101108f, -0.31051141f, -0.19232687f, 0.24712035f, 0.59102464f, -0.17935672f, 
    0.13621674f, 0.10525320f, 0.09992523f, 0.13321321f, 0.01085068f, -0.02223111f, -0.10075038f, -0.28695863f, 
    0.03098519f, 0.06771109f, 0.12977278f, -0.04184835f, -0.12967995f, -0.02381795f, -0.04660833f, -0.05698774f, 
    -0.30450049f, -0.08341259f, 0.03420870f, 0.26353329f, 0.02015432f, 0.46575072f, 0.20143208f, -0.04929040f, 
    -0.09316351f, -0.05629984f, 0.05914162f, -0.07527236f, -0.07375161f, -0.03694645f, -0.08305772f, 0.02197594f, 
    0.01694098f, 0.03012561f, -0.02167622f, 0.01532077f, -0.03664088f, -0.08174722f, -0.01098948f, -0.04352637f, 
    0.01706333f, -0.04082949f, -0.03277845f, -0.04481347f, -0.00102796f, -0.02063102f, -0.10076029f, 0.00915087f, 
    -0.10304679f, 0.03811276f, -0.07833409f, -0.10139957f, -0.09532114f, -0.05224091f, -0.01916557f, 0.04977910f, 
    -0.03047185f, 0.03844280f, -0.00968899f, 0.03616168f, -0.03597315f, -0.10438921f, -0.08981784f, -0.03326949f, 
    -0.01287385f, -0.05164811f, 0.06287669f, -0.05742705f, -0.08393148f, -0.07685884f, -0.04370449f, 0.06491374f, 
    0.04862065f, -0.05584110f, 0.02899929f, 0.03269322f, 0.06131415f, -0.04954626f, -0.09398114f, -0.03459429f, 
    0.00277549f, -0.08832856f, -0.05874056f, -0.00462145f, -0.07841988f, 0.01645453f, 0.05124888f, -0.05438982f, 
    -0.07384981f, -0.04337245f, -0.06477264f, -0.03034507f, -0.03088140f, -0.01733060f, 0.05218178f, -0.00530351f, 
    -0.04245788f, 0.02022007f, -0.07253814f, 0.06467494f, -0.01072490f, 0.04498506f, -0.06117508f, -0.02245944f, 
    0.04183492f, -0.08199923f, -0.00211672f, 0.01078418f, 0.03772322f, -0.04888005f, 0.06275181f, -0.00202583f, 
    0.01528825f, -0.06248739f, 0.06738999f, 0.07580385f, 0.01725792f, 0.07512149f, -0.00197812f, -0.02288506f, 
    0.02582275f, 0.00864765f, 0.00173388f, 0.07230135f, -0.03155950f, -0.08215552f, 0.01220387f, 0.02387480f, 
    -0.08562862f, -0.00401876f, -0.03712209f, 0.03868748f, 0.07654412f, -0.05116478f, 0.05636103f, 0.02918544f, 
    -0.08304247f, -0.02956964f, -0.04732156f, 0.04916842f, -0.02834501f, -0.06381822f, 0.01821003f, 0.00327192f, 
    0.01440576f, 0.02903268f, -0.06483701f, 0.02518112f, -0.00025885f, -0.03715542f, 0.02487022f, -0.04212873f, 
    0.18154877f, -0.12643816f, -0.30903223f, -0.00282141f, 0.04913646f, -0.30671540f, 0.35663086f, 0.32748970f, 
    0.61469233f, -0.09277140f, 0.19837774f, 0.21496470f, -0.21228248f, 0.05291458f, -0.55519897f, 0.46069849f, 
    -0.19910605f, 0.12649760f, 0.08022149f, -0.03104754f, -0.00616459f, -0.38185719f, -0.47103465f, 0.12119286f, 
    0.24435802f, 0.18582684f, -0.07269511f, 0.18473694f, -0.12288408f, 0.10869064f, 0.04439595f, -0.21313991f, 
    0.01295810f, -0.06544313f, 0.21716911f, -0.44349581f, -0.05172034f, -0.39372042f, 0.01484636f, -0.21208179f, 
    0.01702528f, 0.02435192f, -0.62397277f, -0.04229130f, 0.06349993f, 0.01718320f, 0.11225319f, -0.65965122f, 
    -0.37099093f, -0.06254286f, -0.21134336f, 0.01919656f, -0.35053593f, 0.09743600f, 0.14108944f, 0.00459945f, 
    -0.13681588f, 0.11372212f, 0.46604109f, 0.35535392f, -0.16798951f, 0.34583932f, -0.02013270f, -0.15196273f, 
    0.18708847f, 0.18084294f, -0.20222420f, -0.37126461f, 0.08295947f, 0.08121102f, 0.55025375f, -0.03004759f, 
    0.08499976f, 0.01929154f, 0.10152628f, 0.33417276f, -0.00544786f, 0.22975349f, 0.08513626f, 0.12316088f, 
    0.15728721f, 0.10180841f, -0.04369779f, -0.12404280f, -0.21986024f, -0.68528920f, -0.37451193f, 0.20250002f, 
    0.01449521f, 0.04809504f, 0.24697831f, -0.51229680f, 0.24063544f, 0.03630175f, 0.11993484f, 0.30274656f, 
    0.26334801f, 0.17899589f, 0.15417372f, 0.20375119f, 0.05379916f, 0.19994919f, 0.10315656f, -0.35163563f, 
    0.29858935f, 0.39920312f, -0.37653980f, 0.19152005f, 0.20563692f, -0.14379710f, 0.25131616f, -0.14660065f, 
    0.24986358f, -0.20555566f, -0.38013062f, -0.05721314f, 0.14351119f, -0.57706004f, -0.09560023f, 0.17591932f, 
    -0.44422600f, -0.06334639f, 0.09773283f, -0.38281840f, -0.05650200f, -0.46462283f, 0.31191450f, 0.09994907f, 
    0.08699176f, -0.02186193f, 0.23749207f, 0.24153776f, 0.20916000f, -0.26097065f, 0.05992009f, 0.09468427f, 
    -0.38358483f, 0.15074256f, -0.35232654f, 0.15099983f, 0.11364149f, -0.09539536f, -0.04781669f, -0.59168988f, 
    -0.27037644f, -0.03987868f, 0.15388188f, 0.22408152f, -0.00301152f, -0.02375050f, -0.26370135f, 0.26033404f, 
    -0.22692235f, 0.28062642f, 0.08067212f, 0.29984632f, 0.18961252f, -0.30923507f, 0.16819985f, -0.20088920f, 
    0.04438918f, -0.11048894f, 0.03908022f, -0.39545637f, 0.05966442f, -0.04344518f, 0.27977690f, 0.06241008f, 
    -0.06328305f, 0.05863909f, 0.31783050f, 0.04564383f, 0.05624669f, 0.02218427f, 0.20541301f, -0.54964042f, 
    -0.01315377f, -0.00060977f, -0.00264549f, 0.17991905f, -0.34408230f, 0.13710624f, -0.20749569f, -0.08853806f, 
    0.00009888f, 0.35871542f, -0.20426886f, 0.18457505f, -0.22635841f, 0.13605534f, -0.01640782f, -0.16125417f, 
    -0.01868954f, 0.24209642f, -0.19626427f, -0.21265893f, 0.03146340f, 0.07843810f, 0.05506824f, 0.08003378f, 
    -0.00130801f, -0.14468636f, -0.11795460f, 0.21128970f, 0.09198254f, 0.20488010f, 0.14998728f, 0.15154848f, 
    -0.19790247f, 0.57483476f, -0.19100977f, -0.21065047f, 0.05324766f, -0.20413658f, -0.27768365f, 0.10810484f, 
    0.01529124f, -0.15221047f, 0.14418398f, -0.38824904f, 0.01571388f, -0.11807406f, 0.16021657f, -0.14899963f, 
    0.10722668f, 0.13663462f, -0.14317068f, -0.01134198f, 0.22111364f, -0.05325723f, -0.18365055f, -0.25579080f, 
    0.19015485f, 0.17203051f, -0.10819394f, -0.47248402f, -0.12757577f, -0.07028314f, 0.07621938f, 0.08257653f, 
    -0.05974809f, -0.14611490f, -0.10874971f, -0.02156534f, 0.04642754f, 0.00479056f, -0.04200713f, -0.16150670f, 
    -0.34301063f, 0.04588678f, 0.05395614f, -0.03025646f, 0.12579036f, 0.06098862f, 0.02190874f, 0.16223674f, 
    -0.09167661f, 0.40088916f, 0.05009682f, -0.00624468f, 0.06490048f, 0.30332762f, -0.07729904f, -0.00194785f, 
    -0.21767069f, 0.14583705f, -0.18578009f, 0.04001314f, 0.10395303f, -0.05265978f, 0.21309608f, 0.31554475f, 
    0.63754857f, -0.18592972f, -0.19745751f, -0.20060505f, 0.33837247f, 0.13456164f, -0.17208612f, -0.02714141f, 
    -0.13914067f, -0.04391610f, -0.05050845f, -0.13193363f, 0.34415376f, 0.22390658f, 0.44970119f, -0.01922161f, 
    0.28301659f, -0.11191322f, -0.32705876f, 0.07089932f, -0.06795535f, 0.09774904f, 0.34218284f, -0.05655540f, 
    0.41405731f, -0.05983764f, 0.15870969f, -0.05265760f, -0.06491068f, 0.05342415f, 0.24967790f, -0.30619419f, 
    0.16070080f, -0.05007485f, 0.18970178f, 0.13128750f, -0.26826632f, -0.58405596f, -0.32215106f, -0.42817804f, 
    -0.53415823f, 0.18065821f, -0.02938647f, -0.23683871f, -0.29064336f, 0.09976334f, -0.23593561f, 0.31037045f, 
    -0.19626284f, -0.23154080f, -0.02251592f, -0.00628949f, -0.12381835f, -0.07992756f, -0.02102938f, 0.23177284f, 
    -0.32913104f, -0.16744994f, 0.13613467f, -0.16783278f, -0.09445442f, -0.09191547f, 0.07173105f, -0.02998030f, 
    0.27387539f, -0.28283548f, 0.01672343f, -0.05730268f, 0.06577389f, -0.04242230f, 0.47470888f, -0.06955925f, 
    0.05012395f, -0.18709065f, -0.59721845f, 0.39442599f, -0.56322813f, 0.19555920f, 0.16558783f, -0.45412409f, 
    -0.25795773f, 0.09153525f, 0.25126135f, -0.59112102f, -0.04089484f, -0.38035169f, 0.10364606f, 0.15676644f, 
    0.10761330f, -0.28580466f, -0.09721754f, -0.11825880f, -0.19162296f, 0.19837803f, -0.37840417f, 0.34157559f, 
    -0.27726287f, -0.18146923f, 0.05894501f, 0.00401841f, 0.13010277f, 0.16188732f, -0.21249522f, 0.37143421f, 
    0.46951535f, -0.43779352f, -0.09301239f, -0.03468408f, 0.09818084f, -0.01123025f, -0.69047982f, 0.29472324f, 
    -0.06922422f, 0.12127069f, -0.22724245f, 0.09136967f, -0.12500189f, 0.43321618f, 0.16251816f, 0.23202871f, 
    0.34203359f, 0.10712875f, 0.38589874f, 0.11442786f, -0.12318894f, 0.08995783f, -0.04389212f, 0.21184796f, 
    -0.40374005f, 0.18727669f, -0.06202427f, -0.14546084f, 0.01640443f, -0.10031158f, 0.05372903f, -0.10989009f, 
    0.18314846f, 0.15964346f, 0.05052311f, 0.12303720f, -0.60084981f, 0.14356185f, -0.09711432f, 0.37372002f, 
    -0.12860325f, 0.01637209f, -0.33304217f, 0.35395128f, 0.05077367f, 0.19852401f, -0.28264967f, 0.02302153f, 
    0.12483355f, 0.00948634f, 0.04657858f, 0.09737477f, 0.00043231f, 0.05091270f, 0.23522268f, 0.35773787f, 
    0.10473821f, 0.15581521f, -0.34436008f, -0.00588531f, -0.06241477f, -0.08379561f, 0.19751774f, -0.26013339f, 
    -0.30293080f, 0.02463758f, 0.20679805f, 0.00340459f, 0.05881552f, -0.33394256f, 0.27014297f, 0.16202506f, 
    0.20089774f, -0.00048493f, 0.01013050f, -0.06943151f, -0.09659639f, 0.08218946f, -0.33789116f, 0.14510731f, 
    0.08377255f, 0.09433033f, -0.15546833f, 0.02599712f, 0.00404685f, 0.21923167f, -0.06751990f, -0.02735878f, 
    0.09234819f, 0.06252140f, 0.18111585f, 0.03407051f, -0.13554953f, -0.07036147f, 0.30035856f, -0.34431541f, 
    0.17282294f, 0.04870481f, 0.20688553f, 0.09467930f, -0.23425676f, 0.20382817f, 0.15734920f, -0.57435501f, 
    -0.05172849f, -0.09358712f, 0.14695117f, 0.48627451f, -0.12393576f, 0.09306128f, -0.20568991f, 0.16305432f, 
    0.05334408f, 0.08217734f, -0.07279283f, 0.22435775f, 0.21598750f, -0.04396286f, 0.09186083f, 0.11990964f, 
    -0.11960624f, 0.06036115f, 0.16035354f, 0.02557783f, 0.18003169f, -0.16275796f, 0.14451532f, 0.30029249f, 
    0.89672148f, 0.24261934f, 0.23535417f, -0.28365269f, -0.07973786f, 0.09289339f, -0.36987588f, -0.06878544f, 
    -0.03516396f, 0.03101190f, -0.02804685f, 0.02125625f, -0.04570064f, -0.01983181f, -0.00633394f, -0.02105579f, 
    0.04100186f, 0.01710063f, 0.05054932f, -0.09484711f, 0.00575657f, -0.02954379f, 0.05457522f, -0.00248991f, 
    0.03822245f, 0.05924683f, -0.07217038f, -0.05157444f, 0.01057059f, 0.06091293f, -0.01075757f, -0.07458096f, 
    0.01115530f, -0.07196475f, 0.02301544f, -0.09901419f, -0.07093600f, 0.08389115f, -0.00551720f, -0.06377376f, 
    -0.02721973f, -0.06914749f, 0.02112810f, -0.07182381f, -0.06438418f, -0.06165156f, -0.01196902f, 0.00439210f, 
    -0.00169962f, -0.07585674f, -0.01231903f, -0.00776906f, -0.03151296f, -0.07939437f, 0.04598212f, 0.06928399f, 
    -0.00233446f, -0.03988443f, -0.05292957f, -0.03926259f, 0.06277462f, -0.05949662f, -0.06351199f, -0.10265569f, 
    0.02397472f, -0.08396608f, -0.08657943f, -0.05618833f, -0.02643893f, -0.04661865f, 0.00333527f, 0.04205635f, 
    -0.09896066f, -0.08235121f, 0.02052249f, 0.00306257f, -0.08693689f, -0.02593928f, 0.07912827f, 0.01346323f, 
    0.01264392f, 0.02042651f, -0.03096647f, 0.06039745f, -0.00909808f, -0.05888837f, -0.12824777f, -0.07259544f, 
    -0.05624445f, -0.05595579f, -0.03278384f, -0.07375614f, 0.03695621f, -0.06450737f, 0.08810831f, 0.05735363f, 
    -0.05973471f, -0.01117463f, 0.03477730f, -0.03135435f, -0.02374821f, 0.01241667f, 0.03590190f, -0.02274689f, 
    -0.05761687f, -0.06466169f, -0.03430928f, -0.06681810f, -0.04373370f, -0.00448093f, 0.08994117f, 0.05114249f, 
    -0.07670294f, -0.07672419f, -0.04883917f, -0.02294914f, -0.03711117f, -0.09500720f, -0.04179513f, -0.05457098f, 
    -0.09355135f, -0.02259580f, -0.02108999f, 0.03489518f, 0.03155281f, 0.05861670f, -0.09078940f, 0.01395123f, 
    -0.04772390f, -0.05276471f, 0.03835739f, 0.01693475f, -0.09807104f, -0.09449812f, -0.01896435f, 0.03992698f, 
    -0.05605048f, 0.07469567f, 0.06675503f, -0.24274856f, -0.08219174f, 0.26195663f, -0.01959710f, 0.19514422f, 
    0.44854626f, -0.21841553f, 0.11923799f, -0.21664450f, 0.19368009f, 0.19044185f, 0.11313581f, 0.07958551f, 
    -0.45932758f, 0.13689123f, 0.19278944f, 0.18937294f, 0.45283377f, 0.40683776f, 0.17729358f, 0.15549129f, 
    0.21394660f, -0.25574514f, -0.18986629f, -0.38327107f, -0.18707427f, 0.30231798f, -0.38480026f, 0.45771599f, 
    0.23212519f, 0.40485728f, 0.21518366f, 0.09521154f, -0.06066059f, -0.17543663f, -0.18344222f, -0.01446204f, 
    -0.03293794f, -0.07548849f, -0.05643965f, -0.07015535f, 0.04095565f, -0.07199392f, -0.26318023f, 0.15577935f, 
    0.07692445f, -0.06993627f, -0.04858533f, -0.39791715f, -0.07111507f, -0.01864838f, -0.33575210f, 0.13531578f, 
    0.12039930f, -0.54935354f, 0.48793700f, 0.13550539f, 0.02075267f, 0.20235065f, 0.04643083f, 0.10367009f, 
    0.25341687f, 0.07317469f, 0.00745872f, 0.27259165f, 0.17444538f, -0.12361389f, -0.07383447f, -0.11865144f, 
    -0.01798851f, 0.08621979f, 0.27452290f, 0.18908887f, 0.01032333f, -0.03685771f, -0.53403765f, -0.09835222f, 
    -0.16025375f, -0.31419268f, 0.22902642f, -0.04230496f, 0.06097583f, 0.14654648f, 0.30430037f, 0.00185045f, 
    -0.07606893f, -0.06704839f, -0.11282177f, 0.24270968f, 0.30795300f, 0.13232072f, 0.08304825f, -0.07477264f, 
    0.31911993f, -0.01083204f, -0.10352832f, -0.22067161f, -0.06830209f, 0.17257637f, -0.31909165f, 0.11404280f, 
    0.14228572f, 0.13830093f, 0.09293641f, 0.48516476f, -0.02560528f, 0.14575255f, -0.00303812f, 0.09129336f, 
    -0.07275885f, 0.17750467f, -0.02062486f, 0.04035327f, -0.13784355f, -0.00882554f, 0.20264256f, -0.04652520f, 
    0.65037495f, -0.22325462f, -0.42756310f, 0.06986562f, 0.13051404f, -0.20011555f, 0.18460694f, -0.31824639f, 
    -0.03995217f, 0.05676209f, -0.08487595f, -0.00693548f, -0.05837858f, -0.04913298f, -0.08204339f, 0.01320356f, 
    0.03416011f, 0.03272485f, 0.05798699f, -0.09721308f, -0.06279732f, -0.06186616f, 0.04027626f, -0.08471096f, 
    0.02648256f, 0.04399991f, 0.02314721f, -0.11759347f, 0.06154195f, 0.00197275f, 0.03337445f, -0.00660961f, 
    0.06699188f, -0.09718432f, -0.06905305f, -0.11191569f, -0.13600710f, 0.04231485f, -0.08982501f, -0.10771510f, 
    -0.00525667f, 0.03444941f, 0.04139026f, 0.03083733f, 0.06658475f, -0.07742210f, -0.12859257f, -0.01713667f, 
    0.02293615f, 0.02147094f, 0.03281138f, 0.04203491f, 0.04027475f, 0.05508601f, -0.08833195f, 0.01400390f, 
    -0.00746357f, 0.04484314f, 0.04790228f, 0.00054279f, 0.02425077f, -0.03327743f, -0.03004644f, 0.03895609f, 
    0.04644134f, -0.06212632f, -0.04608988f, 0.02996017f, -0.04581476f, -0.03251598f, 0.02544299f, -0.09352273f, 
    -0.01321969f, -0.08107146f, -0.10458588f, -0.09474877f, -0.00003422f, 0.01165019f, -0.00394476f, -0.13165475f, 
    -0.02453923f, -0.06950251f, 0.03530519f, -0.01423919f, -0.02508140f, 0.06108610f, -0.10469316f, -0.01829314f, 
    0.01481775f, -0.00004787f, -0.06997421f, -0.04661545f, -0.05257430f, -0.06964196f, -0.08166860f, 0.07101754f, 
    -0.07312254f, -0.00626500f, -0.06010435f, 0.02567328f, -0.10846248f, -0.07904912f, 0.01344474f, 0.06689891f, 
    0.02283660f, 0.02662463f, 0.00365299f, -0.03932681f, -0.00437455f, -0.05974719f, 0.00157913f, 0.02149850f, 
    -0.04679526f, 0.04726597f, -0.05187705f, -0.01822024f, -0.05476666f, -0.03762164f, -0.02499043f, 0.00066956f, 
    0.02419144f, 0.00025681f, -0.08682881f, -0.05721477f, -0.08606867f, 0.05875866f, -0.07521152f, -0.10822445f, 
    -0.08737910f, -0.09844045f, 0.04630951f, -0.09999385f, -0.06083270f, 0.02613378f, -0.03097138f, -0.00501932f, 
    -0.14889094f, -0.34791651f, -0.06934427f, -0.01286439f, 0.06821791f, -0.21697710f, 0.15644717f, -0.12250416f, 
    0.46996632f, -0.20478407f, 0.09536409f, -0.32548437f, 0.17373611f, 0.09068143f, -0.04159844f, -0.42197046f, 
    0.28866446f, 0.10363789f, 0.19400522f, 0.01238952f, 0.23997575f, 0.08367810f, 0.13791463f, 0.24265204f, 
    -0.21881621f, 0.01590625f, -0.05633354f, 0.15789206f, 0.37361023f, -0.24453811f, -0.01970492f, -0.16824105f, 
    -0.10285399f, 0.15508765f, 0.33006537f, 0.24656196f, 0.13571675f, -0.10006257f, -0.32686248f, 0.07932514f, 
    -0.36622250f, 0.04470001f, -0.26681632f, 0.05434847f, -0.04770475f, -0.05627750f, -0.09603471f, -0.08791564f, 
    -0.11163007f, -0.05022607f, -0.22681080f, -0.20656042f, -0.01253364f, 0.03975335f, 0.15083030f, 0.11578573f, 
    -0.02877050f, -0.00810554f, -0.01199718f, 0.20724839f, 0.19990516f, 0.31274736f, 0.04076045f, -0.04749084f, 
    0.10651735f, 0.24870770f, -0.02233902f, -0.01275536f, 0.20138708f, 0.04171593f, 0.67547202f, -0.13504682f, 
    -0.06382994f, 0.15930380f, -0.25182149f, 0.23741838f, 0.12160625f, 0.05002808f, -0.19142689f, -0.18666257f, 
    -0.02443575f, 0.15012637f, -0.25181958f, -0.10267901f, -0.12630527f, -0.04452729f, -0.48339221f, -0.04686909f, 
    0.02232239f, 0.08450147f, 0.27525660f, -0.40624097f, 0.31117895f, 0.16138558f, -0.06098732f, 0.39309675f, 
    0.09078451f, -0.20542710f, 0.10323951f, -0.16890614f, 0.23344289f, 0.18345706f, 0.04831800f, -0.12355785f, 
    0.03367083f, 0.28022730f, -0.06327744f, 0.15909870f, 0.02142314f, -0.00984899f, -0.02280053f, -0.16069368f, 
    0.58215243f, 0.10953083f, 0.21971858f, -0.02637777f, -0.08942814f, 0.01005118f, -0.12478981f, -0.28077048f, 
    -0.22683349f, 0.26934057f, -0.24455270f, 0.03483328f, 0.05861351f, -0.14671443f, 0.44299427f, -0.15390255f, 
    0.07724388f, -0.01150892f, 0.03597866f, -0.00806274f, -0.05648673f, -0.05193532f, -0.07192711f, -0.11604274f, 
    0.04534739f, -0.03067704f, -0.04396324f, -0.11028160f, -0.00211907f, -0.06628606f, -0.00968080f, -0.12252207f, 
    0.11627005f, -0.02799691f, -0.01631734f, -0.01241170f, -0.11228094f, -0.00560629f, -0.09084164f, -0.00973772f, 
    0.01798606f, -0.12125075f, -0.05388771f, -0.16108029f, 0.08465207f, -0.04185095f, 0.19502887f, -0.01150449f, 
    -0.09415234f, -0.11934432f, -0.09350787f, -0.05405474f, 0.01979184f, -0.07454544f, 0.03967424f, -0.07351100f, 
    -0.05050527f, 0.01886260f, -0.02758406f, -0.03472700f, -0.03774914f, -0.02347309f, -0.05374555f, 0.11360279f, 
    -0.04022302f, -0.04039621f, -0.08129887f, -0.05890043f, 0.01709271f, -0.07025103f, -0.04879105f, -0.03619152f, 
    -0.06789181f, -0.00798023f, -0.19054079f, -0.07885899f, -0.13264912f, 0.07567175f, -0.06699819f, -0.04779282f, 
    -0.08589789f, -0.03832477f, -0.15307508f, -0.11092602f, -0.01176905f, -0.02126491f, 0.00167640f, -0.16627057f, 
    -0.01190692f, -0.17709151f, 0.07160050f, -0.09641812f, -0.06681453f, 0.00293414f, -0.00320425f, -0.08603769f, 
    -0.14097567f, -0.09675012f, -0.01604006f, -0.00513354f, 0.01017299f, 0.04816852f, 0.05302671f, -0.04117171f, 
    -0.05029193f, -0.07456352f, -0.13291334f, 0.12078617f, -0.16187946f, -0.12563373f, 0.01818485f, 0.01668945f, 
    -0.11325329f, -0.11999689f, -0.07564938f, -0.05607936f, -0.11472479f, -0.02467242f, -0.03261255f, -0.11403132f, 
    -0.08353843f, -0.10682872f, 0.00683202f, -0.16382070f, -0.05772889f, -0.06786472f, -0.09123258f, 0.06433196f, 
    0.01502193f, 0.02665276f, 0.01436346f, -0.07796978f, -0.11429656f, 0.03830983f, 0.03466381f, -0.09259798f, 
    -0.06553926f, -0.06432254f, -0.02187417f, -0.04863160f, 0.00211795f, 0.08747585f, -0.04174624f, 0.04221981f, 
    -0.05825891f, -0.07535182f, -0.06553665f, -0.05426233f, -0.01395775f, 0.06507131f, 0.02424500f, 0.04291148f, 
    -0.04503606f, -0.06349649f, 0.00862959f, 0.02777695f, -0.02676857f, -0.01087448f, -0.03223507f, -0.03752569f, 
    0.05945998f, -0.04021858f, -0.04437630f, -0.05222826f, 0.00142569f, -0.05441710f, -0.06414722f, 0.01842529f, 
    -0.04849905f, -0.04726384f, -0.09239369f, -0.03522214f, 0.00146827f, -0.03140381f, 0.04134076f, 0.02819001f, 
    -0.06610202f, 0.06757590f, -0.03079871f, 0.04586828f, 0.05258416f, -0.06993787f, 0.08007968f, -0.02440471f, 
    -0.08217917f, -0.03999545f, 0.00377431f, 0.05434909f, 0.08544585f, 0.02515751f, -0.10685675f, -0.09474392f, 
    -0.02089949f, -0.03701993f, -0.05452910f, -0.01334157f, -0.00464847f, 0.01568543f, 0.04628719f, -0.06250215f, 
    0.03124125f, 0.00448522f, 0.01273508f, -0.08243217f, 0.05303494f, -0.05979980f, -0.04387246f, 0.04855777f, 
    -0.03346122f, -0.07301170f, 0.01549065f, -0.07515921f, 0.06002735f, -0.09263560f, 0.00109533f, 0.03250643f, 
    -0.09000015f, -0.08002520f, 0.03724699f, 0.06572511f, 0.05842560f, 0.05885247f, 0.04422600f, 0.00179854f, 
    -0.08015467f, 0.00309853f, 0.00348979f, 0.01500300f, 0.05432417f, 0.06615669f, -0.06809971f, -0.07649004f, 
    0.03667676f, 0.04009302f, -0.05580720f, -0.07736623f, 0.02749457f, -0.09052533f, 0.03856742f, -0.06083580f, 
    0.07078841f, 0.07681560f, 0.06173775f, 0.03203136f, -0.06442600f, 0.00316541f, -0.02288646f, -0.01564780f, 
    -0.08096916f, 0.04503706f, -0.01576538f, 0.03844153f, -0.03595060f, -0.06480014f, -0.05741968f, -0.06399954f, 
    -0.02950407f, -0.04359566f, 0.05224770f, -0.01338006f, 0.00069727f, -0.05238299f, -0.06114947f, -0.08795846f, 
    0.04946195f, -0.03415805f, -0.05907091f, 0.02676768f, -0.05042058f, -0.04707256f, 0.02821273f, 0.00046415f, 
    -0.02842751f, -0.10300262f, 0.00218669f, -0.05104125f, -0.01236507f, -0.29170963f, 0.04529318f, 0.04974248f, 
    0.00329919f, -0.08272746f, -0.19985381f, -0.11236599f, -0.05965630f, 0.11357389f, 0.00490112f, -0.46046582f, 
    -0.07768735f, 0.01018746f, 0.09752913f, 0.20659246f, -0.02583400f, 0.14367615f, -0.00131902f, 0.25759363f, 
    -0.42058370f, -0.28575921f, -0.14023057f, -0.08456761f, 0.35867006f, 0.13424286f, 0.11046800f, 0.07876289f, 
    0.31549117f, 0.21841469f, 0.46083754f, -0.04937667f, 0.10372498f, -0.18391751f, 0.29223958f, 0.07114231f, 
    0.10190185f, 0.04619190f, 0.04806954f, 0.04450394f, 0.11107498f, -0.00138454f, -0.24781363f, -0.41983205f, 
    -0.09554578f, 0.08141025f, -0.27662230f, -0.02114640f, -0.14860883f, -0.05405137f, -0.01561802f, -0.08719584f, 
    -0.03825351f, 0.07684419f, 0.22468983f, 0.13098888f, 0.12672004f, 0.38707346f, -0.05298418f, -0.08580277f, 
    0.21337503f, 0.31549859f, -0.05950988f, 0.11656643f, -0.01937320f, -0.00381410f, 0.39537960f, -0.09266312f, 
    0.02324419f, 0.11838153f, 0.05796758f, 0.00389509f, 0.08548626f, 0.11272362f, 0.10007539f, -0.09299941f, 
    0.06071663f, -0.03431406f, -0.07808945f, -0.03813967f, 0.06416661f, 0.07812419f, -0.25659320f, -0.09041988f, 
    -0.10793989f, -0.08028273f, 0.13807525f, 0.08336878f, 0.29511175f, 0.11619280f, 0.01358903f, 0.25375178f, 
    0.09949306f, -0.07688475f, -0.05551422f, -0.37141696f, 0.36625969f, 0.31007791f, 0.14989108f, 0.06416012f, 
    0.04081033f, 0.02529722f, -0.03756737f, -0.00351237f, -0.00549937f, 0.13324220f, -0.02600876f, -0.00275347f, 
    0.12684800f, -0.01314017f, 0.02241710f, -0.05787103f, -0.12298267f, -0.04248619f, 0.01680605f, -0.05272326f, 
    -0.80075383f, 0.13235864f, -0.24361305f, 0.21707922f, 0.22142220f, 0.24176995f, 0.46188307f, 0.07838355f, 
    -0.31032032f, 0.00363183f, -0.01422732f, 0.12331128f, 0.22023323f, -0.21914808f, -0.17395276f, -0.51118511f, 
    -0.06205606f, 0.01867108f, -0.19015054f, 0.00756623f, 0.29268056f, 0.04966472f, 0.23960482f, -0.10062549f, 
    -0.26692128f, -0.34919143f, -0.00356855f, 0.13600798f, 0.03522839f, -0.07770836f, 0.12307313f, -0.07807161f, 
    -0.06222632f, 0.06424311f, -0.13132626f, 0.23913209f, 0.15998909f, -0.37191510f, 0.13276494f, 0.15537456f, 
    0.11452093f, -0.18631266f, 0.16363154f, 0.37983894f, 0.06060129f, 0.07785313f, -0.43553728f, 0.14377551f, 
    0.09932087f, 0.06410421f, -0.33772811f, -0.16174170f, 0.05012177f, 0.00706366f, -0.04314942f, 0.09124463f, 
    0.02605200f, 0.29498047f, -0.12520511f, -0.02851837f, -0.00417879f, -0.04235245f, 0.22253975f, 0.13796441f, 
    -0.05409928f, 0.13495138f, 0.14870305f, -0.01760197f, -0.06779443f, -0.08411898f, 0.21670850f, -0.02775025f, 
    -0.00382501f, -0.14514478f, 0.18678994f, 0.31367493f, -0.09607323f, 0.07475016f, -0.08809432f, 0.23347566f, 
    0.04423194f, 0.42681876f, 0.03662130f, -0.32510829f, 0.19098343f, -0.14701633f, 0.13794634f, 0.05895757f, 
    0.25224715f, -0.08439393f, 0.00386468f, 0.19162524f, -0.05447007f, 0.19888489f, 0.17552045f, 0.14437093f, 
    -0.18558554f, 0.14061515f, 0.13331735f, -0.14929000f, -0.00638688f, 0.09172086f, 0.02110252f, -0.28797805f, 
    -0.02278029f, 0.05272820f, 0.45300558f, 0.31272563f, 0.15394874f, 0.10380489f, -0.30533755f, 0.27375099f, 
    -0.48432118f, -0.52188957f, 0.13861939f, 0.15128164f, -0.00003449f, 0.20471708f, 0.07631039f, 0.25695416f, 
    0.02405348f, -0.22767365f, 0.03259552f, -0.02589126f, 0.02238110f, 0.20723014f, -0.10098862f, 0.26941040f, 
    0.01351492f, 0.15873089f, -0.19404773f, -0.22255875f, 0.10198620f, -0.47318155f, -0.03119464f, 0.23165819f, 
    0.01151748f, -0.00041116f, -0.05001154f, -0.01545322f, -0.08109090f, -0.04007054f, -0.07331971f, -0.01176386f, 
    -0.00647166f, -0.01070520f, -0.05671438f, -0.05684948f, 0.03249909f, -0.03576493f, -0.03951557f, 0.00841056f, 
    -0.01215665f, -0.01067274f, 0.02276557f, 0.05329672f, -0.05535639f, 0.05941271f, -0.03948912f, 0.00106613f, 
    0.06797442f, -0.00066084f, 0.04084018f, -0.05107515f, -0.00131409f, 0.02504539f, 0.04645982f, -0.01451510f, 
    -0.04085028f, -0.03723504f, 0.04032215f, -0.00099729f, -0.08204196f, -0.06783915f, 0.04561481f, 0.05776089f, 
    0.01993895f, -0.00532129f, 0.03468165f, 0.00921206f, 0.08318689f, -0.00338052f, -0.07756630f, 0.00928782f, 
    -0.04789988f, -0.08841334f, 0.06780177f, 0.00852005f, -0.08008237f, -0.02767060f, 0.00371523f, 0.00798128f, 
    -0.08594831f, 0.03475438f, 0.01135060f, -0.05890637f, -0.08869927f, -0.00287056f, -0.07231416f, 0.04351982f, 
    0.06844537f, 0.05994936f, -0.04338383f, -0.00297020f, -0.08448917f, 0.00008313f, -0.06713250f, 0.06203099f, 
    -0.05788727f, 0.08382474f, 0.04950497f, -0.01332252f, 0.04003482f, -0.09105650f, -0.08574091f, 0.07694729f, 
    0.04569746f, -0.03856770f, -0.04639516f, 0.03786774f, -0.03215173f, 0.03349084f, -0.03244178f, -0.03041185f, 
    0.07064874f, -0.01011660f, 0.07574774f, 0.06316386f, -0.08785038f, -0.09172433f, -0.07988670f, 0.03910149f, 
    0.02054394f, 0.05108109f, 0.06584207f, 0.00515779f, -0.03394299f, -0.05833704f, 0.07119023f, 0.06201592f, 
    -0.02522116f, 0.04399538f, -0.09099218f, 0.02535699f, 0.03924597f, -0.06844301f, -0.04726765f, -0.05749613f, 
    -0.06846178f, -0.06637693f, -0.04615181f, -0.01984160f, -0.08350760f, -0.09287541f, -0.09236257f, 0.03957754f, 
    0.06833265f, -0.01962500f, -0.07740959f, 0.06887063f, -0.01264156f, 0.06041843f, -0.00290114f, -0.01648028f, 
    -0.01631919f, -0.09910903f, 0.05721680f, -0.03010912f, 0.03799520f, -0.06521200f, 0.06261298f, -0.09017963f, 
    0.04494153f, 0.00880714f, -0.09421880f, -0.09112426f, -0.03547426f, -0.05548840f, -0.08332995f, -0.00215039f, 
    -0.02536934f, -0.00620065f, -0.05908412f, -0.05406874f, -0.02937377f, 0.00091930f, -0.04141298f, -0.01845425f, 
    0.01250727f, 0.04061057f, -0.12942564f, -0.06609228f, -0.10873485f, 0.04164813f, -0.04427030f, 0.00527646f, 
    -0.12087486f, 0.03154330f, 0.01998607f, -0.06145158f, 0.01301871f, 0.00691812f, -0.06486599f, 0.06780723f, 
    -0.01099720f, 0.06929512f, 0.04507177f, -0.08210521f, -0.03386769f, -0.03828295f, 0.07919487f, 0.04395235f, 
    0.03911771f, 0.02652862f, -0.06099017f, -0.07374698f, -0.08554003f, -0.06310874f, -0.01439297f, -0.04366687f, 
    -0.06957660f, -0.01638469f, 0.07818426f, -0.04603506f, -0.06670665f, -0.09034765f, -0.07199601f, 0.05289808f, 
    -0.01311774f, -0.09007575f, -0.02109709f, 0.00637410f, -0.00645993f, 0.03967527f, -0.12612402f, -0.04200640f, 
    -0.03167749f, 0.02764889f, 0.06860088f, 0.08583706f, 0.00354974f, -0.05379005f, -0.00565925f, 0.02016862f, 
    -0.11462146f, 0.06826629f, 0.01353875f, -0.02900289f, -0.04991962f, -0.07104418f, 0.06227949f, 0.07364228f, 
    -0.09513947f, 0.05171084f, -0.08078717f, -0.08502366f, -0.04562439f, 0.01218656f, -0.00119491f, 0.06112968f, 
    0.00517653f, 0.04865441f, 0.01750938f, 0.06151202f, -0.07970463f, 0.01150007f, 0.00415331f, -0.01812394f, 
    -0.01393028f, 0.02786484f, 0.08132914f, -0.02805276f, -0.07844573f, -0.03440949f, -0.07793973f, -0.08590065f, 
    -0.03867817f, -0.03244272f, -0.07488675f, -0.01656746f, 0.07734118f, -0.04876716f, 0.02858922f, -0.06238519f, 
    0.03070742f, -0.03064789f, -0.11189815f, 0.00348497f, -0.05352699f, -0.13780165f, -0.04088363f, 0.01020251f, 
    0.23248717f, -0.17917824f, -0.29272008f, -0.08590945f, 0.01091214f, -0.33855140f, -0.08371477f, -0.27800530f, 
    0.29716346f, 0.17402227f, 0.15722601f, 0.17281280f, 0.16129947f, 0.01886173f, -0.13027760f, 0.92594814f, 
    -0.27152437f, -0.16766489f, -0.04137885f, 0.15745260f, 0.40776312f, -0.01516547f, 0.10671514f, -0.21235546f, 
    0.37988234f, -0.13148415f, -0.20370598f, 0.11132156f, -0.18709548f, 0.11064380f, 0.25472000f, 0.20496413f, 
    0.14875712f, 0.03585492f, -0.06206419f, 0.09091900f, -0.05297569f, -0.14651437f, -0.25692534f, 0.02180872f, 
    -0.13631086f, 0.02778364f, -0.04574419f, -0.04989650f, -0.00602265f, 0.04721720f, 0.13730255f, -0.47255695f, 
    -0.05143248f, 0.19733419f, -0.00886967f, -0.05332381f, 0.37264839f, 0.17952900f, -0.01705583f, 0.13883251f, 
    0.10990644f, 0.17762128f, -0.09214181f, 0.20996504f, 0.22337592f, 0.14884049f, 0.01667335f, -0.22602752f, 
    0.14794613f, 0.02444071f, -0.00889141f, 0.16097701f, 0.20797411f, 0.20417604f, -0.11649728f, -0.11031739f, 
    0.21809833f, 0.02255833f, 0.15029682f, 0.08153193f, 0.06767803f, -0.40828037f, -0.03084238f, 0.14651620f, 
    -0.11519393f, 0.14605568f, -0.11162042f, 0.52922672f, 0.02891846f, -0.03792569f, 0.38272247f, 0.19039525f, 
    -0.03298992f, 0.12269320f, -0.12486617f, -0.03960160f, 0.14593638f, -0.49425790f, -0.11964095f, 0.06255408f, 
    0.16735028f, 0.26400146f, -0.18131331f, 0.31094682f, -0.00836856f, 0.08358047f, -0.20315236f, 0.06802050f, 
    -0.07079311f, 0.00375339f, 0.12985475f, 0.23845141f, 0.08884821f, 0.04284698f, 0.00864789f, 0.04759552f, 
    -0.22856836f, 0.16819090f, -0.24787940f, -0.00937013f, 0.05097628f, 0.07174812f, 0.04343974f, -0.12858191f, 
    0.21231356f, 0.14160024f, 0.23931116f, 0.08919602f, -0.04289496f, -0.00407007f, 0.02289462f, 0.02613163f, 
    -0.06011862f, -0.33270285f, -0.27627200f, 0.09704769f, 0.14254136f, 0.06150732f, 0.06818839f, -0.25467563f, 
    0.23834419f, -0.02763669f, -0.01909229f, -0.25055313f, 0.23982933f, -0.03701831f, -0.12253488f, -0.36609077f, 
    0.11328187f, 0.00290669f, 0.12991773f, 0.07425030f, 0.28703555f, -0.06984623f, 0.31261948f, 0.15737563f, 
    -0.15103602f, -0.10150975f, -0.14933197f, 0.20251347f, 0.54505765f, -0.25752309f, 0.02205334f, -0.28790262f, 
    -0.14446244f, 0.12965958f, 0.01479113f, 0.15766774f, -0.07809932f, 0.07632455f, -0.44645855f, 0.04408261f, 
    -0.24372658f, 0.01830792f, -0.22420295f, 0.10264850f, 0.00944424f, 0.03648468f, -0.00043592f, -0.17573620f, 
    -0.05481857f, -0.06580792f, -0.14046595f, 0.04600224f, 0.12288921f, -0.05725517f, 0.07943632f, 0.20133059f, 
    -0.05062914f, -0.02437977f, -0.13305303f, 0.08530684f, 0.03903262f, 0.12726571f, 0.13694185f, -0.09895719f, 
    0.05342115f, 0.16596848f, 0.09221567f, 0.11208348f, 0.09399825f, 0.06567388f, 0.80287302f, -0.05503415f, 
    -0.08943947f, 0.18215597f, -0.36961171f, 0.30564275f, 0.21526198f, 0.09673909f, 0.04358846f, -0.05448779f, 
    -0.01758331f, 0.06988327f, -0.23203151f, -0.03373936f, -0.01022839f, 0.16998306f, -0.33151740f, -0.01600464f, 
    0.08548343f, 0.04680720f, 0.26981142f, -0.10167920f, 0.04378219f, 0.03328139f, 0.06502917f, 0.29108644f, 
    -0.12657100f, -0.10203320f, -0.03063129f, 0.00025193f, 0.30364200f, -0.05002753f, -0.01164846f, -0.06628782f, 
    0.09969803f, 0.04661241f, 0.07115852f, 0.19615828f, 0.12204437f, -0.03232729f, 0.07840670f, -0.03285436f, 
    0.39090958f, 0.05829867f, 0.08248966f, 0.05255501f, 0.05920881f, 0.01721924f, -0.06900270f, -0.34703526f, 
    0.00060230f, 0.32207972f, -0.00712413f, -0.15517358f, -0.04421984f, -0.18468674f, 0.29155836f, -0.15733494f, 
    0.19482394f, 0.22265410f, -0.03807324f, -0.09707237f, 0.04972318f, -0.13636611f, -0.19253935f, 0.04249214f, 
    -0.15504652f, 0.15275541f, -0.01386948f, 0.10681076f, 0.15598279f, -0.45023361f, 0.02979704f, 0.56303537f, 
    -0.14946410f, -0.26832145f, 0.01979165f, 0.26529753f, 0.05032171f, -0.16743685f, 0.09244715f, -0.37965485f, 
    0.06714819f, 0.25398809f, 0.01540357f, 0.19224554f, -0.12499610f, -0.06058967f, 0.34863797f, 0.46089441f, 
    -0.31482819f, -0.85425287f, -0.21550433f, 0.11255929f, 0.03865653f, -0.17231186f, 0.05204659f, 0.09004533f, 
    -0.12139100f, 0.08256599f, 0.29251379f, -0.00863380f, -0.01524074f, 0.03221675f, 0.03639517f, 0.05811853f, 
    0.06668716f, 0.28019932f, 0.37134388f, -0.08751463f, 0.02697195f, 0.20713498f, -0.18195912f, 0.24509302f, 
    0.24442512f, -0.07245413f, -0.51580912f, -0.11614367f, -0.12945291f, -0.31599617f, -0.14805725f, -0.14953665f, 
    -0.52231765f, 0.00023071f, 0.00037983f, 0.01120621f, 0.05746533f, -0.09464305f, -0.23284273f, -0.16125166f, 
    0.16771884f, -0.18734609f, -0.07512560f, -0.05682762f, -0.00452713f, -0.49905872f, -0.20576145f, 0.23734254f, 
    -0.06733769f, 0.13135462f, -0.02931640f, -0.02879594f, 0.00957081f, 0.10277600f, -0.28903398f, 0.25466916f, 
    0.04875267f, 0.00038046f, -0.26041195f, 0.54459113f, -0.15834507f, -0.67267674f, -0.25541478f, -0.02109297f, 
    -0.01973246f, 0.23952055f, 0.24717218f, 0.34527606f, -0.22484289f, -0.23639587f, -0.19082052f, -0.06340634f, 
    -0.16698711f, -0.16591734f, 0.11676284f, -0.23047020f, -0.24364911f, 0.01761089f, -0.02310484f, 0.15011506f, 
    -0.27068552f, 0.00854091f, -0.19357155f, -0.04365828f, 0.11166945f, 0.15549488f, 0.03713455f, -0.15719697f, 
    0.09100727f, -0.56233686f, 0.20814268f, 0.12528405f, -0.11479037f, -0.02707573f, 0.01616675f, -0.15932505f, 
    0.23935336f, 0.01518980f, 0.26734096f, 0.11987734f, 0.04985603f, -0.55452114f, 0.17431694f, -0.04936244f, 
    -0.45237991f, 0.11400738f, -0.32483345f, 0.04637324f, 0.23326202f, -0.09519973f, -0.09639842f, -0.14765052f, 
    -0.14982678f, -0.09806500f, 0.16974400f, 0.20061034f, -0.07881362f, 0.12819186f, -0.16829972f, 0.10477573f, 
    -0.05871375f, 0.18012616f, 0.12542960f, 0.14171584f, -0.03282560f, -0.05216127f, 0.03754266f, -0.50157994f, 
    -0.00020949f, -0.16058297f, 0.09674717f, -0.37494010f, -0.00610746f, -0.03715515f, 0.34284794f, 0.03186221f, 
    -0.09216737f, 0.04298564f, 0.16113302f, 0.04149035f, 0.02725430f, -0.05674926f, 0.09942897f, -0.08949581f, 
    -0.01229112f, -0.13146944f, 0.14712970f, 0.20310332f, -0.08899062f, 0.07941119f, 0.00421190f, 0.01469750f, 
    0.00243834f, 0.31001550f, -0.13862948f, 0.06141008f, 0.01946215f, 0.21606576f, 0.00379551f, 0.05391639f, 
    0.06786923f, 0.10194258f, -0.01918841f, -0.10213144f, 0.19461258f, 0.22323126f, -0.18891600f, -0.01467728f, 
    -0.07988156f, -0.08701651f, 0.05703956f, 0.02164027f, 0.18090749f, -0.11120063f, 0.04827480f, 0.19653779f, 
    -0.14085458f, 0.24272889f, -0.09886828f, 0.23231056f, 0.13473037f, 0.01033256f, -0.11031707f, 0.28508779f, 
    -0.01059131f, -0.02624310f, -0.05209268f, -0.21976282f, 0.16076952f, -0.15943511f, 0.05669825f, -0.15895581f, 
    0.06247637f, 0.32804865f, -0.31636429f, 0.04377918f, 0.00200440f, -0.10076768f, -0.18327335f, -0.13430047f, 
    0.16491967f, 0.25858074f, 0.01873758f, -0.29698434f, -0.21965146f, 0.10268067f, 0.08651897f, -0.07830507f, 
    -0.21620707f, -0.02626772f, -0.13687991f, 0.02769174f, 0.09333472f, 0.15982588f, -0.06878602f, -0.11569979f, 
    -0.21281241f, -0.03563236f, 0.01934777f, 0.27111411f, 0.03027127f, 0.07406803f, -0.12143984f, 0.26194543f, 
    -0.09810648f, -0.06012104f, 0.11004755f, 0.12984957f, 0.28716809f, 0.47529846f, -0.05305438f, -0.22764498f, 
    -0.32135203f, 0.17684792f, -0.14394517f, 0.10418090f, 0.19481000f, 0.02933820f, 0.01037914f, -0.14654073f, 
    0.35292685f, -0.12307131f, -0.06079122f, 0.11228123f, 0.28986987f, -0.02197220f, 0.42904049f, 0.16731320f, 
    -0.03335793f, -0.05265509f, -0.12999585f, 0.17293905f, -0.15194871f, -0.08296829f, 0.12255111f, 0.25082558f, 
    -0.27224943f, 0.20821956f, -0.15139382f, -0.16056514f, -0.05994248f, 0.36964834f, 0.07460364f, 0.30644307f, 
    -0.18002960f, -0.02193429f, -0.53491563f, 0.17401005f, 0.01809267f, -0.04878499f, -0.03367001f, -0.43398440f, 
    0.08122037f, -0.04686337f, 0.06667169f, 0.10476876f, 0.13982587f, 0.21960151f, -0.19825764f, 0.11552932f, 
    -0.00553940f, 0.11549570f, -0.15472792f, -0.02810917f, -0.06518792f, -0.36052316f, 0.05946357f, 0.17270179f, 
    0.09354345f, 0.00071133f, 0.14790452f, 0.09464204f, 0.08258899f, 0.18228745f, 0.02943718f, 0.18652950f, 
    -0.11130788f, 0.27440196f, 0.04915151f, -0.02749118f, 0.34799713f, -0.05977338f, 0.06066643f, -0.05062950f, 
    -0.15215540f, 0.25259894f, -0.16837555f, -0.21395053f, 0.05495337f, 0.16417712f, 0.20039172f, 0.03340402f, 
    -0.02509500f, 0.25381020f, 0.11935925f, -0.03288760f, 0.02319060f, 0.00058996f, -0.07850800f, 0.02352841f, 
    -0.19095352f, 0.11011051f, -0.12598298f, 0.68389589f, 0.27074042f, 0.06197404f, 0.00502841f, -0.03774981f, 
    0.03495749f, -0.16898274f, 0.21306588f, -0.24106327f, 0.12439906f, -0.06138830f, 0.04135732f, -0.05581647f, 
    0.37646699f, -0.00493963f, -0.11079665f, -0.03981533f, 0.15798050f, 0.17937456f, -0.01443250f, -0.18791938f, 
    0.25678474f, 0.02889785f, 0.21857263f, -0.09382212f, 0.06205078f, -0.47092485f, -0.17119588f, -0.00825838f, 
    -0.08496401f, 0.00032424f, 0.07393096f, -0.07184552f, -0.05561537f, 0.07804964f, -0.07240413f, -0.07203767f, 
    -0.09006648f, -0.01724100f, 0.04404834f, -0.07237457f, 0.05699777f, -0.00475401f, -0.04174923f, 0.04094131f, 
    -0.05948925f, -0.04720303f, -0.00159415f, -0.05396960f, -0.06101483f, -0.01132233f, -0.05496895f, -0.03155983f, 
    0.04167864f, 0.09518579f, 0.01179145f, -0.02419727f, -0.12181926f, 0.05346641f, -0.07247467f, -0.05274109f, 
    -0.07349298f, -0.05387178f, -0.04503187f, -0.06284377f, 0.02671967f, -0.06011505f, -0.07760297f, -0.10249300f, 
    -0.03173912f, 0.02159703f, -0.03725101f, -0.07416191f, -0.00096436f, 0.05730866f, -0.04485807f, -0.01503723f, 
    0.02730175f, -0.06482750f, -0.05620815f, -0.09090697f, 0.03153248f, 0.03088298f, -0.00411594f, -0.05852449f, 
    0.01188166f, 0.05371194f, 0.04846053f, 0.03223321f, 0.02474381f, 0.07105108f, -0.05596263f, 0.04914233f, 
    -0.07082096f, -0.08892622f, -0.00303713f, 0.01905342f, -0.14478070f, -0.11278526f, 0.02611747f, 0.06076803f, 
    -0.08757917f, -0.01440994f, -0.08420434f, 0.01557232f, -0.10442463f, -0.02169597f, 0.00517530f, -0.06464662f, 
    0.09798966f, 0.04434390f, 0.08055900f, -0.06262424f, -0.03776474f, 0.04145835f, -0.08263612f, 0.02149973f, 
    -0.01988106f, 0.04750108f, 0.04688240f, 0.06390475f, -0.09169699f, -0.01688116f, -0.03558462f, 0.06447287f, 
    0.05256164f, 0.05937402f, 0.02155416f, 0.09018461f, -0.05236290f, -0.09113984f, -0.00804121f, -0.00143147f, 
    -0.02960027f, -0.03121612f, -0.02605802f, -0.00798141f, -0.13521069f, -0.02473483f, -0.02854002f, -0.09038946f, 
    -0.05663880f, -0.00741978f, -0.07531941f, 0.02198536f, 0.01245886f, 0.01138980f, -0.07719729f, 0.00700564f, 
    -0.06981461f, -0.07541912f, 0.00487176f, -0.00250993f, -0.06534276f, 0.09307571f, -0.09992123f, 0.06800552f, 
    0.05272076f, -0.19283897f, -0.24264307f, -0.03971487f, 0.19599938f, 0.35896724f, 0.11056897f, -0.36501312f, 
    0.16677891f, 0.25280845f, 0.02550910f, 0.01168673f, 0.24348906f, -0.11719591f, -0.06638579f, -0.09114291f, 
    -0.06508223f, 0.05389472f, 0.10496428f, -0.00732195f, 0.27671850f, 0.11081657f, 0.14904967f, -0.13523576f, 
    0.13314615f, -0.23239802f, 0.03406103f, 0.03036304f, 0.22582254f, -0.21556084f, -0.06707804f, -0.28473172f, 
    0.01205302f, 0.22967730f, -0.08951151f, 0.13051195f, -0.07982682f, 0.00862252f, -0.13795182f, 0.07477472f, 
    -0.30325487f, 0.03182890f, -0.61104465f, 0.04448665f, -0.00719294f, 0.04887725f, 0.14654407f, -0.11784888f, 
    -0.04402772f, -0.10765942f, 0.04454657f, 0.01587615f, 0.27828956f, 0.05483609f, -0.04578233f, 0.23845559f, 
    0.23338708f, -0.06288725f, -0.32592812f, -0.16448972f, 0.27884394f, -0.01528224f, 0.15346101f, -0.03130500f, 
    0.06596296f, 0.07206203f, 0.13358018f, 0.16474946f, 0.21905780f, 0.30210990f, 0.29824632f, -0.04523092f, 
    0.05330633f, 0.12404495f, -0.00986823f, 0.06830097f, 0.12164450f, -0.06914408f, -0.04875862f, -0.00774508f, 
    -0.01564482f, 0.06184005f, 0.02742791f, 0.16014628f, -0.00215038f, 0.04840235f, -0.03590596f, 0.08992232f, 
    0.04940011f, 0.14360343f, 0.17856118f, -0.16496633f, -0.11565892f, -0.06399963f, -0.03791872f, 0.07685107f, 
    -0.14027907f, 0.00396772f, -0.09245767f, 0.14620408f, -0.07816863f, 0.01715008f, -0.03551741f, 0.13016793f, 
    0.10019905f, -0.27455825f, 0.11525044f, 0.06898104f, 0.10609665f, 0.06670462f, -0.04719307f, -0.03383414f, 
    0.37287751f, 0.26404312f, 0.13063139f, 0.00009777f, 0.11880288f, 0.21728630f, 0.04195345f, -0.27183071f, 
    0.62639970f, 0.31011257f, 0.20019515f, -0.12662308f, -0.02297014f, -0.27559277f, 0.07038791f, -0.17283210f, 
    0.00454284f, -0.03611335f, 0.15037265f, -0.05581957f, -0.12003466f, 0.69152099f, -0.15858258f, -0.23068064f, 
    0.31945276f, -0.17861292f, 0.24193926f, -0.14919525f, 0.07375246f, 0.05519745f, 0.27085876f, -0.33099574f, 
    -0.28866333f, 0.13885693f, 0.05080261f, 0.06717823f, 0.16690360f, 0.29172778f, 0.15670590f, -0.00521429f, 
    -0.16645867f, -0.24358243f, 0.14913951f, -0.11262214f, 0.17113914f, -0.12838060f, 0.19963975f, 0.05897024f, 
    0.31190047f, 0.17066203f, 0.24192744f, 0.01839800f, 0.07508203f, -0.01433541f, -0.05310851f, -0.05513461f, 
    0.00509550f, 0.02940233f, -0.56697595f, -0.01684869f, 0.04273291f, 0.04097524f, -0.14974903f, 0.60989493f, 
    -0.00311252f, 0.18386243f, -0.20584480f, -0.16647676f, 0.04896284f, -0.19163533f, 0.11664660f, 0.06764719f, 
    0.09533499f, -0.16394025f, 0.19436924f, 0.03001283f, 0.31586346f, 0.13844913f, -0.05757850f, 0.05684194f, 
    0.05851154f, 0.08953704f, -0.03180169f, 0.20817569f, 0.05746483f, 0.00413577f, -0.36888292f, 0.12776880f, 
    0.14401774f, 0.21612248f, 0.06642856f, -0.09083990f, 0.01728768f, -0.12245720f, 0.09228309f, -0.20044617f, 
    0.10761733f, -0.15009494f, 0.12936176f, 0.17976721f, 0.09828773f, 0.11684397f, 0.04477787f, -0.17106436f, 
    0.07130753f, -0.03900726f, 0.03846490f, -0.10274682f, 0.27132255f, 0.17562091f, -0.09898492f, 0.13919345f, 
    0.07926904f, -0.11172765f, 0.15918778f, -0.09947119f, 0.06715737f, 0.20114979f, -0.17632748f, 0.06504007f, 
    -0.45470095f, -0.29219222f, 0.05926615f, 0.15710098f, 0.03854136f, 0.04665834f, -0.19518994f, 0.03823537f, 
    0.16735750f, 0.05101246f, -0.11320883f, -0.11368494f, -0.00037447f, 0.18746233f, 0.17880343f, 0.32416585f, 
    0.62303621f, -0.01358337f, -0.11753424f, 0.20147499f, 0.24927121f, -0.23935416f, 0.23461150f, 0.09407620f, 
    -0.05267615f, 0.05850716f, 0.01401064f, -0.15749349f, -0.05516393f, 0.01482404f, -0.06274703f, -0.11806358f, 
    0.05336632f, 0.05990665f, -0.01963512f, 0.05537520f, -0.02845223f, -0.12412419f, 0.04773162f, 0.06689881f, 
    0.05475508f, -0.00966532f, -0.04288584f, -0.03795530f, 0.04549145f, -0.00820557f, 0.08867306f, -0.07106604f, 
    -0.08239654f, -0.00659762f, 0.01675742f, 0.00377756f, -0.01701177f, -0.03140210f, -0.08519989f, 0.09633035f, 
    0.00893262f, -0.09369609f, -0.12772910f, 0.11060819f, 0.02345448f, 0.05126342f, -0.05830098f, 0.02652596f, 
    -0.03493830f, -0.02481744f, 0.10176511f, 0.03152904f, 0.03985780f, 0.03534237f, -0.14420624f, -0.07559056f, 
    0.01176523f, -0.03265781f, -0.04322613f, -0.06892301f, -0.03236219f, -0.15700573f, -0.12790284f, -0.00247697f, 
    0.02870170f, -0.03185128f, -0.07278967f, -0.03896628f, -0.09306823f, -0.03831194f, -0.03905115f, 0.02170877f, 
    -0.05507623f, -0.02392434f, -0.08912869f, -0.05511305f, 0.02515307f, -0.03198287f, 0.04414586f, -0.06046508f, 
    -0.14323051f, -0.07394063f, -0.00025577f, -0.13143863f, -0.13036872f, 0.02693412f, 0.01888676f, -0.03226499f, 
    0.06939286f, -0.02546616f, -0.10341689f, -0.09057686f, -0.10966572f, 0.06998982f, -0.04251320f, -0.08703358f, 
    -0.01332829f, -0.10490838f, 0.02819148f, -0.02464516f, -0.10660475f, -0.02393882f, -0.00861254f, 0.08776197f, 
    -0.11821200f, -0.03519651f, 0.00167415f, -0.05278466f, 0.01457742f, -0.00564867f, 0.06501185f, -0.03811568f, 
    -0.07389711f, -0.05674117f, -0.08709097f, 0.00404952f, -0.02004646f, -0.04721712f, -0.00128194f, 0.00680777f, 
    -0.13808471f, -0.04787584f, 0.03822215f, 0.05377946f, -0.13230821f, -0.00248649f, -0.04194973f, -0.05651971f, 
    -0.06867389f, -0.08582812f, -0.06314650f, -0.04960666f, -0.09649081f, 0.14113210f, -0.01361247f, -0.05302022f, 
    -0.06239474f, -0.07764345f, -0.05960825f, -0.12130006f, 0.05899363f, -0.00338489f, -0.10887521f, -0.05622945f, 
    0.02306420f, -0.11432330f, 0.01283395f, 0.05303053f, 0.01676111f, -0.03555767f, 0.00449416f, 0.00053411f, 
    -0.03988678f, 0.05531279f, -0.11358391f, -0.05930283f, 0.11393195f, -0.01167671f, -0.02923761f, -0.07621721f, 
    -0.02931740f, -0.01695901f, -0.10795547f, 0.01376175f, 0.04222885f, -0.02982116f, -0.08980304f, 0.06344714f, 
    -0.05898536f, 0.04439658f, -0.02278581f, -0.02798445f, 0.00983270f, -0.07884666f, -0.05512779f, -0.03206821f, 
    -0.01198003f, 0.05484887f, 0.11403181f, -0.07650582f, 0.03649144f, 0.01546013f, 0.05973019f, -0.00539322f, 
    0.06185218f, -0.08478897f, -0.02068756f, -0.04510043f, -0.03789443f, -0.00934323f, 0.02774291f, -0.09597420f, 
    0.03080931f, 0.03933274f, -0.01243664f, -0.07147570f, -0.05487586f, 0.04367520f, -0.09111314f, -0.08234201f, 
    -0.01523365f, -0.02294704f, 0.03074865f, 0.00783914f, 0.01309752f, -0.01326140f, 0.06930715f, -0.05717704f, 
    -0.02211421f, 0.04589295f, -0.03234598f, 0.03546056f, -0.01429414f, 0.00335862f, 0.03408763f, -0.00443152f, 
    0.08025052f, 0.00503198f, -0.00439999f, 0.07133029f, -0.06004963f, -0.02533380f, 0.03454444f, 0.00595754f, 
    0.06287793f, 0.04330033f, -0.02043763f, -0.02522978f, -0.10268007f, -0.08216374f, -0.00998968f, 0.02104673f, 
    -0.12766887f, -0.05324830f, 0.06709471f, -0.00314637f, 0.01416670f, 0.01775231f, -0.00141377f, 0.00918672f, 
    -0.08726913f, 0.03377518f, -0.05192712f, -0.11066122f, -0.07946430f, -0.02053422f, -0.11208276f, -0.05785509f, 
    -0.03311836f, -0.00095480f, 0.05461693f, 0.03202024f, 0.03493196f, -0.04950102f, 0.02650601f, -0.03002719f, 
    0.07309041f, -0.02255321f, -0.05118505f, -0.02214057f, 0.02024649f, 0.07191882f, 0.03708893f, 0.01141307f, 
    0.13273419f, -0.17622019f, -0.06556691f, 0.15078321f, -0.04687501f, -0.19406696f, -0.10558227f, -0.41539049f, 
    -0.62167984f, 0.20438349f, -0.17544129f, 0.46056044f, -0.00632020f, 0.05282045f, -0.11104751f, 0.11422467f, 
    -0.69460106f, -0.19023755f, -0.18170542f, 0.12935412f, -0.31564328f, -0.29707628f, -0.11362249f, -0.09083657f, 
    -0.11751503f, 0.03986793f, 0.38010916f, 0.05239215f, 0.00312474f, -0.40421101f, 0.25023264f, -0.40758172f, 
    0.03633517f, -0.04671830f, -0.27900925f, -0.16427453f, 0.09803713f, 0.05395878f, 0.19370021f, 0.03326281f, 
    0.13829443f, 0.01358841f, 0.02895099f, -0.03261884f, 0.08666723f, 0.02949666f, 0.05492991f, -0.32380074f, 
    -0.08064864f, 0.27743235f, -0.09071153f, 0.29565838f, 0.17054561f, -0.08567284f, 0.24949579f, -0.09340011f, 
    -0.23372550f, 0.41511005f, -0.24840985f, 0.00799169f, 0.28803504f, -0.09519120f, 0.04461593f, -0.10813156f, 
    0.17765138f, 0.15398568f, -0.08750912f, 0.02354524f, 0.07211769f, 0.33002812f, 0.13126074f, 0.00943038f, 
    0.07572132f, -0.08450137f, -0.04773703f, -0.32772446f, -0.01524928f, -0.13951316f, 0.31597033f, 0.00936741f, 
    0.04104142f, 0.22562091f, -0.42255154f, 0.47100291f, -0.07696409f, -0.10889571f, -0.29845786f, 0.00975424f, 
    0.03591825f, 0.09576961f, 0.11613274f, -0.38213304f, -0.11100197f, -0.47568098f, -0.03808838f, 0.13664781f, 
    -0.15853716f, 0.23504432f, -0.18194687f, 0.41252035f, -0.11917525f, 0.11621260f, -0.00967867f, -0.06841635f, 
    -0.04585474f, -0.31244871f, 0.11857025f, -0.23796086f, 0.15091082f, 0.02630784f, 0.06742002f, -0.07264128f, 
    -0.38848642f, 0.08519839f, 0.00360902f, 0.02787803f, 0.18280278f, -0.12500182f, 0.10591176f, -0.00655559f, 
    -0.46026391f, 0.49214399f, 0.50855845f, 0.06512813f, 0.00440086f, 0.35507268f, -0.05717368f, 0.21453436f, 
    0.15401642f, 0.23180492f, 0.15555327f, -0.08162930f, -0.16430193f, -0.09825587f, 0.07512750f, 0.34825549f, 
    0.34536892f, -0.38195923f, -0.01641478f, 0.24098507f, -0.38056940f, 0.14895716f, 0.16449599f, 0.70595288f, 
    0.55987120f, 0.01554936f, 0.06252817f, 0.23338769f, -0.04613066f, 0.02579978f, -0.02230550f, 0.23666161f, 
    -0.06903353f, -0.02721345f, 0.13283886f, -0.21605434f, 0.35713494f, 0.16577201f, 0.32482466f, 0.40701497f, 
    0.20415606f, -0.21733589f, 0.21833056f, -0.35186613f, 0.08593725f, -0.37704149f, 0.29053277f, -0.07170497f, 
    0.41504332f, 0.03655254f, 0.20789972f, -0.14406602f, 0.06042580f, 0.06103026f, -0.21671847f, -0.19529264f, 
    -0.30762580f, 0.15437385f, -0.14498091f, 0.20038384f, -0.29022193f, -0.23544674f, 0.17203435f, -0.20589921f, 
    -0.42245868f, -0.01120084f, 0.29218057f, 0.29188621f, 0.05446102f, 0.37359238f, -0.12255212f, -0.16294268f, 
    0.12595835f, 0.27700338f, -0.11104506f, 0.12789114f, 0.01074370f, -0.25336722f, 0.18247537f, -0.02181404f, 
    0.11672179f, 0.06781997f, 0.28916660f, 0.23521414f, -0.27960047f, 0.18724512f, 0.22112077f, 0.00341764f, 
    0.03695479f, -0.10865735f, -0.06437727f, 0.03583447f, 0.04748990f, -0.14334540f, -0.03973997f, -0.02925847f, 
    -0.07411274f, -0.06547061f, 0.06360783f, 0.06600665f, 0.43051049f, 0.09258683f, 0.02500140f, -0.11255178f, 
    0.21185197f, -0.09034903f, 0.10741912f, 0.50400859f, 0.15790167f, 0.15906501f, 0.14072338f, -0.15445095f, 
    0.13652200f, 0.25116825f, -0.36622769f, 0.03411568f, 0.00572986f, -0.10917187f, -0.16502255f, 0.07419636f, 
    0.17239413f, 0.04621809f, 0.05823667f, 0.05068287f, -0.06461133f, -0.10409142f, -0.12797731f, 0.21374445f, 
    -0.06725041f, -0.03888487f, 0.02015741f, 0.30010766f, 0.29038113f, 0.08850979f, 0.08716646f, 0.16420804f, 
    0.01455480f, -0.04861886f, 0.15258972f, 0.06565803f, 0.10551438f, 0.41356072f, 0.04579555f, -0.12607320f, 
    -0.15773478f, 0.22708628f, -0.11854220f, 0.00368466f, -0.00715350f, -0.01187083f, -0.05020170f, -0.40767923f, 
    -0.23385468f, 0.14119531f, 0.00376269f, 0.13165668f, 0.25736362f, 0.09147760f, 0.23973748f, 0.12916611f, 
    0.07389995f, 0.00224567f, -0.03686041f, 0.20067061f, 0.03035295f, -0.18574008f, -0.21182111f, -0.05833593f, 
    -0.16823475f, 0.39273572f, -0.05264441f, -0.16813235f, -0.00352598f, 0.24966498f, 0.14820817f, 0.14338981f, 
    -0.27406463f, -0.02740977f, -0.24358417f, 0.17862533f, -0.03029465f, 0.01709742f, -0.01851181f, -0.14207126f, 
    0.12916358f, -0.11378226f, 0.19932953f, 0.05844957f, 0.11032140f, 0.17226925f, -0.30004653f, 0.12942111f, 
    0.11631685f, -0.00894939f, -0.26605308f, -0.18884924f, 0.06489670f, -0.10003404f, -0.00367645f, 0.10503753f, 
    0.04852465f, 0.12472045f, 0.04994388f, 0.14933878f, 0.03891556f, 0.11247344f, 0.22994222f, -0.04968919f, 
    0.09959424f, 0.02889507f, 0.04266973f, 0.05174069f, 0.09646007f, 0.14186572f, -0.07834268f, -0.11639652f, 
    -0.19425766f, 0.24249966f, 0.09622341f, -0.14237796f, 0.12886313f, 0.10302604f, -0.06767386f, -0.14707845f, 
    0.14709239f, 0.10471533f, 0.15018217f, -0.30131859f, -0.00965342f, 0.00330486f, 0.02329947f, 0.19985053f, 
    -0.15693587f, -0.01606238f, -0.02271652f, -0.39099589f, 0.26143396f, -0.00256318f, 0.10198583f, -0.11654551f, 
    0.08671706f, -0.00563938f, 0.17909868f, -0.19854799f, 0.00638740f, -0.04765682f, -0.03277590f, 0.03211999f, 
    0.71032351f, 0.07541570f, 0.07396391f, -0.01281483f, 0.00373256f, -0.01583844f, 0.22661120f, -0.26833555f, 
    0.40912411f, 0.08948215f, 0.33125737f, -0.00393114f, 0.10160732f, -0.16555542f, 0.06393296f, -0.01954749f, 
    -0.04995319f, -0.10027226f, 0.06161104f, -0.04600186f, 0.11468484f, 0.77968746f, -0.15642966f, -0.30672306f, 
    -0.13709484f, 0.28069419f, -0.01123806f, 0.16761242f, 0.21011396f, -0.03066259f, 0.02240826f, 0.12991548f, 
    0.05919408f, -0.10767711f, -0.06570933f, 0.03211790f, 0.31627053f, 0.01685891f, 0.26198453f, -0.05672382f, 
    0.16707540f, 0.06368107f, 0.01792168f, 0.15449584f, -0.03565276f, -0.33525941f, 0.08763104f, 0.23586579f, 
    -0.15944748f, 0.10949081f, -0.28689268f, -0.01631085f, -0.02048096f, 0.29365191f, 0.11659195f, 0.22223105f, 
    -0.15430309f, -0.01859391f, -0.52569038f, 0.11678837f, 0.00648800f, 0.00224365f, 0.12818918f, -0.13149500f, 
    0.02102074f, 0.06296004f, 0.23278020f, 0.13615228f, 0.17238657f, 0.22972257f, -0.18408319f, 0.40500557f, 
    0.03677865f, -0.01933746f, -0.46518314f, -0.16092415f, 0.15818909f, -0.40376320f, 0.05736616f, 0.03154038f, 
    -0.12425277f, -0.07495520f, 0.13314882f, 0.28408068f, -0.01521269f, 0.12043595f, 0.23531622f, -0.00123425f, 
    0.18175633f, 0.02411607f, -0.12100500f, -0.16288052f, 0.05089454f, -0.07337228f, 0.01131966f, 0.12517920f, 
    -0.09534750f, 0.12118430f, -0.08781868f, -0.01571434f, 0.18143252f, 0.09255237f, 0.17368326f, 0.07208426f, 
    0.10299918f, 0.27996066f, 0.05896108f, -0.01040437f, -0.12372737f, -0.10042098f, -0.06585614f, 0.17070040f, 
    -0.19987109f, 0.16106929f, -0.08658633f, 0.21136497f, 0.00133297f, -0.00822243f, -0.01963262f, -0.04137446f, 
    -0.09956211f, -0.26168820f, 0.17518137f, -0.04248314f, 0.03441167f, 0.07248619f, -0.07867011f, 0.01740391f, 
    0.47019473f, 0.14053543f, -0.04014291f, 0.08958749f, 0.12455959f, 0.19501594f, 0.14290302f, -0.23734894f, 
    0.65020692f, 0.04589981f, 0.29259285f, -0.01700352f, 0.06761504f, -0.46431458f, -0.00938272f, -0.04126287f, 
    0.21765170f, -0.03269804f, 0.05561485f, 0.09690218f, 0.12413578f, 0.25459594f, 0.06648877f, 0.10610055f, 
    0.15302512f, 0.17460637f, 0.06156016f, 0.04806045f, 0.09337079f, -0.13513793f, -0.11188598f, 0.14082792f, 
    0.13690761f, 0.09032584f, 0.00644822f, 0.04348578f, 0.19320396f, 0.16248220f, 0.04351364f, 0.09873166f, 
    0.26368159f, 0.01107462f, 0.01804759f, 0.09205620f, 0.20224494f, -0.08951452f, -0.10596944f, -0.13642763f, 
    -0.12639154f, 0.20220780f, -0.00724223f, -0.01235133f, 0.00811241f, 0.10318787f, 0.12249754f, 0.09198933f, 
    -0.28633872f, -0.00068480f, -0.10131438f, 0.20044509f, 0.05643327f, -0.08914782f, 0.15696155f, -0.09002906f, 
    0.03462453f, -0.16696042f, 0.26849008f, -0.02962184f, 0.20427953f, 0.19500136f, -0.11385559f, 0.32616207f, 
    0.33190024f, 0.01754762f, -0.13753283f, -0.09957625f, 0.12987372f, 0.00369556f, -0.11143636f, 0.10630830f, 
    0.04782398f, 0.04075193f, 0.02547530f, 0.01697874f, 0.14857049f, 0.11411203f, 0.16557108f, -0.10995671f, 
    0.15093993f, -0.12711395f, 0.08362965f, 0.10822573f, -0.05018771f, -0.07661407f, -0.08772502f, -0.01315808f, 
    -0.36621845f, 0.18969399f, 0.10317635f, -0.11320222f, 0.02442464f, 0.00880919f, 0.07988835f, 0.14194025f, 
    0.21818262f, 0.10175231f, 0.00465183f, -0.17180990f, 0.01837157f, 0.05362484f, 0.14145517f, 0.15433306f, 
    -0.04614487f, 0.09255692f, -0.10009434f, -0.54242384f, -0.10795904f, -0.13966699f, 0.14187808f, -0.00037727f, 
    0.23368724f, 0.01024483f, 0.10678726f, -0.00041929f, -0.01353524f, 0.00431325f, 0.05616870f, -0.04972310f, 
    0.49244922f, 0.23939869f, 0.03282279f, -0.01578875f, 0.02625856f, -0.09785067f, 0.14526124f, -0.13401504f, 
    0.72592396f, 0.11134417f, 0.13651647f, -0.00226019f, 0.01274921f, -0.10801899f, 0.06700975f, -0.21772619f, 
    0.03345592f, 0.03143257f, -0.09214702f, -0.04193683f, -0.05727949f, 0.00436167f, -0.01799060f, -0.08322166f, 
    0.01312249f, 0.01939037f, 0.02017017f, 0.03360249f, -0.10822415f, -0.10830552f, -0.08504079f, -0.03039509f, 
    0.00461884f, -0.06047966f, -0.08133434f, -0.07313615f, 0.05797982f, -0.11087791f, -0.02657698f, -0.10524099f, 
    -0.07840736f, -0.01222559f, -0.07968321f, -0.08158289f, -0.08837637f, -0.01918005f, -0.04499123f, 0.02314001f, 
    -0.03517517f, 0.03387550f, 0.01082438f, -0.03757028f, -0.03525922f, -0.01898195f, -0.09921293f, -0.09652072f, 
    -0.06697292f, -0.04753482f, -0.08726430f, -0.05479409f, -0.01456676f, -0.02912951f, -0.02960794f, -0.06054410f, 
    -0.06570709f, -0.11196776f, -0.03402821f, 0.03760647f, -0.02022204f, -0.07412548f, 0.04718588f, -0.03394081f, 
    -0.06993158f, -0.10681640f, 0.02181024f, -0.09850225f, 0.02018510f, -0.00582443f, -0.05833727f, -0.03829436f, 
    -0.10894129f, -0.06098027f, -0.03201230f, -0.08456715f, -0.06493243f, 0.01694517f, -0.03060432f, 0.04588818f, 
    -0.04513288f, -0.00329243f, -0.07189503f, -0.05684503f, 0.03686228f, -0.03013524f, -0.07177626f, 0.04605886f, 
    -0.10049567f, -0.02061483f, 0.03328537f, -0.06144601f, 0.04858863f, -0.00145659f, 0.07789848f, -0.00283943f, 
    -0.09445202f, 0.05194389f, -0.11141077f, 0.01014916f, -0.00328165f, 0.00813028f, -0.02786128f, -0.05569177f, 
    -0.08250319f, -0.04183819f, -0.06355142f, 0.00157327f, -0.09361508f, 0.02504665f, 0.02746318f, -0.10805000f, 
    0.02466629f, -0.03002143f, -0.08671700f, -0.07135491f, -0.04930304f, 0.00107463f, 0.01534079f, -0.07303787f, 
    0.00291918f, -0.11759724f, -0.01673572f, -0.02356791f, 0.01065762f, -0.05379343f, -0.07240433f, 0.02041232f, 
    -0.08247015f, 0.07022472f, 0.00493546f, 0.04914017f, -0.03877146f, -0.04049059f, -0.00860444f, 0.00283770f, 
    -0.12136513f, -0.07245219f, 0.01502069f, 0.13903247f, 0.11516874f, 0.08653956f, 0.12387912f, 0.06404857f, 
    -0.00679821f, 0.12817852f, -0.11208311f, 0.08376420f, -0.00019878f, 0.07957327f, -0.16478725f, -0.68090212f, 
    -0.24761151f, 0.01553417f, 0.07527543f, 0.09642011f, 0.00375081f, 0.01430785f, 0.21058147f, 0.17954385f, 
    -0.02545538f, -0.03425592f, -0.01251624f, 0.16265932f, -0.00073102f, -0.05882514f, -0.27411363f, -0.14438835f, 
    -0.00785023f, 0.44786203f, -0.28183866f, 0.05827079f, 0.25059998f, 0.43065929f, 0.21068922f, 0.22815669f, 
    -0.18328647f, -0.02431048f, -0.12982641f, 0.10925370f, 0.05615010f, 0.05644057f, 0.09207930f, -0.16203846f, 
    0.11568911f, -0.11756305f, 0.05203275f, 0.03793534f, -0.05067787f, 0.13006544f, -0.17401324f, 0.11466907f, 
    0.07485578f, 0.08665749f, 0.12196727f, -0.09494106f, -0.01135017f, -0.13745594f, 0.07433987f, 0.02134995f, 
    0.08127911f, 0.09918092f, 0.10721411f, -0.08051888f, -0.08057415f, 0.13144584f, 0.36288005f, 0.15193668f, 
    -0.08362315f, 0.09542394f, -0.00823581f, -0.02988493f, 0.10856922f, 0.18808426f, -0.07019990f, -0.14023685f, 
    -0.04857115f, 0.08378642f, 0.13168076f, -0.30625033f, -0.04391215f, -0.01493074f, -0.13371083f, -0.16554636f, 
    0.09824334f, 0.08341669f, 0.34088215f, 0.03971758f, -0.05124388f, 0.19525334f, 0.04160970f, 0.05028770f, 
    -0.02645130f, -0.05810506f, -0.04182802f, -0.25419018f, 0.06197718f, 0.12740310f, 0.29298240f, 0.04169001f, 
    0.22628027f, 0.14141774f, 0.14800547f, -0.12307213f, 0.20027401f, 0.06173694f, 0.11029740f, -0.03199602f, 
    0.65851337f, 0.02683394f, 0.09109725f, 0.00655049f, 0.12625177f, -0.12622635f, 0.01587374f, -0.23747121f, 
    0.07247591f, -0.15302794f, 0.14803076f, -0.10620753f, 0.11263463f, -0.10105678f, -0.17907050f, -0.01867634f, 
    -0.06471644f, 0.03631954f, -0.04125450f, 0.03720601f, -0.09659651f, -0.04306777f, -0.04785874f, -0.07382137f, 
    -0.01071608f, -0.00852569f, -0.05923410f, -0.07974079f, -0.02126445f, 0.07061488f, 0.04900834f, 0.00655941f, 
    -0.08030163f, -0.01369782f, -0.01494371f, -0.00377746f, -0.02873157f, -0.03789848f, -0.01857539f, -0.05130136f, 
    0.05503839f, 0.01198978f, 0.01014690f, -0.06394148f, 0.01422880f, 0.01405658f, 0.07439791f, -0.03029531f, 
    -0.05366615f, -0.11038960f, -0.09192038f, 0.01283647f, 0.04653183f, -0.06407025f, 0.08079171f, -0.05818584f, 
    -0.00290047f, -0.06413476f, 0.06168215f, 0.00623140f, 0.01455596f, -0.05405641f, 0.00223592f, -0.01744254f, 
    -0.03883830f, -0.09814069f, 0.04497152f, -0.10898662f, -0.05309513f, -0.08324833f, 0.01524347f, -0.00991230f, 
    0.04860370f, 0.05554163f, -0.07536477f, -0.08846319f, -0.04297081f, -0.03411286f, 0.07520150f, -0.05034785f, 
    0.00951143f, 0.01921395f, -0.02814844f, -0.04727064f, -0.04780031f, -0.12131858f, 0.04504728f, -0.01362045f, 
    -0.08027232f, 0.01875198f, -0.06574559f, -0.06575587f, -0.04803742f, 0.03751647f, 0.01068809f, -0.02487207f, 
    0.00414226f, -0.08884565f, 0.04508396f, 0.01928552f, -0.00660327f, -0.09446660f, 0.06636953f, 0.01663401f, 
    0.03662633f, 0.01567529f, -0.10458893f, -0.01355903f, 0.02385204f, -0.00156607f, -0.05045798f, -0.07994977f, 
    0.01511899f, -0.03394036f, -0.01515145f, -0.04114836f, -0.04224301f, 0.04217055f, -0.01830104f, 0.03389671f, 
    -0.04941131f, -0.00996636f, 0.01017544f, 0.04698408f, -0.06489418f, -0.03803954f, -0.03731760f, -0.08019097f, 
    -0.00045941f, -0.02287859f, -0.10673596f, 0.06569857f, 0.04308378f, 0.05240855f, -0.05854654f, -0.04369079f, 
    -0.06948503f, -0.05904394f, 0.01312995f, -0.04724495f, -0.00585843f, -0.08640955f, 0.04544648f, 0.04848421f, 
    0.22931531f, 0.20645383f, 0.11119354f, -0.08341236f, -0.50281304f, 0.38740498f, 0.06612880f, -0.07831362f, 
    0.10955553f, -0.00139976f, 0.11449424f, 0.06609351f, -0.05746166f, -0.14758916f, 0.12640068f, 0.02679913f, 
    -0.06822125f, 0.17032558f, -0.10062875f, -0.37849256f, 0.12291841f, 0.01955434f, -0.36597502f, -0.05715717f, 
    -0.02304665f, -0.24353755f, 0.21931708f, -0.39590362f, -0.01967684f, -0.41294917f, -0.18512045f, -0.16623875f, 
    -0.12916391f, 0.12127651f, -0.06480873f, -0.08521802f, -0.02692677f, -0.21560347f, 0.22407955f, -0.29997727f, 
    -0.31140643f, -0.05639985f, -0.32484725f, -0.00542375f, -0.01056755f, 0.01484339f, 0.10847667f, 0.08171201f, 
    -0.04314615f, -0.01055689f, 0.14061840f, 0.14875571f, -0.04035947f, 0.03517067f, 0.21730272f, -0.16482079f, 
    0.16319156f, -0.14285165f, -0.12477429f, -0.21176820f, 0.07903156f, -0.06377168f, -0.11842380f, 0.12539519f, 
    -0.00793116f, -0.06914998f, -0.28647339f, -0.22854514f, 0.00682688f, 0.01060145f, 0.02852136f, -0.07719639f, 
    -0.03630640f, -0.26624399f, -0.31422070f, -0.05758283f, -0.20270060f, -0.22341056f, -0.18161012f, -0.10007348f, 
    0.10514117f, -0.27168539f, -0.01649087f, -0.08791103f, 0.04272712f, -0.06252076f, 0.22990899f, -0.07609859f, 
    0.24437191f, -0.27957785f, -0.16396534f, -0.01441271f, -0.27672219f, 0.16647869f, 0.03289822f, 0.17982320f, 
    -0.18492226f, 0.01713230f, 0.12551698f, -0.42920280f, -0.34657851f, -0.10053669f, 0.17783603f, -0.03065445f, 
    0.07208142f, -0.27612665f, -0.05667914f, -0.06207938f, 0.09344327f, 0.09002838f, -0.07629340f, 0.04493529f, 
    -0.10605055f, 0.04929284f, 0.03740993f, -0.03018683f, 0.06820149f, -0.04923965f, 0.03890375f, 0.08856961f, 
    0.22535287f, -0.26547152f, -0.01413368f, -0.13558549f, -0.03634036f, -0.11137404f, -0.00945928f, 0.10865013f, 
    -0.01036176f, 0.01038502f, -0.11476574f, -0.13984179f, -0.04021113f, 0.19300622f, -0.00971066f, 0.16787152f, 
    0.00032165f, 0.04481620f, 0.18133214f, -0.05912046f, -0.09513802f, -0.11211405f, 0.02576641f, 0.47699189f, 
    -0.19024868f, 0.20969899f, 0.03009920f, -0.02946547f, 0.14223345f, 0.25397220f, 0.16860478f, 0.16506833f, 
    -0.05307264f, -0.18143903f, 0.18025203f, -0.02768833f, 0.70887458f, 0.09291022f, 0.03201936f, -0.18680350f, 
    0.17730051f, 0.29555336f, 0.01967911f, -0.24486886f, -0.12064847f, 0.04372122f, 0.40731400f, 0.05337203f, 
    -0.21950857f, 0.08756683f, -0.04812000f, -0.01807487f, 0.00686696f, 0.01084307f, -0.03721222f, -0.34429306f, 
    0.03455205f, -0.12369455f, 0.37884048f, 0.05994690f, 0.07466217f, 0.08708224f, -0.03958528f, 0.35753101f, 
    0.35310316f, -0.04969438f, 0.08339752f, -0.14021087f, 0.22539411f, 0.29230288f, -0.31843045f, 0.10839331f, 
    0.14380896f, 0.00175007f, -0.01892701f, -0.02014579f, 0.07037477f, 0.00109976f, 0.33559227f, -0.09540151f, 
    -0.06744525f, -0.09240939f, -0.04528628f, -0.02542078f, -0.09610543f, 0.00033489f, -0.03641852f, -0.36832798f, 
    -0.05510885f, 0.02105894f, 0.04759732f, 0.10147507f, 0.10173088f, -0.17398001f, 0.45668596f, 0.04664096f, 
    0.27742800f, 0.14204235f, -0.01134473f, -0.18049985f, 0.05903674f, 0.15506123f, -0.01824282f, 0.37506893f, 
    -0.14007670f, 0.02722110f, -0.07607022f, -0.49451584f, -0.13496390f, 0.06505829f, 0.43269634f, -0.22660421f, 
    0.06649199f, -0.07476769f, 0.14785521f, -0.00903191f, 0.09090693f, -0.00545133f, -0.15212449f, -0.09199198f, 
    0.23667787f, 0.11945341f, 0.31156158f, -0.02132414f, 0.03116067f, 0.07627388f, -0.05075183f, -0.03013421f, 
    0.14575876f, -0.00589453f, 0.16482501f, 0.10171080f, -0.01660115f, 0.28018171f, 0.29618761f, -0.11119228f, 
    0.24231452f, -0.23608918f, 0.20687185f, 0.05899495f, -0.23894298f, -0.27359617f, 0.31561959f, 0.54509467f, 
    0.06812489f, 0.12514167f, 0.25229043f, 0.23205364f, -0.19213279f, 0.14400508f, -0.27020085f, 0.28298253f, 
    -0.89355850f, 0.24631751f, 0.06025174f, 0.03520153f, -0.26054129f, -0.07340812f, -0.21140176f, 0.10676139f, 
    0.10080726f, 0.14443627f, 0.11624137f, 0.07682703f, 0.10164639f, 0.04397843f, 0.03516072f, -0.57717717f, 
    0.12696272f, -0.03472151f, 0.36623719f, -0.68973637f, 0.01334844f, -0.07264008f, 0.35042137f, -0.20440966f, 
    0.09652819f, 0.03918093f, -0.04566363f, 0.01165218f, -0.04949722f, 0.07597049f, 0.13105363f, -0.24269192f, 
    -0.08512320f, 0.01675802f, 0.03989851f, -0.04167202f, -0.15894151f, 0.30650148f, 0.04927076f, 0.11286007f, 
    0.34656990f, -0.03326634f, 0.27957511f, 0.32641959f, 0.13415278f, 0.11484148f, -0.28874424f, -0.03179528f, 
    0.17373729f, 0.25563011f, -0.10010952f, -0.19637275f, 0.08818494f, 0.06878632f, -0.02119743f, 0.01822706f, 
    0.12733392f, -0.25905702f, 0.08904516f, 0.22364973f, -0.33261886f, 0.09562340f, 0.01407409f, -0.22926660f, 
    -0.04731610f, 0.33470330f, 0.24982218f, 0.19464873f, -0.01699913f, -0.45213756f, -0.11166409f, 0.04254545f, 
    0.20743735f, -0.00440509f, 0.16403967f, -0.17200428f, 0.35799798f, -0.02813892f, 0.22276551f, 0.22043414f, 
    0.31844079f, 0.34858167f, -0.05177996f, -0.24394685f, -0.08612262f, -0.03350360f, -0.05725682f, -0.27332112f, 
    0.32497242f, 0.38503546f, -0.09362525f, 0.00311291f, -0.06822798f, -0.17616805f, 0.07552971f, -0.15437365f, 
    -0.00504962f, -0.04849236f, -0.15156043f, -0.00008635f, 0.02949210f, -0.45963424f, 0.08153083f, 0.30074149f, 
    -0.17907456f, 0.10168304f, 0.15976310f, 0.06987830f, -0.04233549f, -0.20522474f, 0.31540933f, -0.01371779f, 
    -0.00267794f, 0.01129606f, 0.00753314f, -0.04643909f, -0.06220513f, 0.02458794f, -0.05302775f, -0.02376117f, 
    0.03158700f, -0.03748019f, -0.10770333f, -0.04680225f, -0.05395987f, 0.05477556f, 0.02739579f, 0.02605953f, 
    0.03833045f, 0.00671230f, -0.04005149f, -0.00982300f, 0.02385267f, -0.00944229f, -0.05544640f, -0.10202499f, 
    -0.10167167f, 0.03391353f, -0.00042946f, 0.02312625f, -0.08679241f, 0.00645569f, -0.01385111f, 0.01154872f, 
    -0.10804611f, 0.03982908f, 0.01419578f, -0.10199513f, 0.06557085f, 0.01465821f, -0.02022202f, 0.04730194f, 
    -0.02506032f, -0.01542577f, -0.08395819f, -0.04216549f, -0.00260504f, -0.02911443f, 0.04824383f, -0.04098579f, 
    -0.09110555f, 0.04549636f, 0.01299116f, 0.04482144f, -0.10863704f, 0.02800388f, 0.03107772f, 0.04401187f, 
    -0.04150190f, 0.02930892f, -0.09908067f, -0.10027099f, 0.01402631f, 0.00019188f, -0.06070451f, -0.07911101f, 
    0.02861363f, 0.03807599f, -0.08215583f, -0.07795967f, 0.00632003f, -0.00817185f, -0.01974070f, -0.05008148f, 
    -0.09686732f, -0.06503429f, -0.01172094f, 0.02386018f, 0.00356278f, 0.00835839f, 0.04110293f, -0.04939741f, 
    -0.00074964f, -0.07896364f, 0.05462532f, -0.08197677f, -0.02879494f, -0.05585893f, 0.06116788f, -0.00854887f, 
    -0.01482159f, 0.05740470f, -0.06668300f, 0.01491840f, -0.04113404f, 0.02734570f, -0.05434209f, -0.00273828f, 
    -0.01748386f, -0.06191838f, -0.03265254f, -0.04526881f, -0.07836960f, 0.06555409f, -0.03177898f, -0.00498482f, 
    -0.11076175f, -0.04428756f, -0.05485945f, 0.03535953f, -0.02897764f, -0.05748029f, -0.05689681f, -0.10369161f, 
    0.00189814f, -0.11754992f, -0.03885708f, 0.08746953f, -0.11144707f, 0.00898029f, 0.04052906f, 0.00887784f, 
    0.06269566f, -0.07818045f, -0.04052870f, -0.06791886f, -0.00004781f, 0.00704487f, 0.06821576f, -0.05710789f, 
    0.04208540f, 0.18004465f, 0.30872029f, 0.05243373f, 0.24686131f, -0.26797172f, 0.14002982f, 0.22385968f, 
    -0.17232685f, 0.06698351f, -0.19291452f, -0.15609694f, 0.19572444f, -0.25348237f, 0.18237026f, -0.28183138f, 
    0.32670924f, 0.11117800f, 0.02802210f, -0.03896452f, -0.41889733f, 0.02477013f, -0.18279271f, 0.18044555f, 
    -0.19423571f, 0.25198093f, -0.08834488f, 0.06669208f, 0.13026801f, 0.20377195f, -0.16045934f, -0.16714610f, 
    -0.20501448f, -0.39468637f, -0.00813366f, -0.22012796f, -0.02787207f, -0.19911018f, -0.05216161f, 0.09649266f, 
    -0.19358231f, -0.05186876f, 0.58531046f, 0.02929350f, -0.03306709f, 0.02358931f, 0.18322788f, 0.27436459f, 
    0.22861335f, -0.29471177f, 0.39998421f, 0.14796531f, -0.11030272f, 0.09327344f, -0.27117133f, 0.07598943f, 
    0.25431466f, -0.06791601f, -0.35432369f, -0.17099276f, -0.48934910f, -0.00683394f, 0.01522862f, 0.15666378f, 
    -0.21918431f, -0.12331956f, 0.01533511f, -0.12633936f, -0.11114687f, 0.01406193f, -0.62165427f, -0.13472894f, 
    -0.18821071f, -0.19595905f, -0.07138346f, 0.06598429f, 0.13843536f, 0.10279717f, -0.09410283f, 0.32276472f, 
    -0.41134405f, -0.08160766f, -0.02048510f, -0.51280087f, 0.09852887f, 0.09556228f, -0.19374597f, 0.16356920f, 
    0.10851301f, 0.13403623f, -0.09741507f, 0.36753616f, -0.14957294f, 0.23764844f, -0.06349030f, -0.12504776f, 
    0.02120281f, -0.00257616f, -0.12546177f, -0.21156228f, -0.09556747f, -0.11876500f, 0.17541176f, -0.04260103f, 
    0.11368871f, 0.52341014f, 0.06007306f, -0.29220539f, -0.15679176f, 0.18322814f, 0.19840509f, 0.17041376f, 
    0.22696957f, -0.34125742f, -0.08156866f, 0.08792687f, 0.16482118f, 0.03919252f, -0.10210992f, -0.14122015f, 
    -0.20688909f, -0.83986187f, -0.48571855f, -0.14328821f, -0.07895326f, 0.22849339f, 0.08936727f, 0.05753464f, 
    -0.17290407f, -0.18486083f, -0.18110234f, 0.12430848f, 0.31413165f, -0.08790331f, -0.06227712f, -0.63352698f, 
    0.01066204f, -0.01894836f, -0.29641214f, -0.02437892f, 0.29143760f, -0.00579282f, -0.02737418f, 0.57323033f, 
    -0.02885429f, -0.57557631f, 0.10856793f, 0.18281069f, 0.33426160f, 0.09337475f, -0.11677646f, -0.13645659f, 
    0.04407874f, 0.15450136f, -0.02695416f, 0.25410277f, 0.12455223f, -0.13774782f, 0.07728346f, -0.14366274f, 
    0.09962390f, -0.26005393f, -0.24092728f, 0.16356044f, 0.00819501f, -0.14984293f, -0.45126772f, -0.04044775f, 
    -0.06512903f, -0.05634113f, -0.26417142f, -0.07289319f, -0.02977591f, 0.00331391f, 0.21633336f, -0.05254337f, 
    -0.04154140f, 0.04606576f, 0.00487727f, 0.09545787f, 0.14250943f, -0.05401487f, 0.12386456f, -0.04974877f, 
    -0.12723872f, 0.16089538f, -0.03618583f, 0.05302462f, -0.01827159f, 0.24380755f, 0.26411167f, -0.09747343f, 
    -0.08196202f, -0.32080626f, 0.13440228f, 0.22638933f, 0.11282547f, 0.14633282f, 0.12703001f, 0.13141049f, 
    -0.16869655f, 0.18387358f, 0.02685232f, -0.07487927f, 0.09144748f, -0.36321777f, 0.09252018f, 0.35468251f, 
    0.08106179f, 0.06025665f, -0.35769013f, 0.30933186f, -0.07059465f, 0.17202479f, 0.40295017f, 0.28830579f, 
    -0.29014143f, 0.26298964f, -0.00195552f, -0.40595269f, -0.11209841f, -0.06391673f, -0.12889074f, -0.27189577f, 
    -0.08986903f, 0.23234561f, -0.03792925f, 0.15518987f, -0.22334522f, -0.11117138f, -0.22315848f, 0.05921116f, 
    -0.20094024f, -0.08077887f, 0.02871158f, 0.11142880f, -0.02710628f, 0.09847648f, 0.12204096f, 0.00296586f, 
    -0.25140309f, -0.06282762f, 0.14122275f, 0.09126520f, 0.04252860f, 0.21458691f, -0.48297772f, -0.04757295f, 
    0.36899418f, 0.07926471f, -0.20769037f, -0.29085362f, -0.04746261f, -0.50724775f, -0.49363860f, 0.27293664f, 
    0.14659701f, -0.06758799f, 0.18149200f, -0.02366586f, 0.23373255f, 0.04742923f, -0.30144608f, -0.53823686f, 
    0.17621268f, 0.14772592f, -0.10924313f, 0.08170133f, 0.21810624f, -0.01749072f, 0.13687904f, 0.51711583f, 
    0.28920582f, -0.18730539f, 0.22414704f, 0.19863926f, 0.21172316f, 0.30464551f, 0.19295123f, -0.11247231f, 
    0.19196352f, -0.02998526f, 0.05218151f, 0.11903537f, 0.16026022f, 0.19808820f, 0.08480188f, -0.08097897f, 
    0.20228457f, -0.29418787f, 0.06601452f, -0.15901147f, -0.11614180f, -0.16589892f, 0.17455669f, 0.01205960f, 
    0.06147194f, 0.02924188f, -0.42161664f, -0.03225505f, -0.02169802f, 0.04665342f, -0.03603619f, 0.35935119f, 
    -0.10796013f, -0.04895918f, 0.09426168f, -0.06033880f, -0.00447512f, 0.15427367f, -0.07840461f, 0.17528833f, 
    0.04487681f, 0.05598497f, -0.04481247f, 0.11677762f, 0.01489719f, 0.21164902f, 0.04809281f, -0.06144551f, 
    -0.08829755f, -0.13189836f, 0.07985456f, 0.35535493f, 0.09398289f, 0.07995025f, -0.21084528f, 0.01598796f, 
    -0.06275643f, 0.10079692f, 0.20255935f, -0.25455692f, 0.09130490f, -0.36939171f, 0.08454084f, 0.18258162f, 
    0.01617515f, -0.14606594f, -0.12023018f, 0.45417958f, 0.20476498f, 0.19094805f, 0.21449398f, 0.38151312f, 
    -0.23972696f, 0.23088802f, -0.20014550f, -0.13044611f, 0.26774970f, -0.06717142f, -0.12372716f, -0.19476612f, 
    -0.01843385f, 0.37662834f, -0.15158382f, 0.23694518f, -0.22474582f, -0.07592624f, -0.17758261f, 0.11887018f, 
    -0.57963282f, -0.12786500f, 0.18340127f, 0.06161438f, -0.23975161f, 0.19477038f, 0.02694538f, 0.02981695f, 
    0.29371223f, -0.10520782f, -0.10604932f, 0.01314156f, -0.06282220f, 0.25569484f, -0.20886645f, 0.10208852f, 
    0.46166745f, -0.26716208f, -0.14540578f, 0.35584217f, 0.00017209f, -0.36314037f, -0.32941929f, 0.19079201f, 
    -0.17446582f, 0.18570119f, -0.12619847f, 0.18759200f, 0.24590203f, -0.29827836f, 0.00320266f, 0.17780130f, 
    -0.22444923f, -0.11548369f, -0.40112084f, -0.08590081f, 0.00849443f, 0.18523814f, 0.25610185f, -0.16466756f, 
    -0.23150709f, -0.36473608f, -0.11087960f, 0.12753262f, 0.01991668f, -0.01923280f, -0.12960860f, 0.09146988f, 
    -0.42341197f, 0.03522500f, -0.16082966f, 0.04531995f, 0.48643073f, 0.12770846f, 0.10111553f, -0.49988547f, 
    0.08751319f, 0.00061920f, -0.29467973f, 0.03148801f, -0.00351795f, -0.04521960f, 0.13707568f, -0.10601720f, 
    0.18941489f, 0.01373169f, 0.27818751f, -0.05779876f, 0.06639705f, -0.06619906f, 0.19143455f, -0.40290460f, 
    0.17497738f, 0.20827501f, 0.05378641f, 0.18044475f, -0.14351037f, -0.21653588f, 0.27274272f, -0.26192614f, 
    -0.20449081f, 0.32302514f, 0.26676631f, 0.11961651f, -0.23660550f, 0.09964481f, 0.14353406f, -0.22734438f, 
    -0.02414737f, -0.04525938f, 0.04762644f, -0.03230762f, -0.12944937f, 0.04567672f, 0.39103475f, 0.32307819f, 
    -0.17227058f, 0.05187203f, 0.07147909f, -0.11766889f, 0.09214642f, 0.25892240f, 0.23925996f, 0.03095526f, 
    0.44740602f, -0.04470987f, 0.09828117f, 0.02417025f, -0.27878588f, -0.06336783f, -0.02644131f, 0.04324558f, 
    -0.18100283f, -0.00419790f, 0.10780065f, 0.12471855f, -0.26185632f, 0.09752494f, 0.21982579f, -0.31430069f, 
    -0.01794714f, -0.07304641f, 0.42121673f, -0.26822215f, 0.11606579f, -0.26269734f, -0.08850908f, 0.13105787f, 
    0.10869825f, -0.09630379f, -0.06324757f, -0.20406944f, 0.03530081f, 0.04672272f, 0.04845854f, 0.19268969f, 
    -0.59365231f, -0.25988489f, 0.10291484f, -0.04034386f, 0.18035100f, -0.01948767f, -0.02280365f, 0.36643374f, 
    -0.29988387f, 0.05471606f, -0.22385830f, -0.39073896f, -0.05035498f, 0.27616549f, -0.37145022f, 0.25935230f, 
    -0.01601855f, -0.00214319f, -0.01134712f, 0.10350333f, 0.25090715f, 0.43537259f, -0.06788669f, -0.37835076f, 
    -0.15909453f, 0.25099227f, -0.06011585f, 0.02859875f, 0.25096419f, -0.04498332f, 0.06721064f, -0.49071491f, 
    -0.23172198f, 0.01243852f, -0.08512557f, -0.03618306f, 0.06907775f, 0.03819529f, 0.24842723f, -0.14242922f, 
    0.08325757f, 0.10398294f, -0.03860874f, 0.28396553f, -0.31960225f, -0.22214675f, -0.05728548f, 0.19273008f, 
    -0.07270425f, 0.21083748f, -0.27426359f, 0.29270789f, -0.03097107f, 0.33663812f, -0.10732822f, 0.14409152f, 
    -0.20681833f, -0.08400008f, -0.25424880f, 0.07652641f, 0.04945621f, 0.05398443f, 0.16324317f, 0.18056226f, 
    0.01621935f, 0.03475097f, 0.06810270f, 0.13422795f, 0.10818416f, 0.23598282f, -0.07561959f, -0.03104565f, 
    -0.03927085f, 0.13706660f, -0.31706905f, -0.17786545f, 0.00922065f, -0.37494957f, 0.20107237f, 0.06191081f, 
    0.02258475f, -0.10978855f, 0.03567680f, 0.22160497f, -0.05970102f, 0.18615024f, 0.05011816f, 0.17153223f, 
    0.19262698f, 0.16916916f, 0.04359768f, -0.03806688f, 0.29677635f, 0.04706047f, -0.08130657f, 0.15379311f, 
    -0.00099866f, 0.26518077f, 0.06487553f, -0.04506800f, 0.10574915f, 0.13832261f, 0.09027279f, 0.03343390f, 
    0.03519182f, 0.17505251f, 0.25174785f, -0.11428456f, -0.28103471f, -0.00958747f, 0.12247552f, 0.03837038f, 
    -0.18456401f, 0.09721313f, 0.00014639f, 0.30584505f, 0.17596258f, -0.02901345f, -0.14273819f, 0.13319574f, 
    -0.07578455f, -0.19107683f, 0.09519690f, -0.09228125f, 0.12227210f, 0.06840603f, 0.04620098f, 0.15597373f, 
    0.49533871f, 0.04930907f, 0.10415424f, -0.07710695f, 0.12807006f, 0.09965301f, 0.14025174f, -0.04873366f, 
    0.41778463f, 0.13175866f, 0.26441482f, -0.13774683f, -0.06276990f, -0.47923371f, -0.21909784f, -0.02721832f, 
    0.16980350f, 0.07648548f, -0.05850189f, 0.22025158f, -0.17853092f, 0.06010392f, 0.21309446f, 0.24583836f, 
    0.24858125f, 0.16639295f, 0.15866856f, 0.33647802f, -0.04686417f, -0.04037421f, -0.12759589f, 0.37432748f, 
    -0.51418126f, 0.08051108f, 0.03431901f, 0.01545189f, -0.18290091f, -0.34027860f, -0.27933320f, -0.09857331f, 
    0.19802693f, 0.22171953f, 0.11008815f, 0.06700166f, -0.51304555f, -0.13179028f, -0.02008064f, 0.25848833f, 
    -0.15664338f, -0.19639672f, -0.04307708f, 0.04224259f, -0.09590629f, -0.02703667f, -0.14034748f, -0.10820996f, 
    -0.01273050f, 0.00763088f, 0.11267678f, 0.10256030f, -0.07822823f, 0.07693800f, 0.26664802f, -0.17927845f, 
    -0.05811361f, 0.35322815f, -0.06896244f, 0.11856534f, -0.04883489f, 0.23807269f, 0.23461866f, 0.02767279f, 
    0.03987159f, 0.05464730f, 0.00468279f, 0.21777473f, 0.08641034f, -0.17413209f, 0.03552379f, 0.04108059f, 
    0.07621860f, 0.00376344f, -0.08880291f, -0.01748670f, -0.04817241f, 0.22162393f, -0.25010571f, 0.00424496f, 
    0.33168036f, -0.09956269f, -0.14975250f, 0.22274947f, -0.10039527f, 0.15455432f, 0.07436696f, 0.12358817f, 
    0.07081465f, 0.27644235f, 0.20444280f, 0.27132478f, 0.02397082f, -0.20355065f, -0.00632528f, 0.02508439f, 
    0.22197667f, -0.12399149f, 0.16529028f, -0.21420909f, 0.07371122f, -0.02365537f, 0.19007421f, -0.14907913f, 
    0.21799248f, 0.18145280f, 0.18488820f, 0.13075694f, 0.00254643f, 0.11927158f, -0.04669530f, -0.06368496f, 
    0.15661424f, 0.21959046f, 0.00276938f, -0.01894510f, 0.09863356f, -0.09761722f, 0.16389926f, 0.01372140f, 
    -0.15357293f, 0.06978855f, -0.16142946f, -0.09041022f, 0.17053221f, -0.13576208f, 0.28580230f, 0.34211212f, 
    0.36375704f, 0.11099393f, 0.48392636f, -0.05635089f, -0.06207384f, 0.20437850f, -0.05881961f, -0.01680502f, 
    -0.01616521f, 0.01644610f, -0.07011366f, 0.03743166f, -0.01439500f, 0.06519336f, -0.07672747f, 0.00382741f, 
    -0.07722186f, -0.04130762f, -0.03763756f, 0.08219658f, -0.07753444f, -0.00173045f, -0.03386937f, 0.02493413f, 
    -0.09323049f, -0.02911825f, 0.06205513f, -0.04489800f, -0.01381296f, 0.08067408f, -0.02739486f, -0.07376035f, 
    0.05188651f, 0.04248987f, 0.06980211f, -0.00138835f, 0.07625273f, 0.06724169f, 0.03515480f, 0.06779404f, 
    0.01112816f, -0.04516143f, -0.02691025f, 0.01446979f, -0.06916784f, 0.03790218f, 0.00662098f, -0.04215156f, 
    -0.06971123f, -0.07437623f, -0.06196673f, 0.04440634f, -0.06766953f, -0.00542507f, 0.07757088f, -0.09160067f, 
    -0.09564617f, -0.08383452f, 0.01365418f, -0.00563871f, 0.03092869f, 0.00723969f, -0.05019036f, -0.04657508f, 
    -0.07479184f, -0.08838367f, 0.05783072f, -0.00238293f, 0.01687420f, -0.07925394f, 0.01945088f, -0.10198519f, 
    0.05434953f, -0.02732583f, 0.06672239f, -0.06475701f, -0.07287068f, 0.06440434f, -0.05106642f, 0.02974426f, 
    -0.02843054f, -0.03601371f, -0.05798309f, -0.00035321f, -0.01420369f, -0.02711488f, 0.08344538f, -0.00943332f, 
    -0.02793448f, -0.06455349f, -0.08592448f, -0.09268010f, 0.01153760f, 0.00651250f, 0.05236167f, -0.02157937f, 
    -0.05961525f, -0.00906324f, 0.01963727f, -0.06806158f, -0.02623145f, 0.00354657f, 0.05219449f, 0.06453568f, 
    0.05567414f, -0.00009650f, -0.00988650f, -0.05074805f, -0.04671160f, -0.08534580f, 0.00628492f, -0.04366284f, 
    -0.05858276f, -0.01265727f, -0.06406417f, 0.07273930f, -0.08159175f, 0.01390390f, 0.05546407f, 0.04150502f, 
    0.07439052f, 0.02618096f, 0.05917319f, -0.07312053f, -0.04947108f, -0.04610986f, -0.03108866f, -0.07709663f, 
    -0.05930183f, 0.00798944f, 0.02092332f, -0.01531241f, 0.04255533f, 0.02610352f, -0.04290554f, -0.03958806f, 
    -0.07264963f, 0.05060042f, -0.00322396f, -0.04400834f, -0.09425802f, 0.00037178f, -0.08373733f, 0.04362433f, 
    0.05088465f, -0.07113172f, 0.07091579f, 0.02224620f, 0.01060519f, -0.05023797f, -0.00932860f, -0.02105956f, 
    0.00782035f, 0.01818664f, -0.09301496f, 0.01111499f, -0.00573563f, -0.02987226f, -0.04968061f, -0.06918000f, 
    0.00167907f, 0.01202965f, 0.00353448f, 0.01578031f, -0.03403962f, -0.01315377f, -0.04900736f, -0.07910641f, 
    -0.06470162f, -0.07816149f, -0.00872709f, -0.05332680f, -0.04654378f, -0.06833187f, -0.02217300f, -0.05393192f, 
    0.00554619f, 0.00699798f, -0.08258600f, 0.06894181f, -0.07592228f, 0.03724285f, 0.07004179f, -0.10357399f, 
    -0.07755774f, -0.02775354f, 0.07115398f, 0.02786024f, 0.08509398f, -0.02154971f, -0.10965285f, -0.04492578f, 
    -0.00195042f, 0.07136188f, -0.03102174f, 0.02481240f, -0.07706445f, -0.02280958f, -0.07373596f, -0.04995642f, 
    0.01053153f, 0.03377522f, 0.04679109f, 0.05035212f, 0.07598573f, 0.00780302f, 0.03779387f, -0.06553522f, 
    -0.03158176f, 0.03959196f, 0.03731320f, -0.08215221f, -0.03548611f, -0.07888091f, -0.05797623f, -0.06404333f, 
    0.04694952f, -0.00682954f, 0.03848552f, -0.05339839f, -0.07808781f, -0.07525168f, 0.04472696f, -0.00975231f, 
    -0.05220805f, 0.04727596f, 0.04586082f, -0.00961110f, 0.00886050f, 0.01282781f, -0.06249307f, -0.05436317f, 
    0.01898593f, -0.07186987f, -0.10436306f, 0.04631723f, -0.08913085f, -0.02758699f, -0.08773144f, -0.04784648f, 
    -0.03558178f, -0.03076297f, 0.01486658f, 0.00906724f, 0.05971403f, 0.04471484f, -0.04435596f, -0.08006944f, 
    -0.02555573f, -0.08271526f, 0.05405888f, -0.03136458f, 0.03954326f, -0.05378304f, -0.03562921f, -0.00367832f, 
    0.05129312f, -0.03889056f, -0.07378831f, -0.05251390f, 0.03545748f, -0.05527535f, 0.06102596f, 0.01137682f, 
    0.00436971f, 0.05275088f, -0.00240625f, -0.20100364f, 0.12879410f, 0.02955280f, 0.00190229f, 0.22928767f, 
    -0.09801392f, -0.02059161f, 0.00405164f, -0.00925689f, 0.03071039f, 0.07559122f, 0.01801246f, 0.00048912f, 
    -0.04302540f, 0.06098101f, 0.08504599f, -0.00563813f, 0.26855540f, 0.21209177f, 0.34194314f, 0.13086373f, 
    -0.14217973f, -0.20844463f, -0.12979554f, -0.06598797f, 0.68453664f, 0.10845138f, 0.11336949f, 0.00053817f, 
    0.30293071f, 0.33718118f, -0.00416836f, -0.28191549f, -0.12657371f, 0.23498137f, 0.38871819f, 0.11934340f, 
    -0.14905697f, -0.00657816f, -0.34842709f, -0.00617056f, 0.11107432f, 0.09395830f, -0.09628157f, -0.14609146f, 
    0.14110419f, -0.21226524f, 0.31248534f, -0.07040143f, 0.08400473f, -0.01171110f, 0.03612119f, 0.26744714f, 
    0.29101512f, -0.11437909f, 0.40104917f, -0.04589273f, 0.37910566f, 0.24911979f, -0.36288375f, 0.14623298f, 
    0.22252938f, -0.07101702f, -0.05768153f, -0.03010393f, 0.04234847f, 0.02296713f, 0.33270314f, 0.04781602f, 
    -0.35706517f, 0.00506703f, 0.21363804f, 0.09134802f, -0.14839920f, -0.11904097f, -0.11854634f, -0.47664514f, 
    0.06517825f, 0.02152683f, -0.01580588f, 0.02270841f, 0.10853503f, -0.05945357f, 0.28025401f, -0.13772067f, 
    0.14713974f, 0.20127219f, -0.00262472f, -0.04172852f, 0.06148594f, 0.27620313f, 0.02868310f, 0.23476852f, 
    -0.13944636f, 0.05528123f, 0.01696904f, -0.38480607f, -0.32199466f, 0.07137416f, 0.53535980f, -0.04928236f, 
    0.05396249f, 0.02658442f, 0.18927361f, 0.03278334f, -0.01493843f, 0.08841866f, -0.25844026f, -0.32295617f, 
    0.15634723f, 0.07282592f, 0.24491012f, 0.08501293f, 0.00265833f, 0.01691199f, -0.07395976f, -0.04323702f, 
    0.20545994f, -0.12783355f, -0.02322543f, 0.12519567f, 0.14970595f, 0.27786273f, 0.03132983f, 0.03268964f, 
    -0.05162854f, 0.04475277f, -0.02791010f, -0.06910071f, -0.08299467f, 0.02188167f, -0.09241654f, -0.08411732f, 
    -0.05159308f, 0.04060289f, -0.06040987f, -0.01312277f, -0.09948279f, 0.02986635f, -0.13276985f, -0.04855069f, 
    -0.05727021f, -0.02957774f, -0.04841123f, -0.02554931f, 0.00787528f, -0.03482430f, -0.00613061f, -0.06294294f, 
    -0.08459457f, 0.03177934f, -0.08438356f, 0.02983544f, -0.07262934f, 0.02548626f, 0.02575487f, -0.02833132f, 
    -0.07775740f, 0.06673853f, -0.07824089f, -0.01961543f, -0.07888867f, -0.04660099f, 0.02927542f, -0.10421401f, 
    -0.06465478f, -0.04542637f, -0.05890237f, -0.08207465f, -0.08497733f, 0.00165976f, 0.01241784f, 0.04865149f, 
    -0.04078176f, -0.12254528f, -0.06905031f, 0.00796386f, 0.02474371f, -0.01158982f, -0.06566853f, -0.09127213f, 
    -0.07923843f, 0.03049747f, -0.09179779f, 0.00171101f, -0.05622082f, -0.01943606f, -0.05472869f, -0.07276760f, 
    -0.09313329f, -0.01579195f, -0.09811823f, 0.00944569f, 0.01517324f, 0.04649531f, 0.00464767f, -0.05576195f, 
    0.03514110f, 0.03899739f, -0.06571186f, 0.00308818f, -0.08771452f, -0.10756681f, 0.02252202f, 0.03560318f, 
    -0.01171983f, -0.00234309f, 0.05667314f, -0.05247340f, -0.02327608f, -0.07287412f, -0.01558730f, -0.09835545f, 
    -0.03927398f, -0.09776368f, 0.00083772f, -0.02775844f, 0.01851437f, -0.05336161f, 0.02981636f, -0.04197938f, 
    0.03916414f, -0.06238108f, 0.02293681f, -0.07901862f, -0.10230111f, -0.10043582f, 0.01652526f, -0.04016472f, 
    -0.05746454f, -0.07380273f, 0.03896222f, 0.06916656f, -0.10499652f, 0.05642314f, 0.02588200f, -0.02435525f, 
    0.00257332f, -0.01782608f, -0.01778361f, 0.04145569f, -0.01306546f, -0.11699774f, -0.06424278f, -0.03611594f, 
    0.04384916f, -0.05289343f, 0.03771754f, -0.04407576f, -0.07073260f, -0.02743440f, -0.08494962f, -0.03476787f, 
    -0.01118299f, 0.09337085f, -0.05893454f, -0.00056843f, 0.35260478f, -0.05276294f, 0.05956751f, -0.24902916f, 
    -0.55541229f, 0.02081096f, -0.18010923f, -0.13970621f, 0.17135915f, 0.00472097f, 0.04243572f, -0.27825293f, 
    0.55509764f, -0.20915526f, 0.11344085f, 0.13381594f, 0.31361115f, 0.20204256f, 0.31016630f, 0.09380756f, 
    -0.09536196f, 0.01669962f, -0.13857298f, 0.12741399f, 0.38900653f, -0.13782790f, 0.10416670f, -0.29753757f, 
    0.01512937f, 0.18946473f, -0.06080113f, 0.01868350f, 0.07169734f, 0.33083698f, 0.00089587f, 0.28540507f, 
    -0.18697026f, -0.03653152f, -0.40725565f, 0.09338333f, 0.04725023f, 0.09679977f, -0.00033326f, 0.00700887f, 
    0.21042183f, -0.14022692f, 0.14313017f, -0.04173739f, 0.08597586f, 0.02001191f, -0.06517329f, -0.10105099f, 
    -0.11931279f, 0.11709921f, 0.11515180f, 0.05238509f, 0.00339109f, 0.13558213f, -0.00694137f, 0.04761977f, 
    0.04990857f, 0.06009832f, 0.05519607f, 0.07963328f, 0.08459009f, 0.01645880f, -0.02706483f, 0.04874905f, 
    -0.16857108f, 0.21599324f, 0.01808159f, 0.03633543f, 0.15117556f, -0.02902856f, 0.11657045f, 0.01560672f, 
    0.06838158f, -0.00781080f, -0.15079364f, -0.14051956f, 0.01490405f, 0.18419287f, 0.24727543f, 0.19937028f, 
    0.06703062f, 0.16632241f, 0.15728074f, 0.04872645f, 0.12993683f, -0.02402790f, -0.03591097f, -0.09517322f, 
    -0.06598048f, 0.01471411f, -0.13437557f, 0.38569310f, 0.02805834f, 0.11745058f, 0.06946280f, 0.09448465f, 
    -0.15702210f, -0.25094965f, 0.00801998f, -0.02994720f, 0.02932945f, 0.02925319f, 0.16525619f, 0.09486245f, 
    -0.07234085f, 0.03777111f, -0.10916878f, 0.04285662f, 0.06747352f, 0.36389810f, -0.14727394f, -0.18606138f, 
    0.01341795f, 0.09476282f, -0.17156629f, 0.00990290f, 0.07051848f, -0.50011057f, -0.09577334f, 0.13665524f, 
    -0.19980289f, -0.37575293f, 0.16837816f, -0.05684378f, 0.10305577f, -0.32020473f, 0.12736292f, -0.06683439f, 
    -0.02910881f, -0.01783617f, -0.03388183f, -0.31857970f, 0.25843745f, 0.10027831f, 0.00364101f, -0.63078594f, 
    0.50754017f, 0.14958887f, 0.28614822f, 0.11968239f, -0.19377677f, 0.12911461f, 0.08592857f, 0.17060012f, 
    -0.23267066f, -0.00867784f, -0.03688379f, -0.04193820f, 0.07727068f, 0.03958437f, -0.28125930f, -0.20058687f, 
    -0.11365303f, 0.35948727f, 0.22243930f, -0.02397363f, 0.36404231f, 0.02047874f, -0.02398524f, 0.22797973f, 
    -0.54215950f, -0.00162512f, 0.20193332f, 0.14056018f, 0.07514632f, -0.05032284f, -0.05034975f, -0.30345443f, 
    0.09596103f, -0.27123472f, 0.14038792f, -0.03057347f, -0.02984166f, -0.02045693f, -0.07839059f, 0.03551032f, 
    0.23363720f, -0.13974585f, 0.08362411f, 0.01039080f, 0.07871807f, 0.02715513f, 0.01097396f, -0.01956259f, 
    0.29975617f, 0.05462253f, 0.15644950f, -0.01414078f, 0.18709071f, 0.04711143f, 0.03621799f, -0.21289332f, 
    -0.34690577f, 0.14153613f, -0.21724209f, 0.26219872f, 0.18992054f, -0.04602239f, -0.15331843f, 0.01102487f, 
    -0.24061921f, -0.00329719f, -0.35852674f, -0.09477524f, 0.02296632f, 0.20597772f, -0.49784359f, 0.16710776f, 
    0.12592325f, 0.10074972f, 0.30752805f, 0.42804733f, 0.30319762f, 0.30051479f, -0.05522514f, 0.13955161f, 
    0.17313164f, -0.05848123f, -0.28349140f, -0.37518299f, 0.07350449f, 0.29550034f, 0.34902292f, 0.10548647f, 
    -0.00495819f, 0.38190114f, 0.03672836f, 0.05092997f, -0.02126674f, 0.11791171f, 0.12952349f, -0.28031892f, 
    0.09560724f, -0.18644954f, 0.23243751f, 0.10772979f, 0.06253386f, 0.11045734f, -0.20818414f, -0.38080898f, 
    -0.54424155f, -0.32431075f, -0.30834311f, -0.03913746f, 0.08270980f, 0.22592667f, 0.13255841f, -0.08811375f, 
    0.02415697f, 0.08249926f, -0.00474208f, -0.01022731f, -0.00921296f, 0.05831628f, 0.04490715f, -0.01901592f, 
    -0.08830932f, -0.10138651f, 0.04758768f, -0.01136192f, 0.00065059f, -0.05412282f, -0.04074554f, 0.00841940f, 
    -0.06427845f, -0.01524637f, -0.05593760f, -0.06698531f, -0.03844040f, -0.01448126f, -0.05835612f, -0.02465937f, 
    0.00469485f, -0.07406957f, -0.09063520f, 0.00511049f, 0.07435919f, 0.02289293f, -0.00115593f, 0.08013905f, 
    -0.04220269f, -0.02065750f, -0.04098721f, -0.00338503f, 0.02850507f, 0.02393721f, 0.07847666f, -0.00700360f, 
    0.01950139f, 0.02998357f, -0.07851738f, -0.05036094f, -0.01088271f, -0.06572483f, 0.05309167f, -0.03535591f, 
    -0.02805517f, -0.08226973f, 0.05257256f, -0.07816041f, 0.00853125f, -0.06554681f, 0.05028888f, -0.07655019f, 
    -0.03679033f, -0.03503253f, 0.02416989f, -0.01150828f, -0.10001849f, -0.06584522f, -0.02276349f, -0.01846274f, 
    -0.07860140f, -0.03543066f, -0.05271463f, 0.00980384f, 0.05618285f, 0.00148355f, 0.07005940f, -0.09431451f, 
    -0.00735965f, 0.03958170f, 0.00771963f, 0.05603308f, 0.02584234f, -0.10238204f, 0.06339481f, -0.01433969f, 
    -0.09713106f, -0.03750776f, -0.09958064f, 0.04227834f, -0.09834535f, -0.02942980f, -0.05215226f, 0.01053153f, 
    -0.00822900f, 0.04020037f, 0.04301720f, -0.03704830f, -0.01646551f, -0.08553565f, 0.05013326f, -0.07775043f, 
    0.05273854f, -0.03508767f, -0.07532860f, -0.00518511f, -0.09267408f, -0.06040276f, -0.08024243f, 0.05217183f, 
    -0.06783381f, 0.04766633f, -0.03215528f, -0.01668355f, 0.05148098f, 0.01083816f, 0.06184923f, -0.06775068f, 
    -0.06316171f, 0.01865237f, 0.03925747f, -0.03366864f, 0.01016473f, -0.07148214f, -0.05785168f, 0.05453436f, 
    0.03177016f, -0.01864936f, -0.06116722f, 0.03774277f, 0.07056951f, 0.05775523f, -0.06454864f, -0.01549187f, 
    -0.07567926f, -0.00244223f, 0.06680525f, -0.04870690f, -0.00951444f, -0.02246475f, -0.03315381f, 0.04535567f, 
    0.03892972f, 0.06124403f, -0.07242113f, 0.06298514f, -0.06355305f, 0.05554800f, 0.00079738f, -0.01758822f, 
    -0.04621795f, -0.00388049f, 0.08062911f, -0.03014157f, 0.02571216f, -0.08521026f, 0.05795446f, -0.04286467f, 
    0.04818014f, -0.01271498f, -0.07586709f, 0.02576253f, -0.05049205f, -0.04853460f, -0.07287052f, -0.05642389f, 
    -0.06602584f, -0.04731250f, -0.01630467f, 0.06853928f, 0.07891933f, -0.05891302f, 0.01555513f, 0.00593155f, 
    -0.03198340f, 0.07122745f, -0.05059366f, -0.08037941f, -0.03954667f, 0.00392943f, -0.02986333f, 0.08362249f, 
    0.04497076f, -0.06768284f, -0.02578977f, 0.03705204f, 0.01199301f, -0.06007484f, -0.06540012f, 0.00209171f, 
    -0.06963618f, -0.07751122f, 0.01430671f, 0.02756478f, -0.05722648f, 0.02907728f, -0.00909876f, 0.03100974f, 
    -0.00241821f, 0.04663164f, 0.04688480f, 0.00586494f, -0.05734891f, -0.06055571f, 0.06216484f, 0.07641484f, 
    0.06711326f, -0.08323468f, 0.02776132f, 0.05707816f, -0.03386093f, -0.04941622f, 0.07846327f, -0.07465401f, 
    -0.04442729f, -0.04841161f, -0.01216906f, 0.00245641f, -0.07088886f, -0.02518688f, 0.05332347f, -0.01498733f, 
    -0.03409987f, 0.01735006f, 0.07065802f, 0.06399798f, 0.08714570f, -0.04936593f, -0.05140476f, 0.01276316f, 
    -0.05855536f, 0.08625740f, -0.01965801f, 0.01475335f, -0.03010801f, 0.08606765f, -0.07169859f, -0.08004945f, 
    -0.04889382f, -0.02294866f, -0.01573920f, -0.07235146f, 0.06911857f, 0.03977288f, 0.04343357f, -0.03461633f, 
    0.01744749f, -0.08149755f, 0.07654114f, 0.03690331f, -0.07304881f, -0.06051056f, -0.06878699f, 0.05478121f, 
    0.06110652f, 0.03722170f, 0.01413163f, 0.04745239f, -0.01674384f, -0.05853093f, -0.07435910f, 0.01572498f, 
    0.16808583f, -0.05261622f, 0.15678346f, 0.32297564f, 0.06194502f, 0.45011020f, 0.20651549f, -0.03670879f, 
    -0.45006672f, 0.34982204f, 0.05076857f, 0.24178462f, -0.09359290f, -0.09244830f, -0.05951250f, 0.19011213f, 
    -0.13555442f, 0.05995791f, -0.02515120f, 0.08390997f, -0.11375194f, -0.17463624f, -0.31959933f, 0.02873114f, 
    0.08687633f, 0.21841985f, 0.26169240f, 0.22863497f, -0.70564532f, -0.48253423f, 0.19036494f, -0.30240151f, 
    -0.15679139f, -0.12903868f, 0.01053526f, -0.37148160f, -0.05651588f, 0.11317073f, 0.01157345f, -0.02636420f, 
    0.00833645f, 0.00928862f, -0.33143103f, 0.21421482f, -0.02377762f, -0.01604602f, 0.29055253f, -0.04456005f, 
    -0.12931390f, 0.10608508f, -0.01341712f, 0.17921515f, -0.05506825f, 0.20753160f, 0.14245553f, -0.18150571f, 
    -0.16475552f, 0.32243851f, -0.18523426f, 0.17920831f, 0.06651397f, -0.25486261f, 0.04346702f, -0.00794417f, 
    -0.00193181f, 0.10428255f, -0.16777122f, 0.02857151f, 0.11168932f, 0.23310024f, -0.35308951f, 0.03160658f, 
    0.21232766f, -0.03661530f, -0.10788269f, 0.07998040f, 0.14436513f, 0.09617431f, 0.14843702f, 0.33625728f, 
    -0.21558365f, 0.39648327f, 0.06009813f, 0.15481271f, 0.22247136f, -0.12343125f, -0.00619072f, -0.05763849f, 
    0.25404903f, 0.01881210f, 0.14273408f, -0.53339624f, -0.07242187f, -0.30954301f, 0.12837149f, -0.32803252f, 
    0.10363220f, 0.18504572f, -0.16779067f, -0.16591932f, 0.16628391f, 0.03596789f, -0.18133615f, -0.18191274f, 
    0.09102088f, 0.22157893f, 0.04721830f, -0.22985280f, 0.07777163f, -0.08297490f, 0.19984525f, 0.01064926f, 
    -0.20593250f, 0.14811347f, -0.22350214f, -0.07513845f, 0.18452144f, -0.09109662f, 0.14558929f, -0.01677102f, 
    0.38748068f, 0.35480830f, 0.42525151f, 0.03193573f, 0.00999123f, 0.05758310f, 0.07170130f, 0.28599826f, 
    0.17032962f, -0.30100673f, -0.22560321f, -0.00080236f, -0.14764379f, -0.13651270f, -0.04694277f, -0.13662164f, 
    0.44674721f, -0.04159835f, 0.26455459f, 0.03577831f, 0.04462485f, 0.17636023f, 0.04350384f, 0.93442130f, 
    -0.48513862f, -0.02016163f, 0.07971666f, 0.21304063f, 0.22865871f, 0.04862519f, 0.17126903f, -0.27005836f, 
    0.01113762f, -0.18393958f, -0.13379508f, -0.16779484f, -0.10190780f, 0.00220114f, 0.06103352f, 0.12652145f, 
    0.15392965f, 0.08129003f, 0.06807043f, 0.15656686f, -0.13587379f, -0.13879463f, -0.15399534f, -0.07183453f, 
    -0.03229700f, -0.02749373f, 0.09895951f, -0.06084114f, 0.04294077f, -0.05548498f, -0.09103171f, -0.20868616f, 
    -0.06817183f, 0.31416795f, -0.06580932f, -0.11536645f, 0.18284021f, -0.17901906f, 0.37177843f, 0.20665550f, 
    0.06151395f, -0.03928005f, 0.25233236f, 0.22307941f, 0.34105080f, 0.34697559f, -0.01194101f, -0.19923221f, 
    0.22813979f, -0.07231962f, 0.07518611f, 0.08617096f, 0.05978657f, 0.14527506f, -0.04373641f, -0.19928303f, 
    -0.01101914f, -0.06133432f, 0.11997295f, 0.06589194f, -0.05634111f, -0.36008847f, 0.01017342f, 0.04153271f, 
    -0.10858986f, -0.20949794f, -0.05630072f, 0.56689352f, -0.12545852f, -0.01286041f, 0.08608934f, 0.06525803f, 
    0.00386507f, -0.06622465f, -0.03963534f, 0.06309753f, 0.12363902f, -0.25863683f, -0.10284327f, 0.01475881f, 
    0.12139828f, 0.18161707f, 0.06853972f, 0.40434271f, -0.13767457f, 0.18379405f, -0.05148783f, 0.18764378f, 
    -0.14438272f, -0.10778578f, 0.09235377f, 0.50411689f, 0.12439826f, 0.04087263f, -0.07802643f, -0.13575958f, 
    -0.49093759f, 0.11537378f, -0.11353705f, 0.03720563f, -0.02111644f, -0.00099943f, 0.04263387f, -0.04974137f, 
    -0.07119977f, 0.22702411f, -0.03821667f, 0.08487478f, 0.04861233f, 0.08900973f, 0.06548612f, -0.05577043f, 
    -0.42947468f, 0.25613314f, 0.28693941f, -0.12044163f, 0.27627617f, -0.45000991f, -0.11492065f, 0.51828682f, 
    -0.45049539f, -0.02818796f, -0.31430215f, -0.19729432f, -0.06222643f, -0.00576577f, 0.09924538f, -0.30668250f, 
    0.31523588f, 0.10044027f, -0.12850969f, -0.19288288f, -0.29646853f, 0.03183923f, 0.03169584f, 0.25434387f, 
    -0.74069732f, 0.02132733f, -0.04048976f, 0.01063529f, 0.10793038f, 0.12593746f, -0.08482199f, 0.42377678f, 
    0.10335702f, -0.03116067f, -0.00407217f, -0.02445509f, 0.33988547f, 0.30177832f, 0.09317631f, 0.14485702f, 
    0.15752167f, 0.02006373f, -0.10488035f, -0.04792500f, -0.04291626f, 0.04920415f, -0.28414997f, 0.49369392f, 
    0.07500247f, -0.51430577f, 0.26613292f, 0.05048342f, -0.30056930f, 0.16088074f, -0.37036765f, -0.05385385f, 
    0.14824419f, -0.07884801f, 0.41455045f, -0.33721709f, -0.56166238f, 0.02999659f, -0.42664868f, 0.41439915f, 
    -0.03986079f, -0.07283120f, 0.14113259f, -0.23601627f, -0.30610228f, -0.10663847f, -0.47332916f, 0.29054049f, 
    -0.36704373f, 0.32168469f, 0.16624343f, -0.13546568f, -0.01671792f, 0.18827267f, 0.10721114f, -0.15348125f, 
    0.03793289f, -0.09014983f, 0.09212999f, -0.88560343f, 0.15222207f, -0.01336513f, -0.24466980f, -0.13582292f, 
    0.12212776f, 0.22913568f, 0.09255542f, -0.47806498f, 0.03001116f, 0.44323590f, 0.05390751f, 0.20632917f, 
    -0.25519207f, -0.33797607f, 0.05879195f, 0.07866550f, 0.05505808f, 0.07943757f, 0.34781516f, -0.40473408f, 
    0.09840274f, 0.19542399f, 0.01032941f, -0.61074919f, -0.04633115f, 0.00820064f, -0.07713272f, -0.31340903f, 
    0.39787009f, -0.41084123f, -0.27263933f, 0.04813552f, 0.01132979f, 0.11227205f, -0.51572323f, 0.37204993f, 
    -0.35400537f, -0.54048640f, -0.14714667f, -0.10620626f, 0.22230937f, -0.32232720f, 0.07781722f, 0.07363319f, 
    -0.05764979f, 0.25129136f, 0.13729186f, -0.04752672f, -0.26191178f, 0.42573789f, -0.08372380f, 0.18906793f, 
    0.02290615f, 0.05938204f, 0.16188672f, 0.11800802f, -0.08866548f, 0.28037581f, 0.13865332f, -0.41311517f, 
    -0.24171750f, -0.09534137f, -0.20066942f, 0.12888911f, -0.21735609f, 0.08416529f, 0.16470723f, -0.08221547f, 
    0.13103826f, -0.04630368f, -0.13029800f, -0.11603946f, -0.27383631f, 0.23533294f, 0.00484379f, 0.51403868f, 
    0.24470723f, 0.09805667f, 0.04301479f, 0.12519301f, 0.05086529f, 0.14202331f, 0.20109536f, -0.13207754f, 
    0.21794811f, -0.04018016f, 0.17752285f, -0.11332999f, 0.02514836f, -0.00408741f, -0.08332632f, 0.16937171f, 
    0.19673522f, 0.17057833f, -0.09607286f, -0.09344903f, -0.12042633f, -0.10189743f, -0.08765270f, -0.15408203f, 
    -0.13824289f, -0.09059231f, 0.15627809f, 0.02801299f, -0.01534534f, -0.09086506f, -0.00578654f, 0.09531103f, 
    0.01574659f, 0.03686238f, -0.02323213f, 0.13804753f, -0.12591004f, -0.10414347f, -0.25596797f, 0.05353113f, 
    0.14989382f, -0.04397458f, 0.39329001f, -0.25107047f, -0.01687117f, 0.21194740f, -0.08560336f, -0.26892513f, 
    0.13702692f, -0.23286422f, 0.32608855f, -0.02071398f, -0.16426834f, 0.06764044f, -0.00948798f, -0.26196834f, 
    -0.21584658f, -0.11940107f, -0.15685105f, 0.18847823f, 0.01103648f, 0.09786317f, 0.21425396f, -0.25163415f, 
    0.16143794f, -0.06239191f, 0.17605937f, -0.07121710f, 0.04506737f, 0.05351101f, -0.28209844f, 0.24051741f, 
    0.05265016f, -0.20163535f, 0.05482120f, 0.07971352f, -0.05908724f, 0.05684549f, -0.02488163f, 0.16639300f, 
    -0.33865255f, 0.06518922f, -0.01228429f, -0.06084238f, 0.03013537f, -0.08021504f, 0.11425262f, 0.16339107f, 
    0.34588599f, -0.06525732f, -0.07112830f, 0.16888238f, 0.04758813f, 0.00893949f, -0.27552578f, -0.00454985f, 
    -0.01917881f, 0.06622203f, 0.06489427f, -0.03392247f, -0.05872950f, 0.16958325f, -0.00409156f, 0.12768517f, 
    0.04853986f, 0.02509448f, 0.11681123f, 0.33869258f, -0.09074332f, 0.10499614f, 0.10425200f, 0.27189150f, 
    0.24411966f, -0.14654000f, -0.12263859f, 0.20241994f, -0.13449976f, -0.02779998f, 0.19648951f, -0.12885351f, 
    0.08155888f, -0.08124973f, -0.08047277f, -0.04622912f, -0.57789123f, 0.25040877f, 0.20947094f, 0.55984384f, 
    0.14791329f, -0.01779653f, -0.01364931f, -0.01351279f, -0.02583364f, -0.06529780f, 0.10618668f, -0.07519740f, 
    0.37020412f, 0.07692973f, 0.23692426f, -0.14279811f, -0.02528860f, 0.03518769f, -0.11993784f, -0.02457437f, 
    0.05025558f, 0.27788737f, -0.24830063f, 0.07347990f, 0.00637433f, -0.13764833f, 0.02468894f, -0.10222883f, 
    -0.07963474f, 0.00425022f, 0.15678933f, 0.17727520f, -0.02322046f, -0.09240495f, -0.09899868f, 0.01508998f, 
    0.04348560f, -0.04824818f, 0.07991585f, 0.19231966f, -0.07835399f, -0.07142114f, -0.26704234f, 0.10883234f, 
    0.14966452f, 0.12502933f, 0.29279050f, -0.08217841f, 0.06486329f, -0.16012904f, 0.28296003f, -0.02239735f, 
    0.07653812f, -0.01633228f, -0.02664284f, 0.40473351f, -0.02674672f, 0.16571163f, 0.18509442f, 0.06270344f, 
    -0.08932742f, 0.03142207f, -0.04324706f, 0.21055657f, 0.06012567f, -0.15468012f, -0.11701879f, -0.21940139f, 
    0.09743275f, -0.03066644f, -0.11709765f, 0.44695804f, 0.07470833f, 0.25989336f, -0.09008902f, 0.17417645f, 
    -0.18305594f, -0.01694229f, 0.08164771f, 0.17396221f, -0.00517666f, 0.12381869f, -0.11485257f, -0.05589885f, 
    -0.35397944f, 0.05995048f, -0.26832277f, 0.02815282f, 0.03527477f, -0.01621985f, -0.04073196f, 0.12613066f, 
    0.15504128f, 0.03489036f, 0.04585231f, 0.16463970f, 0.09507696f, 0.02639698f, -0.09839839f, 0.12220328f, 
    0.01266030f, 0.16902587f, 0.16900544f, 0.01228599f, 0.31738380f, 0.31868526f, -0.16516921f, -0.06772470f, 
    -0.03717590f, -0.06704151f, -0.27120519f, -0.21210819f, 0.02642250f, 0.04601025f, 0.12322726f, -0.16562487f, 
    0.53498471f, 0.06542604f, 0.07653853f, 0.07560980f, -0.34467113f, -0.18645738f, -0.09051530f, 0.36460018f, 
    -0.38395986f, -0.05052241f, -0.08389574f, 0.03900440f, 0.17222457f, 0.39097360f, -0.09792510f, -0.23792228f, 
    -0.43998268f, -0.29928118f, 0.19019930f, -0.06830770f, 0.44559887f, -0.04235413f, -0.17080815f, 0.17644762f, 
    -0.10073031f, -0.00913139f, 0.39984688f, 0.04015975f, -0.05518774f, -0.04099989f, -0.00632167f, 0.27706358f, 
    0.18980019f, -0.12019037f, -0.01234462f, 0.21312039f, -0.06462440f, 0.06361759f, -0.27466482f, 0.02130405f, 
    0.09142335f, 0.20954834f, -0.09267033f, -0.09460476f, -0.42325008f, -0.06656914f, 0.18538447f, 0.14798322f, 
    -0.01759895f, 0.09136496f, 0.22055595f, -0.05263819f, -0.17061384f, -0.03900377f, 0.57612455f, -0.00751527f, 
    -0.07753989f, 0.26759809f, -0.01587001f, -0.16683219f, 0.32055947f, 0.28895846f, 0.14793193f, 0.25078982f, 
    -0.05841073f, -0.20351839f, -0.09578204f, -0.53637934f, 0.19042104f, 0.07172012f, 0.03698342f, -0.01622148f, 
    -0.26515707f, 0.27374876f, 0.22900490f, 0.32401234f, 0.14782754f, 0.24335840f, -0.07384275f, -0.01744098f, 
    -0.16652736f, -0.24580202f, -0.15481789f, -0.30090418f, 0.38536662f, 0.11521100f, 0.17697099f, -0.06722053f, 
    -0.19473140f, 0.04764936f, 0.05799909f, -0.41205558f, 0.13248447f, 0.21975236f, 0.22178034f, -0.04034074f, 
    0.63987184f, -0.25409308f, 0.28407311f, 0.04329916f, 0.00824052f, 0.09773614f, -0.26578060f, -0.26103312f, 
    -0.45917168f, -0.26224431f, -0.17299032f, -0.02072705f, 0.13820718f, -0.10141993f, 0.18164773f, 0.06271093f, 
    0.06084117f, -0.11159495f, 0.03361513f, -0.06805770f, 0.06370176f, 0.01342857f, -0.06537984f, 0.03650922f, 
    0.06003929f, 0.07834724f, 0.03509512f, -0.04302318f, -0.04129608f, 0.01171115f, -0.04672983f, -0.02732535f, 
    -0.00772656f, -0.05703184f, -0.09387037f, -0.02453328f, 0.01467547f, 0.06400246f, -0.05631197f, 0.03733671f, 
    -0.06100625f, -0.07933000f, -0.05502624f, 0.07097759f, 0.04940534f, -0.09987424f, -0.04612743f, -0.06885840f, 
    -0.07830292f, -0.05257091f, 0.01433426f, -0.07151033f, 0.06304500f, 0.02340343f, -0.09923422f, 0.04197726f, 
    0.05188245f, -0.02037615f, -0.05507821f, -0.01953831f, -0.05821489f, 0.04582684f, -0.02154717f, -0.00399281f, 
    0.00170492f, -0.08841135f, 0.04891518f, 0.02200249f, -0.00456499f, -0.05380474f, -0.09478728f, -0.00443796f, 
    -0.08799567f, 0.00520315f, -0.07270635f, -0.02813697f, 0.00018673f, -0.01192741f, -0.08101770f, -0.09571470f, 
    0.01556254f, -0.06001249f, -0.07705474f, 0.00080845f, -0.01913184f, -0.00326458f, -0.07288427f, -0.06575649f, 
    0.03780744f, -0.07695080f, 0.07862098f, -0.09211020f, -0.00712009f, 0.06815019f, -0.07412774f, 0.04353027f, 
    0.05545990f, -0.02066590f, 0.03239474f, -0.09382796f, -0.02633900f, -0.09922912f, -0.08789114f, -0.04859107f, 
    -0.11799910f, 0.05462473f, -0.08972406f, 0.03413752f, 0.01826158f, -0.07080849f, -0.04638302f, 0.03473102f, 
    0.03111950f, -0.02783756f, -0.05231006f, -0.06121081f, -0.01408653f, 0.01619404f, -0.04307343f, 0.05475298f, 
    -0.06212298f, 0.04141111f, 0.05959045f, 0.05331130f, 0.00330639f, 0.03708059f, -0.08115090f, -0.08926374f, 
    0.06737319f, 0.04993448f, -0.00948983f, 0.02330911f, 0.00857076f, -0.04417707f, -0.06282481f, 0.06464472f, 
    -0.05135386f, 0.05606024f, -0.01438639f, -0.02341860f, -0.05013509f, 0.01198284f, -0.01778371f, -0.07667286f, 
    0.02344200f, -0.27049619f, 0.01399580f, 0.05592849f, 0.18338080f, 0.05808187f, -0.16457665f, -0.46954766f, 
    0.12474407f, 0.11333477f, 0.05987022f, -0.01979596f, 0.06413932f, 0.01886683f, -0.11897569f, 0.87298590f, 
    -0.20592104f, -0.22549033f, 0.15719953f, 0.05124622f, 0.24107914f, -0.01141664f, 0.11763639f, -0.21962789f, 
    0.12355729f, 0.04642331f, -0.08512390f, 0.10208259f, -0.38475907f, -0.15842925f, 0.16821559f, 0.22689432f, 
    0.19911075f, 0.02207967f, -0.04409929f, -0.11280693f, -0.07015441f, -0.06700305f, -0.22978488f, 0.10180310f, 
    -0.09032034f, -0.02788795f, -0.73004436f, 0.08393929f, -0.06285843f, -0.07314608f, 0.01534429f, 0.42245185f, 
    -0.20389655f, -0.00786758f, -0.24295743f, -0.00815354f, 0.25264388f, 0.11300458f, 0.11950004f, -0.03128133f, 
    -0.04044718f, 0.00380290f, 0.00394649f, -0.01540430f, 0.33093041f, -0.02423803f, 0.08594075f, -0.20151187f, 
    0.10873450f, -0.03345528f, 0.16962798f, 0.19573224f, 0.12394382f, 0.18170641f, -0.15476912f, -0.03248432f, 
    0.03773870f, 0.02978633f, -0.04316134f, 0.03384997f, 0.05769868f, -0.24529059f, 0.09444676f, 0.07687083f, 
    0.05746800f, 0.09323042f, -0.21595116f, 0.61834145f, 0.16874987f, 0.15854163f, 0.50009376f, 0.18178713f, 
    -0.11069012f, 0.23143916f, 0.02065420f, -0.23043083f, 0.10371497f, -0.18628907f, -0.06022966f, -0.08331629f, 
    -0.07585163f, 0.22433226f, -0.21877204f, 0.40428388f, -0.04482406f, 0.07238235f, -0.01900137f, 0.03101783f, 
    -0.19663525f, -0.10230602f, 0.08505372f, 0.21043269f, -0.00527164f, 0.05346595f, 0.02789483f, -0.15142263f, 
    0.23592049f, 0.14413720f, -0.01063303f, 0.05089555f, 0.08022229f, 0.14479339f, 0.00692516f, 0.00873859f, 
    0.78359824f, 0.16658080f, 0.08537108f, 0.06211427f, -0.05328267f, -0.32240734f, -0.13841228f, -0.03066255f, 
    -0.00832190f, 0.14307182f, -0.04515880f, 0.22271143f, -0.06465538f, -0.18177953f, 0.01145082f, -0.08233997f, 
    -0.22134927f, 0.14955337f, 0.12053476f, 0.22504216f, -0.02047765f, 0.11057639f, 0.07283346f, 0.10185166f, 
    -0.12750991f, -0.14080587f, -0.17968006f, -0.04379118f, -0.27798522f, -0.16247770f, -0.01333449f, -0.27848506f, 
    0.21083455f, 0.30812719f, 0.26413727f, 0.12069280f, -0.62173474f, -0.02838525f, 0.13348265f, -0.12922901f, 
    -0.21639757f, -0.35142729f, -0.11840681f, 0.37117255f, -0.09804696f, 0.07948587f, -0.24662952f, -0.05154096f, 
    0.20955312f, -0.03837955f, -0.01581066f, -0.01138178f, -0.05002354f, 0.05649164f, 0.25138062f, 0.20819898f, 
    -0.03969594f, 0.29325339f, -0.06828432f, 0.10809990f, -0.01717290f, 0.10490321f, 0.08311108f, -0.14185278f, 
    -0.16619055f, 0.26490921f, -0.12242094f, 0.08546323f, -0.11725049f, -0.29818383f, 0.39401931f, -0.09360905f, 
    -0.12929119f, -0.12486807f, 0.10452278f, 0.23518820f, -0.05735934f, 0.10802051f, -0.34696218f, 0.25804555f, 
    0.33657560f, 0.25049287f, -0.13351931f, -0.18373784f, -0.10119659f, 0.10563751f, 0.22862484f, 0.41407347f, 
    0.28987151f, 0.11751164f, 0.06369275f, 0.22592695f, 0.07227167f, 0.10458139f, 0.16602395f, 0.08215526f, 
    -0.08248571f, 0.09158946f, -0.03231633f, -0.26909503f, -0.14940001f, -0.06834761f, -0.00753920f, -0.18848617f, 
    0.04744200f, 0.06980696f, 0.20249885f, 0.34240559f, 0.07411659f, -0.03204241f, -0.31347066f, 0.06040912f, 
    -0.04107467f, -0.00510093f, 0.05974715f, 0.03179701f, 0.13379189f, 0.07996133f, 0.12145095f, 0.29383928f, 
    -0.19898458f, 0.03212767f, -0.12938145f, -0.07083181f, 0.12079777f, 0.13753024f, 0.01676409f, 0.28914720f, 
    -0.16924956f, 0.37097964f, 0.24107972f, -0.07187656f, 0.03261359f, -0.23039992f, -0.10425819f, 0.19340543f, 
    0.21449986f, 0.18131249f, 0.25842333f, -0.16803953f, 0.02617825f, 0.07771580f, -0.32119805f, -0.37871131f, 
    0.02727640f, -0.15257084f, -0.02675259f, -0.04033201f, -0.21948014f, -0.16878539f, 0.22088155f, -0.27235562f, 
    0.05315223f, 0.07592160f, -0.05049648f, 0.12526278f, -0.24376178f, 0.14592446f, -0.02639165f, 0.21776637f, 
    -0.12991492f, -0.06115672f, 0.30068591f, 0.03233065f, 0.50641447f, 0.23626575f, 0.41303194f, -0.05378211f, 
    0.27359623f, -0.59043467f, 0.09473234f, -0.22172609f, -0.01345003f, -0.25182906f, 0.34793293f, -0.11782353f, 
    0.26186809f, -0.07485934f, -0.13104211f, 0.08387979f, 0.06348912f, 0.04901492f, -0.20529194f, 0.43274140f, 
    -0.25500843f, 0.03504625f, 0.16194233f, 0.17649136f, 0.00767980f, -0.07884279f, -0.01416837f, 0.03501661f, 
    0.05864666f, 0.27990508f, -0.21736665f, -0.02568846f, 0.01470568f, 0.47221205f, -0.16175745f, -0.12106590f, 
    -0.29441878f, 0.25212908f, -0.11266543f, 0.03042961f, -0.03909447f, -0.15438406f, -0.18949901f, 0.04442516f, 
    0.04694900f, -0.22270383f, 0.09877332f, -0.21494785f, -0.05463892f, -0.19101951f, 0.25521097f, 0.10037904f, 
    0.08600190f, 0.10916340f, -0.08570386f, 0.16395040f, 0.18451877f, -0.01510413f, -0.36958671f, 0.01643459f, 
    -0.00882042f, -0.00053461f, -0.20620789f, 0.02722165f, 0.11191989f, -0.00821665f, -0.23560879f, -0.01948333f, 
    -0.07227404f, -0.01260262f, 0.08491441f, 0.16373673f, 0.17484659f, -0.06737016f, -0.16671214f, -0.08081307f, 
    -0.42118359f, -0.55235338f, -0.15955529f, -0.18917479f, -0.16459371f, 0.02764291f, -0.03669845f, 0.05489119f, 
    0.09905734f, 0.08687729f, -0.08071031f, 0.05689729f, 0.00255042f, 0.22076748f, 0.01880695f, 0.06880615f, 
    -0.01005450f, -0.16223948f, -0.04265933f, 0.26329672f, 0.24910180f, -0.22815758f, 0.21838957f, 0.36284634f, 
    0.04529893f, 0.01074355f, -0.15324666f, 0.03952216f, -0.18238541f, -0.22996306f, 0.13957699f, 0.23543136f, 
    0.37429470f, -0.08876163f, 0.26845396f, 0.13261811f, -0.08242416f, 0.10601203f, 0.03252881f, 0.56945401f, 
    -0.64714211f, 0.16966909f, -0.04183712f, -0.25163862f, -0.05828338f, -0.04209731f, -0.02848995f, -0.16746062f, 
    0.03321094f, 0.06223831f, 0.17542657f, -0.07861383f, -0.17159915f, -0.01722926f, 0.17170364f, 0.17453609f, 
    0.20060335f, 0.11871287f, -0.07709511f, 0.07858282f, -0.09158880f, 0.00730099f, -0.00627988f, -0.16792169f, 
    0.29105005f, 0.06060303f, 0.02005549f, -0.08978257f, 0.05706283f, -0.07541931f, 0.06530966f, -0.15695566f, 
    -0.00066917f, 0.34839827f, 0.07441965f, -0.01810629f, -0.02708845f, -0.01944177f, 0.46225655f, 0.13816816f, 
    0.09979598f, -0.09247963f, 0.36855364f, 0.00675479f, 0.21175708f, -0.15298817f, 0.00507033f, 0.01706469f, 
    0.21282288f, -0.16890390f, -0.02251835f, 0.00298636f, -0.13296343f, -0.13905175f, 0.13594970f, 0.16044912f, 
    0.09353644f, -0.06028648f, -0.00973966f, -0.02147490f, -0.21130115f, -0.00207340f, 0.08504449f, -0.09962714f, 
    0.29694763f, -0.12468441f, 0.23484011f, 0.23498702f, -0.08824273f, -0.08799529f, 0.43760312f, -0.15263753f, 
    0.23585348f, -0.06727900f, -0.01391627f, 0.02697769f, 0.04134104f, 0.12821589f, 0.14670405f, 0.27536044f, 
    0.06331617f, 0.16213156f, 0.35752609f, -0.01275639f, -0.29431441f, 0.09127172f, -0.01448818f, 0.10932498f, 
    0.00609003f, -0.03572168f, -0.01466084f, 0.31782451f, 0.15024075f, 0.01299620f, -0.18383163f, 0.10312908f, 
    -0.56121367f, -0.07138292f, 0.09281392f, -0.06018352f, 0.04290970f, -0.19663364f, 0.21404575f, 0.37916473f, 
    0.21107583f, -0.07013316f, 0.12002569f, -0.16356371f, -0.10395224f, 0.23794733f, 0.28008348f, 0.03779970f, 
    -0.01418967f, -0.22240219f, 0.09400584f, 0.13943626f, 0.09806986f, -0.00192325f, 0.14348914f, -0.02445787f, 
    -0.04986572f, 0.14795530f, -0.18231700f, 0.03197271f, 0.17833699f, -0.05460254f, -0.16981865f, -0.39625251f, 
    -0.36462647f, -0.01332616f, 0.25572675f, 0.25077680f, 0.21879725f, 0.00906011f, -0.25763837f, 0.23761712f, 
    -0.17111608f, 0.07865066f, 0.09707907f, 0.24035943f, 0.37107408f, -0.33187044f, -0.06785138f, -0.77742738f, 
    -0.11218273f, 0.15291192f, 0.24496968f, -0.43543571f, 0.08617428f, -0.08413212f, 0.09828221f, -0.12751894f, 
    -0.16506378f, 0.07579494f, -0.30180767f, 0.09942076f, 0.06114560f, 0.05064682f, 0.20164767f, -0.62830061f, 
    -0.06190974f, -0.00054191f, 0.15980533f, 0.08762968f, -0.11695881f, 0.19451742f, 0.03488423f, 0.15115605f, 
    0.36381871f, 0.07864802f, 0.01826778f, 0.16614962f, 0.08945504f, 0.22191226f, 0.03454038f, -0.20219690f, 
    -0.03373536f, 0.21190245f, -0.27043745f, -0.24707597f, 0.12869120f, 0.21032034f, 0.34136328f, -0.12479793f, 
    -0.03553266f, -0.19030438f, -0.17303737f, 0.16305260f, 0.28826186f, 0.10364003f, -0.00970501f, 0.01931102f, 
    -0.03962562f, 0.35779327f, -0.06590323f, -0.08837640f, -0.14592907f, -0.07441406f, -0.51756656f, 0.21638989f, 
    0.10487554f, -0.05010926f, 0.16350400f, -0.07315801f, 0.11800624f, -0.02580003f, 0.10086615f, 0.23896512f, 
    -0.01610274f, 0.18056388f, -0.07524592f, -0.23742780f, 0.17242861f, -0.11921630f, 0.13210239f, -0.13225989f, 
    0.24795923f, 0.14449990f, -0.01460817f, -0.34859025f, -0.02449947f, 0.01741335f, 0.11953705f, -0.17604418f, 
    0.14286281f, -0.04750714f, 0.01868417f, -0.03699665f, 0.11385651f, -0.07111852f, 0.13141371f, -0.10616844f, 
    0.00555638f, 0.05939267f, -0.05098493f, -0.23101164f, 0.05975164f, -0.25242397f, 0.35056895f, 0.05004747f, 
    -0.39496166f, -0.03614700f, 0.22877516f, 0.14809647f, 0.32963404f, -0.52428824f, 0.19619380f, 0.14536552f, 
    -0.45382360f, 0.19495761f, -0.81993651f, -0.28143263f, 0.22125825f, -0.02348400f, 0.00491541f, -0.23392940f, 
    0.06016710f, -0.28488448f, 0.13025169f, 0.22209556f, -0.24799177f, -0.04305870f, -0.07917520f, 0.07874651f, 
    -0.11612478f, 0.27376816f, -0.30102175f, 0.32474682f, 0.09323297f, 0.30306706f, 0.06052516f, -0.05147187f, 
    -0.18268926f, -0.20606731f, -0.04365199f, 0.09499562f, 0.06200283f, 0.02124669f, -0.17991079f, 0.19963956f, 
    -0.20245084f, 0.02336550f, 0.32675803f, 0.02085645f, 0.03727303f, -0.01348162f, 0.08833367f, -0.01521338f, 
    0.11206812f, -0.29852095f, 0.13226284f, 0.03389830f, -0.15250476f, 0.20060013f, -0.36057630f, 0.02962971f, 
    0.04907290f, 0.17143844f, 0.03418091f, 0.21282411f, -0.67271072f, 0.25944349f, 0.14657147f, 0.07905714f, 
    0.01818824f, -0.18367673f, 0.09005204f, -0.03675492f, -0.02286544f, 0.03180718f, -0.05443716f, 0.01359456f, 
    -0.40608215f, -0.02031536f, 0.23079528f, 0.10932826f, 0.19521968f, -0.05368935f, -0.12218240f, 0.27107567f, 
    -0.16512379f, 0.18923220f, -0.54255998f, -0.24364582f, 0.09868325f, 0.14558809f, -0.50570375f, 0.27567291f, 
    -0.19435656f, 0.13668565f, 0.05743390f, -0.04971094f, 0.13158421f, 0.02212279f, -0.01906260f, -0.17243114f, 
    0.04495192f, 0.13066038f, -0.05055065f, -0.14697956f, -0.24087605f, -0.10274568f, -0.04790337f, 0.16882943f, 
    0.10561575f, 0.37183902f, 0.07429972f, -0.16831627f, -0.26637638f, 0.08730863f, 0.19062279f, -0.09493052f, 
    -0.02482441f, -0.53598398f, -0.81543589f, -0.02923243f, 0.12143635f, 0.16114004f, -0.62967396f, -0.06168745f, 
    -0.56786972f, -0.38470444f, -0.64215881f, -0.42268851f, -0.14854959f, -0.08515438f, -0.23752451f, 0.11032294f, 
    -0.21968235f, 0.20674628f, -0.07954055f, -0.02365305f, 0.05286236f, -0.28569341f, 0.06237338f, 0.23130058f, 
    -0.02929484f, -0.42312613f, -0.31173930f, -0.16131712f, -0.22855116f, 0.31864083f, 0.23276092f, -0.45247009f, 
    -0.04940733f, -0.37922236f, -0.18021356f, 0.08391335f, 0.00793438f, 0.09935284f, 0.00073595f, 0.10353121f, 
    -0.44830087f, -0.16837050f, 0.09700537f, -0.21439822f, 0.64987940f, 0.04374637f, 0.15946242f, -0.39710656f, 
    0.24202958f, 0.26516616f, -0.32394239f, 0.20714869f, -0.04476588f, 0.00971621f, 0.11950402f, -0.28922588f, 
    0.32004035f, -0.08110301f, 0.51609039f, -0.31592363f, -0.01996261f, -0.05707261f, -0.17355168f, -0.26659751f, 
    0.06973378f, 0.08358430f, 0.11212333f, 0.19753323f, -0.15100534f, -0.59520108f, 0.27085906f, -0.00440761f, 
    0.19276497f, 0.17260921f, 0.36729366f, 0.05398395f, -0.00819084f, 0.28759092f, 0.06888364f, -0.28763732f, 
    -0.03922878f, 0.11292573f, -0.23930095f, -0.00367820f, -0.25680903f, -0.23593354f, 0.59987324f, 0.17211230f, 
    -0.06212812f, -0.15236744f, 0.15311454f, -0.07110947f, -0.16913898f, 0.31425503f, 0.17692411f, -0.30416131f, 
    0.50191122f, -0.07545870f, 0.11956078f, -0.08019824f, -0.50365806f, -0.04668796f, -0.56089568f, -0.41039360f, 
    -0.14275388f, -0.57901466f, 0.04835492f, 0.08658672f, -0.12756194f, 0.24433298f, 0.11728061f, -0.00569569f, 
    0.04946496f, -0.32705081f, 0.54051930f, 0.00777919f, 0.22445275f, -0.05589911f, 0.13619885f, 0.17326771f, 
    0.05622491f, -0.17758366f, -0.01981547f, -0.02746693f, -0.08699970f, 0.01587375f, -0.24055974f, 0.21294050f, 
    -0.67732996f, -0.06164760f, 0.06733925f, -0.06304747f, 0.00220946f, -0.10663777f, 0.11003512f, 0.31087387f, 
    -0.54034847f, 0.12721834f, -0.25885436f, -0.02182469f, 0.16017501f, 0.91677642f, -0.61320007f, 0.23425122f, 
    0.01501221f, -0.06345208f, -0.02354911f, 0.02366495f, -0.11763195f, -0.02581195f, 0.03235635f, -0.08637355f, 
    0.15879598f, 0.01117370f, 0.12266773f, -0.23982152f, 0.21760011f, -0.10794460f, 0.14397103f, -0.50381225f, 
    0.52124643f, 0.22928986f, 0.06638090f, -0.16197550f, -0.02140937f, 0.02439814f, 0.00139454f, 0.15439318f, 
    -0.12518911f, -0.11247840f, 0.02278749f, -0.07179970f, 0.25847912f, -0.17668584f, -0.37512460f, -0.20836107f, 
    -0.25138676f, 0.20180483f, 0.29639524f, 0.19943483f, 0.11794682f, 0.05529952f, -0.37473714f, 0.08118188f, 
    -0.46366277f, -0.06523517f, 0.13491908f, 0.12012386f, -0.05276018f, 0.01980714f, -0.08074486f, -0.19404839f, 
    0.18701482f, 0.00592576f, 0.06373330f, -0.11523122f, 0.18836614f, -0.00732096f, 0.32635370f, 0.07936597f, 
    0.25505203f, -0.25855508f, -0.17607072f, -0.11682247f, 0.05246503f, -0.36961752f, -0.03271026f, 0.05459123f, 
    0.16175623f, 0.00715886f, 0.21554922f, 0.13496430f, 0.07844502f, 0.01201016f, 0.10341132f, -0.37460443f, 
    -0.27252796f, 0.07861421f, -0.38273424f, 0.14204200f, 0.12836559f, -0.12604244f, -0.11201227f, -0.09849335f, 
    -0.26688215f, -0.07244890f, -0.09861014f, -0.05900091f, 0.07491585f, 0.14527047f, -0.13197124f, 0.11911654f, 
    0.17173544f, 0.12214966f, 0.17446233f, 0.13883087f, 0.01336094f, 0.28624463f, -0.02964410f, 0.23940007f, 
    -0.02569795f, -0.02791476f, -0.06779700f, -0.55591780f, -0.01486505f, 0.10724559f, 0.26962224f, 0.07501429f, 
    -0.01379053f, -0.06410135f, 0.09019756f, 0.33092102f, 0.12721139f, 0.22262417f, 0.20390353f, 0.06811465f, 
    0.16600706f, -0.17331630f, 0.43078503f, 0.03360923f, 0.04870062f, 0.18860768f, 0.07914254f, -0.08615790f, 
    -0.37160590f, -0.27475324f, -0.23079832f, -0.11617878f, 0.10540830f, 0.06718305f, 0.40114102f, -0.22511488f, 
    0.05079536f, -0.17855005f, 0.17425120f, 0.25461864f, 0.24071822f, 0.24103355f, 0.12336448f, 0.00207019f, 
    -0.11188056f, 0.23189171f, -0.24279177f, 0.02094870f, 0.22481409f, -0.02669688f, -0.28187555f, -0.21532290f, 
    -0.37263295f, -0.03664982f, 0.09356721f, 0.09574358f, 0.20351876f, -0.10632447f, -0.08558856f, 0.13746518f, 
    -0.10354757f, 0.11508654f, 0.14304861f, 0.33307320f, -0.37333491f, -0.50034952f, -0.03246418f, -0.38679123f, 
    -0.14645593f, 0.03713409f, -0.00047624f, -0.34042016f, 0.05985417f, 0.00516172f, 0.19499058f, 0.24744257f, 
    -0.16886435f, -0.04094788f, -0.41446880f, 0.05253635f, 0.07950669f, 0.04306803f, 0.17924725f, -0.64231360f, 
    -0.05088609f, 0.06465670f, -0.04917835f, 0.19589563f, -0.17903242f, 0.12801686f, 0.09783980f, -0.01339946f, 
    -0.11012253f, 0.26176047f, -0.15108712f, 0.09391540f, -0.04608998f, -0.09951184f, -0.00630499f, 0.02764914f, 
    -0.02654145f, 0.16878504f, -0.10745936f, -0.05649715f, 0.04428389f, 0.31676400f, 0.05759406f, 0.11262710f, 
    -0.16496608f, 0.04951474f, -0.10620446f, 0.20194842f, 0.42050767f, 0.18227166f, 0.12000978f, 0.01105181f, 
    -0.14024787f, 0.51419944f, -0.17435345f, 0.02883356f, 0.08087920f, 0.01031051f, 0.01650426f, 0.11806460f, 
    0.24016124f, 0.17900270f, 0.35827455f, -0.75722057f, 0.05623381f, -0.17687124f, 0.03199540f, -0.08786158f, 
    0.11321554f, 0.19660075f, -0.21309495f, -0.12145161f, 0.38861585f, 0.14910632f, -0.15873577f, -0.14507216f, 
    0.19069889f, 0.04203368f, 0.04131963f, -0.33857748f, -0.00225799f, 0.01310127f, 0.12776208f, -0.16340612f, 
    0.56615400f, -0.02852798f, -0.19837269f, -0.03517428f, 0.23372382f, 0.01228463f, -0.06905376f, -0.00544580f, 
    0.19947591f, 0.34632811f, 0.24213760f, -0.23647498f, 0.05668506f, -0.15189563f, -0.10943343f, 0.09151049f, 
    -0.05477773f, -0.03135807f, -0.16798855f, 0.26782891f, 0.10501783f, -0.23129810f, 0.13995034f, -0.05085581f, 
    -0.23265627f, 0.08269865f, 0.05082565f, 0.11110441f, 0.05053215f, 0.11721832f, -0.03787125f, -0.30107504f, 
    -0.21380039f, -0.10797912f, 0.02190419f, 0.09969595f, -0.04418964f, -0.16967787f, -0.06914566f, 0.08943537f, 
    -0.02580073f, 0.20904329f, 0.08191984f, 0.30193013f, -0.33093941f, -0.00710087f, 0.22436981f, 0.08027510f, 
    -0.02021479f, -0.01049869f, -0.09431241f, 0.34415075f, 0.07179567f, 0.15918320f, -0.31757382f, 0.08583030f, 
    -0.00247003f, -0.05294627f, -0.25758824f, 0.08415969f, -0.05439512f, 0.01787457f, 0.28212258f, 0.05417816f, 
    0.07544569f, 0.02421775f, -0.28114846f, 0.21909630f, -0.02225809f, -0.03805466f, 0.26777580f, -0.41842386f, 
    -0.26210576f, 0.31745994f, 0.05114183f, 0.17669523f, -0.11657153f, -0.30569470f, 0.43243596f, -0.06875694f, 
    0.05731108f, 0.02662260f, 0.18982367f, -0.04578218f, -0.02475525f, 0.28276411f, -0.25851455f, 0.25486287f, 
    -0.04194754f, 0.18043922f, 0.01793060f, -0.01902273f, 0.27516356f, 0.12797664f, 0.19550198f, 0.24887088f, 
    0.14244866f, 0.20897390f, -0.09808432f, 0.16544250f, -0.04888694f, 0.16494504f, -0.08160028f, 0.02485028f, 
    -0.08023840f, 0.10485378f, 0.30513966f, -0.06921564f, -0.16423894f, -0.05544494f, 0.05196021f, -0.26486218f, 
    0.07813405f, 0.02626116f, -0.02772482f, -0.32152331f, 0.17266750f, 0.19262163f, -0.45230994f, 0.10032947f, 
    -0.05610806f, 0.04484564f, 0.03162843f, -0.04595196f, 0.14989445f, 0.17757791f, 0.24545327f, 0.10410450f, 
    -0.27106717f, -0.18125342f, 0.09308454f, -0.09526624f, 0.07944965f, 0.03725366f, -0.10721828f, -0.00287216f, 
    -0.05521363f, 0.17034575f, -0.02966644f, -0.24445729f, -0.04681227f, -0.42851132f, -0.24237274f, 0.12610905f, 
    -0.14278358f, 0.03497354f, -0.15214653f, 0.08927338f, 0.38906687f, 0.18180954f, 0.06512451f, -0.24509467f, 
    0.05802231f, 0.14356379f, -0.09856374f, -0.10649166f, 0.15200743f, 0.01595848f, 0.07205024f, -0.23831877f, 
    0.09083954f, -0.04230506f, 0.00120615f, -0.27316102f, 0.24583195f, -0.07453412f, 0.20316614f, -0.01003729f, 
    -0.14687623f, 0.09158775f, -0.08756509f, 0.07726373f, -0.13577312f, 0.14616822f, -0.09366039f, 0.20784466f, 
    -0.26428521f, 0.09733789f, -0.06761944f, 0.43834004f, -0.22651975f, 0.43966690f, -0.26056939f, 0.33547062f, 
    0.08201163f, 0.02742917f, -0.49818468f, -0.01359956f, -0.03870779f, 0.05964632f, 0.10864837f, 0.11257429f, 
    0.14290491f, -0.02517041f, 0.06533472f, 0.06219625f, 0.07013877f, 0.02946668f, 0.11906740f, -0.06296795f, 
    -0.18137167f, 0.03648907f, 0.05458904f, -0.11806732f, -0.25355709f, -0.39668834f, 0.31912902f, 0.17590094f, 
    -0.04513949f, -0.14639829f, 0.28563824f, -0.00235493f, -0.17131472f, 0.07525145f, 0.25663576f, 0.27869421f, 
    -0.10662460f, 0.36185536f, -0.02286295f, -0.02383856f, 0.27545547f, 0.22575533f, 0.02887016f, 0.12504067f, 
    0.36042905f, -0.00316945f, 0.04172925f, -0.37438208f, -0.05407500f, 0.24792422f, 0.25090781f, 0.00046217f, 
    0.00639927f, 0.22817649f, 0.14189559f, 0.30251455f, -0.43461272f, 0.13394651f, 0.20300958f, -0.10723104f, 
    -0.21938577f, -0.15538378f, 0.18771183f, 0.41417295f, 0.14510337f, -0.03819603f, -0.11042372f, 0.18174618f, 
    -0.14950144f, -0.38174877f, 0.10079354f, 0.01604408f, 0.20687592f, 0.03376999f, 0.10879462f, 0.16737662f, 
    0.43167418f, -0.18332423f, 0.12438608f, 0.03328644f, 0.09635884f, 0.15468778f, -0.03523988f, 0.04063599f, 
    0.14129639f, -0.00680861f, -0.13403241f, -0.44173720f, -0.08672880f, -0.58638388f, -0.16466163f, 0.03277282f, 
    0.02940120f, -0.08552767f, -0.08583985f, 0.01472854f, -0.06001509f, 0.07948092f, -0.10842507f, -0.06954707f, 
    -0.35983786f, 0.21457498f, -0.00886823f, 0.08710782f, 0.18063985f, -0.18489450f, 0.13413145f, -0.19219819f, 
    -0.57810503f, 0.02530777f, -0.14315449f, -0.00756012f, -0.04174580f, -0.03774769f, 0.09872139f, -0.12171140f, 
    -0.17180049f, -0.12126071f, 0.20341663f, 0.02292147f, -0.02422883f, -0.49771389f, -0.20810592f, 0.00361585f, 
    0.03159215f, 0.16534770f, -0.10824926f, 0.16459350f, -0.02257609f, 0.25220281f, 0.00963880f, 0.13034028f, 
    -0.19276066f, -0.01351932f, -0.35046276f, 0.00692119f, 0.02291840f, 0.04744875f, 0.06337001f, -0.04951119f, 
    0.10706926f, 0.09803863f, 0.20101824f, -0.02613007f, 0.10037556f, 0.11297613f, 0.24332149f, 0.32208127f, 
    0.23144074f, -0.08665043f, -0.01276061f, -0.17831028f, 0.10618259f, -0.36470276f, -0.05342781f, 0.13322021f, 
    -0.05772333f, -0.11522216f, 0.11287585f, 0.12063977f, 0.05046590f, 0.19513664f, -0.14085272f, -0.02277402f, 
    -0.22333036f, -0.00838257f, -0.20805465f, -0.11546884f, 0.14949556f, -0.21481907f, 0.03582162f, -0.19056073f, 
    0.09930192f, 0.01359859f, -0.03491229f, 0.24011719f, 0.05507959f, 0.11898758f, 0.24854302f, -0.01275251f, 
    0.30716088f, 0.25289050f, 0.22573406f, -0.48769253f, -0.08881368f, 0.11172468f, -0.13364838f, 0.23235606f, 
    -0.12584680f, 0.20656267f, 0.18825151f, 0.19215773f, -0.17057185f, 0.09950591f, 0.35291985f, 0.03979640f, 
    -0.08700865f, -0.32491851f, 0.15803108f, -0.17467947f, 0.10887036f, 0.07550713f, -0.03660924f, -0.00312557f, 
    -0.05336259f, -0.07303751f, 0.17434882f, -0.00459911f, 0.11294094f, 0.24953878f, 0.07023482f, 0.21950021f, 
    0.44430459f, 0.00123051f, 0.16534704f, -0.04734455f, 0.08332381f, -0.11175463f, 0.17050353f, 0.00275170f, 
    -0.03001115f, 0.33080497f, 0.01703908f, -0.02553423f, -0.13998391f, -0.06360289f, 0.07920521f, 0.39063329f, 
    0.48811817f, 0.02766693f, 0.12433662f, 0.13282950f, -0.19243772f, 0.07863051f, 0.04394583f, 0.08083627f, 
    0.11461174f, 0.12481778f, 0.00991509f, -0.00788437f, -0.02509530f, 0.03493031f, 0.10597467f, 0.13084950f, 
    0.10333237f, -0.10540230f, 0.08714122f, -0.15712537f, 0.33252153f, 0.38426757f, -0.10700180f, 0.27176404f, 
    0.07411592f, 0.32245824f, 0.04906268f, 0.03505656f, -0.03460611f, 0.06181297f, 0.40907758f, 0.02622112f, 
    0.28493178f, 0.10383409f, 0.42954567f, -0.06439135f, -0.03908155f, 0.06781346f, -0.02737742f, -0.31291273f, 
    0.21068712f, -0.00930066f, 0.16443017f, -0.00043609f, -0.09338911f, -0.03918024f, -0.06653337f, 0.17648032f, 
    0.11862736f, -0.12379239f, 0.23040771f, -0.14806063f, 0.03037271f, 0.06705294f, -0.03500662f, 0.14735822f, 
    0.06980274f, 0.03230963f, -0.08904227f, -0.14170577f, -0.05554064f, -0.07125489f, 0.63808793f, 0.07417169f, 
    0.09472017f, -0.02817149f, 0.11796225f, 0.00814652f, -0.16256715f, 0.39285430f, 0.05474493f, -0.05900103f, 
    0.23765662f, -0.22443181f, 0.20800769f, -0.19576310f, -0.05518422f, -0.10153036f, -0.16432115f, -0.08017873f, 
    0.11343534f, 0.02820938f, 0.01993605f, 0.33268785f, 0.01012377f, 0.29288554f, 0.12331876f, 0.32286116f, 
    0.01866323f, -0.07439280f, 0.28641620f, -0.37886432f, 0.14514467f, 0.02564999f, 0.31821546f, 0.05783650f, 
    0.24591470f, 0.00983352f, -0.09185646f, 0.10248206f, 0.03792811f, 0.00469717f, 0.01076057f, 0.12599045f, 
    0.24888517f, 0.00253523f, 0.22441681f, -0.02247585f, -0.00633942f, -0.08670750f, 0.13780348f, 0.08458312f, 
    -0.13761622f, -0.23204610f, 0.10401975f, -0.01407093f, -0.00333701f, 0.41436237f, 0.20210895f, -0.15898234f, 
    0.22294860f, -0.08976666f, 0.05421361f, 0.01505437f, -0.35498044f, -0.02846597f, 0.11053794f, 0.07387891f, 
    0.30007502f, -0.23415013f, 0.06226953f, 0.09208253f, -0.08626989f, 0.08991390f, 0.14368397f, -0.00640991f, 
    -0.12507172f, 0.05399955f, 0.21677741f, 0.06371482f, -0.12494137f, 0.19012447f, -0.26372069f, 0.05165857f, 
    -0.05307979f, -0.28051835f, 0.30194223f, -0.56829691f, -0.22353165f, -0.24101783f, -0.45794690f, 0.37622881f, 
    -0.07698603f, -0.09448433f, -0.49505052f, -0.17394242f, -0.04134530f, -0.29448792f, -0.00236169f, -0.26505917f, 
    -0.27332041f, -0.04012920f, 0.14521742f, 0.06984589f, 0.05072845f, 0.07868885f, -0.06166132f, 0.32595637f, 
    -0.07969211f, 0.07973486f, -0.24749684f, 0.07693210f, 0.29987875f, -0.33545375f, 0.14319143f, -0.66043478f, 
    -0.25377002f, -0.17839745f, -0.00978789f, 0.18759069f, 0.40440670f, 0.13599651f, 0.06341209f, -0.17880867f, 
    0.13498333f, 0.21971084f, -0.22741975f, 0.07516720f, 0.17690742f, -0.00998197f, -0.19966294f, -0.21631375f, 
    0.10654978f, -0.32118577f, -0.18047780f, 0.08654279f, -0.02539250f, 0.08785351f, -0.04015484f, 0.05251861f, 
    -0.10605898f, -0.23981099f, 0.08957760f, 0.19663294f, 0.08322000f, 0.05415743f, 0.07310371f, -0.39217332f, 
    0.04575848f, -0.26650065f, 0.03866247f, 0.03668522f, 0.05169216f, 0.13492641f, -0.14925054f, -0.20864195f, 
    0.05482848f, -0.17319126f, -0.01934099f, 0.67252892f, 0.02686162f, 0.10925133f, 0.13219294f, 0.12122340f, 
    0.01718446f, -0.07386667f, -0.10223112f, 0.09772756f, 0.16656093f, -0.06137279f, -0.24731581f, 0.06575397f, 
    -0.22798595f, 0.36190230f, 0.52013165f, 0.05891784f, -0.03933002f, -0.11065909f, 0.13660544f, -0.16038832f, 
    -0.04399314f, -0.00382392f, 0.14837618f, 0.43284720f, 0.15444405f, 0.52075624f, -0.26017880f, -0.07150257f, 
    0.16747984f, -0.04073306f, -0.11773011f, 0.14268088f, 0.16931495f, -0.27639198f, 0.24073575f, 0.08987200f, 
    -0.25397971f, 0.01424304f, -0.13936627f, 0.20426300f, 0.12665629f, 0.01294746f, -0.00997137f, -0.03263868f, 
    -0.29026967f, -0.17337628f, 0.09856629f, 0.07047439f, -0.20143177f, -0.30170122f, -0.31194717f, 0.00999945f, 
    0.01417008f, 0.33932549f, 0.13926132f, 0.31283918f, -0.09847984f, -0.26911709f, 0.25703168f, 0.01136823f, 
    -0.06778331f, -0.32238951f, -0.02485182f, 0.04096111f, 0.02782300f, -0.18671137f, 0.00284639f, -0.07500636f, 
    0.11365865f, -0.04613727f, 0.37740636f, 0.07603684f, 0.03255726f, -0.05355005f, 0.23502684f, -0.36774239f, 
    -0.07881229f, 0.17650430f, -0.09394132f, 0.25463665f, -0.07470853f, 0.12554686f, 0.22681075f, -0.15562233f, 
    -0.24569868f, 0.26262566f, -0.08076993f, 0.15841490f, -0.18666661f, 0.04177806f, 0.24153192f, -0.24211057f, 
    -0.04274420f, 0.04746114f, -0.04850611f, 0.00897949f, -0.05576284f, 0.20850292f, 0.01859735f, 0.11541975f, 
    0.04077625f, 0.09155818f, -0.17697774f, 0.04993964f, 0.17213179f, 0.25867975f, 0.24067800f, 0.45381027f, 
    0.26365733f, 0.28675619f, -0.19820210f, 0.11505303f, -0.11138986f, -0.14577201f, -0.52687496f, 0.22746848f, 
    -0.12429905f, -0.02360471f, 0.24419156f, -0.38520899f, -0.08743625f, -0.26598528f, 0.12309093f, -0.18718074f, 
    0.12300664f, 0.12087285f, 0.05576712f, -0.18845518f, 0.17692825f, 0.11839218f, -0.19386388f, -0.05482097f, 
    0.07104836f, 0.26155970f, -0.04044955f, -0.11504554f, 0.13638960f, -0.08013825f, 0.29432631f, 0.16975032f, 
    -0.15740339f, -0.20909946f, -0.08633801f, -0.01387413f, 0.18493022f, 0.05300118f, -0.05537114f, -0.05403525f, 
    -0.45216432f, 0.05013719f, 0.11801849f, -0.32091585f, -0.03676336f, 0.09873955f, 0.11053300f, 0.33777598f, 
    -0.00668750f, -0.01953920f, 0.07602790f, 0.06758238f, 0.05818013f, -0.05410960f, 0.09499925f, -0.02065049f, 
    -0.05475751f, 0.08957828f, 0.16137774f, -0.15930209f, 0.08888236f, -0.12400845f, 0.01472087f, -0.18584749f, 
    -0.08001438f, 0.25647607f, 0.12715475f, -0.19686978f, -0.06785406f, -0.02774663f, 0.11260139f, 0.14390559f, 
    0.02925908f, 0.19531339f, 0.07913094f, 0.07351287f, 0.02441054f, 0.08104106f, -0.38469645f, -0.08567770f, 
    -0.35794872f, 0.11858499f, 0.12564516f, -0.12784772f, 0.24629040f, 0.04801640f, -0.07744496f, 0.10219037f, 
    -0.57634324f, -0.02368461f, 0.09836980f, 0.02592668f, -0.01139939f, 0.00366242f, 0.15312961f, -0.25911304f, 
    0.13520032f, -0.15866770f, 0.22102302f, -0.12457431f, 0.09313506f, 0.15753463f, 0.06849285f, 0.20992602f, 
    0.23019159f, -0.17929381f, -0.30815035f, -0.04641230f, -0.09679426f, -0.35235801f, 0.09308199f, 0.11241847f, 
    0.00877828f, -0.12477712f, 0.16534740f, -0.02182760f, 0.02005708f, 0.12809694f, -0.03704467f, -0.13789500f, 
    -0.21631292f, 0.14444543f, -0.45619184f, 0.25395426f, 0.18235812f, -0.11311273f, -0.15894195f, 0.04507745f, 
    -0.51562846f, 0.11664686f, -0.13011618f, -0.43992370f, 0.14064533f, 0.02864863f, 0.01470507f, 0.15842550f, 
    0.25304651f, 0.22581714f, 0.19117838f, 0.13181095f, -0.00235038f, 0.20437095f, -0.05975913f, 0.36544815f, 
    0.00319924f, 0.16506912f, -0.10564499f, -0.58875650f, -0.12382226f, 0.13699676f, 0.26794663f, -0.15715073f, 
    0.19566523f, 0.30008546f, 0.00519266f, 0.01716048f, 0.15745121f, 0.02809495f, 0.17598464f, -0.05374293f, 
    0.35683811f, -0.30710089f, 0.27875149f, 0.00742944f, 0.12661994f, 0.02898012f, -0.15163113f, -0.32041538f, 
    -0.15144482f, -0.34656009f, -0.21773475f, -0.26038483f, -0.02543291f, -0.18236032f, 0.31390268f, -0.22484620f, 
    -0.08407751f, -0.02004482f, -0.08503988f, -0.05712166f, -0.06679836f, 0.04894768f, 0.02907228f, -0.01398897f, 
    -0.00805373f, -0.06043218f, 0.03715816f, -0.05970979f, -0.03964354f, 0.00472555f, 0.03832486f, 0.07539067f, 
    0.00868937f, -0.03385162f, -0.05162249f, 0.04906301f, 0.08135215f, -0.03850473f, -0.03874703f, -0.09596619f, 
    -0.03874440f, -0.06281371f, -0.03574285f, -0.04807803f, 0.04406762f, 0.01614794f, -0.07611071f, 0.00824274f, 
    -0.08079267f, 0.06037591f, 0.00512045f, -0.08363894f, 0.07410265f, -0.04561053f, -0.00252636f, -0.04947121f, 
    0.04386690f, 0.06313800f, -0.06758557f, -0.10439067f, 0.01262471f, 0.07971659f, 0.04542849f, -0.08832124f, 
    -0.04916044f, -0.04634760f, 0.05146867f, -0.08297700f, -0.05580253f, -0.06192242f, -0.09456559f, -0.04147910f, 
    -0.06971682f, -0.10461990f, 0.05525165f, -0.09000023f, 0.05183666f, 0.03888720f, -0.05818633f, -0.09884885f, 
    0.05037061f, -0.07736970f, -0.05965823f, -0.00831954f, -0.11300091f, -0.01554137f, -0.04744452f, -0.04945338f, 
    0.03407702f, -0.03015583f, -0.04458694f, -0.07503189f, 0.04073323f, -0.02470496f, -0.08129925f, -0.04910520f, 
    -0.07607169f, -0.09782075f, 0.05774501f, -0.06620754f, -0.03621010f, -0.08838211f, 0.10061949f, -0.04925745f, 
    0.02911779f, -0.04651564f, -0.00011876f, 0.01914500f, -0.04071445f, -0.03888290f, -0.01849109f, -0.05435827f, 
    -0.02023369f, 0.03820666f, -0.10871086f, 0.01654511f, 0.04849646f, -0.03040941f, 0.02736006f, 0.03236004f, 
    -0.06916103f, -0.05022905f, -0.03972339f, -0.02442242f, -0.03051533f, -0.08147167f, -0.02159543f, -0.03797243f, 
    0.00372800f, -0.11424814f, -0.09958578f, 0.00035442f, -0.10450671f, 0.02619025f, -0.10614888f, 0.00424431f, 
    0.00208930f, 0.03455167f, 0.00147942f, 0.04391582f, 0.04850779f, -0.07895633f, 0.01894367f, 0.01308746f, 
    -0.13970980f, 0.20803197f, 0.07552034f, -0.10541801f, 0.20495701f, 0.56457800f, -0.10893194f, -0.06821274f, 
    -0.01679490f, 0.08949312f, -0.07327123f, 0.04694960f, 0.03174319f, 0.14360873f, 0.24436711f, -0.01343011f, 
    0.71886986f, 0.01312125f, 0.04134914f, 0.04162616f, 0.27059266f, 0.27760446f, 0.60253638f, 0.04733313f, 
    0.02244250f, -0.15238832f, -0.10385831f, 0.06704866f, 0.01215876f, 0.14536826f, 0.11334846f, 0.41883889f, 
    0.02198592f, 0.19867440f, -0.02592628f, -0.06076388f, 0.12141648f, 0.32744554f, 0.21603346f, 0.33802491f, 
    0.02840398f, -0.07768586f, -0.61587876f, 0.01622696f, 0.10827171f, 0.03029957f, -0.23389009f, 0.10524613f, 
    0.13167435f, 0.01089326f, 0.06919404f, -0.03090073f, 0.00428873f, 0.07722133f, -0.23338130f, 0.05478870f, 
    -0.07687832f, -0.09440403f, 0.12064932f, -0.08666972f, 0.04205742f, -0.15443660f, -0.18254344f, 0.17093770f, 
    0.07862800f, 0.02619001f, 0.05340536f, 0.26308587f, -0.00925384f, -0.05798891f, -0.13982826f, 0.18490848f, 
    -0.06575109f, 0.23028812f, 0.29124573f, -0.04430702f, 0.02287673f, -0.11616605f, -0.02212832f, -0.14562760f, 
    -0.03449098f, -0.05543337f, 0.07255051f, -0.32176924f, 0.07380456f, 0.17609528f, 0.58422834f, -0.03148892f, 
    0.04881036f, 0.24399264f, -0.04254054f, 0.07315303f, 0.12568568f, 0.14691465f, 0.01117607f, -0.23670578f, 
    -0.14874636f, -0.01300207f, -0.02057937f, 0.34620118f, 0.13007224f, 0.13697097f, -0.05973059f, 0.03470857f, 
    -0.08795005f, -0.15729953f, 0.21303624f, -0.06981578f, 0.00038091f, 0.10414701f, -0.03788224f, 0.11920994f, 
    0.57865304f, 0.08902090f, -0.16152182f, 0.01625249f, 0.02483585f, 0.25979346f, -0.03063748f, 0.02531055f, 
    0.28487182f, -0.17079872f, -0.06823461f, 0.04074503f, 0.13998379f, -0.47490895f, -0.28259754f, -0.01003299f, 
    0.04802186f, 0.02347931f, 0.07459061f, -0.09772739f, 0.04343263f, 0.02695915f, -0.00644070f, -0.02505331f, 
    -0.12020698f, -0.03074412f, 0.02777725f, -0.10796810f, -0.09099099f, 0.02086745f, 0.02509259f, -0.03307840f, 
    0.27451459f, -0.07182109f, -0.02309177f, -0.08522456f, 0.00269156f, -0.09935465f, 0.01196272f, -0.00846716f, 
    -0.12526080f, 0.03729040f, -0.11568522f, -0.08146627f, 0.08280289f, -0.07485867f, -0.03514943f, 0.06541219f, 
    -0.01241708f, -0.05708434f, -0.07657845f, 0.01949095f, 0.00868896f, -0.06179436f, 0.02983346f, 0.00987455f, 
    -0.00354705f, -0.05956302f, -0.06531416f, -0.13767999f, -0.00267255f, 0.00623694f, -0.07417125f, 0.12837389f, 
    -0.07912657f, -0.10809533f, -0.02329674f, 0.01341088f, -0.05528893f, -0.03787235f, -0.02967609f, -0.12454310f, 
    -0.13103656f, 0.02424559f, -0.05580348f, 0.05128818f, -0.06889318f, 0.07118253f, 0.00215077f, -0.16278341f, 
    0.00811311f, -0.09692928f, -0.02121621f, -0.10030495f, -0.00903689f, -0.10090929f, 0.06976189f, -0.11303607f, 
    0.00865777f, -0.10435480f, 0.01678920f, 0.02046057f, 0.00251903f, -0.05644167f, -0.09797149f, -0.06508697f, 
    -0.06844771f, -0.04759024f, -0.15152688f, 0.08571800f, -0.00132004f, -0.09425420f, 0.08502058f, 0.03219316f, 
    -0.03814166f, -0.00543281f, -0.04304982f, -0.00655630f, -0.08697486f, -0.03907149f, -0.08442502f, -0.06553086f, 
    0.01311381f, 0.01781688f, -0.05626443f, 0.08899590f, 0.05461577f, -0.11341070f, 0.05033549f, -0.08146954f, 
    -0.09660199f, 0.04605079f, -0.04968892f, 0.05786765f, 0.02135119f, -0.09070161f, -0.03379457f, -0.03607756f, 
    -0.04844750f, -0.13472542f, -0.07325634f, -0.04302248f, -0.13976377f, -0.02656594f, -0.10619613f, -0.08284310f, 
    -0.05192974f, 0.02279423f, -0.05210736f, -0.05761306f, 0.01845036f, -0.01185026f, -0.06664860f, -0.00797233f, 
    -0.01600867f, -0.11765449f, 0.01688550f, -0.08425690f, -0.01222745f, 0.06809207f, -0.02472652f, -0.08702245f, 
    -0.01702766f, -0.08318184f, -0.01645654f, -0.04646793f, 0.08166276f, -0.03286802f, -0.03218263f, -0.04971157f, 
    -0.01429553f, -0.08253256f, 0.00317901f, 0.00848215f, -0.08596025f, 0.02738145f, 0.07749034f, 0.02691580f, 
    0.04389076f, -0.06518610f, 0.02172782f, -0.08120003f, 0.00559772f, -0.01279448f, -0.01379653f, -0.02405792f, 
    -0.11142412f, 0.08630326f, 0.03132874f, 0.06081086f, 0.01325714f, -0.07994138f, -0.00140128f, -0.08498680f, 
    0.04203761f, -0.02308020f, 0.03694560f, 0.03993040f, -0.05374232f, 0.07180350f, -0.07042778f, -0.05642343f, 
    0.01330585f, -0.05716965f, 0.03308593f, -0.08603922f, -0.04196842f, -0.00983413f, -0.01631434f, -0.04289107f, 
    -0.04261459f, -0.04867473f, 0.01052882f, -0.02809377f, 0.00912769f, -0.10182847f, 0.03824406f, -0.02916870f, 
    -0.07184638f, 0.02743785f, -0.08615999f, 0.02282981f, -0.00996562f, 0.02337342f, -0.06673565f, -0.01986099f, 
    -0.02889858f, 0.03101545f, -0.03292986f, -0.08363713f, 0.07210483f, -0.08707910f, -0.05184709f, 0.01804692f, 
    -0.11150223f, 0.00909743f, -0.09394062f, -0.07595623f, -0.02323565f, -0.08705381f, 0.07597164f, 0.02252143f, 
    0.03697425f, 0.05183874f, -0.05036547f, -0.06789733f, 0.04305497f, -0.06779929f, -0.09349482f, 0.04297568f, 
    0.05617543f, -0.03041850f, -0.03884853f, -0.04181568f, -0.05480703f, 0.04083947f, 0.00008286f, 0.02255425f, 
    0.06886218f, 0.00624547f, 0.05749358f, -0.09464879f, -0.00868546f, -0.07828985f, -0.06907324f, 0.04963334f, 
    -0.03910228f, -0.02361395f, -0.04394726f, 0.00728220f, -0.08201491f, 0.00895077f, -0.02918191f, -0.03293574f, 
    -0.06578156f, -0.04465557f, -0.09732296f, -0.07566857f, 0.02244040f, -0.08200520f, -0.06580855f, 0.00805147f, 
    -0.05536930f, 0.12059104f, 0.08161850f, -0.05712801f, 0.04901823f, 0.24518345f, -0.23949122f, -0.44132560f, 
    0.04102881f, 0.16867568f, 0.06115644f, -0.02327784f, 0.19880174f, 0.09534653f, 0.29099837f, -0.51948047f, 
    -0.12700184f, -0.15277041f, 0.03252020f, 0.21439916f, 0.39862743f, 0.21564172f, 0.46501443f, -0.04398584f, 
    0.16109018f, -0.14660063f, -0.00723404f, 0.13214009f, 0.09295630f, -0.36209664f, 0.13734373f, -0.02979213f, 
    0.10034366f, 0.18560930f, 0.00620033f, 0.31469247f, -0.00697288f, 0.14067724f, -0.06005979f, 0.18390223f, 
    0.04788781f, -0.03465563f, -0.71026987f, -0.06587592f, 0.02849334f, -0.06080845f, -0.06016520f, 0.32192683f, 
    0.05490289f, 0.12175812f, -0.10334067f, -0.02493747f, 0.23603112f, -0.01291351f, -0.13652772f, 0.09025448f, 
    0.04631493f, -0.10038296f, 0.00675680f, 0.02398819f, 0.15003777f, -0.21386461f, -0.01448627f, 0.03238660f, 
    0.01737591f, 0.07549198f, 0.16471893f, 0.26317263f, 0.09171727f, 0.02653089f, -0.38728064f, 0.13727336f, 
    0.04612698f, 0.29499075f, 0.16432261f, -0.20310302f, 0.03843554f, -0.38509616f, -0.06101565f, -0.00046922f, 
    0.15459530f, -0.12683855f, 0.03862760f, 0.19158825f, 0.07843681f, 0.36117473f, 0.25677240f, 0.10606018f, 
    0.05022541f, 0.08861632f, 0.10178034f, -0.22275844f, 0.17969356f, 0.01245452f, -0.03807176f, -0.18485385f, 
    0.02942671f, 0.06302857f, 0.24878068f, 0.28654280f, -0.04634947f, 0.25742328f, -0.43370563f, 0.25526968f, 
    -0.40460375f, -0.52839071f, 0.20601434f, 0.09179506f, 0.08874204f, 0.10428840f, -0.09140170f, 0.19500355f, 
    0.14583738f, 0.11296193f, -0.19345842f, -0.02196426f, 0.00798336f, 0.24950258f, -0.07593040f, 0.18679845f, 
    0.40811247f, 0.00777546f, -0.10515401f, -0.01542174f, 0.18917111f, -0.67638898f, -0.17615648f, 0.06076790f, 
    -0.32551992f, -0.17642322f, 0.11051838f, 0.09512824f, 0.36623439f, 0.77260721f, -0.01169886f, -0.03320004f, 
    -0.25622210f, 0.13384549f, -0.61915952f, -0.16198373f, 0.27007562f, -0.03255660f, -0.27931044f, -0.50660276f, 
    0.55011088f, -0.25750750f, 0.05012178f, 0.22783592f, 0.10559389f, 0.00325114f, 0.22527273f, -0.00955600f, 
    0.22267419f, 0.17802222f, -0.47876975f, 0.15211332f, 0.17411652f, 0.01244402f, 0.11948150f, -0.02309209f, 
    -0.25502792f, 0.36095187f, -0.10708120f, 0.04573353f, -0.08734646f, 0.29195064f, 0.08260654f, 0.20911635f, 
    -0.25583196f, -0.01985661f, 0.03523184f, 0.04148686f, -0.01346637f, 0.04726510f, -0.01280726f, 0.40976959f, 
    0.12270591f, -0.24520943f, 0.13946442f, -0.09072235f, -0.09994941f, 0.15605254f, -0.73789597f, 0.23646584f, 
    0.05003566f, 0.09698860f, -0.17085336f, -0.03966397f, -0.31961539f, -0.03734715f, -0.08794446f, 0.14583300f, 
    0.03584618f, -0.23981114f, 0.20252290f, -0.02751637f, 0.13924432f, 0.18819875f, -0.27385199f, 0.04984373f, 
    -0.16734196f, 0.15628761f, 0.22038554f, -0.09595437f, 0.13384895f, -0.19661385f, -0.08688011f, -0.02295715f, 
    -0.28638572f, 0.22858925f, -0.18808930f, -0.29881266f, 0.09637509f, 0.08833957f, 0.02688118f, 0.18060939f, 
    -0.13978001f, 0.25171325f, -0.05864536f, 0.49149191f, 0.21281086f, 0.04879496f, -0.06691813f, -0.30639696f, 
    0.10739757f, 0.13092639f, -0.02630865f, -0.25857750f, -0.10801811f, -0.06837422f, 0.01543990f, -0.00593743f, 
    0.13685724f, 0.24584524f, 0.32847440f, -0.20591116f, -0.30667809f, 0.07923771f, 0.00581080f, -0.18885064f, 
    0.30059859f, 0.13846779f, -0.57763880f, 0.01190450f, 0.07981223f, 0.07248928f, -0.22642134f, -0.40946272f, 
    0.11910655f, -0.06559473f, -0.19461204f, -0.09992048f, -0.13069251f, -0.17900778f, -0.39890179f, -0.17392385f, 
    0.13205537f, -0.10660870f, -0.14672634f, 0.23612982f, -0.05888527f, -0.38930020f, 0.21253975f, 0.03523698f, 
    0.12062721f, -0.06813327f, 0.17497618f, 0.31475228f, -0.20132269f, 0.09670243f, -0.14691684f, -0.26725432f, 
    -0.29398498f, 0.08399410f, 0.03623794f, -0.14134382f, -0.15907361f, -0.47865692f, -0.23221016f, 0.07618376f, 
    0.06162129f, 0.15039444f, 0.25170314f, 0.19114964f, -0.16632777f, -0.14390995f, 0.19067606f, -0.04800965f, 
    0.02919841f, -0.08221841f, 0.25373262f, 0.00225092f, 0.06752913f, -0.12713513f, 0.04990938f, -0.26123810f, 
    0.11315097f, -0.00757986f, -0.03314973f, -0.04510701f, -0.05130428f, 0.02238137f, 0.26682061f, -0.59913570f, 
    -0.25445536f, 0.33513716f, -0.35594204f, 0.23939215f, -0.22064383f, 0.06902310f, 0.35672089f, -0.21706074f, 
    -0.21656086f, 0.29436100f, 0.00070798f, 0.22648329f, -0.10242148f, 0.07488100f, 0.18849318f, -0.11037787f, 
    0.14107491f, 0.10818984f, -0.20878057f, -0.32151392f, -0.13026062f, 0.17112285f, 0.30270141f, 0.17024401f, 
    0.16119745f, 0.04212521f, -0.09961389f, 0.09849418f, -0.05984158f, 0.32418883f, 0.22172286f, 0.14833090f, 
    0.45693132f, 0.09119023f, -0.09953480f, 0.04838034f, -0.09578383f, -0.24143270f, -1.10015512f, 0.00812661f, 
    0.07023475f, -0.25961119f, 0.30012712f, -0.55789721f, 0.00735340f, -0.07340258f, 0.19836813f, 0.14768264f, 
    0.09699736f, 0.08361819f, 0.26648620f, -0.37199715f, 0.31095988f, 0.21354413f, -0.19512363f, -0.03648962f, 
    0.26873353f, 0.29084778f, -0.34036353f, -0.07579953f, 0.28499627f, -0.18107052f, 0.14573778f, 0.15973940f, 
    0.00837847f, -0.04435315f, -0.13139144f, -0.08949059f, 0.22147311f, -0.23641615f, 0.16157298f, 0.15948801f, 
    -0.56486505f, 0.10963563f, 0.26645613f, -0.35679111f, 0.10446802f, -0.15188517f, 0.45568264f, 0.29284757f, 
    -0.43212759f, 0.05791558f, -0.03405572f, 0.06149437f, 0.28483531f, -0.55919021f, 0.05607503f, 0.37396398f, 
    -0.08032720f, -0.18452492f, -0.33827078f, -0.11808948f, -0.21575405f, 0.29845861f, -0.13860016f, -0.46627447f, 
    -0.72146660f, -0.25810677f, -0.13148908f, 0.08198133f, -0.10006286f, 0.01219599f, 0.22870657f, 0.16657150f, 
    -0.50598651f, 0.15977409f, -0.22232559f, 0.37067461f, 0.14140785f, 0.35483012f, 0.29607335f, 0.16967230f, 
    0.22553058f, 0.34311038f, -0.13435794f, 0.21010850f, 0.06602588f, 0.43028137f, 0.20220181f, 0.03656821f, 
    0.30148441f, 0.07186110f, 0.17386566f, -0.22176126f, -0.01910740f, 0.05862997f, 0.04052148f, 0.01537112f, 
    0.35781723f, -0.00228260f, -0.17389831f, 0.02984253f, -0.64693129f, 0.02037776f, -0.07181359f, -0.08185956f, 
    -0.01101038f, 0.06298156f, 0.37590021f, 0.13119335f, -0.23179941f, 0.19137511f, -0.02877169f, 0.06686917f, 
    0.16308488f, -0.17448138f, -0.04166409f, -0.30416927f, -0.12266299f, -0.05500787f, 0.41126242f, 0.37353694f, 
    -0.24307950f, 0.27727279f, 0.33949006f, -0.20103657f, -0.06401340f, 0.33493474f, 0.10047764f, -0.46753702f, 
    0.40195271f, 0.09089754f, 0.08131527f, -0.45605353f, -0.34605128f, -0.24839218f, -0.16129696f, -0.17391412f, 
    -0.29972637f, -0.11997627f, 0.14473954f, 0.41807467f, 0.09993278f, 0.08980536f, 0.27643731f, -0.25150049f, 
    0.16225711f, -0.23536275f, 0.28022707f, 0.18149531f, -0.06577393f, 0.10341728f, -0.30961445f, 0.04744774f, 
    0.19922495f, 0.22550365f, -0.17277172f, -0.26954377f, 0.06084535f, -0.15375386f, -0.00748310f, 0.09693059f, 
    -0.13452941f, -0.28279766f, -0.44387364f, 0.01579579f, -0.01494032f, -0.47580591f, -0.19330516f, 0.18164264f, 
    -0.54484898f, -0.02892016f, -0.00189555f, -0.31256336f, -0.04052379f, -0.19005603f, -0.71363676f, 0.09221509f, 
    0.11643644f, -0.18300742f, 0.12592775f, 0.11538121f, 0.00667327f, 0.32780424f, 0.19721934f, 0.18140832f, 
    0.04262257f, 0.21331640f, 0.04324269f, 0.09622702f, 0.03516779f, 0.03219819f, -0.16280496f, -0.17861870f, 
    0.19590935f, 0.08458878f, 0.11690307f, 0.30555126f, -0.01496439f, 0.11575788f, 0.14099851f, 0.02515417f, 
    0.24652717f, -0.04560570f, -0.12538046f, 0.01122384f, -0.36848527f, 0.01627371f, -0.13473815f, 0.53551054f, 
    -0.01813708f, 0.30854037f, -0.02863727f, -0.20767613f, 0.02776409f, 0.05874715f, 0.20419462f, -0.03951422f, 
    -0.16266438f, 0.05950979f, 0.20382071f, 0.10748847f, 0.03420574f, -0.08788852f, -0.05076315f, -0.16521588f, 
    -0.06663474f, -0.06749669f, -0.13737988f, 0.06380654f, 0.04624519f, 0.15704188f, -0.08988526f, 0.05691530f, 
    0.03702348f, -0.08301415f, -0.02006463f, 0.15965004f, 0.08726355f, -0.18012229f, -0.10573436f, 0.06080083f, 
    0.24359570f, 0.01228870f, -0.05317490f, 0.19275631f, 0.13420168f, 0.05740556f, -0.42530859f, -0.15800495f, 
    0.14822613f, -0.12809193f, 0.23487407f, 0.07594639f, 0.04969975f, -0.12253181f, -0.14825763f, -0.15168776f, 
    -0.31450200f, 0.13208669f, 0.16451314f, 0.10007721f, 0.09776636f, 0.07534508f, -0.13702324f, 0.01127781f, 
    0.17924628f, -0.02577200f, 0.07294073f, -0.19885236f, 0.21363321f, -0.06167555f, 0.11824409f, -0.12570018f, 
    0.14274038f, 0.19615695f, -0.20028222f, -0.14411035f, -0.07039893f, 0.06337518f, 0.14369103f, 0.07941149f, 
    0.25448048f, 0.32940909f, 0.20777565f, -0.06873687f, -0.05533048f, 0.12004270f, 0.00391297f, -0.14805265f, 
    -0.22817460f, 0.14626333f, 0.06715617f, 0.02382887f, 0.01302790f, -0.11255343f, 0.15676260f, -0.18239155f, 
    0.37422973f, -0.07937030f, 0.10946564f, 0.15474448f, 0.01597112f, -0.00395455f, -0.32500708f, -0.14420952f, 
    -0.21209085f, -0.31231266f, -0.42929459f, -0.10283399f, 0.26505661f, -0.48504490f, 0.16681817f, 0.12592490f, 
    0.17692977f, 0.02988020f, 0.04473915f, -0.08895713f, 0.12444324f, 0.20428759f, -0.29187152f, 0.16753377f, 
    0.17502233f, -0.01607677f, 0.00085247f, 0.09625605f, 0.19935600f, 0.10901828f, 0.24033345f, -0.15219253f, 
    0.04483785f, -0.31339830f, -0.30799988f, -0.01210525f, 0.38915071f, 0.24341816f, 0.10115671f, -0.19249789f, 
    0.23001793f, 0.49007335f, 0.01634205f, -0.07068994f, -0.02275929f, 0.09860964f, 0.17888515f, 0.04710933f, 
    -0.10281160f, 0.03833001f, -0.00956331f, 0.01384172f, 0.06910936f, -0.01540832f, -0.08995195f, -0.65223068f, 
    -0.20023195f, -0.28213811f, -0.06836267f, -0.18938993f, 0.30684695f, -0.07685817f, -0.29546344f, 0.11890011f, 
    -0.12155393f, -0.07095890f, 0.32015771f, 0.12501192f, 0.25619468f, 0.34519342f, -0.00754799f, 0.07916398f, 
    0.34231159f, -0.04284430f, 0.10863385f, 0.03160769f, 0.28993669f, 0.12623669f, 0.47910684f, 0.01503877f, 
    -0.55350000f, 0.06935727f, 0.11844150f, 0.14650539f, -0.08158972f, -0.02677347f, 0.00323466f, -0.34637097f, 
    0.01111027f, -0.10923050f, -0.22503421f, 0.24829794f, -0.10725969f, -0.01523993f, -0.01607081f, 0.02732601f, 
    0.02265328f, 0.20984833f, 0.01294757f, 0.16911861f, 0.12323599f, 0.08714023f, -0.03218096f, 0.27417102f, 
    -0.08202689f, -0.13494389f, -0.33148247f, -0.50146234f, -0.45945454f, 0.00228171f, 0.50370324f, 0.03997796f, 
    0.28267398f, 0.13382737f, -0.04185183f, 0.23945829f, 0.06832611f, 0.00004284f, -0.00094969f, -0.33542615f, 
    -0.28614235f, 0.16024877f, -0.05706443f, -0.05456756f, -0.06292609f, -0.11395747f, -0.40794727f, -0.17031904f, 
    -0.50024354f, -0.13208242f, -0.01303961f, 0.04476257f, -0.05549851f, 0.26702434f, -0.04316701f, -0.02035973f, 
    0.10175616f, 0.24159852f, -0.13590714f, 0.03856499f, 0.14997536f, -0.06123520f, 0.03932532f, -0.00058858f, 
    0.19845298f, -0.05495749f, 0.08866898f, 0.01828996f, 0.03695156f, 0.05895945f, 0.20721412f, 0.53741360f, 
    0.13215128f, -0.13577127f, -0.11604005f, 0.06587414f, 0.11222430f, 0.09177013f, 0.09836159f, -0.14348438f, 
    0.21714574f, 0.15340975f, -0.15221140f, 0.03484827f, -0.00304357f, 0.37131631f, 0.13617624f, 0.44245714f, 
    0.07069811f, -0.29554960f, -0.27485836f, 0.23546888f, -0.12807666f, -0.06011804f, -0.10695637f, -0.02963334f, 
    0.23166218f, -0.07251900f, -0.01211910f, -0.16037735f, -0.01662848f, 0.06435829f, 0.11807024f, 0.33968595f, 
    0.09945885f, 0.11755335f, 0.09472030f, 0.00513699f, -0.05266318f, 0.10401370f, 0.00434095f, 0.03721456f, 
    -0.14472796f, 0.14040010f, 0.04966683f, -0.04677757f, -0.30616680f, 0.02837158f, 0.07501266f, 0.06417783f, 
    -0.15437093f, -0.17052455f, 0.08292486f, 0.15337445f, -0.00657225f, -0.11508128f, -0.06647741f, 0.06593312f, 
    0.19269474f, 0.17853875f, 0.12697665f, -0.15128759f, 0.00640481f, -0.03618096f, 0.06342379f, 0.28073698f, 
    0.16297372f, -0.14179865f, 0.25660157f, 0.09338144f, -0.01224332f, -0.03043933f, 0.58548307f, 0.22562747f, 
    -0.14345270f, 0.18576343f, -0.15327735f, 0.28526926f, -0.01157895f, 0.13100564f, -0.00916508f, -0.66011941f, 
    -0.02196279f, -0.04004006f, 0.29970062f, 0.46603036f, -0.12685752f, -0.17062123f, -0.40863177f, 0.08894205f, 
    -0.11718153f, -0.14182082f, -0.05654201f, 0.15420549f, 0.06716640f, 0.08296744f, 0.08064049f, 0.16901867f, 
    -0.00318817f, 0.03594108f, -0.21533002f, -0.02514746f, 0.05886721f, 0.22020495f, 0.00192107f, 0.20924602f, 
    0.46860567f, -0.13329025f, -0.20999181f, -0.01775874f, 0.04326914f, -0.33461893f, -0.40683046f, 0.06924392f, 
    0.03334007f, -0.09964167f, -0.05115016f, -0.05595863f, 0.07790646f, 0.01057802f, -0.07864716f, -0.04553564f, 
    -0.06925371f, -0.07468808f, -0.04415964f, -0.05693274f, 0.01191386f, 0.00357532f, -0.07586801f, -0.08739659f, 
    -0.01614820f, -0.01823395f, -0.04745005f, -0.07197872f, -0.06602173f, -0.07698733f, 0.02021203f, -0.04948032f, 
    -0.08900341f, -0.10290121f, -0.04278595f, -0.04273560f, 0.05655305f, 0.07725230f, 0.07226177f, 0.03201579f, 
    -0.01804388f, -0.03342539f, 0.03583262f, -0.06539051f, 0.03478263f, -0.01363388f, 0.00493250f, -0.03092377f, 
    0.05964764f, -0.04193958f, -0.06801507f, 0.03986148f, -0.01234317f, -0.05857195f, -0.08075272f, -0.04705223f, 
    -0.07587205f, -0.02553735f, -0.03381022f, 0.05390641f, 0.05110496f, 0.03096706f, 0.01488916f, 0.04908344f, 
    0.01312448f, 0.05439482f, -0.05952263f, -0.09869689f, 0.00362006f, -0.07567766f, 0.05964631f, 0.06597777f, 
    -0.05170213f, -0.00938704f, -0.04396686f, -0.04038260f, -0.00919600f, 0.05352604f, -0.08547018f, -0.07635782f, 
    -0.08377154f, 0.04202849f, -0.06332614f, 0.06170367f, -0.09194742f, 0.08029052f, 0.03696986f, -0.04376116f, 
    -0.04060079f, -0.05521221f, 0.05410270f, -0.00641705f, -0.10304072f, -0.04668847f, -0.02178871f, 0.03265043f, 
    -0.01362033f, 0.05794046f, 0.01092862f, 0.02630570f, 0.04361708f, -0.03761090f, 0.00822812f, -0.00616433f, 
    -0.07724889f, -0.08569567f, -0.05219094f, -0.06677225f, 0.02407167f, 0.04853957f, -0.01809069f, 0.02261365f, 
    0.07724942f, -0.08900267f, -0.09237026f, -0.10066738f, -0.01921511f, -0.08157107f, -0.06697267f, 0.03310230f, 
    0.01946936f, -0.00928590f, -0.10286787f, -0.00178978f, 0.02359750f, -0.08304600f, -0.02986311f, -0.09924319f, 
    0.02938598f, -0.02369605f, -0.02333917f, -0.09557678f, -0.02891629f, -0.00916304f, -0.02828003f, -0.01142704f, 
    -0.10132141f, -0.12630571f, 0.01161193f, 0.01377007f, 0.07633587f, 0.15093912f, -0.01666314f, -0.54873610f, 
    0.34429210f, -0.00475208f, 0.03416886f, -0.16149406f, 0.25690264f, -0.01791756f, 0.02025348f, 0.12611900f, 
    -0.07430862f, -0.27532521f, 0.29871571f, 0.14066626f, 0.45712048f, 0.10120565f, -0.10372484f, -0.19491757f, 
    0.24564801f, 0.18184583f, -0.10499556f, 0.20808551f, 0.29064018f, -0.22140169f, 0.12381930f, 0.18725030f, 
    0.01403425f, -0.07430250f, -0.10404803f, 0.30257800f, 0.01983076f, -0.21702679f, -0.56359774f, -0.05173917f, 
    -0.18816479f, -0.05188046f, -0.34612116f, 0.02988412f, 0.00544476f, 0.08775990f, 0.19388172f, -0.00472634f, 
    0.02291956f, 0.08637637f, 0.02393080f, -0.04226973f, 0.33463511f, -0.00239145f, 0.09986847f, 0.00918269f, 
    0.02428273f, 0.00828741f, -0.12359688f, 0.12084714f, 0.05053557f, 0.23772125f, 0.13912158f, -0.25252625f, 
    -0.02883707f, -0.07789534f, 0.05567145f, 0.26167026f, 0.21927612f, 0.24786520f, 0.15231274f, 0.01507454f, 
    -0.03304297f, 0.06091299f, -0.01396126f, -0.03128021f, 0.06375235f, -0.37784085f, -0.04149619f, 0.29710343f, 
    0.05219751f, 0.02117947f, -0.27408987f, 0.35602844f, 0.00870665f, 0.21650016f, 0.03813274f, 0.33854505f, 
    -0.11455148f, 0.19094685f, -0.02223496f, 0.07932008f, -0.12834506f, -0.05733960f, -0.11653352f, -0.22328599f, 
    -0.05019060f, 0.17988704f, -0.09133760f, 0.23049194f, -0.20096427f, -0.13460588f, -0.40827194f, 0.14734562f, 
    -0.21762893f, 0.04018000f, 0.13869397f, 0.24620007f, 0.05884001f, 0.11736681f, 0.10907417f, 0.21133861f, 
    -0.21726999f, 0.05661645f, -0.04856108f, -0.05051354f, 0.00733360f, 0.19319008f, -0.12290900f, -0.09804400f, 
    0.03909503f, 0.09178410f, -0.22432949f, -0.08404352f, -0.00691726f, -0.37064680f, -0.24910532f, -0.01551216f, 
    0.16647214f, 0.17061572f, -0.01868756f, -0.14558434f, 0.03975797f, -0.03913542f, -0.31290391f, -0.40055460f, 
    -0.01102613f, -0.10473075f, -0.03581660f, 0.09024356f, -0.02411758f, -0.33807331f, 0.28487587f, -0.26879096f, 
    -0.30750808f, 0.13116232f, -0.12962142f, -0.18815930f, -0.21724650f, 0.07894030f, 0.17484890f, -0.15687494f, 
    -0.05799430f, 0.03245540f, 0.45603982f, -0.14190982f, 0.26471362f, 0.17176703f, 0.11272464f, -0.07123131f, 
    0.00126644f, -0.36646640f, 0.08809194f, 0.21536201f, 0.16704169f, 0.01548863f, 0.00105834f, 0.09893317f, 
    0.19731823f, 0.03605447f, 0.45576602f, 0.06573829f, 0.10400280f, 0.07164197f, 0.04332844f, -0.09486235f, 
    0.01350586f, 0.21765737f, 0.21250136f, 0.16474058f, 0.30029652f, 0.04808299f, -0.14879151f, 0.03140702f, 
    -0.03648937f, 0.01159289f, -1.07981312f, -0.41154689f, -0.01122499f, -0.26740831f, -0.06269888f, 0.11841965f, 
    -0.24790771f, 0.11279045f, 0.08257841f, 0.12765718f, -0.04701666f, -0.10358694f, -0.46069816f, -0.17604259f, 
    0.19112043f, 0.00962509f, -0.39839125f, -0.20986123f, 0.01131420f, 0.08693594f, 0.06469500f, 0.26621094f, 
    0.25322267f, -0.13151522f, -0.15698335f, -0.30107385f, 0.05958163f, 0.09313822f, -0.59988493f, 0.01168454f, 
    0.06814378f, 0.08104267f, -0.17544696f, 0.07206140f, -0.09108497f, 0.09681971f, -0.41331258f, 0.33649060f, 
    -0.30242309f, -0.17968391f, 0.03441414f, 0.07570469f, 0.24666037f, -0.09960344f, 0.15167198f, -0.12004340f, 
    -0.52017152f, -0.20927632f, 0.09302130f, -0.06773908f, 0.11077829f, 0.05596329f, 0.02399719f, 0.25389045f, 
    0.25283867f, 0.18306659f, 0.36772263f, -0.01244869f, 0.06667890f, 0.23444016f, -0.01116476f, -0.41287285f, 
    -0.43457517f, -0.28997567f, 0.17002439f, 0.09961208f, 0.06795408f, 0.30854830f, 0.33206126f, -0.04158562f, 
    0.05922230f, -0.25716493f, 0.17337775f, 0.08065112f, -0.16320969f, -0.67697734f, 0.19624206f, 0.25141096f, 
    -0.13009341f, -0.09965660f, 0.17362499f, 0.19695458f, -0.05015066f, 0.06979490f, -0.05718639f, -0.19365670f, 
    -0.25422874f, 0.06536066f, 0.09359174f, 0.27114999f, -0.33895153f, -0.13200748f, 0.05749032f, 0.04609305f, 
    -0.02932359f, -0.09888401f, -0.06996419f, -0.00787193f, -0.36145127f, -0.03055486f, 0.08004186f, 0.48967215f, 
    0.30085388f, 0.13594785f, 0.18856688f, -0.22871086f, -0.01110048f, -0.22673708f, 0.14512931f, -0.08765911f, 
    0.06089395f, 0.05796975f, 0.09923865f, -0.00545684f, 0.10127863f, 0.02484952f, -0.24150267f, -0.38856426f, 
    0.09242635f, 0.27665842f, -0.14638770f, 0.03586193f, 0.00111963f, 0.03734516f, 0.27934158f, 0.04024368f, 
    0.05336573f, -0.10010114f, 0.46071306f, 0.38432321f, 0.26902065f, 0.20097187f, -0.17511365f, -0.16708058f, 
    0.22670984f, 0.07152854f, -0.08520331f, 0.10918008f, -0.08988211f, -0.01544969f, -0.36372268f, -0.18241845f, 
    0.01528894f, -0.17841078f, 0.23979680f, 0.12635562f, -0.10439708f, -0.12986986f, 0.04702054f, -0.29719120f, 
    -0.24004175f, 0.21347344f, 0.21184856f, 0.46553600f, -0.05952316f, -0.01237308f, -0.34792215f, 0.07470609f, 
    0.05239837f, -0.02849002f, 0.02689518f, -0.16686189f, 0.38437107f, -0.12488027f, 0.13087486f, 0.05563593f, 
    0.43788034f, 0.20500837f, 0.05870172f, 0.05098407f, 0.05674870f, 0.30856284f, -0.04332079f, 0.02451446f, 
    0.12009556f, 0.26671487f, 0.07982571f, 0.21612328f, -0.01035692f, 0.05102753f, -0.08955153f, -0.12737903f, 
    -0.17644012f, -0.07184633f, -0.25755548f, 0.05245145f, -0.07589343f, -0.08900538f, 0.18588552f, 0.06252816f, 
    -0.22599773f, 0.14036572f, 0.05658488f, 0.25133064f, 0.03731861f, 0.10531502f, 0.17802389f, 0.02815045f, 
    0.14197950f, -0.13494964f, -0.06193981f, 0.00722636f, 0.00146478f, 0.54291445f, 0.11319508f, 0.16342548f, 
    0.23927851f, 0.09939339f, 0.24992581f, 0.03480183f, 0.13199775f, -0.01988188f, -0.13812788f, 0.26202235f, 
    0.37130952f, 0.10037340f, 0.09147219f, 0.08068212f, 0.28696045f, 0.13569126f, 0.25289175f, -0.07089707f, 
    0.19192022f, -0.11645385f, -0.12619895f, -0.01083898f, -0.05227416f, 0.16536249f, -0.06397052f, 0.29088688f, 
    0.05639666f, 0.37009507f, -0.31144440f, -0.30783722f, -0.04788977f, 0.08416591f, 0.12640145f, 0.14012749f, 
    -0.19600391f, 0.01090599f, -0.31869206f, 0.03939734f, -0.04363547f, -0.08106644f, -0.00670383f, -0.08761119f, 
    -0.07652314f, -0.07240569f, 0.00169790f, 0.00488910f, 0.30181316f, 0.11469471f, -0.08393056f, 0.18813993f, 
    0.22879648f, -0.21532361f, 0.06883669f, -0.00820899f, 0.27650741f, -0.06705866f, -0.22469024f, 0.10169742f, 
    0.27068079f, -0.01421323f, -0.09575844f, -0.02685565f, 0.16428691f, 0.14532565f, 0.03409493f, -0.13517658f, 
    0.07936110f, -0.28871608f, 0.16014995f, 0.15171784f, -0.04527332f, -0.14721559f, -0.15474316f, -0.37179381f, 
    -0.33778474f, -0.05648961f, 0.13911054f, 0.21355829f, 0.10630458f, -0.08019339f, 0.29559398f, 0.00116481f, 
    0.22638652f, 0.06636737f, -0.02421893f, -0.00747314f, 0.18536600f, -0.02747557f, 0.10386773f, 0.00091738f, 
    -0.12163379f, 0.08452496f, -0.18028797f, -0.21854849f, -0.32725915f, 0.09892851f, 0.38975009f, -0.11081079f, 
    0.20966315f, 0.20870158f, 0.19302069f, 0.20769534f, 0.07639819f, 0.03069935f, -0.15826568f, -0.10437974f, 
    0.12044848f, 0.14104085f, 0.05234684f, 0.08397502f, -0.02466958f, 0.02935058f, 0.15465412f, -0.08106358f, 
    0.62530905f, -0.18131761f, 0.19694369f, 0.04577700f, -0.08893553f, -0.15058753f, -0.22373977f, -0.15775315f, 
    0.33385408f, 0.11824109f, -0.15894641f, -0.22208481f, -0.04815158f, -0.29065132f, 0.05822659f, -0.01921281f, 
    0.04024391f, -0.15703921f, 0.27201217f, 0.02264968f, -0.11648393f, -0.27354109f, 0.01501442f, 0.40476534f, 
    -0.27810869f, 0.16531605f, -0.04973457f, -0.17721975f, -0.14023890f, 0.17395209f, 0.15066014f, 0.20945422f, 
    -0.14914249f, -0.11101612f, 0.33291435f, -0.12304084f, 0.58641714f, 0.12108871f, 0.24703118f, -0.62262994f, 
    0.29002571f, -0.13986149f, 0.26490471f, -0.03110555f, -0.09357078f, -0.01397631f, 0.17490147f, 0.02414659f, 
    -0.07340525f, -0.05503131f, 0.05729070f, 0.16333349f, 0.04936048f, -0.03669488f, -0.08919438f, 0.08560319f, 
    -0.18469378f, -0.08120736f, 0.35123631f, 0.15427649f, 0.19679821f, 0.10464098f, 0.11800932f, 0.27959105f, 
    0.23375118f, 0.00379356f, -0.13042770f, -0.17400615f, 0.21192786f, 0.76924884f, -0.15848707f, 0.00764361f, 
    -0.09969665f, 0.24400200f, 0.08996066f, 0.06504998f, 0.17696317f, -0.13074225f, 0.25366127f, -0.29494384f, 
    -0.12359800f, 0.14371096f, -0.37944844f, -0.10635217f, -0.17396919f, -0.03977465f, 0.09710233f, -0.10346660f, 
    0.05425613f, -0.12191644f, -0.32199958f, 0.19487020f, 0.20431007f, -0.15209512f, -0.72810769f, 0.13623063f, 
    0.09011360f, 0.18021981f, 0.02100730f, -0.45084804f, -0.00447568f, 0.04418653f, -0.46958810f, 0.36623850f, 
    -0.27809063f, -0.14634134f, -0.00360716f, 0.31132594f, -0.15970616f, 0.08949699f, 0.36595961f, -0.48237661f, 
    0.06112284f, -0.12714273f, -0.18371795f, -0.00870586f, 0.22353369f, -0.04053656f, 0.02664335f, -0.17330591f, 
    0.04398125f, 0.21977848f, 0.22575800f, -0.00449661f, 0.01248190f, 0.17250879f, -0.26662096f, -0.52560318f, 
    0.10837797f, -0.20088769f, 0.20337313f, -0.01761610f, 0.18368505f, 0.25816235f, 0.48220038f, -0.02663575f, 
    -0.05857629f, -0.09571567f, 0.24335177f, 0.17553584f, 0.30967930f, -0.32168010f, -0.09679630f, -0.37031195f, 
    -0.39536572f, 0.09302177f, -0.21257225f, -0.08074777f, 0.38277793f, 0.10734113f, 0.05247237f, -0.69059342f, 
    0.17466845f, -0.21334362f, 0.19952643f, 0.25195280f, -0.20402151f, 0.10082642f, -0.03361189f, 0.15572217f, 
    -0.16230127f, 0.05843782f, -0.06320738f, 0.18418273f, 0.06673168f, -0.39555329f, 0.11473200f, -0.32808217f, 
    0.11005383f, -0.23535928f, 0.17660075f, 0.17783757f, 0.07018800f, -0.03058130f, -0.18331061f, 0.15831521f, 
    -0.04355534f, -0.05811426f, -0.21312049f, 0.12718852f, 0.10259806f, -0.01320656f, 0.15398429f, 0.22499301f, 
    0.13566375f, 0.05831923f, -0.16376363f, 0.06785929f, -0.03723649f, -0.06521170f, 0.15806364f, -0.24608578f, 
    -0.10420385f, 0.22694007f, 0.10501324f, 0.05878080f, -0.04592372f, 0.20598221f, 0.31147021f, -0.19493844f, 
    0.02752457f, -0.02929816f, 0.23146480f, 0.07905929f, 0.11211531f, 0.26950771f, -0.07196888f, 0.14131448f, 
    0.02164010f, 0.35447997f, 0.08931687f, -0.11043935f, 0.31797290f, -0.12510407f, 0.03784007f, 0.28612888f, 
    0.11175846f, 0.10811859f, -0.14206536f, 0.14740281f, 0.14468785f, 0.24280752f, -0.16708434f, 0.21977310f, 
    -0.18889676f, 0.09753543f, 0.22281475f, -0.04615123f, 0.18892001f, -0.01379386f, -0.09111574f, -0.20801853f, 
    0.12653553f, 0.22739081f, 0.05556724f, 0.38403755f, 0.24456726f, 0.16103984f, -0.18002701f, 0.16921806f, 
    -0.28459832f, -0.16463706f, -0.02227026f, -0.12629828f, -0.02576742f, 0.22821477f, 0.17243625f, -0.02147814f, 
    0.05354746f, -0.02599143f, 0.07901210f, -0.07350259f, 0.11491346f, 0.30895987f, -0.19669721f, -0.00733899f, 
    -0.49903059f, 0.26215678f, -0.20079806f, 0.02377541f, 0.08679891f, -0.31007916f, -0.10935117f, 0.19339226f, 
    0.04070103f, 0.13995376f, -0.03582788f, 0.14312629f, -0.01292486f, -0.10800397f, 0.03330053f, 0.03191125f, 
    0.04637355f, -0.18514706f, 0.12635066f, 0.05376127f, -0.09963549f, 0.03114274f, -0.00998642f, -0.31984052f, 
    -0.02897169f, -0.11028551f, -0.03923860f, 0.01883616f, 0.03449957f, 0.02433285f, -0.11976847f, 0.16004147f, 
    -0.16733350f, 0.11039758f, 0.23140833f, -0.00761930f, 0.50344783f, -0.12847997f, 0.29277492f, -0.41481110f, 
    0.24158408f, -0.11908804f, 0.26225725f, -0.05229568f, 0.08469132f, -0.26669216f, 0.17323694f, -0.16859479f, 
    0.05613348f, -0.01843622f, 0.00233373f, 0.05165014f, 0.05985538f, -0.06556281f, 0.12634341f, -0.44761312f, 
    -0.13090172f, 0.12672636f, -0.31008425f, 0.18361802f, 0.14365424f, -0.14279179f, 0.19432688f, -0.11162072f, 
    -0.37211040f, 0.29715326f, 0.05553574f, 0.12664510f, 0.09720924f, 0.27282235f, 0.15832578f, -0.19657263f, 
    0.06031877f, 0.30072165f, -0.05900143f, 0.11779196f, -0.00448262f, -0.04468927f, 0.45979157f, -0.06357478f, 
    0.18549198f, 0.02825607f, 0.06289287f, -0.00642643f, 0.08769909f, 0.18804364f, 0.19664986f, 0.20497163f, 
    0.20921265f, 0.13156679f, -0.06956869f, 0.16638617f, -0.17726994f, -0.02849473f, -0.66724735f, 0.06937500f, 
    -0.04754423f, -0.03250463f, 0.08795490f, -0.22281687f, 0.01362941f, -0.20367703f, -0.01355795f, 0.30753145f, 
    0.09511474f, -0.14041810f, 0.11326180f, 0.10935207f, 0.41806003f, 0.01842482f, -0.04396456f, -0.01067098f, 
    0.19128555f, 0.09736121f, -0.23218715f, -0.11348881f, 0.16525052f, -0.13925664f, 0.11555469f, 0.14380991f, 
    -0.02283913f, 0.06866342f, 0.06736455f, -0.10631595f, 0.04362471f, 0.17936662f, -0.02932235f, -0.00471080f, 
    -0.12285631f, 0.35194737f, 0.09256817f, 0.14251401f, 0.01682351f, 0.24716379f, 0.44995546f, 0.18906337f, 
    0.27567789f, 0.04183317f, 0.03045890f, 0.06664314f, -0.37530261f, 0.25466481f, 0.13248478f, 0.00906248f, 
    -0.00159706f, -0.04267571f, 0.16247869f, -0.05869476f, -0.14572871f, -0.15280366f, 0.17819960f, 0.04475883f, 
    -0.09154598f, 0.34678093f, -0.05286512f, -0.22029364f, -0.04203746f, -0.01800278f, -0.24765578f, 0.14078291f, 
    0.03084866f, -0.22720058f, 0.42674920f, -0.19968979f, -0.08848910f, -0.09234526f, -0.32979870f, -0.31990701f, 
    -0.15782855f, -0.10669956f, 0.38299045f, 0.11319041f, -0.10009562f, -0.05210664f, -0.30143264f, -0.17349906f, 
    -0.24296740f, 0.06369558f, 0.08084107f, 0.11865380f, -0.03451193f, -0.01964688f, 0.17504773f, 0.14118636f, 
    -0.12878689f, -0.09393811f, 0.13990085f, 0.03233282f, 0.27074060f, 0.11388101f, 0.43737027f, 0.04641996f, 
    0.04608657f, -0.15461653f, 0.01387894f, -0.25359190f, 0.12569048f, 0.01530804f, 0.14328122f, 0.15637131f, 
    -0.00762489f, 0.15844081f, 0.15003377f, -0.01055091f, 0.10130294f, 0.02599751f, -0.25320905f, -0.51682842f, 
    0.01718221f, 0.08051480f, -0.37027547f, 0.21817766f, -0.01330496f, -0.03204471f, -0.08249082f, 0.04738406f, 
    -0.22548847f, -0.43336862f, 0.10134475f, -0.00364763f, 0.21499561f, 0.08539595f, -0.22848360f, 0.03917868f, 
    0.23359376f, 0.09133741f, 0.13615680f, -0.24494599f, -0.07490524f, 0.12817203f, -0.11093176f, 0.34447673f, 
    0.04679896f, -0.17168000f, 0.20402321f, 0.04207562f, -0.00958922f, 0.19443171f, 0.36998263f, -0.20618714f, 
    0.19724569f, 0.03460950f, -0.16396095f, 0.06425522f, 0.26325658f, 0.09532894f, 0.14366303f, 0.01959959f, 
    0.33599746f, 0.15557007f, 0.28158408f, 0.01476043f, 0.05544250f, 0.10630579f, 0.03327428f, 0.01585446f, 
    -0.28199366f, 0.05300737f, 0.07957361f, 0.09873149f, 0.02910003f, 0.38937122f, 0.47154045f, -0.14299847f, 
    0.14875987f, 0.03060647f, 0.10474087f, -0.04848126f, 0.00723164f, 0.23424798f, 0.05040592f, -0.09023215f, 
    0.00631153f, 0.10992527f, 0.05180582f, 0.01673839f, 0.07460769f, 0.00220656f, 0.10653639f, 0.10150118f, 
    0.16220567f, 0.07519312f, 0.13160051f, 0.20553175f, 0.24467689f, 0.28929338f, 0.15819584f, 0.08329353f, 
    0.08953270f, -0.13697679f, 0.08817956f, -0.15063973f, 0.41556349f, 0.10548905f, 0.10390989f, -0.19767892f, 
    0.14530793f, 0.26048270f, 0.03770237f, -0.23301233f, 0.02884738f, -0.02979922f, 0.36262175f, 0.11889508f, 
    -0.14635855f, 0.00443841f, -0.01914332f, 0.02464470f, -0.04059974f, -0.02143981f, -0.01909786f, -0.19079693f, 
    -0.07733206f, -0.01438119f, 0.18927549f, 0.05340134f, 0.18953213f, 0.03371478f, -0.00375701f, 0.36097017f, 
    0.22024234f, -0.00407860f, 0.01014516f, -0.02422068f, 0.37521127f, 0.37553695f, -0.20942514f, 0.03594639f, 
    0.15416124f, 0.18948342f, -0.10719441f, 0.07670919f, 0.23042071f, -0.05104512f, 0.16341978f, -0.15636796f, 
    0.05538291f, -0.23698397f, -0.00162977f, 0.08868486f, -0.00516165f, -0.12433495f, -0.08953423f, -0.31894746f, 
    -0.23435573f, 0.00611598f, 0.05654754f, 0.16685855f, 0.18847619f, -0.02988915f, 0.15160292f, 0.05801425f, 
    0.17985108f, 0.01132750f, -0.03369805f, -0.03489760f, 0.22209628f, -0.03643924f, -0.04121131f, 0.37202349f, 
    0.01828445f, 0.01927892f, -0.14486662f, -0.65878564f, -0.02002502f, -0.12706293f, 0.41773570f, -0.11300313f, 
    0.05358464f, 0.03827395f, 0.10160948f, -0.04596993f, 0.00573911f, 0.06593854f, -0.07991184f, -0.03165090f, 
    0.35228869f, 0.24193531f, 0.13448371f, 0.05932852f, -0.12387370f, -0.01506715f, 0.00792234f, -0.18637103f, 
    0.43676713f, 0.11461000f, 0.08034027f, 0.24248302f, 0.08594113f, 0.00288328f, 0.28206348f, -0.06518663f, 
    -0.06516467f, 0.18959142f, 0.19865370f, 0.05277119f, 0.30151781f, -0.34495464f, -0.10080179f, -0.11581213f, 
    -0.48993298f, 0.00812563f, -0.16542247f, -0.12187179f, 0.25773036f, -0.08124379f, 0.17435580f, -0.77175975f, 
    0.44546211f, -0.13401721f, 0.17432393f, 0.16482554f, 0.03257137f, 0.14204815f, 0.08465353f, 0.13799128f, 
    -0.17635290f, 0.00572928f, -0.11040656f, 0.10080308f, 0.40398261f, -0.06571165f, 0.14500669f, -0.31155822f, 
    -0.00269053f, -0.17181709f, 0.15040691f, 0.10844287f, 0.01467343f, 0.21827714f, -0.01052191f, 0.21169223f, 
    -0.00641612f, -0.04749002f, -0.32120726f, 0.06021693f, 0.02081424f, 0.09727296f, -0.02539085f, 0.24437375f, 
    0.08405809f, -0.01169966f, 0.18627328f, -0.00129640f, 0.02821478f, -0.05197032f, -0.07079624f, -0.08503556f, 
    0.01538740f, 0.18805858f, -0.00471787f, -0.03464643f, -0.07725741f, 0.24440633f, 0.06035833f, 0.01742077f, 
    0.00318267f, 0.09049971f, 0.15365838f, 0.04634910f, 0.07258289f, 0.08410338f, 0.03781246f, 0.06426037f, 
    -0.01574022f, 0.36179543f, 0.10573637f, -0.09627847f, 0.15931444f, -0.11187762f, 0.06583265f, 0.13010021f, 
    0.06697413f, -0.04155669f, -0.15844022f, -0.02122107f, 0.05061931f, 0.13896886f, -0.04262263f, 0.17158647f, 
    -0.12648012f, 0.08171358f, 0.07019719f, 0.02469146f, 0.12768660f, -0.00534015f, -0.09933938f, -0.20558499f, 
    0.01521973f, 0.02428616f, 0.09043276f, 0.22919647f, 0.17561904f, -0.00924433f, -0.21879321f, 0.03615377f, 
    -0.12279944f, -0.28273612f, -0.05203081f, -0.08827149f, -0.11390585f, 0.21854603f, 0.08932952f, 0.18732280f, 
    0.07430917f, -0.04771442f, -0.02233733f, 0.01430236f, 0.08107803f, 0.34981194f, -0.07322302f, -0.06508933f, 
    -0.12356977f, 0.10005746f, -0.31923747f, 0.11724354f, 0.14840479f, -0.44731021f, -0.07990610f, 0.27814153f, 
    -0.13372827f, -0.33778778f, 0.11271746f, -0.07943637f, 0.21588756f, -0.25151035f, 0.16075139f, -0.23360933f, 
    0.26744097f, 0.15256855f, 0.11308547f, -0.30910921f, 0.19792435f, -0.18512309f, 0.07051270f, -0.45739084f, 
    1.06244576f, 0.10153100f, 0.27916005f, 0.01785372f, 0.18344054f, 0.09028455f, 0.19961363f, -0.03567659f, 
    -0.03877380f, 0.01317424f, -0.20633446f, 0.09835425f, 0.21403989f, -0.05830036f, 0.03258820f, 0.00174213f, 
    -0.17962264f, 0.25413343f, 0.32711262f, 0.16689387f, 0.20842890f, 0.14693728f, -0.22072405f, 0.17380956f, 
    -0.61842704f, -0.01318001f, 0.21387325f, 0.01603282f, 0.03681660f, 0.00307215f, 0.08593857f, -0.22103627f, 
    0.11867719f, -0.20505056f, 0.12418500f, -0.16732611f, 0.15888552f, 0.14161164f, -0.21870458f, 0.05169338f, 
    0.11925167f, -0.13127057f, -0.27126309f, 0.09194025f, 0.10536639f, -0.31234366f, 0.03894426f, 0.11600833f, 
    0.14743723f, 0.02135533f, 0.08177795f, 0.18519896f, 0.12899190f, 0.09661230f, -0.24509567f, -0.24183154f, 
    -0.33194306f, 0.24422809f, -0.25205600f, 0.25221768f, 0.11487945f, -0.22298914f, -0.11960020f, 0.08752067f, 
    -0.31981719f, 0.17075403f, -0.27960363f, -0.27542767f, 0.11509369f, 0.06790994f, -0.42101356f, 0.15051220f, 
    0.21249920f, 0.23813164f, 0.20091304f, 0.22196221f, 0.26189166f, -0.03144825f, -0.10842589f, 0.17336935f, 
    0.07476408f, 0.13200362f, -0.25988102f, -0.63826072f, -0.12284758f, 0.25521526f, 0.17047110f, 0.07779248f, 
    0.02331661f, 0.26251048f, 0.18589704f, 0.26776567f, 0.12867497f, 0.10736053f, 0.10044640f, 0.03117916f, 
    0.25103068f, -0.06252425f, 0.01198721f, 0.04740839f, -0.07188895f, 0.24703664f, -0.22972807f, -0.48904794f, 
    -0.14103301f, -0.38275433f, -0.30362689f, -0.12657209f, 0.06793600f, 0.11798782f, 0.14568390f, -0.27448094f, 
    -0.08436465f, -0.08304509f, -0.04537073f, -0.05246272f, -0.09603114f, 0.06694534f, 0.02531010f, 0.01059347f, 
    -0.11241278f, 0.03911737f, -0.07327142f, -0.07034786f, 0.07392035f, -0.08230710f, -0.00022777f, 0.05451299f, 
    -0.08382738f, 0.00164056f, 0.00063278f, 0.02576547f, -0.06761754f, -0.13135301f, -0.01736546f, 0.01138984f, 
    -0.09526756f, 0.07087447f, -0.03668370f, -0.06883945f, -0.04842572f, -0.11933812f, -0.01710460f, -0.07811730f, 
    -0.11190176f, -0.01065885f, -0.03791047f, -0.10610554f, 0.07965118f, 0.01907455f, 0.05023043f, -0.09194027f, 
    -0.02229637f, 0.04675026f, -0.00699336f, -0.00007691f, 0.06643733f, 0.02618431f, -0.06302822f, -0.00673678f, 
    0.05221568f, -0.05911839f, -0.09538284f, 0.04152388f, 0.01974302f, 0.04340415f, -0.10071119f, 0.00735622f, 
    0.04485074f, -0.01810406f, -0.03016928f, 0.05478035f, 0.03474512f, -0.03948454f, -0.01254181f, 0.03004536f, 
    -0.01716630f, -0.05582482f, 0.06281897f, -0.08068296f, -0.02550140f, -0.05810047f, 0.03266912f, -0.06962311f, 
    -0.07584101f, -0.08918405f, 0.03388631f, -0.07633713f, -0.08031861f, -0.08481227f, -0.07097933f, -0.06367823f, 
    0.04715751f, 0.00545716f, -0.06125844f, -0.11007139f, 0.04405711f, 0.05873524f, -0.04512307f, -0.07902409f, 
    0.07177146f, -0.06970613f, 0.05057984f, -0.07672744f, -0.08865193f, -0.01085718f, -0.03958973f, 0.00893013f, 
    -0.05673569f, 0.01757143f, 0.03670841f, -0.03592638f, -0.03087601f, -0.05831464f, 0.02341480f, 0.01989629f, 
    -0.04401082f, 0.06814324f, 0.03410565f, 0.03986106f, -0.06551213f, 0.06972263f, 0.03031532f, -0.07611524f, 
    0.05999237f, -0.09434222f, 0.06573652f, -0.00222885f, -0.08799203f, 0.04471459f, -0.02592727f, 0.06009356f, 
    0.00127063f, 0.07405081f, -0.03120694f, 0.03586023f, -0.05858039f, 0.01076427f, -0.08711512f, -0.07176981f, 
    0.02750680f, 0.49439868f, 0.09779986f, -0.17042407f, 0.02113082f, 0.42580041f, -0.02465974f, 0.25484180f, 
    0.37371388f, -0.35909873f, 0.24263693f, -0.03741576f, -0.16338408f, 0.11905270f, 0.26380426f, 0.22135016f, 
    0.56530440f, 0.09425450f, -0.15311995f, -0.11400942f, 0.17081547f, 0.23525369f, 0.10930816f, 0.17094648f, 
    0.30122194f, -0.03988485f, -0.09367628f, -0.17647101f, 0.08173236f, 0.56413674f, 0.07624689f, 0.28585917f, 
    0.01421389f, -0.07618899f, -0.27402183f, 0.09195776f, -0.02549135f, -0.14445585f, 0.17696874f, -0.14478059f, 
    0.22631332f, 0.01663856f, 0.25713414f, -0.22063325f, 0.02827090f, -0.04029712f, -0.06774003f, -0.20856421f, 
    0.11385535f, 0.22536279f, 0.16886461f, -0.01278725f, -0.11799377f, -0.08634120f, -0.12171442f, 0.18298949f, 
    -0.02168580f, -0.11987004f, 0.16647735f, -0.03944662f, -0.09024513f, 0.11443913f, -0.13753498f, 0.10739391f, 
    0.03772930f, 0.12021925f, -0.25239679f, 0.16224295f, -0.03725782f, -0.40264940f, -0.01648030f, 0.16703963f, 
    0.27536732f, -0.06981689f, 0.30553293f, 0.03748414f, -0.19155389f, 0.12912904f, -0.09263852f, -0.03735167f, 
    0.05572769f, -0.24956645f, 0.46200135f, -0.23195738f, -0.10344132f, 0.01345990f, 0.21777654f, -0.13823122f, 
    0.03066108f, -0.28313139f, -0.13189168f, 0.44802898f, 0.01129792f, 0.19788919f, 0.22169469f, -0.26144889f, 
    -0.06253938f, -0.15521219f, 0.39296290f, -0.31720224f, 0.01676233f, -0.01191354f, -0.32598007f, 0.20580567f, 
    0.11987519f, -0.03764801f, -0.17139508f, 0.36557719f, -0.01111757f, 0.06253400f, -0.07238839f, 0.27253571f, 
    -0.18658614f, -0.08418560f, -0.04347217f, -0.01680335f, -0.08533610f, 0.04483628f, 0.20486838f, 0.21662015f, 
    0.62572664f, -0.27521759f, -0.32314545f, -0.06127680f, 0.10560154f, -0.17271550f, -0.11352766f, 0.05993569f, 
    0.24914975f, 0.32982010f, 0.06857070f, -0.00896255f, 0.02271672f, -0.10238924f, -0.07039395f, 0.04164432f, 
    -0.32970747f, -0.08446673f, 0.01024783f, -0.06126178f, -0.05276736f, -0.39444625f, 0.25301036f, -0.21336555f, 
    -0.24362586f, 0.15031621f, -0.12367679f, -0.21141544f, -0.44460568f, 0.04569614f, -0.04065933f, 0.13041312f, 
    -0.14002350f, 0.11781134f, 0.48540381f, -0.10443171f, 0.16971251f, 0.00692992f, -0.13971494f, -0.68518347f, 
    -0.16961503f, -0.46661001f, 0.09565765f, 0.14629076f, -0.18144882f, -0.05865890f, -0.17673784f, 0.16721329f, 
    -0.06091878f, 0.00316018f, 0.39459354f, 0.14473966f, 0.01862430f, -0.06778789f, 0.03796893f, -0.16514155f, 
    0.06276428f, 0.00639457f, 0.26674145f, 0.13112915f, 0.21669438f, 0.12258899f, 0.00684703f, -0.04126697f, 
    0.01440087f, -0.08321877f, -1.04438734f, -0.40629855f, 0.06059797f, -0.31336534f, -0.08236112f, 0.12627904f, 
    -0.33732015f, 0.18525387f, 0.06810939f, 0.01318770f, 0.07919755f, -0.12700832f, -0.58603293f, -0.29490092f, 
    0.13879003f, 0.06199552f, -0.91383958f, -0.12631686f, 0.14982472f, 0.09428560f, 0.00008159f, 0.22539975f, 
    0.07998157f, -0.14758416f, -0.16529942f, -0.25085810f, 0.19824137f, 0.15928608f, -0.60591465f, -0.03441732f, 
    0.12685966f, 0.14098677f, 0.05748216f, 0.03315262f, -0.20640528f, 0.15877275f, -0.41856992f, 0.35530877f, 
    -0.30774263f, -0.12271821f, -0.14420348f, 0.21639580f, 0.16240598f, 0.03897969f, 0.30676314f, -0.13113208f, 
    -0.28955597f, -0.01019084f, -0.03385388f, -0.15543495f, 0.13236609f, -0.08963954f, 0.07158445f, 0.04799071f, 
    0.14371836f, 0.26231381f, 0.38054791f, 0.03314067f, 0.06561130f, 0.21691419f, 0.13403656f, -0.67599970f, 
    -0.33515209f, -0.23512556f, 0.14411649f, 0.07523119f, 0.06768430f, 0.71028215f, 0.33327374f, -0.10299214f, 
    0.07679662f, 0.13715374f, -0.27717149f, 0.13133581f, -0.04046232f, -0.32756746f, 0.13805662f, 0.41728052f, 
    0.41812256f, 0.01320635f, 0.25562331f, 0.49005726f, -0.27868733f, 0.27725774f, -0.12679134f, 0.86289972f, 
    -0.99676514f, 0.06066132f, -0.21895476f, -0.20271069f, -0.06886898f, -0.36976632f, -0.14927109f, -0.04418585f, 
    0.08805748f, 0.09403156f, 0.23589489f, 0.17113708f, -0.65424526f, 0.18911196f, -0.02396935f, 0.49751681f, 
    0.18053190f, 0.17038722f, -0.13642111f, -0.12503120f, -0.09661160f, 0.12688768f, 0.14403214f, -0.14230059f, 
    0.17077540f, 0.05761101f, 0.11637179f, -0.14436544f, -0.06592932f, -0.04478608f, 0.05829133f, -0.43800238f, 
    0.02320217f, 0.38490555f, -0.16501801f, 0.13649723f, -0.11252140f, -0.03193675f, 0.45496812f, -0.17871112f, 
    -0.11099085f, 0.06611202f, 0.47782394f, 0.21209005f, 0.25021800f, -0.29094124f, -0.04797741f, 0.11024522f, 
    0.34788018f, -0.03898391f, -0.08249614f, -0.12838691f, -0.15975101f, 0.14676256f, -0.03166947f, 0.17661871f, 
    -0.04356004f, -0.13396212f, 0.17737010f, -0.03253443f, -0.19384637f, 0.17541768f, 0.34198755f, -0.10133772f, 
    0.26081491f, 0.06477363f, 0.21364304f, 0.29425225f, -0.08348424f, -0.30259883f, 0.50089091f, -0.12958802f, 
    0.31941062f, -0.02627666f, 0.17401946f, 0.17502272f, -0.02904505f, 0.12820017f, 0.21968240f, -0.07981002f, 
    0.05941667f, 0.18749787f, 0.13294049f, 0.93729156f, -0.14886217f, 0.29333824f, 0.21772271f, -0.05671562f, 
    0.18444000f, 0.33395168f, -0.09436943f, 0.10851027f, 0.37785307f, -0.03461788f, 0.03813127f, 0.05102158f, 
    -0.50220984f, 0.00090021f, 0.04643238f, 0.01355780f, 0.05376351f, -0.39026007f, 0.05806134f, 0.43887216f, 
    -0.40588897f, 0.00891356f, 0.54043055f, -0.00161495f, 0.08766887f, 0.32007459f, -0.04603331f, 0.10587526f, 
    0.13183102f, -0.00896062f, -0.28763416f, 0.12360899f, 0.04114237f, -0.15849081f, 0.14934321f, -0.15054710f, 
    0.82382846f, -0.07535966f, 0.20694260f, 0.00848044f, 0.10667917f, 0.03669849f, -0.06077437f, 0.59784073f, 
    0.43601286f, -0.03409739f, 0.06221193f, -0.13596399f, 0.14986679f, -0.21693280f, -0.15370192f, -0.08007812f, 
    0.12140969f, 0.20123276f, 0.09775699f, -0.01770337f, -0.45857972f, 0.01034920f, 0.03992995f, 0.46435893f, 
    -0.30890983f, -0.26810306f, -0.06411829f, 0.50651652f, -0.15637787f, -0.26550639f, -0.50624853f, 0.03011965f, 
    0.03707967f, 0.06680456f, 0.22302811f, 0.03865103f, 0.05009464f, -0.01452624f, 0.28063440f, -0.01643603f, 
    -0.17263885f, 0.36020058f, -0.28391722f, 0.04075629f, -0.01661716f, 0.10049412f, 0.14356437f, 0.01820865f, 
    -0.23684667f, 0.06597330f, -0.10983971f, 0.22108555f, -0.20252420f, -0.03321154f, 0.20572363f, -0.14887394f, 
    0.00574278f, -0.01497363f, -0.07948062f, -0.03098701f, 0.12667239f, 0.20732856f, 0.03235104f, -0.05402200f, 
    0.24391948f, 0.08158330f, -0.26378745f, 0.18478227f, 0.12004430f, 0.09676895f, -0.01534250f, 0.35161844f, 
    0.29751763f, 0.04964415f, -0.07667415f, 0.01797323f, -0.14129421f, -0.01893384f, -0.06987014f, 0.00961461f, 
    -0.09582883f, -0.06841613f, 0.06259169f, -0.03079016f, -0.04401419f, -0.01150932f, -0.03798100f, -0.32911611f, 
    0.10647821f, 0.06994691f, 0.18258254f, 0.17228208f, 0.15389816f, -0.02131620f, -0.31041536f, 0.13667241f, 
    0.03402641f, 0.06155826f, -0.08774030f, 0.32181656f, 0.21269833f, -0.02355042f, 0.12329511f, 0.22997566f, 
    -0.00740404f, 0.18852353f, -0.01083336f, -0.06647769f, 0.17519331f, -0.12063955f, 0.00720507f, 0.11966965f, 
    -0.12161916f, 0.29202107f, 0.11282291f, -0.24743557f, -0.10996777f, 0.18957098f, -0.05518080f, -0.03081474f, 
    -0.04519771f, 0.16114263f, -0.09011311f, 0.10005981f, 0.14067362f, 0.29048872f, 0.09580231f, -0.16661873f, 
    0.01209454f, 0.22070974f, 0.02448510f, 0.10001818f, 0.00472293f, 0.00463792f, 0.12289310f, -0.28224316f, 
    -0.26844910f, -0.03420440f, -0.16808555f, 0.01734910f, 0.14078103f, -0.03628538f, 0.22797248f, -0.13412604f, 
    0.17526856f, 0.20803399f, -0.01300366f, 0.32612365f, -0.51595193f, -0.01882779f, -0.09984705f, 0.33253437f, 
    -0.19124998f, -0.01076740f, -0.45048553f, 0.31115216f, 0.17507297f, 0.39219594f, -0.21694614f, 0.08545335f, 
    -0.06646376f, -0.01743417f, -0.07053678f, -0.01238044f, 0.05932854f, -0.07429734f, 0.13069724f, 0.27494264f, 
    0.15150429f, 0.08083222f, -0.06554017f, 0.04056937f, -0.05249307f, 0.04611061f, -0.00306150f, -0.22099991f, 
    -0.21508706f, 0.15285920f, -0.01060982f, 0.05638952f, -0.08117719f, -0.42039680f, 0.23776697f, 0.12402371f, 
    0.02549841f, -0.18735673f, -0.03464348f, 0.23271570f, 0.00073858f, 0.14852980f, -0.21839114f, 0.18737260f, 
    0.27681544f, -0.00575203f, 0.11133206f, -0.14812137f, -0.04483635f, 0.10972524f, 0.09556086f, 0.01889469f, 
    0.19945931f, 0.08134291f, 0.25327581f, -0.03915206f, -0.02998117f, 0.12917581f, 0.29114288f, -0.16666012f, 
    0.05343825f, 0.09243256f, 0.09431081f, -0.14361650f, -0.30168551f, 0.04979993f, 0.14004390f, -0.45807257f, 
    0.00747822f, 0.02613137f, 0.16865399f, 0.53299940f, 0.01772605f, -0.09829719f, -0.42718905f, 0.15981080f, 
    -0.11404409f, -0.12230265f, 0.18445833f, -0.00192709f, 0.03446322f, 0.10463780f, 0.04070764f, 0.27119991f, 
    -0.26068136f, 0.14761171f, 0.07512973f, -0.00648402f, 0.19658794f, 0.05508473f, 0.18106504f, 0.08510560f, 
    0.52122891f, 0.23457028f, 0.22029068f, -0.08604953f, -0.06211726f, -0.46667516f, -0.51197511f, 0.07409228f, 
    -0.19098336f, -0.04318129f, 0.36515066f, 0.09713703f, 0.27488753f, -0.11711036f, 0.00377189f, 0.02883801f, 
    -0.37785256f, 0.19393879f, -0.48080006f, -0.22079326f, 0.23745409f, -0.34217036f, -0.02374932f, -0.15211621f, 
    0.51385611f, -0.09785470f, 0.06071064f, 0.10826868f, -0.20940731f, 0.09391809f, -0.16837968f, 0.14398867f, 
    -0.09965521f, 0.28693146f, -0.18335003f, 0.14476034f, 0.35445467f, 0.06663056f, -0.05056531f, -0.07461992f, 
    -0.40593272f, -0.32888591f, -0.02992891f, -0.04397298f, 0.10447638f, 0.10871069f, -0.05526881f, 0.19692701f, 
    -0.21296538f, -0.05774561f, 0.30854607f, 0.21857186f, -0.03578958f, 0.06403334f, 0.06485552f, 0.79887325f, 
    0.23016168f, -0.47339305f, 0.47375262f, 0.21911250f, -0.22163522f, 0.34534270f, -0.75629199f, 0.27634114f, 
    0.25200704f, 0.13188504f, -0.44528878f, -0.14743865f, -0.46775964f, -0.11611387f, 0.04117502f, 0.15855584f, 
    -0.25604203f, -0.18636246f, 0.14193046f, -0.11777383f, -0.09498760f, -0.02031264f, -0.90422422f, -0.09798850f, 
    -0.03583112f, 0.01864179f, 0.11633238f, -0.02953504f, 0.09596561f, 0.00600463f, -0.03144322f, 0.34177664f, 
    -0.35880500f, 0.08417397f, -0.19587955f, -0.44130385f, 0.19509372f, 0.03788184f, -0.11439089f, 0.10896809f, 
    -0.03328059f, 0.28643456f, -0.16245098f, 0.22206724f, 0.07033090f, -0.04459008f, -0.09065470f, -0.10597049f, 
    -0.11476514f, 0.15053202f, -0.05062770f, -0.36750016f, -0.16305161f, -0.22307681f, 0.17203766f, -0.02479511f, 
    0.19479619f, 0.34777188f, 0.22840284f, -0.30330786f, -0.45024315f, 0.09618285f, 0.12483627f, -0.05591552f, 
    0.37458554f, -0.16341373f, -0.33185229f, 0.03718619f, 0.00002518f, 0.12742464f, -0.09099041f, -0.32410845f, 
    0.06715959f, -0.64431685f, -0.23418844f, -0.06354228f, -0.08498409f, 0.10355153f, -0.06499658f, -0.04922187f, 
    0.11951905f, -0.09879510f, -0.13327955f, 0.09207343f, -0.14375810f, -0.34668836f, 0.02188149f, 0.08865609f, 
    0.22604728f, -0.04644967f, 0.19595423f, 0.20445964f, -0.03302094f, 0.20259084f, 0.08688752f, 0.13647906f, 
    -0.51133043f, -0.02559294f, -0.05562456f, -0.04082806f, -0.14134286f, -0.25453204f, -0.08925591f, -0.05029478f, 
    0.05152774f, -0.13394535f, 0.01917070f, -0.10114166f, -0.19196929f, -0.05122023f, 0.27509451f, 0.12208956f, 
    0.13654122f, 0.00904883f, 0.24058585f, 0.13582243f, -0.03700337f, -0.11483903f, -0.11015089f, -0.02332024f, 
    0.28506643f, 0.07194731f, 0.10564416f, -0.13393512f, -0.01777936f, 0.03654698f, -0.06018097f, -0.27597284f, 
    -0.03435329f, 0.39831725f, -0.12786515f, -0.02272813f, 0.07292410f, -0.06206086f, 0.53155041f, 0.07771153f, 
    0.01662720f, 0.12545003f, 0.27516961f, 0.27166414f, 0.13649520f, 0.07837109f, 0.05359607f, -0.03649328f, 
    0.15972446f, 0.06760034f, 0.04091120f, 0.10386498f, 0.04105259f, -0.04292054f, 0.25035110f, -0.09358034f, 
    0.14666313f, 0.07497387f, 0.03873942f, -0.01407045f, 0.06413832f, 0.11374404f, 0.16524072f, 0.07456572f, 
    0.33511165f, -0.02722220f, 0.00547056f, 0.39363322f, -0.17658561f, 0.05305155f, -0.18560813f, 0.03111683f, 
    -0.00031842f, -0.10999200f, 0.07633204f, 0.02388722f, 0.16453332f, -0.04212658f, 0.13466835f, 0.15841587f, 
    0.16409631f, -0.01472042f, 0.27322185f, 0.32280141f, 0.18560207f, 0.28293625f, -0.19998947f, 0.04717505f, 
    0.00284281f, 0.04070099f, -0.13363284f, 0.28191966f, 0.10013033f, 0.07652494f, 0.06820894f, 0.15622719f, 
    -0.26798713f, 0.04737373f, -0.13081130f, 0.03248098f, 0.07608292f, -0.10433935f, 0.01493423f, 0.29827040f, 
    -0.27764717f, 0.14843014f, 0.02496898f, -0.05258982f, 0.10564536f, 0.06635729f, 0.29988351f, 0.05009213f, 
    -0.25313008f, -0.17988254f, -0.04119441f, -0.00103479f, 0.26696032f, -0.11873385f, -0.00292800f, -0.11181754f, 
    0.05116608f, 0.03079949f, -0.20894596f, -0.39236975f, 0.32611567f, 0.06380823f, -0.01246617f, 0.76445889f, 
    0.57896167f, -0.29889098f, 0.30892265f, 0.33180702f, 0.31076542f, 0.18270923f, 0.09551444f, -0.19550958f, 
    -0.00282535f, -0.05532854f, -0.38617265f, 0.02054252f, 0.26691955f, 0.17085426f, 0.05188867f, 0.28063783f, 
    0.19274507f, 0.11124925f, -0.15682237f, 0.11568914f, -0.17278886f, -0.03891912f, -0.21177334f, 0.18671557f, 
    0.03950980f, 0.01757085f, 0.10038326f, -0.08432325f, 0.07884369f, 0.06604242f, -0.11922089f, 0.15677363f, 
    0.11440455f, -0.17211512f, -0.02539397f, -0.03605047f, 0.31407896f, -0.20998900f, -0.02185512f, 0.08561961f, 
    0.00371378f, 0.04768414f, 0.12520497f, 0.10707463f, 0.07368200f, 0.63516313f, 0.17223163f, -0.05108359f, 
    -0.00136895f, -0.37691185f, 0.23533528f, 0.18721464f, 0.04209781f, 0.02687236f, 0.34049985f, -0.02149251f, 
    -0.44655645f, -0.08351586f, 0.27697375f, -0.09097882f, 0.06226132f, -0.23938069f, -0.08863650f, 0.09135779f, 
    0.11158884f, -0.16358697f, -0.28159964f, 0.49198014f, -0.04023449f, 0.34071112f, 0.31740716f, 0.07872432f, 
    -0.42298892f, 0.18080862f, -0.28437942f, 0.17706184f, 0.09132320f, -0.12895772f, 0.02494762f, 0.08310908f, 
    0.05319794f, -0.08537390f, -0.06199113f, -0.17024642f, -0.20761427f, -0.08106402f, 0.40762055f, 0.26408038f, 
    -0.08528917f, -0.06261475f, 0.30579329f, 0.22511478f, -0.15059264f, 0.24349080f, 0.02042770f, -0.23074147f, 
    -0.25837854f, -0.05410278f, -0.05390036f, 0.02551139f, -0.09096483f, 0.25082698f, -0.39848718f, -0.01730696f, 
    -0.36717185f, 0.18798423f, -0.48353624f, 0.15091112f, -0.04409712f, 0.23052077f, -0.34479949f, -0.01373585f, 
    0.15366508f, -0.14599314f, -0.10517172f, -0.09175958f, -0.24262862f, -0.10315633f, 0.16500519f, 0.18148546f, 
    0.45487487f, -0.03382022f, 0.33003271f, 0.12991442f, 0.03337066f, 0.25939897f, 0.01217611f, 0.54641223f, 
    -0.35332790f, 0.01751010f, 0.13544600f, 0.16165194f, -0.01373839f, -0.07620093f, 0.03981490f, -0.13593985f, 
    0.17204219f, -0.13126880f, -0.07972781f, -0.12179360f, -0.46711177f, 0.13589990f, -0.05502652f, 0.66798663f, 
    0.05270142f, 0.26193792f, -0.02160862f, 0.11672955f, -0.05395253f, -0.08751621f, -0.28008249f, -0.05561628f, 
    -0.02509354f, -0.00151665f, -0.07485877f, -0.03036515f, -0.07975563f, -0.00584145f, -0.06649984f, 0.01389294f, 
    -0.02810201f, 0.23353143f, -0.17017211f, -0.17675066f, 0.13157782f, -0.05857589f, 0.33934787f, 0.14168538f, 
    -0.01566759f, -0.13344826f, 0.38692141f, 0.28689408f, 0.26756805f, 0.04144425f, -0.01467418f, -0.03385414f, 
    0.24110880f, -0.05162555f, -0.02807910f, 0.12648803f, 0.09713220f, 0.03602145f, -0.26080528f, -0.13698602f, 
    0.11423028f, -0.09835941f, 0.24321525f, 0.17674191f, 0.01323451f, -0.14635555f, -0.18397339f, 0.10813741f, 
    -0.03208257f, -0.04021202f, 0.12457579f, 0.53280121f, -0.05554059f, 0.15878895f, 0.00387154f, 0.09239033f, 
    0.14398935f, -0.06531254f, -0.03246304f, 0.04555865f, 0.12614219f, -0.01634057f, 0.13569286f, -0.08479609f, 
    0.22677764f, 0.07532436f, -0.10511785f, 0.15449968f, -0.13532047f, 0.22850235f, 0.02241009f, 0.22043708f, 
    0.00798924f, 0.12193161f, 0.10180534f, 0.46419027f, 0.07550551f, 0.12212650f, -0.06348743f, -0.07288168f, 
    -0.38647419f, 0.11543395f, 0.00327531f, -0.01971393f, 0.01874866f, -0.15585367f, 0.07561284f, 0.09296615f, 
    0.21192069f, 0.06765611f, 0.03991774f, 0.02069646f, 0.05300426f, 0.14783011f, -0.03224869f, -0.15839781f, 
    -0.16937971f, 0.04166005f, -0.02758535f, 0.16126087f, 0.06290401f, -0.32001063f, 0.06831097f, 0.01840219f, 
    -0.55575114f, 0.17164983f, -0.09886794f, 0.11413353f, 0.10219619f, 0.13540953f, 0.12359081f, -0.27072740f, 
    -0.30137971f, -0.14624751f, -0.04268844f, 0.07967060f, -0.15622388f, -0.06353404f, 0.00258211f, -0.08471459f, 
    -0.05249188f, 0.14791742f, 0.02428180f, 0.28348911f, -0.23541282f, -0.22217523f, 0.06961865f, -0.09922892f, 
    -0.01254161f, 0.09686540f, -0.30612257f, 0.25214505f, 0.02411332f, 0.22417803f, 0.01014659f, 0.05250018f, 
    -0.04012994f, -0.04132926f, 0.29298359f, 0.01512123f, -0.03301942f, -0.06239488f, 0.20884894f, 0.14011250f, 
    0.24788524f, 0.18476960f, 0.10020580f, 0.11118238f, -0.13807529f, -0.07774611f, 0.06454808f, -0.11760867f, 
    -0.10903796f, 0.11711551f, 0.01182174f, 0.05382668f, -0.17091523f, -0.69281584f, 0.16650565f, -0.05496289f, 
    0.02386321f, -0.20823243f, 0.05534663f, -0.02954331f, -0.16552882f, 0.12101631f, -0.19080591f, 0.35503730f, 
    -0.10761803f, -0.02957018f, 0.00904591f, -0.09913424f, 0.05685788f, -0.00305634f, 0.22071265f, -0.12689799f, 
    0.34260216f, 0.09372032f, 0.10549752f, 0.08386362f, -0.02180665f, 0.08874357f, 0.42378715f, -0.11369929f, 
    -0.03654761f, 0.01114520f, 0.15662187f, -0.09532731f, -0.11409398f, -0.01763027f, 0.06802797f, -0.17005190f, 
    -0.01904880f, 0.12299547f, 0.19073805f, 0.24114071f, -0.17975202f, -0.03323756f, -0.25346515f, 0.22795647f, 
    -0.02850146f, -0.13530651f, 0.09520437f, -0.17066389f, 0.00240024f, 0.02848026f, -0.07077388f, 0.12721364f, 
    -0.41143712f, -0.16330755f, -0.01066159f, -0.07469758f, 0.01710217f, -0.06979514f, 0.01036043f, 0.22697830f, 
    0.61901176f, 0.03832382f, 0.20156769f, -0.19004078f, -0.01848988f, 0.21935438f, -0.49832892f, 0.26877940f, 
    0.01031365f, -0.08428183f, -0.00150440f, -0.04777116f, 0.00586032f, 0.03076025f, 0.02660194f, -0.04222729f, 
    -0.10025141f, 0.05673071f, 0.00419456f, -0.09775532f, -0.05053732f, -0.00269866f, -0.09259929f, 0.05735356f, 
    -0.01389843f, 0.05698673f, -0.00583935f, -0.00372749f, -0.00997878f, 0.02250661f, 0.01716272f, -0.06945777f, 
    0.05768729f, -0.07493618f, 0.05949335f, -0.08150557f, 0.01116845f, 0.00492860f, -0.03092554f, -0.04279051f, 
    0.00883238f, -0.08767673f, 0.04472644f, 0.05844786f, -0.04436035f, 0.01072072f, -0.07879525f, 0.03850402f, 
    -0.08065052f, 0.01894839f, -0.03191162f, -0.08605947f, 0.01928559f, -0.07540488f, 0.03782385f, 0.02700463f, 
    0.04931824f, -0.02473018f, -0.08104979f, 0.03524133f, -0.06548128f, -0.05251022f, 0.05861470f, -0.07231272f, 
    0.02840758f, 0.02530889f, -0.04592057f, -0.04510611f, -0.08476294f, 0.03490089f, -0.08149325f, -0.04460183f, 
    -0.06460249f, 0.01353384f, -0.11851043f, 0.00037998f, -0.03224253f, -0.04913282f, -0.04560873f, -0.02917614f, 
    -0.03206252f, -0.04082589f, -0.10414525f, -0.02138769f, 0.02860026f, -0.10039347f, -0.05097039f, -0.02211307f, 
    0.03109878f, -0.04539162f, -0.01442016f, 0.02312911f, -0.05269182f, -0.08950156f, -0.07315389f, -0.08380029f, 
    -0.03170216f, -0.06218224f, -0.08875393f, -0.02105206f, 0.05261689f, 0.00634982f, -0.04701557f, 0.03878272f, 
    -0.02132398f, -0.07697320f, -0.03833029f, -0.00945727f, -0.08586951f, 0.05202028f, -0.00921031f, -0.05797276f, 
    -0.10807975f, 0.02389956f, -0.05544316f, -0.03278572f, 0.00751065f, -0.05139348f, 0.07024828f, 0.00065576f, 
    -0.00503468f, -0.01194608f, 0.01494001f, -0.01509841f, 0.02665594f, 0.01979062f, 0.01110662f, -0.02227392f, 
    0.03114648f, -0.00393566f, -0.05706253f, -0.07356991f, -0.03103713f, -0.03609825f, 0.05248588f, -0.02207854f, 
    0.04006974f, 0.04618560f, -0.02842144f, -0.04130334f, -0.00882103f, -0.05978024f, 0.00671396f, 0.04659275f, 
    -0.07024768f, 0.03254055f, -0.08908471f, -0.08098634f, -0.06341358f, -0.08907945f, -0.04199833f, 0.05668649f, 
    0.02280927f, -0.06295178f, -0.09880811f, -0.00413715f, -0.06983628f, -0.05620965f, 0.00335325f, -0.04744443f, 
    0.04375664f, 0.04630782f, 0.03192342f, -0.07380289f, 0.03796891f, -0.01902364f, -0.00908311f, -0.05213849f, 
    0.05307196f, -0.02728680f, -0.07166374f, -0.02036878f, 0.02650181f, 0.00613267f, 0.04137226f, -0.06546997f, 
    0.01123711f, -0.04919020f, 0.05018822f, -0.02564159f, 0.07690798f, 0.06390053f, 0.05364619f, -0.01504243f, 
    -0.04839361f, -0.09328320f, 0.02888556f, -0.09641342f, 0.05506061f, -0.09240782f, -0.02840523f, 0.05213217f, 
    -0.01809607f, -0.01046735f, -0.03140292f, 0.03344679f, -0.01380803f, -0.05690340f, 0.00099381f, 0.06483211f, 
    0.06907456f, 0.06986179f, -0.06313049f, 0.01937686f, -0.07360991f, 0.00101370f, 0.07835437f, -0.10206815f, 
    -0.03318693f, 0.01195819f, -0.03412759f, -0.06800324f, -0.01605406f, 0.01565201f, 0.03755429f, -0.00882666f, 
    0.07123733f, -0.09757801f, -0.02602225f, -0.03542057f, 0.00514439f, 0.06744429f, 0.04612758f, 0.03757612f, 
    0.06135427f, -0.01859483f, 0.00947129f, 0.02843563f, 0.02866694f, 0.00111583f, -0.01905125f, 0.06195574f, 
    -0.05768653f, -0.09797476f, -0.07002273f, 0.08181227f, -0.01715348f, 0.06542601f, 0.07919326f, -0.02768891f, 
    0.05914400f, -0.05970198f, -0.08968857f, 0.02858667f, -0.04479105f, -0.09283927f, 0.02953836f, 0.03253197f, 
    0.04253747f, -0.07800791f, 0.05872181f, -0.02747293f, 0.01692790f, 0.01011704f, -0.00811457f, -0.03113236f, 
    0.02525607f, -0.02947802f, 0.01672436f, -0.06547766f, -0.06084641f, 0.04952190f, -0.04072442f, 0.03544465f, 
    -0.04863269f, 0.18062685f, -0.06195100f, 0.15385973f, 0.18065123f, 0.17353113f, 0.06077119f, 0.36831111f, 
    0.17043333f, 0.12687567f, 0.16875067f, 0.34083146f, -0.30394128f, 0.30630770f, 0.00878078f, 0.24121444f, 
    -0.10857955f, 0.07230287f, -0.30170497f, -0.00742722f, -0.03944568f, 0.00381866f, 0.27175647f, -0.03584326f, 
    0.20722841f, 0.01018829f, -0.03071223f, -0.00818109f, -0.37955269f, 0.19071463f, 0.15742584f, 0.53017110f, 
    0.19798040f, 0.37934521f, -0.65114051f, -0.20701817f, 0.13343152f, 0.45808938f, 0.38825053f, 0.15037237f, 
    0.23818223f, 0.01180369f, -0.05659088f, 0.03802695f, -0.00736735f, -0.07419813f, -0.02114915f, 0.23440312f, 
    0.01214075f, 0.03774944f, -0.14459586f, 0.19058537f, -0.05783247f, 0.03305712f, -0.09159075f, -0.32443339f, 
    -0.15611829f, 0.00030320f, 0.31536731f, 0.10687697f, 0.02017036f, -0.14010905f, -0.06126085f, 0.13660553f, 
    0.21722810f, -0.18158759f, -0.10440520f, -0.00446204f, -0.08727290f, 0.15570697f, 0.02834051f, 0.20374838f, 
    0.15127890f, -0.11086709f, 0.38835478f, -0.22677588f, -0.26560876f, 0.18533286f, 0.21450722f, -0.21376087f, 
    0.20267764f, -0.03388378f, 0.22236776f, -0.05184694f, -0.01279316f, -0.07892368f, 0.37595809f, -0.41384092f, 
    -0.01018326f, 0.04555690f, -0.07155676f, 0.45130336f, -0.07136996f, 0.22841497f, 0.11237188f, -0.34767139f, 
    0.04849824f, 0.20354484f, -0.03632785f, 0.12284457f, -0.28596744f, 0.29816988f, 0.29538137f, 0.16135727f, 
    0.01040768f, 0.01875679f, 0.25191304f, 0.09081379f, 0.15119866f, -0.04114258f, -0.20554598f, 0.04787650f, 
    -0.55240959f, 0.11879964f, 0.13295409f, 0.05001983f, 0.14477974f, -0.27670801f, 0.07625853f, 0.12088367f, 
    -0.10747809f, -0.07666635f, 0.30979192f, 0.05149759f, 0.06116316f, 0.44341847f, -0.75182605f, -0.01779815f, 
    0.02475876f, 0.06285965f, 0.01428724f, -0.06025315f, -0.18125468f, -0.13293411f, -0.11949638f, -0.17995527f, 
    0.02150906f, -0.14788280f, 0.08908819f, -0.01766709f, -0.03466310f, -0.26423231f, 0.11136556f, -0.34033191f, 
    -0.22715478f, 0.00443549f, -0.01801318f, -0.21746151f, -0.41194609f, 0.04896638f, 0.06276453f, -0.17971988f, 
    0.01070138f, 0.16005564f, 0.37155351f, -0.15017132f, 0.55418533f, -0.16415781f, -0.03564258f, -0.06681520f, 
    -0.16730046f, -0.31156617f, 0.07251693f, 0.47439882f, -0.18659998f, 0.07269488f, -0.42160252f, 0.04158548f, 
    0.08981531f, -0.08211681f, 0.30032408f, 0.08743717f, 0.05664625f, -0.03410535f, -0.07075107f, 0.12883560f, 
    0.07607954f, 0.17694387f, 0.02694939f, 0.10735457f, 0.36560565f, 0.02065127f, 0.05586888f, 0.07088497f, 
    0.17688826f, -0.26760194f, -0.73675585f, -0.30582076f, 0.07849717f, -0.23098804f, 0.09798238f, 0.02921356f, 
    -0.23058073f, -0.00208628f, 0.09322862f, 0.18824551f, 0.06034845f, -0.14687656f, -0.29674816f, -0.25450483f, 
    0.13724956f, 0.21106255f, -0.65203899f, -0.03221986f, 0.05673014f, -0.02006918f, 0.01206352f, 0.03839871f, 
    -0.07270686f, 0.05471762f, -0.15989114f, -0.27058637f, 0.15887192f, 0.15408131f, -0.37199035f, -0.09365971f, 
    0.02961671f, 0.12014320f, -0.11187993f, 0.02760497f, -0.09393205f, 0.01087467f, -0.18879256f, 0.29938239f, 
    -0.21323664f, -0.15811823f, 0.16738090f, -0.60768598f, 0.06624959f, -0.06944587f, 0.05293119f, -0.09033921f, 
    -0.17451066f, -0.11391650f, -0.03737261f, 0.16197777f, 0.18435895f, -0.05415203f, 0.02295013f, 0.20461498f, 
    0.03105914f, 0.21167940f, 0.34651160f, -0.04061540f, -0.07979959f, 0.28660676f, 0.10235520f, -0.48116404f, 
    -0.32668987f, 0.12263981f, 0.11930627f, -0.02413851f, 0.08997402f, 0.47448123f, 0.38142732f, -0.26085094f, 
    0.22111456f, -0.09029101f, 0.12843905f, 0.25376719f, -0.02763065f, 0.50394690f, 0.12725484f, 0.03649144f, 
    -0.34381112f, 0.17181849f, 0.04186013f, 0.32808095f, -0.01330993f, 0.02561756f, -0.20036304f, 0.25113043f, 
    -0.09233516f, 0.10067572f, 0.00604841f, 0.08057550f, -0.15092841f, -0.21678561f, -0.27649730f, 0.01528387f, 
    0.26039845f, 0.09270078f, 0.23801520f, 0.18868606f, -0.86094886f, -0.41180480f, -0.02098951f, -0.66553289f, 
    -0.33281830f, -0.01653744f, 0.10001013f, -0.41366366f, -0.21570757f, -0.08825450f, 0.08646715f, -0.03245686f, 
    -0.14762336f, -0.03940465f, -0.26002297f, 0.25186867f, 0.07831801f, -0.01893489f, 0.20871907f, -0.02051612f, 
    0.00637936f, 0.06959394f, -0.08825888f, 0.14446862f, -0.18554762f, 0.24554019f, -0.04034358f, -0.00251905f, 
    0.02623243f, 0.18533058f, -0.20851995f, 0.17569700f, -0.01790367f, -0.35724980f, 0.07131697f, 0.02450881f, 
    -0.00332632f, 0.10075264f, -0.13977331f, -0.09029132f, 0.06888673f, 0.27266741f, -0.32872999f, -0.09101634f, 
    0.32489264f, -0.03033379f, 0.02265211f, 0.21803944f, 0.01495874f, 0.06540402f, 0.05991397f, 0.18825340f, 
    -0.30546877f, 0.25124735f, 0.21878074f, 0.04313359f, 0.06657894f, -0.12834513f, 0.06185912f, -0.02039933f, 
    0.23661581f, -0.08574362f, 0.01598682f, -0.39293060f, 0.02824673f, -0.41303453f, 0.15838842f, -0.23676650f, 
    0.10387697f, 0.26139480f, -0.10157140f, -0.38941583f, 0.12709635f, 0.00582076f, -0.10568113f, -0.08967068f, 
    0.24205856f, 0.14782293f, 0.11682872f, -0.12471223f, -0.00351633f, -0.13799034f, 0.07491122f, 0.09117840f, 
    0.00343277f, 0.07225828f, -0.22073875f, -0.05726395f, 0.08900229f, -0.15518752f, 0.28483650f, 0.14639848f, 
    0.17676774f, 0.38395542f, 0.48498613f, 0.01862767f, -0.15473990f, 0.25514102f, 0.01126549f, -0.01013865f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07724556f, -0.16283120f, 0.07972443f, 0.01137456f, -0.09192316f, 0.07146724f, 0.15685791f, 0.26463029f, 
    0.23111223f, 0.02471314f, 0.14822204f, -0.34428057f, -0.03276017f, -0.05502333f, 0.17904823f, -0.04146995f, 
    0.11365011f, 0.22629973f, -0.13008457f, 0.01931632f, 0.05225932f, 0.05821144f, -0.09561811f, 0.08616631f, 
    0.01447170f, -0.04163568f, 0.10791336f, 0.05307133f, -0.06032376f, -0.09864138f, 0.29088566f, 0.02075402f, 
    0.02732570f, 0.15647106f, 0.18438672f, 0.04769347f, 0.06095728f, 0.06346742f, -0.08938628f, -0.08760623f, 
    0.32279187f, 0.08764645f, 0.12719278f, 0.06097434f, 0.03225336f, -0.05567323f, 0.08206441f, 0.04813343f, 
    0.05836174f, -0.00075583f, 0.09673747f, -0.08658380f, -0.13140380f, -0.09793695f, 0.10155019f, 0.06694383f, 
    0.07457566f, 0.22294289f, -0.00554759f, -0.10594988f, 0.15667467f, 0.00117596f, -0.00013151f, 0.03414311f, 
    -0.03189787f, -0.07729677f, 0.27375203f, 0.25511590f, -0.17081477f, 0.13197106f, 0.21904007f, -0.09968492f, 
    -0.08051235f, 0.04458734f, 0.01535854f, -0.17255287f, 0.09696843f, 0.16099933f, 0.04912363f, 0.12140537f, 
    0.02522015f, 0.28222793f, 0.08334237f, 0.00677445f, 0.04257223f, -0.04103266f, 0.02012427f, 0.04139949f, 
    -0.02118113f, -0.07551757f, 0.00558668f, -0.05418742f, -0.02005384f, 0.16786018f, -0.06507545f, 0.10681242f, 
    0.00395292f, 0.13294324f, 0.09889629f, -0.03340027f, 0.00528473f, 0.09028376f, -0.28551304f, 0.30698848f, 
    0.05315336f, -0.25601965f, 0.13238476f, 0.15365238f, -0.21555398f, 0.15054065f, 0.05831860f, 0.00858421f, 
    -0.06895787f, 0.04802523f, -0.30396223f, 0.24765129f, -0.01668760f, -0.07326762f, -0.16216809f, 0.11529101f, 
    0.06243888f, 0.23770198f, 0.09800711f, -0.07824993f, -0.03534404f, 0.09942619f, -0.30078614f, 0.21689765f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.02685977f, -0.23483510f, 0.09596175f, 0.06821187f, -0.09034522f, -0.06695416f, 0.06279198f, 0.13097805f, 
    0.16463746f, -0.46799380f, -0.62006748f, 0.52117670f, 0.07104520f, -0.00177008f, 0.08772103f, 0.05228111f, 
    -0.43072590f, -0.02240630f, -0.71344674f, 0.17743109f, -0.07251034f, 0.15838799f, 0.00462499f, -0.31471965f, 
    -0.00116375f, -0.01333095f, 0.01114702f, 0.01165734f, 0.01587913f, 0.03358062f, -0.03447842f, -0.19765294f, 
    -0.75007045f, 0.21775013f, 0.14715934f, 0.03432764f, 0.08480315f, 0.07725248f, -0.10994065f, -0.04696344f, 
    0.16841356f, -0.44409314f, 0.24222182f, 0.10675035f, 0.14281194f, -0.01766523f, 0.20062658f, -0.02851597f, 
    0.17301556f, 0.17239127f, 0.08562230f, -0.10447733f, -0.26042503f, -0.16478243f, 0.08356686f, -0.14865476f, 
    0.12527721f, 0.03332895f, 0.06282310f, -0.09044006f, 0.20721549f, -0.05528165f, -0.08369641f, -0.18864454f, 
    0.03487185f, -0.01556164f, 0.11464696f, -0.22286314f, -0.73623449f, 0.23255685f, 0.03416111f, -0.04568536f, 
    -0.08383760f, 0.03700359f, -0.14033398f, -0.00917414f, -0.00598693f, 0.18110028f, -0.37398234f, 0.02217442f, 
    -0.17725404f, 0.36802870f, 0.00931866f, -0.14139125f, 0.27066737f, 0.03633620f, -0.03200379f, -0.27875909f, 
    0.10394905f, -0.06120758f, 0.08838122f, -0.17154147f, 0.04639751f, 0.12035710f, -0.36930028f, -0.34472644f, 
    -0.06497097f, 0.22044036f, -0.17575045f, -0.16002971f, -0.02118487f, -0.40857437f, -0.38231754f, 0.13028608f, 
    0.16855447f, -0.01122952f, -0.02368286f, -0.28054664f, 0.00993934f, 0.12931487f, -0.07579076f, -0.36483809f, 
    -0.00999173f, 0.13160552f, -0.42051792f, 0.09859001f, -0.49481389f, 0.23261271f, -0.57231575f, -0.10470066f, 
    -0.60590571f, -0.08675724f, 0.15208666f, 0.07087709f, 0.04399432f, 0.25054255f, -0.41224930f, 0.09009894f, 
    0.04702475f, 0.43001059f, -0.09693293f, -0.07231927f, 0.04206327f, 0.07354624f, -0.17371413f, 0.05196263f, 
    0.12274558f, 0.07553939f, 0.30043164f, 0.32761469f, 0.03860394f, 0.00483494f, 0.24774617f, -0.02390676f, 
    0.11776182f, -0.54215431f, -0.31556708f, 0.04012970f, 0.01146790f, 0.19609687f, -0.05371121f, -0.36423859f, 
    -0.06814318f, 0.00194049f, 0.06590227f, -0.67427111f, 0.06543362f, -0.06987512f, 0.14669307f, -0.29888365f, 
    0.33310214f, -0.32644507f, 0.15601230f, 0.01280645f, -0.12211762f, 0.02398150f, -0.05158272f, -0.04778880f, 
    0.24319731f, 0.24844374f, -0.08593021f, 0.08056148f, -0.08408459f, -0.04658461f, 0.00702185f, -0.05592561f, 
    -0.32971278f, 0.13212025f, -0.06320965f, 0.05136527f, 0.26750612f, -0.45759991f, 0.11097235f, -0.10132501f, 
    -0.14744592f, -0.07539347f, -0.00685322f, 0.04749981f, 0.15019694f, 0.01729207f, -0.15891379f, 0.17651220f, 
    0.00563144f, 0.01227154f, -0.34074992f, 0.17006917f, 0.47493827f, 0.02920176f, 0.12374540f, 0.23854767f, 
    0.08317053f, 0.09192434f, -0.27326274f, 0.26817152f, 0.14670502f, -0.41483247f, 0.14051956f, -0.12384134f, 
    -0.19360635f, -0.55381513f, -0.35006407f, -0.12078228f, -0.07564197f, 0.18617395f, 0.03185049f, -0.43030018f, 
    -0.06012049f, 0.03721258f, 0.05346647f, -0.02659156f, 0.00046708f, -0.15428011f, -0.20972635f, -0.17779411f, 
    0.00924932f, 0.01356188f, 0.32816675f, 0.07590604f, -0.05003203f, -0.23536175f, 0.24119450f, 0.06769317f, 
    0.15400390f, 0.03776531f, -0.45470122f, -0.13885209f, -0.42220959f, 0.03511643f, -0.26953664f, 0.02624787f, 
    -0.02205763f, 0.20976749f, 0.03716075f, 0.21710637f, 0.09277636f, -0.15629072f, 0.32668638f, 0.03434814f, 
    0.01643515f, 0.16094907f, -0.35969976f, 0.02199930f, -0.07330734f, 0.32075384f, 0.02694733f, -0.31943047f, 
    -0.53253859f, -0.21738832f, -0.35321167f, 0.06307006f, 0.07524777f, 0.08268478f, -0.35472080f, 0.10791066f, 
    -0.13853745f, 0.24057278f, -0.04931924f, -0.13341869f, -0.08454262f, 0.10191767f, -0.20486122f, -0.06946290f, 
    -0.26170877f, -0.43456942f, 0.01867948f, 0.28348538f, -0.03834939f, 0.00755520f, -0.04547212f, -0.10598174f, 
    -0.00086668f, 0.02615615f, -0.13179561f, 0.19354926f, 0.01336380f, -0.07164541f, -0.54024148f, -0.20763220f, 
    -0.22450434f, -0.62826443f, -0.21288542f, -0.09630940f, -0.34080344f, 0.14643478f, 0.02437563f, -0.05900167f, 
    -0.12805066f, -0.04138105f, -0.32164505f, -0.12723561f, -0.53889787f, -0.00444268f, 0.10678232f, 0.00284604f, 
    0.06356379f, -0.24548465f, -0.31176493f, -0.06760166f, 0.22836955f, -0.35872683f, -0.60544276f, 0.21664719f, 
    0.02694455f, 0.00992267f, -0.01375602f, 0.02191576f, -0.05135986f, -0.04480349f, -0.13876285f, -0.58719260f, 
    -0.03602439f, -0.07607313f, -0.33635643f, -0.01235771f, 0.15520102f, 0.21386798f, 0.06410883f, 0.37732077f, 
    -0.03644268f, -0.26816586f, 0.15742634f, -0.58891547f, 0.25615302f, -0.70406854f, -0.24035969f, 0.21164027f, 
    -0.43290162f, -0.50455904f, 0.13516836f, 0.28745508f, 0.05614995f, 0.27177233f, -0.08391879f, 0.01060553f, 
    -0.20439482f, -0.12469146f, 0.06257021f, -0.05709193f, -0.05454961f, 0.12669554f, 0.14612885f, 0.09323470f, 
    0.37907064f, -0.35810828f, -0.29642045f, 0.23947573f, 0.02915432f, -0.41371393f, -0.54540133f, -0.03788114f, 
    -0.38533947f, -0.16356331f, 0.01523198f, -0.08679147f, 0.02185617f, -0.52074754f, -0.05186595f, -0.53927702f, 
    -0.03964036f, 0.14188008f, -0.21602745f, 0.16778664f, 0.13204375f, 0.27247930f, 0.11231998f, 0.13179803f, 
    -0.46750078f, 0.07473106f, 0.21124212f, 0.05675922f, -0.02783917f, 0.26705429f, -0.55460966f, -0.36103448f, 
    0.16288607f, 0.02432056f, 0.22525580f, 0.00254822f, -0.06189319f, -0.07292841f, -0.36546490f, -0.56829298f, 
    -0.29152486f, -0.56430864f, -0.58519745f, -0.31428576f, 0.01530156f, 0.03931659f, -0.24104619f, -0.09042503f, 
    -0.21711484f, 0.18023127f, 0.02934275f, -0.22919323f, 0.00983822f, 0.08526190f, 0.03045874f, -0.17323826f, 
    -0.01178818f, -0.06032747f, -0.46557859f, 0.09114661f, -0.03053080f, 0.03471411f, 0.02983252f, -0.03607515f, 
    0.18855079f, 0.12091553f, 0.12107746f, -0.00253645f, 0.01520516f, -0.34974790f, -0.02707406f, 0.06381015f, 
    -0.60302097f, -0.28955796f, -0.01434982f, 0.10150274f, 0.11172605f, -0.00528146f, 0.08641418f, -0.02990215f, 
    0.05040641f, -0.26253089f, -0.37267360f, 0.07827423f, 0.16088952f, 0.16927525f, 0.20854957f, -0.34251326f, 
    0.09808113f, -0.16501626f, 0.04496947f, -0.02796349f, -0.05650863f, -0.00529727f, 0.17595130f, 0.05042389f, 
    -0.02544521f, 0.04938031f, -0.12223408f, -0.14117767f, -0.02890209f, -0.13570331f, 0.04208386f, 0.02921846f, 
    0.01322902f, -0.04050011f, 0.04206874f, -0.22705209f, -0.66441917f, 0.04640227f, 0.46348274f, -0.24560067f, 
    -0.10129190f, 0.13545074f, 0.04833494f, 0.09967124f, -0.03263799f, -0.21506196f, -0.00482617f, 0.03406740f, 
    0.02453963f, 0.05722340f, 0.09134679f, 0.02229827f, -0.04811378f, 0.05330366f, 0.32643214f, -0.57597351f, 
    -0.14627980f, 0.10986602f, 0.00616130f, 0.18686038f, -0.10301112f, 0.14753294f, -0.18221040f, -0.16213241f, 
    0.03832776f, -0.37849408f, 0.10467573f, -0.60968351f, -0.55492711f, -0.13615432f, 0.10517743f, 0.07557005f, 
    -0.02656352f, -0.18226276f, -0.28968886f, -0.76087791f, 0.10443814f, 0.12054678f, 0.32122254f, -0.33707428f, 
    0.18829513f, 0.00746703f, 0.08561324f, -0.05171468f, 0.05090375f, -0.45832446f, -0.21677913f, -0.16016072f, 
    -0.17796984f, 0.40228850f, 0.05988630f, -0.02410496f, -0.09787643f, 0.02756985f, 0.13483636f, 0.02646057f, 
    -0.00099660f, -0.19925278f, -0.04866706f, -0.70411199f, -0.07923432f, -0.12785946f, -0.32478333f, 0.04723975f, 
    0.02968269f, 0.23174380f, 0.16658939f, -0.05271766f, 0.00872498f, -0.13651188f, -0.08791240f, 0.19040817f, 
    -0.04797088f, -0.00833611f, 0.07326940f, 0.05147485f, -0.00216175f, -0.05349619f, 0.01555188f, 0.21534951f, 
    -0.05815301f, 0.02252362f, 0.14650983f, -0.07971769f, 0.10402884f, 0.07202809f, -0.07454009f, -0.04495028f, 
    0.04712455f, -0.18722145f, 0.17753309f, 0.13786928f, 0.06527910f, -0.10679305f, 0.07044845f, -0.09675422f, 
    0.07691130f, -0.08448091f, -0.17556362f, -0.06280539f, -0.30461967f, -0.03553881f, 0.00687073f, 0.00590935f, 
    0.13466193f, -0.05463416f, -0.05609940f, -0.01648705f, -0.20730917f, -0.00723405f, -0.04619080f, -0.05295934f, 
    -0.04093487f, -0.08419827f, 0.16234802f, -0.22974202f, -0.60067457f, 0.09845895f, -0.14174818f, 0.15933093f, 
    -0.07013268f, -0.06210444f, 0.08402080f, -0.06588370f, -0.12420147f, 0.09766256f, -0.45945990f, 0.21702428f, 
    0.00224732f, 0.20485644f, 0.00781494f, 0.06605426f, -0.15330513f, 0.03897924f, -0.99288094f, 0.08250869f, 
    0.09148320f, 0.02963368f, 0.12083481f, 0.00928536f, -0.06576887f, 0.12687774f, 0.07129946f, 0.14342523f, 
    -0.02377081f, -0.00569299f, -0.32200187f, -0.05176936f, -0.04986142f, 0.04618095f, 0.20369430f, -0.13563462f, 
    0.00518105f, -0.35856369f, -0.01553003f, 0.16042487f, -0.06460994f, -0.02856919f, 0.00283044f, 0.02409644f, 
    0.01444368f, 0.30861792f, -0.01961068f, -0.15959649f, 0.10694243f, 0.13322626f, -0.31436023f, -0.03994619f, 
    -0.56967771f, -0.27461857f, 0.02098256f, -0.04185006f, 0.04739036f, -0.00745926f, 0.19884229f, 0.17451330f, 
    0.20692228f, -0.51441729f, 0.04318965f, -0.01291710f, -0.02357023f, -0.05098191f, 0.12362874f, 0.08784232f, 
    0.03670420f, 0.06340482f, 0.10401553f, -0.12442049f, -0.05317186f, 0.02710350f, 0.08291174f, 0.00009752f, 
    0.26761669f, -0.00295959f, -0.89269531f, -0.08627285f, -0.08888199f, 0.04057539f, -0.01482555f, 0.21753164f, 
    -0.03318441f, -0.00783513f, 0.03502417f, -0.19205181f, 0.05156202f, -0.04846635f, 0.18623357f, 0.11524183f, 
    0.14746729f, -0.12733495f, -0.32835102f, -0.00631221f, 0.13388126f, -0.00070514f, -0.08937359f, 0.04005611f, 
    -0.21541086f, 0.01298361f, -0.00526817f, 0.01053131f, 0.14958443f, -0.04021787f, -0.03981627f, 0.00019818f, 
    0.31864408f, 0.16092508f, 0.21079479f, 0.01156771f, -0.01866805f, -0.12790263f, -0.28540760f, 0.21041031f, 
    -0.17260945f, 0.09302572f, 0.01685299f, -0.00260129f, 0.09007449f, -0.03483124f, -0.22637068f, -0.03908438f, 
    -0.08041649f, -0.05069861f, -0.11646821f, 0.19442758f, -0.66974837f, -0.19037868f, -0.20994532f, -0.70565861f, 
    0.03302844f, 0.02560839f, -0.29536542f, -0.35128802f, 0.12396282f, 0.15530190f, -0.19013207f, 0.26926062f, 
    0.14254068f, -0.26452464f, -0.31714225f, -0.42230654f, 0.02182329f, 0.13656802f, -0.03374924f, -0.14068757f, 
    0.16937037f, -0.07469416f, -0.40756434f, -0.02896487f, -0.03403467f, -0.26370659f, 0.18782188f, 0.12244552f, 
    0.02804246f, 0.00871882f, 0.23153822f, -0.23599039f, -0.06439754f, 0.16792569f, 0.00584844f, 0.08600534f, 
    0.11197519f, 0.28250104f, -0.61750883f, 0.10441836f, 0.18076611f, 0.15300991f, -0.30740911f, 0.08186183f, 
    -0.00167051f, -0.01578541f, 0.07140835f, -0.02390655f, 0.02820205f, -0.42426109f, 0.20580912f, 0.05915137f, 
    0.22130239f, 0.10824843f, -0.31409651f, 0.04461879f, -0.07495665f, -0.20716837f, 0.28781331f, 0.05543377f, 
    -0.09395000f, -0.44430861f, -0.03367702f, -0.02754806f, 0.02390453f, 0.07374500f, 0.17304282f, 0.04387542f, 
    0.16453636f, 0.26941791f, 0.23893005f, -0.10463583f, -0.04734671f, 0.04012535f, -0.34620628f, 0.05631583f, 
    0.30925709f, 0.11100473f, -0.09205245f, 0.15837696f, -0.04523099f, -0.08004812f, -0.10945836f, -0.06169637f, 
    -0.10702720f, -0.01346708f, -0.04633475f, 0.05217674f, -0.04308768f, -0.03716720f, 0.01494677f, -0.34652120f, 
    -0.67723787f, 0.13043234f, -0.28705311f, 0.00304233f, -0.25519225f, 0.03375867f, -0.00866297f, 0.03928278f, 
    0.06140847f, 0.05069644f, -0.14949329f, -0.38340440f, -0.11349943f, 0.04569447f, -0.13479877f, -0.02614633f, 
    -0.34202263f, -0.35531414f, 0.13206974f, -0.00113764f, 0.05102004f, 0.00350689f, 0.10597667f, -0.24963355f, 
    -0.10195655f, 0.23472765f, -0.01104829f, -0.04170677f, -0.71669167f, -0.01389368f, -0.41889960f, -0.09351298f, 
    -0.00966846f, 0.04509509f, 0.28527972f, 0.01117882f, -0.45817012f, -0.08505005f, 0.14599353f, -0.00651056f, 
    -0.06698357f, 0.02538154f, 0.15684216f, -0.11384373f, 0.05614696f, -0.08197576f, 0.26693836f, -0.98258984f, 
    -0.21383838f, 0.09543714f, 0.08487249f, -0.50956345f, -0.56893218f, -0.12039761f, 0.44373780f, 0.22076300f, 
    -0.34979752f, -0.02093683f, -0.48387772f, -0.00252008f, -0.09350060f, -0.23972008f, 0.18260375f, 0.26951101f, 
    -0.49146667f, 0.08797535f, -0.27219918f, -0.21941666f, -0.00838676f, 0.03511439f, -0.11191452f, 0.20711549f, 
    -0.11333290f, -0.32517618f, -0.01364045f, 0.08126073f, 0.27866831f, -0.16495468f, -0.14337066f, -0.33889917f, 
    -0.00989774f, -0.37474018f, -0.10435489f, 0.12684774f, 0.21613553f, -0.03853362f, 0.21289580f, 0.09971657f, 
    0.45746440f, 0.17156507f, -0.09171639f, -0.04074888f, 0.00760623f, -0.07153657f, -0.12270257f, 0.25008556f, 
    0.03823049f, 0.26867574f, -0.02278567f, -0.04485179f, -0.10291505f, -0.04907746f, -0.21259910f, -0.25601989f, 
    -0.41644984f, 0.06368949f, -0.88769007f, 0.24202339f, -0.04232018f, -0.07244198f, 0.04579298f, -0.02247838f, 
    -0.37149391f, -0.20165730f, -0.49818069f, -0.37644374f, -0.02477953f, -0.31698847f, 0.02485545f, 0.13700821f, 
    -0.14677754f, 0.01534441f, -0.11074586f, -0.13285123f, 0.03089924f, -0.03722843f, -0.45428145f, 0.13561432f, 
    -0.21424741f, -0.13575554f, 0.05252147f, -0.04799750f, 0.03239805f, -0.05342856f, 0.05070347f, -0.00954605f, 
    -0.51460195f, 0.39699104f, 0.11888409f, 0.07288189f, 0.10358767f, -0.09069403f, 0.15351005f, -0.03271012f, 
    0.05182598f, 0.21394520f, -0.55102038f, 0.07157863f, 0.20011456f, -0.00349361f, 0.03208796f, -0.57415479f, 
    0.03690745f, -0.54246473f, -0.03673292f, -0.02833808f, 0.16230588f, -0.07433451f, 0.06344979f, 0.13765207f, 
    0.02423813f, 0.06304263f, -0.39092767f, -0.41586921f, 0.48684266f, -0.33446237f, -0.61053044f, 0.22900327f, 
    -0.04583343f, -0.06122113f, -0.26759666f, 0.06628565f, -0.16880763f, 0.00379616f, 0.15955028f, -0.21578425f, 
    0.17438871f, 0.03679150f, -0.26169750f, 0.10534136f, 0.11409822f, 0.12305368f, 0.21211202f, -0.23141658f, 
    0.20105156f, 0.03291010f, 0.05715579f, -0.02197531f, 0.02556315f, -0.13170421f, 0.14999451f, -0.06512228f, 
    -0.22044581f, -0.19552961f, 0.09585240f, -0.32910326f, -0.03348386f, -0.15567689f, 0.22102958f, -0.61411822f, 
    0.01679022f, 0.22696094f, -0.00759570f, 0.03870284f, 0.13747226f, 0.01457142f, -0.00080090f, 0.06575995f, 
    -0.05126028f, -0.21415134f, 0.27851766f, -0.17895399f, -0.39097485f, -0.16840032f, 0.22672321f, -0.48179072f, 
    -0.01338348f, -0.53672934f, -0.48467177f, 0.00443624f, -0.09646342f, -0.36930498f, 0.16027941f, -0.50252014f, 
    -0.55868143f, -0.40570033f, -0.56140751f, 0.04950095f, -0.06439336f, 0.06315630f, 0.18023415f, 0.05765162f, 
    0.07586612f, 0.25797772f, 0.24948141f, -0.27945295f, -0.08453885f, -0.09206394f, 0.08219549f, 0.02909122f, 
    -0.35111564f, -0.07438935f, 0.55275792f, -0.65099657f, 0.03818149f, 0.13510075f, -0.01989963f, 0.03182293f, 
    0.06492138f, -0.08085763f, 0.21753649f, 0.04774847f, 0.00695742f, 0.02620066f, -0.04014983f, -0.38316143f, 
    -0.41006717f, 0.20484063f, -0.26768246f, -0.10461067f, -0.37814385f, 0.17802659f, -0.11113364f, -0.00108567f, 
    -0.12262014f, 0.32182547f, -0.28413680f, -0.35683680f, -0.15462194f, -0.06460559f, -0.46862549f, 0.02273595f, 
    -0.16699404f, 0.08611573f, 0.11269431f, -0.01531407f, -0.17270868f, -0.14535305f, 0.26480043f, 0.17684841f, 
    -0.60859555f, -0.47588867f, -0.07407466f, -0.06612752f, 0.13310723f, -0.00973267f, 0.13007008f, 0.06024409f, 
    0.05976519f, -0.00828510f, -0.29223511f, 0.01205927f, -0.15254146f, 0.05167447f, 0.01955386f, -0.11408075f, 
    0.04864604f, -0.23991087f, -0.13970499f, 0.40471068f, -0.02925808f, -0.28020269f, -0.18738155f, 0.27587187f, 
    0.10081506f, -0.41108036f, -0.40235746f, -0.28561679f, -0.38952190f, -0.04123101f, -0.10997751f, -0.14852124f, 
    0.08901301f, -0.08993962f, 0.08586389f, 0.07583035f, 0.04558067f, 0.03959280f, -0.48861721f, -0.37184975f, 
    -0.27057397f, -0.33351636f, -0.48123282f, 0.05380457f, -0.10076521f, -0.25188541f, -0.08285199f, 0.09833073f, 
    -0.21729714f, 0.20158191f, 0.11585542f, 0.19731285f, -0.03815423f, 0.10102595f, 0.23345384f, 0.13508706f, 
    -0.06153610f, 0.11120326f, 0.04974451f, -0.34992898f, -0.54120487f, -0.37802592f, -0.40570462f, -0.01859369f, 
    -0.02733778f, -0.11043390f, 0.04928849f, 0.00013366f, 0.00971556f, -0.18633914f, -0.14961658f, -0.13175672f, 
    0.01944413f, -0.14249898f, 0.06010043f, 0.02927905f, -0.00094853f, -0.08521377f, 0.07678102f, 0.09204658f, 
    0.10951035f, -0.20848167f, 0.19607118f, 0.34965736f, -0.04954006f, 0.00552999f, 0.09524076f, -0.07561479f, 
    0.25807104f, 0.24252434f, 0.06369446f, -0.19920959f, -0.00130535f, -0.80648249f, -0.01188763f, 0.12080076f, 
    -0.05770845f, -0.07190768f, 0.13456534f, -0.32543120f, 0.04259489f, -0.06334181f, -0.27181688f, 0.07560020f, 
    0.44633052f, 0.16016871f, -0.06404165f, 0.01476839f, -0.17285466f, -0.47876710f, 0.03540776f, 0.05050245f, 
    0.03560160f, -0.06052987f, -0.09141434f, -0.18050143f, -0.17469350f, -0.05098447f, 0.06191938f, -0.04716556f, 
    -0.07944763f, -0.02408724f, 0.04347869f, 0.03474443f, 0.39057308f, -0.40991786f, -0.63809162f, 0.15641026f, 
    -0.08915094f, -0.06385290f, 0.07920638f, 0.00383381f, -0.01731963f, -0.02854370f, -0.01696861f, 0.29143700f, 
    -0.07367826f, -0.03435459f, -0.03134732f, -0.00531187f, 0.10379520f, 0.01515329f, -0.02971336f, 0.12628251f, 
    0.01749083f, -0.57724416f, -0.19045472f, -0.24496330f, -0.04926722f, 0.16360176f, 0.31058556f, 0.17934524f, 
    0.31052792f, 0.06073996f, 0.05859737f, 0.03164522f, 0.09891098f, 0.01664775f, 0.04526974f, 0.21384484f, 
    0.26030812f, 0.02926772f, -0.29149479f, -0.01330896f, -0.06086913f, -0.54303896f, -0.10972986f, 0.23117739f, 
    0.44740543f, -0.09063924f, 0.18767181f, -0.34021565f, 0.00539409f, -0.35686353f, 0.27372047f, 0.06748462f, 
    -0.26166254f, 0.04888945f, 0.08127980f, 0.13039315f, 0.18974563f, -0.10740492f, 0.03323626f, 0.09033535f, 
    -0.04773692f, -0.54347324f, 0.50289464f, 0.11568647f, -0.12870964f, -0.16347636f, 0.07747429f, 0.06019534f, 
    0.03848017f, -0.15343305f, 0.05889539f, 0.04445017f, -0.00488109f, -0.01341139f, 0.09960043f, -0.09641791f, 
    -0.16679144f, -0.21795952f, -0.17227592f, 0.04634435f, -0.06159919f, 0.07909708f, 0.10819697f, -0.04486945f, 
    0.00063640f, -0.08454744f, -0.57286096f, -0.61201954f, 0.01402828f, -0.08139514f, 0.07342263f, 0.03982380f, 
    -0.54498261f, -0.35359427f, -0.43909109f, 0.02020924f, -0.06402312f, 0.28144008f, -0.01132791f, 0.30725428f, 
    -0.07688550f, 0.01775107f, 0.19386251f, 0.17741799f, -0.07538567f, 0.05030749f, 0.13747111f, 0.23364280f, 
    -0.44052222f, -0.13783720f, 0.12570775f, -0.06388448f, 0.18538088f, 0.24668722f, -0.10399675f, -0.01680438f, 
    -0.23202792f, -0.28166670f, -0.00705629f, 0.01425625f, -0.04749355f, -0.06717899f, 0.02131212f, -0.00348365f, 
    0.03557811f, -0.19691125f, -0.61742419f, -0.09377923f, -0.28485960f, -0.02704526f, 0.04309241f, -0.11761700f, 
    0.08570746f, -0.26107988f, -0.06483734f, 0.02017653f, 0.15810187f, 0.05413465f, 0.19607170f, 0.17474276f, 
    -0.02611650f, 0.08830738f, -0.28222302f, 0.08635943f, 0.14312097f, 0.10792053f, 0.08261327f, -0.14316577f, 
    -0.08584302f, 0.16987547f, -0.21741824f, -0.27665347f, -0.21435133f, 0.08906698f, -0.21268070f, -0.13394256f, 
    0.10394438f, 0.01011021f, 0.03355843f, 0.10204943f, 0.04863693f, -0.29683304f, -0.15570733f, -0.40608844f, 
    -0.15064146f, 0.00300398f, 0.10370816f, -0.09326400f, 0.00860830f, 0.30155542f, -0.00035271f, -0.52796954f, 
    -0.20430398f, 0.10714106f, 0.23386692f, -0.16692337f, 0.05857412f, 0.14222603f, -0.64322656f, 0.14612509f, 
    0.12295046f, -0.68215603f, 0.20968322f, -0.03953013f, -0.28527629f, 0.01476455f, 0.14241587f, 0.05840499f, 
    -0.09521958f, -0.06508736f, -0.88616866f, -0.71585989f, -0.06424616f, -0.00142439f, -0.33048239f, 0.01208108f, 
    0.11120924f, 0.20496152f, -0.16124906f, -0.02894700f, -0.00796765f, -0.29956982f, -0.40027663f, -0.29085082f, 
    -0.00693064f, -0.22041196f, 0.02290850f, 0.02809685f, 0.06240530f, -0.02901258f, -0.25314340f, -0.05442436f, 
    -0.21107239f, -0.24469048f, -0.54163641f, 0.39807945f, 0.04481765f, 0.00388202f, -0.23419452f, -0.07168544f, 
    -0.19709395f, -0.04080160f, 0.14618634f, 0.12112409f, 0.01682168f, -0.28115386f, -0.01889094f, -0.65575892f, 
    -0.02628358f, -0.03474298f, -0.39963514f, 0.28661096f, 0.07225075f, 0.06147098f, 0.16721705f, -0.05024591f, 
    0.29907236f, 0.04108134f, 0.07030152f, 0.03005790f, 0.08904520f, 0.00457761f, -0.04648704f, 0.04604001f, 
    0.25678664f, -0.38588908f, -0.11149730f, 0.13090841f, -0.07931036f, 0.05194342f, -0.16725507f, -0.02255297f, 
    0.31014147f, -0.06826774f, -0.44621134f, -0.03352546f, -0.63336599f, 0.29785526f, 0.14849819f, 0.17988957f, 
    0.12004293f, 0.02344122f, -0.07298525f, -0.03753195f, -0.14546098f, -0.03949849f, 0.10205387f, -0.61833334f, 
    -0.04538818f, -0.01215147f, 0.32367870f, 0.05347725f, -0.04368919f, -0.23794341f, 0.03420499f, -0.45691761f, 
    -0.04049443f, 0.17036696f, 0.24285685f, 0.28705615f, 0.00387242f, -0.07723711f, -0.25815350f, -0.24679700f, 
    -0.47239012f, 0.13238111f, 0.20695817f, 0.20545204f, 0.12996337f, -0.45257950f, -0.01069683f, 0.26397738f, 
    -0.40051308f, -0.03025177f, -0.03545995f, 0.01801975f, -0.07083338f, 0.14798565f, -0.39814568f, 0.08028638f, 
    -0.59206754f, -0.23104379f, -0.13134491f, 0.19019663f, 0.05618036f, 0.09017018f, 0.16846165f, -0.22874177f, 
    -0.16099957f, 0.49693218f, 0.08230145f, 0.03669373f, -0.06054350f, -0.18193705f, 0.05471770f, -0.51356125f, 
    0.05166277f, -0.14001651f, 0.22930497f, -0.05930477f, 0.18416935f, 0.17506400f, -0.38123098f, 0.00378632f, 
    0.13597322f, -0.02401709f, 0.19049494f, -0.07080161f, -0.01528072f, -0.22110683f, 0.08961890f, 0.19785856f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.05859949f, -0.00035117f, -0.08874441f, -0.14443064f, 0.03462862f, -0.03169772f, 0.04018765f, -0.27152178f, 
    -0.04666220f, 0.04078614f, 0.19276936f, 0.03556538f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
