#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59422034f, 0.63737196f, 0.50325114f, 0.25113434f, 0.11307690f, 0.03871542f, 0.18172680f, 0.12795416f, 
    -0.04625266f, 0.17407367f, -0.03663094f, 0.03673390f, 0.01013031f, 0.40173411f, -0.03769571f, -0.22510934f, 
    -0.18897985f, -0.00489542f, 0.00035516f, -0.17055862f, 0.14411069f, 0.22636969f, 0.01291164f, -0.26785824f, 
    -0.13000602f, 0.48684725f, 0.17138411f, -0.29578152f, -0.39696142f, 0.15001129f, 0.08750278f, 0.20987721f, 
    0.13413773f, -0.32610625f, -0.30712923f, 0.13045260f, 0.12097447f, 0.23414411f, -0.25233832f, -0.37532410f, 
    -0.08735353f, 0.32305098f, -0.25312889f, 0.12348317f, -0.02279918f, -0.50808972f, 0.23878975f, 0.22958471f, 
    -0.00191138f, -0.05427418f, 0.86810344f, 0.38365483f, 0.25943437f, -0.68706757f, -1.19646490f, 0.47075367f, 
    0.50258225f, -0.18473701f, -0.07707150f, -0.35623264f, 0.15138419f, -0.64462918f, 0.04591236f, 0.07214643f, 
    0.07067974f, -0.05135820f, -0.15273491f, -0.20440003f, -0.00221512f, -0.42823094f, -0.75149453f, -0.42015997f, 
    0.16305125f, 0.25124922f, -0.16637495f, -0.08074208f, -0.30286822f, -0.73160899f, -0.35462147f, -0.83157712f, 
    -0.86031914f, -0.45467165f, -0.04591737f, -0.24815425f, -0.21159592f, 0.37024540f, -0.30450183f, -0.09583925f, 
    -0.54973799f, 0.19765712f, 0.17021978f, 0.07089581f, 0.41859713f, 0.19088700f, -0.07080328f, -0.33383724f, 
    0.06799573f, -0.26430112f, -0.53166205f, 0.42815188f, 1.64203262f, -1.00145018f, -0.77708960f, -0.34732077f, 
    -0.83612609f, 0.48920339f, 0.39272833f, 0.22918157f, 0.49649516f, 0.12703817f, -0.15190679f, 0.55379379f, 
    -0.02581587f, -0.32413244f, -0.26106521f, -0.01855186f, 0.00871999f, -0.01750481f, -0.06790359f, -0.23393811f, 
    0.07988050f, -0.14484878f, -0.03102023f, 0.09245490f, 0.35770741f, -0.94740945f, -0.25043175f, 0.36961272f, 
    0.04513618f, 0.13127376f, 0.37460989f, 0.43651989f, -0.17583536f, 0.10167021f, 0.72503304f, 0.31697094f, 
    -0.21344805f, 0.18891893f, -0.52924001f, 0.03599576f, 0.04287440f, -0.17034993f, -0.34148756f, -0.17258088f, 
    0.19140771f, 0.20008464f, 0.03017087f, 0.15993531f, -0.07629109f, -0.16618550f, -0.18097517f, 0.40952545f, 
    0.15136063f, 0.11700065f, -0.42179853f, 0.00418530f, -0.37542689f, -0.11819474f, 0.77082783f, -0.76488721f, 
    -0.07435155f, -0.38262486f, 0.03049833f, 0.42196223f, -0.55222547f, -0.06013150f, 0.01460963f, -0.03158713f, 
    -0.22082449f, -0.08566503f, 0.14706901f, -0.04077991f, 0.13496421f, -0.31412590f, 0.23622137f, 0.03189084f, 
    0.05332759f, 0.04276554f, 0.17396517f, -0.14995056f, 0.63146579f, -0.62260646f, -0.36506534f, 0.25668395f, 
    0.54282773f, -0.13781597f, 0.26538742f, -0.08718164f, -0.41056821f, 0.07169675f, -0.25385353f, -0.06589866f, 
    0.14861852f, 0.16210829f, -0.28378221f, -0.21136725f, 0.08958227f, 0.21152794f, 0.26442283f, -0.24693069f, 
    -0.10741679f, 0.02173283f, 0.40366149f, 0.11777234f, -0.07568779f, -1.02544558f, -0.51334715f, -0.38049749f, 
    0.23634855f, 0.07503091f, -0.19123784f, -0.74002773f, 0.13030456f, 0.40607196f, 0.63065511f, -0.37355143f, 
    -0.14626600f, 0.12376169f, -0.39944813f, -0.21671768f, -0.26056182f, 0.01383334f, -0.31287786f, 0.03658840f, 
    -0.26961040f, -0.01927435f, -0.54439515f, -0.41510040f, 0.27309254f, 0.25772238f, 0.14599283f, -0.10668173f, 
    -0.56616825f, -0.48940781f, -0.17444319f, 0.36567754f, -0.33342314f, -0.18697953f, -0.28379479f, -0.50524575f, 
    -0.34298995f, -0.32314339f, -0.46564031f, -0.71745551f, -0.74806315f, -0.34319338f, -0.01038294f, -0.08235811f, 
    -0.26997906f, -0.01070944f, -1.22233510f, -0.80682254f, -0.12011208f, 0.57032216f, 0.71592981f, -0.17608371f, 
    -0.05108862f, 0.14331710f, 0.58960229f, -0.30921608f, 0.30021524f, -0.16095975f, 0.22635123f, -0.11656676f, 
    -0.34028268f, 0.04772796f, -0.21465228f, -0.01122941f, 0.12192434f, 0.27645797f, -0.07264606f, -0.25073504f, 
    -0.15350164f, 0.03143325f, 0.66301376f, -1.35614026f, -0.46811038f, -0.40807351f, -0.42218226f, -0.29659122f, 
    1.04425037f, -0.38636383f, -0.43384352f, 0.62701541f, 0.85075957f, -0.01886930f, -0.01904203f, 0.02832396f, 
    0.09644536f, -0.10106080f, 0.10280263f, 0.03511566f, 0.16207413f, -0.00329733f, -0.03609244f, -0.05457504f, 
    0.05077837f, -0.09075792f, -0.23772272f, 0.35852438f, 0.78027815f, -0.37730440f, -0.02967051f, -0.01719707f, 
    0.06294549f, -0.49222282f, -0.03274582f, 0.51908445f, 0.08870697f, 0.00839612f, -0.25554451f, -0.07193699f, 
    0.56250536f, -0.27506888f, -0.27629063f, 0.09323107f, 0.07091664f, -0.33752871f, 0.17269267f, -0.24906214f, 
    -0.01510334f, -0.15513344f, 0.01042732f, 0.16303551f, 0.15175106f, 0.70022643f, 0.82004404f, 0.07555967f, 
    -0.37962812f, 0.25875935f, -0.23443389f, 0.23155895f, -0.08912879f, -0.58757120f, -0.90527231f, 0.08624379f, 
    0.27864018f, 0.18843655f, -0.47991759f, -0.16654016f, -0.27739528f, 0.31469339f, -0.02302530f, 0.32903329f, 
    -0.08981644f, 0.14922123f, -0.02226101f, -0.14367361f, -0.09444498f, 0.02641219f, 0.07253636f, 0.03579580f, 
    0.02890407f, 0.06703927f, 0.21220748f, 0.16381110f, 0.59049958f, -0.11103095f, 0.29168203f, -0.34833142f, 
    -0.09348408f, 0.59020013f, 0.18633382f, -0.08389263f, -0.24755524f, -0.46562687f, 0.21424946f, -0.21712963f, 
    -0.25037056f, 0.12245806f, 0.43728352f, 0.06396186f, 0.10249054f, -0.11677838f, -0.12877767f, 0.34204811f, 
    0.44200197f, 0.46979675f, 0.09305014f, -0.07323216f, -0.43761411f, -0.25197187f, 0.26354328f, 0.22998902f, 
    0.12490849f, 0.14532082f, -0.06018732f, 0.22516429f, -0.17412998f, -0.06291712f, -0.00802340f, 0.10160471f, 
    0.06783631f, -0.13256671f, -0.01644257f, -0.06058265f, 0.05186282f, -0.07155787f, 0.28969997f, -0.09926578f, 
    -0.49928924f, 0.28604335f, -0.31781608f, -0.43142095f, -0.06722555f, 0.03215925f, 0.00126741f, 0.15604943f, 
    0.27033368f, 0.07344069f, -0.17314917f, 0.40548915f, -0.27926818f, 0.35924459f, -0.27290848f, -0.41699043f, 
    -0.21867882f, 0.08062619f, 0.17136557f, -0.03861279f, 0.25235650f, 0.49940908f, 0.28960288f, 0.30727911f, 
    -0.00494169f, -0.05719535f, 0.12284735f, 0.00811294f, 0.09815693f, 0.06228411f, -0.92450851f, -0.87108046f, 
    -0.43120268f, -0.87401164f, -0.69096446f, 0.28116587f, 0.30155247f, 0.53639311f, -0.24166684f, 0.08207666f, 
    0.14979383f, 0.06213251f, -0.09293209f, 0.20583725f, -0.15990295f, -0.20710225f, -0.10737283f, -0.03414367f, 
    0.07944252f, 0.05891743f, -0.50736135f, -0.52477366f, -0.62036145f, 0.17966995f, 0.50416547f, 0.36717835f, 
    0.09856781f, -0.52280563f, 0.84486938f, -0.13977398f, -0.30919206f, 0.13159619f, 0.25954291f, 0.00789690f, 
    -0.32983723f, -0.32823080f, -0.22982919f, 0.27089149f, 0.13541445f, 0.47204566f, -0.25879082f, -0.06383376f, 
    0.12157118f, -0.11881339f, 0.25304338f, -0.47210354f, -1.38600504f, -0.67512614f, 0.16090409f, -0.21213876f, 
    -0.67363864f, -1.14274824f, -0.62849402f, -0.45376289f, -0.79670328f, 0.33009228f, 0.17479715f, -0.05329030f, 
    0.18295659f, 0.14834626f, 0.05054236f, -0.19922811f, 0.19598067f, -0.39205331f, -0.07213751f, -0.16379832f, 
    -0.05278392f, 0.20268221f, -0.20726439f, -0.62599748f, 0.56151891f, 0.70094007f, 0.31350106f, -0.01103570f, 
    0.32370022f, -0.82961130f, -0.34096918f, -0.05907602f, -0.17488521f, -0.55785310f, 0.13349260f, 0.34319875f, 
    -0.03970997f, 0.39096323f, 0.05029490f, -0.06536279f, -0.21553351f, 0.24166524f, 0.28455332f, -0.10258351f, 
    0.08495219f, 0.12522826f, 0.07195558f, 0.13228372f, -0.12576428f, -0.72293293f, -0.42630216f, -0.63363910f, 
    -0.89068639f, -0.44343293f, -0.05259307f, -0.56551224f, -0.70725638f, -0.82214069f, -0.29093266f, 0.21695720f, 
    0.33036697f, 0.06702769f, 0.24458615f, -0.33848360f, -0.33257285f, -0.41920787f, -0.31014690f, -0.43549207f, 
    -0.53682816f, -0.19258031f, 0.02043688f, 0.24074218f, -0.05798966f, -0.05055373f, -1.58656609f, -0.11595920f, 
    -0.14366803f, -1.23677564f, -0.51939207f, 0.11481271f, 0.52259034f, 0.56154263f, 0.34022072f, 0.38597038f, 
    -0.08824357f, -0.32472950f, -0.44430068f, -0.45732814f, 0.13209517f, -0.20787165f, -0.19701402f, -0.13100213f, 
    -0.10335401f, -0.42137170f, -0.09665603f, -0.29137459f, -0.04750044f, -0.66128415f, -0.70253783f, -1.28286994f, 
    -1.22030222f, -0.68418431f, -0.23015201f, -0.82456094f, 0.62707686f, 0.78359830f, -0.76707572f, -0.74752325f, 
    0.45162076f, -0.37713289f, -0.39954200f, -0.03121050f, -0.20289640f, -0.32691136f, 0.15073861f, 0.20666966f, 
    -0.35313404f, 0.10400683f, 0.02991417f, 0.02735189f, -0.21603639f, -0.14021820f, 0.25555992f, -0.27736679f, 
    -1.13878298f, -0.15013719f, 0.00590020f, 0.77323174f, 0.72959173f, 0.29545969f, -0.14231820f, -0.15101150f, 
    -0.21846122f, 0.48002970f, 0.13964552f, 0.01752446f, -0.45451197f, 0.29507950f, 0.00841520f, 0.12661871f, 
    -0.15123439f, -0.02416806f, 0.04644280f, -0.01098484f, -0.05165203f, -0.38737071f, 0.19699568f, 0.20655943f, 
    -0.27984142f, -0.30507994f, -0.54523939f, -0.32389924f, -0.24898072f, 0.10929243f, -0.19046007f, -0.03342345f, 
    -0.04908126f, 0.52910614f, 0.34857389f, -0.25059476f, 0.71672744f, 0.01875911f, -0.07228341f, 0.00995890f, 
    -0.29220581f, -0.08087955f, -0.29280454f, -0.52241170f, -0.44971773f, 0.23371911f, 0.20284954f, 0.26331764f, 
    0.33088624f, 0.20072579f, -0.68306100f, 0.08116754f, 0.41906774f, 0.27045125f, 0.16968183f, 0.07382268f, 
    -0.43221712f, -0.49532774f, 0.50699443f, 0.39302304f, 0.12680019f, -0.00331119f, -0.14058545f, -0.14541920f, 
    0.07186273f, -0.16030097f, -0.04287567f, -0.05982711f, -0.11322916f, -0.14368218f, -0.43170455f, 0.06344282f, 
    -0.40876827f, -0.16131516f, -0.48037079f, 0.72246313f, 1.14079988f, 0.75249493f, -0.24521784f, -0.44694382f, 
    -0.85228342f, -0.50055701f, -0.06220199f, -0.48370272f, -0.58844709f, -0.10036642f, -0.14849256f, -0.28205806f, 
    0.24981439f, 0.13872556f, 0.08562849f, 0.33273825f, 0.18752672f, -0.02729359f, 0.34284759f, -0.12460018f, 
    0.13149545f, -0.26978523f, -0.34882355f, -0.22224015f, 0.53041995f, 0.73067993f, -0.06472776f, -0.62109733f, 
    0.26272568f, -0.17629492f, 0.43159187f, 0.48557004f, -0.33460546f, -0.35499629f, -0.48003483f, -0.03728934f, 
    0.04254138f, -0.10013079f, -0.39312503f, 0.33113736f, -0.26428515f, -0.35520923f, 0.16744874f, -0.24969307f, 
    0.04680846f, 0.14270557f, 0.04681458f, 0.23944913f, -0.05647761f, -0.10196632f, 0.02862393f, 0.34070700f, 
    -0.46888956f, 0.00335863f, -0.55042189f, -0.65672666f, -0.06506521f, -0.32796398f, -0.67424285f, -0.26771593f, 
    0.30672503f, -0.65728688f, -0.38183737f, 0.47490421f, -0.04974326f, 0.32494497f, -0.05251566f, -0.34592378f, 
    0.02333319f, 0.00903895f, 0.22024186f, 0.29615277f, 0.21530063f, 0.30991280f, 0.99723816f, -0.37620625f, 
    -0.73431545f, -0.97353017f, -1.00336099f, 0.45853299f, 0.33343640f, 0.20566331f, -0.20946385f, 0.18138561f, 
    0.19243908f, 0.41235933f, 0.11332416f, -0.09067976f, 0.41495559f, 0.19766270f, 0.02895917f, 0.06661507f, 
    -0.29642332f, 0.01303161f, 0.05568689f, -0.26489091f, -0.19505398f, 0.02021713f, 0.12122548f, -0.14975511f, 
    0.87533242f, 0.49952808f, -0.05919344f, -0.11774396f, -0.61002398f, -0.21646266f, 0.35004836f, 0.41665789f, 
    0.09064685f, -0.18762344f, -0.17760752f, 0.16968186f, -0.62206608f, -0.50782502f, 0.29819727f, -0.27685270f, 
    0.16828218f, 0.03524439f, 0.24241726f, 0.01005244f, 0.21727125f, -0.27828115f, -0.18777822f, 0.27385977f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06244765f, 0.56791329f, 0.02746727f, 0.05764722f, 0.34529760f, 0.63243997f, 0.05616545f, 0.52769667f, 
    0.05403914f, 0.18173027f, 0.37304828f, 0.27324441f, 0.52210695f, 0.04092693f, 0.16725338f, -0.01154415f, 
    0.16415954f, 0.21125416f, 0.28833118f, -0.32953656f, 0.21748896f, -0.25585422f, 0.17157972f, -0.16578583f, 
    0.18601814f, 0.44557625f, 0.13168395f, 0.33133772f, 0.25654608f, 0.09822488f, 0.65027428f, 0.47781435f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29326177f, -0.26140103f, -0.06751319f, 0.06953587f, 0.09276964f, 0.04753391f, 0.02939752f, 0.02646983f, 
    0.04498383f, 0.00983949f, 0.05876582f, 0.02012767f, -0.07794653f, -0.16367161f, -0.92307496f, 0.14746854f, 
    -0.17820513f, -0.27118772f, -0.06779852f, -0.08982224f, -0.10209371f, -0.05432129f, -0.04487137f, -0.14668609f, 
    -0.03743340f, -0.73977935f, -0.18609971f, 0.02246714f, -0.01582520f, -0.02420088f, -0.05641198f, -0.06250458f, 
    -0.16642046f, -0.11288619f, 0.02800124f, 0.19314019f, 0.35571408f, 0.15362130f, 0.04361063f, -0.18094970f, 
    0.30809382f, 0.04231331f, 0.03076747f, -0.04757244f, 0.00354664f, 0.04937672f, 0.02268581f, -0.00596747f, 
    -0.28241810f, -0.34495395f, -0.59250450f, 0.13582066f, 0.13283521f, -0.08085476f, 0.04913464f, -0.17132629f, 
    -0.19544920f, -0.07693554f, -0.34026235f, -0.04017305f, -0.05141259f, -0.12101912f, -0.05670388f, -0.11619110f, 
    -0.11421643f, -0.04576828f, 0.10662483f, 0.04640730f, -0.28440157f, -0.01107769f, -0.06735911f, -0.24744628f, 
    -0.07703947f, 0.02359030f, 0.17471893f, -0.05965195f, -0.06306671f, -0.10634046f, -0.14704555f, 0.10995534f, 
    -0.04637149f, 0.01276771f, -0.01944028f, -0.05279923f, -0.29174116f, -0.29318005f, -0.19789362f, -0.03223754f, 
    -0.04230107f, -0.05306076f, 0.01706206f, -0.05454062f, -0.14063127f, -0.16506283f, -0.02503670f, -0.00836678f, 
    0.06868278f, 0.12327484f, 0.24087013f, -0.23027609f, -0.33724380f, -0.16786465f, -0.22555326f, -0.14637788f, 
    0.03941331f, -0.12565571f, -0.03094489f, -0.12703894f, 0.32674104f, 0.07038817f, -0.10870177f, -0.13129272f, 
    -0.14508221f, -0.13914126f, -0.09387147f, -0.21311295f, -0.13770841f, -0.02955795f, -0.13547158f, 0.00617328f, 
    0.44484517f, 0.22831368f, 0.12643647f, -0.49204245f, 0.02412282f, -0.15306583f, 0.13006207f, -0.15646517f, 
    -0.03636422f, -0.26051179f, -0.02421175f, -0.16506727f, 0.35595617f, 0.34243372f, 0.16135915f, -0.18372689f, 
    -0.02659854f, 0.22507757f, 0.12166057f, -0.13681488f, 0.05068782f, 0.05880817f, 0.03307494f, 0.03303592f, 
    -0.66839051f, -0.28946713f, -0.24619111f, -0.14437178f, -0.11125047f, 0.06084640f, -0.01191306f, 0.02904392f, 
    -0.05611431f, -0.14099252f, -0.16878192f, 0.11547493f, -0.09754910f, -0.26871082f, -0.73379821f, 0.26619515f, 
    -0.14514752f, -0.19912930f, -0.01529483f, -0.00815407f, -0.03458584f, 0.07256702f, 0.04715107f, -0.05569644f, 
    -0.15287082f, 0.02026423f, -0.07008186f, 0.00641889f, 0.05560046f, 0.04186901f, 0.00815029f, -0.02286410f, 
    -0.12740259f, 0.07224721f, 0.02361796f, -0.26629165f, -0.06015231f, 0.01306198f, 0.01517858f, 0.05012242f, 
    0.03538188f, -0.00022760f, 0.05259425f, -0.03522347f, -0.01916342f, -0.02733785f, -0.04699116f, 0.04314224f, 
    -0.06491362f, -0.00931553f, -0.01969144f, 0.04231105f, 0.04451792f, 0.21787053f, -0.06613689f, -0.09856137f, 
    0.01856897f, -0.15531507f, -0.13335980f, -0.11376447f, 0.34583482f, 0.36713868f, -0.22638939f, -0.20230524f, 
    0.05021054f, -0.05081102f, 0.09619580f, 0.11410067f, 0.01904289f, 0.07395022f, -0.05448223f, 0.01229664f, 
    0.17576475f, 0.24495998f, -0.09286857f, -0.01101006f, 0.00189412f, 0.08335216f, -0.02317477f, -0.25010097f, 
    0.00678943f, -0.18828294f, 0.02052170f, -0.27846408f, 0.56767887f, 0.23185584f, 0.01642811f, -0.23793820f, 
    0.19852883f, 0.03576522f, 0.10108759f, 0.12235724f, -0.07033549f, 0.04817348f, -0.07852714f, 0.11215795f, 
    -0.09116122f, 0.02264250f, -0.10856913f, 0.00266854f, -0.17865407f, -0.15058447f, -0.15793884f, -0.13191478f, 
    0.00406097f, 0.10229972f, -0.01239558f, -0.06195986f, 0.43401861f, 0.28717712f, -0.12866706f, -0.23159783f, 
    0.17904569f, 0.16268799f, -0.10623663f, 0.03307568f, -0.06231358f, -0.17939550f, -0.00981363f, -0.03314392f, 
    -0.02732490f, 0.03714913f, -0.00551736f, -0.12818281f, 0.09290482f, 0.17116942f, -0.00427106f, -0.03061540f, 
    -0.06093619f, 0.07605939f, 0.10315973f, 0.17064160f, 0.54519457f, 0.19325043f, -0.26585597f, -0.12644306f, 
    0.23905300f, 0.08831991f, 0.20376913f, 0.08326386f, 0.00860718f, -0.01401722f, -0.01692253f, 0.05144077f, 
    0.08580678f, 0.02542786f, 0.06445567f, -0.02212799f, -0.03332930f, 0.07322125f, 0.05586169f, 0.04821900f, 
    -0.13834345f, -0.11534994f, -0.16973029f, -0.00057993f, -0.02995149f, 0.11040027f, -0.08742362f, -0.05054659f, 
    0.00150465f, 0.09423318f, 0.06005887f, -0.22649218f, -0.13285483f, -0.18590678f, -0.09054193f, -0.10789161f, 
    -0.45404044f, 0.21670911f, 0.14259012f, -0.29801840f, 0.01978279f, 0.02141381f, 0.00247572f, 0.06344073f, 
    -0.00792898f, 0.02614789f, -0.04669834f, 0.09108087f, 0.01011894f, -0.00085572f, 0.08393747f, -0.07724152f, 
    0.02464107f, 0.16801715f, -0.00393453f, -0.09680469f, 0.02542446f, 0.01362603f, 0.01020882f, 0.02308576f, 
    -0.63489181f, -0.20470880f, -0.49667037f, 0.54486918f, -0.06010251f, 0.03748894f, 0.03573162f, 0.01313073f, 
    0.07902621f, -0.04387690f, 0.06787653f, -0.03535693f, 0.30048954f, 0.14298156f, -0.03574048f, -0.28871879f, 
    0.00640548f, 0.02387168f, -0.16192797f, 0.01454958f, 0.02215408f, 0.01433552f, -0.02384080f, -0.02726738f, 
    0.14781338f, -0.02521570f, -0.17685641f, 0.18045288f, 0.05683659f, 0.05829559f, -0.23574571f, -0.11626888f, 
    -0.07999457f, -0.10715595f, 0.06625932f, 0.00277634f, -0.75431359f, 0.14346395f, -0.04417671f, 0.21357337f, 
    0.04056918f, 0.02051130f, -0.03987003f, 0.04844514f, -0.00385688f, -0.10758002f, -0.02013605f, -0.03212047f, 
    0.26919889f, 0.35325328f, 0.08788320f, 0.24883449f, -0.09509837f, -0.00872819f, -0.05520747f, -0.03592455f, 
    -0.00631010f, 0.01702948f, 0.04238382f, 0.06024479f, 0.28028584f, -0.06733848f, 0.04802995f, 0.28429800f, 
    -0.13770585f, 0.00275099f, 0.22659045f, 0.13132387f, -0.03387978f, 0.00128118f, -0.07125218f, 0.12274217f, 
    0.45211259f, -0.34413600f, 0.44020039f, -0.21033758f, -0.01516504f, -0.13436906f, 0.15233096f, -0.02475581f, 
    -0.03868613f, -0.16343825f, -0.11515486f, -0.28547752f, -0.17779489f, 0.17550398f, 0.09394538f, -0.37820366f, 
    0.04511126f, 0.11497970f, -0.28242102f, -0.71434665f, -0.03682511f, -0.02391388f, -0.16239911f, 0.01336764f, 
    1.17325068f, -0.13639520f, -0.40672424f, -0.45606422f, -0.04298298f, 0.04894414f, 0.03704454f, -0.08275279f, 
    0.06860779f, 0.18077250f, 0.01460109f, 0.02215619f, 0.14216892f, 0.06117965f, -0.08890207f, 0.18000422f, 
    -0.06367926f, 0.02229351f, -0.01077816f, 0.01670602f, -0.19628480f, 0.07373092f, -0.10767248f, 0.19046253f, 
    -0.34781006f, -0.14434464f, -0.53861052f, -0.19837557f, 0.05981285f, -0.23891461f, 0.00116605f, 0.05301969f, 
    -0.04371483f, -0.10639108f, -0.07873023f, -0.15582024f, -0.00985378f, 0.28390020f, 0.13109116f, -0.09092815f, 
    0.01503012f, 0.04449658f, 0.01278511f, 0.04355483f, -0.05524306f, 0.00818463f, 0.07571012f, -0.00270257f, 
    -0.11898636f, 0.16592112f, -0.43799326f, -0.47637090f, 0.01966352f, -0.21360341f, 0.10971190f, -0.01006816f, 
    -0.01357097f, 0.14967738f, 0.07691979f, -0.04829520f, -0.09943164f, -0.32214680f, -0.28664216f, -0.12236412f, 
    0.04566824f, -0.00831942f, 0.08710364f, 0.17446549f, 0.07508662f, -0.01907788f, -0.31609964f, -0.03943852f, 
    -0.48657280f, 0.10508198f, -0.39263535f, 0.00263542f, 0.05240809f, 0.18142435f, 0.17050128f, -0.15750775f, 
    0.19044368f, 0.02642983f, -0.10904363f, 0.07452517f, -0.15582539f, 0.23372123f, -0.15585683f, -0.10956701f, 
    0.04945527f, 0.11150282f, -0.06219973f, -0.09125339f, -0.11694049f, 0.10816596f, 0.04051745f, -0.14745250f, 
    0.41595203f, 0.14208049f, 0.15654482f, 0.11059234f, -0.05949668f, 0.03842606f, 0.07778902f, -0.13815315f, 
    0.02183628f, -0.05300325f, 0.07151389f, 0.11064218f, 0.31259125f, 0.03923061f, -0.11255296f, -0.06625363f, 
    -0.32297188f, -0.24394004f, -0.08868565f, -0.18290803f, -0.03950009f, -0.03475225f, -0.03085929f, 0.10555547f, 
    0.03731861f, -0.07538809f, 0.04682885f, 0.11629678f, -0.03814452f, -0.09751995f, 0.00106700f, -0.02226315f, 
    -0.04271928f, -0.06093117f, -0.12889951f, 0.06505676f, 0.12170462f, 0.11097977f, 0.15542147f, 0.07301944f, 
    0.02689715f, -0.06684526f, -0.05424019f, -0.08433173f, -0.00656591f, 0.02151888f, -0.01596533f, 0.07655779f, 
    -0.01882960f, -0.03990491f, 0.04499631f, 0.06799927f, 0.06125846f, -0.08020810f, 0.04009525f, 0.04186923f, 
    -0.23637624f, -0.14427415f, -0.01462417f, 0.03502074f, -0.06456076f, 0.02410485f, -0.43527871f, -0.01481688f, 
    -0.30487174f, 0.07754821f, -0.01115861f, -0.02006972f, -0.03791584f, 0.03180419f, 0.07224914f, 0.11728162f, 
    -0.12440075f, -0.04643098f, -0.31203583f, 0.04894192f, 0.03172232f, -0.01231060f, 0.13148516f, 0.09927174f, 
    0.17049469f, 0.07565824f, 0.03722548f, -0.05410348f, -0.43694276f, 0.08024509f, 0.17894813f, 0.22393391f, 
    -0.11985273f, -0.01966122f, 0.15111502f, 0.16968718f, -0.02360659f, -0.00268286f, 0.09425966f, 0.00475957f, 
    0.13042529f, 0.01699849f, -0.06429797f, -0.08058795f, 0.06026867f, 0.04451641f, -0.25649926f, -0.03443054f, 
    -0.05510490f, -0.08198497f, 0.01394491f, 0.07867972f, -0.00607073f, -0.03504748f, 0.26476607f, 0.48203349f, 
    0.01234615f, 0.18708110f, 0.04918496f, 0.16037671f, -0.01956585f, 0.01141443f, 0.00297050f, 0.00663215f, 
    -0.25421488f, -0.16722874f, 0.01108673f, -0.17059258f, 0.09692039f, 0.11188512f, -0.24421339f, 0.01953590f, 
    -0.08171490f, 0.04022205f, -0.30716580f, -0.27859038f, 0.67340487f, 0.10941803f, 0.27964866f, 0.07539751f, 
    -0.04132489f, 0.06212403f, -0.01985123f, -0.09446590f, 0.06129629f, -0.14810647f, -0.02622989f, -0.08881802f, 
    0.07158480f, 0.06649125f, -0.04280341f, 0.08412430f, 0.00229506f, 0.02563128f, 0.02432235f, 0.00981392f, 
    0.05022886f, -0.01268135f, -0.10019606f, -0.04026670f, -0.37272704f, -0.11004913f, -0.29911485f, -0.12877108f, 
    -0.09733144f, 0.06951030f, 0.17991205f, 0.17779377f, 0.01802307f, 0.12857789f, -0.04963487f, 0.03418538f, 
    0.03699278f, 0.18261258f, -0.05544806f, -0.00227917f, 0.02346297f, 0.03557041f, 0.02872551f, -0.01232733f, 
    -0.22666049f, -0.18401799f, -0.09591240f, -0.05045208f, 0.10638084f, -0.00260002f, -0.07551335f, -0.29467413f, 
    -0.04816752f, -0.25002143f, -0.14133281f, 0.12259336f, -0.01919897f, 0.03695080f, -0.03457171f, -0.00065765f, 
    0.50777084f, -0.10715827f, 0.23151323f, 0.39304137f, -0.17459078f, -0.13497461f, 0.05879888f, -0.04602557f, 
    -0.07592972f, -0.03421978f, -0.06330813f, 0.04343884f, -0.01589809f, 0.30776641f, 0.04797633f, -0.10529181f, 
    0.10887682f, -0.07431904f, 0.12777250f, 0.09990938f, -0.10386438f, 0.10841369f, -0.02742940f, 0.00862941f, 
    0.31519556f, -0.38709030f, -0.24378502f, -0.12026414f, 0.07955340f, 0.11241416f, 0.00317495f, -0.14801194f, 
    0.27383500f, 0.06163352f, 0.03747385f, -0.00311138f, 0.05589319f, 0.12975809f, 0.31212062f, 0.06640983f, 
    -0.11186326f, 0.03298006f, -0.05169446f, -0.08091298f, -0.05844033f, 0.02733333f, -0.01677522f, 0.02577640f, 
    -0.21536474f, -0.10725597f, 0.06887802f, -0.17986234f, -0.04457664f, -0.06599294f, -0.04164583f, 0.06707310f, 
    -0.05751590f, -0.11634692f, 0.04189479f, -0.01880324f, 0.06405412f, -0.05815087f, -0.09493031f, -0.03544592f, 
    0.01518957f, -0.01209070f, 0.14967361f, 0.09693128f, 0.12125839f, -0.06642389f, -0.15693660f, 0.00483767f, 
    -0.35299882f, 0.12102988f, 0.05384672f, -0.62206078f, 0.04965001f, -0.03525367f, 0.02416703f, -0.12654375f, 
    -0.03262404f, 0.12782055f, 0.17178205f, 0.00789268f, -0.70038253f, 0.02199156f, -0.24955048f, -0.21371283f, 
    0.14121506f, 0.29891706f, -0.01870423f, -0.06050062f, -0.02410366f, -0.03570159f, 0.04102494f, 0.00566657f, 
    -0.46099156f, 0.82873482f, 0.11237069f, -0.14022829f, -0.05224697f, 0.10443238f, -0.11244444f, -0.11291077f, 
    -0.08285477f, -0.10564386f, -0.11955755f, -0.05706375f, 0.17473035f, -0.25180110f, 0.05167608f, 0.17393784f, 
    0.11786412f, 0.01942584f, 0.00379972f, 0.06127218f, 0.09466457f, -0.02824395f, 0.02404224f, 0.08812211f, 
    -0.14782946f, -0.05112027f, -0.23119454f, -0.45023349f, 0.07073757f, -0.01336164f, 0.00141051f, -0.01317649f, 
    -0.01636493f, -0.00931516f, 0.04666496f, -0.11042809f, -0.25327569f, -0.04400832f, 0.12859336f, -0.10375097f, 
    0.02295691f, -0.03540473f, -0.02847520f, 0.05184351f, 0.01635979f, -0.02878312f, 0.18607464f, -0.11326746f, 
    -0.66439581f, -0.12040827f, 0.02536310f, -0.01653955f, 0.05783901f, -0.02273257f, -0.15075147f, -0.15896472f, 
    -0.01647305f, 0.00963718f, 0.00729105f, -0.05340887f, -0.06989249f, 0.17897040f, 0.09738890f, -0.09407662f, 
    0.08245473f, -0.03468182f, -0.08781473f, 0.01471414f, -0.01246421f, -0.02879146f, -0.12412470f, -0.05176389f, 
    0.17171963f, -0.02438809f, -0.43202236f, 0.10039840f, 0.00989756f, 0.17163649f, -0.07556148f, 0.32215589f, 
    0.01483614f, 0.18746223f, 0.05525169f, -0.07416450f, 0.39881769f, 0.08834656f, 0.13668230f, 0.52981174f, 
    0.13944627f, 0.13904090f, -0.21235746f, 0.22136426f, 0.07238566f, 0.04685274f, 0.04634206f, 0.21013248f, 
    -0.04261272f, 0.12463135f, -0.07109778f, 0.21043530f, -0.05292267f, 0.09549839f, 0.07194719f, -0.04528196f, 
    -0.00712093f, -0.05360367f, 0.09689572f, -0.11201528f, -0.06846922f, -0.16801809f, 0.22921808f, -0.50388557f, 
    0.04225492f, -0.06597054f, -0.15177315f, 0.16569802f, -0.00750641f, -0.08217126f, 0.02827123f, 0.05299519f, 
    0.07386646f, 0.03891319f, -0.29870072f, -0.09351442f, 0.03260705f, -0.11485096f, 0.10011750f, 0.08964308f, 
    0.07235308f, -0.00715269f, -0.07393815f, -0.01819195f, -0.24942650f, -0.01535098f, -0.00629517f, -0.05033764f, 
    -0.04387219f, 0.01400302f, 0.03744193f, 0.03834319f, 0.01537336f, -0.02559449f, 0.05344079f, 0.00694676f, 
    0.04602087f, -0.10335620f, -0.07441711f, 0.01600720f, -0.01489673f, 0.01287763f, -0.17353691f, 0.03155544f, 
    -0.10209654f, -0.17766210f, -0.13540947f, -0.05965061f, -0.56841874f, -0.41176608f, -0.29375258f, -0.11225893f, 
    0.15678741f, 0.15744291f, 0.08636729f, -0.15640661f, 0.01621132f, -0.10266940f, 0.02387091f, -0.07804865f, 
    -0.19829439f, 0.10623220f, -0.22549152f, 0.34353489f, -0.02983745f, -0.11096244f, -0.00159364f, 0.15905629f, 
    0.04996670f, 0.14997418f, 0.18698227f, -0.26707324f, -0.83206916f, -0.69642812f, -0.25022420f, -0.25796020f, 
    -0.12585056f, -0.26972315f, 0.03826622f, -0.13828799f, -0.04603612f, 0.03261390f, 0.00824658f, -0.03953288f, 
    -0.30663651f, -0.06844681f, 0.14898404f, 0.02579410f, -0.31328878f, -0.22710969f, -0.22239181f, -0.00315284f, 
    0.04053426f, -0.10154828f, 0.00973746f, 0.05224494f, -0.18282720f, -0.27433902f, 0.05132435f, -0.12853377f, 
    -0.02538162f, -0.09017373f, 0.08132883f, -0.07231344f, 0.04716527f, -0.04746172f, 0.03678214f, -0.03442571f, 
    0.28510940f, 0.48121709f, 0.45265955f, 0.39270464f, 0.00314755f, -0.05765408f, 0.12389324f, 0.10933761f, 
    0.01955357f, -0.03116318f, -0.13283528f, 0.03391550f, 0.00720024f, -0.20854490f, 0.99475515f, 0.57874811f, 
    -0.18823503f, -0.14514387f, 0.00487481f, 0.07995334f, -0.00881499f, 0.02439202f, 0.01494059f, -0.01968575f, 
    -0.00952380f, -0.11437347f, -0.12462151f, 0.12747540f, -0.02189038f, 0.03262090f, 0.01662613f, 0.08828600f, 
    0.11338004f, -0.07625619f, 0.02076328f, 0.04954469f, 0.36700109f, -0.10514341f, -0.08312384f, 0.02312310f, 
    0.02511697f, 0.10173605f, 0.02976846f, -0.05819266f, -0.05031803f, 0.06325666f, -0.23805311f, 0.12464649f, 
    0.03931994f, 0.01549163f, -0.06517738f, 0.08203567f, 0.02708913f, -0.02289080f, -0.04493213f, 0.11581786f, 
    0.05214669f, 0.05742644f, 0.17662622f, 0.18530717f, -0.28392684f, -0.08337933f, 0.25307930f, -0.37055913f, 
    0.02381116f, -0.08911967f, -0.32628381f, -0.18288395f, 0.05632725f, -0.04695778f, -0.03535981f, 0.05313965f, 
    0.40796691f, -0.74453968f, 0.07493012f, -0.10505067f, 0.01026378f, 0.04936187f, 0.09340087f, 0.00238830f, 
    -0.03507240f, -0.09053554f, -0.02333637f, -0.00214350f, -0.27021414f, -0.38838810f, -0.34229085f, -0.20573899f, 
    -0.30929381f, 0.10452154f, -0.30157959f, -0.18796869f, -0.06132439f, -0.03891126f, -0.09991260f, 0.01347774f, 
    -0.03530220f, 0.32379279f, 0.35523236f, -0.05157990f, -0.07419778f, 0.08072602f, 0.07258521f, -0.07944100f, 
    0.07941492f, 0.14610612f, -0.04585459f, 0.11482918f, 0.04295160f, -0.09608135f, 0.15857558f, -0.10371865f, 
    0.04836407f, 0.09319498f, -0.01931759f, 0.06623526f, -0.02489111f, -0.04623013f, 0.03000505f, -0.03868346f, 
    -0.46780747f, -0.42587116f, -0.46682885f, 0.14895743f, 0.03665351f, -0.13369526f, -0.20116937f, -0.13205823f, 
    0.03499827f, -0.11109255f, 0.12769002f, -0.06208709f, -0.36712831f, -0.01627419f, -0.15568325f, 0.19223242f, 
    -0.03268469f, -0.24599524f, -0.16709305f, -0.21932352f, -0.14065370f, -0.13666394f, -0.18311484f, -0.09450395f, 
    -0.40138015f, -0.11012129f, 0.20783265f, 0.18390001f, 0.03329024f, 0.07153478f, -0.02054744f, -0.03787775f, 
    0.08613107f, 0.06135560f, 0.01267844f, -0.13314909f, -0.02316207f, -0.24920271f, -0.08516167f, 0.15617765f, 
    -0.12293536f, 0.10406670f, -0.16355881f, 0.12523173f, 0.01213857f, -0.06022952f, 0.02486711f, -0.18695405f, 
    -0.51671004f, 0.20873795f, 0.05758699f, 0.23784220f, 0.05825777f, 0.19960284f, 0.26276585f, -0.20490532f, 
    -0.02329480f, 0.03252826f, 0.05704474f, 0.10001159f, 0.33423573f, 0.08753277f, 0.11694485f, -0.70608574f, 
    0.15300161f, 0.26916471f, -0.06407468f, -0.03646149f, -0.20081253f, -0.01762116f, -0.11846770f, -0.22142583f, 
    0.16629516f, -0.55331272f, 0.38370329f, -0.07276718f, -0.12666094f, 0.08422347f, -0.29211652f, -0.02143630f, 
    -0.13407624f, 0.20289904f, 0.07455520f, -0.07172998f, -0.58380479f, -0.21075247f, -0.06948431f, -0.59400177f, 
    -0.01778943f, 0.13699342f, -0.04725979f, 0.15224463f, -0.14835551f, 0.00902890f, -0.13459028f, 0.01648259f, 
    0.16375867f, -0.11443676f, -0.04298103f, -0.04867018f, -0.05940574f, -0.04155607f, 0.08560652f, 0.14536282f, 
    -0.04822964f, -0.00438750f, 0.02625426f, -0.04645711f, -0.10765235f, 0.19995475f, -0.18039894f, 0.22780049f, 
    -0.04213312f, -0.03320574f, -0.08946764f, -0.07630781f, -0.09792046f, 0.05517814f, 0.02291822f, 0.12172159f, 
    -0.42314920f, 0.02945460f, -0.31498644f, -0.56329596f, -0.03584471f, -0.01629544f, -0.02342452f, 0.02164386f, 
    -0.14264028f, -0.02379943f, -0.05582202f, -0.17139229f, 0.32188749f, -0.23802978f, -0.08702698f, -0.04937125f, 
    0.25097680f, 0.02511513f, -0.00703406f, -0.04695454f, -0.27631038f, 0.06635933f, -0.08006030f, -0.06819221f, 
    -0.95963436f, 0.15742476f, -0.14861435f, -0.03130881f, 0.09746549f, -0.09644795f, -0.02037869f, -0.23144035f, 
    -0.10274609f, -0.00289256f, -0.24355635f, -0.34370741f, -0.06085179f, 0.15175836f, 0.56577867f, 0.37994105f, 
    -0.19793195f, 0.07894950f, -0.13134080f, -0.01014334f, 0.10255530f, 0.11054791f, -0.04088080f, 0.07585875f, 
    0.01557287f, -0.12534365f, -0.35437533f, -0.33822900f, -0.08811672f, -0.04741081f, 0.20325816f, -0.02598428f, 
    -0.32598874f, -0.03252980f, -0.18480678f, 0.04730614f, -0.22734751f, -0.18750292f, -0.10285704f, -0.05589754f, 
    -0.26246983f, -0.27541879f, -0.34270474f, -0.01935580f, 0.10352902f, 0.29588208f, 0.02293006f, -0.12756275f, 
    0.35201108f, 0.07454848f, -0.12038825f, 0.31165412f, 0.06862954f, 0.02055697f, -0.06429917f, -0.12388780f, 
    0.09047449f, 0.04374624f, 0.19216904f, 0.04659189f, 0.07727940f, -0.10900990f, -0.05008196f, 0.07612744f, 
    0.06948553f, 0.15810488f, 0.05789856f, 0.03622432f, 0.00693296f, 0.04389576f, -0.06683603f, 0.08973059f, 
    -0.01266873f, -0.17139253f, -0.54165930f, -0.46985221f, 0.13062827f, 0.01531616f, -0.30170450f, 0.33227688f, 
    -0.09725762f, -0.14081563f, -0.17376406f, -0.13539350f, -0.08935336f, -0.04948995f, -0.29727483f, 0.18346672f, 
    0.03163733f, 0.13112959f, 0.03506538f, 0.10544811f, 0.04922335f, -0.09583239f, -0.02680799f, -0.05521375f, 
    -0.06381523f, -0.42702180f, 0.74202996f, 0.21091868f, -0.01824195f, 0.07808186f, -0.24133500f, 0.23249385f, 
    0.11273842f, -0.02287934f, 0.29269716f, 0.07121362f, -0.01676438f, -0.19521497f, -0.12223915f, 0.26010394f, 
    0.07518440f, -0.04162492f, 0.09004262f, 0.01558772f, -0.01975296f, 0.12749335f, -0.07207906f, 0.03936784f, 
    0.78495997f, -0.14237407f, 0.06273213f, 0.20112057f, 0.16725455f, 0.03669795f, 0.09422830f, -0.10253337f, 
    -0.21767992f, 0.07427939f, 0.03403787f, 0.10122105f, -0.24466196f, 0.17249855f, 0.03452738f, 0.22053979f, 
    0.09490401f, -0.01338071f, -0.02694269f, -0.23125435f, -0.05816305f, 0.04515212f, 0.06054122f, 0.19427352f, 
    -0.20072566f, 1.01872134f, -0.15718456f, -0.59601361f, -0.05490126f, 0.23062800f, 0.08587924f, -0.20522599f, 
    -0.21364431f, -0.12249675f, 0.19036463f, 0.35074598f, -0.04058027f, 0.13317668f, -0.07490367f, -0.00308333f, 
    0.05162928f, -0.08927190f, 0.10135324f, -0.02471766f, 0.07109055f, 0.30731258f, -0.26593202f, 0.14155371f, 
    0.11480376f, 0.08882227f, 0.04677071f, -0.26464990f, -0.08663732f, 0.10317223f, -0.14935534f, 0.14683332f, 
    0.08367493f, 0.08140287f, -0.08730562f, -0.06339741f, -0.11067484f, -0.25720045f, 0.59107172f, 0.07709651f, 
    -0.11113494f, 0.08219475f, 0.08887754f, 0.02317119f, 0.15790173f, -0.05923737f, -0.05056278f, 0.06113999f, 
    0.46257827f, 0.22063014f, 0.37907243f, 0.03218452f, 0.13031393f, -0.08363687f, -0.11653766f, 0.10344013f, 
    -0.06377018f, -0.05317377f, 0.23451994f, 0.15204673f, 0.14469600f, -0.31637207f, 0.32786980f, -0.07301289f, 
    -0.01166799f, 0.12321050f, -0.11783107f, 0.05746773f, 0.13028334f, -0.19545875f, -0.42407045f, -0.13416508f, 
    -0.47576013f, -0.16519521f, 0.01603349f, 0.41659206f, 0.03981373f, 0.05128117f, 0.05536655f, -0.05632344f, 
    0.02848115f, 0.00807652f, 0.09827807f, 0.09416135f, 0.59537649f, -0.46815673f, 0.02721484f, -0.46779120f, 
    -0.25298682f, -0.02085099f, -0.09276424f, 0.23858939f, -0.01285106f, 0.02847155f, 0.24512668f, -0.21849561f, 
    -0.11180031f, -0.10649230f, -0.03906484f, 0.06828774f, 0.08466564f, 0.10073820f, 0.11151537f, -0.03282278f, 
    0.13529450f, 0.03477672f, 0.10671265f, 0.14200328f, -0.07725781f, -0.15728883f, -0.19237354f, -0.31364164f, 
    0.07945603f, -0.05516535f, -0.21479927f, -0.31342870f, -0.01924299f, -0.08422839f, 0.14970618f, -0.27836397f, 
    -0.26628149f, 0.46866241f, -0.10348864f, 0.02969038f, 0.02579395f, -0.10575221f, -0.04917576f, -0.05984622f, 
    -0.21845150f, -0.07951584f, 0.15615757f, 0.17829356f, 0.01378688f, 0.20793743f, 0.12635523f, 0.09562675f, 
    -0.12930785f, 0.06276947f, -0.01012162f, 0.05437857f, 0.10238156f, -0.02770563f, 0.00057476f, 0.01607870f, 
    -0.11758140f, -0.29694936f, 0.14089991f, 0.03442390f, -0.06626020f, -0.01593363f, -0.19750366f, 0.16680339f, 
    -0.01779812f, -0.28722838f, -0.17539620f, -0.02110394f, 0.12037759f, 0.21323587f, -0.27325132f, -0.12337852f, 
    -0.08397432f, 0.03625063f, 0.09345284f, -0.04919688f, 0.16012004f, -0.19255169f, -0.04413102f, -0.05053893f, 
    0.15320186f, -0.17955591f, -0.14767759f, 0.14891197f, -0.04355226f, 0.00031131f, 0.03960612f, -0.03494976f, 
    0.02377728f, -0.12002502f, -0.00339785f, -0.01833676f, 0.34519526f, 0.05145783f, -0.66923368f, -0.16197547f, 
    0.02775953f, -0.07874168f, 0.14860523f, -0.10669658f, -0.06339684f, -0.23576730f, -0.28677776f, -0.19669363f, 
    -0.15975262f, 0.27417740f, 0.01105008f, 0.19119717f, -0.22892679f, 0.22484337f, -0.08734206f, -0.04582857f, 
    -0.07816992f, -0.07326012f, -0.00068437f, 0.02327629f, 0.10221551f, -0.10105595f, 0.14499728f, 0.10600193f, 
    0.13548075f, 0.07017532f, -0.01552139f, -0.06065768f, 0.07688619f, -0.12999251f, 0.12802450f, -0.05324287f, 
    0.02861869f, -0.45289454f, 0.08634075f, 0.13865136f, -0.22507274f, 0.01404714f, -0.27229348f, -0.16597345f, 
    -0.22550166f, 0.17606792f, -0.13268761f, -0.09921374f, 0.10173111f, 0.15589263f, -0.17085399f, 0.12267729f, 
    -0.36002880f, -0.16584943f, 0.07213549f, -0.05379291f, -0.05959555f, -0.04479637f, 0.04117578f, -0.04840449f, 
    0.02950947f, -0.29187575f, 0.02515283f, -0.28987643f, -0.04138612f, 0.07261319f, -0.03963937f, 0.13031031f, 
    -0.07390418f, -0.11212771f, -0.07556921f, -0.28364533f, 0.28078088f, 0.17394727f, -0.17510557f, -0.06630304f, 
    0.16607071f, -0.00875710f, 0.27581245f, 0.05239875f, 0.15208569f, 0.01499593f, 0.05245001f, -0.15942582f, 
    0.07588167f, 0.08208359f, 0.01634754f, 0.05151240f, 0.05561031f, 0.00639439f, -0.05059779f, 0.00970954f, 
    0.11123105f, 0.10876152f, -0.12092288f, -0.15210396f, 0.01777405f, -0.01599186f, -0.02259431f, 0.00876476f, 
    0.03032622f, 0.08236762f, 0.08828419f, 0.09960281f, 0.00422251f, 0.00954568f, 0.07100406f, -0.03428805f, 
    0.04958076f, 0.16854230f, 0.01828376f, 0.01889836f, 0.00697036f, -0.11007977f, -0.09253936f, 0.04636904f, 
    0.12473153f, -0.15617919f, -0.15088391f, -0.03267373f, -0.01588508f, 0.25454581f, 0.40501046f, 0.23653263f, 
    -0.10944795f, -0.05687265f, -0.01695823f, 0.18918420f, 0.03588022f, -0.03411619f, 0.01559517f, -0.12343226f, 
    0.01895772f, -0.23169100f, 0.18419871f, -0.07350096f, -0.30365497f, -0.12803029f, -0.23944721f, -0.09721744f, 
    -0.22537486f, -0.06654089f, -0.27016035f, -0.11045745f, 0.08622616f, 0.14819841f, 0.42825788f, 0.02214867f, 
    -0.16801098f, -0.11661164f, -0.10004730f, 0.12650387f, -0.01626507f, -0.07949407f, 0.07913500f, 0.09548979f, 
    -0.04704707f, 0.09984712f, -0.03060918f, 0.14916386f, -0.12241678f, 0.02237225f, 0.25227293f, -0.07057811f, 
    0.07221130f, -0.03543752f, -0.03628036f, -0.04433342f, 0.17345989f, 0.18250304f, 0.18621570f, 0.15120506f, 
    -0.04819550f, -0.08903841f, -0.04413199f, 0.08715317f, 0.18251790f, 0.05232785f, 0.05618634f, 0.06479327f, 
    -0.34470055f, -0.05900183f, -0.02754820f, 0.09088200f, -0.14801946f, -0.12538287f, -0.10608769f, 0.05734719f, 
    0.24210109f, -0.07471184f, 0.09774704f, 0.20566812f, -0.15622716f, -0.09097087f, -0.00857793f, 0.15322618f, 
    -0.14768328f, -0.14294498f, 0.03700748f, -0.17030355f, -0.04150981f, -0.03351310f, -0.01705008f, 0.05055333f, 
    -0.05858268f, -0.09997014f, 0.01121218f, 0.10235371f, -0.00826400f, -0.07306319f, 0.05748374f, -0.00160393f, 
    -0.14186315f, 0.14794226f, -0.09130733f, 0.14980778f, 0.09340743f, 0.13155566f, 0.08186704f, 0.17466153f, 
    -0.00192086f, 0.04014177f, -0.17106721f, -0.04511382f, -0.20611338f, -0.40801802f, -0.06799497f, -0.08171857f, 
    0.01283672f, -0.22683379f, -0.24200523f, 0.06595134f, 0.03034928f, -0.04164001f, 0.02121206f, -0.16185956f, 
    -0.03717957f, 0.08972590f, 0.34867230f, 0.27472430f, 0.19784467f, 0.41664553f, -0.24773765f, 0.40206602f, 
    0.12764768f, 0.19479947f, -0.07177161f, -0.04525382f, 0.12905973f, -0.08769255f, -0.03482261f, -0.05771570f, 
    -0.24598353f, 0.22777088f, -0.70540273f, -0.39548400f, 0.15791906f, 0.11812226f, -0.06396980f, 0.01569631f, 
    0.14935538f, -0.03375416f, -0.03644222f, -0.11629584f, -0.06369888f, 0.21197422f, -0.03741286f, 0.39381322f, 
    -0.10952573f, 0.14589483f, 0.10004503f, -0.01484226f, -0.05835493f, -0.11618010f, 0.00486500f, -0.15179865f, 
    0.09672942f, 0.04318096f, 0.02900209f, 0.03968342f, 0.06284966f, -0.10058430f, 0.00893735f, -0.09928839f, 
    -0.21178509f, -0.03991511f, -0.01621810f, 0.09916865f, 0.34415331f, -0.11171494f, -0.26330990f, -0.22497679f, 
    0.07355234f, 0.01014501f, 0.12931229f, 0.05046427f, 0.11804030f, -0.05434295f, 0.01147431f, -0.02042612f, 
    -0.07369879f, -0.34793064f, -0.01484603f, 0.06582365f, 0.06121838f, 0.00207360f, -0.05293430f, 0.01423223f, 
    0.00299898f, 0.14708643f, 0.00817469f, 0.00307880f, 0.09958021f, 0.11729816f, -0.03100941f, -0.31730765f, 
    0.18713695f, 0.14720944f, -0.06934787f, -0.00769074f, 0.19382526f, -0.06903928f, 0.15913299f, 0.14015451f, 
    0.21855672f, -0.09475473f, -1.05850101f, -0.37240389f, -0.01805482f, 0.16141172f, -0.03837318f, 0.02360179f, 
    0.14125554f, -0.07028460f, -0.31044999f, -0.18134396f, 0.27540472f, -0.01629209f, 0.04730200f, 0.30570745f, 
    0.09180160f, -0.15556189f, 0.11452205f, 0.34163162f, -0.08910247f, 0.00323245f, 0.08968788f, 0.14078261f, 
    -0.09403728f, -0.27388611f, -0.08581705f, -0.08590833f, -0.10932595f, 0.04634951f, -0.09042720f, 0.00351287f, 
    0.23528174f, -0.25722340f, -0.00566915f, -0.05095682f, -0.65603089f, -0.09448926f, 0.04934922f, 0.08806054f, 
    0.01602016f, -0.12424953f, -0.13853684f, 0.14550167f, 0.23922560f, 0.15295289f, -0.00882251f, 0.14894263f, 
    0.33421278f, 0.12915115f, -0.15203971f, 0.26604480f, 0.07549260f, 0.23616445f, 0.10244698f, -0.04342813f, 
    0.01171729f, 0.02161316f, 0.05228503f, 0.21938187f, -0.02349755f, -0.16781335f, 0.01970918f, 0.17979519f, 
    -0.08654872f, -0.01033032f, -0.21175316f, 0.03052913f, 0.25849059f, 0.13959780f, 0.19718730f, 0.06158364f, 
    0.05109541f, -0.19084863f, 0.31903547f, 0.43167010f, 0.11885014f, 0.01267396f, -0.15695678f, -0.06905337f, 
    -0.02649484f, 0.01519870f, -0.12621707f, -0.10085666f, 0.15590894f, 0.41146877f, 0.24815871f, -0.09492213f, 
    -0.09086552f, -0.00803363f, 0.10982522f, 0.12108558f, -0.06587778f, -0.11144929f, -0.18649022f, 0.05619814f, 
    0.21360812f, -0.15583415f, 0.27187368f, 0.19525817f, 0.08930016f, 0.07161883f, 0.06346517f, 0.07238323f, 
    -0.05790307f, -0.12939848f, -0.01397142f, 0.19614084f, -1.03233576f, -0.65254468f, 0.00226902f, -0.34752399f, 
    0.04699608f, -0.08133231f, 0.00995111f, 0.07460079f, 0.14446878f, -0.28769115f, -0.12450427f, 0.18778799f, 
    0.21547544f, -0.20817815f, 0.16144146f, 0.09759533f, 0.03129904f, -0.07673375f, -0.09920771f, 0.00040117f, 
    0.14520879f, 0.15390597f, -0.02761160f, 0.14205553f, -0.02474764f, 0.00548304f, -0.45508090f, -0.15969817f, 
    0.33553082f, 0.10873814f, -0.01275134f, 0.27125412f, -0.00089503f, -0.07142626f, -0.00673498f, -0.07294277f, 
    0.05402951f, -0.19773173f, -0.06270872f, 0.12658414f, 0.02703107f, 0.02373585f, -0.07857943f, -0.01200406f, 
    0.08589928f, -0.04828546f, 0.49678802f, 0.07144972f, -0.21272105f, -0.11582156f, -0.01463731f, 0.13143188f, 
    0.05926330f, -0.02289008f, -0.06785905f, -0.01854496f, -0.02921283f, -0.11955835f, 0.10858284f, -0.05885760f, 
    -0.17342319f, -0.11852151f, -0.15219298f, -0.07371047f, -0.12863761f, 0.12825043f, -0.12231670f, -0.20669229f, 
    0.24464215f, 0.33095312f, 0.09717280f, -0.05861370f, 0.07323388f, 0.10390381f, 0.21193531f, -0.17171025f, 
    0.32634199f, -0.23281009f, -0.13100041f, -0.10483042f, 0.04328872f, 0.00955642f, -0.02467357f, 0.06464921f, 
    0.03486186f, -0.19124947f, 0.31836727f, -0.06852271f, -0.17421278f, 0.09044523f, 0.09280548f, -0.26551166f, 
    -0.04754939f, 0.03397842f, 0.11603498f, 0.18098783f, 0.21927506f, 0.10004813f, 0.13748489f, 0.02324397f, 
    0.20872556f, 0.02730409f, -0.09795748f, -0.35177907f, 0.05521974f, 0.00460939f, 0.02412980f, -0.04237868f, 
    -0.16104320f, -0.15983999f, -0.24135417f, 0.02130663f, 0.23290204f, -0.11718988f, 0.08762350f, -0.03495866f, 
    -0.10096763f, 0.13733929f, -0.05087861f, -0.00151834f, -0.10513803f, 0.14969300f, 0.08891177f, -0.35540694f, 
    0.11679607f, 0.05881712f, 0.14453714f, -0.29459772f, 0.04137818f, -0.05865371f, 0.01401274f, -0.02884139f, 
    -0.32800785f, 0.35790712f, -0.14725871f, -0.25123891f, -0.03894841f, -0.09765740f, 0.06688052f, -0.00971654f, 
    0.04688270f, -0.18026310f, -0.17829850f, -0.30697620f, -0.37183127f, 0.12533183f, -0.00137534f, -0.42025647f, 
    0.15334438f, -0.03035311f, -0.07682751f, 0.10517117f, -0.02929791f, 0.06038642f, 0.02594899f, -0.07910856f, 
    -0.17664713f, -0.04556631f, 0.19999199f, -0.02094665f, 0.07568150f, -0.18455328f, -0.10245729f, 0.02565579f, 
    0.17876580f, -0.15073888f, 0.02138915f, -0.12407400f, -0.00953657f, -0.29077908f, 0.10165902f, -0.16366434f, 
    -0.11330050f, -0.19348696f, -0.04247644f, 0.01319537f, 0.17032476f, -0.00601866f, 0.19412945f, 0.01983890f, 
    -0.25699973f, -0.38255873f, 0.15376715f, 0.21552423f, 0.01799658f, -0.03133561f, -0.02463993f, 0.09275599f, 
    0.07615423f, -0.25423077f, -0.19513109f, -0.28079498f, -0.04047371f, -0.16045287f, -0.21295059f, 0.21982965f, 
    -0.12459910f, 0.05780317f, 0.09938664f, 0.02034022f, -0.02128505f, 0.04825208f, 0.06880005f, -0.03913234f, 
    -0.05866503f, 0.14344455f, -0.33433160f, -0.11636956f, 0.13326596f, 0.10635128f, -0.09551206f, -0.04413725f, 
    0.04306232f, 0.02780153f, -0.04845999f, -0.01656631f, 0.18833962f, 0.03380937f, 0.08616830f, 0.11946622f, 
    0.18536162f, -0.05135074f, 0.02269131f, 0.20401663f, 0.09666216f, 0.10205655f, 0.15219927f, 0.08303839f, 
    -0.09237186f, 0.01999172f, -0.21756841f, -0.29187909f, 0.01692673f, -0.05297771f, 0.07667803f, 0.13023537f, 
    0.08113693f, -0.09127459f, -0.03274838f, -0.11178224f, -0.12481134f, -0.10612951f, -0.32207808f, 0.36788312f, 
    0.09742521f, -0.07671589f, -0.06607393f, 0.01140267f, 0.02317851f, -0.03820428f, 0.05068996f, 0.11237653f, 
    0.10767035f, -0.06740882f, -0.23142704f, -0.08554779f, -0.04919170f, 0.07752291f, 0.00349015f, -0.01097316f, 
    -0.07744522f, -0.09749475f, -0.14512512f, -0.15335104f, -0.02807945f, 0.03111705f, 0.18918099f, -0.18088812f, 
    0.09539641f, -0.02643982f, -0.02279451f, -0.00162901f, -0.01163676f, 0.09758962f, -0.10597410f, 0.00322030f, 
    0.35662550f, 0.15076290f, 0.25281924f, -0.06576432f, 0.00118529f, -0.07678611f, 0.03392120f, 0.01821345f, 
    0.02777741f, 0.04543331f, 0.32712764f, 0.34357914f, -0.70803970f, -0.63977498f, -0.25144175f, -0.05156780f, 
    -0.22770135f, -0.18576333f, 0.31684646f, -0.07114384f, 0.04928134f, 0.01528267f, 0.04545074f, -0.11673279f, 
    -0.14545250f, 0.35793576f, -0.34160569f, 0.44446826f, 0.03589927f, -0.11855163f, 0.11701220f, 0.09134545f, 
    0.09048165f, 0.10909612f, 0.11029216f, 0.00363465f, 0.17282587f, -0.16665620f, 0.39396805f, 0.17296559f, 
    0.05613521f, 0.03846154f, -0.01103010f, 0.03318920f, 0.08859465f, -0.12888479f, 0.25834262f, 0.10147659f, 
    -0.43624502f, 0.21110445f, 0.31242821f, -0.63502878f, -0.07002255f, 0.09087440f, 0.07099101f, -0.02870707f, 
    0.01812388f, 0.01237603f, 0.01542924f, 0.08674041f, 0.18055908f, -0.10738803f, -0.03872416f, 0.14616966f, 
    -0.00945528f, 0.07143815f, -0.03533018f, 0.08931816f, 0.10024491f, 0.18246125f, -0.21739992f, -0.09254590f, 
    0.20193847f, -0.65959930f, -0.45586601f, -0.15222891f, -0.16242634f, 0.16729008f, 0.12469894f, 0.19694653f, 
    -0.00640264f, -0.04221708f, 0.01518596f, 0.14718230f, -0.42472619f, -0.54858357f, -0.02782257f, -0.25170654f, 
    0.05114928f, -0.00963177f, -0.09695018f, -0.02805098f, 0.01144740f, 0.17582096f, 0.24612473f, 0.01004594f, 
    -0.21259664f, 0.02092902f, 0.49913538f, 0.11718322f, -0.16421801f, -0.41061857f, 0.09681379f, -0.05740296f, 
    -0.15679978f, 0.09427434f, 0.09639370f, -0.06346391f, -0.59470922f, -0.05018834f, 0.40796927f, 0.12975045f, 
    0.03708856f, -0.34442136f, 0.07285118f, 0.29330137f, -0.04489356f, 0.11459475f, 0.02729489f, 0.04390484f, 
    0.01925776f, 0.12640895f, -0.33314586f, -0.19302271f, -0.00270150f, -0.07472488f, -0.00540968f, 0.19349380f, 
    -0.03459042f, 0.04831487f, -0.01829688f, -0.12565950f, -0.00721767f, -0.63049370f, 0.10897221f, -0.05247199f, 
    0.25748330f, 0.23394525f, 0.10872528f, -0.43982983f, -0.01730385f, 0.00196651f, -0.05114205f, 0.06188479f, 
    -0.17172596f, 0.02193658f, 0.24139374f, -0.00208128f, 0.04279091f, 0.11174405f, -0.10317791f, -0.08455101f, 
    -0.06090199f, -0.13401267f, -0.09681714f, 0.04573468f, 0.19977964f, -0.06449454f, -0.18464239f, -0.11846828f, 
    -0.12657841f, 0.04253343f, 0.15609355f, 0.03760855f, -0.13644080f, 0.04848237f, -0.15762800f, -0.12119462f, 
    -0.17989653f, 0.09660827f, 0.04313473f, 0.06595051f, -0.11305228f, -0.46015087f, -0.19652107f, -0.00601160f, 
    -0.08687664f, -0.03736357f, -0.16003294f, -0.07163339f, -0.63479257f, -0.63059193f, -0.61030024f, -0.04850790f, 
    -0.06511238f, 0.01167626f, -0.02024330f, -0.30523974f, -0.06017820f, -0.02159641f, -0.04203025f, -0.02558773f, 
    -0.29627112f, 0.25371793f, 0.29122901f, 0.21162327f, 0.01580722f, -0.14441098f, -0.11579750f, 0.14953366f, 
    0.00131840f, 0.08796280f, -0.14623165f, 0.27834904f, -1.17148924f, -1.01004767f, -0.56737334f, 0.51330864f, 
    -0.37798423f, 0.22273576f, -0.39634460f, -0.44351527f, 0.03996496f, -0.06346989f, 0.01534893f, 0.07562742f, 
    0.13001312f, -0.25575626f, -0.17058335f, 0.00200837f, 0.01498331f, 0.10066584f, 0.22889647f, -0.06351618f, 
    -0.02501659f, -0.05353295f, -0.11751316f, -0.01343945f, -0.89457768f, -0.74308437f, 0.14216898f, -0.00032512f, 
    -0.07534453f, -0.09509604f, -0.40022701f, -0.35762006f, -0.08214671f, 0.09567969f, -0.05603463f, 0.01948466f, 
    -0.23760059f, 0.05617294f, -0.03175215f, 0.15128163f, -0.13125829f, 0.04561256f, 0.06066669f, -0.02963777f, 
    0.01694383f, 0.03540343f, 0.14541669f, 0.14373063f, -0.45956168f, -0.63053036f, 0.20794523f, -0.04870462f, 
    -0.02219993f, -0.04513291f, 0.06636532f, -0.25271297f, -0.05711787f, 0.11189973f, 0.03261549f, 0.09131777f, 
    -0.07831270f, -0.12851965f, -0.09059368f, 0.14761832f, 0.04182981f, 0.01691544f, 0.04438475f, 0.16021045f, 
    0.20853353f, 0.04988410f, 0.07721380f, -0.10978255f, 0.07309774f, 0.27730891f, 0.10556503f, 0.23955910f, 
    0.08811628f, -0.09523928f, -0.10963302f, 0.19671680f, -0.02465783f, 0.07516520f, 0.09557653f, 0.00491307f, 
    0.08678591f, -0.01768108f, -0.00849585f, 0.04962371f, -0.04266685f, 0.07869553f, -0.04718604f, 0.11268550f, 
    0.19647917f, 0.20432423f, 0.07774298f, 0.08971020f, 0.26084596f, -0.51760238f, -0.20932260f, -0.15227012f, 
    -0.03243214f, 0.22135463f, 0.33611631f, -0.23430707f, 0.03807377f, -0.03083800f, -0.01768008f, 0.03113617f, 
    -0.28429711f, -0.14502627f, 0.04644910f, -0.43206480f, 0.08543313f, -0.04460368f, 0.03266558f, -0.03735591f, 
    -0.06764475f, 0.07508308f, 0.03495190f, -0.10969811f, -0.69547015f, -0.80594844f, -0.26389876f, -0.18026352f, 
    -0.00773610f, -0.06703414f, -0.00772021f, -0.36784813f, 0.01095787f, -0.13392991f, 0.06024621f, -0.03254629f, 
    0.52472353f, 0.44971099f, -0.13384029f, -0.04661866f, 0.02689859f, -0.05202090f, 0.08521666f, 0.15020642f, 
    0.04380709f, -0.04970676f, 0.12195642f, -0.01319234f, 0.01229406f, -0.02451216f, -0.39341727f, -0.37827709f, 
    -0.04516111f, 0.07889858f, 0.14927514f, -0.03666106f, -0.03478688f, 0.06412656f, 0.00720302f, -0.00815061f, 
    -0.00902052f, 0.06740981f, -0.02021939f, -0.08280028f, -0.07336100f, -0.01197539f, -0.04849096f, 0.03011589f, 
    0.08926698f, -0.02385794f, 0.07048780f, -0.01617568f, -0.34567851f, 0.27202579f, 0.13411748f, 0.13220344f, 
    0.02509256f, -0.10817505f, 0.10302965f, -0.15458925f, -0.05402365f, -0.00593950f, 0.08869192f, -0.08010292f, 
    0.12869358f, 0.66320741f, 0.02259117f, 0.27853090f, -0.04251512f, 0.12710115f, -0.05216720f, 0.04324715f, 
    0.04667611f, 0.17602322f, -0.02951215f, 0.01156655f, -0.40279490f, -0.32030946f, -0.58068687f, 0.02116544f, 
    0.15172823f, -0.09616455f, 0.12556425f, -0.05130830f, -0.04558381f, -0.01116236f, -0.11714426f, 0.01092745f, 
    -0.46279943f, -0.33777863f, -0.37839094f, 0.01306081f, -0.05863297f, -0.01967896f, 0.19110043f, 0.01487281f, 
    -0.04965516f, 0.24569160f, -0.01344500f, -0.05282660f, 0.29947472f, -0.04972038f, -0.05954147f, -0.23292840f, 
    -0.02679442f, -0.03734437f, -0.07686898f, -0.03276316f, -0.15012564f, 0.03152234f, -0.01824226f, -0.35862979f, 
    -0.07147408f, 0.38422182f, 0.03757482f, 0.16626668f, -0.08766323f, 0.06117936f, -0.11237666f, -0.07054828f, 
    -0.04235959f, 0.05351022f, -0.02927364f, -0.02455418f, 0.17881158f, -0.00825552f, 0.30078104f, -0.36187425f, 
    0.08070361f, 0.02028041f, -0.11053425f, -0.00083342f, 0.01594771f, -0.06579597f, 0.01811595f, -0.06586958f, 
    -0.43974987f, -0.14417955f, 0.04511505f, 0.43142998f, -0.00991675f, 0.16740483f, 0.11048366f, -0.10142066f, 
    0.00682636f, -0.06531426f, 0.01926266f, -0.01595549f, -0.01641630f, -0.30691928f, 0.37498239f, 0.02752699f, 
    -0.15464456f, -0.17900653f, -0.13230048f, -0.08834977f, -0.03341088f, -0.09794740f, 0.11558540f, -0.25011274f, 
    0.46913278f, 0.02021326f, -0.21764892f, -0.16848049f, -0.25474852f, 0.03613865f, -0.09516279f, 0.01381265f, 
    -0.14361857f, 0.05804081f, -0.24831270f, -0.04430154f, 0.96313286f, -0.70618671f, 0.21353751f, -0.51001054f, 
    -0.30037299f, 0.19630940f, -0.38323656f, 0.15810224f, 0.14518003f, 0.08700370f, -0.01717694f, -0.03375783f, 
    -0.17868334f, -0.02560397f, -0.23178686f, 0.08817354f, 0.03830334f, 0.03569475f, 0.01870662f, -0.03122203f, 
    0.01657143f, 0.00245975f, -0.18342303f, -0.12485252f, -0.37166390f, 0.35635555f, 0.10438878f, 0.01819563f, 
    0.09840068f, -0.17357738f, -0.00158037f, 0.15292522f, 0.04739445f, 0.11823446f, 0.09406313f, 0.02176990f, 
    -0.04988094f, 0.09791934f, -0.01104819f, -0.01148789f, 0.02698058f, 0.04653366f, -0.04200280f, -0.02677928f, 
    -0.06895834f, -0.03067638f, -0.06835840f, -0.17431282f, -0.02549617f, -0.01837740f, -0.00218386f, -0.00712860f, 
    -0.06757402f, -0.03834234f, -0.05291500f, -0.05943660f, -0.01163595f, 0.02340328f, 0.04642303f, 0.01791362f, 
    0.16097406f, 0.08277475f, -0.07168619f, -0.07337582f, -0.14243287f, -0.30847687f, 0.20496088f, 0.08948616f, 
    0.04864534f, 0.00211903f, 0.06362578f, 0.08137500f, -0.77927101f, -0.07973804f, 0.10830042f, 0.29869822f, 
    0.05527809f, 0.00621019f, -0.04109916f, 0.02299138f, 0.05899749f, -0.04795110f, 0.02045828f, -0.04846740f, 
    0.33514059f, 0.04702958f, 0.02589145f, -0.49419668f, -0.00074945f, 0.24549340f, 0.04879731f, -0.02236646f, 
    -0.15876605f, -0.00726147f, -0.04226797f, -0.15331215f, -0.19952229f, -0.62382883f, 0.42196882f, 0.09157322f, 
    0.14127016f, 0.31094524f, 0.21361203f, 0.18930766f, 0.01048942f, -0.02243628f, -0.01957091f, 0.01439821f, 
    -0.12565386f, 0.03643615f, -0.10692490f, -0.01149887f, -0.01143864f, -0.13134664f, -0.02820594f, 0.00109875f, 
    0.03778418f, 0.00327825f, 0.03203424f, -0.01273573f, -0.19638656f, -0.58461553f, -0.07298626f, -0.10674877f, 
    0.00907665f, -0.03991788f, -0.00384790f, 0.10918011f, 0.04613073f, 0.01980969f, 0.08389129f, -0.01339193f, 
    0.21320988f, -0.77590603f, -1.00309849f, -0.11002415f, 0.04535547f, -0.18856739f, -0.09443680f, 0.00106287f, 
    0.25430146f, 0.02898515f, 0.04999558f, 0.13078842f, -0.10080711f, -0.72811413f, -0.02596840f, -0.76364487f, 
    0.00787018f, -0.08738428f, 0.08208108f, 0.29129133f, -0.01959419f, -0.00578989f, 0.02946156f, 0.02027829f, 
    0.30231869f, -0.08199562f, 0.11124874f, -0.20286559f, -0.03722888f, 0.03806458f, -0.06593111f, -0.07164143f, 
    -0.11495591f, 0.07386696f, -0.23982863f, -0.31642306f, 0.37511054f, -0.51908630f, -0.12624750f, -0.21662034f, 
    0.04473341f, -0.11146494f, 0.03854150f, 0.00847815f, -0.00552829f, -0.10328079f, 0.10406149f, -0.03251958f, 
    0.29054374f, -0.17202915f, 0.17922106f, -0.12679285f, -0.02009458f, 0.00745336f, -0.01090649f, -0.01284901f, 
    0.15423976f, -0.00887015f, -0.13950215f, -0.05682361f, -0.20960295f, 0.36339700f, -0.43836814f, -0.02161550f, 
    -0.01411676f, -0.06157548f, 0.03827909f, -0.03403993f, 0.05176738f, 0.01469877f, 0.04179622f, 0.03722528f, 
    -0.31436807f, 0.28042644f, -0.25188071f, 0.23119161f, 0.04367675f, -0.02153331f, 0.08893776f, -0.03436734f, 
    0.05171908f, 0.03508523f, -0.04088282f, -0.02610957f, -0.89538902f, 0.28615031f, -0.42248100f, 0.49708930f, 
    0.14609998f, 0.04060499f, 0.00381632f, -0.11547358f, 0.04488952f, -0.01410954f, -0.08927989f, -0.05699142f, 
    -0.26487523f, -0.05958869f, -0.08765795f, -0.02438440f, -0.12842341f, -0.01567423f, 0.02979985f, -0.06374215f, 
    -0.17676866f, -0.00846315f, 0.08427989f, 0.08886050f, -0.14265493f, -0.01589425f, -0.10936697f, -0.06438788f, 
    0.12263279f, 0.07253163f, -0.06327871f, -0.04790219f, -0.00692694f, 0.14779459f, 0.01001982f, 0.08339533f, 
    -0.38019529f, 0.25628448f, -0.00638247f, -0.20431933f, -0.06645647f, -0.04742721f, -0.09651338f, -0.02376845f, 
    -0.22097471f, -0.00610753f, -0.06340927f, 0.02492052f, -0.21156928f, -0.05442363f, 0.03101487f, 0.28230003f, 
    -0.25534734f, 0.14670002f, -0.02157373f, 0.03352369f, 0.11784902f, 0.34768164f, -0.11641958f, 0.11566362f, 
    -0.64699733f, -0.27977797f, 0.12758473f, 0.35144529f, 0.03225598f, -0.05073202f, -0.14707752f, 0.05623368f, 
    0.17366049f, 0.00549469f, -0.10273857f, -0.29471660f, -0.04661766f, -0.37015784f, -0.12449379f, -0.02970031f, 
    -0.06267315f, 0.14923139f, 0.15402454f, -0.03423802f, -0.04806461f, -0.06024205f, -0.03608724f, 0.00677054f, 
    -0.14323969f, -0.17783162f, 0.07574327f, 0.32836008f, 0.02744880f, 0.11967736f, 0.00532647f, -0.19197425f, 
    0.23550090f, 0.17512219f, 0.03636273f, 0.34450072f, -0.06396525f, 0.02063644f, -0.14902498f, -0.04694096f, 
    -0.17664093f, 0.01382261f, 0.05153842f, -0.00719119f, 0.21214053f, 0.10064268f, 0.15008308f, -0.01164076f, 
    0.15429850f, 0.32343975f, 0.01683878f, -0.05756023f, 0.11230223f, -0.12689452f, -0.07573585f, 0.06967022f, 
    0.01329154f, 0.06451214f, 0.07815614f, 0.23101050f, 0.07473450f, 0.10236474f, 0.12687643f, 0.20828341f, 
    0.06813292f, -0.11586314f, -0.02171905f, 0.04590848f, 0.01496577f, 0.21209599f, 0.05970404f, 0.22719465f, 
    0.45037341f, 0.06260745f, 0.06147100f, -0.30233246f, 0.41346610f, 0.07428381f, -0.04174373f, 0.15587938f, 
    -0.13548191f, -0.07854655f, -0.07542590f, -0.12449697f, 0.08078268f, -0.20593072f, -0.12531395f, -0.57173628f, 
    -0.00391822f, 0.04703914f, 0.10949063f, 0.08001454f, 0.06045759f, 0.13706303f, 0.15767424f, -0.23700379f, 
    0.36975145f, 0.08392015f, -0.19058350f, -0.39114356f, -0.20024048f, -0.07550415f, 0.11813997f, 0.02046074f, 
    0.22437020f, 0.06253857f, 0.27862474f, -0.00760352f, -0.20054257f, -0.23623797f, -0.72133017f, -0.11722303f, 
    0.20244230f, -0.05940831f, 0.19083284f, -0.02138076f, -0.07537170f, 0.01473884f, -0.20730294f, -0.20403095f, 
    0.00818126f, 0.06350703f, -0.10047887f, 0.14472854f, 0.13691431f, -0.00966798f, 0.01566519f, -0.11644132f, 
    0.30153143f, 0.03146513f, 0.01573370f, 0.30326036f, -0.30964318f, 0.13108885f, -0.01618136f, 0.22946455f, 
    -0.33874655f, 0.02943281f, -0.16565801f, -0.14187965f, -0.09672337f, 0.01097758f, -0.17769815f, -0.00538235f, 
    -0.26138827f, -0.02708017f, -0.00152798f, -0.16872540f, -0.11619605f, 0.09071995f, 0.13488133f, -0.02834105f, 
    -0.03260770f, 0.12161221f, 0.02391508f, 0.11103714f, -0.05966084f, 0.13050395f, -0.09727717f, -0.01919873f, 
    0.01955662f, -0.08154513f, 0.00680507f, -0.06474116f, -0.05133319f, -0.03464987f, 0.00277489f, 0.08145227f, 
    -0.07895933f, -0.03420195f, -0.07474884f, 0.00625611f, 0.02653067f, 0.10555880f, 0.11213137f, 0.04430930f, 
    0.00903816f, 0.08123461f, 0.23164195f, 0.14469500f, 0.21522921f, 0.03722794f, -0.27407718f, -0.03602294f, 
    -0.10685048f, 0.10375094f, -0.05538553f, 0.08054978f, 0.08242918f, 0.17124280f, 0.05281891f, 0.08959452f, 
    0.19942386f, 0.10240571f, -0.29392508f, 0.03292319f, -0.02858710f, -0.16734618f, 0.19194651f, -0.03995488f, 
    0.21476585f, -0.00600005f, 0.14144945f, 0.09241027f, 0.52953005f, -0.54311955f, -0.67012364f, -0.17743154f, 
    -0.17294344f, -0.17877913f, 0.03913732f, -0.00999002f, -0.01671864f, -0.08410694f, -0.09782608f, -0.04893330f, 
    -0.04869261f, 0.10451000f, 0.12278534f, -0.03776633f, -0.04294986f, -0.17582133f, -0.03577910f, -0.11474319f, 
    0.00727190f, 0.03621068f, 0.03847906f, 0.10942674f, -0.60382295f, -0.96758139f, -0.78769273f, -0.38965768f, 
    -0.18980484f, -0.01630390f, -0.02362597f, 0.16400333f, -0.10343746f, 0.10777724f, 0.03169707f, -0.00288770f, 
    -0.20209508f, -0.13325453f, -0.17831837f, 0.15057553f, 0.06366790f, 0.12774242f, 0.09302872f, 0.10540692f, 
    -0.13961442f, 0.00349544f, -0.18604310f, -0.56158096f, 0.08614116f, -0.41370031f, -0.60943717f, 0.09542228f, 
    0.06516693f, 0.28673318f, 0.29674026f, -0.06878754f, -0.04501497f, -0.21046554f, -0.02051088f, -0.00483453f, 
    0.31884429f, 0.04632349f, -0.21916382f, -0.36636636f, -0.13059276f, 0.02657692f, -0.00286378f, -0.16839652f, 
    -0.09026298f, 0.10620540f, 0.02308951f, 0.05599947f, -0.20259368f, -0.33005792f, -0.26589194f, -0.07575735f, 
    0.23359285f, 0.25337899f, 0.03149619f, 0.06444002f, -0.00002733f, 0.02595814f, 0.17225091f, 0.04086317f, 
    0.15100488f, 0.18356216f, -0.21746026f, -0.29502782f, 0.12131552f, -0.13535583f, -0.08852533f, -0.01671874f, 
    -0.21732995f, 0.15426917f, -0.16348846f, -0.02766434f, -0.66464984f, 0.09402266f, 0.11183893f, 0.21541007f, 
    0.12079698f, -0.08933258f, -0.24768126f, -0.18895268f, -0.13600849f, -0.08151465f, -0.02262981f, -0.08007015f, 
    -0.72320467f, 0.13185531f, 0.30180678f, 0.05470959f, -0.14330602f, -0.17832240f, -0.12909967f, -0.06076694f, 
    -0.12360394f, -0.04387815f, 0.08858626f, 0.15912624f, -0.36456576f, -0.22634274f, -0.25294656f, 0.30403811f, 
    0.08296462f, -0.07417076f, -0.47395241f, 0.06221529f, 0.15239514f, 0.03440296f, 0.14133956f, 0.15725240f, 
    -0.44769022f, -0.20903230f, 0.19995955f, 0.27087313f, -0.02740142f, 0.16390523f, 0.06938101f, 0.19749483f, 
    -0.12429864f, -0.08420889f, 0.00536650f, 0.02330926f, 0.06966536f, 0.44515181f, 0.15871471f, 0.06466896f, 
    -0.07044181f, -0.12007011f, -0.03457406f, -0.04696054f, -0.09602147f, 0.00495182f, -0.17852144f, -0.05658188f, 
    -0.11892823f, -0.01706049f, -0.02255263f, 0.01732293f, 0.15393181f, 0.22842993f, 0.21933381f, 0.02508870f, 
    0.17986329f, 0.04804635f, 0.00307164f, 0.01616344f, 0.02305231f, -0.03891292f, 0.08039562f, -0.29799014f, 
    0.08194934f, -0.06167482f, 0.02700547f, 0.17407209f, 0.01619810f, 0.02130178f, 0.00411937f, -0.10153913f, 
    0.02122101f, -0.01864753f, -0.13664025f, -0.24460654f, -0.07794563f, 0.03025772f, 0.04260188f, 0.14891419f, 
    0.07227962f, 0.23502299f, 0.00599829f, 0.16313961f, -0.04007239f, 0.19709228f, 0.23471937f, -0.13317662f, 
    0.06187234f, -0.23335889f, 0.03932825f, 0.21980782f, 0.02048056f, 0.06896026f, 0.07103244f, 0.06337050f, 
    0.21294242f, 0.07446545f, 0.93151820f, -1.10362995f, 0.05000521f, -0.26957232f, -0.20865491f, -0.17728086f, 
    -0.34710974f, 0.13065805f, 0.00730481f, -0.10150018f, -0.22393034f, 0.04808543f, 0.06012598f, 0.29402089f, 
    -0.05449951f, 0.13765626f, -0.28672659f, -0.19016446f, -0.06848532f, -0.06147421f, -0.05512458f, -0.13753253f, 
    -0.72563046f, -0.23976249f, -0.81554550f, 0.35575074f, 0.02595112f, -0.01900892f, 0.02563258f, -0.05285866f, 
    0.00279609f, -0.02020319f, -0.20582101f, -0.04397342f, 0.06677690f, -0.69519979f, 0.00437944f, 0.01364743f, 
    0.00266333f, 0.04397842f, 0.12141342f, -0.19479254f, 0.03538621f, -0.18976127f, -0.04582427f, 0.10659362f, 
    0.27704296f, 0.24145983f, -0.61011159f, 0.09834640f, -0.05104100f, -0.01997109f, 0.08907455f, -0.00495290f, 
    0.13103448f, -0.13002080f, 0.01329665f, 0.02195329f, -0.13963242f, -0.42070192f, 0.12850550f, -0.00850677f, 
    0.08245671f, 0.12741163f, 0.04904186f, -0.08999328f, 0.02065105f, 0.19910423f, 0.02770673f, -0.03398997f, 
    -0.54736054f, 0.01151821f, 0.27251866f, 0.44195762f, 0.31585172f, -0.13760339f, -0.08507342f, 0.06321842f, 
    0.07521663f, -0.04448023f, -0.12765306f, 0.03769039f, 0.34104887f, -0.10240417f, 0.04783592f, -0.27419248f, 
    -0.30390653f, -0.08220574f, 0.02842945f, -0.36237121f, 0.20679745f, 0.08000269f, -0.06948508f, 0.05953671f, 
    -0.37138137f, 0.07607940f, 0.12118848f, 0.12782839f, 0.26431113f, -0.20062973f, 0.12247820f, -0.18127607f, 
    0.00037838f, -0.14103875f, -0.02734468f, -0.23055653f, -0.48680565f, 0.00461103f, -0.08057559f, -0.12890817f, 
    0.07240853f, 0.06683397f, 0.01766401f, 0.25868130f, 0.03061764f, 0.04493486f, -0.15967715f, -0.09124613f, 
    0.05538703f, -0.22011907f, 0.13770168f, -0.00083860f, 0.12654880f, -0.03361378f, -0.15793097f, 0.18422408f, 
    0.24863039f, -0.05188863f, -0.25500363f, 0.06249571f, -0.34296310f, -0.08909220f, -0.42747521f, 0.21403930f, 
    0.20604654f, 0.18945177f, 0.22201727f, 0.08727796f, 0.11938704f, -0.08643107f, 0.01855359f, 0.11241218f, 
    0.18220168f, 0.14110912f, 0.05889226f, -0.16461402f, 0.17291902f, -0.05207787f, 0.19008501f, 0.06900102f, 
    -0.02338590f, -0.24965101f, -0.08395644f, 0.07018141f, 0.21435425f, 0.10024585f, -0.44444928f, -0.17449301f, 
    0.02396365f, -0.00013338f, 0.14865746f, 0.18821901f, -0.06562335f, 0.00735342f, -0.01771070f, -0.13318856f, 
    -0.12517549f, -0.36271501f, 0.22984284f, -0.12615539f, 0.25926495f, -0.18783602f, -0.00422101f, 0.01938434f, 
    -0.08798867f, -0.14381047f, -0.09705763f, 0.29093277f, -0.08975752f, -0.05412690f, 0.10660402f, 0.21824555f, 
    0.14427640f, -0.01677535f, 0.06025187f, 0.21917053f, -0.00780763f, 0.03176995f, 0.03350293f, 0.03863562f, 
    0.07803237f, 0.31683171f, -0.57603461f, 0.04678288f, 0.14274485f, 0.13077196f, 0.25741076f, 0.02191532f, 
    0.08569367f, -0.10649431f, -0.11845098f, -0.19653273f, -0.29852632f, 0.24862491f, 0.30472523f, -0.50163871f, 
    -0.24996413f, 0.00158514f, 0.01123668f, 0.18232191f, 0.02765835f, 0.07587431f, 0.05228354f, 0.05716401f, 
    -0.18685955f, -0.05155470f, 0.30387488f, 0.32130483f, 0.04835868f, -0.10802129f, -0.19595861f, -0.16057099f, 
    -0.03754032f, 0.03250566f, 0.11118240f, 0.13472743f, -0.26222658f, -0.20858575f, -0.46460664f, -0.20905064f, 
    -0.28860298f, 0.12387419f, -0.24401060f, 0.21705365f, 0.24469499f, -0.00648044f, 0.06729177f, 0.04460935f, 
    -0.09029520f, -0.33002636f, 0.26832119f, 0.28985068f, 0.07542168f, 0.21624455f, -0.17666897f, -0.31918231f, 
    -0.09841903f, -0.07595138f, 0.07752000f, -0.21410526f, 0.20193645f, 0.28314334f, 0.33511084f, -0.05936682f, 
    0.01297299f, -0.29726800f, 0.00199319f, -0.17094360f, 0.04831457f, 0.01717655f, -0.12192362f, 0.00575214f, 
    0.03595743f, -0.19444121f, 0.09647235f, 0.31879488f, -0.04403513f, 0.16067988f, 0.01488100f, -0.21579070f, 
    0.00566527f, 0.01746590f, 0.22635205f, 0.04911152f, -0.14064787f, 0.46640494f, -0.77356815f, -0.00456576f, 
    0.11443118f, 0.03705427f, 0.12234864f, 0.12588367f, -0.11116754f, -0.06380238f, -0.08093858f, 0.09927327f, 
    -0.46082228f, -0.04573151f, 0.03623797f, -0.23573521f, 0.13932911f, -0.23024206f, 0.16022456f, -0.03660712f, 
    0.08361177f, -0.02620649f, 0.03585012f, -0.01597187f, -0.55464870f, -0.24262761f, -0.50403285f, -0.36380076f, 
    -0.01411030f, -0.20090966f, 0.09099068f, 0.00418928f, -0.02190170f, -0.00433310f, -0.14074937f, -0.02304345f, 
    -0.01955262f, 0.16340302f, 0.66091865f, -0.65975040f, 0.01497855f, -0.17391843f, -0.08638273f, -0.01723268f, 
    -0.06601203f, 0.04930552f, 0.11700936f, 0.02527261f, -0.42272425f, -0.11881869f, -0.76415265f, 0.20973220f, 
    0.14677018f, 0.05296204f, 0.22454718f, -0.07706999f, 0.05236202f, -0.02944571f, -0.20527361f, -0.00773807f, 
    -0.08628581f, -0.52191287f, -0.55260932f, -0.53325021f, -0.41340330f, -0.26969892f, 0.04760083f, -0.16329414f, 
    -0.05802998f, 0.12247228f, -0.22654943f, -0.21640728f, 0.11021092f, -0.10520375f, 0.08110839f, 0.19592538f, 
    -0.02508652f, 0.01698419f, -0.06406568f, 0.19117303f, -0.02761177f, -0.10063539f, 0.15267253f, 0.09296153f, 
    0.06646689f, -0.07141182f, 0.33397412f, 0.49354160f, 0.07435220f, 0.10316448f, -0.27992031f, 0.06066596f, 
    -0.09043425f, -0.23215550f, -0.54277557f, -0.22770311f, -0.14352043f, -0.03909488f, 0.22712448f, 0.24052225f, 
    0.10283625f, 0.07740241f, -0.02530874f, 0.04873011f, 0.04858132f, -0.02826786f, -0.05380276f, 0.05936771f, 
    -0.33300290f, 0.23694205f, 0.09890476f, 0.02454691f, -0.11503967f, -0.00055514f, -0.01623278f, 0.23206426f, 
    0.00054883f, -0.15581827f, 0.06034247f, -0.01852171f, 0.17923333f, 0.05646790f, 0.46873218f, -0.08866081f, 
    0.03819465f, -0.10691082f, 0.12761113f, 0.01650889f, -0.19095118f, -0.00934024f, 0.04229473f, 0.00073759f, 
    0.17579874f, 0.73014021f, 0.01380682f, -0.06090350f, -0.32729924f, 0.10272585f, 0.11573878f, 0.06888964f, 
    0.01535683f, 0.25490525f, -0.21361586f, 0.08843192f, -0.07036775f, 0.37034419f, -0.43297049f, 0.29015616f, 
    -0.07428770f, 0.18542559f, 0.09781686f, -0.12470705f, 0.02980314f, 0.14836885f, 0.06864823f, 0.26533988f, 
    -0.30926079f, 0.01113459f, 0.09061542f, 0.02596129f, -0.01158947f, -0.09414210f, 0.07760672f, 0.03720482f, 
    -0.14117143f, -0.07957318f, -0.22856918f, 0.01907218f, -0.17232156f, 0.05484411f, -0.40742809f, 0.36318395f, 
    0.13708735f, 0.04125527f, 0.02701595f, 0.02336212f, 0.08046841f, -0.00813950f, -0.21340747f, -0.18924721f, 
    -0.31736812f, 0.46531793f, 0.16872858f, 0.10120406f, -0.12944102f, 0.04760674f, -0.16694196f, -0.00560023f, 
    0.10878608f, -0.06541438f, 0.06440209f, 0.10618459f, 0.25462270f, 0.16398191f, -0.50901115f, 0.28039351f, 
    0.08022884f, 0.03634925f, 0.15185532f, -0.15101685f, -0.28335053f, 0.05444847f, 0.26000589f, -0.05690163f, 
    -0.38816476f, 0.12201893f, 0.08778856f, 0.07030541f, -0.12595755f, -0.03592199f, -0.12542583f, 0.46033975f, 
    -0.00839568f, -0.19483460f, 0.14514063f, 0.08994861f, -0.03850118f, -0.17942305f, 0.05676697f, 0.12346169f, 
    -0.00778227f, 0.01306682f, 0.19869348f, -0.04011060f, -0.10383055f, -0.03056024f, 0.10961214f, -0.09232905f, 
    -0.26905933f, 0.39238349f, 0.45448834f, -0.19740042f, -0.13383371f, 0.02313270f, 0.03349229f, 0.14750209f, 
    0.06247806f, -0.01369563f, 0.10289164f, -0.03458714f, -0.00574238f, -0.09483135f, -0.13426635f, -0.35218516f, 
    -0.22860886f, -0.06761899f, -0.04963681f, -0.09201700f, -0.21342725f, 0.12487961f, 0.05369319f, 0.08432813f, 
    0.10868850f, 0.29918569f, 0.41474748f, -0.02086160f, -0.24291018f, 0.06980792f, 0.07537584f, -0.01413357f, 
    0.12636475f, 0.36241049f, 0.36331925f, 0.10557013f, -0.32339430f, -0.66243267f, 0.20589656f, 0.12334435f, 
    -0.00250948f, 0.01354146f, 0.05024564f, -0.16787176f, 0.07558654f, 0.18120766f, -0.03878872f, 0.01508582f, 
    -0.69545954f, 0.40311983f, 0.20954126f, -0.08636512f, -0.05479384f, -0.02721361f, 0.06624080f, -0.10908905f, 
    0.02126500f, 0.05679427f, 0.06825878f, 0.02986199f, -0.57186991f, 0.06291077f, -0.80956149f, -0.11774320f, 
    0.02830319f, -0.15238841f, -0.11060978f, 0.18526311f, -0.11258205f, 0.13574995f, -0.20776010f, -0.02420338f, 
    -0.29345694f, -0.33043340f, 0.17757326f, -0.18871744f, 0.02089991f, 0.05633186f, 0.07261055f, -0.08728468f, 
    -0.04426721f, 0.20206267f, 0.23495629f, -0.07756498f, -0.18361686f, 0.07407870f, -0.21868175f, 0.02444140f, 
    0.00948830f, -0.17388870f, 0.07231382f, 0.06162587f, 0.03108015f, 0.12890227f, 0.07904172f, -0.02417780f, 
    0.57834578f, -0.22779505f, 0.05358094f, -0.28570729f, -0.02505157f, -0.16978125f, 0.00282434f, 0.02656078f, 
    -0.14964481f, 0.00822992f, -0.48974875f, -0.58676618f, -0.26100719f, -0.20497756f, -0.10209953f, 0.11914257f, 
    0.08164378f, 0.08300432f, -0.17024067f, -0.13983299f, -0.08576353f, 0.08803262f, 0.08755372f, -0.25864398f, 
    -0.79005772f, 0.28777206f, 0.14215754f, -0.34192047f, 0.03405165f, 0.25386530f, 0.01080704f, 0.07063460f, 
    -0.00307572f, 0.03764005f, -0.09392093f, -0.13613552f, -0.32463866f, 0.19960503f, 0.14511633f, -0.17340232f, 
    -0.00605867f, 0.00539447f, 0.11119607f, -0.05267800f, -0.00548275f, -0.15968610f, 0.20745175f, -0.00819357f, 
    -0.26327765f, 0.11302807f, -0.34077358f, -0.21359456f, -0.14652508f, 0.03210658f, 0.20341749f, -0.03369234f, 
    -0.09861023f, -0.05781677f, -0.44398829f, -0.16634253f, 0.27734300f, -0.56976610f, -0.22622608f, -0.22584589f, 
    -0.00249816f, -0.14973183f, 0.18093140f, -0.20558102f, -0.26627770f, -0.00543183f, -0.08366134f, -0.13703074f, 
    0.24227150f, -0.22966388f, 0.05068451f, -0.19533166f, -0.32485658f, 0.19870116f, 0.09932272f, 0.10931348f, 
    0.05059236f, 0.03154894f, -0.21486913f, 0.24819979f, -0.20404801f, 0.01170078f, 0.25845972f, -0.00863622f, 
    -0.05561502f, -0.19066122f, 0.46407196f, 0.01335191f, -0.04259756f, 0.11698434f, 0.27881801f, 0.25175548f, 
    -0.02862052f, 0.20662835f, 0.10356005f, 0.17632879f, 0.10844057f, -0.09761473f, -0.19302408f, 0.06286417f, 
    -0.18203922f, 0.04677541f, -0.10406668f, -0.12982853f, 0.04369274f, -0.01478172f, 0.26664516f, -0.07504196f, 
    -0.30636734f, -0.00033637f, 0.04631938f, 0.03380122f, 0.02835423f, -0.04210916f, 0.18265647f, 0.09286109f, 
    0.29044986f, 0.01210050f, 0.31812862f, -0.27916873f, -0.03824480f, 0.01558078f, -0.04513827f, -0.01873766f, 
    -0.05492087f, -0.03691219f, 0.07435094f, -0.09506703f, 0.15010431f, 0.11456290f, 0.34020910f, -0.04119673f, 
    -0.03359157f, 0.15086231f, -0.20936200f, 0.17137662f, -0.24449049f, 0.05613749f, 0.09811304f, 0.04006600f, 
    -0.34646910f, 0.13258286f, 0.21564619f, 0.15518068f, 0.04965262f, 0.17782381f, 0.12234543f, 0.02245332f, 
    -0.00594402f, 0.00400819f, 0.40847331f, 0.28641480f, 0.17013687f, -0.13403340f, -0.21080616f, -0.19631653f, 
    -0.33056831f, -0.26522473f, -0.07104687f, 0.02013696f, 0.05754976f, 0.04319793f, -0.01507175f, -0.15766855f, 
    -0.44457880f, -0.50709039f, -0.01820067f, 0.41416073f, 0.14611533f, -0.06619409f, 0.07748290f, 0.31189758f, 
    -0.35670808f, 0.15813959f, 0.02585135f, 0.01747402f, -0.54765469f, 0.13544357f, -0.27063242f, -0.06585322f, 
    0.12023085f, 0.00864250f, 0.04550057f, -0.28814644f, -0.02038602f, -0.02130707f, 0.04058333f, 0.01622909f, 
    -0.11300571f, -0.80381835f, 0.68457943f, 0.29219538f, 0.23106085f, -0.05926087f, -0.02169088f, -0.07094014f, 
    0.09221239f, 0.01648934f, 0.17600693f, -0.04697027f, -0.04906795f, 0.16956651f, 0.20227174f, 0.27034512f, 
    0.10930974f, 0.02948219f, 0.13948481f, -0.05352117f, -0.17294511f, 0.04778351f, -0.20577545f, -0.28466895f, 
    0.41906476f, -0.05427021f, 0.03427451f, -0.10018944f, 0.22512199f, -0.03299824f, -0.03406511f, 0.04031207f, 
    0.09473728f, 0.10834328f, 0.21062784f, 0.11423116f, -0.85822564f, 0.03015900f, -0.14450958f, 0.07335949f, 
    -0.04312049f, 0.00635326f, -0.03750504f, -0.03065594f, -0.03021864f, -0.02480659f, 0.23297103f, 0.14307702f, 
    -0.12367655f, -0.16706543f, -0.04363019f, 0.18240418f, 0.34336314f, 0.05199433f, -0.04952269f, 0.08814634f, 
    0.06008324f, 0.07315488f, 0.17518792f, -0.03009454f, -0.37162405f, 0.25863576f, 0.11474750f, 0.36053804f, 
    -0.03341261f, -0.27003667f, -0.00774844f, 0.05970421f, 0.01382357f, -0.11521490f, -0.01671492f, -0.11415800f, 
    0.33115196f, -0.04082311f, 0.30836412f, -0.10402673f, -0.07748436f, -0.01676233f, -0.01685065f, 0.24917564f, 
    -0.32650417f, -0.04223105f, 0.16790441f, 0.05504675f, 0.12072981f, 0.11191177f, 0.25420722f, -0.19371025f, 
    -0.23270278f, 0.10027729f, -0.35381702f, -0.07987274f, 0.01279673f, 0.02837974f, 0.05997214f, -0.03653098f, 
    0.15898380f, 0.08210984f, -0.17168291f, -0.10746058f, -0.13183127f, 0.19329982f, 0.01866551f, -0.00624304f, 
    -0.00913061f, 0.01937492f, -0.04664289f, -0.00913216f, 0.36840263f, -0.04809747f, 0.32149816f, -0.19719827f, 
    0.04775921f, -0.00842443f, -0.08439489f, 0.05781211f, -0.17348042f, 0.03735204f, 0.02483621f, -0.14528364f, 
    -0.00270758f, -0.22384568f, 0.01914642f, -0.10241033f, 0.12234692f, 0.19950254f, -0.06017995f, 0.17286251f, 
    -0.03006598f, -0.10998243f, -0.18390065f, -0.32506868f, 0.04202487f, -0.29280820f, 0.44174999f, -0.14311196f, 
    -0.25043008f, -0.06873605f, -0.11066841f, -0.00211264f, -0.11724395f, 0.05261106f, 0.05841142f, 0.04983051f, 
    -0.09814497f, -0.26740047f, 0.09478863f, 0.29780036f, 0.24616434f, 0.21516825f, -0.01303623f, 0.06834064f, 
    -0.04437767f, -0.00574261f, -0.06863615f, -0.23461802f, -0.20118156f, -0.35370958f, 0.09281356f, -0.06317560f, 
    -0.16174740f, -0.02267480f, -0.12921660f, -0.20401889f, 0.02167204f, 0.02607423f, 0.03074656f, -0.10070834f, 
    0.45061678f, 0.14804845f, 0.34126598f, -0.09787738f, 0.10946192f, 0.13478015f, -0.10943425f, 0.04585791f, 
    -0.22815500f, -0.07809525f, -0.02924466f, 0.04866459f, -0.31857765f, -0.36703500f, -0.29580855f, -0.02467418f, 
    -0.17431876f, -0.32600531f, 0.00337447f, -0.25869799f, -0.00461663f, 0.15167324f, -0.01284888f, -0.02554402f, 
    -0.15702020f, -0.07738394f, -0.25581524f, -0.53271687f, -0.02395139f, 0.02563960f, 0.10962947f, -0.05134445f, 
    -0.01354052f, 0.10189366f, 0.23906156f, 0.04963736f, -0.34452605f, 0.48828113f, -0.31255573f, 0.26583943f, 
    -0.08670623f, -0.07710672f, 0.15970899f, 0.15675746f, -0.04485849f, 0.02360316f, -0.05583195f, 0.20445922f, 
    -0.59211707f, 0.07609339f, -0.35945207f, 0.05095602f, 0.09887638f, -0.01534724f, 0.07925686f, -0.09909966f, 
    0.10612508f, 0.18390065f, 0.31684965f, 0.33606282f, 0.00335871f, -0.09894257f, -0.09109803f, 0.10101267f, 
    -0.04575672f, -0.05583420f, -0.00826123f, 0.00409992f, -0.14884377f, 0.10487930f, -0.12532035f, -0.21136294f, 
    -0.00412415f, 0.14098506f, -0.07489114f, 0.12017836f, -0.02843343f, -0.07012423f, 0.05040331f, -0.00642592f, 
    0.21877210f, 0.10559832f, 0.11472197f, -0.02832721f, 0.42551506f, -0.13418770f, 0.62315005f, -0.28440535f, 
    0.06838397f, -0.11869366f, -0.23034196f, 0.06934552f, -0.05391093f, -0.15164742f, 0.01079406f, -0.06421749f, 
    0.54345399f, 0.00273321f, 0.13893583f, -0.28589487f, -0.09629694f, 0.20276695f, -0.24806084f, 0.14495450f, 
    -0.12495415f, -0.08939460f, 0.02666704f, 0.04937434f, 0.27014390f, 0.04634237f, 0.35873112f, -0.35085532f, 
    -0.24385253f, -0.05411139f, -0.13299367f, -0.20692964f, -0.05854850f, 0.00834487f, -0.15338492f, -0.11232352f, 
    -0.58204639f, -0.15422924f, 0.00721918f, 0.17349143f, -0.13205917f, -0.07939295f, 0.09916991f, 0.04543813f, 
    -0.06023494f, 0.03979370f, -0.23683475f, -0.07520209f, 0.17805432f, -0.29807284f, 0.48508736f, -0.13974418f, 
    0.00791220f, -0.03832034f, -0.20591673f, 0.00989161f, -0.28108716f, -0.01682029f, -0.03534306f, 0.06033715f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24639545f, 0.10133070f, 0.15171120f, -0.08026637f, -0.06933151f, 0.01752065f, 0.08019131f, -0.13614632f, 
    0.06700363f, 0.06309291f, 0.08974680f, -0.02729869f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
