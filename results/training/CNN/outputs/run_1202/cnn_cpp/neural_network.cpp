#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01228081f, -0.07217940f, 0.36145669f, 0.79862863f, 0.08045866f, -0.51173109f, 0.46433151f, 0.30682281f, 
    0.27732208f, -0.57979083f, -0.38668796f, -0.10858279f, -0.43321365f, -0.59741014f, 0.10630779f, -0.29932636f, 
    0.00796546f, 0.47043496f, 0.67570978f, 1.09194279f, -0.57294315f, -0.00564094f, -0.45652252f, -0.47259673f, 
    -0.15418325f, 0.16426815f, 0.16686413f, -0.12842895f, 0.41677696f, 0.30706480f, 0.58227646f, 0.40475625f, 
    0.48710096f, -0.15078963f, 0.20342316f, 0.17366701f, -0.48277488f, 0.11282031f, -0.36436260f, -0.15631230f, 
    -0.13199714f, -0.30619103f, -0.00129719f, -0.40630108f, 0.01110846f, -0.51538628f, 0.47799164f, 0.30492410f, 
    0.24554798f, -0.82090318f, -0.43500340f, 0.08123178f, 0.16183800f, -0.04344922f, -0.06016877f, -0.22244036f, 
    0.11826103f, 0.15543815f, -0.06372000f, -0.31987897f, -0.49033448f, -0.71505743f, -0.25109249f, -0.57562405f, 
    0.93998730f, -0.40330774f, -0.39864203f, 0.04067980f, -0.02381204f, -0.23748057f, -0.31469697f, 0.45909587f, 
    0.53774065f, 0.56905985f, 0.04831649f, 0.05790744f, 0.26241586f, 0.38620114f, 0.05218141f, 0.53252101f, 
    -0.28649068f, -0.25341529f, 0.21380623f, -0.00613476f, 0.41101468f, -0.03852662f, 0.57453614f, 0.19243790f, 
    -0.55001485f, -0.18506655f, -0.17766906f, 0.22289069f, -0.21832582f, -0.12238691f, -0.48557052f, -0.49123007f, 
    0.43409345f, 0.47232926f, 0.73729205f, 1.01475549f, 0.30286324f, 0.41295576f, -0.33341080f, 0.34784091f, 
    0.09670103f, 0.28417131f, -0.27991140f, 0.04362980f, 0.68979752f, -1.06198800f, -0.86826509f, 0.10487662f, 
    -0.12942840f, 0.31271559f, 0.17652006f, 0.19490905f, 0.10220192f, -0.39971372f, -0.39541110f, -0.32055280f, 
    0.39496344f, 0.50564092f, 0.55304360f, -0.51930332f, -0.05807146f, -0.22348318f, -0.79101121f, -0.23292203f, 
    -0.10250258f, 0.32391113f, -0.56365234f, -0.60898268f, -0.30415949f, 0.89353055f, -0.21127118f, -0.69333971f, 
    -0.54986429f, 0.29120874f, 0.17869779f, 0.46799019f, -0.53227186f, 0.14660512f, -0.16064830f, -0.25894848f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19722991f, -0.26708108f, 0.31362677f, 0.47939566f, -0.04942068f, 0.33187062f, 0.06911968f, 0.29951689f, 
    -0.00311181f, 0.22071838f, -0.02913535f, 0.09937522f, 0.23832884f, 0.18179452f, 0.16977650f, 0.21971120f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05521210f, 0.08538073f, -0.26135835f, 0.26616982f, 0.09329243f, -0.04664873f, 0.21491796f, 0.11267783f, 
    0.10581441f, 0.09062237f, -0.04482931f, -0.04389065f, 0.13599937f, -0.03477857f, -0.04815285f, 0.18211256f, 
    0.07617123f, 0.17271712f, -0.25296688f, -0.17074753f, 0.07920068f, 0.15187930f, 0.17662558f, -0.04753245f, 
    0.23765145f, 0.02140837f, 0.19093485f, -0.07056949f, 0.01254248f, 0.14967871f, 0.21689476f, 0.02289941f, 
    -0.02134990f, 0.01919269f, 0.11487830f, -0.01206638f, -0.09093129f, 0.11365958f, 0.06089482f, 0.09173483f, 
    0.02270830f, 0.12173550f, 0.10179237f, 0.15564686f, -0.05893040f, 0.21798281f, 0.11837939f, 0.04131578f, 
    0.41855404f, -0.01335904f, 0.04539651f, 0.25401536f, 0.05118135f, -0.18931758f, -0.32549471f, -0.09198216f, 
    -0.07598924f, 0.14938451f, -0.10367261f, -0.08541199f, -0.06425066f, -0.01129988f, -0.22565949f, 0.16898769f, 
    -0.04884817f, 0.21160206f, 0.04443315f, -0.01975005f, -0.05698196f, -0.09429671f, 0.03443330f, 0.01557699f, 
    -0.44764102f, -0.10695007f, -0.03028926f, 0.05383453f, 0.22038348f, -0.04096252f, 0.05294471f, -0.00717604f, 
    0.06628180f, 0.17653365f, -0.04808447f, 0.02613345f, 0.08103372f, 0.10919120f, 0.20511253f, 0.13374023f, 
    -0.08734064f, -0.11594437f, -0.15181258f, -0.07537039f, 0.18184866f, -0.26700357f, 0.03816696f, -0.29200858f, 
    0.21134308f, 0.23209335f, 0.06185525f, -0.30135819f, -0.26411095f, -0.20933311f, 0.16231056f, 0.10944786f, 
    -0.11808832f, -0.22288124f, 0.06898224f, -0.06623459f, -0.11033047f, 0.05447041f, 0.25649267f, -0.10781751f, 
    0.05249382f, 0.04884763f, 0.08060687f, 0.00172659f, 0.20693031f, 0.24711445f, -0.00068397f, -0.07282075f, 
    -0.02513148f, 0.03137688f, 0.27505299f, -0.15213659f, -0.12698576f, -0.03075228f, -0.15012714f, -0.15016098f, 
    -0.11678291f, 0.06052715f, -0.02654386f, 0.10712387f, 0.14417012f, -0.09861054f, 0.07058278f, -0.11389551f, 
    0.20282528f, -0.09506542f, 0.04731109f, 0.05383145f, 0.05026694f, -0.20605369f, -0.21161796f, -0.04160646f, 
    -0.00223644f, 0.03192169f, -0.00600946f, 0.00370506f, -0.08652771f, -0.01161330f, 0.05290871f, -0.04475064f, 
    0.06379508f, 0.05123908f, -0.03016653f, -0.07764068f, 0.06285483f, -0.03215213f, 0.04301257f, -0.05474579f, 
    -0.04475747f, -0.04266945f, -0.04894669f, -0.00954643f, 0.00746960f, -0.03402204f, -0.00087349f, -0.09090804f, 
    0.06299642f, -0.00608639f, -0.05356431f, -0.01152444f, -0.01783636f, -0.10116152f, -0.01311159f, 0.06043914f, 
    0.03655643f, -0.04231950f, -0.04323250f, 0.02190994f, -0.07688209f, -0.01015193f, -0.02476504f, -0.02108616f, 
    -0.00423773f, 0.02711436f, -0.03634825f, -0.02367472f, 0.02676441f, 0.06911053f, -0.09403716f, -0.05708499f, 
    0.01032714f, -0.01365697f, -0.00175969f, -0.08333419f, 0.06115822f, 0.05221533f, -0.05742018f, 0.01751436f, 
    -0.04657764f, -0.06160462f, -0.06194947f, -0.07783346f, -0.08762115f, -0.03641015f, -0.07815979f, -0.05453612f, 
    0.01717400f, -0.04360126f, 0.01726994f, -0.03817595f, -0.06785504f, 0.00534927f, 0.03383924f, -0.01980848f, 
    0.05582122f, -0.09122821f, -0.06938939f, 0.01312822f, -0.01689169f, -0.01695675f, 0.00629454f, -0.02033872f, 
    -0.04560880f, -0.04957512f, 0.02892374f, 0.01402446f, 0.00258293f, -0.04701396f, 0.06292216f, 0.04779992f, 
    -0.03016615f, -0.02318252f, -0.06433441f, -0.08789326f, 0.04545352f, -0.01978583f, 0.06704937f, -0.08039263f, 
    0.02128972f, -0.06383912f, 0.01843588f, 0.04191083f, -0.08151545f, -0.01404295f, 0.05045267f, -0.00201945f, 
    -0.08236504f, -0.07092261f, -0.00322117f, 0.05467460f, 0.07466906f, 0.04216367f, -0.00188261f, -0.07902355f, 
    -0.03458900f, -0.05306677f, -0.00620223f, -0.06228648f, 0.00807504f, -0.07449954f, -0.04063132f, 0.00876563f, 
    -0.03274658f, -0.01065801f, 0.05586589f, 0.06084265f, 0.00154772f, -0.06950783f, 0.00197825f, 0.07501871f, 
    0.04235941f, -0.05425682f, 0.00720974f, -0.06644753f, -0.07522850f, -0.02841046f, -0.09013289f, -0.01366615f, 
    -0.07914492f, -0.08364189f, -0.03357496f, 0.01958048f, -0.03564512f, 0.01724503f, 0.00752554f, -0.08307257f, 
    0.03366715f, 0.01076352f, -0.06612246f, 0.05522928f, -0.00927528f, 0.02980714f, -0.05962215f, -0.05619438f, 
    -0.08486032f, -0.00810503f, 0.01699050f, -0.06353474f, -0.00985542f, -0.02601556f, -0.05953427f, -0.04749665f, 
    -0.01394182f, 0.04406882f, -0.07756832f, -0.01719498f, -0.07458046f, 0.07180211f, 0.03148630f, -0.06962278f, 
    -0.01430472f, 0.04190759f, 0.00889269f, -0.06245534f, 0.00527348f, -0.07110365f, -0.02901904f, -0.00994322f, 
    -0.01561311f, -0.09388901f, 0.04780489f, 0.05884811f, -0.04730688f, -0.03618807f, 0.02815534f, -0.02032221f, 
    0.06580525f, -0.04331357f, -0.01124797f, -0.07721686f, -0.02021183f, -0.00371265f, -0.04734747f, 0.01823462f, 
    0.02131672f, 0.05626883f, -0.02832790f, 0.04711239f, 0.00745974f, 0.00441080f, 0.02676311f, -0.01092549f, 
    -0.02173038f, -0.08690389f, -0.08470962f, -0.07470110f, -0.05998909f, -0.07471563f, 0.02059351f, -0.07954250f, 
    -0.08481631f, 0.05977024f, -0.01533102f, -0.05426592f, -0.03146562f, 0.06023237f, -0.01316515f, -0.07574607f, 
    -0.02758034f, 0.04596051f, 0.00034095f, 0.02380798f, -0.00032837f, 0.03954512f, -0.05140559f, -0.04036595f, 
    0.02951993f, 0.06514844f, -0.00288728f, -0.03935671f, 0.06736156f, 0.01638859f, -0.06640103f, 0.00435525f, 
    -0.00027398f, -0.01452371f, -0.04544111f, 0.03855634f, -0.05765156f, -0.04144558f, 0.03352357f, -0.04652257f, 
    0.00485477f, -0.02686036f, -0.01753508f, 0.03947360f, -0.00269935f, 0.01955034f, 0.03747383f, -0.05262631f, 
    0.02382200f, -0.02749793f, 0.06557830f, -0.04792102f, -0.00279812f, 0.02176650f, -0.05227687f, 0.04591302f, 
    -0.00360480f, -0.02151899f, -0.01521290f, 0.05505048f, 0.01199058f, -0.06458066f, -0.05433945f, 0.00097724f, 
    -0.01761431f, -0.09313007f, -0.08343887f, -0.04334375f, 0.01701275f, 0.06145238f, -0.02195792f, -0.03619770f, 
    0.04965710f, 0.05047274f, -0.07773833f, -0.03381742f, 0.00993277f, -0.06761481f, -0.08495472f, -0.02453338f, 
    -0.04462497f, -0.08251372f, 0.06047012f, -0.04648855f, -0.08775865f, -0.03973337f, 0.06128254f, -0.08934028f, 
    0.05585671f, 0.26125094f, -0.17155090f, -0.02478305f, 0.00626891f, 0.19275485f, 0.16411303f, 0.19130412f, 
    -0.04761827f, -0.52424967f, -0.31051588f, 0.24653895f, -0.23356494f, -0.01666957f, -0.32283702f, 0.23126543f, 
    0.03282884f, -0.11389229f, -0.50685883f, -0.26969916f, -0.33291844f, 0.02048600f, -0.09546187f, -0.13249405f, 
    -0.02332455f, 0.04932809f, 0.14019421f, -0.06083810f, -0.23508482f, -0.04127401f, -0.18382327f, 0.01922877f, 
    -0.01939423f, 0.19343945f, -0.08339860f, -0.00603554f, -0.14752117f, 0.02154572f, 0.05121335f, -0.07714743f, 
    0.02429783f, 0.00158669f, -0.01367683f, 0.03299495f, -0.18126950f, -0.31476429f, -0.06892965f, 0.09563696f, 
    0.09524312f, -0.08260511f, 0.26798573f, -0.05758413f, 0.09087356f, 0.23595324f, -0.01199820f, 0.10899895f, 
    -0.01890005f, 0.02364058f, 0.13460849f, -0.07949245f, 0.11042365f, -0.01516794f, -0.11642599f, -0.17102252f, 
    0.03025077f, -0.14509594f, 0.17063800f, 0.09543063f, -0.00971797f, 0.09423892f, 0.24328662f, -0.19954690f, 
    -0.26633924f, 0.34169003f, -0.06939210f, 0.00018427f, -0.30105731f, -0.04684545f, 0.03592925f, -0.18528494f, 
    0.01327239f, -0.20795460f, 0.06115058f, 0.06247284f, 0.03784300f, -0.03799226f, -0.05927489f, 0.08732969f, 
    -0.14457738f, 0.15743226f, -0.09225602f, -0.43642944f, 0.20207250f, 0.02416135f, 0.01309523f, -0.14190872f, 
    -0.21187769f, 0.03540288f, 0.26588279f, -0.29817760f, 0.02627594f, 0.13946532f, 0.09724703f, -0.20525123f, 
    -0.04360459f, 0.00050362f, 0.11883735f, 0.22567084f, 0.58272493f, 0.03906149f, -0.24598582f, 0.01004822f, 
    0.04176715f, -0.04605905f, 0.01058878f, 0.09546625f, -0.08197597f, -0.16600104f, 0.32602721f, 0.40528363f, 
    0.21615604f, -0.00706207f, -0.34479108f, 0.24851725f, 0.03612727f, -0.11714892f, -0.13514751f, -0.02898440f, 
    0.34380743f, -0.01043884f, -0.02776268f, -0.06185718f, 0.05441805f, -0.14958549f, -0.06286573f, 0.13263799f, 
    0.37179258f, 0.08716809f, 0.13750535f, 0.04612862f, -0.10382455f, 0.32227522f, -0.05717054f, 0.04032419f, 
    0.08442874f, -0.33923277f, 0.01653218f, 0.07684172f, 0.19788337f, 0.19287045f, -0.28709453f, 0.01238848f, 
    -0.16553406f, 0.06773001f, 0.02022893f, -0.09997169f, 0.16477543f, 0.06309754f, 0.05896910f, 0.03461326f, 
    -0.02055771f, -0.25186160f, -0.01633105f, 0.30824572f, 0.43388486f, 0.11915220f, 0.03976902f, -0.04140394f, 
    -0.05730857f, -0.03589694f, -0.09386326f, -0.15410624f, -0.02847009f, -0.22637586f, 0.09852975f, 0.10496781f, 
    0.16188176f, -0.00933278f, 0.07105317f, -0.25389981f, 0.18346053f, 0.03017611f, -0.04172799f, 0.06197292f, 
    -0.09792843f, -0.07702095f, 0.01941467f, -0.05775215f, 0.27737004f, 0.09736411f, 0.16351300f, -0.12572339f, 
    0.03629869f, -0.06779290f, 0.23618034f, -0.00431466f, 0.02699655f, 0.02477012f, 0.11194965f, -0.02344998f, 
    0.33344245f, 0.10787697f, 0.09678770f, 0.09771723f, -0.00785510f, 0.33334032f, 0.06112389f, 0.01533087f, 
    0.30035505f, 0.15352602f, 0.10814244f, 0.23493111f, -0.15035754f, 0.16819952f, -0.09514073f, -0.01328750f, 
    0.14589344f, -0.07771127f, -0.08971878f, 0.02582136f, 0.05349671f, 0.12148802f, 0.04600978f, -0.12088475f, 
    0.00928265f, -0.01439495f, 0.07068647f, -0.06400335f, -0.10909928f, 0.25101817f, -0.09840149f, 0.13623445f, 
    0.18717602f, 0.01887578f, -0.15993269f, -0.12904106f, -0.05473864f, 0.24094735f, -0.03249323f, -0.00859907f, 
    -0.06501461f, -0.05091384f, -0.32890689f, 0.30099607f, 0.27037531f, 0.30187908f, 0.01389585f, 0.07380451f, 
    -0.03420637f, 0.10449156f, 0.08598209f, 0.00646950f, -0.02837138f, 0.16525175f, 0.34710395f, 0.13389635f, 
    0.03951992f, 0.02675648f, -0.01796518f, 0.00498766f, 0.09886371f, -0.04643698f, -0.24194884f, -0.26507026f, 
    0.16615558f, 0.10313515f, 0.28583091f, -0.00829996f, 0.15150934f, 0.15093179f, 0.05665513f, 0.00437186f, 
    -0.05269297f, 0.19396301f, -0.14068767f, 0.02135463f, 0.13960218f, 0.04255289f, 0.17191827f, 0.14886266f, 
    -0.12042922f, -0.25655848f, -0.05453457f, 0.09800947f, 0.02588009f, 0.11956837f, 0.04987151f, 0.28858411f, 
    -0.02604831f, 0.05731345f, 0.02460458f, 0.16515647f, 0.00340735f, 0.02195865f, 0.03791140f, -0.00489544f, 
    0.01922932f, 0.43282461f, 0.47973943f, -0.13029967f, -0.10970885f, -0.05540231f, 0.13734332f, 0.07035182f, 
    -0.03400364f, -0.17627478f, 0.37161925f, 0.07322536f, -0.17190620f, 0.07986604f, 0.02057833f, 0.23561998f, 
    0.10079039f, -0.10555526f, -0.05038688f, 0.11938351f, 0.40649268f, 0.28319901f, -0.15939465f, 0.06321815f, 
    -0.09395300f, 0.06363206f, 0.08690380f, 0.00845058f, 0.27570662f, -0.26384991f, -0.20808601f, -0.00570151f, 
    -0.00595750f, -0.01119136f, -0.09267791f, 0.07655258f, 0.07493075f, -0.30050799f, -0.12377088f, 0.21576832f, 
    0.03617962f, 0.02525973f, -0.09301429f, -0.07806045f, 0.10688796f, -0.02772942f, 0.10566930f, -0.19045775f, 
    -0.35825941f, 0.15228239f, 0.10094739f, -0.01270275f, -0.10296842f, 0.20663521f, 0.21230382f, -0.45158064f, 
    -0.49933726f, -0.52227807f, 0.06734301f, -0.14013509f, -0.00875285f, -0.09848143f, -0.02559511f, -0.09840447f, 
    0.17073241f, -0.09291003f, -0.17929929f, 0.09056303f, 0.03719933f, -0.12161815f, 0.14705448f, 0.11831786f, 
    -0.04051235f, 0.18693078f, 0.26168028f, 0.17594863f, -0.16878812f, -0.09923957f, 0.04225888f, 0.02423058f, 
    0.09483399f, 0.30693734f, 0.08228825f, 0.09002010f, -0.13503699f, -0.00203595f, 0.21255840f, 0.10297386f, 
    -0.06783178f, -0.23345245f, -0.20715623f, 0.18236271f, -0.01738232f, 0.03849835f, 0.06872451f, 0.18141194f, 
    -0.15068491f, 0.08353571f, -0.03135060f, 0.08261291f, 0.41495997f, 0.22853234f, -0.07508489f, -0.01513419f, 
    -0.01633329f, 0.08500923f, 0.06740985f, -0.09782346f, -0.02245770f, 0.18195936f, 0.07294771f, -0.16411340f, 
    -0.04206234f, 0.01789067f, 0.06631859f, 0.05230592f, 0.03468265f, 0.02971128f, -0.31625846f, -0.23206453f, 
    0.26839903f, -0.09719843f, 0.04216570f, -0.42536247f, 0.17120011f, 0.09134583f, 0.06885961f, -0.22259319f, 
    -0.33242649f, -0.16078009f, -0.13202524f, -0.10425087f, -0.09925330f, -0.02180470f, 0.01605431f, 0.04473670f, 
    -0.01892555f, -0.06861076f, -0.07474045f, 0.05105479f, 0.06542763f, -0.07301310f, -0.08765352f, -0.06365362f, 
    -0.11034033f, 0.02515532f, -0.07063259f, -0.10224953f, -0.10268706f, -0.08656876f, -0.00449147f, -0.08334547f, 
    -0.04119913f, 0.08842079f, 0.00243584f, 0.05178896f, 0.03823839f, -0.03875059f, -0.05634214f, 0.02481691f, 
    -0.02474225f, -0.08471796f, 0.04142767f, -0.09383781f, 0.02609085f, -0.04594443f, -0.05085817f, 0.05771351f, 
    -0.09036266f, -0.04113287f, -0.04727817f, -0.08821376f, 0.00525622f, -0.06535562f, -0.05497637f, -0.00102964f, 
    -0.05911950f, 0.04004660f, 0.04639138f, 0.04593102f, -0.03627319f, 0.02174746f, -0.09683348f, -0.03159707f, 
    0.04900309f, 0.03753714f, -0.04535893f, -0.01568015f, -0.00293427f, 0.02871846f, -0.02085287f, 0.02467769f, 
    0.00047177f, -0.00416730f, -0.11380491f, -0.03580770f, 0.04192837f, 0.06477286f, 0.07813293f, 0.02899339f, 
    0.04985785f, -0.08289558f, 0.01750773f, -0.03247224f, -0.09130660f, 0.03014776f, -0.09265981f, -0.06948558f, 
    -0.01015603f, -0.03004512f, 0.07810994f, -0.06876960f, 0.00247561f, -0.00933223f, 0.01596572f, -0.07856662f, 
    0.03404982f, -0.11359596f, -0.07247849f, 0.06395099f, -0.05969380f, -0.03785081f, 0.04622620f, 0.00951287f, 
    -0.09358426f, -0.01407764f, 0.04375182f, -0.06942256f, 0.02266890f, 0.01026231f, 0.01582412f, -0.00322336f, 
    0.03470093f, 0.03932647f, -0.00507984f, -0.04530976f, 0.07947747f, -0.00121796f, -0.07592234f, 0.00305026f, 
    0.03450767f, -0.06431869f, 0.05669362f, -0.09888043f, -0.01924271f, 0.00229379f, -0.01185367f, -0.09319376f, 
    -0.08525250f, -0.03636416f, 0.02124346f, -0.01589223f, 0.02470658f, -0.10717444f, 0.04815802f, -0.00104908f, 
    -0.02669050f, -0.04242498f, -0.07471471f, -0.01398420f, 0.00294535f, 0.00113789f, 0.06135242f, -0.01225605f, 
    -0.11598514f, -0.03957283f, -0.07716103f, -0.09265845f, -0.06557608f, -0.03689829f, 0.05912801f, 0.00700016f, 
    -0.00485368f, 0.04468771f, -0.11038388f, -0.08367912f, 0.03747379f, 0.05243638f, -0.02516812f, 0.05611951f, 
    0.04836881f, 0.03501697f, 0.05245505f, -0.07447806f, -0.03051673f, 0.05280277f, -0.07230911f, 0.05874178f, 
    0.06210941f, 0.01130535f, 0.01367730f, -0.02152741f, -0.08915277f, 0.05204429f, -0.01602468f, -0.00103233f, 
    0.06074540f, -0.03699061f, -0.08499719f, -0.08780482f, -0.02631268f, 0.07071985f, -0.03051938f, 0.02706352f, 
    0.05223600f, -0.06366490f, -0.08521574f, 0.00233960f, 0.01345568f, -0.03499700f, -0.08386691f, 0.03725050f, 
    0.02237952f, -0.04674981f, -0.04289544f, -0.05411073f, -0.00744636f, 0.05506617f, -0.06781788f, -0.03200087f, 
    -0.02563893f, -0.07679106f, 0.05897730f, -0.06012136f, -0.05558433f, -0.08723751f, -0.08018593f, 0.02581367f, 
    -0.09095571f, -0.00217104f, 0.01624594f, -0.02541014f, -0.03924312f, 0.02296462f, 0.03506037f, -0.06729494f, 
    0.05463733f, 0.01861034f, -0.05347770f, -0.00375323f, 0.06588691f, 0.02131845f, -0.00432283f, 0.03425372f, 
    -0.09271639f, -0.06323558f, 0.00296250f, -0.07453988f, -0.07628424f, -0.06832581f, -0.01912896f, 0.03308146f, 
    -0.04046023f, -0.01987610f, 0.04569809f, -0.08903946f, -0.02795515f, 0.00402648f, -0.04158637f, 0.03339280f, 
    -0.01761780f, 0.00508722f, 0.04983919f, -0.08329313f, 0.05565105f, -0.04406192f, 0.04461531f, -0.02278469f, 
    0.01013532f, -0.05252125f, -0.07767286f, -0.04231274f, 0.01525792f, -0.01359006f, -0.08899096f, -0.00719965f, 
    0.00983112f, -0.07910416f, 0.00135628f, -0.08501628f, -0.05300625f, -0.01892928f, -0.00845504f, 0.02854322f, 
    -0.01887397f, -0.06288463f, -0.04189175f, -0.07765248f, 0.00709554f, -0.00958640f, 0.04668064f, -0.07163765f, 
    0.05192400f, 0.04736242f, 0.05566948f, -0.02976850f, -0.08136385f, -0.08301206f, -0.07864578f, -0.09369419f, 
    -0.03493069f, -0.00449529f, -0.04497693f, 0.00132691f, -0.03500688f, 0.06754071f, 0.00681605f, -0.06301600f, 
    -0.01643585f, -0.07660845f, 0.02362028f, 0.05392224f, -0.07375339f, 0.05053582f, -0.08945353f, -0.08043788f, 
    -0.03577921f, 0.01719389f, 0.00443965f, 0.06160833f, 0.05248963f, 0.02237880f, -0.03953324f, 0.00796854f, 
    0.17704959f, 0.15014948f, 0.19239636f, -0.24698348f, 0.02737590f, -0.21605180f, 0.12815015f, 0.05031864f, 
    -0.02331673f, 0.21233794f, 0.20606245f, -0.02218873f, -0.05166399f, -0.03659790f, -0.05680218f, 0.10962459f, 
    0.06249205f, 0.19978344f, -0.58716393f, -0.24544266f, 0.41976893f, -0.01050524f, 0.06071192f, 0.06252516f, 
    -0.06426927f, 0.06238735f, 0.10347394f, -0.03566715f, 0.15868528f, -0.07126144f, -0.29673287f, 0.01043771f, 
    0.02640727f, -0.01813816f, -0.22598758f, -0.08940350f, 0.27977252f, 0.10178328f, -0.10205406f, 0.12891674f, 
    0.13412927f, -0.07093641f, -0.01122636f, -0.02185430f, -0.23374794f, 0.08481505f, -0.06073654f, 0.17862633f, 
    -0.24262165f, 0.17037408f, 0.11298154f, -0.09324673f, 0.08684243f, -0.03213332f, -0.10402048f, -0.23943941f, 
    -0.30318886f, 0.01635486f, 0.19190201f, -0.02604853f, -0.05310182f, -0.02954426f, -0.21255027f, 0.03676661f, 
    0.26048011f, 0.17192432f, -0.11578516f, 0.26399735f, -0.00892160f, 0.16320528f, 0.04015113f, 0.06055111f, 
    0.02119301f, 0.12703177f, 0.07087627f, 0.06588873f, 0.03954897f, -0.03750836f, 0.18775487f, -0.06797504f, 
    0.12827608f, -0.17637007f, 0.11492939f, 0.22310419f, 0.17522645f, -0.06544852f, -0.11815042f, 0.09848826f, 
    -0.17069247f, -0.06098085f, 0.11326660f, -0.02736421f, 0.12647229f, -0.10909348f, 0.12126523f, 0.21577427f, 
    0.15580477f, 0.08239345f, 0.42977536f, 0.02738040f, 0.03628532f, 0.15843298f, -0.11065485f, 0.05713695f, 
    0.17799748f, -0.08603069f, 0.05250666f, 0.09770336f, 0.16205855f, -0.39071485f, -0.31838325f, -0.13708676f, 
    -0.02571109f, 0.13216111f, 0.01680217f, -0.13960825f, -0.17847335f, 0.11625706f, -0.01104432f, -0.04539659f, 
    0.11427430f, 0.12632702f, -0.25580531f, 0.08121378f, -0.09905574f, -0.23329768f, 0.30406883f, 0.02160184f, 
    -0.08245711f, -0.19354065f, 0.12662236f, 0.10142326f, 0.02107585f, -0.10819644f, -0.02093367f, 0.48328048f, 
    0.06794459f, 0.05717217f, 0.06821170f, 0.11463462f, -0.08211193f, -0.21571904f, -0.17451763f, -0.12752667f, 
    -0.05825207f, 0.15675125f, -0.10719870f, -0.15146741f, 0.18142183f, -0.03290206f, 0.03114433f, -0.04280351f, 
    0.15305389f, -0.22568801f, -0.02603288f, 0.35621917f, -0.07766875f, 0.07086786f, -0.28296977f, -0.01977722f, 
    0.07302179f, -0.19999786f, 0.14411414f, -0.10693241f, -0.21607910f, -0.05283157f, 0.09794232f, 0.15749562f, 
    0.03646474f, 0.00183898f, 0.13170883f, -0.16414784f, -0.44883245f, -0.06750719f, -0.02813931f, -0.00588020f, 
    -0.09682787f, 0.11548624f, 0.01575109f, 0.12341513f, -0.08252971f, -0.03996088f, 0.12586418f, 0.10195027f, 
    -0.16900522f, 0.00615259f, 0.11550183f, 0.03165432f, 0.02773929f, -0.12694842f, -0.12760130f, 0.05687513f, 
    0.20384046f, -0.06492328f, -0.04906873f, 0.12763737f, 0.12065780f, 0.07363129f, -0.03743302f, -0.01164803f, 
    -0.04866556f, 0.03833390f, -0.07841346f, -0.08883134f, 0.18167123f, -0.09488654f, -0.13371609f, 0.15547349f, 
    -0.04817066f, 0.43691206f, -0.03338026f, 0.13939221f, 0.20773001f, 0.06238125f, -0.05656200f, 0.05596469f, 
    0.10988761f, -0.44638178f, -0.10813899f, -0.39855766f, -0.01480725f, -0.04698369f, 0.16330232f, 0.02660178f, 
    0.11784732f, -0.09047387f, -0.46355480f, 0.00952525f, 0.18130340f, -0.13091215f, -0.06063316f, 0.15610500f, 
    -0.05919942f, 0.08043930f, -0.21910161f, 0.00607349f, 0.05536674f, -0.02300400f, 0.14322005f, 0.13138917f, 
    0.09054223f, 0.14340572f, 0.13471790f, 0.20245434f, -0.09217948f, 0.22833802f, 0.02239284f, 0.03009284f, 
    0.08180808f, -0.17691232f, 0.07760990f, 0.00454023f, 0.08699752f, 0.07821801f, 0.27578098f, 0.13286538f, 
    -0.01493775f, -0.06755964f, 0.03239725f, -0.14995734f, -0.00291893f, -0.22853117f, 0.13419467f, 0.24072732f, 
    0.16656366f, 0.12942544f, -0.13485231f, -0.15680392f, -0.02243223f, 0.02756013f, -0.16072659f, 0.07280977f, 
    0.34174269f, 0.01014162f, -0.19416848f, -0.05901355f, -0.02915231f, 0.01468099f, 0.19834304f, -0.21851036f, 
    -0.03900453f, 0.21609461f, 0.11576819f, 0.08422055f, 0.06730246f, -0.09602304f, 0.04512628f, -0.10351151f, 
    0.16488183f, -0.10141173f, 0.01908051f, -0.08278088f, -0.05076885f, 0.18971933f, 0.06811565f, 0.15345645f, 
    -0.05693981f, -0.79354638f, -0.29988626f, 0.16376223f, 0.13275629f, -0.04273736f, -0.21231620f, -0.01577485f, 
    0.05730881f, 0.05827399f, 0.22209452f, 0.13678682f, 0.17541754f, 0.04280752f, 0.17214365f, -0.09902238f, 
    -0.02380597f, 0.07408509f, -0.00537233f, -0.03909811f, -0.15556681f, 0.19469683f, 0.06507407f, -0.01972886f, 
    0.04278395f, 0.08026727f, 0.13830760f, 0.04810007f, -0.27495942f, -0.12633558f, 0.13860212f, -0.06291725f, 
    -0.17082019f, -0.29797742f, 0.04969072f, 0.09803466f, -0.00173859f, 0.06943755f, -0.16379793f, -0.01931474f, 
    -0.33416036f, 0.05716505f, -0.22338903f, -0.09237722f, -0.19510782f, 0.01681478f, -0.10352401f, 0.17502300f, 
    -0.01273399f, 0.10781552f, 0.25764775f, -0.26973858f, -0.00093082f, 0.12426484f, 0.00699407f, -0.44245508f, 
    0.22355196f, 0.64643991f, -0.21301974f, -0.30867478f, 0.10327903f, 0.04768752f, -0.02969126f, -0.03578448f, 
    0.03220999f, 0.08485012f, 0.35378721f, -0.00573664f, 0.16226925f, -0.02515725f, -0.04787342f, 0.22788219f, 
    0.00761740f, 0.16400458f, -0.31731459f, 0.38079357f, 0.00414190f, -0.00028016f, -0.05466833f, -0.14218447f, 
    -0.06023611f, 0.04908267f, 0.23388901f, 0.05477042f, -0.12041055f, 0.02236300f, -0.00256617f, -0.08034859f, 
    0.18708821f, -0.19795708f, 0.10777947f, -0.05781749f, -0.01404733f, 0.53974462f, 0.12652504f, 0.07610673f, 
    0.20627365f, 0.02244266f, 0.10160089f, 0.07810856f, -0.23260272f, -0.21143454f, 0.37858805f, 0.09875420f, 
    -0.20234996f, 0.04522579f, 0.01332981f, -0.18557326f, -0.16924545f, -0.02288934f, 0.33507314f, 0.07602016f, 
    -0.09957141f, -0.04673539f, -0.32644743f, -0.13653582f, -0.15189566f, -0.23701473f, -0.25964633f, -0.11988913f, 
    -0.00531328f, -0.32447118f, -0.24052995f, -0.30998266f, 0.07606914f, 0.00594523f, 0.15356386f, -0.26986313f, 
    0.42453995f, -0.06565651f, 0.04755577f, -0.10568158f, 0.16623873f, -0.01539859f, 0.16653447f, -0.06855312f, 
    -0.09558581f, -0.20996331f, -0.07048467f, 0.02235456f, -0.23240100f, 0.12988274f, 0.12893987f, 0.10530724f, 
    0.00062560f, 0.10973402f, 0.23537144f, 0.01988269f, 0.14209718f, 0.14497353f, -0.02577579f, 0.16789685f, 
    -0.17252444f, -0.03027497f, 0.02534718f, -0.17383747f, -0.52853209f, -0.07133735f, -0.04956487f, -0.28740704f, 
    0.00525362f, 0.02531731f, 0.03244844f, 0.11355977f, -0.42100719f, -0.42049390f, 0.09823270f, -0.05769979f, 
    0.00247714f, -0.08743218f, 0.16030063f, 0.08124515f, 0.19480728f, 0.09342120f, 0.11732689f, -0.14920773f, 
    0.10501982f, 0.21440384f, -0.08304195f, 0.05675695f, 0.09978963f, -0.27223179f, 0.19415689f, -0.01332480f, 
    -0.05874073f, -0.02662527f, -0.14674769f, 0.04344486f, -0.11073913f, 0.08503664f, 0.32049856f, 0.05629506f, 
    0.13050039f, -0.03827478f, -0.04156271f, 0.08685627f, 0.02873830f, -0.05868186f, 0.04162176f, -0.03308535f, 
    -0.01190241f, -0.16853808f, 0.05684609f, -0.07783021f, 0.04297968f, 0.02104157f, 0.18943025f, 0.05467506f, 
    0.28458589f, 0.25401506f, -0.27388641f, 0.03350476f, 0.01017731f, 0.05428273f, 0.02844268f, 0.04076475f, 
    0.02401161f, 0.10774352f, 0.01501517f, -0.06070087f, -0.03953783f, -0.11994268f, 0.07455912f, -0.08042151f, 
    0.05335822f, 0.05137812f, 0.32476917f, 0.35069308f, -0.00821823f, -0.05948506f, -0.23351927f, -0.05363772f, 
    -0.07636832f, 0.05204188f, -0.05273701f, -0.18542887f, -0.50353926f, -0.03748441f, 0.14274313f, -0.01275975f, 
    0.02969627f, -0.06936767f, 0.24663758f, 0.08803076f, 0.21179469f, 0.16344377f, -0.32828608f, 0.00817271f, 
    0.14187376f, 0.07199392f, 0.06932668f, 0.08725663f, -0.09280145f, 0.15470430f, -0.31835732f, -0.05861147f, 
    0.00348436f, 0.00320196f, 0.13137192f, 0.07486213f, 0.11483878f, 0.16157241f, 0.04064718f, 0.10753588f, 
    0.11822461f, -0.04439059f, 0.01928221f, -0.01975012f, 0.12957637f, -0.13382211f, 0.02681701f, 0.49382904f, 
    -0.10471868f, 0.11153764f, 0.22689411f, -0.09802937f, 0.07455402f, 0.01443888f, 0.03924891f, -0.13423985f, 
    0.01756218f, -0.01532701f, 0.02218723f, -0.12302396f, 0.12412331f, -0.02827627f, 0.11121693f, -0.06735650f, 
    -0.24179158f, 0.16070005f, 0.12665451f, -0.05778309f, -0.15102597f, -0.30363756f, -0.18171582f, 0.03001262f, 
    -0.00717984f, -0.02094439f, 0.07224615f, 0.33589920f, -0.03056961f, 0.18612920f, 0.14887086f, 0.05791097f, 
    0.18007131f, 0.18425639f, 0.10333151f, 0.08027524f, 0.09242915f, -0.23210806f, -0.08959196f, -0.17162217f, 
    -0.04908758f, 0.05150454f, -0.13763542f, -0.08932033f, -0.08960591f, 0.01696060f, -0.11767852f, -0.17824395f, 
    0.10256933f, -0.13741548f, 0.06497233f, 0.13868542f, 0.03146704f, -0.33209056f, 0.05789437f, 0.28262144f, 
    -0.13061535f, 0.09826843f, -0.09297965f, -0.08819082f, 0.15474433f, -0.00204637f, 0.11457842f, 0.13937983f, 
    -0.07837984f, -0.01872062f, -0.06975837f, 0.00315330f, 0.02050786f, -0.14380166f, -0.05008405f, 0.16832162f, 
    0.50815707f, -0.10166007f, -0.05570368f, 0.03225750f, 0.32073712f, 0.07518221f, 0.24548317f, -0.12732092f, 
    0.37449178f, 0.18372633f, 0.22984301f, -0.00908314f, -0.13972390f, -0.01597418f, -0.02380407f, 0.11383087f, 
    0.03995637f, -0.07196831f, -0.09589663f, 0.12582187f, 0.04133852f, -0.11042710f, -0.07041647f, -0.13194723f, 
    0.03357944f, 0.05756225f, -0.21546814f, 0.07862215f, -0.17814972f, 0.01344562f, 0.12487348f, -0.01189194f, 
    0.09408084f, 0.17977667f, 0.10563774f, 0.34046936f, 0.05042303f, 0.34968907f, 0.05650500f, -0.06103386f, 
    -0.09567051f, -0.05320891f, 0.12912589f, 0.16938503f, -0.43545899f, -0.54078805f, -0.40555426f, -0.15039586f, 
    -0.05589980f, 0.25909528f, 0.07654987f, -0.14634438f, 0.14372820f, 0.04319777f, -0.10253150f, -0.43050843f, 
    0.07331165f, -0.13889280f, -0.09784181f, 0.09913886f, -0.05160312f, -0.01262695f, 0.21061428f, 0.02796235f, 
    0.45745620f, -0.11456918f, 0.02739180f, -0.27688661f, -0.07209552f, 0.12158529f, -0.14754419f, -0.02416681f, 
    -0.20833445f, -0.20078893f, 0.02541865f, -0.03896890f, -0.19071850f, -0.01172710f, 0.02000373f, -0.02102123f, 
    -0.27236947f, -0.16705196f, 0.11357930f, 0.10111620f, -0.10785668f, -0.08968298f, 0.15301979f, 0.17229247f, 
    0.20516942f, -0.15040433f, 0.10681961f, 0.06203185f, 0.00941236f, 0.03366822f, 0.07303251f, -0.02182324f, 
    0.17213017f, 0.09364410f, 0.15089510f, -0.31922159f, 0.03694169f, 0.20082077f, 0.12459703f, 0.15549389f, 
    0.11908852f, 0.13819221f, -0.00690790f, 0.11168613f, 0.22391811f, 0.14593172f, 0.22803462f, 0.00751680f, 
    0.08241475f, 0.01747217f, 0.09106986f, 0.06015422f, -0.30419216f, -0.14730108f, -0.02500419f, -0.14582178f, 
    -0.09143171f, 0.02724924f, 0.00110344f, 0.20910537f, 0.11140826f, -0.44008961f, -0.32587111f, -0.12866953f, 
    0.04389977f, -0.03009592f, 0.03686922f, 0.29473469f, 0.23390640f, 0.07262068f, 0.26095769f, 0.01502658f, 
    0.05686237f, -0.08068305f, -0.08896063f, -0.01509676f, 0.10644232f, 0.03749089f, 0.09839014f, 0.01445518f, 
    -0.11126299f, -0.09033531f, 0.07254069f, 0.00964933f, 0.21254396f, 0.13158472f, 0.10993058f, 0.11471725f, 
    0.45621166f, 0.26199669f, 0.14232610f, -0.15385580f, -0.27432385f, -0.10550744f, -0.11433262f, -0.09042501f, 
    0.20521580f, -0.15006687f, 0.23123303f, 0.15738121f, 0.04751224f, -0.12901509f, 0.02300027f, -0.11711042f, 
    -0.15583789f, 0.20166156f, -0.31718048f, -0.07594817f, -0.24706829f, -0.03509184f, -0.01672416f, -0.06505062f, 
    0.05456214f, 0.11362457f, 0.16307539f, 0.45581701f, 0.29184821f, 0.02786539f, -0.11282435f, 0.15700874f, 
    -0.01065721f, -0.04476423f, 0.23621342f, -0.00442037f, -0.03136711f, 0.27802670f, -0.02851911f, -0.10359603f, 
    0.17636876f, -0.08045601f, 0.00004434f, 0.04111303f, -0.01866058f, -0.35996851f, -0.12607750f, 0.00230746f, 
    0.06341312f, 0.03893914f, 0.03659023f, -0.07442333f, -0.17939904f, -0.04172504f, -0.12625629f, -0.13098368f, 
    0.06282941f, -0.00883973f, -0.06911265f, -0.18076581f, -0.02254477f, -0.08527502f, -0.00741301f, 0.08112474f, 
    -0.41214585f, -0.09033149f, 0.12940632f, -0.09179512f, -0.01690077f, -0.14667702f, -0.09508787f, -0.02543287f, 
    0.00751526f, -0.05369126f, -0.02176654f, -0.02398082f, -0.03634387f, -0.07885916f, -0.01260030f, 0.00178368f, 
    0.02619887f, 0.02186687f, 0.00081013f, 0.06781099f, -0.00809991f, 0.03550970f, -0.02577840f, -0.07422143f, 
    -0.07067387f, 0.06099383f, -0.03439162f, -0.00838302f, -0.03088664f, 0.07461298f, -0.00126324f, 0.04736447f, 
    0.00285892f, 0.04460366f, 0.01591187f, -0.01419090f, -0.01124632f, 0.03520455f, 0.00296872f, 0.02857532f, 
    0.03265761f, -0.04102099f, -0.08068369f, -0.03351081f, 0.01222336f, 0.01371706f, -0.02241613f, -0.00130906f, 
    0.05091274f, -0.07502844f, -0.06793793f, -0.04625032f, 0.07080117f, -0.03822304f, 0.00670808f, -0.01821475f, 
    -0.04598404f, -0.03294085f, 0.01681855f, -0.07905979f, -0.09176270f, -0.05964196f, 0.05980445f, -0.03428014f, 
    -0.03495991f, -0.05975574f, 0.05136748f, 0.02867104f, 0.06298693f, 0.07146404f, -0.05295428f, 0.03975301f, 
    0.04089677f, 0.05671306f, 0.05376856f, 0.02665100f, 0.00496495f, 0.02766751f, 0.05627306f, 0.03267544f, 
    -0.06113528f, 0.06848237f, -0.06145708f, -0.04014483f, -0.03196229f, 0.02090858f, 0.01702049f, 0.03235876f, 
    -0.00308358f, 0.01402489f, -0.02200348f, 0.07232495f, 0.05128985f, -0.08450571f, -0.06168635f, -0.05432804f, 
    0.03292966f, -0.04278218f, -0.03532837f, -0.07134106f, 0.04847389f, -0.06136722f, 0.04125597f, -0.06594367f, 
    0.02487630f, -0.08231103f, 0.00096680f, -0.02089199f, 0.06573059f, -0.08276561f, -0.05160961f, 0.06515621f, 
    0.00891482f, -0.07093370f, -0.05282822f, 0.01536276f, -0.06052555f, 0.01862141f, -0.05141198f, -0.04203392f, 
    -0.05242416f, 0.01814386f, -0.00035433f, 0.03247454f, -0.02776103f, -0.08914454f, 0.03572836f, -0.02934676f, 
    -0.05029853f, -0.00063313f, -0.00869155f, 0.04185414f, 0.00678637f, 0.04643176f, -0.05705124f, -0.02205336f, 
    -0.04403095f, 0.01115587f, 0.00571932f, -0.04321734f, -0.04613418f, -0.06096192f, -0.00646619f, 0.03882433f, 
    0.01614041f, 0.05846896f, 0.03780767f, -0.01382166f, -0.06386998f, -0.01075657f, 0.03123520f, -0.05284148f, 
    -0.31655246f, -0.58062619f, 0.05330105f, -0.00316918f, 0.06988700f, -0.24335407f, 0.05849690f, 0.06264531f, 
    -0.02369300f, 0.00475130f, 0.26448709f, 0.22455674f, -0.13507946f, 0.03619127f, -0.09964756f, 0.10120608f, 
    0.12085406f, -0.02874215f, 0.03518794f, -0.45027074f, -0.52248126f, -0.11116634f, -0.11412057f, 0.06300651f, 
    0.04437328f, -0.00333616f, -0.05007112f, 0.49176309f, -0.34854341f, -0.34951487f, -0.08376349f, 0.12025159f, 
    -0.10410194f, 0.01668512f, 0.15580808f, -0.03113891f, 0.10695264f, 0.12879999f, 0.23839195f, -0.11367176f, 
    -0.03972254f, 0.00809764f, 0.10969973f, -0.00941059f, -0.08811052f, -0.09245318f, -0.11780998f, 0.06127309f, 
    -0.02155533f, 0.07312237f, -0.01210225f, -0.11281984f, 0.09478793f, 0.24043091f, -0.02974675f, 0.11045174f, 
    -0.01934220f, -0.06631708f, -0.10263892f, 0.08232629f, 0.22884715f, -0.14312297f, 0.00086736f, -0.30142251f, 
    -0.06054649f, 0.31948924f, -0.14596736f, 0.12825637f, 0.13453564f, 0.17772140f, 0.01067564f, -0.03868340f, 
    0.16176085f, -0.05607506f, -0.06438789f, 0.03705584f, -0.04225477f, 0.11218497f, -0.00413109f, -0.00986871f, 
    0.03659712f, -0.47490227f, 0.14010310f, -0.05969578f, -0.12844369f, -0.10560162f, -0.26389718f, 0.14763756f, 
    -0.10307384f, 0.04871813f, -0.00257389f, 0.46158758f, 0.14789243f, 0.08776511f, 0.04613046f, 0.06513184f, 
    0.09960527f, -0.02639828f, 0.07677085f, 0.02072234f, -0.13696565f, 0.30723709f, 0.06718311f, -0.25821334f, 
    -0.17893448f, -0.01038866f, -0.04828237f, 0.14065647f, 0.16677591f, -0.14954592f, -0.27261972f, 0.06482533f, 
    -0.10220354f, -0.02100100f, 0.05019714f, 0.00835836f, 0.00311037f, -0.11364171f, 0.04028603f, -0.06644531f, 
    -0.09746928f, 0.00119995f, -0.10128404f, 0.17132993f, -0.02837529f, -0.01970441f, 0.09053360f, 0.31447551f, 
    0.40619740f, -0.09513477f, 0.05367176f, -0.10820391f, 0.06370208f, 0.15344763f, 0.14536139f, 0.16960925f, 
    -0.26115289f, 0.34098139f, -0.09007520f, -0.09266860f, 0.08150682f, 0.12672493f, 0.08550150f, -0.03446535f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22068934f, 0.01538323f, -0.05954858f, 0.46893406f, 0.03852350f, -0.01116884f, -0.08337194f, 0.01818902f, 
    -0.29111245f, 0.45163783f, 0.08214316f, -0.11095439f, 0.09103308f, 0.34403345f, -0.02528559f, 0.05719624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.34283531f, 0.11044475f, 0.23940831f, 0.25534576f, -0.35879478f, -0.42095798f, -0.14282042f, 0.01613408f, 
    0.09225130f, 0.08735134f, -0.07936209f, -0.00065635f, 0.24704668f, 0.14666046f, 0.00274484f, 0.35768226f, 
    -0.03513698f, -0.16255243f, -0.11418576f, 0.42831478f, -0.15920408f, -0.00815941f, 0.00430505f, -0.19873337f, 
    0.07640328f, 0.02920062f, 0.32833835f, -0.11895098f, 0.10128578f, 0.14987685f, -0.19425172f, -0.00195203f, 
    -0.15263012f, 0.20974924f, 0.03777959f, 0.29093188f, 0.21817695f, 0.46189174f, 0.03475867f, -0.05309798f, 
    0.10415790f, -0.28583393f, -0.01898521f, 0.00227147f, -0.14864637f, -0.10151894f, 0.17730883f, 0.19990170f, 
    -0.05853928f, 0.14070427f, 0.22021170f, 0.69352698f, -0.04408188f, -0.26775411f, -0.19758014f, 0.20451136f, 
    -0.27226794f, 0.25706962f, 0.04918159f, -0.07689837f, -0.29882360f, -0.12571375f, -0.01045161f, 0.23569775f, 
    -0.07241529f, -0.13865656f, 0.21941778f, -0.02257654f, 0.00410262f, -0.23265275f, 0.06509399f, 0.21222162f, 
    -0.06325379f, -0.20054698f, 0.13190648f, 0.23756641f, -0.20365676f, 0.07258111f, 0.02101076f, -0.22157994f, 
    0.30490300f, 0.07101066f, 0.15876798f, -0.18170829f, -0.09548961f, -0.39016202f, -0.04759505f, -0.21599333f, 
    -0.08512242f, 0.42604360f, -0.13642307f, -0.09205661f, 0.64123374f, -0.09035412f, -0.15122044f, -0.10009463f, 
    -0.15942274f, -0.21719220f, 0.20587865f, -0.11074913f, 0.00892561f, 0.08975560f, 0.18838757f, -0.22543535f, 
    0.06072403f, -0.14965951f, -0.08706066f, -0.10467005f, -0.20517330f, -0.08116263f, 0.15545022f, -0.01771364f, 
    -0.21957923f, -0.07062121f, 0.16123742f, -0.30246818f, -0.05107717f, 0.13932744f, 0.07056731f, 0.23115909f, 
    0.37489358f, 0.12130885f, -0.19224924f, -0.15053202f, 0.25005233f, 0.11032134f, 0.15819292f, 0.49771410f, 
    0.03027898f, 0.12688020f, -0.03652446f, -0.05973374f, 0.02062500f, -0.52551198f, 0.19193609f, -0.13760787f, 
    -0.18536162f, 0.19807760f, 0.31129968f, -0.24360593f, 0.27173403f, 0.23772646f, -0.15321366f, 0.15919548f, 
    -0.16682577f, -0.21818072f, -0.13757280f, 0.10450271f, 0.21075033f, 0.51912278f, -0.15662451f, 0.05003799f, 
    -0.40444630f, -0.16694501f, -0.28499827f, 0.47244158f, -0.23759370f, -0.03022393f, -0.02028587f, 0.27414539f, 
    0.29445383f, 0.03240159f, -0.13416637f, -0.28971979f, 0.24605496f, -0.29039994f, 0.10321832f, 0.01684362f, 
    -0.60255241f, 0.14086871f, 0.28734538f, 0.07172133f, 0.04644160f, 0.11086971f, -0.15585579f, 0.03187799f, 
    -0.24974509f, -0.08158806f, -0.07274532f, -0.31999514f, 0.23835965f, 0.24765860f, 0.23206054f, 0.17852929f, 
    -0.10721043f, -0.36563274f, 0.18514268f, -0.72362691f, -0.13051875f, 0.34882352f, 0.12494069f, -0.09354766f, 
    0.18481381f, 0.26046982f, 0.10480429f, 0.52948916f, -0.13816655f, -0.03790911f, 0.01394123f, -0.06435301f, 
    0.45064712f, 0.02875955f, -0.05801680f, 0.26747563f, -0.21068479f, 0.06976905f, 0.02484098f, -0.00476934f, 
    -0.27772990f, -0.05278641f, -0.00659004f, 0.00639324f, 0.13036916f, -0.28571868f, 0.22676997f, 0.17828554f, 
    -0.20833601f, 0.09639610f, -0.47734720f, 0.37631476f, 0.26359245f, -0.49314639f, 0.04383209f, 0.39490080f, 
    -0.08037727f, -0.18464211f, -0.18428631f, -0.00947407f, 0.43862620f, -0.24603735f, 0.22739354f, 0.20695613f, 
    -0.21337728f, 0.06024327f, 0.12358529f, 0.06650370f, -0.03188667f, -0.33639359f, -0.15251023f, 0.28547746f, 
    -0.18053256f, -0.24631725f, -0.05192158f, -0.12227312f, -0.27652347f, 0.06883211f, 0.13310201f, -0.16773632f, 
    0.50457388f, 0.27632201f, 0.12857999f, 0.16165850f, 0.09672309f, 0.21008737f, -0.22784597f, 0.38818276f, 
    0.40881455f, -0.15084606f, -0.04952550f, -0.45147046f, -0.11722682f, 0.08369821f, -0.09948771f, 0.18044096f, 
    -0.03377774f, 0.11460156f, 0.11593546f, 0.27611417f, 0.54965866f, -0.23987770f, 0.05621645f, 0.30157220f, 
    -0.22290877f, 0.07965040f, -0.12596402f, -0.05336050f, 0.34553891f, 0.22851190f, -0.25222957f, -0.06970084f, 
    -0.37910539f, 0.29920399f, 0.08577672f, -0.21803714f, 0.00369810f, -0.00578836f, -0.15027124f, -0.09465673f, 
    -0.12520914f, 0.12621237f, 0.03494710f, -0.15625833f, 0.09069906f, -0.02248028f, 0.02157770f, 0.22125632f, 
    0.17758714f, -0.20730676f, -0.13116126f, -0.05531672f, -0.27477688f, -0.09152635f, 0.00693883f, -0.15791366f, 
    0.12262016f, 0.17487454f, -0.14720806f, 0.01003653f, -0.08103202f, 0.27872124f, 0.11821440f, 0.22929104f, 
    0.16662639f, -0.05685970f, -0.50888008f, 0.51986241f, -0.30714223f, -0.24583407f, -0.19738743f, 0.33713615f, 
    -0.21389422f, 0.09171382f, -0.24201125f, 0.09756078f, -0.13742213f, -0.04969135f, -0.01452802f, 0.16634038f, 
    0.13523731f, -0.12721629f, 0.09840750f, -0.23502532f, -0.12369567f, -0.08669952f, -0.16915450f, -0.18757020f, 
    -0.01087033f, -0.04535881f, -0.05155951f, -0.11301313f, -0.00719527f, -0.24635351f, -0.10049027f, 0.11218980f, 
    0.15554622f, -0.14950275f, 0.16454223f, -0.15178713f, -0.16210076f, -0.21435308f, -0.01163876f, -0.19849423f, 
    -0.25398448f, 0.26505128f, -0.10212258f, 0.23648338f, -0.16588271f, -0.01178062f, 0.11078545f, -0.15665723f, 
    -0.15700218f, 0.31023911f, -0.21453814f, 0.10509448f, 0.60135609f, 0.24294780f, -0.21446151f, 0.37044483f, 
    0.30960387f, -0.08496982f, 0.14117190f, -0.10211656f, -0.04340222f, -0.00050102f, -0.15381503f, 0.23909955f, 
    -0.60901338f, -0.08167286f, 0.08057591f, 0.29063630f, -0.23348065f, 0.40934536f, 0.18854998f, 0.06335938f, 
    -0.08304534f, 0.05405623f, -0.10939162f, 0.12801123f, -0.23247622f, -0.04169262f, 0.18612273f, -0.15939997f, 
    -0.07474796f, -0.10171906f, 0.08491938f, 0.04974602f, 0.20781803f, -0.14168105f, -0.18450856f, -0.11588129f, 
    -0.18389714f, -0.18329300f, -0.11894177f, 0.03896404f, 0.40752518f, 0.00939951f, -0.01320373f, -0.12036874f, 
    -0.29444706f, -0.15660337f, 0.01024193f, -0.23368321f, 0.62980175f, -0.19478482f, 0.15263583f, 0.37198800f, 
    -0.26771200f, -0.05003465f, -0.15369581f, 0.09380616f, 0.15235193f, 0.04204577f, -0.09138145f, -0.09402160f, 
    0.00920675f, 0.08499783f, -0.15808211f, -0.22718790f, 0.43869054f, -0.04206239f, 0.16751991f, 0.38754091f, 
    -0.28401887f, 0.03241042f, -0.00273714f, 0.67548269f, -0.12444638f, 0.22957949f, -0.03422133f, -0.12109056f, 
    -0.44442013f, 0.11406696f, -0.31070301f, -0.01329197f, -0.29564506f, 0.43801230f, -0.20651223f, 0.20146529f, 
    0.21050006f, 0.00207124f, -0.02235753f, 0.32301638f, 0.29862794f, 0.05850942f, 0.15796089f, 0.07277815f, 
    -0.24842574f, -0.02891644f, 0.12496828f, -0.11190132f, -0.40541965f, -0.25859010f, -0.03116946f, -0.44252262f, 
    -0.09870353f, -0.15516761f, -0.10964972f, -0.08519712f, -0.22478649f, -0.10357931f, 0.19657618f, 0.02577814f, 
    -0.08894944f, -0.23571771f, -0.11556861f, 0.00738847f, 0.00737095f, -0.09628394f, -0.06103587f, 0.03992391f, 
    0.36594158f, -0.07881477f, -0.14594348f, 0.15483108f, 0.14158820f, -0.40359133f, 0.08261909f, -0.04198864f, 
    0.32593229f, 0.08934754f, 0.18339387f, 0.02676809f, -0.34864566f, -0.30291638f, 0.12987329f, 0.07455502f, 
    0.12011401f, -0.21697865f, -0.13211937f, 0.42384720f, 0.12052900f, 0.40294465f, 0.01130207f, 0.07940315f, 
    -0.33164465f, 0.17777932f, 0.16906358f, 0.17512807f, -0.52514458f, -0.38258672f, -0.12461413f, 0.25155613f, 
    0.13780986f, -0.09586482f, -0.02711076f, 0.40440860f, -0.20285028f, -0.06242352f, -0.04473969f, -0.08082785f, 
    -0.25697646f, -0.00305381f, -0.21961486f, 0.15525141f, 0.41092402f, 0.14837451f, 0.10943442f, 0.11316036f, 
    0.12057166f, -0.11192809f, 0.14140582f, 0.26417208f, 0.09769524f, 0.34696317f, 0.25035137f, 0.15808895f, 
    -0.48746896f, 0.14108649f, 0.05430470f, -0.13844940f, -0.36979759f, 0.07884880f, -0.05934778f, -0.10665023f, 
    0.00031313f, -0.13244076f, 0.13738433f, 0.28144595f, 0.29859298f, -0.32189649f, -0.10456100f, -0.23725432f, 
    -0.10895396f, 0.03147333f, 0.55754524f, 0.54935437f, -0.32557288f, -0.33639279f, 0.19044968f, 0.53962344f, 
    -0.22022580f, 0.21871418f, 0.10781758f, -0.25389171f, 0.37002939f, 0.06715663f, -0.13888745f, 0.14497809f, 
    0.00005612f, -0.12890711f, -0.31569153f, 0.17994598f, 0.43962756f, -0.60012960f, -0.00176028f, 0.23051953f, 
    -0.28005454f, -0.08389276f, 0.01393077f, 0.11475960f, 0.19391407f, -0.07146214f, 0.09318426f, -0.01563810f, 
    0.09105317f, 0.38334179f, -0.23665909f, -0.28238624f, 0.30281833f, 0.27691543f, 0.08125927f, -0.16494994f, 
    -0.15590046f, -0.00278774f, 0.15932146f, -0.18253310f, 0.27555272f, -0.41517344f, -0.20958720f, -0.17073971f, 
    -0.20182663f, 0.24511538f, 0.45117924f, -0.37867901f, 0.50618494f, -0.26359758f, -0.18971413f, 0.47271836f, 
    -0.03386050f, -0.18443060f, 0.12232804f, 0.20432507f, -0.22353745f, 0.18759663f, 0.19333108f, -0.23106806f, 
    0.18567280f, 0.24969444f, -0.03312145f, 0.22012821f, 0.50084227f, -0.25097358f, -0.07206678f, 0.24597770f, 
    -0.19408606f, 0.16168815f, -0.11328668f, 0.46732309f, -0.20705363f, 0.39232200f, 0.25153089f, -0.02700878f, 
    -0.07701981f, 0.22034757f, -0.83080935f, 0.25653189f, 0.25144801f, 0.31522682f, 0.07946645f, -0.06706295f, 
    -0.11284313f, -0.21425064f, 0.16116829f, 0.10336653f, 0.08079940f, 0.10823178f, 0.08163577f, -0.07399958f, 
    -0.52191776f, 0.32347745f, -0.11644466f, -0.02796590f, 0.08865250f, 0.07102991f, -0.09211174f, -0.14905697f, 
    0.12809946f, 0.18610075f, -0.00092207f, 0.12123708f, -0.20872265f, -0.45639646f, 0.18265510f, 0.05693378f, 
    -0.08338137f, 0.33189449f, 0.36788648f, -0.21239612f, 0.22977686f, 0.22077546f, -0.13337500f, 0.14255393f, 
    -0.19106330f, 0.10928124f, 0.22901116f, 0.20892143f, -0.22082700f, -0.02487311f, -0.10199699f, 0.15226205f, 
    0.14602746f, 0.01283900f, -0.10015813f, 0.12281059f, -0.21729654f, 0.10687076f, -0.13066654f, -0.23294315f, 
    0.21014538f, 0.23784210f, 0.06352220f, 0.29327625f, 0.24935706f, -0.44527552f, -0.07921446f, 0.09192079f, 
    0.36253214f, 0.01472930f, -0.19459546f, 0.07483689f, -0.43035772f, -0.17066903f, -0.20530431f, -0.08628780f, 
    0.25937065f, 0.24286380f, -0.08362591f, -0.29080120f, 0.10127824f, 0.24456587f, -0.04058065f, -0.04175401f, 
    0.46349096f, -0.28961313f, -0.25298786f, 0.33897120f, 0.12058349f, 0.12850831f, -0.22635102f, -0.20268631f, 
    0.26321384f, -0.11657990f, 0.05923301f, 0.09998381f, 0.05057874f, -0.50777286f, -0.17558792f, -0.10460384f, 
    -0.02838675f, 0.31969824f, -0.01790357f, -0.20909271f, 0.00092808f, 0.23603219f, 0.17055589f, -0.31618816f, 
    -0.10852990f, -0.02110461f, -0.06807903f, -0.12879571f, 0.20076613f, 0.37199080f, -0.23560411f, -0.19261612f, 
    -0.42193004f, -0.00813809f, -0.13289598f, -0.18037970f, 0.10693780f, 0.20952824f, -0.19339743f, -0.08558362f, 
    -0.06312799f, 0.03429710f, -0.18286681f, -0.14718138f, -0.13395901f, -0.32863328f, 0.18395333f, -0.05471939f, 
    0.25097427f, 0.11095324f, 0.30459428f, 0.20443222f, 0.03444188f, -0.12462131f, 0.13059388f, 0.57080001f, 
    0.37030911f, -0.12774760f, 0.06778911f, -0.15705344f, 0.10243473f, -0.20164225f, -0.10302661f, -0.08453639f, 
    0.30625233f, -0.02836818f, -0.26730013f, 0.00300401f, 0.31147891f, 0.14900260f, 0.09709418f, -0.41391605f, 
    -0.10717883f, -0.01652056f, -0.15896079f, -0.39702708f, -0.02915885f, 0.02099164f, -0.12069120f, -0.04830238f, 
    0.02860701f, -0.24095845f, 0.37053126f, 0.51441693f, -0.05292446f, 0.29529756f, 0.12138268f, 0.04026924f, 
    0.46911684f, 0.15278125f, -0.19668326f, -0.03061379f, -0.26385751f, -0.68004221f, -0.04051133f, 0.12574753f, 
    0.17465210f, -0.02131003f, -0.08675020f, -0.03292831f, -0.06169990f, 0.22530292f, -0.07263434f, 0.31410357f, 
    0.20007505f, -0.06144139f, -0.09245750f, 0.29397517f, 0.23648681f, 0.03427457f, -0.04282740f, -0.15474130f, 
    -0.13047934f, 0.15987372f, -0.41842955f, -0.20483574f, 0.16342708f, -0.09009767f, -0.13842168f, -0.47340095f, 
    0.27511108f, -0.21864477f, 0.15137056f, 0.15472740f, 0.24814801f, -0.04731966f, -0.05588205f, -0.21007714f, 
    -0.31555933f, 0.29446259f, -0.11330017f, -0.29781681f, -0.50113630f, -0.11295784f, -0.06446177f, -0.23344611f, 
    -0.11209559f, 0.21616331f, -0.01363236f, 0.35003006f, -0.26335201f, 0.19259213f, 0.07973993f, 0.13063228f, 
    0.05002232f, 0.16540951f, -0.08739991f, 0.21305797f, -0.02638045f, 0.37227452f, 0.13183132f, 0.11399069f, 
    -0.02499020f, 0.20951930f, -0.13933283f, 0.02851900f, -0.02077470f, -0.01018938f, 0.25048375f, 0.19273518f, 
    0.50593346f, -0.14153172f, -0.29780489f, 0.41880941f, 0.16631369f, 0.06374664f, 0.08855210f, -0.10921112f, 
    -0.14534293f, -0.04913556f, 0.19967458f, -0.12134873f, 0.05608789f, 0.28958690f, -0.08654976f, -0.05533938f, 
    0.34473506f, -0.12262461f, -0.13858531f, 0.34950042f, 0.18930948f, -0.26302409f, -0.02294429f, 0.41812757f, 
    0.43760920f, -0.02057355f, 0.19671567f, -0.35716364f, 0.14982615f, 0.02891176f, -0.09569663f, -0.24597445f, 
    -0.32704058f, -0.05014385f, -0.47041774f, 0.04397390f, 0.23690332f, -0.23240103f, -0.08587838f, 0.01902115f, 
    0.40695882f, -0.19453861f, -0.10109631f, -0.09243965f, -0.12214411f, -0.25834405f, 0.11197748f, 0.11457636f, 
    0.36115441f, 0.01374160f, 0.23748398f, 0.30316332f, 0.33064789f, -0.18552561f, 0.08131899f, -0.32847178f, 
    0.04855705f, 0.04994303f, 0.06514928f, 0.26500410f, 0.19153333f, -0.43289340f, 0.02976749f, 0.22951300f, 
    -0.27183843f, 0.26531553f, -0.66693997f, -0.27527997f, 0.31951010f, 0.39447039f, 0.08040995f, -0.23808734f, 
    -0.20079626f, -0.01912499f, 0.18338299f, 0.34374726f, -0.31985909f, -0.14703169f, 0.03413517f, 0.10537557f, 
    -0.02181056f, -0.02739013f, 0.00731620f, 0.43353626f, -0.29715660f, 0.00095971f, 0.13113785f, 0.35514432f, 
    0.18800442f, -0.21135755f, -0.24151492f, -0.00523321f, 0.27303720f, 0.34490281f, 0.09716669f, 0.17216867f, 
    -0.21575966f, -0.10301057f, -0.53454530f, -0.27150470f, 0.01778030f, -0.25183132f, 0.07800197f, -0.16344486f, 
    0.28369811f, -0.20340286f, -0.15806447f, -0.07521641f, 0.01462515f, 0.08825725f, 0.03968515f, 0.19133362f, 
    0.43016914f, -0.09807356f, -0.23411055f, 0.55533123f, 0.19567242f, -0.30447409f, 0.15597327f, -0.03720179f, 
    0.25048587f, 0.23171841f, 0.15483648f, 0.56592214f, -0.25159028f, -0.41921717f, 0.21573406f, -0.06938541f, 
    0.19507080f, 0.15517810f, -0.25255626f, -0.07264415f, 0.17796075f, 0.10788434f, -0.11670735f, -0.24735074f, 
    -0.16260837f, 0.01465353f, -0.14923462f, -0.10741238f, 0.01051038f, 0.12478707f, 0.10168761f, -0.05767572f, 
    -0.26718327f, -0.10311475f, -0.19846341f, -0.24643981f, -0.09966459f, 0.04210050f, 0.04895025f, -0.24114902f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13558400f, 0.40072304f, -0.40602714f, 0.62756425f, -0.05276260f, 0.40369573f, -0.17200619f, -0.35262460f, 
    0.10788334f, 0.26948729f, -0.07342154f, 0.10368001f, 0.39066830f, -0.11511581f, 0.27668440f, -0.07639947f, 
    -0.01424597f, 0.02687274f, 0.08805510f, -0.07372130f, 0.11204731f, 0.12828861f, -0.18275094f, 0.17572004f, 
    0.18958209f, -0.02316676f, 0.09058885f, 0.50784189f, 0.19411717f, -0.18013808f, 0.43213567f, 0.45071203f, 
    0.38739669f, 0.22211279f, 0.42432499f, 0.17235833f, 0.26176950f, 0.07428139f, -0.09903126f, -0.03417224f, 
    0.36575544f, 0.30500907f, 0.14856559f, 0.34362251f, -0.59326583f, 0.29348272f, 0.22813091f, 0.14832613f, 
    -0.01137012f, -0.28046542f, 0.01263582f, 0.44355294f, 0.39661860f, -0.10655595f, 0.01881198f, -0.11216729f, 
    0.35251185f, -0.18654650f, 0.48910075f, 0.05719107f, 0.01258521f, -0.39640024f, 0.09086457f, -0.14529853f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00241944f, -0.16739525f, 0.05179525f, 0.03324021f, 0.06751764f, -0.12674542f, -0.08711687f, -0.00780980f, 
    -0.14197831f, -0.05701391f, 0.02887885f, 0.04238254f, -0.04171531f, 0.07846703f, -0.09732564f, -0.04520915f, 
    -0.03176611f, -0.17649668f, 0.08185574f, -0.08432367f, 0.09930268f, -0.07247970f, -0.05750044f, -0.12771508f, 
    0.09701838f, -0.05706523f, -0.13552469f, 0.03841306f, 0.03412767f, -0.04783531f, -0.08368493f, 0.00938863f, 
    0.04638116f, 0.03703137f, -0.09880590f, -0.09931880f, -0.16843560f, 0.01791787f, 0.02104467f, -0.04304038f, 
    -0.06092175f, -0.06884222f, 0.03885452f, 0.00651185f, -0.02017062f, 0.09283744f, -0.13982293f, -0.05719454f, 
    -0.12146978f, 0.00453841f, -0.00498845f, -0.06997930f, -0.11911768f, 0.04644419f, 0.00633636f, 0.00935305f, 
    -0.14242348f, 0.03026158f, -0.07889792f, -0.11592137f, -0.04492728f, 0.06924570f, -0.11360864f, 0.02708097f, 
    -0.07119043f, 0.12806326f, 0.36536399f, 0.07868543f, 0.08022863f, -0.05844497f, 0.09191429f, 0.16374448f, 
    -0.07853374f, 0.20167446f, -0.38039839f, -0.18685411f, 0.02250672f, 0.09341015f, 0.02018976f, 0.04018394f, 
    -0.10480823f, -0.01770191f, -0.05664433f, 0.18051921f, -0.08504443f, 0.11158115f, 0.40266141f, -0.03721657f, 
    -0.07060502f, -0.00813292f, 0.21002510f, 0.55085260f, -0.29896235f, 0.12407243f, -0.29692829f, 0.05414982f, 
    0.11768605f, -0.02698799f, -0.04689414f, 0.12177434f, -0.03531493f, -0.29533890f, 0.17940377f, 0.83583701f, 
    0.02825924f, -0.08214848f, -0.04740535f, -0.18695071f, -0.05861798f, -0.21830347f, 0.17599468f, 0.07961721f, 
    -0.02973937f, -0.12774529f, 0.21009701f, -0.09838927f, -0.31623027f, 0.21032538f, 0.19208349f, 0.24501516f, 
    0.06446771f, -0.31474432f, 0.01210609f, 0.19359858f, 0.22898880f, 0.16013299f, 0.00746453f, -0.10185348f, 
    -0.04850130f, 0.04801106f, 0.05627623f, 0.04751671f, -0.11352050f, -0.10987911f, 0.10091081f, -0.08643181f, 
    -0.09475699f, -0.13554780f, -0.00792424f, 0.06410457f, -0.09752251f, -0.01672924f, -0.14660992f, 0.06783565f, 
    -0.12803298f, -0.13733701f, 0.08344419f, -0.01405311f, -0.06309670f, 0.07459101f, -0.14973220f, 0.06625828f, 
    -0.05190991f, 0.03282838f, -0.18190019f, 0.10162687f, -0.01082076f, -0.03101788f, -0.07086600f, 0.02124022f, 
    -0.06082692f, -0.06123953f, 0.03469633f, 0.05433193f, -0.02831328f, 0.09180792f, 0.07379805f, -0.13801144f, 
    0.09833840f, 0.05903445f, -0.08991773f, -0.13369593f, -0.05501093f, 0.00095709f, -0.04064845f, -0.11869156f, 
    -0.03914798f, -0.04382220f, -0.07148999f, 0.05564244f, 0.03115063f, 0.03939350f, 0.04634690f, -0.09098971f, 
    -0.06345191f, -0.06374875f, -0.06881283f, 0.03759009f, -0.06576511f, -0.03330839f, -0.06178345f, 0.11794168f, 
    -0.06645003f, 0.01894212f, -0.07234164f, 0.01647511f, -0.12357353f, 0.02395169f, 0.11050300f, 0.01224186f, 
    0.03983031f, -0.12804852f, -0.08727874f, 0.10270590f, 0.10478838f, 0.06255479f, -0.06296403f, -0.11250031f, 
    0.02625127f, -0.01848152f, 0.03961772f, 0.08390729f, -0.02417767f, -0.12057528f, 0.01341004f, -0.11641461f, 
    -0.04105118f, -0.04399544f, 0.05322450f, -0.04519532f, 0.07379057f, -0.00129433f, -0.07422143f, -0.00787867f, 
    -0.06324583f, -0.10684438f, -0.10808973f, -0.06146073f, -0.06763309f, -0.12116676f, 0.07048292f, -0.06892946f, 
    0.02917588f, 0.00512451f, -0.10056735f, -0.03064586f, -0.12446614f, -0.09243539f, 0.10866228f, -0.02590939f, 
    -0.04609725f, -0.09631988f, 0.03974809f, -0.03569466f, 0.00858603f, 0.00513809f, 0.01716736f, -0.07755093f, 
    -0.13341697f, -0.05023987f, 0.01871189f, 0.07872082f, 0.09131771f, 0.05550343f, 0.07457601f, 0.04879978f, 
    -0.03804764f, -0.10918597f, -0.07943574f, -0.05683578f, -0.10122132f, 0.08630386f, -0.07043438f, 0.11228435f, 
    -0.09009923f, -0.04815623f, -0.06596368f, -0.10354932f, -0.10595440f, -0.09732961f, 0.12250249f, -0.09039226f, 
    0.03669752f, -0.06346669f, 0.10117309f, 0.03134170f, 0.01556954f, 0.02726039f, -0.09867227f, 0.03801664f, 
    -0.08657026f, -0.10711463f, 0.06665123f, -0.04438759f, -0.10198414f, -0.08250290f, -0.07010149f, 0.00106128f, 
    0.01981719f, -0.08596532f, -0.06840716f, 0.02287657f, -0.00540039f, 0.04928170f, -0.01383287f, -0.06390546f, 
    0.10351426f, 0.11267170f, -0.03285772f, -0.05800153f, -0.07965693f, 0.03529545f, -0.04232159f, 0.03486926f, 
    0.03572288f, -0.03519633f, 0.06839269f, -0.08330993f, 0.10021344f, 0.04472832f, -0.02957409f, -0.02418432f, 
    0.06508598f, -0.07807544f, -0.08447497f, 0.04536762f, 0.07735775f, -0.02466990f, 0.03763314f, 0.10859966f, 
    0.10126030f, -0.30099463f, -0.32523128f, 0.02270016f, 0.10899261f, 0.45998544f, -0.01400588f, -0.11825507f, 
    0.01598712f, 0.10298960f, 0.38197267f, 0.17430680f, 0.00596193f, -0.03640401f, 0.05823013f, -0.44698244f, 
    0.12279084f, 0.08407282f, -0.01891337f, -0.11379965f, 0.04057570f, -0.03401653f, -0.06586904f, 0.50911134f, 
    -0.07610888f, 0.08958784f, -0.04799765f, -0.20312037f, 0.13849249f, 0.08462182f, 0.01218021f, 0.05627812f, 
    0.18351746f, 0.14023244f, 0.12980819f, -0.02566312f, 0.07414749f, 0.08455226f, 0.04181738f, -0.05949418f, 
    0.27083039f, 0.07605215f, -0.05336807f, 0.18744291f, -0.15952882f, 0.33729485f, -0.00564832f, -0.12962903f, 
    0.05073529f, -0.27003589f, 0.18454900f, 0.19603750f, 0.36584795f, -0.35447633f, -0.22390859f, -0.27581656f, 
    0.58523095f, 0.18110201f, 0.24567991f, -0.01234344f, 0.32423195f, 0.02299288f, 0.20666726f, 0.10698219f, 
    0.41797668f, 0.16836661f, -0.12443963f, 0.34291309f, -0.01071332f, 0.09686622f, 0.07760176f, 0.25180265f, 
    0.05355193f, -0.44804531f, -0.13480152f, 0.19927122f, 0.15202388f, -0.48226210f, -0.10772041f, 0.28186840f, 
    -0.00833915f, 0.03568509f, -0.01745086f, -0.21585566f, -0.04680441f, -0.06456941f, 0.11486600f, -0.61271292f, 
    -0.06191451f, -0.08373301f, 0.04410453f, 0.20174572f, 0.01108489f, 0.10106328f, 0.31095091f, 0.09551185f, 
    0.09520753f, -0.32046619f, 0.21351257f, -0.55132842f, 0.13044091f, 0.25930271f, -0.01495951f, -0.47353494f, 
    -0.17816558f, 0.20133755f, -0.10648159f, 0.16285136f, -0.28952801f, -0.03665366f, -0.05096820f, 0.35344070f, 
    -0.03531153f, 0.07482024f, 0.49318388f, -0.10490472f, 0.09421860f, -0.03882061f, -0.20497897f, 0.08611590f, 
    -0.56908798f, -0.05481271f, -0.12436925f, 0.17352052f, -0.48171669f, -0.08069795f, 0.36562571f, -0.09900674f, 
    0.43426034f, -0.19386612f, -0.63171756f, 0.07636240f, 0.00972018f, 0.58172995f, 0.08304219f, 0.09199808f, 
    0.12542081f, -0.03899539f, 0.30208486f, -0.33050999f, -0.11270045f, -0.29304162f, -0.17281824f, -0.01342935f, 
    0.29411325f, -0.16948591f, -0.08647513f, -0.21958575f, 0.01673064f, -0.02476586f, 0.55413973f, 0.16561632f, 
    0.04450773f, 0.18646935f, 0.02452406f, -0.16761692f, -0.23286816f, 0.11946110f, -0.07029440f, -0.05160299f, 
    0.17222184f, -0.31459177f, 0.01846804f, -0.28450689f, 0.06414473f, 0.39717472f, 0.14856501f, 0.10954310f, 
    0.16229275f, 0.33410278f, -0.04738858f, -0.10944638f, -0.40498310f, 0.17685649f, -0.09063249f, -0.02518069f, 
    -0.06376693f, -0.21076125f, 0.52927583f, 0.09632377f, 0.07899655f, -0.08933132f, -0.24900945f, -0.14422761f, 
    0.53464890f, 0.13545457f, 0.15949568f, -0.11544262f, -0.18063477f, 0.04376889f, 0.35500705f, 0.00543755f, 
    0.02507291f, -0.00279580f, -0.08270230f, 0.66099662f, -0.09295860f, -0.11816215f, -0.04210056f, -0.53865260f, 
    -0.21220575f, 0.24816453f, -0.02458164f, -1.00485134f, 0.02573372f, 0.48192677f, 0.27829620f, -0.52770567f, 
    -1.02785063f, 0.00074825f, 0.01393250f, 0.21224265f, 0.02087377f, -0.05911516f, 0.23573148f, -0.13102044f, 
    0.00998349f, -0.15718189f, -0.08010422f, 0.55854261f, 0.29033548f, -0.05901682f, 0.23290257f, 0.34588787f, 
    0.27641919f, 0.17144181f, 0.27110967f, 0.20807806f, -0.14258267f, -0.01002447f, -0.05741280f, 0.38217479f, 
    -0.00605249f, -0.06905928f, 0.11997700f, 0.28705895f, -0.96214575f, 0.12954248f, -0.38139319f, -0.05438881f, 
    -0.34910065f, -0.70531183f, -0.66083914f, 0.14617030f, 0.33765513f, -0.04385013f, -0.43668154f, -0.30906132f, 
    -0.01663153f, -0.40673098f, 0.21852142f, 0.25869235f, 0.09446748f, -0.21008362f, 0.34090036f, 0.06956596f, 
    -0.05073723f, -0.12835704f, 0.06352573f, 0.07819126f, -0.01623012f, 0.09497815f, -0.07132389f, -0.05581783f, 
    0.05302548f, -0.01339948f, -0.13711275f, 0.07942851f, 0.00317788f, -0.04332128f, -0.07189030f, -0.11140279f, 
    0.08894651f, -0.12834717f, 0.04715219f, -0.01588414f, 0.02202255f, 0.01379231f, 0.00075935f, -0.04207734f, 
    0.08834901f, 0.01958412f, 0.08770382f, -0.14369066f, 0.04032234f, -0.09142169f, 0.07323538f, -0.01005179f, 
    -0.14902599f, -0.03818924f, -0.08637391f, -0.11762629f, -0.11252689f, -0.14899689f, -0.08587646f, -0.03138922f, 
    -0.13259268f, 0.06803025f, -0.00875945f, 0.06774245f, -0.03338148f, -0.08211058f, -0.14161831f, 0.09992256f, 
    -0.11750104f, 0.01758572f, -0.08813009f, 0.09578231f, 0.09064792f, 0.00871165f, -0.12929854f, -0.04120991f, 
    0.09996375f, -0.13571472f, 0.04528394f, 0.03373671f, -0.02075461f, -0.11015394f, 0.04170232f, -0.07984364f, 
    -0.10267396f, -0.03933334f, 0.11039721f, -0.12332191f, -0.06154184f, -0.05933913f, -0.03139207f, 0.03599975f, 
    -0.07545512f, 0.02610132f, -0.03092469f, 0.03191584f, -0.06267762f, -0.07795200f, 0.04905541f, -0.09671609f, 
    -0.11082400f, -0.10179119f, 0.01728380f, 0.04092532f, -0.12377338f, 0.07724434f, -0.00073304f, -0.05465647f, 
    0.09725950f, -0.12055001f, 0.06926735f, 0.00741586f, 0.06581725f, -0.01468170f, 0.04132198f, -0.13631114f, 
    0.11039387f, -0.01722041f, -0.08791676f, -0.05331549f, -0.02162903f, 0.10742845f, 0.00862535f, -0.06678601f, 
    -0.05588345f, -0.13770950f, -0.10152946f, -0.11556217f, -0.09755589f, 0.09664690f, -0.01580636f, 0.07923520f, 
    -0.10986407f, 0.00143582f, -0.08402689f, 0.04791039f, 0.11859250f, 0.05605875f, 0.04463677f, 0.03339405f, 
    0.08615809f, -0.04849442f, -0.01173145f, -0.02499438f, 0.03269741f, 0.07299913f, 0.01932535f, -0.05527765f, 
    -0.16588588f, 0.01578204f, 0.05441816f, 0.26975659f, 0.07534982f, -0.09938562f, 0.08878879f, -0.26427364f, 
    0.19230181f, 0.17280191f, 0.22860113f, 0.11594751f, 0.08284850f, -0.09451327f, 0.23045129f, -0.30180845f, 
    -0.19849038f, 0.07023155f, -0.03783322f, -0.19764860f, 0.03255271f, -0.09064871f, -0.12843972f, 0.67654014f, 
    0.03464378f, 0.12568614f, 0.05808692f, 0.36666301f, 0.47190130f, -0.06743184f, 0.05763794f, 0.23748815f, 
    0.13543554f, 0.40889800f, 0.20503905f, -0.38602355f, -0.01109427f, 0.02168802f, -0.18231028f, -0.11110152f, 
    0.33480069f, 0.15930517f, -0.08322571f, 0.10006177f, -0.19401808f, 0.30075148f, 0.25628325f, -0.24763721f, 
    -0.02773946f, 0.21285486f, -0.47842282f, 0.16036318f, 0.45500606f, 0.08513573f, -0.24390431f, -0.32848331f, 
    -0.29969415f, -0.15372898f, 0.23172176f, -0.08652733f, -0.26872015f, -0.25481534f, 0.06249367f, 0.15522070f, 
    0.41170034f, -0.02152657f, -0.24881679f, -0.05561106f, 0.12457472f, 0.29243901f, -0.00015716f, -0.00196306f, 
    0.10675928f, 0.00841061f, -0.04374654f, -0.49285066f, 0.19098827f, 0.05211144f, -0.05005471f, 0.16390558f, 
    0.29979602f, -0.02284034f, 0.03164420f, -0.08296684f, -0.01324636f, -0.05453257f, 0.38407189f, -0.24719974f, 
    0.04648761f, 0.03500726f, 0.19906756f, 0.02684382f, 0.00622181f, 0.05276105f, 0.29438743f, 0.14483066f, 
    0.16336569f, -0.14768505f, 0.13094223f, -0.06794816f, -0.09718824f, 0.32372564f, 0.19938815f, 0.12035514f, 
    -0.05072668f, 0.37039366f, 0.05655473f, 0.20658609f, -0.19960153f, 0.19268948f, -0.18749608f, 0.20793344f, 
    0.10598272f, -0.09199134f, 0.27611563f, 0.08824331f, -0.19778460f, -0.11262693f, 0.42451894f, 0.32085237f, 
    -0.02150204f, 0.32204881f, 0.07444260f, 0.20743030f, -0.14368144f, 0.40301946f, 0.42051142f, 0.12273695f, 
    -0.03167903f, -0.11325338f, -0.07624586f, -0.15725029f, 0.03076477f, 0.03057304f, 0.12372172f, 0.03767541f, 
    -0.09770001f, -0.08554658f, -0.07718232f, 0.03070445f, -0.10245831f, -0.13337313f, -0.10648114f, 0.00857197f, 
    -0.06457065f, -0.09708153f, -0.03451132f, 0.07248724f, -0.11473792f, 0.08614625f, 0.12265031f, 0.02192214f, 
    0.01049151f, 0.10931923f, 0.11204098f, -0.10777360f, -0.14238434f, -0.01746477f, -0.17391828f, -0.18505219f, 
    0.01354830f, -0.02137544f, -0.16472374f, 0.06722050f, 0.08161114f, 0.08099774f, -0.02196448f, 0.20346873f, 
    0.07483561f, -0.16753013f, -0.06476361f, 0.03104820f, -0.01615186f, -0.13705143f, 0.06829184f, 0.04067736f, 
    -0.04752711f, 0.09027809f, 0.01237335f, 0.01482338f, -0.00677324f, -0.15659854f, -0.10549773f, 0.04256695f, 
    0.06167883f, -0.09542213f, -0.05081801f, 0.04475047f, 0.14387599f, 0.07729292f, -0.01920232f, 0.05281560f, 
    -0.01937975f, -0.13202897f, -0.00131624f, 0.03913366f, 0.01308280f, 0.00094861f, -0.00244768f, -0.14645463f, 
    -0.07315146f, -0.15293446f, -0.03088784f, 0.00069936f, 0.05769321f, -0.02947784f, 0.05802251f, 0.04361382f, 
    -0.03903521f, 0.04885947f, 0.10446042f, -0.09647123f, 0.07092617f, -0.00611354f, 0.03652794f, 0.07359871f, 
    -0.10604990f, 0.00429501f, -0.02128119f, 0.10368461f, 0.03695267f, -0.00454205f, 0.01640745f, -0.15800422f, 
    -0.09257885f, 0.02581295f, -0.08426365f, -0.14099045f, -0.11511161f, 0.02307207f, -0.10869172f, 0.03174312f, 
    0.03470101f, -0.17855382f, -0.06361989f, 0.01000455f, 0.01292927f, -0.04139911f, -0.06072396f, 0.02762691f, 
    0.04838558f, -0.07083986f, -0.03534437f, -0.15427086f, 0.05965883f, -0.05245283f, 0.00047799f, -0.02992480f, 
    -0.11538847f, -0.00439416f, -0.05252258f, 0.05392006f, 0.03744085f, 0.05844927f, -0.08645469f, 0.03938933f, 
    0.02011976f, -0.23940796f, 0.32872894f, 0.30938053f, 0.06349771f, -0.30814469f, -0.04026663f, -0.19063194f, 
    -0.50362527f, 0.23182544f, -0.17020497f, -0.02024678f, 0.25447416f, 0.43812826f, 0.15785122f, 0.11153316f, 
    -0.04357543f, -0.23562844f, 0.04125659f, 0.38060787f, -0.00052679f, -0.05698086f, 0.03550064f, -0.20778736f, 
    -0.01081876f, -0.10248821f, -0.07460283f, 0.16765571f, -0.09603015f, -0.11257651f, 0.23956606f, 0.30333099f, 
    0.01223674f, -0.08879114f, 0.33609498f, 0.62202340f, -0.21759529f, 0.04090786f, 0.06090261f, 0.24720103f, 
    -0.08016841f, -0.51928550f, -0.09089397f, 0.28701147f, 0.19569679f, -0.26044750f, -0.29325321f, 0.31317055f, 
    -0.23497428f, 0.27710795f, -0.26134124f, -0.12436167f, -0.09496316f, 0.05032095f, 0.38542184f, 0.38867190f, 
    -0.15290652f, -0.07886640f, -0.11737880f, 0.33943254f, -0.16534337f, 0.19230913f, 0.00914881f, 0.00733244f, 
    0.03791709f, -0.26777965f, 0.19149083f, 0.09433736f, 0.05690217f, -0.46068460f, 0.02483949f, 0.04777407f, 
    -0.16928676f, 0.12776820f, 0.14397417f, -0.11950120f, 0.06387119f, 0.26916721f, 0.27650446f, 0.04566310f, 
    -0.01048287f, -0.04972160f, -0.10945864f, 0.17823473f, -0.10472444f, -0.01277822f, 0.05990783f, 0.12359191f, 
    -0.03165032f, 0.30869219f, 0.20407937f, 0.11994445f, -0.23319219f, -0.09111078f, 0.09665663f, 0.09195240f, 
    0.11316153f, -0.12861739f, 0.20743607f, 0.25626260f, -0.40048665f, 0.34462407f, 0.02035671f, 0.02755389f, 
    -0.21140176f, -0.43867910f, 0.00091833f, -0.02554030f, -0.17649835f, -0.59040457f, 0.56204093f, 0.14707699f, 
    -0.57122290f, 0.45035681f, -0.16664907f, -0.40177104f, -0.30920035f, -0.25826323f, -0.13372062f, 0.13946103f, 
    -0.11165705f, -0.40994477f, -0.33297393f, 0.17928049f, -0.24256735f, 0.02388630f, -0.35054013f, -0.11057857f, 
    -0.16350770f, 0.02642103f, -0.06328180f, 0.24820529f, 0.04969692f, 0.07298985f, 0.10109675f, -0.07766832f, 
    0.06668249f, 0.03747759f, 0.21897769f, -0.53932291f, 0.17602925f, 0.35711685f, 0.52209342f, 0.26361468f, 
    0.01966003f, -0.00291047f, -0.07011510f, 0.02254045f, 0.07830980f, 0.11369784f, 0.05521788f, -0.03048472f, 
    -0.11866023f, 0.31882149f, 0.10373709f, -0.21137722f, -0.05128757f, 0.10756691f, 0.24250089f, 0.21717863f, 
    -0.06671238f, 0.04717547f, 0.45216605f, 0.49861497f, -0.02859806f, 0.50385070f, 0.07218472f, -0.67070258f, 
    0.01032828f, 0.11496536f, -0.01602284f, 0.02887828f, -0.14268406f, 0.14094354f, -0.21333545f, 0.23264012f, 
    -0.06963500f, 0.44688210f, -0.60848159f, -0.14175373f, 0.13189682f, -0.15371245f, 0.10967547f, 0.11421610f, 
    0.03629069f, -0.08784126f, 0.04934954f, -0.20831458f, -0.26581493f, 0.08289117f, -0.25423074f, 0.08793006f, 
    -0.08544952f, -0.03155843f, -0.15033248f, 0.10806227f, -0.10874586f, -0.10434029f, 0.04441810f, 0.03995867f, 
    0.06067703f, -0.05276311f, -0.03868327f, 0.02837571f, -0.08207131f, -0.01790314f, 0.07471341f, 0.01515476f, 
    0.07494555f, 0.07936291f, -0.03263691f, 0.09191507f, -0.01310604f, 0.08129965f, -0.13734169f, 0.07169292f, 
    -0.01652592f, -0.06861699f, -0.02829998f, 0.07970629f, -0.11650808f, 0.03885294f, -0.05741817f, -0.11275626f, 
    -0.09732167f, -0.14822917f, -0.01302765f, -0.08993962f, 0.05380079f, -0.01517718f, 0.09548303f, 0.11809351f, 
    -0.08101091f, 0.08861698f, 0.10891492f, 0.09219855f, -0.11736929f, 0.07023748f, -0.01800000f, -0.08222435f, 
    -0.06348937f, -0.02282516f, -0.03111943f, -0.08106714f, -0.10800639f, -0.13079795f, 0.00612522f, -0.03028066f, 
    -0.07651005f, -0.02322501f, 0.11058570f, 0.13474683f, -0.04251602f, -0.02114094f, -0.02010508f, 0.05586585f, 
    0.05072949f, 0.16204076f, 0.11693668f, 0.27360502f, -0.07092945f, -0.08061575f, -0.14124773f, 0.05357769f, 
    0.03335559f, -0.01331597f, 0.31541213f, 0.16899158f, 0.01642830f, -0.17150366f, -0.00027117f, 0.08832286f, 
    -0.10269687f, 0.16883877f, -0.03829324f, -0.10950503f, -0.07922427f, -0.10937123f, -0.10232887f, 0.48268738f, 
    0.09318685f, -0.05253057f, -0.01889813f, 0.24374756f, 0.27555946f, 0.07236099f, 0.16877593f, 0.07088095f, 
    -0.07956804f, 0.19234905f, 0.09972205f, -0.31620982f, 0.02259955f, 0.28311142f, -0.08406354f, -0.23043977f, 
    0.13048169f, 0.25974584f, 0.00689825f, 0.10518090f, -0.17324744f, 0.06501319f, 0.11802651f, -0.10723010f, 
    -0.05492229f, 0.05856583f, 0.37897757f, 0.04786314f, 0.12531194f, -0.00283673f, -0.13365093f, -0.13283502f, 
    -0.50961673f, -0.08422092f, -0.05171811f, 0.11681019f, -0.09867460f, -0.09589516f, 0.20013878f, 0.01301576f, 
    0.21909338f, 0.11916692f, -0.13670141f, 0.11637720f, -0.10005362f, -0.14661248f, -0.09359708f, 0.09181356f, 
    0.00381156f, 0.04239732f, 0.07387838f, -0.14019839f, 0.20771731f, -0.27807176f, -0.01215129f, 0.18065600f, 
    0.14659721f, -0.17584130f, 0.05433984f, 0.01871827f, 0.08955987f, -0.03890337f, 0.32943064f, 0.23000287f, 
    -0.07184779f, 0.08323990f, 0.06096479f, 0.45422456f, -0.18809181f, -0.10569878f, 0.11168547f, -0.02399977f, 
    0.22559813f, 0.05930881f, 0.18118073f, -0.57202673f, -0.09533419f, 0.24978407f, 0.07794403f, -0.13928668f, 
    0.02588204f, 0.20932683f, -0.08385120f, -0.21108204f, -0.23673488f, 0.00304326f, -0.18601808f, 0.29137009f, 
    0.09140023f, -0.25439891f, 0.56500524f, -0.17645709f, -0.16330780f, 0.15978566f, -0.13916406f, 0.17202494f, 
    -0.13171019f, 0.02488874f, -0.09258203f, 0.03373563f, -0.29225656f, -0.10076439f, -0.15229981f, 0.13651101f, 
    -0.02436326f, -0.10355762f, -0.02422580f, -0.07660823f, -0.08010852f, 0.03538370f, -0.06524593f, -0.04393579f, 
    0.00022341f, -0.07307200f, -0.08408004f, -0.00580825f, 0.05449630f, 0.09903645f, 0.09981237f, -0.04005262f, 
    0.00530792f, 0.04958779f, -0.03483311f, 0.00480885f, -0.11146474f, -0.07833221f, 0.01471748f, -0.08021161f, 
    0.10698680f, -0.09239567f, -0.02151513f, 0.10650346f, -0.09941353f, -0.08137518f, 0.02386611f, 0.02928985f, 
    -0.10283248f, -0.11852649f, -0.10705513f, 0.09911631f, -0.08783907f, -0.10088710f, -0.01099622f, -0.03690293f, 
    0.07982644f, 0.03178062f, -0.12662810f, 0.08338621f, -0.19323245f, 0.05520673f, 0.05761183f, -0.12679297f, 
    -0.09177189f, 0.05261403f, 0.07663051f, 0.08506741f, 0.05167761f, 0.00371886f, -0.01942930f, -0.03845664f, 
    0.03074521f, 0.02824313f, -0.06423940f, -0.02586123f, -0.08312958f, 0.08905169f, -0.08023169f, -0.00816716f, 
    0.03590310f, 0.03759472f, 0.25919828f, 0.49195075f, -0.00368412f, -0.28721797f, -0.09244455f, -0.57151580f, 
    -0.24255347f, 0.22295058f, 0.19038214f, 0.65355283f, 0.04769072f, 0.23430017f, 0.21957642f, -0.72658777f, 
    -0.52212834f, 0.14643678f, -0.07052247f, -0.06604700f, 0.01736723f, 0.08402928f, -0.10474245f, 0.33198607f, 
    0.09600494f, 0.23373388f, 0.01099864f, 0.30206060f, 0.41669068f, -0.03155702f, 0.18712300f, 0.32713747f, 
    -0.00756506f, 0.28823397f, 0.30210215f, 0.15321255f, -0.05656426f, 0.13596196f, -0.10973193f, -0.03712334f, 
    0.27619371f, -0.27194262f, -0.07691970f, 0.25380275f, -0.39385432f, 0.13351490f, 0.04193615f, -0.10873880f, 
    -0.07895132f, 0.09547393f, -0.42824644f, 0.16831000f, 0.39478013f, -0.23420778f, -0.50775677f, -0.17863755f, 
    -0.06551100f, -0.35013425f, -0.03059526f, 0.00424537f, 0.14465345f, -0.13663355f, 0.24887842f, -0.12939365f, 
    0.09750029f, 0.13344440f, 0.07712372f, -0.18374021f, 0.09449883f, 0.11522098f, 0.00254669f, 0.11562157f, 
    -0.07007299f, -0.23655355f, 0.17416044f, -0.05619288f, -0.10541694f, 0.06469824f, -0.44131956f, -0.04243003f, 
    0.23105912f, 0.18132061f, 0.13898008f, 0.34829792f, 0.12506452f, 0.09801199f, 0.67321247f, -0.03490409f, 
    -0.12048706f, 0.30732557f, 0.22332683f, -0.06471706f, -0.35937202f, -0.08954182f, -0.35595137f, -0.87829792f, 
    0.07079382f, -0.05427903f, -0.41274646f, -0.70375341f, 0.11011719f, 0.22308536f, 0.29908559f, 0.28391957f, 
    0.13783567f, -0.05333519f, 0.07874290f, -0.52806580f, 0.10679746f, -0.02604367f, 0.04180093f, -0.06623863f, 
    -0.01949536f, 0.11142252f, -0.17886117f, 0.01113366f, -0.51730084f, 0.28056449f, 0.19026043f, 0.18877961f, 
    -0.29461977f, 0.20396435f, 0.28594086f, 0.63347214f, -0.21450366f, 0.10566862f, 0.10495596f, 0.02344162f, 
    -0.18063588f, -0.11796768f, 0.09411098f, 0.07417191f, -0.03794372f, 0.26708949f, 0.12637943f, 0.21637625f, 
    -0.04189447f, 0.06905159f, -0.22617687f, -0.37473971f, 0.01790257f, 0.21119161f, 0.21544926f, 0.17058405f, 
    -0.02345552f, 0.09540357f, 0.01609130f, 0.08348018f, -0.09254050f, -0.01259033f, 0.30414540f, -0.63194072f, 
    0.01319923f, 0.29183534f, 0.30071136f, -0.18550555f, -0.34234637f, 0.10340218f, -0.12498917f, 0.15851657f, 
    -0.08130908f, -0.19982943f, 0.01347023f, 0.55378890f, 0.13193427f, 0.09474254f, 0.30648822f, 0.26596859f, 
    0.10588290f, -0.18157211f, -0.05893986f, -0.08356096f, 0.10488272f, -0.17200014f, -0.08113761f, 0.00108072f, 
    -0.03091784f, -0.17758277f, -0.34168193f, 0.07016873f, 0.01857530f, 0.05714742f, 0.16774279f, 0.36458975f, 
    0.22316259f, 0.01959185f, 0.02480108f, -0.18023962f, 0.10661989f, 0.18595722f, -0.12907477f, 0.03694374f, 
    0.15636317f, -0.09891184f, -0.23941779f, 0.02572047f, 0.03115958f, 0.29417190f, 0.06899388f, 0.15950675f, 
    0.34827334f, -0.12337065f, 0.20987317f, 0.02224922f, -0.20274796f, -0.03718896f, 0.26941788f, -0.08692668f, 
    0.12048037f, 0.14071481f, 0.10504109f, -0.01720094f, 0.05410566f, -0.11335121f, 0.26585391f, -0.38525933f, 
    -0.01847006f, 0.24601215f, 0.22933823f, -0.37084293f, -0.18272555f, -0.12060955f, 0.15193665f, 0.03494332f, 
    -0.01101286f, -0.22732604f, 0.05530210f, 0.17491531f, 0.16267873f, 0.60905182f, 0.08880513f, -0.69434500f, 
    0.04760063f, 0.12380700f, 0.07758149f, 0.04542780f, -0.46388036f, 0.04857583f, -0.09667552f, 0.07502567f, 
    -0.13477199f, -0.12938365f, -0.08987308f, 0.00188241f, -0.12361594f, -0.27513281f, -0.09167734f, 0.01119746f, 
    0.01360969f, -0.20717087f, 0.08548488f, -0.14806947f, -0.11795029f, -0.13581090f, -0.20911033f, 0.10986861f, 
    -0.09552446f, -0.06874592f, 0.05713271f, 0.00929431f, -0.02872106f, 0.06079785f, -0.02133292f, 0.07576302f, 
    -0.10958780f, 0.06336007f, -0.13250390f, 0.03162325f, -0.15576886f, 0.06201269f, -0.04424492f, 0.07375996f, 
    -0.13234256f, 0.00594613f, -0.06239347f, -0.12731682f, -0.04440209f, -0.09003349f, 0.03094473f, -0.06195750f, 
    0.03683889f, -0.06143037f, -0.12711945f, 0.00773757f, 0.05168573f, 0.04133384f, -0.10675450f, 0.05666051f, 
    -0.08342046f, -0.02753462f, -0.13119107f, -0.12028243f, -0.14083643f, 0.07603332f, -0.06487246f, -0.11426400f, 
    0.03715936f, -0.11163244f, 0.02601166f, 0.01904131f, -0.11101999f, -0.12641305f, -0.12919074f, -0.11889109f, 
    0.05368035f, 0.04288310f, -0.10415754f, 0.03369742f, -0.06094794f, -0.13579635f, 0.00333770f, 0.03490352f, 
    -0.04102229f, -0.03638437f, -0.15421961f, 0.00409604f, 0.04062285f, 0.03820527f, 0.00883996f, -0.04023071f, 
    0.00292923f, -0.00496286f, -0.20876810f, 0.05464278f, 0.00418670f, 0.24638714f, 0.10459201f, -0.33573273f, 
    0.19920619f, 0.16372038f, 0.34512454f, 0.26557556f, -0.12573372f, -0.36030367f, 0.07332194f, -0.38640657f, 
    0.24590714f, 0.18294512f, 0.08760040f, 0.02775093f, 0.08016405f, 0.05700684f, 0.04438719f, 0.31463194f, 
    -0.10852461f, 0.10557972f, -0.07267569f, -0.03911703f, 0.17205325f, -0.02930045f, 0.04104441f, -0.13119090f, 
    -0.08808779f, 0.06622700f, 0.13156284f, -0.14073385f, 0.01759790f, 0.08767103f, -0.03780989f, -0.10713013f, 
    0.29421324f, -0.06759766f, -0.09115850f, -0.00952283f, -0.15859909f, 0.11649879f, 0.27756429f, -0.08766154f, 
    0.11404670f, -0.04867436f, 0.35702172f, -0.03416986f, -0.03247213f, -0.18392128f, -0.03055223f, -0.09762678f, 
    0.37563789f, 0.04922087f, 0.03542678f, -0.00050866f, 0.00207511f, 0.01862131f, -0.10042781f, 0.12260112f, 
    0.21074930f, 0.04535588f, -0.32737362f, -0.13108695f, 0.01092610f, 0.47792163f, 0.00565990f, -0.17206284f, 
    0.24557008f, -0.13776198f, 0.33673871f, 0.22017191f, 0.11259598f, 0.09066150f, -0.07922919f, -0.13428698f, 
    -0.10640594f, 0.05829353f, -0.04708952f, 0.02286344f, -0.04760478f, -0.05487642f, -0.21316499f, 0.18655120f, 
    0.06442109f, -0.12500468f, -0.09066840f, -0.35356456f, 0.18124066f, 0.10321969f, 0.22028658f, -0.00812884f, 
    -0.08099762f, 0.14748907f, -0.12232793f, 0.05694091f, -0.00828950f, 0.01118077f, -0.09494381f, -0.33479324f, 
    -0.01313859f, 0.13303596f, 0.03570440f, 0.30974215f, 0.05020907f, 0.33639187f, -0.07823255f, -0.20959179f, 
    0.25977871f, 0.12847205f, 0.35356212f, 0.32810089f, 0.38975352f, -0.24593075f, -0.03144217f, -0.18739310f, 
    0.36275893f, 0.14032684f, 0.17344712f, -0.27920130f, 0.06395394f, 0.19313791f, 0.42378816f, 0.09420936f, 
    -0.22949688f, -0.07637636f, -0.10431890f, 0.37738398f, -0.00482437f, -0.01866747f, -0.05506096f, 0.01438354f, 
    0.24585962f, -0.59692198f, 0.12400843f, 0.15976973f, -0.43571535f, -0.29745838f, 0.19002815f, -0.05805594f, 
    0.03435610f, -0.01524418f, 0.11588766f, -0.13442704f, -0.04901331f, -0.05822515f, -0.00516046f, -0.02756848f, 
    0.07004075f, 0.38112521f, 0.10130842f, -0.21338247f, -0.01535763f, -0.11040384f, 0.25264600f, 0.03191180f, 
    -0.17910860f, 0.05439521f, -0.11057045f, -0.61827767f, -0.00219049f, 0.63373828f, 0.14508721f, -1.24286246f, 
    -0.05189522f, 0.04246775f, -0.11435021f, 0.19313459f, 0.05487563f, 0.08144457f, -0.01048058f, 0.26836291f, 
    -0.06330473f, 0.09479342f, -0.17622349f, -0.35748953f, 0.40919638f, -0.23853137f, -0.20633608f, 0.02897167f, 
    -0.50766742f, 0.11764570f, -0.55343425f, -0.26809716f, -0.60917395f, -0.24204569f, 0.02801044f, -0.06624965f, 
    0.04469718f, 0.00527667f, -0.04119377f, 0.00737004f, -0.01495430f, 0.01924396f, -0.11375314f, -0.10817608f, 
    -0.01594752f, -0.09515303f, 0.03954281f, -0.12380140f, -0.00887886f, -0.09131545f, -0.08759454f, 0.01737867f, 
    -0.10062024f, 0.04436833f, -0.09477521f, -0.05300264f, 0.01884876f, -0.05547436f, -0.08497262f, 0.03328443f, 
    -0.01688874f, -0.08717287f, 0.06843214f, -0.05258310f, -0.09523329f, 0.00024736f, -0.04772626f, 0.04827306f, 
    -0.07656337f, 0.01367861f, -0.03487656f, 0.01280287f, -0.03143680f, -0.04596862f, -0.12135209f, 0.10875824f, 
    -0.06769797f, 0.09153908f, 0.07298507f, -0.02640595f, -0.09140849f, 0.09584105f, -0.02586634f, -0.09304577f, 
    -0.03755370f, -0.11562267f, 0.03674358f, 0.02425969f, -0.05195408f, -0.06600614f, -0.02941076f, 0.08615665f, 
    0.11341347f, -0.08577561f, -0.05116922f, 0.00248989f, 0.01208852f, 0.06518926f, -0.02157541f, 0.12158929f, 
    -0.20868409f, 0.02384500f, 0.13231139f, -0.14169502f, -0.09609509f, -0.05437759f, 0.07320136f, -0.76064241f, 
    -0.08126079f, 0.03949064f, 0.31094950f, -0.15790880f, 0.02279139f, 0.04458360f, 0.30126059f, -0.36341503f, 
    0.28427741f, 0.00787065f, 0.05853630f, 0.17691953f, -0.03984942f, 0.08185458f, -0.49264684f, 0.10288253f, 
    -0.06298980f, 0.30820259f, 0.00268153f, -0.40164629f, 0.17870128f, -0.08267653f, 0.20209748f, 0.26342571f, 
    -0.13251124f, 0.14421225f, 0.14649490f, 0.45161310f, -0.16757706f, 0.36671078f, 0.01398915f, -0.88254982f, 
    0.08758332f, -0.08945300f, 0.05404919f, 0.12125359f, 0.10135873f, 0.00775197f, -0.11555127f, 0.05693872f, 
    0.08960139f, 0.08211408f, -0.25884232f, -0.04796687f, 0.16675536f, -0.34262180f, -0.10538408f, 0.14341812f, 
    0.32876152f, -0.06491349f, -0.24222670f, -0.11820482f, 0.21629757f, 0.20649520f, -0.51308459f, -0.05032190f, 
    0.40693903f, -0.06468301f, -0.06394102f, 0.30119070f, -0.04923193f, 0.03757505f, -0.01863238f, -0.28066707f, 
    -0.01676483f, -0.07490711f, -0.14112304f, -0.16654170f, 0.28833875f, -0.06850088f, 0.16397992f, 0.07080261f, 
    0.11991767f, -0.16239882f, 0.15601631f, 0.01046934f, -0.10570239f, -0.00234479f, -0.20781462f, -0.18996780f, 
    -0.05033560f, -0.10760927f, -0.03419765f, 0.03011498f, 0.32195854f, 0.05569319f, 0.46043578f, 0.23033592f, 
    0.16814853f, -0.08562156f, 0.16402216f, -0.02434091f, -0.12888137f, -0.01865188f, 0.11042407f, -0.05460716f, 
    -0.17635038f, 0.05727086f, -0.10784066f, 0.38582736f, 0.01173861f, 0.17627303f, -0.21285340f, 0.04885240f, 
    -0.01031520f, -0.20276085f, 0.43457127f, 0.15205204f, -0.01380255f, -0.33310804f, 0.24212328f, 0.00653219f, 
    0.10561671f, 0.39251232f, 0.07589789f, 0.02713842f, 0.11830986f, 0.37731639f, 0.64925194f, -0.07555152f, 
    -0.14017802f, -0.02527274f, 0.00523326f, 0.04462587f, -0.07953286f, -0.09119889f, 0.05200146f, 0.03957878f, 
    0.16913079f, 0.12072609f, -0.05996676f, -0.00432934f, -0.07632854f, 0.11446706f, 0.17133698f, 0.10632443f, 
    -0.08894782f, 0.22487517f, -0.02730061f, -0.05491209f, -0.13639739f, -0.09878976f, -0.10058603f, 0.00796639f, 
    0.06879736f, -0.03011322f, -0.06790444f, -0.15713595f, 0.18116905f, -0.03262903f, 0.08022334f, 0.28537309f, 
    -0.02711300f, 0.23081560f, 0.14433700f, 0.12233019f, 0.04737724f, 0.01723880f, -0.05741160f, -0.51744264f, 
    0.11269095f, 0.02704079f, -0.01130825f, 0.01909734f, 0.08847652f, 0.18879442f, -0.02819764f, -0.20578264f, 
    -0.05227615f, 0.07449157f, -0.40728232f, 0.06427136f, 0.37401265f, 0.03407921f, -0.25852144f, 0.01634352f, 
    -0.10590485f, -0.08193951f, -0.05361571f, -0.37890351f, 0.02745756f, -0.07302722f, -0.13986039f, 0.02514264f, 
    0.22800638f, 0.14023378f, -0.15501267f, 0.22833978f, 0.03128402f, 0.07219883f, 0.08080976f, -0.09925477f, 
    0.17782986f, 0.04157454f, 0.11889409f, 0.36589757f, 0.04635092f, 0.00382650f, -0.13044842f, -0.06006171f, 
    -0.21238658f, 0.06100487f, -0.04524615f, 0.08915155f, -0.05819894f, -0.03167441f, 0.12773024f, 0.51926661f, 
    0.09198239f, -0.08919894f, -0.03937300f, 0.72751993f, 0.15465775f, 0.02640522f, -0.16993675f, 0.10957418f, 
    0.12836854f, 0.37744135f, 0.07933433f, -0.36030364f, -0.00015913f, -0.00469019f, -0.09880299f, 0.44447339f, 
    0.16460754f, 0.32199591f, 0.00483823f, -0.11271459f, -0.23871015f, -0.00428834f, 0.22507007f, 0.15888697f, 
    -0.26718327f, -0.04128230f, 0.44189146f, -0.02218624f, 0.18731785f, 0.10133000f, -0.26956788f, -0.15908675f, 
    -0.17748292f, -0.36119276f, 0.24719192f, 0.18253188f, -0.13216157f, -0.35156506f, 0.18290576f, -0.04770596f, 
    -0.06265119f, -0.23885190f, 0.12149453f, -0.06187669f, 0.06424348f, -0.10168278f, -0.11899391f, -0.43376309f, 
    -0.11514670f, 0.14198111f, 0.11540650f, -0.16019422f, -0.02602820f, 0.38890916f, 0.39876312f, -0.22901550f, 
    0.60087717f, 0.02042092f, 0.13923500f, 0.29395327f, 0.06845929f, -0.01536107f, 0.02300658f, 0.15413374f, 
    0.02649816f, 0.47560114f, -0.06148377f, -0.10745892f, 0.01661010f, 0.11774260f, 0.09131955f, 0.11482047f, 
    0.08163843f, -0.13021089f, 0.32716757f, 0.61214340f, -0.27409783f, 0.19704740f, 0.18029718f, -0.05930312f, 
    -0.17887443f, -0.23091474f, -0.02310306f, 0.08384167f, 0.42078221f, -0.24229403f, -0.20170206f, 0.22834800f, 
    -0.14407544f, 0.15208796f, -0.06943718f, -0.03686782f, -0.12509340f, -0.33494431f, 0.14626397f, 0.41076970f, 
    0.45405656f, 0.01651047f, -0.25840020f, -0.02261248f, 0.06182881f, 0.37532640f, -0.28714558f, -0.18351014f, 
    -0.04753537f, -0.07850803f, -0.13133803f, 0.07191212f, -0.06383409f, -0.00824609f, -0.09400949f, -0.10637297f, 
    -0.11799783f, -0.15271081f, -0.10741354f, 0.08937575f, -0.14308242f, -0.03597291f, 0.02073805f, -0.04898585f, 
    0.09631941f, 0.07351168f, 0.04511249f, 0.06784634f, -0.09970357f, 0.04354094f, -0.01201271f, 0.05858669f, 
    0.01992541f, 0.06894393f, 0.00283244f, -0.10496920f, -0.00467398f, -0.11700004f, 0.04751728f, -0.04376912f, 
    0.09231979f, -0.02599746f, -0.08353622f, -0.02234001f, -0.09205376f, 0.02693895f, 0.02919354f, -0.08124464f, 
    -0.12154999f, 0.04638262f, -0.02280916f, -0.08115526f, 0.03803499f, -0.00811952f, -0.00981104f, -0.03450917f, 
    -0.11928514f, -0.01431200f, 0.07423627f, -0.02336304f, -0.02659433f, 0.04473779f, -0.06740391f, -0.11399566f, 
    -0.00198019f, -0.09700336f, -0.03140350f, -0.08502963f, 0.08220131f, 0.05118339f, -0.00189406f, 0.06632045f, 
    -0.11848574f, -0.04979401f, 0.15230840f, 0.06680491f, -0.07950331f, -0.22466391f, -0.12459870f, 0.07558478f, 
    0.02202285f, 0.37669337f, -0.04290633f, 0.20435181f, 0.06828821f, -0.27941042f, -0.06410413f, 0.01773724f, 
    -0.39478534f, 0.24002858f, 0.03436408f, -0.04164902f, -0.04898310f, 0.02649982f, -0.11972028f, 0.14747716f, 
    0.06288414f, 0.06566491f, 0.19868657f, 0.75126982f, 0.26207483f, 0.06601660f, -0.23694254f, 0.28936654f, 
    -0.01620571f, 0.10705096f, -0.15652366f, -0.09187896f, 0.19450186f, -0.03365080f, -0.14510061f, 0.31972340f, 
    0.26920262f, -0.15834135f, 0.02157743f, -0.09378055f, 0.07368518f, 0.12485784f, 0.21105860f, -0.06898905f, 
    0.06585819f, -0.04600561f, -0.32572854f, 0.12382551f, 0.24041159f, 0.07513397f, -0.02668724f, 0.03485062f, 
    -0.02278757f, -0.43736875f, 0.04740717f, -0.06990396f, 0.31300658f, -0.27394560f, -0.20031002f, -0.08460031f, 
    0.21952043f, 0.12320256f, -0.07964724f, -0.11462106f, 0.00897305f, 0.27322465f, 0.00345491f, -0.00177935f, 
    -0.05468018f, -0.21804757f, -0.06937983f, -0.11577075f, 0.23248360f, -0.04594649f, -0.24955161f, -0.00242511f, 
    -0.01681716f, 0.08036296f, -0.01027036f, -0.16131729f, 0.10624971f, 0.09795651f, 0.22972867f, -0.52765542f, 
    -0.11233224f, -0.15227798f, 0.15333465f, -0.11727617f, 0.04778370f, 0.09341262f, 0.11114509f, 0.10122208f, 
    0.22566687f, 0.08499081f, -0.13903236f, -0.39142960f, 0.18367979f, -0.11169712f, 0.16290383f, 0.19229931f, 
    0.14231956f, 0.19229372f, -0.07325067f, 0.05659162f, -0.12595034f, 0.17687218f, -0.03660911f, 0.01013890f, 
    0.13881761f, -0.22090480f, 0.12650728f, 0.30250794f, -0.01314580f, 0.05463991f, -0.10813200f, -0.04723294f, 
    -0.11634898f, 0.15561450f, 0.07115315f, 0.14296713f, -0.00498199f, -0.05649280f, 0.54064316f, -0.05269127f, 
    -0.13034423f, -0.12903047f, 0.01667928f, -0.12066767f, -0.02797033f, -0.14702898f, 0.06979588f, -0.04852026f, 
    -0.00979719f, 0.03130024f, -0.17944011f, 0.09835619f, 0.00391428f, 0.09804730f, -0.08557612f, 0.09673504f, 
    0.01639952f, -0.05244784f, -0.12434700f, -0.12228834f, -0.00646386f, -0.11277857f, -0.01951165f, -0.09804074f, 
    0.01466353f, 0.03375284f, 0.05522226f, -0.09318399f, 0.07568739f, 0.07857136f, -0.05452950f, 0.04496921f, 
    0.06538752f, -0.11983627f, -0.09208477f, 0.08849578f, -0.10165511f, 0.04855195f, 0.00056900f, -0.00413931f, 
    0.09309692f, 0.06115182f, 0.00320734f, -0.10850668f, 0.01747997f, -0.01883698f, -0.12968794f, -0.09441427f, 
    -0.07980398f, 0.00257696f, -0.01719716f, -0.00986621f, 0.03437833f, 0.05386166f, -0.14000566f, -0.06566212f, 
    -0.06213301f, -0.02026929f, -0.05721603f, 0.07829994f, -0.03410292f, -0.12276705f, -0.08786412f, 0.03697404f, 
    -0.06833592f, -0.06619446f, -0.01051307f, 0.09918083f, -0.03804091f, -0.09260036f, 0.00038894f, 0.01000608f, 
    0.00640540f, -0.03937085f, 0.05612393f, 0.02826423f, -0.09437883f, 0.05372770f, -0.10542554f, 0.00582055f, 
    -0.01910047f, -0.14896120f, 0.05669752f, -0.02457952f, 0.08521038f, -0.09080635f, -0.03540341f, -0.14409532f, 
    -0.02946109f, -0.05676979f, -0.06720955f, 0.01563829f, 0.11244075f, -0.10581926f, -0.10385616f, -0.04564048f, 
    -0.06209649f, -0.12151805f, 0.04704947f, -0.00903793f, 0.08206540f, -0.03771053f, -0.04753764f, -0.05628267f, 
    0.00087819f, 0.03346396f, 0.02193165f, -0.09132943f, -0.11453863f, 0.00640090f, 0.09007347f, 0.04216728f, 
    -0.14726333f, -0.15429731f, -0.05408894f, -0.12157427f, -0.01635610f, -0.09492818f, 0.11633198f, -0.11685956f, 
    0.04157138f, -0.09444363f, -0.03603122f, -0.02609673f, -0.06715319f, -0.08136578f, -0.08755852f, -0.09062040f, 
    -0.32273775f, 0.13708116f, 0.02580369f, -0.82053906f, -0.00399625f, 0.09855275f, -0.06362619f, -0.04113537f, 
    0.14330992f, 0.15604377f, 0.07327364f, -0.12571774f, -0.07203604f, 0.10295072f, -0.36753905f, -0.15270019f, 
    0.18378191f, 0.25377536f, -0.12100106f, 0.38557512f, 0.08235192f, -0.02776636f, 0.28826869f, 0.09167401f, 
    0.02337077f, 0.49078909f, 0.28863582f, 0.35555458f, 0.13146630f, 0.08137012f, -0.53402495f, 0.11202183f, 
    0.18513277f, 0.28950843f, -0.41346693f, 0.66221464f, 0.22384337f, 0.05324584f, 0.17143492f, 0.60378557f, 
    0.30885682f, 0.03359804f, 0.08205741f, -0.52113098f, -0.07133102f, -0.01326459f, 0.10875196f, -0.09660404f, 
    0.01407733f, -0.23800066f, -0.25562224f, 0.27626646f, -0.24918774f, -0.08123512f, -0.01349830f, 0.03342804f, 
    0.40596017f, -0.06880721f, -0.03722483f, -0.09006590f, 0.23279770f, 0.10201348f, -0.47195095f, 0.09492291f, 
    -0.44509172f, -0.05253020f, -0.00117804f, 0.15267664f, 0.00872448f, 0.09499145f, -0.00482205f, -0.46934155f, 
    0.04934104f, 0.01139751f, 0.24039508f, -0.09987967f, 0.07016554f, -0.11683489f, 0.22384401f, -0.66594207f, 
    -0.63384449f, 0.11980033f, -0.09576231f, -0.11989477f, -0.07014273f, 0.02307106f, -0.38121775f, 0.22263512f, 
    0.03504693f, 0.13449271f, -0.05486387f, 0.26760918f, 0.66220516f, -0.11683990f, 0.13440670f, 0.05988294f, 
    0.09267811f, 0.24528836f, -0.02183863f, -0.09527670f, 0.12469147f, -0.00333151f, -0.05338182f, -0.30935898f, 
    0.20716271f, -0.09293137f, -0.00116911f, 0.15583849f, -0.22582088f, 0.19503175f, 0.09117739f, -0.06551033f, 
    0.03933437f, -0.56785899f, -0.40922886f, 0.39455757f, 0.57786483f, -0.28606340f, -0.22981173f, -0.26684442f, 
    0.20806770f, -0.03032355f, 0.29548126f, -0.22236589f, 0.38580379f, -0.11753218f, -0.08100256f, 0.11335806f, 
    0.01638253f, 0.12441486f, -0.35267180f, -0.02173392f, 0.10557590f, 0.49345762f, -0.02865106f, 0.15544279f, 
    0.06549739f, 0.05918904f, 0.15625341f, -0.44389474f, 0.00544470f, -0.68832266f, -0.16516832f, -0.21738780f, 
    -0.00015734f, 0.14406380f, 0.10590247f, -0.40057287f, -0.00069103f, 0.01425511f, 0.36105993f, -0.31731787f, 
    0.05636675f, 0.25413871f, 0.24624838f, 0.07189234f, 0.07235876f, -0.07646218f, -0.08580615f, -0.06325398f, 
    0.23583947f, -0.08086494f, -0.17539455f, -0.29077682f, 0.06761704f, 0.18030888f, 0.17103688f, 0.56617504f, 
    0.29460737f, 0.16396746f, -0.01451351f, 0.13251042f, -0.14613090f, 0.35449368f, 0.06346063f, -0.13901281f, 
    0.26601958f, -0.32395387f, -0.06762066f, 0.24041130f, 0.11296383f, -0.09619565f, 0.11031348f, -0.11052811f, 
    0.39348030f, 0.03918854f, 0.25158706f, -0.01632991f, 0.29925692f, -0.01642494f, 0.54563528f, 0.02509047f, 
    -0.38430884f, -0.10343952f, -0.25950372f, -0.32017609f, -0.10576218f, 0.36536950f, 0.03206162f, -0.02093806f, 
    0.12607704f, -0.18229206f, 0.44132769f, -0.22253224f, -0.27998272f, -0.36261722f, 0.38966510f, -0.06751195f, 
    0.13941267f, 0.09099147f, -0.12091070f, -0.28468278f, -0.06302965f, 0.05805913f, 0.09232266f, 0.17794277f, 
    -0.07992483f, 0.28198734f, 0.20933075f, -0.58984476f, -0.28529280f, -0.06095152f, -0.15019552f, -0.52674377f, 
    -0.02129882f, -0.21806994f, 0.10374789f, 0.40379912f, 0.13874398f, 0.41714400f, -0.08709869f, -0.34552404f, 
    0.01399439f, 0.03938321f, -0.08494690f, -0.24471813f, 0.03386374f, 0.06616187f, 0.09689470f, -0.48685402f, 
    0.04923392f, 0.03677050f, -0.60733962f, -0.04102293f, -0.01961467f, -0.01156751f, -0.01902371f, -0.10951789f, 
    0.33712888f, 0.07823108f, 0.13529702f, -0.18158521f, -0.10300116f, 0.04850850f, -0.27378961f, -0.06972587f, 
    0.54679859f, 0.05250621f, -0.34416410f, 0.29296082f, -0.06139590f, 0.30836275f, 0.10941760f, 0.08624230f, 
    0.35282099f, -0.23588815f, 0.17959945f, 0.12111891f, -0.03530618f, -0.16981977f, -0.08374739f, 0.03116347f, 
    0.11771924f, -0.00912902f, -0.02181057f, -0.17504302f, -0.03754396f, -0.06060269f, 0.41846588f, 0.31941760f, 
    0.07572470f, 0.15819950f, 0.16181749f, 0.26120588f, -0.27555308f, 0.00315848f, 0.23024124f, -0.14284161f, 
    0.16793153f, -0.08329448f, 0.08354544f, -0.50843984f, -0.04533191f, 0.48719439f, 0.13730910f, -0.09695546f, 
    0.18031770f, 0.52213424f, 0.06871488f, -0.03900050f, -0.32831934f, 0.24206305f, -0.12203471f, 0.14788041f, 
    -0.21864155f, 0.06980081f, 0.65536577f, -0.07834029f, -0.05202260f, 0.06666726f, -0.36053014f, -0.14987291f, 
    -0.19164856f, 0.11334050f, -0.00387466f, 0.07875564f, -0.30182999f, -0.07912876f, 0.55535299f, 0.10599032f, 
    -0.05346092f, -0.11570255f, -0.14315240f, 0.03560097f, 0.00243001f, -0.07912684f, -0.01314645f, -0.04691523f, 
    -0.03224367f, -0.05540223f, 0.05662388f, -0.03731721f, 0.02555202f, 0.07372540f, -0.11150466f, -0.00766641f, 
    -0.04670918f, 0.01827021f, 0.07075384f, -0.07960695f, 0.09750696f, -0.11693066f, 0.07204274f, -0.10214683f, 
    0.09199301f, -0.06643362f, 0.00553439f, -0.06381702f, 0.03379794f, 0.11788869f, -0.03628084f, 0.02090018f, 
    -0.04794206f, -0.00316718f, 0.01295361f, -0.08274461f, -0.06966517f, 0.02075243f, -0.02294795f, -0.08265388f, 
    -0.05951844f, 0.04676588f, -0.12789433f, 0.03776238f, -0.09357869f, 0.03609102f, 0.10064224f, -0.13176343f, 
    -0.12713540f, -0.05449864f, -0.02287750f, -0.00976007f, 0.00124328f, -0.05351471f, 0.09419147f, -0.08901351f, 
    -0.14765252f, 0.01891230f, -0.07170101f, -0.06925479f, 0.08840604f, -0.11605769f, -0.13675219f, 0.05657437f, 
    0.23430184f, 0.21466306f, -0.30716288f, 0.01911234f, 0.01854384f, 0.24346144f, -0.01296557f, -0.56582218f, 
    0.12054801f, -0.06541717f, -0.14147688f, -0.56807393f, 0.24953756f, -0.17417054f, -0.16218531f, -0.09268968f, 
    -0.08421550f, -0.26877719f, 0.06700984f, 0.17969707f, 0.06020543f, 0.03192494f, -0.28233755f, -0.08030756f, 
    -0.12234998f, -0.51458204f, -0.34369132f, -0.21941771f, 0.21287654f, 0.07579389f, 0.31137380f, 0.06183749f, 
    0.12659070f, -0.02359149f, 0.05134841f, -0.03020292f, 0.03900895f, -0.32511139f, -0.15236066f, 0.08455071f, 
    -0.07942875f, 0.15848400f, -0.03291130f, 0.15261577f, 0.20993549f, 0.32770953f, -0.44246653f, 0.08738913f, 
    0.13459732f, -0.23904607f, 0.54850274f, 0.23463261f, -0.00827425f, 0.01687788f, 0.32343957f, -0.25870249f, 
    -0.07138104f, 0.50691670f, 0.18849701f, 0.04883438f, -0.10870035f, 0.21170722f, 0.68019998f, 0.06354281f, 
    0.12317401f, -0.10842986f, 0.03680228f, -0.04607559f, 0.02294467f, 0.04533337f, -0.00091298f, -0.07046982f, 
    -0.02717441f, -0.10844766f, -0.08534726f, -0.09380898f, -0.06839696f, -0.04562819f, -0.03691822f, -0.08967063f, 
    0.08228227f, -0.14124118f, -0.01971586f, -0.06609459f, -0.07960740f, -0.00855938f, 0.12049977f, -0.00156247f, 
    -0.01373459f, -0.07174208f, 0.07182038f, -0.05412895f, 0.08077350f, 0.09331395f, -0.07320580f, 0.03563330f, 
    0.01857853f, 0.07779029f, 0.01833493f, 0.06410547f, -0.00037878f, -0.00562953f, -0.12322513f, 0.12206034f, 
    -0.07960968f, -0.07759901f, 0.02860425f, -0.02547053f, 0.08154285f, 0.13201901f, 0.05003672f, 0.05311953f, 
    0.07417843f, 0.02948421f, -0.08033265f, -0.07629592f, 0.03372131f, -0.13260140f, -0.09270163f, 0.02972864f, 
    -0.07930945f, -0.12418790f, -0.01420617f, 0.05400905f, 0.01824256f, -0.14820217f, -0.01811986f, -0.04320364f, 
    0.04310520f, -0.09650391f, -0.10135490f, -0.08441894f, 0.06763628f, -0.05569125f, 0.06694357f, -0.08312880f, 
    -0.08924019f, 0.04772187f, -0.03704054f, 0.08406110f, 0.02938818f, 0.01488021f, -0.02726813f, 0.03747217f, 
    -0.13213937f, -0.15769565f, 0.06526461f, 0.09472781f, 0.02293542f, 0.06893057f, 0.00460874f, -0.09009757f, 
    0.06241281f, -0.06331281f, -0.00187519f, -0.12578852f, -0.12690158f, 0.10555296f, 0.01817934f, -0.08132885f, 
    -0.09223189f, 0.01087354f, 0.04564416f, -0.04562765f, 0.03087992f, -0.13074844f, 0.09127565f, 0.01308674f, 
    0.03217677f, -0.17327422f, -0.11857061f, 0.08810651f, -0.07552947f, 0.01959312f, 0.00837805f, -0.13236292f, 
    -0.14533012f, 0.05248303f, -0.01380536f, 0.07995465f, 0.06080115f, -0.01470427f, -0.04209870f, -0.09425919f, 
    -0.04033998f, -0.01329388f, -0.15260439f, -0.00637834f, 0.00138863f, -0.08119676f, -0.00671345f, -0.03767757f, 
    0.43097401f, -0.09137931f, 0.02006704f, -0.21953720f, 0.03726083f, 0.24974264f, -0.06949333f, 0.11654007f, 
    -0.07016419f, -0.29502296f, -0.23018818f, -0.22476424f, 0.16673099f, 0.27377233f, 0.03325966f, 0.33800107f, 
    0.14480653f, -0.08526053f, 0.07868887f, 0.16864745f, -0.01914108f, -0.06268188f, 0.08403296f, -0.31572562f, 
    -0.02087439f, -0.12739886f, 0.24877666f, -0.04745862f, -0.17235316f, -0.09510568f, 0.07721782f, -0.12585284f, 
    0.23859310f, 0.07850790f, -0.08514337f, 0.45366213f, 0.11157488f, 0.15154882f, 0.33507293f, 0.47316280f, 
    -0.03823871f, -0.04185675f, 0.11338709f, 0.15907414f, 0.02819137f, 0.05913423f, -0.15261605f, 0.45558196f, 
    0.24252221f, -0.14799929f, 0.41416538f, 0.10999945f, -0.39766085f, 0.18633714f, 0.31568536f, 0.33868629f, 
    -0.13793501f, 0.36953256f, 0.20782530f, 0.01349160f, 0.03502864f, 0.47638172f, 0.34906495f, 0.07676966f, 
    0.21959035f, 0.04810034f, -0.24137518f, 0.23499267f, 0.02075623f, -0.21166949f, 0.02884322f, -0.56121546f, 
    -0.42030358f, 0.06688850f, -0.23179439f, -0.58872879f, 0.15719354f, -0.22525528f, -0.00028777f, 0.05351156f, 
    -0.21823654f, -0.30860886f, -0.08372055f, 0.43036795f, -0.01323972f, -0.04862093f, 0.00618842f, 0.20817822f, 
    0.09725176f, -0.92806411f, -0.34958583f, 0.27311945f, 0.12495755f, 0.06259504f, 0.15920556f, 0.15908073f, 
    0.15729862f, -0.12961018f, 0.26752058f, -0.35053894f, -0.42381048f, -0.41737512f, 0.11107507f, 0.39630836f, 
    -0.07251224f, -0.23144211f, -0.10580713f, 0.25542456f, -0.12159730f, -0.15441206f, -1.14290202f, 0.20299061f, 
    -0.34139311f, 0.13634528f, 0.33377805f, -0.11191144f, -0.10585790f, 0.33094117f, 0.11147849f, 0.05332657f, 
    -0.38422945f, 0.11175299f, -0.35439906f, 0.61923981f, -0.35892004f, 0.13688131f, 0.27873611f, 0.08348682f, 
    0.02706631f, 0.02469043f, -0.11789005f, 0.41398901f, 0.04673256f, 0.06758590f, 0.06440371f, -0.01483880f, 
    0.20890412f, -0.12281365f, -0.00609840f, 0.21959253f, 0.00839898f, 0.01662191f, 0.50355506f, -0.05552045f, 
    -0.12591906f, -0.05790984f, 0.12317996f, 0.08752661f, -0.10060380f, 0.09614293f, -0.04826798f, -0.39934486f, 
    -0.00727530f, 0.22937609f, 0.11265689f, -0.14297554f, 0.14530674f, -0.01830105f, 0.18793273f, 0.29779381f, 
    -0.02983769f, -0.18381792f, 0.39402804f, 0.27965328f, 0.11398583f, 0.40854025f, 0.11430702f, -0.42214134f, 
    -0.06485196f, 0.23333095f, 0.08375372f, 0.06019695f, -0.47931725f, -0.00354626f, -0.14285229f, 0.17367885f, 
    -0.09143646f, 0.24903026f, -0.51189756f, 0.18317461f, 0.24995455f, -0.26565653f, -0.01275820f, 0.12946565f, 
    -0.19646086f, -0.16790128f, 0.00249166f, -0.15883571f, 0.03193958f, -0.02949383f, -0.13458361f, -0.12363888f, 
    0.04239017f, -0.53805435f, -0.22832575f, -0.08832695f, 0.09050512f, 0.01104946f, 0.05300586f, -0.71741307f, 
    -0.35824415f, 0.26343715f, 0.12805095f, -0.41778186f, 0.01324946f, 0.07654656f, 0.27907777f, -0.21018937f, 
    0.23267503f, -0.15627596f, 0.04233538f, 0.51290196f, 0.12112379f, 0.07136475f, -0.14265954f, 0.41136238f, 
    -0.10252437f, 0.03132473f, 0.02663093f, -0.02636903f, -0.05601622f, 0.08375512f, 0.03874097f, 0.02833536f, 
    0.08263648f, -0.08998528f, 0.17507760f, 0.50996375f, -0.34709555f, -0.20581397f, 0.03557935f, 0.04183625f, 
    -0.19798604f, -0.23816828f, 0.09850213f, 0.11121231f, 0.19019419f, 0.06222085f, -0.37471250f, -0.01418149f, 
    0.12447517f, -0.15885769f, 0.17124946f, -0.04512394f, 0.15751757f, -0.29176906f, 0.28970757f, 0.23058367f, 
    0.52269942f, -0.10417689f, -0.00037497f, 0.02329027f, 0.10624887f, 0.30581182f, -0.14190269f, 0.03016422f, 
    0.04273858f, -0.60466748f, 0.08924077f, -0.11448183f, -0.11768410f, -0.31331167f, 0.04463494f, 0.03726636f, 
    -0.46643505f, 0.10206541f, 0.12923510f, -0.11547602f, -0.06818274f, 0.28684327f, 0.00180199f, 0.06789238f, 
    0.06327582f, -0.66492540f, -0.06806274f, 0.27374658f, 0.08218507f, -0.00056329f, 0.07370952f, 0.17651351f, 
    0.06228688f, 0.12717091f, -0.11318315f, -0.13949805f, -0.32761791f, 0.01929039f, 0.01438040f, -0.02011546f, 
    0.09442151f, -0.44077525f, 0.12392050f, 0.32395071f, -0.57306308f, -0.11412309f, -0.00731701f, 0.09136893f, 
    -0.38053519f, -0.65462768f, -0.10953957f, 0.08231147f, 0.21102563f, -0.45700818f, -0.51544660f, 0.20874259f, 
    -0.04695093f, 0.03201355f, 0.21956226f, -0.15348059f, -0.39019361f, -0.28677431f, 0.14521299f, 0.16300330f, 
    0.05028919f, 0.06881098f, -0.32520485f, 0.14484684f, -0.05863653f, 0.11517536f, -0.20782860f, 0.04475944f, 
    -0.08785459f, -0.03724254f, 0.06578776f, 0.11653756f, -0.05542107f, 0.16667899f, -0.12298672f, -0.27292863f, 
    0.00955571f, 0.19961680f, 0.41066736f, -0.29688826f, -0.11072856f, -0.14167540f, -0.07326361f, 0.01884897f, 
    0.30146524f, 0.21904275f, -0.06702939f, -0.10910297f, -0.00641805f, 0.11863501f, 0.26824003f, 0.69050550f, 
    -0.10458338f, 0.05140186f, -0.00753592f, 0.37903458f, 0.06945419f, 0.04218504f, -0.30026364f, 0.15132298f, 
    0.02908961f, 0.38739109f, 0.00919807f, -0.17617516f, -0.13238126f, 0.14627533f, 0.16295207f, 0.28979152f, 
    0.03871211f, 0.13763556f, -0.08201288f, -0.35519943f, -0.14020534f, -0.21772271f, 0.13523595f, 0.07703405f, 
    -0.04480549f, -0.07528303f, 0.26670265f, 0.00868063f, 0.11392473f, -0.02229364f, -0.37322018f, 0.10474973f, 
    0.40377790f, -0.01679073f, -0.02416583f, 0.05437792f, 0.16248244f, 0.11423444f, -0.14482012f, 0.01570382f, 
    0.26890901f, -0.09472901f, 0.20867233f, 0.34271795f, 0.12226656f, -0.07249761f, 0.05561090f, -0.29534373f, 
    -0.25173563f, 0.34636459f, -0.03857832f, -0.21147475f, 0.21309879f, -0.01248533f, -0.05941474f, 0.18460187f, 
    -0.17135982f, -0.21764319f, -0.06313604f, 0.41113517f, 0.09305207f, -0.11406138f, 0.26385480f, 0.39341035f, 
    -0.11803692f, -0.13110086f, 0.12515171f, 0.64627320f, -0.21069574f, 0.05622932f, 0.02549316f, 0.22029816f, 
    0.24478360f, 0.08480412f, 0.11558628f, -0.07021082f, -0.08973581f, -0.15908441f, 0.28172433f, 0.49888459f, 
    0.03899984f, -0.14522919f, 0.13065998f, -0.07274397f, -0.03658474f, -0.17796212f, -0.01861017f, 0.17301469f, 
    -0.17304036f, 0.06649988f, 0.00646550f, 0.09390922f, -0.24835669f, 0.30739409f, 0.17156392f, 0.10356988f, 
    -0.41743124f, -0.23670247f, 0.03634698f, 0.53919983f, -0.06810673f, 0.08442329f, -0.10789794f, -0.15011075f, 
    -0.30450779f, -0.08083980f, 0.14980364f, -0.24214138f, -0.07016149f, 0.23046497f, 0.00687091f, 0.19985829f, 
    0.12875316f, 0.26618168f, 0.14647669f, -0.03706038f, -0.21213736f, -0.01254312f, -0.01929493f, -0.01754124f, 
    0.05002572f, 0.30040535f, 0.13476834f, 0.08543957f, 0.11737874f, -0.12111534f, 0.18751499f, -0.01654147f, 
    -0.08304664f, 0.39230382f, 0.22366604f, -0.21317452f, -0.00424073f, 0.10453707f, -0.10091878f, 0.14526106f, 
    0.07446691f, 0.19422820f, -0.07516098f, -0.08186116f, 0.01637005f, 0.34397727f, 0.02706516f, -0.20546666f, 
    0.24520965f, -0.14463758f, 0.01064528f, -0.09298103f, 0.02474926f, -0.12035438f, 0.30716819f, 0.04354631f, 
    -0.08617093f, -0.09928165f, 0.14554867f, 0.07810452f, 0.15535478f, -0.17730777f, -0.25135538f, 0.12222809f, 
    0.49455437f, -0.20973343f, 0.11149786f, -0.18398580f, 0.26567414f, 0.05482527f, -0.81725985f, -0.05682718f, 
    0.06315013f, -0.13493973f, 0.07342640f, -0.08071040f, -0.06423855f, -0.07655023f, 0.09976918f, -0.10086687f, 
    -0.15004487f, 0.02440063f, 0.10541585f, -0.09894802f, -0.01999114f, -0.11720043f, -0.03053635f, 0.10492197f, 
    -0.03361633f, -0.01422964f, -0.07740624f, 0.02019932f, 0.05044436f, -0.07080455f, -0.05804895f, -0.02361648f, 
    -0.01247795f, 0.05323745f, -0.02439708f, -0.07844801f, -0.01955686f, 0.04224321f, -0.10975733f, -0.05088922f, 
    0.10695749f, -0.10734718f, 0.01592326f, -0.02781290f, 0.02845682f, -0.11470268f, -0.09057548f, -0.00369715f, 
    -0.13279156f, -0.08251605f, -0.12429659f, 0.00278909f, 0.02989288f, -0.12636521f, 0.05260667f, -0.11182694f, 
    -0.12692691f, -0.04987948f, -0.05964946f, 0.02526946f, -0.05823452f, -0.08043067f, 0.10423195f, 0.04493117f, 
    -0.12776119f, -0.04431572f, -0.07947969f, -0.09035804f, -0.01609312f, 0.08412477f, -0.02512880f, -0.06210780f, 
    -0.06492312f, -0.08518770f, -0.11575243f, -0.06811485f, 0.00650957f, -0.08628508f, 0.01638395f, 0.03617021f, 
    -0.06318256f, -0.10559164f, 0.10605082f, 0.04075673f, 0.05424376f, -0.00879084f, -0.01500718f, -0.03423341f, 
    -0.00111766f, -0.12148282f, 0.11461191f, -0.03863372f, -0.07602181f, -0.09674247f, 0.04482709f, -0.02550779f, 
    0.06873259f, -0.07364784f, -0.04508735f, -0.02491206f, 0.04833548f, 0.04079098f, 0.02408928f, -0.06353019f, 
    -0.10239807f, -0.12393709f, -0.05596346f, 0.04899512f, 0.05727074f, 0.06970885f, -0.06280237f, -0.05393305f, 
    -0.04209548f, 0.08172849f, 0.07352799f, -0.09851032f, -0.06209259f, -0.06710039f, -0.03253277f, -0.00207765f, 
    0.03129737f, -0.09623519f, -0.09099703f, 0.00496195f, 0.00186414f, -0.00062083f, -0.02139874f, -0.08030123f, 
    0.05817549f, 0.07951929f, 0.03411381f, -0.10664685f, 0.07002167f, 0.08018503f, -0.07060352f, 0.09056172f, 
    0.46599737f, 0.13329029f, -0.08520655f, 0.03209836f, 0.10896982f, 0.14801446f, 0.00885177f, -0.11487549f, 
    0.25343710f, -0.11224452f, 0.22138686f, -0.13804220f, 0.02438664f, 0.08563533f, -0.05821731f, 0.17293961f, 
    0.08621239f, -0.10417767f, 0.05951759f, 0.10501467f, -0.12941265f, -0.09032017f, 0.47873762f, 0.28230640f, 
    0.02037466f, 0.19083570f, 0.15350452f, 0.04354844f, -0.48183149f, -0.11947326f, 0.00093114f, -0.11907891f, 
    0.13813210f, 0.08574670f, 0.08147998f, -0.13791199f, -0.03738622f, 0.17505907f, -0.02941893f, -0.05850376f, 
    -0.01788168f, 0.41780955f, 0.11063616f, -0.11312291f, -0.25176051f, 0.17695735f, 0.17377432f, 0.27632633f, 
    -0.04783330f, -0.18704608f, 0.73493141f, -0.05243060f, -0.17591874f, 0.10311060f, -0.25013477f, -0.16269064f, 
    0.03025218f, -0.07960978f, 0.21163785f, 0.28463000f, -0.32260224f, -0.18115248f, 0.02940031f, 0.09812041f, 
    -0.39099744f, -0.08909348f, 0.32025668f, 0.07906392f, 0.09003198f, -0.14840288f, 0.11792758f, 0.06922626f, 
    -0.18084489f, 0.24806006f, -0.06831617f, 0.04571057f, 0.06647003f, 0.10181959f, 0.36831641f, -0.16592178f, 
    -0.65573537f, 0.35824576f, 0.00345656f, -0.10278828f, -0.12115369f, -0.10479180f, 0.01726402f, -0.17641813f, 
    0.00792010f, 0.24602684f, 0.18447016f, 0.22715779f, 0.27175251f, 0.11170712f, 0.15955766f, 0.21269885f, 
    0.00044221f, 0.33806437f, 0.14675300f, 0.06771030f, 0.23255275f, 0.22528666f, -0.06832527f, -0.07909272f, 
    0.20985189f, -0.37465867f, -0.01116307f, 0.21391815f, -0.27674085f, 0.07198554f, 0.26263022f, -0.00737427f, 
    -0.12202041f, -0.36582223f, -0.59544444f, 0.19789048f, 0.52633655f, -0.21264705f, -0.17404878f, 0.06727253f, 
    0.18647166f, -0.42582345f, 0.35451111f, -0.13577545f, 0.40674502f, -0.09191135f, -0.01547340f, -0.05076102f, 
    -0.32496583f, 0.09382981f, 0.08929726f, -0.27770451f, 0.04788595f, -0.45657483f, -0.06394196f, 0.10793774f, 
    -0.06496418f, 0.34782326f, -0.18841089f, -0.10065963f, -0.08404185f, 0.21203110f, -0.03433953f, 0.08971027f, 
    -0.25419822f, 0.14557689f, -0.14421259f, -0.11182415f, 0.05801838f, 0.05230968f, -0.05865512f, -0.14157060f, 
    0.09634338f, 0.01644313f, 0.18835708f, 0.20414470f, 0.18036097f, 0.04516418f, -0.14644662f, 0.19966443f, 
    0.05948436f, 0.04903592f, 0.12771292f, 0.40545705f, 0.23076160f, -0.24631917f, 0.12634313f, -0.06026714f, 
    0.06899869f, -0.13841048f, 0.10197028f, 0.08315112f, 0.17960763f, 0.12466471f, 0.09672984f, -0.08276363f, 
    0.14350852f, -0.03684918f, -0.64691252f, -0.08066645f, 0.35552856f, -0.02454154f, 0.17068665f, 0.16342443f, 
    -0.05454703f, -0.13397139f, -0.07324177f, -0.19374910f, 0.22199257f, 0.07682628f, -0.37884048f, -0.08548008f, 
    -0.01875885f, 0.04576988f, 0.05971977f, 0.07349158f, -0.04915413f, -0.00085388f, -0.03501597f, -0.04072882f, 
    -0.08798812f, 0.07988262f, 0.08093598f, -0.10010754f, -0.07686376f, -0.18374012f, -0.00535558f, -0.10321912f, 
    0.10439714f, -0.09607337f, 0.11818819f, -0.15217578f, 0.11269550f, 0.04875280f, -0.00135363f, -0.11432374f, 
    -0.06850313f, -0.01889984f, -0.12586771f, -0.13966949f, 0.09293177f, -0.04945542f, 0.02779044f, -0.13195427f, 
    -0.16401017f, -0.14056185f, 0.10091637f, -0.07013316f, -0.01794650f, 0.03428122f, 0.01178516f, -0.11625304f, 
    0.03028768f, 0.00762788f, 0.07055399f, -0.10637911f, -0.08664360f, -0.12269484f, 0.00124661f, 0.09700350f, 
    -0.04346087f, 0.10092348f, 0.01967427f, -0.01458035f, -0.05137215f, 0.05302181f, -0.01107572f, -0.01730722f, 
    0.03099107f, -0.02146397f, -0.14805599f, -0.12824750f, -0.03568388f, -0.15587297f, 0.08370701f, 0.11547805f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15104409f, -0.10115865f, -0.14560468f, 0.00755177f, 0.07468903f, 0.02776991f, 0.46233353f, 0.02650044f, 
    0.17177930f, -0.04392645f, -0.05117802f, 0.45025635f, 0.15895091f, 0.10182273f, -0.03231701f, -0.01493711f, 
    -0.21554284f, 0.20247875f, 0.05172145f, 0.32103920f, 0.16259661f, 0.09969198f, 0.17114787f, -0.00640946f, 
    -0.40585050f, 0.03940122f, 0.00410717f, 0.13204685f, 0.10909211f, 0.45648247f, -0.05769996f, -0.03491062f, 
    0.24041460f, 0.00331434f, 0.31870490f, -0.16006896f, -0.01042689f, 0.23328230f, 0.33056071f, -0.15679969f, 
    -0.09993045f, 0.11894910f, 0.33596361f, 0.33820555f, -0.18808661f, 0.10109542f, 0.06921154f, 0.20101389f, 
    -0.12972462f, -0.17275944f, 0.09557552f, 0.17125751f, 0.31442598f, 0.11077239f, -0.19898446f, 0.00205590f, 
    0.17378046f, 0.06521367f, -0.13701910f, -0.07461327f, -0.06828679f, 0.23409161f, -0.23615214f, -0.08989634f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.01241499f, 0.28603917f, -0.08199000f, -0.08616417f, 0.09320655f, -0.53163528f, -0.50168562f, -0.46134117f, 
    -0.07636900f, 0.05277442f, 0.00816056f, -0.39889628f, 0.01095231f, 0.06530897f, 0.04150456f, 0.26836234f, 
    0.35684130f, -0.01771047f, -0.10212705f, -0.30070248f, -0.10926846f, 0.02680966f, -0.26458451f, -0.04289558f, 
    0.01682393f, -0.35357010f, -0.03272809f, -0.46732163f, -0.40762144f, -0.53806531f, -0.02951650f, -0.07990993f, 
    0.02725489f, -0.28727007f, -0.16512971f, 0.12312885f, 0.10457283f, 0.08529357f, -0.40265641f, -0.12313806f, 
    0.10791098f, -0.05787267f, 0.28369588f, 0.11344138f, 0.03708371f, -0.19723317f, 0.10043126f, -0.04401273f, 
    -0.14903140f, 0.08176392f, 0.14254959f, 0.05331869f, 0.09323608f, 0.23989841f, 0.65059596f, -0.49368402f, 
    0.13622235f, -0.55631733f, 0.12971905f, -0.09486398f, 0.06737409f, -0.18907221f, -0.02084605f, -0.04382494f, 
    0.03445780f, 0.14212745f, -0.04154752f, 0.01641627f, 0.09372146f, -0.18960920f, 0.18497591f, -0.20797497f, 
    0.16120315f, -0.11603671f, 0.00591411f, 0.06527862f, 0.10634936f, -0.14286733f, -0.12626010f, 0.23823231f, 
    -0.74799216f, -0.22206019f, -0.08572137f, -0.03527007f, 0.16445424f, -0.01571404f, -0.13440506f, -0.01485617f, 
    -0.33766392f, -0.27116916f, -0.05926702f, -0.05624319f, -0.20863643f, 0.33531013f, -0.10190640f, 0.01717278f, 
    0.00574420f, -0.17775644f, 0.24928629f, -0.15567175f, -0.12581228f, 0.08459048f, 0.14464603f, -0.00871105f, 
    0.06791030f, 0.33975917f, -0.39237848f, -0.10859239f, -0.09800477f, 0.12651366f, -0.01703777f, 0.08046575f, 
    -0.04861872f, -0.11467168f, 0.01453193f, 0.59168887f, -0.15481821f, -0.06563929f, -0.50387615f, 0.04949899f, 
    0.17534541f, 0.03049782f, -0.02419096f, 0.02635895f, 0.18261389f, -0.27492970f, -0.20819639f, -0.07680682f, 
    0.08062942f, -0.09487573f, -0.17361216f, 0.02669425f, -0.06398466f, 0.05233999f, 0.06276592f, -0.07868341f, 
    0.68142927f, 0.09773301f, -0.00735560f, 0.31907848f, -0.26425284f, -0.02798524f, -0.04416616f, -0.26879770f, 
    -0.33604038f, -0.13319606f, -0.12895446f, 0.02913542f, -0.29982218f, -0.00430228f, 0.52237833f, 0.30166650f, 
    -0.39282188f, -0.83392102f, 0.06931338f, -0.19168432f, -0.16720726f, -0.56196624f, -0.02137348f, -0.49885389f, 
    0.02835544f, 0.05774095f, 0.08257841f, -0.71641326f, -0.05065964f, -0.10322811f, 0.00393605f, -0.24841255f, 
    0.11815047f, -0.66884720f, 0.27302048f, 0.02864049f, -0.27591261f, 0.04110342f, 0.08114158f, -0.08164770f, 
    -0.11463027f, 0.02043086f, -0.36466250f, -0.23916656f, 0.10452202f, -0.67232996f, -0.30837584f, -0.13889800f, 
    -0.10450777f, -0.29456761f, -0.02090237f, 0.06473756f, -0.42416736f, 0.28980088f, -0.07970009f, -0.09056994f, 
    -0.04920626f, -0.30904815f, 0.06456878f, 0.10875076f, -0.10507501f, 0.02553797f, -0.42178106f, -0.41051823f, 
    0.10827063f, -0.08853554f, -0.05855924f, 0.03492017f, 0.00223369f, -0.02054959f, -0.12031634f, 0.18328561f, 
    -0.05002300f, 0.13644618f, 0.01277821f, -0.19902614f, -0.36758178f, -0.02269931f, 0.11960492f, -0.36344048f, 
    0.04935867f, -0.04561063f, 0.06274543f, -0.06001189f, 0.17658196f, -1.10182416f, 0.10714515f, 0.17381302f, 
    0.04018223f, 0.10275617f, -0.92747694f, 0.05758245f, -0.00930605f, -0.91638565f, 0.04263508f, -0.04056750f, 
    0.10307649f, -0.33346775f, 0.08570778f, -0.24202733f, 0.31187168f, -0.37333149f, -0.11151040f, 0.31975520f, 
    0.05193359f, 0.09421775f, 0.08694563f, 0.15829463f, 0.10542054f, 0.21958841f, -0.05877255f, -0.34057063f, 
    -0.06375001f, -0.10879364f, 0.06101383f, -0.01468888f, -0.55313027f, 0.08797288f, 0.08184807f, -0.12148154f, 
    -0.09979442f, 0.10456113f, -0.04595222f, -0.02607922f, 0.02328099f, -0.20505144f, 0.06554489f, -0.12263568f, 
    0.22859269f, 0.09646050f, -0.09385449f, -0.10332613f, 0.07805622f, -0.10087359f, 0.05356996f, 0.17036092f, 
    0.04423349f, 0.21273245f, -0.00295937f, -0.07230606f, 0.08797659f, 0.04297625f, 0.06822914f, -0.07556012f, 
    0.18904480f, 0.17640385f, -0.02070945f, -0.23350568f, -0.43866497f, -0.27969632f, 0.04003938f, 0.08481473f, 
    -0.10818267f, 0.05836709f, -0.11842377f, 0.21380654f, 0.01177273f, -0.06345212f, -0.29350266f, -0.07535782f, 
    0.05062193f, -0.14918378f, -0.63677388f, -0.83389980f, -0.44508311f, 0.03309691f, -0.13143601f, -0.43643385f, 
    0.06207898f, 0.00840888f, -0.03603470f, -0.38663885f, 0.04524383f, -0.04057644f, -0.57201356f, 0.21949999f, 
    0.13699752f, 0.13128680f, 0.12319711f, 0.03448549f, 0.10714077f, -0.01192247f, 0.10981663f, -0.04788972f, 
    0.06933442f, -0.08455104f, -0.06078151f, 0.02264855f, 0.01464569f, 0.08932077f, 0.01201191f, 0.07923283f, 
    0.02972038f, -0.01951196f, 0.02594543f, -0.02914229f, 0.07275420f, -0.13537551f, -0.05823323f, -0.15940669f, 
    0.13158008f, -0.00110823f, 0.10912666f, -0.04039234f, 0.20362177f, 0.02535983f, 0.11344969f, -0.04018606f, 
    -0.00094544f, -0.24944580f, -0.01909449f, 0.13707848f, 0.05610242f, 0.01058195f, 0.03915423f, -0.04337465f, 
    0.10643557f, -0.15681151f, 0.15723091f, 0.09997672f, 0.10295646f, 0.13616349f, -0.12039055f, -0.03302473f, 
    0.10612614f, 0.06615491f, -0.21421610f, -0.07837827f, 0.06959551f, 0.22453678f, 0.00623093f, 0.07941133f, 
    0.03347193f, -0.16066611f, 0.01338406f, 0.15363802f, -0.06271856f, 0.18779333f, 0.10631455f, 0.11021931f, 
    0.11535846f, -0.18501461f, 0.08537813f, 0.02914010f, 0.09480456f, -0.49746591f, -0.08639000f, 0.05438975f, 
    0.01963201f, -0.11526055f, -0.11209246f, -0.06026705f, 0.02851775f, 0.24835861f, 0.09444863f, 0.00389575f, 
    -0.63283068f, 0.07649235f, -0.08201271f, 0.19742332f, -0.97513145f, -0.14771563f, -0.03243256f, -0.51311886f, 
    0.45498601f, -0.85956162f, 0.01084434f, 0.11543929f, 0.01018429f, -0.04125470f, 0.19340007f, -0.49842316f, 
    -0.10973826f, -0.34525940f, 0.06434294f, 0.01783470f, 0.16377303f, 0.24786964f, 0.07065380f, -0.84543931f, 
    -1.23442864f, 0.15618609f, 0.28201720f, -0.40284958f, -0.09454174f, 0.31069607f, 0.02348678f, -0.15799977f, 
    0.00985080f, 0.16127732f, 0.42862853f, 0.01487038f, -0.53464770f, -0.42899373f, -0.09500606f, -0.30422866f, 
    0.05442870f, 0.00077942f, -0.32990840f, -0.21087785f, -0.83626181f, -0.98726249f, 0.00636534f, 0.23509593f, 
    -0.42650059f, 0.07744498f, 0.04103858f, -0.08903882f, -0.54869330f, 0.24532157f, 0.27061060f, 0.10458461f, 
    -0.03683561f, 0.37168419f, -0.16851474f, -0.03334180f, 0.11474649f, 0.08438389f, -0.01014986f, 0.23991030f, 
    -0.44061917f, 0.08969037f, 0.08176638f, -1.08575249f, 0.01406455f, 0.09422655f, -0.00472198f, -0.13364647f, 
    -0.24858980f, -0.47588769f, 0.10912421f, -0.57189471f, -0.19204077f, -0.04580596f, -1.04802692f, -0.05136777f, 
    0.43720868f, -0.05556174f, -0.03913666f, -0.22162439f, -0.12004147f, -0.15642907f, 0.12282376f, -0.96469384f, 
    -0.19837117f, -0.31590599f, -0.46041915f, 0.15573916f, -0.05068601f, -0.11720115f, 0.32605547f, 0.10487299f, 
    0.00383542f, 0.25859356f, 0.02252005f, 0.32042092f, -0.13159262f, -0.32001615f, 0.04071612f, -0.29657432f, 
    0.00697265f, -0.00281156f, 0.21114801f, -0.22185606f, -0.46272314f, -0.61680138f, -0.13949950f, 0.02416310f, 
    -0.35598502f, 0.14074838f, 0.05800356f, 0.00928237f, -0.12611012f, 0.10946154f, -0.02734048f, -0.14160541f, 
    0.04302108f, -0.39930227f, -0.16330774f, -0.08961774f, -0.10567144f, 0.18754403f, -0.09017494f, 0.11468341f, 
    -0.68674910f, 0.10024349f, -0.10275098f, 0.03285342f, 0.16378348f, -0.06818633f, -0.12237967f, -1.09309685f, 
    -0.33393890f, -0.73834306f, -0.00667655f, 0.12548825f, -0.46188471f, -0.03597240f, -0.26561049f, -0.04401785f, 
    -0.37052920f, -0.05851400f, 0.07447137f, 0.04934673f, 0.37111971f, -0.03141866f, 0.04112607f, -1.00778925f, 
    0.20369601f, -0.04851934f, 0.12532780f, -0.67967588f, -0.09164283f, -0.14535871f, 0.23870175f, 0.03353711f, 
    0.10081636f, 0.06710434f, -0.26377201f, 0.25465858f, -0.06937494f, 0.32944793f, 0.02321286f, 0.56339288f, 
    -0.16096085f, -0.06087352f, 0.02180775f, -0.43735221f, -0.82395679f, -0.44004819f, -0.03207919f, -0.05336855f, 
    -0.72302073f, 0.05562979f, 0.13061342f, 0.07693264f, 0.26394206f, -0.65155274f, -0.46121466f, -0.02231736f, 
    -0.13994426f, -0.07707328f, 0.05048224f, 0.08748364f, 0.07332598f, 0.11459304f, -0.36229295f, -0.39235497f, 
    -0.02967117f, 0.06175248f, 0.10228776f, 0.21854061f, -0.60915303f, 0.04661442f, -0.07495993f, -0.43424523f, 
    -0.75230604f, -0.04755867f, -0.08790890f, 0.05286928f, 0.02530168f, 0.04739595f, 0.23557082f, 0.09550074f, 
    -0.11554053f, 0.10557808f, -0.06484812f, 0.12488590f, -0.07452748f, -1.55849409f, 0.09785606f, 0.50644022f, 
    -0.25068232f, 0.08987411f, -0.04785066f, 0.07418408f, -0.00979790f, 0.16678573f, -0.22265179f, -0.02674601f, 
    -0.11510715f, 0.01145910f, 0.12904736f, -0.14050038f, 0.00092176f, -0.37039185f, -0.09557934f, -0.31756413f, 
    -0.16327722f, 0.01870702f, -0.64555591f, -0.48368886f, 0.07366522f, 0.17752248f, -0.43775079f, 0.10177521f, 
    -0.20608088f, 0.30622527f, -0.03470751f, 0.00976512f, -0.19277857f, 0.24731505f, 0.16653466f, 0.07761430f, 
    -0.17351085f, -0.47977009f, -0.09239271f, -0.10741863f, 0.03180620f, -0.18467921f, 0.55645084f, 0.05966067f, 
    -0.76687384f, -0.14506064f, -0.01597106f, -0.13599899f, 0.19527879f, 0.01843777f, -0.07310095f, -0.37321982f, 
    -0.61265111f, 0.25466669f, 0.08340600f, 0.03851023f, 0.27086115f, -0.10107549f, -0.33687294f, -1.14940822f, 
    0.09717238f, 0.44980320f, -0.01819889f, -0.23699181f, 0.08216084f, -0.29819626f, 0.04822387f, -0.88140088f, 
    0.11674341f, 0.09308983f, -0.08455397f, -0.55988204f, -0.04035659f, 0.35968477f, 0.19186033f, -0.05318372f, 
    -0.06927614f, -0.67687070f, -0.21454500f, -0.06774391f, -0.96427244f, 0.40719199f, -0.01329207f, 0.03603464f, 
    -0.04819196f, -0.06818547f, 0.25534210f, -0.28608355f, 0.35699555f, -0.39100686f, -0.66505504f, -0.29315618f, 
    -0.28200078f, -0.09055898f, -0.16638519f, -0.02575693f, 0.22129005f, 0.05652893f, 0.31711403f, -0.01863825f, 
    -0.07581089f, -0.36771259f, -0.05938691f, -0.12035903f, -0.01674158f, 0.28529188f, -0.47516599f, 0.35832685f, 
    -0.42036644f, -0.03616856f, -0.06992096f, 0.17908578f, -0.07690569f, 0.05290809f, -0.00994410f, -1.42995405f, 
    -0.14612308f, 0.28312710f, -0.11009722f, 0.00524761f, -0.13047272f, -0.00685456f, -0.46342072f, -0.12925068f, 
    -0.13391052f, 0.51095492f, -0.03795952f, 0.19273725f, 0.10910240f, 0.04010863f, 0.05233398f, -0.08778176f, 
    -0.40670234f, 0.11522246f, -0.03618922f, -0.28699666f, 0.05477539f, -0.17115337f, -0.05975701f, -0.03774639f, 
    -0.07052514f, -0.16765194f, 0.01141608f, 0.23464322f, 0.33292934f, 0.12649316f, 0.05628070f, -0.34437212f, 
    0.02379885f, 0.10745459f, -0.52064568f, -0.20843832f, 0.11384299f, 0.42747366f, -0.03667627f, 0.19477731f, 
    -0.39803588f, 0.18746038f, -0.02497046f, 0.05261157f, 0.24541210f, -0.29880756f, -0.25145155f, -0.17515293f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17122948f, 0.29127714f, -0.03451644f, 0.09357280f, -0.17111124f, -0.30168927f, -0.05243537f, -0.20916873f, 
    0.10704279f, 0.10238399f, 0.26213604f, 0.06741195f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
