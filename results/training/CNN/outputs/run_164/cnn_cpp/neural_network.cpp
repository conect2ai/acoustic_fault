#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.75333905f, -1.13658178f, -1.04249120f, -0.24473079f, 0.10711072f, -1.14733434f, 0.41567469f, 0.57747239f, 
    -0.54920900f, 0.27350128f, 0.21257518f, -0.06136669f, 0.07868255f, -0.35979110f, 0.03205316f, -0.06658312f, 
    0.42441413f, 0.10046193f, -0.19113642f, -0.11627780f, -0.01222048f, -0.12274129f, -0.01671558f, 0.05587115f, 
    0.10415938f, 1.26416147f, 0.66450840f, 0.34391797f, 1.11529469f, -0.13508794f, 0.42003995f, 0.33101556f, 
    0.04751019f, 0.49462736f, 0.05285277f, -0.51207101f, 0.02960925f, -0.39520985f, 0.26664186f, 0.10276973f, 
    -0.20395602f, -0.15066363f, -0.42739823f, -0.51689917f, 0.28002706f, -0.43641999f, -0.26100668f, -0.12174873f, 
    0.15209727f, 0.32022408f, -0.83270156f, -1.01997864f, -0.78629035f, -0.08285228f, 0.31123093f, 0.40045318f, 
    0.13156794f, -0.52595031f, 0.67597085f, -0.19124709f, 0.03245680f, 0.21441169f, 0.28656769f, 0.11819831f, 
    -0.31923679f, -0.42296609f, 0.24805443f, -0.11253422f, -0.32184979f, -0.16286805f, 0.28270522f, -0.05194529f, 
    0.05134458f, 0.29657489f, -0.25837022f, 0.53175050f, 0.04468887f, -0.72770554f, -0.58226568f, 0.19446774f, 
    0.73420876f, -1.00395679f, 0.80242205f, 0.96564156f, 0.63041055f, -0.63968921f, -0.18430977f, -0.35589075f, 
    -0.12462121f, 0.22437695f, 0.20437080f, -0.15434960f, 0.08364775f, 0.02770392f, 0.47705081f, -0.07305541f, 
    0.09492368f, -0.19730867f, -0.04396414f, -0.45958862f, -0.99021846f, -0.98737383f, 0.74803305f, 0.65187979f, 
    -0.86823338f, 0.16328597f, 0.36203277f, 0.73802066f, -0.38308674f, -0.57513601f, -0.25515631f, 0.21833839f, 
    -0.31197521f, 0.61907846f, 0.10491901f, -0.19280614f, -0.15230003f, -0.21837917f, -0.04896714f, -0.35176349f, 
    0.19396468f, -0.06963582f, 0.26828012f, 0.21715713f, -0.05751138f, -0.09226181f, -0.61084026f, 0.43566746f, 
    0.80411226f, -0.24870858f, -0.55406946f, -1.14392579f, -0.51546323f, -0.58994192f, -0.15720496f, -0.06396622f, 
    0.03523660f, 0.16472962f, -0.33984321f, 0.42579710f, -0.09672351f, -0.22771727f, 0.08126955f, -0.04192961f, 
    0.46340072f, 0.33905160f, 0.42325509f, 0.61177713f, -0.04914892f, -0.17599025f, -1.46448386f, -0.58295494f, 
    0.07977476f, -0.08405740f, -0.11167601f, 0.67647976f, 0.57385069f, 0.07010420f, 0.07257817f, -0.05962346f, 
    0.29816568f, -0.21823190f, 0.70545793f, -0.12289353f, 0.18196389f, 0.12513442f, -0.01434478f, 0.36195311f, 
    -0.59915566f, -0.13210621f, -0.12730104f, -0.32933775f, -0.49478588f, -0.46954799f, -0.41893503f, 1.52816260f, 
    0.80541259f, 1.11411190f, -0.14630039f, -0.24689962f, -0.07691884f, -0.22064605f, -0.24425383f, 0.48925945f, 
    0.50310653f, 0.01847618f, 0.24544214f, -0.16312736f, -0.18459685f, -0.04799289f, 0.27310130f, -0.05387303f, 
    -0.01058280f, -0.07440126f, -0.28090605f, -0.12769841f, 0.12338649f, 0.11236552f, -0.16292033f, 0.05173765f, 
    -0.21193713f, 0.06244572f, -0.92259187f, -1.02859616f, -0.09536876f, -0.68482405f, -0.23367195f, 0.31957126f, 
    0.53432083f, 0.23916529f, -0.47530669f, -0.23655353f, 0.11151647f, -0.16525403f, -0.70237142f, -0.18326595f, 
    0.52804410f, 0.23047255f, -0.02659413f, 0.09231998f, 0.36341804f, -0.09677441f, 0.49851412f, 0.19482820f, 
    -0.00650631f, 0.26716235f, -0.82673949f, 0.07632972f, 0.65311629f, 0.18927689f, 0.75525028f, -0.15019961f, 
    -0.42633927f, -0.48084852f, -0.06091606f, -0.41791579f, 0.45318788f, -0.11878355f, -0.20318697f, -0.76713294f, 
    -0.46793023f, 0.33719021f, 0.21854825f, -0.53381443f, -0.76694852f, 0.08746556f, -0.40640652f, -0.13013594f, 
    -0.16946478f, 0.07388835f, 0.85508341f, -1.45931566f, -0.04635364f, 0.70422751f, -0.01984316f, -0.42778867f, 
    1.44676280f, 0.19732042f, -0.02277630f, 0.27883744f, 0.05520152f, 0.17125264f, -0.33249748f, -0.24807367f, 
    -0.05536876f, -0.29315436f, 0.06454719f, -0.51798087f, 0.21543051f, -0.40377325f, 0.15957236f, -0.01633138f, 
    0.00619138f, -0.10347177f, 0.12516363f, -1.25271297f, 1.40531421f, 0.82546985f, -0.98278648f, 0.52429843f, 
    0.65514922f, -0.52116668f, -0.78812265f, -0.46179172f, -0.86343449f, -0.18245588f, -0.04072930f, 0.00680923f, 
    0.52757347f, -0.39630678f, -0.30568939f, 0.08137510f, -0.23742858f, -0.22913906f, 0.19380078f, -0.28926015f, 
    0.19415995f, 0.18182716f, 0.10987464f, 0.10472289f, -0.14271200f, -0.83524877f, 0.00102330f, 0.37354031f, 
    -0.13382807f, 0.42438078f, -0.64657480f, 0.59087479f, -0.49368235f, -1.02283692f, 0.28001407f, -0.29030088f, 
    -0.12657504f, 0.14218713f, -0.02452892f, 0.28134480f, 0.43927789f, -0.35515317f, -0.25393498f, 0.33459356f, 
    -0.08495546f, 0.08945623f, 0.73798686f, -0.18223274f, 0.15917201f, -0.11151274f, 0.57327873f, 1.22121203f, 
    0.31252253f, -0.88116717f, -1.08492422f, 0.16716352f, -0.10362895f, -0.54070073f, -0.02962507f, 0.43968946f, 
    0.52609873f, -0.23253152f, -0.11056101f, 0.40714788f, 0.10610894f, 0.02649186f, 0.32820386f, 0.31047627f, 
    -0.07628227f, -0.43117601f, 0.14803892f, -0.15182291f, -0.04669255f, 0.18666279f, 0.96126926f, 0.13884921f, 
    -0.73293924f, -0.74242622f, 0.25983229f, 0.90561432f, 0.62865978f, 0.16157666f, 0.26831993f, 0.63160723f, 
    0.17697728f, -0.23751681f, -0.09807674f, 0.00153827f, -0.06143142f, -0.26293576f, 0.01333780f, -0.26740351f, 
    -0.01940635f, -0.05868635f, -0.21004036f, -0.01101126f, -0.30541003f, -0.10522194f, -0.02746035f, 0.38855591f, 
    -0.11667047f, -0.00874062f, -0.95479149f, -0.71184427f, -0.71762800f, -0.03125834f, -0.44040415f, -0.15127498f, 
    -0.38563713f, -0.43417060f, 0.67741442f, -0.28228453f, -0.08997622f, -0.44782111f, 0.11072147f, -0.30440295f, 
    0.37954500f, 0.50788224f, 0.40256765f, -0.41619828f, 0.08701006f, -0.49838594f, -0.22815087f, -0.09360756f, 
    -0.79989868f, 0.88050610f, 0.46925849f, -0.89238238f, -0.29923528f, -0.21200213f, 0.55310208f, 0.49433893f, 
    -0.55224264f, -0.33102354f, 0.46570873f, 0.66192430f, 0.13683170f, 0.01742101f, 0.16680831f, -0.13843130f, 
    0.36250526f, -0.35041267f, -0.36799884f, 0.24374650f, 0.11380689f, 0.39684603f, 0.03065571f, 0.35830650f, 
    -0.69779211f, -0.10011024f, 0.29263756f, -0.18197438f, -0.60303241f, -0.50950319f, 0.02254821f, 0.79565543f, 
    -0.37883791f, -0.34338725f, -0.70104611f, -0.02433388f, -0.40223849f, -0.75780392f, -0.49782479f, -0.65049195f, 
    -0.32621911f, 0.25067186f, 0.66511440f, 0.26576567f, -0.51559925f, -0.24958920f, -0.53960794f, -0.11132830f, 
    -0.20162314f, -0.11961661f, -0.34491014f, -1.28246832f, 0.22959386f, 1.07038772f, 0.81576550f, 0.42170140f, 
    0.58574229f, 0.85952210f, 0.18302295f, -0.16814813f, 0.13340768f, -0.48057207f, -0.28771305f, 0.51236880f, 
    0.24173021f, 0.27559540f, 0.15877554f, -0.06513372f, -0.02721848f, 0.14005803f, 0.06864759f, 0.06423303f, 
    -0.29551098f, 0.08127467f, -0.19717766f, 0.27243197f, 0.69615865f, 0.47067162f, 1.29108429f, 0.61168349f, 
    0.90139753f, -0.22436452f, 0.41843492f, 0.08595798f, 0.29951105f, 0.36730081f, 0.26075318f, -0.12837334f, 
    -0.17971095f, 0.16787344f, 0.01433593f, -0.19054319f, 0.13204490f, 0.17267616f, 0.38128623f, 0.47301385f, 
    -0.17899151f, 0.42296827f, -0.44983581f, -0.19679959f, -0.02007652f, -0.12479120f, 0.74791980f, 0.02927763f, 
    0.67871261f, -0.85139108f, 0.42040598f, -0.81837893f, -0.98003548f, -0.06155192f, 0.48719218f, 0.80000627f, 
    0.38180694f, 0.46203780f, 0.23069215f, 0.12706080f, 0.15340762f, -0.34287465f, 0.13858224f, -0.01302026f, 
    0.04206511f, 0.22542208f, 0.23358583f, 0.22235587f, -0.12227854f, 0.25387654f, -0.38706741f, -0.67006177f, 
    0.10799679f, 0.87017775f, 0.66609502f, 0.34141138f, -0.53811061f, 0.21125810f, -0.14110287f, 0.42705080f, 
    0.36007178f, 0.07928347f, 0.33676782f, 0.35562053f, -0.19072203f, 0.13984761f, 0.52667713f, 0.08429432f, 
    0.33211154f, 0.21315400f, 0.30250946f, 0.50334126f, 0.03979640f, -0.18261090f, -0.18695696f, 0.43327403f, 
    0.66278619f, 1.02137661f, -0.15637645f, -0.59137976f, -0.12357838f, -1.02649844f, -0.20093006f, -0.34157681f, 
    0.00771195f, 0.14637794f, -0.09530246f, -0.18656826f, -0.60869521f, 0.02277903f, 0.16551881f, 0.33147416f, 
    0.08467655f, -0.32280809f, -0.27426502f, -0.11946660f, -0.45955008f, -0.38300911f, -0.04128404f, -0.75577372f, 
    0.03229711f, -0.55693108f, -0.06229235f, -0.71130961f, -0.13877133f, -0.55721766f, 0.18978004f, -0.28173870f, 
    -0.64873695f, 0.47575030f, 0.31152353f, 0.37571263f, 0.51375657f, -0.38300309f, -0.57299668f, -0.48298666f, 
    0.19923459f, -0.44110841f, 0.30758020f, 0.31824785f, -0.34133264f, -0.02402689f, 0.03151338f, 0.50412232f, 
    0.61995733f, 0.58287448f, 0.95140111f, -0.36200488f, -1.41598880f, 0.30571577f, -1.03975499f, 0.12732309f, 
    0.03204501f, -0.15032235f, 0.21752107f, 0.17932616f, -0.15903826f, 0.09177147f, 0.00889196f, -0.07876335f, 
    -0.15716180f, 0.02321975f, -0.00460974f, -0.15661797f, -0.03339022f, 0.06413983f, 0.16511016f, 0.13945100f, 
    0.01318009f, -0.84787136f, -0.53814816f, -0.31719652f, 0.31196070f, 0.15259475f, -1.31516123f, -0.39101040f, 
    0.05039351f, 0.34741551f, -0.29406160f, 0.74561250f, 0.51778203f, -0.29650083f, 0.11517299f, -0.01664984f, 
    0.22240631f, -0.03977661f, -0.16180523f, -0.08652802f, -0.23048045f, -0.07089807f, 0.12937175f, 0.09276682f, 
    0.10686476f, 0.05890704f, 1.14923930f, 0.58171022f, -1.21785188f, 1.04753423f, -1.12805510f, -0.39221615f, 
    0.22514121f, -0.55285168f, 0.46988717f, 0.16886960f, 0.41015506f, 0.04318840f, 0.34328443f, -0.06682546f, 
    0.12402879f, 0.07198411f, -0.30117971f, -0.12959808f, -0.01313563f, 0.10036388f, 0.02092321f, 0.31733856f, 
    0.07576388f, 0.06373347f, -0.29981250f, -0.83077329f, -0.73948580f, -0.84037381f, -0.35438907f, -0.71521503f, 
    0.83549041f, 0.83609605f, 0.06622634f, -0.03704624f, 0.91004908f, -0.41857576f, -0.37253791f, 0.05526381f, 
    -0.27231452f, 0.06277382f, -0.17200150f, 0.39103177f, 0.22883470f, -0.06501158f, -0.03278003f, -0.02596722f, 
    -0.25273812f, -0.28576279f, -0.26362860f, 0.21151628f, 1.18542409f, 0.94662040f, 0.84077126f, 0.85299104f, 
    0.69981611f, -0.52586436f, -0.17897318f, -0.42643401f, 0.14438102f, -0.35921055f, 0.13255234f, -0.06212441f, 
    -0.38332349f, 0.18560168f, -0.04406394f, 0.00440389f, 0.24960691f, 0.33687532f, -0.17101717f, 0.16762727f, 
    0.32536349f, 0.34096321f, 0.33972585f, 0.43490914f, 0.35485849f, -0.08771779f, -0.99307311f, -0.31428653f, 
    0.18130010f, -0.39933234f, 0.32126161f, 0.84815377f, 0.26451573f, -0.28543764f, 0.70858276f, -0.73322558f, 
    -0.05146449f, -0.28844327f, -0.01348271f, -0.34538636f, -0.62270749f, -0.54587859f, -0.18965416f, -0.20199099f, 
    -0.19579296f, -0.19017254f, 0.30077600f, -0.04370708f, 0.15301485f, -0.04348337f, -0.53414917f, -0.87733060f, 
    -0.84479916f, -0.69381297f, -0.57613939f, -0.24310580f, 0.56147164f, 0.41966337f, 0.76833397f, 0.30192262f, 
    -0.44322678f, -0.09467687f, 0.46598604f, -0.18822286f, -0.20683122f, 0.04405741f, -0.13375320f, 0.15339106f, 
    0.29019037f, 0.05810318f, 0.00923545f, 0.27071291f, -0.30681869f, -0.06872217f, 0.30377176f, -0.66875565f, 
    -0.21062079f, -0.35456321f, -0.37266234f, -0.50579774f, -0.86502129f, -0.22089665f, 0.38687736f, 0.23001227f, 
    0.22301251f, -0.05174067f, 0.58993798f, -0.52493614f, 0.27015948f, -0.10681663f, -0.04978697f, 0.30976468f, 
    -0.41626683f, -0.30657375f, -0.26144385f, 0.13333565f, -0.31604937f, 0.66404623f, -0.04116109f, 0.50795418f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05671929f, 0.51190144f, 0.27880308f, 0.00339809f, 0.24259135f, 0.26572984f, 0.04646640f, 0.39394134f, 
    0.12205550f, 0.32437664f, 0.02853162f, 0.17790940f, 0.37576407f, 0.01358223f, 0.37194180f, 0.18976305f, 
    0.23157385f, -0.18106674f, 0.22419085f, 0.23314343f, 0.23631978f, 0.16202870f, 0.12506571f, 0.20001920f, 
    0.31897330f, 0.40280014f, 0.19563037f, 0.16190070f, 0.23658374f, 0.24736884f, 0.15053754f, 0.07001786f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.68691564f, 0.16824366f, -0.13593897f, 0.05171507f, -0.01203009f, -0.04418907f, 0.06015494f, 0.09331256f, 
    0.01841800f, -0.07163983f, -0.04325014f, 0.04406330f, 0.14489059f, -0.08209777f, -0.29124129f, 0.26389530f, 
    -0.18294828f, -0.16884689f, -0.12494434f, 0.13520044f, -0.06453539f, -0.04976108f, 0.00926825f, 0.09326762f, 
    -0.25140747f, 0.08531574f, 0.02825994f, -0.20755984f, 0.15583239f, 0.00372622f, -0.04042539f, 0.07054988f, 
    0.01809829f, -0.07441455f, -0.09665789f, -0.01271534f, 0.66357934f, -0.23647684f, 0.07184126f, -0.16085577f, 
    -0.06973299f, -0.05962683f, 0.07469871f, -0.10100140f, -0.13228439f, -0.10192801f, 0.14583117f, 0.17001973f, 
    -0.34250051f, 0.24464491f, -0.00748433f, 0.37008390f, 0.00188544f, 0.01423908f, 0.06706591f, 0.06642395f, 
    0.21690907f, 0.04424059f, 0.11078666f, -0.14473136f, 0.06120738f, -0.14431937f, -0.24464598f, 0.37180960f, 
    0.16432439f, 0.01765890f, -0.16107577f, 0.02231785f, -0.07517128f, -0.06598297f, -0.03363370f, -0.02631069f, 
    0.35670376f, -0.10535114f, 0.05730371f, -0.01935508f, 0.04827051f, -0.05700764f, -0.00550887f, 0.06330441f, 
    0.12038884f, -0.11604339f, 0.08211507f, 0.02098755f, 0.17447799f, 0.04089275f, -0.18868624f, -0.13335015f, 
    -0.10190134f, -0.28119946f, -0.11953638f, 0.08473672f, 0.06431048f, 0.02042470f, 0.01674858f, -0.04331078f, 
    -0.16883284f, 0.17360763f, -0.06480259f, -0.49156857f, -0.01155106f, -0.00427522f, 0.14635892f, 0.16516730f, 
    -0.00784563f, 0.20696472f, -0.03460363f, -0.17919831f, -0.14074436f, -0.10045295f, -0.06027994f, 0.27416801f, 
    -0.09822024f, -0.03643186f, 0.16073504f, 0.07782100f, -0.24916388f, 0.13709468f, -0.16234484f, -0.00980094f, 
    -0.20998476f, 0.18516089f, 0.00904128f, 0.29025614f, -0.06377058f, -0.05010789f, 0.03865995f, -0.15936869f, 
    -0.09938968f, 0.16488111f, -0.10491247f, -0.04109049f, -0.70737630f, 0.18876418f, 0.25638950f, -0.40209162f, 
    0.06436804f, -0.06339787f, 0.06959051f, 0.00864338f, 0.08935117f, -0.08945919f, -0.06608936f, 0.02811747f, 
    0.02255760f, -0.11863722f, -0.02070573f, 0.25197959f, -0.04015420f, 0.12542047f, -0.08695537f, 0.07876625f, 
    -0.16119912f, -0.13683027f, -0.02814424f, -0.27770329f, -0.35584179f, 0.37482509f, -0.09768794f, 0.33672148f, 
    0.04913733f, 0.10374340f, -0.07398853f, -0.07279550f, 0.06928516f, 0.18233320f, -0.04235603f, 0.01017483f, 
    0.02028637f, 0.00073467f, 0.17262617f, -0.26390138f, 0.07556619f, 0.11168303f, 0.00780749f, -0.03170601f, 
    -0.05498309f, 0.09814100f, 0.10103946f, 0.08124777f, -0.43979514f, 0.00061973f, 0.28242028f, -0.36396730f, 
    0.07297660f, 0.05274576f, -0.11755549f, 0.02122351f, -0.00713047f, -0.06571521f, 0.03754738f, -0.15915655f, 
    -0.33416176f, 0.18616681f, 0.05119344f, 0.07316235f, -0.05387221f, 0.20981975f, -0.06837783f, -0.10750619f, 
    0.03371523f, -0.12243170f, 0.13424997f, -0.01329653f, -0.17060308f, 0.39616898f, 0.23116714f, -0.47896570f, 
    0.04301451f, -0.00029622f, -0.04816504f, -0.01127773f, -0.02707400f, 0.31373662f, 0.23121652f, -0.00547745f, 
    -0.31933674f, 0.17478488f, -0.12020105f, 0.31363836f, 0.12992550f, 0.10009579f, 0.06702252f, -0.04280224f, 
    0.03457437f, -0.24600826f, -0.05700429f, -0.05626034f, 0.04883179f, 0.06455228f, -0.03748446f, 0.18805617f, 
    -0.11709069f, 0.12235073f, 0.05226275f, -0.12568094f, 0.08696369f, 0.02634091f, 0.00037286f, -0.06798361f, 
    0.07775471f, -0.14353387f, -0.08960176f, 0.14079182f, -0.07856002f, 0.06613335f, -0.16717383f, -0.00045356f, 
    -0.01346655f, 0.10944568f, 0.02327123f, 0.07393388f, -0.09934574f, -0.03187084f, 0.04925865f, 0.06063115f, 
    0.00903746f, 0.11345217f, 0.07325280f, -0.12500966f, 0.05106133f, 0.05589652f, -0.04986411f, -0.07715712f, 
    0.00967369f, 0.05776423f, -0.19909924f, 0.20368701f, -0.12836812f, 0.02216157f, 0.04279792f, 0.07747249f, 
    0.01902824f, 0.19075853f, -0.16609584f, 0.07345661f, -0.21851793f, -0.27692842f, -0.19777659f, 0.01957806f, 
    -0.08169487f, 0.13637251f, 0.05919115f, 0.04820875f, 0.00424464f, -0.05534133f, -0.09693123f, 0.11772841f, 
    -0.15213697f, 0.10118429f, -0.15076025f, 0.12151457f, -0.16375634f, -0.10204703f, -0.07856815f, -0.23375534f, 
    -0.08144645f, -0.00426975f, -0.13136683f, 0.08961973f, -0.28774762f, -0.00384702f, -0.22708237f, 0.34528720f, 
    -0.08554871f, -0.20595331f, -0.10036105f, -0.04914846f, 0.06118384f, 0.06674711f, 0.00735527f, -0.11213210f, 
    -0.26044971f, 0.11381943f, -0.22111893f, 0.14550926f, -0.00874277f, 0.06856328f, -0.08434749f, -0.01537479f, 
    -0.05617962f, -0.02380706f, 0.12991801f, 0.09124036f, 0.47513238f, 0.13002233f, 0.14842728f, -0.37517232f, 
    0.07160005f, 0.03249661f, -0.05709951f, 0.13075815f, 0.10128829f, -0.07356692f, -0.05303813f, 0.15963694f, 
    0.23322903f, 0.16068400f, -0.09115149f, 0.06742706f, -0.33685783f, -0.19782406f, -0.08347175f, -0.00293863f, 
    -0.07240525f, -0.06854421f, -0.20849696f, -0.05195665f, -0.13464549f, 0.10002111f, 0.01921251f, -0.15018253f, 
    -0.03937812f, 0.06113305f, -0.11529970f, 0.06361172f, -0.04928119f, 0.06675117f, 0.06519787f, -0.07174419f, 
    0.14703059f, 0.23898122f, -0.25472668f, -0.65864432f, 0.14912882f, 0.05495807f, 0.15249626f, 0.01174595f, 
    -0.05368664f, -0.09719856f, -0.00720356f, 0.05082742f, -0.34390891f, -0.17191400f, -0.27597815f, -0.12703601f, 
    -0.05888977f, 0.05932393f, -0.00174674f, 0.05199189f, 0.08098504f, -0.00000920f, 0.07495725f, -0.28227884f, 
    0.58024281f, -0.06315660f, -0.03029315f, 0.08944445f, 0.01624681f, -0.01197665f, -0.10904761f, 0.01679358f, 
    0.01671443f, -0.10853564f, 0.14564547f, 0.01584230f, 0.33545941f, 0.14206040f, 0.07602595f, 0.26021194f, 
    -0.09199486f, 0.05280355f, 0.15163101f, 0.05265878f, -0.13969679f, 0.03202031f, 0.02125099f, -0.02175828f, 
    0.19805767f, -0.02601017f, -0.23483744f, 0.07950176f, 0.09305702f, -0.07864966f, 0.09522005f, 0.07600053f, 
    0.05099498f, -0.23596266f, 0.01322035f, -0.02253177f, -0.03023597f, -0.12733874f, 0.11767053f, -0.26553625f, 
    0.10950088f, -0.00223063f, -0.06410413f, 0.10213886f, 0.19478805f, 0.13336354f, -0.04303034f, -0.01565268f, 
    -0.41688412f, 0.06588098f, -0.27462235f, 0.30787852f, -0.17879364f, -0.11323889f, 0.00270336f, -0.07607913f, 
    -0.05899336f, -0.12643230f, -0.04253934f, 0.13631643f, -0.57218134f, -0.01839723f, -0.10799087f, -0.02617481f, 
    0.00481447f, -0.09249283f, -0.02664182f, 0.00373063f, -0.04948461f, 0.02793986f, 0.22146431f, 0.10427443f, 
    -0.32137319f, 0.25250420f, -0.03063989f, 0.10807892f, 0.11640421f, 0.05613067f, -0.23127653f, 0.07753288f, 
    -0.23300682f, -0.16878465f, 0.09237738f, 0.13020794f, 0.38728666f, 0.07060984f, 0.10994675f, 0.11870085f, 
    0.02904096f, -0.14014974f, 0.07985169f, -0.01875648f, -0.00720222f, -0.08186974f, -0.11087976f, -0.05758323f, 
    0.10209981f, -0.12712397f, 0.06871613f, -0.62594545f, 0.07050550f, -0.07401498f, 0.10341480f, 0.04190404f, 
    0.20358568f, -0.32421362f, -0.00051849f, -0.01346739f, -0.05159116f, 0.05949052f, -0.10681245f, 0.09208792f, 
    -0.10937259f, -0.05060933f, -0.11844923f, -0.05196452f, -0.01295597f, -0.45311624f, 0.20813023f, -0.19527535f, 
    0.39513886f, -0.47998703f, -0.09653813f, 0.11934998f, -0.04339086f, 0.08270524f, 0.10565188f, -0.02186570f, 
    0.12642905f, -0.10159001f, -0.08842745f, -0.09745368f, -0.17378899f, -0.04693642f, -0.27585667f, -0.24167617f, 
    0.00442924f, 0.10000378f, 0.16016878f, -0.14177522f, -0.02484689f, 0.20634165f, 0.06205245f, -0.12057256f, 
    -0.24483082f, 0.28396305f, -0.12060812f, 0.03403662f, -0.00764612f, 0.11160935f, 0.13144246f, -0.12601653f, 
    0.10151593f, 0.05328582f, 0.01479018f, 0.01524912f, -0.42370570f, -0.01371309f, -0.42239979f, -0.07412329f, 
    -0.19059195f, -0.12423778f, -0.06282741f, -0.09509198f, 0.03728573f, -0.09998167f, -0.02367368f, 0.12677577f, 
    0.37026444f, -0.35635877f, 0.09677157f, -0.21206427f, -0.00400728f, -0.02284931f, 0.00466911f, -0.01652003f, 
    -0.07400830f, -0.04330455f, -0.08382509f, -0.00169155f, 0.15410860f, -0.10186668f, -0.13869053f, -0.01049337f, 
    0.29240385f, 0.04419839f, -0.04646514f, -0.05593121f, -0.09707583f, 0.07214370f, 0.01343752f, 0.13536941f, 
    -0.33084741f, 0.18571956f, -0.07717253f, -0.21694314f, 0.12066260f, -0.14153472f, 0.04510912f, -0.03520908f, 
    -0.07797460f, 0.11144906f, -0.00036450f, -0.25880167f, -0.22708637f, -0.08116625f, -0.48936996f, -0.16331781f, 
    0.02762597f, 0.03010505f, -0.08714701f, 0.13009149f, 0.07536348f, -0.38959101f, -0.19065924f, -0.10617062f, 
    0.14875373f, 0.21577196f, -0.16977665f, 0.16144007f, -0.03488688f, 0.13322277f, -0.13824417f, 0.10080363f, 
    0.04899715f, 0.29651120f, 0.03931829f, -0.13691717f, 0.18851238f, 0.09498273f, 0.25540930f, 0.33017474f, 
    -0.06379486f, -0.15612960f, -0.10937835f, -0.04899444f, -0.09201451f, 0.04077909f, 0.03348336f, 0.12284130f, 
    -0.32434946f, 0.07140033f, 0.07985943f, -0.03348227f, 0.06941201f, -0.09557394f, 0.11106036f, 0.04481791f, 
    0.27977949f, 0.09239221f, -0.03554786f, -0.08127691f, 0.31287649f, -0.16279364f, -0.19476867f, -0.03886126f, 
    0.09528335f, -0.04283748f, -0.24843469f, 0.00490132f, -0.08073948f, 0.10951486f, 0.00560527f, -0.08617844f, 
    0.08123412f, -0.26158461f, -0.28941312f, 0.11664236f, 0.03032637f, -0.05027198f, -0.11992482f, -0.02032249f, 
    -0.01689492f, -0.22832720f, 0.12522383f, -0.19328587f, -0.28528696f, -0.25438124f, -0.08654669f, 0.10851394f, 
    -0.01664682f, 0.06800754f, -0.16239031f, 0.16125147f, 0.15827325f, 0.00572061f, 0.11699092f, -0.07207984f, 
    -0.15270633f, 0.15334776f, -0.16087824f, -0.24163766f, -0.00971454f, 0.02963289f, 0.08202430f, 0.01874335f, 
    0.01376210f, -0.00208548f, 0.17791320f, -0.00523715f, 0.07011483f, -0.04229377f, -0.15616626f, 0.04316805f, 
    0.03740469f, 0.14485237f, -0.04251002f, 0.18326481f, -0.08883014f, -0.14103180f, -0.08050671f, 0.12822525f, 
    0.52525669f, -0.54391068f, -0.13447692f, 0.09337850f, -0.02435493f, -0.06421325f, 0.08405566f, 0.15606222f, 
    -0.08673094f, 0.10958129f, -0.17931767f, 0.15536401f, -0.08586050f, -0.00445669f, -0.13137516f, -0.07216274f, 
    0.11511373f, -0.01766416f, 0.00470117f, -0.00573384f, 0.11366785f, 0.13928890f, 0.04729820f, -0.13252260f, 
    0.27437165f, 0.00958028f, 0.12669051f, 0.37204298f, -0.01273941f, 0.00800703f, 0.15276648f, 0.01839761f, 
    0.01549334f, -0.05279651f, 0.02624956f, 0.09100262f, 0.09890416f, -0.11317398f, 0.00368627f, 0.19546360f, 
    0.01908298f, 0.02123733f, 0.06898252f, -0.03878285f, 0.10607179f, -0.06961130f, -0.33423725f, -0.10119168f, 
    0.04872645f, -0.23216529f, -0.12817825f, -0.21124452f, 0.18430661f, -0.06034210f, 0.03230084f, 0.03847356f, 
    0.09563317f, 0.00103737f, -0.03051479f, 0.01583949f, -0.28558835f, -0.01854781f, -0.05774320f, -0.10022496f, 
    0.09360749f, -0.11673857f, -0.12133022f, 0.08363508f, 0.04323097f, -0.18715905f, -0.05471064f, -0.01471934f, 
    0.74210316f, -0.32608321f, -0.23646712f, 0.34319022f, -0.18371555f, -0.05929071f, 0.02504636f, 0.01774410f, 
    -0.05104101f, 0.07564888f, 0.08319691f, 0.04544902f, 0.08772773f, -0.06773558f, -0.04840315f, -0.12032100f, 
    0.08506227f, 0.00342060f, -0.01392338f, -0.04105740f, -0.08033538f, 0.15038088f, 0.09238137f, -0.00854767f, 
    0.09572703f, -0.11408994f, 0.26038033f, -0.07865555f, -0.17071383f, 0.10591552f, -0.42730516f, 0.07844847f, 
    0.02368909f, 0.00534097f, -0.17917986f, 0.07871819f, -0.20620815f, 0.25830081f, -0.00312107f, 0.41729879f, 
    0.10596577f, 0.04133930f, 0.13130490f, 0.12282541f, -0.00877340f, -0.15144607f, -0.05568694f, -0.06114400f, 
    0.18302533f, -0.02147209f, -0.32416767f, -0.32924926f, -0.28178385f, 0.11832482f, -0.10657066f, 0.10837072f, 
    0.30898541f, 0.00640834f, -0.08338374f, -0.16991931f, -0.22908558f, -0.29069355f, -0.14538650f, -0.23481488f, 
    -0.13499413f, 0.11729052f, -0.08052719f, 0.01027936f, 0.08778249f, 0.02235645f, 0.04411047f, -0.00557131f, 
    0.39446592f, 0.02366662f, 0.05827427f, -0.05030997f, -0.10580532f, -0.11622276f, -0.12154756f, 0.20241669f, 
    -0.01990352f, -0.00695775f, -0.16003217f, -0.19062370f, -0.16766898f, 0.16382234f, 0.03888909f, -0.12372023f, 
    -0.02874949f, 0.08629547f, 0.12219788f, 0.10775819f, -0.03833476f, 0.06856637f, 0.05723284f, -0.05634245f, 
    -0.29083562f, 0.07314881f, -0.10410234f, 0.16318032f, -0.06952376f, -0.07846988f, -0.03042163f, -0.04621732f, 
    -0.04433582f, 0.08347250f, -0.07159095f, 0.12766856f, -0.30428055f, -0.39679870f, -0.02258894f, -0.05274681f, 
    -0.10368280f, 0.03625236f, -0.12919967f, 0.11907407f, 0.04574132f, 0.26927713f, -0.20402096f, -0.07139060f, 
    0.34220037f, -0.15401158f, 0.21232712f, -0.16957691f, -0.02088936f, -0.01168532f, 0.06972739f, 0.13758335f, 
    0.07125376f, 0.05001554f, 0.03980196f, -0.06653727f, 0.20061228f, 0.26464689f, -0.47577211f, -0.17212780f, 
    0.05482604f, 0.19343105f, -0.06251826f, -0.11259832f, -0.00827074f, 0.08843277f, -0.11193428f, 0.04817759f, 
    -0.40896118f, -0.15621385f, -0.35904378f, -0.14060201f, 0.02708344f, -0.11673926f, -0.12767781f, -0.02277668f, 
    0.06219261f, -0.09694660f, 0.09447894f, -0.21856834f, 0.27353051f, 0.11340695f, -0.04946720f, -0.21396695f, 
    0.00233563f, 0.21948874f, 0.08298833f, 0.05235628f, 0.04075573f, -0.00620029f, -0.13314246f, -0.12812750f, 
    0.11698926f, 0.15726496f, 0.11926733f, 0.02151545f, 0.03742108f, -0.02256818f, -0.00142700f, 0.03031078f, 
    -0.15323702f, -0.07581589f, 0.13015552f, 0.11489766f, -0.63528901f, 0.14559726f, -0.20261870f, -0.10266230f, 
    -0.19756936f, -0.02687719f, 0.04544564f, -0.13228604f, -0.16348277f, 0.00879023f, -0.02079533f, -0.15584721f, 
    0.20834409f, 0.00352128f, -0.11511540f, -0.27162758f, -0.05762130f, 0.20943940f, -0.08864580f, 0.05015420f, 
    -0.07360160f, -0.18215533f, 0.05796358f, -0.12274852f, -0.05256116f, -0.16097558f, -0.03303063f, -0.24735384f, 
    0.13519721f, -0.04411665f, 0.18717134f, 0.12392315f, -0.05653796f, 0.05576818f, 0.05350299f, -0.01058068f, 
    0.08843442f, -0.15393350f, 0.01065625f, 0.09025815f, 0.06212926f, 0.07213401f, -0.05608314f, -0.02785495f, 
    0.16802306f, -0.10115246f, 0.09216743f, 0.01617434f, 0.09702759f, 0.00324530f, 0.06895511f, -0.01832158f, 
    -0.04060262f, -0.04425524f, 0.11189038f, -0.14433393f, -0.21208234f, -0.04222839f, 0.09544938f, 0.09323299f, 
    0.38211897f, 0.12828866f, -0.16761367f, -0.09621688f, 0.08768127f, 0.10582355f, 0.05940317f, -0.03558471f, 
    -0.12960348f, -0.20338067f, -0.06692407f, -0.21105792f, 0.01660450f, -0.08579437f, 0.16706763f, -0.08285322f, 
    -0.08853917f, 0.11147846f, -0.07712460f, -0.07238992f, -0.10386918f, -0.20358957f, -0.15329990f, 0.07821271f, 
    0.02702205f, -0.02042012f, -0.28760973f, 0.07719816f, -0.00211409f, 0.04181198f, 0.00509635f, -0.18231487f, 
    -0.19268671f, -0.04140640f, -0.15792695f, -0.03869298f, -0.38575584f, 0.12848017f, -0.08077111f, -0.22117679f, 
    0.04712965f, -0.02432387f, -0.01907080f, -0.03704102f, -0.16323578f, 0.06692281f, -0.19221403f, -0.20779400f, 
    -0.69525355f, -0.06112662f, -0.01525317f, -0.24982053f, -0.00076630f, 0.12727450f, -0.03211610f, 0.04735291f, 
    0.03834649f, 0.08019359f, 0.02015145f, 0.00558710f, 0.35465410f, -0.36817360f, -0.16304842f, -0.11797934f, 
    0.04290199f, 0.02201932f, -0.14006297f, -0.16594499f, 0.05745380f, -0.05256220f, 0.13900425f, -0.15441380f, 
    0.06032990f, -0.09893239f, -0.14815508f, -0.06450613f, 0.04613139f, -0.13626824f, 0.10490126f, 0.01127480f, 
    -0.13735433f, 0.02243091f, -0.03822270f, -0.03368835f, 0.39669946f, 0.18318787f, 0.21623474f, 0.18348594f, 
    -0.11828085f, -0.19508807f, 0.06773989f, 0.15917508f, 0.04706669f, -0.02279308f, -0.10203341f, -0.09146340f, 
    0.02981677f, 0.01707109f, -0.20675670f, 0.07478653f, 0.21916640f, -0.01106597f, -0.01672674f, -0.04755585f, 
    -0.10816781f, 0.01789547f, 0.10266965f, 0.08108167f, 0.24050795f, -0.08956780f, 0.15478995f, 0.08721603f, 
    -0.15247880f, -0.10777811f, -0.07863665f, -0.10646331f, 0.15043083f, 0.19845018f, 0.12234525f, 0.13038963f, 
    0.10894012f, 0.29808915f, -0.07525407f, 0.39849859f, -0.19881207f, -0.19759756f, 0.06179465f, 0.20189162f, 
    -0.01960055f, 0.03238051f, -0.04153041f, 0.09368350f, 0.18935268f, -0.09464993f, -0.05563682f, 0.11927470f, 
    -0.07713915f, -0.01449441f, -0.13221166f, 0.05223334f, -0.00757700f, -0.12203262f, -0.01275567f, 0.01051185f, 
    0.07631679f, 0.08184405f, 0.04783439f, -0.05137653f, -0.05354067f, -0.12883089f, 0.04084048f, -0.06916150f, 
    -0.05173966f, 0.07780314f, -0.13076551f, -0.01072744f, -0.20075810f, -0.56374842f, -0.45385101f, -0.12816271f, 
    -0.22986968f, -0.08271979f, -0.07314758f, 0.09528618f, -0.01822828f, -0.07988226f, 0.07373063f, 0.09849194f, 
    0.27773497f, 0.09683397f, -0.25874412f, 0.07248127f, -0.13793810f, -0.16712874f, 0.08824372f, -0.01882790f, 
    -0.02037647f, 0.16888538f, 0.08280600f, 0.05855519f, -0.28821033f, 0.14804436f, -0.04725118f, 0.08507576f, 
    -0.16608228f, 0.01895811f, 0.03460936f, -0.12741001f, 0.05024264f, 0.03443060f, -0.00800237f, -0.02540199f, 
    0.27293319f, 0.09547736f, 0.24840070f, -0.16735815f, -0.03985726f, -0.01480543f, -0.01123571f, -0.01240956f, 
    -0.12695783f, -0.08654177f, 0.05088953f, 0.10439464f, 0.38095769f, 0.02051567f, 0.11342645f, 0.11588652f, 
    0.09220858f, 0.20402434f, -0.20785709f, -0.00748100f, 0.02103458f, 0.01960403f, -0.01197418f, -0.14174594f, 
    -0.10015010f, -0.04755919f, -0.15995921f, -0.15289073f, 0.01754431f, -0.08672654f, 0.00266338f, -0.07363646f, 
    0.13108207f, 0.11188755f, -0.11434636f, 0.18227822f, -0.37942562f, -0.44360468f, -0.61818254f, 0.11537381f, 
    -0.13165957f, -0.03296713f, -0.03635221f, 0.02954301f, -0.08013833f, -0.00540161f, -0.00217249f, -0.06570349f, 
    0.00542273f, 0.05094422f, 0.03614589f, -0.01523908f, -0.20299216f, -0.08993240f, 0.01462552f, 0.04456630f, 
    0.02864214f, 0.14808163f, -0.14515911f, 0.09208660f, 0.24031389f, -0.11008275f, -0.01526431f, 0.14018843f, 
    0.03001959f, 0.02284698f, 0.01362797f, 0.12440790f, 0.12872253f, 0.19858190f, -0.12659205f, 0.11204179f, 
    -0.19316362f, 0.08289479f, -0.00102749f, 0.26386830f, -0.00140068f, 0.01130037f, -0.03444622f, -0.09893860f, 
    -0.13438359f, 0.23672338f, 0.03500828f, 0.09172046f, 0.76923507f, 0.08481434f, 0.17560008f, 0.05129598f, 
    0.13013825f, -0.07900986f, -0.09260772f, 0.19806136f, -0.02377024f, -0.10838730f, 0.00422650f, -0.15752266f, 
    0.38023567f, 0.04418276f, 0.09217057f, 0.10476525f, -0.10497686f, -0.00222433f, -0.09356362f, -0.06977170f, 
    -0.01968996f, -0.12847388f, 0.02008186f, -0.11004546f, -0.55622381f, 0.22563143f, 0.06602729f, 0.19925386f, 
    0.03919451f, 0.09329764f, -0.04506211f, 0.13910852f, -0.08430867f, -0.25304255f, -0.01176900f, -0.14387149f, 
    -0.23003039f, 0.04301397f, -0.03423262f, -0.00562100f, 0.06187674f, 0.02903448f, -0.18517339f, -0.04002962f, 
    -0.23043142f, -0.13152665f, -0.09851852f, 0.04056384f, -0.06949491f, 0.31002420f, 0.04545525f, 0.12238514f, 
    0.01455185f, 0.08277412f, -0.01793392f, 0.10453822f, 0.14497723f, -0.00843643f, 0.05074969f, 0.14040034f, 
    -0.09477485f, 0.02976402f, 0.18445252f, -0.22094008f, 0.01775132f, 0.04446280f, 0.04872997f, -0.01287582f, 
    0.04938443f, -0.00527137f, -0.16214250f, 0.00408972f, -0.13381115f, 0.21616575f, 0.22711046f, 0.04681016f, 
    -0.14718121f, 0.09178051f, -0.12182393f, 0.08658756f, -0.00341365f, 0.16060710f, 0.13683057f, 0.10040776f, 
    -0.11949304f, 0.04908338f, 0.08104952f, 0.14614260f, -0.09469185f, -0.03502223f, 0.15240014f, -0.18075007f, 
    -0.05236394f, -0.03035023f, -0.10930462f, -0.00448341f, -0.58286768f, -0.14779809f, -0.26634565f, 0.15417294f, 
    -0.11394640f, -0.04445972f, 0.02163757f, -0.05053264f, -0.01804327f, 0.10014922f, 0.07612587f, -0.01845914f, 
    -0.44612136f, 0.17516147f, 0.35241315f, 0.13891216f, -0.00112270f, 0.06964228f, -0.02342353f, 0.05498541f, 
    -0.04700401f, -0.00212570f, -0.04927971f, -0.04077220f, 0.17323647f, 0.01430614f, -0.03820867f, 0.00240593f, 
    -0.00645021f, 0.11773754f, -0.06768359f, 0.00000845f, -0.01513044f, -0.04739088f, 0.02041030f, -0.00558921f, 
    -0.13639657f, 0.23340869f, -0.10340013f, 0.36285415f, 0.04618239f, 0.13516581f, 0.20338288f, 0.08958692f, 
    -0.05599650f, 0.06879659f, 0.01992842f, -0.02657259f, 0.13072930f, 0.14099512f, 0.06974237f, -0.06191087f, 
    -0.06429131f, -0.06826666f, 0.11152831f, -0.12677276f, 0.10908825f, -0.00261236f, 0.01527411f, 0.09279947f, 
    -0.04833485f, -0.39403930f, -0.10721215f, 0.13831991f, -0.04680063f, -0.01430075f, -0.04378298f, 0.08631950f, 
    -0.07774927f, 0.06410348f, -0.12596789f, -0.00837712f, -0.13076800f, 0.31407571f, 0.08592754f, 0.06316601f, 
    -0.01119784f, -0.09130512f, -0.05738849f, -0.07121912f, -0.09902184f, -0.01262939f, -0.02580233f, -0.08618418f, 
    0.53728390f, -0.34837365f, -0.44417155f, -0.06982198f, -0.00712140f, 0.02053068f, -0.04511963f, -0.01708090f, 
    0.06735066f, -0.15784612f, 0.10798170f, -0.22051442f, -0.02824445f, -0.14389265f, -0.06023396f, -0.27136555f, 
    -0.09564059f, -0.04629039f, 0.01740115f, -0.02658897f, -0.00443322f, -0.09174649f, -0.04069787f, -0.12641312f, 
    -0.53326678f, -0.52939218f, -0.24242416f, -0.02208865f, -0.07301459f, 0.01569132f, -0.11032371f, -0.12012519f, 
    -0.07016440f, -0.11869384f, 0.02497709f, -0.13102867f, 0.19548617f, -0.08725354f, -0.03190815f, -0.03122525f, 
    -0.00090203f, 0.09970494f, 0.07910476f, 0.07917035f, -0.16596080f, -0.02338172f, 0.15332368f, 0.04796627f, 
    0.05412864f, -0.04368478f, -0.04943526f, -0.10665407f, -0.17097150f, -0.14525372f, 0.03534465f, 0.02590340f, 
    -0.16204152f, -0.05451112f, -0.04516301f, 0.01883565f, 0.07647992f, 0.11681171f, 0.12614954f, 0.04156144f, 
    -0.06507035f, -0.10713411f, 0.00964439f, -0.07761966f, -0.15280257f, -0.03392710f, 0.05616737f, 0.13468561f, 
    -0.36766961f, -0.07640128f, 0.00104862f, 0.11727886f, 0.05151149f, -0.06904668f, 0.02385730f, 0.13809615f, 
    0.01110413f, 0.06690346f, 0.09194861f, -0.00241949f, 0.11056561f, 0.24854700f, 0.23870832f, 0.04727139f, 
    0.07306483f, -0.00208030f, 0.04880809f, 0.08798438f, -0.09873335f, -0.05446598f, 0.02774238f, 0.11078085f, 
    -0.15248644f, 0.12859292f, -0.15200478f, -0.01924869f, 0.19105268f, 0.01781178f, -0.04307953f, 0.08647504f, 
    0.12772547f, -0.03239270f, 0.01823289f, -0.04483178f, 0.07796761f, -0.43312803f, -0.09553200f, 0.19700234f, 
    -0.04172752f, 0.07687239f, -0.03369223f, -0.15559505f, 0.11055257f, 0.02489770f, 0.09470320f, 0.03224228f, 
    -0.26609695f, -0.08691274f, -0.09019436f, -0.45614651f, 0.03329229f, 0.09774990f, -0.14377943f, 0.09285887f, 
    -0.14501877f, -0.08892237f, -0.13542898f, 0.13239984f, -0.19881639f, -0.24954841f, 0.23311912f, 0.09943897f, 
    -0.07941647f, 0.07155547f, -0.13989261f, -0.05169923f, 0.08188833f, -0.15947090f, -0.11955338f, -0.00403595f, 
    -0.20547573f, 0.35317406f, -0.12002068f, -0.06147507f, 0.03150062f, -0.08216447f, 0.22580060f, 0.05868663f, 
    -0.03130829f, 0.29109153f, -0.06982087f, 0.16122355f, -0.32189655f, -0.16757958f, 0.17458449f, -0.12671411f, 
    -0.21339007f, 0.07593374f, -0.00260685f, -0.00116077f, 0.11264937f, 0.07312000f, 0.04045337f, 0.13415410f, 
    0.20444389f, -0.13751817f, -0.04423665f, 0.23149729f, 0.16150050f, -0.05722318f, 0.04306787f, 0.05970240f, 
    -0.01492490f, 0.00641542f, 0.04748418f, 0.12150421f, -0.06896999f, 0.15522620f, -0.07816499f, -0.18477181f, 
    -0.05540403f, -0.15312934f, -0.13056658f, -0.08563173f, 0.05167244f, 0.03416615f, -0.20127398f, 0.21474868f, 
    -0.86582172f, 0.62961841f, 0.12800701f, -0.06149124f, -0.06051626f, 0.02712054f, -0.15183184f, -0.07170768f, 
    -0.05989874f, -0.04729708f, 0.01649658f, -0.04592981f, 0.31840095f, 0.53738856f, -0.05475979f, -0.47947401f, 
    -0.08149778f, -0.04366392f, -0.10106304f, 0.06175176f, -0.04003480f, -0.00825113f, 0.05052039f, -0.03884873f, 
    -0.14272545f, 0.09713381f, -0.05030305f, -0.09223057f, -0.03148000f, -0.05708329f, 0.02350987f, -0.01645791f, 
    -0.03618700f, -0.03211758f, 0.15063684f, -0.06128933f, -0.32004493f, -0.65000975f, 0.24085566f, -0.16871276f, 
    -0.03987408f, -0.04643940f, 0.08007393f, -0.00963017f, 0.14588420f, 0.04616724f, -0.08008962f, -0.13850510f, 
    -0.19716911f, -0.16685817f, -0.11152361f, 0.20946866f, 0.03078124f, 0.07582852f, 0.05229794f, -0.01948243f, 
    -0.00512444f, -0.12356022f, -0.00615816f, -0.02126445f, 0.25224566f, -0.10761764f, 0.30887046f, 0.17498843f, 
    -0.01675867f, -0.10677863f, 0.15990749f, 0.11554097f, 0.04231773f, -0.13763864f, 0.10873720f, -0.07895263f, 
    0.12257472f, 0.20018715f, 0.11679590f, -0.04830391f, 0.06322235f, -0.17491761f, 0.14702684f, -0.12810600f, 
    -0.09096406f, 0.07017773f, -0.03099120f, -0.04323800f, 0.02661183f, 0.02412543f, 0.38324240f, -0.10858093f, 
    -0.05594711f, -0.13494590f, 0.20653667f, 0.06327883f, -0.06115318f, 0.20592590f, -0.01914217f, 0.26058882f, 
    -0.31761682f, -0.08143061f, -0.19679689f, -0.11041517f, 0.11321598f, -0.07514450f, 0.16140431f, 0.07842868f, 
    0.03572032f, 0.02305914f, 0.04575957f, -0.02288673f, 0.11725165f, -0.07874401f, -0.09810911f, 0.03644822f, 
    -0.01696782f, 0.15607932f, 0.18535402f, 0.13708365f, 0.04183138f, -0.22030951f, 0.08763884f, -0.14710587f, 
    -0.82800901f, -0.07655928f, 0.28783926f, 0.08473933f, -0.04948587f, -0.20451377f, -0.14874205f, -0.14627551f, 
    0.11251873f, -0.04159911f, -0.10911685f, -0.01668392f, -0.15174100f, -0.18039136f, -0.01686535f, -0.04621454f, 
    -0.08201966f, 0.01035688f, 0.04240390f, -0.22456029f, -0.13023053f, -0.19697620f, -0.03126441f, -0.02121803f, 
    -0.13958523f, -0.09650514f, 0.22431794f, 0.06129482f, -0.01165219f, 0.15853463f, 0.00797950f, 0.04604528f, 
    -0.03597890f, 0.03914296f, -0.05469579f, 0.08733650f, -0.01327231f, -0.00758652f, -0.18422200f, -0.34882542f, 
    0.21383026f, -0.08658623f, 0.07573653f, -0.00790547f, -0.12661925f, 0.03476680f, -0.05068227f, 0.01441597f, 
    0.04952316f, -0.24076298f, 0.15431303f, -0.29467237f, -0.05855851f, 0.09844238f, -0.00756434f, -0.03298301f, 
    0.10442226f, 0.00472675f, 0.05153493f, -0.10006358f, 0.03966887f, -0.03586271f, -0.07636554f, 0.25642636f, 
    0.13652284f, -0.00393264f, 0.09041343f, -0.08645117f, 0.08402375f, -0.04523811f, -0.02312819f, -0.07651798f, 
    0.05647799f, -0.09018324f, -0.13344239f, -0.11203882f, -0.01802973f, 0.08917613f, -0.06924984f, -0.23570770f, 
    -0.01864723f, -0.12759362f, -0.08173053f, -0.09740704f, -0.79224581f, -0.27355412f, 0.06387739f, 0.32666221f, 
    0.03401668f, -0.05807825f, 0.07115471f, 0.05451952f, -0.14651558f, 0.12608117f, 0.15062605f, 0.17610739f, 
    0.13432114f, 0.06186514f, 0.33853763f, 0.25498769f, -0.19119930f, 0.10505193f, -0.01656664f, 0.00852245f, 
    0.04626809f, 0.15382081f, -0.07024240f, -0.11984012f, -0.70832843f, 0.26210767f, 0.03030348f, 0.03540180f, 
    0.07946836f, -0.09337700f, -0.08219916f, 0.06385843f, -0.14714046f, 0.01832643f, 0.00798251f, 0.10949959f, 
    -0.29346591f, -0.07049627f, 0.17627722f, 0.36078686f, -0.04653062f, -0.00682577f, -0.09184235f, 0.04968856f, 
    -0.07241328f, -0.06187332f, 0.11728244f, -0.00471781f, 0.42759767f, 0.09440658f, -0.14077994f, 0.05814516f, 
    0.12232391f, -0.01087977f, 0.05598660f, 0.12486468f, -0.20719068f, 0.03365130f, -0.00008987f, 0.14695339f, 
    -0.75795221f, -0.09951633f, -0.14512247f, -0.37837604f, 0.10128359f, 0.20855007f, -0.00543660f, 0.01388649f, 
    0.00591479f, -0.07408349f, -0.17547733f, 0.08872437f, -0.03604820f, 0.04883297f, 0.09721545f, -0.06688521f, 
    -0.06514922f, 0.08373160f, 0.00210997f, -0.15171960f, -0.11747076f, -0.05070101f, -0.18426992f, -0.10545447f, 
    -0.54366857f, -0.18334959f, -0.10983442f, -0.22343135f, -0.14087339f, 0.14713892f, 0.08925273f, 0.01961589f, 
    -0.04030911f, 0.23239093f, -0.06922824f, -0.02626145f, 0.16142765f, 0.13020200f, 0.07877248f, -0.21908656f, 
    -0.03664007f, -0.05754860f, -0.25561360f, -0.29973793f, -0.01785656f, 0.10548054f, -0.08260874f, -0.04942549f, 
    -0.42760342f, -0.01294078f, -0.04615868f, -0.07484341f, 0.16684471f, -0.15587117f, 0.10570055f, 0.04275442f, 
    -0.13364242f, 0.01724536f, -0.06778518f, -0.17513794f, 0.21990040f, 0.07983947f, 0.06593304f, 0.08497532f, 
    -0.05081587f, -0.07370917f, 0.09235860f, 0.03388514f, -0.01101234f, 0.01603924f, 0.13986102f, 0.12910518f, 
    -0.79971713f, -0.48346844f, -0.07192853f, -0.09925538f, 0.01681094f, 0.04886291f, -0.19961691f, -0.31506732f, 
    0.05061364f, -0.18869664f, 0.04497904f, -0.17741397f, 0.09939104f, -0.01661840f, 0.10545903f, 0.12055495f, 
    0.08865293f, 0.21452361f, 0.09315023f, 0.04193350f, -0.04117599f, -0.11216146f, -0.05516332f, 0.08686104f, 
    0.21049428f, -0.38773033f, -0.07940748f, -0.01434780f, 0.07534292f, 0.30480203f, -0.00388708f, -0.18919221f, 
    -0.01285516f, -0.15682347f, 0.00890293f, -0.17249535f, 0.02385631f, 0.16152006f, 0.19217911f, 0.10554855f, 
    0.21841402f, -0.05866447f, 0.17315230f, -0.08382306f, 0.05271878f, -0.14178285f, 0.16508529f, -0.12358811f, 
    -0.18354648f, 0.20375504f, 0.12764482f, -0.12922120f, -0.23707864f, 0.03281267f, -0.15156937f, 0.08513647f, 
    0.01591250f, -0.14074375f, -0.05569658f, -0.16104664f, -0.32782501f, -0.31966856f, 0.43152559f, 0.53685439f, 
    -0.09152649f, 0.02387805f, 0.10496327f, -0.08302373f, -0.05632820f, -0.01615380f, -0.00516464f, 0.03195949f, 
    -0.26159421f, -0.41797781f, 0.04927420f, 0.05192309f, 0.12851304f, 0.05430180f, 0.23173161f, -0.00192102f, 
    0.19499579f, 0.03056547f, -0.12212946f, 0.09719046f, 0.25318399f, 0.14999197f, -0.09761336f, -0.13389584f, 
    -0.21787274f, 0.01965583f, 0.08876740f, 0.04099606f, -0.00821983f, -0.13952859f, 0.10134530f, 0.01551823f, 
    0.25150794f, 0.13201806f, -0.07669114f, -0.15498629f, -0.08435271f, -0.09941258f, -0.20461567f, -0.10529902f, 
    0.11539625f, 0.05130380f, 0.00649062f, -0.04609739f, 0.11575236f, -0.15796307f, -0.10030475f, 0.02838683f, 
    -0.13431092f, -0.09790964f, 0.06346516f, 0.08219805f, 0.07077251f, 0.00613699f, 0.08956118f, 0.02751193f, 
    -0.30279490f, -0.36134097f, 0.03271294f, 0.15761523f, 0.15655050f, -0.31554195f, 0.01611351f, 0.17245129f, 
    0.17766999f, 0.22002293f, -0.12971705f, 0.26036572f, 0.16753244f, 0.04556517f, 0.07609342f, 0.19189370f, 
    0.10115332f, 0.08471062f, -0.01740723f, 0.04447000f, 0.15151566f, -0.10743914f, -0.13885705f, -0.05862672f, 
    -0.64353633f, 0.21776938f, 0.10211075f, -0.40966246f, 0.08616165f, 0.02779954f, -0.09664710f, -0.14088643f, 
    -0.04737320f, 0.07012090f, -0.01470763f, 0.14061160f, 0.00199150f, 0.16807555f, 0.26512593f, -0.21260375f, 
    0.11432853f, 0.00821251f, -0.08767570f, 0.14190440f, 0.19763617f, 0.15648575f, -0.11791486f, 0.06470526f, 
    0.13760900f, 0.07791274f, 0.32209522f, -0.04555869f, 0.01178345f, -0.04352977f, 0.22099936f, 0.07261699f, 
    -0.27529857f, -0.09051450f, 0.11512388f, 0.22266924f, -0.22105980f, 0.08421130f, 0.15631817f, -0.16076553f, 
    -0.04177663f, -0.04847255f, 0.09187657f, 0.16958565f, 0.28012690f, 0.14107504f, 0.09880921f, 0.26122272f, 
    -0.09248179f, 0.05463506f, 0.12720940f, 0.07574206f, 0.10026322f, -0.04944516f, -0.03467003f, 0.11283620f, 
    0.08921059f, -0.13080110f, 0.25519896f, 0.28371176f, -0.08529854f, -0.10443626f, 0.05667168f, 0.30333045f, 
    -0.10049654f, -0.13764183f, 0.02187679f, 0.01502145f, -0.08936109f, -0.01365950f, 0.18231088f, -0.00522964f, 
    -0.09955668f, 0.13225566f, -0.05852087f, 0.14729562f, -0.00397483f, -0.07331152f, 0.05041035f, 0.13168871f, 
    0.00449964f, -0.03993105f, -0.02140388f, -0.10202724f, 0.05819487f, -0.11102897f, -0.04393962f, -0.22050400f, 
    0.04808315f, -0.14462675f, 0.10153447f, 0.09963230f, 0.04300748f, 0.09281922f, -0.08332836f, 0.30927381f, 
    0.13196869f, 0.23185401f, 0.19811393f, -0.04684614f, -0.01181047f, -0.13664712f, -0.06914086f, -0.07208908f, 
    -0.00522709f, -0.08358581f, -0.05706020f, -0.18912804f, -0.29715976f, 0.17593169f, -0.46388406f, -0.03443668f, 
    0.03591552f, 0.09874639f, -0.15141840f, -0.11805791f, 0.06400055f, -0.15718102f, 0.04913035f, -0.08411114f, 
    0.00981378f, -0.03973132f, 0.10312819f, 0.08032531f, -0.12043948f, 0.02980912f, 0.10012418f, 0.07589979f, 
    0.06024962f, 0.08618380f, 0.11960141f, 0.29108283f, 0.05557476f, 0.12930912f, -0.27234271f, -0.17330556f, 
    0.04145970f, -0.11174330f, -0.06380571f, 0.10849651f, -0.02963043f, -0.08685429f, 0.08848245f, -0.42624682f, 
    -0.15480442f, -0.34976968f, -0.27618259f, 0.07217298f, 0.01100461f, 0.19220185f, -0.15424339f, -0.12907083f, 
    -0.03264642f, 0.03042402f, 0.07680123f, 0.03055917f, -0.03361284f, -0.25927892f, -0.14549367f, 0.11250592f, 
    0.05497518f, 0.00502567f, 0.12443900f, -0.07768736f, 0.06255456f, 0.16314526f, -0.25707632f, 0.08491601f, 
    -0.34199694f, 0.03575430f, -0.15107593f, -0.38845661f, 0.07919388f, -0.11826857f, 0.09726823f, -0.08028194f, 
    -0.04053262f, -0.06260114f, 0.05405140f, 0.00522334f, -0.39591277f, 0.15274242f, 0.20791396f, 0.02324420f, 
    -0.13653496f, -0.11581477f, 0.04352487f, 0.18685551f, 0.07749876f, 0.00422121f, -0.03877718f, -0.00675347f, 
    0.21863435f, -0.13705616f, 0.04778716f, -0.26187715f, -0.06134038f, 0.01728282f, -0.05244406f, -0.15990020f, 
    -0.06974308f, 0.03657635f, 0.02757253f, 0.13887616f, -0.59278053f, -0.06294533f, -0.04031413f, 0.01308225f, 
    -0.00641202f, 0.10548493f, 0.36581689f, 0.12072213f, 0.02246608f, -0.07443925f, -0.07973465f, 0.05479452f, 
    0.14853662f, -0.33388913f, 0.11478262f, -0.19799630f, 0.10001241f, 0.07466555f, 0.03956866f, -0.01270841f, 
    -0.02480529f, 0.12067532f, 0.17611152f, -0.00412103f, -0.04988123f, 0.04061871f, -0.07445699f, -0.59846789f, 
    0.02909963f, -0.09029438f, 0.06587648f, 0.11214840f, -0.10855000f, -0.03135365f, -0.05705297f, -0.05383078f, 
    0.26357353f, -0.15622519f, -0.10901062f, -0.03166456f, -0.23983966f, 0.16610309f, 0.01351872f, 0.25875965f, 
    0.06359354f, 0.28629199f, -0.08805274f, 0.11919585f, -0.65060961f, 0.27315810f, -0.00479480f, 0.32079884f, 
    -0.09914882f, 0.05874477f, 0.04964542f, 0.00297926f, 0.01691728f, 0.11530228f, 0.09334613f, -0.05762665f, 
    -0.38669169f, 0.14507616f, 0.00661318f, -0.08812546f, -0.04454016f, -0.19336970f, -0.04700937f, -0.20822722f, 
    -0.09353859f, 0.04847220f, 0.04232455f, -0.09928351f, 0.19815631f, -0.38881481f, -0.15186770f, -0.29506105f, 
    -0.14266279f, 0.17487499f, -0.02857774f, 0.08650716f, -0.00119643f, 0.12240435f, -0.07402779f, 0.07878946f, 
    0.79214203f, -0.48046380f, 0.33951724f, -0.30369583f, -0.00143981f, 0.05624989f, 0.05565381f, -0.10638368f, 
    -0.00435892f, 0.01731633f, 0.28704721f, 0.21407916f, 0.30170056f, -0.26321477f, 0.02904981f, -0.06561692f, 
    -0.13449086f, 0.02267371f, -0.00706737f, 0.01071105f, 0.04481278f, -0.03144768f, -0.12267493f, 0.08959347f, 
    -0.13069995f, 0.00632613f, 0.17174697f, -0.19236846f, -0.01674217f, -0.03393499f, -0.00764429f, -0.20485450f, 
    -0.16388595f, -0.09040654f, 0.06259932f, -0.04343708f, 0.02857046f, -0.04840581f, 0.21235225f, 0.10162013f, 
    0.13043846f, -0.08929381f, -0.06806988f, 0.15680364f, -0.00063962f, 0.01823330f, -0.12582053f, -0.11808255f, 
    -0.38457403f, -0.09331729f, -0.13556395f, 0.16506122f, -0.02716150f, -0.04430543f, 0.08542794f, 0.03172176f, 
    0.02025378f, -0.00794836f, 0.07111754f, -0.00094404f, -0.06881166f, -0.36109158f, -0.06181344f, 0.18945256f, 
    0.00398917f, -0.09034486f, 0.16625892f, -0.05772435f, -0.01566377f, -0.12323700f, -0.08340976f, 0.04458835f, 
    0.00862633f, -0.18552113f, -0.22493070f, 0.31641808f, -0.03112299f, 0.08066604f, 0.02329290f, 0.06105445f, 
    -0.24301149f, -0.20695777f, 0.04976520f, -0.00496747f, 0.15212883f, -0.22879358f, -0.27320230f, 0.11557309f, 
    0.07991119f, -0.14629640f, 0.08832960f, 0.17424402f, 0.26474175f, -0.00088685f, -0.10999870f, 0.09345410f, 
    0.38169163f, -0.70201707f, 0.31316930f, -0.07443598f, 0.03997648f, 0.06075782f, 0.18363099f, -0.02709998f, 
    0.04981808f, -0.16883273f, -0.05218847f, -0.08012237f, 0.16845384f, 0.06493349f, 0.11528617f, -0.20441857f, 
    -0.22892146f, 0.07531138f, 0.04735861f, 0.06771982f, 0.10101772f, -0.16045243f, 0.09016141f, 0.00626996f, 
    0.16928682f, -0.04704070f, -0.15382877f, 0.05037123f, 0.06817193f, 0.14161325f, -0.11169011f, -0.14370757f, 
    -0.03153211f, -0.23322943f, 0.01939023f, -0.03397344f, -0.11886425f, -0.03006585f, -0.03210263f, 0.07186491f, 
    -0.03003866f, 0.10424920f, -0.02229376f, -0.02769793f, 0.04007792f, -0.08904920f, -0.19053417f, -0.19132283f, 
    0.30973122f, 0.07983181f, 0.13781916f, -0.62344867f, 0.03767053f, 0.10906426f, 0.20627150f, -0.06096515f, 
    0.01426245f, -0.00757752f, -0.05705444f, -0.11432414f, 0.16509899f, 0.24294539f, 0.04523848f, 0.10221528f, 
    0.05620505f, 0.14314897f, -0.04419085f, -0.16622417f, -0.00983152f, 0.00666148f, -0.13418128f, 0.10208431f, 
    -0.31023711f, 0.19015683f, 0.12606987f, 0.62068152f, -0.05315998f, 0.08220031f, 0.00572941f, -0.02675297f, 
    -0.07396699f, -0.07253943f, -0.16055883f, -0.05850124f, 0.03993817f, 0.00030408f, 0.13698156f, -0.02537643f, 
    0.07130178f, 0.05690065f, -0.04846460f, -0.13714847f, 0.00458412f, -0.06924739f, 0.09669171f, -0.13445720f, 
    -0.41347015f, 0.11667995f, 0.26236513f, 0.34665585f, 0.04006352f, 0.24690500f, -0.08666866f, -0.07846427f, 
    -0.05969312f, -0.01002062f, 0.12584707f, 0.08441962f, 0.05753857f, -0.24649040f, -0.14663655f, -0.17914943f, 
    -0.08955661f, -0.02590711f, -0.03343858f, -0.00217054f, -0.11021555f, 0.06191880f, -0.01296316f, 0.21338685f, 
    -0.24649289f, 0.32335883f, 0.18460461f, -0.38622916f, 0.14846024f, 0.03792151f, -0.18572411f, 0.08495767f, 
    -0.02886540f, 0.04237523f, -0.04157477f, -0.08313806f, 0.19939092f, -0.27006698f, 0.19595614f, -0.03807801f, 
    -0.04911083f, 0.03386396f, -0.08573083f, -0.24728611f, 0.01429947f, 0.05542469f, 0.10563993f, 0.31512132f, 
    -0.14016765f, -0.23371141f, -0.08117953f, -0.24203072f, -0.11068367f, -0.04244214f, 0.10063452f, -0.13175546f, 
    0.07529940f, 0.05663005f, 0.02716414f, 0.08960449f, -0.17535894f, 0.04218701f, 0.08613376f, -0.12356663f, 
    0.09947764f, -0.11612842f, 0.06097652f, -0.24345082f, 0.12908140f, -0.10535818f, 0.18294007f, -0.17123760f, 
    0.27988744f, -0.00199741f, 0.31981564f, 0.02697466f, 0.11023603f, 0.02674164f, 0.00086045f, -0.01102605f, 
    0.03802060f, 0.12140828f, 0.02768718f, -0.05298943f, -0.11959437f, 0.09105363f, -0.04146277f, -0.16771957f, 
    0.00681497f, 0.05413784f, 0.01605926f, -0.09908595f, -0.02614201f, -0.03953545f, -0.03102941f, -0.12370845f, 
    -0.16317186f, 0.18473886f, 0.24516888f, 0.03774641f, 0.18887851f, -0.00656189f, 0.06010079f, -0.05022154f, 
    -0.13528320f, 0.06731060f, 0.00725817f, -0.11121298f, 0.25661334f, 0.24383774f, -0.19090807f, -0.03532930f, 
    -0.01443195f, 0.05819987f, -0.15766862f, -0.07837791f, -0.14047877f, 0.02659784f, -0.03478930f, -0.04815052f, 
    0.24810956f, -0.14204030f, 0.17460865f, 0.16081741f, 0.11690257f, -0.01013032f, 0.07136508f, -0.04801823f, 
    0.03813877f, 0.06160324f, 0.00766013f, -0.01648142f, 0.29735640f, -0.00449240f, -0.10657677f, 0.06834268f, 
    -0.01759622f, -0.16496424f, -0.00739840f, -0.11375532f, -0.10234337f, 0.05738914f, -0.01204974f, -0.01961328f, 
    0.05360134f, 0.07285725f, 0.09607781f, 0.08831056f, 0.12223867f, -0.08004080f, 0.03196925f, 0.00942862f, 
    -0.03673739f, -0.00873898f, 0.02355391f, -0.05928809f, -0.28751844f, -0.05091856f, -0.32729283f, -0.21277454f, 
    0.01123713f, -0.00477109f, -0.05988995f, -0.01046680f, -0.14698042f, -0.03774760f, 0.00809017f, -0.06199058f, 
    0.19234116f, 0.29595748f, 0.16498677f, 0.27872181f, 0.15095356f, -0.00189461f, -0.01755481f, 0.02154349f, 
    -0.02138430f, 0.05630465f, 0.02168808f, -0.14395963f, -0.05027900f, 0.05677439f, -0.00092825f, 0.01944965f, 
    -0.20446086f, -0.00092589f, -0.07765161f, -0.16651781f, -0.15070766f, 0.11389961f, -0.13088699f, -0.23794433f, 
    0.28155568f, 0.15902601f, 0.09683637f, -0.18446970f, -0.19476375f, -0.03442781f, -0.09105686f, -0.04980945f, 
    -0.11353590f, 0.06835496f, -0.21882671f, -0.01257842f, 0.12392478f, 0.05754927f, 0.21308331f, 0.34759665f, 
    0.06548061f, -0.06925567f, -0.03798332f, -0.16717087f, -0.18208800f, 0.06643126f, -0.14613825f, -0.04605459f, 
    0.04147210f, 0.00601079f, 0.08371894f, 0.18673638f, -0.05262444f, -0.01206872f, -0.13976289f, 0.15242521f, 
    0.00330937f, -0.07552891f, -0.08246545f, -0.02317917f, 0.31485862f, -0.33950111f, 0.02528542f, -0.07397082f, 
    0.14881741f, -0.11252507f, 0.00768112f, 0.03588917f, -0.14265621f, 0.03478792f, -0.03722334f, -0.06103180f, 
    -0.30363992f, -0.01799201f, -0.13317887f, -0.06082843f, -0.22291377f, -0.02778397f, -0.08717948f, -0.08033321f, 
    -0.02930056f, 0.03990951f, -0.08291655f, -0.12004498f, 0.11956881f, -0.17173943f, -0.03659337f, 0.17523225f, 
    0.02304451f, -0.02648429f, -0.07989240f, 0.01593726f, -0.03268895f, 0.00973382f, -0.10004312f, -0.11065535f, 
    0.34361240f, -0.10104447f, 0.20064683f, 0.19282214f, 0.05633611f, -0.04157721f, -0.05435482f, -0.20207483f, 
    -0.13006316f, -0.05100012f, -0.05721731f, -0.05073964f, 0.15965003f, 0.11804654f, 0.22558752f, 0.20913221f, 
    -0.00911182f, -0.01396729f, 0.02019359f, 0.08052742f, -0.00359495f, 0.02559219f, 0.03295976f, -0.02197877f, 
    0.14043152f, -0.50034052f, 0.07696173f, -0.14780781f, -0.06223814f, -0.00085659f, -0.05560851f, -0.09106559f, 
    0.07092968f, 0.12338577f, -0.01437273f, -0.13962151f, -0.01803213f, 0.30134746f, -0.03904329f, -0.19214466f, 
    -0.04583554f, 0.09167490f, -0.04664993f, -0.12284115f, -0.10096404f, -0.10828119f, -0.02990026f, -0.03969359f, 
    0.09211191f, -0.35864046f, -0.00389344f, -0.03888912f, -0.23389961f, -0.13176985f, -0.07955740f, -0.08680090f, 
    0.12986246f, -0.00291767f, -0.04169544f, 0.07186693f, -0.37095681f, 0.14362334f, -0.00329277f, -0.09344323f, 
    -0.22546779f, -0.03765723f, 0.05512629f, -0.02639698f, -0.05676917f, -0.05610297f, -0.13902490f, -0.09556653f, 
    -0.13877538f, -0.34403723f, 0.11184026f, 0.06704281f, 0.01192490f, -0.14489496f, 0.02229622f, -0.02111984f, 
    -0.02481253f, 0.04375982f, -0.05980113f, -0.08557251f, 0.24188121f, 0.01650368f, 0.07155322f, 0.16796650f, 
    -0.06360301f, -0.13642056f, 0.06961478f, -0.02791813f, -0.02077790f, -0.01830512f, -0.11282094f, -0.10900725f, 
    -0.10707375f, -0.16203216f, -0.19780278f, 0.03808238f, 0.00503134f, -0.10456984f, -0.03675758f, 0.07194469f, 
    -0.08284059f, -0.01518655f, -0.02401654f, -0.08714670f, 0.00512785f, -0.22750577f, 0.15129569f, -0.10728910f, 
    -0.03599232f, -0.13534689f, -0.08447073f, -0.10708016f, -0.11936241f, 0.01553923f, 0.13082679f, -0.11162364f, 
    -0.33647245f, 0.24233389f, -0.00331521f, -0.16077162f, -0.32877082f, 0.01926137f, -0.10062642f, -0.02898828f, 
    -0.05376860f, -0.07270893f, 0.15744068f, -0.17763853f, 0.00399457f, 0.13673224f, 0.14110397f, 0.27854869f, 
    0.00468918f, 0.06441383f, 0.11410841f, 0.03818552f, -0.07474863f, 0.04496787f, 0.08481123f, -0.06164842f, 
    -0.33039027f, -0.31180981f, -0.16055001f, -0.18143338f, -0.06374962f, -0.01800069f, -0.11125349f, -0.08842852f, 
    -0.14620420f, 0.05698710f, -0.01165305f, -0.06227098f, 0.14415470f, -0.05163931f, 0.03024320f, -0.11476122f, 
    -0.09268421f, 0.04523801f, -0.08457343f, 0.04997429f, -0.04373954f, 0.06217292f, -0.09888358f, 0.07413109f, 
    0.09942516f, 0.20816056f, 0.12691797f, 0.11714766f, 0.05274664f, 0.08855592f, 0.03527912f, -0.19015029f, 
    0.03928436f, 0.13583414f, -0.00733081f, -0.09889364f, 0.20866409f, 0.02153059f, 0.17014715f, 0.08291785f, 
    0.07717101f, 0.16469540f, 0.09385909f, -0.02255033f, -0.07010172f, 0.02101761f, 0.02381586f, -0.16345473f, 
    -0.37119645f, 0.03836843f, 0.20838133f, -0.16523692f, -0.14204161f, 0.03890153f, -0.05699147f, -0.21078211f, 
    0.02093361f, 0.04898741f, -0.13896623f, -0.04130875f, 0.25574157f, -0.12876843f, 0.12390690f, 0.13962057f, 
    0.07871919f, 0.02608855f, -0.09114844f, -0.08899383f, -0.07098406f, 0.00355529f, -0.16184889f, -0.03787394f, 
    -0.24163400f, -0.08392386f, 0.31646082f, -0.10009617f, -0.02744332f, -0.07946660f, -0.00231236f, -0.05584214f, 
    0.03169085f, -0.07892483f, 0.09275801f, 0.11308835f, -0.18856563f, 0.16870025f, -0.07446244f, 0.03072444f, 
    -0.11162861f, -0.09566915f, -0.20534812f, 0.07183500f, 0.01833830f, 0.12641819f, -0.09051554f, -0.17957410f, 
    0.04005485f, -0.26406515f, 0.10532825f, -0.23317957f, -0.03209687f, -0.05611814f, 0.01249772f, 0.01858939f, 
    -0.08141689f, 0.00880704f, -0.02131656f, 0.05109133f, -0.25591591f, -0.21480529f, -0.11030169f, -0.41454703f, 
    -0.18052360f, -0.16128471f, 0.20713247f, 0.08024214f, 0.19451059f, 0.26625121f, -0.08692881f, -0.02557197f, 
    -0.09305902f, -0.30059037f, 0.15670110f, -0.09948631f, 0.11659231f, -0.06634936f, -0.01538308f, -0.11703000f, 
    -0.06570341f, 0.09673470f, 0.08631341f, -0.16356881f, 0.05542879f, 0.05730346f, -0.06544051f, 0.00738010f, 
    0.10667562f, 0.06541331f, -0.03962699f, -0.13404731f, -0.00373366f, -0.01832402f, -0.00805536f, 0.12569249f, 
    -0.30192500f, 0.07277879f, 0.16022468f, 0.12223481f, 0.01582571f, -0.08700715f, 0.11494997f, 0.03017675f, 
    0.02584868f, -0.08035245f, -0.01358993f, -0.00504976f, -0.22174230f, -0.10632127f, 0.18781017f, 0.02045939f, 
    -0.16948886f, -0.06631324f, 0.04372895f, 0.03649252f, 0.15994127f, -0.16691521f, -0.09349696f, 0.03890046f, 
    0.34741366f, 0.02108442f, -0.19436084f, -0.06659224f, -0.02177211f, -0.07294656f, -0.05775267f, 0.02508540f, 
    0.20544416f, -0.16272953f, -0.08824957f, 0.08568788f, -0.12372876f, -0.13815022f, -0.20402172f, -0.21562776f, 
    0.21778975f, 0.00841846f, -0.07740875f, 0.02115320f, 0.15057963f, 0.03102474f, -0.11046114f, -0.06255810f, 
    -0.38917345f, 0.05266120f, -0.08505904f, -0.47665325f, -0.11067174f, -0.08888450f, -0.02395789f, -0.12311587f, 
    0.04441768f, 0.12398843f, -0.24180432f, 0.19823703f, 0.30874100f, -0.33882305f, -0.26973629f, -0.16022432f, 
    0.08408396f, -0.02489473f, 0.09144909f, -0.10901119f, 0.05353953f, 0.00776731f, 0.09159219f, 0.14957072f, 
    0.12034347f, 0.30389029f, -0.07159853f, 0.15846482f, -0.08950372f, 0.10676672f, -0.08001462f, -0.13949457f, 
    -0.04550822f, 0.03194804f, -0.03716535f, 0.02248556f, -0.03282577f, 0.04550552f, -0.32272726f, -0.29495394f, 
    -0.08507205f, 0.10313120f, -0.12363143f, -0.03402938f, 0.05688532f, 0.03708597f, -0.00223704f, 0.12296201f, 
    0.32378712f, 0.15815422f, -0.08354238f, 0.03840743f, -0.02229551f, -0.06832208f, 0.05619632f, -0.01946373f, 
    0.04944011f, -0.01437974f, -0.02797736f, 0.18342595f, 0.09095387f, -0.10989890f, -0.47029328f, -0.12475153f, 
    -0.04261184f, -0.11762580f, -0.16998701f, -0.09911531f, -0.00082809f, -0.15080814f, 0.12314706f, 0.04696971f, 
    0.02066691f, -0.13118859f, 0.17107555f, 0.14820388f, -0.05579445f, -0.11464816f, 0.03179942f, -0.00444418f, 
    -0.07955907f, 0.01016046f, 0.08207568f, 0.11285399f, 0.30192998f, 0.03184763f, 0.04365244f, 0.30150160f, 
    0.16474104f, -0.12667887f, -0.09290441f, -0.04399022f, 0.06753782f, 0.16288522f, -0.17507873f, -0.12033394f, 
    0.06602559f, -0.07108960f, -0.25715777f, -0.06266046f, -0.08293576f, 0.13600646f, 0.11946574f, -0.11790651f, 
    0.12016170f, 0.04712608f, 0.14559659f, 0.03921694f, -0.02000164f, 0.06402489f, 0.04747676f, 0.01671817f, 
    -0.12293056f, 0.01601899f, 0.02013869f, 0.03634413f, 0.04543376f, 0.09529855f, 0.02062165f, 0.16939920f, 
    -0.21980761f, -0.30233851f, -0.19095239f, 0.05857629f, -0.05606696f, -0.14539286f, -0.08811324f, -0.07751735f, 
    0.04952332f, -0.00558022f, 0.17573899f, 0.16686955f, 0.00062012f, 0.11946341f, 0.05354613f, -0.31870693f, 
    0.03093418f, -0.11865480f, -0.01557696f, -0.07126240f, -0.14277688f, -0.01429865f, 0.29409167f, 0.04613543f, 
    0.12778136f, 0.13614944f, -0.23115011f, -0.13179503f, 0.15140644f, -0.07853455f, -0.05471808f, -0.04293125f, 
    0.12203924f, 0.03099910f, 0.04152059f, 0.05771590f, -0.38918352f, -0.14209066f, 0.14239646f, -0.14059319f, 
    -0.01950049f, -0.03710881f, -0.10450595f, 0.07551335f, 0.07959183f, -0.02826037f, -0.11708998f, 0.16892354f, 
    0.09944469f, -0.12960663f, -0.13597500f, 0.01375257f, -0.00533294f, -0.24918710f, 0.03339746f, 0.07227596f, 
    0.15867446f, 0.15935256f, -0.10144856f, -0.06092300f, -0.10809402f, -0.05226856f, 0.21942702f, -0.04221550f, 
    -0.18312812f, 0.06793789f, -0.10799397f, 0.06671404f, 0.02577939f, -0.02231830f, -0.08975319f, -0.08723036f, 
    -0.11468296f, -0.31128141f, 0.09538357f, 0.26071697f, 0.21588898f, 0.08469626f, -0.01526554f, 0.01718945f, 
    0.06015601f, -0.01418647f, 0.17044327f, 0.06921566f, 0.21926104f, -0.09536231f, 0.11287209f, -0.04960200f, 
    0.07094375f, -0.05139200f, 0.09071376f, 0.01653891f, -0.00125090f, -0.09282434f, -0.11433186f, -0.13911588f, 
    -0.15244702f, 0.05393676f, 0.25401345f, 0.09209275f, -0.16272104f, 0.09818252f, -0.07196376f, -0.00677510f, 
    -0.04688890f, -0.04094114f, -0.02882979f, -0.25049630f, -0.11264022f, -0.01544522f, 0.15611753f, -0.02914977f, 
    0.06301372f, 0.02345464f, -0.05035761f, 0.00593597f, 0.01374911f, -0.03703767f, -0.10846344f, 0.30826971f, 
    0.08737824f, -0.47130042f, -0.20707026f, 0.14266250f, -0.03998417f, 0.10646512f, 0.06776792f, 0.06904055f, 
    -0.09006315f, 0.05118431f, 0.03438848f, -0.15783858f, -0.38469782f, 0.09204862f, -0.04091146f, -0.05300168f, 
    0.08418214f, 0.17481260f, -0.01881645f, -0.09972931f, 0.21154335f, -0.09742660f, 0.19910163f, 0.04950021f, 
    -0.65595162f, -0.23489165f, -0.12846427f, 0.41986987f, 0.03187948f, -0.04069019f, -0.14825457f, -0.02693078f, 
    0.03205610f, 0.03140646f, -0.01258938f, -0.03083143f, 0.04547022f, 0.34217259f, 0.03813924f, -0.03471712f, 
    -0.04167109f, -0.04226470f, 0.01841211f, 0.29072836f, 0.01549614f, -0.17812769f, 0.09809781f, -0.00403598f, 
    0.57514971f, 0.15941229f, -0.10523662f, 0.25525224f, 0.09305713f, 0.04481738f, -0.10931341f, -0.04463871f, 
    -0.06220620f, -0.01086927f, 0.03934503f, 0.14353636f, -0.07627108f, 0.11425950f, 0.14405811f, -0.28684637f, 
    -0.13343956f, -0.04336265f, 0.06468662f, -0.10928090f, -0.15171218f, -0.05469314f, -0.13009049f, -0.08750495f, 
    0.27134103f, -0.18636583f, -0.09431041f, 0.13478580f, -0.04983535f, 0.00984382f, 0.13145871f, 0.01763090f, 
    0.15032029f, -0.07472654f, -0.08713079f, 0.05676683f, 0.25196397f, 0.01345036f, 0.23116782f, -0.14073490f, 
    -0.01205604f, 0.11446864f, -0.16479912f, -0.01836678f, -0.06973045f, 0.09357651f, -0.02981205f, -0.16335422f, 
    0.09876803f, -0.47299832f, 0.01017681f, 0.20716862f, -0.09453904f, 0.00739341f, -0.25646842f, 0.19882721f, 
    -0.17354342f, 0.06106993f, -0.05007422f, 0.19371398f, -0.08551563f, 0.29999682f, -0.09690238f, -0.16704957f, 
    0.15089062f, -0.05601611f, 0.03717567f, -0.05737564f, -0.11917865f, 0.11523574f, 0.20840299f, 0.01320904f, 
    -0.46807328f, -0.22499961f, -0.30611300f, 0.18540050f, 0.16404915f, -0.00872688f, 0.04094814f, -0.02511031f, 
    -0.14971836f, 0.10493452f, 0.04255147f, 0.01432560f, -0.22654700f, -0.59548384f, -0.24084568f, -0.33487445f, 
    -0.04697591f, -0.07796899f, -0.17832814f, 0.09240045f, 0.01976708f, -0.17096543f, 0.07844238f, 0.03579442f, 
    0.48439702f, 0.24392056f, -0.21265724f, 0.20386533f, 0.05832033f, 0.05819048f, 0.01912237f, 0.34034339f, 
    -0.17045099f, 0.00862465f, 0.12243374f, 0.02604570f, 0.04950539f, 0.00637628f, 0.26743615f, 0.04226146f, 
    0.16107671f, 0.01185443f, -0.13172132f, -0.05764204f, 0.04403174f, -0.02610265f, 0.15232630f, -0.04503471f, 
    -0.27008945f, 0.46738300f, 0.12189966f, 0.23237133f, 0.00051111f, 0.12757197f, 0.09358589f, 0.14643982f, 
    0.01835353f, 0.12661844f, 0.08975737f, -0.00726456f, 0.07176670f, 0.03364607f, -0.06384660f, -0.16700731f, 
    -0.10312099f, 0.05176450f, 0.02309482f, 0.03482342f, -0.01967354f, 0.07330588f, -0.16257560f, 0.22112288f, 
    0.34557030f, -0.27185899f, 0.06751920f, -0.12102873f, -0.08082952f, 0.09983233f, -0.15481000f, -0.02825282f, 
    0.04759295f, -0.15531445f, 0.06177292f, 0.08346361f, -0.05764017f, -0.18700469f, -0.09941791f, 0.12487929f, 
    -0.02837583f, 0.10077804f, -0.14914916f, -0.01480014f, -0.15003382f, 0.02097164f, 0.18863976f, 0.02768878f, 
    0.61735392f, 0.21408246f, -0.33550704f, -0.18516478f, 0.04596635f, -0.06856825f, 0.05946985f, 0.02783536f, 
    -0.05348928f, -0.09029331f, 0.00383132f, 0.10952625f, -0.34589189f, 0.22895797f, -0.20685218f, -0.15625194f, 
    0.14227727f, -0.01528620f, -0.12636919f, -0.10564465f, -0.23915550f, 0.01073986f, 0.04425143f, -0.00874301f, 
    -0.10701025f, 0.06178651f, -0.20127356f, -0.33989084f, -0.02251486f, 0.03526695f, -0.04869812f, 0.05079364f, 
    -0.01401080f, 0.00512830f, -0.01877946f, -0.19524294f, -0.18625413f, 0.41574976f, -0.07513367f, 0.06875717f, 
    0.12406416f, -0.06294390f, -0.12715861f, 0.02657022f, -0.03820240f, -0.09303892f, -0.08407451f, -0.07476862f, 
    -0.11963642f, 0.05640299f, 0.06050376f, -0.28445327f, -0.19910994f, -0.18464236f, -0.13122720f, 0.11269384f, 
    -0.02068427f, 0.21910223f, -0.08036519f, -0.09120534f, -0.01501579f, -0.20485541f, 0.09422328f, 0.24236824f, 
    0.05222675f, -0.07108068f, -0.10820904f, -0.02037695f, 0.11392733f, -0.04177679f, -0.13374485f, -0.22202547f, 
    0.44277000f, 0.03558089f, 0.32257327f, -0.13517953f, -0.04532249f, -0.04408755f, 0.10705516f, 0.02817127f, 
    0.01223198f, 0.05733890f, 0.00294205f, 0.00253446f, -0.18194652f, -0.21824901f, -0.03105319f, 0.35420573f, 
    -0.16275983f, 0.14630426f, -0.01229753f, -0.00887711f, 0.13424520f, 0.07608973f, 0.04486692f, -0.16734309f, 
    -0.74940711f, 0.34143674f, 0.19880386f, -0.17926133f, -0.12794647f, 0.07970023f, 0.21280591f, -0.13248238f, 
    0.04109159f, 0.00838817f, 0.11879753f, 0.05041464f, -0.22308132f, -0.20347194f, 0.01632221f, -0.28610352f, 
    0.18303633f, 0.04710529f, 0.20736782f, -0.06624810f, 0.05418355f, 0.06973291f, -0.01874297f, 0.14798185f, 
    -0.35868421f, 0.05484273f, -0.04032888f, -0.64033747f, 0.07053766f, 0.01480136f, -0.15361574f, -0.19482821f, 
    -0.14107676f, -0.18706989f, -0.07892797f, -0.21891233f, -0.14454246f, 0.13099922f, 0.04324664f, -0.16554053f, 
    -0.08354513f, 0.16445486f, 0.01635983f, -0.06943090f, 0.10511933f, 0.14304397f, 0.07672643f, 0.09562762f, 
    -0.11448043f, -0.22867624f, 0.17118612f, -0.01335003f, 0.06315512f, -0.08392905f, -0.11283184f, 0.12906419f, 
    -0.02309347f, 0.15039305f, -0.13896503f, 0.05808330f, -0.11910428f, -0.28311613f, 0.15887387f, 0.21997254f, 
    -0.16682515f, 0.01091282f, -0.04839020f, 0.01662771f, -0.05392648f, 0.16231547f, -0.01192007f, -0.22442000f, 
    -0.00954424f, 0.07293162f, -0.03043644f, -0.20644803f, 0.00333764f, 0.10391322f, -0.04535967f, -0.00505005f, 
    -0.04218996f, -0.05440487f, 0.03326553f, 0.02382988f, -0.66601509f, -0.37975532f, -0.21349317f, -0.17233036f, 
    0.08345006f, 0.09369452f, -0.02818970f, -0.12215167f, 0.18969987f, 0.13614589f, -0.19945736f, -0.06728753f, 
    0.29029101f, 0.05841168f, -0.01528922f, 0.07662316f, -0.22807072f, -0.12539367f, 0.02184331f, 0.04096214f, 
    0.09654462f, -0.30323067f, 0.11346357f, -0.10151046f, -0.24280298f, -0.40845844f, 0.03408507f, -0.08870154f, 
    0.01842434f, -0.00432143f, -0.06865327f, -0.02517671f, -0.04158437f, 0.04499580f, -0.09462634f, -0.00756324f, 
    -0.03900864f, -0.03946770f, 0.05105617f, 0.19174467f, -0.11067127f, -0.00559714f, 0.12233509f, 0.04613448f, 
    0.09445104f, 0.11377525f, 0.00089950f, -0.12397523f, 0.27948925f, 0.31872597f, 0.18697219f, 0.18228857f, 
    0.09062791f, -0.05010739f, 0.18534797f, -0.10510013f, -0.00078424f, 0.17689687f, 0.09036668f, 0.13061126f, 
    0.12156064f, 0.20218208f, -0.18477853f, 0.08470541f, -0.11042652f, -0.22110343f, -0.03757458f, -0.16153991f, 
    -0.07485426f, -0.25589681f, -0.04415194f, -0.09849419f, -0.87799382f, -0.73484695f, 0.15131038f, -0.06942870f, 
    0.18523556f, 0.01479293f, -0.00658676f, -0.17421947f, 0.14680186f, -0.06046601f, -0.05007570f, 0.18760262f, 
    -0.03535011f, -0.10058139f, 0.03747721f, -0.12744324f, -0.06010769f, -0.01016657f, 0.14529558f, -0.15395337f, 
    0.08948765f, 0.04350824f, 0.08740624f, -0.11070112f, 0.03598018f, 0.22583242f, 0.14916824f, 0.09916687f, 
    0.03264307f, -0.07552351f, 0.02618990f, 0.01429671f, -0.05402682f, -0.29386821f, 0.15845983f, -0.08100379f, 
    0.04044661f, -0.34483910f, -0.26777261f, -0.03223720f, -0.05874748f, -0.02915282f, -0.03855222f, -0.03452561f, 
    -0.00010030f, -0.20797303f, -0.14382304f, -0.10710527f, -0.45664030f, 0.10492288f, -0.22386439f, -0.17028983f, 
    0.30456802f, 0.07964160f, 0.07814336f, -0.02617607f, 0.13295738f, 0.24000856f, -0.06091127f, 0.01101406f, 
    0.13763368f, -0.00811485f, 0.22537673f, 0.03651154f, 0.03963479f, 0.14539741f, 0.03285574f, 0.05483936f, 
    0.12048959f, 0.17004691f, -0.14024040f, 0.11561774f, -0.56920052f, 0.19667117f, -0.13091126f, 0.06234937f, 
    -0.00787173f, -0.05183442f, -0.03400800f, -0.09750959f, -0.07486098f, 0.09210756f, 0.05914720f, 0.09077748f, 
    -0.07508308f, -0.16105969f, -0.21149895f, 0.06392510f, 0.03111413f, -0.06057564f, 0.19109485f, 0.02098361f, 
    0.17379747f, -0.05798814f, -0.08672509f, -0.07192425f, 0.01807400f, -0.02211638f, 0.11085857f, -0.02108777f, 
    0.08866033f, -0.01930664f, 0.01074185f, -0.04056062f, 0.01971617f, 0.03402375f, -0.08636484f, -0.18536282f, 
    -0.30642563f, 0.00335419f, -0.22078863f, -0.08210326f, -0.02466477f, -0.02313919f, -0.03986068f, 0.03970695f, 
    0.05585386f, 0.03148428f, 0.03852509f, 0.13634436f, -0.05346866f, -0.08991864f, 0.02211089f, -0.15815905f, 
    -0.21990919f, 0.04252977f, -0.02816231f, -0.25329915f, -0.16250810f, -0.31029060f, -0.22962835f, -0.42436200f, 
    0.11737464f, 0.02321428f, -0.11276107f, -0.03230046f, -0.13583539f, -0.19410838f, -0.12516324f, 0.24907309f, 
    -0.10251116f, 0.08033513f, 0.00045222f, 0.01915428f, -0.63237715f, -0.30713555f, -0.18978772f, -0.36766550f, 
    0.02977044f, -0.17202900f, -0.03907527f, 0.05172209f, 0.08254167f, 0.06709072f, -0.11632417f, 0.12950443f, 
    0.25373799f, 0.05763841f, -0.13227016f, -0.06444687f, -0.03631426f, 0.11373520f, 0.09064987f, 0.09886454f, 
    0.09794737f, -0.02676777f, -0.02079307f, 0.03785796f, 0.14307567f, -0.02966003f, -0.21985313f, 0.09112075f, 
    -0.03340686f, -0.11726406f, 0.14069237f, 0.16298729f, 0.21479538f, 0.17620711f, 0.23192857f, 0.01730844f, 
    0.04155453f, 0.07840574f, 0.17724060f, -0.12677036f, -0.00986694f, -0.08425567f, -0.11901518f, 0.03806942f, 
    -0.13801581f, -0.03058996f, -0.00306363f, -0.02387677f, 0.22760668f, 0.09804901f, -0.02944523f, -0.26296899f, 
    -0.19472505f, 0.04785735f, 0.09843731f, 0.22614710f, 0.08897940f, 0.06575458f, 0.12329780f, 0.03698501f, 
    -0.40614313f, -0.01928527f, 0.23393409f, 0.13929866f, 0.24998708f, -0.07653006f, 0.03641685f, -0.09835289f, 
    0.02374769f, -0.00206751f, -0.09111100f, 0.01725264f, 0.34440228f, 0.23491764f, 0.06977066f, 0.02652124f, 
    0.24321863f, 0.04648569f, 0.12068373f, 0.09175329f, -0.07021004f, -0.04535759f, -0.04993759f, 0.11258575f, 
    -0.54085863f, -0.36012843f, 0.26181903f, 0.08881152f, 0.11624308f, -0.07517736f, 0.01103514f, 0.09948844f, 
    0.16618688f, 0.18487723f, -0.00740500f, 0.25279340f, 0.28512821f, 0.24749567f, -0.07709172f, 0.09757081f, 
    -0.20487243f, -0.11749347f, -0.03745056f, 0.02643961f, -0.05673020f, -0.02047381f, -0.06422405f, -0.07121546f, 
    -0.49999878f, -0.26117739f, -0.09557462f, -0.40030858f, 0.04900976f, 0.04613598f, 0.14446893f, 0.12951678f, 
    0.05747479f, 0.13192008f, 0.02874726f, 0.18822749f, 0.24243730f, 0.08394056f, -0.03716991f, 0.06751785f, 
    -0.11487519f, -0.17976172f, 0.02471592f, 0.04338308f, 0.17718166f, -0.03192709f, -0.15604238f, -0.13421561f, 
    0.26518670f, 0.03775573f, -0.00166647f, -0.16419537f, -0.09035803f, -0.00530231f, -0.04453878f, -0.11556535f, 
    0.00033176f, 0.01720677f, 0.07325465f, -0.09431999f, 0.14778054f, -0.03210480f, -0.03676042f, -0.23842113f, 
    0.02140443f, 0.16805319f, 0.08254950f, -0.01227121f, 0.12743847f, 0.03099986f, -0.01816236f, 0.09372793f, 
    -0.09175987f, 0.38424435f, -0.09643396f, 0.08336909f, -0.12133876f, -0.12105157f, 0.05558538f, -0.07187615f, 
    0.00036821f, -0.02593900f, 0.10975070f, -0.15785937f, 0.04605997f, -0.31192702f, -0.08846915f, -0.25249475f, 
    0.01936125f, -0.16500583f, -0.01776630f, 0.06795266f, 0.07816198f, 0.04883924f, -0.05417132f, 0.01020832f, 
    0.36009929f, -0.06695689f, -0.08208761f, 0.02835651f, 0.02635593f, -0.00042003f, 0.13590696f, 0.05250087f, 
    -0.04587195f, 0.09993118f, -0.06656949f, 0.11345442f, 0.10408960f, 0.12288480f, -0.14763793f, 0.07384521f, 
    0.09413555f, -0.02422861f, -0.08589703f, 0.07975724f, -0.11738588f, -0.01502332f, -0.03163438f, 0.04202242f, 
    -0.47505590f, 0.04230985f, 0.20573302f, -0.18733032f, -0.12049774f, 0.12566151f, -0.09830508f, -0.10707849f, 
    0.15643872f, 0.15540364f, 0.28754872f, 0.01044873f, -0.00460533f, 0.04186153f, 0.03528949f, 0.09520349f, 
    0.15835264f, 0.03373891f, 0.13148791f, -0.01238784f, 0.06772958f, -0.24683852f, 0.06233253f, 0.01505888f, 
    -0.02983490f, -0.05220108f, 0.10782093f, -0.00383200f, 0.01181935f, 0.11036754f, 0.01971407f, 0.08922481f, 
    0.00209811f, 0.07931032f, 0.25601724f, 0.05444482f, 0.52021158f, 0.23815329f, -0.18804887f, -0.24850482f, 
    0.00194667f, -0.13944116f, -0.09839705f, 0.01628693f, 0.06944082f, 0.06375723f, 0.09650332f, 0.07513572f, 
    0.03633057f, 0.23637012f, -0.19210485f, 0.00485204f, -0.16880991f, -0.07571012f, -0.02768251f, -0.29842672f, 
    0.03067166f, 0.01428567f, 0.06042863f, 0.00080194f, 0.06130961f, -0.25229061f, -0.08295432f, -0.09509734f, 
    0.04574657f, 0.13353015f, -0.02654368f, 0.00764772f, 0.01449798f, 0.02743705f, -0.02487146f, 0.09451195f, 
    -0.72286087f, -0.12621227f, -0.32321149f, -0.01524330f, 0.33579126f, -0.18914661f, 0.18348725f, 0.10975477f, 
    0.07855333f, 0.04352836f, -0.03016312f, 0.07064661f, -0.10796522f, -0.16335295f, 0.03873028f, 0.51018244f, 
    -0.20923384f, 0.09268507f, -0.07655627f, 0.01621691f, 0.04684185f, -0.15816726f, 0.07595311f, 0.12294254f, 
    -0.03048019f, -0.08226439f, 0.17281199f, -0.04431327f, -0.02017990f, -0.13782911f, -0.04471421f, 0.09295068f, 
    0.10291335f, 0.02466446f, -0.05589601f, 0.07509880f, 0.43395767f, -0.02757209f, 0.05506658f, 0.03531760f, 
    0.02963729f, -0.11919693f, -0.05987364f, -0.00928755f, -0.01248857f, 0.01463980f, -0.02186301f, 0.08534467f, 
    -0.01906342f, -0.37334096f, -0.01300317f, 0.07431744f, 0.09452352f, -0.02528985f, 0.09616510f, -0.02368760f, 
    0.09309299f, 0.08193605f, 0.07280865f, -0.09870084f, 0.12765934f, 0.16317777f, -0.03853510f, 0.08003011f, 
    -0.10217625f, 0.10827386f, -0.06489398f, -0.04545719f, 0.14950523f, 0.06764060f, -0.00563961f, -0.16384888f, 
    -0.13524453f, -0.10120261f, 0.10025867f, 0.09124545f, -0.16999023f, 0.13771710f, -0.15236983f, -0.04421667f, 
    -0.01836148f, -0.03524788f, 0.07659338f, -0.20063807f, 0.01143348f, -0.32517549f, -0.18230395f, 0.04884426f, 
    -0.08401019f, 0.00801814f, 0.08520167f, -0.28237078f, -0.12305956f, 0.10656869f, 0.00615781f, -0.06585842f, 
    -0.28627586f, 0.02687939f, 0.09587511f, -0.08556266f, 0.03614705f, 0.02855246f, -0.06304942f, -0.07268534f, 
    -0.16326952f, -0.15125464f, -0.02733947f, 0.09059875f, 0.11952927f, -0.55413377f, -0.12447553f, -0.31408086f, 
    0.07211699f, -0.04040870f, 0.08443201f, 0.08890324f, -0.04506149f, -0.03780555f, 0.05884718f, 0.02796467f, 
    0.18742347f, -0.07702084f, -0.18599272f, 0.25605917f, 0.09209692f, -0.06647291f, 0.01803625f, 0.11116257f, 
    -0.15557788f, 0.04187510f, -0.12461955f, -0.06371392f, 0.18909919f, -0.05306040f, 0.11307815f, 0.27292982f, 
    0.19165127f, -0.12115511f, 0.03928698f, -0.08274218f, -0.14979650f, -0.13959149f, 0.00072556f, -0.14690681f, 
    0.15908740f, 0.11267637f, -0.10665059f, -0.24965684f, -0.04808180f, -0.00314031f, 0.05068040f, -0.03257050f, 
    0.04903293f, 0.11062761f, 0.04785684f, 0.04401633f, -0.15672596f, 0.01842484f, 0.16320510f, -0.04104993f, 
    -0.13651834f, 0.08455254f, -0.05684870f, -0.18549152f, 0.21085022f, 0.01905082f, -0.09918160f, -0.03124935f, 
    0.44387323f, -0.19112782f, -0.11575378f, -0.19362997f, 0.05089091f, -0.03959643f, -0.08693997f, -0.03420252f, 
    -0.01170861f, 0.02001172f, 0.07570741f, 0.11266669f, -0.25872585f, 0.28674281f, -0.18709423f, -0.58034527f, 
    0.03618178f, -0.00063936f, 0.08417309f, -0.01450828f, -0.07458107f, 0.02338892f, -0.11769157f, -0.14227368f, 
    0.08631007f, 0.02830407f, -0.01443725f, -0.00132106f, 0.26379046f, -0.04516410f, -0.13908556f, 0.07999872f, 
    0.01798241f, -0.02856665f, 0.01107431f, 0.04892667f, 0.17788643f, -0.24784486f, -0.01166476f, 0.04975533f, 
    -0.14870566f, 0.04587166f, 0.01310216f, 0.00427718f, -0.08435188f, -0.07249608f, -0.02661283f, -0.11627253f, 
    0.35721040f, 0.10813361f, -0.26583639f, -0.21509176f, -0.00792081f, -0.06795409f, -0.06748335f, 0.01940380f, 
    0.02750758f, -0.12472689f, -0.17725319f, -0.12333199f, -0.27018633f, -0.24805444f, -0.28757352f, 0.07155221f, 
    0.16165198f, 0.09142866f, 0.10410530f, -0.02986699f, 0.10073826f, -0.12674227f, -0.04404950f, 0.00384563f, 
    0.00355011f, 0.21899202f, -0.02114074f, -0.03274810f, -0.10214122f, -0.07471680f, -0.03850605f, -0.07826909f, 
    0.03556898f, 0.01388063f, -0.02913138f, -0.07194491f, -0.05537670f, 0.32851467f, 0.01813877f, -0.22497252f, 
    -0.21897590f, 0.07056940f, -0.14030313f, -0.18236198f, -0.04757886f, 0.01244140f, 0.16168320f, -0.11712417f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04771461f, 0.02804750f, -0.05317671f, -0.01027856f, 0.04879841f, 0.02864120f, 0.01925230f, -0.09105017f, 
    0.01918336f, 0.04323696f, 0.04963415f, 0.02056827f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
