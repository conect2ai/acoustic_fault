#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84756690f, -0.85171145f, 0.32620198f, 0.57190675f, -0.13150002f, 0.74824566f, 0.14380887f, -0.30393112f, 
    0.13512197f, -0.70252901f, -0.86767226f, -0.54064804f, -0.59231627f, -0.60015708f, -0.52033937f, -0.19613174f, 
    0.08099142f, -0.21736379f, 0.32129902f, 0.10563815f, -0.59559333f, 0.62506342f, 0.05866356f, 0.40696782f, 
    -0.61769468f, -0.38946313f, -0.35802242f, -0.35621181f, 0.72319180f, 0.42619097f, 0.79437357f, -0.63184255f, 
    0.28751600f, -0.56473720f, -0.41402322f, -0.43653902f, 0.82836169f, 0.18242918f, -0.48157656f, 0.82553250f, 
    0.78971136f, -0.41044220f, -0.10186177f, -0.50573653f, -0.25600338f, -0.79492855f, -0.52166253f, 0.72585553f, 
    0.15302640f, 0.94775379f, -0.95056033f, -0.49974826f, 0.27677855f, 0.09180871f, -0.81126040f, -0.75681257f, 
    -0.54313499f, 0.50717175f, -0.35698354f, -0.69473088f, -0.08653996f, 0.45663652f, 0.21995279f, -1.10008395f, 
    -0.06069497f, -0.79335874f, -0.11526705f, 0.83492023f, -0.56147033f, -0.02773659f, 0.28854465f, -0.09141052f, 
    0.55958998f, 0.61673880f, 0.86555958f, -0.99474245f, -0.40238398f, -0.53912169f, -0.26221269f, 0.51028717f, 
    -0.60527200f, 0.84250271f, 0.64387590f, 0.05253438f, -0.34516120f, 0.60357094f, -0.43161130f, -0.31848472f, 
    0.09611823f, -0.04700851f, 0.54184788f, -0.58884019f, 0.83216530f, -0.52081066f, -0.76238769f, -0.49890000f, 
    0.58181620f, 0.39270508f, -0.15142325f, 0.63911241f, 1.08881867f, -0.74042827f, 0.63061327f, -0.07572048f, 
    -0.71596378f, -0.00349846f, 0.01732127f, 0.07075604f, -0.54019296f, -0.20706818f, 1.06154954f, -0.70697862f, 
    1.03748977f, 0.34000078f, -0.13751702f, 0.56659281f, 0.30105200f, -0.00251494f, -1.17226267f, 0.08585852f, 
    0.42001161f, -0.11747535f, -0.10198160f, -0.42647931f, -0.31212199f, -0.33688787f, 1.01325834f, -0.14165996f, 
    0.71362013f, 0.24750213f, -0.67685282f, -0.50205386f, 0.03636915f, -0.03115033f, -0.51101619f, -0.54771268f, 
    -0.98973978f, 0.60105056f, 0.68925112f, 0.24545571f, 0.69328362f, -0.09272769f, 0.14685483f, 0.06002246f, 
    0.83059216f, 1.03851008f, 0.56172776f, -0.16287316f, 0.24327561f, 0.62858850f, -0.08484165f, -0.32975802f, 
    -0.34971273f, -1.27362084f, 1.47330761f, -0.41017660f, -0.00629133f, -0.01134362f, 0.10580815f, -0.07425991f, 
    -0.18777743f, 0.10635107f, 0.46601176f, -0.49974230f, -0.48700956f, -0.49269688f, -0.88190913f, -0.78274709f, 
    0.08630712f, -0.09412649f, 0.20508683f, -0.03180471f, -0.59288651f, 0.08681601f, -0.46563077f, 0.71225137f, 
    0.66560751f, 0.28342819f, 0.73299670f, 0.02341011f, 0.31737757f, -0.46130040f, -0.79531968f, -0.62373620f, 
    -0.56459206f, -0.08071347f, -0.26374340f, 0.16539095f, -0.20372844f, -0.28285024f, -0.72725302f, 0.74255693f, 
    -1.03411853f, 0.02291110f, -0.09365834f, -0.28544852f, -0.38602322f, -0.32829478f, 1.08290315f, -0.79637963f, 
    0.34572208f, 0.37175965f, -0.29853442f, 0.64664435f, -0.05140693f, 0.14732490f, -0.44313985f, 0.85688031f, 
    0.96008360f, 0.53134030f, -0.43607375f, 0.65664035f, -0.44841784f, 0.10770677f, 0.14630002f, -0.38271600f, 
    -0.37687328f, -1.12764359f, -0.13419122f, 0.39332500f, 0.88125515f, -0.02642785f, -0.27117592f, -0.03463425f, 
    -0.39256942f, -0.50592995f, -0.96559864f, -0.79255849f, -0.51806593f, 0.41085869f, -0.04132250f, -0.35985774f, 
    -0.14199869f, 0.22695775f, 0.09517293f, 0.64380151f, 0.15736239f, 0.55928451f, 0.74113637f, -0.31682652f, 
    -0.50645536f, 0.63710201f, 0.44450414f, -0.67169344f, -0.69762880f, -0.36793360f, 0.18914978f, -0.75173289f, 
    0.03872951f, -0.52638417f, 0.13341722f, -0.57199764f, -0.47816882f, -0.67986596f, -1.13763571f, -0.70728385f, 
    0.17700820f, 0.72410727f, 0.68315995f, 0.09726545f, 0.37597957f, 0.89322197f, 0.83335179f, 0.76672846f, 
    0.41277906f, -0.70437473f, -0.53474766f, 0.18260624f, 0.27073970f, 0.44827783f, 0.82742262f, -0.45858240f, 
    -0.55102223f, 0.71575654f, -0.41519669f, -0.51219004f, -0.24344295f, -0.19567524f, 0.38458505f, 0.51084709f, 
    -0.36069989f, -0.18538572f, -0.62076902f, -0.97190374f, 0.30809590f, -0.47778448f, -0.22190452f, 0.34193739f, 
    0.91176188f, 0.89152044f, 0.19824763f, -0.18823475f, -0.85132557f, -0.24337392f, -0.10217780f, 0.15835354f, 
    0.40174657f, -0.02567961f, -0.04149609f, -0.47940841f, 0.98259878f, 0.69372135f, 0.01151090f, -0.13475023f, 
    -0.18182591f, 0.23270041f, -0.18630895f, 0.18225491f, 0.20171309f, -0.84309208f, -0.09187691f, -0.68450385f, 
    -0.08104704f, 0.23967935f, 0.61399943f, 0.18778183f, -0.46760118f, 0.79926240f, -1.07539272f, 0.29899266f, 
    -0.67355359f, 0.55318308f, 0.40489814f, 0.06357923f, -0.81560618f, 0.75534159f, -0.20159233f, 0.81355292f, 
    0.24267197f, 0.74269438f, -0.31597623f, 0.32492805f, -0.66455692f, 0.78997666f, 0.40991342f, 0.18309382f, 
    0.27428541f, 0.51712757f, 0.42598122f, -0.51998973f, 0.30592552f, -0.52384156f, 0.31407925f, -1.07652330f, 
    -0.33856574f, 0.75118649f, 0.83887768f, 0.10970715f, -0.34039563f, 0.14954898f, -0.35458574f, 0.46451753f, 
    -0.30802938f, 0.48757613f, -0.68084890f, 0.19031423f, -0.63722271f, -0.31136349f, 0.55395001f, 0.52018505f, 
    0.87390989f, 0.92083693f, -0.55682701f, -0.70737314f, 0.60068494f, 0.43807688f, -0.48895726f, 0.44644922f, 
    0.23491110f, 0.65580016f, -0.55947948f, -0.82273936f, 0.38232902f, -0.25945976f, -0.39166415f, -0.35415182f, 
    0.42042091f, -0.49794933f, -0.20876279f, 0.92548788f, -0.22500813f, 1.04724431f, 0.09980328f, 0.18834785f, 
    0.37210673f, -0.58158064f, -0.05819833f, 0.51184821f, 0.93656206f, 0.95180410f, -0.04838230f, 0.30316982f, 
    0.06121118f, 0.54957849f, 0.34551811f, 0.11849429f, -0.62474024f, 0.22023195f, 0.54735827f, -0.85455114f, 
    -0.20575777f, -0.67941433f, -0.08836103f, 0.41819450f, -0.44509169f, 0.14509679f, 0.01112628f, 0.00920760f, 
    -0.57765728f, -1.06937468f, -0.37197790f, 0.08006671f, 0.57876295f, -0.34588739f, 0.34185779f, -0.68554932f, 
    -0.88695151f, -0.35404721f, 0.92241275f, 0.53427809f, 0.11536758f, -0.27081770f, -0.48508650f, -0.18417697f, 
    -0.18278252f, -0.16917400f, 0.61652285f, -0.89720404f, 0.72859341f, 0.66783768f, 0.24324453f, 0.16529043f, 
    0.72502422f, -0.41614178f, -0.77626592f, 0.63563550f, -0.35270482f, -0.39509103f, -0.26592425f, 0.25446981f, 
    -0.07708344f, 0.78211433f, -0.26932728f, 0.95497113f, 0.53361011f, -0.85417736f, 0.15069082f, -0.22168875f, 
    -0.32919943f, -0.46182695f, 0.61120009f, -0.39602247f, 1.05356598f, -0.87817478f, 0.66570187f, -0.16536802f, 
    0.52150625f, -0.43821755f, 0.14625879f, -0.04801593f, -0.42484820f, 0.65500313f, -0.00773081f, -0.99786735f, 
    -0.60443032f, 0.25210717f, 0.31317800f, 0.03811909f, -0.78164589f, 0.89083374f, -0.66965032f, 0.33117729f, 
    -0.45310989f, -0.53783536f, 0.20550767f, -0.08251525f, -0.29813212f, -0.22994249f, -0.60758346f, 0.16816053f, 
    -0.06087607f, 0.29732448f, -0.81094939f, 0.55442595f, -0.01675789f, 0.53951317f, 0.61870533f, 0.47721505f, 
    -0.25603306f, 0.55264729f, 0.27653867f, 0.65025926f, 0.44310567f, 0.34085414f, -0.33820000f, -0.78406566f, 
    -0.80050641f, -0.39226326f, 0.50058824f, 0.92803007f, 0.34262219f, -0.28014359f, -0.29472241f, 0.26459411f, 
    -0.70199168f, -0.03135378f, 0.79257661f, -0.40697402f, -0.28474733f, -0.53587174f, -0.38281205f, -0.17909527f, 
    0.01439410f, -0.58353579f, -0.96298397f, -0.50070953f, -0.30511683f, 0.75995362f, 0.76182705f, 0.03899283f, 
    -0.07055759f, -0.25341514f, 0.88681793f, 0.72197181f, -1.26582050f, -0.42761016f, 0.23915838f, 0.78976238f, 
    0.24519369f, -0.36692676f, 0.44259125f, -0.31404307f, -0.94634974f, -0.55996644f, 0.57746077f, 0.37760863f, 
    0.54367697f, -0.11868721f, 0.30577457f, -0.33420968f, -0.12699132f, -1.12377858f, 0.89836216f, 0.43688953f, 
    -0.18918887f, 0.60270178f, 0.22197348f, 0.01739699f, -0.16216069f, -0.11634939f, 1.07108271f, 0.84394526f, 
    0.72217286f, 0.00402578f, -0.57530081f, -0.35095105f, 0.11090764f, -0.44030657f, -0.57927752f, 0.78935343f, 
    -0.58645290f, -0.45261076f, -0.05323148f, 0.70295048f, -0.30830935f, 0.04782412f, -0.84703255f, 0.82702643f, 
    -0.18355010f, -0.76405942f, -0.75084156f, 0.21139267f, -0.56736493f, 0.25580013f, 0.45504656f, 0.80126089f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14727004f, 0.18103640f, 0.07319038f, -0.03966063f, 0.10499562f, 0.00291778f, 0.19699371f, 0.19681805f, 
    -0.11624704f, 0.36798477f, 0.05858156f, -0.10348802f, 0.00584393f, 0.04447202f, -0.11578394f, 0.24436530f, 
    0.19396603f, 0.12871745f, 0.38479474f, -0.05528254f, 0.35999531f, 0.04932366f, 0.11592810f, 0.26474792f, 
    0.26580280f, 0.11610106f, -0.16565880f, -0.16515236f, 0.22124919f, -0.09886251f, 0.23982690f, -0.00224978f, 
    0.12427284f, 0.30428070f, -0.17876381f, -0.12715743f, -0.08763646f, 0.39463791f, -0.00576692f, 0.05896671f, 
    0.12229060f, 0.14615823f, -0.03538334f, 0.22765651f, 0.15278685f, 0.36717585f, 0.11202480f, -0.22039586f, 
    0.33779699f, 0.03760813f, -0.16290523f, 0.30405012f, 0.21148483f, 0.07215963f, 0.28730562f, 0.02543233f, 
    0.21175446f, 0.06546124f, -0.01680727f, 0.13521528f, -0.01697907f, 0.19084348f, -0.09015119f, 0.11740510f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11088073f, 0.04425070f, 0.12619668f, -0.09486087f, -0.25793746f, 0.06326285f, 0.07426280f, -0.01646605f, 
    0.02658841f, 0.05786828f, -0.03325367f, -0.05530117f, 0.04562261f, -0.07235493f, -0.05048712f, -0.00958254f, 
    0.01574944f, 0.01465601f, 0.05647390f, -0.05323588f, -0.30534962f, -0.42871511f, -0.18935655f, 0.08984137f, 
    -0.08689350f, -0.02052147f, -0.04469932f, -0.02101308f, 0.05915380f, 0.02066429f, -0.01662077f, -0.04258143f, 
    -0.04195245f, -0.04798178f, 0.03814469f, 0.04720894f, 0.00393633f, 0.06707051f, -0.02005229f, 0.01470688f, 
    0.15643315f, 0.02741098f, 0.04951686f, 0.03689192f, 0.07135564f, 0.05045179f, 0.03041883f, -0.00627917f, 
    0.02383329f, -0.08972900f, 0.00882260f, -0.02099709f, 0.01258428f, -0.01513350f, 0.03814587f, 0.06437849f, 
    0.10466042f, -0.04103311f, -0.05343641f, 0.04307421f, -0.14122213f, 0.03610421f, 0.24668002f, 0.08099984f, 
    -0.05619949f, -0.08633242f, -0.04656499f, 0.08434839f, -0.05671310f, 0.00105270f, 0.02542851f, 0.00874614f, 
    -0.00456001f, 0.04283962f, -0.01198645f, 0.10847429f, 0.02760043f, -0.08903406f, -0.03226938f, -0.00327324f, 
    0.03579731f, 0.02604667f, 0.15216173f, 0.08658279f, 0.28239024f, -0.12317990f, -0.00679632f, -0.04269209f, 
    0.07284991f, -0.08762679f, 0.02277822f, 0.11832120f, 0.01573752f, -0.02722846f, -0.02041255f, 0.00713068f, 
    -0.01684129f, 0.05479458f, -0.07220015f, 0.08843724f, -0.08770896f, -0.04096464f, 0.28544825f, 0.02086649f, 
    -0.26594317f, 0.01735839f, -0.01829713f, 0.08337454f, 0.04335561f, 0.08275562f, -0.02097628f, 0.06004672f, 
    -0.03332341f, -0.01033971f, -0.09128276f, -0.01640777f, -0.05859441f, 0.02832279f, -0.11623029f, -0.02134780f, 
    -0.14389506f, -0.27444634f, -0.05669677f, -0.04053546f, -0.05109365f, 0.00312096f, -0.08572031f, 0.00942739f, 
    -0.00238239f, 0.05727516f, -0.06047773f, -0.03717307f, -0.02532868f, -0.06034511f, 0.02831399f, 0.04230464f, 
    -0.00131953f, 0.02416190f, -0.05136860f, -0.05102075f, 0.38186565f, 0.14194602f, -0.03427630f, -0.12447675f, 
    -0.13943824f, 0.03306312f, 0.00205409f, -0.00385453f, 0.01922156f, 0.03804532f, -0.01888295f, 0.04015835f, 
    -0.09909880f, -0.02251066f, 0.09563184f, -0.02493721f, 0.04141617f, 0.08764040f, 0.07340345f, -0.02404696f, 
    0.12554318f, 0.02441961f, -0.03270690f, -0.01754369f, 0.06729965f, -0.02340243f, -0.12806264f, -0.12560514f, 
    0.04809380f, -0.00001121f, -0.00866328f, -0.03462322f, 0.00965949f, 0.00392768f, 0.02807906f, -0.00029200f, 
    0.03282804f, 0.01111546f, 0.05599819f, -0.02188858f, 0.00709779f, 0.02022575f, -0.01477311f, -0.11283062f, 
    0.15744171f, -0.09916401f, -0.01737517f, -0.11569699f, 0.06456919f, 0.03322237f, -0.07079867f, 0.01557662f, 
    -0.01607448f, -0.06684715f, -0.04961921f, -0.01467493f, 0.04797247f, -0.03163296f, 0.00707868f, -0.03939643f, 
    0.22027905f, -0.22263309f, -0.02089093f, 0.12195130f, -0.24709404f, -0.09547926f, -0.01912190f, 0.00468881f, 
    -0.06218541f, -0.06479302f, -0.00575573f, 0.04796084f, -0.02886383f, -0.01262488f, -0.04874877f, -0.03245948f, 
    -0.05719748f, 0.03494351f, 0.04670190f, 0.06498627f, 0.20168774f, -0.07199936f, 0.10858285f, -0.07165477f, 
    0.32982984f, -0.22101453f, 0.01531524f, 0.03068665f, 0.07471828f, -0.03085820f, 0.02861572f, 0.01059040f, 
    -0.02768199f, 0.05218542f, -0.12548818f, 0.08044140f, -0.03683936f, 0.09335732f, -0.12269849f, -0.00525052f, 
    -0.21999156f, -0.04248514f, 0.05716676f, 0.15091024f, -0.07526354f, 0.03430846f, -0.00021097f, 0.08080309f, 
    0.03515573f, -0.08436946f, 0.02273452f, -0.03206107f, 0.05156265f, -0.02734125f, 0.03467273f, 0.01569118f, 
    -0.04069506f, -0.01299909f, 0.02072920f, -0.04954567f, -0.03074266f, -0.09469473f, 0.10361557f, 0.14310634f, 
    -0.36677220f, 0.09226876f, 0.04275052f, -0.00448321f, -0.01065446f, -0.01479718f, 0.04411050f, -0.00739181f, 
    -0.01003386f, 0.03104974f, 0.04975780f, 0.03723270f, 0.00179036f, 0.08475925f, -0.07889507f, 0.01810044f, 
    0.29980430f, -0.15702307f, 0.09842287f, -0.05374443f, -0.15729734f, -0.06406049f, -0.10515589f, 0.01761332f, 
    0.00870759f, 0.05992511f, -0.07986090f, 0.00105578f, -0.07130950f, 0.05107228f, -0.05282418f, 0.03946896f, 
    -0.04422705f, 0.13009825f, 0.10320068f, 0.03768447f, -0.09713399f, 0.14115438f, 0.11791825f, -0.08876903f, 
    -0.17249765f, 0.05028718f, 0.02274676f, 0.03805751f, 0.02263469f, -0.03292218f, -0.02244535f, -0.00882781f, 
    -0.01330732f, -0.02731723f, -0.03116564f, 0.06043084f, 0.03136008f, -0.01560837f, -0.01614885f, 0.02926414f, 
    0.16342862f, 0.06063553f, -0.00629644f, -0.13812423f, 0.25960210f, -0.17690152f, -0.14207888f, -0.00847054f, 
    0.02042791f, -0.01264174f, -0.04909777f, 0.03261359f, 0.01201913f, -0.03838299f, 0.01822516f, 0.04352044f, 
    0.09405942f, -0.10776374f, -0.01766161f, 0.10822164f, 0.40130261f, 0.14113185f, 0.16893557f, -0.17093135f, 
    0.16661295f, -0.00507671f, -0.09397276f, 0.03860031f, -0.10179378f, -0.05198200f, 0.04754104f, -0.02013412f, 
    -0.06295293f, -0.04381582f, 0.08239698f, -0.04742238f, -0.08590399f, 0.07486591f, -0.16516335f, -0.07193742f, 
    -0.06545179f, -0.29645109f, 0.19469421f, 0.12605691f, -0.00620087f, 0.01195381f, 0.04505617f, 0.03958733f, 
    0.01891135f, 0.01477915f, -0.04867718f, -0.07904112f, -0.00831505f, -0.02084759f, -0.03912246f, 0.03426366f, 
    -0.00789302f, 0.00562498f, 0.06113435f, -0.11013986f, -0.32888922f, 0.10985232f, -0.09186906f, -0.00697721f, 
    -0.09254186f, -0.06024713f, 0.01890087f, 0.01764935f, 0.00139316f, 0.03877597f, 0.06742024f, 0.02197060f, 
    0.04102738f, 0.03197191f, 0.07435343f, -0.01272209f, -0.01189564f, -0.01951990f, -0.06077355f, -0.01057211f, 
    0.00820077f, -0.25428721f, 0.10982707f, 0.08605162f, 0.00410951f, -0.05390269f, -0.02131472f, 0.01787725f, 
    -0.00228194f, 0.03575547f, -0.02920669f, -0.10735479f, -0.00936307f, -0.01082035f, -0.00613297f, -0.07235625f, 
    -0.01054979f, -0.04723863f, 0.02884370f, -0.04211684f, 0.17480965f, -0.22367848f, -0.18386146f, 0.19147618f, 
    -0.13772513f, -0.08186273f, 0.02025701f, 0.02196339f, 0.13180649f, -0.04326789f, 0.07968296f, 0.07968519f, 
    -0.09593532f, -0.05594511f, 0.03010321f, 0.01776163f, -0.05923643f, 0.00585504f, -0.01089067f, 0.09674609f, 
    0.28827286f, -0.19509946f, 0.00844225f, -0.02335490f, -0.18965445f, -0.01468223f, 0.04044038f, -0.08971318f, 
    -0.02083414f, -0.04521745f, -0.18086098f, 0.00280655f, -0.02951133f, 0.01370861f, 0.00004069f, -0.01577877f, 
    -0.05271900f, -0.00527891f, 0.01374430f, 0.01071448f, 0.04151801f, 0.10355546f, 0.00716729f, -0.20194668f, 
    0.16250737f, -0.11352058f, -0.07639992f, -0.06197394f, -0.00095588f, 0.08024282f, -0.06276049f, 0.05688436f, 
    -0.05071872f, -0.06252822f, 0.04915505f, -0.01706838f, 0.00384271f, 0.00304787f, -0.00740721f, -0.00853750f, 
    -0.10129452f, 0.13317314f, 0.12199693f, -0.05403246f, -0.29931828f, 0.04354981f, 0.03896623f, 0.03943305f, 
    0.00736299f, 0.01282975f, 0.06030447f, 0.02260988f, -0.00312403f, 0.05413720f, -0.04804155f, -0.04618140f, 
    0.06988361f, 0.02192538f, -0.02054803f, -0.04925120f, -0.24078748f, 0.09950657f, -0.10828805f, 0.01522877f, 
    -0.23682153f, 0.05152003f, -0.04942813f, 0.09076797f, -0.06383949f, -0.03441844f, -0.01022528f, 0.04510639f, 
    0.06810270f, -0.00558538f, 0.04030553f, -0.08242891f, -0.04439475f, 0.00920965f, -0.04751410f, 0.05672038f, 
    0.03557971f, 0.00288048f, 0.08022192f, -0.04942393f, 0.12635732f, 0.02138116f, 0.03248257f, 0.06621074f, 
    -0.08171494f, -0.02370908f, 0.08116916f, 0.01421593f, -0.01406913f, 0.02435726f, -0.01893336f, -0.16052739f, 
    -0.00642538f, 0.03098643f, -0.03629829f, 0.07292737f, -0.06366994f, -0.21528985f, -0.16407661f, -0.00036266f, 
    -0.23733041f, 0.07003640f, -0.03832538f, -0.01985217f, 0.01812073f, 0.08252192f, 0.01563443f, -0.08394321f, 
    0.03768305f, -0.06108314f, -0.03098463f, 0.10128762f, -0.05535346f, -0.02738056f, -0.03211813f, 0.07405394f, 
    -0.39396781f, 0.07983587f, -0.15765120f, 0.03664611f, -0.19912562f, -0.05220323f, -0.06892300f, 0.01167912f, 
    0.00186268f, 0.04437565f, -0.02105726f, -0.04674600f, -0.07287336f, 0.08632968f, 0.05845428f, 0.04511055f, 
    -0.04165925f, 0.01066862f, 0.06527019f, -0.10517619f, 0.09383465f, 0.01909774f, 0.06048819f, -0.21838988f, 
    0.03048570f, -0.15334919f, -0.12807122f, 0.00833599f, -0.02287430f, -0.00647422f, -0.02458768f, -0.07407373f, 
    -0.01620174f, 0.01676963f, -0.08366196f, 0.09356967f, -0.03155944f, 0.06722156f, -0.01610162f, 0.02307315f, 
    0.07618009f, -0.29557350f, 0.16899079f, 0.08561593f, 0.04116939f, 0.00753277f, 0.03725169f, 0.01859171f, 
    0.04002986f, -0.02619710f, -0.11543378f, 0.07380014f, -0.00999635f, 0.03760133f, -0.04067644f, 0.04498899f, 
    0.04851942f, -0.00515083f, -0.16156259f, -0.04068322f, 0.02205781f, -0.22294009f, -0.02709004f, 0.08080073f, 
    -0.07603795f, 0.05603498f, -0.01184932f, -0.09169436f, -0.01876467f, 0.01242876f, -0.07103727f, 0.07122672f, 
    0.00088544f, 0.06869278f, 0.04488781f, -0.01170059f, 0.02457675f, -0.13341045f, 0.02638919f, -0.04779137f, 
    0.13924648f, 0.04040702f, 0.10246362f, -0.19949000f, 0.07326491f, -0.04419742f, -0.10872053f, -0.04539605f, 
    0.02497464f, 0.02534135f, 0.05313068f, -0.05502856f, 0.00363475f, 0.05251492f, -0.07695273f, 0.07483577f, 
    0.00605349f, 0.01906324f, 0.02259133f, 0.05064541f, 0.17124417f, 0.10325312f, 0.00321209f, -0.08006041f, 
    0.02313378f, -0.06246859f, -0.02152139f, -0.02985051f, -0.06761443f, -0.08687877f, 0.06848030f, 0.04670544f, 
    -0.08232436f, 0.06980646f, 0.00368120f, 0.01651866f, -0.01084535f, 0.03743783f, 0.01579661f, 0.04889707f, 
    -0.03094655f, -0.13357176f, 0.00397005f, 0.02839696f, 0.08365002f, -0.00054293f, 0.00876691f, -0.11241235f, 
    0.08876409f, 0.03855903f, 0.03963749f, 0.02712206f, -0.02898487f, 0.02772342f, 0.03112882f, -0.03476563f, 
    0.09511702f, 0.01377118f, 0.09602410f, -0.04586527f, 0.09642792f, -0.19030571f, -0.06393005f, 0.19082312f, 
    -0.21163082f, -0.04444179f, -0.05187514f, -0.09258314f, 0.02590260f, -0.03113532f, 0.03657324f, 0.05979872f, 
    -0.07946922f, 0.00362636f, -0.01425539f, 0.00814299f, 0.00925393f, -0.07460738f, -0.03238295f, 0.04402222f, 
    0.19665302f, 0.07429682f, 0.16198610f, -0.07498821f, 0.05817100f, 0.03018851f, -0.03165850f, 0.12033504f, 
    -0.08309251f, -0.01250026f, -0.01555884f, -0.16219088f, -0.00957375f, -0.05871627f, 0.10543042f, 0.05198749f, 
    -0.01695484f, -0.07145726f, 0.06159884f, 0.03165776f, 0.08730472f, 0.02789648f, 0.01535799f, -0.11174759f, 
    0.14424226f, -0.08455200f, -0.01757319f, -0.12204596f, -0.02060009f, 0.04476672f, -0.04917349f, -0.01250115f, 
    0.05806113f, 0.02037074f, -0.02622796f, 0.05822465f, 0.01129840f, -0.04659379f, -0.03853247f, -0.02262256f, 
    0.05517511f, 0.22352153f, 0.10144837f, -0.01261566f, -0.11800744f, 0.04170557f, -0.01081336f, -0.00004368f, 
    -0.09963913f, -0.04714404f, 0.03018390f, 0.01733864f, 0.04235623f, 0.02359959f, 0.01465813f, 0.07212824f, 
    0.16452549f, 0.08006274f, -0.00008049f, 0.06700819f, 0.14743711f, -0.06065120f, 0.02285657f, 0.04495798f, 
    -0.08520340f, -0.01097739f, -0.03371990f, -0.03112747f, 0.03286666f, -0.01001423f, 0.00477299f, 0.01562154f, 
    -0.06538847f, 0.01955974f, -0.02728858f, -0.07109348f, -0.03977153f, -0.06464418f, 0.02199366f, -0.04485195f, 
    -0.07082587f, -0.03233295f, 0.03694323f, -0.19664605f, 0.25493971f, -0.10700928f, -0.04305804f, -0.12961192f, 
    0.04018230f, 0.06439874f, -0.01450484f, -0.02418770f, 0.08195705f, -0.01440622f, 0.00171187f, -0.07744338f, 
    0.01609376f, -0.03079447f, 0.02869477f, -0.04072872f, 0.19563092f, -0.44386175f, 0.12222718f, -0.02701667f, 
    -0.01467503f, 0.01227839f, -0.03238729f, 0.01114910f, 0.00227917f, 0.02439100f, -0.12766704f, 0.00500664f, 
    0.09689886f, 0.02554891f, 0.02287860f, -0.03233477f, 0.01122085f, 0.06716397f, 0.00414761f, -0.01546083f, 
    0.36560377f, -0.22548781f, 0.06770025f, -0.10434756f, 0.11963759f, -0.16001445f, 0.05259968f, 0.11453170f, 
    -0.10360449f, -0.04466695f, -0.04999370f, 0.07375592f, -0.09810165f, 0.04042559f, 0.10773079f, 0.06543190f, 
    0.04330359f, 0.04489322f, -0.04580218f, -0.11002025f, -0.02267207f, 0.11854348f, -0.10673541f, -0.10955420f, 
    0.16308676f, 0.00348710f, -0.05500855f, -0.02262024f, -0.01587742f, -0.03414691f, 0.00215633f, 0.01325329f, 
    0.00665286f, -0.01674020f, 0.00243814f, -0.06496800f, 0.01918282f, 0.01754866f, -0.03744409f, 0.02201578f, 
    -0.14411546f, -0.09546577f, -0.06639366f, 0.06805640f, 0.00533736f, 0.03044947f, 0.01423502f, -0.04942818f, 
    0.03756808f, 0.02530735f, 0.01686181f, 0.06199662f, -0.06992096f, -0.04411399f, -0.07959350f, 0.05675535f, 
    -0.02666534f, -0.00793334f, 0.05999065f, -0.05871996f, 0.03443387f, -0.13184553f, 0.08685408f, 0.08786076f, 
    -0.01778555f, -0.00862373f, 0.00464400f, -0.04962194f, -0.06265556f, 0.00790983f, -0.05430947f, -0.03583860f, 
    0.02971090f, -0.09050962f, 0.00566245f, -0.00738124f, 0.04168507f, -0.09081287f, -0.00197183f, -0.03156357f, 
    -0.17486469f, 0.25682896f, -0.03008469f, -0.05035815f, -0.07219357f, -0.01472591f, 0.03887678f, -0.03010840f, 
    -0.11667859f, -0.00867554f, -0.05376591f, -0.01989767f, 0.00636366f, -0.02363810f, -0.03916194f, -0.05957441f, 
    0.02206697f, 0.02688156f, -0.03845099f, -0.03607738f, 0.19919507f, -0.24961784f, 0.02771823f, 0.00876867f, 
    -0.08532158f, -0.02370536f, 0.07982842f, -0.09003573f, -0.10313211f, 0.08622237f, 0.06555001f, 0.06448160f, 
    0.09964975f, 0.04950724f, 0.06357646f, 0.02252158f, -0.14917260f, 0.01681907f, 0.00708346f, -0.02239031f, 
    0.19859385f, -0.38810965f, 0.09805684f, 0.01589108f, 0.06794492f, -0.02335755f, 0.03751922f, 0.00434495f, 
    -0.03720748f, -0.02041026f, -0.11220353f, 0.02053086f, 0.02613161f, 0.03992866f, 0.01954531f, -0.01353544f, 
    0.02729611f, 0.04662426f, -0.04031091f, -0.02258641f, 0.21518613f, -0.16886973f, 0.04933392f, 0.08932969f, 
    -0.20804743f, -0.07739332f, -0.12577714f, 0.01694411f, 0.02800411f, 0.05436679f, -0.11935635f, 0.08093309f, 
    -0.05157717f, 0.07261615f, -0.00274884f, 0.04041269f, -0.02826373f, 0.07565237f, 0.01389312f, 0.03370806f, 
    0.35584256f, 0.02050532f, -0.00419960f, 0.11795728f, -0.17285389f, -0.15845545f, -0.17409539f, -0.03564461f, 
    -0.01179097f, 0.00279377f, -0.00379002f, -0.06457898f, -0.03330723f, -0.02154348f, -0.01387722f, -0.16114362f, 
    -0.05225611f, 0.06583832f, 0.00684109f, 0.02739581f, -0.14968415f, -0.17671987f, 0.04444878f, 0.06680588f, 
    -0.08378135f, 0.02254400f, 0.00283453f, 0.01888881f, -0.14016740f, -0.04055316f, -0.09193207f, -0.04209353f, 
    -0.05572518f, -0.02339561f, -0.07689539f, -0.00987828f, -0.03027392f, 0.04673438f, 0.01287498f, -0.11859158f, 
    0.19554798f, -0.01830474f, 0.11340696f, 0.01272194f, 0.01465961f, -0.08519236f, -0.07954915f, 0.03287559f, 
    -0.09861457f, 0.07378989f, 0.06222756f, 0.00527228f, -0.07613086f, -0.00286274f, -0.01251986f, 0.01160237f, 
    -0.03080727f, 0.06693949f, -0.04325442f, -0.15202665f, -0.00889068f, -0.28560296f, 0.04132122f, 0.06917247f, 
    -0.12207138f, -0.06941506f, -0.04684528f, -0.08732738f, 0.11959787f, -0.02615553f, -0.04805300f, 0.08673608f, 
    -0.02539719f, -0.04410803f, -0.04029529f, -0.00968138f, 0.06315754f, -0.08618133f, -0.01827073f, -0.06471280f, 
    0.06680827f, -0.04452225f, -0.01546596f, -0.13670217f, 0.09503399f, -0.08548282f, 0.04287010f, -0.04113278f, 
    -0.00478602f, 0.01644563f, -0.07615650f, -0.01711871f, -0.00715248f, 0.02101817f, 0.03504915f, 0.00283120f, 
    -0.06534304f, 0.01640146f, -0.04750463f, 0.00797778f, 0.07060964f, 0.23106185f, 0.12478092f, -0.11927085f, 
    -0.26607537f, 0.04908412f, 0.08832684f, -0.02001783f, 0.02953456f, -0.10147065f, 0.01438784f, -0.00977911f, 
    0.00653829f, 0.01397506f, 0.00788809f, -0.00507425f, 0.04971900f, 0.02571479f, 0.03078863f, 0.04090653f, 
    -0.10764374f, 0.00468743f, -0.03065233f, 0.08993152f, 0.02574321f, 0.04358124f, -0.03409776f, 0.00576785f, 
    0.07483957f, 0.04616930f, 0.02929219f, 0.04558362f, -0.03903391f, -0.01021921f, -0.05719503f, -0.02114728f, 
    -0.06220301f, 0.05243761f, 0.06699442f, 0.03969496f, -0.19916993f, 0.22116451f, -0.01717745f, -0.20071891f, 
    -0.28407076f, 0.03848843f, 0.02783985f, -0.01398233f, 0.08297468f, 0.01232115f, 0.03245177f, 0.00555136f, 
    0.02689232f, 0.07263729f, -0.03036110f, -0.00666403f, -0.07291126f, -0.01975736f, 0.06285205f, 0.01574030f, 
    -0.28052795f, -0.00415805f, 0.14976256f, -0.14165741f, 0.17953382f, -0.08660021f, -0.02823072f, -0.11157945f, 
    0.03222181f, -0.02882301f, -0.01146018f, -0.01964186f, 0.08696721f, 0.07135554f, 0.06410428f, 0.04731444f, 
    -0.06256839f, -0.00169773f, -0.09719513f, -0.05627508f, 0.07611481f, 0.12892336f, -0.11661194f, -0.17759974f, 
    -0.27179477f, 0.05966762f, 0.00955429f, 0.03706327f, 0.06414526f, -0.03961168f, 0.05410040f, -0.03154241f, 
    0.09719308f, -0.02389519f, -0.01822500f, 0.07001813f, 0.02574059f, 0.01906644f, -0.01188310f, 0.02453132f, 
    -0.08259141f, 0.02697806f, 0.03289676f, 0.00869664f, -0.29511791f, 0.03387409f, 0.00832756f, 0.02773316f, 
    0.02650796f, 0.02562409f, -0.03092673f, 0.02153704f, -0.08986591f, -0.02500066f, -0.03017516f, -0.02640795f, 
    0.00911267f, -0.03860839f, 0.06727988f, -0.00961149f, -0.12660635f, 0.05277779f, 0.11785217f, 0.00478067f, 
    0.10126490f, -0.10615415f, -0.15240225f, 0.01286789f, -0.00910557f, 0.02690081f, 0.00541579f, 0.03269831f, 
    -0.08718800f, 0.08193251f, -0.06935443f, 0.01895444f, 0.02780609f, -0.00271984f, -0.08644042f, -0.03525569f, 
    0.00610028f, 0.12846798f, 0.12776841f, -0.07275484f, 0.18980156f, 0.03647477f, -0.02579978f, 0.03217538f, 
    -0.06210997f, 0.01684815f, -0.13839075f, -0.05106490f, 0.06891837f, -0.05666906f, 0.01540164f, -0.02511012f, 
    0.00522030f, -0.09113156f, 0.06776637f, -0.05625116f, -0.31065848f, -0.14878279f, 0.10385084f, 0.06032617f, 
    -0.00314634f, -0.00597168f, -0.01376276f, 0.05150752f, 0.10447406f, 0.11116704f, 0.06799977f, 0.08242278f, 
    0.00561551f, 0.05297300f, -0.00810688f, 0.00728171f, -0.06801436f, -0.07057724f, 0.02146333f, -0.10129659f, 
    -0.03702384f, 0.18291473f, -0.10359704f, 0.10201257f, -0.27667931f, 0.04974272f, 0.05623971f, -0.03797275f, 
    -0.07334054f, 0.00978592f, 0.06751133f, 0.10391883f, -0.12507913f, 0.06533600f, 0.07080879f, 0.08535454f, 
    0.07798377f, -0.03640051f, -0.01848769f, 0.06936359f, 0.05678870f, 0.02012500f, 0.00537344f, -0.06483517f, 
    -0.07397754f, 0.03848732f, -0.02847348f, 0.04285534f, 0.03897950f, 0.06500488f, -0.05901828f, -0.05730363f, 
    0.04229285f, 0.14269397f, -0.08195053f, -0.04685714f, 0.04774365f, -0.17495808f, -0.16607362f, -0.10418575f, 
    0.02514525f, -0.14475067f, 0.01761414f, -0.02239946f, 0.04415594f, -0.04135035f, -0.01850350f, -0.13509667f, 
    0.01692760f, -0.00653537f, 0.09408446f, 0.04399112f, 0.02312078f, -0.00315466f, -0.07104681f, -0.07604025f, 
    -0.04861376f, -0.02802296f, 0.04359606f, -0.02299621f, 0.19757290f, 0.03337935f, -0.09623180f, -0.00490452f, 
    0.24191149f, -0.07379088f, -0.03241098f, 0.04631395f, -0.07620899f, 0.03058285f, -0.01523057f, 0.05093964f, 
    -0.00458796f, -0.01644815f, -0.06012055f, 0.00476470f, -0.10703330f, 0.10070880f, 0.00172887f, -0.04382382f, 
    0.19720088f, -0.36200461f, 0.06005669f, -0.05228630f, 0.01687068f, 0.04354012f, -0.04624188f, -0.04430197f, 
    0.05630252f, -0.09160420f, -0.12020549f, -0.03068672f, -0.09602568f, -0.03123612f, 0.02420189f, -0.11526489f, 
    0.09101690f, -0.07026818f, 0.12647644f, 0.05091735f, -0.14646797f, -0.07383316f, -0.18428122f, -0.07301372f, 
    0.11111253f, -0.10971978f, 0.00681401f, 0.00840686f, -0.07886802f, 0.04250885f, 0.03987352f, -0.06231373f, 
    0.07210717f, -0.02513137f, -0.01090553f, -0.09948664f, -0.01257124f, 0.02086677f, 0.03186269f, 0.03516681f, 
    0.03704034f, 0.07823754f, -0.02195215f, 0.03080700f, -0.00584825f, 0.04749982f, -0.05512872f, 0.04064010f, 
    -0.03726281f, 0.05632338f, -0.01241399f, -0.08268523f, 0.04292837f, 0.02836554f, -0.05920216f, -0.02540842f, 
    0.08273061f, -0.13990445f, 0.01789113f, 0.03032175f, -0.14935422f, -0.05579492f, -0.24578828f, -0.01404344f, 
    0.01365800f, 0.06168971f, -0.00325938f, -0.01856324f, 0.03237183f, 0.17016253f, -0.00469301f, 0.00569813f, 
    0.02044891f, -0.03800602f, 0.04205846f, 0.07675053f, 0.05375293f, 0.00289333f, -0.14525959f, -0.00813033f, 
    -0.06149952f, 0.04350341f, -0.21368757f, 0.14164506f, 0.00548439f, 0.03556921f, -0.00483726f, 0.00162952f, 
    -0.02706912f, 0.03941169f, -0.04608298f, -0.11082705f, -0.00919982f, 0.04614474f, -0.07844642f, -0.00734970f, 
    0.02806878f, -0.06677017f, -0.09132382f, 0.05163187f, 0.28782558f, 0.07772660f, 0.04080290f, 0.01550962f, 
    0.08788867f, -0.03490655f, -0.03647081f, 0.05743559f, -0.02233288f, 0.01628800f, 0.08687524f, -0.04831212f, 
    0.03455067f, 0.07283030f, 0.01210079f, 0.00418652f, 0.05649276f, 0.02310558f, -0.00563249f, 0.07302029f, 
    -0.23333822f, -0.09366006f, 0.06919678f, -0.02834594f, -0.13019241f, 0.03751826f, -0.01800434f, 0.01335636f, 
    0.06757583f, -0.09095939f, 0.00903144f, 0.06895633f, 0.02130745f, -0.00811856f, 0.03077731f, 0.02264901f, 
    0.02729148f, -0.10700454f, -0.04534392f, -0.05377560f, -0.10543872f, -0.37057579f, 0.03967747f, -0.28704411f, 
    0.10069592f, -0.01978377f, -0.17070386f, 0.01462077f, -0.03828990f, -0.02006393f, -0.05124195f, 0.04381098f, 
    -0.00786599f, -0.06142049f, 0.11890417f, -0.15100971f, -0.03324294f, -0.13826212f, 0.04091269f, -0.08724644f, 
    -0.42533365f, 0.21203865f, -0.04092536f, -0.14359893f, 0.05107135f, -0.07412011f, -0.01795820f, -0.09768979f, 
    -0.09283716f, 0.00766286f, 0.01891008f, -0.06995415f, -0.06069462f, -0.03311214f, -0.06556224f, -0.05617093f, 
    -0.02021315f, 0.03924449f, -0.06529153f, 0.13171704f, 0.17223866f, -0.04798345f, -0.04862586f, -0.04223393f, 
    -0.24310081f, -0.00796351f, 0.06747468f, -0.01147683f, -0.01923182f, 0.06665733f, 0.15766424f, -0.03834232f, 
    -0.01556029f, 0.01245954f, 0.01425352f, -0.03894565f, 0.04112584f, -0.11304898f, 0.00708535f, -0.05267666f, 
    0.09040418f, 0.13253668f, 0.10786210f, 0.00169366f, -0.05936591f, -0.01752746f, -0.05417519f, 0.01861279f, 
    -0.00106029f, -0.04717492f, 0.07727727f, -0.08741783f, 0.12664197f, 0.01469231f, 0.07959045f, -0.08666799f, 
    -0.06970529f, -0.18059705f, -0.03815164f, 0.08158465f, 0.03884390f, 0.04548183f, -0.10031440f, 0.04069784f, 
    -0.17753428f, -0.05271930f, 0.07428013f, 0.01348809f, -0.04385406f, 0.07064057f, 0.06743143f, 0.05005025f, 
    -0.02073112f, 0.04372422f, 0.08033259f, 0.04301943f, 0.07285012f, 0.00771844f, -0.01131923f, -0.00662425f, 
    0.08965877f, 0.21223778f, 0.05646880f, 0.17268872f, 0.10705339f, 0.00761911f, 0.00055704f, 0.05896226f, 
    0.03897524f, 0.05189454f, -0.06269863f, 0.00874845f, -0.10719868f, 0.08485305f, -0.07994282f, 0.03140186f, 
    -0.01756818f, 0.09315762f, -0.03208530f, -0.09980441f, -0.32494748f, -0.04831939f, -0.23317778f, -0.28022927f, 
    0.28725442f, 0.10584765f, 0.08738517f, -0.00767154f, 0.02188068f, 0.03785036f, 0.05369953f, -0.00880704f, 
    -0.03739936f, -0.01468431f, 0.13709475f, 0.02880126f, -0.03674591f, 0.01078318f, 0.06217504f, -0.09478386f, 
    0.06764979f, -0.03916254f, -0.01543006f, -0.12038841f, -0.00622456f, 0.00405744f, -0.04951384f, 0.08786848f, 
    0.02334381f, -0.02437524f, -0.05721663f, 0.06882203f, 0.03892593f, 0.07679887f, 0.02664151f, -0.02947582f, 
    -0.03614970f, -0.13253254f, -0.00967120f, -0.08251137f, -0.05985764f, -0.07269856f, -0.02397009f, 0.04961013f, 
    0.03795054f, -0.12871082f, -0.00918138f, 0.03131269f, 0.08053168f, -0.01802477f, -0.01291682f, -0.10510626f, 
    -0.01146768f, -0.05777112f, -0.13242187f, 0.06429756f, -0.04965145f, 0.02356566f, -0.05354844f, 0.10161369f, 
    0.02358620f, -0.11738993f, 0.04246125f, -0.11641414f, 0.01810199f, -0.00511576f, 0.01027590f, 0.01945016f, 
    0.07100523f, -0.03692268f, -0.05982409f, -0.03012550f, 0.04812644f, 0.07300629f, -0.05385941f, 0.02881238f, 
    -0.01880544f, -0.01124487f, -0.02196947f, -0.08460774f, -0.35681114f, 0.00966078f, 0.07515267f, -0.03920997f, 
    -0.28165588f, 0.01115413f, 0.02777734f, -0.05789171f, -0.05656831f, -0.02371387f, -0.00616885f, -0.03315123f, 
    -0.04673191f, 0.00304374f, -0.12492813f, -0.00767261f, -0.12130882f, -0.05472637f, -0.06019336f, -0.14829190f, 
    0.14388332f, 0.00918423f, 0.11113299f, -0.01864175f, 0.08398914f, -0.02990929f, -0.00599918f, 0.04030061f, 
    0.02174750f, 0.07122411f, 0.13224258f, 0.03010729f, 0.05194736f, -0.02207543f, -0.08487514f, 0.02241293f, 
    0.00011406f, 0.02850126f, 0.06077060f, -0.03617861f, 0.18349472f, 0.11663322f, 0.03997169f, 0.10261889f, 
    0.18559240f, -0.01721861f, -0.06446638f, 0.06619602f, -0.03000734f, -0.01267893f, 0.07528762f, -0.04507879f, 
    0.04323933f, 0.08202910f, -0.07234342f, -0.02857317f, 0.10463789f, 0.02316461f, -0.01570535f, 0.00947944f, 
    0.20011301f, -0.07591499f, -0.17093016f, -0.00512633f, -0.11197165f, 0.02962260f, 0.00644756f, 0.03085047f, 
    -0.04978968f, 0.03904314f, 0.02350388f, 0.06825280f, -0.01742763f, -0.02896493f, 0.02732924f, 0.03401144f, 
    0.03589544f, -0.00717007f, -0.00507201f, 0.07263077f, 0.14874111f, -0.12002225f, -0.03461775f, 0.03228725f, 
    -0.09787995f, 0.00052337f, -0.02014736f, 0.02458842f, 0.07787471f, 0.07814465f, -0.02448061f, -0.04564442f, 
    -0.03880860f, 0.00923115f, -0.01643312f, 0.02023382f, 0.01657765f, 0.01685702f, -0.09069585f, -0.09857057f, 
    -0.06793588f, 0.26321259f, 0.06159373f, -0.07779609f, 0.13114409f, -0.10850608f, 0.03384028f, -0.04502335f, 
    -0.05472703f, 0.09615550f, -0.07388699f, -0.04345128f, 0.03597499f, -0.00055220f, -0.00646820f, -0.00349989f, 
    -0.08865096f, 0.03313871f, 0.03444608f, -0.01699647f, 0.15444760f, 0.05010863f, 0.03801622f, -0.07222122f, 
    -0.11757947f, -0.00929182f, -0.06654275f, -0.01659674f, -0.03052085f, -0.03791984f, 0.09080277f, 0.02780281f, 
    0.05793557f, 0.04927354f, -0.06385788f, -0.10836452f, 0.05262722f, -0.06438308f, -0.14348269f, -0.05115142f, 
    0.27581164f, -0.05530185f, 0.00034745f, 0.04339902f, -0.05373148f, 0.02952827f, 0.04344274f, 0.02096953f, 
    0.08009293f, 0.05464018f, 0.01727293f, -0.05403012f, 0.06912261f, -0.04385818f, 0.03739179f, 0.08318886f, 
    -0.02835124f, 0.01439333f, -0.04870227f, 0.05209348f, -0.03595332f, 0.03125179f, 0.11512367f, 0.04960907f, 
    0.17914057f, -0.10636576f, -0.02825707f, 0.00735479f, -0.01622769f, -0.03631833f, 0.01227784f, 0.02716472f, 
    0.09591619f, 0.05674315f, -0.00343545f, 0.01787562f, 0.01232492f, -0.13177112f, -0.02331698f, -0.00524255f, 
    0.01383601f, -0.19629140f, 0.04415398f, -0.13960651f, 0.00296997f, -0.02349311f, -0.01082015f, 0.01231780f, 
    -0.04782787f, -0.06392282f, -0.02647743f, -0.02095977f, 0.03875811f, -0.02429683f, -0.04634563f, -0.04534310f, 
    0.03111411f, -0.14727475f, 0.06769750f, -0.11214960f, -0.12973021f, -0.03325657f, -0.02241006f, -0.20263635f, 
    -0.02128047f, -0.04301666f, 0.02306605f, 0.00868173f, 0.09243231f, -0.04339731f, -0.06804770f, 0.00253453f, 
    -0.03352902f, -0.00704181f, -0.04316531f, 0.01154823f, -0.12354128f, 0.03131879f, 0.08485866f, -0.15165138f, 
    0.10037134f, -0.04188483f, 0.01030492f, 0.07752131f, 0.17826198f, 0.02608436f, -0.13622314f, 0.05772949f, 
    -0.00936857f, -0.03637577f, -0.03256889f, -0.04260376f, 0.03646324f, 0.04732623f, 0.04373928f, 0.01999412f, 
    -0.03057555f, -0.08376187f, 0.01103637f, -0.09002554f, -0.09883668f, -0.04994632f, -0.01852166f, -0.01386316f, 
    -0.06988311f, 0.09881255f, -0.02733204f, -0.02211176f, 0.03790741f, -0.02491943f, -0.06335355f, 0.00678102f, 
    0.01227558f, -0.02093634f, 0.03117816f, 0.07057623f, 0.01649248f, -0.04352589f, 0.02172985f, 0.01956812f, 
    -0.08708119f, -0.06009218f, -0.04203337f, -0.09975643f, -0.04126659f, -0.03911073f, -0.00743972f, 0.05048547f, 
    0.00467947f, 0.08884339f, -0.12915732f, -0.05216118f, 0.00882923f, 0.05149810f, 0.10140672f, -0.09260013f, 
    0.01431492f, -0.01437743f, -0.16061170f, 0.07120795f, -0.22184713f, -0.20860241f, -0.08836794f, 0.05632741f, 
    -0.03132172f, 0.01534554f, -0.04154229f, -0.00202096f, 0.06099159f, -0.03860407f, 0.06735757f, 0.00474241f, 
    0.09364337f, -0.04099791f, -0.02136756f, -0.03210480f, -0.02007402f, -0.05358492f, -0.01238205f, -0.06059831f, 
    -0.29047799f, -0.01146893f, -0.04571934f, -0.02787570f, 0.08646586f, -0.02424844f, -0.03277406f, -0.18502198f, 
    -0.09617278f, 0.01333849f, 0.12012925f, 0.20995121f, -0.06166375f, -0.03510784f, 0.01947265f, -0.07861153f, 
    0.04092045f, 0.06704856f, -0.00084941f, 0.03404899f, 0.19499259f, 0.18854252f, 0.06206899f, 0.05461951f, 
    0.09415958f, 0.04220656f, -0.04632345f, -0.00709834f, 0.00171245f, 0.01626618f, -0.01118566f, 0.02381239f, 
    -0.04556531f, -0.00939608f, -0.08662277f, -0.01214652f, 0.08099180f, 0.06131945f, 0.08134330f, 0.01912501f, 
    0.30860642f, -0.25813243f, -0.06900945f, -0.05963142f, -0.15656340f, 0.06368907f, 0.06040626f, -0.01881316f, 
    0.01629912f, -0.00650909f, 0.06580204f, -0.03920597f, -0.00864659f, -0.00378443f, -0.10982996f, 0.09653506f, 
    0.00685740f, -0.03653254f, -0.00554341f, 0.07128536f, 0.04803129f, 0.00320731f, 0.01517625f, -0.02223577f, 
    0.02318860f, 0.00686161f, 0.01059571f, -0.01084534f, 0.03489272f, -0.03656852f, 0.05811185f, -0.05432823f, 
    0.04252575f, -0.05845399f, 0.07519255f, -0.05461935f, 0.01501830f, 0.00164982f, -0.04102414f, 0.12480190f, 
    0.25465041f, 0.11625160f, 0.05827585f, -0.15289818f, -0.09173042f, 0.00595741f, -0.06447152f, -0.06818266f, 
    0.06211635f, -0.04119175f, -0.04627758f, -0.01896712f, -0.04421390f, 0.11521322f, -0.04115783f, -0.00609659f, 
    -0.00649226f, 0.09617783f, 0.02114398f, 0.01097498f, 0.19712391f, -0.19382267f, 0.02867578f, -0.24460889f, 
    0.01705538f, 0.05382777f, 0.02015737f, -0.05154355f, 0.04270810f, -0.01321429f, -0.04276926f, -0.05599813f, 
    -0.00718483f, 0.00385722f, -0.10079571f, -0.02337264f, 0.08819326f, -0.06960693f, 0.01776169f, 0.08887142f, 
    -0.21944587f, 0.12958574f, 0.17059658f, -0.00608550f, 0.15699545f, 0.05555924f, -0.09530974f, -0.00375237f, 
    -0.05729355f, -0.03365289f, -0.00191866f, 0.01197742f, -0.00723217f, -0.01220877f, 0.00534456f, 0.03380264f, 
    0.06101203f, -0.07015061f, 0.02473768f, 0.04130484f, 0.01992261f, 0.19602752f, 0.09435849f, -0.00673999f, 
    0.08363975f, -0.13115421f, 0.00526427f, 0.03010754f, -0.03571917f, 0.03646993f, -0.02591200f, 0.00410395f, 
    0.03530999f, 0.01250929f, 0.00352014f, 0.05717232f, 0.05049055f, 0.01214830f, -0.03777062f, 0.02310355f, 
    -0.20040268f, -0.07706574f, -0.18198521f, -0.06219001f, -0.18159284f, 0.06872311f, 0.02471710f, 0.00373310f, 
    -0.02915988f, 0.06392130f, -0.02088820f, -0.07636961f, 0.02847869f, -0.04383856f, -0.05393349f, -0.09396377f, 
    -0.01980895f, 0.04616297f, -0.15209624f, 0.09272707f, -0.13300706f, -0.04082270f, -0.03159983f, -0.00870139f, 
    -0.06075609f, 0.10263177f, -0.03112409f, 0.00741706f, 0.09870987f, 0.00111320f, -0.03223105f, -0.00904972f, 
    -0.00342682f, 0.07676724f, -0.00424209f, 0.01542738f, 0.00405907f, -0.04678214f, -0.06259570f, 0.03792123f, 
    0.26503214f, -0.31316593f, -0.02696138f, -0.03574442f, -0.04482373f, -0.08610398f, -0.03711648f, -0.07518996f, 
    0.04568009f, -0.00001481f, 0.09588400f, 0.05862175f, -0.06860808f, 0.01848488f, -0.02595184f, 0.03542547f, 
    -0.02399347f, 0.02743144f, -0.03389381f, 0.06042782f, -0.13967693f, 0.08528393f, 0.06596787f, 0.01148549f, 
    -0.02282478f, 0.05666121f, -0.06217567f, -0.01306219f, 0.04340436f, 0.06944891f, 0.10574638f, 0.01663262f, 
    -0.02765772f, 0.04405388f, -0.12544110f, -0.08799158f, 0.15739006f, -0.04187449f, 0.03364746f, 0.08323099f, 
    0.06902777f, -0.25121951f, 0.07335432f, -0.15832514f, -0.00981132f, -0.04094522f, -0.02256772f, 0.01668052f, 
    0.00777858f, -0.01790808f, -0.01880372f, -0.02911600f, -0.02274759f, -0.00416258f, -0.02609846f, -0.01128469f, 
    0.05131180f, -0.12519841f, -0.00314720f, -0.02555900f, 0.02282212f, 0.21422733f, 0.10202648f, -0.02146287f, 
    -0.02350463f, -0.10042915f, 0.01199637f, 0.08292236f, 0.00651829f, 0.12288503f, 0.06247642f, -0.06668951f, 
    0.09463423f, 0.01339702f, -0.00199324f, 0.04807238f, -0.11725398f, -0.01070864f, -0.01778611f, 0.09923813f, 
    -0.09081832f, -0.06260023f, -0.04129015f, -0.03408232f, 0.13627012f, 0.12186207f, -0.00889266f, -0.01069717f, 
    0.03449858f, -0.05707270f, 0.12609147f, -0.01213436f, -0.03910608f, -0.04987341f, -0.05437086f, -0.00398985f, 
    -0.19091208f, 0.01902075f, -0.04030998f, -0.08044610f, -0.36999378f, 0.10957691f, 0.06487548f, -0.05831461f, 
    -0.12831819f, -0.04037371f, -0.04454408f, 0.04200222f, 0.09684730f, -0.00841903f, 0.08885904f, 0.05365527f, 
    0.13186875f, 0.02594954f, 0.03862480f, -0.06118831f, -0.05453057f, -0.12928908f, -0.05415268f, 0.12841217f, 
    -0.22252116f, -0.11150023f, -0.23330781f, -0.18199632f, 0.16133070f, 0.11338636f, -0.00747563f, 0.01295310f, 
    -0.04002443f, -0.00957367f, 0.02221045f, 0.06367405f, -0.02048138f, -0.06393663f, 0.00104712f, 0.01595149f, 
    0.01035334f, -0.07976481f, -0.01126365f, -0.00062081f, -0.17969111f, -0.18779303f, -0.12441903f, -0.01860472f, 
    0.00215209f, 0.00094953f, -0.00103746f, 0.07916695f, -0.11547375f, -0.06459964f, 0.04754383f, -0.03095131f, 
    0.03198401f, -0.00168845f, 0.05693515f, 0.04323616f, 0.05967835f, -0.02789830f, 0.02630994f, -0.03483344f, 
    0.14823152f, -0.04419046f, 0.13056506f, 0.03915326f, 0.06966978f, -0.01065447f, -0.06193656f, 0.07217990f, 
    0.00348728f, -0.01961147f, 0.04267525f, 0.00691117f, -0.05777745f, 0.08879340f, -0.07600149f, -0.05983609f, 
    0.07538217f, 0.00426931f, 0.04094920f, 0.11557427f, 0.03886332f, 0.06808339f, -0.12870637f, 0.02642632f, 
    -0.17294252f, 0.01774873f, -0.00977661f, -0.05109477f, -0.02244195f, 0.03753714f, 0.01879945f, 0.06468821f, 
    -0.03723176f, -0.03604124f, 0.01846490f, 0.07277580f, -0.00646314f, -0.00349773f, -0.01829488f, -0.03293041f, 
    -0.20603259f, -0.04376503f, -0.07940090f, -0.07400436f, -0.21036848f, -0.06643373f, 0.07973999f, 0.00493487f, 
    -0.06097484f, -0.02050167f, -0.05067329f, -0.04567569f, 0.02767861f, -0.04675372f, -0.06805617f, -0.00391949f, 
    -0.04722372f, -0.02925725f, -0.09368800f, -0.05599561f, 0.23151803f, -0.04324314f, -0.08436730f, 0.03585233f, 
    -0.15220356f, -0.09189793f, -0.02649386f, -0.03589488f, 0.01330648f, 0.06662213f, 0.04534484f, -0.01824865f, 
    0.00983776f, -0.01167241f, 0.07237174f, 0.06985667f, -0.01328141f, -0.00935409f, -0.08508840f, 0.02821101f, 
    0.34680331f, -0.24467990f, 0.09991117f, -0.12112995f, 0.05617183f, -0.05595892f, -0.09424519f, -0.01627081f, 
    0.05934951f, -0.08045534f, -0.01196292f, 0.02928033f, -0.05591149f, -0.03647633f, 0.07651211f, -0.11988322f, 
    -0.02935656f, 0.03554998f, -0.00929102f, 0.04085058f, 0.17365378f, -0.09485879f, -0.08795340f, 0.02921897f, 
    -0.13375595f, 0.01356468f, 0.02700110f, -0.03094985f, -0.03515705f, 0.09325177f, 0.07891757f, 0.03847574f, 
    -0.02043322f, 0.05287280f, -0.07571334f, 0.04692145f, 0.09709943f, -0.01901869f, -0.02714339f, 0.01534636f, 
    -0.14221418f, 0.09373779f, -0.01839656f, 0.03666195f, -0.27692774f, -0.02923409f, 0.01542729f, -0.00441636f, 
    0.06102133f, 0.13773826f, -0.04303292f, -0.04763328f, -0.00865675f, 0.01512679f, 0.04452861f, 0.03214571f, 
    0.09604193f, 0.04848956f, 0.01745510f, -0.02357195f, 0.05481415f, 0.02280962f, 0.06208459f, -0.03313098f, 
    0.25609067f, -0.05532861f, 0.07135861f, 0.00381375f, -0.02654566f, 0.01706613f, -0.03195399f, -0.00711553f, 
    0.05691027f, -0.12586488f, 0.02120011f, -0.00086590f, -0.04154429f, -0.01323857f, 0.02473196f, 0.08891932f, 
    -0.11441004f, -0.01732237f, -0.00775288f, -0.37937534f, 0.08565667f, -0.05706959f, -0.03268102f, -0.14604506f, 
    0.01863296f, -0.01649838f, 0.20122516f, -0.01395941f, -0.02473029f, 0.00640038f, -0.00373833f, -0.06917010f, 
    0.05742893f, 0.07124361f, 0.05550090f, -0.06327949f, 0.35584173f, -0.31136146f, -0.00409142f, 0.01400256f, 
    -0.09340428f, 0.02156974f, -0.04226371f, -0.03789730f, 0.10590108f, 0.10017797f, -0.03825851f, -0.01443975f, 
    0.02790092f, -0.08398262f, 0.10229744f, 0.08633851f, -0.10278630f, 0.04922304f, -0.09249974f, -0.05313236f, 
    0.08274741f, 0.04528043f, 0.04693713f, 0.00499996f, 0.13231696f, -0.12683578f, -0.06701886f, -0.10046987f, 
    -0.00598128f, 0.01731257f, 0.02530958f, 0.00291245f, -0.00498797f, -0.07660060f, 0.05946969f, 0.02878547f, 
    -0.04819380f, -0.02172147f, 0.01185245f, 0.05621155f, 0.11894722f, -0.25837862f, -0.11180688f, -0.10323028f, 
    -0.30683044f, -0.10925259f, -0.03721678f, -0.07257840f, 0.01800694f, -0.07815854f, 0.01716836f, 0.01203869f, 
    0.02542812f, 0.00718397f, -0.00970985f, -0.05784562f, -0.03483336f, 0.08664715f, 0.06292690f, 0.00362392f, 
    -0.06077526f, -0.04727108f, -0.00901984f, 0.06753734f, -0.02605126f, 0.03059369f, -0.09555618f, 0.00141893f, 
    0.05893786f, 0.04075332f, 0.00335562f, -0.02705472f, -0.01184369f, 0.04901401f, -0.01401138f, -0.02305413f, 
    0.01115631f, -0.00902345f, -0.06123950f, -0.05245324f, 0.04926237f, -0.02413200f, -0.00055255f, -0.05636483f, 
    0.04697850f, 0.03572449f, 0.01678930f, -0.05787242f, 0.00384986f, 0.07078750f, -0.04384628f, -0.01933813f, 
    -0.01784300f, 0.01982127f, -0.04202885f, -0.05247726f, 0.01084564f, -0.06876144f, -0.10198897f, 0.01160607f, 
    0.15876760f, -0.19325055f, 0.14524683f, -0.11181869f, 0.03535093f, 0.06829552f, -0.18586101f, -0.01118635f, 
    0.03144914f, 0.12750337f, -0.03683867f, -0.05515692f, 0.05916765f, 0.02559046f, -0.09946176f, -0.00151803f, 
    -0.16099162f, 0.01993761f, -0.03455366f, -0.07895129f, 0.37097725f, -0.23143473f, -0.04137779f, -0.10477670f, 
    -0.02053457f, -0.00996165f, -0.01879811f, 0.01661337f, -0.00511934f, 0.06086323f, 0.07390281f, -0.06671108f, 
    -0.05168547f, 0.01751475f, 0.08132520f, 0.01454134f, -0.02383770f, 0.01994045f, 0.06840640f, -0.07042109f, 
    0.10307938f, -0.19620012f, 0.08064368f, -0.10086021f, -0.00474436f, -0.03176175f, -0.04265476f, -0.12731868f, 
    0.01729626f, -0.00321150f, -0.00105065f, 0.02244764f, -0.02143291f, -0.00851368f, -0.00396107f, -0.05757178f, 
    -0.01829313f, 0.05237597f, 0.04067751f, -0.03565915f, 0.20387010f, -0.09633039f, 0.02064917f, -0.06689597f, 
    0.02696527f, -0.03706119f, -0.03695858f, -0.11104137f, -0.03780537f, -0.01415143f, 0.00342809f, -0.01339816f, 
    -0.00563544f, -0.02103017f, -0.03054155f, -0.02482439f, -0.00319393f, -0.00844315f, 0.02543385f, 0.01742684f, 
    -0.01038206f, 0.14301580f, -0.10834151f, -0.07648929f, 0.04815659f, 0.00949213f, 0.08290106f, 0.01169686f, 
    0.00674759f, -0.10349283f, -0.04097012f, 0.01258833f, -0.01856649f, -0.02725312f, 0.00650597f, 0.02803611f, 
    0.08650072f, -0.03723045f, -0.00783582f, 0.00438389f, 0.02651552f, 0.07225917f, 0.01042571f, -0.15417641f, 
    0.02122305f, 0.01164986f, 0.00598744f, 0.02513734f, 0.01587604f, -0.02504727f, -0.06732051f, -0.00207568f, 
    0.00424248f, -0.05132851f, 0.01399354f, -0.05035795f, -0.01321996f, -0.01283967f, -0.04462064f, -0.04549040f, 
    -0.11758033f, 0.06962103f, -0.00305776f, -0.03250464f, -0.04652210f, -0.04450210f, 0.11569788f, -0.02218682f, 
    -0.01463427f, -0.09745549f, 0.04664730f, -0.05160928f, 0.03447591f, -0.04324640f, -0.05327318f, 0.04061162f, 
    0.02829388f, -0.01914102f, 0.08699185f, -0.00947510f, 0.30049181f, -0.38581195f, -0.00525345f, -0.22337160f, 
    -0.18152007f, 0.07976507f, -0.06198277f, 0.14715590f, -0.07453436f, 0.01216655f, -0.05641519f, 0.03871975f, 
    0.06312551f, -0.04571130f, -0.04941951f, 0.07431487f, -0.02434930f, 0.13049634f, -0.04000780f, -0.01851774f, 
    0.27258649f, 0.02413086f, -0.11385331f, -0.00760602f, -0.05099073f, -0.12343895f, 0.01625103f, 0.06800820f, 
    -0.00119915f, -0.00827854f, 0.02284339f, 0.00547260f, -0.05750787f, -0.00843634f, -0.04885734f, -0.00344680f, 
    -0.02419131f, -0.06580577f, 0.02991406f, -0.07376052f, -0.24261728f, -0.13330786f, -0.03313540f, 0.01747144f, 
    0.04817980f, -0.05477910f, 0.05034408f, -0.08946792f, -0.03458690f, -0.02550179f, 0.02849036f, -0.07630949f, 
    0.02124797f, -0.02739935f, 0.06066070f, -0.02648173f, 0.00406574f, -0.09686824f, -0.00338891f, -0.00185727f, 
    -0.29122159f, 0.02781749f, 0.02420962f, -0.19058178f, 0.10463125f, 0.07903276f, 0.11895739f, 0.03221183f, 
    0.05115409f, -0.02491682f, 0.04239922f, -0.01108487f, -0.00834807f, -0.12963438f, -0.03352694f, 0.03389112f, 
    0.02734875f, -0.00465439f, 0.02278022f, -0.02577375f, 0.06730690f, 0.02916123f, 0.08820646f, -0.00119487f, 
    0.09784988f, -0.13221645f, -0.03891867f, -0.03247009f, 0.00865632f, 0.03406577f, -0.02900440f, -0.05044226f, 
    -0.01160075f, -0.07873970f, 0.01951217f, -0.01886335f, -0.01214661f, -0.03874098f, 0.02277933f, 0.02183560f, 
    0.00846100f, -0.00467488f, -0.07529783f, -0.15793355f, 0.04826828f, 0.02245137f, -0.05816628f, 0.08577975f, 
    0.06594786f, -0.02412067f, -0.08376283f, 0.01938259f, 0.04536664f, 0.00056173f, 0.00171106f, -0.10828612f, 
    -0.02042522f, -0.00359833f, -0.05055629f, -0.04931543f, 0.13311324f, 0.11454637f, -0.27061594f, -0.14019941f, 
    -0.04659803f, -0.00806746f, 0.04929660f, 0.08511157f, -0.08849252f, -0.00909143f, -0.07766422f, 0.03958910f, 
    -0.03558987f, 0.01642256f, -0.05592788f, 0.00660678f, 0.01234332f, 0.06217708f, 0.04615413f, 0.04596198f, 
    -0.18726574f, -0.12157837f, -0.01803176f, -0.18372837f, -0.23313747f, 0.05764399f, 0.00223398f, -0.02706138f, 
    -0.02633829f, 0.01282310f, -0.00669774f, -0.01268115f, 0.00688164f, -0.08441023f, -0.00619348f, -0.00438570f, 
    -0.02375528f, 0.09448393f, -0.00557404f, 0.00644208f, 0.26432225f, 0.09474531f, 0.15790427f, -0.03687647f, 
    0.00388394f, -0.00056687f, 0.00863798f, -0.03836825f, -0.04944298f, 0.01737521f, 0.00064126f, -0.06792583f, 
    0.02985198f, -0.01516083f, -0.06111205f, 0.05939199f, -0.03257808f, -0.03845921f, -0.00622266f, -0.01687080f, 
    0.13312227f, -0.17423090f, -0.01182987f, -0.00520962f, -0.21026258f, 0.01193966f, 0.01529375f, -0.00907714f, 
    -0.00519286f, 0.01442650f, -0.00563552f, 0.04715472f, -0.00926462f, -0.01533659f, -0.01412030f, 0.01658177f, 
    -0.01044618f, 0.05257095f, 0.00679878f, -0.02260346f, 0.17535174f, -0.08385233f, -0.16179031f, -0.05842322f, 
    -0.08240663f, -0.14745505f, 0.01646175f, 0.01090976f, -0.00409199f, -0.08810746f, -0.01422738f, 0.01524639f, 
    -0.02918346f, 0.03265909f, -0.02644701f, 0.02173328f, 0.03731228f, 0.05157383f, 0.06786361f, -0.00238298f, 
    -0.24234954f, 0.12665692f, -0.03505456f, -0.06885891f, -0.04813194f, 0.06537500f, -0.02852076f, 0.04323439f, 
    0.05980580f, 0.05141151f, 0.00583897f, -0.03997586f, 0.01722175f, -0.00182280f, 0.05502274f, -0.02873892f, 
    0.02878807f, -0.01286671f, 0.04867522f, 0.01513120f, 0.08389855f, 0.10290387f, 0.00506575f, -0.10754874f, 
    0.05815783f, 0.03599092f, 0.04142054f, 0.02155017f, -0.00646691f, -0.03231662f, -0.06182155f, -0.01037685f, 
    -0.00883964f, -0.09212852f, 0.00239386f, -0.00891141f, -0.03772188f, -0.04458328f, -0.03037942f, -0.00811953f, 
    0.12701432f, -0.07867611f, 0.09075448f, 0.03493590f, 0.14836982f, -0.08697104f, -0.06924306f, -0.01054650f, 
    -0.01760737f, 0.02341018f, 0.06233265f, -0.00203734f, -0.00149709f, 0.02885250f, -0.01051148f, -0.02292050f, 
    -0.03027678f, -0.03479881f, -0.00475430f, 0.00480206f, 0.32119432f, -0.18134589f, -0.12838399f, 0.06231339f, 
    0.03752264f, -0.15537031f, 0.02163801f, -0.09587065f, -0.00241191f, -0.02043830f, 0.03168225f, 0.02472198f, 
    0.06040105f, 0.06103952f, -0.03192100f, -0.05555666f, -0.00875272f, 0.07185145f, 0.01003893f, -0.00111965f, 
    0.14109688f, -0.02361284f, 0.09734774f, -0.09602500f, -0.06898481f, 0.00053375f, 0.01879061f, 0.04411291f, 
    0.00291207f, 0.02457304f, -0.02619037f, 0.04642596f, 0.03802760f, 0.01394793f, 0.09335683f, -0.09470241f, 
    -0.09861171f, -0.06286578f, -0.08094036f, 0.00259601f, -0.21700820f, -0.12599976f, -0.01966333f, -0.05385616f, 
    -0.08447189f, -0.06091951f, -0.06666171f, -0.08743783f, -0.01159327f, 0.01770967f, -0.01425245f, -0.00752514f, 
    -0.00420774f, 0.05235809f, 0.08272199f, 0.02165946f, -0.02477935f, 0.01684470f, 0.04406932f, -0.01518138f, 
    0.28520107f, -0.09047237f, 0.07457884f, 0.12572369f, -0.14661343f, -0.09810819f, -0.01655673f, 0.02015723f, 
    -0.07382996f, 0.02842779f, 0.00681395f, -0.02278752f, 0.03384024f, -0.03946687f, 0.01778299f, 0.00884707f, 
    -0.05138036f, 0.05509068f, 0.02437128f, 0.03897007f, 0.00524181f, 0.01303948f, 0.09752180f, -0.12959644f, 
    0.06643353f, 0.06528750f, 0.05281799f, 0.07019624f, -0.02265629f, -0.02587415f, -0.00963658f, 0.07606363f, 
    -0.07303639f, -0.06885339f, -0.00145049f, 0.00103725f, -0.02175490f, -0.00878160f, -0.14205401f, 0.03360695f, 
    -0.20842117f, -0.16971880f, 0.07433649f, -0.16086459f, -0.11251067f, 0.01867722f, -0.06493948f, -0.04256409f, 
    -0.03504701f, 0.04720099f, -0.08179852f, 0.04331555f, -0.02306291f, -0.01539658f, -0.03810955f, 0.01804470f, 
    -0.05269102f, 0.01153443f, -0.08818517f, 0.00650140f, 0.03942296f, -0.00147788f, -0.11016811f, -0.00389837f, 
    -0.13218844f, 0.04713983f, 0.01729214f, 0.04633971f, 0.04522222f, 0.06989898f, 0.02307343f, -0.03107419f, 
    -0.01006473f, -0.01708146f, -0.08991233f, -0.03900298f, -0.05664806f, 0.04515710f, 0.02949206f, -0.09771235f, 
    -0.15879682f, 0.07169421f, 0.00556318f, -0.14237471f, 0.00515139f, 0.04104042f, 0.03285545f, 0.08579751f, 
    -0.04234453f, -0.04578765f, -0.04189580f, 0.04114084f, 0.03424909f, -0.09248414f, -0.02667662f, 0.00416590f, 
    -0.02434846f, 0.05423080f, -0.04272715f, -0.02872578f, 0.11480370f, 0.04932959f, 0.11837433f, 0.04901040f, 
    0.10130336f, -0.01766012f, -0.06272277f, -0.03813102f, 0.02690714f, 0.05862011f, -0.03065589f, -0.01005992f, 
    0.00316847f, -0.01002548f, -0.06148399f, -0.04409447f, -0.12103331f, -0.00139909f, 0.00649517f, -0.02463433f, 
    0.07729659f, 0.17733307f, -0.06413055f, -0.13581890f, -0.13614126f, 0.08664255f, 0.09004438f, -0.03876156f, 
    -0.04608652f, 0.03685128f, 0.05700389f, -0.01459224f, 0.02019191f, -0.09695094f, -0.02008850f, -0.05248852f, 
    0.09532638f, -0.00851603f, -0.07173192f, -0.10306925f, 0.16464937f, 0.16421747f, -0.05019342f, -0.03611787f, 
    -0.09540597f, -0.04658657f, 0.10957477f, -0.03510915f, 0.01672336f, 0.00443923f, 0.01608317f, -0.08915970f, 
    -0.01438668f, -0.01217381f, -0.05970756f, 0.02701560f, 0.11295609f, -0.00292242f, 0.06665780f, -0.02528475f, 
    0.17824343f, 0.04074378f, 0.03185419f, -0.04868542f, 0.01029816f, -0.02705932f, -0.07313375f, 0.01557665f, 
    0.06830085f, 0.12783368f, -0.11122393f, -0.06858354f, 0.10024720f, 0.05096968f, -0.10918909f, -0.02535914f, 
    -0.00204318f, -0.01934997f, -0.01096039f, -0.04575457f, -0.00039910f, -0.03631542f, 0.01151632f, -0.09387646f, 
    0.02034958f, 0.01023545f, -0.02855977f, 0.02039771f, -0.02686495f, 0.04806536f, -0.02625873f, -0.01619414f, 
    0.07371047f, 0.02305277f, -0.02091187f, -0.06399532f, -0.05082706f, -0.05363221f, -0.03805560f, 0.00088967f, 
    0.03853244f, -0.02573179f, 0.15208930f, 0.04295423f, 0.15378815f, -0.07124481f, -0.05322519f, -0.02662654f, 
    0.00141216f, 0.06183301f, 0.01774389f, -0.04991651f, -0.01548629f, 0.02939310f, 0.00553511f, -0.02387398f, 
    -0.01638138f, -0.03088713f, -0.03533146f, -0.00648778f, 0.02403101f, 0.12747891f, 0.00403269f, -0.12022191f, 
    -0.02846258f, -0.05681886f, 0.04685869f, -0.00558632f, -0.03402151f, -0.00717932f, 0.01522802f, 0.00451987f, 
    -0.05076570f, -0.01889036f, -0.02744367f, 0.01041643f, 0.03265895f, 0.00989125f, -0.03328255f, -0.02428411f, 
    0.10774042f, 0.13682275f, -0.07659167f, -0.04805271f, 0.01193535f, -0.00225515f, -0.00233970f, 0.07473037f, 
    -0.01619844f, 0.00065062f, -0.02507662f, -0.00107026f, 0.06686099f, -0.00439119f, 0.00429315f, 0.00084264f, 
    -0.01660991f, -0.04857336f, -0.01264414f, 0.01763394f, -0.28394243f, -0.27393252f, 0.04125550f, -0.10111125f, 
    -0.23683308f, 0.01516735f, -0.07248724f, -0.00466321f, 0.04170420f, 0.05808099f, 0.10351796f, 0.01901540f, 
    0.00961970f, 0.01315438f, -0.03002458f, 0.09779190f, -0.04332997f, -0.04850907f, -0.02087049f, -0.08470702f, 
    0.15567601f, 0.12258711f, 0.04545601f, -0.06698005f, 0.10566697f, 0.04652160f, -0.02243562f, 0.02420874f, 
    0.05045693f, 0.05491254f, -0.05367389f, -0.07387582f, -0.06960403f, 0.05226942f, -0.00814419f, -0.02781443f, 
    -0.00999521f, 0.06529054f, -0.11729747f, -0.01556984f, 0.02077738f, 0.07237588f, -0.04627128f, 0.02195224f, 
    0.03568937f, -0.04023024f, 0.09584191f, 0.07567135f, -0.03853836f, -0.09199972f, -0.02321794f, 0.03128596f, 
    -0.03196751f, -0.00016427f, -0.02626066f, -0.03496687f, -0.06275718f, -0.03474199f, -0.05701661f, 0.01136757f, 
    0.23934256f, -0.01030148f, -0.14873254f, -0.01377541f, -0.15169181f, -0.03560403f, 0.00489798f, -0.02216271f, 
    -0.00742069f, 0.00438053f, -0.06923283f, -0.03413679f, -0.01253978f, -0.00584116f, -0.03298327f, -0.01221477f, 
    0.05950204f, -0.06719137f, 0.07087753f, -0.02748910f, -0.12205969f, -0.05784542f, 0.00706298f, -0.08319861f, 
    -0.13178803f, 0.04334463f, 0.03390270f, 0.01993133f, 0.00222136f, -0.00712769f, 0.03214673f, 0.00593569f, 
    0.03501706f, -0.06947769f, -0.04526505f, 0.04990583f, 0.02867770f, -0.03305817f, -0.02083037f, -0.06243134f, 
    0.22030899f, 0.01202527f, -0.00924912f, 0.14259662f, -0.06044669f, -0.02620565f, -0.06751467f, 0.02086809f, 
    0.05337247f, 0.08454664f, 0.03327226f, -0.00607792f, 0.02962666f, 0.04980873f, 0.01085211f, 0.00718761f, 
    -0.08087356f, -0.07023126f, 0.02926755f, -0.02228572f, -0.11476018f, 0.12465298f, 0.10610136f, -0.01888675f, 
    0.02153880f, -0.02975569f, -0.04065499f, -0.00418524f, 0.01210678f, 0.05284777f, -0.04577563f, 0.09765835f, 
    -0.03202038f, -0.02987719f, 0.02252193f, 0.05442191f, -0.07289831f, -0.03552472f, 0.03069583f, 0.00300739f, 
    -0.21257986f, -0.24688414f, 0.04785219f, -0.10206813f, -0.10294249f, -0.00792534f, -0.04997355f, 0.01180174f, 
    -0.00184758f, 0.05278646f, 0.02376177f, 0.01767999f, 0.01018168f, -0.03270718f, -0.03036226f, 0.06934755f, 
    -0.01466058f, 0.01417614f, -0.05222410f, -0.03768190f, -0.33540112f, 0.07132687f, -0.04136780f, -0.10713661f, 
    0.05166296f, 0.03575830f, 0.03404798f, -0.10740346f, 0.03488040f, -0.05715793f, -0.02677042f, -0.03279524f, 
    -0.00568409f, -0.05207291f, 0.04653865f, -0.06569744f, 0.03818170f, -0.01800414f, -0.12858342f, 0.01354133f, 
    0.03778978f, 0.15674156f, -0.02908723f, 0.05780121f, -0.02747163f, -0.01334882f, 0.07117367f, 0.04384574f, 
    0.03508670f, -0.06242773f, -0.01328427f, 0.05932048f, 0.00948618f, 0.04141317f, -0.00309190f, 0.00262638f, 
    0.02242267f, -0.03680013f, 0.01343692f, -0.04767645f, 0.06555341f, -0.06994170f, -0.07141045f, 0.00317767f, 
    -0.09984133f, -0.00813585f, 0.06901438f, -0.04282653f, -0.00423610f, -0.01557375f, 0.00748729f, -0.02211052f, 
    -0.01818261f, -0.01114540f, -0.00223820f, 0.02006930f, 0.00296697f, 0.05820799f, -0.05294718f, -0.03320516f, 
    -0.06528719f, -0.01122322f, -0.05352663f, -0.05907492f, -0.09450240f, -0.01840149f, -0.04245004f, 0.05629766f, 
    -0.06095852f, -0.04953125f, -0.08423123f, 0.00509142f, -0.02246230f, -0.02443903f, -0.04331047f, 0.01424058f, 
    -0.01944324f, 0.05808756f, -0.02021959f, -0.02702857f, 0.25989497f, -0.15624191f, 0.03779592f, -0.00352931f, 
    -0.15545188f, -0.01502833f, -0.00220328f, -0.05588319f, 0.11400465f, 0.04437016f, 0.01914209f, -0.07983653f, 
    -0.00360678f, -0.01959756f, -0.02639501f, 0.01264995f, -0.02608681f, 0.01922008f, 0.00869104f, 0.00240634f, 
    0.06195736f, 0.02776149f, 0.09402566f, -0.05651734f, 0.00287328f, 0.02952002f, -0.08675922f, 0.07507085f, 
    0.06248500f, 0.04931743f, -0.00159098f, -0.05401276f, 0.08041728f, 0.02413750f, -0.04105635f, 0.03941069f, 
    -0.03726839f, -0.02732830f, -0.02111232f, -0.09598831f, 0.21102935f, -0.01651014f, 0.12306513f, 0.08273464f, 
    0.23248430f, -0.06963274f, -0.09518540f, -0.09276650f, 0.07136239f, 0.09395088f, 0.10046700f, -0.02211281f, 
    -0.04242667f, -0.02643603f, -0.02477273f, -0.03386074f, -0.05207980f, 0.00552422f, 0.02544765f, -0.01328170f, 
    0.21853821f, -0.13502420f, -0.24406368f, -0.00636961f, -0.15443677f, -0.03606363f, 0.00185884f, 0.02493528f, 
    -0.03267961f, -0.03929963f, 0.01206592f, -0.03044398f, -0.00688363f, -0.01470803f, -0.00205511f, 0.03698615f, 
    0.06336937f, 0.03818827f, 0.05405602f, -0.07259644f, 0.26877433f, 0.02187388f, 0.09841573f, 0.14183997f, 
    0.10319306f, -0.08456167f, 0.01240483f, 0.00205843f, 0.05829089f, 0.07287191f, 0.05220416f, 0.00829060f, 
    0.03633562f, -0.01094312f, -0.01462340f, 0.04123563f, -0.08399387f, -0.03574881f, 0.00154737f, 0.05756880f, 
    -0.07006457f, -0.00578711f, -0.14700484f, 0.01756123f, -0.15308192f, 0.01771957f, -0.11254466f, 0.10965290f, 
    0.04898775f, 0.04278619f, 0.02531569f, 0.04605858f, 0.03294994f, -0.01837726f, 0.00524510f, -0.00277282f, 
    -0.02604211f, 0.02470700f, 0.02185827f, -0.02076042f, 0.09551861f, 0.02461202f, 0.11978823f, 0.12997428f, 
    0.14363115f, -0.07549480f, -0.06132573f, -0.04660235f, 0.07732559f, 0.03127518f, 0.02388915f, -0.04854572f, 
    -0.05793852f, -0.01937751f, -0.01735101f, -0.03209699f, -0.01321240f, -0.05417902f, 0.02693470f, 0.02914023f, 
    -0.07701342f, 0.01108228f, 0.02052466f, -0.02189108f, -0.01467216f, -0.12413567f, -0.01971898f, 0.00055065f, 
    -0.06709208f, -0.04535643f, 0.02973657f, -0.04511296f, -0.00567298f, -0.04976577f, 0.05257135f, 0.10546207f, 
    -0.04875334f, -0.01887183f, 0.00102129f, 0.03369419f, 0.14787215f, -0.19342972f, -0.06428079f, 0.01891313f, 
    -0.03243549f, -0.01243920f, 0.03043037f, 0.04635831f, -0.02745350f, 0.02736102f, 0.00784438f, 0.02733616f, 
    -0.02685313f, -0.01046774f, -0.05357916f, -0.01687906f, -0.04734074f, -0.00566580f, -0.06248754f, 0.00830742f, 
    0.00209109f, -0.07697343f, -0.13468497f, 0.08184854f, -0.15052828f, -0.01153968f, 0.01090418f, 0.01881247f, 
    0.01801470f, 0.06873766f, -0.08337577f, -0.05203532f, 0.06243997f, 0.12215777f, 0.02186796f, -0.00436056f, 
    -0.06830019f, -0.02680344f, -0.00323099f, -0.06466100f, 0.17108905f, 0.10433102f, 0.02928681f, -0.13076806f, 
    -0.16517399f, -0.04349593f, 0.01956209f, 0.06701745f, -0.05415018f, 0.04369839f, -0.00815367f, -0.02023204f, 
    -0.01035760f, -0.15988760f, -0.06148467f, -0.00612810f, 0.03194150f, 0.08580712f, -0.00699442f, 0.01275474f, 
    0.18113819f, -0.06442522f, 0.09087592f, -0.08458585f, -0.00636998f, -0.00008480f, -0.05276044f, -0.04475871f, 
    0.00726581f, -0.09195996f, -0.07284099f, -0.02563447f, 0.00097774f, -0.00930143f, -0.03046299f, 0.00482456f, 
    0.02753094f, -0.00739940f, 0.00006359f, -0.01708140f, 0.04855238f, 0.09154512f, 0.04123589f, 0.08651076f, 
    -0.02013393f, -0.08800618f, -0.08085511f, 0.01546154f, -0.04564986f, -0.01220446f, -0.01836039f, -0.02511999f, 
    -0.00229412f, -0.08333433f, 0.00348587f, -0.02797989f, 0.00288030f, 0.16256350f, 0.03347003f, -0.00228080f, 
    -0.10009594f, -0.10705997f, -0.06514659f, 0.01097248f, -0.05441960f, -0.02588211f, 0.01479987f, 0.03592207f, 
    -0.01687752f, 0.07672246f, -0.05179167f, -0.00189195f, 0.06637082f, -0.01029840f, -0.00069557f, 0.03989501f, 
    0.02627246f, -0.02097412f, -0.00830100f, 0.05835029f, -0.04585819f, -0.05629266f, -0.21538530f, 0.14800568f, 
    0.05463406f, -0.02359287f, -0.02402900f, -0.04708254f, 0.06664900f, 0.02100365f, -0.00095250f, -0.01566397f, 
    0.02079902f, 0.02833769f, -0.01433054f, 0.01982925f, 0.10949215f, -0.03191504f, 0.06076300f, -0.01640924f, 
    -0.19206357f, -0.24215357f, -0.13490480f, 0.06478346f, -0.10486513f, -0.04513171f, -0.03848587f, -0.02939919f, 
    -0.04081539f, 0.06022228f, -0.04980811f, -0.08542628f, 0.03810365f, 0.06103866f, -0.01293900f, 0.02574932f, 
    -0.02572143f, -0.00335657f, -0.04714100f, 0.06961928f, -0.10871489f, 0.16911303f, 0.07878760f, 0.14865746f, 
    -0.01705230f, 0.00635718f, -0.07383160f, -0.05147048f, 0.03410578f, -0.08914967f, 0.04312711f, -0.02001326f, 
    0.03492540f, -0.00994507f, -0.03101773f, -0.05184308f, -0.07570032f, 0.05461490f, 0.06619952f, 0.02534317f, 
    0.06979318f, 0.08433983f, -0.10233863f, -0.04147551f, 0.01171774f, -0.05453932f, -0.00462580f, -0.03786111f, 
    0.08250093f, 0.02362284f, -0.06358793f, 0.01876592f, -0.02812002f, -0.01218877f, -0.00360239f, 0.00292137f, 
    -0.07849597f, 0.02424754f, -0.05140786f, 0.02002244f, -0.06789525f, 0.20354959f, 0.00216273f, -0.03264215f, 
    -0.00994147f, -0.02778995f, -0.06392255f, 0.02562677f, 0.04816396f, 0.01279586f, -0.02402638f, 0.02373540f, 
    -0.05336755f, 0.06051901f, 0.00569746f, 0.01016060f, 0.02310906f, -0.01890909f, 0.11155707f, -0.01539684f, 
    -0.22269738f, 0.18105294f, -0.19648895f, 0.15429026f, 0.18429288f, 0.09134964f, 0.03293047f, 0.06383082f, 
    -0.00102299f, 0.06199097f, 0.05676660f, -0.02438990f, -0.01038247f, -0.01382809f, -0.03299573f, 0.00205130f, 
    -0.00816500f, -0.05966228f, 0.03177115f, -0.05620579f, -0.13910386f, -0.13974804f, -0.15536568f, -0.08162195f, 
    0.04023213f, -0.02849427f, 0.01772271f, -0.04483847f, -0.00002559f, 0.06828582f, -0.06331275f, -0.00203971f, 
    -0.00795652f, 0.09328303f, -0.04590393f, 0.01144772f, -0.02559494f, -0.06022200f, -0.01237683f, 0.02929846f, 
    -0.07614374f, 0.13665959f, -0.03972485f, 0.22919105f, 0.09573835f, 0.03949577f, 0.09815511f, 0.05077525f, 
    0.02679765f, 0.02412094f, -0.04346758f, 0.09513964f, 0.01282128f, -0.13894896f, -0.02134958f, -0.04895408f, 
    -0.02191681f, 0.06370669f, 0.07125394f, -0.10326612f, 0.31577909f, 0.09654609f, -0.15481222f, 0.07104742f, 
    0.04935624f, -0.06888849f, -0.00445196f, 0.03554590f, 0.08810714f, 0.08277025f, 0.03981755f, -0.00839904f, 
    -0.05812381f, 0.12775066f, -0.01849808f, -0.07928918f, -0.00010422f, 0.02375489f, -0.00828618f, 0.10537615f, 
    -0.19396877f, 0.32535565f, 0.05877260f, 0.05106449f, -0.01933396f, -0.02473668f, -0.06480887f, -0.01942941f, 
    0.05019560f, -0.15610889f, -0.02793271f, -0.07447148f, -0.05835116f, 0.05823754f, -0.03852974f, -0.00172354f, 
    -0.00523890f, -0.12139769f, 0.10909485f, 0.02801451f, 0.05283017f, -0.03783552f, -0.05833953f, 0.02079719f, 
    -0.06403020f, -0.01453912f, 0.00531195f, 0.00067580f, -0.02313085f, 0.02005704f, 0.03550823f, 0.00588273f, 
    -0.03306546f, -0.04796309f, 0.06001827f, -0.02468033f, -0.00686360f, -0.00210013f, 0.00509339f, -0.01220535f, 
    -0.04463315f, -0.28066304f, -0.23565367f, 0.08421692f, 0.09187760f, -0.01543873f, 0.04289053f, -0.00128323f, 
    0.02428086f, -0.00140354f, -0.02004659f, 0.06075351f, -0.09532557f, -0.03353594f, -0.01789365f, -0.06202375f, 
    0.09973043f, 0.16427709f, 0.00982092f, -0.05325684f, 0.15042333f, -0.12445734f, 0.01904920f, -0.10346086f, 
    -0.08350195f, 0.00085288f, -0.06830602f, -0.03630162f, -0.04603950f, -0.08043437f, -0.01727399f, -0.03855790f, 
    0.01859126f, -0.03143780f, -0.00369287f, 0.01253690f, 0.01708023f, -0.05027798f, 0.02974567f, -0.02007885f, 
    -0.31660086f, -0.43033084f, -0.16039759f, -0.12588322f, 0.01717343f, -0.09977990f, 0.00470583f, -0.04873571f, 
    0.04554628f, -0.08903129f, -0.03872632f, 0.01112362f, 0.02430130f, 0.01635216f, 0.03480140f, 0.01753344f, 
    -0.06826231f, -0.08435591f, 0.00718258f, 0.01676104f, 0.32540593f, 0.32891190f, -0.07683875f, -0.21913470f, 
    -0.06286816f, 0.00260876f, 0.05020984f, -0.01819343f, 0.10294642f, 0.01912773f, -0.00828084f, 0.06330814f, 
    -0.08723238f, 0.02626657f, -0.08747531f, -0.07761195f, -0.03980870f, -0.10750240f, 0.08399535f, 0.07494678f, 
    0.13429166f, 0.16170762f, 0.10271261f, 0.04095207f, 0.01001681f, -0.00386851f, 0.04402031f, -0.01732777f, 
    -0.03442517f, 0.02010651f, 0.00489389f, -0.02665523f, -0.00699575f, -0.08720001f, -0.02221689f, 0.01528978f, 
    -0.01275489f, 0.06750782f, -0.01275379f, 0.06100004f, -0.07941900f, -0.02791795f, 0.08000519f, -0.01364455f, 
    -0.08752158f, 0.00382094f, -0.07380430f, -0.14080213f, -0.06950919f, -0.16993357f, 0.04906039f, 0.04864493f, 
    0.00429755f, 0.10872666f, 0.10170696f, -0.02958923f, 0.09320210f, -0.12823799f, 0.03051954f, -0.02834734f, 
    0.08932059f, 0.08517132f, 0.10907195f, 0.10187594f, 0.03977741f, 0.00389899f, -0.01080520f, 0.01367012f, 
    -0.01536300f, -0.03105758f, -0.02756830f, -0.03036685f, -0.04522822f, -0.03376175f, 0.01935254f, -0.04540806f, 
    -0.02463832f, 0.05642530f, 0.01078792f, 0.03978223f, -0.01984755f, 0.24015428f, 0.08772651f, 0.13746116f, 
    0.03528173f, 0.06850634f, -0.03046386f, 0.01815201f, -0.02902293f, -0.05264596f, -0.05608436f, -0.03664191f, 
    0.03737642f, 0.02988165f, 0.04262867f, 0.00848971f, 0.05319851f, 0.00726404f, 0.06448232f, 0.00233015f, 
    0.03893606f, -0.09175415f, -0.08092024f, 0.00157087f, 0.05125096f, -0.06157414f, 0.10764752f, 0.01856124f, 
    0.05117937f, -0.05541204f, -0.01622751f, 0.07422792f, -0.05746632f, -0.00460406f, -0.04515276f, -0.02546630f, 
    -0.05797624f, -0.02592253f, -0.07197336f, 0.00106660f, -0.32107046f, -0.11439920f, -0.23279071f, -0.02428302f, 
    0.13949643f, -0.08629016f, 0.02843807f, -0.01238594f, 0.04139759f, 0.04106572f, -0.05873502f, 0.01318010f, 
    0.01451171f, -0.03673292f, 0.03319797f, -0.06732696f, 0.02636107f, -0.08729801f, -0.02212100f, 0.04228918f, 
    -0.04434440f, -0.08117498f, -0.01360613f, -0.02783353f, -0.04493437f, -0.06557868f, -0.03975847f, -0.01933469f, 
    0.03106978f, 0.01136696f, 0.03203622f, -0.01972299f, 0.05911718f, -0.01704837f, 0.02865647f, -0.02603110f, 
    -0.02711625f, -0.00984935f, 0.06952641f, 0.04595156f, 0.07864558f, 0.04098182f, -0.00856129f, 0.06137341f, 
    -0.05896266f, -0.05770518f, -0.10312406f, 0.08176763f, -0.05044349f, 0.05127107f, -0.04946357f, 0.03792033f, 
    -0.05296269f, 0.02328216f, 0.07166825f, 0.03381848f, 0.03233067f, 0.09183840f, 0.04639676f, -0.01269401f, 
    0.09534762f, -0.12345044f, 0.01879181f, 0.03464199f, -0.11376073f, -0.02572833f, -0.04375061f, -0.07948117f, 
    0.03728696f, -0.07590995f, -0.06713349f, 0.01382457f, -0.15445192f, 0.05489398f, -0.02053897f, 0.08027472f, 
    0.00739897f, 0.04551968f, -0.07429752f, -0.03222732f, 0.02919884f, -0.01959214f, 0.00436147f, 0.05478395f, 
    0.01080666f, -0.08014376f, -0.06641049f, -0.07983101f, 0.06842218f, 0.07284598f, -0.07337490f, -0.05926484f, 
    -0.00911522f, 0.02694894f, 0.03945449f, -0.04374226f, 0.00822418f, 0.08013310f, 0.02194617f, 0.02957992f, 
    0.07501545f, -0.11424163f, -0.00305837f, -0.02257444f, -0.12732670f, -0.10532003f, -0.10019723f, 0.01714531f, 
    -0.11874525f, -0.03837704f, -0.01173952f, -0.03803647f, -0.04077369f, 0.00483926f, 0.07373380f, -0.01470103f, 
    0.06897633f, -0.00110262f, -0.02765149f, 0.01019761f, 0.03037132f, -0.43392324f, -0.23542994f, 0.15201554f, 
    0.05252666f, 0.03123946f, 0.01854871f, 0.05588293f, 0.05478757f, -0.09894119f, -0.00958049f, -0.04238895f, 
    -0.06934877f, -0.08199403f, -0.03267771f, -0.01986268f, 0.05939195f, 0.07893006f, -0.07371790f, -0.05864869f, 
    0.06016672f, 0.09778188f, 0.03493808f, 0.08945426f, -0.01947115f, 0.00975813f, 0.04542197f, -0.05858457f, 
    0.03586374f, -0.09362390f, -0.03687506f, 0.01912935f, -0.04393977f, -0.02814255f, -0.04387751f, -0.01886892f, 
    -0.01214135f, -0.03884380f, -0.06383208f, -0.03157096f, 0.17744386f, 0.05882980f, 0.15623315f, 0.08603732f, 
    0.12724179f, 0.00681049f, -0.00519682f, 0.00025994f, -0.08431266f, 0.02980831f, 0.01531265f, 0.02135259f, 
    -0.00568084f, 0.02095602f, -0.03819968f, 0.01940071f, -0.01135915f, 0.05074649f, 0.06999055f, 0.03423216f, 
    0.09172956f, -0.29776341f, -0.18334883f, 0.03972125f, 0.07791575f, 0.06184928f, 0.06970988f, -0.00357367f, 
    0.01465263f, -0.00942237f, 0.06719495f, 0.00757878f, -0.06414094f, -0.01648168f, -0.02630966f, -0.00268325f, 
    0.00213905f, 0.05989600f, -0.07473990f, -0.00308850f, -0.11987129f, -0.06326032f, -0.12334975f, -0.08083265f, 
    -0.10858925f, 0.00813223f, -0.06991003f, 0.00645312f, -0.02360509f, -0.05639345f, -0.00282459f, -0.05819873f, 
    -0.00337892f, 0.02651238f, 0.03387062f, -0.01471418f, -0.02577609f, 0.00850754f, -0.04527656f, 0.06439926f, 
    -0.12457817f, 0.20616172f, 0.10441238f, 0.13824396f, 0.06702268f, 0.05397917f, 0.07395107f, 0.07920166f, 
    -0.04397358f, -0.03747543f, 0.05073943f, 0.02630039f, -0.06623257f, 0.00208500f, -0.18126851f, 0.16082284f, 
    -0.06131171f, 0.12208499f, -0.01651327f, 0.08170979f, -0.29140845f, 0.28125805f, -0.02741311f, 0.13283639f, 
    0.08243749f, 0.01242016f, 0.02802723f, 0.00949628f, 0.03431856f, 0.00858768f, -0.02647916f, -0.05400240f, 
    -0.01949661f, -0.09939632f, -0.02319743f, 0.01338354f, 0.01230158f, -0.05676474f, 0.06143398f, -0.02299144f, 
    -0.39709684f, 0.02906610f, -0.03556610f, -0.04098758f, -0.14004384f, -0.12770788f, -0.06693885f, 0.02950186f, 
    0.07762350f, 0.01276341f, -0.10471021f, -0.12452753f, -0.00979090f, 0.01257303f, 0.03117735f, 0.01215866f, 
    0.02547904f, -0.04340038f, 0.05794342f, 0.05303986f, -0.19948801f, -0.20910007f, -0.14032666f, -0.06359584f, 
    -0.06639966f, -0.10436338f, -0.02495421f, -0.05518288f, 0.01578949f, -0.03736634f, -0.07371338f, -0.00371615f, 
    0.07835674f, 0.01798655f, 0.00832816f, 0.05006257f, -0.10565452f, -0.06094144f, -0.02679024f, 0.09279674f, 
    -0.09243203f, -0.07418863f, -0.21288857f, -0.02715138f, -0.12827283f, -0.02060615f, -0.04024172f, 0.02754329f, 
    -0.04970486f, -0.01510031f, -0.02291550f, 0.00008442f, 0.06387687f, 0.03159367f, 0.02463066f, 0.02205582f, 
    -0.00965753f, 0.06082058f, -0.03778279f, 0.06825729f, -0.14553595f, 0.14343721f, 0.00967599f, 0.12624849f, 
    0.01984268f, 0.04443896f, 0.02169224f, -0.01007390f, -0.01720916f, -0.03576849f, 0.06924211f, 0.03507094f, 
    -0.06004427f, 0.01794592f, -0.08539227f, 0.08719903f, -0.10005774f, 0.04655006f, 0.00167416f, -0.00490848f, 
    0.05505642f, -0.34001812f, -0.15554488f, -0.02934667f, 0.08548398f, -0.10833240f, -0.00594258f, -0.00903993f, 
    0.00538102f, -0.02349111f, -0.01408750f, 0.06334866f, -0.02711891f, 0.03239900f, 0.05528023f, 0.00704598f, 
    -0.04483979f, -0.05255387f, 0.00877251f, 0.06337724f, 0.06675141f, 0.10144440f, 0.01200544f, 0.10927717f, 
    -0.06557778f, -0.02918682f, 0.04316940f, -0.02930494f, -0.02762388f, 0.05625102f, -0.02549742f, 0.01291770f, 
    0.01139353f, 0.01017648f, 0.05738052f, 0.07046695f, -0.04858174f, 0.00658044f, -0.02162686f, 0.05713597f, 
    0.18057835f, 0.14453848f, -0.18608834f, 0.01464944f, -0.14020048f, -0.09887444f, -0.05308174f, -0.02798114f, 
    0.06739187f, -0.08119856f, -0.01395392f, -0.18226746f, -0.02973662f, 0.01009434f, -0.07438602f, -0.03163746f, 
    0.00276903f, 0.03257333f, 0.05344278f, 0.06002311f, -0.35626069f, -0.33356738f, -0.01476857f, 0.07303499f, 
    0.04681389f, -0.06147684f, -0.06266305f, 0.01554289f, 0.01651644f, -0.05051599f, -0.05294251f, 0.00114820f, 
    -0.02354823f, -0.10481185f, 0.02264685f, -0.00027888f, -0.02622586f, -0.04346385f, -0.00526730f, -0.04076209f, 
    -0.15982887f, 0.26059476f, 0.08295000f, 0.12192092f, 0.04113799f, 0.06360724f, 0.05048960f, -0.00397065f, 
    -0.00229624f, 0.02722615f, -0.01020931f, -0.03915295f, 0.01423309f, -0.00188970f, -0.11139724f, -0.04926379f, 
    -0.02852445f, -0.01724955f, 0.05017091f, 0.00521134f, 0.06517826f, 0.10484225f, 0.06962594f, 0.15858354f, 
    0.10997741f, 0.04293111f, 0.03754889f, -0.01133853f, -0.02564797f, 0.03740165f, -0.03551446f, -0.03199761f, 
    -0.00259063f, -0.08039861f, -0.00086381f, -0.00408723f, 0.00299895f, 0.06928615f, 0.01719505f, -0.03945170f, 
    0.01454886f, -0.12296283f, -0.00243183f, -0.00763682f, -0.09615945f, -0.05812873f, -0.05725711f, 0.07583378f, 
    -0.04442253f, -0.00291229f, -0.08651777f, 0.07838394f, -0.01025332f, 0.01758283f, 0.01419861f, -0.02302653f, 
    0.02681996f, 0.01005309f, 0.00612015f, -0.01948589f, 0.03647038f, 0.17679721f, -0.11513609f, 0.08621390f, 
    -0.04000087f, 0.00525275f, 0.07591068f, 0.04251530f, -0.16213045f, 0.05816539f, -0.09857292f, -0.03604437f, 
    0.02446517f, -0.01786213f, 0.01621872f, 0.02701797f, -0.03128406f, -0.06957138f, 0.02381469f, -0.07731596f, 
    0.02710221f, 0.10325992f, -0.04974334f, 0.11623576f, -0.04162664f, -0.04184043f, 0.02813243f, -0.05204475f, 
    0.03238766f, -0.03938003f, -0.04832176f, 0.00740962f, 0.01606199f, -0.01855856f, -0.01894198f, 0.04514442f, 
    -0.03160974f, 0.02551245f, -0.00351949f, 0.01087415f, -0.13102074f, -0.36257577f, -0.31292805f, 0.12646633f, 
    0.12923992f, 0.01768616f, 0.11353102f, 0.01560619f, -0.00308188f, -0.08605176f, -0.01864356f, 0.02641730f, 
    -0.07063194f, 0.03726626f, -0.05805555f, -0.00447330f, 0.06007052f, 0.02930217f, 0.01960701f, -0.05796751f, 
    -0.46574658f, 0.11061944f, -0.10700301f, 0.17239806f, 0.04050184f, 0.03668914f, 0.10269295f, -0.00245321f, 
    0.03848922f, -0.05837996f, -0.09568070f, 0.00868402f, 0.04067564f, -0.07029456f, 0.09348797f, 0.01742010f, 
    0.07988144f, -0.03361242f, -0.02437860f, -0.00342582f, 0.04995535f, 0.08610485f, 0.05068072f, 0.12691708f, 
    0.00990517f, 0.08659790f, 0.07026102f, 0.03648973f, -0.00249016f, 0.05532052f, -0.03044029f, 0.10319222f, 
    -0.07443210f, -0.12196682f, -0.09727790f, -0.00611300f, -0.01840505f, 0.07641862f, -0.00632544f, -0.05001979f, 
    0.30617386f, 0.18006803f, -0.07396559f, -0.02065854f, 0.03708782f, 0.03918387f, 0.04177995f, 0.04413284f, 
    0.01394157f, 0.00347256f, -0.01935927f, -0.04675153f, -0.08505635f, -0.05804795f, 0.03477719f, -0.04156376f, 
    -0.01728551f, 0.03966710f, -0.01441667f, 0.00725179f, -0.09691212f, 0.05364649f, 0.13107781f, 0.06045258f, 
    -0.06047267f, 0.02960039f, -0.01262568f, -0.01407332f, -0.01039362f, 0.01794035f, 0.00154769f, 0.04526354f, 
    -0.04866890f, -0.02017333f, -0.05112985f, -0.00783256f, 0.00021694f, -0.00515392f, -0.07684822f, -0.06215752f, 
    -0.11920505f, -0.19938244f, -0.08079494f, -0.07718137f, -0.07378234f, -0.06278760f, -0.11908495f, 0.01039283f, 
    -0.00578101f, -0.00277303f, -0.03651373f, -0.04157386f, 0.01605547f, 0.02253771f, 0.00378329f, -0.05204187f, 
    -0.04402713f, -0.05143350f, 0.00727798f, -0.08493818f, 0.02648674f, -0.06844144f, -0.01862054f, -0.02016792f, 
    -0.09943639f, -0.07611715f, -0.12669416f, 0.03444171f, -0.00400788f, -0.01612139f, -0.04736027f, 0.01760314f, 
    0.00356872f, -0.06758459f, -0.01359801f, -0.01418857f, 0.01507387f, 0.01419937f, 0.04369339f, 0.03492540f, 
    -0.05922462f, 0.13319272f, 0.07120956f, 0.10533541f, 0.04282413f, 0.03881202f, -0.00408348f, 0.01743855f, 
    0.03564736f, -0.01757819f, -0.04210696f, 0.01304939f, -0.04634915f, 0.00861614f, -0.03562238f, 0.00853905f, 
    0.01699270f, 0.00854490f, -0.00136852f, 0.01841441f, 0.00828004f, -0.10129829f, 0.04688717f, -0.01710738f, 
    -0.03569610f, -0.04516589f, -0.11388278f, 0.04570370f, -0.05864673f, -0.07462504f, -0.06279496f, 0.03399585f, 
    -0.05558188f, -0.01100611f, 0.05478181f, -0.00535782f, 0.01316766f, 0.05357527f, 0.07139882f, 0.00115778f, 
    0.17837091f, -0.23887514f, -0.12046286f, 0.07481463f, -0.01480362f, -0.09785718f, 0.07985129f, 0.05881910f, 
    0.00090283f, 0.04622906f, 0.06285997f, 0.01152280f, -0.03899146f, -0.02313422f, -0.00516038f, -0.05432387f, 
    0.04073765f, -0.00164330f, 0.02352331f, 0.03411308f, 0.07178667f, -0.03296662f, -0.15175787f, -0.05639915f, 
    -0.06872465f, -0.05471760f, -0.06315717f, 0.01259839f, -0.06265437f, 0.03098519f, -0.05614682f, -0.02491986f, 
    0.06287360f, -0.02984541f, -0.00432747f, 0.00699618f, -0.03178091f, 0.03002917f, -0.02800571f, 0.00426335f, 
    0.27253407f, -0.14717695f, 0.12422506f, -0.13622150f, -0.02493119f, -0.05858602f, 0.02016981f, -0.02394066f, 
    -0.06138160f, -0.03377697f, -0.01167777f, 0.07096088f, -0.00337208f, 0.00274455f, 0.00257834f, -0.02543880f, 
    -0.00611414f, -0.06197279f, 0.00768424f, -0.03157904f, 0.26266986f, -0.26280010f, -0.15558891f, 0.05630381f, 
    0.05341028f, -0.02845124f, -0.10377374f, -0.05197521f, 0.02812338f, -0.03065515f, -0.01792067f, -0.03465604f, 
    -0.02207210f, 0.01254461f, -0.08526584f, -0.01242543f, 0.03447935f, 0.05770011f, 0.04997863f, -0.02120716f, 
    -0.25364056f, 0.13790128f, 0.04717241f, 0.00401649f, 0.02932096f, -0.10808940f, 0.03276641f, 0.08083564f, 
    -0.03349806f, 0.06103077f, -0.03239587f, 0.09987442f, -0.02681291f, 0.06800008f, -0.01682281f, 0.01495957f, 
    0.03080687f, 0.00223212f, 0.10067898f, 0.04574126f, 0.07363501f, 0.02705654f, 0.07614683f, -0.01535224f, 
    -0.03029874f, -0.04673726f, 0.01285763f, -0.02925473f, -0.00091960f, 0.09162685f, -0.03137860f, -0.01093767f, 
    0.04132587f, -0.09379578f, 0.00654814f, 0.01634183f, -0.01909459f, 0.08163247f, -0.02781090f, -0.02134010f, 
    0.00068937f, 0.04425083f, -0.14536501f, -0.09095331f, 0.14930902f, 0.00804428f, -0.01878873f, -0.00253981f, 
    0.05831136f, -0.05339278f, -0.02006829f, -0.05540391f, -0.00332038f, -0.02656357f, -0.03465940f, -0.08404613f, 
    -0.03802937f, -0.06255332f, 0.02673632f, -0.00342241f, 0.02851848f, -0.02239671f, 0.01821939f, 0.13086769f, 
    0.02321708f, 0.01691258f, 0.05556057f, -0.06332593f, 0.13495412f, 0.01647243f, 0.05762572f, 0.10567591f, 
    0.03402438f, -0.02518528f, 0.03976909f, 0.01186763f, 0.02119819f, -0.03932258f, 0.13439707f, 0.07487622f, 
    -0.03275708f, -0.16023631f, -0.14738950f, 0.17346282f, -0.02097209f, 0.13459602f, -0.03514835f, 0.04298528f, 
    -0.05120637f, 0.04679655f, -0.01473020f, -0.00900998f, 0.05315921f, 0.03438830f, 0.00904779f, 0.05574409f, 
    0.01270717f, 0.03790467f, 0.00418846f, -0.04372085f, 0.33528957f, 0.09083515f, -0.10917463f, -0.01081626f, 
    0.13947012f, 0.00416753f, 0.03101552f, 0.01870332f, 0.06230767f, 0.05242676f, -0.03105492f, -0.04445924f, 
    0.11074903f, -0.02880740f, -0.01688744f, -0.05384680f, 0.01859320f, 0.01569340f, -0.04253098f, 0.10462311f, 
    0.04029045f, 0.09731952f, -0.00003677f, 0.04132241f, -0.10369706f, -0.00959567f, -0.00004217f, -0.02115606f, 
    0.05305357f, -0.00637616f, 0.01445543f, -0.04775237f, 0.03030261f, 0.08826784f, 0.03838205f, -0.03412931f, 
    -0.00835063f, 0.05563512f, -0.05917680f, -0.05268566f, -0.21909177f, 0.19612172f, -0.06577596f, -0.25356036f, 
    -0.22951674f, -0.01623950f, -0.06803617f, -0.07964280f, -0.03493512f, -0.11471388f, 0.02066018f, 0.07480396f, 
    -0.15158190f, 0.12132403f, 0.11369033f, 0.04954391f, 0.01497978f, -0.01285720f, -0.06188143f, 0.00162298f, 
    -0.10764255f, -0.05466277f, 0.08241802f, -0.00677356f, 0.02678641f, 0.02615857f, 0.07845871f, -0.07536996f, 
    0.09905547f, -0.02667717f, 0.08596054f, -0.03080533f, -0.02627102f, 0.02535243f, 0.07115660f, 0.07290819f, 
    -0.06195364f, -0.01423024f, -0.00001692f, 0.07301732f, -0.04578489f, 0.00747750f, 0.11763486f, -0.05602624f, 
    -0.00669932f, 0.04582986f, -0.02875914f, -0.04266872f, 0.03435532f, -0.03504206f, -0.04197143f, 0.00648820f, 
    -0.01599578f, 0.01371098f, -0.00428449f, -0.03422415f, -0.06378492f, 0.03169801f, 0.04385350f, -0.06548953f, 
    -0.15599889f, -0.14294873f, 0.15578213f, 0.14927191f, -0.02706416f, -0.08347834f, -0.04004006f, 0.04927642f, 
    -0.08438997f, -0.05652502f, 0.08132956f, 0.03955778f, 0.05846778f, -0.06620563f, 0.02923119f, 0.07939784f, 
    -0.17092152f, 0.06446641f, 0.02009162f, -0.01268795f, 0.05706266f, 0.03518717f, 0.19377913f, 0.04028416f, 
    -0.08173886f, 0.00431387f, -0.06981865f, -0.02797166f, -0.00336940f, -0.04895508f, 0.03380116f, 0.00871992f, 
    -0.08052014f, -0.10651766f, 0.02708962f, 0.03366930f, 0.03587506f, -0.06510282f, -0.03893115f, -0.02555872f, 
    -0.19798452f, -0.30683190f, 0.20490517f, 0.08684316f, 0.01738196f, -0.00495895f, -0.05291487f, -0.03661704f, 
    -0.12561768f, 0.03922273f, 0.05114281f, 0.03881975f, -0.02546366f, -0.08483650f, 0.00969661f, -0.04848918f, 
    -0.12468184f, 0.03042950f, -0.01485925f, -0.01579208f, -0.03433376f, -0.11036242f, -0.02370336f, -0.06788909f, 
    -0.36184630f, -0.00371742f, 0.01246214f, 0.05852960f, -0.00218308f, 0.03658575f, -0.07481585f, -0.09278415f, 
    0.01166481f, 0.00018014f, 0.04402677f, -0.07798710f, 0.07429030f, -0.06647570f, -0.06093164f, 0.01799705f, 
    -0.33039635f, 0.15153475f, -0.03774264f, -0.02693556f, 0.07402898f, -0.01015049f, -0.08535273f, 0.01986791f, 
    0.07503214f, 0.05600055f, -0.06487098f, 0.02055766f, 0.04794026f, -0.01296953f, 0.01160253f, 0.00639755f, 
    0.03533854f, -0.03486028f, -0.05900821f, -0.14624041f, -0.32604918f, 0.05773070f, -0.03742650f, 0.13771890f, 
    0.11737527f, -0.03164616f, -0.03771808f, -0.00673303f, -0.00097232f, -0.05128890f, -0.03714532f, 0.01785819f, 
    -0.00284459f, 0.02309899f, -0.02287427f, 0.01219579f, -0.03321912f, 0.02660820f, -0.00030245f, 0.10416045f, 
    -0.09972635f, -0.01544030f, 0.31303239f, 0.10322909f, -0.08120515f, 0.10333545f, 0.10787558f, 0.05396041f, 
    -0.02241315f, 0.04832220f, 0.08224949f, -0.01253111f, -0.03117954f, -0.00439238f, -0.03044573f, 0.03498601f, 
    -0.01425323f, -0.00267550f, -0.08451172f, -0.00565840f, -0.12849481f, 0.05313671f, -0.15164377f, -0.10385004f, 
    0.09395340f, 0.04420318f, -0.00943120f, 0.01088565f, 0.08046998f, 0.02194182f, 0.00170738f, -0.05177507f, 
    0.00473035f, -0.00461810f, -0.00128250f, 0.03582405f, -0.03029307f, -0.05145684f, 0.00554889f, -0.03237708f, 
    0.12182824f, -0.09983106f, 0.14201356f, -0.04853545f, 0.00851024f, -0.08192512f, 0.03371864f, 0.03232051f, 
    -0.00706241f, 0.05973382f, 0.07689124f, -0.01887621f, -0.01435392f, -0.05098481f, -0.03780078f, 0.00614952f, 
    -0.00894469f, -0.01244013f, 0.05962425f, 0.03862910f, 0.26594371f, 0.03274126f, -0.09472429f, -0.14533834f, 
    -0.11231991f, 0.03156984f, 0.03864972f, 0.11711910f, 0.00622349f, -0.06216859f, 0.00878319f, -0.02218202f, 
    -0.01492973f, 0.01138028f, -0.04075528f, 0.01838620f, -0.01103885f, -0.02069778f, 0.01889129f, 0.01646890f, 
    -0.01080366f, -0.02405449f, -0.02090952f, 0.16729106f, -0.12275602f, -0.06307758f, -0.01597132f, -0.00448262f, 
    0.00093562f, -0.05997066f, 0.13160661f, 0.01888546f, -0.05611151f, -0.00589725f, 0.02546509f, -0.02150209f, 
    0.03013769f, 0.07935002f, 0.01715201f, 0.07987825f, -0.38755614f, 0.17878483f, 0.08901879f, 0.02351701f, 
    0.08105408f, 0.09386612f, 0.03252786f, 0.04547127f, 0.03102641f, 0.09258661f, -0.04570181f, 0.12782328f, 
    -0.01605497f, 0.05769127f, -0.03715518f, -0.03583551f, 0.04275843f, 0.05115550f, -0.04963873f, -0.10180028f, 
    -0.01434213f, 0.07237773f, -0.14204793f, 0.09317909f, -0.12403174f, 0.06974599f, 0.02815988f, 0.07015637f, 
    0.06643222f, 0.00388848f, -0.08512317f, 0.04583097f, 0.07380064f, -0.05041079f, 0.01207541f, 0.07490279f, 
    -0.01160137f, -0.01185986f, 0.01232930f, 0.02431560f, -0.14557338f, -0.05306055f, 0.05211303f, 0.00747323f, 
    0.01057514f, 0.05418834f, -0.02052447f, -0.00972880f, -0.04220666f, 0.08981768f, 0.02679783f, -0.07396720f, 
    0.03526659f, 0.02601327f, 0.03702363f, 0.01724789f, 0.06328060f, 0.10869718f, 0.04489632f, -0.00647666f, 
    -0.18308514f, -0.00786299f, 0.02410390f, -0.15076922f, -0.18344948f, -0.00645636f, -0.03388914f, -0.02363094f, 
    -0.09649067f, 0.06265768f, 0.07776184f, 0.03582142f, 0.01692546f, 0.01449834f, -0.05606609f, 0.02269115f, 
    0.01144752f, -0.10568887f, -0.06107804f, -0.01012692f, -0.18571860f, -0.00474172f, 0.14215165f, 0.02812826f, 
    0.00436706f, -0.08496242f, -0.04621180f, -0.01567401f, -0.04054370f, -0.00470833f, 0.11816768f, -0.01168467f, 
    -0.00679336f, -0.08208924f, 0.03939077f, 0.02796245f, 0.04791512f, -0.04614399f, -0.03459651f, 0.00806335f, 
    -0.31315389f, 0.04741697f, 0.03160396f, 0.03938016f, 0.06790583f, 0.01277892f, -0.02177432f, -0.01254150f, 
    0.00823254f, 0.01703601f, -0.00134504f, -0.01754470f, 0.01045851f, 0.02173180f, 0.04161052f, 0.01606920f, 
    0.05701992f, 0.06025791f, 0.03313264f, -0.01895944f, -0.17231147f, 0.04457031f, 0.00806841f, 0.11610968f, 
    0.06798850f, 0.05868853f, -0.02972184f, -0.10348364f, 0.11120012f, 0.04911126f, -0.01563525f, -0.04426495f, 
    0.02673391f, 0.03584054f, 0.03857094f, 0.02447699f, -0.03003654f, 0.03242282f, 0.08214687f, -0.03364407f, 
    -0.35836864f, 0.08981875f, -0.09929652f, 0.02545513f, -0.05254587f, 0.01025696f, -0.06868257f, -0.04460118f, 
    0.07386368f, 0.03844002f, -0.00937330f, 0.03461511f, -0.04178115f, -0.03054934f, 0.11829868f, 0.09494330f, 
    0.12814203f, -0.10782307f, -0.07324748f, 0.04578808f, -0.04757309f, -0.11239995f, -0.06416696f, -0.02087155f, 
    0.17885405f, 0.02910772f, 0.06039626f, -0.02388454f, 0.08677831f, 0.06783655f, 0.06692117f, -0.05125990f, 
    0.11198655f, -0.03177708f, -0.02280596f, -0.07086229f, 0.03499767f, -0.04304388f, 0.11564087f, 0.11836550f, 
    0.04401728f, 0.15171170f, -0.17795016f, 0.03639593f, 0.13867259f, 0.12175737f, 0.07225136f, 0.02718604f, 
    -0.01424850f, -0.01744856f, -0.03974895f, 0.03677633f, -0.01895094f, -0.05260037f, -0.06460752f, -0.03933679f, 
    -0.13074121f, 0.07327928f, -0.08454970f, -0.07424571f, -0.29749179f, -0.06590623f, 0.07586287f, 0.03418661f, 
    0.02232533f, -0.09586875f, 0.04164016f, -0.11938541f, 0.02479436f, 0.03811599f, -0.03438753f, -0.01531348f, 
    0.02516706f, 0.01658539f, 0.00016021f, -0.14710917f, 0.01392865f, -0.05039882f, 0.08214346f, -0.00489061f, 
    -0.05174051f, 0.13142343f, -0.04749179f, 0.04263225f, -0.20954481f, -0.09318821f, -0.02736953f, 0.02166980f, 
    -0.00381658f, -0.05582951f, -0.00991272f, -0.09181748f, 0.05384383f, 0.07823251f, 0.01660087f, -0.04582918f, 
    -0.04901106f, 0.08221994f, -0.02201622f, 0.11828582f, 0.02300269f, -0.11808601f, -0.08339215f, 0.13506043f, 
    -0.03679985f, -0.10284611f, -0.05344860f, -0.03729140f, -0.12730730f, -0.01085528f, 0.01025139f, 0.04915324f, 
    -0.05675859f, -0.01936411f, -0.01219892f, -0.08452134f, 0.09094675f, 0.09779283f, 0.05137966f, 0.04792614f, 
    -0.15009840f, -0.23912482f, 0.09688179f, 0.15963346f, -0.02318284f, -0.21196826f, 0.05597758f, 0.04383438f, 
    -0.01973307f, 0.00363556f, 0.01409456f, 0.03602951f, 0.00186095f, -0.07221130f, 0.01467656f, -0.10277969f, 
    0.04268911f, 0.01295994f, 0.07882735f, 0.08813351f, -0.21196656f, -0.11519988f, -0.13702029f, 0.10776771f, 
    0.03072581f, 0.03275096f, 0.00570532f, 0.11703754f, -0.05302725f, 0.06507386f, 0.00718648f, 0.00160832f, 
    0.00437166f, -0.00351351f, 0.03994108f, -0.04203774f, 0.03472828f, 0.08603515f, 0.03576757f, 0.00419288f, 
    -0.20244963f, -0.28353193f, 0.10975239f, 0.12263814f, -0.05448361f, 0.00630987f, 0.00168745f, -0.04782458f, 
    -0.14465179f, -0.11491923f, 0.08129786f, -0.02399145f, 0.00020385f, 0.00120123f, 0.02434113f, -0.06334905f, 
    -0.03369953f, -0.17682357f, -0.03631219f, -0.14555629f, -0.38949072f, -0.24130835f, 0.09226480f, -0.05924274f, 
    0.03440090f, -0.07524944f, -0.02955053f, 0.00247587f, -0.05903232f, 0.03222894f, -0.05807845f, 0.04263556f, 
    0.02249134f, -0.05891408f, 0.02158951f, -0.00683770f, -0.03705132f, 0.01447339f, 0.06921784f, -0.07802512f, 
    0.42909220f, -0.10077436f, -0.17110233f, 0.04422180f, 0.14419666f, 0.13038361f, 0.09284766f, 0.16901439f, 
    0.07825219f, -0.00078620f, 0.07623472f, -0.07222137f, 0.03575851f, 0.10217155f, 0.03627741f, 0.00707254f, 
    -0.10216949f, -0.00731146f, 0.03691778f, -0.05483277f, 0.01583284f, -0.01562024f, 0.12268257f, -0.07932595f, 
    -0.05574437f, 0.00957126f, 0.04144338f, 0.02984358f, -0.01381739f, 0.02452992f, 0.04874423f, -0.02770348f, 
    -0.01656768f, -0.03188294f, -0.01559152f, 0.04509184f, 0.00610560f, -0.00906926f, -0.06088476f, -0.05006086f, 
    -0.54390645f, 0.15050536f, 0.13697416f, 0.13140662f, 0.03823486f, 0.00589354f, -0.12623058f, 0.04541921f, 
    -0.08050796f, -0.03230057f, -0.02940627f, 0.05798628f, -0.02250120f, 0.00750786f, 0.04953020f, 0.02434570f, 
    0.01564491f, 0.01272597f, 0.02429158f, -0.03415776f, -0.10400534f, -0.09727307f, 0.09006305f, 0.10409503f, 
    -0.04266456f, -0.04856231f, -0.04049433f, -0.09375269f, -0.07321332f, -0.05229569f, -0.00700668f, 0.06072077f, 
    0.01772099f, -0.01651801f, -0.03198735f, -0.04716635f, 0.01624450f, -0.04428400f, -0.01669063f, -0.03716961f, 
    0.18649025f, -0.23352142f, 0.17333339f, -0.06277618f, -0.06629252f, 0.02660356f, -0.01979312f, 0.08909579f, 
    -0.05199510f, -0.00066031f, -0.01136686f, 0.01751431f, -0.03016719f, -0.11294890f, 0.01238530f, -0.03184250f, 
    -0.00303300f, -0.07221779f, -0.02974347f, -0.12558866f, -0.11405813f, 0.20666288f, -0.13014536f, 0.18631890f, 
    -0.15909323f, -0.00949672f, -0.02048704f, 0.12353375f, 0.02265867f, -0.03271052f, -0.04365910f, -0.00180443f, 
    -0.08999505f, -0.04297995f, 0.01705490f, 0.00223268f, -0.05379429f, -0.09522811f, -0.06418442f, 0.04514066f, 
    0.12401306f, 0.10060839f, -0.26673368f, 0.18300624f, 0.08824151f, 0.14967918f, 0.04673070f, 0.06936578f, 
    0.00495110f, 0.11259256f, -0.00634170f, -0.07625472f, 0.15378861f, -0.01173878f, -0.10371992f, -0.02716793f, 
    0.02497100f, -0.12207477f, 0.05901645f, 0.05075370f, -0.32355762f, -0.08070803f, -0.10655878f, -0.01781847f, 
    0.14997250f, -0.04620159f, -0.06459560f, 0.03334104f, 0.04135871f, 0.05860775f, -0.00734015f, 0.06613275f, 
    -0.03659482f, -0.04899152f, 0.00321714f, 0.01177753f, 0.01743428f, -0.05952844f, 0.05571876f, 0.00164565f, 
    -0.02407952f, 0.01330312f, 0.13105980f, 0.05803706f, -0.05078229f, -0.03395297f, 0.02254406f, -0.03377115f, 
    -0.09310523f, -0.02028922f, 0.00921949f, 0.03001305f, -0.01573933f, 0.04327419f, 0.03689233f, 0.01116081f, 
    -0.06587206f, 0.05151103f, 0.09637877f, 0.01001286f, 0.00301594f, -0.15918198f, 0.00292335f, 0.14280076f, 
    -0.04168476f, -0.08426627f, 0.05406953f, -0.00222914f, -0.02093167f, -0.03419666f, 0.08658417f, 0.05164356f, 
    0.03878086f, -0.00018258f, 0.07299321f, -0.04779078f, -0.03837021f, 0.04536202f, 0.00872581f, -0.00903280f, 
    -0.16095665f, 0.05063945f, 0.08415939f, -0.01673496f, 0.06149196f, -0.05058068f, -0.00324373f, 0.03365553f, 
    -0.00563518f, 0.02935481f, -0.03120594f, -0.04260056f, 0.11867270f, 0.02858968f, 0.01480705f, 0.02340439f, 
    0.06016615f, 0.04689337f, 0.08970854f, -0.05240380f, 0.15689585f, -0.06496253f, -0.09314505f, -0.02741396f, 
    0.11681386f, 0.06031558f, -0.06040228f, -0.01478659f, -0.13486786f, -0.05529138f, -0.05920099f, -0.04627344f, 
    -0.04614023f, -0.02220790f, -0.01074493f, -0.01978064f, -0.13220125f, -0.11968951f, -0.04818333f, 0.05006324f, 
    -0.07830455f, 0.15023860f, -0.11925983f, 0.13616471f, -0.22466026f, -0.07006948f, -0.01430902f, 0.11847453f, 
    0.03165435f, -0.05277010f, 0.02455736f, -0.07105301f, -0.04538744f, 0.00260452f, 0.05864830f, -0.04034578f, 
    -0.06016917f, -0.01554652f, -0.08523495f, 0.06172094f, -0.04913171f, 0.09313472f, 0.12193540f, -0.02564372f, 
    0.02484622f, 0.13996011f, 0.06684247f, -0.00411255f, -0.01180623f, -0.07514801f, 0.05838245f, 0.05834395f, 
    -0.07158916f, -0.00574802f, -0.11716641f, -0.02629402f, 0.11299518f, -0.01877861f, -0.04023956f, -0.03413978f, 
    -0.45538449f, 0.01677341f, 0.03979230f, -0.16138050f, 0.00603093f, -0.10994606f, 0.04116724f, -0.00421963f, 
    0.00646592f, 0.09347891f, 0.01514800f, -0.05612325f, 0.01653656f, -0.05563208f, 0.12374085f, -0.02024582f, 
    0.05343021f, -0.09581269f, 0.08832198f, 0.02168368f, -0.01162966f, -0.12662111f, 0.14064589f, 0.02135316f, 
    -0.00572970f, -0.01460308f, 0.04869990f, -0.13225058f, -0.03048541f, -0.05743047f, 0.05828825f, -0.09135484f, 
    -0.08006119f, 0.00986202f, 0.01881396f, -0.08339548f, -0.03527704f, -0.00589324f, 0.05668502f, 0.00868467f, 
    0.20825322f, -0.01452840f, -0.02866802f, -0.16043261f, -0.16151962f, -0.02970095f, 0.06344403f, -0.01017338f, 
    0.01808801f, -0.00476196f, 0.01944723f, -0.07323407f, 0.05177847f, 0.00648330f, 0.00685176f, -0.03694944f, 
    0.09086021f, 0.09626289f, -0.03229831f, 0.05370113f, -0.22968735f, 0.01666448f, -0.06734335f, -0.05616270f, 
    -0.04863676f, 0.08545778f, 0.01438869f, 0.03025756f, -0.03725725f, 0.03549756f, 0.02760733f, -0.03827600f, 
    -0.08441206f, 0.05749444f, -0.00942848f, -0.04190817f, -0.08635098f, -0.05857428f, -0.02126460f, 0.04129158f, 
    -0.13935658f, -0.10617737f, -0.11788891f, 0.03029300f, -0.07616390f, -0.03195738f, 0.07269425f, -0.06347642f, 
    -0.05021632f, 0.10291377f, 0.03854024f, -0.01235246f, 0.05487806f, 0.05597561f, 0.00238239f, 0.10410716f, 
    -0.00926949f, 0.02419000f, -0.01368178f, -0.04894566f, -0.55996943f, -0.06652925f, -0.13105650f, 0.06453422f, 
    0.13425471f, 0.03476525f, -0.04730833f, 0.06280040f, 0.05379463f, 0.09843446f, 0.03575648f, -0.01089572f, 
    0.00449520f, 0.09640448f, 0.04436174f, 0.04762834f, 0.05424051f, 0.06384886f, 0.07737700f, -0.02741073f, 
    0.01329512f, 0.10631430f, -0.03085143f, -0.03295087f, -0.07854781f, -0.04502822f, 0.04248279f, -0.00948162f, 
    -0.02217556f, -0.08794680f, 0.06380676f, -0.03770642f, -0.01148914f, 0.04678745f, -0.03279454f, -0.00975765f, 
    0.03899610f, 0.02535448f, 0.01387149f, -0.00397680f, -0.59870690f, 0.03555907f, -0.02876350f, 0.08963355f, 
    0.23602249f, 0.05421897f, 0.06425347f, 0.01858119f, 0.05943194f, 0.12617494f, -0.08026799f, -0.02485694f, 
    0.04860727f, 0.04693970f, -0.02325165f, -0.01496255f, 0.12742482f, 0.06505587f, 0.06576037f, -0.15321937f, 
    0.42781371f, -0.11403517f, -0.17260677f, -0.11954226f, -0.28734234f, 0.01145072f, -0.03026794f, 0.02918072f, 
    -0.18079023f, -0.00986650f, -0.06476104f, 0.03161377f, 0.00471140f, -0.01496767f, 0.00698876f, 0.00450114f, 
    -0.08010756f, 0.02374632f, 0.02339646f, -0.02198263f, -0.46679598f, 0.02672038f, -0.03398536f, 0.13861267f, 
    0.13917804f, 0.07507388f, -0.04382741f, 0.10954031f, -0.01972069f, 0.12036137f, 0.05485709f, 0.03454175f, 
    -0.00506370f, -0.00960792f, 0.04730266f, 0.04135043f, 0.00731786f, 0.00062585f, 0.05353001f, -0.03809918f, 
    -0.08510395f, 0.04649526f, -0.01932420f, -0.25246456f, -0.01974748f, 0.04275493f, 0.01847523f, -0.04642117f, 
    0.02371635f, -0.07519227f, -0.04300487f, 0.00191152f, 0.06892025f, -0.02868089f, -0.07085259f, -0.01476085f, 
    -0.08041201f, -0.16837755f, 0.02072702f, -0.00831097f, 0.10454247f, 0.26274610f, -0.03908125f, -0.11263131f, 
    -0.00167194f, -0.01283550f, -0.00396218f, 0.02896233f, 0.01683852f, 0.02475236f, -0.06950656f, -0.02577167f, 
    -0.01582022f, 0.08530386f, 0.00836122f, -0.02523800f, 0.07228242f, 0.03580826f, 0.00430949f, 0.04481430f, 
    0.23616555f, -0.15281321f, -0.17873898f, -0.07426675f, -0.01992491f, -0.04891742f, 0.03153570f, 0.22134757f, 
    0.02386663f, -0.02058255f, 0.04314782f, -0.12055411f, -0.00766179f, 0.00829083f, 0.01240711f, 0.02096278f, 
    -0.01029870f, 0.01186375f, 0.02483957f, -0.01736212f, 0.04520801f, -0.12313179f, -0.08879017f, 0.05028735f, 
    -0.08790814f, -0.01333579f, 0.02480219f, 0.03901992f, -0.01386586f, -0.27955210f, 0.00498358f, -0.01195422f, 
    -0.00206504f, -0.00255853f, -0.00081936f, -0.07394635f, -0.04509880f, 0.00283497f, 0.07739956f, -0.13813853f, 
    -0.30371445f, -0.19026713f, -0.06061173f, 0.01604048f, -0.06334715f, 0.12205296f, 0.05044585f, 0.11851145f, 
    0.03782428f, -0.01776622f, -0.00417301f, -0.05798345f, -0.01198319f, 0.02029192f, -0.09676675f, 0.04734907f, 
    -0.01796759f, 0.08843490f, -0.05458678f, -0.03157711f, -0.07259209f, 0.01757845f, -0.14208859f, 0.01999675f, 
    0.06321585f, 0.08905259f, 0.00025933f, 0.04975718f, 0.01626249f, 0.04671656f, 0.00763408f, 0.08524431f, 
    0.09910236f, 0.02743460f, 0.09301508f, -0.03972616f, -0.01618096f, -0.01248659f, -0.11694367f, -0.01896059f, 
    0.08534438f, 0.14076033f, 0.11350631f, -0.13942298f, -0.02534937f, -0.01281630f, 0.00909805f, -0.00518497f, 
    0.01342580f, -0.00557251f, 0.06164414f, 0.07356834f, -0.03055658f, -0.05848914f, 0.00923920f, -0.00283854f, 
    -0.03161813f, 0.05949780f, 0.06665935f, -0.01389127f, -0.03136367f, -0.06777754f, 0.25239342f, 0.11406918f, 
    -0.24242686f, 0.09135803f, -0.03400221f, 0.02725062f, 0.04734831f, -0.14331087f, 0.06411436f, 0.01376254f, 
    -0.05930727f, -0.05233891f, -0.08019696f, -0.02273658f, 0.02117969f, 0.04102618f, 0.07974379f, -0.02999331f, 
    0.14451499f, 0.24675390f, -0.02000995f, -0.00414902f, 0.06676276f, -0.06200266f, -0.07171337f, -0.00495419f, 
    -0.05506754f, -0.01449664f, 0.13579044f, 0.07584377f, 0.00077077f, -0.02917021f, 0.04695794f, 0.02255888f, 
    0.02377776f, -0.04737120f, 0.09100479f, 0.04008767f, -0.28065908f, 0.13209225f, -0.14684260f, 0.07085088f, 
    0.00569232f, 0.11885528f, -0.01802545f, -0.01575583f, 0.07550064f, -0.09897409f, -0.07442283f, 0.04993054f, 
    0.04582878f, -0.08163424f, -0.01309962f, 0.00016104f, -0.01243273f, -0.03229095f, 0.08634984f, -0.08447175f, 
    -0.31994414f, -0.17126140f, -0.20317575f, -0.04462902f, -0.02777156f, -0.01457188f, 0.10866727f, -0.02400181f, 
    0.04109282f, 0.07513232f, -0.08201072f, 0.15479691f, 0.11828732f, -0.00729677f, 0.07849054f, -0.00329006f, 
    0.00737505f, -0.06871098f, 0.00999509f, -0.12108275f, -0.38866422f, -0.16228758f, -0.08376405f, -0.16301955f, 
    0.02584468f, 0.05378157f, 0.02481806f, 0.15422845f, -0.01857846f, -0.04809607f, 0.05830002f, 0.00344476f, 
    0.05495665f, 0.01005221f, -0.00527467f, -0.06071940f, -0.05548104f, -0.10824245f, -0.09124830f, 0.02055510f, 
    0.00560710f, 0.03166123f, 0.02258651f, -0.04879821f, 0.07281946f, -0.11845321f, -0.03290404f, 0.04696258f, 
    0.10108948f, -0.02428559f, -0.12231702f, -0.05662001f, 0.05297166f, 0.08587303f, 0.15510984f, -0.10578018f, 
    -0.02530869f, 0.01287402f, -0.03434588f, -0.03898567f, -0.02113754f, -0.08980962f, -0.02299232f, 0.10621553f, 
    0.15617721f, 0.03862486f, -0.00978450f, 0.03395856f, -0.01901328f, 0.03748488f, -0.04689683f, 0.01975211f, 
    0.09203844f, 0.01101806f, 0.04457889f, -0.05752446f, -0.03855961f, 0.01303414f, 0.08666344f, 0.00572130f, 
    -0.01677734f, 0.02763559f, -0.06312595f, 0.12943952f, 0.21089576f, -0.07689562f, -0.06377832f, 0.04592223f, 
    0.15276858f, 0.12721211f, 0.05992565f, -0.13931641f, 0.07702573f, 0.08552474f, 0.06857542f, -0.00848492f, 
    0.18882649f, -0.07041738f, -0.13174884f, -0.04158860f, -0.12509879f, 0.10157406f, 0.00857959f, 0.03265930f, 
    -0.01264720f, -0.00016248f, -0.02577125f, -0.02696607f, -0.12146527f, 0.11704003f, 0.00183789f, -0.08312065f, 
    -0.01895613f, -0.05203341f, -0.11185564f, -0.00461992f, -0.02304435f, -0.12707405f, 0.14105934f, -0.06938382f, 
    0.13040727f, -0.10354362f, -0.04820700f, 0.03992764f, -0.25035816f, 0.00061103f, 0.00398655f, -0.02721417f, 
    0.01868012f, -0.04401833f, 0.03689454f, 0.05210872f, -0.06700492f, 0.00935693f, -0.11207231f, -0.00515931f, 
    -0.04391638f, 0.04695372f, 0.07584484f, 0.02927044f, -0.15750787f, 0.31157666f, -0.26715618f, 0.01062831f, 
    -0.00999419f, 0.06868532f, -0.03300553f, 0.00849515f, -0.03874797f, 0.05685053f, 0.02973675f, 0.19553117f, 
    -0.05025898f, -0.11507267f, -0.03163058f, 0.00337501f, 0.04917209f, -0.00680450f, 0.08954141f, -0.06445394f, 
    0.01838066f, -0.08076988f, -0.12190112f, 0.27484402f, 0.26113427f, 0.00387642f, -0.05319819f, -0.03917741f, 
    0.04735678f, -0.00839933f, -0.01405944f, 0.00336752f, 0.06263799f, 0.04791310f, 0.03448686f, -0.00547746f, 
    0.05387742f, -0.06501576f, 0.04109713f, -0.13876893f, -0.29375264f, 0.08544491f, -0.00587007f, 0.02560090f, 
    -0.11993991f, 0.07658084f, -0.05480387f, 0.04541468f, -0.02862261f, -0.06260547f, 0.04152595f, -0.00503289f, 
    0.03889567f, 0.00457132f, -0.04661733f, 0.01091521f, 0.00843957f, 0.02276647f, 0.01979699f, 0.03150207f, 
    0.13631344f, 0.04807145f, 0.05986204f, 0.07564802f, -0.06741291f, -0.07426595f, -0.00067866f, -0.08014468f, 
    -0.04438787f, 0.05147671f, 0.05601757f, 0.04520867f, 0.12480647f, 0.04272606f, 0.01007407f, 0.02570637f, 
    0.01150671f, 0.13124499f, 0.07696433f, 0.01853986f, -0.40194970f, -0.07904074f, 0.15515499f, 0.29460603f, 
    -0.30708224f, -0.02449773f, -0.02234729f, -0.04650168f, -0.03660539f, 0.05947170f, -0.00517486f, 0.02229397f, 
    0.01663090f, 0.06022903f, -0.14777602f, -0.02959559f, 0.02957952f, -0.08321704f, -0.01397383f, 0.01253041f, 
    -0.05922733f, -0.08236695f, -0.01643225f, 0.14997910f, 0.14466633f, -0.03260466f, -0.08983547f, -0.00321091f, 
    0.02679460f, 0.04436661f, 0.00041522f, 0.05007367f, 0.10472396f, 0.07564192f, -0.02101870f, -0.00401033f, 
    0.01943776f, -0.11527529f, -0.09569944f, -0.00425071f, -0.11700014f, -0.06530876f, 0.02607257f, -0.08924455f, 
    -0.10874508f, 0.01266346f, -0.10001078f, 0.10578973f, 0.04981112f, -0.09404291f, 0.01218636f, 0.03261528f, 
    -0.07435584f, -0.02026598f, 0.00513608f, 0.04872380f, -0.09703615f, -0.00993783f, 0.05208463f, 0.06997993f, 
    -0.04977161f, -0.18681382f, 0.01382745f, 0.03321803f, 0.07143603f, 0.06288347f, 0.00589221f, 0.00102343f, 
    -0.05835719f, 0.04856689f, -0.00028618f, 0.02248662f, -0.00017370f, 0.00173414f, 0.02575683f, -0.05692765f, 
    -0.00231701f, -0.02148229f, -0.14305682f, 0.00932125f, 0.06056059f, 0.14651303f, -0.08896812f, -0.02348343f, 
    0.00245864f, 0.06749111f, 0.04046759f, -0.01464951f, 0.02769797f, 0.10601301f, -0.03145528f, 0.09345227f, 
    0.07317500f, -0.06264903f, 0.04122822f, -0.09313244f, -0.01579054f, -0.00374646f, -0.16669226f, -0.07718347f, 
    -0.13261095f, 0.02686734f, 0.05405641f, 0.11626823f, -0.01733482f, -0.04863501f, 0.04895448f, -0.10519435f, 
    -0.10953058f, 0.01498630f, 0.04974838f, -0.01439585f, -0.00015737f, -0.04696905f, -0.02097755f, -0.01705577f, 
    -0.04915686f, 0.00036140f, -0.04918604f, -0.06744705f, -0.06947793f, -0.10685646f, -0.00268893f, 0.12813936f, 
    0.01157659f, -0.05151897f, 0.05163403f, -0.01612018f, 0.02582118f, -0.01115559f, -0.08976006f, -0.00131365f, 
    0.06372050f, 0.03998693f, 0.11097565f, -0.09037378f, -0.09271970f, 0.04089351f, 0.03311143f, 0.06430501f, 
    -0.11537618f, 0.21782382f, -0.18466181f, -0.10519838f, -0.01483402f, 0.04461430f, 0.03767930f, 0.01413944f, 
    -0.04001632f, -0.04275368f, -0.03140707f, -0.01428469f, -0.01670723f, -0.03492107f, -0.03469854f, -0.00558590f, 
    0.03314267f, -0.05144142f, 0.05535963f, -0.00689769f, -0.40556034f, -0.05769584f, -0.38615027f, -0.16024220f, 
    0.01296424f, 0.07748420f, 0.16162632f, -0.02369467f, 0.03812224f, -0.06198641f, 0.02386222f, 0.06616553f, 
    -0.01186438f, -0.03809021f, -0.01419763f, -0.03621116f, 0.03238667f, -0.04513772f, -0.06576642f, 0.00609599f, 
    -0.04261408f, -0.27500397f, 0.16666803f, 0.06253065f, 0.01494117f, 0.06664702f, 0.10097391f, 0.04984587f, 
    0.09462173f, 0.01644535f, 0.04548233f, 0.00151918f, -0.00708511f, 0.01703050f, -0.08614609f, 0.03079051f, 
    0.08223254f, -0.11867440f, 0.10649469f, -0.03573584f, -0.13179448f, 0.13722397f, -0.12761274f, 0.04772921f, 
    -0.00102952f, 0.14169078f, 0.05752404f, 0.06858939f, -0.10362127f, 0.04428571f, 0.02068983f, 0.06492204f, 
    -0.00033559f, -0.05632425f, -0.04551530f, -0.02033169f, 0.00023500f, -0.03185192f, -0.07885610f, -0.10899879f, 
    -0.48923600f, -0.20373939f, -0.03603571f, -0.12089640f, 0.04208332f, 0.06025369f, 0.00380858f, -0.11677844f, 
    0.01683281f, -0.10073572f, 0.04803967f, 0.05953036f, -0.06939910f, 0.11760592f, -0.04944685f, 0.02254720f, 
    0.10109334f, -0.02317901f, -0.14023772f, 0.01988025f, 0.10782537f, 0.01644429f, 0.03553381f, 0.16211495f, 
    -0.01064724f, -0.01670339f, 0.01930776f, 0.10891555f, 0.00583141f, 0.00625111f, -0.05288960f, -0.01874903f, 
    -0.02679562f, 0.03949417f, 0.04190908f, 0.01068118f, 0.03910564f, 0.04032893f, 0.07890220f, 0.01075722f, 
    0.02531596f, -0.03274306f, -0.07543384f, -0.06728454f, 0.10790797f, -0.04418379f, 0.03364595f, 0.04581602f, 
    0.03633738f, 0.03186107f, 0.15339786f, 0.07883798f, 0.02329924f, -0.06340951f, -0.01645702f, 0.05070291f, 
    -0.00976717f, -0.06369229f, 0.11723838f, 0.04204987f, 0.10608555f, -0.00808660f, 0.09241880f, -0.08161474f, 
    -0.02657598f, -0.01780065f, -0.07752642f, 0.02530313f, -0.01851854f, 0.05948383f, 0.01056912f, -0.09054576f, 
    0.01780720f, -0.03762311f, 0.01247648f, 0.01687174f, -0.12041391f, 0.01463246f, -0.14461173f, 0.09817357f, 
    0.10053208f, 0.03571035f, 0.01102378f, 0.05132494f, 0.01279302f, -0.00870304f, -0.07928657f, 0.06338165f, 
    -0.00978647f, 0.06154922f, -0.09552835f, -0.08960678f, -0.00924213f, 0.04388001f, 0.03788189f, -0.00263826f, 
    0.01260718f, 0.02918048f, 0.01224068f, 0.04955139f, -0.00324474f, 0.17196368f, -0.00314175f, -0.07932363f, 
    -0.04599342f, -0.08293524f, 0.01559615f, -0.00032467f, 0.02337554f, -0.06719194f, 0.13740014f, -0.01137778f, 
    0.02071755f, -0.05873801f, 0.05347186f, 0.11200495f, 0.07609272f, -0.03865178f, 0.04146882f, 0.03707896f, 
    0.13911252f, 0.12659803f, 0.02497312f, 0.08194173f, -0.09514342f, 0.02313416f, -0.16195011f, 0.03896306f, 
    -0.08884416f, 0.09021790f, 0.05298943f, -0.03835059f, 0.11141647f, 0.06551366f, -0.00025999f, 0.07605480f, 
    -0.10528034f, -0.02895878f, -0.02256589f, 0.03020449f, -0.04706610f, 0.00612313f, 0.03337223f, -0.04521868f, 
    -0.03000848f, -0.09379475f, -0.08016368f, 0.08060510f, 0.01694301f, 0.00134379f, 0.00297082f, -0.07153469f, 
    -0.02519078f, 0.06110501f, 0.11728091f, -0.07000670f, -0.04407168f, 0.01136793f, -0.17951606f, 0.06068279f, 
    -0.07367264f, 0.18722917f, 0.19796166f, 0.01554471f, -0.14464770f, 0.07862724f, 0.06534325f, -0.06450866f, 
    0.00845440f, -0.07974651f, 0.04075974f, -0.00596485f, -0.08180616f, -0.02205223f, -0.00688467f, 0.02670183f, 
    -0.01654437f, 0.12090498f, 0.00616676f, -0.03299898f, 0.05705469f, -0.05313961f, 0.09183475f, 0.01100035f, 
    0.00007851f, -0.03094313f, 0.08704781f, 0.06686635f, -0.06219620f, -0.05954028f, 0.03191520f, 0.01632499f, 
    -0.03765233f, -0.00571852f, 0.09057854f, -0.03141509f, 0.00137700f, 0.10006382f, -0.02397807f, 0.01562677f, 
    -0.14612833f, 0.18559657f, -0.15181290f, -0.08503352f, 0.03415364f, 0.03495396f, -0.00914089f, -0.04091461f, 
    0.00665690f, -0.08218236f, 0.03160952f, -0.01368025f, 0.00554179f, -0.05802691f, 0.03823506f, -0.09165141f, 
    0.05475290f, 0.00706886f, 0.08110552f, -0.04555924f, 0.03039307f, 0.00098864f, -0.00409850f, 0.02633452f, 
    0.05765271f, -0.01842901f, -0.10736604f, 0.15928888f, 0.00302145f, 0.14219069f, -0.03653363f, -0.02004162f, 
    0.03869687f, -0.01116018f, 0.03157749f, -0.02062204f, -0.09037480f, -0.11770424f, 0.05916252f, -0.02909777f, 
    -0.02630720f, -0.03962676f, 0.00711248f, 0.07196772f, 0.04437638f, -0.02091763f, 0.05393908f, 0.03904855f, 
    -0.11481683f, 0.06764738f, 0.02543462f, -0.03172300f, -0.01695310f, -0.06018106f, -0.06564817f, 0.01542733f, 
    -0.06528495f, 0.06688128f, 0.07545106f, 0.06695061f, -0.19427893f, -0.14748751f, -0.09374220f, -0.01719045f, 
    0.04524951f, 0.08976466f, -0.04698228f, -0.06198498f, -0.07001507f, 0.07666089f, 0.02651196f, 0.06231541f, 
    0.07080004f, -0.09474216f, 0.02849152f, -0.10664019f, 0.00847124f, -0.04418979f, 0.01174505f, -0.20366393f, 
    0.03541952f, 0.14947167f, 0.15540600f, 0.04816170f, -0.17638043f, 0.09916655f, -0.13945581f, 0.02557219f, 
    0.03629106f, -0.00260045f, 0.05896378f, 0.00758805f, -0.00073928f, -0.09634718f, -0.14019851f, 0.13012446f, 
    -0.04344070f, 0.05387296f, 0.04907255f, 0.04172664f, 0.06342796f, -0.04878747f, 0.07390754f, 0.13581836f, 
    -0.25805879f, -0.06051099f, 0.05800961f, 0.04471636f, 0.03792375f, 0.03938941f, -0.04332761f, -0.05211919f, 
    0.03879157f, 0.03258947f, 0.07136656f, -0.03316654f, 0.06302901f, 0.05644946f, 0.04911061f, 0.03512080f, 
    0.09003077f, 0.04069092f, -0.06433941f, -0.01064315f, 0.00164935f, -0.03484416f, -0.06319582f, -0.01073592f, 
    0.05585179f, -0.11005359f, 0.00788353f, -0.03437475f, -0.07231982f, 0.12523508f, 0.22562219f, -0.04966339f, 
    0.02586862f, 0.03071332f, -0.17803267f, -0.04644116f, 0.02951633f, -0.01013445f, -0.08263243f, 0.03744269f, 
    0.09683733f, -0.05097209f, -0.13264112f, -0.05713900f, 0.05981145f, 0.06161825f, -0.01200200f, -0.06985355f, 
    0.01448910f, 0.12585467f, 0.05800825f, 0.01879192f, 0.02949084f, 0.03644043f, -0.05650552f, -0.05211437f, 
    -0.18231747f, 0.12745664f, -0.12407694f, -0.07132084f, 0.01137301f, 0.07010186f, 0.02517482f, -0.05395805f, 
    -0.04535736f, -0.11034735f, -0.00131279f, 0.06600066f, -0.15069996f, -0.01591766f, 0.00115845f, -0.00429943f, 
    0.00302524f, 0.02083673f, 0.05255965f, -0.02163382f, -0.23577966f, -0.29435459f, 0.06263681f, 0.00220897f, 
    -0.03363319f, 0.00061881f, 0.06256580f, -0.05098608f, 0.04791831f, 0.02585687f, 0.05287519f, 0.01226653f, 
    -0.07755981f, 0.06807542f, -0.07030268f, 0.08441751f, 0.01319133f, -0.05173353f, -0.15691730f, 0.05024800f, 
    -0.06946161f, -0.06418722f, -0.04936664f, -0.05950472f, 0.05540903f, 0.07078008f, 0.01261233f, -0.04935717f, 
    -0.00936606f, 0.05796332f, 0.03199046f, 0.07946410f, 0.11327448f, -0.01847721f, -0.03707173f, -0.07652283f, 
    -0.00398282f, -0.03099117f, 0.14014578f, -0.06812091f, -0.05905258f, -0.10100199f, -0.03276788f, 0.25212637f, 
    0.07752529f, -0.01210265f, -0.01675824f, -0.02026487f, -0.00383124f, -0.06670002f, 0.06596037f, -0.03091307f, 
    0.05216222f, 0.04464212f, 0.04841347f, 0.00618173f, -0.05133002f, -0.03782453f, -0.01795502f, -0.13263540f, 
    -0.03879176f, 0.03892892f, 0.04793303f, -0.00731761f, -0.19059937f, -0.18122120f, 0.04437276f, -0.03000263f, 
    0.03416637f, 0.08617532f, -0.03513812f, -0.02278999f, 0.10817447f, 0.04560251f, -0.02134287f, -0.00471188f, 
    0.01452534f, 0.02245565f, -0.08611595f, 0.06083431f, 0.08194167f, -0.00671441f, -0.08628229f, 0.15479320f, 
    0.19984055f, -0.06939446f, 0.02913817f, -0.00618334f, 0.06862445f, 0.02439518f, 0.02095646f, 0.04052158f, 
    0.06870823f, 0.11783123f, 0.13745563f, 0.06344122f, 0.11650436f, -0.08651260f, -0.04475761f, -0.10320183f, 
    -0.12602112f, -0.00824985f, 0.10202648f, 0.08500846f, -0.16035129f, 0.03105027f, 0.00610415f, 0.01882935f, 
    0.00063842f, 0.02163716f, -0.01068379f, 0.02037006f, 0.00505156f, 0.03122432f, -0.09575187f, -0.04687156f, 
    -0.02219169f, -0.15679361f, 0.00819112f, 0.03135954f, -0.18222339f, 0.06706674f, -0.02481270f, 0.02310845f, 
    0.00362785f, -0.01140487f, -0.07468084f, 0.03230594f, 0.05177217f, 0.03471077f, -0.04516391f, 0.01579178f, 
    0.12497951f, 0.04451970f, 0.05034755f, 0.09428760f, 0.12759282f, -0.01767016f, -0.02695666f, -0.02518835f, 
    0.04340658f, 0.18877383f, 0.03704311f, -0.00533727f, -0.04606734f, 0.03115440f, 0.03118853f, -0.10242413f, 
    -0.08637542f, 0.02459318f, 0.01128034f, 0.04655414f, -0.08878491f, -0.00987757f, 0.06837877f, 0.08222593f, 
    -0.02732012f, 0.04643748f, 0.10334261f, -0.00849376f, -0.31777200f, 0.08137697f, -0.25427347f, -0.14369360f, 
    -0.08426313f, -0.01011295f, 0.08549060f, 0.01902320f, -0.06150277f, -0.11671436f, 0.04683996f, -0.03164482f, 
    0.06365096f, -0.10276787f, 0.01929636f, 0.06479245f, -0.02254931f, -0.04030176f, 0.01488276f, -0.00633002f, 
    0.08391093f, 0.08295736f, 0.06832375f, 0.00991599f, -0.08445667f, 0.01107056f, 0.00385358f, -0.05571914f, 
    -0.02189264f, -0.02440830f, -0.04898284f, 0.04189927f, 0.04572506f, 0.04985781f, 0.20227990f, -0.03635990f, 
    0.00130589f, -0.04163961f, -0.11622611f, -0.06170502f, -0.33295140f, 0.14393018f, -0.25409099f, -0.18550900f, 
    -0.11448450f, 0.10417719f, 0.02963004f, 0.08759549f, -0.07666316f, -0.16956884f, 0.02626983f, 0.05144605f, 
    -0.14802654f, -0.01856577f, -0.02485385f, 0.04871365f, -0.08531864f, -0.00280840f, 0.04552785f, 0.02815001f, 
    -0.15933722f, 0.15058394f, 0.03948616f, 0.05620131f, 0.00927934f, -0.04651370f, -0.08566401f, -0.01557788f, 
    -0.07322627f, 0.10247539f, -0.06702673f, -0.10101009f, -0.06225796f, 0.01341165f, -0.12184365f, 0.05256283f, 
    0.06061928f, -0.02208694f, -0.00706249f, 0.06694856f, -0.28914356f, 0.07073244f, -0.18574029f, -0.11158630f, 
    -0.03696928f, 0.08509307f, 0.04402206f, 0.02402015f, -0.10435503f, -0.13146541f, -0.02458427f, -0.01281288f, 
    -0.05900105f, -0.05640348f, 0.02250229f, 0.04906255f, -0.02433128f, -0.01629320f, 0.04784665f, 0.00602260f, 
    -0.47813302f, 0.05702530f, -0.01758078f, 0.11918276f, -0.20686442f, 0.03386276f, -0.03519961f, -0.00597578f, 
    -0.06624327f, -0.00727820f, 0.05189163f, -0.02322315f, 0.01546356f, 0.03842108f, -0.10840076f, 0.06436973f, 
    -0.05288179f, 0.03135512f, -0.08749462f, -0.06781947f, -0.10375733f, -0.15120065f, 0.12639260f, 0.15449591f, 
    -0.29648477f, 0.00704805f, -0.05482375f, -0.00780210f, 0.01104625f, -0.11209349f, -0.09484003f, 0.03744559f, 
    0.00495764f, -0.06142117f, 0.12596171f, -0.08535770f, -0.05831400f, 0.00590228f, 0.12023207f, -0.09970015f, 
    0.09345856f, 0.13286121f, 0.01222221f, 0.11344730f, 0.01746173f, -0.00061773f, 0.08080386f, -0.13474549f, 
    0.03472551f, 0.09638181f, -0.02119548f, 0.02093490f, -0.14946127f, -0.00619047f, -0.08810047f, -0.02727573f, 
    -0.07789578f, 0.04538561f, -0.07746189f, -0.08196153f, -0.11611777f, 0.03366326f, 0.13353743f, 0.07540654f, 
    0.08414584f, -0.08887273f, -0.18422405f, 0.10121726f, -0.07280882f, 0.09622192f, 0.03489138f, -0.17352928f, 
    0.02261752f, 0.01892579f, 0.03824163f, -0.07388959f, 0.10006095f, -0.33065301f, -0.04110015f, 0.07262633f, 
    -0.07200676f, -0.34712285f, -0.03668886f, -0.10399276f, -0.10110992f, -0.03531557f, 0.03677788f, 0.02185394f, 
    -0.06906850f, -0.00049197f, -0.06284013f, 0.01275133f, -0.04318696f, 0.04915424f, 0.06781904f, -0.03085752f, 
    -0.01396107f, -0.03635342f, 0.08920293f, 0.00192283f, -0.25715801f, 0.05972733f, -0.17006710f, -0.26557159f, 
    0.09372143f, -0.01045877f, -0.02415675f, -0.04170061f, -0.10383607f, -0.05888463f, -0.05273505f, -0.04029914f, 
    -0.02348281f, -0.09541655f, 0.00898261f, 0.05386909f, -0.01907938f, 0.04439988f, 0.07009599f, 0.07225259f, 
    -0.10044126f, -0.05417558f, -0.09732563f, -0.05257506f, 0.05351569f, -0.04628266f, 0.02503544f, 0.03593800f, 
    0.07063343f, -0.00860413f, -0.02010450f, -0.09749270f, 0.01254301f, 0.03720827f, 0.00072517f, 0.02662883f, 
    0.00551835f, -0.01480171f, -0.03215764f, -0.00582566f, -0.04917561f, 0.16499580f, -0.13384694f, 0.01340961f, 
    -0.14596385f, -0.15093794f, -0.00033324f, 0.01834328f, 0.02363121f, 0.04495148f, -0.00813162f, 0.02289252f, 
    0.03129070f, -0.02650585f, 0.07796270f, 0.07955896f, -0.02715570f, 0.00882970f, -0.03049814f, 0.09059064f, 
    -0.10360992f, -0.15367535f, -0.10318156f, 0.10471766f, 0.03590101f, -0.00706042f, 0.11548576f, -0.09637210f, 
    0.01364877f, 0.04164942f, -0.03123330f, -0.03447797f, 0.03804690f, 0.05350672f, -0.03572964f, 0.07651361f, 
    -0.08758064f, 0.06836164f, -0.22033499f, 0.06314733f, 0.23248889f, -0.31958368f, -0.12983003f, 0.07353760f, 
    0.01208849f, 0.08382473f, 0.09990085f, -0.01399533f, -0.06526499f, -0.09472515f, 0.02152762f, 0.01256005f, 
    0.08194400f, 0.00176971f, -0.02017322f, 0.02634288f, -0.02674707f, 0.07227985f, -0.01248857f, 0.05023290f, 
    0.09742191f, -0.00291551f, -0.01887895f, -0.14977825f, 0.07020439f, -0.01647466f, 0.00972329f, -0.01710702f, 
    -0.14157802f, -0.16694015f, 0.07274013f, -0.03196608f, -0.09473485f, 0.00951543f, 0.04974061f, -0.06209835f, 
    0.01064737f, 0.04101636f, -0.06667471f, 0.06881984f, -0.13951072f, -0.04993553f, 0.00841906f, 0.10339727f, 
    0.09968047f, -0.00935604f, 0.09175771f, -0.04343021f, -0.02683837f, -0.07573637f, -0.02036977f, -0.06369809f, 
    -0.05137377f, 0.03599593f, 0.05999990f, 0.01264774f, -0.02829363f, 0.10835239f, 0.03016824f, 0.07024435f, 
    -0.12901667f, 0.17811106f, 0.03393579f, -0.13054121f, -0.28473654f, 0.06958054f, 0.04936646f, 0.04003705f, 
    0.00575925f, 0.05144662f, -0.04693078f, 0.04944118f, -0.03637109f, 0.00715975f, -0.12865835f, 0.04138190f, 
    0.03096760f, 0.00100585f, 0.05050466f, 0.06328681f, -0.17003271f, 0.12547894f, 0.05792387f, 0.07936919f, 
    -0.24914595f, 0.06302661f, 0.05178435f, 0.03209739f, 0.03886914f, -0.05585453f, -0.06635560f, -0.03131199f, 
    0.05853769f, 0.04523381f, -0.10274763f, 0.06401979f, -0.09545862f, 0.02565363f, -0.04842351f, -0.04177531f, 
    0.02978548f, 0.15616179f, 0.00018307f, -0.10129027f, -0.01819786f, 0.00719208f, 0.00355015f, 0.03118305f, 
    -0.08211798f, -0.00826241f, -0.01700803f, 0.00870587f, -0.12650913f, 0.03528167f, -0.05436885f, -0.01675042f, 
    -0.17146020f, 0.09683675f, 0.06026600f, 0.01734175f, 0.03447984f, 0.12561868f, -0.17067946f, 0.27055740f, 
    -0.33491668f, -0.06678775f, 0.15784061f, -0.05451499f, 0.09305676f, -0.01516194f, 0.04002125f, 0.10352198f, 
    -0.03049346f, 0.00092480f, 0.03434977f, -0.01115341f, 0.00162876f, 0.13180920f, -0.12655360f, 0.08279554f, 
    0.32519609f, -0.37409648f, -0.02118840f, 0.19851379f, -0.03065472f, 0.02586645f, 0.11653222f, -0.02231149f, 
    -0.05390217f, 0.01605499f, 0.05121598f, 0.00274729f, 0.10533019f, 0.05118591f, 0.06515387f, -0.03506890f, 
    -0.01837362f, 0.01837054f, -0.01277704f, -0.19147149f, -0.06235824f, -0.13079762f, -0.05688922f, -0.34704092f, 
    0.19462430f, -0.09699451f, 0.03680818f, 0.03428478f, 0.10487428f, -0.07404186f, -0.11176330f, -0.02183016f, 
    0.02047536f, -0.01285955f, 0.03744734f, 0.00798376f, 0.03249881f, 0.06926857f, -0.03133505f, 0.08993616f, 
    -0.17893657f, 0.19523206f, -0.05539734f, -0.14904445f, -0.04884492f, -0.15683763f, -0.07247531f, 0.03034970f, 
    0.04671688f, 0.01829971f, 0.04355426f, 0.01633584f, -0.06150319f, -0.02319550f, 0.00155235f, 0.00709264f, 
    -0.10670783f, 0.08281519f, 0.03699977f, 0.15690216f, 0.00283137f, -0.36127216f, -0.06288838f, 0.08695460f, 
    0.01555117f, -0.00204742f, 0.07138379f, -0.01738394f, -0.01723921f, -0.00152317f, -0.06026400f, 0.00789578f, 
    -0.00667083f, 0.04418879f, 0.06117228f, -0.04585097f, -0.00378438f, -0.01678255f, -0.00053626f, -0.00951536f, 
    -0.43306151f, 0.21842027f, 0.06234146f, 0.17594942f, -0.17659611f, -0.02089495f, -0.09642467f, 0.00291388f, 
    0.06168835f, -0.00840175f, -0.02182326f, 0.01309618f, -0.08137578f, 0.05788996f, 0.01980827f, 0.01334546f, 
    0.01292171f, -0.17124599f, -0.02087729f, -0.11288919f, -0.00508729f, 0.02115459f, 0.19981937f, 0.11282029f, 
    0.20525748f, -0.06551260f, -0.07778767f, 0.03067659f, -0.02003657f, 0.04124972f, -0.07680446f, 0.09147216f, 
    0.01260924f, 0.07460410f, -0.09956051f, 0.01305088f, -0.00790194f, 0.04559809f, 0.04767644f, -0.03088010f, 
    0.00121829f, 0.02211060f, -0.19589229f, -0.09134752f, -0.03892339f, -0.01433392f, 0.03548165f, 0.00551257f, 
    -0.06706412f, 0.06998124f, -0.03039186f, -0.07822789f, -0.05897605f, 0.04026295f, 0.01158380f, 0.00253918f, 
    -0.02505471f, 0.08375406f, 0.07638739f, 0.02426742f, 0.31278601f, -0.21019459f, -0.00490042f, 0.08945009f, 
    0.06493235f, -0.00574437f, 0.03029207f, -0.08433859f, -0.02871568f, -0.03289103f, -0.02037794f, -0.06444690f, 
    0.13183509f, -0.02062617f, 0.06345430f, -0.10092269f, 0.03313636f, 0.07675280f, -0.02652480f, -0.13252287f, 
    0.04684083f, 0.07899139f, -0.12001160f, -0.07327339f, 0.06104903f, 0.01215091f, -0.02821523f, 0.04260396f, 
    -0.02770225f, -0.01847585f, 0.01011767f, -0.11181264f, -0.04868835f, -0.08474393f, -0.06464168f, -0.04076926f, 
    0.06585752f, 0.06950911f, 0.08200555f, 0.00656218f, 0.15935369f, -0.06060304f, -0.03246712f, -0.14277320f, 
    -0.12500839f, 0.01880923f, 0.02893661f, 0.03831917f, -0.07647116f, -0.05357687f, -0.02076804f, -0.03530856f, 
    -0.04799332f, -0.06609445f, 0.04503843f, 0.05863040f, 0.00237373f, -0.03247956f, 0.13138480f, 0.04720094f, 
    0.08711019f, -0.03362143f, 0.06087749f, 0.03417023f, 0.37141672f, 0.06736581f, -0.03111824f, 0.04821574f, 
    0.06192206f, -0.01463001f, -0.09452215f, 0.02770815f, -0.03793094f, 0.09138720f, 0.07603627f, -0.01656577f, 
    -0.00314149f, 0.01301193f, -0.00655776f, -0.02589556f, -0.16425809f, 0.17205055f, 0.14263624f, 0.03556192f, 
    -0.31450790f, 0.08579280f, 0.00286877f, 0.02526621f, 0.05759577f, -0.00525717f, -0.01952870f, -0.04342498f, 
    -0.03510913f, 0.03852909f, -0.05556905f, 0.02739470f, -0.00236522f, -0.05250860f, -0.00319304f, -0.07456017f, 
    0.16165434f, -0.28191313f, 0.00705557f, -0.05193326f, -0.01091180f, 0.00904457f, 0.07247721f, -0.03134915f, 
    0.08245812f, -0.06212762f, 0.00192818f, 0.03964886f, 0.05539749f, 0.04368914f, 0.01650120f, 0.04864164f, 
    -0.04629470f, 0.02655355f, -0.10585484f, 0.03660000f, -0.12686998f, 0.00206023f, -0.01913798f, -0.40129462f, 
    0.16674611f, -0.07479323f, -0.07880668f, -0.00630906f, -0.05158775f, -0.08519034f, -0.00443646f, -0.12732138f, 
    0.07454455f, 0.02000735f, -0.08284519f, 0.07820606f, -0.04267460f, -0.06297071f, 0.06348068f, 0.12489967f, 
    -0.07643636f, -0.19255014f, -0.04451080f, 0.12802614f, -0.10315321f, -0.14171550f, -0.00681500f, 0.05625911f, 
    -0.13489661f, -0.01746056f, -0.07867757f, 0.00155264f, -0.09231789f, -0.06698679f, 0.00486407f, 0.00656510f, 
    0.01506984f, 0.07967267f, -0.12601915f, 0.00833818f, -0.28370887f, -0.00209671f, 0.04669034f, -0.35300639f, 
    0.03154423f, -0.13624106f, -0.09103875f, 0.02457573f, 0.01056633f, -0.16870506f, -0.00206341f, -0.00066748f, 
    -0.05232978f, -0.04201012f, 0.05889391f, 0.06071679f, -0.03015307f, 0.02990728f, 0.02766293f, -0.05819088f, 
    -0.21787183f, -0.03912111f, -0.01366223f, -0.07656978f, 0.08669573f, -0.04623641f, 0.00350936f, 0.10262022f, 
    -0.07485984f, 0.06903890f, 0.06722485f, -0.07905165f, 0.03617887f, -0.02258960f, -0.01301878f, -0.05233032f, 
    0.03647171f, -0.12382488f, 0.15499933f, 0.06554620f, -0.08843634f, 0.20431471f, 0.00555286f, 0.14611800f, 
    -0.21916994f, -0.04762578f, 0.01997232f, -0.00814416f, 0.03785315f, 0.04746141f, 0.00569056f, 0.05103132f, 
    0.00175340f, -0.05038312f, -0.03774833f, -0.00024240f, -0.04379106f, 0.04459978f, -0.06176586f, -0.07348412f, 
    0.05520999f, -0.13188921f, -0.13511395f, -0.03607764f, 0.11042497f, -0.08295165f, 0.06271891f, -0.00304785f, 
    -0.06026523f, 0.03558800f, -0.00747053f, -0.05901736f, -0.00630290f, -0.01012522f, 0.01432188f, 0.01992852f, 
    0.00929303f, 0.12797961f, 0.00343023f, 0.04346004f, 0.03430228f, -0.05846243f, 0.11048310f, -0.12329556f, 
    -0.02265955f, 0.09229560f, 0.08538241f, 0.01977759f, 0.02002118f, 0.00980918f, -0.00259118f, -0.04789753f, 
    -0.00316356f, -0.00708809f, -0.05260407f, 0.00732135f, 0.08969355f, -0.04649425f, 0.04007844f, -0.10183189f, 
    -0.13091388f, 0.16338630f, 0.00563534f, 0.03011666f, -0.26965141f, 0.04879752f, 0.08225394f, -0.00790121f, 
    0.03942318f, 0.07917952f, 0.02386145f, 0.02891266f, 0.00023212f, -0.03089475f, -0.00991287f, -0.00906654f, 
    0.03927278f, 0.00202599f, -0.03012209f, -0.02438208f, 0.06138991f, -0.23952615f, -0.04266198f, 0.05170017f, 
    0.05511951f, -0.07468195f, 0.05639198f, -0.01950368f, -0.04184989f, 0.07252730f, -0.12566872f, 0.01649533f, 
    0.01648951f, 0.09328392f, 0.02508675f, -0.01470558f, 0.00904051f, 0.01149559f, -0.09094040f, -0.04058537f, 
    -0.01949483f, -0.05031793f, 0.02919431f, -0.12249666f, 0.04068327f, 0.07849111f, 0.03220663f, 0.00226269f, 
    -0.04507683f, -0.03930981f, -0.07027712f, -0.06418457f, -0.10538059f, 0.00789635f, -0.04605152f, 0.05117605f, 
    0.05429160f, 0.07542568f, 0.06537516f, -0.12846793f, 0.22776149f, 0.08450497f, 0.11682267f, -0.00051932f, 
    -0.05622585f, 0.13515311f, 0.03408575f, -0.03478639f, -0.07023492f, 0.01599631f, -0.01917975f, 0.02201359f, 
    -0.00627882f, -0.03352508f, -0.01509821f, -0.00765972f, -0.02358723f, -0.00210852f, -0.01978851f, 0.00373823f, 
    0.04216802f, -0.07213400f, -0.13363013f, 0.11010440f, -0.10050692f, -0.22022313f, -0.06798172f, 0.02961508f, 
    0.13472036f, 0.07291738f, -0.00447901f, -0.07858703f, 0.06450065f, 0.03700449f, 0.12430464f, 0.13342229f, 
    -0.01822403f, -0.05605543f, -0.07629747f, -0.07408216f, -0.17086121f, -0.03491268f, -0.04201321f, 0.09152610f, 
    0.03618818f, -0.00879133f, -0.07722589f, -0.01356937f, 0.08168399f, 0.02134904f, -0.05877969f, -0.05914653f, 
    -0.03005464f, 0.07360337f, 0.02325324f, 0.01507365f, -0.03339082f, -0.06159121f, -0.00222725f, -0.02539853f, 
    0.10516351f, -0.31995773f, -0.00913130f, -0.12745570f, 0.17228469f, 0.02713020f, 0.02811246f, -0.06612875f, 
    0.12213298f, -0.04517316f, -0.00890707f, 0.03307842f, -0.04846716f, 0.09876505f, 0.04635856f, 0.00745483f, 
    -0.03752817f, -0.02786100f, -0.12344414f, 0.03530788f, 0.07067679f, -0.00326392f, 0.00034849f, -0.03055840f, 
    -0.06074915f, 0.05267838f, 0.06195293f, -0.04432224f, -0.11141743f, -0.00556604f, -0.00184770f, -0.09153682f, 
    0.03597660f, 0.00959868f, 0.04155662f, 0.06836840f, -0.03081335f, 0.06778152f, -0.03216848f, -0.03272594f, 
    -0.26146904f, 0.10006022f, 0.05358630f, 0.17269354f, -0.04248999f, -0.02540882f, -0.00094472f, 0.02990215f, 
    0.08677451f, -0.03011786f, -0.08680235f, 0.00264228f, 0.02322189f, 0.02855915f, -0.05873858f, -0.00738894f, 
    -0.02276621f, -0.06122497f, -0.12057744f, -0.05249082f, -0.03254296f, -0.11878631f, -0.09845916f, -0.25625974f, 
    0.10284875f, -0.11772529f, 0.04603374f, 0.06249553f, 0.07861556f, -0.09807943f, 0.11124747f, -0.14205875f, 
    -0.13871704f, -0.01552516f, -0.00534290f, 0.00009785f, -0.00583660f, 0.16544965f, 0.03923160f, 0.08618277f, 
    0.07981529f, -0.18083461f, -0.16260116f, 0.18186827f, -0.14326517f, -0.13119455f, 0.09891146f, -0.02481439f, 
    0.05453239f, 0.01686116f, -0.14145246f, 0.07133138f, 0.13855480f, 0.02681307f, 0.11028524f, -0.08050545f, 
    -0.00281382f, 0.01262753f, -0.06965038f, -0.05325764f, -0.01935165f, 0.15689006f, 0.06580681f, 0.12348672f, 
    -0.08685176f, -0.03438000f, -0.10316877f, -0.05173981f, 0.02604084f, 0.01656631f, 0.06295923f, 0.05110206f, 
    -0.04019007f, 0.00602867f, -0.09685015f, -0.00340573f, -0.07434954f, -0.09229802f, -0.11843251f, -0.13831255f, 
    0.03208131f, -0.07259599f, -0.09423193f, -0.19175708f, 0.08282849f, 0.10071889f, 0.03089748f, 0.02187039f, 
    -0.09871799f, -0.02310232f, -0.01299621f, 0.05522776f, 0.05019596f, 0.00081012f, -0.10462089f, 0.03800249f, 
    0.00129036f, 0.05753206f, 0.11443351f, 0.05365350f, 0.00860540f, 0.09659495f, -0.07883371f, -0.06653504f, 
    -0.04933013f, 0.04561821f, 0.11533865f, 0.07365238f, -0.01061096f, -0.00972426f, -0.00667182f, -0.04929348f, 
    -0.01560125f, -0.04592600f, -0.05902101f, -0.00853854f, -0.04394315f, 0.09661197f, 0.04281183f, 0.04528258f, 
    0.08849519f, -0.19399814f, -0.02538667f, -0.03749785f, 0.12287902f, 0.09281867f, -0.03918029f, 0.04914219f, 
    0.07597301f, -0.08759190f, 0.01270902f, -0.02552436f, 0.05072173f, 0.01671313f, -0.08199778f, 0.03634683f, 
    -0.00509900f, -0.03014010f, -0.08314736f, 0.11698918f, 0.00231444f, -0.12219784f, -0.15984082f, -0.03868926f, 
    -0.03379351f, -0.00633093f, 0.05895910f, 0.08027543f, -0.02672049f, -0.11744305f, -0.19100444f, -0.09442186f, 
    0.00808392f, -0.11250339f, 0.05231910f, 0.02310542f, -0.01991553f, 0.06849851f, 0.07823471f, 0.03259363f, 
    0.04486106f, -0.17630018f, -0.11705098f, -0.14630300f, 0.11073953f, -0.06910850f, 0.02612905f, -0.01142799f, 
    0.01274884f, -0.03971616f, 0.05076763f, -0.03593732f, -0.09673105f, -0.02674622f, 0.01405602f, 0.02370187f, 
    0.03617432f, 0.10713024f, -0.04563369f, 0.06095711f, -0.26194859f, 0.21078807f, 0.04301308f, 0.01050428f, 
    0.15886705f, -0.02573127f, 0.00043669f, 0.05758123f, 0.06633657f, 0.09177848f, -0.05342250f, -0.01587120f, 
    -0.02852187f, 0.01149649f, 0.13786601f, -0.02999269f, 0.02575957f, 0.04327482f, 0.13072176f, 0.02596133f, 
    0.37859032f, 0.03875288f, 0.22224419f, 0.06638411f, 0.01713501f, 0.02387092f, -0.02998000f, 0.03775847f, 
    -0.03102581f, -0.09517501f, -0.00412307f, 0.03831095f, 0.10013967f, 0.03084749f, 0.02793853f, 0.05667529f, 
    0.05842680f, -0.01570116f, 0.06674680f, -0.07210057f, -0.04084760f, 0.02096212f, -0.04088848f, -0.15157960f, 
    -0.10092504f, 0.04908879f, -0.00649596f, 0.04782117f, -0.07215036f, 0.02825735f, 0.01111898f, -0.02053998f, 
    -0.05510220f, -0.05056839f, -0.11395716f, 0.01470067f, -0.15243183f, 0.14291303f, 0.05785991f, 0.07811026f, 
    0.03347258f, 0.00972571f, 0.03121120f, 0.13445608f, 0.10234772f, -0.01778815f, 0.03772708f, -0.03991529f, 
    0.01608209f, 0.03484200f, 0.03795574f, 0.02746068f, -0.00410022f, 0.08515184f, 0.03836836f, -0.03210572f, 
    -0.02946201f, 0.02126283f, 0.01129023f, 0.00083440f, 0.12438232f, 0.09649186f, -0.06554352f, -0.08042707f, 
    -0.00028068f, -0.06438128f, 0.03294235f, -0.02127040f, -0.08216914f, -0.00386863f, 0.04263446f, -0.05707610f, 
    -0.03686356f, -0.04671212f, -0.06838094f, -0.12744787f, -0.07912523f, 0.04380267f, -0.02666106f, 0.04842343f, 
    -0.14755122f, 0.00204904f, -0.10724869f, 0.14666355f, 0.10613662f, -0.03011964f, -0.00180387f, 0.03055905f, 
    0.10126383f, -0.00687896f, 0.00176311f, 0.03543027f, 0.06893254f, -0.09193797f, -0.01224967f, -0.05431522f, 
    -0.00378952f, -0.11824550f, -0.09315933f, -0.04562787f, 0.12816747f, -0.40491351f, -0.00809089f, -0.15681997f, 
    -0.01588694f, -0.02628038f, 0.00648904f, -0.06600095f, -0.00745571f, 0.00630042f, 0.03309024f, 0.03299816f, 
    0.05911856f, 0.13514757f, 0.00480201f, -0.03563249f, 0.05612328f, -0.07787631f, -0.03633754f, 0.03583779f, 
    0.13314456f, 0.01311001f, 0.00901812f, -0.15772758f, 0.04652976f, 0.05668418f, 0.01689552f, 0.03164965f, 
    0.03209633f, 0.10785690f, 0.00433902f, 0.09849843f, -0.01317607f, -0.11733013f, 0.02199853f, -0.01571781f, 
    -0.02348948f, 0.04256568f, 0.09727053f, 0.02907294f, 0.03936369f, -0.34421754f, -0.00144451f, -0.23170695f, 
    0.03997805f, 0.00898201f, -0.00170001f, 0.01809985f, -0.09600669f, 0.01129688f, 0.01319781f, -0.05038519f, 
    0.13103035f, 0.04184720f, 0.01670261f, -0.04741668f, -0.00679964f, -0.02258844f, -0.03609373f, 0.09918568f, 
    -0.28998110f, 0.15246028f, -0.03825233f, 0.25271204f, 0.06879358f, 0.12442543f, -0.01761446f, -0.02177752f, 
    -0.01823529f, -0.02790795f, 0.07528882f, 0.03043471f, -0.04404164f, -0.06212030f, -0.11823992f, 0.02212482f, 
    0.02335905f, -0.10828604f, -0.01813653f, 0.02751595f, -0.06371442f, -0.15950055f, 0.03964951f, -0.19794038f, 
    0.05331421f, -0.07342823f, -0.03856358f, -0.04025453f, 0.04698979f, 0.06212096f, -0.09926752f, 0.01280761f, 
    0.00664047f, 0.05035739f, 0.04789917f, -0.13067777f, 0.01446088f, -0.02440190f, -0.03379408f, -0.04408180f, 
    0.09627240f, -0.39689729f, -0.05743765f, 0.19019862f, 0.14936832f, 0.02338362f, -0.00061625f, 0.03414008f, 
    0.00244331f, 0.00612541f, -0.01063533f, 0.05300212f, -0.01982712f, -0.08207417f, 0.05706394f, -0.04527251f, 
    -0.02128678f, 0.09175683f, 0.04834151f, 0.02937049f, -0.00432142f, 0.17659454f, -0.06356891f, 0.07082038f, 
    -0.06131176f, -0.02925883f, 0.07205029f, 0.07495913f, 0.08038921f, 0.03304749f, 0.08146270f, -0.04346123f, 
    -0.03890767f, 0.00278969f, -0.09561603f, 0.04069521f, -0.01131877f, 0.01009321f, -0.11344432f, 0.07111886f, 
    -0.23102985f, -0.02038414f, 0.09368575f, -0.01299299f, 0.01759628f, 0.03790981f, -0.11036352f, 0.10762429f, 
    -0.05506559f, -0.06477940f, -0.00791668f, -0.01128314f, 0.09729556f, 0.02601753f, 0.04443235f, 0.11257068f, 
    -0.04210029f, -0.07312267f, 0.05842173f, 0.03383373f, -0.14546850f, -0.05504235f, -0.00908665f, -0.01226441f, 
    0.08687189f, 0.01597443f, 0.11024217f, -0.07967423f, 0.00106369f, 0.07835545f, -0.03133284f, 0.00802779f, 
    0.01918205f, 0.02121749f, -0.15529940f, 0.05975455f, 0.05712974f, 0.13966767f, 0.00296678f, -0.04659693f, 
    -0.02552698f, 0.03789858f, 0.09900347f, 0.09567494f, 0.12502703f, 0.06590746f, -0.01930386f, -0.01434053f, 
    0.01043774f, 0.01665814f, -0.02519442f, 0.00801944f, 0.00108708f, -0.07973055f, -0.00753049f, -0.02975608f, 
    -0.08036267f, -0.05152096f, 0.00804848f, -0.06280655f, 0.06232666f, 0.08250616f, 0.15273798f, 0.02802386f, 
    0.13493101f, 0.07765602f, 0.08615971f, -0.03863812f, -0.05909643f, -0.02068584f, -0.02693423f, -0.00755684f, 
    -0.07859598f, -0.05996997f, -0.04838405f, -0.00475399f, -0.03645358f, -0.02023319f, 0.07842521f, 0.03420180f, 
    0.05054288f, 0.09354661f, 0.00384376f, -0.04170103f, -0.02187241f, -0.05163430f, 0.01725722f, 0.02399495f, 
    0.00728712f, 0.01113397f, -0.02176656f, 0.04398336f, -0.02819066f, -0.00003681f, 0.01446543f, -0.02541199f, 
    -0.00130060f, -0.04713203f, -0.02870280f, 0.01096502f, 0.11588547f, 0.17260611f, -0.13257851f, 0.01721458f, 
    -0.07838831f, -0.02358101f, -0.02620020f, 0.00641732f, -0.01164481f, -0.03382545f, -0.00935682f, 0.04934252f, 
    0.03290623f, 0.05072789f, -0.03348783f, 0.01993492f, -0.06595998f, -0.01890091f, -0.03697116f, -0.00170515f, 
    -0.27531540f, 0.15972391f, -0.12988402f, -0.04935470f, -0.09390756f, -0.12002340f, 0.02495495f, -0.02661412f, 
    -0.05922002f, -0.04800086f, -0.00673219f, -0.01789771f, -0.09415115f, 0.03050774f, -0.10562484f, 0.01644562f, 
    -0.01048889f, -0.01009711f, -0.00034401f, 0.00672726f, 0.08550441f, 0.02888956f, 0.18080121f, -0.05380472f, 
    0.06674744f, 0.05025798f, 0.05587527f, 0.06004257f, 0.05150197f, -0.01011292f, -0.04542548f, -0.00844365f, 
    -0.02158465f, 0.00859976f, -0.00013761f, 0.00752924f, 0.08174429f, -0.03114767f, 0.01045556f, 0.00306783f, 
    -0.03095797f, 0.08538087f, 0.14355676f, 0.08006248f, 0.11533394f, 0.06364047f, 0.01225783f, 0.03894669f, 
    0.00777743f, -0.03079028f, -0.01625948f, 0.03908892f, -0.00658601f, -0.06825162f, -0.02641665f, -0.01549572f, 
    -0.01039664f, 0.02989145f, -0.00045943f, -0.02887977f, 0.05100954f, 0.04179358f, 0.16176203f, 0.02642167f, 
    0.03339032f, 0.05794669f, -0.02660722f, -0.00826085f, 0.01969639f, -0.01683681f, -0.04454994f, 0.01497686f, 
    0.01869222f, -0.00895836f, -0.05520140f, -0.00964401f, -0.05200143f, 0.01136781f, 0.00153881f, -0.02492460f, 
    -0.02285652f, -0.28177947f, -0.13639107f, 0.00832274f, 0.02288347f, 0.00656407f, -0.11006705f, -0.01547474f, 
    0.00636020f, -0.03130087f, -0.08438636f, 0.02290627f, -0.03856844f, -0.02684467f, -0.00424417f, -0.02570354f, 
    0.04163470f, -0.03547646f, 0.03941175f, -0.00693604f, -0.11558495f, -0.08621341f, -0.10090023f, -0.07066743f, 
    -0.07440281f, -0.03259826f, -0.02503468f, -0.02997172f, 0.00288900f, -0.03431719f, -0.02180595f, -0.04283274f, 
    -0.00701711f, -0.08218496f, -0.00651137f, -0.03313205f, -0.00319220f, -0.05833473f, -0.03626319f, -0.02965109f, 
    0.04130935f, 0.05446957f, -0.19222857f, 0.03291884f, 0.19453309f, -0.09923191f, -0.09468452f, -0.05646371f, 
    -0.01892954f, 0.01186824f, -0.02678485f, 0.01039864f, -0.00360973f, 0.04460233f, -0.01778665f, -0.02543337f, 
    -0.03842651f, 0.02675930f, -0.06027419f, 0.08146039f, -0.17048660f, 0.25124526f, 0.03622444f, -0.00432697f, 
    0.05313911f, 0.00607896f, -0.05781484f, -0.08385725f, 0.03831694f, -0.03936879f, -0.07977930f, 0.06231522f, 
    0.02716289f, -0.02604397f, -0.07748400f, 0.05760223f, 0.00742259f, 0.04913294f, 0.01128972f, -0.05951805f, 
    0.18686506f, -0.22235224f, 0.06640525f, -0.03702435f, -0.03321541f, 0.03725451f, 0.08286116f, -0.02161325f, 
    -0.03527252f, -0.02878936f, -0.03804532f, -0.03711663f, -0.04288874f, 0.06093765f, -0.03570775f, -0.03754725f, 
    0.09835544f, 0.00653308f, 0.03063752f, -0.03020572f, 0.00071643f, 0.03631532f, 0.14851336f, 0.11357669f, 
    0.13991106f, -0.02695616f, 0.08756377f, 0.01406607f, -0.01636937f, 0.01266262f, -0.07461022f, 0.03522748f, 
    -0.05425845f, -0.05216123f, -0.04924573f, 0.03270154f, -0.01281948f, -0.04584252f, -0.07073593f, 0.00944338f, 
    -0.11823833f, 0.03679781f, -0.30243546f, 0.06584265f, 0.14331098f, -0.03359519f, -0.07366814f, -0.10711417f, 
    0.03265653f, -0.05159134f, -0.09762519f, 0.08771814f, -0.07448345f, 0.00301751f, -0.10885193f, -0.01910091f, 
    -0.08463567f, -0.08732495f, -0.03183794f, -0.00771051f, -0.01192337f, -0.13248503f, 0.04594362f, 0.04680673f, 
    0.07847845f, 0.03034510f, -0.02412695f, -0.04348039f, 0.02337407f, -0.04826060f, 0.00425958f, -0.04072750f, 
    -0.01923864f, -0.04604002f, -0.02667900f, -0.05016110f, -0.05111963f, 0.01813252f, -0.00449672f, -0.01355989f, 
    -0.11517050f, -0.21896766f, -0.10755840f, -0.13343708f, -0.20107415f, -0.02835930f, -0.02082797f, -0.00185776f, 
    -0.04629345f, -0.07829840f, 0.01447915f, -0.08415237f, -0.05072065f, -0.03503110f, -0.04387444f, 0.00225718f, 
    0.03512331f, -0.00620337f, 0.00268993f, 0.03349328f, -0.16909432f, -0.03794512f, 0.14487202f, 0.11014766f, 
    -0.14205149f, 0.12138683f, -0.09048306f, 0.00711622f, 0.00961289f, 0.03063850f, -0.02525367f, -0.00704770f, 
    -0.05651734f, -0.02001964f, -0.08577316f, 0.05867359f, 0.02947215f, -0.02132976f, -0.05162451f, -0.03327071f, 
    -0.00308198f, 0.11415602f, -0.08604436f, -0.01066827f, 0.11504313f, -0.04505240f, -0.02551376f, -0.08896168f, 
    -0.01114898f, -0.03212709f, -0.02277036f, -0.00558496f, -0.00603812f, -0.03529443f, -0.07853800f, -0.04237293f, 
    -0.00277087f, 0.05396779f, -0.04724501f, -0.00793233f, 0.21526040f, -0.06427969f, 0.07166107f, -0.01436050f, 
    -0.01475568f, -0.07489752f, 0.07915816f, -0.05718805f, -0.09636928f, -0.00476175f, 0.00930225f, 0.04253813f, 
    -0.01978721f, 0.08129762f, -0.01812483f, -0.05973860f, -0.01892041f, 0.00187788f, 0.01840101f, -0.04341073f, 
    0.07155692f, 0.10035143f, 0.08427554f, -0.01710320f, 0.14172383f, -0.03189112f, 0.03450217f, -0.06878892f, 
    0.00226668f, -0.03194758f, -0.00623186f, -0.01097597f, -0.09206641f, -0.03822758f, -0.00438755f, 0.00660685f, 
    -0.02417686f, 0.03510587f, -0.04993551f, -0.04040751f, 0.16127515f, -0.10659777f, 0.06912245f, -0.00331474f, 
    0.14262360f, -0.01679264f, -0.03970179f, 0.02899216f, 0.02620235f, -0.00440527f, -0.06718751f, 0.04955340f, 
    -0.04826351f, 0.04738242f, 0.02286658f, -0.02966367f, 0.02406010f, 0.00193178f, -0.01433399f, -0.02961138f, 
    -0.10181053f, 0.03277263f, -0.07281839f, -0.04127756f, -0.09905761f, -0.01578323f, -0.02680609f, -0.07496603f, 
    0.03935308f, 0.02033558f, -0.07272404f, -0.01949929f, -0.04070222f, -0.05290091f, 0.03181762f, 0.03180363f, 
    -0.06480110f, 0.03388032f, -0.02801406f, 0.01220294f, -0.14550214f, -0.24719504f, -0.11034972f, -0.09466948f, 
    -0.20337950f, 0.00180299f, 0.00120926f, -0.00811483f, 0.00920789f, -0.09047835f, -0.02840150f, -0.02173069f, 
    -0.01686656f, -0.03500096f, -0.00424071f, 0.00555646f, 0.02362685f, 0.00571108f, 0.00949694f, -0.01768137f, 
    -0.03670401f, 0.07376614f, 0.12043595f, 0.03804177f, 0.03470438f, -0.01833332f, 0.08370465f, 0.02449757f, 
    0.01322637f, 0.02026099f, 0.02946312f, -0.00846458f, -0.02065049f, -0.00615560f, -0.05262644f, -0.04908755f, 
    -0.03206464f, -0.02211182f, 0.00300512f, -0.04595548f, 0.09602315f, 0.11864214f, 0.19736908f, -0.05064987f, 
    0.11065980f, 0.07956690f, 0.05658584f, 0.03218120f, 0.01935525f, -0.01531919f, -0.02557272f, 0.03199719f, 
    -0.05933499f, 0.01162716f, -0.02427868f, -0.02396250f, -0.03450983f, -0.00190120f, 0.06242360f, -0.03348548f, 
    -0.01596078f, 0.09511076f, -0.00119551f, -0.04776984f, -0.02595304f, -0.01588541f, -0.07198280f, 0.00055610f, 
    -0.02319328f, -0.07824532f, 0.06669124f, 0.11014146f, -0.04486043f, -0.03420731f, -0.04108711f, 0.00080317f, 
    0.04877570f, 0.00818020f, -0.01569992f, -0.01349651f, 0.07451839f, 0.13382281f, 0.15683684f, 0.18879765f, 
    0.15383285f, 0.11416868f, 0.14097378f, 0.03294618f, 0.03435564f, 0.00285084f, 0.00548566f, -0.01421102f, 
    -0.05039500f, -0.01647481f, -0.10925978f, 0.00885865f, 0.03873518f, 0.03060658f, -0.00734375f, 0.04343010f, 
    0.11920737f, 0.03079294f, 0.15812063f, -0.00007918f, 0.02966365f, -0.03793043f, 0.00350613f, -0.06377690f, 
    -0.00668467f, -0.00174872f, 0.03809419f, 0.04410692f, 0.01142020f, 0.01359563f, -0.02497904f, 0.02059507f, 
    -0.00861589f, 0.03294393f, 0.01631539f, -0.08275180f, -0.27700973f, -0.01197415f, -0.18877123f, -0.14602812f, 
    -0.03360860f, 0.01411125f, -0.08015041f, -0.03659122f, 0.00029509f, -0.02997825f, -0.03856829f, 0.01790387f, 
    0.02961923f, -0.00994311f, -0.01454259f, 0.00085135f, 0.00450238f, 0.02371404f, -0.00404255f, 0.02814859f, 
    0.00742108f, 0.15467201f, -0.10506661f, 0.00292806f, 0.05680020f, -0.06411443f, 0.01841751f, -0.05918616f, 
    -0.02712180f, 0.00937420f, -0.05908102f, -0.02866105f, -0.01795365f, -0.04559078f, -0.02843865f, 0.02299745f, 
    0.00985794f, 0.08839454f, -0.01617499f, -0.02951667f, 0.09906065f, 0.15706253f, -0.05141616f, 0.05730273f, 
    0.11703460f, -0.07730972f, 0.03514569f, -0.06355394f, 0.00199348f, 0.00597817f, -0.04091468f, 0.00952286f, 
    0.02740274f, 0.00790263f, -0.01147906f, -0.05931906f, 0.01027975f, 0.01556027f, -0.05144444f, 0.01167647f, 
    -0.15882406f, 0.07009632f, -0.08256054f, -0.05823581f, -0.08679308f, 0.00156104f, -0.04226411f, -0.12156630f, 
    0.01594800f, 0.00414532f, -0.07699520f, 0.02108332f, 0.00453402f, -0.05085700f, -0.03800495f, -0.06444243f, 
    -0.01686484f, -0.03146802f, 0.04076850f, 0.05814989f, -0.03897699f, 0.00069406f, 0.05892837f, -0.05753994f, 
    -0.02377195f, -0.09577598f, -0.01505354f, -0.03499495f, -0.05301448f, -0.04526623f, 0.02012079f, 0.01183912f, 
    -0.06945448f, -0.02693157f, -0.03672574f, -0.01513616f, -0.00290417f, 0.02715349f, -0.01552539f, -0.00692724f, 
    0.10362539f, -0.21557735f, 0.00527248f, 0.00809041f, 0.02093434f, 0.00317434f, 0.01081038f, -0.06395973f, 
    0.02665358f, -0.05791338f, 0.02859153f, 0.05074081f, 0.03243373f, 0.01202820f, -0.01415091f, -0.09835823f, 
    0.00055022f, -0.04698965f, 0.07698715f, -0.02037002f, 0.20738922f, -0.18540044f, 0.03550198f, -0.01977389f, 
    0.10232495f, -0.08955736f, -0.03284587f, -0.00953981f, 0.00284395f, -0.00917414f, 0.00286860f, -0.03027274f, 
    -0.00179604f, 0.04013639f, -0.03692116f, -0.02744780f, 0.05116854f, 0.01531213f, -0.00570879f, 0.02056995f, 
    0.11744323f, 0.02222792f, -0.02259177f, 0.01993642f, -0.08163974f, 0.00085986f, -0.03391136f, 0.01184620f, 
    -0.06113077f, -0.07515781f, 0.05062566f, 0.00529122f, 0.05191830f, 0.00478788f, -0.10716041f, 0.04037991f, 
    0.03933953f, 0.00593513f, -0.01697456f, -0.06430253f, -0.12128822f, -0.11354154f, -0.07163842f, -0.01445500f, 
    -0.08615149f, -0.05376466f, -0.01508606f, 0.00302385f, -0.01652999f, -0.05030986f, 0.00955511f, -0.04307998f, 
    -0.05160222f, -0.00328743f, -0.05013700f, 0.01818365f, -0.04794504f, -0.03324399f, -0.06093831f, -0.01038299f, 
    -0.04868657f, 0.04092762f, 0.14280902f, -0.04359308f, 0.06372006f, -0.13874188f, 0.09557834f, -0.04137785f, 
    0.02406994f, 0.03502160f, 0.01166911f, 0.07687611f, -0.06817885f, 0.00913647f, -0.00466109f, -0.03458229f, 
    0.04291374f, 0.02396423f, -0.00164487f, -0.03900863f, 0.07786568f, -0.06976373f, -0.04718058f, -0.02209063f, 
    0.02032429f, -0.08048021f, 0.01768124f, -0.00581373f, -0.00495460f, -0.03493309f, -0.01247927f, -0.04918308f, 
    -0.02654979f, -0.01639587f, -0.00923710f, -0.05704484f, 0.01218669f, -0.00960466f, -0.00957814f, -0.02645100f, 
    -0.03456433f, -0.03631337f, -0.04727056f, -0.09119693f, -0.06436074f, -0.06163487f, 0.03118402f, -0.04919053f, 
    -0.01606901f, -0.03072228f, -0.03290838f, -0.01375953f, -0.01425072f, -0.04099796f, -0.03467228f, 0.01012205f, 
    0.03954575f, 0.00252179f, -0.03471758f, -0.01502402f, 0.02250004f, 0.07279535f, 0.04561866f, 0.08784747f, 
    0.20310485f, -0.06649506f, 0.08158971f, -0.05105767f, 0.01570998f, -0.00804398f, 0.01156225f, 0.05020562f, 
    -0.09675295f, -0.06444336f, -0.01533744f, -0.01338937f, -0.04140604f, 0.10614246f, -0.07463647f, -0.04455362f, 
    -0.21829146f, 0.04951765f, 0.10964742f, -0.00802036f, -0.14464419f, 0.03375788f, -0.05516529f, -0.02030797f, 
    0.05165009f, -0.06139925f, -0.02943354f, -0.01410666f, -0.01169852f, 0.03294888f, 0.07345121f, 0.04950219f, 
    -0.05423577f, 0.02541225f, -0.01781703f, -0.03820608f, -0.06515370f, -0.14766824f, 0.00435330f, -0.14204204f, 
    -0.15448320f, 0.04496353f, -0.01400217f, -0.01716701f, -0.03090105f, -0.07733657f, -0.01872545f, -0.07018279f, 
    -0.03507569f, -0.03417824f, -0.05054838f, -0.03110350f, 0.04232136f, -0.01387116f, -0.01639638f, 0.05591095f, 
    0.04854438f, -0.19992575f, 0.05722647f, 0.04937465f, 0.04624037f, 0.05142405f, -0.02666365f, -0.02642069f, 
    0.01550058f, -0.00166680f, -0.01330339f, -0.02639829f, -0.01331894f, 0.00859708f, 0.00031302f, -0.01772378f, 
    -0.00904252f, 0.01265035f, 0.01806265f, -0.00753136f, -0.03807281f, 0.04201683f, -0.12696740f, 0.02591631f, 
    0.06999100f, -0.04288116f, -0.08369173f, -0.04235047f, -0.03491477f, 0.00042466f, -0.03006651f, 0.05831419f, 
    -0.00837098f, -0.05174777f, -0.03883940f, -0.02954072f, -0.04239269f, -0.01691959f, -0.03176922f, -0.00832619f, 
    0.10925953f, -0.01844084f, 0.12937807f, -0.05653459f, 0.02859293f, -0.01726498f, 0.02891483f, 0.01396420f, 
    -0.01341779f, 0.02253161f, 0.02666731f, 0.03505556f, 0.00351182f, -0.01966635f, -0.00013249f, 0.05370728f, 
    -0.01158096f, 0.01339549f, 0.01244007f, -0.04590027f, 0.06792190f, 0.08342877f, -0.10742589f, 0.04904315f, 
    -0.04415269f, 0.05931915f, -0.01342679f, 0.00120489f, 0.07664151f, 0.01882565f, -0.04798388f, 0.04047067f, 
    -0.02196462f, -0.03151029f, 0.08201274f, -0.04541491f, -0.05218343f, 0.04960684f, -0.00088312f, -0.08343484f, 
    0.03004221f, 0.08587606f, -0.08191366f, -0.02281238f, 0.10464409f, -0.08545415f, 0.01254486f, -0.06843984f, 
    -0.02653947f, -0.00920269f, -0.01610629f, 0.03669395f, -0.10163562f, -0.04096824f, -0.05683417f, -0.02888034f, 
    -0.03681255f, 0.06804912f, -0.02889201f, -0.03437651f, 0.03044509f, 0.08823620f, -0.21974596f, -0.10647209f, 
    0.07778670f, -0.05376289f, -0.04083165f, -0.06674141f, 0.02382617f, -0.04430246f, -0.11978144f, 0.07877691f, 
    -0.02767156f, 0.01752108f, -0.05011651f, -0.00284653f, -0.11246752f, -0.06219506f, -0.02169518f, 0.00363536f, 
    0.23109692f, -0.25521496f, -0.00974081f, -0.08944797f, 0.09797837f, -0.13023727f, -0.02387501f, 0.00648035f, 
    -0.02879327f, -0.02019600f, 0.01911307f, -0.02954547f, -0.06238233f, 0.02602738f, -0.04991765f, -0.04939399f, 
    0.05787788f, 0.00792956f, 0.00457564f, 0.00729322f, -0.03727293f, -0.00263339f, -0.10667822f, 0.02462222f, 
    0.09230947f, 0.00515946f, -0.03412386f, -0.07483327f, 0.02077288f, -0.00434722f, -0.03050693f, 0.02222606f, 
    -0.05469056f, -0.08506852f, -0.06322099f, -0.00355375f, -0.04711328f, 0.00536812f, -0.01232103f, -0.01464485f, 
    -0.17547499f, 0.10608620f, 0.02891204f, 0.04740297f, 0.03208829f, 0.03527306f, -0.08881988f, -0.02976077f, 
    0.02115860f, -0.01555426f, 0.03176447f, -0.03991592f, 0.02577001f, -0.03616803f, -0.03403762f, -0.01819642f, 
    -0.03154745f, 0.04727705f, 0.00466941f, -0.04323698f, 0.08823059f, 0.10378642f, 0.15183349f, -0.01402210f, 
    0.09200110f, -0.15201096f, 0.01223080f, -0.00789471f, -0.00359106f, 0.01064282f, 0.03429366f, 0.02641412f, 
    -0.08166868f, -0.00601220f, -0.01028567f, 0.00836078f, -0.03747100f, 0.00276125f, 0.07240739f, 0.00494722f, 
    -0.14043367f, 0.00743476f, 0.01974029f, -0.03054565f, -0.12130447f, -0.01024430f, -0.04596254f, -0.04065965f, 
    -0.04046125f, -0.06130705f, 0.01580235f, 0.02807765f, -0.02470415f, -0.03463399f, -0.01281387f, -0.00309838f, 
    -0.04641356f, -0.00907813f, -0.02313045f, -0.04909195f, -0.04908769f, 0.06129643f, 0.17749491f, 0.06115911f, 
    0.09345572f, 0.07538779f, 0.05644983f, 0.05301343f, 0.00282642f, 0.01163272f, -0.00596745f, 0.03515120f, 
    0.03903200f, 0.00062494f, -0.02762196f, -0.07033350f, 0.05897280f, 0.03839699f, 0.00754755f, -0.04251933f, 
    0.09658160f, -0.12494051f, 0.03201701f, 0.09121728f, 0.09082685f, 0.03795485f, -0.04486964f, -0.03309448f, 
    0.00385729f, 0.00217919f, 0.01465340f, -0.01386239f, -0.02474429f, -0.02517509f, -0.02432269f, -0.03622222f, 
    0.04210665f, 0.00030709f, 0.04605366f, -0.03528687f, 0.17492479f, 0.02289026f, 0.22134303f, 0.09147643f, 
    0.08884571f, 0.06936353f, 0.09493369f, -0.00150588f, -0.02254117f, 0.00351176f, 0.01028544f, 0.06514689f, 
    -0.02492872f, 0.03289798f, -0.02598249f, -0.00362204f, -0.01059018f, 0.02670843f, 0.06970291f, -0.05762470f, 
    -0.08437793f, 0.13975281f, -0.01481901f, -0.14007249f, -0.03865671f, 0.05084770f, 0.07627270f, 0.00799333f, 
    -0.01360366f, 0.02595008f, -0.00053422f, -0.01052197f, -0.01434496f, -0.04679325f, -0.03229089f, 0.00419298f, 
    0.00709734f, 0.01539822f, -0.02831426f, 0.06045421f, 0.05421419f, -0.01374922f, 0.17112294f, 0.10114440f, 
    0.09567723f, 0.01010355f, 0.03585424f, 0.01207507f, 0.03080345f, -0.00169937f, 0.01882782f, 0.03115321f, 
    -0.03018924f, 0.01671792f, -0.01864735f, -0.02455433f, -0.01188717f, 0.01637128f, 0.02437872f, -0.06136730f, 
    0.02896679f, -0.06019710f, -0.04235316f, 0.05710370f, 0.19504014f, -0.03203556f, -0.01896997f, -0.09106890f, 
    0.09861094f, 0.02479712f, -0.01425396f, -0.06344546f, -0.03280396f, -0.01845694f, -0.02120876f, -0.00610827f, 
    -0.07202353f, 0.00098472f, 0.02354573f, -0.04114542f, -0.10248316f, 0.07565257f, -0.09785618f, 0.00290241f, 
    -0.09029032f, 0.01981465f, -0.02573821f, -0.02331252f, -0.03243391f, -0.10736163f, -0.05070887f, 0.00238409f, 
    -0.03143924f, 0.02892286f, -0.09155285f, 0.03160169f, -0.02564651f, 0.00456333f, -0.00507730f, -0.04077721f, 
    0.10034709f, -0.04640518f, 0.10359861f, 0.00522724f, -0.03341258f, 0.04833389f, -0.03190642f, 0.00143884f, 
    -0.02396550f, 0.05301534f, 0.00192798f, 0.01045494f, 0.01054527f, -0.03574372f, -0.06262527f, 0.03436773f, 
    0.02714730f, -0.03645039f, -0.01068157f, -0.07924920f, 0.09185695f, 0.05616268f, 0.03940829f, -0.02025686f, 
    0.09747033f, -0.02508773f, 0.04660898f, -0.07762692f, -0.01456301f, -0.04645286f, 0.01191511f, -0.00999896f, 
    0.01164011f, 0.01411466f, -0.03207500f, -0.04991709f, -0.05777355f, 0.07690794f, -0.04488756f, -0.03392375f, 
    -0.09571571f, -0.07589396f, 0.12620212f, 0.03480769f, 0.11627640f, -0.05597512f, -0.04013169f, 0.00641682f, 
    -0.05264853f, -0.01977566f, -0.01621315f, -0.03974811f, 0.04955526f, -0.01562299f, 0.02148496f, -0.03964040f, 
    0.00041211f, 0.09312828f, -0.04916409f, 0.04450853f, -0.12078296f, -0.02521621f, 0.12083539f, -0.20192547f, 
    -0.19933580f, 0.04813348f, 0.02782346f, -0.04555457f, -0.02117093f, -0.08460166f, 0.02194939f, 0.01726941f, 
    -0.02559054f, -0.01123603f, -0.03215509f, -0.08838990f, -0.00431235f, -0.00720845f, -0.25775728f, -0.02974917f, 
    0.02554405f, 0.05049175f, 0.03482003f, -0.08989763f, -0.04598040f, -0.02874076f, 0.00997621f, 0.01738038f, 
    0.00531689f, -0.05789732f, 0.01059902f, 0.00632238f, -0.00515167f, -0.10664424f, 0.04510863f, -0.00875127f, 
    0.02113682f, 0.01463294f, 0.04036787f, -0.12184425f, -0.05015947f, 0.04439048f, 0.01719961f, -0.09014297f, 
    0.01048801f, 0.01636377f, -0.02875839f, -0.11974482f, 0.05780376f, -0.06678095f, 0.08664304f, 0.00261982f, 
    0.03948284f, -0.09287475f, 0.07888461f, -0.10448638f, 0.03586051f, -0.01328584f, -0.01008093f, -0.08432675f, 
    0.21210223f, 0.13285942f, -0.05031923f, 0.09095046f, -0.01437453f, -0.02039187f, 0.02186038f, -0.03344781f, 
    -0.05331624f, -0.01236927f, 0.02234054f, -0.03193101f, 0.00621373f, -0.01540612f, -0.00886720f, 0.01018023f, 
    -0.07575487f, -0.02014252f, 0.14429946f, -0.12306876f, 0.01552226f, -0.12559132f, -0.03340831f, -0.05267560f, 
    -0.18456340f, -0.08027124f, -0.01506892f, -0.00811344f, -0.05244302f, 0.02568954f, 0.00493030f, -0.01549413f, 
    -0.02084341f, 0.04675655f, 0.04436487f, 0.01231958f, -0.08811898f, -0.04105318f, 0.07790472f, 0.02603159f, 
    -0.13084127f, -0.08337384f, 0.09845684f, -0.08758570f, -0.15584202f, -0.00168928f, 0.01272054f, 0.00383667f, 
    0.02170272f, -0.01570832f, 0.02491848f, 0.03026420f, 0.00622801f, 0.02103428f, 0.00753223f, -0.04609944f, 
    -0.00700724f, -0.07028847f, -0.02946202f, 0.00486408f, -0.09164117f, -0.04038366f, 0.00687005f, 0.08188447f, 
    -0.07809111f, -0.00953330f, 0.02106065f, -0.06857821f, -0.05378297f, -0.06133310f, 0.03156109f, -0.02474827f, 
    -0.02141191f, 0.06471631f, 0.03129015f, 0.02296537f, -0.02299755f, -0.04035843f, 0.00039144f, 0.01474484f, 
    -0.08307666f, -0.16915831f, -0.12131503f, -0.08388466f, 0.15691739f, 0.00808846f, 0.00584083f, 0.00857968f, 
    0.00008254f, 0.03365258f, 0.07154988f, 0.01532496f, -0.01710603f, 0.06133588f, 0.06106776f, -0.00500791f, 
    0.01677693f, 0.05029308f, -0.01322168f, -0.07607379f, 0.10408453f, 0.00832986f, -0.20625660f, 0.06542216f, 
    0.03616686f, 0.00736358f, 0.01424043f, -0.04694998f, -0.04002295f, -0.00947242f, 0.00547619f, 0.00405635f, 
    0.03979136f, -0.00869780f, -0.00556600f, -0.07024802f, -0.02525645f, -0.03891556f, 0.07642315f, -0.06042783f, 
    -0.05992429f, -0.05701364f, -0.09040526f, -0.16512522f, -0.00284609f, 0.09048453f, -0.02001781f, -0.06438093f, 
    -0.05666591f, -0.03309805f, -0.03426487f, 0.04348549f, -0.01183997f, 0.04002130f, -0.07238647f, 0.03744597f, 
    0.10028853f, 0.00428606f, -0.16533610f, -0.03057732f, 0.01733416f, 0.12797765f, -0.18111983f, 0.12189233f, 
    0.00940235f, 0.00216789f, 0.01598129f, -0.17414992f, -0.03722297f, -0.03181356f, 0.08473272f, -0.02175142f, 
    0.04330425f, -0.06419899f, 0.10672514f, 0.00183451f, 0.00387965f, -0.06038046f, 0.17941953f, -0.08139028f, 
    0.12520580f, -0.16576424f, 0.08186258f, 0.01430541f, 0.04277310f, -0.01886940f, 0.03263072f, 0.02607699f, 
    -0.08060180f, 0.01508604f, -0.03508832f, 0.02457997f, 0.01370870f, 0.00775018f, 0.00809729f, 0.00232964f, 
    -0.02418817f, -0.00126691f, 0.06092533f, 0.07904143f, -0.12663499f, -0.05125449f, 0.19299787f, -0.11167528f, 
    -0.07866694f, 0.01102387f, 0.00290796f, -0.04551182f, 0.02853479f, -0.00002186f, -0.03202937f, 0.04609424f, 
    0.02372606f, -0.04054994f, -0.03322385f, -0.05490009f, 0.02264708f, -0.05672285f, 0.01995119f, -0.08678665f, 
    -0.11452422f, 0.00904224f, 0.10455173f, 0.04870856f, 0.06994764f, 0.04383330f, 0.08291737f, -0.06276926f, 
    -0.07910199f, -0.02773625f, 0.03536347f, 0.00306759f, 0.07417013f, -0.05531871f, -0.09071375f, -0.09346047f, 
    0.09415566f, 0.06203626f, -0.00141769f, -0.13915224f, -0.00576179f, -0.03938279f, 0.09130105f, 0.03416080f, 
    0.13705824f, -0.03100600f, -0.04328451f, -0.02875817f, -0.07537878f, -0.03390793f, -0.01588647f, -0.03033127f, 
    0.00209912f, -0.06108401f, 0.00574379f, 0.02621872f, -0.05663150f, 0.03477914f, 0.02190387f, 0.03486457f, 
    0.07865633f, 0.03044152f, -0.02724978f, 0.10585864f, 0.16220945f, 0.07080912f, 0.06427729f, -0.06234391f, 
    -0.05658171f, -0.04431285f, -0.00119251f, 0.01452490f, -0.01025352f, -0.07669631f, -0.02674859f, -0.07144156f, 
    -0.02323607f, 0.04065078f, 0.06959853f, -0.01956265f, -0.08501053f, 0.11649860f, -0.02418941f, 0.01987194f, 
    -0.01818552f, -0.00063956f, -0.01910234f, -0.17694101f, -0.04428211f, 0.03780604f, -0.03768845f, 0.01369465f, 
    0.04201658f, -0.07479911f, -0.00865982f, -0.01491032f, 0.01624381f, -0.06744853f, 0.06989723f, -0.00461093f, 
    -0.10977113f, 0.03283282f, -0.05498303f, -0.14043449f, -0.17461692f, -0.07930645f, -0.04106106f, -0.05816974f, 
    0.03925699f, -0.08471314f, 0.07470851f, 0.02449448f, 0.02289599f, -0.02962722f, -0.00033705f, 0.02480548f, 
    0.03384729f, -0.07901265f, -0.02406764f, 0.02956049f, 0.03090356f, -0.00956444f, 0.02679834f, 0.03759318f, 
    0.10878152f, -0.03851033f, 0.03493410f, 0.05469771f, -0.07294697f, 0.06373198f, 0.07031047f, 0.01180102f, 
    -0.00648139f, 0.07969155f, -0.00946032f, 0.06391632f, 0.01037217f, -0.02879708f, 0.00772711f, 0.03905833f, 
    -0.19487490f, 0.09733339f, -0.06026086f, -0.21914774f, -0.17083730f, -0.00530835f, -0.02795226f, -0.02555832f, 
    0.02100636f, -0.03067629f, 0.05507503f, 0.01680348f, -0.08792230f, 0.04312596f, 0.00205148f, -0.04961694f, 
    0.02903921f, -0.08944381f, -0.02269353f, 0.03552435f, -0.15900449f, -0.10330380f, 0.00152763f, -0.17173670f, 
    -0.10879970f, 0.02295565f, 0.01991954f, -0.01305329f, -0.04458416f, 0.00881635f, 0.03897488f, -0.02006452f, 
    0.03412250f, 0.01806149f, 0.01736908f, -0.05272473f, -0.00969795f, 0.04069966f, -0.12562554f, 0.00205662f, 
    -0.08359213f, 0.16731510f, -0.03015312f, -0.04812635f, -0.05648119f, -0.01159225f, 0.03794596f, -0.06409454f, 
    -0.03857703f, -0.03292652f, 0.09489743f, 0.06964404f, 0.03566410f, 0.02353437f, -0.00290413f, -0.11949261f, 
    0.01123225f, 0.06348114f, 0.02147822f, -0.08083987f, 0.07019107f, -0.03775505f, -0.22217038f, 0.08113108f, 
    0.07941618f, 0.09497853f, 0.04781410f, 0.00891256f, -0.02645600f, -0.03295749f, -0.04795388f, -0.03503197f, 
    0.01639639f, 0.03074659f, 0.00840857f, -0.01491293f, 0.00632657f, 0.01447022f, 0.04536399f, -0.04503488f, 
    -0.00497745f, -0.05255418f, 0.07091096f, -0.00658925f, 0.04753689f, -0.04308579f, -0.05456026f, -0.00461532f, 
    -0.03132481f, 0.01920931f, 0.02581191f, -0.02927202f, -0.03784893f, -0.06519733f, 0.03473221f, 0.00500324f, 
    -0.04123523f, -0.03419270f, 0.03661911f, -0.01593545f, -0.14427836f, 0.05211768f, 0.18250638f, -0.13829441f, 
    -0.09098098f, 0.01592031f, -0.03039266f, 0.02295613f, -0.07581698f, -0.00716159f, 0.05215206f, -0.05420380f, 
    -0.01628267f, -0.03437253f, -0.02993962f, -0.03514837f, -0.05523110f, -0.02080061f, -0.12136905f, -0.02218165f, 
    0.15430254f, 0.02408812f, -0.17431195f, 0.04806750f, 0.06582285f, 0.00258137f, 0.00336716f, -0.05527574f, 
    -0.07111046f, 0.02127634f, -0.01175873f, 0.04334393f, -0.01408114f, -0.03222487f, -0.02347052f, -0.00240538f, 
    -0.01686232f, -0.00091875f, 0.09815171f, 0.04092721f, -0.07473326f, -0.14677602f, 0.07724404f, -0.15294340f, 
    -0.17386848f, 0.02640962f, 0.05238871f, -0.00723195f, -0.05177908f, -0.03543069f, 0.02442811f, 0.04174246f, 
    -0.02015899f, 0.05479756f, -0.00247773f, -0.04806930f, 0.06607129f, 0.00204677f, -0.13749242f, -0.06545685f, 
    -0.09169509f, 0.08391778f, 0.13181594f, -0.01639142f, 0.03098427f, -0.04080595f, -0.00480041f, 0.01092644f, 
    0.00663462f, -0.06651562f, 0.01083930f, 0.00829585f, 0.05618138f, 0.09636255f, 0.02442302f, -0.02643060f, 
    -0.02074613f, 0.00533493f, -0.02806347f, 0.02316565f, 0.09522232f, 0.02442756f, -0.09868693f, 0.04223186f, 
    0.12072978f, 0.06657444f, 0.05800412f, -0.05965745f, -0.04915111f, -0.04812841f, 0.06803734f, 0.00017153f, 
    0.05661620f, -0.00062461f, 0.06862607f, -0.04629127f, 0.05261315f, 0.03060682f, 0.06996803f, -0.00334429f, 
    -0.09879860f, 0.09484435f, 0.04358781f, -0.01917373f, -0.17171620f, -0.06926019f, 0.02544551f, 0.02805074f, 
    -0.02260919f, -0.01551418f, 0.03974373f, 0.00129762f, 0.03331146f, -0.02959563f, 0.07605300f, -0.12015315f, 
    -0.00458983f, -0.09144130f, 0.07370234f, -0.02033059f, -0.21202244f, -0.07075135f, -0.02066670f, -0.16351767f, 
    -0.13659620f, 0.01030847f, 0.00821692f, -0.03038776f, 0.06410053f, -0.08880466f, 0.08020730f, -0.00042124f, 
    0.06449825f, 0.04616184f, 0.03051777f, -0.01311420f, 0.05239302f, -0.01210928f, -0.02631859f, 0.06450119f, 
    -0.04284425f, -0.02985576f, -0.13551806f, -0.03953888f, 0.01740165f, 0.04614708f, 0.01698405f, -0.04246147f, 
    0.04193338f, -0.00374758f, 0.05864492f, 0.02258700f, 0.05590426f, 0.00931650f, 0.05919299f, -0.01633882f, 
    0.07145659f, -0.01399030f, 0.05924214f, 0.01754613f, 0.08876839f, 0.06679487f, -0.00454662f, 0.02894578f, 
    0.03102469f, -0.05358070f, -0.01225999f, 0.01736455f, -0.04648897f, 0.01348097f, 0.01817744f, -0.05427893f, 
    -0.00854425f, -0.06832948f, 0.01062203f, 0.00169477f, -0.04286739f, 0.01148962f, 0.06875063f, -0.01232583f, 
    -0.09875379f, 0.01708698f, -0.10937120f, -0.06310073f, -0.07808414f, -0.11704640f, -0.01623232f, 0.01608627f, 
    0.01158391f, -0.05974309f, 0.07071886f, 0.00189968f, 0.04267929f, -0.00766416f, 0.10484206f, 0.07261550f, 
    -0.04933470f, 0.01875738f, -0.04056343f, 0.00071729f, 0.04632306f, -0.07179892f, -0.17092985f, -0.14155854f, 
    -0.04035990f, 0.05033316f, 0.01468809f, -0.02224593f, -0.07942273f, -0.03328048f, -0.04116209f, 0.03720834f, 
    0.08846194f, 0.07124552f, -0.03184151f, 0.05330805f, 0.03982031f, 0.01219307f, -0.12053096f, 0.02603091f, 
    0.07036661f, 0.08411039f, -0.11832693f, 0.07184452f, 0.05857042f, -0.04142522f, -0.00210833f, -0.04962251f, 
    -0.05836155f, -0.04908546f, -0.01367509f, -0.08359392f, -0.05619877f, -0.05159212f, -0.00638804f, 0.04456134f, 
    -0.00311309f, 0.00310807f, 0.00111668f, 0.02220556f, 0.14943068f, 0.08720724f, -0.07187214f, 0.02338663f, 
    0.10390520f, 0.00120795f, 0.01066555f, -0.01196202f, -0.03456802f, -0.03371393f, 0.00765656f, 0.03943969f, 
    -0.05481740f, -0.01703453f, 0.00922943f, -0.05616949f, -0.04107458f, -0.00854340f, 0.04376961f, -0.02351306f, 
    0.09364249f, 0.07716003f, 0.09666809f, 0.03857651f, 0.09300523f, -0.14711435f, -0.12006205f, 0.06174015f, 
    0.01174751f, -0.01898300f, 0.00296308f, -0.05542363f, -0.05037915f, -0.00167738f, 0.08161738f, -0.02698361f, 
    -0.00324528f, -0.03582340f, 0.07719542f, 0.00418535f, 0.03983204f, -0.04736876f, -0.07564789f, -0.08878943f, 
    -0.04295254f, -0.03031807f, 0.05853381f, 0.00389442f, -0.03823119f, 0.00790079f, -0.01529887f, -0.03348622f, 
    0.02738435f, 0.02749599f, 0.02729404f, 0.03604640f, 0.02220218f, 0.00346656f, -0.02210317f, 0.02020248f, 
    0.06149087f, 0.04767999f, -0.21648107f, 0.09767741f, 0.02724173f, 0.03257697f, -0.02261651f, -0.06675369f, 
    -0.05607059f, 0.01871886f, 0.05567034f, 0.08020870f, -0.07545663f, 0.07677074f, -0.00224905f, -0.04989281f, 
    -0.05329859f, -0.01185413f, 0.03852826f, 0.01341962f, -0.07329977f, 0.18987760f, 0.04203479f, -0.14478004f, 
    -0.18953063f, -0.06912082f, 0.01969982f, 0.00663507f, -0.01819180f, -0.12926662f, 0.04006286f, 0.01187247f, 
    0.01838312f, 0.03662498f, 0.00913476f, -0.06925279f, -0.01628397f, -0.16990720f, 0.06892294f, -0.00395629f, 
    0.08392914f, 0.18910098f, -0.04272600f, 0.05550079f, 0.06771926f, -0.01322534f, -0.06008180f, -0.16807753f, 
    -0.02211403f, -0.04534203f, 0.08108573f, 0.06191984f, 0.03329055f, -0.04183866f, 0.03429323f, -0.11498928f, 
    0.01597397f, -0.04693480f, 0.12276836f, -0.03129781f, 0.13233222f, 0.01050566f, -0.08878363f, 0.04770954f, 
    0.11613852f, 0.08794650f, 0.05051589f, -0.03740434f, -0.01026286f, -0.00048840f, -0.02932337f, 0.01351842f, 
    0.00794260f, -0.01460588f, -0.06370034f, 0.00652656f, 0.01839009f, 0.08080967f, 0.03173202f, 0.00073905f, 
    -0.10982269f, -0.12247723f, -0.13622017f, -0.20961654f, -0.08073162f, -0.06044767f, -0.04121979f, -0.00655041f, 
    0.02791446f, -0.04063057f, 0.05714265f, 0.03123732f, -0.01653440f, 0.10063827f, 0.04233650f, -0.03282454f, 
    0.00262773f, 0.00368888f, -0.11499120f, -0.04467016f, -0.11069905f, -0.06651011f, -0.07422493f, -0.23065729f, 
    -0.09347510f, 0.00019870f, -0.05482664f, -0.03337723f, 0.05741413f, -0.05193217f, 0.03922179f, 0.02597019f, 
    -0.02950186f, 0.06076464f, 0.00634892f, 0.03649380f, 0.01280583f, -0.01584357f, -0.10409012f, 0.05347237f, 
    -0.04619038f, 0.18592137f, -0.04739280f, 0.01302452f, 0.04222743f, -0.02515447f, -0.04774810f, 0.02941969f, 
    0.05721531f, 0.04218516f, 0.07850341f, -0.04765277f, -0.09177785f, -0.02390668f, 0.07365763f, -0.00496239f, 
    -0.00116039f, 0.04420255f, 0.03380949f, 0.02221499f, -0.06000721f, 0.16244380f, 0.07151144f, 0.06028824f, 
    0.03054274f, -0.00741336f, -0.13592182f, 0.00760369f, -0.04528074f, -0.01926234f, 0.06574058f, 0.00844490f, 
    -0.02561518f, 0.09214474f, 0.01669739f, 0.04489719f, -0.01797283f, 0.00819667f, -0.01822038f, -0.01349000f, 
    -0.05094157f, 0.11872002f, 0.07215591f, -0.04811715f, -0.17522795f, -0.05709124f, 0.04453593f, 0.03984583f, 
    -0.02207121f, -0.02634056f, 0.05952840f, 0.02843140f, 0.00016431f, -0.00376362f, 0.01405545f, -0.05545711f, 
    0.00635391f, -0.06948773f, 0.10838827f, -0.01366792f, -0.07971008f, 0.15589911f, 0.07019898f, 0.01363883f, 
    0.00325202f, 0.02686103f, 0.03863908f, -0.11966248f, -0.02509684f, -0.03608312f, 0.04369943f, 0.05817708f, 
    -0.00035143f, -0.00494401f, -0.10440493f, -0.11017962f, -0.00327579f, 0.06897178f, -0.03070110f, -0.14886692f, 
    -0.08655847f, -0.19271286f, -0.19680507f, 0.02479900f, 0.03773854f, 0.13936357f, 0.02007105f, -0.01285276f, 
    -0.15053846f, -0.05271449f, -0.01311444f, 0.06228222f, -0.01367939f, -0.02487878f, -0.04275196f, 0.04679622f, 
    0.09023669f, 0.04495015f, -0.02373051f, 0.01099985f, -0.07787386f, -0.12327302f, 0.07361294f, -0.17008901f, 
    -0.07252510f, -0.05089925f, -0.08044640f, 0.02130459f, -0.05296944f, -0.04840129f, -0.01238752f, 0.03421299f, 
    0.02449830f, -0.00248540f, -0.04439531f, 0.05243317f, -0.01762994f, 0.02156986f, -0.10335373f, -0.05544645f, 
    -0.17921889f, 0.05878398f, -0.07192273f, -0.03199598f, -0.16455513f, 0.00109226f, -0.00284481f, -0.11009615f, 
    0.04561129f, -0.01198494f, 0.06681178f, 0.02684521f, -0.03190694f, -0.00002882f, 0.05549749f, 0.02087248f, 
    0.01681900f, -0.10486543f, 0.07504788f, -0.03100646f, 0.03595379f, -0.12861171f, -0.01290254f, -0.08276367f, 
    -0.12261048f, 0.06288886f, 0.01257314f, 0.02172499f, -0.12931007f, -0.06149818f, -0.09682969f, 0.06834830f, 
    0.01872204f, 0.03748002f, -0.02279458f, -0.01438415f, -0.00349929f, -0.09738994f, -0.11570925f, 0.02159982f, 
    0.08241767f, 0.16080597f, -0.08913717f, 0.03848900f, 0.05535137f, -0.03126768f, -0.00280989f, -0.06628478f, 
    -0.03810168f, -0.00408652f, 0.01685044f, -0.01100505f, -0.04667172f, 0.02326943f, 0.04597461f, 0.01220651f, 
    0.01983570f, 0.05173111f, 0.01816550f, -0.00509296f, -0.05425435f, -0.10292323f, 0.17342491f, 0.01846034f, 
    0.13331534f, -0.03376251f, -0.05145342f, 0.05060480f, -0.04164260f, 0.04609530f, -0.01380786f, -0.07388851f, 
    -0.03858024f, -0.19692667f, 0.03937564f, 0.01891977f, -0.03315994f, 0.01985461f, 0.02368117f, 0.01820616f, 
    -0.15100734f, -0.15379794f, 0.03453244f, -0.16941959f, 0.02352420f, -0.02472058f, -0.01012782f, -0.00049622f, 
    0.00712354f, 0.00286927f, 0.01543011f, 0.01657410f, 0.05248437f, -0.00460043f, 0.08746907f, -0.03206688f, 
    -0.01681236f, 0.08158040f, -0.05166111f, -0.06561851f, -0.10281572f, -0.07251331f, 0.12255440f, 0.07844973f, 
    0.19435529f, -0.06689094f, -0.04735084f, 0.01876473f, -0.05347553f, 0.07582849f, 0.04015060f, -0.04200535f, 
    -0.09625653f, 0.01046096f, 0.06122149f, -0.01424578f, 0.00126183f, 0.06356800f, 0.00542441f, 0.09795123f, 
    -0.06844773f, 0.17260337f, -0.11903526f, -0.07400325f, -0.11121354f, 0.07526119f, 0.05554798f, -0.10789645f, 
    0.03986170f, -0.02333488f, 0.06655772f, -0.00264742f, 0.03244923f, -0.05207029f, 0.02033663f, -0.01588286f, 
    -0.06543292f, -0.02317096f, 0.08759148f, -0.03670052f, -0.14117822f, -0.00383058f, 0.10847605f, 0.03554988f, 
    0.11748119f, -0.09562010f, -0.07004957f, -0.02327720f, -0.01018272f, -0.03268496f, 0.03375979f, -0.00314191f, 
    -0.04197673f, -0.02725847f, 0.06923786f, 0.00618371f, 0.04807675f, 0.00676331f, 0.00031418f, 0.02568495f, 
    -0.03287744f, 0.02163417f, 0.07813868f, 0.02199969f, 0.13098194f, 0.03562413f, -0.02280218f, -0.04810487f, 
    -0.05203947f, -0.07606572f, 0.04449410f, -0.02711264f, 0.00942390f, 0.02584005f, -0.03418383f, 0.04593606f, 
    -0.03461591f, 0.05459626f, -0.11629026f, 0.05200056f, 0.07297846f, -0.02254176f, -0.04724501f, 0.07181338f, 
    0.07549438f, 0.00847773f, -0.01567498f, -0.08296301f, -0.01135680f, -0.01739672f, 0.05413020f, -0.04366637f, 
    0.01036830f, -0.02961603f, 0.07312841f, -0.00878981f, 0.04910669f, 0.03324050f, 0.01755176f, -0.04955385f, 
    -0.14920431f, 0.02899593f, -0.08736806f, 0.09319614f, -0.04733695f, 0.05164437f, -0.00528387f, -0.07622674f, 
    -0.02467770f, -0.02511155f, -0.01798165f, 0.03254530f, -0.06509541f, -0.03341880f, -0.01387573f, -0.04817153f, 
    -0.02256842f, 0.02764838f, -0.01750329f, 0.01152635f, -0.06645218f, 0.17253132f, -0.15560760f, -0.08344130f, 
    -0.08447282f, -0.09976636f, 0.01772838f, -0.02522632f, -0.07866213f, -0.01892623f, 0.05556046f, 0.02116737f, 
    0.09706812f, 0.02163687f, -0.00145984f, 0.01675339f, 0.00065933f, -0.18375678f, -0.05006063f, 0.11693781f, 
    0.29473564f, 0.00507913f, -0.11531896f, 0.02774395f, 0.02584244f, 0.04051695f, -0.07509615f, 0.01229487f, 
    0.03081124f, 0.01859968f, -0.00409714f, -0.00251040f, 0.08169424f, 0.03390091f, 0.01791261f, 0.06085846f, 
    0.01536125f, -0.05515666f, -0.00558713f, -0.01985335f, -0.02204099f, -0.15859173f, -0.04273453f, 0.11761986f, 
    0.02925059f, -0.10413459f, 0.07842534f, 0.01458069f, -0.04390054f, -0.03048315f, 0.03253655f, -0.03326665f, 
    -0.04471343f, 0.02568836f, 0.00715059f, 0.04789175f, -0.04945478f, 0.04309239f, 0.06664576f, 0.02077883f, 
    -0.15432480f, 0.19418703f, 0.06125372f, 0.02903722f, 0.06306141f, 0.02474249f, 0.02567777f, 0.01356794f, 
    0.03113729f, -0.01876095f, -0.01355798f, 0.02546239f, -0.01510097f, 0.04528934f, 0.02287350f, 0.05021659f, 
    -0.02006190f, 0.01306114f, -0.07187116f, 0.08256680f, -0.18584321f, -0.16672760f, -0.04858344f, -0.14710054f, 
    -0.06474246f, 0.00366258f, 0.04109450f, -0.09174114f, 0.03563536f, 0.01899872f, -0.07946743f, 0.03094098f, 
    -0.03898161f, 0.07255390f, 0.00085118f, 0.02904858f, 0.04558342f, -0.09957385f, -0.01959595f, -0.13309635f, 
    -0.64626557f, 0.26844326f, -0.00143253f, 0.05590257f, 0.12694834f, 0.14240210f, 0.09113445f, 0.01693859f, 
    -0.00961043f, 0.06439424f, 0.00138214f, 0.00088805f, -0.00584914f, 0.02230062f, 0.04336326f, 0.12945220f, 
    0.05025952f, 0.03840259f, -0.11922969f, 0.01808960f, 0.04484648f, -0.23228979f, 0.12748522f, -0.05367330f, 
    0.30679816f, 0.02620769f, 0.00151122f, -0.03634903f, 0.04480150f, 0.09567758f, 0.03241026f, -0.05459051f, 
    -0.05105668f, 0.04045952f, -0.03286578f, 0.00025751f, 0.07431018f, -0.08324459f, -0.07028521f, -0.04371231f, 
    -0.19561018f, -0.12507614f, -0.04384157f, 0.18111156f, 0.08168273f, 0.02793833f, -0.03950199f, 0.04935703f, 
    -0.01861478f, 0.04950120f, 0.03601372f, 0.04534189f, -0.03337210f, -0.03236687f, -0.10038430f, -0.00905437f, 
    -0.07684001f, 0.08869862f, 0.04859282f, -0.01375250f, 0.03365786f, -0.25998434f, 0.05617010f, 0.18205491f, 
    0.06992356f, -0.04937866f, 0.01385316f, -0.03040197f, -0.03535675f, 0.01156719f, 0.03026661f, 0.05618115f, 
    -0.01180962f, -0.03395945f, -0.08010930f, -0.02859469f, 0.04497261f, 0.01183409f, 0.08200985f, 0.08983205f, 
    0.05522458f, -0.23113073f, 0.19854338f, -0.29773605f, -0.23254994f, -0.04958237f, 0.06034274f, -0.04063428f, 
    -0.07359248f, 0.01017252f, -0.00958810f, 0.07398373f, -0.01223168f, -0.13633086f, -0.01702457f, -0.11302601f, 
    0.09334223f, 0.01238421f, 0.09415293f, -0.06051187f, -0.16534710f, -0.01574497f, 0.02638535f, -0.05837959f, 
    -0.01027523f, 0.03668233f, 0.03823263f, -0.06523404f, 0.03168557f, -0.02668764f, 0.02975092f, -0.00183516f, 
    -0.03799558f, 0.03988438f, -0.04805079f, 0.06685276f, -0.00994613f, 0.04688700f, 0.00632800f, 0.00787922f, 
    0.19751190f, 0.06199906f, -0.07488771f, -0.32286921f, -0.27314249f, -0.03183940f, 0.07175562f, 0.03893509f, 
    -0.06684937f, -0.01349975f, -0.00634414f, -0.01929276f, 0.00308669f, -0.01702660f, -0.02300846f, -0.09487892f, 
    0.07546873f, -0.04421198f, 0.08937560f, 0.03156175f, -0.53429723f, 0.12291559f, 0.35081083f, -0.21706517f, 
    0.16620834f, 0.02732109f, 0.05640851f, 0.04474749f, -0.01691721f, 0.01479977f, -0.01419665f, -0.01167268f, 
    0.02217298f, 0.03960964f, 0.06186695f, 0.00848562f, 0.00290926f, 0.15275177f, -0.14063102f, 0.11402210f, 
    0.12142811f, -0.33782202f, 0.29179311f, -0.11488049f, -0.00263029f, 0.15807028f, -0.03051263f, -0.02697678f, 
    -0.04923047f, -0.04337699f, -0.04708809f, 0.00945355f, -0.07467002f, 0.04810188f, 0.11447733f, 0.00321104f, 
    0.06615870f, -0.02280342f, -0.01465221f, 0.03327347f, 0.36729860f, -0.11491524f, -0.07035031f, -0.11099810f, 
    0.06909516f, 0.08700837f, 0.01453858f, 0.01453460f, -0.01936914f, 0.17786242f, -0.07094627f, -0.14138889f, 
    0.05827675f, 0.13039820f, -0.03097118f, 0.12335119f, -0.01609227f, 0.02976636f, 0.02734990f, -0.06086560f, 
    0.24702889f, -0.03202837f, -0.13402195f, -0.19813824f, -0.31737071f, -0.04659666f, 0.03122392f, -0.02685973f, 
    0.02086648f, 0.03638031f, -0.13479371f, 0.05004620f, 0.00264991f, -0.06826521f, 0.04278175f, 0.02213356f, 
    0.07135297f, 0.00848528f, 0.01387241f, -0.01078570f, 0.27369040f, -0.01966360f, -0.06853396f, -0.04049654f, 
    0.08427946f, 0.08434845f, -0.08830072f, -0.02267314f, -0.07310220f, 0.01236403f, -0.02102450f, 0.05388177f, 
    0.04901360f, 0.04059505f, -0.03497653f, -0.00302965f, 0.03999489f, -0.06016485f, 0.02183487f, -0.03032104f, 
    0.08574734f, -0.14829963f, 0.06634366f, 0.03976634f, -0.09633027f, 0.03825270f, 0.09243260f, 0.05646011f, 
    -0.06377789f, -0.05657855f, -0.00325406f, 0.00106784f, -0.03054108f, -0.10752179f, 0.02300891f, 0.01718609f, 
    -0.00468792f, -0.03055700f, -0.14741823f, -0.02842763f, 0.14300959f, -0.75829816f, -0.08225080f, -0.04580344f, 
    -0.13773148f, -0.06063078f, -0.00920807f, 0.00643505f, 0.09465384f, -0.08361704f, -0.11197334f, -0.07431407f, 
    0.07752129f, 0.02414814f, 0.04324835f, 0.11737049f, 0.02780769f, 0.04862269f, -0.06757301f, 0.03441130f, 
    -0.13265981f, 0.01095015f, 0.02837849f, -0.05488306f, -0.06640460f, -0.00815184f, 0.07615770f, -0.00360797f, 
    -0.03628272f, -0.06578407f, -0.05704293f, -0.03425723f, -0.02415282f, -0.01192481f, 0.04322006f, -0.03540641f, 
    0.02652910f, 0.01901064f, 0.01970494f, -0.04309294f, -0.02363282f, -0.16889873f, -0.07281137f, -0.03976478f, 
    -0.03233355f, 0.06820207f, -0.01879894f, -0.11338767f, -0.03079573f, -0.00942863f, -0.00805037f, -0.03279898f, 
    -0.09249737f, -0.10627162f, 0.12860569f, -0.02392578f, 0.04134702f, -0.10275345f, 0.08861320f, 0.07013320f, 
    -0.14228956f, -0.01240716f, 0.06331073f, -0.00110171f, -0.08152648f, -0.05371232f, 0.00821696f, -0.05505841f, 
    -0.03901759f, 0.01831093f, 0.06242235f, 0.03215297f, 0.02714157f, 0.03108274f, 0.07656981f, 0.01312849f, 
    -0.03040892f, 0.01207413f, 0.00153886f, 0.04534468f, 0.07621554f, -0.14447749f, 0.03474266f, 0.00923602f, 
    -0.02207566f, -0.09520598f, 0.01410207f, 0.02072816f, -0.00400872f, -0.04757870f, 0.04540996f, 0.00101304f, 
    0.04714433f, 0.09210371f, -0.08755547f, 0.00143246f, 0.07386448f, 0.09541109f, 0.07003704f, 0.05554612f, 
    0.32642496f, 0.04285230f, -0.15672193f, 0.15805076f, -0.15445875f, -0.05425649f, 0.01252438f, 0.09455362f, 
    0.07005707f, -0.11380275f, 0.02863076f, -0.03588223f, 0.06454201f, 0.01912058f, 0.05355513f, 0.01084995f, 
    0.08563970f, 0.02915578f, 0.01499227f, 0.07193643f, -0.02773611f, -0.09511912f, 0.08572862f, -0.07943955f, 
    -0.06006093f, 0.01096641f, 0.03286410f, -0.11446476f, 0.01947446f, -0.01403380f, -0.01261853f, 0.06830984f, 
    -0.06454119f, 0.00530869f, 0.01587119f, -0.00479392f, -0.08039112f, 0.09824260f, -0.01502646f, 0.02789955f, 
    -0.03171807f, -0.11781481f, -0.06502820f, 0.02517312f, 0.07167880f, 0.08480168f, -0.04251637f, 0.00925042f, 
    -0.02073800f, 0.08041833f, -0.03394113f, -0.05718429f, 0.04034428f, 0.04987421f, -0.03047261f, 0.03736291f, 
    -0.03316536f, -0.01150069f, 0.04638850f, -0.05094654f, 0.06539984f, -0.11877729f, 0.05005648f, 0.12676650f, 
    0.03775185f, -0.04461721f, -0.02447048f, -0.02534981f, -0.03095436f, 0.14850113f, -0.08704783f, 0.09304772f, 
    -0.09781373f, 0.02815150f, 0.05067491f, 0.04914963f, -0.01606681f, 0.06925675f, 0.01450855f, 0.00605105f, 
    0.22465765f, 0.08488803f, 0.00584535f, 0.01348156f, 0.08336601f, 0.04125040f, -0.05757798f, 0.02933780f, 
    0.12154609f, -0.17014877f, 0.05510856f, 0.00819636f, 0.00816496f, 0.02591168f, -0.08638819f, 0.01689539f, 
    -0.08843908f, 0.07161356f, -0.04647376f, -0.04859551f, 0.03028112f, -0.08455969f, -0.09060315f, 0.13543519f, 
    -0.08071952f, -0.04403272f, 0.00773725f, -0.02972794f, -0.07297637f, 0.02291819f, -0.09349038f, -0.00623417f, 
    0.02233568f, 0.05956863f, 0.10794094f, 0.14106701f, -0.04885193f, 0.04384287f, 0.06281528f, 0.03113179f, 
    -0.07252025f, -0.18025924f, 0.01751914f, 0.14966908f, -0.05813767f, -0.04637858f, 0.00520734f, -0.04536304f, 
    0.09570311f, -0.02740349f, -0.02521194f, 0.00468695f, -0.02199657f, -0.04358728f, -0.01201098f, -0.08045272f, 
    0.00690276f, -0.01925615f, 0.04007196f, -0.01436700f, 0.00326059f, 0.07913820f, 0.09520347f, -0.34249389f, 
    -0.17569683f, 0.00295923f, 0.06440461f, -0.03438235f, 0.00297855f, 0.05072169f, 0.01988835f, -0.04244654f, 
    -0.02149971f, -0.12327434f, 0.00072242f, -0.01494507f, 0.02466558f, -0.00837374f, -0.12232434f, -0.03449853f, 
    -0.18140954f, 0.25723913f, 0.00565966f, 0.05131800f, -0.01543138f, 0.10355177f, -0.01679803f, 0.02165078f, 
    0.06664509f, 0.02852797f, -0.08295187f, -0.03343996f, -0.05314262f, -0.00765921f, 0.11942344f, 0.05411089f, 
    0.02295175f, 0.03881619f, -0.14942443f, -0.00359392f, -0.14006004f, 0.02602542f, -0.12816642f, 0.06899895f, 
    -0.04666588f, -0.05023180f, 0.04919603f, 0.01280657f, 0.04185161f, -0.05246334f, 0.01078522f, -0.00553490f, 
    0.03249186f, -0.00934525f, 0.03196545f, 0.10306247f, 0.03025354f, -0.03401359f, 0.04444782f, 0.10208131f, 
    -0.10712142f, 0.01099467f, 0.05482417f, -0.04397436f, -0.17405519f, 0.02846424f, 0.06458548f, 0.01032147f, 
    -0.03915324f, 0.04860646f, 0.00109281f, -0.06775650f, -0.09684622f, -0.08006284f, -0.05249078f, -0.06065438f, 
    -0.01490136f, -0.04361349f, -0.05865600f, -0.01445220f, -0.19456084f, 0.04291746f, 0.10359307f, 0.02065408f, 
    -0.00025481f, 0.08910808f, 0.01845275f, -0.03792798f, 0.05408692f, 0.05326067f, 0.00245220f, 0.02581607f, 
    -0.03102200f, 0.00960231f, -0.12291297f, -0.04564757f, -0.01669228f, -0.00188590f, -0.00158472f, 0.00102656f, 
    -0.02395453f, -0.09728099f, -0.02806175f, -0.09023948f, 0.03639290f, -0.15024006f, 0.07176688f, 0.01956871f, 
    0.14667653f, -0.00107948f, -0.00608331f, 0.04944462f, -0.04931469f, -0.15139195f, -0.07637677f, 0.00583091f, 
    -0.09239435f, 0.13824582f, 0.01309093f, 0.12263094f, -0.13722695f, -0.01509574f, 0.05835302f, -0.20160890f, 
    -0.13491765f, -0.01392918f, 0.02645268f, -0.00068205f, -0.03287505f, 0.01152447f, -0.00546683f, 0.04864714f, 
    -0.04873922f, 0.03123138f, 0.01075520f, -0.11656070f, 0.02786053f, 0.04148507f, 0.11399958f, 0.04822889f, 
    -0.24513160f, -0.20908052f, -0.00376529f, 0.07246189f, -0.07990643f, 0.04143436f, 0.04418925f, -0.05846632f, 
    0.03950012f, -0.09453012f, -0.13388716f, 0.10023730f, 0.06825058f, -0.03445886f, -0.04504090f, -0.06864410f, 
    0.03937232f, -0.14385477f, 0.00573316f, 0.06432889f, -0.13578112f, 0.12238811f, -0.05591025f, 0.12251515f, 
    -0.07780977f, 0.01724917f, 0.04698329f, 0.01518770f, 0.05026444f, -0.13359702f, 0.03087315f, 0.00728731f, 
    -0.01098124f, -0.01743310f, 0.05523086f, 0.02546212f, -0.04445442f, 0.03619532f, 0.00447875f, 0.03962794f, 
    -0.17181922f, 0.09909277f, -0.15629889f, 0.05186468f, 0.03423423f, 0.10205769f, 0.03122285f, -0.00559750f, 
    0.02767184f, 0.08637943f, -0.07728367f, -0.03411712f, 0.02582625f, -0.00592888f, -0.00025012f, 0.03749732f, 
    -0.09674715f, 0.03403133f, -0.00199282f, -0.02742549f, -0.12503377f, -0.01885883f, 0.01912201f, -0.11412977f, 
    -0.05841519f, 0.00722068f, 0.04909128f, 0.03537615f, 0.08396964f, -0.07512864f, -0.10473622f, 0.02379953f, 
    -0.06742165f, 0.01433809f, -0.04451079f, -0.01785543f, 0.06618796f, 0.07252744f, 0.02473084f, 0.02948805f, 
    -0.07079376f, -0.11602543f, -0.00494994f, 0.02724943f, -0.11189315f, 0.08222961f, -0.03009359f, 0.01740577f, 
    0.01560086f, 0.00250874f, 0.04358180f, -0.03244938f, 0.02460927f, 0.00887822f, -0.02894176f, 0.02028025f, 
    0.01644153f, 0.00369496f, -0.00058614f, 0.07031631f, -0.18366630f, 0.25489858f, 0.02667736f, 0.12953591f, 
    -0.05651115f, -0.00563313f, 0.00364775f, -0.01481318f, -0.02042666f, 0.02388539f, -0.05746454f, 0.05939258f, 
    0.07941753f, 0.08352705f, 0.16067508f, 0.09250200f, -0.03208776f, 0.01824949f, 0.02136434f, -0.01149791f, 
    -0.40522587f, -0.18442120f, 0.17023972f, -0.44008622f, 0.00364252f, -0.06015845f, 0.10026407f, -0.04476108f, 
    -0.01267346f, 0.04634309f, 0.06291802f, -0.13525183f, -0.06562161f, -0.01810773f, 0.01567243f, -0.05503397f, 
    0.05622146f, 0.00284892f, -0.06941856f, 0.04114823f, 0.08600885f, -0.06598642f, 0.18931617f, -0.18057227f, 
    -0.17351913f, 0.07109933f, 0.05278444f, -0.04263682f, -0.07765132f, -0.00710905f, -0.03226603f, -0.05417927f, 
    -0.01353380f, -0.00657840f, -0.02264685f, -0.03114816f, -0.02091128f, 0.05579457f, 0.03761768f, 0.01316990f, 
    -0.07885320f, -0.13372076f, 0.16347478f, -0.09651397f, 0.12200783f, -0.05055216f, -0.00283638f, 0.04578099f, 
    -0.00091487f, 0.04431646f, 0.03793361f, 0.02226066f, 0.00599953f, -0.09859864f, 0.01173520f, -0.02499406f, 
    0.02211567f, -0.04355466f, 0.06847331f, 0.04736958f, 0.01396970f, -0.02379224f, 0.08944993f, -0.14338855f, 
    -0.09965821f, -0.07943027f, -0.00281816f, 0.03387963f, -0.06860761f, 0.07040811f, 0.00258171f, -0.02359145f, 
    -0.03592164f, -0.05118106f, -0.01795115f, -0.00303037f, 0.02331275f, -0.05277121f, 0.08687820f, -0.03568275f, 
    -0.16653696f, 0.13467759f, -0.04203980f, 0.07472295f, -0.12565805f, -0.02450564f, 0.11107303f, -0.11027373f, 
    0.06235879f, 0.10253946f, -0.02490567f, 0.00951935f, 0.10403615f, 0.03958330f, 0.04861094f, -0.00590495f, 
    -0.04349497f, -0.05214968f, -0.06398727f, -0.05706303f, 0.13624030f, 0.05228587f, -0.03218960f, -0.09546623f, 
    -0.05403022f, -0.08539446f, 0.04263822f, 0.04880927f, 0.19428733f, -0.08076595f, -0.06425918f, -0.02733761f, 
    0.13655894f, -0.03643810f, 0.03728801f, -0.11437368f, 0.07415579f, -0.03120688f, 0.00830973f, -0.07300443f, 
    -0.21705578f, 0.30640784f, 0.07746033f, 0.12537119f, 0.01642683f, 0.06819483f, 0.01528968f, -0.02209989f, 
    0.00211423f, 0.06008191f, -0.07057838f, 0.03663476f, 0.04109221f, 0.01432013f, 0.05592044f, 0.05197169f, 
    0.03562322f, 0.07162062f, -0.04190356f, -0.04147733f, 0.38190454f, -0.09524550f, -0.07866466f, -0.24530344f, 
    -0.15335326f, 0.01196758f, 0.01427798f, 0.02620471f, 0.02198256f, -0.08748486f, -0.03209340f, -0.03208033f, 
    -0.02299851f, -0.08017288f, -0.03862036f, 0.13007353f, 0.03556691f, -0.10441555f, -0.08258416f, 0.06814224f, 
    0.00385180f, -0.16905886f, 0.04574877f, -0.04388640f, -0.31950080f, 0.08063159f, 0.02625424f, -0.05039829f, 
    -0.04251573f, -0.02306990f, -0.00006260f, 0.04814557f, -0.07942328f, 0.10724971f, -0.14466397f, 0.04503221f, 
    -0.05119175f, -0.05558588f, -0.03038772f, 0.00425387f, 0.10169945f, 0.15774605f, -0.12886170f, -0.19429998f, 
    -0.02762742f, -0.00089297f, -0.03342908f, 0.03751864f, 0.00398752f, 0.04193770f, -0.03901235f, 0.02152209f, 
    0.03681245f, -0.06918637f, 0.00911910f, 0.05627770f, 0.06122712f, -0.00433073f, -0.00478271f, -0.00485750f, 
    -0.24655351f, -0.25977018f, 0.09385845f, -0.03251818f, -0.00158923f, -0.03849032f, 0.01255836f, 0.00601464f, 
    0.03907318f, 0.01331241f, -0.13563633f, -0.01705883f, 0.01003784f, 0.01145790f, 0.02704818f, 0.04461389f, 
    0.01670995f, 0.00533862f, 0.00541521f, 0.04131249f, -0.00821165f, -0.04355286f, 0.00445965f, -0.01447077f, 
    0.16183090f, 0.02989113f, 0.00835987f, -0.09708180f, 0.01190903f, 0.06874423f, -0.09516986f, 0.12826411f, 
    -0.14598994f, 0.00007221f, -0.06903251f, -0.03061863f, -0.10442336f, 0.10124101f, 0.02321312f, 0.02059123f, 
    0.04136444f, 0.07213239f, 0.09818571f, -0.06460477f, -0.05350738f, 0.03740688f, 0.04376760f, 0.06091482f, 
    0.07931154f, -0.13446812f, 0.04276642f, 0.00655797f, 0.00902705f, -0.01311187f, 0.02160489f, -0.05487128f, 
    0.01118252f, 0.03008617f, -0.07521708f, 0.03755910f, 0.16501512f, -0.07913350f, 0.04232126f, 0.07726368f, 
    0.01193761f, 0.11402944f, -0.07938050f, -0.03651300f, 0.05294494f, 0.12585613f, -0.07444181f, -0.04845295f, 
    -0.04426403f, 0.01887398f, -0.07920372f, 0.01463377f, -0.08373263f, -0.01415672f, -0.07462403f, -0.03738531f, 
    0.00185617f, -0.13114159f, 0.05970468f, -0.06872828f, 0.09910110f, -0.00404787f, -0.01424645f, -0.01865443f, 
    0.01762072f, 0.00274789f, 0.00177397f, -0.03034027f, 0.01016127f, 0.00819330f, -0.05678456f, 0.06016936f, 
    0.05394233f, -0.02358873f, -0.06233405f, 0.02262651f, 0.09586009f, -0.20154117f, -0.14083752f, 0.11354502f, 
    -0.08193143f, -0.00960501f, 0.04916902f, -0.09553652f, 0.04639259f, 0.02889010f, 0.00174347f, 0.02051984f, 
    -0.01193759f, -0.04652603f, 0.03769379f, -0.02419752f, -0.00393268f, -0.07273290f, 0.02947561f, 0.00114535f, 
    -0.13223799f, -0.12285639f, 0.29327577f, -0.09422866f, -0.13250272f, -0.04843576f, -0.00703465f, 0.03745531f, 
    0.12186019f, -0.04785140f, 0.02731876f, 0.03314787f, 0.12878168f, 0.06479358f, 0.02365957f, 0.10023381f, 
    0.04041291f, 0.04148182f, -0.03459017f, -0.09100269f, 0.06319413f, -0.03360117f, -0.03737446f, 0.04455099f, 
    -0.00818638f, 0.03576800f, 0.01084066f, -0.07103366f, -0.00425102f, -0.00319780f, -0.00286504f, -0.04167255f, 
    0.01637282f, 0.03253420f, 0.01295300f, -0.05157053f, -0.09715436f, 0.03160681f, -0.04294328f, -0.00104277f, 
    0.50550669f, 0.01015881f, -0.07975055f, -0.19087535f, 0.11212375f, 0.04429505f, -0.02423854f, 0.07906020f, 
    -0.05071409f, -0.09233516f, -0.03213876f, 0.03252570f, 0.00582478f, 0.06485159f, 0.00548403f, 0.03225537f, 
    0.01745150f, -0.09556259f, 0.06289967f, 0.02100281f, -0.15262409f, -0.06214448f, 0.10236735f, -0.25248781f, 
    0.02180209f, 0.01535669f, 0.05286974f, -0.12446379f, 0.03690072f, -0.01099497f, -0.06984767f, 0.03735280f, 
    -0.00428467f, 0.01863182f, 0.03929280f, 0.08390991f, 0.04649130f, -0.11660158f, -0.00114624f, -0.06140860f, 
    0.15586133f, -0.34234574f, -0.04031165f, 0.14924683f, -0.17279223f, -0.10310334f, -0.03593268f, -0.07219440f, 
    0.15744928f, 0.02427883f, -0.10117119f, 0.11427672f, 0.11549259f, -0.07164717f, 0.00705987f, 0.03075805f, 
    0.01090257f, 0.02198611f, -0.06263176f, 0.07372573f, -0.38916981f, 0.06971177f, -0.10089535f, -0.00470099f, 
    -0.03662452f, 0.02915276f, 0.02075756f, -0.03599564f, -0.01240080f, -0.06829277f, -0.08272425f, 0.01176845f, 
    -0.17928138f, 0.04696524f, -0.03917165f, -0.05934436f, 0.03249760f, 0.04982973f, 0.00722276f, 0.09396368f, 
    0.04377605f, 0.08723062f, -0.00556677f, 0.03282022f, 0.00225857f, -0.05813338f, -0.06094877f, 0.03602411f, 
    0.01689164f, 0.06191202f, 0.01762755f, 0.04917137f, 0.01409276f, 0.04500294f, -0.04940550f, -0.02561882f, 
    0.00379501f, 0.10786472f, 0.00793701f, 0.01033024f, 0.19019194f, 0.00052357f, -0.00873107f, -0.01094284f, 
    -0.07993244f, 0.05658075f, -0.00568503f, 0.05766817f, -0.01007692f, 0.02267920f, -0.01887807f, -0.05052295f, 
    -0.04065133f, -0.01921601f, -0.07553715f, 0.05711062f, -0.07738694f, -0.20244308f, -0.14017774f, -0.06319640f, 
    -0.01463953f, -0.08815593f, -0.00446591f, -0.02607082f, 0.00833566f, -0.06114392f, 0.04369290f, -0.01176927f, 
    0.00247260f, -0.03168238f, 0.02026425f, -0.01221005f, -0.03077762f, -0.07694280f, -0.00163109f, -0.01605737f, 
    -0.00424899f, -0.03106133f, 0.06617193f, 0.01813972f, -0.33600247f, -0.05662397f, -0.06782392f, -0.14163545f, 
    -0.06276760f, 0.12249292f, 0.04934136f, -0.02492331f, -0.08007135f, -0.02297732f, 0.03184701f, 0.02703432f, 
    -0.07295904f, -0.17158478f, 0.04231984f, -0.04315446f, -0.10164161f, 0.07850822f, 0.00316727f, 0.03586313f, 
    -0.14206733f, -0.08066951f, -0.16412278f, -0.08005155f, -0.18212754f, -0.02162567f, 0.06230339f, 0.07666199f, 
    -0.04524348f, -0.02748049f, 0.10848946f, -0.03566934f, 0.00944919f, -0.09865043f, 0.03757032f, 0.02322363f, 
    0.01338413f, -0.01144664f, 0.10013048f, 0.03134371f, 0.03368026f, 0.08852623f, -0.15636414f, 0.06097206f, 
    0.00619231f, -0.06712324f, 0.05893053f, 0.02201107f, 0.02561202f, 0.05046849f, 0.03326243f, 0.03757441f, 
    0.01089519f, -0.02871468f, -0.02358568f, 0.05183041f, 0.02062926f, -0.04858866f, -0.04198579f, 0.03317136f, 
    0.14378051f, 0.09104446f, -0.09480919f, -0.01601884f, -0.03815063f, 0.00348565f, -0.10051107f, 0.10259507f, 
    -0.05698188f, -0.00557182f, 0.00538561f, -0.03139491f, 0.03039107f, -0.04553911f, 0.01534167f, -0.01532458f, 
    0.03145991f, -0.02844396f, -0.01963193f, 0.01327175f, 0.09062625f, 0.01892998f, -0.01563573f, 0.08812214f, 
    -0.06754430f, -0.09717328f, -0.03408813f, 0.02363863f, 0.01262019f, 0.02017911f, 0.02046821f, 0.03819203f, 
    -0.01127434f, 0.00039257f, 0.02562307f, -0.02298545f, 0.01466537f, -0.07497425f, -0.07266087f, -0.05273104f, 
    -0.14845327f, -0.03390547f, 0.13157979f, -0.08154188f, -0.19790417f, 0.02373394f, -0.06737635f, 0.02937594f, 
    -0.02979384f, 0.08480437f, -0.04770508f, 0.02664432f, -0.02210657f, 0.07770106f, -0.04439801f, -0.00096848f, 
    0.05265454f, -0.03493598f, -0.11114578f, -0.00375423f, -0.31923604f, -0.20627601f, 0.07302481f, 0.03125035f, 
    -0.05422669f, 0.04637207f, 0.08620264f, 0.02755226f, -0.01875070f, 0.02347549f, 0.06881185f, 0.03940739f, 
    0.02850638f, -0.01831116f, 0.03135562f, 0.01819403f, 0.00651389f, 0.07141183f, 0.01133714f, -0.02052503f, 
    0.08989355f, 0.18655801f, 0.14727226f, -0.05398529f, -0.16578569f, 0.04457681f, -0.01149280f, -0.05308872f, 
    0.05339952f, 0.00685552f, -0.00582716f, 0.03827714f, 0.06086940f, 0.05546799f, 0.00796293f, 0.00633408f, 
    0.08763143f, -0.00926400f, -0.08752155f, 0.04176229f, -0.48056734f, -0.40228787f, -0.13984621f, -0.03361626f, 
    0.01392084f, 0.04327655f, -0.01142720f, -0.03050668f, -0.01195424f, -0.07196350f, 0.10964689f, 0.02919410f, 
    0.01688305f, -0.09454579f, 0.03019566f, 0.05584953f, -0.12447460f, -0.09166612f, 0.10641291f, -0.01540763f, 
    -0.16941983f, 0.02386796f, -0.16095887f, -0.07535549f, 0.06420427f, 0.01338729f, 0.03428817f, -0.03930783f, 
    0.02518554f, 0.04840643f, 0.03299255f, 0.03501610f, 0.00521029f, -0.04384250f, 0.05271712f, 0.05312667f, 
    -0.00002451f, 0.13739598f, -0.07731485f, 0.12838751f, 0.03805644f, 0.03442431f, 0.05052054f, 0.10981135f, 
    -0.06135708f, 0.00729771f, -0.10395208f, -0.01189487f, -0.04387468f, 0.04415059f, 0.01285729f, 0.01731619f, 
    -0.04700084f, -0.10519598f, -0.13769281f, -0.04128254f, -0.13836999f, -0.01080055f, -0.02523003f, -0.06240277f, 
    -0.40497488f, -0.08955773f, 0.13181339f, -0.12273604f, -0.32990286f, 0.08804494f, 0.00919545f, 0.02646204f, 
    -0.09393100f, 0.04832768f, -0.01539959f, 0.00823636f, -0.05058823f, 0.02296618f, -0.03227098f, -0.07012316f, 
    -0.01961895f, -0.13455495f, -0.06488018f, -0.12988752f, 0.06174893f, 0.09733204f, 0.02399346f, 0.05051415f, 
    0.01554278f, -0.00482780f, -0.01138486f, 0.03727362f, 0.00894492f, 0.02777471f, 0.03028908f, 0.01242879f, 
    -0.01879288f, -0.04353701f, 0.04677941f, -0.06586390f, 0.03249352f, 0.15573935f, -0.01785828f, 0.00299429f, 
    -0.34840700f, -0.21659324f, -0.18968706f, -0.09598958f, -0.14929563f, 0.05940873f, 0.00647670f, -0.11099458f, 
    -0.08018097f, 0.00161112f, -0.00805391f, -0.03597606f, -0.04626635f, 0.04481426f, 0.01994364f, -0.03127886f, 
    -0.00957800f, 0.07995050f, -0.00576231f, 0.03735702f, -0.35460478f, 0.04146188f, -0.13816902f, 0.15760902f, 
    0.15939695f, 0.06039206f, 0.02889735f, -0.12519906f, -0.00045508f, -0.01114240f, 0.06448461f, 0.01446951f, 
    0.05036547f, -0.06304835f, 0.12457110f, -0.01749161f, 0.01397819f, 0.05715473f, -0.08439665f, 0.03341736f, 
    0.09982859f, 0.02621130f, 0.11531920f, 0.02446349f, -0.00307348f, 0.05725781f, 0.02601382f, 0.03267130f, 
    0.02411469f, 0.05689275f, 0.01335329f, 0.04100800f, -0.00712791f, 0.02319230f, 0.02312178f, -0.03607757f, 
    0.01122443f, -0.16966780f, -0.03628137f, -0.02016846f, 0.02780182f, 0.01370074f, -0.16909768f, -0.06664159f, 
    0.00217532f, -0.00357769f, -0.02184011f, 0.01946354f, 0.00297149f, -0.00017233f, -0.05252301f, -0.04285542f, 
    -0.12149274f, -0.10051619f, -0.04611302f, 0.01655865f, 0.09176628f, 0.09846601f, 0.04842186f, 0.11162636f, 
    0.07088321f, -0.07448960f, 0.01519669f, 0.01984203f, 0.07366947f, 0.11022338f, 0.07386937f, 0.02079478f, 
    0.02453524f, -0.00396688f, -0.00061649f, -0.01692330f, -0.00591470f, 0.02934566f, -0.01496851f, 0.07503953f, 
    0.01261600f, -0.17169443f, -0.05163035f, 0.03527145f, -0.03466093f, 0.05023399f, 0.03053185f, -0.01363347f, 
    0.07577606f, -0.08060035f, 0.02884627f, -0.05851186f, 0.03735455f, 0.00696870f, -0.01690500f, 0.05594128f, 
    0.00231364f, -0.03814900f, -0.01281559f, 0.08563207f, -0.02854786f, -0.13412057f, -0.15782160f, 0.02268882f, 
    -0.29850626f, -0.22437024f, 0.08579931f, 0.05998320f, 0.03369352f, 0.02435741f, -0.00501408f, -0.02051213f, 
    -0.07241327f, 0.03430323f, 0.05465645f, 0.00282479f, 0.03130706f, -0.05741173f, 0.06333243f, -0.01094102f, 
    0.00728406f, -0.02432238f, 0.04439033f, 0.03512482f, -0.39680272f, -0.21397769f, -0.11625253f, -0.06791173f, 
    -0.19836241f, 0.04161901f, 0.05723115f, -0.03164186f, -0.02101971f, 0.07980739f, 0.06891578f, 0.05042319f, 
    -0.01399134f, 0.05512301f, 0.00323913f, 0.05860939f, -0.02560544f, 0.04646029f, 0.02562407f, 0.00193907f, 
    0.19523190f, 0.07285329f, -0.06515749f, 0.01812568f, -0.02606717f, -0.07745722f, -0.04945221f, -0.04571895f, 
    0.00065945f, 0.02997632f, 0.03048722f, 0.00561561f, -0.00010934f, -0.07663652f, -0.04582971f, 0.01667898f, 
    -0.03968155f, 0.02128615f, -0.04113724f, -0.01648434f, 0.17017394f, -0.03715699f, -0.03981023f, 0.05645129f, 
    -0.08099359f, -0.06204964f, 0.00766388f, 0.01388143f, 0.04016029f, -0.00601867f, -0.03794894f, 0.08959037f, 
    -0.01580144f, -0.06664240f, -0.08481232f, -0.06623890f, 0.02021863f, -0.10122017f, -0.14499795f, -0.07557049f, 
    -0.23677808f, -0.07228670f, -0.18988104f, -0.04441172f, -0.03047563f, 0.00854844f, 0.01188507f, -0.03067312f, 
    -0.01316971f, 0.04315924f, -0.06150103f, -0.10707361f, 0.02853168f, -0.11253914f, -0.01844616f, -0.00352787f, 
    0.00598193f, 0.02319785f, 0.07832162f, 0.05355926f, 0.04927717f, 0.06087989f, -0.01545360f, -0.04445809f, 
    -0.05446108f, 0.03051083f, -0.09568629f, 0.07813627f, -0.07561398f, -0.03329691f, -0.02629232f, -0.02767449f, 
    -0.07530565f, -0.07149740f, -0.07363540f, -0.02280641f, -0.04299822f, -0.08903082f, -0.09644242f, -0.05019759f, 
    0.05461938f, 0.05094019f, 0.01299354f, -0.04797368f, -0.02628273f, 0.05033266f, 0.09237672f, 0.03791656f, 
    0.02889910f, 0.00375021f, -0.02571400f, 0.00525179f, 0.01880783f, 0.00536023f, -0.02356428f, -0.02522999f, 
    0.05096542f, 0.02237113f, -0.01104612f, 0.06582004f, -0.40358114f, -0.28439686f, -0.06343698f, -0.16856419f, 
    -0.09641278f, 0.07115691f, -0.00643235f, -0.03129110f, -0.09439167f, 0.03916618f, -0.00658187f, -0.02095242f, 
    -0.01230610f, 0.07734380f, -0.00585997f, -0.00405287f, -0.03916911f, -0.01100596f, 0.01129121f, -0.01730382f, 
    -0.04973299f, -0.02785950f, -0.01226794f, 0.04635685f, 0.09677918f, 0.06843296f, -0.04356407f, 0.05760734f, 
    -0.02298406f, 0.03946809f, 0.09380836f, -0.03514895f, 0.03627247f, -0.00210018f, 0.03739655f, 0.00583639f, 
    -0.06287754f, -0.01553661f, 0.10139934f, 0.02684709f, -0.14644480f, 0.01101112f, 0.05977699f, 0.02606475f, 
    0.03360868f, -0.01841785f, 0.00744372f, 0.00557220f, 0.00921953f, -0.01409591f, -0.03266250f, 0.01204474f, 
    0.00447494f, 0.01617472f, 0.06667099f, 0.01129794f, -0.03635602f, -0.10743643f, -0.13152628f, -0.03210792f, 
    -0.22120021f, -0.13184486f, 0.10565260f, -0.06211303f, 0.06389024f, 0.08319334f, -0.00077408f, -0.02607893f, 
    -0.03596006f, -0.03408621f, 0.03799948f, 0.05308328f, 0.04225759f, 0.09565166f, 0.00223361f, 0.07469324f, 
    0.00058877f, -0.02224496f, -0.00114033f, -0.06883202f, 0.14721219f, 0.10174239f, -0.04303257f, 0.03552749f, 
    -0.06631455f, -0.07206532f, -0.03981914f, 0.05356746f, 0.05565730f, -0.03824987f, 0.00687379f, 0.00440765f, 
    0.07891479f, -0.03185377f, 0.04593115f, 0.03175367f, -0.01755299f, 0.03320315f, 0.06860624f, -0.03848534f, 
    0.21569023f, 0.06106441f, 0.06427179f, 0.02928697f, 0.05443919f, 0.09681814f, 0.02679630f, -0.01022391f, 
    0.03721526f, 0.05102525f, -0.08811272f, 0.03111873f, 0.00980454f, 0.00162602f, -0.03038902f, 0.11722367f, 
    0.05911224f, -0.00223690f, -0.03371601f, 0.01372504f, 0.04208265f, 0.11911606f, 0.08048026f, -0.06532499f, 
    -0.08594733f, 0.04742618f, 0.06204991f, -0.00550456f, 0.06484380f, 0.05260644f, -0.02909079f, 0.02456549f, 
    0.02323131f, -0.04225053f, -0.04188624f, 0.09310448f, 0.02377126f, 0.08951108f, -0.01926282f, 0.06023206f, 
    -0.07137558f, -0.01749754f, -0.05274756f, -0.11831211f, -0.04148847f, -0.05371562f, 0.06406664f, -0.11122421f, 
    -0.02564044f, 0.04425711f, -0.08212193f, 0.03414043f, -0.12331613f, 0.00288782f, 0.07323188f, -0.06128377f, 
    0.01613200f, 0.08738557f, 0.04069487f, 0.07606627f, -0.16311058f, -0.14257921f, -0.06931589f, -0.02991201f, 
    -0.06742394f, -0.00487493f, 0.01929785f, -0.01895115f, -0.04596917f, 0.02022957f, 0.06932444f, -0.06849013f, 
    -0.04101774f, -0.01219870f, 0.00393824f, 0.00283192f, 0.06062022f, 0.03610791f, 0.09599952f, 0.06487517f, 
    0.19805571f, 0.09479959f, -0.06934290f, 0.02664014f, -0.07236166f, -0.08200178f, -0.06765693f, -0.05036085f, 
    0.06548355f, 0.00692837f, -0.03172874f, -0.04299318f, 0.00934390f, -0.12363685f, -0.11283895f, -0.01583446f, 
    0.00188793f, 0.03517646f, 0.03716193f, -0.05044875f, -0.07304537f, -0.06248578f, 0.00710029f, -0.02630775f, 
    -0.04923926f, 0.09528837f, 0.06874578f, 0.03689276f, 0.04261477f, 0.04942197f, 0.01461115f, 0.03759003f, 
    0.08676688f, 0.00727771f, -0.01282913f, 0.04723523f, 0.09966792f, -0.01391444f, -0.03122245f, 0.07296193f, 
    -0.38400403f, -0.16763674f, -0.03084170f, 0.05860007f, 0.15267491f, 0.05776095f, 0.07993039f, -0.03986177f, 
    -0.02309315f, -0.01700792f, 0.03418510f, -0.02174516f, -0.04398245f, 0.06208036f, 0.01964365f, 0.05137194f, 
    0.07324871f, 0.06059864f, 0.03875456f, 0.03755992f, -0.05855245f, -0.05373979f, -0.02549858f, 0.00356047f, 
    0.02035398f, 0.04290746f, 0.03974908f, 0.01272019f, 0.01923358f, 0.06075565f, 0.04677893f, -0.05361919f, 
    0.02432442f, -0.00275049f, -0.10372013f, -0.00886401f, 0.03682725f, -0.13403659f, 0.09439503f, 0.02692579f, 
    -0.31479043f, -0.12204452f, -0.22431426f, -0.15097444f, -0.04629883f, 0.04562700f, -0.04937308f, -0.05199945f, 
    -0.05480488f, -0.05940696f, 0.09737173f, 0.04404736f, -0.14992422f, -0.10416886f, 0.10185498f, -0.04462906f, 
    -0.06968580f, 0.02727081f, 0.02768861f, -0.00610327f, -0.41067085f, -0.14668784f, -0.12388275f, -0.19375686f, 
    -0.09843720f, 0.05615701f, 0.00159180f, -0.11080039f, -0.04036829f, 0.01653890f, 0.00816468f, 0.02032350f, 
    -0.02574729f, 0.08412142f, 0.04322981f, 0.00545400f, -0.00038180f, 0.10898073f, 0.02956232f, 0.06364498f, 
    0.15361208f, 0.16903616f, 0.06012776f, 0.05523166f, 0.06612670f, 0.03303350f, -0.02849106f, 0.09747375f, 
    0.05367601f, 0.07194724f, -0.02223674f, 0.03696641f, 0.03227038f, 0.00146142f, -0.06789693f, 0.03076680f, 
    -0.02402132f, -0.07778703f, -0.13777000f, 0.03382281f, 0.20460597f, 0.12717192f, 0.08766431f, -0.00099737f, 
    0.04786200f, 0.09476319f, 0.02676739f, 0.04285750f, 0.06482876f, 0.02976847f, -0.05504601f, -0.00738783f, 
    -0.01200660f, 0.04543288f, -0.00467349f, 0.03448046f, 0.09405518f, -0.09977283f, -0.07311570f, 0.06466313f, 
    0.15352477f, -0.12889728f, 0.01188475f, 0.07470921f, 0.13162871f, -0.07882489f, 0.03100241f, -0.00590682f, 
    0.00041692f, -0.03388141f, -0.00899083f, 0.01529570f, -0.05701869f, -0.06742839f, 0.01472266f, -0.09288831f, 
    0.04619925f, 0.01070918f, -0.03270973f, -0.00832519f, -0.01185713f, 0.00606232f, 0.05084471f, -0.09149545f, 
    0.06805265f, 0.04755716f, -0.04879032f, 0.04038132f, 0.03597719f, -0.02763654f, -0.03594091f, 0.01061365f, 
    0.01798732f, 0.00294041f, -0.02028983f, 0.00481303f, 0.15747681f, 0.06615105f, 0.06697547f, 0.08319137f, 
    -0.03729000f, -0.03961700f, -0.03638416f, -0.01187192f, 0.08493638f, 0.05392150f, -0.01124035f, 0.06316338f, 
    0.02092589f, 0.00831999f, 0.01568271f, -0.00858315f, 0.02863877f, 0.03073566f, -0.02942206f, -0.00912723f, 
    -0.01705675f, -0.01674466f, 0.11557116f, -0.00335929f, -0.44623452f, -0.12714761f, 0.15838170f, 0.05428473f, 
    -0.24993570f, 0.05552430f, -0.02369895f, 0.00800975f, -0.08456636f, 0.10152280f, -0.05995161f, 0.03694122f, 
    -0.03863078f, 0.04451296f, 0.05358152f, -0.10306852f, -0.07493529f, -0.02849487f, -0.03716052f, -0.05844289f, 
    -0.34636620f, -0.18190674f, -0.05588839f, -0.19684084f, -0.13010979f, 0.01562528f, -0.00179406f, 0.00774427f, 
    -0.01926123f, 0.05197369f, -0.06021436f, -0.01319997f, -0.10981126f, -0.05631104f, 0.01396878f, 0.08825373f, 
    0.01285643f, 0.04811572f, -0.01579616f, 0.11493416f, 0.15869552f, 0.22241439f, 0.07780652f, -0.02467879f, 
    0.00868710f, 0.01266179f, -0.02920096f, 0.01625654f, 0.02107847f, 0.01423690f, -0.06073534f, -0.03402946f, 
    0.08772141f, 0.02258376f, -0.02474775f, -0.03306263f, 0.13135816f, -0.06877618f, 0.03044810f, 0.04833052f, 
    -0.03423748f, -0.00511807f, -0.04738882f, 0.05906425f, 0.07783135f, 0.01821121f, -0.02830716f, 0.05253188f, 
    0.05954186f, -0.01814782f, 0.03919586f, 0.03621195f, 0.00030245f, 0.04283293f, 0.06508344f, 0.00580209f, 
    -0.01490181f, -0.10060644f, -0.00481926f, 0.04552587f, 0.11620177f, 0.13220857f, -0.09894241f, -0.03518368f, 
    -0.13618328f, 0.06454566f, 0.02871165f, 0.05786748f, -0.00155193f, 0.01555811f, -0.01758176f, -0.05919228f, 
    0.00799947f, -0.01395757f, 0.09149279f, 0.10152964f, 0.10760563f, 0.00827807f, 0.07649141f, 0.11666733f, 
    -0.02636514f, -0.07972879f, -0.08098277f, -0.05862586f, 0.02047042f, -0.03144895f, -0.00294440f, -0.00434458f, 
    0.02450034f, 0.01203161f, 0.05042130f, -0.01463555f, -0.08277304f, 0.04007435f, 0.02643511f, 0.04293923f, 
    0.10407896f, 0.07816972f, 0.06235105f, 0.08479833f, 0.20772453f, 0.12775968f, -0.11287075f, 0.05843174f, 
    -0.05272209f, -0.12776083f, -0.14255768f, 0.00618443f, 0.00106940f, -0.11900146f, -0.00806585f, 0.01008281f, 
    -0.02029457f, -0.09018084f, -0.04667026f, -0.03182251f, -0.05523575f, 0.00523586f, -0.08519093f, -0.02455132f, 
    -0.01003315f, 0.13701272f, -0.01950206f, 0.02361784f, 0.07037497f, 0.00980068f, -0.00956213f, -0.04394994f, 
    0.03262292f, 0.02552644f, -0.00179253f, -0.02489233f, 0.04966708f, -0.00061646f, 0.01243469f, 0.00468336f, 
    -0.01999339f, -0.05570294f, -0.06719594f, 0.00363777f, 0.19253059f, -0.02968857f, -0.04532363f, -0.00966384f, 
    -0.00413425f, -0.08849823f, -0.10790113f, -0.10069422f, -0.00926503f, -0.08203674f, -0.00651950f, 0.06003647f, 
    -0.04975230f, -0.01753215f, -0.04304592f, -0.13185620f, 0.02407112f, -0.01742688f, -0.11409959f, 0.01182271f, 
    -0.25634107f, -0.26845026f, -0.05836520f, -0.03140352f, 0.24377699f, 0.03524365f, 0.03613883f, -0.00393577f, 
    -0.03516172f, -0.13168608f, 0.00963215f, -0.06204748f, -0.00771760f, 0.06651080f, 0.09109751f, -0.00316302f, 
    0.06585418f, 0.05284413f, 0.05370239f, 0.03989686f, 0.18974040f, 0.03714599f, 0.07709758f, -0.06630438f, 
    -0.05746028f, -0.07330241f, -0.10351904f, 0.00087671f, 0.04292881f, -0.01642992f, -0.04108648f, 0.02439235f, 
    -0.05394972f, -0.03018636f, -0.01919033f, -0.02770833f, 0.02683546f, 0.03056399f, 0.01555586f, -0.02996136f, 
    -0.14034742f, 0.09296366f, 0.07491596f, 0.10265528f, 0.06055260f, 0.03343303f, -0.00216763f, -0.03809765f, 
    0.00818288f, 0.07670032f, -0.03546497f, 0.05186306f, 0.03939619f, -0.03507248f, 0.00583287f, -0.04506872f, 
    0.04558184f, 0.09234703f, -0.07135287f, 0.03217193f, -0.42917165f, -0.05091105f, -0.15178114f, -0.14845568f, 
    -0.10298326f, 0.10890469f, 0.02155069f, -0.04790796f, -0.02411391f, 0.02887012f, 0.02909280f, -0.00382974f, 
    0.01666067f, 0.01226975f, 0.00081845f, -0.04803223f, -0.08698735f, -0.01118542f, 0.02107353f, 0.03362530f, 
    -0.10295549f, -0.04084900f, 0.02228247f, 0.01819583f, 0.08581641f, 0.05634233f, 0.05451782f, -0.08560878f, 
    0.04391329f, -0.08821745f, -0.00454640f, 0.01497083f, -0.11230955f, -0.01466387f, 0.05882292f, -0.06662625f, 
    -0.02424526f, -0.03873578f, -0.05552012f, 0.04369268f, -0.06718010f, -0.10285996f, 0.01062878f, 0.00600562f, 
    0.05101866f, 0.05632822f, 0.13076092f, -0.01439121f, 0.10803743f, -0.00351039f, 0.02305308f, 0.04305794f, 
    0.04031949f, 0.02331247f, 0.03117802f, 0.07367910f, 0.06832200f, -0.05189044f, -0.00135318f, 0.00104879f, 
    -0.14486755f, 0.03455604f, 0.08489683f, -0.06281406f, 0.07747672f, -0.07676266f, 0.01255873f, 0.01810750f, 
    -0.02257937f, -0.09665942f, 0.00376589f, -0.01075222f, 0.05564220f, -0.01385572f, -0.03006959f, -0.02913650f, 
    -0.09967726f, 0.01377776f, -0.11083458f, -0.00264711f, 0.06911093f, 0.09937020f, -0.13710436f, -0.18553384f, 
    -0.00383068f, -0.16175954f, -0.12458757f, -0.02096604f, -0.06443549f, -0.13348271f, 0.02980516f, -0.02398924f, 
    -0.04673408f, -0.01995951f, -0.01870101f, 0.01901804f, -0.01986527f, -0.03491569f, 0.09527698f, -0.01297457f, 
    0.00121296f, -0.10155933f, 0.03175952f, -0.01468177f, -0.16467907f, 0.05947824f, 0.00909774f, 0.05972617f, 
    -0.02963503f, 0.04453614f, -0.06597642f, -0.02341027f, 0.05918366f, 0.00252397f, -0.00747997f, -0.10078304f, 
    -0.00236058f, -0.07152746f, -0.02709240f, 0.00814735f, -0.06394193f, -0.29124328f, 0.05704824f, -0.12922281f, 
    -0.06268919f, -0.03411395f, 0.08598921f, 0.02431211f, -0.00321881f, -0.02356222f, -0.02241823f, -0.07836405f, 
    -0.02653111f, 0.03264512f, -0.03213250f, -0.07069701f, 0.07733479f, -0.05345027f, 0.02337755f, 0.00910184f, 
    0.06479400f, -0.37091908f, -0.10472419f, -0.01612778f, -0.21860178f, 0.02690788f, 0.10361553f, 0.08319256f, 
    -0.06105838f, 0.09000978f, -0.04614597f, 0.02987014f, -0.04065485f, -0.05120237f, -0.08235610f, -0.09503821f, 
    0.01947700f, -0.06975488f, -0.07190038f, -0.11850344f, 0.01812262f, 0.05086838f, 0.03659260f, 0.06891936f, 
    0.08931154f, -0.07757054f, -0.02050849f, 0.06965660f, -0.02158946f, 0.04291275f, -0.02644612f, 0.00759821f, 
    0.03306025f, -0.00605001f, -0.02076512f, 0.04153059f, -0.03727524f, 0.03592362f, 0.00043116f, -0.00332611f, 
    0.20646955f, 0.04485518f, 0.02792832f, 0.01038761f, -0.05222990f, -0.06507014f, 0.02281300f, 0.01509899f, 
    0.01299175f, -0.08965711f, 0.02590824f, -0.09642874f, -0.10396971f, 0.02711499f, -0.08142370f, 0.00146730f, 
    -0.02893831f, 0.03374787f, -0.02513615f, -0.05976320f, 0.18685924f, 0.09198896f, -0.03061128f, -0.04106480f, 
    -0.12025470f, -0.08693569f, -0.06379092f, 0.00722192f, -0.09833057f, -0.12040674f, -0.05567396f, -0.02263701f, 
    0.08755892f, -0.04599640f, -0.10456723f, 0.06492953f, -0.01309261f, -0.01544691f, -0.02671454f, -0.08527784f, 
    0.36104721f, 0.02432374f, -0.10513185f, -0.07226636f, 0.04360771f, -0.04366276f, 0.00396921f, -0.00358708f, 
    0.04357575f, -0.07324899f, 0.14431545f, -0.02519868f, 0.00982081f, -0.01735014f, -0.03683951f, 0.08415557f, 
    -0.11079779f, 0.00446466f, 0.02646074f, 0.06319589f, 0.17705007f, 0.04536277f, -0.13673815f, 0.03165353f, 
    -0.13190222f, 0.02669117f, 0.03537193f, 0.03171689f, 0.01071408f, 0.04035269f, -0.01964670f, -0.00219449f, 
    -0.04915981f, -0.00347303f, 0.03577434f, 0.02135348f, 0.05282687f, 0.03180025f, 0.00345355f, 0.00219702f, 
    0.08304450f, -0.01157510f, -0.11570445f, -0.07243965f, 0.24973696f, 0.09491692f, -0.10021115f, -0.02071308f, 
    0.10529394f, 0.07282331f, -0.01874937f, -0.07266083f, -0.00545418f, -0.02279539f, 0.08647566f, 0.05923957f, 
    0.00169330f, -0.01107201f, -0.01633746f, 0.02652631f, 0.17562903f, -0.06787135f, -0.19857037f, 0.09176434f, 
    -0.05333739f, 0.18782002f, -0.00428128f, -0.04205115f, -0.00920809f, -0.08816833f, 0.02254258f, -0.03003564f, 
    0.04595841f, 0.06776373f, -0.08218650f, 0.07393118f, 0.02088090f, -0.06609377f, -0.16473180f, -0.00031174f, 
    -0.17492983f, 0.22715707f, -0.08054592f, 0.02999021f, 0.14684270f, -0.10840160f, -0.03149455f, -0.02551863f, 
    0.09080883f, 0.17742006f, -0.06798720f, 0.05052791f, 0.05172896f, -0.04359189f, 0.01349435f, 0.00759998f, 
    -0.03123699f, -0.03134168f, -0.06538374f, -0.05417314f, 0.05496644f, -0.12917627f, 0.00353401f, -0.00831667f, 
    0.06878918f, -0.06957855f, -0.05083488f, 0.03107260f, 0.01847143f, -0.09510937f, -0.02165610f, -0.05329394f, 
    0.02997593f, 0.00816581f, 0.00347018f, -0.06707870f, -0.02004434f, -0.04403591f, -0.00616913f, 0.03201319f, 
    0.23302193f, -0.00742202f, -0.21765916f, -0.14198211f, 0.11896578f, 0.05889196f, -0.10536487f, -0.06675459f, 
    0.00479509f, 0.02105847f, -0.00045637f, -0.04382035f, -0.00400669f, 0.01375706f, -0.02807785f, 0.06526642f, 
    0.04411897f, 0.05128080f, 0.04631381f, 0.00757397f, -0.21175086f, 0.03689360f, 0.04079282f, -0.07678103f, 
    0.03708446f, -0.02999540f, 0.04634036f, -0.01401453f, 0.05862287f, -0.01305256f, -0.00677682f, -0.00483629f, 
    0.04993502f, 0.02821407f, -0.05851591f, -0.03246998f, -0.07236633f, 0.05797928f, -0.11516888f, -0.04584059f, 
    0.10312393f, -0.00084867f, -0.16346021f, -0.10686724f, -0.32753798f, 0.03568598f, 0.00777059f, 0.03914295f, 
    0.03443552f, 0.08468227f, 0.08026116f, -0.02500332f, -0.03060566f, -0.03541166f, 0.07047416f, -0.07408455f, 
    -0.05570291f, -0.03736442f, -0.02864140f, 0.06969880f, -0.30511427f, 0.06110692f, 0.01311524f, 0.09421735f, 
    0.08254790f, -0.13786434f, 0.12422645f, -0.03950127f, -0.01073424f, -0.10522649f, 0.01955942f, -0.05030381f, 
    -0.01524014f, 0.04450107f, 0.06674349f, 0.02646693f, 0.07184682f, -0.01181535f, -0.01900491f, -0.05006263f, 
    0.08601478f, 0.02546025f, -0.08815490f, -0.03749612f, 0.15043797f, 0.03035289f, -0.07436837f, -0.00690399f, 
    0.03103097f, 0.03426791f, 0.01372317f, 0.00949876f, -0.02766365f, -0.01740221f, -0.00050701f, -0.01998805f, 
    -0.03176550f, 0.04462682f, 0.05737906f, 0.05093171f, -0.33439222f, 0.23977029f, -0.15765719f, -0.01192719f, 
    0.03530477f, -0.01755134f, 0.02365663f, 0.05958843f, -0.01012275f, 0.19747166f, -0.05182153f, -0.02567388f, 
    0.08249965f, -0.06956973f, 0.01784659f, 0.01275093f, -0.04267516f, -0.00164722f, -0.06841661f, -0.16332500f, 
    -0.07563136f, 0.14238913f, -0.09628623f, -0.03508115f, 0.08759187f, 0.01843480f, -0.10038663f, 0.04169155f, 
    -0.03161817f, -0.05929919f, 0.04332251f, 0.06251533f, 0.01319822f, 0.06008260f, -0.02262093f, 0.01788274f, 
    -0.00917822f, 0.02927461f, 0.04296495f, -0.00320079f, -0.20335469f, 0.14043181f, -0.03546653f, -0.07179112f, 
    0.32304120f, 0.01713458f, -0.13036336f, -0.04133240f, 0.03008624f, 0.01336123f, 0.01406329f, -0.03622427f, 
    -0.01506636f, 0.09006125f, 0.02157250f, -0.03433898f, 0.05301271f, 0.00097399f, 0.03923409f, 0.01388761f, 
    -0.17846589f, -0.00229815f, -0.07407256f, -0.09674139f, -0.07928710f, 0.05645452f, -0.07589719f, 0.00968591f, 
    0.03748062f, 0.05111400f, -0.03318967f, -0.01594023f, 0.02970243f, 0.00447360f, -0.01375548f, 0.02752196f, 
    0.08343776f, 0.03902910f, 0.01374258f, -0.01032502f, 0.37920979f, 0.03512481f, -0.20839192f, -0.00152504f, 
    -0.18480150f, -0.03229363f, -0.03353416f, 0.06621244f, -0.02235684f, 0.02819544f, 0.03847064f, 0.00192069f, 
    0.04590351f, -0.01064407f, -0.06076971f, 0.01116959f, -0.01071898f, 0.01401222f, -0.03069054f, 0.02834667f, 
    -0.12813529f, -0.01052883f, 0.05568033f, 0.04561083f, -0.00867342f, -0.04216036f, 0.00349973f, 0.05094617f, 
    -0.00954251f, -0.01832661f, -0.06030804f, -0.01476321f, 0.01551793f, -0.01910172f, 0.03309235f, -0.01137432f, 
    -0.03692421f, 0.03818070f, -0.02089018f, 0.02329724f, 0.07954519f, 0.05765592f, -0.00310778f, -0.03665463f, 
    -0.08008309f, -0.03105638f, -0.08548511f, 0.00032436f, -0.05208314f, -0.15552594f, 0.07394483f, 0.00578965f, 
    0.08083689f, -0.04986506f, -0.00799089f, 0.00498314f, 0.03440353f, 0.01293730f, 0.03286211f, 0.03007680f, 
    -0.06173116f, -0.18347183f, -0.14072229f, -0.01280306f, -0.19761635f, 0.02419848f, 0.01406369f, 0.02852044f, 
    0.01840357f, -0.01254758f, -0.01906716f, -0.03554389f, -0.04710099f, 0.00515687f, 0.05500995f, -0.02988406f, 
    -0.06313613f, -0.05546986f, -0.02890831f, -0.09621229f, 0.19703862f, 0.06961046f, -0.03844760f, -0.09617605f, 
    0.04587248f, -0.17192708f, -0.02062000f, -0.04466620f, 0.00489198f, -0.15178071f, -0.10327823f, 0.00050562f, 
    -0.00017297f, 0.04772257f, -0.01199604f, -0.00662881f, -0.08771282f, 0.02879824f, 0.02849305f, 0.01309634f, 
    -0.16034536f, 0.16935606f, -0.03419750f, -0.00443799f, 0.02699829f, -0.02710719f, -0.03334757f, 0.04236665f, 
    -0.16785708f, 0.00453625f, -0.02962106f, 0.05313850f, 0.04244062f, -0.11676962f, -0.05992338f, 0.05739927f, 
    0.01219187f, -0.07210085f, 0.02445174f, -0.04351067f, 0.31283113f, -0.02910051f, -0.26186067f, -0.01107868f, 
    -0.04833873f, 0.08967763f, -0.03123149f, -0.05908510f, -0.00619396f, -0.01052180f, 0.06956396f, 0.05923689f, 
    0.01207269f, 0.10356285f, 0.04806604f, 0.04694713f, -0.01374086f, -0.03904559f, -0.00838058f, 0.04191646f, 
    0.11276264f, -0.05352515f, -0.04718914f, 0.11340962f, -0.02766260f, 0.08832307f, -0.06295397f, -0.04472209f, 
    0.04657243f, 0.08576010f, 0.01099866f, -0.00503754f, -0.00402557f, 0.05333840f, 0.00527685f, -0.02029487f, 
    0.03019545f, 0.03085055f, -0.06090513f, -0.03817473f, -0.16321011f, 0.22434776f, -0.08524783f, -0.10341924f, 
    0.04818718f, 0.01605806f, -0.13521703f, 0.04950559f, 0.08176580f, 0.00995116f, 0.07110964f, 0.06839862f, 
    0.02247971f, 0.03070588f, -0.02147092f, 0.03074311f, 0.06761898f, 0.03473131f, -0.05586739f, 0.01377519f, 
    0.25714189f, 0.19724579f, -0.18009479f, 0.01732089f, 0.04558324f, 0.05362906f, -0.01101091f, -0.03478982f, 
    0.03056627f, -0.03898035f, 0.09020662f, 0.07730050f, -0.02457541f, 0.01443189f, -0.00958890f, 0.02797033f, 
    -0.01125424f, 0.05294626f, 0.00126605f, 0.08298577f, 0.07964734f, -0.16361678f, 0.06042415f, 0.03587620f, 
    -0.07796128f, 0.05098110f, 0.07232633f, -0.01538160f, -0.04212221f, 0.02914055f, -0.08955345f, -0.10024310f, 
    -0.02046052f, 0.02703994f, -0.05000827f, -0.05803455f, -0.01473244f, -0.05745088f, -0.12053584f, -0.03402055f, 
    -0.07403293f, 0.02980932f, -0.17302503f, -0.04412306f, 0.03669044f, -0.01675191f, -0.04213846f, 0.03055950f, 
    0.06369780f, -0.04649629f, 0.00835123f, 0.10638855f, -0.08156441f, -0.03774293f, -0.06263710f, -0.06644467f, 
    0.04395404f, 0.03613075f, 0.10668582f, -0.00636734f, 0.11496456f, 0.11839511f, -0.13620946f, 0.02040604f, 
    0.26233998f, 0.06273932f, -0.01108503f, -0.02146664f, 0.05588886f, 0.01318632f, -0.02115974f, 0.02105016f, 
    0.00383697f, -0.00721336f, 0.03858947f, -0.03742359f, 0.05537439f, 0.02017651f, 0.02608803f, -0.05709633f, 
    -0.29000518f, -0.10411439f, 0.01604821f, -0.08144645f, -0.08495831f, 0.05116032f, 0.06196004f, 0.01638091f, 
    0.00442027f, -0.05103109f, -0.04626139f, 0.03627972f, 0.08526254f, 0.01288483f, -0.11023860f, -0.04378637f, 
    -0.03387637f, 0.04378954f, -0.09661043f, -0.05745719f, -0.10728662f, -0.03832729f, -0.07807978f, -0.06744824f, 
    -0.18300872f, 0.04805405f, 0.01200347f, 0.07012902f, 0.02283473f, 0.05248959f, 0.02381972f, 0.01988896f, 
    0.02052613f, -0.07189672f, -0.00892232f, -0.04785021f, -0.02242437f, -0.02085930f, -0.06217128f, -0.03945452f, 
    -0.11032698f, -0.21565779f, -0.03869015f, 0.06208964f, -0.01758517f, -0.02137448f, 0.01594320f, 0.07860578f, 
    -0.08963753f, 0.05847488f, -0.11207861f, 0.00905889f, 0.00300344f, -0.02866737f, -0.09349022f, -0.06143674f, 
    -0.00018292f, -0.05538195f, -0.09594099f, -0.01354493f, -0.00823246f, 0.03540104f, -0.02421876f, 0.01563367f, 
    0.17881505f, 0.05575406f, -0.07641132f, -0.08097436f, 0.02195897f, 0.03135407f, 0.01006076f, 0.08542847f, 
    -0.01364705f, -0.05833735f, -0.00748658f, 0.00598978f, 0.01155541f, 0.07055935f, 0.01449953f, -0.02210779f, 
    -0.21796370f, 0.18982361f, -0.12113794f, 0.11051445f, -0.13308679f, 0.04054201f, 0.04874612f, 0.00457333f, 
    0.05944171f, -0.00364041f, 0.00458068f, -0.01555223f, -0.05991391f, -0.02632210f, 0.10171729f, -0.00489358f, 
    0.06379347f, 0.00018380f, -0.10483873f, 0.02435287f, 0.08079734f, -0.00399611f, -0.08212128f, -0.01639989f, 
    0.04430013f, 0.01124516f, -0.05559295f, -0.02295427f, -0.10520569f, -0.09499158f, -0.04618238f, 0.04072973f, 
    -0.02624457f, -0.01656347f, -0.07729398f, -0.01339484f, 0.00591044f, -0.00659772f, 0.03592357f, 0.02211822f, 
    -0.10997736f, -0.52169544f, -0.15288253f, 0.02345205f, -0.03705765f, -0.03627742f, 0.05880846f, -0.03492448f, 
    0.00354477f, -0.00906868f, -0.04201016f, 0.01373262f, -0.05026058f, 0.04431241f, -0.04632487f, 0.06770381f, 
    0.01267469f, -0.08743903f, -0.07965513f, -0.08053203f, 0.40333289f, -0.09638156f, -0.15875772f, 0.01610837f, 
    -0.01831571f, -0.00182499f, 0.04828548f, -0.03926257f, -0.01287135f, 0.02137302f, 0.05323105f, -0.01719262f, 
    -0.03060507f, 0.03986559f, 0.03724306f, 0.02714138f, -0.07063586f, -0.02664773f, 0.03911796f, 0.02854260f, 
    0.05181260f, -0.01206234f, -0.06296621f, 0.01049080f, 0.06920774f, -0.06586874f, 0.00881669f, 0.02293738f, 
    0.05901333f, -0.06713432f, 0.08743396f, 0.00487384f, -0.04017422f, 0.04183971f, 0.04028907f, 0.09282704f, 
    -0.02223041f, -0.04127698f, 0.02883754f, 0.03424773f, -0.03070087f, 0.06641322f, -0.04600474f, -0.03718279f, 
    0.08175185f, -0.00998601f, 0.03205815f, -0.00004912f, 0.02945957f, -0.01234155f, 0.02815185f, 0.04891814f, 
    -0.08529490f, -0.03608105f, 0.04134256f, 0.03593494f, -0.07952514f, 0.05407009f, 0.01772162f, 0.02551580f, 
    -0.11315481f, 0.06492124f, 0.01937780f, 0.04193491f, -0.12589258f, 0.08724280f, -0.00865325f, 0.00702582f, 
    -0.03381112f, 0.00457245f, 0.01745877f, -0.03890253f, 0.02875713f, -0.02676311f, -0.03110682f, -0.07080706f, 
    0.03502442f, -0.07740396f, 0.06129115f, 0.01401136f, 0.00046052f, -0.10437085f, 0.05120201f, -0.06690000f, 
    0.04160731f, 0.04976716f, 0.03256616f, -0.01254368f, -0.02973229f, 0.00206365f, 0.06955460f, 0.01941328f, 
    -0.05138032f, -0.03960171f, 0.03331664f, 0.01280309f, -0.03587205f, 0.02525245f, 0.01563175f, -0.10747837f, 
    0.11764819f, -0.03502677f, -0.00228853f, 0.04448408f, 0.03021617f, 0.08366270f, -0.05920048f, -0.04318545f, 
    -0.01417913f, 0.00040233f, 0.00806571f, 0.02891787f, 0.01193197f, 0.03574035f, 0.00164977f, -0.01581448f, 
    0.02563780f, 0.00512207f, -0.07556224f, -0.02491889f, 0.16371073f, -0.21819355f, -0.08949565f, -0.24229328f, 
    -0.00745915f, 0.01482265f, -0.10333787f, 0.04052389f, 0.11708827f, 0.09755496f, -0.01775179f, -0.11569168f, 
    0.03018092f, 0.01219260f, -0.01429639f, 0.06294696f, 0.00707751f, -0.02203505f, 0.05743511f, 0.00196290f, 
    0.15815684f, 0.23970476f, -0.06653015f, -0.02133635f, 0.38048115f, 0.15448478f, -0.08273769f, 0.02371496f, 
    0.00171827f, 0.06745558f, -0.02530011f, 0.05981277f, 0.01802780f, 0.05377482f, -0.02172310f, -0.07063681f, 
    0.04803211f, 0.07736187f, 0.02085305f, -0.05470441f, 0.04675728f, -0.17535992f, -0.04371043f, 0.07973115f, 
    0.13200319f, 0.02174211f, 0.03115092f, 0.04038308f, 0.03841795f, 0.03758471f, 0.01327565f, -0.00183301f, 
    -0.06109136f, 0.00587082f, 0.11046233f, 0.04372900f, 0.00497146f, -0.03667585f, 0.05265668f, 0.08990421f, 
    -0.00618454f, -0.02935423f, 0.01377924f, 0.05025394f, 0.03720254f, -0.05305436f, 0.02170525f, -0.03781817f, 
    0.01118516f, -0.06286479f, 0.05269644f, 0.00087606f, -0.00579686f, 0.04108717f, -0.01509095f, 0.08640850f, 
    0.01540911f, 0.02146790f, 0.01816586f, -0.06243457f, 0.05624196f, 0.06655492f, 0.04816367f, 0.06580616f, 
    0.16558392f, 0.09477769f, 0.02122365f, 0.00223459f, 0.08411611f, -0.02471605f, 0.03536709f, -0.11477041f, 
    0.04932496f, 0.06539655f, -0.03341707f, 0.02965046f, -0.05576025f, 0.02286851f, 0.03958062f, -0.04089579f, 
    -0.11795001f, -0.17040861f, -0.04198968f, -0.05418402f, -0.06977676f, 0.10697839f, 0.02810092f, 0.03169260f, 
    -0.03194258f, 0.04680508f, -0.01443420f, 0.03571176f, 0.01460641f, -0.07430050f, -0.07369427f, -0.01248735f, 
    -0.10410737f, -0.04004333f, -0.10068820f, 0.00237949f, -0.04777833f, -0.04509787f, 0.07272957f, -0.04347741f, 
    -0.01148657f, -0.00055250f, 0.07562850f, 0.05296036f, -0.04272611f, -0.09772470f, -0.09982926f, -0.07382305f, 
    0.04816654f, -0.03762153f, 0.01045356f, -0.10889672f, -0.00617582f, -0.02838853f, -0.09173345f, -0.01053545f, 
    -0.06338739f, 0.00241117f, 0.04526345f, 0.00774481f, 0.10928520f, -0.09819944f, 0.01282774f, 0.06669042f, 
    0.01535939f, 0.02216443f, 0.08391502f, -0.05355595f, -0.02620549f, 0.03263613f, -0.00759564f, 0.03059415f, 
    0.00302899f, -0.10221136f, 0.03725090f, 0.10400937f, -0.17787251f, 0.15539476f, 0.02007701f, -0.03501749f, 
    -0.06499488f, 0.01894794f, -0.04554937f, -0.01854203f, -0.04757369f, -0.05941274f, 0.01909450f, -0.03022607f, 
    0.06544823f, -0.10563336f, -0.01644354f, -0.00711893f, -0.00083966f, -0.06558271f, -0.02925972f, -0.02844893f, 
    -0.22839773f, 0.23255457f, -0.02547455f, 0.14432149f, 0.03149378f, 0.10770438f, 0.14595759f, 0.02708944f, 
    0.00620553f, 0.00412837f, 0.01918323f, 0.05682128f, -0.00565752f, 0.01080831f, 0.02827755f, -0.07125816f, 
    0.02332803f, -0.02312766f, -0.01868502f, 0.02514309f, 0.00313200f, -0.00919873f, 0.00115424f, -0.03480154f, 
    0.03467467f, -0.03369885f, 0.03479144f, -0.02256311f, -0.06665372f, -0.07499937f, -0.05692422f, 0.00185262f, 
    0.06257950f, -0.02904905f, -0.06162633f, -0.01462113f, -0.06321498f, -0.02209715f, -0.03004062f, -0.02738649f, 
    -0.37727550f, 0.04714440f, -0.01435314f, -0.07790253f, 0.11260315f, -0.07602527f, 0.00126998f, 0.01428111f, 
    0.08079500f, 0.05305042f, 0.00905471f, -0.01448736f, 0.04533219f, 0.04308259f, -0.01305762f, 0.03735450f, 
    -0.02451791f, -0.01050471f, -0.06418317f, -0.10253308f, 0.15823644f, -0.10256778f, -0.09860292f, 0.04424998f, 
    -0.17007200f, 0.01245766f, 0.05251627f, 0.08348813f, -0.05139609f, -0.02519793f, 0.07436396f, -0.04040728f, 
    0.02292061f, -0.02668021f, -0.06250696f, 0.09564714f, 0.05198871f, -0.03713900f, 0.00473740f, 0.04297774f, 
    -0.19571775f, 0.14708960f, -0.02452560f, -0.05069655f, -0.17532030f, 0.07803236f, 0.05316459f, -0.02527643f, 
    0.01644641f, -0.04429651f, -0.05777190f, -0.04905542f, -0.03776783f, 0.01551795f, 0.03878064f, 0.02027034f, 
    0.03611843f, -0.07756453f, -0.00001296f, 0.06186042f, -0.13430440f, 0.13166434f, -0.12267424f, -0.00735310f, 
    0.10356751f, 0.12787724f, -0.03805489f, -0.07230595f, -0.04374228f, -0.04831523f, 0.00948237f, 0.08054128f, 
    -0.01722459f, 0.01352519f, 0.02733287f, -0.09824198f, 0.05696180f, 0.07938634f, -0.01227565f, 0.01353635f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06877123f, 0.04282221f, -0.04376496f, 0.00011778f, 0.01667054f, 0.00142246f, 0.01714464f, -0.05169755f, 
    -0.00632161f, 0.01992738f, 0.03461227f, 0.03174614f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
