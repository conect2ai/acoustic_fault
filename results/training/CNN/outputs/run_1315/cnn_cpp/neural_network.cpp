#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.38602543f, 0.16800082f, -0.24264875f, -0.94819897f, -0.08793812f, 0.18743455f, 0.01284464f, 0.50547397f, 
    0.20843937f, 0.62525338f, 0.09399239f, -0.22057518f, 0.23555821f, -0.58451140f, -0.18671720f, 0.30191636f, 
    -0.13565232f, -0.58048373f, -0.02200531f, 0.08083367f, -0.18329516f, -0.21253937f, -0.61112428f, -0.29060721f, 
    -0.63759565f, -0.90328181f, -1.01734960f, -1.03443933f, -0.90619606f, 0.62810868f, -0.65207905f, -0.08056984f, 
    0.75829762f, 1.18474948f, 0.27698302f, 0.23858519f, 0.08561797f, 0.02074140f, -0.10998210f, 0.24933551f, 
    -0.24168479f, -0.44254276f, -0.17926343f, -0.24138740f, -0.21479626f, -0.14727312f, 0.31971607f, 0.00023507f, 
    0.20896591f, 0.64138252f, -1.00777996f, 0.87836564f, 1.35159945f, -0.94812500f, -1.17398345f, -0.01475573f, 
    0.00660405f, 0.65591681f, -0.04526459f, -0.04977053f, 0.02582098f, -0.06836490f, 0.35034740f, -0.62750167f, 
    -0.00845339f, 0.05952108f, -0.03729356f, -0.30691767f, 0.09448614f, 0.17801052f, 0.02282798f, 0.05118438f, 
    -0.08482725f, -0.30049735f, 0.60039133f, -0.51807058f, -0.50239152f, 0.81788003f, 0.21685831f, -0.23484990f, 
    -1.00877261f, -1.29783165f, -1.13961053f, 0.10568724f, -0.69083726f, 0.36299169f, 0.68543667f, -0.14160888f, 
    0.35738990f, 0.46792436f, -0.06014938f, 0.04813660f, -0.31981564f, -0.00054537f, -0.33990979f, -0.30055487f, 
    -0.18142311f, -0.14610445f, 0.25477216f, 0.27546257f, 0.06574620f, -0.25568062f, -0.05637540f, 0.11035098f, 
    0.07482472f, -0.18787391f, -0.20372280f, 0.48239788f, 0.22881989f, 0.84665191f, -0.16488001f, 0.31889102f, 
    0.01282478f, 0.18560766f, 0.19665278f, -0.34646854f, 0.12199884f, 0.02783044f, -0.34613335f, 0.70549840f, 
    0.25197279f, -0.01968412f, 0.03469555f, 0.11022937f, -0.45473638f, 0.62039632f, -0.67315966f, 0.37796375f, 
    0.65618151f, 0.69773489f, -0.20053697f, 0.51890236f, 0.42730710f, -0.25055984f, -0.73992699f, -0.28280568f, 
    -0.22083542f, 0.19897723f, -0.21534953f, -0.07887703f, -0.35800985f, -0.18373391f, -0.01276096f, 0.08436004f, 
    -0.29374793f, 0.05856899f, 0.23028229f, -0.21394178f, -0.24315244f, 0.06945421f, -1.12171876f, -1.11506236f, 
    -0.85483068f, -1.28465617f, -0.61713445f, 0.17546853f, -1.09719515f, -1.17648172f, -1.09454978f, -0.66579974f, 
    -0.08267302f, 0.25086430f, -0.03619497f, 0.15971658f, -0.21710725f, 0.05853568f, -0.31820640f, -0.09352709f, 
    -0.18712397f, -0.20772029f, -0.29354444f, 0.54882562f, 0.19947149f, 0.20457751f, -0.04734099f, 0.13379698f, 
    -0.02910013f, -0.44731852f, 0.06483496f, 0.28765848f, 0.17941080f, 0.61240321f, -0.13042945f, -0.07888579f, 
    0.09105828f, -0.26934743f, 1.12334764f, -0.50096571f, -0.23785843f, -0.16347161f, 0.14347285f, -0.45676142f, 
    0.17128463f, -0.24290073f, -0.15379712f, -0.02376045f, -0.08388124f, -0.08988260f, -0.18948759f, 0.62528199f, 
    0.13830926f, 0.46649608f, 0.33063009f, -0.03601278f, -0.31905189f, -0.52376860f, -0.01829488f, -0.15789689f, 
    0.20907037f, 0.09288015f, 0.01058789f, 0.06926511f, -0.22917084f, 0.04761000f, 0.45282716f, 0.34475181f, 
    -0.00649877f, -0.44852701f, 0.19919682f, -0.67094743f, 0.18297032f, 0.29513311f, 0.45948160f, 0.09840151f, 
    0.69856089f, -1.28837729f, -0.64514107f, -0.00555293f, -0.29754445f, 0.37452304f, -0.94391584f, -0.13482402f, 
    -0.02598726f, 0.08035319f, -0.34961838f, -0.13002691f, -0.65096021f, -0.72039580f, -0.42864525f, 0.00077552f, 
    -0.27926460f, -0.68640149f, -0.43197694f, -0.66595197f, -0.56205249f, -0.31589249f, 0.09801251f, -0.02939951f, 
    -0.58967769f, -0.65264195f, 1.30535591f, 1.12628782f, 0.36536047f, -0.29405770f, 0.03600413f, -0.40391761f, 
    -0.22128302f, -0.38453826f, -0.73605955f, -0.96414685f, 0.18211079f, 0.36703080f, 0.33073276f, 0.04645834f, 
    0.16472726f, 0.17346138f, 0.20399228f, 0.14534189f, 0.16258913f, -0.14726987f, -0.23006682f, 0.36120141f, 
    -0.23237467f, -0.17280464f, -0.05477385f, -0.55383122f, -0.60710037f, -0.84171480f, -1.28102219f, -1.71694422f, 
    1.10411406f, 0.37955138f, 0.05487253f, 0.34982479f, -0.48147494f, -0.18690981f, -0.32749724f, 0.02659448f, 
    0.40532473f, -0.31474325f, 0.20684248f, 0.13469206f, 0.11193988f, 0.33000794f, -0.25804114f, 0.10247691f, 
    0.47529674f, 0.19597511f, -0.21517788f, -0.19917156f, -1.40879965f, -1.39655995f, -0.23178494f, 1.30642891f, 
    0.84132797f, 1.07208729f, 0.78680480f, -0.31727484f, -0.33505109f, 0.33517680f, -0.24341422f, -0.12721148f, 
    -0.74328554f, 0.17401530f, -0.35793021f, 0.31795400f, -0.04730953f, -0.11319113f, 0.18171440f, 0.22211903f, 
    -0.26113585f, -0.34377518f, -0.13914257f, -0.05814333f, -0.29343081f, -0.49855852f, -1.13533378f, 0.39440769f, 
    1.23759663f, -0.47517776f, -0.72337252f, -1.51613295f, -1.08554304f, -0.55440569f, -0.52747607f, -0.49155104f, 
    -0.29871944f, -0.49597174f, -0.71067882f, -0.62920910f, -0.47633207f, -0.18564825f, 0.34660590f, -0.13849151f, 
    -0.38463327f, 0.01849367f, 0.09237837f, -0.27189511f, -0.02684146f, 0.29503858f, -1.49869692f, -0.85729086f, 
    -0.72523683f, 0.37225595f, 0.44678578f, 0.29747191f, 0.33390903f, 0.28516537f, 0.59206986f, 0.80207509f, 
    0.09439697f, 0.28970110f, -0.11253528f, 0.32855970f, -0.25839302f, 0.01660102f, 0.46531144f, 0.20893390f, 
    0.01237705f, -0.14358915f, 0.10917968f, -0.01213732f, 0.01002109f, -0.19633232f, -0.03545141f, 0.30129433f, 
    0.59898025f, 0.20022367f, 0.25673863f, 0.22826566f, -1.00666928f, -0.24166293f, 0.71914953f, 0.64394641f, 
    0.47472259f, 0.09008735f, -0.10344265f, 0.18942267f, -0.14438042f, -0.23749174f, 0.10713734f, -0.10273099f, 
    -0.14378728f, -0.34811193f, -0.28702655f, -0.46666789f, -0.13664232f, -0.06525999f, -0.24265774f, -0.07775588f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37261939f, 0.93288088f, 0.43383783f, 0.43600127f, 0.09705865f, 0.73540610f, -0.39231369f, 0.88183880f, 
    0.69833761f, 0.19935310f, 0.42960334f, 0.58127606f, 0.21212010f, 0.27862117f, 0.18135913f, 0.36817566f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03923980f, 0.07943332f, 0.03827502f, 0.04952300f, 0.11273881f, 0.21940885f, 0.06018483f, 0.14983056f, 
    0.02772997f, 0.09033797f, 0.12068982f, 0.03226508f, -0.04513228f, 0.13786139f, 0.03367532f, -0.21042335f, 
    0.14778326f, 0.17584565f, 0.08899643f, -0.37011284f, -0.14365819f, -0.26519200f, -0.06715315f, -0.12865895f, 
    -0.10589831f, -0.14732519f, 0.12846056f, -0.11671419f, -0.08915529f, -0.17779885f, -0.22441083f, -0.13383809f, 
    -0.07187571f, -0.19206201f, -0.02300600f, -0.49661127f, 0.54824543f, 0.28516135f, -0.02028771f, -0.65298206f, 
    -0.11150382f, 0.03808924f, -0.11419233f, 0.00449808f, 0.20399387f, -0.00070263f, -0.00832519f, -0.10295592f, 
    -0.03195323f, 0.08402770f, 0.12533274f, 0.11990093f, -0.11130010f, 0.02266949f, 0.00964771f, 0.03079701f, 
    -0.33963495f, -0.30279380f, 0.18152949f, -0.01364686f, -0.67838216f, -1.10582793f, 0.25195944f, 0.31836838f, 
    -0.00114708f, -0.16257767f, 0.05416163f, 0.09993711f, -0.02284371f, -0.04179349f, -0.01308264f, -0.01415417f, 
    0.51581001f, 0.34359440f, -0.29539683f, -0.29374924f, 0.03170207f, 0.23409125f, 0.12611800f, 0.10674316f, 
    0.00595515f, -0.09990806f, -0.00117016f, 0.05056870f, -0.97703218f, -0.30842835f, -0.48210680f, -0.31119436f, 
    -0.03145684f, -0.04143901f, 0.03860675f, -0.06403382f, -0.27221191f, -0.12721954f, 0.00749260f, -0.43770486f, 
    -0.11317737f, -0.07726510f, 0.18726619f, 0.05363829f, -0.19267364f, -0.37234393f, -0.01957502f, -0.11100141f, 
    -0.05483262f, -0.20173070f, -0.11872081f, -0.11065388f, 0.44323891f, 0.29265907f, 0.23241831f, -0.09457004f, 
    -0.27342090f, 0.05549374f, -0.08175965f, -0.09888124f, -0.21925564f, -0.21517670f, -0.23305120f, 0.13680284f, 
    -0.06668802f, -0.12358277f, -0.27133715f, 0.20369968f, -0.06382854f, -0.02264839f, 0.11222021f, -0.18617058f, 
    -0.12158854f, 0.06834599f, 0.07973484f, 0.02335892f, 0.25425914f, -0.36180136f, -0.41216552f, -0.04926702f, 
    -0.06047900f, 0.47332379f, -0.08570732f, -0.03534110f, -0.09907991f, -0.01103638f, 0.03298466f, 0.20181200f, 
    0.75859714f, 0.08277772f, -0.18835150f, -0.18346936f, -0.00787614f, -0.04408069f, 0.12540111f, -0.16546449f, 
    -0.07961461f, -0.13275063f, 0.01958602f, 0.10312195f, 0.53592503f, 0.49338758f, -0.01712693f, -0.62622917f, 
    -0.04739661f, -0.00817114f, 0.10760795f, -0.22043391f, 0.03122691f, -0.07905576f, -0.07890207f, 0.06543890f, 
    0.18033472f, 0.26925910f, 0.13309152f, -0.06056894f, 0.05543343f, 0.07001199f, 0.24426354f, 0.00474729f, 
    -0.01818517f, 0.24823521f, -0.14178002f, -0.13952355f, -0.90025300f, -0.26449510f, 0.03612534f, 0.10784858f, 
    0.10978642f, 0.07678074f, -0.05399353f, 0.06717973f, -0.23255156f, -0.14344025f, 0.00182738f, 0.13174835f, 
    0.10709701f, 0.06804527f, -0.16886559f, 0.06297275f, 0.01932452f, 0.02113041f, -0.25465736f, -0.26306033f, 
    -0.40222430f, -0.23631270f, -0.18005823f, -0.14052263f, -0.98756379f, 0.32820028f, -0.39085966f, -0.15356168f, 
    -0.06019539f, 0.19811289f, 0.18172751f, -0.11527393f, 0.00972177f, 0.14368741f, 0.10764116f, -0.09915964f, 
    -0.16366372f, 0.06097381f, -0.01003795f, -0.37545088f, 0.03791686f, 0.13387783f, 0.00296291f, -0.11482559f, 
    0.16078761f, 0.16236374f, -0.13648482f, 0.03197139f, -0.58229369f, 0.00632531f, -0.39581424f, -0.22160290f, 
    -0.10554592f, -0.15931827f, -0.22333598f, 0.29539806f, -0.16679575f, 0.08650446f, 0.05723017f, 0.12806433f, 
    0.00916759f, 0.10839297f, 0.08189265f, -0.14369892f, -0.03223274f, 0.02856009f, 0.01127450f, 0.03475138f, 
    0.18727131f, 0.17998371f, 0.05217833f, -0.10918111f, 0.47829622f, 0.17441085f, 0.28734052f, 0.23908967f, 
    -0.11860058f, -0.06079759f, -0.14093313f, -0.06408690f, 0.05663975f, -0.07998504f, -0.00053478f, 0.03072169f, 
    0.34628305f, 0.39726493f, 0.25530410f, 0.71624154f, -0.05525625f, 0.18928656f, -0.14042406f, 0.07009690f, 
    -0.10667253f, 0.04714604f, 0.04767510f, -0.02001048f, 0.62444890f, 0.16862364f, 0.28048986f, 0.11376812f, 
    -0.17123047f, 0.04478003f, -0.11066896f, -0.00959730f, 0.07222585f, 0.16406731f, -0.36717853f, 0.29376388f, 
    0.05177604f, -0.05539087f, 0.13297150f, 0.00699299f, 0.19325799f, 0.26276758f, 0.03470591f, 0.02046733f, 
    -0.06688410f, 0.07882911f, 0.09350817f, -0.01604619f, -0.22265500f, 0.27038106f, 0.25889814f, -0.50872380f, 
    0.20210297f, 0.01095494f, -0.22037272f, 0.31959584f, 0.08333636f, 0.11036343f, -0.28173307f, -0.40617412f, 
    0.20920078f, -0.00590936f, -0.04602777f, -0.16925251f, -0.07553414f, -0.31173050f, -0.07627198f, -0.01099212f, 
    -0.06951650f, 0.02545138f, -0.07838445f, 0.15601490f, 0.26384428f, 0.24192983f, -0.14385112f, -0.26693541f, 
    0.10894899f, -0.00002029f, 0.01426115f, -0.01234644f, -0.09029964f, 0.04446008f, 0.03401783f, -0.14880139f, 
    0.41658607f, -0.06339634f, -0.08708946f, 0.15156142f, -0.10506809f, -0.04701975f, 0.10584730f, 0.07587848f, 
    0.23783016f, -0.17866163f, -0.20275754f, -0.21692537f, -0.35846570f, 0.09737021f, -0.41735539f, -0.39965150f, 
    0.12383610f, -0.07117848f, -0.10953959f, 0.08572320f, 0.02322603f, 0.04404783f, -0.08593502f, 0.00130079f, 
    -0.11658920f, 0.01860480f, -0.16351460f, -0.15120162f, -0.11718415f, -0.02178449f, -0.02591831f, -0.03391953f, 
    -0.00404897f, -0.22747999f, -0.21920703f, -0.00766642f, -0.11755992f, 0.03413673f, 0.31901264f, 0.03558452f, 
    -0.09155288f, 0.04547276f, 0.02064006f, -0.07561769f, 0.15239477f, 0.20661812f, -0.11610330f, 0.14861847f, 
    0.34350535f, 0.23543626f, -0.06209318f, 0.54779673f, -0.03576426f, -0.07901225f, 0.09876885f, -0.19747703f, 
    0.10801773f, 0.03471389f, 0.13682240f, 0.32694632f, -0.00924158f, 0.81808102f, 0.08714342f, 0.29643673f, 
    -0.05407130f, 0.14021383f, 0.01842198f, -0.13137181f, -0.22770487f, 0.10529965f, -0.13772044f, 0.07931730f, 
    0.66272736f, 0.30552676f, -0.03371333f, -0.49480975f, 0.18262491f, -0.09410779f, -0.38423789f, 0.21431324f, 
    -0.08634991f, 0.06297518f, -0.19844133f, -0.04666563f, -0.44885966f, -0.73682880f, -0.69823265f, -0.35855904f, 
    0.00574072f, -0.09969455f, -0.14484675f, -0.23777826f, 0.05490290f, 0.02381349f, -0.07991128f, 0.00022929f, 
    -0.04280749f, -0.03098894f, -0.03403599f, 0.20646521f, 0.02541015f, -0.05056495f, 0.15715265f, 0.01169976f, 
    -0.13281369f, 0.24882743f, -0.20410132f, -0.07682509f, 0.27510649f, 0.45160201f, -0.80258697f, 0.21075091f, 
    -0.01493881f, -0.03703634f, 0.00171250f, 0.14792514f, 0.04463075f, 0.01603384f, 0.02510804f, -0.13464192f, 
    -0.88294053f, -0.54155928f, 0.01683423f, -0.14168428f, -0.05219777f, -0.10930399f, 0.07006373f, 0.35632563f, 
    -0.01867430f, -0.05115504f, -0.01346804f, -0.08302226f, 0.08992978f, -0.44668099f, -0.30540669f, -0.39416400f, 
    0.03962288f, -0.02320252f, -0.09008822f, 0.14963293f, 0.19350733f, 0.01303118f, -0.02531641f, 0.09497897f, 
    -0.15979712f, -0.18211704f, -0.04058753f, 0.16033773f, -0.39573273f, 0.25850382f, 0.03987016f, -0.08608396f, 
    0.07927243f, -0.10483603f, -0.12786435f, 0.06084124f, -0.07892498f, 0.10763551f, 0.30181909f, 0.24825397f, 
    0.00647334f, 0.06449746f, 0.09689848f, -0.14303815f, -0.03945262f, 0.00177559f, -0.04694663f, -0.06466211f, 
    -0.49048978f, -0.19046290f, 0.37937075f, -0.18451956f, -0.07880425f, -0.35175097f, -0.57757342f, -0.00353056f, 
    0.06902868f, -0.12466059f, -0.09377949f, -0.01242092f, -0.25789532f, 0.46814108f, 0.70186579f, 0.31670350f, 
    -0.21570288f, -0.08536693f, 0.15863545f, 0.10372416f, 0.16276926f, -0.10134074f, 0.07425622f, -0.08092651f, 
    0.01023716f, -0.34122089f, 0.35234386f, 0.09455922f, 0.04153857f, -0.05961317f, 0.00743720f, 0.23961838f, 
    0.07823696f, 0.16269176f, -0.02626372f, 0.15207043f, -0.76523221f, 0.27541161f, -0.36382926f, -0.16784286f, 
    -0.14463504f, -0.10251087f, -0.14800049f, 0.05699564f, -0.05405072f, 0.00816805f, 0.05322814f, -0.18096861f, 
    0.06438424f, -0.11594644f, 0.16080287f, 0.18931250f, -0.00585859f, 0.04473035f, 0.05025180f, 0.18532632f, 
    0.04506420f, -0.13210537f, 0.04391686f, -0.00561576f, -0.28968060f, 0.04545652f, -0.07179879f, -0.06047658f, 
    -0.03215482f, 0.03329028f, 0.04921080f, -0.05081476f, 0.07666875f, -0.24244095f, 0.04310703f, 0.32656839f, 
    0.46885508f, -0.24299033f, -0.05585694f, 0.15467462f, 0.11971346f, 0.08353660f, -0.00289629f, -0.31233364f, 
    -0.08587389f, 0.03573994f, 0.05373042f, 0.18987972f, 0.45552877f, 0.07313698f, -0.38411611f, 0.14231405f, 
    0.12078726f, -0.06120708f, 0.01810982f, 0.07355661f, -0.00319757f, 0.12153681f, -0.06564359f, -0.02729679f, 
    0.77047670f, -0.22567050f, 0.20134115f, 0.43354064f, -0.15820014f, -0.14095844f, -0.55017394f, -0.18265289f, 
    -0.09069125f, 0.16341197f, 0.22176053f, -0.17845510f, 0.13537720f, -0.05850885f, -0.14092723f, 0.03781154f, 
    -0.01196057f, 0.09455521f, -0.02417889f, 0.16992471f, 0.01024352f, -0.10600997f, 0.03492099f, -0.13040543f, 
    -0.39789718f, -0.06724691f, -0.05178663f, -0.92367214f, -0.08541424f, 0.08051684f, -0.06717321f, -0.00973744f, 
    -0.06394462f, -0.01771881f, -0.56964087f, 0.24145059f, -0.33248729f, 1.07354212f, -0.58387494f, -0.15760787f, 
    0.10563766f, 0.06888669f, -0.06427342f, -0.07103360f, 0.05130064f, -0.17234597f, 0.04400605f, 0.11652178f, 
    -0.12441862f, -0.28977218f, -0.23117526f, 0.47762632f, 0.14204633f, -0.01981615f, 0.05339589f, 0.19081242f, 
    0.05548313f, 0.17916220f, 0.07976468f, 0.07949945f, 0.18844578f, -0.22118278f, -0.53305364f, -0.17130615f, 
    0.10205636f, -0.28551614f, -0.12096492f, -0.11141152f, -0.32566604f, 0.00600680f, 0.06789546f, -0.07204834f, 
    0.02763895f, 0.01626078f, 0.47026345f, -0.03317608f, -0.35204637f, -0.21009970f, -0.20159940f, -0.11672404f, 
    0.08575562f, -0.24153486f, -0.03339024f, -0.15805827f, 0.18794818f, -0.04167932f, -0.06658553f, -0.05016112f, 
    0.05122695f, -0.04230075f, -0.02955542f, -0.09687325f, -0.17048094f, 0.00904565f, -0.00821177f, 0.13849190f, 
    -0.73374182f, -0.39937896f, 0.63363814f, 0.47772044f, -0.09921670f, -0.09174063f, -0.20041966f, 0.15683895f, 
    0.11887720f, 0.36252248f, -0.06353863f, 0.11413327f, 0.08496930f, -0.44368756f, 0.13007917f, 0.50453734f, 
    0.11359096f, 0.07014798f, -0.03907989f, -0.11159191f, -0.07608201f, -0.02155737f, 0.17883088f, 0.25553527f, 
    -0.51441640f, 1.03323340f, -0.98439509f, -0.51926440f, 0.06373215f, 0.13245460f, 0.10699868f, -0.03972042f, 
    -0.57569957f, -0.07475697f, -0.02581638f, 0.06085210f, -0.34157920f, -0.15245852f, 0.03823685f, 0.25446367f, 
    -0.00605047f, -0.19873033f, 0.10068953f, 0.03984316f, -0.14226894f, 0.00716168f, -0.12890531f, -0.09989315f, 
    0.43742132f, 0.10714606f, -0.09265181f, -0.40482193f, 0.36237270f, 0.19693835f, 0.15798387f, -0.01120330f, 
    -0.49838290f, -0.02424841f, -0.33257136f, 0.03481447f, -0.61404735f, -0.04479422f, -0.00922331f, -0.67096329f, 
    -0.25185651f, -0.04296942f, -0.18809760f, 0.12928466f, 0.02749803f, 0.19116926f, -0.08873834f, -0.16957089f, 
    -0.08615331f, -0.11651878f, -0.14873353f, -0.03053364f, -0.15214890f, -0.01135101f, 0.00599008f, -0.00822482f, 
    0.18906765f, -0.05549730f, -0.11945780f, 0.21965709f, 0.01762626f, -0.07142072f, 0.19679534f, -0.00088853f, 
    -0.23620845f, 0.05790280f, -0.18517892f, -0.01023794f, -0.13889866f, -0.20775677f, -0.25711590f, 0.04551474f, 
    0.08224787f, 0.00216665f, -0.32119176f, -0.23535612f, -0.12448899f, -0.46584764f, 0.02201087f, -0.16593136f, 
    -0.08792442f, -0.21199541f, 0.08624510f, -0.22601379f, 0.13243884f, 0.33862776f, 0.43046361f, 0.52615106f, 
    -0.28126606f, 0.06823260f, 0.09325334f, 0.04893291f, -0.19649839f, -0.03572306f, -0.07893409f, -0.14624003f, 
    0.04451104f, 0.06629891f, 0.01998181f, -0.05050268f, 0.16944368f, -0.00580570f, 0.12038238f, 0.05917035f, 
    -0.13099191f, -0.08084300f, -0.26093259f, 0.09760514f, -0.34217754f, -0.91617882f, 0.46637356f, -0.18782815f, 
    0.28788197f, 0.14652851f, 0.06055430f, 0.16144438f, 0.09299812f, -0.19548000f, -0.14674805f, -0.01902278f, 
    0.15491183f, 0.14232080f, 0.16622533f, 0.14741078f, -0.06040778f, -0.13237749f, 0.08995071f, 0.02699897f, 
    0.16889358f, 0.06268411f, 0.11713046f, 0.02647434f, -0.26683035f, 0.10185284f, -0.41451976f, -0.22767600f, 
    0.05679369f, 0.10426673f, -0.03494396f, 0.14090784f, -0.36244768f, -0.15651262f, 0.02555389f, -0.47003976f, 
    0.04167164f, -0.02870106f, -0.02208861f, 0.22062163f, 0.05837670f, -0.35489950f, 0.07209083f, 0.14236318f, 
    -0.06618681f, -0.17574161f, -0.40167797f, -0.23767029f, -0.36854863f, -0.08202270f, -0.01517041f, 0.14524235f, 
    0.11870100f, 0.00552578f, 0.10824303f, -0.20990509f, 0.04988242f, -0.16510783f, 0.08729821f, 0.25913540f, 
    0.25119954f, 0.33850634f, 0.11525238f, 0.34618977f, 0.14045094f, 0.22473024f, 0.09839702f, -0.07188065f, 
    0.19483495f, -0.04939200f, 0.04978079f, -0.14821056f, -0.14635107f, -0.06639220f, 0.17117123f, 0.14460880f, 
    -0.02715307f, -0.30785787f, -0.24727190f, -0.11800692f, 0.03537291f, -0.02240817f, -0.02259875f, 0.10882801f, 
    0.01232617f, -0.84284914f, 0.47026843f, -0.05088464f, -0.06381741f, 0.14360228f, -0.11471415f, -0.10048559f, 
    -0.22342026f, 0.24820180f, -0.00362538f, 0.21137507f, 0.07312179f, -0.00626920f, 0.33191374f, 0.06982989f, 
    0.03981866f, 0.16236362f, 0.04623483f, 0.15820919f, -0.11673511f, -0.13923681f, -0.02663482f, -0.09425173f, 
    -0.01526717f, -0.19437312f, -0.01792859f, 0.05578276f, -0.19687745f, 0.09645297f, -0.02458982f, -0.05728489f, 
    0.07077559f, 0.09517653f, -0.04838230f, 0.02477218f, -0.00301180f, -0.44450915f, -0.10280621f, -0.14994514f, 
    0.01780906f, 0.05800939f, 0.06594105f, 0.05110545f, 0.11664386f, -0.12275988f, 0.15050487f, -0.03320516f, 
    -0.64391333f, -0.06151585f, 0.01212138f, -0.31925604f, -0.00108682f, -0.01743401f, 0.03243754f, 0.18271980f, 
    -0.03977321f, -0.27392387f, -0.14478071f, -0.19128419f, -0.18151945f, -0.62078273f, 0.12807542f, 0.10717225f, 
    -0.12401353f, -0.14740936f, -0.07519945f, -0.08163047f, 0.35415691f, -0.11851434f, 0.01402728f, 0.06724060f, 
    -0.56246763f, -0.03879835f, -0.34034458f, 0.35957402f, 0.38873839f, -0.15851599f, 0.16360466f, 0.14280653f, 
    -0.16493608f, -0.04539293f, -0.19230150f, 0.32442182f, 0.14302067f, 0.21109118f, 0.43425462f, -0.01451302f, 
    0.13031161f, 0.21116444f, 0.02644883f, -0.15275005f, 0.03408312f, 0.10979033f, -0.02667722f, 0.11049708f, 
    0.01563840f, -0.36912236f, -0.14150755f, 0.19681829f, -0.01750556f, -0.03311376f, -0.12733333f, 0.03774334f, 
    -0.26006576f, 0.08494604f, 0.42251319f, 0.05205850f, 0.16890170f, -0.47497353f, -0.07400244f, 0.17768219f, 
    0.03422362f, 0.04041041f, 0.08826788f, -0.01232231f, -0.14714885f, 0.08666012f, -0.02085522f, -0.03187998f, 
    -0.08146030f, 0.19737509f, 0.15280232f, -0.58418143f, 0.18189017f, 0.07914785f, 0.02549838f, -0.47941059f, 
    0.13791786f, -0.08120231f, 0.04314610f, -0.03386885f, -0.26449013f, 0.19164568f, 0.12549348f, -0.00911468f, 
    0.23822846f, -0.00759044f, 0.12338210f, 0.02168667f, 0.44593611f, -0.23280501f, 0.25492921f, 0.35877103f, 
    -0.16812181f, -0.01397992f, -0.26453280f, -0.07332256f, 0.11041211f, 0.16341977f, -0.25694495f, 0.08127320f, 
    0.04224795f, 0.16133735f, 0.08377568f, 0.32338300f, 0.05499677f, 0.13031535f, 0.14056717f, 0.09382468f, 
    -0.16057971f, -0.20200154f, 0.05777872f, 0.10048975f, 0.11827736f, -0.08241597f, -0.15647331f, -0.30680090f, 
    -0.06886936f, -0.15449101f, -0.45362467f, -0.01566808f, 0.21407960f, 0.22677736f, 0.12804216f, -0.17094475f, 
    0.08195458f, -0.14109285f, 0.08065418f, -0.07980742f, -0.16270244f, 0.08356205f, -0.44418994f, -0.52725822f, 
    0.16402212f, -0.05987866f, 0.09774013f, 0.05389092f, 0.06084608f, -0.01749005f, 0.02120367f, -0.09190496f, 
    -0.39950752f, 0.04158893f, 0.16929604f, -0.32399788f, 0.00845244f, -0.15518995f, 0.02083566f, 0.06115098f, 
    -0.03501428f, -0.22394970f, -0.35649213f, -0.21493347f, 0.36034650f, 0.13523160f, 0.44371009f, 0.16581051f, 
    0.05947017f, 0.21263374f, 0.00764359f, -0.06223056f, 0.04183373f, 0.05297134f, 0.11226121f, 0.04267658f, 
    -0.30544665f, -0.34404954f, 0.10798965f, -0.12271021f, 0.10279906f, -0.14891560f, -0.21765372f, -0.04771416f, 
    -0.00918270f, -0.11390442f, 0.30089453f, -0.04782172f, 0.12515230f, -0.24209221f, -0.05546266f, 0.31939876f, 
    0.06995931f, -0.07407704f, 0.05101837f, 0.05847949f, -0.05370133f, 0.01323852f, 0.02339130f, -0.04059877f, 
    -0.26636916f, 0.29858604f, 0.47880730f, 0.18274865f, -0.09088430f, 0.07172386f, 0.17896581f, 0.16543218f, 
    0.02002787f, 0.30076832f, 0.10903129f, -0.00222592f, -0.11690312f, 0.95472395f, 0.06831909f, 0.44091320f, 
    -0.20833926f, -0.21165453f, -0.23960038f, 0.52950782f, -0.01280891f, 0.17970644f, 0.31154343f, 0.02627967f, 
    0.14991803f, -0.17868057f, 0.12702595f, 0.36131552f, 0.02999013f, -0.12511915f, 0.17532264f, -0.35239759f, 
    -0.12909204f, 0.06026514f, 0.04593144f, -0.06714981f, -0.81883764f, -1.51776576f, -1.05183899f, -0.15157074f, 
    -0.05463666f, 0.01264543f, -0.19000834f, -0.13722223f, 0.12246823f, -0.17364846f, 0.05463430f, -0.04871950f, 
    0.17646298f, 0.01757157f, -0.20565614f, 0.04213994f, -0.01943270f, -0.04265868f, -0.17775972f, 0.11301155f, 
    0.05486281f, -0.40757689f, -0.14681938f, 0.07800709f, -0.59699816f, -0.07934532f, -0.03134120f, -0.03378949f, 
    0.24460085f, 0.07556742f, -0.17241624f, -0.06196143f, -0.03198646f, 0.05646998f, 0.03655829f, 0.10524645f, 
    -1.58705962f, -1.72299945f, -0.45809650f, -0.54855651f, 0.13603769f, -0.06551607f, -0.12726749f, -0.51922750f, 
    -0.08438335f, 0.01129752f, -0.07425164f, -0.08136564f, -0.09261421f, -0.22988658f, 0.09699720f, 0.19606248f, 
    0.22867270f, -0.23469986f, 0.24137008f, -0.00145684f, 0.09531273f, 0.11133435f, 0.01444651f, -0.06643254f, 
    0.26750264f, -0.14983757f, -0.17848784f, -0.17738718f, -0.24824654f, -0.36241221f, 0.25406659f, -0.04209698f, 
    -0.00817230f, -0.02034403f, -0.00499500f, -0.42239359f, 0.04826965f, -0.52526397f, -0.26026499f, -0.36184549f, 
    -0.11515208f, -0.06517423f, -0.08507165f, -0.20646007f, -0.13517299f, 0.01989865f, 0.38605282f, 0.13291331f, 
    0.38021517f, -0.34390792f, -0.27340755f, -0.09661312f, -0.02140720f, 0.16769786f, 0.34293818f, -0.02658697f, 
    -0.00478746f, -0.14954337f, -0.26581216f, 0.06090904f, -0.74581778f, 0.27607620f, 0.75822008f, -0.17142250f, 
    0.04901460f, 0.03466354f, 0.24787489f, -0.13787216f, -0.00079240f, 0.08525138f, -0.12949170f, 0.06282761f, 
    -0.16276182f, -0.21663235f, 0.24862716f, 0.09418596f, 0.00851199f, -0.02999846f, 0.12590165f, 0.15864332f, 
    0.30489895f, 0.22617711f, 0.21916409f, -0.03235511f, -1.00165653f, -1.77948511f, -0.78061461f, 0.48678663f, 
    -0.00348112f, -0.04394610f, 0.16475852f, -0.32814112f, -0.02613432f, 0.03399763f, 0.04385297f, 0.14255442f, 
    -0.39842400f, 0.21026991f, 0.48554224f, 0.09574559f, -0.17929308f, 0.01685740f, -0.02276737f, -0.06836400f, 
    -0.23484778f, 0.12040807f, 0.01868914f, -0.05964766f, 0.39027485f, 0.20341045f, -0.24612691f, 0.06520458f, 
    -0.10105327f, -0.11977127f, 0.11934369f, 0.18393029f, -0.30952498f, -0.00188120f, 0.04828732f, -0.08732864f, 
    0.62493151f, -0.16089585f, -0.38923016f, -0.02755440f, 0.01428304f, -0.09250652f, -0.03186708f, 0.02801120f, 
    0.24784712f, -0.10376125f, -0.27780142f, -0.06283524f, 1.01240218f, -0.90827125f, -1.29911947f, -0.58438760f, 
    -0.00328663f, -0.18512955f, 0.07155833f, -0.11497306f, -0.07240442f, 0.27354431f, -0.03042182f, 0.04799282f, 
    0.01441316f, 0.58551472f, -0.46442258f, 0.37257174f, -0.19597588f, 0.49442592f, -0.05722779f, 0.06070930f, 
    0.08122540f, 0.13534296f, 0.14172064f, 0.06355985f, -1.17431164f, -0.58679247f, 0.38516781f, 0.89106899f, 
    0.02007598f, 0.04905013f, 0.04335536f, -0.07479523f, -0.01702907f, 0.00268210f, 0.04937554f, -0.06128834f, 
    0.11601631f, -0.11551104f, -0.14151371f, -0.14387715f, 0.01906640f, 0.07992080f, -0.00478714f, -0.06509829f, 
    -0.34856287f, -0.13065365f, 0.04452869f, -0.09716595f, 0.03532093f, -0.01340815f, -0.35127261f, -0.13546257f, 
    0.02056930f, -0.10214826f, 0.02119228f, -0.02006068f, 0.09411711f, 0.15660883f, 0.02930813f, -0.17357136f, 
    -0.19054340f, -0.69989973f, 0.30237269f, 0.05030632f, 0.07343536f, 0.08927613f, -0.09283233f, 0.12800048f, 
    0.02513896f, 0.04577790f, -0.00600918f, -0.06677967f, 0.07597917f, 0.04285742f, 0.05141879f, -0.15434901f, 
    0.02191996f, -0.06052898f, 0.00887795f, -0.14686698f, -0.01710935f, -0.08620170f, -0.18851164f, -0.23862094f, 
    0.07237525f, 0.14481768f, -0.04381027f, 0.11566520f, -0.19514030f, -0.13151963f, -0.05370390f, -0.05122397f, 
    -0.03063341f, 0.00246716f, -0.08640974f, 0.02806551f, 0.20019904f, -0.41606274f, -0.44639504f, 0.53183794f, 
    0.06965947f, -0.13534153f, -0.12663798f, -0.00703916f, 0.00221399f, 0.01497350f, -0.06135720f, 0.04030059f, 
    -0.11490733f, 0.13282789f, 0.09285676f, 0.01797781f, 0.10362748f, -0.17590083f, 0.09726219f, 0.15272847f, 
    0.05304915f, 0.05477745f, 0.07763093f, -0.04734845f, -0.65276426f, -0.67904341f, -0.68460399f, -0.56109840f, 
    0.04240900f, 0.04059339f, -0.01245876f, -0.24075882f, 0.03998169f, 0.05945228f, -0.00667124f, 0.01562977f, 
    0.39352864f, -0.56265485f, -0.13767351f, -0.22275916f, 0.07142831f, -0.03599637f, -0.13278796f, 0.00110172f, 
    -0.12870087f, 0.14272535f, 0.10763378f, -0.13926648f, -0.30195594f, -0.90816003f, 1.07402766f, 0.16906554f, 
    -0.03963847f, -0.00058705f, -0.23244093f, 0.08569933f, -0.01392851f, -0.01365636f, -0.06604752f, 0.05826565f, 
    0.47838321f, 0.04317811f, -0.14583987f, -0.26940894f, -0.02235616f, 0.06905968f, 0.02662395f, -0.15119228f, 
    0.01530260f, 0.05913179f, 0.07869533f, -0.03693803f, 0.10063481f, -0.05260028f, -0.00248827f, 0.03123591f, 
    -0.06088277f, 0.03654680f, -0.07154592f, -0.04535737f, 0.16190320f, 0.02891534f, -0.13437733f, -0.37514120f, 
    0.16117595f, -0.28886217f, -0.23015721f, 0.01289926f, -0.02878037f, 0.15974414f, 0.11332614f, 0.05316571f, 
    -0.31667146f, -0.05945976f, -0.12736732f, -0.69838774f, 0.21420012f, -0.77896172f, -0.97036439f, -0.13349953f, 
    0.04783002f, 0.05756565f, 0.13966098f, 0.07584935f, 0.21339604f, -0.05427449f, 0.19013706f, 0.21674858f, 
    -0.24138857f, 0.02186595f, -0.00785549f, 0.72702384f, -0.16765757f, 0.08712883f, -0.13984187f, 0.13885885f, 
    0.13787675f, -0.11470906f, 0.17446232f, 0.00137065f, 0.79661906f, -0.23984830f, 0.24838321f, -0.07623767f, 
    0.18708287f, -0.06195708f, 0.13177390f, 0.48238224f, 0.16519265f, 0.08080379f, 0.17233956f, 0.01872836f, 
    -0.14980564f, 0.08034743f, -0.09947950f, -0.10694224f, 0.03338650f, 0.01341049f, 0.01007573f, -0.05598230f, 
    -0.00964891f, -0.14798471f, 0.21870044f, -0.05993904f, 0.01517255f, 0.32373598f, 0.01406230f, -0.04988302f, 
    -0.26073256f, -0.02551728f, -0.04639754f, -0.15723224f, -0.06889773f, -0.02408649f, -0.09124845f, 0.11495065f, 
    -0.47991970f, -1.21012425f, -0.96435314f, -0.52499366f, -0.27026966f, -0.06446301f, 0.28523096f, -0.09859160f, 
    -0.05747030f, -0.06072210f, 0.02854148f, 0.00598892f, 0.01926930f, -0.09986338f, 0.06125639f, -0.01948768f, 
    -0.27604645f, 0.04278077f, 0.11860413f, -0.24603780f, 0.11509151f, 0.06815200f, 0.07310223f, 0.15306193f, 
    -0.36682716f, 0.05206642f, 0.03141684f, -0.02435265f, 0.12969311f, -0.05222725f, -0.32424322f, 0.17154479f, 
    0.24175788f, 0.30080736f, 0.37942919f, 0.29844120f, 0.20056562f, -0.42603761f, -0.52875364f, -0.40331295f, 
    -0.04990824f, -0.02391362f, 0.15151577f, 0.18192562f, 0.07215099f, 0.11147428f, -0.14711729f, -0.25071278f, 
    -0.79069519f, 0.08713932f, 0.23510192f, 0.10273769f, -0.22294554f, 0.12349786f, -0.19640081f, -0.10659937f, 
    -0.06244016f, -0.00462781f, -0.01350543f, 0.04181259f, -0.01180694f, -0.94087565f, 0.05790498f, 0.48725200f, 
    -0.02750028f, 0.23888174f, 0.01140092f, 0.34703958f, -0.28597024f, 0.16462019f, -0.04680604f, 0.11698999f, 
    0.27053750f, 0.10913604f, -0.71605825f, -0.32843035f, -0.19457354f, -0.24676602f, 0.14894754f, -0.10126828f, 
    -0.09361815f, -0.25579423f, 0.19836758f, -0.01781490f, 0.70943654f, 0.09848406f, -0.36042035f, -0.37985724f, 
    -0.16377370f, -0.18827659f, -0.10670518f, -0.08793825f, -0.01472880f, 0.19352485f, 0.02595344f, 0.06740084f, 
    -0.14389427f, -0.16723670f, -0.53007191f, -0.24851157f, -0.02859854f, -0.23391154f, 0.04184781f, 0.07610007f, 
    0.15872380f, 0.15987287f, 0.00913323f, 0.00783137f, 0.01882673f, 0.52577114f, -0.23985873f, -0.34752396f, 
    0.14312983f, 0.00720478f, -0.07835137f, -0.03859719f, 0.01535382f, -0.22125907f, -0.21755955f, 0.16352864f, 
    -0.30970159f, 0.18234448f, 0.25363976f, -0.01649576f, -0.17197290f, -0.18260886f, -0.29536277f, -0.19524175f, 
    0.18662907f, 0.20784093f, 0.21279676f, 0.08431550f, 0.37207487f, -0.00890790f, 0.87292081f, 0.35992414f, 
    0.49949151f, -0.82521230f, 0.14135724f, -0.26780570f, -0.22809392f, -0.06671321f, 0.01574407f, 0.09134290f, 
    -1.03614223f, 0.25710249f, -1.16931391f, -0.43573809f, -0.50100303f, -0.20474479f, 0.06456470f, 0.04287893f, 
    0.14112261f, -0.35330859f, -0.00659111f, -0.16606569f, 0.24087617f, 0.20280829f, -0.45646086f, 0.05891996f, 
    -0.08070432f, -0.04855243f, 0.06531547f, 0.21170701f, -0.17231758f, -0.17345624f, -0.05236363f, -0.11072149f, 
    -0.12987328f, 0.18739878f, 0.29896700f, -0.04062376f, -0.03049325f, 0.01442100f, -0.06485763f, -0.28708452f, 
    0.28355983f, -0.23851529f, -0.02275527f, 0.04417230f, -0.30103141f, -0.46303245f, 0.31798193f, -0.24362712f, 
    0.12592505f, 0.20958197f, 0.04689862f, 0.05818696f, -0.01526048f, -0.10732552f, 0.08606084f, 0.04480679f, 
    -0.73437017f, 0.01985732f, 0.58850163f, -0.34108505f, -0.17262571f, 0.02219159f, -0.17228147f, 0.26355851f, 
    0.07523900f, 0.07390079f, 0.07202840f, 0.07608654f, -0.09151348f, -0.08513237f, 0.24875695f, -0.48988047f, 
    0.00230493f, -0.02580226f, -0.27244094f, -0.06001901f, -0.24984360f, 0.23121686f, -0.25989965f, -0.20798142f, 
    -0.13475141f, 0.13733035f, -0.53344738f, -0.19862038f, 0.13506593f, -0.06532869f, 0.15128298f, 0.05757663f, 
    0.06691899f, -0.38996258f, -0.06189517f, -0.06820541f, -0.64123636f, 0.34557998f, -0.00192769f, 0.54265207f, 
    0.17488402f, 0.09272882f, 0.09743275f, -0.15560940f, 0.10573446f, 0.13081999f, 0.04972002f, 0.07976736f, 
    -0.08799334f, -0.03532445f, -0.19832575f, -0.24788576f, 0.18790746f, -0.04569702f, 0.38556582f, 0.09721275f, 
    0.00926475f, -0.27923062f, -0.15038006f, -0.26124567f, 0.07053508f, -0.01781398f, -0.55467325f, -0.61062175f, 
    -0.11644065f, -0.06039253f, -0.16714047f, -0.03380189f, 0.15142809f, -0.09539661f, 0.20711587f, 0.00289586f, 
    -0.30658442f, -0.22576825f, 0.24773212f, 0.65260905f, -0.14761858f, 0.18415347f, -0.48644668f, 0.13496245f, 
    0.24142136f, -0.11239433f, 0.25557077f, -0.00487926f, -0.28669104f, -0.57928324f, -0.16942585f, 0.06762172f, 
    -0.10734035f, 0.10872502f, -0.15817487f, 0.05419027f, -0.06318808f, 0.12908469f, 0.10044520f, 0.02927492f, 
    0.48816758f, 0.04849148f, 0.39726314f, 0.66005373f, -0.03511766f, -0.08407986f, -0.25085187f, -0.09809849f, 
    0.26759005f, -0.13179550f, 0.10751382f, 0.26837331f, -0.32662451f, 0.12097094f, -0.42946395f, 0.29271212f, 
    0.07365119f, 0.13724171f, 0.02720420f, -0.14448076f, 0.20199406f, 0.10172461f, 0.25896987f, 0.04528617f, 
    0.23103128f, -0.22984548f, 0.41685736f, -0.28626662f, 0.08736172f, 0.06678537f, -0.30584624f, 0.06680942f, 
    -0.13278826f, -0.01054658f, -0.46576452f, -0.61493480f, -0.10402903f, 0.15938161f, 0.07567764f, -0.10116103f, 
    -0.33464703f, 0.07652742f, 0.12676711f, -0.03562860f, 0.14670867f, 0.01769846f, 0.01277024f, -0.21582948f, 
    1.06166947f, -1.46422529f, 0.88867217f, 0.30807313f, -0.10164039f, 0.34359765f, 0.46726450f, 0.17025903f, 
    0.06295838f, -0.05978323f, 0.25960019f, 0.08014964f, -0.63790745f, 0.15317801f, 0.23304056f, -0.00152414f, 
    -0.05768091f, -0.02368598f, 0.19424143f, -0.22816087f, -0.13253070f, 0.24080388f, 0.12324613f, -0.09903477f, 
    -0.71185493f, 0.33537841f, 0.40739909f, -0.14344734f, -0.29568458f, 0.01205106f, -0.10714213f, 0.27207729f, 
    0.10783027f, 0.03461818f, 0.15308078f, 0.09391765f, -0.64073920f, 0.09041900f, 0.23540443f, -0.10583276f, 
    -0.44808042f, -0.07176422f, 0.04209080f, 0.28504473f, 0.21312186f, -0.13873439f, 0.23621571f, 0.14530548f, 
    -0.10850669f, -0.51213014f, -0.39973983f, 0.16657405f, -0.09271647f, -0.23042323f, 0.04071894f, 0.04372188f, 
    -0.03708620f, 0.17224661f, 0.14170215f, 0.07064011f, 0.05134924f, 0.05621736f, 0.77401626f, 0.19926575f, 
    -0.06837813f, -0.09779914f, -0.01076022f, 0.13935310f, 0.01179612f, -0.33021620f, 0.35421419f, 0.07163186f, 
    0.00141353f, 0.02626868f, 0.27428660f, -0.31427944f, -0.02814906f, -0.17647922f, 0.17293669f, 0.13666114f, 
    0.10487966f, 0.30398121f, 0.43596205f, 0.40096742f, 0.03692249f, -0.31110108f, -0.20302814f, 0.10995222f, 
    -0.12708086f, 0.20643437f, 0.21231428f, -0.00139155f, -0.08656890f, -0.05509631f, -0.35227332f, -0.47369120f, 
    -0.35321012f, -0.61347795f, -0.05136142f, -0.16004211f, -0.06991402f, -0.10495783f, 0.02487971f, 0.04497657f, 
    -0.12275659f, -0.10544904f, -0.05730141f, -0.20947477f, 0.22667184f, 0.27233818f, 0.35361478f, 0.16058637f, 
    -0.14683649f, -0.17694099f, 0.11160106f, -0.07709575f, -0.18300200f, 0.28293592f, -0.17073694f, -0.10652831f, 
    -0.76679200f, 0.31275687f, 0.06187161f, -0.38999644f, 0.05181721f, 0.29135641f, -0.47185817f, 0.01627626f, 
    -0.17834173f, -0.04676569f, -0.29962480f, -0.18998970f, -0.39780605f, -0.06977274f, -0.53362727f, 0.42281285f, 
    0.09304681f, 0.37361237f, 0.02777957f, -0.07182121f, -0.02855688f, 0.10737314f, -0.01251427f, 0.00739725f, 
    -0.51095366f, 0.21200366f, -0.25617024f, -0.50709128f, 0.14386387f, -0.04106043f, -0.28582129f, 0.07456522f, 
    -0.05907790f, 0.10524068f, 0.03284097f, -0.25270417f, -0.45242864f, 0.04087907f, -0.06515992f, -0.23963906f, 
    -0.32680413f, -0.40079877f, 0.12725401f, 0.04808736f, -0.30048403f, -0.25617215f, 0.00801951f, 0.00875141f, 
    0.17974523f, -0.09162714f, 0.07120802f, -0.84405118f, -0.14172392f, -0.00581987f, 0.01041160f, 0.04151870f, 
    0.12956023f, 0.07120111f, 0.23707673f, 0.21169189f, -0.12670811f, -1.18598986f, 0.30714053f, -0.36166611f, 
    0.18064184f, 0.11577923f, -0.34256038f, 0.27967212f, -0.29871100f, -0.15490323f, 0.16290483f, -0.28091535f, 
    -0.27583474f, -0.07924779f, 0.59962511f, -0.57594252f, 0.32350168f, 0.05427839f, 0.40494528f, 0.03993398f, 
    -0.00606726f, 0.12627983f, -0.13770224f, -0.02654588f, 0.10751260f, -0.26388001f, -0.01826865f, -0.05076946f, 
    0.23682132f, -0.26524559f, 0.26070479f, -0.35657269f, 0.06081030f, 0.02875821f, -0.08879199f, 0.13181005f, 
    0.00562630f, -0.11192261f, -0.19785449f, -0.02922580f, -0.11902244f, 0.18446794f, -0.00823176f, -0.03250422f, 
    0.24718186f, 0.14103678f, -0.30230969f, 0.00357744f, 0.28129533f, 0.40380776f, -0.14649643f, -0.27896667f, 
    0.02831923f, -0.01108830f, 0.02206969f, 0.07388622f, -0.01602926f, -0.12228805f, -0.09715592f, -0.05338633f, 
    -0.18542217f, -0.41890064f, -0.13615134f, 0.00504392f, -0.20110333f, -0.17788559f, -0.07767952f, -0.24059106f, 
    0.02547697f, 0.03892932f, -0.07637351f, -0.06535751f, -0.22508182f, 0.26028538f, -0.68675119f, 0.79347736f, 
    -0.02310522f, 0.24357378f, -0.26830116f, 0.20412041f, -0.13709305f, 0.26527023f, 0.12115279f, 0.07055973f, 
    0.16874988f, 0.17597646f, -0.03383039f, -0.10549521f, 0.12278426f, 0.12681402f, 0.05865161f, -0.07563557f, 
    -0.04859392f, -0.20238809f, -0.13722673f, -0.33477288f, -0.27782282f, -0.98028982f, 0.03361272f, -0.09165005f, 
    0.17773061f, 0.22846051f, 0.03951337f, -0.28628093f, -0.02754244f, -0.09057811f, 0.37579885f, 0.22110555f, 
    0.64410466f, 0.27528349f, 0.43939739f, -0.12070104f, -0.24828197f, 0.10614227f, -0.33175695f, 0.27847016f, 
    -0.29613844f, -0.00703920f, 0.16661772f, -0.00029320f, 0.36837211f, -0.01164075f, 0.40232709f, 0.03097021f, 
    -0.13460030f, 0.18593369f, 0.15853071f, -0.00521369f, -0.17894956f, -0.03781356f, -0.00863086f, -0.00991214f, 
    -0.85244638f, 0.27726424f, -0.71807617f, 0.42124313f, 0.25605568f, 0.06547622f, 0.16997355f, -0.31893593f, 
    0.03553290f, 0.09026610f, 0.43544653f, 0.18502234f, -0.03715491f, -0.48667994f, -0.03996008f, 0.17631285f, 
    -0.00649682f, -0.47956812f, 0.04463103f, -0.12441267f, 0.06497888f, 0.02751411f, 0.08510995f, -0.09480163f, 
    -0.67761445f, 0.07940859f, -0.58055085f, 0.03232605f, 0.09082464f, 0.02525395f, 0.07883260f, 0.01400374f, 
    0.07727577f, 0.12453493f, 0.03102027f, -0.15808308f, 0.62975216f, -0.25811154f, 0.20846602f, -0.22508880f, 
    -0.05980187f, 0.13894685f, -0.04164651f, 0.10227875f, -0.33021805f, 0.16580531f, 0.01262350f, -0.23682933f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36599410f, 0.16107601f, 0.14632885f, -0.16928096f, -0.15582660f, 0.19443548f, 0.06123760f, -0.26929685f, 
    0.14230061f, 0.01467346f, -0.01173311f, -0.01246938f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
