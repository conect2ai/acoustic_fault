#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.42618167f, -1.16343880f, -1.18328345f, -0.85501504f, -0.50681937f, 0.10366383f, 0.26380512f, 0.32692438f, 
    0.56298780f, 0.34954458f, 0.47807637f, -0.05880550f, -0.10973405f, -0.16224885f, 0.17864087f, -0.14015616f, 
    0.06366222f, -0.32508647f, -0.00348672f, -0.48576280f, -0.47970536f, -0.16482180f, 0.23916906f, -0.25068721f, 
    -0.37625825f, 1.73710454f, -0.61725962f, -0.76665145f, -0.55886090f, -0.64003336f, 0.87864059f, 0.61771488f, 
    0.49044788f, -0.17504062f, -0.19841202f, -0.49414521f, -0.10878500f, -0.17911994f, -0.05344472f, 0.49133316f, 
    -0.09846425f, -0.16867059f, -0.03325186f, -0.15048519f, -0.39620227f, -0.12968042f, -0.65719277f, -0.40910104f, 
    -0.27080634f, -0.19700611f, -0.51492286f, -0.64008605f, -0.78983361f, -0.59470272f, -0.45284751f, -1.06246400f, 
    -1.07068789f, -0.85062522f, 0.17660090f, -0.87126154f, 0.32045254f, 0.02186452f, 0.32415280f, 0.18586305f, 
    0.19041039f, 0.34134093f, 0.13037993f, -0.03625536f, 0.07911018f, 0.19628681f, -0.08182276f, -0.18374798f, 
    -0.14123832f, 0.07069201f, 0.47264317f, 1.11139393f, 0.62705755f, -0.56380463f, 0.07114385f, -0.75004548f, 
    -0.54159319f, 0.15356857f, 0.40898749f, 0.49827126f, 0.31094694f, -0.04660911f, 0.44868529f, -0.45013875f, 
    -0.13482146f, -0.20286894f, 0.01482880f, -0.11529399f, -0.00766953f, 0.06268752f, -0.17109621f, 0.03819006f, 
    0.05749525f, 0.25529996f, -0.32450321f, -0.02177982f, -0.26877809f, 0.09205317f, -1.02922714f, -1.11536515f, 
    -0.76260120f, -0.81309223f, -0.46898755f, -0.05675732f, -0.33328626f, -0.91991335f, 0.36150324f, -0.32002437f, 
    -0.44365487f, -0.64301425f, -0.36041164f, -0.08564629f, 0.03392439f, -0.36062732f, -0.35830128f, -0.72342622f, 
    0.05168735f, 0.14105351f, 0.23174508f, 0.18653375f, 0.55530870f, 0.26351264f, -0.86224699f, -0.13848649f, 
    0.84370810f, 0.40590197f, -0.89502722f, -0.98658723f, -0.15138921f, 1.01139104f, 0.57340735f, 0.13264079f, 
    -0.48059350f, -0.21179986f, 0.09880711f, 0.50638437f, -0.30444941f, 0.06793790f, 0.14435481f, 0.14167032f, 
    -0.26198170f, -0.26435953f, -0.08795517f, -0.09678657f, 0.40526217f, 0.31521574f, -0.66694558f, 0.64677161f, 
    0.84774464f, -0.21267223f, 0.24909756f, -0.24389362f, 0.03165070f, -0.43508539f, -0.43801570f, -0.15583768f, 
    -0.18404765f, -0.17033362f, -0.56996578f, 0.01494477f, 0.26400137f, -0.21737690f, -0.32099262f, -0.21242703f, 
    0.04051288f, 0.41781044f, 0.14578402f, -0.29908630f, -0.30634564f, -0.33116192f, -0.62439603f, -0.50665563f, 
    -0.52127695f, -1.12476671f, -0.70385450f, -0.34293687f, 0.52237177f, 0.67767060f, 0.11084420f, 0.36248866f, 
    0.54032528f, -0.01359527f, 0.89571482f, -0.61022913f, -0.05272526f, -0.51471770f, -0.38979378f, -0.36127138f, 
    -0.23173660f, 0.00948503f, -0.06066285f, 0.32069594f, 0.08505747f, -0.03926303f, 0.23553167f, 0.31944451f, 
    0.52605069f, 1.21342576f, 0.22566947f, 0.49605417f, -0.10127308f, -0.71613002f, -0.65501934f, 0.10588332f, 
    -0.30113208f, -0.28916508f, -0.27256593f, -0.06399939f, 0.42978984f, -0.12985985f, -0.55249381f, -0.14198352f, 
    0.33064780f, 0.30628118f, 0.26797113f, 0.10190260f, 0.10992900f, -0.06537017f, -0.13322195f, -0.07605239f, 
    -0.21357885f, -0.77999413f, -1.20307994f, 0.31849837f, 1.56322384f, 0.67115194f, -0.25144839f, -1.48049009f, 
    -1.42693734f, -0.83425218f, -0.27742338f, 0.09422059f, 0.21809694f, 0.09642479f, 0.36276132f, 0.04755973f, 
    -0.27593529f, -0.24535845f, 0.09479424f, -0.40563351f, -0.27505097f, -0.07602856f, 0.37503245f, -0.13322257f, 
    0.02766019f, -0.22687431f, -0.62083715f, -0.58044940f, 0.00219967f, 0.33997989f, 0.76005405f, 0.74296498f, 
    0.40818316f, 0.03831863f, -0.03928190f, 0.60018474f, 0.12063420f, 0.17329171f, -0.23257639f, -0.44640568f, 
    -0.28239027f, 0.42767385f, -0.11491645f, -0.17679058f, -0.05492629f, -0.39636412f, -0.21457392f, -0.24843517f, 
    -0.20851655f, 0.19047764f, 0.23496611f, -0.08053486f, -0.08978301f, -0.51868618f, -0.25942454f, 0.18174987f, 
    -0.54852444f, -0.60228956f, 0.37566519f, 0.46052286f, -0.11351087f, -0.84267277f, -0.30388188f, 0.27036121f, 
    0.36865172f, -0.51012766f, 0.03345582f, -0.58309501f, -0.68953931f, -0.40769598f, -0.77882671f, -0.39890173f, 
    -0.25187978f, -0.09758784f, -0.39940077f, -0.62731016f, 1.37977481f, 1.31241190f, 0.02292371f, -0.64812207f, 
    -0.51376075f, 0.34060192f, -0.45544490f, 0.19963932f, 0.17320426f, -0.73095632f, -0.53721851f, 0.17148364f, 
    -0.11059964f, 0.11838100f, -0.57130694f, -0.13737316f, -0.05529774f, 0.16955049f, -0.02152775f, -0.05202254f, 
    -0.21770705f, 0.19563469f, -0.04197223f, 0.19650444f, 0.04457308f, 0.48791632f, 0.25011110f, 0.35704273f, 
    0.29583675f, 0.27032071f, 0.25268638f, -0.50440949f, -0.36981902f, 0.29310614f, 0.56610763f, 0.25873995f, 
    -0.11067317f, -0.45678955f, 0.19039457f, 0.67702740f, -0.14279543f, 0.35687876f, -0.21968566f, -0.13542579f, 
    -0.29884151f, 0.14155307f, -0.10338490f, 0.24797319f, -0.09674970f, -0.24582005f, -0.55950588f, -0.36548549f, 
    0.20974189f, 0.65832365f, 0.60958743f, 0.49817193f, -0.10187452f, 0.31981647f, 0.46836862f, 0.31349036f, 
    -0.03711795f, 0.61520129f, 0.32777101f, -0.10962844f, -0.24415192f, -0.43345588f, -0.03319527f, 0.04963640f, 
    -0.15189843f, -0.01642415f, 0.56969768f, 0.67472154f, 0.12839104f, -0.05357175f, -0.04514396f, 0.75069135f, 
    -2.23362875f, 1.05876148f, -0.17240030f, 0.42785728f, 0.31028169f, 0.78290862f, 0.16148473f, -0.85042298f, 
    -0.39266413f, -0.28469214f, -0.27918068f, 0.21165673f, -0.51319528f, 0.31016931f, -0.23852368f, -0.14801630f, 
    -0.01792384f, -0.01884812f, 0.08958376f, -0.04890125f, -0.07334278f, 0.01281314f, 0.11700263f, -0.05878923f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08379217f, 0.15379995f, 0.03462160f, 0.73976648f, 0.24893320f, 0.53926539f, 0.11873595f, 0.64461493f, 
    0.33558187f, 0.72506982f, 0.82412732f, 0.23657298f, 0.83532423f, 0.10011310f, 0.07273169f, 0.49678424f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.53881180f, 0.15761995f, -0.08370307f, -0.15739900f, 0.33015344f, 0.36370748f, 0.17872246f, 0.05221426f, 
    -0.16379410f, -0.09687543f, -0.16485925f, 0.13611270f, -0.09707498f, -0.64568841f, -0.35478318f, 0.15422520f, 
    -0.04149858f, 0.01713471f, -0.04143741f, 0.01484417f, 0.08259677f, -0.00545190f, 0.04803931f, 0.06811032f, 
    0.62334752f, 0.30269882f, -0.02242426f, -0.46515656f, 0.15604720f, 0.17996809f, -0.02256411f, 0.03903537f, 
    -0.00750822f, -0.00556695f, 0.07255761f, 0.07546202f, -0.82154220f, -1.05655110f, -0.38368890f, 0.13907979f, 
    -0.04885482f, 0.19119130f, -0.01288371f, 0.01301546f, -0.18517824f, -0.03468392f, -0.19412960f, -0.04853382f, 
    0.39361671f, 0.21945360f, -0.06852532f, -0.32359353f, 0.03947820f, 0.19628273f, -0.08756473f, -0.13438550f, 
    -0.07198271f, -0.01206800f, -0.14294519f, -0.07935142f, -0.43184331f, 0.46751574f, 0.48649141f, -0.72558981f, 
    -0.27493292f, -0.03850348f, -0.07516828f, -0.31721753f, 0.11418753f, -0.22727363f, -0.04683092f, -0.07853047f, 
    -0.11037404f, 0.11326245f, -0.15706716f, 0.03814543f, -0.06951105f, 0.12363169f, -0.10934096f, -0.02969413f, 
    -0.01345492f, 0.06042219f, 0.06533283f, -0.00304911f, 0.12522236f, 0.03861915f, -0.38889012f, -0.11452295f, 
    0.18195939f, 0.04652080f, 0.05117378f, -0.32563215f, -0.18571128f, -0.02628341f, -0.17658979f, -0.10220434f, 
    -0.33636770f, 0.01692909f, 0.00767047f, 0.16407262f, 0.06363149f, -0.16717538f, -0.52272373f, -0.07970132f, 
    -0.00375530f, 0.04720350f, -0.04381454f, 0.11552221f, 0.47627899f, 0.41237238f, 0.00870928f, -0.48728415f, 
    0.08974499f, 0.00432599f, 0.05408471f, 0.07867978f, 0.02622290f, -0.11285004f, -0.00986614f, -0.13106838f, 
    0.06405840f, 0.01307129f, -0.31941906f, 0.01620216f, 0.02953809f, -0.08813650f, 0.19530727f, 0.09864600f, 
    0.06541088f, -0.02789346f, -0.14742929f, -0.13283481f, 0.14235732f, 0.19564946f, 0.19389503f, 0.20254420f, 
    -0.09856831f, -0.09421126f, -0.12213247f, -0.15897158f, -0.03017509f, -0.23268315f, 0.15168621f, 0.32794812f, 
    -0.56267416f, -0.78415674f, -1.27002895f, 0.30822450f, 0.08316882f, 0.14635420f, -0.07145368f, -0.05897570f, 
    -0.04537277f, 0.06837492f, -0.10510283f, -0.08743006f, -0.30007619f, -0.07150517f, 0.13367823f, 0.05825792f, 
    -0.05400033f, 0.08569026f, 0.03075239f, 0.10125235f, -0.02078101f, -0.08860570f, 0.02286305f, -0.03929647f, 
    -0.05926203f, 0.13027257f, 0.21659645f, -0.02238406f, -0.18015715f, 0.02455923f, 0.03061127f, 0.02705093f, 
    -0.14477554f, 0.02317641f, -0.03074300f, -0.12838951f, 0.57845712f, -0.58231962f, -0.49592501f, -0.33037779f, 
    -0.09754005f, -0.30455416f, 0.31858423f, -0.22287725f, -0.05819370f, -0.12501471f, 0.04953363f, -0.03268364f, 
    -0.06440265f, 0.09615052f, -0.15567952f, -0.04253067f, 0.03540475f, 0.10259717f, -0.09867116f, -0.29378018f, 
    -0.11218798f, 0.11729150f, 0.06724305f, -0.14039955f, 1.26397204f, -0.47397259f, 0.09176935f, -0.07209392f, 
    0.02302148f, 0.07866087f, 0.00045949f, -0.24804281f, -0.16379172f, -0.23486860f, -0.37305710f, -0.46424127f, 
    0.04269559f, 0.17898098f, 0.09577776f, 0.08174536f, -0.01769120f, -0.04106771f, 0.01633360f, -0.36957732f, 
    -0.07695284f, -0.05311324f, -0.00400072f, 0.02876026f, 0.30839324f, -0.03546723f, 0.39294186f, -0.13831994f, 
    -0.01009336f, 0.02034223f, -0.02571622f, -0.01275237f, 0.09320573f, 0.03027678f, -0.08428665f, -0.05306738f, 
    0.23906605f, 0.36126170f, 0.22828186f, -0.10361817f, -0.01525734f, 0.10303047f, -0.00548168f, 0.24160908f, 
    -0.14276445f, -0.01692440f, -0.18120740f, 0.20270777f, -0.95491850f, 0.59837914f, -0.01206839f, -0.12198687f, 
    0.14073880f, -0.04569342f, 0.07493792f, -0.26623285f, 0.00662165f, -0.07540881f, 0.10807723f, -0.04627949f, 
    0.35229978f, -0.43372029f, -0.23492630f, -0.54141033f, 0.05362544f, -0.10324106f, -0.33421910f, 0.02562944f, 
    0.00501686f, 0.07676559f, 0.08728281f, -0.42566401f, 0.01266367f, -0.05218394f, -0.47406608f, -0.27945063f, 
    -0.11076058f, 0.07822453f, 0.09802459f, 0.18752518f, -0.06869473f, 0.05362010f, -0.15659550f, 0.00599666f, 
    -0.09603938f, 0.21305762f, 0.11602563f, -0.25938261f, -0.13852189f, -0.30228716f, -0.33127901f, -0.13009889f, 
    -0.10503790f, -0.04109396f, 0.08807334f, 0.05750224f, -0.55746144f, -0.00981627f, -0.23719510f, -0.05536944f, 
    -0.20541593f, -0.18253885f, 0.13649656f, 0.19858199f, -0.08137026f, -0.09511121f, 0.00040740f, 0.14015098f, 
    0.39911228f, 0.06208120f, 0.06970043f, 0.37953728f, -0.05472654f, -0.01869106f, 0.02388609f, -0.01035152f, 
    0.16343912f, -0.19359484f, -0.08397394f, 0.34725249f, -0.48838174f, 0.00425320f, -0.13463663f, 0.19373530f, 
    0.08216863f, 0.05811230f, 0.05081756f, 0.11457594f, 0.04171231f, 0.01493536f, -0.10382223f, -0.32829067f, 
    0.62076277f, -0.06967592f, 0.22899109f, -0.12562542f, -0.01154860f, -0.19828768f, 0.06947971f, -0.06996442f, 
    -0.05719776f, 0.07916626f, -0.00295380f, 0.13905914f, 0.01433697f, 0.22195347f, -0.06550876f, 0.25310421f, 
    0.05428487f, -0.10415799f, -0.12266909f, -0.04170544f, -0.05306235f, 0.12190812f, 0.09503634f, -0.06023505f, 
    0.00639087f, 0.10739800f, 0.05522063f, 0.06781004f, 0.02612179f, -0.13315439f, -0.04244138f, 0.12399175f, 
    -0.14895704f, -0.03717329f, -0.11497620f, 0.19948442f, 0.32207045f, -0.58236468f, 0.31711307f, 0.21577370f, 
    -0.10049545f, -0.02606727f, 0.03417927f, -0.21489714f, 0.17364016f, 0.09967849f, 0.17760153f, 0.19531870f, 
    -0.05915933f, 0.76400697f, 0.60437059f, 0.47772780f, -0.26094145f, -0.16998230f, 0.16971293f, 0.20314260f, 
    -0.08818141f, 0.00902831f, -0.04652720f, 0.14514950f, -0.45011786f, 0.42022350f, 0.48203322f, -0.16218518f, 
    -0.06646892f, 0.05282968f, 0.07981163f, -0.17890026f, 0.02750893f, 0.14218110f, 0.04736104f, 0.25587085f, 
    -0.66576910f, -0.56488049f, -0.68287247f, -0.11007006f, -0.17411925f, -0.06694948f, 0.02144157f, -0.32700720f, 
    0.06711458f, 0.17226377f, -0.01999396f, 0.05074262f, -0.48673886f, 0.35042617f, 0.17305303f, -0.09690759f, 
    -0.03038437f, 0.08627260f, -0.05848983f, 0.04162107f, 0.18799311f, -0.11166734f, -0.16952147f, 0.25379890f, 
    -0.75117344f, 0.36137468f, 0.09359067f, -0.46481085f, 0.00905537f, -0.08096964f, -0.04754829f, -0.19968949f, 
    -0.07698444f, -0.13248023f, -0.07393477f, 0.03833931f, -0.67554760f, -0.05527925f, -0.15703155f, 0.43908182f, 
    -0.20282687f, 0.13943125f, 0.07087757f, -0.06296162f, -0.01149587f, 0.05112673f, 0.00978136f, 0.02630140f, 
    0.68590051f, 0.19918913f, 0.07795693f, -0.45208746f, 0.09799413f, 0.02302204f, -0.22928648f, -0.00813098f, 
    -0.06924547f, 0.14541829f, -0.06734184f, 0.06263842f, -0.06494456f, 0.46757790f, 0.41039380f, 0.34570745f, 
    0.16436528f, 0.09511594f, 0.13535596f, 0.00601368f, 0.12873006f, -0.20039199f, -0.39676109f, -0.06363577f, 
    -0.47151595f, -0.25112462f, 0.28330460f, -0.37093845f, 0.01363553f, 0.08447069f, -0.05140799f, 0.01684961f, 
    0.08011463f, -0.17119972f, 0.22144815f, -0.11351884f, -0.79795653f, 0.26389790f, -0.27352986f, -0.09617083f, 
    0.18204349f, -0.24347119f, -0.12913638f, 0.03739693f, 0.03196723f, -0.01300299f, -0.01689577f, -0.09017953f, 
    -0.05086574f, -0.58807379f, -0.07604844f, 0.04118577f, 0.01611731f, 0.01506176f, -0.02423574f, 0.13730940f, 
    -0.00421064f, -0.08206233f, 0.19070810f, -0.00754231f, -0.16108747f, -0.03498259f, -0.30371213f, 0.39045957f, 
    -0.12945007f, -0.01290125f, -0.03666169f, -0.20050293f, -0.10638945f, -0.12528169f, 0.29641294f, 0.06289633f, 
    -0.57001227f, -0.13170660f, 0.62313128f, -0.62433439f, -0.03528061f, 0.13250959f, -0.05130314f, 0.11516516f, 
    -0.02357206f, 0.01350687f, -0.00840455f, -0.02364825f, -0.32542789f, -0.15845482f, 0.12388241f, 0.11289616f, 
    0.04888672f, 0.01666704f, 0.03853219f, 0.05326822f, -0.00749504f, -0.03002819f, -0.24030386f, 0.20117816f, 
    -0.06240522f, -0.11144595f, -0.38937309f, -0.09728491f, 0.03862235f, -0.02467887f, 0.09557519f, 0.16827841f, 
    0.04144334f, -0.08544271f, -0.04860184f, -0.24907053f, 1.17379963f, 0.31192875f, 0.02036973f, 0.14704446f, 
    0.11350299f, -0.05688972f, -0.29161394f, 0.01504112f, 0.05657991f, 0.04773030f, 0.05756255f, -0.32312536f, 
    0.26067212f, -0.27373430f, 0.05000072f, 0.27139086f, 0.33361617f, 0.05206744f, 0.15894485f, -0.26655960f, 
    -0.04963193f, 0.04884427f, 0.02335313f, 0.13302197f, -0.30510640f, 0.47630596f, -0.24895196f, 0.52443814f, 
    0.04007567f, 0.05750041f, 0.31095612f, 0.02355636f, 0.04925069f, 0.04970550f, 0.15614484f, -0.20515458f, 
    -0.02561273f, -0.44016361f, -0.18927598f, 0.10357911f, 0.09618032f, 0.04676716f, 0.14869173f, 0.20152964f, 
    -0.03253965f, -0.02847789f, 0.00099795f, -0.08081482f, -0.74222302f, 0.47885311f, -0.10214449f, -0.09651515f, 
    -0.35298863f, 0.19241376f, -0.42370549f, -0.14627351f, -0.29619595f, 0.09510566f, 0.02357469f, -0.10062567f, 
    0.13518421f, -0.27291593f, -0.06619725f, 0.30813897f, 0.06961931f, -0.09953349f, -0.00658925f, 0.10157927f, 
    0.00349238f, 0.04867840f, 0.00519657f, 0.00988661f, 0.02648119f, -0.03571566f, -0.09130058f, -0.40553224f, 
    -0.20628513f, -0.38015437f, -0.10892703f, -0.26384872f, -0.22982313f, 0.11574937f, 0.00143477f, -0.19871019f, 
    0.15470858f, 0.13003792f, 0.35229370f, 0.03056847f, -0.23722227f, -0.00231289f, 0.12839235f, 0.05446495f, 
    -0.06975772f, -0.43516234f, 0.06814621f, 0.04396934f, 0.12834254f, -0.13547005f, -0.22048505f, 0.39617071f, 
    0.13981108f, 0.06955740f, 0.10618687f, -0.04739403f, -0.08969531f, 0.04555859f, -0.00770214f, 0.05206045f, 
    -0.20996819f, -0.26234534f, 0.40431827f, 0.28457770f, -0.10423023f, -0.07034022f, 0.01529225f, 0.11501824f, 
    0.21212934f, 0.17398885f, -0.14006969f, 0.21508509f, 0.15879647f, 0.25562802f, -0.26763386f, 0.34222296f, 
    0.00837055f, -0.06853545f, -0.04045789f, 0.30340844f, -0.07585403f, -0.00953220f, 0.04167638f, 0.11617073f, 
    -0.19120024f, 0.57819200f, -0.41496140f, -0.75963771f, 0.55585462f, 0.14654142f, 0.12647040f, 0.10991138f, 
    -0.41661626f, 0.08996744f, -0.06947760f, -0.03648478f, 0.22398750f, -0.28644419f, -0.16220149f, 0.02934604f, 
    -0.23803213f, -0.13358286f, -0.23042175f, 0.09781937f, 0.09062953f, 0.04425231f, 0.19456185f, -0.01129356f, 
    -0.36008748f, -0.40248474f, 0.66298509f, 0.00067729f, -0.38648605f, -0.19031020f, -0.18915464f, -0.25873104f, 
    0.02803361f, -0.03591928f, 0.06858538f, 0.10880822f, 0.08561733f, -0.66429818f, -0.00934138f, -0.14090121f, 
    -0.44389531f, -0.00762251f, -0.23459063f, -0.12077904f, -0.06247022f, 0.11317150f, -0.06952778f, 0.28885931f, 
    -0.22939865f, -0.03913178f, 0.38955405f, -0.71752608f, 0.12233074f, 0.30436695f, 0.16501969f, 0.04215324f, 
    -0.03976340f, -0.17829667f, -0.29955050f, 0.13725029f, -2.15391636f, 1.49599338f, -0.62299323f, 0.50920230f, 
    0.31261453f, 0.09107188f, -0.31806865f, -0.25578433f, -0.14971481f, -0.20790000f, -0.09788407f, -0.11562339f, 
    -0.09897805f, 0.09583063f, 0.09164992f, 0.14602378f, -0.07784216f, -0.16401169f, -0.00129692f, 0.13421738f, 
    0.07345578f, -0.03853668f, 0.04667084f, 0.25298768f, -0.17685455f, 0.15259321f, -0.11204311f, -0.13446920f, 
    0.00791976f, -0.07935777f, -0.12177661f, 0.03687625f, 0.00530487f, 0.18464822f, 0.08554626f, 0.42462739f, 
    0.12442880f, 0.26712728f, 0.40398470f, 0.34980831f, -0.37411320f, -0.12646592f, -0.07463890f, 0.09183112f, 
    0.05831791f, 0.01652912f, 0.07120807f, 0.00096740f, -0.55345851f, -0.04588123f, -0.49600697f, -0.39269248f, 
    0.20386271f, -0.11553188f, 0.07407570f, 0.01569795f, -0.01362402f, 0.03695289f, -0.00752839f, -0.24259812f, 
    -0.09671407f, -0.04305995f, 0.17070420f, 0.28946996f, 0.09085141f, 0.06178820f, -0.11125540f, 0.00732023f, 
    0.08655316f, 0.01135581f, 0.11390082f, -0.15632091f, -0.07046464f, -0.19172338f, -0.09351783f, -0.04868018f, 
    -0.52791679f, 0.02645512f, -0.01027615f, 0.13222551f, -0.18766822f, -0.04474710f, -0.23951273f, 0.01661894f, 
    0.26611909f, 0.06419631f, -0.38935947f, 0.43066013f, 0.07588794f, -0.29914188f, -0.06849570f, -0.28436047f, 
    0.04675973f, 0.02550459f, -0.06139421f, 0.41284817f, 0.15155570f, 0.37082410f, -0.04447877f, 0.13192515f, 
    -0.21145894f, -0.24403225f, -0.27004281f, -0.01604431f, 0.00450363f, -0.42299059f, -0.23275813f, -0.14372012f, 
    0.47551563f, 0.06847042f, 0.13511591f, 0.40039140f, -0.05763475f, 0.08054294f, 0.02164472f, 0.08775828f, 
    0.18957900f, -0.14870054f, 0.02911842f, -0.03638425f, 0.00397677f, -0.14399661f, 0.50031161f, 0.21716967f, 
    -0.02268599f, 0.14721866f, -0.00916760f, -0.09436756f, -0.06401580f, -0.01086766f, -0.08464524f, -0.00999900f, 
    0.18851535f, -0.45668411f, -0.46718985f, -0.02731896f, -0.04597832f, 0.15295430f, 0.11395460f, 0.06283469f, 
    -0.33506563f, 0.09380595f, 0.04184960f, -0.27827579f, 0.00474729f, 0.06196326f, 0.20729855f, -0.19568866f, 
    -0.05219649f, 0.03737569f, -0.12622797f, -0.13422509f, 0.01200160f, -0.02561177f, 0.04433833f, 0.13844518f, 
    -0.21428271f, 0.36385486f, -0.70541096f, 0.22104399f, 0.14991145f, 0.07373638f, 0.07117780f, 0.01686152f, 
    0.02233674f, -0.06599875f, -0.08151364f, -0.17357069f, -0.01930629f, -0.07503180f, -0.18527950f, 0.08463597f, 
    0.05647101f, 0.02407781f, 0.18343791f, 0.05289435f, 0.04935083f, -0.03576514f, -0.25145990f, 0.04652376f, 
    0.24827898f, 0.15743753f, -0.01100716f, 0.04962333f, 0.08333839f, 0.09290870f, 0.02899364f, -0.06068110f, 
    0.11514321f, -0.00044731f, -0.25026307f, -0.17525928f, -0.41100118f, -0.48202732f, 0.11039600f, -0.58271092f, 
    -0.02638023f, 0.02410800f, -0.10373429f, 0.05449556f, -0.09458052f, -0.18396288f, -0.11849107f, -0.00437107f, 
    -0.30960977f, -0.14431956f, -0.27798417f, -0.37319177f, -0.12878416f, -0.05097189f, 0.08484524f, 0.03262414f, 
    0.18411438f, -0.32424146f, -0.11600813f, -0.43791500f, -0.35679173f, -0.09858126f, -0.42185968f, -0.16775128f, 
    -0.01898097f, 0.06578808f, 0.10233461f, 0.11680475f, 0.16820559f, -0.22692977f, -0.27275077f, -0.45441699f, 
    -0.05191781f, 0.13850079f, 0.18884221f, -0.07116635f, 0.23302498f, 0.34283540f, 0.08659648f, 0.03558455f, 
    -0.02056242f, -0.01222496f, -0.05292562f, 0.16981883f, 0.95675540f, -0.33107671f, -0.56794763f, 0.30819109f, 
    0.05880198f, -0.03943826f, 0.05000446f, 0.11243586f, 0.10395758f, -0.09502018f, 0.07289162f, -0.01869968f, 
    0.12769812f, 0.22726943f, 0.01291672f, -0.06501152f, -0.05036321f, 0.01454972f, 0.05143802f, -0.11814318f, 
    0.11105482f, -0.04439749f, 0.21262464f, 0.17293854f, 0.36590496f, -0.76564991f, 0.24558422f, 0.25329700f, 
    0.06775610f, 0.08927492f, -0.14426261f, 0.11813681f, 0.00987421f, 0.07957549f, 0.00492468f, 0.01282858f, 
    -0.81255847f, 0.20501353f, 0.34774274f, 0.30597293f, -0.02957168f, -0.04775140f, 0.04798596f, 0.26750657f, 
    -0.04604346f, -0.09503275f, -0.27741840f, -0.28118980f, -0.48982209f, -0.35529926f, -0.03466757f, -0.25427350f, 
    -0.08574592f, 0.16910537f, -0.02479530f, -0.34587431f, 0.20782249f, 0.05880640f, 0.22818460f, 0.14881627f, 
    0.12472925f, -0.28870714f, -0.31296793f, 0.20358397f, 0.18943191f, 0.23169312f, -0.06351338f, 0.18615676f, 
    -0.05760958f, -0.00542830f, -0.01448975f, -0.15826552f, 0.44459373f, 0.05776668f, 0.42299756f, -0.33509493f, 
    -0.16128394f, -0.04016614f, 0.13126899f, -0.16461283f, 0.11784013f, 0.04000695f, 0.05648722f, 0.04663458f, 
    -0.36761433f, -0.08541359f, 0.09579048f, -0.08975466f, -0.06370270f, -0.00180917f, -0.10251997f, 0.04141957f, 
    0.13688146f, -0.34228733f, -0.11021058f, 0.27417430f, 0.33507243f, 0.06454231f, 0.32405224f, 0.04258277f, 
    0.02082301f, 0.02578459f, 0.10157194f, -0.08842441f, -0.05213175f, -0.01704443f, -0.18469901f, -0.29319090f, 
    0.12070160f, 0.18179183f, -0.77335137f, 0.04764500f, 0.13318600f, 0.12611662f, -0.01885635f, 0.00313103f, 
    0.19115132f, -0.16791829f, -0.02707172f, 0.11735173f, -0.27412570f, -0.26571140f, 0.14317396f, -0.17219578f, 
    0.09610480f, -0.02712429f, -0.20937529f, 0.03806661f, 0.10153922f, 0.18019567f, 0.22623579f, -0.01493909f, 
    -0.00409309f, -0.25496507f, 0.01135666f, 0.10000988f, -0.24739352f, -0.13235620f, -0.13152385f, -0.10299558f, 
    0.12279405f, -0.02091629f, 0.35267791f, -0.33699849f, 0.84000343f, -0.38137174f, -0.22772942f, -0.16079266f, 
    0.04402877f, -0.07418858f, 0.02029158f, 0.14929292f, 0.02873579f, 0.12252676f, -0.22742844f, -0.24201384f, 
    -0.84764969f, 0.79052800f, 0.05146658f, -0.07811899f, -0.30317268f, 0.15911813f, -0.20606549f, 0.09602763f, 
    -0.20725898f, 0.15443005f, 0.16430508f, 0.04326344f, 0.11886606f, 0.39172781f, -0.01889597f, 0.04343339f, 
    -0.03316851f, -0.00813222f, 0.15312837f, 0.06564319f, 0.17573865f, 0.11123459f, 0.47132075f, 0.26817098f, 
    -1.09680831f, -0.70795918f, -1.04305577f, -0.15889521f, -0.36848214f, -0.21839589f, -0.25110891f, -0.25544626f, 
    0.10807032f, 0.00961428f, -0.04101564f, 0.00595542f, 0.54734093f, 0.11891423f, -0.40823156f, -0.01350698f, 
    0.12221630f, -0.02608131f, 0.16532145f, -0.02725641f, -0.03340284f, 0.18991362f, 0.01295600f, -0.32465926f, 
    -1.00558650f, -0.89917690f, -0.22619374f, -0.78429228f, -0.34445599f, -0.09035909f, -0.24423864f, -0.14894934f, 
    -0.03492080f, -0.02295105f, 0.04294447f, -0.22749025f, -0.08293585f, -0.21211755f, -0.52001512f, 0.10043492f, 
    -0.20378143f, 0.03517921f, 0.13874011f, 0.49147180f, -0.04650844f, -0.14300978f, 0.00816405f, -0.09555731f, 
    -0.39236945f, -0.48435205f, -0.04959992f, 0.15853474f, 0.11979304f, 0.22839963f, 0.18306606f, 0.00365482f, 
    -0.02214212f, -0.08635116f, 0.26437631f, 0.01543197f, -0.26478708f, 0.21377330f, 0.61115324f, 0.78833085f, 
    0.03174982f, -0.13978836f, -0.07730398f, 0.17033421f, -0.02442484f, 0.28853992f, 0.00478110f, 0.02926386f, 
    0.05223138f, -0.29784885f, -0.49559543f, -0.51118106f, -0.11770143f, 0.18704402f, 0.37819731f, -0.03659894f, 
    0.06059531f, 0.04786871f, -0.13945450f, 0.03258167f, -1.42286992f, -1.60010922f, -0.69610655f, 0.54447103f, 
    -0.02642859f, 0.09782892f, -0.23609345f, -0.39040416f, 0.03136593f, 0.02354831f, 0.04208670f, 0.05846719f, 
    0.23332639f, -0.21846233f, 0.29644763f, -0.05142212f, 0.14059429f, -0.09903537f, 0.00062047f, 0.15416388f, 
    -0.02865115f, 0.23563702f, 0.26552880f, -0.08188751f, 0.23455602f, 0.24048172f, -0.39604026f, -0.75333482f, 
    -0.07643857f, -0.09578759f, -0.00880458f, 0.10873915f, -0.27784216f, 0.18390393f, 0.02948260f, 0.24080728f, 
    0.13879319f, 0.11414779f, 0.08311694f, -0.78490639f, 0.06235138f, 0.03821321f, 0.05635006f, -0.00870362f, 
    -0.00418150f, 0.06154068f, -0.06266605f, 0.01584263f, 0.22492112f, -0.22208957f, -0.17283148f, -0.03497827f, 
    -0.01724301f, 0.13987844f, 0.04910704f, 0.11852966f, -0.09374653f, -0.24551395f, -0.19432186f, -0.32510209f, 
    -0.19061139f, -0.17959723f, -0.02704821f, -0.03377166f, 0.06234657f, 0.03561680f, -0.10852032f, -0.07342201f, 
    0.02206435f, 0.01011690f, -0.17205766f, 0.07753862f, -0.45502815f, 0.27316678f, 0.07133725f, 0.33270276f, 
    0.04326110f, 0.10870365f, -0.02090257f, 0.23071797f, 0.25273934f, -0.04542238f, 0.06526307f, 0.09991383f, 
    0.91261125f, -1.42155504f, -0.84600973f, -0.47276399f, -0.23874557f, -0.29711559f, 0.05198607f, 0.18578558f, 
    0.32291719f, 0.05722223f, 0.06615554f, 0.04256456f, 0.04644240f, 0.01012887f, 0.05388657f, 0.40416452f, 
    0.02215413f, 0.02840240f, 0.10949257f, -0.00498798f, -0.16437739f, 0.12237272f, -0.13087197f, 0.14232478f, 
    -0.61833268f, -0.52632153f, -0.45248136f, 0.19150521f, 0.07694040f, 0.12909395f, 0.12386432f, 0.02419577f, 
    -0.04877029f, 0.04454211f, 0.01427916f, 0.00377834f, -0.27921560f, 0.05054067f, 0.17746882f, -0.13400500f, 
    -0.10857522f, -0.04649885f, 0.03781044f, -0.20843275f, 0.07173933f, 0.03215314f, -0.07739560f, 0.01071551f, 
    -0.79602259f, -0.08790156f, -0.81038904f, 1.07636523f, 0.10611706f, -0.03094502f, 0.03100714f, 0.00146244f, 
    -0.02310916f, 0.06023986f, -0.08425695f, -0.06533418f, 0.55358422f, -0.66909552f, 0.23069683f, -0.18064854f, 
    0.10194112f, 0.27418938f, -0.16064928f, -0.22874068f, -0.06441327f, -0.03475844f, -0.11645126f, -0.03366875f, 
    0.03865837f, 0.23916760f, -0.49210674f, -0.18978369f, -0.15689652f, -0.11551815f, 0.20792814f, 0.00825112f, 
    -0.08559255f, 0.05924566f, 0.06091086f, -0.05212171f, 0.58432364f, -0.79428190f, -0.75108337f, -0.76288444f, 
    -0.01937334f, -0.17334659f, 0.17460088f, 0.20715986f, 0.05913669f, -0.15180787f, 0.10572827f, -0.02492571f, 
    0.01375088f, 0.20151734f, -0.22498253f, -0.05567156f, 0.01984841f, -0.24827169f, 0.01446346f, -0.03755195f, 
    -0.02213579f, 0.10841353f, 0.09380458f, 0.15029651f, -0.53558171f, -1.43829930f, 0.49477273f, 0.16958663f, 
    -0.11588641f, 0.19534071f, 0.27029160f, 0.03359940f, 0.08119112f, 0.05781347f, -0.04618829f, -0.11999670f, 
    0.25287864f, 0.21114519f, 0.34888998f, -0.35988089f, -0.00686122f, -0.01489195f, 0.05627501f, -0.12203583f, 
    0.03952781f, -0.09009255f, 0.10346718f, -0.64064693f, -0.16844133f, 0.01743883f, -0.34409210f, 0.30502993f, 
    -0.17068569f, -0.14752252f, 0.05269796f, -0.09055871f, 0.11968403f, 0.00097369f, 0.00607724f, 0.01614070f, 
    -0.39965641f, 0.24991526f, -0.09918234f, -0.03329169f, -0.02785952f, 0.02693505f, 0.08640523f, -0.02277669f, 
    0.06306382f, -0.00885954f, 0.14785685f, -0.12823170f, 0.06964936f, -0.18087488f, 0.18491016f, -0.27332836f, 
    -0.05223389f, 0.01473781f, -0.05177926f, -0.07618537f, 0.04124374f, -0.16842082f, -0.07751928f, -0.17545639f, 
    0.28441191f, 0.16866456f, 0.04835429f, -0.23824008f, -0.01481067f, 0.06423616f, -0.00071034f, 0.09424295f, 
    0.06842889f, 0.08732725f, -0.04089128f, -0.09635119f, 0.05780166f, -0.09440469f, 0.13392924f, 0.09520721f, 
    -0.17429285f, -0.06312246f, 0.08587167f, -0.19590491f, -0.13974965f, -0.02051042f, 0.05057644f, -0.37520498f, 
    -0.47630572f, -0.86984795f, -0.62138969f, -0.22396617f, 0.02048290f, 0.28253004f, 0.09052459f, 0.13455574f, 
    -0.20750955f, -0.08885821f, -0.18448670f, -0.19300231f, -0.52862370f, -0.78419888f, 0.20480251f, 0.09487770f, 
    -0.07384109f, 0.06154775f, -0.18427388f, 0.07250299f, -0.16186017f, -0.17612854f, -0.18245044f, -0.24034247f, 
    -0.21134391f, -0.56592959f, -0.08379500f, 0.08357570f, 0.16269293f, -0.01179631f, -0.02304831f, 0.16266818f, 
    0.01063607f, -0.19026530f, 0.01820656f, -0.00186308f, -0.83732361f, 0.44871703f, 0.31726453f, 0.08476342f, 
    0.02541713f, 0.00237051f, -0.15624967f, -0.09043851f, -0.18433121f, -0.08150015f, -0.11241274f, 0.22061639f, 
    -0.54035538f, -0.71348971f, -0.68820471f, -0.30264363f, 0.01456856f, 0.11778507f, -0.05712384f, 0.12839770f, 
    0.00854578f, 0.08358003f, 0.08891060f, 0.16427138f, 0.82867402f, 0.12374528f, -0.04194633f, -0.26481193f, 
    0.35264489f, -0.32828063f, 0.06123263f, -0.09910305f, 0.24325728f, 0.02375119f, 0.29793411f, 0.18530852f, 
    0.11569360f, 0.14390394f, 0.46707937f, -0.13953169f, 0.01090510f, -0.06693785f, -0.01337768f, -0.03047447f, 
    -0.10303686f, -0.04398143f, 0.01745880f, -0.18227379f, -0.20471795f, -0.54877502f, -0.15152785f, 0.36041766f, 
    -0.26090989f, 0.20760037f, 0.23200805f, 0.02511877f, 0.13069004f, 0.11337273f, 0.19546850f, 0.13388300f, 
    -0.30572411f, 0.12923467f, 0.12796931f, 0.23527931f, 0.04167975f, -0.10763050f, 0.03758604f, -0.21183158f, 
    -0.13449137f, -0.06157041f, -0.06925394f, 0.00387888f, 0.86452848f, -0.10116582f, -0.33690169f, -0.32726642f, 
    0.08265958f, -0.08366342f, 0.10533915f, -0.06644646f, 0.07624150f, 0.17402428f, 0.09660392f, 0.15374550f, 
    0.13259047f, -0.12472770f, -0.18957841f, -0.25377581f, -0.24404965f, -0.03607011f, -0.06301274f, -0.07119820f, 
    0.03353534f, 0.21229923f, 0.07071153f, -0.22174546f, 0.17877463f, -0.14388704f, -0.25640285f, -0.13919549f, 
    0.15232784f, 0.18130641f, 0.02925871f, 0.11257752f, 0.02389910f, 0.05341871f, -0.41216445f, -0.48810926f, 
    -0.94772184f, 0.22168723f, 0.27622974f, 0.38770396f, -0.03273026f, -0.20860185f, -0.17486328f, -0.07312144f, 
    0.02801365f, -0.04941471f, 0.10309298f, 0.17629060f, -0.16605726f, 0.08692811f, 0.02830778f, -0.19511777f, 
    0.11127751f, -0.03651158f, 0.02479842f, 0.01189021f, -0.02693276f, 0.00549679f, 0.11199261f, 0.04493782f, 
    -0.03328322f, -0.10523240f, -0.05131617f, -0.33742246f, -0.14191258f, -0.05187301f, 0.04280542f, -0.05621007f, 
    0.02882314f, 0.14231266f, 0.19123243f, 0.31949118f, 0.54802299f, -0.08445442f, 0.10901358f, -0.12192510f, 
    -0.29006499f, 0.11656619f, -0.25450385f, 0.13096832f, 0.10240810f, -0.01321535f, -0.15263531f, 0.19437152f, 
    -0.03799606f, -0.17642210f, 0.68223751f, 0.30904403f, 0.05214208f, -0.38042173f, -0.26358515f, -0.35805303f, 
    0.01293877f, -0.03553402f, 0.24538809f, 0.20542750f, 0.38720867f, -0.29363707f, 0.31818327f, -0.41458717f, 
    0.02417258f, -0.11897441f, -0.12826243f, 0.11936743f, -0.07435474f, 0.11472632f, 0.13208689f, 0.18040085f, 
    -0.72143793f, 0.21323892f, 0.38738382f, -0.08761853f, 0.02252229f, -0.46761870f, 0.28804281f, 0.31325078f, 
    -0.15397231f, 0.20784104f, 0.18697718f, -0.08573913f, -0.21910352f, -0.04727683f, -0.11892121f, -0.42765585f, 
    -0.22037877f, 0.10915764f, 0.11460435f, -0.08329000f, 0.05835788f, 0.05588437f, 0.03959623f, -0.19562198f, 
    -0.60806400f, 0.29296640f, 0.30859402f, -0.55938554f, 0.13360617f, -0.37444776f, 0.14811769f, 0.10025448f, 
    0.01821445f, 0.19736591f, 0.05836461f, -0.03615179f, 0.21990736f, -0.35589778f, -0.06699047f, 0.19346322f, 
    0.05930758f, -0.15471593f, -0.02210630f, -0.04784866f, -0.03042319f, -0.11815188f, -0.10021929f, -0.03842415f, 
    -0.53205705f, -0.27970773f, -0.09300268f, -0.26150569f, -0.09219262f, 0.42637506f, 0.05634014f, 0.04652856f, 
    -0.07504866f, 0.08147956f, 0.02891989f, 0.24927634f, 0.50119710f, 0.14373526f, 0.59648752f, -0.55536956f, 
    0.19809274f, -0.26285967f, -0.17178397f, -0.07087031f, -0.29708284f, -0.02153543f, -0.08049943f, 0.04937411f, 
    -0.24335578f, 0.41191626f, -1.18997145f, 0.26536545f, 0.26307887f, 0.06973941f, 0.44759977f, -0.00446045f, 
    -0.02639022f, 0.00581936f, -0.12278674f, -0.02385218f, 0.34064516f, -1.18901372f, -0.03975573f, -0.10271477f, 
    -0.04929606f, -0.03186825f, 0.02770046f, 0.03574115f, -0.11217874f, 0.03416878f, 0.04903654f, -0.13793296f, 
    0.03457997f, -0.15233104f, 0.20878901f, 0.44139072f, -0.00787927f, 0.05124988f, -0.28613830f, -0.24938250f, 
    0.12444431f, 0.33233416f, 0.08623711f, -0.28772962f, -0.45621422f, 0.00106689f, -0.23542942f, 0.34534422f, 
    0.18056981f, 0.07188224f, 0.14605850f, -0.07868524f, 0.20681648f, 0.18701838f, 0.01636129f, 0.25229093f, 
    -0.10801600f, -0.10973851f, -0.46138844f, 0.20787361f, 0.11404551f, -0.24617094f, 0.35799474f, 0.00976785f, 
    0.02320390f, 0.09879912f, 0.06638689f, -0.18834056f, 0.20913824f, -0.21754800f, -0.20877384f, 0.04207746f, 
    -0.01615396f, 0.05796628f, 0.05408214f, -0.24084789f, -0.11051079f, -0.04624834f, -0.18749841f, -0.06889978f, 
    -0.07379065f, -0.14036994f, 0.44497192f, 0.45145035f, 0.41604617f, 0.15077740f, -0.12906924f, -0.00076852f, 
    0.07487503f, -0.19092721f, -0.20181468f, 0.04534701f, -0.66857767f, -0.60144681f, 0.11230992f, -0.57211876f, 
    0.03625928f, 0.26876187f, -0.44818068f, -0.08726387f, -0.05134371f, -0.16227488f, -0.14702877f, 0.04056532f, 
    -0.04473251f, -0.08696679f, -0.31876156f, -0.12463040f, 0.04731620f, -0.41408437f, -0.11074362f, 0.16873433f, 
    -0.16248265f, 0.16575454f, -0.29861823f, -0.56029189f, -0.31125385f, 0.69850874f, -0.43493903f, 0.26269540f, 
    0.24872155f, -0.01085847f, -0.29642573f, 0.10107092f, -0.10282168f, -0.33024687f, -0.11033000f, -0.69854242f, 
    -0.23618358f, 0.14806511f, -0.21503066f, 0.08451341f, -0.01178882f, -0.01223127f, 0.07958467f, -0.02205953f, 
    -0.18477529f, 0.18847986f, -0.07439502f, -0.04804377f, -0.43762502f, 0.12858908f, 0.16588007f, -0.22229935f, 
    -0.15532714f, -0.21035777f, 0.19149897f, -0.00104789f, 0.05085758f, -0.05211375f, 0.15736607f, 0.08691149f, 
    -0.00064245f, -0.60809892f, -0.12706868f, 0.21758866f, -0.11644037f, 0.11952630f, -0.02048922f, -0.08584245f, 
    0.19590852f, 0.06770623f, 0.06929614f, 0.17885852f, -0.95072186f, 0.65443963f, -0.61085480f, -0.17643666f, 
    0.03643070f, 0.09937569f, 0.19379815f, 0.10598250f, -0.09557824f, -0.03728165f, 0.03825198f, -0.07879701f, 
    0.47246149f, -0.47170612f, 0.30806184f, -0.29344118f, -0.29679570f, -0.11734515f, 0.11956287f, -0.28026432f, 
    0.05553843f, -0.07644659f, -0.25956541f, -0.34656718f, 0.17945473f, 0.26807418f, 0.45106047f, -0.19047351f, 
    -0.19784775f, -0.04164044f, -0.10767544f, 0.03590212f, -0.09584846f, -0.19645992f, 0.33543411f, 0.03163673f, 
    -0.12429757f, -0.36557767f, -0.28904200f, 0.07711095f, -0.11605563f, -0.10463458f, 0.25409305f, -0.14620927f, 
    -0.11572583f, 0.18358918f, 0.06882273f, 0.10228238f, -0.76539224f, 0.45207119f, -0.61189651f, 0.32693693f, 
    -0.15350741f, 0.33131826f, -0.25558180f, 0.01800065f, 0.07889241f, 0.11474919f, -0.06233973f, 0.17323163f, 
    -0.24876226f, 0.25490800f, 0.26824075f, -0.31075779f, 0.05953873f, 0.16884395f, 0.01354199f, -0.22232041f, 
    0.02754532f, -0.14534943f, -0.13652575f, -0.08224177f, -0.07351926f, 0.32812965f, 0.03781443f, -0.24611419f, 
    0.03599707f, -0.00499805f, 0.20356956f, -0.04772221f, -0.01936617f, -0.17659247f, -0.70563662f, -0.46556816f, 
    -0.07939908f, -0.09903336f, 0.03180124f, 0.55825937f, -0.15065426f, 0.15570231f, -0.03462641f, -0.08800586f, 
    0.10791802f, 0.28052464f, 0.14348502f, 0.04691680f, -0.51653004f, 0.23807423f, -0.68607813f, -0.33546385f, 
    -0.10325713f, -0.21716973f, 0.34171221f, -0.03404675f, -0.49998966f, 0.22761279f, 0.11410534f, 0.03465721f, 
    -0.53902751f, -0.15332220f, -0.16387136f, 0.03098356f, -0.29589543f, -0.07986685f, 0.14837961f, -0.14371006f, 
    0.20706968f, 0.03013788f, 0.30450177f, 0.19580267f, -0.66845244f, 0.99832338f, 0.33374047f, 0.21632206f, 
    -0.19762348f, -0.31872565f, 0.34810185f, 0.84751177f, -0.12491146f, 0.11798893f, 0.24419510f, 0.31737304f, 
    -0.26557100f, -0.10457420f, 0.02786109f, -0.35490066f, 0.02970301f, -0.16846976f, 0.04754599f, 0.05579865f, 
    -0.02749357f, 0.13890548f, 0.14138758f, 0.15654507f, -0.72539836f, 0.04999350f, -0.11192215f, 0.06525632f, 
    -0.11464028f, -0.01386682f, -0.06192904f, 0.17461112f, -0.28838846f, 0.02180259f, 0.14030908f, 0.02461479f, 
    0.13640584f, -0.59978312f, 0.49245298f, -0.42267066f, 0.13876727f, -0.28450212f, -0.26083073f, -0.15215187f, 
    -0.08336674f, -0.01419166f, -0.05955858f, -0.09561834f, 0.40507716f, -0.26273769f, 0.15194473f, 0.55899936f, 
    0.05461699f, 0.02729426f, 0.07281493f, 0.26742893f, -0.38533249f, -0.11525626f, 0.23779401f, 0.03949590f, 
    0.10584543f, -0.37646964f, 0.08459754f, -0.20904002f, -0.08953141f, 0.05698394f, -0.23290882f, 0.13468455f, 
    -0.02144944f, 0.08802528f, -0.02676394f, -0.10069562f, 0.63470447f, -0.22639389f, -0.20510781f, 0.42672750f, 
    0.30206767f, -0.06116866f, 0.01833632f, 0.38681564f, 0.08200028f, -0.03595243f, -0.02455921f, -0.22289215f, 
    -0.01944700f, -0.00345476f, 0.11226650f, -0.23228672f, -0.09406751f, 0.11588452f, 0.22883549f, 0.00020385f, 
    0.09666812f, 0.16004986f, 0.10399693f, 0.04531095f, -0.32603142f, -0.00018855f, -0.47406650f, 0.24170963f, 
    0.25568357f, -0.03385409f, -0.04305757f, 0.30461279f, -0.05226965f, -0.09099403f, 0.06158388f, -0.14622255f, 
    0.89726782f, 0.06441163f, 0.76719755f, -0.42487442f, -0.20905311f, -0.20390292f, -0.17519030f, 0.22859293f, 
    -0.30442041f, 0.08077601f, -0.14322835f, -0.12968417f, -0.58743382f, -0.25665170f, -0.19190963f, 0.22729161f, 
    0.06167084f, -0.21281603f, -0.07029273f, -0.04261947f, -0.05553192f, -0.01204459f, 0.19802842f, -0.14093444f, 
    -0.77905452f, 0.21722867f, -0.54950386f, -0.03062185f, 0.08862081f, -0.06564688f, -0.05233213f, -0.30802035f, 
    0.00696570f, 0.21174902f, 0.14117780f, 0.31141320f, 0.08805315f, -0.80509311f, 0.23674087f, -0.57880986f, 
    0.10211631f, 0.02266166f, -0.20574217f, -0.07052370f, 0.09395526f, 0.07796277f, 0.20286748f, 0.15532339f, 
    0.59245920f, -0.47941697f, 0.43201828f, 0.21768320f, -0.22370139f, 0.04297445f, -0.34478810f, 0.13796592f, 
    -0.13257545f, -0.00282777f, 0.05274227f, 0.05191621f, 0.37570855f, 0.65950656f, -0.01939474f, 0.10357458f, 
    0.08707232f, -0.00976662f, 0.02049445f, -0.13958248f, 0.06100341f, -0.13254118f, -0.20584115f, 0.13833937f, 
    -0.28504512f, -0.09805755f, -0.27218351f, 0.11602128f, -0.18068787f, 0.16595863f, 0.08524138f, 0.09014566f, 
    0.01718838f, -0.18474399f, -0.19084309f, -0.55021113f, -1.23466933f, 0.27030209f, -0.05583247f, 0.11438069f, 
    0.22690344f, 0.18264273f, 0.35253474f, -0.06131155f, -0.29565069f, 0.16311333f, 0.00150935f, 0.25637224f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20788413f, 0.25606969f, 0.14200182f, -0.11292391f, -0.19732018f, 0.03693845f, 0.00119177f, -0.27311647f, 
    0.11323899f, 0.03034713f, 0.03456635f, -0.04056155f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
