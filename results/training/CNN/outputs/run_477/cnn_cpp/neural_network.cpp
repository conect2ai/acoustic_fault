#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.78436130f, -0.67119968f, 0.61169481f, 0.80622631f, 0.25452009f, 0.50459743f, 0.01221663f, -0.50605696f, 
    -0.02968903f, -0.21141802f, 0.25290355f, -0.53669810f, 0.59108943f, 0.58755970f, -0.91187096f, 0.16675410f, 
    -0.24672033f, -0.56039447f, -0.05632560f, -0.81057882f, -0.63689613f, -0.77712631f, 0.27076331f, 0.75570112f, 
    0.06081187f, 0.26563233f, -0.20579015f, -0.25568759f, 0.92541951f, -0.79843473f, 0.61353201f, -0.73256218f, 
    -0.28705114f, -0.20835850f, -0.04415666f, 0.37057284f, -0.27842516f, 0.04261543f, 0.18162352f, 0.58687872f, 
    0.76454955f, 0.16128606f, -0.51315820f, -0.45266289f, -0.15999912f, -0.65325689f, -0.21790245f, -0.19925703f, 
    -0.87155056f, -0.13754316f, 0.33956346f, 0.48885489f, 0.41907567f, 0.17812644f, 0.59049654f, 0.18441929f, 
    0.74546969f, 0.31109732f, -0.50571728f, 0.58272141f, -0.19600677f, 0.38293424f, -0.62417078f, 0.60178614f, 
    -0.78559214f, -0.58658695f, -0.29718733f, -1.04412866f, -0.38907701f, -0.25253835f, 0.26247340f, -0.00549969f, 
    0.21799031f, 0.33694184f, 0.70769620f, -0.35342970f, -0.28227928f, -0.72577345f, 0.48542365f, 0.25022572f, 
    0.51177144f, 0.01189154f, -0.63981616f, 1.08127689f, -0.29244187f, -0.66377509f, 0.81990570f, 0.10473770f, 
    -0.21391919f, 0.42392701f, -0.62383890f, -0.64440840f, -0.70762306f, -0.13621272f, -0.37672198f, 0.80778074f, 
    -0.26123664f, 0.21544331f, 0.04316634f, 0.82299757f, 0.45295486f, 0.69667166f, -0.28044438f, -0.53004110f, 
    0.36933628f, -0.58153409f, 0.05255872f, 0.28153455f, -0.30887079f, 0.76253176f, 0.92559278f, 0.22481503f, 
    0.23885034f, -1.00472665f, -0.22833443f, -0.11911933f, -0.23890112f, 0.78447002f, 0.82872885f, -0.53098083f, 
    -0.17877565f, 0.33367342f, 0.20861503f, 0.01113295f, 0.37257966f, 0.09887461f, -0.70292771f, -0.34779301f, 
    -0.72482395f, -0.11196160f, 0.92275137f, -0.03374957f, 0.34371576f, -0.29081106f, -0.22846478f, 0.47419605f, 
    -0.02402610f, -0.10715015f, -0.83735800f, 0.57945061f, 0.57354146f, -0.09917007f, -0.17357530f, 0.84990478f, 
    0.79318482f, 0.64675182f, 0.95135826f, -0.54319352f, 0.39994752f, 0.22162938f, 0.13299935f, -0.24075834f, 
    -0.17934100f, 0.98843110f, 0.70082706f, 0.46937278f, 0.12633355f, -0.20980980f, -0.30033177f, 0.04988373f, 
    0.55844551f, 0.01742342f, -0.59856039f, -0.41502762f, -0.67572886f, 0.54230565f, 0.62820363f, 0.56548446f, 
    -0.02236174f, -0.02715030f, -0.62410682f, -0.93248051f, -0.42950672f, -0.54327238f, 0.48846835f, -0.48662755f, 
    -0.29288563f, 0.13796094f, 0.15113269f, 0.14340350f, 0.66225886f, -0.33010468f, 0.56390548f, 0.34288463f, 
    -0.46213987f, -0.83128124f, -0.71375436f, -0.43934247f, 0.11435048f, -0.87867761f, -0.22375900f, 0.92773956f, 
    0.95210636f, 0.14355625f, -0.69892430f, -0.03196648f, -0.00403437f, 0.44052160f, 0.39679295f, 0.47986600f, 
    0.58279377f, 0.39197809f, -0.49603260f, 0.33785710f, -0.09835912f, 0.24008442f, 0.69201690f, -0.82550937f, 
    0.36007810f, 0.15861902f, -0.46404219f, -0.18144543f, -1.00318241f, -0.17535420f, 0.14023970f, 0.47963801f, 
    -0.30133188f, -0.88465184f, -0.40437257f, 0.64572513f, 0.57751912f, -0.37474266f, -0.64561296f, 0.23858713f, 
    -0.11481240f, -0.45471111f, -0.62120259f, 0.19513363f, 0.63262171f, -0.74395567f, 0.53768855f, 0.08515546f, 
    -0.19995672f, 0.09320700f, 0.91114438f, 0.53914922f, 0.40203550f, 0.76073241f, 0.48239243f, 0.01930324f, 
    0.50087112f, 0.43589118f, -0.24466346f, 0.21162379f, 0.32619721f, -0.21448092f, -0.85097808f, -0.94480944f, 
    -0.53571475f, 0.37417412f, -0.16087157f, 0.39599988f, -0.12378927f, -0.81066525f, -0.16200547f, -0.75400740f, 
    0.34373534f, -0.78075278f, -0.12584572f, 0.42690465f, 0.28945976f, -0.18885387f, 0.83073163f, -0.48412544f, 
    -0.75212145f, 0.21067697f, -0.09536350f, -0.48366481f, -0.42794701f, -0.49498788f, -0.49778071f, -0.13468002f, 
    0.30531186f, 0.80740756f, 0.86975241f, -0.13506517f, 0.16535196f, 0.26196817f, -0.07856875f, -1.23985744f, 
    -0.11036032f, -0.21543130f, 0.35931131f, 0.53581250f, 0.67115366f, 0.34172559f, -0.22810404f, 0.46115240f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27767289f, 0.03722907f, 0.14778717f, -0.02824741f, 0.18588592f, 0.45084709f, -0.00340933f, 0.13143969f, 
    0.31560013f, -0.06359962f, -0.01306818f, 0.11095887f, 0.01733626f, 0.28558943f, -0.02393232f, -0.21180174f, 
    -0.06968679f, 0.20974639f, 0.11474197f, -0.00456847f, 0.09727377f, -0.05957579f, -0.19442621f, 0.19755144f, 
    -0.09534870f, 0.09110336f, -0.05069842f, -0.26310560f, 0.20302381f, 0.30483931f, -0.37649581f, 0.19596161f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.29351163f, 0.04277503f, 0.24172090f, 0.07783668f, 0.07726458f, -0.04518070f, -0.10105996f, 0.03976934f, 
    0.00002497f, -0.02510112f, -0.06049312f, 0.13638584f, 0.02205342f, 0.07611629f, 0.41960818f, 0.16837350f, 
    0.04875160f, -0.12455797f, 0.05159511f, 0.03779531f, -0.01239500f, -0.03777581f, -0.07515346f, -0.19940513f, 
    0.17760241f, 0.25378409f, -0.08066817f, -0.06715478f, -0.33487397f, 0.01400142f, 0.13665590f, 0.10524851f, 
    -0.02241086f, 0.09441098f, -0.10590493f, -0.04782252f, 0.12379212f, -0.00743421f, 0.00904245f, 0.17967804f, 
    0.06270628f, -0.03209360f, -0.00521517f, 0.00316589f, -0.05473919f, 0.14919513f, 0.04796903f, -0.21507794f, 
    0.09344643f, 0.05120671f, -0.02345059f, 0.06669564f, 0.16209251f, -0.13072628f, -0.33911911f, -0.11477200f, 
    -0.16164832f, 0.19848873f, 0.01900365f, 0.01862736f, 0.11343405f, -0.01196178f, 0.08035491f, 0.04360291f, 
    -0.09827840f, -0.08692086f, 0.08210862f, 0.23236062f, 0.15019836f, -0.04902619f, 0.09474041f, -0.08684941f, 
    -0.16237892f, 0.06023120f, 0.01886053f, -0.05156108f, 0.11857913f, -0.08024003f, 0.20024008f, -0.08106162f, 
    0.07655139f, 0.12009785f, 0.01195883f, -0.05835490f, -0.00222455f, -0.10042877f, -0.04835621f, 0.15124628f, 
    0.18408890f, -0.05638649f, 0.03959125f, 0.07771581f, -0.02876422f, 0.11535632f, 0.09344927f, -0.08178189f, 
    0.04887961f, 0.12759672f, -0.15796702f, -0.11040490f, -0.07884485f, -0.15341587f, 0.15639447f, 0.05602746f, 
    0.02136223f, 0.06409941f, 0.22247654f, 0.10551646f, -0.34225756f, -0.08387350f, -0.27331963f, 0.15545723f, 
    0.10194019f, -0.00843074f, -0.38079283f, 0.04629797f, -0.02076534f, -0.34412780f, -0.05385892f, 0.07240146f, 
    -0.14796664f, 0.02286855f, -0.17067726f, -0.18216276f, 0.05294563f, 0.23693907f, 0.30710226f, 0.07971203f, 
    0.10500636f, 0.12478182f, -0.07993752f, 0.14024203f, 0.00764036f, -0.04938373f, -0.02456755f, -0.09596156f, 
    -0.01883877f, 0.00345499f, 0.13382633f, -0.08345768f, 0.11802021f, 0.15724581f, 0.10663923f, 0.03073548f, 
    -0.32789707f, -0.13945483f, -0.22600220f, 0.05520313f, -0.04672347f, 0.07662815f, 0.03254794f, 0.04002319f, 
    -0.13390213f, -0.60997301f, -0.16545306f, -0.09712643f, 0.09577122f, 0.07457107f, -0.03813045f, 0.05061164f, 
    -0.04947549f, 0.10037264f, 0.29862145f, 0.17369828f, 0.20549975f, 0.00843841f, 0.24500260f, -0.07534807f, 
    -0.00051362f, 0.00083819f, 0.05539283f, 0.16354564f, 0.07067793f, 0.23072973f, -0.18837395f, -0.05208540f, 
    -0.02115187f, 0.15617591f, -0.00632001f, -0.05513709f, -0.35996029f, 0.30732459f, 0.18007368f, 0.07766487f, 
    0.11512510f, 0.02668687f, -0.02005729f, -0.09729780f, 0.24467506f, -0.11195485f, 0.14376901f, -0.27365977f, 
    -0.10540494f, -0.12329789f, -0.25235763f, 0.20951632f, -0.01106455f, -0.00796623f, -0.16340813f, -0.24220942f, 
    -0.20004117f, 0.00416336f, 0.02032846f, 0.04364160f, -0.04626141f, 0.06260271f, 0.01454981f, 0.22059190f, 
    0.03154917f, -0.10273118f, -0.08054309f, -0.12694517f, -0.12353981f, -0.01859650f, 0.07433573f, 0.02611656f, 
    -0.00866989f, 0.23782869f, -0.08870183f, -0.14612582f, -0.20295191f, -0.02763528f, 0.17273468f, 0.05516553f, 
    -0.07740276f, 0.04139055f, 0.01178705f, -0.03624262f, -0.00958439f, 0.13371807f, 0.01952377f, 0.07107183f, 
    0.01121550f, -0.01372311f, -0.62032229f, 0.04837467f, -0.19273858f, 0.02108762f, 0.11151783f, -0.01138591f, 
    0.14509669f, 0.04339362f, -0.06045821f, 0.31695667f, -0.08200351f, -0.07706538f, -0.08641636f, 0.13902019f, 
    -0.00743050f, -0.16386016f, 0.02719996f, 0.11423955f, -0.00569474f, 0.13161629f, -0.03889401f, 0.17676416f, 
    -0.18177924f, 0.13725843f, 0.01326075f, 0.11640960f, -0.10561771f, -0.24045867f, -0.00879531f, 0.13225128f, 
    0.04390319f, 0.12288497f, 0.11166205f, -0.09101517f, -0.20104651f, -0.02313005f, 0.04434302f, -0.04162206f, 
    -0.19933522f, 0.01065889f, 0.22107458f, 0.05880659f, 0.11421407f, 0.08339783f, -0.13862634f, 0.07154835f, 
    0.17439340f, -0.00817405f, 0.06670270f, 0.10261389f, 0.09263887f, -0.05185810f, -0.02442967f, 0.12850532f, 
    0.02022692f, 0.05136150f, -0.02927456f, -0.04981551f, 0.02360547f, -0.00838669f, 0.03397650f, -0.00121196f, 
    -0.05304764f, -0.00236962f, -0.00122578f, -0.00996899f, -0.02409574f, 0.02874929f, -0.02828784f, 0.02317642f, 
    0.03186737f, -0.02367700f, 0.00140559f, 0.01163449f, -0.04997852f, -0.06206735f, -0.01070532f, 0.03872642f, 
    -0.04301030f, -0.02062482f, -0.06031080f, -0.04899278f, 0.04808000f, 0.04642594f, -0.03449262f, 0.04634349f, 
    -0.02146343f, -0.02607948f, -0.00695372f, -0.04625116f, 0.02266344f, -0.02025489f, 0.00069611f, 0.03722201f, 
    0.04548012f, 0.03227492f, -0.00572661f, 0.01084177f, 0.04737652f, 0.04272689f, 0.01539159f, -0.00601249f, 
    0.02186172f, -0.03058685f, 0.04582817f, 0.01062381f, -0.04479293f, -0.00734175f, 0.02563956f, -0.00642728f, 
    0.03230517f, -0.06259595f, -0.04173899f, -0.03567768f, 0.04618445f, 0.01121801f, 0.02184651f, 0.01575158f, 
    0.04296692f, -0.02545975f, 0.03919930f, -0.00501274f, -0.02781516f, -0.06348683f, -0.03357486f, 0.01342189f, 
    0.01018083f, 0.01695261f, -0.05507758f, -0.01431349f, -0.04836067f, 0.00763330f, 0.04798024f, -0.03775417f, 
    0.02447239f, 0.04866768f, -0.00546087f, -0.01440084f, 0.01473595f, 0.04237925f, -0.02453290f, -0.01999300f, 
    -0.06298153f, 0.01726866f, 0.00899457f, 0.02811404f, -0.01978433f, -0.00896137f, -0.05582970f, 0.01884072f, 
    0.02508374f, 0.03683531f, -0.05926914f, -0.05986808f, 0.03506181f, 0.03995056f, 0.03769692f, -0.01015146f, 
    -0.02692270f, -0.02137205f, -0.05593436f, -0.00106696f, 0.04478762f, 0.00391248f, -0.06440612f, -0.06019700f, 
    -0.00852983f, 0.04454225f, -0.02071582f, -0.06384940f, -0.02223193f, 0.01727177f, -0.06010137f, -0.00383140f, 
    -0.02508619f, -0.04581310f, 0.00200408f, -0.04657035f, -0.06037452f, -0.01422529f, -0.02797434f, 0.01145773f, 
    -0.00175778f, -0.03269643f, -0.05787235f, 0.04809919f, -0.01803540f, -0.02601803f, -0.01169247f, -0.02267390f, 
    -0.04542028f, -0.06068235f, -0.05242621f, -0.04472727f, 0.03573461f, -0.06679600f, 0.03710994f, 0.01995583f, 
    -0.00764019f, 0.02530576f, -0.05971466f, -0.04259809f, 0.02648330f, 0.05873917f, -0.05625018f, -0.00171231f, 
    -0.04688161f, 0.01348081f, 0.01480195f, -0.01563605f, -0.03115704f, 0.01331513f, -0.04729525f, -0.00207840f, 
    -0.02761291f, -0.02147704f, -0.01561635f, -0.03879049f, -0.02957857f, 0.02557079f, 0.02383968f, -0.03251801f, 
    -0.03158206f, -0.02869141f, -0.04960327f, 0.01203327f, -0.02731855f, -0.03453311f, 0.00685078f, -0.05502783f, 
    -0.00507594f, -0.01758364f, 0.03975140f, -0.03113719f, 0.00359305f, -0.00058119f, 0.05223066f, -0.06133017f, 
    -0.05723489f, 0.04467497f, 0.02640847f, -0.06098934f, -0.03349570f, -0.03676940f, 0.01974356f, 0.02859472f, 
    0.02666901f, 0.04868633f, 0.01184370f, -0.05465670f, 0.05730119f, 0.04384521f, 0.02840541f, -0.01087189f, 
    -0.01430548f, 0.03399602f, -0.04865786f, 0.03344820f, -0.01861607f, 0.04957190f, 0.03828670f, -0.05112734f, 
    -0.02859374f, 0.02771022f, -0.00359338f, -0.05430565f, 0.01314635f, -0.02907644f, -0.05131733f, 0.02168150f, 
    -0.04106010f, -0.04941740f, -0.00945305f, -0.01171307f, 0.01741606f, -0.04878066f, -0.04714460f, 0.01682911f, 
    -0.00866354f, -0.05299973f, 0.02322422f, -0.06735282f, 0.00916250f, 0.00298392f, -0.03445956f, 0.03948217f, 
    0.04084988f, -0.00831857f, -0.01680617f, -0.00847258f, -0.03475206f, -0.04880713f, 0.00281493f, 0.03761500f, 
    0.04345007f, -0.05421827f, 0.01571626f, -0.06024374f, -0.00567045f, -0.03398621f, -0.03495504f, -0.00788389f, 
    0.00726425f, 0.04857841f, -0.03311540f, -0.01894909f, -0.02656769f, -0.06194811f, 0.02676181f, 0.03139602f, 
    0.00843352f, -0.05945199f, -0.01228104f, 0.00166205f, 0.01323722f, 0.00997341f, -0.06244824f, -0.03220574f, 
    0.01528134f, 0.02957885f, 0.00851630f, 0.04988002f, 0.04795783f, -0.02470376f, -0.05049855f, -0.03489825f, 
    -0.01745241f, -0.01365352f, -0.03799242f, -0.01164086f, -0.05942297f, -0.03911760f, 0.03753474f, -0.05467710f, 
    -0.01407728f, -0.00799326f, -0.02278014f, -0.03690574f, -0.05339757f, 0.03672372f, 0.04076137f, -0.03108590f, 
    0.01000070f, -0.03040873f, 0.00211604f, -0.02763668f, 0.05307102f, 0.05244981f, -0.04780200f, -0.03757140f, 
    0.00965257f, -0.05624504f, 0.00477148f, -0.00376727f, -0.01079989f, -0.06267027f, -0.00878849f, 0.01667252f, 
    -0.03906384f, 0.05397800f, -0.06294540f, -0.02304175f, -0.01182840f, -0.03738211f, 0.01172549f, -0.05849272f, 
    -0.05080680f, -0.04823431f, 0.03103162f, 0.03230666f, 0.03742767f, -0.01648446f, 0.04243497f, -0.02903675f, 
    0.01199772f, 0.05669901f, -0.05224309f, 0.01279512f, 0.01498533f, -0.02910303f, 0.04184316f, 0.00159337f, 
    0.04427984f, 0.01378508f, -0.02938111f, -0.00847052f, 0.02488128f, -0.01460803f, 0.02643325f, 0.05027675f, 
    -0.05905445f, -0.00001263f, -0.01866037f, 0.03812391f, -0.05287777f, 0.01978049f, -0.02505073f, 0.02159650f, 
    0.05716388f, -0.01198819f, -0.00656416f, -0.00416954f, -0.03729396f, 0.04806817f, -0.03350637f, -0.02101750f, 
    0.03226249f, -0.05430791f, 0.05577069f, -0.05150096f, -0.00725581f, -0.04992195f, -0.04054091f, 0.04356211f, 
    0.00826521f, -0.02328419f, 0.04426368f, 0.04775945f, -0.00448184f, 0.01237792f, -0.04903381f, -0.03729757f, 
    0.03211869f, -0.02899050f, -0.06403864f, 0.00948808f, 0.00140440f, -0.02294300f, 0.04703896f, -0.02444567f, 
    0.00168572f, -0.03143665f, -0.06575038f, -0.05478963f, 0.00463683f, 0.02791321f, 0.04032154f, -0.04137018f, 
    -0.05737492f, -0.04528193f, -0.04282878f, -0.03435557f, 0.00808048f, 0.05696977f, -0.01744230f, -0.02917166f, 
    0.05457710f, 0.04300593f, 0.03080826f, 0.02155819f, 0.05746469f, -0.03609418f, -0.02748326f, -0.00950741f, 
    -0.00758928f, 0.00405344f, -0.03428333f, 0.02360268f, -0.03366144f, -0.04515543f, 0.02230795f, 0.00855886f, 
    -0.01550161f, -0.01539239f, 0.01527196f, 0.01350981f, -0.00044211f, -0.03434500f, -0.02750110f, 0.02057124f, 
    -0.06430235f, 0.04953759f, -0.01687604f, -0.02551698f, -0.03858285f, 0.01805667f, -0.04209797f, -0.04437442f, 
    0.01162183f, -0.01645298f, -0.04143482f, -0.05373013f, 0.04064246f, 0.04865643f, 0.03637040f, -0.06018790f, 
    0.02362356f, -0.00796706f, -0.02891955f, -0.01241951f, -0.05686834f, -0.02517859f, -0.00014680f, -0.03478993f, 
    0.00067821f, -0.00408500f, 0.02068280f, -0.05621324f, -0.03918796f, 0.02370534f, 0.02268669f, -0.02822219f, 
    0.03135522f, 0.01015169f, 0.01502310f, -0.03390327f, -0.00201379f, 0.01604272f, 0.05744175f, 0.00408170f, 
    0.02438258f, 0.02021649f, 0.01094632f, 0.01574014f, 0.03096109f, -0.01153448f, -0.03949704f, 0.03709720f, 
    -0.05885924f, -0.04622803f, -0.01495075f, -0.03438114f, 0.01964748f, -0.01844869f, -0.00011889f, 0.02115934f, 
    -0.04448253f, 0.05137802f, -0.03618890f, -0.02163866f, -0.04679780f, -0.02461135f, -0.03606069f, 0.01185969f, 
    -0.03290333f, -0.00046852f, 0.00634661f, 0.01375054f, -0.01392991f, -0.04698969f, -0.04874688f, 0.03788874f, 
    -0.06050832f, -0.01384255f, 0.01860191f, -0.02922492f, 0.02146080f, -0.00115009f, -0.01371552f, 0.02160754f, 
    -0.02480310f, -0.01206739f, -0.01610670f, -0.00796457f, -0.05730893f, -0.00872663f, -0.03090027f, 0.03937539f, 
    0.04110466f, -0.04569477f, 0.00281012f, 0.00988785f, -0.04736058f, -0.00341621f, -0.02304785f, -0.05582024f, 
    0.04568572f, -0.04265973f, 0.02100286f, -0.02511214f, -0.05025285f, -0.02982295f, -0.01292039f, -0.00129555f, 
    -0.03580656f, -0.02240378f, -0.04576042f, -0.01998245f, 0.02801167f, 0.05925798f, 0.03891421f, 0.02505143f, 
    0.00892857f, -0.01634417f, 0.04560461f, 0.01683887f, -0.04558466f, -0.02211711f, 0.03973908f, 0.03641149f, 
    -0.04446765f, -0.02884553f, -0.05831883f, -0.06379875f, -0.05342440f, 0.01518702f, 0.03795272f, -0.02585978f, 
    0.02270360f, 0.02816372f, 0.00422634f, -0.00689183f, -0.00334557f, -0.05784061f, -0.04403410f, 0.04344254f, 
    -0.01961153f, -0.00539163f, -0.02348565f, 0.02250826f, -0.02557972f, 0.03382994f, 0.04059741f, 0.00704841f, 
    -0.04417086f, -0.00564625f, -0.02416356f, 0.02239070f, 0.04507273f, -0.02373267f, -0.02677343f, 0.03130041f, 
    -0.00226732f, -0.02248347f, 0.01892239f, -0.00943499f, -0.02549656f, -0.01799996f, -0.05170720f, -0.05791403f, 
    -0.01973093f, -0.00042226f, -0.02927180f, -0.03746302f, -0.04396388f, -0.05702827f, -0.04653950f, -0.05535669f, 
    0.03442245f, -0.03124612f, 0.04003237f, -0.04641615f, 0.04933970f, 0.01974636f, -0.06136822f, 0.03038950f, 
    0.03052303f, 0.04132909f, -0.02959181f, -0.02473251f, 0.03533901f, -0.02320381f, 0.03530622f, -0.06403377f, 
    -0.06312634f, -0.01328805f, 0.02184504f, 0.00465080f, -0.06074944f, -0.04769089f, 0.01746887f, 0.01617688f, 
    0.04359289f, 0.01234850f, -0.03265593f, 0.02764396f, 0.02415481f, 0.02837805f, -0.05108583f, -0.05818447f, 
    -0.05055782f, 0.05092739f, -0.05299476f, 0.01866456f, 0.05122117f, -0.06046315f, 0.03732974f, -0.03531157f, 
    -0.01053242f, 0.02749131f, -0.01865232f, 0.04464865f, -0.01873581f, -0.05800212f, 0.01770680f, -0.03220094f, 
    -0.05100843f, 0.00742927f, 0.02044896f, -0.03579126f, -0.05858251f, 0.03289655f, -0.00535728f, -0.05137743f, 
    0.01951608f, 0.04764067f, -0.02381818f, 0.02188843f, 0.03416944f, 0.00467203f, 0.01123292f, 0.04222903f, 
    -0.05156092f, -0.05886851f, -0.05970981f, 0.04877831f, 0.01999393f, -0.01175170f, -0.02961069f, 0.03088315f, 
    -0.05060229f, -0.04738009f, 0.03290252f, 0.05098637f, -0.03237192f, 0.00587640f, 0.01645116f, 0.01160489f, 
    -0.03712770f, 0.01858070f, 0.02367859f, 0.03289219f, -0.01527732f, -0.05457896f, 0.04165352f, -0.06107682f, 
    0.00633518f, 0.01742693f, -0.02900565f, 0.00911376f, 0.01077573f, 0.03149229f, -0.05521689f, 0.04172316f, 
    -0.02967837f, -0.06316915f, 0.04343153f, -0.06116755f, 0.03163534f, -0.03190770f, -0.00667282f, -0.05373236f, 
    0.04317265f, 0.02904191f, -0.06266093f, 0.02953588f, -0.02459281f, -0.01263029f, -0.01368201f, -0.06291766f, 
    0.02884235f, 0.03183812f, -0.02767739f, -0.00441660f, -0.02310598f, -0.01007974f, -0.00574369f, -0.03458108f, 
    -0.04902464f, -0.03128203f, 0.01797719f, -0.05347719f, 0.00549619f, -0.02935578f, -0.01290965f, -0.02473103f, 
    -0.04830195f, 0.00780494f, 0.03280506f, -0.00894301f, -0.02334851f, 0.02162702f, -0.01178844f, -0.03264721f, 
    0.04436745f, 0.04129210f, 0.02539671f, -0.02022175f, 0.04336853f, 0.01001374f, 0.01842260f, -0.02530660f, 
    0.03732687f, 0.00667625f, 0.02062318f, -0.03573301f, 0.00542474f, -0.04138573f, -0.01142709f, 0.03464023f, 
    -0.02873025f, 0.04858518f, -0.04435116f, -0.04375737f, 0.01556907f, -0.04908580f, 0.02546340f, 0.04185411f, 
    -0.00972426f, -0.02934068f, 0.01028081f, -0.03307856f, 0.05120171f, 0.00461258f, -0.06352986f, 0.02721631f, 
    -0.01449810f, 0.01257432f, 0.01550171f, -0.05263559f, -0.05199671f, -0.04060131f, -0.01858516f, 0.03726337f, 
    -0.04476602f, 0.03296708f, -0.04784574f, -0.04990467f, 0.05032184f, 0.03196780f, -0.02330756f, 0.03742180f, 
    -0.00205270f, -0.01053549f, -0.02505535f, -0.04085333f, -0.04298481f, -0.05293085f, 0.03657774f, 0.01339875f, 
    -0.01470532f, -0.06470007f, -0.01579063f, 0.02891842f, -0.06470507f, 0.04340600f, 0.03311945f, 0.00298209f, 
    0.00622080f, -0.05966154f, -0.02761739f, 0.04432479f, -0.01733213f, -0.02377770f, 0.03405538f, -0.05811305f, 
    0.01705473f, -0.05491086f, -0.02994872f, 0.00535061f, -0.04258518f, 0.03012699f, 0.00072077f, 0.02794175f, 
    -0.03481898f, -0.02494852f, 0.00639844f, -0.06269293f, 0.03369696f, 0.04969830f, 0.03926262f, -0.04594648f, 
    -0.02487149f, 0.00866351f, 0.04501185f, -0.00721922f, -0.01386089f, 0.00196840f, -0.00103548f, -0.00422864f, 
    -0.05601811f, -0.05985099f, -0.03116751f, 0.03328533f, -0.00984652f, -0.01298417f, 0.02357314f, -0.06567902f, 
    0.01814819f, 0.00482463f, 0.02477093f, -0.03635310f, -0.00041146f, -0.03692071f, -0.03694170f, 0.05135183f, 
    0.05021976f, 0.00466865f, -0.06373809f, -0.05296235f, 0.01740855f, -0.04681558f, 0.03436217f, -0.00498325f, 
    -0.03995556f, -0.02686990f, -0.00871469f, -0.05123166f, -0.03494561f, 0.02669173f, -0.05569260f, -0.05293855f, 
    0.04502581f, -0.01096783f, 0.00728381f, -0.03240849f, -0.02085618f, 0.01194469f, -0.04793903f, -0.03497436f, 
    -0.01642552f, -0.00910010f, 0.05083806f, -0.01063318f, -0.03653890f, 0.00171124f, -0.02181833f, 0.02556263f, 
    -0.06561784f, 0.04633603f, -0.04892169f, 0.02865129f, -0.03647744f, 0.04895555f, -0.02621335f, -0.04499024f, 
    0.00651429f, -0.03178101f, 0.04465950f, -0.00759978f, 0.01018920f, 0.01229432f, 0.03486476f, 0.01355645f, 
    -0.01758821f, -0.00631920f, 0.04586395f, 0.00974727f, -0.02201132f, -0.04080909f, -0.03243648f, -0.01565131f, 
    -0.01796979f, 0.04187943f, 0.01071903f, 0.00248482f, -0.00829457f, 0.01387884f, -0.05407936f, -0.02205395f, 
    -0.05413753f, -0.02044948f, -0.02045213f, -0.03020066f, -0.02013007f, 0.01047945f, 0.04820457f, -0.02405762f, 
    -0.04092278f, 0.03432654f, -0.06210260f, -0.04510794f, -0.04426745f, 0.02910585f, -0.01796109f, -0.00248003f, 
    -0.06086669f, -0.05097900f, -0.04677482f, 0.03554337f, 0.03757158f, -0.04012434f, -0.00864376f, -0.02816810f, 
    0.02286797f, -0.06140601f, -0.00126418f, 0.03599968f, -0.04301368f, -0.06459778f, -0.03192498f, -0.00643180f, 
    -0.04328218f, 0.03104653f, -0.00005260f, -0.02442714f, -0.06542604f, 0.02538389f, 0.03431355f, 0.05866798f, 
    -0.05373070f, -0.05451015f, -0.06532732f, 0.02582622f, 0.01841470f, -0.05172260f, -0.06409512f, -0.06072476f, 
    -0.00280031f, 0.01441179f, 0.04923004f, 0.03481146f, -0.01773728f, -0.01800489f, -0.00148031f, -0.00675359f, 
    0.03813100f, 0.04536207f, -0.03607169f, -0.05328529f, -0.06671125f, 0.03427274f, -0.03106323f, 0.00059541f, 
    0.03939258f, -0.03241472f, -0.05929201f, -0.05610027f, 0.02896993f, 0.01206020f, 0.03317015f, 0.01855098f, 
    -0.04978518f, -0.02531931f, -0.05686932f, -0.04911897f, 0.02327885f, 0.03921335f, -0.05058745f, 0.00623025f, 
    -0.02294031f, -0.03843580f, -0.00911137f, -0.03352327f, -0.04221978f, -0.00319999f, -0.03680794f, -0.03758074f, 
    -0.00129377f, 0.00797047f, -0.05498567f, 0.03965253f, -0.01740160f, -0.05771592f, 0.04058291f, -0.03793390f, 
    -0.03924810f, -0.04217472f, -0.05298328f, 0.04598819f, -0.06529105f, 0.04441238f, -0.04452695f, -0.03555691f, 
    -0.01889206f, 0.00791862f, -0.06800579f, 0.04905115f, -0.06461897f, -0.03690759f, 0.01837496f, -0.02785327f, 
    0.04557484f, 0.04417834f, -0.02215265f, 0.00294165f, 0.04509683f, 0.02013693f, -0.03070240f, -0.02941906f, 
    -0.04672073f, -0.04154322f, 0.03930793f, -0.05019026f, -0.01353530f, -0.03322709f, -0.03473563f, 0.00125304f, 
    0.02481322f, -0.02625495f, -0.02823133f, 0.03972327f, -0.02054772f, 0.00237679f, 0.00713222f, -0.00497130f, 
    -0.04161281f, 0.00257846f, -0.06151899f, 0.04901746f, -0.01780322f, -0.01162655f, -0.04633585f, 0.01425297f, 
    -0.03984113f, -0.04406487f, 0.02018634f, -0.01007910f, -0.03198725f, -0.03584724f, 0.00320408f, -0.01503378f, 
    0.04528718f, -0.02987207f, -0.06019114f, 0.00289679f, -0.06246062f, -0.05259750f, -0.02780078f, -0.02311880f, 
    -0.03505377f, 0.01191511f, 0.04703674f, 0.04062802f, -0.00254427f, -0.03868353f, -0.05463452f, -0.05342619f, 
    0.01761639f, -0.01770937f, 0.04594689f, -0.02810948f, -0.05814475f, 0.00203854f, -0.05725560f, -0.01470573f, 
    -0.04119581f, -0.02225332f, -0.05741118f, -0.03364645f, 0.02959469f, -0.05275257f, -0.00395222f, 0.00072799f, 
    -0.03707856f, -0.04076646f, 0.02705166f, 0.02891762f, -0.05362361f, -0.04335091f, -0.01342816f, 0.01342823f, 
    -0.06351848f, 0.00612502f, -0.03049667f, 0.01960731f, -0.01009891f, -0.04592030f, -0.03912575f, 0.02139428f, 
    0.00592315f, -0.06136635f, -0.01676561f, 0.01581302f, 0.01598081f, -0.02023331f, -0.00837270f, -0.02855641f, 
    0.00108774f, -0.04776854f, -0.05312039f, 0.04146955f, -0.03741111f, 0.01812656f, -0.05002737f, -0.01656868f, 
    -0.01375294f, 0.03527748f, 0.04774344f, -0.02404492f, 0.00602796f, -0.03675328f, -0.02523050f, 0.04573024f, 
    -0.03295423f, -0.05450427f, -0.01434364f, -0.06119634f, -0.03243855f, -0.01143232f, -0.04949652f, -0.06435263f, 
    -0.05936306f, -0.01349392f, -0.03940397f, 0.01749116f, -0.00612395f, 0.04246391f, -0.00845162f, 0.03980714f, 
    0.02877133f, -0.05882900f, -0.00684031f, -0.03653441f, -0.00791351f, 0.03186536f, -0.01900719f, 0.04603505f, 
    -0.06614593f, 0.02542797f, 0.03783962f, -0.01450762f, -0.01915491f, 0.00053351f, -0.05610372f, -0.05141367f, 
    0.32929713f, -0.00860825f, -0.30649486f, -0.06944468f, 0.03282769f, 0.15697868f, -0.01528881f, -0.08370258f, 
    -0.02242510f, -0.35522878f, 0.01330678f, 0.14735763f, 0.05179254f, -0.09284221f, -0.18758126f, 0.22955774f, 
    0.06638803f, 0.08281699f, 0.10350205f, 0.02464045f, 0.00519300f, 0.16086680f, 0.02946443f, -0.05885131f, 
    0.01187215f, -0.00702813f, 0.09970575f, -0.16728556f, -0.27451020f, 0.28273669f, -0.06704113f, -0.00380620f, 
    -0.06521189f, -0.24074888f, 0.10854132f, -0.06296759f, 0.07828368f, -0.14021407f, 0.00074405f, 0.03001658f, 
    0.05634836f, 0.16420092f, -0.00473440f, 0.01867479f, -0.02812261f, -0.06960684f, -0.21841677f, -0.00886056f, 
    0.24138507f, 0.11520660f, 0.25598258f, 0.12538531f, 0.01848593f, 0.10277996f, 0.01941987f, 0.21055514f, 
    0.05346291f, -0.01433191f, 0.17136116f, -0.07051040f, 0.18619870f, -0.02452532f, -0.09606513f, 0.20128290f, 
    0.01479653f, -0.22677204f, -0.05832163f, 0.07449157f, -0.08138815f, 0.06960101f, -0.15753536f, -0.03959201f, 
    0.01611440f, 0.20123500f, 0.19458337f, -0.11843122f, 0.08809422f, -0.06658006f, -0.08357549f, -0.07698280f, 
    0.06669588f, 0.26459932f, -0.26163977f, -0.10256241f, -0.10497946f, -0.16432568f, -0.08397011f, 0.07935592f, 
    0.09644946f, 0.21981990f, -0.25791284f, -0.12563807f, -0.18736492f, -0.01577551f, 0.21755344f, -0.09405345f, 
    -0.15575622f, -0.06527328f, 0.07690728f, -0.02736594f, 0.17538150f, 0.29005852f, 0.14894553f, 0.12240221f, 
    -0.03205088f, -0.04487161f, 0.03605115f, -0.16067041f, 0.17780618f, -0.04997703f, 0.19582796f, 0.12980378f, 
    0.11614437f, -0.12457756f, 0.08113442f, -0.00388442f, 0.13292080f, -0.26798600f, 0.28554761f, 0.21139625f, 
    -0.03645235f, 0.05659572f, -0.02458865f, -0.05281981f, 0.03237525f, -0.06758577f, -0.51569736f, -0.20096177f, 
    -0.04516051f, 0.01700731f, 0.07092161f, -0.06802513f, 0.00273392f, -0.08363934f, 0.12294161f, -0.25043765f, 
    0.05935875f, 0.01749696f, 0.07290746f, -0.02433344f, 0.07321172f, -0.06185594f, -0.07210708f, -0.04069651f, 
    -0.13770518f, 0.21356736f, 0.44378683f, 0.11774215f, 0.21216916f, -0.00503757f, -0.01352040f, -0.01536266f, 
    -0.15973318f, -0.06019361f, 0.19885534f, 0.22651885f, -0.02613284f, 0.07598966f, 0.01237398f, -0.12019944f, 
    0.06524034f, -0.00111144f, 0.15268838f, 0.01867358f, -0.10983317f, 0.05479218f, 0.08496761f, 0.05251777f, 
    0.01612881f, -0.07118405f, -0.06189149f, -0.52812344f, -0.05699564f, -0.03817044f, 0.11862441f, 0.06655225f, 
    -0.15063848f, 0.09608910f, 0.11743029f, 0.04730645f, -0.04421330f, 0.20549919f, -0.21418792f, -0.13310936f, 
    -0.00498572f, -0.06731416f, 0.09348755f, 0.00077580f, 0.23312788f, -0.02653488f, -0.30412498f, -0.29961583f, 
    -0.10464250f, -0.07040156f, 0.05476104f, 0.05110746f, 0.07747211f, 0.03599164f, -0.27186996f, 0.01267658f, 
    -0.01752208f, -0.14976816f, 0.07983745f, -0.04816642f, 0.05663251f, 0.10074585f, -0.18596046f, 0.25495133f, 
    0.09621029f, -0.04464974f, 0.23090953f, 0.12894395f, 0.07575782f, -0.01585833f, 0.10784745f, 0.08391020f, 
    -0.28476790f, 0.16983001f, -0.21459979f, 0.23914848f, -0.08906629f, -0.14243977f, -0.07457393f, 0.08453775f, 
    -0.03184361f, -0.24114773f, -0.16344583f, -0.30920887f, 0.07338981f, -0.11440233f, 0.14250480f, -0.00804552f, 
    -0.15749535f, -0.17849198f, -0.33193398f, 0.14213340f, 0.15781656f, 0.29248753f, -0.06155672f, 0.10359246f, 
    0.08105183f, -0.05631180f, 0.17476057f, 0.06527703f, -0.02975541f, 0.05881701f, -0.00576943f, -0.06815226f, 
    0.01670974f, -0.00376810f, 0.18896575f, 0.05466431f, -0.02417271f, 0.01165042f, -0.25705326f, 0.25042096f, 
    -0.05792863f, 0.06642065f, -0.13857174f, -0.05205505f, 0.05922124f, 0.07028016f, -0.02903620f, 0.34102249f, 
    -0.03041268f, -0.00238504f, 0.15011679f, -0.18578176f, 0.15663376f, -0.17894775f, -0.22254021f, -0.63514173f, 
    -0.30617008f, 0.05128626f, 0.06954984f, 0.10647319f, 0.11515445f, -0.13377224f, -0.11754696f, -0.03815416f, 
    -0.09227737f, -0.20364757f, -0.11130803f, 0.07097986f, -0.01155956f, -0.03352760f, -0.01890702f, -0.00873747f, 
    0.00349617f, 0.03847262f, 0.04605244f, -0.08457812f, -0.02398194f, 0.01336378f, -0.03519687f, -0.00086018f, 
    -0.03841327f, 0.01819995f, 0.02815147f, 0.07218794f, 0.03358482f, -0.08678794f, -0.00953353f, 0.01399840f, 
    -0.04789585f, 0.01335412f, -0.05382602f, 0.02229963f, -0.05614714f, 0.01392189f, -0.06757813f, 0.02975936f, 
    0.00471438f, 0.04196564f, -0.06646907f, -0.00571951f, -0.02097720f, 0.07587244f, 0.00256830f, -0.01124525f, 
    0.02327398f, 0.02397137f, -0.00126428f, -0.00616781f, -0.02303785f, -0.03780660f, -0.02612188f, -0.02990285f, 
    0.01729984f, -0.08051513f, 0.01816181f, 0.05519928f, -0.00624146f, -0.09977753f, -0.05741507f, 0.03427482f, 
    0.00532416f, -0.05505257f, 0.00947989f, 0.02612762f, 0.04362717f, -0.03427224f, -0.04759384f, -0.01772162f, 
    0.04267880f, -0.00305069f, -0.00562408f, -0.02589807f, -0.04549723f, 0.01491085f, 0.03271183f, -0.01067235f, 
    0.07256094f, 0.06852248f, 0.01526953f, 0.01239469f, 0.00053054f, 0.02359436f, 0.02624433f, -0.03782354f, 
    0.03388479f, -0.03887058f, -0.05601461f, 0.03195919f, -0.07369290f, 0.02348622f, -0.03600416f, 0.03418791f, 
    -0.04749585f, -0.00904438f, 0.03817667f, 0.05286190f, -0.05088592f, 0.06460758f, -0.01259765f, -0.04610261f, 
    0.04633553f, -0.08712170f, -0.07231548f, 0.03106258f, -0.06808724f, -0.00994535f, -0.04548045f, 0.00060523f, 
    0.02362625f, -0.03553948f, 0.01929477f, 0.06779382f, -0.05083179f, 0.04839167f, -0.08970430f, -0.01288507f, 
    -0.05191693f, 0.06633805f, -0.04888928f, -0.04918484f, 0.02741061f, -0.04046302f, -0.02789058f, -0.04619297f, 
    0.01814414f, -0.01833734f, -0.00482512f, -0.04039839f, 0.00311553f, 0.04083570f, 0.02147679f, -0.07049989f, 
    -0.03632458f, 0.00595073f, 0.01803839f, 0.05302963f, -0.05801518f, 0.02311190f, -0.00339197f, -0.02123758f, 
    -0.01490998f, -0.02720447f, -0.07308628f, 0.05409352f, 0.02348772f, -0.04706202f, -0.07148574f, 0.02574943f, 
    -0.02536637f, 0.02192578f, -0.07520434f, 0.05600933f, -0.06351875f, 0.06495677f, -0.00032623f, 0.03926580f, 
    -0.01522972f, 0.02483928f, 0.02108824f, -0.10186761f, 0.00156842f, -0.10122515f, 0.02158642f, 0.05458773f, 
    0.05296011f, 0.02943107f, -0.03029957f, -0.01672716f, -0.06418011f, -0.07770701f, -0.06968841f, 0.00201426f, 
    0.00928291f, 0.00228545f, -0.02413473f, 0.04386234f, -0.08703133f, 0.00637765f, -0.01493627f, -0.01536595f, 
    -0.00438094f, 0.04825514f, 0.02329560f, -0.02370409f, -0.03612829f, -0.05665987f, -0.08444256f, -0.00583784f, 
    -0.03585487f, 0.06107206f, 0.00176033f, 0.06004230f, -0.03030622f, 0.04921303f, 0.05127289f, -0.04199613f, 
    -0.01382942f, 0.04608796f, -0.03579754f, -0.05492945f, -0.03376791f, -0.04353333f, 0.07630125f, 0.02132287f, 
    -0.02113439f, -0.02032036f, -0.07317211f, 0.01748427f, -0.04094986f, -0.02040154f, 0.07117429f, -0.04455131f, 
    -0.01431535f, -0.06632370f, -0.03728976f, -0.06326163f, -0.04888657f, 0.04001911f, -0.05781128f, -0.01371976f, 
    -0.00053988f, -0.04557673f, 0.02730739f, -0.05719696f, -0.02010269f, -0.03084545f, -0.02436126f, -0.01106602f, 
    0.04407599f, -0.02092464f, -0.09384067f, -0.00839118f, 0.04959907f, 0.00089226f, -0.03168160f, -0.05584149f, 
    0.00508701f, -0.05381691f, -0.00286293f, 0.00249101f, -0.00728915f, 0.00853366f, 0.05205561f, 0.00882015f, 
    0.03598104f, 0.02520049f, 0.05612071f, 0.01357165f, -0.00738033f, -0.06638646f, 0.01751120f, 0.01197428f, 
    0.02147768f, -0.00357318f, -0.02873493f, 0.02289962f, 0.01120934f, -0.02211442f, 0.04696538f, 0.02981215f, 
    -0.03477237f, -0.06965095f, -0.04875175f, -0.06087301f, 0.00545550f, -0.01299234f, -0.05826792f, 0.00319689f, 
    -0.02419553f, -0.04036979f, -0.00630858f, 0.02362294f, -0.02296071f, 0.02230266f, -0.03359662f, -0.00216416f, 
    0.02970799f, -0.02280661f, -0.06618681f, -0.00566800f, -0.02273799f, 0.06445500f, 0.01374853f, 0.00918489f, 
    -0.04581677f, 0.02383193f, -0.01081980f, -0.04192909f, -0.01234234f, -0.01862163f, -0.00428931f, 0.00354552f, 
    0.03189393f, -0.06590482f, -0.07662053f, -0.00621381f, 0.00183121f, 0.01463457f, -0.06390339f, -0.02062769f, 
    0.26513141f, -0.07874766f, -0.18581925f, -0.09796897f, 0.00028014f, 0.18900447f, -0.09649280f, -0.06181476f, 
    0.11704607f, -0.44782916f, 0.22296564f, 0.13287441f, 0.13651711f, -0.07420766f, 0.09193580f, 0.08285745f, 
    0.20183563f, -0.06535112f, 0.23895800f, 0.07036708f, 0.27905786f, -0.26207763f, 0.03449949f, 0.07253040f, 
    -0.04390551f, 0.11471724f, -0.01415810f, 0.11965329f, 0.19033642f, 0.23105882f, -0.05563030f, 0.01625716f, 
    -0.00410142f, -0.12581165f, 0.00436281f, 0.05161453f, 0.07768457f, -0.08355349f, 0.10412803f, -0.09799145f, 
    0.09321381f, -0.03871572f, -0.00447222f, 0.03651509f, 0.02489650f, 0.13056400f, -0.25618342f, -0.08177974f, 
    -0.01970258f, -0.00610528f, -0.11508165f, 0.00704947f, -0.09796182f, 0.11379919f, 0.02258034f, 0.11415345f, 
    -0.24663326f, 0.32790363f, 0.14156803f, -0.02056330f, 0.11292107f, -0.23066843f, -0.14269416f, 0.07306976f, 
    0.12192827f, 0.01801652f, -0.09093586f, -0.07266229f, -0.09294837f, 0.10113874f, 0.16353431f, 0.03260139f, 
    -0.02108041f, 0.05089248f, -0.03290454f, -0.10629774f, -0.15350169f, -0.11428864f, -0.11549097f, 0.10974794f, 
    -0.11559018f, -0.02091449f, 0.16396762f, -0.32726938f, -0.18303843f, -0.00681954f, 0.13441311f, -0.02314689f, 
    0.09237172f, -0.16704980f, 0.30705693f, -0.20850198f, 0.39541602f, 0.14399199f, 0.12255894f, 0.24958241f, 
    -0.10426518f, -0.12020093f, -0.06168039f, -0.20686382f, 0.30074114f, 0.02568384f, 0.15527990f, 0.11925349f, 
    0.17355165f, -0.13582978f, -0.01177885f, 0.08613700f, 0.17855547f, -0.08619931f, -0.10903087f, 0.25771490f, 
    -0.01681080f, 0.00665343f, -0.00759703f, -0.01223151f, 0.03563243f, -0.15722243f, 0.13092811f, -0.03254696f, 
    0.03141497f, 0.06682862f, -0.03893279f, -0.08933905f, -0.02418570f, 0.03521307f, -0.33490950f, 0.15223953f, 
    0.21389382f, -0.08866983f, 0.01188473f, 0.01882565f, -0.05120703f, 0.05233275f, -0.03304952f, 0.08821192f, 
    -0.00718469f, -0.20947148f, -0.02938535f, 0.01591039f, 0.02376814f, 0.05674283f, -0.04259684f, 0.23966807f, 
    0.11038821f, -0.05500859f, -0.22594666f, 0.20569274f, 0.09752102f, 0.06029150f, -0.19594751f, -0.05815377f, 
    -0.04715696f, -0.03713980f, 0.16440734f, 0.21894665f, 0.09754499f, -0.08391713f, 0.08236065f, 0.07181186f, 
    0.01437756f, 0.07241776f, -0.05625938f, 0.05982974f, 0.39377952f, -0.23642138f, -0.01457080f, 0.04897453f, 
    0.12100001f, 0.01093974f, 0.11153936f, -0.29831704f, 0.00133122f, 0.06881431f, 0.25348678f, -0.23062404f, 
    0.26723298f, -0.11990353f, 0.01064473f, -0.00299538f, 0.25135529f, 0.05063894f, -0.35386267f, 0.05620495f, 
    -0.06689825f, 0.02165014f, -0.03823450f, -0.06919128f, 0.00136351f, 0.06943363f, -0.24528755f, -0.47868955f, 
    -0.02502138f, -0.04084381f, 0.27211875f, 0.10642326f, -0.12389410f, -0.05306822f, 0.13199584f, 0.24953966f, 
    0.29733306f, 0.02011608f, -0.07014886f, 0.21718757f, -0.03236780f, 0.09433623f, 0.13619675f, -0.10815617f, 
    0.05158869f, 0.04233701f, 0.21293908f, -0.13690475f, -0.24368189f, -0.00531545f, 0.06297239f, 0.10225956f, 
    -0.23635226f, -0.16088213f, 0.44276777f, -0.04872918f, -0.07264215f, -0.10779852f, 0.16323625f, 0.05131602f, 
    -0.10028424f, -0.06406467f, -0.08079699f, -0.09246085f, -0.02207637f, 0.11525857f, 0.01274325f, 0.12043866f, 
    -0.23587383f, -0.22236653f, 0.19534355f, -0.06664376f, 0.05564887f, -0.01849944f, 0.00000416f, 0.11644626f, 
    -0.04404411f, -0.14312324f, -0.17635545f, -0.00068092f, 0.16588779f, -0.03767347f, -0.04192101f, 0.07943861f, 
    -0.24437588f, -0.14250849f, -0.05865790f, 0.07486965f, 0.27646235f, -0.07288159f, 0.18822415f, -0.07205084f, 
    -0.05494868f, 0.36150274f, 0.15210004f, -0.01982477f, -0.09518562f, -0.01487406f, 0.11472519f, 0.08288436f, 
    -0.07684579f, 0.13484432f, -0.15082215f, -0.03871059f, -0.08168956f, -0.03897769f, -0.12169765f, -0.00455292f, 
    -0.05685721f, -0.01299776f, -0.06063179f, -0.04887177f, 0.21344921f, -0.03943421f, -0.09221135f, 0.12878376f, 
    -0.18092325f, -0.03988414f, -0.09421606f, -0.01524366f, 0.06786709f, 0.09502235f, -0.04765658f, 0.10735048f, 
    -0.05579035f, -0.02283318f, -0.03387842f, -0.00824894f, -0.05181525f, -0.01133528f, 0.02852676f, 0.04598938f, 
    -0.01333508f, -0.00034322f, -0.00812402f, 0.03477867f, -0.04537528f, -0.04493875f, 0.02277263f, -0.02000655f, 
    -0.02096548f, 0.04898591f, -0.01030505f, -0.06118166f, -0.03805067f, -0.06101541f, -0.00201683f, 0.00401188f, 
    -0.01321672f, -0.05099972f, -0.05254230f, -0.00803123f, -0.01884997f, 0.02140442f, -0.05993863f, 0.03088514f, 
    -0.05115747f, -0.05468087f, -0.00245328f, -0.06462525f, 0.01452436f, 0.00705060f, 0.00338414f, -0.01617200f, 
    -0.01057059f, -0.04132690f, 0.04238930f, -0.04924582f, -0.04669187f, -0.06238288f, -0.03657894f, 0.00829181f, 
    -0.02102947f, -0.01215885f, 0.01998332f, 0.03760418f, -0.03695566f, 0.02088954f, -0.02860791f, 0.02545953f, 
    -0.03849654f, 0.02038915f, -0.01632850f, -0.04904576f, -0.06020911f, 0.03675196f, -0.04975888f, -0.03483897f, 
    -0.02826842f, -0.05394556f, -0.01604344f, -0.01190521f, 0.03803343f, -0.01085378f, 0.04592051f, -0.03356411f, 
    0.02638930f, -0.06306014f, -0.01927121f, 0.02155809f, -0.04640316f, -0.03560453f, 0.02747265f, -0.05017132f, 
    -0.03355078f, 0.04485510f, 0.02252852f, 0.04263856f, -0.06242988f, 0.03484692f, 0.00092327f, -0.05877224f, 
    -0.04623474f, -0.02006649f, 0.02626895f, -0.01376846f, -0.03528516f, -0.02112146f, -0.06283083f, 0.04506622f, 
    0.00777721f, -0.04500313f, -0.00267492f, 0.02485604f, 0.03322682f, 0.03433937f, -0.04065116f, 0.00798228f, 
    0.02446434f, -0.04205114f, -0.03352477f, 0.04365830f, 0.03991615f, 0.01543381f, -0.01380585f, -0.03742453f, 
    0.04451500f, 0.02233562f, 0.03412923f, 0.00441201f, -0.03100851f, -0.03453520f, -0.01155381f, -0.04902317f, 
    -0.00023071f, -0.01718857f, 0.00538638f, -0.02549710f, -0.00983898f, -0.05233711f, -0.01333848f, -0.05547166f, 
    -0.01495076f, -0.00072340f, -0.00071296f, -0.00955330f, -0.05693121f, 0.02763496f, -0.06077524f, 0.03809762f, 
    0.01572410f, -0.02435736f, -0.01767646f, -0.05207709f, 0.00391167f, 0.00314363f, -0.02588491f, -0.00637818f, 
    -0.01379273f, -0.00812840f, 0.01752594f, 0.05113542f, -0.00932631f, -0.04961082f, 0.02425750f, -0.05986416f, 
    0.01116112f, 0.04055054f, -0.00971402f, 0.03360151f, 0.02783736f, -0.04485113f, 0.04139588f, 0.02148496f, 
    0.02781346f, 0.02717974f, 0.04706841f, -0.04266732f, -0.02138488f, -0.05063204f, 0.00563428f, -0.01590239f, 
    -0.05921460f, -0.04597594f, -0.01225607f, 0.04395396f, 0.03141334f, -0.05779120f, 0.01880161f, -0.01890873f, 
    -0.00250112f, 0.02012347f, 0.01893996f, -0.04783464f, -0.06477050f, -0.03224205f, 0.02141318f, -0.03976611f, 
    0.01347030f, 0.02088448f, -0.04862120f, -0.00886015f, -0.03337564f, -0.03067754f, 0.03091678f, -0.01802029f, 
    0.04449164f, -0.04376400f, -0.00468367f, -0.00491873f, 0.04295870f, 0.04953808f, 0.01610628f, 0.02039473f, 
    0.04034339f, 0.04681687f, -0.06355139f, 0.01918878f, 0.01875770f, 0.03459221f, -0.03024572f, -0.03157531f, 
    -0.01019346f, -0.02981584f, -0.06446536f, -0.05443951f, -0.00343877f, 0.03475042f, -0.00675883f, 0.01706929f, 
    -0.01874953f, 0.05081242f, 0.04322895f, -0.03131760f, -0.06617810f, -0.04756096f, -0.02065531f, 0.03920695f, 
    -0.03018223f, 0.03908516f, -0.01409734f, -0.01414379f, 0.02558424f, -0.02805828f, 0.00453333f, 0.01780812f, 
    0.02957373f, 0.02528243f, -0.01614915f, 0.02679595f, 0.02554153f, 0.02586032f, 0.01980183f, -0.03997930f, 
    -0.01054503f, 0.03958149f, -0.04084652f, 0.00158812f, 0.05101333f, 0.00797259f, -0.04314683f, -0.05022132f, 
    0.00168351f, -0.00941989f, -0.02973009f, -0.05566698f, -0.02184333f, -0.06504255f, 0.00785927f, 0.02922703f, 
    -0.00449086f, -0.03657231f, -0.06403240f, 0.04238882f, -0.02944286f, -0.02778245f, 0.00288666f, 0.04789988f, 
    0.02078058f, 0.03284974f, 0.04595666f, -0.02210616f, -0.03285701f, 0.03150498f, 0.02294064f, -0.06392016f, 
    -0.03001134f, 0.00230418f, 0.04821740f, 0.01772306f, -0.00724838f, 0.00001116f, 0.04088739f, 0.04519248f, 
    0.02881846f, -0.01388398f, 0.04121634f, -0.03464390f, -0.05017990f, -0.03408776f, 0.04555605f, -0.04113264f, 
    -0.02163290f, 0.00786715f, -0.00423729f, 0.01740693f, -0.04913283f, -0.00059510f, -0.05614272f, -0.03972091f, 
    -0.00808375f, 0.03355733f, -0.05864654f, -0.05643787f, 0.04079584f, -0.03495339f, -0.04850243f, -0.00854626f, 
    -0.05240780f, 0.00831479f, 0.05771572f, 0.00937753f, -0.04002146f, 0.05381168f, -0.05159748f, -0.02724184f, 
    -0.04692068f, 0.03962831f, 0.02354341f, -0.03741323f, -0.03423832f, 0.04935947f, -0.01535591f, -0.00223868f, 
    -0.03858727f, 0.01572269f, -0.04933350f, 0.04351334f, 0.02366129f, -0.03300856f, -0.04526863f, 0.03135054f, 
    0.05263551f, -0.05264776f, 0.01722508f, -0.04748147f, 0.03598651f, 0.01606659f, 0.02724402f, -0.00480954f, 
    -0.03444833f, 0.04061599f, -0.00535095f, -0.01359259f, -0.01637295f, -0.04341371f, 0.04649181f, -0.02580393f, 
    -0.03336036f, 0.02711817f, 0.01812888f, -0.03674694f, 0.03849450f, -0.04542845f, -0.00072540f, -0.01670205f, 
    0.00599671f, -0.00590713f, 0.04990451f, -0.03034468f, 0.05006372f, 0.02436201f, 0.05235639f, -0.05424566f, 
    -0.01700048f, -0.03943136f, -0.05864791f, -0.03149915f, 0.00451342f, 0.01531918f, -0.00276380f, -0.02879006f, 
    0.02247370f, -0.00369809f, -0.04929904f, 0.03131564f, 0.02204479f, 0.01250192f, 0.04584033f, -0.01454147f, 
    -0.00957053f, 0.01304573f, 0.02495459f, -0.01269394f, 0.01457748f, -0.03883474f, -0.01103755f, -0.02438126f, 
    -0.04000138f, 0.03814541f, -0.01397947f, 0.03394603f, 0.02704389f, 0.00847566f, -0.00636028f, 0.01210946f, 
    -0.00279077f, -0.02308980f, -0.05479857f, 0.01825321f, -0.06374994f, -0.02112245f, 0.02712458f, 0.06060193f, 
    -0.00271876f, 0.03467679f, -0.03953379f, -0.01587164f, -0.02888966f, 0.02611373f, 0.03955862f, -0.03224722f, 
    -0.05288123f, -0.02024054f, 0.02818811f, -0.05314817f, 0.00799027f, 0.05228231f, -0.00189620f, 0.03786293f, 
    0.02375314f, 0.02720422f, 0.00836535f, 0.03014296f, -0.00900965f, -0.03384739f, 0.00829161f, -0.03814599f, 
    -0.03375082f, 0.04953502f, 0.06190315f, -0.01464380f, -0.03215304f, -0.01612179f, -0.03393110f, 0.00634742f, 
    -0.06275284f, 0.02653317f, 0.01443455f, 0.02118941f, -0.00740321f, 0.03434724f, -0.01041849f, -0.03605047f, 
    -0.05805753f, -0.02091426f, 0.00672189f, 0.05158269f, -0.05073427f, 0.02480277f, -0.03039514f, -0.04372873f, 
    -0.02411738f, 0.01765071f, 0.00029445f, 0.04273397f, 0.00410598f, -0.01853331f, -0.04936756f, -0.01128333f, 
    -0.00639427f, -0.02059349f, 0.04439602f, -0.00026964f, -0.04600830f, -0.04395731f, -0.06369841f, -0.00593179f, 
    0.06033293f, -0.02593176f, -0.03468468f, -0.01669928f, 0.03615503f, -0.05825766f, -0.05056455f, -0.03617980f, 
    -0.04140960f, -0.02385339f, -0.05693112f, 0.02080465f, -0.04593373f, -0.03291123f, -0.04729847f, 0.04064614f, 
    -0.04868829f, 0.04298513f, 0.02659800f, 0.01681135f, 0.00418979f, 0.00540174f, 0.03860687f, -0.03450183f, 
    0.02759050f, 0.04974738f, -0.01019509f, 0.03116891f, 0.03808927f, -0.03933692f, -0.01311950f, 0.05677890f, 
    -0.00690199f, -0.02650621f, 0.04522480f, -0.03388903f, -0.01877552f, -0.05236911f, 0.01017042f, 0.01889602f, 
    -0.01217267f, -0.05773110f, -0.03698553f, 0.04897804f, 0.05993887f, -0.04912071f, 0.03882388f, 0.02586544f, 
    -0.02440371f, 0.04256716f, -0.02703811f, -0.01296281f, -0.04865550f, -0.04566582f, 0.00773519f, -0.01011513f, 
    0.01903915f, 0.01460844f, -0.02790459f, 0.03064374f, -0.05948916f, 0.01153654f, -0.05271038f, -0.00729639f, 
    0.05235873f, 0.03027689f, 0.04595994f, 0.01978606f, 0.03684480f, -0.03535350f, -0.05896964f, -0.01713455f, 
    -0.04487795f, 0.01562414f, -0.06296887f, 0.00879530f, -0.04743226f, 0.04881464f, -0.03217951f, -0.00724741f, 
    -0.04217933f, -0.03908557f, -0.01157130f, 0.04144289f, -0.00723347f, -0.03420110f, -0.01947760f, -0.01831343f, 
    0.01770286f, -0.03497643f, -0.03612013f, 0.03790063f, 0.02113119f, -0.02871256f, -0.03529949f, 0.01320703f, 
    -0.04151304f, 0.04540300f, -0.04912559f, -0.01818046f, -0.04859997f, 0.01660757f, -0.00934417f, -0.00848768f, 
    -0.04100734f, -0.00485028f, -0.05176133f, -0.04734103f, 0.00257253f, -0.01145636f, 0.02502701f, -0.01099895f, 
    0.00433350f, 0.03379195f, -0.04309365f, 0.00406918f, -0.03441175f, -0.05010127f, -0.02073189f, 0.02500008f, 
    -0.05498790f, 0.05002651f, 0.01602065f, -0.02574167f, -0.02965938f, -0.03566967f, 0.02116586f, -0.02957831f, 
    -0.05197163f, -0.06121070f, -0.04419682f, -0.05462274f, 0.03944262f, -0.04256193f, -0.06164257f, 0.01954503f, 
    -0.05675723f, -0.00411433f, 0.02675640f, 0.03925696f, -0.01942905f, 0.01419295f, 0.03076797f, 0.00404517f, 
    -0.02099868f, -0.04656357f, 0.04113331f, 0.03655399f, 0.00542367f, 0.00942733f, -0.00646779f, 0.00239736f, 
    -0.00544675f, 0.02933485f, -0.00310776f, -0.05047409f, 0.01151852f, -0.03277528f, 0.03378535f, -0.01758220f, 
    0.04332308f, 0.01458151f, -0.02589025f, 0.05130721f, -0.02494752f, -0.04231051f, -0.00847826f, 0.04958929f, 
    -0.01177888f, 0.00592386f, -0.03933425f, -0.04922789f, 0.00461343f, 0.01266177f, -0.04299500f, -0.03338411f, 
    -0.01031126f, -0.02839787f, -0.04298359f, -0.03946511f, -0.04302903f, 0.00347301f, -0.05600386f, -0.00460831f, 
    -0.02166977f, 0.04546040f, -0.04520448f, -0.02467134f, -0.03545872f, -0.02265282f, -0.04756310f, 0.03861966f, 
    0.04380033f, -0.03491828f, 0.01842567f, 0.05454234f, 0.02097635f, 0.04693360f, 0.00924532f, -0.05909621f, 
    0.04446383f, -0.03031792f, 0.01735687f, -0.03501659f, 0.00946553f, -0.05771897f, 0.01652725f, -0.00378800f, 
    -0.04559081f, -0.05980910f, 0.04676097f, 0.03895072f, -0.00018891f, 0.05086615f, -0.03678887f, -0.06308156f, 
    -0.05927165f, 0.05018943f, 0.01494117f, 0.02957424f, -0.04066962f, -0.01542896f, 0.04084333f, -0.00409407f, 
    0.03513717f, -0.00897601f, -0.03836901f, -0.01537561f, 0.04949714f, 0.00453602f, -0.03228134f, -0.00123446f, 
    -0.03430500f, 0.01704524f, 0.02082047f, 0.01022603f, -0.01390749f, -0.03540787f, -0.06352109f, -0.00385299f, 
    -0.05460595f, 0.02525068f, 0.00416252f, 0.03526611f, -0.02738903f, -0.04066051f, -0.01048705f, 0.02049891f, 
    -0.02580956f, -0.04605453f, -0.04316776f, -0.00244620f, 0.04453512f, 0.04353043f, 0.03669402f, -0.04832367f, 
    0.04277654f, 0.00898404f, -0.04078140f, 0.03374304f, 0.02176839f, -0.02149464f, -0.01349691f, -0.02606123f, 
    -0.04829587f, 0.00242040f, -0.04846287f, 0.00825881f, -0.05550845f, 0.04649784f, 0.00077736f, 0.05316294f, 
    -0.05000648f, -0.02417216f, 0.00727529f, -0.01074278f, -0.04016273f, -0.03505837f, 0.04355951f, -0.04259827f, 
    -0.02757363f, 0.03975647f, -0.05792259f, -0.06289472f, 0.01183714f, 0.05391034f, -0.04775624f, -0.00231169f, 
    0.03572266f, -0.00626065f, -0.00761599f, -0.02597095f, -0.00642894f, -0.00961138f, 0.04695046f, -0.04222990f, 
    -0.02307143f, 0.00371082f, 0.02912143f, 0.01681241f, -0.03092747f, 0.04428139f, -0.05980180f, 0.00152010f, 
    -0.01801597f, -0.01537278f, -0.03619392f, -0.03530019f, -0.03948492f, -0.04486710f, -0.01576173f, 0.03861164f, 
    0.03409975f, -0.02208158f, 0.01829626f, 0.01165787f, -0.02499875f, -0.05897618f, 0.03026699f, 0.00593753f, 
    0.03159943f, -0.03957098f, -0.00401694f, -0.02030694f, 0.03788039f, -0.04929449f, 0.05343938f, -0.00122721f, 
    -0.00867667f, -0.04910421f, 0.03704013f, 0.00688381f, -0.00642300f, 0.01430813f, 0.01111380f, 0.01007412f, 
    0.04544995f, -0.04043851f, -0.05418028f, -0.02290884f, -0.02411271f, -0.00880104f, 0.00603431f, 0.04841832f, 
    -0.02790965f, -0.03778855f, -0.02901537f, -0.01710490f, 0.05086208f, -0.04300036f, 0.04101065f, -0.00745579f, 
    -0.04151351f, -0.05345429f, 0.01485055f, -0.03554647f, 0.00946496f, -0.04280390f, 0.04225438f, 0.01664791f, 
    -0.01715635f, -0.04862249f, -0.04540308f, 0.02272989f, 0.00098224f, 0.04585530f, 0.00007723f, -0.04052047f, 
    0.03611129f, -0.00941038f, -0.04164128f, 0.03003307f, -0.04323407f, 0.00195859f, 0.00437211f, -0.01775875f, 
    0.04845534f, 0.04707408f, -0.00148859f, -0.05714156f, 0.04951862f, -0.06453889f, 0.02868386f, -0.04443905f, 
    0.02376254f, 0.01351648f, -0.04923863f, 0.05568708f, 0.03457709f, 0.00982367f, -0.00168335f, -0.00207866f, 
    -0.01619063f, -0.05334600f, 0.04527823f, -0.04115149f, 0.02499705f, -0.05270877f, -0.03731233f, 0.03917355f, 
    0.14627449f, 0.12781712f, 0.25881413f, 0.01472096f, 0.17123926f, 0.05597721f, 0.16124529f, 0.08975314f, 
    0.04382944f, 0.01895963f, -0.09046291f, -0.30337220f, -0.10773702f, -0.15124376f, -0.07333552f, 0.08408600f, 
    -0.00711411f, 0.12579341f, -0.32926291f, 0.20498820f, 0.27838057f, 0.04622639f, 0.10661518f, 0.01215446f, 
    -0.02884655f, 0.04315160f, -0.12254617f, -0.35700977f, 0.12691548f, -0.61848754f, -0.06343545f, -0.06920991f, 
    -0.09021704f, 0.15155140f, -0.11414707f, 0.12462451f, 0.13911982f, 0.05687569f, -0.02460289f, 0.05191077f, 
    0.00170438f, -0.00914172f, 0.06245867f, 0.15115702f, 0.13812749f, -0.21954070f, 0.36858428f, 0.14118025f, 
    0.00979802f, 0.13363270f, -0.07501621f, 0.03100762f, -0.11098850f, 0.04646732f, 0.13205300f, -0.10262628f, 
    -0.04426568f, 0.05926860f, 0.15772827f, -0.00790778f, 0.02113848f, 0.06716347f, -0.16049170f, 0.26238772f, 
    0.26178771f, 0.15459511f, -0.00284347f, -0.02128720f, -0.02895699f, 0.11765437f, 0.05638186f, -0.06743709f, 
    0.23466136f, 0.02724005f, -0.30613860f, 0.11069790f, 0.06096094f, -0.01596702f, -0.07828453f, -0.12667367f, 
    0.02632978f, 0.12736043f, 0.22465305f, 0.13099988f, 0.07682381f, -0.05978398f, -0.11019411f, -0.06590703f, 
    0.09606814f, 0.12550412f, -0.07426502f, -0.32949033f, 0.40285876f, -0.06808721f, 0.09531924f, -0.09393726f, 
    -0.09556240f, 0.11811069f, 0.22502469f, -0.14141199f, 0.06351452f, 0.02175304f, 0.16311741f, 0.14223793f, 
    0.03948071f, 0.17449978f, -0.07634570f, -0.14304104f, -0.13325508f, -0.21702540f, -0.55407494f, 0.03353109f, 
    -0.11620390f, 0.02449643f, 0.00458329f, 0.00558582f, 0.28395694f, 0.07106709f, 0.28761855f, -0.00481999f, 
    0.00364190f, 0.01281967f, -0.20533691f, 0.00251991f, -0.02610749f, -0.03946242f, -0.37352020f, -0.19660872f, 
    0.19752944f, 0.01816820f, -0.12770836f, 0.00839527f, 0.09250401f, 0.08128248f, -0.20932186f, 0.25073400f, 
    -0.16178748f, 0.07259014f, -0.02137817f, -0.17409588f, 0.17128913f, 0.11217980f, -0.15782396f, 0.10439213f, 
    -0.27218363f, 0.00993623f, -0.04370605f, 0.38654265f, -0.08941818f, 0.01098956f, -0.05909969f, -0.02338790f, 
    -0.04197748f, 0.30032891f, 0.12293588f, -0.17111441f, 0.06853165f, 0.02720445f, -0.04556191f, -0.06069615f, 
    -0.09284507f, 0.06261297f, -0.17390083f, -0.13750212f, 0.20368943f, -0.19949311f, -0.11354943f, -0.02849990f, 
    0.01739174f, 0.01282560f, -0.04192042f, -0.25736380f, -0.23455425f, 0.56803155f, -0.02859434f, 0.05308434f, 
    0.24173705f, 0.01958071f, 0.06135882f, -0.12020639f, 0.19004485f, -0.15305467f, -0.31226188f, -0.07948982f, 
    -0.04256372f, 0.03197566f, -0.04077005f, -0.13758051f, 0.06076739f, 0.18203917f, -0.08993408f, -0.00478865f, 
    -0.21714953f, -0.25941023f, 0.15787883f, 0.02490150f, -0.16056004f, 0.24743207f, 0.11133444f, -0.00191208f, 
    -0.11122236f, 0.31139296f, 0.11212369f, -0.00699977f, 0.26689762f, 0.02942471f, -0.03295024f, -0.44804251f, 
    -0.19234070f, -0.19120112f, 0.11651953f, 0.16964382f, 0.10550806f, -0.03194461f, -0.06209052f, -0.01886890f, 
    -0.11212782f, -0.06385712f, -0.01878173f, -0.06517670f, -0.00992346f, 0.13610826f, -0.19722585f, 0.01688206f, 
    -0.03038872f, 0.11591277f, 0.09209096f, -0.01776319f, -0.18523560f, 0.02237830f, -0.05627569f, -0.19742125f, 
    0.09125755f, 0.09592061f, 0.34744149f, 0.19298390f, 0.13602392f, 0.16664149f, -0.00068185f, -0.00166546f, 
    -0.00210525f, 0.04451236f, 0.09270862f, 0.12935376f, 0.21678823f, -0.31807318f, 0.23310743f, -0.07514295f, 
    0.05809269f, 0.06997735f, 0.12248944f, -0.15138803f, -0.30592835f, 0.02205110f, -0.11829887f, 0.08750349f, 
    -0.04540998f, 0.05504693f, 0.06007941f, -0.22986829f, 0.02225213f, -0.26920345f, 0.00454976f, -0.49968010f, 
    0.20016025f, -0.07417963f, -0.10266493f, 0.09549144f, 0.21403977f, -0.02017654f, 0.02752779f, -0.32216141f, 
    0.07576728f, -0.16797462f, -0.28211638f, 0.15162745f, -0.15218946f, -0.04739155f, 0.06373919f, 0.03948157f, 
    -0.08354276f, 0.31307882f, -0.12798408f, -0.09574211f, 0.05511630f, -0.12720093f, -0.04806389f, 0.32660961f, 
    -0.11114253f, -0.04669155f, 0.13941345f, 0.01911486f, 0.02518326f, 0.01771271f, 0.00163611f, -0.00779145f, 
    -0.21585755f, 0.25827909f, -0.16394718f, -0.08196596f, 0.03621183f, -0.16513859f, 0.05743501f, -0.06041383f, 
    0.03796102f, 0.10626519f, -0.08122937f, -0.08767993f, 0.03160798f, -0.20778218f, -0.03942287f, -0.11005403f, 
    0.09311996f, 0.14672039f, 0.00944712f, 0.34985295f, -0.19885588f, -0.12891063f, -0.07032719f, 0.06803486f, 
    0.02773398f, -0.10990984f, -0.03409187f, 0.09968819f, 0.13090709f, -0.09097706f, -0.06857397f, -0.07166604f, 
    -0.04639326f, 0.09787884f, -0.10113044f, 0.14575613f, -0.11325391f, -0.10088363f, 0.11254802f, -0.03064775f, 
    0.15475951f, 0.11064089f, -0.12877376f, 0.00735096f, 0.03868702f, 0.02679083f, -0.23761867f, -0.22870520f, 
    0.23288476f, 0.33299744f, 0.03207149f, -0.01843252f, -0.01386222f, 0.07913318f, -0.01196938f, 0.15892568f, 
    0.10393552f, 0.09103464f, -0.05699719f, -0.00940980f, 0.07463227f, 0.01767144f, 0.05739221f, 0.19913951f, 
    0.10834093f, 0.08009047f, 0.14441185f, 0.30645421f, 0.07781409f, -0.01001800f, -0.02375711f, 0.07867146f, 
    0.07342090f, 0.17118292f, 0.07849984f, 0.20490517f, -0.05662223f, -0.09112503f, 0.07439525f, -0.02750533f, 
    0.03505900f, -0.02486753f, -0.14746279f, -0.23862292f, -0.06642903f, -0.18633378f, -0.17466855f, -0.04617964f, 
    -0.04029041f, 0.09343553f, 0.13154395f, -0.48568064f, 0.01045769f, 0.16184637f, 0.16615620f, 0.14630508f, 
    0.03143341f, 0.08527479f, 0.03935077f, -0.19154054f, 0.32954359f, -0.04701136f, 0.12820052f, 0.07709437f, 
    0.10584481f, -0.12768899f, -0.20656931f, -0.12700582f, -0.01038308f, -0.38914001f, -0.02974800f, 0.01225800f, 
    -0.02344064f, -0.07746667f, 0.02782710f, -0.07707614f, -0.01111169f, 0.00391297f, 0.12285255f, 0.04657008f, 
    -0.08898695f, -0.19151932f, -0.15536837f, 0.07606217f, 0.03923164f, 0.11015596f, -0.03193196f, -0.14582460f, 
    -0.34501466f, 0.03726618f, 0.00090209f, 0.03069918f, 0.07380798f, 0.22002216f, 0.06961428f, -0.08965537f, 
    -0.24095088f, 0.11481757f, -0.01967616f, -0.01188312f, 0.01616547f, 0.01267111f, -0.00407643f, -0.17030185f, 
    -0.09234497f, -0.42959005f, -0.06481095f, -0.07807380f, 0.15186553f, 0.05770881f, 0.09984932f, -0.03759610f, 
    0.02873285f, 0.01711188f, 0.19445033f, -0.01328844f, -0.10214785f, -0.37196764f, 0.05292470f, -0.03640281f, 
    -0.04444982f, -0.02293930f, -0.03256746f, -0.11292788f, 0.01189233f, -0.14751808f, -0.39970258f, -0.09812755f, 
    -0.06757035f, -0.03905599f, -0.06969912f, 0.06305040f, -0.27256468f, 0.10615396f, 0.18235320f, 0.05632876f, 
    0.15410000f, 0.01299428f, 0.20429821f, -0.21852799f, 0.16036370f, 0.10725274f, 0.04549040f, -0.31239855f, 
    -0.15286462f, -0.22203374f, 0.14872836f, 0.15557027f, -0.19228378f, 0.07603002f, -0.17567731f, -0.12889625f, 
    -0.12031279f, -0.01169434f, 0.05981272f, -0.04093684f, -0.00418434f, 0.11830536f, -0.20013261f, 0.31548810f, 
    0.02080967f, -0.01672821f, 0.13759588f, -0.03127862f, -0.16011180f, 0.11985060f, -0.03017128f, 0.11037683f, 
    -0.01996739f, -0.00327521f, -0.09941549f, 0.09495219f, -0.23098283f, 0.00425338f, -0.07442798f, 0.03692367f, 
    -0.00717413f, 0.03856317f, 0.10767275f, -0.00054356f, -0.18307899f, -0.04315136f, 0.02370330f, -0.20373707f, 
    0.08360903f, -0.00735640f, -0.52766830f, -0.37261778f, -0.36696309f, 0.14951798f, -0.06231993f, 0.08859409f, 
    -0.10444523f, -0.06821858f, 0.07516990f, 0.38921672f, 0.29982901f, -0.01483832f, 0.19859405f, -0.09890980f, 
    -0.10243800f, 0.09433146f, 0.07985462f, 0.09715270f, 0.23361719f, 0.05314179f, 0.16262054f, 0.21797346f, 
    -0.09017768f, 0.09246219f, 0.19215003f, 0.12034195f, 0.03308257f, -0.10008530f, 0.12695822f, 0.15726663f, 
    0.15018210f, 0.27660042f, 0.00383126f, 0.05317828f, 0.06721973f, -0.01442197f, 0.17307959f, -0.00189571f, 
    -0.10323965f, 0.03441809f, -0.00542236f, 0.11533859f, 0.00996961f, -0.05988514f, 0.02637558f, 0.33955109f, 
    0.05461178f, -0.09332478f, -0.05694192f, -0.15788619f, -0.07076950f, 0.08480243f, -0.05894881f, -0.03487688f, 
    -0.04704056f, -0.00147597f, 0.05210463f, 0.02952080f, -0.05791840f, -0.03068234f, -0.05042857f, -0.02541484f, 
    0.02888098f, -0.00724150f, -0.01235265f, -0.06811713f, -0.00686524f, 0.01901135f, -0.04960458f, 0.05208386f, 
    0.00115742f, 0.04632648f, 0.00726494f, 0.02985632f, -0.05559413f, -0.04425922f, 0.02363471f, -0.02540863f, 
    -0.02948763f, -0.01154409f, -0.03400155f, -0.02313909f, 0.00623151f, 0.04152860f, -0.05858986f, 0.02350810f, 
    -0.00864653f, -0.02797240f, 0.03283320f, 0.00597124f, -0.04498914f, 0.04253411f, 0.01719525f, 0.00805571f, 
    -0.04724465f, -0.06476315f, -0.00053754f, 0.04126407f, -0.01192944f, 0.01105362f, 0.04830990f, 0.00293754f, 
    0.00983884f, 0.04648587f, -0.04386820f, -0.04925149f, -0.04972960f, -0.04756024f, -0.03569139f, 0.02170509f, 
    -0.03827025f, -0.03376266f, -0.05439227f, 0.05875524f, -0.07290176f, -0.04918785f, -0.04211382f, -0.03965578f, 
    -0.03236552f, -0.01475595f, -0.00369534f, 0.03259629f, -0.02130527f, 0.02376361f, 0.02086766f, 0.00592700f, 
    -0.00395320f, 0.02256554f, 0.05878422f, 0.03106589f, -0.05910760f, -0.05829060f, 0.04593924f, 0.02485001f, 
    0.01146039f, 0.00100334f, -0.05325579f, -0.01880574f, -0.04775316f, 0.04970872f, -0.00429117f, -0.06583975f, 
    0.05644475f, 0.03836507f, 0.05758117f, -0.04310453f, 0.01369186f, -0.05248226f, -0.05017301f, -0.04141152f, 
    0.00306043f, -0.02935518f, -0.04070496f, 0.01265288f, 0.03201328f, -0.03350642f, -0.05893077f, 0.04483641f, 
    -0.02926619f, -0.03802197f, -0.02291173f, 0.02545640f, -0.04700385f, 0.04977985f, 0.00851624f, 0.04698649f, 
    -0.04959804f, -0.02839814f, -0.03676926f, 0.04111409f, -0.06649610f, 0.01623744f, 0.02799425f, 0.05881571f, 
    0.00039317f, 0.00646486f, -0.06215550f, 0.01324871f, -0.04595695f, 0.00018444f, -0.03606787f, 0.03633988f, 
    -0.02710565f, 0.01671178f, 0.04516742f, 0.01279377f, -0.02693426f, 0.04800890f, 0.00163586f, -0.04980811f, 
    0.00301102f, 0.02442728f, -0.00678605f, 0.02837181f, -0.04161036f, 0.03934053f, -0.01082950f, -0.02569367f, 
    0.01938180f, 0.03875981f, -0.03026905f, -0.03700440f, -0.00069701f, -0.00331898f, 0.00286878f, -0.02646680f, 
    -0.06017256f, -0.02562444f, 0.03851109f, 0.01442265f, 0.00765478f, 0.05522542f, -0.04237036f, 0.04793597f, 
    0.04082820f, -0.06868763f, -0.05436697f, -0.00245831f, -0.03401761f, -0.03744556f, 0.02252574f, -0.03132058f, 
    -0.03374074f, -0.04852749f, -0.05293208f, 0.03708427f, -0.03682566f, -0.03373091f, -0.01394082f, -0.05274791f, 
    -0.01808670f, -0.01417264f, 0.04888895f, -0.01324452f, 0.02252375f, 0.02690779f, 0.04197884f, -0.06212153f, 
    0.02133529f, -0.01675715f, -0.04957888f, -0.03830751f, 0.00659422f, 0.04012121f, 0.06916060f, 0.04039600f, 
    0.05515667f, -0.04811486f, -0.05420358f, -0.05609913f, -0.03959940f, 0.05029589f, -0.05579204f, -0.02109825f, 
    0.04706820f, -0.05860280f, -0.04044009f, 0.02110684f, -0.01503251f, -0.03238223f, -0.02372588f, -0.05822834f, 
    0.00816873f, 0.02286710f, -0.00890295f, -0.05938469f, 0.00913162f, -0.00025401f, -0.01124860f, 0.03941498f, 
    0.01104772f, 0.00582165f, -0.04504433f, -0.06044346f, -0.04611292f, -0.01896314f, -0.02237379f, 0.04526722f, 
    -0.02991187f, -0.02178720f, -0.04299984f, -0.00319253f, -0.04719147f, -0.02753811f, 0.00833305f, -0.00206738f, 
    0.02197218f, -0.06043060f, 0.05290474f, -0.01101168f, 0.04866257f, -0.01135608f, -0.02025850f, 0.04220767f, 
    -0.05375820f, -0.00952163f, 0.01662525f, 0.03825561f, -0.03026777f, 0.01148295f, 0.04506641f, 0.00005830f, 
    0.04802619f, 0.04283826f, -0.01371320f, -0.01461503f, 0.03991336f, 0.03134594f, -0.00025848f, -0.03799727f, 
    -0.04527677f, 0.01354403f, 0.01549751f, -0.01460223f, 0.00821113f, 0.04548096f, -0.02357647f, 0.04253100f, 
    -0.03242600f, -0.01993543f, 0.01883404f, -0.05221973f, 0.03034486f, 0.00042699f, 0.02383795f, 0.00540245f, 
    -0.03526694f, -0.04129367f, 0.02749915f, -0.01993370f, 0.05807436f, -0.02812299f, -0.00496038f, -0.00552242f, 
    -0.01168690f, -0.04497375f, -0.04139853f, -0.04143209f, 0.02145863f, 0.02119536f, 0.03209720f, -0.00688790f, 
    0.22696243f, -0.14417775f, -0.07623260f, 0.07225543f, 0.00863241f, -0.01702841f, -0.10816687f, 0.04259882f, 
    -0.23486567f, -0.07049044f, -0.52591544f, -0.02229276f, -0.13165091f, -0.03026526f, 0.02891617f, -0.07991378f, 
    0.02840849f, 0.10103631f, -0.09552184f, 0.02454490f, -0.20748514f, 0.01878492f, 0.06926950f, 0.02583737f, 
    0.12445830f, -0.05727680f, 0.11711100f, -0.08656354f, -0.02414281f, -0.03176428f, 0.00982013f, 0.00670692f, 
    -0.17071061f, 0.00295047f, 0.09625618f, 0.11283205f, 0.07593185f, -0.00482744f, -0.00034676f, 0.08743824f, 
    -0.04994820f, -0.05415707f, 0.00762079f, -0.03316761f, -0.25647968f, -0.31184128f, 0.22172576f, -0.19837984f, 
    0.09549005f, 0.08883398f, -0.01370569f, -0.01767736f, -0.09809276f, 0.05051434f, 0.23067780f, -0.07195535f, 
    0.12832971f, -0.32399204f, -0.12832168f, 0.05439794f, 0.14258114f, -0.07288630f, -0.10937427f, 0.17983876f, 
    0.04113676f, -0.17518066f, 0.12055651f, 0.06996165f, 0.05963935f, -0.04194960f, 0.10264358f, -0.03455527f, 
    0.16824038f, -0.02386058f, -0.05184750f, 0.13730292f, 0.06709384f, 0.04842655f, -0.14353532f, 0.10423828f, 
    0.07419632f, -0.36873898f, -0.14863339f, -0.19022146f, -0.09994555f, 0.03588990f, 0.07051554f, 0.20686062f, 
    0.06220440f, -0.00822200f, 0.06202081f, 0.13158345f, -0.32037303f, -0.00314678f, 0.09663087f, 0.09500787f, 
    -0.01589589f, 0.10835365f, 0.21280877f, 0.23015939f, 0.23855104f, 0.03240574f, -0.14732069f, -0.02653315f, 
    -0.06256079f, 0.06452616f, 0.05377193f, 0.06168839f, 0.09252678f, 0.08099046f, 0.03646406f, -0.09903474f, 
    -0.04603511f, -0.03827566f, 0.03471988f, 0.03666227f, 0.07306098f, 0.22879492f, 0.04375466f, 0.10066152f, 
    -0.12663284f, -0.01643000f, -0.11368141f, 0.03858372f, 0.02951299f, 0.09479724f, 0.22852245f, 0.09598110f, 
    -0.09577959f, 0.10343134f, 0.03444532f, 0.09018848f, 0.03995036f, -0.19088943f, 0.03063115f, -0.20381413f, 
    -0.00893619f, 0.18120253f, -0.22374107f, -0.05410116f, -0.11837081f, -0.13488573f, -0.05549365f, -0.06974219f, 
    0.19695400f, 0.11573916f, 0.04604075f, -0.50905687f, 0.09593948f, -0.15473180f, 0.10838723f, -0.06784528f, 
    -0.16464914f, 0.51224262f, 0.20161137f, -0.06128678f, 0.00996187f, -0.07087521f, 0.19102369f, 0.07725368f, 
    -0.07086710f, 0.00936796f, 0.07943133f, 0.05787537f, -0.09431703f, 0.12318294f, -0.06686139f, 0.12271117f, 
    0.06924475f, -0.11942626f, -0.12107316f, -0.02733472f, 0.00911696f, 0.03959624f, 0.13366327f, 0.11068030f, 
    -0.04457063f, -0.13121612f, -0.00301769f, 0.02338798f, 0.08167040f, 0.26271415f, -0.02568460f, 0.05319501f, 
    -0.09099359f, 0.04937967f, -0.05336859f, 0.12702821f, -0.01386628f, -0.46820936f, -0.00155597f, 0.25470135f, 
    0.17360963f, 0.01532154f, -0.27085948f, -0.18828905f, -0.11092368f, 0.00331372f, -0.01988500f, 0.10446046f, 
    -0.06660514f, 0.19979760f, 0.01644769f, -0.06401641f, 0.00088456f, 0.09787330f, -0.07687155f, -0.07579324f, 
    -0.16986533f, -0.26435477f, 0.19408152f, 0.05671622f, 0.15735310f, -0.00668785f, -0.04072759f, 0.04782516f, 
    0.12770109f, -0.19816150f, -0.29721558f, 0.08047302f, 0.18991190f, 0.06616982f, 0.15487432f, -0.16396181f, 
    -0.16070850f, -0.10944366f, 0.21528363f, -0.14578059f, 0.08713209f, 0.06890388f, 0.09123780f, 0.16469082f, 
    -0.32334590f, 0.00991103f, 0.33920431f, -0.16030394f, -0.05023761f, -0.21777074f, 0.06212629f, -0.03332034f, 
    0.03193015f, -0.06712411f, 0.00123174f, 0.17170288f, 0.13350971f, -0.09793539f, 0.02165764f, 0.30751020f, 
    0.11970951f, -0.09903776f, -0.01301811f, -0.03204262f, -0.10605907f, 0.09493822f, -0.19335978f, 0.19058321f, 
    0.19538504f, 0.01762318f, -0.16143979f, -0.03446661f, -0.08027385f, 0.12993105f, 0.11024879f, -0.04640130f, 
    -0.04324530f, -0.04027132f, -0.16372246f, 0.09346393f, -0.09194888f, 0.02947380f, 0.16540021f, 0.00156700f, 
    0.08628029f, 0.00832049f, 0.02386904f, -0.19000399f, -0.04631496f, -0.31393147f, -0.27260906f, 0.01242034f, 
    -0.06871179f, 0.12667978f, -0.00290139f, 0.02391595f, 0.01872307f, 0.12419045f, -0.11603207f, 0.08628181f, 
    0.04690392f, -0.03848007f, 0.03577747f, -0.06104018f, -0.06273671f, -0.06093074f, -0.05560519f, 0.02598060f, 
    -0.01307484f, -0.06104532f, -0.02395475f, 0.02190784f, -0.02593193f, 0.02442456f, 0.00165695f, 0.00908097f, 
    -0.03006916f, -0.06509777f, 0.04053692f, -0.01567291f, -0.02276465f, -0.05657414f, -0.02500337f, -0.01916109f, 
    0.04265257f, 0.01840827f, 0.03725326f, -0.02156905f, 0.02254125f, -0.05120372f, 0.01084639f, -0.05381131f, 
    0.03867408f, 0.03397635f, -0.01918210f, 0.00372916f, -0.04840874f, -0.04209056f, -0.01433960f, 0.02041175f, 
    -0.04666520f, 0.02133752f, -0.04121812f, 0.00764089f, 0.02210400f, 0.04796704f, -0.03730697f, -0.06404295f, 
    0.02086393f, -0.06152662f, 0.04099679f, -0.00264848f, 0.00926549f, -0.00767841f, -0.02556990f, -0.06788536f, 
    0.00540846f, -0.06209233f, 0.04229990f, 0.04434969f, -0.04908496f, 0.01890419f, -0.02861536f, 0.02910028f, 
    0.04396357f, -0.04872492f, 0.02074239f, -0.03769214f, 0.04629134f, -0.00606619f, -0.06712113f, -0.03418013f, 
    -0.05611668f, -0.04400022f, -0.04053482f, 0.03970355f, 0.04366807f, 0.01226209f, -0.02885098f, 0.01020881f, 
    -0.02741536f, 0.03250824f, -0.05197413f, 0.02269918f, -0.05770648f, 0.00049747f, -0.04488383f, -0.03934712f, 
    -0.00714574f, -0.00812906f, 0.02632662f, -0.05490278f, 0.04122556f, 0.03521671f, -0.06380242f, 0.04056685f, 
    -0.04623468f, -0.04732776f, 0.03780304f, -0.01482975f, -0.03185708f, -0.00833874f, 0.04654378f, -0.00922654f, 
    -0.00336607f, 0.00542208f, -0.00838674f, -0.03565912f, 0.04300509f, -0.05134350f, 0.00815429f, -0.04729928f, 
    -0.05463366f, -0.04553991f, -0.01094579f, -0.03123438f, -0.04948702f, 0.00298174f, 0.01607718f, 0.01355925f, 
    -0.05317002f, -0.05941390f, 0.00372088f, -0.04488146f, -0.02276724f, -0.04561360f, 0.01931026f, 0.00656646f, 
    0.04061137f, -0.04359714f, -0.03028193f, 0.03005702f, 0.04620554f, -0.06636597f, -0.00759871f, -0.04883536f, 
    -0.01339029f, 0.03478290f, -0.00663977f, -0.00336970f, 0.00108134f, 0.00976621f, -0.06433742f, -0.04672223f, 
    0.05056755f, -0.03738413f, -0.00972546f, 0.02871292f, 0.01602023f, 0.04351472f, -0.00699944f, 0.04480773f, 
    0.01147061f, 0.01397901f, 0.03544827f, -0.03490208f, -0.06717337f, 0.04820902f, -0.04731359f, -0.03652628f, 
    0.04459810f, 0.04622029f, -0.04166466f, -0.05381732f, 0.02939329f, -0.04411016f, -0.04282635f, -0.00721625f, 
    -0.05265757f, 0.01798958f, 0.03934541f, -0.06514657f, -0.04157098f, 0.01967603f, -0.02599679f, 0.02791003f, 
    -0.00822484f, -0.02233013f, 0.03252473f, -0.01157191f, 0.03117794f, -0.03687028f, 0.00249242f, 0.02413688f, 
    0.02189853f, -0.01672837f, 0.02169596f, -0.04640130f, 0.02901015f, 0.03963829f, 0.01162347f, -0.03738177f, 
    -0.02914855f, 0.03279700f, 0.02621787f, -0.02002490f, 0.02920569f, 0.04634498f, 0.05024503f, -0.06511901f, 
    -0.04003452f, -0.05016759f, 0.01739082f, -0.04812345f, -0.01056680f, 0.04602592f, 0.04650404f, -0.02270755f, 
    -0.00005883f, -0.05207503f, -0.00809920f, -0.01154063f, -0.02674436f, -0.03283010f, -0.05787773f, -0.06478068f, 
    -0.01913385f, 0.04918087f, -0.05323040f, -0.04250384f, 0.02419821f, 0.02769868f, -0.01784589f, -0.01161755f, 
    0.01557795f, 0.04265494f, -0.00060808f, 0.00086027f, -0.06200707f, 0.03171337f, -0.01073792f, -0.06713235f, 
    -0.03970535f, -0.00191425f, -0.01234461f, 0.01533778f, 0.04267897f, -0.00574261f, 0.01335240f, -0.00244188f, 
    -0.04508490f, -0.05631525f, -0.00489890f, 0.03925515f, -0.04697465f, 0.04907328f, -0.03846256f, -0.05158369f, 
    0.00047019f, -0.01129320f, -0.02542416f, -0.02076130f, 0.01357579f, -0.00642914f, 0.02456158f, -0.02853574f, 
    -0.05588107f, 0.04392070f, -0.05475669f, -0.02569312f, 0.02570247f, 0.01365320f, -0.00826573f, 0.01902642f, 
    -0.04929304f, 0.03376024f, -0.00436692f, -0.00238614f, -0.01729156f, -0.05172953f, -0.02913901f, -0.02813206f, 
    0.02949356f, 0.03666960f, -0.04772570f, 0.00481336f, 0.02936385f, -0.04167579f, 0.04995277f, -0.00718809f, 
    0.01432539f, -0.01288601f, -0.06202215f, -0.06112966f, 0.04615446f, -0.06581673f, 0.03391443f, 0.03700812f, 
    -0.25131857f, -0.16506748f, -0.19732504f, -0.01039917f, -0.01344674f, -0.23688145f, 0.01706420f, 0.02232005f, 
    0.12944771f, 0.43735841f, 0.13832083f, -0.15707293f, 0.06719320f, 0.01505097f, 0.00860950f, -0.07184492f, 
    -0.04640745f, -0.08041324f, -0.08881431f, 0.16298999f, 0.13609202f, 0.08353049f, -0.09931994f, -0.30662680f, 
    0.08636180f, -0.00079417f, 0.00265538f, 0.28414091f, 0.15350337f, 0.04899386f, -0.24957733f, -0.15407452f, 
    0.04511714f, 0.18457457f, 0.20021647f, -0.08088499f, 0.06797042f, -0.02429351f, -0.10660153f, -0.01118021f, 
    -0.02456074f, -0.06755181f, -0.11797720f, 0.12830576f, -0.00187994f, -0.22200797f, -0.11141554f, -0.08492619f, 
    -0.20918709f, -0.12444260f, -0.21049060f, -0.01759533f, 0.03997048f, 0.08254422f, 0.03695029f, -0.29969430f, 
    0.11385377f, -0.20948322f, -0.17892288f, 0.11167694f, -0.09390152f, -0.18641640f, -0.00893734f, 0.28796875f, 
    0.22461744f, 0.01892701f, 0.01314450f, -0.00847897f, -0.05426893f, -0.09797324f, -0.09351288f, -0.07895254f, 
    -0.06862909f, -0.20630974f, -0.02317690f, -0.02256071f, 0.02075769f, 0.11134952f, -0.08559217f, -0.06168554f, 
    -0.04569502f, 0.20788750f, -0.09872375f, -0.01283646f, 0.04899045f, 0.05301628f, -0.01717693f, 0.09122477f, 
    0.06184445f, 0.03250859f, 0.03752592f, 0.37246901f, 0.29095429f, 0.00799345f, 0.17360103f, 0.00449902f, 
    -0.04789174f, -0.02535310f, 0.08864792f, -0.22172634f, -0.40420291f, 0.00019533f, -0.02830742f, -0.01776530f, 
    -0.02229346f, -0.00079613f, 0.00697268f, -0.07979383f, 0.14366524f, -0.07283732f, 0.02128680f, 0.02379249f, 
    0.18243404f, -0.05534194f, -0.15882416f, -0.15757671f, 0.03994766f, -0.15939456f, -0.06662209f, -0.22508779f, 
    -0.15645638f, -0.01392710f, -0.17444944f, -0.07953637f, 0.09624361f, -0.04762431f, 0.25866017f, 0.30124712f, 
    0.14629292f, 0.24078685f, -0.11133405f, 0.09943566f, 0.22976162f, -0.07491736f, -0.06707068f, -0.01496068f, 
    -0.18924001f, -0.17588536f, 0.11446702f, 0.12277820f, -0.14688192f, 0.06901355f, -0.04577411f, 0.07588134f, 
    -0.75612885f, -0.06904621f, -0.06102905f, -0.04858339f, 0.04450385f, -0.01581844f, -0.13282393f, 0.03809080f, 
    -0.11809652f, -0.24118760f, -0.36909062f, -0.13639542f, -0.09301524f, -0.13159890f, 0.10813875f, -0.17720023f, 
    0.06955580f, -0.01316895f, 0.29039633f, 0.25863713f, 0.13495909f, 0.45101148f, -0.04261141f, -0.06028249f, 
    0.10318681f, 0.08740529f, 0.15793681f, 0.04730764f, 0.24732473f, 0.22196200f, -0.18168706f, 0.11024125f, 
    0.17507832f, -0.13564759f, 0.16036032f, 0.02064536f, -0.08877035f, -0.09662867f, 0.06795955f, -0.13287319f, 
    -0.08461820f, -0.02358917f, -0.04231188f, -0.22402203f, -0.04522047f, 0.06448736f, -0.19805662f, 0.13966839f, 
    0.06453221f, -0.09626170f, -0.05246586f, 0.03033737f, 0.06282441f, 0.03258732f, 0.14137448f, -0.13792193f, 
    -0.08972900f, 0.07361449f, 0.09312636f, 0.08924542f, -0.02242228f, 0.02007038f, 0.02542505f, 0.24910593f, 
    -0.21418594f, 0.13527139f, -0.04102996f, -0.04772539f, 0.08010763f, 0.06645808f, -0.04509480f, 0.09395126f, 
    0.13246132f, 0.31439701f, -0.23467696f, 0.10345127f, 0.10059972f, 0.19294704f, -0.02848865f, 0.08978040f, 
    -0.12501419f, -0.00292088f, 0.06588728f, 0.02222683f, 0.00954812f, 0.08637475f, 0.15089707f, 0.09861755f, 
    0.07405411f, 0.12415311f, -0.28251249f, 0.08256047f, -0.09053582f, -0.12697238f, -0.17056134f, -0.08170810f, 
    0.09599502f, 0.08983475f, 0.03535811f, 0.12055250f, -0.17714271f, -0.16097425f, -0.21113694f, -0.07768376f, 
    0.16520788f, -0.24393094f, 0.11003809f, -0.19688179f, 0.00353140f, 0.11095998f, 0.09506117f, 0.12271325f, 
    -0.07145066f, 0.13988543f, -0.02320717f, -0.10064460f, -0.17345019f, -0.16931993f, -0.05930862f, -0.06404999f, 
    -0.03071436f, 0.14562051f, 0.04651431f, -0.18455751f, -0.13568544f, -0.13004687f, 0.18192889f, 0.23565474f, 
    -0.05510259f, 0.01819535f, -0.05952028f, -0.02180961f, -0.01196927f, 0.14415491f, 0.18897852f, 0.05802648f, 
    0.14958289f, 0.22292142f, -0.00089263f, -0.07131209f, -0.02156195f, 0.01233999f, -0.02792431f, 0.16455452f, 
    0.00753996f, 0.02549644f, 0.03472223f, 0.00064487f, -0.05072951f, -0.06372459f, -0.00184390f, -0.01350166f, 
    0.03686566f, 0.04188545f, -0.05234999f, 0.04698242f, -0.02697198f, -0.01120354f, 0.02680267f, 0.04078864f, 
    0.03665122f, 0.03855048f, 0.01418179f, -0.06791560f, 0.03322788f, -0.05547481f, 0.05264618f, -0.03606868f, 
    0.04283256f, 0.04188404f, -0.00075527f, 0.01480229f, 0.00956121f, 0.03939293f, 0.02254882f, 0.00163608f, 
    -0.03201884f, 0.02524306f, -0.03511523f, 0.00411651f, 0.05070000f, 0.01217530f, -0.01136920f, -0.03247984f, 
    -0.01490432f, -0.00553192f, 0.01111616f, 0.00927913f, -0.01043381f, 0.03478903f, 0.00766589f, -0.02307631f, 
    0.04539125f, -0.05713215f, -0.00072410f, 0.05487236f, 0.02834330f, 0.02961637f, -0.06140466f, -0.03617592f, 
    0.02559035f, 0.03688354f, 0.01936187f, -0.02612696f, -0.02250430f, -0.00230395f, 0.02403764f, -0.05984579f, 
    -0.01341356f, -0.00934999f, 0.01866412f, 0.04585001f, -0.05154426f, 0.01752039f, -0.01138859f, -0.00152623f, 
    -0.01585750f, -0.03826303f, -0.02556339f, 0.02470781f, 0.05094762f, -0.00331909f, 0.03949975f, 0.01556205f, 
    -0.00774675f, -0.05529759f, -0.00959886f, 0.01897964f, 0.03573693f, 0.02915086f, -0.00164742f, -0.06206321f, 
    -0.02652000f, 0.02639186f, -0.06715477f, 0.03901554f, -0.04525011f, -0.07086126f, -0.05987947f, -0.00311980f, 
    -0.00041645f, 0.04215133f, 0.04769192f, 0.00876117f, -0.04164341f, 0.01369287f, -0.04283770f, 0.03925844f, 
    -0.06287714f, -0.01280534f, 0.01555168f, -0.00905568f, -0.00118924f, 0.00189122f, 0.03819310f, 0.04203916f, 
    -0.00168309f, -0.02830653f, -0.05025559f, -0.06362867f, -0.04449062f, -0.06044859f, -0.01766451f, 0.04519564f, 
    0.00821469f, -0.02720350f, 0.01102213f, -0.02672834f, 0.04861241f, 0.03397246f, -0.01983788f, -0.06827269f, 
    0.00421671f, -0.01433353f, 0.04837829f, -0.01582391f, -0.04002962f, 0.03348118f, -0.01873044f, -0.00565551f, 
    -0.02069782f, 0.02179652f, 0.02003748f, -0.06117836f, -0.04878083f, -0.02839026f, 0.03299125f, 0.01670132f, 
    -0.03713719f, -0.01218587f, -0.04695155f, -0.06392934f, -0.05847139f, 0.04988492f, 0.03002036f, 0.05423245f, 
    -0.03158735f, -0.00731403f, -0.00969055f, 0.00541951f, 0.05347304f, 0.03262622f, -0.00526788f, -0.04513204f, 
    -0.01835283f, -0.01142959f, -0.04057978f, 0.02608007f, 0.03239084f, 0.00311218f, -0.06113663f, -0.05235293f, 
    -0.06503678f, -0.05253210f, -0.03223810f, 0.01218183f, -0.00205712f, 0.00532085f, -0.06593067f, -0.03949735f, 
    0.02791372f, -0.03084586f, -0.00070052f, -0.01935672f, -0.06201309f, 0.01145149f, -0.02059395f, -0.01172407f, 
    0.02046230f, 0.00531665f, 0.04603319f, 0.01363552f, -0.02550464f, 0.02616112f, 0.05479268f, -0.06900302f, 
    -0.05722773f, -0.05741714f, -0.03369112f, -0.00021021f, -0.03904806f, -0.05487667f, 0.03980799f, -0.02026577f, 
    0.00090242f, -0.03229883f, 0.01031243f, -0.04271574f, -0.04383860f, 0.03240098f, -0.03174093f, 0.00121265f, 
    -0.03087674f, 0.02739742f, 0.03739927f, -0.05144620f, -0.01509964f, 0.04301659f, 0.00842378f, 0.05122667f, 
    -0.00630802f, -0.06588357f, -0.00807432f, -0.06098371f, 0.00250870f, -0.02571865f, -0.04830479f, 0.00635072f, 
    -0.05949099f, 0.00490678f, -0.03041761f, 0.04499522f, -0.01794642f, -0.02713535f, 0.01680260f, 0.03512279f, 
    0.03606053f, 0.01314016f, -0.03613725f, 0.03181757f, 0.03630270f, 0.03405097f, 0.00308792f, -0.02202534f, 
    0.01092821f, 0.00333730f, -0.04986075f, -0.04314205f, -0.00741265f, 0.02747715f, -0.01970517f, -0.02501057f, 
    -0.02474422f, 0.02974381f, -0.00552415f, -0.03876904f, 0.02062604f, -0.02362186f, -0.05233747f, -0.00273460f, 
    0.00386334f, -0.00801802f, -0.05909131f, -0.00896982f, -0.05909913f, 0.00059490f, -0.03848630f, 0.03635220f, 
    0.00044599f, 0.03264171f, -0.03974904f, -0.00933539f, -0.03556642f, 0.04044183f, 0.02236968f, -0.04447102f, 
    0.01897210f, -0.04423955f, 0.03375084f, 0.01218017f, -0.05190800f, -0.01546596f, 0.03036053f, 0.01213961f, 
    0.01917509f, -0.00929927f, 0.00231617f, 0.00119672f, 0.00336680f, 0.02571111f, -0.05416016f, -0.01822478f, 
    -0.05816540f, -0.02517610f, 0.05055857f, 0.04619679f, 0.03139951f, -0.02219537f, 0.03525879f, -0.04567999f, 
    -0.06213532f, 0.04969793f, -0.05691502f, 0.03175396f, -0.02163036f, -0.02640631f, -0.05532227f, 0.02644728f, 
    0.04051859f, 0.01142408f, -0.01383075f, 0.00331936f, 0.04559519f, -0.05900880f, -0.05737567f, -0.00985826f, 
    -0.01437465f, -0.02603193f, -0.00141522f, 0.00230300f, -0.02375465f, -0.03876290f, 0.04422201f, 0.04081243f, 
    -0.05176017f, 0.03811265f, -0.02053917f, 0.01963804f, -0.01670939f, 0.02158573f, 0.02337657f, -0.06142547f, 
    0.04568411f, -0.01436473f, -0.01524033f, -0.00370636f, 0.02423471f, 0.04283478f, -0.05253586f, -0.03424842f, 
    0.02233899f, -0.04834402f, -0.01443773f, -0.02271573f, -0.03747953f, -0.04149522f, -0.00228898f, -0.04853912f, 
    -0.03975462f, -0.01316003f, -0.03683086f, -0.05965994f, -0.06072560f, 0.03537751f, -0.05240551f, -0.00684930f, 
    0.00147804f, 0.04018484f, -0.00763189f, -0.02779770f, -0.05095119f, -0.01174615f, -0.02109917f, -0.03105231f, 
    0.02211063f, -0.01951626f, 0.02576607f, -0.05678937f, 0.03778694f, -0.05043994f, 0.03968234f, 0.01489584f, 
    0.04230190f, 0.00677116f, -0.05980635f, -0.01047687f, 0.02103757f, -0.03346175f, -0.06260425f, -0.05511040f, 
    -0.01516381f, -0.04398885f, 0.05478373f, 0.03469468f, -0.05562749f, -0.06553431f, 0.00116618f, -0.03380862f, 
    0.05352441f, 0.01449919f, -0.03114378f, -0.03973505f, -0.03445377f, -0.01079782f, -0.02516971f, 0.03552388f, 
    -0.01190675f, -0.05479046f, -0.03243398f, -0.05123916f, -0.04498578f, 0.02202144f, 0.04601103f, 0.00728211f, 
    0.05638666f, -0.04799370f, -0.01415004f, 0.00696457f, -0.03489702f, 0.03360084f, 0.03958138f, -0.00974061f, 
    0.00731434f, 0.02885848f, 0.03324714f, -0.02215544f, 0.04686665f, 0.03973273f, 0.03774783f, 0.04628713f, 
    -0.02040137f, 0.02282040f, 0.01090595f, 0.02964780f, -0.05347828f, 0.00042152f, -0.01257563f, -0.05078065f, 
    -0.02614548f, -0.05319212f, 0.01054170f, -0.04304455f, -0.00360533f, -0.04048132f, -0.04311184f, -0.05478185f, 
    0.01555718f, -0.00614800f, -0.03788105f, 0.03175728f, -0.03907593f, 0.05276847f, 0.00283732f, -0.01801366f, 
    0.00985652f, -0.02444002f, -0.00208832f, -0.05520301f, -0.00780997f, 0.05884169f, 0.01868003f, 0.01856602f, 
    -0.05294278f, -0.06436680f, -0.01378763f, -0.04266774f, -0.05260448f, 0.03408678f, 0.01313619f, -0.01920602f, 
    -0.04982666f, -0.01071197f, 0.04879947f, -0.04418358f, 0.00486095f, 0.04768233f, -0.02293559f, -0.06846712f, 
    0.02353098f, 0.03544530f, 0.03588459f, -0.00533984f, 0.02106761f, 0.02688119f, 0.01693143f, -0.04851232f, 
    -0.04948860f, -0.04267624f, 0.04631851f, 0.02137814f, -0.02510471f, 0.00992820f, 0.05035992f, 0.01474752f, 
    -0.01886003f, -0.01952893f, 0.02054198f, -0.02286496f, -0.00900766f, 0.05477648f, 0.02095260f, -0.03051739f, 
    -0.02232939f, 0.03713663f, 0.04023594f, -0.00626569f, -0.02202792f, -0.06311077f, 0.04470855f, 0.01079424f, 
    -0.02805442f, 0.02508214f, 0.00958479f, -0.01506329f, -0.00935307f, -0.05440396f, -0.03876727f, -0.03282637f, 
    -0.02264268f, -0.00323421f, -0.01189050f, -0.05075020f, 0.00797804f, -0.01753686f, -0.02738749f, 0.03863562f, 
    -0.03951269f, 0.03492615f, -0.05396336f, 0.03734534f, 0.04462226f, -0.04049068f, -0.06193581f, -0.02122962f, 
    0.02369506f, -0.01323281f, 0.03999895f, 0.06334036f, 0.00214467f, -0.02984429f, -0.03175834f, -0.05217304f, 
    0.02599234f, 0.01187997f, 0.00711726f, 0.03761096f, 0.03169535f, -0.04769601f, -0.00061094f, 0.00491944f, 
    -0.04145644f, 0.02919161f, -0.01488444f, -0.02056951f, -0.05579583f, 0.04808984f, 0.00191024f, -0.02362828f, 
    0.03634492f, -0.06017768f, 0.02408401f, -0.05188845f, 0.00264275f, 0.00096483f, 0.03555467f, -0.02729050f, 
    0.05117861f, -0.01701990f, -0.00830734f, -0.05472584f, -0.01639211f, -0.04743372f, -0.01677081f, -0.02161984f, 
    -0.01329866f, 0.03326282f, -0.05155588f, 0.00864450f, 0.02129320f, -0.03188198f, -0.05582013f, -0.03047343f, 
    0.02430083f, -0.05105137f, 0.00747399f, -0.01931546f, -0.02722922f, 0.05022770f, 0.01742212f, 0.00053638f, 
    -0.41671196f, -0.15072727f, -0.14978965f, 0.02252791f, 0.08805473f, 0.00925187f, -0.09110462f, 0.20119575f, 
    -0.06710636f, 0.09174631f, -0.05899916f, 0.09507269f, -0.06043607f, 0.18514885f, -0.09238298f, -0.20076287f, 
    0.25341946f, -0.00820263f, 0.02682457f, 0.05785251f, -0.13322750f, -0.06763165f, -0.15646608f, -0.08582103f, 
    -0.04289394f, 0.17851982f, -0.01442630f, 0.32068861f, -0.28719124f, 0.01327348f, 0.13234338f, 0.13643032f, 
    0.02114204f, 0.02431225f, -0.10803749f, 0.03324362f, -0.26819190f, -0.00626617f, 0.20782909f, 0.08351389f, 
    0.00446763f, 0.25397125f, -0.21088283f, 0.07942075f, -0.11812143f, -0.07298014f, 0.03804678f, -0.01121255f, 
    0.08920777f, 0.07676349f, -0.04667198f, 0.02976355f, 0.04183451f, 0.00349975f, -0.44752449f, -0.32830989f, 
    0.14595132f, 0.14499821f, -0.05666398f, 0.07334822f, 0.07551219f, -0.07816752f, -0.12879287f, 0.29128832f, 
    0.04398988f, -0.11253045f, -0.23106991f, -0.09556396f, -0.19548711f, -0.07819743f, -0.08237075f, 0.00690134f, 
    0.02681203f, -0.36905155f, 0.32087302f, 0.13254058f, 0.08980502f, 0.08405280f, 0.01540402f, 0.04876487f, 
    0.08231886f, 0.05704155f, -0.10719934f, 0.07646821f, -0.11033033f, -0.08916065f, 0.12799165f, -0.07606003f, 
    0.02084685f, -0.16196780f, 0.22229974f, -0.13981152f, -0.02901500f, -0.00392445f, 0.12784217f, -0.21315736f, 
    0.07346078f, 0.15134984f, 0.14566630f, -0.11310512f, -0.35139301f, 0.08585998f, -0.12868656f, 0.08253077f, 
    0.11020371f, 0.20539452f, 0.14130478f, 0.03258905f, 0.58297187f, -0.19437668f, 0.24559425f, 0.03675723f, 
    -0.06506435f, 0.11497584f, -0.11049601f, 0.13054529f, -0.08127455f, 0.04217055f, -0.24196452f, 0.05123461f, 
    0.14990622f, 0.10372208f, -0.14087245f, -0.11551854f, 0.08939613f, 0.03292484f, -0.03050322f, 0.08262146f, 
    0.00792886f, 0.01228711f, 0.00102920f, 0.01686599f, -0.04281557f, 0.21548200f, 0.06438027f, -0.12465190f, 
    -0.36606872f, -0.01681576f, 0.10696714f, -0.04497423f, 0.29026031f, 0.08760230f, 0.02588104f, 0.10711062f, 
    0.32468447f, -0.09146344f, 0.16811359f, -0.00761081f, -0.06435748f, 0.13233995f, 0.03371282f, -0.08739860f, 
    0.11685495f, 0.08277104f, -0.54415226f, -0.07625759f, 0.01281096f, 0.04604169f, -0.02424939f, 0.04023140f, 
    -0.04005245f, 0.11814698f, 0.05346724f, 0.11035357f, -0.16342638f, -0.06447361f, 0.02539902f, 0.16425870f, 
    0.02436028f, 0.00713975f, 0.17142043f, 0.01083367f, -0.03447541f, -0.07887133f, -0.03679272f, -0.04117628f, 
    0.18086287f, 0.05264349f, -0.22068317f, 0.02801525f, -0.13687541f, -0.08596062f, -0.03951447f, 0.04515909f, 
    0.02441596f, -0.04812803f, -0.01303525f, 0.20615400f, -0.00432894f, 0.03188546f, -0.06699466f, 0.13505721f, 
    0.03528317f, 0.16545735f, -0.04708222f, 0.00768380f, -0.07491913f, -0.05225908f, -0.18567578f, -0.33206627f, 
    0.14303945f, -0.11111908f, 0.17076159f, 0.14190370f, 0.18104179f, -0.08841102f, 0.04190234f, -0.06178346f, 
    -0.10934356f, 0.25696105f, 0.07416759f, -0.14640233f, 0.01822434f, 0.06827454f, -0.26644483f, -0.06069118f, 
    -0.04732764f, -0.09081209f, -0.03491339f, -0.14431851f, -0.08152866f, -0.02701928f, -0.05625423f, 0.17519586f, 
    -0.01250511f, 0.15557575f, 0.06983830f, -0.13491082f, -0.24510702f, 0.18418162f, -0.01831976f, -0.07102249f, 
    0.01029622f, -0.02267248f, -0.44182444f, -0.10685128f, -0.28316534f, -0.00902903f, 0.01323038f, 0.19701354f, 
    0.06689408f, 0.02721511f, -0.02904061f, 0.30425423f, -0.04377208f, -0.06803636f, 0.13474908f, 0.10841445f, 
    -0.00519479f, 0.00766923f, -0.18375471f, 0.02383671f, -0.00867792f, 0.19923630f, 0.17946713f, -0.21515204f, 
    -0.16589150f, -0.16905768f, 0.24267603f, -0.08788861f, -0.05872649f, 0.12439321f, -0.03160847f, -0.19557580f, 
    0.01857218f, 0.00258084f, -0.06922885f, 0.13751993f, 0.05473732f, -0.05693888f, -0.22609760f, 0.15327562f, 
    0.04292799f, 0.17566523f, 0.15974310f, 0.04490553f, -0.08302289f, 0.13873330f, 0.08800533f, 0.20643736f, 
    0.18210325f, -0.05480443f, -0.01738415f, 0.09411563f, -0.16974248f, 0.04779729f, -0.01538044f, 0.02690996f, 
    -0.01829122f, 0.05233184f, -0.01145050f, 0.03263855f, -0.06405155f, -0.04234746f, -0.02503121f, 0.04374860f, 
    -0.03150001f, 0.00220560f, -0.04348741f, 0.02619811f, -0.03179893f, 0.02239521f, -0.03458823f, 0.02463739f, 
    -0.03271964f, -0.05455784f, 0.00964863f, 0.04752295f, -0.03218294f, 0.04193930f, 0.05236488f, 0.00528220f, 
    0.02290833f, 0.03472155f, -0.00381488f, 0.02163203f, -0.06251207f, -0.02491824f, -0.05025722f, -0.04768868f, 
    -0.00107477f, -0.03657418f, -0.03304376f, -0.02030000f, 0.00685625f, -0.05306362f, -0.05391850f, 0.00584200f, 
    -0.02188745f, 0.04325276f, -0.03923422f, -0.04489266f, -0.00350957f, -0.05709454f, 0.00554326f, -0.04869954f, 
    0.00134129f, 0.00574152f, -0.00511443f, 0.03024453f, -0.04175775f, -0.01207807f, -0.01840091f, -0.03392491f, 
    -0.03935044f, 0.03511366f, -0.05450122f, 0.04250233f, -0.04834976f, -0.01267978f, -0.02230673f, 0.06070511f, 
    -0.04727508f, -0.01274922f, -0.02261633f, -0.05783548f, -0.03412579f, -0.02346814f, 0.02668359f, 0.01890781f, 
    -0.06380912f, -0.04568861f, -0.02338057f, -0.05956917f, 0.00529432f, -0.01116302f, -0.02597203f, 0.02543216f, 
    -0.01098007f, 0.04622796f, -0.01760605f, -0.01886246f, -0.05552752f, -0.02235659f, -0.01548125f, -0.06332085f, 
    0.04461401f, 0.03850248f, -0.04480050f, -0.03178056f, 0.01933392f, -0.00088341f, -0.01523081f, -0.01400761f, 
    -0.04425525f, -0.06105262f, 0.01199417f, 0.01432595f, -0.02396450f, -0.05379778f, -0.06468347f, 0.01073096f, 
    -0.01514361f, -0.01609516f, 0.00519046f, -0.00039148f, 0.02913719f, 0.05045978f, -0.04302043f, 0.00472851f, 
    -0.00209384f, -0.02507359f, 0.01214734f, 0.05237013f, 0.04624831f, -0.04979217f, -0.00049746f, -0.02041767f, 
    0.02787716f, 0.04755815f, 0.01538621f, -0.02171940f, -0.00810007f, 0.01737151f, -0.04863346f, -0.00853267f, 
    0.04696165f, -0.04894333f, -0.06190813f, -0.04214412f, -0.00083868f, -0.00072302f, 0.06302802f, -0.06103133f, 
    0.04273410f, 0.04530963f, 0.01913567f, 0.02970629f, -0.02150417f, 0.04075270f, -0.02924546f, 0.00499547f, 
    -0.01791902f, 0.02994993f, 0.02502579f, 0.01894758f, -0.01746889f, -0.00882793f, -0.00886582f, 0.03022808f, 
    -0.02594673f, 0.01181589f, 0.05151577f, 0.02801556f, 0.01713077f, -0.00148747f, 0.02214942f, -0.05166798f, 
    -0.01433828f, 0.03101690f, -0.04053374f, -0.03214268f, 0.02140543f, -0.03779872f, -0.03408591f, -0.01040144f, 
    0.02062065f, 0.02591031f, 0.04777432f, 0.05129791f, -0.03578574f, 0.00766932f, 0.05228373f, 0.02775670f, 
    0.05031239f, 0.01583384f, -0.04404401f, 0.05982469f, 0.00562516f, 0.00858819f, -0.00846353f, -0.06481707f, 
    -0.02978012f, -0.02528819f, -0.03958093f, 0.05794184f, 0.03891283f, -0.04810882f, -0.06141326f, -0.03088037f, 
    -0.05225514f, -0.05020558f, 0.03445577f, -0.01658616f, 0.02196450f, -0.02870176f, -0.00496717f, 0.00882298f, 
    0.02960380f, -0.04110824f, 0.00930810f, -0.05507431f, 0.02633321f, -0.05082526f, 0.02733566f, 0.04715286f, 
    -0.00160190f, 0.00202705f, -0.01687379f, -0.00726287f, -0.06363562f, 0.04975843f, -0.02079480f, -0.03600487f, 
    0.03106331f, -0.00288791f, 0.02264180f, -0.05221243f, -0.00307497f, 0.02438311f, 0.02444732f, 0.01951770f, 
    0.02547551f, 0.03789521f, 0.02609453f, -0.04083333f, -0.00130172f, 0.03356818f, -0.05017623f, -0.02819336f, 
    -0.05367512f, 0.00423867f, 0.04385732f, -0.04107489f, 0.01663175f, 0.01823065f, -0.01949219f, -0.05490277f, 
    -0.04593479f, 0.00692830f, -0.00943005f, -0.01315731f, 0.04033907f, -0.04689670f, -0.06452470f, -0.01566547f, 
    0.00873459f, 0.03512778f, -0.00205989f, 0.02169881f, -0.02709795f, 0.01086586f, -0.01793783f, 0.03467466f, 
    -0.05410954f, 0.04886192f, -0.04295231f, -0.05124188f, 0.05295989f, 0.00448973f, 0.01837205f, -0.00623355f, 
    -0.05867043f, 0.05139331f, -0.04879940f, -0.00528553f, 0.05131616f, -0.01100049f, 0.02553870f, 0.04599653f, 
    0.02746827f, -0.03438933f, 0.04804913f, -0.03912080f, -0.02985771f, 0.01379399f, -0.00861207f, 0.00519138f, 
    -0.01858985f, -0.00478087f, 0.03503091f, 0.00113528f, -0.05900171f, -0.03758228f, -0.05168625f, -0.04441892f, 
    -0.00120857f, 0.02342544f, -0.01138857f, -0.04755744f, -0.04228085f, -0.03535091f, -0.06284846f, -0.02407020f, 
    0.04793009f, 0.01801160f, 0.04635506f, -0.02198095f, 0.00471552f, 0.04286434f, 0.04356716f, -0.06167330f, 
    0.01160889f, 0.02225581f, 0.05190369f, -0.02961721f, 0.00808715f, 0.02527107f, -0.00551355f, -0.04179088f, 
    -0.06400257f, -0.00270041f, 0.01910446f, -0.01485358f, 0.02938572f, 0.00384864f, -0.00392585f, -0.04080091f, 
    -0.06006603f, 0.03329048f, -0.04843367f, 0.00993064f, 0.00635735f, -0.04887935f, -0.00440036f, 0.04708607f, 
    0.04559657f, -0.05522655f, 0.05011276f, -0.04744001f, -0.03653287f, 0.04894270f, 0.04370528f, -0.00909130f, 
    -0.00512056f, 0.01874460f, -0.01300231f, -0.02920561f, 0.05282546f, -0.06228977f, -0.02763698f, -0.05285567f, 
    -0.04838417f, -0.06072657f, -0.05369801f, 0.01234398f, -0.01428631f, 0.01572694f, -0.04643638f, 0.00089381f, 
    0.05028379f, 0.02158233f, -0.01157751f, 0.04231391f, -0.01989667f, -0.05423933f, 0.02314971f, -0.01776787f, 
    0.03319155f, -0.02588050f, -0.04871617f, -0.02357307f, -0.03680223f, 0.00253375f, -0.02416442f, 0.04195496f, 
    0.01608776f, -0.05747656f, 0.00446546f, -0.01881812f, -0.04828190f, -0.02909505f, 0.03267019f, -0.03269351f, 
    0.04308382f, -0.01152810f, 0.01079050f, -0.04957426f, -0.06065938f, -0.00903579f, -0.06296489f, -0.03868444f, 
    0.03453692f, -0.05655908f, -0.00477986f, -0.04948724f, -0.01443079f, -0.02891205f, -0.01850239f, -0.04740205f, 
    -0.02377677f, -0.00620564f, -0.00131271f, 0.03709596f, -0.02986132f, -0.01935479f, -0.00557224f, -0.01603537f, 
    -0.02275778f, -0.05724323f, -0.00485268f, 0.02557232f, 0.02907298f, 0.00766898f, -0.04751325f, -0.03777049f, 
    -0.01741200f, -0.03631073f, -0.01914891f, -0.00094963f, -0.01503677f, -0.02273456f, 0.04870340f, 0.04533413f, 
    -0.02331190f, -0.06414419f, -0.04036488f, -0.04577603f, -0.02600193f, 0.01078045f, 0.01509716f, -0.04803824f, 
    0.05860937f, -0.05199550f, 0.04709217f, -0.05742560f, -0.03364606f, 0.01991574f, 0.03044760f, 0.05024784f, 
    -0.00331652f, 0.03178521f, -0.01113676f, -0.05392416f, 0.00724318f, 0.03260132f, -0.01209236f, -0.00876949f, 
    -0.00143045f, -0.01145491f, -0.06366733f, -0.04491938f, 0.00640895f, -0.02569375f, -0.00511013f, -0.03777522f, 
    -0.01876036f, 0.03420478f, 0.01717721f, 0.05127603f, 0.05047942f, 0.03329146f, 0.01088887f, -0.02138261f, 
    0.05162238f, 0.01300552f, 0.01957397f, -0.04642093f, 0.03265283f, 0.04748584f, 0.04724100f, 0.04333628f, 
    -0.03336982f, -0.04972224f, -0.04936776f, -0.04955053f, -0.00226331f, 0.01648699f, -0.02383867f, -0.01288511f, 
    -0.05926694f, -0.00452047f, -0.01632124f, 0.03203949f, -0.01150232f, -0.02608551f, -0.02487074f, -0.02765377f, 
    -0.01118421f, 0.00943445f, -0.02835147f, 0.00009821f, 0.04538923f, 0.00005391f, 0.05249142f, -0.00494419f, 
    -0.03504833f, -0.04754484f, 0.01022547f, -0.02187162f, -0.01794412f, 0.02081697f, 0.01436561f, -0.02527944f, 
    -0.05659973f, -0.01030013f, -0.01321840f, -0.03381632f, -0.04306773f, 0.03633974f, -0.06263260f, 0.00924360f, 
    0.01739899f, 0.01704989f, -0.03183720f, -0.06057861f, -0.00765083f, -0.03115022f, -0.04546383f, -0.01666293f, 
    -0.04119382f, -0.01433916f, -0.02351675f, -0.04412851f, -0.02438481f, 0.04480424f, -0.01848526f, -0.04350254f, 
    -0.02404771f, 0.04229707f, -0.05443300f, 0.03611336f, 0.00111721f, 0.01363058f, 0.04866197f, 0.01358018f, 
    -0.00483195f, -0.02252396f, 0.00026519f, -0.02905605f, -0.06139708f, 0.00231262f, -0.03912331f, -0.03014961f, 
    0.00205975f, -0.00865359f, 0.01385308f, -0.04052134f, -0.02928112f, -0.01600952f, 0.04392921f, -0.05833432f, 
    0.02308088f, 0.01556104f, -0.02546740f, 0.02670734f, 0.00182612f, 0.05146283f, -0.03367166f, 0.04209942f, 
    -0.00358211f, 0.03715818f, -0.04084466f, -0.05834978f, 0.00642516f, -0.05255402f, -0.04240248f, -0.04014641f, 
    -0.00999518f, 0.03158134f, -0.01736341f, -0.03723583f, 0.04354775f, -0.02591360f, 0.01421484f, -0.02446245f, 
    0.00549782f, 0.01994050f, -0.03190336f, -0.00847365f, -0.03170650f, -0.03005570f, -0.02860089f, 0.00903992f, 
    -0.31721187f, 0.02319145f, -0.16677144f, -0.06896610f, 0.01878215f, 0.13310562f, -0.04967135f, -0.03184383f, 
    -0.15551469f, 0.00771021f, 0.22208151f, 0.17023571f, 0.03199242f, -0.00868773f, 0.02653599f, -0.13447577f, 
    0.21252955f, -0.04547212f, 0.03155455f, 0.17886902f, 0.09847315f, -0.05460342f, 0.24273284f, 0.06203829f, 
    -0.05214621f, 0.02421494f, -0.04896344f, 0.21085623f, 0.22895375f, 0.27244571f, -0.07325146f, 0.08106849f, 
    -0.02042107f, 0.01258255f, -0.19929737f, 0.06947263f, -0.03177897f, 0.07901682f, -0.07082714f, 0.09362388f, 
    0.02255760f, 0.18530145f, -0.03161941f, 0.13511060f, 0.02057536f, -0.12647508f, 0.21378465f, -0.16012436f, 
    -0.07090354f, 0.05142613f, 0.10657623f, 0.11424606f, 0.10231422f, -0.04143675f, 0.08439792f, -0.13148405f, 
    -0.24241742f, -0.16530278f, 0.01520820f, 0.00112403f, 0.00374047f, 0.09423892f, -0.32871985f, 0.16699542f, 
    0.02672921f, -0.07019924f, -0.19804439f, 0.07140634f, -0.03447391f, 0.02603491f, 0.05192130f, -0.08464412f, 
    -0.21214370f, -0.07263358f, 0.04768939f, 0.02168893f, -0.14717311f, -0.26340875f, -0.08472028f, 0.14056350f, 
    -0.04430684f, 0.10494176f, -0.12166810f, -0.17353459f, -0.18552239f, 0.06070903f, 0.11942834f, -0.03523319f, 
    -0.26913795f, 0.02652877f, 0.25993693f, 0.02371139f, 0.14777888f, 0.19702661f, 0.11080509f, 0.13420436f, 
    0.07138365f, -0.09366055f, 0.03243390f, 0.14665823f, -0.03801320f, -0.34135509f, -0.12267401f, 0.08252219f, 
    -0.01802240f, -0.01236194f, 0.12078901f, -0.13725750f, -0.01126551f, 0.07302499f, 0.05364844f, 0.12335390f, 
    0.02487755f, 0.15641826f, 0.16637656f, -0.09872717f, -0.11594500f, 0.04552114f, 0.17303073f, 0.12740558f, 
    0.10042697f, 0.15125956f, -0.25203973f, 0.03346005f, -0.06518159f, -0.18404840f, 0.01589186f, 0.08942810f, 
    0.07313367f, -0.03295605f, 0.08550353f, -0.00776586f, -0.33414000f, 0.27275717f, 0.07199576f, 0.07801502f, 
    0.02945771f, -0.11652208f, 0.02285427f, -0.01480646f, 0.31762457f, 0.07262838f, -0.05535499f, -0.32128325f, 
    0.08698463f, 0.15431005f, -0.36131129f, -0.12905908f, -0.03164134f, 0.25803316f, 0.00753675f, 0.16616255f, 
    -0.19619155f, -0.11839608f, -0.06769349f, -0.14990267f, 0.00003584f, 0.01303041f, -0.11469548f, -0.09118081f, 
    0.14928760f, -0.14331217f, -0.06083886f, 0.01005279f, 0.32449603f, 0.09792416f, 0.20298569f, -0.08970695f, 
    -0.25379708f, -0.04974414f, 0.28001192f, 0.21539184f, -0.00036328f, 0.11356716f, -0.01766362f, 0.08985188f, 
    -0.07868939f, 0.12154632f, 0.10650659f, 0.09786884f, 0.25965479f, -0.19283625f, -0.37418279f, -0.23181061f, 
    0.04555934f, 0.05432675f, 0.08854176f, -0.00978779f, -0.05307710f, 0.02185252f, 0.01196366f, -0.18064819f, 
    0.10377242f, 0.01017630f, 0.14371288f, 0.06164102f, 0.04982622f, -0.22732680f, -0.03487752f, 0.00791131f, 
    -0.01399773f, -0.14334425f, -0.04151186f, -0.07803496f, 0.00564589f, -0.10646976f, -0.05086607f, -0.21364240f, 
    -0.02051295f, 0.26260763f, -0.04860888f, 0.04380194f, -0.16666287f, 0.14304240f, -0.12714846f, 0.12205535f, 
    -0.14426440f, -0.00480565f, 0.24374035f, 0.06308646f, 0.02159297f, 0.01362210f, 0.04516852f, -0.01744302f, 
    0.02654986f, 0.09155601f, 0.00583323f, 0.06321770f, -0.06286830f, 0.00788581f, -0.05955154f, -0.05148509f, 
    -0.17719574f, -0.05008645f, -0.10174400f, -0.09952460f, -0.11853351f, 0.03120705f, 0.17162290f, 0.06667402f, 
    -0.15411659f, 0.12784880f, -0.37216958f, 0.19783190f, -0.16549930f, -0.06732830f, -0.04978942f, 0.12207228f, 
    -0.27781007f, -0.01248816f, 0.12683396f, 0.02803601f, -0.02285164f, -0.02043337f, 0.08969313f, 0.10902582f, 
    -0.04291225f, 0.09162767f, -0.02934356f, 0.03722994f, 0.17560552f, 0.00400149f, 0.31396493f, -0.15228546f, 
    -0.05904517f, -0.02810480f, -0.05082652f, 0.13076571f, 0.17642102f, 0.11491223f, 0.10752112f, 0.11027324f, 
    0.01611707f, 0.22920479f, -0.02219466f, 0.08630700f, 0.06556369f, 0.01591557f, -0.39851189f, 0.09042411f, 
    -0.02193860f, 0.10639228f, 0.27536148f, 0.13152662f, -0.01589556f, 0.05116518f, -0.01110737f, 0.00292954f, 
    -0.00682262f, -0.02689158f, 0.02802954f, -0.03522038f, 0.02337178f, -0.02776649f, 0.02764842f, 0.03472231f, 
    0.04852905f, 0.00870765f, -0.00439262f, 0.00510663f, 0.02119072f, -0.00348140f, -0.01233017f, 0.03226757f, 
    -0.03555790f, -0.00449486f, -0.04444114f, -0.01537808f, -0.06573863f, -0.04404266f, -0.04443821f, -0.01090359f, 
    -0.00871726f, -0.02573095f, 0.01769335f, 0.02762762f, -0.03076630f, 0.04100005f, -0.01238243f, 0.01676551f, 
    -0.05832154f, -0.01288692f, 0.03404822f, -0.04161358f, 0.03739899f, 0.03284644f, -0.06200267f, -0.04604581f, 
    -0.02242679f, -0.05951817f, 0.00777327f, 0.02230167f, 0.04164005f, -0.01742490f, -0.06472807f, 0.04275245f, 
    -0.05931384f, 0.02329943f, 0.00190607f, 0.01107296f, -0.03878419f, 0.00084689f, -0.01732459f, 0.02248402f, 
    -0.06064389f, 0.02851334f, -0.04062187f, 0.03706486f, 0.01706122f, -0.04109423f, -0.01441189f, -0.01682951f, 
    -0.02749723f, -0.06919079f, 0.03173929f, -0.05596619f, 0.01909111f, -0.03422789f, -0.01688465f, -0.04410645f, 
    0.00316226f, -0.01530330f, 0.03434156f, -0.05890888f, -0.00309308f, 0.04713973f, -0.06559832f, -0.05675967f, 
    0.04744476f, -0.06231033f, 0.01512272f, 0.01786776f, -0.02494952f, 0.02126656f, 0.02049609f, -0.06204124f, 
    -0.06344831f, -0.02134788f, 0.01244710f, -0.06167263f, 0.03892804f, -0.05211708f, 0.01634229f, 0.01076640f, 
    -0.05669823f, -0.03406971f, -0.03414783f, 0.00960988f, 0.01789296f, -0.02980525f, -0.05686887f, 0.03919493f, 
    -0.01633959f, 0.02909915f, 0.02147383f, 0.02123669f, 0.01640442f, 0.00145079f, -0.04775144f, 0.02047015f, 
    0.02740208f, 0.04723983f, 0.04671032f, -0.04740560f, -0.00114680f, -0.00751221f, -0.01055302f, 0.04401508f, 
    -0.01144945f, 0.00042306f, 0.02519015f, 0.02402247f, -0.03830497f, -0.06347930f, 0.00541195f, 0.05721003f, 
    -0.04440764f, 0.03728325f, -0.03705270f, 0.00669684f, 0.04665504f, -0.01725832f, 0.01358387f, -0.03816747f, 
    -0.00421036f, 0.04810198f, 0.02314652f, -0.02307539f, -0.03014255f, -0.04324928f, 0.01999207f, -0.04598384f, 
    0.04959987f, -0.01978232f, -0.04229480f, 0.01796799f, 0.01961483f, -0.03731797f, 0.01983041f, -0.02829902f, 
    -0.05576833f, 0.04999313f, -0.00005596f, -0.01013643f, 0.02593336f, -0.01441998f, -0.06422625f, 0.00847986f, 
    0.00073957f, -0.02311099f, -0.01508228f, 0.04202021f, 0.02272788f, -0.04870785f, 0.00365769f, -0.02884996f, 
    -0.00649500f, 0.02157270f, 0.00802763f, 0.04561163f, 0.01091071f, 0.03810032f, -0.00729240f, -0.05776325f, 
    -0.01935213f, 0.01288307f, -0.05261056f, -0.05649533f, 0.03282448f, 0.03968556f, -0.04791366f, 0.00303731f, 
    0.02213142f, -0.06516078f, -0.03780494f, 0.01286425f, 0.01598989f, 0.00792679f, 0.02942233f, 0.04970261f, 
    -0.03035238f, -0.06319053f, -0.03705492f, -0.04257539f, 0.01177095f, 0.04421886f, 0.00751910f, 0.04395643f, 
    -0.01995765f, -0.02953970f, -0.05067690f, 0.00844776f, -0.06365928f, 0.00605928f, -0.04255454f, 0.01106089f, 
    0.00904860f, 0.04094926f, -0.02825269f, 0.03808436f, -0.06332085f, -0.00652414f, -0.06526926f, 0.04319528f, 
    0.02522260f, -0.05923373f, 0.04984339f, -0.04500585f, -0.00761086f, 0.00303493f, 0.04007181f, -0.02071840f, 
    0.00030343f, -0.00970625f, -0.03618148f, -0.06459465f, -0.05586242f, -0.02823156f, -0.06559519f, 0.01393147f, 
    -0.03431122f, -0.01841308f, -0.06617127f, -0.00959454f, 0.00662736f, 0.04690835f, 0.02442285f, 0.04827753f, 
    0.03284701f, 0.04755348f, -0.01589395f, -0.00785779f, -0.05574179f, -0.05513685f, 0.01109262f, -0.06164901f, 
    -0.03729435f, -0.03215848f, 0.00261202f, -0.01745078f, -0.01123512f, -0.04734299f, 0.02464631f, -0.06306568f, 
    -0.05616330f, 0.02783987f, 0.05625717f, -0.04792260f, -0.04240419f, -0.00598285f, 0.04849862f, 0.00544896f, 
    -0.01259536f, 0.00223385f, -0.04086916f, -0.03269082f, -0.02099791f, 0.03827454f, -0.06621726f, -0.06461499f, 
    -0.00271137f, 0.01564300f, -0.00776493f, 0.01742889f, -0.03892999f, -0.01265497f, 0.03389324f, -0.03815380f, 
    -0.02858784f, -0.04211796f, 0.02878206f, -0.06776180f, -0.05178235f, 0.02640240f, -0.01934941f, 0.03987535f, 
    -0.36435029f, 0.10539757f, 0.06286915f, -0.05069682f, -0.05866580f, 0.07994619f, 0.01525852f, -0.01825860f, 
    0.13647474f, 0.05793333f, -0.06598849f, -0.15417199f, -0.10598796f, -0.02081496f, 0.00555784f, -0.13501725f, 
    -0.05959884f, 0.02461672f, 0.46120358f, 0.03828821f, 0.09110522f, 0.00662537f, -0.09451809f, -0.16721433f, 
    -0.04348209f, 0.16336094f, 0.18012542f, -0.15560392f, -0.02715463f, -0.07847583f, -0.04656541f, 0.13502730f, 
    -0.04555722f, -0.07385205f, -0.02093905f, -0.11411793f, 0.23571540f, 0.14094460f, 0.12728748f, 0.07327484f, 
    -0.24562719f, 0.03634175f, 0.00549592f, 0.06516790f, 0.05844356f, 0.31531784f, -0.13702476f, -0.17001413f, 
    -0.09611753f, -0.04442283f, -0.01266528f, -0.00507198f, 0.10594813f, -0.09455068f, -0.24683416f, 0.16283672f, 
    -0.22782354f, 0.02468916f, -0.01383790f, 0.09895740f, 0.06800351f, 0.12514399f, 0.14355661f, -0.67569089f, 
    -0.14616838f, -0.04757296f, 0.07296149f, 0.02529119f, -0.05016463f, 0.09408969f, 0.12302770f, -0.12976462f, 
    -0.05647748f, 0.06989241f, -0.05402520f, -0.01020629f, 0.20495135f, -0.02319522f, -0.02036093f, 0.03042246f, 
    -0.15011767f, -0.29143503f, 0.16129293f, -0.68673432f, 0.01063426f, 0.06823665f, -0.03727111f, -0.01961742f, 
    -0.16910651f, 0.09067177f, 0.09679549f, -0.01552902f, 0.22470918f, 0.17499661f, 0.06490694f, -0.07009408f, 
    -0.09873040f, -0.10418356f, 0.08372880f, -0.25659975f, -0.07159421f, -0.05998006f, 0.03930737f, 0.02752055f, 
    0.16514532f, -0.10429721f, -0.04312517f, 0.12899615f, 0.07779339f, -0.22141086f, -0.48942474f, -0.05628547f, 
    0.13984944f, 0.14765961f, -0.01930496f, -0.06078900f, -0.00937349f, 0.22001021f, 0.17345774f, -0.03634969f, 
    -0.02708960f, 0.02212870f, 0.06786298f, -0.22339018f, 0.02636101f, 0.00855770f, 0.28382772f, 0.18728197f, 
    0.05881206f, 0.12183733f, -0.01273825f, -0.07430791f, 0.04687072f, -0.08966284f, 0.06058135f, 0.55340761f, 
    0.05054437f, -0.02349265f, -0.01002368f, -0.05122125f, 0.09804515f, -0.05646432f, 0.05825155f, 0.09360148f, 
    -0.19147521f, 0.00729054f, -0.09759358f, 0.06294401f, 0.09219287f, 0.22093758f, 0.02792985f, -0.00584609f, 
    0.00620802f, -0.05934970f, 0.27299413f, 0.13562247f, 0.01304758f, 0.05917112f, 0.13251270f, -0.08647071f, 
    -0.01591355f, -0.07096794f, 0.35327721f, 0.07641790f, 0.10316594f, -0.01217809f, -0.12439654f, 0.08471652f, 
    0.21409036f, 0.06094984f, 0.04146012f, 0.11398394f, -0.00413229f, 0.12703709f, -0.06896508f, -0.11883788f, 
    -0.18759048f, -0.12563564f, 0.07519569f, 0.04163707f, -0.31287450f, -0.26767424f, 0.00769151f, 0.01539624f, 
    0.08178095f, -0.01278104f, -0.24773499f, 0.15091783f, 0.07734390f, 0.25961944f, -0.12459598f, -0.03256422f, 
    -0.07842761f, 0.00729920f, -0.05273329f, 0.00702517f, 0.00654533f, -0.02631550f, -0.16195171f, 0.11423683f, 
    0.07385016f, -0.00142553f, 0.14394183f, -0.05940022f, -0.19072206f, 0.13799374f, 0.16483274f, -0.09512682f, 
    -0.09761937f, -0.35661402f, 0.10266236f, -0.15726103f, -0.12674934f, 0.12005612f, -0.04405575f, 0.02962996f, 
    -0.08104232f, -0.15010500f, 0.19245504f, -0.07351780f, 0.10910814f, -0.01022029f, 0.01500819f, 0.03875438f, 
    -0.06245371f, 0.01348599f, 0.17627622f, 0.00593438f, 0.05621850f, -0.09895535f, 0.06383913f, 0.03271910f, 
    0.01991406f, -0.08722986f, 0.12195288f, -0.06284802f, 0.03095320f, -0.03947524f, -0.08109548f, -0.01478698f, 
    0.09751419f, 0.02998757f, 0.12306319f, -0.04204677f, 0.09555344f, -0.12090355f, -0.03285262f, -0.08965132f, 
    0.18485589f, -0.23775329f, 0.17103526f, -0.10990948f, 0.18544175f, -0.17236388f, -0.13245246f, -0.01138599f, 
    0.03683154f, 0.07922802f, 0.10473541f, -0.07249664f, -0.20566027f, -0.21628058f, 0.00963304f, -0.20400645f, 
    -0.06514557f, 0.18491338f, -0.15772283f, -0.15884693f, 0.00295475f, -0.09151982f, 0.49881312f, -0.09995692f, 
    0.15077932f, 0.02684288f, -0.10430797f, 0.12175638f, 0.04802980f, 0.27223003f, -0.02644610f, 0.26511452f, 
    0.19330887f, -0.01967275f, 0.21286248f, -0.04548671f, 0.08539557f, -0.00064254f, 0.03990034f, -0.04976799f, 
    0.01420900f, 0.25630254f, -0.02015347f, -0.10360856f, 0.06622390f, 0.07406650f, 0.10642426f, 0.13495202f, 
    0.20823164f, -0.15062730f, -0.08423293f, 0.21934170f, 0.17334177f, 0.03603644f, -0.09803275f, 0.06026544f, 
    0.07435399f, -0.07577119f, 0.05143852f, 0.07062306f, -0.23380564f, -0.03468280f, -0.01471041f, 0.01613805f, 
    0.11723776f, 0.12837535f, -0.09711627f, 0.02972894f, 0.18935849f, 0.25086409f, 0.06924563f, 0.02493380f, 
    0.14120363f, 0.14170505f, -0.04202585f, -0.00018604f, 0.07262421f, 0.07118595f, -0.06123966f, -0.14667365f, 
    0.06868159f, 0.10532863f, 0.00506831f, 0.04202368f, -0.00484976f, -0.12547989f, 0.08438291f, -0.07488520f, 
    -0.07669710f, 0.01614727f, -0.02723854f, 0.13304365f, 0.14458704f, 0.13832542f, 0.13719052f, -0.00042008f, 
    0.11922882f, -0.03562469f, -0.00409964f, 0.08962093f, 0.14807655f, 0.04909613f, -0.06061212f, -0.33262798f, 
    0.02027296f, -0.16671538f, -0.16556579f, -0.08207203f, -0.05511724f, 0.03218304f, 0.04586371f, -0.09250058f, 
    0.39935437f, 0.08222476f, 0.22541861f, 0.04034015f, 0.09844161f, 0.18662234f, 0.12555066f, 0.01636223f, 
    0.18266372f, -0.26813018f, -0.07017753f, 0.25436732f, 0.02814062f, -0.22156544f, 0.09197303f, -0.01662074f, 
    0.14319955f, 0.22095440f, -0.66075742f, 0.04909368f, 0.07055607f, 0.10223910f, 0.12190982f, -0.05120178f, 
    -0.10944144f, -0.08442783f, -0.27536526f, 0.32951298f, 0.12282331f, -0.10959263f, 0.00965481f, 0.09835176f, 
    0.04146302f, -0.00462438f, -0.07222818f, 0.23800473f, 0.06327309f, -0.15589067f, 0.18084581f, 0.03127939f, 
    0.08595632f, -0.12039837f, -0.02514797f, 0.09126515f, 0.02635838f, 0.41457236f, 0.13919361f, 0.07084841f, 
    0.09359912f, -0.03913057f, -0.03938634f, -0.06885449f, 0.02254451f, 0.21457843f, -0.27438134f, 0.13916345f, 
    -0.22075954f, 0.06086292f, 0.05149135f, 0.13381080f, 0.03570072f, 0.08674661f, -0.24028973f, -0.13077216f, 
    0.18336065f, 0.04053545f, 0.16232960f, -0.09136164f, 0.06405455f, 0.13692142f, -0.04125604f, 0.33978945f, 
    0.32741404f, 0.02910978f, 0.02286978f, 0.15438443f, -0.07072841f, 0.12614192f, 0.13848341f, 0.08738119f, 
    0.00179038f, 0.42396584f, 0.19888628f, 0.05133885f, 0.09589843f, 0.20855339f, 0.17806461f, -0.07962231f, 
    -0.02717690f, -0.04777140f, 0.01530671f, 0.20412831f, -0.37025070f, 0.00010010f, -0.04236039f, -0.00813478f, 
    0.01007353f, -0.06168440f, -0.21785340f, -0.32450825f, 0.18036932f, -0.16255233f, -0.12143695f, 0.04911117f, 
    -0.19855189f, 0.11106151f, 0.26579517f, -0.14993484f, -0.19786046f, -0.00781681f, -0.03434939f, 0.16936925f, 
    0.08909425f, 0.07604375f, -0.04447094f, 0.21020789f, 0.06360046f, -0.40630567f, -0.47066617f, 0.21048978f, 
    -0.10567372f, 0.14548187f, 0.06335784f, -0.03388393f, -0.01556851f, 0.15286517f, 0.31610689f, 0.20654225f, 
    0.04234069f, 0.04492541f, -0.03722789f, -0.06431800f, 0.11274441f, -0.00647942f, 0.19993564f, 0.19125131f, 
    -0.01958217f, 0.03212540f, -0.07762267f, 0.07674108f, -0.04331649f, 0.20691794f, 0.02504039f, 0.25268209f, 
    -0.07228973f, -0.10017268f, -0.71588004f, 0.16952550f, 0.08803801f, 0.06592327f, -0.10431261f, -0.06858235f, 
    -0.07869141f, -0.61131620f, -0.00978544f, 0.02056326f, 0.03956951f, 0.06535173f, 0.13877973f, 0.02310635f, 
    0.01303630f, -0.28522474f, 0.22848617f, 0.12759383f, 0.21951559f, 0.14357802f, 0.18676069f, -0.13878985f, 
    -0.05566611f, 0.16544741f, -0.05657747f, -0.11587352f, 0.05815993f, -0.05010915f, -0.27102762f, -0.25947037f, 
    0.17670083f, 0.00448986f, -0.02443677f, 0.02581875f, 0.01674921f, -0.08043646f, -0.21414798f, 0.03692906f, 
    0.19482896f, -0.05396184f, -0.01656091f, -0.02726957f, -0.03942768f, -0.14626768f, -0.14029148f, -0.07453153f, 
    -0.04736066f, 0.26165265f, 0.03617803f, 0.06917126f, -0.06527603f, -0.07250073f, -0.42518416f, -0.23252355f, 
    0.06759275f, -0.17627273f, -0.03266824f, 0.09141697f, 0.00687495f, -0.08687887f, -0.14426459f, -0.80638868f, 
    -0.20887807f, 0.22887054f, -0.06032520f, -0.09295630f, 0.07286640f, 0.17663845f, 0.04812723f, 0.02287705f, 
    0.01682730f, -0.03220326f, 0.03570842f, 0.00682556f, -0.02580750f, 0.02781003f, -0.03464050f, 0.04413608f, 
    0.00763430f, -0.01424796f, -0.02828099f, 0.00533150f, -0.00031490f, 0.01720146f, -0.02494155f, 0.04710337f, 
    -0.02991829f, -0.02837482f, -0.01600611f, -0.05835769f, -0.05502427f, 0.04653466f, -0.03741442f, -0.06128311f, 
    0.03378679f, -0.01992878f, 0.02297121f, 0.01546108f, -0.03666486f, -0.01026651f, 0.05058545f, -0.04569164f, 
    -0.04919366f, 0.01388812f, -0.06069714f, -0.05337429f, -0.04443246f, 0.00700691f, -0.05317988f, -0.03311156f, 
    -0.03806845f, 0.03873659f, 0.03212664f, 0.02421453f, -0.04557793f, 0.04982764f, 0.04011111f, -0.00873401f, 
    -0.03863477f, -0.01858283f, -0.04239704f, 0.00494171f, -0.06682295f, 0.00542734f, -0.01196305f, 0.01366302f, 
    -0.04588243f, 0.00155989f, -0.01916347f, 0.03726111f, -0.06405004f, 0.02532059f, -0.06005776f, 0.03894403f, 
    0.03588080f, 0.03532768f, -0.00856958f, -0.05621930f, 0.04827740f, -0.00446083f, 0.00967426f, -0.00967415f, 
    0.00868734f, -0.02865431f, 0.04997216f, 0.00457870f, -0.03186292f, -0.00444823f, -0.02344576f, 0.01984207f, 
    0.03978733f, -0.03963679f, 0.00944421f, -0.01354807f, 0.01969544f, -0.01855513f, -0.02951040f, -0.01738807f, 
    -0.00669941f, 0.04532845f, 0.04636043f, 0.02584984f, 0.01838616f, 0.03486256f, 0.04193010f, -0.02465386f, 
    -0.00431335f, 0.05333036f, -0.01334678f, 0.00904918f, -0.00790139f, -0.05920285f, -0.06681851f, 0.00202251f, 
    -0.02646671f, 0.02650740f, 0.02901988f, -0.03678198f, 0.02572522f, -0.05702106f, -0.03147512f, 0.05643192f, 
    -0.01906835f, -0.03414036f, -0.02010110f, 0.00314955f, -0.04359563f, -0.02479453f, -0.01850819f, -0.06203584f, 
    0.01559894f, -0.06458520f, -0.03833778f, -0.02580013f, -0.00950186f, 0.00899980f, -0.01350693f, 0.02391845f, 
    -0.03617688f, -0.01025917f, 0.03684186f, -0.03398520f, -0.01861641f, 0.04508659f, 0.01917499f, 0.04724193f, 
    0.01766820f, 0.01378374f, -0.02592371f, 0.03704739f, 0.05773899f, 0.03790116f, -0.04189993f, -0.01391957f, 
    -0.01712387f, 0.04627839f, -0.00126512f, -0.04670018f, 0.04968137f, 0.01162798f, 0.04901466f, 0.00326443f, 
    0.01534039f, 0.04918355f, 0.00703665f, -0.01996333f, -0.04163508f, 0.00292757f, 0.00701677f, 0.04635617f, 
    0.02229145f, 0.02780580f, -0.00650614f, -0.04469044f, -0.04733134f, 0.02427388f, 0.00643854f, -0.02858487f, 
    0.01423881f, -0.02951772f, 0.00746094f, -0.05366548f, 0.02597193f, -0.01653116f, 0.03819671f, 0.01903436f, 
    -0.00917149f, -0.00730665f, -0.00787959f, -0.05040525f, 0.03660347f, 0.03005617f, 0.04702201f, 0.02827628f, 
    0.02755013f, -0.04774028f, -0.04024335f, -0.00519518f, -0.02906015f, -0.01831393f, -0.05203923f, -0.03121962f, 
    -0.02382518f, -0.03748666f, -0.06267984f, -0.01266884f, 0.03302312f, -0.04650050f, -0.03708614f, 0.01931974f, 
    -0.03460788f, -0.01691795f, -0.00293334f, 0.03022292f, -0.00809199f, 0.01966220f, -0.00767934f, -0.05052819f, 
    0.00516860f, -0.02626810f, -0.01398448f, 0.02492957f, -0.06085640f, 0.04466652f, -0.01579255f, -0.01572678f, 
    0.01910437f, -0.03061175f, -0.03031648f, -0.02895898f, 0.00043461f, -0.03810266f, -0.02877536f, 0.00508216f, 
    -0.01364230f, -0.00144423f, -0.00254750f, -0.00904449f, -0.01631180f, 0.05144856f, -0.02569223f, 0.04151629f, 
    0.03886060f, 0.02006669f, -0.00368692f, -0.03665105f, 0.04040351f, 0.01583014f, -0.01152196f, -0.02263343f, 
    -0.05964404f, -0.01803997f, -0.01398276f, -0.01603711f, 0.02505353f, -0.02901784f, -0.05288533f, 0.02643065f, 
    0.03277110f, -0.04877604f, -0.04037341f, 0.00316181f, -0.02931808f, 0.00800886f, -0.02776638f, -0.02618319f, 
    -0.04516127f, -0.05566951f, -0.05688175f, -0.03430958f, 0.00858852f, -0.02325463f, 0.05590712f, -0.04897104f, 
    -0.01654825f, -0.02933150f, -0.03391812f, 0.01454521f, 0.00010551f, -0.01099625f, -0.00059157f, -0.03605644f, 
    -0.02799733f, -0.01282168f, 0.01667463f, 0.00567921f, 0.02155983f, -0.05056441f, -0.04644231f, -0.04252081f, 
    0.01448832f, 0.00379673f, -0.05456431f, -0.05594090f, -0.00929298f, -0.00006755f, 0.03123210f, -0.00580413f, 
    0.36005348f, -0.27576655f, 0.07354322f, 0.05025021f, 0.23471770f, 0.17955673f, -0.02698457f, -0.00319609f, 
    -0.04068217f, -0.07653938f, -0.11930444f, -0.15516441f, -0.08879182f, 0.07293729f, 0.13314380f, 0.24700081f, 
    0.05356109f, 0.16711044f, 0.00558619f, -0.52150112f, -0.06260033f, 0.17521773f, 0.16249323f, -0.01147465f, 
    0.16850156f, 0.07374594f, -0.16649765f, -0.13427666f, 0.02219463f, -0.03941640f, -0.06826866f, 0.02166399f, 
    -0.11069286f, 0.01817289f, 0.05644058f, 0.06361744f, 0.19654141f, 0.06471168f, -0.14634536f, 0.05648042f, 
    0.10311717f, -0.02608055f, -0.07223845f, -0.02789483f, 0.28599766f, -0.01579171f, -0.03491245f, -0.05631130f, 
    0.12571746f, -0.19271110f, -0.03930842f, 0.00251464f, -0.12622595f, -0.08108998f, 0.14612588f, 0.13657318f, 
    0.15117197f, -0.07391553f, -0.01453662f, 0.12834366f, 0.02732663f, -0.09672824f, -0.05894027f, -0.11134427f, 
    0.21687947f, 0.05449663f, -0.12863940f, 0.11685234f, -0.06819440f, 0.03724827f, 0.06286228f, -0.11357809f, 
    0.10255197f, 0.11212355f, 0.11122584f, -0.03019862f, 0.00867331f, 0.09009163f, -0.05746359f, -0.02068037f, 
    -0.13083111f, -0.01330904f, -0.06516868f, 0.26481009f, 0.00395058f, 0.04715311f, -0.13399996f, -0.01574092f, 
    0.00688451f, 0.11132753f, -0.01585567f, -0.30264488f, -0.42093205f, 0.05911097f, 0.06017229f, 0.11189119f, 
    0.01481188f, 0.00736848f, -0.18050326f, 0.08963861f, 0.07467597f, 0.12259495f, -0.26222265f, -0.05003669f, 
    -0.10825168f, -0.01359206f, 0.02733681f, 0.00910887f, -0.04752931f, 0.18962741f, 0.04584720f, -0.14873774f, 
    -0.12567079f, 0.16342483f, 0.11295585f, 0.07137600f, -0.04221091f, -0.12906942f, 0.27223840f, 0.07985242f, 
    0.10954814f, -0.01197703f, 0.21291585f, -0.13324898f, 0.01174959f, 0.08195971f, 0.56351817f, -0.04677786f, 
    0.03925816f, 0.02915428f, 0.20209038f, -0.02365551f, 0.13492717f, -0.02041434f, -0.10388126f, -0.27337930f, 
    -0.22499949f, -0.42256021f, 0.11556291f, -0.03199033f, -0.11784347f, -0.02197502f, 0.02581878f, -0.15418890f, 
    -0.03014367f, -0.01498169f, 0.04164597f, -0.39342260f, -0.10707524f, 0.02789660f, 0.01349246f, 0.10799306f, 
    -0.05198571f, 0.24233350f, 0.16328920f, -0.00655302f, -0.14025173f, -0.02792425f, -0.09296146f, -0.14122811f, 
    -0.12113342f, -0.00123848f, 0.13075148f, -0.17135489f, -0.38186398f, 0.08653376f, 0.26634952f, 0.07835069f, 
    0.11199418f, 0.07657631f, -0.00373018f, -0.06600177f, -0.45820588f, -0.13587034f, -0.20244427f, 0.06772570f, 
    0.03445763f, 0.04971238f, -0.21833549f, -0.09436249f, -0.22322962f, 0.01595790f, 0.21315996f, -0.12309099f, 
    -0.17351080f, 0.08869137f, 0.06672405f, 0.13744242f, 0.26216218f, -0.24880508f, 0.17511156f, 0.45634136f, 
    -0.14397441f, -0.17937356f, -0.16045876f, 0.10033283f, 0.18159188f, 0.11262961f, 0.01645653f, 0.30868325f, 
    -0.01610293f, -0.13926296f, 0.05018176f, 0.02200391f, -0.12091806f, -0.06461285f, -0.07289436f, -0.12184098f, 
    -0.12112376f, -0.20775874f, -0.08386802f, -0.18999484f, -0.10525268f, 0.11938360f, 0.19551235f, 0.12761123f, 
    -0.00103081f, -0.05063696f, -0.06553356f, -0.00805470f, 0.03654225f, -0.06604449f, 0.06264352f, 0.00618034f, 
    0.17573971f, 0.28085393f, -0.00013384f, -0.36482573f, 0.09733613f, 0.19478452f, 0.23905775f, -0.04571700f, 
    -0.11903488f, -0.33881453f, -0.04417454f, 0.11915592f, -0.18451731f, -0.09409847f, 0.13141356f, 0.18914439f, 
    0.01818642f, -0.20965059f, 0.04309774f, -0.01371652f, 0.13294961f, -0.06606618f, -0.08299886f, -0.12238526f, 
    0.20605180f, -0.11469419f, 0.03532506f, 0.05162783f, -0.11830677f, -0.01682436f, 0.31083244f, -0.07261132f, 
    0.09299262f, 0.14618020f, 0.10926697f, -0.03515955f, -0.14283243f, 0.15562420f, 0.05781155f, -0.19931012f, 
    -0.03315759f, -0.07603832f, -0.04253823f, 0.20709439f, 0.12351306f, 0.02786392f, 0.14088233f, 0.36631224f, 
    0.02401243f, 0.22968616f, 0.09845673f, -0.00212786f, -0.25725579f, 0.13365097f, -0.03421685f, 0.42729658f, 
    0.21356201f, 0.10561347f, 0.17982100f, -0.21449070f, 0.03622245f, 0.06595906f, -0.05616766f, -0.15654074f, 
    -0.10518756f, 0.24438627f, 0.17620200f, 0.11786065f, 0.13636813f, -0.19636327f, 0.09299416f, 0.27299994f, 
    -0.06984485f, -0.28913283f, -0.74420166f, -0.34867081f, -0.03317415f, -0.07348841f, 0.06856863f, -0.05933084f, 
    0.12173839f, -0.14740030f, 0.00200516f, -0.21055020f, 0.33401641f, 0.13161519f, -0.07344849f, -0.02983471f, 
    0.17669585f, 0.03377159f, -0.05540814f, -0.07700393f, -0.48649445f, -0.28198189f, -0.02462054f, 0.16973127f, 
    0.06955770f, -0.12074726f, -0.01099950f, -0.13450737f, 0.09682960f, 0.22633179f, 0.15716328f, -0.13553110f, 
    -0.06724925f, -0.21315084f, -0.08784786f, 0.16148563f, -0.18673372f, 0.09367676f, 0.18135220f, -0.21644408f, 
    -0.01433459f, -0.07160676f, -0.04985577f, -0.08487905f, 0.00559927f, 0.01494221f, -0.03559460f, 0.10283908f, 
    -0.02917239f, -0.12352975f, -0.02333656f, 0.05296429f, 0.01117123f, -0.01037789f, -0.05801429f, -0.34993610f, 
    0.21720381f, 0.00858392f, 0.21066174f, 0.19785783f, 0.12374728f, -0.06138589f, -0.00220094f, 0.07600775f, 
    -0.00738626f, -0.09766955f, 0.04457857f, 0.06000465f, 0.03519647f, -0.08349387f, 0.10824852f, -0.19366512f, 
    0.19849013f, -0.57707304f, 0.07724722f, -0.14169706f, 0.06507658f, -0.14927153f, -0.14732313f, -0.22560732f, 
    0.07878409f, -0.02976136f, -0.02722703f, -0.02613996f, 0.42258459f, 0.08248824f, -0.00023502f, -0.01119047f, 
    -0.10162761f, -0.00823479f, 0.20329097f, 0.04237690f, 0.15233347f, -0.03859082f, 0.24026668f, -0.15976892f, 
    0.07521161f, -0.07134853f, -0.11675668f, 0.06691764f, -0.03171919f, -0.16172379f, 0.14981921f, -0.09247715f, 
    0.12215712f, 0.11299178f, -0.17049378f, 0.14910997f, -0.02465325f, 0.16892003f, 0.02693133f, 0.00233584f, 
    0.04898441f, -0.09387556f, -0.09813368f, 0.16357796f, 0.00230436f, 0.15443109f, 0.36864084f, -0.12613624f, 
    -0.24372172f, 0.15359882f, -0.06160809f, 0.08302208f, 0.00577365f, -0.03086757f, -0.31089246f, -0.03711172f, 
    -0.05196817f, -0.21340716f, -0.01858575f, -0.13473828f, -0.17857677f, -0.03780586f, 0.07871635f, 0.02860732f, 
    -0.05100868f, 0.22120571f, -0.03190123f, 0.12794547f, -0.15586579f, 0.07052973f, 0.07324089f, 0.09737061f, 
    0.04145631f, 0.03914079f, 0.04042501f, 0.09605020f, 0.06110472f, -0.08310448f, -0.01067007f, 0.01062943f, 
    -0.01381283f, 0.12643935f, 0.23877403f, -0.04445533f, -0.32699880f, -0.16865295f, -0.14568993f, -0.02513027f, 
    0.07119483f, 0.21221620f, -0.11877252f, 0.04748312f, 0.40551409f, -0.02358338f, 0.14903937f, -0.08396313f, 
    0.15204091f, -0.02863118f, 0.01480209f, -0.03521608f, -0.20457827f, -0.08846516f, 0.00650090f, 0.09540433f, 
    0.09782901f, 0.07628087f, -0.04521973f, -0.12542877f, -0.05601428f, -0.54766977f, -0.00532688f, 0.01954869f, 
    0.05147297f, -0.00694812f, 0.18236652f, 0.06962845f, -0.16035254f, 0.11991303f, 0.06442615f, 0.09406988f, 
    0.07829431f, -0.05712207f, 0.04149435f, 0.08558255f, 0.10933579f, -0.17201000f, 0.26754475f, -0.16391575f, 
    0.13563074f, -0.42109728f, 0.02136682f, 0.11603533f, 0.24307442f, 0.05005382f, 0.03918798f, 0.17506467f, 
    0.47109157f, -0.26387420f, -0.25853196f, 0.11327697f, 0.27962908f, -0.00998997f, -0.03402621f, -0.10639790f, 
    0.07303984f, 0.00444916f, 0.24889895f, 0.28476116f, -0.05129952f, 0.08028299f, 0.08915506f, 0.12572439f, 
    -0.01964114f, -0.06784706f, -0.09525616f, -0.12881224f, 0.25427482f, -0.13509956f, -0.01333689f, 0.01769701f, 
    -0.15318292f, -0.07285795f, 0.00269585f, 0.09268588f, -0.33129990f, -0.01921388f, 0.07478923f, 0.10939468f, 
    0.03433644f, 0.01060339f, -0.00466351f, 0.09037742f, -0.06662303f, -0.22929990f, -0.18961217f, -0.03376733f, 
    0.14536937f, 0.11279533f, 0.04223185f, 0.06897084f, 0.00794051f, 0.00131675f, 0.02976137f, -0.36090586f, 
    0.07552564f, 0.15860087f, 0.02583037f, 0.07248145f, 0.02062388f, -0.10494617f, -0.30514875f, -0.30825284f, 
    0.04451642f, -0.08613756f, 0.04389086f, -0.13950104f, -0.08802522f, -0.09461407f, 0.03398680f, -0.06605829f, 
    0.49619600f, -0.35641137f, -0.00272951f, -0.00182898f, -0.05581085f, -0.03723333f, -0.05596265f, 0.01459162f, 
    0.25032508f, -0.09747919f, 0.01347611f, -0.09609058f, -0.05432831f, -0.15901123f, 0.05525306f, 0.08172986f, 
    0.03013676f, 0.02027625f, -0.10308228f, -0.01629908f, -0.18297276f, 0.15449330f, 0.12740727f, 0.05112383f, 
    0.23612578f, -0.13685803f, -0.15921541f, -0.18527192f, -0.09570409f, 0.20186487f, 0.08266328f, 0.08012715f, 
    -0.03975875f, -0.09902896f, -0.01231862f, -0.39437008f, -0.05248039f, -0.19079216f, 0.02032076f, 0.10259368f, 
    -0.04818265f, -0.02732280f, -0.10882796f, -0.11753789f, 0.36365861f, 0.27893102f, -0.06046797f, -0.00805772f, 
    -0.12585023f, -0.08779982f, 0.37039828f, 0.15840891f, -0.03319904f, -0.16496457f, -0.25429812f, -0.02178577f, 
    0.05715986f, 0.08574760f, 0.05497201f, 0.23985381f, 0.12414499f, 0.16013399f, -0.07932872f, 0.05991797f, 
    0.23798455f, -0.19926143f, -0.05238090f, 0.01380144f, 0.10048865f, -0.00739435f, 0.04073096f, -0.34164259f, 
    -0.06293307f, 0.22800942f, 0.10376161f, 0.23581943f, -0.05720982f, -0.01891453f, 0.03895515f, -0.04076385f, 
    -0.01485642f, 0.01948364f, -0.05570107f, -0.14155649f, -0.00032747f, 0.19653954f, -0.20308590f, 0.10937024f, 
    0.05205890f, 0.01751323f, -0.19778658f, -0.09252512f, -0.07511611f, 0.02322717f, -0.10928787f, -0.05778565f, 
    0.21071288f, 0.11670873f, -0.24027619f, 0.05171100f, -0.01152495f, 0.12578230f, 0.14323509f, 0.05614696f, 
    -0.09181735f, -0.05543067f, -0.14559549f, -0.03601889f, -0.09615526f, 0.11310249f, -0.07903221f, 0.08651336f, 
    -0.04090777f, 0.03646458f, 0.00035051f, 0.05456677f, -0.08590480f, -0.00287430f, 0.35343447f, -0.12504406f, 
    0.16352482f, -0.12348022f, -0.07597894f, 0.14568476f, -0.01288637f, -0.25088874f, -0.14980523f, -0.01982674f, 
    0.01560480f, -0.12085029f, 0.09620973f, 0.04864577f, -0.06198047f, 0.27761719f, 0.01473051f, -0.05744245f, 
    0.22664906f, -0.01036569f, 0.04924921f, 0.04975247f, -0.14666159f, -0.01262107f, -0.18155076f, -0.33872086f, 
    -0.39551103f, -0.41718382f, 0.01486545f, -0.02008856f, -0.10812131f, 0.10393757f, 0.13185452f, 0.19907877f, 
    -0.09782027f, 0.00420587f, -0.12237801f, 0.07853186f, -0.23802345f, 0.02912123f, -0.01013460f, 0.01788980f, 
    0.16752581f, -0.15164340f, 0.07767806f, 0.08501847f, -0.16288437f, -0.09601419f, 0.17449719f, -0.11341713f, 
    0.02926808f, -0.01373926f, 0.27240226f, 0.22695377f, -0.23325501f, 0.10921840f, 0.07545060f, -0.10986291f, 
    0.08711958f, -0.15267932f, -0.02796743f, -0.44107285f, -0.27117217f, 0.21673706f, 0.26470315f, 0.06451352f, 
    -0.06347588f, 0.03950323f, -0.09160448f, 0.19432330f, -0.01666947f, -0.12718162f, 0.02432343f, -0.00974890f, 
    0.01995414f, -0.17021133f, 0.00481045f, 0.24799852f, -0.10018805f, -0.25360072f, -0.01558180f, 0.06846217f, 
    0.17941627f, -0.00008143f, -0.03851473f, -0.10344573f, 0.12583013f, 0.09831744f, -0.29552287f, 0.02809066f, 
    -0.03579519f, -0.14131851f, 0.04086633f, -0.09923770f, 0.03960928f, -0.05660086f, -0.16505219f, -0.06481030f, 
    -0.12368105f, -0.03143729f, 0.24293485f, -0.04888671f, 0.19722907f, 0.15070790f, 0.08728588f, -0.00795365f, 
    -0.06817697f, -0.04109527f, -0.15806133f, -0.00174099f, -0.19528441f, -0.02130394f, -0.13890694f, 0.04728715f, 
    0.13834347f, -0.14542352f, -0.00504846f, 0.20969698f, 0.16658647f, 0.00943701f, 0.08341292f, -0.00172919f, 
    -0.15974247f, 0.05538985f, -0.08075868f, 0.19774759f, -0.06038962f, 0.19576137f, -0.17279936f, 0.00624976f, 
    0.17216881f, 0.14222385f, 0.05120687f, -0.07295349f, -0.12709326f, 0.30249944f, -0.19333231f, -0.04480526f, 
    0.07388362f, 0.12901142f, 0.21994491f, 0.22358379f, -0.43688449f, -0.08861499f, 0.36385810f, 0.13122718f, 
    -0.03095866f, 0.36149153f, 0.04192284f, -0.12122057f, 0.04162871f, 0.22786687f, -0.12604658f, -0.05500190f, 
    0.04826676f, -0.14519119f, -0.08317128f, 0.21163525f, -0.23129150f, -0.06001697f, 0.05225026f, 0.32709724f, 
    0.06011521f, -0.08493233f, -0.04448983f, -0.30053136f, -0.02970596f, -0.07110875f, 0.05612667f, 0.14613178f, 
    0.25619519f, 0.03987314f, 0.00957174f, 0.01936030f, -0.17835486f, -0.00670571f, -0.09377959f, 0.21504475f, 
    0.02415983f, -0.01659861f, -0.04270704f, -0.02250435f, -0.02915588f, 0.04329109f, 0.01893343f, -0.03970133f, 
    -0.01973663f, 0.05100507f, -0.05744253f, 0.04850360f, 0.03235544f, -0.04874305f, -0.02024538f, -0.04971363f, 
    0.03765827f, -0.01535632f, 0.02670038f, 0.01037759f, -0.03049778f, 0.02803595f, -0.05367769f, -0.05012383f, 
    -0.00658213f, -0.02984243f, -0.02512887f, 0.00152062f, 0.02015496f, -0.00569900f, 0.00787099f, -0.05569185f, 
    -0.01039414f, 0.00828585f, -0.03241841f, -0.05277429f, -0.03870733f, -0.00987535f, -0.02225970f, -0.05922542f, 
    0.01266038f, 0.03865713f, 0.04052088f, -0.02472692f, -0.04181737f, -0.02895693f, 0.00901333f, -0.00467739f, 
    -0.05252048f, -0.06433681f, 0.02205055f, 0.01190468f, -0.05911785f, 0.05183025f, 0.01974873f, 0.04559103f, 
    0.05459866f, 0.00825449f, -0.02472075f, 0.00198791f, 0.02536393f, 0.03467204f, -0.05503968f, -0.01675480f, 
    0.03270406f, -0.03081124f, -0.06115037f, -0.00504947f, -0.03296361f, -0.00170361f, -0.02624368f, -0.02610209f, 
    -0.06434758f, 0.04748388f, 0.05362525f, -0.04537062f, 0.02381761f, 0.02669660f, 0.03999161f, 0.00071029f, 
    0.03324017f, 0.04377861f, -0.02462698f, 0.02382323f, 0.04326107f, -0.05858456f, 0.01502340f, 0.01432647f, 
    0.01909007f, -0.00247809f, 0.02019054f, 0.02492672f, -0.00088829f, -0.01543548f, 0.04794713f, -0.05511354f, 
    -0.01291816f, -0.05403978f, -0.01930764f, 0.03887686f, 0.01036772f, 0.02213855f, -0.05292388f, -0.03446098f, 
    0.02108329f, 0.03674579f, -0.00375866f, -0.01928505f, 0.03039287f, -0.00529004f, -0.00054006f, -0.03853127f, 
    -0.02821421f, 0.04059270f, -0.02438689f, -0.01105692f, -0.04884882f, 0.02382311f, -0.01468416f, -0.01967388f, 
    -0.05826437f, -0.02541161f, 0.02388171f, 0.02005623f, 0.00326095f, -0.05723344f, -0.00455876f, 0.02983355f, 
    0.01029559f, -0.03323758f, 0.00091042f, 0.03989627f, 0.00291932f, -0.03375929f, -0.04859625f, 0.02494673f, 
    -0.01020829f, -0.04107425f, -0.00152461f, -0.05873502f, 0.03263604f, 0.00445489f, -0.01990566f, -0.01894034f, 
    0.03250298f, -0.02940514f, -0.00191841f, 0.00415403f, -0.01890274f, -0.01362473f, 0.03566789f, -0.05657686f, 
    0.02141818f, 0.04145502f, -0.02179755f, -0.03102158f, 0.03439118f, 0.04835064f, -0.05844675f, -0.05282532f, 
    0.03986709f, -0.04761464f, -0.03855637f, -0.04916550f, -0.02440260f, 0.02497503f, -0.02024196f, -0.05679999f, 
    -0.03273251f, 0.04590386f, 0.00028215f, -0.04482370f, -0.05177570f, 0.02563312f, 0.01549166f, 0.02190466f, 
    0.00973755f, -0.00652420f, -0.05847191f, 0.03900402f, -0.00958138f, 0.00050798f, -0.04987486f, 0.00179900f, 
    0.00875557f, 0.00113274f, 0.02289127f, -0.02929686f, 0.01012927f, -0.01051497f, -0.05484574f, -0.03709282f, 
    0.00054127f, -0.05282436f, 0.03946939f, -0.03134392f, 0.03766210f, 0.01644733f, -0.00022053f, 0.05058264f, 
    0.02695405f, 0.02944551f, 0.01224694f, 0.05603128f, 0.01462633f, 0.01430954f, 0.01400455f, 0.00263275f, 
    -0.01808652f, -0.05918634f, -0.00035951f, 0.00590627f, -0.04434815f, 0.03775255f, 0.04010470f, -0.04352278f, 
    0.02477318f, -0.04955172f, 0.00367993f, -0.01810874f, -0.00723647f, 0.02907459f, -0.06069060f, -0.02524895f, 
    -0.02417998f, -0.01034530f, 0.04707213f, -0.04007738f, 0.01398918f, -0.04329399f, 0.01072122f, -0.02984156f, 
    -0.00918055f, 0.04432118f, -0.02646585f, -0.05189836f, 0.03327121f, -0.02220711f, 0.00124732f, 0.01451918f, 
    0.05593986f, 0.01012651f, -0.05425067f, -0.05609027f, -0.01030682f, 0.03380571f, -0.02593151f, -0.04482035f, 
    -0.03133826f, -0.04388511f, 0.01275257f, -0.03418893f, -0.00660220f, -0.06590052f, 0.04952431f, 0.02740508f, 
    0.04149345f, -0.00507358f, 0.02858334f, -0.05688263f, -0.00607323f, 0.03128073f, -0.01724115f, 0.04880030f, 
    0.00381373f, -0.03004207f, 0.04908935f, -0.01174210f, 0.01633824f, 0.01005700f, 0.05311883f, -0.01438104f, 
    -0.05545072f, -0.06117544f, 0.01629229f, 0.02737816f, -0.00125204f, 0.00275803f, 0.03852863f, -0.04076766f, 
    0.00300756f, 0.03081855f, -0.05076884f, 0.00761459f, -0.01714894f, 0.02455537f, 0.01468487f, -0.02853415f, 
    -0.04555671f, 0.03904452f, 0.03835734f, -0.04655377f, -0.00074487f, -0.06122024f, -0.04352373f, -0.04224967f, 
    0.02363674f, -0.02861625f, 0.01901574f, 0.02868424f, -0.05754427f, 0.01014349f, 0.01740880f, 0.04976591f, 
    -0.02836540f, -0.05070483f, -0.00867862f, 0.02538372f, -0.02805740f, 0.04575421f, -0.02613850f, -0.04352126f, 
    -0.05443233f, -0.00601589f, -0.02094717f, -0.03987051f, -0.06358172f, 0.03936504f, 0.03086535f, 0.02903637f, 
    0.00173416f, 0.03913291f, -0.05611765f, -0.04472692f, 0.01000813f, 0.03498057f, -0.00257750f, -0.05879772f, 
    -0.01942728f, -0.06516583f, -0.01341203f, 0.01296683f, -0.04921657f, -0.01057196f, -0.02511922f, -0.01859880f, 
    -0.04775491f, 0.00636355f, -0.04056388f, -0.06960198f, -0.00265933f, -0.01541520f, 0.04839057f, 0.02789500f, 
    0.03935848f, 0.03828690f, 0.03125612f, -0.06009774f, 0.03448952f, 0.03813755f, -0.02393387f, -0.03722048f, 
    -0.03137093f, -0.02007643f, -0.06389259f, 0.02844178f, -0.05484988f, -0.06587666f, -0.05217052f, 0.01285070f, 
    -0.01887694f, -0.04050789f, 0.02054224f, -0.02146345f, 0.03767757f, -0.03774218f, 0.04600313f, -0.05213401f, 
    -0.06759019f, 0.02112515f, -0.00742942f, 0.04309459f, -0.02749660f, 0.02644146f, 0.00790518f, 0.03629850f, 
    0.03911906f, -0.00522581f, -0.02201998f, -0.00205881f, -0.03311455f, 0.01802291f, -0.04265862f, -0.01622470f, 
    0.00667886f, 0.03266124f, 0.00331576f, -0.03130239f, -0.01188261f, 0.00566122f, -0.00198430f, -0.03537031f, 
    0.00986449f, 0.00491558f, 0.03680142f, 0.04901672f, -0.04119804f, 0.04003002f, -0.03262124f, 0.01567936f, 
    -0.05655222f, 0.02647391f, -0.00599493f, -0.00768581f, -0.01633623f, 0.04610743f, 0.04043994f, -0.05963216f, 
    0.02862033f, 0.02422605f, 0.04826460f, -0.05120021f, -0.03673769f, 0.01178135f, -0.02517032f, -0.06986512f, 
    0.04441511f, -0.02656415f, 0.03482212f, 0.00862218f, -0.05120140f, -0.02859360f, 0.02644777f, -0.04831128f, 
    -0.06735121f, 0.01123788f, 0.03694278f, 0.02758322f, 0.03464166f, -0.03195054f, -0.03668207f, 0.04688472f, 
    0.02997616f, 0.01142479f, -0.02954001f, -0.01426024f, 0.02448406f, -0.03710556f, -0.01543712f, -0.02779090f, 
    0.03546394f, -0.04249151f, -0.04560722f, -0.00374611f, -0.05233480f, -0.02721105f, -0.00995261f, 0.05148743f, 
    0.05281800f, -0.04916612f, -0.02731661f, -0.02136546f, -0.06780759f, -0.02064027f, -0.02027904f, 0.04459148f, 
    -0.01679831f, -0.06010921f, -0.03686047f, -0.00088319f, -0.03015454f, 0.02403633f, 0.00078429f, -0.00323117f, 
    -0.05478208f, 0.04118758f, 0.01125242f, -0.04657400f, 0.04856104f, 0.02071964f, 0.03958075f, 0.04990085f, 
    0.00917578f, -0.05794406f, -0.05197313f, -0.02200996f, -0.01449518f, -0.02309884f, 0.01888841f, -0.06211146f, 
    -0.05575228f, 0.05380561f, -0.01709984f, -0.04363171f, -0.05359996f, 0.03590904f, 0.03842842f, 0.03962719f, 
    0.01842106f, -0.04139930f, -0.04549995f, -0.02014832f, 0.01080972f, -0.05808214f, -0.02016854f, 0.00263603f, 
    0.02822436f, 0.04527769f, 0.03800387f, 0.03902603f, -0.05131845f, -0.05589161f, -0.06904187f, -0.03799764f, 
    -0.02203374f, 0.01598956f, -0.01635077f, 0.02192735f, 0.03144518f, 0.00198656f, 0.03585653f, -0.06622466f, 
    0.04544310f, -0.01122719f, 0.03887410f, -0.03689224f, 0.01957869f, -0.03146291f, -0.04027232f, 0.03406253f, 
    0.02738497f, -0.03939322f, -0.05720815f, 0.02569238f, 0.01832412f, 0.01052819f, 0.02344647f, 0.01997496f, 
    -0.04807664f, 0.00638261f, 0.01648412f, 0.03842812f, -0.04418259f, 0.03910653f, -0.01185802f, -0.00435670f, 
    -0.06048162f, -0.00147294f, -0.06168096f, 0.04435240f, -0.00637172f, 0.02668741f, -0.05918302f, 0.04510758f, 
    0.02090986f, -0.02301396f, 0.01254447f, -0.03265996f, 0.04000041f, -0.01537120f, -0.02454425f, -0.02798393f, 
    0.02845375f, -0.04620975f, 0.00292367f, -0.06587391f, -0.02447904f, 0.00746243f, -0.02285558f, -0.00539841f, 
    0.00710763f, 0.04700975f, -0.02937979f, 0.04717215f, 0.00271109f, 0.05057836f, 0.04274228f, 0.04496337f, 
    -0.05090732f, -0.00235039f, -0.06310588f, -0.01630627f, -0.04517348f, -0.01810551f, 0.03960197f, 0.02665400f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.15935203f, -0.00978887f, -0.00774526f, 0.01634103f, -0.00796828f, 0.08826472f, -0.01760799f, -0.02995713f, 
    -0.03384495f, -0.02226589f, -0.05072781f, 0.09481196f, 0.17486890f, -0.00681671f, -0.02736855f, 0.00119451f, 
    -0.09379986f, -0.05192328f, -0.06432239f, 0.05473718f, -0.06311180f, -0.05945726f, 0.02719945f, -0.06738256f, 
    0.06395928f, 0.11548107f, -0.00766864f, 0.08999396f, 0.05017078f, 0.13995397f, -0.04093967f, -0.04277651f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17179690f, 0.04679382f, 0.10423405f, 0.16009401f, -0.00132510f, -0.04170886f, 0.16934885f, -0.15058812f, 
    0.01885861f, -0.15231131f, -0.05800599f, 0.04039515f, -0.19169737f, -0.00915729f, 0.07791934f, 0.13339704f, 
    0.45538202f, -0.04384822f, 0.02497795f, -0.33524981f, 0.00048020f, -0.05483935f, -0.00507514f, 0.10191718f, 
    0.12240875f, 0.10386515f, -0.05927898f, 0.53498626f, -0.25777715f, 0.52367133f, -0.07744964f, -0.12091610f, 
    -0.12844308f, -0.04955883f, 0.12666053f, -0.17957899f, -0.11531190f, -0.04681513f, 0.09800731f, -0.02572129f, 
    0.07263182f, -0.06088023f, 0.07514765f, -0.03547953f, 0.07918701f, -0.12269477f, -0.04255370f, 0.03736169f, 
    -0.06446758f, 0.05126572f, 0.06176835f, 0.00201429f, 0.03237409f, 0.14187935f, -0.18477768f, -0.10868169f, 
    -0.09154111f, 0.02550400f, -0.11200640f, -0.17190565f, 0.01078951f, -0.04615758f, 0.16582359f, 0.02064144f, 
    0.10504604f, -0.02285147f, 0.13188308f, 0.00737245f, -0.00913487f, 0.08840168f, 0.09048760f, -0.08292584f, 
    -0.07511171f, 0.11732230f, -0.09808417f, -0.17367570f, -0.07936227f, 0.12538834f, 0.02954468f, 0.02725648f, 
    -0.15888615f, 0.17417274f, -0.16451921f, 0.11823386f, 0.03002017f, -0.14600672f, -0.12009455f, -0.08961511f, 
    0.13119845f, -0.20013918f, -0.04982474f, -0.16290364f, 0.00892896f, -0.10610733f, 0.12250644f, -0.15769811f, 
    -0.03894509f, -0.04431392f, -0.16582571f, 0.03085101f, 0.06188510f, 0.11155556f, 0.16223255f, -0.08238135f, 
    0.02574857f, 0.09807044f, 0.14137810f, -0.04657160f, -0.22581054f, 0.13656212f, 0.31024221f, 0.10542226f, 
    0.00533236f, -0.07650997f, -0.03455159f, 0.13904409f, 0.13891871f, -0.10393830f, -0.14562389f, -0.03244015f, 
    0.13119000f, 0.13445993f, -0.00165427f, 0.05381700f, 0.47651464f, 0.15540288f, -0.10985912f, -0.07368234f, 
    0.47881767f, 0.09433893f, 0.06995774f, 0.02070074f, 0.03882888f, -0.40006047f, -0.15040430f, 0.41326675f, 
    -0.02685249f, -0.09759573f, 0.06104575f, -0.03541170f, -0.12968360f, 0.12575029f, -0.27107441f, -0.08873107f, 
    0.37745112f, 0.06588441f, 0.15300663f, 0.03451923f, -0.13699591f, -0.16501917f, -0.00146234f, -0.15645011f, 
    0.15977332f, -0.01413202f, 0.08843861f, -0.21899185f, 0.10735457f, 0.17459024f, -0.00868553f, -0.07496589f, 
    0.33346304f, -0.11523950f, 0.13153082f, 0.00539309f, 0.17885138f, 0.20251806f, -0.09722610f, 0.21978647f, 
    -0.11476847f, 0.04865406f, 0.04915215f, -0.31282640f, -0.19671944f, 0.04897140f, -0.09660223f, 0.14736976f, 
    0.52470547f, -0.11319511f, -0.13522853f, -0.32973009f, 0.13367425f, -0.01568378f, -0.33321491f, 0.09463809f, 
    0.18067805f, 0.27413005f, -0.11034538f, -0.15007176f, 0.41699260f, 0.23858070f, 0.04857178f, 0.00188476f, 
    0.41739729f, 0.11377358f, 0.07384363f, 0.00261591f, 0.08099208f, -0.55967748f, 0.09167632f, -0.08673333f, 
    -0.02589187f, 0.01367657f, -0.07725271f, 0.34030458f, 0.50444895f, 0.01023720f, 0.14699833f, -0.00952353f, 
    0.10619995f, -0.13427325f, -0.03171643f, 0.11112664f, -0.06179470f, -0.08159592f, -0.17160672f, 0.13526115f, 
    0.37812629f, 0.11271784f, -0.11309592f, -0.23276217f, 0.26067147f, -0.18547709f, 0.17496561f, 0.07832086f, 
    0.44390285f, 0.08549313f, 0.10490074f, 0.03815933f, -0.02327223f, 0.12873437f, 0.10480290f, 0.10119841f, 
    -0.17725335f, 0.03199405f, -0.14666358f, -0.55906069f, 0.11786797f, -0.08259749f, 0.03709471f, -0.09280445f, 
    -0.34614781f, 0.03570840f, 0.17563689f, -0.08875199f, 0.16951334f, 0.00685780f, -0.09413468f, 0.06000895f, 
    -0.09941051f, 0.47695854f, 0.05767601f, -0.09463812f, 0.04722334f, -0.15366824f, -0.10070238f, -0.13193834f, 
    0.20031483f, -0.08736061f, 0.05359024f, 0.10965611f, -0.07393716f, 0.09129683f, -0.09086779f, -0.16227476f, 
    -0.07228874f, 0.09688434f, -0.13126540f, 0.31180134f, -0.37844074f, 0.10617425f, 0.22044432f, 0.15540315f, 
    0.16634898f, 0.06594700f, 0.14070114f, 0.06301854f, -0.11600602f, 0.18088797f, -0.27391669f, 0.05355716f, 
    -0.10747071f, 0.14025038f, -0.05779538f, -0.09215903f, 0.74588388f, 0.05094770f, -0.15856653f, -0.08061519f, 
    0.07249621f, -0.09740921f, -0.15794784f, 0.06350067f, -0.02778584f, 0.20930849f, -0.13406835f, 0.35460579f, 
    -0.13901420f, 0.03138423f, 0.14987449f, -0.09547909f, -0.00485614f, -0.03252330f, -0.03583204f, 0.07097969f, 
    0.13006440f, -0.06484278f, -0.06449727f, -0.46667030f, -0.00633685f, 0.14877404f, -0.12168712f, 0.06958453f, 
    0.54313344f, 0.01301510f, 0.07825225f, -0.11692517f, -0.30813822f, 0.39296356f, -0.01112982f, 0.15996256f, 
    0.48374423f, 0.09344203f, -0.16723269f, -0.17578287f, -0.13949835f, -0.29263520f, 0.13064271f, 0.18315212f, 
    -0.12407208f, 0.17401361f, 0.08668290f, 0.19943483f, 0.46007821f, -0.02899482f, -0.76417357f, -0.14646502f, 
    0.61358380f, -0.05645999f, 0.07876144f, -0.06397440f, 0.00160906f, -0.08710366f, 0.09027824f, -0.07685720f, 
    0.03533173f, 0.09606659f, -0.02565059f, -0.30874845f, 0.04670373f, -0.01132649f, -0.00250488f, -0.00732825f, 
    0.15136969f, 0.04007651f, 0.16845275f, -0.02564876f, 0.12396519f, -0.08045328f, 0.13120654f, -0.08233425f, 
    0.09482221f, -0.07693300f, 0.03415098f, -0.49672544f, -0.01152840f, 0.14074764f, 0.14183873f, 0.14110909f, 
    0.18474185f, 0.16260535f, -0.15929905f, 0.28371036f, -0.07068913f, 0.03391473f, -0.03137680f, 0.10119460f, 
    -0.35983601f, 0.26721871f, -0.06567033f, 0.29120609f, 0.17142490f, 0.00087369f, -0.03959241f, -0.06871811f, 
    0.25933698f, -0.06750241f, 0.11317007f, 0.15653864f, -0.01952141f, 0.01512953f, -0.05861500f, -0.26202476f, 
    0.05695952f, -0.15396996f, -0.00621466f, -0.20882082f, 0.06450737f, 0.00366509f, 0.11119910f, -0.10535569f, 
    -0.77495545f, -0.05145414f, -0.08999050f, 0.05092803f, 0.11015165f, -0.16342698f, -0.06757935f, -0.06912431f, 
    0.30330062f, 0.06187157f, 0.16442645f, 0.37750807f, 0.21591115f, -0.34679514f, -0.02132826f, -0.17018987f, 
    0.16073534f, 0.13320364f, -0.17628349f, -0.12323964f, 0.10732865f, 0.07921853f, -0.03427394f, -0.10781708f, 
    -0.17103237f, 0.06314658f, -0.12190251f, -0.15818964f, 0.10940778f, 0.17468642f, -0.19747928f, 0.10484749f, 
    -0.11652745f, -0.14721525f, -0.07743111f, 0.00491961f, 0.00210909f, -0.01137505f, -0.11937223f, 0.12020405f, 
    0.05654637f, -0.09815722f, -0.05851778f, -0.17665730f, -0.09149881f, -0.19970611f, 0.00354697f, 0.04258477f, 
    0.03066872f, 0.07374951f, -0.10829571f, -0.07950407f, -0.14007832f, -0.07593226f, -0.07479545f, -0.06931960f, 
    0.05567425f, 0.16564474f, -0.04727570f, -0.20255364f, 0.08882780f, -0.01790033f, -0.10650561f, 0.14053439f, 
    -0.04940587f, 0.15046772f, -0.08706618f, -0.09101693f, -0.06765560f, -0.01016045f, -0.23096552f, -0.03903193f, 
    -0.12034988f, -0.07330877f, 0.06577939f, 0.04489591f, -0.05599188f, -0.03654173f, -0.12142811f, -0.06704836f, 
    -0.09295063f, 0.15556227f, 0.14393257f, 0.11747062f, -0.14856519f, -0.11364302f, 0.23096068f, 0.00509845f, 
    -0.10540727f, -0.13214691f, -0.00807304f, 0.46265534f, -0.14858477f, -0.15022032f, 0.04889211f, 0.02767259f, 
    -0.03071509f, -0.08590204f, 0.12603836f, -0.19057517f, -0.13133518f, -0.14641309f, -0.26077303f, -0.16152558f, 
    0.01171186f, 0.29580310f, 0.07844435f, -0.22999421f, 0.00434896f, -0.15002485f, -0.07005799f, 0.03823292f, 
    -0.01514102f, 0.02460780f, 0.17297272f, -0.05779218f, 0.15831861f, -0.10507643f, 0.12634285f, -0.08404338f, 
    0.09545007f, 0.00707547f, -0.08043819f, -0.17652166f, -0.03312367f, 0.04934519f, -0.14159320f, -0.01240574f, 
    -0.06761421f, -0.09711694f, -0.15769665f, -0.15011469f, -0.00795518f, 0.03967001f, 0.01816611f, -0.06162478f, 
    -0.14679895f, -0.00406844f, -0.14079934f, 0.08537801f, 0.07321875f, -0.13320369f, -0.01974807f, -0.13560764f, 
    0.00521883f, -0.02390791f, 0.14854552f, -0.10737281f, -0.14658254f, -0.43373418f, -0.04039092f, 0.05081380f, 
    -0.16232231f, 0.17462106f, -0.03120258f, -0.16425502f, -0.00544548f, 0.08526605f, 0.36032948f, 0.05723904f, 
    -0.10610577f, -0.04123053f, -0.00401434f, -0.00265047f, 0.05807916f, 0.06630943f, 0.07154484f, 0.01562637f, 
    0.33068442f, -0.03668791f, -0.05111115f, 0.10007333f, 0.44403625f, 0.12906827f, 0.01302521f, 0.02510120f, 
    0.33229330f, 0.15213051f, -0.08459260f, 0.13587925f, -0.06348558f, -0.49897707f, -0.12822784f, 0.42790502f, 
    0.09771398f, 0.16152628f, 0.05364507f, -0.15183713f, 0.13376483f, 0.13582645f, -0.10850746f, 0.01206365f, 
    -0.25963283f, -0.04323583f, -0.17241049f, 0.28239208f, -0.02261457f, 0.17887500f, 0.12170272f, 0.05055190f, 
    0.32030988f, 0.10661155f, -0.14885062f, -0.35335442f, 0.37518555f, -0.08583033f, -0.01566368f, -0.08153251f, 
    -0.27461132f, 0.04420567f, -0.00632577f, -0.01158766f, 0.14453353f, 0.05588616f, -0.03187690f, 0.31043464f, 
    -0.00552304f, -0.05459220f, -0.00364743f, 0.46564412f, -0.19199657f, 0.13954172f, 0.39594626f, -0.15942974f, 
    -0.16927314f, -0.10916541f, 0.09732348f, 0.33862841f, -0.03970160f, -0.10671435f, 0.49885485f, 0.10078818f, 
    0.24701998f, -0.33347368f, 0.04049533f, -0.03355932f, 0.04056184f, -0.03684635f, -0.00701973f, -0.13985494f, 
    0.04557036f, 0.11192095f, 0.13044330f, 0.15611741f, -0.02157038f, -0.07781794f, -0.01655850f, 0.29513645f, 
    0.03277058f, 0.00270639f, -0.08862616f, -0.02667279f, -0.33667082f, 0.06752301f, -0.12954421f, 0.16342755f, 
    -0.27501473f, -0.02801296f, 0.09251963f, -0.13479221f, 0.14231615f, -0.05640861f, -0.18660779f, 0.18359807f, 
    0.10794156f, -0.19629882f, 0.15335476f, 0.19039965f, -0.22418487f, 0.14892043f, 0.13232352f, 0.03775646f, 
    -0.02084228f, -0.04189998f, 0.03695594f, -0.02079652f, -0.08036715f, -0.08706407f, -0.16252512f, -0.22447231f, 
    -0.17525814f, -0.11654855f, 0.08098145f, 0.05446562f, 0.01048713f, -0.03909480f, -0.09233932f, 0.01081213f, 
    -0.08617406f, 0.06382246f, -0.07133172f, -0.15946497f, -0.07398361f, 0.05532948f, 0.12351386f, 0.16857968f, 
    0.05038419f, -0.01056792f, 0.12680517f, 0.00436595f, -0.15566589f, -0.00976299f, 0.00247470f, 0.11799532f, 
    0.28548312f, -0.01199230f, -0.13303357f, -0.08764819f, 0.14799383f, -0.21481684f, -0.04695296f, 0.48764881f, 
    -0.04466949f, -0.17609067f, -0.16143104f, -0.20706946f, 0.31863692f, -0.06360005f, -0.24029438f, -0.05572745f, 
    -0.48567823f, -0.13676272f, -0.09459469f, 0.26401621f, 0.05615191f, -0.01799786f, 0.39463609f, -0.04208510f, 
    0.30909258f, -0.17155769f, 0.10681009f, 0.11283614f, -0.30013016f, -0.21329480f, -0.07015591f, 0.14408630f, 
    0.09122439f, -0.13394333f, -0.04762857f, 0.06846302f, 0.12116016f, -0.34876245f, 0.02789235f, 0.04909610f, 
    -0.16540456f, -0.00322147f, -0.10554849f, -0.17557232f, 0.33407879f, 0.09679519f, 0.42566916f, 0.08067664f, 
    0.03459646f, 0.13419832f, -0.13367094f, 0.22876810f, 0.15675016f, -0.14720201f, 0.15437958f, 0.04347462f, 
    -0.41685125f, -0.15907116f, -0.07800476f, -0.02295052f, -0.17421678f, -0.25413120f, -0.01794747f, -0.15383175f, 
    -0.01412151f, 0.16177167f, -0.01903498f, -0.00024124f, -0.06991690f, -0.15741125f, 0.01477480f, 0.07250421f, 
    -0.16163898f, 0.15952189f, -0.02520546f, -0.16187955f, -0.08978344f, 0.14816083f, 0.07303712f, -0.05496880f, 
    -0.46722043f, 0.09104380f, -0.15100996f, 0.09858984f, 0.12763722f, 0.16643606f, -0.15716776f, -0.14564876f, 
    0.34483513f, 0.27266496f, 0.07574742f, -0.21438950f, -0.20381574f, 0.19434170f, 0.03025921f, -0.07372020f, 
    0.18150145f, 0.12733684f, -0.13914736f, 0.13270836f, -0.10361747f, -0.17316140f, 0.05457200f, -0.03907511f, 
    0.16294460f, -0.14787303f, 0.13890718f, -0.30766520f, -0.10702523f, -0.11374643f, -0.17763469f, 0.07264491f, 
    0.44154519f, 0.12994306f, 0.08392848f, 0.01428896f, -0.10912244f, -0.06318409f, -0.00548230f, 0.13824736f, 
    0.31231618f, 0.18207756f, -0.10216013f, 0.04252975f, 0.61239433f, 0.01715121f, -0.05922647f, 0.15755697f, 
    -0.30949417f, -0.00492302f, 0.02064246f, -0.03260362f, 0.12724809f, 0.00249065f, 0.02373876f, -0.00161809f, 
    -0.02020008f, 0.03669515f, 0.05769093f, -0.12735252f, 0.21145646f, -0.06178993f, -0.44012034f, 0.06535239f, 
    0.33359617f, -0.18133058f, 0.08933815f, 0.41204357f, 0.13887310f, 0.03909343f, -0.50815588f, 0.13863999f, 
    0.32595533f, 0.24926852f, 0.06577366f, 0.10246884f, 0.23454176f, 0.09453897f, -0.03700931f, 0.05359468f, 
    -0.07299568f, -0.00757135f, 0.03672071f, 0.07411408f, 0.02564513f, 0.07639036f, 0.08919939f, 0.09731074f, 
    0.03634808f, -0.09739084f, 0.04522162f, -0.15232775f, 0.06589957f, -0.10270485f, -0.12445807f, 0.09489790f, 
    -0.17266539f, 0.05107258f, 0.05070198f, -0.09321639f, 0.00259325f, -0.12925719f, -0.11170521f, 0.18098848f, 
    -0.17148717f, -0.10798070f, -0.12690738f, 0.02471225f, -0.07763608f, 0.05561341f, 0.06934498f, -0.11043506f, 
    0.04976169f, -0.16289881f, 0.08253329f, -0.12445104f, -0.09733731f, 0.34181416f, 0.23521520f, 0.46680418f, 
    0.05088026f, 0.01259919f, 0.11004382f, 0.33200619f, -0.41775718f, 0.07650972f, 0.04683792f, -0.16998456f, 
    0.22662422f, -0.08357798f, -0.02508979f, -0.15424195f, -0.09614331f, -0.08169580f, 0.15276377f, -0.05837716f, 
    -0.18077908f, -0.16787355f, 0.13872197f, -0.08957131f, -0.32603768f, 0.25533554f, -0.09872362f, -0.15567750f, 
    -0.02990529f, -0.00652293f, -0.04768556f, 0.00437558f, -0.08600322f, -0.20937823f, 0.03585293f, 0.09248225f, 
    -0.01757594f, -0.05668579f, 0.05032863f, 0.49268144f, -0.06676637f, -0.11294420f, -0.07370388f, 0.08663473f, 
    -0.28250253f, 0.02784614f, 0.16196427f, 0.38846841f, 0.15596819f, 0.12673353f, 0.07190169f, 0.11490054f, 
    -0.19735378f, 0.03388563f, 0.16842330f, -0.24466746f, 0.74546504f, 0.12589660f, 0.03700968f, -0.06533247f, 
    -0.08876948f, -0.04292807f, -0.10363398f, 0.10739854f, 0.08070325f, 0.73272651f, -0.08429788f, 0.08638502f, 
    0.12330754f, -0.17973921f, -0.00753274f, 0.08318487f, -0.23571774f, 0.07276736f, -0.01552895f, 0.07557140f, 
    -0.21345162f, 0.04376493f, 0.12848762f, -0.17932937f, -0.00413326f, 0.08504128f, 0.07956418f, -0.08262528f, 
    0.06905549f, -0.16049863f, 0.13989858f, 0.21310684f, 0.23419829f, 0.46764004f, 0.11004353f, 0.06584780f, 
    0.27594256f, -0.12292968f, 0.05768889f, -0.02702047f, -0.14295159f, -0.07204892f, 0.08094544f, -0.24046345f, 
    -0.08898139f, -0.02184627f, 0.10558810f, 0.40701282f, 0.11347751f, -0.12350580f, 0.07702460f, -0.14410709f, 
    -0.26911619f, -0.07807520f, 0.03585916f, -0.42450806f, 0.01139598f, -0.06146905f, -0.05703584f, -0.00328826f, 
    0.27283734f, 0.13950230f, 0.01862614f, 0.10596718f, 0.25851393f, 0.43378159f, -0.07191337f, 0.15434757f, 
    0.02611017f, -0.02040582f, -0.17595844f, 0.13874261f, -0.08092060f, -0.14885724f, -0.05022310f, -0.12850936f, 
    -0.13885993f, -0.04617764f, 0.07532181f, 0.05173947f, 0.04172340f, -0.14869246f, 0.02591113f, 0.12609489f, 
    -0.00428477f, 0.02907970f, -0.16670549f, -0.15823118f, 0.11371681f, -0.10092659f, -0.05478439f, 0.13405252f, 
    0.07746537f, -0.13380736f, -0.12672730f, -0.09476759f, -0.10578091f, -0.13461986f, 0.15102795f, -0.08767577f, 
    0.33707741f, 0.01721581f, 0.06464125f, 0.00578997f, -0.12077776f, -0.14361367f, -0.04894185f, -0.12287355f, 
    0.03370709f, -0.00373968f, -0.00613320f, -0.31937358f, -0.61010581f, -0.16639352f, 0.35592806f, 0.00460262f, 
    0.11327248f, -0.11465175f, -0.05671046f, 0.00647595f, 0.16026539f, 0.15072700f, 0.15798238f, -0.07722092f, 
    -0.25564787f, 0.43222442f, -0.17172445f, -0.06973474f, -0.05042949f, 0.19347103f, -0.12357728f, -0.06473240f, 
    0.20685978f, 0.07409321f, 0.16608308f, 0.10212892f, -0.05782305f, 0.12309888f, -0.10446983f, 0.17323317f, 
    0.04122168f, 0.03893562f, -0.06517599f, -0.07016985f, -0.21049276f, 0.16263522f, 0.12252575f, 0.05620592f, 
    0.37355080f, -0.00840801f, -0.01270536f, -0.11493148f, 0.06736124f, 0.14882846f, 0.05792974f, -0.02503738f, 
    0.18398671f, -0.30722696f, 0.12134530f, -0.35408598f, -0.02155865f, -0.23415516f, -0.17276785f, 0.07662377f, 
    -0.33563399f, -0.05615080f, -0.10539969f, 0.13464317f, -0.00890545f, 0.12846075f, -0.08544918f, -0.12813365f, 
    0.14235222f, 0.08322874f, -0.05396687f, 0.32581884f, 0.00674676f, -0.11317667f, 0.04841956f, 0.11958872f, 
    0.42670709f, 0.07331990f, 0.02414440f, 0.44344893f, -0.14657168f, 0.08810741f, 0.29096535f, 0.09151276f, 
    -0.51462179f, 0.17065302f, 0.07191679f, 0.25084350f, -0.19527858f, 0.24482337f, -0.01434232f, -0.03660082f, 
    0.39558467f, -0.04932431f, -0.10481865f, -0.17096578f, -0.05127725f, 0.03841437f, 0.14190197f, 0.16201861f, 
    -0.00148357f, -0.13004376f, -0.15220213f, 0.24970414f, 0.15920192f, -0.10276618f, -0.45389858f, -0.15766738f, 
    -0.06084178f, 0.02045886f, -0.15530220f, 0.07894478f, -0.06089269f, 0.09576712f, 0.29932794f, 0.00614130f, 
    -0.16478211f, -0.15387489f, -0.17997332f, -0.18842222f, -0.43371788f, 0.09290008f, -0.10125596f, 0.14753650f, 
    0.34691167f, -0.08987427f, -0.12320228f, 0.05154996f, 0.13665701f, -0.47468811f, 0.11614309f, -0.04237072f, 
    -0.06648330f, 0.00633943f, -0.03019916f, 0.38230905f, 0.39044857f, -0.16736436f, -0.10787167f, 0.07743479f, 
    0.11021152f, 0.15116325f, -0.15544899f, 0.47841617f, 0.13388991f, 0.17010896f, -0.35396031f, 0.07635950f, 
    -0.26210055f, 0.22573219f, -0.09800252f, -0.15706156f, 0.51192719f, 0.03856121f, -0.00141194f, 0.06993014f, 
    -0.11292772f, -0.15164798f, -0.12158719f, -0.18086593f, 0.12228699f, 0.25643662f, -0.04256122f, 0.09422921f, 
    -0.03121960f, 0.08767948f, -0.01976778f, 0.19754811f, -0.09055563f, 0.12793645f, -0.00194841f, 0.10091309f, 
    -0.53648829f, 0.05716236f, -0.00487925f, -0.18221679f, 0.04436345f, 0.04356914f, 0.24046712f, 0.17984043f, 
    -0.05345904f, -0.02966364f, 0.06046868f, 0.36770040f, -0.26656187f, 0.48429620f, -0.14486404f, -0.03598855f, 
    0.25906715f, 0.15853156f, -0.12735586f, 0.08681169f, 0.02470454f, 0.14696811f, 0.12539427f, -0.05982279f, 
    -0.02383931f, -0.10953385f, 0.11053933f, -0.38477847f, -0.37479717f, 0.06625214f, 0.22433047f, 0.13537252f, 
    0.41062382f, 0.04910131f, 0.10036456f, 0.27198446f, 0.09397952f, -0.11954477f, -0.06487527f, -0.14668849f, 
    0.20697129f, -0.20816897f, -0.01014036f, -0.00371264f, -0.20139669f, -0.01215947f, -0.13864018f, 0.01456080f, 
    0.15209696f, -0.11173450f, 0.10341457f, -0.06438908f, -0.13362494f, -0.27595437f, 0.02543712f, -0.04274100f, 
    -0.11652701f, 0.09531230f, -0.16576014f, 0.06144962f, -0.10729229f, -0.07733794f, 0.15386122f, 0.15571865f, 
    -0.03009414f, 0.15060534f, -0.16485900f, 0.05279239f, -0.13210948f, -0.08154766f, -0.03002360f, 0.02822300f, 
    0.12899935f, -0.20671566f, 0.14656118f, 0.45687884f, -0.12858066f, 0.31335551f, -0.02461988f, -0.02178396f, 
    -0.02993832f, -0.14964382f, 0.13623379f, 0.16541450f, -0.11672852f, -0.14281428f, 0.03408224f, -0.13332668f, 
    -0.04931367f, -0.17380743f, -0.10139021f, 0.05619073f, -0.00660917f, 0.15269358f, -0.08035433f, 0.00216009f, 
    -0.12300608f, 0.02962097f, -0.13088000f, 0.06626789f, 0.08244499f, 0.01670507f, -0.09472251f, 0.09432315f, 
    -0.03811881f, -0.06128544f, -0.06540234f, -0.05132209f, -0.15141138f, 0.10651743f, -0.10407171f, -0.00603798f, 
    -0.16814034f, 0.07775705f, 0.00624424f, 0.06771272f, 0.15642813f, 0.01079019f, -0.13614514f, 0.07978942f, 
    0.13577685f, 0.13314921f, 0.05942878f, -0.16467293f, -0.08100896f, -0.14973710f, -0.15063700f, 0.08662678f, 
    -0.04648749f, 0.07373199f, -0.15658641f, -0.15398718f, 0.02204392f, 0.13814430f, -0.09199744f, 0.09917777f, 
    0.08764773f, 0.01149943f, -0.13420747f, -0.11814716f, -0.13504004f, -0.19755021f, 0.05076773f, 0.00693522f, 
    0.06397834f, 0.15567181f, 0.11714484f, -0.11378211f, -0.11755686f, 0.14428063f, 0.10667157f, -0.29196644f, 
    -0.00035062f, -0.06717158f, -0.04537835f, 0.22011380f, 0.22055875f, -0.03086047f, 0.09287741f, 0.01829258f, 
    0.13894027f, -0.05240600f, -0.08264200f, -0.28999609f, -0.06749555f, -0.04284826f, -0.11448325f, -0.12126094f, 
    -0.11718464f, 0.08196242f, -0.05682528f, 0.57615560f, -0.13739409f, 0.35068232f, -0.15627992f, 0.06876379f, 
    -0.11988136f, -0.04236209f, -0.01806579f, -0.12434375f, -0.14621730f, 0.52784109f, 0.06969992f, -0.03964754f, 
    0.02081030f, -0.13048731f, -0.00578279f, -0.34167597f, 0.15244867f, 0.00220623f, 0.36257493f, 0.10593960f, 
    -0.36075845f, 0.08300342f, 0.15190683f, 0.41160968f, 0.06353495f, -0.08683264f, 0.30160272f, -0.04059470f, 
    -0.31999889f, 0.35161003f, -0.01526077f, 0.23149356f, -0.33375219f, -0.36659282f, 0.11326061f, 0.06482702f, 
    -0.31264198f, -0.15090750f, 0.04024924f, -0.14780836f, -0.13709594f, -0.08516135f, -0.15788142f, 0.06429901f, 
    -0.00393955f, -0.04198486f, -0.03878894f, 0.53961658f, -0.23363271f, -0.16201907f, 0.45281470f, 0.12475476f, 
    -0.23548557f, -0.17238860f, -0.10712154f, -0.14489481f, -0.05317786f, 0.03983271f, 0.28430259f, 0.03478917f, 
    0.35902503f, 0.13785905f, 0.06321391f, -0.07352896f, -0.10702416f, -0.23918453f, 0.03143097f, 0.02009235f, 
    -0.14807342f, -0.08403403f, -0.17307660f, -0.13261040f, -0.12149459f, 0.00904463f, 0.10159995f, 0.14857017f, 
    0.01474308f, 0.08260692f, 0.13494933f, -0.31316456f, 0.25453609f, 0.03074221f, -0.03350938f, 0.05235447f, 
    -0.87029952f, 0.12235357f, 0.16581972f, -0.27709052f, 0.06818289f, -0.11944678f, -0.03246614f, 0.11469299f, 
    0.64112228f, 0.04211388f, 0.00792033f, 0.13130711f, 0.20222692f, 0.01449187f, 0.09092078f, -0.09098966f, 
    0.12148933f, -0.07113577f, -0.09961943f, 0.00139921f, 0.02987575f, 0.35305002f, 0.01028631f, -0.08597201f, 
    0.13717473f, 0.10986029f, 0.04789188f, -0.39460266f, -0.51729143f, -0.11084422f, 0.10747837f, -0.17799938f, 
    0.32597953f, 0.10494480f, 0.17242782f, -0.12394813f, -0.07224197f, 0.13931020f, 0.07338795f, -0.07074360f, 
    -0.18702693f, 0.20349962f, -0.15327244f, 0.18486860f, 0.31200874f, 0.18997870f, -0.02113847f, 0.04396736f, 
    0.18140718f, 0.11938721f, -0.04149566f, 0.12791975f, -0.03354265f, 0.49506852f, -0.08839016f, 0.31279922f, 
    -0.07478751f, 0.11132748f, -0.11829937f, -0.15784918f, 0.17622094f, -0.12698562f, -0.40753838f, -0.14439949f, 
    0.54870874f, -0.15997630f, -0.12246700f, -0.08460053f, 0.10320765f, -0.05100890f, -0.01911657f, 0.11380076f, 
    -0.00032548f, 0.13725980f, -0.01421990f, -0.22921672f, -0.38419974f, 0.15513946f, 0.06414484f, 0.12018649f, 
    0.17312989f, -0.14441082f, -0.10838161f, -0.10187359f, -0.02743945f, 0.00993642f, -0.03274476f, 0.13964729f, 
    -0.05123594f, 0.03362393f, 0.07151924f, -0.47011718f, 0.02330308f, -0.17301077f, -0.04848211f, -0.13564757f, 
    0.02836558f, -0.09834556f, -0.00348862f, -0.10484786f, -0.13710918f, -0.07571466f, 0.27194443f, -0.09932762f, 
    0.07113733f, -0.30835593f, -0.04565456f, 0.26946476f, -0.09803853f, 0.46248659f, 0.16152817f, 0.02427743f, 
    -0.01980737f, 0.16615443f, 0.15686184f, -0.03171822f, -0.00106037f, 0.10395729f, -0.16798547f, -0.11644278f, 
    0.14274375f, -0.13557434f, -0.12780964f, -0.03465293f, -0.12609975f, 0.01963278f, 0.11572412f, -0.09678569f, 
    -0.12464703f, -0.11286014f, 0.01182482f, -0.01610640f, -0.06712212f, -0.17219564f, -0.16616651f, 0.03217663f, 
    -0.03127250f, -0.08112282f, 0.08989645f, 0.09638418f, -0.07493166f, -0.11979527f, 0.02998674f, -0.07769765f, 
    0.00573249f, 0.15075062f, -0.00925343f, -0.13753524f, -0.16301316f, 0.28035527f, 0.10444970f, 0.51174760f, 
    0.12796330f, 0.07933407f, 0.13509619f, 0.21651830f, 0.01984937f, 0.07407531f, -0.25984466f, 0.02133194f, 
    -0.08380016f, -0.01576270f, -0.14939718f, 0.44458386f, 0.12593570f, -0.03931102f, 0.56084794f, 0.11712597f, 
    -0.24795364f, -0.34806001f, -0.03024958f, 0.25368658f, -0.53112298f, 0.09256556f, 0.13907355f, -0.06555496f, 
    -0.01808680f, -0.15906732f, 0.12656255f, 0.12780522f, 0.06475807f, 0.21068999f, -0.01239920f, -0.39381868f, 
    -0.07099678f, 0.13711458f, -0.07103915f, 0.20916235f, 0.21699058f, 0.13049281f, 0.12653841f, 0.01360970f, 
    0.32185328f, -0.00714057f, -0.09321847f, 0.06822719f, 0.04926315f, 0.07015964f, -0.22075842f, 0.04013982f, 
    -0.44257465f, 0.33086708f, -0.03078071f, 0.37650949f, 0.53932697f, 0.16502465f, -0.07716406f, -0.12822469f, 
    -0.03721156f, -0.10962848f, 0.07939684f, 0.16006605f, 0.17043456f, -0.06160924f, 0.17450717f, -0.07577157f, 
    -0.06878732f, 0.08510262f, 0.03341206f, -0.14598985f, 0.11903332f, -0.15668108f, -0.23460773f, -0.01135095f, 
    0.03299874f, -0.10138302f, -0.12953216f, -0.05012194f, 0.11513876f, -0.15300922f, -0.09374290f, 0.14661053f, 
    0.00409732f, 0.03711573f, -0.04872209f, 0.04746696f, 0.02216589f, -0.13234769f, 0.08126340f, 0.05298923f, 
    0.15324989f, -0.12194988f, -0.16466923f, -0.08193769f, 0.15076874f, -0.11193363f, -0.13599624f, -0.13523865f, 
    0.13221760f, 0.06733689f, -0.16270614f, 0.03057279f, -0.17920756f, -0.08794488f, -0.06176254f, -0.00940533f, 
    -0.56155527f, 0.02808354f, 0.16903417f, 0.51393211f, -0.05847405f, 0.15942450f, 0.02670000f, -0.16766472f, 
    0.15958011f, -0.04896451f, 0.13839220f, 0.20137694f, -0.22940625f, -0.27981734f, 0.03077980f, 0.05064686f, 
    -0.09597094f, -0.12076615f, -0.11961266f, -0.01576089f, -0.15828046f, 0.12691960f, -0.00601736f, -0.15184869f, 
    -0.00118621f, 0.14663799f, 0.12591092f, 0.36945415f, 0.27321976f, 0.06896170f, -0.06323867f, 0.10968032f, 
    -0.11651918f, 0.02087588f, 0.12509288f, 0.18248862f, -0.16811027f, -0.10415556f, 0.07542933f, -0.14102095f, 
    -0.19464834f, 0.28920901f, 0.07949963f, -0.21572573f, -0.46531990f, 0.16216111f, 0.06544543f, 0.06733741f, 
    0.18429586f, 0.17894273f, 0.16373874f, -0.08413135f, -0.16198236f, 0.19942278f, -0.03577143f, 0.28245327f, 
    -0.12710992f, -0.17794119f, -0.13854529f, 0.12109917f, 0.33174399f, 0.08018507f, 0.00473451f, -0.00250850f, 
    -0.09713868f, -0.08357991f, 0.04503092f, -0.08598351f, -0.15997870f, -0.00379898f, 0.40409365f, -0.00553611f, 
    0.44765329f, -0.01518182f, 0.14363241f, -0.41645449f, 0.05003582f, -0.42596781f, -0.09257832f, 0.09049913f, 
    -0.00753877f, -0.03544366f, 0.09898996f, -0.01955155f, -0.13803260f, -0.32592225f, 0.19179583f, 0.08362842f, 
    -0.05523699f, 0.16835776f, -0.17597827f, 0.43901664f, 0.47207469f, -0.04431619f, 0.10096780f, 0.12930536f, 
    -0.28687719f, -0.03438050f, -0.03746300f, 0.33671790f, 0.01869283f, 0.12312964f, 0.06989395f, 0.09162373f, 
    -0.01011191f, 0.10466004f, -0.13492867f, 0.09158593f, 0.15753137f, -0.19042404f, -0.12998880f, 0.05250065f, 
    -0.07765336f, -0.13126235f, 0.06499096f, 0.05741447f, 0.10827671f, 0.51986396f, -0.12302923f, 0.20109035f, 
    0.14333715f, -0.10224599f, 0.05109141f, -0.38310024f, 0.22978236f, 0.02989366f, -0.10028349f, -0.04608228f, 
    -0.19199552f, -0.05407153f, 0.13867870f, 0.34054023f, 0.07014219f, 0.03531536f, 0.14075188f, 0.11776374f, 
    -0.58711171f, 0.27191153f, -0.15491761f, -0.00478100f, -0.26400965f, 0.14053191f, 0.02905464f, -0.12383171f, 
    -0.00651248f, -0.15436059f, -0.15733546f, -0.13180053f, 0.07490530f, -0.14144205f, -0.04512845f, -0.11041357f, 
    0.17661898f, -0.08154251f, 0.05696741f, 0.10430253f, -0.02403109f, 0.15194477f, -0.06814016f, 0.14729255f, 
    -0.13260716f, 0.13947760f, 0.13773097f, -0.12429591f, -0.07153433f, 0.06669429f, -0.07219053f, 0.08585505f, 
    -0.10204711f, -0.12622969f, -0.08242710f, 0.07088950f, -0.13906783f, -0.06285065f, -0.10149578f, -0.03646332f, 
    0.33027616f, 0.01699267f, 0.11667573f, -0.11197471f, 0.13569924f, 0.23192559f, 0.03473223f, -0.08561813f, 
    -0.03075405f, -0.03320710f, -0.15735881f, 0.36064312f, 0.35801458f, 0.15664323f, 0.09695276f, 0.01156613f, 
    -0.53408891f, -0.00699587f, -0.16377360f, -0.09046099f, 0.00723811f, -0.10489182f, -0.03452982f, -0.13697460f, 
    0.27342233f, 0.23769088f, -0.10510822f, -0.13756347f, -0.18725491f, 0.03086345f, 0.09164687f, -0.13237111f, 
    0.06534844f, -0.08729213f, -0.06954099f, 0.03809232f, 0.06812771f, -0.18660024f, -0.08485049f, 0.29904717f, 
    0.07765678f, -0.04231145f, 0.04049128f, -0.29090321f, 0.24268888f, 0.09821282f, -0.08299956f, -0.13521837f, 
    0.04479304f, -0.03950237f, 0.08727382f, 0.35879010f, 0.01841998f, -0.04817290f, 0.30339086f, 0.00877706f, 
    0.00290145f, -0.01954102f, -0.00889713f, 0.38228819f, -0.21864556f, -0.34843421f, -0.01558064f, -0.06076150f, 
    0.22179866f, 0.15713230f, 0.13172761f, 0.14403696f, -0.09543985f, -0.43644854f, -0.08946729f, 0.00966608f, 
    -0.08957018f, 0.15305971f, 0.03243522f, -0.23294039f, -0.28857461f, -0.11342020f, 0.05416844f, 0.04229857f, 
    0.07817537f, 0.05792383f, 0.10262373f, -0.31245801f, 0.16910477f, 0.06544679f, -0.00657470f, -0.03365713f, 
    0.26934075f, 0.08216668f, 0.03049608f, 0.11847030f, 0.74368727f, 0.51519531f, -0.12381443f, 0.13518690f, 
    0.00740979f, 0.00224081f, 0.04001329f, 0.11031165f, 0.13311245f, 0.55599910f, 0.00549066f, 0.11055283f, 
    0.09070013f, -0.05701461f, 0.09610250f, -0.08822688f, 0.43460950f, 0.14828557f, -0.39573035f, 0.15878586f, 
    0.35218245f, 0.11474667f, -0.11982068f, -0.02567544f, -0.10104445f, 0.05913049f, 0.21033290f, -0.10926798f, 
    -0.12084465f, 0.18076840f, -0.12095364f, -0.21714333f, -0.31418741f, -0.13556078f, -0.14564544f, -0.07503445f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03349457f, 0.06034929f, -0.04909601f, -0.10341173f, -0.04505133f, -0.16025002f, -0.18085329f, 0.05240503f, 
    0.02243313f, 0.20021641f, -0.11228514f, 0.27882946f, -0.22099286f, -0.09347062f, -0.19750582f, 0.05583999f, 
    0.00652237f, 0.02025527f, -0.03791547f, -0.00767748f, 0.13953152f, -0.13728473f, 0.06543795f, 0.18863907f, 
    0.05066660f, -0.06035659f, -0.05109315f, -0.01347234f, -0.26877868f, 0.24569249f, 0.26941738f, 0.16560748f, 
    0.09252056f, 0.30496743f, -0.28601715f, 0.19536053f, 0.22667308f, 0.08479525f, 0.22594436f, 0.02600644f, 
    0.31462759f, 0.12953089f, -0.16613811f, 0.21914834f, 0.08814759f, 0.13265398f, -0.27019182f, 0.18675067f, 
    0.17790133f, 0.16293903f, -0.13678758f, 0.06814487f, 0.06656500f, -0.13269502f, 0.17488022f, 0.04560113f, 
    0.02018547f, 0.11087137f, 0.33596686f, 0.16335037f, 0.30115533f, -0.11846276f, 0.13738927f, -0.17405325f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.51264274f, -0.08554637f, 0.06984419f, -0.11359632f, -0.15854400f, -0.20139650f, -0.22200565f, -0.23190327f, 
    -0.41680291f, -0.04567678f, -0.58301699f, 0.17595436f, 0.19546963f, -0.10352236f, 0.10211710f, -0.57100439f, 
    0.01341952f, 0.13560346f, -0.09327312f, 0.00772033f, -0.05944286f, -0.01927270f, 0.15999877f, 0.48421222f, 
    -0.30425850f, -0.16709967f, 0.35533640f, -0.07320895f, -0.01385996f, -0.31710637f, -0.04157495f, 0.13128966f, 
    0.05545157f, 0.17528574f, -0.08080179f, 0.07443345f, -0.18665408f, -0.11176769f, 0.26923734f, 0.17004828f, 
    0.56481588f, 0.11658332f, 0.05762982f, 0.29430655f, -0.17147051f, -0.27766830f, 0.17034180f, 0.03936427f, 
    -0.36001363f, 0.39758632f, -0.03723606f, 0.21677600f, -0.00666361f, -0.15274045f, 0.38743138f, -0.37848976f, 
    -0.60937381f, 0.05664697f, -0.08362173f, 0.04437592f, -0.13609746f, 0.21909444f, 0.31425640f, -0.86825520f, 
    0.06670319f, -0.04395428f, 0.06534661f, 0.20627739f, 0.12684506f, 0.29232532f, -0.03953337f, -0.11242238f, 
    0.46732903f, -0.20555848f, 0.09529253f, 0.14478573f, 0.15215643f, 0.00315629f, 0.05669669f, -0.15476072f, 
    0.05441114f, 0.18121825f, -0.06788100f, -0.08995969f, -0.14551418f, 0.09300884f, -0.45365492f, -0.25418463f, 
    -0.05229871f, 0.39729953f, -0.04591409f, -0.02808541f, -0.48312613f, 0.23050492f, 0.22139437f, 0.18092693f, 
    0.04109046f, 0.03186283f, 0.18071300f, -0.08918808f, 0.44863188f, 0.11065786f, -0.10039712f, -0.31681797f, 
    0.03207780f, -0.01761521f, 0.01179726f, 0.10521340f, -0.29796296f, -0.18943925f, -0.02292039f, 0.33502012f, 
    -0.48611301f, -0.29701397f, 0.04994541f, -0.50050914f, 0.37254634f, 0.05114948f, -0.52441192f, -0.59022498f, 
    -0.21646641f, -0.07497921f, -0.35922402f, 0.01272665f, -0.11706535f, -0.22508690f, 0.48530513f, -0.52582330f, 
    -0.09461035f, -0.07568302f, 0.08384917f, 0.06338996f, -0.25133550f, -0.05731545f, 0.29531169f, -0.02502838f, 
    -0.38308388f, 0.46785909f, -0.10616570f, -0.49407178f, 0.18378387f, -0.16365014f, -0.04686507f, 0.11760980f, 
    0.06088009f, 0.25157055f, 0.10334659f, 0.16572390f, 0.01841648f, -0.06071604f, 0.24909432f, -0.25030211f, 
    0.37324187f, 0.04266426f, -0.14329393f, 0.04461892f, -0.53521687f, -0.31769833f, -0.06322361f, 0.19533511f, 
    -0.09105632f, -0.66258723f, -0.17218897f, -0.71648872f, -0.36284056f, -0.68222851f, -0.03335503f, -0.03627428f, 
    -0.02099830f, -0.03038180f, -0.08527877f, -0.06667258f, -0.16910483f, 0.26156181f, 0.56826919f, -0.53514379f, 
    -0.26533914f, 0.21824439f, 0.11009526f, -0.47324929f, -0.52938640f, -0.08931690f, -0.24189612f, -0.19208369f, 
    0.39866987f, 0.04201134f, -0.62728560f, 0.02810251f, 0.22206776f, -0.07970904f, 0.09898577f, -0.08801194f, 
    -0.20401917f, 0.09154819f, -0.05454662f, -0.07970119f, -0.02217969f, -0.28953931f, 0.15121523f, -0.46048486f, 
    -0.17257178f, -0.57644022f, 0.23808227f, 0.25579837f, -0.75020033f, 0.02944561f, 0.00448842f, -0.45783329f, 
    0.05408521f, 0.01629391f, 0.06909252f, 0.06121323f, -0.13182670f, -0.08022381f, 0.06302908f, 0.29159448f, 
    0.25789264f, 0.13949607f, 0.70980984f, 0.01768244f, -0.36792579f, 0.14407630f, -0.48728597f, -0.66316199f, 
    -0.01324198f, -0.62742972f, -0.34310398f, 0.31641945f, 0.00293240f, 0.42785695f, -0.55302393f, -0.31472084f, 
    0.04420751f, -0.08503249f, -0.11327458f, -0.11895620f, -0.02126019f, -1.07228303f, -1.09918988f, -0.37101364f, 
    0.11255024f, -0.19369216f, 0.00692002f, 0.27257279f, 0.20437135f, -0.16644928f, -0.14851357f, 0.04343087f, 
    -0.07615444f, 0.24677232f, 0.23561838f, -0.05386446f, -0.31378484f, 0.21364495f, -0.49490976f, 0.15193759f, 
    -0.39400443f, -0.09535092f, 0.10400835f, -0.14504446f, -0.11381396f, -0.03659517f, -0.45510137f, -0.01415994f, 
    -0.22210981f, 0.19894451f, -0.09712844f, -0.24084540f, -0.59401447f, -0.03599412f, 0.04911928f, -0.23060979f, 
    -0.09200594f, -0.15371963f, 0.17914666f, 0.10740323f, 0.51280200f, -0.04928007f, 0.29639581f, -0.46331692f, 
    -0.22550206f, -0.29341567f, 0.07691000f, -0.00678012f, 0.25396970f, 0.31820649f, 0.27173296f, -0.04348216f, 
    0.07587282f, -0.28593358f, 0.03144541f, -0.13931517f, 0.33697650f, -0.23120920f, 0.17003642f, 0.04075649f, 
    -0.13193785f, -0.01070182f, 0.07046286f, -0.24919865f, -0.15440193f, -0.26006284f, -0.06268680f, -0.11767801f, 
    0.22715907f, 0.24582033f, 0.01906142f, 0.40055266f, -0.37940028f, -0.06882784f, -0.13112991f, -0.19374079f, 
    0.18307526f, -0.05380831f, 0.29513291f, -0.03477509f, 0.10737801f, -0.04331094f, -0.15145816f, 0.10348561f, 
    0.15290026f, -0.09270684f, -0.06865613f, 0.12132505f, 0.02005267f, 0.43965733f, -0.49873182f, 0.30290619f, 
    0.02989789f, 0.22944956f, -0.21173812f, 0.22433664f, -0.32565221f, -0.03831475f, 0.04555148f, 0.10328898f, 
    0.05648607f, -0.07756548f, -0.13087195f, -0.53982186f, -0.08865558f, 0.07215495f, -0.42677185f, -0.84298468f, 
    0.50997722f, 0.15128088f, 0.16355233f, 0.07801449f, -0.07763057f, -0.25139490f, 0.03339799f, -0.07703794f, 
    0.02727286f, 0.44315863f, -0.01508995f, 0.06156760f, -0.67298025f, -0.27994296f, -0.05613135f, 0.36494657f, 
    -0.16328822f, -0.03849135f, 0.03308117f, 0.02424686f, -0.04629974f, -0.13600501f, -0.20155457f, 0.32090354f, 
    0.29159936f, 0.13336025f, 0.02149503f, -0.48419449f, 0.09687469f, -0.02275798f, -0.05710839f, 0.12239989f, 
    -0.26315573f, -0.33036721f, 0.20055474f, -0.10096616f, -0.02512483f, -0.29068059f, 0.14900199f, 0.00695437f, 
    -0.20304717f, -0.02853219f, -0.10213886f, -0.01814010f, -1.29844868f, -0.07185710f, -0.31367984f, 0.45483214f, 
    -0.17199549f, -0.28368059f, -0.74690449f, 0.22232831f, 0.20476405f, 0.04774038f, 0.09040019f, -0.96524870f, 
    -0.11282220f, -0.29917902f, -0.28395116f, -0.22510752f, 0.01635538f, 0.02447851f, -0.03568900f, -0.15410069f, 
    -0.15414762f, -0.24162836f, -0.30510369f, -0.01322216f, -0.24885249f, -0.27130175f, 0.00301776f, -0.11216518f, 
    -0.00584905f, 0.07365767f, -0.15636756f, 0.07010502f, -0.91177261f, 0.03682254f, -0.01293107f, -0.45461363f, 
    -0.49942794f, 0.06602509f, 0.02180739f, 0.15272439f, 0.61700916f, -0.21013923f, 0.15332405f, 0.06225089f, 
    -0.03054360f, -0.88224387f, -0.11983632f, -0.08730506f, 0.25380820f, 0.04994529f, 0.27250251f, 0.12212156f, 
    0.06566887f, 0.07099432f, 0.45290327f, -0.04216006f, 0.11335560f, 0.16895147f, -0.61033684f, 0.36185664f, 
    0.04913098f, 0.05226728f, -0.08143139f, -0.19302590f, 0.28033715f, 0.38675910f, -0.18591835f, -0.47509030f, 
    -0.11662634f, 0.24682027f, 0.26038131f, -0.18604183f, -0.17737818f, 0.04104800f, 0.09088872f, -0.33739313f, 
    0.02183320f, -0.08335752f, 0.14283726f, 0.26998344f, -0.23432873f, -0.09852196f, 0.19093364f, 0.31442139f, 
    -0.21169543f, 0.17711879f, 0.18527606f, 0.10694267f, 0.69356203f, -0.53476822f, -0.11211964f, -0.55147773f, 
    0.03624248f, -0.14036457f, 0.42407119f, -0.12148538f, -0.13803916f, -0.33133680f, -0.28447008f, 0.10862259f, 
    -0.12855230f, -0.12354285f, -0.12244516f, -0.66286832f, -0.46093580f, 0.44746292f, 0.21808633f, -0.04530976f, 
    0.26453778f, -0.04442224f, 0.11748461f, 0.21960427f, -0.81138134f, -0.16801485f, -0.33765730f, -0.97804749f, 
    0.25373206f, -0.28618824f, -0.26344749f, -0.14076757f, -0.55657881f, 0.22731072f, -0.03200330f, 0.19450173f, 
    -0.03867211f, -0.03650710f, -0.04600987f, 0.07958429f, -0.05156472f, 0.06971467f, 0.39025733f, -0.55694717f, 
    0.47110927f, -0.09048710f, -0.15335841f, -0.45173740f, -0.84003282f, 0.04856567f, 0.06437614f, 0.66966474f, 
    -0.11288433f, -0.05409528f, -0.02096186f, 0.20153123f, 0.10423142f, -0.01634772f, -0.65352160f, 0.08183091f, 
    -0.16943792f, -0.21279708f, -0.19280009f, 0.03445935f, 0.31235892f, 0.42243114f, -0.03000252f, 0.28373516f, 
    -0.03450311f, 0.06231727f, -0.37969375f, 0.01761613f, -0.49190095f, 0.44193763f, -0.07486536f, 0.18426956f, 
    -0.13888754f, -0.09322526f, -0.02691318f, -0.02714646f, -0.63163316f, 0.20845965f, -0.85472631f, -0.37256584f, 
    -0.13900852f, 0.03769898f, 0.11558843f, -0.45641610f, 0.18276732f, -0.18807818f, -0.45752576f, 0.19128442f, 
    -0.01421345f, 0.23326869f, -0.40416458f, 0.06344207f, 0.18513708f, -0.73239154f, 0.10142786f, -0.49826616f, 
    0.31928140f, 0.09899050f, -0.10328311f, -0.06378435f, -0.63037419f, -0.46318421f, -0.50786471f, -0.70483673f, 
    -0.21247765f, 0.07111254f, -0.25237656f, -0.31657675f, -0.49836165f, -0.07960743f, -0.07077311f, -0.00319149f, 
    -0.10985103f, -0.26107374f, -0.78821611f, 0.27458459f, -0.54998714f, 0.03471749f, -0.20566210f, -0.55314636f, 
    -0.51017886f, -0.53167158f, -0.74397701f, -0.06494772f, 0.34275874f, -0.13669775f, 0.30392423f, 0.12066225f, 
    -0.11828124f, -0.33638033f, -0.30777591f, 0.36999401f, 0.14049575f, -0.57412571f, 0.29328603f, 0.59498066f, 
    0.15319191f, 0.12295713f, -0.02035190f, 0.35238275f, -0.00308268f, 0.32984179f, -0.50519329f, -0.08255820f, 
    0.16054386f, -0.12016174f, -0.00768855f, 0.35911086f, 0.13820863f, -0.01846047f, -0.00489789f, 0.18155888f, 
    -0.03231008f, -0.03231303f, -0.02625872f, -0.09847659f, 0.15670916f, -0.14237641f, -0.54618591f, 0.31912157f, 
    -0.27022302f, 0.05769259f, -0.01655496f, -0.30740952f, 0.25524378f, 0.15743141f, 0.42321444f, 0.37829879f, 
    -0.16896676f, -0.03616795f, 0.48641253f, -0.05051935f, 0.22523153f, 0.14400661f, 0.06575097f, -0.43989050f, 
    -0.00043987f, -0.12792146f, 0.21778986f, -0.75178254f, 0.20050766f, -0.05152374f, 0.09751546f, -0.15834637f, 
    -0.40387467f, 0.19522479f, -0.24795808f, -0.11012835f, -0.42260498f, -0.14929394f, -0.47208336f, 0.13296710f, 
    0.07485986f, -0.15063682f, -0.55399090f, -0.26071885f, 0.39272812f, 0.40258962f, -0.48077294f, -0.37891245f, 
    -0.02779394f, -0.11336081f, 0.08603010f, 0.09126455f, -0.59526831f, -0.74738377f, -0.00315367f, -0.60828328f, 
    0.13434222f, -0.36229935f, 0.01888411f, -0.32236338f, 0.02482536f, 0.04837448f, -0.21300015f, 0.14779478f, 
    0.15465295f, 0.08551674f, -0.25727567f, 0.05925962f, 0.18992350f, -0.02751441f, 0.14357163f, 0.07217819f, 
    -0.94990760f, 0.06701335f, -0.08985736f, 0.07185002f, -0.15975164f, -0.71993911f, 0.12935294f, 0.13713519f, 
    0.06453530f, -0.65677124f, -0.28212899f, 0.11650287f, 0.27886978f, 0.02455091f, 0.09927169f, -0.57139117f, 
    -0.10824284f, 0.22637665f, 0.30095699f, 0.43930537f, -0.04063449f, 0.09089025f, 0.19722551f, 0.44669673f, 
    0.04556265f, -0.04868144f, -0.87125832f, -0.04655091f, -0.27800474f, 0.26387236f, -0.38117251f, -0.14765356f, 
    -0.04055735f, 0.34222919f, 0.08410805f, 0.12765025f, -0.24586864f, 0.09435840f, -0.17254569f, -0.17489237f, 
    -0.01606284f, -0.04696806f, 0.02349434f, -0.36617759f, 0.23095016f, 0.23267710f, -0.38382745f, -0.16659720f, 
    -0.69509590f, -0.50254631f, 0.01076527f, 0.03865023f, -0.14135157f, -0.11129367f, 0.68362492f, 0.03808053f, 
    0.24570134f, 0.24094477f, 0.03835163f, -0.07924358f, 0.08188637f, 0.16503815f, -0.09556117f, -0.58224273f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04233939f, 0.11734594f, 0.00068953f, 0.05774409f, 0.31943521f, 0.08852657f, 0.07252189f, -0.30624303f, 
    -0.19341408f, 0.08417699f, 0.01307587f, 0.06158707f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
