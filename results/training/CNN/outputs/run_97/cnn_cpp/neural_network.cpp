#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51171476f, -0.32150424f, -0.51455539f, 0.01073128f, 0.28878289f, 0.30103442f, 0.32669389f, -0.63054681f, 
    0.36268002f, -0.42126995f, 0.18069051f, 0.13382064f, -0.27430367f, 0.26766464f, -0.13264439f, -0.05767503f, 
    0.01242994f, 0.50843364f, 0.19993912f, -0.14359121f, 0.28478488f, -0.25045523f, -0.55319554f, -0.15480995f, 
    0.07955483f, 0.85667598f, 0.72176981f, 0.47801334f, 0.97984809f, 0.76807427f, -0.05351958f, 0.19093160f, 
    -0.03143207f, 0.05937558f, -0.14603229f, -0.28765541f, -0.08090664f, 0.23602463f, 0.22578432f, -0.00233576f, 
    -0.00881933f, 0.19335337f, 0.20585020f, 0.06929302f, 0.03518830f, 0.06871784f, -0.13990289f, -0.16698693f, 
    0.00704959f, 0.05095709f, -0.14781086f, -0.86744899f, 0.22688422f, 0.47845942f, -0.48134837f, -0.09391180f, 
    0.14380914f, 0.69764566f, -0.33900976f, -0.26669011f, 0.21560863f, -0.04813341f, 0.04747475f, 0.22523257f, 
    -0.06741782f, -0.32262105f, -0.20430097f, -0.18557264f, -0.25855982f, 0.08110337f, -0.30234438f, 0.21395023f, 
    0.11975086f, 0.16747968f, -0.05835811f, -0.77544582f, 0.79972851f, 0.19777286f, -0.58987296f, -0.19069448f, 
    0.40953174f, -0.19212437f, -0.54538816f, 0.24792698f, -0.39132231f, -0.12418163f, 0.22523092f, -0.23079753f, 
    0.06417236f, 0.01877522f, -0.36389643f, 0.19668142f, -0.10416351f, -0.15816084f, 0.10612394f, 0.10562044f, 
    -0.01747401f, 0.10646917f, 0.07224084f, -0.08997715f, -0.50742769f, -0.56811285f, 0.03448273f, 0.48317569f, 
    -0.37208405f, 0.21017285f, -0.10780988f, 0.62635881f, -0.47913450f, -0.49962759f, -0.04487139f, -0.05366727f, 
    -0.05871288f, 0.07626917f, 0.06959844f, -0.02159908f, 0.08723158f, -0.10766111f, -0.32238191f, -0.14611167f, 
    0.21319567f, 0.28054646f, -0.00452391f, 0.45784980f, -0.27448636f, 0.36122340f, 0.22432119f, 0.64147210f, 
    -0.15956065f, 0.55852777f, -0.76285690f, -0.48362306f, -0.54853052f, -0.13440527f, -0.20882009f, 0.27344817f, 
    -0.13322516f, 0.10120234f, 0.12882328f, 0.03256502f, 0.39809009f, -0.16422549f, -0.18910742f, 0.04069273f, 
    -0.20457327f, -0.14947690f, -0.31769294f, -0.01893584f, -0.27211270f, -0.10042278f, 0.48173130f, 0.67054331f, 
    -0.11380216f, -0.07840346f, 0.65128851f, -0.07428414f, -0.26893339f, 0.19606592f, 0.38838568f, 0.41428921f, 
    0.01118322f, -0.12104609f, -0.11790780f, -0.24951002f, 0.02294649f, 0.04792199f, -0.10862995f, -0.42061052f, 
    -0.11344955f, 0.38660178f, -0.24414925f, -0.06403753f, 0.32350746f, 0.01878090f, -0.29776943f, 0.02467668f, 
    -0.90773284f, 0.60245275f, 0.50024563f, 0.26136550f, 0.63402432f, 0.27886334f, 0.30447772f, -0.42296690f, 
    0.02810708f, -0.02106713f, -0.07302289f, -0.09491033f, 0.46849892f, 0.09576309f, 0.35981280f, 0.20424755f, 
    -0.10836057f, 0.18763368f, 0.07430562f, 0.08852042f, 0.06003270f, 0.12760511f, -0.32568294f, 0.15236191f, 
    0.26711798f, -0.82145745f, -0.40571639f, 0.63863790f, 0.24114670f, -0.69363606f, 0.41992128f, 0.18850826f, 
    0.07108421f, 0.29374093f, 0.29444304f, 0.04367163f, -0.38621962f, 0.03186549f, 0.33638346f, -0.04191525f, 
    -0.22349581f, -0.16991727f, 0.23840822f, -0.27310255f, 0.13861480f, 0.16601461f, -0.24264576f, 0.29415810f, 
    -0.04226169f, 0.86744082f, 0.44347012f, 0.61398840f, 0.31557456f, 0.53249574f, -0.17744868f, -0.03117499f, 
    0.00688327f, -0.17811365f, 0.29278198f, -0.10581163f, 0.29047990f, -0.04316160f, 0.36495247f, 0.13591260f, 
    -0.13230550f, -0.12889099f, -0.11593328f, 0.11475848f, -0.26276267f, 0.18757921f, 0.06453256f, -0.26488167f, 
    -0.17685512f, 0.15525140f, 0.98898822f, 0.25936818f, -0.78982192f, -0.71675795f, -0.48424062f, 0.09854812f, 
    -0.14348695f, 0.10191457f, 0.09008193f, -0.17078799f, -0.19316652f, 0.01763670f, 0.14123729f, -0.04080856f, 
    -0.08966321f, -0.05560244f, -0.12656876f, -0.06027455f, 0.04398501f, 0.09525634f, -0.01187776f, 0.14988175f, 
    0.06030643f, -0.18616830f, 0.13473782f, -0.25127089f, -0.06653933f, -0.56536657f, -0.57574308f, -0.16651936f, 
    0.42315972f, -0.43061650f, -0.11347543f, 0.22324567f, -0.01297489f, -0.19598347f, -0.17416544f, 0.11504330f, 
    0.17071034f, -0.27788103f, 0.20201719f, 0.10234367f, -0.07570145f, 0.13532826f, 0.30650005f, 0.36528191f, 
    0.28510869f, 0.25114152f, 0.14772947f, 0.16903351f, 0.68417615f, 0.49877149f, 0.44659504f, 0.68490100f, 
    0.41283184f, 0.06173034f, -0.13774419f, 0.07451647f, 0.04921869f, 0.11191415f, -0.11161901f, -0.34135622f, 
    -0.14887802f, -0.22911747f, 0.07380918f, -0.21964304f, -0.31803653f, -0.09247606f, 0.01897999f, -0.01350704f, 
    0.48868144f, 0.30795956f, 0.26366997f, -0.03082036f, 0.32528374f, 0.70776677f, 0.72776258f, 0.75104940f, 
    0.54386979f, 0.25513512f, -0.36512038f, -0.16180414f, -0.30603009f, 0.21518254f, -0.30479619f, 0.32157001f, 
    0.28912437f, -0.22524042f, 0.34873080f, -0.51759797f, 0.07494841f, -0.30674925f, 0.09225176f, -0.24142306f, 
    -0.30712152f, -0.16124830f, 0.11518565f, 0.16372365f, -0.03277721f, 0.12167088f, -0.71067119f, -0.05673316f, 
    -0.21993865f, -0.39583519f, -0.60198349f, 0.64357865f, 0.55861276f, -0.31097126f, 0.36683384f, 0.53664529f, 
    0.01526139f, 0.01226983f, -0.17073545f, -0.02753449f, 0.16263919f, 0.06221671f, -0.02103071f, -0.10643690f, 
    0.05404114f, -0.11813095f, -0.30986875f, -0.21173497f, -0.04647740f, 0.18099363f, -0.12165087f, -0.07213535f, 
    0.45464364f, -0.13995717f, -0.01426592f, 0.75042605f, 0.25697544f, 0.04870801f, -0.67287636f, 0.36576167f, 
    0.07947424f, -0.24494302f, 0.18557759f, -0.44634512f, 0.28938398f, -0.36568615f, 0.04967588f, 0.28794569f, 
    -0.04518757f, -0.07028358f, -0.16570145f, -0.03651011f, -0.07204457f, 0.28025034f, 0.17891304f, 0.01966111f, 
    0.87547344f, 0.55676818f, 0.09052103f, 0.36474088f, 0.22170174f, 0.33200258f, 0.23562467f, 0.28564224f, 
    0.53032607f, 0.15616900f, -0.38217434f, 0.19471052f, 0.01606214f, -0.52515477f, -0.17291020f, -0.06984555f, 
    0.05347806f, -0.08481234f, -0.17657590f, -0.02027536f, -0.17305514f, 0.11907740f, -0.06459471f, -0.20764580f, 
    0.14976998f, -0.09796960f, -0.60452491f, -0.28689933f, -0.04720517f, 0.13564587f, 0.70625883f, 0.71958989f, 
    -0.26527622f, -0.05228432f, -0.26776415f, -0.32026306f, 0.42997614f, 0.15242265f, 0.12092499f, 0.31128308f, 
    -0.15031043f, 0.23681900f, 0.17940758f, -0.01965174f, 0.23914562f, 0.13383825f, -0.07877769f, 0.12190901f, 
    -0.11775979f, -0.05593092f, -0.67651504f, 0.45755237f, -0.37585652f, 0.27803481f, 0.02691643f, 0.05560756f, 
    0.51343578f, 0.27289599f, -0.51247764f, 0.46221912f, -0.34213421f, -0.13388996f, 0.44377440f, -0.16369168f, 
    -0.15532675f, -0.33784771f, -0.32100067f, -0.23923004f, 0.21962732f, -0.37304258f, 0.26098880f, 0.17438909f, 
    0.01619585f, 0.24027066f, 0.33176035f, -0.07305496f, -0.76755559f, -0.28689575f, 0.54200751f, 0.03042081f, 
    -0.16756128f, 0.65347189f, 0.49848303f, 0.10671740f, 0.31320709f, -0.39766386f, 0.04324006f, -0.51366109f, 
    0.04793232f, -0.42727005f, -0.24948560f, -0.08587134f, -0.17423537f, -0.01442963f, -0.21513271f, -0.12760137f, 
    0.08050103f, -0.13289830f, -0.15835133f, -0.20109566f, 0.11720750f, -0.55111521f, 0.46696496f, 0.34788525f, 
    0.04144126f, 0.30320361f, 0.03153167f, 0.28564465f, 0.34529760f, 0.00171239f, -0.17999829f, -0.43571424f, 
    0.15156324f, 0.02589683f, -0.19334418f, -0.16844641f, 0.10736743f, -0.32168359f, -0.25755128f, -0.07506268f, 
    -0.33406457f, -0.06481759f, -0.34970230f, -0.10148773f, 0.18891206f, 0.09429681f, 0.03042541f, 0.75196165f, 
    -0.14669889f, -0.67636633f, 0.51923954f, -0.87852979f, -0.10737342f, -0.13873476f, 0.28876615f, 0.00023364f, 
    0.00025156f, -0.06028738f, -0.12269671f, 0.20521265f, 0.08752647f, 0.28857595f, -0.20581040f, -0.17320298f, 
    -0.15892434f, -0.05642345f, -0.06465401f, -0.05089621f, -0.06507524f, -0.10683654f, 0.22149022f, 0.64896637f, 
    0.66845262f, 0.36168447f, -0.09593648f, -0.60287631f, -0.58058304f, 0.22093369f, -0.20608510f, -0.02102137f, 
    0.30852965f, 0.09592587f, -0.21892038f, 0.28055125f, 0.26089865f, -0.20053941f, 0.07644902f, -0.09552106f, 
    -0.09231859f, -0.06267403f, 0.23710373f, 0.28731754f, -0.23546258f, 0.42483586f, 0.00184754f, -0.46844387f, 
    -0.83185589f, -0.42322657f, 0.21371597f, -0.06881798f, -0.74648136f, 0.54456609f, 0.74237370f, -0.35093343f, 
    0.32380792f, 0.30871561f, -0.31512287f, 0.06341484f, -0.24835619f, 0.05305024f, 0.09782407f, -0.10768184f, 
    0.01892318f, -0.24255070f, -0.02996580f, 0.16480592f, 0.18771853f, 0.14431222f, 0.24317650f, 0.18519792f, 
    -0.24136887f, -0.64194602f, -0.73534620f, -0.19110693f, -0.26664704f, 0.25172132f, -0.11845570f, 0.47055551f, 
    0.26089576f, 0.16080748f, -0.10093895f, -0.22739542f, 0.00358642f, 0.29736814f, -0.31738305f, 0.08270901f, 
    0.14098778f, 0.15869230f, -0.24529211f, -0.26515177f, -0.27305636f, 0.03384785f, 0.23861158f, -0.29678556f, 
    0.14432435f, -0.20039000f, 0.10177942f, 0.66119021f, -0.51383382f, 0.44031003f, 0.76122391f, -0.13649261f, 
    0.58383960f, -0.42959520f, -0.23863681f, 0.19024196f, 0.09443256f, -0.07716347f, -0.28733045f, -0.38613808f, 
    -0.26777673f, -0.22459097f, 0.00729251f, -0.20081148f, -0.35096040f, -0.03875867f, 0.18540271f, 0.10683598f, 
    -0.15246417f, 0.05090018f, 0.11035495f, -0.10535404f, 0.57596380f, 0.63765937f, 0.29097784f, 0.57767856f, 
    0.16530716f, -0.05947017f, 0.15344940f, 0.46098194f, -0.54279935f, 0.08382054f, 0.17652416f, -0.36993426f, 
    -0.25625443f, 0.03429979f, -0.04815276f, 0.10074206f, -0.34878090f, -0.19404198f, -0.15997377f, -0.37242514f, 
    0.27554053f, -0.09912231f, -0.20518528f, 0.31900704f, 0.04184362f, 0.09822211f, 0.87615627f, -0.62453711f, 
    0.27921218f, 0.36237687f, 0.35528344f, 0.35126492f, 0.27455193f, -0.16939533f, -0.07306279f, -0.03736747f, 
    0.14930321f, 0.03152573f, -0.33490852f, -0.14516245f, -0.06403934f, -0.23490974f, 0.32534531f, 0.02513299f, 
    0.35249367f, -0.02570660f, -0.10218665f, -0.40041354f, -0.15026446f, -0.43652505f, 0.34791315f, 0.62911034f, 
    -0.57319719f, -0.23595752f, 0.04232130f, 0.16142313f, -0.54172111f, -0.48175305f, 0.15139227f, -0.04207234f, 
    -0.27388006f, 0.11662205f, -0.23713118f, 0.29609734f, 0.18127282f, -0.08951708f, 0.43460289f, -0.34168720f, 
    -0.29255104f, -0.17140590f, -0.23955454f, 0.09949968f, -0.01041658f, -0.64210922f, -0.23897105f, 0.34702933f, 
    0.33804491f, 0.51259512f, -0.76670241f, -0.03873118f, -0.21765457f, -0.54995787f, 0.15239494f, 0.14467359f, 
    0.42313588f, 0.17100509f, -0.05541571f, 0.33895814f, 0.38254026f, 0.03031298f, -0.03474458f, -0.02613224f, 
    0.29229513f, -0.07171028f, -0.25010839f, 0.33446595f, 0.22875835f, 0.00682203f, -0.65668005f, 0.20515482f, 
    -0.34510401f, -0.55274284f, -0.10200172f, 0.60759640f, 0.58411628f, 0.28985581f, 0.51924515f, 0.53961921f, 
    0.33170739f, 0.12525594f, 0.22134534f, -0.23924093f, 0.01148551f, 0.12282754f, 0.13698027f, 0.08136906f, 
    0.32126459f, 0.05231117f, 0.02378185f, -0.08808684f, 0.04653016f, 0.07808349f, -0.03923029f, -0.10633671f, 
    0.40740851f, -0.68116635f, -0.06451084f, -0.17267764f, -0.02500097f, -0.54332650f, 0.03782225f, -0.11138455f, 
    -0.55002344f, 0.40907201f, -0.29701436f, -0.08198148f, 0.27240083f, -0.16540389f, 0.02801710f, 0.20738295f, 
    -0.13864459f, -0.23956068f, 0.35487774f, 0.03446184f, -0.04581825f, 0.01138080f, -0.09313738f, 0.25129876f, 
    0.87354761f, 0.31072581f, 0.20413461f, 0.47940296f, 0.36055949f, 0.48621693f, 0.12436652f, -0.20726360f, 
    0.00621016f, -0.13342363f, 0.16315570f, -0.11765514f, -0.24820694f, 0.02482278f, -0.21673514f, 0.35945350f, 
    -0.04039863f, 0.01674887f, 0.08747800f, 0.18098310f, 0.07411583f, -0.13785522f, 0.02832521f, 0.14522789f, 
    0.27346137f, -1.02462184f, 0.95255977f, 0.04232265f, -0.68189490f, 0.23046806f, -0.22249655f, 0.01207029f, 
    0.11424983f, -0.15307403f, -0.40298206f, -0.01355124f, -0.00476878f, -0.26496840f, 0.02292647f, -0.20706166f, 
    0.02865862f, 0.15038115f, -0.14670870f, -0.10340289f, -0.28366190f, -0.00764824f, 0.15137638f, 0.25427508f, 
    0.19092187f, -0.00962044f, -0.16008477f, 0.13432343f, -0.35357702f, -0.40772381f, -0.36283818f, 0.69032693f, 
    0.22271015f, 0.35596326f, 0.56381965f, 0.22507238f, 0.13332549f, -0.31543782f, 0.19890556f, -0.00470277f, 
    -0.33866528f, 0.25372761f, -0.30546394f, 0.02313407f, -0.30911991f, -0.08424044f, -0.08160339f, -0.37463671f, 
    -0.03265321f, -0.11595756f, 0.14295413f, 0.95793593f, 0.58256847f, 0.41937780f, -0.01058041f, -0.31111661f, 
    0.29309699f, -0.01374920f, -0.05503510f, 0.39996937f, 0.36931658f, -0.01808786f, 0.26771367f, -0.26611078f, 
    0.06333822f, 0.10186252f, 0.06675033f, -0.03217542f, -0.05803453f, -0.13942195f, -0.19346052f, -0.07022346f, 
    -0.02739412f, -0.13105880f, 0.07027300f, 0.26092884f, 0.84336001f, 0.75214952f, 0.91762954f, -0.45587599f, 
    -0.36923864f, -0.60064524f, 0.58506036f, -0.30319896f, -0.36967140f, 0.01087341f, 0.15038565f, 0.17124920f, 
    -0.17795584f, -0.04157140f, 0.05103770f, 0.05267767f, -0.01068896f, 0.03384196f, 0.15495238f, 0.04563883f, 
    0.12441613f, 0.06020116f, 0.15113083f, -0.02533064f, 0.32242158f, 0.03362790f, -0.40172762f, 0.03731645f, 
    0.21224520f, 0.36271867f, 0.26415503f, 0.38738802f, -0.12126657f, 0.22611135f, 0.42478177f, 0.06605104f, 
    -0.04403347f, -0.19877009f, -0.00430389f, -0.45009863f, 0.38398394f, 0.20621130f, -0.33464414f, 0.26810765f, 
    -0.06166770f, -0.11266269f, -0.36586869f, 0.25769398f, 0.06703472f, -0.30285388f, 0.29899645f, -0.47107393f, 
    -0.58899212f, -0.74861717f, -0.29674983f, 0.03364812f, 0.75510293f, 0.24523591f, 0.19208758f, 0.18179627f, 
    -0.28701010f, -0.15544218f, -0.53869778f, -0.34545982f, -0.00729910f, -0.18507607f, 0.26916984f, -0.09120262f, 
    0.01509332f, -0.01277237f, -0.12498815f, -0.01104194f, -0.02756250f, -0.14662802f, -0.10536565f, -0.12595910f, 
    -0.61662483f, -0.50620598f, -0.55341858f, -0.29616094f, 0.34104142f, -0.08371241f, -0.49883589f, -0.08489069f, 
    0.10369035f, 0.25371802f, -0.09974887f, 0.24247108f, -0.29854533f, -0.08235567f, -0.07704843f, 0.04870054f, 
    0.09644133f, -0.18909302f, -0.00794313f, 0.03371828f, 0.21733423f, -0.23795156f, 0.23543121f, -0.21352732f, 
    -0.35117304f, -0.20576662f, -0.72060478f, -0.48799068f, -0.26729327f, 0.48595110f, -0.23980749f, 0.05680414f, 
    0.05505573f, 0.57441121f, -0.29105151f, -0.36843821f, 0.12088861f, -0.16407558f, -0.57869530f, -0.21858637f, 
    0.21509346f, 0.25416857f, -0.07109095f, 0.37553734f, -0.04590826f, 0.15598845f, -0.41350770f, 0.17638168f, 
    0.06693140f, 0.50574023f, 0.76801193f, -0.66990685f, -0.32237998f, -0.19281296f, 0.61649007f, -0.23635063f, 
    -0.51893133f, -0.47887143f, 0.08449299f, 0.23373750f, 0.33630976f, 0.07556639f, 0.14968146f, -0.03813593f, 
    0.09196084f, -0.27344134f, 0.23342671f, -0.04433679f, -0.05046820f, 0.01623327f, -0.02601370f, 0.04924287f, 
    -0.02335573f, 0.10144488f, 0.29183328f, 0.03154862f, 0.73002875f, 0.62118918f, -0.59366977f, -0.56373549f, 
    -0.42482495f, -0.23641598f, 0.34141383f, -0.22026324f, 0.25749749f, -0.28553763f, -0.14973657f, -0.12678683f, 
    -0.47547656f, -0.43827531f, -0.07369436f, 0.17323461f, 0.09317797f, -0.14335188f, 0.25057042f, 0.02882930f, 
    0.10554586f, -0.05854416f, -0.36344215f, 0.29112402f, -0.27867448f, -0.33950260f, -0.18557088f, -0.20070747f, 
    -0.25397450f, 0.21182357f, -0.04916724f, -0.11134162f, -0.64141345f, -0.51785213f, 0.19712791f, 0.31021124f, 
    -0.18589048f, -0.47977328f, -0.22819328f, 0.01860109f, -0.11213860f, -0.22868061f, -0.55570632f, 0.19948414f, 
    -0.10569998f, -0.00209260f, 0.15276749f, 0.33423159f, -0.31721818f, -0.59556913f, -0.53376991f, -0.46669582f, 
    0.18853182f, -0.09360126f, 0.36018726f, 0.24742956f, 0.01544391f, 0.05814728f, 0.52108288f, -0.31319845f, 
    -0.04003392f, -0.27642149f, 0.25737521f, 0.26434338f, 0.40897459f, -0.36219370f, 0.21352494f, 0.32784277f, 
    0.22776109f, -0.02299056f, 0.19620803f, 0.18784396f, 0.26281404f, 0.82758033f, 0.30162615f, -0.38442084f, 
    0.02696441f, -0.22762232f, -0.49626866f, -0.51063824f, 0.09890331f, -0.14307310f, 0.22480480f, 0.48255074f, 
    0.00471246f, 0.40290448f, -0.12818468f, -0.03002665f, 0.24271911f, 0.23846376f, 0.26954263f, -0.25518245f, 
    0.06629439f, -0.21523505f, -0.04472248f, 0.20321584f, 0.42273945f, -0.40565041f, -0.00163297f, -0.07924546f, 
    0.34964687f, -0.25981745f, -0.39247853f, -0.44320405f, 0.07508141f, -0.60139638f, -0.41965565f, 0.21769030f, 
    0.23515664f, 0.25656575f, -0.36928916f, 0.16201751f, -0.39877579f, -0.54904592f, -0.48343796f, 0.17435566f, 
    -0.25478306f, 0.17880180f, 0.26438966f, 0.00611017f, -0.33048448f, -0.10257172f, -0.26930368f, 0.15836248f, 
    0.45533553f, -0.20324533f, -0.03317984f, 0.72339845f, 0.74885505f, 0.17836732f, -0.51641983f, 0.05870314f, 
    -0.25650400f, 0.12905335f, 0.14626408f, 0.08505417f, 0.24380989f, 0.03666488f, -0.27656844f, -0.35686114f, 
    -0.16075222f, -0.00277286f, 0.28675565f, 0.39829409f, -0.36285022f, 0.11553568f, -0.38319203f, -0.15914483f, 
    -0.84094900f, -0.56700367f, -0.34008420f, 0.00688355f, 0.06748530f, -0.35501507f, 0.68395555f, 0.49688718f, 
    -0.05045776f, 0.29310599f, -0.40753576f, 0.02211089f, 0.37324050f, -0.29016384f, -0.07325243f, -0.06036488f, 
    0.16912968f, 0.14029285f, 0.13298799f, -0.16796401f, 0.28606778f, -0.18600993f, -0.29515216f, 0.18020955f, 
    0.18788902f, -0.38178825f, -0.04080235f, -0.44875473f, 0.59486634f, 0.28997877f, -0.48998702f, 0.52145725f, 
    0.32110128f, 0.49095395f, 0.36599457f, 0.03169335f, 0.13231941f, -0.11649184f, -0.14518723f, -0.33957657f, 
    -0.24439029f, -0.34137511f, 0.06472835f, -0.11524079f, 0.07848044f, 0.40242115f, 0.19163552f, 0.20840500f, 
    -0.30865526f, -0.06904614f, -0.60199165f, -0.40417036f, 0.01987326f, 0.13832441f, -0.71302867f, 0.23165761f, 
    -0.04457794f, -0.38893455f, -0.24466419f, -0.03153266f, -0.16410655f, -0.16146614f, -0.09471320f, 0.07170924f, 
    0.28593051f, -0.19968471f, -0.01279633f, 0.11860266f, -0.31957248f, 0.19522811f, 0.05289448f, 0.36644676f, 
    -0.02915587f, -0.03511082f, -0.38374740f, -0.38283285f, 0.70397329f, -0.60752922f, -0.31331617f, -0.13256909f, 
    0.66150087f, -0.18163100f, -0.49451903f, -0.16188993f, -0.26737750f, 0.23099497f, 0.17469753f, 0.05451383f, 
    0.33911154f, -0.25703117f, -0.25078627f, -0.11448343f, 0.07309806f, -0.16130306f, 0.22430341f, -0.13638283f, 
    0.13718860f, 0.07382654f, 0.26676840f, 0.22613512f, -0.70368677f, -0.41381851f, -0.35456008f, -0.14962816f, 
    -0.33089569f, 0.33427143f, 0.77741176f, 0.13651951f, 0.13629870f, 0.16111426f, 0.20407087f, -0.08248398f, 
    -0.00713657f, -0.37805963f, 0.07721900f, 0.04763199f, -0.24840286f, 0.16935846f, -0.04399131f, -0.44504145f, 
    -0.00428323f, -0.21694881f, 0.13599381f, -0.01939267f, 0.02334656f, -0.21744847f, -0.29662991f, 0.13518380f, 
    -0.54843867f, 0.32188672f, -0.02733714f, -0.16278912f, -0.33140224f, -0.31944954f, -0.52619469f, -0.29063278f, 
    0.33330572f, -0.18096761f, 0.29951417f, 0.21654506f, -0.11363218f, 0.32931790f, 0.14403139f, 0.36938411f, 
    0.53719413f, -0.25318828f, -0.09261589f, -0.10312504f, 0.23619594f, -0.13619849f, -0.18657193f, -0.52870661f, 
    -0.05581433f, -0.22685614f, 0.43760151f, -0.83229691f, 0.05514899f, -0.31667089f, -0.51609993f, -0.15591654f, 
    0.13000895f, 0.26816791f, 0.16393545f, 0.23238412f, -0.26919055f, -0.04338193f, -0.46727729f, -0.30306047f, 
    0.15551902f, 0.03972559f, -0.18515716f, -0.03816631f, -0.10274658f, 0.00827942f, 0.25546280f, 0.13827458f, 
    -0.44877541f, -0.17334138f, -0.46082255f, -0.65040296f, -0.50590205f, 0.10233097f, -0.52553350f, -0.24680896f, 
    0.35505214f, 0.40276739f, 0.37116450f, -0.14097515f, -0.09206088f, 0.20340887f, -0.11175560f, 0.09080436f, 
    0.21429861f, 0.25139686f, 0.16237666f, -0.03535361f, -0.08798820f, 0.21268640f, -0.01941234f, 0.22550738f, 
    0.60768002f, -0.78496325f, 0.79492438f, 0.60413021f, -0.32080874f, -0.06759303f, 0.24432190f, 0.25849971f, 
    0.33767152f, -0.31362748f, -0.07979684f, -0.10226608f, -0.01421961f, -0.19647889f, 0.00802674f, 0.02398292f, 
    -0.22946821f, -0.34251860f, -0.27958325f, -0.07589658f, -0.28999236f, 0.10005549f, 0.13423352f, 0.09627609f, 
    0.26402420f, -0.49806273f, -0.27724454f, 0.29836252f, 0.35116950f, -0.02776596f, 0.44306970f, 0.47582886f, 
    -0.48908088f, 0.00466405f, -0.41056129f, 0.12130175f, 0.49282750f, 0.30357000f, 0.32627749f, 0.09883106f, 
    0.23398049f, -0.00804380f, -0.22713037f, -0.45427647f, -0.05576043f, -0.26996475f, -0.32689506f, -0.20731722f, 
    0.23289762f, 0.09104706f, -0.02358651f, -0.79486227f, -0.54947233f, 0.05185937f, -0.17221966f, -0.62616366f, 
    0.56401438f, 0.12756720f, -0.61511207f, 0.16454886f, 0.23983374f, 0.41071948f, 0.26395875f, 0.08729060f, 
    0.05455773f, -0.33838400f, 0.10581009f, -0.20245779f, -0.38361380f, -0.38686582f, -0.03398510f, -0.27173269f, 
    0.38100591f, -0.09089821f, 0.06466505f, -0.29679590f, 0.76048142f, 0.49960741f, -0.76125991f, 0.09453198f, 
    -0.16085878f, -0.02237271f, -0.59882534f, -0.71776509f, -0.33619016f, 0.26025829f, 0.43255773f, 0.27774230f, 
    0.18312785f, 0.04888784f, -0.04919649f, 0.08214303f, 0.01145361f, -0.13195005f, 0.06753694f, 0.32379314f, 
    0.24227032f, 0.00055939f, -0.04154699f, 0.03676639f, 0.74323744f, -0.26458576f, -0.32122812f, 0.98246539f, 
    0.50908148f, -0.31349027f, 0.04648625f, -0.33933654f, 0.32373863f, 0.25400507f, -0.38961327f, -0.39289922f, 
    0.02591907f, 0.10276576f, -0.03304182f, 0.26262000f, 0.32723162f, 0.12571211f, -0.21769696f, 0.27426386f, 
    -0.09156973f, 0.06441723f, -0.17696036f, 0.14465606f, 0.17209926f, -0.38284701f, 0.85424691f, 0.16006057f, 
    -0.73802650f, 0.36334997f, -0.43765095f, 0.45408776f, 0.48361018f, 0.14665902f, 0.07497471f, -0.10632753f, 
    0.40691197f, -0.17746657f, 0.01551222f, 0.19778022f, 0.38696089f, -0.13060939f, -0.01450897f, -0.00628358f, 
    0.08156617f, 0.03041927f, 0.09917830f, 0.05597523f, 0.24171147f, 0.15362927f, 0.72767484f, -0.53149313f, 
    -0.02101910f, -0.04213259f, 0.58565158f, 0.24619688f, 0.41967961f, 0.04760274f, -0.06955928f, 0.41095272f, 
    0.20417251f, 0.22730327f, -0.26703224f, -0.11001167f, -0.04795370f, -0.29065421f, 0.05945601f, 0.02203394f, 
    0.41810480f, -0.24044898f, 0.03178726f, 0.10925867f, 0.02270992f, -0.18091621f, 0.08257876f, 0.31129128f, 
    -0.05680662f, 0.17293350f, 0.37249106f, 0.90082884f, 0.02001804f, -0.43037191f, -0.27818373f, -0.63485563f, 
    -0.26225591f, 0.36296517f, 0.49848208f, -0.05744730f, -0.00730978f, -0.12326049f, 0.12321360f, -0.16291481f, 
    0.17022882f, 0.36251935f, 0.02335329f, 0.03890278f, 0.30199870f, -0.06399482f, 0.14950214f, 0.10693484f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19323853f, 0.28247440f, 0.21109788f, 0.17183033f, 0.18481129f, 0.18594703f, 0.15349619f, 0.15135090f, 
    0.10986611f, 0.29786691f, 0.11163063f, 0.17752376f, 0.18047202f, 0.18288177f, 0.12340718f, 0.14743340f, 
    0.23294900f, 0.29447952f, -0.05401899f, 0.22119951f, 0.11345298f, 0.03589845f, 0.07071032f, 0.08262480f, 
    -0.04304090f, -0.07720413f, 0.16052745f, 0.09394030f, 0.00596319f, -0.02394296f, 0.17070687f, 0.24283437f, 
    0.08605848f, 0.18203025f, -0.07297281f, 0.13468000f, 0.31565425f, 0.15450056f, -0.04612869f, 0.01728595f, 
    0.01359346f, 0.27641800f, 0.11059851f, 0.23227644f, 0.19011174f, 0.05320444f, 0.16774127f, 0.06589959f, 
    0.20240495f, 0.18506356f, 0.22435755f, 0.21034101f, 0.03666539f, 0.22966541f, 0.25832823f, 0.29938695f, 
    -0.10612550f, 0.18846235f, -0.03207139f, 0.03387446f, 0.07483808f, 0.03289516f, 0.21000940f, 0.16283241f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05625313f, -0.12556092f, -0.12832303f, -0.09682928f, 0.13033973f, 0.07267994f, 0.00366786f, 0.04749433f, 
    0.07172035f, 0.02324280f, -0.05297499f, 0.03995627f, 0.12262254f, 0.19384374f, 0.15211992f, -0.05213525f, 
    -0.07857567f, 0.02690029f, 0.08984658f, -0.04977787f, 0.01493375f, 0.00398791f, -0.05738331f, 0.07785870f, 
    0.07039668f, -0.07999271f, 0.01620684f, 0.03545631f, -0.06487451f, 0.06024345f, -0.07480095f, -0.05447922f, 
    0.05377385f, -0.00219461f, -0.01746486f, -0.03346575f, -0.03629624f, -0.06882909f, 0.11094447f, 0.05738793f, 
    0.02341475f, 0.01214227f, 0.00856525f, 0.01216699f, -0.07061296f, 0.02323815f, 0.07638890f, 0.04573010f, 
    -0.06202384f, -0.06968995f, -0.07349858f, -0.06143220f, -0.04358321f, 0.11535850f, 0.00686597f, -0.05102455f, 
    0.13696806f, -0.04291069f, 0.03518954f, -0.12363937f, 0.24630661f, 0.25899342f, 0.09488308f, 0.04238597f, 
    -0.05028713f, 0.02377519f, -0.02923051f, 0.02757177f, -0.01893000f, -0.10610282f, -0.03732254f, -0.06339572f, 
    -0.01483503f, 0.20712164f, 0.13784662f, -0.15225634f, -0.02009772f, 0.03347687f, 0.10277486f, 0.06725429f, 
    0.01904658f, 0.01179184f, 0.07865294f, 0.01746484f, -0.03195941f, -0.00795813f, 0.02898561f, 0.15612398f, 
    -0.01829784f, 0.08617434f, 0.09767504f, -0.08977765f, -0.02188515f, -0.03687980f, -0.02733454f, -0.09587980f, 
    0.45721504f, -0.07938734f, 0.09544069f, -0.01123079f, 0.02607098f, -0.01286793f, 0.06361757f, -0.11754196f, 
    0.05985579f, 0.00210791f, 0.09863160f, -0.03511987f, 0.20913361f, 0.21386191f, 0.15673183f, -0.09276603f, 
    -0.08253857f, 0.03841008f, 0.02320017f, 0.08510732f, -0.12691917f, -0.05737227f, 0.01783863f, 0.03609190f, 
    -0.01989086f, -0.34460127f, -0.01045821f, -0.03847310f, 0.07472523f, -0.12083291f, 0.17742324f, 0.09466720f, 
    -0.00384271f, -0.06361915f, -0.01469985f, 0.03848581f, -0.08484355f, -0.17429632f, -0.00183956f, -0.09267899f, 
    0.00813018f, 0.02708607f, -0.00522367f, -0.07860406f, 0.05472139f, 0.03638161f, -0.00363739f, -0.00495057f, 
    -0.00283822f, 0.13518240f, 0.03891703f, 0.02097160f, -0.01681201f, 0.05702117f, 0.00797581f, 0.02634017f, 
    -0.04805862f, 0.07765041f, 0.06890006f, 0.08385081f, 0.05264777f, 0.26595598f, -0.14618911f, 0.13585360f, 
    -0.04383039f, -0.04949060f, 0.01660543f, 0.05135667f, -0.05606148f, 0.09363745f, 0.00688524f, 0.05565446f, 
    0.36917448f, 0.00499798f, -0.07450704f, -0.12078081f, 0.04459103f, 0.06947132f, 0.01078061f, 0.00294827f, 
    0.00333521f, 0.11647539f, 0.04150621f, -0.03964157f, 0.05612979f, -0.14593385f, 0.12874134f, -0.03981873f, 
    0.06756020f, 0.08003557f, 0.07782294f, -0.04682353f, 0.01153439f, 0.06210218f, 0.00567498f, -0.10659420f, 
    0.10684129f, 0.14779413f, 0.03132400f, 0.06744736f, -0.06606690f, -0.00632875f, 0.04679608f, 0.02809098f, 
    -0.07710908f, 0.03971936f, 0.02489222f, -0.00689930f, -0.09610945f, -0.04886206f, 0.12708877f, -0.09263243f, 
    0.03053857f, 0.01984628f, -0.09726870f, 0.05826637f, 0.03849555f, -0.05985110f, 0.06132130f, 0.09294114f, 
    -0.04045044f, 0.25357309f, -0.00366054f, 0.04475612f, 0.00503104f, 0.07253329f, 0.09182996f, -0.03739784f, 
    0.02610189f, 0.08772653f, 0.03328559f, 0.12186049f, 0.12789372f, 0.03990137f, -0.05894681f, -0.05473205f, 
    0.00525280f, 0.10367073f, 0.04829989f, -0.00092949f, -0.06929794f, 0.00834117f, 0.06258827f, 0.06760687f, 
    -0.09260239f, 0.00594509f, -0.05811658f, 0.13847700f, -0.00010705f, 0.07853377f, 0.06469744f, -0.04003302f, 
    0.00710687f, 0.04055596f, -0.05941631f, -0.02638284f, -0.32226405f, 0.10452512f, -0.02235950f, 0.28554669f, 
    0.04613360f, 0.06999836f, -0.00219057f, 0.01156212f, -0.02195333f, 0.05219610f, -0.01143423f, -0.12571782f, 
    0.02085691f, 0.28361362f, -0.03814297f, 0.15390037f, -0.11686573f, 0.04284756f, -0.01090898f, -0.01506968f, 
    -0.03637630f, -0.05411893f, 0.00811707f, 0.08582839f, 0.15729418f, 0.04642146f, -0.12037434f, 0.02044729f, 
    -0.02312209f, -0.06433558f, 0.01442875f, -0.03935529f, 0.03493251f, -0.04662177f, 0.05521011f, 0.10531794f, 
    -0.14717111f, -0.06580643f, -0.19615279f, -0.13868384f, 0.00884442f, 0.04144238f, 0.01676262f, 0.07742246f, 
    -0.00982072f, 0.06881282f, -0.07877413f, 0.09340512f, -0.10725944f, -0.20710553f, 0.25476196f, 0.16556361f, 
    -0.06233752f, -0.03581074f, 0.09156442f, 0.02105864f, 0.00371704f, 0.08893052f, 0.06174963f, 0.04278077f, 
    0.12616020f, -0.02360224f, 0.02151249f, 0.15142934f, -0.04843284f, 0.03577552f, 0.02147964f, 0.04850864f, 
    -0.01017381f, 0.06497473f, 0.00633223f, 0.03282524f, 0.06979746f, 0.08045977f, -0.07990693f, 0.08334709f, 
    -0.08663885f, 0.02128161f, -0.07843374f, -0.00095086f, -0.08777168f, -0.01435995f, 0.09994768f, -0.02541013f, 
    0.07146911f, 0.05905427f, -0.29405522f, 0.02598501f, -0.00132679f, 0.11175431f, -0.03304863f, 0.09922311f, 
    0.02615613f, 0.05045478f, 0.00487187f, -0.13765778f, 0.35177600f, -0.15620133f, 0.06395984f, 0.01218573f, 
    0.09607146f, 0.11208349f, -0.03929242f, -0.04892777f, 0.01889931f, -0.04954017f, 0.07644670f, -0.08547419f, 
    0.21018408f, 0.08792727f, 0.00033604f, -0.13218910f, 0.03289198f, 0.02970850f, -0.00734863f, -0.04935476f, 
    -0.02244849f, 0.00196133f, -0.04207552f, 0.03135647f, -0.17499082f, -0.05967267f, -0.04240322f, 0.20496595f, 
    -0.01044889f, -0.02883697f, 0.01242624f, -0.09289522f, -0.00518971f, -0.00399657f, -0.02911047f, 0.00833377f, 
    0.08239579f, 0.00312744f, 0.07909257f, -0.03081040f, -0.05499592f, -0.07549874f, 0.03177918f, 0.14843562f, 
    0.11121342f, 0.02282310f, -0.00860814f, -0.02895903f, -0.04104852f, -0.14679483f, -0.09430877f, 0.10210300f, 
    0.01957296f, 0.01179709f, 0.03753415f, -0.00766754f, 0.02861740f, -0.00299765f, -0.01602486f, -0.01150254f, 
    0.18388578f, 0.14467904f, -0.20922878f, -0.05409732f, -0.06605908f, 0.05394853f, 0.00250565f, -0.02475411f, 
    0.05244333f, 0.16437513f, -0.05849802f, 0.06968237f, -0.02501875f, 0.08837844f, -0.01273653f, 0.06162740f, 
    -0.01013484f, -0.02808515f, 0.05119434f, 0.09777158f, -0.07831408f, 0.05877328f, 0.11495180f, -0.11323048f, 
    -0.20480755f, 0.27292874f, 0.07138563f, 0.01202268f, 0.04794469f, 0.02469026f, 0.02866789f, 0.07485374f, 
    -0.05361155f, -0.04183432f, 0.04967916f, -0.04344055f, 0.06828208f, -0.07441648f, 0.07100433f, -0.02789794f, 
    -0.08514344f, 0.07092165f, -0.01489694f, 0.05760461f, 0.07423627f, 0.03401143f, -0.03630108f, -0.03345501f, 
    0.14500536f, -0.09370818f, -0.01196570f, -0.19969185f, 0.05008644f, -0.00253231f, 0.06940728f, 0.01030353f, 
    -0.04161905f, -0.09051516f, 0.01686857f, 0.07471077f, -0.17055336f, -0.23963110f, -0.01611713f, -0.24089275f, 
    -0.06844852f, 0.01454712f, -0.02379967f, 0.01302306f, -0.05073979f, 0.11720279f, 0.04964516f, -0.04364073f, 
    0.05417540f, 0.05873511f, -0.07310475f, -0.17672527f, 0.09855601f, 0.03146269f, -0.03706289f, -0.04003589f, 
    -0.05004825f, 0.07835320f, 0.04651465f, 0.01900067f, 0.09057215f, -0.09162822f, 0.15585949f, -0.08115053f, 
    -0.14514115f, -0.01727443f, 0.09372547f, 0.07856122f, 0.00735857f, 0.00120899f, -0.05922969f, -0.04593002f, 
    -0.20015153f, -0.02606785f, -0.10380223f, 0.17332132f, 0.04123200f, 0.05185521f, 0.03398275f, -0.02159677f, 
    -0.02584703f, 0.01911680f, -0.04972511f, 0.09612963f, -0.03657497f, 0.05624078f, 0.00995130f, 0.08619695f, 
    0.07638600f, 0.01418591f, 0.05340094f, -0.07288750f, 0.03402240f, 0.15380204f, 0.04568449f, -0.01854836f, 
    -0.11629476f, -0.06940870f, -0.06244006f, -0.07385629f, 0.04355862f, 0.09951607f, 0.04756279f, 0.02469950f, 
    0.08282953f, 0.01312459f, -0.03317537f, -0.03322300f, 0.00747064f, -0.02071353f, 0.21970159f, 0.06010558f, 
    -0.02112239f, -0.00922420f, -0.06766935f, 0.08767624f, -0.02569308f, 0.01019347f, -0.04868844f, -0.10845757f, 
    -0.22563891f, 0.07362429f, 0.01183518f, 0.13930526f, -0.02075529f, -0.00734544f, 0.10642700f, -0.05638463f, 
    -0.00669347f, 0.03806123f, -0.01780220f, -0.03460394f, 0.04290343f, -0.02027493f, 0.17017132f, -0.19011134f, 
    -0.02626444f, 0.04459951f, 0.00997405f, 0.01401183f, 0.04618926f, -0.05856614f, -0.07119333f, 0.05199547f, 
    0.06519836f, -0.03090533f, -0.21491352f, -0.06653924f, 0.02120229f, 0.06058432f, 0.09987562f, 0.04228130f, 
    -0.00912282f, 0.02159216f, -0.06802067f, 0.11865397f, 0.13996878f, 0.09660157f, -0.00054905f, -0.13156530f, 
    -0.00648705f, -0.00292609f, -0.07435492f, -0.07478920f, -0.10051271f, 0.05421209f, -0.00625558f, 0.00993142f, 
    0.07277571f, 0.05072490f, -0.12311133f, -0.03673522f, 0.00923312f, 0.02213352f, -0.05524630f, 0.10192090f, 
    0.04513887f, -0.00134640f, 0.08384697f, -0.08012307f, 0.06935241f, -0.05365396f, 0.09584710f, 0.01669474f, 
    -0.14393155f, -0.06442357f, -0.00001988f, -0.01920263f, -0.08832581f, -0.04736684f, -0.06615486f, 0.02662202f, 
    0.20306447f, 0.07013517f, -0.02466229f, -0.15708718f, 0.01569740f, -0.03056234f, 0.03802712f, 0.09986433f, 
    0.08746779f, 0.02565392f, 0.04333802f, 0.03754919f, -0.00250365f, 0.01440263f, 0.05270896f, -0.09272765f, 
    0.00817133f, 0.06254166f, 0.08697087f, -0.04490202f, 0.01585443f, -0.03588564f, 0.04793449f, 0.02883231f, 
    0.29931891f, -0.10182613f, 0.06073509f, 0.03338084f, 0.00119078f, 0.08959027f, -0.06123379f, 0.00456089f, 
    -0.02656317f, -0.06692790f, 0.00840324f, -0.11307840f, -0.31601229f, -0.12491103f, 0.08628517f, 0.05059558f, 
    0.03966391f, -0.06819098f, 0.05959705f, 0.03859078f, 0.01391152f, -0.05239761f, -0.06794836f, -0.08327885f, 
    0.11875093f, -0.00153944f, -0.13252276f, 0.32758960f, -0.01067914f, 0.07825727f, 0.08042146f, 0.07765059f, 
    0.00586305f, 0.07845958f, 0.03662790f, -0.15145390f, 0.09218727f, -0.09371075f, 0.13313530f, 0.02458960f, 
    0.00195004f, 0.03890342f, 0.01529103f, 0.00267237f, 0.01322704f, 0.01151042f, 0.00638793f, -0.05620336f, 
    0.35208809f, -0.27441144f, 0.01559659f, -0.05138087f, -0.10706931f, -0.06521834f, -0.09809996f, -0.00277708f, 
    0.11803736f, 0.09085912f, -0.01536077f, -0.04352510f, -0.25609902f, 0.07572816f, 0.06433585f, 0.05823719f, 
    0.08351858f, 0.11942977f, 0.06956872f, 0.04354640f, -0.07841778f, -0.08619724f, -0.11537642f, 0.00335614f, 
    0.14388032f, -0.05723040f, 0.01470706f, -0.05449083f, -0.03716736f, 0.10967359f, -0.00954332f, -0.06543888f, 
    0.01720601f, 0.01534522f, 0.03325431f, 0.05996987f, -0.03069656f, -0.05522015f, 0.01163787f, -0.00635479f, 
    0.00649834f, 0.04321996f, 0.07268112f, -0.03866382f, 0.03980966f, -0.02298797f, -0.02644089f, 0.05110090f, 
    0.25701040f, -0.05029727f, 0.32917628f, -0.13915741f, -0.08394986f, 0.05931914f, -0.01969437f, 0.01564278f, 
    -0.07875945f, -0.01266517f, -0.02398779f, 0.02297103f, 0.36655766f, -0.00694128f, 0.23227853f, -0.04127856f, 
    0.00775279f, 0.11792631f, -0.05368846f, -0.03830388f, -0.13114825f, -0.08912420f, -0.02189473f, -0.01086020f, 
    -0.08654363f, 0.07592850f, 0.05120142f, 0.14015740f, 0.00736596f, 0.05709909f, 0.05678282f, -0.08366332f, 
    0.00986387f, 0.00737604f, 0.05301242f, 0.04874057f, -0.42999101f, 0.00725634f, -0.03676783f, -0.24311021f, 
    0.01781067f, -0.04420005f, -0.03449032f, -0.02436114f, -0.10912336f, 0.01483746f, -0.01147591f, -0.02543059f, 
    0.31225693f, 0.06716044f, 0.02496289f, -0.01783455f, 0.11174044f, -0.03895408f, 0.10662467f, 0.05573882f, 
    -0.00955379f, -0.01924078f, 0.00068668f, 0.10264935f, 0.02061844f, -0.07623350f, 0.03371957f, 0.14022134f, 
    0.03364221f, 0.06880999f, -0.04904535f, 0.08511271f, 0.08391794f, -0.01874359f, 0.02693104f, 0.04578625f, 
    0.34390876f, 0.07304502f, 0.10465473f, 0.14404665f, 0.16215193f, -0.04836069f, 0.12305678f, 0.10477724f, 
    -0.06461888f, 0.05858565f, -0.00529078f, 0.13441421f, -0.09559488f, -0.11778391f, 0.12517667f, -0.12836643f, 
    0.00208038f, 0.01791722f, -0.05400654f, -0.06572593f, -0.03918185f, 0.01528695f, 0.10872193f, 0.06628973f, 
    -0.15327558f, -0.03544497f, -0.06608140f, 0.00083615f, 0.11518211f, -0.00911467f, -0.10340846f, -0.09207536f, 
    0.09043963f, 0.02848908f, 0.02598647f, 0.04894615f, 0.34751216f, -0.05784247f, -0.11044966f, -0.10592090f, 
    0.09911580f, -0.03315684f, -0.05604183f, 0.10297121f, -0.05101442f, 0.04036971f, 0.07370689f, 0.07830474f, 
    -0.16289875f, 0.03746371f, 0.04911799f, -0.19580117f, 0.02322633f, -0.00072274f, -0.04999371f, 0.02634078f, 
    -0.02353817f, 0.05046002f, 0.10772258f, -0.00784796f, -0.26739430f, -0.05729872f, -0.11591163f, -0.05764188f, 
    0.04538128f, 0.04256772f, -0.00859830f, -0.10943055f, -0.12064601f, -0.01828172f, 0.03441374f, 0.06752710f, 
    -0.09661716f, 0.31368914f, 0.05973032f, 0.28114823f, -0.00871394f, 0.13455631f, -0.13311079f, 0.02021751f, 
    0.15666720f, 0.05546781f, -0.04783973f, 0.03237126f, -0.06198661f, 0.23072241f, 0.05024559f, 0.14057717f, 
    0.06389021f, 0.04907229f, -0.00218332f, 0.04550363f, 0.01437245f, 0.00412877f, 0.04135494f, -0.00838927f, 
    -0.24395211f, -0.09046154f, -0.12501694f, -0.27367818f, 0.07613344f, -0.02092086f, -0.03120584f, -0.09475209f, 
    -0.01139443f, -0.04810314f, -0.09015831f, 0.04719112f, -0.24268983f, -0.09787539f, 0.13088514f, -0.28094047f, 
    0.10716967f, 0.04133343f, -0.03100834f, -0.06136743f, -0.03781812f, -0.01315878f, 0.01317463f, -0.01462107f, 
    -0.25865555f, 0.10091577f, -0.02875084f, 0.11592980f, 0.05271726f, 0.04599622f, 0.07025782f, 0.00505512f, 
    0.05432705f, -0.07056353f, 0.08123636f, 0.10019925f, -0.32064742f, 0.10988081f, -0.07987256f, -0.02605648f, 
    -0.00017932f, 0.00164693f, -0.06059583f, 0.02487439f, -0.01501641f, -0.05845935f, 0.09394009f, 0.16258490f, 
    -0.24903981f, 0.01991485f, -0.01138432f, -0.13037197f, 0.05350506f, 0.04769181f, -0.03363320f, -0.10025879f, 
    0.08253507f, -0.01451187f, -0.06944338f, 0.01942307f, 0.13859111f, 0.00600798f, -0.08306428f, 0.12729545f, 
    0.04267831f, 0.05941455f, 0.04517045f, 0.02307999f, 0.05165067f, 0.03338971f, -0.04062100f, -0.03582620f, 
    0.14702117f, -0.41112214f, 0.06258746f, -0.16149373f, -0.09587596f, -0.04080878f, -0.00193397f, 0.00239688f, 
    0.03982793f, 0.07469088f, 0.05384697f, 0.15012766f, 0.13188726f, -0.13973628f, 0.12043969f, -0.14106312f, 
    0.01036143f, -0.03243184f, -0.00518302f, 0.00694848f, -0.00776007f, -0.00927524f, -0.04407718f, 0.07627799f, 
    0.27430755f, -0.05237554f, 0.09471353f, -0.14283471f, -0.02107437f, -0.03358984f, 0.03671500f, -0.07398577f, 
    0.06326953f, -0.01496102f, 0.03154747f, 0.13350056f, 0.27856407f, 0.12178192f, -0.03434452f, 0.19651026f, 
    0.10499845f, -0.11568854f, 0.02434488f, 0.08125633f, -0.00397969f, -0.00001521f, 0.07200460f, 0.02790295f, 
    0.07493636f, -0.15412654f, 0.06158179f, -0.17101270f, 0.20815034f, 0.04501640f, 0.05631070f, 0.02730912f, 
    0.02676570f, -0.01838009f, 0.08318493f, -0.06659823f, 0.07836467f, -0.07998800f, 0.08399066f, -0.08323408f, 
    0.02126205f, 0.01705620f, 0.05412438f, -0.00321149f, 0.01869213f, 0.12049129f, 0.00337401f, -0.04848825f, 
    0.14291824f, 0.04539506f, 0.23079892f, -0.00184307f, 0.02117993f, 0.09606414f, 0.09066082f, 0.01048213f, 
    0.01456161f, -0.04950344f, 0.00451065f, 0.00678535f, -0.06680016f, 0.02889569f, -0.14418131f, 0.02654385f, 
    0.08177219f, 0.03619670f, 0.01926255f, 0.07049038f, 0.01675011f, 0.00716318f, 0.01514888f, -0.00780652f, 
    -0.11880005f, 0.06599063f, 0.00640528f, -0.15688655f, 0.08315214f, -0.08855098f, -0.05710428f, -0.08472194f, 
    0.03521338f, -0.01563311f, 0.05650740f, -0.02771808f, -0.00232352f, 0.01530122f, 0.01105785f, -0.13906245f, 
    0.08176129f, -0.01655338f, 0.07169796f, -0.07980613f, 0.03708753f, 0.02277271f, 0.01148095f, 0.03637937f, 
    0.26061985f, 0.09580411f, 0.29186115f, -0.02120451f, 0.05033290f, -0.13090508f, 0.03321759f, 0.03759630f, 
    0.06084069f, -0.03056223f, 0.09158289f, 0.03738277f, -0.09905986f, 0.05808481f, 0.00123445f, -0.12125309f, 
    0.08090937f, -0.03924419f, 0.05116794f, 0.03963023f, 0.07869987f, -0.00897515f, 0.04004931f, -0.07268836f, 
    -0.23010266f, -0.14506187f, -0.00428995f, 0.05458273f, -0.02079869f, -0.03995595f, 0.04945892f, 0.08025873f, 
    0.02134434f, -0.00647443f, 0.04185569f, -0.03410698f, 0.09835697f, 0.00194174f, 0.18802771f, 0.05608710f, 
    0.03589780f, 0.00778155f, 0.01908322f, 0.06907705f, 0.04099417f, -0.03167894f, -0.03911651f, -0.02755020f, 
    -0.44392693f, 0.19984491f, -0.09737150f, -0.11924611f, 0.03260823f, 0.04901960f, 0.03209790f, -0.11849060f, 
    0.00126374f, -0.05380637f, 0.05073695f, 0.02767248f, 0.00466242f, -0.22297263f, 0.15384996f, 0.23916656f, 
    0.07527021f, -0.06848238f, -0.07868867f, -0.01597132f, -0.11200184f, -0.02548331f, 0.06252800f, -0.00186075f, 
    -0.02283739f, -0.04293998f, 0.14671376f, -0.05030825f, -0.08057573f, -0.01649018f, 0.06627557f, 0.00385155f, 
    0.12491824f, -0.11922666f, 0.02473157f, 0.08617524f, -0.26950234f, 0.07083914f, 0.01343330f, 0.06591842f, 
    -0.00293532f, 0.11074131f, 0.00779713f, -0.09159552f, 0.07811095f, -0.01223415f, -0.12089246f, 0.10384914f, 
    0.03119350f, -0.39270288f, 0.07653455f, 0.19459648f, 0.06721730f, 0.06421066f, 0.00852608f, -0.01882250f, 
    -0.05388391f, 0.07386433f, -0.03689880f, 0.09414323f, -0.02438891f, 0.05452907f, -0.11688990f, -0.08771437f, 
    0.12019747f, 0.00457114f, 0.02789591f, -0.08320297f, 0.05993673f, 0.03134473f, 0.11598726f, 0.06583755f, 
    0.02964790f, 0.16610736f, -0.11667658f, 0.16838913f, -0.03008869f, 0.09850210f, -0.04360069f, 0.08630416f, 
    0.05030967f, -0.00317361f, -0.04096222f, -0.01634097f, 0.02525880f, 0.19995692f, -0.05644394f, 0.09963970f, 
    0.03602534f, 0.07018636f, -0.09885401f, 0.05054552f, 0.09966011f, 0.08583897f, -0.03944102f, 0.06861314f, 
    -0.09896072f, 0.06850343f, 0.05053421f, -0.06110927f, -0.00877336f, 0.10635165f, 0.06345474f, 0.06420432f, 
    0.02192931f, 0.01238236f, -0.04512655f, 0.07526125f, -0.19078490f, 0.22246800f, 0.05330249f, 0.21818544f, 
    0.07715762f, 0.09268717f, -0.07987397f, 0.03514434f, 0.01820400f, 0.04062011f, 0.03207686f, -0.01075689f, 
    0.24163321f, 0.04398587f, 0.24134748f, -0.09340604f, 0.00324426f, -0.00460604f, -0.07813813f, 0.00242719f, 
    -0.04193946f, 0.03942501f, 0.00729743f, 0.02504613f, 0.10442268f, 0.04915149f, 0.07370738f, 0.10281024f, 
    0.02602592f, 0.00402837f, 0.07994650f, 0.05894256f, -0.06031923f, -0.03450331f, 0.05817378f, 0.09767332f, 
    0.03799374f, -0.02194936f, 0.03020913f, 0.02317242f, 0.01960344f, -0.00731931f, 0.03569222f, 0.07162440f, 
    0.03530916f, 0.03061495f, 0.06955104f, 0.01095064f, -0.19978942f, 0.10207070f, -0.08650201f, -0.06461293f, 
    0.08874922f, 0.05568384f, -0.03139720f, -0.08102484f, 0.00768601f, -0.01372342f, 0.10904904f, 0.01555299f, 
    0.27067384f, 0.06061250f, -0.04667312f, -0.07258264f, -0.01805308f, 0.01783386f, -0.00884148f, -0.01728410f, 
    -0.02320257f, 0.03771286f, -0.04669535f, 0.13186860f, -0.23230967f, 0.28888214f, -0.05498194f, 0.07149188f, 
    0.03322199f, -0.01284894f, -0.06281878f, 0.04782969f, 0.01289925f, 0.06410294f, 0.06666005f, -0.04600318f, 
    0.14153014f, -0.24065715f, 0.11832801f, 0.02641565f, 0.06719556f, 0.06539124f, 0.07030310f, -0.06266786f, 
    -0.04438425f, 0.01708543f, 0.02488639f, 0.03378224f, -0.02472824f, -0.16326803f, 0.05033667f, 0.06096543f, 
    0.02813714f, -0.10664941f, -0.03711956f, 0.04349424f, -0.02813303f, 0.01878724f, 0.02535486f, -0.00470899f, 
    0.12551418f, 0.08138633f, 0.03364839f, 0.14368299f, 0.06074022f, 0.01771135f, 0.06026443f, -0.05249154f, 
    0.01585479f, 0.04680038f, 0.04533660f, 0.02706108f, -0.03415542f, 0.11931682f, 0.14211883f, 0.22766300f, 
    0.06079485f, -0.05706442f, -0.06720134f, 0.10448466f, 0.09499749f, 0.00958673f, 0.05642929f, 0.04359110f, 
    0.00745312f, -0.03088644f, 0.09729086f, 0.11514732f, 0.05311495f, 0.10621053f, 0.01221564f, -0.09926177f, 
    -0.02637456f, 0.11091251f, 0.02413574f, 0.02976453f, 0.16117463f, -0.04021598f, -0.12337431f, 0.00533911f, 
    -0.04122316f, 0.03536268f, 0.00062072f, 0.15192559f, 0.13470085f, 0.04132524f, -0.03696624f, 0.03391918f, 
    -0.04119647f, 0.10774678f, -0.03160460f, 0.09742794f, 0.00719946f, 0.07431201f, 0.00584683f, 0.01205843f, 
    0.02391258f, -0.04894885f, -0.06193110f, 0.12016303f, 0.13890696f, 0.15535015f, -0.09762643f, 0.02355936f, 
    -0.00857037f, 0.01213569f, -0.05203283f, -0.01304486f, 0.03885955f, 0.01719674f, -0.02851663f, 0.08579594f, 
    0.35901788f, -0.01378115f, 0.05093278f, -0.32194552f, 0.05514040f, 0.00719218f, -0.05010662f, -0.08748122f, 
    -0.04191510f, -0.07331376f, 0.02498069f, 0.17162642f, 0.00228303f, 0.06061999f, -0.12865297f, 0.05130123f, 
    0.01219100f, 0.01570848f, 0.02498372f, -0.00149613f, 0.02455183f, 0.07171091f, 0.02030618f, 0.02253658f, 
    -0.10537603f, -0.01264144f, 0.08509979f, 0.05589701f, -0.00583822f, 0.09871595f, 0.12572017f, 0.05000668f, 
    -0.00137405f, 0.06503418f, 0.00461788f, 0.01999011f, 0.39176071f, -0.22273450f, -0.01438796f, -0.02745381f, 
    0.04359666f, -0.12214391f, -0.06801593f, 0.00194906f, -0.00549376f, -0.00139836f, 0.06047670f, 0.00775785f, 
    -0.31325534f, 0.11298743f, 0.11445343f, -0.22754732f, -0.02431629f, -0.09767669f, 0.02608531f, 0.06159514f, 
    0.03972100f, -0.02518746f, -0.00884807f, 0.07148402f, 0.10429673f, -0.27591121f, 0.20361887f, 0.26185158f, 
    0.11741392f, -0.02257703f, -0.08052767f, 0.00090952f, -0.02257603f, -0.02738195f, 0.03857004f, 0.03114918f, 
    -0.11538295f, 0.09272296f, -0.23183180f, 0.13398755f, 0.01683450f, 0.02061205f, 0.07235745f, -0.10007778f, 
    -0.00412107f, 0.05950941f, 0.04116463f, 0.05103350f, -0.11792435f, 0.14363807f, -0.29411113f, -0.16577703f, 
    0.01393121f, -0.06494396f, 0.09623165f, 0.05829534f, 0.03528947f, 0.09381827f, -0.00782948f, -0.01872345f, 
    0.13077486f, 0.08218922f, -0.09350095f, -0.13766560f, -0.01423187f, 0.01476759f, -0.02366293f, 0.10967214f, 
    0.05424727f, 0.07773373f, 0.14696611f, 0.00352822f, -0.18019949f, -0.33159065f, 0.01864726f, 0.10579863f, 
    -0.09641791f, -0.05552025f, -0.00586667f, 0.06353486f, 0.04904214f, 0.03549498f, 0.14700668f, 0.14361866f, 
    -0.04366903f, -0.02410320f, 0.07963622f, 0.00248616f, -0.02071516f, -0.01505031f, 0.00402575f, -0.01480321f, 
    0.01911404f, -0.00526736f, -0.04709515f, 0.02609397f, 0.05737795f, 0.28834197f, 0.00688449f, -0.10298863f, 
    0.17451155f, -0.13756812f, 0.03266815f, 0.06763665f, -0.02862818f, 0.13847175f, -0.09239690f, -0.08691582f, 
    0.05742640f, -0.01709878f, 0.01489613f, 0.08795105f, 0.00262547f, -0.00380670f, 0.16360468f, 0.09779844f, 
    -0.02287934f, -0.02735642f, 0.00507975f, 0.02761188f, 0.00160162f, 0.07240640f, 0.06308088f, 0.15139543f, 
    0.07449210f, 0.05732911f, 0.03119400f, 0.13908713f, -0.04869934f, -0.03667707f, -0.03182271f, 0.00069906f, 
    -0.06682140f, -0.20497274f, -0.06649655f, -0.06562930f, -0.05208904f, -0.05576964f, 0.04891324f, -0.01594819f, 
    0.01588443f, 0.01993641f, -0.15377410f, 0.12280101f, -0.49835348f, 0.06027129f, 0.10355590f, 0.34089485f, 
    -0.08053567f, 0.01081520f, -0.02101839f, 0.10802666f, 0.09507779f, 0.08266959f, 0.10756778f, 0.05385079f, 
    0.02679347f, -0.03500132f, -0.01122236f, 0.28170076f, 0.00851410f, 0.00249960f, -0.05470106f, 0.08794083f, 
    -0.03406456f, 0.05084332f, -0.05565330f, -0.00717297f, -0.28840059f, -0.32120520f, 0.01255868f, 0.10204973f, 
    -0.02414557f, 0.07728495f, -0.01757160f, 0.03789152f, 0.11054197f, 0.05769645f, 0.07107347f, 0.01016397f, 
    -0.02589183f, -0.34649840f, 0.10977513f, -0.20863640f, -0.06091796f, 0.03676921f, 0.00630507f, 0.02884768f, 
    0.01513116f, -0.03125987f, 0.02464816f, 0.03796785f, 0.10176402f, 0.01320488f, 0.01338938f, 0.00025495f, 
    0.05161246f, 0.01880237f, 0.10225779f, 0.04316782f, 0.10626280f, 0.12770401f, 0.10011746f, -0.01941275f, 
    -0.04906867f, -0.14513864f, 0.06659026f, 0.17069031f, -0.09271617f, 0.05190527f, 0.04768822f, 0.09407214f, 
    0.16032685f, 0.11305615f, 0.06726602f, -0.00963848f, -0.13317254f, -0.10739139f, -0.01168332f, 0.27757221f, 
    0.00080288f, 0.12212418f, -0.00919859f, 0.06783655f, 0.05172976f, -0.06437805f, 0.07878377f, -0.01859296f, 
    0.02397634f, 0.14976330f, -0.00469922f, 0.02184129f, 0.04922564f, -0.06780693f, -0.03997588f, -0.10604302f, 
    0.00008943f, 0.00640623f, 0.01307737f, -0.02375072f, 0.28218478f, -0.12610313f, 0.02301659f, -0.02717280f, 
    -0.03261287f, -0.04366640f, 0.12779671f, 0.05142060f, 0.04204973f, 0.01228450f, -0.01791159f, -0.01538328f, 
    0.08229285f, -0.29197985f, -0.06113371f, -0.04735348f, -0.06680735f, 0.03681115f, -0.04874517f, -0.03276683f, 
    0.02257868f, -0.07906166f, -0.01604589f, 0.01204596f, 0.06673027f, 0.10943983f, -0.05095702f, 0.03392251f, 
    -0.02408648f, -0.00908602f, 0.08442393f, 0.03938561f, 0.03586461f, 0.12172958f, 0.16320293f, 0.02394261f, 
    -0.19578870f, 0.35328510f, -0.05588165f, 0.03082256f, -0.04731317f, 0.05774478f, -0.02286949f, 0.09437741f, 
    0.01473121f, -0.05468019f, 0.05428324f, -0.25000119f, 0.17718872f, 0.20642382f, -0.05376709f, 0.06648225f, 
    0.00695626f, -0.10887527f, 0.04418172f, -0.00174999f, -0.07393065f, -0.06685126f, -0.15952545f, -0.12142584f, 
    -0.13606669f, 0.07789518f, -0.06078171f, 0.02119747f, -0.03753234f, 0.08684199f, -0.12403006f, -0.03420410f, 
    0.00834385f, -0.07477441f, -0.08720757f, -0.17947161f, -0.31307024f, -0.08938304f, 0.04884447f, 0.26850009f, 
    0.08213588f, 0.03498875f, 0.06784256f, -0.17260848f, -0.05321714f, -0.00109167f, -0.03253282f, 0.01298741f, 
    -0.28121507f, 0.08799484f, -0.00387107f, 0.28620762f, -0.04142094f, 0.01511951f, -0.04149422f, 0.04004673f, 
    0.00258311f, 0.11672855f, -0.02254841f, 0.04694259f, 0.06398631f, -0.01766240f, -0.02537774f, 0.04065597f, 
    0.06836294f, -0.01134146f, 0.03989229f, 0.07424632f, 0.04456605f, 0.00845522f, -0.01291502f, 0.12657814f, 
    0.09128962f, 0.08989228f, -0.11006863f, -0.07005507f, -0.02388819f, 0.04899704f, 0.07435407f, 0.00392779f, 
    -0.07047942f, -0.06087954f, -0.05260828f, 0.02465428f, -0.18027504f, 0.08595505f, 0.23411639f, -0.14853507f, 
    0.05264444f, -0.01091084f, -0.06243358f, 0.13708788f, 0.04358236f, -0.16317114f, -0.03063045f, -0.18695492f, 
    -0.06876387f, 0.01180330f, -0.03292976f, 0.15298964f, 0.02788091f, -0.12054972f, 0.01862092f, -0.00203681f, 
    -0.00565538f, -0.04289959f, 0.02563248f, -0.09764104f, 0.03332060f, -0.11572805f, -0.19433445f, 0.15312178f, 
    0.00427367f, -0.15541255f, -0.00404753f, 0.04811604f, 0.07672125f, 0.06271827f, 0.05284001f, 0.04218135f, 
    -0.13790168f, 0.08135960f, 0.07851046f, 0.10048103f, 0.03304991f, 0.06453208f, -0.04469666f, 0.01973554f, 
    -0.00090417f, -0.09507814f, -0.02848841f, 0.03627350f, 0.04360105f, 0.10076227f, 0.06807333f, 0.04070970f, 
    0.03964883f, -0.04649538f, 0.10270322f, 0.05711804f, 0.05931031f, 0.10332491f, 0.03492387f, 0.26768348f, 
    0.00741332f, 0.24129087f, -0.00870950f, -0.08727778f, 0.01027502f, -0.04230628f, -0.01319997f, -0.12492373f, 
    0.09545963f, -0.02041757f, 0.08610247f, 0.14572221f, 0.17060037f, 0.05291586f, -0.04770977f, -0.02973094f, 
    -0.00698247f, 0.05939821f, 0.08132984f, 0.05097444f, 0.10789372f, 0.06159371f, 0.00055338f, 0.11449872f, 
    -0.18821099f, -0.34139818f, -0.09192650f, 0.04741380f, -0.08958651f, 0.07178739f, 0.00508056f, 0.00800567f, 
    0.13964158f, 0.01015999f, 0.06951629f, 0.19340228f, -0.07628392f, 0.34893546f, 0.10127525f, -0.07141414f, 
    0.11041430f, 0.03898628f, 0.10554927f, 0.01541507f, 0.13063304f, 0.14065154f, -0.11736333f, 0.05689279f, 
    0.12387565f, 0.11660843f, -0.08823626f, -0.19812745f, -0.13432503f, 0.05025849f, -0.02747314f, -0.07552589f, 
    -0.17335853f, -0.09194935f, 0.00125433f, -0.05933743f, -0.38650107f, -0.39821145f, -0.17233339f, -0.05541040f, 
    0.06582461f, 0.00968891f, 0.00309126f, -0.09405392f, 0.07147393f, -0.07845114f, -0.02945780f, 0.07725643f, 
    -0.48363417f, 0.01813184f, -0.01939494f, -0.07005153f, -0.05128092f, 0.03779901f, 0.04333477f, 0.07391954f, 
    0.13063546f, 0.04481707f, 0.07511944f, 0.08975280f, -0.01481049f, 0.03481391f, 0.03209282f, 0.08576768f, 
    -0.07992420f, -0.09965163f, -0.06983244f, -0.05813222f, 0.00312614f, -0.01035354f, -0.04599014f, 0.00592607f, 
    0.24396691f, -0.16606693f, 0.12021396f, -0.19438317f, -0.05045867f, 0.08342358f, 0.00735554f, -0.09334251f, 
    0.05262838f, -0.04545119f, -0.18627508f, -0.21163714f, 0.16219762f, 0.03155912f, -0.11900658f, 0.02096393f, 
    0.03258373f, -0.00027362f, 0.05179910f, 0.02775897f, 0.04674922f, -0.05101876f, 0.04190571f, -0.07873114f, 
    0.09353308f, 0.10025036f, -0.09589046f, 0.19129427f, -0.00682655f, -0.01157387f, -0.05091755f, 0.02567010f, 
    0.08998013f, -0.07067453f, 0.11822779f, -0.11379249f, -0.00781694f, -0.13582136f, -0.08339223f, 0.01113322f, 
    -0.05590408f, 0.04055286f, 0.05643355f, -0.00383910f, 0.09550998f, -0.06564665f, 0.08027899f, 0.05083387f, 
    -0.26705819f, 0.00425988f, 0.04409407f, 0.18714111f, 0.04812560f, -0.02974316f, 0.01096619f, 0.08194067f, 
    0.00743187f, 0.06794845f, -0.02404385f, 0.00101688f, 0.09905303f, 0.01855054f, 0.15804876f, 0.05806981f, 
    -0.00436483f, 0.12332918f, 0.01967213f, 0.08028071f, 0.06118168f, -0.18743189f, 0.01410375f, -0.02011716f, 
    0.15575689f, -0.02125684f, 0.10366433f, -0.01761005f, 0.00638031f, -0.02895870f, 0.09595955f, -0.03023966f, 
    0.06089269f, 0.13507546f, -0.06013672f, 0.19878036f, -0.00363419f, -0.28407606f, -0.06161698f, 0.09294420f, 
    -0.04596077f, 0.12243751f, 0.12158505f, -0.05530435f, 0.02705045f, -0.09690757f, 0.04475824f, 0.11398081f, 
    -0.03614482f, 0.19541070f, 0.05411230f, 0.19195560f, 0.11145960f, -0.03752604f, 0.03059701f, 0.03332762f, 
    0.01936194f, 0.00196352f, 0.02227584f, -0.11143902f, 0.11875915f, -0.14667927f, 0.03243189f, -0.09580105f, 
    -0.11993168f, -0.08823286f, 0.06336767f, -0.02082476f, 0.11511875f, 0.05373583f, -0.04357592f, -0.01586132f, 
    -0.02821139f, 0.24827750f, 0.01169497f, 0.03863199f, -0.05820957f, 0.02012996f, -0.02377124f, 0.07260516f, 
    -0.01684074f, 0.01506961f, 0.04199740f, -0.09703986f, 0.11203935f, 0.18039745f, -0.12900595f, -0.00709897f, 
    0.05956724f, -0.11892199f, 0.07919633f, 0.08370894f, 0.01568750f, 0.07287413f, 0.07773829f, 0.00964582f, 
    0.04671899f, 0.07972048f, -0.04091563f, 0.16136850f, 0.05067362f, 0.03362804f, 0.00006757f, 0.02724459f, 
    -0.07324833f, 0.05232893f, -0.03067468f, -0.03678115f, 0.14441784f, 0.03509922f, -0.10220830f, -0.03979481f, 
    -0.06448081f, 0.02547047f, 0.10804777f, 0.13419664f, 0.07540663f, 0.05156556f, 0.02017296f, 0.03726499f, 
    0.12298261f, 0.09096336f, -0.02785337f, -0.04206018f, -0.07622399f, -0.15243970f, 0.04198316f, 0.01120864f, 
    0.00758583f, -0.14712718f, -0.02419326f, 0.01713802f, 0.07703748f, 0.06009781f, 0.08412575f, -0.01524375f, 
    0.11668367f, -0.02210910f, 0.12766004f, -0.01184165f, 0.02354584f, 0.17708844f, 0.13137560f, 0.08798068f, 
    0.29231611f, 0.13813980f, 0.13270402f, -0.03489702f, 0.07720104f, 0.05363858f, 0.02726397f, 0.09556856f, 
    -0.04637003f, 0.13017927f, 0.00882175f, 0.00375993f, -0.02320238f, 0.02493849f, 0.02887120f, 0.04920098f, 
    0.03279855f, 0.02287942f, 0.03287769f, 0.02740113f, 0.11749552f, 0.01987157f, 0.04886604f, 0.10773920f, 
    -0.44400606f, -0.04300068f, -0.07559305f, 0.10216581f, -0.14520900f, 0.09467585f, 0.03163291f, -0.07642877f, 
    0.09604324f, 0.03431978f, -0.15463431f, -0.15698327f, -0.19919685f, 0.10559797f, 0.11603060f, 0.03885753f, 
    0.04697122f, 0.00194838f, 0.13262188f, -0.00237780f, 0.03965325f, -0.07050347f, -0.00041687f, 0.05943828f, 
    0.06022572f, 0.03059962f, 0.02702449f, 0.02079496f, -0.04287398f, 0.06346816f, -0.03815485f, 0.09740418f, 
    0.00251259f, -0.07738334f, -0.06203104f, 0.03814884f, -0.19158231f, 0.30004236f, 0.12360638f, 0.00188693f, 
    0.10202751f, 0.01262169f, 0.06971908f, 0.07302523f, 0.04698052f, 0.15171295f, 0.06399538f, 0.04596528f, 
    0.16252637f, -0.21451296f, -0.01417665f, 0.22341003f, -0.12340677f, -0.03940089f, 0.04102213f, 0.02367525f, 
    0.07619482f, 0.02718581f, 0.09430522f, 0.15402424f, -0.18963604f, 0.21783318f, 0.02840583f, -0.17242637f, 
    -0.06838066f, 0.15540755f, 0.10657201f, 0.04206839f, 0.11582452f, 0.13379818f, -0.06906320f, 0.27318236f, 
    -0.03925036f, -0.13610175f, 0.10974266f, -0.04265896f, -0.10464530f, 0.04756513f, -0.00516337f, 0.05727577f, 
    0.06388879f, -0.08214144f, 0.04732570f, 0.02352133f, 0.12579101f, -0.15807365f, 0.25699744f, 0.05498517f, 
    -0.05567461f, 0.05508016f, -0.02052139f, 0.18243974f, 0.04682748f, 0.08576500f, 0.12086853f, 0.24242294f, 
    0.01635738f, -0.01267353f, -0.00326111f, 0.01162110f, 0.01182562f, -0.02266738f, -0.01546790f, -0.01876252f, 
    0.02380915f, -0.01574050f, 0.00124868f, -0.03744261f, -0.03126023f, 0.01026056f, -0.02232433f, 0.03350172f, 
    0.01554088f, 0.00490158f, 0.02871561f, 0.02965552f, -0.00872199f, 0.00657161f, -0.01161902f, -0.01628012f, 
    -0.03284051f, 0.00832090f, -0.01018732f, 0.01709242f, -0.00635691f, 0.02352824f, 0.00319535f, -0.00259504f, 
    -0.03453993f, 0.00088824f, 0.02661203f, -0.00165830f, 0.01500251f, -0.02735175f, -0.02270185f, -0.03128087f, 
    0.01414083f, -0.02181272f, -0.02956414f, -0.01119832f, -0.03262502f, -0.01245513f, 0.03612227f, 0.00262950f, 
    -0.00698337f, -0.00535575f, 0.00902815f, -0.03393459f, -0.00201210f, 0.01249241f, -0.03628067f, 0.01657055f, 
    0.00200999f, 0.02183344f, -0.02766016f, -0.01175247f, -0.03787122f, -0.00265670f, 0.01264203f, 0.01228052f, 
    0.02313184f, 0.01821045f, -0.01156263f, -0.03233860f, -0.02684060f, 0.03178336f, 0.01599998f, 0.03155986f, 
    0.01316555f, -0.02803152f, -0.00999622f, -0.02870679f, 0.02915643f, -0.01147524f, -0.00895789f, -0.03122958f, 
    0.01588026f, 0.00460335f, -0.02756987f, -0.00280567f, -0.01187477f, 0.00658142f, -0.02420399f, -0.00856656f, 
    0.00187181f, 0.01798566f, -0.00997819f, -0.03456247f, -0.02704525f, -0.02201170f, -0.03118419f, 0.00915881f, 
    -0.03110444f, -0.02777262f, 0.02505778f, 0.02413744f, 0.00903629f, -0.00939338f, -0.02692316f, 0.04315569f, 
    -0.02495059f, -0.00349326f, 0.02228096f, 0.02085846f, -0.00415152f, -0.02021448f, -0.02126948f, -0.00027153f, 
    0.02660987f, -0.02177173f, -0.03473483f, -0.02213722f, 0.01656842f, -0.03786157f, -0.01996415f, 0.00930800f, 
    -0.02405906f, -0.00047234f, 0.00740408f, 0.01782610f, -0.01222745f, -0.03181727f, -0.02158717f, -0.01510836f, 
    -0.03259162f, 0.02210534f, -0.02180538f, -0.02827904f, -0.03726554f, -0.03474069f, 0.03266008f, -0.03699439f, 
    0.01827792f, -0.01919053f, 0.00748971f, -0.02848502f, -0.03979601f, -0.02233731f, -0.03096457f, -0.01285567f, 
    -0.00699496f, 0.02055589f, 0.01971200f, 0.00670283f, -0.01662282f, -0.01598219f, -0.02728109f, -0.01607267f, 
    -0.04085847f, -0.02126195f, 0.00875458f, 0.00377568f, -0.01012142f, -0.03573667f, 0.01067778f, -0.03031412f, 
    0.00358681f, 0.03374562f, -0.03065749f, -0.04129075f, 0.03607064f, -0.03573116f, -0.02855851f, 0.00277991f, 
    0.00317246f, -0.01203625f, 0.00305543f, -0.01445188f, -0.03596809f, 0.01099651f, -0.02708942f, -0.01303105f, 
    0.02361176f, -0.00664560f, -0.03719225f, 0.03075462f, -0.00859183f, 0.01162687f, 0.01190889f, 0.00649410f, 
    -0.03406693f, -0.01141006f, 0.02113470f, 0.01081704f, 0.00957860f, 0.01035974f, 0.02542727f, 0.00459348f, 
    0.00156783f, -0.03023600f, 0.00821480f, 0.01384764f, -0.02317208f, 0.02539805f, 0.02616942f, 0.00859717f, 
    0.03071205f, 0.02777218f, 0.03061649f, 0.02619272f, -0.01483117f, -0.00353580f, -0.01289731f, -0.01789804f, 
    0.01302210f, 0.01866622f, 0.00374799f, 0.01027852f, -0.01266595f, 0.03000438f, -0.01150553f, 0.00589209f, 
    0.02433215f, -0.01733405f, -0.01538106f, -0.01918949f, -0.04069157f, -0.00600702f, -0.01507501f, 0.01427058f, 
    0.00225100f, -0.00817645f, -0.03154562f, 0.00274841f, -0.00242392f, 0.01932502f, -0.02736401f, -0.03122699f, 
    -0.03814423f, 0.02226805f, 0.00777448f, 0.02310239f, -0.02490699f, -0.01953893f, 0.01244078f, 0.03301350f, 
    -0.02970475f, -0.00710415f, 0.00222552f, -0.02597941f, -0.03275774f, 0.00465088f, -0.03334891f, 0.02278557f, 
    -0.02780217f, -0.02134838f, -0.00899687f, -0.02499041f, -0.03575732f, 0.03673543f, -0.03408344f, -0.02771470f, 
    -0.03467003f, -0.02684912f, 0.02753791f, -0.02259615f, -0.02054492f, -0.01030337f, -0.03217094f, -0.00018524f, 
    -0.01124083f, -0.00939407f, -0.01256012f, -0.01611224f, -0.01217516f, -0.01489729f, 0.01789579f, -0.02740479f, 
    -0.02579941f, -0.01943518f, -0.03290220f, -0.02667270f, 0.02870192f, 0.00676564f, -0.00117783f, -0.00082283f, 
    -0.02350040f, 0.02430410f, 0.00056441f, 0.00105437f, -0.00429338f, 0.01701579f, -0.00388813f, -0.00226636f, 
    0.01415729f, 0.02482573f, -0.00367651f, 0.02739747f, -0.03817465f, -0.00317278f, -0.03543029f, -0.02003646f, 
    -0.01947242f, -0.01821698f, 0.01604950f, -0.00860698f, -0.02958171f, -0.00691044f, 0.00017620f, -0.03528164f, 
    -0.03886871f, -0.02153597f, -0.02314143f, -0.01298014f, 0.00139343f, -0.02890714f, 0.02140199f, 0.02886901f, 
    0.02067353f, -0.02122295f, -0.00337653f, -0.02288748f, 0.00306395f, 0.03479497f, -0.00466673f, -0.02152975f, 
    -0.02240301f, 0.02490155f, 0.01276100f, 0.03257344f, -0.02664003f, -0.03442307f, 0.02095741f, 0.00495450f, 
    -0.01878145f, -0.03247201f, 0.00916660f, 0.02539797f, -0.03668182f, 0.03075810f, -0.02479337f, 0.01996321f, 
    0.01935513f, 0.02003097f, 0.01835662f, -0.00169420f, -0.01505776f, 0.01018315f, 0.01892149f, 0.01110119f, 
    -0.01834612f, -0.00139080f, -0.00429851f, -0.02021605f, -0.03275481f, 0.02430893f, 0.01586086f, -0.02809861f, 
    0.00404911f, -0.03463332f, -0.01139305f, 0.01236849f, -0.01617931f, 0.01613490f, -0.02203423f, 0.00807168f, 
    0.01554279f, -0.00107622f, 0.02915522f, 0.00617524f, 0.02837932f, -0.02240743f, -0.01084046f, 0.01159028f, 
    0.02078983f, -0.02320924f, 0.01607964f, -0.03015453f, 0.00321755f, -0.02584645f, -0.01878876f, 0.03427113f, 
    0.01131237f, -0.02421227f, 0.01242986f, -0.02000724f, 0.01648677f, 0.00616839f, -0.03416127f, 0.00442565f, 
    0.02019408f, 0.03153104f, -0.01190302f, 0.01689780f, -0.00903555f, -0.01708488f, 0.01963167f, -0.02462660f, 
    0.01692028f, 0.01294629f, 0.01916160f, -0.01544777f, -0.00598398f, -0.03135286f, -0.03282287f, -0.02944486f, 
    0.00203699f, 0.00447352f, 0.02975345f, 0.01123272f, 0.00296968f, -0.01166546f, -0.02479098f, -0.01847612f, 
    -0.00276149f, -0.01040470f, -0.01425792f, 0.03011789f, 0.00563033f, -0.00146903f, -0.01838212f, -0.02506457f, 
    -0.02205185f, 0.03023220f, 0.02705738f, -0.01080879f, 0.02156399f, 0.00090912f, -0.03073225f, -0.03477637f, 
    0.02778888f, -0.03769173f, -0.03551213f, 0.00493835f, -0.00162235f, 0.02275943f, -0.02053193f, -0.03905191f, 
    -0.02235057f, -0.01764318f, -0.03320327f, 0.01362142f, -0.03690367f, 0.01495828f, 0.01013993f, -0.02239662f, 
    -0.03396245f, -0.02742951f, -0.01384662f, 0.00992907f, 0.03021481f, 0.00763959f, 0.00808562f, 0.00495663f, 
    0.02902974f, -0.02290407f, 0.03243845f, 0.00831906f, 0.00151048f, -0.00113520f, -0.02453980f, -0.00465641f, 
    -0.03175577f, -0.00339781f, 0.00606612f, -0.03987699f, -0.03676217f, 0.01156157f, -0.02101686f, -0.02591784f, 
    0.02311114f, 0.00917906f, 0.02391469f, 0.00707153f, -0.01913496f, -0.01367796f, 0.02317363f, -0.01467176f, 
    0.01318862f, 0.00545208f, -0.00222660f, -0.01515282f, 0.02968436f, -0.04162173f, 0.01529220f, -0.02331024f, 
    -0.00828622f, -0.04189190f, -0.00031590f, 0.01554423f, 0.00528351f, 0.02323896f, 0.01678311f, 0.00563263f, 
    -0.00494702f, 0.01045092f, -0.02024294f, 0.02483401f, 0.02131514f, 0.00174541f, -0.01005079f, -0.02613877f, 
    -0.04018563f, -0.03050125f, 0.01440093f, -0.02763122f, -0.00204086f, -0.01385841f, -0.00939597f, 0.03110803f, 
    0.02724918f, 0.01111661f, 0.01011902f, -0.00298663f, 0.01181096f, -0.01995883f, 0.01799395f, -0.00726006f, 
    0.00930062f, -0.00857724f, -0.02768439f, -0.03364290f, 0.02294647f, -0.00309420f, 0.02008482f, 0.00391828f, 
    -0.01918598f, -0.02203202f, 0.00062973f, 0.00415462f, 0.00324192f, -0.03534725f, 0.00306043f, -0.03410640f, 
    -0.00348739f, 0.02185641f, -0.01522958f, -0.02363213f, -0.01804600f, -0.02910808f, -0.03865855f, 0.00212791f, 
    0.02089406f, -0.00078151f, 0.00246606f, -0.01536385f, -0.03869808f, 0.01809533f, -0.00968171f, 0.00921664f, 
    0.01595175f, -0.01371681f, -0.03727417f, 0.02877465f, 0.02006778f, 0.00084404f, -0.03667835f, 0.02572961f, 
    -0.03145636f, -0.03679777f, -0.03507915f, 0.01495673f, -0.01379103f, 0.00490603f, -0.00993709f, -0.02617283f, 
    0.01100966f, -0.03222690f, -0.01692821f, 0.00884594f, -0.00347339f, 0.01766335f, 0.03513338f, 0.02438270f, 
    -0.03492652f, 0.01694005f, -0.01233175f, 0.01981026f, -0.02995406f, 0.02958923f, 0.01151076f, -0.02305482f, 
    -0.01653355f, -0.01042088f, -0.02834111f, -0.02333272f, -0.01262342f, -0.00029000f, -0.02390372f, -0.02953136f, 
    -0.03108524f, -0.01662081f, -0.02810896f, 0.00587542f, -0.01894558f, -0.02681683f, -0.02313258f, 0.00452746f, 
    0.00254084f, -0.01743010f, -0.02753054f, -0.00790303f, 0.00132944f, 0.02306835f, -0.00074664f, -0.03398111f, 
    -0.00029108f, 0.00873450f, -0.00058434f, -0.02864349f, 0.00538402f, -0.02130528f, -0.00966784f, -0.00629219f, 
    -0.00979610f, 0.01654810f, 0.00174993f, 0.02260367f, 0.00161373f, -0.00407457f, 0.01613290f, -0.01734500f, 
    0.02854164f, -0.00432974f, -0.02391717f, 0.00751236f, -0.02483210f, 0.00409463f, -0.02415777f, -0.03523992f, 
    0.02148412f, -0.01418674f, -0.02481908f, 0.02104784f, -0.02244918f, -0.00395615f, -0.01092594f, -0.00445344f, 
    -0.03684302f, 0.02647538f, -0.02228872f, 0.01573948f, -0.00433047f, 0.01489170f, -0.03540961f, -0.00439276f, 
    0.03202067f, -0.03589853f, -0.00750013f, -0.01249744f, -0.02468396f, -0.00856222f, 0.00032541f, 0.02038688f, 
    0.00130701f, 0.00380046f, 0.00069371f, -0.03078939f, 0.01928108f, -0.03415636f, 0.02804549f, -0.01077813f, 
    -0.00663261f, 0.02235821f, -0.00875664f, 0.00310493f, -0.01192697f, -0.03428109f, -0.01439358f, -0.00276042f, 
    -0.01673702f, 0.01165862f, -0.03669405f, 0.00758182f, 0.01672442f, 0.01214538f, -0.03574250f, -0.01730659f, 
    0.02655808f, -0.02068595f, 0.01341126f, 0.00008131f, -0.02041076f, -0.00579486f, -0.00743381f, -0.01878010f, 
    0.00485424f, 0.01149427f, 0.00773828f, -0.00424777f, 0.01497597f, -0.01207915f, -0.02086527f, 0.02701727f, 
    -0.03256563f, 0.03179106f, 0.01938066f, -0.01538893f, -0.00845317f, 0.01232507f, 0.00069451f, 0.03000343f, 
    -0.03651259f, -0.02256332f, -0.03448771f, 0.00268225f, 0.02067950f, -0.00720714f, -0.02327945f, 0.01963454f, 
    0.02550216f, 0.01070650f, 0.00935176f, -0.00249693f, -0.02941879f, -0.02114173f, 0.03067875f, -0.00036921f, 
    0.00332789f, 0.03257104f, -0.00795015f, -0.01844754f, -0.02232461f, -0.00907643f, -0.00378174f, -0.01103529f, 
    -0.00805090f, -0.02780497f, 0.01475940f, 0.00371954f, -0.00692715f, -0.02039141f, 0.01980918f, -0.01877740f, 
    0.02095893f, -0.03165803f, -0.02641952f, 0.00091739f, -0.02048768f, -0.00966799f, -0.03893843f, 0.02478612f, 
    0.00608986f, 0.00018554f, -0.01577687f, 0.00686311f, 0.01883903f, -0.03411432f, -0.03294728f, 0.02431945f, 
    -0.03548314f, 0.01423016f, -0.03576505f, 0.00901495f, 0.01905382f, -0.02376911f, 0.00605833f, -0.01198665f, 
    -0.01082437f, 0.00118727f, -0.03734210f, -0.00993592f, -0.00091073f, -0.03552997f, -0.00689768f, 0.01050803f, 
    -0.00135423f, -0.01674947f, -0.03836703f, -0.01351957f, -0.03545487f, 0.01943286f, 0.01610863f, 0.02757681f, 
    -0.29026425f, 0.02435114f, 0.03744146f, -0.05970243f, 0.14083345f, 0.09324576f, 0.01212259f, -0.04314335f, 
    0.13441417f, 0.00993441f, 0.04382511f, -0.02765273f, 0.10358966f, 0.26914474f, 0.23133145f, -0.06899710f, 
    0.05181019f, 0.03664199f, 0.07441180f, 0.05057503f, -0.04869267f, 0.03830551f, 0.01553021f, 0.02443372f, 
    0.00304924f, -0.10464758f, -0.12757649f, -0.10709655f, 0.02356523f, -0.03375765f, -0.00086612f, 0.03011664f, 
    -0.13119313f, 0.01507273f, -0.06701680f, 0.05925316f, -0.08543584f, -0.06612147f, 0.08634524f, 0.10612419f, 
    0.02634392f, -0.09791861f, -0.01916326f, 0.03695184f, -0.04584616f, 0.04430036f, 0.00562499f, -0.00918827f, 
    -0.04366636f, -0.06847224f, -0.03959595f, -0.15199776f, 0.06821085f, 0.04074818f, 0.01289561f, 0.12638183f, 
    -0.05017920f, -0.02102595f, 0.03017718f, -0.00988480f, -0.15906247f, -0.01551740f, 0.07448460f, -0.05418904f, 
    -0.06637307f, -0.08636770f, -0.07180578f, -0.03296026f, -0.04666498f, -0.03840891f, 0.04357424f, 0.13081847f, 
    0.12697473f, 0.02958527f, 0.06244253f, -0.04073726f, 0.08281970f, -0.02101467f, 0.01320538f, -0.09196291f, 
    -0.01332248f, 0.02254694f, -0.04838225f, -0.07482170f, -0.01061451f, 0.27427608f, -0.06438008f, -0.29367924f, 
    0.12299140f, -0.03289772f, -0.01604630f, 0.06245223f, 0.07892922f, 0.01531709f, -0.00001181f, 0.09144902f, 
    -0.01350053f, 0.00381065f, 0.07565052f, -0.28311896f, -0.03084219f, 0.05405948f, -0.05197452f, 0.01491379f, 
    0.03253896f, 0.06968427f, 0.08216076f, -0.13158293f, 0.00108357f, 0.15387541f, 0.21483271f, -0.04705054f, 
    0.11030967f, 0.03005298f, 0.06330316f, 0.03451094f, -0.05341486f, -0.03190048f, 0.04781144f, 0.02292700f, 
    0.12212952f, 0.17975312f, -0.11438989f, 0.15359014f, -0.03477465f, -0.05707010f, 0.03383975f, 0.04009393f, 
    -0.01568300f, 0.10020901f, -0.00207031f, -0.16512999f, -0.02719674f, 0.07650870f, -0.00591097f, 0.19906485f, 
    0.14528415f, 0.08585501f, -0.01963629f, 0.00168959f, 0.02344163f, 0.04383123f, 0.04199463f, -0.00266504f, 
    0.02551410f, 0.13402049f, 0.13649495f, -0.12770286f, 0.02278280f, 0.02671440f, 0.02939215f, 0.07511377f, 
    0.06126053f, 0.09026755f, -0.00398442f, -0.00836682f, -0.22503047f, 0.13215165f, 0.21999298f, 0.00779418f, 
    -0.02526280f, -0.01306194f, 0.01729657f, -0.05318229f, -0.11950362f, -0.07800496f, -0.00502476f, 0.11294233f, 
    -0.19451360f, 0.02508567f, -0.01370596f, 0.16150452f, 0.09522234f, 0.02982417f, 0.10843400f, -0.01779677f, 
    0.05773306f, 0.04875983f, 0.05102752f, 0.01748331f, -0.14560200f, 0.05855500f, 0.04598878f, -0.07864476f, 
    0.00451260f, 0.07031664f, -0.04011948f, 0.07107893f, 0.03781704f, 0.09507691f, -0.07233837f, -0.00548373f, 
    0.20759839f, 0.26612633f, 0.23209392f, -0.01504184f, -0.03040422f, 0.04511554f, 0.06066449f, -0.08266666f, 
    -0.04313192f, -0.00453164f, 0.03590105f, -0.00403420f, -0.27099678f, 0.14918351f, -0.01063763f, -0.04845949f, 
    0.11030537f, 0.05860188f, 0.03978543f, -0.02477312f, 0.06070391f, 0.04679286f, -0.01035117f, -0.02965117f, 
    -0.06288350f, -0.21829806f, -0.02316337f, -0.08592138f, -0.02447858f, 0.01143441f, 0.07672779f, 0.01670935f, 
    -0.04093914f, -0.02564737f, 0.08380079f, -0.18468638f, 0.01169217f, 0.20614609f, 0.07774935f, -0.06527716f, 
    0.04056285f, 0.10868985f, -0.06444791f, -0.03752621f, -0.08571839f, -0.00915678f, 0.01361460f, 0.00604143f, 
    0.00694957f, 0.09199654f, -0.07042832f, -0.00813660f, -0.11008219f, 0.01585527f, -0.01897842f, -0.11071138f, 
    -0.01245643f, -0.05963506f, -0.05006142f, 0.04703189f, 0.01897565f, 0.03869038f, -0.03737192f, 0.02240803f, 
    0.13694729f, -0.05035556f, -0.15942617f, 0.02273519f, 0.09969222f, -0.03323663f, 0.02784609f, -0.09592783f, 
    0.11857459f, -0.14636457f, 0.11329930f, -0.00317811f, -0.07543867f, 0.02642300f, -0.07535647f, 0.06194190f, 
    0.01458954f, 0.05782645f, 0.01193260f, 0.01313502f, -0.10367350f, -0.08195583f, -0.04618558f, -0.07372016f, 
    0.06452841f, 0.11069264f, 0.10991238f, 0.04885504f, -0.01785831f, -0.00253219f, -0.00244647f, -0.02548655f, 
    -0.30770317f, 0.01991277f, 0.03929085f, 0.20355357f, 0.14380515f, 0.15935928f, 0.05564669f, -0.09195924f, 
    0.03091842f, -0.10714690f, 0.07014362f, 0.19557813f, 0.22748542f, 0.12185922f, -0.05658872f, 0.16604578f, 
    0.03452224f, -0.06793915f, -0.01526987f, 0.06317709f, -0.01155804f, -0.10242151f, 0.06350235f, 0.00993712f, 
    0.11650708f, 0.17390256f, 0.07682616f, -0.08772036f, 0.04726662f, 0.06036339f, -0.02519498f, 0.03296711f, 
    -0.00021302f, -0.02753215f, -0.04752137f, -0.11989006f, 0.15502729f, 0.26040846f, 0.12361731f, -0.13472380f, 
    0.03054565f, -0.02150565f, 0.01001969f, -0.01087106f, -0.01705566f, -0.03041434f, -0.02259913f, -0.01215355f, 
    0.25770083f, 0.10992038f, 0.02170587f, -0.15672114f, -0.00635613f, -0.01104644f, -0.04596324f, 0.15270667f, 
    0.03935547f, -0.04741802f, 0.00710780f, 0.01807876f, 0.23530725f, -0.12853238f, 0.07057709f, -0.15627027f, 
    -0.12285006f, -0.00056847f, 0.06492401f, 0.01076379f, 0.04240270f, -0.01632809f, 0.04339715f, 0.02057047f, 
    -0.08647384f, -0.01828061f, -0.00600993f, 0.13262610f, 0.05626426f, 0.01861480f, 0.11402560f, -0.05309227f, 
    0.02374125f, 0.10940249f, 0.13793355f, -0.02490337f, -0.23003352f, 0.02429006f, 0.07501281f, 0.16904084f, 
    -0.02389190f, -0.05986233f, 0.05241288f, -0.13272044f, -0.06247313f, -0.04860860f, 0.00896798f, 0.07677168f, 
    -0.07702181f, 0.46048227f, 0.18618532f, -0.10720380f, -0.00499562f, -0.00414000f, 0.08672423f, 0.00787472f, 
    0.09905376f, 0.08184841f, -0.07358356f, 0.06353851f, 0.25780970f, -0.23409377f, 0.01210984f, 0.44648528f, 
    -0.02915436f, -0.11305732f, 0.05325410f, -0.00917864f, 0.00979594f, -0.07094829f, -0.00964874f, 0.00165906f, 
    0.05023540f, -0.02013399f, -0.08784623f, 0.22109079f, 0.03757875f, 0.02562088f, -0.01214705f, -0.12488157f, 
    0.06997869f, -0.01312227f, 0.08656240f, 0.00153602f, 0.02074680f, 0.25354910f, 0.17324214f, 0.10321663f, 
    0.04066839f, 0.14503577f, 0.02295336f, 0.01412232f, -0.04024070f, -0.03916096f, -0.03239877f, 0.00079909f, 
    0.01310284f, -0.24367239f, 0.20991892f, 0.02507341f, -0.05658065f, 0.03752156f, 0.01340701f, -0.06261554f, 
    0.02827434f, -0.01467294f, 0.00554403f, -0.06642830f, -0.14517921f, 0.14352778f, -0.03356785f, -0.15949550f, 
    0.04214643f, 0.02873670f, 0.05365328f, 0.04361513f, 0.08435505f, 0.09038065f, -0.08672363f, 0.06727339f, 
    0.05410316f, 0.13654415f, 0.08796546f, 0.27532667f, 0.06539371f, 0.02469092f, -0.09664975f, -0.01744888f, 
    0.11867642f, -0.03421069f, 0.02147807f, 0.00014516f, -0.21326816f, 0.11506609f, 0.04514524f, 0.28758314f, 
    0.17451026f, 0.09786732f, -0.04252502f, 0.00851184f, 0.02337838f, 0.10272070f, -0.06458479f, -0.00826434f, 
    0.09588492f, -0.01966662f, 0.11064174f, 0.31009892f, 0.11858112f, 0.08925006f, -0.04388312f, -0.01813501f, 
    -0.02998642f, 0.00464675f, 0.02875264f, -0.08700053f, -0.29260218f, 0.08242999f, 0.05939389f, 0.05442753f, 
    -0.07780375f, 0.01694313f, -0.02439500f, 0.02162733f, -0.03584829f, -0.05556574f, 0.04555658f, -0.02779455f, 
    -0.09093596f, -0.12976350f, 0.10906839f, -0.04929822f, -0.13294229f, -0.04984938f, 0.05782486f, 0.07943957f, 
    0.02569019f, -0.07574729f, 0.01408521f, -0.00673317f, 0.09014767f, 0.01833189f, 0.01806692f, 0.06763000f, 
    0.00867407f, 0.04636698f, -0.02484069f, 0.04668935f, -0.03634110f, -0.08076815f, 0.09593810f, -0.11958249f, 
    -0.17000513f, -0.02831316f, -0.03463912f, 0.06141905f, 0.18597725f, 0.13850506f, -0.04438386f, 0.02966279f, 
    0.04912333f, 0.04014559f, -0.03580114f, -0.03671705f, -0.06717768f, 0.14209664f, 0.04593077f, -0.02862130f, 
    0.02579631f, -0.14195976f, -0.02010797f, -0.03826176f, 0.00620502f, -0.04847515f, -0.11070028f, -0.03809447f, 
    -0.00205122f, -0.13117698f, 0.08953299f, 0.02812408f, 0.00457373f, -0.00568843f, 0.03839226f, -0.00955873f, 
    0.00468260f, 0.06887443f, -0.06693887f, -0.01708443f, -0.34224355f, 0.16586873f, -0.18900059f, -0.20476435f, 
    0.09123991f, -0.02569723f, 0.06333571f, 0.09035826f, -0.07369885f, 0.01297313f, -0.00221277f, -0.07442874f, 
    -0.06578244f, -0.12571602f, -0.03056188f, 0.06393571f, 0.10014552f, 0.11761077f, 0.08417355f, -0.06317316f, 
    0.02520100f, 0.00382689f, 0.09519751f, -0.01035223f, 0.04603283f, -0.21985485f, 0.12064987f, -0.15441243f, 
    0.05326729f, 0.05060506f, 0.02512984f, -0.05178414f, -0.02028286f, -0.08367962f, 0.03923270f, -0.10001725f, 
    -0.12764947f, 0.12832904f, 0.11233367f, -0.01382080f, 0.14048046f, 0.10454877f, 0.00762298f, -0.03943641f, 
    -0.03526762f, -0.07849513f, -0.03939859f, -0.02294726f, -0.23927625f, 0.02945146f, 0.12065404f, 0.10834270f, 
    0.01678738f, -0.04187707f, -0.00501591f, -0.01666716f, -0.06021909f, -0.05963276f, 0.02148921f, -0.07333384f, 
    -0.33398095f, 0.04532339f, -0.01690350f, 0.11898747f, 0.11511493f, 0.07382867f, 0.13612314f, -0.05533935f, 
    -0.02129616f, -0.03532035f, 0.10284220f, -0.00799483f, 0.04189631f, 0.04477859f, -0.04564809f, -0.07508600f, 
    -0.04342758f, -0.05118403f, 0.02181632f, -0.02507168f, 0.01255108f, 0.04407886f, 0.06299838f, 0.07725146f, 
    0.09135366f, -0.18079597f, -0.01655851f, 0.05199420f, 0.04420873f, 0.03387682f, -0.05988844f, -0.14217375f, 
    -0.03223006f, -0.10468988f, 0.10992182f, 0.10255711f, 0.02287094f, -0.05325918f, 0.12336425f, 0.17880097f, 
    -0.00299759f, 0.00139395f, 0.07316072f, 0.11582169f, -0.04961000f, -0.02445929f, -0.05823478f, -0.06633944f, 
    0.01976987f, 0.32605794f, 0.03145764f, -0.03220048f, -0.12271141f, 0.03199594f, 0.10225145f, -0.02061750f, 
    -0.05080236f, -0.00725000f, -0.08911850f, -0.01923911f, -0.16171299f, 0.03006228f, -0.02627769f, -0.07986825f, 
    -0.13011418f, 0.09939807f, -0.00785672f, 0.08393432f, -0.06676883f, -0.01471403f, -0.02944858f, 0.03587498f, 
    0.01268047f, -0.07103930f, 0.04754252f, -0.03067662f, 0.02182707f, 0.08401331f, 0.05255539f, 0.08493990f, 
    -0.04804240f, -0.08739328f, -0.05690108f, 0.07455274f, 0.00702506f, -0.04828963f, 0.07944953f, 0.21811108f, 
    -0.08635951f, -0.13933931f, -0.08397124f, -0.00434917f, -0.15477648f, -0.00820116f, -0.01853702f, 0.05387225f, 
    0.10434961f, 0.24254309f, 0.07876036f, -0.28055170f, -0.00049846f, 0.09130717f, -0.11658529f, 0.02976455f, 
    0.06123783f, 0.06239755f, -0.03485318f, -0.02343119f, 0.40050837f, -0.23229942f, 0.05195689f, 0.19627264f, 
    -0.07548852f, -0.01297625f, -0.01973825f, -0.17344703f, 0.09176596f, -0.00773509f, 0.01587513f, -0.05175764f, 
    -0.02412691f, 0.06080034f, 0.04271989f, -0.05865824f, 0.01058681f, -0.01384295f, 0.06412533f, -0.00126379f, 
    0.04937133f, -0.02764172f, -0.02626453f, -0.08416569f, -0.10232646f, 0.10250799f, -0.03885665f, -0.23042358f, 
    -0.12142474f, -0.03915282f, -0.03297841f, -0.09172045f, 0.01442380f, -0.05863759f, 0.03561999f, 0.08078792f, 
    -0.12865332f, -0.15012984f, 0.02326704f, 0.04184833f, -0.05692678f, -0.04294369f, -0.04882398f, 0.02330798f, 
    -0.05503837f, 0.00138582f, -0.02647482f, 0.00849612f, 0.08815169f, 0.02086828f, 0.01714220f, 0.18405050f, 
    0.20690607f, 0.04344073f, -0.03824739f, -0.04966431f, 0.00527876f, 0.07710432f, 0.02428627f, -0.01566036f, 
    0.16742857f, -0.02401055f, 0.04023960f, -0.13872838f, 0.00942927f, -0.08420295f, 0.11000747f, 0.08783796f, 
    -0.03211638f, 0.08813649f, 0.02880156f, -0.02259999f, 0.08013348f, -0.16520248f, -0.20905739f, -0.38342145f, 
    0.12712681f, 0.02867042f, 0.02689056f, 0.03591568f, 0.07779377f, -0.00484094f, 0.09049316f, 0.05591187f, 
    -0.04472095f, -0.09427689f, -0.08503066f, -0.16868073f, -0.02070692f, -0.10305445f, -0.00199712f, 0.06338762f, 
    0.03840779f, -0.00400137f, 0.03283971f, 0.07772267f, -0.22423001f, -0.21551038f, -0.09503552f, -0.05093600f, 
    0.08696419f, 0.09581466f, 0.03255687f, -0.03758842f, -0.04557467f, 0.08176579f, 0.00956774f, -0.01417085f, 
    0.12623836f, -0.06730492f, -0.03564980f, 0.13843238f, 0.06346040f, 0.01175322f, 0.02276089f, -0.05722950f, 
    0.04167763f, 0.09122549f, -0.02956366f, 0.02712545f, 0.30339226f, -0.05196387f, -0.07388568f, -0.20721160f, 
    -0.00656187f, -0.02740981f, -0.09372931f, 0.10830268f, 0.00700424f, -0.05571360f, 0.01864391f, -0.03729454f, 
    0.05206319f, -0.00781236f, 0.00041683f, 0.11694892f, 0.01631322f, 0.00263537f, -0.04204476f, 0.17045587f, 
    0.07314017f, 0.09872406f, 0.14069977f, -0.03329621f, -0.17636389f, 0.04059562f, 0.06500464f, 0.14842463f, 
    0.17307580f, 0.10121294f, 0.06110686f, -0.10474321f, 0.04399929f, 0.00225842f, 0.03821182f, -0.05828230f, 
    -0.28825533f, 0.14515135f, 0.05953039f, 0.05015772f, -0.06977949f, -0.01257367f, -0.02294287f, 0.03048529f, 
    0.07942034f, 0.00762137f, -0.02568369f, -0.00656718f, -0.29482499f, 0.01126425f, 0.08737259f, 0.09888477f, 
    0.09070675f, -0.05308317f, -0.11814774f, -0.00458306f, -0.02681812f, -0.00306064f, 0.06424103f, 0.09627329f, 
    -0.09007121f, 0.00278713f, -0.02015971f, 0.05554525f, 0.15619084f, -0.00364670f, 0.03279836f, -0.04409603f, 
    0.03399547f, 0.05530458f, -0.05462608f, -0.12600414f, -0.14518134f, 0.00212638f, 0.14860234f, 0.04373936f, 
    0.16552956f, 0.08296400f, 0.04842686f, -0.00424722f, -0.05991948f, 0.03674817f, 0.02030342f, 0.00017735f, 
    0.05951907f, -0.05481857f, 0.07574068f, 0.03349473f, -0.07752643f, -0.11328141f, 0.09596849f, 0.11814561f, 
    0.06575685f, -0.06335506f, 0.06078229f, 0.07284513f, 0.07226789f, -0.00461843f, 0.00499773f, 0.04725420f, 
    0.01200880f, 0.04260081f, -0.03593585f, -0.04953804f, -0.00632274f, -0.05055359f, 0.03195003f, 0.00948798f, 
    0.18478952f, 0.07938005f, 0.13432765f, 0.14427167f, 0.10815867f, -0.05111939f, 0.03099296f, -0.02639630f, 
    0.09279954f, 0.03656503f, 0.00130331f, 0.02310631f, 0.11316767f, 0.00232383f, -0.04876345f, -0.06365641f, 
    -0.04474873f, -0.07668337f, 0.02588079f, 0.04780319f, 0.02924245f, -0.04475919f, -0.07165607f, -0.05385077f, 
    0.39664432f, -0.05102284f, 0.02163692f, 0.09523401f, -0.03717274f, 0.01013048f, -0.07678040f, 0.05439364f, 
    0.06008386f, 0.05727478f, 0.04206647f, -0.03175065f, 0.12526932f, -0.10651904f, 0.06574707f, 0.10582460f, 
    -0.04339330f, -0.09936999f, 0.00488336f, 0.11638291f, 0.07579806f, 0.01439577f, 0.05792356f, 0.01989745f, 
    0.12077262f, 0.03041454f, 0.09809529f, -0.01194221f, 0.05830167f, -0.01004955f, 0.02018027f, 0.00912955f, 
    0.01622888f, 0.05032334f, 0.14238001f, 0.05266536f, -0.13440533f, 0.03896508f, 0.02837223f, -0.39101830f, 
    0.02926441f, 0.04974034f, -0.09457285f, 0.03482118f, -0.01350501f, -0.09788579f, 0.10716233f, 0.20362481f, 
    -0.12549685f, -0.09352718f, 0.03189340f, -0.06179102f, 0.10345583f, 0.07424568f, 0.06616887f, -0.00025794f, 
    0.09106126f, 0.04380191f, 0.03443283f, 0.00098263f, 0.41106650f, -0.20154347f, 0.03534101f, 0.11896742f, 
    -0.06533045f, -0.01481622f, -0.02116393f, 0.04016154f, 0.00736204f, 0.05234214f, 0.06876975f, 0.00419409f, 
    -0.21687089f, -0.01683790f, 0.13793735f, 0.16805404f, 0.05934783f, -0.12235233f, 0.06845571f, 0.07531685f, 
    0.03939021f, -0.12166112f, -0.00035288f, 0.03612981f, 0.36902127f, 0.44718114f, -0.11317173f, -0.09316984f, 
    0.18484433f, -0.10005403f, -0.05845765f, 0.07953379f, 0.00809227f, 0.06497756f, -0.03587147f, 0.07858880f, 
    0.18795647f, 0.00307166f, 0.15963276f, -0.00111494f, -0.01666743f, -0.02898244f, -0.03752595f, 0.01105603f, 
    0.05798894f, -0.01351290f, 0.01575132f, -0.04163861f, 0.10614636f, 0.06926993f, 0.06990893f, -0.00299825f, 
    -0.00593974f, 0.05000313f, 0.05638603f, 0.01810971f, -0.03414421f, 0.11836646f, -0.10257416f, -0.05381268f, 
    -0.03553865f, -0.24792205f, -0.13109797f, -0.30096161f, 0.00041226f, -0.03878536f, -0.08988097f, 0.02408888f, 
    -0.02028824f, -0.07491189f, -0.00853003f, 0.04286915f, 0.25158554f, -0.00337626f, -0.09851158f, -0.09382903f, 
    -0.05451376f, -0.02213402f, -0.00181313f, -0.04676573f, -0.03193252f, -0.04711946f, -0.01257805f, -0.11159323f, 
    0.14616424f, 0.13057931f, 0.07735842f, 0.21751724f, -0.12349678f, -0.03892270f, 0.02238481f, 0.13300559f, 
    0.01290900f, -0.04722599f, 0.09914988f, 0.04529965f, -0.24134457f, 0.11039235f, -0.02648691f, -0.24900627f, 
    -0.04227170f, 0.03686633f, 0.03805856f, 0.01257874f, -0.07587358f, 0.02068584f, 0.09193046f, 0.02975980f, 
    0.07977676f, 0.19841841f, 0.08609736f, 0.11188794f, 0.11934149f, 0.04254308f, 0.04648252f, -0.04325755f, 
    -0.09042533f, -0.01109219f, 0.08382214f, -0.00317709f, 0.11105955f, -0.16749620f, -0.23696029f, -0.34973156f, 
    0.04760171f, 0.05290344f, 0.06711846f, -0.00919915f, 0.01225456f, -0.04412740f, 0.03511712f, 0.06103986f, 
    0.01814249f, 0.20174354f, 0.14279929f, 0.15676665f, -0.05579751f, -0.19131614f, 0.03185723f, 0.20308053f, 
    0.00714807f, -0.01437695f, 0.11010829f, -0.07242707f, 0.11227849f, 0.13214718f, 0.16404457f, 0.08116417f, 
    0.10240451f, 0.16455613f, -0.00562071f, -0.05054848f, 0.04346046f, -0.06572174f, -0.03485704f, 0.00196653f, 
    -0.21334799f, -0.10519228f, 0.03993483f, -0.09396657f, 0.05653981f, 0.06645480f, -0.00429871f, -0.06980962f, 
    -0.01149968f, -0.03452805f, -0.02129910f, 0.05326110f, 0.10675283f, -0.05860117f, 0.03375656f, 0.08724938f, 
    -0.04537712f, 0.06580179f, -0.00207828f, 0.04168672f, 0.08424562f, -0.02714948f, 0.04412230f, 0.03518230f, 
    -0.19709487f, 0.16067237f, -0.02674909f, 0.20509407f, -0.09583230f, -0.00199635f, -0.05744690f, 0.21556994f, 
    0.04690025f, -0.01669711f, -0.01489476f, -0.08594554f, -0.31730872f, 0.04816167f, 0.15180305f, -0.04080432f, 
    0.08210755f, 0.04316104f, -0.14170474f, 0.03409781f, 0.11351696f, 0.04227965f, -0.02760991f, 0.11940914f, 
    -0.34830436f, -0.07813603f, 0.22933689f, 0.11770625f, -0.00188039f, -0.03883019f, -0.00913402f, 0.07506773f, 
    0.02548765f, 0.01216091f, 0.03470818f, 0.10694928f, -0.15753457f, 0.10439974f, -0.01067779f, -0.14992571f, 
    0.11763152f, 0.00853145f, 0.01974613f, -0.01363623f, -0.06126707f, 0.01958687f, 0.10564943f, -0.05068631f, 
    -0.30299598f, -0.08410690f, 0.07944792f, -0.04578464f, -0.07455500f, -0.01220852f, -0.00421352f, 0.08497947f, 
    0.02572821f, 0.12236270f, -0.02889766f, 0.00035305f, -0.11735646f, 0.02864459f, -0.06368115f, -0.19467485f, 
    0.03577257f, -0.10310899f, -0.00643946f, 0.10629669f, 0.03607555f, -0.03911040f, -0.06376566f, 0.04297180f, 
    0.00601690f, -0.10494011f, -0.02040475f, 0.10354976f, -0.02210769f, -0.06964237f, -0.08021829f, 0.05969967f, 
    -0.06601048f, -0.06465902f, 0.05853182f, 0.11650213f, -0.05951232f, -0.01972872f, -0.04785816f, -0.06547269f, 
    -0.04668821f, -0.05956884f, 0.15795222f, -0.07214732f, -0.02464264f, -0.06194963f, -0.00557299f, 0.04593690f, 
    -0.11042912f, -0.26139271f, 0.10848267f, -0.29399350f, -0.00766559f, 0.05511558f, 0.02984240f, 0.05536927f, 
    0.08698384f, 0.09005736f, -0.00611416f, 0.04473669f, 0.07673828f, 0.10459495f, -0.04894933f, 0.02272517f, 
    0.06744777f, -0.04742949f, -0.06472004f, 0.05270778f, -0.06979481f, 0.05379239f, 0.05206308f, -0.06995942f, 
    0.24085619f, -0.13433462f, 0.10813884f, 0.15973349f, -0.05355755f, -0.08378769f, 0.02184627f, 0.01717023f, 
    0.04653766f, -0.03059843f, 0.00675911f, 0.02615090f, 0.24843727f, -0.23643170f, 0.02755168f, 0.27106619f, 
    0.00659896f, 0.03009639f, 0.08585878f, 0.01133006f, 0.02428719f, -0.03368351f, -0.04212636f, 0.05907787f, 
    -0.11066016f, -0.25127476f, -0.02537865f, -0.31567302f, -0.07307259f, -0.07753928f, 0.14413264f, -0.05000653f, 
    -0.00003649f, 0.07557341f, -0.07871398f, 0.06658164f, -0.10013182f, 0.17793399f, -0.02634826f, -0.21507360f, 
    0.09072036f, -0.00680577f, -0.12617005f, -0.01439267f, -0.07635730f, 0.06069952f, 0.10423939f, -0.07328192f, 
    -0.04605116f, -0.14650866f, 0.00007348f, 0.07610067f, -0.07875622f, -0.02930073f, -0.01569388f, 0.02323292f, 
    0.07856461f, -0.01458941f, 0.02407571f, -0.08708998f, 0.04210249f, -0.07898506f, -0.16689669f, -0.19293508f, 
    0.04806481f, -0.02912105f, -0.02985710f, 0.00897445f, 0.02349609f, 0.02142702f, 0.00162515f, -0.00513111f, 
    0.01662097f, 0.00733475f, -0.22926868f, -0.20922862f, 0.07044432f, -0.08089770f, 0.08557159f, -0.06655994f, 
    0.03634572f, 0.02872103f, 0.02003489f, 0.02715666f, -0.06444008f, -0.06279461f, 0.00454831f, -0.23189171f, 
    -0.04411850f, 0.08981837f, -0.03050981f, 0.00162412f, -0.00683066f, -0.00334353f, 0.02502662f, 0.10259609f, 
    -0.11671419f, 0.05648297f, -0.01293205f, -0.24112250f, 0.03821557f, 0.00539916f, -0.06076368f, 0.00116907f, 
    0.05293582f, -0.07670008f, 0.02794116f, 0.01519862f, 0.24784727f, 0.05377701f, -0.18481235f, -0.16133614f, 
    -0.06475810f, 0.02474515f, -0.06961329f, 0.08025617f, 0.04584847f, -0.00133303f, -0.01249530f, -0.13330197f, 
    0.34123436f, -0.00218678f, -0.12675500f, -0.10778906f, -0.08042181f, -0.02765269f, 0.07107472f, 0.06716436f, 
    -0.11637165f, -0.04908031f, -0.05128464f, -0.05948419f, 0.14220205f, 0.09668597f, -0.18807252f, -0.41256961f, 
    0.04531694f, -0.04280667f, 0.03914952f, -0.01628338f, 0.00660903f, 0.09616725f, -0.01476806f, -0.04760670f, 
    -0.02829664f, -0.07191560f, 0.03099939f, 0.06524435f, 0.05412666f, -0.03678529f, 0.00047705f, 0.08505184f, 
    -0.01107928f, 0.06551651f, -0.01397697f, 0.00683719f, 0.36615300f, 0.03603313f, -0.27206680f, 0.21456912f, 
    0.00213296f, -0.04925190f, -0.04592093f, 0.01228396f, -0.01609236f, 0.01073261f, 0.07673341f, 0.05324505f, 
    -0.04391866f, 0.23872103f, -0.00226955f, 0.11589192f, 0.08415698f, -0.02701358f, 0.02260809f, 0.02768270f, 
    0.08072387f, -0.02806119f, 0.06641068f, -0.01464583f, -0.11961785f, 0.20038927f, -0.06104770f, -0.08539952f, 
    0.04318904f, 0.02094644f, 0.06053815f, -0.01945066f, 0.04378952f, 0.08795452f, 0.09575350f, -0.06412195f, 
    -0.28986710f, 0.10904981f, 0.14780180f, -0.22402984f, 0.01008968f, 0.00361561f, 0.08310901f, 0.04932224f, 
    0.19228774f, 0.00543072f, 0.04192349f, 0.06393545f, 0.26424173f, 0.07059552f, 0.15760401f, 0.16516437f, 
    -0.01671679f, -0.03360448f, -0.04764720f, -0.09935086f, -0.03989962f, -0.00590664f, 0.12609227f, 0.01863205f, 
    -0.33016017f, 0.00122612f, -0.14010642f, -0.14782375f, -0.04657114f, 0.03243212f, -0.02127342f, -0.01149454f, 
    -0.09135797f, 0.09369650f, -0.03658867f, 0.04220501f, 0.09612454f, 0.30174091f, 0.01288994f, -0.05776715f, 
    0.11385485f, -0.08226071f, 0.02694563f, -0.04894256f, -0.06865671f, 0.01773184f, -0.10172945f, 0.04527010f, 
    -0.18390884f, -0.07005668f, -0.00838365f, -0.19556022f, -0.02045213f, 0.13382828f, 0.04367105f, 0.03848385f, 
    -0.07182240f, 0.02093876f, 0.12394759f, 0.04077511f, -0.05077494f, -0.04014592f, 0.07013458f, 0.08204437f, 
    -0.06713333f, -0.08885451f, 0.01974323f, 0.05781115f, 0.05325950f, 0.04376126f, 0.03915519f, 0.03673450f, 
    0.10900294f, -0.06559853f, 0.06596348f, 0.01801259f, -0.08272875f, 0.14975758f, -0.06097358f, 0.01678908f, 
    0.00198608f, 0.03119793f, -0.05709623f, -0.04615812f, -0.55380636f, 0.29006991f, -0.02305182f, 0.01501238f, 
    0.03570067f, -0.04959921f, -0.04985552f, -0.00256341f, 0.15930353f, 0.02641735f, 0.00916741f, 0.03676467f, 
    -0.17756766f, 0.16673544f, -0.05998041f, 0.02118934f, 0.04853987f, -0.02059010f, -0.05017873f, -0.04125072f, 
    -0.06104063f, -0.02061688f, 0.01379839f, -0.07365570f, 0.08248522f, -0.08710699f, 0.10688306f, 0.02824600f, 
    -0.07817950f, -0.04915485f, -0.14015761f, -0.03350335f, -0.05249116f, -0.01749267f, 0.00005513f, -0.02176163f, 
    -0.04970278f, -0.02664562f, -0.13417301f, -0.04525163f, -0.02724879f, 0.04286409f, 0.05865973f, 0.01574257f, 
    -0.09773529f, 0.06088719f, -0.00501905f, 0.06433262f, 0.21637917f, -0.09868350f, -0.09961212f, -0.06628457f, 
    0.04310302f, -0.00845322f, 0.03118791f, 0.00654282f, 0.10245965f, 0.02679917f, 0.07282901f, 0.05165159f, 
    0.24818486f, 0.02626840f, 0.17420202f, 0.18820165f, 0.06421152f, -0.02435361f, -0.03489126f, -0.02842390f, 
    -0.02743581f, -0.02047465f, -0.00560671f, 0.02206918f, -0.08077098f, -0.05943304f, 0.09109637f, 0.21227159f, 
    -0.05210782f, -0.03442815f, -0.09679937f, -0.06319932f, -0.08493590f, -0.04170776f, -0.03888758f, 0.01152585f, 
    0.23736884f, 0.26681176f, 0.02438321f, 0.03834343f, 0.12266007f, 0.06667294f, 0.09176432f, 0.09316034f, 
    0.02897424f, 0.09025939f, -0.04247927f, 0.03588479f, 0.00848550f, -0.03786786f, 0.07198191f, -0.08061627f, 
    0.08965661f, -0.11126398f, 0.02954340f, 0.12203220f, -0.03161295f, -0.02352721f, -0.11161650f, -0.03728637f, 
    0.29435235f, -0.10906896f, 0.01829025f, -0.08368593f, -0.07417551f, -0.05828905f, -0.04454662f, -0.02846003f, 
    0.02274196f, 0.06689204f, 0.03292267f, 0.03540526f, -0.43519300f, 0.18675579f, -0.00298442f, -0.13570188f, 
    0.06685059f, -0.04673002f, 0.01017884f, -0.00371277f, 0.06387779f, 0.06796793f, -0.01846574f, 0.02715858f, 
    -0.17021860f, 0.07420022f, -0.08424279f, -0.19228747f, 0.02331564f, -0.04257623f, -0.00251504f, 0.01958616f, 
    -0.00383364f, -0.06708136f, -0.10360624f, -0.04530084f, -0.12882443f, 0.27615175f, -0.03526023f, 0.01559917f, 
    0.06790910f, 0.04544913f, 0.02855683f, -0.01043682f, -0.13888273f, 0.01369575f, 0.06426153f, -0.01341115f, 
    -0.02337035f, 0.00064254f, -0.21171091f, 0.10116117f, 0.14637820f, 0.03735355f, -0.01477429f, -0.01565703f, 
    0.09201323f, -0.11192547f, -0.09086760f, 0.00743178f, -0.04508456f, -0.12130556f, -0.11018469f, 0.04469888f, 
    0.09166943f, -0.01118880f, -0.04553245f, -0.14472708f, 0.01267546f, 0.04665454f, -0.05856454f, 0.04990061f, 
    -0.01198566f, -0.14936377f, 0.09284668f, 0.14642669f, -0.15191106f, -0.15919097f, -0.05026108f, -0.14531188f, 
    0.01062593f, 0.04423918f, -0.02656961f, 0.00476572f, -0.40120259f, 0.11846110f, -0.14195943f, -0.09158414f, 
    0.02156016f, 0.07190473f, -0.03730843f, 0.02514971f, 0.02419447f, -0.01955767f, 0.06187504f, 0.11102999f, 
    -0.15506046f, 0.03113435f, -0.08565938f, 0.03994779f, 0.10747298f, 0.19069251f, 0.01987720f, 0.01043931f, 
    -0.06263886f, -0.00686698f, -0.02163405f, 0.05789451f, 0.02928137f, 0.11179129f, 0.17195326f, -0.29592836f, 
    0.05955881f, -0.11885570f, 0.04398869f, -0.09489315f, -0.04119185f, -0.08722614f, 0.03454146f, -0.03783148f, 
    -0.05508764f, 0.17116943f, -0.11181878f, 0.17086758f, -0.07507701f, -0.05230311f, -0.03816201f, 0.05517400f, 
    -0.06094728f, 0.02380553f, -0.09996233f, 0.04082965f, -0.02849154f, 0.06058585f, -0.26393747f, -0.06030006f, 
    0.00429706f, -0.00965464f, 0.06688719f, 0.03905126f, 0.04848728f, -0.05573472f, 0.04404497f, 0.00678311f, 
    0.06859577f, 0.01292734f, 0.08816274f, 0.02528354f, 0.09161308f, -0.00014892f, 0.03054620f, 0.07019443f, 
    0.01035757f, 0.02534370f, 0.10047819f, 0.06262469f, -0.05394245f, -0.21751741f, 0.01098029f, -0.01993780f, 
    -0.00536562f, -0.06230349f, 0.07007071f, -0.04509041f, 0.08794077f, 0.09459691f, -0.00336468f, 0.14659157f, 
    0.14448807f, 0.25569975f, -0.00797712f, -0.05006874f, 0.11783732f, 0.08448907f, 0.04188174f, -0.13687980f, 
    0.05977524f, 0.02977935f, 0.01985812f, 0.08034635f, -0.06694494f, 0.11630408f, -0.04811936f, -0.00345987f, 
    -0.00982231f, -0.02135946f, 0.02402386f, -0.00282496f, -0.00507083f, -0.02844669f, 0.07976394f, -0.00555591f, 
    0.16599905f, 0.09341244f, 0.01132987f, 0.13901216f, 0.00286079f, 0.02138365f, -0.04773157f, -0.01668354f, 
    0.02658620f, -0.05060980f, 0.01951410f, 0.02535949f, 0.14993995f, 0.08807660f, 0.14224111f, 0.18448961f, 
    0.11710697f, -0.08463868f, 0.07275050f, -0.04580499f, 0.06496808f, -0.03092162f, -0.02906159f, 0.01731976f, 
    0.21150738f, 0.13677867f, -0.19833124f, -0.09909221f, 0.09793569f, 0.09678846f, 0.01938702f, -0.02634880f, 
    -0.13352677f, 0.00218337f, 0.06008719f, 0.02685765f, -0.05439640f, -0.15220252f, -0.03859932f, -0.12861842f, 
    0.11187617f, -0.02607817f, -0.00537998f, -0.06413686f, -0.00421652f, -0.03868806f, 0.05429150f, 0.09113906f, 
    -0.22300138f, 0.01395485f, 0.16547853f, -0.12369885f, -0.06566983f, 0.02689168f, -0.09609777f, -0.11989275f, 
    0.05422054f, -0.06147005f, -0.05827298f, 0.00669522f, -0.17410342f, 0.11690953f, -0.08280434f, 0.00117681f, 
    0.03865355f, -0.05458985f, 0.01591408f, 0.02274885f, -0.03212353f, 0.09470960f, -0.00853481f, -0.03600433f, 
    -0.19013254f, 0.02049540f, 0.19005941f, -0.14203323f, -0.02870967f, 0.05436384f, 0.05839499f, -0.05449193f, 
    0.00669837f, 0.01703544f, -0.00319237f, 0.02186716f, -0.08869082f, -0.00273639f, 0.08887082f, 0.15284516f, 
    0.05827849f, 0.07893867f, 0.04414861f, -0.02173055f, -0.11264722f, 0.00574136f, 0.07147099f, 0.02292632f, 
    0.20738186f, -0.10432743f, -0.11114964f, 0.17216638f, 0.08259135f, 0.01740849f, -0.05961606f, -0.03104973f, 
    -0.02200690f, 0.01172106f, 0.04828439f, -0.06158049f, -0.28698450f, 0.10763983f, -0.01005257f, 0.03704917f, 
    -0.09228212f, 0.04068936f, -0.04332305f, 0.00872325f, 0.02688127f, 0.01140668f, -0.05747455f, 0.02249032f, 
    -0.00542850f, -0.09125386f, 0.06004882f, 0.18294834f, 0.07555205f, -0.05939795f, 0.04664254f, -0.09165437f, 
    0.05559529f, -0.05809671f, 0.07918382f, 0.03259759f, 0.15128320f, -0.07894453f, 0.09627262f, -0.03354523f, 
    -0.06280061f, 0.13658652f, 0.04340218f, -0.01018756f, 0.10626919f, 0.04100064f, 0.15696219f, 0.00761571f, 
    -0.30855152f, 0.12504208f, -0.07032540f, -0.08787978f, 0.10119034f, 0.05809736f, -0.06981878f, -0.05824592f, 
    0.00900556f, -0.05408453f, -0.01938931f, 0.03660746f, 0.01992522f, -0.04282947f, -0.00146194f, 0.03382597f, 
    -0.04957682f, -0.01684452f, -0.03483083f, -0.05167483f, 0.02017396f, 0.03582276f, -0.02306985f, -0.06538610f, 
    -0.08600584f, -0.07386515f, 0.16269182f, 0.11803781f, -0.00909691f, -0.00033804f, 0.07444511f, -0.01250672f, 
    0.05588479f, 0.12260136f, -0.00751454f, 0.02703753f, -0.08457439f, -0.00957489f, -0.08852941f, -0.22308354f, 
    -0.02575185f, 0.05519477f, 0.08957436f, -0.03400328f, 0.03470322f, -0.07244601f, -0.00209549f, 0.08875991f, 
    -0.25594136f, 0.20097354f, 0.06715759f, -0.03970406f, 0.02213512f, 0.08684875f, 0.09720498f, 0.06278470f, 
    0.07654351f, -0.04034324f, 0.01873766f, -0.01532198f, -0.01196898f, 0.16377579f, -0.01040138f, -0.16077873f, 
    0.07114626f, 0.01799959f, 0.01995316f, 0.00724781f, 0.05770768f, -0.03758385f, 0.12753810f, -0.08099598f, 
    -0.01819247f, -0.02951375f, 0.04921115f, 0.03970798f, 0.08193579f, 0.07778517f, -0.00449579f, 0.03234155f, 
    0.04223578f, -0.10798474f, 0.02858933f, 0.05734169f, -0.01985697f, 0.08465465f, -0.04420820f, -0.08537219f, 
    -0.03926286f, -0.00085912f, 0.08140039f, -0.05625920f, 0.06343788f, -0.04946110f, -0.08689988f, 0.06907468f, 
    -0.09230365f, 0.14742345f, 0.12280843f, -0.16009851f, 0.12375022f, 0.07262085f, 0.17482054f, -0.06190488f, 
    0.09239609f, 0.01668875f, 0.01484897f, 0.04943481f, -0.23170796f, -0.01615262f, 0.06474021f, -0.11723388f, 
    0.11375929f, -0.10262635f, 0.00603796f, -0.01669416f, -0.00182312f, -0.02554171f, 0.01348042f, -0.10842907f, 
    0.03702275f, -0.09954158f, 0.09496073f, -0.03548136f, -0.01312596f, -0.02982793f, 0.03199859f, 0.07388099f, 
    0.06656098f, 0.06193223f, 0.02780978f, -0.04760698f, -0.18577686f, -0.07585371f, 0.19818257f, 0.15387128f, 
    0.02050709f, -0.00666637f, 0.09100376f, 0.02981026f, 0.06807832f, 0.01020301f, -0.02179682f, 0.02164803f, 
    -0.11241168f, -0.00918257f, -0.00516805f, 0.26274061f, -0.03337618f, 0.01392464f, 0.05542429f, -0.19079143f, 
    0.01997225f, 0.04183315f, -0.04874383f, -0.02072806f, -0.30020252f, 0.08167777f, 0.00660654f, -0.16917270f, 
    0.04018271f, -0.04882160f, 0.02232308f, 0.01214801f, 0.05439171f, 0.07696339f, 0.03020281f, -0.11607213f, 
    -0.46400231f, 0.12922774f, 0.14540905f, -0.02761838f, 0.05117250f, -0.08459222f, -0.09035429f, -0.04968550f, 
    0.05141071f, 0.07066346f, -0.06585085f, 0.07502598f, -0.42882627f, 0.13199309f, 0.22624093f, 0.12058261f, 
    0.01545213f, -0.02279531f, -0.00045777f, -0.05319392f, -0.01721988f, 0.07462587f, -0.09296010f, 0.04765587f, 
    0.24959259f, 0.05680368f, -0.00906113f, 0.31263757f, -0.04099993f, 0.00416714f, -0.09215298f, -0.08026066f, 
    0.07235154f, 0.07674811f, 0.06108933f, 0.10757313f, 0.02227369f, -0.04072528f, -0.05125696f, -0.12049425f, 
    -0.10563976f, -0.11417321f, -0.01654507f, -0.08258537f, -0.03908120f, 0.05735312f, -0.09721239f, 0.10053111f, 
    -0.07564320f, -0.11184449f, 0.03184701f, -0.17300335f, -0.10192187f, 0.02957819f, 0.00807156f, -0.09685799f, 
    -0.00821730f, 0.04394590f, 0.00838170f, 0.07401317f, -0.08016060f, -0.09715989f, 0.11208004f, 0.05068497f, 
    -0.10865854f, -0.03444711f, -0.07693014f, -0.00046901f, 0.08039838f, -0.01384213f, -0.01574091f, 0.11836680f, 
    -0.07927971f, -0.17796387f, -0.05219488f, -0.16456819f, -0.06730803f, 0.01198355f, -0.09089464f, -0.12690774f, 
    0.07375560f, 0.01065614f, 0.12524264f, 0.03338942f, 0.05091134f, -0.15088335f, 0.17900845f, 0.24480024f, 
    0.09230023f, 0.02981655f, -0.07301840f, -0.08545059f, -0.00481989f, -0.06996802f, 0.17581029f, 0.12121466f, 
    -0.01036619f, -0.16921382f, 0.09496954f, -0.15778036f, 0.06663720f, -0.11131202f, 0.07590833f, 0.04837376f, 
    -0.06974845f, -0.02100340f, 0.04471101f, 0.02092103f, 0.07282639f, -0.05039777f, 0.11680026f, -0.03746469f, 
    0.07103770f, -0.16310228f, -0.01854465f, 0.13431336f, 0.06637343f, 0.04885026f, -0.10367037f, -0.06950842f, 
    -0.04141124f, -0.09824350f, 0.09791026f, -0.11675661f, 0.02174423f, -0.09429916f, 0.12069307f, 0.12607689f, 
    0.02226855f, 0.07331407f, -0.08040565f, 0.00855961f, -0.00637690f, 0.05471990f, -0.01866115f, 0.13099460f, 
    0.07357694f, 0.12298880f, 0.07762313f, -0.07986887f, -0.05239287f, -0.01660706f, 0.02206353f, 0.12161597f, 
    0.15791902f, 0.02725177f, -0.09636270f, 0.00689710f, 0.10225023f, -0.16085623f, 0.03318471f, -0.13490857f, 
    -0.01281431f, 0.00356211f, -0.17807594f, 0.02740981f, -0.33827189f, 0.13701232f, 0.11951199f, 0.15328696f, 
    -0.00014673f, -0.09712169f, -0.02294772f, -0.05501722f, 0.04485214f, 0.03102677f, 0.12003045f, 0.15626873f, 
    -0.22577348f, 0.06128775f, 0.04051705f, -0.10173474f, 0.02864191f, 0.03587759f, -0.13163012f, 0.06039455f, 
    -0.05218917f, 0.01134576f, 0.01840835f, -0.16472428f, -0.02437784f, -0.11589186f, 0.03747297f, 0.19432895f, 
    0.03118656f, 0.06461170f, -0.01461688f, -0.02566998f, 0.00082394f, -0.08960501f, 0.05381477f, -0.08066682f, 
    0.07995754f, 0.16496044f, 0.02723699f, -0.11373410f, -0.06861400f, -0.03084450f, -0.14546008f, 0.07169363f, 
    0.14941519f, 0.08918777f, -0.06847931f, -0.09489082f, -0.15526900f, 0.01977522f, 0.09586133f, 0.02203853f, 
    0.10323437f, 0.05888921f, -0.00792131f, 0.05453336f, 0.12201987f, -0.01922507f, -0.01182991f, -0.04335457f, 
    0.03268053f, -0.16007198f, -0.04447259f, 0.12901822f, 0.01632351f, 0.04669241f, -0.01821635f, 0.01608178f, 
    0.13389698f, 0.13557211f, 0.01488587f, -0.12706533f, -0.02455520f, -0.13991944f, -0.06280323f, 0.34121916f, 
    0.03922535f, 0.13136169f, 0.03810586f, -0.05832558f, -0.07808433f, -0.17323942f, 0.02078562f, -0.05389193f, 
    -0.25913215f, -0.07432533f, -0.09348743f, -0.11639090f, 0.00891977f, -0.05390494f, 0.02855206f, -0.13337067f, 
    0.02454462f, -0.05296704f, -0.01932055f, -0.00504572f, 0.28672826f, -0.00729587f, 0.04761827f, 0.01828125f, 
    -0.02211220f, -0.06240078f, 0.02341170f, -0.03959372f, 0.07105476f, -0.10351588f, -0.02220936f, 0.01507709f, 
    0.32259297f, -0.07043335f, -0.01113786f, 0.03214423f, -0.01613590f, 0.01780378f, -0.02267766f, -0.09655479f, 
    -0.05639568f, -0.02655928f, -0.07070792f, 0.07265361f, -0.08229251f, 0.10829590f, -0.06757454f, -0.02786818f, 
    0.03053343f, 0.08014576f, 0.07297918f, 0.04639294f, 0.07531130f, 0.02934394f, 0.14232117f, 0.03475723f, 
    -0.25643381f, 0.07783841f, 0.00312102f, 0.04654821f, -0.07759335f, 0.12113532f, 0.09930371f, 0.12675782f, 
    -0.06411745f, -0.11431132f, 0.20408425f, -0.30928141f, 0.03966437f, 0.20132205f, -0.04668580f, -0.07051946f, 
    0.05680298f, -0.09909192f, 0.01417242f, -0.05732163f, -0.00415142f, -0.09778224f, -0.11256910f, -0.21099576f, 
    -0.02710775f, -0.00067730f, 0.08243082f, 0.02260215f, -0.21071313f, 0.05129875f, -0.08398217f, -0.17362963f, 
    -0.11425418f, -0.07152271f, -0.04275271f, -0.03423455f, -0.06316570f, 0.02059534f, -0.06466121f, -0.00573797f, 
    0.09764816f, -0.05824960f, -0.00676795f, 0.05573130f, 0.18742527f, -0.01100564f, -0.05753187f, -0.11620354f, 
    0.06768172f, -0.10870179f, -0.02446309f, 0.15987273f, -0.03803630f, -0.03585763f, -0.02680377f, 0.12219733f, 
    0.07924377f, -0.02829735f, 0.10915334f, 0.00308919f, -0.08620938f, -0.15271269f, 0.06280354f, -0.04868654f, 
    0.14187799f, 0.03179992f, 0.08649604f, 0.01373759f, 0.03336814f, 0.02760909f, -0.12155162f, 0.03673491f, 
    -0.14122501f, -0.00611145f, 0.03294161f, -0.04035867f, -0.00382858f, 0.13023593f, -0.00220153f, -0.07309881f, 
    0.02979427f, -0.11414581f, 0.01984224f, 0.09296162f, -0.05779352f, -0.03559900f, 0.21958271f, 0.13828996f, 
    0.08748829f, -0.09410550f, -0.08983406f, 0.13899563f, 0.14829488f, -0.17880404f, -0.03828418f, -0.15215482f, 
    0.12634183f, 0.01258172f, 0.08763730f, 0.06882079f, 0.15235898f, -0.15567724f, 0.05794231f, -0.16544725f, 
    0.12276927f, 0.02474818f, 0.00672836f, -0.13501999f, 0.28015998f, 0.03335356f, -0.02653532f, -0.10255609f, 
    0.01987159f, -0.23969921f, -0.00759455f, 0.09891626f, 0.06915802f, 0.02427837f, 0.11002305f, -0.12952864f, 
    -0.10642911f, -0.05045763f, 0.10081369f, -0.07474982f, -0.00804687f, -0.12367631f, -0.07107911f, 0.01218171f, 
    -0.02320309f, -0.20871793f, 0.03037689f, 0.02502420f, -0.01330124f, 0.03984792f, 0.13537033f, -0.10767039f, 
    0.07960659f, -0.03528565f, 0.11253460f, -0.09271861f, -0.00972291f, 0.05195855f, -0.02761749f, 0.18307535f, 
    -0.12423629f, 0.19038221f, 0.00327079f, 0.00457440f, -0.02675512f, -0.08946503f, 0.02432865f, -0.02636752f, 
    0.06030584f, -0.11911752f, 0.04399399f, 0.14227736f, -0.02285156f, 0.14527069f, 0.00094451f, 0.02364537f, 
    0.03618808f, -0.07214114f, -0.02213844f, -0.10191298f, 0.00023235f, 0.08337831f, -0.03598251f, 0.21578281f, 
    0.05590257f, -0.05221379f, 0.02007432f, 0.18469290f, 0.00947155f, 0.06414168f, 0.00339758f, -0.11844296f, 
    0.06359012f, 0.01495174f, -0.02386839f, 0.25743487f, -0.06534883f, 0.07570527f, 0.16604701f, 0.20620547f, 
    -0.01564142f, 0.04768058f, 0.01788475f, 0.01806126f, 0.14098716f, 0.08469891f, -0.10478658f, 0.07313924f, 
    -0.00983192f, 0.09178118f, -0.00932514f, -0.12395655f, -0.02540546f, 0.00270353f, -0.02533087f, -0.12689438f, 
    -0.06024001f, -0.05351223f, 0.04067480f, 0.01545827f, 0.28539157f, -0.04152420f, -0.18061610f, 0.03926855f, 
    0.04222417f, 0.11880170f, 0.02958479f, -0.05764338f, -0.12160325f, -0.09928624f, -0.04597951f, 0.06078001f, 
    -0.02398774f, 0.08401889f, -0.21741383f, 0.04965017f, -0.06332517f, 0.01254879f, 0.05897143f, -0.01928768f, 
    0.02919466f, 0.09769378f, 0.11022935f, 0.08414895f, 0.04198527f, 0.14058670f, 0.03695935f, 0.02367662f, 
    -0.09383524f, -0.09538541f, 0.03072196f, -0.06061233f, 0.09180842f, -0.02884347f, -0.06994398f, 0.07148886f, 
    0.24901327f, 0.03155150f, -0.27290261f, -0.08780408f, -0.03458360f, 0.10029032f, -0.13492282f, 0.11922036f, 
    0.10361810f, -0.01286023f, -0.17353672f, -0.03024893f, -0.11291260f, 0.06208406f, -0.03503495f, 0.01267069f, 
    0.10396278f, 0.01792204f, -0.06758723f, 0.09012662f, 0.12114436f, 0.06919317f, 0.02061514f, -0.02418761f, 
    -0.06972030f, 0.11576272f, 0.01022313f, 0.01644702f, 0.02138172f, 0.02864044f, -0.07571440f, 0.09637538f, 
    0.08910514f, -0.22612169f, 0.04551413f, -0.13590400f, 0.04332486f, 0.24170062f, -0.08864268f, -0.01279727f, 
    -0.03107567f, 0.04962857f, -0.05144670f, 0.01857676f, 0.03013747f, -0.04767692f, 0.13213871f, 0.05581723f, 
    -0.20699126f, -0.15574928f, -0.08026359f, 0.18967678f, 0.04465877f, -0.08852261f, 0.02803788f, 0.23175117f, 
    -0.00273664f, 0.07692403f, 0.08558412f, -0.09006599f, 0.01436050f, 0.03174254f, 0.06863108f, 0.15658240f, 
    0.07174785f, 0.10435425f, 0.04812497f, 0.08673170f, 0.04172077f, -0.11513649f, -0.01370718f, 0.08373130f, 
    -0.13833614f, -0.05093076f, -0.01485381f, -0.05505856f, 0.02884959f, -0.01877666f, 0.09354616f, 0.02198269f, 
    -0.02378234f, 0.13322029f, -0.19079703f, 0.16620316f, 0.11815236f, 0.00794597f, -0.16640627f, -0.03018855f, 
    0.01213575f, -0.05584074f, 0.03503131f, -0.02983584f, 0.08753695f, -0.21399200f, -0.00842706f, 0.12772855f, 
    0.01461801f, 0.13583729f, -0.10658235f, 0.11229387f, 0.09391882f, -0.02924986f, 0.05373311f, 0.09803667f, 
    0.03639540f, 0.11359774f, 0.02475024f, -0.04147911f, 0.28758264f, 0.02990521f, 0.06089034f, -0.04587358f, 
    0.09857798f, 0.06514427f, -0.06993446f, -0.03424513f, 0.04045453f, 0.11180864f, -0.03227310f, -0.22103307f, 
    -0.09629614f, 0.07192815f, -0.00347828f, 0.04658090f, -0.01791853f, 0.11415219f, 0.04417376f, -0.01659741f, 
    0.05359175f, -0.04790554f, 0.03011694f, -0.15475720f, 0.03244705f, 0.06045595f, -0.01074589f, -0.02434677f, 
    -0.00333664f, -0.11426903f, -0.03423635f, 0.04469356f, 0.13514690f, -0.02558557f, -0.09901557f, 0.00351965f, 
    -0.16999853f, -0.11009143f, 0.01075136f, -0.10021174f, 0.01201364f, -0.01068659f, -0.02522097f, 0.10029720f, 
    0.01278537f, 0.12017165f, -0.05419162f, -0.12817457f, 0.05064824f, 0.20450978f, 0.08486097f, 0.03667950f, 
    -0.01046918f, 0.01843239f, 0.00614574f, 0.09758373f, -0.04463544f, -0.08328606f, 0.10730486f, 0.07858580f, 
    -0.26597449f, -0.08293019f, -0.12174197f, -0.01916397f, 0.01458432f, -0.06143910f, 0.05322700f, 0.02584416f, 
    0.08162846f, -0.12458740f, 0.05428923f, -0.00634687f, -0.09975314f, -0.04886896f, -0.07899839f, -0.10771656f, 
    0.08025169f, -0.10284160f, 0.11549793f, -0.08533222f, -0.00257280f, 0.18033563f, 0.17356913f, 0.17930834f, 
    -0.02976843f, 0.15643491f, 0.00951641f, 0.04465365f, 0.07064923f, -0.01784025f, -0.06632426f, -0.06435636f, 
    -0.07171430f, 0.05515875f, 0.18728247f, 0.10590085f, -0.02514258f, 0.05855187f, -0.06205619f, -0.02301506f, 
    0.03110075f, -0.02514986f, -0.02769739f, 0.09107437f, 0.05362064f, -0.05900856f, 0.05740185f, 0.11786304f, 
    -0.24514216f, 0.03210713f, -0.06955504f, 0.11779805f, -0.12813446f, 0.08136230f, 0.02262678f, -0.14200690f, 
    -0.00491405f, -0.05750958f, -0.15555200f, -0.07105522f, -0.14518873f, -0.05402964f, 0.03653610f, -0.05956728f, 
    0.03335394f, 0.02963191f, 0.05355181f, -0.01290059f, -0.10578198f, -0.02360822f, -0.05076281f, 0.11219356f, 
    -0.11941279f, -0.09992841f, 0.00018193f, -0.12413767f, 0.01810538f, -0.01937005f, -0.03052508f, 0.07716937f, 
    0.06151367f, -0.10983184f, 0.06683287f, 0.09329893f, 0.14456765f, 0.18126582f, 0.05236322f, 0.11306247f, 
    -0.01635061f, -0.04585250f, 0.05794907f, 0.00108684f, -0.00576541f, 0.18396001f, -0.00720512f, 0.04040949f, 
    0.08321071f, -0.06174226f, 0.12385218f, -0.13416971f, -0.05537148f, -0.11988391f, -0.05936114f, -0.16080062f, 
    0.12974335f, 0.04248917f, 0.06786126f, 0.15029863f, 0.20786726f, 0.04241431f, 0.02695033f, 0.02863063f, 
    -0.04414606f, 0.11314435f, -0.05408690f, -0.02369261f, 0.12294138f, 0.05960812f, -0.06104334f, 0.25934175f, 
    0.05643848f, 0.07911510f, 0.09236296f, 0.05013830f, -0.06014210f, -0.00561313f, -0.08403087f, 0.04931572f, 
    0.13747120f, -0.18617684f, 0.08042807f, -0.01367820f, -0.09008988f, -0.02080916f, 0.19013923f, 0.14249992f, 
    -0.07153130f, 0.06698467f, -0.01880402f, -0.03026785f, -0.02992453f, 0.03078599f, 0.07427818f, 0.19634394f, 
    0.01351515f, 0.00991778f, -0.01592223f, 0.02058716f, 0.01462025f, -0.02679939f, -0.03456616f, 0.01817205f, 
    0.02653551f, 0.03006529f, -0.03320413f, 0.02479602f, -0.02230113f, 0.01571012f, -0.03478187f, -0.02246735f, 
    -0.00338364f, -0.00979763f, 0.00047282f, -0.02678497f, -0.03609869f, 0.00008545f, 0.00821740f, 0.02379026f, 
    -0.01993403f, -0.03841167f, -0.00949525f, -0.03424351f, -0.03106232f, -0.01379639f, -0.02252190f, -0.03605712f, 
    0.01691020f, -0.01571195f, -0.02682860f, -0.03256468f, -0.00773888f, -0.00353053f, 0.02104682f, 0.02462763f, 
    -0.00180004f, -0.02072235f, -0.00089244f, -0.02935060f, -0.03560382f, -0.03049603f, 0.02560603f, 0.00726064f, 
    0.00408281f, -0.02310395f, -0.01033785f, -0.02850563f, 0.03187043f, -0.00737134f, -0.02611543f, 0.00729751f, 
    -0.02957760f, 0.00470723f, 0.02352867f, 0.00442571f, -0.00406924f, 0.03066972f, -0.03780100f, -0.01875696f, 
    -0.02573088f, 0.00092764f, -0.00848728f, 0.03221649f, -0.02952827f, 0.01371342f, 0.02327690f, 0.02861529f, 
    -0.02187117f, 0.01993000f, 0.02007800f, 0.03020876f, -0.02659690f, -0.01337392f, -0.03743844f, -0.02739351f, 
    -0.03273273f, 0.03080173f, 0.02016830f, 0.00312191f, 0.00557360f, -0.02987303f, 0.00602012f, 0.01862117f, 
    -0.02253368f, -0.01237903f, 0.01615648f, 0.00710029f, -0.02146409f, 0.00890420f, -0.03457818f, -0.01838478f, 
    -0.00958009f, 0.01366530f, 0.00255141f, -0.01588045f, -0.02856123f, -0.03785819f, -0.02079347f, 0.00916936f, 
    -0.02986051f, -0.00171380f, 0.02505101f, 0.03071768f, -0.02533018f, -0.02685065f, -0.02166754f, 0.01940178f, 
    0.00957236f, 0.01818316f, 0.01892823f, 0.01751223f, -0.03641170f, 0.03214557f, -0.01689990f, -0.03809084f, 
    -0.03600730f, -0.00178258f, 0.01288940f, -0.00383894f, 0.00890775f, 0.00023834f, 0.02230391f, 0.01376688f, 
    0.02040792f, -0.00413689f, -0.00888118f, 0.00795662f, -0.01628069f, 0.00737016f, 0.01059675f, 0.01809552f, 
    -0.01662367f, -0.01646588f, -0.03473427f, -0.03617400f, -0.01282205f, -0.02778682f, -0.03514244f, -0.02492867f, 
    -0.03546001f, 0.02866059f, -0.03199352f, -0.01917055f, -0.02623513f, -0.02635808f, -0.03832497f, -0.03483106f, 
    -0.03413315f, 0.00726473f, -0.00426365f, 0.03202257f, 0.02548418f, 0.02483999f, -0.00652777f, -0.03268772f, 
    -0.02628261f, 0.01714087f, 0.00781326f, -0.01758930f, -0.01706162f, -0.03241266f, -0.00875616f, -0.00149144f, 
    -0.02555994f, -0.02490337f, -0.03192057f, -0.03130614f, -0.01990310f, -0.02367635f, -0.02204632f, 0.02210798f, 
    0.01616614f, 0.00063295f, 0.00419693f, -0.02582777f, 0.01098996f, 0.01554151f, -0.03192399f, -0.01516564f, 
    0.01719736f, -0.02342901f, -0.00729613f, -0.02508406f, -0.03712783f, -0.02967419f, -0.03689418f, 0.00349035f, 
    -0.00081538f, -0.03563127f, -0.01932343f, -0.03537430f, -0.00722881f, -0.00307123f, 0.00644626f, -0.00513645f, 
    -0.01922606f, -0.02652129f, -0.02312753f, -0.02397414f, 0.02367634f, 0.01707836f, -0.00276608f, 0.01702403f, 
    -0.02730113f, -0.01717929f, 0.01506307f, -0.00361025f, -0.01734280f, -0.01981917f, -0.01166660f, 0.01331372f, 
    0.00407451f, 0.00983464f, -0.00895009f, 0.02406233f, 0.00360552f, -0.03835161f, -0.01555568f, 0.01813729f, 
    0.02676794f, 0.02061177f, 0.00944268f, -0.02535559f, 0.00940533f, 0.01767270f, -0.00781707f, 0.00665776f, 
    -0.02610952f, -0.00317373f, -0.02540267f, -0.03323939f, -0.03627831f, 0.03199286f, -0.02053863f, 0.00176878f, 
    0.03080972f, 0.02579896f, 0.00422333f, 0.02739527f, 0.00356339f, -0.03130504f, 0.02722942f, -0.02664303f, 
    0.01215159f, -0.01239890f, 0.03018992f, 0.01800859f, 0.01305679f, -0.00997483f, -0.01138338f, -0.03294596f, 
    0.03209328f, 0.00952969f, 0.02982938f, -0.03761314f, 0.01150597f, 0.02261368f, -0.00026460f, -0.01020700f, 
    0.01645163f, -0.03690696f, 0.00603425f, -0.03782042f, -0.00150088f, -0.01694039f, -0.01940654f, 0.00570012f, 
    -0.03833434f, -0.03354839f, -0.03585110f, 0.02961111f, -0.02486873f, -0.02874845f, 0.00358656f, -0.01520786f, 
    0.02617859f, -0.03538425f, -0.01679808f, 0.02887827f, 0.02663961f, -0.03398646f, -0.00715670f, -0.02996974f, 
    0.00774777f, 0.01124099f, -0.02946363f, 0.01514798f, -0.01587885f, -0.03855024f, 0.01047537f, 0.01053138f, 
    0.01734133f, 0.01185596f, -0.02703166f, 0.00272038f, 0.01511639f, -0.02131417f, 0.01590695f, -0.00072715f, 
    -0.02266878f, 0.01745843f, -0.03148692f, 0.00262730f, 0.02252277f, -0.01346263f, -0.03341417f, -0.03256971f, 
    -0.02217812f, 0.02221571f, 0.01144172f, -0.03606189f, 0.01068833f, 0.00498785f, 0.00026620f, -0.00860037f, 
    0.02079090f, -0.01945670f, 0.01319685f, -0.00894823f, 0.01250158f, -0.00877171f, -0.01134478f, 0.03135401f, 
    -0.02491987f, -0.03735014f, 0.01545459f, -0.03727868f, -0.03742612f, -0.01919729f, -0.00848642f, -0.01850848f, 
    0.00165931f, -0.00216938f, -0.03412618f, -0.03684245f, -0.03569323f, -0.03859538f, -0.02195186f, 0.01439569f, 
    0.01130553f, 0.00457740f, 0.00266174f, 0.02614397f, -0.00189103f, 0.01543236f, -0.00114449f, 0.01992317f, 
    0.01867129f, -0.00485911f, 0.00225935f, -0.03045744f, 0.00654590f, -0.01987349f, -0.00578753f, -0.02658516f, 
    0.00762313f, 0.01335406f, 0.00910433f, 0.00302877f, -0.02536278f, 0.01624131f, 0.00952175f, -0.01747301f, 
    0.00137752f, -0.01222663f, -0.03094638f, -0.00190956f, -0.00237591f, -0.03903320f, -0.02476648f, 0.00625961f, 
    -0.03597370f, -0.03018328f, 0.02044101f, -0.02005221f, 0.02253796f, 0.00893061f, -0.03158812f, 0.00617824f, 
    0.00044261f, -0.03269150f, -0.03269146f, -0.03959541f, 0.00442584f, -0.01947510f, -0.01209121f, -0.00816308f, 
    0.00067797f, -0.00242030f, -0.01905602f, 0.00678044f, -0.03093255f, 0.00277317f, 0.00957971f, -0.02096102f, 
    0.00958257f, -0.01663281f, -0.03193785f, -0.02707127f, -0.01863754f, 0.00403512f, 0.00220163f, -0.01040700f, 
    0.02064816f, -0.02807556f, -0.01201019f, 0.01628476f, -0.01049642f, -0.03421350f, -0.01331212f, -0.01310884f, 
    0.02503704f, 0.00286097f, 0.02662915f, -0.01051335f, -0.00526937f, -0.02176960f, 0.01618223f, 0.00640304f, 
    0.02171792f, -0.01373749f, -0.01881758f, 0.00956069f, -0.00817731f, 0.02959818f, 0.01742981f, -0.03564619f, 
    -0.00131420f, 0.03228649f, -0.01445568f, 0.01877145f, 0.00693613f, -0.01223216f, -0.02154819f, -0.00545329f, 
    -0.00655835f, -0.03688730f, 0.01185246f, 0.00871188f, 0.00599861f, 0.00305340f, 0.02054672f, -0.00963642f, 
    -0.02497334f, 0.01826271f, 0.01441181f, -0.01936696f, -0.01355826f, 0.01509597f, -0.02913613f, -0.00588540f, 
    -0.03134959f, -0.01527123f, 0.03009802f, 0.02861267f, -0.00542389f, -0.02847022f, -0.02891704f, -0.02790520f, 
    -0.00925629f, -0.00807168f, 0.00847430f, 0.02691591f, 0.01714242f, -0.02512006f, -0.03647235f, 0.01370705f, 
    0.00209642f, -0.02073469f, 0.03015844f, -0.03133503f, -0.00367116f, -0.00180205f, 0.00175249f, -0.00015305f, 
    0.03100880f, -0.01822896f, 0.01189358f, 0.01722623f, 0.03042961f, -0.03109307f, 0.02972951f, -0.00244196f, 
    0.01983215f, -0.03159393f, -0.00535732f, 0.00529792f, -0.03683344f, 0.02842685f, 0.02261503f, 0.01702402f, 
    0.01372192f, 0.02648415f, -0.03159082f, -0.02387709f, 0.00462624f, -0.00881364f, -0.03097832f, -0.00099007f, 
    0.03102851f, -0.03492640f, 0.02391144f, -0.02904463f, 0.01748914f, -0.03234079f, -0.01018222f, -0.02250158f, 
    0.02906414f, 0.02434380f, 0.02486244f, -0.01059797f, 0.02394211f, -0.00056653f, -0.02833056f, 0.00090367f, 
    0.02600280f, 0.01187337f, -0.02352893f, -0.01277614f, -0.02370311f, 0.02681495f, 0.01882336f, -0.02477130f, 
    -0.00650384f, -0.02490060f, 0.02453628f, 0.02715269f, -0.02151049f, 0.03213736f, -0.02748290f, -0.03534816f, 
    0.00905509f, 0.00953246f, 0.02376705f, -0.00226722f, 0.00908050f, 0.01371208f, 0.01647932f, 0.01672946f, 
    0.01757817f, -0.00757211f, -0.01450755f, -0.02176514f, 0.02128851f, 0.00769715f, 0.01159497f, -0.02356015f, 
    -0.01961654f, -0.00227215f, 0.03072916f, 0.01317980f, 0.00407579f, -0.02390781f, -0.01207752f, -0.02399990f, 
    0.01449274f, -0.01127779f, -0.03711198f, 0.01057389f, -0.02018633f, -0.02835152f, -0.03688803f, 0.00967663f, 
    -0.03698832f, 0.00693754f, -0.00086149f, -0.01390587f, 0.00870930f, -0.01174294f, 0.00738089f, -0.02222094f, 
    0.00810828f, 0.02375470f, -0.02334163f, -0.00082678f, -0.01376467f, -0.00533000f, -0.03027029f, 0.01506477f, 
    -0.02088375f, 0.01647722f, 0.02122514f, 0.00533283f, 0.01457529f, -0.02648396f, -0.01476457f, 0.02930160f, 
    -0.03277293f, -0.03202129f, -0.03937225f, -0.00457103f, -0.03204663f, 0.03301373f, 0.00845251f, 0.00617277f, 
    -0.03029850f, 0.02625571f, 0.01367265f, -0.00695213f, -0.01944089f, 0.03047838f, 0.01439118f, -0.02199698f, 
    0.02120932f, -0.01340960f, -0.00553315f, -0.01124565f, -0.03792273f, -0.02068148f, 0.02464998f, 0.02965141f, 
    -0.02388845f, -0.03015262f, 0.01976934f, 0.01800031f, -0.01263025f, 0.03233266f, -0.00745345f, -0.00070465f, 
    -0.02718138f, 0.00619357f, 0.01787030f, -0.02875568f, 0.00828162f, -0.01713757f, 0.01724750f, -0.00365221f, 
    0.02599080f, -0.01300333f, -0.00392089f, 0.01787869f, 0.01203411f, -0.00235231f, 0.01255394f, 0.02839496f, 
    0.02653970f, -0.03817954f, -0.01675936f, 0.02933096f, -0.01315366f, -0.01652609f, 0.01287956f, -0.01453035f, 
    0.01552748f, -0.01596074f, -0.00512361f, -0.02544675f, -0.00426266f, -0.02141024f, -0.00433955f, 0.00595911f, 
    -0.02534377f, 0.02495321f, 0.01963542f, 0.00714878f, 0.02617135f, -0.02106654f, 0.01771268f, -0.00414327f, 
    0.03282730f, -0.02151976f, -0.01899479f, 0.01663878f, 0.01896297f, 0.03051671f, -0.02604267f, 0.01501703f, 
    -0.01258214f, -0.03886742f, -0.00306957f, -0.02711384f, 0.01804231f, -0.03565825f, -0.03077142f, -0.01479964f, 
    0.01871419f, -0.02057536f, 0.02890307f, -0.02919617f, 0.01833832f, -0.02004592f, -0.02916523f, -0.02894968f, 
    0.00140236f, -0.03410945f, -0.00863477f, -0.03116522f, 0.02138282f, 0.02084322f, -0.00605599f, -0.01068737f, 
    -0.00769584f, 0.03174426f, -0.02848268f, -0.03009477f, 0.02280338f, -0.01786198f, -0.03130229f, 0.02784322f, 
    0.02321258f, -0.00585073f, 0.03107430f, -0.03923653f, -0.00977558f, 0.02797661f, -0.02555166f, 0.01911945f, 
    0.03145961f, -0.03648669f, 0.03419757f, 0.00989628f, -0.01857387f, 0.00149560f, -0.01112209f, 0.03206129f, 
    -0.01195980f, -0.00754311f, 0.02369076f, 0.03283816f, 0.01712784f, -0.01114824f, 0.01872976f, 0.00521716f, 
    -0.00286522f, 0.03239980f, -0.02906046f, -0.01871304f, 0.00247447f, -0.01005901f, -0.00095986f, 0.00476968f, 
    -0.00494825f, 0.01485597f, 0.02152531f, 0.01328794f, 0.02297959f, 0.00477538f, 0.00245852f, -0.03818560f, 
    -0.01920077f, -0.00395420f, 0.02662884f, 0.01249506f, -0.01788867f, 0.00706072f, 0.00715494f, 0.02097231f, 
    -0.03293960f, 0.01220971f, -0.02536181f, -0.01204650f, -0.02007339f, -0.01760974f, -0.03413821f, -0.01110301f, 
    0.00017260f, -0.00618165f, -0.01804512f, 0.00233927f, 0.00031150f, -0.03166206f, -0.01312778f, -0.01879162f, 
    -0.01258619f, 0.01248502f, -0.04001555f, 0.02467445f, 0.02049082f, -0.00826363f, 0.01581662f, 0.01224341f, 
    -0.03129891f, -0.03757503f, -0.01647170f, -0.02605667f, -0.00092199f, -0.00839791f, -0.01759835f, -0.02489232f, 
    0.00371855f, -0.03092431f, 0.00799117f, -0.00963368f, -0.01695096f, -0.00030626f, 0.01367905f, 0.00490533f, 
    -0.03324692f, -0.00570742f, 0.02699429f, 0.00273793f, -0.03124884f, -0.02009553f, -0.00332561f, -0.03383849f, 
    -0.03887207f, -0.01715987f, 0.00920336f, -0.01965682f, -0.01127972f, 0.01914833f, 0.00378437f, 0.01807340f, 
    -0.03797805f, -0.00578406f, -0.01503032f, -0.01989174f, -0.02975358f, -0.02881050f, -0.03048364f, -0.03655650f, 
    -0.03443133f, 0.00408219f, 0.00971404f, 0.01157095f, -0.02175532f, 0.02612069f, -0.03439554f, -0.01682866f, 
    -0.02079406f, -0.03758425f, 0.00880679f, -0.02021557f, 0.00597123f, 0.00895863f, -0.03374005f, 0.01583924f, 
    0.00507473f, 0.02954821f, -0.02033376f, 0.02548960f, 0.00749274f, 0.00966247f, -0.00724958f, 0.02566157f, 
    0.02181608f, -0.01475555f, -0.00492089f, 0.03970329f, -0.03249288f, 0.01114904f, -0.01164320f, -0.03659680f, 
    0.01599877f, -0.03386666f, 0.02182412f, 0.00789468f, 0.02278679f, -0.03238185f, 0.01981489f, 0.01549339f, 
    -0.01292352f, -0.03198877f, -0.03540097f, -0.03962637f, 0.02578157f, -0.00558819f, 0.02711129f, 0.02766179f, 
    -0.01471851f, 0.03160436f, 0.01449349f, -0.00410667f, 0.01213920f, -0.01542024f, 0.02825886f, 0.00330181f, 
    -0.00749573f, 0.01532257f, 0.03023803f, -0.00109869f, -0.02275638f, -0.03327591f, 0.00981377f, 0.02581224f, 
    0.01834529f, 0.00345064f, -0.03620007f, 0.01938186f, 0.00534517f, 0.01013012f, 0.00415385f, -0.00891828f, 
    0.01093179f, -0.02715010f, -0.00986583f, 0.01542355f, -0.02344126f, -0.01217961f, 0.02251544f, -0.01174108f, 
    -0.02088935f, -0.02426081f, -0.03432554f, -0.00135383f, -0.00721863f, -0.01964462f, -0.02103206f, -0.01361980f, 
    -0.02728293f, -0.03405663f, 0.01257214f, -0.02848795f, -0.02753924f, 0.00319877f, -0.01766159f, 0.01484061f, 
    0.01935196f, 0.01064774f, -0.01881379f, 0.02290055f, 0.00436989f, -0.00551301f, -0.02026829f, -0.00697319f, 
    0.02076257f, -0.02919848f, 0.01615535f, 0.01575298f, -0.02707079f, 0.01043749f, 0.01316282f, -0.01373876f, 
    0.01912512f, -0.02253366f, 0.00103772f, -0.02529931f, 0.01381458f, 0.01477695f, 0.00679136f, -0.02267830f, 
    -0.01371624f, -0.03944284f, 0.01794208f, 0.00687698f, -0.00330762f, -0.03702224f, 0.00474006f, -0.02173749f, 
    -0.04193712f, 0.01414618f, 0.02274418f, -0.01486719f, -0.01109885f, -0.01534313f, -0.00876748f, -0.00481933f, 
    -0.03632146f, 0.03006607f, 0.01119557f, -0.04239196f, 0.02336046f, -0.02488162f, -0.03492744f, -0.01772393f, 
    0.01088425f, -0.02708555f, 0.01150244f, 0.01291591f, -0.03344745f, 0.00349818f, -0.02860031f, 0.01368732f, 
    0.01460583f, 0.00533486f, 0.02656296f, 0.02756571f, 0.03816181f, 0.00671055f, 0.03184738f, -0.00200670f, 
    -0.02785024f, -0.00140469f, 0.02453172f, 0.00923525f, -0.04072904f, 0.00066971f, -0.02602553f, -0.01432189f, 
    0.02787504f, -0.02181735f, 0.02158181f, 0.03587351f, 0.02236469f, -0.02943286f, -0.04217273f, -0.02298557f, 
    -0.03209642f, -0.01993579f, 0.00609388f, 0.00615968f, -0.00168326f, -0.01433969f, -0.01921729f, 0.01001989f, 
    -0.00524072f, 0.01626822f, -0.02593854f, -0.01673567f, -0.01565815f, -0.01013807f, 0.02098526f, -0.03634309f, 
    -0.01929641f, 0.02080092f, -0.03931305f, -0.02560470f, -0.03416634f, -0.00719858f, 0.02846006f, -0.02159186f, 
    -0.00115719f, -0.00702304f, 0.00603023f, 0.02624511f, -0.01070092f, -0.03817864f, -0.00832425f, -0.00978235f, 
    -0.02822778f, 0.03128363f, -0.00276777f, -0.00724492f, -0.00263823f, 0.01131925f, -0.01892563f, -0.02371707f, 
    0.02049927f, 0.01588751f, 0.00180504f, 0.02455699f, -0.01507746f, 0.00297915f, 0.02690247f, -0.04287436f, 
    0.02565613f, 0.02666078f, 0.01269687f, -0.02688387f, 0.01600750f, -0.02113697f, -0.00792797f, 0.01703763f, 
    -0.01311754f, -0.02736175f, -0.03355066f, -0.03261065f, 0.03351968f, 0.01136496f, 0.03076329f, 0.01814972f, 
    -0.00483097f, 0.02423174f, -0.02349620f, -0.01059402f, -0.04056102f, 0.00898247f, -0.01733937f, 0.02703706f, 
    0.02284734f, -0.02173780f, -0.03900728f, -0.00284903f, -0.00119601f, -0.03046733f, 0.00080258f, -0.02112459f, 
    -0.02335905f, 0.00044378f, 0.01342905f, -0.03133116f, 0.01119770f, -0.00718905f, 0.01574770f, 0.01640049f, 
    -0.02353997f, -0.01353692f, -0.03350011f, -0.01829637f, -0.01703629f, 0.01736780f, -0.03811867f, -0.01788169f, 
    0.00623392f, 0.02269286f, -0.03481001f, -0.02701603f, 0.02404107f, -0.02615516f, 0.01234677f, -0.02565574f, 
    -0.01254044f, 0.01352763f, -0.00640571f, 0.02447714f, -0.00097058f, 0.01605691f, 0.02744684f, 0.00971608f, 
    -0.00198467f, -0.01322699f, 0.00523235f, -0.00485111f, 0.01184841f, -0.03303917f, -0.02495386f, 0.02278093f, 
    -0.03078810f, 0.02242937f, -0.02455892f, -0.02624965f, -0.02873680f, 0.02474209f, 0.01397339f, -0.02771455f, 
    -0.03110821f, 0.00111613f, 0.01797306f, -0.03054242f, 0.01066300f, -0.02311222f, 0.01915752f, 0.02096488f, 
    -0.00011873f, -0.01454454f, 0.01176547f, -0.01462263f, -0.01560714f, 0.01494244f, 0.02849446f, -0.01919587f, 
    -0.01994130f, 0.01165549f, 0.02207655f, -0.00083018f, 0.01044078f, 0.01732804f, -0.03863612f, -0.01469136f, 
    -0.00297962f, 0.01051750f, -0.03832852f, 0.00922263f, -0.00118645f, 0.03441806f, 0.02371859f, -0.03133038f, 
    0.02866574f, 0.02596889f, 0.01533956f, 0.00257946f, 0.01616095f, -0.00602919f, 0.00846958f, -0.03410162f, 
    0.02847496f, -0.00768414f, 0.02332898f, 0.01382159f, 0.01860433f, -0.01224371f, -0.02499434f, 0.00967224f, 
    -0.02394511f, -0.02977607f, 0.01168348f, -0.03998532f, -0.00412386f, -0.01964822f, 0.01777924f, 0.01102602f, 
    0.01953491f, -0.02557528f, -0.02727286f, -0.01523630f, -0.01075466f, -0.00680506f, 0.03295561f, -0.00358904f, 
    -0.01327496f, -0.03707139f, -0.01443446f, -0.02053803f, 0.02339862f, -0.02576774f, -0.01280681f, -0.03107315f, 
    0.01817918f, -0.00920103f, -0.03540464f, -0.03317475f, -0.01240109f, 0.00114615f, -0.04260459f, 0.00085336f, 
    -0.01837690f, 0.01583243f, -0.01513200f, 0.00704774f, -0.00246973f, 0.00675070f, -0.00766280f, -0.00713642f, 
    -0.03134874f, 0.01423323f, -0.01009101f, 0.02929589f, 0.01860522f, -0.01691622f, -0.03736393f, -0.00252325f, 
    -0.02647921f, -0.02269443f, -0.02157187f, -0.00135469f, -0.02189812f, -0.02435350f, -0.00332104f, -0.00254447f, 
    -0.00123191f, -0.00528758f, 0.02224919f, 0.01320904f, 0.01492523f, -0.04127534f, -0.01892857f, -0.00007179f, 
    0.02029864f, -0.03406338f, 0.00728212f, -0.02998088f, -0.00774665f, 0.00885458f, 0.02551273f, 0.00134137f, 
    -0.02373798f, 0.00043594f, 0.03209805f, 0.00498078f, -0.01166737f, -0.00606465f, 0.02777771f, 0.02687464f, 
    -0.03291178f, 0.00944256f, 0.01777328f, -0.01101708f, 0.02416811f, -0.03123650f, 0.00687279f, -0.02032183f, 
    -0.01582913f, -0.02101974f, -0.02142410f, 0.00144287f, 0.02707175f, -0.03941495f, -0.00876281f, 0.01061745f, 
    0.01848065f, 0.01520547f, 0.01018049f, -0.01045191f, -0.02343670f, -0.03046535f, -0.02942985f, 0.02728286f, 
    -0.00570079f, -0.00824075f, 0.00763700f, 0.00170860f, 0.01327813f, 0.00667805f, -0.00385629f, -0.00167879f, 
    -0.02691106f, 0.02880183f, 0.01437635f, -0.00544035f, 0.01645561f, -0.00786254f, -0.01264950f, 0.01826643f, 
    -0.00696892f, 0.01700324f, -0.01464784f, 0.01051611f, -0.00372299f, 0.00488984f, -0.01752306f, 0.02231743f, 
    0.00547827f, -0.02641680f, 0.01775599f, -0.01555170f, -0.03782831f, -0.04146739f, 0.01915865f, 0.02890605f, 
    -0.01900522f, 0.01236712f, 0.02495695f, 0.02202919f, -0.01980716f, 0.01825799f, -0.00933653f, 0.02711927f, 
    -0.02561690f, -0.00467853f, 0.00553632f, -0.00613379f, 0.00190743f, -0.03750330f, 0.00538807f, 0.00247721f, 
    -0.03415119f, 0.00611089f, 0.02270610f, 0.01665399f, -0.00738999f, 0.00158135f, -0.03676263f, -0.00418320f, 
    -0.01260670f, -0.00843813f, 0.03033603f, 0.00790211f, 0.02361620f, -0.00217080f, -0.02875182f, -0.01515158f, 
    -0.02436220f, -0.01837283f, 0.00410358f, -0.02324070f, -0.04064795f, -0.04125926f, 0.01170446f, -0.03798259f, 
    0.00887563f, -0.01237074f, 0.02073479f, -0.00866142f, -0.04303331f, 0.01395151f, 0.02369010f, -0.02674731f, 
    -0.01685686f, -0.03110070f, 0.01782213f, 0.02352083f, 0.01351772f, -0.01671817f, 0.01663151f, -0.02387023f, 
    -0.00893816f, -0.01621380f, 0.01300306f, -0.02929889f, 0.01868308f, -0.00883671f, 0.00716664f, 0.00124589f, 
    -0.00433117f, -0.01390596f, -0.00194938f, -0.04592512f, -0.04624039f, -0.03828608f, -0.02856162f, 0.00916928f, 
    -0.02111143f, -0.00633176f, 0.01799336f, -0.01591683f, -0.03349742f, -0.02322097f, 0.01366331f, 0.00323724f, 
    -0.03448074f, -0.02131810f, 0.02311907f, -0.00113482f, -0.01473727f, 0.01584584f, -0.02153276f, -0.00721958f, 
    0.00366609f, -0.00639684f, 0.00920843f, -0.01710192f, 0.01801468f, -0.00044539f, 0.02602069f, -0.04240852f, 
    -0.03598826f, -0.00528020f, 0.01040465f, 0.00980362f, -0.03101500f, -0.03673217f, 0.01861608f, -0.00759255f, 
    0.00960017f, 0.00974310f, 0.01075062f, -0.00482844f, 0.02078279f, -0.01488748f, 0.00622924f, -0.00922536f, 
    -0.03508431f, 0.01474048f, 0.00981051f, -0.02061392f, -0.01706056f, -0.03994450f, 0.01355577f, -0.03378993f, 
    -0.04536811f, -0.03639461f, 0.00728283f, 0.01291535f, 0.00012582f, 0.01581285f, -0.01195382f, -0.00266172f, 
    -0.04358392f, -0.02993541f, -0.00292115f, -0.02563280f, 0.01991643f, 0.02428604f, -0.04036656f, -0.03406722f, 
    -0.04744580f, -0.02131746f, -0.03591976f, 0.01605450f, 0.00717285f, -0.00888199f, 0.00517315f, 0.01729549f, 
    0.01903183f, 0.01462910f, 0.01175820f, -0.00579373f, 0.00804900f, -0.01843550f, -0.01592934f, -0.03815524f, 
    -0.00590633f, 0.01619502f, -0.03637013f, -0.02732599f, -0.04391587f, 0.00374557f, -0.01592270f, 0.00057074f, 
    -0.01602310f, -0.01392826f, -0.04091842f, 0.01828307f, 0.02013386f, -0.03480820f, -0.02179294f, -0.00154981f, 
    0.01387255f, -0.00403364f, -0.00460512f, -0.01263658f, -0.01952073f, -0.03241789f, 0.01877744f, 0.01415085f, 
    0.00180007f, -0.04132038f, -0.03147784f, 0.00035316f, -0.03108822f, -0.02358744f, -0.03339417f, 0.02427654f, 
    -0.00278627f, 0.02352707f, -0.02351837f, 0.01823626f, 0.02312991f, -0.01794191f, -0.02379826f, 0.03136582f, 
    -0.01944237f, -0.01967672f, -0.02875765f, -0.01263424f, -0.01331799f, 0.00773800f, -0.00940579f, -0.03118780f, 
    -0.04071654f, -0.00128364f, -0.00487682f, 0.03225933f, 0.00025987f, -0.01626797f, -0.03664685f, -0.02409687f, 
    -0.03332438f, 0.03028591f, 0.02680877f, -0.01491225f, -0.01146318f, -0.03759219f, -0.02934374f, 0.01626812f, 
    0.01968528f, -0.01076622f, 0.00809149f, -0.01767087f, 0.01223826f, 0.00977896f, -0.01332966f, -0.01321279f, 
    -0.03548247f, 0.00890537f, -0.02859595f, -0.03059407f, -0.03460376f, 0.00115893f, -0.01994257f, -0.01104845f, 
    0.00028508f, -0.00006007f, 0.00423040f, -0.00067672f, 0.01366595f, 0.02397395f, -0.00594222f, 0.01773038f, 
    0.00159545f, 0.00492008f, -0.00897874f, -0.00279702f, -0.03840822f, 0.02475963f, 0.02581857f, -0.01749796f, 
    -0.01593570f, -0.01092846f, 0.00558315f, -0.04114386f, -0.00137629f, -0.00013266f, 0.01133868f, -0.01592439f, 
    -0.00557515f, -0.00107689f, -0.01461432f, -0.01323972f, -0.02313918f, -0.04062860f, 0.02001454f, 0.00137837f, 
    0.00254277f, 0.01822360f, -0.02072606f, -0.00973016f, 0.02424489f, -0.00049617f, -0.04163795f, -0.02404924f, 
    0.02220771f, 0.00693468f, 0.00459050f, 0.01931733f, 0.02857088f, -0.02521993f, 0.01116604f, -0.03425674f, 
    -0.02833660f, -0.01121662f, 0.00470393f, -0.00664826f, 0.01970899f, 0.02207864f, -0.02065991f, 0.01204207f, 
    0.02029767f, -0.02162839f, 0.02142500f, 0.02978881f, 0.00298627f, -0.02031788f, -0.02468327f, -0.03770189f, 
    -0.03073607f, -0.04146095f, 0.02065916f, 0.02198400f, 0.01521892f, -0.00335767f, -0.04190845f, -0.02018946f, 
    0.01850507f, -0.02167289f, 0.02682696f, 0.01127142f, 0.02838953f, -0.01227814f, -0.00687524f, 0.01536252f, 
    -0.02202612f, 0.02306624f, -0.03667904f, -0.00986047f, 0.00852128f, -0.02838249f, -0.02863502f, -0.02543667f, 
    -0.00173565f, -0.03725303f, -0.02260622f, -0.00772087f, -0.02355594f, 0.00527110f, -0.01506587f, 0.00767392f, 
    -0.02926781f, -0.03349503f, -0.02283888f, 0.01383015f, 0.01425234f, -0.01523737f, -0.02146692f, -0.00623625f, 
    -0.02039177f, 0.00903927f, 0.01531387f, -0.04125763f, -0.02469733f, -0.04109109f, -0.02661770f, 0.00130793f, 
    0.01508904f, -0.01651693f, 0.00501488f, -0.03374064f, -0.02153525f, -0.03183041f, -0.03520965f, 0.02182857f, 
    0.00648277f, 0.00800767f, 0.02985442f, -0.00205081f, 0.00193425f, 0.02590265f, -0.00708747f, -0.02757707f, 
    -0.02758798f, -0.02964397f, -0.04155381f, 0.00566412f, 0.00236028f, -0.02682286f, 0.01882483f, -0.03320372f, 
    -0.00132013f, -0.02130581f, -0.03401956f, -0.01028275f, 0.02090943f, -0.01378545f, 0.01998177f, 0.02041486f, 
    -0.02786777f, -0.03110835f, -0.03808605f, -0.00077498f, -0.00665055f, -0.02547127f, -0.02789169f, -0.03457731f, 
    -0.04168130f, 0.02656394f, -0.03962192f, -0.00523108f, -0.00166290f, 0.02225827f, -0.00954843f, -0.00235606f, 
    -0.01869339f, 0.00082762f, -0.04199470f, -0.01121603f, 0.00029857f, -0.01297906f, 0.00505630f, 0.00981733f, 
    -0.02263682f, 0.01285970f, -0.02043576f, 0.02544773f, -0.03855760f, 0.02290821f, 0.00366361f, -0.04146501f, 
    -0.01813281f, 0.02727460f, -0.03566140f, -0.01997642f, -0.01228109f, -0.03422228f, -0.03622169f, 0.02821329f, 
    0.00997013f, -0.03023045f, -0.01782335f, 0.00794429f, 0.00553492f, 0.01845180f, -0.00742546f, 0.00514478f, 
    -0.01973363f, 0.00847517f, -0.00817534f, 0.00951015f, -0.03692378f, -0.02727421f, -0.01129245f, -0.03884283f, 
    -0.03940425f, 0.01076238f, 0.01568253f, -0.03631920f, -0.03543379f, -0.02516595f, 0.02125257f, -0.01866321f, 
    -0.02311579f, 0.02374184f, -0.03586176f, -0.00942437f, -0.01970752f, -0.02737474f, 0.02919221f, 0.02204308f, 
    0.01051172f, -0.01225570f, 0.00029127f, -0.03121565f, 0.00070227f, 0.01080284f, -0.00627277f, -0.03076170f, 
    -0.00807731f, 0.01138311f, 0.01539787f, 0.00095620f, -0.03083099f, -0.00781070f, -0.02448105f, 0.02340549f, 
    -0.01571630f, 0.02548990f, 0.02969572f, -0.03870447f, 0.00715633f, -0.03956256f, -0.01168172f, 0.01606678f, 
    -0.01192075f, 0.00929508f, -0.03511965f, -0.00777773f, -0.03343086f, 0.02514866f, -0.02561090f, -0.04016518f, 
    0.01251153f, -0.01724170f, 0.00409438f, 0.01555242f, -0.03836296f, -0.02914883f, 0.02657897f, -0.01123019f, 
    -0.01391647f, 0.00043202f, -0.02895204f, -0.01538462f, -0.00395986f, -0.02260758f, -0.00319957f, 0.02396924f, 
    -0.03340054f, -0.01295777f, 0.02096321f, 0.02164481f, -0.03613276f, 0.01301682f, -0.01155267f, -0.02814997f, 
    0.00625500f, -0.01547756f, 0.02683426f, 0.02172196f, 0.00609915f, 0.01209828f, -0.03369273f, -0.04089285f, 
    0.02265707f, -0.01010765f, -0.03778274f, -0.03037947f, 0.01024877f, -0.02798385f, 0.02743778f, -0.01252695f, 
    -0.03073351f, -0.01290648f, 0.00442658f, -0.03266062f, 0.01417985f, -0.04112087f, 0.01496372f, 0.00146407f, 
    0.02037845f, 0.00085553f, -0.01886565f, -0.00664258f, 0.00358256f, -0.04151465f, -0.02167119f, -0.02354011f, 
    0.00999562f, 0.00057204f, -0.03074762f, 0.02524240f, 0.00723031f, 0.01954372f, -0.03494123f, -0.03564860f, 
    -0.00341347f, -0.02576476f, -0.02428310f, -0.01601285f, -0.00482892f, 0.01123103f, 0.01208877f, -0.01106525f, 
    -0.01294598f, 0.01112733f, -0.00305185f, 0.01086253f, 0.01725344f, -0.02440509f, -0.02026456f, -0.00515856f, 
    -0.03980996f, 0.02816035f, -0.02408056f, -0.03030901f, -0.01243340f, -0.01803773f, -0.03247067f, 0.01046440f, 
    0.02508179f, -0.01986559f, 0.00710879f, -0.01064548f, -0.01054505f, 0.00295537f, -0.01797814f, 0.02179236f, 
    -0.02068782f, 0.01409115f, 0.00676754f, -0.01663461f, 0.02184400f, 0.02258787f, -0.03759539f, 0.02768357f, 
    -0.03894130f, 0.02770270f, -0.01818992f, 0.00558203f, -0.00355763f, -0.02945311f, 0.00323928f, -0.01283867f, 
    -0.02284179f, 0.02172142f, -0.00006267f, -0.03163829f, 0.00717971f, -0.03991510f, -0.02875116f, 0.01175903f, 
    -0.02115018f, 0.01145459f, -0.03525693f, -0.04081538f, 0.00047492f, 0.00611062f, -0.03452979f, -0.02792037f, 
    0.01445657f, -0.02973882f, -0.02279086f, 0.00228361f, -0.02247147f, -0.00649330f, -0.03323478f, 0.01865831f, 
    -0.00264099f, 0.02313554f, 0.00670064f, 0.00190155f, 0.00429480f, -0.02421092f, 0.01413697f, -0.01480251f, 
    -0.02475591f, -0.03975407f, -0.02484315f, 0.02901332f, 0.03001610f, -0.03278048f, 0.01611365f, 0.00073013f, 
    0.01897851f, -0.04142456f, 0.01283184f, -0.01771419f, 0.00990754f, -0.01957158f, -0.00354545f, -0.02025584f, 
    0.00640207f, -0.00880803f, -0.03768419f, 0.01946736f, -0.01876049f, -0.01382036f, 0.00627965f, -0.03747300f, 
    0.00068769f, 0.00152815f, 0.01008244f, -0.01202241f, -0.00625854f, -0.02528945f, 0.00440115f, 0.01069253f, 
    -0.00137960f, -0.02329843f, -0.01085972f, -0.03591440f, 0.02659887f, -0.00420832f, 0.01646773f, -0.02163523f, 
    -0.01300515f, -0.01481525f, -0.00197406f, 0.02313752f, -0.00137866f, -0.02668841f, 0.00502754f, -0.03067591f, 
    -0.03645455f, 0.02060318f, 0.01554337f, 0.02441990f, 0.01216529f, 0.02970409f, 0.00791695f, -0.01931584f, 
    -0.03199625f, 0.02863844f, 0.01863881f, 0.00206795f, 0.01470610f, -0.02791571f, -0.02339964f, -0.01849695f, 
    0.01882119f, -0.00497553f, 0.02274719f, -0.04144846f, 0.01590875f, 0.01728347f, 0.00957928f, -0.00271286f, 
    0.00497346f, 0.01738176f, -0.03885402f, -0.02161348f, -0.01178585f, -0.03440201f, 0.02575535f, -0.03296063f, 
    -0.03692242f, 0.00594445f, 0.01473033f, 0.00549986f, -0.03206602f, 0.00712977f, -0.02071751f, -0.01750136f, 
    -0.00176435f, -0.02050284f, 0.00170302f, -0.00486949f, -0.01171809f, 0.02878071f, 0.02902313f, -0.03752349f, 
    0.01445578f, 0.02188226f, -0.01452569f, 0.02767270f, 0.02483007f, 0.01361037f, -0.03142522f, -0.03423807f, 
    -0.02112171f, -0.02675486f, -0.02436016f, -0.03391751f, 0.00062843f, -0.02287794f, -0.01700018f, 0.02954073f, 
    -0.00357345f, 0.00480968f, 0.01216286f, -0.01180387f, 0.00273775f, 0.00461313f, 0.02917803f, 0.00347424f, 
    -0.01744100f, -0.01940167f, 0.01736314f, -0.04052497f, -0.03025125f, -0.00066575f, -0.02262140f, -0.01719737f, 
    -0.03665009f, -0.02452159f, 0.02291414f, 0.00479090f, 0.02083310f, -0.00006372f, -0.00780654f, -0.01709436f, 
    -0.03343055f, -0.01178361f, 0.01174710f, -0.00833429f, 0.01513300f, -0.02523120f, -0.03112824f, -0.00689511f, 
    -0.02180658f, 0.01412795f, -0.03778232f, 0.02639665f, -0.02929698f, -0.02635515f, 0.01117019f, 0.02196949f, 
    0.00735549f, 0.00024650f, 0.01138912f, -0.02785670f, 0.00058173f, -0.02294918f, 0.02261208f, -0.01835722f, 
    -0.02513652f, 0.00258699f, -0.02982109f, -0.04009506f, 0.02829822f, -0.03767923f, 0.01716944f, 0.00760736f, 
    -0.00059327f, -0.01625935f, 0.01271912f, 0.01926692f, -0.02959861f, -0.01113783f, -0.02822719f, -0.02037167f, 
    -0.02610072f, -0.00018862f, -0.03290203f, -0.00581704f, 0.00541839f, -0.01321270f, 0.01594046f, -0.04023699f, 
    -0.02301075f, 0.02437326f, -0.00819476f, -0.03706720f, -0.00433901f, -0.01661634f, 0.01524891f, 0.02666101f, 
    0.01559206f, 0.00086218f, -0.00061573f, -0.02224207f, -0.03999362f, -0.03117082f, 0.02277171f, -0.00010519f, 
    -0.01240349f, -0.02060760f, 0.02121275f, 0.02220646f, 0.02506605f, -0.04131834f, -0.01173009f, -0.03688536f, 
    -0.03477302f, 0.01421532f, -0.02230011f, -0.02599138f, -0.01011039f, -0.00095924f, -0.01006185f, -0.01752369f, 
    -0.00291185f, 0.00297156f, 0.02460456f, -0.03745586f, 0.02778281f, -0.04181601f, 0.01982323f, -0.04061640f, 
    0.02017932f, 0.00460844f, -0.00265186f, 0.02591490f, -0.00536468f, 0.02119236f, 0.01314869f, 0.02460365f, 
    0.01676892f, 0.01675549f, -0.00407904f, 0.01704085f, -0.00410214f, 0.02319681f, -0.03943583f, 0.01390537f, 
    -0.02161071f, -0.01752476f, 0.02645766f, -0.02964463f, 0.00648599f, 0.01264843f, -0.01012195f, -0.03695075f, 
    -0.00143155f, -0.01310701f, 0.01962346f, -0.00261031f, -0.00469601f, -0.01856654f, -0.00786327f, -0.01952486f, 
    -0.00148744f, -0.01345746f, -0.00452559f, -0.02622646f, 0.00598188f, -0.01077306f, -0.02494929f, -0.01112895f, 
    0.02699640f, -0.04049093f, 0.00745745f, -0.03211047f, 0.01314644f, 0.00556433f, 0.01018945f, -0.03399080f, 
    -0.03345999f, -0.02728494f, 0.02399852f, -0.03542858f, 0.02425692f, 0.01222328f, -0.00894318f, -0.01471918f, 
    0.02854864f, -0.00706276f, -0.02428957f, -0.03624363f, 0.01857582f, -0.03550902f, -0.00750118f, -0.01868812f, 
    0.01771463f, 0.01401747f, -0.00827736f, 0.00375832f, 0.01526940f, 0.02923299f, -0.03896801f, 0.01452107f, 
    -0.01689665f, -0.01567457f, -0.00153198f, -0.02478856f, 0.01489008f, -0.00718679f, -0.00155045f, -0.01064172f, 
    -0.00086669f, 0.00164912f, -0.01237064f, -0.01665461f, 0.00884216f, 0.01780399f, 0.00309445f, -0.02556326f, 
    -0.01747371f, 0.02593727f, 0.01060253f, -0.01722374f, 0.02574683f, -0.01149766f, -0.01700213f, -0.00485011f, 
    0.00318568f, -0.00957409f, -0.03388508f, 0.00879330f, 0.02278703f, -0.02152232f, 0.00089604f, -0.04102597f, 
    -0.03940422f, -0.00365050f, 0.00930372f, -0.00540638f, 0.01678360f, -0.03750640f, -0.02796233f, -0.00062564f, 
    0.02518254f, 0.00050443f, 0.03004435f, 0.02051941f, -0.03858684f, 0.00082384f, 0.00691544f, -0.04131751f, 
    -0.02402512f, -0.02485013f, 0.02501732f, -0.04099162f, -0.03699120f, -0.00627787f, 0.01253340f, -0.00057472f, 
    -0.02015771f, 0.01398378f, -0.01826777f, -0.00754285f, 0.00329199f, -0.00424473f, -0.00809789f, -0.00714213f, 
    -0.00248012f, -0.01861122f, 0.01201487f, -0.01340465f, 0.02990391f, -0.02567957f, -0.01256094f, 0.01395717f, 
    -0.00635485f, -0.02438905f, -0.00145480f, -0.00626019f, -0.04186336f, -0.03242004f, 0.01462116f, 0.02110289f, 
    0.01139702f, -0.00944144f, 0.03570447f, -0.00699649f, -0.01226584f, -0.02397861f, -0.02680248f, -0.03959245f, 
    -0.02548882f, 0.01022174f, -0.01639236f, -0.00310964f, 0.00366237f, -0.01086527f, -0.00640125f, 0.02264423f, 
    -0.01847462f, -0.03757532f, -0.01445210f, -0.02291896f, -0.03026276f, -0.00676252f, -0.03323318f, 0.02253761f, 
    -0.00803255f, -0.03764903f, 0.00687518f, -0.02565831f, -0.04334538f, 0.01413984f, -0.02763972f, -0.04121225f, 
    -0.02102703f, 0.00230783f, -0.00933793f, 0.00465900f, 0.01003222f, 0.02375551f, 0.02593392f, 0.00467150f, 
    -0.02287265f, 0.02668397f, -0.02936354f, 0.02307852f, -0.01492460f, 0.02185388f, -0.03192274f, 0.02730001f, 
    -0.02472739f, 0.02284912f, -0.00402141f, -0.00231175f, -0.02485429f, 0.02188597f, -0.00637162f, 0.02532237f, 
    -0.01564376f, -0.03857390f, -0.02519158f, -0.00089381f, -0.02467284f, 0.00571317f, -0.01313403f, -0.02802896f, 
    -0.02017692f, 0.02123176f, -0.01724740f, -0.04060214f, -0.02774037f, 0.00808665f, -0.00574785f, -0.01589840f, 
    0.00607897f, -0.01148368f, 0.02161784f, 0.02869581f, 0.02391494f, 0.01762977f, -0.02391940f, -0.01399990f, 
    -0.03401860f, -0.03031506f, -0.00419633f, -0.00717361f, 0.01289612f, 0.01682623f, 0.02434652f, 0.02990740f, 
    0.01539526f, -0.00458337f, 0.00148145f, 0.02538972f, 0.01542554f, -0.00690818f, -0.01690319f, 0.00752272f, 
    -0.01852575f, 0.00871634f, -0.01187460f, -0.02207284f, 0.00561925f, 0.02463650f, 0.01555713f, 0.01902099f, 
    -0.01149169f, -0.03140176f, 0.02631751f, -0.03472582f, -0.03777796f, -0.01206730f, -0.00332118f, -0.03219724f, 
    -0.01028296f, 0.00570428f, -0.03550440f, 0.00127208f, 0.02921079f, 0.00455206f, -0.03468496f, 0.01708193f, 
    0.02335550f, 0.02727057f, 0.00954391f, -0.01767977f, 0.01221373f, -0.01630865f, -0.00589275f, 0.02833553f, 
    -0.01353766f, -0.03065771f, 0.00894865f, 0.00136088f, 0.02522161f, -0.02467928f, 0.01109979f, -0.04072161f, 
    -0.00718805f, 0.01121983f, -0.03217068f, 0.04137249f, 0.00007691f, -0.02626114f, -0.01371548f, -0.00187188f, 
    0.02175415f, -0.02641646f, 0.01248737f, -0.01868487f, -0.02918366f, -0.03374842f, 0.02694618f, 0.01980449f, 
    -0.03841283f, -0.01819203f, -0.01892866f, -0.02284750f, 0.02579635f, 0.02978745f, -0.00874452f, 0.00283030f, 
    -0.01128388f, 0.01510075f, -0.00230205f, -0.00425806f, 0.01657273f, -0.03095130f, 0.02061097f, 0.02004623f, 
    -0.03011385f, -0.02345989f, -0.02458964f, -0.01336665f, -0.01396863f, -0.03183506f, -0.00072737f, 0.02069847f, 
    -0.02475155f, 0.02103821f, -0.02086374f, -0.01400018f, 0.02122228f, -0.01567116f, -0.01641446f, 0.01649702f, 
    -0.00160335f, -0.03629631f, -0.01384009f, -0.01024865f, 0.02141867f, -0.00864536f, 0.01819726f, 0.02615493f, 
    0.02029670f, -0.00366870f, -0.03433577f, -0.01856896f, 0.00545753f, 0.00589053f, -0.02779823f, 0.01331982f, 
    -0.01676579f, 0.00438008f, 0.01652403f, -0.03460460f, 0.02750795f, 0.00027261f, -0.04410335f, -0.03688751f, 
    -0.03702214f, -0.01618737f, -0.02030676f, -0.01706346f, -0.01741556f, 0.02782772f, -0.01661079f, -0.02433163f, 
    -0.01941171f, -0.04305831f, 0.00029022f, 0.00023840f, 0.02114030f, 0.02874864f, -0.02801777f, -0.02073510f, 
    -0.02954155f, 0.00090320f, -0.02435550f, -0.02217755f, 0.02009320f, 0.01897400f, -0.01565252f, -0.00756205f, 
    0.02082613f, -0.03401230f, -0.01007816f, -0.00321508f, -0.00006856f, -0.02986776f, -0.01831342f, 0.01091570f, 
    -0.00797118f, -0.02017486f, -0.03574851f, 0.03371998f, -0.00425440f, -0.03565303f, -0.01082752f, -0.01622787f, 
    -0.04215119f, -0.02677145f, 0.00691472f, -0.03678935f, -0.02455728f, -0.01360108f, 0.00169530f, 0.01754143f, 
    -0.01458529f, 0.01151732f, -0.01115812f, -0.02965110f, -0.03593247f, -0.02452654f, 0.02202023f, -0.02389432f, 
    -0.02867338f, -0.00811298f, -0.01426116f, -0.01590192f, 0.02673100f, 0.02595391f, 0.02528764f, 0.02155710f, 
    -0.01855215f, 0.01752690f, -0.02147369f, 0.01413275f, -0.00289319f, 0.02360135f, -0.02320988f, 0.01114957f, 
    0.02640659f, 0.01684180f, -0.03104145f, 0.00530661f, -0.02787321f, -0.03603392f, 0.01935643f, -0.04015649f, 
    -0.00955589f, -0.01120152f, -0.00670261f, -0.02281893f, 0.02889165f, 0.00800681f, -0.02412111f, -0.00199808f, 
    -0.04472599f, -0.00304029f, 0.01186373f, -0.03003423f, -0.03129117f, -0.01135308f, 0.00348139f, 0.00754815f, 
    0.01692164f, 0.03161752f, -0.03293503f, -0.03718511f, -0.03449699f, 0.02097689f, 0.01980942f, 0.00809958f, 
    -0.01540335f, -0.03134963f, 0.00119901f, 0.01472226f, 0.01008272f, -0.03198922f, -0.04109262f, -0.02516226f, 
    0.00375765f, -0.02822392f, -0.01784823f, -0.01753375f, 0.03394382f, 0.00138496f, -0.01991370f, -0.03252551f, 
    -0.02083527f, 0.00338191f, -0.01636018f, -0.03144786f, -0.00932326f, 0.02165070f, -0.03744435f, -0.02709671f, 
    -0.00090522f, 0.01298356f, -0.00498688f, 0.00308176f, 0.00118020f, 0.02561915f, 0.01461883f, -0.03470637f, 
    -0.03118347f, 0.02806389f, -0.02260303f, 0.02448725f, 0.01660024f, 0.01042158f, -0.01592112f, -0.00736225f, 
    -0.01429914f, 0.02303549f, -0.01145917f, 0.01093952f, -0.04070818f, -0.00474787f, 0.01147994f, 0.02512544f, 
    0.02131384f, 0.00897857f, -0.01113869f, -0.03417728f, -0.02322274f, -0.03042644f, 0.01706344f, 0.02085620f, 
    0.01195205f, -0.01324689f, -0.02565763f, 0.01254482f, -0.00629091f, -0.03259943f, -0.00096500f, -0.00971230f, 
    0.00576587f, 0.02356672f, -0.04058390f, -0.00524155f, -0.00563689f, -0.02707920f, 0.00866630f, 0.01193113f, 
    -0.00726246f, -0.01376661f, -0.04222791f, 0.03516570f, 0.00178891f, -0.02796225f, -0.03783771f, -0.01298883f, 
    0.01615258f, -0.01950582f, -0.03164246f, 0.02589999f, -0.00718509f, -0.01883253f, 0.03363114f, -0.04482617f, 
    0.02210913f, 0.01601719f, 0.00169074f, -0.01907745f, 0.03045470f, 0.02740155f, 0.00453573f, -0.00581196f, 
    0.00276333f, 0.02407763f, -0.00903219f, 0.02151443f, 0.01151489f, -0.00386374f, 0.01448384f, -0.00532585f, 
    0.02811067f, 0.00686268f, -0.01370877f, -0.02773767f, 0.01656071f, -0.03725041f, -0.02971511f, -0.00279505f, 
    -0.01095058f, -0.00684739f, -0.03220942f, -0.00267903f, 0.02537171f, -0.03094253f, -0.04543714f, 0.01394559f, 
    0.00240511f, 0.00697486f, -0.02443111f, -0.00840573f, -0.02330084f, 0.03412918f, 0.02301815f, 0.02441863f, 
    -0.02568482f, -0.00437739f, 0.01497414f, 0.00441940f, -0.03883264f, 0.01630894f, 0.02274417f, -0.01569728f, 
    -0.00453264f, 0.02375069f, 0.02443021f, 0.02315738f, -0.03522801f, 0.03020124f, -0.03497492f, -0.02505306f, 
    0.01941613f, 0.02534775f, -0.01772915f, -0.02288100f, -0.04202949f, -0.03355024f, 0.02706097f, -0.04046279f, 
    0.00342443f, 0.01748723f, -0.01979672f, -0.03652001f, -0.00262066f, 0.02756435f, -0.00216096f, 0.01318727f, 
    -0.01728314f, -0.02670776f, -0.01763472f, 0.01087819f, -0.01956297f, 0.03353977f, 0.01962877f, 0.01181531f, 
    0.01842374f, 0.00623084f, -0.00517317f, -0.03483866f, 0.02761737f, 0.02343431f, -0.00643467f, -0.03430304f, 
    -0.02227750f, -0.00649148f, 0.01149561f, -0.01397996f, 0.01274216f, -0.02256114f, -0.03928946f, 0.02216040f, 
    0.02028337f, -0.01529896f, 0.02927271f, -0.00914111f, 0.00857378f, -0.00717242f, -0.03126593f, -0.02263175f, 
    0.01367406f, -0.03569546f, 0.00652185f, 0.01952855f, -0.01179000f, -0.01216158f, 0.02455969f, -0.03320077f, 
    0.02214914f, -0.02730149f, -0.03708642f, 0.00953191f, 0.02887782f, -0.02743983f, -0.01826350f, -0.02870960f, 
    -0.00917178f, -0.02516140f, -0.02191208f, 0.01558054f, -0.01066770f, -0.03774041f, -0.02631860f, -0.02725245f, 
    -0.03576482f, -0.00089477f, 0.00735874f, 0.01058584f, -0.00175210f, -0.03829041f, -0.02609525f, 0.03434188f, 
    0.02582864f, -0.01195444f, -0.01371559f, 0.01035543f, -0.01043218f, -0.03796230f, 0.00627962f, -0.01688617f, 
    -0.00810082f, -0.00527054f, -0.03448553f, -0.02103042f, -0.02958240f, -0.02018014f, -0.02344149f, 0.02909366f, 
    -0.01028225f, -0.01123891f, 0.02820909f, 0.02964809f, 0.01836667f, 0.00947370f, 0.02327272f, 0.01477592f, 
    -0.01726872f, 0.00801232f, -0.02859523f, 0.00228554f, -0.01043794f, 0.00239728f, 0.00611689f, 0.02609826f, 
    0.01278661f, -0.00869755f, 0.01147388f, 0.02527808f, -0.01836330f, -0.02893827f, 0.02103161f, 0.02272940f, 
    -0.00743401f, 0.02382993f, 0.00373938f, 0.03358698f, -0.02237311f, -0.02984358f, 0.00409992f, 0.02486527f, 
    -0.00185760f, 0.01290211f, 0.01282564f, -0.01086052f, -0.01304367f, -0.00655223f, -0.00479735f, 0.00248811f, 
    0.02934956f, 0.00510022f, -0.01059854f, -0.03793964f, -0.00287138f, 0.00706708f, -0.02123258f, -0.03158471f, 
    0.01015023f, -0.02228340f, -0.01838936f, 0.02386736f, -0.01938989f, 0.01349857f, 0.00482270f, -0.02150253f, 
    0.01907130f, -0.02585798f, 0.02535024f, -0.03560163f, 0.03367428f, -0.01525992f, -0.01289462f, 0.01257392f, 
    0.00847268f, 0.02552324f, 0.00908340f, -0.00664117f, -0.04063403f, -0.03013389f, -0.01618773f, 0.00057899f, 
    0.03298492f, 0.01022357f, 0.02617494f, -0.01683651f, -0.03762443f, -0.02185215f, -0.02280721f, 0.00826212f, 
    0.02202769f, -0.02820349f, 0.01928992f, 0.00393386f, 0.01069493f, 0.01269758f, -0.03078684f, -0.00184568f, 
    -0.02631241f, 0.00420499f, -0.03300170f, 0.02874129f, 0.00436675f, 0.01922060f, 0.00249842f, -0.00876679f, 
    0.02272635f, 0.01571593f, -0.00692657f, -0.03356796f, -0.03007877f, -0.01032771f, -0.01807335f, -0.04023892f, 
    0.01244250f, -0.01797934f, 0.02802545f, -0.01698514f, -0.03348235f, 0.02562821f, 0.02007557f, -0.00536898f, 
    -0.01001452f, 0.01289944f, 0.00080150f, -0.00858376f, 0.01311166f, -0.01364418f, -0.00066597f, -0.01871486f, 
    0.02121289f, 0.02531233f, 0.00591846f, -0.02625688f, 0.00829942f, 0.00502931f, -0.03911649f, -0.00106781f, 
    -0.00695802f, -0.01038708f, -0.03813818f, 0.01760962f, -0.00349544f, 0.00054500f, -0.00164361f, 0.01772017f, 
    0.01408827f, 0.02353087f, -0.00164399f, 0.00760108f, -0.00208411f, -0.00355017f, 0.02313352f, 0.02979616f, 
    -0.01545623f, 0.01847070f, -0.02578480f, -0.03351671f, -0.02183263f, -0.04222770f, -0.01002544f, 0.02019384f, 
    -0.02635007f, -0.02697757f, -0.01456120f, -0.00449355f, 0.01806542f, -0.00329153f, -0.00947410f, -0.01405885f, 
    -0.01572778f, 0.00220122f, 0.00863740f, 0.00554495f, -0.01403461f, -0.02896251f, 0.02551846f, 0.01949615f, 
    0.02417169f, -0.01609641f, -0.03284138f, 0.01619471f, 0.00559397f, 0.02735605f, -0.00128949f, -0.04066725f, 
    0.01921932f, -0.01574472f, -0.03866711f, -0.03019610f, 0.01179119f, -0.01126559f, 0.02328479f, 0.00431958f, 
    0.02566839f, -0.01131329f, -0.02231846f, -0.00129847f, 0.02569300f, 0.00282173f, -0.02778253f, -0.03311952f, 
    -0.03232747f, -0.02908420f, 0.00941829f, -0.01016468f, 0.01248500f, 0.00920055f, -0.00973024f, -0.03964072f, 
    0.00988845f, 0.00748773f, -0.00824406f, -0.00657458f, -0.01158426f, 0.02012183f, 0.00260652f, 0.00186090f, 
    0.01193282f, 0.02401024f, 0.00264045f, 0.02215729f, 0.01588092f, -0.02620744f, 0.00564136f, 0.00172934f, 
    0.07989763f, 0.03796627f, 0.11329462f, 0.02313027f, 0.06943398f, 0.06395514f, 0.04355571f, 0.15183279f, 
    -0.00287933f, 0.13009571f, -0.09167942f, -0.01074137f, 0.14641678f, 0.23468611f, 0.14734362f, 0.05431765f, 
    -0.05118198f, -0.04999654f, 0.09153710f, -0.02759539f, 0.02048419f, 0.00426358f, -0.05458925f, -0.06220004f, 
    0.28580424f, -0.20450988f, 0.14429566f, -0.07241772f, -0.04514252f, 0.01002967f, 0.01971160f, -0.01338014f, 
    0.10011125f, -0.09992101f, -0.00078741f, 0.05890981f, 0.40699029f, 0.05295572f, -0.02248671f, -0.09224105f, 
    -0.01754858f, 0.07409783f, 0.07957815f, 0.03275087f, 0.09453844f, 0.06994864f, -0.07235708f, 0.08463404f, 
    0.15381110f, -0.04015735f, 0.09659880f, 0.06289609f, -0.05620518f, -0.10755850f, 0.07778151f, -0.14523821f, 
    0.11786408f, 0.03858880f, -0.01685011f, 0.10062277f, -0.12063555f, 0.07303245f, 0.10303538f, 0.19952925f, 
    0.08633127f, 0.03236231f, 0.14496022f, -0.00214961f, -0.01801283f, 0.08782592f, -0.07500416f, -0.07866088f, 
    -0.31055790f, 0.17823088f, 0.04509514f, 0.05220654f, -0.05677290f, 0.05367573f, 0.04163338f, 0.13591482f, 
    -0.04181030f, 0.06495821f, 0.10880590f, 0.03201250f, 0.12522738f, -0.30757031f, -0.00616137f, 0.02244089f, 
    0.01217197f, 0.00692819f, -0.03600677f, -0.12419102f, -0.16009712f, 0.02300944f, -0.09418370f, -0.20229524f, 
    0.44814801f, -0.01273815f, 0.11045372f, -0.07312969f, -0.02576359f, 0.00008398f, 0.17910595f, -0.08155525f, 
    0.03986070f, -0.08393563f, 0.12905900f, 0.06104342f, 0.04458803f, 0.10081337f, 0.07334270f, 0.18997505f, 
    -0.01243245f, -0.02777237f, 0.00647225f, -0.03205703f, 0.08820256f, -0.05532484f, -0.00601981f, 0.05613166f, 
    0.43047577f, -0.23323488f, -0.24055836f, 0.11711895f, 0.00527941f, 0.05110015f, 0.06196447f, 0.06171260f, 
    -0.01941051f, -0.04141449f, 0.06223374f, 0.05548543f, 0.11926039f, 0.10937874f, 0.07504057f, -0.05624779f, 
    -0.13133918f, -0.07408982f, 0.02330957f, -0.03171916f, -0.04957785f, -0.07537948f, -0.02645517f, -0.08455942f, 
    -0.08823412f, 0.06610942f, 0.09882651f, 0.09768555f, 0.00497936f, 0.01870898f, 0.01343657f, -0.04536899f, 
    -0.01806915f, -0.03572340f, 0.11307179f, 0.04038874f, -0.06984223f, 0.01667404f, 0.04893123f, 0.09065981f, 
    0.12862834f, 0.05899311f, 0.05676258f, 0.12743917f, 0.02158082f, 0.09586689f, 0.10274509f, 0.01570393f, 
    0.07787870f, 0.04583307f, 0.00111582f, 0.05077575f, -0.03622466f, 0.02472732f, -0.05326993f, -0.03454801f, 
    -0.07696890f, 0.06227706f, 0.01155474f, 0.07062595f, 0.18911885f, -0.01254550f, -0.06182777f, 0.03993697f, 
    -0.08275405f, -0.07533459f, -0.06116303f, -0.03951396f, 0.05161829f, 0.06758754f, 0.07145888f, 0.12244211f, 
    -0.09237680f, 0.09802625f, 0.05770256f, 0.12354523f, -0.10507620f, -0.02809003f, 0.01668916f, 0.10474224f, 
    -0.09248956f, 0.04920581f, 0.06772980f, -0.00717067f, 0.20492636f, -0.33371851f, -0.01929580f, -0.18573332f, 
    -0.09002252f, -0.05009297f, 0.01031243f, 0.05813225f, -0.05809473f, -0.03368830f, -0.08049411f, 0.07207596f, 
    -0.02253284f, 0.05804109f, 0.09671921f, 0.06896500f, 0.15872668f, -0.02288890f, -0.04943705f, -0.10165050f, 
    -0.07837927f, 0.02632022f, -0.06237032f, 0.22940321f, 0.14352439f, -0.36873686f, 0.16604209f, -0.01554857f, 
    0.02630121f, 0.06899887f, 0.08599120f, 0.01150473f, 0.06325459f, 0.06308379f, 0.18089740f, 0.10137537f, 
    -0.01183938f, -0.14465255f, 0.02137133f, 0.07790620f, -0.05645740f, -0.00204387f, 0.05941573f, 0.01680460f, 
    0.06554509f, 0.05548881f, 0.12262424f, 0.02751733f, -0.02042740f, 0.12056783f, -0.14094180f, 0.29622772f, 
    -0.02274349f, 0.09539798f, 0.02671335f, 0.13849728f, 0.12435194f, 0.21749534f, -0.01338413f, 0.02621531f, 
    -0.18857437f, -0.08487578f, -0.08412924f, -0.02455782f, 0.13804093f, -0.03502319f, 0.09737790f, -0.00286403f, 
    -0.03760380f, 0.01069748f, -0.03421019f, 0.01852863f, 0.48413363f, -0.26743394f, 0.15449861f, -0.11247285f, 
    -0.05971199f, -0.06325343f, 0.03089341f, -0.09429031f, -0.02550952f, -0.06906177f, 0.06980279f, 0.06231194f, 
    -0.14495844f, 0.05741421f, 0.09029190f, -0.05100778f, -0.13569176f, -0.06254750f, -0.04575089f, 0.01782034f, 
    -0.05071403f, 0.07067703f, 0.07729305f, 0.02060045f, 0.26405150f, -0.03639066f, -0.26214498f, 0.32924050f, 
    -0.01988745f, 0.05068791f, 0.17609587f, -0.06817263f, -0.01985805f, 0.10796709f, 0.01231257f, 0.10200290f, 
    0.04811520f, -0.10892012f, -0.05806503f, 0.06949508f, -0.13570157f, 0.07960440f, 0.02372120f, -0.02968501f, 
    0.11251727f, 0.12089131f, -0.03490759f, 0.18500529f, 0.16988230f, -0.08714759f, 0.18040651f, 0.05156668f, 
    -0.22146116f, 0.04059356f, 0.01887520f, 0.01582240f, -0.10263707f, -0.08428044f, 0.02165995f, -0.06474501f, 
    -0.04958937f, -0.17973438f, 0.13724016f, -0.02443705f, 0.07661444f, -0.00100083f, 0.04939798f, 0.00549682f, 
    -0.04727076f, 0.07351424f, -0.03712878f, -0.00962415f, -0.26975119f, -0.02570630f, 0.19507001f, 0.17456761f, 
    -0.02544844f, 0.12211695f, -0.10736469f, -0.03466033f, -0.06384865f, 0.08271874f, -0.07455529f, -0.16389920f, 
    -0.28783703f, -0.04923708f, -0.10586444f, 0.03127579f, -0.04223447f, -0.01076379f, 0.01279235f, 0.04250360f, 
    0.03243864f, 0.04420049f, -0.05259254f, -0.00564279f, 0.02414435f, 0.21360588f, -0.20635381f, 0.07291457f, 
    0.05412835f, 0.00069081f, -0.01205395f, -0.07911100f, 0.01804945f, -0.06446820f, 0.08755135f, -0.08693825f, 
    -0.02231577f, 0.07389465f, 0.20399794f, -0.06372625f, -0.13037297f, 0.00092619f, -0.03165576f, 0.06040079f, 
    -0.15401474f, -0.08286478f, 0.06351212f, -0.02776033f, 0.17932263f, 0.25166649f, 0.13630673f, -0.24489352f, 
    0.05296033f, -0.06328907f, -0.01307148f, -0.08261614f, -0.07455499f, 0.12383860f, -0.01611568f, 0.02099863f, 
    -0.23814397f, -0.02634531f, 0.05998842f, 0.10501797f, 0.00094016f, 0.07530235f, 0.00075853f, 0.01126307f, 
    -0.04529482f, 0.12386034f, 0.04728498f, 0.20163013f, -0.22625770f, 0.17762291f, -0.05250052f, 0.06901484f, 
    -0.12970489f, -0.05092350f, 0.00578605f, 0.06813931f, 0.02231583f, 0.05218891f, 0.04646371f, -0.09365662f, 
    -0.15010986f, 0.04245945f, -0.17599261f, 0.18154518f, 0.14064762f, 0.00204734f, 0.02050537f, -0.02061774f, 
    0.06873722f, -0.07552312f, 0.00047012f, -0.09436749f, -0.04459766f, -0.11769262f, -0.00974599f, 0.04470253f, 
    -0.09154700f, 0.05506441f, -0.04721249f, 0.11199209f, -0.01664790f, 0.07880163f, 0.08565246f, 0.08450375f, 
    0.04036899f, 0.01179155f, 0.12264764f, 0.02978050f, 0.07166715f, -0.06098199f, 0.04059424f, 0.04592308f, 
    0.01883666f, 0.04031130f, 0.10292479f, 0.16810952f, 0.18011685f, 0.36670497f, -0.03644694f, -0.10015842f, 
    -0.17236796f, -0.07850598f, 0.03943844f, 0.07624196f, -0.07272699f, 0.02397682f, -0.03954954f, 0.10762026f, 
    -0.18354362f, 0.06673115f, 0.04666417f, -0.15513374f, -0.17720824f, -0.04974031f, 0.04111111f, 0.02567498f, 
    0.07953717f, 0.10423438f, 0.06316833f, 0.09388079f, 0.22569017f, 0.11754499f, -0.23489201f, 0.07895815f, 
    -0.03762067f, -0.06055225f, 0.04689321f, 0.01025101f, -0.00698573f, 0.00747339f, -0.09358811f, -0.01681355f, 
    -0.09602854f, -0.18034585f, -0.11439419f, -0.04645340f, 0.08642916f, 0.15198056f, 0.00632500f, -0.05374896f, 
    -0.02652353f, 0.03728955f, -0.07706878f, 0.09530215f, 0.27935490f, -0.16137083f, -0.08142025f, -0.17167060f, 
    -0.06467569f, -0.06672589f, 0.03172745f, 0.01566307f, -0.02524265f, 0.16235875f, -0.06126000f, 0.01281346f, 
    0.11584675f, -0.00521608f, -0.06620181f, -0.04329795f, -0.13582051f, -0.03293464f, 0.03641142f, -0.03398357f, 
    0.10625080f, -0.12682760f, 0.04568929f, -0.12461727f, 0.07674936f, -0.09975556f, -0.18898974f, 0.02701861f, 
    0.06130522f, 0.00220289f, -0.08763896f, 0.07868184f, 0.04617456f, 0.10902626f, -0.14141893f, -0.05045437f, 
    -0.11777031f, 0.12404187f, -0.08739581f, 0.00055131f, 0.01204432f, 0.06943524f, -0.11719833f, 0.02419048f, 
    -0.01880918f, -0.10615823f, 0.05180357f, 0.12900117f, 0.16667435f, 0.01328654f, 0.04983325f, 0.10102777f, 
    -0.10301317f, -0.08249371f, -0.09957421f, -0.03315308f, -0.05484683f, -0.16397825f, -0.03003062f, -0.02271485f, 
    -0.01331697f, -0.18222396f, 0.07151809f, -0.09168843f, -0.02978609f, -0.03306386f, 0.04986545f, -0.04718976f, 
    -0.05653899f, 0.06922008f, -0.00327259f, 0.12831193f, 0.03141526f, -0.03936842f, 0.08885965f, -0.00795821f, 
    0.00392601f, 0.17451650f, 0.03142850f, 0.01386982f, -0.11509752f, -0.06439745f, 0.06171823f, 0.08651654f, 
    0.21148869f, 0.10585085f, 0.11040293f, -0.16447276f, -0.02200752f, -0.07068902f, -0.04163329f, 0.08118142f, 
    -0.02156473f, -0.04723070f, 0.03023393f, 0.14113940f, 0.26990464f, 0.03966246f, -0.16650443f, 0.04480480f, 
    0.00674825f, -0.05661332f, 0.01235335f, 0.01247930f, 0.03851075f, -0.01818705f, 0.01076591f, -0.03248204f, 
    0.09166902f, 0.02907963f, 0.04071068f, -0.06527631f, -0.04762509f, 0.06236552f, -0.08201677f, 0.03993760f, 
    -0.15511523f, 0.11667337f, 0.00602432f, 0.16461457f, 0.03107773f, 0.03343779f, 0.15771762f, -0.02784189f, 
    -0.04853506f, 0.06707586f, -0.03986658f, -0.03366391f, 0.07853426f, -0.10473379f, -0.05199747f, 0.07088853f, 
    -0.03146248f, 0.14986028f, 0.19752054f, -0.01588447f, 0.05822947f, 0.01481762f, 0.01772196f, -0.03612504f, 
    0.09168006f, -0.11901506f, -0.01071482f, -0.05560496f, 0.15036322f, 0.22095670f, -0.19154182f, -0.00686678f, 
    -0.06577428f, 0.04240979f, -0.17677647f, -0.06875130f, -0.03803666f, 0.04107362f, -0.08651254f, -0.02007556f, 
    0.31079850f, -0.10213234f, 0.01216044f, -0.21709153f, 0.07559265f, -0.06602577f, -0.03599749f, 0.08182925f, 
    -0.01997471f, -0.07582127f, 0.18684541f, -0.13723499f, 0.16809599f, -0.19808388f, 0.02735777f, -0.06497019f, 
    -0.04892623f, 0.09724556f, 0.08692959f, -0.03462042f, 0.01441641f, -0.03676863f, -0.09107798f, -0.10430892f, 
    0.48715928f, 0.04113864f, 0.18959008f, -0.09803669f, -0.01359884f, 0.01004754f, -0.09179533f, 0.05055279f, 
    0.15847285f, 0.01212770f, -0.02031374f, 0.10050642f, 0.22552535f, -0.11173584f, 0.01858899f, -0.01227443f, 
    0.06193125f, 0.10436571f, 0.02343442f, 0.02060727f, 0.03686652f, -0.06731731f, -0.17124014f, -0.04673401f, 
    0.18270773f, 0.09450149f, -0.00208756f, -0.01923250f, 0.02862921f, 0.08190563f, 0.06694294f, -0.04280897f, 
    -0.01817323f, -0.12875235f, 0.00769474f, -0.21101137f, -0.41621372f, 0.16187192f, -0.02725873f, 0.10590331f, 
    0.20956595f, 0.00409840f, -0.01110107f, -0.09128431f, -0.00532382f, -0.10675675f, -0.12917495f, -0.07535640f, 
    0.28518432f, -0.12569666f, 0.05857574f, -0.08554862f, -0.13783903f, -0.06419601f, -0.06311090f, 0.02141822f, 
    -0.00654036f, -0.02345377f, -0.06118675f, 0.08174670f, -0.10877316f, -0.09012251f, 0.17972174f, 0.06350345f, 
    0.11127260f, 0.11508771f, -0.02853015f, -0.02035137f, 0.11161301f, -0.01764059f, -0.13289258f, -0.11291875f, 
    -0.03741247f, -0.02758972f, -0.03111803f, 0.01849294f, -0.03634870f, 0.00454640f, -0.04173627f, 0.01935972f, 
    -0.01476098f, 0.00105512f, -0.01783001f, -0.00889301f, -0.00159345f, -0.02458559f, 0.04144721f, -0.02612376f, 
    -0.02414550f, 0.03901811f, 0.00791025f, -0.00315380f, -0.03348680f, 0.03007286f, 0.03120800f, 0.03597148f, 
    -0.00751000f, -0.01940569f, -0.01954389f, -0.02121607f, -0.02035450f, 0.01208425f, -0.03599543f, -0.03200681f, 
    0.01270215f, -0.01273990f, -0.03549825f, -0.03085877f, 0.00498658f, -0.02869049f, 0.01145868f, 0.00156966f, 
    0.01295904f, 0.02010543f, -0.03757738f, 0.01426246f, -0.03399637f, -0.01705461f, -0.01291775f, -0.03251504f, 
    -0.01674987f, 0.00525525f, 0.01380946f, 0.02575061f, -0.00384442f, 0.01502652f, -0.00763487f, 0.00444208f, 
    0.01593643f, 0.03219779f, -0.04001198f, -0.00107981f, 0.02093083f, 0.01145219f, 0.00811488f, -0.00620489f, 
    -0.00729674f, -0.03732130f, -0.00092845f, -0.01354345f, -0.03357107f, -0.03414330f, 0.02509651f, -0.03931969f, 
    -0.01853550f, 0.02383862f, -0.03480078f, -0.02249054f, 0.02169319f, -0.02333919f, 0.03852379f, 0.02703681f, 
    0.00014432f, -0.03397769f, 0.02528193f, 0.01834338f, -0.02502400f, -0.02371716f, 0.01639970f, 0.01144785f, 
    -0.00388029f, 0.00530188f, 0.02562976f, -0.00315218f, -0.01262157f, 0.00159198f, -0.01751271f, 0.04001494f, 
    -0.02227817f, -0.01542061f, -0.00070022f, -0.02556157f, -0.01747233f, -0.01099334f, 0.00684978f, 0.03759125f, 
    -0.03540557f, -0.03518067f, -0.00280281f, -0.01943282f, -0.03646057f, 0.02625590f, 0.00085742f, 0.00159609f, 
    0.02075534f, -0.01511302f, -0.02920824f, -0.02018221f, 0.00189432f, -0.02116818f, 0.00228583f, 0.02191779f, 
    0.00015579f, 0.02568188f, -0.00410000f, 0.01516100f, 0.02424674f, -0.00431012f, -0.01557537f, 0.02048855f, 
    0.00572847f, -0.03467172f, -0.00792070f, 0.00262831f, 0.00159706f, 0.00774293f, -0.02575352f, 0.01236477f, 
    0.00707432f, -0.00112344f, 0.01289558f, 0.01784208f, 0.02096898f, -0.01730974f, 0.00973410f, -0.03007499f, 
    -0.00418596f, 0.00375780f, -0.02621778f, -0.01920565f, 0.02738453f, -0.03991145f, -0.02073073f, 0.00876966f, 
    -0.02060966f, 0.02180296f, -0.02755274f, 0.01373490f, -0.02951451f, 0.01810380f, -0.01520254f, -0.03015872f, 
    0.01572125f, -0.02043470f, -0.02920890f, -0.03389676f, -0.00683925f, -0.02435874f, -0.02032491f, -0.03432343f, 
    -0.00302986f, -0.02079012f, -0.01876258f, -0.02912149f, -0.04282927f, 0.01904466f, 0.02588721f, -0.01875819f, 
    -0.01281150f, 0.02556466f, 0.02292111f, -0.03344051f, -0.02639493f, 0.01179357f, -0.02026290f, -0.01323804f, 
    0.00466569f, -0.02955409f, -0.03808476f, -0.02030608f, 0.00955115f, 0.00865321f, 0.02526557f, -0.00608890f, 
    0.01539052f, 0.02458087f, -0.00275625f, -0.03925294f, -0.00139318f, -0.02685687f, -0.02718587f, 0.00994592f, 
    0.00022996f, 0.00447359f, -0.03614089f, 0.02332022f, 0.00614322f, -0.02212319f, -0.02844344f, -0.01277510f, 
    0.03051576f, -0.04251527f, 0.00873975f, 0.01314815f, 0.00002703f, -0.01120116f, -0.02280860f, -0.01145410f, 
    0.00465309f, 0.01931651f, 0.01861952f, -0.01275636f, -0.00312016f, 0.01096452f, 0.01746572f, -0.01796483f, 
    -0.03551796f, -0.03801875f, 0.01737533f, 0.00414772f, -0.03075442f, -0.03878671f, -0.03660621f, 0.02313224f, 
    0.00096248f, 0.01849190f, 0.00086161f, -0.03277845f, -0.03038657f, -0.03939793f, -0.00726908f, -0.03480222f, 
    -0.01587526f, 0.01272772f, -0.01683756f, -0.04023442f, -0.01484534f, -0.02263744f, -0.02691927f, 0.02198843f, 
    0.01867865f, -0.04034517f, 0.00756142f, 0.00176767f, 0.01088287f, 0.02069636f, -0.01304981f, 0.02658615f, 
    0.00383347f, -0.02050799f, 0.02748178f, 0.00202718f, -0.00332502f, -0.03227410f, 0.02100574f, -0.03881216f, 
    0.01848257f, -0.02783776f, 0.00522269f, -0.03824991f, -0.00806121f, -0.04252589f, 0.03743559f, -0.02911687f, 
    0.03216828f, 0.00271450f, 0.00880030f, -0.00890698f, -0.03603629f, -0.00658818f, 0.02901318f, -0.01708718f, 
    -0.03167602f, -0.01797709f, 0.03061326f, -0.02676984f, -0.01555679f, -0.00427363f, -0.02432837f, 0.00958154f, 
    0.04410018f, -0.01036760f, -0.01715579f, -0.01010179f, 0.02867974f, 0.00026598f, 0.02682156f, 0.00297693f, 
    0.01183209f, 0.02114435f, -0.03221973f, -0.01420722f, 0.03292386f, -0.01423475f, 0.02782422f, -0.01745373f, 
    -0.03407647f, -0.03581411f, 0.01908743f, 0.02313802f, 0.00249491f, 0.01448030f, -0.01872809f, -0.03935654f, 
    0.02462883f, 0.01147802f, -0.00712633f, 0.00758590f, 0.01929395f, 0.02929158f, 0.00125679f, 0.01355892f, 
    0.00433572f, 0.01202277f, 0.02022333f, -0.01368911f, 0.04062881f, -0.00560880f, 0.01150467f, 0.01555075f, 
    0.01073580f, 0.02614412f, 0.00430689f, 0.02964804f, -0.01441147f, 0.00146993f, -0.02215298f, -0.00211547f, 
    0.01103576f, 0.02506772f, -0.01858922f, -0.01459120f, 0.01736655f, -0.01110440f, -0.01028384f, -0.00029199f, 
    0.02925482f, -0.00187355f, -0.02171470f, -0.01032697f, 0.01843497f, 0.00891168f, 0.00022343f, -0.01867216f, 
    -0.02154249f, -0.00073482f, -0.00212255f, -0.02358537f, -0.00925994f, 0.01806378f, -0.00880467f, 0.02793433f, 
    0.00512285f, -0.01468345f, -0.02992211f, 0.01383122f, 0.00995143f, -0.03549635f, 0.01719495f, 0.00163899f, 
    -0.00910026f, 0.02042728f, -0.01702963f, 0.00415465f, -0.03809605f, -0.00949986f, -0.02430747f, -0.04426223f, 
    0.02627933f, 0.02667185f, -0.01285373f, 0.01628248f, 0.03197493f, -0.00618920f, -0.01541972f, 0.02833827f, 
    0.02269043f, 0.02914393f, 0.00108358f, -0.00304219f, -0.00946948f, -0.01157949f, -0.00575981f, 0.00802306f, 
    -0.01812985f, 0.02575738f, -0.01910798f, 0.03688046f, -0.04449933f, -0.01506496f, 0.00454420f, -0.00293890f, 
    0.00889334f, 0.00348113f, -0.00397715f, 0.02138505f, 0.00720318f, 0.01319608f, -0.02027142f, -0.03226617f, 
    -0.04295620f, 0.00883524f, -0.02283359f, 0.01410525f, 0.02786535f, -0.02372851f, -0.00634067f, -0.02412606f, 
    -0.02338043f, -0.00459158f, 0.01769557f, -0.00958920f, -0.01085142f, 0.01867787f, -0.01047871f, -0.01174897f, 
    0.02276411f, 0.01510125f, 0.03407717f, -0.02193619f, 0.01245950f, 0.03472208f, -0.02952096f, -0.02906340f, 
    -0.01864185f, 0.00206162f, 0.01791897f, -0.01734317f, -0.02673138f, -0.02743620f, 0.01694874f, -0.01880841f, 
    0.01714520f, 0.01631043f, -0.01543161f, -0.01028477f, -0.02713007f, 0.01745731f, 0.02508915f, 0.01882908f, 
    0.00584668f, 0.00845904f, 0.00349423f, -0.01177665f, -0.01067800f, 0.01020282f, -0.03001278f, 0.03687170f, 
    0.01633856f, -0.00723854f, -0.03063510f, -0.01609886f, 0.02508017f, -0.03369877f, -0.01766133f, 0.00040724f, 
    -0.00916964f, -0.02655295f, -0.02820655f, 0.01251833f, -0.02857173f, 0.02973753f, 0.01622302f, 0.01318232f, 
    -0.03433935f, 0.00414349f, 0.00845695f, -0.01995172f, 0.00571515f, 0.00264606f, 0.00322720f, -0.03698301f, 
    0.00960817f, 0.01930434f, -0.01752658f, 0.01921622f, 0.02656554f, -0.00842123f, -0.03756919f, -0.01966405f, 
    -0.03822910f, -0.04042565f, 0.03011369f, -0.01457083f, 0.00413830f, 0.01438176f, -0.03685655f, 0.02656603f, 
    0.01669873f, 0.01008874f, 0.01553205f, 0.00673045f, 0.00382331f, 0.00153828f, -0.04029619f, 0.01721173f, 
    -0.01146378f, 0.01292546f, -0.03566523f, -0.01166059f, 0.01554799f, 0.02910953f, -0.01590124f, -0.03626749f, 
    -0.03792145f, -0.02096818f, 0.00025667f, 0.01012771f, 0.00054012f, -0.02656604f, 0.01041359f, 0.01849133f, 
    -0.00214772f, -0.03909116f, 0.02098300f, -0.02188545f, -0.01166004f, 0.00273377f, 0.01530356f, 0.01468708f, 
    -0.00625927f, -0.02897839f, -0.00950939f, 0.03086593f, 0.01384728f, -0.01126422f, -0.01447238f, -0.00040444f, 
    -0.02757499f, 0.02326049f, 0.00804442f, 0.01613057f, -0.00763003f, -0.01336056f, -0.04468241f, -0.00072744f, 
    -0.00014217f, -0.00071700f, -0.00014154f, -0.01360572f, -0.03646728f, 0.00113038f, -0.01748666f, -0.00802431f, 
    -0.01581055f, 0.01295417f, 0.00772326f, -0.03401266f, 0.02105295f, -0.03216739f, -0.01174736f, -0.03831330f, 
    -0.03085367f, 0.00743831f, 0.02538686f, -0.01862023f, -0.03094148f, 0.00469889f, 0.00736343f, 0.03180044f, 
    -0.00428441f, 0.00923651f, 0.02535776f, 0.02944616f, -0.01780696f, 0.02974136f, 0.01384197f, -0.02462745f, 
    0.04540559f, -0.03535312f, 0.02918697f, -0.00450109f, -0.02889161f, -0.03401015f, -0.00998176f, -0.02281664f, 
    0.02175077f, -0.00108611f, -0.04319203f, -0.00100646f, -0.00496424f, 0.02042633f, -0.00544518f, -0.00309546f, 
    -0.02870316f, -0.02091183f, 0.04162956f, -0.01162397f, 0.00441953f, 0.01134623f, 0.01783560f, -0.01675857f, 
    -0.02625561f, -0.02059850f, 0.00833592f, -0.02479482f, -0.02542024f, -0.03525027f, -0.00758944f, 0.02811965f, 
    0.01772265f, -0.00911898f, -0.01901423f, -0.02064712f, -0.02731529f, 0.00506200f, -0.03792956f, 0.02609242f, 
    -0.00830793f, 0.01910337f, 0.02410957f, -0.01481390f, -0.00006730f, -0.01000085f, -0.04151586f, 0.01723816f, 
    -0.02136161f, 0.02460103f, -0.01464742f, -0.03547079f, 0.00241963f, -0.03295704f, -0.01905994f, -0.03462719f, 
    -0.04125958f, -0.01522301f, 0.00497864f, 0.00050347f, -0.03255041f, 0.01530126f, 0.00499922f, -0.01329383f, 
    -0.00398181f, -0.03937007f, -0.03726648f, -0.01751642f, -0.00411898f, 0.02415436f, -0.00185446f, -0.02496922f, 
    -0.02207999f, 0.02614243f, -0.03017034f, -0.02256329f, 0.02518278f, 0.02237027f, 0.00408528f, 0.00716349f, 
    -0.01133332f, -0.00741769f, -0.00898511f, 0.01319454f, -0.01277739f, 0.01036406f, -0.01074862f, 0.00771187f, 
    -0.03573541f, 0.01625369f, 0.00489548f, 0.02409322f, 0.01318748f, 0.02462463f, 0.00915929f, 0.02578221f, 
    0.02441858f, -0.01305111f, -0.00225921f, -0.04363436f, -0.01817315f, 0.02518864f, 0.01972761f, 0.01107268f, 
    -0.01910246f, 0.00598626f, -0.01294430f, 0.02447175f, 0.01185699f, 0.01013108f, 0.00118224f, 0.02426672f, 
    -0.00139867f, -0.03212328f, -0.02066532f, 0.02594379f, 0.01875812f, -0.00427206f, 0.02719672f, -0.02069607f, 
    -0.01661382f, -0.03283110f, -0.02218720f, -0.02819216f, 0.02356509f, -0.02549465f, -0.02789590f, 0.00517614f, 
    0.01221059f, -0.03512019f, -0.02027261f, -0.00381556f, 0.03152009f, 0.00031089f, -0.03904636f, -0.02479873f, 
    -0.01099687f, -0.03551924f, 0.01729441f, 0.02298299f, 0.00824066f, -0.02562951f, -0.00523227f, -0.03458605f, 
    0.02199556f, -0.00470486f, -0.00441614f, -0.01426693f, -0.00374906f, -0.01420038f, -0.02640612f, -0.00880284f, 
    -0.02555117f, -0.01925051f, 0.01910862f, 0.01644902f, -0.00809559f, -0.02290493f, 0.00760268f, -0.01047170f, 
    0.02725811f, 0.01129097f, -0.02738211f, -0.02057718f, -0.04110463f, -0.00627791f, 0.03074026f, 0.00894822f, 
    0.01456986f, 0.03198302f, 0.00969210f, -0.01305366f, 0.00926842f, -0.00188918f, 0.02136297f, 0.01579228f, 
    0.03359466f, -0.02651914f, -0.01172672f, -0.03853059f, 0.01522442f, 0.03497611f, 0.02764025f, 0.00545411f, 
    0.03760112f, 0.02033300f, 0.03162480f, 0.01053195f, 0.01291452f, -0.02747406f, 0.03313201f, -0.01991013f, 
    0.02340903f, 0.03018802f, 0.01298460f, -0.03390552f, -0.03442850f, -0.00561946f, -0.04168845f, -0.00684825f, 
    -0.04088962f, 0.01904445f, 0.03020980f, -0.04059790f, 0.01702725f, 0.00206731f, -0.00201638f, 0.00766052f, 
    0.02085007f, 0.00178936f, -0.03980457f, 0.00744293f, 0.01038534f, -0.03536682f, -0.02069835f, -0.02000995f, 
    -0.03989519f, -0.01660590f, -0.00625887f, -0.00770431f, -0.02350289f, 0.02065762f, -0.00063797f, -0.03715504f, 
    0.00206186f, -0.01507814f, -0.03927261f, -0.03183191f, -0.00449099f, -0.01643803f, -0.02206308f, -0.00766352f, 
    0.02200838f, 0.01492999f, 0.01852619f, -0.01906459f, -0.04436762f, 0.00534960f, 0.00700848f, 0.00712145f, 
    0.02506172f, 0.01599444f, 0.00600634f, -0.01214423f, -0.01280650f, -0.04425164f, -0.00973457f, -0.00405632f, 
    -0.01149852f, 0.02179515f, -0.01870549f, 0.00433678f, 0.02164995f, 0.03788682f, 0.02387791f, -0.04418243f, 
    -0.01678421f, 0.00275692f, 0.00056659f, -0.03433752f, 0.02222015f, -0.00664376f, -0.00326649f, -0.02896998f, 
    0.00550349f, -0.02503420f, 0.00678821f, -0.03799517f, 0.01869150f, 0.01270460f, -0.02749606f, -0.02815596f, 
    -0.00931056f, 0.01686039f, -0.01934296f, 0.02453015f, 0.02151667f, -0.00476085f, -0.03248137f, 0.02662525f, 
    0.01095030f, -0.03278429f, 0.01332455f, 0.01284473f, -0.00344455f, 0.01184746f, -0.00919283f, -0.01181953f, 
    0.01357881f, -0.02334078f, -0.00134571f, -0.03768010f, 0.02354624f, -0.04278634f, 0.03106503f, 0.01158819f, 
    0.02105829f, -0.00274372f, 0.00699904f, -0.01306663f, -0.00230753f, -0.02966901f, 0.01744017f, 0.01964072f, 
    -0.02911210f, 0.02575865f, 0.02513081f, -0.01003978f, -0.04304511f, -0.04082491f, 0.00275199f, 0.00909767f, 
    0.01970662f, 0.00513242f, -0.02979931f, -0.01901025f, -0.03120023f, -0.02764094f, -0.01389350f, 0.01340095f, 
    -0.00027626f, -0.02944042f, 0.01673192f, -0.01126154f, -0.03313346f, 0.01392478f, -0.01580862f, -0.03526806f, 
    0.02190941f, 0.01371227f, 0.00138084f, -0.01091134f, 0.01283651f, -0.00846501f, -0.01974217f, -0.02644604f, 
    -0.00382130f, -0.02745150f, 0.01420849f, -0.00715618f, -0.00605935f, -0.01497352f, 0.03734131f, 0.02229885f, 
    -0.00191780f, 0.01507311f, 0.00856876f, -0.02010245f, 0.00306180f, 0.00688831f, -0.00419294f, -0.03482186f, 
    -0.04399612f, -0.02241623f, 0.00038766f, -0.01999499f, -0.00989032f, -0.03171110f, -0.04393352f, -0.03183542f, 
    0.02620908f, -0.01125824f, 0.01905556f, -0.03061878f, -0.01023598f, -0.00887557f, -0.00126996f, 0.02551173f, 
    -0.00954105f, 0.01815100f, 0.02768086f, -0.00971035f, 0.01782912f, -0.02565968f, 0.01783590f, -0.04283562f, 
    -0.03864620f, 0.00976317f, 0.00980270f, -0.01305291f, -0.01436807f, -0.03492331f, -0.01106534f, -0.02145608f, 
    -0.01613386f, -0.01555547f, 0.01236277f, 0.00119043f, -0.02893518f, -0.00919995f, 0.00348172f, 0.00345633f, 
    -0.00799052f, -0.04021379f, 0.01669799f, -0.02150802f, 0.01753505f, 0.00246602f, 0.00433634f, -0.03037268f, 
    0.02486271f, 0.00891376f, 0.00111666f, -0.02615020f, -0.02382191f, -0.00628309f, -0.00522616f, 0.00025798f, 
    0.01761717f, -0.00410926f, -0.01639667f, -0.03457546f, -0.01441160f, -0.03973060f, 0.02379438f, -0.00968245f, 
    0.01228991f, -0.01332136f, -0.04387185f, 0.02924082f, -0.02523429f, -0.00048817f, -0.01582606f, -0.00020306f, 
    0.02777863f, 0.00182609f, -0.03414761f, -0.00529278f, 0.01221895f, -0.04347374f, 0.02054875f, -0.01534678f, 
    0.01088697f, -0.03836234f, -0.02213022f, 0.00015246f, 0.01323972f, -0.00250334f, 0.00504059f, -0.02862452f, 
    -0.03055491f, 0.00647885f, 0.00652007f, -0.01804429f, -0.00436441f, 0.01043189f, 0.02446442f, -0.01875951f, 
    -0.01247086f, -0.01094296f, -0.02487143f, -0.00232178f, -0.01066351f, -0.01069792f, 0.02240661f, -0.03465816f, 
    -0.01622197f, 0.01462699f, 0.00496069f, -0.00600220f, -0.03180228f, -0.03016697f, -0.01779925f, -0.03073886f, 
    0.01981598f, 0.00294360f, -0.03612950f, -0.01590767f, 0.00489347f, -0.04541270f, -0.03135640f, 0.01174901f, 
    -0.03174200f, -0.01406648f, -0.01953032f, 0.00903092f, -0.01310166f, -0.02353427f, -0.00647830f, 0.01405053f, 
    0.01002555f, 0.01861243f, -0.01299580f, -0.01755026f, -0.03217710f, -0.02016915f, -0.02841647f, -0.02047386f, 
    -0.00265734f, -0.00401847f, 0.01870937f, -0.04024936f, -0.03165671f, -0.00924313f, -0.01848484f, -0.01348512f, 
    -0.00539006f, 0.02571311f, 0.02746645f, -0.01940132f, 0.01979722f, -0.00069581f, 0.02638651f, -0.01182454f, 
    -0.04406877f, -0.03631704f, -0.00036246f, -0.03114144f, 0.00221927f, 0.02965758f, 0.00175347f, -0.01834689f, 
    -0.04627500f, -0.01446609f, -0.00835957f, -0.02630896f, -0.03875950f, -0.01715853f, 0.02590611f, -0.01527237f, 
    -0.01805623f, 0.01772751f, -0.00634133f, 0.02774481f, -0.00412378f, -0.01473564f, -0.02943235f, 0.00999229f, 
    0.00424107f, 0.02825924f, -0.00958677f, 0.02282585f, 0.01281750f, -0.00183792f, -0.01624727f, -0.01277205f, 
    0.02200823f, -0.00972715f, 0.00839604f, -0.03804444f, -0.02962036f, 0.02775228f, 0.00290540f, -0.02529566f, 
    0.01583964f, -0.01368388f, -0.00878756f, 0.02593456f, -0.02209801f, 0.02152772f, -0.03449541f, 0.01231889f, 
    -0.03642913f, 0.00742517f, 0.00755675f, -0.01513107f, -0.03843688f, -0.00612174f, 0.01022340f, -0.03547208f, 
    -0.00218540f, 0.01470494f, 0.01864817f, -0.00184391f, 0.00924104f, 0.02922266f, 0.00101505f, -0.00300364f, 
    -0.02045092f, 0.00922125f, -0.02361878f, -0.03308408f, -0.00904625f, 0.01349065f, -0.03031646f, 0.02035338f, 
    0.00207143f, -0.00913768f, 0.02555305f, 0.00609080f, -0.02577583f, -0.01599739f, -0.00534140f, 0.00540013f, 
    -0.00647344f, 0.02419279f, 0.02025185f, -0.01072874f, 0.00428357f, -0.02061591f, -0.00712990f, 0.00383089f, 
    0.00794131f, 0.00130831f, 0.00247959f, 0.00262673f, 0.02541322f, 0.01008586f, 0.00159058f, -0.03033631f, 
    0.00239858f, -0.03479566f, -0.02372176f, -0.03096056f, 0.01802845f, 0.01845494f, -0.03412649f, -0.02061158f, 
    -0.00849499f, -0.02840829f, 0.01022696f, -0.03752382f, 0.02272914f, -0.03413915f, -0.01529278f, 0.00930720f, 
    -0.02336294f, 0.00151121f, 0.01667256f, -0.00416639f, -0.01681235f, -0.00037206f, -0.03431754f, 0.01429803f, 
    -0.02489972f, -0.02314303f, 0.00331800f, -0.00072375f, -0.04190038f, -0.01363292f, -0.03076839f, -0.03188257f, 
    -0.02284716f, 0.02836587f, -0.02599251f, 0.01329125f, 0.01275470f, 0.00815646f, -0.00081923f, -0.03150526f, 
    0.02798106f, -0.02565653f, 0.00017126f, -0.02402706f, -0.02450939f, 0.01340718f, 0.01660413f, 0.01248226f, 
    -0.03149723f, -0.01346272f, 0.03706837f, -0.00916440f, 0.00645170f, 0.03698485f, -0.03678988f, -0.01145781f, 
    -0.00079775f, 0.01610139f, -0.00139419f, 0.01607904f, -0.03325474f, 0.02478388f, 0.02175438f, 0.00822190f, 
    0.02606039f, 0.00655922f, -0.00535374f, -0.03606869f, -0.03677493f, 0.02897885f, 0.01776546f, -0.00695091f, 
    -0.02866448f, 0.02313348f, 0.01357416f, -0.01425467f, 0.02321770f, 0.00374827f, 0.00333461f, 0.01253899f, 
    -0.00639485f, -0.01022159f, -0.00894734f, 0.01169607f, -0.03856430f, -0.00857684f, -0.03430853f, 0.01480353f, 
    -0.03659447f, -0.04109266f, -0.02694389f, 0.00730501f, 0.01348298f, -0.03909759f, -0.02548936f, 0.01391788f, 
    -0.00947615f, -0.02971257f, -0.00839530f, 0.01258193f, -0.04672386f, -0.01231082f, 0.01817772f, -0.04066212f, 
    0.00521787f, -0.01848652f, -0.02114630f, 0.00952477f, 0.00995859f, 0.01729315f, 0.01793236f, -0.03430844f, 
    -0.02391621f, -0.03500809f, -0.02383878f, 0.00191653f, -0.01935281f, -0.00557879f, 0.02123977f, -0.02078339f, 
    0.01718165f, 0.02108468f, -0.03405609f, -0.02348965f, 0.00839793f, -0.03589674f, -0.04421644f, -0.02831282f, 
    -0.01689634f, -0.02142871f, -0.02393376f, -0.00717034f, 0.02420356f, -0.00937559f, -0.01721611f, 0.01490177f, 
    0.01964787f, 0.01724359f, -0.04263508f, 0.00634443f, -0.03960587f, -0.02926253f, 0.00508128f, -0.04453124f, 
    0.01422848f, -0.04160012f, -0.00994347f, -0.02280948f, 0.01347760f, -0.03999859f, -0.00488331f, 0.01025117f, 
    0.00618903f, 0.00749545f, -0.00546919f, -0.04029585f, -0.01601497f, -0.00298004f, -0.02681371f, -0.00570519f, 
    0.03307748f, -0.02875664f, -0.00019572f, -0.00123097f, -0.02039798f, -0.00812784f, 0.00565152f, -0.04232877f, 
    -0.00781116f, -0.03547532f, -0.04284276f, 0.00381186f, 0.01062753f, -0.01544174f, -0.03695696f, -0.01868799f, 
    -0.02662528f, 0.02086655f, 0.00137390f, -0.00783939f, 0.02346270f, 0.02673615f, -0.01102144f, -0.00672007f, 
    -0.03875621f, -0.02164708f, -0.02380206f, -0.01554198f, -0.02743648f, -0.00817483f, -0.03654016f, 0.00792561f, 
    -0.02113304f, 0.03316925f, -0.02478027f, 0.00039462f, 0.02487448f, 0.01572353f, -0.01241848f, -0.02403256f, 
    0.03277565f, -0.01327571f, -0.01659066f, -0.02964656f, -0.00689248f, -0.02854346f, 0.03048043f, -0.02389039f, 
    -0.02114292f, -0.00156343f, -0.01862316f, -0.02480340f, -0.00867709f, -0.03914518f, -0.04429986f, -0.00247950f, 
    -0.00581715f, -0.01318058f, 0.01662834f, -0.01915823f, 0.01562911f, -0.00497349f, 0.00149622f, -0.03797765f, 
    -0.00352028f, -0.00765105f, -0.00048978f, 0.02265275f, -0.01107345f, -0.04439743f, -0.02741417f, 0.00783495f, 
    -0.00203344f, -0.02374407f, 0.01381021f, 0.01849601f, -0.00164230f, -0.01882587f, -0.00091647f, 0.00216741f, 
    -0.01653185f, -0.01496867f, 0.00152170f, 0.01089361f, -0.03995677f, -0.02053596f, -0.01821267f, 0.02085698f, 
    0.01075968f, -0.03044698f, -0.00134003f, -0.03740242f, 0.03398001f, -0.03608596f, -0.01866830f, 0.01579094f, 
    -0.04409399f, 0.02354696f, -0.00527329f, 0.02479820f, -0.02359073f, -0.01615029f, 0.00963798f, -0.00601103f, 
    0.02373111f, 0.00268060f, 0.00570058f, -0.03758823f, -0.02062464f, -0.01777763f, 0.02414265f, 0.02652124f, 
    0.01921636f, -0.00428365f, -0.02122677f, -0.02628878f, -0.00461617f, 0.01613816f, 0.01163669f, -0.01333875f, 
    -0.01387212f, -0.01697923f, -0.02406322f, -0.00458025f, -0.02902711f, 0.01820154f, 0.01945147f, 0.01524427f, 
    0.02181248f, 0.02349321f, -0.00636683f, 0.00499544f, -0.04143611f, -0.02745260f, -0.04069246f, 0.01570298f, 
    0.00624448f, -0.02481121f, 0.02129199f, -0.01879318f, -0.00288768f, 0.02485466f, -0.00134455f, 0.03627538f, 
    0.00038043f, 0.03440781f, 0.00788234f, -0.03705414f, 0.02014530f, 0.02046843f, 0.02057270f, -0.02237470f, 
    0.01508619f, -0.02013317f, 0.01672207f, 0.02329274f, -0.00056773f, -0.00591628f, 0.00461964f, 0.01369459f, 
    0.01751269f, 0.02469798f, -0.01550112f, 0.01996389f, 0.01706026f, 0.01969935f, -0.00100734f, -0.00898658f, 
    0.00321453f, -0.04565965f, -0.00762819f, 0.01619684f, -0.03630530f, 0.00547455f, 0.00696869f, 0.00191937f, 
    -0.02221697f, 0.01512925f, 0.01160832f, -0.01685157f, 0.00844988f, -0.00712975f, 0.02037873f, -0.04094565f, 
    -0.01484385f, 0.00819559f, -0.00732796f, -0.02342687f, 0.00150618f, 0.00024310f, -0.01853270f, 0.03062980f, 
    0.02658254f, -0.02862795f, -0.04157913f, 0.00616608f, -0.01249657f, -0.01782488f, -0.02293227f, -0.00411422f, 
    0.02272314f, 0.00031195f, -0.02291190f, 0.01610942f, -0.00840937f, -0.03295169f, -0.00946124f, -0.04173712f, 
    -0.03576098f, -0.02423999f, -0.02531213f, 0.01425064f, 0.03060752f, -0.02268925f, -0.00397029f, -0.02445736f, 
    0.01112719f, 0.00912803f, 0.01413882f, 0.00507321f, -0.00433476f, 0.03260522f, -0.02363849f, -0.02695710f, 
    -0.02119968f, 0.00484380f, -0.03525091f, 0.01717627f, -0.00554084f, -0.01424660f, -0.00917675f, -0.02972994f, 
    -0.01500225f, 0.02956339f, -0.01892517f, -0.01803791f, 0.00419491f, -0.01563543f, -0.01502656f, -0.04003195f, 
    0.01963141f, 0.02419571f, -0.03884643f, -0.04151227f, 0.02065978f, -0.00393917f, 0.02386694f, 0.02789758f, 
    0.00433398f, -0.04006406f, -0.00885801f, -0.03805457f, 0.01846664f, -0.00193436f, -0.03639625f, -0.03733636f, 
    -0.00544356f, 0.01154303f, 0.00764041f, 0.01195782f, -0.01212488f, -0.00104426f, -0.01298433f, 0.02362226f, 
    0.01590644f, 0.01680342f, -0.01101869f, -0.03135279f, 0.03166761f, 0.00930072f, -0.01324335f, -0.01732064f, 
    -0.02105085f, -0.03464977f, 0.01866049f, -0.01800829f, 0.01042004f, 0.00428145f, 0.01906570f, 0.02431625f, 
    0.00050073f, 0.00933006f, 0.02732006f, 0.02407471f, -0.02004105f, -0.01019958f, -0.00570134f, 0.01579602f, 
    0.00139186f, 0.00745780f, 0.00791866f, 0.00579000f, -0.02085000f, 0.00265394f, 0.00676529f, 0.00473021f, 
    -0.00086012f, -0.02001874f, -0.03496817f, 0.00259242f, -0.03215173f, 0.01712218f, 0.00136956f, 0.00619531f, 
    0.02702156f, 0.02216647f, 0.02500214f, -0.03468238f, 0.02043731f, 0.01243273f, 0.00465364f, -0.01902857f, 
    -0.00436340f, 0.02975225f, 0.00055911f, 0.00594775f, 0.01141575f, -0.00476975f, -0.00315999f, 0.00143647f, 
    0.00027783f, -0.01723455f, -0.02452049f, 0.00637397f, -0.00998876f, 0.00401407f, 0.00165680f, 0.01307678f, 
    0.02075626f, -0.02679067f, -0.04119332f, 0.03032568f, -0.03209456f, 0.00526235f, -0.03852657f, 0.02011896f, 
    0.00719917f, -0.01397031f, 0.01667864f, -0.03578820f, -0.04017475f, -0.00100469f, -0.01985828f, 0.01763939f, 
    -0.01609997f, 0.01124642f, 0.03004514f, -0.00199096f, 0.02745275f, 0.02756258f, 0.03296082f, -0.02954251f, 
    -0.00360978f, -0.03841603f, -0.02103063f, -0.03114853f, -0.00191511f, -0.02963829f, -0.02716762f, -0.03220744f, 
    -0.00476686f, 0.02919427f, 0.00776029f, -0.02456761f, 0.01922420f, 0.00382254f, -0.02141233f, -0.00350010f, 
    -0.03743073f, -0.02014391f, 0.02893534f, -0.03464652f, -0.00203798f, 0.01397764f, -0.01374148f, -0.03493581f, 
    0.02737171f, 0.00300637f, -0.02858580f, -0.04132001f, -0.00127753f, -0.03147358f, 0.00730746f, 0.02100939f, 
    -0.03738302f, -0.02208666f, -0.02122425f, -0.01443269f, 0.01508669f, -0.03940467f, -0.00029243f, -0.00733930f, 
    -0.01041684f, -0.02884149f, 0.03386333f, -0.01053211f, -0.02005174f, 0.03264138f, -0.01820308f, 0.02014379f, 
    -0.02710521f, 0.00989015f, -0.00837936f, -0.02450871f, 0.02413042f, -0.03415727f, 0.03128491f, -0.00820807f, 
    -0.00388855f, 0.01090558f, 0.00777343f, -0.01947394f, -0.02473933f, -0.01151878f, -0.01621463f, -0.00949535f, 
    -0.01372792f, -0.00460477f, 0.02076623f, -0.03416075f, -0.02568261f, -0.02094480f, -0.00311407f, -0.02545424f, 
    -0.03467818f, 0.01772220f, -0.02170018f, 0.01391937f, 0.03045938f, 0.01988113f, -0.01588415f, -0.00429230f, 
    -0.03254179f, 0.01264824f, 0.00679805f, -0.03964976f, 0.02467285f, 0.00445754f, -0.02469606f, 0.01793486f, 
    -0.00608415f, -0.00173474f, -0.00509166f, -0.01358389f, 0.00472300f, -0.00247760f, 0.00933171f, -0.03732137f, 
    0.00980326f, -0.03539296f, -0.03925532f, -0.00292544f, -0.00899865f, 0.01805728f, -0.02052435f, 0.01183403f, 
    -0.01558934f, 0.03349401f, 0.01504144f, 0.01573254f, 0.02592571f, 0.00485258f, -0.01782008f, -0.01213127f, 
    -0.01584749f, -0.00994618f, 0.01781012f, -0.02640975f, -0.04111545f, -0.00092603f, 0.03983109f, -0.00995554f, 
    0.01238809f, 0.02090789f, 0.01358715f, 0.02805877f, 0.02511476f, 0.01858691f, -0.03165388f, 0.02371483f, 
    0.01993784f, -0.03265904f, -0.03533700f, -0.03753123f, -0.02289908f, -0.01269072f, 0.02131648f, -0.02964710f, 
    0.01256498f, -0.02081725f, -0.01135202f, -0.02860609f, -0.01117296f, 0.02743165f, 0.00797358f, -0.00556063f, 
    -0.01825842f, -0.02257778f, 0.00084312f, -0.02583560f, -0.03159304f, -0.00171754f, 0.00509245f, 0.01874137f, 
    -0.03858976f, -0.02422584f, -0.01742983f, 0.01501505f, 0.00627538f, 0.00235453f, -0.04185374f, -0.00771622f, 
    0.02715583f, 0.03128803f, 0.00253657f, -0.02438483f, -0.00063785f, 0.02018755f, 0.02877947f, 0.00175764f, 
    0.00892707f, -0.01289359f, 0.02712859f, 0.03752118f, 0.02879932f, -0.00145732f, 0.01857535f, -0.01938187f, 
    0.01254760f, 0.03532597f, 0.02085902f, -0.01254047f, 0.01313055f, -0.02627893f, -0.03622019f, -0.00723895f, 
    0.00001791f, -0.04165220f, 0.01899686f, -0.00781814f, 0.01697008f, -0.00359707f, -0.00515694f, -0.02527132f, 
    -0.02626858f, 0.01016531f, -0.03107578f, -0.03731556f, -0.02528229f, -0.02223094f, 0.01596711f, -0.01980160f, 
    -0.01297916f, 0.02181415f, 0.00053826f, 0.02796294f, 0.00594221f, -0.00903173f, 0.00390377f, -0.02821627f, 
    0.00130120f, 0.01847205f, 0.01202553f, 0.01665840f, 0.02479232f, -0.00697511f, -0.00864274f, -0.02542860f, 
    0.00984172f, 0.00459059f, 0.02498061f, -0.02482213f, -0.00539729f, -0.02638344f, 0.01163968f, 0.02270347f, 
    -0.00957659f, 0.02043927f, -0.02357423f, -0.03482838f, -0.03173856f, -0.01653370f, -0.01320382f, 0.02438875f, 
    0.00644635f, 0.03676945f, -0.02707318f, 0.00213120f, -0.00139349f, 0.00112838f, -0.00631410f, 0.01563374f, 
    0.01426825f, 0.00191907f, 0.01469102f, -0.00738043f, -0.03411081f, -0.03289355f, -0.03545285f, -0.03578828f, 
    -0.02592159f, 0.01942161f, 0.02362802f, -0.03129962f, 0.00238139f, -0.04134053f, 0.00400886f, -0.01925540f, 
    -0.01181479f, 0.00605883f, -0.00412843f, -0.01933068f, 0.04257151f, 0.01444253f, -0.02494599f, 0.00641328f, 
    -0.01972603f, -0.00554874f, -0.01862369f, -0.03712252f, -0.00900158f, -0.00884201f, -0.01220819f, 0.00790684f, 
    0.02486366f, 0.00675244f, -0.01033571f, 0.00720421f, -0.00376454f, 0.02619919f, -0.01075628f, 0.02378935f, 
    -0.00980572f, -0.02096848f, -0.03661748f, -0.03710593f, -0.03147581f, -0.00176137f, 0.01515390f, -0.02735107f, 
    0.02420447f, -0.03162349f, 0.00981162f, -0.02304375f, 0.02544787f, -0.01556283f, 0.00434153f, -0.03185249f, 
    0.00876962f, -0.00288548f, 0.01231060f, 0.00517334f, 0.00310864f, -0.03688488f, 0.00049008f, 0.01258794f, 
    0.01695283f, -0.00384865f, 0.01989308f, -0.01148451f, -0.03510622f, 0.03505480f, 0.03151280f, 0.02304317f, 
    0.02414387f, 0.02439877f, -0.03212246f, -0.02423363f, -0.01970746f, 0.04321659f, -0.03588936f, -0.00689914f, 
    -0.02867842f, -0.02082424f, -0.02761455f, 0.03009080f, 0.00772657f, -0.03680383f, 0.00116291f, -0.03101491f, 
    -0.04326701f, 0.02075538f, -0.01039375f, -0.04028331f, -0.03390430f, -0.01235877f, 0.01115887f, 0.00457397f, 
    0.02209577f, 0.00201092f, 0.01061592f, 0.01576551f, -0.03424848f, -0.01258679f, -0.00279390f, 0.00259923f, 
    0.00047595f, -0.02566194f, -0.01311655f, -0.04005573f, 0.00625633f, -0.02320697f, -0.02071523f, 0.02860442f, 
    0.01569477f, 0.00543918f, 0.01703563f, 0.01943834f, -0.01856336f, 0.02545738f, -0.03730607f, 0.00232425f, 
    0.03288912f, -0.01457075f, 0.01523465f, -0.00988803f, -0.01768201f, -0.01913529f, -0.00755443f, -0.03087936f, 
    -0.03720044f, -0.01324451f, -0.02663375f, 0.00686149f, 0.02039156f, -0.01502480f, 0.01002438f, 0.00446300f, 
    -0.04288366f, -0.00735090f, -0.03357720f, -0.02338104f, -0.00572266f, -0.01478852f, 0.00484949f, -0.02983459f, 
    0.02003342f, 0.01020954f, -0.00132575f, -0.03195422f, -0.01532756f, -0.01776252f, 0.01320618f, -0.00915962f, 
    -0.02120552f, 0.02465121f, -0.00474808f, -0.00169880f, -0.01024049f, -0.00157233f, 0.01977596f, -0.00880468f, 
    0.00725402f, 0.02707411f, 0.00264501f, -0.02747775f, -0.00165647f, -0.03032936f, -0.01080986f, 0.02280708f, 
    0.02402201f, 0.01449826f, -0.03703605f, 0.02760509f, 0.02082897f, -0.01218797f, -0.02433411f, 0.01846910f, 
    -0.03629290f, -0.00580373f, 0.02478825f, -0.00413243f, -0.01450360f, -0.04078328f, -0.01873484f, -0.02846400f, 
    -0.03262235f, 0.00589370f, 0.00258737f, -0.02525857f, -0.01981690f, 0.01555516f, -0.03774641f, -0.03088573f, 
    0.00560406f, -0.02099650f, 0.02597057f, -0.00357405f, -0.01778688f, -0.01652629f, -0.03693857f, 0.00681380f, 
    -0.03440607f, -0.00072153f, -0.03187696f, 0.00881588f, 0.00658778f, 0.01591095f, -0.03051084f, -0.02680411f, 
    -0.00245048f, 0.00519441f, 0.00213171f, -0.02911622f, 0.00265256f, -0.00078783f, -0.03349973f, -0.01843975f, 
    -0.00449048f, 0.02767340f, 0.00882622f, -0.01241429f, -0.03638564f, 0.01530473f, -0.00482090f, 0.01782460f, 
    -0.01568876f, -0.02865084f, 0.03030995f, 0.01386474f, -0.01628124f, -0.03527407f, 0.02747068f, 0.00285965f, 
    0.01367010f, 0.02889440f, -0.02116028f, -0.02482417f, -0.03454146f, -0.02784175f, -0.02252581f, 0.00667331f, 
    -0.01530900f, -0.03187264f, -0.02987508f, -0.02131112f, 0.02829689f, 0.00450361f, -0.03440055f, -0.02974253f, 
    -0.04133430f, 0.01453501f, 0.01145350f, 0.02919538f, 0.00972441f, 0.00159123f, -0.01571467f, -0.03951026f, 
    0.00639184f, -0.01876147f, -0.01101250f, 0.02059656f, 0.00885198f, 0.00641890f, -0.03859298f, 0.00677482f, 
    0.00345660f, -0.03639691f, -0.03698989f, -0.00189523f, -0.01627797f, -0.01001541f, -0.02616296f, -0.02087283f, 
    0.00371768f, -0.02829054f, -0.02499772f, -0.00065914f, 0.01692148f, -0.03062506f, 0.03045889f, 0.01422256f, 
    -0.01533523f, -0.03077118f, -0.02541150f, -0.03737245f, -0.01886352f, 0.01480655f, 0.00925463f, 0.00979096f, 
    -0.02497398f, 0.00385473f, 0.02137060f, 0.00236972f, 0.00125106f, 0.01637243f, 0.01917361f, -0.03515788f, 
    -0.00228850f, 0.02237690f, 0.01613657f, -0.02149023f, -0.03454636f, -0.01828693f, 0.02670654f, 0.01830220f, 
    0.01457207f, -0.02180079f, 0.00924344f, 0.02837148f, -0.00151687f, 0.02159034f, 0.01960238f, -0.00728972f, 
    0.02005395f, -0.01443863f, -0.02067345f, 0.02672238f, -0.03644283f, 0.01368797f, -0.01041733f, -0.01693435f, 
    0.02933413f, 0.03039733f, 0.00552487f, -0.02237627f, 0.00374462f, 0.01611282f, -0.02706002f, 0.00872920f, 
    0.02995599f, 0.03036662f, 0.02101147f, -0.00183930f, 0.00724537f, 0.01987442f, 0.01142873f, -0.00475407f, 
    0.01139912f, -0.03116568f, -0.00651138f, -0.00552310f, 0.00618472f, -0.00489148f, -0.03787887f, 0.02117253f, 
    0.00733462f, 0.00827421f, 0.00353058f, 0.00423053f, 0.02192882f, 0.02784895f, 0.00216247f, -0.01854734f, 
    -0.03676721f, 0.00446447f, -0.00269144f, 0.02741038f, 0.02383951f, -0.03523950f, 0.01896642f, 0.01471622f, 
    -0.00143020f, 0.00124785f, -0.03026398f, -0.02306125f, -0.01341822f, 0.03954324f, -0.01951394f, -0.00702949f, 
    -0.02412990f, 0.02618430f, -0.03403201f, -0.03599589f, 0.01010467f, 0.02495743f, 0.01679445f, 0.02724124f, 
    -0.06554683f, 0.06598009f, 0.08560596f, 0.02971996f, 0.02474192f, -0.11122479f, 0.13034140f, 0.01014147f, 
    0.00097784f, 0.00900335f, -0.07379001f, 0.01555095f, 0.04030265f, -0.02169649f, -0.07517838f, 0.14982282f, 
    0.00392542f, -0.01103653f, -0.02010260f, 0.00278001f, -0.02296928f, -0.01525553f, -0.00878152f, 0.03827947f, 
    0.10828115f, 0.15901591f, -0.05185661f, -0.04576908f, -0.08853415f, 0.09914982f, -0.13927996f, 0.11875825f, 
    -0.07112639f, 0.03944189f, 0.06576148f, 0.04731585f, 0.35103375f, 0.20195691f, -0.00667000f, -0.24931760f, 
    -0.05920609f, 0.14774910f, 0.03087294f, -0.03520958f, -0.02619699f, -0.07750306f, 0.02964599f, 0.10320341f, 
    0.25134930f, 0.08094427f, -0.06826897f, -0.01277916f, -0.00394527f, 0.03668370f, -0.04987736f, 0.04051073f, 
    -0.10113925f, -0.02825647f, 0.05203739f, 0.04868777f, -0.08106025f, -0.10962661f, 0.00097867f, 0.11300647f, 
    -0.05646501f, 0.03532536f, -0.01532469f, -0.02865241f, 0.03450228f, 0.06775502f, 0.04333653f, -0.16732423f, 
    0.09140038f, -0.10424413f, -0.11656705f, 0.05072236f, -0.05931015f, 0.15073268f, -0.07460224f, 0.03030236f, 
    0.00965246f, -0.01722643f, 0.13031395f, -0.02925657f, 0.20745632f, 0.02559581f, -0.08424142f, -0.17790547f, 
    0.09136325f, 0.02451772f, 0.00457656f, 0.11675498f, 0.02806828f, -0.18182188f, -0.14693975f, -0.07620021f, 
    -0.02302775f, -0.04403448f, 0.02864506f, 0.03261214f, 0.06133757f, -0.12318101f, 0.05806868f, -0.02091197f, 
    0.02163937f, 0.05133072f, 0.11040171f, -0.04517568f, -0.17535661f, -0.14085013f, -0.03307648f, -0.03080096f, 
    -0.08213393f, 0.05882192f, 0.04019447f, -0.14727381f, -0.07967400f, -0.02653170f, -0.01283237f, 0.01212222f, 
    -0.01040882f, -0.09601311f, 0.19922280f, 0.11787861f, -0.11033712f, 0.10577407f, 0.11654343f, 0.01158378f, 
    -0.07877767f, 0.05343113f, 0.01911819f, 0.07670702f, 0.02274823f, -0.04982572f, 0.04210543f, 0.03299515f, 
    0.05160480f, -0.05051034f, -0.04459477f, 0.02112683f, 0.01173433f, -0.11966599f, 0.04661443f, 0.03945287f, 
    0.01420880f, -0.11699001f, -0.11068083f, 0.01067656f, 0.07962282f, -0.01518359f, -0.13089241f, -0.24840392f, 
    -0.11527828f, -0.01881564f, 0.02812941f, 0.04678873f, -0.10072552f, -0.05188525f, 0.01247475f, 0.14738162f, 
    -0.04908113f, -0.05941754f, -0.09821189f, -0.06132922f, 0.02692146f, 0.03082418f, -0.04327917f, -0.04675426f, 
    0.16599825f, 0.08537653f, 0.17028295f, -0.10635260f, 0.10212290f, -0.02052061f, -0.00375594f, 0.20755157f, 
    0.09067995f, -0.07040353f, 0.05463395f, 0.03718559f, 0.20661604f, 0.01406338f, 0.02313821f, -0.09303763f, 
    0.01991392f, -0.02234562f, -0.15252437f, -0.01544800f, -0.04094912f, -0.02948427f, -0.02838532f, 0.05538601f, 
    0.05870539f, -0.08652857f, -0.12249620f, -0.07764912f, 0.02139444f, -0.04944370f, -0.04612278f, 0.00184010f, 
    0.06906511f, 0.14686160f, 0.00340243f, 0.03782050f, -0.15149619f, 0.06262116f, 0.02594154f, -0.01229254f, 
    0.01496047f, -0.05962369f, -0.03058547f, 0.05615935f, 0.00690371f, -0.02023047f, -0.09177704f, 0.04732751f, 
    0.25236344f, -0.06334498f, -0.01566375f, -0.19492172f, -0.04198200f, -0.11260487f, -0.00583286f, -0.02830135f, 
    -0.00211875f, 0.06779617f, -0.05570687f, 0.19849063f, -0.12083368f, -0.00330350f, -0.02733642f, 0.11645468f, 
    -0.00391583f, 0.11813668f, 0.09448820f, 0.02838429f, -0.02878212f, 0.19081752f, 0.20464617f, 0.14776771f, 
    0.11907658f, 0.02217196f, -0.19801664f, 0.07427291f, 0.18742891f, -0.01858537f, 0.02840614f, 0.11085981f, 
    -0.02581580f, 0.06688974f, 0.05882486f, 0.06030871f, 0.24023019f, -0.11666472f, 0.07082906f, -0.17523508f, 
    0.05639438f, 0.08008134f, 0.04759637f, 0.06068447f, -0.07047992f, 0.07570946f, 0.05804737f, 0.01170501f, 
    -0.09363513f, -0.18074179f, -0.02718598f, 0.02901428f, -0.10650991f, -0.06453022f, 0.01347149f, -0.21010210f, 
    -0.12345129f, -0.00333486f, 0.03609988f, -0.08638145f, 0.17582323f, 0.07576656f, -0.10903512f, 0.09844753f, 
    -0.07925422f, -0.07621279f, -0.11011114f, 0.02803408f, 0.02492302f, 0.04734462f, 0.03642736f, -0.03593728f, 
    0.06563803f, 0.01451225f, -0.12879503f, 0.27681971f, 0.02816498f, 0.01089490f, 0.01689157f, 0.14825797f, 
    0.02511833f, 0.07760234f, -0.08410176f, 0.02207958f, 0.09374972f, 0.09600730f, -0.03796011f, -0.36600190f, 
    0.14587933f, -0.10215409f, -0.00316548f, -0.17665085f, 0.01218929f, 0.18655579f, 0.04513226f, 0.09604774f, 
    -0.17559986f, -0.00787061f, -0.16846924f, -0.02574920f, 0.00004908f, 0.03967508f, -0.07341591f, 0.11089274f, 
    0.08689670f, 0.12008952f, -0.06988148f, 0.10739753f, -0.15541111f, 0.08410594f, -0.22023262f, -0.00772024f, 
    0.03781473f, 0.21753521f, 0.11611475f, 0.00478372f, -0.00955607f, -0.04151281f, 0.02167967f, -0.01855638f, 
    0.20520486f, -0.02107384f, 0.01623637f, -0.02598276f, 0.17366146f, -0.00779034f, 0.05360851f, 0.07816028f, 
    0.01246029f, 0.02151613f, 0.06211618f, -0.00792730f, -0.12066106f, 0.07104312f, 0.09689322f, 0.18760660f, 
    0.01808108f, -0.02833975f, -0.15432578f, 0.02180370f, 0.08985451f, -0.09491310f, -0.05744478f, -0.15169746f, 
    0.15954906f, 0.03819171f, 0.02127665f, -0.11043936f, 0.00315757f, 0.03605635f, -0.05279514f, 0.07912422f, 
    -0.02696979f, -0.06276815f, -0.03167430f, -0.01929596f, 0.06124153f, 0.08712046f, -0.06718431f, -0.13872267f, 
    -0.01664887f, -0.09640840f, 0.08443782f, 0.03184903f, 0.01408478f, -0.00888146f, 0.01613988f, -0.18066758f, 
    -0.05788114f, 0.06831793f, -0.07365141f, 0.01800905f, 0.02904234f, -0.06944860f, -0.06757192f, 0.12577853f, 
    -0.10336903f, -0.06509876f, 0.10963292f, -0.14571902f, 0.43745220f, 0.04807813f, -0.03677098f, -0.10575226f, 
    0.08544900f, -0.01628948f, -0.04312745f, -0.06048691f, -0.08212171f, -0.01660783f, 0.04807133f, 0.00279607f, 
    0.00910862f, 0.22431457f, -0.00876643f, -0.03908491f, -0.00864420f, -0.02821247f, 0.01713711f, 0.16477813f, 
    0.03765449f, 0.09034751f, -0.02794126f, -0.01894222f, -0.02892298f, -0.14368133f, 0.09815010f, -0.16239749f, 
    -0.01249039f, 0.01840224f, 0.01196453f, 0.01173573f, 0.02375564f, 0.05316826f, 0.06027988f, 0.04253512f, 
    -0.30602410f, -0.02420765f, 0.13909152f, -0.10724123f, -0.05163585f, 0.03305884f, -0.07183071f, -0.05216102f, 
    -0.05087192f, -0.06703733f, -0.00500087f, -0.07032085f, -0.06778505f, -0.02601349f, -0.04053773f, 0.04922602f, 
    0.18596917f, 0.00572091f, 0.00341139f, 0.01619198f, 0.01819263f, 0.16174053f, 0.08498946f, -0.08332147f, 
    -0.31386518f, 0.10175493f, 0.24568132f, 0.19872789f, -0.09104255f, 0.08427547f, 0.13358611f, 0.19057472f, 
    -0.01914603f, 0.01815154f, 0.14723198f, 0.17064852f, -0.06961913f, -0.15189615f, 0.21061650f, 0.03813327f, 
    -0.04034764f, 0.04071445f, 0.08304642f, 0.10155868f, 0.00458005f, 0.00255878f, 0.04812224f, 0.06894798f, 
    0.02659171f, -0.15234205f, 0.07069190f, 0.05673820f, 0.06253751f, 0.00009646f, -0.00520969f, 0.10318793f, 
    -0.08290064f, 0.11128197f, -0.03539304f, 0.11717337f, -0.09883443f, 0.05483537f, 0.24685419f, -0.10720626f, 
    -0.13889137f, -0.09065241f, 0.03723543f, -0.00041702f, -0.02930359f, -0.00093051f, -0.04145966f, 0.00525125f, 
    0.00519625f, 0.04480715f, -0.09567351f, 0.24207380f, -0.06952982f, 0.10544385f, -0.02779135f, -0.10103579f, 
    0.07663266f, 0.14915200f, 0.00562141f, 0.06557778f, 0.14010862f, 0.13756277f, -0.00496623f, -0.06755219f, 
    -0.03352533f, -0.07467267f, 0.00437645f, -0.01754738f, 0.05146465f, 0.20235996f, 0.01317739f, 0.12076719f, 
    -0.02589046f, -0.04527441f, -0.11989079f, 0.12942204f, 0.00280613f, -0.04223526f, -0.08393004f, 0.06142857f, 
    -0.10279074f, -0.20400338f, 0.11819821f, -0.03645970f, 0.16940691f, -0.11252286f, 0.04679378f, 0.07365436f, 
    -0.18212815f, -0.04701009f, 0.04199267f, 0.09866409f, -0.03582592f, 0.02896025f, -0.08465391f, -0.19366691f, 
    -0.15519917f, -0.01183874f, 0.20697206f, -0.09523717f, -0.05399882f, 0.00532848f, 0.11300375f, 0.01544279f, 
    0.03600426f, 0.06947553f, 0.06828248f, 0.09216284f, 0.10542680f, 0.07853154f, -0.05819037f, -0.18174227f, 
    -0.01562823f, 0.02815544f, -0.03377173f, 0.10205295f, -0.09776756f, -0.16163032f, 0.11432215f, 0.05780405f, 
    0.16771781f, 0.02129504f, 0.09140033f, -0.05488056f, -0.01216601f, -0.09261153f, 0.02539881f, 0.08081774f, 
    -0.01152246f, 0.02359337f, -0.14944485f, 0.10358391f, 0.02675237f, 0.02930672f, 0.05004324f, 0.02297801f, 
    -0.01350162f, 0.10544768f, 0.05082002f, -0.07732132f, -0.13341163f, 0.06024258f, 0.06248012f, 0.07213080f, 
    0.12505829f, -0.03937823f, 0.00140164f, -0.09839711f, 0.02928503f, 0.02770114f, 0.04182994f, 0.08449251f, 
    0.01922273f, -0.07601278f, -0.02909971f, 0.18876231f, 0.20791629f, 0.20047976f, 0.10094754f, -0.19295903f, 
    0.03769871f, -0.02883231f, -0.00184122f, 0.05120077f, -0.00035170f, -0.02672477f, -0.00131716f, -0.03568793f, 
    0.01652720f, 0.03310636f, 0.08044209f, -0.01787456f, 0.10104037f, 0.05687029f, 0.01883335f, 0.09577585f, 
    0.08075230f, 0.02878520f, -0.01489737f, -0.00440926f, 0.03729916f, -0.00917562f, 0.05153249f, 0.01222418f, 
    0.03789920f, 0.02159616f, -0.00943013f, 0.03330833f, 0.06479886f, -0.30897748f, -0.11324952f, 0.03605494f, 
    -0.07206272f, -0.01941223f, 0.02392959f, 0.05015204f, -0.04166258f, -0.13104954f, 0.11191085f, -0.00659024f, 
    0.03177390f, 0.10063674f, 0.01903793f, 0.01550450f, -0.02911992f, -0.03397587f, 0.14840922f, -0.00997785f, 
    -0.03778178f, 0.03259894f, 0.00234004f, 0.01656932f, 0.06229672f, -0.05911837f, -0.08863440f, -0.07196354f, 
    -0.06766990f, 0.12532847f, -0.16989283f, 0.00844405f, -0.03606457f, -0.05667771f, -0.14906500f, 0.03627475f, 
    -0.04982603f, 0.08243862f, 0.06151295f, 0.13052411f, 0.08726121f, 0.15563802f, -0.09139218f, 0.04945790f, 
    0.10869391f, -0.11780000f, -0.03439573f, 0.17210551f, 0.06715168f, 0.14953268f, -0.05336207f, -0.10422724f, 
    -0.02174267f, 0.00623399f, 0.05990013f, 0.12428525f, 0.03320870f, -0.04592427f, -0.11575005f, -0.02733174f, 
    -0.04140560f, 0.26851529f, 0.00585973f, -0.01396615f, -0.13362959f, -0.00639169f, 0.27217016f, -0.17569944f, 
    0.05276004f, -0.03168488f, -0.04182879f, -0.12192827f, 0.01311904f, -0.02824454f, -0.05520194f, -0.01929239f, 
    0.13672592f, 0.06269138f, -0.05805822f, 0.20153776f, 0.11801983f, -0.09406265f, -0.00094392f, -0.06492360f, 
    -0.06492166f, 0.04097207f, 0.06835495f, 0.08711252f, 0.18714435f, -0.18655261f, -0.07205971f, -0.07628477f, 
    -0.00471411f, -0.09392228f, 0.02620128f, -0.03337606f, -0.07668732f, -0.00714123f, 0.08661784f, -0.06467373f, 
    -0.28602663f, 0.11015023f, -0.03510603f, -0.01651158f, 0.01607775f, 0.02247863f, 0.03381621f, -0.09724627f, 
    -0.10639171f, 0.05091846f, -0.03616196f, -0.03354713f, -0.14694569f, 0.11793511f, 0.01340584f, 0.16295542f, 
    0.06128995f, -0.06095738f, 0.04900612f, -0.04038241f, 0.09618241f, 0.02552919f, -0.05059456f, -0.22279450f, 
    0.01627501f, -0.01505077f, -0.01541132f, -0.00036743f, 0.01601239f, 0.00503992f, 0.00569484f, -0.02095772f, 
    0.00589801f, 0.00601677f, -0.03743460f, 0.01688432f, -0.01102993f, -0.00747319f, 0.01508735f, -0.02828161f, 
    -0.03609311f, -0.03980142f, 0.00598358f, 0.02465218f, -0.00506145f, -0.04015787f, -0.02847244f, -0.02656188f, 
    0.01318182f, 0.02729426f, 0.00314974f, -0.00197046f, -0.02990891f, -0.01938459f, 0.01522683f, -0.02585972f, 
    0.01665617f, 0.02822164f, -0.04497271f, -0.02755808f, 0.01331517f, -0.03430087f, -0.01600474f, -0.00780633f, 
    -0.00315721f, -0.01657128f, -0.00844502f, 0.00512570f, -0.03355495f, -0.01919263f, -0.02520960f, -0.01120220f, 
    0.02304093f, 0.00361501f, -0.00368685f, -0.01082806f, -0.01093235f, -0.02896918f, -0.04302999f, -0.03465278f, 
    0.00513314f, -0.00856457f, -0.00088037f, 0.00477641f, -0.01200699f, -0.04599178f, 0.01023031f, -0.03813826f, 
    -0.00590654f, -0.01460919f, 0.00524094f, -0.04294322f, -0.01215515f, -0.02464675f, -0.00104709f, 0.00193425f, 
    -0.00210533f, -0.04126658f, -0.00616347f, 0.01002755f, -0.01353855f, 0.01287329f, 0.00664715f, -0.00233103f, 
    0.00086253f, -0.03761750f, -0.01507363f, 0.00020599f, 0.03242880f, -0.02873026f, -0.03224615f, -0.00730586f, 
    -0.00847192f, -0.02181420f, -0.04705391f, -0.01049050f, -0.03615228f, -0.02445771f, -0.03147266f, -0.01130108f, 
    0.02796205f, 0.01866343f, -0.01606803f, 0.00878246f, -0.00299249f, 0.02343792f, -0.01547329f, -0.00793459f, 
    -0.00849808f, -0.04451719f, -0.00496164f, -0.01008188f, 0.00401807f, -0.00189101f, -0.00903435f, -0.01852901f, 
    0.02324062f, -0.00333004f, 0.03014056f, 0.01961136f, 0.01947594f, -0.03769635f, -0.01306857f, -0.03236910f, 
    -0.00229747f, -0.03622395f, 0.00060859f, -0.01711550f, 0.01223903f, 0.02035208f, -0.02288873f, 0.00397438f, 
    -0.00039619f, 0.02717076f, -0.04527492f, 0.00670269f, -0.01629013f, 0.02844255f, -0.03397524f, 0.00093711f, 
    0.02820582f, 0.02349180f, -0.01739296f, 0.01379923f, -0.02764423f, 0.00516913f, 0.03060507f, -0.01072746f, 
    0.01037092f, 0.01919493f, 0.00032909f, 0.00749484f, -0.04471628f, -0.01684129f, -0.01516020f, 0.01986716f, 
    -0.00467332f, 0.01406654f, 0.02304931f, 0.03174482f, 0.02389072f, -0.00849247f, 0.00368636f, -0.00910238f, 
    -0.00170585f, 0.00557531f, 0.02666527f, -0.01673776f, 0.01730723f, -0.00207925f, 0.01921561f, -0.03280281f, 
    -0.03138304f, 0.01668982f, -0.01360026f, 0.01110942f, -0.00897942f, 0.01372591f, -0.04110131f, -0.00477861f, 
    -0.03214113f, -0.03064638f, 0.00273482f, 0.02013071f, 0.00810168f, 0.02094053f, -0.00098308f, 0.01487725f, 
    -0.02176122f, 0.01563850f, -0.04454276f, -0.01183114f, 0.01006207f, -0.00402835f, -0.03504631f, -0.00664540f, 
    0.00800678f, 0.01418003f, -0.04108709f, 0.02481791f, 0.02134017f, 0.00850019f, -0.01696522f, 0.00595588f, 
    -0.04124850f, 0.00708903f, 0.00113465f, 0.00706457f, -0.02511433f, -0.01314670f, 0.01653724f, 0.02436274f, 
    0.00543952f, -0.00724969f, -0.00445140f, -0.03107658f, 0.02679361f, -0.00664038f, -0.04238234f, 0.02528441f, 
    -0.00851199f, -0.02126224f, -0.01665293f, -0.04044576f, -0.00210684f, -0.01257817f, -0.00713377f, -0.03212110f, 
    0.01445838f, -0.00212641f, -0.00264237f, -0.01328014f, -0.02548542f, 0.00572677f, 0.00526718f, -0.02164410f, 
    0.00605567f, -0.03265772f, -0.00300842f, 0.00368566f, 0.00804608f, -0.02878999f, -0.03656588f, -0.00854164f, 
    0.00000072f, -0.03410487f, -0.01329055f, -0.01307225f, -0.00860032f, -0.03106541f, -0.01761213f, 0.01856055f, 
    -0.03755503f, -0.01520684f, -0.03981648f, -0.01574566f, -0.00994161f, 0.00802315f, -0.01899895f, -0.00534962f, 
    -0.01265204f, 0.02611246f, 0.02313341f, 0.02004359f, -0.02096662f, -0.00644657f, -0.02987733f, -0.00789628f, 
    -0.01433084f, 0.01076905f, -0.04531220f, 0.03853488f, -0.04191979f, -0.01240040f, 0.02013418f, 0.00284214f, 
    0.00496757f, 0.02063763f, -0.04013643f, 0.00723379f, -0.01769736f, 0.00970177f, 0.00230302f, -0.00608163f, 
    -0.01736572f, -0.00082962f, 0.00562191f, -0.03820172f, 0.01638226f, -0.02971694f, -0.02641339f, -0.02844028f, 
    -0.04224372f, -0.01793193f, -0.01676903f, 0.02630338f, 0.00945817f, -0.00843318f, 0.00366975f, 0.02247687f, 
    -0.00512354f, 0.00784026f, 0.00106044f, 0.01875080f, 0.01399824f, -0.03067858f, 0.02410360f, -0.00005965f, 
    0.00426482f, -0.01818701f, -0.00454529f, -0.01935020f, 0.02523549f, -0.02967059f, -0.04342642f, -0.03758714f, 
    0.02053109f, -0.02273134f, -0.03087158f, 0.02986920f, -0.03244270f, -0.01156543f, 0.02210898f, -0.03846516f, 
    -0.03868866f, -0.02851373f, -0.02308825f, -0.01182274f, -0.02164051f, -0.02845006f, -0.00997902f, 0.00748108f, 
    0.00822401f, -0.01053125f, 0.01947175f, 0.02019995f, 0.01524400f, -0.02405462f, -0.04030280f, -0.02216656f, 
    0.01480254f, 0.01525710f, -0.04435690f, 0.00516994f, 0.00069563f, -0.01592501f, -0.02477992f, -0.03131005f, 
    -0.00960656f, -0.02474120f, 0.01606611f, 0.00845566f, -0.02024440f, -0.00519835f, -0.01475475f, 0.01142792f, 
    0.02510920f, 0.00415448f, -0.03008835f, 0.00177581f, -0.03145215f, -0.00332254f, 0.03525500f, -0.00364192f, 
    -0.01183316f, -0.00152242f, 0.02326543f, -0.02275524f, -0.03470555f, 0.01657986f, 0.00481464f, -0.02497628f, 
    0.01500064f, 0.00788360f, -0.02640808f, -0.02325737f, -0.03432760f, -0.02313932f, 0.02420724f, 0.02154004f, 
    0.00615619f, -0.04191504f, -0.02079271f, -0.01676108f, -0.04428946f, -0.02965205f, -0.03622332f, 0.01280690f, 
    -0.04152285f, 0.02538116f, -0.04202030f, -0.04671564f, 0.00475061f, 0.00938127f, -0.02699510f, -0.00142948f, 
    0.02366675f, -0.02188814f, -0.02648143f, -0.04398170f, 0.02229693f, 0.00972427f, -0.01788877f, 0.02619654f, 
    -0.01357269f, 0.00106916f, -0.02583843f, -0.03699353f, -0.01914254f, -0.02755049f, -0.03571750f, 0.02225756f, 
    0.03282032f, 0.01980127f, 0.02649854f, -0.01832020f, -0.03479431f, -0.01824573f, -0.04159497f, -0.03593256f, 
    0.00146891f, 0.03106436f, 0.00624680f, -0.01204613f, -0.03980154f, -0.00970895f, -0.03416251f, -0.04394770f, 
    -0.02132302f, -0.01294134f, -0.02432116f, -0.02715178f, -0.02142159f, -0.04444389f, -0.00955166f, -0.04227682f, 
    0.01010660f, -0.00457693f, 0.00630368f, 0.00666459f, -0.01034847f, 0.01675262f, 0.02414162f, 0.00481996f, 
    -0.02327527f, 0.00172820f, -0.00267332f, 0.01472003f, -0.03227041f, -0.04291476f, -0.03648381f, -0.02826865f, 
    0.01314524f, 0.00811116f, 0.01217313f, -0.03070460f, 0.01855393f, 0.02307984f, 0.00822264f, 0.01783384f, 
    0.02061212f, 0.01208366f, 0.00033416f, -0.03975406f, -0.03520533f, -0.00998506f, -0.03018877f, 0.01647869f, 
    0.01756252f, 0.00751108f, -0.01029487f, -0.02288343f, -0.00232251f, 0.00375444f, -0.02734554f, 0.02877834f, 
    0.01957691f, -0.02606422f, 0.01553088f, 0.00151099f, -0.02400724f, 0.01216905f, -0.02883848f, -0.02704147f, 
    0.01723843f, -0.02095547f, -0.01684527f, 0.00702639f, -0.01095419f, 0.00555141f, -0.03426692f, 0.00332151f, 
    0.00150100f, 0.00779825f, -0.00566139f, -0.00105244f, 0.03012277f, -0.01852143f, 0.00294312f, -0.03918446f, 
    -0.03158334f, 0.02305857f, 0.01391892f, -0.00465821f, -0.02234472f, -0.02716273f, -0.04310388f, -0.03028151f, 
    0.00642824f, 0.02735262f, -0.00522537f, -0.00690267f, 0.01585216f, -0.00314567f, -0.00313948f, -0.00490904f, 
    0.02406823f, -0.03076133f, -0.03767935f, 0.02584815f, 0.01156240f, 0.03174691f, -0.03246570f, 0.02345605f, 
    -0.03553509f, -0.02121252f, -0.01285547f, -0.03697463f, -0.03346289f, -0.00828906f, 0.02484389f, 0.01638945f, 
    0.02265855f, 0.01182604f, 0.01101025f, -0.01184523f, -0.03615456f, 0.01534664f, 0.02456250f, 0.00090327f, 
    -0.03089507f, -0.04028806f, -0.03055291f, -0.00104029f, -0.01430206f, -0.01210481f, 0.03256555f, 0.01871013f, 
    -0.02644494f, -0.00106778f, 0.00064558f, -0.03183063f, -0.03275343f, -0.02938140f, -0.03976643f, -0.01146423f, 
    -0.02915897f, -0.02868461f, -0.00652684f, -0.00596295f, -0.00054800f, 0.01940012f, -0.02684006f, -0.02868347f, 
    -0.01361689f, -0.01249505f, 0.00920439f, 0.01558916f, 0.01815372f, 0.02354110f, -0.01056730f, 0.00049546f, 
    0.01682859f, 0.01418424f, -0.00832634f, 0.01513752f, -0.03321245f, -0.01176821f, -0.00475508f, -0.01677061f, 
    -0.00945058f, 0.02198044f, -0.00097561f, -0.01106837f, -0.03673088f, 0.02257792f, -0.00891495f, -0.02126863f, 
    -0.02555108f, -0.00944840f, -0.03367634f, -0.03496724f, 0.01674495f, -0.01899584f, -0.01231494f, -0.02082641f, 
    -0.02203718f, 0.03107774f, 0.00165910f, -0.00253842f, -0.03584087f, 0.00576320f, -0.00707214f, 0.01176932f, 
    -0.01992273f, -0.02978411f, -0.03233661f, -0.01040220f, 0.00438794f, -0.03700232f, 0.02402602f, 0.02485875f, 
    0.01916253f, -0.03887710f, 0.01424136f, 0.02838485f, -0.01371256f, 0.00466733f, -0.02137812f, -0.03814396f, 
    -0.03721486f, -0.00216273f, -0.03944234f, 0.02348277f, -0.02131895f, 0.00248801f, -0.03255906f, 0.01649981f, 
    -0.03517267f, -0.01841936f, -0.02479710f, -0.03205674f, 0.01639898f, -0.01951222f, 0.02411042f, -0.01593204f, 
    -0.03444474f, 0.00458355f, 0.02019219f, 0.02178129f, -0.03827143f, -0.00154548f, 0.01563661f, 0.00777555f, 
    -0.04591779f, -0.00086395f, 0.00810089f, 0.02027182f, -0.01768705f, 0.01664272f, 0.02698094f, -0.03427622f, 
    0.01546501f, -0.03935511f, 0.01794615f, 0.00078612f, 0.00181235f, -0.02035936f, 0.00892436f, -0.03024245f, 
    0.02877611f, -0.00138696f, 0.01876847f, 0.01913298f, -0.00651033f, -0.02324228f, 0.02917165f, 0.00165945f, 
    -0.02653844f, -0.02020928f, -0.03115429f, -0.00178774f, 0.01579793f, -0.00310679f, -0.01616174f, 0.00031431f, 
    0.01636100f, -0.01418975f, 0.00352211f, -0.00008718f, -0.03620707f, 0.01375363f, -0.00859044f, -0.01607301f, 
    -0.00481362f, -0.00732468f, 0.02983016f, -0.00504115f, 0.01148286f, 0.02744109f, 0.02681976f, -0.04222433f, 
    0.01106388f, 0.01278150f, 0.01731460f, -0.00319053f, 0.01681397f, -0.02786433f, -0.00459549f, -0.01558782f, 
    -0.02641756f, -0.02873298f, 0.01736799f, 0.00712297f, 0.00559848f, -0.02965026f, 0.01781188f, 0.00518789f, 
    -0.03870701f, -0.02836489f, -0.00575057f, -0.00973853f, 0.02259326f, 0.01509793f, -0.03823164f, 0.03299372f, 
    0.01668408f, -0.02150320f, -0.02771997f, -0.01685799f, -0.00862010f, 0.01345385f, -0.00987683f, -0.03127676f, 
    -0.03991539f, -0.00884376f, -0.00025751f, -0.01435979f, 0.00769478f, 0.01517764f, 0.01710088f, 0.01864169f, 
    -0.01717805f, 0.01418024f, 0.00397804f, -0.00661937f, 0.01963853f, -0.00311612f, -0.00365158f, -0.01873930f, 
    0.02032715f, -0.02797004f, -0.04018209f, -0.00095387f, -0.00749247f, -0.03680013f, -0.04568106f, 0.01770147f, 
    0.00785039f, 0.00120076f, -0.02186928f, -0.03652931f, -0.01098029f, -0.03009901f, 0.00667975f, -0.02467554f, 
    0.00439032f, -0.01026172f, -0.02418118f, -0.00415060f, 0.01830523f, -0.04233700f, -0.01376040f, -0.02590608f, 
    -0.03626332f, -0.00652511f, -0.04000232f, -0.02509608f, -0.00190756f, 0.03152011f, 0.02296097f, -0.01581795f, 
    -0.10884324f, 0.05230672f, -0.06956369f, 0.19789682f, 0.08518191f, 0.06735923f, -0.01245927f, 0.17054456f, 
    -0.10106677f, -0.04328505f, 0.01812632f, 0.00216130f, -0.07598758f, -0.04691808f, -0.18298534f, 0.07782163f, 
    -0.03299296f, -0.01275638f, -0.08363809f, 0.02633769f, 0.02956560f, -0.06847487f, -0.08790148f, 0.00554775f, 
    0.05556380f, 0.17799637f, -0.07696009f, 0.27760765f, -0.07735534f, -0.01234307f, -0.00693119f, -0.05695985f, 
    0.03612132f, -0.03966002f, 0.00579186f, 0.07523469f, -0.52735031f, -0.03663105f, 0.05650049f, -0.02426193f, 
    0.01591374f, 0.02076776f, 0.08339678f, -0.06171650f, -0.01568353f, 0.03653904f, 0.09893997f, -0.03264903f, 
    -0.01891746f, 0.20308515f, -0.15628672f, 0.43812767f, -0.00117614f, 0.04903665f, -0.07625727f, 0.02822812f, 
    0.07840332f, -0.00073665f, -0.05211822f, -0.02818862f, -0.06675861f, -0.12380765f, -0.05602793f, -0.24862325f, 
    0.07705377f, -0.01645400f, -0.13001731f, -0.01002465f, 0.00044759f, -0.02476475f, 0.00986585f, -0.04780998f, 
    0.00490866f, -0.05367287f, 0.17258070f, -0.04997739f, -0.01580372f, -0.04076034f, 0.01749856f, -0.06420876f, 
    0.02358742f, -0.06528875f, 0.05298607f, 0.01043793f, 0.43895125f, 0.08659183f, -0.14602475f, 0.08759429f, 
    -0.08311226f, 0.06968393f, 0.04656320f, 0.04688881f, -0.01088194f, 0.05467427f, 0.03105851f, 0.03497818f, 
    0.16353996f, -0.21920764f, 0.02592240f, 0.15766929f, 0.02698841f, 0.05370965f, -0.09037210f, 0.03772340f, 
    0.04894709f, 0.12122473f, -0.05473372f, 0.18365750f, -0.02329510f, 0.03603783f, 0.00299428f, -0.09909295f, 
    0.00478381f, 0.06916735f, 0.00917133f, -0.04167163f, -0.07280982f, -0.01652000f, -0.10155778f, -0.03119440f, 
    0.12915485f, -0.03129384f, 0.26732045f, -0.19855316f, 0.04595502f, -0.01489710f, 0.00967337f, 0.07065418f, 
    0.04783693f, -0.11106016f, 0.04224676f, 0.02673451f, -0.22814931f, -0.07120571f, 0.16751483f, -0.10918295f, 
    0.04070670f, 0.01541386f, 0.04987394f, -0.00664942f, 0.08156615f, 0.11953714f, 0.04566278f, 0.09668082f, 
    -0.09690533f, -0.03195921f, -0.07724869f, 0.06677539f, -0.04799581f, 0.04690024f, 0.04695720f, -0.07190644f, 
    -0.09291175f, 0.01653219f, -0.07117809f, 0.09750237f, -0.00216034f, -0.03089755f, 0.07606658f, -0.08246196f, 
    0.06847318f, -0.06875732f, -0.02019909f, -0.02463927f, 0.04017821f, -0.07987730f, 0.07305215f, 0.03163325f, 
    -0.02110318f, 0.16234665f, -0.05502611f, -0.08045017f, 0.06343418f, -0.04684964f, 0.02106223f, 0.00052970f, 
    0.03841536f, 0.02986708f, -0.01630005f, -0.01382234f, -0.24917057f, -0.02421169f, 0.04096060f, 0.02598148f, 
    0.05297651f, 0.03068472f, 0.03703089f, -0.02721826f, 0.03818452f, -0.10928015f, 0.12947367f, -0.03115899f, 
    0.14496858f, 0.11279358f, -0.01761186f, 0.15523049f, 0.12519123f, -0.01027948f, -0.01768438f, -0.03354617f, 
    -0.00569012f, -0.07997897f, -0.00602028f, -0.03834051f, 0.20201176f, 0.13931626f, -0.05244705f, 0.10564066f, 
    -0.00108937f, 0.00982981f, 0.05296091f, 0.06935813f, 0.01312736f, 0.03560990f, 0.07612430f, -0.00361012f, 
    0.37635875f, 0.08591546f, -0.00418274f, -0.00144791f, 0.00493359f, 0.08936322f, -0.09282731f, -0.00828061f, 
    0.04119581f, 0.14379397f, 0.08238474f, 0.06646024f, 0.22379386f, -0.13142233f, -0.00238991f, 0.14212139f, 
    -0.05703827f, 0.00899373f, -0.02016995f, 0.03845110f, 0.03057298f, -0.04454323f, -0.08836795f, -0.01366019f, 
    0.16126390f, 0.02633633f, 0.06264105f, 0.09756415f, -0.00361120f, 0.01924078f, -0.06587513f, 0.00413147f, 
    -0.08011711f, 0.10838699f, 0.04174579f, -0.13814959f, -0.28184104f, 0.20640330f, 0.04353349f, -0.02105708f, 
    -0.01074851f, -0.07915871f, 0.12749138f, -0.03067100f, -0.06407595f, -0.11174016f, 0.11115660f, 0.01813086f, 
    -0.06151148f, 0.26196054f, -0.00263336f, -0.01706832f, 0.13321908f, 0.02021672f, 0.02936089f, -0.04862700f, 
    -0.03664930f, 0.04020177f, 0.11221883f, 0.07887574f, 0.31730902f, 0.05645957f, -0.00311924f, 0.13556561f, 
    -0.04102279f, 0.06884658f, -0.06949943f, 0.03341309f, 0.05693150f, 0.06033731f, 0.06059658f, 0.11975824f, 
    0.23085050f, 0.12209489f, 0.10571744f, -0.09287461f, 0.02766120f, 0.03435658f, 0.05198269f, 0.16635057f, 
    0.06755775f, -0.04675421f, -0.04114094f, -0.04622031f, -0.05141101f, 0.03388920f, -0.03512689f, -0.34324175f, 
    0.04666481f, 0.11338245f, -0.04335938f, 0.03423531f, 0.00886531f, 0.00568141f, -0.02246128f, -0.00215376f, 
    0.13903499f, 0.07832687f, 0.07590122f, 0.07109614f, -0.00112086f, 0.05066407f, -0.01810679f, -0.10004296f, 
    -0.02924684f, -0.04069952f, 0.13715658f, -0.08695824f, 0.00927135f, 0.02554090f, -0.11642608f, 0.21063459f, 
    -0.03345183f, 0.01101427f, 0.03760747f, -0.12163547f, -0.01099996f, 0.06273403f, 0.09446187f, 0.10339510f, 
    0.00022174f, 0.02428128f, -0.28122008f, 0.28202549f, -0.06655887f, 0.10068912f, 0.06680979f, -0.10879794f, 
    0.01278115f, 0.05716032f, -0.05308275f, -0.04999047f, 0.20085178f, -0.17857772f, -0.07413190f, -0.15881944f, 
    0.10094694f, 0.02461933f, -0.03216036f, -0.13255551f, -0.04530258f, -0.01216990f, 0.09754534f, 0.04837563f, 
    0.23305254f, 0.02241739f, -0.00482816f, -0.12339021f, 0.08113704f, -0.03015174f, -0.00114855f, 0.06509177f, 
    0.00565702f, 0.04484462f, -0.01045778f, -0.04193283f, -0.14983669f, -0.17599073f, 0.16553524f, -0.04401205f, 
    -0.02237787f, 0.09918424f, 0.01314225f, 0.14980249f, -0.04338482f, -0.00989432f, -0.03183239f, -0.07263409f, 
    0.03098711f, -0.03413851f, 0.06455483f, 0.14261086f, -0.05099832f, 0.05462985f, -0.02320735f, -0.03761938f, 
    0.00023743f, 0.06965998f, -0.06758309f, 0.07294223f, -0.24940510f, -0.14520676f, -0.18798064f, -0.19013344f, 
    0.13337567f, 0.13470855f, 0.04289919f, 0.06336368f, 0.03384322f, -0.02798910f, 0.03828734f, -0.03289845f, 
    0.16807568f, 0.09324995f, 0.07211408f, -0.14667977f, -0.00028862f, -0.00582826f, 0.05332658f, 0.10643901f, 
    0.06033027f, -0.07130390f, -0.05234081f, -0.06161571f, 0.15699099f, 0.05833980f, 0.08901071f, -0.00316905f, 
    0.07582121f, 0.00857906f, -0.02108391f, -0.09394985f, 0.02299213f, -0.02993593f, -0.04015866f, -0.03940472f, 
    -0.03693146f, -0.06983962f, 0.02108832f, -0.06810816f, 0.08831166f, 0.05464901f, -0.02469886f, 0.03149544f, 
    0.01060805f, -0.01096358f, 0.01142721f, 0.19396450f, 0.21138363f, -0.05075642f, 0.10128977f, 0.12620197f, 
    0.10602000f, 0.07870856f, -0.11695243f, -0.09478988f, 0.05704674f, -0.01847729f, -0.06546113f, 0.02662724f, 
    0.41302261f, 0.08611378f, 0.01830585f, -0.26044279f, 0.09517335f, 0.03034401f, -0.01160901f, 0.06129160f, 
    -0.00880068f, 0.05753321f, -0.14429197f, -0.14867829f, -0.09235393f, 0.07906307f, 0.08694630f, -0.05418240f, 
    0.02024053f, -0.07142250f, -0.04045978f, 0.02366484f, 0.10768910f, 0.00401936f, -0.04567915f, 0.02452582f, 
    -0.01821694f, 0.10462274f, 0.13429531f, -0.18461441f, 0.11911081f, 0.08977105f, 0.07488492f, 0.13190137f, 
    0.04536399f, 0.02870779f, 0.01120285f, 0.04246351f, -0.14217748f, -0.02557287f, 0.20566754f, -0.30362564f, 
    0.02083579f, -0.03768335f, 0.02325468f, -0.00021581f, 0.01987733f, 0.08164097f, 0.01587806f, -0.00007717f, 
    -0.04462305f, 0.05040709f, 0.01432577f, 0.15302855f, -0.12928064f, -0.09623105f, -0.01324279f, -0.01511594f, 
    0.00956546f, -0.02391754f, 0.02462916f, -0.10091937f, -0.03881018f, 0.00094645f, -0.01338779f, -0.04720556f, 
    0.01317538f, -0.03539543f, -0.06606228f, 0.03094664f, 0.00746598f, -0.16554324f, 0.02731370f, -0.06000264f, 
    0.25162372f, 0.01803238f, 0.05005898f, -0.05225317f, 0.04022289f, 0.10139942f, -0.04481999f, -0.00537031f, 
    -0.03911455f, 0.08696628f, -0.02301199f, 0.10209744f, -0.00443118f, 0.00435168f, 0.21961053f, -0.07286204f, 
    -0.05911027f, -0.05473136f, 0.01847306f, 0.03940063f, -0.00527082f, 0.01539804f, 0.13207784f, 0.10530542f, 
    -0.06814912f, -0.04690691f, -0.07472102f, -0.09802505f, -0.07385480f, -0.05097346f, 0.13015929f, -0.04408551f, 
    -0.06686465f, -0.05498884f, -0.00850481f, -0.10482683f, -0.21923009f, 0.05648843f, 0.05810775f, -0.05327303f, 
    0.01527494f, -0.08554786f, 0.01280276f, 0.01160749f, -0.03923035f, 0.16009405f, -0.10937975f, 0.02321312f, 
    0.50609809f, 0.02062645f, -0.02714748f, -0.04735096f, 0.10649627f, 0.00369787f, -0.02007874f, 0.00814483f, 
    0.06055892f, 0.01805246f, 0.04925241f, -0.01617712f, 0.15670381f, -0.16466706f, -0.03230686f, 0.18714963f, 
    0.05239046f, -0.02680261f, -0.01865161f, 0.00426772f, 0.04967995f, 0.11954894f, -0.01875925f, 0.08545924f, 
    -0.01072964f, 0.15417126f, 0.00288550f, 0.35928032f, 0.05894918f, -0.10565609f, 0.06658079f, -0.05412762f, 
    -0.01048072f, 0.08507004f, -0.02567288f, 0.04351870f, -0.28999123f, -0.10726646f, 0.06111008f, -0.14898336f, 
    0.04594327f, -0.05105434f, -0.04882783f, 0.01925690f, 0.02221941f, 0.06049591f, -0.03005769f, 0.00360914f, 
    0.44902363f, 0.10891671f, -0.00000477f, 0.04353942f, 0.08979037f, -0.00316451f, 0.04271946f, 0.08625329f, 
    0.04352278f, -0.01954151f, -0.03391344f, -0.01745288f, 0.10798302f, 0.03338442f, -0.07819840f, -0.07883284f, 
    0.04931274f, 0.09214862f, 0.06415660f, 0.00483928f, 0.05297461f, 0.12386180f, -0.00403113f, 0.00647220f, 
    0.15872988f, -0.18008818f, 0.04005324f, -0.01668951f, -0.05864297f, 0.04109598f, 0.06775281f, 0.00809095f, 
    0.00312464f, 0.11638890f, -0.13312569f, -0.07037067f, 0.09016653f, -0.04005528f, -0.02073132f, 0.00528920f, 
    0.10125824f, 0.01021146f, 0.04190972f, 0.07444674f, -0.05351627f, 0.07727328f, 0.04916815f, 0.04476715f, 
    0.22431746f, -0.15394051f, -0.04947318f, 0.09503867f, -0.07139026f, 0.08793885f, -0.01194739f, -0.09825074f, 
    0.06997590f, -0.07388724f, -0.05624424f, 0.05549688f, 0.00327888f, 0.06317671f, -0.02952683f, 0.09615221f, 
    -0.02095287f, 0.02641976f, -0.00799076f, -0.05741573f, 0.12905541f, -0.04527096f, 0.09015798f, -0.06937694f, 
    0.28524134f, -0.06296276f, -0.01828599f, 0.15172839f, -0.13498491f, 0.00567842f, -0.00465948f, -0.00050947f, 
    -0.11047204f, 0.00402448f, 0.08463614f, -0.18755926f, -0.16322914f, 0.13709669f, -0.08748718f, -0.38706860f, 
    0.03724359f, 0.00207903f, 0.03381487f, 0.01786946f, 0.04025203f, 0.05008800f, 0.06753209f, 0.00731105f, 
    0.02071162f, -0.26160958f, -0.04905364f, 0.11390210f, -0.03481023f, -0.00696825f, -0.06608340f, -0.01813701f, 
    -0.08942219f, 0.07972538f, 0.11510369f, 0.04996995f, 0.04681660f, -0.19495156f, -0.03522977f, -0.26617229f, 
    0.13358034f, 0.02649776f, -0.07237168f, 0.03126130f, 0.00603793f, 0.06773362f, 0.07303710f, 0.01949484f, 
    0.25375047f, -0.01985882f, 0.00287352f, 0.08261210f, 0.06073096f, -0.07372805f, -0.02694147f, 0.02312176f, 
    0.00033131f, -0.03250346f, -0.01919638f, -0.02638601f, 0.12850428f, 0.14507185f, -0.15360384f, -0.16342984f, 
    -0.07630891f, 0.02604651f, -0.00500121f, 0.05296551f, -0.00921363f, 0.14115028f, 0.10186531f, -0.00913353f, 
    0.08110706f, -0.02220499f, -0.10049368f, 0.06017805f, 0.12135856f, 0.00270543f, 0.03957071f, 0.00313821f, 
    -0.00437618f, 0.02776939f, -0.01584403f, -0.06833840f, 0.31991392f, 0.11636169f, 0.05355523f, 0.15353251f, 
    -0.02952006f, -0.02121267f, -0.03530033f, 0.02933815f, 0.05848679f, -0.01364903f, -0.05981396f, 0.09524581f, 
    -0.36168650f, 0.15609770f, -0.15383327f, 0.15127499f, 0.02600966f, 0.02177217f, 0.02986921f, 0.05138103f, 
    -0.00647548f, -0.04691013f, 0.10181834f, 0.04593176f, -0.20023064f, -0.21779037f, 0.24643190f, 0.11732771f, 
    -0.16659719f, 0.06142776f, -0.03928808f, 0.04783636f, 0.00640113f, 0.02002059f, 0.10886697f, 0.04274155f, 
    -0.17422889f, 0.10404266f, -0.08267663f, 0.11308963f, 0.11786231f, 0.01599301f, 0.00560376f, 0.01843167f, 
    -0.04800814f, 0.07332563f, 0.03388870f, 0.05759544f, 0.04543224f, 0.07924117f, 0.10711147f, 0.11393064f, 
    0.08948140f, 0.07900335f, 0.03577663f, 0.00946323f, 0.08556671f, 0.04466715f, 0.07774311f, 0.13515806f, 
    0.19976160f, 0.02055542f, 0.11351541f, 0.12421320f, -0.00098672f, -0.03101145f, -0.00977452f, 0.00070350f, 
    -0.00165470f, -0.07898576f, 0.07304086f, 0.11393033f, 0.05911556f, 0.28988424f, 0.00577175f, -0.03517908f, 
    0.07270255f, 0.05502109f, 0.05185696f, 0.01305823f, -0.02597076f, 0.07364911f, 0.03395444f, 0.05948804f, 
    -0.36202550f, 0.01389649f, -0.10470363f, 0.01326667f, 0.02554095f, 0.08374656f, 0.01601752f, 0.01066651f, 
    0.03300305f, 0.00185166f, -0.07903913f, 0.09362008f, 0.31413987f, 0.04772247f, 0.12931861f, 0.12969998f, 
    0.00085094f, -0.04979946f, -0.03533256f, 0.05589610f, 0.10612816f, -0.07261220f, -0.03842631f, 0.03789024f, 
    0.18180530f, -0.05299908f, 0.15827048f, -0.02242162f, 0.01758881f, -0.03662330f, 0.06714937f, 0.07872372f, 
    -0.05940777f, 0.03683830f, 0.01144589f, 0.01550853f, -0.04761580f, -0.32695308f, -0.05652100f, -0.21951897f, 
    -0.01997970f, 0.02608266f, 0.02013210f, 0.09007406f, 0.01493849f, -0.01668508f, -0.08690891f, 0.00388356f, 
    0.26030791f, 0.01732245f, 0.18032885f, 0.20928147f, -0.07989584f, 0.04233990f, 0.05436982f, 0.04801900f, 
    -0.01456729f, -0.05762640f, 0.00239256f, 0.06328768f, 0.33247143f, 0.10719339f, 0.18336581f, 0.11462980f, 
    -0.01999707f, -0.05838830f, 0.02037838f, 0.03635968f, 0.16735955f, -0.10283523f, -0.03938213f, 0.02780648f, 
    -0.26678944f, -0.22058447f, -0.03782836f, -0.18138206f, 0.02295803f, 0.04950743f, -0.00752571f, -0.03213068f, 
    0.03509376f, 0.05810926f, 0.00842645f, 0.00942023f, 0.06313927f, 0.15401432f, 0.12111096f, 0.03248562f, 
    0.00130296f, 0.01876310f, -0.00942823f, 0.00769721f, 0.05762990f, 0.03116594f, -0.03077715f, -0.04100339f, 
    0.04188904f, 0.07113430f, 0.09633434f, 0.07640729f, 0.01230850f, 0.05846357f, 0.04174906f, 0.05770930f, 
    0.01293158f, -0.01611146f, 0.08670857f, 0.03285016f, -0.04825173f, 0.05431623f, -0.05826997f, 0.18416525f, 
    0.14749530f, 0.11526870f, 0.07468197f, -0.00726334f, 0.04718299f, 0.05464125f, 0.04011937f, 0.01678717f, 
    -0.19644561f, 0.04843863f, -0.02194245f, 0.00850071f, -0.01873628f, 0.04478314f, 0.12818582f, 0.12264136f, 
    -0.06297814f, -0.06681143f, -0.03678944f, 0.01114020f, -0.29472613f, 0.11332979f, -0.11654873f, 0.09654143f, 
    0.12813863f, 0.06445928f, 0.08412037f, -0.02371515f, 0.08577420f, 0.03761847f, 0.11055329f, 0.06645817f, 
    -0.02147090f, 0.10138638f, 0.05651969f, 0.03549482f, 0.03774253f, -0.00456704f, 0.01100886f, 0.05627118f, 
    0.01911165f, 0.11317709f, 0.07205971f, 0.05594606f, 0.32966569f, -0.00820380f, 0.15729247f, -0.26736385f, 
    -0.13640580f, 0.11323443f, 0.08682680f, 0.08288259f, 0.01999491f, -0.04137249f, 0.11514997f, -0.09222053f, 
    0.27060330f, -0.03184431f, 0.14218695f, 0.13206351f, -0.02951456f, 0.01092407f, -0.02896747f, 0.04905030f, 
    -0.03209265f, 0.00583136f, 0.03569683f, -0.00565681f, -0.43525696f, 0.15121101f, -0.21427187f, 0.00923680f, 
    0.03713518f, 0.00234119f, 0.01099491f, 0.07689717f, 0.00934485f, -0.05692317f, -0.12724103f, -0.03099375f, 
    0.02597748f, -0.12419208f, -0.27566651f, -0.04784014f, 0.07486402f, -0.09912640f, 0.02884216f, 0.09963036f, 
    0.12727244f, 0.06124087f, 0.09685571f, 0.04863187f, -0.02003658f, 0.00323804f, -0.04473926f, -0.00876603f, 
    -0.08519980f, 0.12539519f, 0.02555189f, 0.08582632f, -0.00273285f, 0.02944665f, 0.15304188f, 0.08643135f, 
    0.09390376f, 0.11578971f, 0.00105888f, 0.00936735f, 0.09712065f, 0.05262836f, 0.06640100f, 0.10938898f, 
    0.07339304f, 0.04959303f, 0.07617715f, 0.10077641f, -0.04549952f, 0.12518172f, 0.05784952f, 0.03879671f, 
    0.16610137f, 0.07726628f, 0.07390650f, 0.04821478f, 0.13206416f, -0.00777841f, 0.05328036f, 0.19700316f, 
    -0.30949453f, 0.12081248f, -0.10846217f, 0.07089708f, 0.05597983f, 0.05526867f, 0.07468448f, 0.06429779f, 
    -0.01846077f, 0.06918672f, 0.06784270f, 0.04157409f, -0.37910756f, 0.05668348f, 0.04385796f, 0.06704307f, 
    0.08526557f, -0.01758838f, -0.01546937f, 0.06087929f, 0.00736817f, -0.02053288f, -0.05167664f, 0.04448200f, 
    -0.09367476f, -0.26131007f, -0.09271506f, -0.16965632f, 0.12069372f, 0.06937974f, 0.00325234f, 0.07341529f, 
    0.08656108f, 0.03438653f, 0.02651160f, -0.00558982f, 0.09605555f, -0.06293022f, 0.19202700f, 0.01947634f, 
    0.04898071f, -0.00678513f, 0.07488797f, 0.04089671f, 0.06134022f, 0.07862812f, -0.04409799f, -0.02009323f, 
    0.31773707f, 0.11074961f, 0.04799974f, 0.08436933f, 0.01939154f, 0.03372642f, -0.01810515f, 0.02215292f, 
    -0.04169474f, 0.06148859f, -0.07182014f, -0.02633458f, -0.04262265f, -0.00549939f, -0.03835388f, 0.02865433f, 
    -0.11774354f, -0.01091721f, -0.01200447f, 0.17328754f, 0.09557499f, 0.09804823f, 0.09658561f, 0.04086694f, 
    -0.17970902f, -0.24769126f, 0.05249458f, -0.12477144f, 0.12733351f, 0.03790362f, 0.12137369f, 0.03487634f, 
    0.14859615f, 0.11979499f, 0.05113187f, 0.11197165f, 0.44424102f, 0.12555525f, 0.11853761f, 0.04560813f, 
    -0.03012714f, -0.11180650f, -0.06936582f, -0.01611999f, -0.00639820f, -0.00414469f, 0.05209959f, 0.05258053f, 
    0.32857814f, 0.27424613f, 0.11744495f, 0.11306224f, -0.00378761f, -0.02225615f, 0.01005003f, 0.03419159f, 
    0.07839116f, 0.10393875f, 0.10406660f, -0.00021515f, 0.00916059f, 0.13522488f, -0.03691177f, 0.09951147f, 
    0.12249810f, 0.02406204f, 0.02141615f, 0.03036158f, 0.05931266f, 0.08601637f, 0.04248681f, -0.02932641f, 
    -0.04246999f, -0.25084445f, -0.16381553f, -0.07411113f, 0.14663285f, 0.04861856f, 0.04055458f, 0.07864417f, 
    -0.01184638f, 0.10308751f, 0.09002006f, 0.19641569f, 0.05593060f, -0.14141507f, -0.10822298f, 0.10888854f, 
    0.13666227f, 0.01236132f, 0.04019821f, 0.02073623f, -0.02387770f, 0.04247209f, 0.05761807f, 0.07425708f, 
    0.04349366f, -0.27100390f, -0.04330730f, -0.12740859f, 0.00048870f, 0.04238144f, -0.02740700f, 0.09353057f, 
    0.03625139f, -0.04502812f, -0.04993014f, 0.05708988f, 0.20527062f, 0.01839062f, 0.14760956f, 0.01608136f, 
    0.01779645f, 0.08393544f, 0.01561481f, 0.00486193f, -0.01077518f, 0.04159812f, -0.00771796f, 0.05689713f, 
    0.24461041f, 0.12284642f, 0.02527186f, 0.08823705f, 0.04349254f, 0.08005236f, 0.09386904f, 0.09198603f, 
    0.06892014f, -0.01478618f, 0.05284052f, 0.08334000f, -0.07508191f, -0.00583523f, 0.01895927f, 0.13186106f, 
    0.14691202f, -0.00689994f, -0.02452962f, 0.04434559f, -0.00531386f, -0.07675897f, 0.04358144f, 0.09263236f, 
    0.04841438f, -0.01664688f, -0.13669202f, 0.01338870f, 0.10809929f, 0.05652704f, 0.00671194f, 0.01252093f, 
    -0.01368038f, -0.01708562f, -0.06568939f, -0.04738493f, 0.23648258f, 0.03986089f, -0.00123576f, 0.04798178f, 
    0.01440362f, -0.05459921f, 0.00706259f, 0.06986362f, 0.06588014f, 0.12676258f, -0.03191949f, 0.07923222f, 
    -0.06963231f, -0.05814733f, -0.07486170f, -0.00308647f, -0.02742156f, 0.07838706f, -0.00283544f, 0.18198372f, 
    -0.03309773f, 0.00492736f, 0.12426956f, -0.02258928f, 0.03939254f, -0.01239972f, -0.00464249f, 0.09426390f, 
    -0.01274611f, 0.09746183f, -0.03451870f, 0.08222260f, -0.11274265f, 0.04867094f, -0.00532163f, -0.02557708f, 
    -0.23800321f, 0.09305128f, -0.16103521f, -0.06515995f, 0.12052155f, -0.03766212f, -0.01886417f, 0.09102856f, 
    0.04005637f, -0.06678296f, 0.09360927f, 0.03012287f, -0.13115516f, 0.05403393f, -0.02993514f, 0.02763532f, 
    0.08698287f, 0.05747337f, 0.12006986f, 0.01431121f, 0.07306871f, 0.02909630f, -0.00896095f, 0.01969060f, 
    -0.15762873f, 0.01979550f, -0.00274319f, 0.09599440f, 0.04927823f, 0.16049390f, 0.03647825f, 0.03258398f, 
    0.04030792f, 0.01900009f, 0.03018566f, 0.04164994f, -0.05451893f, -0.19085650f, 0.16246620f, 0.01671200f, 
    -0.01120647f, 0.09226138f, 0.02893769f, 0.06460420f, 0.01665825f, 0.01299250f, 0.03419747f, -0.02972608f, 
    -0.25336510f, -0.10568783f, -0.25637674f, -0.04733919f, 0.08197327f, 0.12960586f, 0.01963550f, 0.07071706f, 
    0.08390456f, 0.04115846f, 0.02256579f, 0.08390994f, 0.00016877f, 0.07161687f, 0.07558466f, 0.16554472f, 
    0.12508558f, 0.01141054f, 0.06550773f, 0.07350034f, 0.03985475f, 0.10266878f, 0.03638322f, 0.09970079f, 
    -0.35522845f, -0.00191112f, 0.06698439f, 0.10287434f, 0.06843624f, -0.07516437f, 0.10573478f, 0.10271496f, 
    0.10344428f, 0.09220771f, 0.08174419f, 0.01052127f, -0.04716391f, -0.15756682f, -0.16054788f, 0.14551276f, 
    0.06367272f, 0.01061337f, 0.05025607f, 0.09851174f, -0.03338665f, 0.02472983f, 0.05065149f, 0.04498226f, 
    -0.06123773f, 0.07969356f, 0.13139550f, 0.17038457f, 0.01510316f, -0.06005410f, 0.03963325f, 0.03576012f, 
    -0.05290988f, -0.05126074f, 0.03322842f, 0.16775790f, -0.26242742f, 0.16685912f, 0.00250281f, 0.07217544f, 
    -0.03609814f, -0.00004827f, -0.02631850f, 0.09704282f, -0.02061164f, -0.05289020f, 0.05126989f, 0.14949487f, 
    -0.52033371f, -0.02423709f, -0.20962206f, 0.17353341f, 0.24640366f, -0.03013594f, -0.05068232f, 0.09927124f, 
    0.02199679f, -0.07093612f, 0.13401163f, 0.00134676f, -0.25136337f, -0.03579549f, 0.10079758f, 0.07894313f, 
    -0.14023538f, 0.05694136f, 0.02243256f, 0.01196889f, -0.03192220f, 0.01119219f, 0.06207000f, 0.06830387f, 
    0.11537433f, 0.15842265f, -0.04301492f, -0.00698952f, 0.05809699f, 0.04403543f, 0.00746020f, -0.07523146f, 
    -0.01511502f, 0.06396274f, 0.01460473f, 0.03456041f, -0.08992811f, 0.04785146f, 0.08167221f, -0.25763047f, 
    -0.01138902f, -0.01489484f, 0.03770642f, 0.09931081f, -0.00125579f, 0.03771441f, 0.09947884f, -0.10469162f, 
    0.19503325f, 0.01608180f, -0.07443498f, 0.02151546f, 0.06143434f, 0.04134772f, -0.00900694f, 0.07268356f, 
    0.06395223f, -0.01049731f, -0.03039444f, 0.02486118f, -0.09272556f, 0.06306002f, 0.09286292f, 0.08430047f, 
    0.05825112f, -0.02104567f, -0.00882464f, 0.08607960f, 0.03638368f, 0.02301526f, -0.01066072f, 0.03131935f, 
    0.03791315f, -0.01735049f, -0.06276821f, 0.08063945f, 0.08004478f, 0.00474902f, -0.05855337f, 0.17511930f, 
    0.03597366f, 0.03127793f, 0.00164573f, -0.02919021f, 0.35285881f, 0.12585193f, 0.04473028f, 0.11653098f, 
    0.01567168f, 0.01104849f, -0.02197764f, 0.07352536f, 0.08364952f, 0.06153921f, -0.01407142f, -0.00378128f, 
    -0.26856625f, 0.07129596f, -0.07835912f, -0.00893956f, -0.00797914f, 0.00766204f, 0.09537245f, 0.03420317f, 
    -0.07143533f, 0.02847400f, 0.02453151f, 0.01839021f, -0.14296120f, -0.04556751f, -0.13529725f, -0.18774346f, 
    0.06434491f, -0.01118756f, 0.03991578f, -0.06922810f, 0.05344542f, 0.09122621f, 0.01462164f, 0.04996090f, 
    -0.20825888f, 0.01948236f, -0.08151548f, 0.01570218f, -0.02268352f, -0.04710623f, 0.03375446f, -0.08374117f, 
    0.00328587f, 0.04271066f, 0.04191655f, 0.17629385f, -0.15559343f, -0.06086746f, 0.10709629f, -0.06452256f, 
    0.05753376f, -0.06843441f, 0.00935454f, 0.00890110f, 0.03858964f, 0.12897445f, -0.05339362f, 0.07962796f, 
    0.01795428f, 0.02672104f, 0.10053448f, 0.07720885f, -0.04471254f, -0.02329206f, 0.06197071f, 0.06172754f, 
    -0.00989143f, 0.10488215f, 0.05654797f, 0.08940020f, 0.11452878f, -0.05156148f, -0.14983706f, -0.11358184f, 
    -0.01638538f, 0.01767743f, -0.00616259f, 0.04179036f, -0.02400738f, 0.05167417f, -0.00269953f, -0.10698492f, 
    0.12073151f, -0.07366836f, -0.05711252f, 0.20540725f, -0.00330993f, 0.08441012f, 0.06864059f, 0.15233569f, 
    0.10970214f, 0.03491924f, -0.06423429f, 0.12893282f, 0.13787882f, 0.10450083f, 0.15230405f, 0.09810673f, 
    0.03637608f, -0.02234061f, -0.02308555f, 0.03219917f, 0.21297073f, 0.06497103f, -0.01728734f, 0.06153329f, 
    0.12331247f, -0.14755443f, -0.05046253f, -0.05230799f, 0.03715023f, 0.03848015f, 0.09936567f, -0.02368987f, 
    -0.06086604f, -0.13062839f, 0.12238179f, -0.01234354f, -0.04165322f, -0.19006298f, 0.02097763f, -0.07717982f, 
    -0.08880673f, 0.00931527f, -0.04584739f, 0.02941063f, 0.01149993f, 0.05390970f, 0.02481186f, 0.05669563f, 
    0.09177572f, 0.13806267f, 0.19407929f, 0.21829993f, -0.03723009f, -0.02030045f, 0.11387142f, 0.04859535f, 
    0.04313051f, 0.01163735f, 0.06578625f, 0.00008026f, 0.06497956f, 0.10765842f, 0.28850323f, -0.01180307f, 
    0.07432643f, 0.03727798f, 0.04346672f, 0.10135411f, 0.08177929f, 0.05111124f, 0.03528172f, 0.04597650f, 
    -0.01261862f, -0.12798536f, 0.05125393f, 0.07642071f, -0.00889426f, 0.01598266f, 0.01693339f, 0.05269830f, 
    -0.04355207f, 0.09940848f, -0.01364094f, 0.05546252f, 0.04345614f, -0.04649050f, 0.03083912f, 0.04194037f, 
    0.01454177f, -0.01690485f, -0.04668754f, 0.00240761f, 0.10160121f, 0.02624502f, -0.00833567f, 0.04854844f, 
    0.04605755f, 0.08788528f, 0.11981110f, 0.12017698f, 0.03774649f, -0.01646673f, -0.00391397f, 0.10974508f, 
    -0.00984122f, 0.01501788f, 0.11325601f, 0.03461263f, 0.12749672f, -0.06312711f, -0.06773962f, 0.00265553f, 
    -0.02715405f, -0.03724196f, 0.10396513f, 0.02895486f, -0.02699949f, 0.03317623f, -0.02322349f, 0.01548336f, 
    0.05920317f, 0.12572084f, -0.06542968f, 0.12766798f, 0.07300817f, -0.03309793f, -0.04366274f, -0.00960300f, 
    -0.01545376f, 0.00334889f, -0.12888783f, 0.07159594f, -0.03911383f, -0.17293914f, 0.00884898f, 0.19406229f, 
    0.03018120f, 0.05212572f, 0.06874102f, 0.02563352f, 0.09136452f, 0.01807879f, 0.04953671f, 0.09161513f, 
    -0.07977194f, -0.00251877f, 0.02753016f, 0.03847827f, 0.08718553f, -0.00838167f, 0.01900298f, 0.10907537f, 
    0.07727919f, 0.04399505f, 0.09537191f, 0.00263985f, -0.12803036f, 0.04908303f, 0.12857741f, -0.22630399f, 
    -0.09184665f, 0.04707910f, -0.05498622f, -0.07693180f, 0.08916932f, 0.00365688f, 0.09325667f, 0.18887027f, 
    -0.16694751f, -0.05264105f, 0.14325535f, -0.00058262f, 0.04192979f, 0.00319989f, -0.00551780f, 0.00395766f, 
    0.01350877f, 0.12978213f, -0.05509849f, 0.06271400f, 0.08051941f, -0.10806926f, -0.08261680f, 0.09784494f, 
    -0.03275663f, -0.02462306f, 0.01795001f, 0.00377248f, -0.01305850f, -0.04493247f, -0.01179549f, 0.02366294f, 
    -0.19405392f, -0.05574945f, 0.00327287f, 0.06591145f, -0.07498822f, -0.15033561f, 0.04675598f, 0.06120561f, 
    0.09781007f, 0.02878609f, 0.04282486f, -0.01149014f, 0.41826802f, 0.40354139f, -0.29837459f, -0.06420352f, 
    -0.03993391f, 0.03990671f, 0.00300140f, -0.00308104f, -0.15611291f, 0.02127637f, 0.01039500f, 0.08479565f, 
    0.09021297f, -0.00107256f, 0.03770081f, 0.03842250f, -0.20058972f, 0.13539036f, 0.01279435f, 0.07454701f, 
    -0.00797820f, -0.02617117f, 0.08521072f, 0.10297173f, -0.06174581f, -0.08412915f, 0.13732563f, 0.12384789f, 
    -0.04146931f, 0.13125335f, 0.02888899f, 0.03879321f, 0.00608216f, 0.04648937f, -0.03462079f, 0.03654684f, 
    -0.18483931f, -0.12764330f, -0.10111538f, -0.03072016f, 0.01494061f, 0.03152886f, -0.03484153f, -0.03014735f, 
    -0.06140208f, 0.14239071f, -0.11797053f, 0.10079288f, -0.15020034f, 0.01634183f, 0.05365235f, 0.08237878f, 
    -0.06750539f, 0.01968227f, 0.01584316f, -0.04504662f, -0.05804125f, 0.05125884f, -0.04819695f, -0.00258719f, 
    -0.05134698f, -0.15386720f, -0.04147096f, 0.11741706f, -0.04603227f, 0.02132246f, 0.04693846f, 0.09948513f, 
    0.02475624f, 0.08742633f, 0.03926633f, 0.00115280f, -0.07258625f, 0.01426770f, -0.03303878f, -0.03863362f, 
    0.01532467f, 0.04276588f, 0.05982050f, 0.01604625f, -0.00540335f, -0.05235174f, 0.09975719f, 0.01815349f, 
    0.28188390f, 0.12987368f, 0.21341874f, -0.03652757f, 0.00439706f, 0.03227977f, -0.01018800f, 0.02155841f, 
    -0.07125842f, 0.03002333f, 0.06944667f, -0.02324531f, 0.07757176f, 0.16988121f, -0.14785883f, -0.38125578f, 
    0.00091099f, -0.06922527f, 0.10737132f, 0.00855516f, 0.06589285f, 0.09677017f, 0.03994542f, 0.04035506f, 
    -0.25407717f, -0.18322104f, 0.08265996f, 0.12775631f, 0.05043489f, 0.02081400f, 0.06800484f, 0.08822230f, 
    0.02199340f, 0.07867736f, 0.10478807f, 0.07287665f, 0.02880714f, 0.17526016f, 0.12221874f, 0.06517143f, 
    -0.01025313f, -0.04039973f, -0.05135117f, -0.02969367f, 0.00128184f, -0.05315540f, 0.06538319f, 0.07835630f, 
    -0.11356233f, 0.10537954f, 0.05942521f, 0.05775140f, 0.05453432f, -0.00603453f, 0.00642033f, -0.05228243f, 
    0.08009565f, -0.00414786f, -0.01297392f, -0.06101917f, -0.00504081f, -0.10926217f, -0.00709214f, 0.13387825f, 
    0.01254951f, 0.05845004f, 0.02584058f, 0.12253425f, 0.00272798f, -0.00582709f, 0.03618049f, 0.07102852f, 
    -0.15575942f, -0.15429646f, 0.14315853f, 0.00424166f, 0.11379188f, -0.07049517f, 0.00881867f, -0.01180077f, 
    0.03117135f, 0.02368040f, 0.11956278f, -0.01166918f, 0.05014130f, 0.13001645f, 0.03268149f, -0.05019369f, 
    0.02649251f, 0.01965730f, 0.01993782f, -0.01733705f, 0.05751600f, -0.03226890f, -0.00903903f, 0.09526842f, 
    -0.19982934f, -0.23091413f, 0.15668158f, 0.05819109f, -0.13576315f, -0.01739149f, 0.02643134f, -0.00755873f, 
    0.08063524f, 0.08916004f, 0.02905689f, 0.06247699f, 0.04741858f, -0.08511211f, -0.13378894f, -0.05931649f, 
    0.01595390f, 0.03786040f, 0.08814060f, -0.05112148f, 0.05299775f, -0.00789264f, 0.00489754f, -0.01114171f, 
    -0.15676376f, 0.05002810f, 0.11516992f, -0.15015027f, 0.01072276f, 0.00688045f, 0.09153195f, -0.02843094f, 
    0.04553623f, -0.00582808f, -0.04025153f, 0.07355382f, 0.01827506f, -0.15437485f, -0.03790834f, -0.29696757f, 
    -0.05023244f, -0.04602940f, -0.03074044f, 0.11786238f, -0.02641997f, -0.10487884f, 0.00372687f, -0.03621383f, 
    0.15298167f, -0.06488858f, -0.10479457f, 0.05175730f, -0.00219449f, 0.03838813f, -0.04301239f, 0.03291735f, 
    0.10914496f, -0.12862624f, 0.01460572f, -0.02796674f, 0.05749340f, -0.09786938f, 0.04418461f, 0.03745823f, 
    -0.05542063f, -0.07379980f, 0.08546900f, -0.05189444f, 0.06803297f, 0.14680150f, -0.06972360f, 0.10704062f, 
    -0.14777540f, -0.17561263f, 0.06672759f, -0.15736178f, 0.02579956f, 0.09306173f, -0.05423568f, 0.03651049f, 
    0.02706295f, -0.05085199f, 0.05942644f, -0.02104066f, 0.04260339f, -0.16008537f, -0.10237432f, 0.06528755f, 
    -0.06812488f, -0.08317163f, -0.04128683f, 0.01664882f, -0.10655260f, -0.00378544f, -0.00468590f, 0.04351901f, 
    -0.09588559f, -0.07866247f, -0.00175579f, 0.02869863f, -0.03357860f, -0.04863742f, 0.01186309f, 0.06113792f, 
    0.08518364f, 0.03945926f, 0.06130663f, 0.09935232f, 0.09421153f, -0.09803119f, 0.00359307f, 0.22479573f, 
    0.07500456f, 0.12605318f, 0.12385345f, 0.03256138f, 0.03565330f, -0.04488929f, 0.07197083f, 0.13244507f, 
    -0.07668690f, 0.03773456f, 0.06161575f, -0.11457840f, -0.04362055f, -0.02040413f, 0.07814283f, -0.03874677f, 
    -0.04904472f, -0.03848093f, -0.00759561f, 0.16910930f, -0.05959934f, -0.12526426f, -0.15042062f, -0.17236432f, 
    0.07621857f, 0.09947123f, -0.03182280f, -0.01122550f, 0.06476197f, -0.03257427f, 0.07396216f, -0.12086233f, 
    -0.07578576f, -0.08193489f, -0.07828718f, 0.04743082f, -0.07541434f, 0.07108796f, 0.00498780f, 0.02106027f, 
    -0.04178480f, 0.08916923f, -0.05000907f, 0.06489844f, 0.04343943f, 0.12813962f, 0.07150427f, -0.03056241f, 
    0.05433299f, 0.06853180f, 0.03696197f, 0.02277925f, 0.00968765f, 0.09494540f, -0.00214413f, -0.02177269f, 
    -0.04896479f, -0.02752928f, 0.04125378f, -0.09305765f, 0.03908466f, -0.08214565f, 0.03410585f, 0.03715730f, 
    0.10331351f, 0.04382277f, -0.00765107f, -0.06166974f, 0.02998384f, -0.06570501f, -0.08743064f, 0.01002409f, 
    0.06068783f, 0.09438151f, 0.03535228f, 0.02710009f, -0.06386101f, 0.08266281f, 0.04506619f, 0.00712612f, 
    -0.07678380f, -0.01439580f, 0.16304633f, -0.11652449f, 0.09067399f, -0.10211868f, 0.04957391f, 0.03476373f, 
    -0.01838131f, 0.02276111f, 0.09671639f, -0.01177727f, 0.04687234f, -0.00531116f, -0.09307127f, -0.08152065f, 
    -0.08307336f, 0.08008900f, -0.01588237f, -0.01473807f, 0.08663721f, -0.08203962f, 0.03560768f, 0.02145725f, 
    -0.01608914f, 0.04811488f, -0.08311886f, -0.04067579f, 0.07573243f, -0.00461636f, 0.12737824f, 0.08095486f, 
    -0.01508226f, -0.17553103f, 0.01065634f, -0.05793320f, -0.20683166f, 0.08032677f, -0.17287862f, -0.26971549f, 
    -0.04292434f, 0.03701491f, 0.00589343f, -0.02462724f, 0.08647233f, -0.02417648f, 0.00824598f, -0.00129794f, 
    0.15869206f, 0.01950205f, -0.05763942f, 0.15334216f, 0.02191397f, 0.15095945f, -0.06908160f, 0.17329456f, 
    0.01704394f, 0.02548047f, -0.01537325f, -0.10362849f, -0.18067113f, 0.21479250f, -0.22062586f, -0.02928909f, 
    -0.00195258f, -0.04946313f, 0.04373943f, -0.01648010f, 0.00649207f, 0.04575194f, -0.00139181f, -0.06181996f, 
    0.21180959f, -0.02555568f, -0.03158576f, -0.00873867f, 0.01651559f, -0.04151661f, -0.00926890f, 0.08941944f, 
    0.11789846f, -0.08351577f, -0.01592131f, 0.01159627f, -0.04358293f, 0.08365641f, 0.03926152f, -0.11468491f, 
    0.04468116f, 0.01276783f, -0.02561550f, 0.05753907f, 0.08828198f, 0.00433240f, -0.02531304f, -0.03765392f, 
    0.07401850f, 0.08001973f, 0.02335867f, -0.02683216f, -0.08807752f, -0.00622085f, 0.07923190f, -0.15259807f, 
    0.08926258f, 0.03892685f, -0.01225680f, 0.04626334f, -0.40592235f, -0.02748391f, -0.01131157f, -0.38391629f, 
    0.05233728f, 0.02484101f, 0.00476033f, -0.00039290f, -0.03785603f, 0.09028360f, 0.04709109f, 0.02659022f, 
    0.31934604f, -0.06295005f, 0.17535657f, -0.14684142f, 0.14783563f, 0.08355170f, -0.04351738f, 0.06034363f, 
    0.02699802f, 0.02838169f, 0.06834257f, -0.02066658f, 0.38981670f, 0.09024724f, 0.08419796f, 0.20900394f, 
    0.03519861f, 0.12666790f, -0.08169575f, 0.06950907f, -0.00975473f, 0.00141872f, 0.04019922f, 0.08370789f, 
    0.32949376f, -0.09915969f, 0.16421787f, -0.25123543f, 0.07447798f, 0.03867063f, 0.08159339f, 0.02032822f, 
    -0.04592537f, -0.05466970f, 0.12193712f, 0.02941283f, 0.20048442f, 0.17780092f, 0.14878127f, 0.01817495f, 
    -0.05761802f, 0.06887787f, 0.05405403f, 0.04311311f, -0.02419415f, -0.01550864f, 0.11118104f, 0.05646535f, 
    -0.15780617f, 0.02502846f, -0.13824244f, -0.06293055f, 0.05577754f, 0.12003957f, -0.05884268f, 0.04036334f, 
    0.09195703f, 0.05746161f, 0.07381321f, 0.04268571f, -0.06682014f, -0.08331039f, 0.11551395f, -0.05811540f, 
    0.16431922f, 0.02081942f, -0.00647563f, 0.08414304f, 0.03110084f, -0.09279812f, 0.00222333f, -0.00092258f, 
    -0.01670462f, 0.11411549f, 0.01090760f, -0.23808950f, 0.02429763f, -0.06836838f, 0.07372110f, -0.03101996f, 
    -0.07622768f, -0.04194863f, 0.12928128f, -0.12825905f, -0.20928161f, 0.01951466f, -0.01284520f, -0.16323288f, 
    0.00610556f, 0.04518652f, 0.03537639f, -0.03859200f, -0.02633739f, 0.01206051f, 0.08708692f, 0.04414109f, 
    -0.27332875f, 0.08517630f, -0.04616575f, 0.42990717f, 0.04493679f, 0.11924921f, 0.00421126f, -0.06908645f, 
    0.01176464f, 0.11988188f, -0.08989449f, 0.06129237f, 0.17313649f, 0.18505697f, -0.09634817f, 0.29899266f, 
    0.04392072f, 0.04857456f, -0.05512766f, -0.03934940f, -0.07392427f, -0.00842927f, 0.03803882f, -0.02518749f, 
    -0.23583442f, -0.03488376f, -0.07414761f, -0.39071241f, 0.13726971f, -0.03104160f, -0.08458161f, -0.00774509f, 
    0.06626402f, 0.04262155f, 0.08294373f, 0.09905045f, -0.18059206f, 0.08721404f, -0.13031624f, -0.21439266f, 
    -0.06980255f, 0.02471600f, -0.01695087f, -0.03039816f, 0.03522667f, 0.14367953f, -0.00308482f, -0.03562796f, 
    0.02529541f, 0.03744148f, 0.01684065f, 0.06482170f, -0.01406649f, 0.11724278f, 0.02815224f, 0.05427285f, 
    0.02130396f, -0.01462942f, 0.08288043f, 0.02829348f, -0.00852749f, 0.04302240f, -0.07132229f, -0.00489037f, 
    0.06254793f, 0.06692670f, 0.03952267f, 0.08100934f, -0.07005746f, 0.11193159f, 0.06863709f, 0.07640280f, 
    -0.39266235f, -0.07978877f, -0.06431796f, -0.20497300f, -0.00669462f, 0.03471775f, 0.02605259f, -0.01400511f, 
    0.09876409f, 0.06998567f, -0.02062510f, 0.08041943f, -0.11815837f, -0.02930160f, 0.04002275f, 0.07379042f, 
    0.08092519f, 0.01790923f, -0.02814584f, 0.05380557f, 0.03587102f, -0.03742468f, 0.02524813f, -0.03142525f, 
    -0.19275779f, -0.24409840f, 0.08184439f, -0.10398367f, -0.03044410f, -0.08417065f, 0.10052755f, 0.01929876f, 
    0.12058496f, 0.03003246f, -0.00254140f, 0.13779224f, -0.01893804f, 0.12328289f, -0.00375068f, -0.18958400f, 
    -0.02443702f, -0.02130371f, -0.01926875f, 0.06851008f, -0.04816454f, 0.09323110f, 0.10033239f, 0.10364111f, 
    0.00183147f, -0.02603441f, -0.09865885f, -0.16073120f, 0.03228258f, -0.04040645f, 0.10741953f, 0.06638595f, 
    0.10459054f, -0.00792148f, -0.05424848f, 0.17557974f, 0.22826779f, -0.16819623f, 0.10059456f, 0.32373708f, 
    0.10988680f, 0.09584128f, -0.01942565f, 0.07975157f, -0.13669097f, 0.11203004f, -0.07205249f, -0.02069843f, 
    0.03336765f, -0.01168790f, -0.01275317f, -0.05340979f, 0.00829053f, 0.07617197f, 0.01270581f, 0.03866228f, 
    0.03610545f, -0.06304391f, -0.05584785f, -0.06885924f, -0.07267142f, -0.06680316f, -0.01962417f, -0.09653477f, 
    0.03486433f, -0.00522548f, 0.11211943f, 0.03339677f, -0.03449864f, 0.02228095f, 0.10398693f, -0.03442140f, 
    0.07203571f, -0.07275217f, -0.02998001f, 0.09059902f, 0.01398705f, 0.05177799f, 0.02290372f, -0.11126727f, 
    -0.07758877f, 0.10224408f, 0.01158258f, 0.04151706f, -0.25268957f, -0.06469057f, 0.12181423f, 0.18515921f, 
    0.08230393f, -0.05350551f, 0.07179148f, 0.05269310f, 0.03840132f, 0.13738069f, 0.03237578f, 0.11002923f, 
    -0.20978829f, -0.04868210f, -0.09915332f, -0.20589763f, 0.12822311f, -0.10897405f, -0.01092898f, 0.07246293f, 
    -0.03917619f, 0.00000159f, -0.10765492f, -0.00217824f, -0.11926171f, 0.03421106f, -0.06151137f, -0.22154820f, 
    0.06268311f, 0.04412198f, 0.01294581f, 0.00303663f, -0.02983928f, -0.04198778f, -0.02495816f, 0.02542891f, 
    0.36278054f, 0.10826544f, 0.33232710f, -0.20347112f, 0.10351724f, -0.03275263f, 0.00730137f, 0.23399512f, 
    0.09127960f, -0.05081077f, 0.19732113f, -0.03137367f, 0.23313592f, 0.20398119f, -0.03687252f, 0.05556880f, 
    0.02879673f, -0.01167288f, 0.04310208f, 0.13312101f, 0.05957182f, -0.07686290f, 0.02794635f, -0.11485445f, 
    -0.17352732f, -0.08425815f, -0.04995181f, 0.01854024f, -0.00676448f, 0.00510775f, 0.05703581f, -0.03431553f, 
    -0.02942830f, 0.02483839f, -0.02631247f, -0.00001880f, 0.23615356f, 0.04746306f, 0.03222074f, 0.16424470f, 
    0.04533084f, -0.07296583f, 0.05856689f, -0.06152428f, 0.08473694f, 0.02124372f, 0.02763050f, 0.06957755f, 
    -0.41042927f, 0.06102315f, -0.15343560f, -0.22481829f, 0.03345960f, 0.01713108f, 0.03736643f, -0.00927423f, 
    0.09629939f, -0.02217287f, 0.09943446f, -0.03835850f, 0.17873468f, -0.05406143f, 0.12061779f, 0.44167972f, 
    0.03178133f, -0.05712137f, -0.04379160f, -0.07155178f, -0.08696704f, -0.02889132f, 0.04183168f, 0.05353075f, 
    0.01295457f, 0.00416770f, -0.02902779f, -0.01141943f, -0.12925640f, -0.00986936f, -0.02751750f, 0.01896219f, 
    0.00347123f, 0.03063178f, -0.06837443f, 0.00916093f, -0.45796940f, -0.14501151f, -0.00155294f, 0.00224022f, 
    0.06499074f, 0.08378445f, 0.08077647f, -0.01558858f, 0.16943581f, 0.09638831f, 0.04314059f, -0.02521346f, 
    -0.22145651f, -0.20416400f, 0.21029872f, 0.10567786f, 0.00315009f, 0.04763388f, -0.02624453f, -0.05425848f, 
    -0.02577337f, 0.01894487f, -0.03729457f, 0.00414423f, -0.10047474f, 0.11034524f, -0.11178357f, -0.10749376f, 
    0.07909013f, 0.00725112f, 0.05618598f, 0.05786986f, -0.01370794f, 0.05474265f, 0.10585782f, -0.03346941f, 
    -0.21756661f, 0.00431211f, -0.03891808f, 0.27929530f, -0.16178183f, 0.02587315f, 0.08938453f, 0.01252875f, 
    -0.03804963f, -0.06919054f, 0.07357953f, 0.05656776f, -0.00838152f, -0.10904919f, -0.05556185f, 0.09368497f, 
    -0.05449763f, 0.03208509f, -0.03148762f, -0.02236762f, -0.01102537f, 0.07212710f, 0.11451111f, -0.00541097f, 
    0.08595555f, 0.04338772f, -0.17174236f, 0.22517227f, -0.06077173f, 0.05028255f, 0.01124917f, -0.08883258f, 
    -0.04401486f, 0.03782596f, -0.01474312f, 0.01622682f, -0.09960825f, 0.00424747f, 0.03867722f, 0.31936857f, 
    0.10832378f, 0.07289992f, -0.06349095f, 0.09452110f, 0.01004105f, -0.00241247f, 0.00567390f, 0.01611968f, 
    0.10077439f, 0.13077314f, 0.24839517f, -0.15347220f, 0.02445989f, 0.06395523f, 0.01105743f, -0.03166515f, 
    -0.02204647f, 0.13458435f, -0.02633242f, 0.11683936f, 0.01787125f, 0.17277800f, 0.15553114f, 0.31330854f, 
    0.05674322f, 0.01552483f, 0.04868203f, 0.00172470f, -0.00453206f, 0.25262141f, 0.06936713f, 0.11318436f, 
    -0.09459555f, -0.08602507f, 0.06984551f, 0.09593064f, 0.04467013f, -0.12502778f, 0.01001763f, 0.04322354f, 
    0.02997576f, -0.00254929f, 0.15419848f, -0.08010849f, -0.19617574f, 0.09493245f, -0.01809797f, 0.13222602f, 
    0.11773933f, 0.12856245f, -0.04775716f, -0.02364239f, 0.02558455f, -0.05378157f, 0.00614323f, -0.09859867f, 
    0.29142967f, 0.12420575f, 0.15698524f, 0.13586849f, -0.00173136f, -0.01018172f, -0.03804250f, -0.04157332f, 
    -0.00746348f, 0.12233376f, -0.05582270f, 0.21533316f, -0.04740344f, 0.08170836f, 0.00563674f, -0.06597064f, 
    0.08756755f, 0.10705994f, 0.08160410f, 0.08374346f, 0.17253831f, -0.06706399f, 0.15094455f, 0.06729808f, 
    -0.09418768f, -0.11500935f, 0.02953236f, 0.00110296f, -0.08704083f, 0.01481113f, 0.08017918f, -0.00457098f, 
    -0.06910761f, 0.03888766f, 0.01528827f, 0.02901283f, -0.03667039f, 0.02098496f, 0.02701196f, -0.20071767f, 
    0.00187629f, -0.08597548f, -0.11139974f, 0.04872148f, -0.06532035f, 0.04437923f, 0.06366716f, -0.10858343f, 
    0.15695269f, 0.00113307f, -0.08641144f, -0.05600959f, -0.02736608f, 0.12934482f, 0.02191259f, 0.01997337f, 
    0.03197028f, -0.03219584f, 0.13071786f, -0.03882591f, 0.25088406f, 0.12312449f, 0.07393246f, 0.30213171f, 
    0.01042080f, 0.03424940f, -0.01267201f, 0.01541475f, 0.03730751f, 0.00397902f, -0.03941497f, 0.13748780f, 
    -0.11143743f, -0.01715633f, 0.11085002f, 0.03198071f, -0.02039028f, -0.03957836f, 0.05954409f, -0.03048335f, 
    0.00376163f, 0.05783866f, 0.04169348f, 0.01325531f, 0.12104127f, 0.01119469f, 0.02178088f, 0.10207499f, 
    -0.11003723f, -0.02016153f, -0.04367526f, 0.15471546f, 0.05560918f, -0.13941957f, -0.03314085f, -0.04060423f, 
    0.12031168f, 0.18089174f, -0.06541681f, 0.15158476f, 0.01028189f, 0.11891879f, -0.05696649f, -0.00364263f, 
    0.00369632f, -0.08785187f, 0.07599577f, 0.14183173f, -0.04496693f, 0.04798898f, 0.11949863f, -0.00255338f, 
    -0.01299714f, -0.03236696f, -0.00948426f, -0.09741889f, 0.09685559f, -0.04371035f, -0.05079663f, -0.03793148f, 
    -0.04672412f, 0.05989496f, -0.00350528f, -0.17492376f, 0.10431328f, 0.06723315f, -0.04247826f, 0.04034745f, 
    0.06044616f, 0.10051130f, 0.05147501f, 0.09326660f, 0.16211924f, 0.08291843f, 0.02664545f, 0.03862628f, 
    0.06537979f, -0.04014769f, 0.03093527f, 0.07115042f, -0.02442635f, 0.16424285f, -0.03018818f, -0.02249215f, 
    -0.03185124f, -0.00206019f, 0.08836601f, 0.00256586f, -0.01085999f, 0.02966405f, 0.05297419f, 0.03494065f, 
    0.05108650f, 0.22446738f, -0.04524759f, 0.12930915f, 0.28232566f, -0.20718941f, 0.09104615f, 0.26713428f, 
    0.09954897f, -0.01221238f, -0.03803022f, 0.06434163f, -0.03725035f, -0.05414305f, -0.01328504f, 0.03601445f, 
    -0.26008403f, 0.10385134f, 0.05267794f, -0.23982249f, 0.07686640f, -0.04464657f, 0.09808216f, 0.06708587f, 
    0.00918536f, -0.05783064f, 0.03181679f, 0.09310552f, 0.11607626f, -0.10312147f, 0.18953109f, 0.34334192f, 
    -0.08653309f, -0.05326043f, 0.00936012f, -0.00732426f, 0.00871850f, -0.06772768f, 0.01683452f, 0.03551924f, 
    -0.28018847f, 0.11858822f, -0.03770710f, -0.05280107f, 0.05381488f, 0.11321884f, 0.14097525f, -0.11189033f, 
    -0.04660951f, 0.11902671f, 0.04963063f, 0.05872378f, 0.15381740f, 0.10005014f, -0.08672942f, -0.05618335f, 
    0.09185515f, -0.03007251f, 0.07414331f, 0.03500031f, -0.01767960f, -0.07355872f, 0.01552350f, -0.05344466f, 
    0.01640878f, -0.02562073f, -0.03012106f, -0.01461864f, -0.02218197f, 0.00237516f, -0.03447112f, -0.03093606f, 
    -0.01945945f, -0.02949770f, 0.01959233f, 0.02636134f, -0.01351537f, -0.03349870f, -0.03030767f, 0.01538849f, 
    -0.00119331f, 0.01681475f, -0.01089058f, -0.02358486f, -0.00101215f, 0.01196446f, -0.03065543f, 0.00683198f, 
    -0.00207505f, -0.01135993f, 0.01242768f, 0.02771505f, -0.01259741f, 0.01825897f, -0.01921553f, -0.04038294f, 
    -0.03567030f, -0.03561378f, 0.02262197f, 0.01582532f, 0.02772913f, 0.00492164f, -0.02850397f, 0.01206500f, 
    0.00409212f, 0.02032406f, -0.00614372f, 0.00101951f, -0.03426406f, 0.01306687f, 0.01376112f, 0.02936317f, 
    -0.01220065f, 0.00967608f, 0.02215029f, 0.02290838f, 0.00566128f, -0.02985188f, 0.01021019f, 0.01908680f, 
    -0.02695303f, -0.02199031f, 0.01077822f, -0.02003717f, -0.01998850f, 0.01032934f, 0.02609782f, -0.03686496f, 
    0.03791655f, 0.00081384f, 0.03132408f, -0.03318647f, 0.00494927f, -0.03291095f, 0.00879047f, -0.02292832f, 
    -0.01940331f, -0.00774146f, 0.01492750f, -0.00057706f, 0.00981761f, 0.02511997f, 0.00635492f, -0.02162503f, 
    -0.02755228f, 0.02373327f, -0.01521637f, 0.02008702f, 0.00758940f, 0.01156878f, -0.03997989f, 0.03143401f, 
    -0.00763945f, -0.00053525f, 0.01963224f, -0.02925384f, -0.03234667f, -0.01457482f, -0.02727566f, 0.01335928f, 
    -0.01512732f, 0.00336694f, 0.00642862f, 0.01620041f, 0.01039562f, -0.00620691f, -0.02349678f, -0.03054366f, 
    -0.02761550f, 0.02140871f, 0.02652582f, -0.00817837f, -0.00074594f, -0.00283148f, 0.02148480f, -0.01276981f, 
    -0.01628974f, -0.00819780f, 0.00085658f, 0.02912597f, -0.02359026f, 0.00103813f, -0.02797121f, -0.03517290f, 
    -0.03569864f, 0.02829752f, -0.02204698f, -0.02290275f, -0.03721113f, 0.01497974f, -0.02761891f, 0.00622003f, 
    -0.01659191f, -0.01004696f, -0.03586821f, 0.01572274f, -0.01649770f, -0.02790574f, -0.01838842f, -0.01802082f, 
    0.02916502f, 0.00488104f, 0.02803412f, 0.01397035f, 0.00146629f, -0.00955553f, -0.01562519f, -0.03524801f, 
    0.00876064f, -0.02942296f, -0.03599252f, -0.02244596f, -0.00429942f, -0.01547068f, 0.00943113f, 0.01991215f, 
    0.02535845f, -0.01466530f, -0.03889955f, 0.03914053f, -0.03268347f, 0.00617256f, -0.00334607f, 0.02890426f, 
    -0.02265845f, -0.00102016f, 0.00753739f, 0.01624688f, -0.02347432f, -0.00474985f, 0.02280996f, -0.01548296f, 
    -0.00938500f, 0.02176782f, -0.00474661f, 0.02068464f, -0.01791932f, -0.04099137f, -0.01293432f, -0.02983360f, 
    0.00730783f, -0.02662340f, -0.03117916f, -0.03116948f, -0.00502186f, 0.00331457f, -0.03390217f, 0.02550314f, 
    -0.01460594f, -0.01378218f, -0.01409138f, 0.03599058f, -0.04176757f, 0.01685306f, 0.00543714f, -0.02878522f, 
    -0.01771548f, 0.02350510f, 0.02150786f, -0.00638012f, 0.02528153f, -0.03702063f, 0.02684730f, -0.01188798f, 
    -0.02641916f, -0.02345606f, -0.02527677f, -0.00920827f, 0.02864200f, -0.03378674f, -0.01174502f, -0.03778229f, 
    -0.02427186f, -0.03327226f, -0.04152762f, 0.03897351f, -0.01029949f, -0.02804348f, -0.02622051f, -0.01499709f, 
    -0.00176461f, 0.02619219f, 0.00204323f, -0.02771586f, -0.02365398f, -0.03870370f, -0.03048743f, 0.01223105f, 
    -0.02301981f, -0.02836869f, -0.00636782f, -0.02090995f, -0.01505995f, -0.00371320f, 0.02874546f, -0.03949343f, 
    -0.00850018f, -0.02061061f, -0.00632874f, -0.00066929f, 0.00214533f, -0.02479083f, -0.02987967f, -0.02181775f, 
    0.02040151f, 0.02592064f, 0.02559702f, 0.00137622f, 0.01365927f, -0.00155776f, 0.01712148f, 0.00589813f, 
    -0.01384259f, -0.02192487f, -0.04161928f, -0.03877456f, -0.01296146f, 0.02660693f, 0.00131180f, -0.00544090f, 
    0.00911129f, -0.00244738f, -0.03955080f, 0.00532911f, -0.01325480f, 0.01752662f, 0.02778961f, -0.03878485f, 
    -0.00340725f, -0.01189056f, -0.02232559f, -0.02999294f, -0.02758401f, 0.02340335f, -0.00867084f, -0.02988831f, 
    0.02512872f, -0.01226121f, 0.00355025f, -0.02720355f, 0.00241691f, 0.00963566f, -0.00080670f, -0.00956008f, 
    -0.03547713f, 0.02835239f, -0.00974847f, 0.00332281f, -0.02857410f, 0.02027076f, -0.00501098f, 0.03666224f, 
    0.02319540f, 0.03178580f, 0.02812818f, 0.02275721f, 0.00629918f, 0.02479335f, -0.01231191f, 0.01413207f, 
    -0.02662412f, 0.02493034f, 0.02708454f, -0.01325325f, -0.02613606f, 0.02885040f, 0.01211766f, 0.00914106f, 
    -0.01837585f, 0.00225401f, 0.01130120f, -0.00814203f, -0.01447014f, -0.03292260f, -0.04124188f, 0.00703328f, 
    0.02423723f, 0.00926329f, -0.00915075f, 0.02218718f, -0.00059521f, -0.00914337f, 0.00932935f, -0.04118640f, 
    -0.02882424f, 0.01606416f, -0.03830403f, -0.02094174f, 0.00011259f, 0.01715137f, 0.01330157f, 0.02242435f, 
    0.01464954f, -0.00541573f, -0.04192520f, 0.02560674f, 0.04167556f, 0.00761335f, 0.01818914f, 0.02176081f, 
    0.01963057f, -0.03340115f, -0.01291347f, 0.03809622f, 0.00729733f, -0.00560551f, 0.00582557f, -0.01807590f, 
    -0.01570513f, -0.02703248f, -0.02341243f, 0.02496509f, 0.00802831f, -0.00990396f, -0.00267852f, -0.01284638f, 
    -0.00508343f, -0.01473712f, 0.01906682f, -0.01614084f, -0.00610970f, 0.00808254f, -0.01697222f, 0.00446082f, 
    0.01647799f, 0.01713618f, 0.00729217f, 0.00974286f, -0.02674364f, 0.01123433f, -0.02854358f, -0.01160719f, 
    0.01145286f, -0.01837023f, -0.00585564f, -0.01444826f, -0.02227701f, -0.04140566f, -0.00251377f, 0.01443674f, 
    -0.02224832f, 0.02949301f, 0.01112383f, 0.02341831f, 0.00599488f, -0.02139216f, -0.00213327f, -0.01371957f, 
    -0.03048273f, -0.03396789f, -0.03701110f, -0.00764602f, -0.00015917f, 0.03365012f, -0.03370148f, 0.00205201f, 
    -0.01008406f, 0.00262233f, -0.02872540f, 0.00272679f, 0.00635715f, 0.00542561f, 0.01998012f, 0.02451005f, 
    -0.02113654f, -0.01515202f, -0.00307403f, 0.01566306f, 0.00000777f, 0.01645145f, -0.03642551f, -0.02893071f, 
    0.00714560f, -0.00111279f, -0.01215879f, -0.01827957f, -0.02999334f, 0.02132715f, -0.00008028f, -0.04029801f, 
    -0.04132632f, -0.00723223f, 0.01491256f, -0.03605012f, -0.01616421f, 0.00837189f, 0.02800549f, -0.02727582f, 
    -0.04023886f, 0.00947806f, -0.02357254f, 0.02949576f, -0.00651442f, -0.01822227f, 0.00455883f, -0.00260869f, 
    -0.03735967f, -0.01057260f, -0.00995873f, 0.02988763f, -0.01758322f, -0.00497718f, -0.02562465f, -0.01269572f, 
    -0.01874219f, 0.01480799f, -0.03234626f, 0.02283726f, 0.01091119f, 0.01230774f, -0.00921959f, -0.02555056f, 
    -0.01266872f, 0.03102279f, -0.02957917f, -0.02484647f, -0.02447294f, -0.01650971f, -0.00669058f, -0.00348245f, 
    -0.00164978f, -0.02266565f, 0.01267371f, 0.00654313f, -0.01480390f, -0.00569746f, -0.00976035f, 0.00815728f, 
    0.00152573f, 0.01810404f, 0.02615573f, 0.01987216f, 0.02179067f, 0.01038100f, 0.01531423f, 0.00253580f, 
    -0.03120486f, 0.02956028f, -0.01065386f, -0.01994040f, -0.00610780f, -0.04015646f, -0.02186586f, -0.02974137f, 
    0.00696272f, -0.03648626f, 0.01625104f, -0.01732878f, -0.04174053f, 0.04137619f, -0.00362610f, 0.03520325f, 
    0.00043167f, -0.03803594f, -0.02827221f, 0.01009273f, -0.01526048f, -0.02138547f, -0.02298789f, 0.02863180f, 
    -0.01109278f, 0.02750327f, 0.01887849f, -0.00866635f, -0.01848870f, 0.00623718f, 0.02906831f, 0.01027442f, 
    0.00704919f, 0.00857253f, 0.01628077f, -0.04147062f, -0.01128129f, 0.00622640f, 0.02963724f, -0.01527863f, 
    -0.02590475f, -0.03220820f, 0.00439550f, 0.02373045f, 0.00183044f, -0.04105468f, -0.01601128f, -0.03240189f, 
    0.02114017f, -0.00672583f, 0.01251711f, -0.00252024f, -0.00968383f, 0.00313236f, 0.01037902f, 0.02934847f, 
    0.01779407f, 0.00687202f, -0.03916825f, 0.02777484f, 0.02745239f, 0.00311354f, 0.02038235f, -0.02650690f, 
    -0.04174463f, 0.01618169f, 0.00327267f, -0.03890814f, -0.03403262f, -0.02410455f, 0.03366739f, 0.01900957f, 
    -0.01663414f, 0.02143981f, 0.01468516f, 0.00510324f, 0.01325706f, -0.03360508f, 0.03081409f, -0.02721138f, 
    0.00490424f, -0.03485574f, 0.01249801f, -0.02796778f, -0.01558055f, -0.00693027f, -0.03812315f, -0.00063604f, 
    -0.01287511f, -0.04016757f, -0.00560262f, -0.01172656f, 0.00969211f, -0.03277317f, -0.01370907f, -0.01291890f, 
    0.00597082f, -0.01193393f, -0.03630470f, 0.02960293f, -0.00305225f, -0.00607255f, -0.01378154f, 0.00568790f, 
    0.01838091f, 0.01831896f, 0.02812798f, -0.01352645f, 0.00243863f, 0.01128482f, -0.00526357f, -0.02054074f, 
    0.01100345f, -0.00731058f, -0.00953973f, 0.01438628f, 0.01778615f, 0.00374493f, 0.02112322f, 0.01013468f, 
    0.01094128f, -0.02805809f, -0.02732913f, 0.01991194f, 0.02472469f, 0.02142021f, -0.02828088f, 0.00689751f, 
    0.02283249f, 0.00726679f, 0.00048721f, 0.02380957f, -0.02097660f, 0.02938103f, -0.01203048f, 0.00103018f, 
    -0.01836189f, -0.01272280f, -0.02106025f, 0.02259866f, -0.00800843f, 0.03001539f, -0.01889143f, 0.02837840f, 
    0.02855736f, -0.00986348f, -0.03762725f, -0.00308653f, 0.01326020f, 0.02286093f, -0.03371040f, -0.02229253f, 
    0.02649863f, 0.00333533f, -0.00389792f, -0.02591595f, 0.02263704f, -0.02584020f, -0.02137867f, -0.00785381f, 
    0.00138514f, -0.02471902f, 0.00753133f, -0.02599886f, 0.01865901f, 0.01533535f, -0.00484555f, 0.01492361f, 
    0.02413634f, -0.00063510f, 0.01803005f, -0.01750989f, -0.04082853f, -0.02838376f, 0.01612040f, 0.01943949f, 
    -0.03765875f, 0.00580586f, 0.03959256f, -0.04020584f, -0.01980333f, -0.02096927f, -0.02343140f, 0.01801613f, 
    0.02805906f, 0.01350785f, 0.00258925f, -0.01155778f, -0.02873864f, 0.01554994f, -0.02721898f, 0.00170899f, 
    -0.02715374f, -0.00915785f, -0.02437843f, -0.02701188f, 0.01539364f, -0.02208354f, 0.03749624f, -0.00432451f, 
    -0.00647322f, 0.02263068f, -0.03741115f, 0.02464745f, -0.01009554f, -0.01954781f, 0.00516256f, -0.02639867f, 
    -0.01231457f, 0.01793031f, -0.02750430f, -0.01772821f, 0.02520179f, -0.02921918f, 0.00157546f, 0.00111336f, 
    -0.01473846f, -0.00260898f, -0.00258581f, 0.01856974f, 0.01249473f, 0.02900603f, 0.02335831f, -0.01492523f, 
    -0.00591951f, -0.02704052f, 0.01934684f, -0.01162690f, 0.00935743f, -0.03169701f, -0.01439495f, 0.03743590f, 
    0.00637273f, -0.00228818f, -0.02069228f, -0.02023613f, -0.03970544f, 0.01431709f, -0.00659839f, -0.03547687f, 
    -0.01844534f, 0.02364175f, -0.01099897f, -0.03576362f, -0.01954390f, -0.02870746f, -0.02521878f, 0.01079894f, 
    0.02579469f, 0.02265307f, -0.04087834f, -0.03618683f, 0.01139234f, -0.01815878f, 0.01918708f, 0.01902871f, 
    -0.00156292f, 0.01292002f, 0.00104781f, -0.02831599f, -0.01262091f, -0.00966353f, -0.03603492f, 0.00496627f, 
    0.04199440f, 0.02514947f, -0.01818030f, 0.02167453f, 0.01462030f, 0.01712959f, 0.00146013f, 0.00381398f, 
    -0.01975053f, 0.01731571f, -0.03826873f, 0.00137888f, -0.01101811f, 0.02409958f, -0.04114586f, -0.00568598f, 
    -0.01149164f, -0.01871303f, 0.01540976f, 0.02169466f, -0.00375182f, 0.02976491f, -0.02766284f, 0.00094749f, 
    0.01277928f, -0.03975008f, -0.00593549f, -0.02971764f, -0.01002261f, 0.01661461f, -0.01194219f, -0.00603438f, 
    0.01501206f, -0.01271566f, -0.02439157f, -0.01664236f, 0.02549632f, 0.02093489f, -0.00654875f, -0.01016747f, 
    -0.01432812f, 0.00819115f, 0.00047034f, -0.02082588f, 0.01218290f, 0.01285710f, -0.01522537f, 0.01301937f, 
    0.03785809f, 0.02999241f, -0.01979122f, -0.02246572f, 0.02913846f, -0.02287132f, -0.03401675f, -0.03553868f, 
    0.01729175f, -0.01532428f, -0.03369945f, -0.00217244f, 0.01103006f, -0.02292865f, -0.01746753f, -0.03383261f, 
    -0.01201743f, -0.00367879f, 0.02657815f, 0.01524498f, -0.00090322f, -0.02080955f, -0.01197569f, -0.00030846f, 
    -0.03163612f, -0.00690985f, -0.01068825f, 0.00885526f, 0.03215260f, 0.00398332f, 0.01413353f, -0.01213470f, 
    0.02629938f, 0.02727165f, -0.02068516f, -0.02726144f, -0.02660886f, -0.00957260f, 0.00244523f, -0.00538187f, 
    0.01521068f, -0.01913484f, 0.00072104f, 0.01662015f, -0.02588487f, -0.01677213f, -0.03451325f, -0.01561831f, 
    0.03526726f, 0.03306681f, -0.03462408f, -0.01863223f, -0.01325047f, -0.01667095f, 0.01707415f, 0.02426513f, 
    -0.03050319f, 0.00960502f, 0.00635359f, -0.02211585f, 0.03281627f, 0.02416549f, -0.00612430f, 0.03176593f, 
    -0.02283819f, 0.01244146f, -0.02502253f, -0.01299930f, -0.03489648f, 0.00929093f, -0.02141745f, -0.00068110f, 
    0.00716545f, -0.00593721f, -0.04294986f, -0.02184012f, 0.00708506f, -0.01007454f, -0.01411640f, 0.01133267f, 
    -0.00524125f, 0.00518240f, -0.02943061f, -0.00726634f, -0.03110070f, -0.01742667f, -0.02306090f, -0.00107014f, 
    -0.03568928f, -0.01134922f, -0.02552988f, 0.03391818f, -0.02895431f, 0.02547272f, -0.00022796f, 0.00088316f, 
    -0.00859312f, 0.03360875f, -0.00081911f, -0.01730393f, 0.00476638f, -0.02510105f, -0.01253581f, 0.00201644f, 
    0.00582338f, 0.01612958f, -0.03844390f, -0.01468276f, 0.02530348f, -0.02796701f, 0.01613929f, -0.00281306f, 
    -0.01651409f, 0.01015476f, 0.00451901f, 0.01440864f, 0.02995982f, 0.01646781f, -0.02945170f, -0.02838134f, 
    0.03395624f, -0.02625526f, 0.01562163f, 0.00686766f, -0.00989740f, -0.02393856f, -0.00310867f, -0.01915795f, 
    -0.02849669f, -0.02275867f, 0.02651734f, -0.02962209f, 0.03269947f, -0.02089927f, -0.00476191f, 0.03564656f, 
    -0.02866831f, 0.02704682f, -0.03760314f, -0.04307336f, -0.03601311f, 0.02936094f, -0.00665859f, -0.01774452f, 
    -0.02004648f, -0.01227562f, -0.03149923f, 0.01448867f, -0.01266321f, 0.01316276f, 0.02915404f, 0.01196473f, 
    -0.02397528f, 0.01094859f, 0.01733815f, -0.00043053f, -0.02219238f, -0.01438359f, -0.01292466f, 0.00004061f, 
    -0.00005012f, -0.01773972f, -0.00497074f, -0.01667095f, -0.02781758f, 0.00411816f, -0.03013676f, 0.00813467f, 
    0.01797309f, -0.02149880f, -0.02405911f, -0.01493237f, 0.01360978f, -0.01277128f, 0.02997815f, 0.02729941f, 
    -0.02853754f, -0.00677383f, -0.02669991f, 0.00690177f, -0.01729192f, -0.00541810f, -0.00565178f, 0.01713979f, 
    0.02633146f, -0.01787303f, -0.02779459f, -0.02035251f, 0.02748064f, -0.03365090f, 0.00842676f, 0.00048034f, 
    -0.01818406f, 0.02369885f, 0.02626803f, 0.01553852f, 0.02104271f, 0.02300426f, -0.02850919f, 0.00429089f, 
    0.02667837f, -0.03186708f, 0.02360643f, 0.00321735f, 0.02342262f, -0.00257656f, -0.00465356f, 0.02148833f, 
    -0.01065746f, -0.03561525f, -0.01046343f, 0.01198077f, 0.02580986f, -0.02923446f, 0.02681978f, -0.03485767f, 
    -0.04101036f, 0.00312430f, 0.00412326f, -0.03021227f, 0.00249589f, 0.02018928f, 0.00155084f, -0.02111878f, 
    0.02707806f, -0.03118364f, -0.01555098f, -0.03819243f, 0.01913097f, -0.03372777f, 0.02379109f, -0.00556727f, 
    -0.01406878f, 0.01660886f, -0.00877922f, 0.00792264f, -0.01257982f, -0.03342978f, 0.02771933f, -0.02358864f, 
    -0.03668277f, 0.01438830f, 0.02401149f, -0.01562450f, 0.02697923f, 0.01888550f, 0.01683192f, 0.00665475f, 
    0.00347213f, 0.02894488f, -0.03770244f, 0.01733040f, -0.02566800f, 0.01777513f, 0.00471136f, -0.00865363f, 
    -0.01705880f, -0.02734065f, 0.00129682f, -0.00049150f, -0.01455391f, -0.00518309f, 0.01501959f, -0.02570304f, 
    -0.02395278f, 0.01817795f, 0.02629604f, 0.01875614f, 0.02727942f, -0.00202611f, 0.01029442f, 0.01365308f, 
    -0.00500175f, 0.00011625f, 0.02806986f, 0.01860442f, 0.00514996f, 0.00630205f, 0.00195806f, 0.00732344f, 
    -0.02018999f, -0.03272797f, 0.01020203f, 0.02288526f, -0.02877216f, 0.01394011f, -0.01472912f, 0.00771568f, 
    0.01628130f, 0.00382475f, 0.00378321f, 0.00650193f, 0.00591997f, 0.02418097f, -0.03011630f, -0.03208797f, 
    -0.01853155f, -0.00402362f, 0.02279904f, -0.00274468f, 0.01848286f, 0.02669619f, -0.02638871f, 0.00255647f, 
    -0.02692270f, -0.02533739f, 0.00221520f, 0.00752189f, -0.01160267f, 0.00002369f, -0.00522978f, -0.00124954f, 
    -0.03124393f, -0.02635706f, -0.00047360f, -0.03112855f, -0.03796396f, -0.01100637f, -0.02501173f, -0.00400740f, 
    0.02681587f, -0.00891044f, 0.01824309f, -0.01992456f, 0.02046889f, 0.01369344f, -0.03572725f, -0.02125270f, 
    0.01031561f, 0.00352070f, -0.02028598f, -0.00704827f, 0.03302239f, -0.01032553f, -0.02736753f, 0.02091372f, 
    -0.04158162f, -0.02152905f, -0.02625767f, -0.00699516f, 0.03693301f, -0.00542081f, 0.01606706f, -0.00501010f, 
    0.01849440f, -0.00936000f, 0.01269027f, -0.03716430f, -0.00785875f, -0.02982195f, -0.00978471f, 0.00597565f, 
    0.00485858f, 0.02074336f, 0.03469229f, -0.00388100f, -0.02091078f, 0.03229788f, -0.00429233f, 0.00505076f, 
    -0.01233203f, -0.01765272f, 0.00446692f, -0.01728762f, -0.00279313f, 0.02910436f, -0.02899066f, 0.02429483f, 
    -0.01145552f, -0.03326589f, 0.00030890f, 0.02813252f, -0.02601538f, -0.00467406f, 0.00695106f, -0.01522635f, 
    -0.01526395f, -0.02331256f, -0.01703730f, -0.00220240f, -0.04470707f, -0.00101132f, -0.02127785f, 0.00090645f, 
    -0.01589419f, 0.02481950f, 0.01532480f, -0.02591026f, -0.02414971f, -0.00207223f, 0.03451234f, 0.00093426f, 
    -0.00901149f, -0.00545767f, 0.02705093f, -0.00811284f, 0.02786049f, 0.01796216f, 0.01678840f, -0.03522024f, 
    -0.03084781f, -0.00158104f, -0.02135202f, 0.02314083f, 0.02508260f, 0.00935453f, -0.03370677f, -0.01699357f, 
    0.03247029f, 0.01795605f, 0.01450919f, 0.02864247f, -0.00770551f, 0.01172278f, 0.00350631f, -0.00511448f, 
    -0.01349913f, 0.00962154f, -0.02452452f, -0.00715622f, -0.00498987f, -0.02354707f, 0.02416265f, 0.01985352f, 
    -0.00905761f, -0.00829532f, -0.01675446f, 0.02797203f, -0.01889865f, -0.03289795f, -0.01059695f, 0.01378254f, 
    -0.01130662f, -0.02117106f, -0.01216251f, -0.01149476f, -0.00225306f, -0.02358281f, 0.00039416f, -0.02687046f, 
    0.03183365f, -0.01601788f, -0.02181775f, -0.02764687f, -0.03694304f, 0.01353921f, 0.02354246f, 0.00429819f, 
    0.02966828f, -0.03172956f, -0.03532709f, 0.01910404f, 0.02083867f, 0.01702223f, 0.02124616f, 0.01587547f, 
    0.01057281f, 0.01743045f, 0.00941550f, 0.01495954f, 0.02052041f, 0.01130640f, -0.03595992f, -0.00028653f, 
    0.01321201f, -0.03030168f, -0.03817733f, -0.00596620f, -0.03196698f, -0.01450388f, -0.02736067f, 0.02304845f, 
    0.02209525f, -0.03662595f, -0.01175435f, 0.03021042f, 0.03096672f, -0.01808524f, 0.03054232f, -0.00820627f, 
    -0.03622567f, 0.02862725f, -0.03526320f, -0.00013990f, -0.00041021f, 0.00903282f, 0.03316100f, -0.00324119f, 
    -0.00364760f, 0.01862022f, -0.03805326f, 0.02328852f, -0.00525830f, -0.02936591f, -0.01104088f, -0.02276470f, 
    -0.03393346f, -0.00388708f, -0.01615808f, -0.02122806f, -0.03825953f, -0.02314042f, -0.02184869f, 0.00034508f, 
    0.01768419f, -0.01926634f, -0.00622257f, -0.03286460f, -0.03261499f, -0.03823972f, -0.00991682f, -0.03821874f, 
    0.00491430f, 0.03035258f, 0.00968774f, 0.00092107f, -0.00057312f, 0.01346769f, -0.01654426f, 0.02536264f, 
    0.00674708f, -0.01956661f, 0.00328353f, -0.01262764f, -0.03786496f, -0.01791088f, -0.01381085f, 0.00129025f, 
    -0.00965408f, -0.02401316f, -0.01464481f, -0.00765926f, 0.03169771f, -0.00378202f, 0.01975352f, 0.03655316f, 
    0.00530122f, 0.01467233f, -0.02251480f, -0.03830335f, 0.02621669f, 0.03063203f, -0.01231616f, 0.00492644f, 
    0.00716544f, -0.00478164f, -0.03865294f, 0.00198231f, -0.00042452f, 0.02863276f, -0.02435444f, -0.00486892f, 
    -0.01956972f, -0.04235656f, 0.03077303f, 0.02462985f, 0.02665224f, 0.02103198f, 0.01956271f, -0.01237263f, 
    0.01514141f, 0.01605210f, 0.01686717f, 0.03341862f, 0.02133642f, -0.01470256f, 0.02370119f, 0.01100087f, 
    0.02370685f, -0.02901721f, 0.03062099f, -0.01697782f, -0.02719932f, -0.01194389f, -0.02619450f, 0.02105609f, 
    -0.03438075f, -0.02076774f, -0.02636824f, 0.02335224f, 0.01644363f, 0.02076010f, -0.02291099f, 0.01031660f, 
    0.03067492f, 0.00049903f, -0.03237474f, 0.00595783f, -0.02779024f, 0.02583744f, 0.01164633f, 0.02659761f, 
    -0.02072261f, -0.03265546f, -0.00910821f, -0.04158613f, -0.00238144f, 0.00897769f, 0.00840471f, 0.02644989f, 
    0.03121542f, 0.00436258f, -0.01742582f, 0.01024289f, 0.01847674f, 0.01417618f, -0.01190692f, -0.01561772f, 
    -0.02396531f, 0.02686481f, -0.00820606f, 0.01114294f, -0.02726541f, 0.00347965f, -0.01937796f, -0.02998196f, 
    0.02490649f, -0.03165951f, -0.00733949f, 0.00772580f, -0.00017455f, -0.00578128f, 0.00415996f, 0.02848069f, 
    -0.01974976f, -0.01919625f, -0.00197272f, -0.00361753f, 0.01964186f, 0.00151556f, 0.03512655f, -0.02077774f, 
    0.00494467f, 0.01081700f, 0.02793761f, 0.02024628f, -0.02774447f, 0.01751998f, -0.01151786f, -0.00078987f, 
    -0.03263961f, -0.00788722f, -0.00254045f, -0.01944000f, 0.01651198f, 0.03059227f, 0.02074956f, -0.02818108f, 
    -0.01067575f, -0.00696944f, -0.01697124f, -0.02520428f, -0.00637670f, 0.01107999f, 0.02307166f, 0.00008913f, 
    -0.03210581f, -0.00189282f, 0.00522847f, 0.00102681f, 0.02069773f, 0.00883266f, -0.03555642f, -0.03502903f, 
    -0.01576015f, -0.03598869f, -0.02623783f, -0.04398476f, 0.00335888f, -0.03824945f, 0.02574746f, -0.00086783f, 
    -0.02067491f, -0.02263449f, 0.01443145f, 0.00214229f, 0.00218348f, 0.01827613f, -0.03056143f, -0.01879674f, 
    0.02513406f, 0.00991300f, 0.03295694f, 0.00386967f, 0.00315265f, -0.01493506f, -0.00097928f, 0.00552482f, 
    0.00712505f, 0.01555912f, -0.02920433f, -0.03661949f, -0.03360849f, 0.00254454f, 0.02698307f, -0.00955580f, 
    0.03534396f, -0.03863217f, -0.03623993f, 0.01081743f, 0.00840825f, -0.02527371f, -0.02384128f, 0.03475786f, 
    -0.00746191f, 0.00490355f, -0.00642597f, -0.02928470f, -0.02327411f, -0.01305510f, 0.03075618f, 0.03140955f, 
    -0.00737992f, -0.03784858f, -0.02156876f, -0.02285183f, 0.02124568f, 0.03324541f, -0.00764692f, -0.02618874f, 
    -0.00788790f, -0.02987465f, 0.03463428f, 0.00100255f, -0.03053753f, -0.01140883f, 0.00417009f, 0.02480090f, 
    0.02486405f, -0.03267557f, -0.01570781f, -0.00280548f, -0.03439476f, -0.03074770f, -0.00358274f, -0.01860654f, 
    -0.02839476f, -0.00385903f, -0.02366706f, -0.01516183f, 0.02393005f, 0.01924613f, 0.02006256f, 0.02992303f, 
    -0.00759595f, -0.01595305f, 0.01996174f, -0.03652745f, 0.00627028f, -0.00095831f, 0.03239981f, 0.01668539f, 
    -0.08040057f, 0.06769192f, 0.23070578f, -0.05884191f, -0.12730235f, -0.10209843f, 0.13040423f, -0.07623044f, 
    0.01669101f, -0.06536252f, 0.03416626f, 0.06987779f, 0.17083082f, -0.05645982f, -0.12308003f, 0.17807686f, 
    0.10032032f, 0.01503836f, 0.07111144f, 0.01523512f, 0.01145436f, 0.02546533f, 0.02860040f, -0.04173704f, 
    -0.03238871f, 0.03740935f, 0.09312772f, -0.08227254f, -0.02463590f, 0.11084300f, -0.08795095f, 0.00877260f, 
    0.01430064f, 0.09991979f, -0.01979965f, -0.03015629f, 0.27054653f, 0.21714348f, -0.04891875f, -0.12772675f, 
    0.01968407f, 0.07802872f, 0.03448867f, -0.07021835f, 0.04656928f, -0.15759833f, -0.03572126f, 0.00014571f, 
    -0.01730011f, -0.01872190f, 0.13901800f, -0.11472777f, -0.03847177f, 0.03189985f, -0.05326095f, 0.03225128f, 
    -0.03805032f, -0.07227296f, -0.01286849f, -0.06772827f, 0.03139266f, -0.12658469f, -0.19555689f, 0.04972633f, 
    -0.12127451f, 0.00675156f, -0.02085477f, 0.04394056f, 0.12076549f, 0.03579061f, 0.00258573f, -0.09042945f, 
    0.16156459f, -0.04331146f, -0.11051086f, 0.08781397f, -0.03789862f, 0.14085881f, -0.06350257f, 0.05510647f, 
    -0.04362706f, -0.02821908f, 0.03588150f, -0.07851229f, -0.06275771f, 0.00618034f, 0.04980956f, -0.10547332f, 
    0.00815509f, 0.03009953f, 0.02336839f, -0.02364859f, 0.08838508f, -0.04602090f, -0.11302665f, -0.00879704f, 
    -0.22098482f, 0.18596937f, 0.05371870f, 0.09169445f, 0.06601450f, -0.03337599f, 0.06957888f, -0.06251154f, 
    -0.04414050f, 0.01703412f, 0.05443375f, -0.01774151f, 0.10283172f, -0.03271303f, -0.18981053f, -0.07267357f, 
    -0.01134382f, -0.03856320f, 0.01308719f, -0.03409415f, 0.00173816f, 0.09978319f, 0.05722757f, -0.04976792f, 
    -0.11753610f, 0.33055580f, -0.05735743f, -0.04821598f, -0.05617123f, 0.05829140f, 0.05484090f, 0.04295839f, 
    -0.02373863f, 0.10086732f, -0.02469006f, 0.05058431f, 0.16240110f, 0.09244648f, 0.00161194f, 0.03365383f, 
    0.06849378f, 0.03006492f, 0.03551909f, 0.04868194f, -0.08776224f, -0.08020032f, -0.01079144f, 0.08361296f, 
    0.23401849f, -0.03610715f, -0.07002673f, 0.06600631f, 0.14337835f, 0.00307629f, -0.03294213f, -0.05981201f, 
    -0.05622280f, -0.03291526f, -0.02091912f, -0.05703262f, 0.11739331f, -0.11333561f, -0.16816291f, 0.06239230f, 
    -0.01230045f, -0.05055730f, -0.02820520f, -0.05027914f, 0.04036306f, 0.09943806f, -0.06065993f, -0.05733706f, 
    0.21680754f, 0.09646815f, 0.21216492f, 0.04642029f, -0.01978074f, 0.02162074f, -0.00855952f, 0.15396740f, 
    0.01661225f, -0.09571208f, -0.00325609f, -0.02732942f, 0.11029397f, 0.06008663f, 0.00452405f, 0.05445166f, 
    0.04006577f, 0.00155342f, 0.00317411f, -0.02831151f, -0.08405857f, -0.01070905f, -0.01519653f, -0.03358293f, 
    0.11843336f, -0.04408571f, -0.07031400f, 0.02741533f, 0.05610919f, -0.09521211f, 0.02114085f, 0.09154741f, 
    0.01770610f, 0.09423357f, 0.00416266f, -0.00478249f, -0.14292960f, 0.06236168f, 0.13631691f, -0.04416187f, 
    -0.00674889f, -0.04571872f, -0.07935788f, -0.10324452f, -0.03874994f, -0.04276428f, -0.05314372f, 0.04940217f, 
    0.24363075f, 0.00666113f, 0.01979522f, -0.06711584f, 0.06857146f, -0.08926784f, -0.08044448f, -0.07542618f, 
    -0.00778023f, -0.03479910f, -0.09298460f, 0.06106718f, -0.26699039f, 0.08661444f, 0.02849285f, 0.14203763f, 
    -0.02651601f, 0.05796777f, 0.07195021f, -0.04949059f, -0.01579015f, 0.07053138f, 0.07944527f, 0.04935066f, 
    0.06245195f, 0.00649428f, -0.05541890f, 0.03836420f, 0.19781028f, -0.05215026f, 0.09773920f, 0.08891228f, 
    -0.01995747f, -0.02364455f, 0.02056815f, 0.03945761f, 0.33639887f, -0.12393852f, -0.06846789f, -0.31709662f, 
    -0.03319895f, 0.03416558f, 0.03405417f, -0.00803914f, -0.01361812f, 0.07535585f, -0.06347068f, 0.07548669f, 
    0.14208618f, -0.13479450f, -0.03171732f, -0.07199276f, -0.04411985f, -0.02312895f, 0.02155077f, -0.12350222f, 
    0.04820565f, -0.02577595f, -0.07000574f, -0.03139700f, -0.15583068f, 0.21623810f, 0.14422382f, 0.06979563f, 
    -0.02172782f, 0.04194436f, -0.06167381f, -0.01520055f, -0.01023746f, 0.06523648f, 0.02354093f, -0.09405757f, 
    0.07451899f, 0.09819359f, 0.13334519f, 0.22261406f, 0.07266674f, -0.00376003f, -0.04864136f, -0.00225725f, 
    -0.04474390f, 0.03058246f, -0.01005743f, -0.13595074f, 0.07817344f, 0.02444914f, 0.06262659f, -0.10526581f, 
    0.06327330f, -0.04155516f, -0.06569993f, -0.21858808f, 0.00247543f, 0.02491981f, -0.03965997f, 0.02108234f, 
    -0.12170251f, -0.04644809f, -0.11192870f, 0.08276753f, -0.01156595f, -0.01085198f, 0.00499714f, 0.08132391f, 
    -0.04389715f, 0.03211378f, -0.10162416f, 0.07984452f, -0.13146631f, -0.06226856f, -0.03410351f, 0.05151093f, 
    0.04209230f, 0.13727164f, 0.02290537f, 0.11756504f, 0.01861452f, -0.01886525f, -0.05538393f, -0.05677211f, 
    0.07963254f, -0.06109629f, 0.05477849f, 0.04561208f, 0.03606188f, -0.00854386f, 0.10404023f, -0.07767842f, 
    0.00639137f, 0.04909522f, 0.09984635f, 0.00170046f, -0.16762593f, -0.02454323f, -0.04800513f, 0.16319969f, 
    0.01165854f, 0.02309390f, -0.03411887f, 0.04033260f, 0.02514539f, 0.02888657f, -0.05103492f, -0.05128505f, 
    0.20491350f, 0.18471748f, 0.14664263f, 0.13555698f, 0.02529508f, -0.00194164f, -0.06100267f, 0.00729467f, 
    -0.03957653f, -0.01141800f, -0.01257632f, -0.02906068f, 0.00547751f, 0.11776407f, -0.09067049f, -0.13784897f, 
    -0.03472324f, -0.02882021f, -0.01309133f, 0.07214057f, -0.06161098f, 0.00220822f, 0.07512062f, -0.02436748f, 
    0.13934080f, 0.02245608f, -0.06771098f, 0.18356082f, 0.05694300f, -0.06630360f, 0.05407432f, 0.08717840f, 
    -0.09176956f, -0.05311563f, 0.05103911f, -0.17535725f, 0.15569386f, 0.04009727f, 0.02755674f, 0.00692173f, 
    0.01048210f, -0.00671318f, -0.02428133f, 0.00707365f, -0.01332960f, -0.17904797f, 0.00903322f, -0.01606562f, 
    0.09000176f, 0.19110914f, 0.04355533f, 0.13460469f, 0.09734244f, -0.04754001f, -0.03679895f, 0.08223397f, 
    -0.03257599f, 0.03672561f, -0.02459472f, -0.10234415f, 0.23843904f, -0.07278594f, -0.05598112f, -0.13868068f, 
    0.03285647f, -0.03766168f, -0.00272551f, 0.06844436f, 0.05676703f, 0.08678728f, 0.04017540f, 0.04235526f, 
    0.31299224f, 0.09921220f, -0.01628857f, -0.10369002f, -0.03523000f, -0.02469461f, 0.00676483f, 0.01943338f, 
    -0.03787533f, -0.05954137f, -0.06212402f, -0.07189941f, -0.06587204f, 0.00986694f, 0.03100864f, 0.00549599f, 
    -0.01122826f, 0.00634744f, 0.08661459f, -0.02624454f, -0.11007038f, 0.06258465f, 0.01932311f, -0.02721488f, 
    -0.27508104f, 0.22705568f, 0.17225765f, 0.06421971f, -0.07200529f, -0.00140724f, 0.04776111f, 0.00259128f, 
    -0.08549257f, 0.04848073f, 0.14156967f, 0.12768239f, -0.00077682f, -0.03258500f, 0.20566545f, -0.00069720f, 
    0.01864934f, 0.10794928f, 0.08251158f, 0.04581767f, -0.10180271f, -0.06216542f, -0.01869931f, 0.01238556f, 
    0.12828077f, 0.04015771f, 0.03985685f, 0.08199382f, 0.06654292f, -0.01680213f, 0.02667352f, 0.02677098f, 
    -0.09083291f, 0.03871167f, -0.06478786f, 0.09639898f, 0.01918457f, 0.11280020f, -0.01695472f, -0.03133239f, 
    0.05638586f, -0.08788137f, -0.02235283f, -0.01805783f, -0.00139312f, 0.05177514f, 0.05149694f, 0.08201197f, 
    0.23185593f, 0.04165936f, -0.16604416f, 0.05427907f, -0.01072125f, 0.05416070f, 0.00153496f, -0.07970410f, 
    0.08956034f, -0.00794806f, 0.02876728f, -0.06257400f, -0.00611726f, 0.08459664f, -0.02612013f, -0.08626042f, 
    -0.06643261f, 0.02500186f, -0.01918869f, -0.04025560f, -0.03877100f, 0.17684424f, -0.04729907f, 0.10343736f, 
    -0.17979595f, 0.12573697f, 0.07124798f, 0.10453679f, -0.03810493f, -0.02635960f, -0.02037908f, 0.00553266f, 
    -0.09174974f, -0.03477784f, 0.11353567f, -0.04820000f, 0.06268231f, 0.14665808f, -0.02970816f, -0.04857281f, 
    -0.01554786f, 0.02521401f, -0.02531836f, 0.07029855f, 0.04166737f, 0.03916356f, 0.03864745f, -0.02142998f, 
    0.10479706f, -0.04438286f, 0.09684855f, 0.00572639f, 0.00582709f, -0.05804196f, 0.00892446f, -0.05325308f, 
    0.11301253f, 0.05891675f, -0.03927349f, 0.03778998f, 0.21402593f, 0.05597831f, -0.06844103f, 0.12657614f, 
    0.08107056f, 0.09404149f, 0.04891451f, -0.05982999f, -0.01511880f, -0.02876490f, 0.11627413f, 0.09728462f, 
    -0.01540357f, 0.13833834f, 0.20840262f, 0.11624341f, 0.01413068f, -0.09996141f, 0.02180319f, 0.02852350f, 
    0.04487721f, -0.08131906f, -0.04333615f, 0.02952523f, -0.12192409f, 0.15497264f, 0.11150957f, 0.02829114f, 
    0.02062711f, 0.04834005f, -0.03552132f, -0.03256182f, 0.01701687f, 0.01815091f, 0.03890347f, -0.08023315f, 
    -0.00899718f, -0.10152915f, 0.07924094f, -0.11620317f, 0.00408938f, 0.01326876f, 0.03341104f, 0.04946855f, 
    0.04661536f, -0.05986400f, -0.02775491f, 0.01212220f, 0.13802546f, 0.15343763f, -0.06346494f, -0.05757686f, 
    0.02857343f, 0.05705665f, 0.03035893f, -0.05440507f, -0.01349839f, 0.02670512f, 0.01824864f, 0.08981714f, 
    0.04663778f, 0.05739996f, 0.22725256f, 0.02742780f, -0.01614643f, 0.02521787f, -0.03433290f, 0.03372992f, 
    0.03671151f, 0.03407893f, 0.01996067f, -0.08786922f, -0.19402437f, -0.07133976f, 0.04705763f, -0.01821977f, 
    0.00093534f, 0.01756913f, -0.10549060f, 0.01366181f, -0.06464215f, -0.16569588f, -0.03990435f, -0.08070619f, 
    -0.24651197f, -0.03927879f, -0.06988768f, 0.01551327f, -0.06769443f, 0.00849795f, 0.06483780f, 0.04497094f, 
    0.04003169f, 0.01246205f, 0.04150964f, 0.00972005f, 0.06475846f, 0.10863248f, 0.14351438f, -0.05022295f, 
    -0.03169373f, 0.01662878f, 0.07669276f, -0.06270117f, 0.05538926f, -0.01695320f, 0.02141485f, -0.01730095f, 
    0.11206277f, 0.08901947f, 0.01657907f, 0.07862996f, 0.09435231f, -0.04313922f, -0.00082580f, 0.07110389f, 
    -0.01132758f, 0.08419602f, -0.03862064f, 0.04958201f, 0.10118686f, -0.10640894f, 0.06860568f, 0.02269138f, 
    0.12577426f, -0.06286122f, -0.01422415f, 0.00072841f, 0.02860470f, 0.13005614f, 0.02032142f, -0.01910887f, 
    -0.20488285f, 0.14312901f, 0.12384247f, 0.01409349f, 0.08176773f, -0.06715564f, 0.05144001f, -0.14105864f, 
    -0.03525943f, 0.20129126f, 0.02100238f, 0.13667984f, 0.11428649f, 0.02958594f, 0.10617148f, 0.10328617f, 
    0.02718798f, 0.01606078f, -0.02875212f, 0.05670958f, 0.03224461f, -0.09298398f, 0.05707907f, -0.01255452f, 
    0.00256087f, 0.15996313f, 0.02675437f, 0.27915442f, 0.06135860f, -0.02204882f, 0.08614268f, -0.00656782f, 
    -0.01237473f, -0.00001993f, -0.04383663f, 0.00465672f, 0.10582038f, 0.03439142f, -0.08045763f, 0.06172201f, 
    -0.03577338f, -0.12912594f, 0.00907677f, 0.05323512f, -0.07311299f, 0.01840653f, 0.08260359f, -0.03515459f, 
    -0.33471146f, 0.11125388f, -0.07790718f, 0.09412194f, 0.05559779f, 0.07156526f, 0.02931874f, -0.10953957f, 
    -0.08118461f, 0.12195984f, -0.00029852f, 0.00670393f, -0.14813092f, -0.03482640f, -0.07419991f, 0.27126300f, 
    0.02842004f, -0.04682006f, 0.09345201f, -0.02819035f, -0.00212390f, -0.08045208f, -0.00599049f, -0.08480199f, 
    0.10112281f, -0.16308187f, 0.02161239f, -0.00302491f, -0.08322757f, 0.08168203f, -0.00838853f, 0.04643784f, 
    0.00101993f, 0.01394775f, 0.01141610f, 0.10486856f, -0.01436335f, 0.11126885f, 0.06457166f, -0.11881005f, 
    0.02957891f, -0.03839108f, -0.08312794f, -0.03292525f, 0.04813770f, 0.05738737f, 0.06151420f, 0.01155827f, 
    -0.02204056f, -0.10284137f, 0.09434477f, 0.01095874f, 0.11500649f, 0.01930124f, 0.08372724f, -0.11197419f, 
    0.12785235f, 0.08733416f, 0.06042893f, -0.02365089f, -0.15079877f, -0.09309313f, -0.07476905f, 0.16189747f, 
    -0.02860790f, 0.02894296f, 0.00154562f, -0.02288398f, 0.03597518f, 0.05838260f, -0.01698733f, 0.12421735f, 
    -0.21233411f, -0.04708508f, 0.12260732f, -0.11913813f, -0.01556169f, -0.00048590f, 0.01040645f, -0.06790019f, 
    0.10609218f, 0.07449123f, 0.08285253f, -0.00579939f, 0.21573275f, 0.23417802f, 0.03741354f, -0.17832047f, 
    -0.03784065f, -0.00663519f, -0.05426962f, 0.08596603f, 0.06862388f, 0.00292511f, -0.00702959f, 0.09775557f, 
    -0.08175294f, 0.08577859f, 0.09480307f, -0.03986906f, 0.03406872f, 0.00549379f, 0.02876821f, 0.07133207f, 
    0.07470354f, 0.09144221f, 0.02919041f, 0.07252604f, -0.06327285f, -0.12443405f, 0.11468789f, 0.23087113f, 
    -0.02071803f, -0.03488520f, -0.02873358f, -0.05561687f, -0.00557945f, -0.03381299f, 0.11809164f, 0.00347522f, 
    0.14170773f, -0.00978707f, 0.00497718f, 0.04389552f, 0.09724110f, 0.01119652f, -0.00893280f, 0.09774344f, 
    -0.04198872f, -0.04660894f, 0.02316606f, 0.05588989f, 0.32198358f, 0.18539664f, 0.01532283f, -0.07181622f, 
    0.03266411f, -0.01283937f, -0.03882092f, 0.07523427f, 0.00607005f, 0.13624661f, 0.05311896f, 0.04787010f, 
    -0.26769036f, 0.22282748f, -0.22461426f, -0.04716660f, 0.13751358f, -0.03283795f, -0.08949761f, -0.07261655f, 
    0.15641358f, -0.07021368f, 0.00950954f, 0.03475068f, 0.00780615f, 0.03792708f, 0.07712424f, -0.05743402f, 
    -0.07041785f, -0.00128350f, 0.04158118f, -0.08168738f, -0.00509573f, 0.04129371f, 0.00125236f, -0.01102075f, 
    0.11965894f, 0.17603433f, 0.00523356f, -0.05808873f, 0.03504189f, -0.02066811f, -0.03285107f, 0.04289103f, 
    0.01674362f, 0.11748598f, 0.05685383f, 0.04440242f, 0.19498339f, 0.09650176f, -0.04134659f, -0.14745972f, 
    0.07263261f, -0.02400495f, -0.02877751f, 0.00559316f, 0.08463680f, 0.06098026f, 0.11499964f, 0.07677259f, 
    0.34228918f, -0.03478128f, -0.06448414f, 0.02045768f, -0.09392177f, 0.12211520f, 0.09899274f, -0.02076569f, 
    -0.10588662f, 0.03383963f, -0.06151387f, -0.02986096f, -0.27871943f, -0.10260804f, 0.02316979f, 0.14597811f, 
    0.07937142f, -0.00873724f, 0.13984498f, -0.02873849f, 0.01757820f, 0.00309541f, 0.08962224f, -0.01327750f, 
    -0.10746632f, 0.00865042f, -0.04307505f, -0.09588274f, 0.09669028f, 0.07189392f, 0.00870925f, -0.09221261f, 
    0.01364893f, -0.03213426f, 0.12205345f, 0.06757402f, 0.15625672f, -0.04007822f, 0.05640328f, -0.09113419f, 
    -0.05778395f, 0.05856314f, 0.04662216f, 0.02907866f, -0.02211770f, -0.06669732f, 0.04502010f, 0.04581878f, 
    -0.00208223f, 0.08171493f, -0.06394179f, 0.12674631f, 0.01906908f, 0.02779607f, 0.01994415f, -0.04867531f, 
    0.07654486f, -0.01880283f, 0.01006773f, 0.04598935f, 0.13200955f, -0.07416315f, -0.04113119f, -0.10379605f, 
    0.03911458f, -0.10986099f, -0.04601988f, 0.04436916f, 0.07792825f, -0.07538358f, -0.08320149f, -0.01074922f, 
    -0.01452221f, -0.14392993f, 0.06067965f, 0.00702078f, -0.01426571f, 0.04180565f, 0.06950358f, 0.01041243f, 
    0.10034549f, 0.03586723f, -0.05145669f, -0.00270946f, -0.15280418f, 0.05975755f, 0.00655482f, 0.19807830f, 
    -0.04187064f, -0.03271256f, 0.07077011f, -0.08648238f, -0.00036478f, -0.04501797f, -0.02207357f, 0.07078316f, 
    0.21699923f, 0.31386101f, -0.02564508f, -0.01782689f, 0.10716113f, 0.03950258f, -0.08334634f, 0.11024127f, 
    0.08091143f, 0.03888714f, 0.01627504f, 0.10305677f, -0.15179065f, 0.08612815f, 0.07122310f, -0.06331249f, 
    -0.00026997f, -0.03480393f, 0.10985756f, -0.06098983f, -0.01996401f, 0.02822696f, 0.02399813f, 0.05553988f, 
    0.05163345f, 0.00718390f, 0.16931958f, -0.35574642f, 0.01088547f, -0.03474767f, 0.04664130f, -0.06177377f, 
    -0.04331151f, -0.01067944f, 0.03939513f, -0.01298909f, -0.28008300f, -0.02791202f, 0.13967134f, 0.10157473f, 
    -0.02216931f, 0.06830019f, 0.04653774f, 0.08292419f, 0.03153129f, -0.02432979f, 0.06625386f, 0.02426354f, 
    0.10983177f, -0.10481484f, 0.12087432f, 0.00694966f, 0.03233102f, -0.01339120f, 0.02703879f, -0.04079319f, 
    -0.06098517f, -0.03188709f, 0.05981020f, 0.04810282f, 0.15029404f, -0.22562850f, 0.06649321f, 0.04784805f, 
    -0.05066257f, -0.10028283f, -0.12125558f, 0.01130031f, -0.00171027f, 0.04957771f, 0.01791937f, 0.03778038f, 
    -0.13620645f, 0.00419272f, 0.05468256f, 0.02684112f, -0.07525501f, -0.00861887f, -0.06580026f, -0.02572673f, 
    0.07439681f, 0.00832274f, 0.10012598f, -0.00129749f, 0.24243544f, 0.03962404f, -0.17877162f, -0.11179012f, 
    0.03784377f, 0.05362372f, 0.06605191f, 0.01009086f, -0.02967300f, 0.05555782f, 0.04484379f, 0.05338584f, 
    0.20184098f, -0.03851371f, -0.04928290f, 0.03917232f, -0.03826144f, 0.04585600f, 0.06999675f, 0.03853546f, 
    -0.07147415f, -0.06285051f, -0.05088689f, -0.01552115f, -0.01665272f, -0.17718495f, 0.10614703f, 0.12827940f, 
    0.11459613f, 0.10898653f, -0.12100241f, -0.04959118f, 0.03600267f, 0.01486705f, -0.06894553f, 0.12321009f, 
    0.11758358f, -0.10541160f, 0.04850292f, -0.02815311f, 0.02580909f, 0.00505967f, 0.04263963f, -0.05221806f, 
    0.11503617f, 0.02967642f, 0.01419725f, 0.05305533f, -0.43012384f, -0.10389023f, -0.00742118f, 0.09719480f, 
    -0.01025007f, 0.00766190f, 0.03197379f, -0.02734265f, -0.04756842f, 0.01601399f, 0.01252124f, 0.07638431f, 
    0.19571514f, -0.10990863f, -0.07035803f, -0.10421879f, -0.05836725f, 0.04615645f, 0.08401779f, 0.04499216f, 
    -0.05433533f, -0.06190767f, 0.02397683f, 0.02605522f, 0.17093025f, 0.04477325f, -0.11045619f, 0.12412216f, 
    0.09646572f, -0.05577166f, 0.01925749f, -0.03764110f, 0.02509792f, 0.02704239f, 0.06568707f, 0.03415574f, 
    0.31908530f, 0.10469807f, -0.03409841f, 0.16709505f, 0.04629146f, -0.04501444f, 0.03282160f, -0.03036263f, 
    -0.01830368f, 0.03416272f, 0.06963240f, 0.11289973f, 0.12349305f, -0.05989389f, 0.09471074f, 0.03354910f, 
    -0.05955707f, -0.02832376f, 0.00914515f, 0.04258000f, -0.06536482f, -0.13574859f, 0.00788723f, 0.08897112f, 
    0.17036642f, 0.13079338f, -0.21115935f, -0.25690541f, -0.03973081f, -0.04997009f, -0.01427387f, -0.07086610f, 
    0.02696989f, -0.01479768f, -0.06730037f, -0.08252887f, 0.04468997f, -0.00044538f, -0.10725771f, -0.27117452f, 
    -0.08252550f, -0.00730087f, 0.01876114f, -0.05048875f, -0.00757643f, 0.06373451f, 0.05271368f, -0.01852161f, 
    -0.01292073f, 0.12939398f, -0.02578435f, -0.09122279f, -0.09427359f, 0.06885232f, 0.06986118f, -0.08307798f, 
    0.04759028f, -0.06784543f, -0.06780426f, -0.02060793f, 0.15665706f, -0.02448993f, -0.19086690f, 0.05140477f, 
    0.16674373f, 0.07952626f, 0.04885914f, -0.05623907f, 0.12369070f, 0.01608947f, 0.03909715f, 0.06013229f, 
    0.13249318f, 0.06332126f, 0.20462935f, -0.15780292f, 0.12760217f, -0.03264814f, -0.00372352f, -0.06563745f, 
    -0.04562082f, 0.04616383f, 0.01332090f, 0.06455050f, -0.21941335f, 0.00938616f, -0.01900878f, -0.00826695f, 
    0.03669985f, 0.04339029f, 0.13580486f, 0.00897077f, 0.08275514f, 0.03860017f, 0.12810612f, -0.00401356f, 
    -0.08882686f, 0.05186729f, 0.19646749f, -0.13804315f, -0.03676725f, -0.02039907f, 0.06634065f, 0.02711985f, 
    0.11881068f, 0.07160516f, -0.08938398f, -0.02866606f, -0.24571033f, 0.20726050f, 0.09710208f, -0.07040936f, 
    0.19890016f, 0.09771357f, -0.09311202f, -0.01176245f, -0.01182494f, 0.00719420f, 0.10528585f, 0.01848763f, 
    0.22407244f, -0.03954714f, -0.17454836f, -0.03761830f, 0.02806280f, -0.02899232f, 0.03524021f, 0.00295344f, 
    0.03604819f, 0.03218624f, 0.03131567f, 0.02789827f, -0.02680736f, -0.18281087f, 0.05468753f, 0.08875819f, 
    0.06700910f, 0.04480359f, 0.08603256f, 0.00017474f, 0.33898300f, 0.07290155f, -0.02397844f, 0.09721580f, 
    -0.10030166f, -0.00598384f, -0.00557917f, 0.01838889f, -0.05944714f, 0.10137945f, 0.04333852f, 0.04565731f, 
    0.03376625f, 0.01318126f, 0.02273493f, 0.05653966f, -0.03263053f, 0.05106154f, -0.04048393f, 0.03800008f, 
    -0.02417513f, -0.14774951f, -0.10370263f, 0.09744773f, 0.04226022f, -0.00635448f, 0.05836324f, -0.02456525f, 
    -0.02063622f, -0.08197489f, -0.03112844f, -0.00096266f, 0.00638278f, 0.00838760f, -0.05791020f, -0.05113813f, 
    0.02198396f, 0.14110008f, 0.14212771f, -0.07440747f, -0.02345914f, -0.12289727f, -0.07121752f, 0.12549035f, 
    -0.07378711f, 0.05164805f, -0.04222523f, -0.06051103f, 0.09024339f, 0.02476829f, -0.04017829f, 0.18036279f, 
    0.25253829f, -0.07871097f, 0.02736583f, -0.09002505f, -0.08712849f, -0.02378983f, 0.00393883f, 0.07417010f, 
    -0.02123079f, 0.01091411f, -0.00128961f, 0.00590074f, -0.09810144f, -0.00984940f, -0.13623644f, -0.07824828f, 
    -0.11462069f, 0.01625843f, -0.02041444f, 0.08552814f, -0.00174926f, 0.10742037f, -0.05826513f, -0.09845555f, 
    0.12321194f, 0.05612999f, -0.11775711f, -0.06309777f, 0.01507318f, 0.18477713f, -0.09135765f, 0.14082605f, 
    0.04572070f, -0.06492132f, 0.02281696f, -0.04892965f, -0.06127869f, 0.01245483f, -0.01980595f, -0.10353850f, 
    0.02544178f, -0.01601978f, 0.05381659f, -0.10017696f, -0.00098100f, 0.02509046f, 0.01504174f, 0.02553774f, 
    0.18269622f, -0.22963351f, 0.08158951f, 0.12424073f, 0.19162925f, -0.04924930f, -0.04624088f, -0.14039423f, 
    0.06476558f, 0.09294748f, 0.02846836f, 0.03497629f, 0.18746416f, -0.11152007f, -0.01996411f, 0.00165406f, 
    0.12306991f, 0.02175470f, 0.06443004f, -0.08324702f, 0.00359242f, 0.04776518f, 0.11803187f, 0.00120735f, 
    -0.06985284f, 0.07255822f, -0.10755589f, -0.13479081f, -0.02867843f, -0.03780235f, 0.15656933f, -0.06949233f, 
    0.08776793f, -0.02019257f, 0.00776317f, -0.01229772f, 0.11091953f, 0.05867996f, -0.26457936f, -0.02632399f, 
    0.05690775f, 0.01059292f, 0.03663506f, 0.02607431f, 0.06006054f, -0.05940138f, 0.05198631f, 0.06345879f, 
    -0.20086443f, -0.10574308f, 0.03975134f, 0.04563028f, -0.02275849f, -0.04909338f, -0.02256112f, 0.09273970f, 
    0.07479919f, 0.02798276f, 0.01581292f, 0.02421008f, -0.07101339f, 0.17138873f, -0.06521325f, 0.16319941f, 
    0.04895566f, 0.01358585f, 0.00559265f, 0.00606341f, -0.00047908f, 0.00310520f, -0.07465220f, 0.04398745f, 
    0.16845110f, -0.04265473f, 0.06891693f, 0.05542757f, 0.04841012f, -0.03848599f, 0.04277905f, 0.04361313f, 
    0.08301756f, 0.02420253f, 0.11695961f, 0.08741809f, 0.31459096f, 0.03611962f, 0.04047664f, -0.15355621f, 
    0.01192131f, 0.04570691f, -0.00602810f, 0.10326296f, -0.02426128f, 0.01132684f, 0.00678255f, 0.08912186f, 
    0.02399230f, -0.03455169f, -0.00262786f, -0.03113313f, -0.01747088f, 0.00560146f, 0.02756237f, -0.02037730f, 
    0.00229462f, 0.01464479f, 0.00833993f, -0.00394261f, 0.00086048f, -0.00250851f, 0.02863959f, -0.02314946f, 
    -0.00155039f, -0.00593469f, 0.01338102f, -0.02111611f, -0.01807232f, 0.02378423f, 0.00248219f, 0.00785383f, 
    0.02062679f, 0.02271024f, -0.01240150f, 0.01072702f, 0.00203420f, -0.00755972f, -0.02498949f, 0.02953758f, 
    -0.04119960f, 0.01455501f, 0.00902124f, -0.00875129f, 0.01785629f, 0.03023828f, 0.02728763f, 0.01829902f, 
    -0.02920239f, 0.02856916f, 0.00229977f, -0.03439768f, -0.00671749f, -0.03135568f, -0.00718186f, 0.02911410f, 
    0.02663118f, -0.02711702f, -0.01506369f, -0.02238296f, 0.02760337f, -0.00919304f, -0.02842302f, 0.01519104f, 
    0.01162893f, -0.01756248f, -0.03857001f, -0.03835291f, 0.01037856f, 0.01979209f, -0.03965989f, -0.00170782f, 
    -0.01907717f, 0.00294825f, 0.01653801f, -0.03931620f, -0.01523016f, -0.01986373f, -0.01436701f, 0.02361008f, 
    -0.02634863f, 0.02778049f, -0.03550439f, -0.03529098f, 0.02816181f, -0.00543520f, 0.01576901f, 0.01854329f, 
    -0.01713961f, 0.02848843f, 0.02103527f, -0.00538282f, -0.00447214f, -0.01516161f, 0.01329905f, -0.03785365f, 
    0.00071935f, -0.00027508f, -0.02611826f, -0.00936359f, -0.00218916f, 0.01137969f, -0.01741422f, -0.03061437f, 
    -0.02572199f, -0.03336018f, -0.02119969f, 0.02268736f, -0.02146489f, -0.03072386f, 0.01737588f, -0.02483969f, 
    0.00350599f, 0.01572338f, 0.02309222f, -0.03094324f, -0.03973770f, -0.00441824f, -0.02213513f, -0.03597046f, 
    0.01259301f, -0.03086705f, 0.00165497f, 0.01870902f, -0.02164952f, -0.03516168f, 0.00140913f, 0.01573623f, 
    -0.04030878f, -0.02009268f, -0.01403726f, -0.04000698f, 0.02723249f, -0.01566564f, 0.00237804f, -0.02048434f, 
    -0.02474664f, 0.02048616f, 0.03020508f, -0.00986883f, -0.02487477f, 0.01177108f, 0.02731378f, 0.01535574f, 
    0.00741816f, 0.00570793f, -0.04018347f, -0.00314426f, 0.00560806f, 0.01460285f, 0.00339310f, 0.01435940f, 
    -0.01701174f, 0.01957291f, 0.02092881f, -0.03605988f, 0.01845456f, -0.00869151f, -0.03348250f, -0.03407444f, 
    0.00487570f, -0.00408938f, -0.02862697f, -0.01496741f, -0.02724672f, -0.00870303f, -0.02628757f, -0.00964424f, 
    -0.02512388f, -0.01161592f, -0.01390698f, 0.02983459f, -0.02861090f, 0.01982536f, -0.00751205f, 0.03004818f, 
    0.01448549f, -0.03505738f, -0.00194888f, 0.00285217f, -0.00362486f, -0.00542199f, -0.02351002f, 0.00945463f, 
    -0.02125040f, 0.02325319f, -0.00411868f, 0.01785500f, -0.03640127f, 0.02528383f, 0.00246094f, 0.02783034f, 
    -0.01086881f, -0.03273832f, -0.02846652f, 0.01051556f, -0.03972039f, 0.01775634f, -0.02149822f, -0.00526016f, 
    -0.02823508f, 0.02565628f, 0.02559311f, -0.01553117f, 0.00508108f, -0.02594841f, -0.01435921f, -0.02418620f, 
    0.00680614f, -0.00013685f, 0.01073102f, -0.01038839f, -0.02511583f, 0.01784034f, 0.01596032f, -0.01680496f, 
    -0.03278985f, -0.00367721f, -0.02855191f, -0.02860448f, -0.02809914f, 0.00627935f, -0.00327809f, 0.01318611f, 
    -0.02494392f, -0.01395785f, -0.00849127f, -0.03589754f, -0.03829202f, -0.00687360f, 0.00115368f, -0.00882397f, 
    0.00193643f, -0.01856536f, 0.02207394f, 0.01227169f, 0.02781428f, -0.02417965f, 0.01334867f, 0.00874041f, 
    -0.00918658f, 0.01767539f, 0.00163674f, -0.03310527f, 0.01128710f, 0.01954327f, -0.02364871f, -0.03299085f, 
    0.02712667f, -0.04102369f, 0.02034428f, 0.00638874f, -0.02726891f, -0.03535569f, 0.01245841f, -0.00730399f, 
    -0.02722367f, 0.00279787f, -0.03528507f, -0.02394393f, 0.02916675f, -0.00006212f, -0.00573613f, -0.02303408f, 
    0.02506786f, -0.03046805f, 0.01719784f, -0.01235552f, 0.01380851f, -0.03311056f, -0.03270062f, 0.02025551f, 
    0.00941576f, 0.02415309f, -0.01784561f, -0.00796998f, -0.03926952f, -0.04029562f, -0.02550177f, 0.00364696f, 
    0.01503595f, 0.01167085f, 0.00037791f, -0.01342489f, 0.02297160f, 0.00962080f, -0.02930844f, -0.03902288f, 
    0.01974145f, 0.01440068f, -0.00210676f, 0.01996573f, 0.02078510f, -0.04130920f, -0.02836130f, -0.02405649f, 
    0.00252460f, -0.01224974f, 0.00505569f, 0.03026584f, 0.02030612f, 0.00931609f, -0.02717209f, 0.01828657f, 
    0.02930559f, 0.01548199f, 0.03180280f, -0.01184276f, -0.01897046f, 0.02087374f, -0.00355081f, 0.02492832f, 
    -0.02311159f, -0.03509650f, 0.02523692f, 0.00503801f, -0.00782884f, -0.00847631f, -0.00070233f, -0.01734715f, 
    0.01761575f, -0.02907593f, 0.00312187f, 0.00731944f, 0.01494549f, 0.02341906f, -0.01617418f, -0.00048954f, 
    0.02859790f, -0.03996955f, -0.03446068f, 0.01866971f, -0.00616148f, 0.01580713f, 0.02365905f, 0.01506664f, 
    -0.02885305f, -0.02155673f, 0.00949034f, 0.02003014f, -0.02226935f, -0.03569665f, 0.02428506f, -0.03892367f, 
    0.01951843f, -0.03621367f, 0.00937397f, 0.03187017f, -0.01296061f, 0.02554593f, -0.02798710f, -0.03475172f, 
    0.00626381f, 0.01355911f, -0.01583952f, 0.00942352f, 0.01107224f, -0.03491868f, 0.00819696f, 0.02210657f, 
    0.01787600f, 0.01874025f, -0.01883799f, 0.00061799f, 0.00406133f, 0.01420357f, -0.03743939f, -0.04101920f, 
    -0.00659878f, 0.00988588f, -0.00915559f, 0.00165458f, 0.03157848f, -0.04052320f, -0.02245633f, -0.00819457f, 
    0.02326760f, -0.01330513f, 0.02789343f, -0.02115102f, 0.02385903f, -0.00686615f, -0.03484949f, 0.02586654f, 
    -0.01881436f, -0.03956413f, 0.01046802f, 0.01167521f, 0.01646443f, 0.01745088f, 0.00278025f, -0.01121948f, 
    -0.01450853f, 0.03045256f, 0.02285901f, -0.02414580f, -0.02940260f, -0.01613631f, 0.02458319f, -0.01648652f, 
    0.03390493f, -0.01549080f, 0.01156230f, -0.00545473f, 0.03303041f, -0.01868299f, 0.00955881f, -0.00516205f, 
    -0.01816146f, 0.02206305f, -0.00262800f, -0.03333551f, -0.03260448f, -0.01031285f, -0.03767287f, -0.01851130f, 
    -0.03531969f, -0.03441739f, 0.02068694f, -0.02656833f, -0.01373778f, -0.03667040f, -0.03319061f, -0.03948234f, 
    0.00388636f, -0.01456817f, -0.02999230f, 0.03024733f, 0.00325622f, -0.01329980f, -0.01800047f, -0.02892517f, 
    -0.03166617f, -0.03547193f, -0.04011442f, -0.01747842f, 0.00728060f, 0.02010242f, -0.01054157f, 0.03342427f, 
    -0.03719519f, -0.02846063f, 0.00755186f, -0.02271333f, -0.02877558f, 0.00816396f, -0.02761650f, -0.01025584f, 
    -0.03762847f, 0.03053826f, 0.00351311f, -0.00762825f, -0.03948115f, -0.03852567f, 0.01213236f, -0.00530215f, 
    -0.03934216f, -0.00611844f, 0.01410906f, -0.01857221f, -0.01740578f, 0.02482994f, -0.01932911f, -0.02998687f, 
    -0.02792148f, 0.01537625f, 0.02233224f, -0.03579051f, -0.02239583f, 0.00735941f, 0.00222172f, 0.01900168f, 
    0.02941339f, 0.00244899f, 0.02018441f, -0.00847742f, -0.00746019f, -0.01291550f, -0.02663269f, -0.03011967f, 
    0.01100822f, 0.00133808f, -0.02490100f, -0.03535711f, -0.01788555f, 0.02208181f, -0.01874549f, -0.01984713f, 
    0.02474377f, 0.02761465f, -0.01149514f, 0.02916700f, 0.01196422f, 0.00416843f, -0.03906473f, -0.01769251f, 
    0.02095239f, 0.02415940f, -0.02680536f, 0.01265350f, -0.02425276f, 0.00291491f, -0.01255459f, -0.02032853f, 
    -0.01582998f, -0.04058582f, -0.00806681f, 0.02388755f, 0.02922726f, 0.02685330f, 0.01864855f, -0.01448048f, 
    -0.01304002f, -0.03325456f, -0.01417649f, -0.03854746f, -0.02503901f, -0.00723950f, -0.01429458f, -0.02784143f, 
    -0.02913652f, -0.03839833f, -0.02956333f, 0.01516275f, -0.03178791f, 0.00522572f, -0.02271647f, 0.01499663f, 
    -0.03076603f, 0.01463874f, 0.01694369f, 0.02185744f, -0.02617601f, 0.02998107f, 0.02128530f, -0.00604005f, 
    -0.00315181f, -0.02669452f, 0.01825561f, 0.01297533f, -0.00365429f, -0.01396874f, -0.03696854f, -0.00487789f, 
    0.00440174f, -0.00214147f, 0.02721162f, 0.01575750f, -0.02972439f, -0.03536887f, -0.01389420f, 0.02084974f, 
    -0.03905332f, -0.00074240f, 0.01802278f, -0.02924965f, -0.01876135f, -0.03075874f, 0.00671951f, -0.00133961f, 
    -0.00273739f, 0.02332158f, -0.00375009f, -0.01774373f, -0.02873426f, 0.00100227f, 0.02055142f, -0.02143424f, 
    -0.03057782f, 0.02821719f, -0.02227664f, 0.02432507f, -0.04082772f, -0.03173837f, -0.03893404f, -0.03325027f, 
    0.01709418f, 0.01021549f, -0.00771462f, -0.01064398f, 0.00435293f, 0.02676422f, -0.03518590f, -0.00313650f, 
    -0.00740938f, -0.02397092f, 0.00271812f, -0.02509356f, -0.03177271f, -0.01738080f, -0.04088793f, -0.00527582f, 
    0.02447154f, 0.00977300f, -0.03483190f, -0.03946171f, -0.01987134f, -0.00665941f, -0.01493606f, 0.00437317f, 
    -0.00663911f, 0.02099963f, -0.01697721f, -0.03294068f, -0.02088373f, -0.02069710f, -0.01098350f, -0.02364808f, 
    -0.03218277f, 0.00912364f, 0.02459969f, 0.02434278f, 0.02542278f, -0.02093336f, -0.04034723f, 0.00107922f, 
    0.02007132f, 0.01085305f, 0.02798652f, 0.03041852f, -0.01704268f, -0.03332590f, -0.02495741f, -0.02260512f, 
    0.01294931f, -0.04041295f, -0.00924338f, 0.00364595f, -0.02429947f, 0.00242125f, -0.03530051f, -0.03460136f, 
    0.01101107f, 0.02431286f, -0.02170772f, -0.01406031f, -0.03043078f, -0.01082357f, 0.00840864f, -0.02137594f, 
    0.02996947f, 0.01726210f, -0.02883109f, 0.00083707f, -0.01387245f, -0.01181416f, 0.00596210f, -0.02150849f, 
    -0.02904618f, 0.02650948f, 0.02523370f, -0.04098571f, -0.03347498f, -0.00420503f, -0.02001619f, -0.02872718f, 
    0.01476652f, 0.02900801f, 0.00641417f, -0.02070312f, -0.03501647f, -0.02140655f, -0.02675548f, -0.00970762f, 
    0.02087143f, -0.01954040f, -0.01347358f, -0.00940664f, -0.01424331f, -0.02091470f, -0.02107603f, -0.04107422f, 
    -0.04028417f, 0.00861406f, 0.02102774f, -0.01030448f, -0.03606996f, 0.02103749f, 0.02863072f, -0.02540010f, 
    0.01629541f, 0.00856432f, 0.01433627f, -0.03822552f, -0.01956737f, -0.00092514f, 0.01515376f, -0.02048993f, 
    0.00857393f, -0.01915181f, 0.02720965f, 0.02409157f, -0.02218088f, 0.03003058f, -0.03753629f, -0.00399473f, 
    0.02145261f, -0.01012843f, -0.00280228f, 0.01587335f, -0.03612623f, -0.03374936f, -0.01921335f, 0.01871727f, 
    -0.02570506f, -0.02966010f, -0.03070804f, -0.01094450f, 0.02254664f, 0.01024913f, -0.02099768f, 0.02341765f, 
    0.00686817f, 0.00162890f, -0.00171915f, 0.02328517f, -0.00022800f, 0.01350813f, 0.01408531f, -0.01016953f, 
    0.01599626f, 0.01672889f, -0.03109837f, 0.01479837f, -0.02215881f, -0.03390326f, -0.03025874f, -0.02651060f, 
    0.00902938f, -0.01012729f, 0.00405621f, -0.03250326f, -0.02288439f, -0.02834232f, -0.01351528f, -0.01697536f, 
    -0.03580078f, 0.00985082f, -0.03401000f, -0.01510518f, 0.00085348f, -0.02584282f, -0.03216963f, 0.02818148f, 
    -0.01454856f, -0.02624503f, 0.01181583f, 0.02004717f, -0.03670181f, -0.04043220f, -0.03494823f, -0.03334417f, 
    -0.01537954f, 0.01173561f, 0.00093647f, -0.02122265f, -0.00573335f, -0.00113075f, 0.00259236f, -0.00362383f, 
    -0.02938718f, 0.00573722f, 0.01982023f, 0.02739042f, 0.02697337f, -0.00988501f, -0.00723905f, -0.02748964f, 
    -0.00510333f, 0.01788633f, 0.01208737f, 0.02644505f, -0.03012350f, -0.00725983f, 0.00892472f, -0.00238898f, 
    0.01656557f, -0.00124179f, -0.04029281f, 0.01703597f, -0.02886137f, 0.00157328f, -0.04667093f, 0.01258237f, 
    0.02227428f, -0.02992104f, -0.04012522f, 0.01065355f, 0.00831234f, 0.01329766f, -0.00015883f, 0.03119908f, 
    -0.02179114f, -0.01940760f, -0.03386389f, 0.01549496f, -0.01169834f, -0.02071667f, 0.00316947f, -0.02459110f, 
    0.00262116f, 0.01740378f, 0.00916777f, 0.01477793f, -0.03485933f, -0.03000299f, 0.03020583f, 0.01786148f, 
    -0.00159872f, -0.02218660f, 0.00919597f, -0.00049940f, -0.02067219f, -0.02439126f, -0.02305460f, 0.02014315f, 
    -0.00465338f, 0.00218217f, 0.01152211f, -0.01191701f, -0.02799552f, -0.00893297f, -0.01825514f, -0.03556077f, 
    0.01997069f, -0.04366377f, 0.02520132f, 0.01455498f, -0.03148759f, 0.01721619f, -0.03339779f, 0.00457273f, 
    0.01197671f, 0.01004419f, 0.00260123f, 0.02462369f, 0.00708461f, -0.01459003f, -0.00449160f, -0.01917458f, 
    -0.02326897f, 0.02268351f, -0.01907276f, 0.01658666f, -0.01458120f, -0.03477967f, -0.01182382f, -0.01520082f, 
    0.01496491f, 0.02447503f, 0.00580933f, -0.00400130f, -0.03478030f, -0.02461973f, -0.01949516f, 0.02075961f, 
    -0.02906612f, 0.02283428f, 0.02397515f, -0.01673595f, -0.00151931f, 0.01546800f, -0.00432043f, 0.00625205f, 
    -0.00096797f, -0.04062386f, -0.02976953f, 0.01733458f, -0.01575284f, 0.01210649f, 0.02738388f, -0.01950229f, 
    -0.03274125f, 0.00686211f, 0.00623569f, -0.01605448f, 0.00222222f, -0.01701282f, 0.01581972f, 0.01853250f, 
    -0.00467492f, -0.01391498f, 0.02912161f, -0.04558348f, -0.03122137f, -0.00111546f, 0.02898205f, 0.03341307f, 
    0.03309036f, 0.01471876f, 0.00510967f, 0.00662410f, 0.00841071f, -0.01234217f, -0.04166229f, -0.00744694f, 
    -0.03176318f, -0.02031395f, 0.01263373f, -0.01843625f, -0.03618411f, -0.00179855f, -0.00798575f, -0.00151003f, 
    0.00849189f, 0.00319968f, 0.02123881f, 0.02433258f, -0.02271422f, -0.00562580f, -0.00019493f, 0.01891792f, 
    -0.04359193f, -0.01045897f, -0.04061585f, -0.00216388f, -0.00043573f, -0.03816174f, 0.01778972f, 0.00654706f, 
    -0.02610110f, -0.01289852f, 0.00673595f, -0.00661032f, -0.01149531f, -0.03384580f, 0.00657761f, -0.01192852f, 
    0.01829094f, 0.02356236f, -0.01980744f, -0.01945165f, -0.03406728f, 0.00710360f, 0.00813990f, -0.03965360f, 
    0.01602503f, 0.01834799f, -0.03935279f, -0.01806076f, -0.02682726f, 0.01685959f, -0.03199852f, -0.03468375f, 
    -0.01091771f, 0.01511086f, -0.02586086f, 0.02943747f, -0.03582703f, -0.04409878f, -0.03105370f, -0.03420448f, 
    -0.03158036f, -0.01616708f, 0.01336851f, 0.01277944f, -0.01005884f, -0.01198022f, 0.02332495f, -0.01653309f, 
    -0.00316898f, -0.03252120f, 0.00641745f, 0.01730710f, -0.03161626f, 0.00626017f, 0.02614252f, 0.00609740f, 
    -0.04255198f, -0.02598814f, 0.01478524f, -0.02866270f, 0.03094975f, 0.02592427f, 0.00393789f, 0.01363385f, 
    -0.00513330f, -0.02420323f, 0.01849899f, -0.02738562f, 0.03115727f, 0.00331953f, -0.03561634f, 0.01039789f, 
    0.01088612f, -0.01063892f, 0.01180434f, -0.03839296f, 0.00889903f, -0.03989406f, 0.02205691f, 0.02104358f, 
    -0.03814341f, -0.01774434f, 0.00980941f, -0.00264946f, 0.02507307f, -0.01320409f, -0.03361508f, 0.02955021f, 
    -0.02797352f, -0.02117851f, -0.01001166f, -0.04097372f, 0.01253834f, -0.02919276f, -0.00351703f, -0.01156856f, 
    -0.01148595f, -0.00768613f, -0.01354159f, 0.02577910f, -0.00577639f, -0.03576738f, 0.01581853f, -0.01929475f, 
    0.00491439f, -0.00705918f, 0.02523804f, 0.01324034f, -0.03832112f, 0.00302129f, -0.00729300f, -0.02240492f, 
    0.01603250f, -0.02547735f, -0.02009268f, 0.02091075f, 0.00110158f, -0.03225322f, 0.01295722f, 0.01177347f, 
    -0.00623433f, 0.03095665f, 0.02418921f, -0.00836258f, -0.03914059f, -0.00253563f, -0.02480312f, -0.00933287f, 
    -0.04410180f, -0.02162963f, -0.01408989f, -0.04287166f, 0.00468701f, 0.02466075f, -0.00148937f, 0.01500498f, 
    -0.01805745f, 0.02058721f, 0.00267086f, 0.00584560f, -0.00341769f, -0.03540617f, 0.02650012f, 0.02767907f, 
    0.00983313f, -0.01329780f, -0.03135966f, 0.02245760f, -0.01934764f, -0.02223426f, -0.03439700f, -0.03408957f, 
    -0.01998654f, -0.01521154f, 0.02620002f, 0.02282989f, -0.01328548f, -0.02586556f, 0.02355209f, 0.01508932f, 
    -0.00695502f, -0.01336955f, 0.02048102f, -0.00547209f, -0.03486347f, 0.02520906f, -0.03508554f, 0.02561931f, 
    -0.03364114f, 0.03579037f, 0.03190439f, 0.03106750f, 0.00680483f, -0.01003587f, 0.01522331f, -0.01007970f, 
    -0.00297273f, -0.02375883f, -0.00983748f, 0.00346288f, -0.02337443f, 0.02022354f, -0.01155521f, 0.01117036f, 
    -0.03231737f, -0.01228500f, 0.01846759f, -0.02083023f, -0.03718743f, -0.03359302f, -0.00317962f, -0.02171404f, 
    0.01792750f, 0.02022695f, 0.01721721f, -0.01768683f, 0.01782197f, -0.00341336f, -0.02512519f, -0.03822210f, 
    -0.03217764f, -0.02133859f, -0.01222812f, 0.01600781f, 0.02312345f, 0.00527551f, 0.01983199f, 0.02321955f, 
    -0.02549722f, -0.00620292f, 0.01902760f, -0.02520465f, -0.00682437f, 0.02976479f, 0.01448194f, 0.04000123f, 
    -0.02588968f, -0.01431580f, 0.00772606f, -0.04583079f, -0.03496487f, -0.00786850f, 0.00370343f, 0.03214172f, 
    0.02584721f, -0.01925325f, 0.02506666f, 0.01972232f, -0.03729693f, -0.02904911f, -0.02588430f, -0.01941153f, 
    0.01535939f, -0.03897720f, -0.01448877f, 0.02120436f, -0.02855051f, -0.04065623f, 0.02404188f, -0.01965214f, 
    -0.00763627f, -0.03475331f, -0.03083518f, 0.01600761f, 0.01450513f, 0.01370371f, 0.02195737f, 0.01645092f, 
    -0.02130078f, -0.03192150f, 0.01268865f, 0.03104322f, -0.00317052f, -0.01600122f, -0.00173688f, -0.03146302f, 
    0.01447926f, 0.01419231f, -0.02697293f, -0.01019635f, 0.01680599f, -0.03745303f, 0.01061225f, 0.00148831f, 
    -0.02040736f, -0.01037132f, 0.01034427f, 0.01134648f, -0.00463064f, -0.01554451f, 0.00581593f, -0.01325195f, 
    -0.01521818f, 0.01028119f, 0.02938340f, -0.01027919f, 0.02437791f, -0.02387658f, 0.01708519f, -0.00825882f, 
    0.02178015f, 0.01915040f, -0.03331603f, -0.01685104f, -0.03894424f, 0.00310424f, -0.00626810f, 0.02162664f, 
    -0.00036591f, 0.00521067f, 0.00479219f, 0.03484153f, -0.01320108f, -0.03170474f, -0.01582934f, -0.02166284f, 
    -0.04428912f, -0.03318472f, 0.02103863f, -0.03303302f, -0.01733392f, 0.01717431f, -0.01225391f, 0.01981176f, 
    -0.01360596f, -0.04522071f, 0.02995816f, -0.01986273f, 0.01226878f, -0.00608294f, -0.03495460f, -0.00635413f, 
    0.00984679f, -0.02283851f, 0.02508110f, 0.02588928f, 0.02213455f, 0.00603351f, 0.01788300f, -0.00525297f, 
    -0.02541357f, -0.03977212f, 0.01457061f, -0.03309762f, 0.01916176f, -0.00251693f, -0.00796785f, 0.00871679f, 
    -0.02969310f, -0.02522014f, -0.02925265f, -0.00186430f, 0.03344952f, -0.00070853f, -0.00788614f, -0.04353106f, 
    0.00906060f, 0.01713364f, -0.00666995f, -0.00014590f, -0.00760732f, -0.03557950f, -0.01477394f, -0.03425337f, 
    0.02360349f, -0.02291263f, -0.04583752f, 0.01035144f, 0.00660178f, -0.01466633f, 0.00278446f, -0.01268279f, 
    -0.02636411f, -0.03406888f, -0.00264143f, 0.00854888f, 0.00799914f, 0.02254854f, 0.02180507f, -0.00212040f, 
    -0.00191202f, -0.03067557f, -0.02092206f, 0.01967438f, -0.00355723f, -0.02707142f, 0.01634637f, -0.00633127f, 
    -0.02524862f, -0.00553831f, 0.02157108f, 0.01729154f, 0.02419389f, 0.02549609f, -0.01194001f, -0.02121177f, 
    -0.04193849f, -0.02370374f, -0.02993560f, 0.00011664f, -0.00485379f, -0.01135754f, 0.01367762f, 0.00736432f, 
    -0.02256349f, -0.00954336f, 0.00551888f, 0.02455148f, -0.03815658f, -0.02166359f, 0.00874422f, 0.01877395f, 
    -0.03309925f, 0.02040129f, -0.00936469f, -0.03360656f, -0.00918892f, 0.00643523f, -0.01991261f, -0.03968515f, 
    -0.00732133f, 0.02167333f, -0.02984408f, -0.00494082f, 0.00928552f, -0.00715810f, 0.01596892f, -0.01160017f, 
    0.01106153f, 0.00148259f, -0.02381309f, -0.01941823f, -0.00979231f, -0.01056049f, -0.02179136f, -0.03353610f, 
    -0.02086368f, -0.04351142f, 0.01890136f, 0.00439820f, 0.01976963f, -0.00130137f, -0.01455392f, -0.01409490f, 
    -0.02728416f, -0.02579177f, -0.01347878f, -0.02859266f, 0.00626176f, 0.01280293f, 0.02383934f, 0.00415651f, 
    -0.02080490f, -0.02637170f, -0.00245474f, 0.01708716f, -0.01427099f, -0.00826427f, -0.02738810f, 0.00751485f, 
    -0.04412205f, 0.00022127f, -0.04155307f, -0.03631661f, -0.02790613f, 0.01154111f, 0.00043690f, 0.02435706f, 
    0.01193061f, 0.00984563f, -0.02003689f, -0.04410206f, -0.03139818f, 0.00281231f, -0.03459368f, 0.02335007f, 
    0.02642982f, -0.02761334f, 0.03401089f, -0.01271157f, 0.00765003f, -0.02542301f, -0.03953504f, -0.00636108f, 
    0.00369383f, -0.01219412f, -0.04161819f, -0.04032224f, -0.01515082f, 0.01833035f, -0.00745154f, -0.01563866f, 
    -0.01289482f, -0.01772577f, 0.00360237f, 0.01982448f, -0.03248482f, -0.03566517f, 0.01241573f, -0.02592556f, 
    -0.00089872f, 0.01264582f, 0.02262663f, 0.01295072f, 0.01949391f, -0.03582512f, -0.01554760f, -0.04020468f, 
    -0.03190786f, -0.00527540f, 0.01879315f, -0.01005801f, -0.03092772f, -0.03184075f, 0.00555243f, 0.01046314f, 
    -0.00438336f, -0.01213092f, -0.02018519f, 0.00219326f, -0.01254215f, 0.00660901f, 0.01697956f, -0.03801777f, 
    -0.03177245f, -0.04219885f, -0.04055255f, 0.02479227f, -0.00333702f, -0.00522767f, -0.01607875f, 0.00580312f, 
    0.00024103f, -0.03894922f, -0.04494446f, -0.04007183f, -0.03711196f, -0.00786949f, 0.00777070f, -0.02536208f, 
    0.02305871f, -0.00805974f, -0.00964113f, -0.02244557f, 0.01424099f, -0.01751303f, -0.02573891f, 0.01974054f, 
    0.01214784f, -0.00426343f, -0.00685554f, -0.00266521f, 0.00495909f, -0.00435493f, 0.02888534f, 0.00473220f, 
    -0.00965811f, 0.02455053f, 0.00800884f, 0.00374844f, 0.01061128f, -0.03209461f, -0.02640409f, 0.01169791f, 
    -0.02729570f, -0.03684844f, -0.04236775f, -0.00618463f, 0.00192539f, -0.02339548f, -0.00111234f, 0.02424148f, 
    0.02313987f, 0.01332140f, -0.01610779f, 0.01837878f, -0.00825572f, -0.03944739f, 0.01166890f, -0.03092330f, 
    -0.02991417f, -0.01388548f, 0.01467098f, 0.00051846f, 0.02626995f, -0.00396089f, -0.04411394f, 0.02063611f, 
    0.02179035f, -0.01704914f, -0.00868053f, 0.01771708f, -0.01175595f, 0.00089413f, -0.02490288f, -0.01512132f, 
    -0.02360477f, -0.03001472f, -0.03096138f, 0.00724817f, -0.02342603f, 0.01759378f, 0.02162224f, 0.00350344f, 
    -0.03181693f, -0.00726836f, 0.00262481f, -0.00359011f, -0.02472528f, -0.00989721f, 0.01719934f, 0.02381513f, 
    -0.03986207f, 0.02281636f, -0.02709738f, -0.00150696f, -0.02993049f, 0.00607560f, 0.01127484f, -0.01510813f, 
    -0.03190295f, -0.02124288f, -0.02356986f, 0.03315210f, 0.02346225f, 0.01958641f, 0.03659424f, -0.01991785f, 
    0.01520866f, 0.00611021f, -0.00709635f, 0.03181216f, -0.01233188f, 0.00606373f, -0.00140877f, 0.00618160f, 
    0.01452251f, 0.02610675f, -0.01334048f, -0.02482844f, -0.01396590f, 0.01179041f, 0.00800437f, -0.02179508f, 
    0.01184185f, 0.02045405f, 0.02332788f, 0.02913176f, 0.00071775f, -0.02049534f, 0.00978334f, 0.00451686f, 
    -0.03714379f, 0.03016168f, -0.02505762f, -0.02572914f, 0.02758204f, 0.02492628f, -0.03266748f, -0.02650431f, 
    0.01423383f, 0.02763129f, 0.00882013f, -0.00483399f, -0.04063028f, 0.00310099f, 0.02971971f, 0.01917610f, 
    0.02064626f, 0.00760748f, -0.01963889f, -0.02852678f, -0.00426193f, -0.03185654f, -0.02191889f, -0.04006602f, 
    0.00523923f, 0.01078856f, -0.01993048f, -0.01944828f, -0.01303709f, -0.02091933f, 0.00156185f, -0.01409798f, 
    -0.03010768f, -0.01739118f, -0.01490940f, -0.00887451f, 0.02571343f, -0.00535647f, -0.03697714f, -0.01999416f, 
    -0.00777374f, -0.03626634f, 0.02430604f, -0.03278403f, -0.01518329f, 0.02178447f, 0.01745140f, 0.00663065f, 
    -0.00570566f, -0.02421428f, 0.01625264f, 0.01727679f, -0.00136202f, 0.01528095f, 0.02248141f, 0.02427800f, 
    0.03001113f, 0.00561910f, 0.01995227f, 0.02232457f, -0.01950561f, 0.02043694f, 0.01287458f, -0.00811588f, 
    0.00978025f, 0.02361406f, -0.04062271f, -0.02260439f, -0.03114720f, 0.01737992f, 0.01764425f, 0.01289745f, 
    0.02011794f, 0.01748358f, 0.00264892f, 0.02925361f, 0.02642263f, -0.02857358f, -0.00297276f, -0.03606293f, 
    -0.01407381f, -0.02208033f, 0.02137934f, -0.02150924f, 0.00824476f, 0.00576382f, 0.01284388f, -0.02207875f, 
    -0.01497621f, -0.02659009f, 0.02458598f, -0.03056058f, 0.00527763f, 0.02393167f, 0.00920844f, -0.03257370f, 
    -0.00730038f, 0.01828454f, 0.01215809f, -0.02514602f, -0.02449631f, 0.00700996f, 0.00590606f, 0.01463139f, 
    0.02037914f, -0.01871585f, -0.03026714f, 0.02060208f, 0.02851689f, -0.00735250f, 0.01746693f, -0.04160594f, 
    -0.02022244f, -0.03445510f, -0.00656574f, 0.00834652f, 0.00610591f, 0.02839505f, -0.02246236f, -0.01977592f, 
    0.02852468f, -0.02276311f, 0.01160849f, -0.00031696f, -0.02009073f, -0.00480014f, -0.01776511f, 0.00097106f, 
    -0.03757672f, 0.02178947f, 0.00400101f, -0.02017628f, 0.01465734f, 0.00096077f, -0.01509498f, 0.00962160f, 
    0.01015604f, -0.04087166f, -0.02228521f, 0.02906406f, -0.02888573f, 0.00597813f, -0.01553839f, -0.02212765f, 
    -0.00196595f, -0.02818737f, 0.02807946f, -0.02325965f, -0.02726402f, 0.00419607f, -0.02449905f, -0.01411382f, 
    -0.04051938f, -0.02830119f, 0.01608726f, -0.02527818f, -0.01126714f, 0.02577972f, 0.00287264f, -0.01835187f, 
    0.01164333f, -0.00532252f, -0.02888823f, -0.03740472f, 0.00824642f, -0.03595815f, -0.02885088f, 0.00966827f, 
    -0.00329485f, -0.01553536f, 0.02783474f, -0.00385729f, -0.04021038f, 0.01174174f, 0.00644362f, -0.01874866f, 
    -0.02972889f, -0.02687348f, -0.01113007f, -0.03808709f, 0.00520527f, -0.00263075f, 0.01028915f, -0.01913560f, 
    0.02811570f, -0.00867460f, -0.03173234f, -0.01080008f, -0.03095620f, -0.02273961f, 0.01498685f, 0.01095671f, 
    -0.01092158f, -0.03625445f, -0.02494855f, -0.00640804f, -0.00593152f, -0.02992046f, -0.00026812f, -0.01442977f, 
    -0.01423410f, -0.02360044f, 0.02478013f, -0.00255767f, 0.01634892f, -0.00594555f, 0.01049614f, 0.02815965f, 
    -0.04046511f, 0.02968303f, -0.02802963f, -0.04110676f, -0.04147601f, 0.01446464f, 0.01405085f, -0.01382668f, 
    -0.01891538f, -0.01920312f, 0.02940177f, -0.01772670f, 0.01683303f, -0.00838317f, -0.02433385f, -0.01804045f, 
    -0.03847900f, -0.03299106f, -0.01635075f, -0.01630192f, 0.00222477f, 0.00153675f, -0.00498028f, 0.01749556f, 
    -0.03792625f, -0.02657187f, -0.00352716f, -0.02048485f, 0.02844323f, 0.02743141f, 0.02054897f, -0.04109726f, 
    -0.03638713f, -0.01018732f, 0.01158040f, -0.00213478f, -0.01900530f, -0.00757382f, -0.01384621f, -0.00078732f, 
    -0.00801233f, -0.00729950f, -0.01340384f, -0.00755948f, -0.02737084f, 0.01633592f, -0.03127170f, -0.00705839f, 
    -0.03873081f, 0.02551349f, 0.00683991f, 0.02246365f, 0.00902499f, -0.00375262f, -0.00071708f, 0.02576600f, 
    0.01226921f, 0.01153095f, -0.00292428f, -0.01650284f, -0.01483607f, 0.02359430f, -0.03130465f, 0.01716724f, 
    -0.03543784f, -0.03264849f, -0.01223035f, 0.01651841f, -0.02686329f, -0.03052680f, 0.01697623f, -0.00277671f, 
    -0.00949224f, -0.01469710f, -0.03337419f, -0.02157767f, -0.02647820f, 0.00293144f, 0.00320227f, -0.02233837f, 
    0.00473596f, 0.03003871f, -0.03569946f, 0.01045550f, -0.00022518f, 0.00886670f, -0.02234195f, -0.00453503f, 
    0.02350331f, -0.04048987f, 0.00265377f, -0.02339509f, -0.00484565f, 0.00651818f, 0.02358645f, -0.03541544f, 
    -0.00509014f, -0.02229871f, 0.02184500f, 0.01404632f, 0.01291548f, 0.00346461f, 0.01311418f, -0.03208681f, 
    -0.00564213f, 0.00406733f, -0.03258060f, -0.03909980f, 0.02488218f, -0.01756752f, 0.02833623f, 0.02090254f, 
    0.00369367f, -0.00234303f, 0.00380825f, -0.02072920f, 0.02863017f, -0.01884090f, -0.03766650f, 0.01782370f, 
    -0.01368742f, 0.00389155f, -0.03340177f, 0.02756557f, 0.00461995f, 0.02476130f, -0.01432151f, 0.02962864f, 
    0.02397095f, -0.02668199f, -0.00090843f, -0.01985401f, -0.01330411f, -0.02298234f, -0.01139766f, 0.01134890f, 
    0.02845630f, 0.01407765f, -0.02072954f, -0.04180833f, -0.00303388f, 0.01684977f, -0.02832702f, 0.02944298f, 
    -0.00411191f, -0.01972827f, -0.01666163f, 0.02030904f, -0.00589088f, 0.00452703f, -0.00570142f, 0.02928267f, 
    -0.00612079f, 0.00953004f, -0.01361852f, 0.01114795f, 0.01995409f, 0.02261614f, -0.00762504f, -0.00926945f, 
    0.00480340f, -0.00785830f, 0.00624107f, -0.03193023f, -0.01879039f, 0.02640077f, 0.01822974f, -0.02404405f, 
    0.02814301f, -0.03335670f, -0.03927478f, -0.01678697f, 0.00954209f, 0.01302647f, -0.03342171f, 0.01094701f, 
    0.01304309f, 0.00301438f, 0.00940469f, -0.02496601f, -0.01223739f, -0.03622096f, -0.02587977f, -0.02942961f, 
    -0.03576215f, -0.03384431f, 0.02019962f, 0.00017757f, -0.00375312f, 0.02180618f, -0.03835559f, -0.00130985f, 
    0.02158297f, -0.01933075f, 0.02501209f, -0.03773738f, 0.00938152f, 0.00106926f, 0.00334097f, 0.02350361f, 
    0.01532690f, -0.01745221f, 0.01812021f, 0.01535431f, 0.01902891f, -0.02637205f, -0.03852392f, 0.01680969f, 
    0.02796468f, -0.02317904f, 0.00258405f, 0.01376172f, -0.00891489f, -0.01005232f, 0.00321325f, -0.01232971f, 
    -0.02787784f, -0.00711342f, -0.01036912f, -0.00424374f, -0.03082730f, -0.03370097f, -0.00929736f, -0.00495668f, 
    -0.03575963f, 0.00599565f, 0.01071758f, 0.02301801f, -0.01712415f, -0.03127719f, -0.03852529f, -0.00736903f, 
    0.02637387f, -0.03906797f, -0.03455122f, 0.01364520f, -0.01165498f, -0.02247444f, -0.00259380f, 0.00235167f, 
    -0.00273975f, 0.02893274f, -0.01599500f, 0.01320694f, -0.04157795f, 0.02974650f, -0.00030816f, -0.02605875f, 
    -0.03880900f, 0.00201439f, -0.00006597f, -0.00044779f, 0.00659862f, -0.02025896f, 0.00703734f, -0.03567177f, 
    -0.00547759f, 0.03321949f, 0.00604260f, -0.00108050f, 0.01454542f, -0.00025309f, -0.02842888f, -0.02388080f, 
    -0.02903198f, 0.01022144f, 0.00692249f, -0.02110613f, 0.02357443f, -0.02273861f, 0.02680581f, 0.00125427f, 
    -0.00282243f, -0.00948594f, -0.00790502f, -0.02973447f, -0.03742279f, -0.00535011f, -0.00898781f, 0.00802997f, 
    -0.03664268f, -0.04131832f, -0.01767123f, 0.02467198f, -0.02174985f, -0.00617821f, 0.01987059f, 0.02603399f, 
    -0.01617817f, 0.01078288f, -0.01198116f, -0.00179090f, 0.00328300f, 0.02982235f, -0.02180928f, -0.01994279f, 
    -0.03300170f, -0.01326401f, -0.03252767f, -0.01385806f, 0.00872777f, 0.00940720f, 0.02959203f, -0.03846901f, 
    0.02741532f, -0.03681826f, 0.00593883f, 0.01699881f, -0.03826875f, 0.00497703f, 0.00678148f, 0.00976380f, 
    -0.01631709f, -0.02049159f, -0.02967071f, 0.00547062f, 0.00188926f, -0.03244177f, 0.02331629f, -0.01530428f, 
    -0.02334599f, -0.02298283f, -0.01527980f, -0.01779638f, -0.02875796f, 0.01409287f, 0.02835890f, -0.03590983f, 
    0.00003766f, -0.03232723f, 0.02076646f, 0.00326237f, -0.02424010f, -0.00678886f, -0.00121154f, 0.00450447f, 
    0.02065347f, 0.00203078f, 0.00676183f, 0.00551440f, 0.00869782f, -0.02853496f, -0.01819210f, 0.01754151f, 
    -0.00054612f, -0.01095879f, -0.03389175f, -0.04094954f, -0.02660751f, 0.00620104f, 0.00262169f, -0.01386095f, 
    -0.00707786f, -0.04043448f, -0.02441026f, -0.02573590f, -0.00542520f, -0.01442292f, 0.01861035f, -0.03285563f, 
    0.01491828f, -0.04060018f, -0.00970855f, 0.00868602f, 0.01833650f, -0.00823128f, -0.01608768f, -0.02154350f, 
    0.00280822f, 0.01521665f, -0.02968577f, 0.02086555f, -0.04192395f, -0.03423645f, -0.02337567f, 0.02349819f, 
    0.01839697f, -0.03636198f, 0.00021091f, -0.00195632f, -0.01204301f, -0.00697192f, -0.01849467f, 0.02591682f, 
    0.00016973f, -0.03207205f, -0.01917225f, 0.02478817f, 0.01892537f, -0.01320148f, -0.00021523f, -0.01738845f, 
    -0.03232455f, -0.00422541f, -0.02042674f, -0.00736918f, -0.03849181f, -0.02002896f, -0.01025022f, -0.00394250f, 
    -0.02806094f, -0.03780546f, 0.02658454f, -0.03137513f, 0.02660876f, -0.03692537f, -0.02516379f, -0.02690384f, 
    -0.02493106f, 0.01352778f, 0.00676331f, -0.00622600f, -0.02283570f, -0.01125382f, 0.02648547f, -0.01659933f, 
    -0.00102400f, -0.03310542f, -0.00824409f, 0.02381835f, 0.02053879f, -0.03235310f, 0.02287601f, -0.02307348f, 
    -0.03667995f, 0.02806414f, -0.01065173f, 0.00525389f, 0.01031381f, 0.00624113f, -0.03011770f, 0.00650955f, 
    -0.02022686f, 0.02911264f, 0.02098702f, -0.00384995f, 0.02654254f, -0.02410581f, -0.04140152f, 0.02012223f, 
    -0.00527771f, -0.02817523f, -0.03142780f, 0.02180734f, -0.03825006f, 0.00269145f, -0.01288566f, 0.01486082f, 
    0.00834658f, -0.03189395f, -0.01776413f, -0.04178328f, 0.02132295f, 0.01642117f, -0.01839842f, 0.02274748f, 
    0.01816223f, 0.00651121f, 0.01528438f, 0.02201986f, 0.02331406f, -0.03016507f, 0.00775825f, 0.01412230f, 
    0.01804721f, -0.02876051f, -0.00235674f, -0.03028277f, -0.00630797f, -0.04089081f, -0.00683756f, 0.02137676f, 
    -0.02636764f, -0.01911604f, 0.02547432f, -0.03383027f, -0.04186264f, 0.01493690f, -0.03710531f, -0.00238075f, 
    -0.00602849f, -0.03715923f, 0.00424962f, -0.01595877f, -0.02566064f, -0.03725825f, 0.01608817f, 0.00824868f, 
    -0.01323069f, -0.03809593f, -0.00633892f, 0.02411088f, 0.02519121f, 0.01858831f, -0.03904738f, -0.01138563f, 
    -0.01905842f, -0.03023051f, -0.03375003f, -0.02329398f, 0.01364133f, 0.02489698f, 0.02144837f, -0.02685121f, 
    0.02985786f, 0.01854447f, -0.03311142f, 0.02935268f, -0.00691757f, -0.03121375f, -0.03131854f, 0.01614592f, 
    -0.03882778f, -0.03214032f, 0.01833680f, -0.04201705f, -0.02164958f, 0.02839691f, -0.02377039f, -0.01378289f, 
    -0.03730704f, -0.01769033f, -0.01471706f, 0.03596801f, -0.00617643f, -0.02715044f, 0.01495080f, -0.00639497f, 
    -0.03993991f, 0.00044895f, -0.02206718f, 0.02334015f, -0.04113512f, 0.02062341f, -0.02882178f, 0.01509026f, 
    0.02445995f, -0.03317716f, 0.01400626f, -0.03714747f, 0.01737491f, -0.00837523f, -0.02621820f, -0.02375388f, 
    0.00471129f, -0.02746358f, -0.01759059f, -0.00654320f, 0.02001389f, -0.04015744f, -0.04042674f, -0.01033089f, 
    -0.01449372f, 0.00101469f, -0.03952483f, -0.03039742f, -0.03064511f, 0.02097665f, -0.02258557f, 0.00935338f, 
    0.32696792f, 0.11915895f, 0.15664534f, 0.06458053f, -0.07055739f, -0.05146533f, -0.06352649f, 0.04058891f, 
    -0.09504415f, 0.01187679f, 0.07287291f, -0.08310575f, 0.12720273f, -0.10702410f, -0.04267223f, 0.03205396f, 
    0.15461265f, 0.03988384f, -0.11177862f, -0.06577593f, 0.00381974f, -0.04674878f, -0.05014163f, 0.07616826f, 
    -0.19294101f, 0.01323657f, 0.02535968f, -0.07703805f, 0.01143751f, 0.03929379f, 0.04889997f, 0.08211593f, 
    0.05756069f, 0.03450532f, 0.00476201f, -0.11794288f, -0.04717909f, 0.04663663f, -0.15360729f, 0.13145834f, 
    0.08227068f, 0.09663410f, -0.02857443f, -0.01418210f, 0.00475498f, 0.12857926f, -0.10811605f, -0.09970398f, 
    -0.14145774f, -0.01076749f, 0.13554958f, -0.07692445f, -0.07890867f, -0.04457636f, -0.05325626f, 0.01507295f, 
    0.04001802f, 0.04116340f, 0.10432582f, 0.03142479f, 0.05927048f, -0.15476631f, -0.18049285f, 0.22656624f, 
    0.15275939f, 0.08734334f, 0.03224349f, -0.04161090f, -0.02861702f, 0.06846264f, 0.03088267f, 0.04179981f, 
    0.27738345f, -0.00439547f, -0.18560949f, 0.09048332f, 0.17334315f, -0.04118270f, 0.05179231f, -0.11157175f, 
    -0.03072519f, 0.00620162f, -0.05228938f, -0.01127142f, -0.20790373f, -0.19296603f, 0.07302883f, -0.13365990f, 
    -0.10592112f, 0.02222232f, -0.08488862f, 0.06915805f, 0.04206332f, 0.04022979f, -0.02638734f, 0.10752107f, 
    0.14639127f, 0.04537654f, -0.12092979f, -0.01780260f, 0.02854775f, 0.00653561f, -0.00112177f, 0.12488811f, 
    -0.07326721f, -0.04720103f, -0.01126937f, 0.00769482f, 0.05210786f, 0.03734563f, -0.15279600f, 0.03712735f, 
    0.09286139f, -0.04897092f, 0.01774927f, -0.06353409f, 0.15334244f, 0.01313860f, -0.00019879f, 0.01246065f, 
    0.11848812f, 0.19756284f, -0.12867683f, 0.03674321f, 0.01893224f, -0.07602891f, -0.00363898f, -0.13148637f, 
    -0.01106958f, 0.12721498f, 0.07571130f, -0.07870223f, 0.20542400f, 0.13836445f, 0.01459677f, 0.27852085f, 
    0.05739558f, -0.05485636f, -0.08690719f, 0.02462865f, -0.00342831f, 0.01225465f, -0.01912625f, 0.01016914f, 
    0.07898723f, 0.01721121f, -0.10045295f, -0.03480878f, 0.06081650f, 0.03643991f, 0.09393403f, -0.04855482f, 
    0.04463261f, -0.05793533f, 0.09049592f, 0.00016262f, 0.22555865f, -0.08284500f, 0.02064992f, 0.08343329f, 
    0.07870939f, 0.11908054f, 0.08580502f, -0.09237898f, -0.03556988f, -0.02878916f, 0.03512155f, 0.05383924f, 
    0.06631143f, 0.04757523f, 0.08514420f, 0.16810958f, -0.05478554f, -0.05735910f, 0.00894026f, 0.05789643f, 
    -0.06484000f, -0.00364059f, -0.01244049f, -0.07780880f, 0.27326643f, -0.07523464f, -0.13004644f, 0.21896957f, 
    -0.06973395f, -0.10948214f, 0.03344234f, -0.00642616f, 0.05565500f, 0.01292023f, 0.01416046f, 0.06676994f, 
    0.06448988f, -0.02841541f, 0.04868303f, -0.10801018f, 0.16554771f, 0.04793426f, 0.03078472f, 0.01721866f, 
    0.00261299f, -0.05079203f, 0.01582730f, 0.05686022f, 0.25589445f, -0.02562553f, 0.17288791f, -0.01100795f, 
    -0.07075319f, 0.02281221f, 0.07493770f, 0.03767452f, 0.01442235f, -0.04702593f, -0.06606492f, 0.01413246f, 
    -0.18401425f, -0.00222136f, -0.13321538f, 0.12812524f, 0.04376549f, -0.02119890f, -0.06157446f, 0.07300283f, 
    -0.03163958f, -0.05490755f, 0.02760063f, -0.14911467f, 0.01936768f, 0.11580222f, -0.02345354f, -0.01321714f, 
    0.05581560f, -0.05689451f, 0.01019664f, 0.02019307f, 0.15159576f, 0.04875588f, -0.02848629f, -0.02171163f, 
    -0.21991257f, 0.03225050f, -0.02899527f, -0.19217351f, -0.02194999f, -0.02714289f, -0.04988105f, 0.11706956f, 
    0.01907437f, 0.09166375f, 0.07916861f, 0.03537185f, -0.00808498f, -0.14239305f, 0.10964295f, -0.24780340f, 
    -0.09200281f, 0.22854261f, -0.11979984f, 0.04212112f, 0.16627842f, -0.07913397f, -0.00553711f, 0.00858147f, 
    0.17655319f, 0.02345172f, -0.17229503f, -0.07922833f, -0.03315889f, 0.11249689f, -0.04091619f, 0.04301771f, 
    0.03218024f, 0.05381907f, -0.05175272f, 0.02849926f, 0.28195468f, 0.05880221f, 0.04601942f, 0.13948286f, 
    -0.02582377f, 0.09745369f, -0.00006556f, 0.05857330f, -0.00925746f, -0.00948729f, 0.05571928f, -0.08276580f, 
    0.08963704f, 0.06345742f, 0.10040644f, 0.35609072f, -0.08533474f, -0.17319985f, -0.06901182f, 0.01357196f, 
    0.09309401f, 0.07594324f, 0.12102797f, -0.08270282f, 0.04129181f, -0.00203079f, -0.00174415f, -0.02031783f, 
    0.01404527f, -0.02709319f, -0.04342290f, 0.02682768f, 0.05058828f, 0.00398867f, -0.04350620f, 0.03076234f, 
    0.06219690f, -0.16069151f, -0.01435082f, -0.25891092f, -0.00970991f, 0.03961649f, -0.06278705f, 0.00371088f, 
    -0.02279832f, -0.01475174f, -0.00901346f, 0.00535830f, 0.01377077f, -0.07997953f, 0.05487422f, -0.18462798f, 
    0.01272870f, 0.03362509f, 0.09018776f, 0.08587514f, 0.07590570f, -0.00309234f, -0.04395953f, -0.04577329f, 
    -0.11424344f, -0.14346150f, 0.07879794f, 0.01751405f, -0.11082757f, 0.07898501f, -0.13744253f, -0.17148164f, 
    -0.04826802f, 0.03523136f, -0.05226902f, -0.03288453f, 0.21098773f, 0.11304692f, -0.08831661f, 0.00074415f, 
    -0.07785008f, -0.05503206f, -0.07828455f, 0.02524652f, -0.14573839f, 0.04981150f, -0.05293258f, 0.03047247f, 
    0.00033278f, 0.13267438f, 0.07091454f, 0.16989930f, -0.08472952f, -0.06987564f, 0.02820084f, 0.10423253f, 
    0.06466078f, 0.01952292f, 0.03282412f, -0.08373129f, -0.04175451f, 0.06504297f, -0.08459327f, -0.06889036f, 
    0.10839703f, 0.02096419f, -0.00036258f, -0.04299313f, 0.02936179f, 0.03654929f, 0.11504433f, 0.11805145f, 
    0.23374726f, -0.27510422f, 0.06477154f, -0.02457231f, 0.14578599f, -0.03796668f, -0.03787837f, -0.10601810f, 
    -0.12140764f, 0.02553606f, -0.09958115f, 0.06927598f, 0.01650072f, 0.18278646f, 0.04025376f, 0.08641244f, 
    -0.00617224f, 0.09288105f, -0.00160589f, -0.11477987f, 0.10025202f, 0.02495688f, 0.08377149f, 0.06923354f, 
    -0.17531019f, -0.00719548f, 0.15624797f, 0.15718503f, 0.08203841f, -0.11058862f, -0.02522931f, 0.15057020f, 
    0.00446571f, -0.03081620f, 0.01646277f, -0.09461498f, 0.18706945f, -0.08796235f, -0.01138223f, -0.26520532f, 
    0.07156442f, 0.02116803f, 0.02946277f, -0.01698823f, -0.01142299f, -0.01601378f, -0.00040543f, 0.03807458f, 
    0.32686016f, 0.05638527f, -0.17759234f, 0.02559234f, -0.01974818f, -0.08397164f, 0.12439229f, -0.04678822f, 
    0.07140607f, 0.07639071f, 0.06739073f, 0.06114069f, 0.05878777f, -0.08040304f, 0.02429963f, -0.03115672f, 
    -0.10604454f, 0.03784508f, -0.07418071f, 0.01003290f, -0.09681078f, -0.15124415f, -0.02895982f, 0.05104208f, 
    0.18908224f, -0.06085454f, 0.15180686f, 0.21831903f, 0.00537901f, -0.09278709f, 0.08438753f, 0.04154563f, 
    0.13495363f, 0.13257797f, -0.01449366f, -0.13333631f, 0.24855170f, -0.02430463f, 0.09896074f, 0.17401168f, 
    0.04595423f, -0.10071447f, -0.02990165f, -0.00392057f, 0.12266400f, -0.06685784f, -0.08105268f, 0.01177701f, 
    0.09125256f, 0.00891724f, 0.07639118f, 0.34372619f, -0.03472270f, -0.07715943f, 0.00845639f, 0.00958419f, 
    0.09346005f, -0.07061566f, -0.00696631f, -0.09514822f, 0.08978823f, -0.29982501f, -0.16124614f, -0.01642305f, 
    0.18178946f, -0.10604788f, 0.08387134f, -0.05509568f, 0.05899969f, -0.02689331f, 0.05174622f, -0.01801584f, 
    -0.01794465f, -0.03722590f, 0.04250831f, -0.23008488f, 0.01689412f, 0.03892895f, -0.06313042f, 0.01364829f, 
    -0.04050350f, 0.06815878f, 0.11393820f, 0.00597391f, -0.01720918f, 0.01714707f, 0.01232519f, -0.04494819f, 
    -0.06154143f, -0.06381568f, -0.02482579f, -0.04981336f, 0.00506656f, -0.01999486f, -0.09813786f, 0.02729472f, 
    0.21149036f, 0.08093709f, 0.13024564f, 0.17206138f, -0.06420882f, -0.01989992f, -0.04297234f, -0.01546624f, 
    0.00501868f, -0.06937030f, -0.02979776f, -0.01845345f, 0.12553647f, -0.00901833f, -0.17166723f, -0.07176915f, 
    0.00330232f, -0.10458758f, 0.14100707f, -0.05278101f, -0.01835681f, -0.01685190f, -0.03634182f, 0.01113844f, 
    0.13580975f, -0.02210228f, 0.02669815f, 0.08148263f, 0.04379623f, 0.10300691f, -0.02693753f, 0.15506652f, 
    0.17739311f, -0.03752195f, 0.04804899f, -0.04498884f, 0.34205276f, -0.21249060f, 0.05604156f, 0.18117659f, 
    0.09976393f, -0.03800090f, 0.12002026f, -0.06054837f, -0.15770648f, 0.01797352f, 0.00290674f, -0.01863267f, 
    0.11286905f, 0.20108663f, -0.01969813f, 0.12872250f, -0.04951296f, -0.00464827f, -0.04789706f, 0.05578189f, 
    0.10699838f, 0.00908136f, 0.08663970f, -0.18351178f, -0.01008089f, -0.13542385f, -0.11099497f, -0.06247466f, 
    0.04207893f, 0.08146466f, 0.08165626f, 0.03101512f, 0.06749564f, -0.05979905f, 0.17445953f, 0.13303068f, 
    0.03165169f, -0.04193299f, 0.08893269f, 0.06023833f, -0.06337953f, 0.11891679f, 0.04220700f, 0.03874734f, 
    0.09949812f, 0.01023914f, -0.11206209f, 0.03606043f, -0.12282962f, 0.05262964f, -0.07823158f, -0.01257984f, 
    0.05864738f, -0.02273385f, 0.00430647f, -0.02153857f, 0.02990708f, 0.06113138f, 0.10629816f, -0.10108039f, 
    0.02752834f, 0.02131702f, -0.00514075f, 0.14017265f, -0.14934839f, -0.04686945f, -0.03458257f, 0.07382819f, 
    -0.06873295f, -0.01925567f, 0.02876981f, -0.12980892f, 0.08793710f, -0.03639428f, 0.09306763f, 0.31310725f, 
    0.00342156f, -0.08693706f, -0.04358375f, -0.00800242f, -0.13531102f, 0.13135840f, -0.05540265f, -0.08871277f, 
    0.10745056f, 0.10558169f, -0.04998681f, -0.01110037f, 0.15710405f, -0.12027948f, 0.02752430f, 0.03510211f, 
    -0.09933215f, 0.07252005f, 0.09176084f, -0.01225191f, 0.35296646f, 0.08710884f, 0.13939366f, 0.00174428f, 
    -0.03249974f, 0.02875709f, -0.04082944f, 0.10600791f, -0.04839677f, 0.05385109f, 0.13224748f, 0.03181475f, 
    -0.55106032f, 0.07894245f, -0.01550486f, -0.32502025f, 0.02731083f, 0.03619227f, -0.10751650f, 0.06119971f, 
    -0.05311516f, 0.06345642f, 0.01103460f, -0.02091592f, 0.11113548f, 0.00368124f, 0.08273394f, -0.18140011f, 
    -0.01263596f, 0.04045175f, -0.08228140f, -0.03401914f, -0.06159220f, -0.05418588f, -0.09464452f, 0.04400801f, 
    0.56213641f, 0.26961091f, -0.02144853f, -0.11966940f, 0.15383977f, 0.07618682f, 0.03389408f, -0.01591679f, 
    -0.06426542f, -0.15606360f, 0.00034055f, -0.02257315f, 0.36783344f, 0.01813191f, -0.17217661f, 0.28916389f, 
    -0.03170937f, -0.00780714f, 0.02407142f, -0.05224176f, 0.13920653f, 0.13119346f, -0.00328196f, -0.10184424f, 
    0.13557465f, -0.05608998f, -0.05197617f, -0.12311868f, 0.14397542f, -0.03018012f, -0.06215155f, 0.08585943f, 
    -0.03852307f, -0.00289979f, -0.12395079f, -0.05048669f, 0.08027305f, 0.23250948f, -0.24105136f, 0.09576382f, 
    -0.06313882f, 0.10146922f, 0.01399782f, -0.02385703f, -0.05224915f, -0.03350501f, 0.09273431f, -0.00769072f, 
    -0.25241160f, -0.11260757f, 0.01022408f, 0.04837213f, 0.02944798f, -0.00241364f, 0.03967335f, 0.02893126f, 
    0.07283928f, -0.10151852f, 0.01340106f, -0.06145467f, -0.14243126f, -0.13284278f, 0.00902557f, 0.20318674f, 
    0.17274362f, -0.07757798f, -0.04846504f, -0.10229432f, 0.02187131f, 0.01474497f, 0.06151528f, 0.03208880f, 
    -0.03547744f, -0.02771025f, 0.02627233f, 0.00482067f, -0.01188746f, -0.03786832f, 0.01432930f, -0.02106591f, 
    0.02026521f, 0.01111483f, -0.01417951f, 0.00974156f, -0.02535621f, -0.02292148f, -0.03218795f, -0.03600656f, 
    0.01880907f, 0.01661475f, 0.01413668f, -0.03280455f, 0.00534692f, -0.01801110f, -0.02666455f, -0.03159962f, 
    -0.02459782f, 0.00617597f, -0.01821827f, 0.02177554f, -0.04138861f, 0.00062421f, -0.00441504f, 0.02188560f, 
    0.02815120f, 0.00161367f, -0.00779495f, 0.00335459f, 0.01442795f, 0.02145982f, -0.01086531f, -0.03100354f, 
    -0.04021183f, -0.02467711f, 0.00759958f, -0.01529152f, 0.02492139f, -0.01746441f, 0.00389155f, -0.00620386f, 
    -0.01265719f, 0.01219602f, -0.00350439f, -0.02642580f, -0.02895112f, -0.02815908f, -0.03163273f, 0.01061455f, 
    -0.03924116f, -0.01024763f, -0.03029577f, 0.01050909f, -0.02860220f, -0.00695859f, -0.01349180f, -0.03344110f, 
    -0.01316587f, 0.00082350f, -0.03619101f, -0.02414772f, -0.01893027f, -0.00535610f, 0.01718429f, 0.01099107f, 
    -0.00553703f, 0.02350193f, -0.04016149f, -0.00971962f, -0.03106812f, -0.02022352f, -0.01804851f, 0.01367154f, 
    0.00925769f, -0.02251620f, 0.00761112f, 0.00158142f, 0.01378043f, 0.02599639f, 0.00442735f, -0.02774444f, 
    -0.00504923f, -0.03455551f, 0.02708955f, -0.02389596f, -0.02961691f, -0.02512665f, 0.02686282f, 0.02867115f, 
    -0.01588234f, -0.01776909f, -0.01745232f, 0.01115012f, -0.01402634f, -0.02626925f, -0.04109258f, 0.02101485f, 
    0.02170553f, 0.00741143f, 0.02838389f, -0.02294805f, -0.02377384f, 0.02597587f, -0.00275684f, -0.00075521f, 
    0.01124105f, -0.02947260f, -0.01671801f, -0.03924709f, 0.01503205f, 0.00327231f, -0.03319790f, -0.01269602f, 
    0.02813946f, -0.02661052f, -0.01392734f, 0.00179117f, -0.03277082f, -0.02266920f, 0.00502198f, -0.03450041f, 
    -0.02378805f, -0.01151883f, -0.03667413f, -0.03486120f, 0.02890272f, -0.01746541f, -0.01167301f, -0.00878857f, 
    -0.01247946f, 0.02780475f, -0.04194604f, 0.02289812f, 0.02528826f, -0.00245804f, -0.03409410f, 0.02300386f, 
    -0.02005376f, 0.00892150f, -0.02155793f, -0.00165709f, -0.02947431f, 0.00882370f, 0.00281481f, -0.00891202f, 
    0.01800278f, -0.01431282f, -0.03329771f, -0.01645850f, -0.00096993f, -0.01945801f, 0.01942606f, 0.01041432f, 
    -0.02008630f, 0.00140992f, -0.02893570f, -0.00054902f, 0.01530221f, 0.02859788f, -0.03930438f, 0.00675179f, 
    0.00921000f, 0.00658129f, -0.04168862f, 0.02239585f, -0.03201739f, 0.01165256f, -0.00993780f, -0.03042258f, 
    0.02199119f, -0.01517229f, -0.01547456f, -0.03694301f, 0.02479596f, -0.01942571f, -0.02068542f, -0.01328600f, 
    -0.01799799f, -0.01626349f, 0.02469767f, -0.00989633f, 0.02008328f, 0.01954478f, -0.03160552f, 0.02255859f, 
    -0.00050019f, -0.03208999f, -0.03197832f, -0.04186638f, -0.03987383f, 0.01748722f, -0.02824915f, -0.00861019f, 
    -0.01194741f, -0.01981152f, 0.01643422f, 0.00257610f, 0.00034193f, 0.02841554f, -0.00389023f, 0.01085536f, 
    0.00813959f, -0.00016317f, -0.00584591f, -0.02132040f, -0.01484668f, -0.02011364f, -0.03793790f, 0.01754300f, 
    -0.04161882f, -0.03328871f, -0.02750342f, 0.02908822f, 0.00513063f, -0.03692961f, -0.03170620f, 0.02104329f, 
    0.01173999f, -0.02035776f, -0.01949865f, 0.00399514f, -0.02763133f, -0.00290034f, 0.01980169f, -0.03959198f, 
    -0.02163251f, -0.00580348f, -0.00366210f, 0.02815058f, -0.03779661f, -0.00149189f, 0.01474718f, -0.00089505f, 
    -0.01255844f, -0.00999063f, -0.00526718f, -0.01856807f, -0.03974421f, 0.02318952f, -0.03316917f, -0.02085881f, 
    0.02256256f, 0.02840079f, -0.02897180f, -0.01826730f, 0.02916264f, 0.02342680f, 0.02639480f, -0.03983965f, 
    -0.00042464f, -0.00514639f, -0.01426251f, 0.01719163f, 0.02636207f, -0.02517331f, 0.00317563f, -0.03903659f, 
    0.00337348f, -0.02161159f, 0.02642988f, -0.04125370f, 0.00681504f, -0.03249790f, -0.01240340f, 0.01891584f, 
    -0.00799430f, -0.00098696f, -0.01446337f, -0.03219550f, -0.02988560f, 0.01741991f, -0.02386315f, 0.00168150f, 
    -0.02859732f, -0.01206709f, 0.00374807f, 0.02275486f, 0.01362330f, -0.02494937f, -0.02667415f, -0.04126714f, 
    0.00767762f, 0.00905402f, -0.02003839f, 0.02206002f, 0.01728896f, -0.00596342f, -0.03891285f, 0.01448067f, 
    -0.02343905f, -0.01782282f, 0.01626934f, -0.04081414f, -0.00055064f, -0.03849398f, -0.03513594f, 0.03281264f, 
    -0.02900703f, 0.00346422f, 0.00813838f, 0.02912024f, -0.02242248f, -0.02344543f, 0.01689587f, -0.02911896f, 
    0.00837687f, 0.00776590f, -0.00215101f, 0.01094436f, -0.02408773f, -0.01785459f, -0.03614491f, 0.00735082f, 
    -0.01394878f, 0.02105892f, -0.02305070f, -0.02378403f, -0.04194061f, 0.02777313f, 0.00283138f, -0.00818299f, 
    0.02922156f, 0.00420739f, 0.02096041f, 0.01111021f, -0.02491526f, 0.01528901f, 0.00311324f, -0.02852615f, 
    0.00375114f, -0.03325408f, 0.00322353f, -0.01397318f, -0.03248529f, 0.00489462f, -0.02682344f, 0.01202641f, 
    0.01714634f, 0.02636291f, 0.00083668f, -0.00428084f, -0.03533645f, 0.01370789f, 0.00236438f, -0.01763890f, 
    0.02073171f, 0.03330984f, -0.01573075f, 0.02581401f, 0.02801018f, -0.01083636f, 0.01280931f, 0.00135334f, 
    -0.02238012f, 0.00244154f, 0.00264569f, -0.00708799f, 0.00666374f, -0.03362479f, -0.04068220f, -0.00750818f, 
    -0.00891114f, -0.03451828f, 0.00263676f, 0.01455780f, -0.03031425f, -0.01207765f, 0.00373969f, -0.03917904f, 
    -0.01290526f, 0.00370238f, -0.00636871f, 0.01179970f, -0.00136091f, 0.01986535f, -0.00232244f, -0.03362541f, 
    -0.01291257f, -0.00028761f, 0.02339349f, -0.02859787f, 0.02768611f, -0.02657886f, -0.00680675f, 0.02667939f, 
    -0.04083901f, 0.02894863f, 0.00301128f, -0.01615929f, -0.00916691f, 0.02738899f, -0.00631174f, -0.00792865f, 
    0.02620772f, 0.01912093f, -0.01908559f, -0.02229438f, -0.03685422f, 0.02104380f, -0.00271592f, -0.03832563f, 
    0.01325743f, 0.00529145f, 0.02115140f, -0.03606721f, 0.02924855f, 0.02115201f, 0.02480247f, -0.02385984f, 
    0.02459747f, -0.02591929f, -0.04026859f, -0.02205622f, -0.01345216f, 0.02355685f, -0.02870683f, -0.01723001f, 
    0.02109841f, -0.02849955f, 0.02846288f, -0.03583911f, -0.00301429f, 0.00862166f, 0.01724838f, -0.01826296f, 
    -0.03892423f, 0.00279376f, -0.03387947f, 0.03379580f, -0.00527688f, -0.02725063f, -0.03244036f, 0.01717934f, 
    0.01610387f, -0.03986368f, 0.01232261f, -0.03409938f, 0.01462330f, 0.02815036f, -0.02519043f, 0.02464209f, 
    -0.02123104f, 0.01898839f, 0.01856395f, 0.01776792f, 0.00896236f, -0.01226383f, 0.02885847f, -0.02617045f, 
    0.00729342f, -0.00141059f, -0.02009034f, 0.00054242f, 0.02199862f, 0.01565124f, 0.02691930f, -0.03347353f, 
    0.01051182f, 0.01529336f, 0.01435800f, 0.00626421f, -0.00213659f, -0.02902974f, -0.00746659f, 0.00900677f, 
    -0.01578863f, 0.02463898f, 0.00537650f, -0.02385936f, 0.02883872f, 0.01075310f, -0.03210954f, -0.02121240f, 
    0.01785330f, 0.00986174f, -0.01036149f, 0.00451241f, 0.01247473f, -0.02417988f, -0.03229005f, 0.01545858f, 
    -0.00321596f, -0.03084196f, -0.00049411f, 0.00897180f, 0.01868315f, -0.03957782f, -0.03543383f, 0.01242946f, 
    -0.00226030f, -0.00003134f, -0.00351670f, -0.02828868f, -0.02662100f, 0.02083796f, -0.02052968f, -0.01505266f, 
    0.01647403f, 0.00231161f, -0.03805694f, 0.02271712f, 0.01857672f, -0.02895092f, 0.00091767f, 0.00390018f, 
    -0.00761068f, 0.02912569f, -0.00224832f, 0.00222239f, -0.00771321f, -0.01020515f, 0.00746399f, -0.00077816f, 
    0.00655567f, -0.00831766f, -0.00733351f, -0.00387504f, -0.02395627f, -0.00147074f, -0.02539814f, -0.02692596f, 
    -0.03975172f, -0.01289967f, -0.04006165f, -0.03026803f, 0.00396556f, 0.02231642f, -0.00847273f, 0.01517904f, 
    0.01023124f, -0.02400591f, -0.03520654f, 0.01734403f, -0.01447193f, 0.02822233f, -0.02208850f, -0.03660086f, 
    0.00185194f, -0.01083857f, -0.03667702f, -0.00014627f, -0.02201535f, 0.01206948f, -0.01679422f, 0.00891692f, 
    0.02010132f, -0.03776785f, 0.02906393f, 0.00533545f, -0.03728737f, -0.02049529f, -0.02697236f, -0.02436310f, 
    0.01815501f, 0.01908269f, -0.04092322f, -0.03475204f, -0.02900456f, 0.00568030f, -0.01786140f, 0.00638959f, 
    0.00116231f, -0.03251133f, -0.01993754f, 0.00639439f, 0.00141335f, -0.03594696f, -0.02483517f, 0.01329611f, 
    -0.01960443f, -0.02855854f, 0.02234605f, -0.01536658f, -0.00075458f, -0.00542401f, -0.01319932f, -0.00053770f, 
    0.01976275f, -0.02282024f, 0.02034011f, -0.03486497f, -0.03539513f, -0.01128735f, 0.02371014f, 0.02716464f, 
    0.00567377f, 0.00293548f, -0.02320973f, -0.01342576f, -0.03030906f, 0.01708412f, -0.01329210f, 0.01219120f, 
    -0.04056570f, -0.02070135f, 0.01638308f, -0.02196186f, -0.01398038f, -0.02001397f, -0.00491405f, 0.01569406f, 
    -0.00938223f, 0.02249512f, -0.01038660f, 0.02191736f, -0.02315551f, -0.02039434f, -0.03415658f, -0.03833851f, 
    0.01656864f, -0.02827996f, -0.03385137f, -0.02916590f, 0.01168922f, 0.01772056f, -0.01362838f, -0.01504553f, 
    -0.03198433f, 0.01621955f, -0.01134157f, -0.00120283f, -0.03132409f, 0.01290195f, -0.03332940f, -0.00999726f, 
    0.00479278f, -0.02047750f, 0.02644404f, 0.01076107f, 0.00970563f, -0.02758359f, 0.01864692f, 0.00363035f, 
    0.01375681f, -0.01557542f, -0.03725389f, 0.01655760f, -0.01265978f, -0.00236966f, -0.00161611f, -0.00545264f, 
    -0.01293906f, 0.01229196f, 0.02459939f, -0.01919326f, -0.04034727f, 0.01622351f, -0.01780059f, -0.02547702f, 
    -0.03276891f, 0.02424338f, -0.01561440f, -0.01456853f, 0.02029133f, -0.02907928f, 0.02101992f, 0.01979656f, 
    0.00417441f, -0.03650819f, 0.00475498f, -0.03963725f, 0.00258111f, -0.03864830f, 0.00380630f, -0.02385909f, 
    0.02307226f, 0.01786106f, 0.00932500f, -0.00836581f, -0.01047608f, 0.01401259f, -0.00233954f, -0.02526020f, 
    0.01681170f, -0.00985805f, -0.00280475f, -0.00721983f, 0.00022622f, -0.00333890f, -0.03585785f, 0.00307554f, 
    -0.02733938f, -0.03700833f, -0.03742914f, 0.00049993f, -0.00783949f, 0.01560999f, -0.04004889f, -0.01425318f, 
    0.00397877f, -0.02126504f, 0.03428242f, -0.00690226f, -0.01787219f, 0.00747191f, -0.03684773f, -0.02090933f, 
    -0.02499444f, -0.03645371f, 0.02825375f, -0.03227787f, -0.02282484f, -0.04142545f, -0.02322524f, -0.02922054f, 
    -0.03674178f, 0.02179043f, -0.03318705f, 0.00624713f, 0.02198751f, 0.02839706f, 0.01760296f, -0.02976904f, 
    0.01671961f, 0.03576011f, -0.01178909f, 0.00855990f, 0.00695607f, -0.01418197f, -0.04108906f, 0.00931719f, 
    -0.00068640f, 0.00285334f, 0.00373289f, -0.02423374f, -0.02181862f, 0.01136763f, -0.02854025f, -0.00812202f, 
    -0.03938632f, 0.02636810f, -0.01210217f, 0.01917271f, 0.02574269f, -0.02073439f, 0.02415052f, -0.03288540f, 
    -0.02610683f, 0.01143863f, -0.03485410f, 0.02382720f, 0.00498556f, 0.02856173f, -0.03738073f, -0.03229373f, 
    -0.00901057f, -0.03825723f, 0.01491922f, 0.00249462f, 0.00874484f, -0.01453528f, -0.04187824f, -0.03438545f, 
    -0.02548407f, -0.00481899f, 0.01232244f, -0.00096823f, -0.00629170f, 0.00985459f, -0.00860251f, -0.01040705f, 
    -0.01382307f, -0.00119865f, 0.02257087f, -0.00720791f, 0.00034044f, 0.01184418f, 0.02884783f, 0.01574212f, 
    -0.00805916f, 0.00653081f, 0.01577610f, 0.00186112f, 0.00600070f, -0.03904832f, -0.00651387f, 0.01073701f, 
    -0.02133353f, -0.01209883f, 0.00480453f, -0.03772921f, -0.00942234f, 0.02465707f, 0.01160436f, 0.01880755f, 
    0.00014563f, -0.02914003f, -0.02422327f, 0.02641651f, 0.02081971f, -0.03027950f, -0.00546521f, 0.01338546f, 
    0.00555024f, 0.02360914f, 0.00055356f, -0.03274104f, -0.01200388f, 0.01315415f, -0.00435610f, 0.02807203f, 
    0.01932243f, -0.01705805f, -0.01502637f, -0.03866557f, -0.02717299f, 0.01023734f, -0.01586995f, 0.01737032f, 
    -0.01330115f, 0.02447026f, 0.02384442f, -0.04133363f, 0.02479763f, 0.01572903f, -0.03199299f, -0.00458797f, 
    -0.03668052f, -0.02274094f, -0.00052413f, -0.02860444f, 0.00675494f, 0.02469221f, 0.01529376f, 0.02127297f, 
    -0.01486255f, -0.03407971f, -0.01123122f, -0.02659181f, 0.00447511f, -0.00272118f, -0.02484321f, -0.02467794f, 
    -0.03763066f, -0.03954710f, -0.03976421f, 0.00324123f, -0.03206917f, -0.00127453f, -0.00124210f, -0.03546422f, 
    -0.02549751f, -0.01894746f, -0.03501190f, 0.01293060f, 0.02377212f, -0.00793371f, -0.01058789f, -0.01481135f, 
    -0.01844035f, 0.01539433f, -0.02692221f, -0.04322100f, -0.02494343f, 0.00547950f, -0.01094892f, 0.01727483f, 
    -0.00808671f, 0.01463554f, 0.03050823f, -0.04118215f, -0.03054739f, 0.01059650f, 0.03058320f, 0.02657848f, 
    -0.00723449f, -0.03846867f, -0.03009943f, -0.01905737f, -0.02123615f, 0.00771485f, 0.02531831f, 0.00256928f, 
    0.01607343f, -0.03610183f, -0.02114768f, -0.02805145f, 0.01112351f, 0.01677948f, -0.03094462f, -0.00954513f, 
    -0.02189003f, -0.01754607f, -0.00381144f, -0.02240694f, -0.03591119f, -0.00221061f, 0.00872669f, 0.02674885f, 
    -0.04132631f, -0.03597801f, -0.03060052f, 0.01252587f, -0.00770787f, -0.03994077f, -0.02875064f, -0.04163925f, 
    -0.01043458f, -0.01095691f, 0.00392413f, -0.01644059f, -0.03498702f, 0.00352644f, 0.02805687f, -0.02784243f, 
    0.01609769f, 0.02850530f, -0.01521011f, 0.01768569f, -0.04149497f, -0.00869590f, -0.00960733f, -0.02765762f, 
    -0.02333264f, -0.02059162f, 0.01629351f, 0.02086005f, 0.02526931f, -0.00836526f, 0.00660219f, 0.01747792f, 
    -0.01427560f, -0.00739764f, 0.00988846f, -0.01689612f, -0.01669070f, -0.00805693f, -0.03397596f, 0.02286540f, 
    0.01780535f, 0.02805351f, 0.00778627f, 0.02403051f, -0.02963399f, -0.00137121f, -0.00870506f, -0.02477069f, 
    0.00846572f, -0.01545695f, 0.01194296f, 0.02617556f, 0.00997379f, 0.00960605f, 0.01166113f, -0.03237412f, 
    0.00733369f, 0.01079758f, 0.01693000f, 0.01163047f, -0.01693583f, -0.02152495f, 0.02100124f, 0.02423880f, 
    -0.02929831f, -0.03269429f, -0.00289793f, -0.04165653f, 0.01591966f, -0.02592819f, -0.00332703f, -0.01231056f, 
    -0.02701811f, -0.03692925f, -0.04634864f, -0.04605231f, -0.00086368f, -0.00697350f, 0.00405744f, -0.01663976f, 
    -0.02549997f, -0.02600969f, -0.04118413f, -0.04075088f, 0.00611029f, 0.02799419f, -0.03885366f, -0.02316955f, 
    -0.03380540f, 0.02258867f, -0.02513915f, 0.00995067f, -0.00879847f, -0.00592150f, -0.01268839f, -0.01953401f, 
    0.01488260f, 0.01437597f, 0.01546609f, -0.01437218f, -0.00810195f, -0.03156356f, 0.00671817f, 0.01232217f, 
    -0.00544812f, -0.02280258f, -0.01287929f, 0.01998416f, -0.01377578f, -0.02087997f, 0.00688879f, 0.02311527f, 
    -0.00920875f, -0.00750443f, -0.01938921f, 0.00385357f, -0.02273073f, 0.02047476f, -0.00865547f, -0.01472539f, 
    -0.01391579f, 0.00212174f, 0.00433226f, 0.01251697f, 0.02038966f, 0.01607462f, -0.00795082f, 0.02862639f, 
    -0.00599081f, -0.04313294f, 0.02660934f, 0.01568039f, -0.02675756f, 0.01074602f, -0.00692164f, -0.01239812f, 
    -0.00511626f, -0.03420294f, 0.00338847f, -0.01187404f, -0.01444172f, 0.02451649f, 0.02311663f, -0.01154834f, 
    -0.00349631f, 0.01541393f, -0.01065505f, -0.04082270f, -0.03132169f, -0.01003124f, -0.01041604f, -0.02163344f, 
    -0.00834819f, -0.03234360f, -0.00446855f, -0.02070854f, -0.03824345f, 0.02071047f, -0.03243615f, 0.00043575f, 
    -0.02154462f, 0.01352618f, 0.02124956f, -0.01943929f, -0.03178926f, -0.03518175f, -0.04004393f, -0.00393014f, 
    0.02248752f, 0.00241453f, -0.01508258f, -0.01425858f, -0.02814454f, 0.00233354f, -0.03130011f, 0.01762169f, 
    0.00117474f, 0.02409761f, 0.01639994f, 0.00576829f, -0.03271972f, 0.00844784f, 0.02320161f, 0.02421767f, 
    -0.03341373f, -0.01109695f, -0.04502919f, -0.00336676f, -0.00598628f, 0.01954426f, 0.02908972f, 0.00343541f, 
    0.00759590f, 0.00566131f, 0.02470120f, 0.01526936f, 0.00048034f, 0.00983938f, 0.00766241f, -0.02594959f, 
    0.01786225f, -0.03885639f, -0.02266936f, -0.01910684f, -0.03385316f, 0.01993495f, -0.02821425f, 0.02309605f, 
    -0.00403186f, -0.02704187f, -0.02961025f, 0.02432433f, -0.02117262f, 0.01464595f, 0.00735548f, 0.00884385f, 
    -0.03060068f, -0.03606693f, -0.03776046f, 0.01705755f, -0.00883252f, -0.00741583f, -0.00376968f, -0.03008487f, 
    -0.03452940f, -0.01317295f, 0.01200559f, 0.02138635f, 0.01269229f, 0.02905405f, 0.00559440f, -0.03807913f, 
    0.02102594f, 0.00932591f, -0.01233850f, -0.01592367f, -0.03674339f, 0.01399206f, -0.02090224f, -0.02558227f, 
    -0.01867034f, -0.02120294f, -0.02291055f, 0.02034511f, -0.02974542f, 0.02030652f, 0.02075925f, 0.01025858f, 
    -0.03200805f, -0.01419609f, -0.00663254f, -0.03624253f, -0.00096807f, 0.01282179f, -0.03410473f, -0.02521172f, 
    0.00113335f, 0.01316053f, 0.01171188f, -0.01458977f, 0.02553364f, -0.03044259f, 0.00484786f, 0.01847605f, 
    0.01426567f, -0.00932009f, -0.00515431f, 0.00669942f, -0.02842033f, -0.01295904f, 0.01384441f, -0.02124872f, 
    -0.04293929f, -0.02991776f, -0.00893779f, -0.02041305f, -0.03459631f, 0.03207586f, -0.03067663f, -0.02927903f, 
    0.00640638f, 0.01092291f, 0.00612942f, -0.00056988f, 0.02595823f, -0.01716994f, -0.01525029f, 0.00434709f, 
    -0.03168802f, -0.02369548f, 0.01644291f, -0.00562171f, -0.04227680f, -0.00385921f, -0.02526116f, -0.04377553f, 
    -0.03006868f, -0.01509438f, 0.02381036f, -0.01883738f, -0.02684361f, -0.01205620f, -0.02792270f, -0.01244932f, 
    -0.00912114f, -0.00876175f, 0.01868088f, 0.02356059f, -0.00272991f, -0.00437258f, -0.02039396f, 0.00105557f, 
    0.01825167f, 0.02263469f, 0.00963347f, -0.01456809f, -0.03595948f, 0.01451193f, 0.01986884f, 0.02250910f, 
    0.01867912f, -0.01095650f, 0.00640713f, -0.03927139f, 0.01711692f, -0.01693582f, -0.01216206f, 0.02488739f, 
    0.01813437f, -0.00128777f, 0.00573300f, -0.04057037f, -0.03992417f, -0.02318446f, 0.00140719f, -0.00270352f, 
    -0.02130301f, 0.00064687f, 0.00868847f, -0.00389063f, 0.02872663f, -0.04346978f, -0.03789350f, -0.01599506f, 
    0.01411460f, 0.01809057f, 0.00905540f, 0.01640467f, -0.01475279f, 0.01250461f, 0.02589588f, 0.01689108f, 
    0.02328905f, -0.03736997f, 0.00598841f, -0.02006507f, -0.02619540f, 0.02900438f, -0.04596861f, -0.00517294f, 
    0.01809753f, -0.00908228f, -0.00862694f, 0.01475835f, 0.01450330f, -0.03820210f, -0.01708541f, -0.00970964f, 
    0.01344574f, -0.04092179f, 0.01179064f, 0.01704326f, -0.04005037f, -0.02909357f, -0.01477059f, -0.00215758f, 
    -0.00622516f, 0.01247600f, -0.02659219f, -0.03748873f, -0.00497492f, 0.00599188f, 0.00430637f, -0.03875173f, 
    -0.00827524f, -0.03113213f, -0.01928432f, 0.02662674f, 0.02352532f, -0.01751136f, 0.01943414f, -0.01188366f, 
    0.01165790f, -0.01080579f, -0.01161729f, 0.02295079f, 0.01201647f, -0.00789869f, 0.01885504f, -0.01138067f, 
    0.00419411f, 0.01234795f, -0.01768596f, 0.02354820f, 0.02249729f, -0.02970785f, -0.03944582f, 0.01942359f, 
    -0.02869604f, -0.02988703f, 0.01773585f, -0.00116031f, -0.02846118f, 0.02300798f, 0.01959562f, 0.02845448f, 
    0.00771136f, -0.00545166f, 0.00138769f, 0.02253138f, 0.00330156f, 0.02023530f, 0.00116000f, -0.01887028f, 
    -0.02101761f, -0.03578762f, -0.03779836f, -0.03935191f, -0.03597840f, -0.04230894f, 0.01956807f, -0.00631443f, 
    0.01335531f, -0.02343339f, -0.02529044f, -0.03189943f, -0.02395726f, -0.03738602f, -0.02637145f, -0.04401803f, 
    -0.00224290f, -0.02470048f, -0.01375483f, 0.00940796f, 0.00993127f, 0.02116748f, -0.02750291f, 0.01311631f, 
    -0.04334605f, -0.04132710f, 0.02380533f, -0.03683745f, -0.00005595f, -0.03051629f, -0.01079162f, -0.00178299f, 
    -0.02449387f, 0.02801837f, 0.01669264f, 0.00695626f, 0.02195359f, 0.01452659f, -0.00392525f, -0.00521047f, 
    0.01221216f, -0.02917854f, -0.01558462f, 0.00986361f, -0.01471057f, -0.00143257f, 0.02210398f, -0.03451872f, 
    -0.01348258f, -0.03501123f, -0.03920203f, 0.02329763f, -0.03391999f, -0.00979859f, -0.03965295f, 0.02138555f, 
    -0.02751309f, 0.02706176f, -0.03288733f, -0.01881089f, 0.02408146f, 0.02009519f, -0.02183407f, -0.01763737f, 
    -0.03945927f, -0.03185654f, 0.02156268f, -0.00531775f, 0.02067349f, 0.02430775f, 0.01920412f, 0.00869166f, 
    -0.04238614f, -0.01611073f, 0.01067695f, 0.02018955f, -0.03702049f, -0.01166731f, -0.01849362f, -0.03727682f, 
    -0.03283318f, -0.01262750f, -0.00134415f, 0.01319898f, 0.00029240f, -0.02255595f, -0.03498126f, 0.02984202f, 
    -0.03893108f, -0.03687095f, -0.01683408f, -0.00731420f, 0.02092036f, -0.03758693f, 0.00048544f, -0.03555153f, 
    -0.03850390f, -0.03911518f, -0.03640626f, -0.03974546f, 0.00745659f, 0.02151687f, -0.03281760f, -0.00478124f, 
    -0.01704999f, -0.02604791f, 0.00491485f, -0.02402348f, -0.03282733f, -0.03730781f, -0.03613318f, 0.00831935f, 
    -0.04180370f, -0.00074146f, -0.03281324f, 0.01409458f, 0.00129383f, -0.01762401f, -0.00390431f, 0.01435447f, 
    -0.00290826f, -0.03694272f, -0.01504996f, -0.03967631f, 0.03154083f, 0.01603425f, -0.01021623f, 0.01039774f, 
    -0.04056367f, -0.03611681f, -0.03567132f, -0.03103504f, -0.00169039f, -0.01188872f, -0.00645115f, -0.02421640f, 
    0.02636164f, 0.00329499f, -0.04058620f, 0.02027547f, -0.00730753f, -0.04374721f, -0.02258861f, 0.00289942f, 
    -0.03231476f, 0.00991177f, -0.01451960f, 0.00271099f, -0.03790895f, 0.00009494f, -0.02963952f, -0.02023101f, 
    -0.01853357f, -0.03154440f, -0.02150672f, 0.03184485f, -0.03194888f, -0.00073717f, -0.02689626f, 0.00643898f, 
    -0.00531100f, 0.00494119f, 0.02303127f, 0.00389650f, -0.01784227f, -0.02034288f, -0.01873618f, -0.02241920f, 
    -0.01733258f, -0.04170937f, -0.02410173f, 0.00078848f, -0.02335979f, -0.00992695f, 0.00054819f, 0.00967429f, 
    -0.01594206f, 0.00953019f, -0.03134695f, -0.00946667f, -0.03519410f, -0.02532962f, -0.02445256f, 0.02793908f, 
    -0.01397813f, -0.01704357f, 0.01003981f, -0.01563234f, -0.00824527f, -0.03242854f, 0.02022210f, 0.00510623f, 
    -0.00601000f, -0.01177073f, -0.04444021f, 0.02688808f, -0.00364505f, 0.02164292f, -0.04060231f, 0.01387801f, 
    0.01240960f, -0.02987143f, 0.02204031f, 0.02423524f, -0.00027891f, 0.00688819f, -0.03480110f, -0.02932587f, 
    0.00131011f, -0.02327970f, -0.03458644f, 0.01906389f, 0.02547317f, -0.02145455f, 0.01012266f, 0.01231816f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01774587f, 0.04178872f, 0.08194476f, 0.00489340f, -0.02828318f, 0.03082002f, 0.02511365f, 0.06430221f, 
    -0.01597671f, 0.02103224f, -0.02053302f, 0.01892433f, -0.01195204f, -0.04105265f, -0.01161798f, -0.00273122f, 
    -0.04920145f, -0.03949235f, 0.03442641f, 0.04474842f, 0.05272365f, 0.02694063f, -0.00373789f, -0.03032181f, 
    -0.06343082f, 0.07155703f, -0.03910247f, -0.01294599f, -0.00805530f, 0.05925977f, 0.00915053f, -0.01858277f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.24279492f, -0.52275223f, 0.07481863f, 0.11640204f, -0.25715661f, -0.49612749f, 0.49487376f, -0.28863829f, 
    -0.05913454f, -0.02878958f, -0.12424657f, 0.14427277f, -0.25233170f, -0.15994978f, -0.16646947f, -0.14827281f, 
    0.20484880f, 0.10255152f, 0.20726353f, 0.08993440f, -0.05796589f, -0.24025397f, 0.02969908f, -0.02998844f, 
    0.34477961f, 0.09568792f, -0.17253518f, -0.06441054f, -0.00550884f, -0.48458076f, 0.05400551f, 0.11552569f, 
    0.00435366f, -0.31644920f, 0.05505440f, 0.03682303f, -0.07647613f, -0.09168767f, -0.23633993f, -0.01289754f, 
    -0.01316302f, -0.04571423f, -0.07336691f, -0.11146843f, 0.16391186f, 0.14642803f, 0.03117908f, 0.05325938f, 
    -0.32153350f, -0.04656568f, 0.31018880f, 0.23268238f, 0.24096684f, -0.62735921f, 0.02221246f, -0.03455141f, 
    -0.32874000f, -0.16788012f, 0.04756663f, -0.07005385f, -0.06133767f, 0.09788105f, -0.11068369f, 0.03707049f, 
    0.29722279f, -0.42166469f, -0.17292547f, -0.05906173f, -0.02596748f, 0.41563445f, -0.57854891f, -0.21615273f, 
    -0.15238942f, 0.08068484f, 0.16175635f, -0.15808243f, -0.04190960f, -0.04157352f, 0.09651050f, 0.04903453f, 
    0.29137298f, 0.14886476f, 0.12440819f, -0.36354029f, -0.00058307f, -0.05120890f, 0.15874624f, 0.07542261f, 
    0.13647176f, -0.05944713f, -0.00899595f, -0.05719285f, 0.14221717f, 0.30358163f, -0.05102865f, 0.02980885f, 
    0.01170304f, 0.03284808f, 0.23795307f, -0.17768259f, -0.58229733f, -0.48161814f, -0.22357397f, 0.27562711f, 
    0.04179394f, 0.00210224f, -0.16539395f, 0.15872312f, 0.36818826f, 0.00286389f, -0.14346895f, 0.04963754f, 
    0.36902204f, -0.10011205f, -0.49316466f, -0.07407188f, -0.31851926f, 0.23753895f, -0.01124032f, 0.01428361f, 
    0.11459349f, -0.37566727f, 0.12255381f, 0.04981110f, 0.13509645f, -0.06017104f, 0.08141284f, 0.07907158f, 
    -0.22727577f, -0.15293790f, -0.04554559f, 0.09627127f, 0.25877103f, 0.12797576f, 0.51769900f, -0.23131870f, 
    0.09954683f, 0.11495141f, -0.16974019f, -0.12714559f, -0.04091017f, -0.06580127f, -0.05208619f, 0.09928271f, 
    0.27153328f, -0.07634589f, -0.58020884f, 0.08235077f, 0.19809511f, 0.05313626f, 0.07484409f, -0.04239656f, 
    0.21256056f, -0.42147452f, -0.06921140f, -0.03587136f, -0.00895596f, 0.03056773f, 0.15575099f, 0.10203455f, 
    0.18266876f, -0.11321602f, 0.06776364f, -0.10566492f, 0.38102433f, -0.26352873f, 0.17836235f, 0.50201541f, 
    -0.17592160f, -0.15955143f, -0.08925662f, -0.11230341f, -0.38546622f, 0.00002659f, -0.14130716f, 0.03836087f, 
    -0.50968629f, -0.13171178f, -0.27069771f, 0.10839919f, -0.23817179f, 0.07379017f, 0.06541101f, 0.05616828f, 
    -0.28932700f, 0.05163073f, 0.05368275f, -0.15290886f, 0.10894617f, -0.09243774f, 0.01145473f, -0.16665842f, 
    0.24481411f, 0.07920916f, -0.36416206f, 0.10198651f, 0.07679220f, -0.18460116f, -0.44954461f, -0.42190167f, 
    0.14423086f, -0.05496626f, -0.09746477f, -0.00369629f, 0.51124048f, 0.04629533f, -0.16404673f, 0.13680920f, 
    -0.33977729f, -0.10742076f, -0.28372660f, -0.02379404f, 0.12749374f, 0.17113087f, -0.12767997f, -0.11145061f, 
    -0.35308504f, 0.28918883f, 0.14240363f, 0.09697019f, 0.00900708f, -0.35209829f, -0.13927358f, 0.01807315f, 
    -0.18527974f, 0.38423505f, -0.17244685f, 0.16469513f, 0.42783433f, -0.12094487f, 0.10123484f, -0.28714085f, 
    -0.07730440f, -0.03909177f, -0.15356001f, 0.01550786f, 0.21881735f, -0.04204350f, 0.04313063f, 0.04147521f, 
    0.12449837f, 0.04770611f, 0.04133973f, -0.48792964f, -0.46715218f, 0.17703401f, 0.10838027f, -0.01313483f, 
    0.17408694f, -0.36799103f, -0.17794640f, -0.16364896f, -0.13749079f, 0.06683122f, -0.15166147f, 0.07064214f, 
    -0.48909283f, 0.08619916f, -0.10810083f, -0.05325906f, -0.11208287f, 0.44539449f, -0.06211181f, 0.40514961f, 
    0.15908684f, 0.06610157f, -0.10587482f, 0.14624321f, 0.04186522f, 0.16777393f, -0.16817325f, 0.02073734f, 
    -0.45540115f, -0.08838042f, -0.06205554f, -0.21773750f, 0.06995297f, -0.35282716f, -0.05151774f, 0.00810873f, 
    0.25949404f, 0.22708735f, -0.08665916f, 0.06681257f, -0.04402335f, 0.05273211f, 0.14235935f, -0.06556526f, 
    -0.23722506f, 0.41174310f, -0.57503575f, -0.14909032f, 0.09968100f, 0.22847758f, -0.56546474f, -0.34944457f, 
    -0.07365076f, 0.03520853f, -0.01413225f, 0.06756093f, -0.37141955f, -0.03963334f, -0.09628201f, -0.03752427f, 
    0.31289268f, -0.02679654f, 0.32247093f, 0.17136551f, -0.05293668f, 0.08263343f, 0.14763817f, -0.14179893f, 
    0.03202592f, -0.21240517f, 0.10560162f, 0.04859914f, 0.14102839f, -0.31986251f, 0.13124721f, 0.13586769f, 
    -0.17589463f, 0.20897816f, 0.47711974f, -0.13267766f, -0.35753360f, 0.06011688f, -0.14537938f, -0.12754671f, 
    -0.11604545f, -0.00958224f, -0.10333794f, 0.16731234f, -0.31894284f, 0.07266119f, 0.05500723f, -0.01857144f, 
    -0.32901216f, 0.00883750f, 0.19621041f, -0.34085491f, -0.10997575f, 0.21794640f, 0.11967447f, 0.09952033f, 
    -0.38333112f, 0.23622951f, -0.06518397f, 0.11161666f, -0.15314937f, 0.02289550f, -0.15477480f, 0.11301336f, 
    -0.24186556f, -0.04953498f, -0.27554646f, 0.16291322f, -0.31449300f, -0.58545059f, -0.37529063f, -0.25586814f, 
    -0.13009955f, -0.01596066f, -0.16017853f, -0.08950691f, -0.17462991f, 0.00016410f, 0.05613295f, 0.02492333f, 
    -0.25301298f, 0.15999833f, -0.42682394f, 0.21516803f, -0.06487202f, 0.12651265f, 0.10839935f, -0.05515229f, 
    0.32310286f, 0.29737663f, -0.16683683f, 0.08320554f, -0.02229286f, 0.39496157f, -0.10964129f, 0.09700090f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05565917f, -0.05091427f, -0.09384690f, -0.06900897f, -0.13617636f, -0.14158747f, -0.04906727f, -0.11324427f, 
    -0.19616999f, 0.17958619f, 0.13127257f, -0.03927082f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
