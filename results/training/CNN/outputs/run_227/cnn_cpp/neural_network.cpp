#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44378194f, -0.46794859f, -0.68500227f, 0.65448773f, -0.33614635f, 0.68719840f, -0.08872147f, -0.05965302f, 
    0.02834048f, 0.74472797f, 0.02279726f, 0.48564643f, 0.90670544f, 0.08722860f, 0.05670663f, 0.42747939f, 
    0.07401284f, -0.02231675f, 0.79883313f, 0.41765380f, 0.61563927f, -0.67115825f, 0.07717688f, -0.21793868f, 
    0.04515456f, 0.12077988f, 0.30175400f, 0.88735455f, 0.86393583f, 0.57303363f, -0.03011074f, 0.35371161f, 
    -0.14641567f, -0.00874668f, -0.03966252f, -0.17338727f, 0.59231579f, 0.36854547f, 0.49885517f, 0.65308297f, 
    -0.22645144f, 0.62077969f, -0.23322938f, 0.20695451f, 0.20334162f, -0.80553025f, -0.42538145f, -0.68994194f, 
    0.19587725f, 0.53786421f, -0.10672143f, -0.26737872f, 0.37849122f, 0.11448314f, -0.96032113f, -0.59515780f, 
    0.15987878f, 0.63890195f, 0.60552245f, 0.44678056f, 0.08037548f, -0.21274462f, 0.14840008f, -0.31521842f, 
    0.41325238f, -0.31928784f, -0.29771340f, 0.27743009f, -0.84259897f, 0.06537452f, 0.52794343f, 0.32169995f, 
    0.23249729f, -0.34144056f, 0.23207073f, -0.91831946f, 0.14519389f, 0.71334052f, 0.20530151f, -0.06632990f, 
    0.31928086f, 0.05706882f, -0.48248976f, 0.22024088f, -0.87792784f, 0.77810538f, -0.28328764f, -0.01350279f, 
    0.11801793f, -0.20736474f, -0.77336609f, -0.43343475f, -0.28271341f, 0.24412763f, 0.52894604f, -0.32248792f, 
    0.31019035f, -0.42204869f, -0.21746291f, 0.20004824f, 0.28824207f, 0.57932538f, -0.20331103f, 0.55548364f, 
    -0.28294665f, 0.47573227f, -0.01667890f, 0.31113607f, 0.37232348f, 0.14300707f, -0.44613242f, 0.34577501f, 
    0.32790515f, 0.08365301f, 0.44366983f, -0.51030779f, -0.34703675f, -0.23404275f, 0.81476605f, -0.26466906f, 
    0.56953716f, -0.39355111f, -0.39111069f, 0.31940192f, 0.15310617f, 0.39549157f, 0.57036871f, 0.43404245f, 
    0.61263132f, -0.44128886f, -0.93962073f, 0.27365482f, 0.05760681f, -0.04289441f, -0.43622437f, -0.42661291f, 
    0.03445259f, 0.17230467f, -0.92031455f, -0.40924644f, -0.46290976f, 0.37880099f, -0.10931045f, 0.15704687f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02879217f, -0.07201760f, 0.08236136f, -0.00060962f, -0.03565666f, 0.14597717f, -0.14324208f, -0.15179606f, 
    -0.20222896f, -0.09973156f, -0.36208907f, -0.02677801f, 0.38373277f, -0.21062768f, 0.08141451f, 0.07745104f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01862029f, 0.04318749f, 0.03467105f, -0.06651103f, -0.02182456f, -0.00960717f, -0.02722848f, -0.03797909f, 
    -0.07825544f, 0.00844348f, -0.07571691f, -0.08740580f, -0.03507619f, 0.06355985f, -0.06258140f, 0.06307648f, 
    -0.02307703f, 0.01189239f, -0.04946483f, -0.09144259f, -0.07138188f, -0.01850752f, 0.03672560f, -0.04275294f, 
    -0.00209523f, 0.01929205f, -0.08851175f, 0.02805118f, 0.00762393f, 0.06856956f, -0.00101348f, 0.03309098f, 
    0.07009504f, -0.01834779f, 0.03253252f, -0.03795940f, 0.04634000f, -0.05291050f, 0.07494625f, -0.07541003f, 
    -0.04302354f, 0.03388317f, -0.04321725f, 0.06046000f, 0.07248064f, 0.07151999f, -0.05945321f, -0.00148790f, 
    -0.02132500f, 0.04213519f, 0.04711829f, -0.07332107f, -0.01903873f, 0.01290776f, -0.00906770f, -0.03621582f, 
    0.01756592f, -0.06443876f, -0.05893698f, -0.08511094f, -0.06339011f, -0.08001175f, 0.05436653f, 0.02321775f, 
    0.04118362f, 0.01379271f, -0.03154729f, 0.05111605f, -0.00875604f, -0.08674584f, -0.03006748f, -0.03194021f, 
    0.04210268f, -0.07853849f, -0.01592727f, 0.04283122f, -0.06293794f, -0.06560830f, 0.00492889f, -0.03004491f, 
    0.00267053f, -0.01004418f, 0.00848587f, 0.00013822f, 0.04047058f, -0.08389118f, -0.02988152f, 0.06883130f, 
    0.02662724f, -0.03772049f, -0.04917092f, -0.06504901f, 0.06884243f, 0.02029530f, -0.06460392f, -0.09075913f, 
    0.02173010f, 0.04611619f, -0.09278242f, -0.03286454f, -0.06935978f, 0.01553031f, 0.02721148f, 0.00961172f, 
    0.00530917f, 0.07132272f, 0.01919543f, 0.04015084f, 0.00349567f, 0.03636117f, 0.02431154f, -0.02500087f, 
    -0.02209228f, 0.01099865f, -0.05283601f, -0.08618929f, -0.06522045f, 0.03344256f, 0.05720507f, -0.09135690f, 
    -0.01157899f, 0.02594399f, -0.00054401f, -0.05495035f, 0.01103776f, 0.05818844f, 0.04088057f, 0.05984020f, 
    -0.08621215f, 0.04007351f, -0.00757430f, -0.06830055f, 0.01095981f, 0.06172920f, 0.03703590f, -0.01211740f, 
    0.00761361f, -0.06966124f, -0.06078164f, -0.00435096f, -0.08979794f, 0.04063056f, 0.00049940f, 0.02348845f, 
    0.19790377f, -0.01879536f, -0.04417725f, 0.01101879f, 0.04128053f, -0.02039581f, 0.03561347f, 0.11890821f, 
    0.07785712f, -0.61478591f, -0.17500837f, -0.24382856f, 0.36168537f, -0.16770597f, -0.12596385f, 0.13103281f, 
    -0.06813963f, 0.12328918f, 0.05738921f, 0.00405240f, 0.25295338f, 0.18153720f, 0.14314699f, 0.07410091f, 
    0.01879555f, 0.02848752f, 0.04260985f, -0.06470460f, -0.36788747f, -0.13342969f, 0.17929973f, 0.00589330f, 
    -0.08686339f, -0.07928263f, -0.11808916f, -0.11236567f, -0.65820611f, -0.26202723f, -0.20655361f, 0.14688395f, 
    0.13422833f, 0.11675147f, -0.07507517f, 0.19915460f, -0.17461413f, 0.07688883f, 0.00747888f, 0.05905113f, 
    -0.04490836f, -0.08532874f, -0.04349460f, 0.00590992f, 0.13040715f, -0.02447269f, 0.25120109f, 0.14448597f, 
    -0.19614115f, 0.07062645f, -0.04904275f, 0.06814495f, -0.00937454f, 0.12454032f, -0.03929843f, 0.03577975f, 
    -0.11423980f, 0.21945731f, -0.10985049f, -0.03154754f, 0.18734522f, 0.23317887f, 0.06502466f, -0.07255571f, 
    -0.11282694f, -0.22831701f, -0.02524846f, 0.09290791f, -0.10726182f, -0.11251093f, 0.08819710f, 0.06433074f, 
    -0.06199488f, 0.08514584f, 0.08055875f, 0.01327610f, -0.05216943f, -0.15212691f, -0.01409396f, 0.20861302f, 
    -0.02370486f, -0.13477175f, 0.13408123f, -0.06436653f, -0.11633009f, -0.36911422f, -0.05385596f, -0.08585862f, 
    -0.06075536f, 0.02074133f, -0.02802517f, -0.14868884f, 0.01124798f, 0.12750037f, -0.01233468f, 0.00782977f, 
    -0.00878363f, 0.00876491f, 0.04312052f, 0.05068324f, -0.05764879f, -0.05513831f, -0.07908247f, 0.16185489f, 
    -0.04592825f, 0.07240346f, -0.01250071f, 0.09209475f, -0.01276671f, -0.12544475f, -0.25930351f, 0.02011055f, 
    0.04147178f, -0.04589648f, 0.01765693f, 0.13795619f, 0.09153697f, 0.13154487f, -0.02356958f, -0.29085666f, 
    -0.02458579f, 0.21637088f, 0.10734997f, 0.05214996f, -0.08477107f, -0.02963161f, -0.01938138f, 0.43750194f, 
    0.32087007f, 0.08967379f, 0.01826820f, -0.08856640f, 0.11344143f, 0.07417034f, -0.17869176f, 0.14305475f, 
    -0.13471909f, -0.05980854f, -0.34064779f, 0.15529758f, 0.19107844f, 0.05275919f, -0.09838762f, -0.09316560f, 
    -0.13866425f, -0.31956550f, 0.24111959f, -0.14358419f, -0.01886302f, 0.07450978f, -0.19880345f, -0.13795517f, 
    -0.10696154f, 0.07038678f, -0.10758742f, 0.15866692f, 0.31307128f, -0.19111741f, -0.01921680f, -0.06010849f, 
    -0.06158523f, 0.02327327f, 0.08114788f, -0.09271737f, 0.29813093f, 0.42403671f, 0.23550393f, 0.01239343f, 
    0.01315960f, 0.07864312f, -0.07195888f, -0.03025869f, 0.05847315f, -0.04083651f, 0.11821598f, 0.15473349f, 
    0.01296858f, 0.21111518f, 0.17380907f, 0.08444699f, -0.13123760f, -0.42879844f, -0.03960720f, -0.15841448f, 
    0.10542019f, 0.01309608f, 0.03382497f, 0.01071162f, 0.03577592f, 0.02325962f, 0.06517421f, 0.20897546f, 
    -0.42335457f, 0.08469336f, 0.12997152f, 0.00787003f, 0.09460323f, -0.00924317f, -0.11764663f, -0.03916288f, 
    -0.02263180f, -0.05727545f, 0.14532948f, 0.01179784f, 0.13660921f, -0.03001991f, -0.02563249f, -0.14637721f, 
    -0.25907761f, -0.47359243f, -0.41999379f, -0.13508360f, 0.06690156f, 0.07103455f, -0.09017715f, -0.19336444f, 
    0.11014454f, -0.45677575f, 0.06050090f, 0.07775687f, -0.02308046f, 0.09661345f, -0.03380571f, -0.02522706f, 
    -0.05953579f, 0.03919522f, -0.28378925f, -0.42441666f, -0.06818506f, -0.08068728f, 0.06698587f, -0.10270576f, 
    0.17098285f, -0.00904790f, 0.05951164f, -0.25840840f, 0.00162080f, 0.16350864f, -0.10088684f, 0.07431570f, 
    0.10752220f, 0.12217285f, 0.10550610f, -0.14262466f, 0.05839784f, 0.10304575f, -0.08299681f, -0.05384026f, 
    -0.12703256f, 0.05979351f, 0.15226167f, 0.29627514f, 0.17493437f, -0.09325579f, -0.03552986f, -0.06803133f, 
    -0.17433609f, 0.13066384f, -0.13017428f, -0.02948407f, -0.15455359f, 0.07026128f, 0.04460565f, -0.22734423f, 
    0.32862905f, -0.12896653f, -0.04709318f, -0.13744639f, 0.10954947f, 0.11809660f, 0.07089038f, 0.27379999f, 
    0.09818477f, 0.02209472f, 0.05063570f, 0.03041101f, 0.04301424f, -0.02194536f, 0.08960568f, 0.11968221f, 
    -0.08531149f, -0.02162523f, -0.03831071f, -0.09494416f, -0.05325831f, -0.02695153f, 0.01235953f, -0.08852907f, 
    0.06379174f, -0.00839894f, 0.04560895f, 0.00294546f, 0.06209563f, -0.05810808f, -0.03694038f, 0.00155596f, 
    -0.04020426f, -0.06872558f, -0.00106277f, -0.05031346f, 0.03296694f, -0.02139707f, -0.06094573f, 0.04338463f, 
    -0.03335729f, 0.05410561f, 0.01372611f, -0.00279237f, -0.06084120f, -0.01580137f, -0.02783368f, -0.05137203f, 
    -0.00062402f, -0.02706711f, -0.07355807f, -0.08690403f, -0.00013065f, -0.02743418f, -0.08632092f, 0.01448641f, 
    -0.10387499f, -0.06501134f, -0.00576552f, -0.07876831f, 0.01714709f, -0.06917207f, 0.01214378f, -0.06465472f, 
    -0.07843921f, -0.03729588f, -0.04412869f, -0.03411176f, -0.08923903f, 0.01738694f, -0.00057133f, 0.05400036f, 
    -0.08049744f, -0.06548204f, 0.03504236f, -0.02839294f, -0.06393059f, 0.02384134f, -0.03130858f, 0.00267537f, 
    -0.03994163f, -0.08202755f, 0.00048521f, -0.04314944f, 0.03562979f, -0.06290258f, -0.08667931f, -0.05540542f, 
    0.01295874f, -0.07667217f, 0.03216153f, 0.04295538f, 0.00597373f, -0.07508630f, 0.01825088f, -0.09180311f, 
    0.03385250f, 0.08416476f, -0.01279303f, -0.10364404f, -0.06566815f, 0.04946402f, 0.01717733f, 0.05520093f, 
    -0.08610851f, -0.10147493f, 0.07921590f, 0.03141474f, 0.06873235f, 0.03853808f, -0.06609727f, 0.03645951f, 
    0.01486819f, 0.05062851f, 0.05355985f, -0.00623923f, 0.01401521f, -0.09577095f, 0.03417914f, 0.05095812f, 
    -0.01779928f, -0.00831805f, 0.00283123f, -0.04887520f, -0.06342059f, -0.01265464f, 0.04981194f, -0.05870555f, 
    -0.01082921f, 0.04980591f, -0.06651475f, -0.09029411f, -0.05772621f, -0.08912933f, -0.06216815f, -0.03795134f, 
    0.00420218f, -0.03376539f, -0.07222085f, -0.03235502f, -0.07325505f, -0.06840788f, 0.04974207f, 0.01926537f, 
    -0.04846837f, -0.10244928f, 0.00254048f, 0.02983687f, -0.09228719f, -0.05569949f, -0.05169616f, -0.04782503f, 
    0.05724767f, -0.00685734f, -0.02586074f, -0.05353857f, -0.01169706f, -0.02828929f, -0.02155195f, -0.02876623f, 
    0.17543668f, 0.12191828f, 0.31491902f, -0.21060345f, -0.04341914f, 0.13479464f, -0.04580810f, 0.05020533f, 
    0.09487163f, 0.30912247f, 0.05140218f, 0.17707394f, 0.06523165f, 0.08393351f, 0.01486780f, 0.04412209f, 
    -0.24971682f, 0.05207426f, 0.07718671f, -0.15129979f, 0.01917714f, -0.08164411f, 0.18590137f, -0.11919820f, 
    0.03106966f, -0.00210368f, 0.04843057f, 0.09367757f, -0.48699221f, 0.09963668f, 0.09725893f, -0.05193746f, 
    0.08143051f, 0.10324203f, -0.31483659f, 0.01688614f, 0.17983340f, -0.12477633f, 0.14566587f, -0.07341935f, 
    0.03849249f, -0.01690937f, 0.12136596f, 0.07392693f, -0.34289733f, -0.03567069f, 0.17424479f, 0.17621323f, 
    -0.06609266f, -0.04100403f, 0.03103792f, -0.16275707f, -0.05246708f, 0.03677435f, -0.15584381f, 0.30606353f, 
    0.27364954f, -0.18094160f, -0.14148691f, 0.26977840f, 0.04792888f, 0.02019214f, -0.13203694f, 0.00628602f, 
    -0.26366314f, -0.23091826f, -0.21681981f, -0.13196598f, -0.01344728f, -0.03686301f, 0.20221426f, -0.11058091f, 
    -0.25199744f, 0.22735652f, 0.02227014f, -0.13527197f, 0.09267418f, -0.11475077f, -0.13936006f, 0.26444164f, 
    0.01607822f, -0.22625592f, -0.25706032f, -0.03996241f, -0.23852354f, 0.07866929f, 0.10568532f, -0.00379564f, 
    0.09107855f, -0.11055741f, -0.23190840f, 0.10198694f, 0.05558061f, -0.03441252f, 0.07607071f, -0.15304692f, 
    -0.02874827f, -0.07585230f, 0.02935648f, 0.04922904f, -0.17060606f, -0.10089053f, 0.17870574f, 0.10982244f, 
    0.05260170f, -0.05076839f, -0.04486854f, 0.03658560f, 0.20066872f, 0.20621382f, 0.09477462f, -0.05712717f, 
    -0.00968622f, 0.10858504f, -0.15091442f, 0.13492326f, 0.00151767f, 0.21579003f, -0.07748874f, -0.04764564f, 
    -0.00274525f, -0.14872256f, -0.11839437f, -0.04127385f, 0.07970307f, -0.13204317f, 0.23925623f, -0.05228552f, 
    0.00694304f, 0.08839102f, -0.21555352f, 0.13900234f, 0.04636347f, 0.07032346f, -0.10710988f, 0.15564479f, 
    0.23836458f, -0.08694274f, -0.08714968f, -0.00485339f, -0.07842784f, 0.12712598f, -0.32689247f, 0.03178556f, 
    0.04264533f, -0.12220445f, 0.13530973f, 0.03959334f, 0.03636336f, -0.05196311f, -0.06096264f, -0.03638573f, 
    0.00814880f, 0.09220464f, -0.24366076f, -0.29630840f, 0.01607443f, 0.10155223f, 0.15280689f, -0.03673768f, 
    0.14972243f, -0.17888942f, -0.02014523f, 0.16368732f, 0.00918851f, 0.06561348f, -0.01876792f, -0.17856663f, 
    0.08323688f, -0.14205989f, 0.08870345f, 0.16340581f, 0.11403508f, -0.16190048f, 0.17825699f, 0.02160426f, 
    -0.16920276f, 0.14972006f, -0.00870869f, 0.05658495f, 0.06357083f, -0.05690682f, -0.07131410f, 0.16533454f, 
    0.04160260f, 0.25615287f, 0.00989100f, -0.04122256f, -0.53570503f, 0.08021566f, -0.02911661f, 0.28842536f, 
    -0.05832252f, 0.11317635f, -0.02588334f, -0.13576086f, -0.06462343f, 0.12318987f, -0.01213109f, -0.29546112f, 
    0.17203276f, 0.01878303f, 0.11124756f, 0.15171385f, 0.07667416f, -0.02249084f, -0.08913819f, -0.15917905f, 
    0.25797567f, 0.09846961f, -0.03244744f, -0.10912184f, -0.16935739f, 0.07022388f, -0.21146758f, -0.18821172f, 
    -0.10175059f, 0.10629012f, 0.06400648f, -0.11289264f, 0.05235770f, -0.03082529f, 0.26219994f, -0.07616562f, 
    -0.48038891f, 0.09914134f, 0.29396465f, -0.06202339f, 0.04271244f, -0.12785335f, 0.02862983f, -0.05051216f, 
    0.23081398f, 0.29706490f, -0.22787878f, -0.35074744f, 0.02416505f, 0.05886767f, -0.14989589f, 0.02009884f, 
    -0.24053055f, 0.12503089f, 0.29225600f, -0.25225684f, 0.19985804f, 0.08712614f, -0.08691894f, -0.22688490f, 
    0.11153872f, -0.03488258f, 0.16546208f, -0.07372940f, 0.05519528f, 0.02936388f, 0.08304519f, 0.22546370f, 
    0.09703662f, 0.18346603f, -0.06016621f, 0.01788433f, 0.02826567f, 0.38489673f, -0.07873631f, 0.05030732f, 
    -0.04394554f, -0.00158311f, 0.19939652f, -0.15248019f, -0.05397721f, -0.21797363f, 0.03573489f, 0.02098030f, 
    -0.37610799f, 0.02552387f, 0.11112957f, -0.17967223f, -0.00220513f, 0.09193783f, -0.17470878f, -0.16767538f, 
    0.07358119f, -0.15918265f, 0.07517955f, -0.05892716f, -0.17856470f, 0.22494763f, 0.07595690f, 0.20520625f, 
    -0.01309122f, 0.28577930f, 0.10763447f, -0.12855983f, 0.12443538f, -0.01562316f, 0.04949210f, -0.01394747f, 
    0.09692030f, -0.26245046f, -0.04352521f, 0.11949723f, -0.14687485f, 0.10240007f, 0.07110248f, 0.04200502f, 
    0.05044566f, 0.15398076f, -0.25222382f, 0.06211452f, 0.05619554f, 0.13119335f, 0.09952477f, 0.11736637f, 
    -0.09556428f, -0.10102349f, -0.09427791f, 0.11640976f, -0.08314034f, -0.05489661f, 0.23106010f, 0.15372187f, 
    0.32766664f, 0.04405298f, -0.07218624f, -0.08566707f, -0.32637838f, -0.09248237f, -0.05093310f, 0.12804651f, 
    -0.02172511f, 0.04845828f, -0.03513418f, 0.12977089f, 0.23803307f, 0.17781752f, -0.09570646f, 0.07759787f, 
    -0.10162884f, -0.06659401f, 0.01065607f, -0.12876527f, 0.09407517f, -0.06434739f, 0.50504225f, 0.21065952f, 
    0.37140751f, -0.07675606f, -0.09634969f, -0.11030570f, 0.09062602f, -0.00334926f, 0.07664022f, 0.14026091f, 
    -0.11754920f, -0.12333975f, -0.09542336f, -0.17196280f, -0.04831729f, -0.06154806f, -0.03617142f, -0.20716724f, 
    0.14872970f, 0.02773101f, -0.26577067f, -0.12575451f, -0.04376455f, 0.18573214f, -0.04717812f, -0.15187357f, 
    0.01422122f, 0.07753713f, -0.17697057f, -0.48898837f, 0.05393162f, 0.05874187f, -0.10439306f, -0.05817484f, 
    0.06719629f, -0.24723679f, 0.23919135f, 0.08636035f, 0.19763860f, -0.12547186f, -0.03649551f, -0.02516155f, 
    0.14271431f, 0.23248139f, 0.09942467f, 0.42779866f, 0.14207442f, -0.03016914f, -0.10880554f, 0.10851483f, 
    0.01557795f, -0.10371464f, 0.02289160f, 0.06185486f, 0.09959961f, 0.13232546f, 0.00296516f, -0.12516424f, 
    -0.02243843f, 0.11083853f, 0.17636029f, -0.08390255f, -0.10240576f, -0.04568726f, 0.11538570f, -0.05156595f, 
    -0.13083783f, -0.12355331f, 0.03855655f, 0.00996675f, 0.11309205f, 0.06404357f, -0.48179537f, 0.11815158f, 
    -0.53112757f, 0.08412530f, -0.06216717f, 0.05928805f, -0.09134873f, -0.08722085f, 0.01448314f, -0.08298359f, 
    -0.14708781f, -0.19939394f, -0.03373948f, -0.15500805f, -0.20378278f, -0.19026224f, 0.10513616f, -0.05922778f, 
    -0.39655620f, 0.31506634f, -0.01055648f, -0.02414791f, 0.09931905f, -0.17448555f, -0.10033343f, -0.15884747f, 
    -0.19763198f, 0.11774362f, -0.08444119f, 0.14993788f, 0.16726017f, 0.06939061f, -0.01329634f, 0.08175627f, 
    -0.01170571f, 0.01147201f, 0.29669058f, 0.40718302f, 0.20818728f, -0.07450322f, 0.19474448f, 0.18249539f, 
    -0.06394787f, 0.07063559f, 0.08327937f, 0.17413147f, -0.00507245f, 0.17582290f, 0.11206540f, 0.17754862f, 
    -0.10966318f, 0.05089561f, 0.19555764f, 0.09950980f, -0.07804002f, 0.38409662f, 0.21842617f, -0.08133191f, 
    0.09003356f, 0.10054763f, 0.04790222f, -0.27073929f, 0.03213208f, -0.52099419f, -0.13561001f, -0.27524722f, 
    -0.05848944f, -0.04107300f, 0.00716926f, 0.00343745f, 0.01358134f, -0.04350843f, -0.27217335f, -0.42778394f, 
    -0.33045340f, 0.03553480f, -0.03586476f, -0.00898828f, -0.21255419f, 0.05371563f, 0.05068579f, -0.03176973f, 
    -0.03530728f, -0.06242817f, 0.05056610f, -0.15721050f, -0.13441393f, -0.12862490f, -0.00520051f, 0.22290197f, 
    -0.38197020f, 0.00605377f, 0.00918222f, 0.07969411f, -0.11168688f, 0.10690907f, 0.16740941f, -0.03226257f, 
    0.08863187f, 0.08538254f, -0.08078568f, -0.33402649f, -0.02610434f, -0.09540406f, 0.00652211f, 0.05343229f, 
    -0.10738435f, 0.04192256f, -0.36326763f, 0.17703502f, -0.23639795f, -0.00617764f, -0.16772760f, 0.08191385f, 
    -0.00447064f, -0.05634619f, -0.03295608f, 0.16570033f, -0.00946204f, 0.07959078f, -0.01875568f, -0.09615013f, 
    0.00729050f, 0.01544216f, 0.01407504f, 0.05633177f, 0.06327523f, 0.19645074f, -0.17530015f, 0.02375417f, 
    0.09146395f, 0.02976706f, -0.04032345f, 0.01677890f, -0.12941797f, -0.04400317f, -0.26412496f, 0.11315313f, 
    -0.06100211f, 0.23661610f, -0.20261155f, 0.00730260f, -0.02848220f, 0.11432631f, -0.10244657f, 0.09328191f, 
    0.11562394f, 0.07036068f, 0.24346568f, 0.11488881f, 0.00840145f, 0.02063506f, 0.02874345f, 0.25543514f, 
    0.04477945f, -0.15767303f, -0.01840696f, 0.07522657f, 0.14693730f, 0.15537626f, 0.06826641f, 0.10734752f, 
    0.12722364f, -0.23085038f, 0.09725323f, 0.16749391f, 0.00229036f, 0.20181717f, 0.04916475f, -0.14277919f, 
    -0.11769859f, -0.28077629f, -0.20453604f, -0.21322097f, 0.19993348f, -0.00302516f, 0.13950124f, -0.04109543f, 
    -0.02662288f, -0.06934424f, 0.24760221f, 0.07588374f, 0.18741634f, -0.40294486f, -0.00760807f, -0.07007499f, 
    -0.05003677f, 0.03478499f, -0.01751188f, 0.14136435f, 0.19118197f, -0.13122734f, -0.11285083f, 0.05120497f, 
    0.24542141f, 0.18847936f, -0.02138655f, -0.06553286f, -0.24662308f, 0.06719513f, -0.16706844f, -0.07072171f, 
    0.04969598f, 0.14994268f, -0.05376923f, 0.01047876f, -0.07448535f, -0.20680039f, 0.37657288f, -0.04602703f, 
    0.11869535f, 0.05401166f, 0.13361193f, 0.11843264f, -0.02495221f, 0.11372114f, -0.11576901f, 0.13027088f, 
    -0.03098932f, 0.23273222f, 0.08709940f, -0.09157764f, -0.18411589f, -0.01327514f, 0.11146561f, -0.05722673f, 
    0.04512876f, -0.12909941f, -0.04085867f, -0.10284075f, 0.19080004f, -0.08743455f, -0.13172214f, 0.06180066f, 
    0.27971709f, 0.00780856f, -0.50993735f, -0.10603391f, -0.19669975f, 0.10664745f, 0.11661406f, 0.02777455f, 
    0.02156354f, -0.00287517f, 0.13477363f, 0.05030894f, 0.10011908f, 0.03801472f, -0.11536484f, 0.00899900f, 
    -0.06182835f, -0.07317828f, 0.12625742f, 0.45059302f, -0.01665637f, -0.14635575f, -0.11561134f, 0.05321261f, 
    -0.18790261f, 0.32985085f, 0.05215179f, 0.04211252f, 0.28248346f, 0.05523111f, 0.00704176f, -0.10736763f, 
    0.14217746f, 0.10237840f, 0.05909897f, -0.11280605f, -0.30089426f, -0.19291411f, -0.04324871f, 0.07646107f, 
    0.10258202f, -0.06247718f, 0.08745215f, 0.06159635f, 0.02386724f, -0.15027705f, 0.03542022f, 0.19108273f, 
    0.14222448f, 0.02905902f, -0.22015056f, 0.08408084f, -0.15704393f, 0.06340237f, -0.07521665f, -0.37818873f, 
    -0.14037289f, -0.19084306f, -0.14813864f, 0.04218322f, 0.16970970f, -0.01416594f, 0.08765789f, -0.18877257f, 
    0.12509856f, 0.00816655f, 0.10522207f, 0.01732471f, -0.03694959f, -0.02560985f, 0.14835273f, -0.12497567f, 
    -0.13459629f, -0.18690264f, 0.17561798f, -0.07443934f, 0.04763339f, -0.17403574f, 0.00659190f, -0.08458785f, 
    -0.04719080f, -0.07852533f, -0.26773602f, 0.02677976f, -0.03912465f, 0.11986784f, 0.11917771f, -0.20083575f, 
    -0.11095977f, -0.16354740f, 0.07715744f, 0.27273113f, -0.24310452f, -0.08392244f, -0.02812912f, 0.19187422f, 
    0.03521362f, 0.14868674f, -0.25964704f, -0.12847984f, 0.34245023f, 0.32407552f, -0.14200783f, 0.03349451f, 
    0.27367055f, 0.17887209f, -0.10924464f, -0.14726712f, -0.38679722f, 0.18093100f, 0.06171368f, -0.07654354f, 
    0.13442357f, 0.04666248f, -0.09080534f, 0.06745920f, 0.02625432f, 0.31437409f, -0.26374018f, 0.05285225f, 
    -0.10453970f, -0.05417188f, 0.15090735f, 0.07749729f, -0.11976834f, 0.07697349f, 0.31776032f, -0.14306976f, 
    -0.00622678f, -0.07920057f, -0.07743183f, -0.03829897f, -0.00430686f, 0.10483879f, -0.00495431f, 0.08645957f, 
    0.13820805f, -0.20594274f, -0.05916837f, 0.00929547f, 0.07192140f, 0.09738905f, -0.04702524f, -0.10364665f, 
    0.18807937f, -0.18927447f, -0.21918906f, -0.01021883f, -0.18412335f, 0.09318607f, -0.12744847f, -0.13212058f, 
    -0.12187958f, 0.48085907f, 0.04114285f, -0.14308310f, -0.02889366f, 0.11442967f, 0.12209351f, -0.10424747f, 
    -0.03957090f, 0.02865881f, 0.20340052f, 0.00097342f, 0.20226336f, -0.14491728f, -0.02333387f, 0.07860505f, 
    0.05850493f, 0.14373641f, 0.08613531f, 0.26461521f, 0.12089663f, 0.13051118f, -0.04090199f, -0.04635775f, 
    0.00431357f, -0.07400401f, -0.09481841f, -0.00203742f, 0.22039747f, -0.09943323f, -0.09146716f, -0.08175501f, 
    -0.20648737f, 0.11152153f, -0.00489772f, 0.18169889f, 0.19092101f, 0.02688539f, 0.01590220f, -0.19619882f, 
    -0.02856797f, 0.06251368f, -0.06110306f, 0.06678653f, -0.00846118f, -0.07538824f, -0.75258869f, 0.15143074f, 
    0.19255365f, -0.01548377f, -0.01256826f, -0.05934612f, 0.06635952f, 0.02883172f, -0.02812240f, 0.03979624f, 
    -0.18514004f, 0.22126050f, 0.06381473f, 0.07190152f, 0.04456136f, -0.30871993f, 0.07056084f, 0.00281501f, 
    0.14433564f, 0.40217766f, -0.30248410f, 0.15871350f, 0.22251262f, -0.06770279f, 0.06718641f, 0.06923606f, 
    -0.08453226f, -0.36129966f, 0.05713756f, 0.43124586f, 0.08018898f, 0.11422217f, -0.15562461f, -0.19039908f, 
    -0.04390289f, 0.16040008f, 0.10506779f, -0.32871360f, 0.18191487f, 0.23300827f, 0.00001285f, 0.14589515f, 
    0.07524998f, -0.11680402f, 0.11452191f, 0.27158856f, -0.29888564f, 0.26330715f, 0.09734880f, 0.19033690f, 
    -0.04680875f, -0.11527941f, -0.03774373f, 0.10178385f, -0.07332853f, 0.23080285f, 0.14012019f, 0.07159205f, 
    0.21133496f, -0.08681531f, 0.18260252f, 0.03020532f, 0.06928686f, -0.05509675f, 0.24777086f, -0.08312876f, 
    -0.18041217f, 0.09618442f, -0.06307454f, 0.07551465f, -0.09412172f, 0.06789704f, -0.48990315f, 0.24539240f, 
    -0.13006231f, -0.08286196f, 0.08337333f, -0.17715456f, -0.02349762f, 0.10113693f, 0.15877475f, -0.07494096f, 
    -0.17259710f, -0.46888852f, -0.12621720f, 0.34831205f, 0.15016288f, -0.12273084f, 0.06144730f, -0.01039599f, 
    -0.43087628f, -0.04010178f, 0.02389354f, 0.13680167f, -0.06921034f, -0.06175049f, -0.03683798f, 0.02852525f, 
    0.07813367f, 0.16625185f, -0.01697855f, -0.21856532f, 0.05932787f, -0.00092018f, -0.00376146f, 0.10945510f, 
    -0.30816472f, -0.11018939f, -0.52985936f, 0.28397685f, 0.09088820f, -0.14164422f, -0.01741623f, 0.11954958f, 
    -0.12690967f, 0.12945837f, -0.08560468f, -0.21890748f, -0.34911844f, 0.01692152f, -0.15632260f, -0.04240368f, 
    0.01490251f, -0.01475789f, 0.13098167f, -0.13191241f, 0.33446169f, -0.23527446f, 0.01625769f, 0.02843017f, 
    0.13560045f, -0.25483111f, 0.14496309f, 0.06767047f, 0.02996223f, 0.19990501f, -0.33261842f, -0.07394587f, 
    0.17233366f, 0.01005776f, 0.02076768f, 0.11234496f, -0.11827473f, -0.11293119f, -0.02417305f, -0.21548446f, 
    0.18998849f, 0.11441436f, -0.13182904f, -0.07885790f, 0.08796510f, -0.21016929f, 0.09766768f, -0.24062814f, 
    0.00108582f, -0.17894448f, -0.10339180f, 0.02064087f, -0.01061104f, -0.00549712f, 0.02547226f, -0.05733471f, 
    0.15661103f, 0.23490262f, 0.06761626f, -0.04388876f, -0.03569866f, 0.02859273f, -0.11646470f, 0.10248297f, 
    0.02117174f, -0.30546680f, -0.01358480f, -0.18707055f, 0.14402543f, -0.10643030f, -0.09690158f, 0.02588338f, 
    0.00179123f, 0.04071045f, -0.17633253f, -0.03475917f, 0.02468636f, -0.10374717f, 0.07542340f, 0.04773519f, 
    -0.03622372f, -0.16126899f, -0.07724639f, -0.71728444f, -0.02114561f, -0.13925131f, -0.03194196f, -0.12419309f, 
    -0.03721017f, -0.19756536f, -0.06553022f, -0.16983128f, -0.12537514f, -0.32772681f, -0.15580742f, 0.07992197f, 
    0.02393775f, 0.21344969f, 0.08723192f, 0.13964242f, 0.07042508f, -0.15769751f, 0.23241542f, 0.26881704f, 
    0.04255697f, 0.11296733f, 0.20129856f, 0.02055294f, -0.00509424f, -0.02067997f, 0.12184566f, 0.18128105f, 
    0.13748711f, 0.23850821f, -0.07120725f, -0.10894105f, 0.06424632f, 0.14682011f, 0.03541882f, 0.12119378f, 
    0.13703714f, 0.02250587f, -0.08487780f, 0.19883253f, -0.01321297f, -0.27659386f, 0.17018256f, 0.00684429f, 
    -0.05194270f, 0.03265446f, -0.15383600f, -0.06911818f, -0.23718786f, -0.16439593f, 0.07502425f, 0.15401150f, 
    0.09580649f, -0.39997432f, 0.30069652f, -0.04924372f, 0.10469157f, -0.00811517f, 0.01417167f, 0.12901571f, 
    -0.18102011f, -0.08780917f, 0.16274539f, 0.11449449f, 0.22800180f, -0.16549632f, 0.28807282f, 0.11803650f, 
    -0.08246138f, 0.01742513f, 0.10276937f, -0.46257448f, -0.16716348f, 0.25162381f, -0.02394669f, -0.03349465f, 
    -0.09755865f, 0.00092891f, -0.05849360f, 0.08429243f, 0.13493945f, -0.10993676f, -0.46219021f, 0.07544712f, 
    0.04890709f, 0.08822604f, -0.00574978f, -0.04611033f, 0.16447550f, 0.52551228f, 0.17793389f, 0.05063184f, 
    -0.14146769f, -0.15431960f, 0.05427983f, -0.10592040f, 0.29829353f, -0.03223648f, -0.06824759f, -0.35472003f, 
    -0.21087934f, -0.07735857f, 0.13883576f, -0.07490744f, -0.10976571f, -0.01139991f, -0.01248884f, 0.10117923f, 
    0.18591683f, -0.03610848f, 0.03490470f, -0.05130463f, 0.02656056f, -0.06483173f, -0.05288043f, -0.12389628f, 
    0.26675746f, 0.32909852f, 0.15944760f, 0.25195393f, 0.05761641f, 0.15582003f, 0.10588779f, -0.08933954f, 
    0.07898053f, -0.09940728f, 0.11280439f, 0.09581650f, 0.10727197f, 0.06261259f, -0.11551331f, 0.13038041f, 
    0.00622932f, 0.19038102f, -0.05770052f, -0.23433374f, -0.10904944f, -0.06559599f, -0.15677047f, 0.01096762f, 
    -0.23659214f, -0.18953796f, -0.01670852f, -0.17287484f, -0.01401017f, 0.07264218f, -0.07366613f, -0.00554037f, 
    -0.00210832f, -0.06780221f, 0.01512194f, -0.05883630f, 0.21233082f, 0.01066566f, 0.08209736f, -0.11896002f, 
    -0.04635686f, 0.03861216f, -0.09568249f, 0.12140080f, -0.17486435f, 0.15056829f, 0.11512440f, 0.09390293f, 
    0.25171965f, 0.02781611f, 0.06342185f, 0.06853306f, 0.01792406f, 0.00503651f, 0.27777648f, 0.52645224f, 
    0.01589538f, -0.08185431f, -0.08424565f, 0.07147352f, 0.00092861f, 0.02451296f, 0.24647531f, -0.58390039f, 
    -0.03975723f, -0.14397854f, 0.18498074f, 0.02586233f, -0.03756079f, -0.00424788f, -0.08418108f, 0.05409763f, 
    -0.03654402f, -0.31137517f, -0.25085694f, 0.10959523f, -0.03703153f, -0.18389663f, 0.01431487f, -0.00577716f, 
    0.07257467f, -0.07188097f, -0.34098223f, 0.11045658f, 0.12109777f, -0.03075171f, 0.11563135f, -0.04330019f, 
    -0.10624734f, -0.16539466f, 0.23206349f, 0.19179091f, 0.21218923f, -0.04915023f, -0.10599284f, 0.13512696f, 
    -0.04628882f, 0.14856914f, -0.12940429f, 0.08796224f, 0.17144346f, -0.04977806f, -0.01696204f, 0.13070530f, 
    -0.10783885f, 0.20092176f, 0.06223300f, 0.03503174f, 0.09411213f, -0.10691624f, -0.13787672f, 0.19953987f, 
    0.00250434f, -0.01570073f, 0.15933815f, -0.11011178f, 0.06879396f, -0.46009436f, -0.05642746f, -0.22015807f, 
    0.03855568f, -0.11254568f, 0.05277609f, 0.04524454f, -0.04294944f, -0.19566031f, 0.02368024f, 0.10802574f, 
    0.14127293f, -0.33756122f, -0.15099634f, -0.19541501f, 0.01538438f, 0.01586471f, 0.07423837f, 0.01203671f, 
    -0.32321006f, 0.05842569f, 0.07503987f, -0.21310747f, 0.21729620f, 0.05640282f, 0.02098716f, -0.03165788f, 
    -0.05992528f, 0.07414377f, -0.08076476f, 0.02775915f, -0.03690506f, -0.04507115f, 0.05269120f, -0.01450523f, 
    -0.05163823f, -0.00280067f, -0.07632164f, -0.01201497f, -0.06315099f, 0.07111037f, -0.05229990f, 0.00535913f, 
    -0.04134106f, 0.05997245f, 0.06274895f, -0.07442543f, -0.06409083f, -0.04625621f, 0.04454029f, 0.06115399f, 
    0.06769586f, 0.07264688f, -0.03438497f, 0.03090196f, -0.02111679f, 0.05372558f, -0.05485754f, -0.05591451f, 
    0.01237238f, -0.00588477f, 0.01316821f, 0.07355425f, -0.03796745f, -0.00723862f, -0.06569610f, -0.03245694f, 
    -0.03729093f, 0.02047395f, -0.06973387f, 0.02057789f, 0.04123788f, 0.03068700f, -0.07203051f, 0.04643303f, 
    0.02118045f, 0.07220779f, -0.06688313f, -0.08392438f, -0.00956694f, -0.02382349f, -0.04207046f, -0.04100459f, 
    -0.04752176f, -0.00362330f, -0.01533250f, 0.05858225f, -0.09344653f, -0.03721345f, -0.06220783f, -0.04786025f, 
    0.01185429f, -0.01483908f, 0.07413092f, -0.03975972f, 0.04191069f, -0.07734128f, -0.01879147f, 0.00099774f, 
    0.02694267f, 0.05579926f, 0.03395070f, -0.02753171f, 0.00828404f, -0.04268308f, 0.04366624f, -0.01642495f, 
    -0.05135332f, -0.06338471f, 0.05666884f, -0.02844975f, -0.03366362f, -0.05658682f, 0.03604057f, -0.03667506f, 
    -0.08164214f, -0.05410304f, 0.03190766f, -0.04364094f, -0.05129321f, -0.04734113f, 0.07785038f, -0.06680349f, 
    -0.04444365f, -0.06723365f, 0.00615611f, -0.00551580f, 0.06717420f, 0.03922635f, -0.07447377f, -0.02308098f, 
    0.06432530f, -0.01617766f, -0.08093435f, 0.05293483f, -0.02384039f, 0.05625840f, -0.00360288f, -0.06976730f, 
    -0.06076383f, 0.01522951f, -0.01827389f, 0.04029081f, -0.04026731f, -0.03573968f, -0.05723302f, 0.00391362f, 
    -0.00212283f, -0.02261700f, -0.07083104f, -0.03375053f, -0.06765340f, 0.06744827f, -0.05921349f, 0.01339516f, 
    0.04920773f, 0.00176616f, 0.06784654f, 0.07573970f, -0.03046125f, 0.01648819f, -0.08192674f, -0.05690024f, 
    0.04846611f, -0.01653815f, -0.06414194f, 0.04008768f, -0.04214769f, -0.05689482f, 0.05403016f, -0.08022285f, 
    0.01680830f, 0.01500316f, -0.77518314f, 0.16104536f, 0.18033867f, 0.11157259f, -0.08147793f, -0.07922569f, 
    -0.00644231f, -0.07773147f, -0.25098017f, 0.09964848f, 0.07979239f, 0.12192996f, 0.14918490f, 0.09208024f, 
    0.21223648f, -0.18329532f, 0.44540182f, -0.00861105f, 0.07974958f, -0.17308234f, -0.04886837f, 0.03530000f, 
    -0.00647491f, 0.08239651f, -0.08428830f, 0.37268823f, 0.24175464f, -0.11772430f, -0.09687678f, -0.10201621f, 
    -0.00602774f, 0.04300044f, 0.06135478f, 0.07601241f, 0.26450107f, 0.03395914f, 0.14660880f, -0.21416639f, 
    0.20787904f, -0.18069728f, 0.08773296f, -0.14295289f, 0.02857471f, 0.14483002f, -0.32722476f, -0.40777031f, 
    0.03490986f, 0.12895778f, 0.00281431f, 0.19726998f, -0.09247410f, -0.11817183f, 0.00336885f, 0.13494179f, 
    0.05769351f, 0.12469931f, 0.03422723f, 0.04452254f, -0.07740934f, 0.10012963f, -0.00719181f, 0.19400451f, 
    -0.04790436f, 0.00357771f, -0.10114034f, 0.01514106f, -0.13400327f, -0.20857924f, 0.08535459f, -0.10694635f, 
    -0.28313059f, -0.11999563f, -0.20052952f, -0.04197240f, 0.04504452f, -0.16886285f, -0.03510755f, 0.04775746f, 
    0.06072983f, -0.15569383f, -0.42055559f, 0.00640131f, 0.01412643f, 0.16004682f, 0.05836957f, -0.00544144f, 
    0.07507941f, -0.11146075f, 0.15967867f, -0.15929499f, -0.25605085f, 0.03013772f, 0.00167340f, 0.01307291f, 
    -0.06396633f, -0.01971049f, -0.11502626f, 0.25286341f, 0.05197381f, 0.23069806f, -0.24486068f, 0.01309628f, 
    0.00221072f, 0.02093306f, 0.06366710f, -0.03043320f, -0.11903686f, 0.04204079f, -0.02698586f, -0.07964756f, 
    0.15770259f, -0.02169078f, 0.00218822f, -0.08453357f, 0.10684881f, -0.08774754f, -0.02544146f, 0.10611138f, 
    -0.09298415f, 0.00161945f, -0.16697778f, -0.10183813f, 0.07809974f, 0.10189793f, 0.30956340f, 0.14992535f, 
    0.41828427f, -0.04981101f, -0.16634934f, 0.15289843f, 0.12168005f, 0.24017280f, 0.23309465f, -0.15242587f, 
    -0.16153744f, -0.38371873f, 0.04634000f, 0.15745935f, -0.03675900f, 0.04096433f, 0.03074337f, 0.03935631f, 
    0.16122055f, -0.03195946f, 0.30769470f, -0.23314413f, -0.05651681f, -0.06152379f, 0.05076426f, -0.00995954f, 
    -0.10888031f, 0.22853504f, 0.30907279f, -0.00978754f, -0.15770197f, -0.11334005f, -0.08096194f, 0.01651045f, 
    -0.01643019f, 0.21505463f, -0.00587810f, 0.05303010f, -0.07638889f, 0.21042942f, 0.09604440f, 0.26726690f, 
    -0.00297749f, -0.04768046f, -0.03626560f, -0.14479358f, 0.01608978f, -0.14268683f, 0.09212881f, 0.05036415f, 
    0.13640095f, 0.01509023f, 0.15663873f, 0.01503650f, -0.18725260f, 0.00763238f, -0.16801220f, 0.11681435f, 
    -0.04557538f, 0.12221614f, -0.05684774f, 0.06574483f, 0.15370545f, -0.41752839f, -0.34345770f, 0.29213384f, 
    -0.11001540f, -0.08811606f, 0.03549499f, -0.02956613f, -0.12211037f, -0.00976696f, 0.22178705f, -0.09410746f, 
    -0.04710019f, -0.34417668f, -0.07973290f, -0.23144470f, -0.00032272f, -0.08128587f, 0.00698145f, 0.07583550f, 
    -0.14008236f, -0.54465240f, 0.23843622f, 0.12822303f, 0.08204804f, 0.21922614f, 0.09385716f, -0.29504663f, 
    0.08230765f, -0.08847882f, 0.24106014f, -0.01786586f, -0.07167560f, -0.12900311f, 0.03429506f, -0.01748281f, 
    0.08758049f, -0.30794281f, -0.10448998f, -0.19053048f, 0.09833761f, 0.04503347f, 0.04305694f, -0.13349770f, 
    -0.11475835f, 0.06779462f, -0.61910003f, -0.31485832f, -0.03905176f, -0.12003066f, 0.11222963f, -0.05595157f, 
    -0.07789192f, -0.14237614f, 0.16431761f, 0.13624054f, 0.04864269f, -0.17585112f, 0.09121905f, 0.13019408f, 
    -0.18690605f, 0.13420013f, 0.10518759f, -0.15941049f, 0.27117595f, 0.28453261f, 0.05038776f, -0.02939564f, 
    0.01047299f, -0.10875659f, 0.11103714f, -0.10764673f, 0.27980956f, -0.14386705f, 0.15178774f, -0.50479901f, 
    0.09731290f, -0.05503238f, 0.09580623f, 0.12945302f, -0.14827800f, 0.16467836f, 0.16382346f, -0.05477675f, 
    0.00460881f, 0.33239779f, 0.13295983f, 0.01510927f, 0.16900146f, 0.08421459f, 0.20584141f, -0.08564895f, 
    -0.21097669f, -0.20606436f, 0.20600875f, 0.05236292f, 0.05128073f, 0.18764023f, 0.07931577f, 0.14584151f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08336002f, 0.02603261f, 0.12744987f, 0.05103983f, 0.10056376f, 0.08467179f, -0.18379474f, 0.12909207f, 
    0.10327978f, 0.01315770f, 0.06740309f, -0.04595388f, -0.12926099f, -0.03200942f, 0.09440409f, 0.27152359f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14290497f, -0.10986415f, 0.14937815f, 0.04334801f, -0.10524353f, -0.20778720f, -0.12616235f, -0.26174304f, 
    -0.11988748f, -0.15540655f, -0.13892037f, -0.07227878f, 0.10251662f, 0.08628593f, -0.10153674f, 0.12664215f, 
    0.23630421f, 0.05863549f, 0.22996910f, 0.02493087f, 0.10154039f, -0.23339510f, 0.10022411f, 0.15394452f, 
    -0.32844251f, -0.05552579f, -0.20780659f, -0.04600132f, 0.21738155f, 0.00058214f, -0.02740067f, 0.26351434f, 
    -0.12881854f, -0.12899539f, -0.19256893f, -0.23451537f, -0.01567630f, -0.09759501f, -0.10520585f, -0.14649367f, 
    -0.21456155f, 0.02098217f, -0.24879315f, 0.13923126f, 0.02024623f, -0.12942016f, -0.20711145f, -0.04750647f, 
    0.01352871f, 0.46132696f, -0.10994774f, 0.08471327f, -0.19163387f, 0.36584857f, 0.21297327f, 0.32895792f, 
    -0.31559679f, 0.32859284f, 0.15037322f, 0.50539231f, -0.02643865f, -0.04023805f, -0.41874945f, 0.10497168f, 
    -0.23807906f, 0.33936742f, -0.21490324f, 0.16793467f, 0.42370227f, 0.33283660f, -0.06385065f, -0.29026613f, 
    0.31949776f, -0.09523512f, 0.02281315f, 0.14144552f, -0.14357552f, 0.11546965f, -0.16204923f, 0.24051341f, 
    0.06149957f, -0.25589129f, 0.43592313f, -0.04956035f, -0.12771674f, 0.43091008f, -0.12825516f, -0.35729250f, 
    -0.13687623f, 0.00886587f, -0.51898980f, 0.23985514f, 0.17236802f, 0.09804320f, 0.27660358f, 0.05566373f, 
    -0.11756417f, -0.25753629f, 0.36758757f, 0.00367030f, 0.15320833f, 0.01148365f, -0.13509019f, 0.23712161f, 
    -0.18606173f, -0.23761310f, 0.05345841f, 0.31161460f, 0.31036463f, -0.10481750f, -0.22086617f, 0.39359096f, 
    -0.11383680f, 0.01228813f, 0.19753247f, 0.21579342f, 0.17986676f, 0.12217095f, -0.18917058f, 0.07818853f, 
    0.49831378f, -0.28728658f, 0.46750143f, 0.05863596f, 0.12954223f, -0.07238997f, -0.01273740f, -0.17288053f, 
    0.00023808f, -0.14947316f, 0.24297103f, 0.13977499f, 0.01307240f, 0.20891389f, -0.00838094f, 0.25778431f, 
    -0.11376134f, 0.29950905f, -0.06595519f, 0.51157141f, -0.09322272f, 0.12918955f, -0.50776792f, 0.33541495f, 
    0.08319184f, 0.48540768f, 0.13103679f, -0.17896268f, -0.03525473f, 0.00147218f, 0.15371993f, -0.19481513f, 
    0.27044177f, -0.20510355f, -0.16912985f, 0.01749428f, 0.07793473f, -0.15673892f, -0.31951243f, 0.18335697f, 
    0.20847782f, 0.57852495f, -0.36117491f, -0.23194666f, 0.25489730f, -0.07534492f, -0.03974106f, -0.05354075f, 
    0.21385635f, -0.15309036f, 0.43331894f, 0.04633449f, 0.16165523f, 0.22847964f, -0.05709319f, -0.10734354f, 
    -0.08901209f, 0.30642694f, -0.23252940f, -0.11452486f, 0.20090999f, -0.01745319f, 0.34899202f, 0.02556036f, 
    -0.19522272f, -0.17550385f, -0.40643173f, -0.23308958f, -0.15528420f, 0.06295681f, 0.31351531f, 0.19542426f, 
    0.21648614f, 0.43391320f, -0.14645770f, 0.05560954f, 0.21042307f, 0.49221411f, -0.42189962f, 0.42991287f, 
    -0.22179729f, -0.10202273f, 0.43626153f, 0.26292688f, -0.29608348f, -0.10370199f, -0.13575548f, 0.24057819f, 
    0.09824723f, 0.03198593f, -0.43669111f, -0.09373456f, -0.11786706f, -0.06790774f, 0.25887448f, 0.07725262f, 
    -0.14307395f, 0.19670993f, -0.30873612f, 0.10716935f, -0.11925191f, 0.12865752f, 0.29754049f, -0.11813274f, 
    -0.20640486f, 0.22500783f, -0.03006469f, 0.10748724f, -0.09905110f, 0.14577062f, -0.27988753f, 0.22606805f, 
    0.42276499f, -0.27420411f, -0.10623626f, 0.22273423f, 0.27670664f, 0.12693177f, 0.05614036f, 0.00335582f, 
    0.20110182f, -0.10393158f, -0.41270581f, 0.14501536f, 0.28707221f, 0.31420770f, 0.14902173f, -0.05509486f, 
    0.39597866f, 0.44883355f, -0.15620378f, -0.09283202f, -0.05633629f, 0.19543542f, 0.35181242f, -0.36500123f, 
    0.13624994f, -0.46578324f, -0.14325793f, 0.14972901f, -0.25884596f, 0.30368254f, -0.20927034f, 0.20410646f, 
    -0.03950939f, 0.78696901f, -0.25397724f, -0.36156714f, -0.04319797f, 0.20915842f, 0.20326814f, 0.31172967f, 
    -0.06278685f, 0.15135716f, -0.46608877f, -0.02073921f, 0.03994313f, -0.02274055f, 0.29795167f, 0.02341753f, 
    0.48904878f, 0.15742134f, 0.36622488f, -0.67548829f, 0.27487436f, 0.18248104f, -0.21561560f, 0.30814594f, 
    0.11725049f, 0.50380152f, -0.15000167f, -0.07518428f, -0.14063500f, 0.31065238f, -0.00461198f, 0.19224453f, 
    -0.20828792f, -0.25850904f, -0.08245040f, -0.30650845f, -0.16006587f, 0.08800429f, 0.04553168f, 0.31085366f, 
    0.04479402f, 0.08291247f, -0.20274332f, -0.16100204f, -0.37525550f, 0.05876580f, -0.27101913f, -0.07674032f, 
    -0.44638300f, 0.34548664f, 0.40445504f, 0.57401079f, 0.27855039f, -0.19330163f, 0.07240280f, 0.18468526f, 
    -0.04758772f, 0.11828199f, 0.11514848f, 0.06270241f, 0.04533054f, -0.53240520f, -0.00402001f, 0.24957803f, 
    -0.46362230f, 0.18064617f, -0.15444481f, 0.22894146f, 0.00061187f, -0.11216547f, 0.27484930f, 0.00778422f, 
    0.13259280f, 0.01594933f, 0.47016290f, -0.22303066f, -0.15164128f, -0.31599399f, -0.32420716f, 0.22210023f, 
    0.41921735f, 0.12968107f, 0.29579565f, -0.00181143f, 0.30591574f, 0.04356579f, 0.00802053f, -0.13429181f, 
    0.15821011f, -0.61316663f, 0.09517664f, -0.05787394f, -0.06677997f, 0.48382601f, 0.20443118f, 0.09365232f, 
    0.13867369f, 0.09600092f, -0.11408455f, 0.22558734f, 0.05831442f, 0.18161447f, -0.17679611f, 0.14105505f, 
    0.09342026f, -0.16958591f, -0.37575355f, -0.14702633f, 0.03194379f, 0.03465238f, -0.00242649f, -0.49986932f, 
    -0.01615855f, -0.40763915f, 0.06118752f, 0.31034574f, 0.64741212f, -0.03182060f, 0.37949872f, -0.05269493f, 
    0.05890746f, 0.00971005f, 0.17960365f, 0.24426633f, 0.16754670f, 0.36684439f, 0.28277624f, -0.19229232f, 
    -0.11693954f, 0.25262454f, -0.22532576f, -0.01622914f, 0.03519692f, 0.17221694f, -0.26768321f, 0.08676202f, 
    0.13239199f, 0.02821230f, -0.33745554f, 0.24024926f, -0.03611331f, 0.09693120f, 0.34703580f, 0.14006169f, 
    -0.07312981f, 0.36245054f, 0.13396369f, 0.24251889f, -0.14204586f, -0.24368218f, -0.36048004f, 0.43174016f, 
    -0.21911705f, 0.05798344f, -0.27551809f, 0.13907482f, 0.37837920f, -0.10383398f, 0.07236442f, 0.30316648f, 
    0.16273609f, -0.46483886f, 0.09649419f, -0.10929181f, -0.06451636f, 0.14401914f, 0.23706524f, 0.21019684f, 
    -0.00420342f, -0.61179662f, 0.15810949f, -0.11481252f, 0.15425321f, 0.20602289f, -0.20718461f, -0.19244742f, 
    -0.33572125f, -0.12511119f, -0.12650381f, -0.06492451f, 0.17869878f, -0.00917629f, 0.43667603f, 0.57446486f, 
    0.11388820f, 0.16845889f, -0.35132051f, 0.20970847f, -0.02610261f, 0.02880707f, 0.47150373f, 0.11904585f, 
    0.37903854f, -0.01840636f, -0.46639848f, 0.19443591f, 0.12847376f, -0.09701356f, -0.23240216f, 0.06809655f, 
    -0.23382135f, 0.23268965f, 0.21014538f, 0.21677187f, 0.56441420f, 0.22232962f, -0.32245484f, -0.31120226f, 
    0.22216603f, -0.14894001f, 0.08008091f, -0.29519278f, -0.42105401f, 0.02731306f, 0.04812067f, 0.13849194f, 
    -0.10861984f, 0.36096090f, -0.44728205f, -0.09541366f, 0.30353433f, -0.10544898f, -0.35728097f, -0.25177497f, 
    0.04302887f, -0.01504888f, -0.00719169f, 0.22885503f, -0.33947101f, -0.16044408f, 0.04316792f, 0.37015432f, 
    0.17514950f, 0.14425594f, 0.34814653f, 0.04823123f, -0.36263520f, 0.04920710f, -0.12951000f, 0.11284884f, 
    0.24781618f, 0.23363884f, 0.16607812f, 0.46171755f, -0.19490892f, -0.15068923f, -0.41107193f, 0.17401423f, 
    0.16368535f, -0.22715035f, 0.06231369f, 0.03984152f, -0.05417894f, 0.52077651f, -0.27073857f, 0.35537425f, 
    0.42908445f, 0.49525028f, -0.28010219f, -0.37588957f, 0.25267705f, 0.08397906f, 0.03061973f, -0.07801845f, 
    0.08026723f, 0.17457268f, -0.18332210f, 0.12159527f, -0.10823558f, -0.11058988f, 0.12022300f, -0.22981219f, 
    0.41219357f, 0.57312131f, -0.00430319f, 0.26356709f, -0.33446538f, 0.16947114f, 0.16487302f, -0.33185762f, 
    -0.14903000f, 0.42619213f, 0.21980195f, 0.04177170f, 0.15323314f, -0.29619464f, -0.01871844f, -0.44240156f, 
    -0.46009177f, 0.27225170f, -0.19646922f, -0.23238130f, 0.12239862f, -0.00933777f, 0.21946482f, 0.24191695f, 
    -0.02580277f, -0.20972188f, 0.41123202f, -0.11610568f, 0.14026661f, 0.60221887f, 0.17197011f, 0.23873378f, 
    0.35873237f, -0.07204176f, -0.27442071f, 0.03792039f, -0.16196240f, 0.16702811f, -0.07099680f, -0.25639284f, 
    -0.17433885f, 0.09664958f, 0.49903738f, 0.08881760f, -0.11997560f, -0.00632077f, -0.38117790f, 0.08449842f, 
    -0.04624682f, -0.66578132f, 0.22032823f, 0.11670835f, 0.38279527f, 0.20561111f, -0.06080252f, -0.42528290f, 
    -0.20702997f, 0.11265717f, 0.22385491f, 0.10063262f, -0.36182851f, 0.46975407f, -0.16243102f, 0.29119393f, 
    0.33725265f, 0.26698071f, -0.43364599f, -0.37154019f, 0.15795958f, -0.08097380f, 0.11715976f, 0.10651396f, 
    -0.14368826f, 0.15986541f, 0.28951541f, -0.16269375f, -0.01614898f, -0.08977392f, 0.14844641f, -0.34780744f, 
    0.25667024f, -0.34250918f, 0.07813829f, 0.44349843f, 0.48902985f, 0.16407764f, -0.11930399f, -0.03197145f, 
    0.15979438f, -0.27052990f, 0.33502692f, 0.08190012f, 0.24271573f, -0.25731230f, -0.02854245f, 0.04332175f, 
    -0.16750763f, -0.04998904f, 0.49135005f, 0.55311650f, 0.18352209f, 0.24183369f, -0.12294574f, 0.34948441f, 
    -0.21540019f, 0.08746301f, -0.36967665f, -0.05976285f, 0.22539672f, 0.33172190f, 0.25007698f, 0.14501306f, 
    -0.13633618f, 0.32932317f, 0.10426300f, 0.05240848f, -0.39248052f, -0.02726729f, -0.23942889f, 0.27643111f, 
    -0.16548741f, -0.19263455f, -0.07244379f, -0.05971068f, 0.05727844f, -0.05756141f, 0.02558417f, 0.16715956f, 
    0.06459603f, 0.00423024f, 0.06905905f, -0.24676774f, -0.10390637f, 0.02861583f, -0.25211790f, -0.23525403f, 
    0.18088073f, 0.32295996f, -0.62781245f, -0.07829270f, -0.01166091f, 0.23561168f, -0.27266449f, -0.44285414f, 
    0.09399825f, 0.04668356f, 0.23770781f, 0.70799887f, -0.12771530f, -0.14140931f, 0.04915653f, 0.23010977f, 
    0.15433414f, -0.10832886f, -0.20377029f, 0.20527570f, 0.36985007f, -0.12045705f, 0.10627361f, 0.27684188f, 
    0.46073446f, -0.31328553f, 0.21494399f, -0.39688468f, 0.08917391f, -0.06557236f, 0.04603915f, -0.10173307f, 
    -0.20604903f, 0.26457179f, -0.30631167f, 0.21890351f, -0.08971027f, 0.22694279f, 0.37028852f, -0.24534327f, 
    -0.64630759f, -0.45602891f, 0.29827186f, 0.03163690f, -0.11350285f, -0.08161041f, -0.00457662f, 0.28071725f, 
    -0.03105755f, -0.11234110f, 0.45070821f, -0.17177048f, -0.18542330f, 0.04407623f, -0.06274912f, 0.09241994f, 
    -0.24976954f, -0.05318223f, 0.24125600f, 0.65885729f, 0.40361795f, -0.08051876f, -0.18519022f, 0.21179748f, 
    -0.17807490f, 0.23678577f, -0.03754041f, 0.02046568f, -0.13128878f, -0.10073718f, 0.22211803f, -0.17154683f, 
    0.15695657f, -0.00944896f, 0.13518563f, 0.25255033f, 0.36576533f, 0.18164347f, 0.18652289f, -0.43180940f, 
    0.02492926f, -0.04024807f, 0.48324791f, 0.05414357f, -0.02260163f, 0.12518400f, -0.59568948f, 0.31286183f, 
    0.11484365f, 0.33763704f, -0.00483967f, 0.14220108f, -0.17355083f, 0.05202695f, 0.31532148f, -0.32506672f, 
    0.20362140f, 0.27359611f, -0.22041133f, 0.09594998f, 0.05100330f, -0.01025206f, 0.15965267f, 0.54781979f, 
    -0.20622529f, 0.01625281f, 0.14355174f, -0.55288827f, -0.35655564f, 0.14250080f, 0.45131668f, -0.34656313f, 
    -0.18821850f, 0.20709772f, -0.22826108f, 0.19175014f, 0.00937248f, -0.06914096f, -0.03655636f, -0.31303090f, 
    0.38490275f, 0.34490612f, 0.50553721f, -0.49014276f, -0.42518145f, -0.16584057f, -0.02596635f, 0.04938972f, 
    0.15683943f, 0.25903255f, -0.27808535f, 0.21058093f, -0.21346131f, 0.21290170f, 0.24984138f, 0.01846118f, 
    -0.40274525f, 0.34042719f, -0.13014510f, 0.26910225f, 0.44896242f, 0.17254746f, -0.27175263f, -0.12108296f, 
    -0.19078809f, -0.04104028f, -0.21074936f, -0.11312315f, -0.14051296f, -0.16676430f, 0.00758646f, -0.64553404f, 
    -0.00718181f, -0.15880398f, 0.32008648f, 0.15107718f, 0.23981760f, -0.20227638f, 0.10496486f, 0.01829878f, 
    0.23521727f, 0.26877102f, -0.24743958f, -0.12401108f, -0.22690803f, -0.24198751f, 0.41035348f, -0.03232627f, 
    0.05253393f, -0.25852680f, 0.23551004f, 0.37615976f, 0.34618485f, -0.16340192f, -0.17753568f, 0.26243091f, 
    -0.05404320f, 0.14401452f, -0.41461027f, 0.21555886f, -0.26135677f, 0.23969929f, 0.28738871f, 0.51029950f, 
    -0.10610819f, -0.20199373f, -0.07080146f, -0.14569464f, -0.15480021f, -0.02377435f, -0.08763004f, 0.32804573f, 
    -0.22717287f, 0.17426156f, -0.38660640f, -0.16680913f, 0.00488539f, 0.31108314f, -0.43933576f, -0.03617330f, 
    -0.05400051f, 0.32938203f, -0.54384929f, 0.29601556f, 0.30179942f, 0.01584744f, 0.23479037f, -0.10753232f, 
    0.08029005f, 0.05054545f, -0.21709991f, -0.02766293f, 0.01296448f, 0.02032482f, -0.21686260f, -0.07140773f, 
    -0.10227892f, -0.16984127f, -0.24452487f, -0.19006395f, -0.06315755f, -0.20262247f, -0.12936585f, 0.18370889f, 
    -0.00803149f, 0.05253847f, -0.05561162f, 0.17601915f, 0.07757830f, 0.07924474f, -0.21960503f, 0.06899679f, 
    -0.12935674f, 0.22612156f, 0.10638487f, 0.21857142f, -0.35957333f, -0.05641685f, -0.10996561f, 0.55151910f, 
    0.03670518f, 0.01605041f, 0.12694873f, -0.02158544f, 0.39585140f, 0.13954592f, -0.17078389f, -0.64280301f, 
    0.22394191f, 0.20697728f, -0.51390374f, 0.02438590f, 0.38986874f, -0.11840376f, -0.04294780f, 0.11982277f, 
    0.10006348f, 0.07407609f, 0.05175229f, -0.01783988f, 0.04339486f, 0.21982582f, 0.01395216f, 0.11001478f, 
    0.08927675f, 0.48548967f, -0.15631229f, 0.42159232f, -0.23888731f, 0.16907136f, -0.56138974f, -0.25940073f, 
    -0.06417689f, -0.19715042f, -1.00989580f, -0.22054389f, 0.28814584f, 0.37169480f, 0.09638906f, 0.03561262f, 
    0.31755200f, -0.07020038f, 0.10374420f, -0.22724697f, -0.18606921f, -0.07002798f, -0.34651345f, 0.27380979f, 
    0.10776733f, 0.39520925f, 0.49418139f, 0.08668786f, 0.11186900f, 0.10192727f, -0.18813406f, -0.23265648f, 
    0.30887908f, -0.43745902f, -0.35344645f, -0.21096313f, -0.10677788f, 0.16671319f, -0.34721205f, 0.02642684f, 
    -0.20329531f, 0.16412221f, -0.00218942f, 0.23763083f, 0.12387334f, -0.25265145f, 0.43697649f, -0.19853635f, 
    -0.15772396f, 0.30005953f, 0.08835445f, -0.42043701f, -0.15887801f, -0.03119313f, 0.45428815f, -0.10419944f, 
    -0.07229027f, -0.09245683f, 0.33212897f, -0.23485285f, 0.25772855f, 0.41567895f, -0.35911411f, -0.05887156f, 
    0.24819098f, 0.39027816f, -0.22533035f, 0.06622316f, -0.15507509f, 0.14961798f, 0.39831245f, -0.34956503f, 
    -0.02262160f, -0.10619218f, -0.73812747f, -0.17559180f, 0.05587306f, 0.54630035f, 0.07251377f, -0.36354995f, 
    0.63507724f, -0.28215033f, -0.04774088f, -0.16203006f, 0.13366020f, -0.14161971f, 0.19269425f, -0.16447182f, 
    -0.21344748f, 0.34749836f, 0.29341263f, 0.13388544f, 0.02925205f, -0.05638418f, 0.42696267f, -0.19191509f, 
    -0.53990805f, 0.17940725f, -0.57544380f, 0.20369653f, 0.24939896f, 0.10314690f, -0.20433100f, -0.08384966f, 
    -0.06788393f, -0.38686019f, 0.30368251f, -0.05687631f, -0.13398044f, -0.05267929f, -0.03150349f, -0.12826957f, 
    -0.08303534f, -0.03816100f, 0.26541618f, -0.70511693f, -0.29902017f, 0.04814704f, 0.21842214f, 0.01704460f, 
    -0.21618995f, 0.12822545f, 0.43150574f, 0.22696316f, 0.27462071f, 0.47125068f, -0.23661564f, 0.00239020f, 
    0.00837337f, -0.23848853f, 0.17769445f, -0.23977038f, -0.08464912f, -0.18803713f, -0.12801142f, -0.04565921f, 
    -0.08835394f, 0.29250035f, 0.39708379f, 0.07783171f, 0.04659880f, -0.03667419f, 0.06794340f, -0.06307254f, 
    -0.29757115f, -0.72736025f, -0.01378007f, 0.10015818f, -0.05798663f, -0.16215292f, 0.05359753f, 0.42056763f, 
    0.14922102f, 0.36764067f, 0.02792042f, -0.09377287f, -0.40503880f, 0.06559950f, -0.03863347f, 0.30383426f, 
    0.18507019f, 0.58945119f, 0.11965564f, 0.06396988f, -0.41587290f, -0.01371493f, -0.25410092f, -0.04486008f, 
    -0.04632436f, 0.13116169f, -0.09884179f, 0.17454427f, 0.00629175f, 0.23347519f, -0.09613737f, 0.25046265f, 
    0.15892509f, 0.29867056f, 0.12097576f, 0.31467691f, -0.21599624f, -0.08866701f, 0.11628731f, -0.55200058f, 
    -0.23496322f, -0.42723468f, 0.31225628f, 0.21007752f, 0.13933380f, -0.15981328f, -0.25446945f, 0.12783512f, 
    0.16239460f, -0.04183623f, -0.11617902f, -0.17455442f, -0.23546484f, -0.05688214f, -0.27309766f, 0.66522306f, 
    -0.12825225f, 0.38617232f, -0.21873318f, 0.14721718f, 0.10690003f, -0.11597680f, 0.12374847f, 0.08965207f, 
    0.34149626f, -0.09943181f, -0.26374248f, 0.25952005f, -0.13737167f, -0.00135177f, 0.28522259f, -0.05212321f, 
    -0.03226658f, -0.12677315f, 0.27155092f, -0.23646086f, 0.42612201f, 0.13640785f, 0.01466147f, -0.37769470f, 
    -0.37358201f, 0.33893329f, 0.15931283f, -0.14226510f, -0.13687854f, -0.22136158f, 0.30690020f, 0.16309716f, 
    0.22550961f, -0.00797578f, 0.11465785f, 0.21453692f, -0.17300022f, 0.07382367f, 0.48677620f, -0.15877210f, 
    -0.01984584f, -0.25342113f, -0.12689020f, 0.38426411f, 0.59938347f, 0.23497333f, -0.44119099f, -0.30155212f, 
    -0.21303050f, -0.07982378f, -0.21181118f, -0.16084424f, -0.07822719f, -0.23879701f, -0.16999368f, -0.12387281f, 
    -0.08436698f, -0.20154469f, 0.22372328f, -0.22485426f, -0.19090560f, 0.14839613f, -0.18073066f, -0.11385786f, 
    0.00096730f, -0.01088490f, 0.37149549f, 0.02005955f, -0.07682999f, 0.16458569f, -0.49365568f, 0.34741244f, 
    0.32456481f, -0.02620969f, -0.13196157f, -0.14086217f, -0.06391199f, 0.14341815f, 0.07178818f, -0.22862649f, 
    -0.01022271f, -0.05839378f, 0.14412154f, 0.05798746f, 0.16449788f, -0.15318947f, -0.36024022f, 0.14151017f, 
    0.24973443f, 0.09210064f, -0.19365323f, -0.31911987f, 0.24900462f, 0.03147867f, 0.42454338f, 0.09014335f, 
    0.20627515f, 0.08547186f, -0.04017524f, 0.19952905f, 0.22774196f, -0.40893716f, 0.51532364f, 0.21865456f, 
    -0.69970137f, -0.06378587f, -0.32699654f, 0.11400635f, 0.14277537f, 0.06963206f, 0.12867638f, 0.05406295f, 
    0.18171632f, -0.32539755f, -0.00289645f, -0.04420811f, -0.10501665f, -0.11649920f, 0.15117179f, -0.05788260f, 
    0.17735502f, 0.46424598f, -0.40948370f, 0.05817116f, 0.19549912f, -0.08788297f, 0.03251145f, 0.46085122f, 
    0.09377044f, -0.17643227f, 0.19725744f, -0.23406917f, 0.13321193f, -0.44171068f, -0.22958922f, -0.17289023f, 
    0.11225905f, -0.10147434f, 0.47025299f, -0.21670938f, 0.39010394f, 0.12632655f, 0.08822983f, 0.36605126f, 
    0.22937275f, -0.15763082f, -0.57693416f, 0.07521372f, 0.13749313f, 0.26379040f, 0.40029004f, -0.11600409f, 
    0.30385917f, 0.11583920f, -0.86793160f, 0.01172306f, 0.06966620f, 0.23323527f, 0.03575609f, 0.34709808f, 
    0.10803759f, 0.50117552f, -0.27137268f, -0.09099404f, 0.39928865f, 0.11294301f, 0.31353912f, -0.21024166f, 
    -0.20771988f, 0.31730086f, 0.27416015f, -0.23761827f, -0.03112033f, 0.09702301f, -0.37832007f, -0.05257011f, 
    -0.02333648f, 0.16291972f, -0.26877582f, -0.09956641f, 0.29910171f, -0.00857694f, 0.60031164f, -0.11650671f, 
    -0.08304714f, 0.21255474f, 0.48276734f, 0.04631689f, -0.30458760f, -0.06789404f, -0.08644012f, 0.07238952f, 
    0.23332508f, 0.08729859f, -0.30276480f, 0.04889859f, 0.23305781f, -0.31867418f, -0.20820665f, -0.06348981f, 
    -0.25699985f, -0.56703138f, 0.55831951f, 0.43084639f, 0.40074250f, -0.17503612f, 0.17169502f, 0.43346468f, 
    0.25410372f, 0.21798365f, -0.13911843f, 0.23487835f, 0.00982625f, -0.10272320f, -0.06587685f, 0.34977582f, 
    0.62781787f, -0.22692525f, 0.39516875f, -0.03858019f, -0.04699592f, -0.09820494f, 0.10344567f, -0.12141664f, 
    0.14858964f, -0.21359499f, -0.20430411f, -0.13147187f, 0.01023869f, -0.18688565f, -0.19212705f, -0.02252607f, 
    0.08148590f, -0.19578737f, -0.16386399f, -0.09640628f, -0.02309611f, -0.10101306f, 0.10089543f, -0.23785016f, 
    -0.09325782f, -0.00418424f, -0.02627468f, 0.23110896f, 0.24876934f, 0.21149853f, 0.53686988f, -0.09907413f, 
    -0.02726956f, -0.48680428f, -0.38978732f, 0.14869265f, -0.11836664f, -0.19195896f, 0.01726456f, 0.39895508f, 
    0.20418429f, 0.15937266f, -0.00955260f, -0.22677502f, -0.17925967f, 0.59600759f, 0.35324138f, -0.33865502f, 
    0.16292325f, 0.06221597f, -1.16680026f, -0.22057053f, 0.33043692f, -0.18339713f, 0.01788184f, 0.16920607f, 
    -0.15384939f, -0.35965094f, 0.48062149f, -0.15418114f, -0.32916853f, -0.23761055f, 0.33550096f, 0.18459576f, 
    0.02382596f, 0.23299918f, -0.06864761f, 0.18763092f, 0.38398555f, -0.14311589f, 0.16348976f, -0.11551992f, 
    -0.23855968f, -0.30648574f, 0.35121167f, -0.14213520f, -0.20817797f, -0.00436049f, 0.12054723f, -0.21888006f, 
    0.23964506f, -0.06063490f, 0.23459303f, 0.03823632f, 0.30823681f, -0.13931271f, 0.10239121f, -0.10836391f, 
    0.01075648f, 0.49466601f, -0.03511525f, -0.21941124f, 0.06910035f, 0.46609268f, -0.05514697f, 0.11760865f, 
    0.00770358f, 0.23027495f, -0.23877086f, 0.42762166f, -0.34029487f, 0.18888450f, -0.20066890f, 0.05224195f, 
    0.13836753f, 0.15845051f, 0.15003455f, 0.22690669f, -0.22195944f, 0.25506255f, -0.40113088f, -0.24509893f, 
    0.53569150f, -0.16059247f, -0.40110251f, 0.41021165f, 0.26246804f, 0.10207243f, -0.48546576f, -0.05791420f, 
    -0.14852424f, -0.09809396f, -0.33672771f, 0.24348181f, 0.35991877f, 0.11187436f, -0.19721621f, -0.20334272f, 
    -0.16253035f, -0.12668373f, 0.18459646f, -0.45257476f, -0.08556097f, 0.04865794f, 0.29007447f, 0.54431033f, 
    0.14600718f, -0.04994946f, 0.41510060f, 0.16380978f, -0.30565628f, 0.46628362f, -0.26560616f, -0.07500755f, 
    0.26374725f, -0.14750139f, -0.90850806f, 0.17425568f, 0.10950169f, 0.18152763f, 0.07036778f, -0.21364485f, 
    -0.19478245f, 0.27477282f, -0.16936679f, -0.11814584f, -0.52503091f, -0.21458481f, 0.19746590f, 0.40043795f, 
    0.13335687f, 0.54499412f, -0.30616105f, -0.21124427f, -0.08589722f, -0.13148986f, -0.01965988f, 0.15059292f, 
    0.10812163f, -0.13068736f, 0.17403619f, 0.00731337f, -0.07141153f, 0.28097546f, -0.03188401f, -0.08688626f, 
    0.10837927f, -0.16416474f, 0.50698566f, 0.15232792f, 0.36851069f, -0.04380338f, -0.40940583f, -0.36627918f, 
    0.09855057f, -0.29070961f, 0.19288506f, -0.00788448f, -0.10862859f, -0.21250379f, -0.18804917f, 0.14605093f, 
    0.02000568f, 0.40521270f, 0.37331802f, 0.36151496f, -0.04765569f, 0.11652535f, 0.27463722f, 0.10206168f, 
    0.08458361f, -0.21060653f, 0.47989795f, -0.21064122f, 0.43337208f, 0.40402210f, -0.65951443f, 0.34129342f, 
    -0.10105412f, -0.19824025f, -0.28567564f, 0.31873372f, -0.27859607f, -0.01863180f, 0.17320411f, -0.29258925f, 
    -0.18408668f, 0.04384116f, 0.01797446f, -0.02919370f, -0.29145288f, -0.34378317f, -0.09769268f, -0.15702830f, 
    -0.14297180f, 0.46611965f, 0.17361012f, -0.35799652f, 0.32486928f, -0.05949759f, 0.28710857f, 0.31517684f, 
    0.08647141f, 0.36490375f, -0.31412780f, 0.07233492f, 0.39798558f, 0.17319819f, -0.15676601f, 0.15481915f, 
    0.06572451f, 0.03979051f, 0.01274852f, -0.24028593f, -0.35589740f, -0.19722912f, 0.00468782f, -0.13066587f, 
    0.20062362f, -0.01910142f, 0.09733535f, 0.22746471f, -0.26281771f, 0.03871976f, 0.31625015f, 0.10719135f, 
    0.60458261f, -0.03818551f, -0.42257774f, -0.22601615f, 0.27231717f, -0.01343655f, 0.36167744f, -0.44231048f, 
    0.15058942f, 0.46281570f, 0.06479827f, -0.18881056f, -0.18332598f, 0.32274464f, -0.39556751f, 0.10806295f, 
    0.26309487f, -0.24126327f, -0.26551580f, 0.15415038f, 0.17376347f, 0.21271349f, 0.10570556f, -0.03729383f, 
    -0.05931167f, -0.38997480f, -0.11796073f, -0.06038275f, 0.40778250f, 0.52215368f, -0.16898458f, -0.22979659f, 
    0.49356258f, 0.23356454f, -0.04553605f, -0.54349250f, -0.07199342f, 0.04829817f, 0.26417518f, 0.03823221f, 
    -0.15087533f, -0.29846117f, 0.06190310f, 0.22401544f, 0.34656116f, 0.15963846f, -0.40299889f, 0.14499980f, 
    -0.22984186f, 0.38926542f, 0.23638645f, -0.19985217f, 0.27088693f, -0.16455823f, -0.10766178f, -0.33287191f, 
    0.13189419f, -0.07300647f, -0.06837534f, 0.18164110f, -0.18491149f, 0.12223805f, -0.05428647f, 0.16693674f, 
    -0.08320241f, -0.24679749f, -0.23183984f, 0.04304007f, -0.24756956f, -0.04954613f, -0.00006126f, -0.22607747f, 
    -0.03227434f, 0.16180041f, 0.00862171f, 0.06958970f, 0.29862577f, 0.02345071f, 0.10125120f, 0.10472726f, 
    -0.05514377f, -0.34285867f, -0.02931740f, -0.22591946f, -0.12744419f, -0.22745939f, 0.16531990f, 0.07933509f, 
    0.06395398f, 0.38659781f, -0.16432095f, -0.02287034f, 0.20513281f, 0.45926759f, -0.06601640f, -0.14736569f, 
    -0.17754316f, -0.01445383f, -0.00610051f, -0.23720047f, -0.33182770f, -0.20869915f, 0.12406959f, 0.06819529f, 
    0.23530976f, -0.22769423f, 0.11352152f, 0.20614915f, -0.38803676f, 0.05635457f, -0.13516605f, 0.14660954f, 
    0.05383122f, -0.02873977f, -0.65609705f, 0.21402423f, -0.02950384f, 0.23737566f, 0.46500763f, 0.49441320f, 
    -0.23877373f, 0.27842870f, 0.08801142f, -0.23885337f, -0.25325432f, -0.52719009f, 0.37345922f, 0.36167476f, 
    -0.27529293f, 0.16286549f, -0.39681566f, 0.37235180f, 0.31240946f, -0.14271905f, -0.17971487f, 0.22246511f, 
    -0.15973209f, -0.13362615f, 0.15489662f, 0.15755218f, 0.35632032f, 0.23535612f, 0.15836294f, 0.18503113f, 
    -0.13646369f, -0.47517076f, -0.23395288f, -0.27021548f, -0.19026817f, -0.15220778f, -0.30564022f, 0.46972370f, 
    0.13071579f, 0.35668531f, 0.08640363f, -0.10292955f, 0.07146282f, 0.09350048f, 0.36482033f, -0.16515684f, 
    -0.60004419f, 0.06211356f, -0.05126149f, 0.51929855f, 0.19018430f, 0.08765975f, -0.24075066f, -0.25424722f, 
    0.22822469f, -0.16637895f, 0.21960446f, -0.24943708f, 0.33718550f, 0.02756665f, -0.34513700f, 0.04260324f, 
    0.24448963f, -0.47586566f, -0.30300194f, -0.04234308f, 0.11236385f, -0.12522434f, 0.31423545f, 0.23288964f, 
    -0.19487777f, 0.07935235f, -0.17934954f, 0.22504452f, 0.54364336f, 0.11739493f, -0.24181272f, 0.15222009f, 
    -0.11316158f, -0.02740817f, 0.18886623f, 0.26941454f, -0.40342298f, -0.06250369f, -0.04703480f, 0.15504636f, 
    0.08625163f, 0.12129826f, 0.12741476f, 0.10596336f, 0.05520191f, -0.26477274f, -0.09097283f, 0.05876066f, 
    -0.06264921f, 0.26673540f, -0.02579222f, -0.24384907f, 0.08200735f, -0.03339651f, 0.15090571f, 0.17578611f, 
    0.24805951f, -0.18144977f, -0.21234335f, -0.06221081f, 0.19540152f, 0.00751879f, 0.19889359f, -0.31562731f, 
    0.12416197f, 0.17906459f, 0.20746136f, 0.10229403f, 0.04179038f, 0.10639475f, 0.08075445f, 0.29797125f, 
    0.03303381f, 0.09914857f, -0.21901327f, 0.05560507f, 0.14940347f, 0.27664319f, -0.51740479f, 0.16054048f, 
    0.08988718f, 0.46662357f, 0.17536984f, -0.15511793f, -0.32323092f, 0.06522927f, 0.24395010f, 0.01425473f, 
    0.13899697f, -0.15177803f, 0.29308945f, 0.09149091f, -0.17930049f, -0.45005003f, -0.78071231f, 0.53063178f, 
    -0.01220455f, -0.28877777f, -0.46813363f, 0.24206214f, -0.23248024f, -0.12268139f, 0.49604106f, 0.48805943f, 
    -0.23605677f, 0.02629716f, -0.46665263f, -0.24390738f, -0.01257775f, 0.57087320f, -0.80636913f, 0.15905796f, 
    0.07362048f, -0.23023927f, 0.18851131f, 0.10309178f, -0.03786113f, 0.19697602f, -0.13572326f, -0.08394056f, 
    0.12534364f, -0.18712828f, -0.01065858f, -0.23137000f, -0.16239570f, 0.18687747f, 0.06455455f, 0.36435735f, 
    -0.05415415f, 0.30981669f, -0.58114725f, -0.15708828f, -0.43838993f, 0.03558039f, 0.38044798f, 0.07691673f, 
    0.08978119f, -0.10138369f, 0.45683336f, -0.17377429f, 0.18034539f, 0.24400486f, -0.22147313f, -0.32098570f, 
    0.44749373f, 0.23613989f, 0.01403652f, -0.33647081f, 0.15815155f, -0.17114200f, 0.34966010f, -0.33185002f, 
    0.00348712f, -0.24873064f, 0.49082592f, -0.13354142f, 0.09284827f, -0.23440857f, -0.00163437f, -0.08393863f, 
    0.38033387f, -0.43629551f, 0.30749992f, -0.14104895f, 0.59640658f, -0.01475373f, 0.19853558f, 0.05295308f, 
    0.02427614f, 0.28821093f, -0.01854896f, -0.24784130f, -0.66467077f, -0.31990710f, -0.78315806f, 0.38143653f, 
    -0.29524064f, 0.34287426f, 0.08689132f, 0.44422564f, -0.10021054f, 0.06878088f, 0.35780185f, 0.08051108f, 
    -0.24775088f, 0.21353704f, 0.46467796f, 0.14407006f, -0.39597973f, -0.26666746f, 0.30899221f, 0.24875478f, 
    -0.42247760f, 0.13555034f, 0.52513027f, 0.10217950f, -0.67399681f, -0.07776341f, -0.12728760f, -0.02114189f, 
    -0.20070086f, 0.57483369f, -0.10253590f, -0.07171518f, -0.03320844f, 0.36824071f, -0.23392338f, -0.50715572f, 
    0.38373676f, -0.13749097f, -0.07087044f, 0.04086881f, -0.06060490f, 0.21650118f, 0.05527265f, 0.25310305f, 
    -0.19237825f, 0.22326982f, 0.07026929f, 0.20483522f, -0.11838539f, 0.35612506f, -0.21059914f, -0.37393090f, 
    -0.14458077f, 0.48877475f, -0.03966301f, 0.06555435f, -0.15069176f, 0.13566917f, 0.20151962f, 0.05906432f, 
    -0.12377669f, 0.18066896f, -0.73691291f, 0.17673969f, 0.08646043f, 0.22969525f, -0.17893289f, -0.38839719f, 
    0.29301354f, 0.06728150f, 0.33870173f, 0.62197202f, 0.04584566f, -0.03526726f, -0.49516070f, -0.02837560f, 
    0.06439459f, 0.46856001f, 0.07059431f, 0.00283214f, -0.21542552f, 0.25303420f, 0.06574398f, 0.02292925f, 
    -0.04588796f, 0.15704954f, 0.27938148f, -0.16217576f, -0.18133926f, -0.12298909f, -0.11324448f, 0.05496821f, 
    0.11663422f, 0.21664302f, 0.14921282f, -0.00061604f, 0.10785785f, -0.40727630f, 0.09313910f, -0.18571557f, 
    0.28915268f, -0.24268247f, 0.50387245f, -0.15965237f, 0.45644024f, -0.04205058f, -0.23888683f, -0.21262564f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00716297f, 0.21939182f, 0.02654590f, -0.11690132f, -0.18349649f, 0.16732001f, 0.03427475f, -0.12249902f, 
    0.09213264f, 0.28734285f, 0.04016119f, 0.12974298f, 0.04305688f, 0.03316561f, 0.04522545f, -0.03103489f, 
    0.45616508f, -0.02297916f, 0.23498072f, 0.13298409f, 0.04740439f, 0.10883432f, 0.01784956f, 0.38203868f, 
    0.39010322f, 0.08271835f, -0.02124396f, 0.36324948f, -0.11678351f, 0.49234447f, 0.08895414f, -0.03544646f, 
    0.04210808f, 0.01208149f, -0.07832596f, 0.22038876f, -0.23719032f, -0.00872677f, -0.30457899f, -0.05256594f, 
    -0.13128796f, -0.16777204f, -0.39206275f, -0.15854216f, 0.18577701f, 0.24714126f, -0.56486410f, -0.12606306f, 
    -0.06497110f, 0.04054980f, -0.22683850f, 0.01390342f, -0.01980304f, 0.15116169f, 0.31746778f, -0.26390097f, 
    0.33531749f, 0.36982241f, 0.27560791f, -0.12586319f, 0.67206663f, -0.08220989f, -0.16404161f, 0.08483446f, 
    -0.30710834f, 0.28278682f, 0.43708035f, 0.08325756f, 0.28530627f, -0.01109416f, 0.08233445f, -0.21803373f, 
    0.14884157f, -0.32281008f, 0.07641274f, 0.41768950f, -0.05550447f, -0.06833553f, 0.02935040f, -0.12364709f, 
    0.00515397f, -0.31587821f, -0.35409102f, 0.13717684f, -0.07764268f, 0.06307381f, -0.35358757f, 0.46025139f, 
    0.28746960f, 0.09467454f, 0.42636973f, 0.21988307f, 0.30446309f, 0.47232237f, 0.43782333f, -0.10116876f, 
    -0.08695729f, 0.39993054f, 0.47349411f, 0.30957565f, -0.27235308f, 0.72215617f, 0.21741669f, 0.12869200f, 
    0.12210298f, 0.43395472f, 0.49113992f, -0.05813408f, -0.16748232f, -0.31073698f, -0.13137801f, -0.05761866f, 
    -0.17761153f, 0.38257486f, -0.06895178f, -0.08992954f, 0.19620515f, 0.40472168f, -0.14292882f, 0.32752019f, 
    0.22142217f, -0.20708138f, -0.94122982f, 0.39682311f, 0.26109526f, -0.30692786f, 0.10234065f, 0.33368951f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04807042f, -0.00017819f, 0.06437873f, -0.45668182f, -0.09318710f, 0.29832366f, -0.20770863f, -0.05799733f, 
    -0.43027496f, -0.15741298f, -0.04045141f, 0.00615565f, -0.43269008f, -0.52531791f, -0.03873882f, 0.16438834f, 
    -0.10881282f, 0.07415860f, -0.29175675f, 0.02941070f, 0.06060025f, 0.08426158f, -0.04373811f, 0.60271090f, 
    0.02077877f, -0.41666508f, -0.12240927f, 0.23745042f, -0.11071074f, -0.05270233f, 0.07109715f, -0.22573009f, 
    0.00393626f, 0.11438076f, 0.22793402f, -0.13698904f, -0.51569808f, 0.02713532f, 0.10133436f, -0.02254171f, 
    -0.45463151f, 0.00141102f, 0.07653028f, 0.02680456f, 0.12166068f, 0.10249653f, 0.11326470f, -0.08647984f, 
    -0.45074379f, -0.73517597f, -0.52261418f, 0.31675214f, 0.03435947f, -0.54095805f, 0.30462962f, 0.03205904f, 
    -0.28016251f, 0.35193989f, -0.53667438f, -0.08026870f, -0.52700937f, 0.16396540f, 0.04825507f, 0.15542115f, 
    -0.35654154f, -0.01734100f, -0.05233422f, 0.03856576f, -0.16151680f, -0.11996016f, -0.38877061f, 0.03640190f, 
    0.10525113f, -1.29847479f, 0.06912027f, -0.18595192f, 0.11276013f, -0.23743792f, 0.13989747f, 0.05395842f, 
    0.03278599f, -0.40585521f, 0.00193324f, 0.10212941f, -0.18072161f, 0.03022740f, -0.00237459f, 0.36240828f, 
    0.18313256f, 0.21506518f, -0.28471625f, -0.52419287f, -0.04953752f, 0.46490878f, 0.01763684f, -0.45500630f, 
    0.02716409f, -0.07593893f, 0.16744980f, -0.10780826f, 0.10271861f, 0.08878390f, 0.19141877f, -0.55169338f, 
    0.05116635f, -0.03381546f, -0.01332083f, 0.26816607f, -0.05860595f, 0.12408429f, -0.50472999f, 0.22045805f, 
    0.02581829f, 0.03991752f, 0.08773346f, -0.12596205f, -0.66497332f, -0.39844280f, -0.20507677f, 0.25824323f, 
    0.21576515f, 0.09573095f, 0.48727611f, 0.11265152f, -0.00112861f, -0.26744998f, -0.28069267f, 0.07821895f, 
    -0.06336779f, 0.07274128f, 0.05047824f, -0.12352431f, -0.18045841f, -0.12984782f, 0.03450396f, -0.05982569f, 
    -0.20731732f, -0.01692058f, -0.08881693f, -0.01413781f, -0.30138415f, -0.09435653f, -0.08467387f, -0.14669688f, 
    0.28699985f, 0.04165840f, 0.03908928f, 0.18798336f, 0.16912611f, 0.22135678f, 0.03518562f, 0.36609453f, 
    -0.05769452f, -0.20712131f, -0.05216088f, 0.31594697f, -0.53864700f, -0.30174470f, -0.12122525f, -0.00811659f, 
    0.06486591f, -0.41534939f, 0.26864848f, -0.21257551f, -0.98647207f, 0.06953909f, -0.11922170f, 0.06683781f, 
    -0.33034539f, 0.01758924f, 0.13578735f, 0.04290568f, 0.16274996f, 0.10890135f, -0.18501833f, 0.05703988f, 
    -0.21513188f, -0.47984794f, 0.24717493f, -0.34543473f, -0.05004997f, 0.01423590f, -0.40759245f, -0.00236045f, 
    -0.02224492f, -0.07619091f, -0.12011862f, 0.29121906f, -0.55733740f, 0.04923814f, -0.11698835f, 0.68166095f, 
    0.33460307f, 0.12806587f, -0.11333939f, -0.04883097f, 0.04769522f, -0.20179854f, -0.07253935f, -0.24852887f, 
    0.03633367f, 0.58372855f, -0.06452329f, -0.05276396f, 0.07885524f, 0.10417853f, 0.11453694f, 0.26831609f, 
    -0.67281431f, 0.21704732f, -0.03863093f, 0.16359285f, -0.03512754f, -0.03903724f, -0.27012655f, -0.64454406f, 
    0.14721304f, 0.12924580f, -0.35194165f, -1.76300943f, 0.06413127f, -0.69119716f, 0.07732879f, 0.44547981f, 
    0.20242469f, -0.49077505f, 0.31061772f, -0.57923645f, -0.01134899f, -0.00086593f, -0.02135096f, 0.12496921f, 
    -0.07064527f, -0.02390265f, -0.13154642f, 0.28859359f, 0.19676319f, -0.48863116f, 0.49852335f, 0.04035911f, 
    -0.52177799f, 0.11582212f, 0.01172957f, 0.00469334f, 0.60244799f, 0.09072656f, 0.01701522f, 0.13070132f, 
    0.18697315f, 0.69427449f, -0.30583990f, 0.02083304f, -0.07824506f, -0.06636315f, -0.14371006f, 0.03687301f, 
    0.02283281f, 0.02771959f, 0.01608125f, 0.10638508f, -0.15954107f, 0.15302640f, -0.25435230f, -0.77637959f, 
    0.14701685f, -0.43674582f, -0.48975548f, 0.12849697f, -0.20951720f, 0.01921489f, -0.71216869f, 0.26565582f, 
    0.51704615f, 0.15088925f, -0.01191927f, 0.05897560f, 0.12227064f, -0.50337702f, 0.15809739f, -0.12741771f, 
    0.21056880f, 0.27999511f, -0.13921422f, 0.02653628f, 0.16765752f, -0.29896995f, 0.04033466f, -0.50529319f, 
    0.10457209f, 0.13653758f, 0.28881937f, 0.01081213f, -0.19703689f, 0.14855482f, -0.41125971f, -0.27642202f, 
    0.21002506f, -0.07440456f, 0.01006363f, -0.31379148f, -0.98282290f, -0.37740570f, -0.01522927f, -0.30103078f, 
    -0.00467329f, -0.62250102f, 0.23864697f, -0.14049540f, -0.17564610f, 0.13106178f, 0.04750831f, -0.03573480f, 
    0.10331251f, 0.14558068f, 0.09690557f, 0.38111961f, -0.62694323f, 0.24380401f, -0.00853259f, -0.14053725f, 
    0.53121257f, -0.58304858f, -0.35698730f, -0.38070258f, 0.09703992f, -0.08769032f, 0.14306331f, -0.11186182f, 
    0.04787940f, -0.20992170f, 0.04784428f, -0.51130408f, -0.05783634f, 0.21414308f, 0.42624739f, -0.30162087f, 
    0.25376976f, 0.10071541f, 0.26176703f, -0.58299297f, -0.45269465f, 0.05370083f, 0.11808359f, 0.22412448f, 
    0.01794058f, -0.27838549f, 0.09452835f, -0.20708597f, -0.15784392f, -0.10714769f, 0.24516670f, -0.62449163f, 
    0.00026344f, -0.97279960f, 0.17569527f, 0.26247561f, 0.01244603f, -0.50742340f, 0.08357717f, -0.32679868f, 
    0.00534180f, 0.00376902f, 0.12115204f, 0.04251690f, 0.25649300f, 0.13562541f, -0.12463295f, -0.40082207f, 
    0.07678764f, 0.06429086f, 0.11367831f, 0.08459233f, -0.78487521f, 0.48400173f, 0.33867425f, -0.14890379f, 
    -0.42526177f, -0.87260824f, -0.01997115f, -0.29585642f, 0.21471611f, 0.00577409f, 0.06245871f, -0.93133175f, 
    -0.00586967f, -0.27701643f, -0.01331105f, 0.30237594f, 0.19398297f, -0.29328471f, -0.11376502f, -0.02636881f, 
    0.27196196f, -0.13080728f, 0.13423395f, -0.39959332f, 0.34683096f, -0.09102929f, 0.00441605f, 0.08266655f, 
    -0.67366302f, -0.13962573f, -0.32515979f, 0.31585315f, 0.24244678f, 0.00991268f, -0.16793498f, -0.45724538f, 
    -0.02299167f, 0.26707751f, -0.26156607f, -0.86820567f, -0.00788228f, -0.11366646f, 0.23040627f, 0.31020987f, 
    -0.22289449f, 0.11316983f, -0.18340094f, -0.32026559f, -0.22529608f, -0.34689406f, -0.41101056f, 0.26501012f, 
    0.11729965f, 0.05919702f, 0.29923385f, -0.12020919f, -0.53673786f, 0.17440675f, -0.01070617f, 0.20334229f, 
    0.22888817f, 0.06333259f, -0.13391857f, -0.23338838f, 0.02834462f, -0.53189558f, 0.16236165f, -0.09243684f, 
    0.38667101f, -0.04178099f, 0.48606887f, 0.12923184f, -0.43052202f, -0.06264088f, -0.04694210f, -0.04100408f, 
    -0.53665221f, -0.21631852f, -0.16274387f, -0.41300836f, 0.21332887f, 0.17965730f, -0.41814268f, 0.09133240f, 
    -0.04899856f, -0.59330583f, -0.03316220f, -0.17402387f, -0.25309670f, 0.04821336f, -0.20214939f, -0.45547315f, 
    0.03952009f, 0.17259157f, 0.15315390f, 0.18485992f, 0.02898912f, -0.07870523f, -0.38483882f, -0.47090453f, 
    -0.29056925f, -0.19764645f, 0.21693110f, 0.12619568f, -0.82947260f, -0.21569641f, -0.07877684f, -0.02735646f, 
    0.31574881f, 0.05680663f, -0.15461570f, 0.00197436f, -0.68309683f, -0.00862038f, -0.48986828f, -0.68941873f, 
    -0.05339369f, -0.22576846f, -0.08339547f, -0.63741195f, -0.09590071f, -0.36615327f, 0.13996121f, -0.35644105f, 
    0.20477857f, -0.05850343f, 0.06875619f, 0.18550858f, -0.25586286f, 0.36698106f, -0.71748877f, -0.26133040f, 
    -0.56322956f, 0.27859882f, 0.39090586f, 0.17295270f, 0.18860944f, 0.30539009f, 0.12291158f, -0.59440029f, 
    0.01141427f, -0.01687502f, -0.02357732f, 0.06139848f, 0.02593534f, 0.20338735f, 0.18444592f, 0.08156293f, 
    0.23593640f, 0.13990177f, -0.03141623f, -0.37984583f, 0.01017862f, -0.18510455f, -0.02521801f, -0.14611623f, 
    -0.05411194f, 0.07659926f, -0.12576792f, -0.17280218f, -0.18035007f, 0.14274424f, 0.18913798f, -0.12782332f, 
    0.17578280f, 0.18156973f, -0.24947335f, 0.10836045f, -0.06406602f, 0.31752482f, -0.50618136f, 0.30984938f, 
    0.06352137f, 0.18357344f, -0.14812444f, 0.18404795f, 0.18217124f, -0.00227254f, 0.01895418f, 0.11176802f, 
    0.08149099f, -0.02597839f, -0.97928292f, -0.19916873f, -0.36940762f, 0.17874955f, -0.15317705f, 0.04977601f, 
    -0.41233763f, -0.15784138f, -0.23793672f, 0.03166290f, -0.06174371f, -0.11586986f, -0.15962802f, -0.00015630f, 
    0.02697697f, 0.20004293f, 0.46797732f, -0.89421946f, 0.64854431f, -0.21981901f, 0.02012076f, -0.94779891f, 
    -0.03649438f, -0.29531574f, 0.27245423f, 0.12803636f, 0.09665095f, -0.04800734f, 0.35172299f, -0.31505993f, 
    0.02240934f, 0.17858858f, 0.06384011f, 0.03883057f, -0.13921289f, -0.35158181f, -0.04862790f, 0.04731029f, 
    -0.26805729f, -0.58000249f, 0.15674478f, -0.17626974f, -0.09841508f, 0.05049492f, -0.12007666f, 0.26932165f, 
    0.12250239f, 0.22455125f, 0.07704552f, 0.14148745f, 0.25116718f, 0.62386125f, -0.08402834f, -0.49869511f, 
    0.04550850f, 0.06479073f, 0.02169542f, -0.04533923f, -0.12232348f, 0.10083620f, 0.08510032f, 0.30875415f, 
    0.01736847f, -0.00792115f, -0.00376464f, -0.53229433f, -0.17856778f, 0.27287036f, -0.28966194f, -0.06167481f, 
    -0.05392385f, -0.01480287f, 0.04541919f, -0.08070874f, -0.74824631f, -0.80311769f, -0.44171914f, 0.20547254f, 
    0.10532853f, -0.54376513f, 0.27931568f, 0.12849568f, 0.13885334f, -0.57588297f, 0.08253024f, -0.03704436f, 
    -0.01765318f, 0.06639889f, -0.08059284f, -0.07357215f, -0.42591980f, 0.02327123f, 0.16092733f, 0.12014873f, 
    0.10950372f, -0.24820194f, -0.07120833f, -0.03440931f, -0.01258661f, -0.64145637f, 0.21803895f, -0.14091298f, 
    -0.17790745f, 0.01896435f, -0.10916150f, -0.15636027f, 0.10788865f, 0.24282002f, 0.00797481f, 0.03426438f, 
    -0.43205687f, 0.00486957f, 0.05066388f, -0.11762425f, 0.02387141f, -0.21218462f, -0.30017558f, 0.08219310f, 
    0.11895206f, 0.36361676f, -0.60143930f, 0.05057793f, 0.46945524f, 0.14984888f, 0.20484741f, -0.03167620f, 
    0.15538597f, -0.01686863f, 0.13055301f, 0.20201902f, -1.11674988f, 0.11295181f, 0.33075607f, 0.21760882f, 
    -0.09091352f, 1.00992990f, 0.20438607f, -0.78664643f, -0.04853879f, 0.20170143f, -0.29035130f, 0.05000252f, 
    -0.03252031f, -0.79100198f, -0.22730505f, -0.34453136f, -0.86769718f, -0.42167643f, -0.09536581f, 0.45952240f, 
    -0.50062007f, -0.39081740f, -0.05508881f, 0.02242355f, 0.07071611f, 0.05262427f, 0.42666563f, 0.06492528f, 
    -0.32982504f, 0.20641877f, -0.05484947f, 0.23195861f, 0.11626370f, -0.17939328f, 0.00191241f, 0.05592816f, 
    -0.29492232f, 0.39262879f, -0.11831666f, -0.01036591f, 0.28101835f, 0.04812174f, -0.21666691f, -0.38559520f, 
    0.17355208f, -0.03586286f, -0.15096597f, -0.30486926f, -0.11298719f, -0.04115660f, 0.03710826f, 0.14432742f, 
    0.11331265f, 0.32590762f, -0.06795678f, 0.10736923f, 0.15519960f, 0.06568018f, -0.19663574f, -0.44146758f, 
    -0.06346016f, -0.00190107f, -0.16414741f, 0.28142372f, 0.24263971f, 0.13793972f, -0.31641868f, 0.21782275f, 
    -0.01764634f, -0.02492842f, -0.23458122f, -0.07167574f, 0.62986416f, 0.45872280f, 0.10015670f, -0.09323248f, 
    0.17713051f, 0.06745525f, -0.66704392f, -0.64900160f, -0.41109878f, 0.24035762f, -0.24173655f, 0.18472643f, 
    -0.10065290f, -0.04727851f, 0.03853136f, -0.03103515f, -0.11547411f, 0.11042450f, -0.18522501f, 0.04139514f, 
    -0.18613033f, -0.57013911f, -0.06707011f, 0.10607688f, 0.07785605f, 0.17367843f, 0.01500649f, 0.28690547f, 
    0.05380972f, -0.60794550f, 0.00117012f, 0.14859858f, 0.17533967f, 0.03105230f, 0.04191684f, -0.98891377f, 
    -0.18345721f, -0.36769959f, -0.03778313f, -0.00434828f, -0.27850774f, -0.10930275f, 0.36654341f, -0.30890873f, 
    0.18403164f, -0.01738644f, -0.32071620f, 0.19893794f, -0.81091279f, 0.14161402f, -0.76161844f, -0.28887618f, 
    -0.03903958f, 0.05563122f, 0.26920414f, -0.02351069f, 0.35756108f, -0.07168608f, -0.24206610f, 0.36884528f, 
    0.32999086f, -0.34837204f, -0.22658314f, -0.39742228f, -0.41206113f, -0.12891017f, 0.31915057f, 0.02060953f, 
    -0.03284822f, -0.97007614f, 0.03775470f, 0.23148336f, -0.18855278f, 0.10426602f, 0.37659350f, -1.56079495f, 
    -0.56810218f, 0.25329238f, 0.13187845f, -0.14127192f, 0.09021822f, 0.34076488f, -0.71738285f, 0.11713029f, 
    0.08961453f, 0.00837215f, 0.02303229f, 0.12660143f, 0.10154010f, -0.02992947f, -0.30482492f, -0.36251271f, 
    -0.99267453f, 0.07686838f, 0.05681240f, -0.43771315f, 0.07597584f, 0.03510573f, -0.17714694f, -0.08795522f, 
    0.12922582f, 0.02469993f, 0.11444811f, 0.02225562f, -0.39184552f, 0.02250993f, 0.04930237f, -0.43517077f, 
    0.11840924f, 0.38811907f, -0.05994824f, 0.07685655f, 0.21460608f, 0.19333568f, -0.06791990f, 0.34837705f, 
    -0.04799765f, 0.06975637f, 0.18090342f, -0.12031544f, -0.20941329f, -0.43367612f, -0.70588762f, -0.00672580f, 
    0.12523720f, 0.03547083f, -0.16196635f, 0.14893264f, -0.07331667f, 0.46403953f, 0.27142620f, 0.20496301f, 
    -0.07106104f, 0.20361574f, -0.90465331f, -0.02089671f, 0.12899661f, 0.29515138f, -0.17095436f, -0.73407209f, 
    0.01955787f, -0.28036797f, -0.00908041f, 0.08753861f, 0.15189251f, -0.03064697f, 0.07105595f, 0.03479539f, 
    0.03594949f, 0.10878326f, -0.07432640f, -0.03807211f, -0.45571056f, 0.13872783f, 0.01211507f, 0.07007869f, 
    -0.07636646f, 0.12762925f, -0.83421576f, 0.01283007f, -0.31910366f, -0.13916780f, 0.16732633f, 0.27918693f, 
    -0.00201634f, 0.16970247f, -0.00121938f, 0.44275394f, 0.26975265f, -0.85355181f, -0.38033235f, 0.07370220f, 
    -0.22725339f, 0.09514593f, -0.56774724f, 0.08946113f, -0.32462743f, -0.25882950f, 0.19477035f, 0.02733746f, 
    -0.08984387f, 0.01505011f, 0.30240721f, 0.15835720f, -0.33669332f, 0.01248316f, 0.15087906f, -0.23934869f, 
    0.54415786f, -0.29671663f, 0.14838064f, 0.30164269f, 0.24960935f, -0.02529072f, 0.02127076f, 0.06632372f, 
    -0.63814467f, 0.14366546f, -0.02428740f, -0.84557414f, -0.03226396f, 0.01447717f, -0.30186060f, -0.02974135f, 
    -0.00916814f, -0.08917568f, -0.56598485f, -0.21364225f, -0.12277961f, 0.04845899f, -0.15026364f, 0.15601738f, 
    -0.30405346f, 0.35592067f, 0.08010006f, -0.45693564f, -0.39132306f, 0.23431642f, 0.10990381f, -0.20527127f, 
    0.35030979f, -0.03393028f, 0.14127460f, -0.14714465f, -0.01494638f, 0.03978874f, 0.27915260f, 0.22666560f, 
    0.04353859f, 0.09474920f, -0.02340385f, 0.70339161f, -0.31807223f, 0.11012476f, -0.12103443f, 0.22877215f, 
    -0.14596638f, -0.76642889f, -0.64149553f, -0.62627608f, 0.08035377f, -0.09404820f, -0.42845443f, -1.02340090f, 
    -0.02486185f, -0.23412029f, -0.74628633f, -0.81308025f, 0.25638348f, 0.39864135f, 0.03462001f, 0.15044926f, 
    -0.26416385f, -0.34639356f, 0.12382640f, -0.50733137f, -0.26096195f, -0.83604258f, 0.44198683f, -0.17055856f, 
    -0.07893650f, -0.07207213f, 0.41467988f, 0.10083089f, -0.29070476f, 0.44592345f, -0.39219868f, -0.15996069f, 
    0.05019090f, 0.12515312f, 0.04480287f, -0.26571548f, 0.16024524f, -0.74939948f, 0.29366994f, 0.07355843f, 
    -0.20294622f, -0.50027746f, 0.04281790f, 0.24301875f, 0.03024743f, 0.02644435f, -0.21441469f, -0.24466977f, 
    -0.47712928f, -0.01489156f, -0.02387236f, -0.27546757f, 0.02948051f, -0.10161185f, -0.09018913f, -0.15644071f, 
    -0.21288471f, 0.00265898f, 0.31208366f, 0.21356277f, -0.43252501f, 0.24153693f, 0.32785195f, -0.59229851f, 
    -0.70373291f, -0.39626995f, 0.09516799f, -0.28925031f, -0.76608062f, -0.75097096f, 0.31135547f, 0.32389647f, 
    0.05892706f, 0.06602602f, -0.09625912f, 0.21538588f, 0.32723874f, -0.05148889f, -0.13410421f, -0.17482746f, 
    -0.06211195f, 0.26278055f, -0.06317614f, -0.37256485f, 0.03509966f, 0.06538030f, -0.82711810f, -0.01899221f, 
    0.17731366f, -0.33757478f, -0.54714650f, 0.32270917f, -0.29518431f, 0.06623297f, -0.21890566f, -0.61054134f, 
    0.08741125f, -0.00909266f, 0.05885029f, 0.28654060f, -0.76828456f, -0.23912482f, 0.32194394f, 0.08689484f, 
    0.18138069f, 0.17608181f, 0.02843492f, -0.50417709f, 0.01852901f, 0.43461078f, -0.41786498f, 0.36711815f, 
    -0.20708644f, -0.09171246f, 0.09946858f, 0.50741947f, 0.03801956f, 0.05366470f, 0.37713113f, -1.09677112f, 
    -0.13858970f, -0.05674642f, -0.44741532f, -0.78182614f, 0.52112651f, 0.07824353f, -0.99787432f, -0.01908687f, 
    0.01744668f, -0.11886133f, -0.03840270f, 0.06278254f, -0.24115147f, -0.67377490f, 0.00318682f, -0.49332681f, 
    -0.06576127f, 0.15638980f, 0.08440227f, -0.47200570f, -0.13468938f, 0.13730611f, -0.03205721f, 0.26385796f, 
    0.33823559f, 0.01679627f, 0.21311529f, -0.05920702f, 0.13398452f, -0.18734714f, -0.13663262f, -0.20891058f, 
    0.22922409f, -0.48329422f, -0.09884974f, -0.12685174f, -0.51246887f, 0.03262905f, -0.26062757f, 0.06223741f, 
    0.00225815f, -0.01067223f, 0.00050309f, -0.02733161f, -0.00688608f, 0.10901852f, 0.26348731f, -0.02305541f, 
    0.26871139f, 0.07949645f, -0.12042698f, 0.09639081f, 0.12815012f, -0.13471895f, -0.03296740f, -0.24325950f, 
    0.21094856f, -0.49263626f, 0.10846918f, -0.08463200f, -0.07349203f, 0.02738579f, 0.12714309f, -0.38359740f, 
    0.09051228f, -0.29527396f, -0.05230338f, 0.04915813f, 0.13839917f, 0.17141883f, 0.02468918f, -0.08182019f, 
    0.00869409f, -0.67297566f, -0.03935137f, 0.13976438f, 0.38989437f, 0.15479243f, 0.13419066f, 0.00646694f, 
    -0.14651692f, 0.02295345f, -0.65339416f, -0.03192466f, 0.06539351f, 0.10501225f, -0.07504242f, 0.06716871f, 
    -0.47701216f, -0.28881922f, 0.45626673f, -0.25138447f, -0.21137750f, -0.09377404f, -0.08718974f, -0.03861926f, 
    0.16978161f, 0.10774793f, -0.30969879f, -0.48833984f, 0.07284567f, -0.39552447f, 0.06464776f, 0.02696643f, 
    0.40070471f, 0.27686980f, 0.22978820f, 0.17793228f, -0.26647094f, -0.09906989f, -0.02662551f, -0.07692692f, 
    0.13106269f, 0.26500067f, -0.05646322f, 0.10233556f, 0.03346774f, -0.04709810f, 0.06682110f, -0.04339361f, 
    0.45665628f, -0.89650631f, -0.86238730f, -0.08236082f, -0.28556228f, 0.06588024f, 0.32939166f, 0.28862047f, 
    -0.16058314f, -0.10684501f, 0.06417383f, -0.21917942f, 0.14096829f, -0.25274616f, -0.14066041f, 0.42908281f, 
    -0.13380714f, 0.29146552f, -0.15104887f, 0.01821492f, -0.17612620f, 0.02830865f, 0.23763284f, 0.12389494f, 
    -0.00712372f, 0.03190618f, 0.08296006f, 0.17124230f, 0.12484623f, -0.02388616f, 0.29323962f, 0.16302580f, 
    0.05826326f, -0.02101211f, -0.02406788f, -0.01444394f, 0.00397108f, -0.23966102f, 0.09163789f, 0.05989779f, 
    0.01725297f, -0.30076575f, -0.74825519f, -0.09783133f, 0.04857718f, -1.05737782f, -0.13107063f, 0.47511235f, 
    -0.00427681f, 0.08005957f, -0.00354600f, 0.28117323f, 0.00148232f, -0.65824795f, 0.03978457f, -0.13165744f, 
    0.08863776f, 0.23147233f, 0.18533801f, 0.26034290f, 0.23112074f, 0.52524364f, -0.02416774f, -0.39240256f, 
    -0.77887458f, 0.06435299f, 0.33275899f, 0.09458159f, 0.02774996f, -0.14931253f, -0.33855066f, 0.13740635f, 
    0.10251963f, 0.22067951f, 0.06868378f, -0.74814528f, 0.04718107f, -0.16370875f, 0.12073403f, -0.01051825f, 
    -0.74568075f, -0.13574938f, 0.10062572f, -0.48213428f, -0.24716945f, -0.30332372f, -0.11843715f, -0.08527222f, 
    0.04167311f, 0.02345561f, 0.08493979f, -0.33499712f, 0.45229143f, 0.18434791f, -0.06566067f, -0.56153494f, 
    0.26301104f, -0.08139892f, 0.03736366f, 0.17656037f, 0.27019805f, 0.35786852f, 0.04927078f, -0.09871728f, 
    0.16234891f, 0.08847903f, -0.05336954f, -1.11496389f, 0.49914706f, -0.01851823f, -0.92309749f, -0.38606891f, 
    -0.09955358f, 0.16247217f, 0.01430657f, 0.19095875f, 0.08523225f, -0.13079779f, -0.23169193f, 0.09533634f, 
    -0.21764936f, -0.23729956f, 0.07130662f, -0.13437156f, -0.35986906f, 0.43383557f, -0.28607896f, -0.11121394f, 
    0.01710127f, 0.23678608f, -0.04263307f, 0.28906518f, -0.03265951f, -0.01194382f, 0.02548247f, 0.13420659f, 
    -0.09446149f, -0.30746225f, 0.21066561f, 0.13160259f, -0.21159513f, -0.80483693f, 0.24066675f, 0.26812440f, 
    -0.35666403f, -0.59563935f, 0.00283999f, 0.05862864f, -0.35809740f, 0.18094274f, -1.39237118f, 0.04967302f, 
    0.01148999f, 0.05947056f, 0.08794238f, -0.59541565f, 0.29942355f, -0.23631158f, 0.01403166f, -0.53343564f, 
    -0.06757060f, 0.02887588f, -0.06806593f, -0.29901099f, -0.93065804f, 0.18564637f, 0.20267078f, -0.56574446f, 
    -0.13885342f, -0.06779671f, 0.54953557f, 0.15815243f, -0.09091426f, 0.04423217f, 0.22778927f, 0.14996484f, 
    -0.04004348f, -0.33205950f, -0.05632225f, -0.26830816f, 0.20050281f, -0.45122808f, -0.71611911f, 0.13869566f, 
    -0.83451140f, -0.00724181f, 0.22975045f, 0.20574205f, 0.00864786f, -0.09822275f, 0.08225921f, 0.33538836f, 
    -0.22485268f, 0.30075017f, 0.26253635f, -0.45351154f, -0.31290862f, 0.02081560f, -0.28697345f, -0.25640181f, 
    -0.10707386f, -0.12084607f, 0.12033463f, -0.65577662f, 0.06916708f, 0.30960810f, 0.22039543f, -0.71990079f, 
    0.02628524f, 0.12873590f, 0.06222884f, -0.00340293f, -0.78495306f, 0.00641857f, -0.29647359f, -0.52565056f, 
    -0.04607240f, -0.08489642f, -0.11713283f, 0.35613748f, 0.00461085f, -0.65045691f, 0.06782599f, 0.04638419f, 
    0.54463065f, 0.35529989f, -0.76553112f, 0.01906553f, -0.13217552f, 0.12960486f, 0.05959373f, -0.08559295f, 
    -0.17232108f, -0.01588370f, -0.63041389f, 0.34878266f, 0.04604650f, 0.13101259f, 0.09276296f, 0.18920091f, 
    -0.53646964f, -0.49619356f, 0.15801243f, -0.16959360f, 0.03937636f, 0.07684898f, -0.38032106f, 0.22938816f, 
    -0.06031111f, -0.31609678f, -0.00018215f, 0.20524181f, 0.08969042f, -0.95062697f, -0.55258226f, -0.20770331f, 
    0.23565468f, 0.23878837f, 0.04186450f, -0.17776000f, 0.39067578f, 0.05859516f, 0.14775482f, 0.00793541f, 
    -0.42915133f, -0.13737504f, -0.02217702f, -0.53043193f, -0.10703211f, -0.38928306f, -0.04992626f, -0.54307544f, 
    -0.24894965f, 0.17564547f, -0.00387051f, 0.35683450f, 0.14102980f, 0.12504384f, 0.24385048f, 0.07752975f, 
    0.06154182f, 0.10650690f, 0.19304334f, -0.42093340f, -1.07973778f, 0.04511457f, -0.43918240f, 0.05439557f, 
    0.06862049f, -0.02314930f, 0.03933685f, 0.11307471f, -0.42459056f, -0.02980850f, -0.27880239f, 0.27032799f, 
    -0.03172388f, -0.01420024f, 0.15920918f, 0.31044552f, 0.02494421f, -0.10888223f, 0.14308651f, 0.13168131f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04492470f, 0.02563057f, -0.06565864f, -0.22690418f, 0.22753240f, -0.03742697f, 0.10414271f, -0.35822046f, 
    -0.30267686f, -0.01385991f, 0.24255960f, 0.11591496f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
