#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00425466f, 0.81588894f, 0.22565769f, -0.30914775f, 0.42424354f, -0.14783333f, -0.70324153f, -0.72000587f, 
    -0.25723162f, -0.02097344f, -0.03912979f, 0.25906670f, 0.08128115f, -0.03736543f, 0.39542216f, -0.12076417f, 
    0.00771128f, -0.28449437f, -0.16739985f, 0.22950055f, 0.30119613f, 0.26949048f, 0.20008934f, -0.25199482f, 
    0.09237585f, -0.33613619f, -0.59354973f, -0.55788249f, -0.67056412f, -0.30794168f, -0.35071763f, 0.51675105f, 
    0.53859961f, 0.33504608f, 0.39594865f, 0.04061043f, -0.26359212f, -0.01299006f, -0.05943970f, -0.12961839f, 
    0.18553676f, 0.41169280f, 0.28545901f, -0.12484588f, -0.30155787f, -0.06299801f, -0.17666484f, 0.15549491f, 
    0.17022778f, 0.00229558f, 0.25618663f, 0.60711575f, 0.43133122f, -0.12553291f, -0.01516160f, -0.16954240f, 
    0.24857320f, 0.42223313f, -0.26988462f, -0.55214781f, 0.04898126f, -0.09131180f, 0.03293396f, 0.32952437f, 
    0.11773971f, -0.28535008f, -0.09264559f, 0.25406638f, 0.00792539f, 0.19602436f, 0.28746530f, 0.19495286f, 
    -0.04004325f, 0.63838452f, -0.31884673f, 0.80803245f, 0.69518048f, 0.81878674f, 0.11803059f, -0.13759157f, 
    0.07905741f, 0.03544421f, 0.14368217f, 0.03449573f, 0.40588588f, 0.37774163f, 0.19781695f, -0.29728359f, 
    -0.23877345f, -0.17232798f, -0.31813562f, -0.26358566f, -0.01980013f, 0.11251000f, -0.44851756f, 0.39772895f, 
    0.17009275f, 0.12438941f, 0.15175219f, 0.14862713f, 0.42450362f, 0.54502934f, -0.26826841f, 0.79789656f, 
    0.17595834f, 0.06707451f, 0.52168524f, -0.02289673f, 0.36132538f, 0.34485376f, 0.00005956f, 0.17122866f, 
    0.18626474f, -0.34623748f, 0.29325032f, -0.13283436f, -0.08817522f, -0.04137207f, 0.00697136f, 0.52280319f, 
    0.14772134f, -0.15180995f, 0.44374630f, 0.38845521f, 0.05846883f, -0.61657554f, 0.08258452f, -0.54060316f, 
    -0.78832525f, -0.34347185f, 0.44915605f, 0.38652825f, 0.05283115f, 0.41109276f, 0.65460122f, 0.24243501f, 
    0.24344885f, 0.19784237f, -0.08940362f, -0.27460855f, 0.05910907f, 0.11048539f, 0.16178800f, 0.37411740f, 
    -0.22653171f, -0.16457728f, -0.51301473f, -0.13003978f, -0.13815005f, 0.22177702f, -0.13539350f, 0.03994607f, 
    0.02787380f, 0.31774440f, -0.33880040f, -0.30306986f, -0.05092710f, 0.10313091f, -0.26897046f, 0.55510110f, 
    -0.20689997f, -0.07594591f, 0.45127371f, -0.48139617f, -0.26112285f, -0.45304930f, -0.61034667f, -0.38673508f, 
    0.06025847f, -0.29453638f, 0.02087787f, -0.23557311f, 0.30852538f, -0.02971786f, -0.22048812f, -0.95426732f, 
    -0.53683943f, -0.46100146f, 0.30740580f, 0.80768728f, -0.67335737f, 0.48143780f, 0.18994942f, -0.09465071f, 
    -0.28995207f, -0.22064576f, 0.15263870f, 0.02862000f, 0.02763956f, -0.03487841f, 0.03504715f, -0.09417830f, 
    -0.08300324f, 0.20809102f, 0.10713156f, -0.24043474f, 0.15458775f, -0.11637185f, -0.20159279f, -0.03863786f, 
    -0.31789601f, -0.54563600f, -0.31489769f, -0.30324289f, 0.41884381f, -0.88295442f, -0.53643340f, 0.01350611f, 
    -0.73719060f, -0.43377778f, 0.24539886f, 0.32259580f, 0.11181989f, 0.10356031f, 0.11448409f, -0.18010801f, 
    0.09456512f, -0.16439606f, 0.19497649f, 0.25622612f, -0.35876125f, 0.13460673f, 0.10570882f, 0.47894639f, 
    0.42480129f, -0.15711586f, -0.99311590f, -0.31077403f, 0.43576923f, 0.04281947f, -1.00587285f, 0.58643490f, 
    0.58038998f, -0.82979739f, 0.02123873f, -0.03678951f, 0.19544187f, 0.09701976f, -0.23013544f, -0.01457066f, 
    -0.30595055f, 0.15836132f, 0.09434231f, -0.08919707f, -0.15085492f, 0.20805885f, -0.01527459f, 0.07916366f, 
    -0.10904813f, 0.06729873f, 0.42552850f, -0.46473649f, -0.49662474f, -0.92522383f, 0.56718445f, -0.00044762f, 
    0.79331106f, -0.26195884f, -0.26116273f, 0.40211940f, 0.18163213f, -0.33960888f, -0.41667688f, 0.01300068f, 
    -0.08153708f, 0.24830943f, 0.12077470f, -0.28127643f, -0.39718232f, -0.30049515f, 0.24088065f, -0.04708478f, 
    0.00623302f, 0.06954423f, 0.05964001f, 0.65849257f, -0.38844946f, -0.02189704f, 0.19281667f, 0.58024782f, 
    0.44744095f, 0.48756808f, 0.13532382f, 0.34670904f, 0.28392106f, -0.09426985f, 0.14200458f, -0.43678570f, 
    -0.05765789f, -0.28431430f, -0.06170006f, -0.29298496f, -0.24255724f, -0.30346996f, -0.35737947f, 0.05245864f, 
    0.07641542f, 0.08167204f, 0.22243159f, 0.19065838f, -0.09216075f, -0.46449697f, -0.53103292f, -0.18389626f, 
    -0.30375671f, -0.30295610f, -0.25877535f, 0.04912233f, 0.68856639f, -0.15631965f, -0.33652309f, -0.14788172f, 
    0.23132473f, -0.23238979f, -0.56061536f, 0.03406494f, 0.19173525f, -0.02070729f, 0.18458235f, 0.02870252f, 
    0.04090797f, -0.08583200f, 0.01707582f, 0.08504324f, -0.00229724f, -0.72527748f, 0.32013535f, -0.55308187f, 
    -0.31239459f, 0.18367064f, -0.88214052f, 0.36106607f, 0.38124913f, 0.18716154f, -0.47699010f, 0.25296146f, 
    -0.00670168f, 0.06936666f, -0.20198196f, 0.38587880f, 0.31087801f, 0.14598019f, 0.16006941f, 0.15590751f, 
    0.01596970f, 0.25987518f, 0.21168800f, -0.26017830f, 0.34595904f, 0.29263237f, -0.94856018f, 0.37109742f, 
    -0.26729703f, -0.61834401f, -0.37823966f, 0.53395307f, 0.27889520f, -0.61971009f, 0.26226100f, -0.27999181f, 
    -0.08050770f, -0.11305160f, 0.44502810f, 0.06152390f, -0.03773334f, -0.18284136f, -0.29620615f, 0.06557275f, 
    -0.43358010f, -0.52022010f, 0.15788694f, 0.00492248f, 0.32612050f, 0.45113650f, 0.13754408f, 1.15760791f, 
    0.25454736f, -0.04346569f, 0.42022312f, 0.34627187f, -0.37807482f, 0.23305032f, 0.24031028f, -0.04621333f, 
    -0.00337451f, -0.11131978f, -0.03265544f, -0.01894812f, -0.26000726f, 0.04426545f, 0.18246713f, 0.17472407f, 
    0.05174087f, 0.35650247f, 0.26804304f, -0.19706602f, -0.25106308f, -0.26412317f, -0.33144593f, 0.22552820f, 
    -0.61760837f, -0.29888657f, 0.85147494f, -0.51339746f, 0.35075390f, 0.56487149f, -0.31936455f, 0.63609970f, 
    0.00473299f, -0.76603115f, -0.18146090f, -0.42479363f, -0.35091102f, -0.25531328f, -0.48552915f, 0.25804380f, 
    0.21294396f, 0.01255280f, -0.01931953f, 0.01920111f, 0.02560650f, -0.00313223f, 0.04683330f, -0.09325334f, 
    0.05236050f, 0.04730590f, 0.57232744f, -0.65246630f, -0.35472798f, 0.15232232f, -0.41239101f, -1.03720832f, 
    -0.23924540f, -0.30259863f, -0.27532667f, 0.54967892f, -0.20356651f, 0.20738678f, 0.13935016f, -0.15993412f, 
    0.11965360f, 0.16545014f, -0.65965658f, 0.04467361f, -0.02138842f, -0.10507678f, 0.15579922f, 0.35106876f, 
    -0.19835597f, 0.09142923f, 0.88924855f, 0.15741025f, 0.37317571f, -0.57867742f, -0.65957755f, -0.31133729f, 
    0.46768299f, -0.33509520f, -0.36961704f, -0.53624284f, -0.18580157f, 0.31779149f, -0.35312295f, -0.07177728f, 
    -0.24976969f, -0.02149340f, 0.19313346f, -0.15678810f, 0.28782889f, 0.04962941f, -0.28511691f, -0.16455096f, 
    0.07429142f, -0.23701145f, -0.11568254f, 0.08896565f, -0.29734048f, -0.37117347f, -0.36987484f, -0.29619882f, 
    0.68569958f, 0.76286447f, -0.03401653f, 0.50668818f, 0.48768497f, 0.27016824f, -0.22215782f, -0.27107051f, 
    -0.23621270f, -0.20277300f, -0.23463275f, -0.08199818f, 0.07779723f, 0.15292931f, 0.09047588f, 0.00957488f, 
    -0.15962449f, -0.01338428f, -0.10543139f, -0.01591169f, 0.64662957f, 0.59666800f, 0.63938433f, 0.72452497f, 
    0.46774524f, -0.01969870f, -0.03375354f, -0.20727980f, -0.64634633f, 0.10098120f, 0.07963792f, -0.04096867f, 
    -0.26715252f, 0.25963709f, 0.23304290f, 0.07996973f, -0.12212315f, 0.15698633f, 0.18649127f, -0.09723162f, 
    0.35677284f, 0.08438689f, -0.11509011f, 0.24267220f, 0.32376647f, 0.30345184f, 0.61732781f, 0.52917314f, 
    0.70239121f, 0.47418356f, 0.39487955f, 0.12502028f, 0.23448056f, 0.15913577f, 0.19173488f, -0.09057940f, 
    -0.32169214f, -0.24642998f, -0.16413677f, 0.05281101f, -0.03719932f, -0.34156871f, -0.39935696f, -0.39842790f, 
    -0.03007080f, -0.52163386f, 0.03883059f, -0.06983027f, -0.16217375f, -0.18615045f, -0.22317478f, -0.20338596f, 
    0.38880464f, 0.10570560f, 0.75584066f, 0.56491572f, -0.17907599f, -0.62843436f, -0.54507917f, -0.14129612f, 
    0.16919653f, 0.44058791f, 0.52081597f, 0.23836051f, 0.01804561f, -0.54048640f, 0.23431253f, 0.02158749f, 
    -0.23068850f, -0.04007826f, -0.16378690f, -0.02777626f, -0.02603253f, -0.11416578f, 0.23080008f, -0.23823182f, 
    0.17256255f, -0.29222849f, -0.60926425f, -0.54814118f, 0.56668830f, 0.60008472f, 0.11681911f, 0.48304737f, 
    0.28151560f, -0.09770007f, -0.04428216f, -0.20624498f, -0.10256632f, -0.11742254f, 0.42122287f, -0.14954485f, 
    -0.27758348f, 0.09207534f, 0.35205522f, 0.09469377f, -0.17868073f, 0.03092596f, -0.33402750f, 0.03742290f, 
    -0.62913352f, -0.32158357f, -0.15889242f, 0.59800142f, 0.36706552f, 0.40918314f, 0.04940319f, 0.31037480f, 
    -0.33644164f, -0.18811397f, -0.06982945f, 0.11087972f, 0.28068399f, 0.13758436f, 0.34855142f, 0.11369579f, 
    -0.19860274f, -0.04563028f, 0.05696147f, 0.34982115f, 0.32501286f, 0.23986700f, -0.15369610f, 0.30520487f, 
    -0.28940782f, 0.63998163f, -0.09878290f, -0.83251137f, -0.11382581f, -0.24236484f, 0.08441415f, -0.67030168f, 
    0.31614965f, -0.29662865f, -0.27427271f, -0.33762258f, 0.01106656f, 0.24350980f, 0.28602424f, 0.12614574f, 
    0.30878654f, -0.26589093f, -0.05383582f, -0.10309113f, 0.14773087f, 0.01903421f, -0.06916241f, -0.22600368f, 
    0.33728775f, 0.05870298f, 0.67826033f, 0.68884557f, -0.91936016f, -0.69452947f, -0.72676069f, 0.51910889f, 
    -0.19941129f, -0.34929818f, -0.05218816f, -0.34588894f, 0.01640387f, 0.10123385f, 0.13050516f, 0.10109425f, 
    0.15996365f, 0.08857717f, -0.09695123f, 0.02389616f, -0.07815563f, -0.18528475f, 0.01155123f, 0.07300588f, 
    0.10277578f, -0.15994519f, 0.30902514f, -0.30260980f, -1.10173023f, 0.02191130f, -0.20967282f, -0.42683113f, 
    0.46932322f, 0.23935464f, 0.44357848f, 0.59145403f, -0.09344759f, 0.26992238f, 0.03480738f, -0.19029979f, 
    0.64647377f, 0.32461593f, 0.23130149f, -0.04151838f, 0.05674560f, -0.17547606f, 0.19899878f, 0.34287399f, 
    -0.06659038f, 0.14766857f, -0.21221115f, 0.26215667f, -0.54146886f, 0.29820153f, -0.52246076f, -0.66965330f, 
    -0.28602415f, 0.05204414f, -0.69519281f, 0.51669025f, 0.54187948f, -0.10832028f, -0.39269710f, 0.04829979f, 
    -0.52246952f, 0.09240926f, -0.18654765f, -0.20117918f, 0.46384129f, -0.28291339f, -0.12234204f, -0.16088690f, 
    0.02081379f, 0.39437354f, 0.02541474f, -0.13088059f, -0.22893748f, 0.66108537f, 0.89848340f, 0.23565325f, 
    0.79938060f, -0.29209033f, -0.17430034f, 0.36618212f, -0.53813720f, -0.13408490f, 0.61752230f, 0.51463276f, 
    0.15739933f, -0.01033861f, -0.08285361f, -0.05300786f, -0.08467635f, -0.26408419f, 0.16956477f, 0.16812122f, 
    0.09381782f, -0.35901201f, 0.39588279f, 0.20468023f, -0.05652393f, 0.17099278f, 0.22901478f, -1.15386534f, 
    0.52772439f, 0.87435591f, -0.07678338f, 0.56878626f, 0.88307506f, 0.08308104f, 0.37620315f, 0.10763509f, 
    -0.29163024f, -0.06081797f, -0.25717822f, 0.34253672f, -0.35443771f, -0.36050713f, -0.32391703f, -0.25106812f, 
    0.03811205f, -0.13340312f, 0.04663847f, -0.00172473f, -0.21363096f, -0.15191077f, -0.22721654f, -0.15947545f, 
    -0.97885716f, -0.44700485f, -0.48538041f, -0.22636147f, -0.46255663f, 0.77335244f, 0.78244585f, -0.12582071f, 
    0.42773652f, -0.13676040f, -0.13875556f, -0.03602174f, -0.16931900f, -0.22530705f, -0.26374653f, 0.28013363f, 
    -0.34083971f, 0.13319974f, -0.24282068f, 0.03427228f, 0.25760910f, -0.02522810f, 0.11104865f, 0.05458710f, 
    -0.06177771f, 0.62578100f, -0.57841849f, -0.61387217f, -0.28246883f, -0.26230836f, -0.53617060f, -0.39163858f, 
    -0.40663198f, -0.09254473f, -0.47014415f, 0.22903955f, 0.29198045f, -0.04151706f, 0.09557497f, -0.23583905f, 
    -0.15137589f, 0.26888296f, 0.15629864f, 0.08387075f, 0.25767076f, 0.05161175f, -0.06660169f, -0.08407544f, 
    -0.25190139f, -0.04672610f, -0.15228005f, 0.30010927f, 0.07841093f, 0.32588029f, -0.96618146f, 0.12298255f, 
    -0.34567940f, -0.52426159f, -0.43295595f, 0.53118318f, -0.37525031f, -0.32930782f, -0.01221094f, 0.02119021f, 
    0.48974255f, -0.26323199f, -0.46431378f, -0.22075656f, -0.21429099f, -0.20412372f, -0.17781177f, 0.21613790f, 
    -0.20779631f, -0.14015335f, -0.35762390f, 0.43812802f, 0.58609068f, -0.44219324f, 0.14809531f, -0.75062364f, 
    0.29265341f, -0.44925430f, -1.08304727f, -0.41773513f, 0.16982578f, 0.41181040f, 0.24052082f, 0.16925330f, 
    -0.28710532f, -0.00081538f, -0.08920886f, 0.14329168f, -0.00389910f, 0.31564373f, 0.08430506f, 0.20042314f, 
    0.21703891f, 0.27389908f, -0.08998487f, 0.15713735f, 0.36753690f, 0.62737423f, -0.17341267f, -0.37599328f, 
    -0.06222846f, -0.50385672f, -0.19029500f, -0.32000175f, -0.37222070f, 0.47847390f, 0.60117316f, -0.01614548f, 
    -0.11632753f, -0.03190877f, -0.30999985f, 0.18774660f, 0.24173523f, 0.06620357f, 0.42572883f, 0.05835700f, 
    0.28035015f, -0.37968358f, 0.50331962f, -0.12256264f, 0.73192763f, -0.09919027f, -0.39147082f, -0.03978994f, 
    0.66189998f, -0.20100150f, -0.59956288f, 0.04822926f, 0.34244707f, -0.08535585f, -0.49173912f, -0.47562513f, 
    0.04373416f, 0.10974224f, 0.06188854f, -0.27896070f, 0.00056342f, -0.17282243f, 0.24631837f, -0.33295199f, 
    0.64366812f, 0.51692832f, 0.20722036f, 0.21334498f, 0.24754903f, -0.43109417f, -0.46449322f, 0.50657260f, 
    -0.34545216f, -0.20554291f, -0.16194424f, 0.52964276f, -0.52321863f, -0.31725082f, -0.20871100f, -0.21508954f, 
    0.17256050f, -0.50612307f, -0.47126225f, -0.10200579f, -0.10938551f, 0.23591542f, 0.23679391f, -0.30331764f, 
    -0.25435191f, -0.16417499f, 0.15574864f, -0.29998484f, 0.17478871f, -0.11573588f, -0.27809545f, 0.13603014f, 
    0.79970258f, 0.42770454f, -1.05518949f, -0.58923757f, -0.59361106f, 0.30152053f, 0.21459740f, 0.42302626f, 
    0.01637028f, 0.34640035f, -0.10116932f, -0.03724242f, -0.37814003f, 0.25574037f, 0.21336076f, 0.20324419f, 
    0.00629035f, -0.51794237f, 0.03404528f, -0.27690190f, -0.27797201f, -0.24190463f, 0.18774287f, 0.21751064f, 
    -0.19138178f, 0.42855316f, 0.72563344f, 0.38434139f, -0.13751794f, 0.29689944f, 0.41223660f, 0.46856475f, 
    0.01919934f, 0.19693696f, -0.11547446f, -0.48732659f, -0.19593893f, -0.25790456f, 0.10488252f, 0.23685727f, 
    -0.40520129f, 0.14829950f, -0.32914114f, -0.04105225f, 0.27743796f, 0.25781831f, 0.22467719f, -0.03461573f, 
    -1.24121189f, 0.75233740f, -0.33645743f, 0.07243224f, 0.28290799f, 0.14381602f, 0.69419569f, -0.19750451f, 
    0.42299595f, 0.78146887f, -0.35266256f, 0.07068790f, -0.15148009f, -0.30213037f, 0.08664599f, -0.21625505f, 
    0.17242341f, -0.18439151f, 0.19011931f, -0.09229673f, -0.00315901f, 0.10864389f, -0.08104135f, 0.03182197f, 
    -0.20379625f, -0.12515393f, -0.83916909f, -0.65832865f, -0.30033413f, -0.25904968f, 0.52560198f, 0.28205764f, 
    -0.15598671f, -0.11851344f, 0.23813668f, -0.06965643f, -0.16201900f, 0.23720467f, 0.18747734f, -0.22980422f, 
    -0.24953461f, 0.03654402f, 0.32805040f, 0.33955994f, -0.16226934f, 0.52503133f, -0.12828746f, -0.31210238f, 
    -0.21064648f, -0.07764383f, 0.90885329f, 0.72325921f, 0.54327971f, -0.24464911f, 0.34364444f, -0.38866052f, 
    -0.22740467f, -0.19800118f, 0.27251083f, -0.36135009f, -0.23222095f, 0.25767630f, -0.25839624f, 0.47204095f, 
    -0.25224388f, 0.48522151f, 0.33234629f, -0.25799045f, -0.31693813f, -0.53253198f, -0.15946071f, 0.11443391f, 
    0.30311897f, 0.08368929f, 0.13054693f, 0.54302752f, 0.76814765f, 0.24309340f, 0.30926022f, 0.79505593f, 
    -0.15196094f, 0.42235932f, 0.43424991f, -0.26302534f, 0.24062426f, -0.27867880f, 0.03568451f, 0.11103486f, 
    -0.17944734f, 0.04882691f, 0.24335474f, -0.08986302f, 0.11426891f, 0.10796064f, -0.22685403f, 0.22919229f, 
    0.06221063f, 0.17171374f, 0.00458816f, 0.03065641f, -0.04253099f, -0.36596352f, -0.66897017f, -0.44162482f, 
    0.23406442f, -0.65090007f, -0.79676092f, -0.12985975f, -0.28576192f, 0.14154837f, -0.26120481f, -0.11224028f, 
    -0.08820104f, -0.20917690f, -0.43374950f, -0.23873489f, 0.14909902f, -0.10104933f, -0.10173158f, 0.53121793f, 
    0.21822628f, 0.03825551f, -0.10605919f, 0.11205067f, -0.21521020f, -0.55024946f, 1.08486497f, 0.12962027f, 
    -0.24824612f, -0.66376537f, 0.05820895f, 0.33099392f, -0.43030798f, -0.13593373f, -0.31740052f, 0.05201634f, 
    0.10800425f, -0.22808932f, 0.29668835f, -0.19174680f, 0.06548783f, -0.18971801f, 0.11706392f, 0.11381159f, 
    -0.32510269f, -0.12265615f, -0.39417633f, -0.43034744f, -0.07214560f, 0.24918853f, -0.29968253f, 0.90251523f, 
    -0.05172379f, -0.67012262f, 0.63061678f, -0.70215112f, 0.85374790f, 0.62245989f, -0.48573741f, 0.47851780f, 
    -0.33490884f, 0.06624559f, 0.06955928f, -0.63938373f, 0.07738873f, 0.21573910f, -0.31935716f, -0.17012788f, 
    -0.03929732f, -0.39914635f, 0.00589554f, 0.06711201f, 0.00908553f, -0.14887550f, -0.16689584f, 0.99358386f, 
    -1.24403620f, 0.10926750f, 1.08133459f, 0.44266394f, -0.56927156f, 0.26998755f, 0.32975349f, -0.11190747f, 
    0.26988572f, -0.08175872f, 0.06786916f, -0.02605447f, 0.07805208f, 0.28278512f, -0.11093836f, 0.34739846f, 
    0.27413115f, 0.14794396f, 0.03289314f, 0.08506111f, 0.12432773f, -0.21509266f, 0.05128369f, 0.02930722f, 
    -0.62426519f, 0.60255945f, 0.25309914f, -0.16291448f, 0.52166432f, -0.61310142f, 0.76739365f, -0.27397197f, 
    -0.42623332f, 0.14965396f, -0.13620426f, 0.20445672f, 0.45623323f, 0.06583020f, 0.43878862f, 0.40283674f, 
    0.12282985f, 0.41861010f, 0.15189064f, -0.31539893f, -0.05705497f, -0.13802393f, 0.18230002f, 0.22188272f, 
    0.06226215f, -0.38978755f, -0.72109622f, -0.14620145f, 0.00353358f, -0.48796403f, -0.07206308f, 0.81349438f, 
    -0.23042892f, 0.43984517f, 0.36231819f, 0.36373869f, -0.06341475f, -0.28180319f, 0.00688087f, 0.22542255f, 
    0.02591279f, 0.02153410f, -0.09323255f, 0.06048595f, 0.15687840f, 0.19445089f, 0.35804576f, -0.08759768f, 
    0.26577121f, 0.15297824f, -0.94890898f, -0.28118500f, 0.23254693f, 0.26343888f, -0.28470957f, 0.81183195f, 
    0.91547114f, 0.18226148f, -0.15518454f, 0.40140072f, -0.44279191f, -0.21398504f, 0.01904047f, -0.03996164f, 
    -0.05769540f, -0.25343499f, 0.17576014f, -0.25746706f, -0.05705844f, -0.07920196f, 0.02321131f, 0.02687629f, 
    0.19674487f, 0.01728757f, -0.08051039f, 0.09827525f, -0.10953034f, 0.83369178f, -0.67121941f, 0.00733711f, 
    0.77109140f, 0.20433588f, -0.16313827f, -0.31453407f, -0.49591309f, 0.02883066f, 0.41219446f, 0.32068324f, 
    0.29882929f, -0.10105939f, 0.14998007f, -0.30275446f, 0.11478156f, -0.43916866f, 0.00217472f, -0.20816162f, 
    -0.14395300f, 0.23236161f, -0.09314611f, -0.11368592f, -0.43504143f, 0.65055531f, -0.24716572f, -0.52751362f, 
    0.56255883f, 0.39450711f, -0.28075457f, -0.75280023f, 0.26583105f, -0.41468945f, -0.29522085f, -0.28031349f, 
    -0.32701546f, 0.31022105f, -0.31218377f, 0.00285741f, 0.08164237f, 0.02983883f, -0.26082641f, 0.04874141f, 
    -0.15768680f, 0.19028994f, -0.03531824f, -0.00160992f, -0.48160225f, 0.40665627f, 0.36283660f, 0.86585522f, 
    -0.31685802f, 0.76024699f, -0.05200766f, -0.06723976f, -0.39159417f, 0.22265440f, -0.13698474f, 0.49687824f, 
    0.25838572f, -0.06164700f, 0.06054518f, -0.14146355f, 0.38566127f, 0.13077785f, -0.12564513f, 0.04147362f, 
    0.15873986f, 0.28678817f, -0.32470700f, -0.11544900f, -0.14194125f, 0.11130420f, -0.24559507f, 0.40478560f, 
    0.68669987f, 0.36332130f, 0.53452742f, -0.41277087f, -0.32913789f, -0.47761980f, -0.00900983f, -0.35723594f, 
    0.24990584f, -0.30802464f, 0.07474294f, 0.16028580f, 0.32514551f, 0.43812391f, 0.21020770f, -0.10928382f, 
    0.45891249f, 0.18908319f, -0.28120369f, -0.41583568f, -0.35686561f, 0.00514667f, -0.43771932f, 0.53987825f, 
    -0.03091038f, -0.52995044f, -0.10826974f, -0.31747824f, 0.43119285f, 0.78861624f, -0.18148002f, 0.22630467f, 
    0.75009328f, -0.16916434f, 0.18333943f, -0.40151629f, 0.28555357f, -0.18116789f, 0.11201025f, 0.20694144f, 
    0.08305490f, -0.02358915f, -0.12186392f, -0.16433121f, 0.34471875f, -0.35522538f, 0.02430755f, 0.02223383f, 
    1.18370569f, -0.00207842f, 0.10847773f, 0.41868535f, 0.51062554f, 0.15998986f, 0.41304860f, -0.40959319f, 
    -0.36962867f, -0.12290100f, -0.32229963f, 0.24030375f, 0.07859617f, 0.24820179f, 0.41314310f, -0.02333163f, 
    -0.11871164f, -0.07005435f, 0.19310385f, 0.23349093f, -0.20951344f, 0.21420765f, 0.32997429f, 0.12843694f, 
    -0.25299957f, -0.48763096f, -0.28397623f, -0.40737355f, -0.46117166f, -0.59120548f, 0.04459631f, 0.38646698f, 
    0.29984441f, 0.51988137f, 0.20346659f, -0.28200933f, -0.40489012f, 0.12593824f, -0.28816071f, 0.06034907f, 
    0.09748007f, -0.11706038f, 0.11061832f, -0.04728297f, -0.02934084f, -0.22008431f, -0.43921500f, -0.15270637f, 
    -0.28134871f, 0.21138236f, -0.17196822f, -0.06750075f, 0.27565166f, 0.75741631f, 0.85626751f, 0.82396734f, 
    0.36160436f, -0.05120077f, -0.14448602f, 0.08093735f, 0.02279998f, 0.22835769f, -0.30389261f, 0.46422324f, 
    0.20529327f, 0.32239661f, -0.18610819f, -0.01458575f, -0.04905178f, 0.25780138f, -0.08316731f, -0.17972918f, 
    -0.22164808f, -0.07516629f, -0.09037735f, -0.08838553f, 0.56685853f, 0.56487429f, 0.55181777f, -0.43808085f, 
    -0.75924885f, -0.49393660f, -0.37797675f, -0.47881827f, -0.13268109f, 0.38600436f, 0.05526541f, -0.15801238f, 
    0.07235945f, 0.04238618f, -0.17096533f, -0.21090779f, 0.15455200f, -0.17287762f, -0.07222683f, 0.00431834f, 
    0.14486939f, 0.23473069f, 0.16362682f, 0.11188340f, 0.68693048f, 0.47068641f, 0.69007510f, 0.83143097f, 
    0.60759813f, -0.45955831f, -0.28602809f, -0.30299833f, -0.36707911f, 0.19859311f, 0.64156604f, 0.05787101f, 
    0.07643912f, 0.16268100f, -0.43807063f, -0.30087575f, -0.10954152f, 0.03394800f, 0.28325158f, -0.33669260f, 
    0.07763420f, 0.17713612f, -0.00852544f, -0.05072221f, 0.11351410f, 0.11432240f, 0.60583580f, -0.57811421f, 
    -0.82884240f, 0.19842184f, 0.02792046f, -0.15162463f, -0.22348346f, -0.16946523f, -0.21807975f, 0.00347498f, 
    -0.21310480f, -0.12143904f, 0.24565864f, -0.45215985f, -0.05248627f, 0.21333840f, -0.18779601f, 0.12266044f, 
    0.40930641f, -0.24532111f, -0.35455742f, -0.39305526f, -0.29091516f, 0.44725171f, -0.35602966f, 0.23092188f, 
    0.49778521f, -0.45014119f, -0.46001959f, 0.63497150f, -0.10637233f, -0.11468259f, 0.40103301f, 0.89063716f, 
    0.54724431f, 0.10395958f, 0.09908886f, 0.16590650f, -0.10277041f, -0.22113602f, 0.20259611f, 0.15441240f, 
    -0.52710146f, 0.43649730f, -0.31022969f, -0.01382694f, 0.14899729f, 0.25054941f, -0.09449954f, 0.05192002f, 
    0.29877856f, 0.39478758f, 0.76319164f, -0.89448291f, -0.54304922f, 0.41209394f, -0.13035129f, 0.01723324f, 
    0.04474207f, -0.00113629f, 0.17315148f, 0.19073698f, 0.00534616f, 0.30056494f, -0.20887235f, 0.03764473f, 
    -0.29195669f, 0.50871873f, 0.40822789f, 0.08456263f, 0.00657547f, 0.05358725f, 0.25779194f, 0.04582549f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09292538f, 0.04333229f, 0.09742166f, 0.26197043f, 0.07808258f, 0.18528026f, 0.14326587f, 0.18571246f, 
    0.26530674f, 0.24051234f, 0.06511205f, 0.20816095f, -0.00361364f, 0.37705621f, 0.08638692f, 0.07451198f, 
    -0.05957781f, 0.19999570f, 0.21519034f, 0.14382806f, 0.14263086f, 0.19676916f, 0.13728806f, 0.18394709f, 
    0.27116525f, 0.13024923f, 0.05785448f, 0.16291535f, 0.00486858f, 0.12044369f, 0.28330863f, 0.06089494f, 
    0.25704741f, 0.06450086f, 0.35193470f, 0.23263220f, 0.29466087f, -0.16914773f, 0.37222201f, -0.01138661f, 
    0.03607551f, 0.15444334f, 0.05049398f, 0.29204547f, 0.05434255f, 0.10286718f, 0.24468356f, 0.10475559f, 
    0.07150043f, 0.23461807f, -0.10351150f, 0.26849976f, 0.10894457f, 0.21467765f, 0.22350140f, 0.31259146f, 
    0.24504237f, 0.03930032f, 0.07706870f, 0.08418515f, 0.03651912f, 0.05974927f, -0.09162466f, 0.03533103f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01631032f, 0.00036083f, -0.01913627f, 0.01026863f, 0.00920125f, -0.01847008f, -0.00186518f, -0.01830594f, 
    0.01790363f, -0.02849467f, 0.00293201f, -0.01361913f, -0.03830903f, 0.00379275f, -0.03182118f, 0.01435526f, 
    0.01083669f, 0.00940349f, 0.01018787f, -0.01239371f, 0.01594653f, -0.03595694f, -0.02425795f, -0.01128775f, 
    -0.00778650f, 0.00577242f, -0.01306456f, -0.02055896f, 0.01341210f, 0.02298797f, 0.01511603f, 0.02913385f, 
    -0.00609085f, -0.01398500f, -0.01648728f, 0.02064903f, 0.00653299f, -0.00194169f, -0.03911471f, 0.02228187f, 
    0.01099514f, 0.02888698f, -0.00974972f, 0.01413256f, 0.01477788f, -0.03816425f, 0.01769348f, -0.04040935f, 
    -0.00116683f, -0.03293620f, -0.02069374f, -0.02048414f, -0.04111253f, -0.01729697f, -0.03102188f, -0.01496958f, 
    -0.02282760f, -0.01241312f, -0.00519633f, 0.02709233f, 0.01148501f, 0.00009438f, 0.02728014f, -0.00948185f, 
    0.02391883f, 0.01289294f, -0.03816109f, -0.02299154f, -0.01232053f, 0.02216990f, -0.02707351f, 0.02770029f, 
    0.02570255f, -0.00471481f, 0.01168825f, -0.01415200f, 0.02908049f, 0.00951279f, 0.00871495f, -0.02209007f, 
    -0.00013092f, 0.02363056f, -0.01898353f, -0.00455543f, 0.02977279f, 0.01146383f, 0.01420872f, -0.03467909f, 
    -0.00836960f, 0.01006786f, -0.00273801f, -0.00055908f, -0.03397320f, 0.01749266f, -0.01661023f, -0.02817172f, 
    -0.01401331f, 0.00627984f, 0.00240577f, -0.03409336f, -0.00332244f, -0.00619426f, 0.03042304f, -0.01815927f, 
    -0.01657449f, 0.02369351f, -0.00049121f, -0.02938627f, -0.03960364f, -0.02873289f, -0.02802230f, -0.01386794f, 
    0.00882246f, 0.02551070f, -0.02191654f, 0.01104598f, -0.00719154f, -0.00497621f, 0.01976589f, 0.01251511f, 
    0.00944714f, 0.02722058f, -0.00221075f, -0.01844982f, -0.00362787f, 0.02763588f, 0.01087254f, 0.01704816f, 
    -0.03654958f, -0.01325058f, -0.01490783f, 0.01709909f, 0.02116576f, -0.01512639f, 0.01916809f, 0.01458287f, 
    -0.01073407f, 0.01241245f, 0.00202156f, -0.02523334f, -0.02554701f, -0.03643980f, -0.03535378f, -0.00980532f, 
    -0.03395458f, -0.01208367f, 0.00810114f, -0.00560601f, -0.03749039f, 0.00328117f, -0.03389782f, 0.01638450f, 
    -0.02731381f, 0.00555513f, -0.02896550f, -0.01318431f, -0.01935683f, 0.01939802f, -0.03008342f, -0.02205324f, 
    -0.00013783f, 0.02068178f, -0.00694220f, -0.03307279f, 0.00776171f, 0.02732006f, -0.01000069f, -0.03092293f, 
    -0.00580006f, -0.03959299f, -0.01758562f, 0.02826299f, -0.03644584f, -0.02352135f, -0.02963977f, -0.02859502f, 
    0.02723528f, -0.00711924f, -0.04072280f, 0.00336113f, 0.02625856f, -0.01943026f, -0.01648630f, 0.00688389f, 
    0.02271538f, -0.03195133f, -0.02746934f, 0.02707403f, -0.03441048f, 0.04031387f, -0.03354706f, -0.02612216f, 
    -0.01206798f, -0.02818871f, -0.02654747f, -0.00386692f, 0.00687869f, -0.01610945f, -0.04014459f, 0.00939480f, 
    -0.02742080f, 0.00609919f, 0.02322354f, 0.00779289f, 0.02668471f, -0.02503410f, -0.04079109f, -0.02900642f, 
    -0.01053942f, 0.01579504f, -0.00601456f, -0.02389054f, 0.02149055f, 0.00081212f, -0.02748578f, -0.02390887f, 
    0.02372760f, -0.01940173f, -0.03794273f, 0.00346143f, 0.00068930f, -0.03380711f, 0.01369117f, -0.01865296f, 
    -0.01451888f, -0.01666513f, -0.04151482f, 0.02910099f, -0.02178474f, 0.02573080f, 0.02484674f, 0.01304832f, 
    0.01471493f, -0.03593490f, 0.00286447f, -0.01335250f, 0.00176907f, -0.02846485f, -0.02213293f, -0.03866912f, 
    -0.00658594f, -0.03449570f, -0.03029627f, -0.01132739f, -0.00031805f, -0.02110365f, -0.00191988f, -0.04170934f, 
    0.01570724f, -0.00790495f, -0.00551114f, -0.02694665f, -0.01017744f, 0.01723277f, 0.02598600f, 0.02795538f, 
    0.00803062f, 0.00616109f, -0.01536933f, 0.02128227f, 0.00293675f, 0.02648470f, 0.00396492f, -0.00126915f, 
    0.01804987f, -0.00064873f, -0.01690376f, 0.02752358f, -0.01102699f, 0.01830078f, -0.01070680f, -0.04132332f, 
    0.00240753f, 0.01585704f, -0.00281180f, -0.03022678f, 0.00969864f, 0.02425067f, -0.01568533f, 0.00450487f, 
    0.01923319f, -0.01671890f, -0.01013767f, -0.03247835f, 0.00718651f, 0.01664306f, -0.03521589f, -0.01071644f, 
    0.02872166f, -0.00931536f, 0.01177212f, -0.03329967f, -0.02502604f, -0.03748717f, -0.02112972f, 0.02230187f, 
    -0.03594430f, 0.01252384f, -0.01653146f, -0.01683699f, 0.00038673f, -0.00412958f, -0.00743196f, -0.00491824f, 
    0.02985876f, 0.02706799f, 0.02778331f, 0.01048569f, 0.02146338f, -0.02119160f, -0.01759761f, -0.03119098f, 
    -0.00661735f, -0.01753693f, 0.00495926f, -0.03597763f, -0.02491299f, -0.02041345f, -0.04014849f, 0.01364564f, 
    0.01189692f, -0.01753127f, -0.01954992f, 0.00735321f, -0.04120217f, -0.02710793f, -0.00826359f, -0.03072432f, 
    -0.03412006f, -0.03423810f, -0.03030693f, -0.03660667f, -0.00651541f, 0.00902696f, 0.00549421f, -0.01470720f, 
    -0.02916247f, 0.01341467f, 0.01446856f, -0.01991295f, 0.01024446f, 0.02539024f, 0.00078140f, -0.02569670f, 
    0.04197416f, -0.02939892f, 0.00241582f, -0.00742282f, 0.01053372f, 0.01743924f, 0.03574290f, 0.01943978f, 
    -0.00828242f, -0.00177251f, 0.00802777f, 0.00710387f, -0.01997295f, 0.01127293f, -0.02926205f, -0.03852565f, 
    -0.00566476f, -0.00075450f, -0.01995407f, 0.01369787f, -0.02426454f, 0.02650839f, 0.01975635f, -0.02698640f, 
    0.01459037f, 0.00998732f, -0.01858884f, 0.01083742f, 0.01954793f, -0.01622862f, 0.00266680f, -0.00726486f, 
    -0.02744503f, -0.00760000f, 0.01791795f, -0.03392017f, 0.03693077f, -0.01790570f, -0.02027844f, -0.02069442f, 
    0.02770462f, 0.01746998f, -0.03461522f, 0.00934190f, -0.00595219f, -0.00716136f, -0.01822150f, -0.03126706f, 
    0.02432935f, -0.00922853f, 0.02271180f, 0.02695324f, 0.01553490f, 0.00112791f, -0.01196217f, -0.03396429f, 
    0.01320595f, 0.03721493f, -0.00319669f, -0.02167787f, -0.03128221f, 0.02076138f, -0.03078199f, -0.02517019f, 
    0.00241448f, 0.01175523f, -0.02579570f, -0.01651271f, -0.02360538f, 0.01664321f, -0.02365682f, 0.02631498f, 
    0.00545922f, 0.02348620f, 0.02478451f, 0.01371966f, -0.02166951f, 0.01238425f, 0.00844842f, 0.00897733f, 
    -0.00418267f, -0.01133379f, 0.01099426f, -0.00962735f, 0.01263085f, 0.00325728f, 0.01061035f, -0.02984511f, 
    -0.02649276f, -0.02248908f, 0.01749126f, 0.02971141f, -0.02671072f, 0.00991691f, -0.02908767f, 0.00614421f, 
    -0.03114879f, 0.00599823f, -0.02969193f, -0.02832159f, -0.02113348f, 0.00062307f, 0.00108479f, -0.03008931f, 
    -0.01346816f, 0.02174705f, -0.01549128f, -0.00054868f, -0.00837423f, 0.01386775f, -0.03076151f, 0.01971252f, 
    0.01373167f, -0.02235938f, -0.02641276f, -0.01878276f, -0.02007258f, -0.00392706f, 0.00198302f, 0.00326117f, 
    0.00133657f, -0.00795123f, -0.03005987f, 0.01761172f, 0.02637904f, -0.02871327f, 0.02005393f, -0.00710087f, 
    -0.00123709f, 0.02585865f, 0.02277398f, -0.03258271f, -0.02960773f, 0.01061456f, 0.01343935f, 0.01068878f, 
    -0.01184370f, 0.00484401f, -0.01114027f, 0.03835387f, -0.02873127f, -0.00193752f, -0.00914703f, -0.02627434f, 
    -0.02633183f, -0.00897376f, 0.02828363f, 0.02776680f, -0.00592538f, -0.03275097f, -0.03298292f, -0.03282118f, 
    -0.00987268f, -0.00402138f, -0.00797115f, -0.00399415f, -0.03071438f, 0.00536590f, 0.01942469f, -0.03204944f, 
    -0.00463883f, -0.01483987f, 0.01767941f, 0.03835657f, 0.01690949f, 0.01303928f, -0.01803691f, -0.00029285f, 
    -0.03505105f, 0.00886559f, 0.00216291f, 0.04013553f, -0.02476079f, -0.02111739f, 0.01532449f, -0.01345781f, 
    -0.03125902f, -0.02707337f, -0.00276932f, -0.00765754f, 0.01792660f, 0.01896056f, -0.02526210f, 0.02506637f, 
    -0.00181114f, 0.02464700f, 0.01224682f, 0.01988605f, -0.02429051f, -0.02108681f, -0.01529122f, 0.00424674f, 
    -0.00469508f, -0.01409733f, -0.01796903f, -0.01245534f, -0.02148705f, -0.02397188f, -0.00368344f, -0.00776608f, 
    -0.00688605f, 0.01052666f, 0.01253716f, -0.04134712f, -0.03562514f, -0.02563572f, 0.02696946f, -0.03563767f, 
    -0.03073062f, -0.00702045f, -0.04165924f, 0.02420025f, 0.02602860f, -0.00766229f, -0.01151598f, -0.00718000f, 
    -0.01076455f, -0.00822519f, 0.02232256f, -0.03305192f, 0.00754342f, 0.00826651f, 0.02583802f, -0.02115418f, 
    0.00679624f, -0.00251478f, -0.01368927f, 0.02011421f, 0.00505199f, 0.01129361f, 0.00542187f, -0.03515706f, 
    0.01946649f, -0.00299841f, 0.00683815f, -0.00052945f, 0.01953396f, 0.02486004f, -0.00399426f, 0.02875073f, 
    -0.02503756f, -0.01123054f, -0.02033107f, -0.02657830f, -0.01263221f, -0.00012701f, -0.03340079f, 0.02576731f, 
    -0.02441687f, -0.01306351f, -0.01412856f, -0.00001694f, 0.00321864f, -0.04096062f, 0.02878249f, -0.01650625f, 
    0.02763613f, -0.02734239f, -0.02389374f, -0.01714426f, -0.04098037f, 0.01186091f, 0.01512325f, 0.00228734f, 
    -0.03997921f, 0.01902172f, 0.01381331f, -0.00151696f, -0.01341467f, -0.02804747f, -0.00954701f, 0.02228675f, 
    -0.03748921f, 0.02440361f, -0.03454040f, -0.02432467f, -0.01422781f, -0.03691557f, -0.02356452f, 0.02469018f, 
    -0.00602403f, -0.02341806f, -0.01058144f, -0.03689295f, 0.01160148f, -0.03162911f, -0.03107179f, 0.00244646f, 
    0.02802463f, 0.02369534f, -0.03681722f, -0.03458085f, -0.00497219f, -0.03886874f, -0.04168573f, 0.00400520f, 
    -0.02503707f, 0.01777283f, 0.02261592f, 0.00172912f, -0.03048898f, -0.00899195f, -0.00761743f, -0.02779399f, 
    -0.02239641f, 0.00880188f, -0.01314048f, 0.02457549f, 0.00312887f, 0.01372547f, -0.01058589f, -0.02279312f, 
    0.02663922f, -0.01104662f, 0.00461387f, 0.02907417f, -0.01230062f, -0.01158639f, 0.02593847f, -0.02261131f, 
    -0.00284370f, -0.04117154f, 0.01402396f, 0.00644872f, -0.01952797f, -0.02106408f, 0.00082433f, 0.02059079f, 
    0.01521016f, 0.00252855f, -0.00241544f, -0.03264295f, 0.02586277f, -0.03495730f, 0.02411319f, 0.01577195f, 
    -0.02111495f, 0.00711920f, -0.04186385f, 0.01877317f, 0.00877543f, 0.02734213f, -0.01205779f, 0.01114013f, 
    -0.03036219f, -0.01228016f, -0.03910114f, 0.01876859f, -0.01655293f, 0.02486674f, -0.00002968f, -0.01311975f, 
    -0.00648267f, 0.02273968f, 0.03973166f, 0.00842048f, -0.01562583f, 0.00823873f, -0.03294239f, 0.00714057f, 
    -0.03465559f, 0.02813144f, -0.00058629f, -0.00360027f, -0.01106243f, 0.02083072f, 0.03520631f, 0.00484694f, 
    0.02881752f, -0.00640557f, -0.01396214f, -0.00904317f, 0.00641392f, 0.00668472f, 0.01042631f, 0.00614678f, 
    -0.03206291f, -0.02870549f, -0.02442133f, -0.04159268f, -0.02557607f, 0.02863825f, -0.03577210f, 0.00519227f, 
    -0.00334899f, -0.02437645f, 0.02283550f, -0.00959741f, 0.02428525f, 0.00718443f, 0.00821435f, -0.01043296f, 
    -0.00137438f, -0.03743248f, -0.01126647f, 0.00403701f, 0.02338937f, -0.00174496f, -0.03566306f, 0.02412331f, 
    0.01929425f, 0.01889976f, 0.01233830f, -0.03542701f, -0.02010821f, 0.00999088f, 0.01729928f, -0.03151413f, 
    0.00402299f, 0.00676237f, 0.03085697f, 0.02309009f, 0.00933583f, 0.00834594f, -0.01737890f, -0.01753465f, 
    -0.03455670f, 0.02219884f, -0.01933899f, 0.00714561f, -0.00678559f, -0.01788930f, 0.01301224f, -0.00449583f, 
    0.01200175f, -0.01409611f, 0.00205291f, 0.02495279f, -0.01323094f, 0.02772799f, 0.01814066f, 0.02950736f, 
    -0.01161720f, 0.00375694f, 0.00240035f, -0.00238720f, -0.00108485f, -0.02609994f, -0.03206462f, -0.01287903f, 
    0.02759450f, -0.00005817f, -0.03948211f, -0.02011874f, -0.00476910f, -0.02332850f, -0.03259601f, -0.00443679f, 
    -0.00408224f, -0.01214849f, 0.01743211f, -0.00537649f, 0.01912472f, -0.00953523f, 0.02776456f, 0.01207280f, 
    0.01793878f, -0.01787242f, -0.00808382f, -0.04034343f, -0.03484352f, -0.00992952f, -0.04077052f, 0.00800503f, 
    -0.00049404f, -0.02068218f, -0.01113992f, -0.00160813f, 0.01496301f, 0.02250417f, 0.00039020f, 0.02760695f, 
    0.01125334f, -0.03077720f, 0.01403884f, -0.03596482f, -0.04201057f, 0.01755865f, 0.01434023f, 0.01653882f, 
    0.02266564f, 0.00016106f, -0.00930876f, -0.03614321f, 0.00224628f, 0.02448046f, -0.02700281f, -0.01192900f, 
    0.02671053f, -0.00219387f, 0.02683917f, -0.02697192f, -0.02830804f, 0.02551134f, -0.03840757f, -0.01491570f, 
    -0.03505032f, 0.02639681f, -0.03905265f, 0.02239662f, -0.01542099f, 0.02783858f, -0.01236954f, -0.00986001f, 
    -0.01407852f, 0.02823261f, -0.02809484f, -0.02284714f, 0.00288940f, 0.00511155f, -0.02973171f, -0.01442380f, 
    -0.01180079f, -0.03446574f, 0.00826525f, -0.01726127f, 0.02828611f, -0.03086412f, -0.00771958f, -0.00507580f, 
    -0.01668125f, -0.01189600f, 0.02043780f, 0.00306788f, -0.03961321f, -0.01763858f, 0.00795999f, 0.02293069f, 
    -0.03433123f, 0.00409098f, -0.03116335f, 0.00618555f, 0.00019887f, 0.00509109f, 0.02832473f, -0.03501495f, 
    -0.02016405f, -0.00201272f, -0.03637528f, -0.03899861f, -0.00207879f, -0.03831463f, 0.02845650f, 0.01487644f, 
    -0.02320068f, -0.02417386f, -0.02809745f, -0.03833421f, -0.01717521f, 0.01355424f, 0.00018790f, 0.02913484f, 
    -0.00585633f, -0.02018387f, 0.02779964f, -0.04134157f, -0.04166868f, -0.03813284f, -0.01190524f, 0.00906143f, 
    -0.02176385f, -0.03472125f, 0.00189684f, -0.03373300f, -0.02892761f, -0.01932601f, -0.02812161f, -0.01196751f, 
    -0.01235456f, 0.00157952f, -0.00991881f, -0.00460185f, -0.01901855f, -0.00187208f, -0.04189746f, 0.01542599f, 
    0.01153506f, -0.01489657f, 0.01748383f, -0.02816805f, 0.00095700f, 0.00927100f, -0.01492887f, -0.00345557f, 
    0.02797017f, -0.03639821f, 0.00447845f, -0.01747510f, -0.01466172f, -0.00538198f, -0.00170307f, 0.02479295f, 
    0.00563573f, 0.00591875f, -0.02737626f, -0.02033132f, -0.04082976f, 0.01255205f, -0.04126212f, -0.02643526f, 
    -0.01557438f, 0.01704478f, -0.02594525f, -0.02748712f, -0.03909932f, 0.00868376f, 0.01916069f, -0.00883521f, 
    0.02889632f, -0.01953663f, 0.02674474f, 0.01876511f, 0.01300910f, -0.01958326f, -0.02749107f, -0.02622711f, 
    -0.04162905f, 0.00229740f, -0.00398889f, -0.01757851f, -0.03255520f, 0.01717716f, 0.02218387f, 0.02556342f, 
    0.02829321f, -0.01668741f, 0.00345412f, 0.02391353f, 0.01990976f, 0.02990548f, -0.03143286f, -0.01527749f, 
    -0.01461099f, 0.01147007f, -0.03635334f, -0.03921526f, 0.00275791f, -0.02892912f, -0.02057503f, 0.01520683f, 
    -0.01716289f, 0.00505551f, -0.01552837f, -0.02325579f, 0.01181341f, 0.02696347f, -0.01144473f, -0.03173109f, 
    -0.00153986f, 0.01384873f, -0.03946772f, -0.03473781f, -0.03316372f, 0.02439173f, -0.03630268f, -0.02630276f, 
    0.02654133f, -0.01144115f, 0.02205281f, 0.00934018f, 0.02526485f, 0.02050040f, -0.03489737f, -0.03919475f, 
    0.01083937f, -0.03086323f, 0.01404026f, -0.03376656f, -0.03428057f, 0.02293352f, 0.02259121f, -0.03258463f, 
    0.00509731f, -0.00088240f, 0.02232802f, -0.01953582f, -0.01793268f, 0.02168277f, -0.01452868f, -0.00310242f, 
    -0.00575838f, 0.02491919f, -0.02097600f, -0.04188033f, -0.02268085f, 0.02958306f, -0.00239224f, -0.04114991f, 
    -0.03843167f, -0.03206226f, 0.00149406f, 0.01122978f, -0.02025337f, -0.00333928f, -0.03619020f, -0.00060040f, 
    0.00238691f, 0.00541569f, 0.01395962f, -0.03566694f, -0.00521792f, -0.01424350f, -0.00717106f, -0.03880677f, 
    0.01006438f, 0.01421370f, 0.01911630f, -0.03879157f, -0.00646843f, -0.03406798f, 0.02047435f, -0.03817707f, 
    0.01565609f, 0.01124061f, 0.01374015f, -0.02359710f, -0.01369026f, -0.00419640f, -0.01277152f, -0.01515327f, 
    0.02428088f, -0.00540045f, 0.00425128f, 0.00957696f, -0.02357418f, 0.00473682f, 0.02876643f, -0.00212653f, 
    -0.03544038f, -0.00085529f, 0.02610100f, -0.00902740f, 0.00249874f, -0.03214818f, -0.00627801f, -0.02877332f, 
    -0.03214248f, -0.00240938f, -0.00266241f, 0.02005662f, -0.00347421f, 0.00058886f, -0.01185434f, -0.01421211f, 
    0.01092784f, -0.01486018f, 0.01239954f, 0.00283714f, -0.02387294f, 0.02156131f, -0.02324936f, 0.00559516f, 
    -0.03797714f, 0.02174087f, -0.02583411f, -0.02857015f, -0.03626887f, 0.00220197f, 0.00044607f, -0.03232080f, 
    0.02302386f, -0.04023423f, -0.03775010f, 0.00550007f, 0.02150133f, -0.00504023f, -0.02903340f, 0.01148244f, 
    0.01411109f, -0.00431315f, -0.01314167f, -0.03194565f, 0.01413504f, -0.03877946f, -0.00482292f, -0.02295276f, 
    -0.01898684f, -0.02276924f, 0.01113291f, -0.02776723f, 0.01953509f, -0.01128976f, 0.01857540f, -0.02862039f, 
    -0.01023097f, -0.02816870f, 0.00127968f, 0.00270707f, 0.01024421f, 0.00301223f, 0.02245358f, -0.02435649f, 
    0.00068364f, 0.02520742f, -0.02904218f, -0.00134962f, -0.02632109f, -0.03469432f, -0.01805663f, -0.02154654f, 
    -0.02427500f, 0.00289581f, -0.03144023f, -0.02439367f, 0.02890651f, -0.00020005f, 0.01385046f, -0.01927573f, 
    0.02132704f, 0.01472713f, -0.01872079f, -0.01723853f, -0.04023119f, 0.00474892f, -0.01699232f, -0.03817782f, 
    0.02205110f, -0.01595065f, -0.01013881f, 0.00720283f, 0.02397397f, -0.01436630f, -0.00301181f, -0.00342805f, 
    0.00606362f, 0.02424754f, -0.03383271f, 0.01470503f, -0.00692435f, -0.02547658f, -0.02207333f, -0.03970530f, 
    -0.01634696f, 0.02184761f, -0.01738426f, -0.02035288f, -0.03095963f, -0.02313418f, -0.02446716f, -0.03501930f, 
    -0.00569656f, -0.02710049f, 0.01816690f, 0.01157943f, 0.00773315f, -0.03192846f, 0.01372113f, -0.02877484f, 
    -0.01396586f, 0.02669156f, -0.02321696f, 0.00512539f, -0.01501791f, -0.03508168f, -0.03939128f, -0.02355323f, 
    -0.01517371f, 0.01858834f, -0.03485371f, -0.04051929f, -0.03417012f, -0.02049627f, -0.02377740f, 0.02191615f, 
    0.01220450f, 0.01358905f, -0.02904810f, -0.02393792f, -0.00212866f, -0.00123315f, -0.01350463f, -0.03505561f, 
    -0.02373063f, -0.00618028f, -0.02483670f, -0.00441786f, 0.01031089f, 0.01245377f, 0.02527370f, -0.01977305f, 
    -0.03937301f, 0.00353448f, -0.01921319f, -0.03975541f, 0.00978933f, 0.02732312f, 0.00793361f, 0.01886278f, 
    -0.03840576f, -0.01946101f, -0.00800216f, 0.02796068f, 0.02767293f, -0.03137744f, -0.02101615f, 0.02986794f, 
    -0.03330512f, -0.02197731f, 0.02436827f, -0.02473717f, -0.02534492f, 0.02701113f, -0.00700175f, 0.01602042f, 
    0.01209730f, 0.00611523f, -0.02140897f, 0.02216491f, -0.01658908f, -0.03018760f, -0.00687690f, -0.01333942f, 
    -0.01103387f, -0.00832778f, 0.01657353f, -0.02726251f, 0.01245192f, 0.01099078f, -0.03936949f, 0.01919804f, 
    0.00480973f, -0.02500385f, -0.03549828f, 0.02336741f, -0.01896222f, 0.01445146f, 0.00029577f, 0.02622262f, 
    -0.03481280f, -0.00949175f, -0.01085802f, 0.00708819f, -0.01392071f, -0.01778931f, -0.01484607f, 0.00516189f, 
    0.00802178f, -0.00633307f, -0.02549635f, -0.03357910f, -0.00844240f, 0.00759722f, -0.01985575f, 0.02039051f, 
    -0.03338009f, 0.01049503f, -0.00540141f, 0.01177980f, -0.01708767f, -0.00094001f, -0.02594697f, -0.00336434f, 
    -0.00193631f, 0.02667595f, -0.00713856f, -0.00567407f, -0.03117295f, -0.00198654f, -0.01305729f, 0.02074100f, 
    0.00826657f, -0.01020579f, -0.02241532f, -0.03359539f, 0.01515761f, -0.01150505f, -0.00800137f, -0.02407117f, 
    -0.00933158f, 0.00316751f, -0.04086241f, 0.00232922f, 0.02681361f, -0.02215701f, -0.02976172f, -0.02446844f, 
    -0.04097684f, 0.02051642f, -0.00184303f, 0.01288927f, 0.01240449f, 0.00714933f, -0.00773005f, -0.01442083f, 
    -0.00101331f, -0.01316365f, 0.01108463f, -0.03263753f, -0.00582519f, 0.00062307f, 0.01303813f, -0.02372204f, 
    -0.03375608f, 0.01413580f, -0.02232369f, 0.00320025f, -0.00987896f, -0.03006597f, -0.02453648f, -0.01697377f, 
    -0.04093821f, -0.01476480f, -0.04066686f, 0.01526190f, 0.02240151f, 0.02332293f, -0.04048233f, 0.00939498f, 
    0.02776559f, 0.00240486f, -0.00986717f, -0.02130973f, 0.01786623f, -0.00761557f, -0.02655949f, -0.03939318f, 
    0.00657422f, 0.01345230f, -0.03812417f, 0.02949526f, 0.00056327f, -0.01103786f, -0.03842523f, -0.01009670f, 
    -0.00101766f, 0.00002521f, -0.02853485f, 0.01968220f, -0.04086216f, -0.03040088f, -0.00564203f, -0.02304248f, 
    -0.01092023f, 0.01530701f, -0.03625825f, -0.01592603f, -0.03423445f, 0.00244571f, 0.01315984f, 0.01862325f, 
    -0.00346815f, -0.02550936f, -0.00510468f, -0.04181144f, 0.01572812f, -0.00992995f, -0.00931456f, -0.02753672f, 
    0.02263509f, 0.01079542f, -0.00244097f, 0.02368399f, -0.01976975f, -0.03002984f, -0.01606025f, 0.01195581f, 
    0.02803035f, 0.02013216f, 0.01039660f, -0.02102945f, 0.02500589f, 0.01406343f, 0.00751603f, -0.03634633f, 
    0.02425840f, -0.04116058f, 0.01057637f, 0.01929860f, -0.01591293f, -0.02648437f, -0.03710731f, -0.00056100f, 
    0.01747892f, -0.03252294f, -0.02241229f, -0.00959233f, -0.03649381f, 0.02815043f, -0.01988858f, -0.01727499f, 
    0.00273760f, -0.02737255f, 0.01580922f, -0.03149420f, -0.01500196f, 0.00368071f, -0.02041700f, -0.02169945f, 
    -0.02604604f, 0.01704470f, 0.01563917f, 0.01401414f, 0.01344561f, 0.00917128f, 0.02546987f, -0.01389583f, 
    -0.00534815f, 0.00429571f, -0.03979001f, 0.02275977f, 0.00142350f, 0.01373778f, -0.01258010f, 0.01020736f, 
    -0.00746569f, 0.01857784f, 0.02425917f, -0.01822161f, 0.00893375f, 0.01937242f, -0.02273666f, -0.01985826f, 
    -0.00522601f, -0.02497575f, 0.02439500f, -0.02475079f, -0.00064783f, 0.01112989f, 0.01580880f, 0.02981448f, 
    -0.01355501f, 0.02975849f, 0.01255237f, 0.00818293f, -0.02553181f, 0.00926940f, -0.02826384f, -0.03632414f, 
    0.00035632f, -0.01339414f, -0.02288719f, 0.00330793f, 0.00486396f, 0.01097027f, 0.00844427f, -0.00123173f, 
    -0.01796504f, -0.02642385f, 0.02518412f, -0.00411548f, -0.03651416f, 0.02630883f, 0.01651324f, 0.00786978f, 
    0.02259876f, -0.00748019f, -0.03736050f, 0.02042271f, -0.04127659f, -0.03830497f, -0.02843025f, 0.01052739f, 
    -0.01287828f, 0.02930218f, 0.01539287f, -0.00024816f, -0.01685821f, -0.01429702f, -0.01352244f, -0.00527911f, 
    0.01844666f, -0.00276648f, 0.01131292f, 0.02679064f, 0.02625705f, -0.02444095f, -0.01612199f, -0.01177117f, 
    -0.00384060f, 0.01285705f, -0.01809205f, 0.02536573f, 0.02131429f, 0.00025047f, -0.03545032f, 0.00494222f, 
    -0.00792489f, -0.00620249f, 0.00184201f, -0.03055137f, -0.01671344f, 0.00033606f, -0.01776384f, -0.02953260f, 
    -0.01756904f, -0.01304107f, 0.00116568f, -0.02318121f, -0.01640992f, -0.00904705f, 0.00483743f, -0.03546394f, 
    -0.01219944f, 0.02627306f, -0.00755331f, 0.00347248f, -0.00375641f, 0.03450649f, -0.00883163f, -0.01208318f, 
    -0.00140390f, -0.02284281f, -0.01446224f, 0.01541033f, 0.01799680f, 0.00825015f, 0.02881185f, -0.02811162f, 
    -0.01942094f, -0.01250896f, 0.00140566f, -0.01891828f, -0.03407412f, -0.01004330f, 0.01351739f, -0.00258710f, 
    -0.01442358f, -0.03235605f, 0.01703703f, -0.01328860f, -0.01284377f, -0.01711309f, 0.01711872f, -0.01713463f, 
    -0.01521094f, 0.01862456f, 0.01892988f, 0.01542309f, 0.00445642f, -0.02292044f, 0.02692369f, 0.01901407f, 
    0.02131460f, 0.00244415f, -0.00658583f, -0.00140453f, -0.02203257f, -0.03802650f, -0.02661897f, 0.00769534f, 
    0.01572587f, -0.01452937f, -0.01717655f, -0.00948561f, 0.02159156f, 0.00138638f, -0.02597497f, 0.02404791f, 
    -0.02375813f, 0.00601667f, 0.02910704f, -0.03514362f, -0.02261272f, -0.00080523f, 0.01672832f, -0.01017480f, 
    -0.03041102f, 0.01962302f, 0.02143998f, 0.03258673f, 0.00661122f, 0.01779024f, 0.01175497f, -0.00884317f, 
    -0.02373491f, -0.03469320f, -0.03294071f, 0.01753486f, 0.03464133f, 0.00741980f, -0.03096392f, -0.01360925f, 
    -0.03217070f, 0.01578938f, -0.01954073f, -0.02928895f, 0.02683238f, -0.02284928f, 0.02506597f, 0.01614723f, 
    -0.02390902f, -0.00706067f, -0.01352810f, -0.02051838f, 0.00904193f, -0.01906917f, 0.02908056f, -0.02298473f, 
    0.00929686f, -0.02599589f, 0.00560202f, 0.01620822f, -0.00881091f, -0.01549917f, -0.01563987f, -0.00240676f, 
    0.00794422f, -0.00953429f, 0.03196979f, -0.02535209f, 0.02491261f, -0.00752228f, -0.02062666f, 0.03139985f, 
    -0.03690621f, -0.02419484f, -0.02344267f, 0.00237120f, -0.01220322f, 0.03004786f, -0.01647293f, -0.02610784f, 
    -0.00357403f, 0.00430100f, -0.03984236f, -0.02616511f, 0.02165485f, 0.00985684f, -0.01233989f, -0.01891667f, 
    -0.00168269f, 0.00460031f, 0.03443958f, 0.02675117f, -0.03362435f, 0.02872304f, -0.03864773f, -0.01799213f, 
    -0.00518620f, 0.02192365f, 0.00392890f, -0.03140308f, -0.03232341f, -0.02773464f, 0.01384805f, -0.00035402f, 
    -0.00305440f, 0.02508462f, -0.03896638f, -0.01829398f, 0.02860102f, -0.01250589f, 0.00904239f, -0.01442879f, 
    0.00209953f, -0.03090370f, 0.00187805f, 0.00613404f, 0.00658743f, 0.01171652f, 0.02840800f, -0.02499156f, 
    -0.01434152f, -0.00821492f, 0.01509434f, -0.00515726f, 0.00666433f, -0.02857443f, -0.02712786f, -0.02938537f, 
    -0.02373574f, -0.00114896f, 0.00598461f, -0.00852172f, -0.03773849f, -0.01682121f, -0.02279655f, -0.00601882f, 
    -0.01864512f, 0.00204313f, 0.02474654f, -0.03821260f, 0.03044523f, 0.00671742f, -0.01304790f, 0.01958997f, 
    -0.02542827f, 0.00957993f, -0.00321854f, -0.02780791f, 0.00624414f, -0.01671096f, -0.02542418f, 0.01296247f, 
    -0.00876440f, -0.02377506f, -0.01753754f, -0.02415032f, 0.02609853f, 0.03092958f, 0.01247318f, 0.01363343f, 
    0.03254397f, 0.01465731f, 0.00809747f, -0.00841269f, -0.00835558f, -0.01678904f, 0.00224068f, -0.02349922f, 
    -0.01200715f, -0.00103438f, -0.03378075f, -0.01937890f, -0.01447199f, -0.01604231f, 0.02116861f, -0.03318182f, 
    -0.00908814f, -0.03180983f, -0.01299281f, 0.02823971f, 0.00391998f, -0.02772983f, -0.02276522f, -0.00394937f, 
    -0.01737829f, -0.00478421f, -0.01546333f, 0.01221705f, -0.01888388f, -0.02340402f, -0.00567290f, -0.03819748f, 
    -0.03330344f, 0.02685931f, -0.01718060f, 0.01065257f, 0.00535257f, -0.00229262f, -0.02410281f, 0.00899408f, 
    0.01953115f, -0.03864888f, 0.03079729f, -0.00003868f, 0.00670775f, -0.01153102f, 0.01531596f, -0.02032110f, 
    -0.02922159f, 0.01363570f, -0.00553779f, 0.00248119f, -0.01589841f, 0.01794197f, -0.03903393f, 0.00903113f, 
    0.02931449f, -0.02167332f, 0.01302514f, -0.01778674f, -0.03085227f, 0.01816576f, 0.02929199f, -0.02420171f, 
    -0.01939917f, 0.02909587f, 0.00676773f, 0.01454185f, -0.00178193f, -0.03087282f, -0.02296006f, -0.02517148f, 
    -0.02499590f, -0.03151516f, -0.03605330f, 0.00070377f, 0.01053185f, -0.00015069f, -0.03337226f, -0.02978538f, 
    -0.01835397f, 0.02423677f, 0.02789415f, -0.01923283f, 0.02688501f, -0.03805508f, -0.02109613f, -0.00287901f, 
    -0.00397594f, 0.00591550f, 0.00688984f, -0.00005720f, 0.02358991f, -0.01524420f, -0.00865446f, 0.03513707f, 
    0.00083090f, -0.01137685f, -0.03853513f, -0.00329177f, -0.02658173f, -0.02723716f, 0.00840205f, -0.02299722f, 
    0.00355187f, -0.02118285f, 0.00625680f, -0.00270888f, -0.01739140f, 0.02835310f, 0.01599361f, -0.01913876f, 
    -0.00340476f, 0.02336277f, -0.02610896f, -0.02605397f, 0.00379079f, -0.03291002f, -0.02784446f, -0.01152544f, 
    -0.00849523f, -0.03003106f, 0.00277987f, -0.00766116f, -0.03076015f, 0.01814854f, 0.01878637f, 0.02650462f, 
    -0.03475821f, -0.04554751f, 0.00287219f, -0.01748770f, 0.01895723f, -0.02312579f, -0.03555178f, 0.02556540f, 
    0.01418291f, 0.00607745f, -0.02549124f, 0.00407279f, 0.01420872f, 0.00320462f, -0.01422449f, -0.02336680f, 
    -0.02497334f, 0.03122781f, 0.02800803f, 0.01298987f, 0.02164484f, -0.00529622f, -0.00807637f, 0.00461857f, 
    -0.00233806f, 0.01770804f, -0.03327258f, 0.02454903f, -0.03715901f, -0.03122892f, 0.00559091f, -0.00381190f, 
    0.02470017f, -0.03275963f, 0.01632105f, -0.01671772f, 0.02792196f, -0.01440085f, -0.01263585f, -0.01699616f, 
    -0.03254063f, -0.02829919f, 0.01968587f, -0.03383724f, -0.02703031f, -0.02014815f, 0.00196851f, -0.03348903f, 
    0.02008771f, -0.01207855f, 0.00944723f, 0.01291369f, -0.01534076f, -0.01744150f, -0.01712423f, 0.01220369f, 
    0.00383749f, -0.03046362f, 0.03133537f, 0.02731787f, 0.00191693f, -0.01423017f, -0.00957008f, -0.01557169f, 
    0.02741553f, 0.03498803f, 0.02739166f, -0.01105088f, -0.03726038f, -0.03573323f, -0.03941098f, 0.02540341f, 
    0.04086289f, 0.02536034f, 0.01837645f, 0.00208629f, -0.00835449f, -0.00402745f, 0.00361496f, 0.01475518f, 
    -0.00306159f, 0.00304073f, 0.03310943f, -0.03618809f, -0.03218634f, -0.00321777f, -0.00360210f, -0.00210099f, 
    0.00881544f, 0.02272644f, 0.01235854f, 0.00618408f, 0.02245150f, -0.03281162f, 0.03343736f, -0.01576359f, 
    -0.01675141f, -0.03858406f, 0.03159283f, 0.00549174f, -0.02392753f, 0.02149697f, 0.02496415f, -0.01408094f, 
    -0.00536593f, -0.01420386f, 0.02788113f, 0.01731800f, 0.00948941f, 0.01177141f, 0.00976237f, -0.00117488f, 
    -0.03349603f, 0.00540665f, 0.00167486f, -0.02286085f, 0.03676889f, -0.01642301f, -0.02562678f, -0.01636073f, 
    -0.01089948f, 0.01091559f, 0.00960340f, 0.02491698f, 0.03091111f, -0.01972686f, 0.01798729f, 0.00024686f, 
    -0.00093726f, -0.02187008f, 0.03491314f, -0.00034976f, -0.00546595f, -0.01238521f, 0.01631914f, -0.00612187f, 
    0.02477618f, 0.03005974f, -0.02985481f, 0.00895930f, 0.02206390f, -0.01226200f, 0.00471481f, -0.02428479f, 
    0.02636598f, 0.02258570f, -0.00456583f, -0.00267534f, 0.02235250f, -0.02147598f, 0.01343251f, 0.02022646f, 
    -0.01201057f, -0.02526278f, 0.01207460f, 0.00818214f, -0.01560675f, 0.02366330f, -0.01128918f, 0.03041710f, 
    -0.00505960f, -0.01746602f, 0.01494763f, -0.03610291f, -0.02347529f, 0.02517381f, -0.02811611f, 0.01305661f, 
    -0.03857781f, -0.01643668f, -0.03631442f, 0.02625244f, 0.02306352f, -0.03911442f, -0.02516875f, 0.01236363f, 
    -0.00350248f, 0.02947665f, 0.02704114f, -0.00420326f, -0.01149266f, -0.02842792f, 0.01284471f, -0.02748005f, 
    0.01624642f, -0.00584444f, -0.00023370f, 0.01620577f, -0.00018502f, -0.00929450f, -0.02440148f, 0.02075694f, 
    -0.04001617f, 0.02555762f, -0.00594935f, 0.03509520f, -0.01755065f, 0.02495927f, -0.03355212f, -0.01230764f, 
    0.04011485f, -0.02275479f, -0.01110839f, -0.01051241f, 0.00647562f, -0.00914279f, 0.01270795f, -0.00632715f, 
    0.00437687f, -0.00149893f, 0.01293217f, -0.02162234f, 0.01721678f, 0.01585306f, -0.02958972f, 0.01754588f, 
    -0.02537471f, 0.01376798f, -0.00472516f, 0.01483786f, -0.01916290f, -0.04080203f, -0.00680592f, 0.00479212f, 
    0.00187876f, -0.04034578f, -0.02612947f, -0.01940972f, -0.03661863f, 0.00335412f, -0.00361615f, 0.01177797f, 
    -0.02197875f, -0.00072040f, -0.00329446f, -0.01060200f, 0.00253645f, -0.00680396f, -0.02073270f, -0.02213612f, 
    0.03006089f, 0.00924790f, -0.03327507f, 0.02687655f, -0.01617990f, -0.03164217f, -0.00352900f, -0.02163124f, 
    0.00366105f, -0.01158506f, -0.02250714f, -0.02405862f, -0.04253473f, -0.03420231f, 0.02922917f, 0.01275360f, 
    0.03045679f, 0.03651042f, -0.02364645f, 0.01902368f, 0.01964695f, -0.02543854f, -0.03551931f, 0.01009769f, 
    0.03875463f, -0.04215199f, 0.01677579f, -0.02852724f, -0.00458762f, -0.01254959f, -0.04517069f, 0.01878341f, 
    -0.03513722f, -0.01558197f, -0.03970548f, 0.00830795f, 0.03197906f, 0.03068130f, 0.00179135f, -0.00013025f, 
    -0.04048529f, 0.03038731f, -0.02324371f, 0.00613683f, -0.00181327f, 0.02013295f, 0.02023273f, 0.00934554f, 
    0.00593081f, -0.02725214f, 0.02035072f, -0.03303915f, 0.00283609f, 0.00599295f, -0.03645525f, 0.02415876f, 
    -0.02120321f, -0.00114622f, -0.01649120f, -0.02036028f, -0.03479155f, -0.02720131f, 0.02578320f, 0.01164649f, 
    0.00192253f, -0.03347542f, -0.01951285f, -0.02541997f, 0.02695868f, -0.00908205f, -0.00078883f, 0.03301232f, 
    0.01980001f, -0.03509720f, -0.02419899f, -0.02876649f, -0.03663047f, 0.01500118f, -0.03358655f, -0.02684753f, 
    0.04225254f, 0.02007261f, 0.02017053f, -0.03326618f, 0.02665746f, 0.01604234f, 0.02297506f, -0.01656071f, 
    -0.01674487f, -0.01328537f, -0.03645888f, 0.02955934f, 0.00212252f, -0.03079113f, 0.02722191f, 0.01147582f, 
    0.02496515f, -0.03288929f, 0.01691829f, -0.03774735f, -0.00391806f, -0.01925414f, 0.00441260f, -0.00217339f, 
    -0.01297680f, -0.00196660f, -0.02999953f, -0.03218146f, 0.00315546f, -0.01420921f, -0.00903817f, -0.01841674f, 
    0.02377774f, 0.01235121f, -0.02255593f, -0.03180029f, -0.02366270f, -0.02876122f, -0.00778031f, 0.02355803f, 
    0.02901359f, -0.03418199f, 0.02957670f, 0.00519925f, 0.01911213f, -0.00718120f, 0.00188763f, 0.02582431f, 
    0.00329032f, -0.03468806f, 0.00675872f, 0.02757105f, 0.01715763f, 0.02142807f, 0.01062640f, 0.02369017f, 
    -0.01311952f, 0.00473224f, -0.02858607f, -0.01122992f, -0.00380984f, 0.00818707f, -0.01497718f, -0.01226893f, 
    -0.00464555f, -0.03022292f, 0.02937124f, 0.02485736f, -0.01814388f, -0.02054702f, -0.00145999f, -0.00472607f, 
    -0.04212644f, -0.03059668f, -0.00087424f, -0.03338544f, -0.00100233f, 0.02103001f, 0.01972981f, -0.00025808f, 
    -0.01021264f, 0.01322136f, 0.00004412f, 0.00842466f, -0.01686398f, 0.02128380f, -0.01852102f, -0.02041506f, 
    -0.00017078f, -0.00600332f, 0.01816131f, 0.02588061f, -0.00265610f, 0.01891300f, -0.03927402f, -0.02648088f, 
    0.02790390f, 0.00322634f, 0.03112255f, 0.01844829f, -0.03252151f, 0.00325466f, 0.00667561f, 0.03368237f, 
    0.02012089f, 0.01774482f, -0.02934093f, 0.00380547f, 0.00366691f, 0.02307956f, -0.03089605f, 0.01310440f, 
    -0.01168317f, -0.02157400f, -0.03498460f, 0.01373580f, -0.00701611f, -0.00696891f, -0.03547699f, 0.02666388f, 
    0.01340671f, 0.00498787f, -0.01741947f, 0.01545650f, -0.02220303f, 0.01970308f, 0.02540253f, -0.01620368f, 
    -0.02683405f, -0.03514485f, -0.02679591f, -0.02978052f, 0.00235422f, -0.01869013f, 0.01523657f, -0.00764356f, 
    0.01113230f, 0.01439087f, 0.01974506f, -0.02899109f, 0.00417766f, 0.01996165f, 0.01890218f, 0.01715383f, 
    -0.03059421f, -0.03250032f, -0.03368070f, -0.01432049f, 0.01319419f, 0.02377689f, -0.00958765f, -0.03460472f, 
    0.02525378f, -0.01857460f, -0.02310775f, -0.01313543f, -0.00530628f, 0.01789516f, 0.01974053f, 0.00718666f, 
    0.00741457f, -0.02694016f, -0.02041072f, -0.03771263f, -0.03849472f, -0.02954061f, 0.00650976f, 0.00718969f, 
    0.01183476f, 0.01761872f, 0.01317751f, -0.03600625f, -0.03551170f, -0.01507037f, 0.02625138f, -0.02580541f, 
    -0.03310166f, 0.03989324f, -0.01197750f, 0.00654679f, -0.00001016f, 0.00346085f, -0.02870393f, 0.01283387f, 
    -0.03488589f, -0.03563910f, 0.01361386f, -0.01871009f, -0.00248023f, -0.02172149f, -0.02898053f, 0.02417520f, 
    0.00439439f, -0.02920635f, 0.01019987f, -0.02982058f, -0.03153009f, -0.02359115f, -0.03559769f, 0.02496318f, 
    0.01464628f, -0.00683858f, 0.02652951f, -0.03198577f, 0.00462370f, -0.02923135f, 0.01777955f, -0.04042624f, 
    0.00234019f, -0.01583795f, -0.00479998f, 0.00168718f, 0.00094024f, 0.03240481f, -0.03243583f, 0.00857303f, 
    0.02270882f, 0.01840381f, -0.02838173f, -0.03758780f, -0.03408931f, -0.00304716f, -0.00540647f, 0.02330010f, 
    0.00933874f, 0.00737649f, -0.03754051f, -0.01508948f, -0.00396913f, -0.01158089f, 0.00125632f, -0.01836321f, 
    0.02573287f, 0.02879704f, -0.02480235f, -0.00047286f, 0.01374856f, 0.02731623f, 0.00241002f, 0.02259242f, 
    -0.03086073f, 0.00930705f, -0.03911540f, -0.01208682f, -0.01915269f, 0.03692527f, -0.04142828f, 0.01955584f, 
    0.01666800f, -0.02001762f, -0.00740477f, 0.01891388f, 0.00489329f, -0.00062933f, 0.00184909f, 0.00898219f, 
    0.00552958f, -0.00633995f, 0.02269787f, -0.03540769f, 0.01010883f, -0.02031279f, -0.03743713f, 0.01614663f, 
    0.01791894f, -0.02157275f, -0.01781983f, 0.02498991f, 0.03142640f, 0.02444730f, -0.03090669f, 0.01630200f, 
    -0.02832237f, -0.02389495f, 0.01906957f, -0.00476788f, 0.01136820f, 0.00105610f, -0.02128705f, 0.03074620f, 
    0.02612860f, -0.00677125f, 0.02733806f, 0.02280365f, 0.02515651f, -0.02088189f, 0.01397731f, -0.02963991f, 
    -0.00797777f, -0.02427887f, 0.03549277f, -0.01630352f, -0.00609599f, -0.03576181f, -0.03634252f, -0.01702343f, 
    -0.01962420f, -0.04052607f, 0.03064751f, 0.02101485f, -0.03050707f, 0.03016115f, -0.00839853f, -0.01138563f, 
    -0.00201051f, 0.02597275f, -0.03593567f, -0.01098126f, 0.01791879f, 0.00006549f, -0.03444507f, 0.03291994f, 
    0.02776104f, -0.00237363f, -0.04315272f, -0.02470069f, -0.01738676f, 0.02453084f, 0.01349729f, -0.01599142f, 
    -0.01829983f, -0.02539351f, -0.03569418f, -0.00107005f, -0.03600852f, 0.01547837f, 0.00273267f, -0.02053675f, 
    -0.00966661f, -0.00341165f, 0.02025780f, -0.02449574f, 0.01999960f, -0.03593725f, -0.02937980f, -0.02379064f, 
    0.01604078f, 0.02190622f, -0.02766771f, -0.00913534f, 0.00740577f, -0.04327374f, 0.02762045f, -0.01364725f, 
    -0.03264069f, -0.02461322f, -0.02198267f, -0.02979494f, -0.03748711f, -0.00220663f, 0.00567984f, -0.04350304f, 
    0.00512176f, -0.02253546f, 0.02769999f, 0.02638327f, 0.02006611f, -0.02486829f, -0.02669309f, 0.01362080f, 
    -0.02535403f, -0.00554243f, -0.00277123f, 0.03123127f, 0.02038294f, 0.00622542f, -0.02159265f, 0.02661148f, 
    -0.01058275f, 0.01242227f, 0.01082917f, 0.01266533f, -0.01552009f, 0.00628222f, -0.00641374f, 0.03096742f, 
    -0.02742889f, 0.00796421f, 0.00639566f, 0.01287814f, -0.02765734f, -0.00736762f, 0.00278656f, -0.02679072f, 
    -0.00769288f, 0.02780558f, -0.00230943f, -0.00516895f, 0.01955325f, 0.01306259f, -0.04311136f, -0.03387936f, 
    0.01533614f, -0.03297244f, -0.00289436f, -0.00789346f, -0.03329105f, 0.02325052f, -0.02161748f, -0.02117470f, 
    -0.00500295f, 0.01210036f, 0.01418412f, 0.00028917f, 0.02165027f, -0.01368680f, -0.02064999f, -0.02468666f, 
    -0.01522739f, -0.00947512f, 0.01961671f, -0.00907155f, 0.01260102f, -0.03559856f, -0.02682855f, 0.00066225f, 
    0.02597450f, 0.02697349f, -0.03486221f, -0.00231313f, -0.04378259f, -0.02340673f, -0.02722676f, -0.01419871f, 
    -0.02111369f, 0.03247174f, -0.03754096f, -0.03823511f, -0.02593815f, -0.03673765f, 0.01532689f, 0.00316567f, 
    -0.02766477f, 0.01441168f, 0.02077243f, -0.03207900f, -0.03001542f, 0.01508462f, -0.00132401f, -0.02567250f, 
    -0.00408163f, -0.00253031f, -0.00045355f, -0.02446338f, -0.00895240f, 0.01016820f, -0.02364895f, 0.01807193f, 
    0.00615605f, 0.02526182f, 0.01719505f, 0.03126616f, 0.02813076f, -0.02470869f, 0.03751292f, 0.03356171f, 
    0.01556932f, 0.01528035f, 0.02289481f, 0.02541955f, -0.00140079f, -0.03677541f, -0.03669358f, 0.03021196f, 
    -0.03391099f, -0.03848382f, -0.01981913f, -0.01001834f, -0.04352053f, -0.00742355f, -0.03247895f, 0.01445098f, 
    -0.04274496f, 0.01929212f, -0.01140927f, 0.02676092f, -0.00391017f, 0.00078670f, -0.01246092f, 0.03135597f, 
    0.03091991f, 0.00607178f, 0.00872591f, -0.01132090f, -0.00944377f, -0.03014452f, -0.00918834f, -0.04103002f, 
    -0.01007147f, -0.01887525f, 0.00127632f, -0.01877400f, -0.01526663f, 0.02027904f, 0.00259958f, 0.01413363f, 
    -0.01214300f, -0.00866599f, -0.01469034f, -0.03555794f, -0.01278172f, -0.01888157f, -0.01946517f, 0.00665519f, 
    -0.03783044f, 0.01425302f, -0.03898395f, -0.03747434f, -0.03376850f, 0.02414484f, 0.01868878f, 0.00083966f, 
    0.00777740f, -0.00372427f, -0.00946044f, -0.03981212f, 0.02830835f, -0.02223264f, 0.00767691f, -0.02192415f, 
    -0.03327596f, -0.02778306f, 0.00789409f, -0.00977044f, -0.01558417f, -0.00897162f, -0.01051565f, -0.01631848f, 
    -0.01004994f, -0.02186717f, -0.01989669f, -0.02720199f, 0.01902900f, 0.01354979f, 0.00619765f, 0.01317358f, 
    -0.00421250f, -0.02020718f, -0.03723279f, -0.03257720f, -0.02492414f, 0.02926209f, 0.00033014f, -0.01769326f, 
    0.02753532f, -0.04135896f, -0.00128830f, 0.01602475f, 0.00598748f, 0.01289194f, -0.01587631f, -0.01400666f, 
    0.01054517f, -0.01071850f, -0.02788113f, 0.02029535f, -0.00358086f, -0.02846330f, -0.00761562f, -0.03125926f, 
    0.01632882f, 0.01996068f, -0.01133340f, -0.00155265f, -0.02006961f, 0.02791462f, -0.04090190f, 0.01518811f, 
    0.04150832f, -0.00345740f, 0.01602930f, -0.01238579f, -0.00147184f, -0.00882556f, -0.00639140f, -0.02555798f, 
    -0.02926348f, -0.02768452f, 0.00629926f, -0.00703638f, 0.01269907f, -0.00391056f, -0.00519622f, -0.00243412f, 
    0.00000513f, -0.00291599f, 0.02568851f, 0.00566313f, -0.02752574f, 0.01098571f, -0.02561934f, 0.00422435f, 
    -0.03953250f, -0.04524811f, -0.03175452f, -0.02565068f, -0.03857260f, -0.02729221f, -0.01652752f, 0.02227013f, 
    -0.03956883f, -0.02207247f, 0.00071396f, -0.03101812f, 0.00398567f, 0.02977596f, 0.00114257f, -0.00376713f, 
    -0.03799254f, 0.00857473f, 0.01766858f, -0.02770588f, 0.00412426f, -0.01381363f, -0.01424938f, -0.04212178f, 
    -0.01534272f, -0.01913953f, -0.00474868f, -0.03229646f, 0.00243068f, 0.03327977f, 0.01722245f, 0.02479120f, 
    -0.02265791f, -0.00729095f, -0.01693871f, 0.02539602f, -0.01066501f, -0.03286288f, -0.02573407f, 0.02757776f, 
    -0.03683285f, 0.02126283f, -0.00586613f, -0.02816646f, 0.01002329f, 0.02743481f, 0.01917948f, 0.01247414f, 
    -0.00069092f, -0.03030773f, 0.02961034f, -0.00639695f, -0.03080735f, 0.02523135f, -0.00380122f, -0.00904957f, 
    -0.00133436f, 0.01999015f, 0.01699384f, -0.00160952f, 0.01131611f, 0.00434590f, -0.03695602f, -0.01813700f, 
    0.00421497f, -0.03218943f, 0.00084437f, 0.01747232f, -0.01803589f, 0.00242139f, 0.00947570f, -0.02442791f, 
    -0.02162373f, 0.01925074f, 0.01516782f, -0.00802828f, 0.03124115f, -0.01158177f, -0.01333882f, -0.00860058f, 
    0.00104268f, -0.02180343f, -0.00829859f, 0.00212514f, -0.01340319f, -0.01798292f, 0.02265734f, -0.01923671f, 
    0.00274982f, 0.01994574f, -0.00934734f, -0.01946788f, 0.01615641f, 0.00782949f, 0.00189627f, -0.01976229f, 
    0.01139978f, -0.01535906f, 0.03109269f, 0.03452376f, 0.02942982f, 0.02783492f, -0.01170232f, -0.03143530f, 
    -0.03705766f, -0.01818431f, 0.02187362f, -0.04069332f, -0.01691108f, 0.00113219f, 0.02752974f, -0.01721464f, 
    0.03191517f, 0.00468277f, -0.02697247f, 0.00382018f, 0.00478861f, -0.03016332f, -0.00782771f, 0.02990771f, 
    -0.00882895f, 0.00084400f, 0.02798502f, 0.02900884f, 0.00696909f, 0.02201875f, -0.02127827f, 0.01707751f, 
    -0.03095907f, -0.00345499f, -0.00147526f, 0.01650720f, -0.01450246f, -0.03267945f, -0.02155283f, 0.01718115f, 
    -0.02447552f, -0.00342123f, 0.00008302f, -0.03164292f, 0.02451427f, 0.01291138f, 0.00843059f, -0.00816255f, 
    -0.01347584f, 0.01334875f, 0.03069145f, 0.01784528f, 0.02743396f, -0.01502319f, -0.03042486f, 0.03298089f, 
    -0.04272274f, -0.03978574f, 0.00248967f, 0.02798066f, -0.03503994f, -0.02380428f, 0.00361923f, -0.00146309f, 
    -0.00403114f, -0.03428816f, 0.02741957f, 0.02461843f, -0.01467337f, 0.01710464f, -0.00908566f, 0.01828496f, 
    -0.02242622f, -0.03800189f, -0.03211277f, 0.00448610f, -0.04124594f, -0.03657163f, 0.02210277f, -0.02962616f, 
    0.03083511f, -0.00377858f, 0.02005634f, -0.02278934f, -0.01570394f, 0.01038392f, -0.03741330f, -0.02121813f, 
    -0.03777704f, 0.00281117f, -0.03027131f, -0.03982165f, -0.01914331f, -0.03517767f, -0.02345347f, -0.02800521f, 
    0.01439751f, -0.01524494f, 0.01131284f, -0.01127896f, 0.02757257f, 0.02280908f, -0.02250051f, 0.02790628f, 
    -0.00281799f, 0.02175144f, -0.02516068f, -0.00909848f, 0.01539582f, 0.01482137f, -0.00743762f, -0.03705038f, 
    -0.00651383f, 0.02633285f, -0.00395840f, 0.01577210f, 0.00937105f, -0.00476662f, -0.01090372f, -0.03178709f, 
    -0.02143015f, 0.02743422f, -0.01616878f, 0.01365331f, -0.01480198f, -0.03850377f, 0.02747558f, -0.00531342f, 
    -0.01461716f, -0.01854368f, -0.03032012f, -0.00118619f, 0.02353878f, -0.03842517f, -0.02693308f, -0.02683130f, 
    0.02231394f, -0.01031076f, -0.03451033f, 0.02749733f, -0.03990204f, 0.00118811f, 0.02522047f, 0.00076806f, 
    0.02834255f, 0.02882621f, 0.00018573f, 0.01498961f, -0.03165096f, -0.01562201f, 0.00726073f, 0.01691637f, 
    0.01184469f, -0.00563153f, 0.02782297f, -0.01874717f, -0.02323470f, 0.01758886f, 0.00482212f, 0.02851232f, 
    -0.02752327f, -0.01086522f, -0.01060995f, -0.02895800f, 0.02114789f, -0.02353664f, -0.00548320f, 0.01679562f, 
    -0.02579558f, -0.02364806f, 0.02133079f, -0.00598392f, 0.00697907f, 0.02330761f, 0.02390393f, -0.03844205f, 
    -0.02919660f, -0.03573770f, -0.03911596f, 0.03279314f, -0.03402426f, -0.01356389f, -0.03402678f, -0.01799901f, 
    -0.03609371f, 0.01818263f, 0.00849787f, 0.03060588f, 0.01816820f, -0.03817276f, -0.03492988f, -0.00744997f, 
    0.02732470f, -0.03341720f, -0.02576118f, 0.01017586f, -0.02431055f, -0.01399760f, -0.00571785f, -0.00253010f, 
    -0.15499003f, -0.25517526f, 0.03062009f, -0.03290813f, -0.16515602f, 0.01632917f, 0.07162362f, -0.09383617f, 
    -0.01403519f, -0.00754413f, 0.08839176f, 0.01041555f, 0.08289436f, -0.12787615f, -0.00544304f, 0.29454431f, 
    0.04236870f, -0.02108334f, 0.01180277f, 0.24982727f, 0.02984137f, -0.06841400f, 0.03407218f, 0.02770891f, 
    0.35213882f, 0.11587559f, 0.05273946f, 0.15683137f, 0.00619910f, -0.12473994f, -0.04100143f, 0.06492487f, 
    -0.07194975f, 0.01696573f, -0.02422118f, 0.04927477f, 0.36605552f, 0.14121160f, 0.23016655f, 0.05824347f, 
    -0.05362653f, 0.14346054f, 0.04901094f, 0.07379178f, 0.07945484f, -0.10149332f, 0.04161291f, 0.02796882f, 
    0.37303740f, -0.00817474f, 0.07776292f, -0.00536303f, -0.05551558f, -0.02488427f, 0.01906749f, -0.14629650f, 
    -0.06410825f, -0.07556066f, 0.01441865f, 0.08037431f, 0.00288353f, -0.18610884f, 0.18358873f, 0.10670588f, 
    0.06746434f, 0.10407121f, 0.14999025f, 0.20671566f, -0.06452923f, 0.06068849f, 0.11326683f, -0.02628910f, 
    0.04317311f, 0.00802424f, 0.03342707f, 0.06743142f, -0.04719414f, 0.04894088f, 0.09271055f, 0.15525241f, 
    -0.15031359f, 0.00159390f, -0.01127272f, -0.05828534f, 0.24343979f, -0.07460254f, -0.21355054f, 0.06152716f, 
    0.12399969f, 0.03611242f, 0.05343242f, -0.07174344f, -0.00906718f, 0.04970153f, 0.11116254f, -0.01652734f, 
    -0.12524661f, 0.00575879f, 0.00796217f, 0.03044139f, 0.06013453f, 0.02901923f, -0.00381858f, 0.13204885f, 
    -0.05160584f, 0.12109717f, 0.19872823f, 0.01450035f, -0.08566877f, 0.02285589f, -0.22195017f, 0.19258825f, 
    -0.03769126f, -0.04454339f, -0.06453119f, 0.06032236f, -0.06549419f, -0.07776578f, 0.14429456f, 0.01102723f, 
    0.28755972f, -0.19326544f, -0.13704458f, -0.14013280f, 0.13928430f, 0.00907537f, -0.08779583f, -0.03957719f, 
    0.13000104f, 0.00737422f, -0.01404536f, -0.09058256f, 0.19325805f, 0.10441961f, 0.07022351f, 0.01873971f, 
    0.14895698f, 0.03560309f, 0.05969872f, -0.01240444f, 0.12709744f, -0.08363348f, -0.07464698f, 0.15837570f, 
    -0.21811835f, -0.29977310f, -0.06971699f, 0.20843570f, 0.07999916f, 0.01683867f, -0.06289743f, 0.21286169f, 
    -0.02654797f, 0.00954176f, 0.01357075f, 0.09946195f, 0.26874176f, -0.16320685f, -0.19742878f, 0.06320331f, 
    0.04125094f, 0.07061061f, -0.04236776f, 0.13767546f, 0.13954172f, -0.09663709f, 0.04492933f, -0.04522416f, 
    -0.50397313f, -0.29324225f, 0.04875051f, 0.04745768f, 0.15248904f, 0.08551620f, -0.01384257f, 0.06726135f, 
    0.02663853f, -0.07233510f, 0.04401152f, 0.04317146f, 0.41858560f, 0.09633426f, -0.04475008f, 0.26212904f, 
    0.14714995f, -0.08138053f, -0.00972833f, -0.04215628f, 0.00207632f, 0.02955316f, -0.10731600f, 0.01579787f, 
    0.30188474f, 0.10607176f, -0.33298689f, -0.18448874f, 0.08825539f, 0.01890527f, 0.00863159f, 0.01581345f, 
    -0.11140124f, 0.16031696f, -0.13471344f, 0.06093099f, -0.27602011f, -0.14370209f, 0.03103253f, -0.01189736f, 
    0.03406834f, -0.07416280f, 0.22389486f, -0.01423786f, -0.08451004f, 0.04287661f, 0.03906975f, 0.09036957f, 
    0.30599183f, -0.12042452f, 0.04984801f, -0.03219005f, 0.12802240f, 0.07460310f, 0.02625599f, -0.00025385f, 
    -0.00818152f, 0.01973312f, -0.01600007f, 0.10619543f, 0.08095354f, -0.24138720f, 0.23879071f, 0.13330370f, 
    0.11171797f, -0.01869877f, 0.03614761f, 0.09320524f, -0.00300780f, -0.03209019f, 0.04052425f, -0.04867559f, 
    0.12286436f, 0.13695005f, 0.23105241f, 0.20864825f, 0.00635113f, 0.09165604f, 0.00040709f, 0.02056941f, 
    0.02849714f, 0.10925971f, 0.00539975f, 0.04912647f, 0.28937253f, 0.16103888f, 0.12320673f, 0.08937241f, 
    0.27359864f, 0.03862234f, 0.09465153f, -0.00379715f, 0.03640335f, 0.00495673f, 0.07143711f, 0.08610205f, 
    0.00272725f, 0.34087667f, -0.02431766f, -0.07746204f, 0.03453432f, -0.09270031f, -0.00773055f, 0.14230436f, 
    -0.03124159f, -0.10193163f, 0.02554435f, -0.04756559f, -0.18535458f, -0.16733848f, 0.12361680f, 0.04090391f, 
    0.09799790f, -0.06240794f, 0.05752042f, 0.15894473f, 0.01323168f, 0.09708545f, 0.03199971f, -0.01453434f, 
    -0.07147183f, 0.15769155f, -0.21626467f, 0.12543939f, 0.11807347f, 0.04294063f, -0.12099268f, 0.00840429f, 
    -0.09065247f, 0.08016645f, 0.06923190f, 0.06197935f, -0.11794404f, 0.09618589f, 0.00178716f, -0.07679075f, 
    -0.10517622f, -0.08496258f, 0.09824051f, 0.04606642f, -0.02033656f, 0.06179217f, 0.06061289f, 0.03063481f, 
    0.12724918f, -0.15571505f, 0.19623516f, -0.26834953f, 0.01082617f, -0.04580637f, 0.15047860f, -0.01292608f, 
    -0.03408261f, 0.01635553f, 0.11736137f, 0.00392043f, 0.10219728f, 0.17099594f, 0.05348600f, 0.16493651f, 
    0.15382044f, 0.03908704f, -0.01063984f, 0.07088006f, -0.03035882f, -0.06392833f, -0.05251619f, 0.03428436f, 
    -0.04407509f, -0.10016807f, 0.02826983f, -0.16089132f, -0.02283053f, -0.03215246f, 0.05747864f, 0.20244171f, 
    0.22460087f, -0.04781342f, -0.06553450f, 0.08100182f, 0.20015927f, -0.07129508f, 0.29938340f, -0.16630469f, 
    -0.14313668f, -0.14187807f, 0.15297900f, -0.02432973f, 0.01164735f, -0.15093611f, 0.11359460f, -0.01161759f, 
    0.20327117f, 0.11502625f, -0.01763618f, -0.03303417f, 0.04447854f, 0.09075008f, 0.01699853f, 0.09914860f, 
    -0.02412110f, 0.06607368f, 0.08360395f, 0.05620237f, 0.06664101f, -0.15188695f, 0.02419763f, 0.29855427f, 
    0.10375489f, -0.09626895f, -0.06714549f, 0.19102627f, 0.01099387f, 0.00297958f, 0.02714711f, -0.01288913f, 
    -0.10401571f, -0.14422120f, 0.05024519f, -0.09243947f, -0.04087416f, 0.09297884f, 0.10544387f, 0.09083781f, 
    0.01035786f, 0.05220598f, 0.03921851f, 0.01691724f, -0.21337149f, -0.07537900f, -0.06369021f, -0.01959010f, 
    0.07732462f, -0.04468377f, -0.03517602f, -0.12368449f, 0.01947833f, -0.00963069f, 0.00515524f, 0.11088344f, 
    -0.11962673f, 0.15662362f, -0.07907931f, -0.09996637f, -0.03621449f, -0.00611117f, 0.12417717f, -0.00349369f, 
    0.00254929f, 0.18982495f, 0.11664434f, 0.11712340f, -0.09259481f, 0.06716621f, 0.13708587f, -0.16146897f, 
    -0.10826729f, 0.02349965f, -0.03231645f, -0.10078056f, -0.04641992f, 0.03964154f, 0.20197572f, -0.07079117f, 
    0.04126798f, 0.03060172f, -0.05238581f, 0.07338233f, -0.08978567f, -0.03575029f, -0.07109896f, -0.02991880f, 
    0.14067321f, -0.11471158f, -0.09247286f, 0.04355665f, -0.00949565f, -0.09155735f, -0.28148401f, -0.07022922f, 
    0.09629998f, 0.06416426f, -0.05433808f, 0.00477992f, 0.10950853f, -0.04835532f, 0.05864353f, 0.05006371f, 
    0.07281187f, -0.24266830f, -0.07398853f, -0.25869337f, -0.13007076f, 0.13541645f, -0.15550911f, 0.07113497f, 
    -0.03640102f, 0.03216021f, 0.13834307f, 0.02927978f, 0.13045031f, 0.13559516f, 0.03153058f, 0.21529061f, 
    0.09095826f, -0.02181802f, -0.00156581f, 0.08884712f, 0.13975303f, 0.00286511f, -0.05039789f, -0.06485661f, 
    -0.08712213f, -0.18946357f, 0.01968433f, -0.02356113f, 0.08504380f, 0.01242123f, 0.03499229f, 0.04099059f, 
    0.15684870f, 0.09629839f, 0.18981647f, -0.07134212f, -0.00674015f, 0.06728572f, 0.21561316f, 0.26183194f, 
    0.17367107f, -0.00046060f, -0.02042943f, 0.06524140f, 0.15281546f, 0.04996147f, 0.03744259f, -0.11970004f, 
    0.36095923f, 0.21967229f, 0.19498821f, 0.26414511f, -0.01494026f, 0.12231293f, 0.00944045f, -0.05467064f, 
    0.02779148f, -0.15431829f, 0.01442662f, 0.16098051f, 0.52173787f, 0.19678874f, -0.01222945f, 0.14074311f, 
    0.03083963f, 0.01852111f, 0.11046216f, 0.08229590f, 0.09257259f, 0.06784020f, 0.02321951f, -0.00013844f, 
    0.02259045f, -0.24210505f, 0.10413540f, 0.04448319f, 0.09244053f, -0.00343680f, 0.16873287f, 0.04442303f, 
    0.09392563f, 0.04047031f, 0.02508942f, 0.06449457f, -0.23086827f, -0.12138995f, 0.09050922f, -0.17170374f, 
    -0.06238005f, 0.11070898f, -0.00948238f, -0.03962833f, 0.13431877f, 0.08335370f, 0.15383816f, 0.12390869f, 
    0.53599030f, 0.10792514f, -0.06443982f, -0.12184665f, 0.02549364f, 0.18324882f, 0.14044026f, 0.08253026f, 
    0.01185849f, 0.05807432f, 0.09724621f, -0.00432017f, -0.15200481f, 0.13141419f, -0.09662899f, -0.14931361f, 
    0.11144322f, 0.06018208f, -0.05874016f, 0.01898126f, 0.14482722f, -0.01565993f, 0.09470093f, 0.01303547f, 
    0.19855399f, 0.13810143f, -0.14897427f, -0.11923891f, -0.08322144f, 0.19046998f, -0.03399872f, 0.01118250f, 
    0.00550112f, -0.02012199f, 0.07942298f, -0.03646959f, -0.04108672f, -0.20717923f, -0.20723782f, 0.08850840f, 
    0.11099745f, 0.01426926f, -0.10181562f, 0.03560273f, 0.05027636f, 0.00312013f, -0.00318923f, 0.08880103f, 
    -0.26125923f, 0.04709604f, -0.10111112f, -0.00560834f, 0.05443746f, 0.01191788f, -0.08691496f, 0.02847722f, 
    0.00795268f, 0.11918787f, -0.03211201f, -0.01683524f, 0.02511918f, 0.19665246f, -0.11254412f, -0.19744064f, 
    0.04042715f, -0.02036175f, -0.04062042f, 0.00693188f, -0.01878874f, -0.06250747f, -0.01505061f, 0.06112162f, 
    -0.21721943f, -0.10091280f, -0.11487687f, -0.03340675f, -0.16239999f, 0.02124906f, 0.05649697f, 0.02107069f, 
    0.05377236f, -0.05691922f, 0.03147546f, 0.10981254f, 0.14199267f, -0.02483743f, 0.12884928f, 0.09128321f, 
    0.07225314f, -0.04346319f, -0.05320019f, -0.01963479f, -0.04734668f, -0.00068234f, -0.07319583f, -0.03680988f, 
    0.01659149f, -0.06933675f, -0.14024921f, 0.02814031f, 0.04432193f, 0.10676450f, -0.07536960f, -0.13348010f, 
    0.00200398f, -0.06757559f, -0.06159933f, 0.11608823f, 0.34671369f, -0.07031757f, 0.15107602f, -0.02334540f, 
    0.21417475f, -0.05944410f, 0.04351919f, 0.06431501f, 0.01113474f, -0.04942009f, -0.00776976f, -0.04520143f, 
    0.10358358f, 0.25577554f, 0.14573774f, 0.07914645f, 0.08954207f, -0.05788213f, 0.14967239f, -0.04028227f, 
    0.06207702f, 0.01243773f, -0.07265871f, 0.09200387f, -0.19508083f, -0.02555813f, 0.09019886f, 0.21689622f, 
    0.14118986f, -0.09386413f, 0.00453869f, 0.13240874f, 0.02322783f, 0.01294261f, 0.00532728f, -0.03229791f, 
    0.34877041f, 0.09710497f, -0.13557762f, -0.21968246f, 0.07064136f, 0.01700962f, -0.05711001f, 0.10297677f, 
    -0.10054637f, 0.16416596f, -0.05157357f, 0.06065324f, -0.15047771f, -0.17507635f, 0.07052172f, -0.11707101f, 
    -0.09454013f, 0.07257331f, -0.00368436f, 0.00533857f, 0.04490162f, -0.05739339f, 0.05437375f, 0.05835278f, 
    -0.15299025f, 0.04962325f, 0.29057974f, 0.03878612f, -0.05161843f, 0.03907622f, 0.02247458f, 0.04568079f, 
    0.19278596f, 0.00839545f, 0.01919893f, 0.00781515f, -0.03328370f, -0.15668139f, 0.07125521f, -0.06873221f, 
    0.01657538f, -0.12926506f, 0.04361057f, -0.16732843f, -0.18270959f, 0.10891164f, 0.10883743f, 0.07493093f, 
    -0.08494259f, 0.03954586f, 0.28582776f, -0.08596232f, -0.06720430f, 0.03504115f, -0.04198018f, 0.01045780f, 
    -0.05011345f, -0.11293673f, 0.06114321f, -0.13797660f, -0.01791179f, -0.10143107f, -0.31391120f, -0.07925729f, 
    -0.13108158f, -0.00678892f, -0.02232827f, -0.02672029f, -0.01811784f, 0.05676679f, 0.04915316f, 0.03597922f, 
    -0.02324667f, -0.01845060f, -0.00372458f, 0.00680391f, 0.01430461f, 0.01751990f, -0.01836487f, 0.02394702f, 
    0.03980614f, -0.01396443f, -0.02036394f, -0.03418726f, -0.02413485f, 0.02567161f, -0.02263409f, -0.02040134f, 
    0.02976296f, -0.01599639f, -0.04099433f, -0.00509304f, 0.02216962f, -0.03236968f, -0.02289908f, -0.00508726f, 
    -0.00816873f, -0.03621561f, 0.02394557f, 0.03320145f, 0.02269595f, 0.01242471f, 0.02881699f, -0.02607444f, 
    0.01528287f, -0.01476980f, -0.02544218f, -0.02014073f, 0.02306269f, -0.01164496f, 0.02200365f, 0.00978237f, 
    -0.00179471f, 0.01128455f, 0.02384310f, -0.03768568f, 0.02252645f, -0.01552271f, -0.04213023f, -0.02973189f, 
    -0.03653090f, -0.02575254f, -0.03866826f, -0.02254791f, 0.00771217f, -0.01993536f, -0.03502951f, -0.04017517f, 
    -0.02005627f, -0.03915187f, -0.01134724f, 0.01411811f, -0.00870581f, -0.01017739f, -0.00127537f, -0.00024439f, 
    0.02483236f, -0.02292905f, -0.00601740f, -0.00052997f, -0.00482634f, 0.02304625f, 0.02860758f, -0.03867400f, 
    0.01448170f, -0.01178192f, -0.03452892f, 0.02169901f, 0.01790236f, 0.02748280f, -0.01753141f, -0.01251828f, 
    0.03912866f, -0.02472782f, 0.01942115f, -0.02355380f, 0.02581950f, -0.00931201f, 0.00406471f, -0.00843405f, 
    -0.00113140f, 0.02369633f, -0.03319119f, -0.01620242f, -0.03319821f, -0.03287314f, 0.01409452f, -0.02125102f, 
    -0.03402067f, 0.03240236f, 0.02088833f, 0.01134467f, 0.00083281f, 0.02170146f, -0.02030380f, 0.01493685f, 
    0.02637478f, 0.00548196f, -0.00566521f, 0.02556597f, 0.01803693f, -0.00259043f, -0.02655385f, -0.00252503f, 
    0.00891146f, 0.01553296f, 0.00637604f, -0.00628448f, 0.01831684f, -0.01222986f, 0.03213736f, 0.00372674f, 
    0.01813276f, 0.01181450f, -0.02718105f, 0.00653140f, 0.01971573f, -0.01622039f, -0.01156472f, 0.00065345f, 
    -0.03085119f, -0.01927439f, -0.00225811f, -0.03507737f, 0.01415211f, -0.03511650f, 0.02401964f, 0.03221294f, 
    0.00450002f, 0.02657392f, 0.02098428f, -0.00433625f, 0.02714126f, 0.01609984f, -0.02140542f, -0.00675379f, 
    -0.01116418f, -0.00390684f, -0.02286042f, 0.02433035f, 0.01406001f, -0.03505763f, 0.02284478f, -0.00344185f, 
    -0.01475645f, -0.00727564f, 0.03924003f, -0.01631951f, -0.01327276f, 0.01275784f, 0.02171169f, -0.03034991f, 
    0.00854808f, 0.00395696f, 0.00188649f, -0.01170077f, -0.00058778f, 0.01989528f, -0.02004010f, 0.02692270f, 
    0.00615940f, -0.04170716f, 0.00341304f, 0.01732179f, 0.02700395f, -0.00526337f, 0.00341347f, -0.02515581f, 
    0.01467789f, -0.03336419f, 0.03466094f, 0.01641207f, -0.04103924f, 0.01039569f, -0.00132347f, 0.01331033f, 
    -0.03253098f, -0.03185555f, 0.00124804f, 0.01840698f, -0.01568228f, -0.01890242f, -0.02464731f, -0.01103941f, 
    0.00939672f, -0.00268691f, -0.04125420f, -0.03295418f, 0.01530098f, 0.00718432f, -0.04212614f, 0.02314108f, 
    -0.01728570f, 0.01319493f, -0.04143339f, 0.01106385f, 0.02538897f, 0.02593198f, -0.02680127f, -0.00742898f, 
    0.01036402f, 0.02266841f, -0.03734804f, -0.01892036f, -0.00996285f, 0.01986634f, -0.00705498f, -0.02296403f, 
    -0.02750175f, -0.03367301f, -0.02153352f, 0.02945195f, 0.02240530f, -0.00699673f, 0.01969997f, -0.02545221f, 
    0.02715091f, 0.02242455f, 0.01904180f, 0.01223135f, -0.03480355f, -0.02651657f, -0.01911312f, 0.03515892f, 
    0.00336874f, -0.02024181f, -0.02884225f, -0.01261287f, 0.02446063f, 0.01454439f, -0.00124561f, -0.01309467f, 
    0.01561986f, 0.02966616f, 0.00587879f, -0.00205644f, -0.02774124f, -0.02661549f, -0.03949893f, 0.01857928f, 
    0.02558381f, 0.02370255f, 0.01070731f, -0.03469823f, 0.01118169f, 0.02476009f, -0.00065804f, -0.02592981f, 
    0.01265087f, -0.00882786f, 0.01633271f, 0.01260958f, -0.02127560f, 0.00779485f, 0.02653124f, 0.02389601f, 
    0.00089021f, 0.00596709f, 0.01497181f, -0.00012581f, -0.03563055f, -0.03720970f, 0.02263766f, -0.01432452f, 
    0.01512356f, -0.00062790f, 0.00665970f, 0.01224461f, -0.00028029f, 0.02279547f, -0.04049525f, -0.02480204f, 
    0.00383156f, 0.01081278f, 0.04077463f, -0.03092179f, -0.01051013f, -0.03118528f, 0.02475690f, 0.01786354f, 
    -0.02649631f, 0.01023837f, -0.01387658f, -0.03127161f, -0.01888639f, 0.00837997f, -0.02889146f, -0.02149371f, 
    0.02473363f, -0.04251924f, -0.00781756f, -0.04043962f, -0.00481959f, -0.03521587f, 0.00302722f, 0.00308489f, 
    -0.02014850f, -0.00360574f, 0.01178175f, 0.02653868f, -0.02132419f, -0.03218740f, -0.02939819f, 0.03099729f, 
    -0.02246456f, -0.01112013f, 0.02805609f, -0.00168622f, -0.01497009f, -0.02010382f, -0.01755757f, 0.02597111f, 
    0.02653008f, -0.01784557f, 0.01372323f, 0.01812061f, -0.03116712f, -0.01637368f, -0.00217250f, 0.01634086f, 
    -0.04169736f, -0.00807530f, -0.01243063f, 0.01240639f, 0.00531045f, 0.00430128f, 0.00642890f, 0.01416342f, 
    -0.01385076f, -0.00890710f, -0.01550745f, 0.01537321f, 0.02415423f, -0.00913059f, -0.02095003f, -0.01678965f, 
    -0.02133546f, 0.00533459f, 0.01195278f, 0.01553913f, -0.03141985f, -0.03480420f, -0.04093808f, 0.03889401f, 
    -0.02368919f, 0.01228526f, 0.02976617f, -0.03612013f, -0.00483518f, 0.00970684f, -0.02490973f, 0.01775787f, 
    0.01259980f, 0.02246110f, 0.02220098f, 0.00048003f, -0.03223784f, 0.01765192f, -0.03420690f, 0.01006175f, 
    0.02203841f, -0.03894942f, 0.02431010f, 0.00761727f, 0.02504778f, 0.03919482f, -0.03252003f, -0.03196525f, 
    -0.02482463f, -0.04172573f, -0.02339729f, 0.00301415f, 0.02598254f, -0.03091946f, 0.01905163f, 0.01774496f, 
    -0.02619547f, -0.02180031f, 0.01306452f, -0.03402635f, 0.01269842f, -0.00004769f, -0.02521872f, 0.02265061f, 
    -0.00387985f, 0.00808852f, 0.01857254f, -0.03518717f, -0.02156483f, -0.02805077f, 0.00351014f, -0.01300880f, 
    -0.01599696f, 0.00048681f, 0.02896034f, -0.01166315f, 0.04154436f, -0.02469693f, 0.01763119f, -0.02477569f, 
    -0.03923812f, -0.01029956f, -0.03611777f, 0.02526991f, -0.01183486f, -0.01289061f, -0.02324583f, -0.04167857f, 
    -0.00841525f, -0.02985272f, 0.00047717f, -0.01227377f, 0.01167072f, -0.01345559f, -0.02336411f, -0.03714662f, 
    -0.04016772f, -0.02095394f, 0.01822998f, 0.01963571f, -0.00645816f, -0.01147713f, 0.00415768f, 0.01113413f, 
    0.02559823f, -0.01490645f, -0.01535928f, 0.01005753f, -0.00952952f, -0.02303889f, -0.01960475f, 0.01088907f, 
    -0.01345177f, -0.01727706f, -0.02542711f, -0.01625147f, 0.00233365f, -0.02692911f, -0.00908511f, 0.02932393f, 
    -0.02602200f, -0.02498114f, 0.02972143f, -0.02088009f, -0.01508953f, -0.00290745f, 0.01239141f, 0.00592548f, 
    -0.01531874f, -0.00093437f, 0.01588094f, 0.00292678f, -0.01353327f, -0.04303807f, -0.00508983f, -0.03009385f, 
    -0.00757693f, 0.00608352f, -0.02581425f, -0.04120190f, -0.01091598f, 0.02810683f, 0.03121920f, -0.00948950f, 
    -0.02116352f, -0.01140706f, -0.03340783f, -0.01095074f, 0.02759292f, -0.00310464f, -0.00308256f, -0.01150982f, 
    -0.02655585f, 0.02485445f, -0.03954554f, -0.02239620f, 0.01653876f, 0.00853870f, -0.02522490f, -0.00886985f, 
    -0.01615127f, -0.03781221f, -0.03707080f, 0.02408167f, -0.03744658f, 0.00282343f, -0.02752293f, -0.01511079f, 
    -0.02703854f, -0.02309541f, -0.00073479f, -0.01104123f, -0.01986969f, -0.00986549f, -0.00208568f, -0.03799785f, 
    0.00497510f, -0.02322707f, -0.02062050f, 0.01791658f, -0.03743943f, -0.02345013f, -0.01557741f, -0.00143009f, 
    -0.01449244f, 0.00178590f, -0.00551859f, 0.02088470f, 0.02337721f, 0.01659405f, -0.00352890f, -0.03164518f, 
    0.00466185f, 0.00046119f, -0.02012368f, 0.00227471f, -0.03119938f, 0.02139253f, -0.02196805f, -0.03106581f, 
    -0.00726965f, 0.01548865f, -0.02731656f, 0.01224851f, -0.00655027f, -0.02464263f, 0.02590416f, -0.03418595f, 
    0.00223781f, -0.01289620f, -0.02916009f, 0.02766502f, -0.02329183f, -0.00938858f, 0.01314388f, -0.03409895f, 
    0.01240969f, -0.02762217f, 0.00955522f, -0.01214741f, 0.00555229f, 0.01133843f, 0.03816259f, 0.02497304f, 
    0.01095343f, -0.02751572f, -0.01693028f, 0.00056883f, 0.00864608f, -0.01603034f, 0.02004893f, -0.02981097f, 
    0.03091031f, 0.02029923f, 0.00790360f, -0.01029942f, 0.01101774f, 0.01598721f, 0.01939683f, -0.00888867f, 
    0.02794817f, 0.01378064f, 0.02442036f, 0.00576425f, -0.00169219f, -0.02804559f, -0.00188282f, -0.01026165f, 
    0.01215407f, -0.02291018f, 0.01204805f, 0.02619001f, -0.00106804f, -0.02115852f, 0.01397423f, -0.02483037f, 
    -0.03934599f, -0.00335837f, -0.02677698f, -0.00821302f, 0.01420055f, -0.02459113f, 0.02268731f, -0.01056337f, 
    0.01448626f, -0.00732133f, 0.01391377f, 0.01096566f, -0.02018537f, 0.01136080f, 0.00724093f, -0.02384849f, 
    0.01888606f, -0.04065466f, -0.04300515f, 0.00074637f, -0.00907581f, 0.02537148f, 0.01907223f, -0.03227065f, 
    -0.00338358f, 0.00815464f, -0.03393723f, -0.00899843f, -0.01501508f, -0.03884691f, 0.02187335f, 0.01738549f, 
    0.00457209f, 0.02687584f, 0.01500225f, 0.01544699f, 0.00438157f, -0.01862894f, 0.00572015f, 0.02174353f, 
    -0.02196901f, -0.02393723f, -0.00056707f, -0.01585531f, 0.00731327f, -0.03073727f, -0.00484720f, -0.03072174f, 
    -0.02238114f, -0.01789874f, -0.00803351f, -0.04267204f, -0.03848055f, -0.02801283f, 0.03845300f, -0.03296208f, 
    0.01812712f, 0.02224898f, -0.00144453f, 0.02961221f, -0.02684373f, 0.02474879f, -0.03218519f, 0.00720643f, 
    0.02032459f, -0.02343937f, -0.00619625f, -0.00332484f, -0.02384460f, -0.00971497f, 0.01210019f, 0.01633898f, 
    0.01373864f, -0.03675931f, -0.03604657f, 0.00760866f, -0.01469429f, -0.03779141f, -0.03226276f, 0.02968828f, 
    -0.02393165f, -0.03980538f, -0.03351241f, -0.00343711f, 0.01386286f, -0.00013186f, 0.01303659f, -0.01900332f, 
    -0.00926147f, -0.01986017f, -0.02337427f, -0.02086437f, 0.01041203f, -0.01150941f, -0.02308211f, -0.00420062f, 
    -0.04069119f, -0.00825053f, -0.01104729f, -0.02017624f, 0.00991524f, -0.01868023f, 0.00204187f, -0.00278117f, 
    -0.03212973f, 0.02836440f, 0.01026146f, -0.02907505f, 0.01072915f, 0.02093099f, 0.02026328f, -0.01679341f, 
    -0.02147453f, -0.00789774f, 0.00284149f, -0.01876998f, -0.02927566f, -0.00732199f, 0.03310290f, 0.00620916f, 
    -0.00661367f, -0.01519444f, 0.00283355f, -0.00449305f, 0.04174510f, -0.03314680f, 0.00156674f, 0.03306974f, 
    -0.00870491f, 0.01554750f, 0.00293519f, -0.02412773f, 0.00049868f, -0.00792637f, -0.01593849f, -0.01963133f, 
    0.03793332f, -0.02071726f, -0.01208160f, -0.02160632f, 0.00879521f, -0.03608418f, -0.03747036f, 0.03010537f, 
    -0.01556186f, 0.00635444f, -0.03598818f, -0.00517448f, -0.02677374f, -0.02309477f, -0.01912307f, -0.03855575f, 
    0.02984020f, -0.00403227f, -0.02746933f, 0.02371914f, -0.00899296f, -0.01406519f, 0.03562129f, -0.02535390f, 
    0.02396847f, 0.00316241f, 0.02910283f, 0.01117336f, 0.02348866f, 0.04230602f, -0.00602481f, -0.00556758f, 
    0.00984155f, -0.03774706f, -0.00076670f, 0.01580201f, -0.01661261f, 0.02721991f, 0.03161569f, 0.02722924f, 
    0.01037842f, 0.01227585f, 0.01378167f, -0.01697931f, 0.01059720f, 0.00800041f, 0.00473686f, 0.01099317f, 
    -0.00455324f, 0.00336347f, -0.03324966f, -0.01846132f, -0.02620548f, -0.01555836f, -0.00093388f, -0.00246050f, 
    -0.04184477f, 0.00970192f, 0.00267061f, -0.02418236f, 0.01580866f, 0.01746088f, -0.02849796f, 0.00873938f, 
    -0.01085044f, -0.01052576f, -0.02879004f, 0.01420780f, -0.02905883f, 0.01912371f, -0.03994782f, 0.03493949f, 
    0.02235711f, 0.01602249f, 0.01225906f, 0.02968147f, -0.03398245f, -0.03503014f, -0.01361668f, 0.00920658f, 
    0.03431091f, -0.02560101f, -0.01302920f, -0.00126370f, -0.01358043f, -0.03157920f, -0.00892492f, -0.00801076f, 
    -0.00903094f, -0.00445343f, -0.02126960f, -0.02462532f, 0.01631732f, 0.01581221f, -0.03963350f, 0.02683007f, 
    -0.03625026f, -0.02381892f, -0.00308041f, 0.00809295f, 0.00679915f, -0.02307170f, -0.02841239f, -0.04019442f, 
    0.01047441f, -0.03582554f, 0.00055810f, 0.01619016f, 0.01349652f, -0.03103565f, 0.00427815f, 0.02944178f, 
    -0.01213516f, -0.03698694f, -0.00119294f, 0.01739118f, 0.00426046f, 0.01483180f, 0.02770953f, 0.02441989f, 
    0.02720972f, -0.00250202f, 0.01736443f, -0.02292504f, -0.00908801f, -0.02041069f, 0.03367285f, 0.02315106f, 
    -0.03354741f, -0.00260073f, -0.00221937f, -0.00284554f, -0.01571599f, 0.02191657f, -0.01372179f, -0.01647365f, 
    0.00793647f, 0.02023870f, -0.00554773f, 0.02543301f, -0.02735666f, 0.00299506f, -0.03772067f, 0.01260576f, 
    0.02524862f, 0.00982024f, -0.02595618f, -0.00381859f, 0.02358480f, -0.03191429f, -0.01128030f, -0.00334699f, 
    -0.00179231f, -0.02144471f, 0.00260492f, 0.01700786f, 0.00459039f, -0.00942821f, -0.00606086f, 0.00599211f, 
    0.02836829f, 0.02993761f, 0.01247166f, -0.03375651f, -0.03025880f, 0.02763660f, -0.01794404f, -0.00260163f, 
    0.00023482f, 0.00652088f, -0.01276060f, 0.02408030f, -0.02669533f, 0.02065619f, 0.02675044f, -0.00878087f, 
    0.00934577f, -0.01667185f, -0.01247419f, -0.00306601f, 0.01185179f, 0.01833145f, -0.03640832f, -0.00281017f, 
    0.01298294f, 0.00852863f, -0.02980166f, -0.01014326f, 0.01567748f, 0.03042787f, -0.01965587f, -0.03600496f, 
    0.00683481f, 0.03256855f, 0.02085817f, -0.01539575f, -0.03475020f, -0.01800814f, 0.01860822f, 0.01982784f, 
    0.02263705f, -0.03123413f, 0.02892549f, -0.02534599f, -0.03277264f, 0.01717598f, 0.01269743f, 0.02474490f, 
    -0.03245680f, -0.01978659f, -0.00101427f, 0.01624476f, 0.00359406f, -0.00797047f, -0.02947254f, 0.00320954f, 
    -0.02441600f, -0.00862614f, 0.00621831f, 0.02439719f, -0.00030031f, 0.02565463f, -0.00503332f, -0.02409772f, 
    0.01288760f, 0.00412991f, 0.02167128f, -0.01877852f, 0.01498480f, -0.05098778f, 0.01363527f, -0.02685910f, 
    0.02164226f, -0.01991713f, 0.00056792f, -0.03341031f, 0.02045527f, -0.02396326f, 0.02751500f, -0.02024164f, 
    0.02425292f, -0.01920776f, -0.03730842f, -0.03700253f, 0.02958679f, 0.01180868f, -0.03015397f, -0.03294532f, 
    -0.03894243f, 0.00833496f, 0.02238347f, 0.02589981f, -0.00889468f, 0.01999351f, -0.03046361f, -0.02831657f, 
    0.01371710f, -0.02359227f, 0.01765201f, 0.02626692f, 0.02182927f, -0.00975804f, 0.02724237f, -0.02413907f, 
    0.04085746f, -0.01318854f, 0.00302843f, 0.01311286f, -0.01077953f, -0.02706101f, -0.04586101f, -0.03786174f, 
    -0.01583564f, -0.00220527f, -0.01690720f, 0.01074467f, -0.01614689f, 0.03822319f, 0.01179423f, -0.00691793f, 
    -0.04089761f, 0.03511397f, 0.01973552f, 0.00648501f, 0.00824863f, -0.00211797f, 0.02741258f, -0.00033992f, 
    0.02540968f, -0.00701742f, -0.02465953f, 0.00610566f, -0.02754122f, 0.00692385f, 0.01449664f, 0.02553572f, 
    0.00511155f, -0.00916378f, -0.02594361f, -0.01135849f, -0.01901983f, -0.03099663f, 0.01160190f, 0.02634675f, 
    -0.00219708f, -0.01630291f, -0.02094653f, -0.03930929f, 0.02091056f, -0.02961965f, 0.01885475f, 0.01712832f, 
    -0.02383940f, -0.02621129f, -0.02554269f, -0.00906056f, 0.01073496f, -0.00065231f, 0.01925261f, -0.02508127f, 
    0.00853209f, 0.00510317f, 0.00928766f, 0.02024551f, 0.02479939f, 0.03491523f, 0.00354066f, 0.00493927f, 
    -0.00154625f, 0.00484629f, -0.00981297f, -0.01761614f, -0.03436863f, 0.02894714f, -0.02663045f, -0.03333504f, 
    0.02243490f, -0.02527130f, -0.00028892f, 0.00900294f, -0.02668335f, -0.00133587f, 0.00092330f, 0.01285719f, 
    0.00174762f, 0.01684449f, 0.02748640f, -0.01831300f, 0.01305270f, 0.02903157f, 0.03206591f, -0.02661195f, 
    -0.00875355f, 0.01176993f, 0.02296868f, 0.02402494f, -0.00472692f, -0.03445864f, 0.01365852f, -0.03386885f, 
    -0.02387565f, 0.02537549f, -0.00338265f, 0.01872236f, 0.00002774f, -0.01206595f, -0.01804795f, -0.03440814f, 
    -0.00229912f, -0.00913324f, -0.01341666f, 0.00191448f, -0.00308087f, -0.00158139f, -0.01930762f, -0.00748589f, 
    0.03118021f, -0.00794416f, 0.00045496f, -0.00894836f, 0.01935009f, 0.02353066f, 0.01510426f, 0.01620707f, 
    0.00662287f, 0.01271550f, 0.00450666f, -0.02314250f, -0.00942739f, -0.01365216f, 0.03323372f, 0.02442524f, 
    -0.02501446f, -0.02971009f, 0.03529490f, -0.04081240f, -0.01466631f, 0.00234327f, -0.02205747f, -0.00792234f, 
    -0.02075449f, -0.04258821f, -0.04904023f, -0.00386146f, -0.03775091f, -0.02331433f, -0.02005786f, -0.01212955f, 
    -0.01421041f, 0.01418888f, 0.01240163f, -0.03103399f, -0.02841649f, -0.00942377f, 0.01251913f, 0.02624062f, 
    0.02426222f, 0.00762808f, 0.02651441f, 0.01882206f, -0.01329036f, 0.01854875f, -0.01001584f, -0.02202440f, 
    0.00154468f, -0.00065299f, 0.01060524f, 0.02207398f, -0.01100981f, -0.01360028f, -0.03097071f, 0.00138928f, 
    0.02305079f, 0.03827399f, -0.00061493f, 0.03119205f, -0.00095345f, -0.02974983f, 0.01274244f, 0.02226668f, 
    0.02438470f, 0.02128162f, -0.02179424f, 0.02983635f, 0.02066899f, -0.01538601f, 0.01915183f, 0.02493907f, 
    -0.03591814f, -0.01451006f, 0.00640732f, 0.01812909f, -0.01414171f, 0.01565995f, -0.01291033f, -0.01248500f, 
    0.02511578f, 0.00348934f, -0.01424106f, 0.01473556f, 0.03145271f, 0.02115331f, -0.02852402f, 0.02331467f, 
    0.02152210f, 0.02897413f, -0.02466228f, -0.01648640f, 0.00325530f, -0.03622938f, -0.01658137f, 0.02228371f, 
    0.00458687f, -0.03709921f, 0.01311792f, -0.01557873f, -0.00356507f, 0.02515882f, -0.00672194f, 0.00831318f, 
    0.00151722f, 0.01686690f, -0.02707053f, -0.02540806f, -0.03300843f, -0.02726437f, 0.03128044f, -0.00682529f, 
    0.03024010f, -0.01206020f, -0.01156472f, -0.03400681f, -0.02444554f, 0.02776302f, -0.03136566f, 0.02392315f, 
    0.02963856f, -0.00861728f, 0.03955857f, -0.02239508f, -0.00109381f, 0.02138730f, -0.00786069f, 0.01857779f, 
    -0.03867232f, -0.01215904f, -0.01639967f, 0.00633358f, -0.00596693f, -0.03655267f, 0.00711352f, -0.00254785f, 
    0.01280085f, -0.03574647f, -0.02469402f, 0.02997673f, 0.00581719f, -0.03160759f, 0.00421792f, -0.04403219f, 
    0.01033454f, 0.00034380f, -0.00690560f, 0.01718454f, 0.02107011f, -0.00104578f, 0.02047948f, 0.02079526f, 
    0.02313998f, -0.04272019f, 0.00985971f, -0.03820822f, 0.02740750f, -0.00952294f, -0.00385782f, 0.02373751f, 
    -0.01109091f, -0.03586508f, -0.00037507f, -0.04358864f, 0.00656371f, 0.02793849f, -0.02786725f, -0.01367827f, 
    -0.04099226f, -0.02107770f, -0.01820043f, -0.03714786f, -0.03541023f, 0.02810553f, -0.00508577f, -0.02307162f, 
    0.01811407f, -0.00285596f, 0.01933275f, -0.02570253f, -0.00582321f, -0.02989259f, -0.00913124f, -0.01936332f, 
    0.01493239f, -0.00985469f, 0.02274625f, -0.01484340f, -0.02137242f, 0.01727939f, -0.00025428f, -0.03590064f, 
    -0.02895145f, -0.00755450f, -0.00939191f, -0.01644804f, 0.01241540f, -0.02547497f, 0.01272525f, -0.00406513f, 
    -0.01676555f, 0.04471973f, 0.00340252f, -0.01278352f, -0.00186984f, 0.01464332f, -0.02750147f, -0.00218517f, 
    -0.01663716f, -0.03593367f, -0.01028159f, -0.00246036f, -0.01749240f, 0.02922232f, 0.01997455f, 0.01399401f, 
    0.00610364f, -0.02510397f, 0.00137940f, -0.01323531f, 0.00572609f, 0.01580747f, -0.02312576f, -0.02703765f, 
    -0.00263266f, 0.02489666f, 0.00920530f, 0.02273165f, -0.02148695f, 0.02633730f, 0.00132529f, 0.00230392f, 
    -0.02135141f, -0.03502646f, -0.00963709f, -0.03114415f, -0.00468697f, -0.02529933f, 0.01621526f, -0.00559319f, 
    0.00802753f, -0.01210550f, -0.01200868f, -0.00248749f, 0.02002120f, 0.01002304f, -0.03128112f, -0.01440654f, 
    0.02134552f, -0.00621397f, 0.00675173f, 0.01337763f, -0.03478124f, 0.02992967f, -0.01458354f, -0.01335847f, 
    -0.03842384f, -0.02522643f, -0.03779237f, -0.02273148f, -0.02021521f, -0.03256657f, 0.00569996f, 0.02801739f, 
    0.00010858f, 0.01862362f, -0.02074065f, -0.00707653f, 0.02529967f, 0.00123659f, -0.01460399f, -0.03541227f, 
    0.01712865f, -0.02752657f, 0.01311485f, 0.04090539f, 0.01366349f, -0.00839647f, -0.02258102f, 0.00819180f, 
    0.03491330f, 0.01603104f, 0.02330789f, -0.04664464f, 0.01924366f, -0.02918174f, -0.00744140f, -0.00411649f, 
    0.00298216f, 0.02973049f, -0.03237212f, 0.00104773f, 0.01041376f, 0.01720704f, 0.01597701f, 0.01576327f, 
    0.02172113f, -0.00366337f, -0.01836621f, -0.00435835f, -0.02245660f, -0.00812661f, -0.00125709f, 0.00351439f, 
    -0.02550336f, -0.03491038f, -0.02109403f, -0.00485458f, -0.03835980f, -0.04028135f, -0.01257591f, -0.01492639f, 
    0.02741240f, -0.00263304f, -0.02111041f, 0.01964054f, -0.02709585f, 0.00154090f, -0.01270879f, 0.02816765f, 
    -0.03481631f, 0.00618447f, -0.02307928f, -0.02666851f, 0.01906287f, 0.00188564f, 0.00917272f, -0.03250933f, 
    -0.00442933f, -0.01662360f, 0.01289206f, 0.02955482f, 0.02198112f, 0.01763579f, 0.02033623f, 0.02073980f, 
    -0.02498258f, 0.02693678f, 0.01523562f, -0.00861644f, 0.00867132f, 0.01364775f, 0.00464575f, -0.00165287f, 
    -0.01870382f, -0.01249897f, -0.00195112f, -0.03723805f, -0.00936200f, 0.02070940f, -0.01193497f, -0.03740729f, 
    -0.03081612f, 0.00852153f, -0.01040727f, -0.00312537f, 0.00740051f, -0.00546896f, -0.00105930f, 0.01720272f, 
    0.02274653f, 0.01393696f, 0.01359839f, -0.03126499f, 0.00597631f, -0.02423858f, 0.00834396f, -0.00859815f, 
    0.02131929f, -0.00185841f, 0.00915047f, -0.02892125f, -0.01057844f, 0.02075065f, -0.00001259f, 0.01842055f, 
    -0.01597164f, -0.01382204f, -0.02350769f, -0.03019557f, -0.02633073f, -0.01387262f, 0.00910795f, -0.01808457f, 
    -0.01622148f, 0.01313088f, -0.00259136f, -0.03514108f, -0.00151922f, -0.01685967f, 0.01357528f, -0.01391336f, 
    -0.01618342f, 0.01882321f, -0.00168573f, -0.02175472f, 0.02402546f, 0.00527365f, 0.00678677f, 0.02963583f, 
    -0.03968937f, 0.00646401f, 0.00382523f, 0.01159930f, -0.03348767f, 0.00777646f, 0.03486663f, -0.02244576f, 
    -0.02325513f, -0.01920068f, -0.02898685f, -0.03797077f, -0.00092678f, -0.00499333f, -0.00363893f, -0.00928165f, 
    0.01765718f, 0.02922941f, 0.00212042f, -0.02027481f, 0.03119983f, -0.03846557f, 0.01041081f, -0.01746260f, 
    0.00358605f, -0.01401134f, 0.02570090f, -0.00172373f, 0.00958769f, 0.00871459f, 0.00537631f, 0.03193235f, 
    -0.01927632f, 0.01002349f, -0.01947807f, -0.03601215f, -0.03228296f, -0.02100452f, 0.00503522f, 0.02305269f, 
    -0.29240185f, -0.10406958f, -0.11978719f, -0.35749373f, -0.02046897f, 0.09211604f, 0.01108880f, 0.00270221f, 
    0.12404880f, -0.02306338f, 0.00111246f, -0.09500943f, -0.05756190f, -0.00720049f, 0.19939618f, 0.22937141f, 
    -0.14181937f, -0.05666120f, 0.08693385f, -0.00744060f, 0.03983347f, -0.02694081f, 0.06378264f, -0.07574568f, 
    -0.10682253f, 0.05446238f, -0.03726033f, -0.01999853f, 0.03709406f, 0.05579944f, -0.02575060f, -0.07521977f, 
    -0.07624249f, -0.05223662f, 0.00597064f, 0.03311810f, -0.17465369f, 0.18413593f, -0.06103514f, 0.08335592f, 
    0.01410530f, -0.00877315f, 0.09266312f, 0.05006610f, -0.01099736f, -0.04697801f, 0.08408782f, 0.06037052f, 
    0.13694134f, 0.01693584f, -0.04738788f, 0.27376577f, -0.02900907f, 0.02575486f, -0.03281225f, -0.08326650f, 
    -0.17213759f, 0.11302885f, 0.11751587f, -0.00021640f, -0.01529575f, 0.22350682f, 0.12388819f, 0.36134994f, 
    -0.04745244f, -0.04548404f, 0.00022912f, 0.16608849f, -0.03330619f, 0.09174331f, 0.02304015f, 0.07254048f, 
    0.06441254f, 0.01311423f, -0.06936700f, -0.10424896f, 0.02195465f, 0.21302773f, -0.07205208f, -0.12176334f, 
    -0.03189428f, 0.07097898f, 0.07261497f, 0.21641178f, 0.21164492f, -0.24221157f, 0.24545148f, 0.08470885f, 
    -0.10326681f, 0.14955343f, 0.02111559f, -0.01939065f, -0.00710826f, -0.09671905f, 0.00649932f, 0.00188717f, 
    0.21493563f, 0.04376338f, 0.03700246f, -0.24126476f, -0.09889859f, 0.08834579f, 0.06196524f, -0.04592740f, 
    0.05425163f, 0.05653450f, -0.00411388f, -0.10183519f, 0.84519649f, -0.19749698f, 0.30523196f, -0.10158195f, 
    -0.11298986f, 0.03503660f, -0.01088150f, 0.00854884f, -0.06014664f, 0.07090392f, -0.03004709f, 0.14852293f, 
    -0.12978494f, 0.06988751f, 0.13244602f, -0.07426062f, -0.05833959f, 0.01499712f, -0.10276061f, -0.09588759f, 
    -0.00405378f, -0.02520484f, 0.09053560f, 0.13234481f, 0.18944044f, 0.05435081f, 0.13403073f, 0.10786117f, 
    0.01014165f, -0.02256209f, -0.12233730f, 0.04018825f, -0.06089946f, 0.02505340f, 0.12626831f, 0.14914240f, 
    -0.21631664f, 0.12474485f, 0.16973199f, -0.06577179f, 0.05078987f, -0.09531681f, 0.05531275f, 0.14411975f, 
    -0.02501786f, 0.02677259f, 0.03801831f, 0.16743572f, 0.15029939f, -0.05786134f, -0.13008177f, 0.09199657f, 
    0.07175481f, 0.02027933f, -0.07509252f, 0.02923561f, -0.12196700f, -0.08756007f, 0.14283954f, -0.06580537f, 
    0.24317822f, 0.20683615f, -0.03372290f, -0.14352782f, 0.10011843f, 0.01580560f, -0.01199387f, 0.02182351f, 
    -0.00818445f, 0.06538123f, -0.00015545f, 0.08424052f, 0.20819893f, 0.19083166f, 0.05084076f, 0.10881247f, 
    0.08160587f, 0.06067938f, 0.05202532f, 0.07324524f, -0.08492009f, -0.08181052f, 0.06029470f, -0.08832154f, 
    0.09999608f, 0.14383817f, -0.09728850f, 0.03246171f, -0.10884448f, 0.09106714f, -0.01401973f, -0.00227176f, 
    -0.02870844f, 0.09942420f, -0.07499492f, -0.00769746f, -0.28998426f, 0.19006470f, -0.14773627f, -0.32899272f, 
    0.07868013f, 0.05742925f, 0.02350598f, -0.01455067f, -0.00698859f, 0.03582825f, 0.13681926f, -0.09543524f, 
    0.03163784f, -0.12563847f, -0.06500588f, -0.18775044f, 0.09987792f, -0.00990727f, 0.00339663f, -0.06232035f, 
    -0.04556281f, -0.05247046f, -0.01294255f, 0.05122716f, 0.03309049f, 0.10939666f, 0.16852030f, 0.10247550f, 
    0.00874358f, 0.06927273f, -0.04996967f, 0.06433102f, -0.01353809f, 0.06089788f, 0.03686111f, 0.03061838f, 
    -0.17882574f, 0.04989043f, -0.02504471f, 0.05072390f, 0.11141811f, 0.02813349f, 0.10443603f, 0.00909013f, 
    0.06165666f, 0.09027449f, -0.00595110f, -0.04682180f, 0.01417547f, 0.10161677f, 0.09603439f, 0.12685357f, 
    0.00534434f, 0.04712925f, -0.05479105f, -0.00864181f, 0.00340375f, 0.03428588f, 0.11352793f, 0.01748001f, 
    0.11203053f, -0.01020143f, -0.16141506f, -0.10779908f, 0.00085368f, -0.07118019f, -0.11596721f, -0.10222284f, 
    0.02086108f, -0.01680011f, -0.06911825f, -0.17712995f, -0.00891891f, 0.15875307f, 0.00235306f, 0.19183639f, 
    -0.04507416f, -0.01306961f, 0.12311245f, 0.22432330f, 0.04581083f, -0.01707358f, 0.02118047f, 0.02688151f, 
    0.11158306f, -0.13132989f, -0.09954701f, 0.02131099f, -0.00861338f, -0.08064403f, -0.02011751f, -0.10800649f, 
    0.04392229f, -0.06498328f, -0.00589714f, -0.15192159f, -0.18063603f, -0.03266000f, -0.12679690f, -0.10521170f, 
    -0.17374568f, -0.03174745f, -0.04512640f, -0.00426690f, 0.09384196f, -0.10732927f, -0.05530933f, 0.06918913f, 
    0.08325493f, 0.16438133f, -0.26090378f, 0.05639976f, 0.01627931f, -0.03594596f, -0.03351424f, 0.09741075f, 
    0.02297584f, -0.04286070f, -0.00407706f, -0.00286186f, 0.13481498f, -0.00021857f, 0.25034425f, 0.10372508f, 
    -0.11287072f, 0.04606787f, 0.01894252f, 0.02903150f, -0.16785146f, -0.02038527f, 0.06945527f, -0.09626780f, 
    -0.12601434f, 0.20637770f, -0.08164519f, 0.05033702f, 0.01915471f, -0.10883205f, 0.06490622f, 0.04597515f, 
    -0.01572599f, 0.07521050f, 0.21149687f, 0.05965608f, -0.03894605f, 0.19613563f, 0.04604879f, 0.08914841f, 
    -0.00635573f, 0.11929774f, 0.02180961f, 0.02259126f, -0.05632735f, 0.07840063f, -0.08739593f, -0.02880158f, 
    0.47807190f, -0.26963216f, 0.08161785f, -0.04748347f, -0.15147555f, 0.08138981f, 0.07309727f, 0.04822968f, 
    0.06255136f, 0.03388765f, 0.07188135f, 0.07010302f, 0.27344847f, 0.00775137f, 0.32577869f, 0.17200965f, 
    -0.08309184f, -0.05847963f, 0.17350756f, -0.12676297f, 0.02176049f, -0.05842308f, -0.01882827f, 0.18247423f, 
    -0.20649298f, 0.00948747f, -0.15650560f, -0.25011742f, -0.06580759f, -0.07136930f, -0.07267764f, 0.04497276f, 
    0.00767828f, -0.08230296f, 0.02240225f, 0.00807986f, 0.13271527f, -0.19475974f, -0.11070848f, -0.21922460f, 
    -0.02089191f, -0.01101445f, 0.04368885f, -0.07923739f, -0.00955005f, 0.03820926f, 0.05301655f, -0.05547509f, 
    0.13092260f, -0.03133855f, -0.18760541f, -0.23334996f, 0.08196539f, 0.13143751f, -0.02831247f, -0.09793432f, 
    0.01578100f, -0.00046997f, -0.06538304f, -0.12929663f, -0.00358983f, -0.04130746f, -0.01178319f, -0.12113965f, 
    0.05985754f, -0.00246912f, 0.09030400f, -0.05748861f, 0.04184438f, -0.07879594f, -0.05798760f, -0.07251901f, 
    -0.28419864f, -0.06786485f, -0.01786014f, -0.16455545f, -0.05743504f, 0.05550721f, 0.01293280f, -0.08735993f, 
    -0.15985753f, -0.02783261f, -0.17935954f, 0.10132253f, 0.32356650f, -0.18503162f, 0.03718682f, -0.29256126f, 
    0.01837412f, 0.09882072f, 0.05254318f, 0.04268174f, 0.06388520f, 0.08263364f, 0.08463984f, 0.07743493f, 
    -0.30080828f, -0.12855929f, 0.02101247f, -0.04241201f, 0.06421536f, -0.15072267f, -0.01831104f, -0.06928109f, 
    -0.03786577f, 0.02656768f, -0.02960327f, -0.05645390f, 0.22178285f, 0.02281553f, 0.17226139f, 0.12794207f, 
    -0.12154563f, 0.02109629f, -0.02814407f, -0.04297461f, 0.04358878f, 0.02182841f, 0.11965374f, 0.02137831f, 
    0.20270066f, -0.01970866f, -0.13904223f, 0.20077090f, 0.03306914f, 0.02078149f, -0.10301146f, 0.05054467f, 
    0.07132336f, 0.06705651f, 0.03453490f, 0.12441283f, -0.12740703f, 0.04909415f, 0.26785737f, -0.12586011f, 
    -0.14755893f, -0.08276046f, 0.13934241f, 0.02465684f, -0.10748525f, -0.01524843f, -0.06012116f, 0.02067305f, 
    -0.36703146f, -0.04792715f, -0.13848709f, -0.03584379f, 0.13138805f, 0.00020980f, 0.01357823f, -0.00864292f, 
    -0.03715060f, 0.16440159f, 0.06876337f, -0.00226384f, 0.10065590f, 0.11532544f, -0.02595228f, 0.15553613f, 
    0.10200725f, 0.05043558f, 0.00897006f, 0.03060715f, -0.16700831f, 0.00761196f, -0.05541852f, 0.02002610f, 
    -0.05371326f, 0.08294538f, 0.16552469f, -0.34727329f, -0.00829992f, 0.05533826f, 0.05748724f, 0.13498040f, 
    -0.01548830f, -0.00811403f, 0.14962727f, -0.04662094f, 0.13620013f, 0.14469989f, -0.16576567f, -0.02686980f, 
    0.09299580f, 0.05428844f, 0.13616063f, -0.00698184f, -0.13356175f, 0.11395575f, -0.13180919f, -0.04126821f, 
    0.22677718f, 0.01664374f, 0.01622305f, 0.16034842f, 0.06838027f, 0.00399356f, 0.03743654f, 0.04506410f, 
    -0.04744158f, -0.12452261f, -0.06002624f, 0.07541884f, 0.72097379f, -0.05671569f, 0.08980450f, 0.06400006f, 
    -0.06551842f, 0.06737633f, 0.05307250f, 0.02804780f, -0.04290956f, 0.11764064f, -0.02643728f, -0.06174945f, 
    0.10383668f, -0.08144455f, 0.00020754f, -0.06350056f, 0.07013202f, 0.13760044f, -0.04250219f, -0.05694670f, 
    -0.00317278f, 0.06969723f, -0.15573396f, -0.06651935f, 0.38518959f, -0.03134808f, 0.27058613f, -0.00220734f, 
    -0.04995938f, 0.04965747f, 0.04914415f, -0.03055666f, 0.00394861f, -0.00033405f, 0.06203974f, -0.01756787f, 
    0.62869239f, -0.25791422f, 0.05317561f, 0.05708231f, -0.04925875f, -0.15663557f, -0.06231024f, 0.06764071f, 
    0.05336816f, 0.08652516f, 0.08142268f, 0.14359321f, 0.27001202f, -0.02569969f, -0.19196311f, -0.12016185f, 
    0.01478489f, -0.03324780f, 0.09019232f, -0.02590479f, -0.08140801f, 0.00252092f, -0.03718089f, -0.06027764f, 
    -0.13945723f, 0.14015745f, -0.22162327f, -0.15130764f, 0.13109669f, 0.02099420f, -0.09544976f, -0.08906849f, 
    -0.02785236f, 0.10207830f, 0.04629381f, 0.06393994f, -0.01528355f, 0.04006903f, 0.04706113f, 0.21229595f, 
    0.05306106f, -0.12687331f, 0.00372790f, -0.06136997f, 0.04542987f, -0.14937449f, 0.00316048f, -0.07232331f, 
    0.01698328f, -0.01063979f, 0.00466603f, 0.05703435f, 0.14612930f, -0.05728111f, -0.01052736f, -0.01543525f, 
    -0.05693259f, -0.02937077f, -0.12480521f, -0.17321576f, -0.03231221f, 0.05221251f, 0.05172065f, -0.00493942f, 
    0.00135076f, -0.02253348f, -0.07658083f, -0.02667850f, 0.02928940f, 0.09516532f, 0.07401330f, 0.05091311f, 
    -0.02404210f, 0.06619640f, -0.05735600f, -0.13926044f, -0.00492880f, 0.00760391f, -0.08158726f, -0.00146873f, 
    -0.07928274f, 0.00452330f, -0.06840368f, -0.14781342f, 0.03127271f, -0.02692376f, 0.08895332f, 0.09927260f, 
    0.01847342f, 0.04451878f, 0.03130922f, 0.16158415f, 0.09160998f, 0.05770406f, 0.00733522f, 0.03184665f, 
    0.23126039f, -0.29416746f, 0.01583433f, 0.24522951f, -0.11245300f, -0.03604231f, -0.04394476f, -0.05784587f, 
    0.02307363f, -0.07326951f, 0.03236854f, -0.21457122f, -0.18700400f, -0.10755698f, -0.17102474f, -0.28057164f, 
    0.16812740f, 0.02015905f, 0.09148341f, -0.04949181f, -0.00310549f, 0.02119668f, -0.05687616f, 0.02001598f, 
    -0.09694026f, 0.06974860f, 0.05892871f, 0.18188423f, 0.19586484f, 0.07920273f, -0.02007239f, 0.02078159f, 
    -0.14374486f, 0.07364760f, -0.00745552f, -0.01074079f, -0.23180945f, 0.19829179f, -0.11605197f, -0.27835345f, 
    0.05354327f, 0.05808932f, 0.00544821f, 0.07542332f, 0.03226515f, -0.04712872f, 0.07811540f, -0.12860149f, 
    0.06018603f, 0.21494327f, 0.16319239f, 0.09027265f, -0.10003067f, 0.04296981f, -0.03858340f, 0.12830785f, 
    -0.04333834f, 0.12702037f, 0.04383710f, 0.08823497f, 0.14259230f, -0.10691586f, 0.02259468f, 0.11272488f, 
    0.02341734f, 0.01514977f, 0.04594988f, -0.10899152f, 0.04456882f, 0.10399250f, -0.06509229f, -0.08400556f, 
    -0.03207411f, -0.00910831f, 0.00381820f, -0.02179219f, -0.03333906f, 0.01272746f, -0.00459427f, 0.02657024f, 
    -0.01708402f, -0.03731318f, -0.03136549f, -0.01320025f, 0.01072957f, -0.03555923f, -0.03696292f, -0.00271821f, 
    0.00927807f, 0.02097241f, -0.03103185f, 0.01154070f, -0.02051826f, 0.01253529f, 0.01246620f, -0.03133944f, 
    -0.01488782f, -0.02067873f, -0.01307835f, 0.01682796f, -0.00617907f, 0.01801855f, 0.01921938f, 0.01996026f, 
    -0.03978444f, 0.01893419f, 0.02394977f, -0.03884559f, -0.03482523f, 0.02950460f, -0.03764253f, 0.01179516f, 
    -0.04158197f, -0.01914959f, -0.01935868f, -0.01336689f, 0.03073847f, -0.03335577f, 0.01334331f, -0.03990833f, 
    -0.02647337f, 0.00003199f, -0.02988339f, 0.04199654f, -0.03690396f, -0.00483415f, 0.01541997f, -0.04062915f, 
    0.01020188f, 0.01522026f, -0.01001328f, 0.03643318f, -0.02823858f, -0.03586917f, -0.01920436f, -0.01302947f, 
    0.00586175f, 0.00273066f, -0.02802766f, -0.02672548f, -0.00080532f, -0.00463308f, -0.03292132f, -0.04089736f, 
    -0.02109034f, 0.02672451f, -0.03942930f, 0.01094732f, -0.01063121f, 0.00034767f, -0.02065053f, 0.01625680f, 
    -0.02007716f, 0.03692532f, 0.01192911f, -0.02062613f, 0.00680415f, -0.00475407f, 0.00622763f, 0.01137183f, 
    -0.01477535f, -0.00173992f, -0.00304545f, -0.00034852f, 0.00171925f, -0.03490310f, 0.03003846f, 0.02296672f, 
    0.02400022f, -0.01352086f, -0.02488842f, -0.03434348f, -0.02817404f, 0.02871947f, -0.00099672f, 0.00505259f, 
    -0.02241435f, -0.00300874f, -0.04132415f, -0.03707446f, 0.02358888f, 0.02746463f, 0.02981924f, -0.02601012f, 
    0.01137985f, -0.00459739f, -0.01171965f, -0.02154524f, 0.02412450f, 0.02853360f, 0.00164304f, 0.01346069f, 
    0.01808237f, 0.01251232f, 0.02701918f, 0.02535589f, -0.02151285f, 0.00176735f, -0.03516868f, 0.00780574f, 
    0.02567972f, 0.01523401f, -0.02517214f, 0.02421439f, -0.01426945f, -0.02170081f, -0.01310977f, -0.01531619f, 
    -0.02122137f, 0.00116232f, -0.01610648f, 0.02860110f, 0.01690115f, -0.00864642f, -0.02170195f, -0.01126420f, 
    -0.00152211f, 0.02576407f, -0.03363879f, -0.00232313f, -0.03021957f, 0.01147749f, 0.00939292f, -0.02352765f, 
    -0.00702704f, -0.03758639f, -0.02734013f, 0.00142889f, -0.02017136f, 0.02783220f, -0.02089345f, -0.03562763f, 
    -0.03491065f, -0.00041866f, -0.02486184f, -0.03608414f, -0.03482206f, -0.00831896f, 0.02308006f, 0.02181709f, 
    0.02391393f, 0.02380992f, -0.00571747f, -0.04063318f, 0.00841967f, -0.02808905f, -0.01638957f, -0.00234224f, 
    0.00622217f, 0.00444502f, 0.01098055f, -0.02361643f, -0.01340942f, 0.01652035f, -0.04109676f, -0.00867772f, 
    -0.04273585f, 0.00116730f, 0.02156956f, 0.02457123f, 0.01998128f, -0.00720132f, -0.04106720f, -0.00645093f, 
    -0.03278289f, -0.02963714f, -0.01036609f, -0.03843048f, 0.02481720f, 0.01610222f, 0.01302814f, 0.00025711f, 
    0.01849213f, -0.02174579f, 0.02568224f, 0.02295453f, -0.02663765f, -0.03492615f, 0.00448403f, -0.00790789f, 
    0.00177961f, -0.00882461f, -0.00665488f, -0.03658777f, 0.00725840f, -0.02497645f, 0.02253599f, 0.00958949f, 
    0.00226029f, -0.00895943f, -0.01508127f, 0.00914032f, -0.02676334f, -0.02612874f, -0.03458246f, -0.03727305f, 
    -0.02191871f, -0.02502517f, -0.00944927f, -0.00915872f, 0.02202065f, -0.01419116f, 0.00286904f, -0.01805269f, 
    0.00334242f, -0.01727231f, -0.03901894f, 0.00790846f, 0.00686661f, -0.02997118f, -0.00310798f, 0.00464943f, 
    0.00908153f, 0.00969025f, -0.00868623f, 0.03788929f, 0.01567370f, 0.02704044f, 0.00047481f, -0.03994207f, 
    0.01778108f, 0.00967021f, 0.00522760f, -0.00211250f, 0.00223700f, -0.01959620f, -0.03393292f, 0.02737515f, 
    -0.00163382f, -0.00421658f, -0.02726642f, -0.04156384f, -0.01957755f, 0.02173516f, -0.02457719f, -0.01264759f, 
    0.02616672f, 0.00387971f, -0.01094310f, -0.00230266f, 0.00144345f, 0.02871596f, -0.02788018f, -0.02173141f, 
    -0.03507982f, 0.02356218f, -0.00017807f, -0.02469014f, -0.02123905f, -0.03258307f, 0.02344136f, 0.00239535f, 
    -0.03371021f, -0.03659135f, -0.02422392f, -0.02944268f, 0.00919524f, -0.01108132f, 0.00886583f, 0.02836029f, 
    -0.03785864f, -0.02927579f, -0.02487499f, 0.02017736f, 0.01030550f, 0.00103086f, 0.00945440f, -0.02107760f, 
    -0.03632291f, 0.02783722f, -0.00387517f, -0.03848724f, 0.02141835f, -0.03517571f, -0.04261044f, 0.02274399f, 
    -0.01657133f, -0.02817302f, -0.01254619f, 0.00597729f, 0.01512590f, 0.00986709f, -0.02523683f, 0.02663909f, 
    -0.02641475f, -0.04197660f, -0.04132078f, 0.00565288f, 0.02519174f, -0.03588346f, -0.00364782f, -0.02277365f, 
    0.02961712f, -0.02677863f, 0.00924654f, 0.00317706f, 0.01381413f, -0.00361952f, -0.00014482f, 0.01542895f, 
    0.01694173f, -0.01136351f, -0.04119124f, 0.01185151f, -0.03416136f, 0.00743665f, -0.00692459f, -0.02903736f, 
    -0.00164933f, 0.00393575f, 0.02276915f, -0.03475292f, 0.01138032f, -0.03832774f, -0.03522210f, -0.00290719f, 
    0.01685589f, -0.02604936f, 0.00739349f, -0.01686610f, 0.00457909f, 0.01034498f, -0.03783396f, -0.00388470f, 
    -0.01297781f, 0.00756459f, -0.01104255f, 0.01033139f, -0.00022413f, -0.03169562f, -0.01301856f, 0.02760129f, 
    -0.02453106f, -0.02457848f, 0.00803290f, 0.02571328f, 0.01111003f, 0.01454434f, -0.02121148f, -0.00707515f, 
    0.02409606f, 0.01986957f, -0.00550915f, -0.00753783f, 0.02547640f, -0.01264821f, -0.02954665f, 0.00618652f, 
    0.01515744f, -0.02722741f, 0.00657547f, -0.03701118f, 0.01711819f, -0.01461732f, 0.00097321f, 0.02094926f, 
    0.02783461f, 0.02996871f, 0.00962824f, 0.02560122f, -0.02675562f, -0.00301607f, -0.02997519f, 0.01209791f, 
    -0.03833047f, 0.02639184f, 0.00735752f, 0.00262472f, 0.01876899f, 0.00328233f, 0.01109498f, 0.00059950f, 
    -0.00742883f, -0.00897442f, -0.01146398f, -0.01773322f, -0.00903642f, -0.00139497f, -0.00768844f, 0.02394309f, 
    -0.02161445f, -0.03208111f, -0.00482149f, 0.01822384f, 0.00752240f, -0.03309867f, -0.01750894f, -0.00710900f, 
    0.01309732f, -0.00592916f, -0.00011723f, -0.03709307f, -0.01707033f, -0.03807979f, -0.02249688f, -0.01621750f, 
    0.00070327f, -0.02690697f, 0.00728445f, 0.00322203f, -0.01760844f, 0.00959077f, -0.01088924f, -0.00416149f, 
    0.00995261f, -0.00801733f, 0.02323278f, 0.02037748f, 0.01042979f, -0.03072749f, 0.00650165f, -0.01340327f, 
    0.02499093f, -0.00698234f, 0.00659293f, -0.03502087f, -0.02518988f, 0.00388290f, -0.01544592f, -0.01080340f, 
    -0.03048287f, 0.02378631f, 0.01951890f, 0.00178563f, 0.00807555f, -0.00926163f, -0.00574148f, -0.01850174f, 
    -0.00574203f, -0.01171337f, -0.03608919f, 0.01269270f, 0.02315305f, 0.01514335f, -0.00640616f, 0.02425001f, 
    -0.00913571f, -0.03866975f, -0.00578004f, 0.01741096f, 0.03005399f, 0.02099995f, -0.01695219f, 0.04098225f, 
    -0.02218926f, -0.04276376f, -0.02013362f, 0.01113305f, 0.01018638f, 0.00211829f, 0.03208674f, 0.02425301f, 
    -0.00656172f, 0.01187683f, -0.00909104f, -0.02827554f, 0.00598769f, 0.02462934f, -0.01417402f, -0.04115573f, 
    -0.03666152f, 0.01568933f, -0.03988818f, -0.02576204f, -0.00867759f, 0.00556421f, 0.01744449f, 0.02897804f, 
    -0.00626306f, -0.03539892f, 0.01702142f, -0.02615577f, 0.02286284f, -0.01641669f, 0.00175098f, -0.02692833f, 
    0.00442441f, 0.01538549f, -0.04256620f, 0.02414301f, -0.00977112f, -0.02021329f, -0.02277405f, -0.02588741f, 
    0.00141808f, 0.02500219f, -0.02990240f, -0.00746124f, -0.00115496f, -0.01678471f, 0.01336710f, 0.01801719f, 
    -0.01294554f, -0.01920197f, -0.03687821f, 0.00112507f, 0.01065924f, -0.02235218f, 0.00349598f, -0.01007220f, 
    -0.01986570f, -0.02426443f, -0.01419772f, -0.02393098f, -0.00440509f, 0.01524551f, -0.01642011f, -0.00285154f, 
    -0.00618182f, -0.01880738f, 0.01230521f, -0.00990399f, -0.04055094f, -0.02255465f, 0.00745089f, -0.02261626f, 
    -0.01771355f, 0.02241840f, -0.02267758f, -0.03418173f, 0.01903568f, 0.02685362f, 0.01174923f, -0.03936305f, 
    0.01348542f, -0.03968598f, 0.02627834f, -0.01303377f, -0.02958727f, -0.02896157f, 0.02028351f, -0.03138557f, 
    -0.02373413f, 0.00006361f, 0.00957396f, -0.00536829f, -0.02099228f, -0.03071069f, -0.00223262f, -0.03730619f, 
    -0.00128403f, -0.02787094f, -0.00896307f, 0.01607536f, 0.01027111f, -0.01180471f, 0.02579207f, -0.00909407f, 
    -0.03532838f, -0.00415882f, -0.02482685f, -0.00489985f, 0.02729722f, 0.02584359f, -0.01864785f, 0.02721079f, 
    -0.02771110f, 0.00077113f, -0.01544935f, -0.03799700f, 0.02224442f, -0.00382739f, 0.02137548f, 0.00942045f, 
    -0.02682832f, 0.00257196f, -0.01419620f, -0.00228635f, -0.00780179f, 0.02496164f, 0.01980298f, -0.02526692f, 
    -0.00084833f, -0.01669154f, -0.02255597f, 0.01807126f, 0.00575283f, 0.00421337f, -0.00499756f, 0.01574255f, 
    0.00059109f, -0.04023640f, -0.01636047f, -0.02591135f, -0.03560954f, -0.00314512f, -0.02313939f, -0.00649218f, 
    0.02245833f, -0.03583826f, 0.00223171f, -0.04229994f, -0.03401418f, 0.01072550f, -0.03740491f, 0.02065071f, 
    0.02717513f, -0.03611687f, -0.01564731f, 0.02765737f, -0.03830777f, -0.02592163f, -0.00099443f, 0.01661498f, 
    0.01987401f, 0.01962706f, 0.02338153f, -0.01561349f, -0.03858941f, -0.00720302f, 0.00792635f, -0.03373393f, 
    0.02316759f, 0.01994410f, 0.01773088f, 0.00333451f, -0.00647750f, 0.00740237f, -0.00131977f, 0.02357132f, 
    -0.04211834f, -0.04196564f, -0.01449484f, 0.00132250f, -0.02228335f, -0.01031207f, -0.02640825f, -0.03843753f, 
    -0.02846903f, -0.01588896f, -0.03313813f, 0.00437516f, -0.02049650f, -0.00144348f, -0.01370252f, 0.01584257f, 
    -0.03330273f, -0.00983825f, -0.02463184f, -0.03106335f, 0.01674797f, 0.00180613f, -0.01725542f, 0.02074522f, 
    -0.00917513f, -0.00731523f, -0.04175495f, -0.03575792f, -0.04093080f, -0.00577814f, 0.00912453f, -0.01399555f, 
    0.01017865f, 0.01777999f, -0.03483418f, 0.00157141f, 0.00920823f, 0.01070458f, -0.00247225f, 0.01663698f, 
    0.00182188f, 0.02268057f, 0.01098038f, -0.01217856f, 0.01931445f, -0.01574451f, 0.00696153f, 0.01853945f, 
    -0.02763165f, 0.01995355f, -0.02070314f, 0.00104171f, -0.02590968f, 0.00789464f, -0.02121202f, 0.02164260f, 
    -0.00770885f, -0.00955679f, -0.01751296f, -0.00365590f, -0.02659860f, 0.02937339f, -0.01050892f, 0.00950196f, 
    0.01399848f, -0.02247224f, -0.03026804f, -0.00039061f, -0.02457715f, 0.00344687f, 0.02191924f, -0.01717506f, 
    0.01990987f, 0.02116913f, -0.01607089f, -0.00946894f, -0.03994684f, -0.02156542f, -0.02728244f, -0.00435480f, 
    -0.03407927f, 0.02547758f, -0.01896712f, -0.02760997f, -0.03633986f, 0.02669177f, -0.04156976f, 0.01274656f, 
    0.03225830f, 0.01149733f, 0.02733165f, -0.02841367f, -0.02337431f, 0.01001282f, -0.02674248f, 0.00523438f, 
    0.00333907f, -0.01406966f, 0.00193969f, -0.00180099f, 0.02580462f, -0.00759873f, 0.00821533f, -0.02341276f, 
    -0.00223948f, 0.01518201f, -0.02528575f, -0.03461424f, 0.01296527f, -0.03158145f, 0.01740064f, -0.00258702f, 
    0.01553405f, 0.01098044f, -0.02615932f, -0.03200328f, -0.02067844f, 0.00200303f, -0.00232053f, -0.00529946f, 
    0.33432749f, -0.00306189f, -0.07790443f, 0.25577247f, -0.05462943f, 0.16891608f, -0.14112143f, 0.11400195f, 
    -0.05656481f, -0.06804644f, 0.01750522f, -0.08631442f, -0.19136329f, 0.09598696f, -0.02078543f, 0.24561925f, 
    -0.01212299f, 0.02185139f, 0.02927438f, 0.08975338f, -0.02436847f, 0.04060883f, 0.06046212f, 0.01346267f, 
    0.17680070f, -0.05991568f, 0.11644544f, -0.01128103f, 0.14252330f, 0.13082185f, 0.04444412f, 0.01647294f, 
    -0.07208879f, -0.11568147f, -0.13231775f, -0.02879465f, 0.29078031f, 0.13326435f, -0.06630319f, -0.17651512f, 
    0.00406162f, -0.03969600f, -0.10520905f, -0.01954660f, 0.05322371f, 0.08880430f, 0.01894299f, -0.02776784f, 
    -0.10093506f, 0.21944490f, 0.20441401f, -0.10495059f, 0.11794623f, -0.03431270f, 0.06409922f, 0.08047147f, 
    0.00072958f, -0.29319718f, -0.08197968f, -0.30540535f, -0.09708024f, -0.18049379f, -0.06497132f, 0.09407964f, 
    -0.04222028f, 0.09236918f, 0.06191967f, -0.12880723f, 0.13561967f, 0.13872281f, -0.09143209f, -0.07880592f, 
    -0.14357616f, 0.03402392f, 0.02431735f, -0.26493466f, 0.12907688f, -0.05906318f, 0.02980958f, 0.05826650f, 
    0.14596909f, 0.03629407f, 0.05222636f, 0.05709448f, 0.03939448f, -0.05234551f, 0.09778612f, 0.04093273f, 
    -0.03478368f, -0.07981440f, 0.03184786f, 0.06189696f, 0.07634384f, 0.04466647f, 0.13504754f, 0.04491943f, 
    -0.20012827f, -0.06707615f, -0.11636350f, 0.18273173f, -0.07507590f, -0.05186023f, 0.02910481f, -0.07475025f, 
    -0.09022205f, -0.15834203f, -0.11398914f, -0.03926548f, 0.05679302f, 0.07637692f, 0.08375937f, -0.10961797f, 
    0.12095144f, 0.01345017f, 0.15760057f, -0.09832614f, 0.01415578f, 0.07850077f, -0.05960387f, -0.00611467f, 
    -0.15007348f, 0.06264437f, -0.04586478f, 0.24805838f, 0.07161292f, 0.00252397f, 0.14061980f, 0.03312337f, 
    -0.01281740f, -0.04869976f, 0.17761627f, 0.00381332f, -0.27985248f, 0.02260303f, -0.14681159f, -0.18721269f, 
    0.11080352f, -0.09776723f, 0.04901973f, 0.03829335f, 0.01708806f, 0.03235589f, 0.11154018f, -0.05335240f, 
    0.23708473f, 0.25432196f, -0.07668890f, 0.08064166f, -0.10063431f, 0.01994683f, -0.02529852f, -0.06280621f, 
    -0.01691556f, 0.20109430f, -0.00228794f, -0.08362515f, -0.07824885f, -0.02704686f, 0.07133912f, 0.15279464f, 
    -0.05088216f, -0.09506698f, 0.14915347f, -0.03455913f, -0.03227324f, -0.06174835f, -0.13709188f, -0.15293351f, 
    0.07448363f, -0.02135156f, 0.09109576f, 0.32913196f, -0.04859604f, 0.00515485f, -0.13840619f, 0.02132312f, 
    -0.04935117f, 0.20118542f, -0.05448333f, 0.01605715f, -0.28230691f, 0.34524003f, 0.04791778f, -0.10982925f, 
    0.00896432f, 0.04706618f, 0.19396366f, -0.06270953f, 0.02283326f, 0.00619583f, 0.04673648f, -0.04466955f, 
    0.26559696f, -0.20145725f, -0.08306398f, 0.40020946f, -0.02693074f, 0.02796961f, -0.00169471f, -0.08763005f, 
    -0.08492386f, -0.11920079f, 0.16722851f, 0.08235613f, -0.00928672f, -0.05161493f, -0.10431105f, 0.20098962f, 
    0.00373430f, 0.04674342f, -0.18785031f, 0.01674906f, 0.11131100f, -0.02155307f, 0.04914422f, -0.00717004f, 
    -0.02638301f, -0.05870423f, -0.04204272f, 0.17511545f, -0.13288504f, 0.06065750f, -0.01008971f, 0.04142690f, 
    -0.01093452f, 0.05371330f, 0.00245676f, 0.09864562f, -0.18632644f, 0.07626171f, -0.07984728f, -0.01621162f, 
    -0.05944904f, 0.02038939f, -0.01220903f, 0.00180376f, -0.02167102f, 0.10245325f, 0.03802479f, -0.01180220f, 
    0.25355318f, -0.00445122f, -0.15171516f, -0.29008231f, 0.15045467f, 0.02236203f, -0.00497108f, -0.05975400f, 
    -0.07778196f, -0.11552568f, -0.03532871f, -0.11749831f, 0.08001489f, 0.03436445f, -0.12140460f, -0.19751585f, 
    0.04453853f, -0.00191091f, -0.03493951f, 0.00344600f, 0.13827135f, 0.01780297f, 0.08006625f, 0.03626730f, 
    0.03199467f, -0.13891338f, -0.03764864f, 0.06882604f, 0.10821681f, -0.03371125f, 0.10718799f, 0.01266933f, 
    0.06794713f, 0.15548158f, -0.18590744f, 0.10062270f, -0.10386764f, 0.00098865f, -0.09245421f, 0.17871183f, 
    -0.01923982f, 0.06695881f, -0.10316574f, 0.02509879f, 0.01787857f, -0.09346905f, -0.00373688f, -0.09142177f, 
    0.07573798f, -0.09356889f, 0.23627067f, -0.11165484f, -0.02431083f, 0.09102486f, 0.06471477f, 0.03345426f, 
    0.00021160f, -0.08742861f, -0.12140239f, -0.08275211f, -0.03161651f, 0.49651212f, 0.05333861f, 0.12725896f, 
    0.14345640f, -0.01551343f, -0.03186025f, 0.07471632f, -0.05223248f, -0.08368520f, 0.02124233f, -0.00376852f, 
    0.02940440f, 0.19128959f, -0.08668701f, 0.42895424f, 0.13635048f, 0.00710151f, 0.00252316f, -0.11231770f, 
    0.08479251f, 0.14159143f, -0.04328934f, -0.04220794f, -0.23487407f, -0.04222300f, -0.08792917f, -0.03564884f, 
    0.04007982f, -0.02407592f, -0.07024378f, -0.16369437f, 0.02654043f, -0.11513664f, -0.03589108f, -0.13408203f, 
    0.25874883f, 0.09365776f, 0.01367404f, 0.46970820f, 0.08599108f, 0.07635243f, -0.13562165f, -0.07879898f, 
    -0.04892538f, 0.13577430f, 0.13312367f, 0.27481803f, 0.19768998f, 0.24388558f, 0.10664565f, -0.15244503f, 
    0.13904275f, 0.06944731f, -0.10611049f, 0.04277330f, 0.06718194f, -0.03632849f, -0.00491914f, 0.02829924f, 
    -0.30393627f, -0.05788444f, 0.00299113f, -0.27972853f, 0.10229117f, -0.06964552f, -0.04599819f, -0.06773856f, 
    0.01881211f, 0.06980708f, 0.04428101f, 0.18353380f, -0.26076445f, 0.07834981f, -0.08196745f, 0.07192451f, 
    0.04503037f, 0.02988389f, 0.02017706f, -0.02785596f, -0.13981383f, 0.04193304f, 0.18823901f, 0.12075257f, 
    0.02208776f, 0.18164985f, -0.05457207f, 0.26075169f, 0.09355322f, -0.10004295f, 0.03774565f, -0.07485630f, 
    0.07879148f, -0.06286054f, -0.08259680f, 0.11580864f, 0.27771032f, -0.05495957f, 0.09234683f, -0.03349134f, 
    -0.09621751f, 0.07313232f, 0.03319740f, 0.13777554f, 0.01097074f, 0.20573542f, 0.33805043f, -0.09465673f, 
    0.29771671f, -0.30112076f, -0.02591090f, 0.27254814f, 0.00293542f, 0.05594973f, -0.11866047f, 0.07287201f, 
    -0.09836946f, -0.08461693f, -0.17655002f, -0.03347124f, 0.23336071f, -0.07644076f, -0.09138099f, 0.06986518f, 
    0.08623544f, 0.04729946f, 0.09207097f, 0.08835310f, -0.04368232f, -0.19309638f, -0.08482642f, -0.10190643f, 
    -0.06304307f, 0.21485822f, -0.16025589f, -0.10700632f, 0.05789857f, 0.00860627f, 0.02778063f, -0.06942661f, 
    -0.10302049f, -0.09988965f, -0.02127159f, -0.00857131f, 0.31583455f, 0.04693735f, 0.04586437f, 0.17080136f, 
    0.09703302f, 0.05958401f, 0.13923322f, 0.04660538f, -0.10301090f, -0.02701806f, 0.14697699f, 0.07970256f, 
    0.47146431f, -0.03893188f, 0.19981056f, -0.15544225f, -0.01638946f, 0.16864005f, 0.16240984f, -0.00274696f, 
    0.11344914f, 0.16815259f, -0.07379870f, -0.04497462f, 0.01913061f, 0.15508111f, -0.02521410f, -0.43803725f, 
    0.18741526f, 0.00893445f, -0.04134263f, 0.10321750f, -0.10325449f, -0.04988724f, 0.15407246f, 0.02999877f, 
    0.05322362f, -0.22883591f, 0.03690970f, -0.13662630f, -0.07732469f, 0.09078956f, 0.11410590f, 0.18179592f, 
    -0.13984290f, -0.06459677f, 0.03635548f, 0.19320856f, -0.13326411f, -0.13667108f, -0.06430184f, 0.09629976f, 
    -0.01407936f, 0.06842842f, -0.00147579f, -0.20624477f, 0.04987568f, -0.01318649f, -0.18782941f, 0.09076001f, 
    0.00265707f, 0.03260681f, -0.11983433f, -0.00228002f, 0.01469876f, 0.12294860f, -0.10431847f, -0.07855418f, 
    0.01917976f, 0.15008815f, 0.09016807f, -0.15720472f, -0.16798159f, -0.00133248f, 0.02445731f, -0.05870330f, 
    0.08051906f, 0.01956670f, 0.03552527f, -0.08052388f, 0.01140439f, -0.14042652f, 0.01064500f, -0.04635762f, 
    -0.16058841f, 0.15486988f, -0.18698215f, 0.25579146f, 0.00661677f, -0.06505162f, -0.22266784f, -0.19594908f, 
    -0.12905118f, 0.10890805f, 0.03828995f, 0.01949914f, 0.39375845f, -0.15258455f, 0.18933798f, 0.35889778f, 
    0.10830338f, -0.11895730f, 0.10599919f, 0.12627427f, 0.16668244f, 0.15663180f, -0.02717209f, 0.01190252f, 
    -0.15394655f, -0.39945462f, -0.05319626f, 0.24550357f, 0.08304854f, -0.05815629f, 0.05125938f, -0.02340330f, 
    -0.01354418f, -0.01846046f, 0.17983741f, -0.06769563f, 0.12168622f, 0.28412735f, 0.12087301f, -0.34243956f, 
    0.23227541f, -0.02192636f, 0.06865704f, -0.03167844f, -0.05574851f, -0.07615396f, -0.15833956f, 0.02002823f, 
    0.27901611f, -0.13226900f, 0.18136908f, 0.16767430f, 0.02968360f, -0.24133724f, -0.10230085f, 0.13099514f, 
    -0.13171205f, -0.17216378f, -0.15491453f, -0.04206475f, -0.11582507f, 0.15377188f, 0.16006514f, -0.09631411f, 
    0.00024015f, 0.04805750f, 0.13567673f, -0.07724945f, -0.15600905f, -0.16117571f, 0.08285870f, -0.18617909f, 
    -0.08852750f, -0.25919536f, 0.01812596f, -0.14466679f, 0.02866428f, 0.16638839f, -0.01006588f, 0.12957305f, 
    -0.03226976f, -0.13408692f, 0.08775593f, 0.10342836f, 0.08913033f, -0.13686799f, -0.08124550f, 0.37535712f, 
    0.02789270f, 0.06145100f, -0.04457360f, 0.10186756f, -0.06638633f, 0.13656223f, -0.00559324f, 0.07527480f, 
    0.02414314f, 0.18644035f, 0.04740036f, 0.30209425f, -0.04568626f, 0.17175823f, -0.11529206f, -0.04264087f, 
    0.06373765f, -0.00508271f, 0.11255510f, 0.10198009f, 0.12729809f, 0.08922149f, 0.01830404f, 0.11488133f, 
    -0.01437863f, 0.00760722f, 0.17990263f, -0.07381607f, -0.04878354f, -0.05602742f, 0.12043494f, -0.03046686f, 
    0.27364141f, -0.13196121f, 0.05280992f, 0.04603948f, -0.12650229f, 0.09034443f, 0.08254001f, 0.02518074f, 
    0.05958723f, -0.06058941f, 0.12082689f, -0.08963355f, -0.27929813f, 0.13278367f, 0.12055656f, 0.04545756f, 
    -0.06958551f, 0.10017644f, 0.13323036f, 0.07023452f, 0.02290835f, 0.04549610f, -0.09638812f, 0.00755343f, 
    -0.14142184f, 0.10700115f, -0.03206874f, -0.07534804f, 0.16113208f, 0.11945957f, -0.07535061f, 0.00763369f, 
    0.00475708f, -0.25446108f, 0.03311972f, 0.05632754f, -0.13444749f, -0.00518714f, -0.11198527f, 0.13819714f, 
    -0.05005564f, 0.05615652f, 0.07680934f, 0.04016877f, 0.06547579f, 0.11419705f, 0.11196037f, -0.01043335f, 
    0.01179109f, 0.03707865f, 0.07540496f, -0.11575367f, 0.02596600f, 0.01239192f, 0.11916874f, 0.02333091f, 
    0.10582583f, 0.01315877f, 0.17962471f, -0.02411112f, 0.35581973f, -0.08981065f, -0.08528882f, -0.06455545f, 
    0.00910231f, -0.03127507f, -0.14140400f, -0.02124768f, -0.05286605f, 0.02109180f, -0.06923090f, -0.08374848f, 
    0.14843023f, 0.14031199f, -0.21581927f, -0.26981613f, 0.07233446f, -0.02064170f, 0.01487617f, -0.08239067f, 
    0.03806828f, 0.07281495f, -0.03967324f, 0.07931504f, -0.01414926f, -0.00354661f, -0.13836974f, 0.47171491f, 
    0.01763539f, -0.12108942f, 0.05913968f, -0.05841203f, 0.22298121f, -0.03825797f, -0.09985918f, -0.01791377f, 
    0.23993367f, 0.02624822f, -0.03795053f, 0.04431918f, 0.00847480f, 0.12925787f, -0.02847056f, 0.06424396f, 
    0.11242171f, 0.06932948f, -0.10193782f, -0.02996803f, 0.35880393f, 0.22063056f, 0.15138367f, -0.18811491f, 
    -0.02412177f, 0.02065016f, 0.08948509f, 0.03433723f, -0.13447005f, -0.16313887f, 0.05608305f, -0.11509833f, 
    -0.03630847f, -0.02618141f, 0.02889045f, 0.00772572f, -0.01455692f, -0.02153574f, 0.00194350f, 0.00571093f, 
    -0.01453974f, 0.01489688f, 0.00887989f, -0.00253621f, 0.01494865f, 0.02027810f, -0.01759952f, -0.03126098f, 
    -0.00149586f, 0.02325587f, -0.03051843f, -0.03802252f, -0.02477847f, -0.03531806f, 0.01087281f, -0.00940188f, 
    0.00680190f, 0.02912337f, 0.01572245f, 0.02920267f, 0.01565485f, -0.01325734f, -0.02675229f, -0.02812570f, 
    0.00012813f, -0.03217739f, 0.01088062f, -0.00702427f, 0.01249046f, -0.00248524f, -0.01951099f, -0.02322610f, 
    0.00295665f, -0.01286544f, -0.03332216f, 0.00686407f, 0.00518995f, -0.00621619f, -0.03364730f, -0.01363403f, 
    0.02176929f, -0.02540030f, 0.01368254f, -0.02008775f, 0.02179039f, -0.02259672f, -0.01160336f, 0.03252704f, 
    -0.03757416f, -0.02405918f, 0.02434214f, -0.02961712f, -0.02413575f, -0.03458980f, -0.03635923f, -0.01091976f, 
    -0.01111681f, -0.00618469f, -0.03720103f, -0.03582096f, -0.03545820f, -0.01111413f, 0.02288210f, 0.01280186f, 
    -0.00419722f, 0.00645966f, -0.00775054f, 0.01801319f, -0.02096200f, -0.00353543f, 0.00675214f, -0.01569958f, 
    -0.01845421f, -0.00593369f, 0.01850320f, 0.00569002f, 0.00924356f, -0.00207029f, -0.03780309f, -0.00764812f, 
    0.01058435f, 0.01669689f, -0.01217169f, 0.01805484f, -0.02969131f, 0.00503676f, -0.03338059f, 0.03224406f, 
    -0.01301886f, -0.03578031f, -0.04085037f, -0.01487593f, -0.03561289f, -0.03537391f, -0.01239919f, 0.00494613f, 
    -0.00309325f, -0.00640733f, 0.00087489f, -0.02935184f, 0.00303524f, 0.02098296f, -0.03936329f, 0.01163011f, 
    -0.01898068f, -0.00753458f, -0.03457266f, -0.00071447f, 0.02958405f, 0.02873510f, 0.01803711f, 0.02528255f, 
    -0.03614603f, -0.03877988f, -0.02950190f, -0.00845045f, -0.01020717f, -0.02431327f, 0.02382033f, 0.00159078f, 
    0.00518197f, 0.02288453f, 0.00149037f, -0.03548592f, -0.02038115f, 0.00660759f, -0.02490592f, -0.03724139f, 
    -0.02122243f, -0.00685133f, -0.01297936f, -0.03321074f, 0.00890034f, -0.01974113f, -0.00860429f, 0.01804469f, 
    -0.01363870f, 0.02023913f, 0.02257487f, -0.03756041f, 0.02210314f, -0.02919521f, -0.01810204f, -0.02565805f, 
    -0.01929785f, 0.00637798f, -0.01897339f, -0.02277275f, -0.00365815f, -0.02251204f, -0.02889312f, -0.00380490f, 
    -0.00475065f, -0.00190306f, -0.02236386f, -0.02202804f, -0.01959688f, 0.00589854f, -0.01790443f, 0.00952904f, 
    -0.03389743f, -0.03050269f, 0.00608237f, 0.02406275f, -0.00468129f, 0.01634620f, -0.00444760f, 0.01608258f, 
    -0.01873193f, -0.01920855f, -0.01327861f, -0.02096874f, -0.01686303f, 0.01091691f, 0.00013934f, -0.01539890f, 
    -0.01948383f, -0.03610490f, 0.02889163f, -0.01083438f, -0.03263550f, -0.01183861f, 0.01478274f, 0.01815917f, 
    -0.03777074f, 0.01369348f, -0.03725635f, 0.01905197f, -0.03638180f, 0.02184066f, 0.00792899f, -0.00969365f, 
    -0.01323092f, -0.03905882f, -0.01815232f, 0.00884263f, -0.00005009f, 0.01074338f, -0.03616039f, -0.00949373f, 
    -0.01353565f, -0.03347711f, -0.03838971f, 0.01529153f, -0.02410570f, 0.02943772f, -0.00210554f, 0.01368625f, 
    -0.01410719f, -0.03125805f, -0.01197480f, -0.03017275f, -0.01066415f, -0.00574139f, -0.00719561f, -0.03623550f, 
    -0.03512344f, -0.01772717f, 0.02570859f, 0.01085828f, -0.02738339f, -0.00517440f, -0.01004693f, -0.03166959f, 
    0.02747853f, -0.02132335f, 0.00702702f, -0.04119667f, -0.03452182f, 0.01771025f, 0.00355687f, -0.00851251f, 
    -0.02375603f, -0.03650416f, 0.01230506f, -0.00118384f, -0.02907424f, 0.00133505f, -0.03118956f, -0.00963315f, 
    0.02198951f, 0.02099953f, -0.00860838f, -0.03774029f, -0.03402143f, 0.02153491f, -0.01905296f, -0.02154224f, 
    0.00363388f, -0.02793114f, -0.02647069f, -0.01271631f, 0.00467553f, 0.02553061f, -0.02727045f, 0.03009887f, 
    0.01977039f, 0.01913450f, 0.01907646f, 0.00671994f, 0.00525501f, -0.01199540f, 0.00144820f, 0.00445094f, 
    -0.00730993f, 0.00780558f, -0.01349336f, -0.03107662f, -0.02544932f, -0.00310412f, 0.00598620f, -0.00318640f, 
    -0.01274004f, -0.03390415f, -0.03385479f, -0.00421872f, 0.01465525f, 0.01530373f, 0.00702348f, 0.02041644f, 
    -0.03935133f, 0.02603878f, 0.00308752f, -0.01648189f, -0.00715170f, -0.00623470f, 0.02717865f, -0.00750406f, 
    0.02488697f, -0.00665804f, -0.02301951f, 0.01851870f, 0.01442749f, 0.01576294f, -0.00935694f, -0.03016577f, 
    0.02907352f, 0.01336273f, 0.00110646f, -0.02772942f, -0.01355243f, 0.00902214f, 0.01227298f, 0.00744146f, 
    0.00926146f, 0.01319872f, 0.01356873f, 0.02188732f, -0.01000889f, -0.00218485f, -0.02696265f, -0.00335462f, 
    0.01913840f, -0.01535648f, -0.00329910f, -0.02490530f, 0.02636147f, -0.00274400f, -0.03127823f, 0.02033912f, 
    -0.00403654f, -0.03480787f, 0.01268279f, -0.02527734f, 0.02989429f, 0.01031867f, -0.00869765f, 0.00908423f, 
    0.01064788f, -0.01122850f, -0.03287889f, -0.02240939f, -0.02756505f, -0.01946273f, -0.00770042f, -0.00055860f, 
    0.00095820f, 0.00979503f, 0.01788778f, -0.00916875f, -0.01580073f, 0.01801496f, -0.00057694f, -0.03396035f, 
    -0.01921055f, 0.00768763f, -0.00554196f, 0.01011024f, 0.01700211f, 0.00161404f, -0.01584213f, -0.01279619f, 
    -0.03820411f, -0.02661249f, 0.02386463f, 0.01317829f, 0.02088710f, 0.03085694f, 0.02963560f, -0.00627245f, 
    -0.01089563f, -0.01163086f, -0.00488209f, -0.00771344f, -0.00267168f, 0.00581909f, 0.00582361f, -0.03302048f, 
    -0.02191920f, -0.03420591f, -0.02944949f, -0.03473574f, -0.01518200f, -0.00506508f, -0.02816569f, -0.03332312f, 
    0.01724048f, -0.01848261f, -0.02851468f, -0.03280837f, -0.03330903f, -0.00686308f, -0.03836791f, -0.03794165f, 
    -0.01752116f, 0.00885058f, 0.00549130f, -0.02663719f, 0.01546214f, 0.02909356f, -0.03847506f, -0.01099294f, 
    0.02069293f, -0.01410881f, -0.03095228f, 0.02225559f, 0.01736934f, 0.01530731f, -0.03484311f, -0.03861700f, 
    -0.03453586f, -0.02504767f, 0.00287339f, 0.01022888f, -0.00719471f, -0.01688802f, -0.02835888f, -0.01170617f, 
    -0.00906519f, 0.00904315f, -0.01695753f, 0.03054512f, 0.01007292f, -0.01944659f, -0.00375446f, 0.00798658f, 
    0.00407520f, 0.02326552f, 0.02356957f, 0.00630981f, 0.00972522f, -0.03891715f, -0.00151171f, -0.01779261f, 
    0.02144800f, -0.00538604f, -0.00861849f, -0.02871065f, 0.02428397f, 0.01285878f, 0.00651654f, -0.01766782f, 
    -0.04073283f, 0.00979763f, 0.01081434f, -0.00536005f, -0.04003767f, 0.01665650f, -0.00590170f, 0.01370291f, 
    -0.01163642f, 0.00254722f, -0.00329516f, -0.00975201f, -0.02021270f, -0.02381794f, -0.03062007f, 0.02406016f, 
    0.03067095f, -0.02350222f, 0.01144572f, -0.03213193f, 0.01656359f, 0.01662582f, -0.03316064f, -0.00127650f, 
    -0.02956263f, -0.02677948f, -0.01907481f, -0.02229406f, 0.01484694f, 0.03011694f, -0.00318384f, -0.01774605f, 
    -0.03462049f, 0.02380364f, -0.01514418f, 0.02934776f, 0.01005690f, 0.00494086f, -0.04015927f, 0.00169082f, 
    0.00852016f, 0.00611540f, -0.01083594f, -0.00405657f, 0.01113442f, 0.01480748f, 0.01706047f, -0.00877195f, 
    0.01927101f, -0.01655450f, -0.03220401f, 0.00698741f, -0.02887767f, 0.00376570f, -0.01909224f, -0.02430323f, 
    0.02135448f, -0.02094699f, -0.04011649f, -0.03717196f, 0.00255563f, -0.02430777f, 0.01423098f, -0.03847277f, 
    0.02817648f, 0.02102530f, -0.00215164f, -0.03991025f, -0.01407638f, 0.01827868f, 0.01437461f, -0.01741376f, 
    -0.03688627f, -0.00632168f, 0.00813370f, 0.01476565f, -0.00704267f, -0.01904271f, -0.03526515f, -0.04110445f, 
    -0.02233934f, 0.01673080f, -0.03927930f, -0.03396958f, 0.02317250f, -0.00269010f, -0.00525855f, -0.01617431f, 
    -0.02548656f, -0.03159893f, -0.01228296f, -0.02784800f, -0.00659289f, -0.00226023f, -0.02604164f, -0.00137669f, 
    -0.00038230f, -0.03031953f, 0.01471377f, 0.00185523f, -0.00575706f, 0.00404982f, -0.02286982f, 0.01245895f, 
    0.01423706f, -0.03997141f, 0.02094824f, 0.00937098f, 0.00191527f, -0.01003431f, -0.00213794f, 0.00586550f, 
    -0.03595186f, -0.00890848f, -0.00113329f, 0.00830026f, 0.02554884f, 0.00612351f, 0.00984394f, -0.01961924f, 
    0.01668643f, -0.00805645f, -0.04053662f, 0.02237424f, -0.04089344f, -0.03487925f, 0.02566425f, 0.00387691f, 
    -0.00200246f, -0.00056536f, 0.01592908f, -0.02767811f, -0.00394115f, 0.02280015f, 0.01844437f, -0.03720391f, 
    0.02583423f, 0.02809149f, 0.03086594f, -0.01330496f, 0.02979979f, -0.00258411f, 0.01945957f, 0.01737878f, 
    0.01723495f, -0.03579081f, 0.01312721f, 0.02793449f, 0.02206502f, 0.01071690f, -0.00704734f, 0.00614963f, 
    0.02205166f, 0.01802941f, 0.02966435f, 0.02274685f, -0.00675312f, -0.03980624f, -0.01521186f, 0.01874734f, 
    -0.00452250f, 0.01341544f, -0.01833984f, 0.01799671f, 0.03532555f, -0.03280064f, 0.02781415f, -0.02249948f, 
    -0.01081823f, -0.03239971f, -0.02000578f, -0.02929216f, -0.00209936f, -0.03270739f, -0.02457276f, -0.02805512f, 
    -0.00532769f, 0.02374754f, -0.00147422f, -0.00749000f, 0.01708553f, -0.00344694f, 0.01270257f, -0.02556736f, 
    0.01852871f, 0.01468107f, -0.03990659f, -0.03713690f, 0.02371127f, 0.00239338f, -0.00226628f, 0.00686539f, 
    -0.00367067f, 0.02177531f, 0.02413617f, -0.02813556f, 0.00544353f, 0.00648277f, 0.01997541f, -0.01566348f, 
    -0.03055893f, -0.00655478f, -0.00937069f, -0.03105379f, 0.01192610f, 0.00470498f, 0.03073775f, -0.02802191f, 
    -0.01321322f, -0.02851631f, -0.03173043f, -0.03308606f, -0.01343920f, 0.01126726f, -0.00676864f, -0.00359429f, 
    -0.02900072f, 0.00911714f, -0.01709279f, -0.00289996f, -0.01279412f, 0.02095877f, -0.00254010f, 0.01608389f, 
    -0.00898464f, 0.00166415f, 0.02817677f, -0.01884228f, -0.02207012f, 0.00121546f, 0.00290315f, -0.01117079f, 
    -0.01996445f, -0.03303415f, 0.01345578f, -0.02692060f, -0.01662937f, -0.01746206f, -0.01692094f, 0.00473946f, 
    0.01123273f, -0.02970134f, 0.01703744f, 0.00256702f, -0.02289297f, -0.04027841f, 0.00325513f, -0.01041095f, 
    -0.01378121f, 0.00556192f, -0.03537113f, 0.01438265f, -0.03915341f, -0.02408452f, -0.02697717f, 0.01439286f, 
    -0.02258509f, 0.01569153f, 0.00169221f, -0.00831227f, -0.01307657f, 0.00022123f, 0.02239501f, 0.00513541f, 
    0.00172164f, -0.03441476f, 0.00655331f, 0.01334962f, -0.03042320f, -0.02224389f, -0.01748880f, 0.01752665f, 
    0.00613189f, -0.03000995f, -0.00247389f, -0.00580489f, -0.00973060f, 0.01132879f, -0.00545721f, -0.01423917f, 
    -0.00353356f, 0.00419232f, -0.00244152f, -0.00870853f, 0.01330218f, -0.03999893f, 0.00155052f, 0.00078188f, 
    -0.01104633f, -0.03210711f, -0.02062340f, 0.01248228f, -0.00367273f, 0.02698805f, -0.00828825f, 0.00832271f, 
    0.02333067f, -0.00534670f, -0.00838132f, 0.00509528f, 0.03064601f, 0.02773190f, -0.02849154f, 0.03096368f, 
    0.00582692f, -0.03874640f, 0.02352499f, -0.02425977f, -0.03830262f, 0.00526730f, -0.01291271f, -0.00117126f, 
    0.02988525f, -0.03626591f, 0.00839789f, 0.03005101f, 0.02161956f, 0.00823013f, -0.00093442f, -0.01069687f, 
    0.00171031f, -0.00416508f, -0.01153276f, -0.02306860f, -0.03443941f, 0.02171448f, -0.01633042f, -0.02643305f, 
    -0.00560574f, 0.00090137f, 0.03003447f, -0.01311597f, 0.01000226f, -0.00028193f, -0.03681748f, -0.00431569f, 
    -0.01677387f, -0.02884488f, 0.03157382f, 0.02147095f, -0.02615757f, -0.03785515f, 0.00360552f, 0.01342209f, 
    0.00957329f, -0.03263495f, 0.02179158f, -0.02358302f, -0.02508065f, -0.01634223f, -0.03625821f, -0.02296050f, 
    0.02418935f, -0.02911870f, 0.01536166f, -0.01724437f, -0.02222855f, 0.03144899f, -0.02487707f, 0.03325519f, 
    0.02625565f, -0.02679651f, -0.03166903f, 0.00811204f, 0.02613869f, -0.01906902f, 0.00744803f, 0.03502141f, 
    -0.00500680f, -0.00886135f, 0.00729454f, 0.01594446f, -0.03058812f, -0.03454335f, -0.03053322f, -0.02310758f, 
    -0.03427712f, -0.03041329f, -0.03262468f, 0.00680030f, 0.02778094f, -0.00013085f, 0.01228672f, -0.02866581f, 
    -0.01588457f, 0.01541324f, -0.01424739f, 0.00343097f, -0.00719460f, 0.00302775f, 0.02397039f, -0.02082180f, 
    0.02479577f, 0.02447131f, -0.00897232f, -0.02818737f, -0.01345007f, -0.02715946f, 0.01245836f, 0.01876962f, 
    0.01483748f, -0.02622417f, -0.01144249f, -0.02212042f, 0.01778279f, 0.00486654f, 0.02028812f, -0.00806807f, 
    -0.02865331f, 0.00259566f, -0.01542350f, -0.01967756f, -0.03721178f, -0.03539163f, 0.00095419f, 0.01885999f, 
    -0.00077795f, 0.02374046f, -0.00972420f, -0.02152189f, 0.01119223f, -0.01331233f, -0.02933428f, 0.01771961f, 
    0.01586984f, 0.01545075f, -0.00076670f, 0.01179010f, 0.02283840f, 0.02753161f, -0.03217108f, -0.02356538f, 
    0.02380817f, -0.01755871f, 0.01285008f, -0.02820924f, -0.02772849f, 0.00706213f, -0.02473091f, 0.01586998f, 
    -0.00774128f, -0.01836749f, 0.00007285f, -0.02810390f, -0.00910935f, 0.01548647f, 0.02451719f, 0.02315596f, 
    0.00438337f, 0.00780504f, -0.03096545f, -0.01084770f, -0.00052693f, -0.00281094f, -0.02998450f, -0.02672292f, 
    -0.00139060f, 0.03458905f, 0.00995281f, 0.00993008f, 0.01280498f, 0.03368147f, 0.00527323f, 0.01448633f, 
    0.01300027f, -0.02677321f, 0.02534632f, -0.03454422f, -0.03365494f, 0.02459170f, -0.02033521f, -0.01342831f, 
    -0.03324128f, 0.02091275f, 0.01262421f, -0.03058123f, -0.02409963f, 0.00472287f, 0.01284616f, 0.03046089f, 
    0.01728048f, -0.02903072f, -0.00268866f, 0.02673186f, 0.01170322f, 0.00391748f, -0.00733303f, 0.02756870f, 
    0.01745809f, 0.02659058f, -0.02853472f, -0.02302005f, -0.01324795f, 0.00988507f, 0.00840833f, -0.03604053f, 
    -0.03138417f, -0.04004787f, 0.00612124f, -0.03561921f, -0.01799938f, 0.01894856f, 0.00297719f, -0.02855063f, 
    0.02876572f, -0.02924131f, 0.00595888f, -0.00851797f, 0.01876312f, -0.02230762f, 0.00364687f, 0.00486315f, 
    -0.01679024f, 0.00377391f, 0.01661952f, -0.02289478f, -0.02972440f, -0.02209998f, 0.02336686f, -0.00759591f, 
    -0.01749018f, -0.01413992f, -0.00686027f, -0.00426631f, 0.01897157f, -0.00921338f, 0.03266072f, -0.02991314f, 
    0.02690393f, 0.03296689f, 0.02963594f, 0.00441008f, 0.01579067f, 0.00966177f, 0.02509553f, -0.02694167f, 
    -0.01118770f, 0.02140611f, 0.00882569f, -0.00662131f, -0.00201247f, -0.01514736f, 0.01521658f, -0.02113055f, 
    -0.00778052f, -0.01300091f, -0.00632963f, -0.02541412f, 0.00318100f, 0.01876256f, -0.03067026f, 0.01262590f, 
    -0.00902263f, 0.01301103f, 0.00746144f, -0.02436372f, -0.00129314f, -0.00344057f, -0.03151257f, -0.00126161f, 
    0.01631994f, 0.02801263f, 0.02661031f, -0.03100863f, -0.00740494f, -0.03553954f, -0.03704324f, 0.01897844f, 
    -0.02880025f, 0.01815844f, -0.00612603f, -0.01974800f, 0.00656360f, 0.01939444f, 0.00503658f, -0.02455137f, 
    0.01676345f, -0.02058361f, -0.01525479f, -0.00583214f, -0.02916980f, 0.01007189f, -0.01596054f, 0.01250913f, 
    -0.02618569f, -0.03190333f, -0.01801217f, -0.03458892f, -0.00660649f, 0.01902397f, -0.03218261f, 0.02297619f, 
    0.02647780f, -0.03071376f, -0.02951776f, 0.01873911f, 0.00073580f, -0.02348139f, 0.00575092f, 0.03016908f, 
    0.00222330f, -0.02505245f, -0.01407063f, -0.01406812f, 0.01947631f, -0.02586687f, 0.01879560f, -0.00046141f, 
    0.02563429f, -0.03352243f, 0.01485381f, 0.02920517f, 0.01479085f, 0.02312189f, -0.03310172f, 0.03385730f, 
    0.01385145f, -0.01718293f, 0.02801167f, 0.00006836f, -0.02708338f, -0.01921174f, 0.02197273f, 0.00932083f, 
    0.01013980f, 0.01943989f, 0.01146644f, -0.00499790f, -0.02263346f, 0.02850997f, -0.02921603f, 0.00565101f, 
    -0.01846440f, -0.02788241f, -0.00396071f, 0.00387973f, 0.02645245f, 0.02090984f, -0.00188739f, 0.00677018f, 
    0.02145014f, 0.01543539f, -0.02407176f, -0.02459244f, -0.00465764f, 0.01129505f, -0.02482966f, 0.02184564f, 
    0.02523723f, -0.03712351f, 0.02758971f, -0.03128567f, 0.00251894f, 0.02916711f, -0.02693499f, -0.02814913f, 
    -0.03254334f, -0.03343056f, 0.01594110f, 0.00686695f, -0.03777522f, -0.01763461f, -0.01285424f, 0.01555560f, 
    0.00541236f, -0.01784516f, -0.02843741f, -0.03488345f, 0.00520593f, -0.02089022f, -0.03298398f, 0.01241088f, 
    0.01042685f, -0.01881488f, -0.01074904f, 0.00453200f, 0.01466151f, -0.00725424f, -0.01715672f, 0.02546485f, 
    -0.02151801f, 0.02749576f, 0.00895204f, 0.02772983f, -0.00555873f, -0.01620381f, -0.03875722f, -0.03206376f, 
    -0.00148828f, 0.00174976f, -0.02255945f, -0.02202763f, -0.03463634f, -0.02692433f, 0.03173083f, 0.02544878f, 
    0.00658331f, -0.02741149f, -0.00380086f, -0.03131521f, -0.01884780f, 0.02044035f, -0.01293969f, 0.01293464f, 
    0.02188055f, 0.02851204f, 0.00443712f, 0.02394855f, -0.00009427f, 0.01269030f, 0.01338314f, -0.02989071f, 
    -0.00204593f, 0.00331830f, -0.00941732f, -0.00929306f, 0.00006984f, -0.03547834f, 0.02442900f, -0.02912807f, 
    -0.01687589f, 0.02197800f, -0.02186814f, 0.01542346f, -0.00554544f, -0.00278400f, 0.00266374f, -0.00261454f, 
    -0.00642759f, -0.01553572f, -0.00128635f, -0.02921185f, -0.00238762f, -0.02886222f, 0.01372592f, 0.01322318f, 
    0.00401245f, 0.03204170f, -0.03288266f, 0.00923634f, 0.00171296f, -0.02393412f, -0.00968658f, -0.00246202f, 
    0.03392385f, 0.00270656f, -0.01314859f, -0.00344509f, -0.01059221f, 0.03200869f, 0.01605682f, -0.01631864f, 
    0.00193399f, -0.02906191f, 0.03586150f, 0.02728259f, -0.03368238f, 0.00789119f, -0.01879069f, 0.02124145f, 
    -0.02741353f, 0.03112868f, 0.02847963f, -0.00675865f, -0.00585419f, -0.01708508f, -0.03475107f, -0.02449275f, 
    0.00588313f, -0.00349138f, 0.02459211f, 0.02476748f, 0.00371492f, -0.01137885f, -0.03179434f, 0.00009790f, 
    0.01258672f, -0.00361268f, -0.03199488f, 0.00271669f, 0.01682428f, 0.01448798f, 0.02298978f, -0.01278009f, 
    -0.03263309f, 0.01879887f, -0.02699989f, 0.03353002f, -0.01237308f, -0.01940020f, -0.03915343f, -0.00722749f, 
    -0.02414588f, 0.02254793f, -0.02092293f, 0.02510425f, -0.00723627f, 0.00824750f, -0.02483845f, 0.00226484f, 
    0.01538398f, -0.02519076f, -0.02230394f, -0.00660979f, -0.01028157f, -0.02516628f, 0.01835800f, 0.02292751f, 
    0.02005059f, -0.01400833f, -0.02432510f, -0.01937218f, 0.02978822f, -0.03023311f, -0.00638423f, -0.01119695f, 
    0.03187753f, 0.01043845f, -0.02177409f, 0.02231766f, 0.02341171f, 0.01876224f, -0.01239309f, -0.00521571f, 
    0.01797146f, 0.00712751f, -0.00245965f, -0.00742941f, 0.02840931f, 0.00107298f, -0.01251414f, 0.02125198f, 
    0.00413221f, -0.00465624f, -0.01365455f, -0.01440416f, 0.00104915f, -0.01256804f, 0.02742702f, 0.01055492f, 
    -0.02494921f, 0.01012641f, -0.02294143f, -0.00742573f, 0.02899520f, 0.02818669f, -0.03414701f, 0.00619812f, 
    -0.03652030f, -0.02082958f, -0.03146806f, 0.00052823f, 0.02138856f, -0.01380076f, 0.00602549f, -0.00314085f, 
    -0.00887354f, 0.01919418f, 0.02443863f, -0.02128864f, 0.00554877f, -0.00488779f, -0.02676264f, 0.02423263f, 
    0.00985274f, -0.00453239f, -0.01955363f, 0.00213967f, -0.01628088f, -0.02470441f, 0.01187687f, -0.02641899f, 
    -0.03213655f, 0.02477917f, 0.01899922f, 0.01513034f, -0.03188905f, -0.00020923f, -0.02147437f, 0.00580611f, 
    -0.02586545f, 0.02397101f, -0.00464483f, 0.00794518f, 0.01777328f, -0.01256317f, 0.00179340f, 0.02975935f, 
    0.01401864f, 0.00714605f, -0.03004924f, 0.00008227f, 0.03072142f, -0.00528311f, -0.00523367f, 0.00706461f, 
    0.00053937f, 0.00014451f, -0.00037236f, -0.00971282f, 0.00100851f, 0.02823522f, 0.02801949f, -0.02459119f, 
    -0.03736656f, 0.02127388f, -0.00517783f, -0.01900291f, 0.02014165f, 0.02933632f, 0.01919596f, -0.03385738f, 
    -0.01661938f, 0.00595901f, -0.02990616f, -0.01817566f, -0.02804234f, 0.00005498f, -0.01733263f, 0.00936120f, 
    -0.03262236f, -0.03001297f, -0.03702303f, -0.00411628f, 0.01096366f, 0.00741786f, 0.01828529f, 0.00541660f, 
    0.02774800f, 0.04278759f, -0.03209384f, -0.03267709f, 0.00988908f, -0.00721648f, -0.01901084f, 0.02424797f, 
    -0.00308876f, 0.02178638f, 0.03222546f, 0.03247399f, 0.01893412f, 0.02842436f, 0.02421502f, 0.00280831f, 
    0.03243166f, 0.02365315f, 0.01677995f, 0.02312736f, -0.00629798f, -0.02840129f, -0.00171323f, 0.00236008f, 
    -0.03696416f, 0.03017867f, 0.02984900f, 0.01733804f, -0.02040946f, 0.01498897f, 0.02451205f, 0.01918103f, 
    0.02790582f, -0.00297568f, -0.03953881f, 0.03040798f, 0.01198699f, 0.01978871f, 0.03290707f, 0.00168689f, 
    -0.00125079f, -0.01967984f, -0.03020717f, -0.02701759f, -0.00982178f, -0.00793105f, -0.01606082f, 0.03317184f, 
    -0.00304497f, -0.01037146f, -0.01608766f, -0.03566445f, -0.03627160f, -0.00492264f, 0.03137239f, -0.02415300f, 
    -0.02087126f, -0.01879844f, -0.03606666f, -0.03240261f, -0.01042807f, 0.00568493f, 0.03211397f, 0.01512415f, 
    0.01656617f, 0.02107986f, -0.03171944f, -0.00464999f, 0.02652773f, 0.02962213f, -0.02882937f, 0.02877449f, 
    -0.00243139f, 0.02370404f, -0.02137767f, -0.03366722f, -0.01478708f, 0.01119778f, -0.00151661f, 0.02475078f, 
    0.02019089f, 0.00018662f, -0.00749845f, 0.00936151f, 0.01705143f, -0.02723354f, 0.01469137f, -0.02512435f, 
    0.01234320f, 0.01195114f, 0.01860316f, 0.01910310f, 0.02663871f, -0.02566925f, -0.00481140f, -0.02597911f, 
    -0.03491170f, -0.03160597f, 0.01743852f, 0.01012904f, 0.02265872f, 0.02434322f, 0.03213624f, -0.00632813f, 
    0.03078764f, 0.02723001f, 0.00453184f, -0.00829854f, -0.01948744f, 0.02403226f, -0.00504467f, -0.03165132f, 
    -0.01829974f, 0.02457679f, -0.01392399f, -0.00883081f, -0.03393850f, -0.00196650f, -0.02089255f, -0.01255958f, 
    -0.03518831f, 0.00593741f, 0.00473004f, 0.02208674f, -0.00695135f, -0.03252494f, 0.01278844f, 0.03092551f, 
    0.00398460f, -0.01518426f, 0.01565311f, -0.00658150f, -0.00818180f, 0.00055994f, -0.02724447f, 0.02724382f, 
    -0.03545742f, -0.02310993f, 0.00482583f, 0.01045474f, -0.03153282f, -0.03293125f, 0.03113579f, 0.00031806f, 
    0.01979380f, 0.00197696f, 0.00704894f, 0.00097701f, -0.01956141f, 0.02659173f, 0.01472933f, -0.01135571f, 
    0.02592912f, -0.01161706f, -0.03727908f, 0.03299276f, -0.03841127f, -0.01000687f, 0.02832657f, -0.02634695f, 
    0.01049517f, 0.00753499f, 0.02064278f, -0.01014074f, 0.02030267f, -0.00101383f, 0.00691099f, 0.01644918f, 
    0.10836382f, 0.03877246f, 0.02500509f, 0.33196232f, 0.01307824f, 0.08697185f, -0.15646952f, 0.07628173f, 
    0.16860344f, -0.04385076f, 0.00673957f, 0.04692426f, -0.27060696f, 0.05380993f, 0.14105658f, 0.16163708f, 
    -0.14280140f, -0.10667788f, 0.12257700f, 0.01138261f, -0.02272651f, 0.02939859f, 0.09123188f, 0.01905681f, 
    -0.04888820f, -0.10528210f, 0.15075065f, -0.12387183f, 0.11076293f, -0.01443158f, -0.00096543f, -0.03780942f, 
    -0.13771869f, -0.06130927f, 0.00586558f, 0.00563376f, -0.26361382f, -0.06122548f, -0.08480819f, -0.10028327f, 
    0.09834203f, -0.07454010f, -0.11319502f, -0.04069991f, 0.07907489f, 0.06941896f, 0.02379601f, 0.06825555f, 
    -0.28172165f, -0.05138575f, 0.06528127f, 0.10208803f, 0.13192585f, 0.01134266f, 0.01902639f, 0.05212609f, 
    -0.06509348f, -0.04283943f, -0.04413772f, -0.10724011f, -0.15615806f, 0.12841862f, -0.04253244f, 0.17462732f, 
    -0.14443076f, -0.01416956f, 0.02733870f, 0.03783099f, 0.09259026f, 0.06500288f, -0.05692511f, 0.02041702f, 
    -0.10810285f, 0.07077749f, 0.16692506f, -0.19024545f, 0.18144993f, 0.07707151f, -0.10078720f, 0.03862833f, 
    0.09921344f, 0.13117096f, 0.04126062f, 0.22339658f, -0.25283608f, 0.17307560f, 0.07336771f, 0.11775831f, 
    -0.03752908f, -0.07547265f, 0.04069111f, 0.15103291f, 0.17390232f, -0.02365392f, 0.04700231f, 0.00254611f, 
    -0.06523613f, 0.05983179f, 0.00270145f, 0.00527840f, 0.01974861f, -0.02679709f, 0.06625547f, 0.02662350f, 
    0.14701210f, -0.05304630f, -0.04252790f, -0.09348622f, -0.15081929f, 0.18495464f, 0.23443949f, -0.12613702f, 
    0.07417663f, 0.00414447f, 0.01228105f, -0.02677579f, -0.02701117f, 0.12347860f, -0.01977255f, 0.11088026f, 
    -0.19459544f, 0.05638693f, -0.10067803f, 0.30921546f, 0.06119999f, -0.13731678f, 0.10446177f, 0.11035570f, 
    -0.07317875f, -0.10519917f, 0.19971527f, 0.07933158f, -0.22770450f, -0.23246694f, -0.17782642f, -0.09812693f, 
    0.07270423f, -0.08955994f, 0.01208309f, 0.00173929f, -0.06523740f, 0.05949979f, 0.10784472f, 0.07207000f, 
    0.16475180f, 0.19562967f, 0.11315235f, 0.02757218f, -0.11738519f, 0.02846797f, -0.03431446f, -0.02689680f, 
    0.01099186f, 0.05264798f, 0.03266825f, 0.03611602f, -0.09885950f, 0.12905616f, 0.10254522f, -0.00388831f, 
    -0.10631008f, 0.00990871f, 0.06899922f, -0.03248039f, -0.04242583f, 0.02860439f, -0.00783973f, -0.08861165f, 
    0.39972907f, 0.18792233f, -0.06944572f, -0.05875581f, -0.01697855f, -0.04515650f, 0.04666773f, -0.01900316f, 
    -0.08189851f, 0.13746399f, -0.15591803f, 0.01105986f, -0.32984400f, 0.06636832f, 0.08482830f, -0.13175637f, 
    0.04024876f, 0.06533937f, 0.18901035f, -0.04859747f, 0.14077364f, 0.01576908f, 0.11212230f, -0.12428239f, 
    0.23238681f, 0.19670103f, -0.01154059f, -0.11406191f, -0.09249002f, -0.09869815f, -0.04428567f, -0.00550035f, 
    0.03966044f, -0.03023122f, 0.18456583f, 0.01071614f, 0.20372805f, 0.12391281f, -0.35091394f, 0.07237547f, 
    0.04232488f, 0.06878310f, -0.10414761f, -0.02411355f, 0.10040376f, 0.06465775f, 0.06446669f, -0.00572094f, 
    -0.04259638f, -0.13328199f, 0.28535011f, -0.08036286f, 0.02683312f, 0.20496033f, 0.00105163f, -0.06514719f, 
    0.10247574f, 0.01672511f, 0.05539380f, -0.00346825f, -0.30593938f, 0.09761297f, -0.01801829f, 0.16776548f, 
    -0.17524053f, 0.04202316f, 0.02071851f, 0.02206270f, -0.04354114f, 0.07615048f, 0.02743342f, 0.06926510f, 
    -0.08333601f, -0.02116801f, 0.05218336f, -0.02210203f, 0.06887139f, -0.13045041f, -0.02188157f, 0.01488680f, 
    0.13273707f, -0.02411775f, 0.06810588f, -0.02268491f, -0.13590655f, -0.00160324f, -0.12991723f, -0.16504894f, 
    -0.02781671f, 0.01058059f, -0.09029145f, 0.08701401f, 0.16107036f, 0.07438190f, 0.22428855f, 0.15151957f, 
    0.04339372f, -0.12258572f, 0.00363088f, 0.00667605f, 0.09683249f, -0.02939767f, -0.08319718f, -0.03639790f, 
    0.26412380f, 0.02979518f, -0.10994076f, 0.11496474f, -0.27082649f, 0.02607886f, 0.03769008f, 0.17191294f, 
    -0.09438334f, 0.03392614f, -0.01873593f, 0.06707276f, 0.03888112f, -0.00076052f, -0.01613203f, -0.04401864f, 
    0.11286177f, -0.09848347f, 0.08636779f, -0.06453383f, -0.00561391f, -0.03307278f, 0.12551220f, 0.05288067f, 
    0.06332686f, -0.07999405f, -0.02109517f, -0.08304902f, 0.16025680f, 0.19028729f, -0.14616957f, 0.17864604f, 
    0.06783697f, 0.00248915f, 0.06854511f, 0.02534248f, 0.10343475f, 0.02556497f, 0.03366088f, -0.06727294f, 
    0.01364257f, 0.04571521f, -0.19674227f, 0.41923052f, 0.05644105f, 0.04147131f, -0.01935241f, -0.00236084f, 
    0.13213462f, 0.07213134f, -0.03653727f, -0.06496529f, -0.12654781f, -0.10234457f, 0.19176018f, -0.12658268f, 
    -0.05334356f, -0.00653894f, -0.07429112f, 0.01882396f, -0.14822641f, -0.15170130f, 0.09990185f, -0.13373347f, 
    0.31073391f, 0.19687092f, -0.09811193f, 0.13683943f, -0.12979384f, 0.05385653f, 0.02410734f, -0.09120138f, 
    -0.04011649f, 0.09713204f, 0.17255384f, 0.17617080f, -0.23874137f, -0.04413841f, -0.05760816f, 0.00617212f, 
    0.08381629f, 0.15247835f, -0.14130671f, -0.00421971f, 0.13065521f, 0.03787418f, -0.05369658f, -0.00771981f, 
    -0.10215414f, -0.08924840f, -0.08117937f, -0.19687825f, 0.04207828f, -0.04223555f, -0.01305719f, 0.15893945f, 
    0.08761505f, -0.01878757f, 0.01440555f, 0.10849942f, -0.23111460f, 0.15602784f, 0.05488948f, 0.02902802f, 
    -0.07848772f, 0.09294966f, 0.11776032f, -0.02726880f, -0.05984137f, 0.00411932f, 0.17242132f, 0.08573558f, 
    0.27982965f, 0.08927054f, -0.04816161f, 0.29872680f, 0.00772648f, -0.00233165f, -0.02396233f, -0.07812784f, 
    0.14476641f, -0.01775799f, -0.06455678f, 0.09413780f, -0.08335365f, 0.06966443f, 0.19214535f, -0.01510220f, 
    -0.00381407f, 0.00750370f, 0.06878244f, 0.09972574f, -0.05242801f, 0.13055567f, 0.15577188f, -0.03088854f, 
    -0.03005955f, -0.02080677f, 0.17443411f, 0.20225723f, 0.01820649f, 0.05898714f, 0.01651270f, 0.00752814f, 
    -0.03621882f, -0.01919953f, -0.03322893f, 0.02697202f, 0.19782652f, -0.09573285f, 0.04331072f, 0.01234045f, 
    0.28400481f, 0.08896873f, 0.03744203f, 0.11329795f, 0.00965256f, -0.06695912f, -0.11418691f, -0.07571679f, 
    0.15095933f, 0.02399866f, 0.06840742f, 0.08157090f, -0.06982078f, 0.05137274f, -0.01072927f, -0.01429925f, 
    -0.14793083f, 0.08756647f, -0.09389793f, 0.03388876f, 0.16885222f, -0.00119866f, 0.28572890f, -0.12489644f, 
    -0.10487894f, 0.00517246f, -0.08669208f, -0.08722740f, -0.09072767f, -0.07102545f, 0.09832694f, 0.20916075f, 
    0.02378733f, -0.08966567f, 0.17494412f, -0.08675434f, 0.07965776f, 0.07119304f, 0.05583458f, 0.04897437f, 
    -0.03822324f, 0.11800767f, -0.01871129f, 0.07231472f, -0.01412257f, -0.03998196f, -0.01127253f, -0.24695681f, 
    0.08895455f, -0.02377759f, -0.02167776f, 0.08479384f, -0.12632801f, 0.10590862f, 0.04953541f, 0.08978580f, 
    -0.11560300f, 0.14037056f, -0.14085399f, 0.10376759f, -0.07707828f, -0.01363248f, -0.08570593f, 0.29434541f, 
    -0.01247935f, 0.03911194f, -0.01413284f, 0.10821917f, 0.08012132f, 0.04187190f, 0.00707733f, 0.11568723f, 
    -0.24510540f, -0.04593444f, 0.15059295f, -0.10675830f, -0.09298951f, 0.04500898f, -0.03824372f, 0.03074504f, 
    -0.10435925f, -0.12962650f, 0.01398105f, -0.03123365f, -0.16567652f, 0.11150311f, -0.06612796f, -0.02781626f, 
    0.12849574f, 0.25442916f, 0.06191314f, 0.06636084f, -0.23616470f, 0.01068507f, -0.11326257f, 0.09626162f, 
    -0.02150114f, 0.00901627f, -0.04916819f, 0.02636402f, 0.08456123f, -0.03415076f, -0.07877828f, -0.05328963f, 
    0.10963406f, 0.28861260f, -0.26810038f, 0.27300128f, -0.00645924f, -0.07557949f, -0.01991829f, 0.01461553f, 
    0.07341246f, 0.07612932f, 0.06785130f, -0.05220087f, 0.37052184f, -0.03795726f, 0.08154245f, 0.10299096f, 
    0.16420543f, -0.08198045f, 0.13985226f, 0.16919966f, 0.06933971f, 0.22729850f, -0.11876580f, 0.03346323f, 
    -0.39807516f, 0.07228161f, -0.08578190f, 0.31416944f, -0.06633746f, 0.03174437f, 0.01089425f, 0.04000100f, 
    -0.00721504f, -0.00623555f, 0.03314618f, -0.01102104f, -0.12383319f, 0.15995112f, 0.04754176f, -0.07172624f, 
    0.09196050f, -0.03813311f, 0.04425674f, -0.01355161f, -0.05933514f, -0.01384613f, -0.08950368f, -0.01858819f, 
    -0.35612977f, 0.04406390f, 0.19266339f, 0.35804299f, -0.02721114f, -0.01779505f, 0.03281431f, 0.06235627f, 
    -0.08151315f, 0.02849758f, -0.13679437f, -0.00352858f, -0.05400256f, 0.24658240f, 0.20904908f, 0.02150271f, 
    0.01069369f, 0.08010056f, 0.02625049f, 0.03398189f, -0.13626638f, -0.09952553f, 0.07665881f, -0.12538721f, 
    -0.12921351f, -0.27332664f, -0.07962056f, -0.12595069f, -0.01762964f, -0.04054957f, -0.05668027f, 0.24024604f, 
    0.01110009f, -0.11596793f, 0.00628284f, 0.07159362f, 0.05675874f, -0.02512730f, -0.14670509f, 0.01134913f, 
    0.11638442f, 0.03599922f, -0.03993658f, 0.13715166f, -0.08273621f, 0.11040762f, 0.01068338f, 0.01307899f, 
    0.39387381f, 0.16174008f, -0.19052024f, 0.16627884f, 0.08520246f, -0.11255769f, -0.08282655f, 0.01928667f, 
    0.05744987f, 0.06195195f, 0.17505179f, 0.11451327f, -0.04655330f, -0.02121650f, -0.05990308f, 0.03303557f, 
    0.03190661f, -0.00770871f, 0.08730651f, 0.05035923f, 0.03745683f, -0.07278837f, 0.04021603f, -0.03892867f, 
    -0.14001065f, 0.07624656f, 0.14227141f, 0.14186558f, -0.02559468f, -0.01998132f, 0.05369658f, 0.12804790f, 
    0.03480509f, -0.04237196f, 0.02281327f, -0.14068344f, -0.45419171f, 0.01912433f, 0.03581321f, 0.21705469f, 
    -0.08475414f, 0.04568104f, 0.02731330f, 0.06805117f, 0.07754830f, 0.01662466f, -0.02084007f, 0.04992662f, 
    -0.09019974f, -0.10631597f, 0.00830152f, -0.02896032f, 0.13757938f, 0.09108953f, -0.09775088f, -0.01266303f, 
    0.06631230f, -0.00177968f, -0.01312620f, 0.08336663f, -0.18271470f, -0.17431822f, 0.08556825f, 0.10992189f, 
    -0.16451013f, 0.02458046f, 0.07372177f, 0.04465354f, 0.03229628f, 0.08066022f, 0.08360124f, 0.01229218f, 
    -0.08822527f, -0.08667687f, -0.10671741f, 0.01111987f, -0.06983305f, -0.05273315f, 0.01745384f, 0.18974748f, 
    0.01623994f, 0.00534987f, 0.19036099f, -0.10611310f, 0.01194175f, -0.23228981f, 0.14775540f, -0.02278379f, 
    0.05861282f, -0.02786677f, 0.01599339f, -0.04291488f, 0.13989972f, 0.02060748f, -0.07803007f, -0.04307025f, 
    -0.06241808f, -0.09890061f, -0.10401760f, -0.02443601f, 0.11069719f, 0.00560999f, 0.00738038f, -0.04182371f, 
    0.06161617f, 0.10490786f, -0.00831996f, -0.02429235f, 0.18256506f, 0.07878034f, -0.16612610f, 0.32885820f, 
    0.08285222f, -0.00144644f, 0.07562435f, 0.20879969f, 0.13555723f, -0.13366792f, 0.01249262f, -0.12312223f, 
    0.08277033f, -0.00070298f, -0.03611399f, 0.13826218f, 0.04942283f, -0.01669160f, -0.19547637f, 0.23364061f, 
    0.15826195f, 0.03375780f, -0.05226605f, 0.16572794f, -0.07833589f, 0.01060229f, 0.27425766f, -0.16628386f, 
    0.09668863f, -0.05070284f, 0.05328291f, 0.01701645f, 0.01501336f, -0.03311656f, -0.05301604f, -0.13717723f, 
    -0.03071445f, -0.01464299f, -0.04265146f, 0.01564743f, -0.03138050f, -0.01658611f, 0.01195927f, 0.00701837f, 
    -0.01536752f, -0.01811411f, -0.03713572f, 0.01108142f, 0.02010785f, 0.02321783f, 0.00524193f, -0.02236339f, 
    -0.02485993f, -0.02212866f, -0.00094140f, 0.03093048f, 0.02344682f, 0.01533917f, 0.00227093f, 0.01860197f, 
    0.01722921f, 0.00820810f, -0.01245204f, 0.02743054f, -0.01162053f, 0.03152933f, 0.02415914f, -0.02810013f, 
    0.00643109f, 0.02463404f, 0.00697923f, 0.02377151f, 0.01389972f, -0.01369974f, -0.03713444f, -0.00702333f, 
    0.01706345f, -0.02585276f, -0.02348523f, 0.01687873f, 0.02241361f, -0.02498929f, -0.03764212f, -0.03460458f, 
    -0.01140419f, -0.01109627f, -0.00529205f, 0.02563493f, -0.00795837f, 0.00746540f, 0.01186476f, -0.02478695f, 
    0.00199268f, 0.00566907f, 0.01859832f, -0.03846785f, -0.02770771f, -0.03552607f, -0.00357984f, -0.02672043f, 
    0.00501023f, 0.01159904f, 0.00299485f, -0.00116755f, 0.02586832f, -0.02739985f, -0.01462231f, -0.02947165f, 
    -0.00210371f, 0.02475096f, -0.03043788f, -0.02605572f, -0.02169798f, -0.02419466f, -0.01823652f, 0.01571601f, 
    -0.00456364f, -0.03021055f, 0.02842534f, -0.02399996f, -0.00484300f, 0.02996494f, -0.04088218f, -0.01116318f, 
    -0.02791882f, -0.00338200f, -0.02175964f, 0.00035139f, 0.03231876f, -0.00919929f, -0.03509654f, 0.02364885f, 
    0.02436407f, 0.02411354f, 0.01798486f, -0.04232785f, 0.01102712f, -0.02052960f, 0.01502099f, 0.03011204f, 
    0.00359501f, -0.01807055f, -0.02880728f, -0.00496932f, -0.01316070f, -0.00712229f, -0.01895524f, 0.00789931f, 
    -0.00718333f, 0.02474888f, -0.00683173f, -0.00795949f, -0.01949394f, -0.02324701f, 0.01923451f, -0.00297496f, 
    0.00584903f, 0.03019826f, -0.00076940f, 0.03155443f, -0.01259055f, 0.00716156f, 0.00720785f, -0.03498101f, 
    0.01208907f, -0.03195202f, -0.03605313f, -0.01166841f, 0.00453666f, -0.01161050f, -0.01347080f, 0.01493804f, 
    -0.01101898f, 0.01937481f, 0.01472364f, -0.01052255f, -0.02268141f, -0.01019659f, -0.02978436f, -0.03204295f, 
    0.00609683f, -0.00280711f, 0.02206818f, 0.03097511f, -0.00552227f, -0.03605605f, -0.02866459f, 0.00284479f, 
    -0.02217541f, -0.03824893f, 0.00967402f, 0.02694774f, 0.02054396f, -0.00558855f, 0.02138569f, -0.00733851f, 
    -0.00052324f, -0.01628573f, 0.01750430f, 0.00950320f, 0.02251438f, -0.01258696f, 0.01466888f, -0.00030536f, 
    -0.03296030f, -0.03269245f, -0.00668778f, -0.01756833f, -0.01507672f, -0.00782686f, -0.02872535f, 0.01237296f, 
    -0.03626431f, 0.02151903f, 0.03021554f, -0.03018848f, -0.03871618f, 0.01271878f, 0.02324676f, -0.01543816f, 
    0.00817131f, -0.02504697f, -0.04162626f, 0.00698651f, 0.00610426f, 0.01195826f, 0.00425627f, 0.01433505f, 
    -0.01758711f, 0.01237535f, -0.00117135f, 0.02746059f, -0.01982537f, -0.02092226f, -0.02461151f, -0.01391031f, 
    0.02008868f, 0.00477949f, 0.00540101f, 0.00810892f, 0.01350186f, 0.00444308f, 0.01651813f, -0.01872015f, 
    0.00426722f, -0.03621446f, 0.02051098f, 0.02665258f, -0.03133050f, -0.00292737f, -0.00384277f, 0.02410282f, 
    0.00384520f, -0.02776553f, 0.00682487f, -0.04129226f, 0.00022482f, -0.00115775f, 0.01157351f, 0.02756642f, 
    -0.01632241f, 0.02853977f, -0.00935497f, -0.00845500f, -0.01931848f, -0.00124663f, -0.00463349f, 0.00273422f, 
    0.00357239f, 0.02037906f, 0.01317611f, 0.01899110f, 0.00250330f, 0.03189909f, -0.00554271f, -0.02058833f, 
    -0.03806581f, -0.03404086f, -0.02129797f, 0.01010708f, -0.01830533f, 0.03150441f, -0.03457452f, 0.00830460f, 
    0.01664457f, -0.02205148f, 0.03124478f, -0.01123928f, 0.00735427f, 0.00355506f, -0.01854802f, 0.01812301f, 
    -0.01283580f, -0.01823385f, 0.02961986f, 0.01339694f, -0.01806555f, 0.03154599f, -0.01907831f, -0.02171663f, 
    -0.00120947f, -0.01597860f, -0.03188574f, -0.00979792f, 0.02295747f, 0.00636830f, -0.00349322f, 0.01667407f, 
    0.03202629f, -0.02948714f, 0.00416738f, -0.01358610f, -0.01065798f, 0.00047893f, -0.03904415f, -0.03822335f, 
    0.02286270f, -0.00867687f, -0.00909553f, -0.03679273f, -0.03001581f, 0.00329656f, 0.00451456f, 0.00968459f, 
    -0.02115703f, 0.01022834f, -0.00492438f, -0.00437857f, 0.01891533f, 0.00290788f, -0.00284596f, 0.02164169f, 
    -0.00330911f, -0.03706835f, 0.01049719f, 0.00543530f, 0.01680337f, -0.03733965f, -0.04147294f, -0.03421647f, 
    0.00706753f, -0.03520673f, -0.02493769f, -0.03699996f, 0.00714073f, 0.01433267f, -0.03123824f, 0.00144585f, 
    -0.01550377f, 0.00252034f, 0.03233272f, 0.02376086f, 0.01625516f, -0.02285981f, -0.02089573f, 0.02488870f, 
    -0.02092404f, -0.02792678f, -0.00735531f, 0.03069038f, 0.01782651f, -0.00205978f, -0.04185598f, -0.03062038f, 
    0.00236533f, -0.02060888f, -0.01967257f, -0.02112454f, -0.02997855f, -0.03097519f, -0.00695811f, 0.01620810f, 
    0.00066046f, 0.01729767f, 0.00320354f, -0.02731784f, 0.02563420f, -0.02137615f, -0.00717898f, -0.03522963f, 
    -0.01527274f, 0.02954388f, 0.00852383f, -0.02776906f, -0.00842932f, 0.02593691f, 0.02696265f, -0.03190926f, 
    -0.03209310f, -0.03496355f, 0.02549511f, 0.01949124f, -0.03798446f, 0.00542946f, 0.01513133f, 0.02739900f, 
    0.01749299f, -0.02228738f, 0.01054850f, 0.00429206f, 0.01282849f, 0.03218978f, 0.01564557f, -0.03106796f, 
    -0.02943268f, 0.00856677f, -0.03065930f, -0.00699915f, -0.03800814f, 0.01691338f, -0.01039043f, 0.02748497f, 
    -0.03257839f, -0.01437748f, -0.02376822f, 0.00272572f, -0.00145224f, 0.02676664f, 0.02839795f, -0.02001037f, 
    0.01761526f, -0.02533499f, 0.00961009f, -0.01610244f, -0.00548687f, -0.00505124f, -0.00315759f, -0.00443066f, 
    0.00310007f, -0.02283479f, 0.01032751f, 0.01258529f, 0.02440587f, -0.03611286f, -0.02779047f, 0.01427526f, 
    -0.02060165f, 0.02655377f, 0.01010691f, -0.02222998f, -0.01951244f, -0.02591730f, 0.00575560f, 0.00791763f, 
    -0.03250175f, -0.03043250f, 0.02603590f, -0.02191261f, -0.01576540f, -0.00311045f, 0.02359135f, 0.00040759f, 
    -0.02532172f, 0.01425931f, -0.02889811f, -0.03965560f, -0.00130451f, -0.03094820f, -0.00283455f, 0.00724916f, 
    -0.02384317f, -0.02971105f, 0.01344483f, 0.00035255f, -0.03745413f, 0.01565619f, 0.01834381f, -0.03922834f, 
    -0.02764838f, -0.00179414f, -0.03589996f, 0.03040254f, -0.00192474f, -0.01449479f, -0.03704106f, -0.03828682f, 
    0.02728999f, -0.00099813f, 0.02158541f, -0.01250408f, -0.01022866f, -0.01108606f, -0.01036818f, -0.03728721f, 
    0.02620322f, 0.00679247f, 0.01050239f, 0.02239863f, 0.01515699f, -0.00640831f, -0.02771626f, -0.03221850f, 
    0.01468305f, 0.02356103f, -0.04036934f, 0.01401503f, -0.01362141f, -0.01983723f, -0.01824225f, -0.00205049f, 
    -0.01409316f, 0.03101273f, -0.02237342f, -0.02241822f, -0.03753049f, -0.03380861f, 0.02373379f, 0.03397933f, 
    -0.02812100f, 0.02127999f, 0.01636206f, -0.02924703f, 0.01171592f, 0.02357284f, 0.03096068f, 0.01637432f, 
    0.00285239f, 0.01623746f, -0.02099288f, 0.01370246f, -0.01785817f, -0.03267604f, -0.01930381f, 0.00720423f, 
    -0.02398848f, -0.01526787f, -0.02228184f, 0.02930387f, -0.02350510f, -0.00355209f, -0.02604171f, 0.01302059f, 
    -0.02956086f, -0.02533183f, -0.02479611f, -0.02506460f, -0.02090854f, -0.00933917f, -0.00416419f, 0.00125806f, 
    0.02741353f, -0.02136058f, -0.00535417f, -0.03294121f, -0.00086342f, 0.01207356f, 0.03349178f, -0.02366697f, 
    -0.02379267f, -0.03047080f, 0.01223687f, -0.02112161f, -0.00910070f, -0.03838059f, 0.02215193f, 0.00002730f, 
    0.02057939f, -0.03666310f, -0.01800514f, 0.00120040f, 0.01031982f, 0.02553907f, -0.00932159f, -0.04067703f, 
    -0.01182247f, 0.00447809f, -0.02024930f, -0.03325609f, -0.02929238f, -0.00224913f, -0.02300796f, -0.01370294f, 
    -0.00361179f, 0.02593259f, 0.02260770f, 0.01077462f, 0.00348938f, -0.00258586f, -0.02195238f, -0.00257114f, 
    -0.02872079f, -0.02566225f, 0.00340306f, 0.02073322f, 0.02889927f, -0.01793087f, -0.01510679f, 0.01068706f, 
    0.03047789f, -0.00465166f, -0.03608881f, 0.01939647f, -0.03005373f, -0.02979659f, 0.03417762f, -0.02246815f, 
    0.01807514f, -0.01211650f, 0.00710575f, -0.00239447f, -0.01788915f, 0.01385114f, -0.03658387f, -0.02421434f, 
    0.00310894f, 0.02504543f, -0.04125345f, 0.01427911f, 0.01566501f, 0.01529200f, 0.02423697f, -0.00546771f, 
    -0.01675668f, -0.03585126f, -0.01881924f, -0.01345826f, 0.01666030f, -0.00352529f, -0.02864378f, 0.02265173f, 
    -0.01222459f, 0.01279080f, 0.01042529f, -0.04208787f, -0.02860202f, -0.02290192f, -0.01653389f, -0.01161402f, 
    -0.02577755f, -0.00491844f, 0.00240644f, -0.00352893f, -0.01569434f, 0.01565469f, -0.01693730f, -0.03165679f, 
    0.02226214f, 0.02738082f, -0.02012289f, -0.03814320f, -0.00046513f, 0.02425348f, 0.01361687f, -0.04019346f, 
    -0.04090156f, -0.01624778f, 0.02294957f, -0.02248435f, -0.03529775f, 0.03086023f, 0.03194762f, 0.02503880f, 
    0.02426765f, 0.01190377f, -0.01027351f, -0.03140016f, -0.01458519f, 0.03044361f, -0.03271788f, 0.00699822f, 
    -0.00533146f, -0.04031074f, -0.03340900f, -0.03088314f, 0.03254367f, -0.00555800f, 0.00720005f, 0.00427619f, 
    0.02227278f, 0.01658710f, -0.02338714f, 0.00061897f, 0.00934303f, 0.01956370f, 0.01225589f, -0.00321763f, 
    0.02551124f, -0.03769669f, -0.03693489f, 0.01524601f, 0.01313108f, -0.00916421f, -0.01893251f, 0.01621578f, 
    0.02423670f, -0.00258660f, 0.00800582f, 0.02877305f, -0.01881897f, -0.00140311f, -0.04275261f, 0.02875097f, 
    -0.03561062f, -0.04012104f, 0.00998350f, -0.01032381f, -0.03065818f, -0.00473756f, 0.00383145f, -0.03977605f, 
    0.00205506f, 0.03171083f, -0.00522325f, 0.01708666f, 0.03099700f, 0.02298485f, 0.00277113f, 0.03138705f, 
    -0.01238348f, -0.01330564f, 0.00213763f, 0.00142491f, -0.01196340f, -0.00206885f, -0.02338952f, -0.00389262f, 
    0.01654613f, 0.01701163f, 0.02662741f, -0.04292506f, -0.00750872f, -0.03483569f, -0.01756373f, 0.01371704f, 
    -0.02906243f, -0.00009420f, 0.01292305f, -0.03681529f, -0.02760026f, -0.03588050f, 0.02083779f, 0.00917186f, 
    0.01408384f, -0.00668607f, -0.03672141f, 0.01763705f, -0.01566187f, 0.02830538f, -0.03773814f, 0.00134431f, 
    0.00784554f, 0.00739051f, -0.00924686f, 0.01862235f, -0.01365066f, -0.01662427f, 0.00378327f, -0.00955374f, 
    0.01767293f, -0.02318194f, 0.01649675f, -0.03496314f, -0.03042426f, -0.02273747f, 0.00147784f, 0.00684513f, 
    0.02460339f, 0.00735487f, -0.01126615f, 0.00648647f, 0.01803346f, -0.02593631f, -0.02380792f, -0.03442199f, 
    -0.01864612f, 0.03128539f, -0.03008077f, -0.03079155f, -0.02725848f, -0.02399894f, 0.01804871f, -0.02645597f, 
    -0.00041443f, 0.02245655f, 0.01203823f, 0.01410417f, 0.01014070f, 0.02264408f, -0.01953908f, -0.03075081f, 
    -0.00467223f, 0.00228867f, 0.03120395f, 0.00657267f, -0.02482487f, -0.00730741f, -0.00650092f, 0.02321147f, 
    -0.01624970f, -0.01870872f, 0.00261787f, 0.00606156f, -0.03234486f, -0.00401782f, -0.01930053f, 0.01257167f, 
    -0.01189847f, -0.02275703f, 0.02080961f, -0.00338423f, -0.00119913f, -0.00576932f, -0.04282578f, -0.01520862f, 
    0.30210659f, 0.15794976f, -0.18448080f, 0.16375330f, 0.16972432f, -0.04653737f, 0.08477014f, 0.00672526f, 
    0.09844737f, 0.12814549f, -0.05480149f, -0.04735805f, 0.33296081f, 0.26574057f, 0.12025800f, -0.03410798f, 
    -0.09481331f, -0.04761939f, -0.04391107f, -0.21505599f, 0.00339401f, 0.02162896f, -0.03799016f, -0.06965488f, 
    -0.21684594f, 0.04853813f, -0.10599124f, 0.03852168f, -0.05305513f, 0.02194182f, 0.06468245f, 0.02079942f, 
    0.10021377f, 0.16032240f, -0.02674990f, 0.07603434f, 0.10483218f, -0.20750967f, -0.16239448f, -0.10623536f, 
    0.09344479f, 0.05297855f, 0.04080038f, 0.00229877f, 0.04882905f, -0.00233830f, 0.07490142f, 0.01792218f, 
    0.12696031f, -0.13463494f, -0.09259562f, -0.12609884f, 0.00281385f, -0.00320526f, -0.06165288f, 0.10357258f, 
    0.04167822f, 0.08442259f, 0.05919862f, 0.06332612f, 0.23009740f, 0.20259987f, 0.06001727f, -0.04655259f, 
    -0.08171497f, -0.02311875f, -0.04364730f, -0.11953748f, 0.01203214f, -0.09271201f, 0.05465624f, -0.08449282f, 
    0.23452710f, 0.07121791f, -0.05230741f, 0.13143700f, 0.00228664f, -0.01662631f, 0.10222324f, 0.03312671f, 
    0.03944419f, -0.11095582f, 0.02552881f, -0.11437110f, 0.21022020f, 0.08675757f, 0.07502866f, -0.24630634f, 
    -0.00495517f, -0.06727427f, 0.05122837f, -0.06630217f, -0.04208351f, 0.06557143f, -0.00555611f, 0.05532584f, 
    0.32358792f, 0.17467739f, 0.01101242f, 0.02977754f, 0.10921403f, -0.03141430f, -0.02697046f, 0.01604690f, 
    -0.10745558f, 0.06115961f, 0.12173654f, 0.07651389f, 0.37821752f, 0.05541288f, 0.03978662f, 0.12562415f, 
    -0.04193136f, 0.06789979f, 0.03224350f, -0.00427557f, 0.09896546f, -0.00935510f, 0.00726735f, -0.01688516f, 
    0.45837769f, -0.09894804f, 0.01088803f, 0.02661508f, -0.02460540f, -0.02367753f, 0.12154596f, 0.01963112f, 
    0.07753837f, 0.12588204f, -0.13217112f, 0.09054485f, 0.03897464f, -0.18652155f, 0.01755134f, -0.10989244f, 
    -0.10173995f, 0.09098062f, -0.06843635f, -0.02680814f, 0.07553791f, 0.06446344f, -0.07911405f, -0.04858859f, 
    0.15448530f, 0.03249592f, 0.04389887f, -0.03959632f, -0.06652179f, 0.04385474f, 0.12088026f, -0.09453656f, 
    0.07605352f, -0.04166941f, -0.06946574f, -0.08610949f, -0.00576517f, 0.20857140f, 0.14638408f, -0.21233492f, 
    0.06515989f, -0.03953985f, -0.09675048f, -0.03764606f, -0.05302453f, 0.11416727f, 0.03107687f, 0.20827040f, 
    -0.01554136f, 0.09513042f, -0.06776655f, 0.05398520f, -0.06049281f, -0.01610211f, -0.05502423f, -0.01829848f, 
    0.00190961f, 0.04813694f, 0.15931970f, 0.08454972f, -0.27121055f, -0.20012462f, -0.02944292f, -0.01128698f, 
    0.05119623f, 0.03758498f, -0.14091960f, -0.05289264f, -0.05390304f, 0.12075213f, -0.11215849f, 0.14703879f, 
    -0.54002613f, -0.09636990f, 0.34838045f, 0.23839416f, 0.03891752f, 0.03870098f, -0.08035785f, 0.14161484f, 
    0.10835805f, 0.03897724f, -0.03412064f, -0.09901873f, 0.27542022f, 0.19383472f, 0.00752550f, -0.03790237f, 
    0.28318292f, 0.04664697f, 0.05115608f, 0.03301284f, 0.06360750f, 0.05523908f, 0.00478772f, 0.00043370f, 
    -0.15663600f, 0.07533238f, -0.13952762f, 0.02820488f, 0.03507939f, -0.07746470f, 0.13181698f, 0.02669575f, 
    0.04356307f, -0.02758928f, -0.00327255f, -0.03901461f, 0.35233951f, -0.03381138f, -0.02199857f, -0.07373945f, 
    -0.10742225f, -0.08596878f, 0.04842725f, 0.05490208f, -0.00344613f, -0.09229347f, -0.06871752f, -0.05368330f, 
    0.01136454f, -0.34638119f, -0.14619663f, 0.12526281f, 0.01265709f, 0.10030245f, 0.00248272f, -0.08748429f, 
    0.06783297f, 0.07636692f, 0.03881022f, 0.16742301f, -0.04215673f, -0.19348589f, -0.06189205f, -0.03201473f, 
    0.10680019f, 0.03738301f, -0.05945149f, -0.09762938f, -0.01857684f, -0.00642516f, -0.06258019f, -0.10411943f, 
    0.14550696f, -0.14915973f, 0.11728797f, 0.30596358f, 0.04742847f, 0.14758645f, 0.18850265f, 0.05003285f, 
    -0.10746025f, 0.15418020f, 0.00702656f, 0.01132310f, 0.26911101f, 0.13887049f, -0.04719588f, -0.09851854f, 
    -0.04003213f, 0.04109887f, -0.00184019f, -0.06104215f, -0.05932605f, 0.00752716f, -0.02495945f, -0.02485710f, 
    0.02058332f, 0.06206859f, 0.17583084f, 0.06554802f, -0.01775854f, -0.08600790f, 0.03205813f, 0.02751248f, 
    -0.01799387f, 0.05600837f, 0.07777378f, 0.11089484f, 0.02992022f, -0.08595207f, -0.04470504f, 0.01339085f, 
    0.11350145f, 0.05587503f, 0.02234094f, 0.00857935f, -0.01785813f, 0.14764808f, -0.02902122f, 0.02908986f, 
    0.02252643f, -0.09637098f, -0.16843976f, -0.24626549f, 0.09258396f, -0.03801418f, -0.02582035f, -0.01339839f, 
    0.04668177f, 0.02340123f, 0.03507832f, 0.13020451f, 0.08902266f, 0.04884338f, 0.05586284f, 0.02630872f, 
    0.01146270f, 0.07248338f, 0.02250265f, 0.09168398f, 0.06773530f, 0.06303292f, 0.09322690f, 0.17683083f, 
    -0.17204386f, 0.17803364f, -0.00812629f, 0.05723413f, 0.09190426f, 0.15170304f, 0.02029805f, -0.06452323f, 
    0.03764122f, 0.02284605f, -0.24555573f, -0.18388815f, 0.32076037f, -0.32047769f, -0.14190608f, -0.02657101f, 
    0.19453393f, -0.09129963f, 0.01645741f, -0.02144798f, -0.05959481f, -0.04027295f, 0.17175084f, 0.05515646f, 
    0.00214662f, -0.11170710f, 0.04049078f, 0.03360008f, -0.02224650f, 0.00391096f, -0.15667054f, -0.03633317f, 
    0.02926338f, 0.03045209f, 0.00774125f, -0.08538117f, 0.33338335f, 0.14085865f, -0.09969386f, 0.07478067f, 
    -0.09588750f, -0.08150516f, 0.04805371f, 0.04260772f, 0.06740402f, 0.09845525f, -0.12051927f, -0.10477047f, 
    0.01465453f, 0.22365640f, -0.07852361f, -0.09379761f, 0.08627847f, 0.07523599f, -0.03044837f, 0.05435604f, 
    -0.07616468f, 0.11791725f, 0.08727802f, -0.09583785f, 0.26696128f, 0.16435869f, -0.07408714f, 0.09206741f, 
    0.19264591f, 0.14505649f, -0.04653471f, 0.06852973f, -0.04687808f, -0.03154870f, -0.24692371f, -0.01713404f, 
    0.14026725f, 0.20857356f, -0.12232276f, 0.16404717f, 0.00947453f, -0.00439948f, 0.01975302f, 0.00781614f, 
    0.03158152f, 0.12803115f, 0.08411923f, -0.01508248f, -0.03891293f, 0.03016768f, -0.04551439f, 0.11378483f, 
    -0.06004371f, 0.02258929f, -0.07673246f, 0.07422508f, 0.04832756f, 0.18556826f, -0.01145156f, 0.07586553f, 
    -0.13907169f, 0.00286513f, 0.00959172f, 0.03675416f, 0.13194311f, -0.04727648f, 0.05256115f, 0.06316741f, 
    0.18358715f, 0.00850167f, 0.13490149f, 0.04384647f, -0.17157093f, 0.19570318f, -0.07898593f, 0.11658161f, 
    -0.05303242f, -0.06122136f, 0.03595957f, 0.05542365f, 0.11441818f, 0.02752334f, -0.03455498f, -0.22854468f, 
    -0.11997530f, 0.33584446f, -0.14203136f, 0.09509333f, -0.05426649f, 0.05578945f, 0.01838629f, 0.04461715f, 
    -0.01498763f, -0.13164480f, -0.01951386f, 0.09137379f, -0.26952666f, -0.06668843f, -0.11630339f, -0.09873909f, 
    -0.04084993f, 0.00602898f, -0.05150989f, -0.01024548f, 0.01801958f, 0.01375307f, -0.04664560f, 0.00561209f, 
    -0.20089187f, 0.19257145f, -0.12102301f, -0.03924888f, -0.02443234f, -0.14128315f, -0.05318753f, -0.00090710f, 
    0.04061149f, -0.01339863f, 0.04267982f, 0.01063412f, 0.34603962f, -0.04780573f, -0.11582159f, 0.01409384f, 
    -0.07904397f, 0.01981097f, -0.00805550f, 0.09695837f, 0.06587283f, -0.09427349f, 0.01490723f, -0.14916369f, 
    -0.08699691f, -0.18264331f, -0.19220304f, 0.07308216f, 0.10026076f, -0.13163069f, 0.21425466f, 0.05594925f, 
    -0.04022905f, -0.16533944f, -0.09643121f, 0.08844482f, -0.18380053f, -0.09389617f, -0.09190924f, -0.05580698f, 
    0.17394884f, -0.04440642f, -0.01058131f, -0.08382585f, 0.04740363f, 0.01462576f, 0.06897023f, 0.09777704f, 
    0.13764302f, 0.10855148f, 0.03087889f, -0.05878150f, 0.01613138f, -0.04500581f, -0.04802548f, -0.00720816f, 
    0.11538018f, -0.03997165f, -0.05430247f, 0.08084783f, -0.22800738f, 0.11046498f, -0.24499360f, 0.03077624f, 
    -0.02817831f, 0.01617984f, -0.11267325f, -0.08167416f, -0.05558136f, -0.18633099f, 0.23027816f, 0.07551098f, 
    -0.00712565f, 0.25518820f, -0.04360102f, -0.13785215f, 0.03526183f, -0.02305967f, -0.03594188f, 0.04029244f, 
    0.05636958f, 0.05505635f, -0.02806413f, 0.03341551f, -0.28406388f, -0.22963488f, -0.04430392f, 0.15136625f, 
    0.02142140f, 0.09404881f, -0.02674131f, 0.04644430f, 0.03695530f, -0.00573727f, 0.10225637f, 0.11459941f, 
    0.06678363f, 0.14615989f, -0.22536753f, 0.00598400f, 0.12150444f, 0.01178985f, 0.09010097f, 0.07653864f, 
    -0.01430391f, 0.02430259f, 0.23565938f, 0.13719830f, 0.18244524f, 0.10289561f, 0.05354402f, 0.07669709f, 
    -0.07975836f, -0.08781466f, 0.03373151f, 0.04025424f, 0.10900233f, 0.05178899f, 0.03534123f, 0.05226419f, 
    -0.08257024f, 0.21167280f, 0.04320249f, -0.02683146f, -0.18329130f, -0.05783826f, 0.09354942f, 0.12299933f, 
    0.00311038f, 0.01820260f, -0.00209920f, -0.11629733f, -0.15486710f, -0.18435453f, 0.16415055f, 0.20812979f, 
    -0.01324988f, -0.01901246f, 0.05942493f, -0.05302862f, 0.01712957f, -0.08686512f, -0.09941117f, -0.05449951f, 
    0.14973827f, -0.07530790f, 0.15145439f, 0.15999812f, 0.07518809f, -0.08219637f, 0.14256127f, -0.03190388f, 
    0.08757740f, 0.00064961f, 0.03199938f, -0.12681124f, 0.08806391f, -0.23773541f, -0.15551218f, 0.19477923f, 
    0.11674578f, 0.09867726f, -0.02046739f, 0.02678045f, -0.07391804f, 0.08183571f, -0.01576213f, 0.11381406f, 
    -0.00554895f, -0.09844907f, -0.13844077f, 0.21762776f, 0.08650500f, 0.09853053f, -0.00290036f, -0.06144060f, 
    -0.09854852f, 0.02304064f, 0.01716712f, 0.19362098f, 0.38432425f, -0.10607009f, -0.14411898f, -0.11686772f, 
    -0.10589079f, -0.07154122f, 0.15578242f, -0.06989423f, -0.06249103f, -0.10265981f, 0.08219458f, -0.01479092f, 
    -0.05886170f, -0.34882867f, 0.15067354f, 0.17150635f, -0.05504245f, -0.02599097f, 0.07601398f, -0.15999591f, 
    0.10978317f, 0.04030827f, 0.00016237f, -0.08202244f, 0.11176138f, 0.22557461f, -0.01019660f, 0.02435787f, 
    -0.06982296f, -0.03579169f, -0.02906983f, -0.04864075f, -0.09562154f, -0.01013485f, -0.02973240f, -0.11360955f, 
    0.05278468f, -0.18793868f, 0.26455492f, 0.16031098f, 0.07226108f, -0.01090418f, -0.09149057f, -0.15389405f, 
    -0.06323865f, 0.04663255f, -0.07589149f, 0.10225535f, 0.23250087f, 0.15988988f, -0.17526546f, 0.24251148f, 
    0.08240421f, 0.05989408f, 0.02043711f, 0.06522072f, -0.00264075f, 0.06789213f, 0.20173119f, 0.09852312f, 
    0.10901666f, -0.16801323f, -0.24322912f, 0.19919571f, 0.20170508f, 0.05611439f, 0.02265648f, -0.06100870f, 
    -0.03080052f, -0.05568244f, 0.09159995f, 0.03485504f, 0.04756511f, 0.04102819f, 0.04514850f, 0.17197682f, 
    0.02894678f, 0.06954160f, -0.08397190f, -0.11923403f, 0.03636136f, 0.06299257f, 0.05812877f, 0.21085954f, 
    -0.03318159f, -0.00192288f, 0.18707009f, -0.02156877f, 0.00291123f, 0.06228475f, 0.11391373f, -0.04333648f, 
    -0.00717325f, -0.04519636f, 0.02136206f, -0.06501913f, 0.03961875f, 0.00024815f, -0.11095931f, 0.01494897f, 
    -0.02943935f, -0.01495737f, -0.10866672f, 0.11327209f, -0.00571841f, 0.03617768f, 0.16650689f, 0.16951077f, 
    -0.10097826f, 0.02652127f, 0.12360149f, -0.27380466f, 0.03708600f, -0.01250337f, -0.08213612f, -0.05144104f, 
    -0.11624057f, -0.06604854f, 0.01377877f, -0.00761452f, 0.05958790f, 0.02884508f, 0.00698677f, 0.16813251f, 
    0.04648210f, 0.08064681f, 0.12526144f, 0.06828008f, -0.10647164f, -0.10328636f, 0.04628585f, -0.09295437f, 
    -0.02991969f, -0.06651872f, -0.15107629f, -0.10353610f, 0.01240722f, 0.16996789f, -0.01365964f, -0.07470873f, 
    0.12154807f, 0.01172573f, 0.07348479f, 0.09307790f, -0.11305092f, -0.02362706f, 0.08895756f, -0.19409440f, 
    0.06815892f, 0.06432223f, 0.03895571f, -0.06749446f, -0.07380604f, -0.01965448f, -0.02826744f, 0.09127612f, 
    -0.12245967f, 0.10405186f, -0.08241763f, -0.09157825f, 0.07089733f, 0.14022501f, 0.08810171f, 0.03843062f, 
    0.15162089f, -0.02270314f, 0.02319953f, 0.00138603f, 0.15623562f, -0.00791218f, 0.11448904f, 0.01444401f, 
    0.07922065f, -0.04289595f, 0.15014383f, 0.09327117f, -0.11589988f, 0.05363644f, 0.00125248f, -0.08370936f, 
    0.13039444f, -0.03500178f, -0.10034110f, 0.04284967f, -0.04429845f, 0.04105811f, 0.09254409f, 0.10966446f, 
    0.05971028f, 0.03347305f, 0.07138382f, -0.06194093f, 0.42015317f, -0.30735654f, 0.09799361f, 0.10257722f, 
    0.03739762f, -0.00581884f, -0.01548522f, 0.02936057f, 0.03813810f, 0.06020142f, -0.10046521f, 0.09360074f, 
    0.30048862f, -0.10209550f, -0.28865942f, -0.02849229f, 0.08684631f, 0.06949946f, 0.06199698f, -0.09626434f, 
    0.01388892f, -0.07672453f, -0.01159300f, 0.03054025f, 0.38026160f, 0.00062376f, -0.18584238f, 0.09013655f, 
    -0.07460814f, 0.03090997f, -0.03634109f, 0.00687578f, -0.03511576f, 0.07940515f, -0.05176638f, -0.03147105f, 
    -0.16572419f, 0.03492566f, 0.04675950f, 0.16009650f, 0.01228991f, 0.01360780f, 0.09017533f, -0.05264384f, 
    0.06964294f, 0.03909424f, 0.04865837f, -0.07719342f, -0.19541141f, 0.19893120f, -0.10712033f, 0.02332731f, 
    0.12416483f, -0.04168510f, -0.00324780f, -0.02533662f, 0.02058828f, 0.03617977f, 0.05086136f, -0.03721819f, 
    0.03864571f, 0.08830158f, -0.06750363f, 0.22510433f, 0.12677656f, 0.05575433f, -0.03966558f, 0.11956225f, 
    0.04410378f, 0.08213950f, -0.04151791f, -0.08303382f, 0.24906099f, -0.27571148f, 0.09841808f, 0.06417208f, 
    0.07791211f, 0.01895548f, -0.07043362f, 0.05892807f, 0.07020684f, 0.00660838f, 0.10420286f, 0.05698735f, 
    -0.01289113f, 0.03486821f, -0.02220391f, 0.11260243f, 0.05371639f, 0.11755934f, -0.04749187f, -0.05451646f, 
    0.21443996f, 0.03178488f, 0.12414919f, -0.05688327f, -0.41962829f, -0.12790203f, -0.17055927f, 0.00401706f, 
    0.09573252f, -0.10126990f, 0.08328491f, 0.01283681f, -0.00099645f, -0.07218602f, 0.07628666f, -0.00992217f, 
    0.14750895f, 0.23929676f, -0.06685686f, -0.18357348f, 0.06255910f, 0.00282079f, -0.10290866f, 0.13960730f, 
    -0.10686853f, -0.14923730f, 0.01352542f, 0.04628974f, -0.06271660f, -0.14942811f, 0.18544438f, 0.01521732f, 
    0.00969580f, -0.03820904f, 0.02498175f, 0.01577552f, 0.00926969f, -0.05040471f, 0.03613241f, 0.04068843f, 
    -0.30689603f, -0.06130011f, 0.08235155f, 0.09933362f, -0.03632967f, -0.02216340f, 0.08929734f, 0.06181407f, 
    0.01334820f, -0.03408141f, -0.06252848f, -0.00765283f, -0.01293034f, 0.18457223f, 0.11992738f, -0.03501115f, 
    0.09650084f, 0.07282242f, 0.17475192f, 0.06625750f, 0.08861299f, 0.06087576f, -0.01361857f, -0.09918307f, 
    -0.28999919f, 0.11350120f, -0.12896301f, -0.16900015f, 0.09303084f, 0.00074523f, -0.05496081f, -0.02752901f, 
    0.02694949f, 0.05558496f, 0.01932562f, -0.03413764f, -0.20175168f, -0.04785666f, -0.09615182f, -0.22724015f, 
    0.10949872f, 0.03943394f, -0.04659770f, -0.14583710f, 0.02077893f, -0.10274144f, -0.13661517f, -0.01571371f, 
    -0.11326634f, 0.17069253f, -0.32150128f, -0.14841908f, 0.07054270f, -0.11736836f, 0.03414216f, 0.08955085f, 
    -0.09229579f, 0.06967743f, 0.07590745f, -0.00755955f, 0.21340376f, 0.09542748f, 0.13587108f, 0.02176394f, 
    -0.00763503f, 0.01152264f, 0.03400905f, -0.06042579f, 0.01855461f, -0.05129578f, 0.09104517f, 0.04688274f, 
    0.10164569f, -0.07997064f, 0.03392832f, -0.01127892f, -0.07167950f, 0.05898032f, 0.13276820f, 0.10929789f, 
    0.05847498f, 0.01452780f, -0.06920011f, 0.13757810f, -0.27721119f, 0.03214102f, 0.08636717f, -0.03031271f, 
    0.05331513f, 0.11889505f, -0.07124934f, -0.05701090f, -0.10588091f, -0.03902549f, -0.07547788f, 0.03795048f, 
    -0.46527180f, 0.07554204f, 0.25152433f, -0.13599990f, 0.06104734f, 0.03516592f, -0.00555425f, -0.04879395f, 
    0.08278972f, -0.03802983f, 0.05183822f, 0.09456541f, 0.27677590f, 0.03593085f, -0.00656004f, 0.09842814f, 
    -0.03893644f, -0.05336432f, 0.09767388f, 0.03880901f, 0.15802515f, -0.01280809f, -0.12597491f, 0.01204727f, 
    0.21317537f, 0.11642151f, 0.02030478f, 0.20961729f, 0.09617452f, 0.11697115f, -0.06097623f, 0.09207127f, 
    -0.14603332f, -0.06704435f, -0.02472643f, -0.12123812f, -0.29734743f, -0.00005770f, 0.05495839f, -0.13935958f, 
    0.06090920f, 0.02622189f, -0.04178102f, -0.03414537f, -0.00762909f, -0.00108478f, -0.03947534f, 0.08797131f, 
    -0.09590483f, 0.19922364f, -0.00522912f, -0.02552666f, 0.01564821f, -0.00851124f, 0.01624960f, 0.00252704f, 
    -0.01341862f, 0.02109429f, -0.10583646f, 0.01907234f, 0.07537267f, 0.00539772f, -0.00212078f, 0.10291170f, 
    -0.03236808f, 0.02578494f, 0.00134839f, 0.08004302f, -0.04742672f, 0.17806728f, -0.00770594f, -0.08733454f, 
    -0.02659174f, -0.02648593f, 0.06546091f, -0.03719581f, 0.15487437f, 0.01637933f, 0.03749406f, -0.00069831f, 
    0.00919534f, 0.01310586f, -0.07080138f, -0.02924903f, 0.30546451f, -0.09725656f, -0.08579047f, 0.04308906f, 
    -0.13948254f, -0.04781723f, -0.05245592f, -0.05259558f, 0.09178191f, 0.01767900f, 0.10702612f, 0.11023635f, 
    0.19214647f, -0.13819234f, -0.00129134f, -0.07078505f, -0.15043126f, -0.06232488f, -0.02160968f, 0.03717373f, 
    0.01754681f, 0.00563863f, -0.03402987f, 0.08767345f, -0.02380250f, 0.14571129f, 0.06416586f, -0.10136830f, 
    -0.15753511f, 0.02450010f, 0.01925570f, -0.05159491f, 0.01583306f, -0.05625114f, 0.03265455f, 0.06095939f, 
    -0.04801929f, -0.00237368f, -0.11397132f, 0.13050054f, 0.06827542f, -0.04911039f, 0.03418222f, -0.00995799f, 
    0.06587616f, 0.03958128f, 0.06589781f, 0.14185049f, 0.04125506f, -0.03873057f, -0.02016824f, 0.01835261f, 
    -0.02434181f, 0.12421338f, 0.03138940f, -0.10011943f, 0.00082296f, -0.00401626f, -0.04635392f, -0.11000701f, 
    0.21983074f, -0.01529872f, 0.10741006f, 0.08544348f, 0.04191997f, -0.01728286f, 0.01710367f, -0.03708210f, 
    0.07966111f, 0.03033146f, 0.16674712f, -0.00030596f, -0.03156248f, -0.02587871f, -0.13497810f, -0.03842814f, 
    0.14554903f, -0.03190248f, -0.05807582f, -0.06489737f, 0.00274852f, -0.09812335f, 0.05927822f, 0.01941985f, 
    0.24368629f, -0.25585118f, 0.19080764f, -0.07114895f, 0.06418551f, -0.02173601f, -0.03792476f, -0.06907415f, 
    -0.00771160f, 0.03210839f, 0.00096557f, 0.02816390f, 0.00183105f, 0.02977942f, 0.07530756f, 0.04961880f, 
    0.10026309f, 0.15443508f, -0.00786836f, 0.06111474f, -0.00573893f, -0.09974869f, -0.02623676f, 0.04817902f, 
    -0.19908075f, -0.12909861f, 0.16400775f, -0.12422322f, 0.08038364f, -0.06076473f, -0.08865512f, -0.11218788f, 
    -0.05287762f, -0.16611436f, 0.07301234f, -0.00771466f, 0.06384931f, -0.10784226f, -0.08690884f, -0.02346686f, 
    -0.00166206f, -0.03604462f, 0.01424853f, -0.08070385f, -0.05176741f, 0.08902796f, 0.02506917f, -0.02022844f, 
    0.19945894f, -0.22099856f, 0.15584667f, 0.23944500f, 0.00133122f, 0.09727025f, 0.00081493f, -0.01978113f, 
    0.06623634f, -0.01653758f, -0.09749029f, 0.01099029f, -0.18307659f, -0.18124098f, 0.06550655f, 0.06394620f, 
    0.00003119f, 0.05600959f, -0.07921729f, -0.18048105f, -0.14125466f, -0.00286141f, 0.02343206f, -0.00055290f, 
    0.63251370f, -0.31822747f, -0.00880787f, 0.14774819f, -0.02211524f, -0.05789769f, 0.02742649f, 0.01765006f, 
    0.04096970f, 0.05804488f, 0.08299975f, 0.10399921f, -0.03507756f, -0.04505127f, -0.27197528f, 0.03075712f, 
    0.02285612f, -0.18670402f, 0.02832187f, 0.05333793f, -0.14065021f, -0.01748810f, 0.11452533f, 0.00027292f, 
    0.50038302f, -0.29089144f, -0.15826611f, -0.02049163f, 0.03442784f, -0.04842878f, 0.03409709f, 0.01172791f, 
    0.04675716f, -0.00149806f, 0.12015995f, 0.00419019f, 0.12018549f, -0.05667397f, 0.06456663f, 0.04260214f, 
    0.08330724f, 0.04418577f, -0.04492601f, 0.10361039f, 0.03987451f, 0.13916649f, 0.00709882f, 0.02337261f, 
    0.33485848f, 0.26689008f, 0.05979513f, 0.04465254f, 0.03024182f, -0.05491024f, -0.07817259f, -0.04502832f, 
    0.13049650f, 0.06538276f, -0.01846045f, -0.02910001f, -0.10973929f, 0.07369489f, 0.07172896f, -0.17286664f, 
    -0.00974500f, -0.08084871f, -0.08453858f, 0.10218769f, 0.03975006f, -0.00035114f, 0.08355891f, 0.03473272f, 
    -0.46348163f, 0.11720771f, -0.00779842f, 0.04415276f, 0.03034482f, 0.10082945f, 0.00477676f, 0.07454611f, 
    0.03695306f, -0.07132516f, -0.05952225f, 0.02072811f, -0.24805236f, 0.01555856f, -0.06986175f, -0.41471466f, 
    0.04688124f, -0.00476022f, -0.00988219f, -0.01287872f, 0.09327527f, -0.05760763f, 0.05130643f, 0.02236784f, 
    -0.06766706f, 0.03226639f, -0.07605010f, -0.04702731f, -0.07536469f, -0.10675873f, -0.05603604f, 0.02205732f, 
    0.03124173f, 0.09876113f, 0.12273517f, -0.00529628f, -0.21395721f, 0.17921664f, 0.07197207f, -0.03262408f, 
    0.12989332f, 0.06307108f, 0.03883299f, 0.12461474f, 0.12354490f, -0.04545340f, 0.00261361f, 0.05671261f, 
    -0.29234451f, 0.13920425f, -0.21700871f, -0.03352958f, -0.09991334f, -0.04209790f, 0.16753425f, 0.03988441f, 
    -0.01702871f, 0.06199328f, 0.07897668f, -0.03520725f, 0.21448936f, 0.14749804f, -0.00866450f, 0.17555486f, 
    0.07956170f, -0.03436760f, 0.07387373f, 0.04650646f, 0.00164990f, -0.09990115f, -0.09054576f, -0.06589078f, 
    -0.13187353f, 0.36334381f, -0.11037716f, -0.18983170f, 0.11585104f, -0.11949223f, -0.03653321f, 0.04866372f, 
    0.12951696f, 0.03162154f, -0.03534842f, -0.08369961f, 0.09335008f, 0.25662005f, 0.21288787f, 0.03722146f, 
    -0.03387055f, 0.00482459f, -0.07170407f, -0.10114355f, -0.07748584f, 0.05356384f, 0.06927544f, -0.06673963f, 
    -0.33985907f, 0.12245195f, -0.13540070f, -0.37462455f, 0.00576535f, -0.12181646f, -0.09058017f, -0.05632577f, 
    -0.11791638f, -0.03703307f, -0.07516469f, -0.03408783f, -0.07302451f, -0.09462185f, 0.09976511f, 0.00771316f, 
    0.08391831f, 0.02589871f, 0.00352898f, 0.07344078f, -0.08918293f, 0.10682324f, -0.09546407f, 0.01592349f, 
    0.22648022f, 0.17653710f, 0.10076192f, -0.09572047f, -0.01202889f, 0.01532106f, 0.08254051f, -0.03458785f, 
    -0.04799462f, 0.06571522f, -0.00286831f, -0.00724873f, -0.10895485f, 0.05435905f, 0.01351852f, 0.25567994f, 
    -0.12322902f, 0.06679731f, -0.03850099f, 0.02184109f, 0.08305914f, 0.10340402f, -0.00436294f, 0.21230510f, 
    0.02396058f, 0.00063718f, 0.02906524f, 0.00919654f, -0.03876023f, -0.00177828f, 0.00811912f, -0.02353133f, 
    0.02893909f, 0.02303175f, 0.02773223f, 0.01958111f, 0.03571437f, -0.01535895f, -0.04135514f, 0.02338910f, 
    0.01704562f, -0.03816447f, 0.02948868f, -0.00814621f, -0.01990573f, 0.01337222f, -0.03031807f, 0.01862207f, 
    -0.00758221f, 0.01956433f, 0.00917941f, 0.01945311f, -0.02215580f, 0.02969674f, -0.03523332f, 0.00735222f, 
    -0.02954258f, 0.01394955f, -0.01221811f, -0.01357896f, -0.02077356f, 0.01616924f, -0.03400459f, -0.02723978f, 
    -0.02953167f, -0.01685890f, 0.00786276f, -0.02995949f, -0.03039652f, -0.03758958f, -0.01585610f, -0.00484591f, 
    -0.00331331f, -0.03426280f, -0.04077118f, 0.01687326f, -0.04174434f, -0.01338643f, -0.02605691f, 0.02413073f, 
    -0.00471189f, 0.00909711f, -0.00023337f, -0.02602712f, -0.03358414f, -0.01619154f, 0.02035017f, 0.02330275f, 
    -0.02824318f, -0.03465019f, -0.01954827f, 0.00827269f, 0.01389469f, 0.00205597f, -0.02592628f, -0.03313624f, 
    -0.02929975f, 0.00734388f, -0.02126931f, -0.00271968f, -0.00392758f, 0.02067820f, 0.01177946f, -0.00046997f, 
    0.02369846f, -0.00801485f, -0.04096568f, -0.02232611f, -0.03172944f, 0.00603650f, 0.02192719f, -0.00366537f, 
    -0.04042594f, -0.02703929f, 0.00077133f, 0.03131691f, -0.01689768f, -0.04081764f, -0.00418784f, -0.01907935f, 
    -0.00578436f, 0.03264330f, -0.02854812f, 0.00545936f, -0.02649189f, -0.03417457f, -0.01621723f, -0.02401866f, 
    0.02612154f, 0.01166583f, -0.02891570f, 0.01933585f, -0.02609049f, 0.00420370f, 0.00469355f, -0.02311082f, 
    -0.02930095f, -0.00147205f, 0.00588786f, 0.00376477f, -0.04081581f, -0.01521990f, -0.01521949f, -0.03968450f, 
    0.00476225f, -0.00520979f, 0.01289545f, -0.03214228f, -0.03379185f, 0.02471609f, -0.00211057f, -0.02661811f, 
    -0.02616318f, -0.02355385f, -0.02519337f, 0.01445298f, 0.01829557f, 0.01242597f, -0.03477910f, 0.01415284f, 
    -0.02028499f, 0.04194256f, -0.00958382f, -0.01895105f, 0.02928536f, 0.02700183f, -0.01254705f, -0.02206152f, 
    0.02947501f, -0.01684634f, 0.02627506f, 0.02449445f, 0.01495697f, -0.00730265f, -0.03922372f, 0.00223394f, 
    -0.01053946f, 0.03245792f, 0.01121281f, 0.02407992f, -0.00185704f, -0.03968559f, 0.02366062f, -0.00690400f, 
    0.00090164f, -0.01397794f, -0.00228273f, -0.03550287f, -0.03841990f, -0.03378115f, -0.01731037f, -0.03080921f, 
    0.00728930f, 0.02012758f, -0.02540571f, -0.00608316f, 0.02309450f, -0.00172614f, 0.02684712f, -0.00309848f, 
    -0.03155329f, -0.02742437f, 0.02069049f, 0.02672667f, -0.02812494f, 0.00117690f, -0.01719089f, -0.03661722f, 
    -0.03471861f, 0.00640870f, 0.02223578f, 0.01371725f, 0.01108844f, 0.00628715f, -0.02583657f, 0.00707628f, 
    0.00800148f, 0.02542854f, 0.02524406f, -0.02451001f, 0.02459389f, 0.03502950f, -0.04013044f, -0.03335351f, 
    0.01222003f, -0.03485804f, -0.01814628f, -0.03670333f, -0.00574913f, 0.01272157f, 0.02993830f, 0.01238495f, 
    0.00130512f, -0.03973006f, -0.00508253f, 0.03925345f, -0.03213898f, -0.00895438f, -0.00011000f, 0.00070631f, 
    0.02817751f, -0.01721134f, 0.02675581f, 0.01323596f, -0.03670082f, -0.00967695f, -0.02932027f, 0.02374821f, 
    -0.00185330f, -0.00567125f, -0.02463427f, -0.03065431f, -0.00285694f, 0.01863962f, 0.02821260f, -0.02467227f, 
    0.02347060f, -0.01137215f, -0.01736866f, 0.01329673f, 0.00922809f, -0.02831660f, 0.02940683f, -0.00221083f, 
    -0.01452296f, -0.02050745f, 0.02135600f, 0.02050560f, -0.02938445f, 0.00174735f, 0.02913373f, -0.01247204f, 
    -0.01286905f, -0.03198069f, 0.02836625f, -0.01157437f, 0.02851962f, 0.02082738f, 0.02586825f, 0.01392290f, 
    -0.04053234f, -0.02280331f, 0.00736138f, -0.00664679f, 0.01453541f, 0.02155125f, 0.02479473f, 0.00389714f, 
    -0.00245408f, -0.00466000f, -0.02541163f, -0.03573403f, 0.01212478f, -0.01602482f, -0.00573309f, 0.01596685f, 
    -0.02222388f, 0.00789559f, -0.00294938f, 0.02718533f, 0.01927453f, 0.00139409f, -0.00389456f, 0.03096212f, 
    -0.01409230f, -0.00992386f, -0.02493188f, 0.01111367f, -0.00987183f, 0.02132288f, -0.01190774f, -0.02992787f, 
    0.02696220f, -0.02876749f, -0.02653919f, 0.01368876f, -0.00674877f, -0.01448785f, -0.01464331f, -0.02194552f, 
    0.04071511f, 0.00236174f, 0.01120628f, 0.00702728f, 0.03133602f, 0.03068284f, 0.00661822f, 0.00401150f, 
    -0.03885154f, -0.01941786f, -0.00914179f, 0.03338247f, -0.02463868f, -0.02271393f, -0.02723823f, -0.03919899f, 
    0.01027160f, -0.02399903f, 0.02517169f, 0.02420202f, -0.00233320f, 0.02534408f, -0.01360545f, 0.00019016f, 
    0.00418832f, 0.01640203f, -0.02652465f, 0.02371330f, -0.00802854f, 0.03456679f, 0.01999641f, 0.02290718f, 
    -0.00542834f, 0.00917901f, 0.02065824f, 0.02239173f, -0.00803634f, -0.02571381f, 0.02182141f, 0.02235991f, 
    0.00648374f, -0.00038578f, 0.01987948f, 0.01769111f, -0.02228555f, -0.01513022f, -0.03255848f, -0.02909020f, 
    -0.02771962f, 0.00898383f, -0.02119089f, 0.00880436f, -0.00896756f, -0.03514919f, 0.02127102f, 0.01739806f, 
    0.01156113f, -0.01381168f, -0.00152150f, 0.01291741f, 0.00242089f, -0.03800786f, -0.01855173f, 0.01615052f, 
    0.02877976f, -0.00336216f, -0.00244912f, 0.02630934f, -0.00480020f, 0.01056206f, -0.02639144f, -0.00509802f, 
    -0.01770354f, -0.00081734f, -0.03739556f, 0.01877986f, 0.01544480f, 0.01492427f, -0.00770017f, 0.00322557f, 
    -0.01634319f, -0.00406661f, -0.01095903f, 0.02276221f, -0.01577157f, -0.01076237f, 0.00028049f, 0.01439779f, 
    0.00359521f, -0.03588427f, -0.03680505f, 0.00165307f, -0.02703623f, -0.01682720f, -0.00203084f, 0.00336795f, 
    0.04232708f, -0.04033308f, -0.02233331f, -0.02926820f, -0.01822435f, 0.00098204f, -0.02928700f, -0.02555670f, 
    0.01332052f, -0.02350431f, -0.00690263f, -0.00532854f, -0.04089344f, 0.01782120f, -0.01974530f, -0.00918172f, 
    -0.03859933f, 0.02978150f, 0.03392441f, 0.02062169f, 0.00906733f, -0.00277074f, 0.00175560f, 0.00131496f, 
    0.02807371f, 0.02165784f, -0.03747666f, -0.01459190f, -0.00150964f, -0.03255388f, -0.00648764f, -0.00663176f, 
    -0.00730095f, -0.02976973f, -0.00932336f, -0.00128201f, -0.00833728f, 0.00497973f, -0.00669250f, 0.02722641f, 
    0.00506066f, 0.01620133f, -0.01505296f, 0.00095968f, -0.00311864f, 0.01506719f, -0.00986542f, 0.00171959f, 
    -0.01692099f, -0.02889266f, 0.02823591f, -0.03332167f, 0.02427516f, -0.02016564f, 0.02011918f, 0.02350423f, 
    0.00252923f, 0.00702519f, 0.02780358f, -0.04215420f, -0.00004223f, -0.03563710f, 0.01629443f, 0.00939958f, 
    -0.00910728f, -0.02915061f, -0.00760105f, -0.04061078f, 0.01283123f, 0.01090892f, 0.00425407f, -0.00976447f, 
    -0.00743713f, 0.00924404f, -0.02003241f, -0.03064099f, 0.00648495f, -0.03674416f, -0.03085856f, 0.03126725f, 
    -0.00992634f, 0.01421370f, -0.03266064f, 0.02102061f, -0.04080035f, 0.00003977f, -0.01160164f, 0.02738057f, 
    0.02029791f, -0.00036261f, 0.01882103f, -0.01032473f, -0.00047776f, 0.02952346f, 0.01699191f, -0.01048972f, 
    -0.01226201f, 0.02364332f, -0.02144824f, 0.00318994f, 0.02079350f, 0.02589853f, 0.02200459f, 0.01665138f, 
    -0.02178910f, 0.01706640f, -0.01063124f, -0.01634963f, 0.01708616f, 0.00687227f, 0.01316214f, -0.01987260f, 
    -0.00142531f, 0.01338429f, -0.03090671f, -0.03456672f, 0.03638164f, -0.00020289f, -0.01565716f, 0.01308396f, 
    0.00940941f, -0.01354468f, -0.01307537f, -0.01990208f, 0.00953969f, -0.01505709f, -0.00526579f, -0.01892243f, 
    0.01813849f, -0.04015322f, 0.01346068f, -0.01069146f, -0.00730597f, 0.01647886f, 0.02620144f, 0.02073798f, 
    -0.02254809f, -0.02244162f, 0.01873250f, 0.00828928f, 0.00651145f, 0.02989191f, 0.01047448f, -0.00726786f, 
    -0.00435990f, -0.02057741f, 0.00922038f, 0.02391076f, 0.01558714f, 0.00543351f, -0.03019487f, -0.00759829f, 
    0.02927186f, -0.02490081f, -0.02655492f, -0.02610238f, -0.03611800f, -0.01577533f, 0.01189853f, -0.01733591f, 
    -0.02366041f, -0.02073830f, -0.01142977f, -0.01639287f, 0.00302954f, -0.01668822f, -0.01340437f, 0.00445341f, 
    0.00005788f, 0.00168808f, -0.01928148f, -0.03110172f, -0.01157271f, -0.00836319f, 0.01334022f, -0.03247796f, 
    -0.01848472f, -0.02647511f, 0.00266131f, -0.00351162f, -0.02410183f, -0.02250319f, -0.01332068f, 0.00320990f, 
    0.01813545f, -0.00791317f, -0.04097180f, -0.03382044f, -0.02350207f, 0.02008471f, 0.01995509f, 0.02817854f, 
    -0.01148806f, -0.01529737f, -0.02322680f, 0.01149744f, -0.01909288f, 0.01608245f, 0.01860951f, 0.01124266f, 
    0.00262062f, 0.00451362f, 0.01490113f, 0.01462207f, 0.00357162f, 0.02304519f, 0.02649749f, 0.00171023f, 
    0.00430709f, -0.01185519f, -0.02159245f, -0.02193783f, -0.00657494f, 0.00228255f, 0.00565347f, -0.01028452f, 
    -0.02539973f, -0.00231657f, -0.00283128f, -0.02280175f, 0.03521869f, -0.00714316f, 0.02009936f, 0.02718486f, 
    0.01035158f, -0.01357653f, -0.03185099f, 0.01350491f, 0.01392224f, -0.03473749f, -0.02507855f, -0.00249608f, 
    -0.04128299f, 0.02390013f, -0.01481655f, -0.01208599f, 0.00930325f, -0.04129028f, -0.02707055f, 0.01324051f, 
    -0.01054015f, -0.02885206f, -0.02671419f, -0.03433214f, 0.00258408f, -0.00656000f, 0.01910535f, -0.02141045f, 
    0.02830914f, 0.00411868f, 0.00906211f, -0.00197556f, -0.03410637f, 0.02426354f, -0.02561381f, 0.00266548f, 
    -0.00817866f, 0.02211137f, 0.01868219f, 0.02099605f, -0.02055412f, -0.03150780f, -0.02471121f, 0.00682420f, 
    -0.00863484f, 0.01936310f, -0.02095060f, -0.04083236f, 0.02494854f, -0.00977838f, 0.02298710f, 0.00675106f, 
    0.03091562f, -0.00691004f, -0.03546404f, -0.00798151f, 0.02546448f, 0.01598814f, 0.00917495f, 0.02553438f, 
    0.01418644f, -0.03957877f, -0.01124627f, -0.04144276f, -0.01184570f, 0.02186406f, -0.03915639f, -0.03705885f, 
    -0.02871240f, -0.03612766f, -0.03731851f, -0.01552445f, -0.02137775f, -0.02237374f, -0.00608839f, -0.00081357f, 
    0.00196478f, 0.00996247f, -0.01475855f, 0.01607653f, -0.03068857f, -0.04137570f, 0.01073865f, 0.01455896f, 
    -0.03778652f, -0.01228117f, -0.03333244f, -0.01244178f, -0.03624852f, 0.02472336f, 0.01504225f, 0.00299753f, 
    0.00204028f, -0.00818288f, -0.03909088f, 0.00374997f, -0.02919444f, -0.02098957f, -0.01000512f, -0.01041119f, 
    -0.02639820f, 0.01380095f, 0.01359651f, -0.01145522f, -0.00021428f, -0.01318610f, -0.03453773f, 0.02399652f, 
    -0.00248744f, -0.00424635f, 0.01398004f, -0.02955811f, -0.00135246f, 0.01003486f, -0.02046077f, -0.00506659f, 
    0.00523969f, 0.01867248f, 0.00262276f, 0.03050605f, -0.00378526f, 0.01657993f, -0.00903049f, 0.02445841f, 
    0.00322863f, -0.02456914f, -0.00386067f, 0.02012261f, -0.03767131f, -0.01390155f, 0.00001601f, -0.04067846f, 
    0.02571621f, -0.02270128f, -0.00779188f, 0.01256390f, 0.00790851f, 0.00650534f, -0.03407330f, 0.00177823f, 
    0.04070542f, -0.01237077f, -0.00215516f, 0.01395961f, -0.02651970f, 0.01292203f, -0.01501228f, 0.01758865f, 
    0.01586966f, -0.00097316f, 0.01656576f, 0.02985326f, -0.00760427f, 0.01034357f, -0.02969562f, 0.01828865f, 
    0.03306321f, 0.02057211f, -0.03022786f, -0.02179659f, -0.01342088f, -0.00832864f, 0.01093980f, -0.02768921f, 
    -0.01978250f, -0.03892415f, 0.01299024f, 0.00944244f, 0.01244818f, 0.01582014f, 0.00588741f, 0.02914453f, 
    -0.04268458f, -0.02133054f, -0.02547488f, -0.01010167f, 0.00259657f, -0.03847856f, -0.03608404f, 0.00363405f, 
    0.03743767f, -0.00665395f, 0.02968844f, 0.02787273f, 0.02972078f, 0.00601253f, -0.02120317f, 0.00399864f, 
    -0.03146625f, -0.00234860f, -0.01611587f, 0.01820185f, 0.03060767f, -0.04389950f, 0.03490591f, -0.03565400f, 
    -0.01654426f, 0.00454666f, 0.01014600f, -0.02966021f, 0.01513617f, -0.00041778f, -0.03074820f, 0.02023368f, 
    0.00340542f, 0.03457300f, 0.02812678f, -0.00518392f, 0.02289822f, -0.01773986f, 0.01012891f, -0.01994835f, 
    0.02660355f, 0.01714304f, -0.00390539f, 0.00448935f, -0.00107954f, -0.00720711f, -0.01605739f, -0.02173603f, 
    -0.02407053f, -0.02104441f, 0.02418302f, 0.00382470f, -0.00097958f, 0.03296999f, 0.02379798f, 0.01474508f, 
    -0.02143578f, -0.00285100f, -0.02077078f, -0.00239611f, -0.00130043f, 0.00363394f, 0.00264524f, 0.02656163f, 
    0.00999470f, 0.00118644f, 0.01433431f, 0.01218598f, -0.01280752f, -0.02018133f, -0.03623082f, 0.00137126f, 
    0.02422384f, -0.01829764f, 0.00217791f, 0.00889597f, 0.00429446f, -0.02687422f, 0.01275910f, -0.02416408f, 
    0.00509035f, -0.02317411f, 0.02418169f, -0.00735447f, -0.00239785f, -0.00908857f, -0.03252200f, -0.01393655f, 
    -0.01445671f, -0.00356613f, 0.00562978f, 0.00475421f, -0.03552342f, 0.02678004f, -0.03563417f, 0.02115887f, 
    -0.00772032f, -0.03405904f, -0.03317314f, -0.01857749f, 0.00661184f, -0.00794099f, 0.02544769f, -0.00655278f, 
    0.01429672f, 0.01368399f, -0.02335143f, 0.02439163f, -0.00658402f, -0.03904635f, 0.02425778f, 0.00966704f, 
    0.00543140f, -0.00631642f, -0.01332016f, -0.02737703f, 0.00637113f, 0.01553224f, 0.01600497f, -0.01078057f, 
    -0.02598015f, 0.01727805f, -0.02503513f, -0.02145546f, 0.00482915f, -0.00465795f, -0.01022846f, -0.01223751f, 
    -0.00778363f, -0.01790402f, 0.03330429f, 0.02302557f, -0.03733264f, -0.02948501f, 0.02462481f, -0.02886129f, 
    -0.01180656f, -0.00942274f, -0.01426541f, 0.00905638f, -0.00928275f, 0.01361251f, 0.01369293f, -0.03280067f, 
    -0.03836705f, -0.03223870f, -0.03434176f, 0.01847462f, -0.00259205f, 0.00293970f, 0.00153498f, 0.02606967f, 
    -0.00565230f, 0.01119667f, 0.00329635f, -0.01631531f, 0.01360976f, -0.02309095f, 0.02645390f, -0.01757737f, 
    0.01688273f, -0.01797516f, -0.02130549f, 0.01419308f, -0.00873811f, 0.01268117f, 0.02664628f, 0.00127075f, 
    0.00768702f, -0.01862610f, 0.02184728f, -0.00311883f, 0.02367523f, -0.02434978f, 0.00977839f, 0.00066632f, 
    0.01031657f, -0.03919563f, -0.01497126f, -0.00121346f, 0.00134618f, -0.01128416f, -0.01058403f, 0.00827539f, 
    -0.01134480f, -0.03435889f, 0.00154676f, 0.01772066f, -0.00140490f, 0.02042208f, -0.03988599f, -0.03064666f, 
    -0.01179863f, -0.01817593f, -0.02388041f, -0.00755012f, 0.02194291f, 0.02888235f, 0.00254330f, 0.00677920f, 
    -0.00113037f, -0.03449035f, 0.01330520f, 0.01693948f, 0.00549923f, -0.03387635f, 0.02563447f, -0.01754586f, 
    -0.03742282f, -0.02543272f, 0.01603003f, 0.03464135f, -0.01549410f, 0.01186316f, -0.01050849f, -0.00388552f, 
    0.03485944f, 0.02677023f, 0.00640880f, -0.00439645f, -0.01897867f, 0.03192221f, -0.02816709f, 0.00698430f, 
    -0.03672282f, 0.02913820f, -0.03806891f, -0.03679857f, -0.03307160f, -0.00123612f, -0.03336139f, 0.02577063f, 
    -0.01193356f, -0.00206425f, -0.03058538f, 0.01426959f, 0.01361363f, 0.00962897f, 0.00301389f, -0.02537572f, 
    0.01491364f, -0.02849782f, -0.00235676f, -0.01467972f, 0.00565274f, -0.01183043f, -0.01117048f, -0.04314488f, 
    -0.01103061f, -0.03781652f, -0.03547436f, 0.01584315f, -0.03088376f, 0.00323593f, 0.02675491f, -0.03256167f, 
    0.00516709f, -0.03655886f, -0.00147747f, -0.02726751f, 0.02631767f, -0.00710092f, 0.02264265f, -0.00833038f, 
    -0.02106857f, 0.00079898f, -0.00396708f, -0.00314482f, -0.03321227f, -0.02796242f, 0.02806810f, -0.02211710f, 
    -0.01356806f, 0.01217765f, -0.02499801f, -0.02218463f, 0.02774372f, -0.01205234f, -0.03560193f, -0.03304813f, 
    0.00044595f, -0.02942966f, 0.01511503f, -0.00306585f, 0.01031245f, -0.02048508f, -0.03017768f, -0.02957120f, 
    -0.03641159f, -0.03261005f, -0.02022217f, 0.01321310f, -0.02999161f, 0.01107471f, -0.00330603f, 0.03377645f, 
    0.00129343f, 0.01060188f, -0.03052957f, 0.01626338f, 0.00614543f, 0.03281614f, 0.00456961f, -0.02251439f, 
    -0.00842369f, -0.00571245f, 0.03167714f, 0.00897711f, -0.01736813f, -0.00410716f, 0.02605856f, -0.01571844f, 
    0.01951737f, -0.02723571f, -0.03862014f, 0.02448191f, 0.00752764f, 0.01637264f, -0.04231909f, -0.04166763f, 
    -0.01994497f, 0.01613492f, 0.01113734f, -0.00805538f, -0.03031172f, -0.01055930f, 0.02342304f, -0.00114180f, 
    0.00015119f, 0.01439054f, 0.01325232f, 0.03601470f, -0.02279757f, -0.01129870f, 0.00285295f, -0.01114795f, 
    -0.01590164f, -0.01677131f, 0.01024807f, -0.02145210f, 0.01316412f, 0.00951954f, -0.02154862f, -0.03125620f, 
    -0.03869502f, -0.03293338f, -0.02419343f, -0.03942235f, -0.01824138f, -0.03492850f, 0.00063123f, -0.00500791f, 
    -0.02417674f, -0.00966834f, 0.02312523f, -0.01292779f, -0.01214166f, -0.00698268f, 0.01061954f, 0.01856203f, 
    -0.01653531f, -0.01446994f, 0.01374928f, -0.01019945f, 0.00330029f, -0.01078949f, 0.03200061f, -0.02900379f, 
    0.03477051f, -0.00406530f, -0.02203240f, 0.03037618f, -0.03524440f, 0.00786627f, -0.00233098f, 0.02603561f, 
    0.01255971f, -0.01993907f, 0.01354501f, 0.02054552f, -0.01003485f, 0.02602595f, -0.01041492f, 0.03108379f, 
    -0.01568694f, -0.03983769f, -0.02332487f, -0.02939683f, 0.02493437f, 0.01493791f, -0.00879548f, 0.03056773f, 
    -0.02107827f, -0.01755512f, -0.03373012f, 0.03064394f, -0.02072364f, 0.01677346f, -0.00397798f, -0.01665064f, 
    0.02148374f, 0.02101232f, 0.00599035f, 0.02631767f, 0.01430654f, 0.02610541f, -0.00537804f, 0.02793298f, 
    -0.01038522f, 0.01307321f, 0.00454540f, -0.01242737f, -0.02544067f, 0.01790159f, -0.02801334f, -0.03056346f, 
    0.00751388f, 0.03449908f, -0.03519759f, 0.00959944f, -0.00519206f, -0.02183893f, -0.03588413f, -0.04245497f, 
    -0.03343635f, 0.01745720f, -0.03155342f, 0.02831325f, -0.03242637f, 0.00483551f, -0.03008969f, -0.04072886f, 
    0.00390532f, 0.01265120f, 0.00953644f, 0.01153180f, -0.03845921f, 0.02357787f, -0.01391398f, -0.03511906f, 
    -0.00972126f, 0.01165543f, 0.02903255f, 0.00062420f, 0.02855594f, -0.01987401f, 0.01614104f, -0.03210270f, 
    0.00960517f, 0.02834051f, -0.00714204f, -0.03593851f, -0.00814590f, 0.02398847f, 0.01796254f, 0.00583477f, 
    -0.00558692f, -0.03426364f, -0.01554224f, 0.01013850f, -0.00299930f, 0.02434603f, 0.03262068f, -0.02639782f, 
    -0.02432815f, 0.01565405f, -0.01843499f, -0.02924776f, 0.01238407f, -0.01361168f, 0.02823091f, -0.00490043f, 
    0.01229285f, -0.01284031f, -0.02768028f, 0.01522426f, -0.01796746f, 0.02863509f, -0.03157911f, -0.01244579f, 
    -0.01307215f, -0.01459741f, 0.03779785f, 0.01109609f, -0.02340021f, 0.01070044f, 0.00852051f, 0.02769652f, 
    0.00102913f, 0.03200440f, 0.02244735f, 0.01283430f, 0.01578863f, -0.03004118f, 0.00287829f, -0.02963265f, 
    -0.02860903f, 0.02877752f, -0.01898672f, -0.02149342f, -0.03949394f, -0.01624514f, -0.01987186f, 0.01625733f, 
    -0.00566636f, -0.00432089f, 0.02992957f, 0.01273745f, -0.02301614f, 0.02027512f, -0.04383914f, -0.02939445f, 
    -0.03557964f, -0.01231767f, -0.02936199f, 0.02593159f, 0.01076586f, -0.01327082f, 0.02297589f, -0.00230580f, 
    -0.03686438f, 0.00075340f, -0.01794896f, -0.02954867f, 0.00295576f, 0.02653975f, 0.01736995f, -0.02627221f, 
    -0.00620611f, -0.03515578f, 0.02557840f, 0.01552956f, 0.01307130f, 0.01726561f, -0.02652991f, -0.00767471f, 
    0.01060858f, -0.02121313f, -0.00942916f, -0.01979939f, -0.04078670f, -0.00447387f, 0.00559212f, -0.01442452f, 
    -0.00233075f, -0.00262863f, -0.00141501f, 0.01033451f, -0.02207757f, -0.02569924f, 0.00213317f, 0.02226367f, 
    -0.00776451f, -0.02409318f, -0.00423806f, -0.02023168f, 0.02176560f, -0.03577605f, -0.03330179f, 0.02654476f, 
    0.01874840f, -0.01576700f, -0.03486985f, 0.02414548f, -0.00901554f, -0.00018137f, 0.03025634f, -0.02577277f, 
    -0.01528455f, 0.01620509f, -0.04108194f, -0.02423857f, -0.00926440f, 0.02946123f, -0.01858237f, 0.03336136f, 
    0.01034230f, -0.03998621f, 0.00209731f, -0.00562073f, -0.03595481f, -0.00011358f, -0.02456054f, -0.00544486f, 
    -0.02613370f, -0.03096590f, 0.00327273f, 0.00131007f, -0.01551459f, 0.02484418f, 0.00376633f, 0.00079820f, 
    0.02089993f, 0.02138177f, -0.00665702f, -0.02016503f, 0.03087585f, -0.03736160f, 0.01944575f, -0.02904185f, 
    0.00043594f, 0.00116853f, 0.00874148f, -0.03184368f, 0.00168387f, -0.01979866f, -0.01224217f, -0.02285818f, 
    -0.01006050f, 0.00231355f, -0.04168560f, -0.03257659f, -0.00615605f, 0.00955055f, 0.01686881f, -0.00834379f, 
    0.00038268f, -0.00942881f, -0.00918597f, 0.03371751f, -0.01347926f, 0.03346114f, -0.00646731f, -0.03222179f, 
    -0.02298115f, 0.03229640f, -0.01653269f, 0.02224823f, 0.01022527f, -0.00790223f, -0.01259612f, 0.00438454f, 
    -0.01630576f, 0.01705470f, 0.00113826f, 0.01885298f, -0.00780333f, -0.02786368f, -0.01541296f, -0.02344946f, 
    0.01444838f, -0.00130695f, -0.03687944f, 0.00981120f, 0.01327092f, 0.00087939f, -0.00985515f, 0.00646248f, 
    0.02262003f, -0.01926680f, 0.01636989f, -0.02989915f, -0.02697609f, -0.01644463f, -0.04227873f, 0.02676204f, 
    -0.02174661f, 0.02783076f, -0.03599741f, -0.02059577f, -0.00467664f, 0.02399353f, -0.02525397f, -0.00649741f, 
    -0.00556971f, 0.02292406f, -0.02435675f, -0.02950570f, -0.03622423f, 0.02856828f, -0.01899498f, 0.00812021f, 
    0.02111144f, -0.02044456f, -0.01842237f, 0.01439046f, -0.01141293f, -0.03008993f, -0.01377594f, 0.02358375f, 
    0.00783312f, 0.00687260f, -0.02252586f, 0.02200710f, -0.01471998f, 0.00800898f, -0.02744450f, 0.02598417f, 
    -0.02003452f, 0.02005571f, -0.02276098f, -0.04386384f, 0.03555098f, -0.00936216f, -0.01833352f, -0.01483980f, 
    -0.01949197f, -0.01807124f, 0.02312437f, 0.00740286f, -0.01661594f, 0.02193976f, -0.00894779f, -0.01985582f, 
    -0.02575130f, -0.00823928f, -0.00856425f, -0.03552931f, -0.00362238f, 0.02042800f, 0.00430873f, -0.03398390f, 
    -0.01753808f, 0.00914539f, -0.00398239f, -0.00801174f, 0.02287825f, -0.01475742f, -0.03198512f, 0.01639900f, 
    -0.02808340f, 0.01270383f, 0.02425891f, 0.03589378f, 0.01830370f, -0.02726445f, -0.01923939f, 0.00997618f, 
    0.01093325f, -0.01701428f, -0.01781124f, 0.01304316f, -0.02830722f, -0.01528635f, 0.01335059f, 0.04008575f, 
    -0.03680221f, -0.03826525f, -0.02935820f, -0.01352063f, -0.04176629f, -0.02184655f, 0.02310376f, -0.01547871f, 
    0.01424224f, -0.01631534f, 0.00723374f, 0.01173965f, -0.02380533f, -0.03822035f, -0.00346956f, 0.03635117f, 
    -0.01293252f, -0.00882854f, -0.02064461f, 0.01679499f, 0.02850968f, -0.00815076f, 0.01313564f, -0.03492081f, 
    -0.00649761f, -0.01872740f, 0.01453529f, -0.00703765f, -0.00416625f, -0.03637071f, 0.00451262f, -0.03066825f, 
    -0.00300934f, 0.01818450f, -0.02998942f, -0.02861933f, -0.02910264f, 0.02117854f, 0.01562312f, -0.03570567f, 
    0.01427002f, 0.00085183f, 0.01403843f, 0.01122391f, -0.03594378f, -0.00316431f, -0.02968041f, 0.02204270f, 
    0.00342722f, 0.00723864f, -0.01718254f, -0.03021332f, 0.03586208f, -0.02162912f, 0.00761477f, 0.02254008f, 
    0.01975917f, -0.03282323f, -0.02998690f, 0.02359829f, 0.00410664f, -0.02708872f, -0.03195298f, -0.02286817f, 
    -0.01907417f, 0.00592593f, 0.02298372f, -0.00598127f, -0.03472530f, -0.02313437f, 0.02567215f, 0.02502830f, 
    -0.00583743f, 0.02933031f, -0.01004229f, -0.03543876f, 0.01680575f, -0.02904219f, -0.01376721f, 0.00032537f, 
    0.01740278f, -0.00721955f, 0.02102146f, -0.01943980f, 0.00670475f, 0.02013891f, -0.03890825f, -0.03733356f, 
    0.02096121f, 0.02591746f, -0.00415471f, -0.00577348f, 0.02978428f, -0.03657404f, -0.00993393f, 0.00701371f, 
    -0.01161327f, 0.00813074f, 0.02673398f, -0.01570033f, -0.02157788f, 0.01317539f, 0.01581562f, 0.01758759f, 
    -0.01483152f, 0.02601898f, -0.01134955f, 0.01365797f, -0.00287532f, 0.02036767f, -0.02824779f, -0.00575609f, 
    0.00519829f, 0.02921085f, -0.04226897f, 0.00277805f, -0.02852308f, 0.00090084f, -0.00837048f, -0.02675552f, 
    0.03062892f, -0.03034811f, -0.03608792f, 0.00266731f, -0.03519077f, 0.02504745f, 0.01746529f, 0.02606750f, 
    -0.01507509f, -0.00044963f, 0.01473402f, 0.01670132f, 0.00418350f, -0.00874920f, 0.00225724f, -0.00100071f, 
    -0.01662754f, 0.01619640f, -0.00827185f, -0.03648657f, -0.03112391f, 0.01773763f, 0.01037332f, -0.00241017f, 
    0.01309513f, -0.04093844f, -0.03761201f, -0.00944133f, 0.01581413f, -0.01378540f, 0.01388161f, 0.02390456f, 
    -0.03420428f, -0.00518173f, -0.01448374f, 0.02777792f, 0.00559815f, -0.01644568f, 0.00521447f, -0.02698679f, 
    0.02546123f, -0.04874869f, 0.00822164f, 0.01112161f, -0.02384838f, 0.00647824f, -0.01627750f, -0.03467226f, 
    -0.00924075f, -0.01363285f, -0.01965278f, 0.02933672f, -0.00504372f, -0.00377226f, -0.02766692f, 0.00487525f, 
    -0.04136067f, -0.03715582f, -0.03608535f, 0.02316439f, 0.01543407f, 0.02740273f, -0.03999210f, 0.01559419f, 
    -0.01005468f, 0.02916004f, -0.03510857f, 0.00826806f, -0.00425827f, -0.02366323f, 0.02507029f, 0.02213411f, 
    -0.01485284f, -0.02809391f, 0.01554659f, -0.02369794f, 0.00777808f, -0.02640644f, 0.02398072f, -0.00869871f, 
    0.03126251f, 0.01719133f, -0.01465044f, -0.02135286f, 0.00071192f, -0.02455607f, -0.03270720f, 0.02446131f, 
    -0.00244456f, -0.03623106f, -0.00728110f, 0.00778672f, 0.02451025f, -0.02156491f, 0.02380281f, -0.04393595f, 
    0.02492364f, -0.00749479f, 0.02076402f, 0.01221730f, -0.01750341f, -0.01356058f, 0.01096518f, -0.00612667f, 
    -0.01554781f, 0.01361842f, -0.01294781f, -0.01358585f, 0.00982923f, -0.01792081f, 0.00281809f, 0.01750824f, 
    0.01227111f, 0.00388044f, 0.00285782f, 0.00211617f, -0.00944349f, -0.01419069f, -0.02475965f, 0.00909032f, 
    -0.00209810f, 0.01869434f, -0.01511761f, -0.04007704f, -0.01379751f, -0.04358840f, -0.00218923f, 0.00321634f, 
    0.01433641f, -0.01858908f, -0.03149557f, 0.02950992f, -0.03702107f, 0.00323277f, 0.01713755f, 0.00576064f, 
    0.00581582f, -0.00954573f, 0.01045445f, -0.01928513f, -0.01926584f, 0.02582845f, -0.01553032f, 0.02768556f, 
    -0.03210442f, -0.03852333f, -0.00866862f, -0.00777995f, 0.02909661f, 0.01491055f, -0.01726155f, 0.02974005f, 
    0.00840168f, -0.01190674f, 0.00152197f, -0.00344386f, -0.00799391f, -0.02221754f, 0.00764220f, -0.02125777f, 
    -0.02480943f, -0.01498591f, 0.00065772f, -0.01279677f, -0.02123746f, 0.00719617f, -0.00948855f, -0.03984049f, 
    -0.01927730f, 0.01693101f, 0.01848561f, -0.03777221f, 0.00850164f, -0.02117606f, 0.02284951f, 0.00069210f, 
    -0.00108460f, -0.03532921f, -0.03653457f, -0.01347575f, -0.03462559f, -0.01012904f, -0.03363051f, -0.02833726f, 
    -0.00373843f, -0.02197553f, -0.01549992f, 0.00831525f, 0.01329240f, 0.01535112f, 0.02013862f, 0.02467987f, 
    -0.01568924f, -0.00983293f, -0.00590757f, -0.00700588f, -0.02792526f, -0.03044579f, -0.00094666f, 0.02048260f, 
    0.01649859f, 0.00076043f, 0.00064642f, 0.02048359f, -0.03297848f, 0.01429581f, -0.02054304f, 0.01526440f, 
    0.02103270f, 0.00898188f, -0.03997333f, 0.03530839f, -0.02602695f, 0.01477090f, -0.01435803f, 0.02096927f, 
    -0.00582375f, -0.04246052f, -0.04059817f, 0.01900195f, -0.02039509f, -0.00934225f, -0.00718015f, -0.00609891f, 
    -0.00425467f, 0.01807196f, 0.00052325f, -0.02825207f, -0.02146889f, 0.01107279f, -0.00168793f, -0.02322183f, 
    0.00408370f, -0.01758065f, 0.00822104f, 0.03002836f, 0.01130501f, 0.02609212f, -0.01884043f, -0.00603657f, 
    0.00984613f, -0.00306204f, 0.01251061f, 0.01144978f, -0.03378918f, 0.02847387f, 0.00288777f, -0.01226064f, 
    0.02962225f, 0.00737794f, 0.01402602f, 0.02277410f, -0.00134651f, -0.02371508f, -0.01386361f, -0.00646451f, 
    0.02344994f, 0.02828800f, -0.03271981f, 0.02785112f, -0.03325024f, 0.00646384f, -0.00745110f, -0.03556358f, 
    -0.03550332f, -0.02746393f, -0.01734928f, 0.00796839f, -0.00787503f, -0.00454375f, -0.03839957f, -0.00789185f, 
    0.00776652f, 0.01000503f, 0.02184563f, -0.02420399f, -0.01722516f, -0.04134583f, -0.03668484f, 0.00466764f, 
    -0.04206573f, -0.00936667f, 0.02556397f, -0.00272345f, 0.00763968f, 0.00120966f, -0.03545794f, -0.01235830f, 
    0.02734306f, -0.02743201f, -0.00608290f, 0.01414250f, -0.00649419f, -0.01739987f, -0.04434678f, -0.02007912f, 
    0.02281384f, 0.02541633f, -0.03125800f, 0.02075534f, -0.00890168f, 0.02447088f, -0.02155181f, -0.00268217f, 
    -0.00122950f, 0.02972600f, 0.02293697f, -0.00987204f, 0.01179179f, 0.01691935f, -0.01829713f, -0.01488550f, 
    0.00208032f, -0.02042413f, -0.01266098f, -0.00302142f, -0.03109482f, 0.03818852f, -0.02653523f, 0.00575897f, 
    -0.01319676f, -0.03469453f, -0.00087269f, 0.00302840f, -0.00061320f, -0.00175676f, 0.02078987f, -0.04239729f, 
    -0.02611717f, 0.02583583f, -0.03565349f, -0.01200861f, 0.01463921f, -0.01485742f, -0.03036719f, -0.03729589f, 
    -0.03414128f, -0.03721723f, -0.01840538f, -0.00971749f, 0.00373394f, 0.00836553f, 0.01201291f, -0.01770112f, 
    -0.01666102f, -0.01300455f, 0.01855618f, 0.01637563f, -0.02108554f, -0.00851867f, 0.01908235f, 0.01433770f, 
    -0.00920790f, -0.03615386f, 0.01256935f, -0.03510597f, 0.00139140f, 0.02701429f, -0.00110312f, 0.02754185f, 
    0.00200122f, -0.03135155f, 0.00525733f, 0.01051147f, -0.01795956f, 0.02831388f, 0.01356653f, 0.01707592f, 
    -0.01477354f, 0.00473527f, 0.03209885f, 0.02761439f, -0.00133341f, -0.03137607f, -0.02847679f, -0.00073734f, 
    0.02279218f, -0.01816479f, 0.02356962f, 0.01531231f, 0.02339021f, -0.03624475f, -0.04011347f, 0.00790446f, 
    -0.02799221f, 0.02106425f, -0.00548731f, 0.02553146f, 0.02469481f, -0.02348114f, -0.00512903f, -0.02341308f, 
    -0.02618803f, -0.02257325f, 0.01652903f, 0.02667802f, -0.00182415f, -0.02905148f, -0.03821670f, 0.02437142f, 
    -0.01791154f, -0.01244210f, -0.02374150f, 0.00553883f, 0.03014139f, 0.00892794f, 0.01064263f, -0.03355712f, 
    -0.03261654f, -0.00060092f, -0.03235152f, 0.00124826f, 0.02664731f, 0.01240668f, 0.01013571f, 0.03269821f, 
    0.03014199f, 0.01217434f, -0.02940424f, -0.01484297f, -0.03655920f, 0.00305992f, -0.00535520f, 0.00364359f, 
    0.01629415f, 0.02046376f, -0.02975426f, 0.01580039f, 0.00611396f, -0.03221024f, -0.01841193f, -0.01968442f, 
    -0.01658370f, -0.03223975f, 0.00218264f, 0.01442119f, 0.01128380f, 0.02848335f, -0.04193177f, -0.03740762f, 
    0.00877601f, 0.01975239f, -0.02901002f, -0.03250797f, 0.00187694f, -0.03971129f, -0.01391341f, 0.02362471f, 
    0.02199105f, -0.02189661f, 0.02654906f, -0.02073056f, 0.00025156f, 0.00459559f, -0.01047754f, 0.01251848f, 
    -0.00648633f, -0.03660390f, -0.00536760f, -0.03845653f, 0.00258358f, 0.02646313f, -0.02583528f, 0.03032336f, 
    0.01445104f, 0.00227769f, 0.02451420f, 0.00574522f, 0.01092199f, 0.01411527f, -0.02782354f, 0.02909425f, 
    0.02514008f, -0.02525257f, -0.00904561f, -0.03125231f, -0.01181319f, -0.00026699f, -0.03285370f, -0.02147798f, 
    0.02674774f, -0.03664704f, 0.00954067f, -0.00398296f, -0.03503090f, -0.00071393f, -0.00187379f, -0.01551427f, 
    -0.02747191f, 0.00100848f, -0.01134057f, 0.00294643f, 0.03551623f, -0.01521706f, -0.02018703f, -0.01883364f, 
    0.03990765f, 0.00854675f, 0.02822124f, 0.00684269f, -0.01777487f, -0.01421806f, 0.00745884f, 0.00295366f, 
    -0.00537253f, 0.02710276f, -0.00280469f, 0.00732076f, 0.01923410f, -0.00240850f, -0.01585734f, -0.01156520f, 
    0.02097828f, -0.02900659f, -0.00884048f, -0.02320732f, 0.01899124f, -0.03607263f, -0.01283342f, 0.01343346f, 
    -0.04325671f, 0.01808953f, -0.01905721f, 0.01147093f, -0.00734601f, -0.00264497f, -0.00958517f, -0.00753825f, 
    -0.00424578f, 0.01188207f, 0.02724756f, 0.01789508f, -0.00151044f, 0.02364505f, 0.01318975f, 0.01110837f, 
    -0.00358138f, -0.03789755f, -0.00659477f, -0.01054171f, -0.01693570f, 0.01988266f, 0.01888497f, 0.02443456f, 
    0.01407691f, -0.02853289f, 0.01428157f, -0.02029143f, 0.02803203f, 0.00761050f, -0.03614934f, -0.03167121f, 
    -0.02636321f, -0.03954465f, 0.01358166f, -0.00615881f, 0.03359088f, -0.01394550f, 0.03227663f, -0.01924471f, 
    -0.04269893f, -0.01560957f, -0.01964808f, 0.00259249f, 0.02491586f, -0.03330571f, 0.02646636f, -0.00919534f, 
    -0.00088577f, 0.02210913f, 0.01500056f, -0.04109875f, -0.01876092f, 0.02331458f, -0.02268106f, 0.01497298f, 
    -0.03681064f, -0.02493021f, 0.02534230f, 0.02849566f, 0.01116575f, -0.00076817f, -0.01171083f, 0.00828177f, 
    0.01288556f, -0.00215913f, 0.00038554f, -0.03425843f, -0.02804186f, 0.00557368f, -0.00451254f, 0.00573379f, 
    0.02622398f, -0.02014833f, 0.03065905f, 0.02425801f, -0.02479201f, 0.01552801f, 0.00071501f, 0.02432282f, 
    -0.01429923f, -0.03365273f, -0.03803483f, 0.03191334f, -0.02382653f, -0.02626861f, -0.00324429f, 0.01874520f, 
    0.00551793f, -0.00776584f, 0.00854004f, 0.02693162f, -0.03290182f, -0.02315746f, 0.03325520f, 0.00557290f, 
    -0.01503412f, 0.02046073f, 0.02224590f, -0.02421312f, -0.01872122f, 0.01935251f, -0.00965774f, 0.01685680f, 
    -0.01549036f, 0.01919839f, 0.03459474f, 0.02260854f, -0.02979720f, 0.00129929f, -0.02048786f, 0.02807991f, 
    -0.01543406f, -0.01423707f, 0.01081483f, -0.01700599f, 0.01956508f, 0.00311585f, 0.01532737f, 0.00172857f, 
    -0.02206658f, -0.02883989f, -0.01069760f, -0.00305967f, -0.01779022f, -0.01065904f, -0.03561332f, 0.02705404f, 
    0.02406526f, 0.01652312f, 0.00696022f, -0.00636296f, 0.02602689f, 0.01509311f, -0.03576048f, -0.01847337f, 
    0.01447650f, 0.00648146f, -0.01541520f, 0.01624245f, -0.01437511f, -0.01923453f, 0.01824684f, 0.01473381f, 
    -0.00555270f, -0.00759058f, 0.00475555f, -0.03581146f, -0.01698644f, 0.00325922f, 0.01519289f, 0.00420665f, 
    0.00192817f, -0.03663171f, 0.00233128f, 0.00528282f, -0.03908584f, 0.00683963f, 0.01228409f, 0.02164530f, 
    0.01189025f, 0.03167056f, 0.00869450f, -0.01458189f, -0.01181362f, -0.00348417f, 0.03563887f, -0.03120970f, 
    0.01268966f, -0.02175443f, -0.02494526f, -0.01917838f, -0.04454979f, 0.01928735f, 0.01213556f, -0.02190159f, 
    -0.03367902f, -0.01214858f, -0.04408428f, -0.00355269f, -0.01098120f, -0.00938331f, 0.00664080f, -0.01343707f, 
    -0.03032524f, -0.02378759f, -0.00813863f, -0.00499144f, -0.00685127f, -0.04001487f, -0.03838282f, 0.00799861f, 
    0.02626405f, 0.01570247f, -0.03228372f, 0.00077069f, -0.03473128f, -0.02156115f, -0.03227013f, -0.02220017f, 
    -0.02347314f, 0.02740825f, -0.04129224f, 0.00954332f, 0.01276756f, -0.04407412f, 0.00167517f, -0.01761835f, 
    0.01305196f, 0.00378888f, -0.01084398f, 0.01681925f, -0.00355788f, -0.01465685f, 0.00218277f, 0.01457285f, 
    0.00038917f, 0.02067451f, 0.00099525f, 0.02990433f, 0.02095845f, -0.02794389f, -0.00017543f, -0.00886607f, 
    0.00053630f, 0.00185348f, -0.01604319f, -0.00398860f, -0.03566315f, -0.02961640f, -0.02841801f, -0.02955684f, 
    0.01042143f, 0.01227827f, -0.03108575f, -0.03535839f, -0.04260528f, 0.00975312f, 0.02612958f, -0.02419407f, 
    0.00213514f, -0.03526000f, 0.00259912f, -0.01882711f, -0.01389944f, -0.02426538f, 0.02711864f, 0.01778301f, 
    -0.01014149f, 0.02417077f, -0.02366548f, 0.01944542f, -0.00924841f, 0.01215944f, -0.03523674f, 0.00645019f, 
    0.02176461f, -0.00240151f, 0.02451159f, 0.00515043f, 0.02032743f, -0.02198476f, 0.00717870f, -0.01556585f, 
    0.02340087f, -0.00241459f, 0.01272482f, -0.02530187f, -0.02011829f, -0.00625517f, 0.00014415f, -0.00083818f, 
    -0.00039974f, 0.00183438f, 0.00539072f, 0.01287438f, 0.02537679f, -0.03092910f, 0.01725383f, -0.01596999f, 
    -0.01610956f, -0.01461870f, -0.04303798f, -0.04471242f, -0.03479889f, -0.03323783f, -0.03911664f, -0.00478844f, 
    -0.03324118f, -0.02385640f, 0.01507199f, -0.01927462f, 0.02328273f, -0.03252136f, -0.02020940f, -0.00687063f, 
    0.00909472f, 0.00810493f, -0.02273898f, 0.00665041f, -0.04328982f, 0.01326144f, 0.00563253f, 0.01201222f, 
    -0.01526213f, 0.02222187f, 0.00052076f, 0.02600564f, -0.02332443f, 0.02339931f, -0.03983518f, -0.02294788f, 
    0.01094345f, -0.01731609f, 0.00119661f, -0.02949387f, 0.01233816f, -0.01113705f, -0.00409841f, -0.03706675f, 
    -0.01707414f, 0.01544811f, -0.03796471f, 0.02259081f, 0.02617195f, -0.02545590f, -0.03310816f, -0.01933633f, 
    0.00905087f, 0.01002057f, 0.00274797f, -0.01678619f, -0.02629446f, -0.03374063f, -0.01958424f, -0.03732059f, 
    -0.02276823f, -0.03373271f, -0.02101116f, -0.02852546f, -0.03554798f, 0.00389373f, -0.03959107f, 0.01611709f, 
    0.01129961f, 0.01982127f, -0.02437301f, 0.01323771f, 0.02636607f, 0.02275335f, -0.03735976f, -0.00399950f, 
    -0.01614314f, 0.01793094f, 0.00932683f, 0.01441754f, 0.00405725f, 0.02122286f, -0.01787703f, -0.03885582f, 
    0.00039635f, -0.01129387f, -0.03497758f, 0.01581497f, -0.01071875f, -0.02072717f, 0.02630065f, 0.02699581f, 
    -0.00303215f, 0.01442874f, 0.02591762f, -0.00025285f, 0.00133341f, -0.03648226f, 0.01503299f, -0.01545605f, 
    -0.03286894f, 0.00475822f, -0.02744328f, -0.00350391f, -0.00832127f, -0.03368401f, -0.02846992f, -0.01873523f, 
    0.00993575f, -0.00530293f, 0.01142422f, 0.00517872f, 0.01679065f, -0.00170165f, -0.01505371f, -0.01456582f, 
    -0.03510020f, 0.00836277f, 0.00273683f, 0.01110243f, -0.02391462f, -0.02317864f, -0.02866417f, 0.02756632f, 
    -0.04133291f, -0.01270414f, -0.01904070f, -0.02074127f, -0.03045015f, -0.03336063f, -0.03566179f, 0.00058666f, 
    0.00510078f, 0.02240613f, -0.00108422f, 0.02124467f, 0.00624100f, -0.04175579f, -0.00798165f, 0.00103822f, 
    0.00118717f, -0.03668765f, 0.02686160f, -0.03800902f, -0.03664232f, 0.02603036f, -0.01702972f, 0.02023921f, 
    0.02369260f, -0.02971934f, -0.02214048f, 0.01626978f, -0.00989805f, 0.01796869f, 0.01481976f, -0.02212726f, 
    -0.03286554f, -0.02759694f, 0.01143915f, -0.04090405f, 0.01757256f, 0.00744301f, 0.02831186f, -0.03526977f, 
    -0.03080305f, 0.02135330f, -0.03587975f, 0.02516949f, 0.02671531f, -0.01673258f, 0.00036787f, -0.00184692f, 
    -0.00403517f, -0.00923457f, -0.02203262f, -0.03935637f, -0.01244380f, -0.04355904f, -0.00713506f, -0.00177766f, 
    -0.00481818f, 0.00092641f, 0.01823908f, -0.00340979f, 0.02285081f, -0.01189303f, 0.01346043f, 0.00565177f, 
    0.01600982f, -0.02336431f, -0.03246295f, -0.02354757f, -0.02773104f, -0.00531632f, -0.00116359f, -0.00141285f, 
    0.01934664f, -0.02438223f, -0.00632578f, 0.01459684f, -0.03750037f, -0.02748484f, -0.00754758f, -0.03205620f, 
    0.02629131f, 0.02190829f, 0.00053655f, 0.00776024f, 0.03468370f, -0.03718229f, 0.00449845f, -0.00019929f, 
    -0.00047392f, -0.01990894f, 0.01122361f, -0.02665974f, -0.03496254f, -0.03675374f, -0.00637150f, 0.01420382f, 
    -0.00947863f, 0.00860190f, 0.00651837f, -0.02966031f, -0.02895107f, -0.03923251f, -0.00576380f, 0.01623599f, 
    -0.03886819f, -0.00746928f, -0.03431142f, -0.03628009f, -0.04376298f, -0.00533282f, -0.04161623f, 0.02489225f, 
    0.01092258f, -0.00042448f, -0.00735970f, -0.03005897f, -0.03398255f, 0.01427929f, 0.01497932f, 0.00595931f, 
    0.02029542f, -0.04199497f, 0.01586842f, 0.00076632f, -0.01446244f, -0.04078139f, 0.00894681f, 0.00011131f, 
    -0.04241447f, -0.00964700f, -0.00181701f, -0.01104873f, 0.02339247f, 0.02462656f, 0.02457724f, 0.02948773f, 
    0.01092440f, 0.00086839f, 0.02212872f, -0.00833994f, -0.00208097f, 0.00907465f, -0.01760793f, 0.00714535f, 
    0.02345093f, 0.00880172f, 0.00385160f, -0.00938310f, 0.00912193f, 0.00870387f, -0.00459476f, -0.01413428f, 
    -0.03749678f, -0.01671294f, -0.02030797f, 0.02391464f, -0.00540560f, 0.00992303f, 0.01105225f, -0.02153361f, 
    0.02266944f, 0.00829513f, 0.00877304f, -0.01741686f, -0.03604861f, -0.02555753f, -0.00631061f, -0.00159222f, 
    -0.03591508f, -0.01077676f, -0.00888223f, 0.02663475f, 0.02461170f, -0.01968473f, 0.01445174f, -0.00911118f, 
    0.02807277f, 0.03018954f, 0.00980107f, 0.01083805f, -0.01176355f, -0.00922804f, 0.01696404f, 0.02524947f, 
    -0.02529533f, 0.01410703f, 0.02061751f, 0.02586635f, -0.03091283f, -0.01048893f, -0.02815293f, -0.01297505f, 
    -0.00183928f, 0.02139104f, 0.03501761f, 0.01628306f, -0.00654765f, -0.00956504f, -0.01887384f, -0.03963759f, 
    0.00397895f, -0.03999353f, 0.02770017f, -0.04179278f, 0.00045701f, 0.02038598f, -0.00590314f, -0.02003665f, 
    0.00647204f, 0.02930298f, 0.02597580f, -0.03059954f, -0.02406220f, 0.00326099f, 0.01861660f, -0.01474487f, 
    -0.03801109f, -0.00774818f, 0.00051111f, -0.02731927f, -0.01574168f, -0.03144048f, 0.00566166f, -0.00118201f, 
    -0.03736486f, -0.00339637f, -0.04441587f, -0.02785248f, 0.01989419f, 0.01309237f, -0.01029413f, -0.02950113f, 
    -0.03443696f, -0.02371245f, 0.02914096f, -0.00009767f, -0.00579016f, -0.01390987f, 0.01405249f, 0.02140443f, 
    0.01273982f, 0.00838924f, 0.01336965f, -0.03287705f, 0.02608890f, -0.01213722f, -0.00017919f, -0.00786383f, 
    -0.00412721f, -0.04064995f, 0.01881515f, -0.02854342f, 0.00376049f, -0.00756150f, 0.01593496f, 0.01971610f, 
    -0.03415704f, -0.01696170f, -0.02357291f, 0.01441212f, -0.03837080f, -0.04383112f, 0.01249222f, -0.01931931f, 
    0.02553933f, 0.00676093f, 0.02062296f, -0.03940937f, -0.00571753f, -0.01328657f, 0.00349246f, -0.04334025f, 
    -0.02094628f, 0.00709282f, -0.01548905f, -0.03349186f, -0.01601996f, 0.01444547f, -0.01759835f, 0.00638750f, 
    -0.00018285f, -0.00188677f, -0.00945614f, -0.02265635f, -0.03700554f, 0.01347477f, -0.00959295f, -0.02370938f, 
    -0.01214162f, 0.00491379f, -0.00357445f, 0.01917921f, 0.02450987f, -0.02114220f, -0.00140743f, -0.00252007f, 
    0.01489227f, -0.03430714f, -0.01053582f, -0.04287437f, -0.03283579f, -0.00321566f, -0.01287150f, -0.02344219f, 
    -0.02969771f, 0.00561816f, -0.01748015f, -0.00611099f, -0.01451083f, 0.00814248f, -0.02676799f, -0.02129137f, 
    0.00643236f, -0.02895526f, 0.00533121f, 0.01416410f, 0.00597029f, -0.03962985f, 0.00902610f, 0.00266063f, 
    -0.00071780f, -0.02021109f, 0.00901742f, -0.03077238f, -0.04434588f, -0.03659436f, -0.00486492f, -0.02632724f, 
    -0.01297334f, -0.03254260f, 0.00302868f, 0.02365778f, 0.01935419f, -0.03687590f, -0.02695060f, -0.00391733f, 
    -0.00888222f, -0.03651219f, 0.02308096f, -0.03879052f, -0.03913681f, 0.01265888f, 0.01941828f, -0.03191885f, 
    -0.00442759f, 0.00690410f, -0.01289882f, -0.02467884f, 0.02866588f, -0.01280211f, -0.02981314f, 0.01559276f, 
    -0.00881125f, -0.03954961f, -0.00602770f, 0.00890832f, -0.02590006f, -0.00514405f, -0.04125258f, -0.02168400f, 
    0.02157474f, -0.00103968f, -0.00348664f, -0.02143259f, -0.00333438f, -0.01358887f, 0.00896705f, -0.00890396f, 
    0.00185984f, 0.01410430f, -0.01353700f, -0.03054610f, 0.01420765f, 0.00321900f, 0.02388320f, -0.02906654f, 
    0.02598303f, -0.02429456f, -0.02635015f, -0.01903799f, 0.00761857f, -0.01525035f, -0.01258057f, -0.03928154f, 
    -0.03304647f, -0.02425515f, 0.02350402f, -0.04271855f, 0.01201481f, -0.03653654f, 0.02881369f, -0.02817934f, 
    0.00318949f, -0.02911927f, -0.00586631f, 0.00337604f, 0.00099582f, 0.02743214f, -0.01951306f, -0.01065664f, 
    -0.00033725f, -0.00010821f, 0.00464025f, -0.03283534f, -0.00766482f, 0.02397829f, -0.00155560f, -0.04523787f, 
    0.01903167f, -0.02098669f, 0.02597887f, -0.02289165f, 0.02541771f, 0.02055093f, 0.01696860f, 0.02319126f, 
    -0.00015112f, 0.01449920f, -0.01130196f, -0.00175232f, -0.00966316f, 0.02039048f, 0.02641581f, 0.00740678f, 
    -0.03471208f, 0.01526838f, -0.00851283f, -0.02974970f, 0.01615676f, -0.00227042f, -0.03945858f, -0.00234685f, 
    0.00351816f, -0.03274143f, -0.01775669f, -0.03140342f, 0.00023962f, 0.01071287f, -0.00478693f, 0.03169945f, 
    -0.04037850f, -0.01451407f, 0.01046896f, -0.00257826f, -0.04315759f, -0.00794827f, 0.01412897f, 0.02767077f, 
    -0.02941338f, -0.04042050f, -0.03771372f, 0.01780816f, -0.03103891f, 0.02287548f, -0.00354235f, 0.00913468f, 
    0.00364132f, 0.00731384f, -0.03423117f, 0.02973462f, -0.01499370f, 0.02285663f, 0.02631032f, -0.01105111f, 
    0.01341406f, 0.02323567f, -0.00969223f, -0.00824617f, 0.00590780f, -0.03552422f, 0.00214914f, 0.01453595f, 
    0.02840167f, 0.02712504f, 0.01161590f, -0.04496335f, -0.01409295f, 0.03148570f, -0.00866970f, 0.02954248f, 
    -0.01735181f, 0.01607214f, -0.00921941f, 0.03978257f, -0.03006335f, -0.00060876f, 0.01861452f, 0.00586834f, 
    -0.00015647f, -0.04207813f, -0.02056319f, -0.00724245f, -0.03741124f, -0.03572986f, 0.00586085f, -0.03914204f, 
    -0.03047143f, -0.01202903f, -0.02591601f, 0.02090586f, -0.04063230f, -0.03185389f, 0.00045209f, 0.00146791f, 
    0.01490629f, -0.00525544f, 0.01427020f, -0.03811663f, -0.00202177f, -0.04153750f, -0.01816816f, -0.02481174f, 
    0.00411907f, 0.00505245f, 0.00105728f, -0.01217774f, -0.00490735f, 0.01819443f, -0.00497234f, 0.03211804f, 
    0.00204559f, -0.00455475f, 0.01997445f, 0.02901191f, -0.03460629f, -0.03328643f, 0.01205294f, -0.03523297f, 
    0.02729424f, 0.04061117f, -0.00059305f, 0.01110620f, -0.03929948f, 0.01748350f, 0.01899669f, -0.02080740f, 
    -0.03806520f, -0.02883680f, -0.01434233f, 0.00412545f, 0.00329662f, 0.00069037f, -0.01021551f, 0.00062325f, 
    -0.01578230f, -0.00491797f, -0.01210827f, -0.03509651f, 0.02389580f, 0.01161070f, -0.00114936f, -0.01413220f, 
    0.00822408f, 0.00306377f, -0.02442381f, 0.02427216f, 0.01347046f, -0.02621069f, -0.02300177f, 0.01737801f, 
    -0.02349561f, 0.01743071f, -0.02341034f, 0.01671491f, -0.02201418f, 0.01680652f, 0.01424314f, -0.00877132f, 
    0.02239586f, -0.02033889f, -0.02059724f, -0.01072148f, 0.02468327f, 0.00683839f, 0.01270364f, 0.02419771f, 
    0.02980336f, -0.02626327f, -0.04166375f, -0.03757101f, -0.02532393f, -0.01300149f, 0.01213543f, 0.02147492f, 
    0.02598258f, 0.00799109f, -0.02226961f, -0.01092461f, 0.01233642f, -0.03851840f, -0.01212481f, -0.00996132f, 
    -0.00478139f, -0.01827325f, -0.02642810f, -0.00277951f, -0.01362070f, 0.00309299f, -0.01925926f, -0.03724137f, 
    0.02491110f, 0.01261756f, -0.00984249f, -0.04374000f, -0.00494746f, -0.03297045f, -0.02812871f, -0.01071042f, 
    -0.02180064f, -0.02822959f, 0.01968476f, -0.02862950f, 0.00432480f, 0.00320214f, 0.02738141f, -0.03737076f, 
    -0.03488492f, -0.04456040f, -0.02335488f, -0.01817458f, -0.03570782f, -0.02212611f, 0.00236038f, -0.03840179f, 
    -0.02450547f, 0.00300574f, -0.03646092f, -0.03277358f, -0.02587239f, -0.01378685f, 0.00077522f, -0.00604458f, 
    -0.00411178f, -0.00202598f, 0.01485724f, -0.04054176f, -0.02782920f, 0.02343743f, 0.00991063f, 0.02233491f, 
    0.00302503f, -0.00176838f, 0.02920106f, 0.01048497f, 0.01904676f, 0.01330310f, -0.01411528f, -0.03909119f, 
    -0.02208795f, -0.00197341f, -0.02311652f, -0.03547702f, -0.03171819f, 0.01261367f, -0.03075854f, -0.03968307f, 
    0.01089913f, 0.02615588f, -0.00757769f, -0.03300196f, 0.02208892f, 0.00192313f, -0.03348448f, -0.03291104f, 
    0.01373489f, -0.03358618f, -0.02251176f, -0.03090198f, 0.01107012f, 0.02511629f, -0.04401957f, -0.02061323f, 
    -0.00751692f, -0.02286608f, 0.02375840f, -0.04237416f, -0.02786705f, 0.00563668f, 0.02244193f, 0.00512567f, 
    -0.01130800f, -0.00419427f, 0.00541646f, -0.00043074f, -0.00133374f, -0.04233460f, -0.02451958f, -0.03148457f, 
    0.02275159f, 0.00475455f, -0.01537971f, -0.02808326f, -0.01940292f, 0.02804133f, -0.00285011f, -0.01580100f, 
    -0.04235342f, 0.02899621f, 0.01983001f, 0.01279377f, -0.02696328f, 0.02516739f, -0.00146826f, 0.01954260f, 
    -0.02878337f, -0.03818629f, -0.00070915f, 0.01098433f, -0.00959086f, -0.03516275f, -0.02067664f, -0.03276872f, 
    -0.02546928f, -0.02960216f, -0.00425442f, 0.02353717f, 0.01325667f, 0.00980160f, 0.01697591f, 0.01534489f, 
    0.02068483f, -0.02566352f, -0.00286836f, 0.00041016f, 0.02168892f, -0.00860751f, -0.02102636f, 0.02239065f, 
    -0.00305686f, 0.02700417f, 0.00753037f, -0.00211999f, 0.01184544f, -0.02817486f, -0.00375360f, 0.01492727f, 
    0.02092102f, 0.01142288f, 0.02517774f, -0.03166601f, 0.00808040f, -0.04453890f, -0.03327373f, -0.02684898f, 
    0.01696171f, -0.00609090f, -0.02746870f, -0.02982481f, -0.01325482f, -0.00536768f, -0.00032695f, -0.02324311f, 
    0.00717895f, -0.01646845f, -0.03412451f, 0.02302954f, -0.00872243f, -0.00710210f, -0.01087464f, 0.01088618f, 
    0.01799877f, 0.03717316f, 0.02186841f, 0.01014581f, 0.01710491f, -0.00303697f, -0.02861485f, 0.01252719f, 
    0.01400665f, -0.02927501f, -0.00638472f, -0.02981310f, 0.01278582f, -0.01302719f, -0.03427642f, -0.04285594f, 
    0.00128269f, 0.00303070f, -0.02813871f, -0.02260242f, 0.02136293f, -0.03545681f, -0.00205556f, 0.01961211f, 
    -0.02345703f, -0.03702441f, 0.01261676f, 0.00440311f, -0.01874835f, -0.01611320f, 0.01769203f, -0.01543827f, 
    -0.00944650f, -0.00475184f, -0.01353922f, 0.01825205f, 0.02305944f, -0.02672525f, 0.01283305f, -0.03114600f, 
    -0.01839169f, 0.01083882f, -0.03506898f, -0.01392016f, -0.02052123f, 0.01229869f, -0.00895887f, -0.03726218f, 
    -0.00215578f, -0.00677386f, -0.01719382f, -0.00943389f, -0.01308573f, -0.02414596f, -0.02096918f, 0.01569500f, 
    0.00868042f, -0.04328208f, 0.00477557f, -0.00061506f, 0.01096450f, 0.01435065f, -0.00691319f, 0.00503300f, 
    0.02893996f, -0.02971380f, -0.03852775f, -0.02524860f, 0.01155460f, -0.03064941f, -0.04202510f, 0.00447659f, 
    0.02175857f, 0.02138051f, 0.01875438f, -0.02184773f, 0.01419696f, 0.00037659f, -0.03750614f, -0.04101652f, 
    -0.00193239f, 0.02280504f, 0.01537161f, -0.01245650f, -0.01013959f, -0.04223163f, -0.02978834f, -0.02507788f, 
    -0.00921319f, 0.00122550f, -0.03909404f, -0.00081043f, -0.03058368f, -0.03746670f, 0.03189616f, 0.02808584f, 
    -0.01271413f, 0.01128820f, -0.01603165f, -0.00137849f, -0.03422106f, 0.00005821f, -0.03344237f, -0.02400727f, 
    0.01836609f, -0.01812159f, -0.00714013f, -0.01745360f, -0.01764504f, 0.03204218f, -0.04219526f, -0.02430032f, 
    -0.04039279f, 0.01635425f, 0.01790439f, 0.03141412f, -0.02741499f, 0.01683920f, -0.00087895f, -0.01225657f, 
    0.00354648f, -0.00779849f, 0.01269973f, -0.01653530f, 0.02395515f, 0.00373183f, -0.02212307f, 0.00048987f, 
    -0.02593082f, 0.02086895f, -0.02658778f, -0.03603563f, -0.00008540f, -0.03304322f, -0.03301030f, -0.03876214f, 
    -0.04043606f, 0.00482423f, -0.01819489f, 0.01710553f, 0.00111797f, 0.01899306f, 0.01745543f, -0.00486314f, 
    0.02540225f, -0.00671283f, -0.01848345f, 0.01376848f, 0.01824583f, 0.00742616f, -0.03082135f, -0.03685804f, 
    -0.02031396f, -0.01416478f, -0.04227718f, 0.01161028f, 0.01381162f, 0.01294942f, 0.01545547f, 0.00232305f, 
    0.00753879f, 0.00814541f, -0.00286861f, 0.01844405f, -0.04289699f, 0.01936762f, -0.01007881f, -0.02237229f, 
    0.01354996f, -0.03424849f, 0.02257473f, -0.00196397f, 0.02579649f, -0.03122143f, 0.01970685f, -0.00829821f, 
    -0.00510363f, 0.02186961f, 0.02283537f, -0.03677020f, -0.02171899f, 0.02130264f, 0.02058282f, 0.01775137f, 
    0.00969143f, 0.02831116f, -0.00827453f, -0.01292347f, -0.01963162f, 0.02458305f, -0.00072434f, 0.01171652f, 
    -0.00168805f, -0.03339074f, 0.01904979f, -0.03443084f, -0.03843116f, -0.00958715f, 0.00184954f, -0.01526384f, 
    -0.02369681f, -0.02104854f, -0.03255110f, -0.02077974f, -0.04044116f, -0.00025278f, 0.01228669f, -0.03081809f, 
    -0.01320238f, -0.02391350f, -0.00487062f, -0.00344572f, 0.01623011f, -0.02596963f, 0.00556428f, -0.02461585f, 
    0.02066182f, 0.02188441f, 0.00214113f, 0.02148626f, 0.01326077f, 0.00742845f, -0.00647301f, -0.02398816f, 
    0.02518836f, -0.01252170f, 0.01914221f, -0.02491550f, 0.02519628f, -0.03172173f, 0.01554120f, -0.02993514f, 
    0.00134256f, -0.01797768f, -0.02848752f, -0.00731502f, 0.01997233f, -0.01406093f, -0.01665656f, 0.02108415f, 
    -0.01249244f, -0.00933634f, -0.03403152f, -0.01233767f, -0.01541179f, -0.00527177f, 0.00924297f, -0.02758011f, 
    -0.01058112f, -0.01644239f, -0.01534627f, -0.01288478f, 0.02655893f, 0.00239735f, 0.02318959f, -0.02685678f, 
    0.00221266f, 0.00498934f, -0.00769992f, -0.02562938f, -0.02699710f, -0.02073414f, 0.01331422f, 0.01340712f, 
    -0.03570220f, -0.02197930f, -0.01954805f, 0.00270260f, -0.00606975f, 0.01086993f, -0.03566320f, -0.03522597f, 
    -0.00948402f, 0.02322206f, 0.01553305f, -0.00218330f, -0.01882524f, -0.03111161f, 0.01925496f, -0.02295875f, 
    0.00030076f, -0.02510301f, -0.01834335f, -0.01194721f, 0.01841804f, 0.01676505f, 0.02012213f, 0.02819490f, 
    -0.04402337f, 0.02536749f, -0.00682368f, 0.02242689f, 0.01505353f, 0.02432555f, 0.00296012f, 0.00025239f, 
    -0.02171599f, 0.01688539f, -0.01037074f, -0.02011074f, 0.01586730f, 0.00644540f, 0.02234000f, -0.00605279f, 
    -0.02461736f, -0.01619208f, 0.01290866f, -0.00463958f, -0.00139287f, -0.01900269f, 0.01328733f, 0.00810686f, 
    -0.02197290f, -0.03702788f, -0.02764931f, -0.02455111f, 0.00592613f, 0.01242370f, -0.00726127f, -0.00343842f, 
    0.01094015f, 0.01475053f, -0.03403362f, 0.00419151f, -0.04023940f, -0.04118631f, 0.01235918f, -0.03370881f, 
    0.01092032f, 0.00139777f, -0.01151067f, -0.00538530f, -0.01809759f, -0.03480751f, 0.02226450f, 0.00947804f, 
    -0.00100355f, 0.02301228f, -0.01909348f, 0.01528997f, -0.02386533f, -0.04447995f, -0.01243859f, 0.02594009f, 
    -0.03325241f, 0.02541008f, -0.00775237f, 0.00450930f, 0.02603599f, 0.00056671f, 0.01367066f, -0.00198376f, 
    -0.01153264f, 0.02934593f, 0.01535937f, 0.02139269f, -0.01339126f, -0.03566511f, -0.01090327f, -0.02773602f, 
    -0.00115070f, -0.00877427f, -0.01089058f, -0.01868397f, -0.00361003f, 0.02841461f, -0.00663148f, 0.00371160f, 
    -0.01795194f, 0.01436929f, 0.02077611f, 0.01600899f, -0.01717004f, -0.01563627f, -0.03870912f, -0.03642843f, 
    0.02080868f, -0.03991010f, -0.03242272f, -0.03748568f, -0.02526862f, -0.02151733f, 0.02641342f, 0.00175611f, 
    -0.00582489f, -0.02280498f, -0.02996995f, -0.02513924f, -0.00333285f, -0.00717849f, -0.01429178f, 0.00944319f, 
    0.01448099f, 0.00415367f, 0.02806307f, -0.00760345f, -0.02165475f, 0.00461079f, 0.03004179f, -0.04041219f, 
    -0.02010070f, 0.00780514f, -0.01796501f, 0.01269617f, 0.02450133f, -0.02663561f, 0.02276781f, 0.01133989f, 
    -0.01250285f, -0.04497096f, -0.02524013f, -0.02047324f, 0.02253565f, 0.01086203f, -0.01288884f, -0.04186478f, 
    -0.02015539f, -0.01998465f, 0.00552034f, -0.01155737f, -0.02898838f, -0.01117300f, -0.01295818f, 0.02397168f, 
    0.00141244f, -0.03622368f, 0.01256148f, 0.01835712f, -0.01205145f, -0.02083209f, 0.00504553f, -0.02174571f, 
    -0.03338518f, 0.03311053f, 0.01800463f, -0.00447047f, -0.00331377f, -0.00921771f, -0.03158742f, 0.00496020f, 
    0.01014491f, -0.01920430f, -0.02978304f, 0.01916969f, 0.01020643f, 0.00085284f, -0.04449051f, 0.02992275f, 
    0.00819818f, 0.00466296f, -0.03053307f, -0.00666974f, -0.01288364f, -0.01183571f, -0.00798175f, 0.01999321f, 
    -0.01820347f, -0.03575816f, 0.01187765f, -0.04009569f, 0.00601706f, 0.02664893f, 0.00877072f, -0.00484688f, 
    -0.00860562f, -0.02109345f, -0.01131333f, -0.01335730f, -0.01477693f, -0.02607917f, 0.02188500f, -0.00006947f, 
    -0.01285070f, 0.02415999f, -0.01461063f, 0.01765535f, -0.03477447f, 0.03039476f, -0.01251410f, -0.02379260f, 
    0.03044116f, -0.00735063f, 0.00699140f, -0.02483423f, 0.01367950f, -0.01866659f, -0.01034630f, 0.03991905f, 
    0.00640588f, 0.00052460f, -0.03873172f, 0.01719690f, 0.01314736f, 0.01096560f, -0.03861425f, 0.00504580f, 
    -0.04071082f, 0.01934011f, -0.04410390f, 0.00790883f, -0.00398491f, 0.01995539f, -0.01421197f, -0.02337625f, 
    -0.01744654f, -0.00057518f, 0.00873969f, -0.03440630f, -0.01288974f, 0.03573839f, 0.00249285f, 0.02210771f, 
    -0.02908944f, -0.04109649f, 0.00408852f, -0.01410591f, -0.02924084f, -0.03057316f, -0.02183483f, -0.01818852f, 
    0.06802735f, -0.09219540f, 0.14743192f, -0.16553500f, 0.12534502f, -0.00169740f, 0.03726880f, 0.04848387f, 
    -0.13396820f, -0.03124602f, -0.03538350f, 0.00311365f, 0.29719427f, -0.26858014f, -0.18613756f, -0.16426688f, 
    -0.05875822f, 0.01479203f, -0.07281677f, 0.02295165f, -0.03315214f, 0.06898307f, -0.02671397f, 0.01293556f, 
    -0.11157040f, -0.26853701f, 0.12032907f, 0.10538618f, 0.02374541f, -0.06335792f, 0.01160775f, 0.17426796f, 
    0.10768847f, 0.08264916f, 0.01997553f, -0.02268288f, -0.22187105f, -0.12954123f, 0.08064771f, 0.22325820f, 
    -0.06547302f, 0.04190352f, 0.04125161f, -0.02301581f, -0.07877644f, 0.05152251f, 0.01000994f, 0.06463198f, 
    -0.30582950f, 0.08805148f, -0.01838311f, -0.24988957f, -0.05206871f, -0.09622243f, 0.04529294f, 0.00666897f, 
    0.11614428f, -0.02687532f, -0.02963307f, 0.16340864f, -0.23589920f, -0.07131117f, 0.01617968f, -0.27109939f, 
    0.03555980f, -0.00471752f, 0.02113340f, 0.00477941f, -0.05406345f, -0.11021418f, 0.02362832f, 0.08200657f, 
    0.19575313f, -0.02848803f, 0.14317557f, 0.07284191f, -0.03405023f, 0.11522387f, 0.08116463f, 0.05872845f, 
    0.16419496f, 0.04037236f, -0.14122321f, -0.00188374f, 0.15448338f, -0.09842515f, 0.04344782f, 0.24616672f, 
    -0.01369086f, 0.00207948f, 0.14315903f, -0.02648095f, -0.11485318f, 0.08034284f, -0.05656036f, -0.06083905f, 
    0.20276728f, 0.08969365f, 0.07857598f, 0.13785091f, -0.00012122f, 0.00160045f, -0.06029859f, -0.02669144f, 
    0.05343407f, 0.06955010f, 0.01908585f, 0.04352526f, 0.04675492f, -0.04693284f, 0.06275871f, 0.03352940f, 
    0.06380028f, 0.03726010f, 0.04213267f, 0.13281780f, -0.05896476f, 0.03283504f, 0.00279885f, -0.01533904f, 
    0.13646854f, 0.13166358f, -0.19373436f, 0.21634790f, 0.06947530f, 0.14788504f, -0.14660646f, -0.04102818f, 
    -0.11994916f, 0.13680930f, -0.11121064f, -0.06026366f, 0.05494928f, 0.21478574f, -0.11415206f, -0.04675697f, 
    -0.03279406f, 0.09816626f, 0.00294223f, -0.06796923f, 0.07232681f, 0.03984493f, 0.00367795f, 0.02206555f, 
    0.14853448f, -0.17986844f, 0.20808260f, -0.06877106f, 0.01558374f, 0.05105671f, 0.04196741f, 0.06025182f, 
    -0.03343939f, -0.00044494f, -0.04812106f, 0.05322563f, 0.05476629f, -0.17587093f, 0.01996352f, 0.04500442f, 
    0.12032200f, 0.00902136f, 0.11408775f, 0.07013796f, 0.04450669f, 0.00859782f, 0.02167580f, 0.01486414f, 
    -0.21995343f, 0.09831427f, 0.18201333f, 0.18200713f, 0.00624774f, -0.03625217f, -0.03621773f, 0.00329842f, 
    0.07919061f, -0.01875630f, 0.10436187f, -0.01701476f, -0.09396825f, -0.25412020f, 0.02032479f, 0.01226049f, 
    0.04523143f, -0.02341916f, 0.01617553f, -0.06146269f, 0.06237097f, -0.07531446f, -0.01431833f, -0.00468554f, 
    0.17498161f, -0.32001424f, -0.01952410f, 0.05533943f, 0.16638245f, -0.04486382f, 0.10965171f, 0.09194402f, 
    -0.07183356f, 0.12763096f, 0.04409576f, 0.07992917f, 0.13081174f, -0.05560100f, 0.18360084f, 0.07474414f, 
    -0.09449965f, 0.01036384f, 0.05226616f, 0.04849461f, -0.04433237f, -0.03589231f, -0.01681976f, -0.01855538f, 
    -0.11364948f, 0.17221980f, -0.03009282f, 0.28568286f, 0.08143459f, -0.06263245f, 0.01774092f, 0.14039409f, 
    0.05444539f, 0.00944541f, 0.08242416f, 0.20373203f, -0.11796559f, -0.04116749f, -0.15190443f, -0.17014864f, 
    0.01131840f, -0.00143963f, -0.04779725f, -0.05993520f, 0.08663054f, -0.07774211f, -0.02260242f, 0.01841680f, 
    -0.50686151f, -0.05981517f, 0.05457796f, -0.06460107f, 0.01594654f, 0.11430643f, -0.02058213f, -0.00401298f, 
    -0.07902684f, -0.09065373f, 0.07785773f, 0.04053853f, -0.32414821f, 0.02822713f, 0.10933448f, -0.14487559f, 
    0.05157323f, -0.02597663f, 0.00051619f, -0.01506844f, 0.01427527f, -0.07198970f, -0.06436433f, 0.08098482f, 
    0.16685452f, 0.35725215f, -0.02868165f, -0.01502545f, 0.07001046f, -0.03081925f, 0.03106152f, 0.11045220f, 
    0.03718533f, -0.15300475f, 0.12053345f, -0.07506890f, -0.11425684f, -0.10381918f, -0.00636982f, -0.20150860f, 
    0.00088583f, -0.02637740f, 0.08477560f, -0.03013472f, 0.05570376f, -0.06205851f, 0.11009927f, -0.04902552f, 
    0.24111649f, 0.09752911f, 0.00581123f, 0.01920416f, 0.05294402f, -0.01288780f, -0.02056696f, 0.09657034f, 
    -0.07819153f, 0.06081309f, -0.08723262f, 0.13012056f, 0.16419742f, -0.27056754f, 0.28041959f, 0.20316954f, 
    -0.01665386f, 0.02801401f, -0.01361922f, 0.08609434f, -0.03019042f, 0.01017583f, 0.02905677f, 0.03541281f, 
    -0.07347206f, -0.09896956f, 0.50050282f, 0.10439631f, 0.06074767f, -0.00438503f, 0.00136228f, 0.07853942f, 
    -0.06523876f, -0.00753918f, -0.07781862f, -0.05878916f, 0.46676111f, -0.06623915f, -0.16185020f, 0.02618210f, 
    -0.05531914f, -0.09770715f, 0.19147173f, -0.12039135f, 0.12341728f, 0.09416191f, -0.01006005f, 0.04737504f, 
    -0.23976435f, -0.14728548f, 0.19043608f, 0.04971061f, -0.15393344f, -0.04271025f, -0.01899133f, 0.20031510f, 
    0.05677677f, 0.11322046f, -0.02534368f, 0.11752132f, -0.47960752f, -0.15098619f, -0.03765055f, -0.00122002f, 
    -0.06654310f, 0.00763626f, 0.03434072f, 0.01035206f, 0.04609197f, -0.04393034f, 0.03941007f, -0.00279705f, 
    0.16165194f, 0.06321645f, -0.02350798f, 0.04361571f, -0.02130925f, 0.04523472f, -0.03040320f, -0.09973080f, 
    0.00918464f, 0.00602124f, 0.05437680f, -0.02222594f, 0.46915841f, -0.30273357f, -0.05847307f, -0.07221841f, 
    -0.07256293f, -0.00731846f, -0.05754102f, 0.04085105f, 0.00492320f, 0.05922901f, -0.04301991f, -0.03180626f, 
    0.28718913f, -0.26629311f, 0.25502253f, 0.01679580f, 0.00501752f, 0.11453532f, -0.02515074f, 0.05436606f, 
    -0.06484920f, 0.11535256f, 0.05964931f, 0.10484067f, -0.17871572f, 0.19686107f, 0.26369035f, 0.06132443f, 
    -0.00685106f, 0.09285721f, -0.08356894f, 0.02921440f, 0.11414102f, -0.04368874f, 0.05549314f, 0.03719845f, 
    0.03961712f, 0.19941300f, 0.21441783f, -0.18189232f, 0.08006192f, 0.09341723f, -0.04487242f, 0.12039714f, 
    0.05930583f, 0.09950978f, 0.05590053f, 0.14100537f, -0.04623778f, 0.08012526f, -0.05602343f, 0.04898306f, 
    0.02955642f, -0.02422987f, -0.02300594f, 0.11284204f, -0.15659191f, 0.10246827f, 0.07793698f, 0.01456369f, 
    -0.15912676f, 0.08785426f, 0.07343733f, 0.00164370f, -0.04364195f, 0.01105678f, -0.00503159f, -0.04338157f, 
    0.07282370f, 0.07745739f, 0.08277714f, 0.07891147f, 0.09947869f, 0.32962152f, -0.08153173f, 0.23453459f, 
    0.04221011f, 0.16511126f, 0.05684415f, 0.12282015f, 0.07384807f, -0.03304075f, -0.01902755f, 0.03930307f, 
    -0.02907309f, 0.22561832f, 0.08536786f, 0.24484113f, 0.11548081f, -0.05840670f, 0.02628168f, 0.01486696f, 
    -0.06879368f, 0.02043880f, 0.05142565f, -0.00605967f, -0.04209489f, -0.12472847f, 0.07954068f, -0.05806911f, 
    -0.08231909f, 0.04744910f, 0.03036032f, -0.09416550f, -0.01354432f, -0.04645106f, 0.02919423f, 0.02482426f, 
    -0.18880270f, -0.00106363f, 0.09647375f, -0.15759686f, -0.06315663f, 0.00099302f, 0.00395577f, -0.01923929f, 
    -0.04802316f, 0.09028482f, 0.08583394f, 0.05683474f, 0.13185553f, 0.09757088f, -0.19443397f, -0.13567379f, 
    0.06543911f, 0.04804657f, -0.07474981f, -0.01439697f, 0.00895291f, 0.06851824f, 0.02997201f, 0.14941649f, 
    -0.11484864f, 0.03336203f, 0.26532730f, 0.04726977f, -0.01790236f, 0.13201323f, -0.06641334f, -0.00637123f, 
    -0.16835853f, -0.02354598f, 0.05435010f, 0.08317427f, -0.20756660f, -0.23525026f, 0.09072646f, -0.12078253f, 
    -0.05166703f, 0.09048492f, -0.02380884f, 0.01454594f, -0.02213471f, 0.04327184f, 0.03943183f, 0.13614686f, 
    0.15967461f, 0.10096343f, 0.09185711f, 0.02173238f, 0.07114646f, 0.09941466f, -0.06035072f, -0.01380081f, 
    -0.13946539f, -0.06595467f, -0.08627521f, 0.11926587f, -0.29203892f, -0.09355389f, 0.32727742f, 0.19209611f, 
    -0.04566881f, 0.10117763f, -0.06341444f, 0.01000155f, -0.06638194f, -0.01389055f, 0.02173004f, -0.01740032f, 
    0.23980360f, -0.22594488f, 0.15223601f, -0.05086885f, 0.20481251f, 0.08602641f, -0.12924694f, 0.09666486f, 
    0.10707761f, 0.05742458f, 0.00980206f, -0.01215431f, -0.19226544f, -0.11490299f, 0.13811240f, -0.10705768f, 
    -0.04597626f, 0.00653050f, 0.00226382f, 0.01778928f, -0.03162295f, 0.02601517f, 0.03916251f, -0.02008020f, 
    0.20896640f, -0.03619990f, 0.12279447f, -0.19206430f, -0.00691641f, 0.09113876f, 0.01318050f, -0.01526191f, 
    0.03888447f, -0.01910469f, -0.03784057f, 0.01269968f, -0.01159815f, -0.15972902f, -0.18575780f, -0.02559638f, 
    -0.02166988f, -0.07238964f, 0.03314888f, -0.03469855f, 0.09053631f, 0.04828165f, 0.04748922f, 0.16887139f, 
    -0.05566420f, 0.14057194f, -0.11812198f, 0.04664639f, -0.01375188f, -0.02231638f, 0.00806171f, -0.11538135f, 
    -0.03523993f, 0.04231749f, 0.12997369f, -0.01627588f, 0.05751890f, -0.04418678f, 0.11298918f, 0.15534598f, 
    0.09676921f, 0.01606126f, 0.01832638f, 0.18162729f, 0.19194955f, -0.09357026f, 0.07705883f, 0.08511525f, 
    0.22536694f, 0.00160639f, 0.06320944f, -0.01954415f, -0.11818579f, 0.08338656f, 0.01263740f, 0.08778700f, 
    -0.13237230f, 0.01049250f, 0.00411796f, -0.00582472f, -0.16359416f, 0.09601127f, 0.14232592f, -0.13538991f, 
    0.05803441f, 0.03728998f, 0.02905639f, -0.02509143f, -0.06298998f, 0.14785540f, 0.07581095f, 0.03406867f, 
    0.10273957f, 0.14095992f, 0.12286115f, -0.10888594f, 0.12641318f, 0.06966689f, 0.08160494f, 0.03465036f, 
    0.11077321f, 0.02131587f, 0.06607758f, 0.10241532f, -0.07597987f, 0.04845900f, -0.12778991f, -0.09243148f, 
    0.11251984f, 0.13010521f, -0.07135370f, -0.04560399f, 0.08103843f, -0.00461167f, -0.00167000f, 0.07624445f, 
    -0.35774049f, 0.00986086f, -0.00911678f, -0.00383962f, -0.01319179f, 0.05333318f, 0.08587056f, 0.14681301f, 
    0.03237833f, -0.07003101f, 0.12764952f, 0.11845870f, 0.11142881f, -0.04115514f, -0.01597072f, -0.13693848f, 
    0.04649800f, -0.00241881f, 0.02159669f, -0.11138485f, 0.01273079f, 0.01405021f, 0.07464711f, 0.14641850f, 
    -0.12822273f, 0.29454076f, -0.03390168f, -0.22213629f, 0.09993101f, -0.02261418f, -0.02630618f, -0.00934094f, 
    -0.03034666f, -0.03440299f, -0.11919980f, -0.02828501f, -0.18337107f, 0.19810267f, 0.11623366f, 0.06293646f, 
    -0.01640118f, 0.04121377f, -0.07996179f, 0.05965976f, -0.13170081f, 0.02485088f, 0.09720939f, -0.07360780f, 
    -0.41015345f, -0.03694259f, 0.17654017f, -0.06972665f, -0.02574565f, 0.11056583f, 0.05091116f, -0.03809856f, 
    0.05469795f, 0.03560345f, 0.02496542f, -0.07155234f, 0.08986617f, 0.11827160f, 0.15811579f, -0.16991472f, 
    -0.03327134f, -0.02040186f, -0.01079363f, -0.03406193f, 0.02351179f, 0.11468466f, -0.17403236f, 0.11100867f, 
    -0.26469380f, 0.05083269f, 0.03127470f, -0.13253744f, 0.03526824f, -0.09244826f, 0.02492093f, -0.03940243f, 
    0.10665002f, -0.07386576f, -0.01115414f, -0.04634975f, -0.40243864f, -0.01081711f, 0.03508908f, -0.00315678f, 
    0.04262127f, 0.00083247f, 0.02529016f, 0.02169096f, 0.08589160f, -0.07778916f, -0.10037204f, 0.13840416f, 
    -0.01053355f, -0.02418594f, 0.01008496f, -0.01446111f, 0.00267030f, 0.00984559f, -0.02686271f, 0.01938800f, 
    -0.03335069f, -0.00651121f, -0.02039598f, -0.03972112f, 0.00988410f, -0.00058636f, 0.00614219f, -0.01000685f, 
    0.02168375f, -0.03368011f, 0.02128386f, -0.00772289f, 0.02118129f, 0.00757915f, -0.00290265f, 0.02317448f, 
    -0.00089638f, -0.00410326f, 0.00147200f, 0.01150564f, 0.03091159f, 0.02718420f, 0.01526500f, 0.00230169f, 
    0.01839428f, 0.02089874f, 0.02802451f, 0.00114784f, -0.01981671f, 0.02374636f, -0.02651646f, -0.00198757f, 
    -0.01112087f, 0.01180588f, 0.01545608f, 0.01789777f, -0.00189589f, -0.00032128f, -0.03018779f, 0.01822884f, 
    0.01767425f, 0.02432452f, -0.02263457f, -0.02947699f, 0.02128684f, -0.01409442f, -0.02233656f, 0.03090061f, 
    0.01163119f, 0.01944125f, 0.00925055f, 0.01491703f, -0.00724015f, -0.02823845f, -0.00586557f, -0.00230949f, 
    0.02293630f, 0.00997766f, -0.03959931f, -0.02144978f, -0.02528658f, 0.01952786f, -0.04029008f, -0.03242028f, 
    0.00139179f, -0.01405797f, -0.01019502f, -0.01347222f, -0.03162846f, -0.02026779f, 0.01907428f, 0.01025646f, 
    -0.01031194f, -0.01311385f, -0.03668804f, -0.02525593f, -0.00162106f, -0.02431697f, -0.00592563f, 0.02712195f, 
    -0.01002435f, -0.04002521f, -0.03251788f, -0.01343076f, 0.01235610f, -0.00669601f, 0.00480718f, 0.00552427f, 
    0.01950587f, 0.00891006f, -0.02588793f, 0.00529462f, -0.03405637f, 0.02638857f, 0.01476336f, -0.00390392f, 
    0.00908787f, -0.01167537f, -0.03557983f, -0.02776827f, -0.01443669f, -0.03223568f, -0.03614931f, -0.00739144f, 
    0.02493644f, -0.02331502f, 0.01797898f, -0.02664087f, 0.02228184f, -0.03417501f, -0.02733497f, -0.02251871f, 
    0.00103312f, -0.01712284f, 0.03000391f, -0.01486075f, 0.00808629f, -0.04018998f, 0.02685445f, -0.03715134f, 
    -0.00100259f, 0.00505102f, 0.02086284f, -0.03443879f, 0.02239454f, -0.02080729f, -0.03096066f, -0.02685720f, 
    -0.02402161f, -0.00864938f, -0.02556727f, 0.01210838f, -0.02236363f, 0.00987794f, -0.03100104f, -0.01638493f, 
    -0.00170037f, 0.02502806f, -0.03287099f, -0.02711850f, -0.03399914f, -0.00637339f, -0.00102245f, -0.01269049f, 
    0.02131997f, -0.01020843f, -0.02033819f, -0.04104538f, -0.01537791f, -0.00418868f, 0.02422126f, -0.03765815f, 
    0.01016906f, 0.01214922f, 0.00638214f, -0.00611699f, -0.02788927f, -0.02759509f, 0.00056854f, -0.02305640f, 
    0.00800867f, -0.03228873f, 0.02728388f, -0.00998535f, -0.03855267f, -0.02391790f, -0.00732705f, -0.02560592f, 
    -0.00733157f, -0.01543572f, -0.01518717f, 0.01496407f, -0.00493578f, 0.01620561f, -0.04117243f, -0.01043032f, 
    -0.02656979f, 0.00833258f, -0.03511326f, 0.01332029f, -0.01341609f, -0.01118938f, -0.03754566f, -0.03850103f, 
    -0.00363947f, -0.01375787f, -0.00801644f, -0.01056272f, -0.02231116f, 0.03207016f, -0.03514856f, -0.00175013f, 
    -0.00122868f, 0.02815054f, 0.01273829f, -0.00344897f, -0.02743662f, -0.03853558f, -0.01546169f, 0.00488899f, 
    -0.00449035f, -0.00909041f, -0.00016534f, -0.00987848f, -0.02402924f, -0.01604119f, -0.00707613f, 0.00598862f, 
    0.01799353f, 0.02192185f, 0.02591076f, -0.02953585f, -0.01810773f, -0.03138640f, 0.03050430f, -0.01703087f, 
    -0.02271374f, -0.01522193f, -0.03700187f, -0.03103445f, 0.02196629f, -0.00557801f, -0.00789993f, -0.00182277f, 
    0.00077187f, -0.01333680f, 0.01852191f, 0.01556198f, -0.02892340f, 0.01522999f, 0.01290342f, -0.01531097f, 
    -0.01000851f, -0.03294244f, 0.03087566f, 0.00793780f, -0.02114736f, 0.01145472f, 0.00054177f, 0.01814622f, 
    -0.03591569f, 0.00994639f, 0.00543637f, 0.02290164f, 0.00246778f, -0.00424483f, -0.01658353f, 0.01974555f, 
    0.02803896f, -0.03074041f, -0.01990918f, -0.03095681f, -0.00947577f, -0.00693678f, -0.03474459f, 0.00093164f, 
    0.00240362f, 0.01106204f, 0.00026291f, -0.02130861f, 0.00935797f, 0.00849096f, 0.01170421f, -0.02426460f, 
    -0.00349208f, 0.02090783f, 0.01126810f, 0.00397089f, -0.02278214f, -0.01924367f, 0.01220869f, 0.00305310f, 
    -0.02250941f, 0.00469404f, -0.03184090f, -0.03528114f, 0.00236618f, -0.03802502f, 0.01469877f, -0.01473652f, 
    0.00967121f, 0.00181067f, -0.02239902f, 0.01467506f, -0.03150067f, 0.01114974f, -0.02476776f, 0.02597322f, 
    0.02151068f, -0.01965485f, -0.02194136f, -0.00110197f, -0.03579728f, 0.01367101f, -0.00415403f, 0.02717969f, 
    -0.00284566f, -0.01788302f, 0.00167962f, 0.00170793f, -0.00416177f, 0.00555458f, -0.03783552f, 0.02344211f, 
    -0.02574924f, 0.00106488f, 0.01757840f, -0.03475133f, -0.00168901f, 0.00281500f, 0.02005523f, 0.00356320f, 
    0.00697589f, 0.01906752f, -0.01990294f, -0.03141877f, -0.03985492f, -0.01757044f, 0.01803188f, -0.00431504f, 
    0.01427307f, -0.02682784f, -0.01507360f, 0.02540683f, 0.02029149f, -0.03419328f, -0.01354589f, 0.01806590f, 
    -0.02803639f, -0.01518764f, -0.01422867f, 0.02119560f, -0.02626571f, 0.01513333f, 0.01994267f, 0.01602054f, 
    -0.00885615f, -0.02522335f, 0.02339384f, 0.01901009f, 0.00530494f, -0.02614859f, 0.02891922f, -0.01804719f, 
    0.00451375f, 0.01990317f, -0.01759938f, -0.00494592f, -0.03228211f, -0.02244346f, 0.02648126f, -0.01347240f, 
    -0.03005032f, -0.03989374f, 0.00121870f, -0.00554282f, 0.01793600f, 0.01691485f, -0.01068640f, 0.00646792f, 
    0.00766349f, -0.01059600f, -0.02160157f, -0.01673846f, -0.03570072f, -0.02529065f, 0.02640790f, -0.03179884f, 
    -0.02885466f, 0.01354446f, -0.01203683f, -0.00062977f, -0.02252981f, -0.02684393f, 0.02423223f, 0.00154993f, 
    0.01307974f, -0.00744540f, -0.04061642f, -0.00513779f, -0.01285262f, 0.00591749f, -0.03683285f, 0.02281905f, 
    0.01356438f, -0.01420470f, -0.00188161f, -0.00791260f, -0.02056944f, 0.02177146f, -0.00834115f, -0.00605811f, 
    0.00950566f, 0.01686501f, -0.00360411f, -0.00687269f, -0.00518940f, 0.00967061f, 0.00671466f, 0.00887125f, 
    0.02428732f, -0.00264233f, 0.00529275f, 0.03089512f, -0.01870760f, -0.01328809f, -0.00716315f, -0.03075516f, 
    -0.00327844f, 0.00278974f, -0.03024791f, -0.00910049f, 0.00440083f, -0.00899659f, -0.02451878f, -0.01870942f, 
    -0.01130939f, -0.00653813f, -0.01992507f, -0.04057690f, -0.00664219f, 0.03060846f, 0.02125532f, 0.00452763f, 
    -0.03477004f, -0.02649413f, -0.03159744f, 0.01541533f, 0.01957519f, 0.00593843f, -0.03446072f, -0.03847437f, 
    -0.02211464f, -0.01580229f, -0.03220106f, -0.00952208f, 0.02492555f, -0.00900838f, -0.01211132f, 0.02816988f, 
    -0.02615145f, -0.03420647f, -0.03541729f, -0.02212117f, -0.04023130f, 0.00634723f, 0.00820139f, -0.00977012f, 
    -0.01467855f, -0.00912206f, 0.00786553f, -0.03527793f, -0.00882002f, 0.02157843f, -0.03644144f, -0.00662432f, 
    0.01380598f, 0.02229739f, -0.03325055f, 0.02656225f, -0.03445017f, 0.00999767f, -0.03460459f, -0.03571343f, 
    -0.02269392f, -0.01004132f, -0.03560231f, -0.00432314f, -0.01425591f, 0.02106738f, -0.00003563f, 0.02214385f, 
    -0.01996186f, -0.00227967f, -0.01526555f, -0.03579772f, 0.01371541f, -0.00611721f, -0.00442958f, 0.02404124f, 
    0.02060505f, -0.00756761f, 0.02118696f, -0.01347176f, 0.01295460f, -0.03367577f, 0.01140666f, -0.01647634f, 
    -0.00407472f, -0.04095318f, 0.00916334f, 0.00913446f, -0.02045503f, -0.01283105f, -0.01948236f, 0.01645878f, 
    0.01948195f, 0.00315468f, -0.01069269f, -0.01840112f, -0.00259276f, 0.02626570f, 0.00373298f, 0.00345607f, 
    0.02494325f, 0.03009888f, 0.02508853f, -0.02256764f, 0.02914939f, 0.00298789f, 0.00984509f, -0.04103531f, 
    -0.00483350f, 0.02650184f, 0.01089722f, -0.02196293f, 0.02684387f, -0.02568941f, -0.02345877f, -0.02298691f, 
    0.01201314f, -0.03845007f, -0.00007107f, -0.01077201f, -0.04028093f, 0.00280465f, -0.01493549f, -0.01318345f, 
    0.00113887f, 0.02264256f, -0.03697482f, -0.01017679f, -0.02876120f, -0.00237214f, 0.02779492f, -0.02337529f, 
    0.00011972f, -0.02666934f, 0.00227592f, -0.01108993f, -0.01502780f, -0.01870853f, -0.03255153f, -0.03458165f, 
    0.02818638f, -0.00434468f, 0.00157725f, -0.02717682f, -0.04081277f, -0.02589633f, 0.02149481f, -0.00694204f, 
    0.02657969f, -0.01192288f, 0.00182702f, 0.00896593f, -0.00308165f, -0.04017291f, -0.01068185f, -0.03017116f, 
    -0.01430539f, 0.01425954f, 0.01358898f, -0.02709454f, 0.02981311f, 0.00242375f, 0.02382193f, -0.00328727f, 
    -0.01903077f, 0.01173301f, -0.01608996f, 0.01736178f, 0.02557366f, -0.00744470f, 0.02120978f, -0.03782078f, 
    0.01010894f, -0.01068084f, 0.00521534f, 0.00380413f, 0.00006943f, -0.03613990f, 0.00215275f, 0.00441814f, 
    -0.00305049f, 0.02798212f, -0.02196445f, -0.02904860f, -0.00771834f, -0.01300796f, -0.03874614f, 0.00759631f, 
    0.00016230f, -0.03617559f, 0.00827777f, 0.00807100f, 0.01076222f, -0.04099067f, -0.01254490f, -0.00832701f, 
    -0.02662579f, -0.00763666f, -0.03591581f, -0.03131688f, -0.03295128f, -0.00486255f, -0.02546846f, -0.03043638f, 
    -0.01094003f, -0.00982872f, -0.00619578f, -0.01213767f, 0.00915992f, -0.01880341f, -0.03823074f, 0.01522363f, 
    0.01830681f, 0.02578522f, 0.00562797f, -0.01178544f, -0.02627052f, -0.03665653f, -0.02070921f, -0.00302263f, 
    -0.03040965f, -0.03799363f, 0.01174650f, -0.01910201f, -0.02401119f, 0.02793379f, -0.02160634f, 0.00939739f, 
    -0.01302272f, 0.02687087f, 0.00609304f, -0.02778643f, -0.01704163f, -0.03132331f, -0.00930358f, 0.00151132f, 
    0.02537178f, -0.00399906f, 0.01398491f, -0.01801515f, -0.01623826f, -0.03359446f, 0.00619229f, -0.01143952f, 
    0.00224717f, -0.03353110f, 0.02872447f, 0.01354848f, -0.02193585f, 0.00430205f, -0.02042626f, -0.03031796f, 
    0.00357576f, -0.01936771f, 0.01620855f, 0.00781306f, -0.02539798f, 0.00841033f, -0.01732469f, -0.02029919f, 
    0.02162211f, -0.01972242f, -0.01844879f, -0.02985832f, -0.01919380f, -0.03422000f, 0.01094403f, -0.00788088f, 
    0.02623045f, 0.01426992f, -0.02161171f, -0.03495600f, 0.02194065f, 0.01858879f, -0.00339778f, -0.02832171f, 
    -0.01084300f, 0.01437007f, 0.03055382f, -0.03002209f, 0.00644988f, -0.00115078f, 0.02987503f, 0.01169413f, 
    -0.02277082f, -0.02795793f, -0.00546777f, 0.00369365f, -0.00758987f, -0.00462680f, -0.01615840f, 0.01987893f, 
    -0.00545659f, 0.02268043f, -0.03039593f, 0.00231941f, -0.02399303f, -0.04084168f, -0.00786834f, 0.01744925f, 
    0.01431212f, -0.01813080f, 0.01403284f, -0.02521787f, 0.01228928f, 0.02302073f, 0.02164434f, -0.02659191f, 
    -0.00716050f, 0.01436466f, -0.03704901f, 0.02712023f, -0.00522864f, 0.01844644f, -0.02796766f, -0.01875465f, 
    -0.04041765f, -0.00753558f, 0.02978269f, -0.01639973f, -0.01315915f, -0.00241995f, 0.01427915f, -0.00958720f, 
    -0.01308587f, 0.01761507f, 0.02388374f, 0.02820827f, 0.00718504f, -0.01852132f, -0.01522053f, -0.01525657f, 
    -0.03427308f, -0.02748596f, -0.01111542f, -0.02627385f, -0.03704292f, -0.00465690f, 0.01056208f, 0.01036214f, 
    -0.00898817f, -0.00061244f, 0.02874964f, -0.03127089f, 0.02567998f, -0.01456563f, -0.04094479f, -0.01623608f, 
    0.00624884f, -0.01045367f, -0.00511952f, 0.01161145f, -0.03011217f, 0.00617192f, 0.01081120f, 0.00606892f, 
    -0.03901102f, -0.01672224f, 0.00571127f, 0.02266300f, 0.03416656f, -0.03385203f, 0.02377041f, 0.01478664f, 
    -0.03479318f, -0.01954706f, -0.03392853f, -0.01242920f, 0.01944166f, -0.01461984f, -0.03673223f, 0.03874566f, 
    0.00115476f, -0.02674363f, -0.02026880f, -0.02788333f, 0.02458491f, -0.03555484f, 0.00211047f, 0.01817734f, 
    0.02660560f, 0.00163892f, -0.00319729f, 0.03495125f, -0.00516844f, 0.02591753f, 0.02170099f, 0.00068243f, 
    0.00109013f, 0.01908093f, 0.00872587f, 0.03100760f, -0.01651693f, 0.02436271f, 0.02802287f, -0.02710756f, 
    -0.00402163f, -0.02433708f, 0.02450379f, -0.03197728f, 0.01617069f, -0.01586793f, -0.00739880f, -0.02198894f, 
    0.00402774f, 0.00115924f, -0.03322129f, -0.04037357f, 0.00094178f, -0.03035012f, 0.02433756f, -0.02451542f, 
    0.00688575f, 0.01692246f, 0.02241299f, 0.01089562f, 0.01446652f, -0.03331139f, 0.02576670f, 0.00597243f, 
    -0.03386032f, -0.00291360f, 0.03781892f, 0.01386177f, 0.02509078f, -0.02431524f, -0.01867295f, -0.02312079f, 
    -0.04028847f, -0.01433581f, 0.02397982f, 0.02256597f, -0.01616443f, 0.01506265f, -0.01398186f, -0.02788349f, 
    -0.03035090f, 0.01145920f, -0.01317646f, 0.02780578f, -0.00134044f, -0.03453999f, -0.03858473f, 0.00465360f, 
    -0.01783021f, -0.00068283f, -0.03938308f, 0.01685079f, -0.01193977f, 0.01400607f, -0.00365513f, 0.01827397f, 
    0.03605857f, -0.00668387f, 0.02153601f, -0.00091449f, -0.00280959f, -0.01884862f, -0.03370269f, -0.01032389f, 
    0.01346566f, -0.03583504f, -0.01472670f, -0.00897078f, -0.02007347f, -0.03782577f, -0.02182909f, -0.03550498f, 
    0.01961020f, 0.00833480f, 0.01820244f, -0.02787787f, -0.02279195f, -0.01170062f, 0.01826396f, -0.00141497f, 
    -0.02113274f, -0.01331415f, 0.02219264f, -0.02895023f, -0.00143734f, -0.03721139f, 0.01393719f, -0.01065463f, 
    -0.00267761f, 0.00436583f, -0.03828662f, -0.00436475f, -0.00467112f, -0.02983582f, -0.00856031f, 0.01976078f, 
    0.01964083f, -0.01347875f, -0.02502878f, -0.00134980f, 0.01257442f, -0.02655953f, 0.00451652f, 0.01185851f, 
    -0.00673061f, -0.00415773f, -0.01871634f, 0.02085246f, -0.02882048f, -0.03128861f, -0.03156428f, -0.02761108f, 
    0.03100679f, -0.01528352f, -0.03226605f, 0.03017396f, -0.02287365f, 0.00290930f, -0.01722476f, -0.00983136f, 
    -0.01989791f, -0.02350650f, -0.00994240f, 0.00787822f, 0.00617911f, 0.01818165f, -0.00678679f, -0.01436004f, 
    0.00366340f, 0.00324245f, -0.03514271f, -0.03841539f, 0.02980856f, 0.00516762f, -0.02289606f, -0.02514010f, 
    -0.02542392f, -0.03344759f, 0.01938783f, -0.00793427f, 0.00668064f, 0.03022849f, 0.00752961f, 0.01317398f, 
    -0.00893139f, 0.01412923f, 0.01507557f, -0.03497468f, -0.02003715f, 0.01973726f, 0.02348188f, 0.02992911f, 
    -0.00797842f, -0.03654378f, 0.02224949f, -0.03523396f, -0.01320078f, -0.00634241f, 0.02957492f, -0.02863780f, 
    -0.03689168f, 0.02363552f, 0.01283425f, 0.00335618f, -0.01938205f, 0.00578197f, -0.02467753f, -0.00887042f, 
    -0.02367555f, 0.00928541f, -0.03156783f, -0.03701222f, -0.01130215f, 0.01707777f, -0.03688968f, -0.02872012f, 
    -0.01804613f, -0.01718927f, -0.02568218f, -0.01339061f, 0.00057708f, -0.02077008f, -0.01862326f, 0.01827068f, 
    0.00604914f, -0.02559721f, 0.01217351f, -0.02095714f, 0.01832179f, 0.03100227f, 0.00100402f, -0.01704424f, 
    0.01930672f, 0.03640332f, 0.01864607f, 0.00184814f, 0.01057546f, -0.03648616f, -0.01530264f, -0.01392172f, 
    -0.01889072f, -0.03703384f, -0.02142379f, -0.03467450f, 0.03013766f, 0.01383247f, -0.01271241f, -0.03736537f, 
    -0.00485120f, 0.01754652f, 0.01931134f, 0.01317534f, -0.01467391f, -0.00803735f, -0.03176325f, 0.02127365f, 
    0.00701769f, -0.02326011f, -0.03109025f, -0.00197289f, 0.00936665f, -0.02543269f, 0.03109387f, -0.02939203f, 
    -0.03296737f, -0.01927118f, -0.03690945f, 0.02352386f, -0.01059315f, -0.00393149f, -0.01261075f, 0.00868237f, 
    -0.02088574f, 0.01341917f, -0.00009314f, -0.01162080f, -0.00112333f, -0.00311382f, 0.00797545f, 0.02487249f, 
    -0.03738917f, 0.02319228f, -0.00083886f, -0.02843789f, -0.03547790f, -0.00283602f, 0.01988141f, -0.00473695f, 
    -0.02484422f, 0.03144775f, -0.02898750f, -0.01430956f, 0.01015246f, 0.02996657f, -0.00299647f, 0.01737385f, 
    0.00436780f, 0.02767418f, -0.01437917f, 0.02742245f, 0.01801256f, -0.02206215f, 0.00414763f, 0.00125829f, 
    -0.01408763f, 0.02463805f, -0.01664384f, -0.01877131f, -0.03479675f, 0.00098707f, -0.01840526f, 0.02845185f, 
    0.00568105f, 0.02206161f, 0.02558820f, 0.02055262f, 0.01487157f, 0.00098021f, -0.00893071f, -0.01115833f, 
    -0.01290749f, 0.01983331f, -0.00427861f, -0.01476045f, -0.00390715f, 0.00345366f, -0.00736874f, -0.00550349f, 
    0.03465269f, -0.02760778f, 0.02056657f, 0.03533402f, -0.00340847f, -0.02227771f, 0.03141509f, -0.02367769f, 
    -0.02828398f, -0.02819728f, 0.03013221f, -0.02526494f, -0.01939715f, -0.00796456f, 0.02876209f, 0.00142285f, 
    -0.02689700f, -0.00540541f, -0.03136994f, -0.03891861f, 0.01269806f, 0.03768662f, 0.02152310f, -0.02728300f, 
    -0.03132435f, 0.01866406f, -0.01415142f, 0.02791047f, 0.02385317f, -0.00681672f, -0.03216122f, -0.01028538f, 
    0.02919898f, -0.00260868f, 0.01093142f, 0.02986979f, 0.01231686f, -0.01095959f, 0.00683540f, -0.01905586f, 
    0.01241321f, -0.02766398f, 0.01177992f, 0.02596322f, 0.01524833f, 0.03008667f, -0.02648734f, -0.03834601f, 
    -0.01412930f, -0.00867319f, 0.02977306f, -0.02552016f, -0.00618455f, -0.03769182f, 0.03018841f, -0.00028937f, 
    0.02837458f, -0.01732104f, 0.01465710f, -0.03239140f, 0.01551041f, 0.00339228f, -0.00515211f, 0.00566562f, 
    0.00101331f, -0.03662054f, -0.00980676f, 0.03534790f, 0.01536139f, 0.02342898f, 0.02755922f, 0.01643668f, 
    -0.02432529f, 0.00456871f, -0.02022458f, -0.02928011f, 0.02633896f, 0.01785093f, 0.00025551f, -0.03929253f, 
    0.03123848f, -0.01117361f, -0.02581297f, -0.03579905f, -0.00613496f, -0.00489186f, 0.01676996f, -0.02971250f, 
    0.02257097f, 0.02215336f, -0.02862946f, 0.02222455f, 0.02720972f, 0.02473379f, 0.00059821f, -0.02930510f, 
    0.00620990f, 0.01813509f, 0.02425316f, -0.03144018f, -0.02805808f, -0.02349042f, 0.01961524f, 0.01610753f, 
    0.00988472f, 0.00273368f, 0.01170640f, -0.02031352f, -0.01642809f, 0.01705750f, -0.02330741f, -0.03565903f, 
    -0.03257583f, 0.01410261f, -0.01590589f, -0.01016590f, -0.03147452f, 0.02854005f, -0.00010867f, -0.00292717f, 
    -0.01098114f, 0.02653336f, -0.01320020f, -0.01955622f, 0.02218080f, -0.00282076f, 0.00268883f, -0.02224946f, 
    -0.00740892f, -0.00239112f, -0.02446400f, 0.02647287f, -0.03484294f, -0.02788547f, -0.02029426f, 0.00863473f, 
    0.02940382f, 0.02705632f, 0.01649467f, -0.00223289f, -0.02583566f, 0.00926662f, 0.03099996f, -0.01458135f, 
    0.00522757f, 0.00283060f, -0.01023149f, -0.01386979f, -0.01483296f, -0.02870067f, -0.00635110f, -0.03022435f, 
    0.00336552f, 0.01625077f, 0.01871569f, -0.03390497f, -0.03673997f, 0.01949120f, -0.03454797f, 0.02326240f, 
    -0.00894555f, 0.00161494f, 0.02227855f, -0.03951612f, 0.02466986f, 0.00335281f, -0.02915698f, -0.02574691f, 
    -0.02606962f, 0.02110132f, 0.03011106f, -0.01197530f, -0.01092773f, -0.02308686f, -0.02238175f, 0.00746157f, 
    0.00118909f, 0.01977651f, 0.00148969f, -0.01821209f, 0.01404713f, 0.01222251f, -0.00815795f, 0.01331572f, 
    0.00448137f, 0.02290656f, 0.00738510f, -0.02299994f, -0.01985182f, -0.03174769f, -0.01372266f, -0.02956289f, 
    -0.02434284f, 0.02569504f, -0.02380409f, 0.02172042f, 0.00973336f, -0.00554189f, -0.00101861f, 0.02460288f, 
    0.01470325f, -0.03087724f, -0.00600253f, -0.02683150f, -0.01313824f, 0.00815586f, -0.02511874f, -0.03040867f, 
    -0.00632759f, 0.02489986f, -0.03506389f, 0.01215024f, -0.02045573f, -0.01157776f, -0.00440915f, 0.02311886f, 
    0.01099623f, 0.01468783f, 0.01386682f, -0.03870919f, -0.02987267f, -0.00422700f, -0.03401567f, -0.00095323f, 
    0.03170612f, -0.00602948f, -0.01416210f, -0.02580087f, 0.00594848f, -0.01103413f, 0.01516569f, 0.03296344f, 
    0.00992024f, -0.02190484f, -0.03528348f, -0.03537183f, 0.02387623f, 0.00901849f, -0.01174730f, 0.03058271f, 
    0.00746086f, -0.00897161f, 0.00101851f, -0.00498343f, 0.02110922f, 0.01099493f, -0.01844173f, 0.00161467f, 
    -0.02110369f, -0.03330932f, 0.01676335f, 0.02467897f, 0.00339562f, -0.00139265f, -0.00331146f, -0.02850978f, 
    0.01834111f, -0.02909965f, 0.02946810f, -0.01967604f, 0.02990381f, 0.01074630f, 0.00728236f, -0.00704470f, 
    0.01187028f, -0.01010410f, 0.01264229f, -0.02908151f, 0.02813545f, -0.02029095f, 0.01701733f, 0.01083577f, 
    0.01743085f, -0.02565790f, -0.02282884f, 0.01235060f, -0.03733416f, 0.00595123f, -0.00792892f, -0.03083543f, 
    -0.00008919f, 0.02281165f, 0.00471362f, -0.02612218f, 0.01770576f, -0.00457055f, 0.00271621f, 0.00672188f, 
    -0.01617388f, 0.01158908f, 0.01226816f, -0.03250828f, -0.00450719f, 0.01415664f, -0.00832908f, 0.01309204f, 
    -0.02525030f, -0.00152763f, 0.00364710f, 0.00543699f, -0.02188909f, -0.00719234f, -0.03499503f, -0.02093075f, 
    -0.02253972f, -0.03759421f, 0.00400016f, 0.00451910f, 0.00332975f, 0.01626538f, -0.02334605f, 0.00107958f, 
    0.03637621f, -0.00182461f, 0.00078746f, 0.02741712f, -0.02874420f, -0.03717026f, 0.01081071f, 0.00284734f, 
    0.01173701f, -0.02658542f, -0.00222922f, 0.01985024f, -0.03298340f, -0.03381576f, 0.00842318f, -0.03455913f, 
    -0.01612437f, -0.00001513f, 0.00000082f, -0.02789069f, 0.01903621f, 0.01680556f, 0.02268698f, 0.00135568f, 
    0.00798532f, -0.02361098f, 0.00246203f, 0.00361377f, 0.02629205f, -0.02113116f, -0.00950465f, -0.01517827f, 
    -0.02398101f, -0.00950968f, -0.02627664f, 0.00066610f, -0.01821374f, -0.03306502f, -0.01258578f, -0.01329355f, 
    0.00982216f, 0.01477669f, 0.02385044f, -0.02537724f, -0.01383443f, -0.00036796f, -0.03653723f, 0.02584749f, 
    -0.01026844f, 0.00023580f, -0.03685623f, 0.02788042f, 0.02571986f, -0.00595857f, -0.00758683f, 0.01517169f, 
    0.01575359f, -0.01270552f, -0.03323853f, -0.00396420f, 0.01903671f, 0.02203623f, -0.01074813f, 0.00070494f, 
    0.01918610f, -0.00002307f, 0.00371891f, 0.01705334f, -0.01157045f, -0.03129858f, -0.00873738f, 0.02180999f, 
    -0.00136795f, -0.00852960f, 0.02857865f, 0.01086466f, 0.00557111f, -0.02447987f, -0.02241671f, 0.00896519f, 
    -0.03257457f, 0.02478568f, -0.03808659f, -0.02609324f, 0.01612418f, -0.03673693f, -0.02554288f, -0.02641850f, 
    0.02215615f, 0.02120775f, -0.02879147f, -0.02948629f, 0.02410588f, -0.03882389f, 0.02775954f, -0.02627185f, 
    -0.01827601f, 0.03037005f, 0.00842813f, -0.01640263f, 0.01397505f, -0.01524766f, 0.00758553f, 0.00643891f, 
    -0.01713747f, 0.03664692f, -0.02338147f, 0.03070783f, -0.02714017f, 0.02713943f, -0.01776852f, 0.00519648f, 
    0.03651009f, 0.02107404f, -0.02451872f, -0.00751097f, 0.01568200f, 0.03351053f, -0.01904267f, 0.01053016f, 
    -0.00677269f, 0.00394118f, 0.02084283f, -0.03858624f, 0.00293898f, -0.01268593f, -0.02659532f, -0.01365600f, 
    0.02089718f, 0.00085354f, 0.02863710f, 0.02117971f, -0.01599706f, 0.02807362f, -0.01701222f, -0.00456531f, 
    -0.01040881f, 0.02346911f, 0.00210921f, -0.00440475f, 0.00170864f, -0.02892172f, 0.01880571f, 0.01871655f, 
    -0.01635323f, -0.01896529f, -0.03381378f, -0.03672262f, -0.00314489f, -0.03556365f, -0.03401069f, 0.01417539f, 
    -0.02699460f, 0.02120722f, -0.03953021f, -0.01359312f, -0.02686986f, -0.01791463f, 0.03445340f, -0.03961153f, 
    0.01491198f, -0.01119491f, -0.02693242f, 0.02484031f, 0.01317587f, 0.01334790f, -0.02526781f, -0.01434000f, 
    0.01134464f, 0.00388155f, 0.00239244f, 0.01776835f, -0.02410698f, 0.01351180f, -0.03540790f, 0.01075069f, 
    0.02521162f, -0.00849698f, 0.01828874f, 0.02484454f, 0.02489657f, -0.02308119f, 0.02829445f, 0.02377149f, 
    -0.00370338f, 0.00899271f, 0.00569936f, 0.02056280f, 0.01686619f, -0.02834219f, -0.04234419f, -0.02384864f, 
    -0.00707364f, 0.02918767f, 0.01657390f, 0.02292052f, -0.00675685f, -0.04015489f, -0.00391131f, -0.01526412f, 
    -0.00379332f, -0.02277984f, 0.00683239f, -0.03587095f, 0.02696952f, 0.01736223f, -0.03933765f, -0.00303653f, 
    0.01550634f, 0.00392969f, 0.01764899f, 0.01128640f, -0.00756366f, -0.03342465f, -0.04018587f, -0.00418068f, 
    0.02023854f, -0.03467964f, -0.00071866f, -0.02678412f, -0.01975946f, -0.01578332f, -0.01855197f, -0.00790365f, 
    -0.01799463f, 0.00229664f, 0.01408545f, -0.00703725f, -0.00083269f, 0.01856335f, 0.03185318f, -0.02814599f, 
    0.02094843f, 0.00447970f, -0.01641621f, 0.02023981f, -0.00190002f, -0.03225645f, -0.02975711f, -0.01151566f, 
    0.03059988f, 0.01143972f, -0.02441158f, -0.03996567f, 0.02542892f, -0.03706106f, -0.01546166f, -0.01003656f, 
    -0.00440640f, -0.02780559f, -0.01233268f, 0.02228504f, 0.00270148f, -0.01002527f, -0.03578696f, -0.02703050f, 
    -0.00347025f, 0.00669231f, 0.01016981f, -0.03791445f, 0.00397787f, -0.01733212f, -0.00323452f, -0.03610631f, 
    -0.03340698f, -0.00763780f, -0.03310241f, -0.01633177f, -0.03513956f, -0.00187830f, -0.00174559f, -0.04147331f, 
    -0.00469522f, -0.01891084f, -0.00532118f, -0.01631774f, -0.01268242f, -0.03985556f, -0.02691464f, 0.02121790f, 
    -0.03623515f, -0.00079572f, -0.03568653f, -0.03367468f, 0.01469540f, -0.03251694f, -0.01029454f, -0.03929067f, 
    0.01777254f, -0.02426773f, -0.00900790f, 0.02976397f, 0.01490230f, 0.00675973f, -0.01185043f, -0.02873912f, 
    -0.01643388f, -0.03825538f, 0.01117717f, -0.03061908f, -0.00998711f, -0.00863635f, -0.00807917f, 0.01974131f, 
    0.01671413f, -0.01332471f, 0.02832957f, 0.02078195f, -0.03326082f, -0.03183841f, -0.02731887f, 0.00102459f, 
    0.02517617f, -0.02643631f, -0.01383910f, -0.04238509f, 0.01962917f, -0.02066759f, -0.02343669f, 0.00719482f, 
    0.02262939f, -0.00287796f, 0.00971292f, 0.01265550f, -0.03475534f, 0.01792286f, -0.01186480f, -0.01599780f, 
    -0.01235698f, -0.03448628f, 0.02664332f, 0.01025610f, -0.03425341f, -0.01424571f, 0.00364205f, -0.00895740f, 
    -0.02730764f, -0.00194732f, -0.03166982f, -0.01037295f, -0.02828369f, 0.02780399f, -0.02948558f, 0.00567355f, 
    0.00099290f, 0.00660819f, -0.02695225f, 0.01546113f, -0.03317418f, -0.03841190f, -0.03729389f, 0.00156121f, 
    -0.03108150f, -0.01506268f, 0.03003112f, 0.02157189f, -0.03601161f, 0.00484980f, 0.02143458f, 0.02062558f, 
    -0.00344770f, 0.01607771f, 0.02131980f, -0.01970126f, 0.01869692f, -0.00628573f, 0.01804629f, -0.03996919f, 
    -0.03057876f, -0.00080222f, 0.01064335f, -0.03912223f, 0.01478352f, -0.01733523f, -0.00188332f, -0.00337566f, 
    -0.01308978f, -0.01876838f, 0.01466526f, -0.01876944f, -0.02990003f, 0.02714358f, -0.02479486f, 0.00272968f, 
    -0.00239216f, 0.00669133f, 0.01669047f, -0.03003787f, 0.00975794f, -0.03176085f, -0.03474090f, 0.01582918f, 
    -0.02337498f, -0.02584548f, 0.00844711f, -0.02054705f, -0.00714086f, 0.02304232f, 0.00873503f, 0.00360452f, 
    -0.01696094f, 0.01969360f, 0.02370390f, -0.03222034f, -0.02424724f, 0.00875782f, -0.04040278f, -0.00917198f, 
    -0.03085610f, -0.03898783f, -0.02093976f, 0.02841074f, -0.00536203f, -0.03939544f, -0.01047283f, -0.01910057f, 
    -0.03847276f, 0.00265214f, 0.02054541f, 0.01924696f, 0.02209967f, 0.00567292f, -0.00341279f, -0.02490670f, 
    -0.00678964f, 0.01499148f, -0.02499316f, 0.00170898f, -0.00029089f, 0.00559194f, -0.02944441f, -0.02286387f, 
    -0.03560742f, -0.01686666f, -0.02221322f, -0.01264420f, -0.01287213f, 0.01755103f, -0.01133674f, -0.02545128f, 
    0.02315098f, 0.01667138f, -0.01160728f, -0.03555061f, -0.01888174f, 0.02877977f, -0.03019749f, 0.01017511f, 
    -0.00315531f, 0.00872066f, 0.02094785f, -0.03212398f, 0.01851935f, 0.02751997f, 0.00685372f, -0.01180285f, 
    -0.01602921f, -0.03278114f, 0.00005307f, -0.03072100f, -0.00059130f, 0.01070745f, -0.02512684f, 0.01448720f, 
    0.00158278f, -0.01382748f, 0.01341848f, -0.02980177f, -0.01100059f, 0.02511986f, 0.00427572f, 0.04428256f, 
    -0.01376346f, -0.00245006f, -0.00014703f, 0.02500465f, -0.03297224f, -0.02862905f, -0.01646956f, 0.03594003f, 
    -0.02957063f, -0.02064718f, 0.00240611f, -0.03300171f, -0.03455983f, -0.01086653f, -0.02885937f, 0.00121372f, 
    0.00985628f, -0.04155587f, -0.02613986f, -0.01781160f, 0.00682293f, 0.01286180f, -0.00158550f, 0.01514535f, 
    0.01614731f, -0.01416657f, 0.01501729f, -0.00681611f, -0.01897417f, 0.03022287f, -0.02965408f, -0.00298237f, 
    -0.01137747f, -0.03635367f, -0.03538272f, -0.01398462f, -0.00590289f, -0.02800095f, -0.01593426f, 0.02981328f, 
    0.02072307f, -0.01550028f, -0.00931471f, 0.02810861f, 0.01482743f, -0.03399839f, 0.03044906f, -0.01384277f, 
    -0.00266944f, 0.00543911f, -0.02327602f, 0.02026901f, -0.00419189f, -0.00100336f, -0.02877107f, -0.01870117f, 
    0.02922903f, 0.02795900f, 0.02168016f, 0.02586057f, -0.00887250f, 0.01137002f, -0.03785824f, 0.02179129f, 
    0.02201304f, -0.04134450f, -0.02820530f, -0.02031883f, -0.00240151f, 0.01653759f, -0.01784460f, 0.01495062f, 
    0.00077372f, -0.01940128f, -0.03844868f, -0.04220776f, 0.01614743f, 0.02194663f, 0.02551725f, -0.03297302f, 
    0.00506943f, -0.02823663f, -0.02496706f, 0.02439914f, 0.00769930f, -0.01946518f, 0.01626898f, 0.00911960f, 
    0.01361210f, 0.03086635f, 0.00369729f, 0.02025942f, -0.03732706f, 0.00464144f, 0.00449584f, -0.03288191f, 
    0.00952651f, 0.00199070f, -0.00398950f, -0.01859556f, -0.01996160f, -0.01557295f, -0.03572062f, 0.02225742f, 
    -0.03313866f, -0.00702362f, -0.03416046f, 0.02759826f, -0.04019282f, 0.00884146f, -0.03233208f, 0.01478412f, 
    -0.03612484f, -0.00497619f, -0.01217997f, -0.00370691f, 0.02525980f, -0.02026813f, 0.01275945f, -0.01876316f, 
    0.02804357f, 0.00107069f, 0.00061870f, 0.00720180f, 0.00303228f, -0.02442538f, -0.00630275f, 0.03688465f, 
    -0.03271786f, 0.01802482f, 0.01516319f, -0.04198596f, 0.00371315f, -0.02983095f, -0.01816463f, -0.02135176f, 
    -0.03771598f, -0.00098467f, -0.01893664f, -0.02200279f, -0.03789319f, -0.03521800f, -0.02639898f, -0.00316902f, 
    -0.01459904f, 0.00401831f, -0.03024879f, 0.00098249f, -0.01521615f, -0.01606453f, -0.01794719f, 0.00286443f, 
    0.01128924f, -0.00875300f, 0.03118262f, 0.00110162f, -0.01194894f, -0.03732773f, -0.01568076f, 0.02140248f, 
    0.01275895f, -0.03836099f, 0.02101616f, 0.00583196f, 0.02592918f, -0.03242760f, -0.00555278f, 0.01621277f, 
    -0.01959179f, -0.04089311f, -0.01779013f, -0.00132734f, 0.02207484f, -0.02326387f, -0.04074972f, -0.00299966f, 
    0.02825016f, 0.02728864f, -0.03250750f, -0.02887375f, -0.00454260f, -0.03900359f, 0.01398018f, 0.01775270f, 
    0.01305528f, -0.01860287f, -0.03572757f, -0.01860506f, 0.00519344f, -0.03150224f, 0.00513322f, -0.02109704f, 
    0.02543316f, -0.01881184f, -0.01093008f, 0.00023310f, -0.01888845f, -0.00815269f, 0.01289307f, -0.03622228f, 
    0.03084019f, 0.02448489f, 0.00987464f, 0.00430468f, 0.02599438f, 0.00792848f, 0.00825034f, -0.00427721f, 
    0.02751964f, 0.03022452f, 0.01299249f, -0.03598272f, -0.03827812f, -0.02488247f, 0.00743101f, -0.02506004f, 
    -0.01050693f, 0.02723964f, -0.02200361f, 0.01335563f, 0.01253778f, -0.01507951f, -0.02677936f, -0.03120561f, 
    -0.03005677f, 0.01767263f, -0.03539856f, -0.00566826f, -0.03247449f, 0.00003430f, -0.01493959f, -0.03445499f, 
    0.00144637f, -0.03369173f, 0.00279355f, 0.00317749f, 0.01353920f, -0.00936188f, -0.02030559f, 0.01748040f, 
    -0.03228826f, -0.02990370f, -0.01126601f, -0.00573141f, -0.01248257f, 0.00760352f, -0.02179307f, -0.02128019f, 
    -0.03373935f, -0.02378684f, -0.01078765f, -0.01718723f, 0.02876156f, 0.02076866f, 0.01894141f, -0.02430954f, 
    0.02040201f, -0.02647179f, -0.03462706f, -0.01212664f, -0.02441920f, 0.01322461f, -0.00028212f, -0.03404978f, 
    -0.01221095f, 0.01880506f, 0.01155507f, 0.01649258f, -0.01213630f, 0.02757242f, 0.02904420f, 0.01369337f, 
    0.00820465f, 0.00620993f, -0.03531953f, -0.02642252f, -0.02669429f, -0.02497643f, -0.00668097f, 0.02419861f, 
    0.00944289f, 0.02783729f, 0.02504153f, -0.01423034f, 0.02302322f, -0.04016527f, -0.00607282f, -0.01185442f, 
    0.02221256f, -0.01756307f, 0.01958734f, 0.02141697f, 0.00141144f, -0.02326912f, 0.00056575f, -0.02671850f, 
    0.02687551f, -0.01868098f, 0.01190932f, -0.02771399f, -0.02803857f, -0.03551860f, 0.00380228f, -0.04084332f, 
    0.02077480f, 0.02584257f, -0.00894777f, 0.01688812f, 0.01118237f, 0.02489215f, -0.03481081f, -0.02052341f, 
    -0.03186686f, 0.02493041f, 0.01226721f, 0.01281025f, 0.00750964f, 0.02834975f, 0.01751827f, 0.02075844f, 
    -0.00531513f, -0.00172219f, 0.01658257f, 0.01162449f, 0.02026379f, 0.00702375f, 0.00521445f, -0.01200926f, 
    -0.00120078f, -0.00842032f, -0.00221890f, -0.02310228f, -0.03282093f, -0.00407698f, 0.01143005f, -0.02088405f, 
    0.03169068f, -0.00287452f, 0.01926275f, -0.00111805f, -0.03410040f, 0.00307087f, -0.02834704f, 0.01409472f, 
    -0.00159238f, -0.01953012f, 0.02694174f, 0.00428347f, 0.02244458f, 0.00751979f, -0.00568347f, -0.03827197f, 
    0.01539436f, -0.01674443f, -0.00223555f, 0.00831914f, -0.01912757f, 0.02887750f, -0.01169483f, -0.01504995f, 
    0.02412499f, -0.03565507f, -0.04151218f, 0.03003781f, 0.00009570f, 0.02111907f, -0.01286221f, -0.00402880f, 
    0.02451948f, -0.00283630f, 0.00906184f, -0.03264029f, -0.00991710f, -0.00641608f, -0.02151860f, -0.00814372f, 
    0.01876737f, -0.02241038f, 0.00107859f, -0.02522305f, -0.01558074f, 0.00372089f, -0.00321530f, -0.00250356f, 
    -0.00273044f, -0.00451849f, -0.00494314f, 0.01904489f, -0.00632378f, 0.01660547f, -0.02252188f, 0.02097187f, 
    0.00547474f, 0.01895465f, 0.01300059f, 0.01805056f, 0.00051675f, -0.00626633f, 0.02804093f, -0.01277851f, 
    0.00458950f, 0.01215173f, -0.01892806f, 0.02570281f, 0.00662197f, 0.00456384f, 0.00875188f, -0.01105827f, 
    0.01764630f, -0.00629153f, -0.03251694f, -0.02812184f, 0.00961484f, -0.00037500f, 0.02389373f, 0.02832607f, 
    -0.01818600f, 0.01021683f, -0.03351779f, 0.02171858f, -0.00221970f, -0.03110439f, -0.02008687f, 0.02009815f, 
    0.10173140f, -0.06817500f, 0.10284910f, 0.20230508f, -0.05380625f, -0.05813598f, -0.06994607f, -0.09007896f, 
    0.13582447f, -0.05993411f, -0.02466867f, 0.05259055f, -0.10440625f, 0.20668334f, 0.14510056f, 0.12129205f, 
    -0.01890293f, -0.04765219f, 0.07333549f, 0.15289602f, 0.03603571f, 0.06007160f, 0.04582387f, 0.00084251f, 
    0.15481237f, -0.06819608f, 0.04507507f, -0.17176199f, -0.04778485f, 0.08872411f, 0.02166839f, -0.08253968f, 
    -0.02423759f, -0.15266122f, 0.07349023f, -0.04078247f, -0.03986623f, -0.19163059f, -0.06643087f, -0.13516051f, 
    0.10795107f, -0.00048010f, -0.02510905f, -0.07939105f, -0.02182453f, -0.05692741f, -0.02571343f, -0.07569759f, 
    -0.09097523f, -0.09429957f, -0.09980428f, 0.07340635f, 0.16362458f, 0.00459366f, 0.02071531f, 0.01904850f, 
    -0.15925884f, 0.06060599f, -0.00425695f, -0.15354906f, 0.17714413f, 0.21625209f, 0.11856439f, 0.01221513f, 
    0.04685387f, 0.01229956f, 0.07855382f, 0.09245514f, 0.07161308f, 0.00145460f, 0.03804122f, 0.07570866f, 
    -0.15303694f, 0.07297759f, 0.12067230f, -0.01888153f, 0.12698643f, 0.03870277f, -0.05826329f, 0.06700938f, 
    -0.00669859f, 0.08992235f, 0.03819676f, -0.04655452f, -0.43731707f, 0.20382950f, 0.17826457f, 0.06063778f, 
    0.01317934f, -0.06156085f, -0.00288114f, 0.13377374f, 0.12985530f, 0.04116129f, -0.08995759f, 0.00087025f, 
    -0.22860290f, -0.03883410f, 0.01551315f, 0.01514422f, 0.05354663f, -0.02037571f, 0.11221164f, 0.03497715f, 
    0.08565518f, -0.04248584f, -0.07754131f, -0.00424518f, -0.70195585f, 0.22575793f, 0.12114401f, 0.01295581f, 
    0.01929625f, -0.06012947f, -0.08719409f, -0.02247041f, -0.02747700f, 0.03379601f, -0.03452802f, 0.09980334f, 
    -0.28491861f, 0.11757169f, -0.05884184f, 0.15592214f, 0.05580234f, -0.09192999f, 0.12631755f, 0.10725103f, 
    -0.08282501f, 0.00890548f, 0.12414499f, -0.02120412f, -0.15452832f, 0.01103345f, -0.19400963f, 0.05134947f, 
    0.06431492f, -0.01010236f, 0.04891226f, -0.11555988f, -0.07840148f, 0.07023048f, 0.02194459f, -0.02151461f, 
    0.21286973f, 0.13887835f, 0.05623457f, 0.27716029f, -0.03456465f, 0.10203445f, -0.06342616f, 0.05177397f, 
    0.02300602f, 0.04937279f, 0.00036912f, 0.09361792f, -0.05220858f, 0.29998904f, 0.10606923f, -0.18229963f, 
    -0.12828057f, -0.07628980f, -0.01639195f, 0.04472909f, -0.02661901f, 0.02657140f, 0.00440803f, 0.03723931f, 
    0.24815783f, 0.17235358f, -0.04432960f, -0.20571931f, 0.04158410f, 0.02854275f, 0.11165616f, -0.04116995f, 
    0.13854121f, -0.04641020f, -0.05100613f, -0.03557712f, -0.13949506f, -0.10066435f, -0.02958709f, -0.00481975f, 
    -0.06552207f, -0.01204729f, 0.14054050f, 0.01364978f, 0.17770541f, -0.03601569f, 0.04798994f, -0.04485192f, 
    0.15314113f, 0.35480440f, 0.14773659f, -0.31562003f, -0.01386140f, -0.07828505f, -0.07460344f, 0.05247181f, 
    -0.03315368f, -0.09570441f, 0.20224050f, 0.00152966f, 0.22012736f, 0.09427468f, -0.07181957f, 0.04170645f, 
    -0.07460287f, 0.04495290f, -0.03894792f, 0.07793115f, 0.10445867f, 0.10565592f, 0.07110186f, 0.03205948f, 
    0.04700116f, 0.16020563f, 0.28327134f, -0.19192870f, -0.06232759f, 0.15373477f, 0.01625125f, 0.08709092f, 
    0.11331593f, 0.03643937f, -0.03534244f, -0.05235866f, -0.07676484f, 0.29506081f, 0.11461238f, 0.12318388f, 
    0.05586936f, 0.12592380f, 0.08207410f, 0.00499046f, 0.00210561f, 0.04938854f, 0.00456232f, 0.07226466f, 
    -0.04014747f, -0.07575466f, -0.01577854f, 0.28333682f, -0.08443791f, -0.11873942f, -0.03337019f, -0.04911697f, 
    0.09252442f, -0.08989944f, 0.08797809f, -0.08841596f, -0.00033027f, -0.12091895f, -0.13578169f, 0.02853871f, 
    0.02778763f, 0.04758654f, -0.03845487f, 0.06802550f, 0.05455162f, 0.05936094f, 0.08089656f, 0.01886457f, 
    -0.27814755f, 0.01768949f, 0.02639536f, -0.03894797f, 0.03852290f, 0.00227083f, -0.07935657f, -0.08914654f, 
    0.06235881f, 0.07126595f, -0.06867305f, 0.10529821f, -0.03576679f, 0.15390995f, 0.19622190f, -0.00741783f, 
    0.00186571f, 0.05911410f, -0.06028527f, 0.08444136f, -0.03477317f, 0.03623002f, -0.05949462f, 0.03509919f, 
    -0.14777225f, 0.01494968f, -0.04545897f, -0.03087162f, -0.05246435f, -0.04141950f, 0.16746239f, 0.08163205f, 
    0.05165882f, 0.00562030f, 0.01033158f, 0.07773586f, 0.10454693f, 0.13715632f, -0.08698916f, 0.08500014f, 
    0.00222941f, 0.13877025f, 0.10189331f, 0.05422569f, 0.01720520f, 0.03870913f, 0.00351056f, -0.02358088f, 
    -0.15753566f, 0.21502179f, -0.00322063f, -0.13915595f, -0.05200097f, 0.05188837f, 0.01259061f, 0.10673456f, 
    0.00039484f, 0.03325611f, 0.03944344f, -0.00171438f, 0.05901986f, -0.00699403f, 0.21078767f, -0.02123811f, 
    -0.02247587f, -0.04293160f, -0.15540513f, 0.06755240f, -0.01791751f, -0.04504390f, 0.02166082f, -0.07945523f, 
    0.33507225f, 0.10891059f, -0.05585419f, -0.07622436f, -0.06227359f, 0.17964524f, -0.02120856f, -0.02871617f, 
    -0.10702670f, -0.03687184f, -0.00269060f, 0.14306200f, -0.01345073f, -0.16331550f, -0.17422137f, 0.09323496f, 
    0.06973737f, 0.03060928f, -0.08717687f, -0.00650204f, -0.00133707f, 0.03726678f, 0.02215349f, 0.00143948f, 
    -0.27588043f, 0.27938783f, -0.05565307f, 0.04912954f, 0.01123651f, -0.01882746f, 0.11387326f, 0.07779654f, 
    -0.00380885f, -0.04385368f, -0.00042935f, 0.05063701f, -0.25991070f, 0.26230779f, 0.12214937f, -0.01370535f, 
    0.07211081f, 0.10548674f, -0.00291819f, 0.05791358f, -0.09059346f, 0.09088828f, 0.05516927f, 0.05022529f, 
    0.10842006f, 0.16061050f, 0.04201428f, -0.03442563f, -0.06717710f, 0.04680901f, 0.01000556f, -0.06123258f, 
    0.05682294f, 0.00781867f, -0.08282764f, -0.02712502f, -0.29023254f, -0.05331931f, 0.10299545f, 0.24628228f, 
    0.01168924f, -0.12107085f, 0.03440410f, 0.01889427f, 0.02708600f, 0.03166962f, 0.05311145f, 0.05109475f, 
    -0.19451308f, -0.01042838f, 0.23197640f, 0.13003214f, -0.08921381f, -0.05935110f, 0.05262292f, 0.02781896f, 
    -0.00057960f, -0.10154984f, -0.01381204f, -0.00720282f, 0.23158063f, -0.10037257f, 0.07113177f, -0.06193411f, 
    -0.01589540f, 0.08974519f, 0.04813597f, 0.00168862f, 0.01153282f, -0.00444378f, -0.00515820f, -0.02085144f, 
    0.26396632f, -0.05851164f, 0.04833451f, 0.21490967f, -0.07159185f, 0.03303795f, -0.02615029f, 0.01902004f, 
    -0.00431096f, 0.00796359f, -0.06474543f, -0.02963180f, -0.18005703f, 0.00845757f, 0.43713927f, -0.07430190f, 
    -0.09007004f, 0.02525870f, -0.11837408f, 0.00548842f, -0.03893265f, 0.00700481f, -0.07112460f, 0.17763542f, 
    0.09989767f, -0.16061085f, -0.00673241f, 0.00765345f, -0.12050335f, 0.07029013f, 0.10267787f, 0.08335836f, 
    -0.06070519f, 0.07062485f, -0.01728132f, 0.16861822f, -0.13790964f, -0.10280658f, -0.05540893f, 0.14904287f, 
    -0.03277436f, -0.00658849f, 0.00803020f, 0.03537536f, -0.02650799f, 0.00873169f, -0.03384503f, -0.03332618f, 
    0.15571356f, 0.24154507f, 0.02472438f, 0.01371200f, -0.01279427f, 0.05119189f, -0.04089646f, 0.03284940f, 
    0.08052304f, -0.01237119f, -0.04810612f, -0.05674911f, 0.06821486f, 0.05283036f, 0.09570052f, 0.09786643f, 
    -0.00362001f, 0.05241537f, 0.10365310f, -0.00960548f, -0.04345842f, -0.00014883f, 0.01603561f, 0.00429052f, 
    0.22779542f, -0.21712303f, 0.05489264f, -0.11249903f, -0.14190295f, 0.11889543f, -0.05851399f, -0.00365834f, 
    0.14159806f, -0.00126425f, 0.03215576f, -0.01195472f, 0.20062900f, -0.11047482f, -0.13080673f, 0.17476767f, 
    -0.09004920f, -0.07543975f, -0.04734159f, -0.04501168f, 0.07244135f, -0.02351386f, -0.06078554f, -0.13445018f, 
    0.14506623f, 0.06894553f, -0.04629238f, 0.33786377f, 0.03235462f, -0.04444249f, 0.07540184f, 0.05329505f, 
    0.17354825f, 0.06935947f, -0.03050286f, -0.05177769f, 0.34089085f, 0.14472367f, 0.00848148f, -0.27026153f, 
    -0.01703310f, -0.00560429f, 0.07861038f, 0.12246791f, -0.07050465f, 0.11587267f, 0.08025624f, 0.09520747f, 
    -0.04546994f, 0.17628278f, -0.01928861f, 0.02437987f, -0.14593656f, 0.02300663f, 0.01543468f, -0.06865707f, 
    -0.00478707f, 0.11584197f, -0.02493582f, -0.01359129f, -0.58384341f, 0.16873597f, -0.19715039f, 0.26677641f, 
    -0.05398495f, -0.03169971f, 0.04821558f, -0.10004930f, 0.05976590f, -0.02526740f, 0.09859193f, -0.02263987f, 
    -0.33047816f, 0.00846595f, 0.03512036f, 0.20148945f, -0.00715515f, -0.02424372f, 0.04673330f, 0.04005189f, 
    0.03685885f, 0.07601675f, 0.03696862f, -0.04878577f, -0.15907010f, 0.20277263f, 0.18168776f, 0.08560020f, 
    0.01461875f, 0.16849525f, -0.08525714f, 0.11051068f, -0.04995670f, -0.03125920f, 0.01557480f, 0.02810565f, 
    -0.24278988f, 0.26064211f, 0.08762889f, -0.05386253f, 0.09312086f, -0.08604407f, -0.00200355f, 0.09795613f, 
    0.01144068f, -0.01219652f, -0.03668695f, -0.02807948f, 0.00195556f, 0.11983502f, -0.00176551f, -0.37701353f, 
    0.10039750f, -0.08164940f, -0.17543164f, 0.12810215f, -0.00093667f, 0.07523095f, 0.07606783f, 0.01585312f, 
    0.21520081f, 0.25880900f, -0.09810577f, -0.00341599f, 0.03287952f, -0.07916845f, -0.01328799f, 0.06916373f, 
    0.08275744f, -0.10122959f, 0.13036139f, 0.03668783f, -0.04898520f, -0.10940448f, -0.15141204f, -0.13187498f, 
    -0.08044982f, -0.01412905f, 0.05773483f, 0.06303648f, 0.02402014f, -0.00633844f, -0.02720127f, -0.04340111f, 
    -0.27320567f, -0.03678527f, 0.01984854f, 0.22857729f, -0.01343130f, -0.04327952f, 0.02375620f, 0.09808070f, 
    0.05460117f, 0.07391131f, 0.01303105f, 0.01318023f, -0.22677326f, 0.09615388f, 0.07671264f, 0.09207127f, 
    -0.03877620f, 0.02464512f, -0.08699646f, 0.09290443f, 0.00962320f, 0.02725532f, 0.00900442f, 0.04723476f, 
    0.10633990f, 0.09023624f, -0.13503635f, 0.13139708f, 0.02145257f, -0.07554600f, -0.03593745f, 0.04881545f, 
    0.00759497f, -0.01493400f, 0.02061517f, 0.06307895f, -0.02947355f, -0.01605943f, 0.22036549f, 0.01272682f, 
    -0.03327196f, 0.01489786f, 0.11314613f, 0.08916375f, 0.00148306f, 0.01250196f, 0.04726917f, -0.03587409f, 
    -0.17909066f, 0.18957613f, -0.10712332f, 0.12932125f, -0.05105557f, -0.13250573f, 0.03374554f, 0.05885943f, 
    0.03735233f, 0.10218073f, 0.11688752f, 0.00391782f, 0.02051524f, -0.20637831f, 0.16511995f, 0.10946649f, 
    0.03170215f, -0.01215074f, 0.05142239f, 0.01764160f, 0.17028463f, -0.11529066f, -0.04037960f, -0.09127861f, 
    -0.09226955f, -0.24530335f, -0.18159455f, 0.20049079f, 0.03495897f, -0.08823441f, -0.11264488f, -0.03477949f, 
    0.04264942f, -0.03474389f, 0.04284912f, -0.16000828f, 0.11535916f, 0.10202850f, 0.12997389f, -0.06547991f, 
    0.13961408f, 0.07792696f, -0.01841208f, 0.31747460f, -0.00106061f, 0.03842556f, 0.04978672f, -0.03654898f, 
    0.15269251f, -0.04661352f, -0.01916829f, -0.09557791f, 0.17860110f, -0.17837678f, -0.15329990f, 0.12692899f, 
    0.06574862f, -0.01476755f, 0.01992941f, 0.14972314f, -0.17004409f, 0.03768150f, -0.06750383f, 0.00620744f, 
    0.07282520f, 0.04598170f, -0.02322714f, -0.02469294f, 0.06398208f, -0.03202115f, -0.01580381f, 0.00170772f, 
    0.04082673f, 0.31698704f, 0.00418143f, -0.13831459f, 0.16807643f, -0.02782738f, 0.07353962f, 0.03034316f, 
    0.08955728f, 0.13592181f, 0.03107431f, 0.08918249f, -0.13672481f, -0.06258803f, -0.10392913f, -0.44333410f, 
    0.13132341f, 0.09574722f, 0.02248969f, -0.14092396f, 0.07804888f, -0.05108761f, 0.00933609f, 0.08562021f, 
    0.16481361f, 0.07288869f, -0.03394688f, 0.16503704f, 0.07811426f, -0.12236039f, -0.04528989f, 0.07458717f, 
    0.16404685f, 0.18112093f, 0.00384767f, 0.03499848f, 0.36010903f, 0.26663765f, 0.08235378f, 0.12464164f, 
    0.03783574f, 0.02980311f, -0.04118536f, 0.08868097f, 0.05358304f, 0.06723871f, -0.04262044f, 0.11143816f, 
    0.03150415f, 0.03000704f, 0.04684184f, 0.13539657f, -0.00839737f, 0.09222294f, -0.09569011f, -0.08420811f, 
    0.15933760f, 0.01226585f, -0.05563141f, 0.21058182f, 0.06460785f, -0.16931958f, -0.22934364f, -0.15244223f, 
    -0.00083511f, 0.04063287f, -0.01292266f, 0.01134011f, -0.03053149f, -0.09251537f, 0.05668721f, 0.05340766f, 
    0.03147663f, 0.08266150f, -0.08069368f, 0.20116009f, -0.05565742f, -0.14905609f, 0.07383527f, -0.04267029f, 
    0.02955837f, -0.02263726f, -0.01570096f, 0.10934832f, 0.02509889f, 0.17759973f, -0.19501391f, 0.04210476f, 
    0.03046348f, -0.05492199f, -0.06170832f, 0.09966411f, -0.02323188f, 0.02016355f, 0.10295046f, 0.03588885f, 
    -0.13040757f, 0.10710910f, -0.04776518f, -0.18091170f, 0.03919469f, 0.13128805f, 0.01387860f, 0.09487478f, 
    0.04644433f, 0.06511306f, 0.05259278f, 0.13356481f, -0.38494354f, 0.06388733f, -0.18211444f, 0.00461944f, 
    0.08691753f, 0.05110342f, 0.04723997f, 0.07719691f, 0.16339003f, -0.12325826f, 0.17352010f, -0.05480717f, 
    0.30331415f, 0.02947546f, 0.04593959f, -0.25482613f, 0.01430428f, 0.10669652f, -0.01678831f, 0.04282784f, 
    0.13544674f, -0.00189773f, -0.05416413f, 0.09722035f, 0.25673690f, -0.06816671f, 0.23416421f, 0.06774105f, 
    -0.01372954f, -0.01386804f, 0.01657605f, 0.08754652f, 0.10834792f, 0.00391136f, -0.01444743f, 0.15517321f, 
    -0.28739956f, -0.21454749f, -0.08621805f, -0.30934739f, 0.02017751f, -0.03554507f, 0.16164953f, -0.11220479f, 
    0.00274868f, -0.14276253f, 0.13431452f, 0.00065862f, -0.17324924f, -0.01579193f, 0.01082050f, 0.02906933f, 
    0.01784671f, 0.13666290f, 0.05077871f, 0.01036193f, 0.13212052f, 0.02429503f, 0.02084539f, 0.04979816f, 
    -0.10403403f, -0.23382403f, -0.03179764f, -0.03275694f, 0.02693086f, -0.01091107f, 0.09763902f, 0.07025185f, 
    -0.05860316f, 0.13331984f, 0.05731124f, 0.03475708f, 0.10963384f, 0.15641417f, 0.08157249f, 0.13120951f, 
    -0.00584177f, 0.02373321f, -0.18987459f, -0.00531034f, 0.04559699f, 0.04405773f, -0.01511757f, 0.16230059f, 
    -0.24345215f, -0.15737070f, 0.13836445f, 0.03522175f, -0.01375236f, 0.04702961f, 0.01981892f, -0.00598514f, 
    0.05373443f, 0.08419318f, -0.06969191f, 0.03404957f, 0.02970878f, -0.05986326f, 0.02958585f, -0.13066657f, 
    0.09542028f, 0.04193901f, 0.01197483f, 0.06559780f, -0.00207549f, 0.00686700f, -0.11128339f, 0.16719373f, 
    0.22087905f, -0.04200283f, -0.09683994f, 0.16527379f, 0.08719841f, 0.03246647f, -0.01436336f, -0.12986308f, 
    0.08064669f, 0.03030347f, 0.09994777f, 0.02634447f, 0.24573220f, -0.20820031f, -0.23127663f, -0.07286802f, 
    0.06722163f, 0.01399906f, 0.04109003f, 0.05007561f, 0.07846834f, -0.02869398f, -0.01721148f, 0.05185699f, 
    0.51773536f, 0.35494432f, 0.13794012f, -0.13519230f, -0.10330725f, -0.03071165f, 0.01906524f, 0.11599746f, 
    -0.05938786f, 0.13439223f, 0.00894497f, 0.21919082f, 0.22033654f, 0.20851935f, 0.19052985f, 0.00210989f, 
    -0.01789379f, -0.04485277f, -0.00739391f, -0.01818728f, -0.04714180f, 0.00619288f, -0.06138693f, 0.10565103f, 
    0.19643244f, -0.04042530f, 0.00071286f, 0.06232165f, -0.06772856f, 0.08999296f, 0.12354142f, 0.09076293f, 
    0.07826228f, -0.02364318f, 0.25375694f, -0.00686756f, 0.16412021f, -0.13475026f, -0.24264315f, -0.11248690f, 
    0.03815284f, 0.06271631f, 0.09898261f, -0.03707556f, 0.05847706f, -0.01449605f, -0.04576713f, 0.03304328f, 
    0.03859951f, 0.02002017f, 0.02564047f, 0.10553303f, 0.00988465f, 0.01398924f, -0.05550063f, 0.02809039f, 
    0.06586187f, 0.07751395f, 0.14140435f, 0.09925501f, -0.13172127f, -0.04960590f, 0.03666541f, -0.11684980f, 
    0.15216926f, 0.02791527f, 0.04307804f, -0.02062417f, 0.20567836f, 0.03210802f, 0.13296431f, -0.07286092f, 
    0.11452376f, 0.00319809f, -0.06928813f, 0.09083048f, 0.13617156f, 0.15247200f, -0.09589082f, -0.03045592f, 
    0.07438815f, -0.07580011f, 0.03799910f, 0.11311173f, -0.18994883f, -0.16300711f, -0.02778881f, -0.18951009f, 
    0.12429327f, 0.03840559f, 0.20278668f, 0.04771378f, 0.04834391f, 0.10857070f, 0.01015204f, 0.16402732f, 
    -0.26586750f, -0.15665431f, -0.03406398f, -0.29856306f, 0.13005494f, -0.12719285f, 0.03672089f, 0.06383169f, 
    0.12821646f, 0.03716265f, 0.04276507f, -0.13884665f, 0.38347468f, 0.21183179f, 0.00630212f, 0.22103691f, 
    0.08326703f, -0.09116878f, 0.05810071f, -0.01869041f, 0.08955124f, 0.12753826f, 0.00387227f, 0.12890317f, 
    0.42300814f, -0.10589623f, 0.14015600f, 0.15756793f, 0.08885953f, -0.01202063f, -0.02275609f, -0.06158667f, 
    -0.00698550f, -0.00102660f, 0.01309048f, 0.03750076f, -0.12991054f, -0.05741483f, -0.09465710f, -0.26833439f, 
    0.06669892f, 0.08521817f, 0.05819850f, 0.02882732f, 0.11688147f, -0.11676098f, 0.05393297f, 0.00555793f, 
    -0.03479775f, -0.01792592f, -0.04541526f, 0.11689251f, 0.10923535f, 0.05233916f, -0.00314262f, 0.01736805f, 
    0.07113986f, -0.02072619f, 0.17998071f, -0.03083089f, 0.06952216f, 0.09571809f, -0.14403465f, -0.15912905f, 
    -0.00367316f, 0.15528607f, 0.04788067f, 0.08436179f, 0.04451612f, 0.03730761f, -0.09150887f, 0.15820144f, 
    0.07863010f, 0.01048021f, -0.24390693f, -0.08176193f, 0.05956943f, 0.02867382f, 0.08554900f, 0.09358260f, 
    0.10539616f, 0.05033099f, 0.12499093f, 0.11540738f, 0.13235050f, 0.17669369f, -0.00473645f, 0.07858814f, 
    0.16954727f, -0.13095805f, 0.00373466f, 0.04486290f, 0.16177770f, 0.07948838f, 0.02129153f, 0.22983736f, 
    0.02252337f, 0.02797739f, 0.17984769f, 0.01546145f, 0.04917199f, 0.05157758f, 0.08586437f, 0.17343399f, 
    0.10425691f, 0.02532704f, 0.10149992f, -0.06444094f, -0.11086116f, -0.18397453f, -0.28899571f, 0.03833769f, 
    -0.01654702f, -0.05242179f, 0.01824912f, -0.05237772f, 0.02314673f, 0.03036397f, 0.00869279f, -0.08924004f, 
    -0.00018033f, 0.28872874f, 0.03183281f, 0.03647142f, 0.18151225f, -0.11033475f, -0.07794303f, 0.08286656f, 
    0.09174110f, 0.00839484f, 0.14696707f, -0.02220289f, 0.28195253f, -0.01770495f, 0.06203093f, 0.06025780f, 
    0.07640845f, -0.10736670f, 0.03266877f, -0.00924091f, -0.01446381f, 0.04374504f, -0.02246268f, 0.15537272f, 
    -0.09427892f, -0.05649482f, 0.05752230f, 0.21086012f, 0.14524198f, -0.03165922f, 0.03241340f, -0.04974417f, 
    0.00409168f, -0.01917436f, 0.03595648f, 0.01014335f, 0.09292635f, -0.04979547f, -0.11088255f, -0.18886331f, 
    0.03883642f, 0.05959605f, -0.02508033f, 0.09582486f, 0.10347378f, -0.01833986f, 0.13298798f, 0.04224667f, 
    0.09887299f, 0.35995346f, 0.08699188f, 0.10364911f, 0.12178952f, -0.10002586f, 0.03567920f, 0.10064163f, 
    0.07519319f, -0.03809930f, 0.00516545f, 0.07943670f, 0.05471444f, 0.25009149f, 0.11943144f, -0.05446842f, 
    -0.01355502f, 0.01486857f, -0.06291354f, 0.09918186f, 0.02878057f, 0.08446072f, 0.08049508f, 0.08320262f, 
    -0.15626134f, -0.13819411f, -0.12137309f, -0.31390914f, -0.04926761f, 0.05096209f, 0.05747785f, 0.02323058f, 
    0.09570251f, -0.08688688f, -0.03867910f, -0.00147284f, -0.10811856f, -0.12735446f, -0.00263506f, 0.10035382f, 
    0.01612450f, -0.01440204f, -0.19188434f, -0.03849587f, 0.09405635f, -0.09418086f, 0.00402131f, 0.03249258f, 
    -0.21721183f, 0.21657708f, -0.08467948f, -0.08180467f, 0.01055140f, 0.06774759f, 0.04122559f, 0.06812232f, 
    0.02437020f, -0.01565238f, 0.01366855f, 0.11166128f, 0.17515388f, -0.17184286f, 0.23765555f, 0.13928536f, 
    0.00212686f, -0.14043754f, -0.04988737f, 0.06901376f, 0.07136694f, 0.04667974f, 0.04901864f, 0.13418578f, 
    0.03578126f, 0.11069948f, -0.13419013f, -0.00724282f, -0.00119244f, -0.00528858f, 0.01519529f, -0.01334068f, 
    0.04288502f, 0.02563621f, 0.11596556f, 0.05734710f, 0.11131277f, -0.15670122f, -0.20340329f, -0.07798927f, 
    0.07442271f, -0.01598380f, 0.10389584f, -0.01671830f, 0.03816134f, 0.13674533f, -0.01031373f, 0.03093074f, 
    0.08120391f, -0.22528990f, 0.03548408f, 0.04389837f, -0.09409735f, 0.15148245f, 0.07121300f, -0.19309215f, 
    -0.01409005f, 0.01344471f, 0.03816716f, 0.07557776f, 0.03831208f, 0.05077159f, 0.00846286f, 0.27779874f, 
    -0.06401892f, 0.15707590f, 0.18745869f, -0.15448941f, 0.13541642f, 0.07134455f, 0.01923017f, 0.05147073f, 
    -0.32212541f, -0.23124376f, 0.17517778f, 0.01492284f, 0.07695138f, -0.08376105f, 0.05273786f, 0.14040084f, 
    0.05300200f, 0.13137975f, -0.05786792f, -0.02217340f, 0.26766533f, 0.23001158f, 0.21346588f, 0.04177521f, 
    -0.07024152f, 0.02047954f, -0.15000281f, 0.06407651f, 0.02158069f, 0.06504432f, 0.02984164f, 0.15217069f, 
    0.17329514f, 0.22380078f, 0.12484092f, -0.24770969f, -0.03873984f, -0.08012098f, -0.02871200f, 0.08118244f, 
    -0.06894806f, 0.09527727f, 0.00348403f, 0.12360775f, 0.24101295f, -0.02787212f, -0.15672134f, -0.01165342f, 
    0.06460396f, 0.01813582f, 0.08789960f, 0.01577502f, 0.14838479f, -0.00608025f, 0.10040300f, 0.02554131f, 
    0.33271137f, 0.00658536f, 0.03265573f, 0.08091924f, -0.03403526f, -0.00764287f, 0.08707957f, -0.03890283f, 
    0.06673800f, 0.10337403f, 0.04337038f, -0.00835205f, 0.09895742f, -0.09397347f, -0.08821573f, -0.31708753f, 
    0.03807000f, 0.15767471f, -0.05797555f, -0.15315437f, 0.07901628f, 0.02012264f, -0.00333331f, 0.07552019f, 
    0.10189810f, 0.02065447f, 0.08876959f, 0.00324184f, -0.00080833f, -0.04640666f, -0.08916686f, 0.09358729f, 
    0.01167325f, -0.03277851f, -0.03948279f, 0.17672375f, 0.21381503f, 0.31032634f, 0.08539595f, -0.03532784f, 
    0.07146493f, -0.04475762f, 0.07553534f, 0.15799205f, 0.02525118f, 0.07987491f, 0.07230612f, 0.10578278f, 
    0.52739084f, 0.33514950f, 0.24863201f, -0.22900108f, -0.00021072f, -0.07396367f, 0.02624164f, 0.09755853f, 
    0.05008998f, 0.04021815f, 0.06584080f, 0.14333020f, -0.01758173f, -0.08744670f, -0.02739358f, 0.04892511f, 
    -0.05461296f, 0.04289413f, 0.03583225f, -0.16485110f, 0.05250698f, -0.00726156f, 0.04800168f, 0.02009636f, 
    -0.01408539f, -0.25982749f, -0.16024499f, 0.22578701f, -0.04296415f, 0.05892036f, 0.20214096f, -0.11047567f, 
    -0.06987773f, 0.05783810f, 0.06802762f, 0.02585024f, 0.27806142f, 0.05899884f, 0.32873613f, 0.25048152f, 
    0.14516421f, -0.00667089f, 0.05498299f, 0.03111949f, 0.02491637f, 0.07044161f, 0.03062510f, 0.01192565f, 
    -0.19074044f, 0.05115795f, 0.23601711f, 0.23398535f, -0.13885359f, -0.09580611f, -0.01074033f, -0.01864305f, 
    -0.22945952f, -0.05277329f, 0.05718685f, 0.15761411f, -0.02717944f, -0.00384772f, -0.19551124f, -0.08141554f, 
    0.18770777f, 0.19161530f, 0.00995950f, 0.18652244f, 0.14914793f, 0.04311548f, -0.07157610f, 0.17232038f, 
    -0.23261085f, 0.17857794f, 0.05163904f, 0.04163769f, -0.17376493f, -0.01293003f, 0.03500262f, -0.01680485f, 
    0.01130210f, -0.01508218f, 0.00772623f, -0.02123615f, -0.28683066f, -0.00457017f, 0.12108316f, 0.11290931f, 
    -0.04325461f, -0.11392009f, -0.00562751f, 0.09207357f, 0.08939973f, 0.00354028f, 0.08520189f, -0.03658413f, 
    0.05014209f, 0.22614209f, 0.25813290f, -0.06561314f, -0.10287441f, 0.00947534f, 0.03919488f, 0.09546427f, 
    0.08400894f, -0.02356377f, -0.00069898f, -0.09787254f, 0.16544209f, 0.02226741f, -0.19566560f, -0.06451142f, 
    0.22416776f, 0.11666950f, 0.04353845f, -0.07407375f, 0.11825819f, 0.06019301f, 0.02057464f, -0.00785168f, 
    -0.15509504f, -0.06264168f, -0.05148214f, -0.09102851f, -0.02624839f, -0.07780240f, -0.14157680f, 0.04418469f, 
    -0.12843917f, -0.02512149f, -0.01169460f, -0.06693742f, -0.28092685f, 0.08233210f, -0.18553400f, -0.33219451f, 
    0.13833468f, 0.19264609f, 0.02830175f, 0.08304361f, -0.04659713f, 0.06825799f, 0.03645789f, -0.00377522f, 
    -0.01347960f, -0.20342715f, 0.20367855f, 0.14680287f, -0.02333765f, -0.05153850f, 0.00184420f, 0.04231270f, 
    -0.04405946f, -0.09369671f, -0.05336748f, 0.02861894f, -0.00711953f, -0.12077399f, 0.09475125f, -0.10599752f, 
    0.09194019f, -0.01071563f, -0.08508179f, 0.07633569f, -0.02021472f, 0.06154208f, -0.05985393f, 0.04100064f, 
    -0.37478584f, -0.15504289f, 0.24585512f, -0.40707052f, -0.04989620f, 0.06852470f, 0.07903828f, 0.10429988f, 
    0.12742905f, -0.00295002f, -0.04562375f, 0.02786149f, 0.01596171f, 0.04118587f, 0.06830215f, -0.02746138f, 
    -0.02887021f, -0.06759533f, 0.08721596f, -0.00857469f, -0.00750387f, -0.04048374f, 0.04808541f, 0.01109879f, 
    0.28462926f, 0.16958988f, -0.15150899f, 0.20442000f, 0.18760535f, 0.15892492f, 0.10694519f, -0.03986017f, 
    0.06191514f, 0.09527108f, 0.01565401f, -0.04829213f, -0.13800856f, 0.07564675f, -0.05136332f, 0.04672333f, 
    0.12448929f, -0.11865222f, 0.15023078f, 0.01189853f, 0.02294749f, 0.14295109f, -0.11070498f, 0.02313822f, 
    0.15749955f, 0.10284668f, -0.04004850f, -0.08530105f, -0.06171094f, 0.00501159f, 0.09509243f, 0.04809745f, 
    -0.05002805f, -0.10993031f, -0.16859041f, -0.06981479f, 0.51139235f, 0.15190336f, 0.23033078f, -0.14850378f, 
    -0.32021186f, 0.08631235f, -0.01399064f, 0.08247446f, -0.01696915f, -0.06694704f, 0.08499980f, -0.00314909f, 
    0.06047641f, 0.22492963f, 0.09512773f, 0.23607029f, 0.01013363f, -0.03148491f, 0.21616887f, -0.12104642f, 
    0.14480329f, -0.02271058f, 0.10165914f, 0.08420601f, -0.12581997f, -0.06766172f, 0.34635016f, 0.29701191f, 
    -0.08630405f, -0.22421262f, -0.04190709f, -0.07567400f, -0.02679664f, -0.11837975f, 0.03523790f, -0.09831533f, 
    -0.14044255f, 0.13019994f, 0.15390405f, 0.00065529f, -0.13149928f, 0.00331178f, -0.03908273f, 0.06817715f, 
    -0.09692194f, 0.05031485f, 0.01843207f, -0.18924019f, 0.00236164f, 0.26023188f, -0.07736266f, -0.14104636f, 
    0.02453612f, 0.06474432f, 0.02775890f, -0.16968206f, 0.07931433f, 0.09242183f, 0.10669940f, 0.10218506f, 
    0.14235388f, 0.02104181f, 0.15691505f, 0.06011243f, -0.08352831f, -0.03388982f, -0.00558244f, 0.07650650f, 
    0.03626459f, -0.03257563f, -0.03574834f, -0.03127732f, 0.08497918f, 0.23252693f, 0.10090407f, 0.26147947f, 
    -0.22359531f, 0.05691071f, 0.16781588f, 0.12225550f, -0.05916895f, 0.05777331f, -0.01600323f, 0.02691652f, 
    -0.28485769f, -0.23788947f, 0.35590217f, -0.07534721f, -0.07587325f, -0.05734310f, 0.03317006f, -0.08410351f, 
    -0.15021293f, 0.01687674f, -0.10270934f, 0.04999813f, 0.25474176f, 0.05638082f, -0.03898767f, 0.05588939f, 
    0.08543985f, -0.00184883f, -0.03512687f, -0.11059359f, 0.10105778f, 0.07158872f, -0.02878976f, 0.15550075f, 
    -0.32259032f, -0.04426926f, 0.02900822f, -0.24888486f, 0.05858316f, 0.21067631f, -0.02896480f, -0.01074853f, 
    0.06626211f, -0.06260659f, 0.00780167f, -0.14665501f, 0.31231916f, -0.10324588f, 0.10662543f, -0.01074374f, 
    -0.03289070f, -0.00371430f, 0.01613732f, -0.09480696f, -0.05383592f, 0.02558038f, 0.12846293f, -0.02082285f, 
    0.07130729f, -0.14307146f, -0.21688086f, 0.04583951f, -0.16876964f, -0.04962516f, 0.12450638f, 0.02724967f, 
    0.00101532f, 0.04140361f, 0.00974659f, -0.06099020f, -0.47293463f, 0.09631518f, -0.31948945f, 0.01487562f, 
    0.06800977f, 0.01670591f, -0.09690017f, -0.02187647f, 0.21853611f, -0.04252658f, -0.09051277f, 0.07017103f, 
    0.46521071f, -0.19500604f, -0.01455483f, 0.23785608f, 0.18314324f, 0.23168229f, 0.20497042f, -0.07620218f, 
    -0.04905161f, 0.02977113f, 0.05727285f, -0.01389200f, -0.28775272f, 0.18264854f, 0.17296480f, 0.03757262f, 
    -0.22561496f, 0.03938289f, 0.00732044f, 0.11729012f, 0.01545782f, -0.06348009f, -0.05488571f, -0.05657971f, 
    -0.47379315f, 0.46295941f, -0.08146548f, 0.14499117f, -0.04100949f, -0.03618711f, 0.08638713f, 0.01148821f, 
    -0.01474068f, -0.03585399f, 0.04025495f, -0.11780084f, -0.18316929f, 0.10633809f, -0.08614958f, -0.16724622f, 
    0.14657365f, 0.12083269f, -0.03267454f, 0.05538514f, -0.06370903f, -0.04436402f, 0.07648002f, 0.18666108f, 
    -0.13467325f, -0.03402933f, 0.15563957f, 0.20743768f, -0.08674219f, -0.06836786f, 0.09425859f, -0.06373172f, 
    0.02678674f, -0.08531160f, -0.07757545f, 0.08459443f, 0.05777815f, -0.04137731f, 0.18939908f, 0.22593968f, 
    -0.03265839f, -0.09611771f, 0.09411533f, 0.07836342f, -0.06877544f, 0.03974074f, 0.06822181f, -0.11812059f, 
    -0.21424584f, -0.00473036f, 0.30432075f, 0.19236138f, 0.05967225f, -0.08475450f, -0.01912616f, 0.00145219f, 
    -0.08883634f, -0.00873132f, -0.04089456f, 0.07716697f, -0.36062443f, -0.13487461f, 0.00379126f, 0.10283525f, 
    -0.19235924f, 0.05599624f, 0.01028043f, -0.02757148f, 0.06368928f, -0.05586957f, -0.07271264f, 0.06524181f, 
    0.48952657f, -0.29255849f, 0.13383423f, -0.00821862f, -0.00246440f, 0.08849899f, -0.01392055f, -0.01793944f, 
    -0.05731519f, 0.06475855f, 0.16044636f, -0.17723799f, -0.02954983f, 0.15864788f, 0.40795943f, 0.05460495f, 
    0.21856961f, 0.06007994f, 0.04092853f, 0.21019869f, 0.03153559f, 0.18229131f, -0.02455310f, -0.05252601f, 
    0.14742482f, -0.06142770f, -0.24213567f, 0.17727812f, 0.03029904f, 0.03743798f, -0.02728662f, 0.02220187f, 
    0.05657705f, 0.03632353f, -0.04671522f, 0.00770237f, -0.03072374f, 0.35396054f, 0.09734885f, 0.22355239f, 
    -0.11719880f, 0.06620170f, 0.10949863f, 0.04631246f, 0.00578372f, 0.14686492f, 0.09159572f, 0.10040936f, 
    0.25093102f, 0.13896638f, 0.22674932f, -0.16394490f, -0.05051567f, 0.13557619f, 0.13403405f, -0.19364777f, 
    -0.06309933f, 0.03920623f, -0.03752153f, 0.05623417f, -0.27937770f, -0.02838168f, -0.12045002f, -0.08924351f, 
    0.13006167f, 0.00723184f, 0.09363948f, 0.03182451f, 0.09797315f, 0.04575785f, 0.08630175f, 0.01119509f, 
    0.03638860f, 0.11328972f, 0.08302141f, 0.13596512f, -0.04008251f, -0.05581276f, 0.04250990f, -0.00523864f, 
    0.04465543f, 0.13684149f, -0.01603535f, -0.09252940f, -0.03883931f, 0.08133246f, 0.31758165f, -0.05127235f, 
    -0.20713069f, -0.02246998f, 0.09212430f, 0.02747956f, 0.02323850f, -0.13510975f, -0.02118425f, 0.03881215f, 
    0.03516847f, -0.21124493f, 0.13190304f, 0.11349636f, 0.05307025f, 0.11472633f, 0.02041917f, 0.07711879f, 
    -0.15460558f, 0.06902903f, 0.08754949f, -0.06017091f, 0.06612077f, 0.35377911f, 0.09323226f, 0.05194937f, 
    0.05137772f, 0.10099792f, 0.18101290f, 0.07249970f, 0.09764058f, -0.04003639f, -0.14362949f, -0.07908165f, 
    -0.36232796f, -0.06742737f, 0.21298242f, -0.09841829f, -0.23069113f, 0.01647300f, -0.00464090f, -0.20537540f, 
    0.00734502f, 0.00704345f, -0.07158289f, 0.05461986f, 0.35156649f, 0.23551890f, 0.09315164f, 0.12937623f, 
    -0.13371007f, 0.12391195f, -0.01280070f, -0.00317266f, 0.02430997f, 0.05465898f, -0.00281120f, -0.03763260f, 
    -0.30154094f, -0.08762831f, 0.20057291f, -0.02641856f, 0.02876258f, -0.14400554f, -0.01585069f, -0.06542352f, 
    0.11439329f, 0.05440600f, -0.04296635f, 0.09514184f, -0.23313621f, 0.24317713f, 0.08323239f, -0.00613778f, 
    0.01544878f, 0.11341678f, 0.04891193f, 0.09292927f, -0.07723321f, -0.07514288f, 0.09579517f, -0.05625718f, 
    -0.09991815f, 0.38411304f, 0.07547443f, 0.03980326f, 0.13874361f, 0.09550644f, 0.05638168f, 0.02400116f, 
    0.06923829f, 0.02423871f, -0.01789738f, 0.11181588f, -0.29484352f, 0.09035890f, 0.26129243f, -0.09035396f, 
    -0.08421127f, 0.12265953f, -0.01259597f, -0.05634519f, -0.06019720f, 0.04721427f, -0.06512215f, 0.05889172f, 
    0.25425607f, 0.00580696f, 0.29047483f, -0.10583362f, 0.06670973f, 0.07348160f, 0.11179068f, -0.08147246f, 
    0.08704972f, -0.01488403f, -0.10420656f, 0.00822386f, -0.12514439f, 0.09429899f, 0.05370502f, -0.05370058f, 
    -0.05108871f, 0.02915711f, 0.11667114f, -0.02554767f, 0.11383381f, -0.04011629f, -0.03238661f, 0.02386480f, 
    0.12369746f, 0.11667420f, 0.09747381f, 0.07089929f, 0.01399844f, 0.04225632f, 0.06275479f, 0.02280846f, 
    0.02066137f, 0.08551347f, 0.00177479f, -0.08418166f, -0.01643539f, -0.03379360f, -0.01610543f, -0.02100010f, 
    -0.05806430f, -0.06704773f, -0.07439832f, -0.05949444f, -0.15956719f, 0.04001711f, -0.05770993f, 0.06111904f, 
    0.23361507f, 0.00517286f, 0.29323971f, -0.05569175f, -0.04153372f, 0.00501863f, -0.09814917f, 0.05051790f, 
    -0.01393564f, -0.02427787f, 0.08422951f, 0.03730616f, 0.12965921f, 0.06605602f, -0.18045336f, 0.08723349f, 
    0.20708895f, 0.08100797f, 0.02188235f, 0.02911624f, -0.01683461f, 0.01155834f, 0.00935264f, 0.12526724f, 
    -0.22565724f, -0.06262019f, 0.12744996f, -0.08386468f, -0.04299703f, 0.07392951f, 0.25332871f, 0.02785076f, 
    0.14823945f, -0.03537049f, 0.02830148f, -0.11752078f, -0.16353513f, -0.06660926f, 0.03205847f, 0.21435519f, 
    -0.06893969f, -0.01902894f, -0.07984200f, -0.05524002f, 0.01881986f, -0.01015384f, -0.13116455f, 0.06748056f, 
    0.18411696f, 0.02676275f, 0.16957825f, 0.33908114f, -0.22438385f, -0.06405742f, -0.04318077f, 0.00576978f, 
    -0.05304738f, -0.06609739f, 0.01384662f, 0.04810513f, 0.02499352f, 0.05796454f, 0.09416783f, 0.01667139f, 
    0.02606491f, -0.06314554f, 0.11939882f, 0.12942231f, 0.04014122f, -0.16164134f, 0.05499377f, 0.02514222f, 
    -0.01737124f, 0.04865970f, -0.33245912f, 0.00372726f, 0.01974930f, -0.01687559f, -0.05588122f, -0.03391578f, 
    -0.01765605f, 0.04568186f, 0.01548813f, 0.00739022f, -0.07680576f, 0.08443197f, -0.05524495f, -0.15416715f, 
    -0.04414125f, 0.07294127f, 0.05120558f, -0.01800044f, -0.04584596f, -0.13114683f, 0.15193233f, -0.15001637f, 
    -0.02908876f, -0.03692991f, -0.04192605f, -0.01433049f, -0.03797384f, -0.03516087f, 0.01281142f, 0.00773897f, 
    0.01358733f, -0.03508608f, -0.00589426f, -0.02434610f, 0.01629430f, -0.02240896f, 0.02837727f, 0.01413344f, 
    0.00343490f, 0.01732654f, 0.02627856f, -0.02231291f, 0.02634627f, -0.03916757f, 0.01012540f, 0.00383514f, 
    0.00841316f, 0.02686845f, -0.01238534f, 0.02685890f, -0.02828254f, -0.02370576f, -0.00003238f, -0.00178105f, 
    0.01040731f, 0.00782490f, -0.03620921f, 0.00296533f, 0.00138956f, 0.01354098f, -0.03027272f, -0.02885591f, 
    0.02007862f, -0.03915902f, -0.01115250f, 0.02340742f, -0.03802556f, -0.03525912f, 0.01630028f, 0.02721901f, 
    0.01764738f, 0.01475488f, 0.02689775f, -0.00689376f, 0.02452260f, 0.01090523f, 0.02059287f, 0.01055119f, 
    -0.00129374f, 0.02672278f, -0.02513701f, 0.03067734f, -0.04220042f, 0.02236083f, 0.01551140f, -0.03880128f, 
    -0.02651388f, 0.00142112f, 0.02293776f, -0.02563198f, 0.01017423f, -0.02356537f, 0.02248127f, -0.01228084f, 
    0.00988325f, 0.01972563f, -0.00476324f, 0.00970400f, -0.01504627f, -0.00606834f, 0.00132054f, -0.03081359f, 
    0.00749226f, 0.00223254f, -0.04066348f, 0.02168309f, 0.00814211f, -0.01909873f, -0.01629593f, -0.01960862f, 
    -0.01542430f, -0.03297067f, 0.02439414f, 0.01818907f, 0.00579086f, 0.02146478f, -0.00459397f, 0.01934015f, 
    -0.00921186f, -0.00364553f, -0.00441009f, 0.01421360f, 0.02296934f, 0.00870329f, -0.03897207f, 0.01032288f, 
    0.00971383f, -0.03417923f, 0.01359332f, 0.00443043f, 0.01736340f, 0.02280512f, -0.01129765f, 0.01787518f, 
    -0.04347035f, -0.01350564f, 0.02613792f, -0.03269289f, -0.03018889f, 0.00234445f, 0.02206753f, -0.01987825f, 
    -0.00531359f, 0.02321623f, -0.02430793f, 0.01533948f, -0.01756680f, -0.03517907f, -0.01818373f, -0.01799118f, 
    0.00477877f, 0.01099992f, -0.02401141f, -0.00845694f, -0.00218503f, 0.01148278f, 0.00786882f, 0.02393460f, 
    -0.01718401f, 0.01644331f, 0.01565646f, -0.01715440f, -0.03422688f, 0.01519234f, -0.04374054f, 0.02329489f, 
    -0.03488331f, 0.00062753f, 0.01988152f, 0.02539990f, -0.00833933f, -0.03647604f, 0.02682157f, -0.00658861f, 
    -0.01084447f, -0.00760838f, 0.01770424f, -0.01481753f, -0.02373543f, -0.03547911f, 0.01430878f, -0.04259083f, 
    0.02292882f, 0.01910995f, -0.00229796f, 0.00410271f, 0.01569351f, -0.03776193f, 0.00602103f, -0.03341134f, 
    0.01858413f, -0.03375894f, -0.00167655f, 0.01288764f, 0.02078450f, 0.02701688f, 0.00592353f, -0.04211860f, 
    0.02506782f, -0.02337964f, 0.02696954f, -0.02360291f, -0.02736953f, 0.00067308f, -0.00390305f, -0.01579791f, 
    -0.03195070f, -0.01325189f, -0.00431325f, -0.01052167f, -0.03989996f, 0.02033130f, -0.02612174f, -0.00388459f, 
    -0.00454807f, 0.02272233f, 0.01765449f, 0.00726136f, 0.00823566f, -0.02956863f, -0.02483884f, 0.02475316f, 
    -0.00437177f, 0.02367762f, -0.02523990f, -0.02247886f, 0.00160902f, 0.01835853f, -0.02425781f, -0.02459618f, 
    -0.02856785f, -0.03515317f, -0.02657275f, -0.00032126f, 0.00545125f, 0.01296182f, -0.02328492f, -0.01272536f, 
    -0.03668284f, -0.04128562f, -0.01956340f, -0.04385222f, -0.03758220f, 0.00117544f, 0.01375762f, 0.02142963f, 
    -0.02256523f, -0.00941012f, 0.00421604f, 0.02516186f, -0.04243705f, -0.00149481f, -0.02741489f, 0.02427263f, 
    -0.01340633f, -0.04195498f, -0.01049853f, -0.02475030f, -0.00059535f, -0.03685334f, -0.02761593f, 0.01975622f, 
    -0.03013863f, -0.03263904f, -0.01621430f, -0.00895272f, -0.04247174f, -0.00046310f, 0.02464880f, -0.01085915f, 
    -0.02913664f, -0.01077434f, -0.00452812f, 0.01390515f, -0.03521607f, -0.01652236f, -0.01419563f, -0.00218236f, 
    0.01462804f, 0.00798732f, 0.02587122f, 0.00157561f, -0.02901664f, -0.02624218f, 0.02155013f, 0.00504473f, 
    -0.00966169f, 0.02391671f, -0.03469747f, 0.02051922f, -0.01784768f, -0.04192805f, 0.00760139f, -0.02640799f, 
    -0.03780808f, -0.01239846f, -0.02238394f, -0.02725410f, 0.02061727f, -0.02175236f, 0.00020362f, 0.00969634f, 
    0.00202108f, -0.00503632f, -0.00738221f, 0.02435563f, 0.01258075f, -0.00503286f, -0.02569043f, -0.01988510f, 
    -0.02722585f, 0.01923859f, -0.03960478f, -0.01882980f, -0.03974768f, -0.04136112f, -0.00238221f, 0.00939461f, 
    -0.02394730f, -0.00482610f, 0.02693642f, 0.02307247f, 0.01633636f, 0.02637362f, -0.01835318f, -0.02521951f, 
    -0.01543708f, -0.00038069f, -0.02647004f, 0.01951211f, -0.01937305f, 0.00090491f, -0.00155918f, -0.02095491f, 
    0.01242584f, -0.01049831f, -0.02355427f, -0.01568128f, -0.02109458f, 0.00632619f, -0.02882936f, -0.03805202f, 
    -0.02153038f, -0.01438029f, -0.02350625f, -0.03734233f, -0.01167555f, -0.00768883f, -0.00547763f, 0.02893633f, 
    0.01844564f, 0.00538565f, -0.02978107f, -0.00478625f, -0.01625988f, -0.03007681f, 0.02328152f, -0.02587747f, 
    0.02616568f, -0.03745646f, -0.00242239f, -0.01353021f, -0.04374198f, -0.01982798f, -0.01835772f, -0.03332377f, 
    0.02564424f, -0.01441551f, 0.00052244f, 0.01570988f, -0.03347271f, -0.00815773f, -0.01765390f, -0.02071343f, 
    -0.00093909f, -0.01713801f, -0.03650345f, -0.02647919f, -0.03160833f, 0.01887958f, 0.02131255f, -0.03434087f, 
    -0.03859694f, -0.02384892f, 0.00670496f, 0.02489207f, -0.01861578f, -0.04047580f, -0.04031220f, 0.01253719f, 
    0.00102763f, -0.03103199f, -0.01393789f, 0.02424580f, 0.00418632f, 0.00903331f, -0.02865473f, -0.03747701f, 
    0.00630081f, -0.00417070f, -0.04311367f, 0.00944581f, -0.00907738f, -0.01321264f, 0.00546989f, 0.02187984f, 
    -0.00784182f, 0.01107621f, -0.00059267f, -0.00931137f, 0.02049340f, -0.02527547f, -0.02856002f, -0.02841937f, 
    -0.04106477f, -0.02273370f, -0.00417551f, 0.01611086f, -0.01128430f, -0.01883732f, -0.01901323f, -0.02266466f, 
    -0.00447685f, -0.00005087f, -0.00481936f, -0.03752509f, 0.01921242f, -0.02425884f, -0.03584585f, -0.02371923f, 
    -0.01230156f, -0.01854446f, -0.02304673f, -0.02960426f, 0.02146337f, 0.01532150f, 0.02052761f, -0.01282127f, 
    -0.00630568f, -0.02803200f, 0.00043559f, -0.00201987f, -0.00959512f, -0.01999532f, 0.02925715f, -0.00490270f, 
    -0.00464198f, 0.02145142f, 0.01164980f, 0.01635339f, -0.02381682f, -0.02561343f, 0.00572237f, 0.01232103f, 
    0.02196290f, 0.01735460f, -0.02487106f, 0.01270471f, -0.02902475f, -0.00470284f, 0.01882838f, -0.04316819f, 
    -0.00080023f, 0.00893873f, -0.02714861f, 0.00027417f, -0.01488510f, 0.02387406f, 0.02644659f, 0.00745396f, 
    -0.02497155f, -0.03814219f, 0.00901185f, -0.04401792f, -0.02301790f, -0.03484614f, 0.00280576f, 0.02057938f, 
    0.00537559f, -0.00550939f, -0.03076473f, -0.01643160f, 0.00442940f, 0.01369664f, -0.03629790f, 0.01491417f, 
    -0.00152925f, -0.02121338f, 0.01767507f, -0.02147779f, 0.02990255f, -0.02392330f, -0.00493901f, -0.04167437f, 
    -0.00256450f, 0.02298685f, -0.02965427f, -0.01844932f, -0.01010203f, -0.00566809f, -0.03439227f, 0.02193746f, 
    0.02513440f, 0.02293404f, 0.02139309f, 0.02622851f, -0.02580633f, -0.03590659f, -0.00302681f, 0.01509308f, 
    -0.00107488f, -0.01893016f, -0.03617192f, -0.02061894f, -0.03400888f, -0.02046952f, 0.00130308f, -0.01963937f, 
    -0.02112215f, 0.01390403f, 0.00023864f, 0.01180811f, -0.02570064f, -0.03717159f, -0.02438097f, 0.00719506f, 
    -0.04441835f, -0.03240811f, -0.03781199f, -0.01830157f, -0.02294964f, -0.00827807f, -0.02669013f, -0.04468172f, 
    -0.03777512f, -0.03571748f, -0.01316537f, -0.04258242f, -0.01299427f, -0.01193786f, -0.01896924f, 0.00520974f, 
    0.01999382f, -0.03076795f, 0.01809805f, -0.01185161f, -0.04335925f, 0.01803953f, 0.00717937f, -0.04369908f, 
    -0.01629847f, 0.02335489f, -0.03132964f, 0.01775909f, 0.01650645f, 0.02126319f, 0.00038242f, -0.01039143f, 
    0.01346710f, -0.00892419f, 0.00692015f, 0.00253490f, -0.00285337f, -0.03779427f, 0.02821261f, -0.01634395f, 
    0.00814595f, 0.00346798f, -0.03696354f, -0.04155365f, 0.01157009f, -0.02644246f, -0.00931594f, 0.01349512f, 
    -0.01947876f, -0.02372707f, 0.02813433f, 0.01763069f, 0.00476248f, 0.01445517f, -0.03540272f, -0.01304852f, 
    -0.02349607f, 0.02295327f, -0.00835739f, -0.00504110f, 0.01087955f, 0.00818580f, -0.03694672f, 0.02465357f, 
    0.01773447f, 0.01039260f, -0.03810697f, -0.01671207f, -0.01165792f, 0.01664599f, -0.04079285f, -0.00777325f, 
    -0.03922157f, 0.01946854f, -0.02262430f, 0.00769451f, -0.02020610f, 0.02156957f, -0.03471716f, 0.01200573f, 
    0.00659207f, 0.00081572f, 0.01090620f, 0.00403978f, -0.00794192f, -0.02289194f, -0.03940025f, -0.03465132f, 
    -0.01392997f, -0.00850936f, 0.01416846f, -0.00974525f, 0.02211388f, -0.02684751f, 0.02150255f, 0.01283796f, 
    -0.02781561f, 0.01488380f, 0.02325392f, 0.00542969f, -0.03738108f, -0.04344905f, 0.01445681f, -0.01595491f, 
    0.02949786f, -0.01836195f, -0.02863712f, -0.00517086f, 0.00288136f, -0.00417984f, -0.00298632f, -0.02468357f, 
    0.00232896f, 0.00980933f, -0.00863415f, 0.02301850f, -0.01747460f, -0.02107235f, -0.00452609f, -0.02182327f, 
    -0.00124891f, -0.03202283f, -0.00673195f, 0.00994427f, 0.00511292f, -0.03891018f, -0.00484295f, -0.03077092f, 
    -0.02984200f, 0.01705674f, 0.02512451f, -0.00758713f, 0.00330165f, 0.02191195f, -0.00288534f, 0.00639004f, 
    -0.03234036f, -0.00570936f, -0.00384675f, -0.01616183f, -0.01795764f, -0.00380392f, -0.01714549f, 0.02651645f, 
    0.00977890f, 0.01210809f, -0.02823184f, -0.01617406f, 0.01558886f, -0.02592953f, -0.03865278f, 0.02537180f, 
    -0.04015025f, -0.01807025f, -0.03917186f, 0.00126534f, -0.02098554f, -0.02519362f, 0.00602252f, 0.01595877f, 
    0.00037054f, 0.01982644f, 0.02380031f, -0.00706901f, -0.03189802f, -0.03608019f, -0.02013334f, -0.03419866f, 
    -0.00144747f, 0.02183752f, -0.00191527f, -0.02379594f, 0.01047250f, 0.02692834f, -0.04071903f, 0.00797245f, 
    -0.00351623f, -0.03368974f, -0.00634021f, 0.00418558f, -0.04134803f, 0.01891150f, -0.03833204f, -0.01749306f, 
    -0.03066158f, 0.00026934f, 0.02530455f, -0.00849973f, 0.01500759f, -0.01060574f, -0.03491604f, 0.01959299f, 
    -0.00807520f, -0.00439477f, -0.02591991f, 0.00795547f, -0.00800074f, -0.03921559f, -0.03433114f, 0.00977016f, 
    -0.01687370f, -0.00789945f, -0.00172497f, -0.03346569f, 0.00796755f, -0.03662745f, -0.04276722f, -0.03823326f, 
    -0.01243440f, -0.01300486f, -0.00713545f, -0.00566167f, -0.02842521f, 0.01102651f, -0.01244227f, 0.00810177f, 
    -0.01772756f, -0.01159058f, -0.00002480f, 0.01285021f, 0.01247967f, 0.00490989f, 0.00317850f, -0.00197193f, 
    0.00618643f, -0.03971348f, -0.04484617f, -0.03492586f, 0.00743629f, 0.01809950f, -0.02512320f, 0.00232689f, 
    0.02034708f, -0.00055964f, -0.02471039f, 0.01707814f, 0.01028147f, -0.00730683f, 0.00078722f, -0.02815103f, 
    0.00105857f, -0.02253277f, 0.00481838f, 0.01230625f, 0.01475226f, -0.00389031f, -0.02246130f, 0.01058740f, 
    -0.00304498f, -0.01884256f, -0.01781818f, -0.02978675f, -0.03188621f, -0.01621582f, 0.00968580f, -0.03641779f, 
    -0.01105151f, -0.03376919f, 0.00049284f, -0.02953933f, -0.00640255f, 0.00384577f, 0.02366673f, -0.01098469f, 
    0.01414181f, 0.05133141f, 0.11271916f, -0.28219303f, 0.04805150f, 0.13222682f, -0.07694367f, -0.05789405f, 
    0.11898530f, -0.25655764f, -0.00876235f, 0.15009093f, 0.14360884f, -0.01496630f, -0.16587517f, 0.01709863f, 
    -0.07090221f, -0.05981515f, -0.09286255f, 0.07878196f, -0.05453353f, 0.09366370f, 0.05083694f, -0.08255854f, 
    -0.07527836f, 0.17481820f, -0.02981141f, -0.11665970f, -0.10526249f, 0.07729019f, -0.09124768f, -0.14953685f, 
    -0.01053440f, -0.21922569f, 0.07864662f, 0.04846135f, 0.02944538f, 0.03463382f, -0.05295590f, -0.02994118f, 
    -0.11869380f, -0.06052576f, 0.10053363f, -0.20330206f, -0.06920094f, 0.14948249f, 0.00588052f, 0.06856815f, 
    0.06243701f, -0.04202517f, -0.35077903f, 0.11895458f, -0.02642193f, 0.00198550f, -0.12744842f, 0.01720290f, 
    -0.08006909f, 0.01030454f, 0.04993010f, 0.00257906f, 0.18780677f, -0.12961233f, 0.11680666f, -0.28883949f, 
    -0.03215151f, -0.01512393f, 0.01598623f, 0.11265524f, 0.02533339f, 0.05993532f, -0.13408054f, -0.00608453f, 
    -0.02568828f, 0.07699165f, -0.10638510f, 0.13436441f, 0.02852567f, 0.18006158f, -0.01781386f, 0.04804077f, 
    0.14234541f, 0.17541862f, 0.03829812f, 0.22173648f, -0.04120352f, 0.16456252f, 0.09754300f, 0.28047547f, 
    -0.02067600f, -0.00858488f, 0.10986751f, 0.14175029f, -0.01025944f, -0.07816183f, 0.11425219f, 0.01507175f, 
    0.05607319f, -0.05148360f, -0.12978122f, 0.03113584f, 0.02357494f, -0.00228149f, 0.05944701f, 0.01852047f, 
    0.08489965f, 0.01325391f, -0.01453421f, -0.18879345f, 0.24157521f, 0.08705188f, -0.10084169f, 0.30278608f, 
    -0.02411915f, -0.04364347f, -0.05063275f, -0.02093971f, 0.07005805f, 0.15408257f, -0.02573177f, 0.11899253f, 
    -0.05428383f, -0.06509948f, 0.17065214f, 0.01934586f, 0.03888196f, -0.05488563f, 0.06485921f, -0.01403312f, 
    -0.09900893f, 0.01695995f, 0.15333708f, 0.06258654f, 0.08134107f, 0.06812509f, -0.05448326f, 0.08158252f, 
    0.10816108f, -0.05531877f, -0.09916062f, 0.10593139f, -0.10506824f, 0.18787539f, 0.21679330f, 0.00445311f, 
    -0.08843017f, -0.08509161f, 0.04541279f, -0.10388734f, 0.00394205f, -0.07981008f, 0.01441601f, 0.13424179f, 
    0.01876756f, 0.14456977f, 0.06790344f, 0.03778729f, 0.08495937f, 0.29217827f, -0.17625675f, 0.00093015f, 
    0.01669990f, -0.10347972f, -0.02985470f, 0.03923631f, -0.27240366f, -0.13944890f, -0.00158252f, -0.03817584f, 
    0.51676977f, -0.00744539f, 0.10070987f, -0.20657198f, -0.01759124f, -0.03415198f, -0.15263626f, -0.01796907f, 
    0.10942575f, 0.01371056f, -0.08196826f, 0.20494826f, 0.14058399f, 0.08579682f, -0.08786049f, 0.05277775f, 
    0.00995409f, -0.00421318f, 0.12575990f, 0.22503330f, 0.15904868f, -0.10648651f, 0.14172776f, -0.07777172f, 
    -0.18605459f, -0.25744179f, 0.05451170f, 0.08594636f, -0.05136390f, 0.01759082f, -0.00678355f, 0.09198359f, 
    -0.01418595f, -0.07534350f, -0.01048628f, -0.03661569f, 0.09384349f, -0.14614742f, 0.09621437f, -0.24898645f, 
    -0.01396252f, 0.07428165f, 0.01718760f, 0.06473891f, 0.07432051f, 0.05406952f, 0.12168797f, -0.36832067f, 
    -0.15628739f, 0.43935177f, 0.04959133f, -0.14321490f, 0.01981693f, -0.12967946f, -0.11451277f, -0.05050227f, 
    -0.00955194f, 0.01980565f, -0.00114201f, 0.07379968f, 0.08158367f, -0.28430447f, 0.07352676f, -0.29269943f, 
    0.13949651f, 0.05653888f, 0.06378454f, 0.15459223f, -0.02733052f, 0.03567864f, 0.04508795f, 0.04509290f, 
    0.05218934f, 0.01210269f, -0.06209419f, 0.08172611f, -0.09392457f, -0.03589609f, -0.00030012f, -0.07578129f, 
    0.01727555f, -0.13750036f, -0.01994054f, -0.06198702f, -0.06593393f, -0.16208629f, -0.15040661f, -0.11482872f, 
    -0.12662119f, -0.03174758f, -0.16548371f, 0.10818502f, 0.12850951f, 0.08100183f, 0.13445376f, 0.05238478f, 
    0.20948356f, 0.09714223f, -0.02515837f, -0.04727275f, -0.00416708f, -0.09968147f, 0.00830165f, 0.00209502f, 
    0.00355307f, 0.12696503f, -0.03411292f, 0.02797942f, 0.11306453f, -0.12518577f, 0.09613716f, -0.18817277f, 
    0.00042509f, 0.08004157f, 0.16995572f, 0.13212521f, 0.06264245f, -0.10164526f, 0.13649352f, -0.03369790f, 
    0.06951123f, 0.16268580f, -0.05969679f, 0.22604360f, 0.02078752f, -0.07777169f, 0.01657085f, -0.09068081f, 
    0.06735034f, -0.18464272f, -0.12270907f, -0.07389461f, 0.14085823f, -0.36622608f, -0.05675755f, 0.15502849f, 
    0.01237047f, -0.17990342f, -0.01675413f, 0.04545979f, 0.01950999f, -0.01478858f, -0.14271070f, 0.16423784f, 
    0.07779890f, -0.19489712f, 0.36038494f, -0.18807811f, -0.02052257f, -0.23678578f, 0.09565034f, 0.01044345f, 
    0.07374907f, 0.06002510f, 0.00642018f, 0.10394968f, 0.36966985f, -0.10276216f, -0.12556495f, -0.11244633f, 
    -0.00607483f, 0.03904641f, -0.03169979f, 0.09759948f, 0.07324950f, -0.05978758f, 0.01351162f, -0.21094096f, 
    -0.22236104f, -0.13017070f, -0.15810201f, -0.11765665f, -0.19642287f, -0.02828162f, 0.04914945f, 0.00967936f, 
    -0.07684940f, 0.09415982f, 0.15209115f, -0.02382441f, 0.16355924f, 0.11675841f, -0.04150357f, 0.15022801f, 
    -0.12128315f, 0.08677529f, -0.02006885f, 0.12370258f, 0.09955085f, 0.15083395f, -0.14798889f, -0.08634748f, 
    0.13267592f, -0.21497187f, -0.13402846f, 0.20829234f, -0.05519366f, 0.19337738f, 0.19834551f, -0.02690200f, 
    0.08988551f, 0.06878947f, 0.16250175f, 0.13131714f, 0.19487052f, 0.06430487f, -0.15370688f, 0.17419781f, 
    -0.06354158f, -0.03359997f, -0.00542923f, -0.05749403f, -0.04463050f, 0.02999683f, 0.04058243f, 0.21071172f, 
    -0.11009564f, -0.01495334f, 0.11241917f, -0.30647704f, -0.00013953f, 0.07514956f, 0.02467946f, -0.03938135f, 
    0.07907864f, -0.04228237f, -0.12883896f, 0.12964226f, -0.03023423f, 0.11630185f, -0.08806158f, -0.11795892f, 
    -0.07130284f, 0.00963128f, -0.02765541f, -0.02737287f, 0.11347221f, 0.00773562f, 0.15934196f, -0.30429110f, 
    -0.16873047f, 0.30140865f, -0.03960216f, -0.12747373f, 0.07860567f, 0.20297931f, -0.21082808f, 0.09864851f, 
    0.06158647f, -0.15465730f, -0.09268271f, -0.08385007f, -0.01868831f, 0.19823499f, 0.05468552f, 0.05743373f, 
    -0.07718613f, -0.01372405f, -0.06581615f, -0.03400754f, -0.11264291f, -0.15266013f, -0.11464912f, -0.15761016f, 
    -0.03682792f, 0.13904096f, 0.02440020f, 0.03044691f, 0.12801215f, -0.04352080f, -0.00181986f, -0.28002697f, 
    0.01172038f, 0.04000159f, 0.01288649f, 0.14993057f, -0.13250765f, -0.19597344f, 0.01473018f, -0.08053328f, 
    0.01689522f, -0.00738720f, -0.00527820f, 0.12939368f, -0.04423548f, 0.09661483f, -0.04120132f, 0.08609311f, 
    -0.27948356f, 0.17157447f, 0.18228465f, 0.36141267f, -0.08242404f, -0.01303481f, 0.14810100f, -0.07899025f, 
    0.01324709f, 0.16526990f, -0.11583735f, -0.19968320f, -0.00168233f, -0.01983347f, -0.13834761f, 0.19709541f, 
    -0.11143558f, -0.09452011f, -0.07968231f, -0.04288321f, 0.07163315f, 0.01117573f, 0.16008018f, -0.10249973f, 
    0.52775389f, 0.04026219f, -0.07516211f, -0.04134970f, -0.04802252f, 0.11505318f, -0.07200026f, 0.09783067f, 
    -0.02507919f, 0.10696470f, -0.11418843f, 0.15909141f, 0.01745601f, -0.12310828f, 0.01380612f, -0.29208073f, 
    0.08134343f, 0.00364521f, 0.15831153f, -0.05420583f, -0.06515811f, -0.00082050f, -0.15788245f, 0.18881175f, 
    0.13520469f, 0.10907368f, -0.13578707f, -0.21803616f, -0.02496939f, -0.20113097f, -0.17525418f, -0.02476430f, 
    -0.04869463f, 0.09489503f, 0.02886717f, -0.21519621f, 0.05507930f, -0.01702501f, -0.09586149f, -0.12196071f, 
    0.03727035f, -0.00124719f, -0.03526350f, -0.05396742f, -0.11841719f, 0.00660011f, 0.02213333f, 0.00057860f, 
    -0.08370869f, 0.05471607f, 0.01651456f, -0.14434174f, -0.03530262f, 0.00162001f, 0.00492809f, -0.01466113f, 
    -0.10172503f, -0.00884289f, 0.15711653f, 0.14042369f, 0.17829360f, 0.17088634f, 0.08389286f, -0.23101467f, 
    -0.14775522f, 0.14893478f, 0.13164136f, 0.04558548f, -0.06212508f, 0.14685982f, 0.01243347f, 0.03690096f, 
    -0.02084813f, 0.02417678f, 0.02082830f, -0.20960987f, 0.21679838f, -0.13537213f, -0.04054282f, 0.11024927f, 
    0.10609248f, 0.01510589f, 0.09728876f, 0.02775380f, 0.42316908f, -0.22218643f, -0.12272542f, 0.33129525f, 
    -0.00511705f, 0.03581248f, 0.16649581f, -0.00572063f, -0.06362904f, -0.05250504f, -0.15420590f, 0.00160992f, 
    0.05429412f, -0.05729807f, -0.01414582f, -0.09001722f, 0.04304466f, -0.04146781f, -0.00265853f, 0.04313589f, 
    0.03697963f, 0.01360576f, -0.28535333f, -0.18393998f, 0.37527758f, -0.16852278f, -0.11703524f, -0.10687513f, 
    -0.08951039f, 0.11312506f, 0.04739460f, 0.02430817f, 0.04432658f, -0.02688487f, -0.07054424f, 0.03322759f, 
    0.52958632f, -0.00355620f, 0.12715857f, -0.12621380f, -0.05653857f, 0.08261424f, -0.19337796f, 0.14951608f, 
    -0.08785722f, -0.02631962f, 0.04223713f, 0.12647718f, 0.06213918f, -0.10990766f, 0.01923675f, -0.09580480f, 
    0.07149928f, -0.03024924f, 0.04834227f, 0.04649013f, 0.14328991f, 0.09115455f, -0.02569707f, 0.08001474f, 
    0.10329641f, 0.01787516f, -0.01714713f, -0.23597278f, 0.05956928f, 0.04245534f, -0.02131455f, -0.03227163f, 
    0.12349796f, 0.07433030f, 0.04784034f, 0.08769027f, 0.09822848f, 0.02380439f, 0.01128160f, -0.07678403f, 
    -0.15602334f, -0.09645846f, 0.07814378f, -0.05240930f, 0.22268017f, -0.12263649f, -0.01072285f, -0.19645420f, 
    0.19186886f, 0.12545301f, 0.07195393f, 0.12828620f, 0.00251515f, 0.01578741f, 0.09503669f, 0.12878138f, 
    0.01740482f, -0.15350041f, 0.01753744f, -0.16278349f, -0.00205082f, -0.25755855f, 0.11043829f, -0.16094524f, 
    0.00503255f, 0.10496502f, 0.05431104f, 0.06829961f, 0.07343321f, 0.16262995f, 0.08601952f, 0.03027784f, 
    0.10156517f, 0.07929190f, -0.15594681f, -0.06057021f, -0.09821388f, 0.03878707f, -0.13632649f, 0.12869626f, 
    -0.10324279f, -0.00678712f, 0.00559618f, -0.05678865f, 0.32391497f, 0.11287546f, -0.04384070f, -0.16385256f, 
    -0.08612213f, -0.04879165f, 0.08275146f, 0.22410315f, 0.08210102f, -0.00900668f, 0.07239799f, 0.13262112f, 
    0.10122085f, -0.06917166f, 0.07698581f, 0.28338212f, 0.02727044f, -0.06074679f, 0.06291532f, -0.02322310f, 
    0.00812359f, -0.05034146f, 0.04850687f, -0.11466017f, -0.10652062f, 0.14794324f, -0.13284722f, -0.03236452f, 
    0.11413973f, 0.04813753f, 0.01117187f, -0.05700164f, -0.15639338f, -0.08148258f, -0.00990608f, 0.01400363f, 
    0.14438324f, 0.07831095f, 0.00641784f, 0.14548181f, -0.09109783f, -0.02763675f, -0.03472273f, 0.08536741f, 
    -0.06250177f, 0.15917535f, 0.00091344f, -0.10674779f, -0.12705801f, 0.04090568f, 0.23499331f, -0.46189639f, 
    -0.10505491f, -0.00500974f, 0.16087709f, 0.17356144f, 0.17067547f, 0.10847436f, -0.04093340f, -0.04996983f, 
    0.03932037f, -0.15536021f, 0.22642644f, -0.33426407f, -0.06948196f, 0.16073124f, 0.01503482f, 0.12964541f, 
    -0.13574593f, 0.17849600f, 0.08296566f, -0.04741987f, -0.17401023f, 0.17676361f, -0.02672813f, 0.38176289f, 
    -0.04240778f, 0.14962290f, -0.04652292f, 0.02726110f, 0.04219326f, -0.11069305f, -0.08392899f, 0.18093385f, 
    -0.03735305f, -0.03130315f, -0.00380792f, -0.03388897f, 0.01778637f, -0.02274292f, 0.00059397f, 0.01460435f, 
    0.03519064f, 0.02458439f, 0.02803017f, -0.01126326f, -0.03656272f, 0.03361531f, 0.01435625f, -0.01792682f, 
    -0.00473822f, -0.00064343f, 0.02760988f, -0.01731970f, -0.03728103f, -0.01796878f, -0.00078380f, 0.00647273f, 
    0.01819893f, -0.04308471f, 0.01651852f, 0.02626463f, 0.00394496f, -0.03705439f, -0.04305181f, -0.03990676f, 
    0.03164912f, -0.02263538f, 0.00336096f, -0.01590754f, 0.01103689f, -0.02821814f, 0.01389860f, -0.01776633f, 
    -0.02430005f, -0.00142798f, -0.01932890f, 0.00221279f, 0.00495919f, -0.00595495f, 0.01321350f, 0.00574374f, 
    -0.02761789f, -0.03439498f, -0.02112924f, 0.02888258f, -0.00311296f, 0.03297455f, -0.03160368f, -0.03019868f, 
    -0.00780573f, -0.03206491f, -0.02433641f, -0.03774292f, 0.00526373f, -0.01118502f, -0.03088648f, -0.00538944f, 
    -0.02308642f, 0.01643935f, -0.03216389f, -0.03437429f, 0.01203310f, 0.01410920f, -0.01857188f, 0.02232689f, 
    -0.03145422f, -0.00613265f, -0.01619693f, -0.02977258f, -0.00883833f, -0.00499321f, -0.03731848f, -0.00604534f, 
    -0.03514514f, -0.02474566f, -0.00425684f, 0.02056120f, -0.02807339f, 0.00558951f, -0.00307768f, 0.01590463f, 
    -0.01703833f, -0.02637447f, -0.02703046f, 0.02774778f, -0.00950361f, -0.01705652f, 0.01566721f, -0.02080832f, 
    -0.01144176f, -0.02944894f, 0.02850084f, 0.00319310f, -0.04241863f, -0.02909620f, 0.01070499f, -0.01358187f, 
    0.01607711f, -0.03604660f, 0.01600384f, 0.01560684f, 0.00080557f, 0.02039745f, 0.00909959f, -0.03488689f, 
    -0.00981965f, 0.00497697f, -0.03378890f, -0.00141640f, -0.01983405f, 0.01356174f, -0.01686964f, 0.02188252f, 
    0.01861171f, -0.00772545f, 0.00638551f, 0.00606593f, -0.03946619f, 0.00148659f, 0.01230743f, -0.04290558f, 
    -0.01088472f, -0.01054052f, -0.00210693f, 0.00336313f, -0.04131437f, -0.03592581f, -0.01778077f, 0.02712837f, 
    -0.02042336f, -0.01038421f, -0.03063229f, -0.04337096f, 0.01421759f, -0.04343481f, -0.02326178f, -0.02291051f, 
    -0.00362962f, 0.00581763f, 0.00512118f, -0.00755692f, 0.02032757f, 0.02474404f, 0.02191990f, -0.01996377f, 
    -0.00397395f, -0.01111766f, -0.02763999f, 0.02550786f, -0.03393462f, -0.02142566f, -0.00243090f, 0.00455110f, 
    -0.00788555f, 0.01301673f, 0.00623681f, -0.00356615f, 0.01141729f, 0.00830784f, 0.02109711f, -0.02111369f, 
    0.00118978f, -0.03153933f, 0.00153907f, 0.00418701f, 0.00789714f, -0.03465667f, 0.02343507f, 0.00373647f, 
    0.01334811f, -0.01261175f, 0.01026165f, -0.02995007f, 0.02089292f, 0.00540699f, -0.03933916f, -0.02329565f, 
    -0.02895709f, -0.00043332f, 0.01481618f, -0.00700871f, -0.01212434f, 0.00568804f, -0.04351284f, -0.03306569f, 
    -0.02126402f, -0.02813338f, -0.03465376f, -0.03451354f, 0.00564737f, 0.01752870f, -0.00622604f, -0.02111365f, 
    -0.03785601f, -0.00560465f, -0.00098702f, -0.04186290f, 0.02623509f, -0.01427208f, -0.02097762f, -0.00809115f, 
    -0.01537153f, 0.01278322f, -0.02765643f, 0.02595754f, -0.04409178f, -0.02675757f, -0.03806105f, -0.00850715f, 
    -0.00934772f, -0.03584160f, -0.00644905f, 0.02630225f, 0.02075860f, 0.02530040f, 0.01614811f, -0.00807155f, 
    -0.04023749f, -0.03156706f, -0.01226744f, -0.01247394f, 0.01372171f, 0.00937241f, 0.02339805f, -0.02214129f, 
    0.03029663f, -0.00259886f, 0.02577025f, -0.01005876f, 0.00759187f, -0.01690851f, 0.01727698f, 0.02579122f, 
    -0.03668154f, -0.01149842f, 0.02610178f, -0.02203702f, 0.01175772f, -0.00368212f, -0.02815004f, 0.02551317f, 
    0.02382509f, 0.00539345f, 0.01990884f, 0.01641902f, 0.01203477f, -0.04065387f, -0.01858804f, 0.00892065f, 
    0.01452781f, -0.02529477f, 0.02948716f, -0.00192471f, -0.02443160f, -0.00926345f, -0.04125283f, -0.04409535f, 
    -0.00621820f, -0.00292546f, -0.01286529f, 0.02623301f, -0.01260118f, 0.02118675f, -0.02067053f, -0.03516330f, 
    -0.01190685f, 0.01649164f, -0.00266965f, -0.03860500f, -0.02937705f, 0.00679224f, 0.02446043f, -0.00993598f, 
    -0.01977739f, -0.02313787f, 0.01236966f, 0.00514284f, 0.00547026f, 0.00939295f, -0.04430284f, -0.04110431f, 
    0.00230357f, 0.01235849f, 0.03044665f, 0.01623003f, -0.03472259f, -0.03965287f, 0.01294867f, -0.03850796f, 
    -0.01734107f, -0.01217115f, -0.00235436f, -0.01803521f, -0.03233910f, -0.00159782f, -0.03414838f, 0.01903265f, 
    -0.01259349f, -0.01120201f, -0.03641907f, -0.02572098f, -0.01785896f, 0.02511208f, 0.01183004f, 0.00542423f, 
    0.01054463f, 0.01501435f, -0.00884719f, 0.00801214f, -0.02670249f, 0.02046954f, 0.02190898f, -0.02610878f, 
    0.02728822f, 0.02695893f, 0.01213965f, -0.00404032f, -0.04141377f, -0.01436356f, 0.01410933f, -0.01016554f, 
    -0.00535853f, 0.02126793f, 0.01053176f, 0.02138148f, 0.00683244f, -0.01656199f, 0.01715775f, -0.03219593f, 
    0.01342545f, -0.02169204f, -0.03236127f, 0.02289355f, 0.01318036f, 0.02851756f, 0.02232349f, 0.01909195f, 
    -0.00963498f, 0.02629251f, -0.02415456f, 0.01357804f, -0.03157046f, -0.01728154f, 0.01468626f, -0.03879431f, 
    -0.02534462f, 0.01371574f, -0.00218944f, -0.03029682f, 0.00067694f, 0.01646028f, 0.00907625f, -0.02781763f, 
    -0.02755173f, 0.02382775f, -0.03612559f, -0.02828446f, 0.01087285f, -0.03684808f, -0.01525904f, -0.03989252f, 
    0.00027826f, -0.00052889f, 0.01770157f, 0.01601585f, -0.01463395f, 0.01436189f, 0.02529111f, 0.02638562f, 
    -0.03861910f, -0.01476287f, -0.01368176f, 0.00263277f, 0.00240909f, -0.00101107f, 0.01284719f, 0.01787137f, 
    0.01440436f, -0.02977996f, 0.01608502f, -0.03400167f, -0.02375961f, -0.00095165f, 0.00635536f, -0.00044893f, 
    -0.00894091f, -0.01205978f, -0.00990490f, 0.02775897f, -0.02393075f, -0.01855281f, -0.01490541f, -0.03396759f, 
    -0.01330815f, 0.01865097f, 0.02596541f, 0.02407450f, 0.02645726f, -0.03394840f, -0.03995238f, -0.03337732f, 
    0.02962451f, -0.03904718f, -0.00901790f, -0.00487654f, -0.01211957f, 0.01233174f, -0.00711135f, -0.00972498f, 
    0.00181676f, 0.02149254f, 0.01008242f, -0.02172915f, -0.01843753f, -0.02008765f, -0.04180041f, 0.00219402f, 
    0.02818943f, -0.00166821f, 0.01373203f, -0.00801200f, 0.00207048f, 0.01704947f, -0.04395561f, -0.02869433f, 
    -0.02867167f, 0.02276505f, -0.00076871f, -0.04323317f, -0.04351469f, 0.01204486f, 0.01776164f, 0.01141913f, 
    -0.00864813f, -0.00616225f, -0.03479262f, 0.00179575f, -0.00206278f, -0.02603362f, 0.02769166f, 0.00900837f, 
    0.00543768f, -0.01578235f, -0.03013140f, -0.01095573f, 0.02718679f, -0.00348658f, 0.02120936f, 0.01590333f, 
    -0.02361900f, 0.00305502f, 0.02731651f, -0.00719106f, 0.02577360f, -0.02037971f, -0.01285786f, -0.01998276f, 
    0.00102457f, 0.01368009f, -0.00097078f, -0.04339220f, 0.01824885f, 0.00458111f, -0.01600550f, 0.02634930f, 
    0.00643042f, -0.03074415f, 0.00092927f, 0.01096193f, 0.01204594f, -0.02608407f, -0.02914606f, -0.02950546f, 
    0.02035556f, -0.03164579f, -0.03269983f, 0.02834878f, -0.03184791f, 0.01354573f, 0.00211157f, -0.03805042f, 
    -0.00108784f, 0.03168017f, -0.03207994f, 0.00826639f, 0.03466091f, 0.00592180f, 0.00673490f, -0.00303076f, 
    0.00421033f, -0.00181946f, 0.01115078f, 0.01846749f, -0.03263266f, 0.01133247f, -0.00754673f, -0.01299450f, 
    -0.03102615f, 0.00988587f, -0.00974916f, -0.01652685f, -0.01124658f, -0.00315003f, -0.02129961f, -0.00609501f, 
    0.01756331f, 0.01275174f, 0.02999219f, 0.00126965f, -0.01875019f, -0.01699277f, 0.01775652f, -0.01604448f, 
    -0.01767150f, -0.00728651f, -0.04106240f, 0.02656623f, -0.02050906f, -0.02206803f, -0.03735503f, 0.00336037f, 
    0.02280405f, 0.01109095f, -0.01133574f, 0.01914197f, -0.02696074f, -0.00177234f, 0.02093860f, 0.00206089f, 
    0.02928230f, 0.01049342f, -0.02851101f, -0.03863941f, 0.02418787f, -0.02907099f, -0.00104025f, -0.01262387f, 
    -0.03435116f, -0.02142118f, -0.02799978f, 0.00172036f, 0.00074195f, -0.00973277f, -0.01113074f, -0.00134761f, 
    -0.02082380f, 0.01262378f, -0.04004677f, 0.02157002f, -0.02986017f, 0.02605692f, -0.00506485f, -0.00311605f, 
    0.02187811f, -0.00024706f, -0.03794344f, 0.00445766f, 0.00382654f, -0.01655225f, -0.02259207f, 0.02506706f, 
    0.02677893f, 0.02139107f, -0.00329037f, 0.03027504f, 0.00255002f, -0.00015757f, -0.02859089f, -0.03395637f, 
    0.02299071f, 0.01051566f, -0.03831763f, 0.03020093f, 0.02343618f, 0.00427020f, 0.02059741f, 0.00419798f, 
    0.00568656f, 0.02539877f, -0.04028973f, 0.00540267f, -0.00278633f, 0.01657688f, -0.00165032f, 0.02363768f, 
    0.01686874f, -0.01483828f, -0.00151617f, -0.03357951f, 0.00211219f, -0.02264941f, 0.01199402f, -0.02196418f, 
    -0.00849941f, -0.00459551f, -0.03522761f, -0.03119546f, -0.01863161f, 0.00813823f, 0.02504033f, 0.00324732f, 
    0.01612258f, -0.02157345f, 0.00925410f, 0.00815878f, -0.00126096f, 0.01089094f, 0.01434837f, -0.02630686f, 
    0.01986697f, 0.02082945f, 0.00927160f, 0.02680990f, -0.00774691f, 0.00197954f, -0.01253137f, -0.01259766f, 
    -0.02381609f, -0.00262260f, -0.03598179f, -0.02229159f, 0.02586774f, -0.03579365f, -0.04336660f, -0.03808231f, 
    -0.00832917f, 0.02099966f, -0.04136471f, 0.00041514f, -0.02027536f, -0.01751222f, -0.03609801f, -0.03230326f, 
    0.01601031f, -0.01494498f, -0.03200274f, -0.01022953f, -0.00708798f, -0.02142133f, -0.03303019f, 0.02587071f, 
    0.00401675f, -0.00218752f, 0.00517609f, -0.00092953f, 0.00474608f, -0.04401071f, 0.00972601f, -0.02196236f, 
    -0.02795205f, 0.00336943f, -0.02343607f, -0.00045469f, -0.02638861f, -0.00398414f, -0.00112728f, -0.00360282f, 
    -0.02697402f, -0.01975542f, -0.00164423f, 0.00627616f, -0.01326057f, -0.01643517f, -0.03403619f, 0.00619017f, 
    0.00224483f, 0.01253974f, -0.03294035f, -0.01978450f, -0.01232877f, 0.03229969f, -0.00622727f, -0.02125547f, 
    -0.02423017f, -0.00527587f, -0.00579263f, -0.03792314f, -0.00532919f, 0.00120789f, 0.00121766f, 0.03001370f, 
    -0.04148950f, -0.02041532f, -0.00744996f, -0.02545439f, -0.01342904f, -0.02296820f, 0.01364710f, -0.00773645f, 
    0.00754237f, -0.01645220f, 0.03780248f, -0.02934229f, -0.03147523f, -0.01260017f, 0.00012193f, 0.01753089f, 
    -0.02352635f, -0.00813971f, -0.04341822f, -0.03970342f, 0.02257622f, -0.01080395f, -0.01297856f, -0.01311589f, 
    -0.03529993f, -0.02321365f, 0.02174773f, -0.03737221f, 0.00769488f, 0.02519214f, 0.02762218f, -0.02113767f, 
    -0.01906863f, 0.02771694f, -0.00009089f, -0.00957249f, -0.03267299f, -0.01323098f, 0.02713978f, -0.01411689f, 
    -0.00574611f, 0.00367388f, 0.01872107f, -0.02677552f, -0.02719388f, -0.01188468f, -0.02315493f, -0.02210827f, 
    -0.00647979f, -0.02032527f, 0.01876021f, -0.01713768f, -0.03849906f, -0.00100457f, -0.03021477f, -0.03071975f, 
    0.00282574f, 0.03055684f, -0.01428532f, -0.03052065f, 0.02747586f, -0.03853245f, -0.01704665f, -0.02103243f, 
    -0.01522509f, -0.02805094f, -0.00368688f, -0.01653812f, -0.03876159f, -0.04017050f, -0.01616876f, 0.00652186f, 
    -0.04245967f, -0.00900211f, -0.04446611f, -0.01355688f, 0.03132528f, -0.02531678f, -0.01407306f, 0.02603366f, 
    0.02621598f, -0.01609336f, 0.00114759f, -0.02466990f, -0.02012228f, 0.01445880f, -0.02526875f, -0.00077334f, 
    -0.02021448f, 0.02658496f, 0.02489197f, 0.01785024f, -0.02197063f, -0.01155998f, 0.02244347f, -0.02896305f, 
    0.01148153f, 0.00108423f, 0.02786746f, -0.02710509f, -0.03620687f, -0.01345055f, 0.00160508f, 0.02214779f, 
    -0.01852561f, -0.02881735f, 0.01422534f, -0.02964469f, -0.00445736f, 0.00386543f, -0.03817968f, -0.03019088f, 
    -0.01603115f, -0.01823106f, 0.00813140f, 0.01547172f, -0.00594141f, 0.00893301f, -0.00751107f, -0.00595653f, 
    -0.00573746f, -0.03458341f, 0.02377282f, 0.01460156f, 0.01736264f, 0.00119529f, 0.02711749f, -0.03810425f, 
    0.02729881f, 0.00905117f, 0.00257678f, -0.01419219f, -0.01973858f, 0.01973455f, -0.02263315f, 0.00474643f, 
    0.02051308f, 0.02889231f, -0.03594962f, 0.02421982f, 0.00017110f, 0.01182099f, -0.00010150f, -0.00040377f, 
    -0.00849034f, -0.00552543f, 0.00689095f, -0.01369561f, 0.00309655f, 0.00190676f, -0.02505395f, -0.03827242f, 
    -0.02241534f, -0.00421972f, 0.00001683f, 0.03533962f, 0.00869996f, 0.01978059f, -0.03934253f, -0.00236619f, 
    0.00401463f, 0.01515142f, -0.02593063f, 0.02410370f, -0.03105762f, 0.01135475f, -0.00839953f, 0.01269826f, 
    0.02703359f, 0.00392863f, 0.02138999f, 0.00903033f, -0.02555839f, 0.02354212f, 0.00770009f, -0.02476256f, 
    0.00303057f, 0.02123179f, 0.00700569f, -0.01969594f, 0.01541128f, 0.02692867f, -0.01304334f, 0.02875684f, 
    0.00768837f, -0.00913226f, -0.00961507f, 0.01486952f, -0.00173790f, 0.01434435f, 0.00866451f, -0.00403617f, 
    0.01064880f, -0.02883615f, -0.01747940f, -0.03370364f, -0.01017296f, -0.00517638f, -0.01298842f, -0.04014083f, 
    -0.00515944f, -0.03520632f, -0.03699262f, 0.01750278f, -0.01196241f, 0.03124397f, -0.01404931f, -0.03209877f, 
    -0.03539557f, 0.01272545f, 0.00815307f, -0.01824623f, -0.01707675f, -0.03413015f, 0.01928075f, -0.02565664f, 
    -0.02515599f, -0.04103382f, -0.02530923f, -0.00482140f, -0.00711341f, 0.02917734f, -0.01111712f, 0.02669184f, 
    -0.01225928f, 0.00170731f, -0.03427188f, 0.03418679f, 0.01999971f, 0.00114455f, 0.01832191f, -0.03062561f, 
    -0.01848403f, 0.00179746f, -0.00540105f, -0.03352194f, -0.02157293f, -0.01018275f, -0.02253701f, -0.02219999f, 
    -0.02643456f, 0.01383476f, -0.03287008f, -0.02585908f, 0.01521587f, -0.01723112f, 0.02554951f, 0.02663447f, 
    -0.03372775f, -0.02500589f, 0.01458755f, -0.03711740f, -0.01125165f, -0.00085465f, -0.03694334f, 0.00832047f, 
    0.02780781f, 0.00982200f, -0.01796254f, 0.01867474f, -0.00037236f, -0.00167080f, -0.03106568f, -0.01566711f, 
    -0.00683168f, -0.02947918f, 0.00133982f, 0.01461870f, -0.03870061f, 0.02606889f, -0.02150313f, 0.01889357f, 
    -0.02763505f, -0.04272496f, -0.00619566f, 0.02531146f, -0.01463782f, -0.02004692f, -0.00371135f, -0.01372009f, 
    0.00967637f, 0.02082371f, 0.00263693f, -0.00947085f, 0.02770381f, -0.03124574f, -0.00899005f, 0.01685315f, 
    -0.02384076f, -0.03730310f, -0.01871337f, -0.01237065f, 0.00270268f, 0.00051901f, 0.01322195f, 0.01480755f, 
    -0.02050634f, 0.01101360f, -0.02214630f, -0.00308202f, -0.01967162f, 0.03634116f, -0.02229189f, -0.03300521f, 
    0.01186418f, -0.01167555f, 0.02367022f, -0.00312268f, -0.00250726f, -0.02245970f, 0.02902813f, -0.02525312f, 
    -0.04032844f, 0.02033023f, 0.01797364f, 0.02951686f, 0.02122306f, 0.03444855f, -0.00762571f, 0.02496222f, 
    -0.01005886f, -0.03211084f, -0.03829067f, 0.01039542f, 0.01071528f, 0.01661945f, 0.00405954f, -0.01202856f, 
    -0.03828444f, 0.02918570f, -0.01789823f, -0.01495872f, 0.00270645f, -0.01115120f, -0.01286690f, 0.00106729f, 
    0.00045852f, -0.02700997f, 0.00796953f, 0.01551416f, -0.03347200f, -0.01779703f, 0.01971504f, 0.02642822f, 
    -0.03640226f, 0.01136318f, 0.00358289f, 0.00969755f, 0.01036218f, 0.00264539f, -0.01792495f, -0.00830811f, 
    -0.02570564f, -0.02371480f, -0.04198668f, -0.00265103f, -0.02248617f, 0.00377786f, -0.03717921f, -0.01533708f, 
    -0.02774693f, -0.02814076f, -0.02582487f, -0.01887613f, -0.02132458f, 0.00740551f, -0.01851056f, 0.03141887f, 
    -0.01033191f, 0.00514728f, 0.02755254f, 0.00497918f, 0.02388730f, 0.00278087f, 0.00922674f, -0.04240168f, 
    0.00854564f, -0.03713367f, 0.02254111f, -0.01625288f, 0.01059093f, 0.01801951f, 0.02489413f, -0.03347326f, 
    0.02297457f, 0.02845258f, 0.02614113f, -0.03111525f, -0.00468324f, 0.02837512f, -0.01480733f, 0.02480277f, 
    -0.00619879f, 0.02527825f, 0.03614209f, 0.02664145f, -0.02260390f, -0.02409347f, -0.01783134f, 0.01995003f, 
    0.00299265f, 0.01746508f, -0.01482525f, -0.01200242f, 0.01855747f, -0.00143461f, -0.03235207f, -0.00667345f, 
    -0.03911743f, -0.01155035f, 0.03214486f, 0.02200231f, -0.01218058f, 0.01794809f, 0.02435769f, 0.01894743f, 
    -0.02620854f, 0.02314600f, -0.00387225f, -0.01036153f, 0.00155091f, -0.02363496f, 0.01708691f, 0.00995995f, 
    0.02833059f, -0.02130887f, -0.03939540f, 0.01848175f, 0.01158717f, 0.00100015f, -0.03634232f, -0.03236835f, 
    -0.00505141f, 0.02018624f, -0.00253757f, -0.01105619f, -0.00336149f, -0.01911812f, 0.00946794f, -0.01344106f, 
    -0.03969038f, 0.00191438f, -0.01323903f, -0.00587901f, 0.00850085f, -0.00085234f, 0.02557078f, 0.00542373f, 
    0.00334842f, -0.02095069f, -0.02804096f, 0.03110720f, 0.02670723f, 0.02418819f, 0.00096691f, -0.02284965f, 
    0.01697439f, -0.02234239f, -0.03901801f, -0.00531707f, -0.02993307f, -0.01366153f, -0.03062149f, -0.03005939f, 
    -0.02854270f, 0.00919030f, -0.01585615f, -0.04036640f, 0.01470875f, 0.00669248f, -0.00523117f, 0.01683359f, 
    0.00923671f, -0.02071936f, -0.01777457f, 0.02633715f, -0.02363569f, 0.01819010f, -0.02002860f, 0.02234394f, 
    0.01904054f, -0.01292248f, -0.00940898f, 0.02467771f, -0.02142791f, -0.03020046f, -0.03762552f, 0.00810627f, 
    -0.02410213f, 0.00791913f, -0.01399689f, -0.01283882f, 0.01685599f, 0.02042756f, -0.00047150f, -0.00969993f, 
    0.00182024f, -0.00066056f, 0.01510208f, -0.03523812f, 0.02097484f, 0.00604216f, -0.00304619f, -0.03263095f, 
    -0.02201157f, -0.02673219f, 0.01273592f, -0.00893840f, 0.02682402f, -0.01585476f, 0.00727608f, -0.02015549f, 
    -0.01777574f, -0.00349843f, 0.01708791f, 0.01324732f, -0.00355134f, -0.02079576f, 0.00730678f, -0.03292428f, 
    0.00621852f, -0.00690675f, 0.02240371f, -0.01687327f, -0.02423687f, -0.03629556f, -0.01346997f, -0.02780735f, 
    -0.00632990f, -0.03692669f, -0.03063714f, -0.02014779f, -0.01752482f, 0.02184056f, 0.00378089f, 0.02592893f, 
    -0.01297741f, -0.00711647f, -0.02612618f, -0.00698856f, 0.00354366f, -0.04015712f, -0.00565293f, -0.02797459f, 
    0.00526661f, -0.01974582f, -0.01989570f, -0.01431171f, 0.00855177f, 0.03766583f, 0.01122643f, -0.01981509f, 
    -0.04038752f, -0.03480126f, 0.03035983f, 0.00436981f, -0.00261811f, -0.02173067f, -0.01846048f, -0.04322362f, 
    0.00455620f, -0.03935033f, 0.01634504f, -0.03059950f, 0.01619768f, -0.03134396f, -0.01828423f, -0.02795407f, 
    -0.00653581f, -0.03678253f, -0.02761191f, -0.02985404f, 0.02800125f, 0.00565697f, 0.01143357f, -0.00233647f, 
    -0.01347516f, 0.02944819f, 0.00094823f, 0.01021085f, 0.00602092f, 0.01626655f, 0.00975453f, 0.02451545f, 
    0.00425131f, 0.01634662f, 0.00735545f, -0.00073394f, -0.00802420f, 0.00573390f, -0.01750534f, -0.02359264f, 
    -0.00030914f, 0.02272452f, -0.01875976f, -0.00320436f, -0.00215778f, -0.01367401f, 0.03233780f, 0.00576132f, 
    -0.03983337f, 0.00399003f, 0.01729514f, -0.00158633f, -0.02082094f, -0.02229511f, -0.00063686f, -0.02977788f, 
    -0.02032751f, 0.01905492f, 0.01214787f, 0.00333145f, -0.01441915f, 0.01080861f, -0.01914386f, -0.02079665f, 
    0.00399056f, -0.00015547f, -0.01597786f, -0.02152774f, -0.00960320f, 0.00891084f, -0.03707701f, -0.03668295f, 
    -0.01312160f, 0.01159141f, -0.03110142f, -0.00647119f, 0.01684153f, 0.00535172f, 0.01412008f, -0.03147873f, 
    0.03032912f, -0.03880844f, 0.02643834f, -0.00900897f, 0.01490126f, -0.03060108f, 0.00033635f, -0.01114996f, 
    -0.03186284f, 0.02803317f, 0.02439735f, -0.00771991f, 0.01816454f, -0.03786551f, 0.02136770f, -0.03591196f, 
    0.01945979f, -0.03305503f, 0.00585605f, 0.01821334f, -0.02095375f, -0.02179532f, 0.00197544f, 0.00136761f, 
    0.00451977f, -0.02577497f, -0.01450570f, -0.00628236f, 0.02468398f, -0.00853392f, 0.00857500f, -0.03936312f, 
    0.00246904f, 0.01031813f, -0.03012288f, 0.02921936f, 0.01448625f, 0.00865486f, -0.02006223f, -0.02782259f, 
    0.00450268f, -0.00304806f, -0.02680412f, 0.00728784f, 0.02410573f, -0.04122588f, -0.00884071f, -0.01199184f, 
    -0.03810037f, -0.01135648f, 0.01474947f, -0.01117211f, 0.00364681f, -0.01399905f, 0.01845879f, -0.01263792f, 
    -0.02061239f, 0.01616323f, 0.02550568f, -0.03148708f, -0.01285728f, -0.02859866f, -0.00933256f, 0.02989884f, 
    -0.03500197f, 0.02133007f, 0.02959433f, -0.02873930f, 0.02335959f, -0.02243121f, -0.03814718f, 0.00948243f, 
    -0.01666030f, -0.00176426f, -0.03506358f, -0.00019581f, -0.01870181f, 0.01590428f, -0.01287029f, -0.02875841f, 
    0.00677491f, -0.01896738f, -0.03043858f, -0.01595651f, 0.03388923f, 0.01144262f, 0.01000993f, -0.01442905f, 
    0.00788867f, 0.02210164f, 0.02958322f, -0.02109564f, -0.03821680f, -0.00416514f, 0.00658386f, -0.01402638f, 
    0.00834288f, -0.00334904f, -0.01020189f, -0.03371631f, -0.02102558f, 0.00673360f, -0.00087456f, -0.01094245f, 
    0.00994251f, -0.01519238f, 0.00437812f, -0.00157665f, 0.00012559f, 0.00338751f, 0.00656127f, -0.03684817f, 
    -0.00182074f, -0.03705340f, 0.02665618f, 0.01926221f, -0.03701619f, -0.00163734f, -0.02022978f, 0.00196465f, 
    0.00518147f, -0.02404608f, -0.00914251f, -0.01860726f, 0.00921327f, 0.02797736f, -0.03402602f, -0.03410904f, 
    -0.02534347f, -0.03333981f, 0.01406793f, -0.03726521f, 0.02310858f, 0.00916915f, -0.01412086f, -0.01997039f, 
    -0.03699825f, 0.00955644f, -0.00767107f, 0.00394808f, -0.00788699f, -0.03909119f, -0.00705968f, 0.02400952f, 
    0.00394210f, 0.00007169f, -0.02858443f, 0.02137726f, -0.00833784f, -0.00445539f, -0.01258193f, -0.02506704f, 
    -0.01834309f, -0.02471384f, -0.01956479f, 0.02878168f, 0.02236769f, -0.03442201f, 0.02400559f, 0.00783654f, 
    0.00433005f, -0.00817543f, -0.00655752f, 0.00615776f, -0.00825610f, 0.01910054f, 0.00238810f, -0.03316355f, 
    0.00698610f, -0.03314199f, -0.01956184f, 0.02466527f, 0.01056363f, -0.01790891f, -0.00441079f, -0.02637263f, 
    0.00395076f, 0.02609209f, -0.02965787f, -0.00850557f, -0.01338349f, 0.01099739f, 0.00160980f, 0.02632970f, 
    -0.01236593f, -0.02076732f, 0.00489897f, 0.03530022f, 0.02541639f, -0.01408128f, -0.03550641f, 0.01378723f, 
    0.00371913f, 0.03063660f, 0.00430298f, -0.00223190f, -0.02065375f, 0.03433237f, 0.01308162f, -0.01422574f, 
    -0.01968384f, 0.04256811f, -0.03381210f, -0.01968549f, 0.02172501f, -0.01871709f, 0.03069432f, 0.00261447f, 
    -0.00568243f, 0.01485078f, -0.00517378f, -0.04025754f, 0.03178193f, 0.00959495f, -0.01488915f, 0.02559822f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01374049f, 0.01401539f, -0.03075890f, -0.01398863f, 0.01725993f, -0.01236591f, -0.03304931f, -0.06163365f, 
    -0.02544683f, 0.01089788f, 0.02945179f, 0.02012314f, 0.03901409f, -0.03883521f, 0.01009629f, 0.05662755f, 
    0.00799329f, 0.02668820f, -0.01944419f, 0.00048933f, -0.00204933f, 0.04066673f, 0.02333931f, 0.01249702f, 
    -0.01375126f, 0.00126834f, 0.09931885f, -0.06996170f, 0.02158294f, -0.01906314f, -0.02996204f, -0.02236959f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16668080f, -0.11541962f, 0.02248277f, 0.03179995f, -0.25691882f, -0.01066693f, -0.08662525f, -0.01025540f, 
    0.16194567f, -0.30752563f, 0.13259833f, 0.09212653f, -0.23099670f, 0.16174683f, -0.10953475f, -0.00551774f, 
    0.10030417f, 0.00056360f, -0.06088782f, 0.11321899f, 0.08784726f, -0.26348680f, -0.01162068f, -0.14665645f, 
    0.08301863f, 0.13929582f, 0.05715076f, 0.37639943f, -0.12967315f, 0.46872598f, -0.15356329f, 0.11215238f, 
    0.13883036f, 0.16876304f, -0.11414572f, 0.04757691f, 0.35260001f, -0.02621240f, 0.02083274f, 0.03577492f, 
    0.11195830f, -0.61170363f, 0.02118843f, 0.12806047f, -0.27610916f, -0.11268307f, 0.08168969f, -0.52907813f, 
    0.07779469f, -0.10324746f, -0.00281516f, 0.15407149f, 0.01263331f, 0.11842844f, 0.10790779f, 0.05779090f, 
    -0.13428204f, -0.20178024f, 0.08354207f, -0.07070193f, 0.16814949f, -0.07271145f, -0.04339115f, -0.07531537f, 
    0.15309401f, -0.11912856f, 0.09160388f, 0.02192926f, 0.12799048f, -0.02867237f, -0.07973327f, 0.47972307f, 
    0.09971543f, 0.07171270f, -0.15697028f, 0.13950287f, -0.23065448f, -0.10715353f, 0.23954353f, 0.35966083f, 
    -0.04021428f, 0.08314794f, 0.15484606f, -0.12361036f, -0.15577869f, -0.33049890f, -0.02478347f, 0.06112269f, 
    -0.12236368f, -0.45841533f, -0.29140890f, -0.06642174f, -0.03015800f, 0.26811591f, -0.10018681f, 0.14023149f, 
    -0.10783835f, -0.15255995f, -0.02266598f, -0.01804090f, -0.43418005f, 0.02438720f, -0.13518041f, -0.11329589f, 
    -0.11958594f, 0.08441027f, 0.05305298f, -0.02238174f, 0.30103096f, -0.13526323f, 0.18484394f, -0.53319848f, 
    0.16509691f, 0.15893531f, -0.00808175f, 0.02106542f, -0.10264631f, 0.38593730f, -0.14127816f, -0.16205351f, 
    -0.13315587f, 0.18636665f, -0.31919307f, -0.00048974f, -0.08889518f, 0.15186492f, -0.16511054f, -0.08547627f, 
    0.05203791f, 0.02567439f, -0.10713302f, -0.15827018f, 0.15659374f, 0.08773973f, 0.04076663f, -0.12921156f, 
    0.11045738f, 0.05867005f, -0.10578205f, 0.12437288f, 0.36738619f, 0.03616837f, -0.56331670f, -0.06467565f, 
    0.03586436f, 0.14924148f, -0.13001764f, 0.17271486f, -0.04081121f, -0.20703854f, 0.00759248f, -0.16268227f, 
    0.13521431f, 0.38263988f, -0.18478833f, 0.28238893f, -0.14034922f, -0.34246108f, -0.16369110f, 0.09288802f, 
    0.09908156f, 0.09687430f, 0.16301872f, 0.16196647f, 0.04053418f, -0.10402199f, -0.04553378f, -0.64703465f, 
    -0.04708000f, 0.13803618f, 0.01072213f, 0.07698004f, -0.26237994f, -0.06801745f, 0.12430783f, -0.06112586f, 
    -0.07213051f, -0.15552337f, 0.13342722f, 0.03385490f, 0.14814079f, 0.11656905f, 0.15874930f, -0.02939908f, 
    -0.04789712f, -0.28946796f, 0.16426820f, 0.32126668f, -0.08404465f, -0.74666989f, -0.14948703f, -0.16534695f, 
    0.07575645f, -0.15177281f, 0.02054321f, 0.11278377f, -0.23229828f, 0.04792630f, 0.08320240f, 0.33675560f, 
    -0.12634252f, 0.33293563f, 0.13333112f, 0.14323547f, 0.29066730f, 0.12470659f, -0.50755382f, -0.52289689f, 
    0.06694373f, 0.05957485f, 0.06290922f, 0.13637777f, 0.14813384f, -0.01133403f, 0.03610882f, 0.01199113f, 
    0.11191198f, -0.50596291f, 0.20986484f, 0.06073459f, 0.11930706f, -0.02464055f, -0.02604910f, 0.01136976f, 
    0.09886809f, 0.15281084f, 0.13914463f, 0.12283929f, -0.37192667f, -0.15550317f, 0.13971108f, 0.31002617f, 
    -0.05199052f, 0.39017019f, 0.15179047f, -0.09388555f, 0.23089559f, -0.15077852f, 0.06971342f, 0.40306097f, 
    0.05981718f, -0.10256729f, 0.00813790f, 0.09720173f, -0.16854005f, -0.14234780f, 0.16273822f, -0.03783818f, 
    -0.16513368f, 0.09631459f, -0.45801914f, 0.26680395f, -0.14188252f, -0.63999176f, -0.05591359f, 0.14574866f, 
    -0.14979880f, 0.11827377f, -0.11500571f, 0.04698771f, 0.04424711f, -0.06069414f, 0.00999724f, 0.42203659f, 
    -0.09039536f, -0.32667196f, 0.02589485f, 0.11575084f, 0.13436863f, 0.04191427f, 0.06710438f, -0.25145757f, 
    0.06324465f, 0.04346107f, -0.01043978f, -0.01191176f, -0.09162968f, -0.54091185f, -0.00622497f, -0.14083745f, 
    0.04173213f, 0.22285149f, 0.19204260f, -0.65525800f, 0.08467572f, -0.53457427f, -0.03595747f, -0.04958648f, 
    0.00989378f, -0.14538251f, -0.15333490f, 0.03153851f, 0.14963923f, -0.10857091f, -0.04684304f, -0.05201359f, 
    0.04351509f, 0.22261539f, 0.04460649f, 0.12819503f, -0.08269157f, 0.05954488f, -0.51334232f, 0.50042492f, 
    0.12598252f, 0.04792388f, -0.01172458f, 0.08124240f, -0.02668536f, 0.35264313f, 0.10501633f, 0.10429638f, 
    -0.02623462f, -0.00658199f, -0.09104632f, -0.43646842f, 0.10794160f, 0.06292786f, -0.07641165f, -0.01593718f, 
    -0.08580338f, 0.03335894f, -0.04359274f, 0.02698582f, -0.28813928f, 0.16264501f, 0.07010178f, -0.20542338f, 
    0.02313281f, -0.49320233f, -0.15257095f, -0.06169025f, 0.07899664f, 0.00189006f, 0.34407523f, 0.58335292f, 
    -0.10292769f, 0.02270191f, -0.14850517f, -0.10278907f, 0.03589614f, 0.31448159f, -0.15711401f, 0.12084093f, 
    -0.13766876f, -0.01355819f, 0.08775676f, -0.43981951f, 0.11902431f, -0.23069319f, 0.01329031f, -0.10078087f, 
    0.10722741f, -0.03255649f, -0.08113894f, -0.15789215f, -0.10236221f, -0.03787295f, -0.11201442f, -0.50042897f, 
    0.08485859f, 0.46139193f, -0.13285401f, -0.16848874f, 0.24689741f, 0.13361555f, 0.29969981f, -0.41576219f, 
    0.05202886f, 0.17155479f, 0.00771889f, -0.02032826f, -0.02532731f, -0.51605266f, 0.10044045f, 0.03053778f, 
    -0.15422425f, 0.11325364f, 0.07116420f, -0.33455265f, 0.12348387f, -0.09446724f, 0.07229786f, -0.05820242f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02037155f, 0.07637748f, -0.22571765f, -0.12079645f, 0.07681134f, 0.04763869f, -0.04142744f, 0.04939543f, 
    0.05800440f, 0.01330639f, 0.10489497f, -0.00687872f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
