#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08773571f, -0.15305364f, 0.66496986f, 0.65963292f, 0.31057000f, -1.05118775f, 0.11068802f, -0.37683153f, 
    0.19158012f, -0.00903631f, -0.34385994f, -0.08815044f, -0.18479073f, 0.34451979f, -0.18082240f, -0.02061451f, 
    -0.06698111f, 0.18543385f, -0.13877502f, 0.13694395f, 0.15275800f, 0.00523962f, 0.10514749f, 0.14951786f, 
    -0.12617464f, -0.41346368f, -0.39392316f, 0.27114516f, 0.77500099f, 0.32348496f, -0.67812061f, 0.18591844f, 
    0.01114862f, -1.04998553f, -0.19150679f, 0.54466897f, 0.50106120f, 0.36312208f, 0.17135137f, 0.24146369f, 
    0.00560591f, 0.14181370f, 0.10423192f, 0.29367384f, 0.02369369f, 0.04307400f, -0.01184176f, 0.02301308f, 
    0.30354056f, -0.13328576f, 0.65328866f, 0.38589686f, -0.31975538f, 0.49254546f, 0.29909843f, 0.28140879f, 
    0.46432132f, 0.61986613f, 0.55297601f, 0.54840958f, -0.03488173f, -0.16157629f, 0.04869919f, -0.12925144f, 
    0.22586536f, 0.06808913f, -0.44570321f, -0.25540206f, -0.09513405f, 0.08508768f, 0.36697471f, -0.06810248f, 
    0.25431198f, 0.07843020f, -0.23385482f, -1.37470376f, 0.64913619f, -0.29262576f, -0.43690947f, -0.07795980f, 
    0.60986978f, 0.13699381f, -0.07987561f, 0.61001271f, 0.28012842f, 0.09879380f, -0.10770961f, 0.25108504f, 
    0.22014092f, -0.17186046f, 0.04365028f, -0.20132239f, -0.04660590f, -0.15037450f, -0.33158296f, -0.13702382f, 
    -0.25523922f, 0.18391463f, 0.15960222f, 0.08547840f, -0.42771813f, -0.54292715f, 0.07825471f, 0.25334346f, 
    -0.48489502f, -0.74799085f, -0.22218457f, -0.01532488f, -0.51124960f, -0.39779487f, -0.43275669f, 0.26586127f, 
    -0.05311100f, 0.19129139f, -0.36818391f, -0.46661556f, -0.48095980f, -0.26496580f, -0.15257290f, -0.27532285f, 
    -0.02461205f, 0.26795775f, -0.09137750f, 0.30801386f, 0.11889913f, 0.79552841f, 0.88228726f, -0.33299163f, 
    -0.58099818f, -0.34615085f, 0.52344316f, 0.24238864f, 0.49950427f, 0.34102613f, 0.39592713f, 0.15562144f, 
    0.02080513f, -0.28623265f, -0.08485378f, -0.12313887f, 0.08142722f, -0.05695088f, -0.21302727f, 0.11126143f, 
    -0.06917388f, -0.39661127f, -0.07678206f, -0.18966961f, 0.06317048f, 0.25328434f, -0.30559197f, -1.08512986f, 
    -0.88817698f, -0.45012799f, -0.41184360f, -0.08516217f, 0.65092468f, 0.44431385f, 0.14947605f, 0.44576576f, 
    -0.05129913f, -0.15551296f, -0.19820714f, -0.19269431f, -0.42534527f, -0.07444395f, 0.21723931f, 0.24447373f, 
    -0.10933574f, -0.05752964f, -0.17017490f, -0.18343720f, -0.07779650f, -0.07172196f, 0.00331404f, 0.91155303f, 
    0.76670998f, 0.51735139f, 0.48919928f, 0.39460045f, 0.34818146f, -0.50568223f, -0.20861349f, -0.46021825f, 
    -0.04889360f, 0.25413677f, 0.40637335f, -0.06337748f, 0.10149643f, -0.13910763f, 0.28915980f, 0.12152100f, 
    0.11111815f, 0.05090239f, -0.06828859f, 0.07677398f, 0.32034495f, 0.43388337f, -0.21534286f, 0.14836992f, 
    -0.40254006f, -0.58981401f, -0.59314466f, -0.64932609f, -0.29422966f, -0.57328510f, -0.08798773f, 0.40275824f, 
    -0.41058329f, -0.05795071f, -0.30059958f, 0.26325548f, 0.25954524f, 0.12544495f, 0.02088443f, -0.23639557f, 
    0.02433179f, -0.11621994f, 0.28633231f, -0.05057704f, 0.14284441f, -0.18885109f, 0.15234606f, 0.11740937f, 
    0.16903055f, 0.97204638f, 0.00343932f, 0.73087060f, -0.15459664f, 0.39827687f, -0.23563303f, -0.03266834f, 
    -0.44624043f, -0.17474416f, -0.41037720f, 0.06849974f, -0.46849993f, 0.01122822f, -0.08538423f, 0.23465221f, 
    0.15412603f, -0.00989290f, -0.20520361f, 0.05782858f, 0.19310257f, -0.26240647f, -0.14409138f, -0.03885683f, 
    0.03524666f, -0.13582581f, 1.13000464f, 0.36891755f, -0.20262410f, 1.05565810f, 0.55168366f, 0.14189145f, 
    0.24179359f, 0.02896880f, 0.62345004f, 0.01325952f, -0.28673312f, 0.13972872f, -0.13407533f, 0.13699336f, 
    -0.23985098f, 0.19090751f, -0.05340192f, -0.05897472f, 0.02152525f, 0.05661808f, -0.10026225f, -0.10748703f, 
    -0.03704209f, -0.15514567f, 0.08029087f, 0.98983461f, 0.45433062f, 0.87353069f, -0.61035007f, -0.41547757f, 
    -0.43776906f, -0.19510648f, 0.28547761f, 0.06280395f, 0.21008088f, 0.02956977f, 0.03860505f, -0.23681365f, 
    0.05446773f, -0.51322347f, -0.23859006f, -0.25188071f, -0.24958551f, -0.21398337f, -0.15327433f, 0.01811097f, 
    -0.19282751f, 0.00701978f, 0.09989295f, -0.22456264f, -0.82093740f, -0.83643144f, -0.67073137f, 0.20156839f, 
    0.56569076f, -0.30786356f, 1.03112316f, 0.07478181f, -0.15001413f, 0.37523583f, -0.01295124f, 0.06074853f, 
    0.23040374f, 0.04436151f, 0.28447911f, -0.13288973f, -0.08169150f, 0.01613787f, -0.04522249f, -0.15310331f, 
    0.17191395f, 0.09521648f, -0.06697271f, 0.14154568f, -0.14582987f, 0.93079793f, -0.35433692f, 0.51116914f, 
    0.24908943f, 0.19194451f, 0.64289868f, -0.40025407f, -0.61197072f, 0.16468401f, 0.17026350f, -0.04916447f, 
    0.14247312f, -0.14898570f, 0.02748863f, 0.09385896f, -0.24625869f, -0.29294673f, 0.33900532f, -0.01620220f, 
    -0.19731136f, 0.26570132f, 0.37632662f, 0.15523157f, 0.22247426f, 0.29319260f, 1.09654772f, 0.25339720f, 
    -0.75568885f, -0.86376536f, -0.03598323f, -0.22434922f, -0.50059319f, 0.04886363f, -0.01190560f, 0.11141971f, 
    -0.46759799f, -0.24464075f, 0.46677986f, 0.11327245f, -0.08115788f, -0.05906631f, 0.07638843f, -0.02250815f, 
    0.23375088f, 0.06783810f, 0.24507941f, 0.06041439f, 0.01558434f, -0.03934434f, 0.03340847f, -0.36379111f, 
    0.76705700f, -0.66398078f, 0.18342751f, -0.62038475f, 0.37394869f, -0.68093938f, -0.79278684f, -0.27611020f, 
    -0.42635825f, -0.02528157f, 0.33212888f, 0.12005658f, 0.24659052f, -0.22754352f, -0.00637430f, 0.12737869f, 
    0.19010133f, 0.13950868f, 0.07526548f, -0.08174368f, -0.17666601f, 0.11283971f, 0.07371820f, 0.11797532f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24352020f, 0.09722802f, 0.06460887f, -0.04623971f, -0.06968718f, 0.20187454f, 0.12608792f, -0.07598868f, 
    0.07264172f, -0.01446539f, 0.24585536f, 0.29156712f, 0.24681802f, 0.02392961f, 0.27408063f, 0.16941124f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07862348f, 0.03401110f, -0.06122344f, -0.07932881f, -0.04991434f, 0.01635199f, -0.00935010f, 0.02896455f, 
    -0.04605579f, -0.07417806f, -0.05494618f, -0.07106073f, 0.00756025f, -0.06094981f, -0.01530835f, 0.06891199f, 
    -0.07873967f, -0.02924583f, -0.03524042f, -0.05807156f, -0.00746776f, -0.00435498f, -0.06075211f, -0.01370261f, 
    0.07002727f, 0.03521963f, -0.03693487f, 0.08027592f, -0.03242012f, 0.04668584f, 0.00073782f, -0.04653963f, 
    0.08594069f, -0.04370635f, -0.03444589f, -0.00445905f, 0.00959126f, 0.01683990f, 0.06815539f, 0.03169186f, 
    -0.00926869f, -0.07515191f, -0.02270491f, 0.02583535f, -0.02440431f, 0.02811182f, -0.08930398f, -0.05921805f, 
    -0.07631067f, 0.00294317f, -0.03867469f, -0.05436710f, -0.07045987f, 0.02503311f, -0.05714735f, -0.00122118f, 
    0.03315325f, -0.16237207f, -0.01647665f, -0.03517152f, -0.00107606f, 0.00245941f, -0.04181768f, 0.00878359f, 
    0.04013862f, -0.00365599f, 0.02910050f, 0.10145114f, -0.03746181f, -0.00840362f, 0.06462395f, -0.04407739f, 
    0.08088580f, 0.00269240f, 0.03671720f, -0.01400117f, 0.02845101f, -0.11755167f, -0.01340382f, -0.11359502f, 
    -0.00631902f, 0.00655135f, 0.00420785f, -0.07702881f, -0.04296050f, 0.05684517f, -0.09521694f, -0.05881331f, 
    0.02244278f, 0.04684449f, -0.00825096f, 0.02462944f, 0.01759031f, 0.04806466f, -0.09080342f, -0.01492830f, 
    -0.01813979f, -0.00068400f, 0.00657033f, 0.00805306f, -0.01874650f, -0.00568187f, -0.07587682f, 0.00877590f, 
    0.02184898f, -0.11449821f, -0.07615250f, -0.11306863f, -0.05989078f, -0.05379230f, -0.08582398f, 0.00726841f, 
    -0.06668851f, -0.08264044f, 0.05266098f, 0.00838229f, -0.06171774f, 0.05806530f, -0.06515487f, -0.02693241f, 
    0.03884590f, -0.06295745f, -0.06709608f, 0.00534478f, 0.03440521f, 0.02835519f, 0.02063822f, -0.02707717f, 
    -0.01781422f, -0.06460904f, 0.03791832f, 0.01047555f, 0.06316432f, -0.03925693f, -0.01037280f, 0.02477411f, 
    -0.02431539f, -0.05012702f, -0.05543547f, -0.03973059f, -0.01993002f, 0.04646686f, -0.02729845f, -0.03466130f, 
    0.08059080f, -0.04406447f, 0.04175848f, 0.03987937f, -0.02149088f, -0.03243761f, -0.06329326f, -0.09308369f, 
    0.05568380f, -0.02913231f, -0.05773809f, -0.05805708f, 0.07690191f, -0.03633820f, -0.07865866f, 0.01966811f, 
    -0.03264208f, -0.00240271f, 0.06989545f, -0.01447798f, -0.08242132f, -0.05631554f, -0.00483817f, 0.00452867f, 
    -0.00337139f, -0.01229542f, 0.00536700f, -0.06606267f, 0.01608941f, -0.01586902f, 0.00630391f, -0.01954568f, 
    -0.05048203f, -0.04628495f, -0.04720398f, 0.03109596f, -0.07947765f, 0.01554641f, 0.06111703f, 0.03973371f, 
    -0.01407628f, -0.07100649f, 0.04045631f, 0.01640029f, -0.02427083f, 0.00596554f, 0.00598579f, 0.04767494f, 
    0.02638891f, 0.02390439f, -0.04787919f, -0.01084952f, 0.01794837f, -0.05002596f, 0.02478998f, -0.06582605f, 
    -0.01877346f, -0.03731556f, -0.01022521f, 0.00136338f, 0.01226260f, -0.05778463f, -0.04444777f, 0.02584294f, 
    -0.03464047f, -0.07494420f, 0.03417742f, -0.02155758f, 0.05258771f, -0.04107526f, -0.05031084f, -0.03015473f, 
    -0.04303176f, 0.00967057f, 0.04100937f, 0.06214020f, -0.07236437f, -0.06167252f, -0.01445778f, -0.01408079f, 
    0.03210739f, 0.01598691f, -0.05348958f, 0.04605396f, -0.00755933f, -0.03289644f, 0.05419425f, -0.00204376f, 
    -0.06825960f, -0.07267029f, 0.01335473f, 0.04670242f, -0.07457626f, 0.02728712f, -0.05104793f, 0.00267946f, 
    0.02801179f, 0.04847606f, 0.04613033f, -0.01096896f, -0.02342064f, 0.03143150f, 0.01429318f, -0.04598811f, 
    -0.00676599f, 0.00830845f, 0.03704204f, 0.05141300f, -0.03962793f, -0.00771487f, 0.05003454f, -0.00623118f, 
    0.02891148f, 0.01877590f, 0.00898212f, -0.03017540f, -0.00847239f, -0.05506061f, -0.06736001f, 0.02349519f, 
    0.00621333f, 0.01237311f, -0.04506383f, -0.04380796f, -0.05983859f, -0.03781098f, 0.01740250f, -0.04878244f, 
    0.01163956f, -0.07131381f, -0.06340976f, 0.04494496f, -0.08709064f, 0.01271739f, 0.02363394f, -0.06608815f, 
    -0.04500835f, 0.06745244f, 0.00389325f, 0.04472542f, -0.00554439f, 0.00089161f, 0.03213745f, -0.02821317f, 
    -0.06474354f, 0.04672062f, 0.00432814f, -0.01126818f, 0.02561946f, -0.04967360f, -0.02721954f, -0.04312435f, 
    -0.02821671f, -0.03546331f, 0.00919092f, -0.06589982f, -0.08073889f, -0.05034265f, -0.02083437f, -0.05969577f, 
    -0.07235342f, 0.04774150f, -0.03687221f, -0.01587765f, -0.04196531f, -0.03569729f, 0.02925844f, -0.04156899f, 
    -0.06977286f, 0.05630616f, -0.04319062f, -0.00516014f, -0.07433776f, -0.05189644f, 0.03539414f, 0.03661257f, 
    -0.03122407f, -0.04314885f, 0.05694317f, 0.04023180f, -0.00196992f, 0.05087920f, 0.04310035f, -0.02449177f, 
    -0.06901579f, -0.08040007f, 0.04743622f, 0.05507124f, 0.03429462f, 0.02145058f, -0.00592641f, 0.04775340f, 
    0.00179126f, 0.04692131f, -0.05841524f, 0.01745622f, 0.00858119f, 0.04582073f, -0.05596005f, 0.03444983f, 
    -0.01705965f, -0.05748210f, 0.02556784f, 0.02375063f, 0.03777049f, -0.02250884f, -0.01134960f, -0.02444895f, 
    -0.03233394f, -0.07742210f, -0.04994979f, 0.01192110f, 0.05248611f, 0.03780970f, 0.02482072f, -0.03887027f, 
    -0.02489414f, -0.07366656f, 0.01406324f, 0.03290560f, 0.05544192f, -0.02707092f, -0.01508761f, -0.02488448f, 
    -0.02943814f, -0.01558226f, -0.02696938f, -0.05822367f, -0.06485073f, 0.03023476f, -0.04648896f, 0.02096051f, 
    -0.01795987f, 0.03082540f, -0.06926602f, 0.03701422f, -0.05937285f, -0.08951051f, 0.05570837f, -0.03977143f, 
    0.30336502f, 0.08250485f, -0.02125687f, 0.01129730f, -0.02505278f, -0.04970980f, -0.04684786f, -0.00721780f, 
    0.04986443f, -0.14335866f, 0.01272562f, 0.07826345f, 0.02866050f, 0.03244473f, -0.18593134f, 0.15195160f, 
    0.03312705f, 0.00776711f, 0.01345040f, -0.00940576f, 0.07952690f, 0.02778460f, 0.07222541f, -0.09852865f, 
    -0.10335829f, -0.05182752f, 0.17318380f, 0.08435819f, 0.01198348f, 0.05144736f, -0.06747697f, 0.06839351f, 
    0.01767077f, 0.11067829f, 0.05203802f, 0.23538753f, -0.18937889f, -0.31382683f, -0.02617628f, -0.06587347f, 
    -0.06426674f, 0.08321211f, -0.04205045f, -0.01745281f, -0.01912064f, 0.13275778f, -0.03249905f, 0.01239847f, 
    -0.48084342f, -0.15368481f, -0.29008639f, 0.08990104f, -0.05691446f, 0.09029823f, -0.02673922f, -0.05860985f, 
    -0.06766843f, -0.01304270f, 0.06203763f, 0.12765382f, 0.19351135f, 0.11323105f, 0.13273470f, -0.09270547f, 
    0.05018673f, -0.09340879f, 0.06371308f, 0.01985735f, -0.05609670f, 0.03609052f, 0.10950173f, -0.07092338f, 
    -0.01724840f, -0.18096025f, -0.17708930f, -0.22126369f, 0.22997740f, -0.01728274f, 0.10958020f, 0.15586855f, 
    0.02869528f, 0.02863791f, 0.01535423f, 0.12113645f, 0.39170048f, 0.30269253f, 0.38992316f, -0.05304458f, 
    -0.09388647f, 0.03517122f, 0.00851149f, 0.03670441f, -0.02509599f, 0.09314492f, -0.16889018f, -0.08675256f, 
    -0.28149274f, -0.11275399f, 0.02331117f, -0.08325551f, -0.01427618f, -0.08012241f, -0.00054238f, -0.06476840f, 
    0.04967811f, 0.01887445f, -0.01812816f, -0.02966036f, 0.52878034f, 0.31883156f, 0.15183698f, -0.02513453f, 
    0.04336346f, -0.10075455f, -0.05270616f, 0.00250537f, 0.02069774f, -0.07276785f, 0.04608120f, -0.04136558f, 
    0.38781527f, 0.16171104f, 0.14959770f, 0.21471746f, -0.08011395f, 0.03847263f, -0.06220783f, 0.13570946f, 
    0.07980220f, 0.06448161f, 0.02617877f, 0.08409113f, 0.03736340f, 0.25268257f, 0.03312014f, 0.09484434f, 
    0.02055714f, -0.05904218f, -0.04188135f, 0.04054181f, -0.00875227f, -0.04580960f, 0.09290229f, -0.00817638f, 
    0.02424183f, -0.03843845f, -0.00247031f, -0.19483335f, 0.11319708f, 0.01882086f, 0.04017369f, 0.09034585f, 
    0.03262574f, -0.09685289f, 0.11499382f, 0.11040700f, 0.25069124f, -0.04586078f, 0.10851444f, 0.06528571f, 
    -0.20674171f, -0.01251878f, 0.05918188f, 0.09657082f, -0.06659595f, -0.06040239f, 0.03881805f, 0.03698654f, 
    0.29358271f, -0.15580097f, 0.10327647f, -0.17421745f, 0.12583174f, -0.07904263f, 0.10387859f, 0.07052951f, 
    -0.11127958f, -0.09907304f, 0.03299709f, -0.02643897f, -0.26598877f, -0.22494990f, 0.08850286f, -0.01308236f, 
    0.02246177f, 0.10315121f, 0.06725370f, -0.02697902f, 0.16536552f, 0.04713719f, -0.00039130f, 0.16859980f, 
    0.29173702f, -0.12405064f, -0.17027338f, 0.02821910f, 0.08964777f, -0.17003071f, -0.06150660f, 0.04382277f, 
    -0.01071946f, 0.01204106f, 0.09627165f, -0.07537061f, 0.35801378f, -0.01789296f, -0.23013143f, 0.17956427f, 
    0.08686643f, 0.07696917f, 0.13345873f, -0.16418320f, 0.05234337f, 0.08242770f, 0.15498459f, 0.17592818f, 
    0.08428909f, 0.01393683f, 0.01475017f, 0.17604101f, -0.11532670f, 0.02373956f, -0.08148380f, 0.12142608f, 
    0.01816738f, 0.12049364f, -0.10519293f, 0.08756846f, 0.00778796f, 0.24493389f, -0.06969370f, -0.09050240f, 
    0.03684449f, 0.02623601f, 0.02229254f, 0.13349284f, 0.02589759f, -0.13796538f, 0.06536035f, -0.01400956f, 
    0.09222402f, -0.12923028f, -0.10300113f, 0.03865458f, 0.01659729f, 0.16736624f, -0.10781810f, 0.11767945f, 
    0.16114429f, -0.05089413f, -0.07224526f, -0.17740500f, -0.01539904f, -0.06196684f, -0.35808063f, -0.15922709f, 
    0.07552727f, 0.02769160f, 0.07051094f, -0.17796929f, -0.01216998f, -0.01380477f, 0.07920464f, 0.02460545f, 
    0.36640352f, 0.49782470f, 0.18639739f, -0.18078272f, -0.02845067f, -0.02052910f, 0.02519378f, -0.06552273f, 
    0.03772311f, -0.10140700f, -0.08455529f, 0.06518468f, 0.07458115f, -0.05698669f, 0.00995523f, 0.00133483f, 
    0.07203694f, -0.01612942f, 0.05246160f, -0.00196835f, 0.07499136f, 0.12752543f, 0.12629943f, 0.03880600f, 
    0.15783328f, 0.26405627f, 0.11014704f, -0.02699948f, -0.02716079f, 0.24919622f, 0.02021853f, 0.12715858f, 
    0.09624387f, 0.05775207f, 0.00130309f, 0.02748627f, 0.02147938f, -0.05098902f, 0.02314163f, -0.00485551f, 
    -0.17179942f, -0.17636731f, 0.05660229f, -0.09126269f, -0.04869927f, 0.04073416f, -0.08565494f, -0.13895260f, 
    0.13037556f, -0.36019742f, 0.12568969f, 0.39535156f, 0.03633958f, 0.03619883f, -0.28973570f, 0.17576897f, 
    0.09799063f, 0.04675375f, 0.00841791f, -0.11209965f, -0.22780634f, 0.14677262f, -0.23577608f, -0.17020266f, 
    0.05022430f, -0.07197857f, -0.08472908f, -0.16479720f, 0.06995855f, -0.02814027f, 0.01707797f, -0.04310388f, 
    0.09721480f, 0.28178731f, 0.05507212f, 0.04964158f, 0.06959116f, 0.03043146f, -0.06940240f, -0.02248495f, 
    0.07690085f, 0.01440324f, 0.11488304f, -0.03166713f, -0.07764697f, -0.26044253f, 0.13418750f, 0.22949286f, 
    -0.01589137f, 0.11157952f, 0.11441007f, 0.00990537f, -0.06565139f, 0.15712979f, 0.12637269f, 0.03091672f, 
    -0.12865306f, 0.13940755f, -0.13807540f, -0.24115987f, 0.16352490f, 0.05038792f, 0.08033507f, 0.03361299f, 
    -0.09489613f, -0.00730731f, 0.03165980f, 0.02081847f, 0.12177447f, 0.01336534f, -0.17341243f, 0.12359293f, 
    0.07831074f, -0.12405960f, -0.03357186f, -0.04023745f, 0.12367747f, 0.05536362f, 0.15342519f, 0.08119861f, 
    -0.30333829f, -0.03722571f, 0.22219884f, 0.30957016f, -0.22324607f, 0.05441061f, 0.01428557f, -0.07574813f, 
    0.05244915f, -0.03300294f, 0.05041878f, 0.10739800f, -0.34679729f, -0.10981400f, 0.19956905f, 0.05903088f, 
    -0.06124993f, -0.04498343f, -0.01379691f, 0.09542871f, -0.04487821f, 0.06404433f, -0.11252569f, 0.06017964f, 
    0.22440878f, -0.06936778f, -0.17046165f, 0.09695578f, 0.05280585f, 0.03908057f, 0.05957733f, -0.13006452f, 
    -0.00432596f, 0.11110701f, 0.13318379f, -0.04532615f, 0.28081807f, 0.31120759f, -0.07619967f, 0.07604574f, 
    0.18957916f, -0.06490064f, 0.01449255f, 0.10059893f, 0.01925230f, -0.00389507f, 0.15475562f, 0.00573002f, 
    0.23402439f, -0.01978140f, 0.25939256f, -0.14923318f, 0.01601083f, -0.01437439f, 0.01208833f, -0.03637703f, 
    0.01715259f, 0.08446658f, -0.00018246f, 0.25517508f, -0.14002195f, 0.17418948f, 0.10649873f, -0.04915087f, 
    0.02220654f, -0.04209484f, -0.04533698f, 0.16317636f, 0.08669204f, 0.08651257f, -0.05250907f, 0.07421622f, 
    -0.28323516f, -0.02623426f, 0.31361371f, 0.24161528f, -0.01851288f, -0.04128757f, 0.09846621f, 0.12836559f, 
    -0.10555071f, 0.05928405f, 0.12133978f, -0.07686916f, -0.42874458f, 0.03331472f, -0.12265246f, 0.01865761f, 
    0.03646412f, 0.09958567f, -0.05515542f, 0.04304802f, -0.05946268f, -0.01103897f, -0.00769047f, -0.14610712f, 
    0.25734824f, -0.04293456f, 0.23451088f, 0.07671873f, 0.18971950f, -0.04750183f, 0.11805851f, 0.03880443f, 
    -0.16271234f, -0.13951115f, 0.01405432f, 0.05428210f, -0.29807407f, -0.25768322f, -0.00900325f, 0.03386536f, 
    0.04924377f, 0.08293331f, -0.03918730f, 0.04500902f, -0.04228900f, -0.09968681f, 0.03570137f, -0.03305117f, 
    0.06177898f, 0.08194777f, -0.17783058f, 0.12700908f, 0.05466974f, -0.02840963f, 0.12444773f, -0.09340232f, 
    -0.05548453f, -0.03398196f, 0.11639147f, 0.07885019f, 0.19100960f, -0.21398444f, -0.00088146f, -0.25377446f, 
    0.01843822f, 0.09577648f, 0.12084890f, -0.02997797f, 0.09003536f, 0.10909846f, -0.04088007f, 0.04857997f, 
    -0.00731981f, 0.09995556f, 0.02604618f, 0.15536478f, -0.14766859f, -0.07244872f, -0.05125558f, -0.01750083f, 
    0.01506354f, 0.06121650f, -0.08051476f, -0.06384727f, -0.19950332f, 0.39040619f, -0.00241978f, -0.08221309f, 
    0.12388745f, -0.06107502f, -0.10475401f, -0.23740083f, 0.09379133f, -0.08611640f, -0.16292182f, 0.05137606f, 
    -0.11559857f, 0.02050879f, -0.09140795f, 0.12427681f, -0.22093482f, 0.01415884f, -0.00036917f, 0.05148372f, 
    0.06322225f, 0.14072253f, -0.02723562f, 0.07386594f, 0.11850177f, 0.16537914f, -0.00076730f, -0.13946018f, 
    -0.07355686f, 0.10129852f, 0.11083240f, 0.03110330f, -0.00725810f, 0.07390000f, -0.06238794f, -0.14238021f, 
    0.13984644f, -0.02599164f, -0.02039224f, -0.05199177f, 0.02175296f, -0.08234977f, -0.03004628f, -0.06383673f, 
    -0.05464387f, -0.06073465f, -0.02689902f, 0.09058993f, 0.33172384f, 0.05289931f, -0.33033091f, 0.08244425f, 
    0.01374022f, -0.01959549f, 0.05321280f, 0.07515945f, -0.03954390f, -0.10017619f, -0.04432297f, -0.15310948f, 
    -0.16355658f, -0.07308196f, -0.23021664f, 0.14788185f, 0.02375285f, 0.01948107f, 0.08414707f, -0.08260412f, 
    -0.12368450f, -0.13408735f, 0.25757608f, -0.03248202f, 0.71051973f, -0.13861762f, 0.12728377f, 0.02218132f, 
    0.00464975f, 0.09400217f, -0.10205927f, 0.16425276f, -0.19619666f, 0.09097302f, -0.05587456f, 0.02142921f, 
    -0.21183316f, -0.02007147f, -0.23263301f, -0.04757063f, -0.08818772f, -0.00120720f, -0.02865740f, -0.09464411f, 
    0.09880427f, 0.19470575f, 0.04938341f, 0.28968880f, -0.19498178f, 0.16961060f, 0.08885188f, 0.00564898f, 
    0.17327183f, -0.06180312f, 0.16137893f, 0.14335528f, 0.04859116f, 0.10149195f, 0.12082732f, -0.10039983f, 
    -0.15534067f, 0.04385230f, 0.17512339f, 0.03352684f, 0.00036198f, 0.04848040f, 0.09706064f, 0.29395467f, 
    -0.19334534f, 0.12518108f, 0.03823567f, 0.06707611f, 0.30781823f, 0.24080457f, -0.04175656f, -0.22661681f, 
    0.16503787f, 0.17643741f, -0.13907072f, -0.03763798f, -0.05185372f, -0.10276277f, -0.07738145f, -0.27943107f, 
    -0.15051195f, 0.26380694f, -0.30008528f, -0.02528232f, -0.06638166f, -0.16876256f, -0.05442594f, -0.07759748f, 
    0.05234592f, -0.00982134f, -0.10368487f, -0.00132945f, 0.14228034f, 0.22404562f, 0.01005713f, 0.08465994f, 
    -0.08472680f, -0.05405200f, -0.23367351f, -0.07324684f, 0.01148107f, -0.12960963f, 0.06419906f, -0.09093311f, 
    -0.01726721f, 0.25471249f, 0.03612080f, 0.08079385f, 0.04923005f, -0.02649185f, 0.04673213f, 0.04109018f, 
    0.16264389f, 0.06550124f, 0.09024406f, 0.05940910f, 0.31088957f, 0.00837635f, -0.03447989f, -0.03401847f, 
    -0.03431727f, -0.03456498f, -0.06011204f, -0.04108701f, -0.01701201f, 0.07492611f, 0.18688589f, 0.28469288f, 
    0.36187178f, -0.09197237f, 0.17715973f, 0.22341074f, 0.03195759f, 0.05092006f, -0.05625278f, 0.05590247f, 
    -0.03614027f, -0.08273289f, -0.05558893f, 0.10467699f, 0.17983411f, 0.09121635f, -0.04656461f, -0.13129796f, 
    0.08797417f, -0.11847746f, -0.16385230f, -0.34503233f, -0.11912910f, -0.02173316f, -0.05238505f, 0.01162279f, 
    -0.16071351f, 0.40258920f, -0.20493746f, 0.04986711f, 0.08950701f, 0.24345793f, 0.06695614f, -0.18621129f, 
    -0.14272431f, -0.02124446f, -0.06519496f, 0.18181694f, -0.12608618f, 0.14576446f, 0.05301666f, -0.11315177f, 
    0.12593335f, -0.03080251f, -0.10990589f, -0.17370096f, 0.08494548f, -0.09214865f, -0.27288097f, 0.07936808f, 
    0.40888068f, -0.10501845f, -0.14318727f, 0.03494336f, -0.03451179f, 0.03767966f, 0.06636818f, -0.18995368f, 
    -0.14216003f, -0.07730627f, 0.03272518f, 0.10295462f, 0.09194171f, -0.10170015f, -0.06997552f, -0.01882822f, 
    0.08820643f, 0.05647682f, -0.06798878f, -0.12996341f, 0.17736416f, 0.00474377f, 0.07038657f, -0.14195375f, 
    -0.17347474f, 0.12624460f, 0.27500552f, 0.04817980f, -0.03854385f, -0.08510596f, -0.13105974f, -0.03808214f, 
    0.01046733f, 0.00903932f, -0.04853450f, 0.10128886f, 0.08503387f, -0.16666339f, 0.12866162f, -0.08849156f, 
    0.02715492f, -0.01306555f, 0.11818314f, 0.04059359f, -0.01296268f, 0.03358752f, -0.09522631f, 0.00335890f, 
    -0.34561029f, -0.09752768f, -0.19239195f, 0.18941599f, -0.02470945f, 0.02568092f, -0.04461896f, -0.02652470f, 
    -0.07778560f, 0.04938812f, 0.00538412f, 0.01757848f, 0.26317501f, 0.13905092f, 0.15554968f, -0.10480750f, 
    -0.03261457f, -0.08541988f, 0.03380262f, 0.12345012f, -0.02361549f, 0.08134472f, 0.11940824f, 0.02105436f, 
    -0.06004655f, -0.05649872f, -0.16941760f, -0.26289910f, 0.27031422f, 0.07847305f, 0.09785695f, 0.07630803f, 
    -0.00705362f, 0.11059369f, 0.09222620f, 0.11590692f, 0.46050334f, 0.31755430f, 0.38598990f, 0.05821947f, 
    -0.09917776f, 0.00704123f, -0.03998329f, 0.06217741f, -0.00099734f, 0.03518004f, -0.19788538f, -0.07597362f, 
    -0.16237171f, -0.02585230f, 0.02307965f, 0.11203812f, 0.07967804f, -0.01087456f, 0.10439643f, 0.03726829f, 
    0.10470457f, 0.05377416f, -0.04159475f, -0.10582919f, 0.59508359f, 0.25878939f, 0.09786145f, 0.16294327f, 
    -0.03536362f, -0.06996911f, -0.08989861f, 0.09076255f, 0.09584257f, 0.01766955f, 0.16908453f, -0.01588520f, 
    0.42859209f, 0.33629116f, 0.15763794f, 0.19907501f, -0.05161257f, 0.06652777f, 0.01770064f, 0.14148401f, 
    -0.09515354f, -0.06268386f, -0.05796960f, 0.00040314f, -0.05168679f, 0.14974521f, -0.07146864f, 0.09036554f, 
    -0.09602096f, -0.14543110f, 0.06287067f, 0.03534490f, 0.02001524f, 0.11233736f, 0.04876993f, 0.02735377f, 
    -0.07629538f, -0.06242623f, 0.11616565f, -0.20257884f, 0.06078789f, 0.02361389f, 0.04306237f, 0.06892604f, 
    0.03045236f, -0.04179884f, 0.10164604f, 0.10816735f, 0.32167840f, -0.07521885f, -0.12541337f, 0.20614053f, 
    -0.16860344f, -0.00735088f, -0.00434968f, 0.03361298f, -0.17644191f, -0.02579819f, 0.00272885f, -0.05862053f, 
    0.38259161f, -0.00817301f, -0.02878737f, -0.16751745f, 0.09149247f, -0.05466586f, 0.08160688f, 0.01778040f, 
    -0.10444015f, -0.06990470f, 0.03023345f, 0.00476792f, -0.20873895f, -0.07116099f, 0.21616629f, 0.08797676f, 
    -0.05483550f, -0.05230317f, -0.03721575f, 0.01844037f, 0.10484118f, 0.00784071f, -0.08276112f, 0.01075453f, 
    -0.02516806f, -0.07700283f, -0.05964602f, -0.00977007f, -0.00843087f, 0.02860581f, -0.02974357f, -0.02957435f, 
    -0.07019385f, -0.04922239f, -0.00841175f, -0.02336106f, -0.00829881f, -0.06540290f, 0.03505563f, -0.04188186f, 
    0.05896776f, -0.03539557f, -0.06539525f, 0.01151224f, -0.07529729f, -0.07331903f, -0.07493339f, -0.06327420f, 
    -0.01892196f, -0.04108477f, 0.04864465f, 0.06080446f, 0.01094736f, 0.03753450f, 0.03505227f, 0.01320067f, 
    0.02074175f, -0.01178402f, 0.01287803f, -0.01675511f, 0.01286150f, -0.07600269f, -0.03817589f, -0.05691663f, 
    0.02923224f, 0.00974655f, 0.00926799f, -0.07975308f, -0.06466960f, 0.01951393f, -0.04183216f, -0.05392173f, 
    0.03573449f, -0.00776662f, 0.06560835f, -0.06538229f, 0.00297777f, -0.01153140f, 0.02567244f, -0.07356040f, 
    0.00747302f, -0.01399618f, 0.04676778f, 0.00455554f, -0.05818452f, 0.06092215f, -0.03645515f, -0.00536041f, 
    0.02270742f, -0.03936021f, -0.01634234f, -0.06384967f, 0.01856105f, -0.06070762f, -0.06423797f, -0.04065055f, 
    -0.06474186f, -0.07499471f, -0.00857211f, 0.00096242f, 0.05768069f, 0.01350384f, 0.05228073f, -0.00119172f, 
    0.04554924f, -0.04240850f, -0.04339807f, 0.05116890f, 0.05181799f, 0.04698459f, 0.02195466f, 0.01542480f, 
    0.03531609f, -0.02125800f, -0.01946421f, -0.00486702f, -0.04817183f, 0.03015400f, -0.04865076f, -0.02742573f, 
    0.01348262f, -0.03915341f, -0.00527274f, -0.04534952f, -0.00544756f, 0.04606088f, 0.00067563f, 0.03222065f, 
    -0.01381151f, -0.00432597f, -0.07709092f, 0.06577702f, -0.02264985f, -0.03965164f, -0.04062039f, -0.00080559f, 
    -0.03422261f, -0.00425889f, -0.04909100f, -0.06203555f, 0.05314041f, 0.04316325f, -0.00448980f, -0.06286431f, 
    -0.04461015f, 0.03991024f, -0.03286388f, -0.04780759f, 0.03259138f, -0.07255840f, -0.02089411f, 0.04419609f, 
    -0.02125713f, 0.04261541f, -0.01740070f, -0.07564273f, 0.03517026f, -0.07632503f, -0.01304515f, 0.05716130f, 
    -0.00687978f, 0.02392963f, -0.00592686f, 0.03490875f, -0.05439293f, 0.01621264f, 0.00507730f, -0.03258734f, 
    0.03163955f, -0.02432727f, -0.06470693f, -0.06466570f, 0.01283996f, 0.01697391f, -0.02034361f, -0.01029197f, 
    0.03941023f, 0.03417259f, 0.02181097f, -0.06818110f, 0.05779613f, 0.01026024f, -0.07381982f, 0.06269591f, 
    0.04102669f, 0.03703117f, -0.05066394f, 0.01298314f, 0.01037243f, -0.02203420f, -0.04437097f, -0.01127906f, 
    -0.03225864f, -0.03899909f, -0.07728050f, 0.02580149f, -0.04294312f, -0.06836575f, 0.04646955f, 0.00946211f, 
    0.05457059f, -0.08221570f, 0.01057691f, 0.00984979f, 0.03810703f, -0.07120019f, -0.00451438f, -0.00233373f, 
    0.03077824f, 0.02364162f, 0.05774237f, -0.01314696f, -0.01532136f, -0.04923541f, -0.04770032f, 0.00243066f, 
    0.00290980f, 0.09573987f, 0.08156541f, -0.27916780f, 0.07488991f, 0.12966126f, -0.05174717f, 0.09500912f, 
    -0.02748087f, 0.13913335f, 0.04119992f, -0.05415435f, 0.37166449f, -0.05839739f, -0.03697445f, -0.07947578f, 
    -0.08832397f, -0.03167919f, 0.13578132f, -0.01020890f, -0.14449747f, 0.00230885f, -0.08999848f, 0.00019187f, 
    0.33706307f, -0.06676122f, -0.02604535f, -0.07940449f, 0.01436779f, -0.02449488f, 0.04086968f, 0.16530839f, 
    0.13208087f, -0.10481464f, -0.12292054f, -0.04959636f, -0.53783506f, 0.14390558f, -0.08435347f, 0.14853716f, 
    -0.05767294f, 0.03975916f, 0.02994187f, 0.16881390f, 0.03316825f, 0.08286446f, 0.12284291f, 0.06143065f, 
    0.30683851f, 0.23063213f, 0.13184832f, -0.14551511f, 0.12264246f, -0.03719235f, -0.03425107f, 0.11515108f, 
    0.19426180f, 0.18095076f, -0.12903136f, -0.18767251f, 0.07818673f, 0.05804275f, -0.08260235f, 0.10213272f, 
    0.01691507f, -0.07566047f, -0.10445993f, -0.06708785f, 0.04792483f, -0.02951251f, -0.00661421f, 0.02011775f, 
    0.25761366f, 0.15548144f, 0.06736340f, 0.29521206f, -0.07895201f, 0.00127771f, 0.06196355f, 0.00846740f, 
    -0.00577399f, 0.01797185f, -0.10782272f, -0.07674026f, -0.10359456f, -0.05656711f, -0.28868321f, 0.22879021f, 
    0.13621764f, -0.01156166f, 0.06693280f, -0.22338887f, -0.00401083f, 0.12168329f, 0.05172594f, 0.17229791f, 
    0.28791609f, 0.37909964f, 0.11340748f, 0.14824338f, -0.07949726f, 0.08685002f, -0.10628796f, -0.10376090f, 
    -0.02630476f, 0.01029306f, 0.11041719f, -0.01709428f, -0.29899248f, -0.06995184f, -0.03940189f, 0.25731888f, 
    0.11045430f, -0.05905975f, 0.07319059f, -0.14553486f, 0.01785390f, 0.10626916f, -0.05109464f, 0.12169618f, 
    -0.11333496f, -0.17120832f, 0.08425531f, -0.20992784f, 0.11920732f, 0.00458885f, -0.05743600f, -0.05676695f, 
    -0.03267016f, -0.02521445f, 0.02484581f, -0.00112409f, 0.06555578f, 0.02186245f, -0.07310088f, -0.01823526f, 
    0.10282286f, 0.05431127f, 0.11547241f, 0.03886036f, -0.03835802f, -0.06681397f, 0.04348121f, 0.03908980f, 
    0.42351446f, -0.08575918f, 0.08286572f, -0.01232977f, -0.01239931f, 0.21605074f, 0.03724932f, -0.00276763f, 
    0.05137704f, -0.05292710f, 0.05269917f, -0.08747752f, -0.05360669f, -0.07703456f, -0.06405044f, -0.13744512f, 
    0.07664355f, 0.04108804f, -0.03054287f, 0.01765433f, 0.03955415f, 0.07152195f, 0.23192619f, 0.06922934f, 
    -0.10708576f, 0.33301935f, -0.10086189f, 0.14221811f, 0.20259881f, -0.03926340f, -0.01386979f, -0.01739786f, 
    0.13831817f, 0.09883028f, 0.03798421f, -0.15312716f, -0.11943340f, 0.04185102f, -0.14318064f, 0.17740655f, 
    0.07749804f, -0.05823603f, -0.01813111f, 0.04176262f, -0.16535087f, -0.07728626f, 0.15400331f, -0.05492917f, 
    -0.22529317f, 0.32719988f, 0.18090577f, -0.14631070f, 0.01406078f, 0.13044743f, -0.05082795f, 0.05596487f, 
    0.01232311f, -0.03867913f, -0.09235568f, -0.03132135f, -0.31954652f, 0.09248510f, 0.04135984f, 0.06720134f, 
    0.01505079f, -0.14678362f, -0.02276147f, -0.04367175f, -0.11539084f, 0.01057740f, -0.05058878f, -0.03685200f, 
    0.08359820f, -0.15413141f, 0.16430490f, 0.07102448f, 0.28096509f, -0.03123511f, -0.01327108f, 0.13556862f, 
    0.04395353f, 0.08272637f, -0.16234997f, 0.18900235f, -0.46419713f, -0.22290696f, -0.05961484f, -0.03486857f, 
    -0.07101820f, 0.12865622f, 0.05880167f, -0.00149720f, -0.00185734f, 0.12912926f, -0.09655890f, -0.02868270f, 
    -0.20126390f, 0.01274225f, -0.07488333f, -0.17568180f, -0.05783334f, -0.12054075f, -0.00451129f, 0.05657211f, 
    -0.20893517f, -0.15335225f, -0.04084796f, 0.02275940f, -0.09544842f, -0.15174046f, 0.08778720f, 0.10851099f, 
    0.04145599f, -0.08266202f, -0.09936168f, -0.01627576f, 0.06880319f, -0.00278816f, 0.17815644f, -0.06661589f, 
    -0.12529062f, -0.32491305f, -0.15727451f, 0.10564602f, 0.14013924f, -0.03238402f, 0.02277050f, 0.02515858f, 
    0.01378699f, -0.07195742f, 0.07703245f, -0.01174794f, 0.07855025f, -0.12408651f, 0.16618749f, 0.14654586f, 
    0.05028489f, -0.05453005f, -0.08434769f, -0.07595757f, 0.12384631f, 0.00704981f, 0.10059146f, 0.08994951f, 
    -0.07175909f, -0.00656142f, 0.12318204f, 0.10363147f, -0.09546032f, -0.00352675f, -0.03281913f, -0.01179737f, 
    -0.08256096f, -0.07754059f, 0.15663543f, -0.09647483f, 0.12436382f, 0.17670824f, 0.18538560f, 0.10577171f, 
    0.25930029f, 0.09610463f, 0.09613198f, -0.02770082f, 0.09661674f, 0.00520961f, -0.02311772f, 0.20843232f, 
    0.11799116f, 0.07902828f, 0.07961635f, -0.12688234f, 0.13288079f, 0.12463169f, 0.01384171f, -0.01740172f, 
    0.00527899f, 0.00765316f, -0.12063392f, 0.10840449f, -0.01005919f, 0.24802461f, 0.10270248f, 0.15823795f, 
    0.18960679f, 0.13953598f, -0.03639030f, -0.07276915f, 0.05078004f, -0.02787186f, 0.07634000f, -0.07815182f, 
    -0.04965527f, -0.03944875f, -0.18008190f, -0.05382261f, 0.02856491f, 0.13295247f, 0.20644297f, 0.06388789f, 
    0.10251483f, -0.06086569f, 0.00985984f, -0.00451936f, -0.02903867f, 0.00175523f, 0.11937340f, -0.08251382f, 
    -0.15145430f, -0.12450089f, -0.02884323f, 0.09902247f, 0.19778378f, -0.19691396f, 0.11530574f, 0.08117529f, 
    0.38145113f, -0.06526591f, 0.00663543f, 0.16950028f, 0.00116120f, -0.05218334f, -0.00229140f, -0.03077531f, 
    0.04496733f, 0.07190638f, -0.00084973f, -0.19449995f, 0.02336282f, -0.21809417f, 0.07433123f, 0.11692994f, 
    0.06220247f, 0.24517883f, 0.07512031f, 0.00150970f, 0.11296938f, 0.11783390f, 0.15537809f, 0.04222924f, 
    -0.50544292f, 0.05800438f, 0.16438434f, 0.10900161f, 0.08358964f, 0.10633603f, -0.04387152f, 0.05951140f, 
    -0.07493131f, 0.14702421f, 0.01701126f, -0.08692110f, -0.29745057f, -0.07554688f, 0.34032810f, -0.09821796f, 
    0.08431776f, -0.06189003f, 0.13752446f, -0.02300515f, -0.00502008f, -0.00882057f, -0.05019271f, 0.14515160f, 
    0.18337728f, -0.15159208f, -0.05208959f, 0.02534874f, 0.16017763f, 0.04986462f, -0.05490948f, -0.04281454f, 
    0.02168803f, 0.01013472f, -0.01359348f, -0.09452601f, -0.16263096f, 0.14916886f, 0.00327291f, -0.01216164f, 
    -0.05052851f, 0.00635042f, 0.01777304f, -0.09216022f, 0.14303860f, 0.01606307f, 0.15984273f, 0.15547213f, 
    0.12520991f, 0.12968147f, 0.49362406f, -0.03947177f, 0.06931815f, -0.06708909f, 0.04138165f, 0.09541342f, 
    -0.03175173f, -0.12083051f, 0.12084758f, 0.13162175f, -0.04559538f, 0.23645373f, -0.26454121f, 0.28718355f, 
    -0.10428971f, 0.15909770f, -0.21273831f, -0.03154657f, -0.00740086f, -0.05586437f, -0.12643781f, 0.14738306f, 
    -0.26783425f, -0.11445430f, 0.02000321f, -0.04547013f, -0.00013894f, 0.01694772f, -0.06458998f, -0.04577570f, 
    0.07800583f, -0.07040756f, -0.09621116f, 0.04217774f, -0.08194645f, -0.02557801f, -0.27537036f, 0.40524447f, 
    -0.01706042f, 0.00287202f, -0.14639211f, 0.02115458f, 0.04006715f, -0.07815973f, 0.00628763f, -0.01759504f, 
    -0.05887817f, 0.01739655f, 0.07136976f, -0.08587693f, 0.04653588f, 0.00362709f, 0.04603970f, -0.01135170f, 
    -0.10778893f, -0.06616180f, 0.11457671f, 0.14337453f, -0.23419671f, -0.02207117f, 0.08917128f, 0.16909951f, 
    0.12224529f, 0.03899231f, -0.05069264f, -0.12460241f, 0.05899461f, 0.05015708f, 0.02954615f, 0.13952287f, 
    0.15056643f, -0.15570711f, 0.01695395f, -0.02453141f, 0.00224150f, -0.00298010f, -0.03127289f, -0.26242074f, 
    0.04395374f, 0.00023043f, -0.03043090f, 0.09749451f, 0.07897732f, -0.03214753f, -0.07445827f, -0.05064343f, 
    0.17554617f, 0.19119351f, -0.01565238f, -0.02827386f, 0.03243075f, 0.02704731f, -0.09816711f, -0.00160217f, 
    -0.47254753f, 0.28045395f, -0.02908443f, 0.18628128f, 0.02378863f, -0.05667537f, 0.11156170f, -0.03446179f, 
    -0.01912844f, 0.07666698f, -0.09827064f, 0.04546356f, -0.08190694f, 0.20151158f, 0.18936168f, 0.17134348f, 
    -0.03012371f, -0.05787221f, 0.03299223f, -0.04877643f, 0.24415493f, 0.02158475f, 0.13703422f, -0.05993456f, 
    0.19520043f, 0.08195845f, -0.06024482f, 0.15228428f, -0.09231958f, 0.03157406f, -0.17215407f, 0.09276820f, 
    0.24609287f, -0.00129447f, 0.08412237f, -0.09688637f, 0.45290941f, 0.11588718f, -0.15594481f, 0.07009315f, 
    -0.04405503f, -0.02820877f, 0.00396807f, 0.06804994f, 0.03989514f, -0.00457912f, 0.15071125f, 0.06961980f, 
    -0.08104403f, 0.14241856f, -0.10705453f, -0.17229261f, 0.12287712f, 0.01647983f, -0.07359655f, -0.00214264f, 
    -0.09428701f, 0.06010093f, 0.08937498f, -0.02707905f, 0.33888438f, -0.08164399f, -0.03342083f, 0.07390524f, 
    -0.03691042f, 0.07383277f, 0.02938380f, -0.07452948f, -0.10271271f, -0.09277199f, 0.03936823f, -0.16686165f, 
    0.20069808f, 0.01363975f, 0.12614697f, 0.04750413f, 0.04099778f, -0.10716141f, -0.01251025f, 0.19352953f, 
    0.02948604f, -0.04333865f, -0.12147598f, 0.04396874f, -0.32547608f, 0.01119263f, 0.03249136f, 0.04768922f, 
    0.00090886f, 0.14444332f, -0.03554834f, 0.10157186f, -0.06800023f, 0.06723531f, -0.02861723f, 0.05727335f, 
    -0.25367233f, -0.06415469f, -0.33083320f, -0.41966555f, 0.05325379f, -0.06161356f, -0.00925094f, -0.08446424f, 
    0.23474723f, 0.00194520f, 0.05542812f, 0.01079017f, 0.08668925f, 0.31655177f, -0.07700800f, 0.18850307f, 
    -0.08852348f, -0.02107382f, 0.01159954f, -0.09323578f, 0.08778141f, -0.05274852f, -0.00065291f, -0.03835730f, 
    0.11980782f, -0.31300494f, 0.06902620f, -0.00760567f, -0.02274087f, -0.02415801f, 0.09801348f, 0.01618916f, 
    -0.01024605f, -0.10494278f, -0.00315983f, 0.01638455f, 0.16982976f, 0.17687778f, 0.00616232f, 0.10251848f, 
    0.11791466f, 0.18222362f, 0.03142105f, -0.04002266f, 0.06685363f, 0.06741083f, -0.13271913f, -0.07654172f, 
    -0.09242261f, 0.14411503f, -0.04083755f, -0.16844104f, -0.17668392f, -0.02933350f, -0.09594445f, -0.18959583f, 
    0.04341201f, 0.03446887f, -0.03557197f, 0.02079400f, -0.11441128f, 0.23938589f, 0.07757348f, 0.02447300f, 
    0.07142203f, -0.03858208f, 0.06938164f, -0.08049996f, 0.06255261f, 0.10750703f, 0.01134854f, 0.04671028f, 
    0.23096558f, 0.06960370f, 0.28420186f, 0.04130170f, 0.09165114f, 0.06681837f, -0.09614500f, 0.07969282f, 
    0.10356422f, 0.07591790f, 0.05838342f, -0.03622521f, -0.23217854f, 0.26515365f, -0.13593847f, 0.13454755f, 
    0.11118653f, 0.09899424f, 0.15371501f, 0.07650413f, 0.02081437f, 0.09627666f, -0.10014484f, 0.07143459f, 
    0.38423559f, -0.18582980f, 0.02062769f, -0.08463200f, -0.03857985f, 0.10979868f, 0.05371658f, 0.06642170f, 
    0.05778787f, -0.11464421f, 0.08945132f, 0.07442529f, -0.09402473f, 0.05293335f, 0.07736468f, -0.05097265f, 
    -0.07485183f, 0.07081029f, -0.00737878f, 0.06395785f, 0.00545433f, -0.01780675f, 0.19354296f, -0.01854046f, 
    0.04408609f, 0.20802313f, -0.18914177f, -0.15543342f, 0.21182695f, -0.03766374f, 0.10122494f, -0.10216735f, 
    0.05812904f, -0.03309087f, -0.01773418f, -0.09136122f, -0.17948140f, -0.10479631f, -0.14185709f, -0.01703064f, 
    0.14894637f, 0.02632557f, -0.12165451f, -0.10606347f, 0.03357581f, -0.00164505f, -0.01076177f, -0.05510022f, 
    0.15591635f, -0.06580392f, -0.04720753f, -0.01335738f, -0.05173317f, 0.01078547f, 0.00893169f, 0.02518751f, 
    -0.07363389f, 0.01294359f, -0.13537705f, 0.12398549f, -0.22998615f, -0.17152664f, 0.24758244f, -0.09627877f, 
    -0.02263885f, -0.15418020f, 0.02326303f, 0.00471172f, 0.09463911f, 0.05241972f, -0.06229328f, 0.09885690f, 
    -0.12522258f, -0.02198403f, -0.00687841f, -0.09679880f, 0.13452739f, 0.03620911f, 0.06953912f, -0.07804094f, 
    0.01524306f, -0.03884394f, -0.08386257f, -0.16311046f, 0.00641965f, -0.13484372f, 0.00843466f, 0.08452395f, 
    0.03963057f, -0.02419890f, 0.19415683f, -0.12440929f, 0.17257892f, 0.08919933f, -0.05546404f, -0.02280878f, 
    0.08335520f, -0.05647447f, 0.36657050f, 0.28149843f, -0.03327345f, 0.01604449f, -0.05778742f, 0.02685583f, 
    -0.14307277f, 0.04195108f, 0.09611779f, -0.03019954f, 0.04120759f, -0.05583616f, 0.01288841f, -0.04032233f, 
    0.09109846f, 0.03816236f, -0.13053824f, 0.00131734f, 0.01210336f, 0.01652867f, 0.03957374f, -0.12414648f, 
    -0.33586353f, 0.29604271f, 0.05590066f, 0.13872355f, 0.09314743f, 0.13433276f, -0.02761281f, -0.05754584f, 
    -0.03503569f, 0.17650293f, 0.00288398f, -0.04588685f, 0.07424131f, 0.03761338f, -0.00173720f, 0.22605634f, 
    0.03189552f, 0.04644134f, 0.01353922f, 0.07168134f, -0.03901211f, -0.03255675f, 0.06916922f, 0.07513340f, 
    -0.09485809f, 0.07214349f, 0.03971152f, 0.35631862f, 0.19511688f, -0.03403975f, 0.05713518f, 0.05812887f, 
    -0.03419682f, 0.04043768f, 0.00486093f, -0.02017424f, 0.37478152f, -0.12811935f, 0.04542538f, 0.39431804f, 
    -0.11171944f, 0.14055400f, 0.03581900f, 0.02224114f, 0.03412137f, -0.09028627f, 0.13075748f, 0.01972503f, 
    0.05513176f, 0.32030389f, 0.04060960f, -0.12065046f, -0.10105879f, 0.05226649f, 0.11502842f, -0.05897630f, 
    -0.02279864f, -0.00643689f, -0.03795346f, -0.01923753f, 0.32973590f, -0.06932183f, 0.14207286f, -0.14647517f, 
    -0.05436257f, 0.03574957f, -0.03655789f, 0.09527954f, 0.06960360f, -0.06511305f, 0.14523838f, 0.01586188f, 
    -0.56360519f, 0.28367379f, 0.11183231f, -0.21840802f, 0.14727943f, 0.04807252f, 0.11645399f, -0.03356067f, 
    -0.05379792f, -0.00787424f, -0.01509857f, -0.04659268f, 0.29099068f, -0.05359319f, -0.27000427f, 0.15461668f, 
    0.03305534f, -0.03484208f, -0.10843955f, 0.04900296f, -0.09648198f, -0.16340652f, -0.05673704f, -0.01416889f, 
    0.32655236f, 0.20067647f, -0.08920351f, 0.28385907f, -0.11122578f, -0.12992108f, -0.13543060f, -0.04754229f, 
    0.05505918f, 0.00891950f, 0.01264529f, -0.02716216f, 0.19615322f, 0.02268750f, 0.13683374f, 0.07767677f, 
    -0.06516758f, -0.03555826f, -0.07883382f, -0.04137099f, 0.01641444f, -0.12968190f, 0.03650408f, 0.02780335f, 
    -0.22255936f, -0.05885324f, -0.24412464f, -0.04812871f, 0.01109518f, -0.07334010f, 0.02462081f, 0.09380413f, 
    0.18674615f, 0.07688333f, -0.01626140f, -0.11910795f, 0.03782315f, 0.02598225f, -0.12152000f, 0.07338271f, 
    0.13831055f, -0.05953969f, 0.17799921f, -0.02013783f, -0.03557912f, -0.07761442f, 0.14089701f, 0.20951338f, 
    0.43314424f, -0.05605188f, -0.14749812f, 0.07321379f, 0.01663798f, 0.17891164f, 0.26693761f, 0.15720645f, 
    -0.17055619f, -0.00164136f, 0.09461336f, 0.14277726f, 0.17710687f, 0.07542416f, -0.02039532f, 0.26117948f, 
    -0.04432996f, 0.01812415f, -0.05168096f, 0.04356858f, 0.11788450f, -0.06440289f, 0.28788316f, -0.03537169f, 
    -0.25318396f, -0.15862249f, -0.19248462f, -0.18364817f, -0.07579105f, -0.34535882f, -0.04577155f, -0.06802315f, 
    0.06609187f, -0.02998980f, -0.04003573f, -0.13706012f, 0.33074817f, 0.21823585f, -0.02986089f, 0.00250597f, 
    0.17166668f, 0.29207012f, 0.08207853f, 0.03821679f, 0.04764038f, -0.13191190f, -0.03107264f, 0.21563622f, 
    -0.31776470f, 0.23640835f, 0.04657410f, 0.36898676f, -0.28864801f, -0.09924211f, -0.19436975f, 0.04638173f, 
    0.01790761f, -0.00525052f, -0.06931648f, -0.07361073f, -0.14198798f, 0.10641077f, 0.01612114f, 0.03029921f, 
    0.21559013f, -0.02616881f, 0.07763713f, -0.15494096f, -0.13203652f, 0.03671307f, 0.05296805f, 0.02870958f, 
    -0.18579358f, 0.24452354f, -0.19394749f, 0.03086024f, -0.24630582f, -0.34030780f, -0.08182508f, -0.00846768f, 
    -0.07651950f, -0.07836414f, 0.02790499f, -0.06640696f, -0.31502619f, -0.16395760f, -0.17852435f, 0.19441994f, 
    0.29341063f, 0.10868000f, 0.11309168f, -0.19057906f, -0.07157259f, 0.04829300f, -0.02271272f, 0.09635154f, 
    0.00785333f, -0.08034468f, -0.00173049f, 0.03261672f, 0.13813494f, -0.05131977f, -0.07491834f, 0.02452266f, 
    0.05289451f, 0.20390198f, 0.07179327f, 0.06880229f, 0.21603569f, 0.12637892f, -0.01913792f, -0.23547928f, 
    0.05218899f, 0.19702806f, 0.08658691f, 0.00909073f, 0.14853974f, -0.01332532f, 0.02395102f, 0.15508936f, 
    0.04188972f, 0.01013946f, -0.03694887f, 0.14282458f, 0.04887432f, -0.12552153f, -0.10349990f, 0.04958808f, 
    0.08058842f, -0.02029634f, 0.05428541f, -0.05762726f, 0.21381523f, -0.10079141f, 0.20051408f, 0.20038164f, 
    0.18232621f, 0.16395634f, -0.07429865f, 0.13994825f, 0.17422108f, -0.08329441f, -0.00566533f, 0.03819114f, 
    -0.23790210f, 0.25548750f, -0.11249246f, 0.04886919f, -0.02136430f, -0.03012772f, -0.14473858f, -0.04829399f, 
    0.13243438f, 0.16086741f, -0.08721295f, -0.00246424f, -0.33695567f, -0.34205568f, -0.07637820f, -0.38571092f, 
    -0.04655750f, -0.21090554f, -0.03730589f, -0.13630922f, -0.15650424f, -0.12939915f, 0.10753173f, -0.00925135f, 
    0.03134492f, 0.05539798f, -0.00357838f, 0.04523741f, 0.02380008f, 0.01952843f, 0.06012550f, 0.01989839f, 
    -0.05261381f, -0.06451084f, -0.00760122f, 0.03134812f, 0.03281671f, 0.03414364f, 0.02210004f, 0.05018616f, 
    -0.04560779f, -0.05203582f, 0.03759941f, -0.02212352f, 0.04729082f, -0.02975962f, 0.00338804f, 0.03161211f, 
    0.02596197f, -0.04662659f, 0.05634029f, -0.04917322f, -0.03933385f, -0.02750578f, -0.06397673f, -0.05782038f, 
    0.00202928f, -0.03245239f, -0.06002983f, -0.00125655f, -0.04861720f, -0.01999263f, 0.00254930f, -0.00466044f, 
    -0.04352505f, -0.07077612f, -0.07384109f, 0.01634678f, -0.04770068f, 0.04743294f, -0.04666831f, -0.05970478f, 
    -0.04247591f, 0.02713026f, 0.00918170f, -0.05962895f, -0.02191405f, -0.05900799f, 0.00954633f, -0.05245573f, 
    -0.00712433f, -0.01750458f, 0.05009960f, -0.03768501f, 0.06811111f, 0.06121403f, 0.00356372f, 0.02955907f, 
    0.05910756f, 0.03988134f, 0.00635899f, 0.03203222f, -0.01148018f, 0.00844870f, 0.07276796f, -0.03118347f, 
    0.05000174f, 0.04470105f, -0.05980808f, 0.05046827f, -0.03311898f, 0.01693216f, -0.03882949f, -0.07154908f, 
    -0.05548068f, -0.05178706f, -0.05419865f, 0.06279453f, -0.05854989f, -0.07756115f, -0.03573646f, 0.01902749f, 
    -0.02177876f, 0.00737794f, -0.00578682f, 0.05872581f, -0.01435872f, 0.02021326f, -0.07044004f, -0.04914471f, 
    -0.00940851f, -0.07379138f, 0.03325426f, -0.03886122f, 0.05696993f, -0.06432018f, -0.01715787f, 0.03572075f, 
    0.01527784f, 0.01698068f, 0.03405666f, 0.00697593f, -0.07388099f, -0.05340335f, 0.02879715f, 0.05594747f, 
    0.02324378f, -0.00632171f, -0.00724966f, -0.04423678f, -0.02242457f, 0.01648991f, 0.05186494f, -0.05423684f, 
    -0.04551231f, -0.04162093f, 0.04510825f, -0.05500528f, 0.04452734f, -0.03381426f, -0.04289583f, 0.04919785f, 
    0.03536098f, 0.06282052f, -0.06905667f, -0.07168294f, 0.05083330f, -0.03875537f, -0.04683218f, 0.01421257f, 
    -0.06985652f, 0.01754724f, 0.00709739f, 0.03375724f, 0.06033910f, -0.05184177f, 0.00463923f, -0.03466699f, 
    -0.05492583f, -0.04128323f, 0.00148872f, -0.04133486f, 0.05617763f, 0.01421479f, -0.02393522f, -0.05920415f, 
    -0.02050349f, -0.06556913f, -0.04813368f, 0.00367119f, -0.05452861f, -0.03516593f, 0.05905295f, 0.03647578f, 
    -0.01293545f, -0.01549837f, -0.06845839f, 0.00398982f, -0.08007900f, 0.01970516f, 0.04906822f, -0.05880539f, 
    0.03681953f, 0.02585351f, -0.01313487f, 0.00247882f, 0.01560449f, -0.07765742f, 0.05103073f, -0.07781807f, 
    0.03236269f, 0.03015783f, -0.00056897f, 0.00147562f, -0.03481119f, -0.01444481f, -0.01601462f, -0.03274498f, 
    0.02605871f, -0.00595248f, 0.03661412f, -0.04492214f, 0.03626111f, -0.02744016f, 0.06245482f, 0.04558598f, 
    -0.04665356f, -0.00770815f, 0.22549550f, -0.47453561f, 0.10170091f, -0.00743135f, 0.09320651f, 0.15691595f, 
    0.03941869f, 0.06976073f, -0.03855314f, 0.07020458f, 0.22276241f, 0.16373017f, -0.11336017f, -0.33163202f, 
    0.10855484f, 0.06339860f, 0.17050509f, 0.18931513f, 0.00739397f, 0.01379938f, 0.05174636f, 0.12625375f, 
    -0.33643517f, -0.01146720f, -0.07895184f, -0.21499856f, 0.07640393f, -0.05162536f, 0.01246642f, -0.06080792f, 
    0.02031579f, -0.19401026f, -0.02371612f, -0.04671272f, -0.08387403f, -0.29391602f, 0.12717158f, 0.27706292f, 
    -0.13486722f, 0.03305238f, -0.04766146f, -0.00504069f, 0.05025294f, 0.04874209f, 0.06481545f, 0.11787108f, 
    0.22782923f, 0.31969944f, -0.00992156f, 0.06089910f, 0.13397174f, -0.01829935f, 0.20186611f, -0.07308825f, 
    0.16172363f, -0.00622911f, 0.12885574f, 0.06530605f, -0.06014051f, 0.17094575f, 0.10482952f, 0.35845974f, 
    0.12921749f, 0.16894110f, -0.02495764f, 0.02101728f, 0.11257176f, 0.09970889f, -0.10941638f, 0.08774113f, 
    -0.06311928f, -0.08712520f, -0.21078908f, -0.10303207f, -0.04204812f, -0.00603318f, -0.08288341f, -0.12435137f, 
    -0.07077610f, 0.04770542f, -0.15032175f, -0.04333358f, 0.18206896f, 0.02103804f, -0.25964078f, -0.16778150f, 
    0.23894680f, 0.11722929f, 0.11233480f, 0.01294617f, -0.04359199f, -0.11048049f, 0.00384027f, 0.05249247f, 
    -0.29365167f, -0.01882473f, -0.34591910f, -0.02116131f, -0.16081652f, -0.00019787f, -0.08277797f, -0.11040897f, 
    0.05025975f, 0.00728522f, 0.09979479f, -0.06824196f, -0.16772705f, 0.15348688f, -0.14629924f, -0.01621410f, 
    -0.03086196f, 0.05893805f, 0.01541440f, 0.01629169f, -0.03912657f, 0.04612753f, 0.07047962f, 0.22607060f, 
    -0.74202615f, 0.13738827f, 0.07913966f, -0.48779723f, 0.10348318f, 0.04643213f, 0.01386213f, -0.11215226f, 
    0.04010439f, 0.06959629f, 0.05096831f, 0.03388897f, 0.23739256f, -0.11792514f, 0.04764456f, 0.24536796f, 
    -0.00507081f, 0.09900155f, 0.02700689f, 0.10564443f, -0.00550047f, 0.04941758f, -0.00070444f, 0.19489200f, 
    -0.03227308f, -0.15060262f, -0.07552492f, 0.11576451f, 0.09788615f, -0.05976966f, -0.07047720f, -0.00766318f, 
    -0.00803479f, 0.09737398f, 0.00924718f, -0.09025830f, 0.04976177f, -0.05594864f, -0.13867614f, -0.12585865f, 
    0.09853981f, 0.00342803f, -0.08933824f, 0.11665501f, 0.00297211f, 0.03953999f, 0.02212368f, 0.00225597f, 
    -0.17155708f, 0.31273788f, -0.00658672f, 0.34907961f, 0.08390813f, 0.29023063f, 0.00432382f, 0.04203396f, 
    0.11856277f, 0.04237497f, 0.04769384f, 0.12650238f, 0.17594086f, -0.01369839f, 0.12069509f, 0.24508207f, 
    0.04334184f, -0.04522611f, -0.02361832f, -0.04020191f, -0.02792797f, -0.18394491f, 0.00790417f, 0.06050075f, 
    0.10410903f, 0.03950119f, 0.04862465f, 0.17040467f, -0.09393220f, -0.00687842f, -0.00546195f, 0.04347908f, 
    0.08882102f, 0.15686823f, 0.19770461f, 0.04334112f, 0.13705419f, 0.00893492f, 0.05983909f, -0.07639518f, 
    -0.06309219f, -0.03694457f, 0.10255948f, -0.08829658f, 0.00573734f, -0.03191470f, 0.00008306f, 0.29378498f, 
    0.49059719f, 0.05286929f, -0.06774267f, -0.14933059f, -0.06920158f, -0.09926961f, -0.03537257f, -0.07847539f, 
    0.19702686f, 0.09625344f, -0.14579669f, -0.16434586f, -0.19964285f, 0.11686802f, 0.06976106f, 0.01840740f, 
    0.05670159f, -0.02394883f, 0.12116733f, -0.03385513f, 0.10760672f, 0.01283971f, 0.08416477f, -0.03325011f, 
    0.35579205f, -0.06988584f, 0.06655620f, 0.13637206f, 0.06951028f, 0.01139626f, 0.02158954f, 0.22929761f, 
    -0.14813972f, 0.02813042f, -0.05452963f, -0.04822879f, 0.29524601f, -0.00014730f, -0.22359869f, -0.04861314f, 
    -0.11106272f, 0.03494695f, -0.09991782f, -0.22869499f, -0.17788155f, -0.15318479f, -0.03535884f, 0.15716408f, 
    -0.17911057f, 0.18533111f, 0.08422092f, 0.22019258f, 0.10987319f, 0.11222314f, -0.15595235f, 0.01723769f, 
    0.01129126f, -0.10830761f, -0.11116106f, 0.04063654f, -0.32024530f, -0.04446456f, 0.09978038f, 0.26451704f, 
    -0.00431282f, 0.06398030f, 0.07605913f, -0.05820850f, 0.02769697f, 0.00810039f, 0.06733630f, 0.12082508f, 
    0.04925605f, -0.02007978f, 0.08821319f, 0.26278144f, 0.20663479f, 0.15394576f, -0.06185196f, 0.23702930f, 
    0.01123875f, -0.03274514f, 0.17436571f, 0.21802326f, -0.11952333f, 0.01681837f, 0.11062068f, 0.17238934f, 
    0.09432687f, 0.07134768f, 0.00712621f, -0.07349569f, -0.07897504f, 0.14817022f, -0.09585983f, 0.07541091f, 
    0.12527199f, -0.19801150f, 0.12912184f, 0.08454338f, -0.02219277f, -0.00224684f, -0.09330392f, -0.03848451f, 
    -0.05276896f, 0.05375540f, -0.04813788f, -0.00662250f, -0.08545547f, -0.14098391f, 0.20392054f, 0.04962749f, 
    -0.03840986f, 0.04997730f, -0.00613499f, 0.03883851f, 0.10167346f, -0.11885210f, -0.07032821f, -0.16636027f, 
    -0.65833098f, 0.11121362f, 0.04613591f, -0.18089373f, 0.00317322f, 0.04074494f, -0.03553843f, -0.06477587f, 
    0.00372823f, 0.04489629f, 0.11322016f, -0.07344447f, -0.13637380f, -0.01422476f, 0.15001032f, 0.19670993f, 
    -0.01417477f, 0.04853051f, -0.03905354f, 0.12777971f, 0.19240758f, 0.01871353f, 0.06977206f, -0.09257130f, 
    -0.19733047f, -0.06559660f, 0.15102988f, -0.02386154f, -0.12806588f, -0.19310708f, -0.10234767f, 0.09003454f, 
    0.11717717f, 0.04506905f, 0.09193398f, -0.05175167f, -0.14590444f, 0.06447836f, -0.07390504f, -0.14973009f, 
    -0.03944280f, -0.00831139f, -0.21203907f, -0.05612404f, -0.17045873f, -0.05432579f, 0.17534316f, 0.06861825f, 
    0.25429347f, 0.10520506f, -0.10556988f, 0.20004678f, 0.11532260f, 0.11080859f, 0.04178242f, -0.13403133f, 
    -0.05371903f, 0.05185000f, 0.07841718f, -0.06225303f, -0.05113115f, -0.03487854f, 0.27086726f, 0.14209694f, 
    0.18881799f, 0.07250212f, -0.03520513f, -0.11069972f, 0.08060075f, 0.03291843f, -0.08221095f, 0.04344827f, 
    0.03760120f, 0.11246503f, 0.14029230f, -0.09475375f, -0.09011550f, -0.04163071f, -0.02041941f, 0.04693809f, 
    0.10949322f, -0.00199736f, -0.16088931f, 0.10071438f, 0.10904597f, 0.28637367f, 0.03076736f, -0.15826230f, 
    -0.00422010f, -0.08193962f, 0.13180816f, 0.01741900f, 0.07784067f, -0.07993278f, -0.06911925f, -0.00239662f, 
    0.13590869f, 0.10091336f, 0.18072885f, 0.29592437f, -0.06869626f, -0.02743424f, -0.04391742f, 0.11751827f, 
    -0.16451427f, 0.04724383f, 0.10314745f, -0.00278446f, 0.02669255f, -0.28731892f, -0.10534538f, -0.19257928f, 
    -0.05867519f, 0.02311348f, 0.06809433f, -0.13004459f, -0.00248970f, 0.00456019f, -0.00865463f, 0.05731545f, 
    0.20376399f, 0.03342244f, -0.07729164f, -0.25829342f, 0.06094733f, 0.09568486f, 0.08473402f, 0.01587741f, 
    0.02847876f, -0.01726372f, 0.01040395f, 0.05066469f, -0.07043183f, -0.15105380f, 0.24694306f, 0.30532563f, 
    -0.24235341f, -0.15504842f, -0.00719149f, 0.11006311f, -0.03969330f, 0.05992954f, 0.04129922f, 0.20107263f, 
    0.13330305f, -0.17333248f, -0.02648233f, 0.01953603f, 0.05575924f, 0.00597544f, 0.14565383f, 0.17876519f, 
    0.04475652f, 0.09654911f, -0.00838666f, 0.07856590f, 0.11711545f, -0.03793384f, 0.19716588f, 0.13497256f, 
    -0.04937580f, 0.01219225f, 0.13296862f, 0.16203901f, -0.04729016f, -0.03115163f, 0.10273059f, -0.13945998f, 
    0.31143746f, -0.19400460f, 0.01863796f, 0.08920716f, -0.20734571f, 0.06163025f, 0.01762247f, 0.02171838f, 
    -0.09822068f, -0.04513133f, -0.02748284f, -0.05168443f, -0.47693172f, 0.15284072f, 0.03676045f, 0.08563182f, 
    -0.01961171f, -0.04543881f, -0.09096750f, 0.04626681f, -0.00413792f, 0.02421520f, 0.03573581f, -0.08180743f, 
    -0.33836612f, 0.20658627f, 0.08219647f, -0.19925450f, 0.10511830f, 0.04294766f, 0.13906369f, 0.03449393f, 
    -0.11098108f, 0.00859015f, -0.04560338f, 0.05604881f, -0.09258322f, -0.26947269f, 0.00233254f, 0.25035608f, 
    0.01099617f, -0.01089184f, 0.10600966f, 0.21736322f, 0.00984877f, 0.09147066f, -0.00722903f, -0.02788474f, 
    0.33984068f, -0.45028317f, 0.21437618f, -0.15099549f, 0.08759321f, -0.15287164f, 0.19646780f, -0.00757981f, 
    0.00222898f, -0.01394346f, -0.07217608f, 0.05794426f, 0.28619593f, 0.06247350f, 0.03830858f, 0.20184246f, 
    0.02014358f, 0.03451274f, 0.05727172f, 0.14677045f, 0.02428104f, 0.02542283f, -0.06440409f, -0.00094615f, 
    0.17923424f, 0.16520914f, -0.04559803f, -0.02434159f, 0.12225025f, 0.10518112f, 0.12997295f, 0.01250474f, 
    -0.07942227f, 0.18075350f, 0.11423722f, 0.13030583f, 0.26967427f, 0.14215612f, 0.04097351f, -0.06684712f, 
    0.11890600f, 0.20365866f, -0.02009642f, 0.24847054f, -0.02396300f, -0.08083118f, 0.04975485f, 0.00017585f, 
    -0.05571970f, 0.16462997f, 0.04026507f, -0.19467749f, -0.15649641f, -0.10702825f, 0.08027057f, -0.02179792f, 
    0.02283648f, -0.11508930f, 0.10070618f, 0.07706531f, 0.52358955f, 0.08026503f, -0.01278264f, -0.09747478f, 
    -0.14063887f, -0.11624779f, 0.02395780f, 0.06953401f, 0.01179713f, 0.06518219f, -0.11823521f, 0.05358341f, 
    0.21062008f, 0.11548955f, -0.14037344f, 0.02780274f, 0.04778739f, -0.04589576f, 0.09520166f, -0.13807522f, 
    -0.09405071f, 0.09273455f, 0.17126000f, 0.15848391f, -0.05443537f, -0.04082634f, -0.07095186f, 0.01160763f, 
    -0.10750352f, -0.00328959f, 0.21428689f, -0.02740907f, 0.22143845f, -0.00117316f, -0.10177006f, 0.12423579f, 
    -0.01708366f, -0.30166233f, -0.08407035f, -0.21595253f, 0.04181144f, -0.05194111f, 0.00036308f, 0.15181616f, 
    -0.03692921f, -0.00523931f, 0.02134418f, -0.00365079f, -0.23429945f, -0.02853403f, 0.10818566f, -0.11779291f, 
    -0.12556879f, 0.08918758f, 0.03832757f, 0.05572126f, 0.00443921f, -0.08619742f, 0.01555434f, 0.01124086f, 
    -0.05053468f, -0.33227602f, -0.27455327f, -0.18115197f, -0.10451011f, -0.09056496f, 0.06298175f, 0.13337331f, 
    0.06170658f, 0.18052047f, -0.09911854f, 0.06388701f, -0.33571088f, 0.25206268f, 0.29611379f, -0.43672767f, 
    0.01582181f, 0.06502361f, -0.01758694f, 0.21996129f, 0.09445921f, -0.06971971f, 0.02539164f, 0.03924299f, 
    -0.38584688f, 0.11868027f, -0.09416936f, -0.39899224f, -0.05562825f, 0.10783140f, 0.12320367f, -0.02612981f, 
    -0.05746748f, 0.08633602f, 0.01649542f, 0.03334126f, -0.43773198f, -0.01782469f, 0.07165652f, 0.20513795f, 
    0.00695989f, 0.15135089f, -0.01580227f, 0.10072114f, -0.09165090f, 0.05487638f, -0.05693913f, 0.11374852f, 
    0.08802362f, -0.31439999f, -0.08497940f, 0.06858158f, -0.11969467f, -0.06950638f, -0.05205850f, 0.12112746f, 
    -0.05345307f, 0.15087026f, 0.12307574f, -0.00885081f, -0.22305894f, 0.18038987f, 0.08222982f, -0.00023790f, 
    0.14304787f, 0.03326492f, 0.06492908f, 0.15298031f, 0.06947016f, 0.13918363f, 0.11000079f, -0.05160001f, 
    -0.20324422f, -0.45373210f, 0.53215921f, -0.05002387f, 0.05876482f, 0.18388511f, 0.21194214f, -0.02343108f, 
    0.10416105f, -0.05174839f, 0.11177459f, 0.12648976f, 0.06227944f, 0.11438692f, 0.38347420f, 0.15743522f, 
    0.14657277f, -0.05544297f, -0.01390896f, 0.00596305f, -0.06370249f, -0.04614496f, -0.04774209f, 0.14610997f, 
    -0.00356530f, 0.02750491f, -0.03501723f, -0.04529428f, 0.03578442f, -0.02749890f, 0.01579189f, -0.03013231f, 
    -0.01589936f, -0.01799722f, 0.01533923f, 0.03914752f, 0.05525544f, 0.02212568f, 0.03844396f, 0.03546434f, 
    0.00654863f, -0.05384207f, -0.02281568f, -0.07319797f, 0.06280321f, -0.03712432f, 0.05989370f, -0.07957742f, 
    0.03528978f, 0.00887092f, 0.01618272f, 0.04954161f, -0.04576710f, -0.01629083f, 0.04406788f, -0.05273936f, 
    0.05641877f, 0.04200063f, 0.02903134f, 0.04947796f, -0.01680056f, 0.02547922f, -0.06797621f, -0.00128456f, 
    -0.07582035f, 0.01670028f, 0.01784929f, 0.03320097f, -0.06605937f, -0.05744426f, -0.02254038f, 0.05132262f, 
    -0.02285230f, -0.04042156f, 0.05457143f, 0.05876245f, -0.07610579f, 0.01726522f, -0.01041285f, -0.05221432f, 
    -0.03810798f, 0.01646701f, -0.04643942f, -0.00057001f, 0.03746342f, -0.06246948f, -0.07245080f, 0.02672121f, 
    -0.05592716f, -0.03487170f, -0.03940617f, 0.00519754f, -0.00108924f, 0.04413690f, 0.00481788f, -0.06730972f, 
    -0.04780045f, -0.08002678f, -0.03280364f, -0.02061017f, -0.05429253f, -0.02338229f, 0.04729645f, -0.04749802f, 
    0.00098711f, 0.04004703f, -0.05043114f, 0.01446138f, 0.04111113f, 0.05944824f, 0.06011451f, 0.03519941f, 
    -0.04087098f, 0.00215508f, 0.03654925f, -0.02602189f, 0.04543709f, -0.03135268f, -0.01133803f, -0.01439524f, 
    0.03780233f, 0.03183417f, 0.04380945f, -0.03883453f, -0.07273866f, 0.01128262f, 0.05306951f, -0.02437322f, 
    -0.03565538f, 0.02373965f, -0.03323770f, -0.02406108f, -0.04629759f, -0.06339715f, -0.02965434f, 0.02864251f, 
    0.05020389f, -0.03051886f, -0.01594781f, 0.01730483f, 0.02604561f, 0.05590952f, -0.00619379f, -0.06481018f, 
    -0.04918530f, -0.02493707f, -0.04657291f, 0.03291640f, 0.01270579f, -0.03981607f, -0.07139001f, -0.01267051f, 
    -0.04579309f, -0.03687552f, -0.00182113f, -0.06737539f, -0.04557619f, -0.01992711f, -0.04029368f, 0.04327367f, 
    0.01001012f, -0.02947203f, -0.01125118f, -0.02869890f, 0.04333382f, -0.01433496f, -0.06673822f, -0.02681465f, 
    0.04647913f, 0.01561602f, -0.03906588f, 0.01293198f, -0.07177235f, -0.07108390f, -0.01010423f, -0.05304870f, 
    -0.03871946f, 0.06166883f, -0.07774396f, -0.07699782f, -0.07789328f, 0.01752391f, -0.00926870f, -0.03503903f, 
    -0.06943248f, 0.01995975f, -0.07406625f, -0.00796005f, -0.01079499f, -0.01252682f, -0.04153745f, 0.01849445f, 
    -0.06222672f, 0.00891705f, -0.07816420f, 0.04984339f, 0.01211231f, 0.05715076f, 0.00848352f, -0.06088194f, 
    -0.04839805f, -0.02023040f, 0.01177691f, 0.00007805f, -0.07310221f, 0.02505150f, -0.02124082f, -0.05643582f, 
    0.01294104f, 0.01407625f, -0.04465674f, -0.03897351f, 0.02910378f, 0.04947604f, -0.07564121f, -0.06478778f, 
    0.06779514f, 0.08722659f, 0.39835852f, -0.10399381f, -0.08469023f, 0.07208993f, -0.03478972f, -0.01542676f, 
    -0.00985657f, 0.18640386f, 0.04035284f, 0.12882018f, -0.04879234f, -0.07037435f, -0.09605627f, -0.25897625f, 
    0.03753876f, -0.04582235f, -0.06084346f, -0.05862132f, 0.14068756f, -0.02043495f, -0.12628855f, 0.09227920f, 
    0.23897061f, 0.16243480f, -0.15020654f, -0.27688798f, -0.01234393f, 0.09727506f, -0.10338903f, -0.03891729f, 
    0.12401851f, -0.04413597f, -0.05711453f, 0.06795549f, -0.10160801f, -0.14810501f, -0.05502899f, 0.21558970f, 
    0.18537170f, 0.01991566f, 0.20218897f, -0.02386791f, 0.07065854f, 0.05978589f, 0.16240984f, -0.00465363f, 
    0.24170688f, -0.14381528f, 0.21392676f, -0.01599105f, 0.13026452f, 0.17330107f, 0.16836585f, -0.18216796f, 
    -0.22499649f, -0.10833257f, 0.01110899f, 0.14560623f, -0.17092258f, 0.04290486f, -0.19094630f, 0.08148690f, 
    0.12366059f, 0.07618570f, 0.04344796f, -0.20104091f, 0.17814779f, -0.07647377f, 0.05737049f, 0.12209910f, 
    -0.11122348f, 0.23685791f, 0.19644822f, 0.05880256f, 0.10505863f, 0.04109177f, 0.11076143f, 0.07023564f, 
    -0.03115321f, 0.09242009f, 0.07405022f, 0.05237037f, -0.54987919f, -0.02841979f, 0.02427929f, -0.07084206f, 
    0.09294095f, 0.15240985f, -0.16764158f, -0.18102212f, 0.03494212f, -0.01893426f, 0.10323565f, -0.10246564f, 
    0.16780654f, 0.09809452f, 0.14904992f, 0.09545556f, 0.17382054f, 0.12509434f, 0.05256812f, 0.15584680f, 
    -0.08854874f, -0.03380638f, 0.15485273f, -0.02141674f, -0.12129751f, -0.15543611f, 0.25317389f, 0.03662592f, 
    0.06460554f, 0.08673615f, -0.09613556f, -0.09056586f, 0.02816921f, 0.03028482f, -0.17780228f, 0.08368372f, 
    -0.36244366f, 0.24871044f, 0.11698516f, -0.22600549f, 0.00799346f, 0.13633323f, -0.00949415f, -0.12333275f, 
    0.03838779f, -0.00701491f, 0.02368591f, 0.02877644f, -0.02898933f, -0.43279469f, 0.26037371f, 0.05789925f, 
    -0.01837256f, 0.07093517f, -0.00482938f, -0.19083810f, 0.00791826f, -0.18991725f, -0.07727627f, 0.03058979f, 
    -0.36340353f, -0.09450468f, 0.07800271f, -0.21358171f, 0.05496669f, 0.12030269f, -0.06389602f, 0.07370741f, 
    -0.03667294f, -0.06755374f, 0.08349200f, 0.01241958f, -0.31908920f, 0.18307562f, 0.02014306f, -0.02767151f, 
    0.17190082f, 0.05486592f, 0.01334810f, -0.09720763f, 0.12109072f, 0.05434348f, 0.16976234f, -0.05952236f, 
    -0.10426822f, 0.01356626f, -0.03376551f, 0.22090383f, -0.16864067f, 0.11938380f, -0.07605212f, -0.08712268f, 
    0.06664377f, 0.07849751f, 0.02598234f, -0.08176005f, 0.05133901f, -0.04495567f, 0.25343543f, -0.03858871f, 
    -0.02583857f, 0.10902914f, -0.06762641f, 0.03738570f, -0.17133434f, 0.12391678f, 0.07524322f, 0.11708590f, 
    -0.12589711f, 0.37515962f, 0.04472440f, -0.06683686f, 0.09577406f, 0.00392614f, -0.17625982f, 0.14717205f, 
    0.07829461f, 0.15317400f, 0.10363229f, -0.09865808f, 0.28538886f, -0.02120191f, 0.01633641f, 0.11767675f, 
    -0.06713034f, -0.05769848f, 0.04638799f, 0.01068719f, -0.01161340f, 0.07209505f, 0.02507941f, 0.10571978f, 
    0.58585018f, -0.28608391f, -0.07024359f, 0.06659694f, 0.13301463f, -0.09943923f, 0.13525812f, 0.33713046f, 
    0.15076755f, 0.02538273f, -0.10932270f, 0.12754703f, -0.09883527f, 0.18063529f, -0.21399109f, 0.07958101f, 
    -0.01302136f, 0.19339600f, 0.04192786f, 0.15614438f, 0.10627944f, 0.04718360f, 0.05616491f, 0.05646498f, 
    -0.04218579f, -0.05962214f, -0.13081264f, -0.30225119f, 0.09336697f, -0.17309406f, -0.01410019f, -0.05472431f, 
    -0.01918619f, -0.09341519f, -0.01455158f, -0.04765004f, -0.01652735f, -0.06865566f, -0.31966686f, 0.13408908f, 
    0.01253358f, -0.09549665f, 0.09017500f, -0.19870120f, -0.01646648f, -0.15752572f, 0.15350454f, -0.04110934f, 
    -0.15563267f, -0.04093153f, 0.14309432f, 0.36116469f, -0.00192671f, -0.10468532f, 0.02327948f, 0.06666710f, 
    0.11588906f, -0.15973423f, 0.08154105f, -0.01263504f, -0.13534835f, -0.17374431f, 0.12337526f, 0.09326559f, 
    -0.03829610f, -0.08134601f, -0.05354479f, -0.18252744f, 0.15849444f, 0.16536182f, 0.13145074f, 0.06923998f, 
    -0.02666356f, 0.28593609f, -0.12011479f, 0.01485845f, -0.01383252f, 0.00068064f, -0.07317065f, -0.09407882f, 
    -0.05725231f, -0.07234669f, -0.05262706f, -0.02341546f, -0.36733094f, 0.34702453f, 0.22799619f, 0.06877708f, 
    0.17131600f, -0.03648188f, 0.00880588f, -0.01616146f, -0.06452947f, 0.11950870f, -0.16105841f, -0.04149335f, 
    0.24344905f, -0.19011593f, 0.00539115f, -0.11322808f, 0.13597643f, -0.04239596f, -0.03884544f, 0.08229176f, 
    -0.00239222f, 0.07495515f, -0.13847373f, 0.08030905f, -0.39118099f, 0.10229903f, 0.16755790f, -0.04736290f, 
    0.05911382f, 0.12788370f, 0.02429787f, -0.12943621f, 0.04522501f, -0.08566805f, 0.02971187f, 0.10304872f, 
    0.00413555f, -0.04722618f, -0.16377877f, 0.00301936f, 0.14418787f, 0.08251433f, 0.08527324f, 0.07013921f, 
    0.07918503f, -0.05235707f, 0.01237173f, -0.02782351f, -0.34133828f, -0.12960626f, 0.31431189f, -0.01993172f, 
    0.06186460f, -0.09817421f, 0.02844695f, 0.11622728f, 0.05229572f, -0.03839002f, 0.18013453f, 0.07366518f, 
    -0.23975001f, -0.10003225f, -0.09758453f, 0.08927356f, 0.06668155f, -0.12688649f, 0.03018316f, -0.19030760f, 
    0.10321330f, 0.04529421f, 0.03276054f, -0.08602817f, -0.04742642f, 0.03711262f, -0.13248183f, -0.22941662f, 
    0.03988913f, 0.10797650f, 0.00157227f, -0.08807283f, 0.02030214f, -0.05708510f, 0.07589886f, 0.02356588f, 
    -0.03822139f, -0.05293529f, 0.05660143f, 0.06339163f, -0.02461333f, -0.01929000f, -0.07645395f, -0.00646057f, 
    -0.06837514f, 0.01514581f, -0.00178873f, 0.00623524f, -0.05853054f, -0.07085299f, 0.03671263f, -0.01093147f, 
    -0.01590635f, 0.06260476f, -0.07798155f, -0.00059808f, 0.01903691f, -0.04180120f, -0.04255310f, 0.05947001f, 
    0.02573329f, -0.05193511f, -0.07183754f, 0.00145966f, -0.01717768f, -0.04229851f, -0.05951217f, -0.05918331f, 
    0.05493320f, -0.03090505f, 0.05411821f, 0.04535958f, 0.01874389f, 0.00560124f, 0.04534348f, 0.04236441f, 
    0.03823777f, -0.00658432f, 0.05636404f, 0.01239587f, -0.07353861f, 0.02919177f, -0.01571433f, -0.01129657f, 
    -0.07745344f, -0.00060712f, -0.06993403f, 0.03601700f, 0.04237217f, 0.04513230f, -0.03840210f, -0.06409211f, 
    0.06062557f, 0.00465096f, -0.04352723f, 0.01917870f, 0.05895152f, -0.07795377f, 0.06228581f, -0.07330263f, 
    -0.05401583f, -0.07826570f, -0.02730489f, 0.06355184f, -0.05717344f, -0.04812138f, -0.05954492f, -0.07321578f, 
    -0.04254070f, -0.01266488f, -0.05389750f, -0.04202572f, -0.04618701f, 0.05827215f, 0.03666156f, 0.00037389f, 
    0.00831792f, 0.00639734f, -0.03972782f, -0.00466712f, 0.03082420f, 0.05621806f, -0.07068569f, 0.04514001f, 
    0.00913125f, -0.03778247f, -0.05231794f, 0.00073954f, 0.00455144f, -0.01316578f, -0.06073010f, -0.06786013f, 
    -0.04757595f, -0.01070551f, 0.00496026f, 0.04320502f, -0.06855803f, 0.03275707f, -0.02204763f, 0.01222082f, 
    -0.00427381f, -0.07196512f, -0.03532088f, 0.00774593f, -0.01497207f, 0.05111006f, 0.00454081f, 0.04036819f, 
    -0.07240278f, -0.00334726f, -0.02341658f, -0.06771889f, 0.05807740f, 0.02434981f, 0.05577854f, -0.07745281f, 
    -0.02358474f, -0.02448766f, -0.05299195f, -0.03334780f, -0.05807008f, 0.04429427f, 0.03895178f, 0.00811865f, 
    -0.07240939f, 0.04891496f, -0.04904187f, -0.05821142f, -0.02037248f, 0.01672189f, 0.00923921f, -0.07840231f, 
    0.03576518f, -0.05475885f, 0.04670158f, 0.04961860f, -0.05113862f, -0.04025367f, -0.01796925f, -0.01571610f, 
    -0.03215930f, -0.03699817f, 0.03772445f, -0.03728870f, -0.06380938f, -0.00720745f, -0.00307842f, -0.05870634f, 
    -0.03708244f, -0.07198630f, 0.02698602f, -0.07959002f, 0.02541574f, -0.06514435f, 0.01293507f, -0.00505254f, 
    0.01750071f, -0.01361009f, 0.02361949f, 0.04862574f, -0.00142941f, 0.00062558f, -0.05198050f, -0.05434538f, 
    -0.00929040f, -0.01870102f, -0.04213485f, 0.00885066f, 0.02440530f, 0.01816711f, -0.07248895f, 0.05687882f, 
    0.02898752f, 0.03252419f, 0.03713127f, 0.03295923f, 0.04509525f, -0.03800969f, 0.03813960f, 0.03816174f, 
    -0.05125674f, -0.00223503f, 0.00638907f, 0.01483735f, -0.06561162f, -0.05707280f, -0.07717340f, 0.01072039f, 
    0.00753711f, -0.29190695f, 0.04747530f, 0.19563623f, -0.09055568f, 0.04998637f, 0.06053158f, -0.05888570f, 
    0.07183935f, -0.06249569f, 0.13809416f, 0.01821438f, -0.25917837f, 0.13376912f, 0.00902559f, -0.05538812f, 
    -0.02098332f, -0.06122212f, -0.06094901f, -0.11686230f, -0.06643595f, 0.10873275f, 0.18894418f, 0.10282959f, 
    -0.00482206f, 0.12315425f, 0.20122628f, -0.10209429f, 0.03056204f, 0.17771493f, -0.09377196f, -0.06188138f, 
    0.10361887f, 0.02518876f, -0.08632177f, 0.15466234f, -0.59311342f, -0.22836488f, 0.08913530f, -0.13362165f, 
    0.06636496f, 0.09042924f, 0.13265124f, -0.09161392f, 0.01062375f, -0.11333308f, 0.14373666f, -0.07002512f, 
    0.08752929f, 0.09204432f, 0.08329459f, 0.53464282f, -0.05740036f, 0.05720180f, 0.05917186f, 0.15878949f, 
    -0.09645500f, -0.10321464f, -0.12808818f, 0.01639611f, 0.27058575f, 0.05698293f, 0.16993135f, -0.17390519f, 
    0.02425027f, 0.05842733f, -0.09667268f, -0.11973382f, -0.04551161f, 0.07988621f, -0.17371196f, 0.15310508f, 
    0.15707847f, -0.06999256f, -0.25403067f, -0.27557957f, 0.19267327f, 0.25070226f, -0.01828762f, -0.12270337f, 
    0.12217716f, -0.02720137f, -0.12283211f, 0.02979525f, 0.12057073f, 0.07165447f, 0.03626542f, 0.08808975f, 
    0.05549289f, -0.03621744f, 0.03441004f, 0.01955216f, -0.06721150f, -0.00571057f, -0.05859000f, 0.06494553f, 
    0.08074613f, -0.24882779f, 0.32209435f, 0.03689976f, 0.15274049f, 0.10003921f, 0.02265506f, 0.08944294f, 
    0.04950761f, 0.10256878f, 0.19616501f, 0.08962614f, 0.29980874f, -0.34494561f, -0.19273074f, 0.21320686f, 
    0.04720471f, 0.00014612f, -0.02473004f, -0.09778573f, 0.03781663f, 0.02110962f, -0.04022480f, 0.28330043f, 
    -0.04461252f, 0.07386093f, 0.16431649f, 0.34593669f, 0.06946746f, -0.00285188f, -0.12159739f, -0.15302499f, 
    -0.10084980f, -0.01309056f, 0.02510242f, 0.14233077f, 0.38489285f, 0.02347398f, -0.12216543f, 0.17930855f, 
    0.00407931f, 0.02707464f, -0.00695159f, -0.04920177f, -0.04980097f, -0.16951051f, -0.02497571f, -0.02922992f, 
    -0.01758036f, 0.02709708f, -0.04266127f, -0.19745080f, 0.16541617f, -0.00822327f, 0.06603801f, 0.09356000f, 
    0.03565508f, 0.11266732f, 0.06860524f, -0.03426558f, 0.25207540f, 0.00188807f, -0.06033958f, 0.08892813f, 
    -0.09200800f, 0.05787199f, 0.10522431f, -0.04860547f, 0.06139654f, 0.14568937f, 0.00203244f, -0.08029585f, 
    0.30465770f, 0.05942105f, 0.12499890f, -0.05940054f, -0.10467754f, 0.04579194f, -0.10468455f, 0.17942320f, 
    0.03580647f, 0.02642994f, -0.06833854f, -0.00992578f, -0.11619775f, -0.13510136f, 0.01381253f, 0.13297673f, 
    0.03706673f, 0.05909279f, 0.04445729f, 0.14651184f, 0.11381230f, 0.09087145f, 0.08721914f, 0.02034611f, 
    -0.07744693f, 0.15508209f, -0.11992326f, 0.24315056f, -0.05168055f, -0.12593727f, 0.07170866f, 0.01787126f, 
    0.24573980f, -0.01847108f, 0.05691791f, 0.04573441f, -0.05090400f, 0.12690009f, -0.05023555f, 0.11548048f, 
    0.01551327f, 0.06987999f, -0.02129484f, 0.02258285f, -0.06810263f, 0.11691649f, 0.19756776f, 0.22514927f, 
    0.21989611f, -0.02163947f, -0.04869917f, 0.05615896f, 0.08937985f, 0.04264783f, 0.09519401f, -0.00521847f, 
    0.06518845f, 0.10070428f, -0.00015057f, 0.04138700f, 0.17853640f, -0.05113198f, 0.08125965f, 0.00819249f, 
    -0.09452673f, 0.15475006f, 0.01483445f, -0.13852376f, 0.03349935f, -0.16468319f, -0.02198206f, -0.08495582f, 
    0.00834229f, -0.06124377f, -0.06455572f, 0.12840761f, -0.08708730f, 0.06420491f, 0.02972032f, 0.25822178f, 
    -0.07130506f, -0.09644736f, 0.01975456f, -0.07003526f, 0.39775088f, -0.05938270f, -0.03697051f, -0.19699037f, 
    0.04315861f, 0.06375027f, 0.06807825f, -0.11453170f, -0.19979694f, 0.03837702f, 0.05608571f, 0.13832347f, 
    -0.21535358f, 0.23556833f, -0.03578528f, 0.09968074f, 0.01986540f, -0.01157680f, -0.10580622f, -0.05293696f, 
    0.18802841f, -0.13620432f, -0.09586781f, 0.00336009f, 0.14967699f, -0.06126275f, 0.10818342f, 0.14853719f, 
    -0.05928914f, -0.02185412f, 0.13178618f, -0.00951444f, 0.11724357f, -0.01414504f, 0.03693425f, 0.05795075f, 
    -0.32450676f, 0.05856083f, -0.12958232f, -0.06519898f, 0.06761173f, 0.01412053f, 0.04408912f, 0.12610565f, 
    0.02516470f, -0.00592803f, 0.22888349f, 0.15457539f, 0.20886265f, 0.10907945f, 0.03820084f, 0.09178454f, 
    0.12089310f, 0.00744457f, 0.00354508f, -0.00946161f, 0.02054655f, 0.08770796f, -0.09902328f, 0.05040444f, 
    0.12922311f, -0.35530221f, -0.06102617f, 0.16675231f, 0.08913527f, -0.09792482f, -0.13422251f, 0.06197286f, 
    0.08921959f, -0.02395244f, -0.01863986f, -0.02359917f, 0.35533959f, 0.08396978f, 0.02281531f, -0.06985476f, 
    -0.08208074f, -0.06540391f, -0.05250536f, 0.05911681f, 0.03169667f, -0.05738302f, 0.04441693f, -0.03040976f, 
    -0.37445140f, 0.28513560f, -0.12043002f, 0.10743293f, 0.03565868f, 0.00107133f, -0.05091172f, 0.04195342f, 
    0.08507475f, 0.02663883f, 0.15494587f, -0.03508830f, 0.18868117f, -0.28477255f, 0.15876251f, 0.14078912f, 
    0.00865274f, 0.12516835f, 0.07277098f, 0.13553180f, 0.16268247f, -0.12481562f, -0.00717429f, -0.08712811f, 
    -0.15029691f, 0.00123783f, 0.18065375f, -0.20172717f, -0.09391805f, -0.06154678f, -0.08158824f, 0.05088544f, 
    0.09330528f, 0.08240761f, 0.10798317f, 0.09590475f, -0.08763324f, -0.11013675f, -0.09062516f, -0.31096533f, 
    -0.02843226f, 0.08502714f, -0.08458144f, -0.09805048f, 0.17638919f, 0.01171976f, 0.15710908f, 0.05569881f, 
    0.33792159f, -0.07356328f, 0.09692903f, -0.38439742f, -0.05874850f, -0.02756569f, 0.09608314f, 0.05950889f, 
    0.00782997f, 0.03660299f, 0.01082046f, 0.18109892f, 0.35558501f, 0.15314598f, -0.25089064f, -0.14411479f, 
    -0.11191211f, -0.01241147f, -0.00669746f, 0.14161123f, 0.00118348f, 0.05625447f, 0.09488939f, 0.06395639f, 
    -0.13320993f, 0.20587876f, -0.06066297f, -0.09294433f, -0.02947208f, 0.03817732f, 0.04838355f, -0.09634943f, 
    -0.00451038f, -0.04035315f, 0.07560736f, 0.05487153f, 0.04505911f, -0.43698999f, -0.00741062f, 0.17264292f, 
    0.05904938f, 0.06595793f, 0.17537916f, 0.01864663f, -0.02120794f, 0.01362928f, -0.01695679f, 0.01514085f, 
    0.12269765f, -0.06853764f, -0.18037094f, 0.12694414f, -0.07331989f, 0.11633585f, 0.10177211f, -0.11211389f, 
    -0.13555910f, 0.11597392f, -0.01656729f, -0.03746208f, 0.05914772f, -0.03237931f, 0.20876409f, 0.03946710f, 
    0.14430176f, -0.01630268f, 0.17968158f, -0.06342866f, 0.14522971f, -0.07325284f, 0.03332589f, -0.06134283f, 
    -0.02333640f, 0.27286407f, -0.06720996f, 0.10306314f, 0.10294889f, 0.09377479f, -0.09677216f, 0.06895803f, 
    -0.16714111f, 0.01150570f, 0.10125415f, -0.07266629f, -0.10730217f, 0.15684460f, 0.21532436f, -0.50857311f, 
    -0.08604259f, -0.02666370f, 0.13432164f, -0.01999880f, 0.00536389f, 0.03905863f, 0.06674670f, -0.06160932f, 
    -0.13625984f, 0.09856566f, -0.12367374f, 0.19307497f, 0.13187756f, 0.15137036f, 0.01397316f, 0.03628861f, 
    0.18037963f, 0.05264411f, -0.08856391f, -0.21085475f, 0.17253971f, 0.12126844f, 0.12659375f, 0.01856957f, 
    -0.07815100f, -0.03202433f, 0.00436288f, -0.04138200f, -0.05123899f, -0.03873624f, 0.02336572f, 0.06171864f, 
    -0.60237038f, 0.41526955f, 0.05652874f, -0.19329165f, 0.03956616f, 0.11614826f, 0.08011972f, 0.03934996f, 
    0.11028191f, 0.01655440f, 0.04351872f, 0.03487502f, 0.12335787f, -0.15220167f, 0.35453182f, 0.31128851f, 
    -0.14963469f, -0.03854690f, -0.06352501f, 0.01881187f, -0.04022653f, -0.04221786f, 0.02491746f, 0.10878829f, 
    0.00961913f, -0.17655995f, -0.00421495f, -0.09908740f, 0.12641792f, -0.01900578f, -0.07961322f, 0.08549656f, 
    0.00359342f, 0.00978855f, 0.09463355f, -0.11139431f, 0.17375705f, 0.12307180f, -0.13538140f, -0.08535532f, 
    0.08847374f, -0.06748213f, 0.03676946f, -0.00787595f, 0.01750151f, 0.10016951f, 0.00520923f, 0.14709376f, 
    -0.18899138f, 0.11371858f, 0.12328722f, 0.26060003f, 0.01775958f, 0.15446751f, 0.01090320f, -0.05151843f, 
    -0.09051773f, -0.07340743f, 0.15105119f, -0.01494664f, -0.37651035f, 0.00238835f, 0.32573885f, 0.12269173f, 
    -0.01330877f, -0.02325864f, 0.01353066f, -0.19667634f, -0.05191830f, -0.02888238f, 0.04289309f, 0.02968981f, 
    -0.11349284f, -0.01574651f, 0.27779785f, -0.08621261f, 0.08356658f, 0.12205433f, 0.09247284f, -0.04983595f, 
    -0.19563094f, 0.12419653f, 0.09698483f, 0.01384020f, 0.26703101f, 0.17027004f, 0.13617435f, -0.07560987f, 
    0.05102326f, 0.13688470f, -0.10755702f, 0.24750589f, 0.04069570f, 0.14943124f, 0.04380992f, 0.04153352f, 
    -0.22926980f, -0.05741150f, -0.15494776f, -0.24892160f, -0.06289849f, -0.10598981f, -0.08281720f, -0.03599612f, 
    0.02224568f, -0.00030850f, -0.05236544f, -0.08493828f, 0.15510629f, 0.35813096f, 0.05691594f, -0.03251670f, 
    0.01741613f, -0.01287329f, -0.00279586f, -0.00895934f, 0.01163240f, 0.06692005f, 0.09516355f, -0.06662961f, 
    0.51957589f, 0.31887412f, 0.19466320f, 0.13899806f, 0.12152775f, 0.03601775f, 0.21104234f, -0.08768057f, 
    0.00728275f, -0.04358935f, 0.08437476f, 0.23408028f, -0.12243532f, -0.14365448f, -0.11723612f, 0.03809638f, 
    -0.05353162f, -0.00575662f, -0.03556430f, 0.04826477f, 0.16183053f, 0.06457081f, -0.14306253f, -0.01500233f, 
    0.19706836f, -0.03752868f, 0.10548143f, -0.01533291f, -0.20910561f, 0.19222434f, -0.07133812f, -0.08224343f, 
    -0.06945726f, -0.01136189f, 0.05468886f, 0.18597081f, -0.43115762f, -0.04018059f, -0.32226288f, -0.28804874f, 
    0.09971340f, 0.13106297f, -0.00430399f, -0.02771159f, -0.09412840f, -0.02466117f, 0.05445859f, 0.03908847f, 
    0.42705777f, -0.01175324f, 0.23333395f, 0.04917087f, -0.10755856f, 0.15377562f, -0.01705418f, -0.16560990f, 
    0.07758192f, 0.17566203f, 0.05166714f, 0.06520709f, -0.65571982f, -0.23060736f, 0.08863752f, -0.30186516f, 
    0.15149304f, 0.03048402f, -0.02407847f, 0.04608003f, -0.15600620f, 0.02723884f, 0.04955376f, -0.00815557f, 
    -0.50432694f, -0.15003863f, -0.17726554f, -0.19296698f, -0.11131431f, -0.02602722f, 0.05871359f, -0.06554134f, 
    -0.17383136f, -0.06100094f, 0.07759312f, -0.16327284f, -0.42941615f, -0.09302539f, -0.02216332f, 0.08244431f, 
    0.17862669f, 0.16288400f, 0.07805490f, -0.03931462f, -0.06966948f, 0.14411435f, -0.12336583f, 0.01854704f, 
    0.38503009f, -0.02549156f, 0.12636623f, 0.13828449f, -0.13916561f, -0.08471832f, -0.04971424f, -0.17050356f, 
    0.08609039f, -0.00800843f, -0.03302947f, 0.11839338f, -0.31026873f, 0.33181989f, -0.14546171f, -0.17409422f, 
    -0.00386679f, 0.12291711f, -0.04539199f, -0.05333362f, -0.10909320f, 0.13827127f, 0.04807085f, -0.08334168f, 
    -0.01240603f, -0.21034066f, 0.13240905f, 0.13163540f, 0.09553016f, 0.24267568f, -0.13136332f, -0.02179766f, 
    -0.05193029f, -0.00659209f, 0.06664527f, -0.03937533f, 0.26065531f, 0.20284638f, 0.22079760f, 0.18206464f, 
    0.10714432f, 0.08302756f, -0.02504640f, 0.14619894f, -0.16560747f, 0.19996713f, -0.09075667f, 0.06080690f, 
    0.27003551f, -0.00756730f, 0.03789055f, -0.30910218f, 0.16844593f, 0.00317749f, 0.00335091f, 0.14338301f, 
    -0.09098022f, 0.04162006f, 0.00536011f, -0.04654028f, 0.13154705f, -0.11741121f, -0.19552007f, -0.08369537f, 
    0.14518914f, -0.05003147f, 0.17516060f, 0.09627370f, 0.17724846f, 0.02711751f, 0.00494911f, 0.00904011f, 
    -0.35914230f, -0.09608985f, 0.03018454f, 0.02318516f, -0.05195004f, 0.05636918f, -0.04080370f, 0.07946638f, 
    -0.08608897f, -0.09815539f, 0.14554401f, -0.02906039f, 0.21842015f, -0.23823655f, -0.00749394f, 0.18954693f, 
    0.00674874f, -0.07664340f, 0.00395819f, -0.01661943f, -0.13108975f, 0.08279576f, -0.06977388f, 0.10829472f, 
    -0.10940783f, 0.02199689f, 0.17294918f, -0.06590718f, 0.15320762f, 0.13231045f, 0.15140915f, -0.17945838f, 
    0.08872227f, -0.09097850f, 0.06383715f, 0.03903612f, -0.38503087f, 0.15061668f, -0.27583966f, 0.30362022f, 
    0.12086550f, 0.18074025f, 0.00692958f, -0.02223079f, 0.15329301f, -0.00228715f, -0.00218289f, 0.00808976f, 
    -0.24902916f, 0.36496440f, 0.00161784f, -0.20281650f, 0.04105620f, -0.10479550f, -0.09310231f, -0.11510054f, 
    -0.09816417f, -0.01326673f, 0.00812244f, 0.02204616f, 0.20238620f, 0.06347297f, -0.22572155f, -0.11167183f, 
    -0.08813773f, 0.02689833f, -0.00147676f, -0.01498168f, 0.05683031f, 0.12418114f, 0.08185051f, -0.01376270f, 
    -0.19042298f, 0.22430059f, -0.20427468f, -0.10262927f, -0.03000188f, 0.05899617f, 0.06800913f, -0.08274928f, 
    0.04666166f, 0.00042874f, -0.03844585f, -0.06475715f, 0.06765385f, 0.30323842f, 0.08753555f, 0.01478139f, 
    -0.15982203f, -0.03883863f, -0.01714305f, 0.01586057f, 0.01990546f, 0.06696095f, 0.06117187f, -0.02575227f, 
    -0.32761729f, 0.15822233f, 0.13497697f, -0.24376827f, -0.08807329f, 0.07209206f, 0.11349913f, -0.02642770f, 
    0.09688076f, 0.10730476f, 0.02745040f, -0.03722534f, -0.10666770f, -0.07608284f, -0.01604645f, 0.09371436f, 
    0.07297631f, 0.07032847f, -0.17643334f, 0.08282609f, 0.03331811f, 0.03040126f, 0.04261312f, 0.11665611f, 
    -0.25826141f, 0.19373785f, 0.12372069f, 0.02318985f, 0.07266782f, 0.06928213f, 0.04289518f, 0.06149037f, 
    0.10127127f, -0.04528354f, 0.10331982f, 0.03692172f, 0.08745351f, -0.15143900f, 0.01011177f, 0.07398901f, 
    0.15289573f, -0.09436092f, 0.05734526f, -0.02336113f, -0.08795123f, 0.00463283f, 0.19787280f, 0.10654061f, 
    0.15395649f, 0.24904209f, -0.28783768f, 0.24707851f, 0.14954074f, 0.18024376f, -0.02834498f, -0.03400686f, 
    0.05533908f, 0.03226174f, 0.09755538f, -0.10025948f, 0.27329618f, 0.03811718f, 0.19139923f, 0.30553833f, 
    -0.03980935f, -0.07835156f, 0.01669161f, -0.14053063f, 0.07696431f, -0.10292860f, 0.10994885f, 0.18087882f, 
    -0.03915619f, 0.08839774f, 0.12060641f, 0.02083544f, -0.16346325f, -0.01678744f, 0.03506439f, -0.00535578f, 
    0.03255933f, 0.00409621f, -0.08635770f, 0.04792428f, 0.12164269f, 0.25099266f, -0.14535126f, 0.06476232f, 
    -0.04810686f, 0.05053147f, -0.01871212f, 0.10885208f, -0.06832324f, -0.05755336f, -0.06702516f, -0.14415736f, 
    -0.06109845f, 0.03798439f, -0.26515582f, 0.03266923f, 0.08264820f, 0.06312997f, 0.17193554f, -0.05748853f, 
    0.04631728f, 0.02526842f, 0.20003241f, -0.07827406f, 0.33240482f, 0.03611856f, 0.03278309f, 0.14366855f, 
    0.09519782f, 0.06572574f, 0.01251256f, 0.11450939f, -0.10429968f, 0.05441825f, -0.00307596f, -0.01688668f, 
    0.13172701f, 0.12697928f, -0.08142219f, -0.11228223f, 0.04394430f, -0.01099203f, -0.00597879f, -0.05819241f, 
    0.10058087f, 0.14821635f, -0.02990551f, 0.16767310f, -0.07213396f, -0.03010914f, 0.36451602f, -0.01063962f, 
    0.05320520f, -0.02809759f, 0.20570149f, 0.14821875f, 0.10507740f, 0.03513060f, 0.04077600f, 0.00274689f, 
    0.16863273f, -0.09390298f, 0.20338300f, 0.17141762f, -0.02424919f, 0.00754250f, 0.10975152f, 0.12782116f, 
    -0.14700252f, 0.11579333f, 0.08228957f, 0.05385438f, -0.00171725f, 0.02563234f, 0.00962290f, -0.27851248f, 
    0.12930660f, -0.01657188f, 0.00653749f, 0.01441417f, -0.06710614f, -0.05039333f, -0.09705229f, -0.17320758f, 
    0.13084088f, -0.09891806f, -0.07952356f, -0.03103022f, -0.00810360f, -0.10749438f, -0.08405149f, -0.00147492f, 
    0.00009786f, -0.04141859f, -0.10717600f, -0.01168378f, -0.12428448f, -0.09852750f, -0.19173186f, -0.13329710f, 
    0.08505502f, 0.06146311f, -0.11357082f, 0.03330718f, 0.05688163f, -0.04114264f, -0.03793298f, 0.01719432f, 
    -0.31945014f, 0.12234295f, -0.23621477f, 0.00960696f, 0.08082096f, -0.01616599f, 0.05424197f, 0.03326815f, 
    0.03887891f, -0.05365723f, 0.15303050f, 0.08578027f, 0.22944139f, -0.16009235f, 0.18974055f, -0.02277583f, 
    -0.11938383f, -0.04142271f, 0.09713985f, 0.05268680f, 0.00146894f, 0.09969137f, 0.05588072f, 0.12328850f, 
    0.51326019f, -0.39857224f, 0.05908858f, 0.21322818f, -0.12023737f, -0.02042682f, -0.13863121f, 0.02237120f, 
    0.03314288f, 0.02205257f, -0.06071610f, -0.05788424f, -0.04183439f, 0.29221302f, -0.12479229f, -0.33203655f, 
    0.07539650f, 0.05879924f, -0.08856628f, -0.11601976f, -0.04051496f, 0.04894613f, -0.15545185f, 0.13074701f, 
    -0.40048331f, 0.10065083f, 0.07437719f, 0.12260251f, -0.00495644f, 0.18028443f, 0.11235275f, -0.01353568f, 
    -0.00244687f, 0.14035885f, -0.09409306f, 0.21057053f, -0.24183403f, 0.09546278f, -0.01935316f, -0.25389200f, 
    0.09547926f, 0.13621543f, 0.03651662f, 0.05145549f, -0.02285459f, -0.03183211f, -0.09515081f, -0.07547107f, 
    -0.24908946f, 0.12743911f, -0.04966584f, 0.34168348f, -0.14107181f, 0.01191120f, -0.06195569f, 0.01229222f, 
    0.13421462f, -0.06547966f, 0.05828445f, 0.08108065f, -0.19224580f, 0.12754157f, 0.02620252f, 0.23385565f, 
    -0.01601742f, 0.08407597f, -0.09363884f, 0.02702875f, -0.04143889f, -0.03434574f, 0.04530011f, 0.02016703f, 
    0.20395617f, -0.01459862f, -0.06392595f, 0.06179374f, 0.13914897f, -0.05081072f, 0.08131494f, 0.05006595f, 
    -0.04714304f, 0.11852103f, 0.16731985f, 0.00786020f, 0.02675082f, 0.13394247f, 0.10301629f, -0.10965939f, 
    0.05932233f, 0.14722502f, -0.00656020f, 0.09090068f, 0.09954727f, -0.00516203f, 0.01991712f, -0.02656987f, 
    -0.07841433f, -0.19055684f, -0.19999033f, -0.11810647f, -0.03201886f, -0.04338060f, -0.04012306f, 0.17151257f, 
    -0.04167414f, 0.06434896f, -0.04497943f, 0.17339146f, 0.29530197f, -0.06403020f, 0.33369794f, -0.14005767f, 
    -0.03894682f, -0.14041509f, 0.09082410f, 0.10950999f, -0.16744484f, 0.13781981f, 0.09955516f, 0.04184386f, 
    0.03947603f, -0.25338173f, 0.14614184f, 0.15918370f, 0.06421727f, -0.02159243f, 0.07921391f, 0.17520700f, 
    0.01726547f, 0.03639703f, 0.03322396f, 0.03509754f, 0.06306585f, -0.07228038f, 0.12853043f, 0.08982479f, 
    0.07179939f, 0.02217655f, -0.01339450f, 0.01753815f, -0.01600004f, -0.11775485f, -0.04885927f, -0.05136777f, 
    -0.06115221f, -0.13464843f, 0.12019967f, -0.05018526f, 0.04169267f, -0.17839375f, 0.00816659f, 0.09069150f, 
    -0.04331590f, -0.09304192f, 0.05346000f, 0.07395997f, 0.17425056f, -0.14244644f, -0.10294177f, -0.06651398f, 
    0.18415229f, 0.09516452f, -0.01460209f, 0.07146638f, 0.05093799f, -0.03328671f, -0.02500950f, 0.01923642f, 
    0.28757310f, -0.04687975f, -0.23567756f, 0.37025544f, 0.07770645f, -0.13675240f, 0.05076856f, 0.03870703f, 
    0.01931130f, -0.00001432f, -0.02354829f, 0.06249166f, 0.19444142f, 0.17803739f, 0.00604562f, -0.09812855f, 
    -0.02834592f, 0.02105063f, 0.15326722f, -0.05146851f, 0.01299790f, -0.00560807f, 0.01226891f, -0.03594813f, 
    0.37760907f, -0.08683053f, -0.11203361f, 0.18269084f, -0.07692663f, -0.09827186f, 0.03152255f, -0.06598746f, 
    0.04886983f, 0.00735378f, -0.00360674f, 0.02898459f, 0.10419107f, 0.23133428f, 0.16351359f, -0.09069006f, 
    -0.07475156f, 0.08084875f, -0.03154529f, -0.12075105f, 0.15389149f, -0.18944423f, -0.15029784f, 0.01428075f, 
    -0.05410036f, -0.14246777f, 0.17565823f, -0.16528834f, -0.06603330f, -0.09772974f, 0.04843694f, 0.15015887f, 
    0.04276751f, 0.08570295f, -0.07111675f, 0.09566227f, -0.23234424f, -0.02918196f, -0.17731552f, -0.46009609f, 
    0.07253006f, 0.22760159f, 0.10871594f, 0.11396094f, 0.06062698f, 0.13367462f, -0.04307359f, -0.03653099f, 
    -0.07886034f, 0.03515263f, 0.03732175f, -0.34208217f, 0.14099391f, 0.08265495f, 0.01906695f, 0.14084043f, 
    -0.06978450f, 0.13715658f, 0.12037937f, -0.08072592f, 0.26656982f, -0.11025900f, 0.01678311f, -0.31314385f, 
    -0.01886203f, -0.07975267f, 0.19197670f, -0.00543181f, -0.00738914f, 0.06648382f, 0.09872761f, -0.01678818f, 
    -0.03059782f, 0.04185461f, 0.05051515f, -0.14863457f, -0.05804362f, -0.02422527f, -0.00683306f, 0.08380206f, 
    -0.00910237f, -0.04094145f, -0.20164922f, -0.05123736f, -0.45680285f, -0.41634274f, 0.11849620f, 0.09602632f, 
    -0.13888894f, 0.02954394f, 0.04523323f, -0.08526067f, 0.00505152f, 0.06342199f, 0.15042397f, 0.11477219f, 
    -0.00330935f, 0.19287691f, 0.02030980f, -0.01550383f, 0.15307574f, -0.00888386f, 0.13382719f, -0.10724934f, 
    0.06301516f, -0.02874239f, 0.02993556f, -0.05249998f, 0.12460698f, 0.53324699f, -0.22811668f, 0.39630440f, 
    -0.00417866f, 0.10948438f, -0.09739923f, -0.04827508f, 0.00749265f, -0.03881479f, -0.08234977f, 0.07204420f, 
    -0.16874196f, -0.16010943f, -0.30535805f, -0.18742558f, -0.02872080f, 0.05142951f, -0.10654043f, -0.05813486f, 
    0.07909650f, -0.03953971f, -0.07272121f, 0.07392091f, 0.27318704f, 0.11641004f, -0.31966558f, 0.17154521f, 
    0.08552974f, 0.16231802f, 0.01045187f, -0.01639191f, 0.04275774f, -0.02482676f, 0.02242780f, 0.05610589f, 
    -0.53710061f, 0.04263634f, -0.23271917f, -0.12939194f, -0.02271303f, 0.06397989f, -0.11914621f, -0.16321994f, 
    0.03182673f, 0.06135755f, 0.15967304f, -0.00587597f, -0.03994268f, 0.29319227f, -0.08364606f, 0.20506479f, 
    0.00212926f, 0.08350016f, 0.07640865f, -0.22839458f, -0.02927831f, 0.12434231f, 0.04118220f, 0.18309295f, 
    -0.32916030f, 0.12675013f, 0.24071588f, -0.25936425f, -0.05525518f, 0.06265885f, -0.06889040f, -0.12733845f, 
    -0.03223684f, -0.00498160f, -0.03870953f, 0.08855008f, 0.30329052f, 0.13707684f, -0.09460118f, 0.31986871f, 
    -0.05996296f, 0.02386596f, 0.01436493f, 0.06733602f, 0.11729614f, 0.01573359f, -0.10453494f, 0.10176950f, 
    -0.13523532f, -0.06631945f, -0.05588989f, -0.03700174f, 0.10999981f, 0.05927507f, 0.05596423f, -0.05330496f, 
    0.08778322f, -0.04983289f, 0.04595587f, 0.02071326f, 0.13506994f, -0.08158354f, 0.05240880f, 0.09791244f, 
    0.03419170f, 0.02696948f, 0.02291453f, 0.12618665f, 0.08049665f, -0.05382723f, 0.17430632f, -0.05092164f, 
    -0.05500177f, 0.46237612f, -0.09557650f, 0.13964498f, 0.08357619f, 0.17247859f, -0.06471232f, -0.06308188f, 
    0.21959294f, 0.03363020f, 0.09758797f, -0.11134193f, 0.14914459f, -0.02399823f, 0.08260643f, 0.31921771f, 
    0.08012643f, -0.08292782f, -0.06139053f, -0.18272543f, 0.04813872f, -0.16270755f, 0.11646561f, 0.09468058f, 
    -0.22655186f, 0.17253645f, 0.11476748f, -0.20634980f, 0.05686043f, 0.04296886f, -0.06344692f, -0.00786757f, 
    0.04194465f, -0.19757073f, -0.03394546f, 0.03078959f, -0.30708155f, 0.05452117f, -0.19486615f, 0.22985785f, 
    -0.06803096f, -0.02058440f, -0.08639111f, 0.09311207f, -0.06381800f, -0.01349964f, -0.01384807f, -0.17288226f, 
    -0.28033286f, -0.19495298f, -0.08185302f, 0.25287193f, 0.09997910f, 0.01547660f, 0.11580186f, -0.00389960f, 
    -0.09603556f, -0.07613725f, 0.22247963f, 0.11084332f, 0.14116222f, -0.22948042f, -0.12846008f, 0.02539618f, 
    0.05605291f, 0.08067701f, 0.02973114f, 0.12294910f, -0.02619681f, 0.21520884f, -0.05624744f, 0.08830906f, 
    -0.19852927f, -0.08850980f, 0.08830167f, -0.33685306f, 0.15911923f, 0.00544060f, 0.08673752f, -0.19431409f, 
    0.20914565f, -0.00371557f, -0.00372633f, 0.17164440f, -0.50525981f, -0.01870310f, 0.17177707f, 0.12229335f, 
    0.06409396f, -0.14031947f, -0.02127006f, 0.24237426f, 0.19453080f, -0.01732176f, 0.14284821f, -0.11148520f, 
    -0.24224649f, -0.26091248f, 0.32937863f, 0.22967568f, 0.08999667f, -0.01616820f, 0.13990442f, 0.19772829f, 
    0.00143196f, 0.12075026f, 0.12933387f, 0.07204293f, 0.04853437f, -0.00838182f, -0.12277296f, -0.21211694f, 
    0.09387542f, 0.08383422f, -0.10309436f, -0.02278348f, 0.01358751f, 0.00565481f, 0.13504156f, -0.12386394f, 
    -0.00623888f, 0.24698670f, 0.09671485f, -0.03684185f, 0.09352573f, -0.09268660f, 0.03707419f, -0.08758993f, 
    -0.01437616f, -0.05501232f, -0.04017232f, -0.08955437f, -0.03021319f, -0.05731648f, 0.01344219f, -0.12379312f, 
    0.10308734f, -0.08918186f, -0.04001155f, 0.07430428f, 0.01942638f, 0.04003991f, -0.00429762f, -0.10505256f, 
    0.00587098f, 0.31143498f, -0.15077789f, -0.06559354f, -0.02543426f, 0.09506560f, 0.17132489f, 0.11399162f, 
    0.03323354f, -0.03170697f, -0.02784096f, 0.11253854f, 0.25335559f, -0.08288346f, 0.15328386f, -0.09875283f, 
    0.08852838f, -0.02687812f, 0.01531285f, -0.09620959f, 0.01491298f, 0.06668426f, 0.12984087f, 0.19105913f, 
    0.30658087f, -0.23818558f, -0.13320674f, 0.17063197f, -0.03646107f, 0.02364408f, 0.10769411f, -0.07457510f, 
    0.14666845f, 0.00526391f, -0.02553243f, 0.12516777f, -0.00768302f, 0.34862572f, 0.04549195f, -0.41498727f, 
    -0.05112402f, -0.17554668f, -0.02729410f, -0.16074394f, -0.09612983f, -0.17789650f, -0.02732158f, 0.10383638f, 
    -0.00413766f, 0.17145474f, -0.19766572f, 0.26452956f, 0.04077964f, 0.25537890f, -0.02280319f, -0.13384666f, 
    -0.15713342f, -0.05094060f, -0.08955549f, 0.03932789f, 0.04724392f, -0.06490546f, 0.04950527f, -0.00933385f, 
    0.09069028f, 0.15065461f, 0.01551097f, -0.04024681f, 0.02053930f, 0.09824985f, -0.06983188f, -0.16018434f, 
    0.22622176f, -0.10356034f, -0.25161025f, 0.21696220f, -0.00042172f, -0.19410589f, 0.09607004f, 0.08565897f, 
    0.04841089f, 0.07159312f, 0.09933621f, -0.06623159f, 0.29812297f, 0.08305556f, 0.00454945f, 0.01920289f, 
    0.00086273f, 0.00488095f, 0.10438237f, -0.06706191f, 0.04211979f, 0.06309882f, 0.06869966f, 0.06906682f, 
    0.13568325f, -0.04541697f, -0.11648405f, -0.04014198f, -0.01737172f, 0.08145016f, 0.08735345f, 0.13127910f, 
    -0.03310008f, 0.04473417f, -0.03107631f, 0.00545347f, -0.11973670f, 0.10841760f, 0.11176370f, 0.01574754f, 
    0.01747270f, -0.01575164f, 0.01671453f, 0.00392784f, 0.04885137f, -0.15098611f, 0.08394001f, -0.04036080f, 
    0.07181677f, 0.04875245f, -0.11680834f, 0.13330221f, -0.07876881f, -0.03056894f, -0.08360538f, 0.08063220f, 
    0.13000694f, -0.00948346f, 0.02397515f, -0.25880978f, 0.37215593f, -0.00941978f, 0.00662268f, -0.12106822f, 
    0.10463788f, 0.15898147f, -0.09312870f, 0.02145976f, -0.05689335f, -0.10433239f, -0.02731574f, 0.02058279f, 
    0.12639065f, 0.49447086f, 0.00300967f, 0.12147279f, -0.03403826f, 0.09070151f, -0.03443758f, -0.09642761f, 
    0.03817090f, -0.06646377f, -0.16648556f, -0.06379005f, 0.12039250f, -0.03603266f, -0.06745675f, 0.15316805f, 
    0.13163774f, -0.03603688f, 0.25620085f, -0.04721537f, -0.02080626f, 0.11045992f, 0.02122033f, 0.19743650f, 
    0.01786719f, 0.19332054f, -0.02868285f, 0.06734762f, 0.04251609f, 0.07765002f, 0.02318656f, -0.03920132f, 
    0.00338261f, -0.03015977f, 0.14126395f, 0.04086751f, 0.14665583f, -0.09349889f, -0.26542985f, 0.16102460f, 
    -0.03734061f, 0.05309505f, 0.01245362f, -0.13940026f, -0.01343089f, 0.17482971f, -0.03141594f, 0.11461310f, 
    -0.04520788f, -0.30191830f, -0.04067999f, 0.14145133f, 0.06900837f, -0.09957637f, -0.08077621f, -0.02388388f, 
    0.06499036f, -0.02173429f, -0.03828563f, -0.01867269f, 0.17979866f, 0.18343419f, -0.08552776f, -0.15794495f, 
    -0.04100392f, -0.09125546f, 0.02638596f, 0.08374788f, -0.04410865f, -0.00778276f, 0.04310206f, -0.08061151f, 
    -0.11667462f, 0.20797768f, 0.14572906f, -0.05388336f, 0.03916425f, 0.02705231f, -0.02177807f, 0.11793627f, 
    0.01544093f, 0.13223328f, 0.06620155f, -0.12264304f, 0.12807639f, -0.44721723f, -0.04014826f, 0.25341469f, 
    0.14234878f, 0.12544833f, -0.00434924f, 0.16438946f, -0.01140515f, 0.07073978f, 0.07947003f, -0.04400523f, 
    -0.31222749f, 0.26931226f, -0.01681748f, -0.29298699f, 0.08089327f, -0.11355560f, -0.06411130f, 0.01376478f, 
    0.13338095f, 0.00220028f, 0.04584518f, 0.07772399f, -0.03585105f, 0.01106797f, -0.17443493f, -0.20884621f, 
    -0.02709125f, -0.20504162f, -0.07096305f, -0.08817620f, 0.12989688f, -0.02857582f, 0.16314419f, -0.06237321f, 
    0.07827106f, -0.14574322f, -0.06437951f, -0.06292107f, -0.09483582f, 0.01814265f, 0.00185527f, -0.04919628f, 
    -0.02228512f, 0.13609879f, 0.07621409f, 0.02559876f, 0.27634713f, -0.02015387f, -0.04235588f, -0.02529199f, 
    -0.08980494f, -0.00369452f, -0.11259229f, -0.00359060f, -0.08924537f, -0.01720686f, 0.10816662f, -0.02719201f, 
    0.47577634f, 0.20952354f, 0.11189981f, 0.01300474f, -0.14054367f, -0.06299122f, 0.04034593f, 0.01156086f, 
    0.08781943f, 0.03407284f, -0.11327132f, 0.06484579f, -0.33915827f, 0.10251117f, 0.02428660f, -0.01915275f, 
    0.02955835f, 0.01820863f, 0.06150307f, 0.10307183f, 0.02416015f, -0.01883047f, 0.04853787f, -0.07295711f, 
    -0.00008458f, -0.23406965f, -0.15903613f, -0.16345264f, -0.02950739f, -0.00844106f, 0.00653391f, 0.03538113f, 
    0.05054807f, 0.16514650f, -0.18172948f, -0.04318902f, 0.24007311f, 0.02263385f, 0.07241986f, -0.18865569f, 
    0.00848225f, -0.15556447f, 0.08353290f, 0.01416168f, 0.04485323f, -0.03339568f, 0.05571335f, -0.01935318f, 
    0.37288809f, 0.03121844f, 0.14840870f, 0.27992871f, -0.06404488f, 0.08119752f, 0.09832484f, 0.20978718f, 
    0.03255827f, 0.04235358f, 0.06978313f, 0.04210901f, -0.24018267f, 0.25177133f, 0.21616586f, 0.02649693f, 
    0.10800219f, -0.00054894f, 0.11584997f, -0.04902655f, -0.06368951f, 0.10211027f, -0.02400585f, 0.00275822f, 
    0.31964287f, 0.07159311f, 0.17888153f, 0.13310264f, -0.00434290f, 0.01651730f, -0.15467608f, 0.01645377f, 
    -0.03784456f, -0.04179741f, 0.06008629f, 0.05300768f, -0.07518817f, -0.22141927f, -0.06539688f, 0.07074232f, 
    0.15531248f, 0.04435824f, 0.07100561f, -0.09880695f, 0.01585709f, -0.00093963f, -0.06342690f, 0.09457666f, 
    0.19391003f, 0.14346430f, 0.11683100f, 0.21969938f, 0.04853747f, 0.07308604f, -0.06366181f, -0.01913827f, 
    -0.05054025f, -0.04101663f, -0.04340563f, 0.03862151f, -0.06647114f, 0.03886756f, 0.06292531f, -0.05823679f, 
    -0.06350543f, -0.00175525f, 0.14014485f, -0.07656473f, 0.01060563f, -0.02841173f, 0.07420427f, 0.04214884f, 
    0.41410667f, -0.29121625f, -0.01107445f, -0.13156626f, -0.10315444f, 0.10760524f, -0.04656265f, -0.00499225f, 
    0.07001647f, 0.07942118f, 0.11905601f, -0.02460702f, -0.06647668f, 0.19033304f, -0.04698305f, -0.09580843f, 
    -0.08770280f, 0.10188019f, 0.00583973f, -0.07513671f, -0.08560149f, 0.10094744f, 0.05635908f, -0.07783900f, 
    -0.09592828f, -0.13533176f, -0.05408647f, -0.15915723f, 0.02992645f, -0.09294467f, 0.04958146f, 0.02072229f, 
    0.05336908f, -0.03151738f, -0.03950804f, -0.03098919f, -0.68587923f, -0.10181695f, -0.12975974f, -0.18472183f, 
    0.12157567f, 0.01886481f, 0.07063659f, 0.06745397f, -0.03979577f, 0.14635484f, -0.00892386f, -0.17717366f, 
    -0.01934805f, 0.02606378f, 0.03564937f, 0.04443928f, -0.05013699f, -0.06593905f, 0.01263970f, 0.04544917f, 
    -0.05758704f, -0.06688610f, 0.03219001f, -0.01961004f, -0.02052810f, -0.06059809f, -0.02753014f, 0.05197848f, 
    0.04240910f, 0.01292175f, 0.00207415f, 0.00581397f, 0.00708772f, -0.00903494f, -0.05336711f, -0.03356032f, 
    -0.00064294f, 0.02572331f, -0.04087033f, -0.03646358f, -0.00581833f, 0.03720028f, -0.01455669f, 0.03287405f, 
    0.03965769f, -0.00424308f, -0.01602837f, -0.03930178f, -0.02963307f, 0.06363503f, 0.04127654f, 0.00753384f, 
    -0.05345416f, -0.06098155f, 0.03039010f, -0.05165430f, -0.00489769f, -0.07574542f, -0.05261235f, -0.01867045f, 
    -0.03789305f, 0.01157495f, -0.06958645f, 0.05365792f, 0.04697950f, -0.00528623f, 0.04203376f, 0.00895620f, 
    0.01803342f, -0.01131057f, -0.02015245f, -0.01124850f, -0.05139513f, -0.05206893f, -0.05450202f, 0.00602566f, 
    0.02052851f, -0.04988969f, -0.00144398f, -0.03170941f, -0.07712960f, -0.05387228f, -0.01043124f, -0.00892309f, 
    -0.04658894f, -0.04349291f, -0.05685478f, 0.03935057f, 0.03240843f, 0.04801202f, -0.03297512f, -0.01945665f, 
    -0.01183522f, 0.02227715f, 0.01935725f, 0.02320529f, -0.03559664f, -0.05403868f, -0.06897031f, -0.01941090f, 
    -0.02583600f, -0.01707743f, -0.01742911f, -0.03451563f, 0.03321962f, -0.07718313f, -0.04308822f, -0.04683482f, 
    -0.05556332f, 0.04930078f, -0.03199458f, -0.04592932f, 0.00442539f, -0.06946424f, 0.04155218f, -0.04304544f, 
    -0.03006552f, 0.03501782f, -0.05167556f, 0.00370546f, -0.00643106f, -0.02866597f, -0.05668962f, 0.02806424f, 
    -0.05258911f, -0.07485389f, 0.05803945f, 0.03349520f, -0.05820933f, -0.00155524f, -0.07149222f, 0.04629145f, 
    0.00809537f, 0.00168270f, 0.03206433f, 0.01943004f, 0.03971435f, 0.01480293f, -0.00901704f, -0.01224920f, 
    -0.05243370f, 0.04949762f, -0.01166168f, -0.06903581f, 0.01970880f, 0.01071041f, 0.00326001f, 0.03267171f, 
    0.06093579f, -0.04650433f, -0.05897365f, -0.02326363f, -0.04265514f, -0.00352801f, 0.06029404f, -0.05174074f, 
    0.03224471f, 0.06180812f, -0.03127599f, -0.04626820f, -0.02516234f, 0.02488886f, -0.06369727f, 0.00855874f, 
    -0.00356153f, -0.01794043f, -0.07460041f, 0.00574732f, -0.00763799f, -0.07189243f, 0.02172963f, 0.01586576f, 
    -0.06034297f, -0.03365075f, 0.00289722f, 0.06434929f, 0.05674309f, -0.01490244f, -0.06273118f, -0.00986291f, 
    0.00817089f, 0.01045796f, -0.01562758f, 0.05845412f, 0.00341069f, -0.05798407f, -0.00194135f, -0.02002692f, 
    -0.03727153f, -0.00485403f, -0.01728828f, 0.01360822f, -0.04871464f, -0.01737011f, 0.03534184f, 0.03403160f, 
    0.00425942f, 0.02525136f, 0.00944187f, 0.05421415f, -0.06500675f, -0.01784234f, 0.00525291f, 0.00977503f, 
    -0.01462750f, 0.11740662f, 0.05147647f, -0.38194224f, 0.18358418f, 0.15058258f, -0.04999554f, 0.04378735f, 
    -0.16669457f, 0.05320492f, -0.09790108f, 0.05862029f, 0.22394389f, -0.01460240f, 0.07555214f, -0.07324947f, 
    0.13312976f, -0.03009056f, 0.00545680f, 0.03566451f, -0.00885661f, -0.00929317f, -0.04888494f, -0.26493704f, 
    -0.40646571f, -0.04995840f, -0.12039008f, -0.18442008f, 0.02702470f, -0.02986937f, 0.03069775f, 0.14245605f, 
    0.00627416f, -0.16285533f, 0.07428930f, -0.06748590f, -0.08996097f, 0.22110987f, -0.06225443f, 0.01214005f, 
    -0.15050763f, 0.05835788f, -0.08673500f, 0.11331454f, 0.01492472f, 0.18489835f, -0.02096918f, 0.07537698f, 
    0.06923909f, 0.38001516f, 0.05346550f, -0.00636733f, 0.06483177f, 0.01011008f, -0.07482225f, -0.06219039f, 
    0.30789015f, 0.05200240f, 0.15624532f, 0.07085480f, -0.31107515f, 0.04656694f, -0.14576016f, 0.18894053f, 
    -0.06722288f, -0.04277006f, 0.07973260f, 0.00933602f, 0.25466418f, -0.03564451f, 0.06388929f, -0.12617271f, 
    0.34431419f, -0.01011306f, -0.06276659f, -0.13773876f, -0.16597396f, -0.11049025f, 0.04539533f, -0.02671816f, 
    -0.03885308f, 0.02733568f, 0.00475354f, -0.01382430f, 0.17468463f, -0.10877229f, -0.36910346f, 0.01014004f, 
    0.12065537f, -0.02543143f, 0.05332577f, -0.06625404f, -0.10231777f, 0.01511301f, 0.07710738f, 0.01476913f, 
    0.09567310f, 0.19991587f, -0.11472732f, -0.09884489f, -0.24772464f, -0.02716817f, -0.05670255f, -0.21656044f, 
    0.02413909f, 0.04157273f, -0.05945459f, -0.03958702f, -0.30244949f, 0.23339593f, -0.11664191f, 0.01009737f, 
    0.00841492f, -0.00091157f, 0.04936506f, 0.01287496f, 0.07363836f, -0.01559836f, 0.09860665f, -0.10145798f, 
    -0.36782020f, -0.00061203f, 0.00922799f, -0.29413527f, -0.01646391f, 0.10149600f, 0.03385533f, -0.00217402f, 
    0.03497556f, -0.10962402f, -0.02510572f, 0.06364473f, -0.24937536f, 0.21535571f, -0.15664040f, 0.08215948f, 
    0.16508283f, 0.05707609f, 0.05191195f, 0.09677305f, -0.03010129f, 0.15447101f, 0.04380422f, 0.07788311f, 
    0.49359441f, -0.07022186f, 0.03000843f, 0.17069887f, 0.02735400f, 0.01954191f, 0.11981373f, -0.01576645f, 
    0.09758348f, -0.03078193f, -0.02479666f, 0.08501593f, -0.16425189f, -0.17535564f, -0.18574335f, -0.07412896f, 
    0.06971098f, -0.07086675f, -0.03481771f, -0.02845801f, -0.04301475f, 0.02673652f, 0.13429378f, 0.12171347f, 
    0.07621701f, 0.18862723f, -0.15323119f, 0.17377792f, 0.37914008f, 0.17793235f, 0.10941926f, -0.12688227f, 
    0.07658485f, 0.07841691f, 0.04340338f, -0.03179790f, 0.32262892f, 0.00045831f, 0.10899658f, 0.52247190f, 
    0.14368008f, -0.07817516f, -0.04524205f, 0.05233784f, 0.03993700f, 0.06698374f, -0.01641655f, 0.01206369f, 
    -0.02660443f, -0.08471343f, 0.13421996f, 0.17546348f, -0.08288104f, -0.17179178f, -0.07717929f, 0.02547081f, 
    0.29709882f, -0.14643528f, 0.09351730f, 0.03256328f, -0.27445075f, 0.20728768f, -0.22495393f, 0.07227275f, 
    -0.05916931f, -0.06947767f, -0.13135427f, 0.00806765f, 0.01227281f, 0.18854930f, 0.19002835f, 0.14652915f, 
    0.05080345f, 0.02252088f, -0.02836518f, 0.21743071f, 0.18317346f, 0.18029176f, -0.02424286f, -0.04893943f, 
    -0.08377152f, 0.19776911f, 0.09760842f, 0.07973553f, -0.05050711f, -0.39876246f, -0.00897153f, -0.03220134f, 
    0.03092234f, 0.07569490f, 0.05936902f, -0.08490767f, 0.07384249f, -0.07377144f, 0.04748537f, -0.04639638f, 
    -0.14547719f, -0.24119703f, -0.16641949f, 0.00294860f, -0.05258766f, 0.16863310f, 0.02529897f, 0.08232129f, 
    -0.08768186f, -0.11866944f, -0.12631038f, 0.06626637f, 0.06268039f, 0.00815880f, 0.20135124f, -0.23893315f, 
    0.04477446f, 0.07944255f, -0.00614757f, 0.00355396f, -0.11546175f, 0.05913832f, -0.02022620f, 0.00604506f, 
    -0.02066039f, 0.01961782f, 0.07073396f, -0.01954884f, 0.10956782f, -0.04654703f, 0.02676377f, 0.11498451f, 
    0.10262099f, 0.04475702f, 0.10705121f, 0.09155969f, 0.07547046f, 0.08145475f, 0.14620262f, -0.27250949f, 
    0.00752544f, 0.06481877f, -0.04115568f, 0.00015621f, 0.03618601f, 0.06778380f, 0.03574228f, -0.08047018f, 
    -0.14617595f, -0.05763996f, 0.15608275f, -0.08059256f, 0.05416474f, 0.08236056f, 0.05432966f, 0.11664413f, 
    -0.05608913f, -0.00965181f, 0.19564271f, -0.04333337f, 0.20348053f, -0.10561501f, -0.03101631f, -0.09612869f, 
    0.08681393f, -0.12769537f, -0.08152339f, -0.02876874f, 0.09582856f, 0.02373304f, -0.10737455f, 0.17545462f, 
    -0.04368572f, -0.13875237f, -0.05814162f, 0.40845400f, 0.04132526f, -0.00451493f, -0.05778065f, 0.06679437f, 
    0.13448474f, 0.07515346f, 0.03009073f, 0.05845321f, 0.41483074f, 0.00310768f, 0.09299975f, -0.09674948f, 
    0.01811236f, 0.05160845f, 0.05490604f, -0.11672786f, -0.03164658f, -0.11388210f, 0.09487704f, 0.00880766f, 
    -0.00778669f, 0.11782339f, -0.14439362f, 0.14490359f, 0.08010184f, -0.07195235f, -0.01777293f, 0.00571207f, 
    0.12597929f, 0.03344739f, 0.02424373f, 0.00171198f, 0.26366392f, 0.15553305f, 0.17127462f, -0.10599426f, 
    -0.03518296f, 0.04727976f, 0.12259027f, -0.16007885f, 0.00981526f, -0.02039081f, 0.03797026f, 0.05744351f, 
    -0.10565539f, 0.05918871f, 0.08950478f, -0.02479942f, -0.12377479f, 0.14343889f, -0.02870765f, 0.04715705f, 
    -0.01572359f, 0.11210115f, -0.06822386f, 0.07936759f, -0.28552160f, -0.05610964f, -0.08978248f, -0.33569506f, 
    -0.03901842f, 0.07425679f, 0.14858843f, -0.16003442f, 0.24787226f, 0.18799065f, 0.14176154f, -0.00477123f, 
    0.01297071f, 0.00177081f, 0.01123620f, -0.01077754f, 0.02330943f, 0.05509442f, -0.04633576f, -0.01441941f, 
    0.05519273f, 0.01872035f, 0.02158907f, -0.03396799f, -0.06971503f, -0.05012376f, 0.00942326f, -0.02480804f, 
    0.04342133f, 0.00700586f, -0.01077408f, -0.00360488f, -0.05973382f, -0.05315794f, -0.02107425f, 0.05001681f, 
    0.01813140f, -0.05612451f, -0.03677467f, -0.06904642f, -0.07485779f, -0.00356204f, -0.01376318f, -0.06045424f, 
    -0.01550669f, 0.06002585f, 0.01168031f, -0.06493392f, -0.02477326f, 0.04275717f, -0.06010806f, 0.06084736f, 
    0.04722684f, 0.04368398f, 0.02504383f, -0.07182579f, -0.02702449f, 0.00620153f, 0.06185874f, -0.05432007f, 
    0.02387725f, 0.05362273f, -0.05374220f, -0.01968561f, -0.02415480f, -0.05429300f, 0.01240883f, -0.05369333f, 
    0.00475031f, -0.04531248f, -0.05800954f, -0.04855624f, 0.05440574f, -0.06527431f, 0.04020865f, -0.02363459f, 
    -0.01634328f, -0.03002656f, 0.06960407f, 0.00017691f, 0.05646326f, -0.03447283f, -0.03250000f, 0.05463483f, 
    0.06647032f, -0.03680430f, 0.03261381f, 0.01047513f, 0.05104988f, -0.01387071f, 0.01755643f, -0.01833766f, 
    -0.03626342f, -0.01845959f, -0.07023758f, -0.04231903f, -0.00945452f, -0.05341357f, -0.00399370f, 0.01063054f, 
    -0.01937809f, 0.00657191f, -0.00778676f, -0.07163915f, -0.03036953f, -0.05263617f, 0.03348589f, 0.02242084f, 
    0.02704558f, 0.03702385f, -0.01098539f, -0.05805122f, 0.05872715f, 0.02524632f, -0.07143340f, 0.04149428f, 
    -0.02858924f, 0.05950536f, 0.02269348f, 0.00264230f, -0.01891177f, 0.03197340f, -0.00990444f, -0.07501241f, 
    -0.04564974f, -0.03320730f, 0.03321990f, 0.01935550f, -0.03659723f, -0.05094419f, -0.04502640f, 0.01820981f, 
    -0.07518251f, 0.03048372f, 0.01049644f, 0.05775667f, -0.07569946f, -0.01087693f, 0.00761132f, -0.03508211f, 
    -0.05762818f, -0.00720480f, -0.07610425f, 0.04334015f, -0.03591137f, 0.04842578f, 0.05993934f, 0.00522207f, 
    -0.02340926f, -0.06932690f, -0.05233136f, 0.00113597f, -0.05264775f, -0.06249722f, -0.06865946f, -0.04670305f, 
    -0.06521968f, 0.03653005f, -0.04262863f, -0.02621963f, -0.00840422f, -0.07013462f, 0.03281986f, -0.05373890f, 
    -0.04517205f, 0.00888151f, 0.04040192f, 0.00116012f, 0.02865045f, -0.02984845f, 0.00689751f, -0.00124987f, 
    0.05335613f, -0.00022275f, 0.01454596f, -0.04644650f, 0.02166515f, -0.07099989f, 0.02205681f, -0.03961774f, 
    -0.07421578f, 0.06121772f, -0.02870754f, 0.01137739f, -0.02796722f, -0.01793265f, 0.01985573f, -0.00206954f, 
    -0.01687669f, -0.05638926f, 0.00023699f, 0.02395429f, 0.05674638f, -0.01967400f, -0.01914801f, -0.01737465f, 
    0.03290623f, 0.00244994f, 0.02433747f, 0.02141985f, 0.01033526f, -0.04496823f, -0.06491716f, -0.06752267f, 
    -0.00957883f, 0.06609870f, -0.07297006f, -0.00719755f, 0.00341047f, -0.04398356f, -0.00900717f, -0.02547792f, 
    -0.02635942f, 0.05144880f, 0.04947029f, -0.00104179f, -0.06141600f, -0.04930692f, -0.04876480f, -0.06198793f, 
    -0.06074122f, -0.02871440f, -0.00110519f, -0.05605593f, 0.06630626f, -0.00304234f, 0.00866239f, -0.05597768f, 
    0.05622489f, -0.01910537f, -0.05041008f, 0.04527698f, 0.05876846f, 0.05642643f, 0.02020613f, -0.00370516f, 
    -0.02782437f, -0.05147388f, -0.01761201f, -0.03022549f, 0.04404048f, -0.02731446f, 0.02324016f, 0.04423024f, 
    -0.06236936f, -0.03613134f, -0.02154892f, 0.02986297f, 0.02978134f, -0.03508220f, -0.00527972f, -0.02558112f, 
    0.01221158f, -0.04420243f, -0.02528022f, 0.04694162f, -0.04455327f, -0.03147715f, -0.06787559f, -0.00464644f, 
    0.00070837f, -0.06577307f, -0.03375236f, 0.00733626f, 0.06037156f, 0.01540676f, -0.05255908f, -0.03324596f, 
    -0.04934994f, -0.05823147f, 0.03370447f, -0.02289970f, -0.06050108f, 0.01526141f, -0.00408071f, -0.05473293f, 
    -0.07257682f, 0.02741871f, 0.05890089f, -0.06241210f, -0.06053131f, 0.02983784f, 0.06226002f, 0.03882191f, 
    0.01620878f, 0.01885172f, -0.02620467f, -0.01843720f, 0.03773192f, 0.00020062f, -0.06444353f, -0.07504082f, 
    -0.00689670f, -0.07214258f, -0.04240458f, 0.02167149f, 0.03057704f, 0.02072683f, 0.02149112f, 0.05687632f, 
    0.03776131f, -0.06265780f, -0.04647044f, 0.02200182f, 0.04380654f, -0.02246673f, 0.00145807f, 0.05454620f, 
    -0.02433206f, -0.02420974f, 0.00207226f, -0.02000351f, -0.02879642f, -0.05880282f, -0.04279360f, -0.03810610f, 
    0.03667251f, -0.02915314f, -0.01283410f, 0.03520342f, -0.02224065f, -0.05166654f, -0.03433183f, 0.06445840f, 
    -0.02501675f, -0.06849433f, 0.05172499f, 0.02044903f, 0.01667025f, -0.03975375f, 0.03840187f, 0.03869802f, 
    -0.01417091f, -0.02041361f, 0.06597147f, -0.01204137f, 0.02799613f, -0.04323107f, 0.00203126f, -0.04583011f, 
    -0.01755520f, 0.00171166f, -0.07279848f, -0.06432878f, -0.02830164f, -0.03137123f, -0.07219193f, -0.06945103f, 
    0.00538893f, 0.04906406f, -0.02018368f, 0.01268397f, -0.07409562f, 0.04318813f, 0.06088051f, 0.06421196f, 
    -0.07483543f, -0.04805852f, 0.02510479f, 0.06133459f, -0.00063317f, 0.02174214f, 0.01341464f, -0.04606151f, 
    -0.04037848f, -0.06329076f, -0.05267784f, -0.00450742f, 0.03544610f, -0.07324480f, -0.00369709f, 0.01627872f, 
    -0.04420429f, 0.01404267f, -0.03686018f, 0.05255098f, -0.06843764f, -0.04166927f, 0.04631492f, -0.06375101f, 
    0.01281268f, 0.02699864f, -0.04218917f, -0.00399660f, -0.04258969f, -0.05123682f, 0.00319293f, 0.03684722f, 
    0.06044067f, -0.02281347f, 0.05656300f, 0.02067113f, 0.00251487f, -0.06274563f, 0.03187113f, -0.06651893f, 
    -0.26859021f, -0.18091008f, 0.14457834f, -0.39033726f, -0.00941466f, 0.05094776f, 0.00421491f, -0.01592078f, 
    0.01933127f, -0.15358961f, -0.06402370f, 0.12149066f, -0.21247877f, 0.06872348f, 0.00408114f, -0.02448179f, 
    0.00572330f, -0.12618855f, -0.11098874f, 0.00541731f, -0.17423950f, -0.06047992f, -0.14563952f, -0.12518796f, 
    -0.33718258f, -0.01840851f, 0.02313573f, -0.15896398f, 0.23459890f, 0.13906063f, -0.02420352f, -0.05077541f, 
    0.04456951f, -0.12551707f, 0.12911439f, 0.08709329f, -0.29368237f, -0.03034933f, 0.13299750f, -0.05806127f, 
    0.10311114f, -0.03372404f, -0.14391324f, 0.01930241f, 0.09159174f, -0.02785921f, -0.04505589f, 0.14669229f, 
    -0.12516713f, 0.23581818f, 0.16543175f, 0.15083241f, -0.02143556f, -0.02785305f, -0.18175681f, -0.03629710f, 
    0.12759922f, 0.03485900f, -0.16589543f, 0.24315557f, -0.06227595f, 0.07146657f, 0.22250023f, -0.02171599f, 
    0.17488161f, -0.00211157f, 0.05306827f, 0.16958718f, 0.23872623f, 0.17047232f, 0.04074035f, -0.05817537f, 
    0.12464126f, -0.02861773f, -0.04291337f, -0.06077572f, -0.09138162f, 0.01779937f, 0.00159543f, 0.05993586f, 
    -0.17008552f, -0.01995935f, -0.09620459f, -0.09002953f, 0.21461174f, 0.09172775f, -0.33156312f, -0.17733175f, 
    0.24934988f, 0.08176477f, -0.05173046f, -0.02783082f, -0.17185895f, -0.11625766f, -0.13792227f, -0.16140378f, 
    0.24577399f, 0.12204073f, 0.38434806f, 0.01549546f, -0.11485092f, -0.12732513f, -0.13909481f, -0.24014166f, 
    -0.09269030f, 0.04165291f, -0.07189459f, -0.03185824f, 0.03585689f, -0.01577859f, -0.21548371f, 0.04068533f, 
    -0.03279305f, 0.09491235f, -0.01916497f, 0.03109965f, 0.15599266f, -0.13128477f, 0.09152988f, 0.07069796f, 
    -0.25956503f, 0.15023331f, -0.17865992f, -0.11626877f, 0.18508510f, 0.07670690f, -0.02488501f, 0.02060691f, 
    0.11419042f, -0.12274018f, 0.09653129f, 0.06172410f, 0.24446265f, 0.06112242f, -0.17280838f, 0.07333111f, 
    -0.02373137f, 0.03519044f, 0.10253521f, 0.04729498f, 0.09898718f, -0.07060473f, 0.03881818f, 0.23256937f, 
    0.30495334f, 0.00652892f, -0.01686382f, 0.12259813f, -0.12635209f, 0.15384050f, 0.03673614f, 0.18755251f, 
    -0.02112232f, 0.03137224f, 0.03804440f, 0.02836033f, 0.21047962f, 0.10881583f, -0.29610610f, -0.11909235f, 
    -0.07609826f, -0.08135744f, 0.06860516f, -0.22070311f, -0.12159465f, -0.08805771f, 0.09035011f, 0.03119163f, 
    0.19887406f, 0.24652496f, -0.10513905f, 0.28307170f, 0.15855169f, 0.14118946f, 0.03250799f, 0.19308765f, 
    -0.17397386f, 0.03799358f, -0.20161977f, 0.12317509f, 0.13341680f, 0.04611850f, 0.09893763f, 0.31551805f, 
    0.13653724f, 0.08933906f, 0.05241835f, 0.12828703f, 0.05564551f, -0.00865312f, 0.02195954f, 0.01909156f, 
    -0.05162549f, -0.00659262f, 0.04585170f, 0.06050754f, -0.00939526f, 0.04406948f, 0.03331351f, -0.03074682f, 
    0.01809855f, 0.05561511f, -0.04293934f, 0.02200019f, 0.03646576f, 0.01926022f, -0.04237092f, -0.03416256f, 
    -0.04927585f, 0.05686391f, -0.01339375f, 0.06054194f, 0.02315755f, 0.01133494f, 0.04833507f, 0.05061654f, 
    0.06014636f, -0.06961683f, 0.00242500f, -0.04243452f, -0.04524599f, -0.03986555f, 0.05194823f, 0.06164226f, 
    -0.00988502f, 0.00633883f, 0.03361233f, -0.07014804f, -0.03904298f, -0.06035369f, -0.02094253f, -0.03385279f, 
    -0.06627835f, -0.03253808f, 0.04423818f, 0.01461980f, 0.02068572f, -0.01640345f, -0.00892482f, -0.04000681f, 
    0.00490741f, 0.02687176f, 0.02260386f, -0.03043968f, 0.05849524f, 0.00524968f, -0.02617596f, -0.01409540f, 
    0.00407767f, -0.02123746f, -0.01528510f, 0.01402419f, 0.03904309f, 0.02571646f, -0.00999088f, 0.06207019f, 
    -0.07605974f, -0.07021591f, -0.03006179f, 0.06083023f, 0.01569453f, -0.04248318f, -0.03943514f, 0.02572046f, 
    0.01908574f, 0.05557825f, -0.04915140f, 0.02823164f, -0.02020993f, 0.05946083f, 0.03404162f, -0.04673710f, 
    -0.01023675f, 0.03718994f, -0.00552562f, 0.02968224f, 0.03220661f, -0.06833844f, -0.00966694f, 0.03074680f, 
    -0.04695151f, -0.01743133f, -0.03693346f, -0.03925586f, -0.07425237f, -0.03723762f, 0.03040886f, -0.03438399f, 
    0.06104168f, -0.04136513f, -0.04379661f, -0.01468952f, 0.03926685f, 0.00035067f, -0.04316335f, 0.01396994f, 
    -0.05223446f, -0.06917015f, 0.02708954f, -0.03627408f, -0.03557069f, 0.02043824f, -0.05693616f, -0.00703470f, 
    -0.02372943f, 0.05815706f, -0.05116023f, -0.05487694f, -0.00602854f, -0.07568213f, -0.02825500f, -0.01485579f, 
    0.02421233f, -0.01323313f, -0.06924087f, -0.02508212f, -0.05205427f, -0.03758742f, -0.02564520f, -0.04101171f, 
    0.03804270f, 0.03401244f, -0.06642929f, 0.03422238f, 0.03528293f, -0.06713759f, -0.05001983f, -0.05107892f, 
    -0.00178604f, 0.04404154f, -0.01202047f, -0.06287974f, -0.03922318f, -0.03731407f, 0.04450912f, 0.02820831f, 
    -0.04173848f, -0.04552722f, -0.05028237f, -0.03355081f, -0.03882228f, 0.01547607f, 0.01876188f, -0.00319010f, 
    -0.00341733f, -0.01263999f, -0.02643926f, -0.02884145f, -0.03474810f, -0.06193126f, 0.01288093f, -0.01132378f, 
    -0.03137923f, -0.02033585f, -0.04663798f, -0.04636893f, -0.01926786f, 0.04717315f, 0.02434595f, -0.02593268f, 
    0.04188187f, 0.06332671f, 0.03014354f, -0.04044372f, 0.02500938f, -0.06530239f, -0.00068899f, -0.02343968f, 
    -0.03087146f, -0.00766628f, 0.01932651f, -0.02065282f, -0.01937542f, -0.04246539f, -0.02513376f, -0.07146334f, 
    -0.00737365f, 0.01107366f, -0.03036245f, -0.02971251f, 0.03608554f, -0.05407148f, -0.07021455f, -0.05633370f, 
    0.23318395f, -0.44683200f, -0.01121179f, 0.21219407f, -0.25971076f, -0.04717003f, 0.05331033f, -0.08758578f, 
    0.01157236f, -0.03848825f, 0.07539474f, 0.05467761f, 0.10295001f, -0.05409408f, -0.14126752f, 0.03733837f, 
    -0.00249016f, 0.02053546f, -0.06985021f, -0.07864294f, 0.08396214f, 0.00839749f, 0.08086512f, -0.02996353f, 
    0.18279079f, 0.31678304f, 0.03972367f, 0.13886259f, -0.00524969f, 0.10220187f, 0.05516196f, -0.14426370f, 
    -0.02129979f, 0.05016934f, 0.02048372f, -0.05210935f, -0.04063949f, 0.15225480f, 0.01261863f, -0.03926334f, 
    0.25528124f, -0.00570848f, 0.12287087f, -0.05418094f, 0.12413786f, -0.14291282f, 0.10764719f, -0.09009071f, 
    0.09895208f, -0.23624583f, -0.06610249f, 0.09585100f, -0.11938740f, 0.06957155f, -0.11647593f, 0.11266031f, 
    -0.03173995f, 0.05634176f, -0.12637526f, -0.05295734f, 0.27774179f, 0.07744589f, 0.30547780f, -0.29433054f, 
    0.03279432f, -0.05745898f, 0.04586010f, 0.17899361f, 0.06237501f, 0.02036998f, -0.01476051f, 0.06163451f, 
    0.19971231f, 0.17669347f, 0.25450689f, 0.02861660f, 0.06714283f, 0.22382846f, 0.07971510f, 0.07377435f, 
    0.06967068f, 0.13357119f, -0.00923292f, 0.10910852f, -0.27182260f, 0.24858747f, 0.15675847f, -0.06513419f, 
    0.07601994f, 0.06692080f, 0.12669840f, 0.07021500f, -0.11674879f, -0.00220820f, 0.02122809f, -0.03413607f, 
    0.42476735f, -0.20061782f, 0.32054293f, 0.14812119f, 0.13057721f, 0.15573134f, -0.01079253f, 0.01476713f, 
    -0.01311191f, 0.01377739f, -0.03150715f, 0.06499146f, 0.22146462f, -0.24290854f, -0.15341307f, -0.01090084f, 
    -0.06879197f, -0.02485612f, -0.06994855f, -0.04233320f, -0.11682997f, -0.00621260f, 0.01620876f, -0.08456418f, 
    0.17101803f, 0.12526993f, -0.13544685f, 0.58887839f, -0.04605992f, 0.00114694f, 0.04820399f, -0.02029763f, 
    -0.19401516f, 0.03548170f, 0.02442029f, -0.14320382f, 0.19622564f, -0.13232371f, -0.16395155f, -0.11401521f, 
    -0.03329700f, -0.06090555f, 0.06810335f, -0.13711955f, -0.09398707f, -0.07143325f, -0.00907469f, -0.02132688f, 
    0.34903759f, -0.25466087f, 0.15879408f, -0.00409427f, -0.09714585f, -0.03015996f, -0.10960417f, -0.06770074f, 
    0.02932182f, 0.24094109f, 0.02609879f, -0.04667879f, 0.08000164f, 0.39141840f, -0.10077448f, -0.01596704f, 
    -0.09591935f, 0.13337748f, -0.02021581f, -0.31029183f, -0.12935536f, 0.10388250f, -0.08122546f, -0.08440191f, 
    -0.20594092f, -0.02213689f, 0.15125978f, -0.24957900f, -0.12340087f, 0.02768493f, -0.04319631f, 0.21998364f, 
    -0.08609013f, -0.05645585f, -0.13105123f, 0.15633209f, -0.40408647f, 0.13935119f, -0.09367103f, -0.09847847f, 
    0.02880725f, -0.01643437f, -0.00612490f, -0.01266222f, 0.05669038f, 0.11576936f, 0.02596472f, -0.12254463f, 
    0.07200703f, -0.08792687f, 0.05857979f, 0.11832234f, -0.00282775f, 0.10682882f, 0.00236748f, -0.10639659f, 
    -0.02726957f, 0.12343638f, -0.09698513f, 0.00211140f, -0.03668235f, -0.35743612f, 0.20769762f, -0.12710531f, 
    -0.04346938f, 0.01536824f, 0.06402545f, 0.01534082f, 0.14581102f, -0.08728578f, -0.13054852f, -0.03370048f, 
    -0.00031623f, 0.04248207f, -0.04019201f, 0.06585924f, 0.05013654f, 0.00593413f, 0.03574449f, -0.04176946f, 
    -0.06858595f, 0.01518573f, 0.09718261f, -0.11120202f, 0.36705375f, 0.14731142f, 0.11339262f, 0.04796295f, 
    0.08408110f, -0.12098324f, 0.05083342f, 0.05785053f, -0.05290119f, 0.13229023f, 0.05118525f, 0.09521019f, 
    0.01672131f, -0.09123538f, 0.17639638f, -0.09635468f, 0.03594111f, -0.03478483f, 0.00483067f, -0.14100139f, 
    -0.09040684f, -0.00820325f, 0.20079112f, 0.27770960f, -0.09295178f, 0.24245822f, -0.08314421f, 0.15338530f, 
    0.03775587f, -0.08591589f, 0.00650176f, 0.07273499f, 0.09517944f, 0.03261360f, 0.08533245f, 0.00449011f, 
    -0.33998677f, 0.02823118f, 0.25220624f, 0.19582361f, 0.04409679f, 0.00722675f, -0.01092666f, 0.15381552f, 
    -0.11283005f, 0.09563246f, 0.03242613f, 0.08385507f, -0.23656857f, 0.17342567f, -0.02388579f, 0.07879993f, 
    -0.05608213f, 0.13149028f, -0.10378673f, 0.09354941f, 0.00667576f, 0.03139420f, 0.05628419f, -0.12751271f, 
    0.05952841f, -0.02730715f, 0.08075779f, 0.15115330f, 0.07607580f, -0.04968875f, 0.06280589f, -0.01022690f, 
    -0.00077519f, -0.02046343f, -0.09072489f, 0.05497970f, -0.06424040f, 0.07678135f, 0.13741602f, 0.01897898f, 
    -0.02665195f, 0.06214467f, -0.02003543f, 0.12434231f, -0.01302903f, -0.11644744f, 0.21733095f, -0.12422834f, 
    0.23845103f, 0.44308767f, 0.02721884f, -0.06615740f, -0.08295213f, 0.06750398f, 0.22891039f, 0.01271617f, 
    0.02661135f, 0.03526575f, -0.00874963f, -0.05291447f, -0.15238117f, -0.24314389f, 0.14735879f, -0.02049438f, 
    0.02628266f, 0.03863450f, -0.05639850f, -0.02850765f, 0.07564881f, 0.20185523f, -0.03399621f, 0.10238657f, 
    -0.40625840f, 0.02325968f, 0.25916916f, -0.01496100f, -0.02426821f, -0.01209763f, 0.09807767f, -0.09670659f, 
    -0.04691429f, 0.06437085f, -0.07326987f, 0.12606563f, -0.14544149f, 0.31334889f, -0.05815690f, -0.00080882f, 
    0.03182156f, -0.10872914f, -0.11569973f, -0.05963036f, -0.06389142f, -0.06267715f, -0.04267590f, -0.06149377f, 
    0.07302591f, -0.05843563f, -0.14130527f, 0.12005848f, -0.10041509f, 0.03367072f, 0.03954794f, -0.02149672f, 
    0.00114378f, -0.03668908f, 0.00798843f, -0.01784147f, 0.07332750f, 0.13440363f, 0.22405720f, 0.02508255f, 
    -0.11988992f, -0.06834593f, -0.01319807f, 0.01690813f, -0.07380422f, -0.18479963f, -0.04824607f, 0.03188605f, 
    0.05750168f, -0.11469675f, -0.01959679f, -0.24492058f, -0.01190668f, -0.09208938f, 0.01473745f, 0.09206896f, 
    0.10826641f, 0.07659447f, 0.09845062f, 0.09914898f, 0.29692444f, 0.20623502f, -0.29519236f, -0.17208771f, 
    -0.03448298f, 0.03616543f, -0.13137338f, 0.05095013f, -0.04373345f, -0.00273297f, 0.05955693f, -0.15413229f, 
    -0.08722970f, 0.19478023f, 0.02022836f, -0.01781202f, 0.06243089f, -0.11935958f, 0.03726538f, 0.04965955f, 
    0.02977147f, -0.10868879f, 0.02133605f, 0.06210444f, -0.20092762f, -0.42315969f, 0.06054780f, 0.12590346f, 
    -0.02674227f, 0.06353156f, 0.03386247f, 0.05184447f, 0.05419317f, 0.06547354f, 0.10055564f, -0.02599918f, 
    -0.12611654f, -0.00194145f, -0.33800906f, -0.02012756f, -0.11444992f, 0.06833476f, 0.03111804f, -0.07648229f, 
    0.00279198f, 0.13220960f, 0.09286904f, 0.01083637f, 0.36160916f, 0.12833093f, 0.38417155f, -0.00262775f, 
    0.16847013f, -0.09414659f, -0.02343926f, 0.15384851f, 0.05298577f, 0.05841474f, 0.08785836f, -0.03903762f, 
    0.10964850f, -0.06655243f, -0.04978443f, 0.18024087f, 0.12828773f, 0.13303198f, 0.13209520f, 0.08580106f, 
    -0.01409552f, 0.15388227f, -0.01629255f, 0.00973482f, 0.16773008f, 0.30513108f, 0.02588639f, -0.30594459f, 
    0.13379885f, 0.11357467f, 0.09318097f, -0.07143219f, -0.06248438f, -0.01311274f, -0.12392406f, -0.06356200f, 
    -0.20831738f, -0.03211282f, -0.01792825f, 0.18751128f, -0.00349066f, 0.02571055f, -0.16675846f, -0.03015327f, 
    -0.02222436f, 0.03222894f, 0.13116741f, -0.09506896f, 0.26055989f, -0.00163752f, -0.15897515f, 0.02682178f, 
    0.18672423f, 0.11645672f, -0.03511538f, -0.11076771f, 0.00560412f, 0.02884520f, -0.06927451f, 0.15042837f, 
    -0.34227231f, 0.24715099f, 0.03837897f, -0.06645376f, 0.13077879f, 0.00951358f, 0.05678913f, -0.02717912f, 
    -0.00779310f, 0.02250651f, 0.03144649f, 0.04383279f, 0.43553215f, 0.11175005f, 0.20766896f, 0.14140418f, 
    -0.07426505f, -0.05968139f, 0.22010250f, 0.04640100f, -0.06422429f, -0.05393277f, 0.04183012f, 0.12694356f, 
    0.36035550f, -0.44161841f, 0.04919900f, -0.14582820f, 0.04421484f, -0.06327447f, -0.11605696f, -0.00641107f, 
    0.02462988f, 0.04274105f, 0.08874626f, 0.01089993f, 0.31275427f, 0.21475448f, -0.19192967f, -0.19402339f, 
    0.04103646f, -0.03024939f, -0.04461708f, 0.08439711f, -0.02383157f, -0.07241745f, 0.01691243f, 0.05945576f, 
    -0.15646814f, 0.20256691f, 0.09201698f, 0.13858220f, -0.01113720f, 0.08621063f, -0.03408277f, 0.04422092f, 
    0.06143151f, 0.07107409f, -0.03734791f, 0.10622670f, -0.50869405f, -0.13942558f, 0.13103260f, -0.04799039f, 
    0.01738122f, 0.11340438f, 0.02713806f, -0.03101729f, -0.03872794f, 0.01045008f, 0.03231243f, -0.04369660f, 
    -0.07779619f, 0.06798023f, -0.01028540f, 0.09991850f, 0.01155952f, 0.06586774f, -0.03949330f, 0.03953915f, 
    0.12000562f, -0.03659552f, -0.06677931f, 0.04157981f, -0.11299953f, 0.02457011f, 0.02222520f, 0.19810043f, 
    0.04885783f, 0.01838158f, -0.02415115f, 0.02606800f, 0.02165162f, 0.09544137f, -0.05369895f, -0.08826482f, 
    -0.13272679f, -0.07575206f, -0.28867355f, -0.03539386f, 0.07724084f, 0.07935245f, 0.20059130f, 0.00241570f, 
    -0.07563485f, -0.02822734f, 0.19713494f, -0.00353180f, 0.42339522f, 0.51201957f, -0.09558763f, 0.00386921f, 
    0.20358217f, 0.00241743f, -0.05586753f, 0.08312032f, -0.00917219f, 0.06869574f, 0.06616796f, -0.01287568f, 
    0.20914227f, 0.06616858f, 0.23506862f, -0.04117925f, 0.10513458f, 0.16918132f, -0.10833707f, -0.07522886f, 
    0.09984879f, 0.02057911f, -0.06596006f, 0.17062505f, -0.41762012f, -0.20762110f, 0.08875397f, -0.03081514f, 
    0.01473110f, -0.03277121f, 0.15144463f, 0.15913753f, 0.15695803f, 0.04172916f, 0.01115571f, -0.15644757f, 
    0.01089511f, 0.26114714f, 0.40880787f, 0.06855654f, -0.12257030f, -0.13488945f, 0.08452384f, 0.05114346f, 
    -0.10498526f, 0.04898704f, 0.22695860f, 0.00927327f, -0.19510068f, -0.16529542f, -0.22037768f, -0.14329623f, 
    0.03000512f, -0.00391761f, -0.11829907f, 0.07424010f, -0.01493093f, -0.02863889f, 0.06829206f, -0.15509512f, 
    0.19031955f, 0.07019271f, 0.11855813f, -0.13502233f, 0.02392143f, -0.10329698f, 0.08525755f, 0.04919700f, 
    0.03255617f, 0.01087850f, -0.06564047f, 0.07648551f, -0.29300171f, -0.04294188f, 0.12949727f, -0.07557765f, 
    -0.06044665f, -0.05389759f, 0.03766339f, 0.13920411f, 0.00516630f, -0.13841049f, 0.00704466f, -0.18601808f, 
    0.09474847f, -0.09390904f, -0.23046044f, 0.13627771f, 0.08525206f, -0.04923572f, 0.04812765f, 0.14454938f, 
    0.13033175f, -0.00000515f, 0.06550153f, 0.04775242f, -0.04989503f, -0.03050731f, -0.05653392f, -0.23061447f, 
    0.13261691f, -0.03765211f, -0.00256097f, -0.10889679f, 0.08670031f, 0.15240681f, -0.00807786f, -0.01933999f, 
    0.25412643f, 0.19493493f, 0.03338935f, 0.28950685f, -0.13525517f, -0.04818933f, -0.11504898f, -0.08787090f, 
    -0.03805395f, -0.03817651f, -0.09684030f, 0.12030846f, -0.10441452f, -0.02361004f, 0.01045548f, 0.01355185f, 
    0.09208126f, 0.04896933f, 0.01071299f, -0.17190811f, -0.08220413f, 0.04036158f, -0.15375428f, 0.02994562f, 
    -0.16288657f, -0.00456847f, -0.09781144f, 0.13952219f, 0.03149154f, 0.14541130f, 0.00601923f, 0.04437679f, 
    -0.05055917f, 0.23156054f, -0.04093984f, 0.08990881f, 0.29673246f, 0.09656716f, -0.09057853f, 0.04949871f, 
    -0.01790780f, 0.04507091f, 0.11903544f, 0.10216534f, -0.02423646f, 0.08580962f, -0.03545858f, -0.00050343f, 
    0.09149837f, 0.06589491f, 0.09909916f, 0.14554690f, 0.06912434f, 0.03438604f, 0.05686980f, 0.01066529f, 
    -0.00964352f, 0.15269239f, 0.22625104f, 0.07057083f, 0.34297165f, 0.09423345f, 0.01328257f, -0.06654757f, 
    0.11769708f, 0.23317449f, 0.04230174f, 0.03496237f, -0.05415639f, -0.01674406f, 0.08234185f, 0.10310137f, 
    0.21379642f, 0.15415174f, 0.09751517f, -0.03068440f, -0.22031926f, -0.10905966f, -0.07404184f, -0.15992355f, 
    -0.05047236f, 0.08077886f, -0.02127795f, 0.10018266f, 0.22337773f, 0.05169168f, 0.05598218f, -0.07776112f, 
    -0.06779917f, -0.02644582f, -0.10154577f, 0.02626840f, -0.09020878f, -0.01123878f, 0.12800175f, 0.02538703f, 
    0.18056841f, 0.17276230f, -0.17071657f, -0.03464230f, 0.09448943f, -0.01548420f, 0.09030899f, 0.05798326f, 
    0.04481882f, -0.04861319f, 0.04204561f, 0.05544775f, 0.28514892f, 0.19568686f, -0.16113718f, 0.02992305f, 
    -0.05724595f, 0.10123541f, 0.03054953f, -0.06987789f, -0.08935071f, -0.08242847f, -0.08751237f, 0.12628604f, 
    0.22709578f, -0.12502535f, -0.15018667f, -0.26149195f, -0.09210990f, 0.07709343f, -0.08286332f, 0.00933358f, 
    0.00072744f, -0.12190014f, -0.06106197f, 0.10374149f, -0.09183744f, -0.01214849f, 0.01476337f, 0.02176098f, 
    -0.11551847f, 0.08650510f, 0.03601554f, 0.05530621f, -0.00451068f, -0.00332652f, -0.07345906f, 0.03464908f, 
    0.05149408f, -0.29447886f, -0.01093979f, -0.21083668f, -0.07830515f, 0.07056639f, -0.00838959f, 0.06861842f, 
    0.12726529f, 0.02294929f, -0.04402035f, 0.04110064f, -0.28041738f, 0.11527572f, 0.05589093f, -0.30747229f, 
    0.10708480f, -0.01798951f, 0.00154531f, 0.05221657f, 0.04949496f, 0.09495585f, 0.04553897f, 0.06194378f, 
    -0.15540646f, -0.21375819f, 0.08104680f, 0.02570673f, 0.01856874f, -0.02693368f, -0.21382535f, 0.01208527f, 
    0.03447849f, 0.10736934f, 0.12496087f, -0.04533964f, -0.28515974f, 0.11562007f, -0.08438623f, 0.29465181f, 
    0.08160444f, 0.08911360f, 0.07749753f, 0.02195951f, -0.05037170f, 0.03349371f, -0.11754287f, 0.10448697f, 
    0.26705852f, -0.09305986f, 0.09722738f, 0.10406650f, 0.02571396f, 0.00612414f, -0.08782973f, -0.00292411f, 
    -0.02325521f, 0.05497916f, 0.05619000f, -0.05719941f, -0.18653728f, 0.02412085f, 0.28834006f, 0.03910927f, 
    -0.02632606f, 0.15365553f, 0.10800928f, 0.08558179f, 0.14279345f, 0.19998603f, 0.08351271f, -0.10998854f, 
    -0.09046680f, -0.29472953f, 0.23512037f, -0.29302919f, 0.10334028f, 0.11908478f, 0.12449506f, 0.14701219f, 
    0.05967103f, -0.15604448f, 0.09592678f, -0.01757708f, 0.12005980f, 0.14293171f, 0.02422716f, -0.03182358f, 
    0.13233216f, 0.07897326f, -0.07518576f, 0.11903621f, -0.00299223f, 0.05645834f, -0.01268533f, 0.20502588f, 
    0.00677004f, -0.02890594f, 0.16876191f, -0.21799780f, -0.02894651f, -0.01776015f, -0.01715554f, 0.11048822f, 
    -0.02104613f, 0.16298105f, 0.07595121f, 0.04385903f, 0.22384423f, -0.09735001f, -0.15900393f, -0.06366429f, 
    -0.11986887f, -0.07298619f, -0.11170871f, 0.04362481f, -0.02048581f, 0.01794218f, 0.06378741f, 0.11617114f, 
    0.22621568f, 0.10066589f, 0.05184743f, -0.04233612f, 0.05218632f, -0.12603974f, -0.00775216f, -0.02389841f, 
    0.04869776f, -0.09377760f, -0.04867066f, -0.01095841f, -0.30036938f, -0.23745222f, -0.00797319f, 0.26820645f, 
    0.10453975f, 0.04361222f, 0.19625947f, -0.03418652f, 0.04210240f, 0.10404205f, 0.04552874f, -0.01639270f, 
    0.29964596f, -0.13510828f, 0.02244555f, -0.04101033f, 0.08013634f, 0.14489309f, 0.12109218f, -0.16024551f, 
    -0.08771338f, 0.05231015f, -0.06023800f, 0.09076858f, -0.04009983f, 0.00072081f, 0.15044288f, 0.02973402f, 
    0.11589310f, -0.14618257f, 0.00711337f, -0.03452988f, 0.07540563f, -0.07468773f, -0.00912394f, 0.05230505f, 
    0.09347546f, 0.13682958f, 0.10384194f, 0.44235048f, 0.16831674f, 0.10305549f, 0.05286413f, 0.10365175f, 
    -0.02864982f, 0.02287124f, 0.08627918f, 0.03264827f, -0.44613865f, 0.09527455f, 0.08787837f, -0.20664898f, 
    0.12360612f, -0.02879345f, 0.06619459f, -0.15640040f, -0.04255894f, 0.04214926f, 0.10894628f, 0.12998237f, 
    0.22459868f, 0.07527845f, 0.08127183f, 0.26771516f, 0.17230165f, 0.18928327f, -0.11284307f, 0.11489907f, 
    -0.05099506f, -0.01794297f, 0.02920693f, -0.06282170f, -0.06663625f, -0.01860800f, 0.15509677f, 0.01353688f, 
    0.12282397f, 0.03008519f, 0.01734655f, -0.09663980f, -0.05785041f, 0.09494628f, -0.02781668f, 0.20237906f, 
    -0.32394302f, 0.33783063f, 0.04088782f, -0.23064162f, 0.04309030f, 0.03945417f, 0.02434102f, -0.16254173f, 
    -0.02288748f, -0.02344101f, 0.00834637f, 0.00862732f, 0.03753828f, -0.28167090f, 0.28972346f, -0.02996045f, 
    -0.06158903f, 0.07033686f, 0.07178240f, 0.03886836f, -0.05053162f, -0.14191777f, 0.15610464f, 0.03806338f, 
    0.15171413f, -0.34864697f, 0.00550299f, -0.16139925f, -0.06432720f, 0.08528347f, -0.09312252f, 0.05640426f, 
    0.06678800f, 0.01962372f, 0.02078600f, -0.02098514f, -0.17639236f, 0.35107845f, -0.11165591f, -0.27564713f, 
    0.07059433f, -0.02080882f, -0.01925517f, 0.02565227f, 0.07103846f, 0.08803254f, -0.01377066f, 0.05803563f, 
    -0.16121775f, 0.01282354f, 0.06454997f, 0.21975656f, -0.07637432f, 0.05956256f, -0.00588307f, -0.08674060f, 
    0.07742021f, 0.01804997f, 0.13174728f, -0.03080754f, -0.41081241f, -0.01511859f, 0.14622164f, -0.02359768f, 
    -0.09551610f, -0.07232374f, -0.03987706f, -0.05032809f, -0.19819322f, 0.02865136f, 0.23085146f, -0.10876240f, 
    0.11755038f, -0.06841309f, -0.10910222f, 0.09044332f, -0.02485236f, 0.00289117f, -0.08202913f, -0.00029886f, 
    -0.01856626f, -0.04860277f, 0.01462187f, -0.11387309f, -0.04554394f, 0.19099785f, 0.06218223f, 0.10054205f, 
    0.13861249f, 0.03672161f, -0.09376410f, -0.04923772f, -0.06937835f, -0.01612492f, -0.08918943f, -0.26356301f, 
    -0.17757392f, -0.02617680f, -0.27624011f, -0.27158257f, 0.09223350f, -0.08086699f, 0.08547144f, -0.07884017f, 
    -0.00415844f, -0.00322906f, 0.08309416f, -0.05888389f, 0.25880328f, 0.39187956f, -0.05331646f, -0.07604970f, 
    0.06054203f, -0.04741031f, -0.06557919f, 0.13671334f, 0.00626808f, -0.01507780f, 0.01379801f, 0.02252897f, 
    0.24337524f, 0.23346919f, 0.16792920f, 0.33910856f, 0.02926802f, 0.13931194f, -0.14651507f, 0.10575007f, 
    0.11714313f, 0.17222114f, 0.03400502f, -0.13197488f, 0.02671761f, -0.42898491f, 0.29191920f, -0.35728431f, 
    -0.01398328f, 0.04736970f, 0.10642723f, 0.11754350f, 0.01324151f, 0.15482137f, 0.13768330f, -0.08615792f, 
    0.36623254f, 0.33230141f, 0.02377013f, 0.08333545f, -0.09389343f, -0.01051077f, 0.21604785f, 0.03188780f, 
    0.04968311f, 0.12955460f, -0.09486525f, -0.00633608f, 0.32465053f, -0.24719736f, -0.05531226f, 0.05523321f, 
    0.16794090f, -0.28270200f, 0.03839934f, -0.18064713f, -0.05041169f, -0.03546235f, 0.07122548f, 0.09328858f, 
    0.15135795f, 0.09881915f, 0.01998551f, 0.17072949f, -0.12454592f, -0.01072060f, 0.10021041f, -0.00956117f, 
    -0.08375666f, -0.00978689f, -0.10401220f, 0.08750161f, 0.27800384f, -0.10953122f, -0.17253718f, 0.14965887f, 
    -0.10129677f, -0.05877247f, -0.06360660f, -0.03246077f, 0.07894216f, -0.12082803f, 0.13759305f, -0.06032630f, 
    -0.04342379f, -0.19383159f, -0.19452831f, 0.00671416f, 0.00512043f, -0.16458887f, -0.12692110f, -0.03258112f, 
    0.14215396f, -0.10252630f, 0.06586398f, 0.06459494f, 0.30776474f, 0.06712992f, -0.15140359f, -0.14587730f, 
    -0.12121143f, -0.05130021f, -0.00404879f, -0.01635186f, 0.05704235f, 0.01891861f, 0.18501149f, 0.10782424f, 
    0.43482879f, 0.13004725f, -0.06716087f, 0.13921042f, -0.02498748f, -0.07890791f, 0.00688333f, 0.10107801f, 
    -0.07415644f, 0.12494017f, -0.07474170f, 0.01813609f, 0.25653490f, -0.31647548f, -0.08511965f, -0.05059987f, 
    0.01622415f, -0.00528843f, -0.15101506f, -0.10086936f, -0.04374657f, 0.06973562f, -0.10324217f, 0.11929005f, 
    -0.03431145f, 0.26942864f, -0.02462300f, 0.07695879f, 0.01713479f, 0.07549196f, -0.04056564f, -0.04564309f, 
    -0.07317166f, 0.03151184f, -0.04725036f, 0.33289769f, 0.10858167f, -0.05923142f, -0.18425882f, 0.20389768f, 
    0.03383647f, 0.01584548f, 0.12218349f, 0.00047744f, 0.09087005f, 0.06510479f, -0.06301706f, -0.05830067f, 
    -0.15900134f, -0.03523574f, 0.06562807f, 0.10536860f, 0.02479462f, 0.13209458f, -0.06925464f, -0.12661166f, 
    -0.14547586f, 0.12198715f, -0.02391646f, -0.00583354f, 0.02896621f, -0.30765760f, 0.19449127f, -0.07555082f, 
    -0.06170382f, -0.00772371f, 0.13527085f, 0.03860936f, 0.02112975f, -0.05368445f, -0.14407262f, -0.17042798f, 
    -0.02102098f, 0.02508632f, -0.13889533f, 0.01625796f, -0.08398994f, -0.04540807f, -0.01007723f, -0.04592705f, 
    -0.09924548f, -0.10780177f, 0.19851738f, -0.13960679f, 0.37934116f, 0.30171111f, 0.05745955f, 0.13393882f, 
    0.13496280f, -0.04208991f, -0.12122045f, 0.06007757f, -0.05478002f, 0.15115295f, -0.02752432f, 0.15692677f, 
    0.05930575f, 0.05791982f, 0.29541460f, -0.24493621f, 0.09311888f, -0.00482423f, 0.04438078f, -0.07344615f, 
    0.19394013f, 0.09042929f, 0.15844265f, 0.18984121f, -0.29567939f, 0.30438429f, -0.10640232f, 0.23000810f, 
    -0.06701849f, -0.06926277f, 0.12091561f, 0.21321186f, 0.10438217f, 0.05301449f, 0.03438491f, -0.14311866f, 
    -0.29170612f, -0.03688331f, 0.27292985f, 0.16300672f, -0.12193619f, -0.07506109f, 0.12480389f, 0.12688638f, 
    -0.09044153f, 0.15863827f, 0.01848789f, 0.06708930f, -0.07479146f, 0.21922439f, -0.26786554f, 0.06330831f, 
    0.09729649f, 0.16231060f, -0.12642045f, 0.05527231f, 0.02627834f, -0.08216511f, -0.05396921f, -0.12015099f, 
    0.15729648f, 0.13511319f, -0.03467479f, 0.18116821f, -0.03487364f, -0.17027302f, 0.08992560f, -0.09005608f, 
    -0.10416137f, -0.04306791f, -0.14446923f, 0.08113354f, -0.18351589f, 0.15271416f, 0.07140653f, 0.01840471f, 
    0.00387795f, 0.06563329f, -0.09173681f, 0.05425898f, -0.03788151f, -0.00682896f, 0.24233396f, -0.20551708f, 
    0.29498506f, 0.37117869f, 0.02236748f, -0.10182146f, -0.10837381f, 0.07385756f, 0.23201385f, -0.02604569f, 
    -0.01722623f, 0.05827060f, 0.10676650f, 0.02851067f, -0.16441575f, -0.12810412f, -0.10144621f, -0.12817872f, 
    0.08675740f, -0.00917364f, 0.07518961f, -0.00691801f, -0.02263650f, 0.20386715f, 0.08205169f, 0.11842521f, 
    -0.01423093f, -0.08595786f, 0.21749049f, 0.06063533f, -0.07251759f, -0.03191512f, -0.00287437f, -0.16336648f, 
    -0.04998980f, -0.01144664f, -0.13433687f, 0.13630201f, -0.22609663f, 0.32279593f, -0.11755563f, -0.03569482f, 
    0.06566239f, -0.07623849f, -0.17382284f, -0.11287890f, -0.02621175f, 0.00209128f, -0.12607829f, 0.02197200f, 
    -0.02448327f, 0.08790401f, -0.15342091f, 0.13699469f, 0.01953088f, -0.07314439f, 0.07903691f, 0.00831101f, 
    -0.00548038f, 0.02596576f, 0.02889841f, -0.07487111f, 0.17208378f, 0.15837024f, -0.03073719f, 0.08148239f, 
    -0.01322153f, -0.00306499f, -0.05784081f, 0.02365025f, -0.13001162f, -0.14083661f, -0.07474581f, 0.01144808f, 
    -0.33309409f, 0.16019875f, 0.02463780f, 0.14023036f, -0.01942791f, 0.12004318f, -0.07256151f, 0.12130166f, 
    0.04381691f, -0.15041664f, -0.00431743f, -0.04123423f, -0.42276332f, -0.08874296f, 0.06191533f, 0.21286799f, 
    0.01479029f, -0.07700443f, -0.11746177f, -0.15991299f, -0.00865216f, 0.07710624f, -0.00403007f, -0.01956887f, 
    0.18979089f, -0.17583679f, 0.09474231f, 0.17665066f, 0.11735820f, 0.11532474f, -0.10133315f, 0.08716657f, 
    0.10825870f, 0.14436634f, -0.11789601f, 0.07168625f, -0.35147446f, 0.12295196f, -0.09290851f, -0.20734483f, 
    0.02643777f, 0.06462140f, 0.01874384f, 0.03359221f, -0.01940122f, 0.12559818f, -0.03053431f, 0.09258324f, 
    -0.27850690f, 0.00700248f, 0.09454597f, -0.29999983f, 0.02114137f, -0.00128783f, -0.01293298f, 0.10285255f, 
    0.05020572f, -0.09452259f, -0.04976383f, 0.00110096f, -0.22553699f, -0.18783168f, -0.11139121f, 0.02164995f, 
    -0.01173849f, 0.02545585f, -0.06739073f, -0.06145594f, 0.00981437f, 0.01136661f, 0.04598720f, -0.03737543f, 
    0.13719039f, -0.30181989f, -0.02449466f, 0.09143242f, -0.06377468f, -0.13466854f, 0.08984740f, -0.03300298f, 
    0.13833399f, 0.03746844f, 0.11675505f, 0.03073978f, -0.08736458f, -0.23744398f, -0.05431493f, 0.26073775f, 
    0.00711065f, -0.18673135f, -0.14531414f, 0.05860016f, 0.15902478f, 0.01251077f, 0.09325343f, 0.03154501f, 
    0.20245488f, 0.06218072f, 0.16452169f, -0.10228061f, -0.04322102f, -0.00933845f, 0.09986750f, -0.07616737f, 
    -0.12278549f, -0.00558713f, 0.15162550f, -0.01474515f, -0.04445450f, -0.08775976f, 0.09153030f, -0.00433100f, 
    0.23036672f, -0.01783677f, 0.04834422f, -0.02896755f, 0.06586434f, 0.12220881f, -0.13456789f, 0.04070710f, 
    0.39317676f, -0.29392901f, 0.01737649f, 0.19761257f, 0.10506737f, -0.03821510f, 0.01661798f, 0.13157867f, 
    0.03930661f, 0.02597722f, -0.07981417f, 0.10208024f, -0.19256717f, 0.11770536f, -0.05231921f, -0.13998392f, 
    0.24142952f, 0.10647538f, 0.02898024f, -0.00456162f, 0.18224688f, 0.06575149f, 0.00840334f, -0.05230870f, 
    0.23576106f, 0.22038279f, -0.19771536f, 0.24713495f, 0.02309074f, 0.05385264f, 0.10129070f, 0.06903668f, 
    0.02934209f, -0.17373659f, 0.00252572f, 0.04827519f, -0.11223191f, -0.11144276f, 0.20952266f, 0.04922512f, 
    -0.09617843f, 0.01690099f, -0.01183345f, -0.05683788f, 0.03639494f, 0.01870749f, 0.07371160f, -0.05951936f, 
    0.33004510f, -0.20437832f, -0.11853891f, -0.14306170f, 0.09580617f, -0.02015049f, -0.01596433f, 0.00885861f, 
    0.03265220f, 0.08314081f, -0.06593873f, -0.07332129f, 0.26827618f, -0.19084632f, -0.30306950f, -0.09697016f, 
    0.10776023f, 0.20339143f, 0.03386471f, 0.10475898f, 0.15961920f, 0.16126487f, 0.14364977f, 0.02041109f, 
    0.24435653f, 0.13164674f, -0.01366099f, 0.21812385f, 0.00748626f, 0.00445923f, -0.01762773f, -0.15940401f, 
    -0.07366474f, 0.06788027f, 0.05495661f, 0.10403873f, -0.07573605f, -0.14094599f, 0.11950670f, -0.07830627f, 
    0.06119429f, -0.02335026f, -0.10229478f, 0.12010770f, 0.17007574f, -0.03261076f, -0.00899961f, 0.11552249f, 
    -0.04047354f, 0.10556652f, 0.24375892f, 0.03164272f, -0.08166198f, 0.01415726f, -0.07895850f, -0.15148959f, 
    0.02421870f, 0.07689937f, 0.07342028f, 0.10261527f, 0.33402136f, -0.07919168f, 0.07767264f, -0.13753104f, 
    0.11562874f, -0.12329735f, 0.15363848f, -0.04323130f, -0.05229470f, 0.08117826f, -0.00276866f, -0.04285007f, 
    -0.16734976f, -0.11243270f, -0.06978112f, 0.26245922f, -0.02713456f, -0.02411050f, 0.01043471f, 0.09360944f, 
    -0.16317141f, -0.08472662f, 0.07052483f, 0.21114621f, 0.06790374f, -0.08170815f, -0.13703610f, 0.01782731f, 
    0.03378892f, -0.00238877f, -0.01793981f, -0.03352641f, -0.03329584f, 0.00267344f, 0.03010291f, 0.07163861f, 
    -0.27136186f, -0.02006946f, -0.15487516f, -0.18945593f, 0.22991498f, 0.14078221f, 0.04658052f, 0.08551852f, 
    0.03919268f, 0.08077429f, 0.13102148f, 0.08291230f, -0.03546897f, -0.00354585f, 0.32692245f, 0.10953528f, 
    -0.31061196f, -0.05561475f, -0.04172862f, 0.11741388f, 0.04445029f, -0.01143259f, -0.00572375f, 0.07698575f, 
    -0.22619519f, -0.29590756f, -0.12788832f, -0.01224658f, 0.11602826f, 0.04624556f, 0.22345567f, 0.18698753f, 
    0.06695437f, 0.02630588f, -0.05762026f, 0.01075100f, 0.22739711f, 0.22749360f, 0.23311533f, 0.01146276f, 
    -0.11727339f, 0.01563619f, -0.08117782f, 0.22956903f, -0.03910582f, -0.01297703f, 0.12306064f, -0.05692594f, 
    0.23682366f, 0.15771745f, 0.03935693f, 0.12518504f, -0.19484304f, 0.03924525f, 0.12793355f, 0.12327006f, 
    0.03813465f, 0.01690078f, -0.04014514f, -0.08100542f, -0.19887999f, 0.05047082f, 0.11709124f, 0.12007120f, 
    -0.08080671f, 0.04545745f, -0.13168949f, 0.10149140f, 0.01096233f, -0.01694615f, -0.00209737f, -0.05809282f, 
    -0.57430017f, 0.10641078f, -0.07039896f, -0.17377630f, 0.07311643f, 0.00237582f, 0.05807698f, 0.08611356f, 
    -0.08454661f, -0.01331034f, 0.09573381f, 0.10593649f, 0.11395268f, 0.04812007f, 0.05720406f, 0.25756276f, 
    -0.13847788f, -0.01367410f, 0.10040183f, 0.14717208f, 0.03670076f, -0.07720301f, -0.07412753f, -0.01398521f, 
    0.41318271f, -0.40670773f, 0.24801043f, -0.15416664f, -0.04195891f, -0.15543282f, 0.03512707f, 0.10104388f, 
    -0.04130459f, -0.14268613f, 0.03425066f, -0.00012947f, 0.16486344f, 0.05944919f, 0.38455990f, 0.06354055f, 
    -0.06791534f, 0.10414885f, 0.00520641f, 0.03796345f, 0.05497249f, -0.05629475f, -0.03570112f, 0.07146894f, 
    0.11091224f, 0.30832258f, -0.16260649f, 0.19032216f, 0.15038756f, 0.05481731f, -0.06540136f, -0.14323246f, 
    -0.12823443f, -0.03495652f, 0.00102676f, -0.01928041f, -0.14306770f, -0.00239266f, 0.16378509f, 0.11976998f, 
    0.08337730f, 0.04006068f, -0.07810146f, -0.15339728f, -0.04568382f, -0.04829913f, -0.21029143f, -0.09219651f, 
    -0.01188130f, -0.26509395f, -0.44653544f, -0.29797354f, 0.00891596f, 0.06353696f, 0.11285120f, 0.05928199f, 
    -0.14462516f, -0.15057985f, 0.07575473f, -0.10389496f, 0.60288596f, 0.56155336f, -0.26398167f, -0.20602818f, 
    0.23024385f, -0.00868816f, 0.13980784f, 0.05172719f, 0.02683955f, -0.00649399f, -0.05517316f, 0.00504301f, 
    0.24656984f, 0.24204451f, 0.14676553f, 0.06467381f, 0.06051735f, 0.05293762f, -0.07268593f, 0.07661580f, 
    -0.03863131f, 0.12484596f, 0.12953152f, 0.13832429f, -0.27139336f, -0.33414334f, -0.04871344f, -0.27302176f, 
    0.05823822f, 0.04415715f, 0.21970421f, -0.00649109f, 0.10775440f, 0.08032753f, 0.00940671f, -0.01526849f, 
    -0.03177920f, 0.22213225f, 0.16868509f, 0.28448281f, 0.01368485f, 0.10062703f, 0.22168013f, 0.25003397f, 
    0.03774713f, 0.19538765f, 0.12907852f, -0.04444572f, 0.13661399f, -0.31935927f, 0.06900465f, 0.07743867f, 
    0.07710516f, -0.21202260f, -0.08011610f, -0.19107442f, -0.04369096f, -0.15095833f, 0.03404048f, 0.04038055f, 
    0.15906341f, 0.07573549f, -0.28946993f, 0.21999401f, 0.02574931f, -0.03176238f, 0.15220514f, -0.01014467f, 
    -0.13554171f, -0.00022349f, 0.06331953f, -0.01077561f, 0.14135177f, 0.11292009f, 0.14443716f, 0.21789415f, 
    -0.06407541f, 0.11106010f, -0.03010481f, -0.07964024f, 0.02720233f, -0.07236155f, 0.16245763f, -0.15523192f, 
    0.16036355f, -0.20701988f, -0.26426312f, -0.07200789f, 0.01247456f, -0.10363047f, -0.05799354f, -0.01739761f, 
    0.02257051f, -0.18420312f, -0.00286598f, 0.07602055f, 0.14040050f, -0.05264560f, 0.06364597f, -0.25372773f, 
    -0.09576060f, 0.11142772f, 0.00590186f, -0.07000764f, 0.02609269f, 0.01128742f, 0.19098653f, 0.20834550f, 
    -0.09411866f, 0.25627986f, -0.13942742f, 0.01491823f, 0.12378304f, -0.02344807f, 0.05550576f, 0.14297156f, 
    -0.03308525f, -0.00278348f, 0.02020998f, -0.02715586f, -0.03862032f, -0.28754935f, 0.00046804f, -0.10746916f, 
    0.11996827f, 0.02027990f, -0.16523512f, -0.18891184f, -0.03976847f, -0.14351988f, -0.19124122f, 0.16382155f, 
    -0.00198994f, 0.05193871f, -0.01437637f, 0.19326305f, -0.12779018f, -0.05227103f, 0.17334197f, -0.05578027f, 
    -0.08879493f, 0.17845517f, -0.00991348f, 0.22640768f, 0.23160134f, 0.06048886f, 0.14836815f, -0.20188636f, 
    -0.09648857f, -0.05698337f, -0.05537696f, -0.02308638f, -0.06745578f, 0.16595833f, 0.01273763f, -0.05894452f, 
    -0.20093073f, 0.25263780f, -0.03480291f, 0.35851768f, 0.00026885f, 0.08083652f, 0.07850347f, -0.05237141f, 
    0.04302952f, -0.02706176f, 0.12094238f, -0.00827756f, -0.02170157f, -0.10532946f, 0.28639525f, 0.10168880f, 
    -0.00202103f, -0.02844068f, -0.02573233f, -0.07914899f, -0.06603962f, -0.02559240f, -0.06885807f, 0.02566984f, 
    0.38468674f, -0.04979768f, 0.19826314f, 0.10433952f, -0.12859395f, -0.12204283f, -0.02551631f, 0.00980519f, 
    0.02327536f, 0.02720515f, -0.05855699f, -0.00442696f, -0.00028253f, 0.25162077f, 0.13020062f, -0.11525673f, 
    -0.03137348f, 0.05262246f, -0.00546505f, 0.02010001f, 0.12498407f, -0.02316149f, 0.05881589f, -0.00349156f, 
    -0.13910076f, -0.04818435f, 0.05987153f, -0.09700524f, -0.08082236f, -0.15496531f, -0.04362061f, 0.24431102f, 
    -0.14485066f, -0.02623677f, 0.09046921f, 0.04272097f, 0.37534887f, 0.13680257f, -0.19030993f, 0.01776458f, 
    -0.17438242f, -0.05657717f, -0.05173293f, 0.01184232f, -0.16091387f, -0.08201881f, 0.13323829f, 0.15323138f, 
    -0.16779257f, -0.26843801f, -0.05255698f, -0.02866958f, 0.10128693f, 0.02354617f, -0.00175622f, 0.08313827f, 
    0.08272326f, -0.09972256f, -0.04206213f, 0.01415421f, 0.09961355f, -0.00824179f, 0.28974622f, 0.52491570f, 
    -0.05435663f, -0.01142373f, -0.00136062f, 0.04403496f, 0.10684395f, -0.13034111f, -0.04483616f, 0.12835462f, 
    -0.04657256f, -0.10117574f, -0.02747038f, 0.08963490f, 0.10652877f, -0.03647955f, 0.10716274f, 0.03493053f, 
    -0.04346864f, -0.00948687f, 0.20214204f, 0.16320078f, 0.05038733f, 0.08304304f, 0.12883414f, 0.17575532f, 
    0.26205307f, 0.12773222f, -0.05242643f, -0.03134820f, 0.07101335f, 0.08186164f, 0.04290939f, 0.00531794f, 
    0.77317160f, -0.28000939f, 0.09506930f, 0.21641687f, 0.03753201f, -0.09422518f, -0.07149435f, -0.03247523f, 
    -0.08569043f, 0.04805760f, -0.07899701f, 0.09019006f, -0.13496277f, 0.21513841f, -0.10963850f, 0.09054131f, 
    0.07949904f, 0.03116577f, 0.13334872f, 0.12389914f, -0.00565001f, 0.10728289f, 0.00346338f, -0.04085128f, 
    -0.27588153f, 0.10702586f, 0.07489058f, -0.02045855f, 0.05418623f, 0.04314784f, 0.13761345f, -0.02259406f, 
    0.05337381f, -0.08408082f, -0.02862569f, 0.02197617f, -0.02036384f, 0.02511038f, 0.25975192f, 0.14847085f, 
    -0.11352788f, -0.02413253f, -0.07475248f, 0.14281316f, 0.17522502f, -0.12957232f, 0.07500786f, -0.17313032f, 
    0.24030644f, -0.22790080f, 0.07986477f, -0.39382109f, -0.01776492f, -0.23776673f, 0.06058876f, 0.11030206f, 
    0.12602495f, -0.02413955f, -0.05463910f, -0.07027399f, 0.03447185f, 0.06598845f, -0.09180540f, -0.21327472f, 
    0.07108697f, 0.14907557f, 0.00485390f, 0.16344267f, 0.05312963f, -0.00093327f, 0.04370805f, -0.07075338f, 
    0.13645843f, 0.11448672f, -0.00139822f, 0.13012688f, 0.06643714f, 0.03325511f, 0.00000801f, 0.02427775f, 
    -0.04075046f, -0.07850001f, -0.15090820f, 0.02147362f, -0.31442308f, -0.08506762f, 0.14833760f, 0.13566880f, 
    0.15896668f, 0.07510490f, 0.00287762f, 0.11888020f, 0.16026421f, -0.00414447f, -0.11278177f, -0.00085562f, 
    -0.42327812f, -0.17278713f, -0.12606740f, 0.05132278f, -0.00131736f, 0.06130401f, 0.04867085f, -0.03661845f, 
    -0.05546138f, -0.10916904f, 0.16522592f, -0.02446822f, 0.52050585f, 0.15736897f, 0.00706506f, 0.05294130f, 
    0.01972605f, -0.02946779f, -0.04587483f, 0.05055159f, 0.07423137f, 0.14149885f, -0.09549370f, 0.08314117f, 
    -0.11945806f, 0.09439002f, 0.19376157f, 0.09830992f, -0.02599914f, -0.04827840f, -0.05279209f, -0.09055379f, 
    0.00842204f, -0.01840702f, 0.14136708f, 0.20286091f, -0.31568852f, -0.27550676f, -0.06745680f, -0.05395032f, 
    0.09676228f, 0.03206860f, 0.15956882f, 0.15597302f, 0.12053657f, 0.14087524f, 0.04511745f, -0.11808108f, 
    -0.35490826f, 0.09466266f, 0.10879903f, 0.02131581f, 0.07486603f, -0.03907480f, 0.02145188f, 0.02453312f, 
    -0.08784134f, 0.16307835f, 0.10640529f, 0.03739524f, 0.21093853f, -0.12329233f, -0.05522115f, -0.05671839f, 
    -0.15488933f, -0.00262141f, -0.01318379f, 0.07472146f, -0.01547176f, -0.00591539f, 0.06338532f, -0.11550344f, 
    -0.16458541f, 0.08677140f, -0.22799055f, 0.05256853f, -0.00962842f, -0.19064057f, 0.23227923f, 0.07577480f, 
    0.02736769f, 0.06276808f, -0.07153741f, 0.08211228f, 0.22425365f, 0.13800135f, 0.06777203f, 0.04882688f, 
    -0.24175467f, 0.07603019f, 0.01536696f, 0.20153040f, 0.02223969f, -0.10270483f, 0.18507153f, -0.13542867f, 
    -0.02631661f, 0.08232216f, -0.13880618f, -0.17925330f, -0.10587906f, 0.06863846f, 0.23470841f, 0.09587765f, 
    0.14517142f, 0.03513030f, 0.08287902f, -0.09188981f, -0.06493420f, -0.05610222f, 0.11576579f, -0.12603201f, 
    -0.00824112f, -0.00240824f, -0.13066585f, 0.01644548f, 0.05288488f, 0.10529748f, 0.03486621f, 0.12530863f, 
    -0.46782345f, 0.33134228f, -0.03757605f, 0.14430532f, 0.08148693f, -0.14870165f, 0.11290153f, 0.04231036f, 
    -0.08818306f, 0.03095369f, -0.04344088f, 0.09525634f, 0.08346265f, -0.13787709f, -0.07558543f, 0.09610854f, 
    0.13685128f, -0.03215547f, -0.03816157f, -0.04192643f, 0.02226971f, -0.07164636f, -0.14436111f, 0.03749658f, 
    0.16040991f, -0.05320042f, -0.03101610f, 0.19162738f, 0.02231065f, -0.04858029f, 0.07356260f, -0.07885821f, 
    -0.05556780f, 0.05564678f, 0.04387485f, 0.11016918f, 0.39953655f, 0.06833296f, 0.32641885f, 0.09338637f, 
    -0.05256290f, -0.01945314f, 0.10728113f, -0.02009090f, 0.04019061f, 0.02787681f, -0.10954861f, 0.01655865f, 
    -0.03204216f, -0.06939760f, -0.03557771f, -0.02256092f, -0.05512599f, -0.05737842f, -0.07145189f, -0.05791062f, 
    0.04184001f, -0.02733488f, 0.02470952f, 0.02844451f, -0.05798224f, -0.06524533f, -0.03722480f, 0.05345810f, 
    -0.07026520f, -0.07293072f, -0.05516966f, -0.00075884f, -0.03676006f, 0.03508074f, 0.04908010f, 0.02762594f, 
    0.02318710f, -0.06812865f, -0.00800131f, 0.02365328f, -0.02576235f, 0.04768669f, -0.01167048f, 0.03850805f, 
    0.00563543f, -0.02471391f, 0.05165187f, -0.08062584f, -0.04935892f, 0.01825145f, 0.04458378f, -0.08070184f, 
    -0.01399471f, 0.03435269f, 0.04115494f, -0.07959852f, -0.03773619f, -0.04563757f, -0.01309712f, -0.08435862f, 
    0.02616195f, 0.03039994f, -0.00290889f, -0.05223408f, -0.02855071f, -0.03265598f, 0.04470485f, -0.03438621f, 
    0.04400409f, -0.07453060f, 0.03550895f, -0.00042829f, -0.06079745f, 0.00055185f, 0.05238494f, 0.00376934f, 
    -0.00518376f, 0.02822829f, 0.02042739f, -0.01143940f, -0.01405295f, 0.01325336f, -0.06924628f, -0.06158453f, 
    -0.05668238f, -0.03160199f, -0.08078187f, 0.03403033f, -0.08480183f, -0.02963972f, -0.01421774f, 0.04601376f, 
    -0.03618108f, 0.05596704f, 0.05078987f, 0.03249800f, -0.06374120f, 0.01728100f, 0.03208264f, -0.01796417f, 
    -0.08164175f, -0.00931289f, 0.05176793f, -0.04415312f, 0.00025152f, -0.04968037f, -0.00210446f, -0.02525644f, 
    0.04581637f, 0.05100065f, -0.00028649f, -0.05102186f, 0.02830306f, 0.05208808f, 0.00890455f, 0.02142685f, 
    -0.05115047f, -0.04537838f, -0.05585805f, 0.04777960f, -0.04263315f, 0.04634279f, -0.01109711f, 0.05167254f, 
    0.02702808f, -0.04059971f, -0.00334888f, -0.01417100f, -0.08078956f, 0.04214425f, -0.04635324f, 0.04616730f, 
    0.02678602f, 0.00305180f, -0.04748084f, 0.01659419f, -0.06114525f, 0.02907220f, -0.03025077f, -0.04353748f, 
    -0.01802970f, 0.04329053f, -0.01165263f, -0.06164020f, -0.06460837f, -0.04185852f, -0.02985981f, -0.02121016f, 
    -0.03728337f, -0.00063099f, -0.00831162f, -0.01180711f, -0.06771513f, -0.05437843f, -0.06349589f, -0.01724695f, 
    -0.06042355f, -0.01490737f, 0.03572954f, 0.00255539f, 0.05055196f, -0.01381818f, 0.03023655f, -0.04266120f, 
    -0.06475624f, 0.01723896f, 0.00657354f, 0.00825226f, -0.00783391f, 0.05893765f, 0.02147426f, 0.05189619f, 
    0.06292186f, -0.07596897f, -0.04894876f, -0.04471115f, 0.03635873f, 0.05491486f, -0.03151982f, -0.05871322f, 
    -0.06164195f, 0.05014295f, -0.03569640f, -0.04282694f, -0.02437373f, -0.01133089f, 0.05263814f, 0.04181842f, 
    0.02757229f, 0.05308253f, 0.02903489f, -0.06685059f, -0.04436574f, 0.04833303f, -0.05771277f, -0.02538886f, 
    -0.06614273f, -0.00429531f, -0.01089312f, 0.00917044f, -0.07405366f, 0.01484164f, 0.02315486f, 0.04354529f, 
    0.16422589f, 0.07573793f, 0.00559826f, -0.08286452f, 0.11458185f, 0.04351032f, -0.13872907f, 0.02194777f, 
    -0.08034206f, -0.01286317f, 0.03848156f, -0.08683669f, 0.32932022f, -0.06289016f, -0.26170972f, 0.08439407f, 
    -0.02527531f, 0.07025152f, -0.01166074f, -0.02621235f, 0.07354373f, 0.09189918f, 0.03139269f, -0.09571368f, 
    -0.04296675f, -0.01107012f, 0.16401310f, 0.16444728f, -0.14908104f, 0.01913792f, -0.03415092f, 0.04819139f, 
    -0.00370468f, -0.03555816f, 0.00244727f, 0.15158123f, -0.14125694f, 0.06386127f, -0.09185126f, 0.06169596f, 
    0.00651941f, 0.11620788f, -0.03124652f, 0.05244024f, -0.12059096f, 0.02431828f, 0.02102864f, 0.03872946f, 
    -0.02960339f, 0.10053197f, -0.20737046f, -0.27755684f, 0.14049701f, 0.11118957f, -0.00450888f, -0.03575822f, 
    0.09474444f, -0.00470085f, -0.02196573f, -0.03690403f, -0.35048854f, 0.03947935f, -0.11787561f, 0.02501842f, 
    -0.03241767f, -0.13707595f, 0.05014002f, -0.09723426f, 0.08559100f, -0.13381860f, 0.04184319f, -0.01712319f, 
    0.35991222f, -0.10163577f, 0.25428918f, -0.06346178f, -0.04711150f, -0.09249891f, -0.02401469f, 0.02711642f, 
    0.00509049f, -0.08549844f, 0.03281770f, 0.10539363f, -0.11958457f, 0.05169418f, 0.11112275f, -0.14326143f, 
    0.06241545f, 0.02078682f, -0.00437902f, -0.02136429f, 0.00171242f, 0.11758578f, 0.08945098f, -0.04233863f, 
    0.43947479f, 0.20942666f, 0.15763694f, -0.10800724f, -0.13666950f, 0.11814599f, -0.11248162f, -0.01661618f, 
    0.15308537f, 0.03647447f, -0.10401798f, -0.07652821f, -0.16712578f, -0.01025969f, 0.12995385f, -0.12163902f, 
    0.12235859f, -0.11371965f, 0.03122818f, 0.03199567f, -0.08744903f, 0.12654667f, -0.12312040f, -0.05422062f, 
    0.06627561f, -0.01442792f, 0.07206410f, 0.01369469f, -0.08019534f, -0.02635056f, -0.11731334f, -0.04026686f, 
    -0.05335702f, -0.03178505f, -0.04000406f, -0.04691728f, -0.29283434f, 0.19286387f, -0.03796183f, 0.11161083f, 
    0.11962506f, 0.04796169f, 0.02367979f, -0.05362641f, -0.07161847f, 0.05087554f, -0.11820465f, -0.03463470f, 
    0.68988985f, -0.24204594f, 0.00752231f, 0.02062021f, 0.03542184f, 0.04304725f, -0.08244043f, 0.02677745f, 
    0.12453403f, -0.13262923f, -0.03156535f, 0.07018559f, -0.26313832f, 0.04573304f, 0.13824400f, -0.08312225f, 
    -0.07047980f, 0.02293710f, 0.12530480f, -0.03409070f, -0.28698513f, 0.12516120f, 0.16162430f, 0.03061416f, 
    0.03159900f, -0.06339847f, -0.12165291f, 0.03601492f, 0.17978849f, 0.04549137f, 0.02801538f, -0.01694726f, 
    0.00301011f, -0.03829933f, 0.10286790f, -0.10031680f, -0.05475601f, -0.05132492f, -0.03103321f, 0.04826306f, 
    0.15267204f, -0.02727391f, -0.04057710f, -0.07256967f, 0.03057685f, 0.06798941f, 0.09898009f, 0.00262260f, 
    -0.08975806f, -0.06570564f, -0.01474451f, 0.03111332f, -0.04771695f, -0.03334080f, -0.04249333f, -0.03882864f, 
    -0.01508703f, 0.05487729f, -0.01135935f, 0.05176988f, 0.02977816f, -0.02677192f, -0.01856236f, 0.01847469f, 
    -0.06755358f, 0.00636640f, -0.04363475f, -0.05844780f, -0.01105149f, -0.03273224f, -0.08540493f, 0.03914638f, 
    -0.07530757f, -0.01475965f, 0.01969276f, 0.08277898f, -0.04988666f, -0.06052924f, -0.00457065f, -0.06068648f, 
    -0.03553392f, -0.06470861f, -0.03177292f, -0.08304361f, 0.03188589f, 0.03155304f, -0.03580956f, -0.01378671f, 
    -0.02388925f, 0.00398132f, -0.05260226f, -0.03046206f, -0.05629371f, -0.00430194f, 0.00061831f, -0.04412334f, 
    -0.07172897f, -0.04920906f, 0.01872432f, 0.01697824f, -0.03128332f, -0.03547665f, 0.04339951f, 0.01796981f, 
    0.06706312f, 0.00455347f, -0.03494610f, 0.06489752f, -0.07366572f, -0.02124257f, -0.03860485f, 0.04732951f, 
    -0.09335270f, 0.01328339f, 0.00361512f, -0.04974003f, 0.03144094f, -0.06952698f, 0.03949986f, -0.06486502f, 
    0.01591383f, -0.08237659f, -0.06160318f, -0.05386867f, -0.06651940f, 0.01425323f, 0.02086437f, 0.03684517f, 
    0.06838500f, -0.07784246f, 0.07285094f, 0.06065854f, -0.09395564f, -0.02548149f, 0.01322329f, -0.07368024f, 
    -0.07635242f, 0.00478374f, 0.01295533f, 0.02996054f, 0.02737769f, -0.01687889f, -0.01326793f, -0.01817870f, 
    -0.05911859f, -0.04135977f, -0.08257782f, -0.05092396f, -0.08451062f, 0.04618238f, -0.03914495f, 0.04073370f, 
    -0.07078911f, -0.04264153f, 0.04886613f, 0.05369911f, 0.04169947f, -0.07642827f, 0.01272515f, -0.09936532f, 
    -0.00346258f, -0.01826940f, 0.03280919f, 0.09194888f, 0.01649037f, -0.03874574f, 0.01786002f, 0.01236737f, 
    0.02737359f, -0.07104846f, 0.00448523f, 0.06466183f, -0.00303896f, -0.03332722f, -0.05246372f, -0.06111031f, 
    -0.08078172f, -0.02873106f, 0.02347294f, -0.01540422f, -0.02521976f, 0.04808170f, -0.07228558f, 0.04669526f, 
    0.01921684f, 0.00373248f, 0.02329324f, 0.04783926f, -0.01043821f, 0.00380278f, -0.00021479f, -0.03608981f, 
    -0.03228124f, -0.00334877f, -0.06759540f, -0.06189631f, -0.06942268f, -0.03660245f, -0.03104909f, -0.05598882f, 
    0.02632955f, -0.05549528f, 0.04600157f, -0.04045197f, 0.00853779f, -0.03087586f, 0.01710379f, -0.05749766f, 
    -0.03254742f, -0.03519219f, -0.09312029f, 0.05198803f, -0.00335395f, 0.01881265f, -0.00336434f, 0.00622479f, 
    0.01758334f, 0.00126946f, -0.05698604f, -0.08563706f, -0.03257946f, 0.01189976f, -0.04078053f, -0.03205103f, 
    -0.04639046f, -0.05120252f, 0.03886498f, -0.08500619f, -0.06723813f, -0.03125050f, -0.02682359f, 0.00202623f, 
    -0.08074622f, 0.01622513f, 0.06490631f, 0.07247583f, -0.03770291f, -0.07148785f, -0.00820459f, -0.05433010f, 
    -0.10986512f, 0.30435365f, 0.29161611f, -0.07148678f, 0.06278469f, 0.14082888f, 0.05786527f, 0.16790290f, 
    0.07358464f, 0.10571720f, -0.06889012f, 0.08946967f, -0.28592947f, 0.10979817f, 0.22646433f, -0.05294794f, 
    0.06076419f, 0.00435608f, -0.02369610f, 0.22135632f, 0.02358817f, 0.08062816f, 0.01749667f, 0.23603962f, 
    -0.07612774f, -0.09625793f, 0.07904563f, -0.11550307f, 0.11594748f, 0.02993959f, -0.02742927f, 0.04585905f, 
    0.11556118f, -0.00179709f, 0.05653039f, -0.02725609f, 0.02664036f, -0.20247488f, -0.11260907f, -0.04637251f, 
    -0.09355635f, -0.01195927f, 0.07317029f, -0.04239286f, 0.00508010f, 0.10414963f, -0.04160067f, 0.08131313f, 
    0.23522983f, 0.17555176f, 0.24486841f, 0.06788339f, 0.03034086f, -0.06105701f, 0.09668754f, 0.00310058f, 
    -0.22322024f, -0.07594452f, 0.09109883f, 0.08962239f, -0.36279240f, -0.13662627f, -0.04851847f, 0.13452518f, 
    0.07039178f, 0.11834779f, -0.02170888f, -0.06607284f, 0.15504362f, -0.06163565f, -0.08639243f, 0.09207433f, 
    -0.23594965f, -0.15348749f, -0.15808208f, 0.03082828f, 0.05541943f, -0.03973517f, -0.13276617f, 0.01587886f, 
    0.04551792f, 0.03921329f, 0.02018114f, -0.10834650f, -0.36319104f, -0.19155723f, 0.03188787f, -0.01114435f, 
    -0.16567846f, -0.00855723f, -0.00778959f, 0.08744328f, 0.08913516f, -0.01616052f, 0.12296302f, 0.06540035f, 
    -0.04666799f, -0.20641081f, -0.15130900f, -0.00818253f, 0.05293985f, -0.03852972f, 0.06759623f, 0.11923569f, 
    0.03424470f, 0.02711502f, -0.00817800f, -0.04548919f, -0.30331981f, 0.07698282f, 0.33502725f, -0.11722378f, 
    -0.00267043f, 0.01659868f, 0.05626038f, 0.08911353f, -0.03603252f, -0.10636468f, -0.05165067f, 0.02726658f, 
    -0.21544325f, 0.18129936f, -0.06890137f, -0.32193661f, -0.00097943f, 0.13063934f, 0.09700391f, -0.07821528f, 
    0.07146338f, 0.09226306f, 0.00892797f, 0.06887040f, -0.19747394f, -0.22245647f, 0.34713116f, 0.10183042f, 
    0.14597684f, 0.13637568f, -0.07148597f, 0.00989937f, 0.08958608f, -0.02764153f, -0.03338826f, 0.01272041f, 
    -0.38686860f, 0.05231617f, -0.22700100f, 0.00564725f, -0.03131700f, -0.00018393f, 0.09816971f, 0.10744184f, 
    -0.05453789f, -0.02512221f, -0.00198410f, 0.05234922f, -0.18448810f, 0.09222971f, 0.15995917f, 0.01462265f, 
    0.10253436f, -0.14585871f, 0.05587226f, 0.06629910f, 0.17602827f, 0.06057962f, 0.02278182f, 0.07857701f, 
    0.16227648f, -0.29475889f, 0.23768176f, 0.31377479f, 0.01814584f, 0.13730048f, 0.08132629f, -0.04394296f, 
    0.12018451f, 0.00334359f, -0.00078261f, 0.03438235f, 0.36724353f, 0.09716205f, 0.33993292f, 0.24463332f, 
    -0.08019064f, 0.18083017f, 0.08956718f, 0.04661037f, -0.08018529f, 0.03305371f, 0.03711730f, 0.11417940f, 
    0.06459261f, 0.16313581f, -0.13070026f, 0.16772962f, 0.01928638f, 0.00295250f, -0.00239860f, 0.03562035f, 
    0.03104101f, 0.01594904f, 0.14118314f, -0.09028137f, 0.12563999f, 0.10930933f, 0.06864388f, 0.18809706f, 
    0.06775492f, 0.07724091f, 0.06436806f, -0.13793486f, -0.12134171f, 0.06908192f, 0.18228596f, 0.03911402f, 
    0.14495045f, -0.01358679f, 0.13355576f, -0.05808601f, -0.01213009f, -0.08027007f, 0.05724115f, 0.20444092f, 
    0.05537013f, 0.09501846f, -0.18656279f, 0.00970178f, -0.08308821f, 0.13735595f, 0.07413998f, -0.10995848f, 
    -0.15010986f, 0.05494626f, -0.04850852f, 0.01594794f, 0.07377352f, -0.07558207f, 0.02298391f, -0.10331623f, 
    -0.09411980f, 0.16612017f, -0.21914168f, 0.20828809f, -0.03848399f, -0.00640282f, -0.01479242f, 0.14687781f, 
    -0.01932454f, -0.03038041f, 0.02827846f, -0.22961296f, 0.39042392f, -0.21166696f, -0.05990347f, -0.18605779f, 
    0.04296817f, 0.13484676f, 0.00449420f, -0.15240765f, -0.12906249f, -0.00466065f, -0.05733480f, 0.10409477f, 
    0.25961283f, 0.22388212f, -0.29873684f, -0.16804408f, 0.00233677f, 0.05915793f, -0.11099745f, -0.11391699f, 
    0.16647376f, -0.06897987f, -0.06738123f, -0.03213803f, 0.33813715f, -0.28475171f, 0.12308559f, 0.35193509f, 
    -0.10094216f, -0.17309068f, 0.14596872f, -0.07521995f, 0.06463226f, -0.03746505f, -0.04569494f, 0.21621838f, 
    -0.22995973f, 0.08647911f, -0.11441730f, -0.12969007f, 0.06345027f, 0.13274053f, -0.00679566f, 0.03366026f, 
    0.03256815f, 0.04675263f, 0.17128652f, 0.12601382f, 0.25837359f, 0.06379414f, 0.03996943f, 0.20385675f, 
    0.02117204f, -0.06987159f, 0.09660325f, -0.05473886f, 0.01528309f, 0.10294848f, -0.13932449f, -0.00428014f, 
    0.20661524f, -0.37705931f, 0.16548903f, 0.05149278f, 0.02785741f, -0.00470168f, -0.15203646f, -0.01751496f, 
    0.10749811f, -0.05310801f, 0.00381139f, 0.01968792f, 0.03909202f, 0.26156002f, -0.03563381f, -0.03406976f, 
    0.04893861f, -0.05125298f, -0.01651626f, 0.00624199f, -0.02535504f, -0.08908500f, 0.03962649f, -0.08941282f, 
    -0.04357631f, 0.29502600f, -0.14617300f, -0.03069612f, 0.10878496f, 0.06421284f, 0.05078102f, 0.00966962f, 
    -0.01023449f, 0.02946579f, 0.10600115f, 0.06202324f, 0.11892129f, -0.50741583f, 0.12665518f, 0.21142943f, 
    -0.02357533f, 0.13177288f, 0.08985466f, 0.29980373f, 0.08457430f, 0.01222668f, 0.08101749f, -0.08772585f, 
    -0.01234896f, 0.04507590f, 0.18356653f, -0.34088859f, 0.11606067f, -0.13071468f, 0.02553471f, 0.09081373f, 
    0.09468658f, 0.05975362f, 0.04406307f, 0.01127975f, 0.11119134f, -0.15790880f, -0.13489537f, -0.00589988f, 
    0.02249224f, -0.02459169f, -0.00847480f, -0.06755733f, 0.05576310f, 0.02644182f, 0.16535594f, 0.01749124f, 
    -0.05126929f, -0.00393613f, 0.02188473f, 0.05697928f, -0.00626987f, -0.04714487f, -0.03247570f, -0.00070047f, 
    -0.01944506f, -0.05073433f, 0.03291935f, 0.01231141f, -0.02231540f, -0.02652673f, -0.07411245f, -0.03523586f, 
    0.05450672f, 0.06088869f, 0.06262045f, -0.06952120f, 0.02643773f, 0.05454167f, 0.00377223f, -0.04636584f, 
    0.01513670f, 0.04403619f, -0.01111498f, 0.02694835f, -0.03062225f, 0.06436036f, -0.02127131f, 0.01700205f, 
    -0.07758508f, 0.03060377f, 0.02310534f, 0.05798467f, -0.04527351f, 0.02050420f, -0.04470373f, 0.03765577f, 
    0.02896046f, 0.05715596f, -0.02986305f, -0.07147832f, 0.01475085f, -0.00072951f, -0.05151745f, -0.02991739f, 
    -0.00484572f, -0.04825753f, -0.01011915f, 0.05681686f, -0.06810597f, 0.01741668f, -0.07676221f, 0.00152989f, 
    0.06047095f, 0.02353187f, 0.02427131f, -0.04734748f, 0.00626465f, 0.05559941f, 0.06806104f, 0.01530293f, 
    0.02206637f, 0.03660009f, -0.05306937f, -0.03497602f, -0.05348196f, -0.04432851f, 0.00960768f, 0.02455384f, 
    -0.04739903f, -0.02359168f, -0.06713071f, 0.00055268f, 0.02944670f, 0.03842268f, 0.03693721f, -0.07257232f, 
    -0.04298777f, -0.01868568f, 0.02347690f, -0.04909842f, -0.02986540f, -0.06016278f, -0.04158975f, -0.05227333f, 
    0.00710924f, 0.03153493f, -0.02361874f, -0.07809442f, 0.06216087f, -0.03817009f, 0.03720198f, 0.03066411f, 
    0.05157227f, -0.04028971f, -0.05229995f, 0.03026069f, -0.01544311f, -0.02047900f, 0.03259740f, 0.02341797f, 
    -0.07011606f, -0.02550039f, -0.03148839f, -0.01028351f, -0.05775806f, 0.05068035f, 0.03915047f, 0.05562914f, 
    -0.06102949f, -0.01923104f, -0.02363210f, -0.05065775f, 0.01494353f, -0.00402343f, -0.06120894f, -0.04161174f, 
    0.03339912f, -0.05054051f, -0.04819157f, -0.05807941f, 0.03277630f, -0.03445480f, -0.00623532f, -0.06833483f, 
    -0.00946746f, -0.07961881f, -0.06834384f, 0.04813865f, 0.04154887f, 0.06017014f, -0.04790109f, -0.05205114f, 
    -0.02012276f, 0.05185926f, -0.05491308f, -0.07424956f, -0.02820176f, -0.07648071f, -0.00719846f, -0.04630451f, 
    -0.02855985f, -0.02422525f, -0.03695819f, -0.01502514f, -0.01211536f, 0.05122131f, -0.02578407f, 0.00469273f, 
    -0.06091418f, 0.05530881f, -0.02171595f, 0.01963457f, 0.04790951f, -0.06948279f, -0.03787024f, 0.00437589f, 
    -0.02793238f, -0.01111675f, -0.04279238f, 0.03208689f, 0.00633821f, -0.00371767f, -0.07281298f, 0.02766193f, 
    0.03721241f, -0.00722221f, -0.01995712f, -0.06208043f, 0.06430969f, 0.05717053f, 0.04339491f, 0.02288100f, 
    0.04703408f, -0.05326420f, 0.03840351f, 0.05381975f, -0.07438818f, 0.03285388f, -0.02381104f, 0.05542495f, 
    -0.03281028f, -0.04790797f, -0.01861189f, 0.01854347f, 0.01425195f, -0.06972369f, 0.03107396f, -0.04340382f, 
    -0.09674880f, 0.03780952f, 0.16720983f, -0.26141077f, 0.07436479f, -0.07144514f, -0.02468510f, 0.25286129f, 
    0.05914494f, 0.02941110f, 0.01638844f, 0.10337035f, 0.06196000f, 0.28174275f, 0.10959747f, -0.05752593f, 
    0.01101165f, -0.15618016f, -0.00516708f, 0.13693726f, -0.03946057f, 0.03235847f, -0.00078616f, 0.08785433f, 
    -0.26616493f, -0.00147534f, -0.11177398f, -0.23256259f, 0.16183229f, 0.04987045f, 0.10348352f, 0.07615454f, 
    0.15525413f, -0.07933430f, 0.01521559f, -0.03166286f, -0.33216411f, -0.13586299f, -0.08087014f, 0.05482206f, 
    0.06380495f, 0.07592231f, 0.14997928f, -0.04736958f, 0.12756951f, -0.07712311f, -0.09331958f, -0.02346349f, 
    0.19005650f, 0.22274657f, 0.04073062f, 0.08870453f, 0.03215504f, -0.06806948f, 0.00940626f, 0.06459857f, 
    0.02243487f, 0.08313116f, -0.10520539f, -0.10613839f, -0.01897606f, -0.21909219f, 0.36937514f, -0.04997917f, 
    0.05886765f, 0.13248897f, 0.12050474f, 0.06863960f, 0.02697009f, 0.16935842f, -0.17073646f, -0.09435538f, 
    0.34597611f, 0.17865402f, -0.21890339f, 0.21395396f, -0.02188975f, 0.01770618f, -0.03367629f, -0.05607014f, 
    -0.03792090f, 0.03028335f, -0.06130292f, -0.16393818f, 0.06841344f, -0.20560017f, -0.25749147f, 0.05590141f, 
    0.12515129f, -0.14976285f, 0.04808931f, -0.16293848f, -0.03403757f, 0.06896795f, -0.00974229f, 0.15608241f, 
    0.16700837f, 0.18505041f, 0.02788613f, 0.10344532f, 0.00325193f, 0.06551524f, -0.08720018f, -0.10197847f, 
    -0.04867649f, 0.00214186f, 0.01134148f, -0.11722738f, 0.14453597f, -0.15696716f, -0.20473614f, 0.07228424f, 
    0.05626057f, 0.01745364f, 0.01848377f, -0.09654113f, -0.04831563f, 0.10001351f, 0.03767120f, 0.09720813f, 
    -0.53706098f, -0.01012556f, -0.15990014f, -0.34737316f, 0.05441682f, 0.02145293f, 0.04101603f, -0.03274510f, 
    0.02668306f, -0.08043110f, 0.02002554f, 0.15035336f, 0.39803693f, -0.03655469f, 0.19457325f, 0.01823703f, 
    -0.07968399f, 0.17626211f, 0.03769766f, 0.14819801f, 0.09887686f, -0.13770597f, 0.13168249f, 0.00183178f, 
    0.19556695f, -0.12535068f, -0.15515684f, -0.02956058f, 0.02009808f, 0.02448318f, 0.16072921f, 0.12694241f, 
    -0.07454102f, 0.04043277f, 0.02309792f, -0.05286642f, 0.04297493f, -0.18503653f, -0.26969409f, -0.07476601f, 
    0.02520848f, -0.01870867f, -0.05751726f, 0.03920774f, 0.04300380f, -0.03842080f, 0.05061996f, 0.11595790f, 
    0.00996119f, 0.16630174f, 0.07056231f, 0.20079888f, 0.02020091f, 0.04043807f, -0.06576481f, -0.03764509f, 
    0.13576777f, 0.05410520f, 0.03907573f, -0.04675109f, 0.08034076f, 0.04722684f, 0.10565412f, 0.27487490f, 
    0.06538735f, -0.08906613f, 0.05846274f, 0.00980800f, -0.05874062f, 0.11170428f, 0.17785953f, -0.11779989f, 
    0.01541991f, 0.05423513f, 0.06305692f, -0.01825601f, -0.07320426f, -0.04498401f, -0.07627059f, -0.07380338f, 
    0.05329275f, -0.03400328f, -0.04517462f, 0.05996410f, 0.04231906f, 0.05564305f, -0.05040507f, -0.01387924f, 
    0.01278955f, -0.05920789f, 0.05106397f, -0.01913868f, -0.06040712f, 0.05449573f, -0.00908905f, 0.01706009f, 
    -0.01593382f, 0.04174453f, -0.00780523f, -0.00052164f, -0.07665727f, -0.05098261f, 0.01117941f, -0.06345179f, 
    0.00329989f, 0.04858050f, 0.01314031f, 0.00164530f, 0.05328951f, -0.01564827f, -0.00658051f, -0.07434992f, 
    0.00430092f, -0.05744494f, -0.02754804f, 0.06006061f, -0.03261540f, -0.03686250f, -0.03173783f, -0.03649190f, 
    -0.01995155f, 0.03039688f, 0.05741020f, -0.01991772f, 0.01872184f, 0.02893324f, -0.00679293f, -0.01789701f, 
    -0.03497667f, 0.03586939f, -0.07404701f, 0.03842175f, 0.05769798f, 0.04960346f, -0.05704228f, -0.03738206f, 
    0.01279637f, -0.01317577f, 0.00248816f, 0.04530371f, 0.04223609f, -0.07432190f, -0.05366582f, -0.05541625f, 
    -0.07033760f, 0.04484791f, 0.04426699f, -0.07226726f, 0.03417085f, 0.04858564f, -0.05175515f, 0.05117343f, 
    -0.07918868f, 0.05677798f, 0.00330094f, 0.01731174f, -0.03491863f, 0.05343462f, -0.05339169f, -0.00965653f, 
    -0.00773773f, 0.04717348f, -0.01823315f, 0.01646131f, -0.03603576f, 0.05326195f, 0.00896778f, 0.01476244f, 
    0.04565164f, -0.04966865f, -0.00671076f, 0.02550319f, -0.07181294f, 0.03725895f, -0.01719999f, 0.01587008f, 
    -0.01623362f, -0.02121790f, 0.03403815f, -0.00424223f, -0.00993290f, -0.07974195f, 0.00996262f, 0.04160938f, 
    0.02740961f, -0.03996628f, -0.01504757f, 0.00702455f, -0.06817053f, -0.02267968f, 0.05372120f, -0.07485567f, 
    0.03801327f, 0.06063959f, -0.07456958f, -0.03869494f, -0.05187031f, 0.01830414f, 0.02617269f, -0.02015084f, 
    0.01177134f, -0.02525025f, -0.03572078f, -0.01314617f, 0.04350195f, -0.01275141f, -0.00222017f, -0.04563911f, 
    0.05365530f, 0.04385576f, -0.07049817f, -0.06393303f, -0.04779254f, -0.00907733f, -0.02451237f, 0.03078501f, 
    -0.02841288f, 0.01674610f, -0.05960485f, -0.01731206f, -0.07579262f, 0.03943768f, 0.04327361f, -0.07741552f, 
    0.00156972f, -0.01677369f, -0.00103573f, -0.01015455f, -0.07579506f, 0.06637937f, -0.05623780f, 0.05834620f, 
    -0.00371462f, -0.04134902f, -0.07497085f, -0.02900192f, -0.07868930f, 0.03593703f, 0.05774879f, -0.06965473f, 
    -0.03985056f, 0.00672403f, -0.07407165f, 0.04240146f, -0.04608839f, -0.03919164f, -0.02512301f, -0.05880648f, 
    0.04571322f, -0.04727793f, 0.02899300f, -0.02438495f, -0.04557864f, 0.02358712f, 0.01017578f, -0.05925675f, 
    0.00612586f, -0.01932267f, -0.03788403f, -0.06728262f, -0.03441128f, -0.04488830f, -0.03134393f, 0.04892628f, 
    0.00189932f, 0.02934081f, -0.06346353f, 0.03438808f, 0.03788357f, 0.00656254f, -0.06497985f, 0.05216675f, 
    0.05793343f, -0.04323188f, -0.06741694f, 0.01108995f, -0.06823359f, -0.06055649f, 0.05718355f, -0.06307292f, 
    -0.04182963f, -0.00499057f, 0.04577092f, -0.06513544f, 0.04784195f, -0.00512029f, -0.05489331f, -0.04499254f, 
    -0.03288716f, 0.05279606f, -0.00653052f, -0.00085445f, -0.03098074f, 0.06026021f, -0.02637461f, -0.00776719f, 
    -0.07766660f, -0.01964828f, -0.02341204f, -0.06768778f, -0.05348016f, -0.02902567f, -0.01335956f, -0.07741836f, 
    0.06199529f, 0.04758526f, -0.00771402f, -0.07113659f, -0.02425711f, -0.06270494f, 0.02347666f, 0.00123622f, 
    -0.06714807f, -0.05551996f, -0.00953092f, 0.04071336f, -0.01179050f, 0.01608325f, -0.01905001f, -0.06028297f, 
    0.00714988f, 0.06286952f, -0.05712826f, 0.00815940f, 0.02893152f, -0.06270578f, -0.05276299f, -0.03505967f, 
    -0.06924413f, 0.00174888f, 0.04158125f, -0.01235514f, 0.02582161f, 0.00317478f, -0.00282987f, -0.02392129f, 
    0.03977348f, -0.00279035f, -0.05290262f, -0.05392733f, -0.03531097f, 0.01401240f, -0.01017153f, -0.05930948f, 
    -0.05946991f, 0.01385610f, -0.00392169f, -0.06608800f, -0.02573380f, 0.01393697f, -0.02163163f, -0.03565556f, 
    0.03941221f, 0.05060182f, -0.01894572f, -0.04714702f, 0.01352251f, 0.00254226f, -0.04546263f, -0.02262019f, 
    0.00860452f, 0.05322218f, 0.05055228f, -0.02632936f, 0.02971510f, 0.04126484f, 0.02016662f, 0.02405074f, 
    -0.00415218f, 0.02865844f, -0.04415159f, -0.03115860f, 0.00730565f, -0.06781430f, -0.06205711f, -0.07698932f, 
    -0.04471794f, -0.04049156f, -0.04908463f, -0.01296739f, -0.00387917f, 0.03923688f, 0.05550434f, 0.02652728f, 
    -0.04515296f, -0.06590809f, 0.06206162f, -0.00745704f, 0.05615099f, -0.06793348f, -0.00153540f, 0.02601589f, 
    -0.03377429f, -0.00522305f, 0.03002465f, 0.00363230f, -0.06626571f, -0.00402738f, -0.06444580f, 0.02922870f, 
    0.02972646f, 0.04071609f, -0.00343427f, 0.05010432f, -0.06764167f, -0.01901812f, 0.00015489f, 0.04038897f, 
    -0.05665463f, -0.02416094f, 0.05745556f, -0.03700618f, 0.05318564f, -0.01170877f, 0.04203921f, 0.00158255f, 
    0.00809069f, -0.03406117f, 0.06207082f, -0.07556501f, 0.05617178f, -0.02085882f, -0.03224935f, -0.05562642f, 
    -0.06187453f, -0.05096681f, 0.04962735f, -0.05868715f, 0.02938980f, -0.06903388f, -0.05006862f, 0.05849805f, 
    0.01547148f, 0.01528657f, -0.06577823f, -0.05239029f, -0.07210383f, -0.06553305f, -0.04697990f, 0.02341532f, 
    -0.01471382f, -0.06010400f, 0.04668981f, -0.06641172f, 0.00370785f, 0.04664302f, 0.00404583f, 0.04188479f, 
    0.02241259f, -0.02388253f, -0.02850209f, -0.05537349f, 0.04557352f, -0.01669171f, -0.01916802f, 0.01556504f, 
    0.01716245f, 0.01070308f, 0.00605185f, 0.00301701f, 0.02784058f, 0.03684844f, -0.02947893f, -0.01259924f, 
    0.01357271f, 0.02117928f, -0.00671810f, 0.03791583f, -0.06123402f, -0.03028457f, 0.05297488f, 0.04676602f, 
    -0.03413725f, -0.06140266f, 0.05234518f, 0.04037895f, -0.05402266f, -0.05989959f, -0.03294678f, -0.07307360f, 
    -0.00819180f, 0.06481388f, 0.00173852f, 0.01302508f, 0.01717130f, -0.02684898f, -0.06223013f, -0.03917565f, 
    0.03893499f, -0.06462868f, 0.05938264f, 0.06029230f, -0.07402701f, -0.02579751f, 0.03690109f, -0.02001339f, 
    -0.08161782f, 0.02115138f, 0.03584291f, -0.05628393f, -0.01779536f, -0.03652336f, 0.00878081f, -0.02934437f, 
    -0.05773805f, -0.01473576f, -0.03113093f, -0.06942492f, 0.01359849f, -0.04958608f, -0.07134014f, -0.04475670f, 
    0.03448599f, -0.03478527f, -0.07170431f, -0.04599151f, 0.02383245f, -0.02878759f, 0.00597916f, 0.05457865f, 
    0.00621471f, 0.01189323f, 0.00579618f, 0.01527909f, -0.00148962f, -0.02086691f, -0.05589426f, 0.01753576f, 
    -0.00762463f, -0.06437812f, -0.02472714f, -0.03724619f, 0.02490889f, -0.04278990f, -0.04215761f, -0.03885709f, 
    0.05051081f, -0.02801872f, 0.04773742f, -0.06052893f, -0.01720677f, 0.05641498f, -0.02213479f, 0.03533557f, 
    -0.01595464f, -0.02146788f, 0.00630168f, 0.00406422f, -0.01531104f, 0.04226726f, -0.05512919f, -0.06836637f, 
    -0.04707012f, -0.02018914f, -0.00740821f, 0.00299717f, -0.03495979f, 0.04646179f, 0.04840711f, -0.07905066f, 
    -0.07419194f, -0.05477182f, -0.01916943f, -0.05439984f, -0.06766261f, 0.05461828f, -0.05866490f, 0.04269070f, 
    -0.06523658f, 0.01087540f, -0.07332747f, -0.01551771f, -0.02297969f, -0.07293966f, 0.01526765f, 0.00488522f, 
    -0.03861695f, -0.06217349f, 0.03963882f, 0.06171481f, -0.00924146f, 0.00420191f, -0.05959959f, 0.06185460f, 
    0.01354972f, -0.06682590f, -0.06625939f, 0.05033826f, 0.04178661f, 0.00808851f, 0.06351865f, 0.00819137f, 
    0.01892693f, -0.06440166f, -0.03884027f, 0.01921998f, -0.04331817f, 0.05213827f, 0.05083904f, 0.00359041f, 
    -0.05590270f, 0.01345791f, -0.02340558f, -0.04152324f, 0.02250249f, -0.01294651f, -0.04368715f, -0.03357457f, 
    -0.04036030f, 0.04481991f, -0.00138460f, -0.06725616f, -0.08303659f, 0.00684727f, 0.01200623f, -0.03680424f, 
    -0.02460375f, -0.06536368f, 0.03912487f, 0.02427427f, -0.04969848f, -0.07795183f, -0.06451020f, -0.02563369f, 
    -0.00604519f, 0.04614662f, -0.02127256f, -0.07787707f, -0.01184177f, -0.00091226f, -0.00151183f, 0.06218379f, 
    -0.06003776f, 0.04305800f, 0.02727389f, 0.03162217f, 0.00648976f, 0.02789827f, -0.00299641f, 0.06297661f, 
    0.05380897f, 0.03502121f, 0.00476101f, 0.01224218f, -0.03600283f, -0.01992181f, 0.03553321f, -0.03942235f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00849484f, -0.01195628f, -0.06307814f, -0.02336520f, -0.08401009f, 0.05544369f, -0.03857613f, -0.04185988f, 
    0.03397071f, 0.05118554f, 0.04941485f, -0.01176297f, 0.00633000f, 0.01028399f, -0.06601357f, 0.15547265f, 
    -0.05594629f, -0.06626020f, 0.02739348f, -0.05760598f, 0.14427182f, 0.17574969f, -0.07117440f, 0.08351146f, 
    -0.02536135f, 0.00087451f, 0.03075571f, 0.08381466f, 0.00629103f, -0.06163132f, 0.13772130f, 0.03990943f, 
    -0.03809609f, 0.02051417f, 0.04077674f, 0.05841280f, 0.03545088f, 0.05730776f, -0.03511754f, 0.09893344f, 
    -0.02486189f, -0.12264588f, -0.01737279f, -0.01496900f, 0.00933335f, 0.07751070f, 0.11717515f, 0.07912564f, 
    -0.11136781f, 0.12113272f, 0.02444811f, 0.10805612f, 0.04220458f, -0.04290522f, 0.03110164f, 0.06235576f, 
    -0.01350814f, 0.14280243f, 0.04895084f, -0.07078126f, 0.08444180f, 0.00302744f, 0.05181992f, 0.03907703f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02879728f, 0.00705853f, 0.12514675f, 0.28701472f, -0.21852262f, 0.31839356f, 0.26795039f, 0.03077214f, 
    -0.49706358f, -0.35869196f, -0.35864887f, -0.30246550f, 0.05682239f, -0.26030424f, 0.03467598f, -0.35259917f, 
    -0.10019178f, 0.26790819f, -0.02946628f, 0.02842128f, -0.47000036f, -0.43838507f, -0.07322489f, 0.03722984f, 
    0.22624679f, 0.09423004f, -0.54723948f, 0.10462416f, -0.13340403f, 0.05582559f, -0.47383633f, -0.36956391f, 
    0.11046740f, -0.20577551f, -0.07387545f, -0.45132640f, 0.19142179f, -0.05786519f, -0.05546260f, -0.43629259f, 
    -0.09890849f, 0.25463754f, -0.03137400f, -0.13779861f, 0.03588468f, 0.08721811f, -0.54946685f, 0.29753864f, 
    -0.25161028f, -0.25182539f, 0.29731521f, 0.25810274f, 0.02617001f, 0.29519886f, -0.11347504f, -0.21836038f, 
    0.07833202f, -0.20816936f, 0.20046449f, 0.08048885f, -0.47635376f, 0.00004613f, -0.07674904f, 0.09006455f, 
    0.08065195f, -0.06582638f, 0.20086056f, 0.07272884f, -0.14710458f, -0.57364398f, 0.19184473f, -0.08984046f, 
    0.02541177f, 0.30707589f, -0.06355894f, 0.17934830f, -0.14125635f, -0.16528200f, -0.08139487f, -0.60971946f, 
    -0.01063341f, 0.17287296f, -0.21122684f, 0.09101634f, -0.52156532f, 0.08484497f, 0.04797055f, 0.28394023f, 
    0.06273391f, -0.17133024f, -0.12374864f, -0.32442459f, -0.24244651f, 0.22480410f, -0.14880845f, -0.08536498f, 
    -0.05391134f, 0.23910993f, 0.00091732f, -0.19851044f, 0.18735790f, -0.03726199f, -0.02735390f, 0.30297747f, 
    -0.10271621f, 0.18606320f, -0.28204921f, -0.00972776f, -0.24525884f, 0.04754178f, -0.12821352f, -0.03912699f, 
    -0.38286880f, 0.40629429f, 0.06079772f, -0.54719102f, 0.24181031f, -0.36354905f, -0.10162327f, 0.25796410f, 
    -0.00283618f, -0.20487426f, 0.20504974f, -0.01442950f, -0.08516552f, 0.08014221f, 0.08638141f, -0.03374409f, 
    -0.11606961f, -0.06353872f, -0.12868603f, -0.00431631f, -0.01599034f, 0.36722106f, -0.04933100f, 0.05671856f, 
    0.22152539f, -0.23666972f, -0.51627421f, 0.29575729f, -0.53696108f, 0.15072829f, 0.04322122f, -0.20793617f, 
    -0.00777484f, -0.10308036f, 0.00462511f, 0.03350520f, -0.48013669f, 0.26969853f, 0.11166333f, -0.57152355f, 
    0.00653501f, 0.00713339f, 0.08786708f, -0.35393697f, 0.35261878f, 0.24017018f, -0.37343532f, 0.03671150f, 
    0.08215854f, 0.34020972f, 0.07531101f, 0.02385974f, -0.25353381f, -0.02055546f, 0.04432670f, -0.35253969f, 
    -0.07353587f, 0.17145844f, 0.02018870f, 0.16624102f, 0.04493355f, 0.11535638f, 0.12288856f, 0.14645840f, 
    0.32406905f, -0.18416840f, -0.27590433f, 0.20547049f, 0.11359657f, -0.28225693f, -0.04058588f, 0.19399647f, 
    -0.04295910f, -0.53489125f, -0.00750127f, 0.00212114f, -0.18558480f, 0.09944088f, 0.00352631f, -0.07795674f, 
    -0.01831305f, 0.05559868f, -0.54101098f, -0.21224999f, 0.29762119f, -0.30273318f, -0.27431774f, -0.09237606f, 
    -0.01954436f, -0.09242529f, 0.38381234f, -0.33577299f, 0.00718188f, -0.50335562f, 0.04226370f, 0.03074275f, 
    -0.19927408f, 0.27320540f, 0.05088347f, 0.01814237f, -0.24183553f, -0.39360303f, 0.06652546f, -0.01270899f, 
    -0.14627078f, -0.72728598f, 0.25991797f, -0.09844549f, -0.01691799f, 0.09231520f, -0.18917482f, -0.14832911f, 
    -0.14909022f, -0.67275631f, 0.00468518f, 0.20784780f, -0.49953324f, -0.09658873f, -0.10580284f, 0.19301625f, 
    -0.08551741f, -0.04794496f, 0.09800398f, -0.59688747f, 0.23314409f, 0.09953395f, -0.53029633f, 0.24631135f, 
    0.38647592f, 0.22303635f, 0.00733848f, 0.37493449f, 0.23148178f, 0.25793126f, 0.07032298f, -0.35672334f, 
    0.07911389f, 0.14637353f, -0.01073449f, -0.08590209f, 0.02114182f, -0.08227850f, -0.04204429f, 0.06394554f, 
    0.07669407f, 0.11115725f, -0.05967450f, -0.24462824f, 0.25746736f, -0.07240739f, -0.03812130f, -0.04212223f, 
    -0.18059690f, 0.20864007f, 0.09774420f, -0.30022761f, 0.21981426f, 0.09496563f, 0.01829513f, -0.35358310f, 
    0.08503494f, 0.05510235f, -0.09457181f, 0.02849339f, 0.34410244f, 0.30900410f, -0.07695860f, -0.25391513f, 
    0.08156878f, -0.00291873f, -0.15997264f, 0.06516884f, -0.13925508f, 0.10178595f, -0.42168653f, 0.29721299f, 
    -0.32954630f, -0.19487570f, 0.11870565f, -0.41579324f, 0.07799322f, 0.00162101f, 0.06106070f, -0.37294537f, 
    -0.06114944f, -0.08371440f, 0.36229071f, -0.22480877f, 0.07085676f, -0.22565147f, 0.08140864f, -0.30921271f, 
    0.23920116f, 0.20083526f, 0.22414601f, 0.39652619f, 0.11982146f, 0.31929228f, -0.08855268f, -0.24349269f, 
    0.11454970f, 0.25113243f, -0.20800066f, -0.11472107f, -0.19289096f, 0.00504758f, 0.02707954f, -0.09944826f, 
    -0.10833101f, 0.00126787f, -0.02493473f, -0.15656604f, -0.49876988f, -0.52740651f, 0.06432460f, -0.02966214f, 
    0.07762734f, 0.09089553f, 0.04761136f, -0.09330971f, 0.22468346f, 0.28841904f, -0.00583923f, 0.24577358f, 
    0.28511426f, 0.17855757f, 0.09817451f, -0.04890151f, 0.18418394f, -0.03950749f, 0.04500418f, 0.14755420f, 
    0.15856086f, 0.19321777f, -0.44747573f, 0.06829000f, -0.34789446f, -0.14953279f, 0.30306062f, -0.82201308f, 
    0.12647912f, -0.03065796f, 0.05885952f, -0.19761887f, -0.15113848f, -0.03183184f, -0.00962286f, -0.64541656f, 
    0.06578287f, -0.12731643f, -0.07056545f, 0.06341682f, -0.65766555f, 0.10824768f, 0.14695346f, -0.21757519f, 
    -0.41458324f, -0.38804391f, 0.20475364f, -0.09509837f, 0.14359005f, -0.09491551f, -0.01569061f, -0.47643197f, 
    -0.13119359f, 0.12625955f, 0.23751111f, 0.00944611f, 0.17572019f, -0.07728586f, 0.00986060f, -0.10885524f, 
    0.02490323f, -0.13007075f, 0.14409769f, -0.08332376f, -0.37516117f, 0.32425267f, 0.19952279f, 0.04520077f, 
    -0.04242435f, 0.09901422f, 0.00288989f, 0.33601949f, -0.14389226f, -0.72322959f, -0.04848574f, 0.22871576f, 
    -0.42671561f, -0.01308252f, 0.15911695f, 0.06503494f, -0.04724832f, 0.02723172f, -0.03843137f, -0.19685026f, 
    -0.25643232f, 0.15830560f, 0.38727385f, 0.41446695f, -0.20815998f, -0.25875726f, 0.33846033f, 0.14625655f, 
    -0.54945362f, -0.27733147f, 0.03903032f, 0.39388749f, -0.27588978f, -0.08986720f, -0.09606903f, 0.13878711f, 
    -0.10375313f, -0.42601383f, 0.21405485f, -0.03361459f, -0.19226712f, 0.19510932f, -0.11935610f, -0.62049127f, 
    0.31750861f, -0.07075556f, 0.16397738f, -0.63752359f, -0.02957859f, 0.08810695f, 0.08903463f, 0.36262831f, 
    0.03552175f, 0.09980033f, -0.19614922f, 0.05961426f, -0.28211585f, 0.11654671f, 0.04306098f, 0.09133370f, 
    -0.13673492f, 0.11105243f, -0.26645681f, 0.16512527f, 0.07995489f, -0.25210646f, 0.00646008f, 0.11155632f, 
    0.26265267f, -0.34496865f, -0.13826060f, -0.02519632f, 0.24972710f, -0.09934573f, 0.05632999f, -0.20791575f, 
    0.01852838f, 0.07222251f, -0.34517258f, 0.06742258f, 0.44864297f, -0.34407976f, -0.09011150f, 0.05921026f, 
    -0.45973682f, 0.18200204f, 0.19337547f, 0.13348308f, -0.10335266f, -0.36895591f, -0.28665709f, -0.11713678f, 
    -0.00903648f, 0.29718533f, -0.03657433f, 0.11146390f, -0.34243324f, -0.12419008f, -0.04402534f, 0.14691877f, 
    -0.04626878f, 0.37443948f, 0.19825627f, -0.12703274f, 0.03064860f, -0.24384643f, 0.34387791f, 0.15184654f, 
    0.24154770f, -0.27873117f, -0.17267500f, 0.03246696f, -0.36659187f, -0.09187277f, -0.07178082f, 0.17640282f, 
    0.09108632f, -0.13894969f, -0.35462418f, -0.00635006f, 0.08688254f, -0.06417760f, 0.07242838f, -0.06597645f, 
    -0.06554777f, 0.01350915f, -0.19261016f, 0.27388868f, 0.24294099f, 0.14278120f, -0.17961764f, 0.09148055f, 
    0.15612400f, -0.19861424f, 0.40070763f, 0.17056791f, -0.05174440f, 0.36058429f, 0.02544092f, -0.09386870f, 
    0.39498618f, -0.39090702f, -0.52872294f, -0.08611377f, 0.18964612f, 0.10802555f, -0.13029261f, 0.02432921f, 
    0.26260093f, -0.30371734f, -0.35990945f, 0.09075765f, -0.24206936f, 0.07213312f, 0.30841511f, -0.28734246f, 
    0.23207985f, -0.06457771f, 0.05052230f, -0.36833400f, 0.23891853f, 0.00077297f, -0.09615137f, -0.40507981f, 
    -0.11366219f, 0.15022774f, 0.05702823f, -0.14490424f, -0.11151677f, 0.09856679f, -0.13660315f, -0.61253208f, 
    0.14166045f, 0.09885241f, -0.29910403f, -0.58139962f, 0.20329730f, -0.43469936f, 0.07517736f, -0.05471052f, 
    -0.02220198f, -0.44778875f, 0.06892852f, -0.06865647f, -0.45160013f, -0.05259172f, 0.03323824f, -0.04666716f, 
    0.07702524f, -0.01135433f, -0.00826076f, -0.56662810f, 0.16742565f, 0.33942226f, 0.01190171f, 0.06654518f, 
    -0.12409000f, -0.01671233f, -0.20658027f, -0.16412351f, -0.04524597f, 0.09450014f, 0.11204854f, 0.29359716f, 
    -0.35846743f, -0.50178146f, -0.01991852f, -0.02460275f, 0.10731668f, -0.46961111f, -0.01225687f, 0.17717277f, 
    -0.04525205f, 0.35154197f, 0.08507455f, -0.07527074f, 0.40431768f, 0.20681091f, 0.00332718f, 0.35563090f, 
    -0.29964313f, 0.00413096f, 0.06872227f, -0.19778922f, 0.33885589f, 0.10843686f, -0.01240954f, 0.35465869f, 
    -0.04556827f, 0.27959648f, -0.00647548f, 0.38109505f, -0.15100685f, -0.05177421f, 0.25807449f, -0.08288800f, 
    -0.04930448f, -0.48148984f, -0.11086252f, -0.26639438f, -0.28107575f, -0.10979066f, -0.00910037f, -0.21434271f, 
    -0.04272161f, -0.03023089f, -0.42009637f, -0.07957900f, 0.19247709f, -0.04412322f, 0.07445092f, -0.07965635f, 
    -0.00307039f, 0.05453952f, -0.53648645f, 0.26985085f, -0.04781124f, -0.50646669f, -0.72791529f, 0.05085992f, 
    0.21274766f, -0.10612798f, -0.07527618f, -0.05464657f, -0.55175281f, 0.08532297f, -0.10749694f, 0.21044496f, 
    0.02065464f, -0.02471358f, 0.16748457f, 0.03903542f, 0.33422816f, 0.25026858f, 0.07703431f, -0.19458517f, 
    -0.00424288f, 0.13923688f, 0.37491208f, 0.11327907f, 0.15274259f, -0.10513298f, -0.21860057f, 0.02103722f, 
    -0.01164621f, -0.01792732f, 0.04938339f, 0.20040359f, 0.04070626f, 0.01436369f, -0.01144226f, -0.04681849f, 
    -0.00583558f, -0.10595874f, -0.49127033f, -0.30221212f, 0.22483669f, 0.27285069f, 0.20899133f, 0.05134175f, 
    -0.42056555f, 0.13964263f, -0.35595769f, 0.08312201f, -0.36511406f, -0.15665545f, 0.07686880f, 0.42230240f, 
    0.09089350f, 0.22420220f, 0.07599860f, -0.06425414f, 0.22962976f, -0.12613411f, 0.03323529f, -0.00160545f, 
    0.09471052f, 0.01958604f, -0.01508422f, -0.00050102f, -0.33524039f, 0.27831906f, -0.01601372f, -0.03043267f, 
    0.17478469f, 0.17162637f, -0.09054184f, 0.04764123f, 0.19696610f, 0.16604984f, -0.02746637f, 0.27348912f, 
    -0.42684153f, -0.23059317f, -0.45164675f, -0.08841210f, -0.39404383f, 0.04285386f, -0.11274391f, -0.10134994f, 
    0.10477514f, 0.06271295f, -0.54368788f, 0.31735140f, -0.07327176f, -0.08837625f, 0.25699010f, 0.25345206f, 
    0.11844894f, -0.44825321f, -0.11856128f, 0.29560727f, 0.02583769f, -0.02859452f, 0.10743260f, 0.34024689f, 
    0.09693186f, -0.51693201f, -0.29279363f, 0.09156342f, 0.00605579f, -0.43306655f, -0.19813524f, 0.30238178f, 
    -0.11688086f, 0.06606108f, -0.30238190f, 0.22085279f, -0.23161256f, 0.23101428f, 0.05411822f, -0.14775975f, 
    0.00772863f, -0.15668795f, 0.18964462f, 0.04443808f, 0.30610576f, 0.07404307f, 0.07824989f, -0.10177638f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02281345f, 0.17089333f, -0.19089633f, -0.04802957f, 0.00018258f, 0.14806375f, 0.02047504f, -0.06071841f, 
    -0.12969899f, 0.03745545f, 0.10300528f, -0.07338982f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
