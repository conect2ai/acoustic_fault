#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57308221f, -0.24502361f, -0.15776961f, -0.81124336f, -0.36058462f, -0.20609145f, -0.34044445f, -0.15573137f, 
    0.43471611f, 0.01943397f, 0.16255502f, -0.17645501f, -0.32348850f, -0.04633053f, -0.10781210f, -0.39579564f, 
    -0.19097880f, -0.10378107f, -0.12781918f, -0.34438044f, 0.02832642f, 0.29246438f, 0.09556054f, 0.23727593f, 
    0.14425255f, 0.08323068f, -0.31842965f, -0.19155301f, -0.40584761f, -0.50395507f, -0.32105297f, -0.50254619f, 
    -0.41155905f, -0.41553262f, -0.37712801f, 0.37629664f, 0.25844365f, 0.07141325f, 0.25283650f, 0.07601122f, 
    -0.01245175f, 0.12900907f, -0.08205558f, 0.02817636f, -0.02627814f, -0.03182843f, -0.02595186f, 0.24108289f, 
    -0.11081163f, -0.16202493f, -0.28193521f, -0.34055522f, -0.06818858f, -0.10549892f, -0.06639437f, -0.63691878f, 
    -0.48867309f, -0.71338326f, -0.42847303f, -0.19475706f, -0.05643241f, 0.37923712f, 0.23538871f, -0.26847774f, 
    0.02979921f, 0.16396958f, 0.25661728f, -0.04702611f, -0.18332238f, -0.26310161f, 0.22903670f, 0.28333542f, 
    -0.00051999f, 0.09804744f, 0.24039477f, -0.02423367f, -0.71548009f, -0.44269106f, -0.10385861f, -0.74537760f, 
    -0.17252046f, 0.06531261f, -0.20703648f, -0.63769913f, -0.75080377f, -0.10110439f, -0.47958693f, -0.07484476f, 
    0.05648440f, -0.41521704f, 0.04995421f, -0.06336741f, 0.02673220f, -0.25327086f, 0.20438102f, -0.07377893f, 
    -0.25479275f, -0.04189085f, -0.04091056f, 0.13049565f, 0.30018827f, 0.63462585f, 0.50143903f, 0.01710802f, 
    -0.03644366f, -0.45017922f, -0.32866105f, -0.15304556f, -0.14432253f, -0.14548348f, -0.14177224f, -0.09418643f, 
    -0.03484567f, 0.16463102f, -0.11984213f, 0.28708959f, 0.16946082f, -0.00445213f, -0.02733280f, 0.13122694f, 
    0.08464889f, -0.10877618f, -0.20639554f, -0.28968188f, -0.23835646f, 0.44990599f, -0.48077577f, -0.38429826f, 
    -0.41946483f, -0.35510722f, 0.54527926f, 0.01193909f, 0.10578284f, 0.25047019f, 0.14943373f, -0.08005869f, 
    0.15737449f, -0.10474876f, -0.19406638f, 0.16677110f, -0.16413882f, -0.12943831f, -0.11544160f, 0.32240161f, 
    0.08885264f, -0.10116532f, -0.19470608f, -0.13750604f, 0.22602744f, 0.27267161f, 0.87423092f, -0.06535188f, 
    -0.16950224f, 0.17183039f, -0.24293199f, -0.28625885f, 0.15425804f, 0.54559708f, -0.14933217f, -0.36583576f, 
    -0.28622347f, 0.05885527f, -0.21724379f, -0.34827054f, 0.00335913f, -0.06307088f, 0.00308848f, 0.23535138f, 
    0.24851634f, -0.20554128f, 0.07593697f, -0.21411620f, -0.13330537f, 0.00789416f, 0.21356845f, -0.18614745f, 
    0.80288750f, 0.27585301f, -0.54368305f, -0.32018524f, -0.35385343f, -0.16390008f, 0.39336005f, 0.04860101f, 
    -0.15599835f, -0.29631594f, -0.07768239f, 0.41120031f, -0.19717668f, -0.29097751f, 0.26229060f, -0.24112028f, 
    -0.27729103f, 0.26838577f, 0.10886703f, -0.12653670f, 0.23256058f, -0.29099068f, 0.11710182f, 0.30310264f, 
    0.03024528f, -0.43011901f, -0.63663572f, -0.21360596f, 0.39631426f, 0.48677960f, -0.21588951f, -0.72222221f, 
    -0.59539151f, -0.34979489f, 0.25591657f, 0.13261330f, 0.42202318f, 0.00378287f, 0.46427819f, 0.06031970f, 
    -0.24136126f, -0.42775860f, -0.04116201f, -0.29565865f, 0.14037836f, -0.32682538f, -0.10569748f, 0.34722331f, 
    0.13726248f, -0.81018847f, 0.14902896f, 0.14891030f, 0.29550555f, 0.42646232f, -0.13531019f, -0.14610894f, 
    0.12752879f, 0.09857035f, 0.41008830f, 0.33685112f, 0.14610717f, -0.07178905f, -0.41449988f, -0.25284401f, 
    0.24463385f, -0.01144412f, -0.07314326f, -0.20880508f, 0.05167330f, 0.18967664f, -0.16554491f, 0.03852206f, 
    0.14251260f, -0.27311993f, 0.31783149f, -0.54428428f, -0.18326198f, 0.25619498f, 0.44220996f, 0.72759104f, 
    0.62176192f, -0.61083299f, -0.54884911f, -0.52724892f, -0.17228721f, -0.14287437f, 0.03256540f, -0.09020047f, 
    -0.11620285f, 0.00669344f, -0.36060774f, 0.14110690f, 0.38832620f, -0.11592479f, -0.12402610f, 0.04205862f, 
    0.14025880f, 0.13557199f, -0.16357578f, -0.88460594f, -0.27939180f, -0.03833358f, 0.38804960f, 0.47831526f, 
    -0.06166903f, -0.62476754f, 0.34139100f, -0.23003845f, 0.17233175f, -0.36893106f, -0.27004135f, 0.18928768f, 
    0.01631236f, -0.32168257f, 0.05139516f, -0.31941909f, -0.12708561f, -0.03062311f, 0.26687768f, 0.11665823f, 
    -0.20759879f, 0.14393538f, -0.17537840f, 0.23076102f, -0.61119604f, 0.24075608f, 0.38408384f, 0.15612426f, 
    -0.08012846f, -0.27244946f, 0.35493565f, 0.00041124f, 0.01322638f, -0.29636520f, -0.48938516f, 0.29242358f, 
    -0.35576156f, 0.13852187f, -0.04146605f, 0.32554293f, 0.15710916f, -0.14721224f, -0.07532686f, -0.26213250f, 
    -0.30120590f, -0.16957508f, 0.12183810f, 0.19655445f, 0.15609993f, -0.55358911f, -0.53485036f, -0.65363824f, 
    -0.96326083f, -0.85899544f, 0.41049182f, 0.36838385f, -0.21305168f, -0.24432428f, 0.13976991f, -0.15241809f, 
    -0.33188772f, -0.05983318f, -0.12511355f, -0.15190832f, 0.15741596f, 0.09350982f, 0.03578603f, 0.04943013f, 
    -0.18027772f, -0.30671474f, -0.12597591f, 0.32039583f, -0.19818613f, -0.28328049f, -0.48108411f, -1.27197874f, 
    0.02852694f, 0.69470912f, 0.43925515f, 0.58949226f, -0.21318573f, -0.03605183f, 0.12070044f, 0.20024420f, 
    0.23784028f, -0.25604695f, 0.24676418f, -0.42066637f, -0.03792379f, -0.20270312f, -0.09453329f, 0.33007964f, 
    0.18542066f, -0.10005532f, -0.10207336f, -0.10584528f, -0.26749143f, 0.19975860f, 0.23725578f, 0.20852585f, 
    -0.10505114f, -0.65687764f, -0.67242354f, -0.35757273f, -0.28312004f, -0.25299287f, 0.22745670f, 0.21408726f, 
    0.37785128f, 0.18647431f, 0.25963894f, 0.31250861f, 0.17579761f, 0.00100098f, -0.13499644f, 0.09722991f, 
    -0.11262134f, -0.14698870f, 0.09407862f, -0.25869787f, 0.19880298f, -0.15286951f, -0.16875970f, 0.16298351f, 
    -0.01899941f, -0.50790656f, -0.13108440f, 0.16361870f, -0.43676916f, -0.25472251f, -0.44664571f, -0.07674438f, 
    0.40626159f, 0.38153231f, -0.06415755f, 0.17648456f, 0.09774499f, 0.04961893f, -0.01194277f, -0.18252568f, 
    0.06862730f, 0.05600746f, 0.20372073f, -0.10631762f, -0.22495320f, -0.41795421f, -0.16064593f, -0.29429680f, 
    -0.17280559f, 0.54907018f, -0.54844004f, -0.90647888f, -0.04389995f, 0.18946457f, 0.42083374f, 0.74125504f, 
    0.45003295f, -0.14440809f, -0.10596882f, -0.43975741f, -0.07423960f, -0.08144885f, -0.24335025f, 0.05667754f, 
    0.00975771f, 0.12126666f, 0.13230175f, -0.13770078f, -0.01542571f, 0.16389813f, -0.06611697f, -0.23807058f, 
    0.13142334f, -0.11433239f, -0.01765593f, -0.26515418f, 0.32242307f, 0.03226536f, -0.01470513f, -0.09001578f, 
    -0.25343651f, 0.39846575f, -0.25451940f, -0.07836397f, -0.22857578f, 0.11063201f, 0.35428664f, -0.40128112f, 
    0.09895822f, -0.00897078f, 0.23283835f, -0.20307826f, 0.18234573f, 0.27808475f, -0.31285608f, -0.21661341f, 
    -0.16937074f, -0.04197079f, 0.30517644f, -0.41232362f, -0.19649678f, 0.33017349f, 0.21350555f, 0.26822472f, 
    -0.14398840f, -0.43223381f, -0.07238917f, 0.20807680f, -0.15084624f, 0.08304718f, 0.07526198f, -0.19917887f, 
    -0.22610913f, 0.37711623f, -0.26884207f, -0.25501847f, -0.37645078f, -0.16015849f, -0.45043018f, -0.46571454f, 
    -0.39531621f, -0.40698805f, -0.42936778f, -0.69646358f, -0.14305285f, -0.63296437f, -0.38094023f, 0.46523410f, 
    0.80950868f, -0.51097268f, -0.43874186f, -0.74397159f, -0.58272290f, 0.12797686f, 0.26248780f, 0.18169293f, 
    0.28273821f, -0.18626252f, 0.18725957f, -0.16498409f, 0.29743195f, -0.29750505f, -0.17178722f, 0.03999380f, 
    0.33427018f, -0.10844143f, -0.00665233f, -0.03350204f, 0.07858370f, -0.95134926f, -0.56594181f, -0.41144660f, 
    -0.18563630f, 0.03293933f, 0.25510344f, 0.07882811f, -0.25650820f, 0.45401901f, -0.19760939f, 0.04264419f, 
    0.31371009f, 0.03419171f, 0.18728732f, 0.03271702f, -0.10788846f, -0.03618438f, -0.28973278f, -0.17178220f, 
    0.12400250f, 0.12296724f, -0.10370141f, 0.28440440f, -0.13353059f, -0.23008198f, 0.41584969f, 0.36825573f, 
    -0.26244372f, -0.03097589f, -0.51619011f, -0.02081682f, -0.10920527f, 0.16149846f, -0.01271336f, 0.08191974f, 
    0.16706246f, -0.12591016f, 0.21939486f, -0.00033306f, -0.05015500f, -0.29882184f, 0.04042899f, 0.28575253f, 
    0.23953786f, -0.34310132f, -0.08915631f, 0.01501283f, 0.15174843f, -0.14028826f, 0.18834995f, 0.28705877f, 
    0.11963923f, -0.34580037f, -0.11198790f, 0.40608847f, 0.02329749f, 0.21639284f, 0.10435513f, -0.00223409f, 
    0.15037785f, -0.22405258f, -0.26481533f, -0.13712281f, -0.22529006f, 0.11675995f, -0.07259656f, -0.05382975f, 
    -0.05882027f, 0.02603560f, -0.00018364f, -0.27008447f, -0.26927790f, -0.36793393f, -0.33141634f, -0.38238797f, 
    -0.49729794f, -0.59765089f, -0.65668356f, -0.27272969f, 0.00654871f, -0.43241888f, -0.59818196f, -0.36071303f, 
    -0.41388419f, -0.17120971f, 0.32833675f, -0.20928994f, 0.16858774f, 0.10077043f, -0.25773975f, 0.10381961f, 
    -0.05471100f, -0.16971438f, -0.09148102f, -0.35284165f, -0.31802446f, -0.28699425f, 0.11356602f, -0.17125732f, 
    -0.29655457f, 0.00256168f, -0.16190311f, -0.33041853f, -0.56640077f, -0.22180344f, -0.01848411f, -0.49765021f, 
    -0.25140026f, -0.36980346f, -0.84762239f, 0.46105254f, -0.51233196f, -0.34842190f, -0.28510603f, -0.34990531f, 
    -0.56245112f, -0.37428701f, -0.39154235f, -0.38982937f, -0.43012360f, -0.12660474f, 0.11867755f, 0.24941991f, 
    -0.08894309f, -0.14689507f, -0.68906212f, 0.09452511f, 0.72394395f, 0.55850995f, -0.42246491f, -0.39337015f, 
    -0.72217917f, -0.29087758f, -0.19094028f, -0.54087728f, 0.59050822f, -0.45387125f, -0.45122549f, 0.26047921f, 
    -0.16105871f, -0.07123747f, -0.17364986f, 0.31637755f, -0.43657058f, -0.34981465f, 0.00275997f, 0.03883784f, 
    -0.02978877f, -0.30839136f, -0.15308432f, -0.42783231f, -0.36182314f, -0.16017283f, -0.11396192f, 0.05114529f, 
    0.45761651f, -0.07686004f, 0.02768252f, 0.38771746f, 0.22103377f, 0.09212304f, 0.13690430f, -0.02087819f, 
    0.04231489f, -0.29446122f, -0.35557124f, 0.18562956f, -0.11592221f, 0.32761598f, -0.34161347f, 0.09881550f, 
    0.37238997f, 0.08733199f, -0.14544949f, -0.11562315f, 0.39238179f, 0.42303661f, 0.38998216f, 0.23898837f, 
    0.20602520f, 0.47812176f, 0.05003563f, 0.25832677f, 0.22128727f, -0.11281569f, 0.09870037f, 0.16152541f, 
    -0.03970905f, -0.22062096f, 0.14229679f, -0.29351431f, -0.20150235f, -0.12249769f, -0.08435958f, -0.15955041f, 
    -0.03346499f, 0.15658008f, -0.07952022f, 0.01492492f, 0.19104081f, 0.12160072f, 0.35978886f, 0.23481797f, 
    0.12777434f, -0.13908583f, -0.28378773f, -0.14667603f, 0.10776629f, 0.04725003f, -0.29067814f, -0.28473631f, 
    -0.15680364f, -0.03274026f, -0.04587996f, 0.19130264f, 0.42621714f, 0.60791552f, 0.11595147f, -0.26044196f, 
    -0.22529896f, -0.12606369f, -0.36669451f, -0.39965922f, 0.21430266f, -0.18972914f, 0.34852895f, 0.38479224f, 
    -0.21207862f, -0.13789301f, 0.13516454f, -0.24423137f, -0.16304356f, 0.06893688f, 0.00666837f, 0.17896430f, 
    0.04730875f, 0.26810202f, -0.45080927f, -0.14988042f, 0.30186698f, 0.17347002f, -0.16352104f, -0.06673609f, 
    0.10536144f, -0.07701762f, -0.00726560f, 0.31888306f, 0.18568181f, -0.19952427f, -0.38442656f, 0.10938353f, 
    0.07853491f, -0.17004226f, -0.36177024f, -0.51044697f, 0.24380779f, -0.19739564f, 0.33810657f, 0.29211101f, 
    -0.13323919f, -0.09090345f, -0.23647934f, 0.24060076f, -0.12301722f, 0.21210051f, -0.02192062f, -0.16096084f, 
    -0.02789059f, 0.15239252f, -0.06423119f, -0.02153958f, 0.23400281f, -0.23787516f, -0.14113002f, 0.43987861f, 
    0.10635232f, 0.34227923f, 0.29873669f, -0.29498437f, 0.12001743f, -0.10795093f, 0.06396373f, -0.24967468f, 
    0.04743081f, 0.15341410f, -0.37515822f, 0.36115938f, 0.21828543f, -0.41061953f, -0.11956260f, -0.05778705f, 
    -0.16074525f, -0.10832775f, 0.26316789f, -0.07250896f, -0.01398367f, -0.06690210f, 0.18327835f, -0.23649131f, 
    0.17208906f, 0.63762188f, 0.15343405f, 0.30776471f, 0.53977859f, 0.37011713f, -0.37999398f, -0.33476767f, 
    -0.36728954f, -0.37562391f, -0.48378021f, 0.05385636f, 0.15976454f, 0.10207500f, -0.06916196f, -0.24444589f, 
    -0.12780690f, 0.00348088f, 0.08452729f, 0.17630200f, 0.01867486f, -0.05507773f, -0.05307732f, -0.17451957f, 
    0.28985357f, 0.12095924f, -0.24868500f, -0.12692970f, 0.09574170f, 0.28909981f, -0.37974656f, -0.40568438f, 
    -0.44764537f, -0.36217806f, -0.36589760f, -0.32320738f, -0.00943444f, 0.00589229f, 0.22526380f, -0.05274145f, 
    -0.05936810f, 0.03746039f, 0.20245439f, 0.21556593f, 0.18967213f, -0.01426005f, -0.11308964f, -0.19018207f, 
    -0.10604796f, -0.23963228f, -0.27147889f, -0.86863005f, -0.19439735f, -0.33761013f, -0.70168966f, -0.68342286f, 
    0.62059581f, 0.01010011f, 0.19871715f, 0.33603755f, 0.55851257f, 0.20233865f, -0.08605448f, 0.06776439f, 
    -0.15879062f, -0.10753327f, -0.02345163f, -0.07937980f, -0.08532710f, -0.08655438f, -0.01597574f, -0.22711028f, 
    -0.13972524f, 0.01394164f, -0.30749223f, -0.10889258f, -0.84080076f, -0.35823974f, 0.28847036f, -0.43417573f, 
    -0.56721020f, 0.68333530f, -0.06319817f, -0.19699210f, -0.04620597f, 0.17452365f, -0.19973207f, -0.01978748f, 
    0.13172135f, 0.18015984f, -0.05894385f, 0.11218780f, -0.19645444f, -0.20333685f, 0.00763872f, -0.14723231f, 
    0.03797810f, 0.34860736f, 0.19993882f, 0.14008018f, 0.23005988f, -0.13991459f, -0.65164095f, -0.22710115f, 
    0.41072342f, 0.54294974f, -0.88274342f, -0.41753036f, 0.36921769f, 0.54216772f, 0.36217844f, 0.10549240f, 
    0.11246257f, -0.20595385f, -0.04004305f, 0.15031762f, -0.24295981f, -0.10407664f, 0.48413795f, -0.21044117f, 
    -0.59327191f, 0.07229512f, 0.20838806f, -0.01662521f, -0.01407079f, 0.40061894f, 0.32639873f, -0.68395656f, 
    -0.35876778f, -0.15213135f, 0.06494474f, 0.17664091f, 0.28796190f, 0.34844983f, 0.27082750f, 0.05015969f, 
    -0.01127497f, 0.02504514f, 0.06318553f, 0.12691551f, 0.17598028f, -0.14936215f, -0.15376329f, -0.20320998f, 
    -0.04951053f, -0.07035983f, 0.34449771f, 0.00549750f, 0.26163685f, -0.08555100f, -0.11165507f, -0.28768039f, 
    -0.51622570f, -0.33490035f, 0.27451158f, 0.82461226f, -0.51542050f, -0.10287672f, -0.13267857f, 0.27073091f, 
    -0.00700445f, -0.06084334f, -0.00009534f, -0.34912151f, 0.09485131f, 0.24603547f, 0.17843448f, -0.12058934f, 
    -0.17487946f, 0.30848867f, 0.12108567f, -0.17483532f, -0.05998078f, 0.14353187f, -0.09578830f, 0.14010540f, 
    0.39441752f, 0.27159083f, 0.04158941f, -0.43401939f, -0.09985493f, 0.26127240f, -0.25789267f, 0.38300797f, 
    -0.35823870f, -0.31099528f, -0.07183962f, -0.25238043f, -0.06939929f, 0.02443074f, -0.14217785f, 0.27323070f, 
    0.29878426f, -0.07955361f, -0.37725040f, -0.13163786f, 0.09520130f, 0.10449498f, -0.15377538f, 0.20015177f, 
    0.21386136f, -0.11474610f, 0.65595508f, 0.01489010f, -0.18515238f, -0.40882909f, -0.70391273f, -0.18037952f, 
    0.03606587f, 0.25915331f, 0.29167905f, 0.27935246f, 0.30111209f, 0.17888345f, 0.10735928f, -0.31999272f, 
    -0.14008370f, -0.14262347f, 0.31202284f, -0.13781051f, -0.33838332f, 0.09543644f, 0.11564948f, 0.08253407f, 
    0.18827440f, 0.19889021f, 0.49401054f, 0.35847366f, -0.61226869f, -0.98784161f, -0.68413872f, -0.03171484f, 
    -0.29404008f, 0.07565858f, -0.35971838f, 0.12944302f, 0.39572224f, 0.55331409f, 0.22789331f, 0.12047409f, 
    -0.16457002f, -0.11347786f, -0.05366068f, -0.37378213f, -0.31643280f, -0.20985840f, 0.38025597f, -0.13770254f, 
    -0.33850366f, 0.03724566f, -0.09498323f, -0.83879387f, -0.54496908f, 0.10673819f, 0.43226168f, 0.36758816f, 
    0.52353013f, 0.20001914f, -0.11848304f, 0.08468759f, 0.24407081f, 0.06276609f, 0.22132096f, -0.05747617f, 
    -0.04371567f, -0.05698436f, -0.45457098f, 0.32162011f, 0.02365164f, -0.38410404f, 0.04138455f, -0.17382297f, 
    0.44209340f, -0.18782195f, -0.09896500f, 0.30347651f, 0.22779226f, 0.69283295f, 0.57639527f, -0.47534117f, 
    0.26935148f, -0.65536755f, -0.50743514f, -0.03481042f, 0.46302980f, -0.20566963f, 0.21009725f, -0.18861103f, 
    0.01976082f, -0.02540145f, -0.30872643f, -0.02786403f, -0.12769207f, 0.16179247f, 0.09958664f, 0.04049946f, 
    0.06922141f, 0.14834526f, -0.30842334f, 0.10092616f, -0.10722176f, -0.12082727f, 0.47908798f, -0.38307071f, 
    0.21076965f, -0.16752531f, -0.62752968f, -0.42230603f, 0.71647680f, 0.34329408f, 0.03974570f, -0.04103908f, 
    -0.46257940f, 0.42850655f, -0.23453256f, -0.31005365f, 0.04078437f, -0.08139130f, -0.07048831f, 0.10877892f, 
    -0.17130710f, -0.19044705f, -0.13413191f, 0.06541729f, -0.13340685f, 0.18495138f, -0.27369934f, 0.09779377f, 
    0.36409068f, 0.13596672f, 0.01496701f, 0.01139523f, 0.60153931f, -0.33151782f, 0.08015894f, -0.36010391f, 
    -0.21416733f, -0.08001585f, -0.08845430f, -0.09305692f, 0.01253129f, 0.29227424f, -0.17432266f, -0.14836383f, 
    0.25356951f, 0.32785821f, -0.00503823f, -0.10432313f, 0.16245778f, -0.26882899f, -0.35955319f, 0.16535924f, 
    -0.25703874f, 0.15698257f, 0.31324038f, -0.26781827f, 0.29748791f, -0.12001569f, 0.27998099f, -0.42525744f, 
    0.20176022f, 0.04544396f, 0.05859451f, -0.24276464f, 0.02949153f, 0.13331945f, -0.19074342f, -0.24380414f, 
    -0.23871316f, -0.05237303f, 0.45003167f, 0.00181567f, -0.06876101f, 0.07778256f, 0.02545616f, 0.04436264f, 
    0.40930605f, -0.58297372f, -0.19565834f, 0.44454053f, 0.25402597f, 0.35625836f, 0.40907663f, -0.10154737f, 
    -0.17404680f, -0.31828287f, -0.19579580f, 0.50105935f, -0.18654165f, -0.53391922f, 0.04873366f, -0.19109480f, 
    0.00777023f, 0.14580759f, 0.24076205f, 0.01715682f, 0.48080784f, 0.03446196f, -0.07962563f, -0.16112363f, 
    -0.26350483f, -0.75860035f, -0.22051735f, -0.00326072f, -0.30101052f, -0.03277874f, 0.20437080f, -0.49301225f, 
    -0.59661353f, -0.07995002f, 0.02278224f, -0.20477280f, -0.42319593f, -0.31476045f, -0.49175182f, -0.20809828f, 
    -0.18476121f, -0.02610387f, 0.00219594f, -0.09804729f, 0.03929388f, -0.09346452f, -0.08639040f, -0.09476335f, 
    0.02795686f, 0.09287880f, -1.03965688f, -0.49975726f, -0.60433489f, -0.85437095f, -0.07933124f, 0.07053906f, 
    -0.41852102f, -0.35896245f, 0.09794186f, 0.53275770f, -0.45048517f, -0.47037208f, 0.09382669f, -0.33532083f, 
    -0.24912859f, -0.00695420f, -0.24615008f, -0.12436993f, 0.28157929f, -0.09852012f, -0.03634587f, 0.03914971f, 
    -0.30863336f, -0.11578618f, -0.04365704f, 0.12931329f, 0.04589912f, -0.03444780f, -0.15691620f, -0.09961176f, 
    0.31545070f, 0.13072892f, -0.06378672f, -0.05742387f, 0.03449694f, -0.10086626f, 0.30412778f, -0.26398593f, 
    -0.09480011f, -0.20219539f, -0.34526190f, -0.12311625f, -0.21648541f, 0.01553181f, -0.22829309f, 0.29388547f, 
    0.23314738f, 0.21363620f, 0.29595247f, 0.10952383f, 0.30043346f, -0.09677660f, -0.07651253f, 0.00743481f, 
    0.26595667f, 0.35557514f, 0.18470970f, -0.26235086f, -0.26837415f, -0.04677635f, 0.12401573f, -0.13246259f, 
    0.21007788f, -0.21657613f, -0.06046686f, 0.14408968f, -0.06649102f, 0.15845057f, -0.09351926f, -0.03705729f, 
    -0.23878631f, -0.09414846f, 0.06498995f, -0.15115012f, 0.05921186f, 1.08794045f, -0.34773016f, -0.28834572f, 
    -0.90674728f, -0.73349810f, 0.12771477f, 0.21608098f, 0.09932300f, 0.21310283f, 0.12665352f, 0.14166065f, 
    0.15278299f, 0.11380921f, -0.22403196f, 0.15701130f, 0.16242729f, 0.05390320f, 0.18453653f, -0.05041544f, 
    -0.32949102f, 0.11483034f, 0.18327598f, -0.13889311f, -0.11715192f, 0.22096010f, 0.20066476f, -0.40830609f, 
    0.03845516f, -0.39083600f, 0.09448204f, 0.26774403f, 0.05682787f, -0.22620061f, -0.15351926f, 0.38041821f, 
    -0.02398814f, -0.18148710f, -0.08454569f, 0.21146245f, 0.26333258f, 0.01257262f, -0.08402096f, -0.19731128f, 
    -0.00317131f, -0.43947202f, 0.09865412f, -0.18084361f, 0.20042536f, 0.15169446f, 0.26614487f, 0.22083056f, 
    -0.27107430f, -0.11340464f, 0.13465917f, 0.04838505f, -0.04806938f, 0.09240401f, 0.01444773f, -0.23424162f, 
    -0.42009786f, 0.27669960f, 0.09653191f, 0.02256276f, -0.04834368f, 0.19989659f, -0.18394044f, 0.07310353f, 
    0.07198552f, 0.09174758f, -0.01263410f, -0.16418625f, -0.36617768f, -0.03713693f, 0.37232271f, -0.00168468f, 
    -0.05812844f, -0.32509848f, -0.02919875f, 0.31681547f, 0.35206637f, 0.24386778f, -0.10011986f, 0.60703766f, 
    -0.47726884f, -0.23008135f, 0.02927091f, -0.30195341f, 0.16908427f, -0.11142267f, -0.00106652f, -0.25470215f, 
    0.04495889f, -0.08545516f, -0.07406845f, 0.11296145f, 0.37528047f, -0.26179984f, -0.29412591f, 0.25520381f, 
    -0.08742105f, -0.02391252f, 0.38127556f, -0.10895845f, 0.17375614f, 0.28681511f, -0.43171430f, -0.11089648f, 
    -0.23417416f, -0.24165128f, -0.10057519f, 0.01593909f, -0.16441777f, -0.01689550f, 0.30785799f, -0.09347881f, 
    -0.08035539f, 0.05901105f, 0.20475532f, 0.11033305f, 0.17321566f, -0.16518700f, -0.20377414f, -0.28837791f, 
    0.07413685f, 0.08632521f, 0.36618796f, 0.25381747f, 0.13072626f, 0.03339085f, 0.20810275f, -0.04939719f, 
    -0.13622466f, 0.20915157f, -0.15751615f, -0.24545866f, -0.09969272f, 0.40316153f, 0.22750139f, 0.04827601f, 
    -0.21000922f, -0.24371357f, -0.04490336f, -0.19335690f, -0.36997026f, -0.06921847f, -0.26838493f, 0.36108434f, 
    -0.15304631f, -0.33021468f, -0.23850471f, 0.73963255f, -0.26962164f, -0.27431569f, -0.24155644f, -0.08392127f, 
    0.13120721f, -0.01160082f, -0.17711109f, 0.43380171f, -0.05089688f, -0.17456257f, 0.09659039f, -0.07337944f, 
    -0.02702010f, -0.05147972f, -0.05248488f, -0.02713721f, 0.21093470f, -0.33275545f, 0.21040528f, 0.06752782f, 
    -0.22508517f, -0.21569589f, 0.28921077f, 0.11826705f, 1.18674648f, -0.34733582f, -0.16685210f, -0.51294392f, 
    -0.43323097f, 0.62319130f, 0.13664301f, 0.02642954f, -0.12526561f, 0.10864977f, -0.03114535f, -0.15658817f, 
    0.10531455f, -0.23177411f, -0.13681231f, 0.02379319f, -0.12902239f, -0.00219680f, -0.09452587f, -0.26244488f, 
    -0.24821968f, -0.37173989f, -0.31909168f, -0.29393974f, -0.19906019f, -1.04384315f, -0.75454086f, 0.25604907f, 
    0.54426068f, 0.33793798f, 0.49652883f, 0.42445493f, -0.17578159f, 0.06637547f, 0.05131932f, -0.16011924f, 
    -0.05957823f, -0.26695850f, 0.40120402f, -0.26090986f, -0.00625640f, 0.21719113f, -0.14820820f, -0.00613988f, 
    0.04114193f, -0.19671732f, -0.08439668f, 0.21403030f, 0.06882737f, -0.05070173f, -0.77419090f, -0.55119395f, 
    -0.44709975f, 0.08004358f, 0.20048335f, 0.29141250f, 0.25841260f, 0.03674490f, 0.25820252f, 0.14124542f, 
    0.18113343f, 0.02540785f, -0.00011749f, 0.18006957f, -0.19247583f, -0.29145202f, -0.18441720f, -0.01976416f, 
    0.17944483f, 0.19383097f, 0.21855353f, 0.12390277f, 0.14058444f, -0.06722469f, -0.24460311f, -0.41187051f, 
    -0.13768546f, 0.28196219f, -0.41473553f, -0.34864578f, 0.19486773f, 0.29856777f, 0.25288436f, -0.27316514f, 
    -0.44328320f, -0.00234976f, 0.28646418f, 0.06392922f, 0.52190024f, -0.19881080f, 0.05575468f, -0.01932850f, 
    -0.27141118f, -0.05970167f, 0.03453651f, 0.16750404f, -0.42825460f, -0.23233305f, 0.39828253f, 0.22655135f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14500642f, -0.00353148f, 0.28583381f, -0.19192478f, 0.06430395f, 0.17447419f, 0.18282658f, 0.34785098f, 
    0.34687075f, 0.29849091f, 0.28566995f, 0.15471391f, 0.23268701f, -0.34065437f, 0.29813725f, 0.34396365f, 
    0.03476983f, 0.10830540f, 0.12045904f, -0.16866010f, 0.21563151f, 0.40776932f, 0.30133131f, 0.04312981f, 
    -0.32804680f, 0.02585199f, 0.02779693f, 0.07450846f, -0.34233031f, 0.08279184f, 0.13112015f, 0.13703489f, 
    0.30991995f, 0.15880983f, -0.18937626f, 0.05376790f, -0.00789363f, 0.38105214f, 0.21347237f, 0.28706107f, 
    0.17024501f, 0.18800853f, 0.23788352f, 0.26718155f, 0.28008687f, 0.19038971f, -0.03097297f, 0.17952396f, 
    0.08533463f, -0.11151166f, 0.08104723f, 0.06297693f, 0.07803252f, 0.29138458f, 0.05681148f, 0.10693193f, 
    0.31169674f, -0.04776418f, -0.08294491f, 0.26156425f, 0.19748552f, 0.19609548f, 0.08109634f, 0.20129867f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13683619f, 0.06287828f, 0.13554759f, -0.12581918f, 0.12127701f, 0.34810483f, -0.15879139f, -0.02558568f, 
    0.00717828f, -0.12373963f, -0.02075648f, -0.08439030f, 0.29088843f, 0.15936756f, -0.20633920f, -0.21423897f, 
    -0.00286694f, -0.09924670f, -0.09809705f, 0.17790514f, 0.01850342f, 0.04087799f, 0.02298617f, 0.00214490f, 
    0.22056657f, 0.19840594f, -0.14200896f, -0.23164594f, -0.06215361f, -0.00445643f, 0.00992818f, -0.11710296f, 
    0.04557240f, -0.01721122f, -0.05006577f, -0.04005156f, 0.30532470f, 0.01217796f, -0.07398304f, -0.12954395f, 
    0.17514300f, 0.11161819f, 0.13081321f, 0.08698894f, -0.06740964f, -0.03562160f, 0.00291193f, -0.04742253f, 
    -0.17614618f, 0.01608720f, 0.05458899f, 0.06589313f, 0.04147597f, 0.01276241f, -0.20314556f, -0.10123021f, 
    0.03445273f, 0.01231925f, 0.04367353f, 0.10341610f, -0.07410215f, -0.11711381f, -0.22756016f, 0.03399969f, 
    0.03993988f, -0.01218105f, -0.05228764f, -0.14829566f, 0.09035514f, -0.02732851f, -0.03994452f, 0.02966819f, 
    -0.26438531f, -0.59010684f, -0.06831147f, -0.13062888f, -0.03351190f, -0.01081616f, 0.01468324f, -0.00160359f, 
    0.03229824f, 0.08506793f, -0.03624765f, 0.02660493f, -0.15276979f, -0.04501082f, 0.01172867f, 0.07837373f, 
    -0.00596805f, -0.11434025f, -0.11127157f, -0.04593828f, 0.00639399f, -0.00718622f, -0.02321797f, -0.02656650f, 
    0.29815295f, 0.20122980f, -0.55020124f, -0.08726759f, -0.02706095f, 0.02645309f, -0.11186332f, -0.18281086f, 
    -0.08057024f, -0.08167789f, -0.03387499f, -0.08671122f, -0.29386804f, 0.11340655f, 0.18676461f, -0.15057345f, 
    -0.02163763f, -0.03238668f, 0.07548737f, 0.03929636f, -0.12065054f, -0.01732483f, 0.02202823f, 0.01067906f, 
    0.25528395f, -0.09066293f, -0.35331362f, 0.03261971f, 0.01473803f, -0.23355742f, 0.15841453f, -0.09798412f, 
    -0.09532262f, -0.01457163f, -0.03013005f, 0.02786067f, 0.36695251f, 0.28240418f, 0.18913279f, -0.30644968f, 
    0.01787925f, -0.06380411f, 0.07829212f, -0.02418911f, -0.03439283f, -0.03598484f, 0.02941477f, -0.07404576f, 
    -0.11257724f, -0.31069291f, 0.01734477f, -0.21610302f, -0.18046664f, -0.07290421f, 0.07482536f, 0.10373325f, 
    -0.07813585f, 0.00646975f, -0.00713900f, -0.05451694f, 0.21977243f, 0.09022043f, -0.17718764f, -0.08801840f, 
    0.14890859f, 0.22679861f, 0.11162213f, 0.07188733f, 0.05097528f, 0.04575045f, 0.05284190f, 0.06470490f, 
    0.28283262f, 0.12168766f, 0.11728969f, -0.07134301f, 0.00131714f, 0.00859794f, 0.07373378f, -0.06604946f, 
    0.16481453f, -0.08896679f, -0.11673542f, 0.06137634f, 0.22778811f, 0.14834909f, 0.00959644f, 0.03395248f, 
    0.04912565f, 0.04074541f, -0.08591874f, -0.27714938f, -0.16218145f, 0.00756452f, 0.03919407f, 0.02259213f, 
    0.01851999f, 0.11504726f, 0.11876971f, 0.01592564f, 0.05881666f, 0.03047240f, 0.06117603f, -0.03200678f, 
    -0.01234160f, -0.02942129f, 0.03842749f, 0.14189886f, 0.17487077f, -0.23398702f, -0.50851506f, 0.13547705f, 
    0.01546380f, 0.07139763f, 0.05731545f, 0.01965514f, -0.00044099f, 0.05551603f, -0.05892924f, -0.04380283f, 
    -0.01595945f, -0.00555854f, 0.02070455f, 0.00122633f, -0.04648396f, -0.02121266f, 0.06680260f, -0.09751502f, 
    0.05748924f, -0.05011488f, 0.05334745f, -0.02231655f, -0.03960756f, 0.13318966f, 0.05178864f, -0.06011819f, 
    -0.11332556f, -0.06546026f, 0.02551177f, -0.01756003f, -0.04942880f, 0.01232742f, 0.19786480f, 0.10356515f, 
    0.14145342f, 0.35325503f, -0.14665322f, -0.21088198f, -0.07744110f, 0.06245192f, 0.08749914f, -0.13519874f, 
    0.03476561f, -0.04289838f, -0.01759225f, -0.08858574f, 0.31194407f, 0.09265681f, -0.08655800f, -0.18158159f, 
    0.06086436f, 0.07888135f, 0.06388092f, -0.01917716f, -0.11696638f, -0.09275571f, 0.03145576f, 0.01600331f, 
    -0.08689851f, -0.20777799f, -0.11650777f, 0.00332028f, 0.03023570f, -0.13127427f, -0.02350364f, -0.01476176f, 
    -0.14369918f, -0.12330610f, -0.10000366f, -0.05423588f, -0.44526574f, -0.17656176f, -0.02838362f, 0.07467793f, 
    -0.02527783f, 0.01716864f, -0.01093563f, 0.02648844f, -0.01702609f, -0.11475620f, 0.02532062f, 0.13700555f, 
    0.40891996f, 0.24731734f, 0.05471514f, -0.18790005f, 0.14446148f, 0.22180152f, 0.11823942f, 0.12903437f, 
    -0.08875518f, -0.11615953f, -0.08562305f, -0.01502468f, 0.20329931f, 0.03935541f, -0.15494232f, -0.15818913f, 
    0.06167779f, 0.11930722f, -0.12356186f, -0.03064135f, -0.12139434f, -0.12151641f, -0.17340143f, -0.04146140f, 
    0.03875530f, 0.09548016f, 0.08151882f, -0.38718793f, -0.15316330f, 0.05424264f, -0.14497109f, 0.10263034f, 
    -0.02479741f, -0.03890901f, -0.09252675f, 0.06560003f, 0.02886971f, -0.01115812f, -0.06805760f, -0.06398074f, 
    0.00756537f, 0.04088556f, 0.04849054f, -0.02526534f, -0.03937818f, 0.16497205f, -0.16736341f, -0.28505078f, 
    -0.35701218f, -0.35019156f, -0.31058949f, 0.01803485f, 0.06915689f, 0.05322443f, 0.02088402f, 0.07702108f, 
    -0.00206324f, 0.07536560f, 0.08242789f, -0.03342216f, -0.19173642f, -0.06359739f, 0.14579356f, 0.06280354f, 
    -0.01524353f, -0.02162450f, -0.09129789f, 0.06162131f, 0.01968125f, 0.10464095f, 0.04033601f, 0.08837137f, 
    -0.15658031f, 0.01560809f, -0.04698508f, 0.00544935f, 0.01980004f, -0.08740047f, 0.07770447f, 0.01231714f, 
    -0.10507071f, -0.02556057f, -0.08868419f, -0.01607075f, 0.06438259f, -0.19430397f, 0.08478987f, -0.04494480f, 
    0.06097760f, -0.06459489f, -0.08121346f, -0.20156977f, 0.02715700f, -0.05754932f, 0.00341492f, -0.01733647f, 
    -0.64378989f, 0.04366076f, -0.26762494f, 0.15927169f, 0.02437687f, -0.01125398f, -0.00182215f, 0.02754171f, 
    -0.01516399f, -0.06020681f, 0.02809278f, -0.03307999f, -0.05641013f, -0.04717117f, -0.25664049f, -0.09846983f, 
    -0.00275757f, -0.04650427f, -0.14681934f, -0.06821160f, 0.02257722f, 0.04944619f, 0.01387134f, -0.00588491f, 
    0.27393544f, 0.19909535f, 0.04724624f, -0.20512067f, 0.05519086f, 0.05696930f, 0.16672313f, 0.16828112f, 
    0.03059103f, -0.01348804f, 0.03573355f, 0.05796274f, 0.05831804f, -0.04602866f, -0.00498204f, -0.05652376f, 
    0.10076826f, 0.13498902f, -0.01891797f, 0.04450324f, 0.11164698f, 0.23549530f, 0.03020609f, -0.05549726f, 
    0.15746942f, 0.01105115f, 0.05288622f, -0.15378654f, -0.03308288f, 0.08846641f, 0.05527471f, 0.05320702f, 
    -0.02382560f, -0.04336928f, -0.02486913f, -0.00369467f, -0.28011474f, 0.31276137f, 0.13999978f, -0.35330278f, 
    -0.14039838f, 0.06229224f, 0.04863821f, -0.08217759f, -0.04529962f, -0.17020352f, -0.08347595f, -0.16002998f, 
    -0.03091195f, -0.15583876f, -0.19180074f, 0.15272214f, 0.03632557f, 0.00128458f, -0.01066068f, -0.02872493f, 
    -0.06744279f, -0.11873160f, -0.21565545f, -0.12709361f, 0.22078507f, 0.17190996f, 0.07340676f, -0.19063744f, 
    0.07806851f, 0.01426449f, 0.05540808f, -0.20482537f, -0.03925693f, 0.02843792f, -0.01300846f, 0.05342976f, 
    0.08937616f, -0.04166911f, -0.10856159f, -0.06977320f, -0.08958615f, -0.03234233f, -0.08005852f, 0.00470984f, 
    -0.02897299f, 0.01271563f, 0.01620105f, -0.01662619f, 0.09904448f, -0.14089997f, 0.19532272f, -0.03483438f, 
    -0.08229618f, 0.10859577f, -0.12552445f, -0.24880022f, 0.01301646f, -0.10305364f, -0.03898222f, -0.08025289f, 
    0.18621907f, 0.09475977f, -0.30356580f, -0.10309748f, 0.01223851f, 0.01941860f, -0.18865138f, -0.16940540f, 
    -0.06300490f, -0.01654497f, -0.04917733f, -0.02400268f, 0.03271681f, 0.10380697f, 0.05723409f, -0.00982785f, 
    -0.02045667f, 0.02579240f, 0.08925700f, 0.01767323f, -0.04132770f, -0.07493341f, -0.19508921f, -0.28416339f, 
    -0.57600147f, 0.03636974f, 0.09932962f, 0.00908923f, -0.02670828f, 0.05062784f, -0.08166850f, 0.02694739f, 
    -0.01157281f, -0.04818801f, 0.03367561f, 0.05899058f, -0.29578504f, 0.04567118f, 0.21839300f, -0.09376899f, 
    -0.01342543f, -0.04459139f, 0.04048667f, 0.03959691f, -0.07365305f, -0.10669636f, -0.11577377f, -0.05315091f, 
    0.03724926f, -0.15671378f, -0.01242945f, -0.05500578f, 0.01451724f, 0.06436288f, 0.03366615f, -0.11809918f, 
    -0.04998595f, 0.08308325f, 0.05175097f, -0.01236825f, -0.20885430f, -0.15822791f, 0.01052449f, -0.15812568f, 
    -0.04530984f, -0.04228670f, 0.05549177f, 0.02060145f, -0.00294673f, -0.01699731f, 0.02526541f, -0.28593811f, 
    0.05091952f, -0.16664843f, 0.09231360f, 0.03906866f, 0.03820537f, -0.11982854f, 0.08511820f, 0.01552113f, 
    -0.14505005f, 0.00765822f, 0.03977837f, -0.01691160f, 0.24248318f, 0.34386477f, 0.00371465f, -0.27858254f, 
    0.02069544f, 0.10480465f, -0.03925729f, 0.04489953f, -0.03379984f, -0.03886523f, -0.05131637f, -0.16799593f, 
    0.29048914f, 0.19722654f, 0.08585920f, -0.11227831f, 0.15396045f, 0.28006709f, 0.17521861f, 0.02356626f, 
    0.01101479f, 0.02685251f, -0.01231895f, -0.02524908f, -0.10829479f, -0.13857581f, -0.34369254f, 0.02724259f, 
    0.03019181f, -0.01127862f, 0.04339384f, 0.05705659f, -0.05578197f, -0.03298187f, -0.00895193f, -0.04946999f, 
    0.00159082f, -0.05435985f, -0.09313733f, 0.07463881f, 0.03456927f, -0.05664281f, 0.03069477f, -0.00987087f, 
    -0.06689620f, 0.03642654f, -0.07775285f, 0.04161819f, 0.08962600f, -0.16923460f, -0.19241212f, 0.08220296f, 
    0.03610940f, 0.03807956f, -0.07162480f, -0.11723331f, -0.08581645f, -0.07562327f, 0.04751523f, 0.01700905f, 
    -0.20519932f, 0.05184003f, -0.13934202f, 0.07828691f, -0.01390348f, 0.04534202f, -0.04312442f, -0.05506173f, 
    -0.05620300f, -0.05480497f, -0.06009290f, -0.03649770f, 0.06459316f, -0.06176952f, -0.10040065f, -0.04382145f, 
    0.07035358f, -0.18568097f, -0.21270409f, -0.14128150f, 0.01509856f, 0.07140701f, -0.05356865f, -0.00950793f, 
    0.10693211f, -0.54157174f, 0.04954299f, -0.12854470f, -0.00588311f, 0.01859397f, -0.03083532f, 0.04122962f, 
    -0.02876644f, -0.03517428f, -0.01712474f, 0.01194675f, 0.03509640f, 0.11993788f, 0.03120755f, -0.02957360f, 
    0.21989390f, -0.19713119f, 0.04554309f, 0.01206362f, -0.00655651f, 0.02714472f, 0.03498508f, 0.06939137f, 
    -0.41236925f, -0.14297022f, -0.33402768f, 0.13412584f, 0.03968147f, 0.05215436f, -0.00586277f, 0.00627494f, 
    -0.00031164f, 0.11248572f, 0.05310912f, -0.17510110f, -0.13950779f, -0.15365614f, -0.39417979f, -0.03707652f, 
    -0.10223909f, 0.07311618f, -0.06351354f, -0.05397581f, -0.16275395f, -0.20714343f, 0.08469185f, -0.04911567f, 
    -0.24215525f, -0.36360976f, -0.34858745f, 0.00404590f, -0.02512667f, 0.03924200f, -0.03269922f, 0.00699433f, 
    -0.08430900f, -0.02268142f, 0.01032099f, 0.04759242f, 0.64434826f, -0.32278877f, -0.17116487f, -0.22062543f, 
    -0.00619940f, -0.00925641f, 0.12770385f, -0.01843264f, -0.03398968f, -0.01523309f, -0.03462691f, -0.14327091f, 
    0.07613888f, 0.11531250f, -0.03531578f, 0.06160882f, 0.08540152f, 0.05596348f, 0.06945793f, -0.02476089f, 
    -0.06479985f, 0.00872506f, 0.00015904f, -0.02282152f, 0.16061713f, -0.13683529f, 0.02988579f, 0.05038590f, 
    -0.03180948f, -0.03491862f, -0.05940013f, 0.03982910f, -0.05351368f, -0.18017967f, -0.05414058f, -0.06515249f, 
    0.08753073f, 0.16916206f, 0.03707280f, -0.03508482f, 0.06351452f, 0.06547972f, 0.04139972f, 0.27972212f, 
    -0.04329808f, -0.00676253f, -0.03534411f, -0.02318059f, -0.01415871f, 0.06840169f, 0.04248167f, 0.04930697f, 
    -0.14346524f, -0.07432295f, -0.14824794f, -0.00251759f, -0.08207116f, -0.03210892f, -0.03081596f, 0.01537597f, 
    -0.09586763f, 0.04524628f, -0.04435623f, 0.03398895f, -0.14575565f, 0.00373239f, -0.09947367f, 0.05083109f, 
    0.01271668f, -0.00928250f, -0.02726007f, 0.06946488f, 0.17173541f, 0.10566755f, 0.31231621f, -0.06377390f, 
    0.10505925f, 0.00520284f, 0.06613887f, -0.29374072f, 0.02439128f, -0.03472800f, 0.00502101f, -0.00712582f, 
    0.03428393f, 0.05652183f, 0.00068156f, -0.02014009f, 0.04061406f, -0.07642573f, 0.03720554f, 0.07597309f, 
    -0.01700534f, -0.02306174f, -0.01998510f, 0.02153590f, 0.31752941f, 0.08680453f, -0.31240168f, -0.15147230f, 
    -0.04553965f, 0.02439280f, 0.06684487f, -0.03583087f, 0.07511798f, 0.05450389f, -0.01583418f, -0.04973669f, 
    0.74679631f, 0.17856714f, 0.06853020f, 0.02106977f, -0.05851261f, 0.00622137f, -0.01165163f, -0.19715013f, 
    -0.00941075f, -0.06701154f, -0.03062906f, 0.03185919f, 0.16339329f, -0.14510980f, 0.23367755f, -0.05299347f, 
    -0.09390285f, -0.01233957f, 0.06707366f, -0.11012177f, 0.00618242f, 0.02237799f, -0.03220033f, -0.00064462f, 
    -0.17329365f, -0.30857578f, -0.04032302f, 0.18886566f, 0.01123575f, 0.06864196f, 0.07952639f, 0.16557688f, 
    0.14991252f, -0.03159770f, 0.02381914f, 0.03844912f, -0.05219155f, -0.04119238f, 0.05651803f, 0.14255060f, 
    -0.00930722f, 0.02733175f, 0.01742425f, -0.01185709f, 0.00933660f, -0.05313752f, -0.04976711f, 0.24933925f, 
    0.20186138f, -0.29643032f, 0.01262012f, 0.10634901f, -0.11597455f, 0.00484665f, 0.20263404f, 0.02626727f, 
    -0.02078866f, 0.02675294f, 0.05864021f, 0.03861779f, -0.62928075f, -0.18250537f, -0.31604803f, -0.00800333f, 
    0.02484784f, 0.02577968f, 0.07837242f, -0.05540945f, 0.09666248f, 0.06428734f, -0.03208245f, -0.02697419f, 
    -0.02039040f, -0.37467426f, 0.08774842f, -0.06871176f, 0.08172292f, -0.01135124f, -0.01822722f, -0.10190997f, 
    0.05395831f, 0.10545986f, -0.12178770f, -0.00633087f, 0.37331957f, 0.24414228f, 0.21466140f, 0.08134980f, 
    0.06277446f, -0.06311589f, -0.14972086f, -0.25348839f, -0.01131270f, 0.01424519f, 0.03563140f, -0.01366705f, 
    -0.02757246f, 0.11885777f, -0.19578272f, 0.06412528f, -0.06664924f, 0.05394194f, 0.06721787f, -0.02006238f, 
    0.12442289f, -0.06926845f, 0.07674657f, 0.05852332f, -0.18920292f, -0.25489351f, -0.01599819f, -0.06654419f, 
    0.05172632f, 0.13250189f, 0.00965329f, -0.23185587f, 0.25288543f, 0.06066862f, -0.03144348f, 0.02275386f, 
    -0.19363266f, -0.00859548f, -0.03468606f, -0.13262463f, 0.02395064f, 0.06131901f, -0.01630083f, -0.08064353f, 
    -0.08276824f, -0.20202006f, 0.13352340f, -0.06337351f, 0.78882986f, -0.24570039f, 0.26143715f, -0.00256161f, 
    -0.02373204f, -0.02456556f, 0.00323927f, -0.02378489f, 0.08130714f, -0.10911483f, -0.09233113f, -0.02624933f, 
    -0.01691613f, -0.01215988f, 0.03417169f, -0.02019302f, -0.15255740f, 0.18191731f, 0.00741715f, -0.11182901f, 
    0.21048456f, 0.02865319f, 0.00841635f, -0.07249105f, -0.09806154f, -0.07065846f, -0.10749446f, -0.19525127f, 
    0.02158495f, -0.00575927f, -0.00309389f, 0.01141022f, -0.26138794f, -0.27531391f, -0.22391428f, -0.62570614f, 
    -0.48096487f, 0.01229599f, -0.29059643f, 0.20296295f, -0.00777589f, -0.11044924f, 0.07397375f, -0.04910759f, 
    -0.08728115f, -0.03380687f, 0.02184966f, 0.05573933f, -0.27487472f, -0.09368689f, -0.18358722f, -0.13926941f, 
    -0.01682216f, 0.10816676f, 0.09233291f, 0.09189801f, 0.05715689f, -0.05334079f, 0.08705636f, -0.09022817f, 
    0.00447771f, -0.05722927f, 0.07887290f, -0.13326330f, -0.02157934f, 0.09746460f, 0.00948385f, 0.02393222f, 
    0.01266493f, 0.12792480f, 0.09757857f, 0.01792201f, 0.11705395f, 0.00165979f, 0.10701924f, 0.09670840f, 
    0.02435922f, 0.03828388f, -0.03644176f, 0.00120322f, -0.24933933f, -0.11264441f, -0.01791240f, -0.21629189f, 
    -0.01036509f, 0.08883677f, 0.07444966f, 0.24643913f, -0.02546247f, -0.05777788f, 0.10805985f, 0.01528562f, 
    0.04296473f, 0.02419276f, -0.05259108f, -0.01488231f, 0.02738663f, 0.05821918f, -0.00944852f, -0.14413060f, 
    0.09265875f, -0.15786445f, 0.12637876f, 0.23536149f, 0.06346739f, 0.05978119f, -0.04718417f, 0.02454275f, 
    -0.53984451f, -0.31746927f, -0.38422915f, -0.52073449f, -0.08353098f, -0.20766319f, 0.11195493f, 0.30242312f, 
    -0.03008689f, 0.04359866f, 0.03543527f, -0.17735285f, -0.02570807f, 0.08942751f, -0.19286838f, -0.01575108f, 
    -0.10065895f, -0.00445745f, -0.05041444f, 0.04449217f, -0.22304733f, 0.01138844f, -0.04320442f, 0.07401861f, 
    0.27610666f, 0.16930148f, 0.20218311f, 0.25916627f, -0.03449066f, 0.00323560f, -0.01407886f, -0.04686258f, 
    0.02284831f, 0.04952802f, 0.00653583f, 0.13426410f, -0.04610965f, -0.00170715f, 0.13554247f, -0.02988623f, 
    0.08908706f, -0.00286068f, 0.10945844f, -0.06068074f, 0.10431339f, 0.13573065f, -0.32661945f, 0.02672588f, 
    0.10631815f, -0.00895044f, 0.02791325f, 0.01910738f, 0.03492393f, -0.10098047f, -0.01757832f, -0.01707940f, 
    0.01363120f, -0.06594663f, -0.06904051f, -0.06435283f, 0.01914176f, 0.08275619f, 0.03985421f, -0.07919274f, 
    -0.09107407f, 0.06747392f, -0.00267787f, -0.27288330f, -0.03972491f, 0.03894671f, -0.06327086f, -0.17666152f, 
    0.35549623f, 0.11495139f, 0.17245282f, 0.11440287f, -0.06267269f, 0.02635767f, -0.08761939f, 0.00212605f, 
    -0.02771765f, -0.01119233f, 0.02484606f, -0.05876606f, 0.09011135f, 0.20397922f, -0.18488578f, -0.02528215f, 
    -0.21324903f, -0.06617357f, -0.14258799f, -0.20938919f, -0.07480298f, -0.06969311f, 0.00835589f, 0.05621524f, 
    -0.12736982f, 0.08994920f, 0.05689362f, -0.16999674f, -0.12887479f, -0.03831729f, -0.09694691f, 0.03991623f, 
    0.00351082f, -0.01392467f, 0.04273151f, 0.00567655f, -0.04029616f, 0.19466099f, -0.09945614f, -0.21727271f, 
    -0.03182534f, 0.02845353f, -0.06197388f, -0.18717256f, -0.08601054f, -0.08660068f, -0.07719237f, -0.15591000f, 
    -0.01141446f, 0.10920371f, 0.24666245f, 0.15198132f, 0.06907906f, 0.03209822f, 0.04979891f, 0.15581363f, 
    -0.06794076f, -0.00841895f, 0.03095256f, -0.01522022f, -0.49779564f, 0.34936893f, 0.04135723f, -0.15442684f, 
    -0.14380053f, 0.17510645f, 0.02354357f, 0.03474015f, -0.03546987f, 0.11944350f, -0.13601215f, 0.05253688f, 
    0.22060771f, -0.05496602f, -0.05959263f, 0.01922011f, -0.08634083f, 0.02678217f, -0.01718650f, -0.02600617f, 
    -0.04387526f, 0.07022941f, 0.06902578f, -0.00111028f, -0.22097556f, 0.08588797f, -0.05756390f, -0.02828570f, 
    -0.01417606f, -0.05730383f, 0.08558005f, -0.02819708f, -0.01872825f, 0.04451572f, 0.05932828f, -0.05328135f, 
    0.24060789f, -0.02288448f, -0.01229444f, -0.05598384f, -0.00685990f, -0.10477743f, 0.01922775f, -0.02231608f, 
    -0.05166696f, 0.03874502f, -0.00504925f, -0.01013077f, -0.24809110f, -0.11808456f, 0.17000781f, -0.20184426f, 
    0.08394159f, 0.22342147f, -0.23380767f, 0.12919889f, 0.04914480f, -0.15164237f, -0.02280517f, -0.00189150f, 
    0.01541304f, -0.48625967f, -0.11277281f, -0.16153328f, 0.08568408f, 0.05933011f, -0.12840961f, 0.11829923f, 
    0.07987411f, -0.13196345f, -0.06736618f, 0.12900615f, 0.00458888f, 0.00661007f, -0.09974364f, 0.08406484f, 
    0.00527443f, -0.01233334f, -0.02527728f, 0.02943033f, 0.01348258f, 0.02366141f, -0.11932962f, 0.07459753f, 
    0.20656803f, -0.01567926f, 0.24265644f, 0.13017401f, 0.04874071f, -0.06854609f, -0.06353090f, -0.01793588f, 
    0.00861704f, -0.01471368f, 0.00712480f, 0.00235947f, -0.69158876f, 0.01608136f, -0.07660250f, -0.02706009f, 
    0.00408296f, 0.04708780f, 0.05765587f, -0.24160640f, 0.14276786f, 0.04319299f, -0.12981233f, 0.00309324f, 
    0.08595154f, 0.02065920f, -0.05777843f, -0.03767289f, -0.04540566f, 0.01221704f, -0.09249267f, 0.06474117f, 
    0.07728010f, 0.04698244f, 0.12743028f, -0.08074667f, 0.17388374f, 0.06435449f, 0.01662601f, -0.03709365f, 
    -0.01780386f, -0.04131329f, 0.04223914f, -0.01394493f, 0.00667269f, 0.06834962f, 0.07647560f, 0.01721946f, 
    0.25794056f, -0.09395938f, -0.07014120f, 0.09319488f, -0.06236727f, -0.03306771f, -0.00526471f, 0.10694899f, 
    0.09476232f, -0.00307503f, -0.09660240f, -0.00167976f, 0.21236314f, 0.23097681f, -0.09602271f, 0.01379435f, 
    0.04505746f, -0.07471569f, -0.04461392f, -0.00537246f, 0.02979883f, 0.02013313f, 0.01446369f, -0.04351022f, 
    0.13464431f, 0.16451901f, -0.08342105f, 0.20872672f, -0.01910922f, 0.10484803f, -0.10804427f, -0.16483726f, 
    -0.00758158f, 0.02467572f, -0.02623318f, -0.11440646f, 0.16271606f, 0.01864619f, -0.00699878f, 0.02161946f, 
    -0.06682707f, -0.05460790f, -0.01473582f, 0.06376432f, -0.04021919f, -0.04682782f, 0.01244155f, 0.01372855f, 
    0.06641249f, 0.02998652f, -0.05165929f, 0.11912343f, -0.03739010f, 0.00325834f, -0.01102429f, -0.03842271f, 
    -0.04964994f, 0.05814698f, 0.06433474f, 0.05595250f, 0.37342656f, -0.17250566f, -0.06327921f, -0.19340502f, 
    -0.00781153f, 0.11593808f, -0.12622084f, -0.16770953f, -0.05308076f, 0.13946076f, -0.05320812f, -0.04811286f, 
    0.08300912f, -0.04302773f, 0.03703026f, -0.02427844f, -0.00930514f, 0.01110994f, 0.05062619f, 0.04230471f, 
    0.00055198f, -0.03926683f, 0.12724030f, -0.24845125f, -0.05918650f, -0.03763482f, -0.02492503f, -0.01312450f, 
    -0.10169923f, 0.10384927f, 0.11371607f, -0.02386112f, 0.09994075f, 0.03402618f, 0.13269673f, 0.07448975f, 
    0.03454952f, 0.07853585f, 0.08235846f, 0.16493668f, 0.00128024f, -0.03645397f, 0.07463049f, -0.09565995f, 
    0.11709804f, 0.04586903f, 0.04231665f, 0.00097621f, -0.04677476f, 0.00264555f, 0.00999700f, -0.12988371f, 
    -0.02466698f, -0.17365831f, -0.09634100f, 0.03402532f, -0.03098758f, -0.02457114f, 0.03074583f, 0.01914585f, 
    0.04579221f, 0.04979679f, 0.10694076f, 0.10573779f, 0.05250733f, -0.07294124f, -0.07902215f, 0.04212459f, 
    -0.05675128f, 0.09948218f, -0.20988570f, 0.09693518f, 0.47214055f, 0.03828698f, -0.04777791f, 0.12322046f, 
    -0.00177914f, -0.00314358f, 0.07274902f, -0.06333859f, 0.15989813f, 0.17166856f, -0.09080780f, 0.01239112f, 
    0.48411518f, -0.06899749f, -0.01708890f, -0.02652737f, -0.01371061f, -0.02548198f, -0.07665992f, -0.07898402f, 
    -0.11961833f, -0.10741571f, -0.19984592f, -0.07804295f, 0.16531710f, -0.19578493f, 0.10865516f, 0.04738796f, 
    -0.01295837f, 0.03566729f, 0.03739296f, 0.06377828f, 0.14972419f, -0.13431731f, -0.05491206f, -0.14681792f, 
    0.01674808f, -0.09090386f, -0.12060119f, 0.03047929f, -0.05606488f, -0.03130826f, 0.04635941f, 0.06580514f, 
    -0.08186842f, -0.11175068f, 0.04344214f, -0.03094895f, -0.16337375f, -0.36158833f, -0.00993465f, -0.02144643f, 
    0.05878312f, 0.11130771f, 0.16192707f, -0.15212715f, 0.27398121f, -0.09850699f, 0.06894830f, -0.01042204f, 
    -0.22953223f, 0.37642163f, -0.08484827f, 0.05611410f, -0.04224285f, 0.09002296f, -0.05850223f, 0.04182581f, 
    -0.05065041f, -0.07991330f, -0.08540802f, -0.00074264f, -0.15810372f, -0.12620349f, -0.18352887f, -0.24658136f, 
    0.01244088f, 0.02862387f, 0.08500826f, -0.20372134f, 0.05835977f, 0.05812844f, 0.02480111f, 0.03724145f, 
    -0.10605720f, -0.53665125f, -0.22888768f, -0.14006987f, 0.02303454f, 0.10780922f, -0.05739755f, 0.03851338f, 
    0.04655407f, -0.04001562f, -0.04327680f, 0.02065283f, -0.56151462f, -0.11301661f, 0.15103029f, -0.24052653f, 
    -0.15656398f, 0.08017740f, 0.08563857f, -0.10653706f, 0.01218688f, -0.01022832f, 0.00862406f, -0.00230068f, 
    -0.13749003f, -0.02950674f, 0.10481113f, -0.11127665f, -0.01543623f, -0.00066640f, -0.24466978f, -0.12941879f, 
    0.02548791f, -0.01919926f, -0.02707281f, 0.06253797f, -0.16043927f, 0.38336697f, 0.15322487f, 0.02527837f, 
    0.01677245f, -0.02152415f, -0.04880770f, -0.10109815f, -0.11444622f, 0.10156041f, 0.01537198f, 0.03216291f, 
    -0.46924889f, 0.19037142f, 0.11140694f, 0.08803684f, -0.03844444f, 0.07115494f, 0.04195809f, -0.04945062f, 
    0.01510593f, -0.08926188f, 0.02276093f, 0.00618720f, 0.18755373f, -0.05648969f, 0.14126000f, -0.06929303f, 
    0.05333842f, 0.04373080f, -0.02040902f, 0.18441221f, -0.08372859f, 0.00399997f, -0.00815425f, -0.01915372f, 
    -0.19943944f, -0.54308742f, -0.08304896f, -0.08501287f, 0.02651469f, -0.07479444f, -0.04974673f, 0.05033893f, 
    -0.12857088f, -0.03884356f, -0.00436305f, -0.01651660f, 0.06174974f, -0.04934826f, -0.20267643f, 0.06354497f, 
    0.04293147f, -0.01519728f, 0.04073502f, 0.03254944f, -0.07865006f, -0.06190299f, -0.06137826f, 0.07646959f, 
    -0.13916086f, 0.21769477f, -0.10598195f, -0.17887270f, -0.01500980f, -0.07724778f, 0.08519862f, 0.04624647f, 
    -0.04505233f, -0.03012585f, 0.05745713f, -0.09946664f, -0.06096158f, 0.13777566f, -0.31284237f, 0.12805267f, 
    0.11363982f, 0.08982429f, -0.00210702f, 0.00490255f, 0.01523418f, 0.05899229f, 0.04389497f, -0.09225010f, 
    0.12294320f, -0.08794828f, -0.14579849f, 0.08061243f, -0.03457237f, 0.04429141f, 0.03348283f, -0.02855731f, 
    -0.06960337f, -0.01050357f, 0.05618006f, 0.04596955f, -0.23840164f, 0.12880999f, 0.37978384f, 0.16926786f, 
    -0.07875178f, -0.07864077f, 0.12554538f, -0.05519841f, 0.01169462f, 0.01237211f, 0.04469515f, 0.00102607f, 
    0.04610611f, 0.04053331f, -0.07623287f, 0.03537693f, -0.02929125f, 0.02047323f, -0.00539994f, 0.16013320f, 
    -0.07328524f, 0.04146154f, 0.05466847f, -0.08576638f, 0.00770453f, 0.24768153f, 0.00289380f, 0.17677988f, 
    -0.07858618f, 0.04855204f, 0.06760243f, -0.02451614f, 0.04279996f, 0.09431697f, -0.05206889f, 0.03366436f, 
    0.00017850f, 0.12483455f, -0.04878194f, 0.08127356f, -0.04382356f, 0.01668206f, -0.02706940f, -0.05442329f, 
    0.04873029f, 0.01421494f, 0.09668374f, 0.00804008f, -0.09544596f, -0.03873532f, 0.48358363f, 0.06010405f, 
    0.04577915f, -0.13344535f, -0.01416031f, -0.02019293f, 0.15537167f, -0.02630096f, -0.04795966f, -0.14270857f, 
    0.08239085f, 0.00230665f, -0.16167539f, 0.02804435f, -0.03125098f, 0.11789959f, 0.04131642f, -0.18418688f, 
    0.03256607f, 0.10542762f, 0.11753690f, -0.06694675f, -0.06841215f, 0.02655417f, -0.03230267f, 0.06419478f, 
    -0.03248446f, -0.00526364f, -0.00919665f, -0.06476825f, -0.10752781f, 0.11189549f, -0.04969250f, 0.12595369f, 
    0.11243396f, -0.39923823f, -0.30755997f, 0.03478831f, -0.00487007f, -0.00835469f, -0.13973306f, 0.05572420f, 
    0.00895803f, 0.01711309f, -0.07373577f, -0.04529713f, 0.19865085f, 0.03816597f, 0.19735032f, 0.27437377f, 
    -0.00580399f, -0.12634666f, 0.08804297f, 0.21545120f, 0.07863323f, 0.05885968f, -0.00668633f, 0.05762462f, 
    -0.21493343f, 0.06662313f, 0.12975144f, -0.07338113f, 0.05374784f, 0.08323653f, -0.03009314f, -0.05704614f, 
    0.06516072f, -0.08563411f, 0.08648327f, 0.05471322f, 0.06824043f, -0.09480017f, -0.04428534f, 0.02548532f, 
    -0.00981296f, -0.02723809f, 0.00909855f, -0.02859274f, 0.16003995f, 0.18905392f, -0.00396309f, 0.01598088f, 
    -0.64981425f, -0.35231128f, -0.03759412f, -0.21453062f, -0.03941005f, -0.13847424f, 0.10705704f, -0.12442268f, 
    -0.03232789f, -0.06374750f, 0.12656644f, 0.01525599f, -0.38585946f, -0.01346235f, -0.00301686f, -0.35469729f, 
    0.05687761f, -0.00992960f, -0.02197003f, -0.08178039f, 0.01587216f, -0.02139011f, -0.04703620f, 0.01840511f, 
    -0.17214048f, 0.23004553f, -0.17241260f, -0.24609695f, 0.16740517f, -0.11584040f, -0.12906921f, 0.00675658f, 
    -0.01735552f, -0.05300498f, 0.04952807f, 0.01745242f, -0.19978887f, 0.06163695f, -0.00909170f, 0.21088985f, 
    0.04107179f, -0.06698187f, 0.02206837f, 0.07498609f, 0.06468949f, -0.27500111f, 0.08535084f, 0.10063757f, 
    -0.42417508f, -0.34050569f, -0.18491676f, -0.21050659f, -0.04386568f, 0.00975717f, -0.02121361f, 0.05805082f, 
    -0.05762001f, 0.00698757f, -0.04426918f, -0.04670847f, -0.05602527f, -0.07604296f, -0.05095733f, -0.04090981f, 
    0.06736692f, 0.00613632f, 0.07531872f, -0.01022346f, 0.03305499f, -0.00768250f, 0.10524280f, 0.00517960f, 
    -0.01882971f, -0.13879950f, 0.11389934f, 0.08386715f, -0.02201203f, -0.00072308f, 0.03913554f, -0.07509623f, 
    0.07811953f, -0.05063291f, -0.12215152f, 0.19227068f, -0.12942943f, 0.21086580f, -0.01131764f, 0.02375720f, 
    -0.00526123f, 0.02677341f, -0.18912722f, 0.07658163f, -0.04941311f, 0.02132219f, 0.00790174f, 0.05048580f, 
    0.20133026f, -0.13001400f, 0.22679822f, -0.21947579f, -0.06941321f, 0.03112563f, -0.04157076f, 0.09180316f, 
    0.04836149f, -0.03860199f, 0.06671236f, -0.09128179f, -0.65898126f, 0.13109709f, 0.07610865f, -0.15436733f, 
    -0.02968865f, 0.00758842f, 0.04723627f, 0.12826064f, -0.04365918f, -0.05296243f, 0.03998228f, -0.00590355f, 
    -0.15676920f, -0.21609834f, -0.15925007f, -0.21618600f, 0.06329139f, 0.00709647f, 0.02811758f, -0.10700906f, 
    -0.00438064f, 0.01559726f, 0.06899467f, -0.06642020f, 0.32449141f, 0.47930405f, 0.23544252f, 0.36067328f, 
    -0.03301721f, -0.01983441f, 0.06779557f, -0.03573061f, -0.05966357f, -0.03055273f, -0.01674013f, 0.12809052f, 
    0.14179093f, -0.11533536f, 0.19899796f, 0.30279014f, 0.02343297f, 0.08213287f, -0.10476860f, 0.16935790f, 
    -0.01617650f, -0.04789283f, -0.05112430f, 0.00043263f, -0.29369757f, -0.01343390f, -0.28443030f, 0.27283552f, 
    0.04180849f, 0.11037155f, -0.08418038f, -0.05397670f, -0.02104082f, 0.05737942f, 0.11702279f, -0.06770529f, 
    -0.07701220f, 0.10644757f, 0.08111291f, 0.10166688f, -0.03605609f, -0.01558091f, 0.08680381f, -0.00676474f, 
    -0.07176857f, -0.05051516f, -0.03116561f, -0.03579688f, 0.03360013f, -0.06201454f, 0.01363660f, 0.23994344f, 
    0.02030902f, 0.09028671f, 0.00439188f, 0.06234170f, 0.02098985f, 0.04865799f, -0.00293607f, -0.00684176f, 
    -0.06631853f, -0.20086488f, 0.03356107f, -0.06664306f, -0.10507744f, -0.10015214f, 0.00106720f, 0.01159063f, 
    0.02584830f, -0.00794904f, -0.00634822f, 0.03034369f, -0.01217297f, -0.12930363f, -0.21543853f, 0.02225441f, 
    0.06581599f, 0.03568785f, -0.26961941f, 0.01955508f, 0.03980482f, -0.05188960f, 0.10784929f, 0.04475736f, 
    -0.14013229f, 0.06787457f, -0.23209949f, -0.11024655f, 0.05106987f, 0.00149503f, 0.04003255f, -0.06592047f, 
    0.00818368f, -0.01499671f, -0.21075597f, 0.09588214f, -0.01745749f, -0.12866183f, 0.09837753f, 0.12656572f, 
    0.03667281f, -0.01355852f, -0.03125004f, 0.09766182f, -0.09743048f, -0.05847771f, -0.20254160f, 0.01753552f, 
    -0.24711895f, -0.12241141f, 0.38453782f, -0.03823351f, -0.01740764f, 0.03749406f, 0.06337954f, 0.11409247f, 
    0.02486505f, -0.02395246f, 0.04890855f, 0.00940411f, -0.04728963f, 0.15721886f, -0.04477116f, 0.02499487f, 
    0.04991326f, 0.04963297f, 0.02190473f, -0.11168545f, 0.03327866f, -0.07272846f, 0.09941964f, -0.01674533f, 
    0.05786058f, 0.02308296f, -0.22256248f, -0.10431260f, -0.01703375f, -0.01513469f, 0.02455081f, -0.04786073f, 
    -0.03540895f, 0.00705182f, 0.10674253f, 0.02014806f, -0.05322511f, 0.15972239f, -0.31006527f, -0.19095935f, 
    0.03293768f, -0.02353379f, -0.02042779f, 0.03037568f, -0.05014157f, 0.03219772f, -0.07496834f, 0.00486400f, 
    -0.00223784f, 0.10279650f, -0.20113137f, -0.17019163f, -0.01766461f, -0.06442967f, 0.08334850f, 0.06469201f, 
    0.10013562f, -0.03181801f, -0.07084741f, 0.02038118f, -0.33850336f, -0.11133853f, -0.00650969f, 0.17913069f, 
    -0.02675051f, 0.02120049f, -0.07649591f, 0.00900959f, -0.07823604f, 0.03213160f, -0.05388310f, 0.01385481f, 
    -0.10794783f, 0.05513408f, 0.25487578f, 0.56125438f, -0.06031090f, -0.09584706f, -0.04139583f, 0.18643920f, 
    -0.01668743f, -0.00380094f, 0.03410207f, -0.04818631f, -0.09019110f, -0.16431101f, -0.06521021f, -0.31012979f, 
    0.03199223f, -0.01461093f, -0.01018329f, 0.00999813f, 0.00216413f, -0.06467306f, -0.06769256f, -0.02904418f, 
    -0.04492240f, 0.01537695f, -0.03878448f, -0.09576460f, -0.02704892f, 0.02502203f, -0.00569595f, -0.01053361f, 
    -0.00898610f, 0.00742254f, 0.14115052f, -0.15517503f, -0.24045523f, 0.35589138f, 0.10553685f, -0.07550088f, 
    -0.01729068f, 0.13544817f, -0.17912309f, 0.03187063f, 0.05951305f, 0.05696401f, -0.04273910f, 0.09576164f, 
    -0.15629527f, -0.21569958f, 0.05477911f, 0.12942733f, 0.04266047f, 0.04074864f, -0.11198816f, -0.06691565f, 
    -0.03225083f, -0.13360593f, -0.08494803f, -0.06380562f, -0.06525989f, -0.02272305f, 0.03490466f, -0.00209196f, 
    -0.12556428f, -0.14834113f, -0.01496592f, 0.04582440f, -0.02438729f, 0.03718974f, 0.03172280f, -0.00081629f, 
    0.12098325f, 0.16289362f, -0.38518167f, 0.12561791f, 0.03742700f, -0.10797165f, 0.10003492f, 0.06479672f, 
    -0.02418043f, 0.06100924f, 0.00983918f, 0.07261164f, -0.08555005f, -0.05230285f, 0.05265846f, -0.08986989f, 
    0.07081563f, 0.00999476f, -0.04471241f, -0.03091525f, -0.05298889f, 0.02686162f, 0.03917195f, -0.07304478f, 
    -0.13468120f, -0.04648599f, -0.10362213f, -0.19643241f, -0.07178597f, -0.05770906f, -0.00801317f, 0.02937534f, 
    -0.01907185f, -0.12742800f, -0.05357398f, 0.04741093f, -0.25775447f, 0.30900338f, 0.04548206f, 0.02548510f, 
    -0.02133613f, -0.04943245f, 0.09726266f, -0.03847205f, -0.08010422f, 0.08185887f, -0.00803292f, 0.04557742f, 
    -0.13614604f, 0.24276231f, 0.13418755f, -0.00831917f, -0.01416414f, -0.00064287f, -0.03102924f, -0.11339358f, 
    0.11859620f, 0.10524318f, 0.19203635f, 0.07375770f, -0.03597447f, -0.01192800f, 0.28699109f, 0.15254210f, 
    -0.02064538f, -0.03206223f, 0.04797242f, 0.08329222f, 0.04534894f, 0.03701902f, -0.06313471f, -0.04095910f, 
    0.00269924f, -0.02669566f, 0.10013565f, 0.11418713f, 0.06288460f, -0.03287435f, 0.01907821f, 0.07599844f, 
    0.07799736f, 0.00315544f, 0.06548271f, -0.14047210f, 0.20151080f, -0.01596195f, -0.05599466f, 0.01212973f, 
    -0.03541244f, -0.07233267f, -0.02114685f, -0.01313263f, -0.06922979f, -0.09482984f, 0.00395944f, -0.03637614f, 
    0.30907321f, -0.06599884f, 0.06286355f, 0.19846280f, -0.05911739f, -0.07147945f, 0.01355809f, -0.01264077f, 
    0.05947458f, 0.01889900f, -0.03987035f, 0.05598861f, -0.03558468f, -0.19787893f, -0.08078979f, 0.19190380f, 
    0.06078943f, 0.16391653f, 0.13159284f, -0.01048647f, 0.04679944f, -0.01739441f, 0.03427533f, 0.00557947f, 
    0.09172107f, -0.04632681f, -0.09661981f, 0.06246978f, 0.00578011f, -0.07736694f, 0.02963984f, 0.00879034f, 
    -0.00223410f, 0.04019541f, -0.19541748f, -0.00467673f, -0.14883712f, -0.11996156f, -0.07089799f, 0.19899663f, 
    -0.00097004f, -0.07130165f, -0.01572804f, 0.04623429f, 0.02521821f, 0.06063918f, -0.05363160f, -0.12688839f, 
    -0.08115917f, -0.02876904f, 0.33364317f, -0.14186530f, -0.22227916f, 0.11523631f, 0.12447815f, 0.00876704f, 
    0.11494780f, 0.03568998f, 0.13875639f, 0.13397905f, -0.58895624f, -0.05277226f, 0.00217279f, 0.15271786f, 
    0.11367550f, -0.07802073f, 0.06510821f, -0.07862701f, 0.00567711f, -0.13678686f, 0.07887913f, 0.01386241f, 
    -0.17973061f, 0.27877027f, 0.14621553f, 0.24040550f, -0.01747878f, -0.09273826f, 0.07219212f, 0.02495196f, 
    0.03080842f, 0.12089482f, -0.05436807f, -0.04213788f, 0.19337207f, 0.17102155f, 0.17986511f, 0.07611087f, 
    -0.19281070f, 0.07126357f, -0.16571024f, 0.04853672f, -0.02899856f, -0.01806474f, 0.21723709f, -0.05119416f, 
    -0.12222375f, 0.00782903f, -0.16260974f, 0.16723301f, 0.05819075f, 0.06845140f, 0.17448325f, -0.05816833f, 
    -0.10060880f, 0.07285372f, -0.05004283f, -0.01397850f, 0.21996982f, 0.12226533f, -0.14932597f, -0.69920635f, 
    0.04389080f, 0.08928740f, 0.02906999f, -0.02869285f, -0.04399799f, 0.18197528f, -0.17687215f, -0.02939832f, 
    -0.31625801f, 0.38851282f, -0.16611145f, 0.39310643f, -0.00514508f, -0.04646491f, -0.14881732f, -0.21369629f, 
    -0.06407338f, -0.10599909f, 0.06455393f, -0.01562198f, -0.03945845f, 0.25631085f, -0.39337966f, -0.45355657f, 
    -0.00058523f, 0.03121256f, -0.04435734f, 0.04650981f, -0.08469756f, -0.11154120f, 0.04238032f, -0.00217310f, 
    0.30259493f, 0.43422744f, -0.10267255f, -0.20840085f, -0.14002481f, -0.08618938f, -0.08574627f, -0.11386257f, 
    -0.35395044f, -0.26291180f, -0.02505688f, 0.04808825f, 0.03337406f, -0.19470894f, 0.02794558f, 0.27381662f, 
    0.04410563f, -0.09102086f, 0.04504562f, -0.07970238f, 0.14149000f, 0.04184734f, 0.00441884f, 0.16723184f, 
    -0.70907414f, 0.68068641f, -0.08163196f, -0.51495761f, 0.14355788f, -0.03974630f, -0.07230031f, -0.01745748f, 
    -0.19146262f, -0.05835782f, 0.02111153f, -0.23166908f, -0.19172940f, -0.14317361f, -0.05639776f, 0.21078029f, 
    0.00536827f, 0.01075573f, -0.07698110f, -0.01110928f, -0.04202752f, 0.00479926f, -0.14308503f, 0.08541068f, 
    -0.09461442f, -0.10964127f, -0.00682419f, 0.03062857f, -0.03850536f, -0.03973860f, -0.08452410f, -0.03344110f, 
    -0.02019561f, -0.01317307f, 0.03497726f, 0.07145316f, 0.21256469f, 0.66819155f, -0.10048833f, 0.04326427f, 
    0.16998021f, 0.02109892f, 0.10073485f, 0.02310575f, -0.23425652f, 0.04010786f, -0.10914941f, -0.03886215f, 
    -0.05972128f, 0.13512504f, -0.09911670f, 0.09925461f, -0.14915645f, -0.05570096f, -0.15388428f, 0.00882983f, 
    0.16324124f, -0.20212421f, -0.15461844f, 0.01380018f, 0.05258471f, 0.04061004f, 0.00214668f, 0.04819954f, 
    0.00890057f, 0.04922282f, -0.04611372f, -0.12987536f, 0.01338411f, -0.00363471f, -0.15183267f, 0.07986486f, 
    0.14244837f, 0.02062558f, -0.30625039f, 0.17829239f, 0.05059621f, 0.01719108f, 0.07690007f, 0.10349817f, 
    0.00162624f, 0.00073866f, -0.04334836f, 0.06412680f, -0.01748555f, 0.01022951f, -0.12424608f, 0.06985693f, 
    0.05723702f, 0.02070589f, 0.02104474f, 0.01739476f, -0.03463845f, 0.02607645f, -0.08187863f, 0.03304057f, 
    -0.52332145f, -0.01803935f, -0.09171518f, 0.17354617f, -0.10752339f, -0.01945714f, -0.29029503f, -0.15392083f, 
    0.09216525f, 0.02163982f, 0.10054602f, -0.09734031f, 0.24509238f, 0.17233796f, -0.15561347f, -0.04062391f, 
    0.04443565f, -0.03248440f, 0.01600454f, 0.06506702f, -0.01628293f, 0.16327824f, 0.03716383f, -0.01267952f, 
    -0.00462348f, -0.07428303f, -0.18012077f, 0.08808538f, 0.03589777f, 0.03745269f, 0.00335921f, -0.01421494f, 
    -0.07092226f, 0.07217319f, 0.01290108f, 0.07265859f, -0.02405337f, 0.00414779f, 0.11929830f, 0.14693651f, 
    -0.00222791f, 0.02329338f, 0.05236797f, -0.04392765f, -0.05457122f, 0.05817811f, -0.00426566f, -0.01631521f, 
    0.16206056f, 0.10484248f, 0.17763340f, 0.09141206f, 0.03400927f, -0.03122259f, 0.02668473f, 0.01527049f, 
    -0.05216451f, 0.02017662f, 0.08276306f, 0.07440159f, 0.26310050f, -0.14113466f, 0.05794865f, -0.13708387f, 
    0.13611601f, 0.14455561f, 0.00238463f, 0.00665131f, 0.10393852f, 0.02896599f, 0.07283375f, 0.02934907f, 
    -0.45744553f, -0.42402795f, -0.13137226f, -0.07124209f, 0.09520315f, -0.05524157f, -0.10505868f, -0.02615016f, 
    -0.10709424f, -0.01490760f, -0.16722560f, -0.04406988f, 0.18485963f, -0.05781258f, 0.14828232f, -0.02756026f, 
    -0.16869980f, -0.24119306f, -0.04781412f, 0.02857970f, -0.06788705f, 0.22401729f, -0.08163806f, 0.08148681f, 
    -0.30289850f, 0.10978980f, -0.13419032f, -0.25439212f, -0.12317676f, 0.04160401f, -0.31682634f, 0.00835572f, 
    -0.14876898f, -0.11504712f, 0.07092547f, -0.03223701f, -0.08543742f, -0.14790270f, -0.09469359f, 0.22440127f, 
    0.10725848f, 0.01851802f, -0.23517194f, 0.15001422f, -0.02924078f, -0.13699371f, 0.01694705f, -0.09764882f, 
    0.06557219f, 0.00965352f, -0.03930893f, -0.30618256f, -0.19176707f, 0.07790771f, -0.18383373f, -0.05449262f, 
    0.07918788f, -0.06586376f, -0.05849960f, 0.13128313f, -0.20375563f, -0.05058903f, 0.27721539f, 0.34476644f, 
    0.00084181f, -0.15318775f, 0.08618956f, -0.19090275f, 0.07614517f, 0.02416051f, 0.01099688f, 0.07547198f, 
    0.02400218f, 0.00667856f, -0.03738253f, 0.26166052f, 0.05438100f, 0.01661371f, 0.16286758f, -0.00008303f, 
    -0.01840197f, -0.01979227f, -0.01943246f, 0.07232933f, 0.33819667f, -0.18462367f, 0.08992597f, 0.08534810f, 
    0.18982676f, 0.07623487f, 0.00651608f, -0.05180281f, -0.02953086f, 0.01707167f, 0.01949982f, 0.03613279f, 
    0.08216044f, 0.04526405f, 0.13925749f, 0.11331189f, 0.01397480f, -0.03134180f, -0.20307437f, 0.10846385f, 
    -0.05262841f, 0.09883472f, 0.02722881f, 0.04422028f, 0.25974357f, 0.10947313f, -0.02474947f, -0.23000289f, 
    -0.06027029f, -0.22299057f, -0.06311318f, -0.01211230f, -0.01289390f, 0.24103259f, -0.00165962f, -0.14104001f, 
    -0.09155587f, 0.13277914f, 0.00882566f, 0.08677485f, 0.09832232f, 0.01274897f, 0.10589300f, -0.15164943f, 
    -0.05239069f, -0.03249693f, 0.03180153f, -0.02101210f, 0.10964767f, 0.04302279f, -0.36659944f, -0.01966152f, 
    -0.10789517f, -0.03680014f, -0.08381067f, -0.07468657f, 0.05805601f, -0.11777983f, 0.19686507f, 0.14360443f, 
    -0.07285568f, -0.15708470f, 0.15916690f, 0.13198599f, -0.18842174f, -0.02392551f, 0.03894110f, -0.01996069f, 
    -0.15433390f, 0.09077929f, -0.10658084f, 0.00372573f, 0.23403597f, 0.10384581f, -0.03709468f, 0.05704941f, 
    -0.01373728f, -0.02792607f, -0.04853415f, -0.08843327f, 0.06180733f, 0.06346106f, -0.02071989f, -0.14296748f, 
    -0.10679898f, 0.04597162f, 0.01360541f, 0.37563244f, 0.00080259f, -0.02357051f, 0.04455634f, 0.09990986f, 
    -0.07841022f, 0.07237232f, 0.05411351f, 0.07227908f, -0.29389191f, 0.35809925f, -0.18238816f, -0.56362677f, 
    0.19645640f, 0.00410529f, -0.06431569f, 0.19354437f, -0.08213739f, 0.16204563f, -0.10785558f, -0.04643648f, 
    0.03443544f, -0.33932012f, 0.25777751f, -0.41928089f, -0.18764494f, -0.03007088f, -0.07428081f, -0.04051568f, 
    0.05252745f, 0.01815586f, 0.02592444f, -0.18201692f, 0.11867524f, -0.04922042f, -0.13956164f, -0.06259268f, 
    -0.16275965f, -0.00366206f, -0.25675249f, -0.03217451f, 0.03172497f, 0.02032129f, 0.01617301f, -0.09994671f, 
    0.26047266f, 0.31629878f, 0.12353205f, 0.06172558f, -0.05304119f, -0.04647549f, -0.04694121f, 0.01096159f, 
    0.08210682f, -0.15942247f, 0.17191073f, -0.00281922f, -0.64459836f, 0.00833424f, 0.12728001f, -0.26731658f, 
    -0.00790640f, -0.26396173f, -0.14888275f, -0.05315559f, -0.32324550f, -0.13922359f, -0.18510863f, -0.14569199f, 
    -0.30863518f, 0.62905198f, -0.25389731f, 0.19086792f, -0.01613172f, 0.15321362f, -0.00795292f, -0.14640015f, 
    0.02266139f, 0.01235885f, 0.11711218f, -0.04247781f, 0.12847066f, -0.13662145f, -0.06260382f, -0.01894982f, 
    0.06095938f, 0.01280826f, 0.01196166f, 0.01032917f, -0.04298693f, 0.02484860f, -0.02884124f, -0.10202178f, 
    0.21115652f, -0.07069662f, -0.13970330f, 0.08904702f, 0.05015321f, -0.04124661f, -0.05550838f, -0.12003890f, 
    0.04909393f, 0.04695977f, 0.03650317f, 0.06132201f, 0.12120822f, 0.13571124f, 0.02681301f, 0.21782035f, 
    0.06825200f, -0.08680814f, 0.05320629f, -0.14529322f, 0.03031494f, 0.10258652f, 0.01511425f, 0.08622058f, 
    -0.23443460f, 0.45386571f, -0.20304447f, 0.19748698f, 0.13136886f, -0.20889558f, 0.03396061f, -0.09708492f, 
    0.04160651f, 0.14546381f, 0.03893700f, -0.01360766f, -0.48731047f, 0.05543055f, 0.05161409f, 0.38504338f, 
    -0.04215315f, -0.04236063f, -0.09378194f, -0.00517340f, -0.03639855f, 0.00275355f, 0.08315927f, 0.02799052f, 
    -0.25006235f, 0.03419086f, -0.02913771f, 0.14287546f, 0.05654556f, 0.04949904f, 0.11001604f, -0.13055801f, 
    -0.08646387f, 0.00401290f, -0.02507086f, 0.12615693f, -0.18255827f, -0.01624018f, -0.06367908f, 0.33140513f, 
    -0.00200451f, -0.06156011f, 0.18414763f, -0.00938665f, -0.13124162f, -0.16575363f, -0.12114067f, 0.11999685f, 
    -0.14715040f, 0.55334729f, -0.37617293f, -0.11664087f, -0.05915520f, 0.05855801f, -0.03150687f, -0.01410273f, 
    -0.08014514f, -0.04416690f, 0.10455485f, 0.02791891f, 0.20955047f, -0.08731844f, 0.04683764f, 0.15940215f, 
    -0.16772543f, 0.08970397f, 0.17674351f, -0.06154080f, 0.10970766f, -0.05163617f, -0.06624208f, 0.05634000f, 
    -0.03847232f, 0.09329420f, 0.36105454f, 0.03171711f, -0.12110137f, -0.10966732f, -0.19292547f, -0.00197319f, 
    -0.05277753f, -0.03478520f, -0.05477491f, 0.07107308f, -0.41355643f, -0.00211270f, -0.00627421f, -0.06722802f, 
    -0.02015050f, -0.11489119f, 0.04184012f, -0.10184537f, -0.08583982f, 0.16767429f, 0.00330125f, -0.13220058f, 
    -0.52264273f, 0.11362077f, -0.00914304f, 0.07529105f, 0.04734661f, 0.04905457f, 0.14137925f, -0.07119007f, 
    0.09271862f, 0.06567518f, 0.05442300f, 0.02203038f, -0.51599699f, 0.81991309f, -0.39919978f, -0.50869328f, 
    0.13894418f, 0.15518218f, -0.06614570f, 0.02384866f, -0.41718596f, -0.04810935f, -0.05358722f, -0.07083496f, 
    0.00980100f, 0.03061409f, -0.13624258f, -0.17163087f, 0.13534065f, 0.12807880f, -0.10751891f, -0.02488502f, 
    -0.05389352f, -0.11394425f, -0.00455044f, -0.00401186f, -0.26386258f, -0.02021770f, 0.01291112f, 0.13757844f, 
    0.14995749f, -0.05402045f, -0.04024197f, 0.10920870f, -0.05575952f, 0.12912685f, -0.04793058f, -0.15407443f, 
    -0.06718361f, 0.12162589f, 0.15983979f, 0.14336348f, 0.01354280f, -0.02500120f, -0.00853732f, -0.18859851f, 
    -0.02158298f, 0.00016328f, -0.03728816f, 0.06127456f, 0.09777153f, 0.15492687f, 0.25254416f, 0.19458462f, 
    -0.11988438f, -0.03578342f, -0.02472320f, 0.03809984f, 0.06620860f, 0.04702574f, 0.00957654f, 0.03370588f, 
    0.00668922f, 0.20801021f, 0.27486974f, 0.08161011f, -0.07313146f, -0.01541678f, -0.01617919f, -0.06403662f, 
    -0.01644309f, -0.02455714f, -0.00078433f, -0.08320217f, -0.03386910f, 0.06138156f, 0.01465097f, 0.01721370f, 
    -0.06497383f, -0.00520354f, 0.04631095f, 0.11927515f, 0.01612712f, -0.02803538f, 0.00634959f, -0.02184547f, 
    0.23249038f, 0.06889909f, -0.01859061f, 0.27976206f, 0.04717171f, 0.02105527f, -0.21024740f, -0.12081016f, 
    0.12889406f, -0.01175868f, 0.03615102f, 0.03123913f, -0.07336073f, 0.07138722f, 0.01695291f, 0.09263913f, 
    -0.15515989f, -0.07520125f, -0.07359419f, 0.03856836f, -0.17359869f, -0.09015994f, -0.02729232f, 0.01761807f, 
    -0.26266748f, 0.26690552f, -0.28740770f, -0.53694052f, 0.08835114f, 0.04538453f, 0.01910531f, 0.09136480f, 
    0.04913674f, 0.00668283f, -0.04809630f, -0.08650261f, 0.06117379f, -0.02154896f, -0.18093470f, -0.13613228f, 
    0.00455849f, -0.12627499f, -0.08637968f, -0.04983994f, 0.04756263f, -0.09065399f, -0.10408363f, -0.12418421f, 
    0.29357442f, 0.07928359f, 0.24049616f, 0.09377383f, 0.02333533f, -0.12861744f, -0.21848971f, 0.03745116f, 
    0.04504491f, -0.06491143f, -0.07121992f, 0.05717515f, 0.08010875f, -0.16357735f, -0.21366772f, 0.03314405f, 
    -0.02340669f, -0.02871070f, 0.01915752f, -0.00211534f, 0.00221684f, -0.01995157f, 0.03357967f, 0.11421025f, 
    -0.03691708f, -0.20150928f, 0.19971867f, 0.01654975f, 0.04622296f, 0.16729295f, -0.13863680f, 0.01336890f, 
    -0.06709332f, -0.02216033f, -0.02419499f, 0.03344276f, -0.15904245f, -0.38632989f, 0.19521771f, -0.05459495f, 
    -0.22442839f, 0.04176778f, -0.01378166f, -0.02468036f, -0.10897256f, -0.08014160f, -0.08388888f, 0.04319391f, 
    -0.04784556f, -0.25146070f, -0.16324803f, 0.23922999f, 0.00218786f, 0.09045111f, 0.01922685f, 0.01264342f, 
    -0.03629296f, 0.03719150f, -0.10838066f, -0.16323797f, -0.17429052f, 0.01997050f, 0.09453340f, 0.13526055f, 
    0.00639643f, -0.13487467f, -0.05218598f, -0.00622412f, -0.01173731f, 0.00139410f, 0.03962392f, 0.05375360f, 
    0.16376209f, -0.33052328f, -0.19284862f, -0.00988263f, -0.10485592f, 0.02127736f, -0.01172862f, 0.03258945f, 
    -0.25788343f, 0.08617616f, -0.14876030f, -0.19886042f, 0.02944151f, -0.05416619f, 0.07712244f, 0.06744297f, 
    -0.01152376f, 0.05100879f, 0.00541594f, -0.06945924f, 0.04283685f, -0.17195171f, 0.01970533f, -0.04902320f, 
    -0.00328572f, -0.01113352f, -0.01788178f, 0.09315617f, 0.01126316f, 0.03194606f, 0.02731032f, -0.09944906f, 
    -0.06768107f, 0.23515350f, 0.00318175f, 0.13231942f, -0.37706164f, -0.46414259f, -0.01749618f, -0.27586213f, 
    0.00778958f, 0.09113656f, -0.14927457f, 0.07126166f, 0.05871781f, -0.00888769f, 0.06056884f, 0.06784640f, 
    0.02967279f, -0.02986487f, 0.07446899f, 0.01722481f, -0.21350817f, -0.08773315f, -0.03346314f, 0.24701139f, 
    -0.16794682f, -0.04626175f, -0.02030283f, -0.11684015f, 0.14138801f, 0.09092572f, 0.01492796f, 0.12195611f, 
    -0.02390872f, -0.02513227f, 0.00794750f, -0.01340390f, 0.03839030f, 0.09588839f, 0.17070758f, 0.52837300f, 
    0.17040908f, 0.06563613f, 0.39519331f, 0.03521626f, 0.03022772f, -0.12128334f, -0.17255059f, 0.04141788f, 
    -0.10647909f, 0.00847020f, 0.06216497f, 0.01109097f, 0.04757150f, -0.00851630f, 0.12546478f, 0.07873713f, 
    -0.08229219f, -0.13933198f, -0.08041158f, -0.09264544f, 0.07769112f, -0.01571113f, -0.07706525f, 0.08776709f, 
    -0.07910367f, 0.00616249f, -0.04868002f, 0.06102522f, 0.02878397f, 0.00239402f, -0.05072200f, -0.01084163f, 
    -0.04620465f, -0.10788408f, -0.12267713f, -0.15084438f, -0.09750646f, -0.06405267f, -0.09397768f, -0.11585900f, 
    0.06316972f, 0.05987526f, 0.02713973f, 0.03496753f, 0.08749112f, 0.14868023f, 0.15319784f, 0.29943097f, 
    0.08860312f, 0.11012342f, 0.21242379f, 0.17647815f, -0.09290497f, -0.01697780f, -0.00185473f, 0.10730579f, 
    0.06215461f, 0.08629656f, 0.11917800f, 0.11126420f, -0.02035589f, 0.09985177f, 0.25062075f, 0.13807461f, 
    0.14806332f, -0.01497318f, -0.01364439f, 0.03536263f, -0.03238697f, -0.09597108f, 0.03257781f, -0.08014195f, 
    0.08235210f, -0.00315698f, -0.04841658f, 0.14841360f, 0.01692696f, -0.12356503f, -0.06772079f, -0.17300865f, 
    0.00002418f, -0.03218684f, -0.04256248f, -0.03736546f, 0.08711983f, 0.07540785f, -0.09357481f, -0.07780861f, 
    -0.07868268f, 0.00836288f, -0.05913463f, -0.01456034f, 0.05646640f, -0.11326747f, -0.28791040f, -0.02824462f, 
    0.05571687f, 0.06616815f, 0.02555758f, 0.00955670f, 0.09055214f, 0.04222000f, 0.07180745f, 0.03843543f, 
    0.04780350f, 0.01875289f, 0.07028262f, 0.03063754f, 0.17184910f, 0.14616515f, -0.07214816f, 0.04250132f, 
    -0.07143358f, 0.07632630f, -0.06373248f, -0.05923164f, 0.01169150f, -0.15301433f, 0.00926735f, -0.03192618f, 
    -0.01796053f, -0.09772995f, -0.06992962f, 0.01707739f, 0.04231976f, 0.12883380f, 0.12127817f, -0.16171214f, 
    0.07020319f, 0.03316464f, 0.07057258f, 0.02127176f, -0.13403314f, 0.13822983f, -0.00785042f, -0.03971535f, 
    -0.29702404f, -0.20212235f, -0.20736773f, -0.01943215f, -0.09190106f, 0.06288168f, 0.05801369f, -0.10757855f, 
    0.13009383f, -0.11674955f, -0.29651383f, -0.16236648f, 0.05111734f, -0.04372591f, 0.10981796f, 0.00222541f, 
    -0.01386581f, -0.02660951f, -0.03802868f, -0.14009549f, 0.21156441f, 0.10970756f, 0.37047565f, 0.21970686f, 
    -0.05966679f, 0.01965521f, 0.04161467f, 0.23374549f, 0.00487563f, 0.00517837f, -0.01425021f, -0.05808241f, 
    0.03439966f, 0.07194664f, 0.15109389f, 0.20163649f, -0.01357902f, 0.07105339f, -0.03515375f, -0.02294649f, 
    0.03846429f, 0.01541948f, 0.00107792f, -0.01071970f, -0.00396921f, 0.16405311f, 0.07828044f, 0.16319999f, 
    -0.03341194f, -0.08016950f, 0.01010581f, 0.03968006f, 0.04050335f, -0.09162254f, -0.03476280f, 0.06581752f, 
    0.12322216f, 0.20656875f, -0.09236807f, 0.14346337f, -0.04132152f, -0.11160707f, -0.01857722f, -0.27377290f, 
    0.03428161f, -0.04445044f, 0.04922494f, -0.02145909f, -0.31110552f, -0.09767759f, 0.20007649f, -0.21070819f, 
    0.04973709f, -0.05508413f, -0.08515245f, 0.03869340f, -0.11070929f, -0.21890378f, -0.10099553f, -0.12863491f, 
    0.01074674f, 0.00197230f, 0.08478934f, -0.10565569f, -0.00272399f, 0.06096587f, 0.02103001f, 0.04611966f, 
    0.07005477f, -0.19902010f, -0.17517667f, 0.07481606f, -0.13892202f, -0.08737897f, 0.10486948f, 0.03549279f, 
    -0.16659594f, -0.00203148f, -0.23718476f, 0.04959524f, -0.03741229f, 0.01063421f, -0.05166333f, -0.05676347f, 
    0.08086567f, 0.11023215f, -0.11957885f, 0.11165302f, 0.06949355f, 0.10997877f, -0.10418414f, 0.06238200f, 
    0.00741252f, -0.07583694f, 0.00244088f, -0.12467626f, -0.15215246f, 0.10313405f, -0.05322864f, 0.07075491f, 
    -0.05718089f, 0.11052344f, 0.04042571f, -0.01636354f, -0.04742971f, -0.10693324f, -0.02568759f, -0.03101408f, 
    0.15342042f, 0.09991076f, 0.17453383f, 0.09206926f, -0.00804236f, 0.00357013f, -0.17712632f, -0.17306982f, 
    0.16007380f, -0.07199040f, -0.00432680f, -0.13578887f, 0.24498321f, -0.13434891f, -0.01132522f, -0.04341837f, 
    0.00738531f, -0.04189287f, 0.05554393f, -0.11252823f, -0.00405402f, -0.02055742f, 0.00783345f, -0.17211226f, 
    0.23730002f, -0.08117011f, -0.17946258f, 0.04375672f, 0.00960203f, 0.04992660f, 0.10107365f, -0.05440424f, 
    0.11976596f, -0.07133395f, 0.05091783f, -0.00324094f, -0.13043399f, -0.11138693f, 0.01160558f, -0.21992463f, 
    -0.08836835f, -0.04294352f, 0.00628740f, 0.23169924f, 0.06722865f, -0.08765153f, 0.08625212f, -0.22334287f, 
    0.04794398f, -0.16902296f, 0.11904916f, 0.11919924f, 0.11004552f, -0.04326061f, 0.05280817f, -0.12139618f, 
    -0.09562865f, -0.00203450f, -0.05290697f, 0.13417329f, 0.08159231f, -0.17834964f, 0.04588744f, 0.04282033f, 
    0.03548244f, 0.06553052f, 0.01306254f, -0.00739169f, -0.05379584f, -0.01512079f, -0.05790878f, -0.02864988f, 
    -0.02843738f, -0.04680062f, 0.20428182f, 0.05804856f, 0.18340997f, 0.04596326f, -0.08956084f, -0.01476795f, 
    0.02672791f, -0.10210168f, -0.10486963f, -0.03625478f, -0.13713452f, -0.10940749f, -0.08064733f, 0.06306084f, 
    0.02018684f, 0.02966307f, 0.01085018f, -0.04613071f, -0.00579925f, -0.03019205f, 0.00921161f, -0.01314088f, 
    -0.23650074f, -0.05852526f, -0.00832208f, -0.03907050f, -0.16210157f, 0.03553648f, -0.14452118f, -0.01509710f, 
    -0.02040718f, 0.00967210f, 0.01432706f, -0.02267888f, 0.09298287f, 0.08499546f, -0.12379871f, 0.09958506f, 
    0.13022584f, 0.06261137f, -0.00303940f, 0.00499452f, -0.05036227f, -0.02493325f, -0.07504091f, -0.11097015f, 
    -0.02031663f, -0.04034055f, -0.01189001f, -0.07655080f, 0.02327845f, 0.03093810f, 0.05253611f, 0.03391019f, 
    -0.10036021f, -0.03102848f, 0.03140329f, -0.01587685f, 0.00532509f, -0.09772430f, 0.02795799f, 0.01130618f, 
    0.03431237f, -0.09184672f, 0.09845641f, -0.11305340f, -0.02686351f, 0.10573284f, -0.02060833f, 0.03633347f, 
    0.19888277f, -0.02541550f, -0.10556953f, 0.14314981f, 0.06537145f, 0.02373414f, -0.01423838f, 0.07896783f, 
    -0.11551318f, -0.11585880f, -0.02884942f, -0.07109903f, 0.11550224f, 0.03287445f, 0.07625341f, 0.04803971f, 
    -0.05688715f, -0.08742896f, -0.03468859f, 0.06993549f, -0.02804394f, -0.03595174f, -0.05292340f, -0.05024620f, 
    -0.11745688f, -0.56335896f, -0.06812441f, -0.20649719f, 0.00024761f, 0.05442663f, -0.02591433f, -0.02291711f, 
    0.00716850f, -0.02539633f, -0.01681327f, -0.09335082f, 0.05278664f, 0.13967010f, 0.08692032f, 0.26309222f, 
    0.12513241f, 0.17258522f, -0.23232788f, 0.16832706f, 0.01823480f, 0.01545553f, -0.07851776f, 0.00680575f, 
    0.10507918f, -0.40421683f, -0.11989303f, 0.00498670f, 0.01043140f, -0.03149705f, -0.01353863f, -0.04252036f, 
    0.05342105f, 0.00292120f, 0.01151882f, 0.06340598f, -0.04137053f, -0.23443186f, 0.02718698f, -0.06304780f, 
    -0.11598004f, 0.00970307f, -0.09082594f, 0.04961543f, -0.08506690f, 0.01758978f, -0.11284400f, -0.02955397f, 
    -0.02724265f, -0.11632905f, -0.09548426f, -0.05738814f, 0.03648860f, -0.01790695f, -0.04461776f, -0.01773329f, 
    -0.05368907f, 0.02661747f, -0.00695365f, 0.21184254f, 0.11737929f, -0.77849728f, 0.23368716f, -0.07238137f, 
    -0.13490230f, 0.00134391f, 0.01154934f, -0.10658529f, -0.00895157f, 0.11325527f, -0.05705608f, 0.02651827f, 
    0.05576328f, 0.03199945f, 0.06770795f, 0.01265021f, -0.06953508f, -0.02000807f, -0.03066028f, 0.02162348f, 
    0.11995371f, 0.03933055f, -0.20497948f, 0.09082307f, 0.15740368f, 0.02076478f, -0.08597605f, -0.00482091f, 
    0.04892997f, -0.03669035f, -0.16776071f, -0.01511344f, -0.19576468f, -0.00077727f, -0.00681230f, 0.00415541f, 
    -0.07439786f, -0.06379005f, -0.02090905f, -0.04936962f, -0.09799242f, 0.06360029f, 0.05271177f, -0.10811247f, 
    0.07133115f, 0.08872128f, 0.04611951f, -0.03829272f, 0.07467179f, 0.08343774f, 0.02151915f, -0.09122668f, 
    0.17764686f, 0.07348515f, 0.04039038f, -0.05697414f, -0.05688262f, 0.01884799f, 0.01264490f, 0.02172135f, 
    0.13385724f, 0.07083885f, 0.14450979f, -0.06963215f, 0.34709376f, 0.17482387f, 0.01656780f, 0.21344264f, 
    0.03911950f, 0.02541362f, 0.08375628f, 0.04260097f, 0.19143930f, 0.20060670f, -0.04921828f, 0.06294352f, 
    0.08495046f, 0.09828181f, -0.15281670f, 0.01847849f, 0.00374078f, 0.04472542f, -0.00333573f, 0.13107318f, 
    -0.07453845f, -0.12216793f, -0.04920161f, 0.11020628f, -0.02135367f, -0.05443720f, -0.06499294f, 0.16346100f, 
    -0.04092587f, 0.00717632f, -0.08993234f, -0.11876930f, -0.04375328f, -0.51964366f, 0.00145736f, -0.19274825f, 
    0.05027317f, 0.07186918f, -0.10357878f, 0.02593107f, 0.08822256f, 0.11161587f, 0.00796047f, 0.00325322f, 
    -0.03414209f, -0.45127964f, -0.13603579f, 0.18585210f, 0.13915855f, -0.08554152f, -0.10287400f, 0.05596799f, 
    0.08298800f, 0.00297211f, 0.02318509f, 0.03344870f, -0.23221791f, 0.19622940f, -0.33867121f, 0.14620852f, 
    0.27285630f, 0.08898208f, -0.02671884f, -0.03309784f, 0.07666209f, 0.07231899f, -0.05354641f, 0.20369920f, 
    0.04424235f, 0.26157334f, 0.13876987f, -0.27735561f, 0.03597938f, 0.08726262f, 0.07724148f, -0.09727885f, 
    -0.02591539f, 0.06001354f, -0.02153907f, -0.00137327f, -0.30997741f, 0.12027337f, 0.09975119f, 0.12704016f, 
    0.00436440f, -0.09297109f, -0.02916347f, 0.06333198f, 0.10714366f, -0.09872858f, 0.13897480f, -0.17389210f, 
    0.13583301f, 0.42212892f, -0.14538753f, -0.42105404f, -0.04748113f, -0.07623474f, 0.01307211f, -0.01885335f, 
    0.10741338f, 0.09763373f, -0.14745048f, -0.10466409f, -0.06504934f, 0.03236267f, 0.31786108f, 0.13759789f, 
    0.03660832f, -0.08149192f, -0.02847624f, 0.01939972f, 0.07334663f, -0.01987993f, -0.11555191f, -0.04477856f, 
    -0.06553251f, 0.06290594f, 0.05122319f, 0.10752583f, 0.13185485f, -0.04630218f, -0.10193512f, 0.01915612f, 
    0.10980958f, -0.12049992f, 0.07679558f, 0.21220928f, -0.10560032f, 0.06012887f, -0.19885838f, -0.39739668f, 
    0.06683625f, 0.04973820f, -0.00431452f, 0.10214840f, -0.01219646f, -0.05659914f, -0.01802035f, -0.03215523f, 
    0.08685639f, -0.24276707f, 0.31921074f, 0.02640087f, 0.07870699f, -0.05903183f, 0.01943823f, -0.04111835f, 
    -0.05086998f, -0.04010152f, -0.11567058f, 0.16124427f, 0.10993505f, -0.08942474f, -0.02328318f, 0.01355611f, 
    0.00959492f, -0.07196167f, 0.00917546f, 0.22881866f, -0.14751473f, -0.00061655f, -0.05258604f, 0.00708580f, 
    0.14716430f, -0.18605648f, 0.06781902f, 0.02155504f, -0.06099125f, -0.05525456f, -0.01116613f, 0.13545239f, 
    0.05036468f, -0.09912031f, -0.05520232f, -0.26522163f, -0.32768711f, 0.32816705f, -0.20520456f, -0.33176851f, 
    -0.04873938f, -0.00486919f, -0.08589246f, 0.00049217f, -0.09962401f, -0.13254973f, 0.03868621f, -0.03685863f, 
    -0.00173616f, -0.12840465f, 0.01112301f, 0.07522811f, 0.30348298f, -0.16849342f, -0.19318996f, 0.05963209f, 
    -0.22716592f, 0.03217791f, -0.02443855f, 0.21509263f, -0.02974510f, -0.15809433f, 0.13934331f, 0.04417861f, 
    0.05970108f, 0.06383578f, 0.03201514f, 0.01364720f, 0.17442100f, -0.15088171f, -0.50373447f, -0.48954904f, 
    0.26123437f, 0.08522101f, 0.31118059f, -0.26372373f, 0.12338368f, 0.01776416f, -0.05376132f, 0.18924779f, 
    0.05149351f, -0.03650867f, 0.02097184f, 0.06037252f, -0.09745691f, -0.01589969f, 0.04854089f, 0.01671119f, 
    0.07080152f, -0.02339003f, 0.02514678f, -0.04705399f, 0.08657822f, 0.12905508f, -0.00153554f, -0.07749021f, 
    0.26816192f, -0.09530785f, -0.09851393f, 0.09047946f, 0.00364282f, 0.00575557f, -0.06167167f, 0.01265858f, 
    0.08178608f, -0.06438622f, -0.05762210f, -0.00342126f, -0.06860605f, -0.07502545f, -0.10626701f, -0.05695349f, 
    -0.00342212f, 0.01941883f, 0.02473528f, 0.09503587f, -0.10006031f, -0.38515875f, -0.40261179f, -0.36129794f, 
    -0.03726846f, 0.07497828f, 0.09709383f, -0.23385255f, 0.12303543f, 0.11406639f, -0.04612958f, -0.22246097f, 
    0.10499076f, -0.14947614f, -0.10026889f, 0.00928683f, 0.18236350f, 0.21944778f, 0.00610208f, -0.04354553f, 
    -0.17648403f, 0.04847119f, 0.02123770f, -0.13632424f, 0.01865298f, -0.00421188f, 0.05111649f, -0.02208637f, 
    0.20886052f, -0.00311198f, 0.35241041f, 0.29549578f, -0.02149274f, 0.07365435f, 0.01061558f, -0.05401114f, 
    0.05198710f, -0.02956820f, -0.06346436f, 0.01042828f, -0.24530268f, -0.22696516f, 0.09834018f, -0.22062032f, 
    -0.09914777f, -0.01927971f, 0.05477268f, -0.05971165f, 0.16881703f, -0.01241388f, 0.34957403f, 0.01210763f, 
    -0.11198710f, -0.06624625f, -0.07619665f, 0.11999722f, 0.03757367f, -0.01389956f, 0.00677861f, 0.02853657f, 
    0.03005373f, -0.08599061f, 0.12198411f, 0.14904395f, -0.00853302f, -0.11360314f, -0.06983428f, 0.11718452f, 
    0.02172819f, 0.03757250f, -0.15124886f, -0.12124746f, -0.07682945f, -0.17772499f, 0.30173299f, -0.09564625f, 
    0.00448323f, 0.09246197f, -0.03306188f, -0.03243425f, 0.01326776f, -0.17097054f, 0.07690947f, 0.15194313f, 
    0.00570469f, 0.14252108f, 0.02652835f, -0.17440102f, -0.02278992f, -0.23788193f, -0.15840651f, -0.10820750f, 
    0.18545783f, 0.13511266f, 0.09020687f, 0.20905337f, 0.07948373f, 0.00896101f, 0.00536232f, 0.19058256f, 
    -0.30796558f, 0.01517902f, -0.11641329f, 0.24259329f, -0.02242291f, 0.02657183f, -0.02577247f, 0.04994557f, 
    0.07505307f, 0.00813780f, 0.01460677f, 0.18848273f, 0.06494117f, -0.23515360f, -0.19627093f, -0.07092466f, 
    0.13362971f, -0.00267818f, 0.02280846f, -0.03108130f, 0.06390212f, -0.01687333f, -0.03720414f, 0.01494696f, 
    0.06290779f, -0.01458660f, 0.11509687f, -0.11624184f, 0.08231363f, -0.11242887f, -0.17061038f, 0.04336239f, 
    -0.05374489f, 0.00758773f, 0.06785268f, 0.01914501f, -0.58051807f, -0.32585886f, -0.31451628f, -0.27383655f, 
    0.00077377f, -0.05574460f, 0.02068484f, 0.09428476f, -0.07543750f, -0.11186332f, -0.00069218f, 0.02077082f, 
    -0.25823626f, -0.16697058f, -0.14932546f, -0.33753508f, 0.11746710f, -0.04929585f, 0.05418181f, -0.12209748f, 
    0.10694928f, 0.05297163f, -0.11833922f, -0.02511039f, 0.33135220f, -0.59516531f, 0.14839374f, 0.33382303f, 
    -0.06906629f, -0.12010420f, 0.04865962f, 0.05064600f, 0.05065639f, -0.10746801f, 0.14944965f, 0.08256885f, 
    0.03253049f, -0.29655239f, -0.02109333f, -0.09747224f, 0.06261409f, -0.06233804f, -0.03475384f, -0.00434004f, 
    0.07685321f, 0.22989024f, 0.11202742f, -0.07790305f, -0.00177991f, -0.04477184f, 0.25940704f, -0.11709407f, 
    0.05778523f, 0.09993146f, 0.15613629f, 0.01431967f, 0.00477223f, -0.05526789f, -0.04045630f, 0.07491162f, 
    -0.05151956f, 0.15162477f, -0.12896416f, -0.15371324f, 0.18441793f, 0.14900331f, -0.12813461f, -0.05223362f, 
    -0.00669450f, -0.08781114f, 0.13260289f, 0.14566746f, 0.00026587f, 0.11565770f, -0.13609695f, 0.10142188f, 
    -0.12948123f, -0.14540495f, 0.00534168f, -0.03531073f, -0.11938421f, 0.08529217f, -0.04680784f, -0.03462521f, 
    0.11562744f, 0.15656306f, 0.03837277f, -0.13888560f, -0.04263633f, 0.05111032f, -0.03880382f, 0.03587901f, 
    -0.13990836f, 0.02359143f, -0.00102474f, -0.08188936f, -0.02505759f, -0.21358573f, 0.17149441f, 0.00728095f, 
    -0.08618222f, 0.01527766f, 0.00350106f, 0.04074960f, 0.15534961f, -0.13409968f, 0.20600808f, 0.15520060f, 
    -0.36405662f, 0.11413233f, -0.30856413f, 0.04457355f, 0.03768096f, -0.07642695f, -0.05185969f, 0.07779453f, 
    -0.05270720f, 0.00850974f, 0.00303616f, 0.09129310f, 0.59117883f, -0.02150816f, 0.01075269f, 0.18106887f, 
    0.04392101f, 0.01121669f, -0.06137182f, -0.08087192f, -0.08801691f, -0.03049787f, 0.04100921f, 0.12597071f, 
    -0.24759926f, 0.01115620f, -0.09222043f, 0.08555195f, -0.04078580f, -0.15798460f, -0.04538278f, 0.19064908f, 
    -0.00903012f, -0.01282337f, -0.15672387f, -0.13736542f, -0.24770978f, -0.11132105f, -0.08471084f, 0.41264227f, 
    0.12163213f, 0.04203938f, -0.06518135f, 0.01214357f, 0.12008175f, 0.02260157f, -0.09636737f, 0.11010535f, 
    0.00409679f, -0.10256653f, -0.07614711f, -0.03969789f, -0.11729661f, -0.08002786f, -0.01871597f, -0.03800846f, 
    -0.04545491f, 0.01715978f, 0.11580667f, -0.08576639f, -0.06655129f, 0.04625922f, 0.32344362f, -0.01867909f, 
    -0.05756459f, -0.03576621f, 0.02248743f, 0.01957939f, 0.05532075f, 0.01159479f, 0.07705003f, 0.05427395f, 
    -0.25743598f, -0.00089385f, 0.21590382f, -0.21249101f, 0.16971713f, -0.09054897f, 0.02141395f, 0.12724763f, 
    0.02436392f, -0.02362792f, -0.03747280f, 0.10535382f, -0.11952573f, -0.01483829f, 0.04815347f, -0.14778745f, 
    -0.07376399f, -0.02859772f, -0.01552763f, -0.02042573f, 0.11728564f, 0.02826814f, 0.04358617f, 0.03696043f, 
    0.02754538f, -0.03484371f, -0.02236407f, -0.15651874f, -0.04530297f, 0.05845648f, 0.02441759f, 0.04525154f, 
    0.17949253f, -0.13811563f, -0.21117286f, 0.10535306f, 0.08531804f, -0.17052571f, -0.27095971f, -0.11081894f, 
    0.07813102f, -0.06870110f, -0.08264259f, 0.13449924f, 0.14389613f, -0.16433305f, 0.05498571f, -0.01102907f, 
    -0.16904064f, 0.02212672f, 0.00055029f, -0.28383687f, -0.01733552f, -0.00245608f, -0.04568412f, 0.10081374f, 
    0.17054451f, 0.01939520f, -0.11653309f, 0.21751340f, 0.13039230f, 0.00003474f, -0.03339538f, -0.20622650f, 
    0.14628881f, 0.18694782f, 0.03724322f, -0.08389648f, -0.07007856f, 0.00633227f, 0.00958330f, -0.00671110f, 
    0.02000369f, -0.06167523f, 0.04218370f, 0.09025265f, -0.03004850f, 0.03685791f, -0.04362397f, 0.12126668f, 
    -0.11701506f, 0.01151007f, -0.00581500f, -0.01409061f, 0.01950209f, -0.05483284f, 0.03035656f, 0.07927855f, 
    -0.06676422f, -0.00457884f, -0.08274629f, -0.10041875f, -0.01312443f, -0.03539177f, 0.01224559f, 0.02807812f, 
    0.15746446f, -0.12887588f, 0.00001414f, 0.17200348f, 0.04132479f, -0.00594731f, 0.05533041f, -0.02721612f, 
    -0.00366387f, -0.05098242f, 0.31508699f, -0.18860725f, -0.07621369f, -0.13046181f, -0.01313681f, -0.21845721f, 
    -0.05603480f, 0.08342554f, -0.09410699f, 0.00868421f, 0.13958399f, -0.13146469f, 0.04218424f, 0.20046738f, 
    0.01074407f, -0.12099545f, -0.13252576f, -0.20767860f, -0.07791116f, 0.05943697f, 0.10357544f, 0.00063017f, 
    0.11756053f, -0.25386506f, -0.18419173f, -0.26538748f, -0.31787407f, -0.26161033f, 0.05958802f, 0.09033807f, 
    -0.03053136f, -0.16496207f, 0.03621987f, -0.05180917f, 0.00386796f, -0.04304149f, -0.07182828f, -0.02725120f, 
    -0.12339056f, -0.12536772f, -0.01095214f, -0.07891300f, -0.02344252f, 0.00593444f, -0.00189490f, -0.06184882f, 
    0.12622796f, 0.12243340f, 0.01558188f, -0.01679483f, 0.13337846f, 0.23624440f, -0.30783001f, 0.08738194f, 
    -0.04272629f, 0.08008569f, -0.14659607f, 0.13541171f, -0.01463970f, 0.14095798f, -0.10640416f, 0.04067417f, 
    -0.65785617f, -0.65594655f, -0.23880571f, 0.02777950f, -0.04633989f, -0.29772413f, -0.09966531f, -0.08735578f, 
    -0.00629274f, -0.03122530f, -0.00641045f, -0.06881374f, -0.24520721f, -0.24265547f, -0.04948296f, -0.34973857f, 
    -0.09594807f, 0.05921137f, -0.21619594f, -0.26438501f, 0.08794378f, -0.08404248f, 0.05364422f, -0.03203784f, 
    -0.63907224f, -0.58526325f, -0.49994209f, -0.30374977f, -0.21118097f, -0.20140822f, -0.26309511f, -0.22363557f, 
    -0.03723403f, -0.03499622f, -0.02345551f, -0.10139877f, -0.41801342f, -0.64804941f, -0.30175465f, -0.02186763f, 
    -0.15893900f, -0.14655311f, 0.05324752f, -0.33623472f, -0.01396572f, 0.04432730f, -0.03925555f, 0.03008400f, 
    0.02999047f, -0.16593038f, -0.20032217f, -0.06462019f, -0.07795380f, 0.15934956f, 0.17074934f, 0.07076196f, 
    -0.00724807f, -0.00188671f, 0.01923351f, -0.02451324f, -0.10043443f, 0.20665750f, 0.00032823f, 0.26092440f, 
    -0.02136716f, -0.10823551f, 0.13392398f, 0.20111983f, 0.06002406f, -0.03045048f, 0.07991181f, 0.04168010f, 
    -0.14976726f, 0.05499812f, 0.00526924f, -0.43951011f, 0.07305172f, -0.02167234f, 0.09184217f, -0.06256276f, 
    -0.01951296f, 0.01916867f, -0.02880725f, 0.08018305f, 0.10973946f, -0.08712180f, -0.21723989f, -0.21430239f, 
    0.10686448f, 0.05486329f, 0.13604154f, -0.01419358f, -0.01898683f, -0.03533012f, 0.01644897f, -0.03274598f, 
    -0.58117843f, 0.25852725f, 0.20653355f, 0.03572881f, 0.01103011f, -0.33033726f, -0.09476057f, -0.01901242f, 
    0.04205349f, -0.06209045f, 0.00179540f, 0.01497459f, 0.26533979f, -0.03302039f, 0.03945850f, 0.07501066f, 
    -0.00139137f, -0.02944848f, -0.00831435f, -0.00879960f, 0.07627878f, 0.04758784f, 0.05633491f, -0.16891231f, 
    -0.41173804f, -0.39512494f, 0.01482096f, 0.42010164f, 0.26764396f, -0.00199004f, -0.08154174f, -0.10226312f, 
    -0.00836447f, -0.01366142f, -0.04616959f, 0.04911273f, 0.31667355f, -0.10599838f, -0.07374968f, 0.26149717f, 
    -0.02369468f, -0.07009742f, -0.00095524f, 0.06680810f, -0.05123957f, -0.02978476f, 0.07958987f, 0.09449618f, 
    -0.10475709f, -0.14983633f, 0.21921155f, -0.08264651f, -0.03120206f, 0.10181867f, -0.05633202f, 0.08999751f, 
    -0.07090745f, 0.02892975f, 0.06832186f, 0.01865107f, -0.49189374f, -0.35032845f, -0.12351227f, -0.13033088f, 
    -0.04856183f, -0.01573096f, -0.09912210f, 0.00347566f, 0.02050474f, 0.06593255f, 0.01909710f, 0.04525412f, 
    -0.25666502f, 0.12164986f, 0.25263900f, 0.11117336f, -0.08671454f, -0.08675814f, -0.02966171f, 0.11502063f, 
    0.05321516f, 0.09947149f, -0.05076706f, -0.04663401f, 0.17857771f, 0.30399635f, -0.01825262f, 0.02452996f, 
    -0.04617015f, -0.06974129f, -0.08993737f, 0.14675082f, 0.02892528f, -0.07018694f, -0.00226512f, -0.01700768f, 
    -0.01162268f, 0.09041247f, -0.02069777f, 0.04961493f, -0.12196289f, -0.02147141f, 0.07920174f, 0.06619249f, 
    0.11902683f, 0.15094033f, -0.01515932f, 0.04271247f, -0.22545540f, 0.06937172f, -0.00986456f, -0.06050469f, 
    0.03497332f, 0.02919735f, -0.01179451f, 0.00665548f, 0.06149244f, 0.17726995f, 0.10423167f, 0.04198368f, 
    -0.01334118f, 0.00202364f, -0.03187256f, 0.03258147f, -0.09382919f, -0.03340528f, 0.23210803f, 0.09322070f, 
    0.08214808f, -0.05315504f, 0.03052254f, 0.10835630f, -0.17322072f, -0.05808445f, -0.16180055f, -0.06786969f, 
    -0.00283210f, 0.05631690f, 0.00527226f, 0.08589513f, 0.06595815f, -0.03252072f, 0.35414845f, -0.02154770f, 
    -0.68713623f, -0.60159057f, -0.27031681f, 0.24702474f, -0.00719865f, 0.02390799f, -0.21478947f, 0.01554162f, 
    0.03827502f, -0.00276278f, 0.04352325f, -0.05091089f, -0.52934724f, 0.15014073f, 0.32314396f, 0.15941855f, 
    -0.10011639f, 0.06597925f, -0.13418005f, -0.06734753f, 0.01743123f, 0.07707614f, 0.07983457f, 0.04628701f, 
    0.28263360f, 0.11662590f, -0.11811399f, -0.00363606f, -0.02081729f, -0.02702552f, 0.07125881f, 0.10863641f, 
    0.07428011f, 0.08680994f, -0.17531668f, 0.02885500f, 0.03913486f, 0.10601956f, -0.03914854f, 0.01402784f, 
    0.03407463f, -0.01834596f, 0.03807759f, 0.04426448f, 0.07287917f, 0.13353516f, 0.19791567f, 0.07250771f, 
    -0.45008537f, -0.63776904f, -0.26639855f, -0.20765087f, -0.28392011f, -0.09664985f, -0.12895319f, -0.01102029f, 
    -0.02633474f, 0.06705486f, -0.04926519f, 0.03086690f, -0.47556558f, -0.67967355f, 0.04803824f, -0.46277130f, 
    0.13878456f, 0.01560870f, -0.11105864f, -0.10607231f, 0.03564144f, 0.04574515f, 0.14295819f, -0.01322142f, 
    -0.63595140f, -0.65787059f, -0.22533557f, -0.23024701f, 0.01574089f, 0.17870812f, 0.07595889f, -0.27228150f, 
    0.04231878f, -0.00653074f, 0.06804340f, 0.06642621f, -0.09659208f, 0.10080263f, 0.23726794f, -0.08918843f, 
    -0.00985526f, 0.00835641f, -0.05823414f, -0.02575064f, -0.01167477f, 0.10822048f, -0.06245814f, 0.08354335f, 
    -0.01106270f, 0.00370307f, 0.03006395f, -0.10686411f, 0.03997137f, 0.00179051f, -0.01627796f, -0.05427061f, 
    -0.06262812f, -0.09256279f, -0.13331252f, -0.17184056f, 0.05394471f, -0.03314709f, -0.06669196f, -0.04003592f, 
    -0.05532124f, 0.14338394f, 0.10499769f, 0.09835926f, 0.00114448f, -0.00987817f, 0.01584119f, 0.03148537f, 
    0.11599572f, 0.00744480f, -0.12947622f, 0.02879202f, -0.00895615f, 0.00760027f, -0.03379417f, 0.15233038f, 
    -0.06983475f, -0.05616716f, 0.08027210f, -0.19251108f, 0.01356653f, 0.13049185f, -0.00551235f, 0.11224083f, 
    0.01708083f, -0.22194427f, 0.23657179f, -0.07559466f, 0.09214032f, -0.03101073f, -0.01411188f, 0.00884582f, 
    0.01958531f, -0.13623138f, -0.13797705f, -0.07371227f, -0.00297563f, 0.02027656f, 0.04991546f, 0.00111672f, 
    -0.02242968f, -0.00718386f, -0.03166549f, 0.06278023f, -0.16881330f, -0.39691722f, -0.28419235f, -0.05398448f, 
    0.12897472f, 0.06638716f, 0.12349700f, -0.18218380f, 0.01156607f, -0.01590403f, -0.02109879f, 0.01519866f, 
    -0.16710947f, -0.15026274f, -0.28308502f, -0.01595065f, -0.20996368f, 0.06458633f, -0.01017377f, -0.35787314f, 
    0.06091195f, 0.02367527f, -0.06983733f, 0.01302391f, -0.24711823f, 0.11720351f, 0.32588899f, 0.25606701f, 
    -0.01452150f, -0.04582993f, -0.03357937f, 0.05387321f, 0.00671130f, 0.08649235f, 0.07079349f, 0.08322030f, 
    -0.28447080f, -0.16602126f, 0.04100761f, -0.13573848f, 0.05694966f, -0.31004429f, -0.14457743f, -0.10080886f, 
    -0.08411047f, 0.02218592f, -0.01982907f, -0.00731191f, -0.03169575f, 0.05523068f, -0.14576161f, -0.04193017f, 
    -0.00036138f, -0.13760170f, -0.00115473f, 0.10047440f, -0.03317196f, 0.02689356f, -0.12864964f, -0.02185541f, 
    -0.15459065f, 0.28670776f, 0.05872443f, -0.01224636f, -0.04462188f, 0.02525271f, -0.03119218f, 0.05159885f, 
    -0.06022003f, -0.10056958f, 0.01543114f, 0.08403272f, -0.17009397f, -0.21812443f, -0.17128292f, 0.29026845f, 
    -0.13741748f, -0.14001332f, 0.02351161f, 0.30772364f, 0.05244574f, -0.06818849f, 0.05472962f, -0.05374465f, 
    -0.04713175f, -0.00713956f, 0.25984058f, -0.35906717f, -0.07265737f, 0.06787481f, 0.12659043f, -0.01483090f, 
    0.04353422f, -0.00378827f, -0.02512538f, 0.00287883f, 0.21406020f, -0.09041931f, -0.20276891f, -0.10873716f, 
    -0.14377716f, -0.13632765f, 0.24476498f, 0.04056166f, -0.03340682f, 0.04041257f, -0.25503013f, -0.16983347f, 
    0.52546793f, 0.13348660f, 0.01901957f, -0.13262488f, 0.02399887f, -0.09140388f, 0.02717253f, 0.03745063f, 
    0.04372160f, 0.08593711f, -0.04044721f, -0.02886543f, -0.20474002f, -0.08102880f, 0.27545497f, 0.03692500f, 
    0.02942020f, -0.03737460f, -0.02165119f, 0.03268065f, 0.03102511f, 0.06132627f, 0.11894515f, 0.10758782f, 
    0.05745827f, -0.12220965f, -0.32149673f, -0.28476629f, 0.06435291f, 0.05998549f, 0.09357103f, -0.07159165f, 
    -0.08018700f, 0.02132557f, 0.00401567f, -0.01895418f, 0.13253720f, 0.19629991f, -0.40217596f, 0.03721659f, 
    -0.07311698f, 0.01964333f, 0.08382552f, 0.16932492f, -0.04211213f, 0.11504373f, 0.09501237f, 0.06978000f, 
    -0.10684524f, -0.04830817f, 0.09686666f, 0.17130956f, 0.04243540f, 0.13502268f, 0.09801283f, -0.14208099f, 
    0.07963509f, -0.07488152f, 0.09537689f, -0.01731872f, -0.07798030f, -0.02014025f, 0.06615846f, 0.28365946f, 
    -0.00856434f, -0.02205101f, -0.05076423f, -0.02532780f, -0.06067834f, -0.10812934f, 0.06253055f, 0.00695340f, 
    -0.12704103f, 0.00364744f, 0.04170498f, 0.18655331f, 0.12154199f, 0.07880975f, 0.02248517f, -0.23221953f, 
    -0.02310963f, -0.13231188f, 0.03184085f, 0.06097721f, -0.13461064f, -0.33482149f, -0.25127658f, 0.04403557f, 
    -0.01628401f, 0.01025022f, 0.05186190f, -0.04073649f, -0.06583480f, -0.05388631f, 0.08083902f, 0.05736373f, 
    -0.42753831f, -0.50055385f, 0.15800291f, -0.05800052f, -0.10909735f, -0.03305611f, 0.10331155f, -0.00549046f, 
    -0.00605503f, 0.02487279f, -0.04872685f, 0.06320459f, -0.20811874f, -0.13293871f, -0.01845183f, 0.04506012f, 
    0.02243392f, -0.12280138f, -0.02197810f, -0.07279329f, -0.00630294f, 0.04101624f, 0.06622797f, -0.01234512f, 
    -0.05116577f, -0.05333219f, 0.01717458f, 0.05032091f, 0.07981721f, 0.02999759f, -0.01225533f, 0.01944043f, 
    -0.04096320f, 0.01846380f, -0.09549803f, 0.06257221f, 0.46590292f, 0.39349207f, -0.10792875f, 0.06849407f, 
    0.01914108f, -0.03464805f, 0.19416009f, 0.14903685f, 0.10423259f, 0.08797994f, 0.01106336f, -0.07497609f, 
    0.15339006f, 0.02011846f, -0.02449479f, -0.07373970f, 0.03528882f, -0.11251865f, 0.08376692f, 0.10837781f, 
    0.00973988f, 0.10973613f, 0.13368359f, -0.05667236f, -0.06853040f, 0.05513372f, -0.05556300f, -0.01383043f, 
    -0.04805188f, -0.02492131f, 0.01893073f, -0.10332484f, -0.00721312f, -0.11479969f, -0.05503561f, -0.01590792f, 
    0.02581466f, 0.08875503f, 0.11386146f, 0.13493745f, 0.13022532f, -0.03436030f, -0.04487535f, -0.09173544f, 
    -0.02545544f, 0.01536727f, -0.00357360f, 0.04226322f, -0.13844986f, -0.15407187f, -0.14883772f, 0.04221842f, 
    -0.05938408f, -0.06644898f, 0.10956647f, 0.02267266f, 0.00893360f, -0.04273805f, -0.01356833f, 0.12842292f, 
    0.00454039f, -0.02484257f, 0.07876221f, -0.21383956f, 0.03571706f, 0.06667621f, 0.07667729f, 0.03730608f, 
    -0.03295451f, 0.00958697f, -0.02667010f, 0.03133646f, 0.11268520f, 0.15797022f, -0.10187636f, 0.03062421f, 
    0.07243469f, -0.05047445f, 0.14901967f, 0.07592771f, 0.09416756f, 0.15082991f, -0.04613457f, -0.01156489f, 
    0.07479066f, 0.15632381f, 0.05465863f, 0.01987847f, -0.01089216f, 0.01093381f, 0.04474102f, 0.09384082f, 
    0.05614066f, 0.13665339f, 0.16004083f, 0.19300127f, -0.09733663f, -0.08029732f, 0.08802115f, -0.02166254f, 
    -0.03834368f, 0.01777187f, -0.09803431f, 0.09684887f, 0.00681150f, 0.10082105f, 0.11944184f, 0.03119923f, 
    -0.21533370f, 0.13121225f, 0.19232576f, -0.02588669f, -0.04840477f, 0.05450014f, -0.08934577f, -0.11224762f, 
    -0.07584014f, 0.06472826f, -0.12088133f, 0.03761166f, -0.10963898f, 0.03014650f, 0.36748305f, -0.04027321f, 
    -0.06576544f, -0.13978012f, -0.11273512f, -0.15346088f, -0.19968475f, 0.00091842f, 0.00961356f, 0.02639940f, 
    -0.39392057f, -0.37647974f, -0.46362889f, 0.05451336f, -0.14184792f, 0.26359355f, -0.12104876f, 0.01456537f, 
    0.01810494f, 0.01522770f, -0.00157397f, 0.00756162f, -0.31490448f, -0.24120121f, -0.18677109f, 0.08122990f, 
    0.13329260f, -0.05302148f, 0.02555490f, -0.06085987f, 0.05533493f, 0.02363365f, 0.02741432f, 0.03583699f, 
    -0.41112852f, -0.43039519f, 0.10189967f, 0.36260858f, 0.02848540f, -0.09131004f, -0.00586869f, -0.13534679f, 
    0.04790504f, 0.00742031f, 0.01128346f, -0.01484853f, -0.27208856f, -0.16641684f, -0.10286147f, -0.39947063f, 
    0.00559808f, -0.14175959f, 0.14869949f, 0.20477961f, 0.00242950f, 0.01451547f, -0.05034044f, -0.07015168f, 
    -0.01592058f, 0.08217487f, -0.11615933f, -0.02803035f, -0.00111079f, -0.07308510f, 0.03760709f, 0.01841150f, 
    0.02733713f, 0.03141796f, 0.01818234f, 0.07446275f, -0.08351433f, -0.10488746f, -0.00154450f, -0.02855874f, 
    -0.14954801f, 0.10549586f, 0.05735041f, 0.00518903f, 0.06037452f, 0.05261014f, -0.04679970f, -0.02507355f, 
    0.06728418f, 0.06842875f, -0.05826155f, -0.00512848f, 0.00723270f, 0.05033660f, 0.03533730f, -0.03150821f, 
    -0.01146747f, 0.09591936f, 0.03362486f, 0.03056524f, -0.58626026f, 0.25716421f, -0.32335624f, 0.20313855f, 
    -0.01648340f, 0.14301869f, -0.02339030f, -0.06343508f, -0.00436742f, 0.06230291f, 0.04361045f, 0.00948863f, 
    -0.75160587f, -0.37274539f, 0.63262439f, -0.15403171f, 0.09765874f, 0.05219382f, 0.00442587f, 0.04813521f, 
    -0.09376621f, 0.07353758f, 0.01268948f, 0.02957708f, 0.22213528f, 0.05503989f, 0.01866381f, -0.13281760f, 
    0.03640813f, -0.02611372f, -0.00485008f, -0.05552821f, -0.13799414f, 0.03401800f, -0.15262073f, -0.12899441f, 
    -0.05616012f, 0.06020088f, 0.31700990f, -0.29149395f, -0.02790931f, -0.06174458f, 0.12897718f, 0.13921392f, 
    -0.01047651f, 0.01170054f, 0.04773270f, -0.03909821f, 0.37929204f, 0.06224151f, -0.06263796f, -0.15260629f, 
    0.03213859f, -0.01609967f, -0.07309458f, -0.00563835f, -0.09145185f, 0.07451408f, -0.07237571f, -0.06230493f, 
    -0.03857310f, 0.13762727f, -0.17853986f, -0.00797529f, -0.06029813f, -0.03180302f, 0.02143632f, -0.01438255f, 
    -0.11172943f, -0.01286085f, -0.02258846f, -0.09700266f, -0.37981594f, -0.38382083f, -0.28701395f, -0.30568552f, 
    -0.08237928f, 0.08573056f, 0.01351003f, 0.13452175f, 0.06893083f, 0.01853479f, -0.04176937f, -0.04644503f, 
    0.25013956f, -0.10444384f, 0.03399143f, -0.41285807f, -0.00938886f, 0.10236381f, -0.11011641f, 0.02524660f, 
    -0.08227798f, 0.04924554f, -0.13309506f, -0.11716986f, -0.19286999f, -0.28793451f, -0.16399072f, -0.18693937f, 
    -0.06185733f, -0.03899546f, 0.06953699f, -0.00113566f, -0.01590040f, 0.00288968f, 0.09682608f, -0.00823956f, 
    0.10287795f, -0.11737860f, -0.05752739f, -0.08310746f, -0.03605429f, -0.00112348f, -0.01551216f, 0.01558609f, 
    0.10337380f, 0.05432309f, -0.10339475f, 0.09321148f, -0.16790946f, -0.22449356f, 0.11167340f, 0.13308761f, 
    0.03083309f, -0.02292169f, 0.11225169f, -0.01029261f, -0.05206958f, 0.03425044f, 0.06312102f, -0.04749383f, 
    0.02851390f, 0.07010849f, -0.11036617f, 0.04182531f, -0.05344427f, -0.06896434f, 0.02748078f, -0.11022674f, 
    -0.14990757f, 0.00497566f, -0.06302825f, -0.03866541f, 0.18999183f, -0.14164875f, 0.03102935f, 0.05910866f, 
    0.00671437f, 0.00227105f, -0.00365565f, -0.00190352f, 0.10915985f, 0.07438564f, 0.07846347f, 0.08088234f, 
    -0.28284964f, -0.50956678f, 0.40440649f, -0.06768279f, 0.08427967f, 0.02210958f, 0.05591201f, -0.06197090f, 
    0.08372068f, 0.04094326f, 0.01756910f, 0.02219900f, 0.56770122f, -0.62099332f, -0.33022735f, -0.48380640f, 
    -0.08231483f, -0.04887920f, -0.17304748f, 0.09245539f, 0.03410010f, 0.00615160f, 0.01063013f, 0.02331973f, 
    -0.07125153f, 0.04766426f, 0.02150204f, -0.01618296f, 0.00957437f, -0.01248931f, -0.01257853f, -0.02632212f, 
    -0.09333566f, -0.07099377f, 0.01010937f, -0.00042071f, 0.00137854f, 0.01942894f, -0.01044704f, 0.07560145f, 
    0.03659138f, -0.03957791f, -0.04119373f, -0.04178263f, 0.01467896f, 0.01614689f, 0.07383046f, -0.07978182f, 
    0.01531982f, -0.41358677f, -0.15581954f, 0.21955670f, 0.02664942f, 0.18957822f, 0.06522389f, 0.09213974f, 
    -0.02030597f, -0.08752811f, -0.03940824f, -0.03266007f, -0.50065935f, 0.26008675f, 0.18667994f, 0.43587834f, 
    0.03728611f, -0.00609536f, 0.02533327f, -0.06401654f, -0.06002608f, -0.16162880f, -0.06498621f, -0.06797279f, 
    -0.19960529f, -0.13866377f, 0.10340390f, 0.45145449f, -0.16024761f, 0.10715556f, 0.11680250f, 0.15889063f, 
    0.03195612f, -0.07374996f, 0.01299608f, 0.05138742f, 0.25133362f, -0.10363952f, 0.09345613f, -0.37312478f, 
    0.02305365f, -0.00670147f, -0.00168614f, 0.09469291f, 0.04356563f, -0.13253118f, -0.15950666f, -0.08927592f, 
    0.04004944f, 0.04394611f, 0.03894179f, -0.13615182f, 0.02348488f, -0.03200335f, -0.00976890f, 0.02575364f, 
    0.04504881f, -0.00838595f, -0.01577561f, -0.14771985f, 0.04156281f, 0.07612544f, -0.02599330f, 0.07439514f, 
    -0.02333313f, -0.02897921f, -0.06540468f, -0.04966037f, -0.04711183f, -0.04403313f, 0.01676756f, 0.02955671f, 
    0.01219751f, 0.01235889f, 0.05601531f, -0.06534821f, 0.00586060f, -0.04244375f, -0.01942421f, -0.05514523f, 
    0.03580528f, -0.05216140f, -0.04773357f, 0.00348132f, -0.02939721f, 0.09391608f, -0.05392697f, 0.00174363f, 
    -0.08998060f, 0.07900340f, 0.04845196f, -0.03938160f, -0.00876151f, 0.00767643f, 0.03843614f, 0.05166425f, 
    -0.08104333f, 0.10132919f, -0.04968838f, -0.08512451f, 0.06058467f, 0.02543457f, -0.02593937f, -0.06249059f, 
    0.01594690f, 0.00946561f, 0.01026955f, -0.04147321f, -0.12275236f, -0.01539440f, 0.04759125f, -0.12012726f, 
    0.02193599f, -0.16893749f, -0.04904545f, -0.02888861f, 0.02411652f, 0.02801182f, 0.01246315f, 0.00608836f, 
    -0.12965745f, -0.17312159f, -0.01136998f, 0.30788764f, 0.13585369f, 0.14414476f, 0.04238463f, 0.03303621f, 
    0.01054260f, -0.03886206f, -0.04631068f, -0.03288827f, 0.49607247f, -0.72198778f, -0.30861911f, -0.28808627f, 
    -0.10376313f, 0.00171247f, -0.08143897f, 0.06442478f, 0.18747136f, -0.04277286f, -0.01882879f, 0.04213294f, 
    0.26422724f, -0.23504548f, 0.03821924f, -0.35780489f, -0.21979749f, 0.11781019f, -0.17219722f, 0.20594445f, 
    0.00704231f, 0.09143495f, 0.02092567f, 0.06993318f, 0.30246302f, -0.36297983f, -0.06591364f, -0.02277302f, 
    0.10323180f, 0.01995287f, 0.01698700f, -0.07442718f, 0.01408004f, -0.01159513f, -0.04550932f, -0.08532085f, 
    0.10398015f, 0.00285456f, -0.12476432f, -0.06808769f, 0.03212345f, -0.04289795f, 0.02960020f, -0.04210785f, 
    -0.03213350f, -0.07116408f, -0.14513719f, 0.04270904f, 0.33810374f, -0.39276990f, -0.17850167f, -0.16078043f, 
    0.07472748f, -0.07948918f, -0.06328782f, -0.11157649f, -0.00949191f, 0.06483050f, -0.01658010f, -0.05619945f, 
    -0.13400851f, 0.26607716f, -0.04010290f, 0.07919127f, 0.01785172f, -0.01453042f, 0.14424048f, -0.00845524f, 
    0.00528844f, -0.03029669f, -0.02333224f, 0.02207511f, -0.00224057f, -0.13884415f, -0.03182433f, 0.23908222f, 
    -0.06550012f, -0.13203341f, -0.14617103f, -0.11180596f, -0.01475992f, -0.15808731f, 0.09295539f, 0.03594101f, 
    -0.49341139f, -0.04690306f, -0.11780991f, 0.23717071f, -0.00629388f, -0.07824734f, 0.22199258f, -0.02741457f, 
    0.03923854f, 0.05652777f, 0.06585177f, 0.06625272f, 0.23083769f, 0.04044160f, 0.02055801f, -0.28192273f, 
    0.01019530f, 0.07580382f, -0.01968491f, -0.02259321f, -0.04299540f, 0.04453485f, -0.04342459f, -0.15095600f, 
    -0.10245553f, 0.03660944f, -0.01815257f, -0.00170495f, -0.03536930f, -0.00849108f, -0.12234025f, -0.06726799f, 
    0.03733176f, 0.04696992f, 0.01882186f, 0.03385705f, -0.17983951f, 0.13253178f, 0.00070020f, 0.08666366f, 
    0.00437444f, 0.05813807f, 0.00531915f, -0.11301535f, -0.03232313f, -0.01854299f, -0.04529759f, -0.02318455f, 
    0.09319770f, 0.07844789f, -0.11010616f, -0.00849071f, 0.04398549f, -0.17975733f, 0.02848300f, -0.04338682f, 
    -0.15711960f, 0.05469013f, -0.02203909f, 0.01196848f, 0.00033999f, 0.03601314f, 0.03539504f, -0.08408381f, 
    -0.02407038f, 0.05700486f, 0.00709437f, -0.03676950f, 0.01080972f, 0.07128724f, -0.05477319f, -0.14049193f, 
    0.01963413f, 0.01020574f, 0.09318540f, -0.07192732f, 0.09014182f, -0.11383838f, 0.05456398f, 0.01146600f, 
    -0.02366146f, 0.02074772f, 0.06650501f, -0.05842517f, -0.08742217f, -0.27804095f, 0.37446830f, -0.08625300f, 
    -0.03785808f, 0.01425223f, -0.16328292f, 0.17123516f, -0.00478693f, -0.05983890f, -0.05480140f, -0.05478934f, 
    0.19714916f, -0.31107843f, -0.17457910f, -0.38152578f, 0.03720495f, 0.03399818f, -0.05974201f, 0.13340586f, 
    0.00703577f, -0.05231716f, -0.00072213f, -0.01451332f, 0.06214372f, -0.01825556f, 0.07796326f, -0.03333960f, 
    0.04445892f, 0.05559000f, 0.06191028f, 0.02444129f, 0.00845560f, 0.03288006f, -0.03044438f, -0.06879003f, 
    0.02182243f, 0.09448309f, 0.08787894f, -0.05115849f, 0.01368018f, -0.03700117f, 0.00322781f, -0.01181789f, 
    0.00951888f, -0.11625796f, -0.01128510f, -0.06223546f, -0.19821341f, -0.19710229f, 0.12197611f, 0.03863033f, 
    -0.13499014f, -0.00665610f, 0.07415670f, -0.14185056f, -0.00130276f, 0.05370219f, 0.01631623f, 0.04432221f, 
    0.11428104f, -0.00264599f, 0.12489399f, -0.07272610f, -0.03867162f, 0.05100072f, 0.00494539f, 0.02426684f, 
    -0.00032394f, 0.07246155f, 0.04061455f, -0.01124546f, -0.02000464f, 0.02232751f, 0.04436108f, -0.02700457f, 
    0.02433059f, 0.01859900f, 0.01178112f, 0.10380291f, -0.13492930f, 0.04861511f, 0.05846223f, 0.02288483f, 
    0.10754976f, 0.03539121f, -0.14102423f, -0.15964609f, -0.00147105f, -0.01548984f, -0.00183349f, -0.08868077f, 
    -0.00684976f, 0.02941637f, -0.04176128f, -0.08112697f, 0.04928892f, 0.04048732f, -0.02991759f, -0.13726889f, 
    -0.12857448f, -0.07220017f, 0.06641521f, 0.03387406f, -0.00884023f, 0.04161533f, 0.05248036f, 0.01388145f, 
    -0.05169530f, 0.00975844f, -0.08687855f, -0.03986613f, -0.02587092f, -0.01615422f, -0.00307250f, 0.01528054f, 
    0.05387855f, -0.03951716f, -0.03475690f, -0.14692329f, -0.04506984f, -0.14081161f, 0.18832079f, -0.09779634f, 
    -0.13009673f, 0.12098575f, -0.03265565f, -0.03973291f, -0.11824099f, -0.01838155f, -0.04070754f, -0.07233207f, 
    -0.05005481f, 0.06593440f, 0.07753142f, 0.05336146f, -0.01312654f, -0.00785268f, 0.01866920f, -0.04087799f, 
    -0.00742532f, 0.09675831f, 0.05278281f, -0.03951043f, 0.32665956f, 0.11137596f, -0.20206138f, -0.44856006f, 
    0.01100609f, 0.02674238f, 0.00533947f, -0.03844008f, -0.04355466f, 0.10583559f, -0.00413326f, -0.13872525f, 
    0.25380304f, 0.03966278f, -0.08895789f, -0.10056634f, -0.00713141f, 0.00745834f, -0.04403944f, -0.00934051f, 
    -0.00998566f, -0.01618785f, 0.02857856f, -0.02342691f, -0.11395651f, 0.18901910f, -0.14191046f, 0.03137527f, 
    0.12690568f, -0.01937151f, -0.02298964f, 0.01621422f, -0.03610571f, 0.14155540f, -0.00340892f, 0.05261940f, 
    -0.35968593f, -0.50030094f, -0.40198946f, 0.09455294f, 0.32298994f, 0.15263604f, 0.09242405f, 0.19048402f, 
    0.06929415f, 0.01108597f, 0.12284406f, 0.14903508f, -0.14652817f, -0.25395134f, -0.15063293f, 0.08335037f, 
    -0.02808469f, 0.13714179f, -0.07024318f, 0.14027064f, -0.07557499f, -0.06012714f, -0.05269475f, -0.03939375f, 
    0.18598922f, -0.31818363f, -0.04104776f, 0.10220769f, 0.04486148f, 0.01264084f, -0.07905223f, 0.14121303f, 
    -0.03329600f, 0.07869752f, 0.02210747f, 0.04297657f, -0.00512025f, -0.30341941f, -0.34629861f, -0.21685827f, 
    -0.15950060f, -0.00636075f, -0.07383929f, -0.39718333f, 0.01555087f, -0.06299572f, -0.01062258f, 0.08180888f, 
    -0.28951877f, 0.06199697f, 0.14314927f, 0.05209352f, 0.03269973f, 0.03859105f, -0.11630624f, -0.13331111f, 
    -0.15527852f, -0.08873069f, -0.08535579f, -0.09704759f, 0.07919968f, -0.14062701f, 0.23832203f, 0.22037773f, 
    0.01544570f, 0.04657318f, 0.20408979f, 0.03223401f, 0.03150368f, -0.10354231f, 0.21605295f, 0.01921436f, 
    -0.29392916f, 0.03849410f, 0.21315500f, 0.17077991f, -0.11497217f, -0.01632029f, -0.03972626f, -0.12562752f, 
    0.02716342f, -0.11951058f, 0.00137248f, 0.01142991f, -0.06807719f, 0.11119257f, 0.10926085f, 0.24718276f, 
    -0.05602651f, -0.01098992f, -0.05751143f, 0.12683561f, 0.00544669f, 0.00204241f, 0.10778682f, 0.02226563f, 
    0.23795174f, -0.51519936f, -0.27818465f, -0.22906482f, -0.07579034f, 0.11709407f, 0.09801311f, 0.00114204f, 
    0.08814016f, 0.05903353f, 0.03986403f, 0.04056301f, 0.26937589f, 0.05891561f, -0.07205745f, -0.24019016f, 
    -0.02857158f, 0.01081557f, 0.03582028f, -0.09370697f, -0.00590247f, 0.00193222f, -0.02958154f, 0.01517989f, 
    0.15555225f, 0.05186520f, 0.07068890f, -0.13254054f, -0.03974464f, -0.04207844f, -0.08874829f, -0.07322219f, 
    0.03875275f, -0.00976128f, 0.04965417f, 0.09384243f, 0.49734080f, 0.18450400f, -0.17543435f, -0.02965021f, 
    0.06387428f, -0.03499365f, 0.03373258f, -0.00714463f, 0.04045503f, 0.01076817f, 0.10156864f, 0.10139707f, 
    0.16332278f, 0.19420052f, 0.05924411f, 0.00771780f, 0.02112035f, -0.02036117f, -0.02514421f, 0.11536120f, 
    0.21425296f, 0.00520386f, 0.01003776f, 0.04954122f, -0.02349379f, -0.39677867f, -0.37131545f, 0.00237712f, 
    -0.05309526f, 0.15351696f, 0.02125034f, -0.05077359f, -0.05846489f, -0.04824295f, -0.04068586f, -0.04161627f, 
    0.17043304f, -0.08800031f, -0.27061978f, -0.22499967f, 0.02278485f, -0.13724013f, 0.02394098f, -0.01794353f, 
    0.12915891f, 0.00422446f, 0.16706976f, 0.10140489f, -0.10442654f, -0.27046064f, -0.15698071f, -0.05106890f, 
    0.09547457f, 0.06691921f, 0.01218996f, 0.10766671f, -0.18116683f, -0.06961694f, -0.06416750f, -0.04493071f, 
    0.01155388f, -0.05576991f, -0.09503045f, -0.02034396f, 0.13524286f, -0.00456734f, 0.04157565f, 0.01396520f, 
    -0.29667491f, -0.24909098f, -0.28989735f, -0.23946558f, -0.12654923f, -0.07541497f, 0.14827420f, 0.14183943f, 
    -0.12952369f, -0.02343111f, 0.03489653f, -0.06178548f, 0.09731983f, 0.06250678f, 0.01059450f, 0.01873834f, 
    0.02091083f, -0.01927315f, -0.11603102f, 0.04085790f, 0.16848727f, 0.05753127f, 0.20427132f, -0.07887428f, 
    0.09454145f, 0.00885244f, -0.10828125f, -0.11594258f, 0.15112559f, -0.00273405f, -0.00476347f, -0.14118747f, 
    0.11612943f, -0.02855791f, 0.01904378f, 0.02485300f, -0.00662368f, -0.01231269f, -0.11771834f, -0.37762186f, 
    0.42500469f, -0.16467576f, -0.28124964f, -0.17619297f, -0.16936681f, 0.15502530f, 0.09224124f, -0.28172183f, 
    0.05231465f, 0.15267396f, 0.07635739f, 0.02864281f, -0.04022145f, -0.36229822f, -0.47952402f, -0.20905274f, 
    0.05757275f, 0.19030593f, 0.17462017f, 0.08536467f, -0.03892197f, -0.06663714f, 0.00967521f, 0.01157301f, 
    -0.23624131f, 0.06193853f, 0.06066439f, 0.09519101f, 0.03820203f, -0.04055096f, 0.00134219f, 0.04715226f, 
    -0.03336849f, 0.03057837f, -0.01212138f, 0.12840189f, -0.15091126f, -0.04201162f, 0.05307186f, -0.08059871f, 
    -0.03188979f, -0.06307527f, -0.04436932f, -0.01739660f, -0.02050442f, 0.04666580f, -0.15292239f, -0.39148405f, 
    0.02637363f, -0.42235488f, -0.46295327f, -0.40955737f, -0.15558074f, -0.25125742f, -0.02248310f, -0.03582307f, 
    -0.04889093f, -0.04583351f, -0.13390075f, -0.09221823f, -0.23201314f, -0.31598037f, -0.40586612f, -0.24987499f, 
    0.00827410f, -0.05761960f, 0.10260314f, 0.05608026f, 0.02928172f, 0.06200615f, 0.03181379f, -0.04111139f, 
    0.36613986f, 0.23539989f, 0.00957925f, -0.20018849f, 0.25449243f, -0.21713541f, -0.07891782f, -0.02428773f, 
    -0.10034721f, 0.13398331f, -0.03193633f, 0.07127241f, -0.08279019f, -0.06273946f, -0.05081151f, 0.08733940f, 
    -0.00774629f, -0.13703896f, 0.06562871f, 0.03544528f, 0.02496384f, 0.13119081f, 0.00001778f, 0.13785361f, 
    -0.27978837f, -0.04116695f, 0.06533710f, -0.26140010f, -0.11497728f, -0.03089535f, -0.00808276f, -0.01607438f, 
    -0.02214489f, 0.01745108f, 0.00756615f, 0.07614659f, -0.21161084f, -0.01053213f, 0.00379111f, 0.02687974f, 
    0.02755725f, -0.09890439f, -0.10177091f, -0.03621727f, -0.00218093f, -0.21520543f, -0.07567381f, -0.16073413f, 
    -0.23086397f, -0.05580139f, 0.13008292f, -0.01950261f, 0.00938433f, 0.10226529f, 0.00306263f, 0.01628255f, 
    -0.18355703f, 0.07874456f, 0.05443627f, 0.04442086f, -0.08462142f, -0.02322411f, -0.01842155f, 0.11670747f, 
    0.03465784f, -0.03148998f, 0.20774825f, 0.01494968f, -0.07006881f, 0.01801178f, -0.03914431f, 0.14262944f, 
    0.01907629f, 0.05368571f, 0.05392801f, -0.01647145f, 0.03450740f, -0.08583609f, -0.02900720f, -0.05750261f, 
    -0.02652922f, -0.01028208f, -0.04477374f, 0.00925853f, 0.04213308f, 0.15179598f, 0.12238711f, 0.05204745f, 
    -0.13838409f, -0.02724574f, 0.00482592f, -0.13622141f, 0.03024470f, 0.05033147f, 0.04784449f, 0.00563216f, 
    0.00678784f, 0.07369127f, -0.07382616f, 0.13141792f, 0.01905070f, -0.01523565f, -0.04576436f, -0.07929806f, 
    -0.01945902f, 0.03003585f, -0.12195851f, -0.02662336f, -0.44748652f, -0.37487850f, -0.11026598f, 0.13802420f, 
    0.06036296f, 0.07765268f, 0.10233310f, 0.06556149f, -0.19537657f, 0.03197975f, -0.10554919f, -0.32124844f, 
    -0.18301277f, -0.49894863f, -0.16924331f, -0.00862889f, -0.04819621f, 0.12840131f, 0.03941269f, 0.15030187f, 
    0.00470529f, 0.09769742f, 0.09197594f, 0.01891673f, 0.37411246f, 0.02425989f, -0.26605093f, -0.32046464f, 
    0.17769036f, -0.08977640f, 0.10174879f, 0.04693851f, 0.12919413f, 0.12570705f, 0.04343268f, 0.27334642f, 
    -0.21375255f, -0.20486863f, 0.01349796f, -0.16997404f, -0.00504458f, 0.08925662f, 0.06262790f, 0.03183445f, 
    0.05716731f, 0.07491429f, 0.06634542f, 0.00770141f, 0.40147239f, 0.01153706f, -0.07934846f, -0.16043393f, 
    -0.03767254f, 0.01806549f, 0.15830106f, 0.03918945f, 0.06382817f, -0.01252016f, 0.03979886f, 0.08611172f, 
    -0.49435103f, 0.08547921f, 0.07251168f, 0.21211749f, 0.08283690f, -0.27328297f, -0.09645431f, -0.03665284f, 
    0.04645848f, 0.04196635f, 0.08555617f, 0.08555612f, 0.18296719f, 0.05958728f, -0.22745661f, 0.01284685f, 
    0.18065490f, 0.04098630f, 0.04460844f, 0.12424608f, 0.02643975f, 0.11704447f, 0.15537733f, 0.18433098f, 
    -0.51188582f, -0.20260762f, -0.22464478f, 0.15545151f, 0.04735576f, 0.09738436f, 0.04098270f, 0.07755578f, 
    -0.13680916f, 0.05113897f, 0.05842934f, -0.03013204f, -0.13040198f, -0.02140567f, -0.16473627f, -0.11978570f, 
    -0.12134181f, -0.01708760f, 0.00542026f, -0.00189011f, 0.07873756f, 0.07258594f, 0.10790994f, 0.14333983f, 
    0.07863528f, 0.17028287f, 0.16208549f, 0.07463928f, 0.05247088f, -0.11556952f, 0.03327654f, 0.01559195f, 
    -0.08832091f, -0.00530008f, -0.00362006f, -0.00256381f, 0.33843222f, 0.14597136f, -0.08085121f, 0.11597899f, 
    0.04478319f, 0.05205794f, 0.01571479f, 0.10544377f, 0.12169670f, -0.06266458f, 0.02307478f, 0.15334478f, 
    0.02825837f, -0.05611429f, -0.00514620f, -0.06614120f, -0.01158172f, -0.00165351f, 0.01911565f, 0.00710803f, 
    -0.14721070f, -0.01725651f, -0.07546189f, -0.10762037f, 0.01396838f, 0.01585425f, -0.04202950f, -0.13491957f, 
    -0.05469019f, 0.02758482f, 0.03316696f, -0.04215857f, 0.00280584f, 0.02252817f, 0.24478562f, 0.02521264f, 
    -0.06882382f, 0.03714772f, 0.10718351f, -0.14511396f, -0.17903027f, -0.09890323f, -0.03899435f, -0.20080811f, 
    -0.08936386f, 0.02881332f, -0.00111347f, 0.05554622f, 0.08006477f, 0.02104012f, -0.10310369f, -0.13601242f, 
    0.01753409f, -0.07402984f, 0.06764915f, -0.04254577f, 0.09520463f, -0.00505204f, 0.05547819f, 0.04956901f, 
    0.06052775f, -0.15587242f, -0.55030078f, -0.07103198f, 0.13529538f, -0.08574458f, 0.15864323f, 0.08470728f, 
    0.05281427f, -0.00894693f, -0.04689505f, -0.01181737f, -0.21899658f, 0.00552513f, 0.04362090f, 0.01770340f, 
    -0.16346930f, -0.12281854f, -0.02282915f, -0.03986396f, -0.04343152f, 0.10515306f, 0.15550916f, 0.18649234f, 
    -0.06550468f, -0.07206320f, -0.00277321f, -0.01876445f, -0.06612892f, -0.04166934f, -0.00167846f, -0.00767089f, 
    -0.06812575f, -0.08967011f, -0.06139655f, -0.15288238f, -0.35991570f, -0.14103809f, -0.00938815f, 0.18695480f, 
    0.14804560f, 0.08277943f, 0.03411844f, -0.02763457f, -0.02965045f, -0.07848742f, -0.10029628f, 0.05659582f, 
    0.03061438f, -0.20986454f, 0.00465460f, -0.08175521f, 0.00926996f, 0.00955219f, -0.06489778f, 0.00193841f, 
    0.06330365f, 0.08008889f, 0.10188033f, 0.11290731f, 0.03311169f, 0.06367612f, 0.00325679f, 0.01663835f, 
    -0.14585146f, -0.19429019f, 0.04576262f, -0.04120608f, 0.14911374f, -0.10423132f, -0.00755463f, -0.01548101f, 
    0.14328431f, 0.07187113f, 0.04406369f, -0.07652375f, -0.02218587f, -0.11764961f, 0.12075097f, -0.11334402f, 
    -0.00120478f, -0.02965570f, 0.03673567f, 0.01170181f, 0.01651544f, 0.06690659f, -0.01923785f, -0.03815368f, 
    0.04865898f, 0.07331949f, 0.17580779f, -0.25700268f, 0.06383857f, -0.03633539f, -0.00556047f, -0.04248591f, 
    -0.26925668f, 0.07983486f, -0.12618797f, -0.19792157f, -0.03360318f, -0.02590208f, -0.12873420f, -0.02253637f, 
    -0.06037695f, 0.02949016f, -0.19171259f, -0.09124493f, -0.07055748f, 0.06091786f, 0.10430983f, 0.03651499f, 
    0.20943055f, -0.02696085f, 0.08092361f, -0.10282058f, 0.07051574f, -0.05103040f, 0.09907216f, 0.03744158f, 
    -0.16178678f, -0.16379055f, 0.07996684f, 0.11944253f, -0.03305425f, -0.02133826f, -0.02429224f, -0.01245599f, 
    -0.07354455f, -0.12874050f, -0.08857910f, -0.27102250f, 0.07129447f, 0.13823806f, -0.29360622f, -0.30929866f, 
    -0.06343567f, -0.05003788f, 0.01216306f, 0.08917532f, 0.14232174f, 0.00789684f, 0.11297301f, 0.12752040f, 
    -0.01965455f, -0.15560883f, -0.09750001f, -0.13030191f, -0.06161769f, -0.00545776f, 0.10689042f, -0.02663665f, 
    0.03451353f, 0.03761261f, 0.08842731f, 0.04063239f, -0.14967522f, -0.05344524f, 0.04985845f, 0.02877750f, 
    -0.15958197f, 0.01733195f, 0.15559025f, 0.14155807f, 0.07663446f, -0.13406762f, -0.05549620f, 0.00440944f, 
    0.05381253f, -0.07892173f, 0.02877592f, -0.15751871f, 0.00838375f, -0.33676028f, 0.01762573f, -0.07738096f, 
    0.03296035f, 0.02430603f, 0.02483614f, -0.03514494f, 0.22634971f, 0.29711804f, 0.09487183f, -0.15392856f, 
    -0.05142815f, 0.01645562f, 0.12363580f, 0.18937857f, -0.01897419f, 0.08294486f, 0.02102963f, -0.00858864f, 
    -0.16165410f, 0.06888061f, 0.03106318f, -0.05955802f, -0.08148498f, 0.03589850f, 0.12792502f, 0.07807812f, 
    0.06634694f, -0.01184234f, -0.00137029f, -0.04350440f, -0.38030627f, 0.19174723f, -0.02152928f, -0.26985955f, 
    -0.10787311f, -0.06960930f, -0.05353614f, 0.30499473f, 0.06835508f, 0.02936145f, 0.03257750f, -0.09848014f, 
    -0.06628876f, 0.19015430f, -0.43469417f, -0.00557965f, 0.20838541f, 0.08825345f, 0.24668799f, 0.06397220f, 
    0.01735549f, -0.00634523f, 0.03375941f, 0.05401012f, 0.26300338f, -0.24528269f, 0.38695854f, -0.56050539f, 
    0.05928486f, -0.20998488f, -0.05849349f, 0.01873134f, -0.17422278f, 0.01844767f, 0.00222660f, 0.04273292f, 
    -0.16537526f, -0.34186950f, -0.22613516f, -0.07757211f, 0.06409823f, -0.05481881f, 0.10280611f, 0.14110178f, 
    -0.13682161f, -0.06462279f, -0.08885577f, -0.07705395f, -0.58633995f, 0.17818743f, -0.51510102f, -0.14258808f, 
    -0.09824330f, -0.24939291f, 0.11487653f, -0.07483115f, -0.02084754f, -0.02430061f, -0.06700142f, -0.02181540f, 
    0.17759970f, -0.21112500f, 0.07481597f, -0.25124773f, -0.18291049f, -0.10199658f, -0.01663722f, 0.01408529f, 
    -0.13564782f, -0.06181265f, -0.00588684f, -0.07403331f, -0.37468380f, -0.12915787f, 0.14822373f, 0.28850383f, 
    -0.00146800f, 0.23186822f, -0.08069669f, -0.14390709f, 0.09247070f, 0.07357851f, 0.02944478f, -0.11307967f, 
    0.03382491f, -0.52805704f, 0.30219898f, -0.30070591f, -0.00760038f, 0.07654441f, -0.15390356f, 0.17876916f, 
    0.04948905f, -0.06475110f, -0.05267713f, 0.00734916f, -0.44644919f, -0.12858839f, -0.05762425f, 0.05290258f, 
    0.03500013f, 0.02717443f, -0.07016116f, -0.01921640f, 0.05585000f, -0.02286447f, 0.04323445f, 0.05451959f, 
    -0.46400237f, 0.08869651f, -0.21156794f, -0.10079420f, 0.07494033f, 0.03652748f, 0.05409871f, 0.09843072f, 
    0.03342027f, -0.14783515f, -0.06093586f, -0.12961595f, -0.14472498f, -0.02517761f, 0.00861942f, -0.33917844f, 
    -0.13324523f, 0.00866176f, 0.07450011f, 0.15216433f, 0.08352774f, 0.00171873f, 0.06431133f, 0.00640958f, 
    0.09315943f, -0.44213706f, 0.15271965f, 0.21712388f, 0.09804541f, 0.00311437f, -0.09910794f, -0.03513218f, 
    0.03701148f, 0.06402206f, -0.03681595f, 0.08181521f, 0.05765797f, 0.22395465f, 0.41010514f, -0.33455575f, 
    0.00960471f, -0.30736712f, 0.01942473f, -0.05619160f, -0.08737504f, 0.04945763f, 0.09909017f, 0.09487822f, 
    0.12152778f, 0.03400589f, 0.25283533f, 0.01456325f, 0.01907371f, -0.17104596f, -0.11418334f, -0.14240322f, 
    -0.03080029f, 0.08283962f, 0.05442384f, 0.12880915f, 0.13622834f, -0.14181986f, 0.04093928f, -0.04604468f, 
    0.08593863f, -0.16798881f, 0.04659567f, 0.07942217f, -0.05052375f, 0.00133758f, -0.01466343f, 0.13537756f, 
    -0.14144680f, -0.03657557f, -0.19283584f, -0.11503803f, 0.07472824f, -0.03672814f, -0.01503747f, -0.05065015f, 
    -0.04746669f, -0.12866549f, -0.04365761f, 0.02770822f, 0.05648682f, -0.14053141f, 0.17488581f, 0.11441043f, 
    0.01131990f, 0.06470212f, 0.02970916f, -0.00166148f, 0.00572772f, 0.07304759f, 0.17128427f, 0.17024656f, 
    -0.07071282f, -0.50766653f, 0.07922406f, -0.29127157f, -0.04051032f, -0.02796937f, 0.06213416f, -0.03806476f, 
    0.00701599f, -0.04332785f, -0.05799680f, -0.05953557f, -0.17953722f, 0.19554402f, -0.05300922f, 0.13033901f, 
    0.02320263f, -0.07972803f, -0.35082027f, -0.07523055f, 0.00699742f, -0.07880083f, 0.07161298f, 0.10175645f, 
    -0.04442277f, 0.08979192f, -0.02360570f, -0.20049602f, 0.02804438f, -0.09789099f, 0.06358747f, 0.02464030f, 
    0.00470880f, 0.00853901f, -0.08017769f, 0.02016089f, 0.00544710f, -0.04969693f, 0.03579080f, 0.03000963f, 
    0.02735395f, 0.05213691f, 0.08460943f, -0.01019708f, 0.04431037f, 0.00294105f, 0.10925138f, 0.22362293f, 
    -0.25940403f, -0.12099190f, 0.19174175f, 0.00805157f, 0.02035406f, -0.01424875f, 0.00397093f, 0.12669550f, 
    0.07189547f, 0.09106702f, 0.04679777f, 0.01527248f, -0.02148511f, -0.01771433f, -0.08311733f, 0.00090874f, 
    -0.18185216f, -0.00281776f, 0.05199249f, 0.04820226f, 0.07481911f, 0.11074831f, 0.03253044f, -0.05577695f, 
    0.21110946f, 0.09981795f, -0.49402124f, 0.12373889f, -0.10773120f, 0.03744026f, 0.03900660f, 0.02473291f, 
    0.01703589f, 0.03380195f, 0.00421688f, -0.10583703f, 0.19600555f, -0.03465419f, 0.22049978f, 0.25496873f, 
    0.14453724f, 0.02766626f, -0.19658919f, -0.08969071f, 0.09783199f, -0.08682242f, -0.19309828f, 0.06265656f, 
    -0.05938092f, -0.16619237f, 0.04982236f, 0.12907700f, 0.02747150f, 0.09037407f, 0.03906068f, -0.00589994f, 
    0.06546514f, 0.08523406f, 0.04396812f, -0.01852563f, -0.13015853f, 0.06771822f, -0.36546052f, 0.01227427f, 
    0.10818239f, -0.04597991f, 0.10534465f, 0.10375444f, 0.04360405f, 0.04622537f, 0.03802098f, 0.05917317f, 
    0.07904489f, -0.09836214f, -0.20416947f, -0.08395628f, 0.06399046f, 0.13275333f, 0.02670904f, -0.05078688f, 
    0.13532400f, -0.11522127f, -0.01704980f, -0.05421739f, 0.25110656f, -0.14488475f, -0.17719904f, -0.42496699f, 
    -0.06921412f, -0.12870999f, 0.07497939f, -0.02847343f, 0.02902194f, -0.02418305f, -0.04840548f, -0.01708333f, 
    -0.23244962f, -0.23128460f, -0.13063821f, 0.00319022f, 0.13995741f, 0.03643925f, 0.04895831f, -0.01452872f, 
    0.04677588f, 0.04123550f, -0.06519838f, -0.04665640f, 0.13772881f, -0.38144565f, -0.18569623f, 0.03300749f, 
    0.15309951f, 0.17460012f, 0.21979646f, 0.25466943f, -0.00940948f, 0.00649075f, -0.01038083f, -0.11947238f, 
    0.12170578f, 0.09462683f, -0.23800732f, -0.07092120f, -0.02978182f, -0.05373843f, 0.03541984f, 0.21909080f, 
    0.08330443f, 0.07378055f, 0.03277458f, -0.01679518f, 0.11200772f, 0.11112767f, 0.21088462f, -0.22447094f, 
    -0.12836364f, -0.11685146f, -0.09114196f, -0.11574746f, 0.07096024f, 0.05756500f, 0.03736218f, 0.07215878f, 
    -0.23613922f, -0.00752144f, -0.37016237f, -0.29833895f, -0.33701420f, 0.16362655f, -0.03857547f, 0.03516192f, 
    0.15467818f, -0.05207800f, 0.01729181f, -0.07724506f, 0.23932199f, -0.13104396f, 0.35682663f, 0.25491571f, 
    0.11068456f, -0.07658008f, -0.06232891f, -0.04440725f, 0.00893742f, -0.02506207f, -0.09349028f, -0.11366116f, 
    0.13587543f, 0.07562882f, 0.23040441f, 0.20302416f, 0.09255172f, -0.14492455f, -0.08123491f, -0.16257173f, 
    0.03621903f, -0.03073410f, 0.03370639f, 0.06655153f, -0.27789292f, -0.11066338f, 0.17579733f, -0.01522160f, 
    0.11325217f, -0.14041035f, 0.02046146f, -0.04593449f, -0.04755820f, -0.06470490f, -0.02628299f, -0.03138283f, 
    -0.23405078f, -0.07738278f, -0.42162693f, -0.09856632f, 0.00590212f, -0.02683936f, 0.08336465f, 0.03828029f, 
    -0.02284408f, -0.04654812f, -0.17648014f, -0.12739678f, -0.33554903f, 0.36739218f, 0.05405353f, 0.10379214f, 
    0.01059433f, -0.19213144f, 0.17209801f, -0.15170458f, 0.20008120f, 0.08042360f, -0.11273379f, 0.01486542f, 
    -0.31981328f, 0.54322356f, 0.39958569f, -0.79496044f, -0.03966020f, -0.03600769f, 0.10261498f, -0.05410617f, 
    0.04094007f, 0.05857329f, 0.01159426f, 0.04074441f, -0.02062408f, 0.09930921f, 0.16625389f, 0.22325060f, 
    0.07839463f, 0.04643144f, -0.19134288f, -0.04957937f, -0.01745044f, 0.02159979f, -0.02466265f, -0.06787933f, 
    -0.30912247f, 0.05895857f, -0.74283236f, 0.27122277f, 0.05687631f, 0.00150238f, 0.26171267f, -0.07398562f, 
    0.03894811f, 0.00811678f, -0.08893637f, -0.03778434f, -0.42032593f, 0.03160530f, -0.38763702f, 0.09519513f, 
    0.05417146f, -0.18134229f, 0.10321126f, -0.06958029f, -0.02712311f, -0.03966981f, -0.05423533f, -0.07724585f, 
    -0.12849207f, -0.09429138f, -0.08316191f, -0.16252199f, 0.08113322f, 0.16403742f, -0.14776403f, 0.22262928f, 
    0.10949954f, -0.06758570f, 0.05475450f, 0.17785217f, 0.09627961f, -0.16624223f, -0.01686676f, -0.21233368f, 
    0.00446598f, 0.07038807f, -0.09663742f, 0.00667307f, -0.05403061f, -0.15115197f, 0.03397533f, -0.00294903f, 
    -0.02441755f, -0.33489043f, 0.23508953f, -0.31479007f, -0.00575011f, 0.11237727f, -0.16024469f, 0.23864347f, 
    0.04345323f, 0.07755879f, -0.00001079f, 0.11567028f, -0.13238327f, -0.07887210f, 0.12134995f, 0.00560494f, 
    -0.05785218f, -0.00252958f, 0.04430893f, -0.03195021f, 0.06877112f, 0.04845357f, 0.02550832f, 0.07530014f, 
    0.08612174f, -0.18761134f, -0.06328297f, -0.09174819f, -0.12929092f, -0.03296283f, 0.04027911f, -0.08466982f, 
    0.08274928f, 0.02934817f, 0.02559553f, 0.00804249f, 0.09288751f, -0.08293923f, 0.17164823f, -0.02216611f, 
    0.01345272f, 0.10218488f, 0.05170310f, -0.01552053f, -0.01715865f, 0.03509533f, -0.12539805f, -0.14651984f, 
    0.16273524f, -0.28335983f, 0.02219353f, -0.05866857f, 0.11144306f, -0.01786665f, 0.08224739f, 0.08456969f, 
    0.07501258f, 0.18110721f, 0.04785191f, -0.02244626f, -0.04347073f, 0.10888039f, 0.59209877f, -0.54024452f, 
    0.01851314f, -0.07158617f, -0.01212801f, -0.13880517f, 0.00100909f, -0.03416329f, 0.06325751f, 0.01659918f, 
    0.19627164f, -0.08363026f, 0.11787785f, -0.08649256f, -0.05760725f, -0.03560453f, -0.10262404f, -0.21712492f, 
    -0.05477241f, 0.03791733f, -0.08393589f, -0.06072738f, 0.13394380f, -0.18709971f, 0.20020343f, -0.12117871f, 
    0.20359406f, -0.03715460f, -0.03438130f, 0.14211224f, -0.04783301f, 0.01192789f, -0.18579540f, -0.04133241f, 
    -0.19568139f, -0.17817456f, 0.00458684f, -0.11419420f, 0.05511295f, 0.09480995f, 0.00987281f, 0.15951824f, 
    -0.02196935f, -0.08916056f, -0.01512428f, -0.07567631f, -0.05657573f, -0.01684155f, -0.17521411f, -0.17306828f, 
    0.07478677f, -0.01058245f, 0.10788499f, 0.05797075f, -0.24679956f, -0.04200521f, -0.09267083f, -0.02328151f, 
    -0.08824325f, -0.04223469f, -0.08845001f, 0.15225337f, 0.11871300f, 0.04509825f, 0.10984507f, 0.00682134f, 
    0.15740640f, -0.02183111f, -0.01828296f, 0.05956929f, 0.09314965f, -0.10476345f, 0.12382723f, -0.26077244f, 
    0.02903615f, -0.08637138f, -0.01929385f, -0.11001582f, -0.29503766f, -0.12406634f, -0.01453906f, -0.10025788f, 
    0.07310032f, 0.01711048f, 0.11710100f, -0.12500368f, 0.03806584f, -0.02910086f, 0.03742059f, 0.02132980f, 
    -0.06250205f, 0.15730700f, 0.07263096f, 0.10095400f, -0.11819477f, 0.16741519f, -0.08053990f, 0.50116879f, 
    0.01022329f, 0.11959466f, -0.25600266f, 0.02649656f, 0.00150439f, -0.16859898f, 0.09860189f, -0.03671801f, 
    0.12555866f, -0.03132451f, 0.24466257f, 0.25082010f, 0.08283049f, 0.01082683f, -0.15340558f, -0.03175799f, 
    0.04362407f, -0.23642427f, 0.00166310f, 0.16498074f, -0.18507904f, 0.27003336f, -0.12548758f, -0.15790255f, 
    -0.03185698f, -0.14232588f, 0.02903499f, 0.03067891f, 0.05555568f, -0.10770566f, -0.00804907f, 0.02880841f, 
    -0.02089328f, 0.07451172f, -0.16076705f, -0.22186057f, -0.19835928f, -0.08911720f, 0.10500658f, -0.02033287f, 
    0.00852303f, 0.10158032f, 0.05309017f, 0.05838856f, -0.16532208f, -0.23573500f, -0.10517242f, 0.07717077f, 
    0.02236789f, -0.20863731f, 0.08688456f, 0.08871541f, -0.10979640f, 0.01894881f, 0.03811984f, -0.00910127f, 
    -0.25480846f, -0.15743135f, 0.12210587f, 0.17591538f, -0.08884738f, 0.05630304f, 0.08829486f, -0.03037895f, 
    0.02006803f, 0.03565901f, 0.07675350f, 0.17388654f, -0.16855523f, -0.17943221f, -0.08397194f, 0.16394690f, 
    -0.07003662f, 0.19489276f, -0.20022514f, 0.04633367f, 0.07017806f, -0.01215821f, 0.02982996f, -0.02701036f, 
    0.02815709f, -0.17560953f, -0.13531478f, -0.01555195f, -0.22965956f, -0.29564950f, 0.06681044f, -0.08316978f, 
    -0.18124042f, 0.09591202f, -0.24035850f, -0.17607412f, -0.10480921f, 0.09735336f, -0.05446907f, 0.23512299f, 
    0.01656142f, -0.10385262f, -0.06158109f, -0.09030291f, 0.08899206f, 0.00872906f, 0.07334072f, -0.16317499f, 
    -0.22903992f, 0.07755373f, 0.10967270f, 0.04571380f, 0.05043098f, -0.01399841f, -0.24729480f, 0.05671048f, 
    0.03339069f, 0.11588740f, 0.18110883f, -0.04075895f, 0.21005040f, -0.21160035f, 0.19538063f, 0.10699387f, 
    -0.08969508f, 0.08285963f, 0.21460228f, 0.08206786f, 0.00835115f, 0.07066368f, 0.05243796f, 0.02358205f, 
    -0.10794579f, 0.37546185f, -0.19153216f, 0.17483653f, 0.03096722f, 0.12421717f, 0.01536423f, -0.05007868f, 
    0.14382826f, 0.03972728f, 0.10725596f, 0.05419597f, -0.13011380f, -0.06166945f, 0.13555621f, -0.29615027f, 
    -0.11337925f, 0.07950167f, -0.17980349f, -0.02366960f, -0.06259302f, -0.13843399f, 0.01212298f, -0.04267694f, 
    -0.05172976f, 0.05381538f, 0.01352231f, 0.15842985f, -0.08839358f, 0.00775122f, -0.11635786f, 0.06776363f, 
    0.10204790f, -0.11766031f, -0.03655351f, 0.05875376f, -0.08713780f, 0.20591937f, 0.26205736f, 0.18189389f, 
    -0.22032943f, -0.04262973f, -0.03367651f, 0.20096649f, -0.05425721f, -0.07838920f, 0.00594348f, 0.07390765f, 
    0.16913091f, 0.06709156f, 0.27497518f, 0.06394793f, -0.08073621f, 0.06397137f, -0.07947689f, 0.08807860f, 
    -0.04924687f, 0.04136875f, 0.10934889f, 0.09178843f, -0.03138474f, -0.32315415f, -0.04066347f, 0.18005459f, 
    0.07676405f, -0.22959656f, -0.07133114f, -0.10822409f, -0.00074649f, 0.00973882f, -0.07363781f, -0.09349757f, 
    -0.50829834f, 0.03894207f, -0.04060159f, 0.20266291f, 0.00315140f, 0.13161899f, 0.00491570f, -0.05610393f, 
    -0.03065331f, -0.19968300f, 0.04148131f, 0.10518619f, -0.21402872f, 0.03907208f, -0.06093277f, -0.05743241f, 
    0.02769623f, -0.03569210f, 0.07901548f, 0.12119882f, 0.04750137f, 0.01853032f, 0.06781074f, -0.09123261f, 
    -0.29725352f, 0.12486722f, -0.16999818f, -0.14834517f, -0.04342670f, -0.07573039f, -0.05743236f, 0.07322334f, 
    -0.01790031f, -0.14565408f, -0.18397436f, -0.30031615f, -0.16105410f, 0.16114244f, -0.10152492f, 0.14533740f, 
    0.07813924f, 0.05064119f, -0.02301601f, 0.06543826f, -0.02357415f, -0.03357617f, -0.12450316f, 0.05968354f, 
    -0.04557906f, -0.15756223f, 0.30065417f, -0.04661121f, -0.07379792f, -0.01648029f, 0.11425087f, 0.11881259f, 
    -0.12701055f, 0.02166768f, 0.08670081f, -0.06445309f, -0.16098835f, 0.24105416f, -0.08530745f, -0.18448912f, 
    -0.07200499f, 0.11747006f, 0.13433631f, 0.01020941f, -0.10634786f, -0.18099968f, -0.43351740f, -0.49408501f, 
    -0.62496644f, 0.19171372f, 0.01543576f, 0.13646773f, -0.01551724f, 0.15018617f, -0.04630512f, -0.06705939f, 
    -0.00332644f, 0.08162600f, 0.21269780f, 0.01304182f, 0.01336445f, 0.19658493f, 0.05744481f, -0.07098115f, 
    0.08792078f, -0.00545651f, 0.00228198f, 0.06436599f, -0.12613687f, 0.06739177f, -0.04548503f, -0.09743574f, 
    0.00587464f, -0.13581139f, -0.05415355f, 0.22534850f, -0.08840794f, -0.05964266f, 0.16103926f, -0.03876316f, 
    -0.01770689f, 0.04683756f, 0.01250510f, 0.13224019f, -0.07705424f, 0.24540910f, -0.01313756f, -0.16007422f, 
    -0.04743915f, 0.02986672f, -0.06350376f, -0.07630872f, -0.02024092f, -0.17513578f, -0.15718877f, -0.22246110f, 
    -0.22849338f, -0.02019181f, -0.36200535f, 0.12636848f, 0.04981566f, -0.19248493f, -0.06608842f, 0.15652496f, 
    -0.00608555f, 0.05093691f, -0.10008454f, -0.11162605f, -0.03929366f, -0.33495682f, -0.35892633f, 0.32320213f, 
    -0.04158833f, 0.03801398f, -0.06530222f, -0.02753836f, 0.11049099f, 0.02743540f, -0.07190713f, 0.03677293f, 
    0.00550546f, 0.30635485f, -0.24416444f, -0.04699308f, -0.11323875f, 0.16135330f, 0.10543954f, -0.03147668f, 
    -0.16200902f, 0.10631322f, -0.20747875f, 0.04627955f, -0.03724580f, 0.18161432f, -0.20668235f, -0.00612161f, 
    0.03483938f, -0.06707334f, 0.16284758f, -0.01803244f, -0.17294371f, 0.19262387f, -0.05893940f, -0.07433932f, 
    -0.08455811f, -0.36963493f, -0.34283310f, -0.32429317f, -0.12466535f, -0.03068316f, 0.01566286f, -0.06946755f, 
    0.05673573f, 0.03156151f, 0.08706277f, -0.07466434f, -0.00742859f, -0.10652442f, -0.15300655f, -0.14048174f, 
    -0.08584885f, 0.07765443f, -0.12294455f, -0.06490494f, -0.22973934f, -0.20890847f, -0.07115981f, -0.12494306f, 
    -0.15140174f, 0.03896804f, 0.07222441f, 0.14274189f, -0.05627227f, -0.20490305f, 0.04979251f, -0.06704666f, 
    -0.18037711f, 0.05480338f, 0.14960997f, 0.02005677f, 0.04659427f, -0.01252632f, 0.25032482f, 0.30827495f, 
    0.02397161f, 0.08052494f, 0.11256269f, -0.08525778f, 0.13328207f, 0.05690517f, 0.13266073f, -0.12936491f, 
    -0.06434841f, 0.14953771f, 0.09818723f, -0.00237942f, -0.07717913f, 0.00242744f, 0.11264154f, 0.06189948f, 
    -0.04720169f, -0.03026159f, 0.00530573f, 0.08570883f, -0.19321236f, -0.26614988f, -0.15036194f, -0.07702219f, 
    -0.05256018f, -0.06092702f, -0.21707918f, 0.05454091f, 0.05773657f, 0.09535701f, 0.04083997f, -0.06813584f, 
    -0.05185155f, -0.18621373f, -0.02459057f, -0.15132515f, 0.00771643f, 0.05667093f, -0.03065419f, -0.08585055f, 
    -0.11639795f, -0.05451224f, -0.13167204f, -0.03130187f, 0.23982124f, -0.16510271f, 0.04397117f, 0.10998422f, 
    0.07741576f, -0.02168586f, -0.04806744f, 0.03864357f, -0.15855683f, -0.08080540f, -0.18813619f, -0.28951660f, 
    0.20869027f, 0.16122833f, 0.03202432f, 0.11916043f, -0.02689892f, 0.02554213f, 0.01510179f, -0.05205347f, 
    -0.14083375f, 0.13599795f, 0.09651178f, 0.11983528f, -0.49191856f, 0.16668478f, -0.22919007f, -0.10853660f, 
    -0.08681864f, 0.12904145f, -0.02993441f, 0.02652206f, 0.10750410f, -0.15634896f, 0.13624442f, 0.07716801f, 
    -0.20170894f, 0.18714020f, -0.08223290f, -0.12381656f, 0.03070045f, -0.11554539f, 0.03037339f, 0.06990935f, 
    0.07954904f, -0.11717989f, -0.06231756f, 0.00079050f, -0.43546069f, 0.11757898f, -0.05359843f, 0.05932519f, 
    -0.03133192f, 0.07706492f, 0.06876694f, -0.04804440f, -0.03616746f, 0.01021626f, -0.03730955f, -0.08351427f, 
    0.07170971f, -0.25398093f, 0.14721568f, 0.25187942f, -0.11866571f, 0.10513504f, 0.07303578f, 0.03885420f, 
    0.04994296f, -0.11630142f, -0.01614781f, 0.08341028f, -0.05352375f, -0.05168513f, 0.13979800f, -0.12894075f, 
    -0.20429924f, 0.06008669f, 0.18612549f, 0.01176240f, 0.06938824f, 0.07034640f, 0.10509485f, 0.13277636f, 
    0.06882882f, -0.30733743f, 0.17283884f, 0.10796136f, 0.03251762f, 0.05296423f, 0.03845780f, -0.09258118f, 
    -0.01478425f, -0.25865129f, 0.03332720f, -0.07140993f, -0.04540082f, 0.07077453f, -0.11586952f, 0.02445280f, 
    -0.11019850f, -0.04871236f, 0.06022535f, -0.00791960f, -0.06958383f, 0.05033632f, 0.15908746f, 0.09300358f, 
    -0.00475590f, 0.19420512f, -0.33576232f, -0.00851826f, -0.23383082f, -0.04391757f, 0.11445734f, -0.12330771f, 
    0.03348193f, 0.12724203f, -0.06126823f, 0.05902634f, -0.03842223f, -0.01084150f, 0.21242377f, 0.11825800f, 
    -0.04490749f, -0.03882752f, 0.16107786f, 0.12821086f, -0.01492282f, -0.01856472f, -0.04043457f, 0.10703868f, 
    0.14764725f, -0.05236314f, 0.46556661f, -0.06905019f, -0.10134013f, -0.02172617f, -0.13463940f, -0.08272850f, 
    -0.05779538f, -0.03596472f, -0.40256339f, 0.02063788f, -0.07428254f, 0.05063971f, 0.41527930f, 0.20620292f, 
    -0.08473451f, 0.14641042f, -0.07556067f, -0.02471466f, 0.21786012f, 0.09171513f, 0.06621038f, 0.05881456f, 
    -0.39888531f, 0.18137826f, 0.11569095f, -0.06566521f, -0.07927668f, -0.05335503f, -0.17023258f, -0.00316238f, 
    -0.12941095f, -0.11786579f, -0.02711811f, -0.00191661f, -0.07503890f, -0.17644437f, -0.34749374f, 0.01378920f, 
    0.09831644f, 0.02813268f, 0.05681669f, -0.03432035f, 0.00180174f, 0.03760756f, 0.02376000f, 0.03990627f, 
    -0.14839856f, -0.02241055f, 0.04773554f, -0.08924826f, -0.04060419f, -0.01588316f, 0.02029630f, -0.05518248f, 
    -0.01819285f, 0.09906943f, 0.05388911f, -0.16112651f, 0.08144717f, 0.17639571f, 0.17559648f, 0.08835802f, 
    -0.00306979f, 0.02274268f, -0.09880453f, 0.00445950f, 0.08736656f, 0.15525097f, 0.11286874f, 0.14279373f, 
    -0.08760742f, 0.11564024f, -0.05054404f, 0.15923440f, -0.07610255f, -0.06090131f, -0.06323042f, 0.07756652f, 
    0.01196797f, -0.13003506f, 0.07049444f, 0.06510131f, -0.12254511f, 0.03342297f, 0.08784810f, 0.23639503f, 
    -0.06077360f, -0.10026205f, 0.04331390f, 0.17765580f, -0.13037503f, -0.20043467f, 0.03905386f, -0.10087183f, 
    -0.05931464f, 0.25744659f, -0.04062473f, 0.05528415f, -0.06341738f, -0.01862200f, 0.10627597f, 0.08109852f, 
    -0.03002379f, 0.12375210f, -0.05666135f, 0.09509025f, -0.11199751f, 0.09760198f, -0.05174601f, 0.12687327f, 
    -0.04893791f, 0.14589341f, -0.21813174f, 0.02205057f, 0.01477433f, 0.01492954f, 0.07607421f, 0.03181887f, 
    -0.22009784f, -0.22379254f, 0.37319198f, 0.23449853f, -0.11585580f, 0.07123443f, -0.29688510f, -0.00467649f, 
    0.10413288f, -0.26399314f, -0.02918225f, 0.05799639f, -0.15599030f, -0.06108791f, -0.05942556f, -0.06974417f, 
    -0.00650079f, 0.07248969f, 0.20602873f, -0.20400026f, 0.01844510f, 0.08721235f, 0.00361619f, -0.23488557f, 
    -0.28515992f, 0.00197860f, 0.01482518f, 0.27281135f, -0.01450629f, -0.02268814f, 0.04801271f, 0.00356723f, 
    -0.22374547f, -0.10851389f, -0.04523339f, -0.14281002f, -0.15060388f, 0.25498018f, -0.03111864f, 0.11046629f, 
    0.01183240f, -0.02741453f, -0.29371417f, 0.11410718f, 0.09939718f, -0.07862096f, 0.16730814f, -0.06373464f, 
    -0.10107558f, 0.17961819f, -0.09759090f, 0.25729170f, 0.09504397f, -0.15810977f, -0.09404261f, 0.11386149f, 
    -0.16091324f, -0.35961124f, -0.20876089f, -0.30269179f, -0.19220535f, 0.53301185f, 0.04849480f, 0.07472733f, 
    0.14542603f, -0.04524745f, 0.04186183f, -0.05449855f, -0.02325047f, 0.06551538f, 0.06778698f, 0.07997428f, 
    -0.14315015f, 0.11011126f, 0.01055827f, -0.13755432f, 0.01621592f, -0.09194715f, 0.01352736f, -0.00884799f, 
    -0.04198982f, 0.05183814f, -0.01544970f, 0.01521852f, 0.21780428f, 0.07313437f, 0.23074540f, 0.04659414f, 
    0.01300753f, -0.01250278f, -0.13919963f, 0.04916187f, 0.03103462f, 0.11146665f, 0.15847331f, 0.06419050f, 
    0.13306442f, -0.22611861f, 0.04826478f, -0.48470736f, 0.03191549f, -0.39621410f, 0.05548831f, -0.04785033f, 
    0.02630216f, 0.06084619f, -0.05344082f, -0.07154286f, -0.16471693f, -0.28174946f, 0.05427603f, -0.06702317f, 
    -0.13435119f, -0.08813697f, -0.09470814f, -0.19957332f, 0.00803959f, -0.03862301f, -0.05504192f, 0.01117664f, 
    -0.04999496f, 0.17205374f, -0.08243858f, 0.05810544f, -0.11082692f, -0.05528485f, 0.14833775f, -0.28656459f, 
    -0.06822933f, 0.02516288f, 0.03836332f, -0.01226247f, -0.11917445f, -0.19322526f, -0.08596089f, 0.11472799f, 
    -0.14965761f, -0.05154785f, -0.13227816f, 0.10900527f, -0.01901401f, 0.03133920f, -0.01250136f, -0.04436041f, 
    0.46151176f, 0.00995488f, 0.26107594f, -0.22303386f, -0.02543543f, -0.05847613f, -0.05241253f, 0.04282152f, 
    -0.08688465f, 0.02601170f, 0.07844203f, -0.06108531f, -0.26262090f, 0.01989891f, 0.10163905f, 0.07164091f, 
    0.11233541f, 0.04402268f, 0.04275048f, 0.07931054f, -0.19065288f, 0.01892689f, -0.17429623f, 0.01986274f, 
    0.12950444f, 0.02015001f, -0.03545700f, 0.28915757f, -0.12331498f, -0.07091969f, -0.00025084f, 0.26600254f, 
    -0.11360572f, 0.01783578f, -0.11090972f, -0.07458135f, 0.30244851f, -0.28908989f, 0.46225011f, -0.28572065f, 
    0.00826240f, 0.02862144f, -0.17494336f, 0.07765546f, -0.04882405f, -0.00473123f, -0.04105363f, 0.08887228f, 
    -0.45833406f, -0.18434685f, -0.00724017f, 0.15167418f, -0.08262594f, 0.04715213f, 0.04344875f, -0.01009694f, 
    -0.14306213f, -0.04628061f, -0.05523014f, -0.00141385f, -0.27906239f, 0.05245243f, -0.14187224f, -0.14936076f, 
    -0.04994126f, 0.03532883f, 0.10435145f, 0.04903203f, -0.00312477f, 0.03852450f, 0.07344091f, -0.08229718f, 
    -0.29606420f, 0.31479663f, -0.16715774f, 0.03548902f, -0.04091946f, 0.02729124f, 0.00290768f, -0.04004565f, 
    -0.05826242f, -0.01734488f, 0.03646750f, 0.02135869f, -0.11069313f, -0.30663538f, 0.17105296f, -0.05719940f, 
    0.17704953f, -0.01880202f, 0.03619904f, -0.05680351f, 0.03034012f, -0.03300373f, 0.05325045f, -0.01503588f, 
    0.07227153f, 0.06818658f, -0.04942551f, -0.05482933f, -0.00692901f, 0.03137746f, 0.02247841f, -0.04042729f, 
    0.07963671f, 0.14348093f, 0.12033561f, 0.01613932f, 0.03446945f, 0.22193316f, -0.12747690f, 0.05143356f, 
    -0.21809055f, 0.07091887f, 0.07170895f, -0.01468159f, -0.01993086f, 0.03985824f, -0.00563782f, -0.01648724f, 
    -0.32334238f, -0.04641927f, -0.29566619f, 0.31376150f, 0.22743303f, -0.11209311f, 0.11912838f, 0.09312201f, 
    -0.00112183f, 0.07830331f, 0.20213556f, -0.02758826f, -0.02031670f, -0.26898283f, 0.09429189f, -0.17558554f, 
    0.02916627f, 0.03471465f, -0.08869716f, -0.00943870f, 0.01017522f, 0.07379536f, 0.04022272f, -0.08017755f, 
    0.04978455f, -0.07706935f, -0.13413772f, 0.04731814f, 0.12268971f, -0.14519230f, 0.10781679f, 0.09408247f, 
    0.04362330f, 0.08998322f, 0.00940875f, 0.07413036f, -0.44370511f, 0.12578480f, -0.29932663f, 0.30026406f, 
    -0.00335407f, 0.04496881f, 0.06057234f, 0.08626722f, -0.30163902f, 0.01217184f, 0.04832016f, 0.15428929f, 
    0.06725301f, 0.01151395f, 0.24783693f, -0.20309129f, 0.02491904f, 0.16873327f, -0.12982596f, 0.07017886f, 
    -0.03072131f, 0.13967630f, -0.00864153f, 0.13371871f, 0.00028376f, -0.10041227f, -0.04721789f, -0.11454050f, 
    0.03064692f, 0.06296668f, -0.05260256f, -0.05349953f, 0.09447970f, 0.15607192f, -0.02086400f, 0.16269894f, 
    -0.12038245f, 0.17158945f, -0.13147664f, 0.14456995f, -0.11769152f, 0.01109779f, 0.08714528f, -0.17086630f, 
    0.05245050f, -0.00724566f, -0.03319622f, -0.03750876f, -0.35264593f, -0.36395141f, 0.29479122f, 0.04963142f, 
    0.04941539f, -0.13997498f, -0.00487463f, -0.09853413f, -0.09965976f, 0.02973408f, -0.00518017f, -0.04234951f, 
    0.13872761f, -0.08131889f, 0.19192392f, 0.07862569f, -0.01897538f, -0.01006888f, 0.12596907f, 0.08387315f, 
    -0.06193312f, -0.03332031f, 0.05934433f, -0.01727787f, 0.00133663f, 0.08135463f, -0.04151610f, 0.04895380f, 
    -0.01990712f, 0.10618597f, -0.07224403f, 0.04269036f, 0.08824864f, 0.06032263f, 0.04946899f, 0.09018539f, 
    -0.15030937f, -0.20077598f, -0.00307328f, -0.00210879f, -0.06736220f, -0.04249715f, -0.23117982f, -0.16037688f, 
    -0.03019091f, 0.09603714f, 0.09355226f, -0.01078745f, -0.43050855f, -0.44716462f, -0.05045185f, -0.02851754f, 
    -0.17279845f, -0.06014208f, -0.16566846f, -0.13219345f, 0.02084557f, 0.03674976f, 0.06722859f, 0.14884453f, 
    -0.06738880f, -0.12733328f, 0.42866662f, 0.33412009f, 0.05106106f, -0.09965601f, 0.00021633f, -0.07896587f, 
    0.11819442f, 0.03207954f, 0.19773178f, 0.00307234f, -0.11970083f, -0.17661868f, -0.13376583f, 0.31306103f, 
    0.04765553f, 0.10819915f, 0.10861219f, -0.04998442f, 0.01725479f, -0.01121088f, 0.11421821f, -0.08765490f, 
    0.14942156f, 0.16986418f, -0.13749088f, -0.04347710f, -0.08322273f, 0.06364255f, -0.06199184f, 0.03313494f, 
    -0.11045753f, 0.01770820f, -0.06347494f, -0.17066027f, 0.28916726f, 0.07998402f, 0.13796556f, -0.20768616f, 
    0.05751780f, -0.01927514f, 0.04730323f, 0.17095549f, 0.06042479f, 0.16044042f, 0.11992262f, -0.00602130f, 
    0.14035229f, 0.13457732f, 0.04293616f, 0.25782496f, -0.05337165f, 0.09749414f, -0.11285555f, 0.07982598f, 
    -0.00406062f, 0.00248622f, 0.06454331f, 0.08395937f, 0.13904391f, -0.08683771f, 0.30600059f, -0.02907778f, 
    -0.06444833f, 0.07798796f, -0.05814354f, 0.11226156f, -0.02037400f, -0.14648603f, -0.08831513f, -0.19150707f, 
    0.07024881f, -0.00427198f, 0.24497257f, 0.09879866f, -0.00680715f, 0.00313470f, -0.06612135f, -0.11628903f, 
    -0.17870738f, 0.13088483f, -0.06312696f, -0.02610721f, 0.45911595f, 0.38158286f, 0.25527835f, -0.12503812f, 
    -0.08896919f, 0.03969340f, -0.14167094f, 0.04199943f, -0.05799687f, 0.00053014f, -0.07087240f, -0.04993894f, 
    -0.00486077f, -0.18792881f, 0.05395238f, -0.15062703f, -0.11461885f, -0.17335568f, 0.08306939f, -0.00725395f, 
    0.00775361f, -0.00935700f, -0.00759811f, 0.00768979f, -0.06391215f, 0.04048429f, -0.24942943f, -0.24954772f, 
    -0.07036158f, -0.12820686f, -0.00455559f, 0.01088989f, -0.00921705f, 0.04100589f, 0.00774556f, -0.04557363f, 
    -0.19363734f, -0.04002007f, -0.06720857f, 0.06606602f, 0.10604372f, -0.04804601f, 0.08529528f, -0.08286986f, 
    -0.11500649f, -0.11752506f, -0.18822281f, -0.06447266f, 0.06874996f, -0.03963895f, -0.23520456f, 0.19013420f, 
    0.14632374f, 0.05423523f, -0.06677980f, 0.06828857f, 0.01053807f, 0.03338880f, 0.12627219f, -0.19452645f, 
    -0.33581212f, -0.33793873f, -0.04869320f, 0.06695734f, 0.05068550f, -0.00054374f, -0.02408469f, 0.03580302f, 
    -0.01881237f, -0.07159847f, -0.01340268f, -0.00791585f, 0.15862612f, -0.02838941f, -0.07481334f, 0.15505895f, 
    0.05770544f, 0.06776332f, -0.06888102f, -0.07730266f, 0.09820244f, 0.03469759f, -0.01333755f, -0.02391213f, 
    0.12672037f, -0.17350987f, 0.20381327f, -0.12169152f, -0.08452961f, 0.02183239f, -0.07650468f, 0.02868377f, 
    -0.00681397f, -0.00719982f, 0.00597358f, -0.12424396f, 0.32180911f, -0.16013183f, 0.22582588f, -0.01986267f, 
    0.20004362f, 0.04804059f, 0.12236840f, 0.13047300f, -0.34639874f, 0.11684523f, -0.02482185f, -0.12491927f, 
    -0.51153946f, -0.33383355f, 0.03278444f, -0.20156822f, -0.11885642f, -0.04299591f, 0.09187788f, 0.03025979f, 
    0.03253693f, 0.13355297f, 0.05602254f, 0.01194518f, -0.36114368f, 0.04083110f, -0.36606860f, 0.16739550f, 
    0.12085903f, -0.00267223f, 0.04617058f, -0.06114295f, 0.00557327f, -0.08710642f, 0.02009884f, -0.16013451f, 
    0.52280849f, -0.08142522f, 0.36572155f, -0.01461537f, -0.05562496f, 0.15443812f, -0.08411035f, 0.06537564f, 
    -0.12739472f, -0.06630911f, -0.04908995f, -0.03901537f, 0.39489320f, -0.49534661f, 0.40772882f, -0.21753049f, 
    0.17998108f, -0.05227785f, -0.16841482f, 0.20277746f, -0.03690813f, 0.01769034f, 0.01550794f, -0.02322396f, 
    0.05939000f, 0.01771734f, 0.00880595f, 0.03772436f, -0.06091776f, 0.07516766f, 0.09370731f, -0.13580170f, 
    0.09473588f, 0.00704249f, -0.11023930f, 0.08340441f, -0.10664548f, 0.20717183f, 0.06869210f, 0.07392155f, 
    -0.01894745f, -0.10441514f, 0.13268912f, 0.09026078f, 0.10992182f, -0.02531474f, -0.14145719f, 0.06172722f, 
    -0.25184470f, 0.17580450f, -0.43648714f, 0.33781770f, -0.09807170f, 0.13096952f, 0.14143443f, 0.06573666f, 
    0.06199490f, 0.04440987f, -0.09264807f, 0.09270197f, -0.10243206f, -0.34342989f, -0.06383839f, -0.03000005f, 
    -0.03093386f, -0.08036758f, 0.01086549f, -0.07940392f, -0.05981898f, 0.02879266f, -0.01750860f, -0.02650488f, 
    0.08913205f, 0.12401976f, -0.13075830f, -0.37423688f, -0.04241830f, -0.13833869f, 0.21556407f, -0.02112236f, 
    -0.00736374f, 0.10837721f, 0.09912769f, -0.01370072f, -0.15271509f, -0.03865350f, -0.24069430f, -0.05957807f, 
    0.00236938f, 0.03594048f, -0.08234588f, -0.04000586f, -0.19181687f, -0.11777534f, -0.07777350f, -0.17264676f, 
    -0.07361452f, 0.14419794f, 0.05548619f, -0.04159167f, -0.12339941f, 0.00944471f, 0.00975104f, 0.02736873f, 
    -0.13255309f, 0.18344049f, 0.01116832f, -0.02470006f, -0.33035365f, -0.10336782f, 0.11813158f, 0.18584485f, 
    -0.01320000f, 0.00295532f, 0.07609007f, 0.03296982f, -0.12105449f, -0.11913499f, 0.02784878f, -0.12806356f, 
    -0.34719595f, 0.22576492f, -0.21665022f, -0.00486733f, 0.07379750f, -0.05457845f, 0.10477319f, -0.09561435f, 
    -0.14072636f, -0.01844243f, -0.07475725f, 0.21870779f, -0.01870794f, 0.01985641f, 0.11250119f, 0.06782509f, 
    -0.04626101f, 0.09788274f, -0.04549286f, 0.03691653f, 0.10889403f, 0.05796280f, -0.07899879f, -0.06527710f, 
    0.00422482f, 0.14129516f, 0.10303697f, -0.20237586f, 0.00544971f, 0.01779762f, 0.01581000f, 0.04324330f, 
    0.08944426f, -0.03482442f, -0.00173703f, 0.06825184f, 0.32615170f, -0.04861735f, 0.17874734f, -0.00078359f, 
    0.00905855f, 0.02657903f, -0.31808478f, 0.10627229f, -0.04129562f, 0.06858849f, -0.05731218f, -0.11637058f, 
    0.31326318f, 0.29441255f, 0.12714760f, -0.21116021f, -0.04925615f, 0.18767233f, -0.04989619f, 0.03177511f, 
    -0.04399963f, -0.00553401f, 0.14821690f, 0.01326324f, -0.13261066f, -0.21760069f, 0.15165336f, 0.36655730f, 
    0.06270078f, 0.05650114f, -0.06674356f, 0.20171116f, -0.15062121f, 0.05088576f, -0.07707068f, -0.00553850f, 
    -0.29854864f, 0.12938705f, 0.05662841f, -0.00301113f, -0.00833578f, -0.02818025f, 0.08244696f, 0.08080865f, 
    -0.13562569f, 0.05967614f, 0.17574726f, 0.02241544f, -0.54702836f, -0.12706214f, -0.27414930f, 0.25571898f, 
    0.18599413f, 0.09927706f, 0.00018749f, -0.10783241f, -0.09948317f, 0.03819054f, 0.07726768f, 0.14188311f, 
    -0.17555572f, -0.07866101f, -0.18153773f, 0.12772012f, 0.02578516f, 0.03928258f, -0.03469423f, 0.03558879f, 
    -0.06998546f, 0.01761284f, -0.05437379f, -0.05665050f, -0.12571922f, 0.00045684f, 0.20256327f, -0.08565439f, 
    0.07023122f, -0.03755664f, 0.17256756f, -0.07081401f, 0.05360351f, 0.03019819f, -0.06495025f, 0.06701031f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18942766f, 0.06405779f, 0.05518174f, -0.08810064f, -0.06501683f, 0.02998565f, 0.01481808f, -0.11122906f, 
    0.03690517f, -0.00188228f, -0.02292583f, -0.00137081f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
