#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.28304288f, 0.39046296f, 0.26996827f, 0.24308337f, 0.15695402f, -0.39911947f, -0.38259619f, -0.23669255f, 
    0.29955873f, 0.09184875f, -0.59892720f, -0.74487340f, 0.43077126f, 0.49961433f, 0.47918463f, -0.21441185f, 
    -0.21209317f, 0.01400761f, -0.18067336f, 0.06793903f, -0.61491311f, -0.32171932f, 0.95774561f, 0.12568188f, 
    0.01937851f, 0.11824545f, -0.31959748f, 0.76192260f, -0.20735672f, 0.45333719f, -0.49629951f, -0.23954137f, 
    -0.21530415f, -0.29852682f, -0.11920861f, -0.21556526f, -0.36802697f, 0.46442696f, 0.22216217f, 0.14271860f, 
    0.31741226f, 0.26411062f, 0.03710955f, -0.51170391f, -0.06536932f, -0.13258988f, 0.55126905f, -0.53356510f, 
    0.44589046f, 0.31404355f, -0.52832526f, -0.26971751f, -0.28743005f, -0.15410917f, -0.33558217f, -0.35743192f, 
    -0.26902831f, -0.51424235f, -0.50625938f, -0.24385142f, 0.35982904f, -0.32152015f, 0.24220195f, -0.20962144f, 
    0.66212809f, 0.07108416f, 0.09016775f, 0.20383376f, 0.49269399f, -0.00966538f, 0.08855750f, -0.01204538f, 
    0.80333489f, 0.44041014f, -0.48656765f, -0.10883686f, -0.10577381f, -0.42317393f, 0.00972251f, 0.16947685f, 
    0.03387621f, -0.13974729f, 0.02627436f, 0.24319200f, -0.07876060f, -0.14575626f, -0.31696674f, 0.34694183f, 
    0.54499596f, 0.03532438f, -0.30777603f, 0.46092945f, -0.13332286f, -0.57095873f, 0.02100155f, -0.49708325f, 
    0.33357900f, 0.29127771f, 0.43233505f, 0.63326895f, -0.56873035f, -0.50706559f, -0.31511432f, -0.34096238f, 
    -0.00511804f, -0.11634067f, 0.41596273f, 0.46347165f, -0.63793677f, 0.54718387f, 0.36843044f, -0.62539619f, 
    0.45246220f, -0.06353465f, 0.00656711f, -0.29746258f, 0.19811031f, -0.29373327f, -0.03218121f, -0.26450542f, 
    0.33974412f, 0.34951398f, 0.44237682f, 0.16531473f, 0.22678481f, 0.36754906f, 0.08117054f, 0.56969315f, 
    -0.15215388f, -0.28970167f, -0.02914126f, 0.21069233f, 0.43149868f, 0.14600764f, -0.53753090f, -0.81716740f, 
    -0.27700022f, 0.36796990f, 0.36522374f, 0.23701611f, -0.42389345f, 0.42881858f, 0.22297595f, 0.07027309f, 
    0.22397408f, -0.62152576f, 0.74726981f, 0.20423707f, -0.24003968f, -0.28820688f, 0.20169109f, 0.23586738f, 
    0.03454161f, -0.36227944f, -0.43395901f, 0.01740607f, 0.52995360f, 0.09054044f, -0.47959009f, -0.09733017f, 
    -0.20548280f, -0.06933206f, -0.54143256f, -0.19835201f, -0.58605045f, 0.28544459f, -0.17692228f, 0.07027769f, 
    -0.20815858f, -0.23810019f, -0.16247219f, -0.02195679f, -0.20971049f, 0.44851869f, -0.39431527f, -0.06893579f, 
    -0.24880591f, 0.48894513f, -0.22944115f, 0.48664990f, 0.96229708f, -0.59387982f, -0.36942384f, 0.69134241f, 
    0.17238335f, 0.57348543f, -0.25024056f, 0.27367321f, -0.48434743f, 0.31967399f, -0.19252799f, 0.27828532f, 
    0.08463926f, 0.43151394f, 0.37064007f, 0.37913945f, 0.00467094f, -0.06638796f, 0.33827794f, 0.74117422f, 
    -0.50845522f, -0.35357958f, -0.00392334f, 0.01114046f, 0.01350834f, 0.19831716f, 0.07552447f, 0.25789738f, 
    0.36755458f, 0.18872058f, 0.05299531f, 0.34974149f, -0.09188862f, 0.43081361f, -0.25299165f, 0.16496722f, 
    0.24619779f, 0.16670296f, 0.02352146f, -0.21604876f, 0.52648652f, -0.62837416f, -0.04829658f, -0.27737778f, 
    0.07862956f, -0.64722437f, 0.43918514f, 0.15089180f, 0.33363429f, -0.78265142f, -0.20304687f, -0.03883199f, 
    0.22411607f, 0.11752430f, -0.17847645f, -0.20979515f, 0.33067948f, -0.03062757f, -0.47734219f, -0.82852679f, 
    0.01122171f, -0.50803447f, -0.01394301f, 0.70824772f, -0.83175296f, 0.40745497f, 0.23171227f, 0.29230389f, 
    -0.10325861f, -0.13171341f, 0.17382233f, 0.29439193f, 0.21012004f, 0.02541290f, 0.68331826f, 0.18177980f, 
    -0.01216226f, 0.48013875f, 0.09381790f, -0.08992398f, 0.18748796f, 0.61062032f, -0.62821347f, -0.24417242f, 
    0.00214553f, -0.24219388f, -0.29727820f, -0.14769979f, -0.26367620f, -0.13096845f, 0.71876913f, -0.65254664f, 
    0.29642969f, -0.27662775f, 0.06042858f, 0.38512900f, 0.02498741f, -0.00789914f, 0.26863921f, 0.61286765f, 
    0.19119278f, 0.38897040f, -0.19631319f, -0.10985886f, -0.49292269f, 0.02801728f, 0.17345691f, 0.28888747f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00778099f, -0.06580007f, -0.13253900f, -0.01083434f, 0.29560706f, -0.04842980f, -0.22476465f, -0.12308032f, 
    0.08441308f, -0.15683407f, 0.05282001f, 0.03269094f, -0.01184273f, 0.32620928f, -0.03766489f, 0.06992555f, 
    -0.12292459f, 0.05987976f, -0.27671343f, -0.34231806f, -0.07597777f, -0.29837596f, 0.19935037f, -0.04344667f, 
    0.06294443f, 0.02266203f, -0.37889877f, -0.24436517f, 0.01886214f, 0.27045456f, 0.23150910f, 0.09761781f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.09593871f, -0.12672351f, -0.06281282f, 0.17039952f, 0.12076168f, 0.07957941f, -0.01488679f, -0.15729183f, 
    0.03471561f, 0.00166081f, -0.26800546f, -0.06727926f, 0.01032746f, 0.05322286f, -0.11216951f, -0.06044133f, 
    -0.15273537f, -0.09292878f, -0.05440581f, -0.00432400f, 0.13970667f, 0.10244550f, -0.01688121f, -0.16863988f, 
    -0.10269108f, 0.00469696f, -0.14126407f, 0.19524880f, -0.04450598f, -0.35052150f, -0.02797897f, 0.03244139f, 
    0.04015708f, -0.18399370f, 0.04349486f, -0.08249096f, -0.11381259f, -0.09135987f, 0.16549110f, 0.04129601f, 
    0.16839857f, 0.11335078f, -0.19643079f, -0.22043106f, -0.07289729f, 0.04464999f, -0.14006978f, 0.03738594f, 
    0.08748143f, 0.03048987f, 0.10510956f, -0.14744806f, -0.04630626f, -0.10610890f, 0.07028950f, 0.07590652f, 
    0.14549993f, 0.09604108f, 0.03171067f, -0.03073297f, 0.12005523f, 0.06823588f, -0.02835698f, 0.20266192f, 
    0.12944907f, 0.10030777f, 0.09998824f, 0.10038714f, 0.05506818f, -0.13037875f, -0.05845066f, -0.07103899f, 
    -0.05814908f, -0.28125045f, -0.12299927f, -0.03497184f, 0.01775425f, 0.07476662f, -0.10624079f, -0.09728347f, 
    -0.11517400f, -0.03719630f, 0.06117240f, -0.04371384f, -0.14565396f, 0.09227293f, -0.06775789f, 0.07111521f, 
    0.10682097f, 0.16739558f, -0.00659265f, -0.05490211f, -0.03875927f, 0.02839833f, 0.05161376f, 0.11620553f, 
    -0.01939558f, 0.14151837f, 0.07926460f, 0.07215554f, -0.13602300f, -0.19657744f, 0.02685651f, 0.11387846f, 
    0.04649246f, 0.03376986f, 0.10569850f, -0.01440255f, -0.10052264f, -0.13601992f, 0.28574055f, 0.22208126f, 
    0.06011609f, 0.10420713f, 0.01235521f, -0.07374849f, -0.02278901f, -0.01243151f, 0.02080129f, 0.17367376f, 
    -0.00196258f, -0.20849092f, -0.12333333f, 0.06819697f, 0.00288122f, 0.13772459f, -0.00384318f, -0.04800915f, 
    0.20300819f, 0.03687467f, 0.00247828f, -0.05741600f, 0.02680735f, 0.16486365f, 0.09655343f, 0.02136699f, 
    0.11773499f, 0.07301187f, 0.01573306f, -0.09110290f, -0.10818729f, -0.03562504f, 0.08526463f, 0.01279662f, 
    0.03382558f, 0.15698971f, -0.21328306f, 0.08659220f, -0.02940216f, 0.10971747f, 0.05237605f, 0.07190941f, 
    0.09713278f, 0.02016169f, -0.03658301f, -0.16010371f, 0.05987433f, 0.11334403f, 0.00136447f, -0.04140887f, 
    -0.07271739f, -0.12341505f, 0.19676523f, 0.18803617f, -0.06481717f, -0.09438647f, -0.01708597f, -0.21424496f, 
    0.01837295f, -0.02692130f, -0.16179383f, 0.10520050f, 0.05665995f, 0.17726402f, -0.01000870f, 0.09228244f, 
    0.14132905f, -0.14706267f, 0.14611234f, -0.01332184f, 0.13862926f, 0.01755833f, 0.17202720f, 0.09518394f, 
    -0.00096717f, 0.03685246f, -0.04397970f, -0.15313622f, -0.15154999f, -0.05179807f, -0.04728927f, 0.07079816f, 
    0.03687882f, -0.00941663f, -0.02413219f, -0.13990837f, -0.01686081f, 0.11061501f, -0.06276292f, -0.02372355f, 
    0.00682796f, -0.04599850f, -0.05297615f, 0.13939966f, -0.14101894f, -0.09782446f, -0.03781927f, 0.00938901f, 
    0.00477998f, 0.08737151f, -0.07961056f, 0.00469878f, -0.08897908f, -0.00681703f, -0.11965445f, 0.11595085f, 
    -0.17134386f, -0.08375427f, 0.02080249f, 0.07951942f, 0.01265141f, -0.00340858f, -0.08724921f, -0.12430383f, 
    -0.14105862f, 0.00339337f, -0.04120838f, 0.10611485f, 0.09515848f, 0.18451773f, 0.07636001f, 0.00747242f, 
    0.03425407f, -0.04962790f, 0.36243641f, 0.11376992f, -0.23851077f, 0.08184087f, 0.13597049f, 0.01742702f, 
    0.10686518f, -0.00478703f, -0.06110672f, 0.19786236f, 0.06944486f, -0.11278262f, -0.16842481f, 0.00686456f, 
    -0.08103720f, 0.03626822f, 0.20575605f, 0.09960426f, -0.00568409f, 0.04960312f, 0.03737067f, -0.02482042f, 
    -0.00876895f, 0.02853764f, -0.14155900f, -0.17476201f, -0.02810993f, 0.24868260f, 0.07919662f, -0.15036733f, 
    0.04705627f, 0.15978913f, -0.04988195f, 0.03941512f, 0.01455823f, -0.26031238f, 0.12060378f, 0.07133196f, 
    -0.04695180f, -0.03370947f, -0.03214972f, 0.02766265f, -0.04897946f, 0.03258473f, 0.03574130f, -0.03061146f, 
    -0.07313235f, -0.17085250f, -0.08655770f, 0.06487864f, -0.01475043f, -0.16739915f, -0.02212956f, 0.12602195f, 
    0.04163066f, -0.06287455f, -0.16528527f, -0.02736348f, 0.06292202f, 0.02814830f, -0.01338823f, 0.09064919f, 
    -0.20742208f, 0.21909781f, -0.31106931f, -0.56908822f, 0.12085257f, 0.08741170f, 0.12379472f, 0.08565815f, 
    0.02722135f, 0.17311832f, 0.08410131f, 0.01753589f, -0.17461284f, 0.00214607f, 0.12850945f, 0.18384577f, 
    -0.02451169f, 0.04434283f, -0.04865979f, 0.00520767f, 0.24528158f, 0.04619603f, 0.02152499f, -0.13026610f, 
    0.01579178f, -0.04800613f, 0.03053457f, -0.07761163f, 0.09090795f, 0.07467298f, 0.15061654f, 0.03959303f, 
    -0.00003239f, -0.01773768f, -0.05666251f, -0.05826361f, 0.01988903f, 0.01285802f, 0.05806062f, -0.16087905f, 
    -0.03569838f, 0.00174930f, -0.17686665f, -0.02816586f, 0.00991683f, -0.02211320f, 0.28720391f, 0.05849086f, 
    0.10029068f, 0.15502897f, -0.01016795f, 0.07711556f, -0.01134038f, 0.04793701f, -0.01798551f, 0.11875723f, 
    -0.07151672f, -0.64880121f, 0.09248897f, -0.17151052f, 0.10529859f, 0.04502589f, -0.05955439f, 0.04757617f, 
    0.00513172f, 0.03976418f, -0.24304329f, 0.04970393f, 0.03824258f, -0.03937806f, -0.06346520f, 0.07084919f, 
    0.03397918f, 0.30861616f, 0.14066266f, 0.16619258f, -0.01118943f, -0.07263021f, -0.03370693f, 0.15514754f, 
    -0.00797345f, 0.08531381f, 0.14859861f, 0.10125791f, 0.01946783f, -0.24691704f, -0.11016569f, 0.12406096f, 
    0.09966423f, 0.19625470f, -0.07697521f, 0.19843812f, 0.27507520f, 0.15888441f, 0.01583662f, -0.02116098f, 
    -0.05787577f, 0.00389959f, -0.07769206f, 0.16644095f, -0.10993405f, -0.02619987f, 0.23271610f, -0.14800309f, 
    -0.02537600f, 0.04105414f, 0.25651661f, 0.02454728f, -0.03757175f, -0.14026797f, -0.17333777f, -0.12298678f, 
    0.05327056f, 0.03073583f, 0.00842187f, -0.07630900f, 0.08632103f, -0.03151236f, 0.02718180f, -0.01645982f, 
    -0.51942044f, 0.06701028f, -0.03634722f, -0.02006073f, 0.06831465f, 0.05839801f, 0.08393404f, -0.00725390f, 
    -0.01791404f, 0.06737665f, 0.05050787f, -0.03803635f, -0.01433256f, 0.12629160f, -0.03887254f, -0.02736891f, 
    0.24893874f, 0.09622006f, -0.17728655f, -0.08254720f, 0.16032653f, 0.21991643f, 0.20388836f, 0.02056055f, 
    -0.02902374f, 0.20730588f, 0.00838636f, -0.21435013f, 0.04146906f, -0.07021608f, 0.08469354f, -0.06874377f, 
    -0.16295338f, 0.05593479f, 0.17929620f, -0.01651999f, 0.06013241f, 0.00011450f, -0.02897388f, 0.21686487f, 
    0.05024979f, 0.06261154f, 0.11047140f, 0.17513673f, 0.11422938f, 0.05338225f, 0.08937368f, -0.04961682f, 
    -0.00896723f, 0.07666392f, -0.05403312f, -0.03565622f, -0.33147690f, 0.31181160f, -0.25719541f, -0.09598394f, 
    0.01610701f, -0.13575020f, 0.07618130f, 0.06415775f, 0.04300344f, 0.17134111f, -0.26059687f, -0.40723342f, 
    -0.17765784f, -0.09692676f, -0.04562385f, -0.02987758f, -0.01671489f, -0.08641931f, 0.02130385f, -0.01812369f, 
    -0.62407583f, 0.13419442f, -0.07918512f, 0.03865129f, -0.00808086f, -0.04460564f, -0.01514690f, 0.01225569f, 
    -0.17994469f, -0.36512405f, 0.15437663f, -0.09158994f, -0.04561963f, -0.01900673f, -0.03807859f, -0.03435783f, 
    -0.13362958f, -0.32015708f, -0.05954192f, -0.14594011f, -0.14542930f, -0.02401395f, -0.03544619f, -0.04936262f, 
    -0.06526670f, 0.00465570f, 0.06662152f, 0.13720033f, 0.02965057f, -0.10670697f, -0.03531284f, 0.13380253f, 
    -0.02243199f, -0.12366443f, 0.38204232f, 0.15218842f, 0.06251577f, -0.06795975f, 0.06601219f, 0.09213592f, 
    0.06716041f, -0.10696010f, -0.13403489f, -0.11792672f, 0.52323806f, -0.51419282f, 0.04833975f, 0.14830673f, 
    0.05835809f, 0.11932340f, 0.04241111f, -0.00538080f, 0.21934663f, -0.68058354f, -0.67274439f, 0.07840489f, 
    -0.12654147f, -0.02292985f, -0.02025031f, -0.06885134f, -0.10087056f, 0.07890031f, 0.10202713f, 0.07845879f, 
    -0.00666643f, -0.00876766f, -0.07640097f, 0.05555944f, -0.09740487f, -0.05152017f, 0.02716025f, 0.15760386f, 
    -0.53381371f, -0.11133629f, -0.04128849f, -0.06188181f, 0.09516732f, 0.14130349f, -0.03801505f, -0.10639949f, 
    -0.15143980f, 0.10803759f, -0.08757822f, 0.03494537f, 0.11505469f, -0.00408773f, 0.00343866f, -0.00932599f, 
    0.00239376f, 0.09178520f, -0.07647622f, 0.10267922f, -0.09134934f, 0.00792398f, 0.11762869f, -0.05963077f, 
    -0.01463778f, -0.07675445f, -0.26184362f, 0.16691905f, 0.03405607f, -0.00749855f, 0.06002548f, -0.01912771f, 
    -0.02084980f, -0.03663410f, 0.16836013f, -0.35058546f, -0.10322811f, 0.10238910f, 0.01599569f, 0.09433066f, 
    -0.05777844f, 0.11260308f, 0.19942121f, 0.12432959f, 0.18074524f, 0.25180173f, 0.09497187f, 0.07143877f, 
    -0.06080429f, -0.02372441f, -0.06547842f, 0.08637287f, -0.00917977f, -0.03750987f, -0.11532452f, -0.01088349f, 
    0.11327297f, 0.06123938f, 0.09314115f, 0.15657026f, -0.02402355f, -0.07948261f, 0.05961084f, 0.02548110f, 
    0.03270693f, 0.17149961f, -0.07491142f, 0.04771902f, 0.12840551f, 0.12593721f, 0.06088540f, -0.24111702f, 
    -0.04042154f, 0.10669374f, 0.16234827f, 0.13469046f, -0.12861888f, -0.08073821f, 0.10340302f, -0.11941365f, 
    -0.09604669f, 0.07562920f, 0.02152274f, 0.05775448f, 0.02173840f, 0.03910993f, 0.08600890f, -0.02098320f, 
    0.05229203f, 0.27857786f, 0.27154413f, -0.04542084f, 0.18518735f, -0.19352977f, -0.06670180f, 0.10350711f, 
    0.01372994f, -0.13600776f, 0.09778934f, -0.13851684f, 0.04125491f, 0.06018218f, -0.01449775f, 0.16300876f, 
    -0.05514318f, 0.03241137f, -0.12986547f, 0.08129682f, -0.02699010f, 0.12094642f, 0.16017808f, -0.15046968f, 
    -0.00846975f, -0.01301079f, -0.13046774f, -0.04617576f, -0.19894405f, 0.29229367f, 0.06858966f, -0.03648893f, 
    -0.08867512f, -0.03688054f, -0.01574498f, -0.20562275f, 0.16395552f, 0.24245507f, -0.00294278f, 0.05317284f, 
    -0.04744974f, 0.05048308f, 0.12411569f, -0.02950112f, -0.10585555f, -0.06231262f, -0.08244052f, -0.13769640f, 
    -0.08059239f, 0.02911448f, -0.05297072f, -0.04150504f, -0.09383435f, -0.01182256f, 0.11815099f, 0.24249266f, 
    0.13096471f, 0.03421957f, 0.07869313f, 0.05749988f, 0.07004239f, 0.12186623f, -0.22457005f, 0.02526736f, 
    0.09750332f, -0.20443226f, 0.05255488f, 0.10856121f, 0.04638757f, 0.07473385f, -0.15534684f, 0.14022088f, 
    -0.08841027f, 0.24747890f, 0.12288684f, 0.09734529f, 0.01747016f, -0.03772282f, 0.05214270f, 0.09136206f, 
    0.10421565f, -0.13292485f, 0.10396427f, -0.23192814f, 0.09103272f, 0.00972058f, -0.06022317f, 0.07047667f, 
    -0.00527394f, 0.17217702f, 0.05853810f, 0.03086193f, -0.12044390f, -0.01431000f, 0.01336193f, 0.02127003f, 
    0.06167716f, -0.06505121f, 0.09390920f, -0.01732932f, -0.06037261f, -0.13334514f, 0.27912170f, -0.03730790f, 
    0.10727698f, 0.12662686f, -0.13729893f, 0.03069035f, -0.32472017f, -0.19803852f, 0.07680283f, 0.09652457f, 
    0.03111164f, 0.10160338f, 0.04419856f, -0.03145815f, 0.10611036f, -0.05881066f, -0.11611110f, 0.06683250f, 
    0.05347803f, 0.01381057f, 0.02723368f, -0.07033000f, -0.01948089f, 0.05802909f, -0.04899251f, 0.22647902f, 
    0.13446721f, -0.05016838f, 0.16209687f, -0.06613390f, -0.05558378f, 0.08739758f, -0.02619373f, 0.02656509f, 
    0.14837295f, -0.01954057f, 0.02162985f, -0.01612572f, -0.01847763f, -0.11570451f, 0.03633170f, 0.04344330f, 
    0.13612045f, 0.27773243f, 0.07356188f, 0.12889610f, 0.06047064f, -0.10820825f, -0.07110702f, 0.01345936f, 
    0.05942516f, -0.10121569f, 0.08624647f, 0.11931021f, 0.25734317f, 0.07593763f, -0.00229573f, 0.09839153f, 
    0.04880051f, -0.01585456f, -0.14418097f, -0.05811947f, 0.01688534f, 0.21641420f, 0.06204922f, -0.11519901f, 
    -0.14273734f, -0.09851266f, 0.10721482f, -0.02587767f, 0.12531750f, 0.30631673f, -0.05611784f, -0.19552384f, 
    -0.03699984f, 0.03314005f, -0.13639310f, -0.04255471f, 0.01668632f, 0.23260340f, 0.09185760f, -0.10332651f, 
    0.05988847f, -0.05949698f, 0.00101852f, 0.12801468f, 0.06430230f, -0.03693244f, 0.12099675f, 0.20277669f, 
    0.04751012f, 0.08356762f, 0.06080699f, -0.02093757f, -0.12548114f, 0.07775410f, 0.06178116f, -0.12955476f, 
    0.24999556f, 0.04027010f, -0.04240896f, 0.10662667f, 0.07983278f, -0.01656134f, 0.08221786f, 0.18657774f, 
    0.26524156f, 0.23401235f, 0.04237373f, 0.03128552f, -0.22178207f, -0.10094693f, -0.03957312f, -0.03477057f, 
    0.01369247f, 0.00324632f, 0.01645009f, 0.03337822f, -0.05947915f, -0.00010645f, -0.05123296f, 0.03981662f, 
    -0.03061390f, 0.01897071f, -0.02264296f, -0.02579511f, -0.05671420f, 0.00582124f, -0.05747230f, -0.03054627f, 
    -0.00580313f, -0.02384991f, 0.04172972f, -0.05070068f, -0.02122252f, 0.03840268f, -0.00241804f, -0.04222929f, 
    -0.05763408f, -0.03704407f, -0.05549198f, -0.06443775f, -0.00598594f, -0.04149631f, -0.02675257f, -0.01710082f, 
    0.00286747f, -0.00119488f, 0.02940858f, -0.06112400f, -0.04782007f, 0.02791452f, -0.01513160f, 0.02581340f, 
    -0.03315775f, 0.02735987f, -0.04992848f, -0.03542659f, 0.02666889f, 0.00064978f, -0.03175543f, -0.01222983f, 
    -0.01144272f, -0.02761781f, -0.03456192f, -0.05915109f, 0.01217890f, 0.01596391f, -0.05969792f, -0.06621732f, 
    -0.02199459f, -0.05668380f, -0.01445915f, -0.03302219f, -0.01425112f, 0.01832217f, 0.04628227f, -0.00674200f, 
    -0.05242561f, -0.03745552f, -0.02089871f, -0.04192749f, -0.03680850f, -0.04644386f, -0.04158356f, -0.04477126f, 
    -0.01567588f, -0.04198428f, -0.04066566f, 0.01670114f, 0.05004276f, -0.03095940f, -0.00366222f, -0.00383280f, 
    -0.05965694f, 0.04439656f, 0.01081190f, -0.04637657f, -0.05442514f, -0.06695659f, -0.03353171f, -0.03924906f, 
    -0.05767252f, -0.01787450f, -0.05205184f, 0.03439404f, 0.01929755f, -0.02586106f, 0.05085406f, 0.00512474f, 
    -0.04935879f, -0.03152348f, -0.03935761f, -0.01014695f, 0.00284922f, -0.05451138f, 0.00631276f, -0.00105377f, 
    0.02452055f, 0.04796379f, 0.04765802f, -0.00472850f, 0.00202231f, 0.05239420f, 0.00885725f, 0.03752498f, 
    -0.02400676f, -0.03615261f, 0.05446965f, -0.04486272f, -0.05926821f, -0.04517008f, 0.01070898f, 0.03086499f, 
    -0.03140681f, -0.01222647f, -0.01674831f, 0.04505896f, -0.06290396f, -0.00581982f, -0.06241499f, -0.02177967f, 
    0.03864348f, -0.04546424f, 0.00631199f, 0.03492792f, -0.02455445f, -0.04277755f, -0.04554815f, 0.02248373f, 
    -0.00477147f, 0.01857984f, 0.01628909f, 0.04232020f, -0.04822195f, -0.01743017f, 0.05212489f, -0.01847014f, 
    -0.04502719f, 0.05268496f, 0.04605613f, 0.03796703f, -0.01471735f, 0.01708112f, -0.06014398f, -0.00228352f, 
    0.00713174f, 0.03362028f, 0.03607021f, -0.02457570f, -0.03133324f, 0.05402106f, 0.03295983f, -0.03520926f, 
    -0.01468928f, 0.05419827f, -0.06402547f, -0.00113282f, 0.02154505f, 0.03582935f, -0.03443439f, -0.05256860f, 
    -0.01242643f, 0.04954373f, -0.03433374f, 0.02831687f, 0.04690757f, -0.05726105f, -0.04309757f, 0.01267704f, 
    -0.01398656f, 0.03896063f, -0.04594943f, 0.00262476f, 0.00981180f, -0.05537112f, 0.00602150f, -0.06014635f, 
    0.00003073f, -0.03314182f, 0.02940365f, 0.04986196f, -0.01944392f, -0.00507626f, -0.01291514f, 0.02455866f, 
    -0.05488431f, -0.02480254f, -0.05244904f, 0.04062741f, -0.01552074f, -0.01488060f, -0.03709479f, 0.02482279f, 
    -0.00287584f, -0.06089951f, 0.01372619f, -0.01057405f, -0.03405901f, 0.01610488f, -0.05132710f, 0.04636347f, 
    -0.05577243f, 0.00717930f, -0.01024873f, -0.04109454f, -0.00455287f, 0.00880338f, -0.05225420f, -0.03388300f, 
    -0.01738960f, 0.02454262f, 0.04409099f, -0.02049393f, 0.04085734f, 0.02296267f, -0.05740061f, 0.05273104f, 
    0.00137284f, 0.04170717f, -0.03321569f, -0.05847054f, -0.05878930f, 0.01667280f, 0.05301731f, 0.01121833f, 
    -0.01866870f, -0.01122606f, 0.02115679f, -0.03310666f, -0.02573537f, -0.00621349f, -0.03608059f, 0.02547461f, 
    -0.00733510f, 0.04166489f, -0.05178619f, 0.04676604f, -0.04052144f, -0.02439917f, 0.02052589f, 0.03885963f, 
    0.03377061f, -0.00130639f, -0.05409814f, -0.05776259f, -0.02565906f, 0.05545598f, 0.04787247f, -0.04637009f, 
    -0.03537658f, 0.03554614f, 0.04152198f, 0.04928371f, -0.04472562f, 0.03718014f, -0.00383275f, -0.00713493f, 
    0.01414242f, 0.04805006f, -0.01226512f, 0.01739199f, 0.03238285f, -0.01477519f, 0.00142020f, 0.01602455f, 
    -0.03795951f, -0.04667576f, -0.03333596f, -0.06449384f, 0.02011521f, -0.05824556f, -0.01046358f, 0.01677531f, 
    0.04184875f, -0.00029530f, -0.03234362f, 0.01547545f, -0.03364133f, 0.05448668f, -0.04908125f, -0.04945077f, 
    0.03797173f, -0.01061049f, -0.06354740f, -0.04962505f, 0.04191245f, -0.05561124f, 0.01374691f, -0.04514987f, 
    0.04414744f, 0.03769426f, 0.03188026f, 0.05117489f, 0.04017138f, -0.06677550f, 0.00169548f, -0.06337529f, 
    0.05209169f, -0.06169812f, 0.02731228f, -0.01850914f, 0.04727049f, -0.04079513f, 0.03779101f, 0.00282583f, 
    0.03254643f, 0.00084681f, -0.02855089f, 0.02281532f, 0.00072029f, 0.00348713f, -0.06048597f, 0.03175877f, 
    -0.04001883f, -0.06716185f, -0.05518314f, -0.04018494f, -0.05944851f, 0.03005964f, 0.03279924f, -0.02030053f, 
    -0.05047857f, -0.05777144f, 0.05219861f, -0.00994648f, -0.05768971f, -0.01330135f, 0.02544889f, -0.04165521f, 
    0.02034042f, -0.00250258f, 0.02909392f, -0.02212695f, -0.05501032f, -0.03578883f, -0.02244490f, -0.00518043f, 
    0.00545874f, 0.03215279f, -0.04756962f, -0.04922241f, -0.02575691f, 0.00020371f, 0.04608858f, -0.05107348f, 
    0.00487263f, -0.05440067f, 0.03014977f, 0.03615689f, -0.03551755f, -0.02384915f, -0.03903673f, 0.02098613f, 
    -0.02881271f, 0.02196089f, -0.02201395f, 0.03071492f, 0.02239371f, -0.06414757f, 0.03013749f, -0.04931644f, 
    0.02438105f, -0.05350917f, 0.03240130f, 0.00754630f, -0.01256577f, -0.06999327f, 0.04148893f, -0.01667795f, 
    -0.02920308f, 0.01485877f, -0.03704893f, -0.00085059f, -0.06515647f, -0.00038684f, -0.01302426f, 0.02308397f, 
    -0.04053159f, -0.00227238f, 0.02467560f, -0.04095082f, 0.04261420f, 0.00321538f, -0.04196449f, -0.00994361f, 
    -0.04465190f, -0.04067072f, -0.06177902f, 0.02077622f, -0.01476731f, -0.03673288f, -0.03548463f, 0.01529571f, 
    0.00254404f, -0.05750963f, -0.03979405f, -0.01489833f, 0.04765943f, -0.01341385f, 0.02536515f, 0.00799423f, 
    -0.05605338f, -0.05780961f, 0.04940494f, -0.01849904f, -0.01927515f, -0.03985909f, 0.04107159f, -0.03918265f, 
    -0.04151919f, -0.04473432f, -0.03687093f, -0.02518901f, -0.04402301f, 0.01714198f, -0.02474119f, -0.04257707f, 
    0.02842571f, 0.04264467f, -0.04458426f, -0.01775392f, 0.04053902f, -0.03508247f, -0.05126769f, -0.01668474f, 
    0.03177572f, 0.02212769f, 0.00683124f, -0.05227929f, -0.04205070f, -0.01287470f, -0.04627345f, -0.05021568f, 
    0.02359982f, 0.04873120f, -0.03608388f, 0.01250403f, 0.00014528f, 0.04152857f, 0.01317312f, -0.05684502f, 
    -0.03352519f, -0.01950398f, -0.06531145f, 0.02815414f, -0.04463373f, 0.01859747f, -0.02768366f, -0.01326844f, 
    -0.00737357f, -0.01303393f, -0.06444952f, -0.05235036f, 0.06200318f, -0.02076262f, -0.01250141f, -0.00731700f, 
    0.03551790f, 0.01159802f, 0.00697920f, 0.01990635f, -0.04631258f, -0.00021807f, -0.01188377f, -0.02189799f, 
    0.00939016f, -0.04075154f, 0.02381620f, 0.04053307f, 0.00152024f, -0.04642257f, -0.04288782f, -0.02306840f, 
    -0.00294853f, 0.01897200f, 0.00114622f, 0.04908502f, -0.03266051f, 0.03958684f, -0.02576958f, 0.04614690f, 
    -0.03516021f, -0.05223683f, 0.05152607f, -0.01130135f, -0.01645555f, 0.01657282f, 0.03972377f, -0.04117458f, 
    -0.04956505f, -0.01686895f, -0.03899920f, -0.05557758f, -0.05957054f, -0.05338631f, 0.02657775f, -0.02270508f, 
    -0.03103938f, 0.00700654f, 0.05205068f, -0.04189089f, 0.02596416f, -0.01859819f, 0.04365519f, -0.06271993f, 
    0.02959506f, -0.04207391f, 0.03533657f, 0.03573995f, 0.01915806f, 0.02501176f, 0.02313829f, -0.01751667f, 
    0.00099212f, -0.04103724f, -0.01445573f, 0.04734777f, -0.03138699f, 0.03833481f, -0.03919984f, 0.02885701f, 
    -0.03131306f, 0.04161177f, -0.00605146f, 0.04538713f, 0.05214708f, 0.00797942f, -0.04776019f, -0.00367305f, 
    0.00428915f, -0.04173740f, 0.02704835f, 0.04415773f, -0.04955392f, -0.03648315f, 0.05065207f, 0.04914371f, 
    0.01027453f, 0.00635570f, 0.01769685f, -0.00992235f, -0.01907847f, 0.02250807f, -0.05267160f, 0.01873769f, 
    -0.02981585f, 0.00658058f, -0.00398988f, -0.01211185f, -0.06069801f, -0.00453898f, -0.01178411f, 0.01096092f, 
    0.02103518f, -0.00211696f, 0.00815642f, 0.02006010f, 0.04680489f, -0.00438295f, 0.02945061f, 0.03635233f, 
    -0.00909730f, -0.05749011f, -0.02773467f, 0.01634730f, 0.04733881f, -0.03812604f, 0.02571561f, -0.02099617f, 
    -0.05322343f, -0.00975963f, -0.02002012f, -0.00947001f, -0.05526126f, -0.06631558f, -0.05782218f, 0.00202791f, 
    0.00560527f, 0.01756572f, -0.04846537f, -0.04814440f, 0.00654600f, 0.05199406f, -0.04339501f, 0.01071016f, 
    -0.01861227f, -0.04288819f, -0.04736711f, 0.02906730f, -0.01103344f, -0.00593036f, 0.02427095f, 0.01051522f, 
    -0.01287489f, 0.05992795f, -0.03699687f, -0.03298160f, -0.05308206f, 0.03404479f, 0.03166511f, 0.00104767f, 
    0.04771687f, 0.04261373f, -0.00247168f, 0.00967530f, 0.03967840f, 0.00252282f, -0.02370746f, -0.01339262f, 
    0.01846993f, 0.00742795f, 0.01694293f, -0.05065700f, 0.00428240f, -0.04764339f, 0.01298250f, -0.01710504f, 
    0.02478642f, 0.01197891f, 0.01573029f, -0.04109993f, -0.04271589f, -0.06880077f, -0.00650082f, 0.00616684f, 
    0.03426462f, -0.04332822f, 0.01457983f, -0.00097987f, -0.00000417f, 0.04084139f, -0.04901234f, 0.01842309f, 
    0.01282141f, 0.04489539f, -0.02460046f, 0.04813826f, 0.03018275f, -0.05633606f, 0.03553413f, 0.00566653f, 
    0.02781558f, -0.01314524f, -0.00192809f, -0.00842091f, -0.05311557f, -0.01795575f, -0.00686838f, 0.03388901f, 
    0.00974521f, 0.00807004f, 0.02963632f, -0.03276994f, -0.05332813f, 0.04333901f, 0.02121175f, -0.06602753f, 
    -0.00910307f, 0.05278618f, 0.05292061f, -0.03273632f, -0.00260238f, -0.04740459f, -0.00659193f, 0.03983530f, 
    -0.05388161f, 0.04110284f, -0.00857775f, 0.01077758f, 0.01778457f, 0.01882205f, 0.02846986f, -0.05639017f, 
    0.01399644f, -0.02949036f, -0.04479562f, -0.01342465f, -0.04880359f, 0.00367407f, -0.01828895f, -0.00102612f, 
    0.05281234f, -0.01769949f, -0.00759601f, -0.04879615f, 0.00953451f, -0.04864658f, -0.02255145f, 0.04839320f, 
    -0.04400774f, -0.01555937f, 0.03245283f, 0.05358189f, -0.04436817f, 0.03783652f, -0.03909790f, -0.01571547f, 
    -0.02742686f, 0.02334059f, 0.03041920f, -0.01382988f, -0.00655313f, 0.03531300f, -0.03493970f, 0.02834659f, 
    -0.05855322f, -0.00122188f, -0.06251871f, -0.04007080f, 0.03301724f, 0.04117126f, 0.03635791f, 0.02548260f, 
    -0.06239175f, 0.00503523f, 0.02674804f, -0.01615444f, -0.06007069f, 0.04821432f, -0.04255155f, -0.04934953f, 
    0.00029938f, -0.04496011f, 0.02708708f, 0.04345069f, 0.03464947f, -0.03328046f, 0.03018662f, -0.05465820f, 
    0.03420554f, -0.05325993f, -0.04542570f, -0.03801674f, 0.06203248f, -0.04114022f, -0.01596998f, 0.05261404f, 
    -0.07228097f, -0.06484492f, -0.04478068f, -0.03516027f, -0.01307584f, 0.03541636f, 0.05489635f, -0.00628752f, 
    -0.02914422f, -0.01514081f, 0.02413441f, 0.05094700f, 0.03510369f, 0.02983373f, 0.02884024f, -0.02971387f, 
    0.00782393f, -0.01724266f, -0.02764723f, -0.04121256f, 0.00875664f, 0.01914298f, 0.03478200f, 0.02145533f, 
    -0.03007871f, -0.00273513f, -0.01004306f, 0.00538144f, -0.03093718f, 0.00140070f, -0.06138855f, 0.04776503f, 
    -0.05718481f, 0.03635446f, -0.00497368f, -0.04760233f, -0.05078062f, -0.04094671f, -0.02682298f, -0.02681678f, 
    -0.00046426f, -0.05042257f, -0.01281687f, -0.00920382f, -0.01125954f, -0.06248901f, -0.05046690f, -0.00170020f, 
    -0.04460141f, -0.01646152f, -0.05847926f, -0.00891238f, -0.05221987f, -0.00706172f, -0.03692035f, 0.05041207f, 
    0.05144768f, -0.03886906f, 0.03441599f, 0.00901435f, 0.00215970f, -0.03705348f, -0.05208625f, 0.02438161f, 
    0.04570634f, 0.01202996f, -0.02716853f, -0.04504417f, -0.04921602f, -0.03382065f, -0.01740036f, -0.01100990f, 
    0.03548353f, -0.03751075f, -0.05158069f, -0.02723320f, -0.01198709f, 0.04575478f, 0.01266132f, 0.01123451f, 
    0.03189799f, 0.03122765f, -0.02269821f, -0.03926087f, -0.03888396f, 0.03126494f, -0.05408750f, -0.01656846f, 
    -0.01685892f, -0.04137835f, -0.03925745f, -0.05916133f, -0.05751614f, -0.04456231f, 0.01859578f, 0.02730459f, 
    -0.05097632f, 0.03835575f, 0.00038003f, 0.02312866f, 0.04222491f, -0.02136757f, -0.03369600f, 0.01948118f, 
    -0.02317733f, 0.00609092f, -0.05149212f, 0.00572876f, 0.02785800f, -0.05881136f, 0.01378762f, -0.01594603f, 
    0.00638730f, -0.04880435f, -0.00461425f, -0.06097578f, 0.03737740f, -0.05295253f, 0.05373342f, -0.02584547f, 
    -0.37789443f, -0.20404188f, 0.03888562f, -0.03044700f, -0.03508066f, 0.10929222f, 0.02664048f, 0.16479297f, 
    -0.08604676f, -0.06295493f, 0.09939998f, -0.00713460f, -0.12493184f, 0.02365446f, -0.20914219f, -0.07616380f, 
    -0.01859018f, -0.01847353f, -0.39319250f, -0.16176881f, 0.03282999f, -0.01233794f, 0.11922739f, -0.10271987f, 
    0.01703199f, 0.07867154f, 0.15171887f, -0.00383055f, -0.57322335f, -0.27172649f, 0.05503118f, 0.17906775f, 
    0.09968628f, 0.03132057f, 0.00552322f, -0.06597955f, -0.20076939f, 0.22673577f, -0.12743883f, -0.00860126f, 
    -0.14958811f, -0.04971442f, 0.01878800f, -0.03073333f, 0.19762269f, -0.08797403f, 0.04653337f, -0.02469793f, 
    -0.09358142f, 0.07942684f, 0.02903691f, -0.10059786f, -0.03661326f, 0.03537037f, -0.10761379f, 0.04371172f, 
    0.12525485f, 0.05148173f, 0.02449252f, 0.04290877f, 0.10107110f, 0.02557615f, 0.03373974f, -0.22751424f, 
    -0.09481611f, -0.02609736f, -0.12698397f, -0.14748178f, -0.00235128f, 0.01763562f, 0.03732995f, 0.09968644f, 
    0.48139367f, -0.11798764f, -0.35773453f, 0.14115082f, 0.19290167f, -0.01117552f, 0.19368543f, 0.03505376f, 
    0.02359775f, -0.09163011f, -0.11704747f, 0.02198484f, 0.02557060f, 0.10425286f, 0.13517810f, 0.11008927f, 
    -0.01181660f, 0.00209734f, -0.07737411f, 0.09377895f, -0.17512463f, 0.08543196f, -0.03689895f, 0.07159345f, 
    0.18337423f, 0.05500436f, -0.08104417f, 0.26905167f, 0.09442086f, -0.19101837f, -0.01027169f, 0.03115277f, 
    -0.19954097f, 0.00023101f, -0.04512683f, 0.07169858f, -0.38789603f, -0.26726711f, -0.27597392f, 0.08907016f, 
    -0.09720413f, 0.04945043f, 0.00726916f, 0.25099459f, 0.07411674f, -0.03037267f, 0.20362194f, 0.16145210f, 
    0.02266885f, -0.09362289f, 0.02018423f, 0.17704126f, 0.12174730f, 0.20404926f, -0.00892524f, -0.13189504f, 
    -0.32009920f, -0.02977915f, 0.02016423f, 0.03885800f, 0.19454664f, -0.09815799f, 0.19073170f, -0.43132964f, 
    -0.19671202f, 0.11021574f, 0.00749785f, 0.15321383f, -0.15458317f, 0.03202656f, 0.04288894f, 0.05333715f, 
    0.15028484f, -0.41010627f, -0.16865313f, 0.08529211f, 0.09243508f, -0.03750159f, 0.19001567f, 0.04875614f, 
    0.22111064f, -0.03650611f, -0.09906038f, -0.04851746f, -0.11564424f, 0.04574238f, -0.02187187f, 0.00399250f, 
    -0.00224754f, -0.09726127f, 0.10789945f, -0.11136720f, 0.00890350f, -0.00906692f, 0.15420607f, -0.06618833f, 
    -0.15636118f, -0.08115797f, -0.04755394f, 0.14249802f, -0.48856282f, -0.23054898f, -0.04547216f, -0.09756569f, 
    -0.09026835f, -0.03564266f, 0.04066512f, -0.11781559f, -0.06820713f, 0.02130938f, -0.12654124f, 0.06540794f, 
    -0.08929487f, 0.00623282f, -0.01790716f, 0.06923138f, 0.03120349f, 0.02841222f, 0.06476273f, -0.11872361f, 
    -0.06720980f, -0.09683016f, 0.05579540f, 0.02352975f, 0.05120431f, 0.09137873f, 0.25235114f, 0.09539770f, 
    -0.26864576f, 0.05771218f, 0.13463859f, 0.10995074f, -0.00622305f, 0.02933135f, 0.04164075f, -0.06067532f, 
    -0.09111676f, 0.05799093f, 0.03060934f, -0.15342741f, 0.07721277f, 0.13038547f, 0.07476395f, -0.05503311f, 
    -0.19552264f, -0.49069318f, -0.02786910f, 0.16986217f, 0.06016751f, 0.03935836f, 0.08091161f, 0.13165058f, 
    -0.00347614f, -0.50867188f, -0.16472369f, -0.33451983f, -0.23305817f, 0.04914313f, 0.12739350f, 0.11267008f, 
    -0.04153277f, -0.05839666f, -0.01626831f, -0.28871933f, -0.17715850f, -0.06043439f, 0.06671936f, 0.10288281f, 
    0.11249477f, 0.16368458f, -0.09392066f, -0.07045777f, -0.13926464f, -0.07324602f, -0.03135265f, -0.03369696f, 
    0.08387800f, -0.03273499f, -0.10810021f, 0.17465830f, -0.12344743f, 0.08501336f, -0.15756321f, -0.04153145f, 
    0.09113125f, -0.05450339f, -0.02216658f, 0.08443192f, 0.04877109f, 0.01592237f, -0.27179262f, -0.17194988f, 
    0.06662659f, 0.08376694f, -0.05284009f, 0.09843778f, -0.09291939f, 0.03526081f, 0.27364671f, 0.14874898f, 
    0.06725456f, 0.05486739f, 0.02961659f, -0.01854668f, 0.03208473f, -0.05580503f, 0.08142224f, 0.46427792f, 
    -0.25023481f, -0.12830767f, 0.11010917f, 0.13195729f, 0.00211217f, 0.10723056f, 0.12202508f, 0.07016000f, 
    -0.07572553f, -0.11545167f, 0.01453634f, 0.13139264f, 0.17306696f, 0.04224125f, 0.05308720f, -0.07523786f, 
    -0.14814456f, -0.00113112f, -0.05631722f, -0.07183854f, 0.04980532f, -0.19947888f, -0.01521956f, 0.06961139f, 
    -0.03882499f, -0.20723122f, 0.12309901f, 0.06020462f, 0.13683027f, 0.00647196f, -0.26263854f, -0.00051278f, 
    -0.09122672f, -0.11379152f, -0.22522204f, -0.23818551f, -0.12037709f, 0.19938898f, 0.02216980f, 0.07154473f, 
    0.04538773f, -0.05530579f, -0.11839022f, -0.05918056f, -0.04961545f, -0.03707862f, -0.00922722f, 0.00092042f, 
    -0.03595819f, 0.05128624f, 0.05658162f, -0.13008264f, -0.04187282f, 0.13883811f, 0.04813033f, 0.09579122f, 
    -0.00240226f, 0.02614588f, 0.00038568f, -0.13088901f, -0.09864645f, -0.15130457f, 0.10798221f, 0.10516400f, 
    -0.02696727f, 0.07454599f, -0.00723012f, 0.19435807f, 0.03425889f, 0.05088191f, -0.22688450f, 0.05090443f, 
    0.11038337f, -0.12099554f, 0.10062169f, 0.12695366f, 0.19869545f, 0.10265287f, -0.08763734f, -0.05260790f, 
    -0.33631366f, -0.16895288f, 0.00220023f, -0.08906530f, 0.00083195f, 0.06245008f, 0.00823510f, 0.07449979f, 
    0.05836090f, 0.04618975f, 0.12373924f, 0.01696555f, -0.04191680f, -0.10051552f, -0.05164721f, -0.02290909f, 
    0.06184402f, 0.03960035f, 0.15131943f, 0.14585257f, 0.14441091f, -0.05870603f, 0.03545513f, 0.11222874f, 
    0.03458399f, 0.11880188f, 0.06180421f, -0.02816683f, -0.08766399f, 0.14187218f, -0.04524264f, 0.16718601f, 
    0.08665797f, 0.17663036f, -0.05624631f, -0.01092777f, -0.14910391f, -0.01482878f, -0.00713235f, 0.12418047f, 
    0.03419373f, -0.12178896f, 0.05862409f, 0.11598715f, -0.14924842f, -0.00851019f, -0.00303323f, 0.01596430f, 
    0.14393637f, 0.03108675f, 0.08549217f, -0.03591684f, 0.02366559f, -0.02339098f, -0.08415473f, 0.11285473f, 
    0.01459797f, -0.02069777f, 0.03727589f, 0.02725647f, 0.04429057f, 0.06242306f, 0.06076641f, -0.14814237f, 
    -0.00171318f, 0.25463805f, -0.01101097f, 0.05100814f, -0.05651787f, -0.15514912f, 0.05542962f, 0.10755620f, 
    0.09222297f, 0.02707042f, 0.10885259f, -0.17255223f, 0.17767176f, -0.12777415f, 0.10931896f, -0.02141871f, 
    0.00987374f, 0.05861508f, 0.06676309f, 0.12959547f, 0.04585885f, 0.14206032f, -0.07591715f, -0.08179628f, 
    -0.14503127f, -0.07341143f, -0.02231349f, 0.17721084f, 0.09438218f, 0.01847409f, 0.03188470f, 0.06288174f, 
    0.16524351f, 0.01068068f, -0.00103514f, 0.20181769f, 0.19269775f, 0.04420772f, -0.18138662f, 0.19038987f, 
    -0.00052517f, 0.03112642f, 0.25880152f, 0.05555461f, -0.03577179f, -0.11281017f, 0.12875737f, 0.05859690f, 
    -0.04428246f, 0.00157643f, 0.01381288f, 0.01312558f, -0.14187676f, 0.02355456f, 0.05173573f, 0.00799579f, 
    0.18191773f, 0.23259078f, 0.20468085f, -0.00911126f, 0.07229371f, 0.01879586f, -0.09077664f, -0.04934404f, 
    0.00281695f, -0.03760601f, 0.02186267f, 0.04538927f, 0.04022203f, 0.08440136f, 0.04374984f, 0.01306551f, 
    -0.04633650f, -0.07231422f, 0.05656233f, 0.03393231f, 0.14986011f, 0.02743710f, 0.05852909f, 0.10949919f, 
    -0.08995540f, -0.20863549f, -0.07930930f, 0.06697213f, -0.02396540f, 0.04138854f, -0.05705296f, 0.07329199f, 
    0.01312509f, 0.02012348f, -0.10336183f, 0.14116083f, 0.02680474f, 0.17416029f, -0.02060089f, 0.11219303f, 
    0.08489069f, -0.11747508f, -0.01597698f, 0.05609712f, -0.09032381f, 0.06935798f, 0.17419647f, 0.06738472f, 
    0.06886023f, -0.18331514f, -0.36513469f, -0.05435082f, -0.08791514f, -0.03979945f, 0.06926911f, 0.11418715f, 
    0.15877287f, 0.11900485f, -0.02179416f, -0.00665369f, -0.09789887f, -0.04629805f, 0.09547202f, 0.01120074f, 
    0.02280182f, 0.13047248f, 0.09525402f, -0.03624984f, 0.08046869f, 0.03634715f, 0.02154374f, -0.06289668f, 
    -0.06948632f, 0.09750147f, 0.09945903f, 0.02746103f, -0.06188347f, -0.15861377f, 0.01442233f, -0.01885900f, 
    -0.04173373f, 0.05237227f, 0.04978974f, -0.06445000f, 0.15068044f, -0.11257016f, 0.12536946f, -0.20357475f, 
    -0.05430470f, -0.07804979f, 0.08414938f, 0.03027100f, 0.13118753f, 0.08548546f, -0.00594164f, 0.09472568f, 
    -0.05163382f, -0.10179000f, 0.12281226f, -0.07438257f, 0.07943170f, -0.00875428f, 0.07315629f, -0.06588060f, 
    0.24494828f, -0.42727804f, -0.15283166f, -0.14833844f, 0.05090476f, 0.05738228f, -0.15592268f, 0.01173066f, 
    0.02738918f, -0.06148379f, -0.49337775f, 0.27510610f, 0.19579664f, 0.10805975f, -0.14040135f, -0.04166306f, 
    0.18034504f, -0.09618641f, 0.01240678f, 0.16053283f, -0.06475791f, -0.15317807f, 0.05242879f, 0.12698649f, 
    -0.09178789f, 0.17342392f, 0.03895859f, -0.04940717f, 0.00166540f, -0.07650341f, -0.07467671f, -0.12890592f, 
    -0.05256103f, 0.00084830f, 0.07216790f, -0.01004448f, 0.06640427f, 0.12031678f, 0.08744512f, 0.12184513f, 
    -0.10724163f, 0.06761999f, 0.03185705f, 0.11680052f, 0.03707466f, 0.05550850f, -0.25095984f, -0.01588832f, 
    0.25482443f, -0.15976182f, -0.07975360f, -0.01506085f, 0.08150833f, -0.10292022f, -0.08228780f, 0.24832107f, 
    0.10988028f, -0.21382381f, -0.27105358f, -0.46823332f, -0.21518560f, 0.03543644f, -0.00007239f, 0.05627684f, 
    0.05848046f, -0.10723218f, -0.24797404f, 0.12288309f, 0.00059788f, -0.00604023f, 0.08580855f, 0.11225046f, 
    0.13021526f, -0.12354061f, 0.06493001f, 0.23193592f, 0.05519377f, 0.03695642f, -0.03357946f, -0.05060691f, 
    0.01341987f, 0.09610002f, -0.23089783f, -0.16564317f, 0.08898223f, 0.02641620f, 0.02554904f, -0.04821159f, 
    0.06520073f, -0.12054090f, -0.02162364f, -0.06440112f, -0.25407678f, -0.18710485f, -0.12228714f, 0.05403468f, 
    -0.02631106f, 0.10291858f, -0.13059704f, 0.04089149f, -0.13761596f, -0.26244438f, 0.18549187f, 0.04320560f, 
    0.08499332f, 0.03264184f, -0.00328521f, 0.05939316f, 0.09385814f, 0.05739394f, 0.07710376f, -0.16736266f, 
    -0.04149400f, -0.01535514f, 0.08850953f, 0.15843730f, 0.02734456f, 0.03614306f, 0.24122429f, -0.07219213f, 
    0.07778160f, -0.06887449f, -0.19078754f, -0.11612009f, -0.04688531f, -0.05069434f, 0.06701985f, -0.00748059f, 
    -0.02246842f, 0.02243562f, -0.05541925f, -0.03080418f, 0.07334729f, 0.10330391f, 0.11273585f, 0.04123487f, 
    0.00323253f, -0.01166863f, -0.19101086f, -0.06257422f, -0.07743919f, 0.11227856f, -0.06476638f, 0.20417258f, 
    0.15240926f, -0.12716679f, 0.10098320f, 0.19842407f, -0.01482913f, 0.07679498f, -0.06248175f, 0.16308671f, 
    -0.02165477f, -0.04705968f, -0.29440713f, 0.12406105f, -0.03136478f, -0.12017860f, -0.06020844f, 0.06227272f, 
    0.15132028f, -0.01800674f, 0.01811163f, -0.22723162f, 0.34640470f, 0.13687815f, -0.16379857f, -0.09261230f, 
    -0.18791929f, -0.08330576f, 0.02545388f, 0.02201019f, 0.31031287f, 0.10865325f, 0.06010743f, -0.08530378f, 
    -0.06890326f, 0.06162809f, -0.03353531f, -0.05709687f, 0.09679975f, 0.13144942f, 0.02204344f, 0.09864938f, 
    -0.39802518f, -0.44740674f, -0.01194989f, 0.03174310f, -0.07944382f, 0.16464418f, 0.14673391f, -0.24605531f, 
    -0.13004500f, 0.03922934f, -0.00362048f, 0.14134279f, 0.02508547f, -0.00722308f, 0.05912258f, 0.06795244f, 
    -0.01044965f, 0.11928667f, -0.14996904f, -0.15025030f, -0.08183440f, -0.05823769f, 0.06250454f, 0.07170463f, 
    0.00448404f, -0.00191553f, 0.32686272f, 0.00649861f, -0.00214201f, -0.12506905f, -0.01644876f, -0.02304918f, 
    0.08844980f, -0.34223014f, -0.05901242f, 0.33945972f, 0.01462901f, -0.10935280f, -0.03314595f, 0.07246082f, 
    0.14748375f, -0.01192705f, -0.12742251f, 0.18765271f, -0.06233041f, -0.08418046f, -0.09767137f, -0.18469101f, 
    0.23204729f, -0.02826358f, 0.22379759f, 0.27905613f, -0.01117877f, -0.00142151f, -0.21716730f, -0.01603601f, 
    0.13112098f, 0.00139253f, 0.05733078f, -0.01373515f, 0.13615108f, 0.04304446f, 0.04965578f, -0.15180270f, 
    -0.09485743f, -0.15338370f, 0.04299170f, -0.04544673f, 0.01186089f, 0.20627739f, 0.02859963f, -0.21347357f, 
    0.09890546f, -0.02868402f, 0.02509093f, -0.09914728f, 0.05494152f, 0.03872105f, 0.28898680f, -0.07747923f, 
    0.02490911f, 0.04220645f, 0.07521547f, 0.09178504f, -0.01647112f, 0.14646700f, 0.07865395f, -0.27679268f, 
    0.10771480f, -0.01802184f, 0.09526303f, -0.05995366f, -0.04310604f, 0.09176052f, 0.00340157f, 0.10906248f, 
    0.03495899f, -0.30911469f, 0.07033905f, 0.01310411f, 0.16845515f, -0.20414947f, -0.02278774f, -0.15177688f, 
    -0.04115779f, -0.13419180f, -0.19909891f, -0.47958544f, -0.19939356f, -0.03579624f, 0.07238777f, -0.13565062f, 
    -0.03415464f, -0.06395406f, -0.05482373f, -0.08009726f, -0.14104146f, -0.10044293f, 0.12933831f, 0.12224670f, 
    0.04950214f, -0.17430976f, 0.18016610f, 0.11459893f, -0.10083323f, 0.24503027f, 0.16164429f, 0.05256487f, 
    -0.04252224f, -0.02110974f, -0.00813849f, -0.10808581f, -0.08067753f, -0.08948274f, -0.13765362f, 0.15663256f, 
    -0.00091282f, -0.00857370f, -0.06419212f, 0.04768405f, -0.01745916f, 0.17614344f, 0.00688859f, 0.18151964f, 
    -0.02470674f, 0.08534855f, 0.22157709f, 0.21041593f, -0.15473041f, -0.10109083f, 0.06046099f, -0.04814269f, 
    0.08662826f, 0.17546515f, 0.02101412f, 0.22038573f, -0.05101209f, -0.02471789f, 0.16124229f, -0.05806440f, 
    -0.16924782f, -0.10927586f, -0.10312978f, -0.13798612f, 0.04970692f, 0.04154666f, 0.02335590f, -0.00133436f, 
    0.28497016f, 0.24921206f, 0.04544739f, -0.06070774f, 0.05640399f, 0.08160789f, 0.13601433f, -0.05107189f, 
    -0.11587139f, 0.08008496f, -0.09287410f, -0.10246924f, 0.04568677f, -0.05571549f, -0.08511814f, -0.05975961f, 
    -0.08403848f, -0.07457310f, 0.17449555f, 0.05200491f, 0.10278872f, -0.02251380f, -0.04081719f, 0.10767489f, 
    -0.02310195f, 0.09093417f, -0.07356253f, 0.08896992f, -0.22216532f, 0.18827868f, -0.16040511f, 0.07405919f, 
    0.07176983f, 0.12422641f, 0.06924181f, -0.22554766f, 0.19817095f, -0.33231634f, -0.02523222f, 0.05780854f, 
    0.12799717f, -0.10323309f, -0.18619822f, -0.00268915f, 0.03230105f, 0.04666977f, -0.03492571f, -0.02360982f, 
    0.11616622f, 0.05983470f, -0.06684326f, 0.09741534f, 0.19600263f, 0.22569960f, -0.03284695f, 0.07273884f, 
    -0.19759625f, 0.13627444f, -0.11978301f, 0.10551653f, 0.15440895f, -0.07990804f, 0.09810073f, 0.10100856f, 
    -0.01564518f, 0.06457552f, 0.13361567f, -0.16279595f, 0.07912021f, 0.16872364f, 0.09561053f, 0.03448529f, 
    0.07484306f, -0.04826304f, -0.15948920f, -0.11966295f, -0.02439084f, 0.10786541f, 0.01898554f, 0.01195717f, 
    0.10224809f, -0.18849711f, 0.04250662f, 0.14103138f, 0.13596395f, 0.00962565f, 0.09056985f, 0.17421433f, 
    -0.06081713f, -0.26050049f, -0.27135435f, -0.18356963f, -0.05822822f, 0.02946773f, -0.12136276f, 0.33767837f, 
    0.00847314f, 0.16862591f, 0.05061766f, 0.03098028f, -0.11687688f, -0.03297155f, -0.11164244f, -0.17737232f, 
    -0.06150420f, -0.01801889f, 0.07437381f, 0.10469479f, -0.31484270f, -0.20684998f, -0.43010297f, -0.07989592f, 
    -0.03094161f, -0.07057235f, -0.13897763f, -0.05815593f, 0.14351848f, -0.09082283f, -0.01657369f, -0.05656421f, 
    -0.02794917f, 0.11569097f, 0.04999854f, 0.03872152f, 0.06399120f, 0.03564087f, 0.20431878f, 0.12858722f, 
    -0.15963869f, -0.01497681f, -0.03506777f, 0.01158016f, 0.13445994f, 0.14271933f, 0.04333984f, 0.04460555f, 
    0.08081729f, -0.18527278f, 0.01792363f, -0.05632804f, 0.18033673f, 0.15586856f, 0.00385258f, 0.05812106f, 
    -0.15618156f, -0.17243372f, 0.15430894f, 0.05925954f, 0.12427250f, 0.02451813f, 0.05189741f, -0.07380785f, 
    0.01393505f, 0.17823938f, -0.08285657f, 0.19889137f, 0.00660599f, 0.03727541f, -0.06476751f, 0.18992835f, 
    -0.04706562f, -0.12271500f, -0.17810476f, -0.00636108f, 0.37501657f, 0.06339707f, 0.05367423f, 0.01023464f, 
    0.26013851f, -0.02436224f, -0.12085964f, 0.35355547f, 0.05446014f, -0.25344720f, -0.21733357f, -0.12928538f, 
    -0.02756601f, 0.14167042f, -0.09621255f, 0.14993182f, 0.07715099f, -0.21023180f, -0.02232449f, -0.17682637f, 
    -0.03152085f, 0.10853986f, -0.03982549f, 0.03656495f, -0.00498568f, 0.13623206f, 0.15779927f, 0.16257010f, 
    -0.04451518f, 0.08224605f, 0.20795240f, 0.21617362f, -0.00442749f, 0.02984452f, 0.30051196f, -0.06890909f, 
    -0.09502247f, -0.06161671f, 0.04383782f, 0.06119376f, 0.21205284f, 0.04749013f, 0.05610660f, 0.10545539f, 
    0.14603162f, -0.12432451f, 0.01650591f, 0.04493777f, 0.17152683f, 0.01392803f, -0.06747932f, -0.02606946f, 
    -0.05612927f, 0.03880274f, -0.04503484f, 0.03758715f, 0.05184094f, 0.00805977f, 0.03260786f, -0.04802693f, 
    -0.01767627f, -0.01761730f, -0.05017573f, 0.02072256f, 0.01846856f, -0.02454059f, -0.03349102f, 0.00187680f, 
    0.02047263f, -0.01622186f, 0.00987560f, -0.06035445f, -0.05776127f, -0.01756890f, 0.04565735f, 0.02280257f, 
    -0.01773613f, -0.02483815f, -0.01194733f, -0.05339820f, 0.04778098f, -0.01460213f, 0.01265263f, -0.05096846f, 
    -0.02974550f, -0.01735873f, -0.05681397f, 0.03062255f, 0.00727533f, 0.04844466f, -0.00259451f, -0.03655136f, 
    -0.00230260f, 0.00745007f, -0.04955305f, -0.02313786f, 0.00180732f, -0.04341410f, -0.00141279f, 0.02115440f, 
    -0.03355429f, 0.00243919f, 0.03266392f, -0.01787341f, -0.01085620f, 0.00540577f, 0.01548063f, 0.04757762f, 
    -0.01722977f, -0.00144333f, -0.05055142f, -0.05098091f, -0.03922442f, -0.02747658f, -0.00176587f, 0.00595881f, 
    -0.02759591f, 0.00929980f, -0.00045241f, 0.00672046f, -0.02618415f, -0.04717080f, 0.04487890f, 0.00218706f, 
    -0.05984770f, 0.03868375f, 0.01521498f, -0.00126730f, -0.06432396f, -0.04537398f, -0.01494995f, -0.06429908f, 
    0.05173461f, 0.03645174f, -0.01223322f, 0.01878890f, 0.04235331f, -0.04583428f, -0.04903860f, 0.04727783f, 
    -0.01170614f, -0.05683875f, 0.05332259f, 0.02255157f, -0.06310237f, 0.05246861f, -0.05618979f, 0.00427899f, 
    -0.05429197f, -0.05736791f, -0.05364029f, -0.00612882f, -0.05309272f, 0.04569360f, -0.03370224f, -0.00974932f, 
    -0.03393797f, -0.05691487f, -0.00205507f, 0.01007509f, -0.01635097f, 0.00377869f, 0.02789243f, 0.04514083f, 
    -0.06005879f, 0.02162166f, -0.01877895f, -0.05795393f, -0.01406735f, 0.01908835f, -0.06321877f, 0.05209601f, 
    0.01231113f, -0.01634006f, 0.00189566f, 0.03095938f, -0.01093670f, 0.04172947f, -0.02666791f, -0.05136503f, 
    -0.05116137f, 0.01580580f, -0.00971779f, 0.00947744f, -0.03912249f, -0.03608070f, -0.03442419f, 0.02325701f, 
    0.01514429f, -0.03435137f, 0.02114021f, 0.04561662f, -0.05266123f, -0.05974733f, -0.06094597f, 0.02518237f, 
    0.04616830f, 0.00471521f, -0.04191235f, 0.04191155f, 0.02065562f, -0.04812216f, -0.02665384f, 0.04134881f, 
    0.04508404f, 0.05478887f, 0.00288688f, -0.06095237f, -0.06044113f, -0.05038700f, 0.05203615f, -0.02855731f, 
    0.03743976f, 0.01099330f, -0.00138352f, 0.05151106f, -0.02521308f, -0.00981550f, -0.06190461f, -0.05642086f, 
    -0.02842468f, 0.02052845f, -0.01771773f, -0.00164144f, 0.05235611f, -0.00195291f, -0.04184388f, -0.03673775f, 
    -0.03134130f, -0.02524438f, -0.03278444f, -0.00005682f, -0.05933582f, -0.00986632f, 0.03596592f, -0.00225540f, 
    -0.02595971f, 0.01977975f, -0.02029853f, -0.02644996f, -0.01895601f, -0.02910352f, -0.04116729f, -0.01509062f, 
    0.01154936f, 0.05210277f, -0.00427954f, -0.04993751f, 0.03715920f, 0.02083675f, -0.03499351f, -0.05410831f, 
    -0.00278952f, -0.04508293f, -0.06407524f, -0.04486843f, -0.04764356f, -0.03436909f, -0.00589429f, 0.01942379f, 
    0.04621860f, -0.01140486f, 0.03087897f, -0.06117589f, -0.02702506f, 0.00044473f, -0.01402518f, -0.04903988f, 
    -0.06218924f, 0.05050271f, 0.04087840f, -0.06353828f, 0.04307900f, -0.04759039f, -0.06022412f, -0.00232089f, 
    -0.04991138f, -0.04631330f, -0.06292884f, -0.06001832f, -0.00408278f, -0.00223965f, 0.04673204f, 0.02495595f, 
    -0.01779423f, -0.01729155f, 0.00060514f, 0.02864717f, 0.04921542f, -0.01139762f, 0.04051778f, 0.02789163f, 
    0.02641039f, -0.03977121f, 0.04443857f, 0.03083006f, 0.03789001f, -0.05682863f, 0.03450575f, -0.06266920f, 
    0.00416192f, -0.02474156f, -0.03556285f, -0.03655985f, -0.04195786f, -0.02620924f, 0.04729515f, 0.01845726f, 
    -0.02497524f, -0.00652510f, 0.03673639f, 0.00712413f, -0.05699512f, -0.04123513f, -0.04901222f, -0.05412199f, 
    -0.05616118f, 0.04529668f, 0.02667402f, 0.04674235f, -0.05602978f, 0.00634905f, 0.01476446f, 0.05085181f, 
    0.02582357f, 0.03579900f, -0.04798402f, 0.00103649f, 0.01497711f, 0.02247865f, -0.06204151f, -0.04389342f, 
    0.04171298f, 0.03530088f, -0.02676973f, -0.04388721f, -0.03014575f, -0.06294233f, -0.06120292f, -0.05804961f, 
    0.30377814f, 0.14969432f, -0.15351537f, -0.01179246f, -0.05328767f, 0.17689554f, -0.03630537f, 0.00769654f, 
    -0.00378872f, -0.32305375f, -0.18325721f, 0.35444069f, 0.03873536f, 0.22886139f, 0.13748944f, 0.07736237f, 
    0.03871844f, -0.02275525f, -0.19667886f, -0.26805988f, 0.22348334f, -0.04619853f, 0.19893122f, 0.13966072f, 
    0.05811734f, 0.01485174f, 0.16851768f, 0.16298886f, 0.18529910f, -0.00114134f, 0.05285042f, 0.00871324f, 
    0.04705127f, 0.06715713f, -0.03315682f, 0.04444166f, 0.08707386f, -0.01901964f, -0.21432090f, 0.00724430f, 
    0.09355899f, 0.04865842f, 0.05555756f, 0.10567921f, -0.04145062f, 0.02518034f, -0.07260694f, 0.00989128f, 
    0.04545614f, -0.03073573f, 0.13242097f, 0.03429082f, 0.17054340f, 0.05945522f, 0.07779362f, -0.13864869f, 
    0.10412017f, 0.19712749f, 0.15903431f, -0.04986763f, -0.00107492f, 0.05773659f, -0.14579247f, -0.05927639f, 
    -0.10876437f, -0.11723399f, 0.02417558f, -0.04347156f, 0.06985289f, 0.03658705f, -0.04867801f, 0.09624055f, 
    0.11572102f, 0.30754468f, 0.13465874f, -0.12366448f, -0.14879842f, -0.02958566f, 0.04164756f, 0.09356511f, 
    0.02692316f, 0.00139611f, -0.18106948f, -0.11436055f, 0.04986047f, -0.03672153f, 0.03371181f, -0.27828917f, 
    -0.21051386f, -0.05788220f, 0.02563694f, 0.00185353f, -0.06403945f, 0.15562308f, 0.01239679f, -0.04336770f, 
    -0.07400391f, -0.19900885f, -0.07732029f, -0.16619749f, 0.13346820f, 0.12058092f, 0.04712396f, 0.08805584f, 
    -0.10225875f, 0.00711593f, 0.04084576f, -0.17632790f, 0.30204260f, 0.20070101f, -0.06863625f, -0.14636612f, 
    -0.00238984f, -0.03436421f, 0.08372645f, 0.03746654f, 0.07158127f, -0.03819009f, -0.19323923f, -0.10460053f, 
    -0.05550385f, 0.01242660f, 0.03687517f, -0.10229091f, -0.24020067f, -0.28813344f, -0.01495283f, 0.13706250f, 
    -0.16848622f, -0.08873506f, 0.06989000f, -0.08224741f, 0.08065211f, -0.19631159f, 0.04956886f, 0.08845038f, 
    -0.22550599f, -0.05306639f, 0.01964693f, -0.00298606f, 0.03855416f, 0.00315064f, 0.02966279f, 0.12707442f, 
    0.15642190f, -0.14183591f, -0.13582525f, 0.13249223f, -0.00647326f, -0.06241263f, -0.18529570f, 0.11351905f, 
    -0.01058651f, 0.02280653f, -0.02269506f, 0.00018041f, -0.04785749f, 0.13929418f, 0.05706584f, 0.08207077f, 
    0.05614565f, 0.18524079f, 0.12449058f, -0.08447187f, 0.04764702f, 0.09137315f, 0.06722292f, 0.11212244f, 
    -0.10124788f, 0.17937437f, 0.04727720f, 0.18487799f, -0.18267958f, -0.12438852f, 0.13979495f, -0.11587215f, 
    -0.07519114f, 0.17258109f, 0.03171854f, -0.20531189f, -0.33639884f, 0.07344218f, -0.01271112f, -0.09999829f, 
    0.02598506f, 0.18688624f, 0.03013981f, 0.01905421f, -0.06430618f, 0.08881860f, -0.05037080f, 0.07764218f, 
    0.08724972f, 0.00179179f, -0.06394016f, 0.01026832f, -0.22285412f, -0.17998207f, 0.02877709f, 0.19712356f, 
    0.00696844f, -0.04911555f, -0.04843464f, 0.00704787f, 0.04971964f, 0.01824760f, 0.10973395f, 0.14848012f, 
    0.22328016f, -0.04506085f, 0.08086890f, -0.06729517f, -0.05187111f, -0.05511578f, 0.01204525f, -0.06307675f, 
    0.25276682f, 0.25743601f, -0.01216055f, 0.10217050f, -0.05110176f, 0.13716622f, 0.03059887f, 0.02081876f, 
    0.07206494f, 0.14453712f, 0.08668459f, -0.05521341f, 0.08495651f, -0.11556328f, 0.14616278f, 0.06618652f, 
    0.07678280f, 0.00528792f, 0.05278927f, 0.23350036f, 0.18786678f, 0.14014715f, 0.02136831f, -0.01910306f, 
    -0.00074381f, -0.06189561f, 0.04530908f, 0.19488896f, -0.05554301f, -0.18607059f, -0.07023985f, -0.11785381f, 
    0.16240738f, -0.05310842f, -0.08165910f, -0.27463964f, 0.22593956f, -0.03882138f, 0.02156860f, 0.06780220f, 
    0.07839803f, -0.06366363f, 0.06557228f, 0.03712532f, -0.11667953f, 0.03669795f, 0.19953188f, 0.15239902f, 
    0.00910685f, 0.01693290f, 0.05492740f, 0.00428640f, 0.17630805f, 0.02694967f, -0.17337298f, 0.09429847f, 
    -0.09937634f, -0.05646780f, 0.05008498f, 0.04341198f, 0.12433334f, -0.00771661f, -0.11858797f, 0.28142172f, 
    0.21036416f, -0.08614712f, -0.05805365f, -0.06337894f, 0.01616753f, 0.00612157f, -0.08104163f, -0.06579660f, 
    -0.17177868f, 0.08303229f, -0.10443626f, 0.08086292f, -0.00646629f, 0.05647311f, 0.09293875f, 0.14428566f, 
    0.07630634f, 0.15966056f, -0.46203089f, -0.13337196f, 0.08438600f, -0.05497880f, -0.01774292f, -0.08317344f, 
    0.05578120f, 0.00592360f, -0.01101899f, -0.14250083f, 0.16729784f, 0.04067197f, -0.03893693f, 0.11482329f, 
    -0.14566346f, 0.08195943f, 0.02553640f, -0.06456341f, -0.01605049f, -0.10113860f, -0.12558593f, -0.06494666f, 
    0.05923182f, -0.02670215f, -0.05015284f, 0.04747231f, -0.20096989f, 0.08157787f, 0.14614783f, 0.03784749f, 
    -0.12113640f, 0.01569092f, 0.04365522f, -0.08096097f, 0.05476731f, 0.02266338f, 0.18078382f, 0.01134062f, 
    0.02622025f, 0.00908616f, -0.02745692f, -0.02177208f, -0.08318565f, 0.08134842f, -0.04469023f, 0.16453379f, 
    0.19986448f, -0.10407817f, -0.01251288f, -0.10731985f, 0.05807286f, 0.12865399f, -0.06541841f, -0.16576211f, 
    0.00893671f, -0.17423297f, 0.04406280f, -0.11486992f, 0.04201329f, 0.03378269f, -0.04949713f, -0.08988567f, 
    -0.13756479f, -0.12975195f, -0.34280708f, 0.06348305f, 0.00557069f, 0.05705515f, 0.08328830f, 0.06337880f, 
    0.09331085f, 0.07140257f, 0.05925843f, 0.19491768f, 0.03898470f, -0.07610855f, 0.00736188f, -0.01408110f, 
    0.04971620f, 0.14479586f, 0.02191152f, 0.17003028f, 0.14028563f, -0.07192133f, -0.00729915f, -0.00937749f, 
    -0.10659328f, 0.14863564f, 0.15169595f, 0.08775319f, 0.06320249f, 0.17037003f, 0.09313221f, 0.00698085f, 
    -0.01743676f, 0.01481481f, -0.06576595f, -0.02225174f, -0.37419799f, 0.02465819f, 0.06212724f, -0.04079215f, 
    0.01962113f, 0.11557524f, 0.02160838f, 0.04304536f, 0.09157875f, -0.09743890f, -0.10682132f, -0.08328111f, 
    0.02644466f, -0.02932236f, 0.11148115f, 0.11314316f, 0.05771310f, 0.04157840f, 0.12425227f, -0.00488750f, 
    0.21825774f, 0.05097901f, -0.00721823f, -0.08539318f, -0.10510452f, 0.04948347f, 0.13581811f, 0.21164258f, 
    -0.00094522f, -0.02767568f, -0.05049346f, 0.00320626f, 0.00249340f, 0.01549497f, 0.01657619f, 0.12633896f, 
    0.04024033f, -0.06187403f, -0.10123739f, 0.03995417f, 0.05638665f, 0.18689704f, -0.01890111f, -0.05410834f, 
    0.16627592f, 0.20447677f, 0.06968814f, -0.12298700f, -0.00440531f, 0.03355927f, 0.08220600f, -0.04136667f, 
    0.05709442f, -0.03949232f, -0.05481558f, 0.00186593f, 0.09421989f, -0.06395169f, 0.04167574f, 0.12964234f, 
    -0.04587151f, 0.00763198f, -0.26943430f, -0.17721453f, 0.11465997f, 0.31634617f, -0.02800071f, 0.07775835f, 
    -0.13879474f, -0.32089072f, -0.04138691f, 0.06006348f, 0.17669457f, -0.28347436f, -0.07205103f, 0.10005953f, 
    -0.04148521f, -0.00571384f, -0.01568447f, 0.01701502f, 0.01786392f, -0.06715114f, -0.00044030f, -0.18158624f, 
    -0.09474311f, -0.04290538f, -0.00527871f, 0.00487166f, 0.03633758f, 0.01907697f, -0.04113059f, -0.16325690f, 
    -0.17089164f, 0.04834808f, 0.05198008f, 0.05414441f, 0.04772767f, 0.01210607f, 0.00167737f, -0.08233573f, 
    0.00592549f, 0.16611564f, 0.11593249f, -0.08278564f, 0.01138863f, 0.13231394f, 0.01558015f, -0.01435022f, 
    -0.17531605f, 0.05790746f, -0.11176557f, -0.10413729f, -0.14590712f, -0.16825032f, 0.04765313f, 0.05318028f, 
    -0.03213416f, 0.01198722f, 0.13957542f, 0.10029493f, -0.20371272f, -0.10423397f, -0.06053852f, 0.01728849f, 
    0.09593122f, 0.13652532f, 0.02260333f, -0.02990025f, -0.12230320f, -0.13366269f, -0.04131718f, 0.00389730f, 
    -0.07107379f, -0.03410937f, -0.13921449f, -0.21025574f, -0.30421007f, -0.29341748f, -0.03107530f, 0.08913395f, 
    -0.00305410f, 0.08807310f, -0.08098050f, 0.01164006f, -0.19798163f, -0.05791702f, -0.14949720f, 0.07836710f, 
    0.02340329f, -0.00932092f, 0.01501353f, 0.06239896f, -0.04651371f, 0.06038084f, 0.08657874f, 0.14636551f, 
    0.01069640f, 0.05680594f, 0.04027632f, 0.03173782f, -0.15846314f, -0.12617426f, 0.10979347f, -0.10445339f, 
    -0.02635543f, 0.01226107f, -0.01621240f, -0.01372805f, 0.05336235f, 0.01811328f, 0.01086877f, -0.13453034f, 
    -0.10034528f, -0.02407909f, 0.00734958f, 0.00014715f, 0.13035966f, 0.01640238f, 0.07025179f, 0.09783920f, 
    0.06779977f, 0.02811036f, 0.09442128f, -0.05402138f, 0.18193507f, 0.03693491f, 0.05568327f, 0.07103198f, 
    -0.11786308f, -0.36079091f, -0.04145560f, -0.01365967f, -0.04173461f, 0.08825761f, -0.06582809f, -0.16568989f, 
    -0.13788500f, 0.10357298f, -0.27217221f, -0.08800945f, -0.39252058f, -0.00738291f, 0.18454991f, -0.14972073f, 
    0.01290141f, -0.00504939f, 0.04584310f, 0.37756678f, 0.17082021f, -0.10483555f, -0.08504306f, -0.00419486f, 
    0.13981098f, -0.06825270f, -0.12374602f, 0.02057859f, -0.02216250f, 0.13362727f, -0.06776460f, -0.03356905f, 
    -0.04206796f, 0.17518051f, 0.07279432f, 0.06353001f, 0.18444541f, -0.43043914f, -0.23152614f, -0.16376843f, 
    -0.04828671f, -0.02653325f, -0.04511172f, 0.00837016f, 0.05928734f, 0.06257883f, 0.38590294f, -0.18879865f, 
    -0.02082990f, -0.07586157f, -0.02527265f, -0.20308495f, -0.15239941f, -0.03889184f, 0.09699240f, 0.00870093f, 
    0.15188563f, -0.16064531f, -0.07201974f, -0.01141886f, -0.05307550f, 0.02979358f, -0.12004136f, 0.01176562f, 
    0.35436860f, 0.02524827f, -0.11301583f, 0.00316114f, 0.14428653f, -0.04377308f, -0.02431271f, 0.07391664f, 
    0.02360515f, -0.22455502f, -0.01308991f, 0.04692644f, -0.04576914f, 0.10377862f, -0.01279909f, 0.04657051f, 
    -0.11938600f, 0.00309542f, -0.19516897f, -0.29988837f, -0.11032134f, -0.01493131f, 0.17723627f, -0.12528896f, 
    0.07359549f, 0.09362257f, -0.09844277f, 0.10037374f, -0.22520299f, -0.32707953f, 0.05040067f, 0.01229062f, 
    0.09937137f, -0.00915796f, 0.03819033f, -0.09259436f, 0.13087250f, -0.15761060f, -0.03737894f, -0.01240496f, 
    -0.00595715f, 0.07719273f, -0.03399484f, 0.16069899f, -0.11618389f, -0.22784673f, 0.05419976f, 0.08168099f, 
    0.01866242f, 0.10283543f, 0.11661860f, 0.06806021f, 0.03439870f, 0.01883241f, 0.25437102f, 0.10530426f, 
    -0.13034025f, 0.02999364f, -0.08881702f, -0.30303490f, 0.03156909f, 0.07946479f, 0.08261983f, -0.19464658f, 
    -0.22983566f, 0.04625826f, -0.14940004f, 0.03494586f, 0.05984937f, 0.04266169f, 0.00313458f, 0.13860565f, 
    -0.09819756f, -0.12943143f, -0.25449350f, 0.01406472f, -0.08306382f, 0.29680997f, 0.08901735f, 0.07580966f, 
    -0.17471437f, 0.15367857f, -0.03362329f, 0.05634380f, -0.06787274f, 0.05107424f, 0.15377857f, -0.10397442f, 
    -0.00980849f, 0.14227085f, 0.07740209f, -0.11162297f, -0.02701792f, 0.00513058f, 0.04107568f, 0.05387881f, 
    -0.01853743f, 0.05317109f, 0.01961353f, -0.04900251f, -0.19576649f, -0.03808291f, 0.08405297f, -0.19223601f, 
    -0.14105953f, -0.09274741f, 0.08123320f, -0.19322732f, -0.29832268f, -0.01781403f, 0.07786890f, 0.09181117f, 
    0.00968086f, 0.05111674f, -0.14675787f, -0.06452195f, 0.04569584f, 0.03899706f, 0.23130745f, 0.06759421f, 
    0.04307910f, -0.00205349f, 0.11332317f, 0.10601101f, 0.00292865f, -0.01963248f, 0.45787066f, -0.00288337f, 
    0.09943870f, -0.04404664f, 0.09402221f, -0.05014853f, -0.00788419f, -0.01036661f, -0.02348073f, 0.17395581f, 
    0.12520774f, 0.13228869f, 0.02372928f, -0.09903460f, -0.06762597f, -0.08691683f, 0.02903164f, 0.02742697f, 
    -0.10165192f, -0.26434079f, -0.10719382f, 0.12317283f, 0.04178829f, -0.10716676f, 0.03598862f, 0.16425133f, 
    -0.02212125f, -0.47771391f, -0.24272291f, -0.33993033f, -0.10186560f, -0.10994228f, -0.23514175f, 0.10957418f, 
    -0.06972858f, -0.05142261f, -0.04800093f, 0.16462302f, -0.30298850f, -0.24834220f, 0.03792768f, -0.03062022f, 
    0.05552084f, -0.11831619f, 0.16723964f, 0.06529818f, 0.19233495f, -0.20563282f, -0.05218316f, 0.00420114f, 
    0.20101835f, 0.07250728f, -0.01060410f, -0.15863302f, 0.21378748f, 0.26452279f, 0.08937883f, -0.01772964f, 
    0.03140632f, 0.17733184f, 0.00137515f, -0.06012559f, 0.03607210f, -0.10017902f, -0.24264163f, -0.27345052f, 
    0.04721128f, -0.07880325f, -0.23348476f, 0.06326255f, -0.15094192f, 0.04034699f, 0.35391501f, 0.27145121f, 
    -0.07982589f, 0.03546439f, 0.15765180f, 0.09313191f, 0.02612497f, 0.09633417f, -0.08443531f, 0.50248790f, 
    0.25840715f, -0.00448352f, 0.00657249f, 0.09927379f, 0.05592402f, 0.02527281f, 0.12550496f, 0.01635616f, 
    -0.06397174f, -0.07084094f, 0.00326999f, 0.01209843f, -0.01158477f, -0.04738688f, -0.05569137f, -0.01722307f, 
    -0.04215782f, -0.02498774f, -0.05883579f, 0.01502827f, -0.05128184f, 0.02579455f, 0.01130400f, -0.06610285f, 
    0.03142306f, 0.01476200f, -0.03139668f, -0.02110875f, -0.03588269f, 0.04175843f, 0.03056135f, -0.04059286f, 
    -0.05412829f, -0.00188137f, -0.04404197f, 0.01297626f, -0.02367289f, 0.02820124f, -0.05374523f, -0.05299431f, 
    0.04398741f, -0.02327304f, -0.05673617f, 0.03458442f, -0.05966389f, -0.03164394f, -0.06574403f, 0.01310279f, 
    -0.05136024f, 0.00379921f, -0.03473910f, -0.03767856f, -0.00387215f, -0.06239093f, -0.00157703f, 0.01664303f, 
    -0.00029847f, -0.02928531f, 0.01334951f, 0.01767766f, -0.02115640f, -0.01139404f, 0.04353068f, 0.02652046f, 
    0.03750298f, -0.06213222f, -0.02441029f, 0.01742303f, 0.02540308f, 0.03378063f, 0.03002526f, 0.00817066f, 
    -0.03089620f, 0.05449333f, -0.00374842f, 0.04461555f, -0.04107681f, 0.04746442f, 0.00411427f, 0.04587077f, 
    -0.00223342f, 0.02827012f, -0.05279892f, -0.07025363f, -0.06231416f, -0.00836513f, -0.00431693f, -0.02556361f, 
    0.04046746f, 0.01280975f, -0.03475834f, -0.04622054f, 0.00347345f, -0.04589212f, 0.01113724f, -0.01236267f, 
    -0.06477597f, -0.04993138f, 0.01910060f, 0.01642202f, -0.05550471f, 0.01477730f, -0.06409724f, -0.00257393f, 
    0.04073006f, -0.00709280f, 0.00996411f, -0.03001814f, -0.03080766f, 0.02072882f, -0.06200706f, -0.00412969f, 
    -0.05579151f, -0.02272487f, 0.04487510f, -0.01052342f, 0.00299567f, -0.05332724f, 0.03259422f, -0.00030588f, 
    -0.03706392f, 0.01649197f, -0.05010616f, 0.02857111f, -0.03553418f, -0.05667388f, 0.00392931f, 0.00351805f, 
    0.03121966f, 0.02655480f, 0.04288851f, -0.04026177f, -0.00109920f, -0.03309045f, -0.06793084f, 0.02429164f, 
    0.02246330f, 0.01741328f, -0.05795225f, 0.03352790f, 0.00536225f, -0.02225407f, -0.03093717f, 0.01674054f, 
    0.04061601f, 0.02395768f, -0.01236070f, -0.03047404f, 0.00474422f, -0.04616007f, -0.04526016f, -0.05028516f, 
    0.04427083f, -0.03757052f, 0.01555773f, 0.01398506f, -0.00050007f, -0.03836488f, -0.06137799f, 0.04133509f, 
    -0.04295224f, -0.05132439f, -0.00378791f, 0.01694801f, 0.00089415f, 0.03777172f, -0.03113496f, -0.04808250f, 
    -0.03147759f, 0.01583765f, -0.00468642f, 0.03284409f, 0.03643296f, 0.03213305f, -0.03196012f, 0.01389093f, 
    0.00025539f, -0.06187431f, 0.00927359f, -0.01515822f, 0.04226137f, -0.04111089f, 0.03830593f, 0.01705353f, 
    0.04894512f, -0.02806368f, 0.00719040f, 0.04305021f, -0.00916498f, -0.00941813f, -0.05571967f, -0.04324114f, 
    0.00619231f, -0.01499041f, -0.00574698f, -0.02212342f, -0.00197416f, -0.03199655f, 0.03093220f, 0.02202080f, 
    0.02863015f, 0.00332977f, -0.01687886f, -0.00920221f, 0.02184286f, 0.01340286f, 0.04117740f, -0.03294142f, 
    -0.00344844f, -0.03984926f, 0.00105671f, -0.02747159f, 0.04099047f, 0.00186272f, -0.03926781f, -0.00816470f, 
    0.00394172f, -0.04008334f, 0.01396903f, 0.05614724f, 0.00660070f, -0.01809135f, -0.00826591f, 0.00702243f, 
    0.00292704f, 0.03593100f, -0.03981516f, 0.02272360f, -0.04214877f, -0.02015817f, 0.03130253f, -0.04892971f, 
    0.02922080f, -0.01585728f, 0.02273520f, 0.01494137f, -0.00487245f, -0.02613772f, -0.03648396f, -0.03573389f, 
    0.00728291f, -0.04087213f, -0.04027776f, -0.00673253f, -0.02557321f, -0.04667542f, -0.04143092f, 0.02855907f, 
    0.03680784f, 0.03507110f, -0.00534043f, -0.05561726f, -0.01743877f, 0.00602804f, -0.03033247f, -0.04908046f, 
    0.00312356f, -0.02034659f, -0.04493507f, -0.02988377f, 0.04617932f, -0.05250067f, -0.02919798f, 0.01361785f, 
    -0.02153163f, 0.05274560f, -0.04169983f, 0.04538690f, -0.01221799f, -0.03494892f, -0.04683717f, 0.04170243f, 
    -0.03119639f, -0.04643494f, -0.01219823f, 0.04488729f, -0.03551805f, 0.04397163f, -0.00926709f, -0.03033899f, 
    -0.00284668f, -0.06345586f, 0.03541098f, 0.04630915f, -0.04365003f, 0.01547840f, 0.04515278f, -0.01411228f, 
    -0.06012455f, -0.00910285f, 0.03354598f, 0.03529714f, -0.03665730f, 0.00929805f, 0.02789450f, 0.04553689f, 
    -0.25218064f, -0.16511256f, 0.10707892f, 0.03834782f, -0.09735983f, 0.10093008f, -0.01179019f, 0.09376076f, 
    -0.00554852f, 0.17031309f, 0.16137537f, 0.26682219f, -0.10912383f, -0.05519865f, 0.01940718f, -0.01215431f, 
    -0.24101153f, -0.18773879f, -0.02704522f, 0.21275806f, 0.22273421f, -0.24438435f, -0.06046689f, -0.03793197f, 
    -0.05481167f, -0.07184768f, -0.12405108f, -0.50160223f, -0.07634215f, 0.05738327f, 0.17170362f, 0.00714117f, 
    0.06279740f, 0.09314513f, -0.11817553f, 0.00108732f, -0.04291417f, 0.01741360f, 0.11079204f, 0.15287961f, 
    -0.10520532f, 0.06182704f, -0.04115517f, -0.00240978f, -0.04501815f, -0.18102695f, -0.17610316f, 0.01685852f, 
    -0.03198079f, -0.04985823f, 0.11440470f, -0.07264967f, -0.04909295f, -0.00345423f, 0.09922487f, -0.06728271f, 
    -0.23009111f, -0.00921933f, -0.06797183f, -0.07206745f, 0.05729625f, -0.03354003f, 0.15263118f, -0.10254499f, 
    -0.01065347f, 0.15044075f, -0.06040146f, -0.09586397f, -0.07443266f, 0.08163358f, -0.02472922f, -0.06004491f, 
    -0.26520768f, -0.29880548f, -0.05460187f, 0.10144138f, -0.00025389f, 0.03180927f, 0.05240027f, 0.01421476f, 
    0.05572300f, 0.13387148f, -0.06753837f, -0.19165581f, -0.08714531f, -0.12744135f, -0.03529756f, 0.19660793f, 
    -0.02279591f, 0.07556903f, -0.00246797f, -0.06952980f, -0.24542345f, 0.08070052f, -0.00510719f, -0.01377323f, 
    0.17956491f, 0.14537519f, -0.00978762f, 0.29200897f, -0.16339350f, -0.32053098f, 0.07209285f, 0.14002265f, 
    -0.22473687f, 0.13797438f, 0.04988041f, 0.00034016f, -0.11430237f, -0.22333303f, -0.03982469f, 0.06216845f, 
    -0.13582474f, 0.12432340f, -0.02364087f, 0.18501507f, 0.07155583f, -0.01577153f, -0.02033088f, 0.18092804f, 
    0.01770294f, 0.03560938f, 0.23518087f, 0.16915400f, 0.18020466f, 0.26499403f, -0.16276495f, -0.03247922f, 
    0.11908341f, 0.00412170f, -0.05976516f, 0.00164838f, 0.16714741f, 0.04636183f, 0.03492724f, -0.19962184f, 
    0.00459909f, 0.16259088f, -0.14915504f, -0.00396789f, 0.00326646f, -0.03147065f, 0.02543270f, 0.16098720f, 
    0.62053549f, -0.02362222f, -0.46397239f, 0.03812690f, -0.11899948f, -0.03212145f, 0.21315652f, 0.09400178f, 
    0.09064197f, -0.14517097f, 0.24236701f, 0.22725098f, -0.18689644f, -0.07340871f, 0.01335130f, -0.00018561f, 
    -0.03470689f, 0.06736268f, -0.02849965f, 0.24997965f, 0.24102797f, -0.20697673f, -0.24394143f, 0.05177904f, 
    -0.06807429f, -0.05724379f, -0.18085814f, 0.20119719f, -0.06890576f, -0.55052739f, -0.09468555f, 0.04780184f, 
    0.01562850f, -0.04363099f, 0.14184572f, 0.26902491f, 0.12728207f, -0.12046357f, -0.08387236f, -0.12201213f, 
    0.01007265f, -0.17805406f, -0.06951380f, 0.00259613f, -0.10761821f, -0.14639048f, -0.14821842f, 0.17778033f, 
    -0.10390701f, 0.08917356f, -0.21764541f, -0.04917956f, 0.13528956f, 0.09244367f, -0.15910414f, -0.02166978f, 
    0.08824510f, 0.00249675f, 0.06973846f, 0.00904577f, -0.01631141f, 0.09283139f, 0.08209740f, -0.15281513f, 
    -0.03927472f, 0.13489074f, 0.11947554f, -0.03489813f, 0.22900803f, 0.07270323f, 0.04967551f, -0.04499290f, 
    -0.52103299f, -0.30709225f, 0.04071567f, 0.12619051f, 0.04870366f, 0.12084543f, -0.05912770f, 0.06963273f, 
    0.17770930f, -0.11950038f, -0.26020813f, -0.15682396f, 0.08732580f, -0.10337811f, -0.08570573f, 0.02503507f, 
    0.05986187f, 0.01879901f, -0.23690881f, -0.29457498f, -0.40862375f, 0.09286959f, -0.19527921f, -0.01847369f, 
    -0.08223403f, 0.03259593f, 0.02865731f, 0.29558200f, -0.10496050f, 0.00466524f, -0.13161580f, -0.10996520f, 
    0.02933344f, 0.03556663f, 0.01279111f, 0.02726619f, -0.10296319f, -0.04204684f, 0.14368422f, 0.01428034f, 
    -0.09206627f, -0.02707822f, 0.01877112f, -0.24336559f, 0.09074821f, 0.35511473f, 0.03371371f, -0.36378053f, 
    0.11164229f, -0.03258237f, 0.02764743f, 0.03760275f, 0.00349791f, 0.11757705f, 0.14749618f, 0.18827100f, 
    0.13253267f, 0.04662223f, 0.11411899f, -0.05799784f, 0.18486784f, 0.02490950f, 0.04317329f, -0.08286105f, 
    -0.04706376f, 0.06587789f, 0.12774438f, 0.05071075f, 0.06675217f, 0.08290219f, 0.03577826f, -0.03007903f, 
    0.07516678f, 0.03707403f, 0.06643401f, -0.05122647f, 0.10131879f, -0.02566463f, 0.06646740f, 0.00737960f, 
    -0.16694655f, 0.14206572f, -0.19233023f, -0.29198456f, -0.24144414f, -0.04389458f, -0.03892974f, 0.03577476f, 
    -0.15392955f, -0.08595080f, 0.22517595f, -0.26394290f, -0.36352834f, -0.08452009f, -0.11355394f, -0.12506543f, 
    0.07404593f, -0.08253106f, -0.04918526f, 0.23537995f, -0.24057209f, 0.14510667f, -0.12103934f, -0.05421511f, 
    0.00612458f, -0.02767675f, -0.15475716f, -0.16272120f, -0.01232743f, 0.16590680f, 0.02113250f, -0.02178506f, 
    0.05457979f, -0.01420199f, 0.01657432f, -0.15516411f, -0.15429395f, 0.06340733f, 0.16498341f, -0.02544609f, 
    -0.10156738f, 0.00082580f, -0.03020285f, -0.21379887f, -0.13524200f, -0.12151444f, -0.13111232f, -0.21980222f, 
    0.00329697f, -0.04448073f, -0.02008675f, 0.07685822f, 0.08495081f, -0.06803588f, 0.03735552f, 0.11232582f, 
    0.30735266f, 0.01270256f, -0.02697581f, -0.05948097f, -0.11722137f, 0.14707403f, -0.03219800f, -0.07903927f, 
    -0.38894185f, -0.01456578f, 0.11255424f, -0.11324587f, -0.07786017f, 0.07623799f, 0.02169764f, 0.25443655f, 
    0.11581451f, 0.03419122f, 0.04373413f, -0.09569032f, 0.10026129f, 0.13899074f, 0.00716974f, 0.07649303f, 
    0.07314129f, 0.07559051f, 0.18236484f, 0.18100186f, 0.06338135f, 0.08612502f, -0.02262144f, 0.03901879f, 
    0.14388795f, 0.14341643f, 0.22374438f, -0.33826777f, -0.43939739f, 0.06773018f, -0.18821794f, 0.02797889f, 
    0.11693926f, 0.00130025f, -0.00608386f, 0.04534090f, 0.18443635f, 0.20581251f, 0.15197006f, -0.00079010f, 
    -0.06286030f, -0.07581860f, 0.06309733f, 0.04428138f, -0.10346272f, 0.14651036f, 0.11787825f, 0.08098827f, 
    -0.00304277f, -0.06109709f, -0.13776183f, 0.15230690f, 0.01766607f, 0.06071983f, 0.02276104f, 0.20778003f, 
    0.04950200f, -0.03547584f, 0.21317358f, -0.00275046f, 0.02347520f, -0.03986330f, 0.03274765f, 0.29220900f, 
    -0.08984562f, -0.07664131f, -0.02065424f, -0.04651312f, 0.09980688f, 0.01839701f, 0.12166470f, -0.12476101f, 
    0.00959774f, 0.15124004f, 0.07657077f, -0.16363920f, 0.08413212f, 0.02166544f, 0.12656784f, 0.07483526f, 
    -0.04842372f, 0.17604959f, -0.19513860f, -0.16473880f, -0.18756726f, -0.01341311f, -0.10878128f, 0.04143463f, 
    -0.26086488f, -0.02759846f, 0.14475766f, -0.07342187f, -0.25834259f, -0.10989550f, 0.00426475f, -0.11581621f, 
    0.13570672f, -0.23748794f, -0.04715359f, -0.17155884f, 0.16109376f, -0.08721989f, -0.07006252f, 0.00029473f, 
    0.27110368f, 0.04734084f, 0.10925790f, 0.01535606f, 0.05268105f, -0.17432326f, 0.10772177f, -0.11069451f, 
    -0.07299952f, 0.09991612f, 0.08859591f, -0.16402960f, 0.03343286f, -0.07347857f, 0.14329889f, 0.13443318f, 
    -0.21020605f, 0.02063181f, -0.03660153f, -0.04575920f, -0.05881324f, 0.05179263f, -0.08987816f, 0.12598011f, 
    0.00331106f, -0.01723084f, 0.02837877f, -0.00872601f, 0.03901874f, 0.10080981f, 0.09167258f, -0.06575183f, 
    0.23139599f, 0.10353032f, -0.01122301f, -0.06679186f, -0.01733165f, -0.07555268f, -0.10538686f, 0.05638037f, 
    0.05789847f, 0.12008785f, 0.01726253f, -0.04835890f, -0.20265104f, 0.06782863f, -0.05808548f, -0.07652700f, 
    -0.08732673f, 0.22235094f, 0.02237464f, 0.03736183f, -0.03171038f, 0.12242017f, 0.03163230f, 0.02034957f, 
    0.24437708f, 0.09804431f, -0.41707465f, -0.04787506f, -0.07420499f, 0.03240427f, -0.03167319f, 0.08536406f, 
    0.08927576f, -0.05015601f, -0.08073328f, -0.23764157f, 0.07942190f, 0.25525728f, -0.04640845f, -0.01491874f, 
    -0.05319591f, 0.08225334f, 0.09885753f, 0.04872994f, -0.20583940f, 0.12658142f, 0.16344737f, -0.06590678f, 
    0.03663960f, 0.07349314f, -0.02296078f, 0.09230339f, 0.00162707f, -0.02548530f, -0.31617045f, -0.03560115f, 
    -0.10741526f, -0.06687686f, 0.09539416f, 0.02987355f, -0.12722273f, -0.09275109f, -0.04045887f, -0.08687202f, 
    0.15430042f, -0.08022191f, 0.02309352f, -0.03139898f, -0.00860506f, -0.04910078f, 0.07819187f, -0.10749711f, 
    -0.05827943f, 0.14543299f, -0.07307366f, 0.00790896f, 0.10922170f, 0.17747842f, 0.14924628f, 0.13012406f, 
    -0.30095574f, -0.30065992f, -0.22614257f, -0.02506362f, -0.08174627f, 0.11449153f, -0.05118524f, -0.16373125f, 
    -0.11758148f, -0.53754222f, 0.41341287f, 0.00491077f, -0.07263178f, -0.23865503f, 0.04122925f, -0.14867489f, 
    0.06001068f, 0.13954593f, -0.45325953f, 0.35869271f, 0.04594080f, -0.06366984f, -0.28705564f, 0.02954850f, 
    -0.09019636f, 0.06546032f, 0.00607862f, 0.37900791f, -0.19349132f, -0.12617584f, 0.21076146f, 0.10664198f, 
    -0.01893680f, 0.15135860f, -0.03142713f, -0.10965629f, -0.01955967f, -0.00644637f, -0.32244834f, 0.01009160f, 
    -0.00296477f, 0.07701448f, 0.00835318f, -0.00868126f, -0.00029856f, 0.00336923f, -0.05672513f, 0.02215521f, 
    -0.23194306f, 0.06053578f, 0.11571226f, 0.02831051f, 0.06553508f, -0.11924960f, 0.03732176f, 0.30696771f, 
    0.48912138f, -0.03375567f, -0.01985847f, 0.05414874f, 0.11113852f, -0.06250609f, 0.08352517f, 0.11890256f, 
    0.19335382f, 0.00556303f, -0.06935547f, 0.13537177f, 0.20336242f, 0.04791010f, 0.16879962f, 0.16811867f, 
    0.20962094f, -0.33690652f, -0.31074616f, 0.05062367f, -0.00143327f, -0.09484848f, -0.01290590f, -0.10674524f, 
    -0.05122285f, 0.12646054f, 0.14349757f, 0.09859713f, 0.02776601f, 0.16626385f, -0.07563803f, 0.13866751f, 
    -0.06076065f, -0.03122684f, 0.00090493f, 0.23645490f, 0.12408657f, -0.08627403f, -0.02480182f, 0.09582268f, 
    -0.05551732f, -0.00345040f, -0.35838205f, -0.07581795f, 0.27134910f, 0.02007516f, 0.03218098f, -0.05110820f, 
    0.09184273f, -0.10890712f, -0.04964163f, -0.18570544f, -0.04892408f, -0.06566662f, 0.04258060f, 0.03707187f, 
    -0.14868529f, -0.27558905f, -0.30729166f, -0.08749989f, -0.05560236f, -0.07237595f, 0.21983433f, 0.00479503f, 
    -0.13088349f, 0.06465439f, -0.08007499f, 0.10752211f, -0.00888016f, -0.04618216f, 0.12037058f, -0.13931172f, 
    -0.39712477f, 0.08886161f, 0.22059706f, -0.04126156f, 0.20657742f, -0.05284757f, 0.06693925f, 0.00928622f, 
    -0.21124360f, 0.19025782f, -0.11136536f, 0.04155009f, -0.18956420f, 0.25203058f, -0.02562156f, 0.05514107f, 
    0.04856385f, -0.33005360f, -0.10524210f, -0.03216494f, 0.12189615f, 0.13436937f, -0.05335681f, 0.09235222f, 
    -0.16682076f, -0.27541417f, -0.19905536f, 0.27446163f, -0.18588655f, -0.01235178f, -0.09011345f, 0.13454682f, 
    -0.04613166f, 0.03451467f, -0.15877198f, -0.11241157f, 0.31110251f, -0.18712889f, 0.03024743f, -0.10349208f, 
    -0.10095150f, 0.02336868f, 0.06630788f, -0.08506641f, 0.20100594f, 0.15476023f, 0.12280961f, 0.07529844f, 
    -0.17055918f, -0.19659798f, -0.16967052f, -0.13398951f, -0.15959403f, 0.21786922f, -0.10828881f, -0.02381248f, 
    -0.23656143f, 0.12559883f, -0.03852334f, -0.02068084f, 0.06461540f, 0.10716832f, -0.01123217f, 0.03805705f, 
    0.03404072f, -0.07089096f, 0.06966628f, 0.09146928f, -0.03699863f, 0.05735045f, 0.21351251f, -0.25375226f, 
    -0.35700834f, 0.10469165f, 0.14293261f, 0.01345525f, -0.12590684f, 0.00418154f, -0.07091976f, 0.10797531f, 
    0.08964018f, 0.13430455f, 0.09047952f, 0.11182909f, -0.03464354f, -0.06522311f, 0.01247780f, 0.05327697f, 
    0.15863219f, -0.12051231f, -0.10164736f, 0.12821670f, -0.13145937f, -0.16032375f, 0.02872971f, -0.20241769f, 
    0.01873850f, -0.00004128f, 0.08610096f, 0.09379622f, 0.03049428f, -0.14647344f, 0.10305610f, 0.08445895f, 
    -0.08014138f, -0.05201397f, -0.00620389f, 0.06313048f, 0.32707635f, 0.04453325f, -0.13513766f, 0.08828231f, 
    0.18849716f, -0.17715666f, 0.14999850f, 0.10112903f, -0.32212800f, -0.07648719f, -0.20895039f, -0.11844921f, 
    0.16061257f, 0.12610161f, 0.06556298f, 0.20085935f, 0.06034858f, 0.10099805f, -0.25309041f, -0.03575394f, 
    0.15192187f, -0.00196160f, 0.04385075f, -0.03411498f, 0.14359072f, 0.21601692f, 0.15138578f, 0.08518616f, 
    0.07764121f, -0.09866539f, 0.16604272f, 0.12537527f, -0.01757588f, 0.11006652f, -0.15646140f, -0.22094157f, 
    -0.23658186f, -0.06804419f, 0.01631050f, 0.20137830f, -0.09423216f, 0.14122286f, 0.08530752f, 0.16181524f, 
    0.07856946f, -0.06714631f, 0.01555273f, 0.06626326f, -0.03178656f, -0.19507509f, -0.12359974f, -0.17493610f, 
    -0.03389616f, 0.00600547f, -0.01364361f, -0.02861255f, -0.02510398f, 0.01523406f, 0.04052140f, -0.03500162f, 
    0.00581225f, 0.01608293f, 0.00264878f, -0.01116598f, -0.01337881f, 0.00148628f, -0.06329477f, -0.06273237f, 
    -0.04647963f, 0.00744817f, -0.01003210f, 0.00127741f, -0.03241335f, -0.05073546f, 0.02518880f, 0.04528113f, 
    -0.05400468f, 0.00425600f, 0.01729303f, -0.02931560f, 0.02717599f, -0.04551912f, -0.00688059f, 0.00530055f, 
    0.02591208f, 0.00562051f, -0.04373032f, -0.01553156f, 0.01081159f, -0.01380877f, 0.01730887f, -0.05146652f, 
    0.02472908f, -0.05880960f, -0.05811589f, -0.04570233f, 0.03186669f, -0.00750212f, 0.00672670f, -0.03778236f, 
    0.00275437f, -0.05449140f, 0.00500166f, -0.03051223f, 0.01089750f, 0.01006460f, -0.01751453f, 0.00030239f, 
    -0.05131901f, 0.02987947f, 0.00925712f, -0.02736396f, -0.01945553f, 0.00735648f, -0.06432999f, -0.02106200f, 
    0.00936854f, 0.02538227f, 0.03168366f, -0.05483494f, -0.00004422f, -0.04769939f, -0.05560140f, -0.01693468f, 
    0.03840678f, -0.00532643f, -0.06178350f, 0.03229462f, 0.00705611f, 0.00538221f, 0.04592834f, -0.05525328f, 
    0.01456499f, 0.00241481f, -0.02362353f, -0.01745484f, 0.01223211f, 0.00710528f, -0.00866633f, -0.05315559f, 
    0.01862018f, 0.01420047f, 0.02496299f, 0.00271810f, -0.04970141f, -0.04134765f, 0.02302018f, 0.01771117f, 
    0.00794622f, 0.03916299f, 0.02027021f, 0.04181511f, -0.02583084f, 0.03591943f, -0.04733692f, -0.05699633f, 
    0.05215307f, -0.00169642f, -0.01546778f, -0.03755739f, 0.04452208f, -0.05812958f, -0.03259443f, 0.02322140f, 
    -0.01633054f, -0.06440658f, -0.02406864f, -0.01580214f, -0.02136712f, -0.02805697f, 0.02582232f, -0.04947345f, 
    -0.03386823f, -0.03912050f, 0.05217127f, -0.02549832f, 0.00130206f, 0.04242276f, -0.02561670f, -0.05790936f, 
    0.00919192f, -0.04080369f, -0.03729448f, -0.03784716f, -0.00403270f, 0.04234365f, -0.00099180f, 0.03325346f, 
    -0.00285927f, 0.02310397f, -0.05088448f, 0.02985710f, 0.00632836f, 0.01369640f, -0.04731584f, 0.01165945f, 
    -0.03809775f, -0.04173020f, 0.04598792f, -0.01398668f, -0.04464475f, -0.05395062f, 0.03488896f, 0.02499809f, 
    0.02377887f, -0.05466327f, 0.01121996f, 0.03989989f, -0.06307952f, 0.05482538f, 0.02880541f, 0.03872253f, 
    -0.01678841f, -0.04481804f, -0.02523923f, -0.01292080f, 0.05605225f, 0.02557145f, -0.01091381f, 0.02853399f, 
    0.01949227f, 0.01360732f, -0.04891393f, -0.04580155f, -0.06342570f, 0.00126756f, -0.03234146f, -0.01768057f, 
    0.03622735f, 0.01743154f, -0.02023437f, -0.01762530f, 0.00668202f, 0.02552177f, 0.00045503f, -0.01541821f, 
    0.02538090f, 0.03501580f, -0.04318887f, 0.00171198f, -0.03434468f, -0.03234022f, -0.01066486f, 0.04015074f, 
    0.00289601f, 0.00182349f, 0.02900769f, 0.03349960f, 0.04584041f, -0.03518249f, -0.02976268f, 0.04458987f, 
    -0.04503774f, 0.01107608f, 0.04908932f, -0.06378391f, 0.03466145f, -0.05473333f, -0.00812197f, -0.00952749f, 
    -0.05997984f, 0.02121981f, -0.01587083f, 0.04851627f, 0.04984942f, -0.04130002f, 0.03410581f, -0.02823269f, 
    -0.00741710f, -0.03416822f, 0.00051185f, -0.05522382f, 0.00497740f, 0.02419502f, 0.00737763f, -0.05536423f, 
    -0.02862898f, -0.01936493f, 0.00314399f, -0.06172306f, 0.03577692f, -0.03152118f, -0.05253670f, -0.04670386f, 
    -0.05366544f, 0.04555747f, -0.04397136f, -0.01316384f, -0.05780251f, 0.00960775f, 0.00713260f, 0.01108644f, 
    0.03729898f, -0.01544404f, -0.00847251f, 0.03685291f, 0.02294417f, -0.03867537f, 0.04906447f, 0.00949924f, 
    0.03579877f, -0.04637177f, -0.03055378f, 0.05276383f, 0.03315591f, -0.05481304f, -0.04924656f, 0.04655390f, 
    -0.04530786f, 0.03893760f, -0.04872849f, -0.01204479f, 0.00332572f, 0.03688742f, -0.00187293f, -0.03962007f, 
    0.00145718f, -0.02346013f, -0.03427580f, -0.01658514f, -0.01220711f, 0.04118299f, -0.04186112f, 0.00485975f, 
    -0.04565078f, -0.03115651f, 0.01021391f, -0.03984870f, -0.03201064f, -0.02241824f, -0.04975877f, 0.00768466f, 
    -0.05665771f, 0.00985704f, -0.02903198f, 0.01765936f, -0.04938436f, 0.04867241f, 0.00333428f, -0.01509136f, 
    0.16464761f, 0.11766238f, 0.12156682f, -0.09687757f, 0.02741172f, -0.13618197f, 0.04812150f, 0.01979136f, 
    0.16535601f, -0.56978965f, -0.59080672f, -0.44617593f, -0.03294439f, -0.12628400f, -0.09577640f, -0.14430800f, 
    -0.24880256f, 0.03530196f, -0.50341988f, -0.41940972f, -0.40846163f, 0.01460719f, -0.13774805f, -0.12164047f, 
    -0.12603058f, -0.17653808f, -0.00945499f, 0.33575082f, 0.21544999f, -0.00174528f, 0.02618879f, 0.04812988f, 
    0.04527614f, -0.03544765f, -0.02616826f, -0.00509151f, 0.10265499f, 0.13091148f, 0.17422575f, -0.08370786f, 
    -0.02043873f, -0.03178596f, 0.08398283f, -0.03434650f, 0.11139450f, -0.18477823f, -0.15452516f, -0.17355026f, 
    -0.09984925f, 0.13180374f, 0.08258662f, -0.05370367f, -0.16337314f, 0.14448209f, 0.11594833f, -0.12978715f, 
    -0.15591969f, -0.24283722f, -0.07331377f, -0.12020334f, -0.03758983f, -0.03028827f, 0.01581244f, 0.19133882f, 
    0.19227570f, -0.08684362f, -0.18437332f, -0.13573866f, -0.06822686f, 0.02268015f, -0.25705245f, -0.06934516f, 
    -0.08735956f, -0.03463257f, 0.03984735f, 0.17270203f, -0.08480386f, 0.13763405f, 0.01269238f, 0.04619980f, 
    0.06276127f, -0.10494429f, -0.22922549f, 0.16228786f, 0.02526922f, 0.08642953f, 0.08056072f, -0.04279367f, 
    -0.04743255f, 0.08238537f, -0.03126568f, -0.13775025f, 0.04506473f, 0.12972578f, 0.03483951f, -0.00895800f, 
    0.01317860f, 0.03637677f, 0.18907264f, 0.08412436f, -0.46283865f, -0.10134422f, 0.07080412f, -0.14545991f, 
    0.21038155f, 0.03422796f, 0.01501654f, 0.07921965f, -0.01852189f, 0.08976898f, 0.05100653f, -0.00688434f, 
    0.01197826f, -0.00590900f, 0.08570415f, 0.05400383f, -0.02380235f, -0.11189453f, -0.05153923f, -0.11809443f, 
    0.01001785f, 0.06729577f, 0.13273637f, 0.06375775f, -0.06151866f, 0.02102222f, 0.17416126f, 0.11174889f, 
    0.25256678f, 0.12780853f, -0.21805939f, -0.23153506f, -0.17699406f, 0.14474489f, 0.14932850f, 0.31028289f, 
    -0.45266682f, -0.08660531f, 0.00269039f, 0.09912821f, 0.06082822f, 0.05128338f, 0.06418791f, 0.05143391f, 
    -0.07017937f, -0.32043123f, 0.14437692f, -0.05396254f, 0.03830770f, 0.16979167f, 0.05512555f, 0.11408690f, 
    -0.09351257f, 0.19954742f, -0.20783798f, 0.08005077f, -0.03535777f, -0.08686091f, 0.01383977f, -0.04907060f, 
    0.02029367f, -0.05446237f, 0.02640530f, -0.20896465f, -0.15124075f, -0.30390340f, -0.15741573f, -0.03326869f, 
    -0.08673727f, 0.04423461f, -0.18466054f, -0.31704652f, -0.04259377f, 0.22795686f, -0.02944800f, 0.05850380f, 
    -0.12226268f, -0.15399383f, -0.01920582f, -0.07912585f, -0.03004787f, 0.00144612f, 0.18267696f, 0.09569701f, 
    -0.13714716f, 0.14204115f, -0.06939866f, -0.04398011f, 0.07098714f, -0.05583824f, 0.09481488f, 0.10963561f, 
    -0.27285078f, -0.11194668f, -0.03799889f, 0.05288861f, -0.05213095f, -0.02502587f, 0.00490364f, 0.12185103f, 
    0.17895618f, 0.19019735f, -0.04845146f, 0.06067991f, 0.04078424f, 0.05420820f, 0.10178895f, 0.13244838f, 
    0.27103546f, 0.03964805f, -0.06427617f, -0.00782164f, -0.18271293f, -0.02876668f, -0.01178146f, -0.04842485f, 
    -0.04578603f, 0.05971604f, 0.15026538f, -0.03271190f, 0.05050424f, -0.21480942f, 0.03727356f, -0.04720156f, 
    0.02311806f, 0.06934769f, -0.18886670f, 0.32439202f, 0.04680397f, -0.19537684f, -0.20195606f, -0.12159931f, 
    0.15188059f, 0.05229726f, -0.05395330f, 0.00564707f, 0.24292080f, -0.11854032f, -0.06955566f, -0.02733575f, 
    0.22831203f, -0.06410821f, 0.15848494f, 0.07215312f, 0.04086297f, 0.01722824f, -0.19444557f, 0.10525090f, 
    -0.09399307f, -0.05375928f, -0.01748081f, -0.06953704f, 0.10262751f, 0.04580555f, 0.12147339f, -0.12369626f, 
    -0.02292787f, 0.01279843f, 0.13150945f, -0.07373988f, -0.01555761f, -0.01089189f, -0.32483780f, -0.14633243f, 
    -0.03711917f, 0.03843001f, 0.18810405f, -0.00536391f, -0.06053432f, -0.08792865f, 0.20298822f, 0.11225557f, 
    -0.04687090f, 0.03988318f, 0.03783366f, 0.07888332f, 0.04362141f, 0.09827186f, -0.08338872f, 0.23156901f, 
    0.20155770f, 0.13370292f, 0.17348632f, -0.01289759f, -0.12988470f, 0.07148944f, 0.02335208f, 0.07350834f, 
    0.05921653f, -0.00289658f, -0.05317286f, -0.07787092f, 0.16338997f, -0.01994561f, -0.03046702f, 0.05390826f, 
    -0.04670217f, -0.12462424f, -0.09511637f, -0.12357228f, 0.25436231f, 0.02632745f, 0.12143819f, -0.22266117f, 
    -0.28625700f, -0.21508974f, 0.22568351f, 0.23999499f, 0.18013984f, 0.22146629f, -0.00020368f, 0.01302636f, 
    -0.22076312f, -0.06333310f, -0.20468087f, 0.09365978f, -0.01931037f, 0.17470203f, 0.10418635f, 0.10724579f, 
    -0.02010590f, -0.15125713f, -0.15348886f, -0.06000421f, -0.13731492f, -0.18454830f, -0.03897721f, 0.05152653f, 
    0.00860342f, -0.00169174f, -0.07845778f, 0.03071826f, -0.17382374f, -0.03993217f, 0.24165700f, -0.03112645f, 
    0.06296628f, -0.01748058f, 0.13242936f, -0.14425141f, 0.05736532f, -0.07230771f, -0.17416248f, -0.10760315f, 
    -0.06154356f, -0.12799133f, -0.10471359f, 0.01589092f, 0.03968520f, 0.27893949f, 0.10251766f, -0.00937631f, 
    -0.06487036f, -0.36023149f, 0.33981451f, -0.06236002f, -0.09853031f, -0.04592872f, 0.11488836f, -0.05205314f, 
    -0.11387247f, 0.14744739f, -0.06431631f, -0.04621303f, -0.05230932f, 0.20238549f, 0.03953831f, 0.08307191f, 
    -0.02228152f, -0.07398918f, 0.07984833f, 0.01475378f, 0.15712470f, -0.02044784f, -0.27346763f, 0.12299522f, 
    0.13123825f, 0.01310657f, -0.03846523f, 0.10897418f, -0.04263451f, 0.03199397f, -0.03131788f, -0.06367437f, 
    0.25026533f, 0.30608329f, 0.22165160f, -0.05424885f, -0.24699096f, 0.07742241f, -0.03521272f, 0.06931803f, 
    0.01201669f, 0.02391598f, -0.04254421f, 0.19321203f, 0.23237136f, 0.03806386f, 0.23388693f, 0.09137082f, 
    0.04806233f, -0.16123953f, 0.06394592f, 0.08014186f, -0.00826974f, 0.00189008f, 0.12564804f, 0.00089553f, 
    0.11403150f, -0.05922521f, -0.06857263f, 0.13057306f, 0.20394722f, 0.26701576f, -0.07652079f, 0.30244640f, 
    -0.09149905f, 0.15704502f, -0.00627977f, 0.06079618f, -0.02623641f, 0.09584721f, -0.02829974f, -0.11056972f, 
    0.13225819f, 0.19978131f, 0.16424005f, -0.01481719f, 0.04512549f, -0.05669663f, 0.07225514f, 0.00126972f, 
    0.02201372f, 0.28840098f, 0.14654863f, 0.20165177f, -0.08701586f, -0.15069838f, -0.09886205f, 0.09020131f, 
    -0.01654543f, -0.06911635f, 0.02196390f, 0.20144467f, -0.01934445f, 0.12650010f, -0.04242642f, -0.19472891f, 
    -0.16684864f, -0.19022837f, -0.25230572f, -0.00018462f, 0.08087593f, -0.04289553f, -0.03143269f, -0.04056372f, 
    -0.04731583f, -0.15191834f, -0.20633398f, -0.18750966f, 0.12433942f, -0.23473664f, -0.00701451f, 0.04804279f, 
    -0.01770079f, -0.16970070f, 0.13069224f, 0.22138478f, -0.22198899f, -0.13070060f, -0.00205666f, 0.14882350f, 
    0.25556198f, -0.01534535f, -0.04761360f, -0.09578113f, -0.02681745f, -0.23141265f, -0.09752821f, -0.18919171f, 
    0.10907338f, 0.10590141f, 0.07971703f, -0.00148822f, 0.04614792f, -0.07944004f, -0.01030724f, 0.23476458f, 
    -0.09780524f, -0.00123197f, -0.01986788f, 0.01698904f, -0.09128008f, -0.02544602f, -0.09371338f, -0.14666775f, 
    -0.01040838f, -0.14970015f, 0.05715656f, 0.01948544f, 0.05636864f, -0.02054919f, -0.05710299f, -0.04788833f, 
    0.03307769f, 0.01439441f, -0.21392845f, -0.11009409f, -0.11693362f, 0.07548072f, 0.02764011f, 0.11808951f, 
    -0.03864581f, -0.09663913f, 0.03987332f, 0.25472763f, 0.04787444f, 0.10427099f, 0.02045903f, 0.18372615f, 
    0.08620976f, 0.06625144f, -0.06289522f, -0.12059907f, -0.16911839f, 0.18122388f, 0.00940742f, 0.10411550f, 
    0.02648717f, 0.06151575f, -0.02499216f, -0.05241941f, 0.14804488f, 0.10338861f, -0.02929776f, 0.13031213f, 
    -0.01218278f, -0.14576253f, -0.08988028f, 0.29225284f, -0.32667282f, -0.03995143f, 0.02952010f, 0.05145276f, 
    -0.04652146f, -0.08944549f, -0.08680756f, -0.00711339f, -0.12304851f, 0.04214459f, 0.04643723f, 0.16948253f, 
    -0.00306889f, 0.04106968f, 0.01039834f, -0.04021419f, -0.00477107f, -0.09401857f, -0.05955336f, -0.04485134f, 
    0.11598252f, -0.03468346f, 0.10743521f, 0.02614210f, -0.02708694f, -0.14747389f, 0.16815542f, -0.02027903f, 
    0.02148091f, 0.07351460f, -0.07887392f, 0.06484652f, -0.00813515f, 0.06017261f, -0.01518225f, -0.02770982f, 
    -0.03949870f, 0.01067687f, -0.06193886f, 0.00371061f, 0.00809496f, -0.00261427f, -0.03818268f, 0.00426974f, 
    -0.04458407f, -0.01118847f, 0.02022669f, -0.01179617f, -0.03175328f, 0.02408384f, 0.00617107f, -0.04393646f, 
    0.01655918f, -0.02281325f, 0.02070538f, 0.04832761f, -0.06431972f, -0.02772680f, -0.01283117f, 0.03538993f, 
    0.04368885f, -0.06745401f, 0.03628254f, -0.05227891f, 0.03759545f, 0.02392785f, -0.00868161f, -0.01132140f, 
    -0.01234434f, -0.06490414f, 0.03000604f, -0.03603183f, -0.00647736f, 0.01956034f, 0.00161787f, 0.00137314f, 
    -0.03476497f, 0.03483121f, 0.04667493f, -0.03896387f, -0.01257964f, -0.00614325f, -0.00805244f, -0.04928107f, 
    0.00247976f, 0.03936002f, 0.00942529f, -0.04708999f, 0.00247556f, -0.04592382f, -0.03275896f, -0.00223500f, 
    -0.02917434f, -0.00950145f, 0.03278321f, -0.01074326f, 0.02261612f, 0.03590403f, -0.06455527f, 0.03263841f, 
    0.03993480f, -0.01744127f, -0.02413237f, 0.04476848f, -0.05946349f, -0.04862196f, -0.03578409f, -0.00709977f, 
    -0.04880719f, 0.04774044f, 0.00528475f, -0.05225302f, 0.02949871f, -0.01288977f, -0.02030756f, -0.01115510f, 
    -0.03860188f, 0.02267925f, -0.03161364f, -0.05217490f, 0.01984663f, -0.05675523f, -0.01664258f, -0.03140696f, 
    -0.01293202f, -0.06229281f, 0.03696146f, -0.06036155f, 0.00656730f, 0.04665532f, -0.01663266f, 0.03928977f, 
    -0.01337677f, 0.02611016f, -0.06459820f, -0.04806855f, 0.02834492f, 0.03600627f, -0.02518236f, 0.00854236f, 
    0.03994032f, 0.01281124f, -0.04463800f, 0.02689443f, -0.00445888f, -0.01332103f, -0.01166415f, -0.04013581f, 
    -0.02015896f, -0.03561512f, -0.04444266f, -0.05098597f, -0.02759613f, -0.05261397f, 0.04008633f, -0.01832983f, 
    0.00781065f, -0.05283711f, 0.05339237f, -0.05975745f, 0.04197960f, 0.05024075f, 0.02939973f, 0.05126473f, 
    -0.03127768f, 0.00755802f, -0.05862506f, 0.03033879f, -0.05024550f, -0.00006357f, -0.01459348f, -0.03797456f, 
    0.03415977f, -0.03351280f, -0.02527618f, -0.02835875f, 0.00970032f, 0.03261328f, -0.03009253f, -0.01191677f, 
    0.04284294f, -0.01732747f, 0.02603236f, -0.00772136f, 0.00039193f, -0.04807093f, 0.01241679f, -0.01655500f, 
    -0.06491318f, -0.00903117f, -0.03989479f, 0.00326914f, -0.00963619f, 0.01026280f, -0.04464388f, 0.02779938f, 
    -0.04494933f, -0.06569944f, 0.05547182f, -0.01468979f, -0.03132031f, -0.03105799f, -0.04778364f, -0.02959978f, 
    0.00699798f, 0.00990759f, -0.04325495f, 0.03116706f, -0.00137949f, 0.03747012f, -0.02712663f, 0.01732065f, 
    -0.00950678f, 0.02557552f, -0.00986390f, -0.04396393f, -0.02671623f, 0.05706682f, 0.00794609f, 0.00934263f, 
    0.04514922f, 0.00029791f, 0.03519677f, -0.02140703f, 0.03890859f, -0.02107844f, -0.05171196f, -0.01289968f, 
    -0.05158710f, -0.05754508f, -0.04544475f, -0.00548028f, 0.02694667f, 0.02863139f, -0.05765759f, -0.01898662f, 
    -0.04804995f, -0.05494604f, -0.01365387f, 0.01335064f, -0.03748706f, -0.05174232f, -0.04920776f, -0.02982269f, 
    -0.05241435f, -0.04642057f, -0.04923959f, 0.02090348f, -0.02751649f, -0.00822634f, -0.02659414f, 0.00309494f, 
    -0.03268529f, 0.04404576f, 0.04007617f, 0.05194091f, -0.04199517f, -0.02847857f, 0.03353628f, 0.01349103f, 
    0.02554279f, -0.05306818f, -0.00554053f, 0.04518177f, -0.02810057f, -0.05352511f, -0.02879439f, -0.01602359f, 
    0.02230215f, -0.00208105f, 0.03997746f, 0.02608361f, 0.01537581f, 0.03912986f, 0.04396452f, 0.00631931f, 
    0.01854880f, -0.03813530f, -0.05711382f, 0.03639371f, -0.00763849f, 0.02490803f, 0.03760441f, -0.01480792f, 
    0.04272299f, -0.02813747f, 0.00050269f, -0.06109749f, -0.03903461f, -0.03512194f, 0.00139563f, 0.00566079f, 
    -0.02201472f, 0.00962386f, 0.05943917f, -0.01593392f, -0.02117752f, 0.04599505f, 0.03924374f, -0.04438844f, 
    0.01483192f, 0.02615457f, -0.03209551f, -0.04413845f, 0.01360079f, -0.00289691f, -0.00332995f, 0.03497986f, 
    0.04625229f, -0.01610605f, 0.02958414f, -0.04494154f, 0.02123921f, -0.01678989f, -0.03621440f, -0.00063474f, 
    -0.05382219f, -0.06342549f, 0.02428483f, -0.00870789f, 0.02008034f, 0.03187747f, -0.05748880f, 0.01378965f, 
    -0.02805083f, -0.11516384f, 0.12160129f, 0.04014985f, 0.16718197f, 0.00261883f, 0.05440881f, 0.11379830f, 
    0.09762560f, 0.36089519f, 0.14656454f, -0.07842019f, -0.01214258f, -0.27329606f, -0.00162862f, 0.07305153f, 
    0.08702992f, -0.00694271f, -0.09848884f, -0.09221249f, -0.16493693f, 0.06342780f, -0.17323028f, -0.03764239f, 
    0.05536216f, -0.04528307f, -0.06751614f, 0.02660851f, -0.14326860f, -0.32275781f, 0.19983107f, -0.02788803f, 
    -0.05662173f, 0.08323579f, 0.05935443f, 0.06475662f, 0.13255432f, 0.20968375f, 0.28784195f, -0.23980403f, 
    -0.09366245f, -0.12806037f, 0.10812736f, 0.16311032f, 0.14997953f, 0.08639079f, -0.24319977f, -0.02060035f, 
    -0.27057388f, -0.03217641f, 0.03117592f, -0.08801828f, 0.17770199f, 0.18544050f, 0.39211521f, 0.30908576f, 
    0.18215635f, -0.03642027f, -0.06350039f, -0.08735981f, 0.05863908f, 0.10772642f, -0.16627142f, 0.09782805f, 
    0.17117177f, 0.21917291f, -0.13185835f, -0.06023826f, 0.05046305f, 0.15628022f, 0.11023712f, 0.01147621f, 
    0.16890147f, 0.09933680f, -0.12815981f, 0.10780279f, -0.03135137f, 0.01510622f, 0.22291321f, -0.07892910f, 
    0.11773272f, -0.15510206f, -0.05946682f, 0.09705012f, 0.02765731f, 0.13339414f, 0.03649220f, -0.12547158f, 
    -0.06880496f, -0.01206639f, -0.08337814f, -0.15160735f, -0.25779232f, 0.07049675f, 0.14580253f, -0.16186780f, 
    -0.11279681f, -0.12418660f, -0.17967455f, -0.02416640f, 0.07157065f, -0.34459576f, -0.05489705f, 0.07011648f, 
    0.16619031f, 0.10920619f, 0.08421586f, -0.08104120f, -0.36296833f, -0.13785192f, -0.21924175f, 0.02709929f, 
    0.12838385f, -0.03396646f, -0.05820233f, 0.01845956f, -0.08898827f, 0.39611274f, 0.30992368f, 0.06798515f, 
    -0.07160848f, -0.07667013f, -0.10808251f, 0.13107851f, -0.01532583f, -0.11078797f, -0.03643870f, -0.10744517f, 
    0.03653948f, 0.06558888f, -0.14163144f, -0.02510503f, -0.03614809f, 0.09802659f, -0.12467431f, 0.17924228f, 
    0.04493178f, -0.00335142f, -0.18024153f, -0.08738114f, -0.06294470f, 0.31299865f, -0.10165656f, 0.07369050f, 
    -0.08502770f, -0.11320651f, 0.04506976f, -0.00761726f, -0.00146743f, 0.26164228f, -0.07257209f, -0.00069868f, 
    -0.09543622f, -0.20775333f, -0.51142544f, -0.26189566f, -0.00745522f, 0.02690982f, -0.07021511f, 0.01661521f, 
    0.00015832f, -0.03672424f, 0.41646555f, -0.02426896f, -0.44482002f, 0.06459580f, -0.02878217f, -0.07844643f, 
    -0.01391205f, 0.03436753f, -0.24789999f, -0.09848141f, -0.04623768f, -0.18152037f, 0.05383003f, 0.10570035f, 
    -0.02039616f, -0.22994874f, -0.06691584f, -0.21294284f, 0.34095961f, 0.18117037f, 0.13661347f, -0.21888943f, 
    -0.07103457f, -0.11267076f, 0.23777211f, 0.07221018f, 0.12953973f, 0.29171109f, 0.06404573f, 0.21305604f, 
    0.01359903f, -0.03990676f, -0.14773887f, 0.11317807f, 0.06163323f, -0.03801700f, 0.02995552f, 0.00320329f, 
    -0.13274473f, 0.08948017f, -0.03243991f, 0.12426431f, -0.00353221f, 0.05364499f, -0.14585763f, 0.14473249f, 
    0.17045572f, 0.06460983f, 0.05795373f, 0.13545045f, 0.01066880f, 0.03999137f, 0.14184269f, -0.01698090f, 
    0.08239590f, -0.06742829f, 0.11420958f, -0.02104852f, 0.18471022f, 0.00144626f, 0.23909140f, 0.00387183f, 
    0.11566822f, -0.46806106f, -0.10821881f, 0.05344318f, -0.12012220f, -0.00773810f, -0.15881185f, 0.01607643f, 
    -0.06120104f, 0.06145124f, -0.08016548f, -0.33509582f, 0.17617987f, 0.18133314f, -0.18409346f, -0.20067702f, 
    -0.07493859f, -0.03224780f, 0.42247665f, 0.07052218f, -0.00002045f, 0.21309206f, -0.00704280f, 0.00372144f, 
    -0.13136280f, 0.20483540f, 0.05227858f, -0.09382392f, 0.16222511f, 0.13812990f, 0.08451383f, 0.06444234f, 
    -0.06382211f, -0.09641273f, -0.01608812f, 0.16154347f, 0.07085399f, -0.45733735f, -0.25723097f, -0.31656381f, 
    -0.00376692f, -0.03611955f, -0.11674488f, 0.00943160f, -0.10269238f, -0.06245330f, 0.05810494f, -0.18571827f, 
    0.03492824f, 0.03218518f, 0.07858441f, 0.03846125f, -0.12919773f, 0.01099508f, -0.00277319f, -0.04063758f, 
    -0.21538657f, -0.02426626f, 0.15833873f, 0.09748212f, 0.02251179f, 0.00715004f, -0.10007128f, -0.03739952f, 
    -0.04247237f, -0.10802905f, -0.10893296f, 0.06114322f, 0.18232356f, -0.02498568f, 0.02098394f, 0.00661715f, 
    0.01991395f, 0.13540182f, 0.00227321f, -0.11970271f, 0.05296862f, -0.08492199f, 0.12276947f, -0.17404932f, 
    0.18500575f, 0.04665185f, 0.08630668f, -0.12613280f, -0.09436109f, 0.00400216f, -0.02719303f, 0.02274226f, 
    -0.05113410f, 0.18419835f, 0.20403528f, -0.29435799f, -0.07370621f, 0.01433955f, 0.10632423f, 0.04420919f, 
    0.04592805f, -0.01165181f, 0.14645937f, 0.14342828f, 0.19388385f, 0.16294190f, -0.17059053f, 0.12386882f, 
    0.17799643f, 0.15017442f, 0.03082731f, 0.06567649f, 0.14947569f, 0.09392668f, -0.10588644f, -0.15200111f, 
    0.05510504f, -0.08582148f, -0.04062436f, -0.06740767f, 0.18485007f, 0.23138189f, 0.16794613f, 0.06673460f, 
    -0.05950051f, 0.13649829f, 0.14645639f, 0.06687764f, 0.08673073f, 0.05112152f, -0.12210582f, 0.03772391f, 
    -0.10460866f, -0.15029512f, 0.06948312f, -0.09786150f, 0.18401809f, 0.00367883f, 0.07322753f, 0.01600188f, 
    0.06772017f, 0.04341383f, 0.06114260f, 0.01512525f, -0.08152730f, 0.04879413f, -0.04169402f, 0.07372370f, 
    0.02084175f, 0.11448882f, -0.04910227f, -0.02862161f, -0.00105655f, 0.05620446f, -0.10729408f, 0.10676499f, 
    -0.42908469f, -0.08111857f, 0.07977219f, 0.14424045f, 0.06191623f, -0.00857062f, -0.05695546f, -0.12709850f, 
    -0.16738215f, -0.34250984f, -0.27025822f, -0.12909366f, 0.22368598f, 0.09641708f, 0.08185647f, 0.04663967f, 
    -0.15541607f, -0.04915367f, 0.02649083f, -0.15368511f, -0.22026840f, 0.01725101f, -0.14250281f, -0.05211145f, 
    0.07437569f, 0.06815826f, -0.00545337f, 0.10030193f, -0.02191147f, 0.06276622f, 0.04993757f, -0.11242597f, 
    0.07752917f, 0.06291693f, 0.00265822f, 0.01172042f, 0.01760884f, -0.31480017f, 0.01786005f, -0.11050831f, 
    -0.30308175f, -0.04055524f, -0.07641546f, 0.14634678f, 0.12526150f, 0.06751143f, -0.03946120f, 0.11959883f, 
    -0.09308757f, 0.01676721f, -0.03345074f, 0.08612799f, -0.10459155f, -0.00027553f, -0.11754507f, -0.02068418f, 
    0.10010949f, -0.09610727f, -0.03080678f, 0.05539416f, 0.02816469f, -0.20387220f, 0.09723590f, -0.15452309f, 
    0.01753735f, 0.07925250f, 0.00985309f, -0.00852633f, -0.08229186f, -0.03442940f, -0.14682458f, 0.03800789f, 
    0.07577688f, 0.29163373f, 0.15388127f, -0.10997789f, -0.10556979f, 0.02536132f, -0.20519596f, -0.11941455f, 
    -0.06130442f, 0.10485336f, 0.16655333f, 0.33769095f, -0.07472364f, -0.09470134f, 0.03361062f, -0.00639440f, 
    0.22259176f, -0.01551438f, -0.02733062f, -0.41137138f, 0.00091343f, 0.00893753f, -0.09710332f, -0.04192074f, 
    -0.09773446f, 0.08563261f, -0.04814202f, 0.10622740f, 0.18690774f, 0.18315917f, -0.22928612f, 0.05107977f, 
    0.10584581f, 0.02690677f, -0.00596277f, -0.02063712f, 0.05810093f, 0.01903871f, 0.07913542f, -0.10130227f, 
    -0.16420168f, 0.04639854f, -0.06076319f, 0.09775955f, 0.04901407f, 0.02372740f, -0.05838396f, 0.13836589f, 
    -0.06941316f, -0.15882169f, 0.18750428f, 0.06951958f, 0.06536730f, -0.08822450f, -0.04041212f, -0.05071938f, 
    -0.16590303f, -0.11803060f, -0.01158972f, 0.17725150f, 0.03426939f, 0.05136181f, 0.02145093f, 0.06073664f, 
    0.10686407f, 0.05262090f, -0.03114146f, -0.04283498f, 0.15702495f, -0.04607162f, -0.11597192f, -0.00893325f, 
    -0.05588169f, -0.03040001f, 0.04196968f, -0.02108132f, 0.14398950f, -0.13591805f, 0.10272788f, -0.16614164f, 
    -0.00629553f, 0.03761866f, -0.04419494f, -0.02836902f, 0.20886302f, -0.23806903f, 0.06201402f, 0.00775016f, 
    -0.00473940f, -0.04942364f, -0.00594151f, 0.10172067f, 0.27940369f, -0.18672477f, -0.14934404f, -0.01502126f, 
    0.03475731f, 0.10023142f, 0.07378572f, 0.16215685f, 0.04637325f, -0.10849784f, 0.04208743f, 0.02943932f, 
    0.01021972f, -0.02660013f, -0.07851145f, -0.07883767f, 0.06006894f, 0.18919244f, -0.09696639f, -0.08794130f, 
    -0.20134360f, 0.07074250f, 0.06209698f, 0.01572775f, -0.04771813f, 0.03483009f, 0.08860298f, -0.23044884f, 
    0.05060920f, 0.06252436f, -0.00288992f, 0.02385531f, -0.09616920f, -0.00888819f, -0.13146435f, -0.04223271f, 
    -0.02842445f, -0.01225625f, -0.00739811f, -0.02632645f, -0.05885543f, -0.01928074f, 0.03866240f, -0.02421117f, 
    0.01222968f, 0.01329920f, -0.03325385f, 0.01149946f, 0.00847614f, -0.04690213f, -0.04593508f, 0.00572266f, 
    0.02214409f, 0.03859994f, 0.04811955f, 0.02395643f, -0.02998390f, 0.03840566f, 0.05574721f, 0.05407186f, 
    -0.02714183f, 0.00158301f, -0.03812043f, 0.04315977f, 0.00798331f, -0.02002725f, -0.02478730f, 0.05081288f, 
    -0.00641885f, -0.05572848f, 0.03789889f, 0.02644773f, 0.00036109f, 0.00965106f, -0.06885523f, 0.04748666f, 
    -0.01143293f, -0.00006983f, 0.00691087f, 0.02149635f, -0.01987841f, -0.00800487f, -0.06948315f, 0.04498066f, 
    0.03013908f, -0.05093442f, 0.00844729f, -0.01886130f, 0.00058597f, -0.04056050f, -0.06448026f, -0.04192424f, 
    -0.01772377f, -0.02004128f, 0.04448302f, 0.01372450f, -0.05816649f, -0.01324503f, -0.05989302f, -0.06344274f, 
    0.02313771f, 0.03779584f, -0.01229134f, -0.02162632f, -0.02020083f, 0.02875208f, -0.05775339f, 0.00377340f, 
    0.06166498f, -0.05395130f, 0.01428609f, -0.04542078f, 0.01294531f, 0.03778233f, -0.02616641f, -0.01601802f, 
    0.02493083f, 0.01557240f, -0.05153177f, -0.01589552f, -0.05614719f, -0.00367023f, -0.06115190f, -0.05084303f, 
    -0.06573486f, -0.03581090f, 0.04966611f, -0.06632838f, 0.01754905f, 0.04646092f, -0.00758994f, -0.02301639f, 
    -0.00050958f, 0.03014633f, 0.03482047f, 0.00838822f, -0.04517131f, 0.03244619f, 0.02939850f, 0.04258019f, 
    -0.04731413f, 0.03106160f, -0.01082765f, 0.00177515f, -0.01376457f, 0.04503098f, -0.00723672f, 0.02155635f, 
    -0.03467854f, -0.06871301f, -0.02266357f, 0.02166455f, -0.01302048f, -0.04973789f, -0.05457471f, 0.04357470f, 
    0.01925453f, -0.02142642f, -0.03708075f, 0.03463286f, 0.03066803f, 0.00757729f, 0.03643475f, -0.07083693f, 
    -0.02886092f, 0.04053013f, -0.00998596f, -0.03839435f, 0.03736763f, -0.02024240f, -0.02072430f, -0.05276190f, 
    -0.00639235f, -0.04992968f, -0.01668249f, 0.04547801f, 0.04498437f, -0.03956784f, 0.04282350f, 0.00426686f, 
    -0.05522152f, -0.04152618f, 0.02758535f, -0.03607043f, -0.03414086f, -0.01193679f, 0.03504004f, 0.01858029f, 
    -0.08023407f, 0.02447289f, -0.03020154f, -0.02458473f, -0.00264568f, -0.03258607f, 0.00485400f, 0.00752575f, 
    -0.03114742f, -0.03133369f, 0.00039420f, -0.00443042f, 0.04990095f, -0.03849104f, -0.06443489f, 0.00304685f, 
    -0.01829921f, 0.03231728f, 0.05079700f, -0.05814597f, -0.01690787f, -0.03326375f, -0.00010002f, 0.04641730f, 
    0.00239220f, -0.00401356f, -0.04616359f, -0.02195144f, 0.01045388f, -0.03382849f, -0.07794900f, -0.01065038f, 
    -0.03097058f, -0.00600102f, -0.06001946f, -0.02618092f, -0.02401197f, -0.05667687f, -0.01008092f, 0.03473076f, 
    0.05161417f, -0.00808347f, -0.01611416f, -0.04720851f, -0.03147429f, -0.03652957f, 0.01020625f, -0.06300905f, 
    -0.01433093f, -0.03700014f, 0.00057198f, 0.02132455f, -0.02716685f, -0.00980141f, -0.01831445f, 0.04724461f, 
    0.02044202f, 0.02286562f, 0.00863561f, -0.02390385f, 0.00384741f, -0.04275315f, 0.02799493f, 0.02696627f, 
    -0.05913922f, 0.03348450f, -0.03525050f, 0.01256836f, -0.06776653f, -0.05287475f, -0.05463288f, -0.03566759f, 
    -0.06706157f, -0.03621672f, 0.04369892f, -0.04781223f, 0.04703383f, 0.00644597f, -0.04216936f, -0.01016794f, 
    0.03043956f, -0.05563776f, 0.04796478f, 0.01064139f, 0.01940774f, -0.00161805f, 0.00212913f, -0.00488176f, 
    -0.03650967f, 0.03762316f, 0.01099092f, 0.03309077f, 0.03486250f, -0.00586673f, 0.01673326f, 0.00848756f, 
    0.00163215f, 0.03580836f, 0.03168501f, 0.03691719f, 0.04074422f, 0.03574035f, -0.01186902f, 0.00157041f, 
    -0.04329304f, -0.05276905f, 0.01232811f, -0.06500182f, -0.06429584f, 0.00091387f, -0.04415550f, -0.05464097f, 
    -0.03578575f, -0.02542585f, 0.02159243f, -0.03954641f, 0.03593510f, 0.05001692f, -0.04745917f, 0.03649769f, 
    0.03237050f, 0.02289105f, -0.02904786f, -0.02949486f, -0.04925236f, -0.05822178f, -0.02720810f, 0.06327103f, 
    -0.00929154f, -0.00315192f, 0.03640691f, -0.04329736f, -0.03637888f, 0.02003969f, -0.01207384f, -0.01441633f, 
    -0.04027438f, -0.18416910f, 0.01626555f, 0.06956349f, -0.03447727f, 0.12389625f, 0.20617902f, 0.05634498f, 
    0.00333104f, -0.21359237f, -0.69551277f, -0.17709218f, -0.07227223f, -0.12218015f, -0.03717503f, 0.01003346f, 
    -0.08189311f, -0.00177671f, -0.40455207f, -0.25337052f, 0.26959708f, 0.06761049f, -0.02598645f, -0.04426831f, 
    -0.07642703f, 0.03636746f, -0.08818982f, 0.31906700f, -0.05432964f, -0.11166614f, 0.02298640f, -0.02635345f, 
    0.05399514f, 0.06180108f, 0.06194620f, -0.11506435f, -0.10486614f, -0.06310742f, -0.02030067f, -0.03230552f, 
    -0.21052344f, -0.09295009f, 0.12256119f, -0.03745801f, -0.01612063f, 0.07822606f, 0.18812494f, 0.08930504f, 
    0.03756356f, 0.00166832f, 0.02531692f, 0.16450919f, -0.03234099f, -0.01583877f, -0.20763108f, 0.09935142f, 
    0.30470991f, -0.14262562f, -0.11865665f, -0.09888878f, 0.06362897f, 0.00464430f, -0.04427295f, 0.09618288f, 
    0.04172374f, -0.11601586f, -0.17484923f, 0.04664385f, -0.14025401f, 0.04040045f, -0.04087445f, 0.02722758f, 
    -0.08877441f, -0.26908723f, -0.42146862f, 0.06794301f, 0.03047060f, 0.01207570f, 0.06745081f, -0.01102173f, 
    0.14470309f, -0.06938821f, 0.21984993f, 0.14522108f, -0.09410767f, -0.07756523f, -0.02636979f, 0.03077345f, 
    0.10193352f, 0.09313133f, -0.07514576f, 0.10105807f, 0.16192833f, 0.00199193f, -0.10632339f, -0.03000396f, 
    0.11123151f, 0.01523649f, 0.05645410f, -0.10210259f, -0.09418027f, 0.13340044f, -0.05386672f, 0.05746366f, 
    -0.02816338f, 0.06098885f, -0.11582895f, 0.05870308f, -0.37075150f, -0.00449361f, 0.01016130f, 0.11703216f, 
    -0.02940646f, 0.03322275f, 0.05817853f, -0.01040861f, -0.01497553f, -0.18300365f, -0.18031237f, 0.04538558f, 
    0.01427483f, -0.00723669f, -0.04225182f, 0.17334856f, 0.11929862f, 0.05017171f, -0.05142428f, 0.12589346f, 
    0.24507533f, 0.07271177f, -0.10673501f, 0.04979612f, -0.03082409f, 0.10490079f, -0.04049260f, 0.02684209f, 
    0.03426662f, 0.08978733f, -0.06324385f, -0.04884637f, -0.02655124f, 0.00876994f, -0.00285185f, 0.16225018f, 
    -0.12878878f, 0.10089614f, -0.02201296f, 0.02732422f, 0.04204987f, -0.11062134f, 0.06016780f, 0.04931374f, 
    0.21350303f, 0.01312442f, -0.00062853f, 0.02805617f, -0.00474997f, -0.03989957f, 0.04795047f, 0.10473470f, 
    0.02228271f, -0.00556644f, -0.20316821f, 0.01514140f, 0.01974263f, -0.14222838f, -0.06847293f, 0.04040305f, 
    -0.01178618f, -0.14816451f, -0.21182491f, -0.26729581f, 0.02555306f, 0.14696735f, -0.06872372f, 0.04154169f, 
    -0.14652573f, -0.05592129f, -0.04597123f, 0.02052213f, 0.29913169f, -0.29146835f, -0.00854202f, -0.07757549f, 
    -0.08519062f, -0.19311124f, -0.10831475f, -0.05927191f, -0.04514508f, -0.24652259f, -0.06157256f, -0.13959444f, 
    -0.10364299f, -0.19589901f, -0.05698201f, -0.07605861f, 0.03751544f, 0.04340309f, 0.01001961f, -0.19340323f, 
    -0.24324749f, 0.00255000f, 0.11474442f, 0.06589098f, 0.03857562f, 0.03739727f, 0.14741081f, -0.08711648f, 
    0.01619070f, -0.05127468f, -0.02511527f, 0.14798078f, -0.04666706f, -0.03833399f, 0.01763989f, 0.07571401f, 
    -0.02873654f, 0.07944976f, 0.09807674f, -0.03209151f, -0.10187264f, -0.12153731f, 0.04389962f, 0.08742597f, 
    -0.04659853f, -0.23639064f, 0.12158959f, 0.25108525f, 0.01669356f, -0.01228655f, 0.08146958f, 0.05130460f, 
    0.05151264f, 0.16615291f, -0.07128350f, 0.07942168f, -0.03897563f, -0.00488308f, 0.09956008f, -0.00761778f, 
    0.03324137f, 0.02800960f, -0.04826726f, -0.44790530f, -0.16621123f, -0.08198465f, -0.16038829f, -0.09228242f, 
    -0.10038213f, 0.16321327f, 0.03349380f, -0.08869646f, -0.12567480f, -0.10732766f, 0.13916254f, 0.12852103f, 
    -0.06124226f, 0.00722502f, 0.02949226f, -0.12295186f, 0.00116559f, 0.21383908f, 0.12391776f, 0.13665166f, 
    0.05174046f, 0.11274225f, 0.01635332f, -0.04030045f, 0.02373352f, -0.08565326f, -0.03779617f, -0.14529911f, 
    0.10856427f, 0.02057110f, 0.08672495f, -0.01848878f, 0.13626356f, -0.03814367f, -0.02202990f, -0.03116211f, 
    -0.08651954f, 0.07322616f, -0.07417827f, 0.00055598f, 0.00427429f, 0.03210192f, 0.06534879f, 0.28055623f, 
    -0.03557418f, -0.10709295f, -0.05331786f, 0.02007238f, 0.17132871f, 0.02924600f, 0.04348866f, 0.07337773f, 
    0.11039940f, 0.21152849f, -0.10326427f, -0.20348115f, 0.13620603f, 0.01143254f, -0.05879581f, 0.07184833f, 
    0.09352900f, 0.07983422f, -0.01893157f, 0.09102206f, -0.02382389f, 0.10644979f, -0.04356111f, 0.21842152f, 
    0.18009956f, -0.02280488f, 0.03419141f, 0.07825843f, 0.18077514f, -0.11788663f, 0.00130390f, 0.02880402f, 
    0.03718575f, 0.05472297f, -0.01588215f, 0.03041540f, -0.07789401f, -0.13686906f, 0.17936519f, 0.08288263f, 
    -0.13398798f, 0.00450878f, -0.02445633f, -0.02519146f, 0.11379193f, -0.01857202f, 0.24402057f, 0.05054936f, 
    -0.01457828f, 0.10748772f, -0.05305232f, -0.10355784f, -0.03019913f, 0.11613825f, -0.01326385f, 0.09311334f, 
    0.06563883f, 0.08168182f, 0.01983981f, 0.03108162f, 0.02238972f, 0.03030665f, -0.00772896f, 0.08917987f, 
    -0.03265762f, -0.22816160f, -0.02856686f, -0.04053656f, 0.02149074f, -0.02116682f, -0.09862427f, 0.03826623f, 
    -0.14774516f, -0.07498968f, -0.26926452f, -0.00721480f, 0.03940688f, -0.07843331f, -0.03266875f, 0.11925969f, 
    -0.05138259f, 0.16665979f, 0.13631019f, 0.26418236f, 0.04332120f, -0.04698370f, -0.00289812f, -0.05085342f, 
    0.03215549f, -0.10571998f, 0.06717711f, 0.05709708f, 0.03914526f, 0.01387736f, -0.04510260f, 0.09393513f, 
    -0.08464044f, -0.06481926f, 0.04343173f, 0.09664275f, 0.12460794f, -0.09895537f, 0.12964204f, 0.15143752f, 
    -0.00478941f, 0.00910268f, -0.13021591f, 0.15307367f, -0.05813303f, -0.14897884f, 0.15816900f, 0.23008204f, 
    -0.06103506f, 0.06752212f, 0.04194382f, 0.07489191f, 0.09879022f, -0.10598280f, -0.08005521f, -0.15075520f, 
    0.01745176f, 0.06471870f, 0.11456666f, -0.00219419f, 0.06620379f, 0.10198039f, -0.10759836f, -0.05325510f, 
    -0.01744220f, -0.09530628f, 0.19867538f, 0.01411280f, -0.10362031f, -0.01921625f, 0.00463401f, 0.10481620f, 
    -0.05186467f, 0.31132072f, 0.01314790f, 0.00686709f, 0.10685900f, 0.02701053f, 0.14617577f, 0.13873847f, 
    0.14092581f, -0.01135770f, -0.02467302f, -0.02650404f, 0.06745645f, 0.10602994f, -0.11243207f, 0.07499947f, 
    -0.10219102f, 0.27069920f, 0.10151268f, 0.25125459f, 0.04981987f, 0.07683374f, 0.16712932f, -0.04612434f, 
    -0.08129882f, 0.02529009f, -0.07252496f, 0.17317650f, 0.26058590f, 0.01170819f, 0.13108857f, 0.08917010f, 
    -0.00037712f, 0.01030312f, -0.05947950f, 0.01644732f, 0.23622164f, -0.05711587f, 0.12668887f, -0.06325400f, 
    -0.13746901f, -0.18358035f, -0.07365473f, 0.01678001f, 0.24874556f, 0.22932206f, -0.29548091f, 0.11248619f, 
    0.13551798f, -0.14058380f, -0.14972900f, 0.05983276f, 0.05944514f, -0.13623315f, -0.22267114f, -0.24790008f, 
    -0.02716291f, 0.00244239f, -0.07286523f, -0.15267795f, -0.05532315f, 0.02201895f, -0.04366460f, -0.16759692f, 
    -0.31353921f, 0.05240498f, -0.02366268f, -0.00671207f, 0.07280317f, 0.05147508f, -0.02122296f, -0.05812061f, 
    -0.25611049f, 0.05275999f, 0.00217104f, -0.06787125f, 0.07629462f, 0.10069627f, -0.03546447f, 0.11055814f, 
    -0.06094001f, -0.17050989f, -0.12127081f, -0.16084491f, -0.06548607f, -0.06084871f, 0.07461955f, -0.07677568f, 
    0.07878105f, -0.09329216f, -0.03483101f, 0.07020821f, -0.07045716f, 0.08164950f, -0.16481197f, -0.03081059f, 
    0.03984444f, 0.06571029f, 0.17518350f, 0.01990528f, -0.13932654f, 0.02650357f, -0.02650202f, 0.02359335f, 
    -0.08502319f, -0.20608507f, -0.06554741f, -0.18560769f, 0.01045019f, -0.67929894f, -0.05648428f, 0.07367600f, 
    0.01337146f, -0.00003811f, 0.00004215f, 0.00255380f, -0.04817327f, -0.38719708f, -0.35628867f, -0.02959486f, 
    -0.01434573f, -0.05958664f, 0.05637123f, -0.03601834f, -0.02815840f, 0.16583098f, 0.07880537f, 0.05714055f, 
    0.08252802f, 0.03950761f, -0.02673817f, -0.00969960f, -0.11217944f, -0.04424314f, 0.15127413f, 0.15144041f, 
    -0.40527090f, -0.01571443f, 0.01601648f, -0.11557995f, 0.03300273f, 0.10630868f, 0.11702781f, -0.05944150f, 
    -0.07783151f, 0.03963462f, -0.03468223f, -0.04978652f, -0.11371925f, 0.08630697f, 0.02959147f, -0.01217666f, 
    -0.25977409f, -0.20010561f, -0.13804394f, 0.16606820f, -0.04015323f, 0.02641078f, 0.08135937f, 0.10826999f, 
    -0.12181113f, 0.30731726f, -0.49210054f, -0.13864458f, -0.02057938f, 0.04819025f, 0.07137567f, 0.15644124f, 
    -0.05252946f, 0.06671139f, -0.19525100f, -0.24118732f, 0.15946689f, 0.03276765f, -0.06948964f, 0.02951629f, 
    0.06066646f, 0.17259890f, -0.05413605f, -0.02850944f, 0.15737516f, -0.15875301f, 0.02110558f, -0.00248865f, 
    -0.12033982f, 0.02790319f, -0.01010533f, 0.01662582f, -0.30666938f, -0.00409886f, 0.27890852f, -0.03493400f, 
    0.02437221f, -0.10424481f, -0.00580285f, -0.11731002f, 0.04423709f, -0.29153594f, 0.15695190f, -0.16409957f, 
    -0.06046772f, 0.04041278f, 0.06155954f, 0.00954792f, 0.10282203f, 0.04935182f, 0.11326765f, 0.25150332f, 
    0.13605730f, -0.11792935f, -0.05001878f, 0.04881017f, -0.06232547f, -0.02407863f, -0.00524364f, 0.15292774f, 
    0.15730695f, -0.12332820f, -0.02411849f, -0.18541954f, 0.12284006f, 0.00149834f, 0.06244643f, 0.10500625f, 
    -0.00941649f, -0.18876252f, -0.53040701f, 0.00669699f, -0.03697243f, -0.07696294f, 0.06065571f, 0.14677580f, 
    -0.04370106f, 0.03813454f, -0.00149829f, 0.09895182f, -0.05094574f, -0.10246564f, -0.01653365f, -0.05159961f, 
    0.22020377f, -0.02134403f, 0.07653132f, -0.02107789f, -0.06785948f, -0.16799313f, 0.03460473f, -0.11739836f, 
    0.01966888f, 0.14106269f, -0.02617773f, 0.03047271f, 0.15615100f, 0.01466533f, -0.11193882f, 0.08547319f, 
    -0.08765774f, 0.09161916f, -0.10043970f, 0.12911144f, -0.21713816f, -0.28440958f, 0.01105916f, -0.06546167f, 
    0.00951326f, -0.00617523f, 0.13249899f, 0.02490806f, 0.14366862f, 0.00118159f, -0.21945171f, -0.12878156f, 
    0.01979739f, -0.01381954f, 0.00235416f, -0.02119182f, 0.12227640f, 0.12437046f, -0.02398278f, -0.13468632f, 
    0.44588026f, 0.00737187f, 0.05239289f, -0.05097713f, -0.09476418f, -0.08881199f, -0.00455634f, 0.04349976f, 
    0.04909134f, 0.15652508f, -0.12046353f, -0.07214427f, 0.03906954f, -0.08258709f, -0.04679235f, -0.10693047f, 
    -0.22415136f, 0.21381651f, -0.22431874f, -0.08685610f, -0.04953849f, 0.17030744f, 0.02260363f, 0.05562428f, 
    -0.09155472f, 0.10595772f, 0.00483691f, -0.04576556f, -0.06768316f, -0.08332204f, 0.07837959f, 0.07271335f, 
    -0.00359597f, 0.18466361f, 0.09568448f, 0.15583158f, 0.33650118f, -0.08805907f, -0.01705843f, 0.17668825f, 
    0.13040341f, -0.07393999f, 0.02789156f, -0.30055755f, 0.27799293f, -0.03662934f, -0.14569598f, 0.07797111f, 
    0.07545383f, -0.19023697f, -0.21340789f, -0.02554261f, 1.15772235f, -0.16237915f, -0.15343665f, -0.17947379f, 
    -0.14192079f, -0.15774842f, 0.02116045f, -0.04900679f, -0.05996587f, 0.04020418f, -0.01857596f, 0.05828867f, 
    -0.27406204f, 0.02941456f, -0.10265918f, 0.05517419f, -0.04394483f, 0.13120931f, 0.00599419f, -0.30571452f, 
    -0.22117141f, 0.10713591f, 0.14962105f, -0.04692313f, 0.02913436f, -0.00756296f, -0.15676703f, 0.28698254f, 
    0.12602562f, 0.01434722f, -0.08819031f, 0.02324249f, -0.06620516f, 0.09228345f, -0.03126003f, 0.13478130f, 
    -0.00335419f, -0.37053299f, -0.01805356f, -0.16245413f, -0.12068744f, -0.07946243f, -0.02621361f, 0.07504415f, 
    -0.07040979f, -0.25443029f, 0.05076425f, -0.00414793f, -0.15509179f, -0.03633667f, -0.13431680f, 0.00212296f, 
    0.00073793f, 0.00441070f, 0.25868419f, -0.03740641f, -0.08488136f, 0.09487578f, -0.09667767f, -0.19397406f, 
    0.07863814f, -0.04952713f, 0.17418581f, -0.39046499f, -0.46861851f, 0.01324867f, -0.13834785f, -0.03710546f, 
    -0.10447869f, 0.00527558f, 0.12334418f, 0.07465828f, 0.17298913f, -0.06648091f, -0.08259819f, 0.03153959f, 
    0.09704625f, 0.07800732f, 0.00309417f, 0.13966668f, 0.01772285f, 0.11490957f, 0.00661468f, 0.12530088f, 
    0.12224197f, 0.01695971f, 0.05733768f, 0.07886545f, 0.04438162f, 0.03549232f, -0.04189213f, 0.08076517f, 
    -0.09080041f, -0.06884521f, 0.09963319f, 0.02455549f, 0.01513421f, 0.01501979f, 0.06180540f, 0.18259323f, 
    -0.14024755f, -0.02276916f, -0.02763383f, -0.03158746f, -0.16478960f, 0.09423046f, 0.03778565f, 0.01663121f, 
    0.16796890f, -0.06571866f, -0.07032485f, 0.02678743f, -0.08469526f, -0.08628102f, 0.05777257f, 0.05156431f, 
    0.04079884f, -0.21031892f, 0.17519720f, 0.14919461f, 0.01685947f, 0.05370969f, 0.14738399f, -0.02874527f, 
    -0.00051656f, 0.12074034f, -0.05036362f, 0.08952926f, 0.12011505f, 0.10689460f, -0.02529417f, 0.26194060f, 
    0.02021175f, 0.09449589f, 0.16880357f, -0.07996499f, -0.20376186f, 0.02620702f, 0.04841330f, -0.00509924f, 
    -0.05977090f, 0.03093697f, 0.00083809f, -0.01538905f, 0.20670183f, 0.05446124f, -0.10040786f, 0.06819131f, 
    -0.08164152f, 0.09129137f, -0.00565280f, 0.09710756f, 0.03563842f, 0.20162819f, -0.03706666f, 0.02208207f, 
    -0.04407059f, -0.06831624f, 0.07178235f, -0.03828093f, -0.02079954f, 0.08702947f, -0.18993680f, -0.16405155f, 
    0.00391081f, 0.15580803f, 0.02908163f, -0.12267659f, -0.08880272f, -0.01920184f, 0.09450672f, 0.27371979f, 
    0.03795159f, -0.25697538f, -0.13278782f, -0.31108120f, -0.12607770f, 0.00405945f, 0.00994288f, 0.05906354f, 
    0.11798982f, 0.00480995f, -0.17057146f, 0.08497221f, 0.14815804f, -0.20664172f, -0.03148182f, 0.11914051f, 
    -0.04858882f, -0.26026216f, -0.31216645f, -0.14002521f, -0.09023704f, 0.01268081f, -0.07324007f, 0.15313479f, 
    0.06116819f, -0.01526840f, -0.08203080f, -0.43861789f, -0.09887962f, -0.05071615f, -0.11259573f, -0.06022581f, 
    -0.06993808f, -0.00574579f, -0.00044279f, -0.18642566f, -0.03321803f, -0.21654043f, -0.00674912f, -0.01484353f, 
    -0.18023640f, 0.01906193f, -0.03404108f, -0.10427188f, 0.00711307f, -0.34362310f, -0.15555951f, 0.12908040f, 
    -0.20286173f, 0.01074225f, 0.02767629f, 0.09567700f, 0.06225179f, -0.04460613f, 0.19191903f, -0.01864041f, 
    -0.00608500f, -0.00610591f, 0.10884601f, 0.15567777f, 0.07887837f, 0.12336383f, 0.42629725f, -0.19765097f, 
    -0.20930947f, -0.10179643f, -0.05208238f, -0.24505624f, -0.08032921f, -0.06362360f, 0.18709202f, -0.04373038f, 
    -0.30830538f, 0.18593575f, 0.06831795f, 0.18361965f, -0.16538852f, 0.09466860f, 0.18500251f, -0.01828570f, 
    0.16207413f, -0.24994415f, -0.44658226f, -0.01135871f, 0.01065418f, -0.00678930f, 0.16362584f, 0.13767608f, 
    -0.01232195f, 0.04912805f, 0.00302272f, 0.22428812f, -0.00719982f, 0.10986549f, 0.00036644f, -0.08618207f, 
    -0.03817830f, -0.06563208f, -0.29132923f, 0.04842185f, 0.13878906f, -0.04502879f, -0.04438798f, 0.03180840f, 
    -0.12523620f, -0.06696000f, 0.15129909f, -0.10899188f, -0.47836089f, -0.32392812f, -0.10460719f, -0.32370463f, 
    -0.27957371f, -0.08046471f, 0.12981814f, 0.06544073f, -0.35234293f, 0.37116611f, 0.03532177f, -0.02435315f, 
    0.07045630f, 0.20866835f, 0.07627177f, 0.03832722f, 0.09172446f, 0.14335574f, 0.12537615f, -0.00453761f, 
    -0.10717200f, -0.16474020f, -0.01141447f, 0.13753742f, 0.07778934f, 0.06273945f, 0.39943168f, -0.09001434f, 
    -0.38326442f, -0.02766034f, 0.00367286f, 0.05691492f, 0.01903962f, 0.13424659f, 0.09406634f, 0.21837972f, 
    0.10462192f, 0.11885316f, -0.13232374f, -0.14464958f, 0.02568034f, -0.07731681f, -0.02544463f, 0.06331591f, 
    -0.14091854f, -0.26027635f, 0.08674951f, 0.12184377f, -0.06379446f, -0.09140460f, 0.09179533f, -0.01034070f, 
    -0.00705863f, -0.11825809f, -0.22659206f, 0.00524309f, -0.09390326f, -0.01279197f, -0.17228757f, 0.24601421f, 
    -0.03169383f, -0.23640276f, -0.01891910f, 0.07012522f, -0.11051625f, -0.15403800f, -0.12886697f, -0.03228523f, 
    0.19476686f, 0.09081420f, 0.00431786f, 0.15876606f, 0.13780731f, -0.17918073f, -0.29429984f, 0.10918555f, 
    0.18572922f, 0.04395032f, -0.09125408f, -0.19115394f, 0.25514480f, 0.22798461f, -0.12964563f, 0.00506803f, 
    -0.05982191f, -0.02500707f, -0.06902412f, -0.04786169f, 0.02035367f, -0.02593260f, 0.07667801f, -0.12066439f, 
    0.00185999f, 0.04167217f, -0.01088123f, -0.03427488f, 0.02838112f, 0.18543531f, 0.21141292f, 0.16848274f, 
    -0.02788799f, 0.04420327f, 0.02381800f, 0.07568037f, 0.08570803f, 0.04845884f, 0.02544432f, -0.33514822f, 
    -0.11424211f, -0.00759147f, 0.14604104f, 0.05633173f, -0.10455955f, 0.06899317f, 0.06595042f, -0.03352001f, 
    -0.16867355f, -0.14607848f, 0.13929114f, 0.00976878f, 0.12269295f, -0.00881866f, 0.07545927f, 0.12463929f, 
    -0.05731540f, -0.11767762f, 0.15025665f, 0.13303626f, -0.24580841f, -0.11261643f, 0.07581181f, -0.03278276f, 
    -0.19200550f, 0.11338481f, -0.15909308f, -0.27849978f, 0.02115148f, -0.15267979f, 0.13386045f, -0.04147393f, 
    0.15468127f, -0.05443722f, 0.24685565f, 0.20321256f, -0.33743909f, -0.13460137f, -0.08547416f, 0.07056030f, 
    0.06653260f, -0.05120054f, 0.07215104f, 0.13193464f, -0.10388003f, 0.13944302f, -0.02391925f, -0.00231460f, 
    0.04034669f, 0.05792137f, 0.08048622f, 0.06510249f, 0.01174766f, -0.20377670f, -0.20332591f, -0.02831583f, 
    -0.00826633f, 0.05678087f, 0.06743125f, 0.08351240f, 0.11116894f, 0.03649202f, 0.05032299f, -0.00969177f, 
    0.15526396f, -0.08105704f, 0.04855145f, -0.24049090f, 0.00696193f, 0.05412619f, 0.03383367f, -0.06040245f, 
    0.08608482f, -0.09341356f, -0.08414389f, -0.14184849f, -0.03283317f, 0.03175494f, -0.01772809f, -0.22377609f, 
    0.49061912f, -0.00119495f, -0.13442411f, -0.00274306f, 0.01312365f, 0.07082712f, 0.03938543f, -0.01685451f, 
    0.11833162f, -0.13727172f, -0.16390269f, -0.01484612f, -0.15744340f, 0.04485444f, -0.10334179f, 0.04837910f, 
    -0.03791147f, -0.02880404f, -0.30317137f, -0.08025792f, -0.15856121f, -0.08016523f, 0.08745490f, -0.11179290f, 
    0.08029861f, -0.03510227f, -0.09084467f, -0.03531300f, 0.27012461f, -0.18915272f, 0.08033941f, 0.05489850f, 
    0.01784305f, 0.02793218f, -0.01823413f, -0.12403792f, -0.24134912f, -0.34178033f, -0.17644385f, -0.05160633f, 
    0.01313309f, -0.01952694f, 0.11480264f, 0.03754675f, -0.00500550f, -0.14168286f, 0.12444143f, 0.06663840f, 
    -0.04637680f, -0.01553767f, -0.05595903f, 0.09184989f, 0.15502720f, 0.01762602f, 0.22062150f, -0.09471478f, 
    -0.09742291f, -0.02221108f, 0.04113427f, -0.01157421f, 0.03921184f, -0.03832988f, 0.06668460f, -0.25190446f, 
    -0.15385291f, 0.12250309f, -0.06656668f, 0.12283769f, 0.04825706f, -0.02614186f, 0.08817698f, 0.04148064f, 
    0.10628060f, -0.25327864f, 0.16539794f, -0.15417500f, 0.10199406f, 0.13588239f, 0.15675676f, 0.03030887f, 
    -0.02449304f, -0.03211643f, 0.01108487f, 0.06093218f, -0.04446596f, -0.07473429f, 0.11309379f, -0.07971081f, 
    0.08820806f, 0.05586690f, 0.04285841f, -0.09168497f, 0.15379427f, -0.07838321f, 0.14183278f, 0.01687547f, 
    -0.09415523f, -0.01740960f, 0.14690572f, -0.09624240f, -0.60215724f, -0.06173149f, -0.16417445f, -0.17672083f, 
    -0.25211608f, -0.04067349f, -0.08151278f, -0.23507196f, -0.15010700f, -0.00846300f, -0.06722945f, 0.12431765f, 
    -0.05371766f, 0.02687503f, -0.04106589f, -0.09416975f, 0.08355024f, 0.05355012f, 0.20003513f, -0.02493821f, 
    0.05501529f, 0.06535387f, 0.04628947f, 0.06865530f, 0.08761059f, 0.02807489f, 0.39193431f, -0.01239108f, 
    -0.05393270f, 0.02205263f, 0.02157407f, 0.08524086f, 0.05049507f, 0.00667219f, -0.02507394f, 0.02819708f, 
    -0.02399141f, 0.06966925f, 0.03726500f, -0.02067071f, -0.02108878f, -0.02969674f, 0.02123157f, -0.06603421f, 
    -0.06718662f, -0.30006889f, -0.10790130f, 0.08730885f, 0.27268633f, -0.07530145f, 0.05750945f, 0.08159422f, 
    0.13890329f, -0.30459946f, -0.12434468f, -0.09064507f, -0.30331603f, 0.05231040f, -0.08812906f, 0.09716494f, 
    0.04943142f, -0.05235906f, -0.00689463f, 0.01981737f, 0.09556190f, 0.01420265f, -0.08105884f, -0.15276472f, 
    0.03129717f, 0.05532632f, 0.02870840f, -0.08256172f, 0.05566527f, 0.02543643f, 0.17110242f, -0.05495821f, 
    0.05649207f, 0.04364517f, -0.02688715f, -0.11374038f, 0.13723172f, 0.12164111f, -0.05007602f, -0.02637973f, 
    0.09450361f, 0.04514477f, -0.04498218f, -0.00556048f, -0.27347416f, 0.06033178f, -0.13802220f, -0.07299683f, 
    0.07766291f, 0.05964394f, 0.05630953f, 0.07745402f, 0.02323295f, 0.13197432f, 0.14254884f, 0.25754368f, 
    -0.13138704f, 0.01138214f, -0.01030725f, 0.21511057f, -0.05251224f, 0.02473282f, -0.01906797f, 0.43885776f, 
    -0.05974779f, -0.19572803f, 0.03644807f, 0.11068886f, 0.02236507f, -0.04210710f, 0.02023181f, 0.03740295f, 
    0.01088216f, -0.01945061f, 0.03245831f, 0.01551964f, 0.00521239f, 0.00540599f, -0.02600003f, 0.04342455f, 
    -0.05637351f, 0.00278243f, 0.01429693f, -0.00862379f, 0.01575318f, -0.01162096f, -0.02105067f, -0.05094740f, 
    0.03935537f, -0.03407941f, 0.03343087f, -0.03751469f, 0.00003975f, 0.04821508f, 0.02293955f, -0.00433210f, 
    0.04235625f, 0.01102582f, -0.05524307f, -0.03766566f, -0.04608321f, -0.05486073f, -0.04240935f, -0.05999537f, 
    -0.02534101f, -0.05196598f, -0.02213932f, -0.01187210f, 0.04337899f, -0.02769688f, -0.00121840f, 0.00854573f, 
    0.03344443f, -0.05993883f, -0.05851475f, 0.01959514f, 0.00449470f, 0.00859409f, -0.04487378f, 0.00131581f, 
    0.03563138f, -0.05279495f, 0.02456717f, -0.03943853f, -0.03295198f, 0.00161885f, -0.03563113f, 0.01533057f, 
    -0.00606402f, 0.02014601f, 0.04398499f, -0.05006408f, -0.01984729f, -0.04442091f, -0.03837456f, -0.03185273f, 
    0.04717547f, 0.00089967f, 0.02719628f, -0.03197588f, 0.02739769f, 0.01894405f, -0.06358664f, 0.05399274f, 
    -0.02905192f, 0.03735234f, 0.01863340f, -0.04601060f, 0.02626059f, -0.03761836f, -0.05344808f, -0.02763174f, 
    0.01133962f, -0.05356202f, -0.01197806f, 0.02586167f, -0.05353633f, 0.04051971f, 0.02608828f, -0.00246376f, 
    -0.05595013f, -0.05268072f, -0.00193826f, -0.04867635f, -0.01661773f, -0.06316947f, -0.04766354f, 0.00652737f, 
    -0.01310341f, -0.01730053f, -0.03786592f, -0.00899856f, -0.01500696f, 0.01036346f, -0.06333132f, -0.02551787f, 
    -0.05540955f, 0.03711629f, -0.04668622f, -0.03847454f, 0.03679681f, -0.03219282f, -0.06035595f, 0.03078722f, 
    0.00198558f, 0.00818996f, 0.02191641f, -0.02840480f, -0.01726168f, 0.04766427f, -0.05675891f, -0.03579749f, 
    0.04332923f, 0.01941931f, -0.04104194f, -0.02721176f, -0.05688744f, -0.06113774f, 0.04161286f, -0.03202691f, 
    0.01763479f, -0.04315964f, 0.04592362f, 0.04879034f, 0.00148128f, -0.01020814f, -0.03854657f, -0.03772249f, 
    -0.00222100f, -0.05031458f, -0.00050072f, -0.01190999f, -0.05296752f, 0.03615884f, -0.02911747f, 0.05221640f, 
    -0.01353158f, 0.05740033f, -0.05857849f, -0.06380888f, -0.03870252f, 0.05286017f, 0.05123097f, 0.04691674f, 
    0.03221954f, 0.01356632f, -0.03658046f, -0.02246134f, -0.02828768f, 0.04202799f, 0.03268062f, 0.03611587f, 
    -0.02017286f, -0.06005004f, -0.05096827f, 0.02077751f, -0.02308070f, 0.01005025f, 0.02281240f, -0.01256908f, 
    0.04662591f, -0.05160733f, -0.01583449f, -0.03650869f, 0.03708619f, 0.05377014f, 0.03135303f, 0.02098319f, 
    0.03551750f, -0.05640861f, 0.04355773f, 0.03511442f, -0.03440662f, -0.01038705f, 0.05011010f, 0.02110964f, 
    -0.03467478f, -0.05446870f, -0.05354036f, 0.04406036f, 0.03352274f, -0.00777595f, 0.03674240f, 0.01719723f, 
    -0.05466411f, 0.03021528f, -0.01810414f, 0.01892046f, 0.02338310f, 0.05202916f, 0.03283552f, -0.02785125f, 
    0.03828502f, -0.03551076f, -0.03124021f, 0.04496342f, -0.04066588f, -0.00633432f, 0.02281171f, -0.03145440f, 
    -0.05075142f, -0.00385620f, -0.01352222f, -0.03819940f, -0.06343304f, -0.01750890f, 0.02910512f, -0.03491164f, 
    0.05092051f, 0.00937425f, -0.00231909f, 0.04290484f, 0.05268914f, -0.02219569f, -0.01601043f, 0.00757875f, 
    -0.03605073f, -0.01393090f, 0.01840714f, -0.00788173f, -0.06036166f, 0.03771760f, -0.01393575f, 0.00493408f, 
    0.03360226f, 0.04829472f, 0.05098253f, -0.04638854f, 0.04579316f, 0.01486918f, 0.03984784f, -0.01594660f, 
    -0.00315989f, -0.00143006f, -0.03440307f, -0.00490716f, -0.02637069f, 0.00161698f, 0.01094240f, -0.04655544f, 
    -0.03863562f, -0.02337182f, 0.02625199f, -0.04136116f, -0.02958325f, 0.00224479f, -0.02281460f, -0.01881925f, 
    0.03826117f, 0.01512353f, -0.03134807f, 0.01787124f, -0.04023041f, 0.03125779f, -0.00679066f, 0.03960703f, 
    -0.05868434f, -0.02894221f, -0.05505536f, -0.00207690f, 0.05359913f, 0.03481823f, -0.05429820f, -0.03800797f, 
    -0.06230193f, -0.05073920f, -0.03612933f, 0.00837613f, -0.05605938f, 0.03593029f, -0.00440756f, -0.00996441f, 
    0.04665345f, 0.03058420f, -0.04954813f, -0.01214966f, -0.05897742f, 0.01305845f, 0.02068676f, -0.05935683f, 
    0.12830207f, 0.08334219f, 0.03783356f, -0.03341832f, 0.13111624f, -0.13705309f, 0.21917699f, 0.15509488f, 
    0.09702165f, -0.11965366f, 0.05073704f, 0.02600889f, -0.02449253f, 0.02268860f, -0.05176834f, -0.09485832f, 
    -0.03835604f, -0.03514702f, 0.14270584f, -0.09330674f, 0.17954640f, -0.00286303f, -0.11276218f, -0.00257238f, 
    -0.04743795f, -0.26606429f, 0.29625419f, -0.15311721f, 0.10639101f, 0.14634944f, -0.33046106f, -0.08306605f, 
    0.06022361f, -0.04738280f, 0.02786912f, -0.03377150f, 0.12754841f, -0.11056421f, -0.03249128f, 0.13447645f, 
    0.13871306f, 0.21471229f, 0.11836006f, 0.23371972f, 0.08804567f, 0.09176233f, -0.23326802f, 0.06259041f, 
    0.11849041f, 0.02108745f, 0.01964622f, 0.23147416f, -0.04564271f, 0.05201128f, 0.03980025f, -0.04353952f, 
    0.00273475f, 0.04382028f, 0.03484839f, -0.14756897f, 0.02634244f, 0.03977602f, -0.33670548f, -0.18395537f, 
    -0.35425326f, 0.02146113f, -0.01549486f, -0.13838813f, 0.14980675f, -0.13409258f, 0.05546130f, 0.02554996f, 
    0.17987138f, 0.10693569f, 0.35968021f, -0.14406732f, -0.13109745f, -0.05575823f, -0.10479826f, -0.04211343f, 
    -0.02281099f, -0.52990681f, -0.26504979f, -0.25512516f, -0.13792883f, 0.02458209f, -0.02243152f, 0.08584803f, 
    -0.14754365f, -0.20192121f, -0.09151505f, -0.23776945f, 0.00725917f, 0.10087328f, 0.19182740f, 0.06724776f, 
    0.05823017f, -0.09621194f, -0.08305480f, 0.01474355f, 0.05404127f, 0.19627126f, 0.03914043f, 0.08968530f, 
    0.07315658f, 0.25262684f, -0.02381567f, -0.07918084f, 0.50612611f, 0.16594946f, 0.12978311f, -0.26092330f, 
    0.13130784f, 0.02891411f, 0.05990306f, 0.14597952f, 0.07564231f, -0.02629112f, -0.00608669f, 0.09152005f, 
    -0.10548853f, 0.05005456f, 0.14539662f, -0.09149595f, 0.07446916f, -0.05682159f, -0.04318970f, -0.36130261f, 
    -0.21427871f, -0.09876138f, 0.01282825f, 0.11674619f, 0.08041434f, -0.01212704f, 0.33676413f, 0.02650428f, 
    0.17700271f, 0.12681890f, -0.04596547f, 0.09306990f, 0.13673417f, 0.14881241f, 0.28984308f, -0.02383122f, 
    -0.55711007f, -0.11921553f, -0.17480333f, -0.04834641f, 0.20790070f, 0.06428290f, 0.08091737f, 0.01561022f, 
    0.03859688f, -0.06143035f, 0.17537820f, 0.18790478f, 0.08694090f, 0.09615010f, -0.08290313f, 0.03643295f, 
    0.22100231f, 0.00035948f, 0.00003085f, -0.02474599f, 0.14341430f, 0.00652623f, 0.03064744f, -0.23354800f, 
    -0.01406852f, -0.04807323f, -0.10667638f, -0.24402761f, -0.37066996f, -0.43268082f, -0.11182391f, 0.10723767f, 
    0.07657041f, -0.05227664f, 0.35245636f, -0.21050709f, -0.27022231f, -0.03993331f, 0.05087498f, -0.03760546f, 
    -0.21720542f, 0.22384654f, -0.00352947f, 0.15782881f, 0.23795950f, -0.01666597f, -0.09461984f, -0.11231320f, 
    0.10629597f, -0.08920654f, -0.03788056f, -0.01707364f, 0.07911733f, 0.01047660f, 0.09197029f, -0.08893277f, 
    0.17960945f, -0.15907052f, 0.06598986f, 0.01859722f, -0.02237121f, 0.08769730f, 0.14680940f, -0.02765361f, 
    -0.18140502f, 0.10237741f, -0.04528884f, -0.11838534f, 0.06667880f, 0.12650898f, 0.20377252f, 0.10916692f, 
    0.05035047f, 0.01490268f, 0.16919781f, -0.00471849f, 0.03984216f, 0.00509083f, 0.11487442f, 0.13103084f, 
    0.24336724f, 0.14210257f, 0.03858233f, 0.18048626f, 0.03554955f, 0.00049533f, 0.05426996f, 0.05433527f, 
    0.21342295f, -0.02637992f, -0.07776663f, 0.07278435f, 0.16583619f, -0.04449710f, 0.03155348f, -0.03564018f, 
    -0.13812949f, 0.10086080f, -0.22036159f, -0.15631147f, 0.01810735f, -0.05089749f, -0.04392318f, -0.07152606f, 
    -0.03610787f, -0.11810450f, 0.07067592f, 0.06647818f, 0.02726140f, 0.04263211f, -0.00985939f, -0.13493471f, 
    -0.06514286f, -0.06646565f, 0.10402662f, 0.21389921f, -0.02987355f, 0.08676161f, 0.19968268f, 0.12506743f, 
    -0.09936193f, 0.08143583f, 0.02356820f, 0.10961916f, 0.08600425f, 0.17842495f, -0.10467184f, 0.00567258f, 
    0.00642665f, -0.04132250f, 0.05532791f, 0.15290597f, 0.04542417f, 0.18180051f, -0.00695146f, -0.08960954f, 
    0.18063699f, 0.08068196f, -0.06868950f, 0.10267842f, 0.01458724f, -0.08329280f, -0.03578212f, 0.02726498f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.01658106f, -0.08332480f, 0.09133197f, 0.02857351f, 0.03608973f, 0.00002577f, 0.14001966f, 0.00395158f, 
    0.08615587f, 0.15646690f, 0.02958654f, 0.07687029f, 0.13757698f, 0.09473737f, -0.03568460f, 0.24583599f, 
    -0.02281671f, 0.00985391f, 0.01592860f, 0.06710423f, 0.05845115f, -0.03433251f, -0.05235850f, -0.01238974f, 
    -0.03227443f, 0.07124094f, 0.08061939f, 0.06549267f, 0.05070736f, 0.13965708f, 0.00485300f, 0.25521025f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07938161f, 0.33966869f, -0.06456200f, -0.04390724f, 0.06397822f, -0.06736026f, -0.05283967f, 0.18866801f, 
    -0.41377786f, 0.24005017f, 0.15979202f, 0.17284139f, 0.24192855f, -0.04557552f, 0.11909764f, 0.08117221f, 
    0.13394658f, -0.21517481f, 0.09818834f, 0.22475916f, 0.18643482f, 0.11671923f, -0.35548034f, 0.00315078f, 
    0.09823424f, 0.06448831f, 0.20153143f, 0.11209087f, -0.35680026f, 0.04803530f, 0.14017242f, 0.03650064f, 
    0.19164459f, 0.45984960f, -0.18107671f, -0.07920729f, 0.14175111f, 0.03258249f, 0.14448832f, -0.12497894f, 
    0.23591749f, 0.04431837f, 0.14050396f, -0.02670354f, 0.26434547f, -0.15005706f, -0.17140515f, -0.00034984f, 
    -0.03939511f, -0.16416483f, -0.11920130f, 0.12826286f, 0.06277090f, -0.05897715f, 0.14333162f, -0.05626648f, 
    -0.16772535f, 0.02991633f, 0.26531088f, 0.58228153f, 0.02624161f, 0.16874766f, -0.00556045f, -0.15122557f, 
    0.13479532f, 0.13883224f, -0.11383364f, -0.04296616f, 0.08615233f, 0.05477999f, -0.07769805f, -0.02121232f, 
    -0.16217656f, -0.04006577f, -0.08381095f, -0.01531528f, 0.07474288f, 0.05873279f, -0.15233582f, -0.12141100f, 
    -0.08172057f, 0.05958391f, 0.03088736f, 0.12074280f, -0.17145808f, -0.15237567f, -0.08690098f, -0.04751243f, 
    0.13078217f, -0.00834038f, -0.01567784f, -0.11509417f, -0.10955799f, 0.04755392f, 0.01171571f, -0.07714656f, 
    -0.04644589f, -0.01358693f, 0.15274179f, 0.04554121f, 0.13757057f, 0.14437549f, -0.21250352f, -0.21613581f, 
    0.16330460f, 0.18730116f, -0.16130805f, 0.08764315f, -0.21240534f, 0.10802808f, -0.08374519f, 0.08599754f, 
    0.09811552f, 0.16727346f, -0.15385216f, 0.15257126f, 0.19841889f, 0.12917402f, -0.44151214f, 0.07387181f, 
    0.11460741f, -0.17347763f, 0.18848024f, -0.45769897f, 0.43403360f, -0.21934883f, 0.12644684f, 0.02484885f, 
    -0.05999990f, -0.14190595f, -0.25424424f, -0.13155225f, 0.05883671f, 0.04758205f, -0.02845511f, 0.18776496f, 
    0.18660495f, 0.15352045f, -0.13633224f, 0.01197739f, 0.01635109f, 0.40468624f, -0.00910689f, 0.11126830f, 
    -0.21011303f, -0.29562622f, 0.16520369f, 0.20622936f, -0.05402937f, 0.07153855f, -0.15858306f, -0.31115419f, 
    0.02528503f, 0.10618991f, 0.12643474f, 0.04611566f, 0.07285421f, 0.18614987f, 0.08867648f, 0.07911611f, 
    0.12567961f, 0.44706503f, -0.13167095f, -0.10556835f, -0.14283729f, -0.13161005f, -0.10413367f, -0.04718891f, 
    -0.04169447f, 0.10975271f, 0.01166925f, -0.10466277f, 0.17535713f, 0.09487104f, -0.11161839f, 0.17782292f, 
    -0.21878597f, 0.11001442f, -0.12961687f, 0.00126014f, 0.02616848f, 0.15026979f, -0.00163783f, 0.19458891f, 
    -0.08027151f, 0.34139934f, 0.24938463f, 0.25909048f, 0.05577681f, 0.12833945f, 0.00869591f, -0.21297766f, 
    0.15487137f, -0.03607471f, 0.04987131f, -0.07687154f, 0.17083052f, -0.06165027f, -0.15761748f, 0.17608377f, 
    -0.17774989f, -0.06925008f, 0.07592081f, 0.04409268f, 0.22948073f, -0.32474628f, 0.06997203f, 0.19833177f, 
    0.23621002f, -0.18093708f, 0.09610096f, -0.03866544f, 0.06340404f, 0.08893379f, -0.30251759f, -0.17784156f, 
    -0.00418086f, 0.12389627f, 0.21277834f, 0.18316917f, -0.19326958f, -0.21159589f, -0.00753533f, 0.18436101f, 
    0.30877748f, 0.34346592f, -0.05434304f, -0.14050896f, 0.04026102f, 0.10660169f, 0.21005514f, 0.11550656f, 
    -0.00899054f, -0.16911255f, -0.01385375f, 0.16543636f, -0.20509721f, 0.13755134f, -0.08657640f, 0.20498720f, 
    0.00981201f, -0.03579249f, 0.12850919f, -0.07589161f, 0.17361341f, 0.01324369f, -0.02669592f, 0.15391554f, 
    -0.17241091f, -0.15227088f, -0.12880808f, -0.38681605f, 0.07487653f, 0.06235477f, -0.10072808f, -0.14043011f, 
    0.10679785f, -0.17726995f, 0.05954996f, -0.03790994f, 0.06984517f, -0.06266956f, -0.04612407f, -0.18760529f, 
    -0.12990150f, 0.02831029f, 0.14991823f, -0.13622920f, -0.16042027f, -0.01998531f, -0.11086433f, 0.02169565f, 
    -0.02570261f, 0.14978720f, 0.10419615f, -0.04043359f, 0.03056246f, 0.12966514f, 0.12745199f, -0.16505238f, 
    -0.17107971f, -0.07704388f, 0.02808605f, 0.03693807f, -0.11263576f, -0.15408567f, -0.11020876f, -0.16513900f, 
    -0.22357534f, -0.26721516f, 0.26268521f, -0.05027470f, -0.17668866f, -0.06461222f, 0.10284481f, -0.13859068f, 
    -0.03366750f, 0.26858130f, -0.07843597f, 0.16565219f, -0.10141157f, 0.19666378f, -0.07168783f, 0.00432250f, 
    -0.22077300f, 0.22904518f, -0.12860361f, -0.14181308f, -0.10943019f, 0.05586927f, 0.06021060f, 0.04653266f, 
    -0.00018922f, 0.03276614f, -0.24372065f, -0.21452434f, 0.18804792f, 0.30675629f, -0.08442568f, 0.11900133f, 
    0.04278881f, -0.16131321f, -0.02763832f, -0.11770867f, -0.04860963f, 0.15975468f, 0.14640638f, -0.13217558f, 
    0.09322871f, -0.08493987f, -0.07620932f, 0.01924292f, 0.01440478f, -0.12567145f, -0.07879180f, -0.11758523f, 
    -0.07144671f, -0.12063292f, -0.08060477f, 0.11682076f, -0.00005771f, -0.07095919f, -0.08051851f, -0.10073380f, 
    0.04772684f, 0.06827152f, 0.07315264f, 0.01161459f, -0.14516743f, 0.03655675f, 0.00429099f, -0.14497206f, 
    0.18501067f, 0.22057864f, 0.13251412f, -0.13346301f, 0.15251155f, -0.02994377f, -0.36986589f, 0.14257497f, 
    -0.29445982f, 0.05999150f, 0.04759608f, -0.03544744f, 0.14333855f, -0.04004939f, 0.15857087f, -0.25804004f, 
    -0.19262074f, -0.10397077f, 0.10015370f, -0.29130825f, 0.01616506f, -0.07426308f, 0.15685320f, 0.24887493f, 
    0.04259798f, -0.00786779f, 0.16886236f, 0.24658564f, -0.45750615f, -0.25534657f, -0.00629311f, -0.03672206f, 
    -0.38119692f, 0.07642031f, 0.04517940f, 0.02919770f, 0.07426707f, -0.08208161f, 0.05188119f, 0.22154555f, 
    -0.06912276f, 0.36231473f, -0.06627584f, -0.12996478f, -0.01708643f, 0.20464261f, 0.02653640f, -0.06940424f, 
    -0.06471332f, 0.32362220f, -0.01511453f, 0.20058373f, 0.11174195f, -0.01954331f, -0.32008427f, 0.02247223f, 
    -0.08331012f, 0.15372930f, -0.05768262f, -0.34378889f, 0.45845181f, 0.20139977f, -0.10902098f, -0.11120266f, 
    0.22294573f, -0.04164565f, -0.13132682f, 0.11513337f, 0.10065375f, 0.13053076f, 0.01000281f, 0.03545858f, 
    -0.12393764f, 0.15424681f, 0.03930458f, 0.00499413f, 0.15687148f, -0.44968206f, 0.13347651f, 0.34695971f, 
    0.22019899f, -0.16432807f, 0.11043817f, -0.08192857f, 0.05906108f, 0.11798991f, -0.36559805f, 0.13614403f, 
    -0.01642411f, 0.09694946f, 0.09733481f, -0.42919254f, 0.16345978f, -0.12620422f, 0.01362023f, 0.16619623f, 
    -0.19974591f, 0.10429199f, 0.15045793f, -0.04170912f, 0.14954893f, -0.09076503f, 0.16049941f, -0.17068651f, 
    0.24222766f, -0.11858868f, -0.06517822f, 0.17374700f, -0.15556121f, -0.16736211f, 0.11960598f, 0.01602975f, 
    -0.07435272f, 0.42399746f, -0.02126098f, -0.36157998f, -0.02720099f, 0.09122002f, 0.08510998f, 0.11076949f, 
    0.06330414f, -0.04399745f, -0.08305531f, -0.42146856f, 0.40100965f, 0.13158272f, -0.05521068f, 0.12615794f, 
    -0.26925305f, 0.38255998f, -0.02326472f, 0.13001780f, 0.11393617f, 0.12121407f, -0.25418600f, 0.05828207f, 
    0.16586752f, -0.03151685f, 0.09653592f, 0.07857277f, 0.07597464f, 0.00813705f, -0.00038183f, -0.45216554f, 
    0.20764433f, -0.01853425f, -0.02755510f, 0.20875074f, -0.08025801f, -0.17079580f, -0.00455973f, 0.31465003f, 
    -0.03399378f, 0.03364241f, 0.10554589f, 0.38483343f, -0.20107190f, -0.06604884f, 0.10267282f, 0.25652254f, 
    0.32875296f, 0.36303905f, -0.09382623f, 0.02621285f, -0.12566046f, 0.15924978f, -0.23819521f, -0.07641105f, 
    -0.55548507f, -0.10726212f, 0.02633135f, 0.01330932f, 0.20561582f, -0.59280360f, -0.15644693f, 0.07646122f, 
    -0.16586509f, -0.10975908f, 0.01533728f, -0.27798885f, 0.02098874f, 0.06759652f, 0.11637246f, -0.02297328f, 
    0.03874281f, -0.21088549f, 0.01805933f, 0.30764133f, -0.65105975f, -0.78173298f, -0.06089282f, 0.07906663f, 
    -0.03432399f, 0.38972142f, 0.11255649f, 0.17682892f, -0.00111817f, -0.10901750f, 0.21371450f, -0.17867944f, 
    0.07993314f, -0.06935023f, -0.02206684f, 0.13536528f, 0.06087713f, 0.11373091f, 0.07933023f, -0.17782237f, 
    0.09719165f, 0.12499322f, 0.09475601f, 0.39555320f, 0.02402097f, 0.09718982f, -0.01272229f, -0.07974278f, 
    -0.07050874f, 0.32829607f, 0.20027751f, 0.59571874f, -0.13209823f, 0.10274179f, -0.07289075f, -0.14953095f, 
    -0.39943129f, -0.14013493f, 0.10252450f, 0.05109238f, 0.04504564f, 0.15282939f, -0.00159169f, -0.20866011f, 
    -0.09200390f, -0.10352625f, -0.12115820f, 0.08480091f, -0.05376664f, -0.14084932f, 0.16105939f, 0.11462577f, 
    -0.19795887f, 0.36885399f, -0.00276053f, -0.05217098f, -0.18337466f, -0.01458218f, 0.08096541f, 0.33824927f, 
    -0.14782766f, -0.25323468f, -0.08277713f, -0.07903616f, -0.08886980f, 0.22894450f, -0.11536252f, 0.21569161f, 
    0.03715853f, -0.11417075f, 0.15163505f, -0.04468976f, -0.15968320f, 0.15225433f, -0.22979282f, 0.01650677f, 
    0.15966260f, -0.24048576f, 0.07707696f, -0.02043004f, 0.15604587f, 0.37526092f, 0.01351851f, -0.43253461f, 
    0.17451183f, 0.29066834f, -0.05068706f, 0.39417285f, -0.04816416f, -0.10061464f, -0.10115600f, -0.13160636f, 
    -0.05572639f, 0.18216692f, 0.27195272f, 0.32013902f, -0.20296869f, 0.02170900f, 0.03509039f, 0.13090865f, 
    0.00616134f, -0.00114723f, -0.11279932f, 0.11061701f, -0.13480167f, 0.17417735f, -0.02438527f, -0.05664716f, 
    -0.15710089f, -0.00514432f, 0.01671616f, 0.03205879f, 0.08030154f, -0.03315364f, -0.14258605f, 0.02222512f, 
    -0.01499173f, 0.02517480f, -0.04943575f, -0.07578553f, -0.17273316f, 0.11981340f, -0.05191965f, 0.10103870f, 
    0.12233268f, -0.03666541f, -0.02561321f, 0.13675365f, 0.02599362f, 0.08597454f, -0.11226827f, -0.10224789f, 
    0.03152106f, 0.10027377f, 0.12987295f, 0.10629904f, -0.09467806f, 0.14625888f, -0.02466605f, 0.06107595f, 
    0.14218800f, -0.00357714f, -0.07665541f, 0.04319297f, 0.15997235f, -0.22499520f, 0.03949152f, -0.08649521f, 
    0.26190946f, 0.20118803f, -0.05384201f, 0.18755375f, 0.23585056f, 0.09484656f, -0.10931606f, -0.12154911f, 
    0.03701373f, 0.49903649f, 0.45732257f, 0.20906624f, 0.08820743f, -0.30287486f, -0.13776644f, -0.13359350f, 
    -0.07754514f, 0.08345985f, 0.14271976f, 0.16846807f, -0.03757408f, 0.00959593f, 0.14425001f, -0.03681627f, 
    0.04826453f, -0.16245902f, 0.02085184f, -0.06593967f, -0.12441487f, 0.03546912f, -0.07577590f, -0.10656866f, 
    -0.13777243f, 0.03027047f, -0.13661323f, 0.09585460f, -0.05975153f, 0.03168893f, -0.18044975f, -0.08894218f, 
    -0.14123259f, -0.00945204f, -0.11034027f, -0.01747448f, 0.07843529f, 0.00687235f, -0.15185899f, -0.16471791f, 
    -0.03899888f, -0.17667955f, -0.07577840f, -0.08025061f, 0.00761329f, -0.08850559f, 0.14969015f, -0.15869004f, 
    0.34415793f, 0.16453479f, -0.15642905f, -0.25107315f, 0.05692477f, 0.45154995f, -0.05883843f, 0.19180313f, 
    -0.03334887f, -0.09391338f, 0.18005639f, 0.34146583f, 0.23979421f, -0.11023391f, -0.47409436f, -0.29413608f, 
    -0.10495525f, 0.08825243f, 0.25231460f, -0.17886932f, 0.23376203f, -0.02807828f, -0.05427355f, 0.11377571f, 
    0.10406075f, -0.03558818f, -0.17318028f, -0.07068440f, 0.05010565f, 0.11774419f, 0.12011830f, -0.01206043f, 
    0.21991093f, 0.21900778f, 0.10531326f, -0.28898156f, 0.28306764f, -0.19332273f, 0.06043328f, 0.10846224f, 
    -0.13089834f, 0.07594157f, -0.03669720f, -0.60450977f, 0.10511586f, 0.00769445f, -0.21696892f, -0.09336337f, 
    -0.10689189f, 0.40232721f, 0.23137921f, 0.54634148f, -0.20919245f, 0.02737734f, 0.06938917f, -0.13610253f, 
    -0.04516358f, 0.27286768f, -0.05863541f, -0.12287793f, -0.00087498f, 0.04799766f, -0.34923762f, -0.01309621f, 
    0.11267444f, 0.24244963f, 0.17059070f, 0.01669520f, 0.09276138f, -0.53801870f, -0.07264441f, 0.16662963f, 
    -0.07591245f, -0.17951576f, -0.16535030f, -0.22885112f, 0.08929718f, -0.14806595f, -0.27433249f, 0.14658208f, 
    -0.00491248f, -0.05991429f, 0.26264042f, -0.16267321f, 0.02551193f, -0.12059247f, 0.02901350f, 0.22864853f, 
    -0.17045732f, 0.08217736f, -0.14739680f, -0.02206280f, -0.15817167f, 0.00622880f, -0.10738228f, 0.07252261f, 
    -0.12783161f, -0.00079592f, -0.07879467f, -0.13722746f, 0.09451444f, -0.10433853f, -0.04378573f, -0.06275141f, 
    0.05300282f, -0.12597375f, 0.09314948f, -0.09217822f, 0.06009803f, -0.15983185f, 0.07878305f, 0.00856625f, 
    0.06712488f, -0.16103880f, -0.05713361f, -0.08078817f, -0.21893625f, -0.04589774f, -0.11028796f, -0.16752845f, 
    -0.25345895f, -0.07666962f, 0.00646879f, 0.10406812f, 0.05600197f, -0.14876674f, -0.05581418f, -0.00756399f, 
    0.07043462f, -0.25015047f, 0.14890501f, 0.04219868f, 0.13222875f, 0.07568822f, 0.13696186f, -0.16404068f, 
    -0.08463811f, -0.23836638f, 0.04035626f, -0.07560894f, -0.18391298f, -0.09859423f, 0.05265091f, 0.08994409f, 
    0.08738956f, 0.00106223f, -0.06790715f, 0.04469362f, -0.12080038f, -0.04758867f, 0.04567051f, 0.07448649f, 
    -0.39580742f, 0.05215638f, 0.23008911f, 0.17319658f, 0.11802951f, -0.03053286f, 0.01662335f, -0.26273692f, 
    -0.23046526f, 0.04919757f, -0.15827768f, 0.34654656f, -0.25163561f, 0.21706940f, -0.09433451f, -0.07106672f, 
    0.07689437f, -0.22979937f, 0.13250919f, 0.06777658f, -0.20537324f, 0.05133092f, -0.26554349f, -0.09013469f, 
    -0.11944589f, -0.49579403f, 0.02471644f, 0.07254501f, 0.12643918f, 0.08049148f, -0.09721616f, 0.13638988f, 
    -0.08096966f, -0.27699712f, -0.04260475f, 0.00793094f, 0.05544584f, 0.04015572f, 0.01278600f, -0.01821103f, 
    0.44553468f, -0.18236291f, -0.02107958f, 0.06303600f, 0.21460374f, -0.20438936f, -0.05232040f, 0.16872518f, 
    -0.01849918f, -0.26121777f, -0.13169727f, -0.01190449f, 0.00023132f, -0.16929460f, 0.18083155f, -0.29690784f, 
    -0.09435148f, 0.00494246f, 0.35403571f, 0.41376573f, 0.04793850f, -0.00073880f, -0.16061786f, -0.01354502f, 
    -0.12003582f, -0.20111200f, -0.07329012f, 0.08955377f, 0.01538672f, -0.14844456f, -0.30000386f, 0.17997521f, 
    -0.16235109f, -0.09208785f, 0.02433738f, 0.18500164f, 0.00730399f, -0.48348990f, -0.13762166f, 0.20869620f, 
    0.03801730f, -0.09044912f, -0.10985211f, -0.46589312f, -0.00824626f, -0.15480517f, 0.22015129f, 0.09608644f, 
    -0.13413036f, 0.01044772f, 0.06337556f, 0.14992411f, -0.02851271f, -0.16548152f, 0.17650642f, 0.16405872f, 
    -0.07142082f, 0.10592016f, 0.24613960f, 0.14653955f, 0.08792365f, 0.05734968f, -0.25462773f, 0.21316306f, 
    -0.27246758f, 0.01805689f, -0.16936854f, 0.07189205f, 0.09996415f, -0.37041619f, -0.03180600f, 0.26543620f, 
    -0.04793419f, 0.03236149f, -0.09435561f, -0.14290494f, -0.19942951f, -0.03054388f, -0.15448533f, 0.23171891f, 
    0.06715606f, -0.24629347f, 0.02739177f, -0.35562435f, -0.21144329f, -0.02272312f, -0.01363122f, 0.07571146f, 
    0.25209826f, 0.11621555f, -0.20105694f, -0.00645805f, 0.10349998f, -0.08889045f, -0.10590313f, -0.02310524f, 
    -0.04414705f, -0.06683667f, -0.15413503f, 0.05806499f, 0.35037529f, 0.24218956f, 0.14419548f, 0.07237809f, 
    -0.09916169f, 0.13365568f, -0.05460261f, 0.45806557f, -0.19778518f, -0.06662048f, -0.01591383f, 0.07625555f, 
    -0.11867001f, 0.30081093f, 0.42669439f, 0.29091612f, -0.11838583f, 0.06943768f, 0.02714109f, 0.04482650f, 
    -0.01491837f, 0.03375384f, -0.00226178f, 0.05447805f, -0.13246024f, 0.15788816f, -0.09469496f, -0.09312021f, 
    0.09566771f, -0.11682830f, -0.02002439f, -0.14827445f, 0.04965556f, -0.10167518f, 0.04440657f, -0.09281877f, 
    -0.19788539f, -0.11588842f, 0.15309292f, -0.05245034f, -0.15072979f, -0.14886846f, -0.16290921f, 0.03482318f, 
    0.02075760f, 0.17486063f, 0.02213655f, 0.02700326f, 0.11843652f, 0.15638535f, -0.02167494f, 0.05634802f, 
    0.11374551f, -0.44661778f, 0.13599302f, -0.09874757f, -0.11968999f, -0.00546665f, 0.36389878f, -0.12449709f, 
    0.09896661f, -0.08583024f, -0.14159384f, 0.02481960f, 0.19931981f, 0.14021811f, -0.05945617f, -0.00548622f, 
    0.05493118f, 0.22068401f, -0.06757857f, 0.31065717f, 0.24568793f, -0.03114887f, -0.12159333f, -0.29751778f, 
    0.03021583f, 0.19836837f, -0.13713610f, 0.26585439f, -0.36043406f, 0.14878310f, 0.10310383f, 0.14748771f, 
    0.01887769f, -0.09500916f, -0.13029368f, 0.04791191f, -0.01836424f, -0.07718205f, 0.26494426f, -0.13998254f, 
    0.14945254f, 0.04907998f, -0.12794481f, 0.13684204f, -0.23945630f, 0.27534121f, 0.14841837f, 0.23097925f, 
    -0.37315369f, -0.44497874f, -0.14206196f, -0.07305954f, -0.06854530f, 0.02109675f, -0.16473271f, -0.02190983f, 
    -0.14994253f, -0.22128223f, 0.03496822f, -0.09254734f, 0.02109988f, 0.18785289f, -0.10945056f, 0.24540147f, 
    0.11390708f, 0.14394669f, 0.16344148f, 0.00083044f, 0.02576086f, 0.11767220f, -0.48115209f, 0.14660603f, 
    -0.06729420f, 0.18768910f, 0.16948397f, 0.06095811f, 0.06071837f, -0.14082046f, -0.13870324f, -0.13424045f, 
    -0.05637731f, -0.17669378f, -0.03315910f, -0.16906819f, -0.11326835f, 0.14602125f, -0.02912482f, 0.11533906f, 
    0.13123089f, 0.11736216f, 0.02995130f, -0.23459809f, -0.00525524f, -0.23082939f, -0.06971875f, 0.23526555f, 
    0.03027330f, 0.03024080f, 0.05484669f, -0.01784285f, -0.14710775f, 0.11615646f, -0.02590461f, -0.08248163f, 
    0.10326178f, -0.16257465f, 0.08064015f, -0.18181629f, -0.10686162f, -0.04396675f, -0.00868261f, -0.15867601f, 
    -0.11720542f, -0.07302727f, 0.14882974f, 0.05861521f, -0.13545987f, -0.05807547f, -0.06290925f, -0.10870037f, 
    0.12933344f, -0.19790050f, 0.11553513f, 0.01254883f, -0.15139344f, 0.00912541f, 0.16795304f, 0.00067017f, 
    -0.12349244f, 0.14136653f, 0.03357145f, -0.01017808f, -0.02430430f, -0.13966067f, 0.01696277f, 0.18281834f, 
    0.00070282f, 0.14229435f, 0.03555071f, -0.20326357f, 0.02788869f, -0.13837315f, -0.12867975f, -0.24195728f, 
    0.28120288f, 0.08158639f, -0.02534824f, 0.15201345f, 0.21284364f, 0.16120932f, -0.15593377f, -0.15422688f, 
    0.03659083f, 0.17921728f, 0.16006207f, 0.06849256f, -0.24322453f, -0.05815145f, -0.03336020f, 0.02347384f, 
    -0.25259396f, -0.19976236f, 0.29087102f, -0.12477954f, 0.14530776f, 0.03507005f, 0.19796732f, -0.19628887f, 
    -0.41743958f, 0.11447138f, 0.08482350f, 0.33321255f, -0.15940219f, 0.04983669f, 0.03619354f, 0.03550476f, 
    0.01870548f, 0.33031502f, 0.13548325f, -0.08186519f, -0.17890088f, -0.06968231f, -0.11741757f, 0.04927231f, 
    0.10201622f, 0.14847206f, -0.16355088f, 0.06803378f, -0.29205495f, 0.14383003f, -0.00462983f, -0.00586087f, 
    -0.14897835f, 0.06138846f, 0.19439659f, 0.05349169f, -0.10364752f, -0.09410392f, -0.02302145f, -0.17147799f, 
    0.05486866f, 0.01678765f, 0.01224595f, 0.21202025f, 0.12976824f, -0.04682106f, -0.06696268f, -0.10234508f, 
    -0.26973677f, 0.27575305f, -0.04076964f, -0.40714195f, -0.16196196f, 0.14801688f, 0.13117409f, 0.26337212f, 
    -0.07737912f, 0.17084002f, 0.09248716f, 0.15004382f, -0.11247131f, -0.00094966f, 0.01280411f, 0.20423323f, 
    0.01778174f, -0.29166535f, 0.26956087f, 0.08780363f, 0.14410833f, 0.15452850f, 0.15379953f, 0.14381362f, 
    -0.08097657f, -0.09998410f, 0.10557821f, 0.03480030f, 0.26777670f, -0.46868885f, 0.02518333f, -0.29614422f, 
    0.11345023f, 0.20248447f, 0.09514158f, -0.27431175f, 0.21192628f, -0.08910950f, -0.06140636f, -0.08339407f, 
    0.00534119f, 0.38781676f, -0.06708387f, 0.36365664f, -0.49866983f, 0.02308040f, -0.03055790f, 0.01192375f, 
    0.01286338f, 0.27513576f, 0.21203838f, 0.02158523f, -0.15949826f, 0.01490679f, -0.09150714f, -0.28010693f, 
    0.18250519f, -0.04364098f, -0.12980394f, -0.04013967f, 0.03075496f, 0.00768942f, -0.09708604f, 0.00136007f, 
    -0.56703520f, 0.32228568f, -0.08588063f, -0.26403248f, -0.08324854f, 0.03416545f, -0.10539143f, 0.34346706f, 
    -0.02103742f, 0.15695155f, 0.02459514f, -0.09093426f, 0.25751182f, 0.31973282f, -0.17141438f, 0.15733120f, 
    -0.27453172f, -0.04059224f, 0.17641632f, 0.10156901f, 0.07043652f, 0.12450331f, 0.13562009f, -0.05207449f, 
    -0.08940983f, -0.05157870f, 0.17735417f, 0.19925043f, -0.10272931f, 0.16103411f, -0.06183607f, -0.30000469f, 
    -0.13059114f, -0.18633704f, -0.11684933f, -0.15312229f, -0.11892804f, -0.09027488f, -0.12037257f, 0.16752499f, 
    0.09442797f, -0.43099526f, -0.10391226f, -0.07767094f, -0.25323015f, 0.39242223f, -0.03005749f, 0.22961214f, 
    -0.21372268f, 0.11685329f, 0.13072760f, -0.00958621f, -0.15576483f, 0.05126008f, 0.22381142f, -0.06049103f, 
    -0.38765538f, 0.07523132f, -0.08533451f, 0.15910083f, 0.14218165f, -0.33367217f, 0.11989265f, 0.12141724f, 
    -0.14636110f, 0.38041729f, 0.00954181f, -0.15825830f, -0.17922488f, -0.05738500f, 0.00197773f, 0.26379871f, 
    0.01095343f, 0.29969028f, 0.13762358f, 0.24226952f, -0.43241182f, 0.02575895f, 0.00679633f, -0.09462015f, 
    0.08262327f, -0.07419575f, 0.09148236f, 0.05792083f, -0.16838989f, 0.06792898f, 0.05110000f, -0.15685269f, 
    -0.04942135f, -0.02504551f, 0.15182123f, -0.15841269f, 0.12458298f, -0.07407288f, 0.13645598f, -0.15585077f, 
    -0.14369236f, -0.11824475f, -0.02295840f, -0.00566784f, 0.04713771f, 0.03109466f, -0.17641537f, -0.08619812f, 
    -0.00853267f, -0.02293733f, -0.07188853f, -0.12493118f, 0.01663749f, 0.00643129f, -0.02552843f, -0.09217104f, 
    -0.21006528f, -0.20968096f, -0.00387318f, -0.11279990f, -0.14790595f, 0.13947733f, -0.22990505f, 0.31527501f, 
    0.01338667f, -0.05999842f, 0.02057535f, 0.02778454f, 0.13579346f, 0.28556964f, 0.14421643f, 0.01565703f, 
    -0.13297911f, -0.34973612f, 0.16213603f, 0.35186481f, -0.15479176f, -0.12685135f, 0.21296068f, 0.00522768f, 
    0.08219849f, 0.15294407f, -0.22907767f, 0.62381226f, -0.36832818f, -0.03736632f, 0.08395091f, 0.19164814f, 
    0.03032731f, 0.06219860f, 0.08255237f, 0.14729394f, -0.13997604f, -0.17390090f, -0.07612016f, -0.06670141f, 
    -0.05155693f, -0.12261678f, -0.01448553f, 0.04359553f, 0.10091990f, -0.09441448f, 0.09047813f, -0.12956209f, 
    0.02227892f, -0.15399495f, -0.12396859f, -0.04135715f, -0.15659678f, 0.13244030f, -0.00422008f, -0.07046684f, 
    0.08629441f, 0.16378732f, -0.01731568f, -0.05366309f, 0.07369582f, 0.10805640f, 0.11128984f, -0.15961626f, 
    0.14535010f, -0.32595533f, -0.05536012f, -0.02952832f, -0.03687762f, -0.04872649f, 0.00683364f, 0.22872746f, 
    -0.00008189f, 0.10473177f, -0.18101095f, -0.20526871f, 0.28219730f, 0.09447791f, 0.09533317f, 0.16597126f, 
    0.05055201f, 0.18981993f, 0.13815483f, 0.11238791f, 0.37414274f, -0.05828375f, -0.18371186f, -0.06681152f, 
    -0.02066807f, 0.16469292f, -0.00380234f, -0.09844314f, -0.26378986f, -0.15435186f, 0.14295681f, 0.04161686f, 
    -0.25605094f, 0.14274022f, 0.28228119f, 0.14649570f, 0.09599652f, 0.05164117f, -0.00325610f, 0.09114215f, 
    -0.20264484f, 0.33454284f, -0.09287000f, 0.19293457f, -0.17508252f, -0.01499552f, -0.08857862f, -0.07703336f, 
    0.02677832f, 0.40650302f, 0.12738143f, -0.00963243f, 0.00827101f, 0.09481062f, -0.15875562f, 0.28694007f, 
    0.07593108f, 0.21360946f, -0.20037353f, -0.26202211f, -0.00744205f, -0.09419192f, 0.07862103f, -0.04755874f, 
    0.05862467f, -0.00484226f, -0.06004214f, 0.12461091f, -0.01328553f, -0.09951936f, -0.13023788f, -0.10383589f, 
    0.01597080f, 0.11905484f, 0.08347013f, -0.07281500f, -0.17731524f, 0.13232236f, 0.06475624f, 0.06769826f, 
    -0.09648478f, -0.12742341f, 0.15921693f, -0.08462576f, -0.10604438f, 0.07621141f, -0.12090165f, 0.03128084f, 
    0.16545027f, 0.09351033f, -0.19997559f, -0.01410947f, 0.13289265f, -0.07691171f, -0.16904783f, -0.11632419f, 
    0.04464138f, 0.20846291f, 0.17482768f, 0.09203577f, -0.07275740f, 0.16099539f, -0.68771946f, 0.05404972f, 
    -0.50636744f, 0.06623966f, 0.00976941f, 0.14590600f, 0.01210720f, -0.54306614f, 0.01410466f, -0.50813860f, 
    -0.14995648f, -0.01443612f, 0.16573426f, -0.33932099f, -0.09300539f, -0.11541513f, -0.06062183f, 0.28625840f, 
    -0.10851839f, 0.26422849f, 0.02006498f, -0.25101906f, -0.33625790f, -0.41211647f, -0.04582501f, 0.18409072f, 
    -0.00920594f, 0.09550003f, -0.03380374f, -0.13132986f, 0.04636531f, -0.02173278f, 0.10563868f, -0.33110219f, 
    0.03756640f, -0.16773720f, -0.02374312f, 0.30139223f, 0.00173071f, 0.31377974f, 0.05078446f, -0.34023586f, 
    -0.20759791f, 0.28450337f, 0.01577346f, 0.22487885f, 0.12387738f, 0.04982562f, 0.16271201f, 0.04459412f, 
    0.18223894f, -0.17194955f, -0.05207324f, -0.10765752f, -0.03273273f, 0.30368403f, 0.01265342f, 0.04162526f, 
    -0.12090375f, 0.16581236f, 0.19141820f, -0.11649872f, -0.05678234f, -0.09378276f, 0.21186151f, 0.01335058f, 
    -0.31677181f, -0.04565236f, 0.09794590f, 0.32410607f, -0.09919789f, -0.11998893f, -0.03351472f, 0.23728563f, 
    -0.33889169f, -0.04416235f, -0.15037504f, -0.42870119f, -0.21486805f, -0.10252091f, -0.05778613f, 0.25842485f, 
    0.10826104f, -0.07605568f, -0.25721657f, -0.26255691f, 0.09129632f, 0.33700499f, -0.06194653f, 0.17439815f, 
    -0.44327155f, -0.09029844f, 0.06573284f, -0.05129742f, -0.08614630f, -0.12328300f, -0.17479160f, -0.11943685f, 
    0.17693357f, -0.17884032f, -0.13037670f, 0.19789718f, -0.18357871f, 0.22470286f, 0.07862142f, -0.34162265f, 
    -0.26894668f, 0.25859961f, 0.10977229f, -0.06113705f, -0.01857289f, -0.11256458f, -0.12226710f, 0.32222220f, 
    -0.06036974f, -0.19239692f, 0.09131820f, -0.32269284f, 0.12130079f, 0.04594819f, 0.15576465f, 0.23998554f, 
    0.18982077f, -0.12673333f, 0.06820687f, -0.11183010f, -0.07698636f, -0.16281849f, 0.11093403f, 0.23261102f, 
    -0.15574349f, -0.03184892f, 0.04622890f, -0.07716284f, -0.13328932f, 0.43978125f, 0.10490245f, 0.17856774f, 
    0.07302272f, -0.17349382f, -0.11308745f, 0.48787919f, 0.13853319f, 0.11039483f, -0.27254504f, -0.29992476f, 
    0.09418840f, 0.12656522f, 0.06806989f, 0.00051327f, -0.13446549f, 0.14843355f, 0.09951632f, 0.03457653f, 
    -0.14250484f, 0.04014603f, 0.16562188f, 0.03320484f, -0.08812413f, -0.09479525f, 0.02626966f, 0.11319539f, 
    -0.24542201f, 0.29196155f, -0.01645380f, 0.10396921f, 0.00893269f, -0.44712928f, -0.13126525f, 0.18152449f, 
    -0.42276862f, 0.13770343f, -0.07549333f, -0.39345434f, -0.12770799f, 0.01737243f, -0.29039600f, 0.19184135f, 
    -0.00248398f, -0.11984868f, -0.15785427f, -0.16455203f, 0.11823893f, -0.07457579f, -0.01255936f, 0.11178740f, 
    0.04228924f, -0.10683463f, -0.16181344f, -0.04595983f, 0.03435008f, 0.09083845f, 0.14400418f, 0.10590488f, 
    -0.13842301f, -0.05331470f, -0.02749783f, 0.11916855f, 0.15514681f, -0.05611464f, -0.08600666f, -0.04418734f, 
    -0.03146864f, 0.10174157f, -0.17782986f, -0.08555590f, 0.10492908f, 0.15830894f, -0.10797711f, 0.08515543f, 
    -0.00552176f, -0.06913546f, -0.17677973f, 0.02504213f, -0.13897465f, -0.02698992f, -0.11506290f, -0.18670763f, 
    -0.21468693f, -0.25606436f, 0.03793614f, -0.08606428f, -0.06119256f, 0.13797718f, 0.10313165f, 0.19368778f, 
    0.01952321f, 0.16207370f, -0.05870064f, 0.01582493f, -0.02269196f, 0.26904148f, 0.17669825f, 0.09215844f, 
    -0.20400667f, -0.14420778f, 0.16004318f, -0.12397212f, 0.32025409f, 0.15066078f, -0.59215379f, -0.00837063f, 
    -0.02101611f, -0.18794741f, -0.08585995f, -0.27552098f, 0.14956073f, -0.13962910f, -0.11033452f, 0.21266305f, 
    -0.38492870f, -0.40697923f, 0.30437225f, 0.07652380f, 0.17216519f, -0.01814270f, 0.10386407f, -0.06115992f, 
    0.08622086f, 0.16499738f, 0.14266482f, 0.19716465f, -0.03353427f, -0.04366639f, -0.17605418f, -0.28992009f, 
    0.22028969f, 0.02739762f, -0.15262200f, 0.10772743f, 0.23291686f, -0.06190163f, 0.04410032f, -0.23005797f, 
    -0.07776128f, 0.11462021f, -0.28541195f, 0.04807246f, -0.23488441f, 0.27101305f, -0.03011849f, 0.12461668f, 
    -0.05229812f, -0.02047568f, 0.24380755f, -0.11206283f, -0.15336232f, 0.10776529f, -0.25936705f, 0.20739670f, 
    0.09432132f, 0.23085333f, 0.07768290f, 0.09641252f, -0.15995865f, -0.11361792f, -0.07230730f, -0.18022954f, 
    0.41524825f, 0.09614968f, 0.07340477f, 0.33181238f, 0.32582417f, 0.12530152f, -0.49470067f, -0.14329726f, 
    -0.10771152f, 0.21469669f, -0.25859037f, -0.57136434f, 0.06465897f, -0.05717273f, 0.01822525f, 0.10517515f, 
    -0.00702206f, 0.07365904f, 0.07585301f, -0.17227742f, 0.11090919f, -0.06239081f, 0.09154677f, 0.06832440f, 
    0.16071890f, 0.17508145f, 0.06596841f, 0.07329973f, 0.05691125f, 0.17978798f, 0.00322682f, -0.07103285f, 
    -0.10121002f, 0.36542988f, -0.06740173f, -0.24060602f, 0.25043532f, 0.09852822f, -0.29364675f, 0.05371214f, 
    -0.05912903f, 0.04222988f, -0.17886227f, -0.42780712f, 0.17734696f, 0.34080982f, 0.05904831f, -0.20172957f, 
    -0.18386029f, 0.19659977f, -0.22373520f, 0.00581870f, 0.07264585f, -0.08033594f, 0.15823513f, 0.21499667f, 
    -0.25660798f, 0.08002309f, 0.16053829f, 0.14538294f, -0.10557192f, 0.37259281f, 0.04050471f, 0.15472347f, 
    -0.14372258f, -0.48449403f, -0.03941992f, -0.03265509f, -0.13047183f, 0.11570993f, -0.09885225f, 0.07373931f, 
    0.16295265f, -0.45802271f, 0.14243355f, 0.24911468f, -0.17186680f, 0.28287134f, -0.00240191f, 0.23269175f, 
    -0.15921913f, -0.07976956f, 0.06277718f, -0.01524333f, -0.08548123f, 0.00091603f, -0.15010215f, -0.02647995f, 
    0.16411687f, 0.18372500f, 0.05200591f, -0.21124347f, -0.10143440f, 0.47031137f, 0.13329531f, -0.09181918f, 
    -0.16152200f, -0.12226808f, 0.07026437f, 0.21229622f, 0.00675748f, -0.02316925f, -0.26047710f, -0.23834403f, 
    0.05267407f, -0.00298663f, -0.15629455f, -0.35637659f, 0.05966342f, 0.03174791f, -0.00785081f, 0.25242528f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.29796040f, -0.19509640f, -0.10413220f, -0.07644473f, 0.32501799f, -0.01660899f, 0.15949167f, -0.33128849f, 
    -0.04063128f, 0.29614627f, -0.06763173f, -0.22296304f, -0.06759361f, 0.31064665f, -0.07093107f, -0.10571906f, 
    -0.19756486f, 0.04341802f, 0.15763213f, 0.15002894f, -0.02195231f, -0.06445729f, -0.13994280f, 0.34634042f, 
    0.08396452f, 0.33812350f, -0.19386479f, -0.20209607f, 0.15756886f, 0.11766534f, 0.25112885f, 0.07377742f, 
    0.06589492f, -0.08586269f, 0.24068570f, 0.09542897f, 0.21662375f, -0.21231788f, -0.07567759f, 0.06052714f, 
    -0.02201874f, 0.01482938f, -0.09193496f, 0.04978099f, 0.11124434f, -0.13435444f, 0.05664990f, -0.06814452f, 
    0.06022220f, 0.06266236f, 0.00271943f, -0.02529134f, -0.00024467f, 0.12262903f, 0.08251368f, 0.09862377f, 
    0.37098473f, -0.15091453f, 0.38063630f, 0.22607972f, -0.07098655f, 0.06685554f, 0.12408134f, 0.07487699f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08379834f, -0.45001706f, 0.14897186f, 0.19438544f, 0.16197699f, -0.01567601f, -0.05864286f, -0.27908146f, 
    -0.09999663f, 0.03280537f, 0.07788640f, 0.17849952f, 0.07006339f, -0.13467330f, -0.26903269f, 0.05608498f, 
    -0.15374905f, -0.30807415f, 0.13816485f, 0.24293567f, -0.06702527f, -0.19261873f, 0.08163656f, -0.01065678f, 
    0.01911647f, 0.00564689f, 0.06411237f, 0.02688084f, -0.00336155f, -0.04567196f, 0.14535697f, -0.05258213f, 
    0.03998418f, 0.03611052f, 0.05607423f, -0.13626601f, 0.14289983f, -0.08779036f, -0.05295544f, -0.10361699f, 
    0.13489869f, 0.21007815f, 0.06842604f, 0.06577149f, -0.29912382f, -0.03718214f, 0.23175283f, -0.02223334f, 
    0.25651151f, -0.19171526f, -0.10203863f, 0.19137186f, -0.03477590f, -0.11263552f, 0.50302416f, 0.04304587f, 
    0.10223474f, 0.18344350f, 0.43842515f, -0.01876087f, 0.16078773f, 0.12900482f, -0.04079738f, 0.19593969f, 
    0.02400816f, -0.08637271f, -0.12493823f, 0.24234889f, -0.45606616f, 0.13393392f, 0.11608653f, -0.00023526f, 
    0.04969770f, -0.25482038f, 0.09559938f, 0.43203136f, -0.02382003f, -0.16400814f, 0.06956255f, 0.49615791f, 
    0.47611031f, 0.08299092f, 0.15676613f, 0.23586513f, -0.06052419f, -0.01065336f, 0.08181210f, -0.42354572f, 
    -0.28006044f, 0.04526237f, 0.10230334f, 0.25494730f, 0.39048108f, -0.26614237f, -0.04382628f, 0.21342272f, 
    0.18274795f, -0.13375019f, -0.36623022f, -0.47099420f, 0.20550770f, -0.09145184f, -0.00020605f, 0.28007969f, 
    0.19249049f, -0.01178363f, 0.04007806f, 0.30558658f, 0.22109538f, -0.05974619f, -0.14451711f, -0.01754594f, 
    -0.36006072f, 0.11082847f, -0.01750111f, 0.58805418f, 0.28033653f, 0.09226196f, 0.39606059f, -0.40703946f, 
    0.07260470f, 0.04235541f, -0.62048239f, 0.00937184f, 0.12372338f, -0.22109601f, -0.03489022f, -0.11524963f, 
    -0.01352282f, -0.12846775f, 0.06981985f, -0.07326116f, 0.04145368f, 0.04985163f, 0.06949458f, 0.01293413f, 
    0.05170580f, 0.00169657f, -0.06238209f, -0.03544581f, -0.06587677f, -0.02374425f, -0.15585817f, -0.08958793f, 
    0.09395168f, -0.00985620f, -0.06341096f, -0.18780318f, -0.10385721f, -0.10307301f, -0.01790798f, -0.10016066f, 
    0.05575903f, 0.02094119f, -0.11381011f, -0.04575131f, -0.01449591f, 0.01411797f, 0.01449990f, -0.11412862f, 
    -0.10009550f, 0.04507406f, -0.03196092f, -0.13812762f, -0.01970541f, -0.03644484f, 0.02561058f, -0.03745072f, 
    -0.14142390f, -0.14602494f, 0.03845556f, -0.15062431f, -0.11555553f, 0.04618695f, 0.05813245f, -0.00772276f, 
    0.04023118f, -0.17046154f, -0.11600245f, -0.07232697f, -0.04045831f, -0.19387114f, 0.08147589f, -0.01414732f, 
    -0.04008446f, -0.12309323f, 0.07941572f, -0.14689921f, 0.01573763f, -0.02709610f, -0.04843302f, -0.02838619f, 
    -0.02506092f, -0.06777097f, -0.00279723f, 0.08138031f, -0.04886619f, -0.07063355f, 0.08162391f, -0.03954118f, 
    -0.03386537f, -0.09258343f, 0.07856990f, -0.06668681f, -0.08554731f, 0.05502925f, -0.16074370f, 0.09120525f, 
    -0.09400056f, 0.02439325f, -0.00990091f, -0.09545679f, 0.00065728f, -0.12308120f, -0.05292039f, -0.01517533f, 
    0.10121354f, -0.00518233f, -0.09551157f, -0.02512805f, -0.12882189f, -0.00732000f, -0.10872103f, 0.03380244f, 
    -0.02364506f, -0.07395467f, -0.03034219f, -0.11651812f, 0.05267500f, -0.07992761f, -0.01363386f, 0.10446432f, 
    -0.10303456f, -0.00433140f, -0.09027086f, -0.01761930f, -0.05468951f, -0.09328423f, -0.01745536f, 0.00177066f, 
    -0.14356422f, 0.05677675f, 0.04887469f, -0.11861877f, 0.01561149f, 0.05372460f, -0.06173202f, 0.07186379f, 
    -0.05090722f, 0.07962994f, -0.06450435f, -0.09293251f, -0.13149324f, -0.09209829f, -0.02105921f, 0.10467836f, 
    0.18863794f, -0.16659994f, 0.05994894f, 0.06031839f, -0.01206074f, 0.05999194f, -0.00590036f, 0.00835137f, 
    0.09323714f, 0.03975438f, -0.02580325f, 0.01051117f, 0.14834486f, 0.14257622f, -0.12239058f, -0.17456524f, 
    0.03415242f, -0.08639602f, 0.01773478f, 0.06001224f, -0.10232833f, 0.03646039f, -0.00793260f, 0.03315113f, 
    0.01974710f, 0.26697028f, -0.00506139f, 0.12613080f, 0.04881710f, -0.10194940f, 0.08871187f, 0.35489592f, 
    0.13114943f, 0.04996844f, -0.04219583f, -0.19591792f, 0.24264272f, 0.05316779f, -0.10029490f, 0.28304693f, 
    0.17572485f, -0.12032451f, 0.21480329f, -0.28331539f, 0.45110345f, 0.03645499f, 0.26372963f, -0.04637251f, 
    -0.07973012f, 0.15650183f, -0.00012438f, -0.36937475f, -0.40552372f, 0.20419575f, -0.39847529f, 0.12076021f, 
    0.40044925f, -0.14877297f, 0.06944044f, -0.19375730f, -0.01393222f, -0.09997378f, -0.04356626f, -0.02506366f, 
    0.10546524f, 0.13657367f, 0.06651647f, -0.41485178f, 0.03145242f, 0.13438734f, 0.10699370f, -0.30310589f, 
    -0.10431317f, -0.01334569f, 0.05843010f, 0.25739470f, -0.12855683f, 0.15096782f, -0.16422038f, 0.18844453f, 
    0.39569795f, 0.31910092f, -0.12607168f, 0.01821617f, -0.03048482f, 0.20617665f, -0.01536955f, -0.23882563f, 
    0.15876666f, 0.08596314f, 0.02241994f, -0.01731670f, 0.07853069f, 0.09823673f, 0.31233001f, 0.05280443f, 
    -0.00699195f, -0.06124856f, 0.05801762f, -0.11989029f, 0.07727959f, 0.09637102f, 0.04831357f, 0.33803540f, 
    0.28639084f, 0.55885041f, -0.08916643f, 0.11230847f, 0.43542379f, 0.06074028f, 0.06079728f, -0.00942809f, 
    -0.02977253f, 0.07329418f, 0.05558312f, 0.17763712f, -0.04414925f, 0.04270099f, -0.39432952f, -0.06189079f, 
    0.22022857f, 0.01638128f, -0.08738644f, 0.20538566f, 0.00866347f, -0.15447217f, -0.05909517f, -0.15491974f, 
    0.01342743f, 0.07865325f, 0.04245101f, -0.43711779f, -0.04373668f, -0.06104267f, 0.01108714f, 0.13226838f, 
    0.04250784f, -0.17852005f, 0.12265738f, 0.18811190f, -0.22630189f, 0.01015353f, -0.09276423f, 0.12052187f, 
    0.43503410f, 0.04926737f, 0.20577416f, 0.08111913f, 0.04454037f, 0.10483348f, -0.12175880f, -0.12082648f, 
    -0.14990710f, -0.02425835f, 0.06711958f, 0.06250079f, -0.04849435f, 0.17296235f, 0.20088676f, 0.14182483f, 
    0.11832741f, -0.13771579f, 0.07987042f, 0.06665544f, 0.09181453f, 0.08059306f, -0.04902066f, -0.13501674f, 
    -0.05307837f, 0.18052000f, 0.13501297f, 0.23237075f, 0.12618162f, -0.00627315f, 0.34629321f, -0.05136187f, 
    0.20853341f, -0.11881822f, 0.10496451f, 0.53523034f, 0.07996759f, 0.00249101f, 0.36612970f, 0.11367675f, 
    0.10858378f, -0.01457455f, -0.07297282f, -0.08238225f, -0.34130374f, -0.27759147f, 0.17614725f, -0.39235428f, 
    0.00295631f, -0.12066268f, 0.04970701f, -0.10312115f, -0.26093039f, 0.13517991f, -0.00034035f, -0.09955706f, 
    -0.04927080f, -0.55337524f, 0.03990594f, 0.21738406f, -0.13541570f, -0.04154309f, -0.34919858f, 0.19117741f, 
    0.76612449f, 0.14509155f, -0.19742849f, -0.07321674f, 0.02063758f, 0.07541374f, 0.03434978f, -0.49519113f, 
    -0.11240089f, 0.10208417f, 0.01878838f, -0.04745770f, -0.01040815f, -0.27653995f, 0.16508542f, 0.21170600f, 
    -0.00457099f, -0.06948275f, -0.52055562f, -0.15595220f, 0.11643002f, 0.02455379f, -0.00731245f, -0.07098424f, 
    -0.00220851f, 0.00262534f, 0.08746547f, 0.07285891f, -0.01423851f, -0.11260760f, -0.12955831f, -0.05868150f, 
    -0.16458349f, -0.01743554f, -0.05234716f, 0.34935641f, -0.31793427f, 0.09192994f, -0.16192734f, -0.31281167f, 
    0.15296182f, -0.02336105f, -0.34640366f, -0.31629622f, -0.08673728f, -0.33301574f, -0.00067692f, -0.22315219f, 
    0.00052210f, -0.29228416f, -0.06461560f, 0.22726929f, 0.09380901f, 0.05477356f, 0.23941827f, -0.11346202f, 
    -0.02262240f, 0.07523005f, 0.08881310f, 0.08748033f, 0.21534912f, 0.45496941f, 0.07439623f, 0.04060315f, 
    -0.60004246f, -0.16644092f, -0.07691205f, 0.27926254f, 0.06327133f, 0.19361308f, -0.12785122f, -0.03198289f, 
    -0.26303706f, 0.10229532f, -0.01582570f, -0.08016498f, -0.15835620f, -0.00768393f, 0.49476677f, 0.35934415f, 
    0.18844084f, -0.05102414f, -0.04357484f, -0.09747183f, 0.28144789f, -0.07461999f, 0.21788566f, 0.11352271f, 
    -0.08668574f, 0.16117597f, -0.02898808f, -0.20669360f, 0.07236679f, -0.03713331f, -0.04534483f, -0.00732338f, 
    0.36633441f, 0.28369397f, -0.10314127f, 0.23965155f, -0.06591360f, -0.25838947f, 0.12903060f, -0.14625901f, 
    0.06599119f, -0.11452933f, 0.15900496f, 0.04973949f, 0.39797115f, 0.05116810f, -0.23521914f, 0.06333034f, 
    -0.12174838f, -0.04173860f, 0.03589018f, 0.03471367f, 0.10666664f, 0.01643699f, 0.07885328f, -0.27025211f, 
    -0.06567458f, -0.03831579f, 0.01100871f, -0.17510505f, -0.00455644f, -0.12550728f, 0.01853197f, 0.17426968f, 
    -0.42490026f, 0.22246785f, -0.13092251f, 0.27741927f, -0.09503875f, 0.24686335f, -0.08336148f, 0.12258471f, 
    0.31930697f, 0.10531300f, 0.10339598f, -0.14985332f, -0.03592587f, 0.33209005f, -0.13292365f, -0.00828635f, 
    0.05991053f, 0.17156608f, 0.29245326f, -0.10430401f, -0.09135846f, -0.02739721f, 0.11781818f, 0.06474733f, 
    0.01993123f, 0.38629591f, -0.07961279f, -0.08943575f, 0.01667227f, 0.04367292f, 0.17427123f, -0.03251815f, 
    0.06075939f, -0.06495807f, -0.06822237f, -0.20952877f, 0.07518077f, -0.63105148f, 0.09033890f, 0.13295537f, 
    -0.06612902f, 0.09365594f, -0.22730410f, 0.23904711f, -0.08024198f, -0.07458455f, -0.23645657f, -0.00251423f, 
    -0.11443976f, -0.23398499f, 0.06632596f, 0.24191034f, -0.08109551f, -0.09430753f, -0.15510820f, -0.10127826f, 
    -0.04193756f, 0.21440686f, 0.06735963f, -0.25809559f, 0.31518564f, 0.20365961f, 0.47730565f, 0.06307656f, 
    -0.46539366f, 0.04998478f, 0.29595694f, 0.07083114f, -0.00435327f, 0.14501588f, -0.08183610f, 0.02309004f, 
    -0.08236516f, 0.18985963f, 0.05279672f, -0.00320617f, -0.01503489f, -0.29317737f, -0.04566061f, 0.00477302f, 
    -0.13069770f, 0.04902463f, -0.13777217f, -0.20336127f, 0.19454993f, 0.11481743f, 0.04942026f, 0.14188591f, 
    0.14948709f, 0.22665350f, 0.21359798f, -0.16167486f, 0.12225241f, 0.11989118f, -0.26948038f, -0.08428670f, 
    -0.10927325f, 0.23069839f, 0.07964542f, -0.18952726f, -0.17230833f, 0.08041519f, 0.32271799f, -0.20523331f, 
    0.31095752f, 0.05869030f, 0.04382376f, 0.16343661f, 0.13964008f, 0.39422351f, -0.28455821f, -0.10108496f, 
    0.13399000f, 0.08212340f, 0.09027551f, 0.26483232f, 0.15415104f, 0.27841130f, -0.18215743f, -0.01893336f, 
    -0.14114718f, 0.18278366f, -0.08919436f, -0.14475189f, 0.42175418f, 0.16779593f, 0.00016321f, 0.07004296f, 
    -0.57267213f, 0.21535648f, -0.12530681f, 0.10734878f, 0.10947116f, 0.12700397f, 0.08525422f, 0.32462043f, 
    0.32520786f, -0.00649392f, 0.04431907f, -0.00428195f, -0.06962230f, -0.06484517f, -0.21872768f, -0.20358624f, 
    0.20827518f, 0.07527955f, -0.03571335f, -0.05305910f, -0.12477399f, -0.09157270f, 0.10292399f, -0.11350233f, 
    -0.05615623f, -0.30757073f, -0.01642658f, -0.56870961f, -0.00765294f, -0.00968821f, -0.01503955f, 0.05519131f, 
    -0.05446397f, 0.14554374f, -0.03702040f, -0.40320218f, 0.20237158f, -0.25503036f, -0.01984215f, 0.15752572f, 
    -0.00473169f, -0.17165200f, 0.05951638f, 0.05513354f, 0.29442826f, 0.24631426f, -0.05670199f, 0.27915981f, 
    -0.08308353f, -0.10451086f, 0.01267408f, 0.14162804f, -0.22377156f, -0.10887115f, 0.06244589f, -0.20617381f, 
    0.10601010f, 0.08367298f, 0.04840995f, -0.13431747f, 0.01088321f, 0.02509340f, 0.31255841f, 0.25097495f, 
    -0.31913197f, -0.07915910f, 0.27570316f, -0.01979165f, -0.08034053f, 0.06064985f, -0.08747395f, -0.06903148f, 
    -0.24180840f, -0.02006157f, 0.03111561f, 0.09433283f, 0.05973450f, -0.13100052f, 0.17655626f, -0.02857343f, 
    -0.08768373f, 0.01736468f, -0.10117929f, -0.04567702f, -0.01816461f, -0.09004976f, 0.05808072f, 0.04519109f, 
    0.23201247f, -0.19716772f, 0.27285677f, 0.19089073f, 0.14820708f, -0.02212654f, -0.20736493f, 0.00968351f, 
    -0.32522503f, 0.14592521f, -0.05031698f, 0.19106260f, 0.13984187f, 0.28894135f, 0.47097468f, -0.29386017f, 
    0.22935034f, 0.13293971f, -0.05642572f, 0.02152376f, 0.02178353f, 0.10098373f, 0.04733310f, 0.07486984f, 
    0.16709422f, -0.18129987f, 0.14570601f, -0.20549399f, -0.11172955f, 0.34967780f, -0.06717914f, -0.07674778f, 
    -0.06611852f, 0.05560998f, -0.02594924f, 0.02324471f, 0.05179060f, 0.16430064f, 0.10260510f, -0.18539526f, 
    -0.38801736f, -0.04267799f, 0.21217820f, -0.08256289f, 0.06025798f, 0.12289632f, 0.02492706f, -0.34367877f, 
    -0.02979806f, 0.17165828f, -0.08176564f, 0.03556346f, -0.08585449f, -0.09984235f, 0.41984522f, 0.28793553f, 
    0.13604729f, -0.04357864f, -0.23154737f, -0.21529560f, 0.21105839f, 0.09077619f, -0.00913442f, 0.25233191f, 
    0.12922515f, 0.00741766f, 0.07391268f, -0.14320731f, 0.29662031f, -0.08351929f, 0.16291134f, 0.07047363f, 
    0.11732052f, 0.05609970f, -0.09850508f, 0.33079365f, -0.14543118f, 0.32426241f, -0.16125073f, -0.19337519f, 
    0.25523594f, -0.07479870f, -0.10048486f, -0.16407678f, 0.07003010f, 0.03212268f, 0.05278000f, -0.12891807f, 
    0.23886712f, 0.09123820f, -0.03883990f, 0.36921409f, 0.18260576f, 0.02062896f, -0.00311711f, 0.14510687f, 
    -0.13700581f, -0.12054197f, -0.03306925f, -0.10333195f, 0.20007263f, 0.29082525f, 0.05796262f, -0.07252309f, 
    -0.54122531f, 0.06003110f, -0.06718642f, -0.10467674f, -0.04457101f, 0.00965426f, 0.02253563f, 0.29279536f, 
    0.09040177f, 0.13106848f, 0.00129080f, -0.08050682f, -0.09865291f, -0.14241980f, -0.14436056f, 0.07350097f, 
    0.27159509f, -0.07907785f, -0.21095224f, -0.04393689f, 0.13004805f, 0.09851178f, 0.03967157f, -0.03057016f, 
    0.04785667f, -0.41293368f, 0.02003821f, -0.31532553f, -0.10540640f, 0.07237017f, -0.00934968f, 0.04803822f, 
    -0.07723162f, 0.05932934f, -0.07473856f, -0.16700412f, -0.17227739f, 0.13380241f, -0.06466451f, 0.17731430f, 
    0.16739175f, -0.03245868f, -0.04013903f, -0.27912799f, 0.02838124f, -0.03147960f, 0.16530755f, -0.05384814f, 
    -0.10708950f, 0.05039995f, 0.08610249f, -0.01620049f, -0.12770149f, -0.12872668f, -0.07868784f, 0.01961686f, 
    -0.14179915f, -0.14117011f, 0.03255686f, -0.06028049f, -0.02560494f, -0.06065206f, -0.15502204f, -0.02705212f, 
    0.07765242f, -0.02973158f, 0.00846432f, -0.03777415f, -0.02032430f, -0.13404939f, -0.02519596f, 0.03950283f, 
    -0.01377925f, -0.09842005f, -0.00349846f, 0.12477608f, 0.09816516f, 0.09014595f, -0.17593083f, -0.01894910f, 
    -0.05685808f, -0.08685739f, -0.02668974f, -0.00566118f, -0.03463980f, 0.01210669f, 0.07557113f, -0.01787804f, 
    -0.08040525f, -0.05497194f, -0.00441691f, -0.13062650f, 0.01795206f, 0.03878383f, -0.06991040f, -0.10021050f, 
    -0.03663509f, -0.06698255f, 0.07793128f, -0.02512038f, 0.02446422f, 0.00220992f, -0.10473777f, -0.13237882f, 
    -0.01270858f, 0.05548468f, -0.01004085f, 0.05372502f, -0.03620591f, 0.00639659f, 0.01841480f, 0.00860000f, 
    -0.10967073f, 0.03969002f, -0.04788090f, 0.14861590f, -0.06141677f, 0.11364140f, 0.02530918f, 0.01564006f, 
    0.05400863f, 0.08878464f, -0.05769950f, -0.03559688f, -0.02090110f, -0.07743476f, -0.00184027f, 0.21551897f, 
    -0.00632368f, 0.29165828f, -0.01590555f, 0.12435770f, 0.04947934f, 0.15781318f, -0.05501730f, 0.05376700f, 
    0.25327659f, -0.10969865f, -0.16776492f, -0.10861896f, -0.01176410f, 0.19256239f, 0.07864085f, -0.03343191f, 
    0.22390988f, 0.15599528f, 0.16309661f, -0.10606373f, -0.04876109f, -0.08230343f, -0.06555558f, -0.15801467f, 
    0.16712147f, 0.03030110f, 0.07985009f, -0.22781342f, -0.01980954f, 0.07720521f, 0.04885770f, -0.08317145f, 
    -0.06473494f, 0.00241381f, -0.05799635f, 0.00022609f, 0.05307792f, -0.29997653f, -0.03900173f, -0.23934487f, 
    -0.19860922f, -0.06817553f, -0.37530851f, 0.13468499f, -0.04554373f, -0.05000613f, -0.36180028f, 0.00973495f, 
    0.15174936f, -0.12206719f, -0.12412246f, 0.03833267f, 0.29495829f, -0.08070315f, 0.19376175f, -0.03793993f, 
    -0.06005465f, 0.01529696f, -0.00828616f, -0.15674101f, 0.19563060f, 0.19419369f, -0.19982909f, 0.05599103f, 
    0.10234660f, -0.08978644f, -0.22331414f, 0.00314793f, 0.03326417f, -0.09141440f, 0.05846112f, 0.28329334f, 
    0.08109973f, 0.01588852f, -0.06637853f, 0.09247519f, 0.18278319f, -0.27672923f, -0.07904053f, -0.02801756f, 
    0.03298742f, 0.10511075f, 0.08823433f, 0.13887002f, -0.04110201f, 0.07604748f, 0.15334404f, 0.00878183f, 
    -0.21221793f, -0.03855022f, -0.25505763f, 0.08196692f, -0.13037001f, -0.10262136f, 0.10252340f, 0.09122937f, 
    0.18260187f, 0.05051928f, 0.10635866f, 0.05380848f, 0.05665958f, 0.00224635f, 0.05120652f, 0.30534244f, 
    0.10587328f, 0.04464146f, 0.59704214f, 0.08865248f, 0.21693207f, 0.15109390f, 0.33417889f, 0.20641419f, 
    -0.03841140f, -0.03868779f, -0.05030531f, 0.07737304f, -0.12375806f, 0.06177102f, 0.07900918f, -0.03912247f, 
    -0.10639247f, 0.00964645f, -0.05854908f, -0.13753618f, -0.03659493f, 0.00303090f, -0.03809470f, -0.05732672f, 
    -0.05494730f, 0.02167973f, -0.03315175f, -0.16543105f, -0.08407487f, 0.05523028f, -0.01720592f, -0.14551894f, 
    0.01196041f, -0.00302324f, 0.04121898f, -0.08354241f, 0.09288065f, 0.05327602f, -0.06810396f, 0.00330025f, 
    -0.09967197f, -0.11921909f, -0.00591071f, -0.05158380f, -0.14527246f, 0.00647892f, -0.02497823f, 0.00825163f, 
    0.00031127f, -0.14168377f, 0.00572876f, 0.04265826f, -0.01875975f, 0.02234644f, -0.03268145f, 0.09416068f, 
    -0.05465652f, -0.03141131f, -0.01849223f, -0.00573160f, -0.11412278f, -0.04384843f, 0.01504360f, -0.16989522f, 
    -0.04912871f, -0.08553872f, -0.05780835f, -0.03756709f, 0.05798068f, 0.02535383f, -0.10032006f, -0.14600644f, 
    0.01887548f, -0.00539241f, 0.01975082f, -0.01194257f, 0.07140869f, 0.13424517f, -0.10592096f, 0.01297015f, 
    -0.00783301f, 0.17553195f, -0.03863949f, -0.11643235f, 0.15167941f, 0.12960038f, 0.07378200f, -0.19471213f, 
    -0.65591353f, 0.00987642f, 0.12564915f, -0.11246535f, -0.05149544f, 0.00802067f, 0.06288888f, 0.05083993f, 
    -0.05817432f, -0.02231989f, -0.05537201f, 0.03096139f, -0.04174734f, 0.02667142f, -0.06692355f, 0.05824483f, 
    0.06776486f, -0.10961669f, -0.05802139f, 0.18754965f, 0.05303891f, -0.00186774f, -0.12088841f, 0.23005313f, 
    0.10817579f, -0.22155784f, 0.09040490f, -0.09802318f, 0.25989231f, -0.11892127f, -0.15025809f, 0.09326794f, 
    0.00610679f, 0.09412638f, 0.08299482f, 0.10549197f, 0.00512392f, 0.33182663f, -0.07893690f, -0.04213385f, 
    0.16341621f, -0.04690709f, -0.08069755f, -0.03827122f, -0.11418004f, 0.12811038f, 0.00474812f, 0.18587756f, 
    -0.06854568f, 0.04590440f, 0.02373510f, 0.19434841f, -0.07347324f, -0.00608004f, 0.06440520f, 0.04821882f, 
    -0.09390236f, 0.22234344f, 0.08019345f, -0.20989747f, 0.35357842f, 0.25942981f, 0.34843361f, -0.45298994f, 
    -0.36935660f, -0.18701220f, 0.23268478f, -0.23454495f, -0.04336901f, 0.02912766f, -0.07341278f, 0.17867452f, 
    -0.22113405f, 0.03141447f, 0.12844796f, 0.03615671f, -0.03504146f, 0.13062206f, -0.10385856f, 0.04555271f, 
    -0.23928505f, 0.08191755f, -0.12261239f, 0.01805616f, 0.09690356f, 0.02478415f, -0.07906339f, 0.34033552f, 
    0.05073428f, 0.08652681f, 0.16196135f, -0.15109919f, -0.05508236f, -0.11434183f, -0.02259340f, -0.07232254f, 
    -0.11878456f, 0.11337069f, -0.07372042f, -0.09939812f, 0.01920092f, 0.36241356f, -0.13039210f, 0.02738656f, 
    0.31102693f, -0.04958422f, 0.28679520f, 0.08736912f, 0.13103406f, 0.20425625f, -0.09534246f, 0.12656796f, 
    0.10573863f, 0.19013987f, 0.00590462f, -0.18029234f, 0.15232441f, 0.03558949f, 0.13303825f, -0.11758936f, 
    0.03240004f, -0.17864643f, 0.11282960f, -0.12617253f, 0.03820111f, -0.07008832f, 0.02209672f, 0.08402559f, 
    0.42630047f, 0.22164796f, -0.27786538f, 0.21146213f, -0.03671756f, 0.14418580f, -0.07148536f, 0.19960470f, 
    0.48757449f, 0.13030910f, -0.02492522f, 0.07453158f, -0.09842451f, 0.16658896f, 0.08382426f, -0.07623877f, 
    0.17446849f, 0.08747830f, 0.15338129f, 0.19912136f, 0.11302088f, 0.05147190f, -0.05728034f, -0.31897542f, 
    -0.05655907f, 0.06206889f, -0.08542135f, -0.09073456f, 0.01350049f, 0.05156900f, -0.18521069f, 0.06365287f, 
    0.08378103f, -0.08613128f, 0.03110825f, -0.10615259f, 0.03157305f, -0.31335029f, -0.36541784f, 0.04581683f, 
    -0.11754256f, 0.06087248f, -0.12779358f, -0.02222627f, -0.10083700f, -0.15301886f, -0.06056139f, -0.05115980f, 
    0.04903029f, -0.10520349f, 0.13818049f, -0.10168080f, 0.05906825f, -0.00508776f, 0.14719135f, -0.16011694f, 
    0.04153192f, -0.04592765f, -0.04734777f, -0.04066417f, -0.03427656f, -0.08752585f, -0.29863828f, 0.07459145f, 
    -0.19444561f, 0.22577137f, -0.03333544f, 0.25292131f, 0.09512927f, 0.16152699f, -0.07999040f, 0.20850649f, 
    0.47438079f, -0.02941809f, 0.04315051f, -0.03521838f, 0.00906397f, 0.03769729f, -0.02348484f, -0.14487650f, 
    0.00063827f, -0.08102361f, 0.29182935f, 0.04190934f, -0.12715745f, -0.13591434f, 0.26873875f, 0.01020547f, 
    -0.15601195f, 0.36534736f, -0.14017598f, -0.03217905f, -0.03225721f, 0.07343100f, 0.16950785f, -0.11741585f, 
    0.10751860f, -0.05913878f, 0.10698441f, -0.12826085f, 0.13331990f, -0.48102909f, 0.10986986f, 0.18283156f, 
    -0.07352691f, 0.11982617f, 0.09581509f, 0.11609516f, 0.17259315f, 0.12684402f, 0.10241492f, 0.07507021f, 
    -0.00524014f, -0.00294595f, 0.04498025f, 0.08480407f, 0.09451263f, 0.11482654f, -0.04416889f, 0.03481207f, 
    0.09358652f, 0.15749736f, -0.02976508f, -0.15977567f, 0.13968678f, 0.06596331f, 0.10055996f, 0.17517287f, 
    -0.01600086f, -0.05155892f, 0.05407600f, -0.20559412f, 0.00358773f, -0.09026045f, 0.05138596f, -0.15671195f, 
    0.08305625f, 0.15364236f, -0.10110898f, -0.04001465f, 0.26631784f, -0.25402775f, 0.06464246f, 0.18481433f, 
    -0.09685561f, 0.11934163f, -0.19070816f, 0.14456137f, 0.14351812f, 0.02215533f, 0.04779213f, 0.02252514f, 
    0.05270544f, -0.26014256f, -0.06235406f, 0.18099470f, 0.10392434f, 0.11816432f, 0.31737012f, -0.04615053f, 
    -0.27151915f, 0.01835052f, 0.13170214f, -0.05498313f, 0.08756720f, 0.15835904f, 0.18842734f, -0.12089480f, 
    0.08260120f, -0.05071414f, 0.25437093f, 0.00965508f, 0.20699552f, 0.12386656f, 0.25677878f, 0.26330507f, 
    0.08233897f, -0.24352746f, -0.01871190f, -0.04240016f, 0.20450275f, -0.19714344f, -0.27384725f, -0.07525600f, 
    0.02874669f, 0.31145182f, -0.06380955f, 0.02273494f, 0.01022244f, -0.12341854f, 0.06926890f, -0.24401298f, 
    0.39149284f, 0.04545942f, 0.17605801f, -0.11699901f, -0.04795622f, -0.27452037f, 0.03899729f, 0.10006920f, 
    -0.48303506f, -0.12168803f, 0.07228805f, 0.15278685f, 0.51646841f, -0.17180216f, -0.13662936f, 0.08068337f, 
    -0.11653712f, 0.05218677f, 0.22549941f, 0.27345729f, -0.17112839f, -0.07291616f, -0.18449241f, 0.40777987f, 
    0.11077620f, 0.02977611f, 0.16170624f, 0.63883406f, 0.13446675f, -0.04587716f, -0.04936420f, 0.01545175f, 
    -0.30487159f, 0.07728269f, 0.09978503f, 0.08567935f, 0.23996101f, 0.48889640f, 0.36959288f, 0.03448257f, 
    0.27742800f, -0.06086413f, 0.37280345f, 0.09552896f, -0.20690684f, 0.12661536f, 0.23896217f, 0.22190928f, 
    0.15968239f, 0.05473549f, -0.02724299f, 0.16014710f, 0.32746428f, -0.14463422f, 0.17603974f, -0.03322383f, 
    -0.10688385f, -0.02540025f, 0.07970386f, -0.07898980f, 0.05412350f, 0.37641704f, -0.02900944f, -0.12821661f, 
    0.43875954f, -0.11260026f, -0.27165475f, 0.11199579f, 0.10421350f, 0.16992779f, -0.08674953f, 0.34714347f, 
    0.05532781f, 0.31431001f, -0.09530317f, 0.00532010f, -0.18950041f, 0.10417144f, 0.20243010f, -0.01279936f, 
    -0.03407570f, 0.08255055f, 0.09020082f, 0.10349087f, 0.14248405f, 0.13034399f, 0.09736007f, -0.33785760f, 
    -0.05043338f, -0.04461445f, -0.16363110f, -0.34576288f, -0.12319700f, 0.11462209f, -0.09528195f, -0.06322739f, 
    0.12466953f, -0.04965035f, -0.07041444f, -0.28372058f, -0.15834469f, -0.19690385f, -0.18431574f, 0.12488405f, 
    0.16691370f, -0.07017612f, 0.37019265f, -0.07657095f, -0.09089611f, 0.00329676f, -0.03174199f, 0.17522258f, 
    0.01279993f, -0.29583383f, -0.06918656f, 0.19860518f, -0.09644565f, -0.11914653f, -0.17449941f, -0.25127724f, 
    0.12671144f, 0.20390864f, -0.08751193f, -0.00067029f, 0.05638692f, -0.16987969f, 0.28777865f, 0.11134290f, 
    -0.37966704f, -0.13129961f, 0.36323437f, 0.14846362f, -0.03921097f, -0.17752154f, 0.00686754f, -0.08455282f, 
    -0.37562728f, 0.09275141f, 0.12360112f, 0.05134317f, 0.18510522f, -0.42435509f, -0.10534069f, -0.07386151f, 
    -0.05028690f, -0.15283795f, -0.06517512f, -0.05564935f, -0.05129609f, 0.11019380f, -0.14265642f, 0.33370599f, 
    0.24339826f, 0.22620246f, 0.13264719f, 0.50674653f, -0.00685279f, -0.04656050f, -0.39877468f, 0.07805811f, 
    -0.09943579f, 0.07259494f, -0.07410182f, 0.44086924f, 0.27118814f, 0.32938778f, 0.60680389f, -0.30314994f, 
    0.15497753f, 0.00223542f, 0.18874788f, 0.16997924f, -0.02280696f, 0.00111176f, -0.17760137f, 0.13388847f, 
    0.03457475f, -0.16134274f, -0.05961259f, -0.01411952f, -0.19022729f, 0.04210735f, 0.21173134f, -0.19271845f, 
    -0.06018437f, -0.09550145f, 0.04414986f, 0.44620427f, 0.03760373f, -0.01899436f, -0.00887416f, 0.02956850f, 
    0.14513376f, -0.01425947f, -0.28711200f, 0.09384211f, 0.05044952f, 0.07626271f, -0.05317736f, -0.21705046f, 
    -0.13474058f, 0.13979301f, 0.10718772f, 0.03011572f, -0.28254572f, -0.19414829f, 0.07811860f, 0.19955066f, 
    -0.17288935f, 0.08392851f, -0.05279237f, -0.21334203f, 0.33949178f, 0.07493486f, 0.25511590f, -0.01789714f, 
    0.14733972f, 0.54606295f, 0.01613003f, 0.02666368f, 0.05772705f, -0.11716077f, -0.00798354f, -0.10018221f, 
    0.16471678f, 0.20582180f, 0.00561867f, 0.41350672f, -0.31442717f, -0.12520739f, -0.18305014f, -0.15738679f, 
    -0.01392338f, 0.01812861f, 0.05627510f, 0.08772053f, 0.24795654f, 0.18206798f, -0.39270726f, 0.10523291f, 
    0.05646649f, 0.03193595f, -0.16085047f, 0.28449056f, 0.20329867f, -0.21991812f, 0.20916608f, -0.00995912f, 
    0.09671266f, -0.19860075f, -0.11233728f, 0.05611617f, -0.04963901f, 0.06066424f, 0.03434971f, 0.30225050f, 
    0.02836469f, -0.22337350f, 0.10504115f, 0.33255392f, -0.09312984f, -0.05174821f, 0.07294080f, 0.22425748f, 
    -0.02480266f, 0.22378834f, -0.11523827f, -0.04494681f, 0.02012123f, -0.08965357f, 0.24966061f, 0.25900304f, 
    -0.01848226f, -0.04661660f, 0.04189065f, -0.19865106f, 0.31329164f, 0.10610343f, 0.12249979f, -0.30233249f, 
    0.02755106f, 0.13283829f, 0.02713302f, 0.05441165f, -0.09017184f, -0.09448145f, 0.16323195f, 0.08272696f, 
    0.28988886f, -0.10110248f, -0.08914360f, -0.02192884f, -0.14262116f, -0.17364584f, 0.14526296f, 0.05356307f, 
    -0.02167159f, -0.03681809f, 0.13183071f, -0.07711385f, 0.24723580f, 0.05287564f, -0.10705668f, 0.25431919f, 
    0.16954350f, -0.12514596f, -0.11607614f, 0.04843550f, 0.14673705f, 0.17384350f, -0.01262826f, -0.30953687f, 
    -0.00602949f, -0.10649585f, 0.08784465f, 0.08205272f, 0.19359028f, 0.16928433f, -0.19148810f, 0.06884789f, 
    0.42983997f, -0.12844184f, 0.24438463f, -0.12875158f, 0.08306893f, -0.00012515f, 0.11669536f, -0.06431807f, 
    0.13657172f, 0.30428681f, -0.00230563f, 0.09023022f, -0.04816526f, -0.15818886f, 0.21597891f, 0.15986019f, 
    -0.01695133f, 0.04539821f, -0.26469001f, 0.11929102f, 0.11070881f, -0.04222781f, 0.06000571f, 0.08901993f, 
    -0.03148846f, -0.29272410f, 0.14281359f, 0.20944047f, 0.11060756f, -0.04906285f, 0.20362674f, 0.08325062f, 
    -0.04243895f, -0.00321703f, -0.15716954f, -0.08560135f, -0.35518819f, 0.28227624f, 0.19862673f, -0.13033515f, 
    0.25838202f, -0.09382357f, 0.34142593f, -0.08620661f, -0.12151138f, 0.06389046f, 0.25463814f, 0.05226428f, 
    -0.05280919f, -0.14739144f, -0.03945196f, 0.02949892f, -0.11814503f, -0.05950245f, -0.07331836f, 0.09316951f, 
    -0.06865287f, -0.07199071f, 0.10694191f, 0.03638189f, 0.07316492f, -0.00694946f, -0.13365455f, -0.08551310f, 
    0.09674169f, 0.00994735f, 0.12011711f, -0.01971753f, -0.09643823f, 0.03469563f, 0.08746263f, -0.00847535f, 
    -0.12330161f, 0.03277104f, 0.04229374f, -0.11099105f, -0.04722160f, 0.07481019f, -0.07267918f, 0.01396525f, 
    -0.03066130f, 0.11258996f, -0.07612286f, 0.02406366f, 0.10072754f, -0.06405354f, 0.02371533f, 0.07714340f, 
    -0.05333042f, 0.03865452f, -0.05324623f, 0.01242582f, -0.02681763f, 0.10438874f, -0.06599716f, 0.08386593f, 
    -0.07515349f, -0.14250535f, 0.12372704f, -0.04613499f, -0.05560177f, -0.03185725f, -0.11275379f, -0.10481686f, 
    -0.11888580f, 0.07116504f, -0.03975661f, 0.03778153f, -0.08165184f, -0.04729626f, -0.03573244f, -0.07138576f, 
    0.20841359f, 0.19922704f, 0.08579817f, 0.11789218f, 0.13866644f, 0.26110822f, 0.07612877f, -0.00575132f, 
    -0.11810049f, -0.15778932f, -0.10312714f, 0.00677704f, 0.09218264f, 0.11027859f, -0.01861909f, 0.17646767f, 
    0.24440010f, 0.14864613f, -0.15320045f, -0.07444093f, -0.05368393f, -0.02699077f, 0.07073910f, 0.09052580f, 
    0.24642795f, 0.25956374f, 0.05993626f, 0.10907936f, -0.14626186f, -0.14662804f, -0.12088727f, -0.04095374f, 
    0.32849330f, 0.12479623f, -0.21289346f, 0.12753151f, 0.17415209f, -0.08191770f, -0.04027079f, -0.18206285f, 
    -0.10713841f, -0.30064079f, 0.08313821f, -0.06401286f, 0.06353187f, -0.07318430f, -0.21751362f, -0.10636532f, 
    -0.15227978f, -0.08389934f, 0.00997081f, -0.33649567f, -0.01976911f, -0.21641427f, -0.10637224f, 0.11856566f, 
    0.07021977f, 0.00699912f, -0.03690294f, -0.04303459f, 0.06420928f, -0.00673512f, 0.20616576f, -0.03831409f, 
    -0.11571927f, -0.04205908f, -0.04105842f, 0.11982825f, -0.11721759f, -0.01520864f, 0.02050712f, -0.15886292f, 
    -0.02740305f, -0.04338348f, 0.12392773f, -0.06317023f, -0.08322465f, 0.07466975f, -0.14920309f, -0.02275676f, 
    0.00562577f, 0.09971323f, -0.05957069f, -0.08636034f, -0.01242271f, -0.14292705f, -0.08761358f, -0.11003833f, 
    0.06762075f, -0.05487930f, 0.07875055f, -0.09927414f, 0.09458927f, 0.01520332f, -0.03544170f, -0.02854609f, 
    -0.04981977f, 0.01415288f, -0.07953342f, -0.03295545f, 0.08108392f, -0.03496036f, -0.10617846f, 0.00552049f, 
    -0.12486292f, -0.07349733f, -0.03414531f, -0.05996157f, -0.13713968f, 0.07803772f, 0.02989149f, 0.06827448f, 
    0.02182218f, 0.02417693f, -0.10812245f, -0.09525311f, -0.05714536f, -0.05141909f, -0.05035502f, -0.14538999f, 
    -0.05039568f, 0.02375038f, -0.07536136f, -0.12754001f, -0.08279017f, 0.10848029f, -0.00307017f, -0.02314534f, 
    0.11389909f, -0.07643475f, -0.01936979f, 0.05718261f, -0.19794112f, 0.01381210f, -0.10534111f, -0.06517005f, 
    0.09717812f, -0.02327569f, -0.06374370f, 0.09073081f, 0.04554636f, -0.13503243f, 0.04755316f, 0.07328377f, 
    0.03173718f, 0.40567830f, 0.03680137f, 0.14386715f, 0.07589794f, 0.05730977f, 0.07973113f, -0.11239266f, 
    0.04323503f, -0.13611752f, 0.02448590f, 0.13500178f, 0.10206784f, -0.00134320f, -0.09174535f, -0.03302936f, 
    0.02833816f, -0.08586109f, 0.36745802f, -0.04219697f, -0.13572994f, 0.08186124f, 0.21702009f, 0.27404305f, 
    0.02766220f, 0.28313893f, -0.10331684f, 0.11268308f, 0.21608533f, 0.08688378f, -0.09088539f, -0.07584028f, 
    0.05630479f, 0.11089477f, -0.22419880f, -0.16879453f, 0.23899175f, -0.00406685f, -0.12739757f, 0.12815727f, 
    -0.09625470f, -0.05775518f, -0.06190151f, 0.22731023f, 0.19996443f, -0.01946905f, -0.25525489f, -0.14405212f, 
    0.24121796f, 0.37994990f, 0.06544468f, -0.18582441f, -0.03575784f, 0.26461586f, 0.23378362f, 0.12409506f, 
    -0.06773490f, -0.29066339f, -0.08764732f, 0.38253674f, 0.15902349f, -0.18332031f, -0.08530486f, 0.20792638f, 
    0.47146240f, 0.07582205f, -0.33216149f, -0.20254886f, 0.11209736f, -0.00356149f, 0.08756070f, -0.09911570f, 
    0.42350364f, 0.24495474f, 0.07125296f, 0.09975559f, -0.27320212f, 0.17508410f, 0.07860635f, 0.05602428f, 
    -0.10896229f, -0.03078473f, -0.15338701f, 0.05414802f, 0.16026917f, -0.10912116f, 0.14204255f, -0.03066220f, 
    0.10406903f, 0.05192798f, 0.20766981f, 0.01976881f, 0.17588349f, 0.11406924f, -0.21622331f, -0.08338141f, 
    -0.07615779f, -0.06034560f, 0.04170432f, 0.07611930f, -0.32158038f, 0.03093007f, -0.37111300f, -0.21405202f, 
    0.22599572f, -0.07587933f, 0.01818638f, -0.24988785f, -0.07854119f, 0.08375703f, 0.16736819f, -0.20679884f, 
    0.03606380f, -0.16248363f, -0.01221617f, 0.11610682f, 0.00124372f, -0.03275720f, 0.01090471f, -0.04448575f, 
    -0.10765971f, -0.11581432f, -0.08773245f, -0.00801604f, -0.09201770f, -0.04097427f, -0.11419207f, 0.07168691f, 
    0.07798344f, -0.06056372f, 0.06248111f, -0.03251190f, -0.01869488f, 0.07121533f, 0.03184752f, 0.02988165f, 
    0.07924014f, -0.10573446f, 0.05488986f, 0.00278709f, 0.03330372f, -0.02733200f, -0.11888432f, 0.09762380f, 
    0.02525056f, 0.04167749f, 0.09282988f, 0.03017517f, -0.09205823f, -0.09369272f, -0.07429657f, 0.04634166f, 
    0.05617956f, 0.03099561f, 0.07488889f, -0.06190078f, -0.08477152f, 0.08644509f, 0.00244471f, 0.10382535f, 
    -0.10373935f, -0.10615287f, 0.01979218f, -0.09789929f, 0.00810981f, -0.06627118f, 0.02168842f, -0.02494029f, 
    -0.12873253f, -0.02465025f, -0.10219107f, -0.11776558f, -0.03098040f, 0.07153984f, 0.05730550f, -0.09781703f, 
    -0.02952927f, -0.25847286f, -0.04447380f, 0.06358017f, 0.25323096f, -0.14736217f, 0.16209857f, -0.19337198f, 
    -0.09862117f, 0.30769995f, 0.08283143f, -0.06233249f, 0.14238077f, 0.05579185f, 0.20773023f, -0.19099584f, 
    0.53421116f, -0.13726124f, 0.09784444f, -0.04853312f, -0.06077784f, -0.17325218f, 0.09173746f, 0.26354036f, 
    -0.47727773f, 0.20072095f, -0.03103341f, 0.12260272f, 0.33188382f, 0.12291437f, 0.18035942f, 0.20831411f, 
    -0.19554424f, 0.14746717f, -0.02451253f, 0.34807134f, 0.13325875f, 0.11916614f, -0.16070215f, 0.20838517f, 
    0.21120484f, -0.27992922f, 0.07536908f, 0.00011770f, 0.12644392f, -0.09460758f, -0.09239075f, 0.00452332f, 
    -0.19969957f, 0.05414263f, 0.09738863f, 0.09095237f, -0.03383660f, 0.64186502f, -0.08725540f, 0.09523284f, 
    0.37584075f, -0.13019028f, 0.23259793f, 0.09403723f, -0.10971982f, 0.06137419f, 0.21998343f, 0.14267255f, 
    0.21626239f, 0.00865212f, -0.02620484f, -0.36420619f, -0.19827712f, 0.16390103f, 0.05411515f, -0.08515475f, 
    0.09954819f, -0.13857721f, -0.00658971f, 0.09176623f, 0.10712198f, -0.17296781f, -0.26448819f, 0.02151926f, 
    -0.56975514f, 0.00151148f, 0.06838439f, 0.23526643f, -0.02813877f, 0.05649107f, 0.10859334f, -0.16072342f, 
    -0.06874751f, 0.02342094f, 0.07539909f, 0.00963900f, -0.09179931f, -0.08813845f, 0.05269247f, 0.28772375f, 
    0.13375184f, -0.12569386f, -0.02043477f, -0.26250264f, 0.22461852f, -0.10631713f, 0.14033563f, 0.29956141f, 
    0.25034845f, 0.53365171f, 0.10121126f, 0.18413645f, 0.44358233f, -0.12096429f, 0.08106109f, -0.01191433f, 
    0.20160443f, 0.17925324f, 0.00731249f, 0.36418343f, -0.05868891f, 0.07767668f, -0.30003679f, 0.03882989f, 
    0.03341200f, 0.10616843f, -0.05353572f, 0.18404119f, 0.01519827f, -0.02447265f, -0.03097244f, -0.20598792f, 
    0.05414396f, -0.00859361f, -0.01875711f, -0.30919513f, 0.16746616f, -0.11927054f, 0.24067163f, -0.04690262f, 
    0.11990828f, -0.06210675f, 0.13071904f, -0.28375947f, -0.26877186f, 0.14872229f, -0.02552967f, -0.17018862f, 
    -0.00056118f, 0.11825959f, 0.08861693f, -0.00558511f, -0.11733127f, 0.18939692f, 0.09258037f, 0.08475130f, 
    -0.35826406f, 0.03849740f, 0.05800900f, 0.04918156f, -0.02737278f, 0.33559012f, 0.09412970f, 0.04481075f, 
    0.11135487f, -0.07218811f, 0.04856398f, 0.09851838f, 0.01115840f, -0.02361771f, 0.01951298f, -0.02241720f, 
    0.06418782f, -0.05845213f, -0.32544887f, 0.01064969f, -0.08320680f, -0.03648390f, 0.09532733f, -0.04934158f, 
    -0.04558268f, -0.15817741f, -0.03098181f, -0.18288076f, 0.07527839f, -0.04931929f, 0.00721401f, 0.17495157f, 
    -0.06656028f, -0.06716659f, -0.16568521f, 0.02876742f, -0.32731923f, -0.21597414f, 0.22309203f, -0.01311073f, 
    0.27883065f, 0.06328904f, -0.03018525f, -0.02661193f, 0.20046295f, 0.14076485f, 0.03225880f, 0.16754581f, 
    -0.06604074f, -0.04229431f, 0.11646228f, 0.06907585f, 0.01482959f, -0.07800990f, -0.19355859f, 0.40272641f, 
    0.58228338f, 0.12084810f, 0.03403880f, 0.19142821f, 0.01863184f, 0.04716060f, 0.02120419f, 0.13347584f, 
    0.33273256f, 0.08226313f, 0.10235525f, -0.08737034f, -0.09115952f, -0.29891729f, -0.21165608f, 0.19679017f, 
    0.32417402f, 0.09174456f, 0.07334342f, 0.12614754f, 0.15277293f, -0.07778479f, 0.06104942f, -0.20293841f, 
    -0.00291815f, -0.39451674f, -0.07915826f, 0.09181780f, -0.16955723f, -0.04907940f, 0.08753184f, 0.02187025f, 
    -0.11199371f, -0.01868840f, 0.04607682f, -0.15742031f, 0.17907175f, -0.04555241f, 0.07006561f, 0.25107434f, 
    -0.17885143f, -0.09887691f, -0.02301916f, 0.04881313f, 0.04449905f, -0.06887159f, 0.19050626f, 0.15733328f, 
    -0.11262930f, -0.15398271f, 0.07323487f, 0.09691250f, 0.00131551f, -0.14186794f, 0.06485230f, -0.02234188f, 
    0.08274099f, 0.07611608f, -0.00071494f, -0.01514802f, -0.05163434f, -0.05385957f, 0.00107474f, 0.04429184f, 
    -0.03794984f, -0.06454848f, -0.12274119f, 0.01581126f, 0.11008976f, 0.01892902f, 0.05767427f, -0.06824253f, 
    -0.07009900f, 0.03263490f, -0.05020867f, -0.00490414f, 0.08567068f, -0.09567311f, 0.00862865f, 0.08786993f, 
    -0.14402580f, 0.05797148f, -0.11168358f, -0.06079488f, -0.09687203f, 0.03072618f, -0.11946196f, -0.07904345f, 
    -0.00268662f, -0.01432082f, -0.01123543f, 0.09983477f, -0.05450315f, -0.06020895f, 0.04034055f, 0.02758887f, 
    0.05470031f, -0.15610296f, 0.02042311f, -0.04859802f, -0.04554641f, -0.06689595f, 0.09126272f, 0.02715125f, 
    0.02207831f, -0.04309531f, -0.05252083f, -0.09232049f, -0.04420592f, 0.08874653f, -0.14992586f, -0.09525613f, 
    -0.11016611f, -0.07363318f, -0.02838681f, 0.25317466f, 0.03100062f, -0.39621219f, -0.07062045f, 0.15020862f, 
    -0.15693010f, 0.10145750f, -0.00709024f, -0.01405161f, 0.11290350f, -0.15132564f, 0.26253721f, -0.14046651f, 
    0.16036753f, -0.22561803f, 0.13123167f, -0.14453880f, -0.10381294f, -0.12352311f, -0.05300686f, 0.22554541f, 
    -0.45855150f, 0.06182749f, 0.13886930f, -0.08415482f, 0.30082953f, -0.06907883f, 0.02830787f, 0.00207023f, 
    -0.20486070f, -0.12571125f, 0.10982878f, 0.13309328f, -0.11248531f, 0.01243986f, -0.11979189f, 0.08370838f, 
    -0.06413250f, -0.37498665f, 0.18104824f, 0.18933903f, -0.14956044f, 0.10956977f, 0.02552735f, -0.09588581f, 
    0.09007215f, 0.06881268f, -0.06267576f, 0.14497489f, -0.02825810f, 0.22926243f, 0.53380793f, -0.03671342f, 
    0.06941355f, -0.01729295f, 0.17026195f, 0.03627812f, 0.10857088f, 0.04102120f, 0.13584360f, 0.00092374f, 
    0.11678342f, -0.17414932f, -0.04981558f, -0.11958706f, -0.00172141f, -0.06834593f, -0.10167953f, -0.20408355f, 
    0.04544655f, 0.23614149f, -0.06178444f, 0.13844551f, -0.06424168f, -0.18569933f, -0.18014814f, 0.36316016f, 
    -0.26023486f, 0.30093047f, -0.06842663f, 0.28642875f, 0.05225564f, -0.11526775f, 0.00880950f, 0.05128672f, 
    -0.07336980f, -0.22993635f, -0.03372335f, 0.03766465f, 0.22026084f, -0.19509602f, -0.10176395f, -0.06380501f, 
    0.14069076f, -0.08503771f, 0.09882491f, 0.12366279f, -0.10388500f, 0.04961847f, 0.07954084f, 0.28709018f, 
    -0.09877944f, 0.15526383f, -0.36005300f, 0.23009118f, 0.22027686f, 0.02644268f, 0.27058110f, -0.11524196f, 
    -0.08718108f, 0.15300739f, 0.14408460f, 0.03311825f, 0.26928788f, 0.01703469f, -0.06141127f, 0.05675783f, 
    -0.20258497f, -0.14532180f, -0.04409631f, 0.16065954f, 0.03108327f, -0.13730992f, 0.28459394f, 0.14045721f, 
    0.20445435f, -0.11744822f, 0.08031923f, 0.08381449f, -0.10499991f, 0.04119541f, 0.03589153f, 0.08466150f, 
    0.10398791f, 0.20588234f, 0.03375478f, -0.14073575f, 0.19418018f, 0.36898306f, -0.17625874f, -0.04857593f, 
    -0.12441160f, -0.08658110f, -0.01384821f, -0.16340838f, -0.01521541f, 0.00829541f, 0.00631005f, -0.06486868f, 
    -0.52716273f, 0.00184897f, 0.10188358f, -0.00879600f, 0.21758643f, -0.38108432f, 0.15689436f, 0.20700292f, 
    -0.13210537f, 0.01068965f, 0.10100719f, -0.10462139f, 0.01573937f, -0.04171287f, -0.03003724f, 0.17525093f, 
    -0.21258245f, 0.23040470f, -0.37216666f, 0.13283421f, 0.02321034f, 0.09010251f, -0.09834355f, 0.07431293f, 
    0.28318763f, 0.23582989f, 0.06990598f, 0.19122684f, -0.06027051f, 0.11402273f, -0.18214481f, 0.06417366f, 
    -0.00785684f, 0.10312599f, 0.15996307f, 0.23877920f, 0.30587396f, 0.16984197f, 0.06833221f, 0.10134782f, 
    -0.06167418f, -0.06439964f, -0.02900723f, -0.06043285f, -0.05390690f, -0.39748800f, -0.21342340f, -0.18612288f, 
    0.00372558f, -0.00902318f, -0.00501862f, -0.15775448f, 0.22900586f, -0.28244764f, 0.22065341f, 0.03690942f, 
    -0.23307863f, 0.11307815f, 0.16367784f, -0.02820565f, -0.02429500f, -0.17091069f, 0.05607429f, -0.12538002f, 
    -0.30464941f, -0.18152656f, 0.02405924f, 0.12674271f, 0.34687695f, -0.17597833f, -0.24417824f, -0.28503507f, 
    -0.30703458f, -0.14593157f, 0.20087007f, 0.11189117f, -0.21355675f, 0.04906481f, -0.03987179f, 0.41170660f, 
    0.20494862f, 0.06533513f, 0.09952644f, 0.47236055f, 0.11982360f, -0.07679208f, -0.27592903f, 0.08457552f, 
    -0.22199215f, 0.06481428f, 0.00001866f, -0.00939545f, 0.12731434f, 0.38610721f, 0.13871506f, -0.08520602f, 
    -0.00854536f, -0.08290754f, 0.16232468f, 0.22298674f, -0.08871952f, 0.09461249f, 0.07252707f, 0.01523651f, 
    0.14380834f, -0.11083000f, -0.01937178f, 0.31598869f, -0.05361696f, -0.04974182f, 0.05042369f, 0.01398318f, 
    -0.12034375f, 0.23720120f, 0.09994997f, -0.08631735f, 0.36221117f, 0.07826253f, 0.12746522f, -0.27538395f, 
    -0.43585694f, -0.03199316f, 0.14905450f, -0.00806873f, -0.01761596f, 0.11128481f, 0.04197394f, 0.23031123f, 
    0.22025609f, 0.02767931f, -0.03989511f, -0.05578941f, 0.19785427f, 0.01590629f, -0.17920138f, -0.15501724f, 
    -0.14937183f, -0.04629794f, 0.25345299f, -0.24243192f, -0.21572706f, -0.01014198f, 0.10485721f, 0.32494164f, 
    -0.08150286f, 0.26717240f, -0.02113061f, -0.26053402f, 0.05162500f, 0.00813180f, 0.13863119f, -0.12115819f, 
    0.17062548f, 0.17868765f, 0.01859380f, -0.22979122f, -0.02191211f, -0.27897879f, -0.01752896f, 0.19603647f, 
    0.19219528f, 0.09103324f, 0.28484863f, 0.24231569f, 0.25984651f, 0.22492810f, -0.07118190f, 0.17525554f, 
    0.00843509f, 0.02945063f, -0.06657853f, 0.17920651f, -0.28362036f, -0.33610925f, 0.05919557f, 0.00139281f, 
    0.12867379f, 0.09044877f, -0.03035062f, -0.05020088f, -0.23336339f, -0.14896351f, 0.14401305f, 0.08707641f, 
    -0.52248925f, 0.05263647f, 0.30469513f, 0.08574823f, 0.07615869f, 0.13174142f, -0.09367327f, -0.35754329f, 
    -0.81523997f, -0.05956025f, -0.12353502f, -0.01795704f, 0.32198557f, 0.30486658f, 0.25180760f, 0.16651548f, 
    -0.31049648f, -0.00863657f, -0.12275277f, -0.03737729f, 0.03437865f, -0.12196869f, -0.03461349f, 0.17737795f, 
    0.07726234f, 0.26100782f, -0.21535958f, -0.05237234f, 0.31490180f, 0.04943067f, -0.03593400f, -0.06744750f, 
    -0.20489426f, -0.01386953f, -0.15274791f, -0.27810523f, -0.00355771f, 0.02015764f, -0.16191107f, -0.18559416f, 
    0.13623026f, 0.10996882f, -0.16332133f, 0.30432671f, 0.12838461f, -0.34347078f, -0.21408163f, -0.05397992f, 
    -0.02067394f, -0.24252157f, -0.02878186f, 0.35770890f, 0.11410429f, -0.15123294f, -0.12318257f, -0.04931731f, 
    0.08519696f, 0.20375729f, -0.06514179f, -0.12197910f, 0.24386983f, 0.12639348f, 0.05809605f, -0.20890841f, 
    0.03481596f, -0.21340413f, -0.04050701f, -0.18704318f, -0.10703016f, -0.07651146f, -0.09464610f, 0.36858895f, 
    -0.15693751f, 0.06980444f, -0.03945880f, -0.00864210f, 0.12516674f, -0.17486157f, -0.11454563f, -0.06458402f, 
    -0.34335420f, -0.06579713f, 0.14974670f, 0.20130011f, -0.04641853f, 0.01841287f, -0.01668328f, 0.07415044f, 
    -0.02760740f, 0.00985730f, 0.03623120f, 0.37018299f, -0.17339924f, -0.06331109f, 0.03160327f, 0.11936706f, 
    0.03062304f, 0.21229492f, 0.09036997f, -0.09422082f, -0.00101255f, 0.24391781f, -0.02262895f, 0.19581030f, 
    0.19960967f, -0.06290711f, 0.50343466f, 0.30661508f, 0.34880310f, 0.18658310f, 0.15583235f, 0.35278609f, 
    -0.32932064f, -0.04379692f, 0.11583602f, -0.14345600f, 0.01929879f, -0.03747255f, -0.40512019f, 0.12210619f, 
    -0.00543147f, 0.19857717f, 0.09585157f, -0.44009915f, -0.04557099f, -0.17394140f, 0.21963058f, 0.13068506f, 
    -0.37676942f, -0.06227462f, 0.38646421f, 0.18019366f, -0.11474317f, -0.10405303f, 0.12364502f, 0.01227933f, 
    0.12613198f, -0.08994133f, 0.13223745f, -0.07001343f, 0.06136866f, 0.08142290f, -0.08506215f, -0.17360899f, 
    0.01983268f, 0.08018946f, 0.20929660f, 0.35719919f, -0.28004044f, -0.08578587f, -0.09932687f, 0.20566782f, 
    0.24157529f, -0.20939568f, 0.21521652f, 0.41884029f, -0.05617160f, -0.02511930f, -0.02884164f, -0.02411115f, 
    0.01437356f, 0.14351714f, -0.04826317f, -0.55092460f, 0.00982850f, 0.28476402f, 0.29008007f, 0.10437540f, 
    -0.06223688f, -0.08552113f, -0.16205108f, 0.13211435f, -0.18304028f, 0.10282319f, 0.27297494f, 0.04392327f, 
    0.07180551f, -0.03521507f, -0.06465365f, 0.00819084f, -0.07541263f, 0.05971060f, 0.06186558f, -0.02472037f, 
    0.09964043f, -0.07649855f, 0.03123528f, -0.06860521f, -0.09749503f, -0.03646667f, -0.03992009f, -0.11795732f, 
    0.00237172f, -0.03047030f, 0.07017360f, 0.05322448f, -0.08339421f, -0.00683957f, 0.08796401f, -0.00354506f, 
    -0.04174418f, 0.01398639f, 0.10984918f, 0.12215927f, 0.02483073f, 0.00398809f, -0.00127176f, -0.14525193f, 
    -0.04560209f, 0.05153318f, -0.06900880f, -0.09839670f, -0.14803571f, 0.11639090f, 0.04718619f, -0.10795974f, 
    -0.15223974f, 0.10142683f, -0.04562267f, -0.03289949f, 0.09863021f, -0.09122506f, -0.06760291f, 0.02035832f, 
    -0.13319422f, -0.11923806f, 0.02660328f, -0.10140327f, -0.09249923f, 0.01894375f, 0.02656849f, -0.10128717f, 
    0.05214585f, 0.07910197f, -0.14114335f, -0.08894521f, -0.15327898f, 0.05244595f, 0.06420926f, -0.04352375f, 
    0.05684128f, 0.04421221f, 0.06229428f, 0.27332100f, 0.11508746f, 0.25130245f, 0.04044365f, 0.02645187f, 
    -0.03132617f, 0.02694727f, -0.12519006f, -0.12681463f, 0.13832824f, -0.05551530f, 0.03866269f, 0.18893175f, 
    -0.05147549f, 0.20999144f, -0.03791784f, 0.23461674f, -0.12561040f, 0.02558066f, 0.08260576f, 0.19337219f, 
    0.16815960f, -0.18072116f, 0.05563924f, 0.08184007f, -0.14056490f, -0.32248291f, -0.41198269f, -0.18055889f, 
    0.30879655f, 0.07524975f, -0.07843685f, 0.14881612f, -0.09181950f, -0.07832728f, 0.08530576f, -0.06595674f, 
    -0.12712818f, -0.41941702f, 0.21613513f, -0.02795836f, -0.37001458f, -0.11886832f, -0.02736602f, 0.01156299f, 
    -0.02107657f, 0.14824535f, 0.07760789f, -0.38726449f, 0.20195189f, -0.01564010f, 0.12872915f, 0.24061492f, 
    0.00201789f, -0.08134919f, 0.07745753f, -0.15260121f, 0.17792346f, 0.14207843f, 0.20746997f, 0.30809870f, 
    0.24481320f, -0.04428748f, -0.08091445f, -0.23146626f, 0.29123312f, -0.03107076f, 0.04319354f, -0.27428576f, 
    0.12021321f, -0.08502174f, -0.10981469f, -0.05451975f, -0.17190436f, 0.01064568f, -0.47688675f, 0.16455980f, 
    0.56568003f, -0.06444579f, -0.06412572f, 0.26477975f, 0.06740847f, -0.13987249f, 0.01611674f, 0.06781616f, 
    -0.10719883f, 0.00725567f, -0.00111878f, 0.10105825f, 0.36980796f, 0.12507159f, 0.05924688f, 0.00436002f, 
    0.16500369f, -0.05434723f, -0.03132370f, 0.04075546f, 0.02316577f, -0.10799696f, 0.08754802f, 0.03659192f, 
    0.10940422f, 0.18786567f, -0.09474082f, 0.18380341f, -0.18869452f, 0.01745087f, 0.26060876f, -0.08078573f, 
    -0.09242690f, -0.09162393f, 0.01319052f, 0.08552147f, 0.11286831f, -0.14345220f, -0.03938859f, 0.11037179f, 
    0.01312495f, -0.00662938f, 0.19802618f, 0.12611774f, -0.25654155f, -0.24525143f, 0.38908127f, 0.15069973f, 
    0.14051884f, 0.01987671f, -0.01739568f, -0.03642395f, -0.04416278f, 0.15629268f, 0.11168163f, -0.09024032f, 
    0.01910196f, 0.04124053f, 0.04386684f, 0.03689131f, -0.06241322f, 0.06723429f, 0.03950566f, 0.39943895f, 
    0.26167622f, -0.12415930f, 0.24723428f, 0.15054555f, 0.00594236f, 0.08136507f, 0.03760565f, -0.33205888f, 
    -0.09736945f, 0.24052130f, 0.05900423f, 0.00598319f, 0.09747225f, 0.19316882f, 0.12605073f, 0.21045452f, 
    0.18212157f, -0.04006898f, -0.19775800f, 0.06981418f, 0.27551442f, 0.10457771f, -0.07697338f, -0.06299163f, 
    0.15277869f, -0.00288061f, 0.02849480f, 0.18935007f, 0.05235490f, 0.01231438f, 0.30606285f, -0.04269906f, 
    -0.28016603f, 0.13426177f, -0.00250503f, 0.34670570f, -0.06870372f, 0.20332365f, 0.11468074f, -0.16399243f, 
    0.06552309f, 0.02062080f, -0.26898080f, -0.02196298f, 0.01300010f, -0.31545255f, 0.03274250f, 0.01706044f, 
    0.02012288f, -0.14116700f, -0.02240421f, -0.14163445f, -0.10268795f, 0.02008962f, -0.20364611f, -0.01985736f, 
    0.08339307f, 0.17193772f, 0.04750246f, -0.06993036f, 0.10174548f, -0.13857010f, -0.14991876f, 0.03132337f, 
    -0.60558856f, 0.03959606f, 0.04439135f, 0.20425586f, 0.04308678f, -0.14004332f, -0.03984413f, -0.12050246f, 
    0.17040713f, -0.10476518f, -0.02208568f, -0.03947130f, 0.11904873f, -0.58054310f, -0.02203276f, -0.05437942f, 
    0.11721698f, -0.04578985f, -0.02922132f, 0.06229119f, -0.05709773f, 0.05617471f, 0.06926414f, -0.01033560f, 
    0.10262162f, 0.25306967f, 0.04986480f, 0.00538554f, 0.19176979f, -0.05149283f, 0.19605385f, 0.11984248f, 
    0.10755771f, 0.10748408f, 0.10821100f, -0.18212047f, 0.05795822f, 0.10849811f, 0.25042099f, 0.03136514f, 
    -0.07955513f, 0.08963574f, -0.05232899f, 0.05870134f, 0.05179441f, 0.22216776f, 0.05269399f, 0.16868889f, 
    0.27750826f, -0.18487702f, -0.11671813f, 0.37573048f, 0.03267825f, -0.23080176f, 0.06130902f, -0.00881945f, 
    -0.14381628f, -0.13768683f, 0.00243406f, -0.03156096f, 0.19341135f, 0.21990927f, -0.24640881f, 0.48792839f, 
    0.11791678f, 0.02851346f, -0.20606454f, 0.31066552f, -0.04687832f, 0.30500504f, -0.05373542f, 0.30439666f, 
    0.12088009f, -0.09534065f, -0.04966820f, 0.06819885f, 0.16513984f, -0.08570693f, -0.13939202f, -0.07827342f, 
    0.00375477f, 0.00191202f, 0.14231214f, -0.12041243f, 0.11556460f, 0.07713911f, 0.26229587f, -0.23103251f, 
    -0.31725389f, 0.09925621f, -0.13895439f, -0.00070766f, -0.29356593f, -0.01098205f, -0.33431882f, 0.00175732f, 
    0.38144872f, -0.01153068f, 0.04088860f, -0.31036186f, -0.17742886f, -0.37278864f, 0.10766142f, 0.22725391f, 
    -0.13011953f, 0.03910590f, 0.22772540f, 0.13798028f, 0.46368530f, -0.00945663f, -0.13286503f, 0.26680866f, 
    0.05996814f, -0.06120457f, -0.05461633f, 0.18292816f, 0.04915757f, 0.04727830f, 0.17676763f, -0.47145510f, 
    -0.04941732f, 0.07201724f, 0.08894925f, -0.11096737f, -0.00721020f, 0.21124317f, -0.02281176f, 0.19620617f, 
    0.44241607f, 0.01414785f, 0.05509370f, 0.10311122f, 0.02629866f, -0.08147199f, 0.04930567f, 0.16739586f, 
    0.30684665f, 0.38598302f, 0.07400286f, -0.01620740f, -0.08635759f, -0.12881804f, 0.20677710f, 0.31686687f, 
    0.02814168f, 0.07579953f, -0.14676361f, -0.07588490f, 0.36777985f, -0.09280647f, 0.19753616f, -0.10135298f, 
    0.11152490f, 0.13170929f, 0.19976635f, -0.00685451f, -0.04618558f, 0.02681896f, 0.48444691f, 0.05934817f, 
    0.00965235f, 0.15926835f, 0.05497115f, -0.24330647f, -0.21366256f, -0.03599582f, -0.12874241f, -0.11921270f, 
    0.11332572f, 0.07850219f, 0.08774398f, 0.04055654f, 0.11066741f, -0.15173365f, 0.14986944f, 0.17306282f, 
    0.23467232f, 0.14748928f, 0.02222717f, -0.00849512f, 0.21139711f, 0.03377574f, 0.16114919f, -0.14355470f, 
    0.02705826f, -0.19072652f, -0.04630812f, -0.14521472f, 0.27582648f, 0.18681951f, -0.39168039f, -0.14784892f, 
    -0.33644351f, 0.15482548f, -0.32320023f, -0.15218042f, -0.07539747f, -0.00440112f, 0.03365858f, 0.43249246f, 
    0.56959218f, 0.20129943f, -0.08649359f, 0.12225404f, -0.42852533f, 0.03447327f, -0.08568717f, -0.12738307f, 
    -0.09269422f, 0.06244551f, 0.08816921f, -0.17976768f, -0.11703157f, 0.07843170f, 0.23349817f, -0.33630165f, 
    -0.16283627f, 0.25903928f, -0.10834652f, -0.61562872f, -0.00541543f, 0.07969061f, -0.04529238f, -0.03589505f, 
    0.13378248f, 0.04218298f, 0.02591538f, -0.57225877f, -0.30842015f, -0.26567218f, -0.40491685f, -0.04762863f, 
    0.15119028f, 0.03367829f, 0.35980058f, 0.05273465f, -0.01039424f, 0.14414357f, -0.02548733f, 0.12296496f, 
    -0.11243251f, -0.11599539f, -0.12401667f, -0.04673736f, -0.05141760f, -0.03545377f, 0.09435076f, -0.07422310f, 
    -0.00955690f, 0.03762397f, -0.03280683f, -0.03956450f, 0.03010960f, 0.08471490f, -0.12278131f, 0.10240825f, 
    -0.13285136f, -0.03999562f, 0.07317631f, 0.03223160f, 0.10593876f, -0.12254499f, -0.07510518f, 0.04328968f, 
    0.05273480f, -0.05599308f, -0.06203845f, -0.01043242f, 0.10958880f, -0.01413132f, 0.08832817f, 0.00913997f, 
    -0.09968291f, -0.08709984f, -0.13097492f, 0.05729098f, -0.10364583f, -0.11603452f, -0.04479874f, 0.04931492f, 
    -0.02604899f, -0.09372535f, 0.10908574f, -0.01595601f, -0.06970049f, -0.05319582f, 0.00006660f, -0.03834222f, 
    -0.02917514f, -0.09360860f, 0.06061110f, -0.03227276f, -0.05046680f, -0.09870835f, 0.04031074f, -0.01083223f, 
    -0.10630670f, 0.11569253f, 0.09433694f, -0.12683386f, -0.10199851f, -0.08684792f, -0.14606015f, -0.11713403f, 
    -0.24519274f, -0.13617164f, 0.01817303f, -0.04788694f, -0.05566417f, -0.15998365f, -0.11607221f, 0.01962075f, 
    0.12254607f, -0.07823218f, 0.08631945f, -0.12801263f, -0.09460762f, -0.30582398f, -0.21776325f, -0.13999404f, 
    -0.00490942f, 0.00676805f, 0.17717427f, 0.26071364f, -0.06192760f, -0.24808568f, 0.04298308f, 0.25290334f, 
    -0.16485627f, -0.14249024f, -0.03513860f, 0.14249507f, 0.08937192f, -0.12996680f, -0.15622731f, -0.39159966f, 
    -0.05812133f, -0.00748324f, 0.10918374f, 0.14978296f, -0.29776692f, -0.05328605f, -0.05105963f, 0.20967625f, 
    0.17129336f, 0.17721130f, 0.22568943f, 0.32460585f, -0.51414770f, 0.10187365f, 0.15386517f, -0.01029878f, 
    0.06823576f, -0.15735768f, -0.00439736f, 0.00509136f, 0.00421760f, 0.11026897f, 0.12302164f, 0.09027063f, 
    -0.31972405f, -0.09031875f, 0.08881832f, 0.03812385f, 0.02267792f, 0.16767380f, -0.09556203f, 0.11714103f, 
    0.18059082f, -0.16266339f, 0.01262894f, 0.14859796f, -0.21386200f, 0.03371710f, 0.04850198f, -0.10057130f, 
    -0.13157248f, 0.07877817f, -0.02409140f, 0.18841577f, 0.15345225f, -0.15354297f, -0.07935735f, 0.25412098f, 
    -0.52898538f, 0.09125038f, -0.03331773f, 0.06344293f, 0.09490165f, 0.14690207f, 0.08393244f, -0.23817340f, 
    -0.07165410f, -0.15528257f, -0.09436367f, -0.10771883f, 0.12050010f, -0.58349419f, -0.12341869f, 0.15022622f, 
    -0.12938498f, -0.06311571f, -0.01424225f, -0.32754046f, 0.16032559f, -0.02469591f, 0.22999015f, 0.38909057f, 
    0.16974765f, 0.44451064f, 0.10280834f, -0.02690651f, 0.10927586f, -0.01657891f, -0.05437152f, 0.11569289f, 
    0.11503051f, 0.12783042f, 0.09148051f, 0.20507307f, -0.00405328f, 0.07176583f, 0.04658578f, 0.01546602f, 
    0.04707142f, 0.08956621f, -0.02982064f, 0.16909739f, 0.24282995f, 0.21116276f, -0.29603621f, -0.08417147f, 
    -0.11938934f, 0.17684720f, 0.12087899f, -0.27077055f, 0.14560746f, 0.09051190f, -0.27684438f, 0.05943222f, 
    0.05611242f, 0.26126802f, -0.06035496f, 0.08461110f, 0.07458047f, -0.22641028f, 0.14759605f, 0.24487390f, 
    -0.36448494f, 0.38532645f, 0.19084008f, 0.36189240f, 0.00762066f, 0.06912161f, 0.12715563f, 0.05398231f, 
    0.63332880f, -0.29252851f, -0.09695920f, 0.05875958f, -0.07351843f, 0.19090754f, -0.16632988f, -0.33503002f, 
    0.39031428f, -0.01443463f, 0.21631230f, 0.00925849f, -0.18044761f, 0.04362387f, 0.03705392f, 0.22282818f, 
    0.08415862f, 0.04976900f, 0.13496251f, 0.01753924f, 0.12528101f, 0.08670560f, -0.06392462f, -0.01743519f, 
    0.10546351f, 0.09829022f, 0.06835005f, -0.30822659f, 0.19857793f, 0.09698740f, 0.14237024f, -0.04984106f, 
    -0.13319558f, -0.14234638f, -0.24087594f, 0.15168884f, -0.15782432f, 0.03824847f, 0.03840276f, 0.16715290f, 
    0.04593088f, 0.14703865f, 0.02837600f, -0.44444570f, -0.07879828f, 0.06299742f, 0.11992570f, -0.41800910f, 
    0.00193567f, -0.03551849f, -0.01777720f, 0.10537126f, 0.00968589f, 0.19167244f, -0.21657401f, -0.06425390f, 
    -0.15363480f, 0.18402256f, -0.26289514f, 0.23268639f, 0.11252464f, 0.14717849f, -0.03145544f, -0.00837092f, 
    0.38788038f, -0.13755462f, 0.03047514f, -0.11716758f, -0.34482843f, 0.16219257f, 0.16671333f, -0.09174959f, 
    0.13816430f, 0.05459889f, 0.11998080f, -0.07352903f, 0.09763915f, 0.02942491f, -0.00168332f, 0.16043955f, 
    0.12200810f, 0.47280037f, -0.06510128f, -0.11220392f, 0.00075881f, -0.08718374f, -0.07544844f, 0.01112078f, 
    0.10121085f, 0.05456769f, -0.06656554f, -0.06519590f, -0.06727161f, -0.18040796f, -0.21869829f, -0.11431205f, 
    0.04572598f, -0.06889348f, -0.18979980f, 0.03697187f, -0.14990813f, 0.04549858f, -0.17842092f, 0.01340523f, 
    0.08223544f, 0.09504358f, 0.04780935f, -0.28872839f, -0.08678140f, 0.22999559f, 0.02236279f, -0.09545628f, 
    -0.04684306f, -0.30836630f, -0.05671442f, 0.30232736f, -0.17166276f, 0.07079555f, -0.14749804f, 0.24476625f, 
    0.07221904f, 0.13279314f, 0.04513356f, 0.09708577f, 0.12038941f, -0.09655030f, 0.05335596f, -0.20852223f, 
    -0.01803076f, 0.07569903f, 0.06874445f, 0.10473375f, -0.07390163f, -0.04434156f, -0.01798714f, 0.05611655f, 
    0.22912546f, -0.08579107f, -0.21507813f, -0.16912170f, 0.21147187f, 0.07746512f, -0.02162871f, 0.04005199f, 
    0.11443537f, 0.10094029f, 0.05166773f, 0.02041981f, 0.14682300f, 0.03412680f, 0.00777082f, 0.08916292f, 
    -0.03117555f, 0.10379127f, -0.03678808f, 0.21642089f, -0.24387689f, -0.03859937f, 0.02552346f, -0.27503619f, 
    0.17499061f, -0.09713954f, -0.27033147f, -0.10211421f, -0.18149397f, -0.20559879f, -0.02018532f, -0.25519869f, 
    -0.10647821f, 0.06833736f, -0.08752899f, 0.05793351f, 0.02054119f, -0.02464226f, 0.04868421f, -0.07935385f, 
    0.05124762f, 0.06137704f, -0.07359551f, -0.08975253f, -0.06143062f, -0.05800870f, -0.02474103f, 0.04268280f, 
    -0.13249685f, 0.00087176f, 0.05740661f, -0.11046796f, -0.09651939f, -0.11041990f, 0.02646931f, -0.10285749f, 
    -0.12204947f, 0.09601940f, 0.08378069f, 0.04370450f, -0.00939732f, -0.04449254f, -0.06680535f, 0.04308319f, 
    -0.01144393f, -0.09750563f, -0.04526392f, -0.16527328f, -0.10982903f, -0.10854974f, -0.06931061f, 0.07875945f, 
    0.01182686f, -0.08815485f, 0.04793509f, -0.03768533f, -0.00307550f, 0.01793820f, -0.02385397f, 0.03216710f, 
    0.10239114f, -0.07295435f, 0.05961688f, -0.11605091f, -0.01604715f, -0.06409450f, -0.14601676f, 0.00294778f, 
    -0.08159076f, 0.00974923f, 0.04129211f, -0.12797774f, -0.03460896f, 0.03996444f, -0.07986119f, -0.09582520f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13004388f, -0.20077428f, -0.03873167f, -0.13874933f, 0.21488740f, 0.15168937f, -0.13600001f, -0.09237616f, 
    0.25131717f, 0.11602933f, 0.04233005f, 0.01228930f, 0.03274706f, 0.07308207f, -0.02749761f, -0.02693381f, 
    0.09954222f, 0.21085913f, -0.15703949f, 0.30493173f, 0.02134598f, 0.10370643f, 0.06014489f, -0.01026377f, 
    0.05576658f, 0.33286166f, -0.02497059f, 0.13231978f, 0.12066466f, 0.02032777f, -0.12249231f, 0.09248550f, 
    -0.00281747f, -0.02655696f, 0.01764969f, -0.06939307f, 0.21118569f, 0.07347459f, 0.04111477f, -0.02528842f, 
    -0.05781228f, -0.07923715f, 0.17371735f, 0.14443626f, -0.04643593f, 0.03150680f, 0.13793698f, 0.09532442f, 
    -0.06540177f, -0.05176324f, -0.17272280f, 0.28107980f, -0.06250254f, -0.17783576f, 0.10192104f, 0.06216461f, 
    0.08117920f, 0.06630885f, -0.10874778f, -0.10276111f, 0.04908131f, 0.10296270f, -0.23362757f, 0.00691387f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.21042833f, 0.11322501f, -0.13785274f, -0.12572557f, 0.09592518f, 0.20591809f, 0.16465271f, 0.40450603f, 
    -0.17555293f, -0.13814914f, -0.30484051f, -0.34704638f, -0.10552731f, -0.02662321f, -0.09739552f, 0.01179089f, 
    0.06331540f, -0.34336862f, -0.00827994f, -0.08545133f, -0.25164446f, 0.13887522f, -0.22892968f, -0.18527584f, 
    -0.07827656f, 0.00306273f, -0.42818484f, 0.14866589f, 0.07111733f, 0.04023467f, -0.04306840f, 0.01154613f, 
    -0.05080786f, 0.02984825f, 0.23813885f, -0.02350475f, 0.04237064f, 0.12233566f, 0.05479672f, 0.11566558f, 
    0.02103556f, -0.06433403f, 0.02576702f, -0.29431382f, -0.12557043f, -0.50772953f, 0.12052687f, -0.15194088f, 
    -0.18443657f, -0.09417952f, -0.14595690f, 0.10334191f, 0.08232572f, -0.32914695f, -0.12610662f, 0.11565202f, 
    -0.37976471f, -0.02810421f, -0.17028089f, -0.01225213f, -0.14151569f, 0.07090108f, 0.18835133f, 0.06319511f, 
    -0.03105657f, -0.82007682f, 0.04284347f, -0.07362632f, -0.09029415f, 0.17665964f, -0.00798380f, -0.17762648f, 
    -0.10802156f, 0.13829032f, -0.70080197f, -0.05274424f, -0.35029343f, -0.09579093f, 0.02509670f, 0.01405501f, 
    -0.05979502f, 0.09887601f, -0.07056978f, -0.03079946f, -0.15949596f, 0.21423285f, 0.20384315f, -0.14297415f, 
    0.20544283f, 0.15585820f, -0.20170523f, 0.05592817f, 0.10766967f, 0.04475322f, -0.13024527f, 0.05669327f, 
    -0.10967463f, -0.08081099f, 0.17017077f, -0.03364187f, -0.17393284f, 0.02448211f, -0.02891120f, 0.13702843f, 
    -0.09527954f, -0.08597130f, 0.33434662f, -0.35626110f, -0.01765261f, -0.11554571f, -0.15161875f, -0.31576192f, 
    0.07649512f, 0.08927660f, -0.08232515f, 0.56460476f, -0.15070596f, 0.07851450f, -0.00622524f, 0.09074301f, 
    0.26476181f, 0.04126612f, 0.18601021f, -0.35427526f, 0.14572461f, 0.25888792f, 0.03424553f, 0.00524135f, 
    0.18895648f, -0.34184808f, -0.04602291f, -0.09997364f, 0.19453800f, -0.46495047f, 0.12898156f, -0.24731705f, 
    -0.06947034f, 0.02241476f, 0.25131699f, -0.04940461f, 0.26179564f, 0.01101835f, 0.07638974f, 0.01746543f, 
    -0.02434990f, -0.07931206f, 0.07512245f, 0.09223298f, 0.25866318f, -0.22164778f, -0.16953400f, 0.15139180f, 
    -0.05671942f, 0.20802693f, 0.08834200f, -0.31311172f, 0.14115576f, 0.33189523f, -0.06326703f, -0.04758248f, 
    0.09426863f, -0.61568385f, -0.27068102f, -0.04259679f, 0.29509023f, -0.42674389f, 0.04498223f, -0.21935788f, 
    -0.06940426f, 0.14025111f, -0.93153250f, -0.18073975f, -0.19173551f, 0.01236087f, -0.14653388f, -0.01936514f, 
    -0.06805431f, 0.00162629f, -0.29104513f, -0.21282719f, 0.04107392f, -0.22700922f, -0.38207319f, 0.21194588f, 
    -0.25006464f, -0.10733367f, -0.17998867f, -0.59457695f, -0.33142793f, -0.72727901f, -0.39765644f, -0.03103735f, 
    0.03630369f, 0.04585326f, 0.08585881f, -0.05986252f, 0.00118413f, 0.08983754f, 0.12640993f, 0.08435784f, 
    0.04706510f, -0.56853557f, -0.08585411f, -0.28382203f, 0.15168759f, 0.16724356f, 0.07136820f, 0.02735964f, 
    -0.70402509f, 0.05968490f, -0.04544491f, 0.02090518f, -0.05812528f, -0.13375852f, -0.26560971f, 0.09157337f, 
    -0.03291032f, -0.01497576f, 0.17879519f, 0.13751090f, 0.01788324f, 0.17669332f, -0.07830966f, 0.04701096f, 
    0.03251144f, -0.19672742f, 0.06689765f, 0.05184005f, 0.11142089f, 0.08424886f, 0.43507171f, 0.14138122f, 
    0.01741563f, -0.02232722f, 0.08679262f, 0.16071326f, -0.07575747f, -0.27773938f, -0.30786118f, -0.10035550f, 
    -0.83739692f, -0.00844632f, -0.25343814f, 0.12822755f, 0.14692751f, -0.05257545f, -0.16853181f, 0.01085673f, 
    -0.28959289f, -0.08628601f, -0.26303512f, 0.02835205f, -0.68449938f, -0.28224501f, 0.01900256f, -0.10148811f, 
    -0.04473108f, 0.01247498f, 0.06918743f, -0.03345418f, 0.03553141f, 0.09853113f, 0.06419114f, -0.27713501f, 
    0.18186353f, 0.03997706f, 0.09219469f, 0.01136174f, 0.08599855f, 0.27790076f, 0.07602581f, -0.10412963f, 
    0.00842034f, -0.32158110f, -0.07236452f, 0.10406010f, 0.02430446f, -0.12047636f, -0.18188444f, -0.11527910f, 
    -0.50818247f, -0.13495374f, 0.15916272f, 0.16936111f, -0.00589562f, -0.14347956f, -0.14320278f, -0.07880405f, 
    -0.06762226f, 0.09383585f, -0.04880993f, -0.15346360f, -0.11926705f, 0.20914441f, 0.09765378f, 0.02130391f, 
    0.02633002f, -0.35466057f, 0.01082347f, -0.00668858f, -0.20527588f, -0.08163809f, -0.77443230f, -0.61309123f, 
    0.02048868f, -0.07399482f, -0.00629111f, -0.44086149f, 0.02214126f, 0.16139418f, -0.20754053f, -0.11152789f, 
    -0.40681195f, 0.07112318f, -0.33435193f, 0.26241434f, 0.22343139f, 0.09841952f, 0.08187360f, -0.02707115f, 
    -0.35268512f, -0.28250360f, -0.18320261f, -0.00305463f, 0.15283792f, 0.01175927f, -0.45521778f, -0.24673313f, 
    0.02778722f, -0.11240406f, 0.12195499f, 0.23981614f, -0.02378750f, 0.01981449f, 0.16385548f, 0.03670492f, 
    0.03815754f, -0.04833310f, -0.11181723f, 0.05377537f, 0.08129686f, 0.12454873f, -0.07575903f, 0.09518286f, 
    -0.41759816f, 0.05630752f, -0.57405746f, 0.10566778f, 0.01221521f, 0.05995202f, -0.08300687f, 0.19102585f, 
    0.04049536f, 0.03684367f, 0.11476405f, 0.02159950f, -0.03068239f, 0.00256317f, -0.20050044f, 0.16576929f, 
    -0.06374229f, -0.30540714f, 0.00507037f, -0.12686180f, -0.30288327f, -0.05145355f, 0.28550780f, 0.07618999f, 
    -0.21159136f, -0.04398688f, 0.13919197f, -0.27897787f, -0.06362930f, 0.07312498f, -0.02596980f, 0.18052122f, 
    0.18612899f, 0.09385279f, -0.62260467f, 0.05546020f, 0.15613501f, -0.09019949f, -0.17994139f, -0.00144838f, 
    0.00313018f, -0.30665189f, -0.10597874f, 0.01547492f, -0.80627936f, -0.58305186f, -0.07795808f, -0.15860412f, 
    -0.83171695f, -0.59486061f, 0.04009288f, -0.10571083f, 0.22361135f, -0.48995134f, -0.21680681f, 0.05551616f, 
    -0.29236057f, -0.06608368f, -0.02030907f, 0.04081967f, 0.19149666f, -0.05906888f, -0.04512350f, -0.07499425f, 
    0.31878361f, -0.20204067f, 0.31216392f, -0.09083141f, -0.58234406f, -0.73323673f, 0.00030478f, -0.43560514f, 
    -0.03444772f, -0.03388951f, 0.04336192f, -0.02124264f, 0.14589831f, -0.56710064f, -0.06852555f, -0.33145028f, 
    0.04791937f, 0.17711402f, -0.15455426f, -0.15983421f, 0.30441394f, 0.01082439f, -0.05155143f, 0.18898875f, 
    0.21966830f, 0.08746792f, -0.05842935f, -0.09755657f, -0.27319688f, 0.03776280f, -0.60825139f, -0.89583421f, 
    -0.25769034f, -0.11754406f, 0.29274946f, -0.36588314f, 0.15304747f, -0.66908556f, -0.13039432f, 0.01723558f, 
    -0.13635908f, 0.63903844f, -0.04211498f, 0.07685949f, -0.84687674f, -0.33404082f, 0.07000913f, -0.20847572f, 
    -0.01254646f, 0.26365414f, 0.29196510f, 0.08748439f, 0.31669807f, -0.62543476f, 0.01902981f, -0.09805451f, 
    0.04859996f, -0.03607362f, -0.00000897f, -0.44704622f, -0.40299958f, 0.08761285f, 0.21833888f, -0.09773276f, 
    -0.44215795f, -0.12398600f, 0.18626931f, -0.02968677f, 0.08347382f, -0.39036375f, 0.04599105f, -0.02867864f, 
    0.06975272f, 0.21036509f, -0.38286886f, 0.04046227f, -0.73354566f, -0.28803173f, -0.00977343f, 0.11747405f, 
    0.02014360f, 0.02311441f, 0.00443353f, -0.13144889f, 0.10692579f, 0.03830412f, 0.15268908f, -0.07778288f, 
    0.01696435f, 0.06510223f, -0.01257769f, -0.27572978f, 0.14435969f, -0.19537117f, 0.30265829f, -0.22899659f, 
    -0.30968764f, 0.00956048f, -0.08063824f, 0.47139260f, 0.11826134f, -0.70932209f, -0.07064410f, -0.03443512f, 
    -0.03769683f, -0.30000442f, 0.09954618f, -0.12938797f, 0.07196610f, -0.71833795f, -0.10102118f, -0.06426147f, 
    0.11425450f, -0.11221998f, -0.20966406f, 0.25974455f, -0.31498972f, -0.54688460f, 0.37544671f, -0.13777196f, 
    -0.20210926f, 0.24203533f, -0.04549834f, -0.02485028f, 0.17129382f, -0.05319523f, 0.07996564f, -0.08920334f, 
    -0.14769961f, 0.28252971f, -0.31851345f, -0.48780701f, 0.09886494f, -0.09199082f, -0.09170829f, 0.07283244f, 
    0.08271599f, -0.06974772f, -0.67043650f, -0.05923630f, 0.00680516f, -0.62020594f, -0.19152386f, 0.08568081f, 
    -0.07369790f, 0.03715578f, -0.03074507f, 0.21575545f, -0.50984675f, 0.20455727f, 0.05974262f, 0.08322728f, 
    -0.37148076f, -0.09644346f, 0.26136327f, -0.07791282f, -0.85506982f, -0.14080186f, 0.35564491f, -0.28566301f, 
    0.17613825f, -0.03194002f, -0.37975618f, -0.32616058f, -0.28918076f, -0.32274827f, -0.40683067f, 0.00191515f, 
    -0.42021775f, -0.39751187f, -0.22581716f, 0.06029691f, 0.21942893f, 0.26991042f, -0.13294153f, -0.11552093f, 
    -0.31950390f, 0.16860954f, 0.13260527f, 0.03802068f, 0.04467462f, 0.16370603f, -0.36653164f, -0.00830790f, 
    0.10021935f, -0.02776779f, 0.10562349f, 0.06211458f, 0.13787147f, -0.08766782f, 0.00600951f, 0.03052210f, 
    0.15540259f, -0.29445553f, 0.10611517f, -0.46951726f, -0.59196234f, 0.04843486f, 0.02113201f, -0.31839484f, 
    0.11797393f, 0.19871673f, -0.40883413f, -0.06278872f, 0.12799045f, 0.21575363f, -0.03004747f, -0.31049562f, 
    -0.05379564f, -0.04200268f, 0.25117534f, 0.20625238f, 0.14559647f, 0.20116037f, 0.33643994f, -0.04892645f, 
    -0.01091110f, -0.01021056f, -0.39160216f, 0.07964511f, -0.09867600f, 0.00674751f, -0.59664226f, -0.28007442f, 
    -0.17090201f, -0.08216479f, -0.69633967f, 0.04573752f, 0.03675890f, -0.13085733f, -0.54894143f, 0.01514213f, 
    0.13111603f, -0.55391937f, 0.01612236f, 0.01858386f, -0.15921386f, 0.13647044f, 0.11792690f, -0.14498793f, 
    0.22702615f, 0.22535670f, 0.24406278f, -0.19824748f, -0.14272106f, -0.25808415f, -0.30826640f, -0.09635101f, 
    0.00740138f, 0.03501267f, -0.08783207f, -0.17139089f, 0.21993399f, -0.01075856f, 0.12150898f, -0.26800576f, 
    -0.26000556f, 0.22566172f, -0.05486367f, 0.37575015f, 0.14528003f, -0.41142979f, 0.06361149f, -0.20286375f, 
    0.00686133f, 0.28215641f, -0.41965368f, 0.12042337f, -0.08797900f, 0.07169775f, -0.10836516f, -0.49519452f, 
    -0.07835524f, -0.39139768f, -0.42767864f, 0.26036343f, -0.12078059f, 0.15584108f, 0.15954964f, 0.04295406f, 
    -0.51181030f, -0.07500605f, -0.27715045f, -0.37680584f, -0.39047241f, -0.12340970f, 0.18937707f, -0.07949702f, 
    0.22536828f, -0.06706664f, -0.07467825f, 0.22848271f, -0.63648415f, 0.16410670f, -0.46022964f, -0.10543541f, 
    0.43593419f, -0.67900038f, -0.13678719f, -0.06875064f, -0.25592348f, -0.35216442f, -0.13638434f, -0.12438972f, 
    -0.08302738f, -0.11885256f, -0.08876855f, 0.04739686f, -0.16477706f, -0.17119487f, -0.31269038f, -0.06801639f, 
    -0.32417151f, 0.13994847f, -0.14100286f, -0.09719355f, -0.05223250f, -0.67286879f, 0.10918509f, 0.15040243f, 
    0.17419332f, -0.27931985f, 0.07999358f, -0.28226927f, 0.03274987f, 0.25738055f, 0.06142883f, -0.14085795f, 
    -0.10120602f, -0.03987966f, -0.22992365f, -0.14846803f, -0.09617740f, -0.00732661f, -0.38452762f, 0.10926238f, 
    -0.08043983f, 0.04008317f, 0.17648984f, 0.11873601f, 0.00843716f, 0.06930366f, -0.47943208f, 0.05680330f, 
    0.09553079f, -0.04062464f, 0.11078253f, 0.12950854f, -0.22267039f, 0.35061699f, 0.12297232f, 0.11169709f, 
    -0.54037315f, 0.07539109f, 0.13818967f, 0.00555447f, -0.03351292f, -0.52092600f, -0.45758599f, -0.00199018f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.34700218f, 0.16375625f, 0.19628477f, 0.00542913f, -0.05597709f, 0.07909422f, -0.01099950f, -0.22119078f, 
    0.15028220f, 0.06442493f, -0.09192379f, -0.02081947f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
