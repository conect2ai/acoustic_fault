#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.14529777f, -1.25326478f, -0.28045306f, 0.91811317f, 0.89258611f, 0.08135886f, 0.21950667f, 0.07840896f, 
    0.01916593f, -0.96272486f, -0.17713851f, -0.26083681f, 0.83357215f, -0.82347620f, -0.34782860f, -0.03055230f, 
    -0.23206067f, -0.64435583f, -0.39776376f, 1.05649757f, -0.45866564f, -0.34851566f, -0.52173364f, 0.57652658f, 
    0.43118739f, -0.13790540f, 0.01761407f, -0.14564876f, -0.37619546f, 0.68413520f, -0.72009128f, 0.18780556f, 
    0.49080697f, 0.21559566f, -0.60001248f, 0.51270819f, 0.69104123f, 0.75324708f, 0.22699903f, -0.25822237f, 
    -0.01561153f, -0.46718892f, -0.03587567f, -0.32339510f, -0.39584664f, 0.51934409f, -0.55191714f, -0.13769212f, 
    0.35010779f, 0.20026934f, 0.38235998f, -0.36136115f, -0.04578049f, 0.31802741f, -0.85801554f, -0.54232067f, 
    -0.44204602f, -0.15121478f, 0.48866507f, -0.02688629f, 0.44486520f, 0.46482494f, 0.51458842f, -0.92928362f, 
    -0.44564387f, 0.25374588f, -0.51564914f, 0.72455013f, -0.24728897f, 0.68082356f, -0.58014041f, -0.10869998f, 
    0.26115394f, -0.25430304f, 0.29118112f, 0.46049780f, -0.66705298f, 0.23824556f, 0.37106776f, -0.39431682f, 
    0.13334164f, -0.88010466f, 0.67038989f, 0.26851073f, -0.74944711f, 0.52128339f, 0.21226604f, -0.16087180f, 
    -0.12210282f, 0.21717954f, 0.96960181f, -0.44888145f, -0.41099116f, 0.37549561f, 0.19988464f, -0.75979239f, 
    0.84502649f, -0.58888620f, -0.34515354f, -0.62850153f, -0.40753663f, -0.85248691f, 0.67024297f, -0.25243339f, 
    0.35135221f, -0.33647177f, 0.37804163f, 0.13153781f, 0.78516126f, -0.30507490f, -0.73871022f, -0.19081223f, 
    -0.17586651f, 0.58219105f, 0.02336322f, -0.19462226f, 0.33228481f, 1.51084208f, -0.91267067f, -0.84480971f, 
    0.26317349f, 0.22274174f, -0.48654032f, 0.14123984f, 0.39985821f, -0.32740706f, -0.08025400f, 0.34846643f, 
    0.77220994f, -0.35897881f, -0.93016845f, -0.89925063f, 0.15506618f, -0.02421071f, 0.17714892f, 0.22884864f, 
    -0.67131925f, -0.80272341f, -0.34769270f, -0.53120875f, -0.59532666f, 0.51324755f, 0.03313474f, 0.27294314f, 
    0.27267328f, 0.38412210f, 0.86526960f, -0.61558419f, -0.74520898f, -0.23824503f, 0.79643387f, -0.78744739f, 
    -0.44778460f, -1.15391088f, -0.47340426f, -0.61122996f, 0.38971600f, 0.11748756f, 0.22141260f, -0.55937630f, 
    -0.62439311f, -0.26497456f, -0.57302666f, 0.17160878f, 0.41762456f, 0.16935804f, -0.54062808f, -0.05942338f, 
    0.41795170f, -0.82306594f, 0.54588091f, -0.92646468f, 0.85002559f, -0.39822870f, -0.47679949f, 1.00791168f, 
    -0.11951774f, -0.02232832f, -0.39559096f, -0.45703968f, -0.72064209f, -0.33439460f, -0.00592690f, -0.66968417f, 
    -0.95600557f, -0.85774225f, 0.49845785f, 0.41993341f, 0.07806358f, 1.18871355f, -0.34741998f, -0.66693598f, 
    0.77072263f, 0.59104472f, -0.14165734f, -0.69106358f, 0.90105933f, -0.46037623f, -0.41104534f, -0.77141201f, 
    0.26404089f, -0.76100481f, -0.46279439f, -0.47509235f, -0.27750638f, -0.47464046f, -0.11444616f, 0.47594377f, 
    -0.42188987f, -0.36938715f, 0.49018249f, 0.64670658f, 0.08856475f, -0.64665878f, -0.68521124f, 0.40021536f, 
    0.59620422f, -0.02384470f, 0.29441783f, -0.69779015f, -0.43232858f, 0.26903656f, 0.38155738f, 0.49406677f, 
    -0.31418782f, 0.42122221f, -1.23092437f, 0.87868351f, 0.47955260f, -0.34859243f, -0.65575290f, -0.44688764f, 
    -0.03448838f, -0.66653222f, -0.75726813f, -0.39796373f, -0.72904307f, 0.61788529f, -0.36225772f, -0.47813469f, 
    -0.25415859f, -0.49478966f, -0.31430855f, 0.32925984f, 0.06026747f, 0.13984744f, 0.26867327f, 0.20309190f, 
    -0.14737822f, 0.07091272f, 0.51767844f, 0.00236851f, -0.64506149f, 0.60720325f, -0.81737053f, -0.46244413f, 
    -0.18141505f, -0.40865684f, -0.47662231f, -0.07407074f, -0.62984902f, 0.53076893f, 0.04795389f, 0.30425966f, 
    0.08361416f, 0.38542676f, -0.11450242f, 0.16566919f, -0.05326309f, 0.03492550f, -0.46066344f, -0.19999333f, 
    -0.15484008f, 0.95378053f, -0.79784715f, -0.52320731f, -0.11270952f, -0.07720646f, 0.50309700f, -0.55790228f, 
    -0.96633387f, 0.47045818f, -0.06408697f, -0.10379420f, -0.35816735f, -0.44425118f, -0.56948793f, -0.48911655f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26752889f, -0.29552540f, -0.04949293f, 0.25509387f, 0.35399067f, 0.22951105f, -0.09017995f, 0.01053048f, 
    0.19261461f, 0.26008558f, 0.17630750f, 0.40006179f, 0.03984866f, 0.42345271f, 0.04870662f, -0.01063446f, 
    -0.06042863f, -0.02791513f, 0.30719998f, 0.11511089f, -0.03624735f, 0.02635041f, -0.09897844f, 0.24379495f, 
    -0.00163447f, -0.07011285f, 0.17344512f, -0.26038298f, 0.16651000f, -0.02172201f, 0.19894907f, -0.13124466f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34457919f, 0.22180176f, 0.38953745f, -0.00799588f, 0.36035833f, 0.02103041f, -0.09675821f, 0.00744864f, 
    -0.10592925f, 0.14536709f, -0.20927462f, 0.11622138f, -0.07311403f, 0.06923740f, 0.08074803f, -0.05490861f, 
    0.01004321f, 0.04335425f, -0.04014060f, 0.00435334f, -0.24064285f, -0.38419157f, -0.00507700f, 0.05362046f, 
    -0.02670589f, -0.06806917f, 0.04368612f, 0.06487439f, -0.08025821f, -0.10603706f, -0.09172172f, 0.00172742f, 
    -0.14209856f, 0.21888384f, -0.08959932f, 0.14212611f, 0.11555172f, 0.12645787f, 0.04810492f, 0.28491038f, 
    0.00242740f, 0.26911068f, -0.37699130f, -0.13911812f, 0.00639335f, -0.01794556f, 0.00373238f, -0.02606601f, 
    0.05873865f, 0.19169843f, 0.03783922f, -0.06417597f, 0.21829939f, -0.14605801f, -0.00469038f, 0.02344046f, 
    -0.01576656f, 0.03066673f, -0.17893070f, -0.09310590f, -0.01845155f, -0.35392040f, 0.02541213f, -0.02345873f, 
    -0.01617938f, 0.21790707f, -0.16641438f, -0.21670620f, 0.06456950f, 0.16675986f, -0.00136890f, 0.12443577f, 
    0.13964251f, 0.06831906f, 0.04623834f, -0.01779093f, 0.05654518f, -0.28145182f, 0.01726882f, 0.07462468f, 
    0.06923204f, 0.02287312f, -0.05463040f, 0.25508127f, 0.38664371f, 0.15330234f, -0.03017746f, 0.01641982f, 
    0.04172433f, 0.03891091f, 0.09780561f, -0.07994268f, -0.14061436f, -0.05936820f, 0.00497273f, 0.01066002f, 
    0.13878368f, 0.08472557f, 0.05099915f, 0.13706531f, -0.43589056f, 0.14602296f, -0.07921050f, -0.33169669f, 
    -0.00336359f, 0.05351852f, -0.11182117f, -0.18508588f, 0.00785206f, 0.15131450f, -0.00294468f, 0.09332410f, 
    0.04464241f, 0.08684178f, 0.05884437f, -0.12081496f, -0.19031206f, 0.02183319f, -0.02037401f, 0.01312025f, 
    0.03803253f, 0.38247684f, 0.32332319f, -0.00002093f, 0.30172491f, -0.01388397f, -0.23459329f, -0.02734236f, 
    0.04295146f, 0.11501679f, 0.05419138f, 0.04647924f, -0.00625363f, 0.00981981f, 0.04668262f, 0.08121117f, 
    -0.05166959f, -0.08278090f, -0.24310771f, -0.13018164f, -0.19070224f, 0.06251579f, 0.18790297f, 0.17953296f, 
    0.12551917f, 0.04246602f, 0.08168047f, 0.06779007f, -0.18047576f, -0.06407615f, -0.03238764f, 0.06430645f, 
    -0.14823313f, 0.09386710f, 0.12463764f, -0.07783625f, 0.13113946f, -0.12084951f, 0.08371339f, 0.03787292f, 
    -0.11826503f, -0.07852510f, -0.11270634f, 0.02926054f, -0.14250799f, 0.16322500f, -0.02177950f, -0.00964328f, 
    -0.18473144f, 0.09630821f, -0.08642751f, -0.07442094f, 0.11395422f, -0.07826620f, 0.05168197f, 0.18540475f, 
    -0.03455032f, -0.01448140f, -0.14933161f, -0.09824168f, -0.18468800f, -0.03896032f, 0.07125623f, -0.00216119f, 
    0.00713806f, 0.17055306f, -0.09399945f, -0.03624598f, 0.06229138f, 0.15499516f, 0.02786056f, -0.06291503f, 
    0.06770309f, 0.04163640f, 0.09060606f, 0.08828116f, 0.01885708f, 0.08997394f, 0.00270608f, -0.05652932f, 
    -0.22699367f, 0.31833467f, -0.12087373f, -0.11430059f, -0.01130389f, 0.13787599f, 0.04821005f, -0.05265040f, 
    -0.00173151f, -0.15551430f, -0.04217313f, 0.00207697f, -0.16213576f, 0.11987595f, 0.04767217f, -0.00770460f, 
    0.20236911f, -0.09062383f, 0.18007141f, 0.18387358f, -0.09616607f, 0.14478303f, 0.35470602f, 0.25474623f, 
    0.25650343f, 0.11840253f, 0.00099548f, 0.04075723f, -0.08490666f, 0.03797912f, 0.07662773f, 0.02277112f, 
    -0.06883256f, 0.06118281f, 0.09122965f, 0.03741566f, -0.06498719f, 0.06024882f, -0.10905195f, -0.01493100f, 
    -0.12994388f, 0.11162473f, -0.05158093f, -0.21720885f, 0.33795190f, -0.13470112f, -0.01218665f, -0.08693221f, 
    -0.08300640f, 0.17921020f, -0.04777705f, -0.04518343f, 0.16892597f, -0.07656579f, -0.04145475f, 0.14661784f, 
    0.06815946f, -0.19323480f, -0.02648446f, -0.00664819f, -0.25849426f, 0.19682063f, 0.08547198f, -0.12211610f, 
    0.09962168f, 0.07452502f, 0.14673690f, 0.08614882f, -0.13166071f, -0.17239575f, -0.03909704f, -0.15804330f, 
    0.02121622f, 0.03554566f, -0.09480543f, 0.04823121f, -0.00819763f, -0.07502355f, 0.06619886f, -0.10500173f, 
    -0.13252969f, 0.00745583f, 0.04029192f, 0.11600550f, 0.46984136f, 0.03759491f, 0.19666788f, 0.05103692f, 
    0.03465624f, 0.06597368f, 0.04002743f, -0.07001429f, -0.12288585f, -0.15058418f, -0.08678543f, -0.20194247f, 
    -0.02871249f, 0.19120236f, -0.07399937f, -0.06063998f, 0.17988817f, -0.02434513f, 0.29064950f, -0.03823704f, 
    0.09400465f, 0.09104405f, 0.22966860f, -0.06901687f, -0.05566123f, -0.05783896f, -0.00813677f, -0.01149496f, 
    -0.01321652f, 0.00644641f, -0.00794204f, 0.01042138f, -0.00774313f, -0.18490081f, 0.07286693f, 0.00813442f, 
    0.00356521f, -0.06965787f, -0.03983563f, 0.29127517f, -0.00661401f, 0.18072061f, -0.00955912f, 0.00138084f, 
    0.04912907f, 0.19442154f, 0.02581283f, -0.01886883f, -0.08902898f, -0.08086293f, 0.04017106f, -0.01359147f, 
    0.15175518f, 0.12967367f, 0.05942299f, 0.22762389f, -0.25568074f, -0.17073672f, -0.15433435f, -0.02167390f, 
    0.12759696f, -0.02953073f, 0.00872205f, 0.01126810f, -0.02934556f, 0.12476949f, -0.12028217f, -0.00145120f, 
    0.00665356f, 0.19280457f, 0.00411213f, -0.23081915f, 0.04553401f, 0.12875263f, -0.00956324f, 0.06464108f, 
    0.23581171f, 0.02951641f, 0.20518202f, 0.08678285f, -0.02173325f, 0.09901876f, 0.12268619f, -0.10566237f, 
    0.06956484f, 0.09920608f, 0.13788706f, -0.10372107f, -0.06812447f, 0.02690486f, 0.00329686f, 0.03060366f, 
    -0.13595793f, -0.10227925f, 0.05779331f, -0.04262424f, 0.24892157f, 0.33453658f, -0.15713289f, -0.01782135f, 
    -0.04135569f, 0.08913517f, -0.09753875f, 0.03294648f, 0.18721473f, -0.03411881f, -0.13037165f, -0.01059490f, 
    -0.00956289f, -0.02561073f, 0.00253380f, 0.04500803f, 0.04405395f, 0.24519043f, -0.00102615f, 0.04371937f, 
    0.16547264f, -0.02932956f, 0.21974215f, -0.04897442f, 0.04272634f, 0.13907686f, 0.14637735f, 0.07990956f, 
    -0.14216010f, -0.06683565f, 0.13092391f, 0.02046671f, -0.05502820f, -0.04947204f, -0.01589575f, -0.03484473f, 
    -0.06956176f, -0.11498109f, 0.11669763f, 0.00982461f, -0.85792464f, 0.23408307f, -0.09494459f, -0.28267956f, 
    -0.16891377f, 0.06289454f, 0.00263378f, -0.04039787f, -0.28171316f, -0.06776446f, 0.25534987f, -0.09339783f, 
    0.13874424f, -0.02278948f, -0.06187017f, 0.01535411f, -0.12718771f, 0.03531428f, -0.13743290f, -0.08553178f, 
    -0.13370435f, -0.11417133f, 0.13539752f, 0.06429632f, -0.04683618f, -0.04893870f, 0.22127835f, 0.03414849f, 
    -0.04597418f, 0.04158719f, 0.02193728f, -0.00222233f, -0.06745118f, 0.07757756f, 0.06942373f, 0.01220809f, 
    0.01528681f, -0.06983527f, 0.07344436f, 0.20789975f, -0.30588081f, 0.27570930f, -0.24377735f, -0.50702542f, 
    -0.10987961f, 0.03810514f, -0.01357953f, -0.22381149f, -0.13775410f, 0.19442193f, -0.08112834f, 0.10749302f, 
    0.00846306f, 0.01151977f, 0.15953492f, -0.27823201f, -0.05716744f, 0.11428408f, 0.13825603f, 0.13402513f, 
    -0.20743729f, -0.09484708f, -0.17443448f, -0.08973891f, 0.00656636f, 0.12783678f, -0.01661793f, -0.04191423f, 
    -0.28724265f, 0.10169991f, 0.07531419f, 0.08835276f, -0.07315063f, -0.05001567f, 0.07441343f, -0.10539786f, 
    -0.12858447f, -0.01441279f, -0.16926993f, -0.07790985f, -0.15598002f, 0.27234372f, 0.23407422f, 0.24462862f, 
    -0.16648956f, -0.06942802f, 0.19705611f, 0.14719081f, -0.10604404f, 0.09948853f, -0.11732853f, -0.02112953f, 
    -0.08627799f, -0.09065972f, -0.08671332f, 0.01205760f, 0.18695952f, 0.30743852f, 0.20375857f, 0.32222387f, 
    -0.24311262f, -0.17145292f, 0.03568946f, 0.06080290f, 0.13840644f, -0.00936285f, 0.03718552f, -0.02508593f, 
    -0.09853846f, -0.04543165f, -0.07520615f, -0.01702711f, -0.03175596f, 0.18451841f, 0.03722143f, 0.05648830f, 
    0.03438791f, 0.08128010f, 0.08292294f, 0.07444712f, -0.01335963f, -0.22878948f, -0.38048232f, -0.13802437f, 
    0.13846490f, 0.12207285f, 0.07037081f, -0.02114203f, -0.15394184f, 0.13592616f, 0.09362644f, 0.05701199f, 
    0.16314004f, 0.15876763f, 0.11460779f, 0.34589994f, -0.04848285f, -0.12496175f, -0.23953083f, -0.13429360f, 
    0.16289645f, -0.08634897f, 0.05629368f, 0.10202063f, 0.20597008f, -0.05171983f, -0.09891862f, 0.11924140f, 
    0.20720638f, 0.07295873f, -0.00183281f, -0.01417581f, 0.08758702f, -0.01612286f, -0.03769533f, 0.20462312f, 
    0.13750361f, 0.09576065f, 0.08635721f, 0.18547282f, -0.18325534f, -0.29384223f, -0.31628811f, -0.14192836f, 
    0.08095648f, 0.21248740f, -0.06080111f, -0.00196791f, -0.10768892f, 0.09029447f, 0.01911592f, -0.07208449f, 
    -0.04574409f, -0.00070212f, 0.09889770f, 0.04432299f, 0.14524068f, -0.01357191f, -0.04985728f, -0.02306315f, 
    0.06914983f, 0.13380821f, 0.11932358f, -0.09241865f, -0.00865520f, 0.19882177f, -0.10153662f, -0.03120055f, 
    0.07375821f, 0.02975136f, 0.07099222f, 0.03281379f, -0.19776465f, 0.11056797f, 0.05290947f, -0.01822735f, 
    -0.18546225f, 0.06092829f, -0.07307844f, -0.03541176f, -0.16340174f, -0.05109083f, 0.04030944f, -0.00683787f, 
    -0.12850480f, -0.08555551f, 0.13417688f, 0.14392771f, -0.12641965f, 0.09051122f, -0.07989778f, 0.06823994f, 
    -0.08558670f, -0.03692867f, 0.06852164f, 0.16956200f, 0.14481618f, 0.20146279f, -0.03090524f, 0.18105344f, 
    0.71041477f, 0.07305063f, 0.24652585f, 0.06282200f, 0.39058551f, 0.08068794f, -0.10589072f, -0.04676539f, 
    0.17103058f, -0.09279980f, -0.15526049f, 0.02667705f, 0.00429710f, -0.05990927f, 0.12681581f, 0.08513036f, 
    0.01063756f, -0.07750835f, 0.01725831f, 0.02437782f, 0.32665426f, 0.13967665f, -0.22106524f, -0.13871934f, 
    0.03793059f, 0.07432315f, 0.26240304f, -0.05980094f, 0.09418403f, 0.05365748f, -0.05726116f, 0.00372037f, 
    -0.06687376f, -0.06902948f, 0.06200221f, -0.01762092f, 0.02065544f, 0.14277555f, -0.03343273f, 0.22702129f, 
    -0.13090985f, 0.22313415f, -0.17674835f, 0.08525340f, -0.27867085f, -0.04933431f, 0.14042677f, 0.44340616f, 
    -0.36831683f, -0.29963034f, -0.01732401f, 0.05212134f, -0.09366021f, 0.14970453f, 0.07452442f, -0.18049674f, 
    0.06390084f, 0.10899348f, -0.10841821f, -0.04939903f, -0.07556503f, 0.00869288f, 0.01080087f, -0.04313221f, 
    -0.14214031f, -0.05092238f, -0.05645899f, 0.06234914f, 0.03407152f, -0.27649245f, -0.01693305f, -0.01502929f, 
    0.01483430f, 0.10973243f, -0.07910513f, -0.07088757f, -0.09793257f, 0.01029672f, 0.11650072f, 0.03940980f, 
    -0.70863444f, -0.00543637f, 0.25644031f, 0.11992881f, 0.19520260f, -0.01649067f, -0.06356253f, -0.11887402f, 
    -0.09924981f, 0.10377094f, -0.05847924f, -0.06005520f, -0.05572191f, 0.05963631f, -0.02294085f, 0.17821389f, 
    -0.03101868f, 0.02086406f, 0.01086036f, 0.03225101f, -0.01093629f, 0.22307356f, 0.12974784f, 0.15913500f, 
    0.01956280f, -0.02079012f, -0.17597042f, -0.07699525f, -0.01241798f, -0.11504310f, 0.12211253f, -0.02340766f, 
    0.01158551f, 0.15365686f, -0.06618141f, -0.14438400f, 0.11015046f, -0.00319514f, 0.12603994f, -0.13924475f, 
    0.53755289f, -0.14408058f, 0.01863828f, -0.29493377f, 0.17843103f, 0.11330232f, -0.08407213f, 0.04549398f, 
    0.18474893f, -0.09852394f, -0.04200427f, -0.03437632f, -0.03582207f, -0.08333828f, 0.05109211f, 0.09868176f, 
    -0.01219787f, -0.15042877f, 0.32847923f, 0.15673412f, 0.31792885f, 0.08860561f, 0.21561165f, -0.08155403f, 
    0.11399997f, 0.06562508f, 0.05009301f, -0.14621653f, 0.28554124f, 0.06931752f, -0.12900160f, 0.01333881f, 
    -0.01718044f, 0.03468493f, 0.05272222f, 0.08747893f, -0.08448142f, -0.05861352f, -0.05084397f, 0.14699249f, 
    -0.18924998f, -0.15671678f, -0.00142405f, 0.06497294f, 0.10549623f, 0.00222371f, -0.07563151f, -0.11903642f, 
    0.07727785f, -0.27422434f, 0.01549377f, 0.14153324f, -0.12503694f, 0.03994857f, 0.06400194f, 0.08322649f, 
    0.03254526f, 0.11733501f, 0.04210220f, 0.05989325f, 0.29965612f, 0.11599626f, 0.21289721f, 0.00947203f, 
    -0.31832653f, -0.16325432f, 0.00569462f, -0.00005342f, -0.11258686f, -0.12152021f, -0.01280851f, 0.00791568f, 
    -0.06382594f, 0.02183289f, -0.00653047f, -0.08365645f, 0.01328402f, -0.11762121f, 0.10471627f, -0.06119814f, 
    0.13790664f, -0.11930224f, 0.38896894f, 0.29511848f, 0.16558881f, -0.09499208f, -0.05795846f, -0.06774884f, 
    0.10797439f, 0.27806410f, -0.08253267f, 0.09724370f, -0.13977197f, -0.13132317f, -0.02779114f, 0.01587544f, 
    0.05339185f, 0.09030411f, 0.06359278f, 0.21205826f, 0.50244862f, -0.10472783f, -0.06951765f, 0.04700651f, 
    0.32443208f, 0.00840354f, 0.04927027f, 0.11047236f, 0.15721278f, -0.12282715f, -0.12915637f, 0.07706049f, 
    0.02822644f, 0.05163720f, 0.11929464f, -0.01404737f, 0.03672316f, 0.02883764f, 0.06163608f, -0.03573464f, 
    -0.56441480f, 0.18916963f, -0.10317427f, 0.29960713f, 0.05701177f, 0.09044331f, -0.23643693f, 0.13960439f, 
    -0.15959062f, -0.28347188f, 0.11426628f, 0.05233549f, -0.04353191f, 0.08960481f, 0.11431992f, 0.08054779f, 
    -0.04904522f, 0.00384355f, 0.03704713f, -0.09627350f, -0.08170835f, 0.05764445f, 0.35741684f, -0.01337503f, 
    0.09319435f, 0.15377092f, -0.23476386f, 0.05663736f, -0.00266504f, 0.15474342f, -0.13212375f, 0.09080092f, 
    0.05454023f, 0.01635732f, -0.06609935f, 0.06141153f, 0.04925161f, -0.03055515f, 0.07857218f, 0.13809942f, 
    -0.27183992f, 0.13142133f, 0.01063751f, -0.12680060f, 0.08039645f, 0.10983394f, 0.13387355f, -0.10993902f, 
    -0.00063454f, 0.31655464f, 0.10690890f, 0.03828613f, 0.09049552f, -0.16253771f, -0.14637224f, -0.01387692f, 
    -0.10595483f, 0.03982376f, 0.07164364f, -0.01715913f, 0.09410287f, 0.14134462f, -0.28539056f, -0.13746180f, 
    -0.02428274f, 0.10472183f, 0.05365793f, 0.12196359f, 0.10787343f, 0.16915910f, -0.10521277f, 0.07695314f, 
    0.16539365f, -0.01337301f, 0.02981095f, -0.08987835f, -0.17450789f, -0.04481881f, 0.06611771f, 0.05797212f, 
    -0.47740117f, -0.00284228f, 0.08384793f, -0.12011934f, 0.00582775f, -0.04163221f, 0.25011632f, -0.03395378f, 
    0.06364533f, 0.16834357f, -0.02151450f, 0.00500011f, -0.07008101f, 0.07783037f, -0.11131641f, 0.02757537f, 
    0.01518750f, 0.11287110f, 0.06283952f, 0.12717950f, 0.32034284f, 0.06739566f, -0.07514744f, 0.30210215f, 
    0.20352148f, -0.13059057f, 0.06301136f, -0.02531426f, 0.22883777f, 0.04724459f, -0.02156765f, 0.10848981f, 
    -0.03949843f, -0.07869791f, -0.02056675f, 0.11590414f, 0.14249432f, 0.17636874f, -0.10493418f, -0.04753260f, 
    0.07188884f, 0.15406501f, 0.00816967f, -0.11076324f, -0.05368297f, 0.03285881f, 0.06841745f, 0.00142767f, 
    -0.05903757f, -0.03724796f, -0.08458734f, 0.11013359f, -0.10488254f, -0.08294008f, -0.01357172f, 0.03481857f, 
    -0.09215389f, 0.25987259f, 0.00635421f, 0.02821705f, 0.67748374f, -0.36475563f, 0.33330014f, -0.01324033f, 
    -0.19265345f, -0.06198133f, 0.08340091f, 0.01540089f, -0.06276928f, 0.10727207f, 0.07352867f, 0.00355477f, 
    0.02901771f, 0.12186402f, -0.10595685f, 0.02727682f, 0.17720261f, -0.05321346f, -0.12536588f, 0.14744399f, 
    0.18227531f, 0.17144173f, -0.33462134f, -0.34332052f, -0.18657319f, 0.15703544f, 0.17958957f, -0.02729747f, 
    0.33766133f, 0.37776998f, -0.01274581f, 0.03392007f, 0.08095767f, 0.03089120f, -0.10284683f, 0.02778288f, 
    -0.07149223f, -0.02663287f, -0.02282322f, 0.12716116f, -0.23969032f, -0.10815711f, 0.76819170f, -0.17532691f, 
    -0.16302107f, 0.13484715f, -0.44271734f, -0.12488525f, -0.10518431f, 0.13129602f, 0.02494963f, 0.07563036f, 
    0.05228050f, 0.14188050f, -0.03459618f, -0.09706323f, 0.26595622f, -0.08418132f, 0.12161148f, -0.11263034f, 
    -0.02538524f, 0.11325095f, -0.21349034f, -0.14759034f, -0.09704365f, -0.08130059f, 0.11428172f, -0.08796600f, 
    0.23559916f, 0.24853849f, -0.06150161f, -0.01481559f, -0.01361228f, 0.03933183f, -0.12306292f, 0.08818784f, 
    -0.00837766f, -0.07188025f, -0.04128311f, -0.05518170f, 0.14362559f, 0.01411494f, 0.19500829f, 0.30861652f, 
    -0.13441849f, -0.00229348f, -0.19219808f, -0.05141919f, 0.01126053f, -0.06170608f, 0.11011331f, 0.16915609f, 
    -0.01103688f, 0.13447966f, -0.01852847f, -0.13343665f, 0.11736955f, -0.06629705f, 0.01925182f, -0.20593473f, 
    -0.62635213f, -0.23964706f, -0.04211463f, -0.08094417f, -0.02792208f, -0.09952085f, -0.03562156f, -0.03456882f, 
    -0.06869001f, 0.02987173f, -0.03102801f, 0.03435750f, 0.10594682f, 0.00621995f, -0.14864297f, 0.09052886f, 
    -0.05167592f, 0.04112469f, -0.15032060f, -0.04290758f, -0.08781515f, 0.33743709f, 0.03194621f, -0.19134191f, 
    0.44719750f, -0.08473765f, -0.23854284f, -0.02380744f, 0.16318642f, -0.08603900f, -0.05434727f, -0.02825116f, 
    0.08756647f, -0.12142431f, -0.00658654f, 0.05961501f, 0.16020007f, 0.01144657f, -0.06847845f, -0.01979022f, 
    0.26142958f, 0.03929001f, -0.21868126f, 0.05212231f, 0.10802426f, -0.01800543f, 0.10463122f, -0.06181873f, 
    0.06148000f, 0.08728015f, 0.00614587f, 0.07380924f, -0.00163510f, -0.02804166f, 0.08387854f, 0.04796305f, 
    0.03543722f, 0.15542741f, -0.06767851f, -0.01598446f, -0.38264745f, -0.34081519f, -0.07491334f, -0.21838063f, 
    -0.10613444f, -0.11611366f, -0.23547952f, -0.11657603f, -0.02278697f, -0.08218232f, 0.07150041f, -0.19673783f, 
    -0.07378863f, -0.10470828f, -0.08393726f, -0.02380814f, -0.08161134f, -0.11510689f, 0.08488941f, 0.15639059f, 
    0.18307398f, -0.06044091f, -0.00683733f, -0.05207490f, -0.23704880f, 0.04847212f, 0.16990741f, 0.16108795f, 
    0.01454228f, 0.08581871f, 0.00362983f, 0.01678819f, 0.04676562f, -0.01363304f, -0.04599202f, 0.06195907f, 
    0.20019127f, 0.20693739f, 0.01878534f, 0.16984840f, -0.42012537f, -0.14054665f, 0.11923619f, -0.05075330f, 
    -0.03739322f, -0.09290560f, -0.22038645f, -0.18513356f, -0.09765697f, -0.15916824f, 0.00959322f, 0.01401243f, 
    -0.04351731f, 0.09956890f, -0.01559350f, 0.10701273f, -0.05478956f, -0.08164379f, 0.00335540f, -0.03600592f, 
    0.44484860f, 0.03174012f, -0.32813525f, -0.12920253f, 0.11727024f, 0.00895019f, 0.11248071f, 0.03606040f, 
    0.14036199f, 0.04278680f, -0.01449444f, 0.02445487f, 0.12520254f, -0.08563054f, 0.13592488f, -0.13940462f, 
    -0.03205556f, 0.13008849f, 0.08863846f, -0.04335102f, 0.07082543f, 0.32218841f, -0.16030489f, -0.01012577f, 
    0.03532294f, -0.02173438f, 0.06274305f, -0.04206544f, 0.11711482f, 0.10191303f, 0.03480257f, -0.01100204f, 
    -0.04350621f, -0.07270349f, -0.00518475f, 0.09032289f, 0.08602986f, 0.04869245f, -0.04127480f, 0.07014190f, 
    -0.01626327f, -0.04753578f, -0.02803039f, 0.00189879f, 0.02039992f, -0.02176377f, -0.03491103f, -0.03751896f, 
    0.01352961f, 0.02571701f, -0.01826039f, -0.02857198f, -0.02110441f, -0.01541482f, -0.00662800f, -0.03293293f, 
    -0.01644458f, -0.04138914f, -0.03886379f, -0.02301262f, 0.02057276f, -0.01350064f, 0.01597215f, -0.02576167f, 
    0.02582040f, -0.01937512f, -0.02960161f, 0.03490347f, -0.03253017f, -0.01441525f, 0.01422686f, 0.03737185f, 
    0.00019011f, 0.01463880f, 0.02602037f, -0.03024904f, -0.03596301f, -0.01658638f, -0.01247022f, 0.02804438f, 
    0.00061567f, 0.00578197f, 0.00991775f, -0.02177254f, -0.01618546f, 0.00889970f, 0.00052870f, -0.01648626f, 
    0.00624380f, 0.01373710f, -0.04046382f, -0.04347608f, 0.02610475f, -0.03366550f, -0.02538538f, -0.01500828f, 
    0.01560635f, -0.00359708f, -0.04159015f, -0.00192542f, -0.03268028f, 0.02226327f, 0.00346689f, -0.00553118f, 
    0.00261478f, -0.01128591f, 0.01623628f, -0.00680699f, 0.02605150f, -0.03133849f, 0.00786784f, -0.01028981f, 
    -0.02236708f, 0.01574495f, -0.01516104f, 0.01472669f, -0.01996605f, 0.00537747f, -0.02674155f, -0.01139933f, 
    0.01208614f, -0.03262851f, -0.01552216f, 0.00116014f, -0.04738043f, -0.00366604f, -0.03302801f, 0.02028438f, 
    -0.04910624f, 0.00754528f, -0.00698303f, -0.02789215f, -0.04716825f, 0.00051841f, -0.02749639f, 0.02006538f, 
    -0.03950485f, -0.03122088f, -0.03955366f, -0.02287134f, 0.02893485f, 0.00460530f, -0.00974557f, -0.02746671f, 
    -0.03642361f, 0.02297109f, 0.00952447f, -0.01004052f, -0.03272124f, -0.03450086f, -0.02240720f, 0.00391032f, 
    0.02917563f, -0.00484409f, 0.00721343f, -0.02663235f, -0.00858745f, -0.02925301f, -0.04191142f, -0.01733398f, 
    -0.00333796f, -0.00820307f, -0.00626487f, -0.00032141f, 0.01256204f, -0.04413359f, 0.02007053f, -0.02273406f, 
    -0.04481103f, -0.01571354f, 0.00475437f, -0.00690947f, 0.00466851f, -0.02236041f, -0.02098322f, 0.02994834f, 
    0.00169546f, 0.00756182f, -0.02067772f, 0.03010986f, -0.04855673f, 0.01052707f, 0.01854111f, 0.02140087f, 
    -0.04291196f, 0.02426959f, 0.01411615f, -0.00846126f, 0.00440799f, -0.01328999f, 0.02532770f, -0.00502852f, 
    -0.00151762f, 0.02878848f, -0.01151295f, -0.00425192f, 0.02435048f, 0.01833053f, -0.01475013f, -0.03352974f, 
    0.00473873f, -0.00957341f, -0.03621938f, 0.01230530f, 0.02578902f, 0.00601719f, 0.02668587f, -0.00649208f, 
    0.01999416f, -0.00740135f, -0.01381592f, -0.03970882f, 0.01406798f, -0.00215740f, -0.01119303f, 0.02283310f, 
    0.00173208f, -0.03863513f, -0.03157798f, 0.02430232f, -0.02897894f, -0.02798749f, -0.02376706f, -0.00766881f, 
    -0.02044224f, -0.00666996f, -0.02859636f, 0.00556522f, 0.02530232f, -0.00655741f, -0.04064088f, 0.03112953f, 
    -0.01456959f, 0.01164634f, -0.01117836f, -0.02657586f, -0.01026171f, 0.00802100f, -0.04421245f, -0.04417347f, 
    0.01649132f, -0.02989253f, -0.04796030f, -0.01136124f, -0.00895654f, -0.03946562f, -0.00406238f, -0.01694049f, 
    -0.02878029f, 0.01826000f, -0.01533878f, 0.01480826f, -0.01018944f, -0.03788932f, 0.03098026f, 0.02712111f, 
    -0.02411947f, -0.00959997f, -0.03577337f, -0.02820524f, -0.01711998f, 0.04608413f, -0.00524359f, 0.01307463f, 
    0.01917076f, 0.03285520f, -0.02333029f, -0.02919386f, 0.02101503f, 0.01087659f, -0.03359611f, 0.02570787f, 
    0.00559338f, 0.00350134f, 0.01490736f, -0.00477374f, -0.03360201f, 0.00430188f, 0.02149033f, -0.04682642f, 
    0.00462598f, -0.02093978f, 0.02839124f, -0.02916000f, 0.00743565f, 0.01023211f, -0.03821288f, 0.00001591f, 
    -0.00510468f, -0.01913271f, 0.02288107f, 0.01366582f, 0.00754136f, -0.02352048f, 0.00748244f, 0.02309370f, 
    -0.03788808f, -0.04485625f, 0.02214745f, -0.00568089f, 0.02754761f, -0.02787148f, -0.03477599f, 0.02794240f, 
    -0.03022997f, -0.00381556f, 0.01951938f, 0.02303412f, 0.00715976f, -0.03075255f, -0.04560781f, -0.01196084f, 
    -0.02866558f, 0.02628884f, 0.02864109f, -0.00701002f, -0.00493940f, 0.02319103f, 0.01531933f, -0.03646331f, 
    -0.01653686f, -0.04528585f, 0.02911564f, 0.00919514f, -0.04520529f, -0.01175148f, 0.02188363f, -0.01755313f, 
    0.01364035f, -0.01962546f, -0.02248398f, 0.02496702f, 0.00509906f, 0.01932789f, -0.03781657f, 0.03108716f, 
    -0.04003474f, -0.01052207f, -0.03005301f, -0.01424252f, 0.01739607f, -0.00665727f, -0.01091683f, 0.00672290f, 
    0.04165489f, 0.03067705f, 0.00054083f, 0.02168000f, -0.02535604f, -0.01735043f, 0.02449333f, 0.00190948f, 
    -0.04375237f, -0.04955724f, -0.04152019f, 0.02152142f, -0.02351195f, -0.02676878f, -0.04464701f, -0.01926352f, 
    -0.01928050f, 0.01032330f, 0.02351241f, 0.02596954f, -0.04005101f, -0.01641027f, -0.04039117f, -0.03610281f, 
    0.01084739f, 0.01151734f, 0.02972408f, 0.03976057f, -0.05019322f, -0.01271769f, 0.01584901f, -0.00477908f, 
    -0.01563532f, 0.00408977f, -0.03125060f, 0.00825526f, 0.00585664f, 0.03170360f, 0.02523347f, -0.01078548f, 
    0.00896588f, -0.00652581f, 0.01862239f, -0.00354333f, -0.00746709f, -0.01505202f, -0.04130808f, 0.02936089f, 
    -0.00553915f, 0.00808117f, -0.04868398f, -0.00402099f, 0.01452302f, 0.02329011f, 0.00450948f, 0.00117696f, 
    -0.00030910f, -0.01510293f, 0.02788841f, -0.02456639f, -0.03756291f, 0.01513413f, -0.00333879f, -0.01437760f, 
    -0.01424227f, 0.00352100f, -0.01546974f, -0.04205050f, 0.00587010f, -0.01847682f, -0.03351259f, -0.01381003f, 
    -0.00899640f, -0.01475209f, 0.01645396f, -0.04160198f, 0.01127357f, -0.01771554f, -0.01099848f, -0.00957388f, 
    -0.03207395f, -0.00210499f, 0.01053404f, -0.03167877f, 0.02554296f, -0.04349710f, 0.01817227f, 0.00702682f, 
    -0.01849311f, -0.03958614f, 0.00179596f, 0.02110608f, 0.00448652f, 0.00770026f, 0.01729294f, 0.01326982f, 
    0.02756586f, -0.03097278f, -0.00153192f, 0.00997917f, -0.02419076f, -0.00084293f, -0.04459731f, -0.01884367f, 
    -0.03043809f, -0.04776241f, -0.02194025f, -0.00899500f, -0.03080913f, -0.03422875f, -0.04858041f, -0.03216874f, 
    0.03555298f, 0.01480158f, -0.00096651f, -0.03266817f, 0.00569664f, 0.00372956f, 0.00078907f, -0.04290898f, 
    -0.03230058f, 0.02968693f, 0.02691849f, 0.02340725f, -0.02163470f, 0.01400171f, 0.00868568f, -0.03255687f, 
    0.00492435f, -0.03309220f, 0.02072088f, 0.00754979f, 0.00590915f, 0.01990138f, -0.02210246f, 0.00609679f, 
    0.01755239f, 0.03830807f, 0.02181031f, -0.04445762f, 0.03412914f, -0.02487026f, -0.01660969f, 0.00131367f, 
    -0.01254868f, -0.01486124f, -0.01761113f, -0.02163453f, -0.01017584f, -0.02423319f, 0.00682536f, -0.02785892f, 
    -0.04424180f, -0.03184471f, -0.04066721f, 0.00908516f, -0.03409887f, -0.03559624f, -0.02748645f, -0.02238719f, 
    0.01157207f, 0.01013796f, -0.03005280f, -0.02753929f, -0.01816020f, 0.02789585f, 0.01507701f, -0.04821830f, 
    0.01406621f, -0.01249227f, -0.02846429f, 0.01147988f, -0.04928007f, -0.03905119f, 0.02936805f, -0.03994929f, 
    0.02545608f, -0.02771156f, -0.03245611f, 0.01448409f, 0.01610139f, -0.00287240f, 0.01910061f, 0.02988994f, 
    0.02474342f, 0.01995768f, 0.02500365f, 0.00772863f, -0.04112801f, 0.01296598f, 0.00818365f, -0.00133749f, 
    -0.03153069f, 0.00549992f, 0.01564969f, -0.01785402f, -0.01478371f, 0.01340285f, 0.01671512f, 0.01656310f, 
    -0.00820514f, 0.03031461f, 0.00807220f, -0.02350848f, 0.02000946f, -0.03021534f, 0.01105091f, -0.02807986f, 
    -0.03446650f, 0.02666231f, -0.03379835f, -0.01861100f, 0.01205780f, -0.04474579f, -0.01822706f, 0.01150505f, 
    -0.03565306f, -0.02076732f, -0.01541973f, -0.03342221f, -0.01041192f, -0.01798913f, -0.04712885f, 0.01969795f, 
    -0.01390366f, 0.00725187f, -0.00396553f, -0.02969987f, -0.03833255f, -0.01753968f, 0.01660654f, 0.02482543f, 
    -0.04028921f, 0.01911220f, 0.00722110f, 0.02333978f, 0.01005425f, -0.00781804f, 0.00389165f, 0.01773434f, 
    -0.00595319f, -0.01660245f, -0.00482546f, 0.00605249f, 0.01640377f, 0.01038454f, -0.01777445f, -0.02402519f, 
    -0.04049543f, -0.02658806f, -0.00503611f, 0.02538564f, -0.01618761f, -0.03592741f, 0.02017505f, 0.02120451f, 
    -0.00745823f, -0.01495734f, -0.01408145f, -0.01490078f, -0.00761592f, 0.02967877f, -0.03886062f, -0.00925937f, 
    -0.00691443f, 0.01829052f, -0.03704021f, -0.04565560f, 0.00482757f, 0.00878016f, -0.00972762f, -0.03129720f, 
    0.00105271f, 0.02988655f, -0.01029157f, -0.02941198f, 0.03077713f, 0.00177276f, 0.02321510f, -0.02202691f, 
    0.02429310f, -0.02032299f, -0.02194856f, 0.02001793f, -0.02222460f, -0.03808287f, 0.00895861f, 0.02558183f, 
    0.02915558f, -0.00257705f, -0.03842505f, -0.01929498f, 0.01885577f, -0.01342699f, 0.00667119f, 0.01638651f, 
    0.00568004f, 0.01618420f, 0.00488541f, -0.01029567f, -0.02011147f, -0.00205504f, -0.01950395f, -0.04237248f, 
    0.01455287f, -0.01761174f, 0.00890892f, 0.01259109f, -0.01900892f, -0.04875383f, -0.00738622f, -0.02169200f, 
    -0.01943696f, -0.00946889f, 0.01784368f, -0.02428153f, 0.01368218f, -0.00437217f, -0.01284865f, -0.01168170f, 
    -0.00090032f, 0.01729863f, -0.00811357f, 0.02010978f, -0.00595981f, -0.01679929f, -0.02252335f, 0.04427301f, 
    0.00885068f, -0.04860042f, 0.01436535f, -0.01853092f, 0.01872735f, -0.01162119f, 0.01903951f, -0.04710656f, 
    -0.29707855f, -0.12448358f, -0.34555328f, -0.29199165f, -0.45619863f, -0.02525334f, 0.01181666f, -0.08958403f, 
    0.12512983f, -0.00513599f, 0.16211925f, 0.04450045f, 0.04515496f, 0.09949194f, -0.04056707f, -0.00962565f, 
    -0.05797883f, 0.04136521f, 0.07412044f, 0.02920011f, -0.24323601f, 0.21041682f, 0.45086661f, -0.21632428f, 
    -0.19975059f, -0.09648163f, 0.11157847f, -0.09722988f, 0.14937358f, 0.00143446f, 0.11562645f, -0.07805944f, 
    0.02321576f, 0.13439003f, 0.04899982f, -0.07225684f, -0.11011487f, -0.08989824f, 0.03717904f, -0.05196596f, 
    -0.18964419f, 0.19775812f, -0.18122944f, 0.19122826f, -0.00559575f, 0.06330283f, -0.24314190f, -0.07590156f, 
    -0.24027632f, 0.27029923f, -0.01144955f, 0.04997583f, -0.07952704f, 0.03191853f, -0.11152214f, 0.17994633f, 
    0.09797687f, 0.08742341f, 0.08474839f, 0.24695127f, 0.10226325f, 0.00960402f, -0.10711658f, 0.01374719f, 
    0.13289812f, 0.13971396f, -0.10715961f, -0.03825701f, -0.08597805f, -0.00460431f, 0.11365297f, 0.13556004f, 
    0.06405044f, -0.03144167f, 0.05504471f, -0.04699308f, 0.05577083f, 0.04165283f, -0.06925800f, 0.20656465f, 
    0.30421007f, -0.05128501f, -0.17377205f, -0.05326289f, 0.04731575f, 0.00461609f, 0.09009124f, 0.02851218f, 
    -0.00187457f, 0.02579026f, -0.01985080f, -0.02546261f, -0.07235228f, -0.02298303f, -0.09694054f, -0.17525382f, 
    -0.09323362f, 0.00124186f, 0.06058793f, -0.12217563f, 0.17909232f, -0.23454250f, -0.09014646f, -0.05099608f, 
    0.09086870f, -0.00181334f, -0.08810128f, -0.02049229f, -0.11880533f, -0.09486198f, -0.02138166f, 0.23504338f, 
    0.19457464f, -0.05247068f, 0.11719900f, 0.12577139f, -0.13732982f, 0.02873638f, 0.05179659f, 0.11712001f, 
    -0.14260887f, -0.11217697f, -0.12737630f, -0.04648282f, -0.24933812f, -0.03798965f, -0.14567871f, -0.14595972f, 
    0.00476146f, 0.00219556f, -0.02871225f, -0.17458127f, -0.03124632f, 0.00753398f, -0.04558139f, -0.05153126f, 
    0.05295447f, 0.01774993f, -0.08501532f, 0.01772594f, -0.07811717f, 0.03713776f, -0.05773177f, -0.00860115f, 
    -0.17742024f, 0.18053918f, 0.08434237f, 0.12149630f, 0.21720544f, 0.04734297f, 0.17148229f, -0.12386896f, 
    -0.00669511f, -0.06004498f, 0.04046379f, -0.03292464f, 0.00329107f, -0.00921882f, 0.09863663f, -0.10469294f, 
    0.10176139f, 0.03017366f, -0.09398617f, -0.09654798f, 0.04370440f, -0.01926374f, 0.05996143f, 0.07865228f, 
    -0.09828884f, -0.03278108f, 0.00576413f, -0.14683704f, 0.13340807f, 0.10453059f, -0.01365813f, -0.01052376f, 
    0.01941300f, 0.02000848f, 0.08959275f, -0.06199735f, -0.68497032f, 0.31214234f, -0.11821479f, 0.34833074f, 
    0.25579572f, 0.10233528f, -0.12388047f, 0.00161114f, 0.20170489f, 0.08941368f, -0.00970393f, 0.09494577f, 
    0.10619682f, 0.07247361f, -0.09408783f, 0.09091355f, -0.05091121f, 0.13407972f, 0.01773996f, 0.21543941f, 
    0.29516757f, -0.15814815f, -0.00571415f, -0.23530221f, 0.24225086f, -0.15975007f, 0.22310543f, 0.08640225f, 
    -0.07396966f, -0.03676643f, 0.03422734f, 0.10111555f, 0.02720950f, 0.01808551f, 0.14393523f, 0.13592859f, 
    0.09178920f, 0.01831800f, 0.11180613f, -0.19158623f, -0.26361647f, 0.00673979f, -0.01549180f, -0.22859560f, 
    -0.22105742f, 0.12940785f, 0.04187461f, 0.00427029f, -0.08940360f, 0.06394658f, 0.01757449f, -0.03899230f, 
    0.08450411f, -0.05572129f, -0.04301427f, 0.01560498f, -0.04260689f, -0.02637490f, 0.04985081f, 0.07409708f, 
    0.27977738f, -0.06611773f, -0.07954771f, -0.17262736f, -0.21525809f, 0.09368937f, -0.05365724f, 0.00592977f, 
    0.08788905f, 0.15141456f, 0.01410817f, 0.20029970f, 0.14850695f, 0.02783069f, 0.02802931f, 0.03697123f, 
    0.04194103f, -0.01254534f, 0.01992544f, 0.18462290f, 0.18239960f, -0.07805753f, 0.16116844f, -0.37000901f, 
    -0.06971464f, 0.10900446f, 0.14285065f, 0.05211908f, 0.17384094f, 0.11870194f, 0.00256921f, 0.12087400f, 
    0.06050846f, -0.10344147f, -0.05957551f, 0.00443176f, 0.05739883f, 0.11271720f, 0.10514046f, 0.00991475f, 
    -0.02775686f, 0.08611101f, 0.12419937f, 0.00586564f, -0.42468947f, 0.03549596f, -0.06300742f, -0.03856776f, 
    0.15135449f, 0.13017328f, -0.01168946f, 0.00904917f, 0.02105402f, -0.05273469f, 0.01380053f, 0.12927781f, 
    0.11648393f, 0.11423523f, -0.06834886f, 0.08219638f, -0.00832394f, -0.06120430f, 0.24016106f, -0.16354604f, 
    -0.26652542f, 0.15470061f, 0.14189406f, 0.05493976f, -0.05856342f, 0.03784634f, -0.04464304f, -0.00375379f, 
    -0.06119534f, 0.03594382f, -0.06927865f, 0.01381137f, 0.06266755f, 0.06115909f, 0.04810857f, 0.21484451f, 
    0.00347872f, -0.06723367f, 0.08337446f, 0.02089623f, -0.23418763f, 0.03535893f, 0.01388507f, 0.14417922f, 
    -0.06007680f, 0.03954595f, -0.06403341f, -0.01092864f, 0.00402698f, -0.05978636f, -0.08496176f, -0.00105703f, 
    -0.03074395f, 0.15875649f, -0.02719005f, -0.16134915f, -0.16121900f, 0.27835155f, 0.02999120f, -0.08638779f, 
    -0.25593010f, 0.08669796f, -0.08155778f, -0.04709592f, -0.03797078f, -0.00830016f, -0.02112426f, -0.10116102f, 
    -0.01269258f, 0.08168308f, 0.04447976f, -0.03581677f, -0.17165516f, 0.02492573f, -0.04647368f, 0.02193220f, 
    0.07060266f, 0.05390145f, 0.09500937f, -0.07132003f, -0.04061333f, 0.17866096f, 0.03621446f, 0.24008949f, 
    0.14402039f, 0.19356197f, 0.12172820f, -0.00473399f, 0.05017006f, 0.02411325f, 0.13565743f, 0.10186050f, 
    0.11046282f, 0.08199237f, 0.06563111f, 0.10995997f, -0.41009015f, 0.46162504f, -0.11575146f, 0.07815514f, 
    0.12091649f, -0.09963427f, -0.03075388f, -0.00781356f, 0.04779396f, -0.10410358f, 0.03509230f, -0.04893849f, 
    -0.06992098f, 0.14502232f, 0.00948330f, 0.01973288f, -0.15260279f, 0.05546121f, 0.19002040f, -0.29104728f, 
    0.09685070f, -0.09057273f, 0.29091236f, 0.04578710f, -0.31984457f, 0.13590536f, 0.06727771f, 0.12589939f, 
    -0.06000815f, -0.16686477f, 0.03879869f, -0.08949421f, 0.01214125f, -0.06698551f, 0.00085211f, -0.03657621f, 
    0.03815879f, 0.01326555f, 0.09258576f, 0.10105463f, -0.07676435f, -0.20643350f, -0.14419888f, -0.38293743f, 
    0.18555465f, -0.09337553f, -0.07675908f, 0.10829037f, -0.02971523f, -0.26241478f, 0.06618521f, 0.04893513f, 
    0.09337535f, -0.17509502f, 0.16075315f, 0.08253510f, -0.25923511f, 0.08432648f, 0.08898386f, 0.02377706f, 
    0.23290044f, 0.02580048f, 0.26724812f, 0.07997413f, -0.28772017f, 0.32906052f, -0.06115807f, 0.07701404f, 
    0.04576393f, -0.08846543f, 0.08310972f, -0.05405454f, -0.04058381f, -0.08766210f, 0.04065100f, -0.02319812f, 
    0.03471164f, -0.03019418f, 0.23371047f, -0.00608235f, 0.21400984f, -0.02608727f, -0.06036885f, 0.01491542f, 
    0.22268459f, -0.10333969f, -0.07474428f, -0.02276745f, -0.12006357f, -0.06996354f, -0.01215927f, 0.20562527f, 
    0.06832371f, 0.05725012f, 0.11836954f, 0.17728367f, -0.09301747f, 0.13096537f, 0.04284943f, 0.26636618f, 
    0.13063067f, 0.12524307f, -0.11747266f, 0.23116784f, -0.07308763f, 0.07555433f, 0.04132105f, -0.14372419f, 
    0.04569399f, 0.01305706f, -0.08000157f, 0.00579416f, -0.12170687f, -0.04411811f, -0.02566853f, -0.02023254f, 
    0.11031316f, 0.05548457f, 0.13430709f, 0.01877753f, 0.50615621f, -0.13208875f, 0.29345593f, -0.31082863f, 
    -0.07419302f, -0.08201558f, 0.07092239f, -0.20044364f, -0.03723276f, 0.11343025f, 0.01846755f, 0.05539773f, 
    0.00273301f, -0.04348281f, -0.00872733f, -0.13550861f, 0.05538354f, -0.16038005f, 0.14104889f, -0.13172852f, 
    -0.10226666f, 0.18464519f, 0.23157994f, -0.07288500f, -0.19961639f, 0.06634467f, 0.06697652f, 0.05141327f, 
    0.12004936f, 0.07597513f, 0.04665558f, -0.08202142f, -0.05721729f, 0.05497992f, 0.04449388f, 0.00642452f, 
    -0.10407404f, 0.02136704f, 0.03108498f, 0.03367718f, 0.10297522f, 0.08540939f, 0.02792015f, 0.02429259f, 
    0.04959300f, -0.06921721f, -0.03443876f, -0.06712215f, -0.04579851f, -0.12322562f, 0.16485593f, -0.02213426f, 
    0.04542896f, 0.06071422f, -0.00401587f, -0.06563748f, -0.03375751f, 0.03464852f, -0.05587743f, -0.03999868f, 
    -0.16711392f, 0.29409409f, 0.19941087f, 0.05023867f, -0.12287749f, 0.11723488f, -0.12499326f, 0.06029757f, 
    0.03553419f, 0.12503877f, 0.02763105f, -0.05112809f, 0.03435690f, 0.00082959f, 0.00845866f, -0.04774646f, 
    -0.06737117f, -0.05196428f, 0.00000226f, -0.18739761f, 0.09137948f, 0.05847265f, -0.06142439f, 0.09225164f, 
    0.17066553f, -0.01156165f, 0.02521716f, -0.06842040f, -0.10256357f, -0.08217128f, -0.01757121f, -0.13064583f, 
    -0.09226420f, 0.03285863f, -0.12452657f, -0.14754711f, -0.06823947f, 0.05156839f, -0.03925373f, 0.03785145f, 
    -0.06099178f, -0.02297812f, 0.23320173f, -0.12217617f, -0.18445627f, -0.04499373f, 0.16591614f, -0.18031302f, 
    0.07115495f, 0.05745344f, 0.11227725f, 0.04304391f, -0.03177457f, -0.05686127f, -0.02540376f, 0.18552813f, 
    0.04296269f, 0.07120064f, 0.11714813f, 0.20435140f, 0.27775115f, 0.03754837f, 0.27376804f, 0.04709329f, 
    -0.21534999f, 0.16077499f, -0.01900972f, 0.01371176f, 0.17626448f, 0.01894447f, 0.05102458f, -0.02319970f, 
    0.03128925f, -0.05669446f, 0.03663338f, 0.04005581f, -0.01561652f, -0.00356704f, -0.00227853f, -0.13035001f, 
    -0.25134310f, 0.52783602f, -0.33422950f, -0.03677051f, -0.08303596f, 0.16780636f, 0.06800910f, -0.09957395f, 
    -0.17369471f, 0.17577721f, -0.17093587f, 0.00367497f, 0.06275344f, 0.23127384f, 0.10313293f, -0.05040238f, 
    0.03963273f, -0.09713516f, 0.03334454f, 0.02597721f, 0.25493473f, 0.15532413f, -0.14730920f, -0.10373935f, 
    0.20371357f, -0.00514057f, 0.10535128f, 0.09969264f, -0.09706810f, 0.21909638f, -0.00726554f, -0.03774717f, 
    0.02697510f, -0.06933542f, 0.06857411f, -0.08133160f, -0.09708513f, 0.04452646f, 0.14626686f, 0.16554609f, 
    0.09053811f, 0.11995416f, -0.22757843f, -0.13623770f, 0.02712161f, -0.03896624f, 0.04491528f, -0.07139767f, 
    0.16992702f, -0.17570442f, 0.02080564f, 0.07693934f, -0.06746097f, -0.15719007f, 0.06440100f, -0.06428628f, 
    0.07236826f, 0.09382372f, 0.08279357f, 0.03987964f, -0.03813535f, 0.13003549f, 0.02913351f, -0.10146974f, 
    -0.20075066f, 0.12423952f, -0.04710864f, -0.00626293f, -0.00464260f, -0.19576856f, 0.15594490f, 0.03208071f, 
    -0.06000503f, -0.05385712f, 0.00555196f, 0.10356861f, 0.08782975f, -0.09894165f, -0.04274192f, -0.04944559f, 
    -0.32263657f, -0.23926625f, 0.22674939f, 0.14435241f, -0.11929093f, -0.13030747f, -0.02298737f, 0.05296682f, 
    -0.01645022f, -0.02957015f, -0.04517889f, -0.01741680f, 0.00916411f, -0.10212165f, -0.00107354f, 0.05542260f, 
    0.13548546f, -0.06883352f, 0.17236130f, 0.17449084f, -0.25788191f, 0.08775593f, -0.06942502f, -0.06194104f, 
    -0.10607211f, 0.08602832f, 0.05964903f, 0.00144390f, -0.02991264f, -0.05221764f, 0.04061874f, -0.07065297f, 
    -0.09267154f, -0.02302657f, 0.09808099f, 0.07998624f, -0.02641801f, -0.11889372f, -0.10787062f, 0.02083374f, 
    -0.05296317f, -0.06457233f, -0.06749695f, -0.08694913f, 0.04734705f, 0.15326458f, -0.05495090f, -0.04465727f, 
    -0.10308240f, 0.15420751f, 0.07764117f, 0.05027359f, 0.01375494f, -0.01791006f, -0.05496005f, 0.03036225f, 
    -0.06043500f, -0.03969160f, -0.01300850f, -0.02155969f, 0.11454238f, 0.04884657f, -0.14538823f, -0.20659013f, 
    0.04346991f, 0.16398524f, 0.10023578f, 0.04522782f, 0.09572604f, 0.17220235f, -0.00672847f, 0.08892900f, 
    0.10509698f, -0.03693023f, 0.05606308f, 0.01060687f, -0.07100417f, -0.00724394f, 0.18184301f, 0.03859771f, 
    0.02229753f, -0.08377668f, 0.12081032f, -0.06790326f, -0.12893817f, -0.05220121f, 0.03612661f, 0.00585545f, 
    -0.07946489f, -0.13402769f, 0.01315800f, 0.07269029f, 0.02263166f, -0.05997170f, 0.02208305f, 0.03684784f, 
    0.20931630f, 0.12390104f, -0.16141260f, -0.08252525f, 0.39096725f, 0.50568509f, 0.06057464f, -0.11954112f, 
    -0.33780104f, -0.15167792f, 0.16655864f, 0.00523541f, -0.12990677f, -0.00967618f, -0.08440851f, 0.00330820f, 
    0.11407913f, -0.03940251f, -0.01851794f, -0.03365185f, 0.06512258f, -0.18177187f, 0.03747020f, -0.03218753f, 
    -0.34042409f, -0.15551968f, -0.06571411f, 0.45579627f, 0.26997587f, -0.20007943f, 0.13269188f, 0.16704334f, 
    0.00230414f, -0.02714132f, -0.07256074f, -0.05587776f, 0.25637230f, -0.00646878f, -0.02444278f, 0.07843660f, 
    0.05458534f, 0.16594221f, -0.02773608f, 0.07133864f, 0.08582664f, -0.09723654f, -0.29190961f, -0.12525946f, 
    0.19865571f, 0.19160260f, 0.04466716f, -0.11469306f, 0.05385768f, 0.06853666f, -0.07680298f, -0.06623915f, 
    -0.02893677f, 0.03310486f, 0.03398009f, 0.00809110f, 0.01964917f, -0.06457669f, -0.04532958f, 0.02176880f, 
    -0.18430384f, -0.12168659f, 0.00249079f, -0.04535738f, 0.00712638f, 0.16644965f, -0.04061379f, -0.04039405f, 
    0.20961620f, 0.00241855f, -0.00387051f, 0.10822572f, -0.10931034f, 0.17878380f, 0.04785202f, 0.09498327f, 
    -0.04983913f, 0.14284402f, -0.04079917f, -0.05140039f, -0.44587800f, -0.26245636f, 0.03216609f, 0.47537911f, 
    0.43356141f, 0.02444901f, -0.04292377f, 0.09999256f, 0.07276032f, 0.15147321f, -0.08636179f, -0.02793914f, 
    0.16143723f, 0.06242304f, -0.13405897f, 0.03308674f, 0.10438838f, 0.12314011f, -0.08088401f, 0.00066210f, 
    0.38834003f, 0.12513666f, 0.20348556f, 0.20049959f, 0.22866520f, -0.10362525f, 0.14087999f, 0.23349403f, 
    -0.08279292f, -0.05959963f, 0.00694216f, 0.02838126f, -0.02590500f, 0.00932099f, -0.00597509f, 0.05108184f, 
    -0.01014471f, -0.06641727f, 0.02420079f, 0.01744538f, 0.08812188f, -0.19508593f, -0.30055800f, 0.03495805f, 
    0.24034704f, 0.07310382f, -0.01504981f, 0.07872688f, 0.15896636f, 0.19074067f, -0.04745237f, -0.02162397f, 
    -0.07215874f, -0.02908764f, -0.04193949f, 0.05001406f, -0.08337568f, 0.10965053f, -0.10055712f, -0.00584143f, 
    0.44530413f, -0.18401147f, 0.52154291f, 0.12292588f, 0.31637585f, -0.25540054f, 0.15962355f, 0.12895490f, 
    0.04908955f, -0.16275546f, -0.02740074f, -0.02612856f, 0.03501672f, -0.08681646f, 0.00320962f, -0.04910358f, 
    0.26730442f, 0.22703332f, 0.00553129f, 0.12345386f, 0.41768092f, 0.17474820f, -0.27825522f, -0.17812140f, 
    0.20763652f, 0.30481675f, 0.07953151f, -0.00732118f, 0.09265051f, 0.10440517f, -0.09071053f, 0.04107643f, 
    0.03372107f, 0.26277009f, 0.13490763f, 0.07107999f, 0.03166702f, 0.07404006f, -0.01296518f, 0.08610638f, 
    0.28583252f, -0.07657428f, 0.42220831f, -0.31567690f, 0.13186790f, 0.00089868f, 0.11881660f, 0.08069570f, 
    0.05330278f, -0.03378387f, 0.08329207f, -0.00450500f, -0.02708324f, -0.06683292f, -0.06085336f, -0.03693387f, 
    0.07418918f, -0.05391311f, 0.07116368f, -0.07303359f, 0.44419649f, 0.04819586f, -0.19407192f, 0.09584346f, 
    -0.01102205f, -0.06872968f, 0.15265200f, -0.00873709f, 0.10593728f, 0.08274785f, -0.07384707f, -0.02388913f, 
    0.07963564f, -0.10097796f, 0.06174211f, -0.05443434f, 0.08276659f, -0.00767560f, 0.18857922f, 0.02275083f, 
    0.18681780f, -0.11578620f, -0.30723444f, -0.12857702f, 0.18319345f, 0.15067595f, -0.01873002f, 0.15182658f, 
    0.09352287f, 0.15863052f, -0.05650426f, -0.05444123f, 0.01510427f, -0.10272367f, -0.04790872f, 0.04262833f, 
    -0.04271000f, -0.06144479f, 0.01002997f, 0.07387923f, -0.45264032f, 0.01277670f, 0.05641111f, 0.39776376f, 
    0.27082214f, -0.04463968f, 0.17996912f, 0.08104539f, 0.03967703f, -0.04212480f, 0.07492951f, -0.00314232f, 
    0.15841721f, 0.14379612f, 0.04743794f, 0.04642229f, 0.08582265f, 0.10516558f, -0.09303463f, -0.01857547f, 
    0.01820488f, 0.13098113f, -0.16168608f, -0.05045726f, 0.13876399f, 0.12805609f, -0.06810339f, 0.03837654f, 
    -0.00534064f, -0.07402371f, -0.05265838f, -0.01055438f, -0.05004326f, -0.08205005f, -0.14490764f, 0.07941176f, 
    -0.04217899f, -0.04149962f, 0.09459055f, 0.00339209f, -0.18764919f, 0.37456307f, -0.25258768f, 0.07932305f, 
    -0.09262370f, -0.00407450f, 0.09200063f, -0.01173791f, -0.02633701f, -0.01461693f, -0.03028634f, 0.01920064f, 
    -0.05269589f, 0.03862735f, 0.05089955f, 0.13043481f, -0.01792774f, -0.08775668f, -0.08887284f, 0.11853340f, 
    0.09006342f, 0.15107629f, -0.05539226f, 0.03651891f, -0.08834064f, 0.02067494f, 0.00276802f, 0.10514349f, 
    0.06860721f, -0.03432759f, -0.03505655f, 0.00710601f, -0.01237796f, 0.04521649f, 0.02925321f, 0.05689076f, 
    0.19747224f, 0.01790254f, 0.01644478f, 0.09197717f, -0.46930328f, 0.29058564f, 0.17047410f, 0.55596995f, 
    -0.01062296f, -0.13092797f, -0.09077576f, 0.26333687f, -0.11514534f, 0.14336662f, -0.04224915f, -0.00356750f, 
    -0.05255939f, 0.06929632f, -0.02015778f, 0.15818024f, 0.01542859f, 0.19734851f, -0.17260443f, -0.02786652f, 
    0.18710630f, -0.03329804f, -0.37201339f, -0.13641553f, 0.19525458f, 0.08748823f, 0.00436885f, 0.03385954f, 
    -0.04444011f, 0.10398354f, -0.03696872f, -0.00248942f, 0.00154219f, 0.05654716f, 0.06469647f, 0.00466886f, 
    -0.00071459f, 0.06744289f, 0.08658655f, 0.01910126f, -0.12413990f, 0.00870646f, 0.01549856f, -0.05108125f, 
    -0.16427326f, -0.14724933f, 0.02569526f, -0.00205937f, -0.09084322f, -0.06111699f, -0.09862338f, 0.00662270f, 
    -0.08683241f, 0.05206553f, -0.02975501f, 0.04422617f, 0.06016956f, 0.04770301f, -0.01821798f, -0.07171104f, 
    0.18701527f, -0.04642661f, -0.18730257f, -0.21785735f, 0.23702469f, -0.05833763f, 0.04288257f, 0.06431618f, 
    -0.10843875f, -0.01909307f, 0.02399751f, -0.04043943f, -0.04935864f, 0.07816652f, -0.01607588f, 0.16153434f, 
    0.05037159f, 0.06666473f, 0.03626033f, -0.04689195f, -0.09594658f, 0.06859311f, -0.00716501f, -0.06833363f, 
    -0.18374290f, -0.05092583f, -0.01553512f, 0.03261822f, -0.04345699f, -0.11696486f, -0.01654119f, 0.05016671f, 
    0.03891209f, -0.03492430f, -0.07199124f, 0.14959191f, 0.12416400f, 0.10062761f, -0.07462148f, -0.01987282f, 
    -0.07021557f, -0.14853610f, -0.06167203f, -0.12454645f, 0.11094084f, 0.02955648f, 0.09533234f, -0.00134503f, 
    0.07294869f, 0.22703043f, -0.12547943f, -0.08978520f, -0.15968251f, 0.01588242f, -0.01806306f, -0.02845822f, 
    -0.07057760f, 0.03316834f, -0.09708466f, -0.07929572f, 0.03671579f, 0.22801077f, -0.07163286f, -0.09442152f, 
    0.10473137f, 0.06798102f, 0.07935570f, 0.06821164f, 0.08755603f, 0.10735036f, -0.05511329f, -0.00823927f, 
    -0.02792074f, 0.07405370f, 0.01268193f, 0.17543176f, 0.00415784f, 0.17584416f, 0.03910973f, -0.07886535f, 
    -0.04041743f, -0.00782350f, -0.04196571f, -0.03626500f, -0.02086297f, 0.01477287f, -0.03161864f, -0.03786272f, 
    0.02788517f, -0.01165930f, 0.02442968f, -0.01989386f, -0.00742574f, -0.02221881f, 0.01438875f, 0.02843282f, 
    0.00198199f, 0.02581009f, 0.00132389f, -0.01958943f, -0.01557110f, 0.02741022f, -0.04082754f, 0.03011724f, 
    -0.01987434f, -0.01541310f, 0.02861447f, -0.03654801f, 0.02766147f, 0.01956224f, -0.00345400f, -0.02855005f, 
    0.03023478f, -0.04208184f, -0.02153398f, -0.04299043f, -0.00420689f, 0.00522011f, 0.02128622f, 0.02008699f, 
    0.01342231f, -0.00390402f, -0.01179886f, -0.03275710f, -0.04539280f, 0.02804383f, 0.02496231f, -0.00786158f, 
    -0.00063299f, 0.03147061f, -0.02980512f, -0.01739541f, -0.02282721f, 0.01558887f, 0.01154450f, 0.02581844f, 
    0.00333760f, -0.02887412f, -0.01437505f, -0.02264977f, -0.00005577f, 0.01019141f, 0.00615234f, 0.02520819f, 
    -0.00616336f, -0.00496677f, -0.03450420f, -0.01454330f, -0.02929608f, -0.04010994f, 0.02289236f, -0.02955700f, 
    0.00185057f, -0.02708793f, -0.01612370f, -0.03921501f, -0.00629839f, -0.03954827f, -0.00658913f, -0.02836690f, 
    -0.02384902f, -0.00731277f, -0.03364208f, -0.02194686f, 0.00996083f, 0.01199880f, -0.02109305f, 0.00109878f, 
    -0.01311140f, -0.03572296f, -0.01139336f, -0.03863955f, -0.02499476f, -0.00716468f, 0.02143315f, -0.02495344f, 
    0.00445835f, -0.01362969f, -0.01994755f, -0.02928192f, -0.01895102f, -0.01891327f, 0.02736103f, -0.02051104f, 
    0.00175967f, -0.00824632f, -0.02864571f, 0.02486100f, 0.01959477f, -0.01083651f, -0.01142109f, -0.00270627f, 
    -0.02694307f, 0.02389851f, 0.02578645f, -0.01067136f, 0.01105215f, -0.03210350f, -0.03191238f, -0.00519766f, 
    0.01336458f, 0.03034353f, -0.03691260f, -0.01707335f, 0.01524033f, 0.02687859f, -0.01842926f, 0.03367693f, 
    -0.01993938f, -0.03241515f, -0.01689699f, -0.01741560f, 0.01577596f, -0.00086322f, -0.03310817f, -0.02669390f, 
    0.00990907f, 0.00309080f, 0.00797683f, -0.02889273f, -0.01391258f, -0.01289071f, 0.02034554f, 0.01332537f, 
    0.01410983f, 0.00585328f, -0.01144325f, 0.02446866f, -0.03754632f, 0.01348548f, -0.01884159f, -0.04305860f, 
    -0.01291238f, 0.02028433f, 0.02794784f, -0.00049946f, -0.00600797f, -0.01665654f, -0.02362248f, -0.03712826f, 
    -0.02757177f, 0.01457182f, -0.04238035f, -0.02695113f, -0.04098028f, 0.02308095f, 0.01448200f, 0.00076587f, 
    -0.02396468f, -0.01027033f, -0.03673401f, 0.02007320f, -0.02743210f, 0.00672212f, 0.02962033f, -0.01835383f, 
    -0.03814753f, -0.04180621f, -0.00947116f, -0.02420449f, 0.02428531f, -0.00591569f, -0.00452776f, -0.04005062f, 
    0.00220582f, 0.00141331f, -0.02543344f, 0.01317237f, -0.03984147f, 0.01882372f, 0.00654868f, 0.00517114f, 
    -0.01294518f, -0.02475432f, 0.00990932f, 0.03121805f, 0.01576389f, -0.00985063f, 0.00301186f, 0.02075667f, 
    0.02401295f, -0.03876111f, 0.02385796f, 0.01818583f, 0.01874384f, -0.03449423f, 0.00263297f, 0.01440933f, 
    -0.02749960f, -0.04244230f, -0.01004961f, 0.01338584f, 0.02836062f, -0.01364298f, -0.00000107f, -0.01374578f, 
    0.02975907f, -0.00063507f, -0.01466183f, 0.01410938f, 0.01113638f, -0.00678308f, 0.01361026f, 0.00055684f, 
    0.02496698f, -0.01381197f, -0.00090316f, -0.01514370f, 0.02474608f, 0.01214985f, 0.02749905f, 0.01694968f, 
    -0.03202540f, 0.01415910f, 0.03104052f, 0.03110752f, 0.01456782f, 0.00911552f, 0.00247604f, 0.00310514f, 
    -0.01187231f, -0.00809756f, 0.02244337f, 0.02005292f, -0.01278970f, -0.02190230f, -0.00021623f, 0.02679069f, 
    0.02174569f, 0.03259497f, -0.04019013f, -0.00862059f, -0.02441953f, -0.00368108f, 0.02408993f, -0.03579871f, 
    -0.03969098f, -0.00775921f, -0.00257500f, -0.02087469f, -0.01940750f, -0.00533495f, -0.00139745f, -0.02546930f, 
    0.01337267f, -0.01601695f, -0.00306558f, -0.02853743f, -0.03260595f, -0.01290349f, 0.00303798f, -0.02254600f, 
    0.00097034f, -0.01595801f, -0.02589897f, 0.01432363f, -0.04451085f, 0.00195477f, 0.01147820f, -0.00651708f, 
    0.00459563f, 0.02744805f, 0.00195353f, -0.02654983f, 0.03201409f, -0.02002913f, -0.04372547f, 0.01048873f, 
    -0.00339209f, -0.02897007f, -0.00401395f, -0.01614242f, -0.03193977f, -0.03894912f, -0.00844093f, 0.00738388f, 
    -0.01386229f, 0.00352204f, -0.02890467f, -0.00113080f, 0.03399606f, -0.04056610f, 0.01861170f, -0.00756773f, 
    0.00068022f, -0.01562890f, 0.02269187f, -0.02934485f, -0.00461565f, 0.01432203f, -0.00374830f, 0.03227383f, 
    -0.01083769f, -0.02944029f, -0.00582774f, -0.03429196f, 0.01679904f, -0.04285058f, -0.01125380f, -0.03198398f, 
    0.03497453f, 0.00824929f, -0.02452688f, -0.02553659f, -0.00588547f, 0.01574214f, 0.02956702f, -0.01483482f, 
    -0.00790444f, -0.03075647f, -0.04221848f, -0.03084655f, 0.01941138f, 0.02174435f, 0.00657267f, -0.02105416f, 
    -0.02751012f, -0.00601637f, -0.03127879f, 0.01865432f, -0.01817353f, 0.02113129f, 0.02231795f, -0.03290692f, 
    -0.03285287f, -0.02277721f, -0.00730605f, 0.00260744f, -0.04227379f, 0.00694204f, 0.01799570f, -0.03795343f, 
    0.00112522f, 0.03165391f, -0.00207995f, 0.03007923f, 0.01199379f, -0.04299567f, -0.01644747f, 0.01890088f, 
    -0.00434053f, 0.00965954f, -0.02152693f, -0.02955662f, 0.00183897f, 0.03186829f, 0.01758461f, -0.04516428f, 
    -0.00193403f, 0.01434790f, -0.01075947f, -0.03588266f, 0.02769965f, -0.03577985f, 0.00008646f, 0.01050906f, 
    0.03356446f, 0.02544599f, -0.03754068f, 0.02827356f, -0.00670292f, -0.03260455f, 0.00821389f, 0.02551007f, 
    -0.03522544f, 0.00806629f, 0.01280894f, 0.01386502f, -0.02979597f, -0.00163754f, -0.00803494f, 0.02282022f, 
    -0.03908760f, -0.04135636f, -0.02752285f, 0.01910989f, 0.02355977f, -0.04232856f, 0.01528807f, -0.00191845f, 
    0.01780521f, -0.00867580f, 0.02267645f, 0.02705160f, -0.03051748f, -0.00570715f, 0.02246620f, -0.03616013f, 
    0.02590833f, 0.01242679f, 0.02861677f, 0.01883578f, 0.00553621f, -0.02862515f, 0.00078005f, 0.03060884f, 
    -0.02690567f, -0.01565756f, -0.03731603f, -0.03962881f, 0.01983670f, -0.03987753f, -0.02700419f, -0.04205633f, 
    -0.03180850f, 0.00733262f, 0.01378680f, -0.03710767f, 0.01902946f, 0.02582099f, -0.02287024f, -0.02950047f, 
    -0.03951490f, -0.03050911f, -0.01100579f, 0.01099040f, 0.03093322f, 0.02939814f, -0.00229184f, -0.03973068f, 
    -0.00430020f, -0.00949754f, -0.02653175f, -0.01293782f, -0.01206267f, 0.00764893f, 0.00723713f, -0.01548345f, 
    0.00149010f, 0.00304331f, 0.00654289f, -0.03596138f, 0.00016363f, 0.03202368f, -0.03568397f, -0.03756447f, 
    -0.00744619f, -0.02962938f, 0.00334792f, -0.01628151f, 0.01599980f, 0.01028883f, 0.02327000f, 0.02138277f, 
    -0.00981608f, 0.00444349f, 0.01982771f, -0.02251717f, 0.01267966f, 0.00306146f, 0.00942961f, 0.02308129f, 
    0.00793023f, -0.01590596f, -0.02185605f, 0.03295726f, -0.00819703f, -0.01737118f, -0.01183454f, -0.02583946f, 
    -0.03379207f, -0.01823441f, 0.02984572f, 0.01012356f, 0.00636324f, -0.03398034f, 0.00650883f, -0.00525332f, 
    -0.02913813f, -0.01721999f, 0.01291570f, 0.00591228f, -0.03734281f, -0.02718088f, 0.02955185f, -0.03623760f, 
    -0.02802776f, -0.04500837f, 0.01789388f, 0.02493431f, 0.00373066f, 0.01278152f, -0.01785402f, -0.00909356f, 
    -0.02189104f, 0.01990922f, 0.01054710f, -0.03961589f, 0.03231009f, -0.04383041f, -0.03671392f, 0.01972593f, 
    0.02344190f, 0.01053838f, -0.01514880f, 0.01983721f, 0.02870196f, -0.02672406f, -0.04241287f, 0.00248042f, 
    0.01232619f, -0.02045513f, 0.02668927f, -0.02705462f, 0.03309272f, -0.00906674f, -0.02795159f, -0.02220386f, 
    -0.00975351f, 0.01539102f, 0.02990880f, -0.00404373f, -0.02911320f, -0.03805786f, -0.02516087f, 0.01962337f, 
    0.02709214f, -0.01862816f, 0.02432630f, -0.02852749f, 0.00203435f, -0.03782940f, 0.00570671f, -0.03652499f, 
    -0.01159912f, 0.01742471f, -0.04494130f, 0.04117366f, 0.00143476f, -0.00769046f, -0.00902646f, 0.02119488f, 
    0.00416859f, -0.01326975f, -0.02110490f, 0.03090536f, -0.02062691f, -0.04670585f, 0.03053985f, 0.01722549f, 
    -0.01805175f, -0.03125991f, 0.01156054f, -0.01935165f, -0.00362250f, 0.00798997f, -0.02187583f, -0.00770214f, 
    0.01354312f, 0.02708151f, -0.04265776f, -0.00821463f, -0.04354170f, 0.03192094f, -0.02097963f, -0.04292938f, 
    0.00956557f, -0.00984257f, 0.02971935f, -0.00424284f, 0.02778085f, -0.03390190f, -0.02913311f, 0.02323299f, 
    -0.04387555f, 0.02881020f, -0.02510104f, 0.01426510f, 0.02971048f, -0.02868408f, -0.01149995f, 0.01694524f, 
    -0.01187716f, -0.00882623f, 0.01779769f, 0.00964202f, -0.04145076f, -0.02974414f, 0.02347204f, -0.00652936f, 
    0.02867046f, -0.04390597f, -0.02562313f, -0.02038752f, -0.01282529f, -0.04508862f, -0.01512573f, 0.00752075f, 
    -0.04011760f, -0.03514696f, -0.02611022f, 0.01992676f, 0.00673162f, -0.01420508f, -0.02841638f, -0.00262849f, 
    -0.01976528f, 0.02986855f, -0.01321316f, -0.03666139f, -0.03672601f, 0.01809026f, 0.01443200f, -0.01970877f, 
    0.02984315f, -0.03961030f, -0.01849307f, 0.02521930f, -0.01203658f, -0.03452953f, -0.01460352f, -0.01061538f, 
    -0.00675697f, -0.00162851f, 0.01369396f, 0.00650306f, 0.00375258f, 0.02494884f, 0.02679232f, 0.01820934f, 
    0.27560452f, -0.45277941f, 0.42019093f, 0.35126400f, 0.13793200f, -0.12080682f, -0.05703102f, 0.11012699f, 
    0.01940157f, 0.01903497f, 0.09276236f, -0.03901704f, 0.06768108f, 0.07719454f, -0.00073893f, 0.09156580f, 
    0.02024567f, 0.07848570f, -0.02317915f, -0.02251348f, 0.08650678f, -0.16848382f, 0.18799581f, 0.09613239f, 
    -0.18278934f, 0.04429987f, -0.08018567f, -0.01667866f, 0.09720100f, 0.04175345f, -0.04244699f, 0.00631098f, 
    0.05418708f, -0.02658463f, -0.15364867f, -0.01740872f, 0.10676395f, 0.12447114f, -0.02222361f, -0.04920696f, 
    0.08264728f, -0.19732991f, 0.39800635f, -0.05022488f, -0.09888151f, -0.03362772f, 0.27458668f, -0.11438710f, 
    0.11535067f, 0.00821112f, 0.07596966f, -0.00840003f, 0.15981901f, -0.06682007f, -0.14501539f, 0.04458538f, 
    -0.03063966f, -0.15934372f, -0.16401063f, -0.21021876f, -0.03642852f, 0.00432583f, 0.07701860f, 0.06607699f, 
    0.22435243f, -0.21957640f, 0.12872659f, 0.15760066f, -0.10089763f, 0.15271901f, -0.09327850f, -0.05795767f, 
    0.06959782f, -0.09742700f, -0.18094067f, -0.01169046f, -0.10976764f, 0.01761628f, -0.10184744f, -0.13127811f, 
    0.46005294f, 0.37390539f, -0.16564855f, 0.00676189f, 0.04027493f, 0.03240094f, -0.03708164f, 0.00860080f, 
    0.06826296f, 0.09863392f, 0.01347265f, 0.00889178f, 0.03292190f, 0.05129261f, -0.00716753f, 0.17360231f, 
    0.19810946f, 0.13188078f, 0.06528918f, 0.19812579f, 0.20042233f, 0.00442757f, 0.12007513f, 0.08396135f, 
    0.06624229f, -0.03008228f, -0.05253499f, 0.02317601f, 0.06672411f, -0.00241198f, -0.01727887f, 0.01583839f, 
    0.06087564f, 0.02060733f, -0.19749060f, 0.00425979f, 0.06648593f, 0.02800474f, -0.04839331f, -0.05311458f, 
    0.01773682f, 0.11782588f, 0.05919030f, 0.15047060f, 0.04721967f, -0.08492608f, -0.02267833f, -0.01019535f, 
    -0.04181414f, -0.17501062f, -0.11143804f, -0.01708354f, 0.18753096f, 0.16109048f, 0.11226647f, -0.00031485f, 
    -0.11449273f, -0.01076890f, -0.11136393f, -0.09718261f, 0.12408299f, -0.08242432f, 0.11021569f, -0.04527328f, 
    0.00988003f, -0.10658167f, 0.03792805f, 0.06355245f, -0.14617424f, -0.06207951f, -0.00678257f, -0.03801810f, 
    0.11304513f, 0.07826504f, -0.09770587f, 0.10090660f, -0.01206223f, -0.07015225f, -0.12172480f, -0.00019414f, 
    0.04324407f, 0.08151515f, 0.03041383f, -0.07720531f, 0.03341413f, -0.00733424f, 0.01183699f, 0.01527326f, 
    0.08584923f, 0.02956511f, 0.01670899f, 0.04715395f, -0.02519684f, -0.04788126f, -0.04390420f, -0.08793940f, 
    -0.12522537f, -0.06131867f, 0.03382721f, -0.05959779f, -0.32175428f, -0.47214398f, -0.05960628f, -0.04345536f, 
    0.45450455f, 0.21988934f, -0.11061103f, 0.00993720f, 0.05361785f, 0.14463070f, 0.33380491f, -0.07175937f, 
    -0.10504787f, -0.02180000f, 0.00581300f, -0.06787965f, -0.07455518f, 0.06775519f, -0.01593411f, 0.02730519f, 
    0.08325715f, -0.02697622f, 0.06943789f, -0.28251812f, -0.52733433f, 0.17630973f, -0.11842276f, 0.04644139f, 
    0.06353464f, 0.10445070f, -0.04675495f, 0.10223081f, -0.04441761f, -0.01560347f, -0.15333387f, -0.00049558f, 
    -0.13622963f, 0.13876222f, 0.03441839f, 0.04068855f, 0.03206855f, 0.11541250f, 0.32952747f, 0.27794525f, 
    -0.19604291f, -0.13523744f, -0.07954033f, -0.00963544f, 0.00433984f, 0.01076057f, 0.00480956f, -0.01694771f, 
    0.05066729f, 0.09196520f, -0.01840198f, -0.00381198f, -0.02160922f, 0.04504577f, -0.01572797f, 0.03402394f, 
    0.11729847f, 0.14472418f, 0.19534466f, -0.00484449f, 0.01137902f, -0.13281691f, 0.07693443f, 0.04419687f, 
    -0.11904289f, -0.05349179f, 0.04468424f, -0.09944520f, 0.22468236f, -0.18262723f, -0.08833066f, -0.13825595f, 
    -0.03626024f, -0.04664535f, -0.04360837f, -0.12441990f, 0.33389807f, 0.07238374f, -0.27081907f, -0.05781336f, 
    -0.47047031f, 0.03944106f, 0.03104543f, -0.05329758f, -0.04005825f, -0.20008406f, 0.06653622f, 0.10526342f, 
    -0.08407478f, -0.02003421f, 0.14297135f, -0.06786060f, -0.01668344f, -0.05158711f, 0.03664466f, 0.00859098f, 
    -0.14542432f, -0.00884015f, -0.28721642f, -0.08272704f, -0.00748920f, 0.20344058f, 0.01360983f, -0.14376003f, 
    0.09531984f, 0.09396466f, -0.03488189f, -0.06962821f, 0.03175540f, 0.05320657f, 0.00944096f, -0.04334141f, 
    0.05737403f, 0.19881883f, 0.22421205f, 0.09006213f, 0.06855273f, 0.07554424f, 0.28409499f, -0.03956288f, 
    -0.22486858f, 0.04470382f, -0.02288300f, -0.05284115f, -0.03598555f, -0.07051266f, -0.04176501f, -0.01661125f, 
    0.04554093f, 0.05168992f, 0.05446628f, -0.03449442f, -0.04000707f, -0.03580144f, -0.08241457f, -0.22099803f, 
    -0.19338320f, 0.23598917f, -0.06938024f, -0.05827655f, -0.11146075f, -0.18320000f, 0.00070127f, 0.09466190f, 
    0.08050951f, 0.21591644f, 0.09084510f, -0.08893407f, -0.01812802f, 0.03846101f, -0.04315569f, 0.13741994f, 
    0.08174081f, -0.29479706f, 0.03794431f, 0.12380569f, -0.12866996f, -0.18917881f, 0.38853392f, 0.06657740f, 
    -0.06185672f, -0.14265800f, 0.05062121f, 0.12948291f, -0.07097807f, -0.11333278f, 0.02525190f, -0.05129118f, 
    0.03984716f, -0.11291616f, -0.06488313f, -0.02322209f, 0.06764466f, 0.02110763f, 0.12548825f, 0.06724265f, 
    -0.22785138f, 0.17984456f, -0.30891103f, 0.19113061f, -0.04110695f, -0.01549748f, -0.01622939f, -0.05147053f, 
    0.07114296f, 0.08711328f, -0.02980418f, 0.02385145f, 0.04622641f, -0.17522702f, -0.11069898f, 0.05051629f, 
    -0.04496044f, 0.14003031f, 0.09499525f, -0.00838087f, -0.35234103f, -0.32990611f, 0.00079402f, -0.08214393f, 
    0.01045393f, 0.03431380f, -0.10607838f, 0.03706067f, -0.09398451f, 0.06897762f, 0.06931095f, 0.06003952f, 
    0.10502668f, 0.08111173f, -0.07303114f, 0.12034170f, 0.11580618f, -0.08603021f, -0.04628078f, 0.29098374f, 
    -0.07228945f, 0.15644524f, 0.11717156f, 0.09361304f, -0.06312122f, -0.16048752f, 0.00797770f, -0.14213476f, 
    -0.09367501f, -0.01405841f, -0.01276208f, -0.03538630f, -0.03654769f, 0.03534237f, 0.02907921f, -0.00530005f, 
    -0.02957605f, -0.01894252f, -0.25911611f, -0.16381367f, 0.51195055f, 0.05519127f, -0.24322703f, -0.06396327f, 
    -0.13748699f, 0.07011915f, -0.10323276f, -0.11313277f, 0.19942789f, 0.06681829f, -0.11458778f, 0.02669573f, 
    -0.21231966f, -0.01394135f, 0.07927361f, 0.09132233f, -0.00618671f, -0.10463984f, 0.16958983f, 0.04417324f, 
    0.04361102f, -0.09004120f, 0.07456734f, -0.11535095f, 0.02247840f, -0.13640466f, 0.04983661f, 0.02718092f, 
    -0.10437820f, 0.07072923f, -0.05618970f, -0.12221743f, 0.00852156f, -0.06782692f, 0.00132410f, -0.16300248f, 
    -0.06744574f, 0.03749536f, 0.11029240f, 0.16420628f, 0.18042654f, -0.23686783f, 0.42383260f, -0.12012614f, 
    -0.00109699f, 0.08631011f, 0.00355923f, -0.00552396f, 0.05518129f, 0.00007105f, 0.12645702f, 0.07552412f, 
    0.32725340f, -0.09573333f, -0.12891217f, -0.00459249f, 0.21323366f, 0.02561356f, 0.20915909f, -0.12804887f, 
    0.07382157f, -0.07405273f, 0.16114779f, -0.06916439f, 0.12329037f, -0.09727047f, 0.26062587f, -0.07647982f, 
    0.02275950f, -0.00401362f, 0.12389359f, -0.02858063f, 0.04598732f, 0.10980021f, -0.14039943f, 0.11084577f, 
    -0.07986996f, -0.08605116f, -0.05381497f, -0.00065493f, 0.14262241f, -0.24260837f, -0.26965588f, -0.41860279f, 
    0.10845982f, 0.08634456f, 0.03511779f, 0.07943279f, 0.10201255f, -0.12001846f, -0.01079360f, -0.06277978f, 
    -0.01353267f, -0.03700547f, 0.01084941f, 0.13225669f, 0.12143804f, 0.10619123f, 0.31555986f, 0.19793849f, 
    0.03817423f, -0.06875089f, 0.45232400f, 0.14455955f, -0.19778027f, -0.04541925f, 0.04831988f, 0.03442480f, 
    0.01094484f, -0.07538515f, -0.05776981f, -0.00224300f, 0.04445530f, -0.08014998f, -0.07524906f, -0.06756512f, 
    0.08250298f, -0.02026103f, 0.03098156f, 0.04478970f, 0.07283323f, -0.05777480f, 0.03721818f, 0.04645563f, 
    0.12200808f, 0.03125846f, -0.00923161f, 0.01888290f, 0.02656006f, 0.08923208f, -0.02627165f, 0.04948365f, 
    0.00940156f, 0.02202909f, -0.05215443f, -0.02642548f, -0.13848981f, -0.09519672f, -0.03691114f, -0.02358160f, 
    -0.13612635f, -0.05286575f, 0.02774086f, 0.19824302f, -0.24657924f, 0.08387530f, 0.01544722f, -0.19581082f, 
    0.01064888f, 0.07048446f, -0.06448405f, -0.05247968f, -0.00607058f, 0.00598707f, 0.04744962f, -0.27546880f, 
    0.06583849f, 0.03483252f, 0.11564439f, 0.38192222f, 0.20525607f, 0.02311583f, 0.05931395f, 0.01388919f, 
    0.16571137f, 0.03786303f, 0.02409049f, 0.04922877f, 0.03500927f, 0.11005927f, -0.01255190f, 0.07475254f, 
    -0.04254185f, 0.00236433f, -0.01252163f, -0.09548321f, -0.04978149f, -0.06048032f, 0.02639110f, -0.00260152f, 
    0.13058434f, 0.24529888f, 0.02955606f, 0.21715009f, -0.04721550f, 0.00645174f, -0.19513078f, 0.08648140f, 
    0.04340087f, -0.21033296f, 0.05723776f, -0.02186765f, 0.13741755f, 0.05126334f, -0.07264531f, -0.07813016f, 
    -0.03409348f, 0.00327514f, -0.08510033f, -0.21192610f, 0.01865306f, -0.22724089f, 0.04443557f, -0.03791283f, 
    0.06296217f, -0.04744375f, 0.04341760f, 0.05463721f, -0.18828365f, 0.05670672f, -0.00797612f, -0.03016368f, 
    0.05205668f, -0.01648034f, 0.03170443f, -0.14978454f, -0.01698501f, -0.03746010f, 0.22094440f, 0.36023116f, 
    0.36515334f, -0.59442484f, -0.46608245f, -0.09657983f, -0.19717938f, -0.25584430f, 0.04857248f, 0.22429590f, 
    0.07356855f, 0.19017452f, 0.25314254f, -0.11867470f, -0.07710443f, -0.08100458f, -0.14897081f, -0.03920550f, 
    -0.06601349f, 0.06014707f, -0.08038752f, -0.03508922f, 0.20703976f, 0.21238090f, -0.10040529f, 0.15704148f, 
    0.05929588f, 0.18640849f, -0.02071014f, 0.20310244f, 0.04989514f, -0.07219951f, 0.00641862f, -0.00711442f, 
    0.03832211f, -0.06825279f, 0.12918349f, 0.07460526f, 0.04548468f, 0.13855198f, -0.13131672f, -0.01015747f, 
    -0.00586749f, -0.21526098f, 0.33233580f, 0.04528618f, -0.04262112f, 0.06554791f, 0.01249283f, 0.02464055f, 
    -0.04110171f, -0.06874302f, -0.12521937f, 0.07285051f, -0.05406163f, 0.17492865f, -0.04739926f, 0.01323823f, 
    0.00555182f, -0.08178698f, 0.01222596f, 0.00379050f, 0.04225411f, 0.00725437f, 0.10017113f, -0.02812681f, 
    0.10025027f, -0.15376404f, 0.07058080f, 0.06695426f, -0.06912429f, -0.03273859f, 0.03173780f, -0.05403061f, 
    -0.01850044f, 0.09447517f, 0.03577264f, 0.10453589f, 0.02906062f, 0.09364121f, 0.04646952f, -0.09145825f, 
    0.20241444f, 0.47471842f, 0.23805065f, 0.18613675f, 0.05988996f, -0.06826391f, -0.11118328f, -0.17194290f, 
    -0.07172596f, -0.08064275f, -0.09044486f, 0.00917418f, -0.01615517f, -0.01268605f, -0.02613692f, 0.08003426f, 
    0.02647184f, 0.03751469f, -0.06179140f, 0.00889062f, 0.23722988f, -0.11433110f, 0.10040722f, 0.12802312f, 
    -0.04384914f, -0.06272490f, -0.00299774f, -0.02845758f, 0.00683525f, -0.00057952f, 0.20493785f, 0.09830271f, 
    0.08222446f, 0.14417954f, 0.05046950f, 0.01098030f, 0.09898648f, -0.03302664f, 0.03861632f, -0.10263368f, 
    -0.02756678f, -0.22121763f, -0.36181542f, -0.12557575f, -0.27131498f, -0.22716798f, 0.08838248f, 0.06802813f, 
    0.06256840f, -0.04874361f, 0.14581923f, 0.07093187f, -0.16972925f, -0.06607022f, -0.03527819f, -0.09950367f, 
    0.03157669f, -0.03555383f, -0.01686645f, -0.06851622f, 0.31413797f, -0.01801035f, -0.10661090f, -0.05181593f, 
    0.16117622f, -0.11294472f, 0.10686636f, 0.11342324f, 0.00202697f, 0.11252954f, -0.04815337f, -0.04089035f, 
    -0.03296693f, -0.09171973f, -0.08388212f, 0.08826277f, 0.05753081f, 0.02978191f, -0.15338537f, 0.00856294f, 
    0.00431862f, 0.05706678f, 0.05054019f, 0.12653342f, 0.06125895f, -0.02325138f, -0.06741409f, -0.04093318f, 
    0.07765009f, -0.10229139f, 0.04805375f, 0.08670113f, -0.00780357f, 0.01732708f, -0.02415877f, 0.03524642f, 
    0.07673147f, 0.00733925f, 0.09956273f, 0.06386293f, 0.26813620f, -0.29312611f, 0.17494604f, -0.01433898f, 
    0.15705290f, 0.05586237f, 0.09847623f, 0.02955274f, 0.14226082f, -0.09284043f, 0.16500236f, 0.04778084f, 
    -0.04083716f, -0.03409566f, 0.03695165f, 0.10717881f, 0.19958486f, -0.05730005f, -0.01125261f, -0.06198051f, 
    0.30397347f, 0.14504969f, 0.04621822f, 0.20546316f, -0.05554927f, 0.16799332f, -0.09186629f, 0.00765003f, 
    0.24297513f, 0.06463531f, -0.04278830f, -0.00470899f, -0.04870013f, -0.03542725f, 0.00415387f, 0.02558372f, 
    -0.09581715f, 0.07192650f, 0.00276081f, -0.01300754f, 0.11066671f, -0.05679280f, -0.20134950f, 0.08858376f, 
    -0.07298251f, -0.15291955f, 0.14599591f, 0.21323587f, 0.09876247f, 0.16701117f, 0.00174466f, -0.13999262f, 
    -0.10894677f, -0.08850650f, -0.04596280f, 0.03318360f, 0.06996948f, -0.06698991f, -0.02985188f, 0.00954427f, 
    0.09138498f, -0.24622998f, 0.01464035f, 0.06266355f, -0.07264826f, 0.01149962f, 0.05870413f, 0.02889622f, 
    -0.01939748f, -0.04797461f, 0.18524463f, 0.00355595f, 0.11058632f, 0.18622792f, -0.08178069f, -0.10310021f, 
    -0.02205296f, -0.11260998f, 0.04262770f, -0.06078674f, 0.44099995f, -0.06325854f, -0.42325515f, 0.21647514f, 
    -0.09786939f, 0.04377373f, 0.07395776f, -0.00255782f, 0.06863443f, 0.23077950f, 0.02938458f, -0.06324896f, 
    -0.04647305f, 0.08049499f, 0.05142491f, -0.10991503f, -0.04003870f, 0.00469087f, 0.13915731f, 0.19689038f, 
    0.12678441f, 0.16868049f, 0.14348128f, -0.08746006f, -0.25870001f, 0.07331957f, -0.26823103f, -0.08355027f, 
    0.12616765f, 0.01996664f, -0.10949139f, -0.04539577f, -0.02881184f, 0.02414453f, -0.01689658f, 0.06670410f, 
    0.13068701f, 0.05154897f, 0.20885500f, 0.13313217f, 0.09429297f, 0.20394503f, -0.06366594f, 0.18075089f, 
    0.09821323f, 0.03461505f, -0.08034760f, -0.00819100f, -0.01754176f, 0.03743136f, -0.08197105f, -0.09807606f, 
    0.02699691f, 0.03914219f, 0.07174219f, 0.00288979f, -0.01556053f, 0.05501169f, 0.03806403f, 0.17566594f, 
    0.12577090f, 0.62401056f, 0.07750730f, -0.00458909f, 0.05203913f, 0.05342314f, -0.27815980f, -0.16679573f, 
    0.14623201f, -0.11405781f, -0.03693464f, -0.13225217f, -0.03196599f, -0.09876154f, -0.00469756f, 0.18606530f, 
    0.09682824f, -0.12147591f, 0.07982419f, 0.01872781f, 0.02789221f, -0.01549784f, 0.24374966f, 0.00739651f, 
    -0.00527072f, -0.02285672f, 0.06753785f, 0.18935466f, 0.10061350f, 0.07346428f, 0.04017412f, -0.03456966f, 
    -0.10795806f, -0.22076175f, 0.05946847f, 0.30840108f, 0.08260589f, -0.02566134f, 0.07096639f, 0.07102606f, 
    -0.13031632f, 0.19660875f, -0.15725775f, 0.14636701f, -0.01707342f, 0.21635441f, -0.12493037f, 0.05285793f, 
    0.08598066f, 0.01835615f, -0.13416919f, 0.13890412f, -0.05784351f, -0.04719349f, 0.08620451f, 0.03450439f, 
    0.00635486f, 0.06002939f, 0.10220078f, 0.28562865f, -0.10664184f, -0.16997986f, 0.28961599f, 0.07518368f, 
    0.19855942f, -0.02366094f, -0.06856993f, -0.04966566f, -0.01649926f, 0.02922986f, 0.06337368f, 0.15241218f, 
    0.09333720f, 0.03927736f, 0.00965966f, 0.09982134f, -0.00900532f, -0.15852717f, -0.03486979f, 0.02465488f, 
    0.01566118f, 0.31845278f, 0.08999942f, 0.14119002f, 0.10653254f, -0.16307142f, -0.05753171f, -0.07033022f, 
    0.01178640f, 0.07511370f, -0.08284190f, -0.03492644f, -0.04277959f, 0.07353335f, 0.09786739f, 0.03412941f, 
    -0.01246431f, 0.08985496f, -0.15608779f, 0.03608033f, 0.48304436f, -0.02426878f, -0.05361407f, 0.18960765f, 
    -0.16439322f, -0.12506486f, -0.06251752f, -0.13951421f, 0.00878280f, 0.11218684f, -0.06021827f, 0.15974846f, 
    -0.06726664f, 0.11087650f, 0.18286899f, -0.05125296f, 0.13675675f, 0.00177406f, 0.19192511f, 0.01746334f, 
    0.29410973f, 0.13992085f, 0.12650691f, -0.08376979f, 0.15032062f, -0.08292578f, -0.03390091f, 0.03279331f, 
    -0.00758580f, 0.00408919f, -0.03225688f, 0.00281926f, -0.01151655f, 0.00703472f, 0.10193645f, 0.01331839f, 
    0.07977139f, 0.08172663f, -0.06392740f, -0.07104050f, 0.14397307f, -0.24426366f, 0.44384831f, 0.14273083f, 
    0.01244531f, -0.05649647f, -0.02245648f, -0.04380567f, -0.03663833f, -0.05926077f, 0.22232731f, 0.05530117f, 
    0.06867504f, 0.16195180f, 0.01868876f, 0.09691592f, 0.08791701f, -0.00417992f, 0.07304857f, -0.11600329f, 
    -0.04291346f, 0.07483111f, 0.25340369f, 0.03391284f, 0.04910466f, -0.05865768f, 0.04026137f, -0.03405520f, 
    0.05872467f, -0.11470240f, -0.03838649f, -0.12524532f, 0.00055070f, 0.00444872f, -0.04922755f, 0.08019815f, 
    0.02315717f, 0.07513364f, 0.07981057f, 0.12449611f, 0.61092818f, -0.18364891f, -0.09966838f, -0.30635846f, 
    0.19890483f, 0.16138570f, -0.16650078f, -0.06590918f, 0.24715650f, -0.08326300f, 0.02211902f, -0.03674262f, 
    -0.00775316f, 0.03174408f, -0.00179318f, -0.01884946f, -0.02016762f, -0.26743042f, -0.07873479f, -0.19465290f, 
    0.24752294f, 0.21705881f, 0.10343508f, 0.05903786f, 0.07983769f, 0.06268270f, 0.10277744f, 0.19188543f, 
    -0.01690549f, 0.07799971f, -0.02946020f, -0.07839817f, -0.02763320f, -0.18641295f, -0.00582653f, 0.06670030f, 
    0.07966866f, 0.02683806f, -0.05313595f, 0.08889055f, -0.01856072f, 0.05141948f, 0.04966052f, 0.03955147f, 
    -0.01967284f, -0.08586378f, -0.07438168f, -0.04335514f, -0.00295274f, -0.06456378f, 0.03544393f, 0.10518203f, 
    0.06995620f, 0.02768794f, 0.21617046f, -0.27885735f, 0.02927275f, -0.05989154f, -0.03062934f, -0.00295042f, 
    -0.02142243f, 0.12352694f, 0.15117945f, 0.08826504f, -0.13373607f, 0.10753255f, 0.13988623f, -0.03172761f, 
    0.04630185f, 0.03880196f, -0.03449262f, 0.01816428f, 0.01553770f, 0.07014418f, 0.16373175f, -0.02951936f, 
    0.05849763f, 0.15345730f, -0.05457568f, -0.03332628f, 0.06268986f, 0.16184643f, 0.16028276f, 0.08604202f, 
    0.00416560f, -0.13461259f, 0.02577373f, -0.05202295f, -0.03791926f, -0.07228458f, -0.05041672f, 0.01345011f, 
    0.02504499f, 0.05368075f, 0.07026705f, 0.09859969f, 0.12604213f, 0.03048512f, -0.00114715f, 0.00656102f, 
    0.24699073f, 0.19703382f, -0.19444726f, 0.22239263f, 0.01788777f, 0.09393239f, 0.01209884f, 0.24264961f, 
    0.03721789f, 0.12585986f, 0.06980368f, -0.08465626f, 0.03253979f, -0.02013027f, -0.02124309f, 0.01935999f, 
    0.13024066f, 0.05541972f, -0.11186365f, 0.03791963f, 0.23000762f, -0.02574103f, 0.00831466f, -0.13005304f, 
    0.13274622f, 0.16365165f, -0.03089935f, 0.04361717f, 0.04607176f, 0.11051203f, 0.09752840f, -0.01468545f, 
    0.04317198f, 0.11364235f, 0.07963187f, -0.10129901f, 0.00182883f, -0.11018531f, -0.00361118f, -0.05645666f, 
    -0.08756126f, 0.07602190f, -0.04679522f, 0.02899262f, 0.01447882f, 0.03254321f, 0.02422633f, -0.05891424f, 
    -0.03110560f, 0.01470763f, -0.05683150f, 0.00591032f, -0.04958954f, 0.10096776f, 0.03061794f, 0.00815785f, 
    0.04719559f, 0.10677099f, 0.01467622f, 0.13644505f, -0.05914851f, -0.34097546f, 0.27256376f, -0.04959771f, 
    -0.08296083f, -0.20462799f, 0.16065261f, -0.04611208f, -0.04413905f, 0.17371091f, 0.10561860f, -0.08188508f, 
    0.04405878f, 0.24165699f, -0.08969987f, 0.12417090f, 0.12851006f, 0.13035294f, 0.07698345f, 0.28246316f, 
    -0.01740387f, 0.65625072f, -0.51636553f, 0.13239557f, -0.15821296f, -0.09553497f, 0.02667067f, -0.01338133f, 
    -0.05816187f, 0.05481239f, 0.13185537f, 0.04352036f, 0.14636731f, -0.14891100f, -0.02510368f, 0.00104075f, 
    0.13772990f, -0.06843355f, -0.17764150f, -0.16534622f, -0.11360377f, -0.26700261f, 0.04045980f, 0.01437851f, 
    -0.23211356f, 0.17549616f, -0.10944227f, -0.22339182f, 0.05804223f, -0.17115982f, -0.01624502f, 0.03938782f, 
    -0.06786037f, -0.00201425f, -0.02884685f, -0.14937823f, -0.03702090f, -0.45271984f, -0.06749661f, 0.06541570f, 
    0.07890700f, 0.13193832f, -0.44365859f, 0.25518745f, 0.34951353f, 0.16486500f, 0.24916334f, 0.17173871f, 
    0.10265607f, 0.19232921f, 0.11111865f, -0.05542026f, -0.09537767f, -0.05425251f, -0.01113658f, 0.11759853f, 
    0.22912057f, 0.14419621f, -0.03349869f, 0.10397224f, -0.51737338f, -0.01084045f, -0.23499636f, -0.23928112f, 
    -0.04909535f, 0.02108490f, -0.11905875f, -0.04094660f, -0.04004066f, -0.06572085f, 0.07090017f, 0.05804703f, 
    0.00311377f, 0.09689305f, 0.06906351f, -0.19443096f, -0.18530302f, 0.12707101f, -0.04420276f, 0.09667251f, 
    0.48842743f, 0.50289810f, 0.33668119f, 0.29035008f, 0.16332173f, 0.08787052f, -0.25369394f, -0.03991860f, 
    0.08143028f, 0.05877985f, 0.12121210f, -0.00851437f, -0.02776217f, -0.02943242f, -0.00807086f, -0.06779419f, 
    -0.06804997f, 0.02042852f, -0.12069137f, -0.04760222f, 0.01241489f, 0.12698379f, 0.11478970f, 0.32277453f, 
    -0.27895871f, 0.13427776f, -0.05597428f, 0.04297699f, -0.11809212f, -0.13352647f, 0.01384149f, -0.02199494f, 
    -0.11587536f, -0.03410122f, 0.03997954f, -0.01572341f, 0.00672765f, -0.18378711f, 0.11570375f, 0.09723739f, 
    0.06608980f, -0.42673373f, -0.07915124f, -0.18788348f, -0.17005207f, 0.13870357f, 0.14457682f, -0.05201121f, 
    -0.14578055f, -0.00945039f, -0.10007182f, -0.09651691f, 0.01972037f, -0.10333834f, 0.03371783f, 0.14365740f, 
    -0.04791552f, -0.13635986f, -0.27486888f, -0.16975157f, -0.62881351f, 0.30534497f, -0.07596485f, 0.27428985f, 
    -0.33166745f, 0.12572165f, -0.11889298f, 0.00646772f, -0.01419092f, -0.02069055f, 0.03359599f, -0.13012336f, 
    -0.01656371f, 0.03446431f, -0.00008002f, 0.00814009f, -0.16108668f, -0.02473407f, -0.09473791f, -0.10309574f, 
    0.12764575f, -0.28375807f, 0.04732711f, -0.32970965f, 0.15775532f, -0.04190121f, 0.11720399f, 0.03045615f, 
    -0.08498913f, 0.12095226f, -0.09578025f, -0.00991977f, -0.12048085f, 0.04446955f, -0.02122355f, -0.14006884f, 
    0.05752665f, 0.00123739f, 0.04336970f, 0.14551304f, 0.11189522f, -0.05942003f, 0.15111142f, 0.01671826f, 
    0.07212944f, 0.11426211f, -0.03890163f, 0.00216951f, -0.04142284f, -0.04470183f, 0.09467590f, -0.00836821f, 
    -0.02354015f, -0.03402942f, 0.11543544f, 0.02837410f, -0.07031702f, 0.13300927f, -0.11370958f, -0.05069801f, 
    -0.27093938f, -0.19774543f, 0.03639677f, -0.35599142f, -0.05089102f, 0.10703506f, -0.17559808f, 0.06851861f, 
    -0.06722802f, -0.09579471f, -0.15934633f, 0.06520694f, 0.06280234f, -0.18083784f, 0.02462915f, 0.03992598f, 
    0.03447710f, -0.12728584f, 0.02336292f, 0.00956921f, -0.18671899f, -0.37574837f, 0.44037336f, -0.45676434f, 
    0.08104394f, 0.03002598f, 0.00119418f, 0.15551302f, -0.05741163f, -0.12514229f, -0.02608177f, -0.14370808f, 
    -0.01754809f, -0.09750308f, -0.06146858f, -0.09172212f, 0.00762038f, -0.05661473f, -0.01091316f, -0.11693329f, 
    0.08049890f, 0.31470147f, -0.05666688f, 0.45996636f, 0.21521460f, 0.03796703f, 0.42481491f, 0.15697722f, 
    0.04603505f, 0.33271220f, -0.02516964f, -0.03210948f, -0.15632617f, -0.15122156f, -0.17023459f, -0.03229335f, 
    -0.03205795f, 0.20824923f, -0.17802931f, -0.13230424f, 0.38433781f, 0.04772922f, 0.61019313f, -0.09876020f, 
    0.16339558f, 0.02261021f, 0.14045194f, 0.08688629f, 0.08237259f, 0.23283474f, -0.04902098f, 0.09086628f, 
    -0.08499854f, -0.09965671f, -0.09498648f, -0.02581116f, -0.03332810f, -0.02510825f, 0.17423832f, -0.17602271f, 
    0.17469896f, -0.07619572f, -0.11702815f, 0.47054413f, -0.10796147f, 0.05154411f, 0.27736762f, 0.12729007f, 
    0.02482288f, 0.37125033f, 0.00840826f, -0.02447015f, -0.10156183f, 0.02031532f, -0.03645811f, -0.02885604f, 
    0.19204904f, 0.01637585f, -0.06299073f, 0.33316731f, -0.03227799f, -0.08041044f, -0.28764769f, -0.10164511f, 
    -0.07128473f, -0.03823312f, 0.11205667f, -0.11798519f, 0.05915444f, 0.11354536f, -0.03715548f, -0.05992834f, 
    0.03720165f, 0.30577669f, 0.00225212f, -0.17288786f, 0.08707085f, 0.18966779f, 0.06301146f, 0.13804939f, 
    0.24214667f, -0.02944326f, 0.05952151f, 0.07764626f, -0.28828764f, 0.06584379f, 0.29159471f, -0.07280488f, 
    0.06935961f, 0.15215147f, 0.10986968f, -0.17980848f, -0.16476698f, -0.05675106f, -0.02861289f, 0.06995054f, 
    -0.14930846f, -0.08460496f, 0.05588372f, -0.21843474f, 0.13884403f, 0.43404838f, -0.33851451f, 0.09766266f, 
    -0.18617369f, -0.01627962f, -0.02676538f, -0.01199197f, 0.12245657f, 0.08828965f, -0.06068440f, -0.08452830f, 
    0.02428226f, -0.00371869f, -0.05792829f, -0.06361098f, 0.15755968f, 0.10569407f, -0.09709994f, 0.14351524f, 
    0.37260464f, 0.15475309f, 0.59366488f, 0.15449342f, 0.09374841f, 0.10944462f, 0.00438860f, 0.25355756f, 
    -0.01754843f, 0.20533474f, 0.18633229f, 0.02906490f, -0.01502809f, -0.09494533f, -0.04760242f, -0.06146282f, 
    -0.11268837f, -0.05305341f, 0.31630015f, -0.05616586f, -0.75550127f, -0.11348741f, 0.13580538f, -0.50994754f, 
    0.04021395f, 0.01244879f, -0.05409998f, 0.02635657f, -0.16444938f, -0.02505451f, 0.32620335f, -0.03219672f, 
    0.03089132f, -0.12323384f, 0.01219863f, 0.00389325f, -0.17218694f, 0.09373412f, -0.19607632f, -0.00109340f, 
    0.10238931f, -0.03304565f, 0.28325635f, 0.18288156f, -0.04309487f, 0.11778917f, 0.13959029f, 0.08327664f, 
    0.02098584f, 0.07534067f, 0.10294363f, 0.02583388f, -0.00076781f, 0.10637177f, -0.01169278f, 0.00623967f, 
    0.10054937f, -0.02062726f, 0.26982173f, 0.11631384f, -0.20588890f, 0.09864581f, -0.25899163f, -0.30597025f, 
    -0.19883294f, -0.07470749f, -0.08520357f, -0.13083375f, -0.06090381f, 0.19641815f, -0.01984810f, 0.05728946f, 
    -0.07053575f, 0.15061089f, 0.04931154f, -0.26208892f, -0.03242158f, 0.22271585f, 0.02417665f, 0.20238824f, 
    -0.02521507f, -0.17963912f, -0.24745417f, 0.12107336f, 0.09256772f, 0.07091669f, 0.09412879f, 0.18063445f, 
    -0.15800075f, 0.02973529f, 0.06966887f, 0.06234501f, 0.04861727f, -0.13842578f, 0.02056038f, -0.04374660f, 
    -0.03317370f, -0.17181900f, -0.17879263f, -0.18390182f, 0.27210382f, -0.05599533f, 0.48974603f, 0.07378000f, 
    0.28257230f, -0.12537324f, 0.21913891f, 0.00179822f, -0.09050801f, 0.09431068f, -0.05057683f, 0.05121488f, 
    -0.06969498f, 0.00412022f, -0.08887851f, 0.05798833f, 0.20945856f, 0.15650330f, 0.13840848f, 0.40141052f, 
    -0.14073385f, -0.19041069f, 0.03924979f, -0.06143154f, -0.03669930f, -0.06533293f, 0.06903782f, -0.12599680f, 
    0.00652600f, 0.03560686f, -0.04863637f, -0.09429113f, 0.02171624f, 0.22566761f, 0.04472060f, 0.05061056f, 
    0.05188347f, 0.14265946f, 0.05743842f, 0.02977189f, 0.16269711f, -0.00296136f, -0.18755311f, -0.13063478f, 
    0.38387367f, 0.16523151f, 0.20015572f, 0.13862869f, -0.03356629f, 0.12557003f, 0.16160433f, -0.02775405f, 
    0.13284308f, 0.19051568f, 0.02978101f, 0.36409542f, -0.05707390f, -0.07138770f, -0.25661996f, -0.05625027f, 
    0.11181550f, 0.01458536f, 0.07429282f, 0.17837508f, 0.18437721f, -0.05730384f, -0.15173517f, 0.04634928f, 
    0.04594956f, 0.22740179f, 0.01999895f, 0.00404455f, 0.08385066f, 0.00998500f, -0.07260575f, 0.26145169f, 
    0.14650975f, 0.14167148f, -0.02186330f, 0.18596384f, -0.21672490f, -0.36027643f, -0.36096388f, -0.13983056f, 
    0.14699563f, 0.33181566f, 0.13201149f, 0.15441088f, -0.11979492f, 0.04316344f, 0.08566313f, -0.04164127f, 
    -0.06992640f, 0.15450405f, 0.06137276f, 0.00536048f, 0.05494991f, -0.02734572f, -0.14038031f, -0.02782315f, 
    0.35130599f, -0.01031170f, 0.21335821f, -0.32646817f, -0.13290712f, -0.17687693f, -0.02752761f, -0.08757117f, 
    0.03526075f, 0.09422942f, 0.13713695f, -0.03057662f, -0.16254432f, -0.00052200f, -0.03585454f, -0.00862381f, 
    -0.17535418f, 0.09450527f, -0.11763187f, -0.11446550f, -0.01358681f, -0.06820658f, 0.04064981f, 0.04574315f, 
    -0.13797924f, -0.13969664f, 0.05549686f, 0.06698234f, -0.00427860f, 0.08402311f, -0.00361246f, 0.04864418f, 
    -0.06304230f, 0.07109839f, 0.05512132f, 0.11612073f, 0.19320114f, 0.19076839f, 0.19924794f, 0.30945125f, 
    -0.18734550f, 0.21741658f, -0.03325003f, -0.15684482f, 0.22312669f, 0.40156552f, 0.04299027f, 0.18372582f, 
    -0.03859664f, -0.12769441f, -0.15406525f, 0.16386710f, -0.06488075f, -0.12851086f, -0.00613600f, -0.03617626f, 
    -0.05255798f, -0.00485808f, -0.08274906f, -0.04018536f, -0.04391446f, 0.36004284f, 0.03093048f, 0.18292931f, 
    0.41413438f, 0.01683419f, 0.24242453f, -0.00378771f, 0.02286110f, 0.06515225f, -0.13588314f, 0.09345136f, 
    0.02515268f, -0.01265909f, -0.03708070f, 0.06278384f, -0.07248825f, -0.05909625f, 0.11045169f, 0.11411976f, 
    -0.14953503f, -0.26445192f, 0.46095964f, 0.05505326f, 0.03788137f, -0.12849256f, -0.14857040f, 0.13503189f, 
    0.11829831f, 0.22657084f, -0.06970402f, -0.09742650f, -0.13484529f, 0.11935883f, 0.05201067f, 0.02019983f, 
    -0.08459934f, 0.27937129f, -0.10875225f, -0.08296261f, -0.13776450f, -0.30448371f, 0.25520077f, -0.00650273f, 
    0.00183229f, -0.06104767f, -0.12431827f, -0.01388301f, -0.03673344f, 0.00418815f, -0.01182677f, 0.02961061f, 
    0.03881397f, 0.05105501f, -0.09711205f, 0.01075826f, 0.03568668f, 0.08427423f, -0.13595165f, -0.02441355f, 
    0.56293297f, -0.06308991f, 0.17809080f, -0.02512528f, -0.00669284f, -0.07355479f, -0.18151109f, -0.16726404f, 
    0.06596629f, -0.00387930f, 0.07183602f, 0.05763021f, -0.00652610f, 0.01724855f, 0.05896937f, 0.08397675f, 
    -0.01312332f, 0.09180304f, 0.12721984f, 0.02163337f, -0.05692351f, -0.07285487f, -0.14275254f, 0.03037813f, 
    -0.14676026f, 0.03197657f, 0.00105840f, -0.03983720f, 0.05803468f, 0.00174111f, -0.10317036f, -0.08447005f, 
    -0.06223421f, -0.23573963f, 0.04844565f, -0.08072512f, 0.01041554f, -0.05976287f, 0.05023004f, -0.05044786f, 
    0.26312995f, 0.02735037f, -0.04616516f, 0.06600981f, 0.30174279f, 0.23795699f, 0.15968838f, 0.11353760f, 
    0.05532090f, -0.08841673f, -0.20738597f, 0.11051561f, -0.03365933f, 0.04269433f, -0.03682046f, -0.03138564f, 
    -0.03897506f, -0.05424881f, -0.05840533f, 0.02206137f, 0.05924158f, 0.30403686f, 0.31308243f, 0.08377310f, 
    0.46733877f, -0.07875894f, 0.14972721f, 0.03916052f, -0.12090167f, -0.07379578f, -0.05969127f, 0.15801799f, 
    0.03476172f, 0.07547362f, -0.04213505f, -0.14149019f, 0.13337477f, 0.04271099f, 0.00662851f, -0.00903384f, 
    -0.16581146f, -0.10715102f, -0.02624264f, 0.12110592f, -0.06238598f, -0.10286657f, -0.11133616f, -0.00652054f, 
    -0.07623007f, -0.02282623f, -0.05347144f, 0.07370934f, -0.04416639f, 0.06956057f, 0.03536804f, 0.06417769f, 
    0.00397322f, 0.01062455f, 0.08706148f, -0.10904676f, 0.17413157f, -0.38592774f, 0.44819373f, 0.06174896f, 
    0.04979070f, 0.08137279f, -0.10633364f, -0.02281682f, -0.08218709f, 0.00073865f, -0.06429884f, -0.01581895f, 
    -0.01028772f, 0.00860425f, -0.08408169f, 0.00388871f, 0.09438171f, 0.07694317f, -0.09725960f, 0.10419824f, 
    -0.47608364f, 0.72903979f, -0.20560685f, 0.34795225f, -0.12380184f, -0.15767999f, -0.12199180f, -0.24277103f, 
    -0.07953309f, -0.08145336f, -0.00710299f, 0.05507135f, -0.01129533f, 0.11486290f, 0.06388025f, 0.10820909f, 
    0.09573669f, 0.03418856f, 0.20430654f, 0.07345366f, -0.13584441f, 0.12229706f, 0.13229333f, 0.18045254f, 
    0.15810058f, 0.16205235f, 0.22022724f, 0.14334148f, -0.04253045f, -0.19111159f, -0.16579916f, 0.07742716f, 
    0.00681352f, -0.04164448f, -0.03038632f, 0.05280502f, -0.01876225f, 0.00138432f, -0.02751953f, -0.04510546f, 
    0.28204542f, -0.28138557f, 0.01742480f, 0.12564637f, -0.02019585f, -0.18055986f, 0.04770763f, -0.13464729f, 
    -0.04201174f, -0.02866752f, 0.07802296f, -0.10702825f, -0.09736371f, -0.05890724f, 0.04961338f, -0.02184492f, 
    0.04700237f, 0.01197772f, 0.02580572f, 0.06216682f, -0.13638489f, 0.55175078f, -0.34415734f, 0.33430395f, 
    0.17335232f, -0.07885628f, -0.03955146f, -0.00649908f, 0.13880511f, -0.01851360f, -0.00969666f, -0.05850336f, 
    0.04771944f, -0.07057803f, -0.06741664f, 0.15905325f, -0.02220191f, -0.02145532f, 0.12003191f, 0.07010264f, 
    -0.19303896f, 0.09059490f, 0.52847219f, -0.09154195f, 0.27039158f, 0.05274247f, -0.03922394f, 0.12483620f, 
    0.06943139f, 0.24377668f, -0.05564862f, 0.02085025f, -0.06993974f, 0.04497812f, 0.00018451f, -0.04202836f, 
    -0.08558818f, 0.06428835f, -0.06202492f, 0.26550147f, 0.17165828f, 0.49348843f, -0.06091766f, 0.25100252f, 
    0.19068736f, 0.05635279f, 0.16293031f, 0.01350860f, -0.03726604f, -0.03374644f, -0.00191125f, 0.00794331f, 
    -0.04489953f, 0.02741260f, 0.00530657f, 0.03833710f, -0.00345540f, -0.15818548f, 0.10363271f, 0.08251859f, 
    0.00635734f, -0.26753345f, 0.55428874f, 0.20666108f, 0.15255527f, -0.03076044f, -0.25269750f, -0.17836054f, 
    0.06834236f, 0.26534188f, 0.01194550f, 0.02388858f, -0.08914014f, 0.08986221f, 0.08224195f, 0.28072777f, 
    -0.17597586f, 0.14808160f, -0.03777234f, 0.05582451f, -0.07956640f, 0.10080393f, 0.40566173f, -0.03870641f, 
    -0.07375533f, 0.09520926f, 0.11298413f, 0.01938895f, -0.09471323f, -0.03746124f, -0.11169223f, 0.09898511f, 
    0.00954791f, -0.00674833f, 0.08768059f, -0.14181642f, 0.05510270f, -0.07619072f, 0.00562146f, 0.01935633f, 
    -0.13313065f, 0.10328123f, 0.47852823f, -0.00207868f, 0.23737761f, -0.00029229f, 0.19022971f, -0.08688750f, 
    -0.03375026f, -0.00437120f, 0.12769736f, -0.03111387f, 0.02291569f, 0.03442850f, 0.08509172f, 0.01115501f, 
    0.02180654f, 0.00604057f, 0.01496737f, -0.05380706f, 0.24832000f, 0.04931846f, 0.13198577f, 0.17163882f, 
    0.03504464f, 0.06302910f, -0.01825332f, 0.16894749f, -0.09694075f, 0.08582222f, -0.08730552f, -0.14365025f, 
    -0.01774225f, 0.03474630f, -0.16355151f, 0.04389792f, 0.00246013f, 0.17125481f, -0.07784816f, 0.07027994f, 
    0.13821292f, 0.44277084f, 0.04148351f, -0.01337782f, 0.23341399f, 0.17292741f, 0.19079816f, -0.04167134f, 
    0.02855226f, 0.03248955f, 0.02467728f, 0.07058024f, -0.03830008f, 0.01132313f, 0.00471694f, -0.01326061f, 
    -0.03676625f, -0.06332099f, -0.08954518f, 0.07274079f, 0.19706312f, 0.35709018f, -0.37310052f, 0.40764034f, 
    -0.12111753f, -0.02665076f, 0.00887758f, -0.02166595f, 0.04291254f, 0.02232588f, 0.02526143f, -0.13493043f, 
    -0.04556419f, -0.16995999f, -0.08217753f, 0.07327345f, -0.10779837f, 0.12758239f, 0.09006405f, -0.18564227f, 
    -0.39423522f, 0.23174393f, 0.23856328f, 0.15062293f, 0.20786384f, 0.06363566f, 0.39058340f, -0.00236999f, 
    0.05974123f, 0.25140595f, -0.09000377f, 0.05971117f, -0.03443538f, -0.04747409f, -0.03527100f, -0.09534787f, 
    -0.06912469f, -0.04411167f, -0.12032059f, -0.00202241f, 0.05879188f, 0.14771992f, -0.17271516f, -0.06833515f, 
    -0.25026476f, 0.08645961f, 0.06002260f, -0.03233368f, 0.03570418f, 0.01417858f, -0.08767877f, -0.07804270f, 
    0.00554062f, -0.16465211f, 0.10963930f, -0.03143135f, -0.05508801f, -0.08534640f, 0.17416692f, -0.04435415f, 
    -0.19101168f, -0.26094946f, 0.41469523f, -0.00550229f, -0.05009973f, 0.01694669f, -0.14497519f, -0.07826702f, 
    -0.01084706f, -0.04258882f, -0.06470044f, 0.09633146f, -0.03652791f, 0.09338364f, 0.08380455f, 0.17048697f, 
    -0.18482502f, 0.13683526f, -0.14035571f, -0.04521816f, -1.10438907f, 0.63667732f, -0.00855982f, 0.50491095f, 
    0.07846677f, -0.14250167f, -0.15575065f, 0.22785017f, -0.03920088f, 0.02553788f, -0.06368561f, 0.11110580f, 
    -0.09988329f, -0.05505547f, 0.01311501f, -0.01614550f, 0.01670658f, 0.15401180f, 0.17365584f, 0.29912001f, 
    -0.10096298f, 0.25376636f, 0.16209070f, 0.11904623f, 0.24757303f, 0.16001858f, 0.17844327f, 0.02545870f, 
    -0.14397442f, 0.02796310f, -0.04448458f, 0.10231096f, 0.00455479f, -0.09178595f, -0.00001720f, -0.01818828f, 
    -0.00326573f, -0.11295836f, 0.06250241f, 0.05162517f, 0.10616145f, 0.02116976f, -0.02367694f, 0.06449238f, 
    0.10134250f, -0.02248433f, -0.02104452f, -0.01308753f, -0.04517047f, 0.00399711f, -0.13486263f, 0.03438744f, 
    0.10514127f, -0.04624378f, -0.06105649f, 0.07523055f, -0.06387410f, 0.01715158f, -0.11583031f, -0.16580565f, 
    0.09504521f, 0.06847685f, 0.22773938f, -0.01842347f, 0.13927533f, -0.01571666f, 0.04875802f, 0.21962506f, 
    0.09936753f, 0.06936671f, -0.08064566f, 0.00809503f, -0.02604894f, -0.08944421f, -0.18360436f, -0.04360130f, 
    -0.15318730f, -0.18072557f, 0.01948816f, 0.06445196f, 0.06532428f, -0.22073293f, -0.20106772f, 0.02132938f, 
    -0.03328961f, -0.01464976f, -0.10741165f, 0.00132026f, 0.08822257f, -0.09884820f, -0.01083263f, 0.06846269f, 
    0.03803127f, -0.04942949f, 0.02441076f, -0.01968962f, 0.00338083f, 0.06189145f, 0.06714957f, -0.15505166f, 
    -0.13627250f, 0.38913444f, 0.16248690f, 0.17750908f, 0.27237275f, 0.25355726f, -0.00483943f, -0.04615664f, 
    -0.01377525f, -0.07249840f, -0.11248028f, -0.08571126f, -0.03485180f, 0.00698187f, -0.01714810f, -0.00537285f, 
    -0.02785579f, -0.07116083f, 0.26308241f, -0.11646886f, -0.34893388f, 0.10952134f, 0.26610807f, 0.04766215f, 
    -0.00207690f, -0.01188796f, 0.12622170f, 0.08144025f, -0.17946804f, 0.03989037f, -0.08786527f, 0.01442755f, 
    0.05030232f, -0.16805354f, -0.00913973f, -0.02906687f, 0.04312195f, -0.15950547f, -0.06314393f, 0.07747332f, 
    0.46279582f, 0.39240226f, 0.00707252f, -0.54442251f, -0.09073992f, -0.04534386f, -0.18528551f, -0.01014118f, 
    0.04131654f, 0.13816284f, -0.10649778f, 0.08932956f, 0.01553101f, -0.05884434f, -0.04128149f, -0.02951052f, 
    0.02184603f, -0.10989396f, 0.04535498f, 0.01170910f, 0.20180811f, -0.07495300f, 0.08392771f, 0.00595500f, 
    0.16912535f, -0.03678611f, 0.15230696f, -0.09997004f, 0.35238558f, 0.08791906f, -0.07018686f, -0.04861374f, 
    -0.04706177f, -0.09196267f, 0.08277157f, -0.06231875f, 0.02106876f, -0.03346128f, 0.10420791f, -0.11249723f, 
    0.18287471f, -0.10874348f, -0.06017519f, 0.10891405f, -0.13710774f, 0.02646657f, 0.17297596f, 0.27103844f, 
    0.07786234f, -0.01948152f, 0.09009751f, -0.08477152f, 0.07190286f, -0.16371168f, 0.10648876f, 0.02391323f, 
    -0.08517093f, 0.08156595f, -0.12687431f, -0.07899080f, 0.04279595f, 0.15501565f, -0.09326548f, -0.10165701f, 
    -0.06511205f, -0.09699791f, 0.00843979f, -0.15292543f, -0.09675203f, 0.08486076f, 0.01908543f, 0.00100130f, 
    -0.04711446f, 0.13248515f, -0.12764075f, 0.03207769f, 0.00842387f, 0.14741291f, -0.00954927f, 0.01369701f, 
    0.00492498f, 0.10711022f, 0.10036875f, 0.07235999f, -0.18357702f, -0.18568717f, -0.04448773f, -0.00640212f, 
    -0.09874510f, -0.05238030f, 0.10706165f, -0.00096232f, 0.09988115f, 0.00972805f, 0.00421284f, -0.07049801f, 
    -0.03144994f, -0.04719700f, 0.03876124f, -0.01659027f, 0.14762644f, 0.11043600f, -0.03230963f, -0.07665280f, 
    -0.00391312f, 0.06177906f, 0.09061281f, 0.03033902f, 0.06967340f, 0.01126943f, -0.02487666f, 0.06521125f, 
    0.03849429f, -0.00073439f, -0.01738423f, -0.14866349f, -0.05952844f, -0.10642667f, 0.01986158f, 0.06868820f, 
    0.06425564f, 0.09684052f, 0.06431440f, -0.24801806f, -0.10801621f, 0.04327926f, -0.07110016f, 0.04824165f, 
    -0.02887956f, 0.07744544f, -0.18543899f, 0.06033674f, 0.08054296f, 0.01615653f, -0.03230126f, 0.04114541f, 
    -0.00916420f, 0.03806103f, 0.04746005f, -0.02283564f, 0.36805153f, -0.22731055f, 0.17867719f, -0.40195757f, 
    0.22585116f, 0.06540099f, -0.19361579f, 0.12970848f, 0.00730816f, 0.08633785f, -0.17898487f, 0.00658708f, 
    -0.01784865f, -0.01295282f, -0.03531273f, -0.04473452f, 0.06306338f, 0.00433149f, -0.00375457f, -0.02658857f, 
    0.04380447f, 0.05073865f, 0.12604548f, 0.01501156f, 0.14491400f, -0.11185177f, 0.04262576f, -0.15291451f, 
    0.02726274f, 0.08922098f, -0.02500084f, 0.02902530f, -0.03871261f, -0.10967171f, 0.10732985f, -0.08081324f, 
    0.01155544f, 0.01924526f, 0.13201882f, 0.07000395f, 0.46860650f, 0.23171496f, -0.17918198f, -0.16010953f, 
    -0.32005930f, -0.31387392f, 0.07751364f, 0.11586576f, -0.22645470f, 0.04174753f, 0.05815435f, -0.01787564f, 
    0.04685098f, -0.03898359f, -0.06176115f, 0.06172198f, -0.03181802f, 0.02198315f, -0.06380954f, -0.00883976f, 
    -0.00424965f, 0.15344471f, 0.28935999f, -0.08663713f, 0.13728441f, 0.11901978f, -0.03562909f, 0.08674879f, 
    -0.05332137f, -0.06832104f, 0.04685635f, 0.07738670f, -0.00641021f, -0.01833663f, -0.02525043f, -0.14309129f, 
    0.09739371f, -0.13043845f, -0.04072005f, -0.02432624f, 0.19893786f, -0.00940134f, 0.01563748f, -0.28228000f, 
    0.19866399f, -0.06422509f, 0.05163451f, 0.01027387f, 0.22916529f, -0.06473564f, -0.14179869f, 0.10958441f, 
    -0.00401074f, -0.00295388f, -0.08216612f, -0.02581578f, -0.00257436f, 0.06097013f, 0.07729037f, 0.00020299f, 
    0.16355647f, 0.19964987f, -0.34716755f, -0.04792057f, 0.15799735f, -0.07234161f, 0.00718864f, 0.01860458f, 
    0.10191687f, 0.00351302f, 0.18516165f, 0.03603132f, 0.02758611f, 0.00227875f, -0.00154657f, 0.03405060f, 
    -0.06882626f, 0.00390651f, -0.01708670f, -0.03043950f, -0.06434025f, 0.12799717f, 0.19268052f, -0.14739577f, 
    0.25364158f, -0.01464020f, -0.07556940f, 0.18312043f, -0.03674083f, -0.11838263f, 0.03785180f, 0.05968803f, 
    0.19894215f, -0.00830459f, 0.04442218f, 0.07952829f, -0.04294213f, 0.06041430f, -0.08210851f, -0.08834460f, 
    -0.34161395f, -0.46654901f, 0.02989554f, 0.17693801f, 0.03958362f, -0.23627558f, 0.24255955f, 0.07762413f, 
    -0.03811600f, -0.03350269f, 0.07163171f, -0.03777659f, 0.05009479f, -0.00536359f, -0.00557211f, -0.01520671f, 
    -0.00107948f, -0.04691705f, 0.10283061f, -0.10317817f, -0.41999012f, -0.14134482f, -0.26488039f, 0.16873455f, 
    0.26841214f, -0.22022232f, 0.16835301f, -0.01069425f, -0.01766941f, -0.17292570f, 0.01505943f, -0.03350793f, 
    0.01235698f, -0.02499677f, 0.06191396f, -0.04464067f, 0.00032248f, -0.01212369f, -0.00317146f, 0.07973189f, 
    -0.08425251f, 0.01852280f, 0.13596417f, -0.05040897f, 0.01593758f, -0.15782279f, 0.23089914f, -0.09032684f, 
    -0.06239075f, 0.14829540f, -0.00089213f, -0.02563483f, -0.00360106f, 0.06161731f, -0.04064885f, -0.07370046f, 
    0.02484566f, 0.01952410f, 0.11158283f, -0.01720778f, 0.23904273f, -0.33143058f, -0.29499829f, -0.22038619f, 
    0.29131436f, 0.16282360f, 0.11499638f, 0.13315456f, 0.22743480f, 0.13639034f, -0.06656753f, 0.05504065f, 
    -0.13186195f, -0.01460614f, 0.05013224f, -0.04687373f, -0.02064637f, -0.15794270f, 0.09112559f, -0.02226786f, 
    -0.06416999f, -0.09721938f, 0.07463250f, 0.19265270f, 0.13923608f, -0.12382630f, 0.13103385f, -0.04610945f, 
    -0.06448121f, -0.03761222f, -0.05890999f, -0.00892672f, 0.01122036f, 0.11003193f, 0.00946564f, -0.04734794f, 
    0.05465505f, -0.00867910f, -0.02306151f, 0.08376741f, 0.03214063f, -0.20091444f, 0.25225076f, 0.00727059f, 
    -0.36129096f, -0.05818677f, 0.00834350f, 0.17286153f, -0.03885987f, 0.00108211f, -0.02469496f, -0.06082194f, 
    -0.02697365f, 0.00986477f, -0.05124524f, -0.19977461f, 0.09124622f, 0.07636925f, -0.01705483f, 0.06256614f, 
    -0.17078130f, -0.23359619f, -0.20991038f, 0.25973576f, 0.36006802f, -0.06620215f, 0.20247732f, -0.10267406f, 
    0.12623248f, 0.09048388f, -0.03609531f, -0.04247520f, -0.01211777f, -0.03701913f, 0.01623761f, -0.01303882f, 
    0.03256206f, -0.02911987f, 0.18064153f, 0.07914118f, 0.10086606f, 0.13506085f, 0.35551557f, 0.03030537f, 
    -0.17441258f, 0.18182208f, 0.04872559f, 0.08459037f, -0.11545117f, -0.19879249f, 0.02047547f, 0.17770214f, 
    0.32461366f, -0.02014786f, -0.12335172f, -0.05327867f, -0.18979280f, -0.00815538f, -0.05405250f, -0.00685390f, 
    -0.21637544f, -0.03246331f, -0.22973788f, 0.22621782f, 0.43746990f, -0.02399887f, 0.18802345f, -0.12534830f, 
    0.04777543f, 0.04031565f, -0.08870806f, -0.08369789f, -0.10150243f, 0.00724012f, 0.03745563f, -0.02733829f, 
    0.02438879f, -0.11775970f, 0.11203746f, -0.00433058f, 0.02349919f, 0.08841820f, -0.04733803f, 0.02798171f, 
    -0.02415888f, 0.07174973f, 0.02711799f, 0.04896415f, 0.00858516f, -0.02810015f, 0.21308255f, 0.11630470f, 
    0.07620579f, 0.04333552f, -0.05385790f, -0.10738868f, -0.16223279f, -0.14348435f, 0.01705666f, 0.08604800f, 
    0.05573432f, -0.25022691f, -0.16617513f, -0.10703105f, -0.01088814f, 0.20318578f, -0.03454393f, 0.25214443f, 
    -0.06782311f, 0.17469850f, 0.03967385f, 0.03714750f, -0.00304849f, -0.01357534f, -0.06918019f, -0.04611164f, 
    0.07429239f, -0.00761876f, 0.14464170f, 0.01480941f, -0.01959560f, 0.03730099f, 0.15882652f, 0.08940560f, 
    0.07476686f, -0.08564914f, 0.20648928f, -0.13600640f, 0.10142645f, 0.04839927f, -0.05306494f, 0.02567490f, 
    -0.01472448f, -0.05171880f, -0.07129618f, -0.05144798f, 0.00238060f, -0.03940347f, 0.00201835f, -0.06578901f, 
    0.10032139f, -0.28480881f, -0.17529835f, -0.14020935f, 0.28529137f, -0.05733871f, 0.04118692f, -0.00829964f, 
    0.22784978f, 0.02732903f, -0.04683961f, 0.03689943f, -0.04211302f, -0.03856685f, -0.00607554f, -0.01815704f, 
    0.01062257f, -0.05173966f, 0.03832807f, -0.03879777f, 0.02754893f, 0.00107920f, 0.11316888f, -0.07947190f, 
    -0.07885175f, 0.02318869f, -0.03947533f, 0.05506711f, -0.05703915f, -0.07650125f, 0.13156973f, -0.03237385f, 
    0.06537132f, -0.07223726f, -0.04827394f, 0.01673689f, -0.05827126f, 0.00114213f, 0.07371971f, 0.01140931f, 
    -0.05176883f, -0.16134240f, -0.06202179f, 0.28091714f, 0.09630135f, -0.02225059f, 0.21309614f, 0.13791005f, 
    0.10387393f, -0.06955315f, -0.06660340f, -0.10720225f, -0.08427537f, 0.01126060f, -0.04040619f, -0.07433514f, 
    -0.03439619f, 0.03399009f, -0.06626008f, -0.06351600f, 0.16367933f, 0.06506519f, 0.06160896f, 0.08698829f, 
    -0.04133601f, -0.04314261f, -0.06601989f, -0.04601474f, -0.01997798f, -0.01895163f, 0.13592637f, 0.02555887f, 
    -0.00345881f, -0.02050486f, -0.04965069f, -0.05716375f, -0.09766242f, -0.02379869f, 0.06578583f, 0.01958800f, 
    -0.27672189f, 0.13850050f, 0.35832050f, -0.09557956f, 0.14690302f, 0.04320318f, 0.09476041f, -0.04110188f, 
    0.01537226f, -0.15599871f, -0.02543795f, 0.00745329f, 0.08576479f, 0.03881948f, 0.01256732f, -0.08068893f, 
    0.06930197f, -0.00233197f, -0.00402605f, 0.10017844f, -0.06592063f, -0.12538213f, -0.09678905f, -0.00567110f, 
    0.23807074f, 0.03943882f, 0.07101336f, -0.10639563f, 0.13520493f, 0.12421311f, -0.09048238f, -0.01121008f, 
    -0.16439570f, -0.01111432f, -0.01285203f, 0.05187240f, -0.00094520f, -0.12335394f, 0.09777507f, -0.12492453f, 
    -0.00766492f, -0.02517082f, -0.02084151f, 0.01344559f, -0.03899905f, -0.00401398f, -0.04284411f, -0.00731329f, 
    0.00358032f, -0.00650853f, -0.03977486f, 0.00878183f, -0.00094180f, -0.03551182f, 0.00681005f, -0.03635521f, 
    0.01162479f, 0.03162000f, 0.02841464f, 0.02266757f, 0.01512359f, 0.02423639f, -0.00888879f, 0.03857138f, 
    0.00832717f, -0.02862675f, -0.00396616f, 0.01288879f, 0.03534861f, 0.01405699f, -0.01807493f, 0.00364038f, 
    -0.03312182f, 0.02321204f, -0.00162483f, -0.01829444f, 0.02831192f, -0.03452515f, 0.01542831f, -0.02426347f, 
    0.02900508f, -0.01732731f, -0.00327251f, 0.01409108f, -0.04467945f, 0.02912212f, -0.04446435f, -0.02923497f, 
    0.01100669f, 0.01036455f, -0.04402326f, 0.02991929f, 0.02756131f, 0.02542174f, -0.00322333f, -0.03399905f, 
    -0.00744492f, 0.03184991f, 0.01589428f, -0.01549571f, -0.03485679f, -0.00038802f, -0.01817385f, -0.00241153f, 
    -0.01161952f, -0.02270805f, 0.00211982f, -0.04361743f, -0.00496126f, 0.02601004f, -0.00319212f, 0.02226510f, 
    -0.04838254f, -0.02379739f, -0.00663402f, 0.01895922f, -0.00496074f, -0.03692271f, -0.01577583f, -0.00888253f, 
    -0.00825414f, 0.00207619f, 0.02569843f, -0.03881621f, -0.01877440f, 0.03516728f, -0.00511546f, -0.02525882f, 
    0.02830430f, -0.00158884f, 0.02608359f, -0.01521570f, -0.01180949f, 0.01249183f, 0.02498018f, -0.02298816f, 
    0.00613655f, 0.02838208f, 0.01372111f, 0.00272533f, 0.02476412f, 0.00794188f, 0.01212600f, 0.02703468f, 
    0.00865053f, 0.02423802f, 0.03390272f, -0.01377949f, 0.02609250f, -0.03683918f, 0.01753046f, -0.04682214f, 
    0.03149037f, -0.02940076f, -0.03392208f, 0.03059503f, 0.02320875f, -0.00481129f, -0.03434800f, 0.00433843f, 
    -0.00715689f, -0.00269963f, -0.03093930f, -0.00846538f, 0.01156861f, -0.03786081f, -0.01308995f, -0.02957754f, 
    -0.04319847f, -0.01625877f, -0.00540027f, 0.01324910f, -0.04319406f, 0.02063391f, 0.00862792f, 0.00925731f, 
    0.03947430f, 0.02284725f, 0.02552208f, -0.01281079f, -0.00197837f, 0.01847437f, -0.04287744f, 0.03176596f, 
    0.02042568f, 0.00729377f, -0.03377372f, -0.01697730f, 0.00018914f, 0.00063748f, -0.02656739f, 0.01376712f, 
    -0.00107269f, -0.03128055f, 0.03319944f, -0.02428909f, 0.01050157f, -0.01085685f, -0.00642828f, 0.01548370f, 
    -0.00439219f, -0.02368491f, -0.01098166f, -0.00266577f, -0.00490380f, -0.02257706f, 0.00843225f, 0.01552580f, 
    -0.04799957f, -0.02617369f, 0.01892223f, -0.00761397f, -0.04138990f, -0.04281051f, -0.04066757f, -0.04299041f, 
    -0.03718592f, -0.00556425f, 0.01320464f, 0.02923908f, -0.03651601f, 0.00507662f, -0.00830568f, 0.00492276f, 
    -0.04077703f, -0.04755867f, -0.02228491f, -0.01525208f, 0.01219050f, 0.03475205f, 0.02157246f, -0.02589044f, 
    0.01867992f, 0.02533580f, -0.02810433f, -0.03691990f, 0.02532589f, -0.02959990f, 0.02320253f, -0.00376430f, 
    -0.00765308f, 0.01087016f, 0.01841035f, -0.03065058f, 0.02192618f, 0.01009247f, 0.02219852f, 0.02982550f, 
    0.03058766f, -0.00737896f, -0.02962197f, -0.03855649f, -0.01616245f, 0.03285842f, -0.00652377f, -0.02425627f, 
    0.01313158f, -0.02719771f, 0.00674771f, -0.01214562f, -0.02650595f, 0.03158312f, -0.03659502f, -0.03585749f, 
    0.00156180f, 0.01696257f, -0.02891945f, 0.01762563f, 0.00552451f, -0.04251352f, -0.01637655f, 0.01047375f, 
    0.02843649f, 0.01209000f, -0.02265254f, -0.03361303f, 0.01434726f, 0.01121346f, -0.04270444f, 0.02871666f, 
    -0.03035920f, -0.04070587f, 0.02220963f, -0.04164742f, -0.04092905f, -0.03955582f, 0.03946640f, -0.02873188f, 
    0.02362212f, 0.02256403f, -0.00403448f, -0.03688767f, -0.03678770f, -0.02275829f, -0.02467718f, -0.00720760f, 
    0.00361309f, -0.00216078f, 0.00886434f, -0.03501415f, -0.02232817f, 0.01113501f, -0.03413137f, 0.00472274f, 
    0.02626356f, -0.04197458f, -0.03747291f, -0.03857052f, 0.00013308f, -0.03329516f, -0.02090022f, 0.00441781f, 
    -0.02758643f, -0.03860907f, 0.00109352f, 0.02913491f, -0.00777833f, 0.02545416f, 0.03316798f, 0.02284452f, 
    -0.02260960f, -0.04250751f, -0.03250107f, -0.00952737f, -0.03197091f, -0.00997377f, 0.01946390f, -0.02793766f, 
    0.01842392f, 0.00494782f, 0.01290340f, -0.02580147f, 0.00475605f, 0.03215791f, 0.01408370f, -0.01559991f, 
    -0.01746193f, 0.00480342f, 0.01740406f, 0.02957149f, -0.01426030f, 0.03108069f, -0.03817704f, -0.04015557f, 
    -0.00888828f, -0.03214025f, 0.01751271f, 0.01407210f, -0.04025608f, 0.02128926f, -0.01413065f, -0.00827715f, 
    -0.04489773f, -0.00311101f, 0.02613718f, -0.03565665f, 0.02179080f, 0.01238838f, -0.03869637f, -0.02908276f, 
    0.01972639f, 0.01001567f, 0.02112407f, 0.00804493f, -0.04189760f, 0.02914697f, 0.02497404f, 0.03548068f, 
    -0.00864666f, 0.00886901f, -0.03562566f, 0.00634901f, -0.04494758f, -0.01350274f, -0.00284330f, -0.01107543f, 
    -0.01568236f, -0.02370003f, 0.00008143f, 0.04356724f, -0.00463203f, 0.02831138f, -0.00980691f, 0.01608398f, 
    0.02347945f, -0.01056451f, 0.02105570f, -0.03762130f, -0.01846184f, -0.02700304f, 0.01698279f, 0.00910932f, 
    0.03536096f, -0.03319387f, -0.00230745f, -0.01434047f, 0.03521252f, 0.02880550f, -0.02036875f, 0.02606349f, 
    -0.03573633f, -0.01799819f, 0.02257163f, -0.00107201f, -0.04165129f, 0.02287907f, -0.00434896f, -0.04396335f, 
    0.03031964f, 0.02667201f, 0.00370662f, 0.02092118f, -0.00855073f, 0.00143802f, -0.01883386f, -0.00314620f, 
    -0.02927923f, 0.02214148f, -0.03422642f, 0.01741417f, -0.00452764f, -0.02451571f, 0.02905648f, -0.00047425f, 
    0.00122036f, 0.01965673f, -0.03103030f, 0.01184913f, -0.01541908f, 0.01295901f, -0.02003012f, 0.00041618f, 
    -0.03259993f, -0.04803246f, -0.00238554f, 0.02034012f, -0.03586875f, 0.00518703f, 0.03737370f, -0.00014460f, 
    -0.02871514f, -0.03605471f, 0.00951861f, -0.00637574f, 0.00278933f, -0.01307067f, -0.02840524f, -0.01029997f, 
    0.01508055f, -0.02494271f, 0.02463709f, -0.03505437f, -0.03478460f, -0.00515192f, -0.01569780f, 0.00857001f, 
    0.01852583f, 0.01964490f, -0.00416126f, 0.03554912f, 0.01383957f, -0.02694274f, -0.03139268f, -0.01061636f, 
    -0.00422540f, -0.03712399f, -0.03107475f, 0.02547050f, -0.00205693f, 0.03232957f, -0.03448981f, 0.01024683f, 
    -0.01980921f, 0.04540649f, 0.01114243f, -0.00519010f, 0.01648550f, -0.01911996f, 0.02659813f, 0.00222342f, 
    -0.04485192f, 0.02721287f, -0.03153390f, -0.04047420f, -0.01573287f, 0.01444795f, 0.03167472f, -0.03017816f, 
    0.03016757f, -0.00014904f, -0.03683206f, -0.02217334f, -0.03761132f, -0.02939494f, 0.00079601f, -0.01344822f, 
    0.00854057f, 0.02381619f, 0.02247878f, -0.01953347f, -0.03881861f, -0.01329502f, 0.01001953f, 0.03079211f, 
    0.01353621f, -0.00542612f, -0.00900561f, -0.02652968f, -0.04886815f, 0.00139099f, -0.02266435f, -0.02115257f, 
    -0.03848523f, -0.01015960f, 0.00976155f, 0.01192731f, -0.01599476f, -0.01443446f, 0.01076408f, -0.03805565f, 
    0.02614825f, 0.01836810f, -0.02113506f, -0.02738839f, 0.02181836f, 0.01567581f, 0.01427261f, -0.02326242f, 
    -0.02589889f, 0.01309384f, -0.03029536f, -0.02390549f, -0.00865627f, -0.04244968f, -0.03345973f, 0.01186759f, 
    0.02614331f, 0.03442324f, -0.03976724f, -0.03328329f, 0.02336076f, 0.00333487f, -0.03995614f, -0.02872829f, 
    -0.03335613f, 0.00963311f, 0.03494724f, -0.00476581f, -0.00463407f, 0.00038441f, -0.04298388f, -0.00134597f, 
    -0.01120292f, 0.00465631f, -0.01555442f, 0.00847183f, 0.02046947f, -0.04283004f, -0.00827754f, -0.00979332f, 
    -0.01940757f, -0.02348893f, 0.01041256f, -0.03805856f, 0.02675050f, -0.03192486f, -0.00484257f, -0.02939549f, 
    -0.00677237f, -0.03161013f, 0.03172036f, -0.02802951f, 0.00135093f, 0.02367303f, 0.00974808f, -0.00640109f, 
    0.00234720f, 0.00957143f, -0.03280834f, -0.02568434f, 0.03130585f, -0.01049332f, -0.02072034f, -0.01270863f, 
    0.02171061f, -0.00245027f, -0.04396755f, -0.00217251f, -0.02468635f, 0.01284399f, -0.02183067f, -0.02592141f, 
    -0.02651121f, 0.03218785f, -0.03743582f, 0.00311203f, -0.02465137f, -0.03610652f, 0.04243121f, -0.01289338f, 
    0.01760234f, 0.01823447f, 0.01513488f, -0.04514223f, -0.02012298f, 0.00007741f, -0.01395728f, 0.02391843f, 
    -0.02319008f, -0.02770686f, -0.03354396f, 0.02728284f, 0.02045159f, -0.03011209f, -0.01215198f, -0.00208318f, 
    -0.02389744f, -0.04523610f, -0.00060054f, -0.04038993f, -0.03240659f, -0.00861682f, 0.02437812f, -0.00162510f, 
    -0.02143991f, -0.00675895f, 0.02797328f, -0.00034582f, -0.03346582f, -0.03210606f, 0.00759637f, 0.01340491f, 
    -0.04594218f, 0.01976270f, -0.03583525f, 0.01605783f, -0.01581741f, 0.00604177f, -0.03891069f, -0.04150660f, 
    -0.01472842f, 0.00363711f, -0.04055881f, 0.03917113f, -0.01329293f, -0.04432966f, -0.04664794f, -0.00935504f, 
    -0.01693812f, 0.03672222f, -0.02369270f, -0.03031353f, 0.00080999f, 0.02048406f, 0.03103133f, -0.02088493f, 
    0.02362650f, -0.03756401f, -0.03222506f, 0.01228779f, -0.01345432f, -0.03971606f, 0.02045402f, 0.02908186f, 
    0.00587704f, 0.02410499f, -0.01937415f, 0.02132040f, 0.00428213f, -0.00054430f, -0.03020840f, 0.00355133f, 
    -0.00887092f, 0.00702391f, -0.03327140f, -0.03267961f, 0.02351477f, 0.02954841f, 0.02452497f, -0.01288569f, 
    0.00489248f, 0.01248717f, 0.00314376f, 0.00021992f, 0.02566139f, -0.01889483f, -0.04500987f, -0.04662360f, 
    -0.01647027f, 0.02111112f, -0.01428829f, -0.03491475f, 0.01476548f, 0.01371506f, 0.02919232f, 0.01358126f, 
    -0.00496971f, -0.00095195f, 0.02270985f, 0.02088415f, -0.02707881f, -0.03656479f, 0.01498869f, -0.02959897f, 
    -0.01248644f, -0.01979074f, 0.02367011f, -0.03245603f, -0.04124404f, 0.01903678f, 0.02984363f, 0.02602146f, 
    0.03316180f, 0.00133152f, 0.03197230f, -0.01107210f, -0.00488031f, 0.03600876f, 0.01289320f, -0.00659319f, 
    0.00162334f, -0.01738509f, -0.02289552f, 0.03055581f, -0.03040632f, 0.00383213f, 0.01082635f, 0.00996568f, 
    0.00745544f, 0.02308465f, -0.00016172f, 0.00937995f, -0.00487463f, 0.02293341f, 0.03108149f, -0.01659145f, 
    -0.04356883f, -0.02377138f, 0.01606616f, -0.04185003f, -0.02186450f, -0.00393002f, -0.01628573f, 0.01654785f, 
    0.00942225f, 0.00394679f, -0.03035877f, -0.03560468f, 0.02000199f, 0.02340482f, 0.03104721f, -0.00746697f, 
    -0.00327478f, 0.00431262f, -0.03836498f, -0.00744667f, -0.04271324f, 0.01941466f, -0.02930767f, 0.01851713f, 
    0.00030340f, -0.01930357f, 0.03403460f, -0.02964913f, 0.01692820f, 0.00356900f, -0.02297138f, 0.01295487f, 
    -0.03331793f, -0.02560809f, 0.02796884f, 0.03212442f, 0.01616319f, 0.01423037f, 0.00864183f, -0.02316717f, 
    0.02819792f, -0.02381757f, 0.03000427f, -0.01019080f, 0.00093554f, 0.01507358f, 0.00898281f, -0.01435738f, 
    -0.04628762f, 0.02732873f, 0.00551318f, 0.01333338f, -0.03566533f, -0.02486234f, 0.02067908f, 0.03231115f, 
    0.03362649f, 0.03191265f, 0.00330607f, 0.03222430f, 0.00468296f, -0.02333342f, 0.02853306f, 0.02357771f, 
    0.02238547f, 0.02922827f, 0.00265310f, 0.00466458f, 0.01520538f, 0.02988650f, -0.03866363f, -0.02465670f, 
    -0.01736243f, -0.04184182f, -0.01739006f, -0.01788400f, 0.02343171f, 0.01611836f, -0.00257618f, 0.01036395f, 
    0.00648876f, -0.03613778f, -0.00225359f, -0.02969781f, -0.01445413f, -0.04750982f, 0.01015355f, -0.01781422f, 
    -0.00695997f, 0.00061100f, -0.00399176f, -0.02592995f, -0.02018153f, -0.00574152f, 0.01103923f, -0.02432899f, 
    0.00422091f, -0.01892541f, -0.00674582f, -0.01269105f, 0.02089594f, -0.03922663f, 0.00784281f, -0.00308380f, 
    -0.03097160f, 0.02988703f, -0.03117488f, 0.00138980f, -0.00841036f, -0.04028874f, -0.00160376f, -0.02348953f, 
    -0.00966321f, 0.02221457f, 0.02704787f, 0.01335220f, 0.00649579f, -0.00252953f, 0.00509071f, 0.00674473f, 
    -0.01102349f, 0.00697855f, -0.00276768f, 0.01201443f, -0.02722318f, -0.01234404f, 0.00422350f, -0.00606551f, 
    -0.04227379f, -0.03616536f, -0.02001889f, -0.03976510f, -0.02330867f, -0.03708427f, 0.02191966f, 0.00507094f, 
    -0.00177753f, -0.00888875f, -0.03878344f, 0.02487752f, -0.01484735f, -0.00591534f, 0.00217644f, -0.04374404f, 
    0.01559360f, 0.01689921f, -0.00985536f, -0.01431278f, -0.01998552f, -0.00906880f, -0.03025227f, 0.00006435f, 
    0.00277327f, -0.01270552f, -0.01900967f, 0.04215930f, -0.03683610f, -0.02580744f, -0.02038633f, 0.02982748f, 
    0.02711955f, -0.01358626f, -0.01882352f, 0.01860899f, 0.00496036f, 0.01007867f, -0.01791540f, 0.03305333f, 
    0.02006234f, 0.02287234f, -0.03338492f, 0.02196113f, 0.00265222f, 0.01407869f, 0.00097113f, 0.01748961f, 
    0.00556950f, -0.04269668f, -0.01537684f, -0.02525004f, -0.01366684f, 0.01014325f, -0.02083738f, -0.00136577f, 
    0.00765788f, 0.01899973f, -0.00129066f, -0.01170069f, -0.02162542f, -0.00403057f, -0.03083205f, -0.00536787f, 
    -0.03061508f, -0.01658905f, -0.01168154f, -0.04479997f, -0.00989662f, 0.00824866f, 0.01483262f, 0.02423971f, 
    -0.03478141f, -0.01900129f, -0.00009176f, -0.01711923f, -0.00843001f, 0.00768650f, 0.00365427f, 0.03702952f, 
    -0.01401089f, -0.03379410f, -0.02657687f, 0.00619441f, 0.00236367f, -0.00796548f, -0.02506546f, -0.00347265f, 
    -0.04171221f, -0.01090158f, 0.01922243f, 0.01232100f, -0.04010653f, -0.03308662f, -0.03014539f, -0.01465891f, 
    0.01537414f, -0.03648304f, -0.01099515f, -0.03376373f, -0.04496950f, -0.01283749f, -0.02766971f, 0.00482196f, 
    0.01462823f, 0.01027109f, -0.00307518f, 0.00291887f, -0.01664132f, 0.01429432f, 0.00389359f, 0.01215592f, 
    0.02047646f, -0.04447424f, -0.03777822f, 0.00353975f, 0.00803216f, 0.00734256f, 0.00553009f, 0.00787462f, 
    0.02718823f, -0.01996885f, 0.00092929f, -0.00610382f, 0.01274560f, -0.01242310f, -0.00363412f, 0.04046154f, 
    -0.00960741f, 0.00172065f, 0.01734734f, -0.00889766f, 0.00390082f, -0.00364752f, 0.00652162f, 0.04061881f, 
    0.01906157f, -0.04250348f, 0.03177979f, -0.04390440f, 0.00265961f, -0.00870650f, -0.01738528f, -0.02410931f, 
    -0.00153508f, -0.03176866f, 0.00144166f, 0.02026430f, -0.00617254f, -0.00809548f, 0.03874395f, 0.01467407f, 
    0.01971464f, 0.01845486f, -0.02240403f, 0.03032757f, 0.03238298f, -0.02832993f, 0.01536210f, -0.00621883f, 
    -0.01581968f, -0.01270278f, -0.01283705f, -0.03375123f, -0.00212447f, -0.03938524f, -0.02678158f, 0.01664820f, 
    0.03274641f, 0.02967611f, 0.00262967f, -0.02418612f, 0.01407695f, 0.00887416f, 0.00050992f, 0.00596756f, 
    0.01847863f, -0.04815658f, 0.00300293f, -0.01457371f, -0.02648467f, 0.02379222f, -0.03836520f, -0.01341281f, 
    0.00813763f, 0.01461039f, 0.02930630f, -0.01457080f, -0.00918287f, 0.01442065f, 0.00466647f, -0.03958400f, 
    -0.01044203f, 0.02643578f, 0.03026980f, -0.03201481f, 0.00150230f, -0.02496424f, -0.01104373f, -0.03708340f, 
    -0.02759773f, -0.01447362f, 0.02253514f, -0.02019803f, -0.00739963f, 0.01848342f, 0.00137462f, -0.03339155f, 
    0.03119102f, 0.02673218f, -0.03405068f, -0.04274560f, -0.00658089f, 0.00332103f, -0.02920183f, -0.02906609f, 
    0.01680996f, 0.00064772f, -0.02318302f, -0.00524478f, 0.02687296f, 0.02794948f, -0.03838629f, 0.00162721f, 
    -0.00965291f, -0.04036448f, -0.03510480f, -0.02505796f, -0.01123839f, -0.03191579f, 0.00709487f, 0.02184179f, 
    0.01948335f, -0.02084772f, -0.01502515f, -0.02500216f, -0.02308670f, 0.00858711f, -0.01303830f, 0.02247899f, 
    0.02450873f, -0.00995591f, -0.02942677f, -0.00578546f, -0.01632328f, -0.00936442f, -0.01767241f, 0.03101951f, 
    0.02752018f, -0.03959155f, 0.00900568f, 0.00612098f, -0.03728708f, -0.04511046f, -0.02607764f, -0.01465433f, 
    -0.00968184f, -0.00493007f, 0.00114089f, 0.00234950f, 0.00877017f, -0.03500927f, -0.04687512f, -0.03454678f, 
    -0.01880154f, 0.03039919f, -0.03504081f, 0.01403878f, -0.00360360f, 0.02229849f, -0.03103415f, 0.01269379f, 
    0.00594736f, 0.01683020f, -0.01104158f, -0.02204076f, 0.01396033f, 0.01858995f, -0.02401520f, -0.02144380f, 
    -0.03642233f, 0.00854270f, -0.03637963f, -0.02387271f, 0.01287329f, -0.02717701f, -0.03981661f, -0.00646758f, 
    -0.01821388f, 0.00570159f, 0.03190950f, 0.03418137f, -0.02985344f, -0.01201068f, 0.01150376f, -0.04826418f, 
    0.00265975f, -0.02077257f, 0.02084220f, -0.00217618f, 0.01175054f, 0.01363816f, -0.02321178f, 0.03065704f, 
    0.02813799f, 0.01684302f, 0.00702313f, 0.00141338f, -0.01346926f, 0.02940869f, -0.01242821f, 0.02603328f, 
    -0.00325004f, 0.02461402f, 0.02730110f, -0.03906099f, 0.00549287f, -0.01396456f, 0.02681755f, -0.03781530f, 
    -0.00411264f, -0.03347009f, -0.01832887f, 0.03741167f, -0.03667912f, -0.03069188f, -0.04451060f, 0.00523593f, 
    -0.00930557f, 0.01990211f, 0.01885245f, 0.01923754f, -0.02189299f, -0.02976536f, 0.01650612f, -0.03500234f, 
    -0.00775430f, 0.01703507f, -0.01430973f, -0.00932943f, 0.00849098f, 0.02851371f, -0.02214604f, 0.00144919f, 
    0.02047377f, -0.00614952f, 0.01655022f, -0.01605165f, 0.02626221f, 0.02613940f, -0.03341190f, -0.03336862f, 
    0.01392240f, 0.02256874f, -0.02549691f, -0.03101674f, -0.01004383f, -0.03274352f, 0.00701246f, 0.02930987f, 
    -0.02925072f, -0.02519938f, -0.00690583f, -0.03295936f, 0.00796822f, -0.01731389f, 0.00169582f, 0.02562360f, 
    0.02862698f, -0.02993444f, 0.01269070f, 0.02341577f, -0.00390403f, -0.00262280f, -0.01561439f, -0.03559281f, 
    -0.01638619f, -0.04674374f, -0.01466976f, -0.03685069f, -0.04311471f, 0.00930180f, -0.00177655f, 0.02013865f, 
    -0.03912286f, -0.03570002f, -0.01122968f, -0.00605242f, 0.01422626f, -0.00841385f, -0.00234527f, 0.02298409f, 
    0.02633840f, 0.01117522f, -0.02058858f, 0.00226348f, -0.00098764f, -0.04167627f, -0.02812206f, 0.01044785f, 
    0.00268586f, -0.03488138f, 0.02716101f, -0.01100669f, -0.00833924f, -0.04631980f, 0.01094343f, -0.03962585f, 
    -0.00481784f, 0.00884710f, -0.00659877f, 0.02452027f, -0.00047465f, -0.00245442f, -0.00172431f, 0.00231588f, 
    0.00738988f, 0.02131394f, 0.00883143f, -0.03640875f, -0.00747931f, 0.01981319f, 0.02004182f, 0.00126474f, 
    0.01553303f, -0.03813866f, -0.03974383f, -0.03600560f, -0.01706024f, -0.03343685f, -0.03654243f, 0.01024489f, 
    -0.00714210f, -0.03838023f, -0.01519166f, 0.01149860f, -0.01295743f, -0.02231854f, 0.00820341f, 0.00320510f, 
    0.01851517f, -0.00216600f, -0.01886820f, -0.04433497f, 0.00335776f, 0.03586544f, -0.02466030f, -0.01370506f, 
    -0.03535707f, -0.00418674f, 0.02149051f, 0.02588483f, 0.00348926f, 0.01632256f, -0.02199250f, -0.03405751f, 
    0.01938307f, 0.00742912f, -0.00813047f, 0.02213777f, 0.04321118f, 0.00407905f, 0.03212033f, -0.04018505f, 
    0.02778307f, -0.02044993f, -0.00274812f, -0.03025822f, -0.03582496f, -0.00086583f, 0.01528956f, -0.01294234f, 
    0.02228837f, 0.01870805f, 0.01209133f, -0.04094089f, 0.01686409f, 0.02579797f, -0.02386392f, -0.03002716f, 
    -0.02091381f, -0.00258645f, -0.04788819f, 0.00722641f, -0.01929107f, -0.03929957f, -0.03376026f, -0.01223473f, 
    0.02750017f, -0.02620453f, -0.00137630f, 0.03008167f, 0.00694748f, -0.03656254f, 0.01781289f, 0.02672017f, 
    -0.03937405f, -0.03968969f, -0.00232621f, -0.04387345f, -0.00876294f, 0.02613900f, 0.03030213f, 0.01801488f, 
    0.02044186f, -0.01097896f, 0.02582091f, -0.01191445f, -0.00066001f, -0.02436461f, -0.01599821f, 0.01648820f, 
    -0.03659361f, -0.02382351f, -0.03254643f, 0.00161864f, 0.00102552f, -0.00466417f, -0.01341455f, 0.01593902f, 
    -0.00440727f, -0.03884860f, -0.01124417f, 0.01605397f, 0.00146820f, -0.03395506f, -0.02741744f, 0.01874815f, 
    -0.03641333f, 0.00691897f, -0.00331386f, -0.02576982f, -0.04082645f, -0.01472852f, 0.00182953f, 0.02088505f, 
    0.01011202f, 0.02091356f, -0.00779317f, 0.02008618f, -0.03528118f, -0.03509007f, 0.01155504f, -0.03058912f, 
    -0.00756383f, -0.01442157f, -0.00570519f, -0.02165275f, -0.00465534f, 0.02050562f, 0.03324229f, -0.00216045f, 
    0.01079806f, -0.00939567f, 0.00561824f, -0.03287475f, -0.00503553f, 0.02123483f, 0.03075049f, -0.02691919f, 
    0.01826216f, 0.00347205f, -0.03075377f, -0.03154836f, -0.01848601f, 0.03092336f, -0.01212988f, 0.02845036f, 
    -0.01671622f, -0.00912628f, -0.02543962f, -0.03199957f, 0.01066096f, -0.01507710f, -0.02284862f, 0.02537756f, 
    -0.03022208f, -0.01632464f, -0.01246152f, 0.03108164f, 0.03416317f, -0.03213554f, -0.04713172f, -0.01204013f, 
    0.02682512f, -0.03726863f, -0.00285472f, -0.04378859f, -0.02230283f, 0.00304581f, -0.02541797f, 0.00063270f, 
    -0.05123064f, 0.00467201f, -0.03086723f, -0.04562546f, 0.01084502f, -0.02022554f, 0.00650738f, -0.02582758f, 
    -0.02194465f, -0.01973564f, -0.02822694f, 0.01740083f, -0.01618578f, -0.02465152f, 0.00038651f, -0.04294362f, 
    -0.03628460f, -0.03526943f, -0.02533159f, -0.00917761f, -0.03873866f, 0.03046113f, -0.02724256f, 0.01743130f, 
    -0.02054147f, -0.04416978f, -0.02563255f, 0.01953120f, 0.02808299f, 0.01879513f, -0.02126970f, -0.00377663f, 
    0.02775312f, 0.01877291f, 0.02252684f, 0.03718732f, -0.01912978f, 0.03861752f, 0.02206637f, -0.03307121f, 
    0.03525040f, -0.01578074f, -0.00558432f, -0.01137839f, -0.00303757f, 0.00743093f, 0.01072228f, -0.04371091f, 
    -0.01302037f, -0.04055312f, -0.01892761f, 0.02571668f, 0.02084500f, -0.02852507f, -0.03402316f, 0.01843823f, 
    0.00465295f, -0.03050105f, -0.01896876f, 0.01947257f, 0.00685840f, -0.00283434f, -0.00048774f, 0.00622190f, 
    0.00445245f, -0.03908535f, 0.01798388f, 0.00264243f, -0.01234189f, 0.02101746f, 0.02955922f, -0.02700547f, 
    0.02763749f, 0.00452980f, 0.00319848f, 0.01061184f, -0.00309102f, -0.03630622f, 0.00153529f, 0.03860995f, 
    0.00718201f, 0.01475426f, 0.01210891f, 0.02400704f, -0.00059905f, -0.00323520f, 0.00083515f, -0.02641428f, 
    0.02472534f, 0.02556274f, 0.02397636f, 0.01388945f, -0.04112022f, 0.00658917f, -0.01535408f, -0.00270934f, 
    0.00599722f, -0.01812210f, 0.00708924f, 0.00118876f, -0.02940877f, -0.01223960f, -0.03433273f, 0.02928615f, 
    0.02931628f, -0.02085781f, 0.02283243f, -0.02427182f, -0.03097614f, 0.02103318f, 0.02881556f, 0.02757578f, 
    -0.01210899f, -0.00546639f, 0.03495722f, -0.03593103f, -0.00949694f, -0.02868991f, 0.03470189f, -0.01310835f, 
    0.02740948f, 0.00955154f, -0.01021327f, 0.03147245f, 0.00650271f, 0.02615626f, -0.00888571f, 0.03021060f, 
    -0.02644796f, -0.00275748f, 0.01044225f, 0.01899870f, 0.01461433f, -0.04173534f, -0.00126374f, -0.01188188f, 
    0.01235357f, -0.00368822f, -0.03434677f, 0.01259828f, -0.00494324f, 0.01627805f, 0.00868782f, 0.01959036f, 
    -0.03506290f, 0.01366205f, -0.04064135f, -0.00182282f, -0.01182418f, -0.04044439f, 0.00552585f, -0.02206910f, 
    -0.02410026f, 0.01736336f, -0.01638955f, 0.00769614f, -0.01903102f, -0.03612132f, -0.00085246f, 0.01688999f, 
    -0.01849181f, 0.03023192f, -0.04304847f, 0.01694671f, 0.01710379f, 0.01166339f, -0.00829726f, 0.02941942f, 
    -0.03576159f, 0.02905691f, 0.01646655f, 0.00739021f, 0.00250543f, 0.01771013f, -0.01993434f, -0.01318689f, 
    0.01374190f, -0.00607208f, 0.00342985f, 0.01823027f, -0.02055640f, 0.00889884f, 0.00112129f, -0.03637905f, 
    0.00939852f, -0.00420068f, 0.01778748f, -0.00836560f, -0.00042668f, 0.02595004f, -0.03381939f, -0.03416763f, 
    -0.00941390f, -0.00376800f, 0.02231409f, -0.00758434f, -0.02596438f, 0.02957837f, 0.03509431f, 0.00933668f, 
    -0.00862143f, 0.01929442f, 0.03237277f, -0.02252487f, 0.00068856f, -0.01950823f, -0.02651499f, 0.02738121f, 
    -0.00786876f, -0.01948786f, -0.01541387f, -0.01880017f, -0.02948904f, -0.02317738f, 0.00581927f, -0.03764920f, 
    -0.04196791f, 0.01107938f, -0.00919063f, 0.00585758f, 0.00250928f, 0.01116400f, 0.01370410f, 0.01131956f, 
    0.00938892f, -0.04866824f, -0.03404501f, 0.02186498f, -0.02328315f, 0.02316410f, 0.02721962f, -0.00491777f, 
    0.01264810f, -0.02096150f, -0.00722935f, 0.01914773f, 0.01132760f, 0.00251077f, 0.01020020f, -0.03730135f, 
    0.03003604f, -0.03701986f, 0.00549013f, 0.00024728f, -0.03456677f, -0.02935440f, -0.01190433f, 0.00315543f, 
    0.00960194f, -0.01430261f, -0.02719386f, -0.04270473f, 0.01757262f, -0.00359885f, -0.02517445f, 0.02504007f, 
    -0.00426267f, 0.00818855f, 0.00403233f, -0.03674628f, 0.02096142f, -0.04058520f, -0.02323164f, -0.01566394f, 
    -0.00558311f, -0.00599411f, -0.02267363f, 0.00412841f, 0.00592154f, -0.01786350f, -0.01832157f, 0.01297333f, 
    -0.00457196f, -0.01466915f, -0.01277323f, -0.00000866f, -0.00504773f, 0.01740593f, 0.00802692f, 0.03089225f, 
    -0.03411980f, 0.02042940f, 0.02214534f, 0.00509713f, -0.03326639f, 0.01135833f, -0.03332795f, -0.02321575f, 
    -0.01968038f, -0.01219842f, -0.00670380f, -0.00366602f, 0.01659704f, 0.00495396f, 0.01913911f, 0.00667937f, 
    -0.03440598f, -0.00870867f, 0.02325577f, 0.01994012f, 0.01758025f, -0.03276404f, -0.01427602f, 0.00211802f, 
    -0.04362501f, 0.01119042f, 0.00710642f, 0.01356050f, -0.02468226f, -0.00535909f, -0.00014217f, -0.03367562f, 
    0.01276036f, 0.00864115f, -0.01246723f, -0.03868894f, -0.01355416f, 0.01217900f, -0.01653238f, 0.01903014f, 
    -0.00771962f, -0.03488052f, 0.02122718f, -0.01254046f, 0.00808928f, 0.00534127f, 0.02453457f, -0.00814776f, 
    -0.01214839f, -0.04589541f, -0.01092109f, 0.01260212f, -0.01313688f, -0.03099885f, 0.03224144f, 0.00873863f, 
    -0.02489392f, -0.00596519f, -0.00137643f, -0.03616815f, 0.02078681f, -0.00842797f, 0.00512199f, -0.01998583f, 
    -0.00770304f, 0.00103980f, -0.01212354f, -0.02512993f, 0.00169596f, -0.02065986f, -0.00246833f, 0.00316528f, 
    0.01557851f, -0.00225350f, -0.04054657f, -0.02244265f, 0.00280691f, 0.00535290f, 0.02219323f, -0.01766714f, 
    0.00720323f, -0.01697716f, 0.00144344f, -0.02858360f, -0.02545509f, 0.01745976f, 0.02089699f, 0.02274716f, 
    -0.03764747f, -0.03233129f, 0.00457542f, -0.04369591f, 0.01349828f, -0.03840151f, -0.02340118f, -0.02996118f, 
    -0.03172455f, 0.02790961f, 0.02692832f, -0.02414239f, -0.01704481f, -0.00476237f, -0.00366144f, -0.01546766f, 
    0.03483988f, -0.03239504f, -0.03523943f, 0.02245338f, -0.03046031f, -0.00494961f, -0.02707617f, 0.02842623f, 
    -0.00561094f, 0.02766758f, 0.01086700f, 0.02668500f, 0.02542801f, 0.01164294f, -0.02246640f, -0.01205237f, 
    -0.01612501f, 0.03204015f, 0.01751438f, -0.01802652f, -0.01168631f, 0.01235858f, -0.03916926f, -0.00860481f, 
    0.02031342f, 0.02099425f, -0.00603701f, -0.01326880f, -0.01656650f, -0.01840630f, -0.00969090f, -0.02594715f, 
    -0.04535577f, -0.01411561f, 0.01063284f, 0.02659895f, 0.00724255f, 0.02506474f, 0.02626549f, -0.02133501f, 
    -0.00215980f, 0.01188377f, 0.03584884f, -0.00699002f, -0.02192759f, -0.00246124f, 0.00084298f, 0.02079188f, 
    -0.02302883f, 0.03107130f, -0.01134681f, -0.01609841f, -0.00084865f, 0.00086065f, -0.01151245f, 0.02332336f, 
    0.00566282f, 0.03203200f, 0.03208872f, 0.00472214f, -0.01414941f, 0.01835523f, 0.01864104f, -0.04927360f, 
    -0.03928835f, -0.00591367f, -0.01724174f, -0.00494597f, 0.02751987f, -0.00253593f, 0.02727911f, -0.03285486f, 
    -0.03727003f, 0.03151614f, -0.02572215f, 0.04192348f, 0.02836283f, 0.02476678f, -0.04422459f, -0.02002048f, 
    -0.03888131f, 0.01162026f, 0.01849269f, -0.00369157f, 0.02022084f, 0.03216914f, 0.01499570f, 0.01705867f, 
    -0.00774764f, 0.00324218f, 0.02977026f, 0.03488701f, 0.00972945f, -0.02706720f, -0.02833105f, 0.01474064f, 
    0.03054000f, -0.02960463f, 0.00605304f, -0.01421464f, 0.01476025f, 0.01700268f, 0.01147305f, 0.01931870f, 
    -0.00976845f, -0.00668644f, -0.00280953f, 0.00321574f, -0.02335065f, -0.03789723f, 0.01827723f, 0.01177426f, 
    -0.01665848f, -0.02224997f, -0.01396638f, 0.02902771f, 0.00705623f, -0.01454234f, 0.03200848f, -0.01485098f, 
    -0.24245919f, -0.14177765f, 0.39194086f, -0.08521434f, -0.05554240f, -0.09546688f, -0.00310853f, -0.09742076f, 
    0.10257529f, 0.04622709f, 0.11452217f, 0.11454725f, -0.03313980f, -0.14769641f, -0.07441389f, -0.06326009f, 
    -0.09301642f, 0.03745723f, 0.00115309f, -0.00740458f, -0.40733325f, -0.24652968f, -0.01280510f, 0.33022621f, 
    0.00578566f, -0.06986465f, -0.16566105f, -0.02288054f, -0.04950177f, -0.30460700f, 0.01558394f, -0.02877593f, 
    0.01218393f, 0.14125817f, -0.06886226f, -0.00418238f, -0.05658519f, -0.19948487f, -0.09735214f, -0.12781896f, 
    -0.15325117f, -0.01393778f, -0.11951491f, 0.10243988f, 0.05644998f, 0.10868810f, -0.08352979f, 0.01147158f, 
    -0.12223260f, 0.07229516f, 0.02392774f, -0.07345688f, 0.03700773f, 0.23627980f, 0.02307864f, 0.19741713f, 
    -0.06140528f, -0.01607449f, 0.08888580f, 0.12648043f, 0.00456543f, -0.07042484f, -0.13715138f, 0.09365254f, 
    0.03825811f, -0.02686543f, 0.04159742f, -0.09969772f, 0.06265091f, 0.07627422f, 0.07655399f, 0.18704692f, 
    0.11470647f, 0.17417605f, 0.24582037f, -0.00069581f, 0.11391205f, 0.10278793f, 0.13979796f, 0.15395863f, 
    0.15300465f, -0.03047828f, -0.03223341f, -0.07258365f, 0.23570879f, 0.06791248f, 0.03086712f, 0.03108874f, 
    -0.06310648f, -0.02981800f, 0.00116868f, -0.01669242f, -0.06663860f, -0.03400669f, -0.05160442f, -0.18691088f, 
    -0.20650451f, -0.04239066f, -0.02740400f, -0.12156308f, 0.22435397f, -0.04295543f, 0.13164532f, -0.00453836f, 
    0.08966260f, -0.01847195f, -0.05753487f, -0.03507340f, -0.04771179f, -0.01286073f, 0.07708071f, 0.30804777f, 
    0.22024037f, 0.31350985f, 0.19060992f, 0.01196708f, -0.04923562f, 0.05466997f, 0.08936577f, 0.03620547f, 
    -0.21971571f, -0.10554202f, 0.08209006f, -0.10030837f, -0.17177135f, -0.15879549f, -0.03185194f, -0.12115780f, 
    0.05951782f, 0.08247891f, 0.12161255f, -0.04091569f, -0.09078352f, -0.07233913f, -0.05110541f, -0.06694465f, 
    0.03879149f, 0.00733578f, -0.00469534f, 0.00892482f, -0.52414811f, 0.03081666f, 0.10377018f, 0.41736385f, 
    0.13739100f, 0.06317415f, 0.00642880f, 0.04836632f, 0.09642866f, 0.01156928f, 0.05833004f, -0.15088156f, 
    -0.08502515f, -0.03839037f, 0.04050579f, -0.07722823f, 0.01752295f, 0.05767451f, -0.02089951f, -0.04734036f, 
    0.00553445f, 0.05838871f, -0.09639256f, 0.08213989f, 0.16599309f, 0.04888305f, 0.00866628f, 0.05721068f, 
    -0.06579878f, 0.04226566f, -0.01935839f, -0.04654392f, 0.06918611f, 0.09989165f, 0.07538002f, 0.06412090f, 
    0.06022183f, 0.02520932f, 0.08171175f, 0.10551441f, -0.19600725f, 0.04785098f, -0.13884401f, 0.12869993f, 
    0.17663504f, 0.00570590f, 0.00574858f, -0.00285667f, 0.06519268f, 0.00017762f, 0.03030223f, -0.01307936f, 
    0.04293454f, 0.12667798f, 0.03105453f, 0.22284265f, 0.15555820f, 0.01850061f, 0.26310223f, 0.05273560f, 
    0.34287485f, 0.17189249f, -0.09482798f, -0.30934530f, 0.18140998f, 0.21946996f, 0.06705385f, 0.01489109f, 
    0.01979242f, 0.00769008f, 0.02864168f, 0.00928441f, -0.10311055f, -0.03872124f, 0.15444125f, 0.10723287f, 
    0.25141683f, -0.23879637f, 0.10227561f, -0.08318260f, -0.25223628f, 0.24122797f, 0.09792421f, 0.10141312f, 
    -0.09837494f, 0.01582484f, -0.14422201f, 0.03534117f, 0.04278516f, 0.18586075f, 0.20892952f, 0.11073698f, 
    -0.04382763f, -0.02831903f, -0.02230659f, 0.04957483f, 0.01176534f, 0.01932778f, -0.00406227f, 0.03663516f, 
    0.11103980f, 0.15479924f, 0.09103940f, -0.01779413f, -0.04248976f, -0.00629419f, -0.01521362f, -0.02830139f, 
    -0.14987089f, 0.10774814f, 0.12751397f, 0.09605018f, 0.19695468f, -0.05762198f, -0.00396559f, -0.03749876f, 
    0.06414359f, -0.05752911f, 0.10706318f, 0.17736597f, 0.28191784f, 0.23080555f, 0.31112853f, -0.49212644f, 
    -0.11642989f, 0.01593198f, 0.08971470f, -0.03363254f, 0.01341853f, 0.10830873f, 0.12680271f, 0.04399524f, 
    -0.00800314f, -0.04969383f, 0.03847551f, -0.05980560f, 0.00911694f, 0.07028222f, 0.12750693f, -0.05524353f, 
    -0.19789906f, -0.27444208f, -0.03324618f, 0.07282147f, -0.11412270f, 0.02804331f, -0.04840715f, 0.03039948f, 
    0.14359309f, 0.00880883f, -0.07954533f, 0.03258450f, -0.06399592f, -0.03633455f, -0.00330112f, 0.00735648f, 
    0.01627895f, 0.02778467f, -0.12558596f, -0.04453888f, -0.21300322f, -0.08957763f, 0.30158442f, 0.23980044f, 
    -0.04364500f, 0.02683582f, 0.04705476f, -0.04886712f, -0.00464312f, 0.00543141f, -0.05181852f, -0.00190683f, 
    -0.03179724f, -0.04334456f, 0.01355467f, 0.01717848f, 0.07466154f, -0.03935174f, 0.02909175f, 0.09766068f, 
    -0.13805403f, -0.13901259f, -0.68325305f, 0.07644752f, -0.09214128f, 0.47758937f, 0.01392351f, 0.08989804f, 
    -0.13713941f, -0.05969882f, -0.12634540f, 0.03605920f, -0.04463752f, -0.05002367f, -0.08848067f, 0.06612078f, 
    -0.39019263f, 0.14102989f, -0.13803199f, -0.17517343f, -0.36053747f, 0.12955450f, -0.01784714f, 0.35014108f, 
    0.05825062f, -0.03590663f, -0.20074596f, -0.04834471f, -0.06178370f, -0.02441260f, 0.03270130f, -0.02173574f, 
    -0.06712887f, -0.03531945f, -0.05803580f, -0.03751389f, -0.12613915f, -0.07808410f, -0.07881421f, -0.06240788f, 
    0.08759990f, -0.01659565f, -0.15408298f, 0.33949813f, 0.02377453f, 0.12898107f, 0.01838069f, 0.21416220f, 
    0.13090003f, 0.08084606f, -0.02856372f, -0.01003001f, -0.02905403f, 0.20137034f, 0.19604339f, 0.14024958f, 
    0.04178429f, -0.04607765f, 0.02616794f, 0.26726130f, -0.18518858f, 0.38497129f, 0.11696999f, -0.10633645f, 
    0.18364942f, 0.09742349f, -0.08442213f, 0.01204953f, 0.00125026f, -0.12809348f, -0.01086665f, -0.02861174f, 
    -0.08630542f, 0.09351137f, 0.10879744f, 0.11764876f, -0.12915261f, 0.05929662f, 0.09420195f, -0.33221212f, 
    -0.28809965f, -0.20769116f, 0.22271305f, 0.26419112f, -0.09084450f, 0.04443770f, -0.00635004f, 0.13651213f, 
    -0.03588498f, -0.18054444f, -0.06340783f, -0.00909241f, -0.00816971f, -0.01734978f, -0.00433884f, -0.02090093f, 
    0.03196913f, 0.05621579f, 0.07643399f, 0.09930903f, 0.40787989f, -0.00178874f, 0.15179625f, -0.47204858f, 
    -0.09701136f, -0.02722184f, -0.12076017f, -0.07413161f, -0.12603629f, -0.04312054f, 0.16121811f, 0.11681540f, 
    0.01458700f, 0.19691800f, -0.01530586f, 0.01448701f, -0.21001849f, 0.08640424f, 0.06098275f, 0.02322973f, 
    -0.20755908f, -0.17123935f, 0.07898154f, 0.33618188f, -0.16467085f, 0.00561207f, -0.07748047f, -0.07423538f, 
    0.10175900f, 0.03228127f, 0.04399697f, 0.01346264f, 0.04860086f, 0.14285871f, 0.14431772f, 0.06175507f, 
    0.07028478f, 0.02947416f, -0.31078318f, 0.07841457f, 0.20150857f, -0.07691242f, 0.13045952f, 0.01606479f, 
    0.12427992f, -0.12462495f, -0.10897238f, -0.02765696f, -0.05356838f, -0.00116028f, 0.00973024f, 0.03273826f, 
    -0.01006080f, 0.12920964f, 0.17682901f, -0.03248106f, -0.06897467f, 0.16114280f, -0.00303950f, 0.00512355f, 
    -0.03419286f, 0.00582241f, -0.10039265f, 0.09789094f, 0.03174619f, 0.19126789f, -0.01154677f, 0.08672225f, 
    -0.00300692f, 0.12612911f, -0.03230773f, -0.06784962f, -0.03156404f, -0.08753778f, -0.00889946f, 0.02395133f, 
    -0.00682356f, 0.00763855f, 0.11294267f, -0.04962117f, 0.23470876f, -0.13882095f, 0.11881977f, 0.01761890f, 
    -0.24926648f, 0.05472621f, 0.41302839f, -0.34912354f, 0.09346735f, 0.00081158f, 0.00170708f, -0.00607126f, 
    -0.01366610f, -0.08927348f, -0.04982408f, -0.15619491f, -0.01407758f, -0.32251993f, -0.04773893f, 0.00798375f, 
    -0.24977967f, 0.05751799f, 0.09961412f, 0.23745054f, 0.03797093f, 0.07142094f, -0.08845468f, -0.00895933f, 
    0.08303961f, 0.02047293f, -0.01686222f, -0.06886493f, -0.01859284f, 0.05375790f, 0.01018008f, 0.03154216f, 
    -0.05458698f, 0.03203024f, -0.02727224f, -0.03217050f, 0.06544881f, -0.07638543f, -0.03541794f, 0.00336043f, 
    -0.00311217f, -0.00307271f, -0.09250973f, -0.06425613f, -0.08861157f, -0.06770998f, 0.27566585f, 0.19653039f, 
    0.17058885f, 0.07449637f, 0.14755423f, -0.01847020f, 0.07055796f, 0.06408434f, 0.01862851f, -0.02353119f, 
    -0.00318998f, 0.16217610f, 0.22909921f, 0.15487885f, 0.12518057f, 0.08831455f, -0.07841591f, 0.13555323f, 
    0.12819019f, 0.07066717f, -0.00197062f, 0.02514290f, 0.12063160f, 0.04148313f, 0.04496301f, 0.01498837f, 
    -0.08790574f, 0.04416859f, -0.01775890f, -0.19046767f, 0.06264599f, -0.03056577f, -0.01929079f, -0.01184881f, 
    0.13121974f, 0.00449800f, -0.05735818f, -0.04360589f, -0.08193144f, -0.00392701f, 0.06380900f, -0.09340961f, 
    -0.00900968f, 0.07255908f, 0.08842344f, -0.00710471f, 0.04367370f, 0.03537486f, -0.00605766f, -0.00266557f, 
    -0.15924187f, -0.09243061f, 0.14723146f, 0.06377661f, -0.04801685f, 0.15226530f, 0.09736871f, 0.13774842f, 
    0.07496953f, 0.13510105f, 0.05103429f, 0.18279453f, -0.01304980f, 0.03451215f, -0.02266369f, 0.06034038f, 
    0.07564602f, 0.09047164f, 0.09063142f, 0.29843336f, -0.08732555f, -0.03065939f, 0.04235427f, 0.30041662f, 
    -0.11394390f, -0.03917753f, -0.04459444f, -0.04296627f, 0.12318268f, -0.10970263f, 0.02305305f, -0.00876261f, 
    0.07762752f, -0.04088438f, 0.16707890f, -0.06349898f, 0.01755635f, -0.04072035f, -0.26649648f, -0.18715718f, 
    0.01131159f, -0.03324947f, -0.00541111f, -0.03472650f, -0.03202947f, 0.01861977f, 0.02361992f, -0.03025707f, 
    0.00208857f, 0.02121386f, 0.02684242f, 0.01492327f, 0.02240407f, 0.01752004f, -0.04156335f, 0.00523674f, 
    -0.04298259f, 0.00148527f, -0.03239477f, 0.00291436f, -0.02868448f, 0.03259598f, 0.01786876f, -0.03891642f, 
    0.01806768f, -0.04386704f, 0.01131332f, 0.00323437f, -0.01136925f, 0.03401336f, 0.02908163f, -0.01502922f, 
    0.00384655f, -0.02687454f, 0.00464359f, 0.01560090f, -0.03728741f, -0.00941537f, -0.01079045f, 0.02438251f, 
    0.01220775f, -0.03057129f, -0.00184165f, -0.00016658f, -0.01645693f, -0.01065810f, 0.02366081f, -0.03114829f, 
    -0.00563594f, -0.00007392f, 0.00474405f, 0.01842908f, -0.00982260f, -0.03033267f, -0.02882947f, -0.00899831f, 
    -0.02007708f, 0.00939610f, -0.03649712f, -0.02399508f, -0.00485239f, -0.01807691f, -0.03997157f, 0.03343402f, 
    -0.03151061f, -0.03944444f, -0.03767436f, -0.00815650f, 0.01027338f, 0.02442370f, 0.00670247f, -0.04270898f, 
    0.01689746f, 0.01944175f, -0.01706080f, 0.00348322f, -0.01432255f, -0.00982390f, 0.01042596f, -0.03870881f, 
    -0.02198269f, 0.01505162f, 0.02664251f, 0.03120018f, 0.00462393f, -0.01545250f, 0.02749571f, 0.01632799f, 
    0.01584302f, 0.00738179f, -0.03831549f, 0.03364306f, -0.00127457f, 0.01509856f, 0.00350861f, -0.00804669f, 
    -0.01671623f, 0.01312881f, 0.01945642f, -0.01528453f, 0.00552517f, -0.00560513f, -0.01286555f, -0.00812696f, 
    0.02685260f, -0.00608090f, -0.01708185f, -0.04015641f, 0.00053174f, -0.03861609f, -0.01242964f, 0.01731168f, 
    -0.00216714f, 0.02231538f, -0.04262086f, 0.02567209f, 0.00665330f, -0.00108334f, -0.00177309f, 0.01428998f, 
    -0.00974870f, -0.01265183f, -0.01684373f, -0.03545552f, -0.03297056f, 0.01096011f, 0.02966689f, -0.02134208f, 
    -0.00264474f, -0.00100122f, -0.01719575f, -0.00435903f, -0.03737744f, -0.00604866f, -0.01616936f, 0.02925681f, 
    0.03415265f, 0.04250719f, -0.02607583f, 0.02298104f, -0.04174359f, 0.00679824f, 0.03676612f, 0.00294111f, 
    -0.03101638f, -0.04081167f, -0.02050718f, -0.02660012f, 0.02871420f, 0.02795411f, 0.00262223f, 0.02642440f, 
    0.02404383f, 0.00679001f, 0.01306335f, 0.01205675f, -0.04692911f, -0.03973885f, -0.04307715f, -0.02009843f, 
    -0.01580769f, -0.04376202f, -0.02994644f, 0.00030705f, -0.02486373f, 0.02383482f, -0.04391684f, -0.00390898f, 
    0.03341045f, 0.03150487f, 0.03313357f, -0.02870987f, -0.01376240f, -0.01132961f, -0.00596118f, 0.00722930f, 
    -0.01048555f, -0.00591507f, 0.00436096f, -0.00946026f, 0.01435616f, 0.01329540f, 0.03126718f, -0.01023864f, 
    0.01401748f, 0.02072716f, -0.03104747f, -0.01540382f, 0.01301607f, -0.03596496f, 0.01907277f, -0.00168152f, 
    -0.00534946f, 0.01671220f, -0.02698541f, 0.00160978f, -0.01029541f, 0.00162241f, -0.04167475f, 0.01117789f, 
    0.00690227f, -0.00203524f, 0.02879522f, 0.01108606f, -0.00776557f, -0.00629334f, -0.03381826f, 0.02060773f, 
    0.01715368f, 0.00727543f, 0.00279369f, -0.03074695f, -0.04212291f, 0.01026867f, -0.00614255f, 0.01905734f, 
    0.01428485f, 0.01614066f, -0.01972042f, -0.00967280f, -0.02683721f, -0.01439846f, -0.02180434f, -0.02528685f, 
    -0.04275149f, -0.01659133f, 0.01557571f, 0.00599116f, -0.04262584f, -0.03155142f, -0.01455531f, -0.03689186f, 
    0.00306346f, 0.00885544f, 0.02117551f, 0.02469457f, -0.03742395f, 0.01628177f, 0.01712611f, -0.01249084f, 
    -0.01937387f, 0.01664645f, -0.02638450f, -0.02433237f, -0.02865687f, 0.00247888f, 0.00599435f, 0.02555750f, 
    0.03618146f, -0.00128530f, 0.02717773f, -0.00491485f, -0.01152186f, -0.00425898f, -0.02216642f, -0.01786370f, 
    -0.00076677f, 0.00965192f, 0.03460342f, 0.01091013f, -0.00501632f, 0.02876011f, 0.02950557f, 0.00632588f, 
    -0.03467389f, 0.01792069f, -0.02896805f, -0.03969225f, 0.03226420f, -0.04427975f, -0.03725690f, -0.03533354f, 
    0.02037162f, 0.00469981f, 0.01115655f, 0.02569786f, -0.00230354f, -0.01108415f, -0.02509169f, 0.00255367f, 
    -0.02571687f, -0.02499278f, -0.02212384f, -0.00035092f, -0.04531488f, 0.02620340f, 0.01466406f, -0.03187633f, 
    0.01087483f, 0.02707443f, 0.02409041f, 0.01695759f, 0.01754812f, -0.01896959f, -0.02881352f, 0.00357937f, 
    -0.00711048f, -0.02301547f, -0.01696076f, 0.02766741f, -0.03716584f, -0.00794986f, 0.00789370f, -0.03228040f, 
    -0.03849664f, 0.02653710f, 0.01100419f, -0.00401861f, 0.01149660f, 0.03061457f, 0.02961601f, 0.02012843f, 
    0.02295642f, 0.00540922f, 0.03551636f, -0.00848841f, 0.01512557f, -0.01999146f, 0.01494768f, 0.02005772f, 
    0.02339773f, -0.03827568f, 0.02439256f, 0.00465080f, 0.02467916f, -0.03287757f, -0.01718644f, -0.00345355f, 
    -0.02912293f, 0.00688996f, -0.02278307f, -0.01254321f, -0.00577795f, 0.00206732f, -0.03094526f, 0.03148319f, 
    0.01553760f, -0.01938935f, -0.00633582f, 0.02664861f, -0.03993914f, 0.03085336f, 0.03133281f, -0.01708926f, 
    -0.01278036f, 0.02206658f, -0.02519228f, -0.00653652f, 0.00269918f, -0.00055916f, 0.00557497f, -0.01222232f, 
    -0.01998305f, -0.02975366f, 0.03213324f, -0.04084959f, 0.03334425f, -0.00744954f, -0.02753250f, 0.00966559f, 
    -0.03649814f, -0.02059127f, -0.01454543f, 0.00160673f, -0.02273690f, 0.01552978f, 0.01973121f, 0.02473395f, 
    -0.03208791f, -0.03017623f, -0.02819089f, -0.01580778f, -0.02226012f, 0.01612925f, 0.02110841f, -0.02864099f, 
    -0.00760635f, 0.02503585f, -0.00207414f, 0.01649981f, 0.03162326f, 0.01412869f, -0.01480621f, 0.00026442f, 
    -0.03902267f, 0.02069244f, 0.02795628f, 0.00079909f, -0.03224961f, -0.04449588f, -0.02352059f, 0.02887304f, 
    -0.03180611f, -0.00398757f, -0.00484012f, -0.04123029f, -0.03343149f, 0.00799010f, 0.03150847f, 0.00951161f, 
    -0.03769338f, 0.01352072f, 0.03224023f, 0.02379156f, -0.02617049f, 0.02604120f, 0.00254768f, -0.00199130f, 
    0.02893865f, -0.00676537f, -0.04366328f, -0.04164278f, -0.02542671f, -0.00013571f, 0.02649294f, -0.03656624f, 
    0.02647916f, -0.00919318f, 0.02709386f, 0.00710860f, 0.03225524f, -0.02427183f, 0.00486975f, -0.01641639f, 
    -0.03649002f, 0.02084271f, -0.01189711f, 0.00990439f, -0.03085137f, -0.02967316f, 0.01301384f, 0.03070678f, 
    -0.02121339f, 0.01911416f, -0.03207893f, 0.02794274f, -0.02487149f, 0.00940388f, 0.03409591f, 0.00740131f, 
    -0.01067269f, 0.00421854f, 0.01947832f, -0.04037679f, -0.01797725f, 0.00538062f, -0.02952975f, 0.00726208f, 
    -0.01928693f, 0.01769603f, 0.02389831f, 0.00831794f, -0.01081028f, -0.00517746f, -0.03120206f, -0.03819744f, 
    -0.01426447f, 0.02482481f, -0.03508117f, 0.01420509f, -0.04337558f, -0.02559079f, -0.00713742f, -0.01484455f, 
    -0.02669396f, -0.04108901f, 0.00104259f, -0.03532132f, 0.02245365f, 0.01807966f, 0.00244218f, 0.00935830f, 
    -0.02956295f, 0.03045065f, 0.01425999f, -0.02145370f, -0.01356266f, -0.02814323f, -0.02190314f, -0.01736473f, 
    0.00904720f, 0.00109853f, -0.01309317f, -0.02778148f, 0.03047654f, -0.01108494f, 0.00477173f, -0.00103779f, 
    0.02758747f, -0.00308716f, 0.02150171f, -0.03645652f, 0.00833440f, 0.02134342f, -0.03464312f, -0.01652017f, 
    -0.03825244f, -0.02566158f, -0.02628818f, -0.00843007f, 0.01171241f, -0.00317669f, -0.03852125f, 0.03299212f, 
    0.03239809f, 0.00769381f, -0.03090051f, -0.03910696f, 0.00482811f, 0.01872844f, -0.01278959f, -0.00468591f, 
    0.01998291f, 0.02359409f, 0.02088481f, 0.01605810f, 0.00924787f, 0.02986760f, 0.02343767f, -0.01110352f, 
    0.01532266f, 0.01651018f, -0.02801884f, -0.02074261f, 0.01460130f, 0.01459914f, -0.02186042f, -0.00457383f, 
    0.01935913f, -0.01334436f, 0.00523137f, 0.00493557f, -0.03483250f, -0.04200982f, 0.02494792f, 0.00581226f, 
    -0.03009370f, -0.03059686f, 0.02588887f, -0.04370202f, -0.03431009f, 0.03043084f, 0.03420940f, -0.03068847f, 
    -0.01804100f, 0.04616116f, 0.00782134f, 0.02851153f, -0.01594994f, -0.00170725f, 0.00330546f, -0.04587066f, 
    -0.02690624f, -0.03529187f, 0.01384437f, 0.01435363f, -0.01458579f, -0.00178206f, 0.00540959f, 0.03348344f, 
    -0.02567077f, -0.01471292f, 0.00779064f, -0.00633708f, -0.03169952f, -0.03677402f, 0.02746993f, -0.02665515f, 
    0.01704564f, -0.03030371f, 0.01201612f, -0.02346196f, -0.02296885f, 0.01709671f, -0.01938456f, 0.00855279f, 
    -0.03923947f, -0.00975358f, 0.01749566f, 0.03230105f, 0.02024095f, 0.01466567f, 0.00866072f, -0.03653051f, 
    -0.04386639f, -0.03456550f, 0.01503531f, 0.03624291f, -0.03248620f, 0.01417810f, -0.00380179f, -0.02629628f, 
    0.00787323f, -0.01850050f, -0.03951584f, 0.01202041f, -0.04304841f, -0.00127394f, -0.00051185f, -0.02567232f, 
    -0.02571595f, -0.00401121f, 0.00418487f, -0.03789159f, 0.01170140f, -0.02934572f, 0.02706188f, -0.02371902f, 
    -0.01015382f, -0.00632658f, -0.00167416f, -0.04547005f, -0.01989195f, 0.01544716f, 0.00631719f, 0.02001460f, 
    0.03305285f, -0.01607467f, -0.00734036f, -0.02101383f, -0.03845603f, -0.01052685f, -0.02199053f, 0.01986975f, 
    -0.03038779f, -0.00226695f, -0.00984942f, -0.03557763f, 0.00449182f, -0.04227045f, 0.00114524f, 0.01528860f, 
    -0.01490904f, -0.04362763f, -0.04188856f, -0.02121546f, 0.00966077f, 0.02416587f, 0.01525946f, 0.00153441f, 
    0.04893278f, 0.09141516f, 0.80820465f, 0.29481179f, 0.45792010f, -0.05241948f, 0.00028795f, -0.06757065f, 
    0.11543601f, -0.16431201f, 0.04652090f, -0.00673663f, 0.10282022f, -0.08208442f, 0.18689726f, 0.06390493f, 
    -0.03290911f, -0.12709512f, -0.02999327f, -0.11229958f, -0.06693163f, -0.34586713f, -0.11456278f, 0.15760724f, 
    -0.10748861f, 0.10416285f, -0.11487302f, -0.03543050f, 0.21269338f, -0.01595891f, -0.06915162f, -0.07252956f, 
    -0.11435723f, -0.12009281f, 0.00484981f, 0.11003156f, 0.28507847f, 0.09376237f, 0.17758724f, 0.13420904f, 
    0.12006608f, 0.08884793f, -0.00374522f, -0.38468698f, -0.09458482f, -0.03740889f, 0.07665895f, -0.13303547f, 
    -0.03599985f, -0.26116613f, 0.12713575f, -0.06966469f, 0.09784157f, -0.29117921f, -0.02539833f, -0.09291241f, 
    -0.19829793f, -0.31527299f, 0.08049545f, -0.21985798f, 0.22086121f, 0.32236436f, -0.48084375f, 0.06794405f, 
    -0.05410821f, 0.00946966f, -0.06663430f, 0.06025976f, -0.00002786f, -0.07603288f, 0.01597263f, 0.03718188f, 
    0.00807045f, -0.05810564f, -0.10212514f, 0.03653457f, -0.01049125f, -0.06179414f, -0.01394650f, -0.05436203f, 
    -0.06646907f, -0.04480270f, 0.28985524f, -0.21327588f, -0.03221561f, 0.04329407f, 0.01622024f, 0.05396127f, 
    0.07070144f, 0.07408960f, 0.04846538f, -0.02164395f, 0.03060431f, -0.03479782f, 0.03680630f, 0.07278296f, 
    0.08753167f, 0.07013595f, 0.12562709f, 0.08126555f, 0.11886880f, 0.24878010f, 0.06092355f, -0.16232611f, 
    0.06908783f, -0.05085337f, 0.03958325f, 0.15893920f, -0.06093455f, -0.16198851f, 0.03825630f, -0.03470915f, 
    0.00361550f, 0.08171779f, 0.04226043f, -0.00236346f, -0.05579021f, -0.03060010f, -0.11458847f, -0.03770192f, 
    0.11360656f, -0.04255332f, 0.34639692f, 0.17247839f, 0.34628174f, -0.03612459f, -0.08554083f, -0.00571342f, 
    -0.12516078f, -0.11091498f, 0.00742648f, 0.08983764f, 0.05871399f, 0.05481696f, 0.06332110f, -0.05101034f, 
    -0.31756207f, -0.16169111f, -0.08314285f, -0.32819110f, -0.12508000f, -0.12674959f, 0.15324232f, -0.06508913f, 
    0.19330637f, 0.13384439f, -0.00655784f, -0.00340165f, -0.07345875f, -0.02688240f, -0.00080342f, 0.05545865f, 
    0.03217295f, -0.04956771f, -0.04975071f, 0.16190569f, -0.00599881f, 0.05123737f, 0.05774660f, 0.16243336f, 
    0.04600261f, 0.16841215f, 0.06014843f, -0.33209577f, 0.12665430f, -0.04119793f, 0.03012456f, -0.14220412f, 
    0.00614212f, 0.09312069f, 0.04521032f, 0.08956351f, -0.02731949f, -0.10024630f, 0.00054352f, -0.06209093f, 
    -0.01558820f, 0.01161779f, -0.21691255f, -0.20042920f, 0.59114552f, 0.19886008f, -0.37282935f, -0.29809067f, 
    0.00831223f, 0.10221834f, 0.03537204f, 0.05299299f, -0.27204400f, 0.10118759f, -0.01579145f, -0.00460155f, 
    -0.03618884f, -0.06075355f, 0.21898915f, 0.08208977f, 0.01484238f, -0.20548894f, 0.12583964f, 0.09178586f, 
    -0.13272494f, 0.00589214f, 0.31338200f, -0.26654309f, -0.18101944f, 0.05738837f, -0.03038000f, -0.11734164f, 
    0.09787992f, -0.05589091f, 0.11072976f, -0.14743181f, 0.15612817f, -0.03847282f, 0.00036692f, 0.00745695f, 
    0.06660098f, -0.15923677f, 0.18939526f, 0.14703524f, 0.22764662f, 0.01737462f, 0.25906414f, 0.17799915f, 
    0.11949777f, 0.03660385f, 0.01178694f, 0.01258384f, 0.27550855f, 0.00913274f, 0.13006844f, 0.03651538f, 
    -0.06747214f, 0.18493290f, 0.20067668f, -0.01620243f, -0.00626232f, 0.19265717f, 0.06023807f, 0.06828612f, 
    -0.06648104f, 0.51743150f, 0.16771488f, 0.12914562f, 0.30825090f, -0.09518803f, 0.06355240f, 0.18449986f, 
    -0.28057146f, -0.06049462f, 0.03277189f, 0.13173272f, -0.02642603f, 0.09979676f, 0.02757365f, -0.08203891f, 
    -0.20610964f, -0.03572138f, -0.22971435f, -0.14202948f, -0.04259340f, 0.17607263f, 0.32454118f, 0.08467856f, 
    -0.06757973f, -0.01024838f, 0.12669104f, 0.03472826f, -0.16844286f, 0.01048073f, 0.14640987f, -0.00661977f, 
    0.20646432f, 0.19891240f, 0.12409753f, 0.11318445f, 0.09390868f, -0.06144355f, -0.08860265f, 0.10590909f, 
    -0.00001620f, -0.26158056f, -0.04275424f, 0.15606241f, 0.33944348f, 0.09420028f, 0.18623741f, 0.00830905f, 
    0.05674168f, -0.03415154f, 0.01758308f, 0.00854436f, -0.13636503f, 0.00129334f, -0.01338804f, -0.11470498f, 
    -0.20943245f, -0.02381226f, 0.03346851f, -0.03819778f, -0.26886490f, -0.22047026f, -0.01794705f, 0.10460217f, 
    0.02748846f, -0.13554473f, -0.04006185f, 0.01402211f, -0.03642605f, 0.02548418f, 0.07937494f, 0.06168095f, 
    0.09587118f, -0.20796892f, -0.06127391f, -0.02758378f, -0.00594855f, 0.05245300f, -0.13083717f, -0.14262517f, 
    -0.11095547f, -0.11310035f, -0.20949331f, -0.18915874f, 0.03387332f, 0.03058491f, 0.20062555f, 0.11868237f, 
    0.15240268f, 0.01601388f, 0.04757255f, -0.18060857f, -0.30573562f, -0.03724965f, -0.10359847f, -0.12478579f, 
    0.15236187f, -0.07151167f, -0.00452560f, -0.09526701f, -0.04758504f, -0.27703965f, 0.11932804f, 0.30201423f, 
    0.15865332f, 0.04373949f, 0.06234386f, -0.01808895f, 0.06513672f, 0.00196943f, 0.06369309f, 0.00970897f, 
    -0.02955392f, -0.00014116f, 0.07899861f, 0.10829239f, 0.18424128f, 0.10401317f, 0.14180559f, 0.15811281f, 
    0.08022556f, 0.06566448f, -0.22384027f, 0.03128147f, 0.12701921f, -0.00204475f, 0.09117154f, 0.04352923f, 
    0.00238782f, -0.00020407f, -0.01978022f, 0.15497622f, -0.00654274f, 0.06066888f, -0.20946355f, -0.12127889f, 
    0.04449498f, 0.01705080f, -0.07384734f, 0.01585432f, 0.12672350f, -0.44023016f, -0.11981960f, -0.17216228f, 
    -0.09603008f, 0.22403121f, 0.05030943f, -0.04160906f, -0.14149104f, 0.12182616f, -0.04614899f, 0.05810781f, 
    0.13414045f, -0.07852730f, 0.13004047f, 0.25303608f, 0.17096001f, 0.02920169f, 0.13281302f, 0.44737217f, 
    -0.19832037f, -0.36058700f, -0.36322394f, 0.25453684f, 0.12033217f, -0.04347759f, -0.00574110f, -0.02068185f, 
    0.05461647f, 0.12632401f, -0.06790207f, 0.04748107f, -0.00862960f, -0.16167153f, -0.12610367f, -0.07471284f, 
    0.00237173f, 0.05030872f, -0.06756949f, 0.00503914f, 0.52410686f, 0.05952837f, 0.12962946f, -0.28545004f, 
    -0.33370155f, 0.00450130f, 0.01772220f, -0.22030425f, 0.09268451f, -0.17253765f, 0.09496681f, 0.12475949f, 
    0.00571643f, 0.26526818f, 0.01789670f, 0.06610923f, 0.05310481f, -0.04552323f, 0.04954081f, 0.15397342f, 
    -0.39865005f, -0.20467278f, -0.40480652f, 0.18818381f, 0.05237133f, -0.16873316f, 0.08185382f, -0.04313795f, 
    0.03411491f, 0.06895040f, -0.16332830f, 0.01478417f, -0.08158075f, 0.03594871f, -0.08301318f, -0.05841635f, 
    0.08363664f, 0.14463435f, -0.23659474f, 0.10417414f, 0.02906474f, -0.02834631f, 0.21021298f, 0.06474768f, 
    0.02822877f, -0.06398461f, 0.03597213f, 0.14767019f, 0.16930611f, -0.20319474f, 0.17004305f, -0.03000301f, 
    0.11499285f, -0.04035253f, 0.04283615f, 0.04300063f, 0.01430190f, -0.02558797f, 0.07136785f, 0.00743284f, 
    -0.01834870f, -0.13179608f, -0.18924616f, 0.05248871f, 0.05121681f, 0.09391468f, 0.15793073f, 0.12490869f, 
    -0.17280084f, 0.13623157f, 0.22928533f, -0.18233103f, -0.18495326f, 0.03025444f, -0.12430463f, -0.08749057f, 
    -0.09267710f, -0.28181890f, -0.10213220f, -0.17913213f, -0.50713372f, 0.04591289f, -0.15598312f, 0.05162385f, 
    -0.16395709f, 0.04739736f, 0.05679370f, -0.14100170f, -0.01741013f, -0.04604546f, -0.07685174f, -0.04445161f, 
    -0.01493695f, 0.12156697f, 0.07083203f, 0.28780940f, 0.00561571f, 0.11926112f, 0.08052117f, 0.08252319f, 
    -0.06734549f, -0.24657518f, 0.12331603f, 0.25984251f, 0.02310360f, 0.01651627f, 0.02035698f, -0.04198183f, 
    0.13783276f, 0.00451777f, -0.02484703f, -0.01386794f, -0.05172382f, -0.07827418f, 0.05575341f, 0.02910595f, 
    0.13286643f, 0.15662260f, 0.01874714f, 0.11990851f, -0.21233805f, -0.33846447f, 0.06584025f, -0.32829404f, 
    -0.22092515f, 0.03008395f, -0.21535969f, -0.16655874f, -0.14821091f, -0.15207279f, 0.01545040f, -0.13008645f, 
    -0.13846286f, -0.08322153f, -0.17510952f, -0.00919716f, -0.20522791f, -0.28424922f, -0.12575558f, -0.30050060f, 
    0.08236181f, -0.31557789f, -0.23314181f, 0.05556390f, 0.08919996f, 0.04641558f, 0.11133803f, -0.03023729f, 
    0.08173684f, 0.01432047f, -0.07075594f, 0.03151672f, -0.00087740f, 0.06016376f, 0.01558872f, -0.01105361f, 
    0.07135679f, 0.12789638f, 0.19035022f, 0.21487108f, -0.00070089f, -0.11109680f, 0.11992478f, -0.21995609f, 
    -0.14993125f, -0.02602339f, -0.14672565f, -0.14435349f, 0.00469134f, -0.00133866f, 0.09447314f, 0.05722823f, 
    0.16144252f, -0.05298667f, -0.04701244f, 0.07867432f, 0.00882598f, -0.07601471f, -0.01603197f, -0.09498891f, 
    0.02237043f, -0.15615262f, 0.16845377f, 0.11080779f, 0.08322059f, 0.04528675f, 0.00579312f, 0.06704408f, 
    0.12131926f, -0.13881494f, -0.08383492f, 0.08147124f, -0.05195488f, 0.00148355f, -0.00342195f, -0.08465130f, 
    -0.02627372f, 0.07452524f, -0.14359035f, -0.12927519f, -0.33972850f, -0.04582377f, -0.08575541f, 0.22498003f, 
    0.12478425f, -0.14281812f, 0.06592571f, -0.09140881f, 0.12500270f, 0.09977045f, -0.05500067f, -0.02080046f, 
    0.03145285f, 0.05564418f, 0.01250926f, 0.06406114f, 0.15692961f, 0.05778300f, 0.03048763f, 0.21090083f, 
    -0.04405807f, 0.02163183f, 0.01850878f, 0.02502645f, -0.03163503f, -0.02386772f, -0.02725481f, 0.03112953f, 
    0.03311661f, 0.01151047f, -0.02980167f, -0.00780729f, 0.01017819f, 0.00156436f, -0.01632480f, -0.01346909f, 
    -0.02058061f, -0.01909823f, -0.01205449f, -0.04011498f, 0.02231047f, 0.00280271f, 0.03131232f, -0.01382317f, 
    0.01987090f, -0.03224674f, 0.02669435f, -0.00421447f, -0.00490934f, -0.00044385f, 0.02454015f, -0.04158311f, 
    0.00947811f, -0.00478794f, 0.00362912f, -0.00385571f, -0.02748888f, -0.03368944f, -0.04248308f, -0.03057649f, 
    -0.03215513f, 0.01338282f, -0.03191039f, -0.02932896f, -0.02002227f, -0.01531829f, -0.02302990f, 0.01005835f, 
    -0.02330533f, 0.00067062f, -0.02976922f, -0.00072096f, -0.02553217f, 0.03163644f, -0.02410451f, -0.03760377f, 
    -0.02887157f, 0.02698857f, 0.03244929f, 0.01240080f, -0.01068478f, 0.00180424f, -0.02528045f, -0.02936369f, 
    -0.01175108f, -0.02689300f, -0.03674826f, 0.01606219f, -0.00751772f, 0.02720806f, -0.03785139f, -0.03023486f, 
    -0.02722130f, 0.02233230f, -0.01638634f, -0.03379254f, -0.00751157f, -0.01425637f, 0.02471589f, 0.01327814f, 
    -0.00013432f, 0.01104822f, 0.02850656f, -0.03468741f, -0.00650499f, 0.02809942f, 0.00176814f, -0.03089465f, 
    0.02705526f, 0.02878457f, -0.02572829f, -0.01951935f, 0.01790303f, -0.01616373f, 0.01636484f, -0.00968883f, 
    -0.03942557f, -0.00759213f, 0.01448265f, -0.01982530f, -0.00584591f, -0.02611624f, -0.04408229f, -0.00803944f, 
    0.00845297f, 0.01570626f, -0.04203622f, 0.00760422f, -0.02926521f, 0.00631465f, 0.00048967f, 0.00234584f, 
    0.00651059f, 0.00180980f, 0.00766403f, -0.03825574f, -0.00679302f, 0.02999361f, -0.02234907f, -0.04329081f, 
    -0.03999460f, 0.01427602f, -0.01154851f, -0.02094349f, -0.01923290f, -0.03636502f, -0.04089300f, -0.02754018f, 
    -0.01876316f, 0.00096297f, -0.01384533f, -0.01888181f, 0.02322833f, -0.04465690f, -0.02124708f, -0.02982256f, 
    -0.00568128f, -0.00210655f, -0.00250305f, 0.01480241f, -0.02085711f, 0.03020384f, 0.03262846f, -0.03322957f, 
    -0.04437691f, 0.02290891f, -0.03489466f, 0.03270447f, 0.01742064f, -0.00139175f, 0.00685300f, 0.00974960f, 
    -0.01521646f, -0.03700799f, -0.02100997f, -0.02044155f, -0.03088690f, 0.02557070f, -0.03955724f, 0.00889859f, 
    -0.04230494f, -0.00818500f, -0.00223703f, -0.02591004f, 0.02149179f, 0.02602485f, -0.03393453f, 0.00180612f, 
    0.02768602f, 0.03069814f, 0.00390778f, -0.02926089f, -0.00758110f, 0.01767610f, 0.01765897f, 0.02581655f, 
    0.00833149f, -0.00717550f, -0.00818513f, -0.01517449f, 0.02325847f, -0.02819560f, -0.02771556f, -0.00227757f, 
    -0.04252723f, 0.02467097f, 0.00734743f, -0.00710053f, 0.01549987f, -0.01865811f, -0.02147476f, -0.01853259f, 
    0.01232970f, -0.02347219f, -0.02971491f, -0.00771048f, 0.00091581f, -0.01858393f, 0.01170169f, -0.00989568f, 
    0.00229239f, -0.03029427f, -0.03993288f, -0.03305194f, 0.00880080f, -0.00343563f, -0.03942702f, -0.03254530f, 
    -0.00290717f, -0.02376309f, 0.00407243f, -0.00380489f, 0.00933108f, 0.02268168f, -0.02621752f, -0.02311363f, 
    0.01416851f, 0.01492332f, -0.04131063f, -0.04412621f, 0.00727534f, -0.01177385f, 0.00096167f, 0.01912412f, 
    0.02770510f, -0.00126728f, 0.01790418f, 0.01026899f, 0.02874352f, -0.02453498f, -0.03227887f, -0.00797740f, 
    -0.01306749f, 0.01121784f, -0.00168394f, 0.00694240f, -0.03674797f, 0.00531512f, -0.01694961f, -0.03605864f, 
    -0.01028879f, -0.02739342f, -0.02613666f, -0.02173196f, -0.03070185f, -0.01900818f, -0.01652094f, 0.02626923f, 
    -0.03997768f, 0.01667827f, -0.00564317f, -0.00664732f, -0.04354094f, -0.01351818f, -0.03548519f, -0.03704828f, 
    0.00380273f, -0.02183315f, 0.01885397f, -0.02742555f, -0.03743125f, -0.02660363f, -0.01531861f, -0.02241998f, 
    0.01771331f, -0.03785945f, -0.00715435f, -0.00964635f, -0.00712423f, -0.03246306f, -0.04488881f, -0.03112798f, 
    -0.03434541f, -0.04347739f, -0.03869935f, -0.03864667f, 0.01270126f, 0.02412228f, 0.02026350f, -0.00069303f, 
    -0.02529971f, -0.04366937f, 0.02396490f, 0.00177494f, 0.03110669f, -0.01354545f, -0.03090719f, 0.01768091f, 
    -0.02848497f, -0.01715466f, -0.03633881f, -0.00360238f, 0.02710297f, -0.03895106f, 0.01792947f, 0.01045410f, 
    -0.01304669f, 0.00994109f, -0.02650497f, 0.02558976f, 0.02939390f, 0.01206075f, -0.02558836f, -0.03913928f, 
    0.02337896f, -0.02307330f, -0.03625677f, -0.03334271f, 0.01748420f, -0.03512780f, 0.01809320f, -0.00570980f, 
    0.02535999f, 0.00100381f, -0.03621214f, 0.01737645f, -0.00693242f, -0.01602060f, -0.02129014f, 0.02435369f, 
    0.01385829f, -0.02219810f, -0.02870372f, -0.02589689f, 0.01237137f, 0.02903945f, 0.01780022f, -0.04424948f, 
    -0.00017833f, -0.02945209f, 0.01870495f, -0.03806933f, 0.01510614f, 0.00350787f, 0.00462738f, 0.01799656f, 
    -0.03210196f, -0.02709657f, -0.00382257f, -0.01134494f, 0.01540860f, 0.02390457f, -0.00648842f, 0.00763959f, 
    -0.01757271f, 0.02613390f, -0.02939603f, -0.00285053f, 0.02783772f, 0.02894833f, -0.04551864f, -0.04431136f, 
    0.01766671f, -0.01083470f, 0.01406872f, 0.02869020f, -0.02314608f, 0.00747699f, -0.00742405f, -0.03873354f, 
    0.00565164f, 0.00158282f, 0.01524507f, -0.03997841f, -0.02814722f, 0.02439393f, -0.01853519f, -0.03254352f, 
    0.00347211f, 0.02405163f, -0.04490983f, 0.02796090f, -0.01508225f, -0.04279265f, 0.01865366f, 0.02208890f, 
    0.01996809f, -0.00820317f, -0.02743700f, -0.03625341f, 0.02787027f, 0.01616318f, 0.02706972f, 0.01894298f, 
    0.02916419f, -0.02122769f, 0.02465073f, -0.03688030f, -0.00064038f, -0.02113268f, 0.01408008f, -0.01557299f, 
    -0.04146807f, -0.03262623f, -0.00640352f, 0.00206147f, 0.00737469f, -0.02585664f, -0.04541556f, 0.01849634f, 
    0.01704485f, 0.01710266f, -0.00336624f, -0.03096983f, 0.01412269f, 0.01819403f, -0.02780765f, -0.00001598f, 
    0.03157894f, -0.01865166f, -0.00732757f, -0.03978493f, 0.03138082f, -0.02099652f, 0.03260315f, 0.00316973f, 
    -0.00794416f, 0.02489514f, 0.02174105f, -0.00865296f, -0.02025365f, 0.00876651f, 0.00866858f, -0.01327986f, 
    -0.02080955f, -0.01944068f, -0.01578555f, 0.01047577f, 0.02407527f, -0.01552298f, -0.03126545f, -0.01565504f, 
    0.01915522f, 0.03149754f, -0.00009973f, 0.00706252f, 0.01169757f, -0.02635865f, 0.02384087f, 0.00762543f, 
    -0.02870944f, -0.04439114f, -0.00026200f, -0.02157105f, 0.00392176f, -0.00793141f, 0.01246362f, 0.00611823f, 
    -0.04269964f, -0.03573101f, 0.00473167f, 0.02352192f, -0.00619616f, -0.01070138f, -0.03152468f, -0.02183563f, 
    -0.00355868f, 0.00836439f, 0.00232566f, 0.01269971f, 0.01053311f, -0.04188065f, -0.03601841f, 0.00089482f, 
    -0.04260390f, -0.02403227f, 0.03159289f, -0.00085819f, -0.04156523f, -0.04186948f, -0.03290876f, 0.01117355f, 
    -0.02381541f, -0.02764727f, -0.04009048f, -0.02809833f, -0.03970203f, -0.00440836f, -0.02353808f, 0.02569513f, 
    0.01263118f, -0.02613146f, 0.02572731f, -0.02309057f, -0.02514718f, -0.00914332f, -0.03614646f, 0.01583534f, 
    -0.03308218f, 0.01218956f, 0.00511774f, -0.04384128f, 0.00182876f, 0.03150290f, -0.00541875f, 0.03343714f, 
    0.01457677f, -0.02925664f, -0.00685411f, 0.01033499f, -0.02269277f, -0.01267822f, 0.01997583f, 0.01831027f, 
    -0.04075475f, -0.00130891f, -0.03217825f, -0.03619060f, -0.00952564f, -0.00814949f, -0.01264790f, -0.02566510f, 
    -0.03796212f, 0.00891158f, -0.01153784f, -0.02384560f, -0.02610011f, 0.03260465f, -0.03299718f, -0.00973084f, 
    0.00878625f, -0.00617559f, -0.00015968f, 0.00742424f, -0.01997903f, -0.02482846f, 0.01829214f, 0.00715594f, 
    0.02462176f, -0.02182109f, 0.01672926f, 0.00085563f, 0.02824467f, -0.01414985f, -0.00857653f, 0.00483166f, 
    0.00331568f, -0.01215478f, 0.03245757f, 0.00284230f, -0.01007458f, -0.04034522f, -0.00560447f, -0.03778259f, 
    0.01941323f, 0.02694967f, 0.03360478f, -0.03883098f, -0.03843621f, -0.01071183f, -0.00473727f, -0.01989673f, 
    0.01789015f, -0.00084705f, 0.02078202f, 0.00753320f, -0.01217636f, -0.04087180f, -0.02524686f, -0.03986572f, 
    0.01056796f, -0.02166646f, -0.03962505f, 0.00279592f, 0.02861854f, -0.03531983f, 0.02903510f, 0.02246499f, 
    0.02122275f, -0.02324428f, 0.00113870f, 0.01280802f, -0.01510067f, -0.03933914f, -0.03831412f, -0.02354329f, 
    -0.02489908f, -0.02845403f, 0.02154067f, -0.01955458f, -0.03611541f, 0.02355167f, -0.00953810f, -0.01270497f, 
    0.01714031f, -0.04199509f, -0.04224348f, -0.03954799f, 0.01415047f, -0.01806910f, 0.01780609f, -0.00552313f, 
    -0.00755768f, 0.03091935f, -0.03251381f, -0.01831224f, -0.00484323f, 0.01615809f, -0.03426818f, -0.01880029f, 
    -0.03738164f, 0.01567421f, 0.00607468f, -0.02876197f, 0.02582662f, 0.00599228f, 0.03035465f, -0.03251100f, 
    -0.02914069f, -0.02449252f, -0.00563295f, -0.02141575f, -0.02734679f, 0.01386178f, 0.00302197f, -0.01499123f, 
    0.03222307f, -0.00149255f, 0.02851355f, 0.02477723f, -0.02160967f, 0.01146920f, 0.02794828f, 0.01844307f, 
    -0.02854730f, 0.00191827f, -0.00131616f, 0.02008914f, -0.02449571f, -0.04364992f, 0.00850959f, -0.01752978f, 
    -0.01174063f, -0.02520482f, -0.01890752f, 0.02979895f, -0.02443925f, -0.00336187f, -0.03558270f, 0.01528601f, 
    0.18335807f, 0.10419147f, 0.18536976f, 0.29033247f, 0.04626912f, 0.14042777f, 0.12094333f, 0.08615927f, 
    -0.03477839f, -0.00267762f, 0.05042363f, 0.01562521f, 0.16848449f, 0.06451471f, 0.10683066f, 0.08928098f, 
    0.00941722f, 0.00529419f, -0.07699866f, -0.08046932f, 0.22120085f, 0.31402418f, 0.31074187f, 0.03313415f, 
    0.24914993f, 0.12072755f, -0.01231047f, 0.07188275f, 0.12507488f, -0.00120464f, 0.08598588f, -0.02639797f, 
    0.13292080f, -0.03941401f, 0.09659225f, 0.04170112f, -0.00804402f, 0.00345189f, 0.04224159f, 0.11235285f, 
    -0.85173827f, -0.15615322f, 0.09701283f, -0.33953482f, -0.29516521f, 0.17068069f, 0.17490157f, -0.21810108f, 
    -0.13391289f, -0.01819808f, 0.06866737f, 0.05295784f, 0.07408595f, 0.08270434f, -0.02346657f, -0.04067295f, 
    -0.02336205f, -0.15449339f, 0.07293881f, -0.13021122f, -0.24997221f, -0.02906767f, -0.37057272f, -0.11356606f, 
    -0.09025280f, -0.00113164f, 0.05976753f, 0.00044683f, -0.11529586f, -0.18152678f, 0.02604864f, 0.08787126f, 
    0.06602232f, -0.20851836f, 0.02568721f, 0.11650118f, 0.00076276f, 0.05857542f, -0.16128297f, -0.20775251f, 
    -0.15775383f, -0.35317248f, -0.51583666f, -0.09450167f, -0.00247899f, -0.11907564f, 0.00305646f, -0.08802009f, 
    -0.02277141f, 0.10111470f, 0.07564730f, 0.02195735f, -0.01285915f, 0.02514827f, -0.01716188f, -0.03902237f, 
    0.10664908f, -0.00031250f, 0.17557523f, -0.00852927f, 0.41875622f, -0.05299996f, -0.20222181f, -0.09137926f, 
    -0.18899755f, 0.04794401f, 0.07575389f, 0.02036043f, -0.07448191f, -0.02140701f, 0.02644258f, -0.02189127f, 
    0.10099337f, 0.03634268f, -0.03668902f, 0.05830156f, 0.13254866f, -0.01830581f, -0.12327383f, -0.01728125f, 
    -0.08466109f, -0.01074380f, -0.28544685f, 0.13249992f, 0.19194962f, 0.14065774f, 0.13156356f, 0.07952727f, 
    -0.00764651f, 0.09350675f, -0.04191468f, 0.18340045f, 0.17805733f, 0.13075678f, 0.00452095f, 0.10107804f, 
    -0.08190931f, -0.07056826f, -0.14556830f, -0.14091626f, 0.18196583f, 0.25180015f, 0.20192443f, 0.03332067f, 
    0.20058472f, 0.08203121f, 0.09549543f, 0.04512790f, -0.14518723f, -0.01000962f, 0.03076960f, -0.00072565f, 
    0.10013057f, -0.10620794f, -0.03184042f, 0.08471267f, 0.02800309f, -0.03018675f, -0.09285941f, 0.01212797f, 
    -0.32666999f, -0.25149617f, -0.19149737f, -0.45604488f, -0.14674255f, -0.10492378f, 0.05705009f, -0.07623675f, 
    -0.03967557f, -0.13779441f, 0.02469419f, 0.04719967f, 0.06657802f, 0.02880178f, 0.00229619f, 0.12432859f, 
    0.12364915f, 0.13245460f, -0.01782079f, -0.12016570f, -0.32559243f, -0.28445035f, -0.34463763f, -0.01609804f, 
    -0.10864244f, 0.18584283f, -0.05487902f, -0.22251138f, -0.10259675f, -0.00459086f, 0.17323560f, 0.10194862f, 
    0.05544324f, -0.14511885f, 0.01477060f, 0.09998613f, -0.00650345f, -0.12897083f, 0.08897634f, 0.05093503f, 
    0.03201125f, 0.07060295f, -0.04198241f, -0.44896710f, -0.18491256f, -0.22256629f, -0.14110245f, 0.06696893f, 
    0.03167641f, -0.00394541f, 0.09765113f, 0.01673577f, 0.11500429f, -0.12663734f, -0.17200460f, 0.10752221f, 
    0.06861222f, 0.02049917f, 0.02655310f, -0.06669684f, 0.14223464f, 0.22951184f, 0.15244845f, 0.16886966f, 
    -0.05709711f, -0.05137083f, 0.11239420f, 0.02526395f, 0.07683079f, -0.10049623f, 0.12149419f, -0.03300582f, 
    0.00059754f, 0.12774007f, -0.00585648f, 0.02783795f, -0.02273360f, 0.05690134f, -0.07450005f, -0.04188006f, 
    0.32175851f, -0.17992058f, 0.04772221f, -0.03316802f, -0.33769390f, -0.03406879f, -0.01757497f, 0.00532534f, 
    -0.21306492f, -0.05478369f, 0.09663670f, 0.06382822f, -0.02204563f, -0.00647841f, -0.06424265f, -0.13664499f, 
    -0.06227893f, 0.02269801f, -0.16952418f, -0.02627908f, 0.43288177f, 0.15705442f, 0.07043402f, -0.08869310f, 
    -0.16961509f, -0.14180437f, -0.04233690f, 0.01428971f, -0.10718932f, 0.12071451f, 0.09288447f, 0.07886978f, 
    0.03788690f, 0.09353946f, 0.00481365f, -0.04223227f, -0.03076361f, 0.00368687f, -0.04263160f, 0.10989295f, 
    0.30517188f, 0.42681733f, -0.00025297f, 0.14984035f, -0.04582905f, 0.04037089f, -0.11434600f, -0.00459280f, 
    0.26364619f, 0.23424542f, -0.02182217f, -0.07693095f, 0.06354154f, -0.00020725f, 0.06795908f, -0.11478461f, 
    -0.09643179f, -0.09052116f, 0.05034328f, -0.02381681f, 0.03625705f, 0.34124476f, 0.46986830f, 0.22720709f, 
    0.20604257f, 0.07284246f, -0.08491918f, 0.04265476f, 0.08599342f, 0.23499319f, 0.07192250f, -0.00743272f, 
    0.11754350f, -0.01386203f, -0.01456549f, -0.06372278f, -0.03502082f, -0.05422478f, -0.19527903f, -0.02342161f, 
    -0.13890173f, -0.07768266f, -0.13097923f, -0.04721423f, 0.05695728f, -0.06277055f, 0.02312810f, -0.10438321f, 
    0.28645983f, 0.12818480f, 0.02397940f, -0.04910540f, -0.04828534f, -0.03083398f, -0.05633139f, -0.01691938f, 
    -0.04164120f, -0.07436571f, 0.00670560f, -0.21637398f, 0.19177181f, 0.30770004f, 0.60793477f, 0.38498867f, 
    -0.04000922f, 0.14726207f, 0.08804987f, 0.04900791f, 0.15200669f, -0.05621548f, 0.10561414f, -0.02590138f, 
    0.01899863f, -0.00770855f, 0.30483413f, 0.11610359f, 0.09408260f, 0.06815898f, -0.01571588f, 0.09167385f, 
    -0.23281252f, 0.17824402f, -0.20471442f, -0.04495587f, -0.03915678f, -0.00021761f, -0.01320750f, 0.04793743f, 
    0.05822598f, -0.07620481f, 0.07556553f, -0.00054733f, 0.00820157f, -0.17287853f, -0.02133036f, -0.08527315f, 
    0.02325710f, 0.09843894f, -0.07404963f, -0.13058476f, 0.10440949f, -0.12402309f, -0.09109162f, -0.02607743f, 
    -0.06453966f, 0.16093706f, -0.02178876f, -0.13284156f, -0.13962428f, 0.20420709f, 0.00529319f, 0.00100374f, 
    -0.00423618f, 0.05106729f, 0.06668930f, 0.12234584f, 0.05874086f, -0.21746542f, 0.08760669f, 0.28229815f, 
    0.04677351f, 0.33515814f, 0.29053524f, 0.40108395f, 0.33314815f, -0.02441105f, 0.00007306f, 0.00103232f, 
    0.19396296f, 0.19492210f, 0.00086483f, 0.01858229f, -0.02289383f, 0.02304992f, -0.03532372f, -0.03092960f, 
    -0.09376455f, -0.03649505f, -0.24464028f, 0.07378074f, 1.05133402f, -0.18310946f, -0.55390584f, -0.44588768f, 
    -0.32769918f, -0.08637802f, -0.08164561f, -0.00770530f, 0.01267446f, 0.03319655f, 0.09043392f, 0.10644626f, 
    -0.09055017f, 0.10135323f, 0.05637207f, -0.00549598f, -0.04301703f, -0.07636495f, 0.15975401f, 0.08881239f, 
    -0.03597629f, 0.22779508f, 0.13924894f, 0.24752326f, 0.26513800f, -0.05821066f, -0.08537365f, 0.02764737f, 
    -0.00993874f, 0.24241360f, 0.03313470f, -0.02455478f, 0.04404815f, -0.09901717f, 0.07834891f, -0.05967866f, 
    0.00385426f, 0.11809301f, -0.39471999f, 0.11283515f, 0.32651013f, 0.02736668f, -0.02755686f, 0.00090572f, 
    -0.26035064f, 0.06878482f, 0.06060160f, 0.09592121f, 0.09719742f, -0.08185102f, 0.04081874f, -0.13675477f, 
    0.03885007f, -0.04447975f, -0.04416166f, 0.00139265f, 0.10936364f, -0.00253186f, -0.08757948f, 0.01283571f, 
    -0.29314071f, -0.07363823f, 0.03798072f, -0.09289633f, -0.03812057f, -0.01767163f, 0.12261960f, -0.06950685f, 
    0.11343247f, 0.02631209f, 0.14780544f, 0.02103475f, -0.02215959f, 0.12837957f, -0.05633613f, 0.00788358f, 
    -0.01737620f, -0.10921983f, -0.01659859f, -0.07371232f, -0.49192256f, -0.08710287f, -0.06640861f, -0.22366211f, 
    -0.03690502f, 0.00311836f, -0.00653992f, -0.14799243f, -0.09126403f, -0.01320297f, 0.06045482f, 0.01330073f, 
    -0.02085116f, 0.04301998f, -0.02164906f, 0.05465574f, -0.04175340f, -0.02168099f, 0.02989775f, 0.04269823f, 
    0.25725374f, 0.35401285f, 0.44643921f, 0.23395996f, 0.09176360f, 0.09426101f, 0.16109736f, 0.04494627f, 
    0.06775981f, 0.03503784f, 0.07191557f, -0.01761845f, 0.03107495f, 0.01038757f, 0.05632377f, -0.03036305f, 
    0.04059756f, 0.12610093f, 0.00159385f, 0.03855620f, -0.04598017f, -0.18738002f, -0.29942015f, -0.12688619f, 
    0.04563361f, 0.10726758f, 0.03733860f, 0.04407524f, -0.00120719f, -0.04424191f, 0.18608199f, 0.19319992f, 
    0.12275564f, 0.15500560f, 0.03656846f, 0.14954066f, 0.16123851f, 0.00319793f, -0.02552153f, -0.11030409f, 
    0.06677722f, 0.09677356f, 0.13885094f, 0.12938567f, -0.01476654f, 0.08614302f, 0.08487295f, -0.16870968f, 
    -0.00956031f, 0.12516658f, 0.00219819f, -0.01904766f, -0.06845351f, 0.00722087f, -0.00967758f, -0.21798904f, 
    -0.02696769f, 0.01849872f, 0.04493288f, 0.11016519f, -0.16122174f, -0.40255240f, -0.37112129f, -0.17376910f, 
    -0.09228256f, -0.04740369f, -0.00074664f, -0.09131873f, -0.06512044f, -0.10192156f, 0.05244510f, 0.11303026f, 
    0.12687728f, 0.05135413f, 0.03818572f, 0.06356702f, 0.10793272f, 0.10933816f, 0.07888699f, -0.07164588f, 
    -0.02831062f, 0.23666887f, -0.00413866f, 0.00620830f, 0.06953999f, 0.01382282f, 0.15096827f, 0.07558973f, 
    0.03944665f, -0.11816029f, -0.00748235f, -0.07678251f, -0.07212149f, 0.00532387f, -0.05150412f, -0.07175541f, 
    -0.13871792f, -0.06171387f, -0.02668659f, -0.25101480f, 0.01832382f, 0.11663131f, 0.34164923f, 0.12752560f, 
    0.13218008f, -0.02701279f, 0.05464759f, 0.02831711f, 0.03723278f, 0.07135064f, 0.06094198f, -0.07772292f, 
    0.01756318f, -0.02457074f, 0.03943802f, -0.13424540f, 0.01904750f, 0.04599929f, -0.02562581f, 0.15942018f, 
    0.02440342f, -0.01589510f, 0.00404740f, 0.02880105f, -0.02255493f, -0.03620433f, 0.02319892f, -0.02413623f, 
    -0.01344467f, -0.03983396f, -0.04536177f, -0.02316145f, -0.00018969f, -0.01642586f, 0.02708520f, -0.01058198f, 
    -0.03757812f, 0.00362979f, -0.00496175f, 0.01543722f, -0.00807536f, -0.01098602f, 0.03001734f, -0.01387146f, 
    0.00187730f, 0.01053500f, -0.00831021f, -0.02327574f, 0.02110646f, -0.02439516f, -0.00309323f, 0.00445392f, 
    -0.01139303f, -0.04241677f, 0.02575485f, 0.02072300f, -0.02439827f, -0.01543449f, 0.00838512f, -0.01552218f, 
    -0.03420619f, -0.01425359f, -0.04119567f, -0.02874200f, -0.00804736f, 0.02268388f, 0.01825932f, -0.01900917f, 
    -0.02641326f, 0.00578969f, 0.01092342f, 0.00399898f, -0.02355014f, -0.01436764f, -0.02466299f, 0.01304882f, 
    -0.01235578f, 0.00109451f, 0.01538542f, 0.00519977f, 0.02415309f, 0.02190736f, -0.01321117f, -0.01270291f, 
    -0.04267687f, 0.00451124f, -0.01409101f, 0.01840854f, 0.00517084f, 0.01477719f, 0.00077976f, -0.03760128f, 
    0.03254446f, -0.04031594f, -0.02850175f, -0.04328903f, -0.00852676f, 0.01661726f, 0.03192051f, -0.01349159f, 
    0.00424771f, 0.00190191f, -0.04515005f, -0.01237705f, -0.02875468f, -0.00668169f, 0.03013879f, -0.03681173f, 
    0.03051651f, 0.00875379f, -0.04457205f, -0.04240176f, -0.00130355f, 0.02468413f, -0.00877176f, -0.00063193f, 
    0.02168763f, -0.04238725f, -0.02873266f, 0.00406281f, 0.03231198f, 0.01332978f, -0.04133126f, -0.02172616f, 
    -0.01457712f, 0.00558565f, -0.04049084f, -0.02750378f, -0.02126960f, 0.02796804f, 0.02646308f, -0.03199075f, 
    -0.04542645f, 0.01328373f, 0.02320162f, -0.02359509f, -0.00594444f, -0.04110340f, -0.01349939f, 0.01469909f, 
    -0.03298171f, 0.03580337f, -0.00286948f, -0.00548632f, 0.01244384f, 0.02023010f, -0.03520411f, -0.01040686f, 
    -0.02754943f, -0.02537406f, -0.01028917f, -0.00513598f, -0.03031701f, -0.03318609f, -0.01015353f, -0.03170579f, 
    0.02282899f, 0.00344108f, 0.01882834f, -0.03926263f, 0.02033048f, -0.03732581f, 0.02947716f, -0.04186681f, 
    -0.04500314f, -0.00239754f, 0.02795535f, -0.02362496f, -0.00965809f, 0.01583852f, -0.02635067f, 0.02257180f, 
    0.00190185f, -0.00955168f, -0.03330131f, 0.01463507f, -0.02269275f, -0.02233503f, -0.00224767f, -0.02446316f, 
    -0.01252340f, 0.01087354f, -0.03455698f, 0.01062288f, 0.03129793f, 0.00996596f, -0.02060710f, 0.03335010f, 
    0.02763173f, 0.02861065f, -0.00192547f, 0.00742667f, -0.04074236f, -0.04052464f, 0.01087210f, 0.01039715f, 
    0.01962581f, -0.02497279f, -0.04171641f, -0.00822579f, 0.02901152f, 0.00697952f, -0.03879252f, -0.01050272f, 
    0.03137140f, -0.02351051f, -0.02995887f, -0.01069216f, -0.01820506f, -0.03756917f, 0.00587134f, -0.03251414f, 
    -0.03474386f, 0.00878738f, -0.01963688f, 0.02690068f, -0.04325574f, 0.00133733f, -0.01763966f, 0.02762361f, 
    -0.03521935f, 0.03308347f, -0.00949084f, -0.02999148f, -0.00787393f, 0.03294885f, -0.03261101f, -0.02341733f, 
    0.03056134f, 0.03206078f, -0.03793852f, 0.00962241f, -0.04356143f, -0.03144155f, -0.02424987f, -0.01185432f, 
    0.00491539f, -0.03716158f, 0.00354244f, 0.00539873f, -0.03295347f, 0.00205256f, -0.04328901f, 0.00519570f, 
    -0.02645166f, -0.01919588f, -0.02606634f, -0.04220574f, -0.03831555f, 0.01791277f, -0.03007272f, 0.02319235f, 
    -0.01468439f, 0.01256633f, 0.00751783f, 0.03138910f, 0.02486130f, -0.03732758f, 0.02321533f, -0.04065179f, 
    0.01318424f, -0.01401778f, -0.02486829f, 0.00901281f, -0.01956398f, -0.03602788f, -0.00722071f, -0.01374407f, 
    0.02689848f, -0.03209788f, -0.03567416f, 0.00977097f, -0.04272598f, -0.01101861f, 0.00959211f, 0.02672711f, 
    -0.00954885f, -0.01089238f, 0.00279722f, -0.03334213f, -0.04380516f, -0.03363545f, 0.01906044f, 0.01992885f, 
    -0.03467058f, -0.00821553f, 0.03019413f, -0.03566577f, -0.02515812f, -0.02347794f, 0.02148579f, 0.01802652f, 
    -0.04472430f, -0.02780504f, 0.01639920f, 0.02174119f, -0.00523009f, 0.01250203f, -0.02606720f, -0.01398483f, 
    -0.04159668f, 0.00547559f, 0.03225224f, -0.01754998f, -0.03813462f, 0.00886566f, 0.02403405f, -0.02390152f, 
    0.00642771f, 0.01000539f, -0.02099155f, 0.02211175f, 0.01566254f, 0.02824217f, -0.00451131f, -0.04293776f, 
    -0.03294640f, -0.01285258f, 0.02449988f, -0.00673173f, 0.01405893f, -0.01100860f, 0.01519986f, -0.01451331f, 
    0.00598161f, -0.00501946f, 0.01412905f, -0.04520861f, -0.00050752f, -0.03474857f, 0.00859543f, -0.03358020f, 
    0.00938673f, -0.02082481f, -0.00161598f, -0.03019219f, 0.00506701f, 0.02540231f, 0.02675821f, -0.02090047f, 
    0.00034050f, -0.03335483f, -0.03157330f, 0.03188043f, -0.01366159f, -0.02305355f, -0.01339707f, 0.02410012f, 
    -0.03911311f, -0.02696255f, 0.03342833f, -0.02691285f, 0.00278224f, 0.01643129f, 0.02460982f, -0.00585367f, 
    -0.03493057f, 0.00804237f, -0.02876419f, -0.04075326f, 0.03090000f, -0.03189240f, -0.02931161f, 0.02395435f, 
    0.00359686f, 0.01482945f, -0.03498421f, 0.01712123f, -0.03812068f, -0.01800593f, 0.02344516f, 0.02206441f, 
    -0.01106278f, -0.00136715f, -0.03741414f, -0.03295561f, -0.04328860f, -0.01123662f, 0.02265419f, -0.00671953f, 
    -0.00171797f, -0.04432946f, 0.02297301f, -0.02957239f, 0.01881649f, 0.02484099f, 0.01124046f, 0.00021880f, 
    0.00086372f, -0.00642294f, -0.00777487f, 0.00915078f, -0.02057072f, 0.01587624f, -0.01620448f, -0.00219201f, 
    0.02191554f, -0.00089283f, -0.02257899f, -0.04350611f, 0.00798910f, 0.02723088f, -0.03107388f, -0.03953952f, 
    0.00525410f, 0.02044241f, 0.00521818f, 0.03148466f, 0.03291598f, 0.02833742f, 0.01702321f, -0.03846482f, 
    -0.02518289f, -0.02692448f, -0.04201327f, -0.01962275f, -0.01473251f, -0.03116714f, -0.01038358f, -0.04480723f, 
    0.03194780f, -0.01489014f, -0.02740475f, 0.00783915f, 0.00276192f, -0.03501204f, -0.00939990f, 0.02282743f, 
    0.00580694f, -0.00285888f, -0.00408677f, -0.00062033f, 0.02805110f, -0.02770367f, -0.03070511f, -0.01256968f, 
    -0.01382881f, -0.01180645f, -0.04151011f, -0.01608214f, -0.03070959f, -0.03870942f, 0.02667749f, 0.02259104f, 
    0.01381699f, -0.01019080f, -0.02168957f, 0.02948096f, -0.00796770f, -0.03066877f, -0.04161066f, 0.00515538f, 
    -0.01868702f, -0.03301311f, -0.00218125f, -0.02349163f, -0.03709888f, -0.04115353f, -0.04032692f, -0.02118578f, 
    -0.00570880f, 0.02128042f, -0.02827822f, 0.02998372f, -0.00116732f, 0.02211030f, -0.03752261f, 0.01836118f, 
    -0.02669141f, 0.00098450f, -0.02049131f, 0.03216733f, 0.03075401f, -0.02774187f, -0.00863843f, -0.00081279f, 
    -0.00519899f, 0.03350421f, -0.03401489f, -0.01289790f, -0.00565419f, -0.00462596f, 0.00094210f, -0.00288834f, 
    0.01719605f, -0.02920934f, -0.01091557f, -0.03583440f, -0.04129369f, 0.01037051f, 0.02308817f, 0.00610192f, 
    0.00794045f, -0.01137932f, 0.03167157f, 0.01473322f, -0.01935337f, -0.04166426f, 0.00174132f, -0.02414206f, 
    0.01495001f, -0.02339352f, 0.02546108f, -0.04020623f, 0.03231249f, -0.02722033f, -0.01727940f, -0.02220992f, 
    -0.02055893f, 0.03338193f, -0.01550016f, 0.02781684f, -0.01771715f, -0.02135438f, 0.02997854f, -0.00529225f, 
    -0.03475275f, -0.02581462f, -0.02782690f, -0.03546388f, 0.01719920f, -0.01226590f, -0.03874345f, -0.03918517f, 
    -0.03349137f, 0.00253073f, -0.04032594f, 0.02778709f, -0.02470708f, 0.01769272f, -0.03970156f, 0.01689570f, 
    -0.02954645f, -0.03970087f, -0.04518290f, -0.01759334f, -0.01420552f, -0.01270947f, -0.04143010f, 0.00746720f, 
    0.02493110f, 0.02720486f, -0.03668740f, -0.01692086f, -0.03972225f, -0.02164711f, -0.01945503f, -0.02841368f, 
    -0.03415964f, 0.02037838f, -0.02570472f, -0.01886178f, -0.02180991f, 0.03006860f, -0.00834879f, 0.02645322f, 
    -0.02285419f, 0.02373170f, -0.02154696f, -0.03138289f, 0.03860163f, -0.01172148f, -0.00674212f, 0.00115275f, 
    0.02847133f, -0.02948569f, 0.03304568f, -0.00904222f, 0.03078117f, 0.02305960f, 0.02047321f, 0.03667557f, 
    -0.01575380f, -0.02384152f, 0.02927386f, -0.02205548f, -0.02822050f, 0.00283667f, 0.00820865f, -0.01374945f, 
    -0.04190882f, 0.00316677f, 0.01603636f, -0.01025054f, 0.00926740f, -0.01621378f, -0.01223324f, 0.02337544f, 
    0.02681072f, -0.01542507f, 0.01835350f, 0.00983511f, 0.03063080f, -0.03866003f, 0.00157378f, 0.03100547f, 
    -0.01307785f, 0.00232828f, 0.01193920f, 0.01697375f, -0.03181740f, -0.00142279f, -0.03881294f, 0.03343841f, 
    -0.00520252f, -0.03867859f, 0.02398984f, -0.01862301f, 0.02456271f, 0.01022420f, 0.00036374f, -0.03967705f, 
    0.01211986f, 0.01257510f, -0.01607118f, -0.04434657f, -0.01706243f, 0.00930344f, 0.02114671f, 0.00515590f, 
    -0.01194640f, -0.03113436f, 0.02518361f, 0.01730962f, -0.00904650f, 0.01958257f, -0.03504438f, -0.04344010f, 
    0.01038005f, -0.03452680f, 0.00519049f, -0.01889695f, 0.01515672f, -0.04099990f, 0.02114418f, -0.01728599f, 
    -0.04072745f, -0.02716334f, -0.00562691f, -0.04082980f, -0.00595724f, -0.03557995f, 0.02661947f, 0.00710968f, 
    -0.03741172f, -0.01542213f, -0.01146042f, -0.00207519f, -0.03644237f, -0.03599252f, -0.04200001f, -0.00109103f, 
    -0.01384604f, -0.04076907f, 0.03273559f, 0.01105143f, -0.00824942f, 0.01310049f, 0.01035193f, -0.04326513f, 
    -0.01341295f, 0.00963025f, 0.01826495f, -0.00569799f, -0.03050344f, 0.02708815f, -0.03252361f, 0.00827147f, 
    0.02203928f, -0.03670904f, 0.03387362f, -0.01344996f, -0.00536614f, -0.04386629f, -0.03728884f, -0.02643208f, 
    -0.04488913f, 0.02284044f, -0.04058878f, -0.01201712f, 0.02558703f, 0.02354491f, 0.00952504f, -0.01852866f, 
    -0.01566741f, -0.00959945f, 0.00052515f, -0.00564248f, 0.00837209f, 0.01423144f, 0.00410506f, -0.03240282f, 
    0.00382166f, 0.02248430f, -0.03406524f, -0.03637784f, -0.00932524f, 0.01359421f, -0.00011959f, -0.04230358f, 
    -0.04376787f, -0.03229500f, 0.02714716f, 0.00482299f, -0.00531229f, 0.01351626f, -0.00139180f, -0.00310944f, 
    0.01741711f, -0.00722266f, 0.01631169f, 0.01417463f, 0.02204314f, 0.01843672f, 0.02041532f, -0.03205902f, 
    0.03209385f, -0.00355696f, 0.01834626f, -0.00940207f, 0.00340530f, -0.04066692f, -0.04272669f, -0.02243472f, 
    -0.01025931f, -0.03184735f, -0.04396066f, 0.02799498f, -0.00842305f, 0.02318019f, 0.01756993f, -0.00647355f, 
    0.01754652f, 0.03307990f, -0.03833301f, -0.04029484f, 0.03275310f, 0.02217007f, -0.03632725f, -0.00825939f, 
    0.00392714f, -0.03757355f, 0.01654824f, 0.03183892f, 0.00455907f, 0.01170171f, 0.01908189f, 0.01879347f, 
    -0.01896286f, -0.04455908f, -0.01614653f, -0.00352085f, 0.00635048f, 0.01416778f, -0.04013545f, 0.03376207f, 
    -0.00139491f, -0.01279184f, -0.03156216f, -0.00195919f, -0.02659588f, 0.00720372f, 0.00012778f, -0.00700381f, 
    -0.01101521f, -0.00570702f, -0.04202335f, 0.03088413f, 0.00244128f, 0.01083399f, -0.02994716f, 0.01529349f, 
    0.01206712f, 0.00928999f, -0.02692424f, -0.00188551f, -0.04367701f, 0.02986985f, -0.00422652f, -0.03493355f, 
    -0.01948030f, -0.01449343f, -0.03896211f, -0.03965650f, 0.00245354f, -0.03997116f, -0.01513849f, 0.01056960f, 
    0.00153357f, -0.01099671f, 0.02037114f, 0.01027302f, 0.02632475f, -0.03383236f, -0.01335168f, -0.03603986f, 
    -0.01476605f, 0.02346997f, 0.00858337f, -0.00346622f, -0.04185114f, -0.03842500f, 0.01698554f, -0.03994204f, 
    0.03091631f, 0.02731324f, 0.01452384f, -0.03166470f, -0.04443745f, -0.04126462f, 0.02432152f, 0.01011754f, 
    -0.01072905f, 0.02958762f, -0.02824288f, -0.02662230f, 0.01150498f, -0.02270806f, 0.00230270f, 0.01518055f, 
    -0.02539186f, -0.02287826f, -0.00956924f, -0.00224432f, 0.03213236f, -0.02509370f, -0.04358461f, 0.00485224f, 
    -0.01187204f, -0.04260666f, -0.01337413f, -0.00041712f, -0.00541334f, -0.00760877f, -0.01527499f, -0.03587618f, 
    0.03180094f, -0.01403806f, -0.01480042f, 0.00924594f, -0.04249132f, -0.01645317f, 0.01830002f, -0.03139361f, 
    0.02199395f, 0.02457644f, -0.00173844f, -0.02180413f, -0.03618979f, -0.01509691f, 0.01702498f, -0.00346387f, 
    0.02436950f, -0.02657756f, 0.01891501f, -0.03289434f, -0.03724746f, -0.04328623f, 0.02747535f, -0.03284562f, 
    -0.02023274f, -0.01755068f, 0.00577182f, -0.04357293f, -0.02298778f, 0.01891343f, -0.02170820f, -0.01013340f, 
    0.01918648f, -0.01516758f, 0.00559427f, -0.03651041f, -0.03766200f, 0.01661487f, -0.01492263f, 0.00853696f, 
    -0.01755380f, -0.01640962f, -0.04457970f, -0.02414116f, -0.03878924f, -0.01353427f, -0.01010392f, 0.01752949f, 
    0.02435651f, -0.01065409f, 0.01917919f, 0.01707667f, -0.01397366f, 0.00170939f, -0.02355582f, -0.03215622f, 
    0.00224018f, -0.03742904f, 0.03229221f, 0.01986991f, -0.00814030f, -0.02559310f, -0.02861606f, -0.00612116f, 
    0.01912532f, -0.02751916f, -0.02175179f, 0.00741073f, -0.04069389f, 0.00040617f, -0.04172957f, 0.03028115f, 
    -0.04412296f, -0.00306319f, 0.02464583f, -0.02792870f, -0.01588832f, 0.01998651f, -0.03753540f, -0.01936975f, 
    -0.02888719f, -0.03338268f, -0.01755163f, -0.01815230f, -0.00515659f, -0.00200789f, -0.01890257f, -0.02549603f, 
    0.01138984f, 0.00637651f, -0.01100392f, 0.00926882f, 0.01841572f, -0.00890497f, -0.04002836f, -0.03175960f, 
    -0.04119571f, 0.00596468f, -0.03820965f, -0.01680596f, 0.00266115f, 0.00438743f, -0.04392797f, 0.03142592f, 
    0.02318979f, -0.01896462f, -0.02458743f, -0.00240047f, -0.02977684f, -0.01693868f, 0.01473272f, -0.04296987f, 
    -0.02193852f, -0.02398053f, 0.00145148f, 0.00279846f, 0.03347841f, -0.03695245f, -0.02314864f, 0.00255922f, 
    0.01073886f, -0.01008327f, -0.03731215f, 0.00829975f, 0.02509299f, 0.03001575f, 0.02452574f, 0.00433538f, 
    -0.02598475f, -0.01844524f, -0.01310364f, 0.01889083f, 0.01008274f, 0.03374811f, -0.01046426f, 0.02849089f, 
    -0.03777352f, 0.01490490f, 0.01900335f, -0.03620685f, -0.04419347f, -0.03295637f, 0.00531313f, -0.02413730f, 
    0.01405394f, 0.02548794f, 0.02274458f, -0.00074000f, -0.00968751f, -0.00040331f, 0.01061861f, 0.01694540f, 
    0.00606072f, 0.01468106f, 0.00887761f, -0.02361160f, 0.00970419f, -0.03803541f, 0.03134284f, 0.01631127f, 
    0.00503752f, 0.00957228f, -0.04325661f, -0.02975470f, 0.02202076f, 0.02309356f, -0.01937751f, -0.02883768f, 
    -0.03982872f, 0.00678816f, -0.02666733f, -0.02061601f, -0.01703439f, 0.01995499f, -0.04461643f, 0.00526165f, 
    -0.00839501f, -0.02596802f, -0.02217861f, -0.00203054f, 0.01679207f, 0.00890485f, -0.02201865f, 0.00701739f, 
    -0.01605017f, -0.03061083f, -0.01535721f, -0.02865474f, -0.03634992f, 0.01403615f, -0.01845351f, -0.00906730f, 
    -0.00969821f, -0.03651587f, 0.03256708f, 0.01730867f, -0.01014883f, 0.00505503f, -0.01583539f, 0.02221850f, 
    0.01386980f, -0.01102298f, -0.00072481f, -0.03193540f, -0.03830385f, 0.01613225f, 0.00372102f, -0.03206323f, 
    0.02008337f, 0.02512490f, -0.01597076f, -0.02702151f, 0.00387443f, -0.04095931f, -0.00421509f, -0.01787419f, 
    0.02046126f, 0.00213688f, -0.02208497f, -0.00740911f, -0.01034112f, -0.00456567f, -0.01612800f, 0.00250386f, 
    0.01255961f, -0.03449256f, 0.01392881f, -0.02829576f, 0.02271646f, -0.00580671f, -0.01689799f, 0.03065855f, 
    0.00532586f, 0.00179996f, -0.00787974f, -0.02997824f, -0.03830627f, -0.02698215f, -0.01354426f, 0.00030712f, 
    -0.00911427f, 0.03352355f, -0.03063194f, 0.02739013f, 0.03367078f, -0.02156250f, -0.00947236f, -0.01844449f, 
    -0.01182877f, 0.02035000f, -0.02736739f, 0.02036794f, 0.01306501f, 0.03105869f, -0.00347346f, 0.00400108f, 
    -0.03433029f, -0.03185783f, -0.00560012f, 0.02943866f, -0.03084761f, 0.01253015f, 0.02643897f, -0.00289405f, 
    0.03363777f, -0.02094198f, 0.00635715f, 0.00992164f, 0.01543062f, 0.00102089f, 0.02568353f, 0.03239749f, 
    0.03102818f, -0.03460551f, 0.03193224f, -0.00561413f, -0.03936798f, -0.02133006f, -0.02353672f, -0.04383260f, 
    -0.01368773f, 0.00225361f, 0.03360127f, -0.01452177f, 0.01478077f, -0.01083030f, 0.01875977f, -0.01530725f, 
    0.00728968f, 0.02815395f, 0.01321441f, -0.03497234f, -0.01901374f, 0.03239566f, -0.03338238f, 0.01048384f, 
    0.03372192f, 0.00440925f, -0.00589111f, 0.01149428f, 0.00615271f, -0.03621390f, -0.02374909f, 0.00857598f, 
    -0.01327583f, 0.03037152f, 0.02152630f, -0.01891962f, -0.04405157f, -0.00234190f, 0.02199905f, -0.03810952f, 
    0.01700478f, -0.01824117f, 0.01288567f, 0.02618174f, -0.00001751f, 0.02017899f, 0.01108589f, 0.02855271f, 
    0.03222087f, -0.02127802f, -0.01581393f, -0.02158201f, 0.00176188f, -0.01318471f, -0.03607084f, 0.00991390f, 
    0.02685870f, -0.02613483f, -0.02611694f, -0.03237782f, -0.02450632f, -0.03703964f, -0.02812554f, -0.03754787f, 
    -0.03597372f, -0.02676100f, -0.00715021f, 0.02240228f, -0.04390702f, -0.04046782f, 0.02246604f, 0.02130742f, 
    -0.00259174f, -0.01736806f, -0.04304013f, 0.01317891f, -0.03032001f, -0.04068558f, 0.01283487f, 0.01467796f, 
    -0.00637577f, 0.00780955f, -0.03992318f, -0.03655641f, -0.01926815f, -0.03921241f, -0.02103613f, 0.01836668f, 
    0.01782656f, -0.02797308f, 0.01076044f, -0.01270090f, 0.02649075f, 0.02441547f, 0.02079769f, -0.02219555f, 
    -0.03506465f, -0.01365399f, -0.04108474f, -0.04247479f, -0.02445831f, -0.00918277f, -0.02455400f, 0.00464729f, 
    -0.01262469f, -0.03940349f, 0.02641768f, 0.01315324f, -0.02812643f, -0.01208698f, -0.03988721f, -0.03481788f, 
    -0.00710221f, -0.02618206f, -0.03622228f, 0.01580263f, -0.00269906f, -0.04353670f, -0.00421654f, -0.01634456f, 
    0.03269754f, 0.01926868f, 0.01205601f, 0.00551105f, 0.00007349f, -0.04176363f, -0.01530014f, 0.01659042f, 
    -0.01886857f, 0.02105305f, -0.04122510f, 0.00143058f, -0.00611735f, -0.02734590f, -0.01670827f, -0.00611955f, 
    -0.01170555f, 0.00362951f, -0.01806790f, 0.01412646f, -0.01570385f, 0.00424231f, 0.02243798f, -0.04019708f, 
    -0.04051953f, 0.00578126f, -0.02537136f, -0.00459705f, 0.00893281f, 0.01966533f, 0.01529702f, 0.02914059f, 
    -0.01327997f, 0.00694442f, -0.01133484f, -0.02544538f, -0.00961646f, 0.01579187f, -0.01337211f, -0.03685952f, 
    -0.04018143f, -0.03357123f, -0.02418257f, 0.01493592f, -0.00494326f, -0.01420493f, -0.03356870f, -0.02323638f, 
    0.03152328f, -0.03653764f, -0.04247514f, -0.03524091f, -0.03282280f, -0.01721078f, -0.03082206f, -0.02385884f, 
    0.03364419f, 0.00304370f, -0.04101886f, -0.00605541f, -0.03233505f, -0.01904950f, -0.04315389f, 0.02528480f, 
    0.00860383f, -0.01433240f, -0.01776604f, -0.00169708f, -0.04336537f, -0.04282077f, -0.03731596f, 0.02667382f, 
    -0.01304996f, -0.00104070f, -0.04831494f, 0.02151356f, -0.04429320f, -0.03205370f, 0.03287494f, -0.03017860f, 
    -0.04622231f, -0.00912679f, 0.02170681f, -0.03001315f, 0.00212623f, 0.02096120f, 0.00071154f, -0.02373515f, 
    0.00644959f, -0.00669087f, -0.03696717f, -0.00506979f, -0.02790636f, 0.00217316f, -0.00230850f, -0.03958990f, 
    0.01938981f, 0.02303861f, 0.00440649f, -0.00262928f, 0.01400234f, 0.01598186f, 0.01945869f, 0.00078695f, 
    0.03591020f, 0.01344601f, 0.01686155f, -0.02630998f, -0.01245651f, -0.03265023f, 0.02841810f, 0.02123545f, 
    0.02325394f, -0.01837822f, -0.02031632f, -0.03944506f, 0.03621807f, -0.02210564f, 0.03296094f, 0.01094926f, 
    0.03475534f, -0.03196284f, 0.02651009f, 0.01767226f, -0.03409444f, 0.01955909f, -0.03076932f, 0.02384356f, 
    0.01008268f, -0.02584755f, 0.03733283f, -0.02502918f, 0.01746339f, -0.01836875f, -0.01009939f, -0.01202659f, 
    -0.04420784f, 0.00844553f, 0.00499690f, -0.00696154f, -0.03098031f, -0.03515475f, 0.02061747f, -0.02597332f, 
    -0.03665889f, 0.02043890f, 0.00605859f, -0.02896611f, -0.03207958f, -0.04554165f, -0.01689637f, 0.00083973f, 
    0.00157576f, 0.04119500f, -0.03660876f, 0.03837427f, -0.00215579f, 0.02549131f, -0.04054848f, -0.04574757f, 
    -0.00838253f, 0.01067527f, -0.02516373f, -0.00333064f, 0.00116168f, 0.02248206f, 0.00547941f, 0.01717679f, 
    0.03316075f, -0.00997837f, 0.02330538f, 0.01701331f, 0.03169092f, 0.00551256f, -0.04551805f, -0.00555034f, 
    -0.01994085f, -0.03835088f, 0.02268752f, 0.01291509f, 0.02549509f, 0.02421520f, 0.00531462f, 0.00846251f, 
    -0.01799212f, 0.00973565f, -0.03013505f, 0.03215558f, -0.03213793f, 0.00396920f, -0.01058800f, 0.03189285f, 
    -0.01287035f, 0.01561821f, 0.00406056f, -0.00162320f, 0.01796694f, -0.01418590f, -0.00788865f, -0.01583254f, 
    0.01527399f, 0.00984698f, -0.01145230f, -0.00511924f, 0.00020010f, 0.02807530f, -0.02342914f, -0.01568425f, 
    -0.01311267f, -0.02145018f, -0.01984040f, 0.03288237f, -0.00972734f, -0.01234355f, 0.01727267f, -0.02743358f, 
    -0.01628833f, 0.02198981f, 0.00315348f, 0.00369322f, -0.02716088f, 0.02276637f, -0.00222300f, -0.00166463f, 
    -0.01043747f, -0.04473739f, -0.02355344f, 0.03324101f, 0.01587143f, -0.01341534f, -0.00678509f, -0.02221282f, 
    0.03860654f, 0.03629518f, -0.03876279f, -0.01361374f, 0.00703278f, -0.02461568f, 0.00722206f, 0.03057674f, 
    -0.00370450f, -0.02935354f, -0.03152820f, 0.02151347f, -0.01166146f, -0.00179376f, 0.00624360f, 0.01730339f, 
    0.02320501f, -0.03111353f, 0.01059914f, -0.00024384f, 0.01135753f, 0.00349050f, -0.01930141f, 0.02838271f, 
    0.01185962f, 0.02323744f, -0.03427702f, -0.00200254f, -0.00231463f, -0.02463892f, -0.01674219f, -0.02835026f, 
    -0.05067021f, -0.00127719f, -0.02912152f, -0.03269043f, 0.00760510f, -0.01626168f, -0.00767292f, 0.03925031f, 
    -0.02310364f, -0.00193786f, 0.02672161f, 0.00189561f, -0.01496959f, -0.03401350f, 0.02296405f, 0.01319032f, 
    0.00200275f, -0.00686687f, -0.03922165f, 0.00296735f, 0.01233493f, 0.03231928f, -0.00507380f, -0.01940390f, 
    0.00961320f, 0.00607586f, -0.01364563f, -0.03617555f, -0.00340783f, -0.03138665f, -0.04968629f, -0.02863715f, 
    0.02322189f, -0.04101035f, -0.01206336f, -0.03253160f, -0.01507412f, -0.00216664f, 0.00668264f, -0.02605778f, 
    -0.04346520f, -0.04785189f, -0.01477951f, 0.02290511f, 0.02655702f, 0.00429323f, -0.00198650f, 0.02214416f, 
    -0.02516432f, -0.02966775f, 0.01366017f, 0.01295360f, 0.00037297f, 0.01833180f, -0.01249365f, 0.00208207f, 
    0.01095910f, 0.02995829f, -0.02259070f, 0.01504815f, 0.00107996f, -0.02516613f, 0.01864300f, 0.02447035f, 
    -0.04465935f, 0.02686190f, -0.01826837f, -0.04401820f, -0.01517147f, -0.00245526f, -0.03348865f, -0.03421644f, 
    -0.03769557f, -0.04253538f, -0.01929875f, -0.01915661f, -0.01134135f, 0.01795748f, -0.02384842f, -0.01835464f, 
    0.01287586f, 0.02694918f, -0.01770736f, -0.04005032f, -0.00600291f, -0.01644691f, -0.00144309f, -0.02621119f, 
    0.00312838f, 0.02089383f, -0.01518865f, 0.01224384f, -0.01770804f, -0.03403382f, 0.00480913f, 0.02735141f, 
    -0.04248419f, -0.04246926f, -0.00988260f, -0.05090658f, -0.04296976f, -0.00130346f, 0.00950452f, -0.03360643f, 
    0.03815696f, 0.00038845f, 0.00791040f, -0.00410836f, -0.04554982f, -0.04583343f, -0.00409624f, -0.00356232f, 
    0.00826746f, 0.00445370f, -0.03319541f, 0.03151856f, -0.02945368f, 0.00895357f, 0.02478181f, 0.00248109f, 
    -0.01638277f, -0.02321358f, 0.00534523f, 0.00896786f, 0.02251597f, 0.00713250f, -0.03102968f, 0.01311617f, 
    -0.05016650f, 0.03580947f, -0.04176058f, 0.03380664f, 0.02385312f, 0.01623387f, 0.02995659f, -0.01097304f, 
    -0.04252996f, -0.03874185f, -0.03843476f, 0.00554102f, -0.01327438f, 0.03289888f, -0.03762645f, -0.00195100f, 
    -0.03288541f, 0.00966750f, -0.02865254f, 0.01520681f, -0.05429153f, -0.01718017f, -0.00803383f, -0.00528512f, 
    -0.02277029f, 0.00923153f, 0.00675199f, -0.02956913f, 0.03536968f, -0.02546838f, -0.00205876f, -0.00958979f, 
    -0.02978940f, 0.01958686f, -0.03270908f, 0.02911675f, -0.01031851f, -0.04012703f, 0.00659582f, -0.00318955f, 
    -0.02728516f, -0.00773290f, -0.01788218f, -0.01766036f, -0.04625108f, -0.03639856f, 0.02683627f, -0.02996822f, 
    0.02204163f, -0.03560129f, 0.02552049f, -0.04074825f, 0.01737789f, -0.00030334f, 0.02922754f, -0.00208703f, 
    0.01267842f, 0.02566695f, 0.03343653f, -0.00632358f, 0.00907060f, -0.04316574f, 0.01996165f, -0.01679659f, 
    0.01122457f, 0.00198996f, -0.00628273f, 0.02902549f, 0.02808042f, -0.01712070f, 0.02276342f, -0.03298142f, 
    -0.00301004f, -0.00539177f, -0.02118699f, 0.02047889f, 0.02165372f, 0.00670569f, 0.02386100f, 0.01995645f, 
    -0.02360831f, 0.00956123f, -0.02162223f, 0.02538788f, 0.00309508f, 0.01995581f, -0.02536593f, -0.00636639f, 
    0.02665806f, 0.01271197f, -0.03088063f, -0.01251458f, 0.00685122f, -0.00739834f, -0.04041193f, 0.00226836f, 
    0.03272576f, 0.03185945f, -0.03636140f, -0.00234044f, -0.01519982f, -0.01081527f, 0.01781273f, 0.00709940f, 
    -0.03902921f, -0.01591596f, 0.03274580f, 0.02371039f, -0.00371552f, -0.03599110f, -0.00693242f, -0.01025697f, 
    -0.02203993f, 0.00917310f, 0.00993226f, 0.02262257f, -0.00753017f, 0.02728018f, -0.01151658f, -0.01502137f, 
    0.00980626f, 0.01201917f, -0.03747055f, -0.00631618f, -0.04067472f, -0.01516306f, 0.00299529f, 0.01823085f, 
    -0.02334184f, 0.02102378f, 0.00946041f, -0.02112873f, -0.02963572f, -0.01775209f, -0.02949247f, 0.00270019f, 
    0.03248709f, 0.00282246f, 0.00574961f, -0.01894563f, -0.02353370f, -0.00399120f, 0.01443153f, -0.05092046f, 
    0.02241860f, 0.00950768f, -0.01821710f, -0.03316985f, -0.02254066f, 0.01007667f, 0.01329352f, 0.00994729f, 
    0.01209363f, -0.02348137f, 0.00227119f, -0.01948992f, -0.02428559f, -0.01844797f, 0.01895759f, -0.04181366f, 
    -0.01251017f, -0.03249460f, -0.02228123f, -0.00621622f, 0.02866674f, 0.02075196f, 0.00246657f, 0.02665860f, 
    -0.02879917f, -0.03670093f, -0.01844678f, 0.02257408f, -0.01900929f, 0.01031453f, 0.01685260f, -0.02387537f, 
    -0.01226466f, -0.01773674f, -0.03339629f, 0.02045062f, -0.01503863f, -0.05474947f, 0.02664132f, 0.02568594f, 
    -0.01818078f, -0.01702645f, 0.02512950f, -0.00414243f, -0.03759504f, -0.02807776f, 0.03228566f, -0.00883163f, 
    0.03415468f, 0.03645790f, 0.01356362f, -0.02707722f, 0.00874061f, 0.00226088f, -0.03548939f, -0.04779569f, 
    -0.00067540f, 0.00908118f, -0.02893678f, -0.02166150f, 0.01374907f, 0.00529675f, -0.01406995f, 0.03288900f, 
    0.00833278f, -0.02458692f, -0.00084634f, -0.05178921f, -0.00775328f, -0.02378823f, 0.01023876f, 0.01770584f, 
    0.00063863f, 0.00057009f, 0.00275075f, -0.03612204f, -0.01460528f, 0.02349563f, 0.00026330f, -0.03058420f, 
    -0.02815040f, -0.04255392f, -0.00934841f, 0.02728082f, 0.01230941f, -0.02758113f, 0.03393377f, 0.03395882f, 
    -0.00088665f, 0.02109864f, -0.03461600f, 0.00733296f, 0.00162427f, -0.03489304f, -0.00982981f, -0.00945217f, 
    -0.00872462f, 0.01904289f, -0.03724187f, -0.00151089f, -0.02344930f, -0.00447307f, -0.05039157f, -0.01646003f, 
    0.01587761f, -0.04346487f, -0.04065019f, -0.01713159f, 0.01416236f, 0.02167556f, -0.00181086f, -0.03372481f, 
    -0.04013542f, -0.02670167f, -0.02862551f, 0.01873928f, -0.02695312f, 0.00199018f, -0.00196387f, -0.02676693f, 
    -0.04227562f, -0.01122417f, 0.00878504f, -0.02692344f, -0.00452937f, 0.00582595f, -0.00916008f, 0.00227563f, 
    0.02675349f, 0.02011715f, 0.03236206f, 0.02357111f, 0.03764201f, 0.01531111f, 0.00224739f, -0.01889004f, 
    -0.03886751f, 0.00722102f, 0.02020426f, -0.00736592f, -0.04553239f, -0.00116019f, -0.03660015f, 0.03363730f, 
    0.02447976f, 0.03430759f, 0.02135704f, -0.02649756f, -0.01396360f, 0.00123479f, -0.00056011f, 0.03584517f, 
    0.02404280f, -0.03835637f, 0.00894083f, -0.01992821f, -0.00030055f, 0.01162699f, -0.01085021f, 0.02360763f, 
    -0.03710981f, -0.03466490f, -0.00446723f, 0.02299546f, -0.03440057f, -0.01969308f, 0.01621095f, -0.04809547f, 
    -0.01896698f, -0.00540927f, -0.03154536f, -0.04160072f, 0.01671523f, -0.00522174f, 0.02428457f, -0.03907346f, 
    -0.01129105f, -0.01151207f, -0.03925335f, 0.01299464f, 0.02162154f, -0.03779042f, -0.02354301f, -0.04700050f, 
    -0.02365185f, -0.00514773f, -0.03354667f, 0.02241069f, -0.03146506f, 0.00598579f, 0.01302230f, 0.01773351f, 
    0.01941568f, -0.00481269f, -0.01245833f, 0.02442601f, 0.02897458f, -0.03499177f, 0.03365299f, 0.02878367f, 
    -0.01736712f, 0.01510453f, 0.02632132f, -0.02900746f, 0.01438906f, -0.01531244f, 0.02598201f, -0.00404040f, 
    -0.00868782f, 0.00333173f, 0.00283650f, 0.03218596f, -0.02493837f, 0.01181401f, -0.01838315f, -0.00945813f, 
    -0.01717503f, -0.03238793f, 0.00629199f, -0.00599124f, -0.04208371f, -0.00563082f, -0.02956927f, -0.00742763f, 
    -0.01805050f, -0.04252246f, -0.02268879f, -0.02714954f, 0.02467088f, -0.03747901f, -0.01524851f, 0.02019583f, 
    -0.01375877f, 0.02772078f, -0.00108852f, 0.01160451f, -0.01442000f, -0.03245440f, -0.00431059f, -0.03542859f, 
    0.02782664f, -0.01610610f, 0.02022852f, -0.01414736f, 0.00213347f, -0.01507345f, 0.01799696f, -0.02047582f, 
    -0.04456259f, -0.04708974f, -0.03065584f, -0.03707565f, 0.01239885f, -0.04148251f, -0.02016982f, 0.01944390f, 
    0.02677206f, -0.00841809f, -0.00055692f, 0.02861970f, -0.00517276f, 0.02976226f, -0.02378265f, 0.02278724f, 
    -0.03268681f, 0.02624132f, -0.02141908f, 0.01586291f, 0.00649060f, -0.02187972f, 0.01460761f, -0.01772471f, 
    -0.02709800f, -0.04059693f, 0.03420638f, 0.01432823f, -0.02955068f, 0.02319056f, 0.02785768f, -0.03551010f, 
    0.00259465f, -0.02937111f, -0.02543985f, 0.03090278f, 0.02283049f, -0.04327910f, -0.02159153f, 0.02304399f, 
    -0.00054741f, -0.03471060f, -0.00486112f, -0.02399511f, -0.01591054f, 0.01149076f, 0.01698148f, 0.01865375f, 
    -0.03955826f, -0.01212872f, 0.03130227f, 0.00215416f, -0.01807327f, -0.02304380f, -0.00437292f, 0.00701097f, 
    0.00209500f, 0.00528885f, 0.03565890f, -0.02941829f, -0.01569018f, 0.00013636f, -0.01323091f, 0.01766340f, 
    0.02840606f, -0.02102304f, -0.02738636f, -0.00055914f, -0.01395294f, -0.03267086f, -0.04201165f, -0.02951582f, 
    0.00742277f, -0.04143325f, -0.02928360f, -0.00888755f, -0.02499097f, 0.00952152f, -0.00881732f, -0.04301477f, 
    -0.02377464f, 0.03186652f, -0.02553370f, -0.03643885f, -0.03971262f, -0.02940293f, 0.01184399f, -0.04364353f, 
    -0.02505970f, 0.01355417f, -0.01542873f, 0.01467272f, -0.00492434f, 0.01460046f, -0.01220260f, -0.00879527f, 
    0.02902499f, -0.01068612f, 0.00412803f, -0.04428161f, -0.02742365f, -0.02729211f, -0.04692370f, 0.00296342f, 
    0.00825932f, 0.03130613f, -0.00237659f, -0.01221678f, -0.03911915f, -0.01742508f, 0.00710221f, -0.01183360f, 
    0.02442401f, -0.04711614f, -0.00085894f, -0.02658159f, 0.00984418f, 0.00068121f, -0.01879182f, 0.01173385f, 
    -0.01698791f, -0.00016608f, -0.03355452f, 0.01238956f, -0.01830835f, -0.03799583f, 0.01163800f, 0.01783350f, 
    0.03041989f, -0.00112308f, 0.02706971f, 0.00379827f, -0.03897592f, 0.01484192f, -0.04175030f, 0.01389772f, 
    -0.04624742f, -0.03822393f, 0.02886540f, 0.00255666f, 0.04138310f, -0.02282615f, 0.01074787f, 0.01619172f, 
    0.02105287f, 0.03103823f, -0.01529330f, -0.03070472f, 0.00859293f, 0.00147806f, 0.00245783f, 0.02425312f, 
    -0.02604673f, -0.03817298f, -0.00154557f, -0.02476280f, -0.03891601f, -0.00831674f, -0.01212740f, -0.01130688f, 
    -0.00626994f, -0.04506074f, -0.04436980f, -0.03225742f, 0.02539799f, -0.03627796f, 0.00577488f, 0.02770139f, 
    0.00262172f, -0.01800782f, -0.02928563f, 0.00906716f, -0.03397549f, 0.00470278f, -0.01939950f, 0.01346636f, 
    -0.00120036f, 0.02033760f, -0.00665141f, 0.01268344f, -0.01346823f, 0.01171243f, 0.01155846f, -0.02603713f, 
    0.02555252f, 0.00437918f, -0.01839543f, -0.01284347f, 0.00138228f, -0.02404229f, 0.01716843f, -0.01037840f, 
    -0.02196868f, 0.00573954f, -0.02986480f, -0.04063062f, -0.01407778f, -0.02149818f, -0.01999362f, -0.02563278f, 
    -0.04643568f, -0.00089365f, 0.02619933f, 0.00654370f, 0.00234531f, 0.01484019f, -0.00695049f, 0.00305754f, 
    0.02318383f, -0.04650783f, -0.03436456f, -0.01803610f, -0.02662713f, 0.02544892f, 0.01905755f, 0.00124012f, 
    -0.02129135f, 0.01156574f, 0.00783615f, -0.04066471f, 0.02905105f, -0.02301417f, -0.00842512f, -0.00173796f, 
    -0.01180501f, -0.02338281f, -0.00571349f, -0.04482561f, 0.01278755f, 0.00411929f, 0.03106875f, -0.04416126f, 
    -0.02783592f, -0.00260872f, 0.01605361f, -0.01951858f, -0.01599286f, 0.01850509f, 0.01055478f, 0.01834577f, 
    -0.02158738f, 0.01019079f, -0.02221924f, -0.01395264f, -0.01191777f, -0.01965507f, -0.03570854f, -0.01944704f, 
    0.04072610f, -0.00051661f, 0.02433673f, -0.01727859f, -0.01518440f, 0.01897210f, -0.00328811f, -0.01874185f, 
    0.01258661f, -0.00513682f, 0.02225286f, 0.01552912f, -0.04516981f, -0.04305299f, -0.02189783f, 0.01228398f, 
    -0.01720335f, -0.00832990f, 0.02677112f, 0.01747646f, 0.02710306f, 0.02098594f, -0.04074762f, -0.01450872f, 
    -0.01067018f, 0.03056386f, 0.01719971f, -0.01816433f, 0.00029051f, 0.00948566f, 0.01385536f, -0.03207333f, 
    0.02631446f, -0.03805009f, 0.02142821f, 0.00154261f, 0.02237152f, -0.02827768f, -0.02284929f, -0.00948928f, 
    0.01078975f, -0.04116348f, -0.00927085f, -0.01652679f, -0.00582844f, 0.01232896f, -0.04604600f, -0.03461249f, 
    -0.01357376f, -0.02036735f, -0.02761634f, 0.02038931f, -0.00932229f, -0.02236893f, -0.04460376f, -0.02814271f, 
    -0.00011874f, -0.02114466f, 0.01824848f, -0.03054677f, -0.03360125f, -0.03839993f, 0.00958207f, -0.03342294f, 
    -0.03041742f, -0.00572354f, -0.02907020f, -0.03100834f, -0.02587451f, -0.04613433f, 0.01107675f, 0.01017079f, 
    -0.01568566f, -0.00195651f, -0.04563437f, 0.00403185f, -0.04579377f, 0.02558966f, -0.03119639f, -0.01501511f, 
    0.03358924f, 0.03136087f, 0.02361572f, 0.01246287f, -0.04311256f, 0.00233622f, -0.01814155f, 0.04076875f, 
    -0.01377441f, -0.00529797f, -0.02196890f, 0.00235636f, -0.00201294f, -0.01232962f, -0.02677615f, -0.00818051f, 
    -0.02678940f, 0.02184354f, -0.00856496f, -0.02869363f, -0.03726570f, -0.00320764f, -0.01471841f, 0.02048513f, 
    -0.02456823f, -0.00529840f, -0.01256099f, 0.01251264f, 0.00829294f, -0.02486018f, -0.00386829f, 0.01413723f, 
    0.01870637f, -0.01312174f, 0.00388644f, -0.04149391f, -0.03239643f, 0.01362792f, 0.02243906f, -0.02204195f, 
    0.00482546f, 0.02210006f, -0.00957039f, 0.02964608f, -0.01664618f, -0.01585140f, 0.02276001f, -0.01816479f, 
    -0.03454714f, -0.02601820f, -0.03718148f, 0.00737765f, 0.02644853f, 0.02437356f, 0.00023783f, 0.02380173f, 
    0.01390946f, -0.01263428f, -0.01689391f, -0.00635641f, -0.04323369f, -0.02384673f, 0.02729305f, 0.01110416f, 
    0.02497510f, 0.01005916f, 0.02914869f, 0.01082035f, -0.01707048f, 0.02071155f, -0.02397053f, 0.02354305f, 
    -0.03707178f, 0.01458034f, -0.02797676f, -0.03003281f, 0.03155148f, 0.02442521f, 0.01058413f, -0.02543681f, 
    -0.00990563f, -0.00019992f, -0.03098845f, -0.01908725f, -0.01007840f, -0.02162624f, -0.04181875f, 0.01093390f, 
    -0.04566846f, -0.00770047f, 0.00345373f, -0.03962564f, -0.03983897f, 0.01528925f, -0.02444346f, -0.00197133f, 
    -0.01280942f, -0.02819414f, 0.02210112f, -0.02150303f, 0.01810852f, -0.02244375f, -0.02373134f, -0.01837699f, 
    0.00345712f, 0.03217181f, 0.01924597f, 0.01684052f, -0.00002492f, 0.02714412f, 0.01266371f, -0.03206527f, 
    0.00090097f, -0.02592380f, -0.00714460f, 0.04279413f, 0.00790842f, 0.04463175f, 0.03694083f, 0.01077914f, 
    0.03139682f, 0.02680267f, -0.01193382f, 0.01377925f, -0.03816637f, 0.00148755f, 0.01461930f, -0.01413178f, 
    0.01834701f, -0.01793420f, 0.02440718f, 0.02239860f, -0.02240869f, 0.00771049f, -0.02100492f, -0.03481725f, 
    -0.02844553f, -0.03310114f, 0.00703230f, 0.01158064f, -0.02363668f, -0.02327589f, -0.00854995f, 0.01785611f, 
    -0.02339384f, -0.02738357f, -0.02121357f, 0.00219050f, 0.02725683f, 0.02716284f, 0.02205634f, -0.00372162f, 
    -0.00104153f, -0.02008683f, -0.03137394f, 0.02004254f, -0.01384505f, 0.00804703f, -0.02489248f, -0.04132926f, 
    -0.04238299f, -0.00032737f, -0.03540723f, 0.00138443f, -0.04035363f, -0.00556767f, 0.01469562f, -0.00942293f, 
    0.02677828f, -0.01408249f, 0.02539239f, -0.02243353f, -0.03610538f, -0.03495001f, -0.01105750f, -0.04704378f, 
    -0.04278371f, 0.00886099f, -0.01300466f, -0.04404618f, 0.00391011f, 0.00868408f, -0.03694418f, -0.02095582f, 
    0.03199624f, 0.00913103f, -0.02043135f, -0.01905807f, -0.02356059f, 0.01170145f, -0.00605750f, -0.02283097f, 
    0.01105336f, 0.01645126f, -0.04104652f, 0.01008342f, -0.02822830f, 0.02933312f, -0.03086684f, -0.00946469f, 
    0.02985701f, -0.01612993f, 0.00111667f, -0.03594385f, -0.00533167f, 0.01730024f, 0.01665258f, 0.02773524f, 
    -0.01446854f, 0.01817196f, 0.00914013f, -0.03125791f, 0.00692783f, -0.03410083f, -0.00193634f, -0.02799621f, 
    -0.04412771f, -0.02104000f, 0.01075769f, -0.03314758f, -0.00816423f, 0.03057013f, 0.00244240f, -0.01235699f, 
    0.00645465f, 0.01634806f, 0.02672574f, 0.00365855f, -0.02657327f, -0.01626646f, 0.01396392f, 0.02611626f, 
    -0.00434852f, -0.04509272f, -0.02168512f, -0.00862961f, -0.00153753f, -0.00644019f, 0.02187071f, -0.00034188f, 
    -0.01919209f, 0.03135591f, 0.01842793f, -0.01944715f, 0.01418381f, 0.01770575f, -0.01973199f, 0.02339755f, 
    0.01009479f, 0.00596953f, -0.02305745f, 0.02981045f, 0.03626715f, 0.00119957f, -0.04185733f, 0.01436584f, 
    0.02399088f, 0.02085308f, 0.00403247f, 0.01730681f, 0.00852089f, 0.00251193f, 0.02966594f, -0.01493531f, 
    -0.02680230f, -0.01396252f, 0.02914586f, -0.01603111f, 0.04021014f, -0.01832849f, -0.02414594f, -0.00741704f, 
    -0.02014476f, -0.03827989f, 0.03278337f, -0.04308782f, 0.03305729f, -0.04993709f, -0.01305611f, -0.01820361f, 
    0.01733793f, 0.02375703f, 0.01516445f, 0.00194729f, 0.00480992f, -0.01588995f, 0.03073835f, -0.01454370f, 
    -0.02262350f, -0.01784563f, -0.04533060f, -0.01822332f, 0.00220766f, -0.00639281f, -0.00638801f, -0.01210860f, 
    -0.02192036f, -0.03091309f, -0.03859245f, 0.00657040f, -0.01309627f, -0.00807444f, -0.01522024f, 0.02382825f, 
    0.00118687f, -0.00109956f, -0.04438271f, -0.03170963f, -0.02728459f, 0.02588933f, 0.00399989f, -0.03761150f, 
    0.02036115f, 0.02026669f, 0.01939518f, -0.01803377f, 0.00499073f, -0.04400716f, -0.04487742f, 0.01377579f, 
    -0.03672577f, -0.00614573f, -0.02194473f, -0.04406465f, 0.02605556f, -0.01991688f, 0.02227927f, 0.01764612f, 
    -0.03914739f, 0.00270594f, -0.01222912f, -0.02653316f, 0.01524524f, 0.00480648f, 0.01402941f, -0.01558018f, 
    -0.00450316f, -0.02003198f, -0.03780968f, -0.04479314f, -0.01414288f, -0.01304912f, 0.00871028f, -0.05859757f, 
    0.00872779f, -0.01133547f, 0.01827123f, -0.02848462f, -0.04630990f, -0.01880697f, -0.03783687f, -0.03626626f, 
    0.02163304f, -0.00997822f, -0.01793127f, -0.01259240f, -0.02898840f, -0.01760274f, -0.01021905f, 0.02104140f, 
    0.02447763f, 0.03043736f, -0.00689444f, -0.00318569f, -0.02888100f, -0.00029901f, -0.02884339f, 0.01925190f, 
    -0.01848843f, -0.03105712f, -0.04707312f, 0.01413802f, 0.04264373f, -0.00989209f, -0.01973847f, 0.00332033f, 
    -0.00674768f, -0.04998317f, -0.03226406f, 0.01423605f, -0.00256446f, 0.01260195f, 0.02341909f, 0.02501104f, 
    -0.04063749f, 0.01427414f, 0.01338196f, -0.01244369f, 0.02197220f, 0.00710629f, 0.00796673f, 0.02803824f, 
    -0.02450589f, -0.02158662f, -0.04263081f, -0.01514214f, -0.04532022f, -0.03440758f, 0.03543595f, 0.01618414f, 
    0.01147653f, -0.02480807f, -0.03483582f, 0.00183881f, -0.03472710f, -0.01913207f, -0.01210152f, -0.01316152f, 
    -0.03829115f, -0.02809968f, 0.02773611f, 0.00209279f, 0.01849045f, 0.02288073f, 0.00143001f, 0.00385884f, 
    0.02962113f, -0.02997368f, -0.03129437f, -0.04439757f, -0.04971142f, -0.03563582f, -0.01607855f, -0.04395857f, 
    -0.03059737f, -0.04072297f, -0.01407955f, -0.02407181f, -0.04429760f, 0.02632864f, 0.00423212f, 0.01657621f, 
    -0.02394602f, 0.00552601f, 0.01212943f, 0.00068378f, 0.00205530f, 0.01996454f, 0.01230353f, -0.01846089f, 
    0.00080473f, -0.00438148f, 0.01758046f, -0.03190486f, 0.00291481f, 0.02670268f, 0.00060080f, 0.02306270f, 
    -0.02745448f, -0.00528490f, -0.01945091f, 0.03392273f, -0.01580330f, 0.01584476f, -0.04229151f, 0.03019937f, 
    0.01963106f, 0.00998122f, -0.00003889f, -0.03278508f, -0.02851194f, -0.01678119f, 0.01743738f, -0.03244219f, 
    -0.02301045f, -0.01816532f, -0.02680240f, -0.01699369f, 0.01729978f, -0.04180257f, -0.02048084f, 0.01703741f, 
    -0.01470381f, -0.02924422f, 0.03694448f, 0.03199942f, 0.00438096f, -0.02640400f, -0.00171201f, 0.02111803f, 
    -0.04339245f, -0.02245971f, 0.00956105f, -0.05260385f, -0.02048393f, -0.03935457f, -0.02993712f, -0.00122739f, 
    -0.02099035f, -0.03948522f, 0.01384559f, -0.01379647f, -0.00954958f, 0.00745762f, 0.03617417f, -0.02982773f, 
    -0.01306854f, -0.00383204f, -0.02546960f, 0.01409064f, 0.00980493f, 0.02988399f, -0.01361729f, -0.01274214f, 
    0.00522965f, 0.03076671f, -0.00390848f, -0.03640186f, -0.01588516f, -0.00736277f, -0.03705731f, -0.02582740f, 
    -0.03728149f, -0.01950756f, 0.00143106f, 0.03179851f, -0.00977521f, 0.02043072f, 0.02788219f, -0.03634268f, 
    0.01273809f, 0.01298265f, -0.00230903f, 0.00481220f, 0.00394107f, -0.00470190f, -0.02336361f, -0.01070044f, 
    0.01183383f, -0.00781879f, 0.02173580f, -0.00960002f, 0.01770682f, 0.01898250f, 0.00944309f, 0.01069932f, 
    0.02759681f, -0.02963071f, 0.01841853f, -0.04041229f, 0.01142187f, 0.02712344f, 0.00764279f, -0.04113925f, 
    0.00680785f, -0.01449370f, -0.02661765f, 0.00347167f, -0.01986131f, 0.03383931f, 0.01968533f, -0.00659007f, 
    -0.01656666f, 0.03596335f, -0.01882334f, 0.01152613f, -0.03298493f, -0.00699729f, -0.00325757f, 0.01876554f, 
    -0.01519215f, 0.00013956f, 0.01288940f, -0.01174004f, -0.04899585f, 0.01601420f, 0.02608921f, -0.02544789f, 
    0.04146309f, -0.01874322f, -0.04326702f, 0.01968295f, -0.02158793f, -0.05609654f, 0.01280980f, -0.03433894f, 
    0.01671295f, 0.01988291f, 0.01689710f, -0.01952730f, -0.03186406f, -0.01191199f, 0.02532068f, -0.02210600f, 
    -0.03296700f, 0.01639306f, -0.01181849f, 0.01678960f, -0.03535907f, 0.00504143f, 0.03991824f, 0.00223270f, 
    -0.01490466f, -0.03600006f, -0.03929875f, -0.00041682f, -0.01428357f, -0.00484279f, -0.01666171f, -0.00980943f, 
    -0.00094602f, -0.00593254f, -0.04353629f, 0.00677607f, -0.02805206f, -0.02911826f, 0.00926717f, 0.00955891f, 
    0.00637686f, -0.01785679f, 0.02643160f, 0.01063913f, 0.00530067f, -0.02277636f, -0.04188811f, -0.03248006f, 
    -0.04237388f, 0.03102237f, -0.03933888f, -0.03025554f, 0.02219698f, 0.02921383f, -0.01194864f, -0.02235781f, 
    -0.02943251f, 0.00848832f, 0.03204052f, -0.00468283f, -0.03034046f, -0.00463334f, -0.00514879f, -0.02606254f, 
    0.01808182f, -0.03216498f, -0.00732991f, 0.00963045f, 0.00817646f, 0.03142738f, -0.02211462f, 0.00607127f, 
    -0.00078947f, 0.04843390f, -0.01152306f, 0.01077760f, -0.01763313f, 0.00439145f, 0.01773778f, 0.01486377f, 
    0.01388281f, -0.00929895f, -0.02266322f, 0.01935499f, -0.03168257f, 0.01390752f, 0.00398365f, -0.03354743f, 
    -0.04243227f, -0.00201088f, 0.02165983f, 0.02487174f, 0.00198685f, -0.01859042f, -0.03359266f, -0.05898070f, 
    -0.00113466f, -0.03330717f, 0.01619977f, 0.02959436f, -0.05658812f, 0.01118486f, -0.02498551f, 0.01054695f, 
    0.00569303f, 0.01306697f, -0.02344728f, -0.03230967f, -0.01512802f, -0.01085291f, -0.00772294f, -0.05199656f, 
    -0.00669267f, -0.02869833f, -0.02475638f, 0.04136038f, 0.03522650f, 0.02845678f, -0.01221490f, -0.01182649f, 
    -0.01391604f, -0.03884948f, 0.03092777f, -0.00446390f, 0.02630749f, -0.00483717f, -0.02261995f, -0.02700146f, 
    -0.01562950f, 0.02064650f, 0.01227041f, -0.03118201f, 0.02358475f, -0.04367832f, -0.02253334f, 0.01609192f, 
    0.00821388f, -0.02205979f, -0.04518179f, -0.00086751f, 0.01479005f, -0.03916791f, -0.01171755f, -0.02051992f, 
    -0.03109063f, -0.00325041f, -0.04003316f, 0.01139874f, -0.03256407f, 0.01663834f, 0.01619878f, -0.03317945f, 
    0.02134735f, -0.01187054f, -0.00813699f, 0.01241526f, -0.00976788f, 0.00012189f, 0.01637893f, 0.00795431f, 
    -0.00561067f, -0.03520121f, 0.01242310f, -0.00456013f, 0.00213217f, -0.04099130f, 0.03055337f, -0.04344987f, 
    0.00329200f, 0.02039185f, -0.04253260f, -0.03829298f, 0.04597825f, -0.00243000f, 0.01491047f, 0.00170356f, 
    -0.00050667f, -0.01247358f, 0.03646982f, -0.01646368f, 0.03448601f, -0.01148540f, -0.00258523f, 0.00246287f, 
    0.02746624f, -0.01460947f, -0.03259161f, -0.04752992f, 0.01432203f, -0.04881299f, 0.00716559f, -0.01284990f, 
    -0.01052967f, 0.03589561f, 0.00886168f, -0.02694114f, 0.02397252f, -0.03169372f, 0.00272234f, 0.02978255f, 
    -0.02760988f, 0.02829348f, 0.00967914f, -0.03184553f, -0.01846768f, -0.02822636f, -0.03720277f, -0.02963765f, 
    -0.02835911f, -0.04493651f, -0.03807531f, -0.00965123f, -0.02146623f, 0.02345911f, 0.01430624f, -0.05255312f, 
    0.00133414f, -0.04292705f, 0.03125722f, -0.00419499f, -0.03893989f, 0.00069978f, -0.05142232f, 0.02597266f, 
    0.00758982f, -0.04627166f, -0.01769240f, -0.04246183f, 0.00595290f, -0.02452752f, -0.01615056f, -0.04653726f, 
    -0.04138416f, 0.04180625f, 0.00049238f, -0.03102664f, 0.01782149f, -0.01096901f, 0.01058813f, -0.03100926f, 
    -0.02607465f, -0.02004858f, -0.01379422f, 0.01120874f, -0.02444643f, 0.02895205f, 0.01494192f, 0.00109890f, 
    -0.03828296f, -0.01491812f, 0.00048674f, -0.01665312f, 0.01251803f, -0.02239244f, 0.00424228f, 0.00373476f, 
    0.01544221f, -0.04378285f, -0.02899179f, 0.00385925f, -0.01119637f, -0.04079636f, -0.04855405f, 0.02190409f, 
    0.01544761f, 0.02700428f, -0.04512082f, -0.05159660f, -0.02587690f, -0.04526072f, -0.04197367f, 0.01745343f, 
    -0.00487361f, -0.02600269f, 0.02178572f, 0.01255781f, 0.00047210f, -0.02184428f, -0.03766057f, 0.00424246f, 
    -0.00000994f, -0.03599736f, -0.03659267f, -0.00996671f, -0.02491047f, 0.01082301f, 0.02464814f, -0.01429967f, 
    -0.00182693f, -0.00081960f, 0.01430514f, 0.00776109f, 0.00586072f, 0.01522645f, 0.03309961f, 0.03069624f, 
    0.01283905f, 0.03654341f, 0.00810830f, -0.02072437f, 0.01411660f, -0.00107607f, -0.01408707f, -0.03586268f, 
    0.00081971f, -0.02922284f, 0.02640199f, 0.02735278f, -0.03185952f, 0.00752247f, 0.02274559f, -0.01368338f, 
    -0.22551361f, -0.03843331f, -0.14973745f, -0.31324431f, -0.00837817f, -0.04136417f, -0.11215566f, -0.05390221f, 
    -0.05789552f, 0.10112581f, -0.15345325f, -0.00451241f, -0.06956670f, 0.07628453f, -0.16917905f, -0.06122569f, 
    -0.06437921f, -0.07378055f, -0.04820799f, -0.02062480f, -0.29113564f, -0.34948257f, -0.73539722f, -0.13100834f, 
    0.07624897f, 0.08743837f, -0.05754727f, -0.15177299f, -0.07818729f, 0.00960357f, -0.03588188f, -0.03721821f, 
    0.03878367f, -0.08332497f, -0.06345772f, 0.01009208f, 0.03470460f, 0.08456579f, 0.04483646f, 0.00176108f, 
    -0.03107440f, -0.21318571f, 0.16930251f, -0.00834189f, -0.01720024f, -0.10748303f, 0.14017728f, 0.18630746f, 
    0.05683251f, 0.11765657f, -0.10316983f, 0.06873739f, 0.05278625f, -0.04533513f, -0.00868816f, 0.13382991f, 
    -0.02978004f, -0.03084068f, -0.05530128f, 0.09248307f, 0.06111269f, 0.10845852f, 0.17646006f, 0.05437724f, 
    0.09163661f, -0.03281898f, 0.03198040f, 0.02467583f, -0.04693704f, 0.15767291f, 0.08815378f, 0.02058028f, 
    0.03034590f, 0.14061806f, 0.12486265f, -0.08574145f, 0.11885671f, 0.03141800f, 0.07149833f, -0.01783485f, 
    0.63950068f, 0.25548923f, 0.12845412f, 0.16199800f, 0.13026805f, -0.09287781f, -0.15614957f, 0.04993359f, 
    -0.05128714f, -0.10325566f, -0.04869056f, -0.02559159f, 0.05288469f, 0.02502976f, 0.01497396f, 0.05836816f, 
    0.08595370f, 0.01385021f, 0.07872530f, 0.18921392f, 0.18454383f, 0.14856015f, 0.19682951f, 0.02609625f, 
    0.03561015f, -0.01252335f, 0.00028676f, 0.01071372f, 0.06457467f, 0.05825481f, 0.06054588f, 0.07051469f, 
    0.11005910f, 0.03819289f, 0.00981702f, -0.03180953f, -0.02687646f, -0.04075161f, -0.03967772f, -0.02756350f, 
    -0.28928185f, 0.01159429f, -0.05852715f, -0.22150125f, -0.23242897f, -0.18091264f, -0.13290755f, 0.03033372f, 
    0.06885653f, 0.02991596f, -0.14926393f, 0.04427450f, -0.18676880f, -0.06687222f, -0.04523070f, -0.13892189f, 
    -0.07216135f, -0.06191434f, -0.04781908f, -0.07735848f, -0.27616885f, -0.18066157f, -0.15498163f, -0.24427636f, 
    -0.02311609f, -0.01166682f, -0.08857998f, 0.13466510f, -0.09654110f, -0.02726000f, -0.10563255f, 0.02415818f, 
    -0.01716923f, -0.06694575f, -0.05911048f, 0.02540573f, 0.08029699f, -0.07587602f, 0.10025667f, -0.00382166f, 
    0.11304958f, 0.17602703f, 0.20670854f, 0.12554352f, 0.16995969f, 0.03165266f, 0.01282265f, -0.01499409f, 
    0.02181759f, 0.06936558f, 0.07636315f, 0.13547751f, 0.02538515f, -0.00078864f, 0.13605092f, 0.01008690f, 
    -0.04061216f, -0.10438114f, -0.00189094f, 0.01499312f, 0.03624061f, -0.00549394f, 0.22734179f, 0.02371856f, 
    0.19562604f, -0.25520611f, 0.00593040f, 0.27826101f, 0.06547449f, 0.13888982f, 0.22556528f, -0.00906613f, 
    0.15053731f, -0.04456533f, 0.18615158f, 0.09850999f, 0.17187142f, -0.06932097f, 0.18729402f, 0.00121927f, 
    0.11861745f, 0.15550457f, -0.01808155f, 0.13957071f, -0.12997372f, 0.33406270f, 0.09720284f, -0.05671528f, 
    -0.00920325f, -0.22979729f, 0.03702296f, 0.02952382f, -0.04551959f, 0.04832029f, 0.13272318f, 0.16044098f, 
    0.21937346f, -0.01612132f, -0.04004005f, -0.05101506f, -0.50362349f, 0.10465071f, -0.15725642f, -0.21374016f, 
    0.09391199f, -0.15071450f, -0.04767483f, 0.03295734f, -0.14630175f, 0.11265394f, -0.13075767f, -0.02588279f, 
    -0.06672283f, 0.03097175f, -0.06406908f, -0.00396997f, 0.04754785f, 0.11402549f, -0.00574526f, 0.02168406f, 
    0.28327671f, 0.14665140f, -0.04098948f, -0.05194742f, 0.03986696f, -0.11451498f, -0.04425635f, 0.01577814f, 
    0.09919083f, 0.12278279f, 0.20973782f, -0.03346540f, 0.14657106f, -0.08723459f, -0.05321689f, 0.04364677f, 
    0.04033836f, -0.04539450f, 0.05494511f, 0.01066277f, 0.37655959f, 0.35511500f, -0.39814928f, 0.28937399f, 
    -0.14634164f, 0.09134147f, 0.12634411f, 0.14858009f, 0.02637635f, -0.09445091f, 0.18990022f, 0.06571284f, 
    0.00970507f, -0.00845730f, 0.07381158f, 0.08887347f, 0.11964488f, 0.05876233f, 0.05068949f, 0.01243141f, 
    -0.07156193f, -0.47611207f, -0.26045144f, -0.06954900f, 0.24475178f, -0.09895002f, 0.16210452f, -0.03488091f, 
    -0.14873175f, -0.20779084f, -0.04895955f, -0.05313734f, -0.01547643f, 0.01795066f, 0.03818258f, -0.02979195f, 
    0.07217969f, 0.17059363f, 0.10245317f, -0.03196779f, -0.58562529f, -0.25202060f, -0.49513644f, -0.21073227f, 
    -0.21555310f, 0.03884672f, 0.13387752f, -0.18307565f, -0.06939336f, -0.19760948f, 0.08249975f, -0.00163994f, 
    -0.04527877f, -0.00219264f, 0.01684193f, -0.04926556f, 0.02408512f, 0.10522110f, -0.05679483f, -0.03811584f, 
    0.39206991f, 0.23561557f, -0.18199497f, -0.14305209f, 0.25225750f, -0.02131085f, -0.05215628f, -0.04433552f, 
    -0.37545469f, -0.00447912f, -0.08740661f, -0.03239093f, -0.02161055f, -0.06439865f, 0.06344084f, 0.15341343f, 
    0.00125138f, -0.00801358f, -0.11731026f, 0.02958575f, -0.30895910f, -0.62734449f, -0.66424221f, -0.52380979f, 
    0.31663570f, -0.01516845f, -0.06196484f, -0.02494134f, -0.07231124f, 0.16287875f, -0.13576275f, -0.06819297f, 
    -0.04123744f, -0.05684710f, -0.05346247f, 0.09575581f, 0.04273144f, -0.00039292f, 0.11874551f, 0.02877042f, 
    -0.14429663f, -0.04829099f, 0.14592282f, 0.05234056f, 0.25702262f, -0.02764296f, 0.02669499f, -0.00354533f, 
    0.12191282f, 0.04207709f, 0.12887333f, 0.10711321f, 0.05875706f, 0.04960402f, 0.19717278f, 0.00076402f, 
    0.10294721f, 0.08288983f, 0.31813276f, 0.10552711f, -0.58871508f, -0.29806468f, 0.19548346f, -0.17449485f, 
    0.15126607f, -0.25878364f, 0.00925853f, 0.16315797f, 0.04662896f, -0.08543151f, 0.03293531f, 0.08057200f, 
    0.16267855f, 0.08313045f, 0.10269348f, 0.09635428f, -0.01502868f, -0.00334217f, 0.07342809f, 0.08901716f, 
    -0.87367976f, -0.36215878f, -0.44073871f, -0.36728668f, 0.09788109f, -0.03284160f, 0.06554218f, -0.09190780f, 
    -0.10810102f, -0.19085643f, -0.04534480f, -0.00820523f, -0.10786881f, -0.04086703f, 0.00895469f, -0.08954074f, 
    0.03938436f, 0.16208915f, 0.07127459f, -0.09716210f, 0.47037441f, 0.14337648f, 0.14553878f, 0.22806512f, 
    -0.04640706f, 0.06767157f, 0.02151132f, -0.06340442f, -0.00278683f, -0.03875231f, 0.08331467f, 0.24084559f, 
    0.05635281f, -0.01327239f, 0.01050699f, -0.00715227f, -0.06524294f, 0.07445413f, -0.03782062f, -0.01007052f, 
    -0.39794791f, -0.14087306f, -0.83076376f, -0.40075648f, 0.30572504f, 0.04053239f, 0.18480787f, 0.07067113f, 
    -0.16912055f, -0.07636982f, -0.10523578f, 0.00533496f, -0.01511186f, 0.04293855f, 0.04049807f, -0.03590303f, 
    0.03180289f, 0.18324834f, 0.15313859f, 0.04671725f, 0.19758040f, 0.07065242f, 0.21140647f, 0.04131320f, 
    0.16409007f, -0.00579523f, -0.01978220f, -0.08891935f, -0.00911199f, 0.03219588f, 0.06021645f, -0.02587746f, 
    0.01132687f, -0.02289422f, -0.12575857f, 0.17496623f, 0.00866586f, -0.08495282f, 0.05777189f, 0.08067131f, 
    0.22796468f, -0.08497201f, 0.01633071f, -0.01472451f, 0.06735626f, 0.08472947f, 0.25764903f, 0.18314700f, 
    -0.06766516f, -0.02903772f, -0.01057543f, -0.01826153f, -0.07989652f, 0.01086956f, 0.02656190f, 0.05782910f, 
    -0.02598025f, -0.02031867f, 0.03990950f, 0.01078908f, -0.06385861f, -0.07813106f, -0.26744890f, -0.04995393f, 
    -0.27732718f, -0.07821915f, 0.08859318f, -0.01114785f, 0.07177331f, -0.01131770f, 0.04061728f, 0.02212041f, 
    -0.05821056f, 0.04914996f, -0.08704595f, -0.08115843f, 0.01571911f, 0.01063667f, -0.13298878f, -0.07160164f, 
    -0.22985373f, -0.49883881f, -0.68717927f, -0.32696065f, 0.25117016f, 0.06893285f, -0.02889679f, -0.14445357f, 
    -0.07729821f, 0.09782060f, -0.06917545f, -0.00501985f, -0.02860586f, -0.01368318f, 0.00413976f, 0.05573129f, 
    0.14404698f, 0.01366673f, 0.08364772f, 0.02938136f, 0.11816375f, -0.01491663f, 0.07912384f, 0.07020273f, 
    -0.00130304f, -0.02117694f, -0.02073900f, -0.01931736f, -0.07384644f, 0.00757668f, 0.03242739f, -0.05964116f, 
    0.02720203f, 0.01892333f, 0.06877222f, -0.17581359f, -0.12475950f, -0.09822455f, -0.09147326f, -0.08632489f, 
    -0.34750015f, -0.22529319f, -0.47474572f, -0.11913850f, 0.16097230f, -0.01324012f, 0.07455368f, -0.09732898f, 
    0.08770899f, -0.02343579f, -0.08584118f, -0.04662290f, 0.06895754f, 0.05684726f, 0.07861617f, 0.06341753f, 
    0.03488855f, 0.07097840f, 0.04619770f, -0.07372425f, 0.30863139f, 0.15889774f, 0.10749946f, 0.18392541f, 
    0.10511976f, -0.03108055f, -0.04069098f, -0.01656998f, -0.06176083f, 0.02629983f, 0.06392471f, 0.04260897f, 
    0.02646530f, -0.04175358f, 0.06391717f, -0.02162379f, 0.00920818f, -0.05252644f, -0.07542235f, -0.05093130f, 
    -0.30891943f, 0.00370457f, -0.08711832f, -0.13523847f, -0.00282197f, 0.10611599f, -0.18054435f, 0.06452462f, 
    -0.04020158f, -0.08254675f, 0.12404075f, 0.03907885f, -0.00654547f, 0.08309377f, -0.01537735f, -0.05925779f, 
    0.07252435f, 0.28079957f, -0.03803349f, 0.21362606f, -0.08955872f, -0.22882472f, -0.66601938f, -0.27873632f, 
    0.14231935f, 0.09217358f, 0.10324640f, -0.02386700f, -0.06247740f, 0.07132355f, -0.12333801f, 0.00388225f, 
    0.00465550f, 0.10931516f, -0.04045319f, 0.09302967f, 0.02479404f, -0.06714903f, 0.18840377f, -0.04550218f, 
    0.00589252f, 0.37791675f, 0.31663486f, 0.26755190f, -0.10222728f, -0.07405530f, -0.03819218f, -0.27343270f, 
    -0.28346479f, -0.12131955f, -0.00056024f, -0.01741191f, 0.07394255f, 0.18237825f, 0.02582102f, 0.06129433f, 
    0.04468155f, -0.04968771f, 0.06298485f, 0.04838621f, 0.11108157f, 0.16752380f, -0.35061091f, -0.01097339f, 
    -0.32669064f, -0.06171352f, -0.09655544f, -0.17567161f, -0.01798870f, 0.19200462f, 0.05003865f, -0.03207695f, 
    0.05129727f, -0.15787694f, -0.04459198f, -0.06344748f, -0.03000512f, -0.00660251f, 0.15827449f, -0.04909202f, 
    -0.41214100f, 0.04382211f, -0.11764420f, -0.01929370f, -0.04592814f, -0.14361438f, 0.04510260f, 0.26878467f, 
    -0.03395373f, 0.03045257f, 0.00280685f, 0.14287543f, 0.06615087f, -0.18316089f, 0.09726785f, 0.11560589f, 
    0.11792858f, -0.18384248f, 0.02494373f, 0.00838616f, -0.14428478f, 0.08804344f, 0.08760114f, 0.02819523f, 
    0.10961186f, -0.02824575f, 0.05248562f, -0.03461446f, 0.02448371f, 0.01290315f, 0.02767852f, 0.02470986f, 
    0.03951480f, -0.10440849f, 0.03023486f, -0.08176930f, 0.11202984f, -0.14176843f, 0.04978805f, -0.08924136f, 
    0.30513299f, -0.15723683f, -0.39377904f, 0.09891216f, 0.15699336f, -0.01675856f, 0.06974421f, 0.17349364f, 
    -0.09526559f, 0.03227300f, -0.01120187f, 0.00918728f, -0.02441059f, 0.04841626f, -0.00876093f, 0.03498583f, 
    0.18174104f, 0.02639390f, 0.23883949f, 0.24522443f, 0.20611995f, 0.16246687f, 0.21608341f, 0.03681409f, 
    0.11967644f, 0.02726424f, -0.08676685f, -0.09076363f, -0.00936258f, -0.08270357f, 0.06758261f, -0.01946533f, 
    0.04049641f, 0.11230409f, -0.16203995f, 0.04530165f, 0.02077759f, -0.07764016f, -0.02965900f, 0.10197148f, 
    -0.33063340f, 0.08846255f, 0.32801104f, -0.04613807f, -0.12667754f, -0.00973422f, -0.10770624f, -0.16986953f, 
    -0.17841399f, -0.09324247f, -0.03290889f, 0.06584495f, 0.07872645f, 0.14736366f, 0.00932780f, -0.00425840f, 
    -0.09212276f, -0.06033311f, -0.08599679f, -0.06336546f, -0.47304913f, 0.09741619f, 0.22759788f, 0.24024794f, 
    -0.43856463f, 0.12731123f, -0.15738808f, 0.02811531f, -0.11934011f, -0.02994585f, -0.00701599f, -0.14204814f, 
    0.02520776f, -0.10754836f, 0.03439421f, 0.11498989f, -0.03332667f, -0.14720112f, 0.03623214f, -0.08611129f, 
    0.12226722f, -0.08423819f, 0.04251746f, 0.00556543f, 0.09573988f, 0.00584803f, 0.07165574f, 0.08658874f, 
    0.02559963f, 0.01661554f, -0.03026835f, -0.00156267f, -0.00861066f, -0.08045267f, 0.08812531f, 0.01557712f, 
    0.11946742f, 0.02554859f, -0.05583178f, 0.00843917f, -0.60480922f, 0.00562674f, 0.12708722f, -0.03160449f, 
    0.12935270f, -0.21030533f, 0.03380934f, 0.18749733f, -0.09435128f, 0.09774762f, 0.12080045f, -0.02547700f, 
    0.05220585f, -0.01710994f, 0.02001529f, -0.09374516f, 0.12426239f, -0.18439436f, 0.16984473f, -0.02014401f, 
    0.38217887f, -0.47903749f, -0.20352916f, -0.12392294f, -0.18196043f, 0.08604571f, 0.06990855f, 0.07651995f, 
    0.16562653f, 0.02625241f, 0.01782179f, -0.01278003f, -0.02325146f, -0.11480468f, 0.01673122f, 0.01571564f, 
    0.09798077f, 0.26639163f, -0.17655414f, 0.04995513f, -0.00011040f, 0.37662283f, 0.08961759f, -0.05736943f, 
    -0.15317093f, -0.05752428f, -0.13716476f, -0.17804056f, 0.00163068f, 0.02536814f, 0.01489584f, 0.04310497f, 
    0.02510905f, 0.10488264f, -0.00042846f, 0.02390172f, 0.02279146f, 0.00491513f, -0.02173416f, 0.02842054f, 
    0.11546429f, 0.29118958f, 0.13828415f, -0.17772637f, -0.07704369f, 0.00273541f, -0.19159304f, -0.03351629f, 
    0.05043369f, 0.03383627f, 0.05829481f, 0.13091376f, -0.13115388f, -0.01660294f, -0.09068572f, 0.06481440f, 
    -0.07537476f, -0.11717436f, -0.00980217f, 0.01704275f, 0.39988595f, 0.15306358f, 0.19473338f, -0.22090378f, 
    -0.46228808f, 0.12800731f, 0.04579294f, -0.00078628f, 0.06360719f, 0.02572437f, -0.00026679f, 0.04948271f, 
    0.00792214f, 0.11389760f, 0.01335431f, -0.04573856f, 0.00437799f, 0.20347899f, -0.13462390f, -0.03047001f, 
    0.29178071f, 0.13724677f, -0.72386843f, 0.15679955f, 0.03832621f, -0.06179699f, 0.18125324f, 0.21987624f, 
    -0.06758507f, 0.04920772f, -0.02596065f, -0.10498130f, -0.04556017f, -0.00610721f, 0.02630451f, 0.02282994f, 
    -0.05827575f, -0.04434821f, 0.12046419f, -0.13408697f, -0.32922703f, 0.18712515f, 0.23188616f, -0.27477702f, 
    -0.41485599f, -0.05180983f, -0.19206606f, 0.05728969f, 0.16839580f, 0.10018460f, -0.01235314f, -0.04600302f, 
    -0.02776366f, -0.01035151f, 0.04966855f, 0.02941846f, -0.03312764f, 0.09675596f, -0.27203640f, -0.23182654f, 
    0.24533397f, -0.15175375f, -0.67639321f, -0.10638162f, 0.22170314f, -0.07866523f, 0.19916131f, 0.19452783f, 
    0.00953450f, 0.08552433f, -0.05242160f, -0.01538457f, -0.08825146f, -0.08483250f, -0.03421106f, 0.01722846f, 
    0.06557842f, -0.06121048f, 0.04748442f, -0.05343023f, 0.19939093f, 0.26004088f, -0.16255501f, 0.15899950f, 
    -0.07079335f, 0.02722997f, -0.07476141f, -0.03825187f, -0.02557714f, 0.07489935f, -0.01828698f, -0.03059361f, 
    -0.03666459f, -0.05134942f, -0.07463273f, 0.15694211f, 0.09820712f, 0.05346704f, 0.11136240f, 0.06021215f, 
    -0.16556010f, -0.01533016f, -0.09780513f, 0.07075111f, 0.09803346f, -0.15633062f, 0.08087688f, 0.20214933f, 
    0.04405641f, 0.09737057f, -0.05002310f, -0.05545392f, -0.07902092f, -0.06355748f, 0.10697088f, 0.03903653f, 
    -0.00282907f, 0.02615999f, 0.19491565f, -0.00379401f, -0.43284616f, -0.27698395f, 0.16438508f, -0.13898420f, 
    0.01770236f, -0.09300248f, 0.02402371f, -0.00984838f, -0.02922682f, 0.12552406f, 0.06421347f, 0.00935662f, 
    0.04688594f, 0.00556782f, 0.02315478f, 0.13258742f, 0.27388391f, -0.03448729f, 0.02615732f, 0.12883335f, 
    -0.43775311f, -0.01193093f, 0.15210029f, -0.08467791f, -0.12734868f, -0.12277859f, -0.34902963f, 0.09346060f, 
    0.03247207f, 0.07341483f, -0.01700168f, -0.00918799f, 0.04036958f, -0.01791857f, 0.00652037f, 0.03054807f, 
    -0.00827985f, 0.04520466f, -0.00294628f, -0.22539879f, 0.72546732f, -0.01811362f, 0.17451596f, -0.28582850f, 
    -0.02206405f, 0.07120626f, -0.06901488f, -0.12540384f, -0.12785563f, -0.17618304f, -0.16123235f, 0.22158590f, 
    0.06431343f, 0.15398078f, -0.08391397f, -0.01727096f, 0.12065171f, 0.06532428f, -0.18741302f, 0.06174090f, 
    -0.28747532f, 0.11440422f, -0.15778756f, -0.03603124f, -0.11406420f, 0.12731981f, -0.22256820f, 0.06062169f, 
    0.02751780f, 0.05733851f, -0.00352168f, 0.05057820f, 0.06763522f, -0.00378556f, -0.01150030f, -0.04475654f, 
    -0.01576272f, -0.05140895f, 0.23897071f, 0.04956542f, 0.25491622f, 0.10765953f, 0.14728551f, 0.09808301f, 
    0.10776756f, -0.02739491f, -0.05550070f, -0.03508381f, -0.03223843f, -0.03298610f, 0.11635432f, 0.11725422f, 
    0.05056027f, 0.21875380f, -0.23921028f, 0.16941866f, 0.08751494f, 0.01413275f, -0.00634029f, 0.19208670f, 
    0.19705822f, -0.07280529f, -0.24262650f, -0.09898670f, 0.14306499f, 0.00113991f, 0.09861263f, 0.15652120f, 
    0.13514093f, 0.02136113f, 0.02305169f, -0.08632308f, -0.03995141f, -0.07551982f, -0.02384314f, 0.05756446f, 
    0.04781247f, -0.17046057f, 0.12785085f, -0.02892987f, -0.29997829f, -0.47211215f, -0.31201470f, -0.11332699f, 
    -0.11996894f, -0.08320915f, 0.30685720f, -0.05121605f, 0.07344308f, 0.02764416f, -0.00631073f, -0.10059033f, 
    0.00280320f, 0.04754072f, -0.09008525f, -0.00326956f, -0.02395498f, 0.06020561f, -0.09651344f, 0.13809012f, 
    0.09462383f, 0.08235081f, -0.32994860f, -0.06558011f, -0.25648144f, -0.06586732f, -0.11202652f, -0.07560745f, 
    0.04586625f, 0.07816266f, 0.02701388f, 0.00683956f, 0.03488759f, -0.03604473f, -0.00006936f, -0.04540254f, 
    0.03317519f, 0.06422926f, -0.05355555f, -0.04938094f, 0.13331951f, -0.11892077f, -0.04093110f, 0.00537781f, 
    0.10174642f, 0.05844012f, 0.01802740f, 0.01901968f, -0.07147816f, -0.03081234f, 0.10012892f, 0.06168612f, 
    -0.02878154f, 0.06059258f, -0.01618322f, -0.00091487f, -0.06806763f, -0.02641402f, -0.02306916f, 0.02197153f, 
    -0.20700561f, 0.06058545f, -0.21733539f, -0.08768672f, -0.09629188f, 0.02685482f, 0.06276832f, -0.09906916f, 
    -0.01846270f, 0.16726707f, 0.01714085f, 0.00032775f, -0.01332476f, 0.09636706f, 0.07141713f, -0.05700128f, 
    -0.09841659f, 0.19706753f, 0.06028541f, 0.11794415f, 0.13094485f, -0.13830425f, 0.00044180f, 0.06706724f, 
    0.14373027f, 0.03576816f, 0.03551332f, 0.06856287f, -0.02820481f, 0.02688152f, 0.08288714f, 0.06462452f, 
    0.00400795f, -0.02157464f, -0.04995559f, -0.00014485f, 0.04230067f, 0.02381061f, -0.06441190f, 0.03818459f, 
    -0.15488221f, -0.09339081f, -0.19515310f, -0.24580468f, -0.11298018f, -0.28312421f, 0.08244493f, 0.15499830f, 
    -0.05034626f, -0.06266224f, 0.06492481f, -0.06968030f, -0.01260022f, 0.03779954f, 0.01126972f, 0.04494927f, 
    -0.00179092f, 0.02295873f, -0.29960254f, 0.00370633f, 0.02207077f, 0.10959337f, -0.27015507f, 0.11588181f, 
    -0.16204938f, 0.05222892f, 0.11116961f, -0.00925814f, 0.09348445f, 0.00680672f, 0.01751191f, -0.02341264f, 
    0.01438906f, 0.02084413f, 0.01084389f, 0.01183972f, 0.01863198f, 0.13214868f, 0.27695218f, 0.11439656f, 
    -0.43160108f, 0.24035470f, 0.62531430f, 0.27772716f, 0.19567059f, 0.03260460f, -0.00655983f, -0.02058343f, 
    -0.09018719f, 0.08827062f, -0.11571313f, 0.06974676f, 0.13271938f, -0.09294205f, 0.03230502f, -0.01216459f, 
    -0.08980631f, -0.04172089f, -0.11827996f, -0.03033780f, -0.26156956f, -0.33731082f, -0.35472664f, 0.42544562f, 
    0.04104672f, 0.05264080f, -0.19280301f, 0.09194319f, -0.14846027f, -0.18585840f, -0.11503167f, 0.02052996f, 
    0.06672881f, 0.04043987f, -0.07518935f, 0.22789901f, 0.06426418f, 0.13708180f, 0.29150942f, -0.06446403f, 
    0.10179374f, -0.19013284f, -0.07259161f, -0.29014781f, 0.16078280f, -0.06865972f, -0.01343681f, -0.17456356f, 
    0.16694868f, -0.02431631f, -0.03273054f, -0.13132899f, 0.18395400f, -0.02746100f, 0.01089093f, 0.11128109f, 
    -0.14984226f, -0.07896896f, 0.04547755f, -0.01951893f, 0.06819495f, -0.05027080f, -0.10266124f, 0.03419048f, 
    0.07528818f, -0.01576587f, 0.09539492f, -0.08069297f, 0.03875042f, 0.14208104f, 0.08749314f, 0.06318717f, 
    0.02144963f, -0.00879545f, 0.02715338f, 0.04230967f, 0.05564939f, -0.08661009f, 0.08206521f, -0.03080290f, 
    0.35734746f, -0.28394607f, 0.19548523f, -0.09222649f, -0.03424831f, -0.00637574f, -0.07340679f, -0.03290555f, 
    -0.04964355f, -0.00105507f, -0.02913854f, 0.00148902f, -0.02709379f, -0.12693273f, 0.05400684f, 0.08699857f, 
    0.10241074f, 0.06029702f, 0.01554349f, 0.17045137f, -0.13875312f, 0.19070074f, 0.02890945f, -0.07166433f, 
    -0.01479281f, -0.09509635f, 0.03560108f, -0.01644576f, 0.01250072f, 0.01473677f, -0.02578038f, 0.01622248f, 
    0.11560002f, 0.07681368f, 0.10369831f, 0.00115163f, -0.12854154f, -0.00811268f, -0.13083225f, -0.02049102f, 
    -0.34477413f, -0.07887437f, 0.08127310f, 0.11033713f, 0.14512990f, -0.08117519f, 0.05257111f, -0.08538982f, 
    -0.06544557f, 0.07270399f, -0.09895775f, 0.19915046f, -0.01384796f, -0.06141032f, -0.05963237f, -0.07418774f, 
    -0.13301115f, -0.11723336f, -0.15053964f, -0.05850814f, -0.33381265f, -0.06665556f, 0.09310997f, 0.25671721f, 
    0.27647135f, -0.05337418f, 0.04441092f, -0.06870661f, -0.15829805f, 0.00456668f, -0.06516592f, -0.00106530f, 
    0.10320727f, -0.03491119f, -0.10356481f, 0.04342886f, 0.09977502f, 0.10139848f, 0.06567302f, 0.08341759f, 
    0.06526848f, 0.11629447f, -0.07703872f, 0.11638099f, -0.18371654f, -0.03180038f, 0.00440520f, 0.06585073f, 
    0.00276661f, 0.05459005f, -0.09152324f, 0.10791364f, 0.08122621f, -0.06005039f, 0.08583681f, 0.12020923f, 
    -0.00129513f, 0.01031451f, -0.02987949f, -0.01622733f, 0.39996189f, -0.08028075f, -0.11061716f, -0.26092979f, 
    0.48359710f, 0.14327943f, 0.16444303f, 0.00665854f, -0.06282095f, 0.15824680f, 0.01648758f, 0.01482505f, 
    -0.05168905f, -0.00046139f, 0.04609490f, 0.00732116f, 0.23626749f, 0.00024304f, 0.15114352f, 0.21453138f, 
    -0.36051011f, 0.42154321f, -0.14226876f, 0.23388369f, -0.29334500f, 0.12759718f, 0.04463327f, -0.09285831f, 
    -0.12128787f, 0.01895317f, -0.03391983f, -0.13404070f, 0.04614375f, 0.10776244f, 0.09354015f, 0.18164465f, 
    0.16882874f, -0.00237959f, 0.14474219f, -0.07888093f, -0.10509713f, 0.30842388f, 0.20392899f, 0.33222148f, 
    0.07617320f, 0.03316645f, -0.08780620f, -0.01706892f, 0.18291736f, 0.20873947f, -0.00064627f, 0.09803741f, 
    -0.04533887f, 0.00721015f, 0.01485221f, 0.02362791f, -0.03619119f, 0.01480374f, 0.03993092f, 0.00956939f, 
    0.08971985f, 0.14171506f, 0.25030351f, 0.00057805f, 0.07022550f, -0.18396097f, 0.21070743f, -0.08121093f, 
    -0.02547086f, -0.01300411f, 0.01459854f, 0.01264041f, 0.01587342f, -0.05980135f, 0.18492697f, -0.09630984f, 
    -0.05380803f, 0.04039223f, 0.00315077f, -0.04847918f, -0.16903976f, 0.34196106f, -0.10847934f, 0.42975926f, 
    -0.01080842f, -0.04084415f, 0.21621123f, 0.02262091f, 0.11787879f, -0.02895589f, 0.00538168f, 0.05978535f, 
    0.04867002f, 0.03486684f, 0.18589137f, 0.12919359f, 0.08099467f, 0.10100591f, 0.03178588f, 0.03169824f, 
    0.14131598f, -0.33330819f, 0.04135588f, 0.02073581f, 0.25749665f, 0.11116075f, -0.06390122f, 0.17891759f, 
    -0.07821678f, -0.15136074f, -0.06100826f, 0.02015546f, -0.10749588f, 0.02623090f, 0.08026107f, -0.10036505f, 
    0.03323364f, 0.06225197f, -0.00476719f, 0.06939863f, -0.26382679f, -0.21924476f, -0.15935363f, 0.30172390f, 
    0.00914390f, -0.12145350f, -0.10326853f, -0.08790606f, -0.00654070f, -0.05849145f, 0.02932840f, -0.02314580f, 
    -0.04996778f, -0.06733643f, -0.02639093f, 0.02369358f, 0.06973027f, 0.11882504f, 0.07971727f, -0.10391508f, 
    0.25893795f, -0.23628031f, -0.29760188f, 0.18186615f, 0.05754524f, -0.09562933f, -0.14096637f, 0.11705957f, 
    -0.13135982f, 0.01507356f, -0.05538000f, -0.00499551f, -0.05050072f, -0.03568958f, -0.02085029f, 0.05065501f, 
    -0.07050707f, 0.01706478f, 0.03035209f, -0.01539690f, -0.20816444f, -0.15580992f, 0.11253690f, 0.19796802f, 
    0.15336540f, 0.03917060f, -0.06947505f, 0.11483249f, -0.09183678f, 0.07993235f, -0.00712685f, 0.00570835f, 
    0.09788059f, 0.15897349f, -0.00079159f, 0.01223159f, 0.11709315f, -0.00180464f, 0.12365265f, 0.12417020f, 
    0.18164803f, -0.05821989f, 0.06390630f, 0.25993714f, 0.25975502f, -0.03271326f, 0.01167119f, 0.10035869f, 
    0.02941032f, 0.03867914f, -0.00972044f, 0.09682979f, 0.05925378f, 0.09369829f, -0.02615882f, -0.03878490f, 
    0.11695346f, -0.12216326f, 0.15310372f, 0.07937875f, 0.03678805f, -0.18438552f, -0.09920945f, 0.00073040f, 
    0.32933718f, 0.13283347f, 0.09252936f, 0.03745302f, -0.01505879f, 0.02810588f, -0.00733908f, 0.02949083f, 
    0.09545891f, -0.08245638f, 0.16292703f, 0.19889164f, 0.13350496f, 0.22537027f, 0.17383617f, 0.26386487f, 
    -0.32899648f, -0.35527572f, -0.37573603f, 0.08596212f, 0.13096485f, -0.12744352f, -0.13697203f, -0.05281666f, 
    -0.21366686f, -0.20338193f, -0.11352079f, 0.04693325f, 0.00341408f, -0.09160141f, -0.03092139f, -0.00858269f, 
    0.05076741f, 0.05664833f, 0.08911858f, -0.11440043f, 0.03775282f, 0.28771585f, -0.35117948f, 0.13008353f, 
    0.06849284f, -0.08329736f, 0.07127278f, -0.15368201f, -0.01635922f, -0.07240626f, -0.03277622f, -0.01446867f, 
    0.01365954f, 0.33389583f, 0.07717987f, 0.15781748f, 0.02472846f, 0.14857808f, -0.14134802f, -0.12564605f, 
    -0.39652994f, -0.19376782f, -0.26345444f, 0.12670569f, -0.00966406f, -0.25149056f, -0.05189994f, -0.00633138f, 
    -0.12433200f, -0.05274959f, -0.09933189f, 0.04285318f, 0.05769545f, 0.07227763f, 0.03094240f, 0.03843604f, 
    0.04078594f, 0.13646647f, -0.17067640f, 0.07484759f, -0.15982857f, 0.20190012f, -0.04599407f, -0.07034439f, 
    0.03433587f, -0.00105914f, 0.04160284f, 0.01455222f, -0.00512125f, -0.03598705f, -0.06719495f, -0.06657320f, 
    0.12313689f, -0.01205961f, 0.08814520f, 0.12707016f, 0.00723428f, -0.00784541f, 0.08787771f, -0.05451265f, 
    0.15413181f, 0.11597303f, -0.01376783f, -0.04349377f, -0.10023196f, 0.15290394f, 0.05728187f, 0.22332075f, 
    -0.05884954f, -0.05005810f, -0.05266650f, -0.06162493f, 0.00627646f, 0.03578581f, 0.00751799f, 0.03235930f, 
    -0.05032246f, 0.08878796f, -0.07322862f, 0.02909004f, -0.56268519f, 0.03708118f, -0.27990448f, 0.64165187f, 
    -0.53168678f, 0.14688040f, 0.10426168f, 0.10246532f, -0.05333752f, -0.09028567f, -0.04746505f, -0.02316079f, 
    -0.09222667f, 0.05843290f, 0.09809378f, 0.18489531f, -0.02799363f, 0.21216971f, 0.10454872f, 0.14828396f, 
    -0.16091016f, -0.14311016f, -0.00484745f, 0.27470323f, 0.11319066f, -0.01772005f, -0.13663477f, 0.02080973f, 
    -0.08423851f, -0.07662839f, -0.02154941f, 0.03597873f, 0.04192717f, 0.05545954f, -0.06512077f, 0.08913400f, 
    0.12036961f, 0.08944234f, 0.14715256f, 0.00736755f, -0.05582994f, -0.16573633f, -0.15382814f, -0.10784028f, 
    -0.10290103f, -0.10306928f, -0.01235624f, -0.07632794f, -0.12337238f, -0.00304128f, -0.06086734f, 0.22287320f, 
    0.09655304f, 0.03450931f, 0.08925692f, 0.11793387f, -0.01168939f, -0.06546300f, -0.13997059f, -0.15439889f, 
    0.08663112f, -0.25885576f, -0.13186611f, -0.04696571f, 0.31103635f, 0.03628740f, 0.02757757f, 0.02103387f, 
    0.03300644f, -0.09088781f, 0.04063940f, 0.07201880f, 0.05605208f, 0.04959471f, 0.09489433f, 0.18359312f, 
    0.00920344f, -0.00588804f, 0.25225750f, 0.08752292f, 0.02044496f, -0.00165374f, 0.06857210f, -0.19115657f, 
    -0.13732965f, 0.00009682f, -0.04276407f, -0.01584788f, 0.03448888f, -0.01150629f, -0.07896443f, 0.00041812f, 
    0.01180039f, -0.11660911f, -0.06821686f, 0.22842886f, 0.14878705f, 0.00674373f, -0.05028437f, -0.04818815f, 
    -0.24585764f, -0.11140081f, 0.10159323f, 0.43288082f, 0.16419512f, 0.21576561f, -0.10631195f, 0.27066419f, 
    0.05404984f, 0.00050573f, -0.17223176f, 0.05850292f, -0.08435562f, 0.04773644f, -0.03721834f, 0.05997109f, 
    0.04597386f, 0.09361093f, 0.03751064f, -0.13771398f, -0.33054873f, -0.08101932f, -0.08624269f, 0.27128008f, 
    -0.00826839f, -0.05851833f, 0.17339943f, 0.08700406f, -0.07036197f, 0.02053757f, -0.03113938f, -0.01905971f, 
    0.16466032f, 0.18427366f, 0.14124386f, 0.09093824f, 0.07714760f, 0.13598168f, -0.03438831f, 0.09571354f, 
    -0.32656980f, 0.06371915f, 0.38310805f, -0.18625328f, 0.52762777f, 0.09749787f, 0.08507663f, 0.24271402f, 
    0.13100290f, 0.16490127f, 0.05058917f, 0.26949972f, 0.05042940f, -0.05039921f, -0.02252079f, -0.00361253f, 
    -0.00676459f, 0.07086453f, -0.00055755f, 0.02032557f, -0.36027411f, 0.13872103f, -0.23635152f, -0.14710420f, 
    -0.03484933f, 0.06952524f, -0.05114617f, 0.00511826f, 0.08422655f, -0.28649732f, 0.00501803f, 0.01621012f, 
    0.03394290f, 0.04256176f, -0.03169481f, -0.15007426f, -0.28431535f, 0.06328090f, -0.18635707f, 0.11052271f, 
    -0.16748700f, -0.00799396f, -0.22187272f, 0.08815372f, 0.03031509f, -0.00038442f, -0.22750957f, 0.01493979f, 
    -0.06273773f, -0.06240979f, 0.14190780f, 0.03281416f, -0.05254344f, 0.05468732f, -0.04856557f, 0.10866024f, 
    -0.01920141f, -0.06215100f, 0.15936814f, 0.14185469f, -0.06688525f, -0.02633478f, -0.10510939f, -0.02214127f, 
    0.02169528f, -0.07158361f, -0.12265540f, -0.09125376f, 0.08694540f, 0.16967422f, -0.03937765f, 0.25796747f, 
    -0.00621113f, 0.13550219f, 0.13826905f, 0.10317215f, 0.16013683f, -0.07996266f, 0.10822500f, 0.15248498f, 
    -0.49352029f, -0.14576557f, -0.03373157f, 0.00975104f, 0.09949695f, 0.14738929f, 0.09999919f, 0.09753400f, 
    -0.03036025f, -0.03301048f, -0.03299244f, -0.09604019f, -0.02742464f, 0.04750830f, -0.00579566f, -0.12621655f, 
    -0.14990498f, -0.03835515f, -0.00509028f, -0.06745388f, -0.00075844f, -0.08886718f, 0.06521922f, -0.02941717f, 
    0.21042788f, -0.00955983f, -0.03490388f, -0.05829862f, -0.03975498f, 0.02984349f, 0.10593834f, 0.11545560f, 
    0.21639988f, 0.15333256f, 0.08394658f, 0.01862730f, 0.00277162f, 0.18921036f, 0.12811971f, 0.01106625f, 
    -0.09245293f, 0.15872411f, 0.17158432f, -0.27779916f, -0.03050153f, -0.18336245f, 0.03077222f, 0.07362621f, 
    0.14752477f, 0.15248945f, -0.07564089f, -0.03618527f, -0.18525182f, -0.07100648f, 0.03608261f, 0.01761635f, 
    0.11229674f, 0.03592189f, 0.07483467f, 0.05845493f, -0.34870079f, 0.17172246f, 0.17512543f, -0.33839193f, 
    0.25671408f, 0.02591215f, -0.02654227f, 0.03808317f, 0.21031721f, 0.10406876f, -0.01960945f, -0.03582566f, 
    0.00508189f, -0.01540161f, 0.12986693f, -0.02199856f, 0.03350245f, -0.04606690f, 0.03642851f, 0.01960479f, 
    -0.20538102f, 0.02877962f, -0.10433760f, -0.00415445f, 0.08242518f, -0.02263301f, 0.00517260f, -0.08736027f, 
    0.02525556f, 0.03225325f, -0.08278368f, 0.03014635f, 0.03931857f, 0.08188719f, -0.02004033f, -0.08440752f, 
    0.13236311f, 0.05176117f, 0.11438821f, 0.07402302f, -0.17207450f, -0.04241494f, 0.03541545f, -0.17123151f, 
    0.07552346f, -0.13054930f, 0.01756611f, -0.02437438f, 0.12726614f, -0.04579441f, 0.01167980f, 0.04431668f, 
    0.01394566f, 0.02962625f, 0.06807277f, 0.20560840f, 0.17808795f, -0.14203231f, 0.21665457f, 0.02354026f, 
    0.13370818f, 0.23355038f, -0.14850435f, -0.18184964f, 0.10623232f, 0.23508771f, 0.12337131f, -0.04659714f, 
    0.00299769f, 0.07411967f, -0.03045742f, 0.00694524f, -0.05030587f, -0.00478009f, 0.28918266f, -0.05623474f, 
    0.02047752f, -0.03725100f, 0.05239503f, 0.25441521f, -0.23588039f, 0.18498869f, -0.13170062f, 0.15048070f, 
    0.41746113f, 0.18758817f, 0.22209965f, 0.36246777f, -0.05605653f, 0.23516825f, 0.05859591f, 0.17538981f, 
    -0.00336613f, 0.06606508f, 0.06597504f, 0.01565495f, 0.09906823f, 0.00753929f, -0.01739038f, 0.01399201f, 
    -0.10359456f, 0.16347769f, -0.15258104f, 0.06982499f, 0.16940503f, 0.00870096f, -0.06171960f, -0.07110681f, 
    -0.15419456f, 0.02221493f, 0.30104500f, -0.06933488f, 0.05866016f, -0.06057667f, 0.09181768f, 0.13050565f, 
    0.13232203f, -0.16954501f, 0.14717397f, 0.00528553f, 0.22092234f, 0.37313712f, -0.22860742f, -0.20746426f, 
    -0.05715216f, 0.20689504f, -0.01133786f, -0.10962550f, -0.14348444f, -0.00176504f, 0.15629528f, -0.00496097f, 
    0.08796539f, -0.05340682f, -0.01356737f, 0.01874598f, -0.05293958f, 0.15767775f, 0.14478283f, 0.02048971f, 
    -0.18870878f, -0.21738900f, -0.07348213f, -0.40440610f, 0.02262506f, 0.04028168f, 0.05568650f, -0.10132585f, 
    0.14875852f, -0.17782496f, 0.02667077f, -0.00989392f, 0.04275651f, -0.04139660f, 0.01907459f, 0.06074061f, 
    0.10222055f, 0.12790141f, -0.04081658f, -0.01977802f, 0.03126451f, -0.12150472f, -0.42727339f, -0.16265567f, 
    -0.11609142f, 0.14399114f, 0.18451838f, -0.10460449f, -0.02072264f, -0.19998387f, 0.04126474f, -0.02718393f, 
    0.08052948f, 0.06872755f, 0.08310397f, -0.03148868f, -0.00705199f, 0.02321194f, 0.20829175f, 0.27393624f, 
    -0.44778150f, 0.12950559f, -0.28089485f, -0.30178413f, 0.02078961f, 0.44368595f, 0.18945146f, 0.03914908f, 
    -0.09285925f, -0.12447748f, -0.07194073f, 0.06943912f, 0.03409523f, 0.09209947f, 0.00974439f, -0.03449342f, 
    -0.08437440f, 0.29832125f, 0.01802695f, -0.16234644f, -0.22359936f, 0.28724703f, -0.09830894f, 0.20540594f, 
    0.43581891f, -0.26174185f, -0.23453094f, 0.03123347f, 0.05426682f, 0.08923723f, 0.04343778f, 0.11181633f, 
    -0.03963795f, 0.02094966f, 0.02049913f, -0.01916041f, -0.06857844f, -0.04089645f, -0.06786660f, -0.09624393f, 
    0.10934782f, 0.21334028f, -0.09913796f, 0.09559990f, 0.12065260f, 0.13477527f, -0.13137974f, 0.01673243f, 
    0.09938594f, -0.06831313f, -0.02768783f, 0.16480480f, -0.06882964f, 0.07951580f, 0.15128522f, 0.07321268f, 
    0.02872998f, -0.11068169f, 0.05658537f, 0.24091014f, 0.16645572f, 0.35302517f, 0.30758733f, -0.25780177f, 
    0.01785937f, 0.04536541f, -0.06608068f, -0.05500082f, 0.13849071f, -0.06187982f, 0.12122393f, -0.07394727f, 
    0.01400362f, 0.07791010f, 0.07130626f, -0.00044706f, -0.04249188f, -0.18201728f, 0.06194977f, -0.24619156f, 
    -0.17104001f, -0.22979984f, -0.36949649f, -0.50648147f, -0.36979988f, 0.08986253f, 0.22199489f, 0.02077093f, 
    0.11627634f, -0.27364314f, -0.01789610f, -0.01417028f, -0.00236147f, 0.10240493f, 0.07313920f, -0.00702630f, 
    -0.00874180f, 0.09113413f, 0.09775411f, 0.35205665f, -0.27749702f, -0.22481544f, 0.00069991f, -0.31149504f, 
    -0.00703675f, -0.03464440f, -0.19331200f, -0.05576265f, -0.24139193f, -0.01554649f, 0.12823696f, 0.10857632f, 
    0.14388986f, 0.03296419f, 0.06560386f, 0.04899352f, -0.20776150f, 0.04345091f, 0.09490341f, -0.12376052f, 
    0.10309768f, -0.05666586f, -0.02452806f, -0.28231925f, -0.26276344f, -0.03744457f, 0.05104689f, -0.07610423f, 
    -0.03076726f, -0.13878998f, -0.00258232f, -0.03302967f, -0.02158629f, 0.17055659f, 0.02082816f, -0.04301102f, 
    -0.03445650f, -0.09668376f, -0.16698660f, 0.01781388f, -0.01884968f, -0.02337451f, 0.10696965f, -0.00275426f, 
    0.19743268f, -0.11239759f, -0.12744454f, -0.06807001f, -0.05442481f, 0.01711801f, 0.18484148f, 0.17493142f, 
    -0.16683237f, 0.06800635f, 0.03826587f, -0.02849369f, 0.02740215f, 0.27899739f, -0.05071337f, -0.08368895f, 
    -0.16065133f, 0.10616520f, -0.10831679f, -0.12803374f, 0.02083677f, -0.03226990f, -0.22165239f, -0.18529934f, 
    -0.06196342f, 0.10448281f, -0.01188337f, 0.08607428f, -0.05966395f, -0.10545040f, -0.03131527f, -0.18352398f, 
    0.03062858f, 0.09963375f, -0.00424321f, -0.01556714f, 0.30854800f, 0.31380311f, -0.01491674f, -0.25341582f, 
    -0.32584351f, 0.03334852f, 0.11033211f, -0.22475734f, 0.11304186f, 0.08080756f, -0.02715727f, -0.00813057f, 
    0.01238164f, -0.09728078f, 0.03043162f, -0.11039198f, 0.05622504f, -0.04565174f, -0.01927249f, -0.24257274f, 
    -0.20082529f, 0.05739299f, -0.13763012f, 0.12567186f, 0.25754884f, 0.01715475f, 0.01630804f, 0.05685850f, 
    0.00817766f, -0.02044588f, 0.02331825f, 0.01560088f, -0.02013159f, 0.10708812f, 0.05595797f, -0.06546095f, 
    -0.19331579f, 0.01206529f, -0.00406010f, -0.03453032f, -0.12498090f, -0.19918250f, -0.16582553f, -0.12265950f, 
    -0.07014106f, -0.03534999f, -0.12100068f, -0.09149512f, -0.06415140f, -0.01312158f, 0.08552210f, -0.18772939f, 
    -0.07041458f, -0.05068533f, 0.14877784f, -0.09227797f, 0.06185878f, -0.01573480f, -0.01034054f, 0.00140796f, 
    0.07493540f, 0.12208012f, 0.16693018f, 0.02588588f, -0.15740201f, 0.01241440f, 0.10277084f, 0.15750702f, 
    0.17746578f, -0.06864891f, 0.04676356f, -0.03140626f, 0.08482900f, 0.03414984f, 0.08387256f, 0.08273751f, 
    -0.15189932f, 0.14718111f, -0.05569501f, -0.12691477f, -0.27917537f, -0.17301454f, -0.04914946f, -0.03096217f, 
    0.09015331f, 0.04709828f, -0.08408293f, -0.10878154f, -0.08746056f, 0.07100917f, -0.06070441f, -0.15606220f, 
    -0.09215293f, 0.10640059f, 0.07739275f, -0.10738633f, -0.03136189f, 0.00173796f, -0.06063006f, 0.01712953f, 
    -0.00643809f, 0.18064204f, -0.30641118f, 0.05107417f, -0.06611855f, 0.23418027f, 0.02723621f, -0.05202323f, 
    0.09819376f, 0.14190912f, 0.02500412f, 0.17909698f, -0.01933683f, 0.10853628f, 0.04414396f, -0.02190838f, 
    0.03303821f, 0.16895756f, 0.10867745f, 0.33166510f, 0.22134857f, 0.31972906f, 0.05742178f, 0.00517119f, 
    -0.07999351f, -0.02555488f, -0.10559694f, 0.02262254f, 0.08684528f, 0.02979508f, -0.02563023f, -0.03084984f, 
    -0.01930285f, -0.06015731f, -0.02637112f, 0.04346900f, -0.10027941f, 0.03679200f, -0.17656137f, -0.23336335f, 
    0.47145888f, -0.07602041f, 0.00998637f, -0.08264898f, -0.28649598f, -0.08842935f, -0.08555477f, -0.17970502f, 
    -0.08436029f, -0.03211823f, 0.10628347f, 0.08437132f, -0.13068835f, -0.05575173f, -0.07443459f, 0.03060760f, 
    0.07524773f, 0.06200194f, -0.02714811f, 0.05670517f, 0.10172652f, 0.05771205f, 0.04525868f, 0.22322534f, 
    -0.02087126f, -0.04466717f, 0.08665469f, -0.04654483f, -0.17405403f, 0.13788022f, 0.00449337f, -0.03216743f, 
    0.02783959f, -0.09482484f, -0.01194068f, 0.16279814f, 0.04237777f, -0.12135674f, -0.00095131f, -0.00620960f, 
    -0.24308476f, -0.11381560f, 0.13122202f, 0.21975221f, -0.20289363f, -0.08950320f, 0.03292900f, 0.47811797f, 
    -0.10046672f, 0.29614586f, -0.30893534f, 0.04700115f, 0.15420415f, 0.08095129f, -0.00666105f, -0.05525315f, 
    0.09464110f, -0.02353592f, -0.30656400f, 0.09771426f, -0.25797439f, -0.15095274f, 0.24895920f, 0.10463183f, 
    0.05172778f, -0.08759691f, 0.00403814f, 0.13862056f, 0.00423485f, 0.04298680f, -0.14298421f, -0.14339173f, 
    -0.12979966f, 0.04841598f, 0.05672524f, -0.11611445f, -0.05946338f, -0.00051929f, -0.07322935f, 0.02116435f, 
    0.43377024f, 0.31821918f, -0.44756877f, 0.02334237f, 0.14080755f, 0.04436054f, 0.00037523f, -0.00789127f, 
    0.01244535f, -0.00658664f, 0.00367113f, 0.11003301f, 0.05614880f, 0.08635511f, 0.06063583f, 0.05619694f, 
    -0.02012318f, 0.18502516f, -0.01423432f, -0.04406917f, 0.21187067f, -0.04993209f, 0.09559750f, 0.06591479f, 
    -0.02643542f, 0.00630737f, -0.12532730f, -0.11922894f, -0.00534678f, 0.04493300f, 0.03793985f, 0.10442708f, 
    -0.03537585f, -0.07540279f, -0.08209406f, 0.02074629f, 0.05264991f, -0.14277594f, -0.04190360f, 0.05825603f, 
    0.04669869f, 0.16389064f, 0.06674090f, 0.01528523f, -0.16024543f, 0.01721016f, 0.05038549f, -0.04900264f, 
    0.11727069f, -0.00996959f, 0.12693262f, 0.02355039f, -0.02751114f, 0.09175182f, -0.01466967f, 0.01982128f, 
    0.10189568f, 0.04993213f, -0.12186009f, 0.06341969f, -0.07867233f, 0.12993360f, 0.31384468f, 0.45146200f, 
    -0.10759158f, -0.09108932f, -0.12872437f, 0.14519686f, -0.16720508f, -0.04224081f, -0.06329267f, -0.02906038f, 
    -0.20941749f, 0.01080635f, 0.00857200f, 0.01897158f, -0.01445857f, 0.10249341f, -0.09274877f, -0.12693219f, 
    0.04923657f, -0.20390868f, 0.01343460f, 0.12218604f, 0.16037537f, 0.05387194f, 0.03117164f, 0.09982778f, 
    -0.02503080f, 0.05100808f, 0.00854791f, -0.01603749f, -0.06193102f, -0.04945940f, 0.05591819f, 0.03663167f, 
    -0.15411142f, -0.13733828f, 0.01453215f, 0.15652721f, -0.57213891f, -0.49609682f, 0.31548497f, 0.37545300f, 
    -0.04141580f, 0.01953036f, -0.22391872f, -0.02945959f, 0.15825327f, -0.14019646f, 0.14769830f, -0.01195742f, 
    -0.15832119f, 0.04787022f, 0.03042380f, -0.19035468f, -0.05146396f, 0.16200662f, -0.29014194f, -0.13113938f, 
    0.56352311f, 0.00515993f, 0.05102153f, -0.06922344f, -0.04296657f, -0.01245276f, -0.11925098f, -0.09759256f, 
    0.15344968f, -0.17475237f, -0.06853829f, -0.00783841f, -0.03485250f, 0.02613078f, 0.04650597f, -0.09208442f, 
    -0.03080603f, 0.08162766f, -0.08980671f, 0.08261901f, 0.09912708f, 0.26571551f, 0.21718848f, -0.03380660f, 
    -0.14009131f, -0.26981449f, -0.00162946f, -0.15723507f, -0.02295005f, -0.02902943f, -0.00570079f, 0.00147332f, 
    0.04773642f, -0.12870657f, -0.03203834f, -0.00701333f, 0.04831875f, -0.12952319f, 0.06276633f, 0.04274406f, 
    0.15941721f, -0.07604931f, -0.03232991f, -0.14176418f, -0.10932099f, -0.03004664f, -0.12435044f, 0.01793520f, 
    0.06338321f, 0.16979617f, -0.04960839f, -0.13422975f, -0.08834135f, 0.08645793f, -0.20664671f, 0.13385548f, 
    -0.02410209f, -0.19215572f, -0.03027421f, 0.18322119f, 0.45289090f, 0.13748176f, 0.23235160f, -0.24197738f, 
    -0.22812989f, 0.07783838f, 0.01687651f, 0.27489620f, 0.07885839f, -0.00592095f, -0.03544185f, -0.09035267f, 
    -0.05670902f, 0.09664077f, -0.05824854f, -0.06778023f, -0.08811802f, 0.04396377f, -0.13207884f, -0.05712630f, 
    -0.09696698f, 0.01601888f, -0.45741844f, 0.12924264f, -0.00351817f, 0.07402114f, 0.13507831f, 0.16973205f, 
    0.13530943f, 0.23347113f, 0.04151913f, 0.02229890f, -0.04886522f, 0.04266207f, -0.02139751f, 0.03448790f, 
    0.00111736f, -0.16019349f, 0.21420944f, 0.00633381f, 0.16751778f, 0.42316288f, 0.46518335f, 0.12741385f, 
    -0.09538532f, -0.01784154f, -0.02503694f, -0.04535566f, 0.13125512f, 0.10060997f, 0.04613430f, 0.02757197f, 
    -0.04943886f, 0.05364798f, 0.03289140f, 0.02736657f, -0.03115427f, -0.07451465f, -0.02922448f, 0.01392124f, 
    -0.20597579f, 0.14616548f, -0.71532136f, 0.10792905f, -0.00710981f, -0.03676473f, -0.21900027f, -0.20968503f, 
    0.14393599f, 0.17756741f, 0.04180556f, 0.04074620f, -0.03211361f, 0.03806957f, 0.11196814f, 0.23041578f, 
    0.03611962f, -0.07061914f, 0.14966512f, 0.19904721f, -0.03243978f, 0.02811999f, 0.11370755f, 0.06956475f, 
    -0.12568794f, 0.00995116f, 0.09683495f, 0.00641712f, 0.03427410f, 0.05978840f, -0.02552617f, -0.00081992f, 
    -0.04386627f, -0.25693837f, -0.16910440f, 0.02607642f, -0.12212110f, -0.02393772f, 0.09841006f, -0.02555941f, 
    -0.32118705f, -0.04476354f, -0.05545147f, 0.23652425f, -0.02461099f, -0.00569075f, 0.11754335f, 0.05545587f, 
    0.03288477f, 0.06989956f, -0.12011413f, -0.23963019f, -0.06152795f, 0.07759022f, 0.10898324f, 0.06307568f, 
    -0.13526241f, -0.07442008f, -0.07715831f, -0.08663537f, -0.20393012f, 0.03616846f, 0.42215383f, 0.14941557f, 
    -0.04799226f, 0.04332594f, -0.12753792f, 0.04075448f, 0.08805572f, -0.00874676f, 0.01843876f, 0.11884437f, 
    -0.15914631f, 0.05542184f, -0.05894778f, -0.01880873f, 0.06853762f, 0.34277672f, -0.23243105f, -0.04742114f, 
    -0.01856187f, 0.42469051f, 0.52143592f, 0.25227705f, 0.06812752f, -0.17199662f, -0.05581828f, -0.01437327f, 
    0.01608655f, 0.18178821f, 0.04254075f, -0.03043350f, 0.05666042f, 0.03215014f, 0.11508626f, 0.06112322f, 
    -0.00099572f, -0.10278197f, 0.28463924f, -0.08162495f, 0.57883799f, 0.09982885f, 0.35943249f, -0.10190193f, 
    -0.24801958f, 0.09103261f, 0.06671438f, -0.05236061f, -0.04298486f, -0.04307844f, -0.09397794f, 0.01687917f, 
    0.07834712f, -0.22767118f, -0.08721048f, 0.00871112f, 0.14979354f, -0.20404637f, -0.31452152f, -0.02904019f, 
    0.09261467f, 0.12295230f, 0.35126641f, 0.11028757f, 0.13118143f, 0.11387369f, 0.05601407f, 0.08870085f, 
    0.06370772f, 0.11861128f, -0.00890168f, 0.02785443f, 0.05161043f, 0.08216404f, 0.07610451f, 0.01265972f, 
    0.01103270f, -0.08861021f, 0.13214579f, -0.01705760f, 0.21297018f, -0.31971005f, 0.13675441f, 0.01738349f, 
    -0.09873378f, -0.01578355f, 0.00479640f, -0.02122123f, -0.01481478f, 0.01372695f, -0.02860584f, 0.06625639f, 
    0.04246248f, 0.18374570f, -0.04875908f, -0.03130729f, -0.01341784f, -0.20149457f, -0.05493374f, 0.15741444f, 
    -0.02271263f, -0.23511170f, -0.12421652f, -0.13292062f, 0.09836928f, 0.10493738f, -0.01247369f, 0.18269674f, 
    0.08305034f, 0.04914384f, -0.03541627f, 0.03288295f, 0.10698565f, -0.13124382f, 0.12537454f, 0.06927858f, 
    -0.06471428f, -0.07238163f, 0.05386106f, 0.09360478f, 0.48492652f, -0.35723522f, -0.03104018f, -0.22761132f, 
    0.35691249f, -0.12746806f, 0.03137351f, 0.06077751f, 0.06608751f, 0.04568280f, 0.03297679f, -0.02905971f, 
    0.06637141f, 0.00045441f, 0.00727869f, -0.11946860f, 0.02341113f, -0.12424088f, 0.11709044f, 0.29221702f, 
    0.06175730f, 0.14218897f, 0.07597537f, -0.00622720f, -0.11336461f, -0.03927618f, 0.08598583f, 0.00630806f, 
    0.01910704f, 0.09675794f, -0.01195310f, -0.01897636f, 0.01252632f, -0.18097854f, -0.06603809f, 0.07305723f, 
    0.11756660f, 0.00388443f, -0.00714367f, -0.04677547f, 0.18789184f, 0.00645238f, 0.06535668f, 0.03487987f, 
    0.08403920f, 0.07831508f, 0.07113253f, 0.04900515f, -0.02910872f, 0.03393528f, -0.00570786f, -0.02636798f, 
    0.08434411f, -0.20031394f, -0.18456630f, 0.01790180f, 0.02281085f, -0.04516492f, -0.08248194f, 0.03319437f, 
    -0.12444182f, 0.23278971f, 0.15594625f, 0.20780291f, -0.10673769f, 0.07123791f, 0.05557051f, 0.07689572f, 
    0.03214121f, 0.14589202f, -0.03635799f, 0.04111279f, -0.03138331f, -0.06801618f, -0.05635531f, -0.08182339f, 
    0.16204977f, 0.26509213f, -0.07029502f, 0.09131730f, 0.14888786f, -0.13722058f, -0.03187696f, -0.00523078f, 
    -0.01721925f, 0.04378647f, 0.08663189f, 0.07567276f, 0.02147958f, -0.03666438f, 0.08549511f, 0.09424797f, 
    -0.00725998f, 0.01906990f, 0.04656388f, -0.00163571f, -0.02812285f, -0.01919913f, -0.07547010f, 0.00529338f, 
    0.33143908f, 0.15585889f, 0.15935700f, -0.10352179f, -0.11988197f, -0.18877272f, 0.02150516f, 0.11440352f, 
    -0.09492758f, 0.01478805f, 0.02981179f, -0.21376255f, 0.18327940f, -0.00100218f, 0.07400294f, 0.07744315f, 
    -0.02712936f, -0.41325638f, -0.09261604f, 0.12482691f, 0.09365790f, -0.05663866f, 0.01939407f, 0.07452611f, 
    -0.03543353f, 0.01187363f, 0.13796450f, 0.12593059f, -0.12012322f, -0.04330817f, -0.05213280f, -0.00254506f, 
    0.02778990f, -0.10463312f, -0.14953277f, -0.03973265f, 0.01973375f, -0.08241138f, 0.19517231f, 0.15466124f, 
    0.34463003f, 0.06651746f, -0.28554741f, -0.03824778f, -0.48075351f, 0.00876629f, -0.09330430f, -0.33796608f, 
    -0.01200893f, -0.19190116f, 0.19524081f, -0.00019035f, 0.00453120f, 0.07386640f, 0.01423374f, -0.05898674f, 
    0.00177172f, -0.03021833f, 0.03773410f, 0.07360102f, -0.05633628f, -0.07149899f, 0.09499507f, -0.22020952f, 
    0.02315212f, -0.06527960f, 0.04962571f, -0.10849769f, 0.04576752f, 0.20655154f, 0.05915969f, -0.00287531f, 
    0.04697061f, 0.15797864f, 0.18690866f, -0.11721794f, 0.10120037f, -0.07629959f, 0.21233392f, 0.15871534f, 
    -0.35028547f, 0.27556708f, -0.05600195f, 0.11520063f, -0.25625581f, 0.01789908f, -0.07831811f, 0.07940841f, 
    -0.42617244f, -0.05706317f, -0.00508290f, 0.11923301f, -0.05333921f, 0.02788588f, 0.04003652f, -0.03266066f, 
    0.01212670f, 0.05568312f, -0.11180630f, -0.00142667f, -0.02809499f, 0.05350893f, -0.06046216f, -0.00891969f, 
    -0.14679186f, 0.11222751f, -0.15423533f, -0.06864760f, -0.04799985f, -0.41863644f, 0.05436856f, 0.00324084f, 
    -0.05364282f, -0.11675990f, -0.08162052f, 0.02130041f, -0.09997997f, 0.08245224f, -0.19380261f, 0.02176328f, 
    0.22978012f, 0.15786272f, -0.09488042f, 0.19029802f, 0.07414316f, -0.07776618f, 0.09565920f, 0.03598854f, 
    0.08873373f, -0.00794397f, 0.07149905f, 0.04620830f, -0.02604059f, 0.00225563f, -0.02314854f, -0.05237065f, 
    0.18506041f, -0.02329001f, 0.01555581f, -0.07597860f, 0.22272390f, 0.05907914f, 0.06827017f, 0.07434999f, 
    -0.16966408f, 0.01403674f, -0.10260735f, -0.05697173f, -0.06568483f, -0.21500745f, -0.03640763f, -0.10077683f, 
    0.03009746f, -0.16373199f, -0.03697817f, -0.09622791f, -0.07736280f, -0.05427929f, -0.02035276f, 0.04000621f, 
    0.19244985f, -0.25220367f, -0.24521874f, 0.03523317f, -0.20759691f, 0.26976833f, -0.02615383f, -0.05490272f, 
    0.01598840f, 0.01407654f, 0.08315057f, 0.04109546f, 0.11106212f, 0.08041586f, -0.06120774f, -0.09143616f, 
    -0.08603951f, 0.00063670f, -0.10564304f, -0.00064553f, 0.01413452f, 0.01170573f, -0.20392023f, 0.04564799f, 
    -0.35648194f, 0.15681170f, -0.04825497f, 0.03202551f, 0.06672692f, -0.03773382f, 0.10107276f, 0.04564736f, 
    -0.05398769f, -0.05755737f, -0.03874863f, -0.05816694f, -0.01046478f, 0.02221606f, -0.02559390f, 0.02278617f, 
    0.12312105f, -0.08584796f, -0.03273093f, -0.07387604f, -0.00116904f, -0.03363219f, 0.00878704f, -0.01174588f, 
    -0.10164344f, -0.21676762f, 0.10048150f, 0.02538675f, -0.06086379f, 0.07506397f, -0.02589598f, 0.09810878f, 
    0.07592123f, 0.07168785f, -0.03714819f, -0.13797989f, -0.10771592f, 0.32530433f, -0.04556663f, 0.12353795f, 
    -0.29765949f, -0.08012484f, -0.06715493f, 0.01088069f, -0.23760217f, -0.08754568f, -0.00568695f, -0.09080901f, 
    0.11500969f, 0.01346732f, -0.00409493f, 0.10712895f, -0.09122107f, 0.05950587f, -0.16404831f, 0.08315920f, 
    0.16569293f, -0.15842159f, 0.04487246f, -0.12469587f, 0.25545892f, -0.08621724f, 0.05651292f, 0.10102123f, 
    0.16603599f, 0.13654457f, 0.02000582f, 0.17284034f, 0.02316550f, -0.02035041f, -0.11530291f, -0.06966251f, 
    0.19953622f, -0.06582499f, 0.10595024f, -0.09713694f, 0.06346134f, -0.24937397f, -0.20007932f, -0.23122512f, 
    -0.36653894f, 0.04735951f, -0.09517848f, -0.24542385f, 0.11808614f, -0.09639932f, 0.11830853f, -0.04311811f, 
    -0.03195628f, 0.03324783f, -0.01757717f, -0.00358067f, 0.03420203f, 0.08324750f, 0.05075658f, 0.03795717f, 
    0.11471745f, -0.15145297f, 0.15900439f, -0.14286165f, -0.36235344f, 0.19802266f, -0.20632985f, -0.01878551f, 
    -0.01664440f, -0.11584715f, 0.02619720f, 0.04782834f, 0.02934798f, 0.00990979f, -0.05275898f, -0.07538697f, 
    -0.06717027f, 0.04533435f, -0.06395791f, 0.05298451f, 0.06598154f, -0.20151624f, 0.33165538f, -0.41325480f, 
    -0.05120305f, -0.01319194f, -0.03513677f, -0.00359460f, 0.10656364f, 0.15984911f, 0.08481123f, 0.12071286f, 
    0.04412305f, 0.09516180f, -0.15364042f, -0.04706808f, 0.12914030f, -0.10705788f, 0.06683230f, 0.04303941f, 
    0.07936628f, 0.53778780f, 0.13522342f, 0.28191596f, -0.16374049f, -0.02408469f, -0.04770074f, 0.13733743f, 
    -0.07406030f, 0.40804434f, -0.01442425f, -0.03319228f, 0.03383946f, -0.04212562f, -0.06372933f, 0.07031301f, 
    -0.09431225f, -0.08683361f, -0.17737539f, 0.00987025f, -0.39801574f, -0.11730918f, 0.08899754f, -0.12601811f, 
    0.11718189f, 0.17835805f, 0.03583007f, 0.18000118f, 0.07532067f, 0.39854330f, -0.05533701f, 0.02037993f, 
    0.07235207f, 0.00543707f, -0.08698082f, -0.02606485f, 0.07850826f, -0.13622710f, -0.05907784f, 0.04206173f, 
    0.08015717f, 0.05090667f, 0.04389155f, 0.22071536f, -0.12129965f, -0.07303511f, -0.00251321f, 0.04004182f, 
    0.07459343f, 0.06024303f, -0.00465982f, -0.01425862f, -0.12387080f, 0.01930952f, -0.01600454f, 0.12822562f, 
    0.14988744f, -0.04987206f, -0.20796476f, -0.02749182f, 0.10600889f, 0.18758947f, -0.20572238f, 0.04877073f, 
    -0.28287053f, 0.02167011f, 0.01531102f, -0.16178906f, 0.04364331f, 0.00111618f, 0.02068910f, -0.05231009f, 
    0.01401611f, 0.00589181f, 0.12960178f, -0.05547594f, -0.00581487f, 0.05401817f, -0.03830721f, 0.10247000f, 
    -0.01311166f, -0.05494196f, -0.01676151f, -0.11082835f, -0.28579348f, -0.00736099f, 0.20901899f, 0.14838804f, 
    0.02749992f, 0.11029071f, 0.03381063f, -0.07959795f, -0.01789986f, -0.10723215f, -0.00466845f, 0.10788363f, 
    0.01407670f, 0.15745746f, -0.10821916f, -0.00412236f, -0.04629852f, 0.14964087f, -0.07318763f, 0.03928864f, 
    -0.13077115f, -0.05031947f, -0.00308428f, -0.03037102f, -0.09964370f, 0.09940568f, -0.06697112f, 0.00234219f, 
    -0.06459492f, 0.07620949f, -0.02537705f, 0.12897784f, 0.14039683f, 0.01764944f, 0.09518893f, 0.20607810f, 
    -0.14978865f, -0.17148553f, 0.16332981f, 0.17858167f, -0.05972497f, 0.16161557f, 0.02005289f, 0.20733860f, 
    0.20230001f, 0.30129012f, -0.08661528f, -0.03064235f, 0.03451634f, 0.04663392f, -0.04282096f, -0.05530785f, 
    -0.02891267f, -0.04895228f, -0.03593467f, 0.04294432f, 0.41048709f, 0.08810458f, 0.30028474f, -0.25184783f, 
    -0.15028556f, -0.14130031f, -0.12248291f, -0.04043931f, 0.07141785f, -0.01254779f, 0.05749922f, 0.01512691f, 
    -0.04578930f, -0.22095403f, -0.20011494f, -0.14709632f, 0.05817151f, -0.06382272f, 0.13720232f, 0.12176422f, 
    -0.22844219f, -0.10218517f, -0.05850730f, 0.06308161f, -0.03563853f, 0.22993475f, -0.00430623f, 0.06977718f, 
    0.15645063f, 0.24838006f, -0.01768281f, 0.01256542f, 0.03766767f, -0.02841281f, 0.11068238f, -0.03659825f, 
    0.02767371f, 0.06846999f, 0.01268609f, 0.12386094f, 0.32922387f, 0.14762360f, 0.01775707f, 0.13447206f, 
    -0.11282319f, -0.02433755f, -0.10608227f, 0.02016358f, -0.05074566f, -0.03095681f, 0.04458098f, -0.01398840f, 
    0.07112312f, -0.10075343f, -0.05904069f, -0.00373994f, -0.11500488f, 0.01684752f, -0.00442550f, 0.10793764f, 
    -0.16897824f, -0.00185678f, 0.05491322f, 0.16616170f, 0.05540103f, -0.00902433f, -0.03963382f, 0.01884721f, 
    0.08653393f, -0.07426903f, 0.00632032f, -0.06452222f, -0.01033348f, 0.04796136f, -0.10280380f, 0.08589187f, 
    0.01358641f, -0.12319622f, 0.02255369f, -0.15596858f, -0.23449257f, -0.18182294f, 0.10909814f, -0.04191960f, 
    0.33108515f, -0.11059551f, 0.14654021f, -0.11975588f, -0.01892109f, 0.01065793f, -0.06037087f, 0.07393628f, 
    -0.02552447f, -0.04494972f, -0.05639795f, 0.07968973f, 0.15919152f, -0.12557253f, -0.16059317f, 0.19995187f, 
    -0.06922047f, 0.01310463f, -0.08659940f, -0.11535628f, -0.14743325f, -0.03768188f, -0.00580390f, -0.09270159f, 
    0.10916254f, 0.13115323f, -0.00000434f, -0.00913413f, 0.01939379f, 0.07181921f, 0.11147436f, -0.03114321f, 
    0.03005964f, 0.00863073f, 0.04894330f, 0.05146181f, 0.05233427f, 0.08800983f, 0.06373370f, -0.00516202f, 
    0.08955240f, -0.05971592f, -0.07062687f, -0.09191605f, -0.05123193f, -0.20480765f, 0.21384479f, 0.10846446f, 
    0.07051405f, 0.08696157f, -0.00375835f, -0.00960461f, -0.06698485f, -0.06365582f, -0.02704177f, -0.06997538f, 
    -0.10687934f, -0.00725880f, -0.10765585f, -0.06528047f, -0.01325021f, 0.17098460f, -0.04142617f, 0.09813458f, 
    -0.03328956f, 0.21984889f, 0.00072418f, 0.00653068f, 0.00025048f, 0.09049614f, -0.05447093f, -0.06596194f, 
    0.07518078f, 0.05054798f, -0.00379331f, 0.03837569f, 0.06490277f, 0.00339917f, 0.00752073f, 0.06066628f, 
    0.04941019f, -0.07312284f, 0.02569439f, 0.00668917f, -0.08292299f, -0.23917711f, 0.12334578f, 0.06446409f, 
    0.06672410f, 0.04480055f, 0.02451286f, -0.07469266f, -0.05494561f, 0.03208496f, 0.06453048f, -0.06909779f, 
    -0.11803288f, -0.13793068f, 0.08149719f, -0.29930988f, -0.13831326f, -0.11527316f, 0.29238752f, -0.10059298f, 
    -0.01554692f, 0.09428591f, -0.01595440f, 0.04380877f, -0.03411297f, -0.06719549f, -0.02470948f, 0.02498012f, 
    -0.02791104f, -0.05039479f, 0.05584154f, -0.07021289f, -0.16872048f, -0.08283032f, 0.00342704f, -0.02803045f, 
    -0.14802448f, 0.05949819f, 0.01433179f, -0.07423315f, 0.16314818f, 0.14494671f, -0.05358259f, 0.04686001f, 
    0.02242395f, -0.02264812f, 0.07091256f, -0.00253609f, 0.09853405f, 0.06872047f, 0.03331418f, 0.25518671f, 
    0.28772238f, -0.06247723f, -0.62437099f, -0.21966878f, -0.09473497f, 0.04291935f, 0.14716533f, 0.26196808f, 
    0.23029207f, 0.14327492f, 0.01210079f, -0.10825750f, 0.03083227f, -0.09272985f, 0.02608773f, -0.05889669f, 
    0.01628122f, -0.05315741f, 0.05659623f, 0.00003520f, 0.12780643f, 0.44942316f, 0.42467225f, -0.29541990f, 
    0.02775811f, 0.12872900f, 0.19496678f, 0.08052927f, 0.34546387f, 0.06735630f, 0.08852283f, -0.02932574f, 
    -0.00239121f, -0.11669746f, 0.15040080f, -0.06459545f, 0.03706141f, 0.18550269f, -0.03420537f, 0.05731717f, 
    0.13126269f, 0.12367755f, -0.08644501f, -0.00592147f, -0.02804279f, 0.26130056f, -0.23256770f, -0.19269320f, 
    0.08553503f, 0.07755049f, -0.01898406f, 0.05099005f, -0.09192929f, -0.03977058f, 0.08595386f, 0.03678456f, 
    -0.01434472f, 0.05134685f, 0.20230895f, 0.03624276f, 0.27385429f, 0.06295175f, -0.07480571f, -0.06094890f, 
    -0.07287866f, 0.10709362f, -0.02448405f, -0.03201691f, -0.01550294f, -0.02164760f, -0.03061767f, 0.16835672f, 
    -0.00183746f, 0.17725503f, -0.01417507f, 0.01499056f, 0.00003802f, 0.17138557f, 0.03409792f, 0.01052260f, 
    -0.30631697f, -0.01203467f, 0.33837616f, 0.01144473f, -0.19876470f, -0.02859752f, 0.00048796f, -0.17339946f, 
    -0.05014194f, -0.08892406f, -0.02706447f, -0.02049506f, 0.06823383f, 0.00553556f, -0.01203890f, -0.04237448f, 
    -0.02797898f, -0.06190429f, 0.16777347f, -0.00334693f, 0.13114901f, -0.06859151f, -0.13526146f, 0.05423072f, 
    -0.01273573f, -0.05885402f, 0.08478958f, 0.06622053f, -0.07523491f, -0.01975140f, 0.06529971f, 0.05287321f, 
    0.03653410f, -0.12040325f, 0.23645669f, 0.02795212f, 0.01672077f, 0.03229974f, 0.02271375f, 0.05061840f, 
    0.15329988f, -0.12869456f, -0.36823454f, -0.15441172f, -0.04531434f, -0.01318084f, 0.05096058f, 0.19775136f, 
    0.07572122f, 0.14251174f, -0.14245312f, -0.06236846f, -0.04093511f, -0.05489714f, -0.02315771f, -0.03253734f, 
    0.03183727f, -0.01745012f, 0.02027000f, -0.01034146f, 0.43971047f, -0.00183830f, -0.26809508f, -0.52728152f, 
    -0.00552090f, 0.06622785f, 0.15547915f, 0.13147150f, 0.37924165f, 0.19042587f, 0.03360341f, 0.12820700f, 
    0.00027483f, -0.10138351f, -0.00875997f, 0.03652827f, 0.09868062f, -0.01195577f, 0.08979537f, -0.03006555f, 
    -0.02254267f, 0.14024070f, 0.06837511f, -0.11356605f, 0.05438429f, 0.02172655f, -0.07857611f, -0.13635941f, 
    -0.06704925f, -0.02657006f, 0.02208205f, -0.08907917f, 0.13565712f, 0.12203752f, -0.00757309f, -0.05964452f, 
    0.06389825f, 0.10160344f, 0.10128830f, -0.05609682f, 0.29310909f, 0.31706795f, -0.16564418f, 0.13913640f, 
    -0.11693551f, -0.15280238f, 0.14026798f, -0.00985390f, 0.05709825f, 0.06604520f, -0.32457897f, 0.24083360f, 
    0.22500287f, -0.00568667f, 0.06315157f, 0.11919118f, -0.03485510f, 0.00256201f, 0.15021229f, 0.11934122f, 
    -0.04456560f, 0.03399765f, 0.27011663f, -0.00841166f, 0.36750346f, -0.07895900f, 0.10840427f, 0.05277688f, 
    -0.15199062f, -0.24413273f, 0.18717647f, -0.08865344f, 0.07144841f, 0.07276600f, 0.14239354f, -0.00986769f, 
    -0.20905568f, 0.08187342f, 0.08513869f, -0.11218148f, -0.01394227f, -0.28083605f, -0.26495293f, -0.21014614f, 
    0.07249700f, 0.12812729f, 0.33019274f, 0.34786844f, 0.02351672f, 0.03611422f, 0.00863412f, -0.07608933f, 
    -0.09846317f, -0.08167826f, -0.01540145f, -0.06756429f, 0.05571377f, -0.01415547f, -0.01594565f, 0.04670579f, 
    0.01327491f, -0.08242647f, -0.28436112f, 0.03643831f, 0.02226698f, 0.09699354f, 0.07921832f, 0.12727088f, 
    0.08504312f, 0.05928303f, 0.10408234f, 0.26937792f, -0.04279467f, 0.10531306f, 0.05679503f, 0.00277805f, 
    -0.04200397f, 0.09633392f, 0.02919103f, 0.05014893f, -0.16630149f, -0.03308236f, -0.11327434f, 0.00092560f, 
    0.32662424f, 0.01666473f, 0.07216258f, 0.07098710f, 0.09608784f, 0.20569704f, 0.15787092f, 0.00878299f, 
    0.01361821f, 0.03640050f, 0.19872449f, 0.08052658f, 0.00445639f, 0.08499131f, -0.00257961f, 0.19747506f, 
    0.03646609f, 0.13945873f, 0.58863211f, -0.10225912f, -0.16432606f, -0.01586485f, -0.09263524f, -0.16455168f, 
    0.08855351f, -0.10856248f, -0.00561103f, 0.04370555f, 0.08449958f, -0.03666277f, 0.02338124f, 0.01720284f, 
    0.09640449f, 0.03402524f, 0.05777941f, 0.15848595f, 0.06902392f, -0.06660996f, -0.18702225f, -0.20931137f, 
    0.01531626f, 0.21473344f, 0.24810284f, 0.14541677f, -0.04916585f, -0.05613313f, 0.05451894f, -0.02226259f, 
    -0.04518848f, -0.06143807f, 0.03395503f, 0.03331651f, 0.03852118f, 0.10869942f, 0.05898507f, 0.27420992f, 
    0.19691618f, 0.31140122f, 0.86028808f, -0.14514391f, 0.01839401f, 0.21885452f, -0.00211403f, -0.42704999f, 
    -0.15296933f, -0.18387498f, -0.02362168f, -0.00836840f, 0.12003973f, -0.03303540f, -0.01752834f, -0.11099365f, 
    0.11099821f, 0.16460168f, 0.11401551f, -0.12568063f, 0.16011457f, 0.13824415f, 0.05354974f, -0.22316237f, 
    0.01856032f, 0.05116871f, 0.09498487f, 0.06407412f, 0.10969383f, -0.02834087f, 0.02975163f, 0.00669942f, 
    -0.04046039f, 0.12219521f, 0.29384795f, 0.03655360f, -0.02420317f, -0.07174521f, -0.13586092f, 0.03237527f, 
    0.13765904f, 0.03274737f, 0.15604453f, -0.18225145f, 0.17208962f, 0.23437649f, -0.12471730f, 0.08750128f, 
    0.21451283f, 0.07456287f, 0.02067816f, 0.23923591f, 0.13756524f, 0.03733695f, -0.00201937f, -0.05675951f, 
    0.11245352f, -0.00166089f, -0.01966383f, 0.14011222f, -0.05508564f, 0.27889934f, -0.05147866f, 0.09621874f, 
    0.00735315f, -0.18118221f, 0.13516489f, -0.08064410f, -0.06277660f, -0.01907693f, 0.02268872f, 0.02086135f, 
    -0.01422852f, -0.08417015f, 0.13212550f, 0.06378135f, -0.09335713f, -0.23705335f, 0.26930287f, -0.17239022f, 
    0.20698148f, -0.02905866f, -0.01600583f, -0.15964907f, -0.08771775f, 0.18240984f, 0.31502172f, 0.04455522f, 
    0.07138468f, -0.12423342f, 0.03531865f, 0.00805971f, -0.03035687f, -0.08952082f, -0.01762376f, -0.00867499f, 
    0.03428091f, 0.03551477f, 0.06486125f, 0.30265540f, -0.26986232f, -0.17586684f, -0.13222457f, 0.28730437f, 
    0.13462330f, -0.11456626f, 0.04647433f, 0.16155261f, 0.06840701f, -0.01753859f, 0.21675079f, 0.07831901f, 
    0.16040488f, 0.06976902f, 0.16224061f, -0.06372851f, -0.03917523f, -0.07205286f, 0.10121417f, 0.07077557f, 
    0.39254797f, 0.10415093f, 0.06919932f, -0.11855426f, -0.04670625f, 0.24515653f, 0.09083142f, 0.07316149f, 
    0.01017470f, -0.03770373f, 0.09607638f, 0.02466744f, -0.10002895f, -0.15481092f, -0.05080109f, 0.02012639f, 
    0.06509746f, 0.12767591f, 0.12061919f, 0.01545870f, 0.07251368f, -0.03710579f, -0.03693856f, 0.17090915f, 
    0.23059916f, -0.06512378f, 0.02586119f, 0.09763151f, -0.04541646f, -0.03536712f, 0.15747921f, 0.05060152f, 
    -0.04298539f, 0.01264710f, 0.14430052f, 0.04333960f, -0.04531129f, 0.01591553f, -0.07193135f, 0.13178903f, 
    0.00490754f, 0.17555363f, 0.00098847f, 0.08156456f, -0.15718718f, -0.00558134f, -0.00549153f, -0.04136298f, 
    0.01942426f, 0.05311425f, -0.00383266f, 0.01773615f, -0.02917825f, 0.04541033f, -0.02983517f, -0.12912969f, 
    0.10022108f, 0.12813577f, 0.03468909f, -0.00234458f, 0.39330786f, 0.24570192f, 0.23555779f, -0.29468375f, 
    -0.00779135f, 0.10134799f, -0.28055421f, -0.22769539f, -0.07966916f, 0.04549057f, 0.13024175f, 0.13776298f, 
    -0.05893024f, -0.02939991f, 0.06057033f, 0.02884463f, 0.08492301f, 0.02979651f, -0.01016706f, -0.32206225f, 
    0.15628204f, 0.09570789f, 0.06092082f, -0.17545392f, 0.04920972f, 0.15256675f, 0.13887130f, 0.23094434f, 
    0.11090628f, 0.07941946f, 0.05039059f, 0.03190530f, -0.05534422f, -0.03564550f, 0.05505273f, 0.08560017f, 
    -0.09413100f, 0.09793911f, -0.06564688f, 0.07734524f, -0.05733979f, 0.17144659f, 0.03183818f, 0.01832882f, 
    -0.08625087f, -0.08096281f, -0.02819683f, 0.02181624f, -0.00683195f, -0.08792726f, -0.01512252f, -0.16196589f, 
    -0.10546908f, 0.06056593f, 0.01741966f, -0.19854553f, -0.01794132f, 0.01171367f, 0.10674311f, -0.03459670f, 
    -0.04501784f, 0.16927822f, 0.06743822f, -0.01463469f, -0.02693845f, 0.09472203f, 0.08627054f, 0.05778294f, 
    0.04415106f, -0.01665954f, 0.02237214f, 0.00951180f, -0.00601120f, -0.13267224f, -0.06202985f, 0.12833774f, 
    0.03498020f, -0.14319591f, 0.05422807f, -0.09324078f, -0.02238511f, 0.21942858f, 0.01547400f, 0.08478022f, 
    -0.04027486f, -0.12828949f, -0.05531025f, -0.08670173f, -0.03837917f, -0.02036702f, -0.05498868f, -0.08291154f, 
    0.10744894f, 0.11734056f, 0.03150063f, -0.03254522f, 0.01062290f, -0.02594237f, 0.05432850f, 0.00747728f, 
    0.00724444f, 0.02821494f, 0.12802139f, -0.10004219f, 0.08011132f, 0.16313644f, 0.08871215f, -0.18040547f, 
    0.09888738f, 0.09915227f, 0.10409565f, 0.10576148f, 0.00491640f, 0.00953446f, 0.02151443f, -0.02340354f, 
    0.07726860f, 0.26300916f, 0.08603525f, 0.14441060f, 0.33229220f, 0.16503599f, 0.22598271f, -0.12070687f, 
    0.11525889f, 0.15698823f, -0.11241808f, -0.03996653f, 0.18581745f, 0.09174838f, 0.04889866f, -0.01274685f, 
    -0.04205095f, -0.19043674f, -0.03917776f, 0.11760575f, 0.00933205f, 0.01119012f, 0.02405615f, -0.16560429f, 
    -0.02533037f, -0.09696804f, 0.27197221f, 0.08723224f, -0.29668099f, -0.14437167f, -0.06665166f, -0.20430368f, 
    0.12926969f, 0.03889372f, 0.19019526f, 0.13327658f, 0.10101087f, 0.07833900f, 0.14288580f, 0.01391806f, 
    0.00338434f, -0.02569477f, -0.01944808f, -0.03581810f, -0.36675343f, -0.56124687f, -0.10197666f, 0.32203969f, 
    -0.16188464f, -0.21321483f, -0.15776290f, -0.00732829f, -0.19636101f, -0.04087518f, -0.00038053f, 0.01700740f, 
    -0.02443147f, 0.14867461f, -0.04294425f, 0.12824249f, 0.20898531f, -0.14022394f, 0.14170016f, -0.03865308f, 
    0.20205244f, 0.09678239f, -0.19487959f, 0.10024972f, 0.09351993f, 0.10160547f, 0.01282782f, -0.07244480f, 
    -0.02216372f, -0.03917503f, 0.10200597f, 0.04496867f, 0.00462676f, 0.15061803f, 0.09278190f, 0.10396198f, 
    0.04085395f, -0.00915526f, 0.04268507f, 0.09864850f, 0.11507172f, 0.06405877f, -0.10152680f, 0.06849892f, 
    0.01116514f, 0.11055142f, 0.13482788f, -0.12171101f, 0.02093974f, -0.11536232f, 0.07902767f, 0.09110137f, 
    0.13658087f, 0.24312072f, 0.22411756f, 0.11798446f, 0.08185633f, -0.01513242f, 0.08424701f, 0.07862096f, 
    0.23250446f, 0.14066830f, 0.14154880f, -0.04417270f, -0.00487343f, 0.10746771f, 0.12944809f, 0.09685937f, 
    0.03436248f, 0.01210149f, 0.03255191f, 0.02158107f, 0.01512583f, -0.08936749f, -0.06574514f, -0.01224621f, 
    0.07641564f, 0.08027332f, -0.05304244f, 0.12687591f, -0.18954954f, 0.06845061f, 0.01057175f, -0.00772821f, 
    -0.05468783f, -0.01203388f, 0.00608302f, 0.03129030f, -0.01651558f, -0.02055766f, 0.02184193f, 0.16613714f, 
    0.07863187f, 0.20301187f, 0.20142834f, 0.08322290f, -0.04759296f, 0.00721420f, 0.05735111f, 0.01964662f, 
    0.06210260f, -0.09522286f, 0.16343683f, 0.17957047f, -0.14042051f, -0.01665384f, -0.11299875f, -0.17642340f, 
    -0.08722898f, -0.02215076f, 0.25836059f, 0.03138285f, 0.09303872f, -0.02743650f, 0.00540257f, 0.01157013f, 
    -0.02956331f, -0.05434439f, -0.08814549f, -0.09650957f, -0.25364622f, -0.13478684f, -0.10313790f, 0.59636235f, 
    -0.18847860f, 0.00761483f, -0.04924052f, -0.07201461f, 0.04322936f, 0.04960519f, 0.06165229f, 0.05143522f, 
    0.02086901f, 0.10437839f, -0.09494951f, -0.06970212f, -0.01355927f, 0.15608525f, 0.05675243f, 0.01628564f, 
    0.14020607f, 0.06280021f, -0.02773733f, 0.21666935f, -0.06099503f, 0.08038444f, 0.01192371f, 0.16776618f, 
    -0.06399547f, -0.01509539f, 0.02006391f, -0.04939821f, -0.00790847f, 0.08049280f, -0.04252974f, 0.10199489f, 
    0.11673325f, 0.04698953f, 0.02970936f, 0.07919792f, 0.21110074f, 0.42990416f, -0.21823423f, 0.11351663f, 
    0.06101932f, 0.15304497f, 0.32358167f, 0.04604640f, 0.00296227f, 0.00662527f, -0.13752720f, 0.07807186f, 
    0.00096127f, 0.23456581f, -0.00193285f, 0.17352346f, 0.12722476f, 0.07255089f, -0.07789429f, -0.00203815f, 
    0.13834397f, -0.04670833f, 0.27402011f, 0.19885451f, 0.19716188f, 0.02639169f, 0.22996913f, 0.17870082f, 
    0.13252482f, 0.32485935f, 0.02658666f, -0.06063044f, -0.01117731f, -0.00153214f, 0.01600339f, 0.12252375f, 
    0.10779710f, -0.09774487f, 0.07494206f, -0.04487757f, 0.02099305f, -0.00234838f, 0.14027974f, 0.05455349f, 
    -0.19782691f, -0.05868563f, -0.21850595f, -0.16303577f, 0.22702491f, 0.17097560f, 0.23404677f, 0.14788827f, 
    0.02258261f, -0.00580663f, 0.00542719f, 0.00678595f, -0.05612017f, -0.04091623f, 0.03886918f, -0.02684029f, 
    -0.13530150f, 0.01710285f, 0.16457425f, -0.04304790f, -0.14771028f, 0.05319692f, 0.06193412f, 0.00507709f, 
    0.12217211f, 0.01667356f, -0.12414926f, 0.10220686f, 0.12214810f, 0.18830393f, 0.15926041f, -0.03872707f, 
    -0.04675671f, 0.00978243f, 0.01612350f, -0.05675833f, -0.34581408f, -0.29977164f, 0.66900361f, -0.06141112f, 
    0.21005422f, 0.03625690f, 0.07248813f, 0.12793797f, 0.26454657f, 0.24750081f, -0.10814656f, 0.11128464f, 
    -0.03849849f, -0.01013588f, 0.04946765f, 0.07286894f, 0.10536859f, 0.06548201f, 0.12561595f, -0.12330332f, 
    0.00551743f, -0.19151172f, 0.06459530f, 0.34989503f, -0.23633623f, 0.17831306f, -0.09095550f, 0.11322378f, 
    -0.04371376f, 0.10592461f, -0.02374996f, 0.07869922f, -0.06324083f, 0.02379370f, -0.03645853f, -0.00232151f, 
    0.01663538f, -0.14143810f, 0.02625549f, 0.06632734f, -0.22262990f, -0.25503260f, 0.17430139f, 0.12658796f, 
    -0.03605897f, -0.18646890f, -0.12955208f, 0.04896482f, 0.13793753f, 0.11995046f, -0.05160902f, 0.14598507f, 
    -0.04126405f, -0.02450811f, -0.10057594f, 0.07324273f, 0.07286713f, -0.07028027f, 0.16895367f, -0.14257087f, 
    0.17514944f, -0.15646090f, -0.33784077f, 0.45006493f, -0.25317323f, 0.05565283f, 0.17085087f, 0.47975326f, 
    0.29442742f, 0.07870942f, 0.00719555f, 0.00124654f, 0.01577514f, -0.03814043f, -0.12495562f, -0.13133986f, 
    -0.02820554f, -0.07529432f, 0.10483865f, 0.17283666f, -0.26587543f, -0.15415369f, -0.23768173f, 0.06092277f, 
    -0.18449673f, 0.03560394f, -0.19803238f, -0.14594692f, -0.07585461f, -0.03895332f, 0.00230025f, -0.00643801f, 
    0.05226690f, 0.09868427f, -0.09813730f, -0.04183805f, 0.00883766f, 0.03630390f, 0.11801387f, 0.04227938f, 
    0.33819661f, -0.07848507f, -0.02852296f, 0.46581861f, -0.20006803f, 0.06523479f, 0.13332732f, 0.10874682f, 
    0.01095005f, 0.22583231f, -0.01802456f, 0.06617258f, 0.01951746f, 0.29018608f, 0.00661006f, -0.02057847f, 
    0.05677192f, -0.03959116f, 0.10506458f, 0.00805606f, -0.13606071f, 0.28495234f, -0.21169364f, 0.29936883f, 
    0.21540268f, 0.16500798f, 0.16717324f, 0.05357559f, 0.06734703f, -0.08766539f, -0.02740805f, -0.00877808f, 
    -0.07896253f, -0.07001324f, 0.01085372f, 0.06867999f, 0.01281843f, 0.47832197f, 0.12967899f, 0.05396894f, 
    -0.28016236f, -0.31739128f, 0.07917567f, 0.22435017f, -0.07526390f, -0.01975215f, -0.23428212f, 0.09009090f, 
    -0.24609317f, 0.04685684f, -0.06528571f, 0.11097621f, 0.05720600f, -0.03418949f, -0.12176590f, 0.01160947f, 
    0.05370504f, -0.05906296f, 0.32576084f, -0.15032563f, -0.63036805f, 0.11130454f, 0.24943157f, -0.05401495f, 
    0.14095303f, -0.07191171f, 0.01011684f, -0.01092801f, 0.11153121f, 0.04772121f, 0.19698794f, -0.03491991f, 
    0.08602397f, 0.18557779f, 0.13756602f, 0.04397652f, 0.08977345f, 0.30989519f, 0.00953167f, -0.05858368f, 
    -0.19394465f, -0.26888070f, -0.08200452f, 0.26335466f, -0.27010992f, -0.06101707f, -0.15808320f, -0.05986742f, 
    0.15075415f, -0.00327446f, 0.05899879f, 0.04567134f, 0.05147248f, 0.08615178f, 0.01198277f, 0.06597684f, 
    0.06096640f, -0.04453882f, 0.10510755f, 0.05592340f, -0.30287296f, -0.01834854f, -0.19281863f, -0.00195330f, 
    0.04534974f, 0.00659951f, 0.01073813f, 0.00964182f, -0.05192778f, 0.01117895f, -0.09355178f, 0.06950722f, 
    -0.05850302f, 0.20024970f, 0.26557934f, -0.00308449f, -0.09786709f, 0.21476156f, 0.02174326f, -0.00740478f, 
    0.11067049f, 0.03965722f, -0.08728914f, 0.18535513f, -0.01927714f, 0.18814835f, 0.01866305f, 0.22468919f, 
    -0.03414444f, -0.00173203f, 0.02640384f, -0.04503703f, 0.04027044f, -0.04783429f, 0.05680060f, 0.07790755f, 
    0.07564299f, -0.04397063f, 0.07777379f, 0.02709872f, 0.26548499f, -0.27427721f, 0.22165130f, 0.34501120f, 
    -0.02685152f, 0.33954370f, 0.31634998f, 0.09411120f, 0.05323623f, 0.09301952f, -0.04555903f, -0.00372958f, 
    0.02990731f, -0.00043588f, -0.02410436f, 0.21329628f, 0.02677928f, -0.05450629f, 0.12103835f, 0.24560860f, 
    -0.29471689f, -0.22502972f, -0.06333955f, 0.07347212f, -0.16376556f, -0.12160709f, -0.10713565f, -0.01385427f, 
    0.12104607f, 0.04392077f, 0.06228290f, -0.00024106f, 0.01826202f, 0.15731665f, -0.01567458f, 0.13872690f, 
    0.13609435f, -0.03019335f, 0.18924706f, -0.00498141f, -0.04280134f, 0.08546185f, 0.10973611f, -0.06338299f, 
    -0.10501774f, -0.00995247f, 0.03239361f, 0.00983327f, -0.02370561f, -0.08789118f, 0.08417518f, 0.19864796f, 
    0.07479610f, 0.09650615f, 0.14429353f, 0.11916955f, 0.09886039f, 0.09278624f, -0.04779157f, 0.04846652f, 
    -0.04551776f, -0.09580905f, -0.02228804f, 0.10316044f, 0.17543018f, -0.02191827f, -0.19138460f, 0.16098952f, 
    0.05183318f, -0.01325729f, 0.06263086f, 0.02614220f, 0.02795738f, 0.16381976f, -0.00646814f, 0.17894417f, 
    0.13892193f, -0.04348851f, 0.09783943f, 0.01431932f, 0.06408843f, 0.10230199f, 0.13112411f, -0.08438811f, 
    -0.01562004f, 0.00181849f, 0.00694007f, 0.02972509f, 0.02985099f, -0.06729210f, 0.03840540f, -0.01855429f, 
    -0.02983757f, -0.03150091f, -0.07390171f, 0.18168895f, 0.15576342f, 0.10943289f, 0.03742488f, 0.04136226f, 
    0.06043110f, -0.25647113f, 0.40411511f, 0.22523119f, -0.04493647f, -0.02968138f, 0.03247816f, 0.08736712f, 
    0.01846717f, 0.17407915f, 0.02610729f, 0.20668256f, 0.04378865f, -0.05437576f, -0.00232728f, 0.14225383f, 
    0.07348283f, -0.08491811f, 0.02949675f, -0.05477963f, -0.20665640f, -0.21900617f, -0.11949346f, 0.29274049f, 
    -0.17109594f, -0.04840952f, 0.00916355f, -0.01603106f, 0.09153207f, -0.13961139f, 0.00426043f, 0.04996115f, 
    0.03374448f, 0.22484134f, 0.16516773f, 0.18342048f, 0.21520576f, 0.14172055f, 0.01307593f, 0.06778575f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06064952f, 0.02042795f, -0.03853636f, 0.14326152f, -0.05850726f, -0.01062086f, 0.08419569f, 0.11048342f, 
    -0.03192278f, -0.08261467f, -0.02545759f, -0.00645313f, -0.04545145f, -0.03259934f, 0.20806094f, 0.01901051f, 
    0.06835428f, -0.03716580f, 0.03092397f, 0.02927128f, 0.02126930f, -0.03634837f, -0.03398440f, 0.02588638f, 
    0.13522355f, 0.08318587f, 0.07181431f, 0.05406868f, 0.02067568f, 0.02050928f, 0.05993380f, 0.16540076f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04822718f, 0.26566768f, 0.13221429f, -0.04444363f, -0.06962220f, 0.13900661f, 0.13897586f, 0.16743317f, 
    0.10101858f, 0.18844481f, -0.35871542f, 0.02420901f, -0.17254405f, -0.11226948f, -0.57161927f, 0.11840129f, 
    -0.71292555f, -0.15894654f, 0.11159433f, -0.11364926f, 0.12257332f, -0.11142027f, -0.04659114f, 0.17243218f, 
    -0.48920572f, 0.00454800f, -0.75430262f, 0.04124654f, 0.07455929f, -0.22808369f, 0.03025936f, -0.56610996f, 
    -0.64180231f, -0.17585312f, 0.07766231f, 0.06704686f, -0.24104568f, 0.12115122f, 0.15341397f, 0.30504948f, 
    -0.76111901f, 0.03801689f, 0.03674553f, -0.08008619f, -0.13688414f, -0.00634495f, 0.09648355f, 0.12356240f, 
    -0.02045804f, -0.07230450f, 0.43849209f, 0.13969406f, 0.15160252f, -0.09419207f, -0.16615607f, 0.02956107f, 
    0.57560420f, 0.11265904f, -0.14132252f, 0.06861483f, 0.05378219f, 0.14782241f, 0.07980841f, -0.23843186f, 
    0.13310690f, 0.20383361f, -0.00124848f, -0.15753931f, -0.27643427f, -0.02962625f, 0.24292119f, -0.20336111f, 
    -0.26641691f, 0.01977358f, -0.24329190f, 0.01064915f, 0.00183816f, 0.15653712f, 0.16632012f, -0.02340537f, 
    0.55649364f, -0.00419377f, -0.09504352f, -0.12032375f, -0.08822648f, -0.09231665f, 0.12462299f, -0.08220115f, 
    -0.68527526f, -0.19462150f, 0.17897826f, 0.18859889f, -0.39598340f, -0.32519761f, -0.05075104f, -0.01128204f, 
    0.22063144f, 0.11172909f, 0.12312384f, -0.45015395f, 0.40706110f, -0.04813328f, -0.60698754f, -0.30129674f, 
    -0.00535556f, 0.35488856f, 0.32746029f, -0.10313706f, 0.09564670f, 0.01275969f, -0.29486158f, 0.07679608f, 
    0.08426089f, -0.02328805f, 0.17922994f, -0.11420754f, -0.08711032f, -0.14115848f, -0.01848879f, -0.17922892f, 
    -0.53820354f, -0.08189312f, 0.04773162f, 0.07986348f, -0.53258848f, 0.16856240f, -0.00339501f, -0.34556794f, 
    0.33801833f, -0.08395245f, 0.10702758f, -0.43842781f, -0.19585417f, -0.01569054f, 0.16581319f, 0.01796993f, 
    0.35156438f, 0.06247229f, -0.02860688f, 0.08207242f, -0.12241417f, 0.13151668f, -0.03858485f, -0.00401157f, 
    -0.04129820f, -0.10059560f, 0.14212939f, -0.12376928f, 0.14272438f, 0.04905609f, 0.07390995f, 0.06237552f, 
    -0.11470602f, -0.23178396f, -0.14247589f, -0.08131470f, 0.25378910f, -0.38468590f, -0.22692370f, -0.03086638f, 
    0.17777248f, -0.24410483f, 0.08002096f, 0.49088168f, -0.14182299f, 0.08205880f, -0.20497398f, -0.08726794f, 
    0.10047892f, 0.06585664f, -0.14207876f, -0.13395484f, -0.08978681f, 0.03628990f, 0.31641614f, 0.05851340f, 
    -0.72513139f, 0.02706996f, -0.02615508f, -0.17286243f, -0.14520760f, 0.07399863f, 0.15662269f, 0.11693818f, 
    -0.20582224f, -0.22632323f, -0.20782834f, 0.20775421f, 0.04043240f, 0.17948349f, 0.10102632f, 0.00740049f, 
    0.19519281f, -0.37436658f, 0.15241183f, -0.18433844f, 0.00486693f, -0.11563090f, 0.10128937f, -0.46633232f, 
    -0.10623676f, -0.29047039f, 0.20632413f, 0.11568376f, -0.18339077f, 0.15187660f, 0.15358248f, 0.00005248f, 
    0.30591851f, 0.08606637f, -0.61021364f, -0.11127882f, -0.08640082f, -0.04233711f, -0.00634349f, 0.05854232f, 
    0.31800088f, 0.34541759f, 0.34324294f, 0.20612492f, -0.04754557f, -0.59231257f, -0.15001819f, 0.02089234f, 
    -0.52691680f, 0.07317030f, -0.15407634f, 0.18790284f, 0.13412707f, -0.11785849f, -0.09676551f, -0.18889226f, 
    0.15881181f, -0.09212643f, 0.38794920f, -0.12730205f, -0.03230846f, -0.12852632f, -0.17540905f, -0.02586220f, 
    0.14403811f, -0.15292539f, -0.67002892f, -0.02094037f, 0.11082327f, -0.01297022f, 0.03873145f, -0.00304794f, 
    -0.29264808f, -0.16520229f, -0.50273639f, -0.47751680f, -0.01895788f, 0.30145660f, 0.25235718f, 0.15153757f, 
    -0.52650595f, 0.16949651f, 0.15710771f, 0.02036463f, 0.19417204f, 0.08029915f, -0.33838385f, 0.37045944f, 
    -0.51432508f, -0.45433676f, -0.06143414f, 0.14543444f, 0.14251986f, 0.06731567f, 0.08855461f, -0.06211052f, 
    -0.37345707f, 0.15071738f, -0.60994577f, -0.11751802f, 0.13143615f, 0.10354236f, -0.12161931f, 0.10134263f, 
    -0.00004900f, -0.47455555f, -0.13086815f, 0.26481321f, -0.48613238f, -0.22035569f, 0.24615870f, 0.08294550f, 
    -0.14301455f, 0.05176796f, -0.05455001f, 0.05730700f, 0.00088091f, 0.08727137f, -0.00671618f, -0.35108802f, 
    0.33446532f, -0.56054187f, -0.38770023f, -0.03273946f, 0.04763222f, 0.14882351f, 0.15730132f, -0.00251168f, 
    0.13779365f, -0.14428847f, 0.24802800f, -0.05527229f, 0.05081781f, -0.02523477f, 0.02824403f, 0.15049937f, 
    -0.29796073f, 0.53505850f, -0.11331694f, -0.10688937f, 0.19112714f, 0.29156810f, -0.40455389f, 0.21353337f, 
    -0.16231026f, 0.33809546f, 0.09298489f, -0.41964018f, -0.11670607f, 0.07017423f, -0.51221550f, 0.22702703f, 
    -0.60959816f, 0.39658290f, 0.07488675f, -0.16568758f, 0.02303096f, -0.04071273f, 0.25290447f, 0.13488026f, 
    -0.38679025f, -0.18041454f, -0.31857449f, 0.02057566f, -0.16131888f, -0.15494469f, -0.05396473f, 0.03117859f, 
    -0.09750873f, -0.12832946f, 0.20471427f, 0.05479454f, 0.18307003f, -0.33833534f, -0.31504187f, 0.08202486f, 
    -0.15727057f, -0.60516387f, -0.15252677f, 0.04907960f, 0.25286847f, 0.17036189f, -0.03638198f, 0.00265455f, 
    -0.08974742f, 0.21793364f, -0.50961769f, 0.13803481f, -0.01254490f, -0.00410243f, -0.29626432f, -0.03884074f, 
    -0.29327315f, 0.16305141f, -0.20463260f, -0.10737549f, -0.16636178f, 0.12163775f, 0.07592128f, 0.11944568f, 
    0.05703900f, -0.19826578f, 0.48000228f, -0.47273818f, -0.53082782f, -0.12613916f, 0.01557448f, 0.29836854f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17109211f, 0.09497308f, -0.10675337f, -0.04532246f, -0.16430861f, 0.03288677f, 0.05393077f, -0.11761531f, 
    0.15307848f, -0.13667457f, 0.00217014f, 0.13376738f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
