#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.37725532f, -0.88383251f, -0.94323361f, 0.01659929f, -0.33653691f, 0.60536593f, 0.08860273f, 0.38581344f, 
    0.61036545f, 0.72707891f, 0.46734715f, 0.09679898f, 0.08794978f, 0.04119157f, 0.03871913f, -0.12705761f, 
    0.02597607f, 0.13844700f, 0.13128820f, -0.23158786f, -0.20636384f, 0.04751044f, 0.07999963f, -0.26703328f, 
    0.19093795f, -1.41159213f, -0.43706706f, -0.56027573f, -0.55751109f, -0.17527685f, 0.04655680f, 0.57884258f, 
    -0.09524655f, -0.26450777f, 0.08530983f, -0.08117713f, -0.34710184f, -0.64084691f, -0.47645819f, 0.21984892f, 
    0.08200309f, 0.19668816f, -0.42387125f, 0.08662006f, -0.19246034f, 0.17368867f, -0.14769951f, -0.20035698f, 
    0.09203217f, -0.35922199f, 0.64568704f, 0.35584432f, 0.39234716f, 0.23100080f, 0.00787314f, 0.35866901f, 
    -0.01428028f, 0.15948291f, -0.09706977f, 0.14317663f, 0.34490827f, 0.19447549f, 0.20487253f, -0.04365489f, 
    -0.01275943f, 0.17921403f, 0.12708600f, 0.15885764f, -0.13048615f, -0.39032409f, -0.07553259f, -0.12375978f, 
    -0.01387559f, 0.21450302f, 0.18089402f, 0.44681308f, 0.89115655f, 0.62105578f, 0.44043833f, -0.67040253f, 
    -0.61969554f, -1.13149524f, -0.37500268f, 0.56487167f, -0.10447913f, -0.05762924f, -0.46394137f, -0.27906036f, 
    0.38748851f, -0.32275647f, 0.05336438f, 0.38243046f, 0.29593408f, 0.09281940f, -0.02193613f, -0.30858132f, 
    -0.07996927f, -0.39438361f, -0.11737049f, -0.18915471f, 0.50589013f, 0.21138051f, 0.02141177f, -0.19739240f, 
    -0.23816882f, 0.19995414f, 0.67469066f, 0.61352867f, 0.27370074f, -0.26566800f, -0.55402642f, -0.04003187f, 
    -0.07586261f, -0.62372512f, -0.22914872f, 0.29096824f, 0.13132699f, -0.32194111f, -0.42312092f, -0.35326025f, 
    0.01511797f, -0.27551937f, -0.24290881f, -0.59017867f, -0.29751500f, -1.14481890f, -0.86217541f, -0.37364396f, 
    -0.00362220f, 0.10602779f, 0.46475303f, -0.24866378f, -1.11959207f, -0.73806190f, -0.22833344f, 0.05977591f, 
    -0.09542987f, -0.28945139f, -0.43861476f, -0.61506855f, 0.09748321f, 0.26767030f, -0.19303744f, -0.29047439f, 
    -0.35049573f, -0.42940128f, -0.12306691f, -0.09953277f, -0.10489980f, -0.20053273f, 0.54014009f, 0.37905520f, 
    0.40511623f, -0.30913392f, 0.37027451f, 0.20652963f, -0.02259185f, -0.63050377f, -0.56421047f, -0.03651752f, 
    -0.15974918f, -0.11501203f, -0.02028864f, 0.07669697f, 0.10865586f, 0.39915079f, 0.00412355f, -0.18707153f, 
    -0.25991985f, 0.17408429f, -0.45758927f, 0.54009211f, 0.25277191f, 0.20480460f, -0.10699920f, -0.13088992f, 
    -0.13094173f, -0.59855849f, 0.34731829f, 0.94353628f, -0.20790416f, -0.54491091f, -0.38867617f, -0.58701736f, 
    -0.00437946f, 0.04959951f, -0.58144367f, -0.07067993f, 0.05563732f, -0.61423993f, 0.07871735f, 0.19382997f, 
    0.08988270f, 0.20530544f, 0.16589786f, 0.26613343f, -0.05500584f, 0.20646258f, 0.30817834f, 0.29041058f, 
    -0.72612417f, -0.05752287f, -0.18619770f, -0.80903488f, -0.17712428f, -0.27314028f, -0.73472965f, -0.78038603f, 
    -0.82688624f, -0.52403802f, -0.12358713f, 0.32046333f, -0.05822578f, 0.43477297f, -0.20910269f, -0.24355271f, 
    -0.84496945f, -0.05108906f, -0.15455103f, -0.28029969f, -0.02335210f, 0.42637080f, -0.16171589f, 0.07958166f, 
    0.35882378f, -0.18032858f, -0.29399082f, -0.21572016f, 0.10647129f, 0.42289335f, 0.38225240f, -0.42625108f, 
    0.29545796f, 0.75353354f, 0.15993734f, 0.09094303f, -0.36908141f, -0.16414827f, 0.34154952f, 0.02812101f, 
    -0.36064494f, -0.32141754f, 0.21235119f, -0.23762634f, -0.53020585f, 0.06032654f, 0.48939222f, 0.00500290f, 
    0.20542313f, 0.36568737f, 0.47834995f, 0.11488263f, 0.27224025f, 0.32704702f, 0.56807554f, -0.13836476f, 
    -0.13053891f, -0.30556673f, -0.17968038f, 0.63468915f, 0.28159598f, -0.22206779f, 0.04749967f, 0.02407882f, 
    0.17587830f, -0.34715241f, -0.24144387f, -0.14108391f, 0.30378592f, -0.33275071f, 0.01060815f, 0.22174247f, 
    -0.14922071f, 0.05580138f, -0.39106089f, -0.02036623f, -1.09867322f, 0.09586911f, 0.98554832f, 0.52762651f, 
    -0.71837455f, -0.08824217f, -0.68604463f, -0.62243885f, -0.23849332f, 0.01611353f, -0.24023630f, 0.70325732f, 
    -0.32694975f, 0.33044496f, -0.32740712f, -0.11424735f, 0.24395284f, -0.01903264f, -0.33656701f, 0.25224778f, 
    -0.26361164f, -0.05177289f, 0.12980439f, 0.15935870f, -0.74701041f, -0.32038453f, 0.01432508f, 0.03747315f, 
    0.11100505f, 0.43748185f, -0.33673793f, 0.78174543f, -0.15641442f, -0.34956104f, -0.43841186f, -0.16160235f, 
    0.71677667f, -0.51349628f, 0.03267885f, -0.00974876f, -0.28152475f, 0.09949204f, 0.17127642f, 0.11656940f, 
    0.07212945f, -0.23612146f, 0.12343311f, 0.09665687f, 0.46542731f, 0.62889469f, 0.00653984f, -0.09019858f, 
    -0.09382007f, -1.00909340f, -0.68684006f, -0.69387692f, -0.43371949f, -0.63270783f, -0.98340243f, 0.61411673f, 
    -0.46231163f, -0.06708913f, 0.32346776f, 0.07274511f, 0.25430083f, 0.24633798f, 0.25834903f, 0.04919310f, 
    -0.42755777f, -0.17977226f, -0.23199120f, 0.19378328f, -0.27388418f, -0.02175610f, 1.12939823f, 0.67481518f, 
    -0.08476269f, -0.93873191f, -1.40012205f, 0.73412591f, 0.10334211f, 0.23730735f, -0.26546329f, -0.10822719f, 
    0.18172777f, -0.12500168f, -0.23741992f, 0.27233830f, -0.07170491f, -0.31382960f, -0.12505224f, 0.07319088f, 
    0.11504531f, -0.05881729f, 0.27265590f, -0.04760155f, -0.29525676f, 0.16516869f, 0.07161559f, 0.39300543f, 
    -0.81742102f, -0.29719457f, 0.50184393f, 0.64819318f, 0.67633939f, 1.10721374f, -0.53993016f, -0.73988563f, 
    -0.38767552f, -0.18676417f, -0.20879188f, 0.12540926f, -0.34948522f, -0.09275465f, -0.02992884f, -0.28528318f, 
    0.03304927f, 0.12051464f, -0.25093696f, 0.28405964f, 0.17656876f, 0.02068979f, 0.15217058f, -0.19359596f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42086396f, 0.14226614f, 0.03260362f, 0.31480491f, 0.15199332f, -0.21556522f, 0.34250951f, -0.04721608f, 
    0.15430816f, 0.43477747f, 0.10980302f, 0.21872889f, 0.60289514f, 0.31700701f, 0.53962553f, 0.24220288f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01279476f, 0.27913141f, 0.18554541f, 0.36623141f, 0.32810575f, 0.23883264f, -0.02121115f, -0.08459049f, 
    -0.19801058f, 0.10298846f, 0.11129492f, 0.07581524f, 0.32533950f, 0.12945196f, 0.14063224f, 0.16357617f, 
    0.15414487f, 0.04793344f, 0.00615309f, 0.06124650f, -0.05893771f, 0.11953486f, 0.10158555f, 0.25614312f, 
    0.06354015f, -0.15852641f, 0.02066152f, 0.03506846f, -0.08925317f, 0.03565039f, 0.33151138f, 0.03632746f, 
    -0.07249932f, 0.24588217f, 0.19537069f, -0.14186364f, 0.11584106f, -0.13253768f, 0.39395311f, -0.03013930f, 
    -0.14826937f, -0.11825680f, 0.07786740f, 0.03972258f, 0.11536656f, 0.09581008f, 0.07602282f, 0.11864670f, 
    0.29472694f, 0.00679898f, 0.04383931f, -0.02070924f, -0.02846915f, -0.02790586f, 0.03452775f, 0.03558046f, 
    0.23273876f, 0.10404919f, -0.02199245f, 0.13348955f, -0.17886809f, 0.08602286f, -0.45168328f, 0.26825476f, 
    0.08816691f, 0.11519478f, 0.04008071f, -0.12318901f, -0.06711663f, 0.11198185f, -0.04087369f, 0.07623154f, 
    0.33410186f, 0.09904988f, -0.12262644f, -0.13450207f, -0.21837150f, -0.07793127f, -0.00467468f, 0.01519051f, 
    -0.25892696f, -0.00918721f, 0.10200614f, -0.07934662f, 0.00806840f, 0.13530940f, -0.17844699f, 0.19580825f, 
    -0.20258914f, 0.08552136f, 0.01331957f, 0.10318846f, -0.19054888f, -0.12109222f, -0.07655047f, -0.17810567f, 
    0.25369674f, 0.07546026f, 0.02910778f, -0.07529863f, 0.16680822f, 0.09059990f, 0.13023330f, 0.24591316f, 
    -0.02293357f, -0.19646686f, -0.05281023f, -0.20105331f, 0.10838848f, -0.11438645f, -0.22204444f, 0.52696395f, 
    0.05838013f, 0.11404110f, -0.11289258f, -0.15827374f, -0.10107639f, -0.08013865f, 0.03680052f, -0.10407566f, 
    -0.12544426f, 0.21392107f, -0.01284235f, -0.00425444f, -0.19701017f, 0.11145727f, -0.01084060f, -0.09373272f, 
    0.18958803f, 0.02993472f, 0.13966449f, 0.09097501f, -0.25880694f, 0.64211947f, -0.26282156f, 0.16332984f, 
    0.18201840f, -0.05674209f, 0.13278283f, 0.21378069f, -0.04573463f, 0.01632223f, 0.02368165f, -0.23458008f, 
    -0.21271701f, 0.15083325f, 0.13394032f, -0.22659685f, 0.33484450f, 0.15995108f, -0.14809465f, 0.06819880f, 
    -0.10858981f, -0.10524560f, -0.16760677f, -0.29552189f, 0.00051479f, -0.27533740f, 0.15577729f, 0.07718011f, 
    -0.06431320f, 0.19544798f, 0.10820543f, 0.06841886f, -0.04251168f, 0.03956391f, 0.13065358f, 0.09029017f, 
    -0.42694783f, -0.25055355f, 0.04291457f, 0.40309337f, -0.37853497f, 0.00089922f, -0.08310231f, 0.02893218f, 
    -0.01330319f, -0.05351734f, -0.10862757f, 0.03100905f, -0.20269486f, 0.63389665f, -0.57008731f, 0.09520106f, 
    0.02880026f, 0.09407522f, -0.03661009f, 0.05339737f, -0.09136356f, -0.12221073f, 0.09377993f, 0.07250328f, 
    -0.32028601f, 0.08488864f, 0.18139517f, 0.02984051f, -0.02078564f, 0.02961659f, 0.02636430f, 0.01183379f, 
    0.10168203f, 0.04389797f, 0.10811939f, -0.15965515f, -0.35299906f, 0.14617851f, -0.14213799f, 0.06408088f, 
    -0.03014303f, 0.06958124f, 0.01623777f, 0.00123987f, 0.08309862f, 0.06268379f, 0.12473504f, 0.22536701f, 
    0.07924978f, -0.14424451f, -0.19190654f, -0.03240281f, 0.11204486f, 0.23306270f, 0.06909946f, -0.06715956f, 
    -0.09523725f, -0.04873225f, -0.04888905f, -0.14156705f, 0.56574392f, -0.38888863f, -0.09930800f, 0.34984863f, 
    0.01299927f, 0.19286238f, 0.09172878f, 0.24159938f, 0.11826183f, 0.17524311f, 0.05288684f, -0.14694701f, 
    -0.03672357f, -0.12023114f, 0.05409474f, -0.24174626f, 0.02564558f, 0.01995989f, -0.03506372f, -0.11460865f, 
    0.40581599f, -0.23269086f, 0.22388552f, 0.15514761f, -0.19215770f, 0.11547597f, 0.19963214f, 0.10839945f, 
    -0.05014372f, 0.11673885f, 0.00852741f, -0.15332258f, -0.03900236f, 0.01042181f, 0.11073183f, 0.12791389f, 
    -0.15794212f, 0.07012576f, -0.12648068f, 0.10500060f, 0.31588006f, 0.44196144f, 0.17636412f, 0.04694502f, 
    0.04239238f, -0.22743917f, -0.14782275f, -0.09539432f, 0.21909599f, 0.10112339f, 0.29434446f, 0.08879991f, 
    0.09292460f, 0.16146228f, -0.16098732f, 0.26732752f, 0.02621543f, -0.05551752f, -0.17589544f, -0.07059476f, 
    0.21590318f, 0.33327359f, 0.30095416f, -0.02256552f, 0.25929397f, 0.06633570f, -0.04226991f, -0.09745984f, 
    0.20360330f, -0.04894830f, -0.18644533f, -0.15915020f, -0.09081911f, -0.24837561f, -0.08957192f, 0.07650404f, 
    -0.00915576f, -0.13926415f, -0.27477458f, 0.01480619f, -0.11260310f, -0.09607577f, -0.00046394f, 0.08649582f, 
    -0.26764077f, -0.19557555f, -0.04276145f, 0.05752449f, 0.19485186f, -0.01209888f, -0.09570358f, 0.01638660f, 
    0.06662585f, 0.06556948f, -0.22131927f, 0.11663012f, 0.27537236f, 0.04414442f, 0.43054596f, 0.25390062f, 
    0.24982284f, 0.14084752f, -0.02961832f, 0.10552367f, -0.13759182f, -0.07940576f, -0.13973995f, 0.08748440f, 
    -0.10864995f, -0.20628491f, 0.32249463f, -0.03489698f, 0.02439513f, 0.09969872f, -0.06639439f, -0.28168938f, 
    -0.20788604f, -0.07201757f, -0.29984602f, -0.14508249f, 0.25393519f, 0.27038443f, 0.26195866f, 0.20516373f, 
    0.09982637f, 0.21514851f, -0.02656081f, 0.04028134f, 0.00969466f, -0.19139449f, 0.04827218f, -0.13563994f, 
    0.12434284f, -0.09329709f, -0.36165950f, -0.06479690f, 0.14550371f, -0.01517478f, -0.12067963f, -0.00393049f, 
    0.04981465f, -0.05743276f, 0.07402598f, 0.09693348f, -0.17869912f, 0.44788784f, -0.43912420f, 0.08987236f, 
    0.16275746f, 0.08238342f, -0.19216530f, -0.00496580f, 0.01619836f, -0.08362024f, -0.06545284f, -0.22085422f, 
    -0.06148932f, 0.13153329f, 0.11076653f, 0.01522015f, -0.08746758f, -0.04196844f, -0.04653783f, 0.06628924f, 
    0.17181090f, 0.08771598f, -0.17404868f, 0.07962613f, -0.20781462f, -0.13890252f, -0.25199175f, 0.14392830f, 
    -0.17878987f, 0.08574336f, -0.04248135f, -0.05785084f, -0.17513317f, 0.08120900f, 0.08098310f, 0.21997154f, 
    0.02615702f, 0.02127296f, -0.09227002f, -0.03396726f, 0.18821371f, 0.03776291f, -0.07102107f, 0.02851462f, 
    -0.01784923f, 0.06307033f, -0.20121682f, -0.14207539f, 0.33094347f, -0.07489730f, -0.19939925f, 0.49326876f, 
    -0.35863709f, 0.11916474f, 0.19631892f, 0.12328022f, 0.07334779f, 0.10635418f, -0.08947408f, 0.00874017f, 
    -0.09822220f, 0.07832626f, -0.13095556f, -0.15999922f, 0.04638203f, -0.00140625f, 0.08563299f, 0.04483216f, 
    0.40644059f, -0.19559005f, 0.23380806f, 0.01856274f, -0.23629068f, -0.20816666f, -0.07797538f, 0.20569597f, 
    0.03091838f, 0.00230066f, -0.13382246f, -0.17164461f, -0.32129347f, -0.15424010f, 0.23729071f, 0.14392672f, 
    0.03658580f, 0.12347887f, -0.02771364f, 0.11229006f, -0.10579698f, 0.50583923f, 0.01669769f, -0.02332148f, 
    0.11670153f, -0.01801696f, 0.06739935f, -0.05404511f, -0.20944312f, -0.15135808f, 0.10612091f, 0.14719629f, 
    -0.10968357f, 0.15300487f, -0.47454783f, 0.27816060f, 0.06070259f, 0.03775746f, -0.02812837f, 0.12016199f, 
    0.07934631f, 0.11499710f, 0.24837703f, -0.02291576f, 0.04754304f, -0.09953400f, -0.04987424f, -0.19259907f, 
    -0.04376888f, -0.01040664f, 0.06981406f, 0.02830790f, 0.24986038f, 0.11785453f, -0.12531248f, 0.05341013f, 
    -0.02367532f, -0.02470972f, -0.00677916f, 0.07446521f, 0.00376187f, -0.24991304f, -0.03269900f, -0.17923780f, 
    -0.07895384f, -0.21992949f, -0.12533887f, 0.10063834f, 0.06840488f, 0.01686326f, 0.03359595f, 0.06563031f, 
    0.00703720f, 0.06839872f, -0.10568342f, 0.00814034f, -0.25786427f, 0.09310154f, 0.51450801f, 0.32242739f, 
    0.19056803f, 0.18453300f, -0.19660175f, 0.30444044f, -0.06006644f, 0.01657976f, 0.04442335f, 0.06739776f, 
    0.00423545f, -0.38355240f, 0.11457738f, -0.11874837f, -0.29953796f, -0.14739303f, -0.34796286f, 0.04758021f, 
    -0.13832493f, -0.03652145f, 0.11094104f, -0.13637698f, 0.03293073f, 0.01841452f, 0.23061830f, 0.45109394f, 
    0.26777983f, 0.21157737f, -0.02062478f, -0.16741529f, 0.11054263f, -0.05842132f, -0.08941083f, -0.06677758f, 
    0.08070933f, 0.35542428f, -0.04587913f, 0.46396184f, 0.12022087f, -0.09265535f, -0.05121408f, -0.16586716f, 
    0.10616574f, 0.03131920f, 0.09332883f, 0.01523523f, -0.16759692f, 0.39450085f, -0.09196880f, 0.16201316f, 
    0.20194958f, 0.09950069f, -0.13348028f, -0.04376198f, 0.09144403f, 0.03262714f, 0.06637457f, -0.06410480f, 
    0.56645179f, -0.33038807f, -0.59873503f, -0.07253563f, -0.15754385f, 0.18180801f, 0.03779051f, 0.01134043f, 
    0.02538495f, -0.01072454f, -0.05017781f, -0.00995837f, 0.33834174f, -0.15206748f, 0.12123496f, 0.10344543f, 
    0.10197140f, -0.14131549f, -0.01036223f, 0.02288499f, -0.03889013f, 0.21229993f, -0.19956845f, 0.00127381f, 
    -0.07910809f, 0.17483105f, 0.11258888f, -0.07908361f, -0.07521796f, -0.15562318f, -0.11138795f, -0.04177461f, 
    0.00567164f, 0.09593770f, 0.21495582f, 0.27460960f, -0.58941466f, 0.30177557f, 0.29322082f, -0.24150766f, 
    0.05048396f, -0.19221963f, -0.05802123f, 0.09626956f, -0.04620373f, 0.02750171f, -0.08309763f, -0.11471080f, 
    0.42226452f, 0.15508366f, 0.04213206f, 0.17901514f, -0.03584563f, -0.11067282f, -0.16414262f, -0.07366496f, 
    0.10725451f, 0.10803987f, -0.48456624f, -0.21518086f, -0.12777537f, -0.09913702f, 0.16956809f, 0.00214291f, 
    0.13756514f, -0.11785889f, 0.05556365f, 0.13504264f, 0.07709481f, -0.11994418f, -0.17117023f, -0.07722308f, 
    -0.10918397f, 0.11705222f, 0.16271676f, -0.03122689f, -0.20383145f, -0.29740447f, -0.14558235f, 0.15062331f, 
    0.00228068f, 0.12419032f, 0.08422375f, 0.06285537f, -0.35003060f, -0.04440107f, -0.14099541f, 0.29360378f, 
    -0.03623684f, 0.15575726f, 0.21895391f, -0.23078901f, 0.09471757f, 0.07852740f, 0.03805487f, 0.01494307f, 
    -0.11374923f, -0.30570573f, 0.15181573f, 0.50099552f, -0.07112212f, 0.07282622f, -0.04704336f, 0.15223454f, 
    -0.01247794f, 0.07159143f, 0.05319537f, 0.11005258f, 0.08957121f, 0.27246395f, -0.11748155f, -0.27799350f, 
    -0.05078559f, 0.09652615f, 0.13597339f, -0.01708310f, -0.03864071f, 0.19944212f, -0.03956400f, 0.14191167f, 
    -0.01214229f, 0.10494170f, -0.05951750f, -0.14477481f, -0.21335980f, -0.04238226f, -0.17589130f, -0.15839477f, 
    -0.03551507f, 0.07997849f, 0.01979546f, -0.17812164f, -0.48303446f, 0.36160055f, 0.16297427f, 0.25884077f, 
    -0.10012280f, 0.08452877f, 0.15206701f, 0.06341761f, 0.05060387f, 0.12779051f, 0.05456996f, -0.14955868f, 
    0.06020214f, -0.16429208f, -0.35477859f, 0.04063328f, -0.20620207f, 0.03030783f, 0.18899916f, 0.30834961f, 
    0.17871684f, 0.03281044f, 0.27572200f, -0.06066860f, -0.34922266f, -0.04197326f, 0.06798864f, 0.44303656f, 
    0.16494200f, -0.07078543f, -0.00300222f, 0.02479258f, -0.01298973f, -0.14313282f, -0.22695635f, 0.03604902f, 
    -0.10908540f, 0.68004757f, 0.37964687f, 0.42202246f, -0.03298153f, -0.05869649f, 0.12468541f, 0.05291909f, 
    0.06578803f, 0.06289786f, -0.02147612f, 0.04732450f, 0.37090665f, 0.05600481f, 0.40323076f, -0.02263476f, 
    -0.06251265f, 0.00739639f, 0.11609331f, 0.00376760f, 0.02813290f, -0.09068602f, -0.02070639f, -0.02509679f, 
    -0.33401728f, -0.09133921f, -0.44101289f, -0.27302918f, -0.11778740f, 0.06425077f, 0.11153442f, 0.11388689f, 
    0.10432732f, 0.00549117f, 0.15986271f, 0.05278071f, 0.10147357f, 0.11378879f, 0.21555115f, -0.20738213f, 
    0.02151714f, -0.07206446f, 0.03187487f, 0.17546809f, 0.07683799f, -0.07788788f, -0.08257294f, 0.07757922f, 
    -0.02685864f, 0.22901991f, 0.08098786f, -0.03192365f, -0.07213632f, -0.04579723f, -0.04645102f, -0.06678062f, 
    -0.08412299f, -0.19979078f, -0.05214607f, -0.03267347f, -0.01387260f, -0.12596714f, 0.62286079f, -0.11062878f, 
    0.20520991f, -0.12842987f, 0.08449392f, 0.10909291f, -0.11368324f, -0.22143984f, 0.13802402f, -0.09387517f, 
    0.23841064f, -0.25996590f, -0.07242170f, 0.01451223f, -0.02711882f, 0.06661852f, -0.01058422f, -0.03806904f, 
    0.12215746f, 0.01864517f, -0.05077059f, 0.14118807f, 0.37146878f, 0.17029579f, 0.35825059f, 0.01188877f, 
    0.01488630f, -0.09221697f, 0.00367773f, -0.00974120f, 0.02463070f, -0.02058858f, -0.02395791f, 0.13592133f, 
    -0.04520825f, 0.15911700f, -0.01587410f, -0.02257720f, 0.06662025f, -0.15508309f, -0.05624954f, -0.12495933f, 
    -0.01445842f, -0.00559914f, -0.00205498f, -0.03591251f, 0.07038539f, 0.32484949f, 0.05427867f, -0.14808650f, 
    0.12454290f, 0.03341987f, 0.29685783f, 0.04474856f, -0.01709266f, -0.15490322f, -0.11060447f, -0.11067411f, 
    0.08460548f, -0.19720042f, -0.23390850f, 0.03471917f, 0.25228906f, 0.26598656f, -0.06814189f, 0.03300044f, 
    -0.10026072f, 0.00274398f, -0.13280845f, 0.03802865f, -0.15039118f, -0.09527799f, -0.04913365f, 0.07776970f, 
    -0.04160436f, 0.14186382f, -0.03122207f, 0.07079658f, -0.13253304f, 0.10476546f, 0.10153438f, 0.05208761f, 
    0.20485885f, 0.54530996f, 0.27609074f, 0.10202530f, -0.12947963f, -0.16269004f, -0.15578036f, 0.06234474f, 
    -0.13282901f, -0.18558067f, 0.09873942f, -0.07755575f, 0.31932244f, 0.30091783f, 0.06918473f, -0.16746505f, 
    -0.04885159f, 0.02919455f, 0.18798232f, -0.03654760f, -0.06877714f, -0.04421822f, 0.06366707f, -0.14226663f, 
    0.03530256f, 0.12645453f, -0.01891230f, 0.03867861f, 0.19027568f, 0.23431881f, 0.20856203f, -0.11519856f, 
    0.08363546f, 0.17042808f, 0.05141588f, -0.02624912f, -0.22353274f, 0.02154076f, -0.02581855f, -0.20563476f, 
    0.04912803f, 0.00307403f, 0.05638351f, -0.25392461f, 0.03475565f, -0.04342440f, 0.07447448f, 0.16546008f, 
    0.31625921f, 0.02438126f, 0.07087489f, -0.22885697f, 0.02548467f, 0.12469873f, -0.07432874f, 0.27060816f, 
    0.05088452f, 0.12591171f, 0.10356919f, 0.06749598f, 0.33761814f, 0.27185911f, -0.41942516f, 0.18178311f, 
    -0.25040838f, -0.19870962f, 0.19325754f, 0.04222911f, -0.03221224f, 0.05570998f, 0.03492260f, -0.15143880f, 
    -0.06318921f, 0.04962335f, -0.02521949f, -0.07796218f, 0.02526276f, -0.01376520f, 0.01959177f, -0.05163615f, 
    0.01571762f, -0.07231351f, -0.04128071f, 0.04133288f, 0.00760429f, -0.04471838f, 0.01772934f, 0.06404473f, 
    0.03430580f, -0.04219890f, -0.01297586f, 0.04174429f, -0.03952540f, -0.01009850f, -0.07811039f, -0.05203442f, 
    -0.02284867f, -0.04672788f, 0.03285882f, 0.05091295f, -0.06295032f, -0.08142409f, -0.04151589f, -0.01554168f, 
    -0.04270884f, 0.05532303f, -0.02451548f, 0.02138625f, -0.04973384f, 0.04429957f, -0.07051677f, -0.00957269f, 
    -0.02405334f, 0.00256396f, -0.03893284f, 0.03029248f, -0.00983331f, 0.02391311f, 0.02129080f, -0.05359012f, 
    -0.04993203f, -0.03765877f, 0.01949896f, -0.06311364f, 0.04417840f, -0.01469081f, 0.01236618f, 0.01931837f, 
    0.04788028f, 0.03713343f, -0.02175707f, 0.04912017f, 0.00085031f, -0.02686239f, -0.06890539f, -0.03609449f, 
    0.05713257f, 0.03869621f, -0.04415774f, 0.01688756f, 0.00627048f, 0.03690416f, -0.04416555f, 0.04725976f, 
    0.03133857f, 0.04085244f, -0.01767607f, -0.04043134f, 0.00376561f, -0.00050987f, 0.06123970f, -0.05474830f, 
    -0.00010723f, -0.01690125f, -0.06443355f, -0.04127562f, 0.03382450f, -0.05215506f, -0.06889746f, -0.04011636f, 
    -0.06503113f, 0.00567750f, -0.05204603f, -0.06904337f, -0.03615548f, -0.07059613f, 0.03985463f, -0.07589697f, 
    0.00103366f, 0.06490535f, -0.06778534f, -0.06136446f, -0.02942911f, -0.06997938f, -0.01378127f, -0.02420023f, 
    -0.02507436f, -0.03367917f, 0.02236143f, -0.03012361f, 0.05394990f, 0.02209021f, -0.02190740f, 0.00108232f, 
    -0.06941421f, 0.03638409f, 0.03158318f, -0.03242865f, -0.03280645f, -0.00649299f, -0.01029652f, 0.02239650f, 
    0.05540557f, 0.07004415f, 0.04368846f, 0.01750938f, -0.01601967f, -0.04456841f, 0.04391774f, -0.03245530f, 
    -0.00876725f, -0.06919838f, -0.01528224f, -0.04978267f, 0.04373557f, 0.05463461f, -0.01346257f, -0.02376008f, 
    -0.00885885f, -0.00856641f, 0.01720792f, -0.05614820f, 0.00217475f, -0.07191662f, -0.02625688f, 0.01961344f, 
    0.02634565f, 0.03001668f, -0.05533281f, -0.04296087f, -0.00747549f, 0.03953371f, 0.02153503f, 0.06519488f, 
    0.05921558f, -0.04742568f, -0.02922316f, -0.00114718f, -0.01744977f, -0.02197413f, 0.01498610f, 0.06191669f, 
    -0.06574617f, 0.00576785f, -0.02994908f, 0.03147700f, -0.05049629f, 0.03716094f, 0.01906927f, -0.03341571f, 
    -0.03298907f, 0.00228672f, 0.01466950f, 0.00766581f, 0.00686996f, 0.03993694f, -0.02565388f, -0.06905752f, 
    -0.05725231f, 0.03563958f, -0.07369314f, -0.06423368f, 0.05763106f, -0.06384978f, -0.06544589f, 0.05574786f, 
    0.04645533f, 0.04049211f, 0.05643320f, -0.00327907f, 0.04968966f, 0.01799182f, 0.03996083f, -0.02695029f, 
    0.00260900f, 0.25488681f, 0.01469511f, -0.11768419f, -0.03446352f, 0.21702994f, 0.14459985f, 0.10958269f, 
    0.12667967f, 0.32648221f, -0.11964418f, -0.07240012f, 0.44331113f, -0.05724615f, 0.09688526f, -0.20025326f, 
    0.06869527f, 0.24147892f, 0.13105115f, -0.08991717f, -0.05998879f, -0.02684174f, -0.11734269f, -0.24521330f, 
    0.01713900f, -0.01386235f, -0.06408354f, 0.03469665f, -0.15932907f, -0.09345411f, -0.14206174f, -0.04992324f, 
    -0.06758077f, -0.08596916f, -0.08685599f, 0.13620774f, -0.39204562f, 0.26517743f, 0.00543832f, -0.47507584f, 
    0.00968544f, 0.13231966f, 0.03039576f, -0.15385057f, -0.09510090f, -0.10207611f, -0.09662075f, -0.03340649f, 
    0.12283497f, 0.19829236f, 0.21366663f, 0.07616678f, -0.10184279f, -0.12146813f, -0.09058794f, -0.07303899f, 
    -0.16757946f, 0.21892691f, 0.03635415f, 0.03588461f, 0.51941520f, 0.03477195f, -0.26522306f, -0.08964717f, 
    0.12485185f, 0.00049716f, 0.13465384f, 0.23017626f, 0.04757614f, -0.05000391f, -0.12193261f, -0.12212624f, 
    -0.16122343f, -0.11566055f, 0.01528518f, 0.02404865f, -0.06669427f, -0.08423384f, -0.01696485f, 0.07609715f, 
    -0.11099744f, 0.08245956f, 0.02112742f, 0.00781965f, 0.02731137f, 0.20936418f, -0.14926794f, 0.10495282f, 
    0.20516810f, -0.04690870f, 0.10285538f, -0.27510670f, -0.04199211f, 0.06261466f, -0.04984242f, 0.06608378f, 
    0.00164598f, -0.06210573f, -0.20827457f, 0.13573393f, 0.03560252f, 0.02330729f, -0.04487547f, -0.02590746f, 
    -0.02584399f, -0.01221067f, -0.03814114f, 0.10357914f, -0.29605898f, 0.39969927f, -0.04723918f, -0.35747030f, 
    -0.21182790f, 0.12524614f, 0.10846802f, -0.04106491f, 0.01666915f, 0.32295239f, 0.03567804f, 0.19260874f, 
    -0.17745037f, 0.21695162f, -0.28794405f, 0.04228968f, -0.06105207f, -0.01122732f, 0.03615776f, 0.01233029f, 
    -0.09571325f, -0.02538396f, -0.01301299f, -0.07000829f, -0.26776579f, 0.21497411f, 0.05520717f, 0.10906056f, 
    -0.07327703f, 0.24244390f, -0.03225303f, -0.05889491f, 0.04564586f, 0.03485870f, -0.07366579f, 0.10039568f, 
    0.17556334f, -0.02818239f, 0.07261477f, 0.21111743f, -0.16657296f, -0.09942891f, 0.21012963f, 0.11044087f, 
    0.09607244f, 0.04968431f, 0.08855090f, 0.15535574f, -0.00365753f, -0.13133873f, -0.27562484f, -0.26284397f, 
    0.24126430f, 0.02587498f, 0.12301661f, -0.00679610f, 0.02428547f, 0.10518403f, -0.10514084f, 0.09966397f, 
    0.67391902f, -0.27669346f, 0.09075467f, 0.40869370f, 0.10577996f, -0.13909346f, 0.19132316f, -0.19175884f, 
    -0.12794900f, 0.08387450f, 0.10725814f, -0.08277588f, 0.22282317f, -0.46894062f, 0.35922638f, 0.28733239f, 
    -0.11586390f, -0.16242623f, -0.02030048f, -0.01225742f, -0.00367611f, 0.13112807f, -0.02511492f, 0.15179750f, 
    -0.02376703f, -0.06021548f, -0.03568961f, -0.04743987f, 0.01184783f, -0.02301957f, 0.03028743f, -0.07922841f, 
    0.00506925f, 0.01055447f, -0.02810718f, 0.04441956f, 0.02252394f, -0.02705738f, 0.04838195f, -0.00379263f, 
    0.00726064f, 0.00619682f, -0.06929234f, 0.05063247f, -0.06844936f, 0.01796241f, -0.05372262f, 0.00286913f, 
    -0.03620260f, -0.05889350f, -0.05151864f, -0.04589275f, -0.07127634f, 0.00644630f, 0.04764965f, 0.07081682f, 
    -0.06277516f, 0.02586250f, -0.02334261f, -0.05180031f, -0.04489984f, 0.01110754f, 0.02137444f, 0.05526939f, 
    -0.04546374f, -0.02560383f, -0.05196353f, 0.00082310f, 0.05683098f, -0.04837965f, -0.00133049f, 0.00803358f, 
    -0.02629774f, -0.03778595f, -0.01059233f, 0.04397146f, -0.04125799f, 0.03631889f, 0.05663204f, 0.01333379f, 
    -0.07771572f, -0.06436298f, 0.04786014f, -0.04277790f, 0.05445780f, -0.02836131f, -0.01362388f, 0.00389908f, 
    0.05967276f, 0.03247138f, -0.01644922f, -0.04158239f, -0.00994776f, 0.01643243f, -0.05085300f, 0.04440580f, 
    -0.00885578f, -0.04848519f, -0.05968779f, -0.03657129f, -0.06960002f, -0.01292465f, 0.02909604f, -0.05287070f, 
    -0.00848899f, 0.04167646f, -0.07721511f, 0.04930658f, -0.00098585f, -0.03081486f, -0.06557272f, -0.01838163f, 
    0.01871419f, -0.07587636f, -0.07038408f, 0.04153690f, -0.06012844f, 0.04158669f, -0.04756390f, -0.02317043f, 
    0.01443887f, 0.05394932f, -0.03004339f, -0.06212995f, -0.05306792f, -0.02964803f, -0.04434177f, 0.03409967f, 
    -0.05272815f, -0.02281011f, -0.00528064f, -0.02975031f, -0.03958391f, 0.06693804f, 0.06341943f, 0.02743645f, 
    -0.00512519f, 0.04628719f, 0.04707583f, -0.00053101f, -0.03788351f, 0.01244095f, -0.06604273f, 0.05642153f, 
    -0.05261855f, -0.04146777f, -0.04750025f, -0.02841048f, -0.00064753f, 0.01760166f, 0.05334440f, -0.02827333f, 
    -0.05661884f, -0.01913839f, 0.03588807f, 0.00205407f, -0.00319429f, -0.04566760f, -0.01349141f, 0.04573392f, 
    -0.06114876f, -0.07410210f, 0.01435407f, 0.02741032f, -0.00808517f, -0.06717433f, -0.06183146f, -0.07448020f, 
    -0.05347464f, 0.03085966f, -0.07846749f, 0.03147413f, -0.00462939f, -0.00100525f, -0.00292809f, 0.05221308f, 
    -0.00338079f, 0.03803618f, 0.05920495f, 0.02233570f, 0.05987991f, -0.00946320f, -0.00135067f, 0.03329890f, 
    0.03561971f, -0.05367589f, -0.04358970f, -0.06744769f, 0.01437065f, -0.06073246f, 0.00239871f, 0.05680423f, 
    -0.02608370f, -0.00256046f, -0.08176962f, -0.06402060f, -0.02466593f, 0.00863912f, -0.03265697f, -0.06308982f, 
    0.00431774f, -0.03787300f, -0.03347913f, 0.00141034f, 0.04560235f, -0.04903042f, -0.02935683f, 0.04611903f, 
    0.02039614f, 0.02140017f, 0.05702657f, -0.00784502f, -0.01311872f, 0.01765513f, -0.05142039f, -0.00229353f, 
    -0.05902006f, 0.02946522f, 0.05743774f, -0.07720374f, -0.05534587f, -0.01816859f, -0.04508139f, -0.03864150f, 
    0.00869002f, 0.01460171f, -0.00003433f, 0.00959460f, -0.02928426f, 0.05295783f, -0.04453366f, -0.01205508f, 
    -0.03184594f, -0.02456697f, 0.01989099f, -0.05674737f, -0.01636240f, 0.05395111f, 0.04468685f, -0.02260906f, 
    -0.00213792f, 0.01763443f, -0.00615231f, 0.02715932f, 0.01060512f, -0.06055087f, -0.07148331f, 0.00543366f, 
    -0.05204138f, -0.02316854f, 0.06185194f, -0.05714820f, -0.01969034f, 0.00785921f, -0.03144284f, -0.00314116f, 
    0.01803211f, 0.01541225f, 0.02988568f, -0.06823015f, -0.08197882f, 0.05442780f, 0.01408979f, -0.07326590f, 
    -0.05200512f, -0.03559542f, -0.03462800f, -0.03445430f, 0.05430399f, 0.04496316f, -0.03840590f, -0.00994240f, 
    0.03813295f, -0.02194526f, -0.03730775f, -0.01299606f, -0.04793108f, 0.04728417f, 0.02123259f, 0.00367478f, 
    -0.04592241f, -0.03738277f, -0.08616105f, -0.06890611f, -0.03969731f, -0.00946020f, 0.02187116f, -0.06634784f, 
    0.02274459f, -0.01546114f, 0.05832940f, -0.06408069f, -0.00781695f, -0.04669312f, -0.03482059f, -0.05696515f, 
    0.03313348f, -0.04698606f, -0.01602030f, 0.04432036f, -0.01195450f, -0.05766302f, 0.03458356f, -0.06578278f, 
    -0.05977459f, 0.00788240f, 0.01260393f, -0.01768442f, 0.02241072f, -0.05674409f, -0.01952120f, -0.04882362f, 
    0.03524568f, -0.00809161f, 0.03453158f, 0.04912477f, -0.07737940f, 0.04378731f, -0.08347911f, -0.05502103f, 
    0.01885306f, 0.00667968f, -0.08314890f, -0.00086472f, -0.05983361f, -0.05921607f, -0.07133155f, -0.00039745f, 
    -0.02572581f, 0.05528301f, 0.03688052f, -0.01773637f, -0.03898683f, -0.01972002f, 0.00209557f, 0.01722280f, 
    0.06108851f, 0.04009006f, -0.07360034f, -0.00406256f, -0.02514271f, -0.00311520f, -0.04629048f, 0.00378296f, 
    0.02667443f, 0.02654427f, -0.05880075f, 0.03886603f, 0.02166455f, -0.08660972f, 0.05225502f, -0.01714217f, 
    -0.03230254f, -0.01484753f, -0.05049520f, -0.06279299f, -0.02611380f, 0.06126766f, -0.02254348f, -0.02946107f, 
    0.01397915f, -0.05635001f, -0.04197406f, -0.03399545f, 0.01260575f, -0.05477559f, 0.01474153f, -0.01441660f, 
    0.03998681f, -0.01586270f, -0.05282197f, -0.03010692f, 0.05722284f, 0.02735164f, -0.08299991f, 0.02875654f, 
    -0.07657716f, -0.00672638f, 0.05428234f, -0.01465968f, 0.00637908f, 0.02799591f, 0.02666870f, 0.03731345f, 
    -0.01207592f, 0.02007316f, 0.04292331f, -0.04048204f, -0.05221051f, -0.06691549f, 0.03540511f, 0.02138989f, 
    -0.03347652f, -0.03131036f, -0.05397788f, -0.03209162f, -0.04763906f, -0.00722598f, -0.04859995f, -0.00538186f, 
    0.03300878f, 0.05700451f, -0.04527198f, 0.03232670f, -0.05494279f, 0.04755230f, -0.03425948f, 0.04544348f, 
    -0.10486557f, -0.43229327f, -0.25552547f, -0.56050760f, -0.19799778f, -0.11549527f, -0.13264832f, -0.04757794f, 
    0.07961660f, 0.13742974f, 0.16639556f, 0.06056257f, -0.38718978f, -0.18321674f, -0.78581655f, -0.41909632f, 
    -0.00786502f, -0.03662273f, -0.13521114f, -0.02873680f, 0.06473327f, 0.03822815f, 0.17341435f, 0.13406587f, 
    0.29396167f, 0.16333242f, 0.05556525f, 0.01724162f, 0.02959893f, -0.05099394f, -0.05139034f, -0.11062831f, 
    -0.08997300f, -0.15286478f, -0.19110148f, -0.12292092f, 0.34534627f, -0.19852504f, -0.19433823f, 0.24411364f, 
    0.18411329f, 0.19671711f, 0.18423717f, 0.10094088f, 0.05802200f, -0.02043630f, 0.06544760f, 0.10935215f, 
    0.12578610f, 0.20777830f, 0.14217037f, 0.31857893f, -0.06570779f, -0.04347698f, 0.08901044f, -0.00261302f, 
    -0.08440170f, 0.17567892f, 0.07427739f, 0.09786586f, 0.04521282f, -0.01669854f, -0.21312122f, -0.06847931f, 
    -0.03652679f, 0.11222313f, 0.00955216f, 0.04723815f, -0.03711209f, -0.02747341f, 0.24884620f, -0.00867426f, 
    0.18064648f, -0.08183649f, 0.00614253f, 0.05666083f, 0.09521259f, 0.18968211f, -0.01903436f, -0.11099773f, 
    -0.19699669f, -0.13973328f, -0.12128577f, -0.02593924f, -0.14746475f, -0.14168282f, -0.09019371f, -0.14763208f, 
    0.24878910f, 0.06298868f, -0.04420980f, -0.21233523f, -0.05189452f, -0.06856972f, -0.06512561f, 0.01551932f, 
    -0.12582964f, -0.05014200f, 0.14730850f, -0.02621805f, -0.02347289f, 0.00892379f, 0.12850606f, -0.14505641f, 
    -0.03316071f, 0.03735110f, 0.00524211f, -0.06354456f, 0.25446549f, 0.14588238f, 0.37086111f, 0.12333649f, 
    -0.03805018f, -0.08898366f, -0.03467053f, -0.13462086f, 0.01910039f, 0.04170172f, 0.02793548f, 0.03787719f, 
    0.43926898f, 0.14598484f, 0.16218111f, 0.17642318f, 0.08327617f, 0.07103261f, 0.00664843f, -0.03286885f, 
    -0.02145304f, -0.01035244f, 0.00926856f, -0.09203576f, -0.29953015f, -0.34498328f, 0.08989029f, 0.03063661f, 
    0.21152793f, 0.21466006f, 0.05874035f, -0.05071483f, -0.10125417f, -0.06042330f, -0.01326800f, 0.04747391f, 
    -0.29947704f, -0.09245987f, 0.08127149f, -0.12146521f, 0.14164840f, 0.13048388f, -0.24447343f, -0.04945675f, 
    -0.06349267f, -0.08098073f, -0.15564755f, 0.02480819f, 0.61012107f, -0.17522040f, -0.25823042f, 0.14083084f, 
    0.02604882f, 0.28105143f, 0.07625651f, 0.23781049f, -0.01071810f, 0.02506064f, -0.00894680f, -0.00267323f, 
    0.85292572f, -0.22837877f, -0.15676416f, 0.04345780f, -0.13639368f, 0.07253844f, 0.30870232f, 0.02617440f, 
    0.09329156f, 0.10871826f, 0.11959499f, 0.00594922f, 0.11017365f, -0.04399438f, 0.35185716f, 0.45225143f, 
    0.03141626f, 0.15712129f, 0.01768092f, -0.14990248f, -0.07667307f, 0.02898985f, -0.01889576f, -0.07591180f, 
    0.46931797f, -0.09474602f, -0.10182904f, 0.02211643f, 0.10168017f, 0.07785823f, -0.22360349f, -0.04183523f, 
    0.02557946f, -0.11219774f, 0.11872905f, -0.05634866f, 0.07401729f, 0.26764750f, -0.07437842f, 0.01586577f, 
    0.11247403f, 0.12997636f, -0.11251937f, 0.22856703f, -0.00724600f, -0.16364557f, -0.11256114f, -0.22890589f, 
    -0.14897256f, -0.14817892f, -0.10053514f, 0.27415708f, 0.11421403f, -0.00488507f, -0.05627745f, -0.01288495f, 
    0.16495149f, 0.07927265f, 0.29559979f, 0.23195770f, -0.66642183f, 0.54242301f, -0.37782234f, 0.17172030f, 
    0.14786609f, 0.32366532f, -0.03705020f, -0.05524386f, -0.10136540f, -0.11803972f, -0.15842822f, -0.11813600f, 
    -0.11584729f, 0.04820117f, -0.04337162f, 0.25642395f, -0.09538160f, -0.10063627f, -0.06347866f, 0.07537422f, 
    0.15234202f, -0.12563522f, -0.02135114f, -0.01987053f, 0.48358497f, 0.23914291f, -0.27487290f, -0.31381080f, 
    0.07039072f, 0.03874967f, 0.14443508f, 0.09988686f, 0.02856185f, -0.14067389f, 0.04450817f, -0.26443937f, 
    -0.09487529f, -0.23776650f, -0.12604612f, 0.06874669f, 0.19113554f, 0.00824844f, 0.16784181f, -0.04444388f, 
    0.11534177f, 0.14504099f, 0.04733868f, -0.05289033f, 0.03515865f, 0.13527016f, -0.17920971f, -0.18420392f, 
    0.06768761f, 0.10107693f, 0.29572001f, 0.02315561f, 0.04923273f, 0.13845856f, -0.06885809f, 0.04657571f, 
    0.26670039f, 0.46731043f, -0.01984779f, -0.34625983f, 0.01770041f, 0.20095028f, 0.22273619f, 0.23691490f, 
    0.13368255f, 0.17684545f, 0.17995705f, 0.04733946f, 0.04853141f, 0.04283084f, 0.20213030f, 0.10533818f, 
    -0.07259631f, 0.12045696f, -0.01346813f, -0.18162271f, 0.07304867f, -0.04758628f, 0.04991886f, 0.12930763f, 
    -0.25863978f, -0.06320136f, 0.10829158f, 0.21384174f, -0.00163600f, -0.11182130f, 0.02037821f, -0.21086030f, 
    -0.10011905f, 0.00146108f, -0.12354513f, -0.00485735f, 0.38528836f, -0.02617869f, 0.38354281f, -0.43807459f, 
    0.11032709f, 0.21573733f, -0.06691059f, 0.12340215f, 0.08901287f, -0.06573270f, -0.00296471f, -0.16573521f, 
    0.23366730f, -0.02676206f, 0.12662838f, -0.17433597f, 0.00366616f, 0.05660485f, 0.07991358f, 0.23944084f, 
    0.00947595f, -0.03624951f, 0.23523362f, 0.16102374f, 0.30156648f, 0.33672079f, -0.10485195f, -0.05870864f, 
    0.15777805f, -0.14484139f, -0.06228629f, 0.54924989f, -0.15819222f, 0.20269096f, 0.09165214f, -0.01498803f, 
    -0.64180374f, -0.35016784f, -0.38238499f, 0.10626296f, -0.06379237f, 0.23687501f, -0.01752913f, -0.01757289f, 
    -0.03270163f, 0.05621128f, -0.22364840f, 0.09508359f, 0.07909866f, -0.20562904f, 0.38460481f, -0.08667670f, 
    -0.12924188f, -0.09716886f, -0.02954652f, -0.08546390f, -0.11977217f, -0.00081237f, -0.20318477f, 0.15410025f, 
    -0.24111947f, -0.14667095f, -0.05806628f, 0.05067757f, 0.11514113f, -0.00512908f, -0.07531554f, 0.30061179f, 
    0.00511423f, -0.08381935f, 0.06959862f, -0.13669316f, -0.04694498f, 0.21494578f, -0.08337849f, 0.01822710f, 
    0.02329648f, -0.06450788f, 0.02600412f, 0.37258375f, 0.10668543f, -0.01920663f, -0.09794515f, -0.14984423f, 
    -0.34791917f, -0.07797423f, -0.09434462f, -0.07572946f, -0.16075534f, -0.28351727f, -0.27271816f, -0.10413245f, 
    0.09258506f, 0.03744733f, 0.07741725f, 0.06519036f, -0.17365481f, 0.03632800f, -0.12740195f, 0.18139732f, 
    -0.05896290f, 0.12950768f, 0.18500899f, 0.14153683f, -0.04637787f, 0.05706765f, -0.02318596f, -0.25117114f, 
    0.02104053f, 0.17221773f, -0.15960522f, -0.05412180f, -0.00682509f, -0.00202986f, -0.07020405f, 0.05513660f, 
    0.07025403f, -0.26150325f, 0.00823498f, -0.03896821f, -0.45160562f, 0.02739869f, -0.00388337f, -0.14063586f, 
    0.01480153f, 0.04231429f, 0.07188229f, 0.00701375f, -0.04965582f, -0.09966596f, -0.10315473f, -0.00231449f, 
    -0.57019818f, -0.01984241f, 0.11988482f, 0.00632098f, 0.08923463f, -0.07369722f, 0.07922892f, -0.20352715f, 
    0.00033452f, -0.06326823f, -0.01201140f, 0.14568219f, -0.10117202f, 0.12636138f, -0.22014230f, 0.14879708f, 
    0.09677255f, 0.18626209f, 0.18682340f, -0.03064286f, 0.05727881f, 0.01128475f, 0.06205700f, 0.16316147f, 
    0.00464768f, -0.06904335f, -0.04164125f, -0.22801068f, 0.13564305f, 0.13674884f, -0.03833220f, 0.01261983f, 
    0.07135147f, 0.09763008f, 0.08864464f, 0.05693833f, 0.11058010f, 0.04332942f, 0.03662223f, -0.21459779f, 
    -0.09665971f, -0.07852861f, -0.03593665f, -0.19158737f, 0.01890059f, 0.17953828f, 0.23207383f, 0.26747552f, 
    -0.20807101f, 0.18183252f, 0.11286525f, -0.21080936f, -0.06164420f, -0.00363904f, -0.03107930f, -0.07233769f, 
    -0.17962138f, 0.03525326f, -0.06963108f, -0.01636261f, 0.30526099f, 0.18285425f, 0.02883956f, 0.20933028f, 
    0.05455819f, 0.17444554f, -0.16359168f, 0.07323904f, 0.00962242f, 0.01997253f, 0.16369781f, 0.01032545f, 
    0.29226246f, 0.12305840f, 0.05305552f, 0.10790166f, 0.25546396f, 0.23238549f, -0.01023941f, 0.16882306f, 
    -0.01279308f, 0.05817122f, 0.24458574f, 0.21781763f, -0.28379562f, -0.22609243f, -0.18053558f, 0.29183263f, 
    0.12054837f, 0.24181400f, -0.01548827f, 0.09199499f, -0.12792991f, -0.09728120f, 0.04853649f, 0.05287324f, 
    -0.51724464f, 0.48987603f, 0.07492127f, 0.62347621f, 0.15384755f, -0.03972372f, -0.17026915f, 0.14932613f, 
    0.27030075f, 0.10171646f, -0.07931861f, 0.01513705f, -0.08522101f, 0.99372423f, 0.01368990f, -0.05356047f, 
    -0.05446574f, -0.23163040f, -0.11570648f, 0.06401658f, 0.04186306f, 0.08352798f, 0.01401366f, -0.06146028f, 
    0.60204637f, 0.03203281f, 0.39530379f, 0.08452965f, -0.26824972f, -0.13815390f, -0.13846257f, 0.12151054f, 
    0.19076891f, -0.09702612f, 0.02396670f, 0.16739529f, -0.03844008f, -0.10950865f, 0.16809754f, 0.07247607f, 
    0.35452837f, -0.03466244f, -0.18626626f, 0.05748098f, 0.03042733f, 0.00922325f, -0.04366554f, 0.06412875f, 
    -0.19062962f, -0.17012255f, -0.00534118f, 0.16639549f, -0.11139169f, -0.06543022f, -0.20167293f, 0.02013734f, 
    0.04269252f, -0.14869599f, -0.14625672f, 0.06334941f, -0.61683798f, 0.31349114f, -0.47958854f, -0.13314623f, 
    -0.05472881f, 0.33093032f, 0.09689718f, 0.02881771f, 0.25288361f, -0.08297442f, 0.07233963f, 0.14168353f, 
    0.25815257f, 0.20395808f, 0.04590102f, 0.38295245f, -0.19739458f, -0.41494489f, 0.03429846f, 0.08613269f, 
    0.38275087f, 0.11184181f, -0.03719876f, 0.16910800f, 0.39711305f, -0.02806430f, 0.12725121f, -0.26464102f, 
    0.21334708f, -0.05147029f, -0.04455738f, 0.31010586f, 0.17258143f, 0.03166381f, 0.09937151f, 0.10340802f, 
    -0.02284357f, -0.21626294f, -0.20235543f, 0.02453334f, 0.27216363f, 0.00710492f, 0.27140072f, 0.22585939f, 
    0.13878520f, -0.08185320f, -0.09623673f, -0.22484808f, -0.22614865f, -0.17106445f, 0.11162211f, -0.32326081f, 
    0.13555884f, -0.16769373f, 0.31437594f, 0.11406066f, -0.08827317f, 0.05840961f, -0.22267680f, -0.10322352f, 
    -0.02524680f, 0.31821144f, 0.09473563f, 0.05081924f, 0.14616530f, 0.16609272f, 0.04321740f, 0.06635129f, 
    0.01329375f, 0.03238388f, 0.08664727f, 0.03574783f, 0.15830819f, 0.11084954f, 0.10731411f, -0.23428681f, 
    -0.37175110f, -0.00818615f, 0.19140860f, -0.22213690f, -0.00877340f, -0.02605833f, -0.03332715f, -0.10954580f, 
    -0.21573499f, -0.46264243f, 0.17268671f, 0.19825496f, 0.11718556f, -0.02985623f, 0.04856469f, -0.09413866f, 
    0.21572773f, -0.10395511f, -0.21856648f, -0.01663450f, -0.27665791f, -0.31241697f, 0.12343372f, -0.29001591f, 
    0.13488087f, 0.13999142f, -0.02246662f, 0.25058267f, -0.11081654f, -0.23623815f, -0.13300659f, -0.01960004f, 
    -0.06327122f, 0.22363536f, -0.25438142f, -0.03463274f, -0.17803439f, 0.02994261f, 0.05306711f, 0.04448214f, 
    0.08550812f, 0.08441321f, -0.06623340f, -0.01891351f, -0.02489183f, 0.24506027f, -0.18330278f, -0.26616392f, 
    0.19962673f, 0.11597822f, 0.16856232f, 0.16966923f, 0.07695010f, 0.14150362f, 0.08447552f, 0.05584679f, 
    0.55792058f, 0.33690146f, -0.37974373f, -0.50207490f, -0.16821893f, -0.07319733f, 0.05284988f, -0.07879668f, 
    0.09298252f, 0.06356052f, 0.03130366f, 0.04393790f, 0.55968773f, -0.39547050f, 0.57841277f, -0.12839265f, 
    -0.02186767f, -0.30935362f, 0.01116792f, -0.04138314f, 0.10125877f, 0.07038367f, -0.02521800f, 0.06910306f, 
    -0.54317456f, -0.20896053f, 0.14767276f, -0.43311384f, -0.05523425f, 0.01510760f, 0.06442330f, 0.13106318f, 
    -0.26151219f, 0.11457448f, 0.11653037f, -0.15259472f, -0.55670470f, -0.50329936f, -1.02699792f, -0.37139475f, 
    0.22074132f, 0.14772494f, -0.10163300f, 0.07833943f, -0.16322066f, -0.02523144f, 0.05163364f, 0.08613981f, 
    0.20327945f, 0.09484227f, 0.12573776f, 0.15397198f, 0.01320137f, -0.05961338f, -0.01965030f, 0.02192808f, 
    0.12023375f, 0.16866073f, -0.06794018f, -0.01462070f, 0.21029019f, -0.01750162f, 0.00421664f, 0.00531704f, 
    -0.39878148f, 0.08856416f, 0.18175714f, -0.08977188f, 0.09556672f, 0.16671386f, 0.01908701f, 0.10004630f, 
    0.26384017f, 0.04965630f, 0.25381115f, -0.14772424f, -0.11436474f, -0.04721063f, 0.02717568f, -0.06206587f, 
    0.22544242f, 0.07839864f, -0.00616125f, 0.04220274f, 0.11648668f, -0.61645049f, -0.44157267f, -0.10044426f, 
    0.22839931f, 0.15239084f, 0.09568794f, 0.12148237f, -0.02793759f, 0.12111649f, 0.00367128f, -0.05477353f, 
    0.29444712f, 0.02891803f, -0.00272479f, 0.12635729f, -0.11632852f, -0.16349724f, -0.04685724f, 0.08827271f, 
    -0.15083039f, -0.02999161f, 0.04676732f, -0.00868728f, -0.03285439f, 0.06468745f, -0.14772341f, 0.00875222f, 
    -0.00059254f, -0.13978586f, -0.14831948f, -0.37276301f, -0.18898290f, 0.00389272f, -0.14837675f, -0.12908728f, 
    -0.64639133f, -0.54730374f, -0.25632730f, -0.18518800f, 0.00935068f, 0.08588553f, -0.00166621f, -0.14438415f, 
    -0.00911148f, 0.03406986f, -0.10069036f, -0.01372026f, -0.01858322f, 0.32051948f, 0.22253078f, 0.04364292f, 
    0.04060948f, -0.06249529f, -0.10157356f, -0.00314438f, -0.05444253f, 0.15333168f, -0.09567030f, 0.02472048f, 
    0.10937944f, 0.16836883f, 0.00951305f, 0.28656283f, -0.00895880f, 0.04931906f, 0.01519065f, 0.07150771f, 
    0.06343718f, 0.02681500f, 0.17770997f, 0.05627783f, -0.21783273f, -0.27261826f, -0.37396008f, 0.11123462f, 
    0.19254488f, 0.20709218f, -0.07487591f, 0.09015768f, -0.05367365f, 0.05018426f, -0.17487451f, 0.06947439f, 
    -0.33211535f, -0.06508982f, 0.08934733f, 0.32100791f, -0.07361393f, -0.08531335f, -0.13626711f, -0.09279083f, 
    0.04937567f, -0.04418402f, -0.14697136f, 0.10529974f, 0.61412549f, -0.13467206f, -0.02816820f, -0.21093372f, 
    0.16855033f, -0.05104324f, 0.16300516f, 0.05459277f, -0.06600583f, -0.03369163f, -0.01062327f, -0.16478765f, 
    0.83328688f, 0.28114650f, 0.01170570f, 0.15909904f, 0.05742502f, -0.16603339f, 0.02036487f, -0.03897325f, 
    0.44626972f, 0.15852901f, 0.00263054f, 0.07933573f, 0.48908496f, -0.02820280f, 0.32042950f, 0.34777024f, 
    0.11756793f, 0.01870429f, -0.02906366f, -0.13458066f, 0.03272338f, 0.11955857f, -0.05960198f, 0.03046679f, 
    -0.58891237f, 0.45128831f, 0.55601615f, 0.19496089f, -0.31198278f, -0.21579075f, -0.03443417f, 0.15287797f, 
    0.03270262f, 0.07665760f, 0.16922289f, 0.05973952f, -0.47406262f, 0.03689133f, 0.38515821f, 0.15771857f, 
    -0.06576282f, 0.01803896f, 0.11284090f, 0.17679229f, 0.16841653f, -0.01911882f, 0.12213121f, -0.06791216f, 
    0.18523674f, -0.19448255f, 0.01077624f, -0.09804774f, -0.05006545f, 0.11550476f, 0.13554808f, -0.02318141f, 
    -0.09542148f, -0.03018869f, -0.06296762f, -0.14034124f, 0.44572303f, -0.17111543f, -0.29808232f, 0.23655084f, 
    0.08886847f, 0.00585952f, 0.21958630f, 0.03922017f, -0.08673107f, 0.12371513f, 0.11063991f, -0.05360199f, 
    0.12169442f, -0.09026773f, 0.00667311f, -0.28420043f, -0.09599295f, -0.09879078f, -0.02472884f, -0.08734082f, 
    0.12264257f, 0.08970071f, 0.25982574f, 0.13308884f, -0.19622838f, -0.23585163f, 0.20261292f, 0.26375130f, 
    0.03805156f, 0.01831287f, -0.05065319f, -0.02797709f, 0.09684605f, 0.12152722f, 0.08426661f, 0.02618981f, 
    0.46141541f, -0.03793019f, -0.09578118f, -0.12344488f, -0.03009829f, 0.27364114f, 0.15317392f, 0.06851613f, 
    0.06083055f, -0.07885805f, -0.02011085f, 0.03162440f, -0.29482850f, -0.24357325f, 0.01923623f, -0.11393113f, 
    0.07968430f, 0.19208954f, -0.07660343f, 0.19422629f, -0.17295735f, -0.10867779f, 0.00358262f, -0.06174907f, 
    -0.31136695f, -0.06265575f, 0.25014418f, -0.02636798f, 0.06213818f, -0.07310060f, 0.11457623f, 0.01470824f, 
    0.12332977f, -0.01699122f, -0.08615734f, 0.10357490f, -0.07462091f, -0.00069587f, -0.12465237f, 0.55092078f, 
    -0.20056403f, -0.10063999f, -0.09693448f, 0.00351636f, 0.10697948f, 0.01000338f, 0.06321879f, 0.06168278f, 
    0.28629339f, 0.29115927f, -0.10661414f, 0.21319397f, -0.06024450f, 0.11222449f, 0.17773232f, 0.10405485f, 
    0.11161020f, 0.20549937f, -0.13895264f, -0.20622569f, -0.25912347f, -0.33130676f, 0.11550944f, 0.05825632f, 
    -0.08668245f, 0.16330527f, -0.03961225f, 0.15976270f, -0.10722069f, 0.01688670f, 0.12287834f, 0.00149574f, 
    -0.21658368f, -0.03198757f, 0.67419863f, 0.48827395f, 0.23527505f, 0.21816128f, 0.10174178f, 0.14512245f, 
    -0.11914751f, 0.08469418f, -0.02906119f, -0.05619336f, -0.17788696f, -0.03259631f, 0.02655114f, -0.06634383f, 
    -0.04574165f, -0.22234467f, 0.21735668f, -0.18480660f, 0.08760032f, -0.09514216f, -0.00650123f, 0.16228172f, 
    1.09891295f, 0.01147567f, 0.25667995f, -0.50719231f, -0.15939760f, 0.07532720f, 0.40745413f, 0.20479502f, 
    -0.04069800f, 0.10070761f, -0.00146297f, 0.03913051f, -0.35446557f, -0.26235747f, -0.07042523f, 0.13842663f, 
    -0.06889138f, -0.09483407f, -0.04313500f, 0.04949725f, 0.07360785f, -0.10189994f, -0.03995713f, 0.05533044f, 
    0.00191361f, 0.03904762f, -0.13476273f, -0.00172019f, 0.05714627f, 0.19275457f, 0.07460854f, -0.05494256f, 
    0.01110465f, 0.07369211f, 0.04602342f, -0.09347815f, 0.29918420f, 0.29019445f, 0.20385033f, 0.06564809f, 
    0.24547365f, -0.07536126f, -0.12812406f, -0.28333107f, -0.07652288f, -0.04380912f, -0.17917496f, 0.01369652f, 
    -0.20254250f, -0.25301120f, -0.25276303f, -0.00910764f, -0.07933852f, -0.03826601f, -0.08780751f, -0.13084690f, 
    0.04187858f, 0.09707538f, 0.12027410f, 0.17470132f, -0.26194793f, -0.11759286f, -0.10727648f, -0.08598316f, 
    -0.17442304f, 0.08593958f, -0.04027275f, 0.02951427f, 0.03789748f, -0.05491829f, -0.00034869f, -0.06813121f, 
    0.73788917f, 0.04060924f, -0.03754688f, 0.06887442f, -0.01612215f, -0.10881884f, -0.05315209f, 0.06443473f, 
    0.03068393f, -0.14076032f, -0.28741989f, -0.17896463f, 0.11317037f, 0.42021570f, 0.07307076f, 0.04415486f, 
    0.09262899f, -0.05174808f, 0.06549644f, 0.13811508f, 0.02421693f, -0.15965690f, -0.12454207f, 0.10775343f, 
    -0.12222912f, -0.26112673f, -0.28035817f, -0.07494337f, 0.00566756f, 0.02257797f, 0.03493374f, 0.12661210f, 
    0.03382885f, 0.23243237f, 0.06097796f, -0.03727045f, -0.21973450f, 0.21368478f, -0.03335641f, 0.13993156f, 
    -0.19318748f, 0.12338108f, 0.28730154f, 0.16774578f, 0.02338655f, -0.03748594f, -0.01967245f, 0.05488861f, 
    0.23374139f, 0.51833993f, 0.40528807f, 0.63470125f, -0.05832533f, 0.04065191f, 0.08976500f, 0.30379584f, 
    -0.04664231f, 0.00879145f, 0.02385621f, 0.10356653f, -0.11201379f, 0.25278512f, -0.09121132f, -0.03356149f, 
    -0.21040761f, 0.11483766f, 0.08955963f, 0.08243497f, 0.11421916f, -0.02539023f, 0.15440018f, 0.06702436f, 
    -0.76045245f, -0.38386759f, -0.34453616f, -0.20621979f, -0.09791081f, -0.03072105f, -0.08176065f, -0.01652503f, 
    0.09128217f, 0.00197862f, 0.07285212f, -0.12128354f, -0.57194513f, 0.60595721f, 0.43046695f, 0.16842136f, 
    -0.12396435f, 0.16778190f, 0.09375201f, 0.16997182f, -0.00007268f, -0.00265807f, 0.06469034f, 0.15173586f, 
    -0.17366178f, 0.01926788f, 0.17753564f, 0.04894874f, 0.14757188f, 0.27466309f, -0.02195317f, 0.04767430f, 
    0.10972975f, 0.07814452f, 0.05820652f, 0.15866402f, 0.13295680f, 0.32580739f, 0.21086119f, 0.01226993f, 
    0.00702172f, -0.14962202f, 0.07656015f, 0.27436706f, -0.12879479f, -0.03846312f, -0.03393483f, 0.13039529f, 
    0.65173113f, -0.38407272f, -0.47578287f, 0.07235679f, -0.04777617f, 0.12442584f, 0.01045130f, -0.14250727f, 
    -0.00830928f, 0.15272930f, 0.08670323f, -0.12833618f, -0.00978478f, 0.03126654f, -0.10484501f, -0.16084051f, 
    -0.02737341f, 0.04286260f, -0.06371489f, 0.15042554f, 0.01936425f, 0.03756786f, -0.07369022f, 0.03092614f, 
    -0.04247434f, 0.08235407f, 0.55234706f, 0.28604934f, -0.03287186f, -0.18141444f, -0.04890272f, 0.01479084f, 
    -0.03013491f, 0.08288325f, 0.22823130f, 0.20644222f, -0.27643964f, 0.09727435f, 0.47022974f, 0.09819848f, 
    0.02009193f, -0.11908802f, 0.01304619f, 0.16942826f, 0.05279129f, -0.01972730f, 0.11079294f, -0.12545395f, 
    -0.14070813f, -0.18351197f, 0.04820351f, -0.09014689f, -0.01046247f, -0.05376949f, -0.00785843f, 0.07271993f, 
    -0.00250486f, -0.06165656f, -0.04620502f, -0.01007838f, -0.26272544f, 0.07278479f, -0.35543120f, 0.05104987f, 
    0.13208327f, 0.24758951f, 0.25892714f, 0.05310364f, 0.05828031f, 0.09754305f, 0.05121498f, -0.00902916f, 
    0.01243656f, 0.04551187f, -0.17220664f, 0.38969645f, -0.04138149f, 0.00267566f, -0.08422530f, -0.03061557f, 
    -0.34605661f, 0.05823170f, 0.11557591f, 0.18284547f, -0.06630974f, -0.16618954f, 0.35793313f, -0.00173659f, 
    -0.01927582f, -0.04804030f, -0.13655534f, 0.13423204f, 0.01924091f, 0.13913670f, -0.05373514f, -0.14391379f, 
    0.10289214f, -0.32608390f, 0.00478345f, -0.18287601f, 0.32837948f, 0.07943218f, -0.01645718f, 0.16375946f, 
    0.02414604f, -0.01802363f, -0.01982136f, -0.02216984f, -0.08718476f, -0.22459729f, -0.15040220f, -0.31751966f, 
    0.09200720f, -0.17846581f, 0.24995819f, 0.07538678f, 0.01036717f, 0.05415485f, -0.00190992f, 0.09551629f, 
    -0.29486471f, 0.08123030f, 0.02986285f, -0.10467015f, 0.25621557f, 0.01328736f, -0.08783869f, -0.11176657f, 
    -0.04216402f, 0.02038918f, -0.16547565f, 0.02313129f, -0.10431066f, -0.02601395f, 0.07995071f, 0.11458012f, 
    0.00493666f, -0.05231263f, -0.01869974f, -0.02057021f, -0.00320069f, 0.26522502f, 0.05265971f, -0.08048557f, 
    0.10356708f, -0.25405142f, 0.16833952f, 0.17693995f, 0.05774100f, 0.08125173f, 0.07555047f, 0.13960657f, 
    0.08482651f, -0.04751345f, -0.08514235f, 0.03300286f, -0.26883021f, -0.54364771f, -0.28046185f, -0.04041998f, 
    0.06487621f, 0.11941319f, 0.02272349f, -0.06560571f, -0.00824841f, -0.00973050f, -0.00195159f, 0.01479509f, 
    -0.27779341f, 0.17284134f, -0.19337139f, 0.24508700f, 0.26892981f, 0.17639661f, 0.07647994f, 0.14120923f, 
    0.07480141f, 0.13730912f, 0.09708184f, 0.19296925f, -0.14301036f, 0.07824659f, -0.32335576f, -0.27626643f, 
    0.07848100f, 0.12061661f, 0.10753120f, -0.18792726f, 0.08195718f, -0.01219358f, -0.03345778f, -0.11614509f, 
    0.61399347f, 0.46068192f, -0.13329534f, -1.14689314f, 0.01626193f, 0.01000639f, 0.17710768f, 0.09749013f, 
    0.32289833f, 0.11663814f, -0.11397865f, 0.03104464f, 0.18166269f, -0.52844507f, 0.32222876f, -0.22904451f, 
    0.18025166f, -0.06523908f, -0.02247535f, -0.00301846f, 0.05935215f, -0.01005686f, -0.00810715f, -0.04654877f, 
    0.26531926f, -0.50427914f, -0.37187523f, -0.30751410f, 0.24571528f, 0.06401905f, -0.00647917f, 0.06165202f, 
    -0.15902384f, -0.16519271f, 0.08101197f, -0.14534822f, 0.06595985f, 0.05134298f, -0.08630884f, -0.04186421f, 
    0.08658589f, -0.18398952f, -0.00737898f, -0.04089159f, 0.02921435f, 0.02911115f, -0.07715347f, 0.14134058f, 
    -0.03824717f, 0.18810228f, 0.14267822f, -0.07571020f, 0.00219590f, -0.04293896f, -0.07368208f, -0.05103566f, 
    0.14765173f, -0.09024093f, 0.24263024f, 0.12528162f, -0.08254515f, -0.20910080f, 0.38627771f, 0.09150689f, 
    0.00622574f, -0.01886073f, -0.24098101f, 0.18509017f, 0.09093820f, 0.04204594f, 0.12860830f, -0.05347056f, 
    0.22340979f, -0.01498388f, -0.05664288f, 0.26095620f, 0.04573728f, 0.08441493f, -0.01040532f, -0.06207498f, 
    -0.03391711f, -0.18614580f, -0.22093666f, -0.26022327f, -0.23209082f, 0.19191021f, 0.33126357f, -0.00144954f, 
    -0.03556620f, -0.06784800f, 0.03534997f, -0.01361043f, 0.03639464f, 0.01636255f, 0.03133854f, 0.02653145f, 
    -0.34109429f, 0.13942878f, 0.11324839f, -0.09465407f, 0.10609394f, -0.16672665f, -0.20522749f, 0.03951879f, 
    -0.03775141f, 0.01563437f, 0.07217599f, 0.00385555f, -0.02381038f, 0.14695467f, -0.11052021f, 0.05224204f, 
    -0.05340561f, 0.02636265f, 0.16021599f, -0.23307419f, 0.08706388f, 0.02291231f, -0.01184780f, 0.02721565f, 
    0.04972893f, -0.10175434f, 0.06267321f, 0.29167584f, 0.03672126f, 0.14800189f, 0.02883273f, 0.12019297f, 
    0.06065680f, 0.13086323f, -0.01210815f, 0.03509963f, 0.18245950f, -0.07911785f, 0.18814364f, -0.07813171f, 
    0.10735752f, 0.00464359f, -0.03746963f, -0.02135361f, -0.09219821f, 0.09415386f, 0.17944466f, 0.13826682f, 
    -0.05311012f, 0.07429615f, 0.23652209f, -0.36672273f, -0.02327917f, 0.01450244f, -0.15708803f, -0.06660873f, 
    0.01763835f, -0.06815780f, 0.12477184f, 0.13463363f, 0.12228283f, 0.38745421f, 0.00277844f, 0.35634735f, 
    0.08186280f, -0.10634671f, 0.09078577f, -0.03999380f, -0.04790196f, 0.12764655f, 0.02718220f, 0.00012244f, 
    0.12537049f, 0.10981754f, -0.32550249f, -0.21218216f, 0.17179736f, 0.24380861f, -0.04426530f, -0.06971613f, 
    0.06134133f, 0.10595405f, 0.06454439f, -0.03360482f, -0.04031879f, -0.02409174f, 0.07272196f, 0.20794435f, 
    -0.02196120f, 0.21219778f, -0.00135157f, 0.07926060f, -0.01636057f, -0.12346870f, -0.04644102f, 0.02662165f, 
    -0.26569068f, 0.28166094f, -0.20308128f, 0.38049951f, -0.02960414f, 0.23051473f, 0.31393090f, 0.12382178f, 
    0.25471643f, -0.05622237f, 0.22103542f, 0.05731105f, 0.11085172f, 0.76767117f, -0.31931752f, -0.16671576f, 
    0.00971987f, -0.14542255f, 0.09891640f, -0.05237725f, 0.02100090f, 0.00240671f, -0.09600335f, 0.03178230f, 
    0.50815094f, 0.58116406f, 0.72022152f, 0.48495546f, -0.23884426f, -0.13551655f, 0.09535035f, -0.03184713f, 
    0.03967077f, 0.11585340f, 0.02162874f, 0.24172541f, -0.06036532f, -0.14859453f, -0.00351986f, 0.31044194f, 
    0.12292276f, 0.10757531f, -0.11004791f, -0.19006602f, 0.08725243f, 0.03621404f, 0.13598178f, 0.29354513f, 
    -0.30743954f, -0.36144075f, -0.09403113f, -0.20664604f, 0.34301710f, 0.12003142f, 0.34909779f, 0.21495123f, 
    -0.15176079f, -0.00929781f, -0.25577569f, 0.00150998f, -0.14510335f, -0.04730903f, -0.03662096f, 0.00822745f, 
    0.10282162f, 0.20311248f, -0.01342540f, 0.13209555f, 0.13461319f, 0.03459961f, 0.11404455f, 0.11120381f, 
    0.09079843f, 0.29938549f, 0.34632903f, -0.12158594f, -0.08434874f, -0.16747406f, 0.15901653f, 0.11364721f, 
    0.37214777f, 0.37150270f, 0.21939936f, 0.21687241f, 0.00891215f, -0.20758736f, -0.00099066f, 0.20271105f, 
    0.11155269f, 0.11840303f, -0.01396098f, -0.03603670f, 0.13580519f, 0.29920322f, 0.13755287f, 0.23808457f, 
    0.12646933f, -0.20292079f, 0.15176082f, 0.18300170f, 0.30382413f, 0.05748156f, -0.04772428f, 0.25065559f, 
    -0.34980908f, -0.49012819f, -0.19727539f, -0.58886009f, -0.22526343f, -0.63239872f, 0.22612390f, 0.03671647f, 
    0.11285414f, 0.15607545f, -0.16556263f, 0.20216575f, -0.39848867f, -0.05952210f, -0.21394412f, -0.41146332f, 
    0.01273044f, 0.21700259f, 0.11021544f, 0.21758825f, 0.00775968f, -0.07642524f, 0.03401074f, 0.01222805f, 
    0.10406890f, 0.00413362f, -0.04455924f, -0.06610315f, 0.12945452f, 0.19950321f, 0.27913490f, 0.18946360f, 
    -0.10050875f, -0.12514170f, -0.29213819f, 0.13403064f, -0.32868102f, -0.23120049f, -0.26492009f, -0.19868751f, 
    -0.04033720f, -0.57802802f, -0.21245532f, 0.29124370f, 0.26442125f, 0.15625931f, 0.08207160f, -0.43924358f, 
    -0.06314731f, -0.13423996f, 0.06689387f, 0.57510638f, -0.02286734f, -0.02916433f, -0.01410398f, 0.13070945f, 
    0.15040439f, 0.07130988f, 0.20122519f, 0.11898009f, -0.35998186f, -0.02825726f, -0.46259463f, -0.15769951f, 
    -0.30095845f, 0.04035696f, -0.33391488f, -0.03467248f, -0.16776404f, -0.18151982f, 0.10093714f, -0.08090943f, 
    -0.25614500f, -0.12915546f, -0.31179419f, -0.49908489f, 0.08151720f, 0.23844573f, 0.24539898f, -0.02293310f, 
    0.18017395f, 0.02393788f, 0.07769926f, 0.01274292f, 0.24318546f, 0.14649555f, 0.03036054f, -0.13844821f, 
    -0.08860817f, 0.57066053f, 0.31274089f, -0.40071478f, 0.41513124f, -0.02150506f, -0.07111913f, -0.08333563f, 
    -0.02875628f, -0.03435733f, 0.18628401f, 0.14886832f, 0.06785017f, -0.43522203f, 0.13246252f, 0.08475221f, 
    0.39824891f, 0.09898750f, -0.23452717f, -0.24547106f, -0.21916312f, -0.08219121f, -0.02874639f, 0.11842680f, 
    0.05387152f, -0.13199000f, 0.17503430f, 0.12290526f, 0.09603827f, -0.07120752f, -0.00687973f, 0.20241457f, 
    0.12623090f, 0.24638152f, 0.16832140f, 0.10389039f, -0.17361003f, -0.18678980f, -0.18043306f, 0.05286964f, 
    0.01049286f, -0.03879937f, 0.17512028f, 0.20831586f, 0.10310485f, 0.13138489f, 0.09867670f, 0.05069914f, 
    -0.17653410f, -0.14604378f, -0.12133006f, -0.24694026f, -0.20921664f, -0.16032836f, -0.02111712f, 0.04140051f, 
    -0.27054083f, -0.03170451f, -0.19898030f, -0.20535797f, 0.20014337f, -0.18480289f, -0.00108397f, 0.26072863f, 
    0.03736725f, 0.19987273f, 0.55769771f, 0.24026170f, -0.01159441f, 0.08305105f, -0.00890512f, -0.01089856f, 
    -0.06187796f, 0.43712848f, 0.10877563f, 0.05233188f, 0.06446497f, -0.04412660f, -0.05925079f, 0.01464651f, 
    -0.06963899f, 0.41110474f, 0.27541465f, 0.10363223f, -0.53086293f, -0.20008428f, 0.00500282f, 0.15089799f, 
    0.05028611f, 0.07189767f, 0.10560192f, 0.15144032f, 0.04027402f, 0.14077505f, 0.05397868f, 0.02577565f, 
    -0.37115419f, -0.28067228f, 0.15282035f, -0.17278351f, 0.06744062f, -0.10232612f, -0.03569169f, 0.14928934f, 
    0.00245865f, -0.17807028f, 0.04154234f, 0.03766834f, -0.20202772f, -0.25260329f, -0.17512195f, 0.23173827f, 
    0.00431062f, 0.05016024f, -0.20096084f, 0.19279215f, 0.07929739f, 0.05952896f, -0.00791476f, 0.02759096f, 
    -0.19317839f, -0.38489649f, -0.10454037f, -0.08857574f, 0.03811295f, -0.10761852f, 0.07660768f, 0.16596870f, 
    0.01302654f, 0.05628262f, 0.04454043f, -0.07653794f, 0.23058881f, -0.03686325f, -0.09105972f, -0.21670847f, 
    0.10225486f, -0.20912412f, -0.05874674f, -0.15341125f, 0.06589266f, 0.28921816f, 0.11698396f, 0.44981790f, 
    0.27952728f, -0.16851586f, 0.04697676f, -0.19409756f, -0.12720791f, 0.09013667f, -0.10880700f, -0.08031303f, 
    -0.12923096f, 0.01742113f, -0.08317845f, 0.13373643f, -0.02809649f, -0.11459493f, -0.34860879f, 0.54686987f, 
    0.24200977f, 0.09991454f, 0.05665754f, 0.09052478f, -0.04135959f, 0.08732394f, 0.06359696f, 0.09445135f, 
    -0.00017794f, 0.07334533f, -0.05100236f, 0.04578373f, 0.29447287f, 0.06266008f, -0.04700855f, 0.31329015f, 
    -0.05221036f, -0.05824252f, 0.00910899f, 0.16043167f, -0.22548443f, -0.45614830f, -0.05565776f, 0.36954233f, 
    -0.06335912f, 0.30765748f, 0.14261539f, 0.11158653f, 0.04895571f, 0.04983840f, 0.06830769f, -0.08310582f, 
    -0.55244279f, 0.53298616f, 0.45122620f, 0.49346378f, -0.10322339f, -0.21031888f, 0.30991682f, 0.08904980f, 
    0.18583964f, 0.07503663f, 0.20020621f, 0.06507146f, -0.32977486f, 0.71394473f, 0.07026421f, 0.16157642f, 
    0.09102659f, 0.00467492f, -0.17701548f, -0.05043883f, -0.04852176f, 0.02535705f, 0.18204698f, 0.04955244f, 
    0.40172985f, -0.00378739f, -0.21264577f, -0.03621797f, -0.01934765f, 0.13660243f, -0.22920261f, -0.22590834f, 
    -0.08475664f, 0.01668482f, -0.02411820f, 0.00609090f, 0.28061941f, -0.17888699f, 0.04179790f, 0.09166013f, 
    0.11764070f, -0.00697734f, -0.17631868f, -0.13623385f, -0.06288831f, 0.00789636f, -0.00889117f, -0.01476100f, 
    0.14918791f, -0.03593004f, -0.03892808f, 0.07535614f, -0.14345908f, -0.02588818f, 0.06333611f, -0.04998363f, 
    0.02834186f, 0.14667605f, -0.03486073f, -0.01779982f, 0.09397641f, 0.14451745f, -0.01814044f, -0.24190596f, 
    -0.03821043f, -0.19977190f, 0.10251181f, -0.06382939f, -0.00123676f, -0.04293767f, 0.07022861f, 0.10752528f, 
    0.37880155f, 0.04741195f, 0.34967083f, 0.32557282f, 0.04506425f, -0.08236115f, -0.08220897f, 0.08181038f, 
    -0.11288808f, 0.10054304f, -0.22091995f, -0.11531694f, 0.37541482f, -0.00069172f, -0.29922032f, 0.24556567f, 
    0.16303788f, -0.03686966f, -0.07057493f, 0.10498463f, 0.17334171f, 0.09898634f, -0.15417989f, -0.01192950f, 
    0.35167342f, 0.05642939f, -0.13731179f, -0.02294769f, -0.28717029f, -0.16813758f, -0.01560174f, 0.15474774f, 
    -0.19799671f, 0.11605562f, 0.02753308f, -0.03932073f, -0.21596940f, -0.12147453f, -0.24154739f, -0.04662949f, 
    -0.00228963f, 0.18252653f, 0.22690532f, -0.10801081f, -0.06217775f, -0.06659331f, -0.10597952f, -0.01498613f, 
    0.03466825f, 0.07679535f, 0.14139386f, 0.41132784f, -0.38769329f, -0.04363865f, 0.07863067f, 0.24551293f, 
    -0.03783317f, 0.10804799f, 0.03879828f, 0.11947603f, 0.12023891f, 0.30750948f, 0.06137423f, 0.18721421f, 
    -0.12036984f, 0.13966617f, 0.10414195f, 0.06503700f, -0.01410017f, -0.05071546f, -0.21129751f, -0.10469830f, 
    0.11032169f, 0.21643604f, -0.17841505f, 0.01327003f, -0.08703041f, 0.05528677f, 0.03236253f, -0.13028106f, 
    0.16387710f, 0.06832088f, 0.08284483f, -0.15545526f, -0.61890471f, 0.20105769f, 0.09492327f, -0.03961772f, 
    -0.05099410f, -0.10668944f, 0.09321250f, 0.00457576f, 0.03124874f, 0.06219143f, 0.01869875f, 0.00404695f, 
    -0.27006626f, -0.18466176f, -0.05180009f, -0.01648163f, -0.16367294f, 0.11888050f, 0.06786440f, 0.13235645f, 
    0.08384224f, -0.03687477f, -0.02687601f, -0.11019706f, 0.18962494f, 0.07420147f, 0.06712148f, 0.16359511f, 
    -0.17242803f, -0.33685902f, 0.07971030f, 0.24647327f, -0.16394328f, 0.01048425f, -0.10499913f, 0.03062858f, 
    0.40857941f, -0.25946015f, 0.07574524f, 0.27552176f, -0.20450155f, -0.05313121f, 0.34530777f, -0.00318705f, 
    -0.22229685f, 0.13693234f, -0.02044490f, -0.00848382f, 0.24587120f, -0.63932538f, 0.51106882f, 0.15999411f, 
    -0.12956510f, 0.10066301f, -0.03731142f, 0.08770789f, -0.08631808f, -0.07302967f, -0.07905378f, 0.15745829f, 
    0.74100798f, -0.26720715f, 0.13800706f, 0.00336350f, 0.31568870f, 0.23777488f, -0.09521694f, -0.23718460f, 
    0.23516974f, 0.08724140f, 0.09535744f, 0.09543885f, 0.12611863f, 0.07188030f, -0.16438904f, 0.10737044f, 
    0.15516275f, 0.12041534f, 0.07521168f, 0.07406664f, -0.00579050f, 0.09160562f, 0.13874204f, 0.22655565f, 
    0.10793948f, 0.07433777f, 0.09667418f, -0.04631718f, 0.14429966f, 0.01223865f, 0.19432287f, 0.04375539f, 
    -0.32188371f, -0.07437629f, -0.11529478f, -0.23160625f, 0.08696718f, 0.12698744f, 0.43901429f, 0.21515574f, 
    0.00815995f, 0.21080247f, 0.22649373f, 0.15132783f, -0.00118964f, 0.15356623f, 0.07349263f, 0.18901230f, 
    -0.14833687f, 0.01338169f, -0.12643987f, 0.33564255f, 0.18774007f, -0.11261226f, 0.20724449f, 0.00089183f, 
    0.19086868f, 0.22921611f, 0.31807888f, 0.29261622f, 0.17590426f, 0.17610537f, -0.11813170f, 0.05307786f, 
    -0.04386099f, 0.16734821f, 0.10881440f, 0.05387977f, -0.05254772f, 0.16015553f, 0.21717873f, 0.10739280f, 
    -0.29222986f, 0.13501357f, -0.06792477f, -0.11753498f, 0.16696948f, -0.00741708f, -0.11156882f, 0.04977151f, 
    -0.43787748f, -0.31471670f, 0.02377548f, -0.47776952f, 0.06035006f, 0.05882917f, 0.05240801f, 0.00405487f, 
    0.20740168f, 0.25404331f, 0.01699610f, 0.18644708f, -0.36269549f, -0.17347945f, -0.23967525f, -0.41125351f, 
    0.17457204f, 0.25471699f, -0.00772892f, 0.07550384f, -0.04136874f, 0.00384054f, 0.05429518f, 0.24736433f, 
    0.02266481f, -0.10449785f, -0.08466939f, -0.14218074f, 0.20779946f, -0.21125875f, 0.29415810f, -0.05414640f, 
    -0.13574357f, -0.05910429f, -0.16512455f, -0.45919037f, -0.34197742f, -0.35605904f, -0.24066985f, -0.54583997f, 
    -0.01891174f, -0.20782919f, 0.28283152f, -0.04098853f, 0.08494038f, 0.04557212f, -0.25131848f, -0.46638590f, 
    0.10924366f, -0.14850870f, -0.09139588f, 0.47556302f, 0.13196750f, 0.33641583f, 0.18211932f, -0.01707832f, 
    0.38287917f, -0.12661670f, 0.13309073f, 0.17831519f, -0.31461203f, -0.00625007f, -0.43533510f, -0.22784093f, 
    -0.01883815f, 0.11006463f, -0.24003705f, -0.63808626f, 0.09550956f, -0.05768192f, -0.36027884f, 0.00336882f, 
    -0.26116145f, -0.30084819f, -0.18127388f, -0.42890757f, 0.21635154f, -0.02099147f, 0.17174645f, 0.48393136f, 
    -0.06890550f, 0.29227942f, 0.01317276f, 0.39894480f, 0.11693238f, 0.31047606f, 0.07379330f, -0.08776846f, 
    -0.79513872f, 0.30820814f, -0.45870000f, 0.45246395f, -0.09672449f, 0.18247460f, 0.06163657f, -0.26576436f, 
    0.03227520f, -0.07227553f, 0.01364326f, -0.03876709f, 0.06527251f, 0.37356099f, 0.21894178f, 0.17842396f, 
    0.30151105f, 0.16363786f, 0.11622214f, -0.24582775f, -0.42109463f, -0.21231419f, -0.11225642f, 0.07141481f, 
    0.04793252f, -0.05476126f, -0.05229230f, 0.03674690f, -0.03920967f, 0.01389550f, 0.01457634f, -0.07519680f, 
    -0.00875180f, -0.05065237f, -0.07226603f, 0.03874205f, 0.00312447f, 0.05093129f, 0.05290242f, -0.06048371f, 
    -0.03579546f, 0.00947204f, -0.05462009f, -0.04182691f, 0.02977450f, 0.06280579f, 0.05529279f, -0.05928575f, 
    -0.05807865f, -0.04578342f, 0.01624287f, 0.06105500f, -0.06585245f, -0.05660679f, 0.05793601f, -0.06755427f, 
    -0.02347131f, -0.00036707f, -0.07182317f, -0.01691619f, 0.00342089f, 0.06927320f, 0.04152202f, 0.01049296f, 
    0.01887319f, -0.01996985f, 0.05850445f, -0.05520403f, -0.07918753f, 0.05412377f, -0.04659309f, -0.04345398f, 
    0.02657948f, 0.04452002f, -0.01877056f, -0.01297952f, 0.06547830f, -0.02969494f, -0.05902442f, 0.01527511f, 
    -0.02784817f, 0.00683790f, 0.01043004f, 0.03715996f, 0.03132560f, 0.02920765f, -0.03482340f, 0.06217548f, 
    0.01306015f, 0.06214336f, 0.05214607f, 0.01217840f, 0.05927281f, 0.00424340f, -0.03750192f, 0.06012752f, 
    0.05460554f, -0.03939300f, -0.02052341f, -0.02654542f, 0.00614851f, 0.03022235f, -0.01730406f, 0.02941647f, 
    0.04182672f, -0.00602055f, -0.03819035f, -0.03087561f, 0.01059411f, -0.00887210f, 0.00688575f, -0.03710521f, 
    -0.04548106f, -0.03505569f, 0.02797216f, 0.06066647f, -0.02603208f, 0.04133884f, 0.03833554f, 0.00382492f, 
    -0.04654392f, -0.07382081f, -0.04445054f, 0.04535590f, -0.07024856f, -0.01428652f, 0.05026520f, 0.02447423f, 
    -0.06140780f, 0.05686248f, -0.03034665f, -0.06385947f, 0.06634940f, -0.04556640f, 0.02303676f, -0.00132274f, 
    0.06812202f, 0.01466569f, 0.03698961f, -0.06271315f, 0.01407672f, -0.04882383f, 0.05830229f, -0.07145692f, 
    0.01947246f, -0.03646403f, 0.04465110f, -0.04024915f, -0.07299390f, -0.06886892f, 0.02996936f, 0.04117820f, 
    -0.06807680f, 0.03892066f, 0.02747910f, 0.01901119f, -0.01634981f, 0.03112497f, 0.02285448f, 0.01539775f, 
    0.00661292f, 0.03443583f, -0.07731900f, -0.06456731f, 0.03650828f, -0.07462288f, -0.06637228f, -0.02667128f, 
    -0.07440844f, -0.01927151f, 0.00465607f, -0.05543413f, -0.06917613f, -0.00896197f, -0.03402665f, -0.04670776f, 
    0.02485879f, 0.04859614f, -0.02461962f, -0.06864314f, -0.04961349f, 0.00587914f, -0.03929630f, 0.00945013f, 
    -0.04380788f, -0.07889953f, -0.02976734f, 0.00330270f, 0.06223525f, -0.01586642f, -0.06167186f, 0.03425707f, 
    0.00926878f, 0.01035838f, -0.03542063f, -0.05628132f, -0.00293767f, -0.05107060f, 0.02655091f, -0.07798765f, 
    -0.05339495f, -0.04616484f, 0.01571136f, -0.07758596f, -0.03112854f, 0.05855408f, -0.03299538f, -0.05890114f, 
    -0.06762010f, -0.01651671f, 0.06004154f, 0.04134440f, 0.02033318f, -0.06716729f, 0.04841388f, -0.03562337f, 
    -0.40774047f, -0.02023425f, -0.43108043f, -0.26714662f, 0.07146000f, 0.16396350f, 0.17610240f, 0.05193786f, 
    -0.04201202f, 0.08106372f, 0.04872566f, 0.02084692f, 0.38728967f, 0.19095436f, 0.11297269f, -0.15279400f, 
    0.14269571f, 0.16850738f, 0.09600282f, 0.00748737f, -0.02691152f, 0.07460209f, -0.03467238f, 0.08582043f, 
    0.06419470f, 0.12834379f, 0.03849857f, -0.09495959f, -0.12120243f, -0.09546608f, -0.03936982f, -0.21083665f, 
    0.00050521f, -0.03649646f, 0.01531020f, -0.07567763f, -0.05102744f, -0.17573696f, 0.55996555f, -0.24719127f, 
    0.17383993f, -0.05265452f, 0.10238619f, 0.11971747f, -0.11744331f, -0.13570851f, 0.06283274f, 0.00521108f, 
    0.26663154f, -0.11495262f, -0.02289453f, 0.25520897f, -0.10866684f, 0.13021997f, -0.17165817f, -0.09932649f, 
    -0.15544869f, 0.15126820f, -0.09423032f, 0.05638560f, 0.20657463f, 0.32839200f, 0.16441913f, -0.03204545f, 
    0.01778482f, 0.07442395f, 0.14400434f, -0.02173717f, 0.10563471f, -0.00261986f, -0.06046925f, 0.01395968f, 
    -0.15855013f, 0.01038150f, 0.00371598f, 0.06523998f, 0.07396898f, -0.16995139f, -0.13498721f, -0.10985136f, 
    -0.02184275f, 0.19386108f, -0.02866789f, 0.05084452f, 0.20171618f, 0.35512820f, -0.19931488f, -0.13952287f, 
    0.01716703f, -0.02775051f, 0.22392495f, -0.07632367f, 0.05386926f, -0.09631497f, -0.02764479f, -0.05757124f, 
    0.05973653f, -0.20162418f, -0.27007788f, 0.00720065f, 0.03986428f, 0.11386570f, -0.07939652f, -0.02464142f, 
    -0.01733447f, -0.03582461f, 0.03959399f, 0.06331958f, -0.21176372f, -0.06749663f, 0.06422915f, -0.04028723f, 
    0.01240462f, 0.01932375f, 0.02786520f, -0.06342056f, 0.05922411f, 0.34356359f, 0.26052547f, 0.24522962f, 
    0.31751162f, 0.39374024f, 0.11743464f, 0.11000624f, -0.06723785f, -0.14862700f, -0.18687265f, 0.04803302f, 
    -0.17671314f, -0.18654495f, 0.20480101f, -0.12074945f, 0.34795254f, 0.28360873f, -0.30711016f, 0.01907618f, 
    0.01462551f, -0.10476594f, 0.23452818f, -0.12925133f, 0.08919497f, 0.02784531f, 0.08077113f, 0.09422799f, 
    -0.03413487f, 0.21269035f, -0.24007146f, -0.03781925f, 0.36021954f, 0.10312112f, 0.32487240f, -0.02745339f, 
    0.21795024f, 0.02027497f, 0.01359076f, 0.20233862f, -0.06656878f, -0.07717990f, -0.02373071f, -0.26458275f, 
    0.00126991f, 0.16635580f, 0.09574039f, -0.08391000f, -0.04005514f, 0.06351759f, 0.03795649f, 0.06976161f, 
    0.22103888f, -0.26658365f, 0.17878830f, -0.04547450f, -0.06957903f, 0.06886303f, 0.11319016f, 0.13820463f, 
    0.23785767f, 0.08142257f, 0.17571960f, 0.14038564f, 0.09707858f, 0.46104348f, -0.37664041f, 0.10052346f, 
    -0.13623826f, -0.22409824f, 0.08288173f, -0.06654442f, -0.05458603f, 0.04450577f, 0.04812784f, 0.01859675f, 
    -0.27932400f, -0.26111588f, -0.60855484f, -0.20191136f, 0.02841939f, 0.09284320f, -0.09207925f, -0.13776757f, 
    -0.09821324f, 0.04301057f, -0.05900750f, -0.15733777f, -0.03701014f, 0.16692348f, -0.16406588f, 0.08329622f, 
    -0.06331246f, 0.08763695f, 0.00887392f, -0.06840117f, 0.08857556f, 0.08790843f, 0.03384760f, -0.00827911f, 
    0.02307114f, 0.03691889f, -0.07312683f, 0.07335975f, -0.01226967f, -0.06371321f, 0.01589404f, -0.17115629f, 
    -0.03012575f, 0.17778744f, 0.13110669f, 0.08396816f, 0.41030544f, -0.07090063f, -0.00318347f, 0.23213896f, 
    0.29456609f, -0.04949081f, 0.01862472f, -0.07924405f, -0.08668600f, -0.06160481f, -0.23996857f, -0.15382557f, 
    0.22269641f, -0.10331506f, 0.12534173f, -0.07358720f, -0.14321831f, -0.07197238f, -0.15856402f, -0.02328772f, 
    -0.00279487f, -0.14482644f, -0.17737213f, -0.23261434f, -0.00200149f, 0.16819291f, -0.23520730f, -0.00379274f, 
    0.13104588f, 0.13922234f, 0.20793799f, -0.22401035f, 0.18785158f, -0.01243396f, 0.12254991f, 0.12872790f, 
    0.11476272f, 0.05960763f, -0.01206921f, 0.05642395f, 0.03661837f, 0.14085723f, 0.03302398f, -0.03609881f, 
    -0.03096787f, 0.10231462f, 0.04854120f, -0.06297999f, -0.07105557f, 0.00002632f, -0.00542682f, -0.07734712f, 
    -0.06842878f, 0.33389172f, 0.13264744f, -0.12987000f, -0.01067396f, -0.03737340f, -0.02210423f, 0.01072350f, 
    0.18824708f, 0.10403105f, 0.35157368f, 0.14196551f, -0.19550210f, 0.08886160f, 0.21048285f, 0.23556180f, 
    0.13951136f, 0.18052176f, 0.15161678f, 0.15432574f, 0.03355779f, -0.03328944f, -0.00055309f, 0.22780292f, 
    -0.10086100f, -0.02225950f, -0.02102178f, -0.04144268f, 0.02082671f, 0.11976589f, 0.04982557f, 0.43108100f, 
    0.10382667f, 0.51015389f, -0.03510241f, 0.10718855f, -0.07349183f, 0.00994661f, 0.02584420f, -0.17680423f, 
    -0.08883255f, 0.01930344f, -0.05610194f, -0.10165289f, 0.40810621f, 0.14143442f, 0.35175163f, 0.15196203f, 
    -0.14758630f, 0.08478940f, -0.04536048f, -0.01933699f, 0.04534006f, 0.02981620f, 0.11019894f, -0.01029917f, 
    -0.01151663f, -0.30530235f, 0.30798456f, 0.05251376f, 0.01561471f, 0.21622777f, 0.08359101f, 0.11243242f, 
    0.06236892f, -0.02196575f, -0.01909675f, 0.02645266f, 0.16254568f, 0.22947025f, 0.40564197f, 0.28774396f, 
    -0.04492987f, -0.20776144f, -0.26458272f, 0.12980147f, -0.18122883f, -0.10682892f, -0.00610510f, 0.01234420f, 
    -0.06038919f, -0.38583615f, 0.26999924f, 0.61136168f, -0.00845476f, 0.04153135f, -0.01242845f, 0.21908566f, 
    -0.21884747f, -0.03380195f, 0.05786394f, 0.11072907f, -0.15462078f, 0.07430396f, 0.13842212f, 0.16355380f, 
    -0.19838946f, -0.00038690f, -0.17848104f, 0.00241648f, -0.10979812f, -0.17544311f, -0.09685115f, 0.15281588f, 
    -0.01363782f, -0.04250246f, 0.05913067f, -0.03024320f, 0.00526960f, -0.01512552f, -0.06277598f, -0.03646047f, 
    0.04679118f, -0.00016751f, -0.05521034f, 0.02679700f, -0.00985411f, 0.02724397f, -0.06840739f, 0.05733939f, 
    0.03889906f, -0.02871900f, -0.00720623f, 0.04916641f, -0.07517371f, 0.03688421f, -0.04814582f, -0.04649991f, 
    0.00755337f, 0.04500138f, 0.01854975f, -0.02995915f, -0.07483176f, 0.02058876f, 0.03143939f, -0.06462993f, 
    -0.06425438f, -0.01398106f, -0.08380705f, 0.00690208f, -0.04145132f, 0.04854528f, 0.05480350f, -0.01523704f, 
    -0.04251063f, -0.01345590f, -0.05226593f, 0.00068984f, -0.05655665f, -0.05290911f, 0.00847752f, 0.04215369f, 
    -0.03946337f, -0.05954915f, -0.03759693f, 0.02312214f, 0.02679297f, -0.06392250f, -0.07833612f, 0.03819508f, 
    0.02497935f, 0.05979277f, -0.06009167f, -0.07548892f, 0.01253841f, -0.01530213f, -0.06712537f, 0.03000105f, 
    -0.06119040f, -0.05131001f, 0.05665656f, -0.04676591f, 0.02903640f, -0.05758784f, -0.06304833f, -0.06905987f, 
    -0.07883894f, -0.00502974f, 0.04407020f, 0.00024767f, 0.03520639f, -0.01357819f, 0.01411156f, 0.00510339f, 
    0.03338888f, -0.07443088f, 0.05367796f, -0.08049984f, -0.00248143f, -0.03122246f, 0.04262382f, -0.07180296f, 
    -0.05755238f, -0.01343887f, -0.00547870f, 0.04513920f, 0.02587625f, -0.07446255f, -0.01027359f, -0.02007735f, 
    0.03706635f, 0.00030456f, -0.06498530f, 0.05401535f, 0.02895714f, -0.05764403f, -0.00513164f, -0.07033973f, 
    -0.07732195f, 0.06130379f, -0.07596170f, 0.05709099f, -0.07465696f, 0.00462276f, -0.02321492f, -0.04614193f, 
    0.03591983f, -0.06151209f, -0.00748466f, 0.04085387f, -0.03719977f, -0.06785036f, 0.01572941f, 0.02859657f, 
    0.00989271f, -0.00344533f, -0.04334715f, 0.05274191f, 0.00041438f, 0.06258299f, -0.07719462f, -0.01863878f, 
    0.00224729f, 0.05402605f, 0.01244327f, 0.05492201f, -0.05983343f, -0.05817367f, -0.06558472f, -0.04057323f, 
    -0.02922549f, -0.07284756f, -0.05276519f, 0.03146521f, -0.00246548f, 0.02565477f, 0.01545120f, -0.05619878f, 
    -0.04675249f, -0.00594939f, 0.03201692f, 0.04875031f, -0.01314512f, 0.00399355f, -0.01910836f, 0.01290455f, 
    -0.01902167f, 0.02612153f, 0.03508766f, 0.00331855f, -0.02116215f, 0.02551731f, -0.03930118f, 0.00095380f, 
    0.00408984f, -0.05569467f, -0.05317646f, -0.04490512f, -0.06546877f, -0.03029577f, 0.06538750f, -0.02984114f, 
    -0.04022862f, -0.07363088f, -0.04919447f, -0.03146805f, 0.01672603f, -0.02251903f, -0.06008763f, -0.01052920f, 
    0.04840611f, 0.03162777f, 0.03308031f, 0.03411144f, -0.06857175f, 0.01595423f, 0.05571402f, 0.02400189f, 
    0.00005781f, -0.00042443f, -0.00302874f, 0.03600505f, 0.04150927f, 0.05478868f, -0.04511515f, 0.02735827f, 
    0.04068239f, -0.05767282f, -0.05151893f, -0.00877993f, -0.03663889f, 0.06312047f, -0.04118420f, 0.04820092f, 
    -0.06885554f, 0.01279902f, -0.03298692f, 0.04209093f, 0.03589268f, 0.01371015f, -0.03197711f, 0.04527069f, 
    -0.05296008f, -0.03165443f, -0.04977398f, -0.06809478f, 0.04229459f, -0.01881872f, 0.01548276f, 0.04183271f, 
    0.02522316f, -0.02846224f, 0.01348687f, 0.00666660f, 0.01083993f, -0.01243850f, -0.05431390f, -0.03619834f, 
    -0.02478735f, 0.01532599f, -0.06944308f, -0.04722513f, -0.05604251f, -0.06160731f, -0.01252027f, 0.03142371f, 
    0.04726756f, -0.01003803f, -0.02506739f, -0.01474152f, 0.01385929f, -0.07611586f, -0.00253525f, -0.07205150f, 
    0.04188934f, -0.07883598f, -0.02950231f, 0.04096709f, -0.02491453f, -0.06775044f, 0.06787011f, -0.01165951f, 
    0.01450261f, -0.03936636f, -0.02638089f, -0.05922560f, 0.05953830f, -0.00255222f, -0.01403015f, 0.04318931f, 
    -0.05231023f, -0.04368097f, -0.03746793f, -0.07334296f, 0.00844731f, 0.03834545f, 0.00181026f, -0.02262784f, 
    -0.05420484f, 0.02003910f, 0.02864859f, 0.01276762f, -0.00635533f, -0.03078281f, -0.01362398f, -0.06571378f, 
    0.03043954f, -0.01666970f, -0.07297979f, 0.06930061f, -0.05276096f, 0.06479080f, 0.04035592f, -0.05757936f, 
    -0.01313267f, -0.03880627f, 0.03439289f, 0.06278052f, 0.05918401f, 0.06967130f, -0.00218635f, -0.06003996f, 
    -0.01108292f, 0.05259234f, -0.06248027f, -0.07717687f, -0.02292218f, -0.07786105f, -0.06611060f, 0.00605953f, 
    0.04992987f, 0.03140437f, 0.00278355f, 0.01861897f, 0.00599403f, 0.01758150f, -0.03932597f, -0.02479497f, 
    -0.06482555f, 0.03393523f, 0.05088270f, 0.00406581f, 0.02230357f, -0.04071853f, -0.03529112f, 0.03669654f, 
    0.04997767f, -0.06818710f, -0.05613139f, -0.04361207f, 0.05234186f, -0.06349639f, -0.05076537f, -0.05571070f, 
    0.00942861f, -0.02826928f, 0.02615964f, -0.04818208f, 0.04427517f, -0.01274817f, 0.02555850f, 0.05704048f, 
    0.00683778f, -0.03886259f, -0.00506030f, -0.03032239f, 0.00305418f, 0.00238404f, -0.01586048f, 0.02160437f, 
    0.06740358f, -0.02150872f, -0.00697342f, 0.05245135f, -0.02476135f, -0.04343834f, 0.02607808f, 0.02849675f, 
    0.03016340f, -0.01445496f, -0.06377640f, -0.04543038f, 0.03722547f, 0.01968722f, 0.04202681f, 0.04852489f, 
    -0.00517009f, 0.03529057f, -0.02921363f, 0.00664473f, -0.05558863f, 0.02879359f, -0.06070517f, 0.05838729f, 
    -0.02581422f, -0.00697409f, -0.00196144f, 0.02965807f, -0.00976079f, -0.06542356f, -0.05882620f, -0.05427514f, 
    -0.01649673f, -0.04813577f, -0.02922835f, -0.07190840f, 0.03593231f, -0.02608990f, -0.04306350f, -0.05827810f, 
    -0.07489185f, 0.01891767f, 0.01749705f, -0.05445519f, 0.04916500f, -0.01063274f, 0.03460710f, -0.02573124f, 
    0.05682400f, -0.09523156f, 0.05139811f, 0.19576433f, -0.19144191f, -0.20452924f, -0.02436591f, -0.03173787f, 
    0.16272247f, -0.00213571f, 0.12691547f, 0.19911820f, -0.40314540f, -0.14485100f, 0.10505830f, 0.15890984f, 
    -0.07077701f, -0.15596120f, 0.13189955f, 0.09683810f, 0.21863908f, 0.09008745f, 0.06297800f, 0.16072531f, 
    0.04269828f, 0.05383293f, 0.09048928f, -0.18518831f, -0.07414918f, -0.05298088f, 0.14932482f, 0.09063977f, 
    -0.02001643f, -0.01146547f, 0.07697631f, -0.06705397f, 0.38206926f, -0.19275774f, -0.21974991f, 0.39571431f, 
    0.25184697f, -0.02003475f, 0.32037479f, 0.23029681f, -0.08415660f, -0.05452663f, -0.05109508f, -0.00710585f, 
    -0.28572044f, -0.06484430f, 0.19583249f, 0.00843373f, 0.00949766f, -0.04906932f, -0.15108892f, -0.17803794f, 
    0.10043400f, 0.32978708f, 0.38101944f, 0.10959247f, -0.37018669f, -0.24632876f, 0.38446897f, 0.25494710f, 
    -0.10653318f, -0.06007516f, 0.04068556f, -0.06662126f, 0.18784115f, 0.04343338f, 0.04750325f, 0.02957311f, 
    0.08466285f, 0.07665266f, 0.24915729f, -0.17207269f, 0.11545373f, 0.25557122f, 0.13110431f, 0.11971415f, 
    0.13264303f, -0.09939049f, -0.01266831f, 0.02377380f, -0.05166349f, -0.34338835f, 0.41458884f, -0.04434378f, 
    0.04882497f, 0.08935528f, -0.02116665f, 0.28611124f, -0.01695258f, -0.01868468f, -0.07615443f, -0.10332305f, 
    -0.26278162f, -0.23611605f, 0.16272385f, 0.14529315f, -0.02176296f, -0.13822532f, 0.13573967f, 0.06325881f, 
    0.08785103f, 0.10075500f, -0.02640794f, -0.03568330f, 0.20187628f, -0.40750054f, -0.15345238f, 0.18339333f, 
    0.08708983f, -0.13129152f, -0.08885615f, 0.02273508f, 0.03287087f, -0.08882779f, 0.00041411f, 0.32526371f, 
    0.56103063f, 0.02923926f, 0.02063156f, -0.04114712f, 0.02159256f, -0.05883365f, 0.03628299f, -0.13104312f, 
    -0.01182520f, -0.00936198f, -0.07111431f, -0.03969940f, 0.44454914f, -0.42428172f, 0.13176559f, 0.17656092f, 
    -0.10155629f, -0.04470374f, 0.22293897f, 0.00704690f, 0.03112594f, 0.03867409f, -0.04339164f, -0.17921893f, 
    0.02102318f, -0.06677128f, 0.16600192f, 0.07125056f, 0.24705707f, 0.11757515f, 0.16718042f, 0.17658967f, 
    0.10125406f, -0.02288588f, -0.08265731f, -0.07916676f, -0.19699834f, 0.03910319f, 0.22681519f, 0.32564339f, 
    -0.07955015f, -0.11311504f, 0.10275473f, 0.00764118f, -0.01482071f, -0.00625380f, 0.07054207f, -0.08949092f, 
    -0.35044083f, 0.57350516f, 0.68300486f, -0.35885561f, 0.00977140f, 0.03784671f, 0.27107015f, 0.35923925f, 
    -0.05703008f, 0.08412895f, 0.22333838f, 0.27912495f, -0.15924846f, -0.09952150f, 0.23006475f, 0.08480014f, 
    0.03446088f, 0.02712351f, -0.07310856f, -0.09061535f, -0.08605384f, -0.08554684f, -0.04478505f, -0.13110989f, 
    0.01557449f, -0.06152467f, -0.00963133f, 0.05590432f, -0.00649241f, 0.01536035f, -0.06815256f, 0.00426497f, 
    -0.04560651f, 0.04041759f, -0.06545582f, 0.05114875f, -0.00084390f, 0.01724694f, -0.05947820f, -0.07377516f, 
    -0.03119652f, -0.06855667f, -0.02212733f, -0.06993792f, -0.03698412f, -0.00200458f, -0.01610292f, 0.05221365f, 
    -0.05047454f, -0.05404153f, 0.02651622f, -0.02694661f, -0.00077947f, 0.02218148f, 0.01658869f, 0.02081109f, 
    -0.00807927f, 0.00768275f, -0.05355743f, 0.02922894f, 0.01831632f, -0.07688794f, -0.04126509f, -0.02120456f, 
    0.05217426f, 0.05838455f, -0.01745972f, -0.07243095f, -0.05762023f, 0.04526584f, 0.01300224f, -0.03438835f, 
    0.05403857f, -0.00378185f, -0.05804802f, -0.03116076f, 0.00243942f, -0.04422552f, 0.01863615f, 0.04169590f, 
    0.02956345f, -0.07696705f, -0.04656108f, -0.04154804f, 0.07047557f, -0.01677578f, -0.00893421f, 0.05831803f, 
    0.06503150f, 0.01941231f, -0.04744593f, 0.01519621f, -0.05129265f, -0.01114953f, -0.01297639f, -0.02459811f, 
    -0.02687434f, -0.07476928f, -0.04382934f, 0.06196942f, 0.03114050f, -0.02134917f, -0.00195056f, 0.04840335f, 
    0.05262767f, -0.06532406f, -0.03586406f, -0.07203951f, 0.04607613f, -0.01194165f, -0.03921989f, -0.03617471f, 
    -0.07496613f, 0.03204490f, 0.06387995f, -0.02500009f, -0.07634758f, -0.03451775f, -0.07109851f, -0.04480536f, 
    -0.04532158f, -0.05349539f, 0.00902043f, -0.02461939f, 0.00059639f, 0.03246268f, 0.02766317f, -0.04311066f, 
    -0.03667239f, 0.01764721f, 0.01747001f, -0.06477167f, -0.05644383f, 0.02015305f, 0.05045003f, -0.03927376f, 
    -0.02505749f, -0.07180760f, 0.00862262f, 0.03654981f, -0.05321877f, 0.00789683f, 0.04504973f, 0.06500841f, 
    -0.07308047f, 0.01161885f, -0.01098663f, 0.06614019f, -0.04697265f, 0.04791869f, -0.02673363f, -0.00639192f, 
    0.06481757f, -0.06247626f, -0.01532822f, 0.04151466f, -0.02151895f, 0.00451882f, -0.05657777f, 0.06537531f, 
    -0.04505841f, -0.06974132f, 0.01291682f, 0.02008738f, -0.06857266f, 0.06471182f, -0.02649784f, -0.06757934f, 
    0.02012911f, 0.04130314f, -0.03344898f, -0.07396329f, -0.06854821f, -0.01617889f, 0.00723570f, 0.03897002f, 
    -0.06288473f, -0.05716798f, 0.02461916f, -0.06478880f, 0.04166175f, 0.04563786f, 0.03441006f, -0.06404024f, 
    0.01196438f, -0.02394416f, -0.00809823f, -0.04659527f, 0.02311682f, -0.02330006f, 0.05230569f, -0.06160632f, 
    -0.01815034f, -0.06425244f, -0.06309248f, 0.04684781f, 0.05749866f, -0.03659540f, -0.01809461f, -0.02762021f, 
    0.00033815f, -0.05154969f, -0.07292572f, -0.00362513f, -0.01233674f, 0.01582053f, 0.05110434f, 0.02661165f, 
    -0.01640240f, 0.02259400f, 0.04193638f, -0.01190817f, 0.00284142f, 0.05440028f, 0.03934798f, 0.05552585f, 
    -0.50299984f, 0.53266060f, 0.13529223f, 0.33430672f, 0.00389040f, 0.14812836f, 0.15570256f, 0.05051319f, 
    -0.06635097f, 0.13392450f, 0.02364363f, -0.08285808f, 0.42605457f, -0.02071804f, 0.37940490f, 0.14865769f, 
    0.08970407f, 0.09037102f, 0.16696447f, -0.09354776f, 0.01571167f, 0.24157143f, -0.07344566f, 0.08349208f, 
    0.10556302f, 0.07258467f, 0.10244853f, -0.11217493f, -0.08187889f, -0.03509404f, 0.06080536f, -0.08968432f, 
    -0.09910091f, 0.12249663f, -0.07855926f, -0.12721536f, -0.07098856f, -0.32354414f, 0.50882119f, -0.24046738f, 
    0.01849899f, -0.13038532f, 0.02597861f, 0.07362556f, -0.04297216f, 0.10491038f, -0.12039199f, -0.03487442f, 
    0.45785162f, 0.15467827f, 0.22554958f, -0.23027460f, -0.01675506f, 0.00014825f, -0.19987941f, -0.15390414f, 
    -0.15133414f, 0.09629229f, -0.13669713f, 0.10495371f, -0.28633076f, 0.01760798f, -0.33551788f, 0.30136985f, 
    0.16572306f, -0.07653946f, 0.01929810f, -0.09095020f, -0.04709378f, 0.09093375f, -0.16021577f, 0.09639387f, 
    0.07998394f, -0.00687863f, 0.01400641f, -0.00745952f, -0.10818193f, 0.11797211f, -0.26754466f, 0.05951314f, 
    -0.21457221f, 0.09497506f, -0.03577811f, 0.02993801f, -0.30877283f, 0.00726839f, -0.40496761f, 0.29108930f, 
    -0.11823294f, 0.09451845f, 0.04820448f, -0.04713963f, -0.07480869f, -0.17714220f, -0.12910447f, -0.16332990f, 
    -0.02482353f, -0.46377927f, -0.12456784f, 0.22126377f, 0.00648685f, -0.07102410f, -0.04792459f, -0.02688657f, 
    -0.15288301f, -0.04599040f, 0.02519160f, -0.09910232f, -0.17009361f, 0.22199757f, -0.25814080f, 0.31998008f, 
    0.11613137f, 0.09588474f, -0.08222307f, 0.09817790f, -0.16718750f, 0.08446773f, -0.00665412f, 0.07928866f, 
    0.17726707f, 0.57614768f, -0.09126610f, 0.15194711f, -0.15114181f, -0.02809390f, -0.20945057f, 0.06710991f, 
    -0.04986654f, -0.08506802f, 0.16509795f, -0.12760073f, -0.35798395f, 0.51440364f, -0.53163588f, 0.47433934f, 
    -0.12376904f, 0.00378816f, 0.09051327f, 0.09861915f, -0.00972429f, 0.11712449f, 0.17623918f, 0.04577680f, 
    -0.23734351f, -0.00023198f, -0.01820837f, 0.19808519f, 0.18213779f, 0.12782457f, 0.15968300f, 0.06408069f, 
    0.10536645f, 0.10133388f, 0.15250900f, -0.00291309f, -0.35496211f, -0.44716793f, -0.02370614f, -0.16347249f, 
    0.09587255f, -0.07591413f, 0.18377143f, -0.38274640f, 0.08051535f, -0.01008484f, -0.01837997f, 0.17971589f, 
    0.53819215f, -0.15836667f, 0.49177933f, 0.40739718f, 0.02318167f, 0.08427390f, 0.17443092f, -0.01307721f, 
    0.07192428f, 0.08733950f, 0.01873179f, 0.12534389f, -0.18180071f, 0.46639726f, -0.49023142f, 0.22864585f, 
    0.01595336f, 0.08747049f, -0.06604394f, -0.07367281f, -0.06735183f, -0.14405438f, 0.05827361f, 0.08894464f, 
    -0.03660863f, 0.01121843f, -0.05921872f, 0.05953284f, 0.06619596f, 0.03468518f, 0.26956728f, 0.23623200f, 
    0.15313479f, -0.22103810f, -0.09488247f, 0.01616566f, 0.12940884f, 0.14654765f, 0.16010068f, -0.02844792f, 
    0.14231166f, 0.13342921f, 0.13447200f, 0.03951800f, 0.01954535f, -0.08392343f, -0.07247134f, 0.10116524f, 
    -0.16446638f, -0.09189354f, -0.03902649f, -0.01739866f, 0.01168945f, 0.03291833f, 0.02453234f, 0.06461552f, 
    -0.00127813f, 0.00922457f, 0.11242060f, 0.04562840f, -0.19894814f, 0.14018036f, 0.06879269f, -0.15476808f, 
    0.20508710f, -0.17369427f, -0.31105807f, 0.08680388f, 0.12092719f, -0.03044952f, 0.06613780f, 0.00908928f, 
    -0.19123448f, -0.18805237f, 0.06734378f, -0.23089252f, -0.01399658f, 0.02495408f, 0.07024520f, 0.02321235f, 
    -0.00676060f, 0.24145854f, 0.20418283f, 0.17507562f, 0.52542228f, 0.24743128f, 0.23308779f, -0.19560759f, 
    0.02219332f, 0.04684932f, 0.25432685f, 0.06064545f, 0.19247365f, 0.06923842f, -0.02895014f, 0.07161572f, 
    0.09799251f, -0.08738671f, -0.19082543f, -0.03033579f, 0.14667974f, -0.17633222f, -0.05573750f, 0.00814934f, 
    0.10834488f, -0.02606012f, -0.04506193f, -0.03120018f, 0.45110047f, 0.20978530f, 0.37152943f, 0.01628883f, 
    0.13484901f, -0.26942486f, 0.31821030f, 0.04259793f, -0.00154071f, -0.07182162f, 0.07460917f, 0.09428389f, 
    0.10399587f, 0.23644418f, -0.12934606f, -0.06298751f, 0.21405734f, 0.14026438f, 0.14738289f, 0.11546582f, 
    -0.06782754f, -0.07974306f, 0.10867559f, -0.01173564f, -0.27291363f, -0.11294594f, 0.16450521f, -0.18231899f, 
    -0.02144387f, -0.04687500f, 0.00366863f, 0.05238530f, 0.06694775f, 0.07525769f, 0.10410886f, -0.07939856f, 
    -0.24762930f, -0.28165233f, -0.09646555f, -0.03533362f, 0.08298223f, -0.11927620f, -0.02054030f, 0.05569887f, 
    -0.04207844f, -0.15198493f, 0.00353996f, 0.13656186f, 0.58617276f, -0.30452409f, -0.01386170f, -0.39814025f, 
    0.16172157f, -0.11644524f, 0.08274449f, 0.03122814f, 0.00656512f, -0.07005396f, -0.03128820f, -0.01763615f, 
    0.08266218f, 0.26196238f, -0.08289018f, 0.10903084f, 0.06823470f, 0.15324743f, 0.27377084f, -0.34637526f, 
    0.10847460f, -0.07376475f, 0.03304625f, 0.19060433f, 0.16849628f, 0.48346984f, 0.12063445f, -0.40790212f, 
    -0.13423048f, 0.03277680f, 0.04351653f, 0.12427460f, -0.15027247f, 0.19610578f, 0.04338011f, -0.03104740f, 
    -0.14425047f, -0.33470494f, 0.05570865f, -0.59365404f, 0.29860166f, 0.10572767f, -0.58024514f, -0.01300534f, 
    -0.16608450f, 0.10138302f, 0.14104693f, -0.09852144f, 0.20099849f, -0.74330425f, 0.20723832f, -0.19408058f, 
    -0.18822430f, -0.16632184f, 0.06809615f, 0.03974535f, -0.12016521f, 0.08796464f, 0.12580891f, -0.05267513f, 
    -0.32136029f, -0.35961360f, 0.00898035f, -0.02425542f, -0.00390128f, -0.16603653f, -0.20013987f, 0.06718355f, 
    0.06318373f, -0.16705292f, 0.15667684f, 0.11696325f, -0.31890482f, 0.22227351f, -0.02668992f, 0.06444343f, 
    0.12757815f, 0.09587348f, 0.03378296f, 0.21904571f, 0.13985713f, -0.25815490f, -0.06877080f, -0.17838426f, 
    -0.28348234f, -0.02854021f, -0.04697875f, 0.21128400f, 0.00789212f, 0.02924629f, -0.13704084f, -0.12674242f, 
    0.29772431f, -0.00242320f, 0.10348702f, 0.12148573f, 0.07309991f, 0.05155816f, -0.67926621f, 0.33793214f, 
    0.04430159f, 0.25134304f, 0.21631229f, 0.08922931f, -0.18855643f, -0.11119263f, 0.01954536f, -0.23498935f, 
    -0.02004625f, 0.08492977f, -0.06168169f, 0.04182677f, -0.03781419f, -0.08618787f, -0.11295782f, -0.12400704f, 
    0.04714139f, -0.35756716f, -0.09670882f, -0.11061760f, -0.06455784f, 0.14520128f, 0.34355557f, -0.25574020f, 
    0.15281089f, 0.20637397f, 0.08613671f, 0.02555720f, -0.02653540f, -0.19991554f, 0.14709136f, 0.05168223f, 
    -0.11023764f, -0.24709694f, -0.20568591f, -0.05060388f, 0.28679535f, 0.14561689f, 0.44142935f, -0.01660381f, 
    0.25426641f, 0.02473749f, -0.11162475f, 0.15457416f, -0.00693283f, 0.04103281f, 0.01645087f, -0.30259049f, 
    0.11100035f, 0.04904353f, 0.17798446f, 0.21070234f, 0.18004090f, 0.04225749f, -0.06953718f, 0.20522889f, 
    0.04596474f, 0.18432841f, 0.19447121f, -0.18036647f, 0.23348895f, 0.23323406f, 0.17667051f, -0.01629044f, 
    0.00529485f, -0.03308654f, 0.05774380f, 0.13095964f, 0.03229438f, -0.21489903f, 0.23470919f, -0.06942432f, 
    -0.15864894f, -0.23031235f, -0.00919995f, -0.18197741f, 0.17582382f, 0.12323996f, 0.25267762f, 0.32528326f, 
    -0.08206702f, -0.19604933f, 0.14527096f, 0.25232852f, 0.16609201f, -0.08916656f, 0.08549732f, -0.02059879f, 
    -0.19419631f, -0.04794548f, -0.25416139f, -0.08927099f, 0.41720060f, -0.40318045f, 0.06737309f, -0.13068034f, 
    0.13329987f, 0.24368854f, 0.06335844f, 0.01171147f, 0.11676035f, -0.12920195f, 0.07454929f, 0.18896259f, 
    0.02150660f, 0.05822980f, -0.01547449f, 0.17573242f, 0.22940773f, 0.31132719f, -0.00411582f, 0.13061349f, 
    0.03179845f, 0.07427876f, 0.07867105f, 0.26794031f, 0.10758897f, 0.26240999f, 0.03239779f, -0.01196663f, 
    0.01750395f, 0.11441885f, -0.04337192f, 0.15917917f, -0.17847943f, -0.08916457f, 0.08078229f, -0.10064572f, 
    0.12349444f, 0.14498091f, -0.44832438f, -0.58892578f, -0.05263814f, 0.06287839f, 0.00180832f, 0.19167851f, 
    0.26659164f, 0.15247653f, 0.04059652f, -0.08223590f, -0.12857741f, 0.07277750f, 0.20558436f, -0.24765237f, 
    -0.18872030f, -0.21970867f, -0.12245073f, -0.08079017f, 0.04781848f, 0.05024954f, -0.03766215f, -0.15656236f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00609703f, 0.06705553f, -0.21855225f, -0.05194171f, 0.23753646f, 0.00177107f, 0.00091925f, -0.05922697f, 
    -0.06310902f, 0.01594183f, 0.01855690f, 0.16168450f, 0.09454562f, 0.36066559f, 0.34503061f, -0.06149836f, 
    0.32198533f, -0.01673642f, -0.03504711f, 0.18923762f, 0.02479235f, -0.33516252f, 0.03859537f, 0.23819806f, 
    0.12937981f, 0.00826690f, -0.04191558f, 0.28254756f, -0.05358157f, 0.18331598f, 0.04534186f, 0.24671870f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11558252f, -0.09468012f, -0.08549050f, -0.65031260f, 0.14938410f, 0.10203532f, 0.31152654f, -0.09094070f, 
    -0.12319299f, -0.16616869f, 0.39791331f, -0.42117453f, 0.29998377f, -0.31445503f, -0.42426440f, 0.07345846f, 
    -0.15350151f, -0.28350016f, 0.05183280f, -0.73368180f, 0.00976439f, 0.38289902f, -0.10021428f, 0.18755832f, 
    -0.10469437f, -0.05359706f, -0.05733062f, -0.68337280f, -0.05689166f, -0.29304770f, 0.38872048f, -0.22550529f, 
    -0.12188435f, -0.32676473f, -0.22637825f, 0.26941624f, 0.22881538f, -0.08691470f, 0.34452006f, 0.11707480f, 
    -0.00971681f, 0.32745069f, -0.12948234f, -0.60021824f, 0.16521001f, 0.52185279f, 0.07944839f, 0.33557850f, 
    0.08115479f, 0.05373042f, -0.26524216f, -0.57784009f, 0.46767277f, -0.79525524f, 0.15784346f, 0.22586237f, 
    0.11198758f, -0.05571861f, -0.04279144f, -0.19732419f, 0.05626314f, 0.30751044f, 0.20109968f, -0.09358405f, 
    0.22867192f, -0.30246627f, -0.03694633f, 0.19384453f, 0.16950710f, 0.16306275f, -0.12297636f, 0.00506807f, 
    0.02137337f, -1.02156329f, -0.39565712f, 0.30884886f, 0.25242767f, -0.85193789f, 0.15512149f, -0.32091570f, 
    0.28659162f, -0.33624765f, 0.32154170f, 0.19784024f, -0.59272814f, -0.21862842f, -0.16757087f, -0.08399373f, 
    -0.50558358f, -0.01714421f, -0.16089675f, 0.03723725f, 0.05452371f, 0.52107882f, 0.05922534f, -0.28105307f, 
    0.38512585f, 0.07331584f, 0.06741149f, 0.01106025f, -0.24863303f, 0.07796714f, -0.38310066f, 0.01670781f, 
    -0.14773892f, -0.29644832f, -0.14072086f, 0.25063068f, -0.23805608f, -0.94769675f, -0.54819721f, 0.17410600f, 
    -0.60558248f, 0.33572850f, 0.11271594f, 0.39521191f, -0.01941925f, 0.34383431f, -0.04907473f, 0.06345101f, 
    -0.00100249f, 0.07850453f, -0.08481699f, -0.37317228f, 0.10392390f, 0.35074756f, -0.28821698f, -0.25540692f, 
    -0.19213073f, 0.33907253f, 0.46796128f, -0.16350876f, -0.22911906f, 0.03785571f, -0.29543987f, 0.16409802f, 
    -0.02792319f, -0.64125943f, 0.00681807f, -0.39676031f, 0.14639479f, 0.05687993f, -0.03571703f, 0.10335357f, 
    -0.24923334f, -0.09804969f, 0.60646373f, -0.22756298f, 0.14386365f, 0.18834358f, -0.04788622f, -0.58929986f, 
    0.13612950f, -0.10715743f, 0.14437856f, 0.00868193f, -0.03401609f, -0.55089140f, 0.06950516f, -0.09683792f, 
    -0.33031040f, 0.24725407f, -0.00924008f, -0.42710844f, 0.16070631f, 0.08818372f, -0.18559420f, -0.05878134f, 
    -0.00104909f, 0.34077039f, 0.14032350f, 0.33306825f, 0.10047827f, -0.46148574f, 0.08627382f, 0.13616939f, 
    0.00922380f, 0.14520016f, -0.51891667f, -0.27208588f, -0.45383877f, -0.37840924f, 0.05355948f, 0.11466771f, 
    0.12146235f, -0.06598802f, -0.15017104f, -0.04749039f, -0.17501499f, -0.55015969f, 0.10603395f, 0.71245772f, 
    -0.54854435f, 0.06381720f, 0.20586109f, -0.62008089f, -0.30372307f, 0.05922652f, 0.15751474f, -0.08099143f, 
    -0.09604470f, 0.24127696f, -0.97243518f, -0.30131716f, -0.07550890f, 0.20402659f, 0.44207010f, -0.75115961f, 
    0.26492950f, -0.39106378f, 0.35012493f, 0.25421828f, -0.22455963f, -0.51070958f, -0.11206622f, -0.10019872f, 
    -0.39992687f, 0.11447186f, 0.09674638f, 0.01988869f, -0.11981999f, 0.40183067f, -0.36671153f, -0.21183363f, 
    -0.31404617f, -0.27145171f, 0.13446753f, 0.57041723f, -0.01889106f, 0.15076198f, -0.09765297f, 0.04418192f, 
    0.09988786f, 0.17479895f, -0.14730430f, 0.02033980f, 0.26208115f, -0.14126471f, -0.36450467f, -0.42548573f, 
    -0.15034047f, 0.39877731f, -0.19683452f, 0.23637146f, 0.27477750f, 0.48034340f, 0.11232831f, -0.26154494f, 
    -0.27865019f, 0.05493348f, 0.03835839f, -0.01592580f, -0.07659577f, -0.87536424f, -0.34364107f, -0.37211916f, 
    -0.65818048f, -0.64439243f, -0.38146290f, 0.43531847f, 0.05415252f, 0.00540925f, 0.23792098f, -0.12718779f, 
    0.09476336f, -0.28857118f, 0.33852831f, 0.53640437f, -0.63964540f, 0.00210502f, -0.47906977f, -0.63224274f, 
    -0.31851572f, 0.07085627f, -0.35857043f, 0.41652840f, -0.29748839f, -0.35738638f, -0.11814436f, 0.27030197f, 
    0.31081080f, -0.01179805f, 0.17253518f, 0.18121955f, -0.06382255f, -0.01445236f, 0.19177787f, 0.12498415f, 
    -0.13060850f, -0.33462626f, -0.30977726f, -0.41382670f, -0.77854246f, -0.13465635f, -0.40922946f, 0.07005323f, 
    -0.03466137f, 0.05594880f, 0.20740823f, -0.40432411f, 0.39039806f, -0.01845130f, 0.18297376f, -0.21640186f, 
    0.28938138f, -0.61651552f, 0.43221807f, 0.14158058f, 0.29579934f, 0.14433521f, -0.16894427f, -0.53191131f, 
    -0.17046450f, 0.08568481f, 0.05602873f, 0.21851240f, -0.08264126f, -0.71184635f, 0.12055249f, 0.32304069f, 
    0.04200497f, -0.20167300f, 0.35576135f, 0.34831467f, -0.57830447f, 0.06426437f, 0.56355065f, -0.04599950f, 
    0.10115568f, -0.30391291f, 0.25190353f, 0.46177003f, -0.04632519f, -0.43885189f, 0.31238052f, 0.27427918f, 
    -0.29146668f, -0.33987460f, -0.75994086f, 0.17549071f, 0.47783282f, -0.48957783f, 0.08434936f, -0.51642954f, 
    0.38155451f, -0.07731222f, -0.09300400f, -0.35798672f, -0.11451532f, 0.31761095f, -0.71398985f, -0.11656964f, 
    0.47554496f, 0.12014243f, -0.13181683f, -0.29743636f, 0.20604900f, 0.09484461f, -0.61193860f, 0.12411788f, 
    -0.08777294f, 0.02477839f, -0.40386939f, -0.24036014f, -1.05812836f, -0.26370484f, 0.41483480f, -0.40194428f, 
    -0.39887887f, -0.07313513f, -0.36703444f, 0.19748361f, 0.07950831f, 0.10009597f, 0.07931439f, 0.13372745f, 
    0.26899070f, -0.17127316f, 0.15602690f, 0.32665125f, 0.08874208f, 0.51629478f, -0.39039820f, -0.46609923f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21840450f, 0.12511444f, 0.16815224f, -0.34822592f, -0.01208189f, -0.06449275f, -0.06979336f, -0.02916976f, 
    0.20955843f, 0.11937320f, -0.06441601f, 0.15030476f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
