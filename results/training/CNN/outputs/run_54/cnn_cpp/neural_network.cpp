#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.12950814f, 0.86308116f, 0.52422464f, -0.25136280f, -0.35360554f, -0.13616107f, -0.33860171f, -0.42633075f, 
    -0.06015697f, 0.14353515f, 0.47404432f, 0.55026942f, 0.11768277f, 0.33194754f, -0.02883369f, 0.28809810f, 
    0.37398791f, 0.52109492f, 0.52766448f, 0.35685641f, 0.11846338f, 0.04363947f, -0.22083665f, 0.00213334f, 
    0.67092890f, -0.31340995f, 0.50371575f, -0.59741902f, 0.85818899f, -0.52583992f, 0.63576591f, 1.20835185f, 
    -0.64229470f, 0.64786482f, 0.36260745f, 0.26523408f, 0.13918161f, 0.18542026f, -0.09872095f, 0.60020941f, 
    -0.35985231f, -0.51441306f, 0.39526081f, -0.09464612f, -0.03516862f, 0.02127585f, 0.27567649f, 0.08433466f, 
    0.36321607f, 0.15200970f, 0.37082076f, 0.79005975f, -0.57893449f, 0.75116014f, 0.30243698f, -0.38860562f, 
    -0.59877771f, 0.28325579f, -0.12602432f, 0.17764665f, -0.61624223f, -0.36775884f, 0.03433071f, 0.23768084f, 
    -0.40810192f, -0.19559127f, 0.20044886f, 0.59072256f, -0.03958564f, -0.25970349f, -0.29377139f, -0.14562471f, 
    -0.53753078f, -0.40955755f, -0.46143863f, 1.18716764f, 0.91816497f, 0.60612643f, 0.29426292f, 0.01390749f, 
    -0.49734014f, -0.09893948f, 0.15923861f, 0.30705899f, -0.30430794f, -0.13099164f, -0.16673231f, 0.28222173f, 
    0.38117096f, -0.17364439f, 0.38978028f, -0.52028579f, -0.05493991f, -0.15529136f, -0.01955651f, -0.44691262f, 
    -0.32860029f, 0.28270096f, -0.26015523f, -0.21317065f, -0.49248424f, -0.09629785f, 0.25248533f, -0.35798430f, 
    -0.27242011f, -0.86249000f, -0.30769318f, 0.92440641f, -0.38352168f, 0.14920492f, -0.45199716f, -0.33444372f, 
    0.15995032f, -0.39009812f, -0.49613318f, 0.33615384f, -0.35588095f, -0.46344337f, -0.21813872f, -0.02576451f, 
    -0.23447597f, 0.34026051f, -0.42960048f, 0.18854716f, -0.05587932f, -1.10470235f, 0.33014891f, 0.69520301f, 
    0.59433496f, -1.08986247f, -0.08366073f, 0.74477577f, -0.80136502f, 0.11368924f, 0.45624989f, -0.13206677f, 
    -0.27129886f, -0.30816874f, -0.32943982f, 0.03053043f, 0.02968228f, 0.04151686f, -0.14328748f, 0.00430592f, 
    0.06417069f, -0.09409528f, -0.06684574f, -0.03023928f, -0.07362938f, 0.15276329f, -0.64974558f, -0.52280575f, 
    -0.92641222f, -0.81842071f, -0.54817098f, -0.71481556f, -0.06235200f, 0.36929688f, 0.34545633f, 0.57922059f, 
    0.35148975f, 0.26977420f, 0.02069552f, -0.18809633f, 0.27220997f, 0.29104623f, -0.01375037f, 0.11432429f, 
    0.17814527f, -0.05092184f, -0.32645056f, -0.28488770f, 0.27863419f, 0.05552657f, -0.07971330f, -0.46346411f, 
    0.83977592f, 0.73290831f, -0.50555474f, 0.01132968f, -1.35197687f, 0.03122442f, -0.67702460f, -0.82004553f, 
    -0.43403569f, 0.20008020f, 0.40851229f, -0.33914530f, 0.21405065f, 0.18814917f, -0.00228403f, -0.44826868f, 
    -0.45050159f, -0.24086638f, 0.32796100f, 0.27411515f, 0.40589845f, 0.26542419f, 0.38421366f, 0.03898177f, 
    1.12079287f, 0.70744646f, 0.81872272f, 0.94538802f, 1.21365297f, 0.69708383f, -0.12642775f, -0.12754241f, 
    -0.12751067f, -0.19290890f, -0.11836336f, 0.35724232f, -0.17034534f, 0.09849680f, -0.03376967f, -0.05099045f, 
    -0.11476787f, -0.19253217f, 0.10182412f, -0.06681792f, -0.14666705f, 0.21706453f, 0.24380757f, -0.26300797f, 
    0.26593107f, 1.20666921f, -0.05230698f, 0.02360017f, 1.21192098f, 0.45433396f, 0.44892794f, 0.31474695f, 
    -0.54362732f, 0.03256053f, 0.30851969f, -0.70159847f, -0.22276957f, -0.20874211f, -0.25395429f, -0.22451387f, 
    -0.20760503f, -0.05309073f, 0.10397851f, -0.10753769f, -0.05355813f, 0.39026982f, 0.02094391f, -0.08166316f, 
    -0.02509762f, 0.12276441f, 0.48265809f, -0.93634892f, 0.08572485f, 0.74742705f, -0.34195426f, -0.84357721f, 
    -0.52023357f, -0.34314883f, 0.42226505f, 0.01814859f, 0.38699585f, -0.26014480f, -0.16714336f, 0.00224509f, 
    -0.17280842f, -0.02633114f, 0.07946596f, -0.15331747f, 0.17948905f, 0.30818528f, 0.05084592f, 0.19526485f, 
    0.15087622f, 0.33958757f, 0.64246446f, -0.27737799f, 0.15712444f, 0.36060140f, 0.53220958f, -0.91259706f, 
    0.63500112f, 0.90593672f, 0.57737279f, 0.62532246f, 0.45580232f, -0.06976782f, -0.31877181f, 0.18447952f, 
    -0.37723491f, -0.65688437f, 0.33637792f, 0.25291574f, -0.01070700f, -0.42307472f, -0.30569172f, 0.21744518f, 
    -0.04055417f, 0.11526749f, -0.03235066f, 0.21645541f, -0.79373920f, -0.14453933f, 0.38092673f, -0.58843327f, 
    0.00152062f, 0.67863810f, -0.66674477f, -0.05318891f, 0.25877118f, -0.63546854f, -0.00441522f, -0.38031399f, 
    0.34306487f, 0.44972986f, -0.22587048f, 0.13747443f, 0.38808575f, 0.33988366f, 0.43235281f, -0.33224642f, 
    -0.19661970f, -0.17869538f, -0.01669716f, 0.33625102f, 0.67369920f, 0.65054297f, 0.80296761f, 1.02647567f, 
    -0.16493410f, -0.59996527f, 0.07229947f, -0.62675327f, 0.28374138f, 0.17910658f, 0.91386694f, 0.22427741f, 
    0.62523246f, -0.39923015f, -0.36295426f, 0.05671534f, 0.50370872f, 0.03814993f, -0.35982844f, -0.24239366f, 
    0.27723375f, 0.03576167f, -0.20439123f, 0.55393553f, -0.50214922f, 0.08926748f, -0.20031132f, -1.48169124f, 
    -0.50813901f, 0.33989146f, 0.07482243f, -0.89463818f, 1.08409667f, 0.54095924f, -0.90437835f, 0.24876370f, 
    0.60875356f, 0.37890056f, -0.10978950f, -0.35348120f, -0.28641331f, -0.25931668f, -0.23100992f, 0.07106432f, 
    0.00669576f, -0.30484682f, 0.11925648f, -0.20723282f, 0.21681529f, -0.13981187f, 0.29069442f, 0.52876973f, 
    -0.57517850f, -0.86599946f, -1.12250566f, -0.35386306f, 0.37862581f, 0.79087871f, -0.26491654f, -0.75864822f, 
    0.35466802f, 0.28141105f, -0.38874245f, 0.59549236f, 0.14042048f, -0.03236735f, -0.24779709f, 0.20254903f, 
    -0.31544301f, 0.01356496f, 0.15410379f, 0.02997753f, 0.11136562f, 0.31122974f, 0.07764814f, 0.08082470f, 
    -0.51847953f, -0.59155738f, -0.41104445f, 0.02113930f, 0.40873113f, 0.01150685f, 0.62454361f, 0.02607106f, 
    -0.09411034f, 0.83382714f, -0.63321924f, 0.23202170f, -0.11104513f, 0.00927015f, 0.09497791f, -0.44045496f, 
    -0.00120001f, 0.42219803f, -0.21652682f, -0.28921902f, -0.08560707f, -0.65116012f, -0.30916017f, -0.00364114f, 
    0.13002363f, 1.36201978f, 0.58111167f, -1.08108222f, 0.48780191f, -0.70485348f, -0.46073684f, -0.32710543f, 
    -0.34225112f, 0.17476270f, -0.28663927f, 0.09058559f, 0.05700077f, 0.65896243f, 0.24803115f, 0.15984476f, 
    0.29206896f, -0.45760995f, -0.31078589f, 0.24359858f, 0.29956710f, 0.44261310f, 0.10799406f, 0.01097476f, 
    -0.34724191f, 0.15106162f, -1.52404463f, 1.72803640f, 0.07520632f, -1.05256009f, 0.24387710f, -0.21474864f, 
    0.77302271f, 0.46006563f, -0.11742800f, 0.40314063f, -0.28579405f, 0.00687997f, 0.31511030f, -0.11796102f, 
    0.20649840f, 0.03471916f, -0.21483558f, 0.02769158f, 0.09425878f, -0.22800133f, 0.26024702f, 0.31343308f, 
    0.05233059f, 0.23683952f, 0.13947091f, -0.84210980f, -0.99277359f, -1.28311145f, -0.25325108f, 0.53361088f, 
    -0.77750880f, 0.62257630f, 0.63427997f, 0.17432381f, 0.03401934f, 0.23879303f, -0.36200932f, -0.09453075f, 
    -0.21566625f, 0.42338577f, 0.25936756f, 0.38327807f, -0.36950395f, 0.17023900f, -0.09064572f, 0.03810340f, 
    -0.27579114f, -0.03299475f, 0.01552291f, 0.46670747f, 0.84897882f, -0.13398370f, -0.92233467f, -0.81186420f, 
    0.37527257f, 0.64668584f, -0.75498652f, 0.17075269f, 0.67865813f, 0.49859768f, -0.57804579f, -0.31425729f, 
    -0.41895205f, -0.30647922f, 0.05094051f, -0.32830757f, -0.21797088f, -0.44691542f, -0.20443095f, -0.12019992f, 
    -0.19833694f, -0.03738401f, -0.01245695f, -0.13102210f, -0.43915626f, -0.18697183f, -0.79070574f, -0.36498132f, 
    -0.42719200f, -0.03643048f, -0.33165601f, -1.12181973f, -0.12474216f, 0.20024413f, -0.56531525f, 0.30072409f, 
    0.49025297f, -0.20107034f, 0.38454995f, -0.43282917f, 0.29257590f, 0.22730972f, 0.56613737f, 0.18808132f, 
    -0.28931329f, 0.13085555f, 0.03188984f, -0.13394819f, -0.42949092f, 0.16131097f, -0.18794625f, -0.26613840f, 
    -0.82545292f, -0.77719402f, 0.34834352f, 0.08627980f, -1.08420038f, 0.80317587f, 0.70590049f, -0.38992330f, 
    -0.39240482f, -0.26069590f, 0.02257942f, -0.15548609f, -0.56207043f, 0.43399817f, 0.25987217f, -0.05730234f, 
    0.27259570f, 0.11768445f, -0.47976384f, -0.15623477f, 0.06421315f, 0.58267874f, -0.16803543f, 0.69168317f, 
    0.69543028f, -0.73263109f, -0.51125699f, -0.93510783f, -0.48721635f, 0.20135862f, -0.49367699f, -0.22935861f, 
    -0.70440429f, -0.45518208f, 0.04809908f, -0.16502878f, 0.43811560f, 0.03361057f, -0.07400496f, 0.36100039f, 
    -0.10636558f, 0.01088254f, -0.35517415f, 0.09357010f, -0.10709155f, 0.04776711f, -0.28633192f, 0.10070232f, 
    0.71436793f, -0.12965132f, 0.72599703f, 0.92597389f, 0.68314433f, -0.66254729f, 0.88976085f, -0.02833226f, 
    -0.85013163f, -0.20745708f, 0.25381076f, -0.32438421f, -0.56882340f, -0.20032896f, -0.32880697f, -0.51665115f, 
    0.13526091f, -0.06506015f, 0.09855037f, -0.22943696f, 0.08597950f, 0.43483624f, 0.26467621f, 0.12992522f, 
    0.04166584f, 0.10400509f, -0.76507872f, -0.18142793f, 1.14821970f, 0.73082876f, -1.16814220f, -0.73163211f, 
    0.00737999f, -0.74048698f, 0.46806067f, 0.14853528f, 0.66735286f, -0.16495052f, 0.10097232f, 0.19920447f, 
    -0.25783974f, 0.34047362f, 0.18361461f, 0.12189059f, 0.06047995f, 0.04742370f, 0.05606005f, -0.35517916f, 
    0.02283194f, -0.47966817f, -1.13572872f, -1.11619389f, 0.42011389f, 1.19000590f, -0.42696965f, 0.46203133f, 
    -0.47353631f, -0.08211642f, 0.03219044f, 0.03543751f, 0.35160840f, 0.07617284f, -0.27721062f, 0.34216049f, 
    0.28075671f, 0.28776687f, 0.40677255f, -0.20918629f, -0.19223292f, -0.17414106f, -0.00442009f, -0.10641094f, 
    0.20996362f, 0.00677464f, 0.00368402f, 0.98788476f, 0.56373531f, 0.71349686f, 0.06647572f, -0.00227767f, 
    -0.26975811f, -1.13988924f, 0.44578788f, 0.20661521f, 0.57381290f, 0.46686932f, 0.32296565f, 0.04652742f, 
    -0.31979579f, -0.17344679f, -0.56625307f, 0.21591380f, -0.14798689f, -0.37274119f, -0.21722817f, 0.21973296f, 
    0.04922922f, -0.00369688f, 0.36637318f, 0.24694483f, 0.54284966f, -0.79256749f, -0.93542141f, 0.37786740f, 
    -0.10934098f, -0.97337884f, 0.46260267f, 0.91648471f, -0.37564605f, -0.04554118f, -0.07856438f, -0.35303143f, 
    0.46554750f, -0.40725717f, 0.41602975f, -0.37586468f, -0.43672624f, -0.15985465f, -0.45172253f, -0.48424751f, 
    0.15696613f, 0.15756461f, -0.02240928f, 0.40677410f, 0.07126150f, 0.47921917f, 0.31991276f, 1.00038934f, 
    1.22542703f, 0.45983201f, 0.13377610f, 0.30167010f, 0.51420867f, 0.38399637f, 0.02375779f, -0.66292346f, 
    0.03847292f, -0.43127659f, 0.28349748f, -0.17873093f, 0.36922577f, 0.17068835f, -0.34902570f, 0.12550279f, 
    0.11083949f, 0.16714898f, -0.45924833f, -0.25563133f, -0.03196066f, -0.06331855f, 0.12347583f, 0.73659617f, 
    -0.55924845f, -0.35734600f, 0.89600956f, 0.76193106f, -1.10264337f, -1.08562994f, -0.45379588f, 0.11983905f, 
    0.48838407f, -0.37115934f, -0.01257043f, -0.08231567f, -0.15941472f, 0.02162462f, 0.14028053f, 0.04710360f, 
    -0.03021397f, 0.06711452f, 0.12470105f, -0.28147587f, 0.05316038f, -0.27774733f, -0.06185904f, 0.03680952f, 
    -1.23647952f, -0.94239199f, -0.33738703f, -0.65753525f, 0.58321887f, 1.14685953f, 0.45932147f, 0.43532270f, 
    0.64265043f, -0.39671719f, -0.02492536f, -0.36781877f, -0.16862865f, -0.36341465f, -0.30939800f, 0.04622075f, 
    0.34421650f, 0.16928914f, -0.07665010f, -0.20109637f, 0.19538490f, -0.22507989f, -0.27751505f, -0.09490485f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11677052f, 0.25985524f, -0.03636988f, 0.18400735f, 0.07907996f, 0.05808477f, 0.26964352f, 0.43123069f, 
    0.19418539f, 0.00507102f, 0.15055116f, -0.00338875f, 0.14232489f, 0.27209187f, 0.45132199f, 0.46743742f, 
    0.07637773f, 0.24102271f, 0.37018263f, 0.25672588f, 0.06448855f, 0.46470734f, 0.03078774f, 0.36157042f, 
    0.26521632f, 0.58575124f, 0.42556855f, 0.23295526f, 0.19799682f, 0.15969844f, 0.13827969f, 0.14149828f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01378824f, 0.23129238f, 0.20719911f, -0.18406367f, -0.02053954f, 0.00780923f, 0.02497384f, 0.18300410f, 
    0.14434688f, 0.06378008f, -0.06257553f, 0.07496481f, 0.42328054f, 0.19255129f, -0.02059137f, -0.05983165f, 
    -0.15357259f, 0.12820537f, 0.05478973f, -0.24210691f, -0.02145800f, 0.10354733f, -0.03880137f, 0.01036858f, 
    0.20472683f, 0.06122060f, 0.13103083f, 0.14373331f, -0.07701971f, 0.09234753f, 0.04572618f, 0.00350731f, 
    0.02619315f, 0.02611401f, -0.08415072f, 0.07800874f, 0.20847012f, 0.01146706f, -0.20124353f, -0.12858590f, 
    -0.36461568f, -0.13714336f, -0.15731892f, 0.13720854f, -0.07239296f, -0.03956932f, 0.02856807f, -0.11851022f, 
    -0.36216763f, -0.07723475f, 0.00230311f, 0.13911477f, -0.10392626f, 0.03443563f, -0.20553353f, 0.02941431f, 
    0.11447311f, -0.01600587f, 0.05720040f, -0.04558950f, 0.67745799f, 0.15626131f, 0.29620892f, 0.00981276f, 
    -0.10087363f, 0.09086914f, -0.08386365f, 0.07853543f, 0.05355876f, 0.07345885f, -0.03317712f, 0.07323954f, 
    -0.06842151f, -0.04817267f, -0.23787805f, -0.24962209f, 0.02737174f, -0.04770194f, 0.02538572f, -0.07230569f, 
    0.06520405f, -0.03695175f, -0.09296730f, -0.07212853f, -0.25940660f, -0.09386366f, 0.06111384f, -0.16486256f, 
    0.01472851f, 0.15691055f, -0.02922581f, 0.02925649f, 0.02642050f, -0.15011656f, -0.01245102f, -0.05596374f, 
    0.24846388f, -0.17809179f, -0.04478574f, 0.26977757f, -0.21929798f, -0.09696899f, -0.06068638f, 0.15965602f, 
    -0.02600606f, 0.01977275f, 0.00229483f, -0.10335618f, 0.24575101f, -0.07168256f, -0.13088162f, 0.61599094f, 
    -0.05344258f, 0.00809100f, 0.06885441f, 0.09870574f, -0.11394002f, 0.01782080f, -0.05013402f, 0.04196614f, 
    0.17906968f, -0.35488117f, -0.03666789f, 0.46129122f, 0.04363295f, -0.07075039f, -0.04960693f, -0.10867242f, 
    0.07852633f, -0.09711972f, -0.12453220f, -0.06970689f, 0.40198398f, 0.33329499f, 0.03468076f, 0.12506323f, 
    0.10169215f, 0.07072975f, 0.02065969f, -0.10180225f, 0.04907176f, -0.03509081f, -0.16391216f, -0.05949885f, 
    -0.25384608f, -0.11817082f, 0.06904478f, -0.12821563f, 0.09052404f, -0.04033437f, -0.07376876f, 0.04416630f, 
    0.15048838f, 0.02930359f, -0.06259613f, 0.11008319f, -0.21391410f, -0.07890293f, -0.26700330f, 0.02525150f, 
    -0.00014669f, -0.20029385f, -0.03833061f, -0.00728048f, 0.14309235f, -0.09946816f, 0.14767568f, 0.00263032f, 
    -0.53854203f, 0.03426505f, -0.04560536f, 0.03149999f, -0.15573758f, 0.01566674f, 0.02617360f, 0.08869237f, 
    0.08207477f, 0.20028225f, -0.18913184f, 0.01715094f, -0.32144463f, -0.08398364f, 0.08059174f, -0.54778796f, 
    -0.08067013f, 0.00764595f, 0.04267047f, -0.10127573f, -0.20334299f, -0.02131323f, -0.02191946f, 0.05587093f, 
    -0.02058399f, -0.10699683f, 0.10342021f, 0.10823804f, -0.07107680f, -0.01945194f, -0.12307624f, 0.05398144f, 
    0.02604546f, -0.02058148f, -0.03429855f, -0.05286527f, -0.08698240f, -0.10555509f, 0.04457003f, -0.17611182f, 
    -0.07079738f, 0.14142264f, 0.02552874f, 0.09244574f, 0.01756940f, -0.17053738f, 0.06929404f, 0.11533099f, 
    0.25022027f, -0.00370244f, 0.11081189f, -0.23565052f, 0.01407899f, -0.07310621f, 0.09558662f, -0.06384097f, 
    0.00193794f, -0.10703254f, -0.15770341f, -0.02736712f, -0.34852800f, 0.42477804f, -0.05960914f, -0.24192442f, 
    0.10557015f, 0.06396845f, 0.00916175f, -0.06649134f, 0.05593101f, 0.00610396f, -0.08164459f, 0.08608674f, 
    0.55331153f, -0.17272672f, 0.15368916f, -0.25305450f, 0.00777212f, 0.10203996f, 0.21572028f, -0.08390654f, 
    -0.14398289f, -0.10539499f, 0.00904999f, 0.00980990f, -0.18701158f, -0.18189023f, 0.04128478f, -0.03131420f, 
    -0.13399889f, 0.02853002f, 0.06100243f, 0.17602642f, 0.12337127f, -0.02714506f, -0.10622892f, -0.16894725f, 
    0.29877663f, 0.00562117f, 0.02561212f, -0.25844303f, 0.00174929f, 0.14028156f, -0.12919965f, -0.07654160f, 
    0.00495812f, 0.05828767f, 0.04095165f, -0.03742547f, -0.40200943f, 0.23138526f, 0.03823750f, -0.16079457f, 
    -0.08357128f, -0.02460562f, -0.06957367f, -0.03208696f, -0.08267857f, -0.00143184f, -0.08929746f, -0.07548890f, 
    0.28806487f, 0.11919388f, -0.01953735f, 0.19437411f, -0.33455846f, -0.03448033f, -0.01731350f, -0.04780412f, 
    -0.07006837f, -0.13176633f, -0.03732167f, -0.01129259f, 0.21595323f, -0.20133583f, -0.05009804f, 0.21727607f, 
    -0.15201287f, -0.03383949f, -0.04911299f, -0.05250756f, -0.12549199f, -0.14345749f, -0.01093535f, 0.01338361f, 
    -0.40913764f, 0.02799912f, -0.37538925f, 0.13592039f, 0.05310893f, 0.08905020f, 0.02490745f, 0.14826514f, 
    0.03110606f, -0.01413354f, -0.04527994f, -0.08572777f, 0.04171504f, 0.01896848f, 0.13204502f, -0.12190486f, 
    -0.14056261f, -0.10647119f, -0.07045437f, 0.01865130f, -0.13375892f, -0.13533862f, 0.01925778f, -0.19275036f, 
    -0.54487133f, 0.05047256f, -0.25202897f, 0.09689061f, 0.10832128f, -0.11047245f, -0.13311221f, -0.17325063f, 
    0.08181325f, -0.11768942f, 0.18973714f, 0.04661825f, -0.03997678f, 0.08129696f, -0.18578543f, 0.29662460f, 
    -0.00974940f, -0.00203882f, 0.02791494f, 0.11499444f, 0.04696858f, 0.00127181f, 0.05607603f, -0.06404502f, 
    0.00816105f, -0.27477795f, 0.44187483f, -0.08674365f, -0.15361784f, -0.00278224f, 0.06049143f, -0.04276379f, 
    0.12324645f, 0.07147243f, 0.14586110f, -0.08694154f, 0.12944762f, 0.16200840f, -0.02257844f, -0.34682322f, 
    0.06082349f, -0.07590157f, 0.08238304f, -0.13787596f, -0.04925545f, -0.01246149f, 0.03705296f, 0.12030297f, 
    0.25036588f, -0.15629508f, 0.08642185f, -0.03394200f, -0.02403353f, -0.08783951f, -0.03110495f, -0.08509210f, 
    -0.07932046f, 0.08050228f, 0.10125602f, 0.04929840f, 0.14873022f, -0.20329726f, 0.07275427f, 0.07137417f, 
    -0.02714920f, -0.06605452f, -0.07161220f, 0.08457004f, -0.21429259f, -0.08785188f, -0.07898344f, 0.21587119f, 
    -0.10050485f, -0.32698253f, -0.25273603f, -0.08323346f, 0.17142950f, -0.14168112f, -0.18479016f, 0.00045035f, 
    0.10414464f, -0.32596788f, -0.08134155f, -0.02001686f, 0.24521743f, 0.18843549f, 0.04405040f, 0.09380579f, 
    0.06864305f, -0.23483893f, 0.13363075f, 0.00561380f, -0.00463960f, -0.03127622f, -0.04460306f, 0.19927110f, 
    -0.04184845f, 0.04891918f, -0.11862040f, -0.37451893f, 0.02820323f, -0.18585074f, -0.05828301f, 0.04300561f, 
    -0.18885686f, 0.08752157f, -0.14705878f, -0.05757237f, -0.77236843f, -0.17126769f, -0.51771104f, -0.05812407f, 
    -0.04331008f, -0.14423576f, 0.06440953f, -0.21566214f, -0.01690989f, 0.00239398f, 0.03807150f, -0.17542204f, 
    0.17368032f, -0.09715448f, -0.10118049f, -0.12381691f, -0.11556587f, 0.05789362f, 0.04715940f, 0.17461173f, 
    0.01069449f, -0.05906460f, 0.10019170f, 0.13732001f, -0.33312732f, 0.13377550f, -0.31755775f, -0.20155913f, 
    0.02347432f, 0.06839105f, 0.01478916f, -0.05758305f, -0.01498309f, 0.17532182f, 0.03401235f, 0.06809905f, 
    0.29113221f, 0.04350116f, 0.30683336f, 0.22440787f, -0.03947018f, 0.09501258f, -0.00732657f, 0.02345253f, 
    -0.03932771f, 0.01140709f, 0.00902008f, 0.08896996f, 0.31064999f, -0.06803441f, 0.08974990f, 0.00271605f, 
    -0.21366316f, 0.05094663f, -0.04105974f, 0.08734744f, 0.02540021f, -0.07286894f, -0.00603511f, -0.06671561f, 
    0.06822562f, 0.01608487f, -0.43363443f, -0.11581981f, -0.09648748f, 0.13323203f, -0.01523705f, 0.15154475f, 
    -0.08928730f, -0.01718506f, 0.04213755f, 0.05439339f, -0.29936391f, 0.05207270f, 0.04287785f, 0.08076248f, 
    -0.00672880f, -0.08674025f, -0.02134988f, -0.04718052f, 0.17035446f, -0.06827717f, 0.12664302f, -0.05762546f, 
    -0.37116978f, 0.13136645f, -0.05433042f, -0.03910682f, -0.01772941f, 0.04896177f, 0.02003991f, -0.02420715f, 
    0.00732512f, 0.08851623f, 0.02424105f, 0.08932688f, 0.00581851f, 0.13845272f, 0.06950720f, 0.02438393f, 
    -0.08912007f, -0.17712057f, 0.00192247f, -0.03336609f, -0.09374271f, 0.02512587f, 0.12637159f, -0.02878417f, 
    0.23726439f, -0.20170085f, -0.30279353f, 0.14755854f, -0.20684889f, 0.03951321f, -0.10899509f, 0.01723514f, 
    0.08192600f, -0.17561647f, 0.12972465f, 0.07755207f, 0.48019966f, -0.26495698f, -0.02324988f, -0.20364492f, 
    0.16003880f, -0.14830226f, 0.03653472f, -0.04297017f, 0.03716786f, -0.03219758f, 0.00520311f, -0.05215842f, 
    0.26115209f, -0.03207400f, -0.03167183f, -0.03877295f, 0.15306550f, -0.07755631f, -0.11036307f, -0.07872276f, 
    -0.16252689f, 0.08555754f, 0.23131464f, -0.04961563f, 0.25532326f, -0.48853487f, -0.02936143f, 0.02129842f, 
    -0.13835013f, -0.24892247f, 0.09074374f, 0.18768683f, -0.19411403f, 0.23488434f, -0.18781124f, -0.00716304f, 
    -0.31720203f, 0.30299455f, -0.17481402f, -0.40124443f, 0.00610083f, 0.15696569f, -0.03656695f, 0.11665666f, 
    0.08649173f, 0.07698686f, 0.11851174f, 0.01108985f, 0.44985390f, -0.16362900f, -0.09859052f, -0.00246870f, 
    0.06644034f, 0.15856279f, -0.09970829f, 0.02808524f, 0.05120377f, 0.00321011f, -0.12093627f, -0.03682573f, 
    0.03569098f, -0.17920406f, 0.23436664f, -0.37064257f, 0.07333738f, -0.19243865f, -0.10860240f, -0.02328977f, 
    0.00053518f, 0.06775127f, -0.13786830f, -0.20810020f, -0.23402016f, -0.05940301f, 0.04237764f, -0.00629817f, 
    0.13219540f, 0.23225082f, -0.05697701f, 0.18265232f, -0.02275973f, 0.02133260f, 0.30483872f, 0.08447751f, 
    -0.16881725f, -0.07578056f, 0.11726551f, -0.52222878f, -0.08309007f, -0.01580817f, 0.21193506f, -0.01958309f, 
    0.17287649f, 0.09310772f, -0.08308873f, 0.08436929f, 0.25936463f, -0.03299548f, -0.20903856f, -0.43652415f, 
    -0.01986903f, -0.16236344f, 0.08185849f, 0.13289835f, -0.05700861f, -0.02086847f, 0.03309334f, -0.00478370f, 
    -0.00977881f, 0.01884919f, -0.01170229f, 0.32145080f, -0.04039302f, 0.05755032f, -0.00031775f, 0.08689200f, 
    0.17229480f, 0.12230374f, 0.03225298f, -0.07836944f, -0.39100865f, -0.14453150f, -0.05503450f, 0.14468339f, 
    0.02275368f, -0.10236746f, -0.08078846f, 0.17341799f, 0.01795172f, 0.05398032f, 0.09050221f, 0.09454295f, 
    -0.21368377f, 0.38531122f, -0.21028452f, 0.30629209f, -0.04308533f, -0.04546158f, -0.04361763f, 0.00739325f, 
    -0.16866902f, -0.12581764f, -0.05536667f, 0.15113996f, 0.05400516f, 0.13804258f, 0.23392868f, 0.28233808f, 
    -0.06012267f, 0.02591360f, 0.05394519f, 0.07232486f, 0.08438251f, 0.06827074f, 0.06028854f, 0.03400614f, 
    0.17306541f, -0.33024111f, 0.08704205f, 0.09948013f, -0.06925128f, 0.04525840f, -0.05176264f, -0.04609436f, 
    -0.03801054f, -0.16642280f, -0.25035292f, -0.04509534f, 0.47940597f, 0.20852077f, 0.03286118f, 0.25110680f, 
    -0.17603071f, -0.02544758f, -0.01959503f, 0.00787734f, -0.01673300f, -0.14708203f, -0.01451571f, -0.00117123f, 
    -0.05475954f, -0.03874817f, -0.04913028f, -0.25787711f, 0.05481447f, -0.10614221f, -0.11308274f, -0.17303184f, 
    -0.15316381f, -0.07455803f, -0.11773030f, 0.02313496f, 0.20662136f, -0.37319595f, -0.13800840f, -0.16046421f, 
    0.11331918f, -0.06170305f, 0.03900587f, -0.01052315f, 0.11140104f, -0.00265673f, -0.07428254f, -0.01706096f, 
    -0.16429038f, -0.00386825f, 0.08324609f, -0.06215317f, -0.01145951f, 0.11342846f, 0.16357809f, 0.01676102f, 
    -0.14490068f, -0.03527921f, -0.01028610f, -0.20821545f, 0.37794897f, -0.03729592f, 0.05256218f, -0.04593992f, 
    0.16417475f, -0.02586607f, -0.08572093f, 0.05430067f, -0.13262887f, -0.07455448f, -0.06014486f, 0.03171781f, 
    -0.31007698f, -0.10882270f, -0.02320164f, -0.10248732f, 0.07474019f, -0.02699845f, 0.07238816f, 0.05455410f, 
    -0.07403185f, -0.08809537f, -0.15370378f, -0.16907988f, -0.23033369f, 0.14601463f, -0.17226334f, -0.12497692f, 
    0.01244274f, -0.00848195f, 0.05308040f, 0.02258124f, -0.22622931f, 0.12189289f, 0.01364939f, -0.06607619f, 
    0.11401366f, -0.15525888f, -0.15103699f, 0.12511632f, -0.06880500f, 0.10667022f, 0.05234071f, -0.11679492f, 
    0.05776948f, 0.07404188f, 0.04149621f, 0.06528272f, 0.25750488f, -0.12384862f, -0.05518569f, -0.42923728f, 
    -0.03969523f, -0.02720703f, 0.14477582f, 0.23823030f, -0.15348062f, -0.03474864f, 0.04630668f, -0.15240146f, 
    0.13573724f, 0.01917863f, 0.22045684f, 0.26211905f, -0.24881770f, -0.13203186f, -0.08918635f, 0.07417493f, 
    0.03058753f, 0.07208922f, 0.01058414f, -0.17278689f, 0.14761159f, 0.04028137f, -0.39015535f, -0.35175961f, 
    0.02209036f, 0.08199428f, -0.06568837f, -0.07686824f, -0.06624061f, -0.17937393f, 0.07060459f, -0.15535384f, 
    0.01383593f, 0.03221328f, -0.06857599f, 0.04618571f, 0.17506832f, 0.06168693f, -0.03189962f, -0.03020657f, 
    -0.03804638f, 0.15446985f, 0.05538616f, 0.00472585f, -0.17109936f, -0.13966119f, 0.07342213f, -0.21845701f, 
    0.18850029f, 0.03134929f, -0.07228626f, -0.00067469f, 0.08156757f, 0.12558675f, 0.00625778f, 0.01840010f, 
    -0.04291764f, -0.16593501f, -0.10206626f, -0.01437069f, -0.07836022f, -0.02341974f, 0.00610154f, 0.05886681f, 
    -0.05832222f, 0.01590976f, 0.04885007f, -0.00993270f, 0.18548381f, 0.02947089f, 0.05691512f, 0.10612452f, 
    0.02271086f, -0.01044778f, 0.11614106f, -0.00197117f, -0.06247298f, 0.12406410f, -0.03932010f, 0.02024284f, 
    -0.15577546f, -0.06588324f, -0.17471905f, -0.03101727f, -0.01792986f, -0.05402405f, -0.15570481f, 0.02202827f, 
    -0.26365462f, 0.08888073f, -0.08950840f, -0.11635064f, -0.00136891f, 0.03752608f, 0.00730755f, -0.10825630f, 
    -0.11146695f, 0.06234254f, 0.00141294f, 0.16465591f, -0.11702722f, -0.10896865f, 0.05482159f, -0.16708952f, 
    0.79869539f, -0.09274507f, 0.18464233f, 0.07057288f, -0.16249362f, -0.02190143f, -0.03073799f, -0.14762531f, 
    -0.10892482f, -0.06277163f, 0.02161278f, -0.02021150f, 0.03697803f, 0.07631198f, 0.19412290f, -0.19304815f, 
    -0.06117332f, -0.15832116f, -0.03032533f, -0.05548753f, 0.02199516f, -0.00152322f, 0.01874258f, 0.02197379f, 
    0.29405510f, -0.14292160f, 0.05009582f, -0.07775214f, -0.03790396f, -0.00534034f, 0.13367197f, 0.02795716f, 
    0.03073263f, 0.05823063f, 0.00123278f, 0.02803901f, -0.08382805f, -0.01933150f, -0.12889805f, -0.33209726f, 
    -0.01660120f, -0.00871448f, 0.08652079f, -0.01090728f, -0.04230431f, 0.05037335f, 0.02187422f, -0.18924685f, 
    0.45867705f, 0.07585175f, -0.22246163f, -0.05422713f, 0.02321696f, 0.10484692f, 0.00208813f, -0.07202408f, 
    -0.00070164f, 0.01641244f, 0.00247266f, 0.04188403f, 0.28754452f, -0.05708794f, -0.02220132f, 0.25121778f, 
    -0.29054767f, -0.11121658f, -0.10581952f, 0.01387499f, 0.01272857f, -0.00185003f, 0.13385648f, 0.10283165f, 
    -0.23611249f, -0.05148982f, -0.05280596f, 0.18219012f, 0.08745201f, 0.16453269f, 0.08225051f, 0.10505096f, 
    -0.12071104f, 0.05672783f, 0.02132321f, -0.12941773f, -0.69241494f, -0.41964558f, -0.33177119f, -0.01854900f, 
    -0.09352028f, -0.02038930f, 0.02072245f, 0.00229434f, -0.03345669f, 0.04070237f, -0.10527190f, -0.15822633f, 
    -0.52581710f, 0.05801694f, -0.01663335f, 0.13268350f, -0.03514700f, 0.22983250f, -0.08080786f, 0.01869158f, 
    -0.05315521f, -0.04720876f, -0.12049931f, -0.00019218f, -0.42093393f, -0.03329912f, -0.49388793f, -0.35152483f, 
    -0.10208144f, -0.08411822f, 0.01596800f, -0.29439241f, -0.08000471f, 0.05527787f, -0.03515979f, -0.12289386f, 
    0.05421397f, 0.22202937f, -0.12549236f, -0.14409511f, 0.19220395f, 0.00182380f, -0.09329383f, -0.06766444f, 
    -0.03369643f, 0.07767943f, 0.04466356f, 0.06045369f, 0.47424114f, -0.22274043f, -0.10417701f, 0.01875880f, 
    -0.07657675f, 0.17024088f, -0.02714117f, -0.02664855f, -0.17186922f, -0.08121900f, 0.10431868f, -0.11573704f, 
    0.25108767f, -0.29964042f, -0.13002157f, -0.11026214f, -0.14002593f, 0.01297190f, -0.30432403f, 0.08425903f, 
    0.16913295f, 0.00909749f, -0.05186727f, -0.30316412f, -0.11875048f, 0.24606843f, 0.04282578f, 0.05485383f, 
    -0.12732275f, -0.06392670f, 0.11291482f, -0.02789644f, -0.16388236f, 0.04688148f, 0.06020772f, -0.02417229f, 
    0.73270738f, -0.10969985f, -0.15333752f, 0.32873833f, 0.06890415f, -0.01988430f, -0.07767722f, -0.02897170f, 
    0.05467070f, 0.04116597f, 0.11374120f, 0.02714003f, -0.06397782f, -0.03756129f, -0.25885618f, 0.11135310f, 
    0.14024197f, 0.12100505f, 0.02472490f, -0.11481682f, 0.00087061f, 0.04931711f, -0.00189743f, -0.05686842f, 
    -0.02022596f, -0.20630187f, 0.05125052f, -0.17834345f, 0.09692135f, 0.01476701f, 0.12960736f, -0.08651429f, 
    -0.13158864f, -0.04878472f, 0.07480574f, 0.01125007f, 0.27718920f, 0.13171603f, 0.23760636f, 0.27949181f, 
    -0.03910180f, -0.13204575f, 0.05977850f, 0.16250072f, 0.03033992f, -0.10043533f, -0.07488723f, -0.05827718f, 
    -0.25692886f, -0.36333197f, -0.33905455f, 0.17401072f, -0.02358166f, -0.06116486f, 0.24499913f, 0.08871477f, 
    -0.09740814f, -0.00078824f, -0.20382355f, -0.05594202f, -0.16556698f, 0.05861340f, -0.23010114f, -0.20699090f, 
    0.01830214f, 0.08217642f, 0.06823378f, -0.05884357f, -0.05527840f, -0.07862287f, 0.06518096f, -0.16385949f, 
    0.34223741f, 0.06713000f, 0.02909163f, 0.30169159f, -0.03783737f, -0.00218757f, 0.26670089f, -0.07785196f, 
    0.15719567f, 0.04980311f, 0.09290226f, -0.05830682f, 0.04569643f, -0.37368068f, -0.30045089f, -0.11028788f, 
    -0.23027337f, 0.03408371f, 0.04012652f, 0.02402722f, 0.05348667f, 0.02622320f, 0.02946766f, 0.00649479f, 
    0.11141659f, 0.07688455f, 0.22360964f, 0.10078568f, -0.03358925f, 0.00990582f, -0.03732716f, -0.18994074f, 
    -0.03416858f, -0.05126783f, 0.08220953f, 0.12551127f, -0.51572436f, 0.34947437f, -0.06337181f, -0.05913811f, 
    -0.01035402f, 0.05011039f, 0.04475799f, 0.24617866f, -0.02235998f, -0.16736415f, 0.01851450f, 0.06664968f, 
    0.00253617f, -0.06218653f, -0.00588275f, -0.24894503f, -0.04151608f, -0.07345776f, -0.08920569f, 0.03660978f, 
    0.06676532f, 0.00761029f, -0.07200629f, -0.01394229f, -0.07163871f, 0.40376189f, 0.18158595f, 0.07683191f, 
    0.18186897f, 0.00683824f, -0.07263521f, -0.09615728f, -0.09458052f, -0.05430543f, 0.08648093f, -0.09644213f, 
    -0.38754261f, -0.67006230f, -0.20124526f, 0.22788379f, -0.00900030f, 0.01432670f, -0.07437643f, -0.05198713f, 
    0.05097604f, -0.09946462f, -0.01450928f, -0.07681353f, -0.04439269f, -0.49227858f, -0.31395495f, 0.12138481f, 
    0.00596473f, -0.13287561f, -0.02103745f, -0.07994210f, 0.12852731f, 0.00494646f, 0.01394728f, 0.03933962f, 
    0.10972619f, 0.05077456f, -0.03818604f, 0.03301859f, 0.04519464f, -0.06530669f, -0.02026872f, -0.03698818f, 
    -0.07702596f, -0.09690738f, 0.01540209f, -0.22588234f, -0.58178049f, -0.18258171f, -0.18175389f, -0.31283319f, 
    0.00418673f, 0.15074371f, -0.13748528f, 0.03672885f, -0.14094967f, 0.04779052f, -0.03893214f, -0.17289133f, 
    0.20790125f, -0.02705581f, -0.00160752f, 0.06535362f, 0.19118026f, -0.01613411f, -0.01103776f, 0.10493807f, 
    -0.04205567f, -0.12813056f, -0.06658503f, -0.04479827f, -0.57795030f, -0.20439699f, -0.37957716f, 0.34497795f, 
    -0.09683479f, 0.10825162f, 0.06901394f, 0.10649404f, 0.00373764f, 0.08149739f, -0.14105386f, -0.00111605f, 
    0.00435700f, 0.05729406f, 0.28672951f, 0.01946993f, 0.12178642f, -0.02133165f, -0.04129953f, -0.01910865f, 
    0.01465833f, 0.20233025f, -0.22004758f, 0.06221443f, -0.04433304f, -0.02561745f, -0.03133645f, 0.14989449f, 
    -0.07638246f, -0.05601829f, 0.02220710f, 0.05610669f, -0.17599000f, -0.01904827f, -0.02106032f, 0.15310848f, 
    -0.20662227f, 0.14925863f, 0.10507971f, 0.04950900f, 0.03558114f, -0.03529742f, -0.07863466f, -0.10519086f, 
    -0.00752504f, 0.03155423f, 0.04253944f, 0.11667987f, 0.55129594f, -0.14409712f, -0.24360122f, -0.14493392f, 
    0.17185293f, 0.08760126f, 0.09512915f, -0.01242831f, 0.10983744f, -0.08998363f, 0.02392286f, -0.06675462f, 
    -0.25937104f, 0.18621084f, 0.26920745f, -0.38899007f, 0.06233831f, -0.02461924f, -0.07304111f, 0.05256505f, 
    0.11669645f, 0.05991082f, -0.08002169f, 0.14577435f, -0.06483684f, 0.07637349f, -0.08068223f, 0.07171912f, 
    -0.05497967f, -0.16415258f, 0.11461443f, -0.02852526f, -0.14699361f, -0.03043087f, -0.10706126f, -0.10264963f, 
    -0.03847514f, 0.19582607f, -0.07723644f, 0.14205654f, -0.00909515f, -0.02837768f, -0.03228087f, -0.12211588f, 
    -0.02165174f, 0.14084207f, 0.02815793f, -0.10713541f, 0.02663763f, 0.06307797f, 0.03080776f, 0.06266256f, 
    -0.08373835f, 0.04972651f, -0.03938099f, 0.01606933f, 0.05286961f, 0.04801011f, -0.13685131f, 0.03975594f, 
    -0.11038326f, -0.03188466f, 0.05629597f, 0.26142675f, -0.16223101f, -0.14653432f, 0.02639441f, -0.07077909f, 
    -0.04642814f, 0.05434596f, -0.07362936f, 0.12085792f, 0.08615098f, -0.07426713f, 0.19225070f, 0.04411929f, 
    0.00941738f, 0.02475798f, 0.07580460f, -0.08466983f, 0.10357520f, 0.15078881f, 0.03956900f, 0.18484595f, 
    -0.83573711f, -0.15386802f, 0.07524819f, 0.15402392f, -0.03175062f, 0.10422195f, -0.04021741f, -0.02255368f, 
    -0.01544216f, 0.00959869f, 0.02251095f, -0.03268482f, -0.13599385f, 0.18273929f, 0.16952267f, 0.29448745f, 
    0.04223964f, 0.23816794f, 0.11783296f, -0.10259006f, -0.08467797f, -0.04439758f, 0.00121348f, -0.08410425f, 
    0.06069148f, -0.04562192f, 0.08004572f, -0.23793843f, -0.06265903f, 0.01762767f, 0.09198287f, 0.05029438f, 
    -0.01749024f, 0.09122457f, 0.05051047f, 0.03631423f, 0.01499650f, -0.32605943f, -0.64696646f, 0.19589692f, 
    -0.10979993f, 0.02707213f, 0.12529781f, -0.06456589f, -0.16363461f, 0.04045064f, -0.10874511f, -0.04556901f, 
    0.27009353f, -0.02457482f, 0.19262400f, 0.00925862f, 0.04444775f, 0.02260323f, 0.09187841f, -0.08122696f, 
    -0.10203215f, 0.19736150f, -0.01027200f, -0.00398628f, -0.42574263f, -0.60311514f, -0.18486843f, 0.07827143f, 
    -0.13071872f, -0.19953559f, 0.11584444f, -0.10599271f, -0.03868704f, -0.02697378f, 0.04838268f, 0.09682429f, 
    0.68470860f, 0.40153095f, 0.00905843f, 0.30726197f, 0.04101423f, 0.08781444f, -0.07730398f, -0.05109154f, 
    0.08527423f, -0.04346248f, -0.12445576f, -0.13448133f, -0.06766818f, -0.16474402f, -0.12794332f, -0.09747860f, 
    -0.18880644f, -0.03701980f, 0.07664884f, 0.00784361f, -0.21873231f, -0.01475370f, -0.07967176f, 0.07904215f, 
    -0.39172187f, -0.50395310f, 0.04855051f, -0.04967126f, -0.08369865f, 0.12735903f, 0.02350929f, 0.00169510f, 
    0.11455851f, -0.01975197f, -0.18395984f, -0.21346301f, -0.63866663f, 0.02849213f, -0.11810275f, -0.13183659f, 
    0.06448405f, 0.18062322f, -0.10788690f, -0.02465670f, 0.05472118f, -0.10832622f, -0.21305573f, -0.05837346f, 
    0.08660070f, -0.08762736f, -0.09050453f, 0.24048671f, -0.06919740f, 0.04061304f, 0.15077174f, 0.06541853f, 
    0.05099440f, 0.09398381f, -0.03808375f, -0.00283224f, 0.01378515f, 0.01702695f, 0.05001990f, 0.14577152f, 
    0.06082805f, -0.11014153f, 0.02893295f, -0.04785387f, -0.00789935f, 0.09338016f, -0.04824701f, -0.04411870f, 
    0.15943392f, -0.21051991f, -0.01234557f, 0.01425516f, -0.01279245f, -0.00701231f, -0.05217875f, 0.01140635f, 
    -0.23526151f, 0.04269605f, -0.06140688f, -0.02507727f, -0.28143930f, -0.01300148f, -0.06970419f, -0.21934241f, 
    0.04328507f, 0.10868248f, -0.06016315f, 0.08270792f, -0.05592576f, 0.11943196f, 0.00562208f, 0.07040104f, 
    0.13855006f, 0.05907075f, 0.00830083f, 0.35446644f, 0.17288236f, 0.05353712f, 0.02924109f, 0.22480574f, 
    -0.01266328f, 0.06522587f, 0.00268520f, 0.07621718f, -0.32215688f, -0.09817859f, 0.20349942f, 0.13052982f, 
    -0.16453743f, -0.20921783f, 0.09601447f, -0.14970838f, -0.00152406f, -0.10347963f, 0.00809617f, -0.05763894f, 
    0.06833516f, 0.10356440f, -0.09306795f, 0.11247307f, -0.03966759f, -0.12083729f, -0.05434510f, 0.17338404f, 
    0.18051808f, -0.09312946f, 0.00906173f, 0.01230662f, 0.31598943f, 0.34967178f, 0.04357080f, 0.05121376f, 
    -0.06585801f, 0.14493607f, -0.01253536f, 0.00729424f, -0.09072790f, 0.01958321f, 0.08630790f, 0.10191842f, 
    -0.13819301f, 0.09760914f, 0.05058801f, 0.36506069f, -0.14813632f, -0.03275132f, 0.12914136f, -0.03218427f, 
    0.08950526f, -0.00148583f, -0.02525442f, -0.18954705f, -0.42076719f, -0.14750986f, 0.04558396f, 0.08365073f, 
    -0.00775961f, -0.04929854f, -0.04267057f, 0.08496929f, -0.01895034f, 0.15624928f, 0.09752040f, 0.02001941f, 
    0.25038305f, 0.33220831f, 0.17735465f, -0.14851344f, -0.01681846f, 0.01772014f, 0.05900467f, 0.09622610f, 
    -0.04665977f, 0.05872462f, -0.01837000f, 0.04704809f, -0.18137656f, -0.26805520f, -0.00399040f, -0.26176339f, 
    -0.15415628f, 0.11248048f, -0.12523746f, -0.09473734f, -0.11147698f, -0.00994603f, 0.05587513f, 0.00827533f, 
    -0.69560289f, 0.10475858f, 0.06287576f, -0.14464460f, 0.15968744f, -0.00994324f, 0.09081776f, -0.01637891f, 
    -0.04933665f, 0.12259332f, -0.08330689f, -0.01093147f, -0.21487497f, -0.17367560f, -0.03646644f, 0.09370952f, 
    0.08765087f, 0.03321434f, 0.03515637f, 0.07446877f, -0.02572285f, -0.08451672f, -0.09211864f, -0.09097818f, 
    -0.31427810f, 0.21956787f, 0.10563437f, 0.23844308f, 0.04019596f, -0.16870381f, -0.00660401f, 0.20008323f, 
    -0.03691845f, -0.01127111f, -0.01987085f, 0.15737773f, 0.19500121f, 0.01003901f, -0.19910033f, 0.03477372f, 
    -0.12547384f, -0.05591719f, -0.12067227f, -0.39099574f, 0.11442319f, -0.04333302f, 0.05305714f, -0.07010174f, 
    0.15660824f, 0.25467539f, -0.12602404f, 0.15796597f, -0.07310286f, -0.18015908f, 0.07025807f, -0.05001121f, 
    -0.00281221f, -0.12888259f, -0.23616104f, 0.02948613f, -0.30977145f, -0.06780417f, -0.14892223f, 0.12381317f, 
    0.00098192f, -0.12105539f, 0.00788256f, 0.22622554f, 0.03654585f, -0.03945040f, 0.15784013f, -0.04421964f, 
    -0.06750327f, -0.38095361f, -0.27065513f, 0.27393538f, 0.06092839f, 0.12501046f, 0.17926894f, 0.02495242f, 
    -0.04461773f, 0.02805969f, 0.02995346f, 0.08197112f, 0.21813273f, 0.12925373f, -0.01957053f, 0.23348308f, 
    -0.08438136f, -0.05751412f, -0.00862770f, 0.01857357f, 0.06379289f, -0.02826897f, -0.02769153f, 0.01607735f, 
    0.09567635f, -0.25815988f, -0.41056398f, 0.23892985f, 0.05008367f, 0.00860791f, -0.05192798f, -0.06374311f, 
    -0.05787618f, -0.14212307f, 0.02076112f, 0.11672153f, 0.06671961f, -0.08644810f, 0.18862437f, -0.04318605f, 
    0.00409023f, 0.09897417f, 0.02017603f, 0.02282794f, 0.14214037f, 0.03581917f, 0.15210834f, 0.02316694f, 
    -0.10769293f, 0.28446585f, 0.19491455f, -0.12953554f, 0.05103666f, 0.06685384f, -0.00008952f, -0.07422394f, 
    0.03251499f, -0.06743675f, 0.04941346f, -0.02577482f, -0.23786306f, -0.14376020f, 0.13615783f, 0.31353197f, 
    -0.03161643f, 0.02166593f, -0.04391741f, -0.15629278f, 0.29071802f, 0.11326110f, -0.03814298f, -0.10613654f, 
    -0.19616896f, -0.22736053f, 0.07653020f, -0.35053229f, -0.00838030f, 0.08015246f, -0.14499685f, -0.08527725f, 
    0.03451866f, -0.23526181f, -0.11209437f, 0.02658667f, -0.08638798f, -0.65633547f, 0.13883992f, 0.07224602f, 
    -0.10845575f, -0.06827458f, -0.08834578f, -0.19952010f, 0.24631800f, 0.21159841f, -0.18317018f, -0.05264467f, 
    0.33924180f, 0.07511251f, -0.32014942f, -0.24811710f, -0.15743279f, -0.07696833f, -0.04405598f, 0.00470763f, 
    -0.09206889f, -0.03675675f, 0.01973699f, 0.07215803f, 0.14511287f, 0.13410828f, -0.20314495f, -0.08220305f, 
    -0.03005116f, 0.00167654f, 0.17793451f, 0.11135013f, -0.04180746f, 0.13869840f, 0.02240399f, 0.10919822f, 
    -0.23416992f, -0.05981560f, -0.00254846f, 0.25729349f, -0.01842965f, 0.15228841f, -0.07169428f, 0.12215714f, 
    -0.07240769f, -0.05302685f, 0.09874664f, 0.00843974f, -0.90536302f, 0.19476892f, 0.37535629f, 0.40307277f, 
    0.02180763f, 0.16742149f, 0.03489539f, -0.00531318f, -0.06849199f, 0.12851994f, 0.17687385f, 0.04795052f, 
    0.04265239f, 0.27149984f, -0.05560988f, -0.07889108f, -0.08577402f, 0.17301811f, 0.08400361f, 0.11018678f, 
    -0.03487787f, -0.15437153f, 0.26331794f, 0.20946537f, -0.22975998f, 0.05943201f, 0.09948394f, -0.38628995f, 
    -0.14514470f, -0.11964381f, 0.13226390f, 0.08682328f, 0.03118360f, -0.03677809f, 0.17948434f, -0.31769869f, 
    0.20002216f, 0.14802922f, 0.25113040f, 0.04247583f, -0.12321486f, 0.04497657f, -0.05638548f, -0.02890716f, 
    -0.27716491f, -0.06094928f, 0.14064825f, 0.01646899f, 0.03902172f, 0.12618776f, -0.01510200f, 0.33283502f, 
    -0.10782509f, 0.21582794f, 0.21775687f, -0.15642387f, 0.04332456f, -0.09976365f, 0.09296849f, -0.01794949f, 
    0.14890753f, -0.13481517f, -0.09277186f, -0.00575866f, 0.01329652f, 0.04463119f, 0.20204023f, 0.07367001f, 
    0.05100028f, -0.19274044f, -0.22297505f, -0.28233507f, -0.28767285f, 0.12432489f, -0.10222602f, 0.06795890f, 
    0.13636497f, -0.20106727f, -0.11429054f, 0.04381511f, 0.02457881f, -0.04227678f, -0.07725614f, 0.11800776f, 
    -0.23703973f, -0.29745871f, -0.06154123f, 0.01451002f, 0.20010966f, 0.01904265f, 0.07930522f, -0.08857040f, 
    0.02358364f, 0.10298808f, -0.14878011f, 0.26136443f, 0.06143784f, 0.04725571f, 0.17317489f, 0.33775648f, 
    -0.15645605f, -0.15419622f, 0.04930926f, 0.14422426f, -0.13731775f, 0.22962783f, -0.19598013f, 0.16038577f, 
    -0.08138659f, -0.05891887f, 0.29210111f, 0.08843241f, -0.00340048f, 0.02665366f, 0.11353758f, -0.15641265f, 
    -0.01081832f, -0.01100152f, -0.06244082f, 0.15979080f, -0.00663654f, -0.14497185f, 0.20332827f, -0.27248263f, 
    -0.04194447f, -0.03200135f, -0.05745819f, 0.04323586f, 0.12059716f, 0.13276725f, -0.09264097f, -0.03853536f, 
    -0.30810004f, -0.04312797f, 0.11370859f, 0.20627961f, 0.09424645f, 0.22932059f, -0.01156500f, 0.07939741f, 
    0.15518385f, -0.08718561f, 0.05983759f, 0.26190311f, 0.30077961f, 0.08972563f, -0.06766774f, -0.11249372f, 
    0.12302289f, 0.03799270f, -0.08913761f, -0.14038520f, 0.04293074f, -0.16780007f, -0.13782996f, 0.14895345f, 
    -0.20497271f, -0.22588201f, 0.14149611f, 0.32917142f, 0.10812329f, 0.13051108f, 0.10090472f, -0.22370784f, 
    0.10130043f, -0.30878374f, 0.14035401f, 0.07514797f, 0.22687328f, 0.10339638f, -0.03734518f, 0.05326753f, 
    0.01408820f, -0.14812352f, 0.00140261f, -0.02380112f, 0.12983388f, 0.06651392f, -0.31810355f, 0.06004368f, 
    -0.33244932f, -0.10187084f, -0.03062673f, -0.11779451f, 0.03016391f, -0.01172335f, -0.00493707f, 0.01460533f, 
    0.10966730f, -0.16141856f, 0.03500145f, -0.07896502f, -0.31524342f, -0.14077026f, -0.01996812f, 0.12436971f, 
    -0.04667516f, 0.03935923f, -0.02858909f, 0.28116229f, 0.13146526f, 0.15839580f, 0.09921655f, -0.01627459f, 
    -0.19748527f, 0.20889945f, -0.17924882f, -0.31789795f, 0.09258448f, 0.19287735f, 0.08205511f, -0.17918904f, 
    -0.08706107f, -0.32056683f, -0.02399074f, -0.50610554f, 0.05104902f, 0.22106321f, 0.30085164f, 0.17925759f, 
    -0.09920633f, -0.11161007f, 0.11981789f, -0.10159273f, 0.00736632f, -0.00169994f, 0.08912773f, -0.00353930f, 
    -0.38228524f, -0.18354575f, 0.14155954f, 0.19624145f, -0.12968954f, -0.02328142f, 0.10637177f, -0.10007431f, 
    0.17275093f, -0.02750140f, 0.12448565f, -0.01152526f, -0.54340571f, -0.00022187f, -0.27236477f, -0.35929483f, 
    0.10946856f, 0.16439794f, 0.00385794f, -0.08258437f, -0.04712903f, 0.15907313f, -0.22942926f, 0.18055946f, 
    0.14284506f, -0.07215701f, -0.01327055f, -0.20438023f, 0.07894981f, -0.10970499f, -0.20723841f, -0.22896406f, 
    0.04410100f, -0.03953338f, -0.00323991f, -0.07430563f, -0.00990110f, -0.10732101f, -0.22843775f, 0.10571975f, 
    0.07600980f, -0.14340869f, -0.09678856f, -0.03053327f, 0.15406202f, -0.12530102f, 0.11789874f, 0.34856662f, 
    0.04790862f, -0.02874719f, 0.08648513f, 0.12527159f, 0.14805816f, 0.07939374f, -0.10634588f, -0.26704964f, 
    -0.08227181f, -0.17703649f, 0.07488990f, -0.19433892f, 0.07887840f, 0.10090098f, 0.06706643f, 0.20678245f, 
    0.11725897f, 0.10402111f, 0.14057307f, 0.03416689f, 0.04935446f, -0.02339999f, 0.09532860f, 0.08029278f, 
    -0.17846324f, -0.06116072f, 0.16179076f, -0.04486014f, -0.15584275f, -0.07795572f, -0.00305927f, -0.01421007f, 
    -0.05899569f, 0.02031661f, -0.01970725f, -0.08888646f, 0.12526631f, 0.03449429f, -0.28311589f, -0.49085346f, 
    0.08038580f, -0.07084530f, -0.13000363f, 0.11929839f, 0.03419562f, 0.10317456f, 0.02693469f, 0.10971846f, 
    -0.36677778f, -0.03287429f, 0.01773321f, -0.10588528f, 0.07830984f, -0.04120613f, 0.15195367f, -0.09048255f, 
    0.04333603f, 0.12799771f, 0.03725792f, 0.06989537f, 0.12554988f, 0.05706607f, -0.13308999f, 0.14085934f, 
    -0.01582912f, -0.05321980f, -0.00447512f, 0.00397982f, 0.00625735f, -0.32434797f, -0.07196455f, 0.01507733f, 
    -0.42278892f, 0.04871118f, -0.01922533f, -0.17583829f, -0.06390125f, 0.12569384f, -0.07478698f, 0.19612512f, 
    -0.07218949f, -0.20489924f, -0.13395883f, -0.27125317f, -0.08507647f, 0.13326724f, 0.27578372f, -0.03365457f, 
    0.05868521f, -0.05817706f, -0.02873453f, -0.09508563f, 0.03592473f, 0.16701181f, -0.18537273f, 0.04217328f, 
    -0.22023636f, 0.01737598f, -0.09853153f, 0.04376344f, -0.14336544f, -0.09245105f, 0.08100221f, 0.04973106f, 
    0.02549784f, 0.14088616f, -0.13483931f, 0.09690430f, -0.12862465f, 0.11729154f, -0.51596832f, 0.06923505f, 
    0.15339266f, -0.04520968f, -0.23497298f, -0.06849204f, -0.01332666f, -0.16357015f, 0.03837380f, 0.01179333f, 
    -0.00654044f, 0.17787889f, 0.03406536f, 0.12059893f, 0.11293200f, -0.16845955f, -0.10811355f, -0.04482057f, 
    0.01141328f, 0.02425573f, -0.39625365f, -0.41850102f, 0.20979115f, 0.08308544f, 0.18136677f, 0.15382534f, 
    -0.01975018f, 0.01021729f, 0.12223221f, -0.21770975f, -0.00734133f, 0.03964311f, -0.03658208f, -0.08229763f, 
    -0.02727064f, 0.33862084f, 0.20183231f, -0.34278166f, -0.08884999f, 0.02616954f, 0.04410895f, -0.03464948f, 
    0.09374045f, 0.16749384f, -0.17842886f, 0.01430036f, -0.24406146f, 0.29561576f, 0.20460315f, -0.02479321f, 
    0.11605922f, -0.08240282f, -0.13408543f, 0.13434322f, -0.00535481f, 0.09204295f, 0.01953344f, 0.15698428f, 
    -0.36453992f, -0.25654373f, 0.01699487f, -0.08223151f, -0.17736217f, 0.10896728f, -0.06675238f, 0.11428817f, 
    0.23512734f, -0.17939898f, 0.16380164f, 0.14055309f, 0.52825183f, -0.16981083f, 0.31635842f, 0.06034632f, 
    0.02200254f, 0.12152620f, 0.11686394f, -0.03494333f, -0.01285352f, -0.11914350f, -0.01650675f, -0.15666384f, 
    -0.52209955f, 0.03917639f, -0.14576796f, -0.11645257f, -0.13849345f, 0.07013820f, -0.22198023f, -0.10806861f, 
    0.06241665f, 0.00883732f, 0.10387745f, -0.12215547f, -0.02645803f, -0.10661192f, -0.13236268f, -0.07808839f, 
    0.20745160f, 0.10638888f, -0.02783001f, 0.03504163f, -0.06443502f, -0.08519626f, 0.03527571f, -0.06291826f, 
    -0.11583735f, 0.20867200f, 0.18458688f, -0.47317326f, -0.30983552f, -0.04306892f, -0.12837940f, 0.18238474f, 
    0.03520544f, -0.00203838f, 0.03600226f, -0.13155632f, -0.05506198f, 0.02104924f, -0.07735854f, -0.34965298f, 
    -0.11747869f, -0.05953174f, -0.06012374f, 0.06204258f, -0.09209039f, -0.08236440f, -0.03322977f, 0.07042845f, 
    0.17746179f, -0.06977114f, -0.01649979f, -0.49963540f, -0.01728521f, -0.23281363f, -0.01878668f, -0.14204009f, 
    -0.09882671f, -0.14212637f, -0.04827438f, -0.18186465f, 0.10367462f, -0.13912298f, 0.19689921f, 0.12826498f, 
    -0.23030226f, -0.02007348f, 0.16516401f, 0.00205934f, -0.16880502f, -0.04032468f, 0.27041635f, 0.10173006f, 
    0.25486454f, -0.10057784f, -0.17319475f, -0.10765527f, -0.14644684f, -0.22279291f, -0.07685515f, -0.01998376f, 
    -0.08170082f, 0.20283848f, -0.28341234f, -0.35914975f, -0.40527609f, 0.36506009f, 0.11412740f, 0.49181303f, 
    -0.08428317f, 0.18471871f, 0.14693882f, 0.09831955f, -0.02172139f, 0.12400648f, 0.18764041f, -0.20408711f, 
    0.51366645f, -0.04124329f, -0.05684742f, -0.17149335f, -0.01042200f, 0.01296916f, 0.01120225f, 0.04690665f, 
    -0.00182019f, -0.03760583f, 0.12314616f, 0.03673607f, -0.07000897f, 0.09475829f, -0.38899189f, -0.15574157f, 
    0.03975420f, 0.15932880f, -0.12059041f, -0.23864593f, 0.03118235f, -0.12818737f, 0.01722654f, 0.09251657f, 
    -0.07146994f, -0.30873173f, 0.02365222f, -0.15497373f, -0.11585179f, 0.15099542f, -0.15074909f, -0.11162549f, 
    0.13586169f, 0.06899275f, -0.03707992f, 0.32418159f, -0.04898898f, -0.04552800f, 0.02366741f, 0.14591257f, 
    0.00775327f, 0.23314992f, -0.15755227f, 0.09319272f, 0.01976611f, -0.08188546f, 0.12557879f, 0.00062375f, 
    -0.32141659f, -0.11014233f, 0.01712590f, 0.26138639f, 0.00099941f, 0.00350983f, 0.04935525f, -0.01975241f, 
    -0.23972563f, 0.04188298f, -0.19814302f, 0.00413850f, -0.33051649f, -0.27491656f, 0.10991143f, -0.15402448f, 
    0.01455358f, 0.02693210f, 0.20935006f, -0.01539432f, 0.05081748f, -0.31513944f, 0.14424330f, -0.15274452f, 
    -0.61747235f, -0.10554624f, -0.23236740f, -0.05144046f, -0.12990969f, 0.05582288f, 0.06000507f, 0.09834476f, 
    0.04640751f, -0.00792799f, 0.05953406f, 0.14104231f, -0.05237783f, -0.03118486f, 0.07035497f, -0.25227806f, 
    0.14236544f, -0.02954000f, -0.01582301f, -0.06942352f, -0.10931806f, -0.00790007f, -0.09709861f, -0.12321712f, 
    -0.33658212f, -0.04335248f, 0.06354492f, -0.27212587f, -0.06999860f, -0.12364473f, 0.07833182f, 0.04295338f, 
    0.12271462f, 0.12046579f, -0.04639204f, 0.03118546f, 0.16174746f, -0.23404945f, -0.13495997f, 0.38369122f, 
    0.18404880f, -0.06940894f, -0.13394403f, 0.08487476f, -0.01489471f, 0.01955235f, -0.03622566f, -0.03975705f, 
    0.46986431f, -0.08426920f, 0.13647550f, -0.18778713f, 0.23971662f, -0.01229209f, 0.09577612f, 0.14917536f, 
    -0.16753344f, 0.08476228f, 0.07510664f, 0.18737400f, 0.46056405f, 0.24971852f, 0.08694321f, -0.11204144f, 
    -0.12966783f, 0.03407463f, 0.10478183f, -0.00240602f, -0.05071107f, -0.08644436f, -0.21402283f, -0.09455536f, 
    0.29924133f, -0.08516306f, 0.12525497f, -0.25159359f, 0.03080048f, -0.05774154f, 0.05574985f, 0.00987103f, 
    0.10479096f, 0.13928722f, 0.09101276f, -0.11534983f, -0.20147365f, 0.21897469f, 0.10262132f, -0.00829697f, 
    0.07488992f, 0.12134719f, -0.08357289f, 0.09852551f, -0.08522517f, 0.15828577f, 0.04109399f, 0.08793381f, 
    -0.06732856f, -0.16427198f, 0.18871044f, -0.12690583f, 0.20497622f, -0.16526201f, 0.05840366f, -0.16437417f, 
    0.06106036f, 0.09230964f, 0.20213388f, 0.15646428f, -0.07302256f, 0.11367000f, 0.16291498f, -0.27467355f, 
    -0.05672970f, 0.05395344f, 0.17107365f, 0.08289680f, -0.07963863f, -0.05428392f, 0.02362353f, 0.03270318f, 
    -0.00761432f, -0.07196065f, -0.30049044f, -0.09968377f, 0.13763328f, 0.12039997f, 0.02919736f, 0.09111978f, 
    -0.06962962f, -0.04377886f, -0.00985030f, 0.00556402f, -0.06322183f, -0.35538587f, -0.10163883f, -0.40210307f, 
    -0.13554725f, -0.07354391f, 0.01225796f, -0.11582716f, -0.02917201f, 0.12572478f, 0.06924742f, 0.15737303f, 
    -0.44331190f, -0.03906194f, -0.26129639f, -0.02753255f, 0.14810276f, -0.09164891f, -0.08156698f, 0.08697952f, 
    0.03149737f, -0.02553840f, -0.04972927f, -0.01503951f, -0.32942536f, 0.12262946f, 0.08856483f, -0.11350893f, 
    -0.14169551f, -0.14854755f, -0.09089115f, -0.00932226f, -0.00838407f, 0.01744621f, -0.01692657f, -0.07350571f, 
    0.13170427f, 0.12699218f, 0.03173451f, 0.01534743f, -0.04092791f, 0.08958780f, 0.01075596f, -0.06575849f, 
    -0.17398180f, -0.02571969f, 0.00854883f, -0.00741323f, -0.09732752f, -0.29328561f, -0.14344278f, -0.16518551f, 
    -0.08023315f, 0.05068573f, 0.02286907f, -0.05665408f, -0.06023034f, -0.04455316f, 0.08224333f, -0.13817346f, 
    0.08159351f, 0.02755190f, 0.17708726f, 0.16679879f, 0.07308947f, 0.04419177f, -0.08453414f, 0.05372521f, 
    -0.08229043f, 0.08546386f, 0.03041065f, -0.07111141f, 0.20923874f, 0.08880158f, 0.04940695f, 0.18995690f, 
    0.21900481f, -0.10042343f, -0.05876857f, -0.02559229f, 0.01200362f, 0.01761601f, 0.05658993f, 0.05067078f, 
    0.25121573f, 0.21726474f, 0.17824878f, 0.17945202f, 0.09327932f, -0.01412342f, 0.05582068f, -0.05535122f, 
    -0.01155664f, -0.07557418f, -0.01051768f, -0.15545620f, 0.24718693f, -0.27845457f, 0.12168708f, 0.19980720f, 
    0.03784859f, -0.09634567f, -0.08254287f, -0.08364769f, -0.11481433f, -0.03787125f, 0.04689679f, -0.04917512f, 
    -0.28887460f, -0.00795439f, -0.21740861f, -0.18402310f, 0.01204413f, 0.01798739f, -0.06124982f, -0.10717080f, 
    -0.21594709f, -0.04540603f, 0.04322152f, -0.11532360f, -0.32384488f, 0.30312380f, -0.15130822f, -0.02234557f, 
    -0.05240906f, -0.16356261f, 0.00138284f, -0.16618770f, -0.11511751f, -0.09623419f, -0.16378595f, -0.13251361f, 
    0.25522074f, 0.32717288f, -0.18300588f, -0.04057152f, -0.25072911f, -0.13995619f, -0.07522397f, -0.22278421f, 
    -0.09252089f, 0.05821972f, 0.04460579f, -0.06789672f, -0.11435394f, 0.01950572f, -0.01637971f, -0.11468294f, 
    0.09569262f, -0.08391221f, -0.11406472f, -0.15431103f, -0.03674808f, 0.01136571f, 0.00077618f, 0.04604028f, 
    -0.00156030f, 0.15848915f, -0.00255001f, 0.18088740f, 0.10848128f, -0.02291009f, -0.08076639f, -0.00633822f, 
    0.00097525f, 0.08974129f, -0.00528801f, -0.08291700f, -0.24257313f, -0.24017644f, -0.20744665f, -0.28429878f, 
    0.07295922f, 0.03236194f, -0.10110501f, 0.00347589f, -0.03403660f, -0.06255070f, -0.04225738f, -0.07957498f, 
    0.39887947f, -0.15431195f, 0.27208319f, -0.06927188f, -0.04989882f, 0.04282622f, -0.14360479f, -0.03902334f, 
    -0.03450561f, 0.14313006f, -0.15738602f, -0.07395766f, -0.24094835f, 0.21499084f, 0.13184302f, 0.09487922f, 
    -0.05260435f, 0.02712942f, -0.09985796f, 0.04208336f, 0.06104191f, -0.01890450f, -0.13116179f, -0.14464681f, 
    -0.30250880f, -0.07282022f, 0.09315144f, -0.10838421f, -0.05868501f, 0.04350110f, -0.08989445f, 0.00122918f, 
    -0.04259554f, -0.06145604f, -0.20012450f, -0.04642441f, -0.21128957f, 0.29639584f, -0.06332083f, -0.00488689f, 
    -0.21539898f, 0.02582960f, -0.10651433f, -0.01932846f, -0.12722583f, -0.05521540f, 0.06488917f, -0.08809094f, 
    0.15492871f, -0.31207356f, 0.18244326f, 0.13741907f, 0.09928173f, -0.02686445f, -0.05482673f, -0.04921552f, 
    -0.08207625f, -0.04548837f, 0.00999684f, -0.10260198f, 0.09420618f, -0.08256519f, 0.33406648f, 0.04834209f, 
    0.14841336f, 0.02147503f, -0.02008653f, 0.04612981f, 0.02508143f, 0.02108024f, 0.10109143f, 0.00884278f, 
    0.22253588f, 0.19615681f, -0.15338460f, 0.16208589f, -0.04528025f, 0.01552845f, -0.04963694f, -0.07678059f, 
    -0.10389785f, -0.05396252f, 0.05228994f, 0.03534904f, 0.14549318f, 0.07718764f, 0.13435011f, 0.11980132f, 
    -0.02944495f, -0.01104972f, -0.03197742f, -0.12136405f, -0.09143887f, -0.05353141f, -0.05997886f, -0.07000845f, 
    0.37727624f, 0.33172584f, 0.13171287f, 0.23797466f, 0.18799114f, -0.02461936f, -0.03604329f, 0.06492320f, 
    0.05883963f, -0.02322288f, 0.05692720f, -0.15359570f, -0.04560586f, -0.00057963f, -0.03892559f, 0.22132148f, 
    -0.05497283f, -0.00168494f, 0.04868076f, 0.03297711f, -0.16271710f, -0.04675830f, -0.02444690f, -0.05515070f, 
    0.20749690f, -0.39865845f, 0.02034067f, -0.02918065f, -0.12151124f, -0.08675571f, -0.08157708f, -0.09815428f, 
    0.05865780f, 0.07390930f, 0.05723345f, -0.13092811f, 0.21970189f, -0.04197459f, 0.07818269f, -0.23166665f, 
    -0.06177894f, -0.06735782f, 0.05385052f, -0.04207666f, -0.05933984f, -0.04714798f, 0.00962097f, -0.06127714f, 
    0.05265948f, -0.03801439f, 0.04617732f, 0.19455469f, -0.02534257f, -0.03464916f, -0.06180205f, -0.10651664f, 
    -0.06867463f, 0.08779974f, 0.01444028f, -0.07557692f, -0.33527872f, 0.04096014f, -0.29722738f, -0.43556663f, 
    0.12526512f, -0.08163168f, -0.03010662f, -0.02935925f, -0.15573648f, 0.06523840f, 0.09950357f, -0.09655522f, 
    0.25083995f, 0.11394251f, 0.18311985f, -0.23454030f, -0.15939476f, 0.05726317f, -0.05387215f, -0.14935789f, 
    -0.03444285f, 0.08058064f, -0.04623109f, 0.04548864f, -0.03471125f, -0.09866996f, -0.02763137f, -0.28787217f, 
    -0.01822611f, 0.06401137f, 0.09204091f, -0.14279243f, -0.04091993f, -0.09541027f, 0.02474300f, 0.03320612f, 
    -0.42043260f, 0.05942377f, -0.15856533f, 0.11717390f, -0.06394160f, -0.06634221f, -0.10414929f, 0.13022365f, 
    0.01715911f, -0.00373795f, 0.17132714f, -0.11458878f, -0.02040486f, 0.33048162f, 0.15561791f, 0.14508039f, 
    -0.01452458f, 0.10526365f, 0.10588795f, -0.03608660f, -0.06258298f, 0.10524639f, 0.03434796f, -0.00227445f, 
    0.19155565f, 0.08902732f, -0.35577780f, -0.02285682f, 0.01720730f, -0.02857075f, -0.13479096f, -0.05033126f, 
    0.06588868f, -0.01152421f, 0.19661096f, 0.22288321f, 0.27291071f, -0.06556252f, -0.13804170f, 0.12571642f, 
    0.01295676f, 0.02683820f, -0.19791259f, 0.11057004f, 0.07128453f, 0.05585497f, 0.10712492f, 0.06333280f, 
    -0.10837578f, -0.09150334f, -0.03646518f, -0.03749048f, 0.10471607f, -0.14250045f, -0.24406786f, -0.06083529f, 
    0.00869457f, -0.07330389f, 0.23461591f, -0.23463245f, -0.06476629f, -0.26363131f, -0.16805916f, 0.03799064f, 
    0.24984908f, 0.09483253f, -0.07740702f, -0.06717061f, -0.14823486f, 0.00530661f, 0.01502781f, -0.10867472f, 
    0.04104209f, -0.17063239f, 0.10490746f, -0.21661305f, 0.17332026f, 0.02241781f, 0.14173274f, -0.03197310f, 
    0.03825852f, -0.01420821f, -0.10509390f, -0.19174315f, 0.13037460f, -0.20617756f, -0.23432724f, -0.08341294f, 
    0.04564572f, -0.10133784f, 0.01323763f, -0.06898576f, 0.05399970f, -0.04887500f, -0.14052010f, 0.09185377f, 
    -0.26611757f, 0.14766090f, 0.10111502f, 0.10316959f, 0.04878701f, -0.00239876f, -0.07192728f, -0.21886981f, 
    0.03971114f, -0.00248028f, -0.02714257f, 0.10247111f, -0.11235633f, 0.08915141f, -0.25015053f, -0.31886539f, 
    -0.09013731f, -0.11576321f, 0.14942718f, -0.04346762f, 0.17457257f, 0.12867510f, -0.05470734f, 0.04238303f, 
    -0.00882200f, -0.03411752f, 0.03481616f, 0.39485568f, 0.19798739f, 0.07051560f, 0.01706989f, -0.11336461f, 
    0.00346252f, 0.11651991f, 0.08499932f, -0.07118179f, 0.26829740f, 0.07139838f, 0.25646675f, 0.30064547f, 
    0.12214410f, -0.08255524f, -0.00399001f, -0.01988179f, 0.07058956f, 0.00465893f, 0.14127357f, -0.08196761f, 
    -0.11768393f, -0.14900160f, 0.22017583f, -0.12737438f, 0.10329310f, 0.06810818f, 0.12032806f, 0.02091203f, 
    -0.04890288f, 0.04499914f, 0.05488389f, 0.01570318f, 0.36457604f, -0.08909078f, -0.00133344f, 0.06985762f, 
    -0.20405938f, -0.04252281f, -0.08708241f, 0.00417366f, -0.01952254f, -0.22235894f, -0.16515465f, 0.03410202f, 
    -0.17598812f, 0.01999421f, -0.07208192f, -0.36051619f, -0.19630393f, 0.10549107f, 0.06251153f, -0.24636820f, 
    -0.03743180f, -0.05281237f, 0.16450307f, 0.00463988f, 0.31905830f, 0.01881203f, -0.23690522f, -0.05103549f, 
    0.10277337f, -0.00946581f, 0.02306033f, -0.08938023f, -0.01847486f, 0.01428434f, -0.16001813f, 0.20732789f, 
    -0.16454828f, -0.12678297f, -0.06270414f, -0.12363156f, 0.05911420f, -0.06665738f, -0.03636443f, -0.11992771f, 
    0.00277255f, -0.07134030f, 0.06473212f, 0.09733772f, -0.09209424f, 0.30332476f, 0.01480056f, -0.05892305f, 
    -0.17780702f, 0.03029868f, 0.07892886f, -0.12302174f, -0.04320722f, 0.03806078f, 0.04708521f, 0.06143321f, 
    -0.03809749f, 0.11885971f, 0.04140376f, 0.25180626f, -0.13529815f, -0.01059788f, -0.09464162f, -0.05164238f, 
    0.01862727f, -0.01380252f, -0.19309488f, -0.06430886f, -0.00228097f, 0.03928259f, -0.27477369f, -0.10298625f, 
    0.08100501f, -0.00585656f, -0.06993905f, 0.01757007f, 0.18841945f, 0.13685594f, 0.04044896f, 0.00652329f, 
    0.23326336f, 0.29636532f, 0.07982208f, 0.28536969f, 0.05885626f, 0.02292643f, -0.06233818f, -0.02385052f, 
    -0.09073611f, -0.00347913f, 0.10539597f, -0.20020756f, -0.38424569f, -0.00681593f, 0.17907198f, -0.05311290f, 
    -0.14842924f, 0.11767901f, 0.00371873f, -0.25058499f, 0.02344132f, 0.02135681f, -0.10104167f, 0.07750313f, 
    -0.18988681f, 0.21344334f, 0.02630950f, -0.03432239f, -0.07769684f, 0.03210035f, -0.21197796f, 0.02048517f, 
    -0.04523504f, 0.04369083f, -0.34664312f, -0.09315985f, -0.43699786f, -0.11667114f, 0.15742470f, -0.28794360f, 
    -0.15979449f, -0.01129901f, -0.16115218f, 0.07263266f, 0.00825264f, -0.02083232f, 0.06511275f, 0.08111742f, 
    -0.33993232f, 0.15073659f, 0.03620574f, -0.09938502f, -0.10303675f, -0.06098235f, 0.11414242f, 0.06860135f, 
    0.06183821f, -0.09094874f, 0.07653198f, 0.14821289f, -0.06476186f, 0.00456643f, -0.38358602f, -0.39802507f, 
    -0.00324216f, -0.10517945f, -0.23060890f, -0.00150070f, 0.05401555f, -0.08005147f, -0.05000093f, -0.05426591f, 
    0.16155916f, -0.09807101f, -0.16990687f, 0.30110207f, 0.12077463f, -0.04794657f, 0.02542381f, -0.00638015f, 
    0.06452660f, 0.05446745f, -0.10792898f, 0.15606734f, -0.34436321f, 0.00541677f, -0.17892429f, -0.25141802f, 
    -0.16492465f, -0.20765358f, -0.02210869f, 0.15199803f, 0.11582877f, -0.00343234f, 0.01682966f, 0.05916490f, 
    -0.18511617f, -0.45987132f, 0.35136738f, -0.17205027f, -0.12071582f, -0.16849455f, 0.00228339f, -0.12025990f, 
    -0.11031909f, 0.05864163f, -0.07711902f, 0.19855464f, 0.14385502f, -0.07363149f, -0.06193963f, -0.05628572f, 
    0.14207007f, -0.12300488f, -0.09293262f, -0.02960318f, 0.03939820f, -0.25504887f, 0.10060714f, 0.09349221f, 
    -0.17702857f, 0.21715723f, -0.07941891f, -0.44235376f, 0.02070873f, 0.01254122f, 0.02824421f, 0.09886868f, 
    0.03859089f, -0.06138359f, -0.05765955f, -0.17184170f, 0.15916841f, -0.10984787f, 0.10134596f, 0.30424726f, 
    0.04970859f, -0.06775398f, -0.15494654f, -0.00288269f, -0.01157735f, 0.03899619f, 0.11111329f, 0.09535189f, 
    -0.29456419f, 0.14085391f, -0.18723953f, -0.02480082f, 0.06189619f, -0.07239102f, -0.29278982f, 0.11476348f, 
    0.13468617f, 0.15201280f, 0.06515411f, 0.04776484f, 0.05569682f, 0.18941197f, 0.20661971f, 0.08598699f, 
    -0.20579050f, -0.02792643f, -0.24785973f, 0.05289170f, 0.13695683f, -0.11874307f, -0.12586203f, -0.25787279f, 
    0.21667378f, 0.20699771f, 0.25368068f, -0.26417640f, 0.15315074f, 0.05002250f, -0.09802599f, -0.07338416f, 
    -0.21863528f, -0.00612454f, -0.03259399f, -0.24435773f, -0.36788994f, 0.00671496f, 0.22091426f, 0.03231952f, 
    0.17764539f, 0.08251565f, 0.06605679f, -0.25206897f, 0.15570724f, 0.09633414f, -0.04418493f, 0.12073671f, 
    -0.21816437f, -0.29821885f, -0.00082321f, -0.05498644f, -0.13124721f, -0.23717983f, 0.13450357f, 0.03508536f, 
    -0.04509621f, 0.15158521f, -0.05281813f, 0.10507186f, -0.02023220f, -0.16436870f, 0.21625081f, -0.17405462f, 
    -0.02782928f, 0.18386316f, -0.12679137f, -0.10538717f, 0.09608658f, -0.08127473f, 0.05493445f, 0.01312715f, 
    0.29365727f, -0.12135378f, -0.08993480f, 0.04816990f, 0.26955429f, -0.03835646f, 0.07060239f, -0.04944690f, 
    -0.10536625f, 0.16099030f, 0.11494821f, 0.27222362f, 0.02902916f, -0.19091056f, 0.17904016f, 0.05300920f, 
    -0.07408982f, 0.00806472f, 0.02293216f, -0.03898972f, 0.00841524f, -0.00273408f, -0.01251753f, 0.12540774f, 
    -0.31153560f, -0.23871304f, -0.11187400f, -0.05088797f, -0.01421811f, -0.05745452f, -0.09729184f, 0.10831025f, 
    -0.02650472f, -0.10475664f, 0.05554758f, -0.15918609f, 0.08657335f, -0.47768754f, 0.07088390f, -0.37098446f, 
    -0.05845578f, 0.12715289f, -0.03793190f, -0.08051366f, -0.08945933f, -0.16482285f, -0.03667350f, -0.03886214f, 
    -0.27732608f, 0.35926923f, -0.23515782f, -0.46847022f, 0.22536218f, -0.05326200f, 0.02115651f, -0.10795060f, 
    -0.14171034f, -0.04396861f, 0.05857896f, -0.09981672f, -0.69819111f, 0.34826666f, -0.27027369f, -0.12160672f, 
    0.15282266f, -0.12144238f, 0.14821543f, -0.11713205f, -0.06506608f, -0.15131645f, 0.03577724f, -0.01794656f, 
    -0.05777701f, 0.08487725f, 0.01530730f, -0.15263440f, 0.02182936f, -0.05858016f, -0.07886865f, -0.11358409f, 
    -0.10969637f, 0.05329075f, -0.00627106f, 0.02704881f, 0.01413135f, 0.04361886f, -0.06626502f, 0.08485982f, 
    0.14606172f, -0.04394990f, 0.10557040f, -0.04381231f, 0.12676646f, 0.22063255f, -0.00584797f, -0.05304182f, 
    0.18552583f, -0.13019675f, -0.10679885f, -0.11104399f, 0.10778747f, -0.22651915f, 0.07899491f, 0.08139123f, 
    -0.06734499f, -0.08776390f, -0.05025280f, 0.08018206f, 0.28104541f, -0.05034497f, 0.32212588f, -0.20124994f, 
    0.07639708f, 0.02859045f, 0.01202599f, -0.18608710f, 0.07449853f, 0.08106613f, 0.08290109f, -0.09064811f, 
    -0.20907791f, -0.17798389f, -0.17210734f, 0.21322247f, 0.00430260f, 0.00495456f, 0.04457005f, -0.10882025f, 
    -0.03621288f, 0.23755474f, 0.07610483f, -0.03162159f, -0.19100511f, 0.26167724f, 0.14116210f, 0.41374955f, 
    -0.03935663f, -0.00895035f, -0.15867421f, 0.04858942f, -0.05584488f, 0.07539073f, -0.10799001f, -0.08456940f, 
    0.09637307f, -0.27063221f, -0.06337649f, -0.07807517f, 0.06866068f, 0.04073155f, 0.02187109f, -0.06909817f, 
    0.10257089f, 0.24735728f, 0.02721349f, 0.00720377f, -0.67879981f, 0.16240345f, 0.24476808f, -0.02489901f, 
    -0.06644797f, 0.04872786f, 0.18686016f, -0.26439300f, 0.06622239f, -0.18741281f, -0.08978025f, -0.08732440f, 
    0.57839227f, -0.83622259f, 0.12159206f, -0.17813630f, 0.14702210f, 0.01677075f, -0.07481282f, -0.02951868f, 
    -0.26544008f, 0.03446150f, 0.17448534f, 0.05539862f, 0.37571257f, -0.35291016f, -0.20775676f, 0.24070270f, 
    0.07028085f, -0.07895208f, -0.11469995f, 0.01556604f, -0.06343827f, 0.01681278f, 0.07560647f, -0.09505294f, 
    -0.05228374f, 0.62587345f, 0.09756240f, 0.17111066f, -0.09586784f, -0.02234126f, -0.02951686f, 0.25272331f, 
    0.08777512f, 0.01500419f, 0.14810316f, 0.11809373f, 0.26824814f, -0.13099229f, -0.10889964f, 0.16677451f, 
    -0.07698660f, 0.03795321f, 0.04797418f, -0.06041321f, -0.04018218f, 0.15443039f, -0.21376230f, -0.11541575f, 
    0.23614872f, -0.17319815f, -0.06384321f, 0.17683211f, -0.12291829f, -0.03674925f, -0.09813096f, 0.32463887f, 
    -0.02757326f, 0.00236532f, 0.10618541f, 0.10890076f, -0.31217769f, 0.02347106f, 0.25486627f, 0.14323755f, 
    -0.11276028f, -0.04817572f, -0.07024974f, -0.02790052f, -0.00228752f, -0.07365046f, -0.05743801f, 0.06393833f, 
    -0.22676872f, -0.09932625f, -0.24205099f, -0.39670253f, 0.08650229f, -0.08964852f, 0.01108178f, 0.04391155f, 
    -0.05349128f, -0.15282163f, -0.02744790f, -0.00885287f, -0.42621091f, -0.22916365f, 0.13545044f, -0.13552845f, 
    0.12449869f, 0.03322542f, 0.11034296f, -0.10694160f, 0.09949351f, 0.08067831f, 0.07567930f, -0.09988441f, 
    0.42197621f, 0.14770807f, -0.25388908f, 0.20924711f, 0.00209749f, 0.01851959f, -0.01846627f, -0.03066485f, 
    -0.03499249f, 0.02201755f, 0.04014841f, -0.19761300f, 0.24385554f, 0.04819203f, 0.06416755f, -0.20651928f, 
    -0.06121356f, -0.00463819f, 0.11489821f, -0.19908974f, -0.05974353f, -0.00903443f, 0.01097626f, 0.00503064f, 
    -0.43428874f, 0.07649350f, -0.08327969f, 0.16146378f, -0.02259726f, 0.04048521f, 0.00486830f, 0.14730388f, 
    0.02254018f, 0.22094731f, -0.01654034f, 0.15165628f, 0.02749099f, 0.00952024f, 0.11730028f, -0.03704515f, 
    0.04855855f, 0.03145589f, 0.00662564f, -0.20850645f, 0.14179124f, -0.23012930f, 0.16055948f, -0.05550212f, 
    -0.27120498f, 0.22712758f, 0.14047071f, -0.56576622f, -0.14567307f, 0.06870689f, 0.01379800f, 0.05265664f, 
    0.05079634f, -0.04693260f, 0.00147694f, -0.04586601f, -0.16463819f, -0.21515471f, 0.05705193f, -0.10372427f, 
    0.17576323f, 0.11172197f, -0.06169317f, 0.11713922f, 0.08945166f, 0.04914831f, -0.06871410f, 0.02526952f, 
    -0.40796334f, -0.18816400f, 0.06531179f, 0.06878667f, 0.10305894f, -0.09439221f, -0.07916716f, 0.03847689f, 
    0.12087350f, 0.17290312f, 0.15737984f, 0.25879550f, 0.05137724f, 0.09984735f, -0.21773095f, 0.14201824f, 
    0.05280412f, -0.08098140f, 0.06531043f, 0.23921491f, 0.05730502f, 0.08270103f, 0.15356894f, 0.22430490f, 
    -0.39709967f, -0.13187414f, -0.17180645f, -0.10888050f, 0.19878478f, 0.04594877f, -0.18650351f, 0.00448254f, 
    -0.04486170f, 0.02227703f, 0.13681699f, -0.04610251f, -0.91279340f, -0.57787049f, 0.16611560f, -0.21310720f, 
    0.17852831f, 0.10805684f, -0.10249276f, -0.12479694f, -0.07634396f, -0.13881542f, -0.04419235f, 0.11056990f, 
    0.01356686f, 0.23655529f, -0.16769120f, -0.13595164f, 0.08772007f, -0.02766464f, -0.02629012f, -0.00193545f, 
    0.13186257f, 0.05525673f, 0.02208370f, 0.00006996f, -0.42657846f, 0.01922435f, -0.08492888f, 0.19848666f, 
    0.03352696f, 0.02767276f, -0.12818626f, -0.15876949f, 0.02278544f, 0.07380313f, 0.00129794f, -0.00794832f, 
    0.21090446f, 0.10157926f, 0.09212965f, -0.18492138f, 0.01186707f, 0.01816897f, 0.04082621f, -0.19486789f, 
    0.02719089f, -0.11557870f, 0.04629508f, 0.13369657f, 0.09423725f, 0.19882558f, 0.13036014f, -0.03134291f, 
    0.12828386f, 0.08604107f, 0.10731403f, 0.09187220f, 0.06186891f, 0.12983216f, -0.11827508f, 0.16962737f, 
    -0.67248404f, -0.40753347f, -0.18626219f, -0.58365667f, -0.00971687f, -0.06662785f, -0.04116581f, -0.08306641f, 
    0.06407697f, 0.02045040f, -0.00370468f, 0.05171319f, -0.46138376f, -0.26001051f, 0.09826773f, -0.15402445f, 
    -0.00253346f, 0.00426752f, -0.07505362f, -0.04071330f, -0.02881543f, 0.02242178f, 0.13463156f, -0.04290931f, 
    0.15017392f, 0.00465498f, 0.35522386f, 0.03225098f, 0.04981043f, 0.08964531f, 0.00841809f, 0.03906432f, 
    0.11658250f, 0.17053112f, 0.02170975f, 0.17485625f, 0.16747747f, -0.00125372f, -0.17697346f, -0.10352330f, 
    -0.10980245f, 0.03201634f, -0.10130379f, -0.03588989f, 0.08273163f, -0.26427707f, 0.10644308f, -0.01997123f, 
    -0.19792067f, 0.14263129f, -0.10736199f, -0.09186383f, -0.02494599f, 0.10995926f, 0.02009182f, -0.05660487f, 
    -0.04527476f, 0.13723542f, 0.18103270f, 0.13175085f, -0.39087957f, -0.11949645f, 0.07480487f, 0.10826886f, 
    0.22847675f, -0.13017964f, -0.11016921f, -0.20151943f, -0.00851016f, -0.00408378f, 0.02202813f, 0.23408434f, 
    0.27056280f, 0.07283963f, -0.17037952f, -0.10357516f, 0.00246227f, 0.15504757f, -0.05883279f, 0.13444969f, 
    0.00800820f, -0.05706855f, -0.04178733f, 0.04656864f, 0.15344839f, 0.08152525f, -0.06965295f, 0.05062477f, 
    -0.08757821f, 0.09998087f, 0.17104068f, -0.09961639f, 0.12534288f, 0.02926468f, 0.10665005f, -0.08460239f, 
    0.27334446f, 0.11684833f, -0.22228418f, 0.11743971f, -0.06319407f, -0.12037817f, -0.09509478f, 0.15180179f, 
    -0.05328539f, 0.02158650f, 0.03280803f, -0.10786413f, -0.54573876f, -0.56481868f, -0.01760268f, 0.08065600f, 
    0.06341813f, 0.01867955f, -0.01344922f, 0.11380277f, 0.08582198f, 0.09810131f, -0.02740638f, 0.24448903f, 
    -0.47405520f, 0.14574994f, -0.16906674f, 0.03590677f, -0.00475555f, 0.08163454f, -0.12704860f, 0.03203206f, 
    0.10575856f, 0.11002892f, 0.05103700f, 0.06367576f, 0.32552683f, -0.10744788f, 0.08989563f, 0.04130812f, 
    -0.00428646f, 0.01999295f, -0.06514958f, 0.14888220f, -0.05598903f, 0.22304355f, -0.13363984f, 0.07664145f, 
    -0.33238155f, -0.34414139f, 0.01834319f, -0.02524704f, -0.04296158f, 0.08991282f, -0.05296173f, -0.00703921f, 
    -0.01837615f, -0.22003430f, -0.37728396f, -0.13383758f, 0.25892726f, 0.26867107f, 0.05558014f, -0.23550390f, 
    0.27096349f, 0.07516488f, -0.02763104f, 0.06929311f, -0.11882455f, 0.05866442f, 0.10006031f, -0.07848904f, 
    -0.04411376f, -0.10558535f, 0.05512702f, -0.18857601f, 0.08153413f, -0.01979611f, 0.08254163f, -0.01596077f, 
    0.03615743f, 0.08522253f, -0.00042255f, -0.20388582f, -0.32291451f, -0.05086241f, 0.19936836f, 0.06796795f, 
    0.02917168f, 0.00882309f, -0.09914631f, 0.04288777f, 0.01025360f, -0.15581481f, -0.01387490f, -0.00579313f, 
    -0.12390634f, 0.03503267f, -0.20599079f, -0.27371898f, -0.04821040f, 0.02523263f, -0.08210015f, -0.00087593f, 
    -0.02176105f, -0.09188157f, -0.10000950f, -0.01731851f, 0.24509771f, 0.08993535f, 0.05210165f, 0.00304327f, 
    -0.01216584f, -0.13486969f, -0.02523489f, 0.08257353f, -0.14280415f, -0.00906938f, 0.02085242f, 0.25090310f, 
    0.07849658f, 0.01808470f, 0.03674858f, 0.34860063f, 0.05458607f, -0.12534915f, -0.02197417f, -0.04222893f, 
    -0.05512608f, -0.00031830f, -0.06720703f, 0.15893951f, -0.45311528f, 0.01494470f, 0.09306421f, 0.10228501f, 
    0.17651917f, 0.19943310f, 0.02820349f, 0.07067730f, 0.14423569f, -0.08804315f, 0.07411431f, 0.03440662f, 
    -0.01298464f, -0.01276876f, -0.09398650f, 0.10439472f, -0.02156777f, 0.22259182f, 0.01222104f, 0.06329416f, 
    0.01500134f, -0.10227919f, -0.14198934f, -0.11976621f, -0.82993758f, -0.28489515f, -0.34388655f, -0.42147198f, 
    0.07633778f, -0.03160450f, -0.24105114f, -0.00060692f, -0.16456532f, -0.13172507f, -0.05507070f, -0.08235304f, 
    0.05896441f, -0.13286163f, -0.10371003f, -0.12757252f, 0.10846343f, -0.01562145f, 0.18936257f, 0.07097778f, 
    0.00711973f, -0.01222513f, -0.04494823f, 0.03712968f, 0.35398802f, 0.08992314f, -0.18562913f, -0.11855415f, 
    -0.29188034f, -0.07829104f, -0.02911575f, -0.09744582f, 0.11092536f, -0.06210735f, 0.03647453f, -0.10978655f, 
    0.40744743f, -0.10080008f, -0.24166307f, 0.20507188f, -0.06436570f, -0.18844727f, -0.06648317f, -0.06769444f, 
    0.02802528f, 0.04729896f, -0.06456252f, -0.02607585f, -0.05074548f, -0.26450172f, -0.13716216f, 0.09773009f, 
    0.06596723f, 0.03673354f, -0.06938981f, 0.12724920f, -0.18285511f, -0.01448905f, -0.01254653f, -0.10799740f, 
    -0.16092041f, 0.23113808f, -0.12376233f, -0.11302704f, 0.11769147f, 0.06295944f, 0.07069475f, -0.02971382f, 
    0.19120894f, 0.08319777f, 0.04358986f, 0.12127041f, 0.18376142f, 0.03702964f, -0.10303967f, -0.04007871f, 
    -0.07577833f, -0.04302232f, -0.07547742f, 0.06849302f, 0.06849994f, 0.00912565f, -0.13914295f, -0.15056136f, 
    -0.50476182f, 0.47725376f, -0.16404371f, -0.01053141f, -0.21442130f, -0.14732519f, -0.00312370f, -0.01298564f, 
    0.05290508f, 0.17189075f, 0.05108371f, -0.01009057f, 0.31748983f, -0.03719489f, -0.00504273f, 0.02777313f, 
    -0.13375916f, 0.09959356f, 0.06238529f, 0.02698449f, -0.02573241f, 0.09845260f, -0.06164663f, 0.10423668f, 
    0.04048222f, 0.27651635f, -0.02374065f, 0.00413120f, -0.05768612f, -0.06050194f, 0.11535982f, -0.09558529f, 
    -0.16095845f, 0.17989977f, -0.00444285f, -0.10131542f, 0.47770140f, -0.01679750f, -0.21387483f, 0.33713248f, 
    -0.24285367f, -0.04309951f, -0.13361400f, 0.06003415f, 0.11918098f, -0.15376173f, 0.12496820f, -0.12392405f, 
    0.31246439f, -0.29823211f, -0.31623748f, -0.08218358f, 0.00982916f, -0.06354326f, -0.01227783f, 0.02464055f, 
    0.08675294f, 0.10185441f, 0.05775340f, 0.09165824f, 0.03058280f, -0.29444098f, 0.08391529f, -0.30022973f, 
    0.21915400f, 0.13714536f, -0.00939692f, 0.00388583f, 0.00442455f, -0.09897266f, -0.10755610f, 0.00302541f, 
    0.00579477f, 0.06883480f, 0.00242985f, -0.40145755f, 0.27303430f, -0.18326502f, 0.03292938f, 0.12709013f, 
    -0.01541103f, -0.07649063f, -0.00419424f, -0.10178272f, -0.68565589f, -0.20836228f, 0.03545022f, -0.27333683f, 
    -0.05462460f, 0.06200262f, 0.10909328f, 0.11643551f, -0.10386083f, 0.18514776f, -0.10811917f, -0.27902728f, 
    0.10370956f, -0.31428403f, 0.02189524f, 0.15466447f, -0.24117488f, 0.00016373f, -0.11410720f, 0.15046628f, 
    -0.04375128f, 0.03055812f, -0.05297120f, -0.02897424f, 0.52604103f, 0.05595765f, 0.04028303f, -0.21379215f, 
    0.03692646f, -0.00210234f, 0.00657415f, 0.04095833f, 0.05610232f, -0.09416343f, 0.08319582f, 0.04481649f, 
    -0.44607943f, 0.29621720f, -0.18639767f, 0.10440728f, 0.05935152f, -0.11919425f, 0.07388847f, -0.07582880f, 
    -0.07623937f, -0.08509925f, 0.09267358f, -0.01908960f, 0.33205241f, -0.27134138f, -0.05241295f, 0.06991001f, 
    0.11186083f, 0.04492798f, 0.05536771f, 0.02435994f, -0.04980284f, -0.08764029f, 0.00713133f, 0.08481769f, 
    0.21000721f, -0.00959299f, -0.15792078f, -0.11858923f, -0.09530514f, -0.04749008f, 0.15635630f, 0.12622619f, 
    -0.01833858f, 0.00143184f, -0.12082863f, 0.03305602f, -0.07351422f, 0.19366962f, -0.19654433f, 0.14988089f, 
    0.31268719f, 0.09203163f, -0.19247696f, 0.05770409f, -0.01980809f, -0.04184634f, -0.08654235f, 0.00322409f, 
    -0.58577937f, 0.08460202f, -0.06852900f, 0.17558211f, -0.00928679f, 0.14716199f, -0.05118575f, 0.17278779f, 
    0.00706271f, -0.01929718f, 0.06344246f, 0.02066743f, -0.20230599f, 0.18079647f, 0.19129571f, -0.02470623f, 
    -0.07620772f, -0.29081646f, -0.00572713f, -0.18551750f, -0.13938454f, 0.01820084f, 0.05869967f, -0.20912854f, 
    0.03376788f, -0.00425963f, -0.17728962f, 0.04193325f, 0.08628844f, -0.07303948f, -0.20297545f, 0.00424034f, 
    0.05448804f, 0.03291670f, 0.23109630f, 0.23023656f, 0.07718469f, 0.11462176f, -0.11946078f, -0.12753992f, 
    -0.16131769f, -0.06885413f, 0.04672138f, -0.32541212f, -0.12974863f, -0.12675837f, -0.10325462f, -0.21966988f, 
    0.20926955f, 0.23330507f, -0.11462115f, 0.04259222f, 0.06777582f, -0.13494013f, -0.04839751f, 0.06685542f, 
    -0.06736768f, 0.00702493f, 0.08803552f, -0.25065792f, 0.16737045f, 0.23358309f, -0.17920266f, -0.02393363f, 
    -0.10867269f, 0.00217754f, 0.14227715f, -0.12938361f, 0.01706251f, 0.09013247f, -0.08912068f, -0.02709496f, 
    0.21978192f, -0.10252447f, -0.29929733f, -0.06967696f, 0.16258258f, -0.00660545f, 0.04844591f, 0.01651003f, 
    0.01651786f, 0.00276642f, -0.08995566f, 0.04094613f, -0.15431759f, 0.24747530f, -0.13984852f, -0.14001994f, 
    0.10001326f, -0.09994224f, 0.05001004f, -0.07573727f, -0.16933081f, -0.02814188f, -0.05870580f, 0.02135489f, 
    -0.02978741f, 0.06041105f, 0.09658737f, -0.16816264f, -0.06157040f, 0.07853960f, -0.01969986f, 0.02991892f, 
    -0.08783300f, -0.06474435f, 0.09212462f, 0.06100462f, 0.34898269f, 0.14560904f, -0.17706165f, -0.33325380f, 
    0.00953083f, -0.00599124f, -0.04131801f, 0.14736669f, 0.01948590f, 0.09911508f, 0.07395914f, -0.03670022f, 
    -0.58912551f, 0.23764770f, 0.17360432f, 0.08225174f, 0.16929190f, -0.10112283f, -0.02788313f, -0.04337744f, 
    0.12185504f, 0.04532556f, 0.11136980f, 0.12627563f, -0.10276027f, -0.27585763f, -0.08904625f, -0.48697567f, 
    -0.05040875f, 0.00326327f, -0.03027907f, 0.06398892f, 0.15340626f, -0.00848168f, 0.02790710f, -0.02384982f, 
    0.33997583f, -0.29689604f, -0.17978010f, 0.52007496f, 0.12638222f, 0.09684844f, -0.02466861f, 0.09077404f, 
    -0.00289082f, 0.13257347f, 0.09791772f, -0.05569191f, -0.09102928f, -0.25864100f, -0.18551874f, 0.01154691f, 
    -0.03229260f, -0.11076532f, 0.15185159f, 0.03425088f, 0.05606974f, 0.04746458f, -0.05677720f, -0.26526317f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09023413f, 0.07106831f, -0.05748157f, -0.03098404f, -0.01248268f, 0.01660972f, -0.02465649f, -0.04039276f, 
    -0.06245029f, -0.00256463f, 0.11271498f, -0.02252986f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
