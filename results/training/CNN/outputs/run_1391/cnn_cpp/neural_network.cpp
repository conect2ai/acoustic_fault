#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55512422f, 0.95583653f, 0.86101735f, -0.54050219f, -0.62087554f, -0.73769313f, -0.16524039f, -0.29231960f, 
    -0.09272917f, -0.50323194f, 0.13242425f, -0.15102729f, 0.22196743f, -0.09436382f, 0.05563338f, 0.00010790f, 
    0.14595623f, 0.17892158f, 0.27374399f, -0.05670444f, -0.06102410f, 0.08750473f, -0.16570264f, -0.15854345f, 
    -0.10659116f, -0.17530051f, 0.22820045f, 0.34668308f, 0.27499571f, 0.09719432f, -0.38352183f, -0.42333806f, 
    -0.04584222f, 0.36825690f, 0.27737969f, -0.14816849f, -0.19966839f, 0.04770257f, -0.07793520f, -0.10786034f, 
    0.07347167f, -0.15219663f, -0.15300699f, 0.16043866f, 0.08291586f, -0.33143383f, -0.06552356f, 0.14853179f, 
    0.12714943f, -0.20400754f, 0.42824370f, -0.07004049f, -0.63678074f, -0.84531033f, -0.66186172f, -0.11543545f, 
    0.07002397f, 0.15291424f, 0.26052490f, 0.14433630f, 0.00750992f, 0.38873765f, -0.09077922f, -0.26666009f, 
    -0.14248250f, -0.18974796f, -0.45251903f, -0.25795087f, -0.30685595f, -0.48994574f, -0.17875893f, 0.05282041f, 
    0.43336338f, 0.07853342f, -0.03269798f, 0.52860743f, 0.25682583f, -0.07001467f, -0.14396611f, -0.39968494f, 
    -0.20463540f, -0.08014874f, 0.13061203f, 0.29806414f, -0.26196930f, 0.08017678f, -0.40260702f, 0.03276629f, 
    0.15341470f, -0.16945343f, 0.44371897f, 0.25222042f, -0.09988046f, -0.18378216f, -0.62892234f, -0.06656617f, 
    -0.12245323f, -0.45847145f, 0.03077579f, -0.38378382f, -0.38650417f, -0.46964282f, -0.13917008f, -0.29717958f, 
    -0.47117609f, -0.60439986f, -0.98355585f, -0.58591700f, -0.53467518f, -0.77002519f, 0.00376158f, 0.20001270f, 
    0.23399377f, -0.12358835f, -0.04400671f, -0.12529546f, -0.15792452f, -0.23823901f, -0.18399517f, -0.20270355f, 
    -0.00415107f, 0.21512713f, 0.02298091f, -0.21121223f, 0.07708847f, -0.44000050f, -0.32752559f, 0.17564295f, 
    0.16416512f, 0.12966211f, 0.26755631f, -0.16047701f, -0.12528081f, 0.31513774f, 0.60325235f, -0.24121930f, 
    0.30364805f, -0.27801320f, -0.08280840f, 0.34611991f, -0.47628608f, -0.04835169f, 0.11193114f, 0.02796997f, 
    -0.10872610f, 0.32267171f, 0.18799898f, 0.26263812f, 0.11906374f, -0.44778562f, -0.70024389f, 0.11723799f, 
    0.45814356f, -0.09115671f, -0.08936517f, -0.22315362f, 0.08195042f, 0.38344067f, -0.15866347f, -0.15860011f, 
    -0.06908701f, 0.26453853f, -0.23636535f, 0.28514579f, -0.39782983f, -0.10559646f, -0.12846406f, -0.09668740f, 
    0.02161885f, 0.14962277f, -0.00481401f, 0.22315919f, 0.34058461f, 0.13444509f, -0.16960722f, -0.62463182f, 
    -0.53058624f, 0.09181691f, -0.28859001f, 0.13880384f, 0.13195564f, 0.14973681f, 0.29633719f, 0.04967824f, 
    0.13809839f, -0.03436285f, 0.02631784f, -0.25785536f, -0.10038598f, 0.35497785f, 0.04643817f, 0.20395221f, 
    -0.11489150f, -0.09238739f, -0.31309736f, -0.00893754f, 0.54711467f, -0.10747254f, 0.15073462f, -0.02987357f, 
    1.01639628f, -1.01329875f, -0.88487124f, -0.08890012f, -0.10427137f, 0.76195401f, 0.75022155f, 0.61471778f, 
    -0.29106691f, -0.30148029f, -0.35710251f, -0.24716564f, -0.19445123f, -0.06132784f, 0.09297739f, 0.07491778f, 
    0.06452683f, 0.13113923f, 0.02326690f, -0.12386076f, 0.17042856f, -0.10998068f, -0.22611217f, 0.15987827f, 
    -0.07928877f, 0.88964778f, 0.00375412f, -0.35056487f, -0.10758552f, -0.58680809f, 0.09668972f, 0.01274281f, 
    -0.15744877f, 0.36560756f, 0.08398312f, 0.34527645f, -0.16419506f, -0.31438425f, 0.17381671f, 0.09156280f, 
    -0.19241840f, -0.00108698f, 0.13850626f, 0.03048347f, -0.09154010f, -0.00313846f, 0.11003796f, 0.03402994f, 
    -0.18645413f, 0.19747888f, 0.42532489f, -0.64670408f, -0.67049247f, -0.35507146f, -0.03403823f, 0.44684333f, 
    -0.12587529f, 0.13928990f, 0.44535595f, -0.17842765f, 0.37765589f, -0.22111885f, 0.33212355f, -0.39412868f, 
    -0.05231553f, 0.07570095f, -0.36462754f, 0.10104455f, -0.40512931f, 0.05518913f, -0.11264841f, 0.07999580f, 
    0.02446878f, 0.03854711f, 0.26130179f, 0.60915953f, -0.35759264f, -0.11052402f, 0.02764081f, -0.27202216f, 
    0.32361406f, -0.13207319f, 0.14855562f, -0.16775949f, -0.02190415f, -0.02719191f, 0.30638942f, -0.41800430f, 
    -0.16082275f, 0.23939790f, -0.24578889f, 0.07931615f, 0.21728498f, 0.08226822f, -0.24151435f, -0.01637153f, 
    -0.11140430f, 0.03386331f, 0.12763673f, 0.20178984f, 0.12307199f, -0.10151344f, -0.35351822f, 0.05556193f, 
    -0.29388684f, -0.07287509f, 0.25117868f, 0.20751239f, 0.02874996f, -0.39923054f, 0.23505968f, 0.12079938f, 
    -0.21430071f, 0.41941622f, -0.04183297f, 0.06389937f, 0.21379587f, -0.47670889f, -0.30455858f, -0.27020746f, 
    0.18388593f, 0.19713607f, 0.20930098f, 0.22631730f, -0.12363324f, 0.35419774f, -0.07072324f, 0.17031148f, 
    0.06752527f, -0.28470346f, 0.34982425f, 0.17321084f, 0.07448512f, -0.03272068f, 0.00750359f, 0.32110262f, 
    -0.31493324f, -0.27692729f, -0.20023289f, -0.11017584f, -0.01107616f, -0.01517731f, -0.10437573f, 0.30089742f, 
    -0.26991555f, 0.32689458f, 0.09300324f, -0.20403484f, -0.25293291f, -0.15543869f, -0.40351212f, -0.44845408f, 
    -0.46203962f, -0.29909188f, -0.41862276f, -0.11377418f, 0.22097500f, 0.03316925f, -0.48953396f, -0.07221364f, 
    -0.11594222f, 0.00465220f, 0.21698731f, -0.27449971f, -0.18722603f, -0.01707586f, 0.09338673f, -0.09241508f, 
    0.24985163f, 0.31909540f, 0.32473773f, -0.01150627f, 0.03297001f, 0.24915710f, -0.32043654f, 0.01128756f, 
    0.33756912f, -0.47816738f, -0.67498451f, -0.63955832f, -0.15712288f, 0.23853946f, 0.39748490f, 0.39931095f, 
    0.24033189f, 0.14213495f, 0.15421721f, -0.18689747f, -0.02461594f, 0.09558202f, -0.13063434f, 0.08041775f, 
    0.13719529f, 0.05899942f, -0.08953945f, 0.11578331f, 0.11316566f, -0.02175473f, -0.28852841f, 0.17452642f, 
    -0.39836594f, -0.44883934f, -0.60243613f, 0.13543887f, -0.60183346f, 0.47924837f, -0.01712448f, 0.02346591f, 
    0.08036827f, -0.16809322f, -0.02476039f, 0.10055704f, -0.03490384f, 0.18001010f, 0.15995468f, 0.02550890f, 
    -0.25934780f, 0.06351670f, 0.26960167f, -0.06929968f, -0.26702201f, 0.02512401f, 0.20881313f, -0.18479742f, 
    -0.44152835f, 0.63885021f, -0.54812342f, -0.09201249f, 0.11578263f, 0.19979450f, -0.04630062f, -0.06368811f, 
    0.19850378f, -0.27695003f, -0.34270084f, -0.12210651f, -0.07433916f, 0.48743927f, -0.47525853f, 0.20768519f, 
    -0.25000960f, -0.17378137f, 0.20926811f, 0.32454532f, -0.28550711f, -0.13293868f, -0.32096761f, -0.27436432f, 
    0.07203618f, 0.27091345f, -0.48798785f, -0.52142936f, -0.44747341f, -0.42633757f, 0.02431770f, 0.07297055f, 
    -0.34892374f, -0.50132269f, -0.66125214f, -0.52234226f, -0.23582861f, -0.28005686f, -0.14978448f, 0.10783034f, 
    -0.32836917f, -0.12150763f, -0.40992951f, -0.25339109f, -0.14207472f, -0.46199331f, -0.41831496f, 0.15775371f, 
    -0.21498145f, -0.02819683f, 0.02421252f, -0.76774651f, -0.71914393f, 0.36062720f, 0.60198468f, 0.34159315f, 
    0.35216463f, 0.39246768f, 0.20291963f, -0.07929585f, -0.28167692f, -0.11516976f, 0.04209311f, -0.26324892f, 
    0.15135762f, -0.43146744f, 0.02786132f, 0.09995307f, -0.22246031f, -0.20540594f, 0.08172116f, -0.18340372f, 
    -0.22863241f, 0.19177528f, 0.19160971f, 0.01215333f, 0.42884260f, 0.44018841f, 0.16702975f, 0.09409294f, 
    0.23271190f, -0.20796105f, -0.05002147f, -0.27244371f, 0.10973080f, 0.14471395f, -0.29160878f, -0.11958615f, 
    -0.04891945f, 0.07501419f, -0.13912754f, -0.06990890f, 0.23469609f, 0.14415459f, -0.05250455f, -0.06810878f, 
    -0.22472711f, 0.01887089f, -0.18419258f, -0.25019413f, -0.45392162f, 0.39572319f, 0.80209035f, 0.38122821f, 
    -0.49332517f, -0.58069688f, -0.68420035f, -0.43426207f, -0.30635959f, -0.53738022f, -0.58240116f, 0.40524843f, 
    0.29417336f, 0.26620382f, 0.28509164f, 0.08221403f, -0.14671123f, -0.22205324f, -0.16866380f, -0.11062909f, 
    -0.25029859f, 0.02844823f, 0.03921648f, -0.09351505f, 0.01665704f, 0.16344303f, -0.43239006f, -0.37768638f, 
    -0.49079561f, -0.57399905f, -0.42697674f, 0.22860003f, -0.03082986f, 0.10664410f, -0.05516241f, -0.27158430f, 
    -0.37890452f, -0.02721526f, -0.04488985f, -0.10511942f, -0.08909062f, -0.12403464f, -0.13233048f, -0.12064108f, 
    -0.34581643f, -0.35557130f, -0.08760806f, 0.50516993f, 0.13481568f, -0.08941718f, 0.15363656f, 0.20810467f, 
    0.40050179f, 0.28192553f, -0.01147082f, -0.36146003f, -0.53104895f, -0.33572921f, 0.17120932f, 0.15983701f, 
    -0.09207778f, -0.07892929f, 0.23859385f, 0.09477680f, 0.44149873f, -0.33061627f, 0.08177476f, 0.04909269f, 
    -0.06516705f, -0.27346259f, -0.20818087f, 0.13846596f, 0.09855602f, 0.06008871f, -0.08650809f, 0.02239735f, 
    0.57238430f, 0.04573210f, 0.00004580f, -0.19229029f, -0.34858090f, -0.13218860f, 0.13281456f, 0.23362324f, 
    -0.24498472f, 0.09104855f, 0.16203469f, -0.02221723f, 0.02407893f, -0.32279801f, -0.19536676f, 0.11308812f, 
    -0.18769510f, -0.16125178f, 0.21719520f, 0.09898553f, -0.36711398f, 0.02816017f, 0.17466938f, -0.07817980f, 
    0.16177937f, -1.07749784f, -0.50412381f, -0.71760637f, -0.28927901f, 0.22353798f, 0.19557412f, 0.18731542f, 
    0.00128208f, -0.51027107f, -0.12106293f, -0.09988389f, -0.34837502f, -0.48807135f, -0.12722096f, 0.23023738f, 
    0.15684865f, -0.11655612f, -0.14336745f, -0.37270328f, -0.12688829f, -0.07956689f, -0.17642891f, 0.14407878f, 
    -0.09943505f, -0.14572391f, 0.48223868f, 0.38158527f, -0.21543144f, -0.06294596f, -0.17308433f, 0.27175337f, 
    -0.15709798f, -0.16432902f, 0.18968499f, 0.36216822f, 0.03126488f, -0.04866314f, -0.17220515f, -0.25310469f, 
    -0.28579831f, -0.00942229f, -0.21301925f, 0.02503929f, -0.06323370f, 0.11391225f, -0.13683622f, -0.00016220f, 
    0.05089702f, -0.13893668f, 0.18547301f, 0.10989755f, 0.12816876f, 0.27182451f, -0.15032297f, -0.30148473f, 
    0.40297791f, 0.34363800f, -0.20034072f, -0.34580466f, 0.23626144f, 0.07607287f, 0.44359890f, -0.17207694f, 
    -0.35767394f, -0.05059050f, 0.09989045f, -0.06827976f, 0.21092103f, -0.06152711f, -0.29088101f, -0.26381570f, 
    0.31664714f, -0.09296909f, -0.08882535f, 0.20016384f, -0.29465675f, -0.25791958f, -0.41989219f, -0.41572779f, 
    -0.03720627f, 0.05824225f, -0.38000751f, 0.00163331f, -0.07279155f, -0.42416242f, 0.14532088f, 0.38761640f, 
    -0.07980515f, -0.13851598f, -0.16364583f, -0.17247307f, 0.07543458f, -0.17772722f, -0.04057597f, -0.07926918f, 
    0.17713197f, 0.34112024f, 0.30348516f, 0.12686524f, 0.46605167f, -0.42150921f, 0.01603930f, -0.09988230f, 
    -0.16388495f, 0.32351574f, -0.24521238f, -0.12463801f, 0.43525025f, 0.08680810f, 0.56075275f, -0.22844350f, 
    -0.25108716f, 0.02279604f, 0.09536799f, 0.00417935f, -0.29254371f, 0.16176318f, -0.32575208f, 0.02433493f, 
    -0.13441625f, 0.16624044f, 0.12760960f, 0.24116935f, 0.26000986f, -0.16453625f, -1.22930300f, 0.12805970f, 
    -0.33626771f, -1.12770021f, -0.49824253f, 0.71737647f, -0.32164514f, -0.14023603f, 0.09678386f, 0.40160570f, 
    0.04355560f, -0.31359065f, -0.09187815f, -0.58814001f, -0.28141159f, 0.19278397f, -0.14581186f, -0.03408325f, 
    0.18372896f, 0.21607763f, -0.03468201f, 0.00391413f, -0.03384073f, -0.14976607f, -0.25725952f, -0.84618533f, 
    0.28451669f, 0.07254378f, 0.26544231f, 0.08470795f, -0.72087920f, -0.24459112f, 0.61769336f, 0.28932700f, 
    -0.27751225f, -0.41421127f, -0.18010364f, 0.32728690f, 0.34698561f, -0.20456181f, 0.10518520f, -0.18962716f, 
    -0.37763470f, -0.53305894f, -0.41516659f, -0.23253681f, -0.26781648f, -0.08346049f, 0.03945462f, -0.11454076f, 
    -0.22692044f, 0.31424934f, -0.52968460f, -0.76631308f, -0.76293635f, -0.00912143f, 0.17060663f, 0.11264511f, 
    -0.06726085f, 0.20926256f, 0.17132300f, 0.11650147f, -0.10485312f, 0.25921181f, 0.25611517f, 0.23053201f, 
    0.02897056f, 0.15044600f, -0.20944560f, -0.02644056f, 0.08025452f, -0.25985333f, -0.30289856f, -0.14302514f, 
    0.13150127f, 0.11537682f, -0.31579599f, 0.15757465f, -0.10253163f, 0.51533031f, -0.23878284f, -0.32246393f, 
    -0.65110940f, -0.27543855f, 0.49259710f, -0.15874581f, 0.32527342f, -0.17303933f, -0.14773901f, 0.07028098f, 
    0.08720365f, -0.13834475f, -0.19343828f, 0.02403459f, -0.05915260f, -0.23150727f, -0.16869330f, -0.07618222f, 
    -0.09580477f, -0.15700001f, 0.09936288f, -0.28609440f, 0.31134826f, -0.07549710f, 0.29718596f, 0.05311898f, 
    0.47327730f, 0.44738662f, -0.14847673f, -0.25878614f, -0.08396983f, 0.21506074f, 0.45601374f, -0.53776878f, 
    -0.25182012f, -0.01656300f, -0.08153863f, -0.34430185f, -0.15616280f, -0.11952949f, 0.29758564f, 0.33036572f, 
    -0.14068885f, -0.17359506f, 0.09816039f, 0.27732840f, -0.07574690f, 0.50269634f, 0.00620048f, -0.25574449f, 
    -0.82807767f, -0.24160394f, -0.10657686f, 0.07683874f, 0.04221764f, -0.40059364f, -0.04096448f, 0.21408400f, 
    -0.12589528f, 0.20381780f, 0.22075854f, -0.12388298f, -0.10415560f, -0.18789735f, -0.56555653f, 0.19502047f, 
    -0.30885619f, -0.23754078f, -0.07147223f, 0.00574874f, -0.29498407f, -0.01553975f, 0.32395279f, 0.28844473f, 
    -0.43613195f, -0.06252140f, 0.38267851f, -0.02802871f, 0.00726727f, 0.08246455f, -0.00958172f, 0.09246305f, 
    -0.00216207f, -0.16900675f, -0.04005818f, -0.25221968f, -0.00945033f, 0.04785208f, -0.51204187f, 0.43126154f, 
    -0.31157950f, 0.22765464f, -0.01581221f, -0.06297755f, 0.14763084f, 0.30250907f, 0.38317427f, 0.15463677f, 
    -0.35353225f, 0.14187212f, -0.00266863f, -0.07906575f, -0.16441159f, -0.14675504f, -0.14333783f, 0.02037515f, 
    0.10168869f, 0.07942731f, -0.01350158f, 0.03036861f, -0.08191944f, -0.03776651f, 0.17892826f, -0.06187366f, 
    -0.00101546f, -0.25614718f, 0.08699806f, 0.06822928f, 0.14671345f, -0.01433056f, 0.59676468f, -0.07277820f, 
    -0.46109930f, -0.30544004f, -0.15401927f, 0.17552352f, 0.36608332f, 0.15864971f, -0.02293923f, -0.05551847f, 
    -0.22014245f, -0.17561489f, -0.19201379f, 0.25666282f, 0.38382867f, 0.03330001f, -0.24071977f, -0.11921064f, 
    -0.10455114f, 0.11535759f, 0.31020874f, 0.10040182f, -0.06800985f, -0.17553058f, -0.17942268f, -0.28358898f, 
    0.43891379f, 0.24928562f, -0.23519883f, 0.21621434f, -0.14275302f, -0.23783711f, -0.20669143f, 0.27572006f, 
    0.07059307f, 0.07048100f, 0.06622630f, -0.27790833f, -0.52957344f, 0.24902165f, -0.10819478f, 0.33580959f, 
    -0.18555225f, 0.07373183f, -0.14405847f, 0.00233336f, 0.01396006f, 0.16741574f, -0.07584451f, -0.33115759f, 
    -0.73914790f, -0.57759321f, -0.14510146f, -0.57237536f, -0.22726493f, 0.62155551f, -0.09274197f, -0.25797722f, 
    0.41300938f, 0.17535609f, -0.29200578f, -0.33386832f, 0.06318170f, 0.51789260f, -0.06138423f, 0.10226128f, 
    0.06338128f, -0.46329382f, -0.41098800f, -0.11802302f, -0.06335232f, 0.05632297f, 0.25413862f, -0.23188172f, 
    -0.32266074f, -0.14572948f, -0.66025984f, -0.47643217f, -0.03375636f, -0.25616169f, -0.14805774f, -0.12528056f, 
    -0.27919805f, -0.13439862f, -0.33454511f, 0.47081307f, 0.57584816f, 0.19363013f, 0.18163960f, 0.06520722f, 
    -0.16427571f, -0.17476176f, -0.16586648f, 0.03759851f, -0.22095713f, -0.26699257f, -0.19156726f, -0.19237466f, 
    -0.02905313f, -0.43040165f, -0.55746996f, 0.22360899f, 0.57426816f, 0.05734969f, -0.30757147f, -0.51848614f, 
    0.39510226f, -0.35375500f, 0.24137923f, -0.76440072f, -0.01143473f, -0.53094977f, -0.36881453f, -0.28063235f, 
    0.09786192f, 0.06499031f, -0.38990936f, -0.21840326f, -0.34338143f, -0.12553573f, -0.17576182f, -0.24225388f, 
    0.04652246f, -0.02029495f, -0.30380017f, -0.80904675f, 0.50267053f, -0.11068521f, 0.27932936f, -0.19831133f, 
    -0.28833601f, -0.42596731f, -0.44725701f, 0.23935200f, 0.83306199f, 0.24083503f, 0.20473582f, -0.09213846f, 
    -0.10343575f, -0.11528924f, -0.01734271f, 0.07771389f, -0.20702167f, -0.26578233f, 0.11457066f, 0.00945276f, 
    -0.15855883f, 0.12075882f, 0.06019300f, 0.24999312f, -0.85390073f, -0.53046626f, -0.03950337f, 0.08920680f, 
    0.46895614f, 0.21795599f, 0.12469274f, 0.03117666f, 0.24437776f, 0.18105830f, -0.36022311f, -0.35003403f, 
    -0.23806763f, -0.05689209f, -0.33740932f, 0.17413655f, -0.01323182f, 0.22308469f, 0.29512852f, -0.06708885f, 
    -0.17472988f, -0.14307557f, -0.28627023f, -0.30662739f, -0.35935795f, -0.14574167f, -0.04345025f, -0.05484778f, 
    0.12135021f, 0.24022786f, 0.21166459f, 0.09631784f, -0.01826460f, -0.07235844f, -0.13936268f, 0.15811256f, 
    0.20407334f, -0.15550792f, -0.23683967f, 0.15390193f, -0.26211128f, -0.26450300f, 0.17322686f, -0.03872819f, 
    0.28229049f, -0.30625314f, 0.00914652f, 0.12604025f, 0.15070184f, 0.16554846f, -0.08606975f, 0.48128214f, 
    0.27371132f, -0.57926798f, -0.41376579f, 0.07134657f, 0.48592582f, 0.32291606f, -0.17537530f, -0.39894769f, 
    0.07676958f, 0.01700199f, -0.30186898f, -0.19130488f, 0.18345399f, 0.34900287f, -0.14119260f, 0.10476845f, 
    0.14200850f, -0.29890165f, -0.14153236f, -0.20408526f, -0.19767563f, -0.06228474f, -0.13410787f, 0.41516930f, 
    0.05042174f, -0.34124941f, -0.00076699f, 0.04103515f, 0.17007399f, -0.08589049f, -0.06363262f, -0.21864399f, 
    -0.18074407f, -0.08493812f, -0.30531120f, 0.40518087f, -0.15845133f, -0.13132338f, 0.07993236f, 0.08197813f, 
    0.00501201f, -0.27042744f, 0.15382940f, -0.12231749f, -0.00248463f, 0.13467871f, 0.17971984f, 0.03225753f, 
    0.01745394f, -0.48915899f, -0.48321092f, -0.32432014f, -0.23528381f, -0.64569879f, -0.71820837f, -0.42986876f, 
    -0.31563219f, -0.83537924f, 0.43880534f, -0.21460834f, 0.12162591f, 0.37016618f, 0.19535866f, 0.16036470f, 
    0.01072067f, 0.23019627f, -0.04925687f, 0.12722936f, -0.25917989f, -0.02184211f, 0.01569431f, -0.05694147f, 
    0.01514474f, -0.56060869f, 0.20622864f, 0.22541837f, 0.28541064f, 0.25539881f, -0.31844720f, -0.51065481f, 
    -0.15815130f, 0.24187581f, 0.42022747f, 0.18794332f, 0.24914369f, 0.04833190f, -0.19045760f, -0.15461564f, 
    -0.14626008f, -0.20890403f, 0.04718717f, 0.16209419f, -0.32025421f, 0.15477012f, 0.18952475f, 0.03835733f, 
    -0.02885960f, 0.16166660f, -0.56797475f, -0.02072140f, -0.65617335f, -0.93022776f, -0.07703726f, 0.29880798f, 
    -0.25846350f, 0.68384731f, 0.17756224f, 0.01653543f, -0.40117192f, -0.17743422f, -0.09528539f, -0.08029973f, 
    -0.17742358f, 0.23358113f, 0.07203256f, 0.09252217f, -0.00464766f, 0.27558321f, -0.05737915f, -0.12180527f, 
    0.03213013f, 0.14465347f, 0.00071106f, 0.37061360f, -0.04256530f, -0.21878074f, 0.06208521f, -0.45620379f, 
    -0.18881975f, -0.03097378f, 0.07663637f, 0.23662288f, 0.21284464f, -0.44144523f, -0.30112413f, -0.17026499f, 
    0.15520707f, 0.41686121f, -0.03038918f, -0.05222420f, 0.00386267f, 0.13564804f, -0.33021918f, -0.17897005f, 
    -0.18048730f, -0.14258353f, -0.10139504f, -0.56943756f, 0.49939084f, 0.31666324f, 0.23656519f, 0.33520836f, 
    0.16746245f, 0.26108047f, 0.17964946f, -0.04741243f, -0.23728597f, -0.13256441f, -0.04210779f, 0.09442257f, 
    0.07984643f, 0.12959243f, -0.03527668f, -0.11662552f, -0.12611485f, 0.12902541f, 0.00407385f, -0.09483332f, 
    0.08756729f, 0.15284252f, 0.02699699f, -0.11696027f, -0.08533031f, 0.46135390f, -0.16127414f, 0.37412739f, 
    -0.58619654f, -0.24218927f, -0.07399026f, 0.09564353f, 0.17000172f, 0.29276678f, -0.08689470f, -0.09779913f, 
    0.05843971f, -0.11260191f, -0.36198342f, -0.15736066f, -0.10727510f, -0.10045961f, -0.15578811f, -0.16161457f, 
    -0.31127453f, -0.56290013f, -0.47600111f, -0.51207781f, -0.59380829f, -0.68290031f, -0.08216272f, 0.40146586f, 
    -0.02581251f, -0.02059891f, -0.02924282f, -0.27433726f, -0.32850650f, 0.08517834f, 0.14523774f, -0.22337402f, 
    -0.33414179f, 0.39237040f, 0.06226254f, 0.50894785f, -0.39759207f, -0.04533688f, 0.12885807f, -0.07149324f, 
    -0.07320865f, -0.23943797f, -0.07127149f, 0.17350107f, 0.03355882f, -0.04518623f, 0.05227734f, -0.45179015f, 
    0.21643747f, -0.09971058f, 0.16465424f, -0.07365894f, -0.18259010f, -0.05275428f, 0.20472662f, -0.00857458f, 
    -0.12255732f, 0.15987812f, -0.51441789f, 0.20169166f, 0.54756993f, -0.27498665f, -0.04342791f, -0.35319388f, 
    0.04941198f, 0.17574415f, -0.02176680f, -0.33113772f, 0.01436619f, -0.13290243f, 0.32768455f, 0.17860129f, 
    0.32863390f, -0.12861869f, -0.37074819f, -0.23169652f, 0.61064219f, -0.14848468f, -0.43163213f, -0.01377361f, 
    -0.38816202f, -0.37212026f, 0.62881273f, 0.01675455f, 0.08542135f, 0.26465547f, -0.02194611f, 0.33451781f, 
    0.22887462f, -0.33913779f, -0.32395253f, -0.17684387f, -0.38922909f, 0.15643570f, 0.22985141f, -0.03174413f, 
    -0.07767257f, -0.96931779f, -0.40321028f, 0.54488468f, 0.67048842f, 0.25467449f, 0.56239247f, -0.44630414f, 
    -0.23460110f, 0.23915941f, 0.25679994f, -0.35439134f, -0.00368172f, -0.24424325f, 0.19807585f, -0.33006883f, 
    0.24450853f, 0.02304773f, -0.02421618f, -0.16965939f, 0.03300618f, -0.22791237f, -0.31228182f, 0.16079676f, 
    0.05285424f, -0.22708160f, -0.54912812f, -0.53084296f, -0.59775996f, -0.33788699f, -0.29411879f, 0.40315741f, 
    0.15200682f, 0.33654159f, 0.28952292f, 0.29403085f, 0.28564295f, 0.21571648f, -0.03944050f, -0.01784033f, 
    0.22292888f, -0.19937459f, -0.14563656f, -0.16722462f, -0.17199115f, 0.20891076f, -0.01322955f, -0.27094141f, 
    -0.08332173f, 0.19217640f, 0.10684073f, 0.50487232f, -0.21086372f, -0.28098407f, -0.19324507f, 0.32017791f, 
    0.03184699f, -0.11615997f, 0.19647393f, 0.37868881f, -0.34780890f, -0.70290023f, 0.75952041f, -0.44950688f, 
    -0.13869120f, 0.12404427f, -0.03297780f, 0.24750501f, 0.04096637f, -0.07459148f, -0.09380101f, 0.12679838f, 
    -0.03437036f, -0.05509862f, -0.25942963f, 0.25534168f, 0.46528131f, -0.52170283f, 0.07081395f, 0.41220859f, 
    0.00472051f, -0.21491772f, -0.04456132f, -0.20182885f, -0.13816221f, -0.01222218f, -0.04294784f, 0.08806628f, 
    -0.14900179f, -0.03707847f, 0.36929598f, -0.09290356f, -0.13608591f, -0.03939848f, 0.24334021f, -0.27643299f, 
    0.21816587f, -0.19609545f, -0.03475273f, 0.11721347f, 0.05445682f, -1.09450972f, -0.34637067f, -0.31887388f, 
    0.60445273f, 0.11876570f, 0.12626919f, -0.37744427f, 0.20664570f, 0.53172725f, 0.73524588f, 0.11760213f, 
    -0.08989495f, 0.11424658f, -0.23421122f, -0.09790295f, -0.18467548f, -0.20334917f, 0.08305559f, -0.03207114f, 
    0.29312307f, -0.08099688f, -0.02217824f, 0.09154357f, -0.10877178f, 0.16503277f, 0.21601610f, 0.11140385f, 
    -0.26239145f, 0.07474078f, 0.24025954f, -0.28137609f, -0.07635902f, 0.15488631f, -0.04062823f, -0.27394015f, 
    0.31123289f, -0.30319622f, -0.20103092f, -0.07259502f, 0.26139784f, 0.04307386f, 0.23881643f, -0.19485454f, 
    -0.14556035f, 0.04846541f, -0.25262061f, 0.00523069f, -0.05089061f, -0.03693004f, 0.17131877f, -1.01646030f, 
    -0.72231525f, -0.46096826f, 0.43027258f, 0.36772159f, 0.69096076f, -0.08868705f, 0.02780914f, 0.06998272f, 
    0.24547860f, 0.20454562f, 0.05463854f, -0.17049341f, -0.02012803f, -0.15684816f, -0.05530162f, 0.17354664f, 
    0.24904130f, 0.19986156f, 0.03273107f, -0.04620679f, -0.09191898f, -0.21435660f, 0.04143925f, -0.06279860f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20870359f, 0.25032303f, 0.20671251f, 0.13331297f, -0.21371570f, -0.00955343f, 0.15909801f, 0.08667799f, 
    -0.04385010f, 0.22375149f, 0.26581851f, 0.25079125f, 0.09926062f, 0.12568028f, -0.05384820f, 0.06938116f, 
    0.10547203f, 0.08067185f, -0.31832069f, 0.33872822f, 0.08643790f, 0.03151911f, -0.38174093f, 0.16868165f, 
    0.19825426f, -0.00282303f, 0.35564280f, 0.28292626f, -0.18218747f, 0.17307830f, -0.18371244f, 0.03403402f, 
    0.14642857f, 0.12342724f, 0.23589900f, 0.18493952f, 0.25411299f, 0.07346688f, 0.10098918f, 0.22273166f, 
    -0.15412980f, -0.02571778f, -0.12464739f, 0.16049923f, -0.21908124f, 0.01997451f, 0.06219481f, -0.00211905f, 
    0.07929500f, 0.15130231f, -0.02339411f, 0.05932199f, -0.00404859f, -0.00569528f, 0.12685253f, 0.17601927f, 
    0.11090025f, 0.02314465f, 0.21480992f, 0.05057245f, 0.18526849f, 0.12056279f, 0.19170998f, 0.12410660f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02863923f, -0.18329138f, -0.06108553f, 0.03922725f, -0.03987578f, -0.01043256f, -0.08890801f, -0.11308403f, 
    0.02652371f, 0.05444365f, -0.01407270f, 0.04749109f, -0.87668377f, 0.15658636f, 0.31534374f, -0.11980864f, 
    0.05972878f, -0.01201764f, 0.02491908f, 0.05395273f, -0.00790933f, 0.00321510f, -0.01557354f, 0.01729376f, 
    0.10284471f, -0.06847639f, -0.11243127f, 0.07388967f, 0.11346604f, 0.00733706f, -0.17377621f, -0.11348459f, 
    -0.09880442f, -0.14274654f, -0.17376044f, 0.14342262f, -0.24945475f, -0.30101827f, 0.10106442f, 0.07281689f, 
    -0.04652368f, -0.00621068f, -0.11503142f, 0.03206705f, -0.11361014f, 0.00454811f, 0.05176178f, 0.08593034f, 
    0.26521671f, 0.25016999f, -0.04582602f, -0.19399114f, 0.11298910f, 0.05141465f, -0.00953148f, 0.10655288f, 
    -0.00136316f, -0.03951468f, 0.02265195f, -0.00434982f, -0.13082014f, 0.04094908f, 0.17097239f, -0.06725479f, 
    -0.00018324f, 0.03086890f, 0.02480291f, -0.01638008f, -0.22125967f, 0.01331413f, -0.26103371f, -0.22933975f, 
    -0.04131068f, -0.01014736f, 0.11280373f, -0.00618997f, -0.23701878f, 0.05027308f, 0.05486552f, 0.06054231f, 
    -0.01186264f, -0.06062203f, -0.08058927f, -0.02841587f, 0.06303403f, 0.10546816f, -0.03305325f, -0.13096875f, 
    -0.05194504f, 0.07587865f, -0.00142830f, -0.27091220f, -0.07093043f, -0.03060390f, -0.09626492f, -0.06841417f, 
    0.18684843f, -0.45939574f, -0.38717335f, 0.09763147f, 0.01727374f, 0.02224267f, 0.01903621f, -0.02063675f, 
    0.02118258f, 0.05663159f, -0.09601582f, 0.04548906f, -0.21319290f, -0.35942799f, -0.22049658f, 0.08748886f, 
    -0.00977938f, -0.04377596f, -0.01378498f, 0.00408221f, -0.18207455f, -0.11360531f, -0.25671944f, -0.15147331f, 
    0.11075064f, -0.10726209f, -0.32597899f, -0.09202725f, 0.05621826f, 0.03062076f, 0.01608405f, -0.10872255f, 
    -0.12340833f, -0.04647748f, -0.08774693f, -0.09336161f, -0.04909888f, -0.23600857f, -0.18394749f, -0.08286710f, 
    -0.02280347f, 0.05004758f, -0.00467264f, -0.01138121f, -0.07075679f, 0.01174055f, -0.00834805f, -0.03720071f, 
    0.01705766f, 0.01444421f, -0.13046207f, 0.02094403f, -0.04390096f, 0.01539571f, -0.03631577f, -0.14048308f, 
    -0.16496861f, -0.04816538f, -0.15158494f, -0.07353526f, -0.13379195f, -0.50990278f, -0.22938524f, -0.14166611f, 
    -0.01563233f, -0.02297249f, 0.05442854f, 0.05082557f, -0.10312966f, -0.15356497f, -0.06211917f, 0.03993672f, 
    0.26943427f, 0.15019952f, -0.10378686f, -0.08682133f, 0.08798935f, 0.08742063f, 0.06269599f, -0.09005339f, 
    0.03172978f, 0.03695485f, 0.00817994f, 0.01045152f, 0.00452898f, -0.29099640f, -0.01351366f, 0.04755700f, 
    0.06204959f, 0.02414965f, -0.21598655f, -0.06161973f, -0.04133584f, -0.01509925f, 0.00695931f, -0.03642372f, 
    0.25236040f, -0.04503679f, -0.04561186f, 0.02153949f, 0.10889407f, 0.06199214f, 0.05133207f, -0.12480097f, 
    -0.12169424f, 0.01374060f, -0.03050582f, 0.13762462f, -0.23593558f, -0.26223391f, -0.25242633f, -0.14583987f, 
    -0.04413654f, 0.02420843f, 0.03209706f, -0.04491473f, 0.03127148f, -0.00720410f, -0.02120654f, -0.01837453f, 
    0.34890351f, 0.13695522f, -0.08945405f, -0.10115936f, 0.13242042f, 0.07665004f, 0.06879206f, 0.03349473f, 
    -0.11259548f, -0.15395124f, -0.12254139f, -0.02313746f, 0.39549300f, -0.34854507f, -0.01988187f, -0.27386191f, 
    0.00411332f, -0.04230314f, 0.10758389f, 0.05368790f, -0.13287437f, -0.10773936f, -0.04326320f, -0.00071149f, 
    -0.42603105f, 0.03394715f, 0.05115059f, 0.05924914f, 0.00680644f, -0.00424188f, 0.01667497f, -0.04886030f, 
    -0.04206856f, -0.03244578f, -0.01436961f, 0.08866900f, 0.10043749f, -0.12714818f, -0.32067916f, -0.07940120f, 
    -0.01616978f, 0.03629243f, -0.11260574f, 0.01801488f, 0.03601030f, 0.07770263f, 0.05508519f, -0.11853681f, 
    0.17309637f, 0.08848075f, -0.07008410f, -0.07351791f, 0.04134911f, 0.19829796f, 0.07058671f, -0.07981910f, 
    -0.01130571f, -0.03752965f, -0.02090781f, 0.04194301f, -0.15519661f, -0.16883518f, 0.12105295f, -0.05441956f, 
    -0.19601944f, -0.13196044f, -0.04614540f, -0.04338278f, 0.00186618f, -0.03840273f, -0.06812626f, -0.06325687f, 
    -0.21459953f, -0.09032853f, -0.38453805f, -0.05355144f, -0.00923571f, -0.04889746f, 0.01720576f, 0.02228723f, 
    0.01434048f, -0.01813104f, -0.06016330f, -0.04657573f, 0.28015909f, 0.14515971f, -0.06453694f, -0.09758416f, 
    0.09995479f, 0.15903798f, 0.17021963f, -0.00404762f, -0.07225128f, -0.01220752f, -0.02462253f, -0.07423400f, 
    -0.44730669f, -0.03166921f, -0.45852211f, 0.17482451f, 0.01539445f, 0.03848239f, 0.04122904f, 0.04384426f, 
    -0.06996078f, 0.00348474f, -0.01207824f, 0.00691311f, -0.05080102f, -0.39284715f, -0.07656711f, -0.17401488f, 
    -0.05088785f, 0.02097399f, 0.08847111f, 0.01229012f, -0.14112829f, -0.00908677f, -0.16182962f, -0.02259474f, 
    0.21574160f, 0.17474008f, -0.04150788f, -0.08462834f, 0.01758431f, 0.07995260f, -0.04311073f, -0.01995268f, 
    -0.01869356f, -0.05781623f, 0.02191491f, -0.04861060f, -0.18757854f, 0.05187159f, 0.15432760f, -0.00501223f, 
    -0.00703019f, -0.00432809f, -0.00340205f, -0.07395945f, -0.05745913f, -0.07739893f, -0.18767422f, -0.23707226f, 
    0.10002711f, 0.25867945f, 0.03678760f, -0.13326888f, 0.04607224f, 0.33267257f, 0.12043833f, 0.21933211f, 
    0.00648178f, 0.03160845f, 0.03086605f, -0.08162495f, -0.13696739f, -0.09611098f, 0.37057951f, 0.09391473f, 
    -0.04128993f, -0.01294965f, 0.04704246f, 0.05627817f, -0.05925818f, -0.03666398f, -0.04062773f, 0.11623113f, 
    0.12020044f, 0.02358719f, 0.06128407f, 0.03777271f, 0.08815404f, 0.10276228f, -0.31643692f, -0.08363102f, 
    -0.00673260f, 0.03010204f, 0.03840878f, 0.04254373f, -0.08596461f, 0.28679132f, -0.10180072f, -0.07585581f, 
    0.00721090f, 0.00585627f, -0.18728955f, -0.21683605f, -0.03455551f, -0.04606702f, -0.01300864f, -0.02475000f, 
    -0.25714558f, -0.10791748f, -0.41066736f, 0.00011357f, -0.01208871f, -0.04837915f, 0.07264173f, -0.01613830f, 
    -0.04143744f, -0.02347804f, 0.10121778f, -0.16472225f, -0.01543349f, 0.12497330f, 0.11690428f, -0.07346308f, 
    -0.17262596f, -0.12783177f, -0.06005901f, 0.01209391f, 0.05125514f, -0.05206660f, -0.08143391f, 0.00922890f, 
    -0.13617818f, -0.28831109f, 0.18432334f, -0.16824730f, -0.03878919f, 0.00739993f, 0.08846667f, -0.02203506f, 
    -0.03678034f, -0.04511597f, -0.13379221f, -0.06949560f, -0.04540855f, -0.02144397f, -0.05083251f, 0.03163278f, 
    -0.02980692f, -0.04792600f, -0.00795390f, -0.04041843f, -0.10136062f, 0.04254441f, -0.04799820f, -0.03152189f, 
    -0.02353576f, -0.24948218f, -0.03678684f, 0.06668451f, 0.04333296f, -0.01425873f, -0.00512949f, -0.06072406f, 
    -0.03446335f, -0.08708906f, -0.12064832f, -0.09208307f, -0.41556481f, 0.22637850f, -0.00041655f, -0.09288495f, 
    -0.01713781f, 0.02873201f, 0.05053596f, 0.04400313f, 0.00598905f, -0.03653491f, -0.01545684f, -0.01117539f, 
    0.24146460f, 0.07032453f, -0.05205450f, -0.14097172f, 0.00663350f, 0.12991309f, -0.02953536f, -0.03654909f, 
    -0.01694606f, 0.09210216f, 0.01471879f, 0.02174738f, 0.32784718f, 0.09299538f, -0.12951359f, -0.16484195f, 
    0.08327643f, 0.02070370f, -0.00424367f, -0.11381233f, 0.14075273f, 0.12119392f, -0.13905406f, 0.04459559f, 
    0.07185934f, 0.07817221f, 0.08402400f, -0.06999299f, -0.27114245f, -0.14097042f, -0.15149325f, 0.09969698f, 
    -0.10892363f, -0.06581864f, -0.06334458f, 0.11800153f, 0.06489219f, 0.08685557f, 0.16925904f, -0.26291680f, 
    -0.14163718f, -0.03175113f, 0.03319498f, -0.07713531f, -0.10602369f, -0.03303252f, 0.08234771f, -0.00189488f, 
    0.34500936f, 0.18521199f, 0.06569522f, -0.06527998f, 0.06486905f, 0.10628818f, 0.13273540f, 0.02818756f, 
    0.09668197f, 0.12088968f, -0.00612464f, 0.15579593f, 0.01046101f, 0.00590292f, 0.00172959f, -0.02042965f, 
    -0.06190326f, -0.03265884f, 0.04055550f, 0.00238031f, -0.02726064f, -0.06958613f, -0.01693799f, -0.01061064f, 
    -0.18886599f, -0.19885474f, 0.05692490f, 0.09525790f, -0.05960339f, 0.08526412f, -0.16983169f, -0.04773703f, 
    -0.06174285f, -0.04259232f, 0.17660169f, 0.10654598f, 0.01892905f, 0.02153171f, -0.03382551f, 0.04612322f, 
    -0.02927717f, -0.04880996f, -0.09979117f, 0.02874120f, -0.06106819f, 0.02298741f, -0.01927370f, 0.03273972f, 
    0.30129525f, 0.11763716f, -0.06103786f, -0.26322350f, 0.05519620f, 0.05622045f, -0.02237346f, 0.06782506f, 
    -0.01482820f, 0.06019150f, 0.03412509f, 0.01307482f, -0.21576019f, 0.13206996f, 0.35839918f, -0.12585068f, 
    0.03872254f, -0.07140725f, -0.01127037f, -0.02091988f, 0.01078402f, -0.01568331f, 0.00876057f, -0.01512375f, 
    0.12796427f, 0.10635293f, 0.06857516f, -0.13718079f, 0.02605130f, 0.22934143f, 0.07173100f, 0.03227405f, 
    -0.00101139f, -0.00641091f, 0.06280972f, 0.08123147f, -0.28601411f, -0.01825551f, 0.20569006f, 0.03035425f, 
    0.01661256f, -0.08942825f, -0.02754570f, 0.00830894f, 0.11319704f, -0.11915679f, -0.06150790f, 0.12161658f, 
    -0.08727686f, -0.08221445f, -0.05813916f, 0.02324895f, 0.06197200f, -0.02811820f, 0.01058475f, -0.00161211f, 
    -0.00330130f, 0.03360907f, -0.00005706f, 0.00585256f, -0.35416549f, -0.37487459f, -0.06314281f, 0.01498141f, 
    0.01299099f, 0.01838430f, 0.00400831f, 0.05847149f, -0.01085248f, -0.06040742f, 0.20205051f, 0.20805858f, 
    -0.20026927f, 0.02779062f, -0.02477701f, -0.10004330f, -0.09998082f, -0.08202533f, -0.00951036f, -0.01962702f, 
    0.02240156f, -0.03680675f, -0.07430267f, -0.06396434f, -0.04243601f, 0.04544039f, 0.12302899f, -0.03402535f, 
    0.13011926f, -0.10722475f, -0.08299395f, -0.08922479f, 0.02757641f, -0.09224461f, -0.04277912f, -0.12101298f, 
    0.22232769f, 0.20645498f, -0.36855727f, -0.05617325f, -0.06484514f, 0.03136841f, -0.01961300f, -0.06684723f, 
    -0.09632230f, 0.18098733f, -0.20359939f, -0.11481663f, 0.35961780f, -0.08074035f, 0.12712187f, -0.35942125f, 
    -0.00105073f, -0.08850031f, 0.08332809f, 0.01279671f, 0.00861186f, 0.09645873f, 0.00733003f, -0.12708876f, 
    0.15535048f, 0.01183243f, 0.03734966f, 0.02105865f, 0.05652123f, 0.08870065f, 0.00754436f, 0.02112121f, 
    -0.03315043f, -0.01744963f, 0.00120338f, -0.00870926f, -0.39073139f, -0.09999398f, -0.12658828f, -0.01991015f, 
    -0.12411486f, -0.00301014f, 0.09011472f, 0.03419826f, -0.10555109f, 0.01480973f, 0.09168216f, -0.20351575f, 
    -0.19267604f, 0.00841029f, 0.02038304f, -0.14105128f, -0.20095319f, -0.00518021f, -0.02823351f, -0.12883028f, 
    -0.02063948f, -0.00122901f, -0.00677058f, 0.01660512f, 0.15486172f, 0.26983824f, 0.24612999f, -0.08855470f, 
    0.01638161f, 0.07494766f, 0.05616006f, -0.04944405f, 0.01926068f, -0.04646294f, 0.08831910f, -0.18381111f, 
    -0.11508577f, -0.20845881f, 0.06647808f, -0.08661319f, -0.11381513f, 0.05510217f, -0.03634298f, -0.01987984f, 
    0.00320392f, 0.05830919f, -0.00735736f, -0.02557036f, 0.30579960f, 0.14372638f, 0.08907318f, -0.03441520f, 
    -0.00226204f, 0.10935366f, 0.12459990f, -0.15536898f, 0.08078905f, -0.05286708f, -0.03403251f, 0.02011162f, 
    0.20720620f, -0.14402924f, 0.13132286f, -0.35077637f, -0.21055783f, -0.11810306f, -0.11785436f, -0.04130718f, 
    -0.07487305f, -0.02916531f, 0.02549643f, 0.03746258f, 0.10773870f, 0.17868800f, 0.15823114f, 0.07491273f, 
    -0.03966726f, -0.05049979f, 0.03979259f, -0.00499772f, 0.03103756f, 0.00562186f, 0.05984162f, -0.01192696f, 
    -0.01379440f, -0.00196945f, -0.17089209f, -0.27722675f, -0.02551115f, 0.06853373f, 0.01150016f, 0.19661418f, 
    0.03642590f, -0.01488447f, -0.21536274f, 0.00799458f, 0.03627315f, -0.13377273f, 0.10177704f, -0.07098736f, 
    0.11370103f, -0.02863960f, 0.02968315f, 0.01482235f, -0.12263474f, -0.01157047f, -0.38155445f, 0.14508224f, 
    -0.20581339f, 0.08060135f, 0.03320578f, 0.11428581f, -0.18002748f, -0.04674350f, -0.06796324f, 0.07638787f, 
    -0.04194009f, 0.03208921f, 0.05137691f, 0.04815839f, -0.06968807f, 0.21627171f, -0.00627420f, -0.05551513f, 
    -0.08785168f, 0.03660036f, 0.03191983f, 0.14508350f, -0.11224985f, -0.17191292f, 0.02222542f, 0.02227111f, 
    -0.12574907f, -0.14090651f, -0.05343295f, -0.02219304f, 0.16508834f, 0.04339874f, 0.20945384f, -0.05760046f, 
    -0.08584028f, -0.01877656f, 0.02378590f, 0.02553119f, -0.31543797f, 0.11236880f, 0.07426930f, -0.01886104f, 
    0.03103310f, -0.00057641f, -0.14033589f, 0.05115233f, -0.18361817f, 0.01163186f, -0.00341005f, 0.01347728f, 
    1.00243485f, -0.24558552f, 0.10354758f, 0.01179724f, -0.01706639f, -0.14606962f, 0.00597199f, -0.13968682f, 
    0.15256374f, -0.15083760f, -0.08027957f, -0.05267271f, 0.22708398f, -0.04256233f, 0.05246648f, -0.01584518f, 
    -0.00563708f, 0.07529492f, 0.00254579f, 0.06303957f, 0.11184160f, 0.18933806f, 0.06815258f, -0.07056284f, 
    0.10916636f, -0.04453115f, -0.44793674f, -0.18767500f, -0.01622932f, 0.04686227f, 0.07978204f, -0.08119495f, 
    0.11013874f, 0.13239735f, -0.05023020f, -0.05978320f, 0.38006786f, 0.13695933f, 0.02857065f, -0.06946687f, 
    -0.05825038f, 0.04355494f, -0.00902329f, 0.00617255f, -0.01465537f, 0.09543912f, -0.06201977f, 0.05377446f, 
    0.01719719f, -0.16093796f, 0.06284127f, -0.05290471f, -0.15902865f, 0.02885305f, 0.15123954f, 0.10535456f, 
    -0.03315174f, -0.12434023f, 0.08389245f, 0.03181701f, 0.27805161f, 0.11181640f, 0.07598536f, 0.13674261f, 
    -0.00261354f, 0.03251288f, -0.02472451f, 0.03171242f, 0.11390997f, -0.11677802f, 0.05992274f, 0.02761802f, 
    0.14555189f, 0.06201035f, 0.09544694f, -0.03626439f, -0.11795124f, -0.02339054f, -0.11738499f, -0.13955994f, 
    -0.09440079f, -0.03951118f, -0.01809487f, 0.06099293f, -0.21566534f, -0.14611003f, 0.08839928f, -0.13172847f, 
    -0.03733227f, 0.06478211f, -0.08124638f, -0.12839530f, -0.09198147f, 0.06305160f, -0.06514797f, -0.06034424f, 
    -0.13032869f, 0.04340670f, -0.02303700f, -0.00075293f, -0.01878228f, 0.02098112f, 0.04099389f, -0.01437122f, 
    0.03257428f, 0.05205100f, 0.12922135f, -0.20645435f, 0.31953505f, 0.05541223f, -0.19699019f, 0.08489019f, 
    -0.04675688f, 0.05476115f, 0.07517561f, -0.36662671f, 0.12160348f, -0.08184166f, -0.04389185f, 0.13226435f, 
    0.10128094f, 0.06268662f, 0.21169330f, 0.34683749f, 0.11653718f, 0.00139875f, 0.09838555f, 0.16405889f, 
    0.01646174f, 0.06623310f, -0.02589418f, -0.04409748f, 0.21200839f, -0.25150844f, 0.27824557f, 0.09470516f, 
    -0.04843398f, 0.05255194f, 0.02595995f, -0.04233319f, 0.10822702f, 0.01425346f, -0.02228597f, 0.02299455f, 
    0.05260193f, 0.12995575f, 0.09658352f, 0.01863652f, 0.00956044f, 0.01223637f, -0.02548925f, 0.08826514f, 
    0.03192176f, 0.11791041f, 0.03273485f, 0.09177781f, 0.10495500f, -0.44820538f, -0.18338688f, -0.31204519f, 
    -0.07516605f, 0.01933517f, -0.05835525f, 0.12921886f, -0.01238359f, -0.03586209f, 0.01185716f, 0.16386135f, 
    -0.01695414f, 0.30997542f, 0.16333832f, 0.18676493f, 0.01714330f, -0.01801696f, 0.03773529f, 0.15576798f, 
    -0.06428649f, 0.00320924f, -0.07442960f, -0.04040621f, 0.02311326f, -0.02146778f, -0.02694892f, -0.05303308f, 
    0.01962178f, 0.02202083f, 0.05230839f, 0.06549218f, 0.01718885f, -0.08893473f, 0.08367524f, 0.06619213f, 
    0.26695687f, -0.02584561f, 0.18752472f, -0.03461071f, -0.10465234f, -0.02065786f, 0.06211312f, -0.05025920f, 
    -0.05783329f, -0.02012781f, 0.00694603f, 0.00931284f, 0.13257049f, 0.01003590f, 0.30620858f, 0.02538625f, 
    0.25360373f, 0.11548489f, 0.10541683f, -0.01927767f, 0.05288518f, 0.00885813f, -0.03418229f, -0.05832433f, 
    0.25384447f, 0.30902773f, 0.26792583f, 0.04955120f, -0.02874117f, 0.00017530f, 0.00105071f, -0.01865078f, 
    0.01268671f, 0.02907014f, -0.04263044f, -0.03133089f, 0.30469161f, -0.04123555f, 0.24360253f, 0.05822868f, 
    -0.04861944f, 0.02991037f, 0.01780221f, -0.00617749f, -0.03739719f, -0.00056371f, -0.09193476f, 0.09837946f, 
    0.06668772f, 0.19069952f, -0.02595644f, 0.14783794f, 0.07582416f, 0.00369146f, 0.13431874f, 0.15808637f, 
    -0.07195886f, 0.03397928f, -0.05612287f, 0.00350798f, -0.31021461f, -0.01752226f, 0.00065823f, -0.06574417f, 
    -0.01844234f, -0.06747185f, 0.04781068f, 0.04903095f, 0.12372478f, 0.02594474f, 0.14870675f, 0.08788335f, 
    0.15556355f, 0.32697606f, 0.00366516f, -0.03586895f, -0.07293348f, -0.03719140f, -0.19781150f, -0.28162554f, 
    -0.08516765f, 0.00232923f, -0.03338346f, -0.07696440f, -0.72087419f, -0.37830424f, -0.16572490f, -0.13849483f, 
    0.07430350f, -0.00885591f, 0.01431650f, -0.08169824f, 0.07736382f, 0.00027760f, -0.21173845f, -0.19438088f, 
    -0.11630701f, -0.18140990f, -0.04972468f, -0.06201146f, 0.13026369f, 0.09221726f, -0.15386009f, -0.23430927f, 
    0.10147689f, 0.02513654f, -0.05688713f, 0.00190179f, 0.01418352f, 0.04327487f, -0.11118344f, 0.01739394f, 
    0.03011769f, -0.01880813f, -0.15661991f, 0.13220075f, 0.03823618f, 0.00278385f, -0.02603751f, -0.10435937f, 
    0.18413897f, 0.09532965f, 0.08803418f, 0.30356002f, -0.05384643f, -0.04924805f, -0.05098690f, 0.04914284f, 
    0.05427263f, 0.08240636f, -0.18222804f, 0.17844105f, 0.04256848f, 0.11607460f, -0.00363694f, -0.24388450f, 
    0.05713103f, 0.09056842f, -0.07982557f, 0.00120131f, 0.03337695f, 0.01485853f, 0.02918939f, -0.11259784f, 
    0.14712007f, 0.19920640f, 0.03877512f, -0.02486586f, -0.03889372f, 0.05630701f, -0.08242260f, -0.03391821f, 
    0.10522327f, 0.03197441f, -0.12266149f, -0.11600497f, 0.12769221f, -0.03141625f, 0.04060427f, 0.01818532f, 
    0.03012607f, -0.04504808f, 0.00322476f, 0.02837971f, 0.02360669f, 0.04378387f, -0.00242562f, -0.00512200f, 
    0.37569067f, -0.01832218f, 0.01861290f, 0.02043331f, -0.01713191f, 0.02109871f, -0.07256030f, 0.08879191f, 
    -0.08578229f, -0.09315993f, 0.07188093f, -0.07771279f, 0.03017440f, 0.03106417f, 0.17951185f, 0.14403670f, 
    0.06401302f, -0.00734723f, 0.00739952f, -0.01547177f, -0.01617019f, -0.02470196f, -0.04920695f, 0.00712943f, 
    -0.12032992f, 0.02093960f, 0.07473775f, -0.09327932f, 0.09112352f, -0.13542180f, -0.09234456f, 0.13914314f, 
    -0.17608848f, -0.01478697f, 0.18455286f, -0.33194214f, -0.14538516f, -0.07418790f, -0.08055386f, -0.08343032f, 
    -0.03747689f, 0.08249396f, 0.01475292f, 0.06015513f, -0.10752410f, -0.24558331f, 0.01113932f, 0.08698115f, 
    0.04047461f, -0.30293709f, -0.02471061f, -0.76033866f, 0.07300822f, -0.00231110f, -0.03812553f, -0.05163101f, 
    -0.01154878f, 0.06874733f, -0.01743514f, -0.19607107f, -0.50169390f, 0.09159889f, -0.00874061f, -0.13366146f, 
    0.20009466f, 0.15670274f, -0.20728816f, -0.00460955f, 0.08349423f, 0.02257469f, 0.04661336f, 0.07220027f, 
    -0.23932984f, -0.02835877f, -0.10609879f, 0.16446571f, -0.05094538f, -0.02334103f, -0.13869931f, -0.05828093f, 
    0.12960868f, -0.30553573f, -0.22705708f, -0.18616283f, -0.02668343f, 0.07768540f, 0.04923956f, 0.13350306f, 
    0.02209335f, -0.00401759f, -0.02786493f, 0.02790392f, 0.03700721f, 0.08342382f, -0.05683250f, 0.03487578f, 
    0.09171738f, -0.16417073f, 0.04618338f, -0.09652077f, 0.04792207f, 0.02808579f, -0.03864544f, -0.06337420f, 
    -0.04530496f, -0.00708553f, -0.08975715f, -0.15502451f, 0.14609666f, -0.00898021f, 0.02204298f, -0.00206546f, 
    -0.21539031f, -0.18326631f, 0.03453304f, 0.00703398f, 0.01555644f, -0.01154365f, -0.01203478f, 0.01261923f, 
    -0.10497445f, 0.09879498f, 0.07320876f, -0.02445665f, -0.12483704f, -0.03736402f, 0.18302114f, -0.18473285f, 
    -0.02543028f, -0.05841620f, -0.01253873f, 0.02681203f, -0.14630854f, 0.10323571f, 0.03741987f, 0.08258551f, 
    0.03311652f, 0.15753242f, -0.08367419f, 0.09918782f, -0.01426389f, -0.00143746f, 0.00659795f, -0.03385787f, 
    0.02076156f, 0.21221793f, -0.01789918f, -0.12819777f, -0.21798417f, -0.07725485f, -0.01348597f, -0.26195806f, 
    -0.00611299f, 0.00468502f, -0.05482327f, -0.14238797f, 0.00446556f, 0.01145755f, 0.09949306f, -0.03424675f, 
    0.01843512f, 0.02595524f, -0.10906954f, -0.06137310f, -0.13273126f, -0.06092384f, -0.05504236f, -0.25979865f, 
    0.19443247f, 0.17238612f, 0.07632356f, 0.11100417f, 0.00207790f, 0.01224528f, -0.02791214f, -0.01095372f, 
    -0.00014815f, 0.03792217f, 0.03078704f, 0.03365025f, 0.16576107f, -0.02008171f, 0.12454411f, -0.04767320f, 
    -0.03488255f, 0.02133204f, -0.06000450f, -0.04640492f, -0.37146637f, -0.13739686f, -0.24782543f, -0.26244926f, 
    -0.03943265f, -0.03369119f, -0.10615078f, 0.03625197f, 0.05789344f, -0.12540877f, 0.00699465f, 0.00261203f, 
    -0.02496042f, -0.03667475f, 0.01334125f, 0.12653254f, -0.22172815f, -0.05827492f, 0.00985684f, -0.05513179f, 
    -0.04022517f, -0.03520670f, 0.05773832f, 0.04391979f, 0.09487201f, 0.07127205f, -0.05097948f, -0.02334517f, 
    -0.10597063f, 0.00720858f, -0.46372575f, 0.08476403f, -0.15278809f, 0.15415333f, 0.19620247f, 0.16248479f, 
    -0.06015002f, 0.33885920f, -0.00208616f, 0.10323518f, 0.22076108f, 0.11884249f, -0.02876447f, 0.02654440f, 
    -0.02789299f, 0.02923670f, -0.00735540f, 0.04799328f, 0.00569736f, -0.03830823f, -0.15119062f, -0.00234303f, 
    -0.01899056f, -0.17344762f, -0.14846499f, -0.16525781f, -0.00333436f, 0.02683813f, 0.03748197f, -0.08689407f, 
    0.11344094f, 0.08667955f, 0.04701417f, -0.02425742f, 0.55004591f, 0.36390767f, -0.24456103f, -0.09671912f, 
    -0.07288363f, 0.06050169f, -0.11951052f, 0.03376332f, -0.03792779f, 0.19975057f, -0.24073744f, 0.01815492f, 
    0.04333445f, 0.16346772f, -0.05470602f, -0.03729342f, -0.15783387f, 0.10280409f, -0.08722973f, -0.07790092f, 
    -0.02942244f, -0.01450119f, 0.03314427f, -0.04760487f, -0.22334962f, 0.28167644f, -0.07874648f, -0.02849592f, 
    -0.04827891f, 0.02629478f, 0.00894858f, -0.04112963f, -0.04483403f, 0.04624002f, -0.15347151f, 0.32574451f, 
    0.00345698f, 0.05669506f, -0.00629868f, 0.05855513f, 0.01713504f, -0.00203744f, 0.08964801f, -0.04794278f, 
    -0.05463905f, 0.11315966f, -0.07598964f, 0.05219911f, 0.08600522f, -0.00994632f, -0.12096488f, -0.06374909f, 
    -0.14291809f, -0.07766332f, 0.07274958f, 0.05286068f, 0.10373599f, -0.16318676f, -0.06817844f, -0.00887891f, 
    -0.15543020f, -0.16328469f, 0.31999806f, -0.45521727f, 0.03432271f, -0.15771331f, -0.24227932f, -0.18239875f, 
    0.06726932f, -0.02825778f, 0.05918568f, 0.00076335f, -0.24238762f, 0.01844267f, -0.01649193f, -0.03453105f, 
    0.02335623f, 0.00061102f, 0.03584478f, 0.05868433f, 0.00855184f, 0.04037400f, 0.00779222f, -0.02947049f, 
    0.02394757f, 0.34373862f, -0.00585046f, 0.02527961f, -0.03869554f, 0.06125498f, 0.04380921f, -0.10829340f, 
    0.04465003f, 0.05198357f, -0.18228108f, 0.02295469f, -0.16542029f, 0.08473789f, -0.04271737f, -0.02286579f, 
    0.03482281f, 0.02154324f, -0.00981500f, -0.05433769f, 0.04988441f, 0.08596474f, 0.07425538f, 0.05618755f, 
    -0.63019764f, -0.51067412f, -0.48554933f, -0.32776240f, 0.08620319f, 0.11374304f, -0.00343063f, -0.06859497f, 
    0.03741950f, -0.00887907f, -0.04447944f, -0.05861001f, -0.01601713f, -0.08306824f, -0.05989650f, 0.19856752f, 
    0.06254485f, -0.04737097f, 0.04746761f, 0.02707365f, -0.06238493f, -0.08451850f, -0.09815767f, -0.02014412f, 
    0.19185373f, -0.01940013f, -0.08605449f, -0.09336894f, 0.08785203f, -0.02424107f, 0.07464740f, 0.15139084f, 
    -0.02270223f, 0.01836319f, -0.00500706f, -0.05566528f, 0.05910017f, -0.06919674f, 0.17157365f, 0.26448253f, 
    0.08389125f, 0.01266154f, -0.04754533f, 0.02245934f, 0.04525293f, -0.05249553f, -0.05719596f, 0.09820950f, 
    -0.28479069f, 0.16176960f, 0.57581627f, -0.01197333f, 0.00637185f, -0.05037042f, -0.12155023f, -0.11311555f, 
    0.07703567f, 0.03277498f, 0.11340903f, -0.08766367f, -0.44031623f, 0.40299922f, 0.00553554f, -0.08702300f, 
    0.01140911f, 0.04362987f, -0.07428846f, 0.02944425f, 0.03597593f, -0.00275794f, -0.06683808f, 0.14042112f, 
    -0.10050911f, 0.28596902f, 0.00436461f, 0.13217551f, 0.02501219f, -0.01934651f, -0.01212487f, -0.00892092f, 
    -0.06705453f, 0.10462646f, -0.01463657f, 0.06928194f, -0.37823337f, 0.14165299f, -0.02537763f, -0.01847657f, 
    -0.01087416f, 0.00288880f, -0.00324045f, -0.07916830f, 0.02396411f, 0.00021574f, 0.00182072f, 0.00284113f, 
    -0.06326401f, -0.11083857f, -0.07658694f, 0.07881781f, -0.07805063f, -0.03931684f, -0.00984887f, -0.13193974f, 
    -0.00945580f, -0.10740623f, -0.11633315f, 0.11988845f, -0.06231711f, 0.02361708f, -0.04219062f, -0.10794494f, 
    -0.00444013f, 0.03605472f, -0.07931064f, 0.06375976f, 0.02829135f, -0.02240887f, 0.04907798f, 0.11884955f, 
    -0.10125110f, -0.11107492f, 0.18577102f, 0.04978897f, 0.00067522f, -0.30874068f, 0.23781368f, 0.03557891f, 
    0.03140837f, 0.02186184f, 0.04411488f, -0.06745350f, 0.01827477f, 0.36516911f, 0.18022557f, 0.04811807f, 
    0.00905915f, 0.13279755f, -0.04831182f, -0.07136626f, 0.10880028f, -0.00214890f, -0.11330915f, 0.08185391f, 
    0.00354976f, 0.08139599f, 0.18068916f, 0.08915072f, -0.00305788f, -0.08508878f, 0.08004907f, -0.08553167f, 
    -0.01217760f, 0.04587908f, 0.06977811f, -0.00588114f, -0.28493088f, 0.12220904f, -0.10491385f, 0.03455941f, 
    -0.06312677f, 0.04987807f, 0.05704853f, 0.00350758f, -0.04896398f, -0.04184769f, 0.12572488f, -0.21696372f, 
    -0.54846197f, -0.31829202f, 0.03107809f, -0.23797952f, 0.04556493f, -0.02787358f, -0.03368258f, 0.00081201f, 
    -0.02013486f, -0.04813943f, 0.05841922f, -0.16362897f, 0.03604915f, 0.11761404f, -0.06493857f, 0.14271013f, 
    -0.01239734f, -0.06397326f, 0.03735501f, 0.03349127f, -0.03942494f, 0.00161111f, -0.02229692f, 0.05830497f, 
    -0.09083030f, -0.10148846f, 0.03983442f, -0.08177880f, -0.00673747f, 0.01576253f, -0.02512767f, -0.00441763f, 
    -0.02242769f, -0.03654210f, 0.02546192f, 0.07374871f, -0.55557930f, -0.42610502f, 0.14853363f, -0.37276891f, 
    0.16751489f, -0.03783204f, -0.38327023f, -0.32690907f, 0.03321167f, -0.00399951f, -0.01841450f, -0.00542671f, 
    -0.44622114f, 0.08722337f, 0.23226851f, 0.07005750f, -0.25096232f, 0.04731178f, -0.08645644f, -0.05751006f, 
    0.04685552f, -0.06929623f, -0.07727022f, -0.06163487f, -0.16086631f, -0.21487035f, -0.04990955f, 0.06204010f, 
    -0.11186298f, 0.04870665f, -0.04444199f, -0.02602554f, 0.03590737f, -0.10284454f, 0.00801973f, 0.05108636f, 
    -0.21898448f, 0.06198027f, -0.01222119f, -0.09663349f, 0.01571486f, 0.07688902f, 0.01463271f, -0.00747779f, 
    0.11241840f, -0.06850751f, 0.01857840f, 0.03670830f, -0.09152880f, -0.09691830f, 0.50029105f, 0.13314083f, 
    0.04129725f, -0.12746285f, -0.06476437f, 0.13994689f, -0.02916889f, -0.01118635f, -0.02575403f, 0.00978682f, 
    -0.23785056f, 0.11433683f, 0.21235235f, -0.17734526f, -0.00991206f, 0.03177335f, 0.01477353f, 0.03700678f, 
    0.02254383f, 0.00666713f, -0.03498541f, -0.04092086f, -0.00277065f, -0.30566570f, 0.03092423f, -0.16066077f, 
    0.01718958f, -0.02591646f, -0.11269148f, 0.11695797f, -0.00851489f, -0.00060768f, 0.01718471f, 0.04141492f, 
    -0.22160619f, -0.02662228f, -0.17138360f, -0.12387695f, -0.14810672f, 0.02840753f, 0.06179030f, 0.02691266f, 
    -0.00928773f, -0.07658862f, -0.07910107f, 0.02282410f, -0.06177544f, -0.11692809f, -0.15402751f, 0.12684123f, 
    -0.02061833f, 0.03746992f, 0.06423877f, -0.01091774f, -0.01978238f, -0.11276858f, -0.06730489f, -0.01622245f, 
    -0.13992132f, 0.31581900f, 0.16747874f, 0.47526318f, 0.04324712f, -0.09136224f, 0.03394681f, 0.05989501f, 
    0.02189187f, -0.01202551f, -0.02419069f, 0.03504431f, 0.08397271f, -0.17663962f, -0.45390543f, 0.05837442f, 
    -0.04057532f, -0.00241648f, -0.00469297f, -0.04981172f, -0.02776133f, -0.07154723f, -0.00262068f, -0.03882803f, 
    0.18639502f, 0.06481095f, 0.18730435f, 0.00216558f, -0.04808890f, 0.01763376f, 0.02874085f, -0.00851134f, 
    0.05506705f, 0.07588081f, -0.02753454f, 0.12384754f, -0.00872535f, -0.13176118f, 0.00942720f, 0.02416026f, 
    0.00405699f, 0.09236983f, -0.17037380f, 0.00127302f, 0.01668112f, -0.00616446f, -0.01409052f, 0.01947727f, 
    0.26748136f, -0.02043088f, -0.37964544f, -0.09130282f, 0.00760054f, -0.01703382f, -0.02332554f, 0.09625893f, 
    0.01115729f, -0.10550410f, 0.06948217f, -0.14097030f, -0.05865687f, 0.02232962f, 0.08610462f, 0.06410189f, 
    -0.03279636f, 0.01350395f, -0.05593810f, -0.08199649f, 0.01789299f, -0.00229665f, 0.02928174f, 0.01678770f, 
    0.09200042f, 0.09633876f, -0.09754447f, 0.05537638f, 0.05023825f, -0.01846221f, -0.07934264f, 0.05659572f, 
    -0.00821438f, 0.04583541f, 0.04018619f, 0.00268162f, -0.12784965f, -0.08453017f, 0.07959349f, -0.00381063f, 
    -0.07442489f, -0.06504529f, 0.01560728f, 0.01322144f, -0.01682478f, -0.00661594f, 0.05581388f, -0.05557275f, 
    -0.07791316f, -0.02031971f, 0.16798104f, 0.00699238f, -0.01490887f, -0.00743680f, 0.00858484f, -0.02252928f, 
    0.08712513f, 0.07544262f, -0.02641817f, 0.02356439f, -0.01085999f, -0.18050832f, 0.12527063f, 0.00965913f, 
    0.06410771f, 0.03568622f, 0.08197977f, -0.01917053f, 0.05073395f, -0.00094343f, -0.08361420f, 0.08453269f, 
    -0.01443976f, 0.03111227f, 0.40711927f, 0.47314176f, -0.03496006f, -0.02587231f, 0.13170408f, 0.09244551f, 
    0.04774449f, -0.13723643f, 0.05692173f, 0.00329156f, -0.05999250f, -0.03953493f, 0.03538923f, 0.02039941f, 
    -0.09866194f, -0.13082072f, 0.00642880f, -0.01100463f, 0.01945266f, 0.03935478f, -0.00548718f, 0.00042790f, 
    0.04602633f, 0.11255449f, -0.25707510f, -0.11853551f, 0.05347697f, -0.00118373f, 0.02897938f, -0.05826769f, 
    -0.10802605f, 0.02356938f, -0.01495175f, -0.02678128f, 0.43274632f, -0.09598462f, -0.08212020f, 0.05602790f, 
    0.09313635f, 0.02802401f, -0.17443237f, -0.00707457f, 0.06203035f, 0.04125818f, -0.16052164f, 0.11133666f, 
    -0.04683386f, -0.01711868f, -0.00497726f, 0.14666671f, 0.01162884f, -0.05939492f, -0.05639795f, 0.10089569f, 
    0.02392522f, -0.02798428f, 0.06507228f, -0.07903999f, -0.00450470f, -0.01161339f, -0.07064488f, -0.03538581f, 
    -0.04077981f, -0.00732234f, 0.05069814f, 0.03512383f, -0.05288895f, 0.03654150f, -0.07998394f, -0.10037646f, 
    0.09081566f, -0.07956773f, 0.10757653f, -0.13137406f, 0.00566988f, -0.09804862f, 0.03026348f, 0.01017363f, 
    0.11613117f, 0.05361872f, -0.03701566f, 0.01844310f, -0.07920893f, -0.01624425f, -0.02942655f, -0.06160676f, 
    -0.01047633f, -0.01051210f, 0.10064350f, -0.01015000f, -0.01861084f, -0.03047386f, -0.00213725f, -0.03796975f, 
    -0.57964700f, -0.21177852f, -0.21689874f, -0.33472419f, -0.02060865f, 0.06747573f, 0.01249271f, -0.07283030f, 
    0.00763270f, 0.00868025f, 0.07310908f, -0.02610959f, 0.00929095f, -0.11819279f, -0.14153135f, -0.00129206f, 
    0.04818855f, 0.13714442f, -0.08594514f, 0.07675540f, -0.01568762f, -0.08261371f, 0.03626972f, -0.06564618f, 
    -0.14581594f, 0.27664146f, 0.22844443f, 0.23516622f, 0.10357390f, -0.12291081f, 0.21512675f, -0.04249991f, 
    0.01758705f, 0.01699761f, 0.03923767f, -0.04183654f, -0.13937089f, 0.03191789f, 0.06876894f, 0.05916393f, 
    -0.00752501f, 0.06588873f, 0.02911266f, -0.11055224f, 0.09581871f, 0.07560884f, 0.04902888f, 0.04895760f, 
    -0.17703702f, 0.02585909f, -0.07862163f, -0.12703937f, -0.04406604f, -0.08277368f, 0.02991332f, 0.05116057f, 
    -0.04633828f, -0.05459340f, 0.03915621f, -0.01884389f, 0.03215820f, 0.08766132f, -0.10577197f, -0.00691660f, 
    -0.00024969f, -0.04007383f, 0.00232578f, -0.05566578f, 0.13825674f, 0.20017166f, 0.04385025f, 0.22457267f, 
    -0.01255310f, -0.39172903f, -0.03602840f, 0.00130976f, -0.13432273f, 0.11129210f, 0.07445819f, -0.00071191f, 
    0.00697630f, -0.14584473f, -0.01475238f, -0.00105979f, -0.00904437f, -0.02621693f, -0.15399829f, 0.03752611f, 
    -0.01654542f, 0.05814588f, 0.05814395f, 0.05343935f, -0.19649120f, -0.11717933f, 0.18023463f, -0.09861013f, 
    -0.07855392f, -0.07187218f, -0.08536693f, 0.14570628f, -0.07519612f, -0.06090418f, 0.09345242f, -0.17939708f, 
    0.06868310f, -0.02511532f, 0.01462292f, 0.09511041f, 0.00071886f, -0.00038769f, -0.27768755f, 0.11798663f, 
    0.05063307f, 0.01326512f, 0.02932121f, 0.03835710f, 0.05422009f, -0.06243287f, 0.06674611f, 0.00967701f, 
    0.04901783f, 0.21748014f, 0.25279418f, 0.17474477f, -0.03194469f, 0.03064489f, 0.06715191f, 0.05134362f, 
    -0.17054251f, 0.10432857f, -0.17082861f, 0.06392813f, -0.03927557f, -0.01012038f, -0.16270083f, -0.05695783f, 
    -0.12348597f, -0.02054523f, -0.01748583f, 0.04115229f, 0.03049088f, 0.02987907f, -0.12583202f, 0.07137624f, 
    -0.20504236f, 0.07699677f, -0.01097276f, 0.13836320f, -0.12398844f, 0.08772381f, -0.15967484f, 0.05040741f, 
    0.00226400f, -0.05266932f, 0.00637862f, -0.06960618f, -0.08549004f, 0.11043363f, -0.07812161f, 0.21177115f, 
    0.09515810f, 0.04871545f, 0.01947088f, 0.08514810f, 0.00831684f, 0.02841093f, 0.00324453f, -0.01281422f, 
    0.01982796f, 0.05428833f, -0.12583016f, 0.14329886f, 0.04300588f, 0.00227576f, 0.03253353f, -0.08778972f, 
    0.07408442f, 0.04297630f, -0.09901389f, 0.12817600f, -0.01583217f, -0.01702853f, 0.11572412f, 0.10983307f, 
    0.04193932f, -0.06706669f, -0.01576520f, 0.21201499f, 0.05050601f, 0.07980319f, 0.00514792f, 0.06527797f, 
    0.01544741f, -0.15156147f, 0.30188707f, 0.10977506f, -0.19993985f, 0.06552608f, -0.07912503f, 0.09655665f, 
    0.04297084f, 0.04013255f, 0.01404701f, 0.02962516f, 0.24058543f, -0.01898952f, 0.10474291f, -0.14550392f, 
    -0.23100665f, -0.07068264f, -0.07514827f, -0.00859543f, 0.05700121f, -0.05472040f, 0.04057977f, 0.01571755f, 
    -0.02843129f, 0.06076859f, 0.04520756f, 0.30374354f, -0.06356878f, -0.04877672f, -0.01011708f, -0.04646734f, 
    -0.01326221f, 0.14639771f, 0.07542809f, 0.06625904f, -0.06725395f, -0.22917630f, 0.15144405f, -0.02107003f, 
    -0.05306754f, -0.03118034f, 0.11715706f, 0.10800668f, -0.03839227f, 0.08032341f, 0.09717624f, 0.01379004f, 
    0.03758866f, -0.15313609f, -0.00735004f, 0.15355296f, 0.06421222f, 0.06022220f, 0.06688680f, 0.11267778f, 
    -0.03358552f, -0.05619183f, -0.05968735f, -0.08586685f, 0.11325176f, 0.06675404f, 0.09603689f, -0.39665046f, 
    0.22925502f, 0.11999891f, 0.03554955f, -0.19944404f, 0.02278506f, -0.08377308f, -0.17172024f, 0.15241596f, 
    0.26970878f, 0.24484135f, -0.07090755f, -0.21068333f, 0.00247538f, -0.04794464f, -0.19415745f, -0.00228374f, 
    -0.04961805f, -0.05744707f, -0.07475389f, -0.01940378f, 0.21994705f, 0.21359600f, -0.10489843f, -0.08098046f, 
    0.13591892f, -0.01973788f, -0.00848480f, 0.05660732f, -0.15018192f, -0.02387684f, -0.07434503f, 0.08268739f, 
    -0.19452240f, 1.10581648f, -0.06434668f, 0.20138848f, 0.28859541f, 0.08406305f, 0.22703071f, 0.01166235f, 
    -0.19513807f, -0.09293762f, 0.01721677f, -0.08267469f, -0.76095146f, 0.09232163f, -0.08687359f, 0.18530844f, 
    -0.08567593f, -0.00500055f, -0.27109632f, -0.19136712f, -0.05602063f, -0.04747989f, 0.08603895f, -0.05004730f, 
    -0.26612535f, 0.07895986f, -0.15195535f, 0.04525007f, 0.08084211f, 0.09380044f, -0.09092183f, -0.01067004f, 
    -0.02542265f, 0.13267545f, 0.05261591f, -0.08044517f, -0.62898010f, -0.14441641f, 0.16984445f, 0.06647628f, 
    -0.01247263f, -0.18763748f, 0.14624329f, -0.09915518f, -0.06452170f, 0.00917053f, 0.04838464f, -0.10984430f, 
    -0.05080128f, -0.08370812f, 0.05314663f, 0.19809289f, 0.05837220f, -0.11585911f, -0.00468357f, 0.11054289f, 
    0.03240184f, 0.02506961f, 0.01114051f, 0.06797906f, -0.41288385f, -0.03520538f, 0.01325675f, -0.01735242f, 
    -0.00930959f, 0.12086467f, 0.13309705f, 0.00635898f, -0.05956511f, 0.15039362f, 0.16667767f, -0.10539018f, 
    -0.11235531f, -0.03334927f, -0.00228767f, 0.15291446f, -0.01085299f, -0.10018498f, -0.01524686f, -0.09418338f, 
    -0.00403668f, 0.00964642f, 0.13939346f, 0.08464953f, 0.23461357f, 0.05691930f, -0.00566057f, 0.43654421f, 
    0.14164235f, 0.05795412f, -0.11131650f, 0.15707365f, -0.02227474f, -0.05581672f, 0.01145446f, 0.13066700f, 
    -0.25976986f, -0.04477319f, 0.00032432f, 0.14830184f, 0.06997634f, 0.02677657f, -0.03715986f, -0.02009477f, 
    -0.04447411f, -0.06586424f, 0.08869503f, -0.00763307f, -0.44856453f, 0.53941196f, -0.12120153f, 0.40253130f, 
    0.11242364f, -0.17516235f, -0.05350996f, -0.10713151f, 0.12518038f, 0.03985656f, -0.07178432f, -0.12958694f, 
    -0.13980114f, -0.07546582f, -0.08781424f, 0.14733145f, 0.05773166f, 0.05181532f, 0.01206830f, 0.08737622f, 
    -0.04797889f, 0.01048480f, 0.02108135f, -0.01658768f, -0.62871540f, 0.64526713f, -0.29217705f, -0.70481598f, 
    0.09666147f, 0.11475725f, -0.02632799f, 0.01104208f, -0.29979253f, -0.14812914f, -0.04748369f, 0.05473554f, 
    -0.06993352f, -0.12731533f, 0.21948519f, -0.00884402f, -0.22998011f, -0.10209896f, -0.08781423f, 0.05895289f, 
    0.04421425f, 0.19861856f, 0.01457818f, 0.04358029f, -0.01165131f, 0.06582619f, 0.37199569f, 0.13311726f, 
    0.10063297f, 0.09325357f, -0.07344030f, 0.15636604f, -0.00081753f, -0.06348097f, 0.04275442f, -0.04154453f, 
    0.05270063f, -0.10785414f, 0.01733914f, 0.24276626f, 0.02871355f, -0.03241545f, -0.02756605f, 0.01904205f, 
    0.01364996f, 0.04449164f, -0.07606611f, 0.08339468f, 0.16096242f, 0.02435615f, 0.19469157f, -0.20840366f, 
    -0.06041784f, -0.09498724f, -0.01949466f, 0.02082248f, 0.08923792f, 0.04904689f, 0.06159307f, -0.07352920f, 
    -0.55294430f, 0.17019722f, -0.04691790f, 0.21553114f, 0.03176030f, -0.02579705f, -0.22291544f, -0.11263072f, 
    -0.10267431f, -0.08262141f, -0.00326736f, 0.10074171f, -0.02782815f, -0.07305852f, -0.13720843f, 0.03734828f, 
    0.04875341f, -0.07195409f, -0.01747821f, -0.11602820f, -0.02068685f, -0.00023022f, 0.06360556f, 0.06412065f, 
    -0.19764481f, -0.17162807f, -0.08035861f, -0.13789247f, -0.03001306f, 0.06153568f, -0.12257608f, -0.08834565f, 
    -0.03495554f, -0.07864031f, 0.04474369f, -0.08753007f, -0.35621756f, -0.00939022f, -0.23438719f, 0.18949410f, 
    0.12484042f, -0.16290352f, -0.02731553f, 0.00773691f, -0.06212722f, -0.07760981f, 0.07737421f, -0.09708566f, 
    0.01546427f, -0.08923489f, -0.00996346f, 0.20239516f, 0.02167682f, 0.02079171f, -0.02242479f, -0.00861938f, 
    0.08780730f, 0.12530686f, 0.02544053f, 0.03394499f, 0.55412632f, 0.01392184f, -0.09115878f, 0.07562949f, 
    0.13400012f, 0.00934310f, 0.04825483f, -0.06545994f, 0.09080373f, -0.06798368f, 0.11224146f, 0.09393091f, 
    0.32646540f, -0.19679576f, -0.02936934f, 0.15573843f, 0.07967760f, -0.07682054f, -0.00152649f, -0.06001320f, 
    0.02594219f, 0.00537227f, 0.14366131f, 0.15848900f, 0.32711983f, 0.18973206f, -0.09058717f, -0.32805517f, 
    -0.11163080f, -0.06356198f, -0.06841962f, 0.03342536f, -0.04559802f, 0.01000770f, 0.07866894f, -0.07311150f, 
    -0.00893165f, -0.18326978f, -0.03247892f, 0.41898188f, 0.04893309f, 0.01072492f, 0.01439949f, -0.01112642f, 
    -0.11503404f, -0.10705609f, 0.08799824f, -0.06682290f, -0.13150319f, -0.05474019f, -0.23201331f, -0.05419802f, 
    -0.09324141f, -0.09812880f, 0.12273818f, -0.05091712f, 0.00962719f, -0.04570927f, 0.01761979f, 0.16714378f, 
    -0.35722297f, 0.53716320f, -0.13759907f, -0.10658509f, 0.16001444f, 0.08732561f, -0.17108344f, -0.00245983f, 
    -0.01777060f, -0.06112319f, 0.01599366f, -0.13427290f, -0.04879082f, 0.00501901f, 0.09974513f, -0.00424381f, 
    -0.10399304f, -0.08368807f, 0.04975625f, 0.11738714f, -0.06268565f, 0.00585996f, -0.00347917f, -0.03652674f, 
    0.05382843f, 0.16067410f, 0.05009648f, -0.17074864f, 0.05503776f, -0.19396736f, -0.02898322f, 0.08718713f, 
    -0.05782402f, 0.06666701f, 0.03378365f, -0.17255114f, -0.22315611f, 0.02151458f, 0.29457769f, 0.05743688f, 
    -0.00423589f, -0.10257825f, -0.10989600f, -0.04002155f, 0.03660444f, 0.04490389f, -0.07162366f, -0.01592154f, 
    -0.12081865f, -0.01059157f, -0.09669641f, 0.35484090f, 0.07417946f, 0.13044426f, -0.05546660f, 0.04666617f, 
    -0.10264034f, -0.11598298f, 0.04566003f, -0.08595645f, 0.46223024f, -0.39261383f, 0.12536605f, -0.27781019f, 
    -0.15366291f, 0.01019589f, -0.07738697f, -0.03562866f, 0.00989814f, 0.11006811f, -0.18262434f, -0.00810601f, 
    0.11472222f, -0.18529306f, -0.00257830f, 0.09441054f, 0.08571515f, 0.12555082f, -0.02210939f, 0.01122354f, 
    -0.15050280f, 0.10257046f, -0.00373537f, 0.06035464f, -0.09476965f, -0.04469036f, -0.14394633f, 0.17590269f, 
    0.06858331f, 0.07886151f, 0.12384185f, 0.10433710f, -0.01372902f, 0.00420645f, 0.07869647f, 0.02583951f, 
    0.26304507f, -0.06915080f, 0.13228616f, 0.05763936f, -0.03686931f, 0.08914530f, -0.00872808f, -0.05738322f, 
    -0.07533134f, 0.06346269f, 0.03002643f, -0.00665065f, 0.18815701f, -0.01541020f, -0.04573777f, -0.08025353f, 
    -0.01135175f, -0.05108896f, -0.02781651f, -0.28394237f, -0.03142134f, 0.05201190f, -0.13767968f, 0.04134115f, 
    0.13382022f, 0.12943408f, -0.24773617f, -0.12726355f, 0.22998568f, 0.04701663f, 0.02606883f, -0.02791580f, 
    -0.12602909f, 0.03263093f, 0.12635686f, -0.04747859f, -0.28726271f, 0.08296295f, 0.00054680f, -0.20563723f, 
    0.13502850f, -0.17488420f, -0.10474487f, 0.02344164f, -0.07300197f, -0.03316861f, -0.02801619f, -0.02222075f, 
    0.27118888f, -0.13367718f, 0.16278471f, 0.24226710f, 0.10021967f, -0.05589398f, -0.04731835f, 0.02980340f, 
    0.02476148f, -0.02496736f, 0.05977884f, 0.00044636f, -0.15330164f, 0.20485237f, -0.22376794f, 0.22997363f, 
    0.05540000f, -0.08403234f, -0.04776953f, -0.18871436f, -0.10549567f, -0.12592784f, -0.11253849f, -0.16845298f, 
    -0.03750863f, -0.27000630f, -0.07735121f, 0.08664867f, 0.00927354f, 0.11724829f, -0.01500871f, 0.04529270f, 
    0.05789707f, -0.02680274f, 0.05159950f, -0.09281699f, 0.31909955f, 0.14207157f, -0.07910108f, -0.31932959f, 
    -0.08302297f, -0.14694773f, -0.05782754f, -0.08271330f, 0.08144919f, 0.04302700f, -0.14835493f, -0.07563687f, 
    0.38425776f, -0.20140602f, -0.19222787f, 0.15392238f, 0.00205560f, -0.10429448f, -0.12455798f, -0.04930926f, 
    0.08261866f, 0.04021041f, 0.03015661f, 0.12692225f, -0.16121039f, -0.11025145f, -0.03354884f, 0.07304645f, 
    -0.13278903f, -0.00556698f, -0.02193991f, 0.06160981f, -0.01210602f, 0.06679265f, 0.10315858f, 0.06454612f, 
    -0.35675591f, -0.34797618f, -0.30465525f, 0.03814807f, -0.10609069f, -0.08533740f, -0.20181328f, -0.05578565f, 
    0.04212954f, -0.02879884f, 0.04065524f, 0.06440649f, -0.09474649f, 0.05601919f, 0.04463820f, 0.01292542f, 
    -0.08532334f, 0.12473036f, -0.03023756f, -0.01665766f, 0.04079468f, 0.05593785f, -0.05596252f, -0.05289675f, 
    0.19597778f, -0.14053252f, 0.14583950f, -0.27200183f, -0.18779084f, -0.13298869f, -0.09539075f, 0.03365954f, 
    -0.05381332f, 0.06131999f, 0.00126140f, -0.09765771f, 0.01018047f, -0.27651533f, -0.11202151f, -0.27225372f, 
    -0.19530602f, 0.04965983f, 0.01466853f, -0.06107805f, 0.11187617f, -0.03036146f, 0.21781720f, -0.24922854f, 
    -0.03968250f, -0.29848585f, -0.00334956f, 0.18737099f, 0.01064454f, -0.07364570f, -0.02671916f, 0.14867221f, 
    -0.25090167f, 0.05492039f, -0.02977930f, -0.02451096f, -0.40098277f, 0.83423674f, -0.17348224f, -0.32523933f, 
    -0.09684419f, 0.10539934f, 0.02335450f, -0.08324987f, -0.18247639f, -0.00280636f, -0.05370217f, 0.07691100f, 
    -0.17457549f, -0.18139032f, -0.06145161f, 0.09250214f, 0.21234563f, -0.02369151f, 0.11614997f, -0.02544161f, 
    -0.04156765f, 0.02660139f, 0.01816705f, -0.04667441f, 0.39796400f, -0.15990238f, 0.05786709f, -0.47037497f, 
    -0.23555197f, -0.08322676f, 0.07373324f, 0.07622851f, 0.12162186f, 0.00387053f, -0.11626900f, 0.00302605f, 
    -0.42923644f, 0.09070174f, -0.21390665f, 0.46788362f, -0.05565109f, -0.21194264f, 0.02051953f, -0.06553981f, 
    -0.01766134f, 0.05529238f, -0.01616185f, 0.03819417f, 0.06317548f, -0.17867197f, -0.16872454f, -0.56982136f, 
    0.26035458f, 0.06410726f, -0.00270162f, -0.04059185f, -0.05861370f, 0.00903090f, -0.04962478f, -0.12401022f, 
    0.04544694f, -0.24160539f, -0.04805514f, 0.16538396f, -0.01986993f, -0.07681955f, -0.13146719f, -0.05518528f, 
    -0.08346827f, -0.04168486f, -0.04351489f, -0.03490736f, -0.13099702f, 0.28304949f, -0.11227021f, -0.35703629f, 
    0.25222197f, 0.08980151f, 0.00825251f, -0.00860622f, -0.28827783f, 0.02991309f, 0.04326779f, -0.09301677f, 
    0.07106398f, 0.25890127f, -0.00323568f, 0.25309253f, 0.05263994f, 0.23319586f, 0.03409982f, -0.10714208f, 
    0.15598918f, 0.00529049f, 0.00681709f, -0.07033613f, -0.14894533f, -0.55162889f, -0.11686751f, -0.06823763f, 
    -0.03541465f, 0.01242104f, -0.01034187f, 0.04824231f, 0.04515890f, 0.02165883f, 0.02096286f, 0.02231610f, 
    -0.02647046f, 0.09065953f, 0.10366978f, 0.12831475f, -0.04909402f, -0.05434886f, -0.08166078f, -0.12472941f, 
    0.02640843f, -0.21611743f, -0.03754865f, -0.00146849f, 0.01299386f, 0.12792918f, -0.15535402f, -0.04798692f, 
    -0.06739233f, 0.00128732f, -0.12705663f, -0.12509787f, 0.14305830f, 0.01395178f, -0.06562796f, 0.14275479f, 
    0.02617177f, 0.10324717f, 0.22202684f, 0.06515215f, -0.04380891f, -0.06846674f, 0.06490411f, 0.05693627f, 
    0.01977675f, -0.05942179f, 0.06031497f, -0.00017259f, 0.13679653f, 0.12387795f, -0.14255407f, -0.06594080f, 
    -0.00024993f, -0.05819454f, 0.04282079f, -0.00615234f, 0.04195251f, -0.22519942f, -0.24338426f, -0.01401366f, 
    0.05057440f, -0.01262125f, -0.06439275f, -0.01017882f, 0.05166809f, -0.08843603f, -0.04591151f, -0.28551117f, 
    0.10147270f, -0.18300527f, -0.02719553f, -0.03309634f, 0.02988438f, -0.23490092f, -0.09681110f, 0.01267442f, 
    -0.19665942f, -0.06190839f, 0.08394906f, -0.15965836f, 0.07149763f, 0.05014415f, 0.00729613f, -0.20915872f, 
    -0.44049931f, -0.17219613f, -0.01283882f, -0.19956633f, 0.11366141f, 0.15310071f, -0.27353880f, -0.01426684f, 
    0.01886327f, 0.00217395f, 0.03039351f, 0.27310798f, -0.05614214f, -0.08438116f, 0.09371521f, -0.12416383f, 
    0.05687372f, -0.02742639f, 0.03901955f, 0.01499042f, 0.06916402f, 0.05275386f, -0.22209406f, 0.15476479f, 
    0.17199829f, -0.17656927f, 0.17173590f, 0.04342004f, -0.01305524f, -0.02721856f, -0.12699659f, 0.02065776f, 
    -0.04317246f, -0.19886021f, -0.16327348f, -0.04569957f, -0.01836590f, -0.03794450f, -0.06678469f, -0.00661867f, 
    0.03721114f, -0.04838939f, 0.00483979f, 0.04205102f, -0.06807861f, -0.00291580f, -0.14904872f, -0.20871158f, 
    0.12080710f, -0.01821186f, 0.02448550f, -0.06590968f, -0.03606342f, 0.00433171f, 0.01697344f, -0.05558868f, 
    0.00186381f, -0.04097848f, 0.03390708f, -0.03235411f, 0.05570146f, 0.06890613f, -0.26325548f, -0.01228667f, 
    0.06005279f, 0.01372416f, 0.02390778f, 0.03779563f, 0.12630202f, 0.03094970f, -0.19874750f, 0.06578832f, 
    -0.04802796f, 0.06497519f, 0.15119353f, 0.03931668f, -0.10873865f, -0.17233671f, -0.04329253f, -0.02057585f, 
    0.06895731f, 0.03406484f, -0.04946744f, 0.03413616f, -0.08135153f, 0.08886108f, -0.01290836f, -0.01134066f, 
    -0.00474596f, -0.07270369f, 0.06623463f, -0.00185684f, 0.08742628f, -0.01828385f, 0.05037466f, 0.01479438f, 
    -0.01610213f, 0.01995030f, 0.13556357f, 0.05482757f, -0.07976358f, -0.14331594f, -0.01981687f, -0.06157077f, 
    0.00978935f, 0.01878004f, -0.17257570f, 0.07548015f, 0.03367081f, -0.29787663f, 0.24832529f, -0.42370325f, 
    -0.08681498f, -0.05488288f, -0.01081660f, 0.08529900f, -0.06490149f, 0.00694814f, -0.00080349f, -0.14716555f, 
    -0.03394293f, 0.06393466f, 0.15286317f, 0.09518129f, 0.00815777f, 0.02475524f, -0.06700063f, 0.00193412f, 
    -0.02700220f, -0.00407555f, 0.04703825f, 0.12867549f, 0.06375661f, -0.62644190f, 0.20882422f, -0.14606318f, 
    -0.02956297f, 0.02810945f, 0.04939807f, -0.03273205f, -0.06984361f, 0.13917419f, -0.03863348f, -0.10455336f, 
    0.19645146f, -0.11043179f, -0.09831378f, 0.09908514f, 0.06047522f, -0.02186590f, 0.10046526f, -0.08890041f, 
    0.12274387f, 0.04483789f, 0.03501223f, 0.07976887f, -0.04003081f, 0.34789056f, 0.08734568f, 0.35260195f, 
    -0.01560968f, 0.03867034f, 0.07903301f, -0.04789897f, 0.02243714f, 0.00826114f, -0.02508003f, -0.14444287f, 
    0.04656151f, -0.03739744f, 0.06302291f, 0.10650732f, 0.01496614f, 0.01581427f, -0.05693369f, -0.00664681f, 
    0.03204734f, -0.01024772f, 0.07562814f, -0.11416190f, -0.05332173f, 0.04419905f, -0.05364085f, 0.07655440f, 
    0.01354752f, 0.14449635f, -0.09177745f, -0.03014531f, 0.00003863f, -0.03600693f, 0.04723840f, -0.10893445f, 
    -0.06455553f, -0.08804996f, -0.27260888f, -0.24798845f, 0.01906874f, 0.00118363f, 0.02444717f, 0.01349040f, 
    0.02104745f, -0.03472035f, 0.00958191f, -0.17197257f, -0.02671703f, -0.13312726f, 0.02969678f, 0.03513541f, 
    -0.08786422f, 0.01885563f, -0.04123350f, -0.06158563f, -0.09383322f, 0.01107910f, -0.06944756f, 0.12290692f, 
    -0.04780853f, -0.22813602f, -0.32785031f, -0.23200364f, 0.06366025f, 0.00368972f, 0.05351078f, 0.08648330f, 
    -0.00504084f, -0.00402057f, 0.00442406f, 0.00644209f, 0.08491132f, -0.09330285f, -0.47763821f, 0.04329202f, 
    0.12247279f, 0.01625367f, 0.05175560f, -0.07161532f, -0.19856486f, -0.14635305f, -0.05601724f, -0.13633513f, 
    0.07259294f, 0.09382492f, 0.19348571f, 0.04915507f, -0.03183274f, -0.08484861f, -0.03881716f, -0.13533820f, 
    0.09719799f, -0.01241410f, 0.01992134f, -0.02197330f, -0.02541399f, 0.14608569f, -0.05321355f, -0.07018505f, 
    0.04035309f, -0.00624895f, -0.05858643f, 0.10968848f, -0.03286859f, -0.18759939f, -0.16491356f, -0.12542458f, 
    -0.02591736f, -0.18476020f, 0.00413112f, 0.11071990f, 0.01134288f, -0.09485386f, -0.07245286f, 0.01214041f, 
    0.01560396f, -0.08884808f, 0.00439784f, 0.07539584f, 0.02765010f, -0.01825842f, 0.05645714f, -0.05432123f, 
    -0.02388278f, -0.02066780f, -0.09016321f, 0.00488729f, -0.08949270f, -0.09076683f, 0.13275860f, 0.05215543f, 
    0.02821125f, 0.08420540f, 0.03651717f, 0.05574433f, -0.04747031f, -0.12211690f, 0.00170776f, -0.13236287f, 
    -0.13354701f, 0.03621364f, 0.02615329f, 0.03965611f, 0.02512924f, -0.09810589f, 0.10820662f, 0.19083659f, 
    -0.00180677f, -0.02544790f, -0.02241067f, -0.11184500f, -0.11529799f, 0.09559876f, 0.02646358f, 0.03747922f, 
    0.15835889f, -0.24118486f, 0.04989675f, -0.09999847f, 0.03408443f, 0.03121937f, 0.09567832f, -0.01897779f, 
    0.06622181f, -0.03265981f, -0.27325794f, -0.16932668f, 0.03820394f, 0.04297204f, 0.03095573f, 0.02921739f, 
    -0.11878351f, -0.02454622f, -0.17795940f, -0.17784125f, 0.04143179f, -0.02238744f, -0.06469549f, 0.04926342f, 
    0.00974372f, -0.23063858f, -0.09416603f, -0.00893320f, 0.06508303f, -0.04119541f, 0.07049727f, -0.05898039f, 
    -0.23301370f, -0.05498952f, -0.06228735f, -0.30333614f, 0.06260949f, 0.05487922f, -0.06591188f, 0.05543054f, 
    0.08776844f, 0.11149758f, 0.02831316f, -0.04565657f, 0.00993897f, -0.03891116f, -0.02004059f, -0.02414070f, 
    -0.22028358f, -0.06681000f, -0.08284719f, -0.18854524f, -0.09798812f, 0.00792706f, 0.09137883f, 0.02901971f, 
    0.08507561f, 0.08035264f, -0.12582482f, 0.26522526f, 0.12719135f, -0.07088877f, -0.41675255f, 0.08993982f, 
    0.01076161f, -0.14966007f, 0.09147859f, -0.01528523f, -0.03799231f, -0.07827199f, 0.10047756f, -0.03354273f, 
    -0.03041949f, 0.12274345f, 0.12148514f, 0.17895567f, -0.17256330f, -0.05581462f, -0.08547779f, -0.01564009f, 
    0.20957105f, 0.04584101f, -0.01507265f, 0.08959928f, 0.06719855f, 0.07797462f, 0.24333161f, 0.16797686f, 
    0.01433774f, -0.07042351f, -0.05018160f, -0.01038015f, 0.20482163f, 0.18641596f, 0.15092173f, 0.03851029f, 
    0.00676940f, 0.09914631f, 0.00795231f, 0.20963272f, 0.03071758f, -0.02334915f, 0.18828885f, -0.01020598f, 
    0.04753739f, 0.01076938f, 0.01062133f, 0.19114624f, -0.08174010f, 0.16840003f, -0.33280125f, 0.21274789f, 
    -0.03788735f, -0.04535495f, 0.16289863f, -0.05951589f, 0.01407735f, -0.14168319f, -0.07676823f, -0.07201341f, 
    -0.29276261f, -0.25058526f, 0.09719280f, -0.06337173f, -0.05996985f, 0.03901502f, -0.06017210f, 0.09046268f, 
    -0.10455519f, 0.16524056f, 0.07468271f, 0.16807510f, 0.03608784f, 0.05168055f, 0.02775164f, 0.04719667f, 
    0.05394004f, -0.01799000f, 0.02381700f, 0.00718631f, -0.20043302f, -0.08208068f, -0.03352121f, -0.01923468f, 
    -0.03894932f, 0.22193861f, -0.41703907f, 0.04295958f, 0.07816713f, -0.08645964f, 0.02733763f, -0.10990433f, 
    -0.07178684f, -0.12592152f, 0.00259839f, -0.04226126f, -0.05104115f, -0.04461076f, 0.13061075f, -0.03508159f, 
    -0.02705480f, 0.12755489f, -0.00736351f, 0.01679629f, 0.05696353f, -0.03681139f, 0.03332173f, -0.06692868f, 
    0.13324977f, 0.21720013f, 0.31426373f, 0.22176635f, -0.10570827f, -0.08360159f, 0.02366329f, 0.13929112f, 
    -0.01134205f, -0.04903512f, 0.02504075f, 0.03193787f, -0.12114274f, 0.04617383f, -0.05826355f, 0.03176012f, 
    0.08770529f, -0.17566723f, 0.12393966f, -0.05842246f, -0.01599361f, -0.02798238f, 0.02699629f, 0.01222718f, 
    -0.17584895f, -0.10143011f, 0.15992647f, 0.17148922f, -0.13964863f, -0.02174035f, -0.07922995f, 0.12064531f, 
    0.00747700f, 0.05567460f, -0.02051439f, 0.01103257f, -0.17137751f, 0.10944832f, -0.23392187f, -0.15325803f, 
    0.00613902f, 0.00342964f, 0.06548537f, -0.03708943f, -0.06776716f, 0.06404155f, -0.08936879f, 0.42334494f, 
    -0.01262925f, -0.03797334f, -0.00608482f, 0.08453266f, 0.15238193f, 0.10176193f, 0.04989462f, -0.00266396f, 
    0.11164337f, 0.05666136f, 0.00086595f, 0.06372567f, 0.00331781f, 0.06005354f, -0.09969424f, -0.04342325f, 
    0.01587314f, -0.06668741f, 0.01361387f, -0.04718551f, 0.09531093f, 0.05506987f, 0.09432229f, 0.33792859f, 
    0.03982209f, 0.02561535f, -0.04844020f, 0.05008887f, -0.01856833f, 0.01438405f, 0.01455746f, -0.06361379f, 
    -0.01217233f, -0.01740420f, -0.03213284f, -0.17036313f, -0.09279716f, 0.03612955f, -0.03290662f, 0.06156507f, 
    -0.13330077f, 0.04921996f, -0.16708452f, 0.03577568f, -0.36169887f, 0.01598756f, -0.15742642f, -0.00135630f, 
    0.16808562f, 0.10554526f, 0.40025312f, -0.02352704f, -0.07604437f, -0.08071962f, -0.16792822f, 0.02763204f, 
    0.15283886f, -0.24036659f, 0.05807584f, -0.06873473f, 0.00667838f, -0.68086976f, 0.11698369f, -0.05863492f, 
    -0.04318443f, 0.00926251f, 0.11157974f, -0.00568802f, -0.03759098f, 0.24073437f, -0.01110047f, 0.17031763f, 
    0.08221348f, 0.11677548f, 0.02416285f, 0.09770789f, -0.06270705f, -0.04385600f, -0.00111387f, 0.04466129f, 
    -0.07069103f, -0.15993860f, -0.15931134f, 0.04368150f, -0.04636373f, -0.01184385f, 0.04911363f, -0.14649676f, 
    0.00059815f, 0.04416556f, -0.02323315f, 0.01111417f, -0.00985877f, 0.02870478f, 0.03613752f, -0.23508547f, 
    0.14117236f, -0.20369829f, 0.10930593f, 0.01427863f, -0.01531703f, -0.11833680f, 0.04321927f, -0.04975700f, 
    0.01792630f, -0.00338618f, -0.19301316f, -0.08121816f, 0.11709820f, -0.01906682f, -0.10894102f, 0.08836216f, 
    -0.08818229f, -0.03839098f, 0.07645053f, 0.04301118f, 0.03846412f, 0.00705020f, -0.11075050f, -0.04750945f, 
    -0.03030089f, 0.05855635f, -0.00258699f, -0.17171596f, -0.12287187f, -0.01246057f, -0.09882393f, 0.12627423f, 
    0.01619742f, -0.07054035f, 0.07324947f, -0.03361433f, 0.02512329f, -0.21280630f, 0.08602192f, 0.16036791f, 
    -0.17211315f, -0.00166951f, -0.11411908f, -0.08528839f, -0.09450588f, 0.01365817f, -0.12023107f, -0.01589170f, 
    -0.21334198f, 0.13920170f, -0.45447147f, 0.21268487f, 0.24350095f, -0.01689055f, 0.08174562f, 0.21290761f, 
    -0.04418207f, 0.05857267f, 0.02634000f, -0.02981973f, -0.11002115f, -0.15129672f, -0.00013744f, 0.18526606f, 
    0.06213168f, 0.00097154f, 0.00223487f, 0.00267966f, -0.01512449f, -0.00070089f, -0.04513607f, 0.06650437f, 
    0.19382909f, -0.05231571f, -0.07929964f, -0.11711086f, -0.04762706f, -0.00728139f, 0.00873145f, -0.02320281f, 
    0.07610559f, -0.00477762f, 0.19128418f, -0.13663715f, 0.10824140f, 0.06651584f, -0.16805242f, 0.00796666f, 
    -0.06669434f, 0.17858127f, -0.00916654f, -0.05917270f, 0.08088654f, -0.30608389f, 0.16284902f, -0.18514785f, 
    0.18147175f, 0.11462736f, 0.13199091f, 0.01017676f, 0.19499768f, 0.12276044f, 0.00285346f, -0.11380598f, 
    0.06372968f, 0.01851056f, 0.04096754f, 0.02852897f, -0.10214894f, -0.46881500f, 0.13702357f, 0.16357397f, 
    -0.09946948f, -0.04473586f, -0.12370957f, -0.03824942f, 0.16250129f, 0.38383859f, 0.26146501f, -0.06690618f, 
    -0.09332386f, 0.00993605f, 0.07110386f, 0.19593565f, -0.08266431f, -0.04534632f, 0.06558646f, -0.05044606f, 
    0.16275591f, 0.16998261f, -0.06805715f, -0.08228020f, 0.06941713f, -0.13350724f, -0.00964673f, -0.06205488f, 
    0.04052370f, -0.06656175f, 0.07407971f, 0.03111546f, 0.23864658f, -0.05756326f, 0.01104057f, 0.07234111f, 
    -0.30006462f, -0.03035500f, -0.34043887f, -0.36194083f, -0.15130062f, -0.02260431f, -0.03607112f, 0.02369783f, 
    -0.07075220f, -0.02567688f, -0.03632260f, -0.18844505f, 0.21546972f, -0.12097993f, -0.24276307f, -0.13228205f, 
    0.00937942f, -0.00746642f, 0.01022548f, 0.04826703f, 0.11507513f, -0.04935480f, 0.06088663f, -0.05360046f, 
    -0.00583654f, -0.12043806f, 0.00433735f, -0.09243768f, -0.04125910f, 0.05367100f, 0.02221764f, -0.07712475f, 
    0.08966007f, -0.08250323f, 0.08775144f, 0.15435405f, -0.12061378f, -0.23315166f, 0.02315483f, 0.06978679f, 
    0.13766557f, 0.01010335f, -0.06846312f, 0.02950889f, 0.18655293f, -0.10353359f, 0.13226205f, 0.10007347f, 
    0.02290247f, 0.03716571f, -0.02365134f, -0.00205325f, 0.15770024f, 0.00837076f, -0.14958961f, -0.08202088f, 
    0.01269112f, 0.28486472f, -0.10399427f, -0.04088280f, -0.08513933f, -0.11951132f, -0.24257855f, -0.14687975f, 
    0.01564582f, 0.02224882f, 0.01808830f, 0.03075888f, -0.11014471f, -0.13900520f, -0.08172210f, -0.11565580f, 
    -0.03857527f, 0.04180660f, -0.02114144f, -0.00481947f, 0.17453265f, 0.22975937f, 0.12390554f, 0.09679174f, 
    0.00723953f, 0.11392234f, 0.04516121f, -0.01261355f, 0.06815065f, -0.09219328f, -0.35883337f, -0.11831207f, 
    -0.01442405f, -0.13562964f, 0.02769855f, 0.05670389f, 0.03297393f, -0.12250629f, 0.03324294f, 0.05658353f, 
    0.09538811f, 0.00374573f, -0.25387102f, -0.26220417f, 0.01262952f, 0.04068436f, 0.04392029f, 0.00816199f, 
    0.00264171f, -0.03826848f, -0.09247829f, -0.21374628f, 0.08961061f, -0.19444373f, -0.03899770f, 0.08007111f, 
    0.07678361f, -0.09318873f, -0.15398254f, 0.14391530f, -0.05375290f, 0.12614170f, 0.00254572f, 0.10334431f, 
    0.08058261f, 0.24426834f, 0.05260844f, -0.25879261f, -0.01058023f, -0.05614710f, 0.03746992f, -0.12030406f, 
    0.07961502f, -0.02358072f, 0.00121718f, 0.03680566f, -0.01356738f, 0.00162980f, -0.05663921f, 0.30921036f, 
    0.04833090f, -0.03861545f, -0.02776065f, 0.00266741f, 0.09994158f, -0.05438647f, -0.06479988f, 0.04649190f, 
    0.01391286f, -0.17893091f, -0.04794535f, 0.03196584f, 0.00318469f, 0.09219696f, 0.04377783f, 0.04068082f, 
    0.02137377f, -0.12705848f, -0.05946692f, -0.24558140f, 0.10310541f, 0.14569038f, -0.15208736f, 0.11433653f, 
    -0.00522378f, -0.16451570f, 0.01951897f, -0.13707629f, -0.05831315f, -0.04425231f, -0.01721930f, -0.05995437f, 
    0.03874056f, -0.00801647f, -0.02728623f, -0.20337230f, 0.09170584f, -0.01227787f, 0.14408122f, -0.07904366f, 
    0.05777952f, -0.00607612f, 0.10492153f, -0.00933930f, 0.12300441f, -0.05261100f, -0.06604581f, 0.15506235f, 
    0.10620363f, -0.08787050f, 0.03253492f, -0.01559342f, 0.00900448f, 0.09076048f, -0.09745871f, 0.05178766f, 
    0.20673436f, -0.05306292f, -0.26914167f, 0.13116914f, 0.15137267f, -0.00881930f, -0.02405189f, -0.04885090f, 
    0.17632356f, 0.01369828f, -0.10028180f, 0.06886200f, -0.07880490f, 0.28333583f, -0.06164274f, -0.01699308f, 
    -0.08793560f, -0.10208906f, -0.01669316f, 0.02452239f, 0.04311533f, -0.07980973f, -0.03470581f, 0.00981249f, 
    0.39519510f, -0.06088128f, -0.20597386f, 0.17164500f, -0.02749989f, 0.00229966f, 0.01477657f, 0.01172206f, 
    0.06900836f, -0.06047037f, 0.01761100f, 0.12566660f, -0.11262724f, 0.19156447f, -0.40376493f, -0.24681237f, 
    0.06905643f, -0.04801301f, 0.02639911f, 0.00063435f, 0.31477147f, -0.12043493f, 0.07436136f, 0.13053365f, 
    -0.09024596f, -0.02803922f, 0.01643266f, -0.06263565f, 0.02234353f, 0.22714892f, 0.13772884f, -0.06356236f, 
    0.07851915f, 0.02818845f, 0.04348613f, 0.07624220f, -0.10840750f, -0.06734960f, 0.13851403f, 0.17178443f, 
    -0.06016849f, 0.01745863f, -0.01852641f, -0.02036563f, -0.00629551f, 0.21468528f, -0.10192330f, 0.04462301f, 
    -0.42723224f, 0.02469161f, 0.14300172f, -0.16840956f, -0.02290465f, -0.03179357f, 0.06297412f, 0.08666866f, 
    -0.01246049f, -0.01639502f, 0.02689592f, 0.06722649f, 0.17488766f, 0.06072021f, 0.13644001f, 0.35681108f, 
    -0.02380376f, 0.06317545f, 0.01083569f, -0.00377139f, 0.05560751f, 0.05262672f, -0.16003521f, -0.07222193f, 
    -0.08509675f, 0.14285165f, -0.19151749f, -0.05023967f, -0.05084160f, -0.04585738f, 0.02487088f, 0.24314557f, 
    0.02007480f, -0.09487978f, -0.03589766f, 0.01402492f, -0.05866658f, -0.04790127f, 0.23070391f, -0.11621444f, 
    -0.06910681f, -0.10108456f, 0.08556811f, 0.09163331f, 0.04628998f, -0.09367862f, 0.00922833f, 0.03534773f, 
    0.04460550f, -0.33235621f, -0.14196582f, 0.00210275f, 0.04283483f, -0.00249914f, 0.02891820f, -0.06200541f, 
    -0.02042304f, 0.03658791f, 0.32145891f, 0.16638340f, 0.08231495f, -0.01861134f, 0.12162844f, 0.30568531f, 
    0.19321525f, 0.01354772f, -0.05408466f, 0.08205705f, -0.07223249f, -0.04236242f, 0.08665312f, 0.04815044f, 
    -0.03956786f, -0.42502347f, -0.19596101f, 0.25613803f, 0.02337408f, -0.01342038f, 0.07654631f, 0.14272259f, 
    0.00680840f, -0.04108439f, 0.16683707f, 0.28993031f, -0.22152121f, 0.02768027f, -0.11404742f, -0.01735878f, 
    0.10639635f, 0.14888534f, -0.13320926f, 0.01218137f, 0.08141638f, -0.03144027f, 0.00414510f, 0.03559409f, 
    -0.14034469f, 0.10306925f, -0.20843157f, -0.15725039f, 0.11762501f, -0.03529874f, 0.04144873f, 0.02174812f, 
    0.09508575f, 0.21043672f, -0.03400622f, -0.13454978f, -0.34168342f, 0.16035245f, -0.02565744f, -0.00287942f, 
    0.00725387f, 0.01055660f, -0.03639710f, 0.14696883f, 0.07682047f, 0.11382812f, 0.12845473f, -0.04606280f, 
    -0.32018256f, -0.05398530f, -0.16013134f, -0.22848266f, 0.04368231f, 0.02539215f, 0.09554652f, -0.16528885f, 
    0.01205932f, 0.00631829f, -0.22364052f, 0.04446157f, 0.12523317f, 0.12002866f, -0.01722645f, -0.13394220f, 
    0.04936904f, 0.00330262f, 0.00168738f, -0.07121349f, -0.16250892f, -0.12722419f, -0.07246044f, -0.15086158f, 
    -0.02419797f, 0.18668930f, 0.01013351f, 0.42716259f, 0.07254003f, 0.04821036f, -0.12592411f, 0.12330768f, 
    0.07386710f, -0.02672340f, 0.03109434f, -0.11884841f, -0.05265443f, -0.01689072f, 0.20596297f, 0.09056084f, 
    -0.20091240f, -0.14620036f, -0.03511482f, 0.18274705f, -0.07898110f, 0.05657990f, -0.01147949f, -0.10325083f, 
    -0.21548872f, -0.12413855f, 0.12468205f, -0.27087083f, -0.08764590f, -0.08639610f, 0.05705573f, 0.04213336f, 
    -0.19943918f, -0.10938457f, -0.22310455f, -0.23182295f, 0.08238968f, -0.11400799f, -0.06591263f, -0.02542572f, 
    0.02909202f, -0.04553165f, -0.02353583f, -0.11744829f, 0.20211282f, -0.10518649f, 0.09498579f, 0.08970241f, 
    -0.12078658f, 0.24590510f, -0.37710583f, -0.05727676f, -0.01594262f, -0.00298193f, -0.01654078f, 0.12103821f, 
    0.13414478f, -0.08328192f, -0.13762379f, 0.09218145f, 0.06492496f, 0.03528478f, -0.09302721f, 0.02105867f, 
    0.09563148f, 0.16694966f, -0.08239793f, -0.06453241f, 0.01931059f, -0.01675357f, 0.05925451f, 0.04734695f, 
    0.12042893f, 0.15906993f, -0.02037166f, 0.05654153f, 0.14880066f, 0.10850940f, -0.04004713f, -0.14599256f, 
    -0.01242279f, -0.01762456f, -0.01022205f, 0.04002781f, -0.17262359f, -0.06883668f, 0.21581408f, 0.07817162f, 
    -0.10342898f, -0.07517236f, -0.01039562f, 0.06669112f, 0.03043529f, 0.05688875f, 0.03690493f, 0.06452890f, 
    -0.11450997f, 0.05579456f, -0.16732635f, -0.19326483f, 0.24751042f, 0.06191452f, -0.01831820f, -0.07723250f, 
    -0.00356603f, -0.06058428f, -0.00324424f, 0.11460635f, 0.16648249f, -0.27001667f, 0.09141874f, 0.03955455f, 
    -0.02258470f, -0.06490679f, 0.04240463f, 0.07342689f, 0.01519909f, -0.04881228f, 0.03138791f, -0.52883834f, 
    -0.08660393f, -0.20652144f, -0.05299962f, 0.03707222f, -0.00846386f, -0.04097151f, -0.03650961f, 0.01024379f, 
    0.03316818f, -0.05446417f, -0.03021789f, -0.06075680f, 0.15676789f, -0.17480402f, -0.24784994f, -0.00061502f, 
    0.01219462f, 0.10376719f, 0.09126625f, 0.03425802f, 0.03395194f, -0.42404950f, -0.27927917f, -0.53898835f, 
    0.04938705f, 0.02978226f, 0.05113468f, 0.10677471f, 0.11021318f, 0.14662805f, -0.08266152f, -0.02057986f, 
    0.05458238f, 0.07749454f, -0.01324090f, -0.00096161f, 0.14166966f, -0.00971569f, -0.07714392f, 0.08374343f, 
    0.22751346f, 0.03819148f, -0.05382403f, -0.04969958f, 0.06877719f, -0.00078159f, 0.07530709f, 0.10956647f, 
    -0.13712054f, 0.03204094f, 0.29647234f, -0.29336181f, 0.20932406f, -0.05683253f, 0.04927707f, -0.32880080f, 
    -0.05480015f, -0.28503060f, 0.02020499f, 0.04802358f, -0.27123153f, -0.42861199f, 0.23474151f, 0.27310270f, 
    -0.05031841f, 0.01216992f, -0.09113854f, 0.00048866f, 0.11249438f, -0.39368439f, -0.12245737f, -0.17869340f, 
    -0.31420583f, -0.20239986f, -0.20691460f, -0.09409213f, -0.05755077f, 0.01568143f, -0.05135539f, 0.12939231f, 
    0.07805299f, 0.04749943f, -0.05220046f, -0.04135787f, -0.30546033f, -0.32577929f, 0.15438849f, 0.13068013f, 
    0.18832712f, 0.00743490f, -0.00194548f, 0.00144283f, 0.18008113f, -0.26026207f, 0.33297330f, 0.22255279f, 
    0.12388549f, -0.30086899f, 0.08618379f, -0.00739804f, 0.21250048f, -0.02594191f, 0.08852694f, 0.07550215f, 
    0.05015137f, 0.13012017f, 0.05329052f, 0.09378034f, -0.28481981f, -0.66550434f, 0.13303348f, 0.15329210f, 
    -0.06219425f, -0.04658763f, -0.04027378f, 0.11997779f, -0.10308065f, -0.15211603f, 0.12668297f, -0.07602076f, 
    -0.03767620f, 0.00552907f, 0.03377670f, -0.03043807f, 0.11949699f, -0.07477387f, -0.05904812f, -0.06382769f, 
    0.09317379f, -0.05550022f, 0.11782601f, 0.12842309f, -0.28393844f, 0.03713209f, 0.02793183f, -0.17662086f, 
    0.02551961f, -0.00725474f, 0.01945684f, 0.03077729f, 0.03758765f, 0.03212896f, 0.03574882f, 0.02102767f, 
    0.27179134f, -0.44908652f, -0.30307525f, -0.42331183f, -0.07833564f, 0.07433980f, 0.17872299f, -0.09578021f, 
    -0.01940399f, 0.04919190f, -0.04410794f, 0.05008229f, -0.01237484f, -0.05029966f, -0.28821510f, -0.00546786f, 
    0.00676349f, 0.07524043f, 0.03151309f, 0.01754495f, -0.07934961f, 0.00008334f, 0.02892375f, -0.01478368f, 
    0.29767415f, 0.33099231f, -0.02790132f, 0.05919524f, 0.09284145f, -0.05006988f, -0.00350630f, 0.19218291f, 
    -0.06633520f, 0.00933261f, 0.08788689f, -0.02881498f, 0.30986935f, 0.14267872f, -0.06490052f, -0.17358215f, 
    -0.03753310f, 0.07809097f, 0.08399545f, 0.10220224f, 0.04164099f, 0.17568570f, 0.14952745f, -0.08360259f, 
    -0.41574049f, -0.43778953f, -0.39810392f, -0.16132239f, -0.09335770f, -0.20875667f, -0.21694717f, -0.45388535f, 
    -0.04725666f, -0.06833493f, 0.01092305f, 0.05122358f, -0.07842474f, -0.06904493f, -0.22384682f, 0.21941347f, 
    0.05754590f, 0.03273185f, -0.10851037f, -0.04811450f, 0.05802912f, -0.04168509f, 0.18648107f, -0.02149540f, 
    -0.15248495f, -0.13236307f, 0.02817646f, -0.01818361f, -0.13894044f, 0.02420620f, -0.24689195f, 0.00252175f, 
    -0.02545648f, -0.00138986f, 0.06452604f, 0.05702182f, -0.21474896f, 0.07455111f, 0.09016516f, -0.08690317f, 
    -0.12189627f, 0.02628961f, -0.03558825f, 0.17031315f, 0.00207699f, 0.07613438f, 0.21419230f, -0.06387727f, 
    -0.36112398f, 0.39995512f, 0.01612318f, -0.00759655f, -0.08337960f, 0.05867852f, 0.03694412f, 0.13989463f, 
    0.09840988f, 0.04724081f, 0.15659536f, 0.04209817f, 0.37317142f, 0.27635941f, -0.10001113f, 0.09556875f, 
    0.12382081f, -0.01706665f, 0.13821171f, -0.01541699f, 0.14306475f, -0.07562376f, 0.02405395f, -0.00138475f, 
    -0.28530246f, 0.52623183f, 0.27702960f, 0.35817713f, -0.05085782f, 0.05598683f, -0.02721384f, 0.19081028f, 
    0.05546885f, -0.10019761f, 0.12497040f, -0.04482873f, 0.09800440f, 0.03935554f, 0.03147535f, -0.00288350f, 
    0.07259884f, 0.00587129f, 0.15686555f, 0.03069487f, 0.04460388f, -0.05873449f, -0.00727714f, 0.01194300f, 
    0.10425928f, 0.29997554f, 0.21407278f, -0.19929349f, -0.02480118f, 0.01836979f, -0.14242393f, 0.04367102f, 
    0.11558331f, -0.10362523f, 0.11858658f, -0.07093126f, 0.00611590f, 0.19405282f, 0.04429761f, -0.04601909f, 
    0.01499608f, -0.02016974f, -0.01654091f, -0.10281122f, 0.03028104f, 0.03810721f, 0.16359141f, -0.02571557f, 
    -0.48118228f, -0.27211261f, -0.04289175f, -0.20975097f, -0.18369286f, 0.08474616f, -0.12631674f, -0.25859442f, 
    0.03969534f, -0.00097562f, -0.07624989f, 0.01236495f, 0.22399883f, 0.28490111f, 0.03742016f, 0.22051267f, 
    -0.06360524f, -0.04096883f, -0.02006850f, 0.13427888f, 0.14533433f, 0.00634804f, 0.03925874f, -0.06786434f, 
    -0.29309714f, 0.09492533f, 0.12282342f, 0.06711631f, -0.01161008f, 0.07290807f, -0.05366150f, -0.02484435f, 
    0.10484093f, 0.01097787f, 0.06373081f, 0.17598175f, -0.15792042f, 0.04415791f, -0.03251032f, 0.14259154f, 
    0.06118860f, -0.05862358f, 0.01286795f, 0.04302318f, -0.00428494f, -0.00307283f, -0.04427006f, 0.18412450f, 
    -0.31418091f, -0.51931876f, -0.39983940f, -0.10191602f, -0.01731518f, -0.15261105f, -0.02665915f, -0.21420214f, 
    -0.02303549f, 0.00775025f, -0.03680267f, -0.02082585f, -0.01747325f, -0.00361059f, 0.09085373f, 0.04782436f, 
    0.01047410f, 0.00034584f, -0.11570171f, 0.06377554f, -0.02613571f, -0.00951908f, 0.02462895f, -0.00284586f, 
    -0.00405556f, -0.00940565f, -0.12168446f, -0.05699322f, -0.02476227f, 0.09825297f, 0.05824775f, 0.11334609f, 
    -0.08190209f, -0.07550386f, -0.06693652f, 0.02631237f, 0.24269502f, -0.42819583f, -0.26584002f, -0.51062065f, 
    -0.00884365f, -0.02339100f, 0.16206661f, -0.07137508f, 0.02171457f, 0.02284599f, -0.04644430f, -0.07389650f, 
    -0.55000478f, -0.59334028f, -0.15987453f, -0.30536479f, 0.09117214f, -0.36547455f, 0.01574462f, -0.20781875f, 
    0.02458534f, -0.00491639f, -0.01798341f, 0.01689877f, 0.26804602f, 0.01602060f, -0.15201099f, -0.17735337f, 
    -0.09547106f, -0.05281945f, 0.10943627f, 0.01181688f, 0.01799834f, -0.05149810f, -0.11134370f, -0.14099535f, 
    0.18948177f, -0.05893378f, 0.01276624f, 0.12520672f, 0.04318085f, -0.07159179f, 0.05692858f, 0.03926202f, 
    -0.00358697f, 0.00698563f, 0.05800540f, -0.04478236f, -0.46238014f, -0.56288195f, -0.18281274f, -0.39345285f, 
    -0.22724359f, -0.13549191f, 0.02519140f, 0.01205654f, -0.02127873f, 0.01425483f, 0.07068000f, -0.03035248f, 
    -0.04659334f, -0.19210415f, -0.00368856f, -0.02470398f, 0.03724748f, -0.01127156f, -0.00525062f, 0.02712736f, 
    0.01308582f, 0.01902721f, 0.06357949f, -0.04451834f, 0.16848896f, -0.03069386f, 0.14226499f, 0.01783811f, 
    0.01484252f, 0.01022179f, 0.02221031f, 0.01355596f, -0.06360527f, 0.16857436f, 0.07500738f, 0.05569965f, 
    -0.47376072f, -0.36672544f, -0.14631979f, -0.40799454f, -0.39080447f, -0.34259561f, -0.22323033f, -0.31640828f, 
    -0.03071988f, -0.04260809f, -0.01262766f, -0.03754807f, 0.00880027f, 0.01021689f, -0.28545699f, -0.00185601f, 
    -0.10464752f, -0.06419423f, -0.07990371f, 0.08927348f, 0.00172863f, -0.03240963f, 0.11983901f, 0.12177477f, 
    -0.58420932f, -0.83997762f, 0.38229781f, 0.27567801f, 0.08096516f, -0.04776647f, -0.07388363f, 0.06366603f, 
    -0.02591652f, 0.01252913f, 0.01815742f, -0.02969411f, -0.04175588f, 0.04841855f, -0.12117639f, -0.66035825f, 
    -0.03533874f, -0.01120644f, -0.02644612f, 0.08718931f, -0.07844999f, 0.00321150f, 0.17890017f, 0.14841041f, 
    0.25226951f, 0.17063279f, -0.01825257f, -0.01812969f, -0.01863489f, -0.11996298f, 0.01664606f, 0.23310602f, 
    0.05485476f, 0.04805861f, 0.08259200f, -0.03181109f, 0.01839068f, -0.22928317f, -0.23851831f, 0.12137460f, 
    0.00521821f, 0.14454792f, 0.16325217f, 0.24253967f, -0.02166810f, 0.02203936f, 0.05175243f, -0.02797785f, 
    -0.10593396f, 0.04673724f, -0.05935682f, -0.15972994f, 0.05085041f, -0.05464043f, -0.04081669f, -0.03951520f, 
    0.00894036f, 0.05767548f, -0.04075199f, -0.01298579f, 0.29940507f, -0.55371433f, -0.87017268f, -0.53173262f, 
    -0.15910728f, 0.08122828f, 0.20315041f, -0.04352395f, -0.00832862f, 0.11848505f, -0.16270301f, -0.04008820f, 
    -0.06330493f, 0.01291520f, 0.19787253f, 0.09054151f, -0.03582979f, 0.01854994f, 0.07137553f, -0.06162417f, 
    0.02654220f, -0.10178883f, 0.14198720f, 0.10764737f, -0.02718314f, -0.20576029f, -0.06148612f, -0.00481277f, 
    -0.06724133f, 0.03640340f, 0.07095140f, -0.02172494f, -0.10233095f, -0.07800487f, -0.09226059f, 0.03044626f, 
    0.25080138f, 0.23537484f, -0.02315137f, -0.03420473f, 0.01408821f, 0.04034413f, 0.07145186f, -0.03677708f, 
    -0.03761443f, -0.17249733f, 0.07197262f, 0.03536445f, -0.02894900f, -0.15689257f, -0.16875213f, -0.07355361f, 
    0.02238056f, 0.12190915f, -0.04548445f, -0.01078158f, -0.03171785f, -0.03178259f, 0.09646083f, -0.06549365f, 
    -0.17704859f, -0.09478907f, 0.16712847f, -0.33397219f, 0.02297436f, 0.13404426f, -0.15880117f, 0.04232751f, 
    -0.03320446f, -0.00124953f, 0.01655237f, 0.25224251f, -0.32018197f, 0.10684307f, 0.17979437f, -0.16242486f, 
    -0.12423274f, 0.04611406f, -0.06573534f, -0.16738278f, 0.06082665f, -0.09924673f, 0.00152679f, 0.12317804f, 
    -0.66154075f, -0.48388228f, 0.21147771f, -0.22576632f, -0.06564786f, 0.07133738f, -0.01786908f, -0.24166459f, 
    0.03533620f, 0.04923522f, 0.07514565f, 0.04450281f, -0.11490824f, -0.31576100f, -0.00782051f, 0.43088514f, 
    -0.17119424f, -0.09669487f, -0.03741657f, 0.25521198f, 0.02903744f, -0.01877872f, 0.03063067f, -0.22324128f, 
    0.07377449f, -0.06671236f, 0.10642119f, 0.02707144f, 0.00365932f, 0.00821803f, 0.04105553f, -0.01446300f, 
    0.03497804f, 0.14513771f, 0.08755884f, 0.07024617f, -0.09722132f, -0.06795235f, 0.03815858f, 0.09176551f, 
    0.04938277f, -0.04785880f, -0.02432149f, 0.02728736f, -0.12242798f, -0.01787677f, -0.03039091f, -0.03718576f, 
    0.08547810f, -0.06971068f, 0.11721934f, 0.02836180f, 0.05756553f, -0.02015968f, 0.05457643f, -0.06481471f, 
    -0.00014737f, 0.07017296f, 0.11526552f, 0.11732841f, -0.09387536f, -0.12405056f, 0.07174975f, 0.00558319f, 
    0.00612628f, -0.07781269f, 0.06893440f, 0.10544502f, -0.00420152f, -0.04692808f, -0.00583288f, 0.00830383f, 
    -0.66568702f, -0.58058828f, -0.66190940f, -0.08691287f, -0.08231990f, -0.08908184f, -0.16844563f, -0.29479966f, 
    0.07000455f, 0.01197696f, 0.04636658f, 0.01946217f, -0.06942253f, -0.26967454f, -0.28643075f, 0.04935715f, 
    -0.01343674f, -0.04468701f, -0.02803958f, -0.05050995f, -0.01029008f, 0.00995161f, -0.02175828f, 0.02520231f, 
    -0.32388714f, -0.21333125f, -0.11259402f, 0.15133682f, -0.03263089f, -0.10570120f, -0.05856008f, 0.20615175f, 
    0.01350974f, 0.01156339f, 0.02965099f, 0.02809670f, 0.16301171f, 0.02647295f, -0.08400156f, 0.04239030f, 
    -0.09684666f, -0.01294984f, -0.00529626f, 0.05608884f, 0.09460350f, -0.07296369f, 0.05254227f, 0.14894295f, 
    -0.00190643f, -0.16507660f, -0.02844067f, 0.04617888f, 0.02927304f, 0.09949527f, 0.03466873f, -0.02107286f, 
    -0.09489542f, -0.05982712f, -0.15402737f, -0.05538514f, 0.05687831f, 0.14523461f, 0.04228504f, 0.00137117f, 
    0.04286822f, 0.02082017f, 0.00638839f, 0.03236821f, 0.05976353f, 0.16745257f, 0.21961306f, 0.12736776f, 
    -0.03501849f, 0.09712441f, -0.09646364f, -0.14790158f, -0.05251536f, 0.05377001f, -0.01019983f, 0.05938075f, 
    -0.01453402f, 0.01580936f, -0.10247571f, -0.07972144f, -0.15653378f, 0.12093353f, 0.03792316f, -0.15503347f, 
    -0.10904201f, -0.18768430f, 0.05540453f, 0.00388201f, -0.11705653f, -0.00050705f, -0.16273841f, 0.13194452f, 
    -0.07339255f, 0.17625424f, 0.01062118f, -0.41816264f, 0.11487906f, -0.08495809f, -0.08870513f, 0.05632424f, 
    0.02051957f, 0.00999868f, 0.11862068f, -0.16345096f, 0.08246666f, -0.13785844f, -0.19697139f, 0.10317139f, 
    -0.06562127f, 0.11057612f, -0.08603267f, 0.10488753f, 0.11918859f, 0.05175500f, 0.06453911f, 0.01693373f, 
    -0.24824721f, 0.32061630f, 0.28143790f, 0.16508523f, -0.04440257f, -0.10692843f, -0.07919587f, -0.03667508f, 
    -0.03276188f, -0.08161560f, 0.12295385f, 0.07026192f, -0.27611300f, 0.10726005f, -0.01839498f, -0.25359371f, 
    0.01805856f, -0.01113814f, 0.15973978f, 0.02164794f, 0.01421332f, -0.08838278f, 0.03715080f, 0.03451841f, 
    0.04897732f, -0.08864164f, -0.09980675f, 0.11048429f, -0.01651845f, 0.14778131f, 0.11202642f, -0.15383257f, 
    0.00542099f, -0.08551366f, -0.03999907f, 0.03085472f, -0.17744343f, -0.02526658f, 0.21932423f, 0.24700755f, 
    -0.07107438f, 0.02186381f, -0.00259839f, 0.00944381f, -0.01244012f, 0.04222989f, 0.10953338f, 0.08213270f, 
    0.00202649f, -0.03831858f, -0.03167751f, 0.01781416f, 0.16158804f, 0.00631603f, 0.03414018f, 0.03813315f, 
    0.04141327f, -0.03843411f, 0.07751554f, -0.11058357f, -0.25506091f, 0.02371203f, 0.20656790f, 0.06543779f, 
    -0.08402789f, -0.14918938f, 0.02575483f, -0.11351695f, -0.09610039f, 0.07821071f, 0.04482621f, -0.05432453f, 
    -0.27677068f, 0.31115067f, -0.41260675f, 0.13310635f, -0.06901272f, 0.07164256f, -0.08556258f, -0.03995722f, 
    -0.00928374f, 0.02925708f, 0.04160309f, 0.06063430f, -0.03437291f, -0.03800938f, -0.01901221f, -0.07436826f, 
    0.05029489f, -0.00556393f, -0.06982423f, -0.07674213f, 0.00866600f, 0.06787036f, 0.01244630f, -0.01070768f, 
    -0.47254747f, -0.24025902f, -0.33630463f, 0.03756370f, -0.05831217f, 0.01066313f, 0.04936885f, -0.10239093f, 
    -0.04697612f, 0.02933749f, 0.13938701f, -0.08168978f, -0.11441492f, 0.00786474f, 0.10137410f, 0.08462982f, 
    -0.06839145f, 0.00878913f, 0.04745537f, -0.06001278f, -0.05672777f, -0.00653026f, -0.09125929f, -0.05842774f, 
    -0.25610626f, -0.22160207f, 0.05910935f, 0.42762336f, 0.10435571f, 0.01126420f, 0.07335853f, 0.08420717f, 
    -0.00896637f, -0.04375950f, -0.03937684f, -0.03019785f, 0.24049151f, -0.19347744f, 0.07292980f, -0.22778988f, 
    0.06113499f, -0.02222398f, -0.03704685f, 0.06421346f, -0.05885349f, -0.02588980f, 0.03837444f, -0.28313375f, 
    0.01803906f, 0.11455339f, -0.18728086f, 0.12476027f, -0.03772396f, -0.10772751f, -0.03643035f, 0.04988375f, 
    -0.06378486f, 0.05578868f, 0.00886319f, -0.01116245f, 0.30840674f, -0.10908172f, -0.22894007f, -0.28269073f, 
    0.03822152f, -0.20617972f, 0.05820761f, 0.08957233f, 0.09558820f, 0.13189356f, 0.02939324f, -0.02581538f, 
    -0.26409861f, 0.04480240f, -0.09064975f, 0.15688989f, 0.00412759f, 0.02298770f, 0.26148772f, -0.01026652f, 
    -0.07295252f, 0.11342425f, 0.00052349f, 0.04404220f, 0.00766770f, -0.08886085f, 0.10510534f, -0.18173920f, 
    -0.01735974f, -0.02505025f, -0.01073669f, -0.04195342f, -0.15850881f, -0.03358191f, 0.02126863f, -0.06261680f, 
    -0.12792476f, -0.12348738f, -0.23170558f, -0.29097456f, -0.13998559f, -0.07665405f, 0.11120698f, 0.05732066f, 
    -0.03774564f, -0.08445544f, -0.02274988f, 0.00358831f, 0.12508854f, 0.02699987f, 0.04081684f, -0.23363867f, 
    -0.01111479f, 0.08583787f, 0.03237649f, -0.01234172f, -0.03580244f, -0.07528783f, -0.00999180f, -0.03944711f, 
    -0.12784709f, 0.10436668f, -0.02189678f, 0.13662274f, 0.16981977f, -0.05420623f, 0.02909648f, 0.03398397f, 
    0.01379155f, 0.02940143f, 0.02765005f, 0.01218541f, 0.00600153f, 0.02057165f, 0.10729273f, -0.06942613f, 
    -0.00199887f, 0.01677896f, 0.01647204f, -0.03829800f, 0.03328227f, 0.08859952f, -0.03337378f, -0.07005195f, 
    -0.24987030f, -0.27303213f, -0.27952048f, -0.16128477f, 0.15205322f, -0.10597358f, 0.00055861f, 0.04393613f, 
    0.04265205f, 0.03151981f, 0.04794698f, 0.05545146f, 0.06953441f, -0.07205008f, -0.07697723f, -0.03771384f, 
    -0.11818991f, -0.05851740f, 0.05458613f, -0.13431188f, 0.05208099f, 0.04320245f, 0.08292622f, 0.01294381f, 
    0.15948555f, -0.15801877f, -0.04711941f, -0.14654624f, -0.03307652f, -0.07364067f, 0.00557750f, -0.01333860f, 
    0.06703289f, -0.14561550f, 0.02141637f, 0.00204856f, 0.13099489f, 0.12302787f, 0.01663754f, -0.28190765f, 
    -0.04662443f, 0.02120953f, -0.00629862f, 0.10413999f, -0.04361847f, 0.03515507f, 0.00588681f, -0.06545530f, 
    -0.27754709f, 0.03218009f, 0.22378346f, 0.05228911f, -0.04700959f, -0.10405976f, -0.02698114f, 0.12956764f, 
    -0.05407416f, -0.05034189f, -0.03172535f, -0.00024470f, 0.10752791f, 0.06179354f, -0.16460955f, -0.19672582f, 
    0.00195298f, -0.03160352f, -0.00256683f, -0.00822629f, -0.05838937f, 0.06052394f, 0.01846245f, -0.28257063f, 
    0.04720217f, 0.04645275f, 0.00374683f, -0.00748475f, -0.00443331f, -0.02839778f, -0.05163790f, -0.09846491f, 
    0.05804298f, -0.03599272f, 0.05453512f, 0.02532552f, -0.77031326f, 0.38737482f, -0.20132206f, 0.39841625f, 
    -0.01672135f, -0.00057318f, -0.03009286f, 0.14317049f, 0.07040940f, 0.02305409f, 0.03057538f, 0.01835111f, 
    -0.44219998f, -0.26778036f, -0.21257588f, -0.17372970f, 0.10691959f, 0.01355577f, 0.10344940f, 0.15050009f, 
    0.01227689f, 0.02177807f, 0.03692217f, 0.06130916f, -0.13024306f, -0.08862139f, 0.01594640f, 0.13305084f, 
    -0.04140328f, -0.07551537f, -0.01210400f, -0.00672291f, -0.00540896f, -0.05401338f, 0.02407187f, 0.01192631f, 
    -0.16227025f, 0.09862573f, -0.03634964f, 0.05017384f, 0.04998101f, 0.02437156f, -0.01275632f, -0.06686636f, 
    -0.03165741f, 0.04372802f, 0.09472071f, -0.05013516f, 0.29376477f, -0.33745754f, -0.28250059f, -0.29988706f, 
    0.03199629f, -0.17871913f, 0.06545746f, 0.07933690f, 0.02933132f, 0.10060748f, -0.04214602f, 0.00336028f, 
    -0.00804642f, -0.02889835f, 0.07687478f, -0.18593751f, 0.04578448f, 0.00361054f, 0.02773439f, -0.06928092f, 
    0.05020398f, -0.00419101f, 0.05491544f, 0.02072081f, 0.00520190f, 0.07635880f, 0.20387712f, 0.00704138f, 
    0.03149470f, 0.02474876f, -0.01101799f, -0.03628485f, 0.00272018f, -0.20589158f, 0.02930127f, -0.11929316f, 
    -0.21129782f, -0.23958649f, -0.16401330f, 0.00092793f, -0.05839547f, -0.10285126f, -0.01455989f, 0.01131114f, 
    0.09163735f, 0.04957948f, 0.05500848f, 0.01602492f, 0.36077166f, -0.19205056f, -0.13077395f, -0.13434850f, 
    0.00905404f, 0.00376159f, 0.01029802f, 0.02607188f, -0.12799020f, -0.02493288f, -0.00137430f, -0.03980250f, 
    -0.08722164f, -0.30128637f, -0.28061345f, -0.38882005f, 0.00791000f, 0.06951046f, -0.03202851f, 0.21307023f, 
    0.03055491f, -0.07070363f, -0.06614617f, 0.03685063f, 0.11061970f, 0.17682321f, -0.35263488f, 0.24738444f, 
    -0.01248377f, -0.03868510f, 0.01786131f, -0.10697582f, -0.02340634f, 0.06050423f, -0.11508600f, -0.04993614f, 
    -0.17441902f, -0.04440515f, -0.14493768f, -0.02175982f, 0.02178736f, 0.06430814f, 0.19153857f, -0.09890382f, 
    0.09082542f, 0.03506188f, -0.00893161f, 0.03778970f, -0.32479998f, -0.20136414f, 0.03620632f, -0.15707758f, 
    -0.04313730f, 0.06432439f, -0.07482950f, -0.03441848f, 0.07147861f, -0.00761538f, -0.00323892f, 0.02894896f, 
    0.06137201f, 0.14322104f, -0.03069415f, -0.00007885f, 0.08152030f, -0.00227668f, 0.05783860f, -0.01294083f, 
    0.00531597f, 0.01461783f, -0.13881528f, -0.28409329f, -0.56461698f, 0.05725199f, -0.23860398f, 0.24441579f, 
    -0.09300304f, -0.08951051f, 0.02685514f, -0.15295407f, -0.02714298f, -0.04104605f, -0.14615361f, 0.09473809f, 
    0.15511152f, -0.03295347f, -0.07297724f, -0.11430806f, -0.00001151f, 0.00979994f, 0.01169206f, -0.00707014f, 
    -0.00055442f, 0.07866372f, -0.08435014f, -0.16346759f, -0.11122441f, 0.08453953f, -0.00663904f, 0.00103787f, 
    -0.03711225f, 0.01337098f, -0.00570729f, 0.05997470f, -0.01396341f, -0.00630888f, 0.08567362f, -0.01543986f, 
    -0.12291564f, 0.05712577f, 0.08919817f, 0.11171439f, 0.06748469f, -0.02106691f, -0.01947408f, -0.09216342f, 
    -0.25054148f, 0.03676235f, -0.10328274f, -0.01418016f, 0.08608029f, 0.00821473f, 0.04009568f, -0.08433770f, 
    0.01589225f, 0.00800571f, -0.08784420f, -0.00743633f, -0.03267501f, -0.03055525f, 0.03771475f, -0.02337575f, 
    0.49232659f, -0.25010008f, -0.24057335f, -0.48492944f, -0.11012266f, -0.05171365f, -0.17588151f, 0.09161849f, 
    0.08245694f, 0.00860294f, 0.04205768f, 0.04356179f, -0.26587462f, -0.49227989f, -0.04220735f, 0.02326196f, 
    0.09606063f, -0.01361352f, 0.13657963f, 0.17471476f, 0.12302723f, -0.00392267f, 0.12061855f, 0.02834223f, 
    -0.39332864f, 0.47485048f, -0.30019361f, 0.37483516f, -0.24035913f, -0.04151185f, 0.08483287f, 0.04216692f, 
    -0.04757579f, -0.01390864f, -0.10060333f, 0.03438718f, 0.39624038f, -0.19454880f, 0.06512100f, 0.14700806f, 
    -0.12020152f, -0.00016909f, -0.16935156f, -0.00300704f, -0.14033590f, 0.06431550f, 0.05028065f, -0.05774672f, 
    0.26680362f, -0.07817496f, -0.15631086f, -0.08667106f, 0.04239235f, -0.08251839f, -0.18485297f, 0.10494183f, 
    0.07218027f, -0.05478351f, 0.03525325f, 0.02719459f, 0.05463695f, 0.03181189f, 0.04287956f, -0.10136028f, 
    -0.02285751f, 0.02395839f, 0.04376240f, 0.03445615f, -0.04956220f, 0.02288345f, 0.00152016f, -0.11248773f, 
    -0.02446031f, 0.15064046f, -0.00570861f, 0.18154982f, -0.00152587f, -0.01548299f, 0.04152425f, 0.03239527f, 
    0.02999779f, -0.07520535f, -0.07375960f, -0.12526697f, -0.02227702f, 0.08989031f, -0.01467647f, -0.06542768f, 
    0.13681464f, 0.04125169f, 0.06653275f, 0.04428279f, 0.00436988f, -0.03794601f, 0.00606866f, -0.03881604f, 
    -0.33300671f, -0.33932650f, -0.17738034f, 0.27805945f, 0.13481337f, 0.08399194f, 0.08395356f, 0.05546077f, 
    0.03119127f, 0.02645802f, -0.00619000f, -0.00877322f, 0.17027585f, -0.16799314f, 0.03183116f, 0.03278528f, 
    -0.05233045f, 0.05359272f, -0.03265342f, -0.01131415f, 0.05068166f, 0.03065255f, -0.01209460f, -0.04881795f, 
    -0.13557886f, -0.26114240f, -0.30628857f, -0.24289608f, 0.04624761f, -0.02066456f, 0.18284641f, 0.03611769f, 
    0.06831972f, 0.02383261f, -0.02056025f, 0.03289807f, -0.03109318f, -0.07726958f, 0.03763629f, 0.03891604f, 
    -0.04576212f, -0.01425462f, -0.04641386f, -0.04568622f, -0.09244457f, -0.04902660f, 0.00148286f, 0.07507039f, 
    0.04996541f, 0.06463431f, 0.05576424f, -0.06635042f, 0.00024270f, -0.04723516f, -0.02189909f, 0.02506364f, 
    0.04977724f, 0.03835751f, 0.04024576f, -0.05625024f, 0.06170644f, 0.04869973f, 0.05953186f, 0.04776885f, 
    -0.00522606f, -0.01261594f, -0.02009788f, -0.01136789f, 0.14162630f, 0.11483587f, 0.12033091f, 0.04020920f, 
    -0.06517760f, -0.01674801f, 0.05533133f, 0.06098185f, -0.13455483f, -0.02325647f, -0.02620672f, -0.06126531f, 
    0.00899990f, -0.04098601f, 0.02185878f, -0.08564463f, 0.05073706f, 0.14352128f, -0.08758061f, -0.07629655f, 
    0.05923640f, 0.07181369f, -0.00320270f, -0.10593513f, -0.27067271f, 0.05430976f, 0.00155882f, 0.05244456f, 
    -0.13805459f, -0.02972210f, 0.01183689f, 0.26960039f, 0.06388546f, 0.08387895f, 0.16981454f, -0.02249376f, 
    0.04953151f, -0.18220428f, -0.02544748f, -0.02699871f, 0.24154083f, -0.09500550f, 0.12837134f, -0.22786716f, 
    0.03207385f, -0.05736485f, -0.07647708f, -0.00897481f, -0.02382396f, 0.16538849f, 0.03229274f, 0.00641673f, 
    0.34177384f, -0.29215553f, -0.24733123f, -0.24599737f, -0.00738098f, -0.00543549f, 0.00901573f, -0.01620804f, 
    0.04721510f, -0.00420860f, 0.01769334f, 0.06112937f, -0.15554696f, -0.26676071f, 0.10341613f, -0.27218461f, 
    -0.01827294f, -0.02673193f, 0.05810086f, -0.02581546f, 0.12068195f, -0.05642828f, 0.04852358f, -0.12031316f, 
    0.01700200f, -0.06084091f, 0.05733336f, -0.11631746f, -0.06896001f, 0.02130364f, -0.04072328f, -0.05907724f, 
    -0.01528618f, -0.02716877f, 0.00388335f, 0.03534228f, 0.46039423f, -0.06647462f, -0.05899544f, -0.36744699f, 
    0.04086840f, 0.04499594f, -0.07427368f, -0.00362477f, -0.12272387f, 0.05665259f, -0.13996978f, -0.13103481f, 
    0.05498325f, 0.00969965f, 0.03464566f, -0.04466200f, 0.00636178f, -0.04620713f, -0.00715729f, -0.13522741f, 
    -0.00981335f, 0.01235570f, 0.02637134f, -0.04480428f, 0.46814695f, -0.03665853f, 0.03369216f, -0.13612975f, 
    -0.11412767f, 0.14120111f, -0.13690616f, 0.12242614f, -0.03261370f, 0.01149054f, -0.04448359f, -0.04295300f, 
    -0.46960035f, -0.07483651f, 0.11170423f, 0.27087891f, 0.15353915f, 0.04318624f, -0.18170285f, 0.01380992f, 
    -0.14420164f, -0.05152979f, 0.03814395f, -0.08471313f, 0.28632712f, 0.26423064f, 0.12399745f, -0.06537016f, 
    -0.06058262f, -0.11225870f, -0.05850089f, -0.01668780f, -0.01333397f, -0.03099728f, -0.00276019f, 0.10862856f, 
    -0.45983914f, -0.19922537f, 0.10824709f, 0.35785121f, 0.09273104f, 0.21665369f, 0.01974618f, 0.05237617f, 
    0.06857274f, 0.12011293f, -0.07103729f, 0.04401498f, -0.20335908f, 0.03494908f, 0.08090286f, 0.13442408f, 
    0.04651412f, -0.01776428f, -0.04677690f, 0.01033935f, -0.07621469f, -0.06843241f, -0.16170853f, -0.44591337f, 
    -0.14784494f, -0.39302552f, -0.36891532f, -0.29911131f, -0.13174853f, -0.01125448f, -0.10158411f, -0.11516710f, 
    -0.00280479f, 0.06146008f, 0.04882932f, 0.01732336f, -0.04406089f, -0.06226429f, 0.00244771f, -0.18152130f, 
    -0.02326084f, 0.01998074f, 0.03444484f, -0.02439136f, 0.08700531f, 0.07503294f, 0.12698424f, 0.14688295f, 
    0.20130794f, -0.05185318f, -0.11746996f, -0.00631792f, -0.08768033f, 0.06279559f, -0.10304631f, 0.07501941f, 
    0.03503590f, 0.09132984f, 0.12590002f, 0.13316661f, -0.09490139f, -0.13379455f, -0.22483651f, -0.12517419f, 
    0.01981005f, 0.03746254f, 0.02943519f, 0.11433516f, 0.14709473f, 0.06556626f, -0.02143422f, 0.07522004f, 
    -0.18178013f, -0.32141954f, 0.09946156f, 0.08967979f, -0.14875513f, -0.00168759f, 0.09611814f, -0.11401597f, 
    0.02487233f, -0.05610191f, -0.07263348f, 0.02975264f, -0.31329462f, 0.16766340f, 0.05982198f, 0.00173483f, 
    0.13322848f, 0.07250863f, 0.04458892f, 0.02309966f, -0.01552706f, 0.02192950f, -0.02263957f, 0.17717828f, 
    -0.04265730f, -0.10352033f, 0.06846701f, 0.05300014f, 0.03235159f, 0.03269587f, 0.15257634f, 0.05783985f, 
    0.08557993f, 0.04004396f, -0.08372265f, 0.06122997f, -0.07879888f, -0.01670616f, 0.05404813f, 0.13873984f, 
    -0.05813015f, -0.06095463f, 0.01813973f, 0.04920954f, 0.06456122f, 0.05340906f, 0.02568782f, 0.14247487f, 
    -0.19799535f, -0.09075579f, -0.09772673f, -0.10716568f, 0.10249539f, 0.08863500f, 0.01883290f, 0.03787446f, 
    0.08837815f, 0.04829412f, 0.04896722f, 0.10066979f, -0.23902193f, -0.07995129f, 0.07968872f, 0.05491752f, 
    -0.03795501f, -0.11757959f, -0.08034173f, -0.05455319f, -0.06640126f, 0.06949105f, -0.08724438f, -0.28742152f, 
    0.10032018f, -0.25343275f, -0.41666850f, 0.13563161f, 0.02865698f, 0.14244263f, 0.17589691f, -0.09426162f, 
    -0.02450774f, -0.02494245f, 0.04980704f, 0.01422297f, -0.32556599f, -0.05886325f, 0.05391388f, 0.15473728f, 
    0.04570018f, 0.11940446f, 0.07580297f, 0.09282441f, -0.00082582f, 0.04698040f, -0.00043115f, 0.02472219f, 
    0.02148254f, -0.14195895f, -0.04458487f, 0.04367747f, 0.08340530f, 0.07855424f, 0.05988471f, 0.15464801f, 
    -0.07377882f, -0.11686569f, -0.13023160f, -0.03182036f, 0.21962728f, -0.14888933f, -0.07506774f, 0.15151836f, 
    -0.06639243f, 0.06781258f, 0.07756416f, 0.00969918f, 0.01518573f, -0.10643782f, -0.00558531f, 0.10867023f, 
    -0.00476470f, -0.18607175f, -0.40652066f, -0.38666913f, -0.26835486f, -0.13050145f, -0.04640907f, -0.16467282f, 
    0.01803776f, 0.02577053f, 0.02549338f, 0.04702277f, 0.03001816f, 0.11866153f, -0.21521428f, -0.28915513f, 
    -0.13651361f, -0.05487117f, -0.01272131f, -0.02160761f, 0.19782706f, 0.02938918f, 0.09758467f, 0.09221170f, 
    -0.34809434f, 0.11964873f, 0.03782394f, -0.08223013f, -0.02927747f, -0.02810876f, -0.04571560f, -0.10949660f, 
    -0.21876734f, -0.17518434f, -0.17807895f, -0.08223854f, -0.29334536f, -0.11542469f, -0.11620775f, -0.02422096f, 
    0.03470471f, -0.07486437f, -0.00793463f, 0.08657219f, 0.01382830f, 0.12512261f, 0.14093883f, 0.04684165f, 
    -0.08370136f, -0.59670049f, -0.44035083f, 0.00453137f, 0.03977918f, 0.04854993f, -0.03274558f, 0.03279997f, 
    -0.04473023f, 0.04262380f, 0.00819534f, 0.15664224f, -0.21008049f, 0.10626954f, -0.07661673f, 0.03008836f, 
    0.15095481f, 0.01751652f, -0.08787747f, 0.02695440f, -0.03936156f, 0.13330615f, 0.15053318f, 0.13172781f, 
    -0.10111553f, -0.05489199f, 0.08603944f, 0.11972289f, -0.03846466f, 0.05571030f, -0.08770701f, -0.05410257f, 
    -0.00430394f, -0.04477623f, 0.06282020f, 0.05314980f, -0.09074967f, -0.20941018f, -0.49367264f, -0.37280688f, 
    -0.15064272f, -0.04565731f, 0.07908642f, -0.09946788f, -0.01837500f, -0.02374325f, -0.00816484f, -0.03906344f, 
    -0.30958292f, 0.02333610f, 0.07370387f, 0.03140550f, -0.04850209f, -0.10489573f, -0.04030106f, -0.03033761f, 
    -0.07730491f, 0.02545930f, 0.01437459f, -0.03261672f, -0.21214427f, 0.02185952f, 0.08488549f, 0.27445421f, 
    -0.01516832f, 0.00963262f, -0.06409644f, -0.00064588f, 0.01122258f, 0.18565786f, -0.03450594f, 0.05860005f, 
    -0.11934058f, -0.39170927f, -0.33332473f, 0.04173652f, 0.10256777f, -0.05066581f, -0.02227547f, -0.09391184f, 
    -0.03026928f, 0.05999353f, 0.02875492f, 0.10647155f, -0.05511487f, 0.03690728f, -0.16129869f, -0.08723746f, 
    0.07590051f, 0.00933560f, -0.06843166f, -0.02831654f, 0.15827738f, 0.14728041f, 0.16832907f, 0.06949022f, 
    0.15667844f, -0.40221238f, -0.37019697f, 0.03253311f, 0.02826006f, 0.05731887f, 0.11904290f, -0.04298518f, 
    -0.05034889f, -0.00878140f, -0.03166880f, -0.08204503f, 0.41093338f, -0.05346874f, -0.31065035f, -0.16358230f, 
    0.10606135f, 0.08137327f, -0.01217610f, 0.08252414f, 0.29107386f, 0.05012666f, 0.02456508f, 0.06647298f, 
    -0.20724195f, -0.34716818f, -0.01730659f, -0.00526645f, -0.01180058f, 0.00172121f, 0.05352072f, 0.09126482f, 
    -0.22414172f, -0.05112654f, -0.05178540f, -0.08817434f, 0.60477233f, 0.09940014f, 0.15602522f, -0.11337502f, 
    0.09270988f, 0.06546263f, 0.05417914f, -0.09085482f, -0.12322950f, 0.02795511f, -0.07629758f, -0.11800442f, 
    -0.02877324f, -0.03906465f, -0.03183733f, -0.04563184f, -0.12887909f, -0.00659105f, 0.02363665f, -0.09450521f, 
    -0.06335139f, 0.10364694f, -0.01779678f, 0.15992987f, 0.38318422f, -0.20491818f, -0.03775778f, 0.13962348f, 
    0.18174565f, 0.04070729f, -0.09147678f, 0.03633571f, -0.03292290f, 0.02434283f, 0.07337856f, -0.09359723f, 
    -0.14262819f, 0.24315050f, -0.05378144f, 0.24311444f, 0.00245557f, 0.00751734f, 0.00497080f, -0.08475053f, 
    0.12865596f, 0.05170714f, 0.06071050f, 0.10668186f, -0.12471034f, -0.02035878f, 0.05495403f, 0.06769489f, 
    -0.02456874f, -0.05307852f, 0.04297568f, 0.02485500f, 0.06052974f, 0.06694473f, 0.05821894f, 0.10495405f, 
    -0.30417219f, -0.40267932f, 0.22193049f, -0.08598576f, -0.01918264f, 0.07390544f, 0.02002074f, -0.00322539f, 
    -0.06408766f, -0.05103511f, -0.01413026f, -0.03976671f, 0.14381456f, 0.12716298f, 0.07575341f, -0.04525270f, 
    -0.01285300f, -0.06945676f, -0.01944932f, 0.01797191f, -0.01091150f, 0.00766133f, -0.04742760f, -0.03231183f, 
    -0.09331099f, -0.51706362f, -0.19578800f, -0.15913604f, 0.06882176f, 0.14218645f, 0.22128151f, 0.11171211f, 
    -0.10698382f, 0.00896507f, -0.02470662f, -0.13960944f, 0.14835475f, -0.03015282f, -0.19904712f, -0.05542618f, 
    -0.00649211f, 0.06639068f, 0.05473338f, 0.01322563f, -0.19861467f, -0.17539522f, -0.23479748f, -0.18522449f, 
    -0.07983129f, -0.05344466f, -0.13551341f, -0.23389782f, 0.13021797f, -0.03046797f, -0.07484607f, 0.15243912f, 
    0.04620775f, 0.09228811f, 0.00551266f, 0.08761453f, 0.37587935f, -0.09199396f, -0.13710761f, 0.02499497f, 
    0.16197295f, -0.02407266f, 0.13864425f, -0.11848004f, 0.00179668f, -0.00484991f, 0.11554261f, 0.06511756f, 
    0.16164185f, 0.22605701f, -0.19537303f, -0.03881321f, 0.03082564f, -0.03004321f, 0.16135904f, 0.05596267f, 
    -0.02057459f, -0.00303343f, -0.22500265f, -0.24700235f, 0.01046992f, -0.01789488f, -0.00254906f, -0.07379280f, 
    -0.10165045f, -0.09801342f, 0.03475220f, 0.04228263f, 0.06340624f, 0.01306595f, 0.12349274f, 0.09285419f, 
    -0.17830163f, -0.19073433f, 0.08909447f, 0.03443477f, -0.02394861f, 0.03064079f, -0.06858390f, 0.07905723f, 
    -0.16213903f, 0.05103406f, -0.07104865f, -0.17609045f, -0.26633218f, -0.00073598f, 0.01223182f, 0.06846583f, 
    0.06609074f, -0.09602100f, -0.01813925f, -0.03565475f, 0.09504118f, 0.06039323f, 0.04994640f, 0.03704923f, 
    -0.02222437f, -0.24525446f, 0.10361806f, -0.03834302f, 0.06350616f, -0.04205985f, 0.03608687f, 0.08488043f, 
    -0.03301311f, -0.05230402f, -0.02434558f, 0.02130269f, 0.32437629f, 0.05336231f, -0.11537392f, -0.10868867f, 
    0.07033198f, -0.19461422f, -0.07419204f, -0.03039961f, -0.02762454f, 0.09973467f, 0.19477591f, 0.05621284f, 
    0.16238666f, -0.26199409f, -0.27940390f, 0.23223220f, -0.01215617f, 0.12660432f, 0.13202971f, 0.00733203f, 
    -0.05108283f, -0.02740583f, 0.03624492f, -0.01412072f, -0.15834680f, -0.04704380f, 0.11399809f, -0.02226893f, 
    0.06772128f, -0.00597610f, 0.04768205f, 0.10123225f, -0.11161844f, -0.08596552f, -0.17297490f, -0.32341206f, 
    -0.27612612f, 0.03900285f, 0.06878670f, -0.10948225f, -0.03349027f, 0.00549316f, -0.00904787f, -0.07478061f, 
    -0.06459670f, 0.00315005f, -0.00842770f, 0.06062863f, -0.24662787f, 0.02272761f, -0.02424318f, -0.02721636f, 
    0.02390293f, -0.01947753f, -0.01475247f, -0.01284135f, -0.14721160f, -0.08358677f, -0.19395597f, -0.35754156f, 
    -0.06185914f, 0.03967937f, -0.01207397f, 0.01590500f, 0.08245402f, -0.01066965f, -0.04140149f, 0.03360890f, 
    -0.03266221f, 0.06150446f, 0.08935440f, 0.09978899f, 0.14083007f, 0.03291680f, 0.04147922f, -0.07373136f, 
    -0.04570933f, 0.02884255f, 0.02285824f, 0.01408841f, 0.12818217f, 0.02174582f, -0.00840063f, 0.03370722f, 
    0.00191508f, -0.09761612f, -0.26031569f, -0.03758023f, 0.02279648f, -0.14202233f, -0.01620417f, -0.07840091f, 
    0.19483636f, 0.11653523f, -0.07527297f, -0.01438949f, 0.28425369f, 0.21033673f, -0.14832665f, -0.43112606f, 
    -0.01294063f, -0.06289137f, 0.02236835f, 0.05035971f, -0.00728068f, 0.06049508f, 0.01203365f, -0.01675690f, 
    -0.15626116f, -0.27879411f, -0.13139328f, -0.05312506f, -0.01311195f, 0.08731293f, 0.11951707f, 0.12559544f, 
    0.16496301f, -0.07533706f, 0.15283181f, -0.07343756f, -0.13074461f, 0.05495822f, 0.09566517f, -0.00646298f, 
    0.17775020f, -0.01613272f, 0.00256453f, -0.15415658f, -0.00735677f, -0.00219919f, -0.11789089f, 0.02249414f, 
    0.22067352f, 0.03435131f, 0.01049901f, -0.09610984f, -0.03038383f, -0.02364201f, -0.02380012f, -0.01391387f, 
    0.08692755f, 0.02839262f, 0.13215758f, 0.09556759f, 0.16109602f, -0.09302024f, -0.34305686f, -0.20855500f, 
    0.13418497f, -0.05157875f, 0.11221850f, -0.03490151f, 0.12206840f, 0.01215218f, 0.07595208f, -0.04070762f, 
    -0.11932627f, 0.13942158f, 0.03514997f, -0.07836854f, 0.03136376f, 0.04171330f, 0.01106429f, 0.00489956f, 
    0.05236210f, -0.07147702f, 0.00677328f, 0.00953076f, 0.01617834f, 0.03393384f, -0.41196889f, -0.22817607f, 
    0.04880205f, -0.14050207f, 0.15779185f, 0.02074273f, 0.07903682f, 0.02644330f, -0.08625279f, 0.03586644f, 
    -0.02733400f, 0.54558241f, -0.82416165f, -0.19301589f, -0.07246932f, -0.03510089f, 0.22251323f, 0.14141034f, 
    -0.01859401f, -0.02530575f, -0.04713876f, 0.04971255f, -0.27019948f, -0.21329115f, -0.35539445f, 0.17860292f, 
    0.10698684f, 0.14973541f, 0.08391377f, -0.04091999f, 0.00249798f, -0.10113187f, 0.06462203f, 0.00160946f, 
    -0.12915270f, 0.10758518f, 0.45329297f, -0.65978503f, -0.05533535f, -0.11738211f, 0.07490619f, -0.12530017f, 
    -0.02834770f, 0.04328064f, -0.06248962f, 0.01886061f, -0.12543027f, 0.16424184f, -0.25287023f, 0.03274280f, 
    0.13153659f, -0.11683965f, 0.09448626f, -0.04782810f, 0.13862552f, 0.15206063f, 0.01427713f, 0.05270181f, 
    -0.18698595f, 0.03564643f, -0.04839446f, -0.16966930f, -0.16565186f, -0.16802727f, 0.14172046f, 0.22421946f, 
    -0.00054267f, 0.07047485f, 0.04822010f, -0.03816035f, 0.11273506f, -0.04856152f, 0.22511794f, 0.16090962f, 
    -0.11832600f, -0.02231066f, -0.08721317f, -0.13169296f, 0.01376489f, -0.11336564f, -0.13082714f, 0.16171804f, 
    -0.32300410f, 0.03423192f, -0.20547104f, 0.06429526f, 0.00789356f, 0.00693736f, 0.03134729f, 0.04988896f, 
    0.05155959f, -0.15442327f, -0.03611528f, -0.11014288f, 0.11958167f, 0.12505418f, 0.05866885f, 0.44757953f, 
    0.00852827f, 0.04707519f, -0.20418528f, -0.05408446f, 0.04066895f, -0.01676027f, -0.02857221f, -0.07951651f, 
    0.11542659f, -0.37003171f, -0.05756878f, 0.02926247f, 0.08564191f, -0.07775684f, -0.14093065f, 0.02238180f, 
    -0.04285631f, 0.04369606f, -0.05936117f, 0.09508034f, 0.03156613f, -0.16402350f, 0.04852122f, -0.36083701f, 
    -0.13684087f, -0.12112679f, -0.01918437f, -0.07551148f, -0.02035406f, 0.16346100f, 0.08797776f, -0.15882365f, 
    0.23125756f, -0.07444309f, 0.33062628f, -0.27596301f, 0.11352883f, -0.22743757f, -0.06187592f, -0.08348472f, 
    -0.20015728f, 0.00032932f, -0.05822581f, -0.03700567f, 0.16052330f, -0.35461614f, 0.02784910f, -0.31097332f, 
    -0.01655234f, 0.02669535f, -0.13508913f, 0.09948265f, -0.11503701f, -0.01134142f, -0.01957241f, -0.08507222f, 
    0.03678999f, 0.15027265f, -0.07616481f, 0.00221250f, 0.09463992f, -0.13730761f, -0.08901298f, 0.05798084f, 
    0.03156406f, -0.00121845f, 0.03840715f, -0.12449428f, 0.07369870f, -0.20985387f, 0.11808615f, 0.07704745f, 
    -0.04952481f, 0.05605470f, 0.09594521f, 0.00101944f, 0.11534641f, 0.05295810f, 0.01739820f, 0.01783738f, 
    -0.24030577f, 0.01711098f, 0.00235064f, -0.46717101f, -0.10566115f, -0.04902603f, -0.13852100f, 0.12247232f, 
    0.03719626f, -0.02504370f, -0.01727843f, -0.01745855f, 0.06283465f, 0.17431870f, 0.15978816f, -0.37105334f, 
    0.08062516f, -0.26932269f, 0.14387308f, -0.22636211f, -0.02675445f, -0.00200667f, 0.08387684f, -0.01216568f, 
    0.22376168f, 0.01056258f, 0.07737890f, 0.00887160f, -0.02944021f, -0.12876287f, -0.21188110f, 0.02978422f, 
    0.11321367f, 0.02131673f, -0.05094927f, 0.11400013f, -0.22545408f, -0.52602607f, -0.06144982f, -0.29320663f, 
    0.14025074f, 0.05635168f, 0.15785448f, 0.01583253f, -0.16133451f, -0.09338222f, -0.07813187f, -0.02457905f, 
    -0.19793126f, -0.14759439f, 0.12290845f, 0.03801117f, -0.19298421f, 0.11640543f, -0.00118247f, 0.12499236f, 
    0.07831112f, 0.06425765f, 0.09344871f, -0.02431771f, -0.22628115f, 0.19501121f, -0.08046180f, 0.33393291f, 
    0.06848865f, 0.08610473f, -0.16840619f, 0.03496360f, -0.02897122f, -0.07457963f, 0.10428503f, -0.11207023f, 
    -0.04355475f, -0.12500623f, -0.09501450f, -0.06243872f, 0.11614208f, 0.04394903f, 0.15646975f, -0.06673765f, 
    0.05451994f, -0.02561933f, 0.03153668f, 0.07447359f, 0.08124604f, 0.55065858f, -0.27906859f, -0.01132921f, 
    -0.05207118f, -0.06701085f, 0.28511342f, 0.05227319f, 0.05059189f, -0.02555183f, -0.07358123f, -0.11188183f, 
    -0.02964196f, -0.05802390f, -0.07326557f, -0.29514992f, -0.07042828f, -0.08256464f, -0.13617571f, 0.09663389f, 
    -0.00172621f, 0.00243883f, 0.05297816f, -0.02079736f, -0.12866065f, 0.35759300f, -0.30728415f, 0.13482077f, 
    0.11483117f, -0.05494668f, 0.17991275f, 0.00816825f, 0.09462283f, -0.04269724f, 0.02700590f, -0.00863428f, 
    -0.05275244f, -0.12416228f, -0.04088604f, -0.40219671f, 0.00588760f, 0.01971681f, 0.10098156f, 0.09613977f, 
    -0.28286356f, -0.03000090f, 0.06426695f, -0.05168889f, -0.26637417f, 0.05568105f, 0.14958462f, 0.36125788f, 
    0.06925126f, 0.02804171f, -0.08633495f, 0.03494433f, 0.03187626f, 0.01836689f, 0.02708152f, -0.00370033f, 
    -0.00436784f, -0.22213246f, -0.08325358f, -0.05176053f, 0.02109776f, 0.06087121f, 0.10641479f, 0.02224378f, 
    -0.09693068f, 0.06955285f, -0.03875567f, -0.00173993f, -0.05608596f, -0.29339966f, 0.07734147f, -0.06307490f, 
    -0.15400960f, 0.07457943f, -0.09497001f, -0.04958504f, 0.20796505f, 0.24848336f, 0.00927120f, -0.08875465f, 
    -0.05215897f, 0.01919105f, 0.07103869f, -0.16792670f, 0.12737176f, -0.24048550f, -0.08341820f, 0.15371877f, 
    0.02628465f, -0.05005615f, -0.03211308f, -0.03854214f, 0.19196153f, -0.00309633f, 0.05579858f, 0.28077510f, 
    -0.04790419f, -0.18318680f, 0.07946205f, -0.11415070f, 0.00839875f, -0.13375819f, 0.02717908f, -0.16194981f, 
    -0.34007642f, -0.17063664f, -0.09413277f, -0.55711949f, -0.20968875f, -0.00111654f, 0.01213079f, -0.12941532f, 
    0.10822719f, -0.00492912f, 0.05617618f, 0.11294164f, -0.35999477f, 0.20980722f, -0.40431994f, 0.41946650f, 
    0.08118025f, -0.09478505f, -0.01067437f, -0.15087324f, 0.08348185f, -0.05034196f, -0.00226580f, 0.04888432f, 
    -0.21345550f, 0.19791119f, 0.07988092f, -0.12628971f, -0.19382541f, -0.16196664f, 0.06082284f, -0.20802723f, 
    0.05258593f, 0.02337351f, 0.09985110f, 0.06415481f, 0.11589101f, -0.47196451f, 0.12286663f, -0.14148112f, 
    0.06668093f, 0.03450603f, -0.01934326f, -0.08386598f, 0.06889808f, -0.05838007f, 0.00907996f, -0.07643682f, 
    -0.31946751f, -0.01304893f, 0.28013730f, 0.14535387f, 0.08593956f, 0.12355176f, -0.14631957f, 0.00968518f, 
    0.10815733f, 0.02451992f, -0.06558869f, 0.05252016f, -0.21454901f, 0.24543774f, -0.41826114f, -0.17775357f, 
    0.18251516f, -0.02549030f, 0.09061196f, -0.05993655f, 0.06597151f, -0.13665920f, 0.15595582f, -0.01877284f, 
    -0.12140757f, 0.05707241f, -0.15307423f, -0.05872530f, -0.05624808f, -0.05973860f, -0.15062845f, -0.00149761f, 
    -0.03222537f, -0.00595214f, -0.00822720f, 0.13703729f, 0.11823276f, 0.00371421f, -0.04760591f, -0.05830526f, 
    0.14091897f, -0.03162129f, 0.14353238f, 0.07519595f, 0.06478046f, -0.11403878f, -0.09765090f, -0.03299727f, 
    -0.05851168f, 0.01186887f, -0.03076182f, -0.18264291f, -0.05628772f, -0.09448944f, -0.01115788f, -0.07365823f, 
    0.04640884f, 0.03975204f, 0.13417462f, 0.16126558f, -0.02594564f, -0.25913179f, -0.34442386f, 0.16407919f, 
    -0.06692918f, 0.02910948f, 0.08463321f, -0.06721823f, 0.01517640f, -0.11235214f, -0.08633563f, -0.04229057f, 
    -0.06425131f, 0.15888542f, -0.35406107f, 0.16895132f, -0.13722140f, -0.07263768f, -0.03898774f, -0.14908600f, 
    0.09492658f, -0.07205703f, 0.09573417f, 0.03528219f, 0.13432954f, 0.02037403f, 0.20033726f, 0.09733090f, 
    0.02699639f, -0.06321966f, -0.14016353f, 0.08118717f, 0.05756759f, 0.15132390f, 0.10406435f, 0.03139719f, 
    -0.68205130f, -0.11446826f, -0.34904173f, 0.02549629f, 0.07681088f, -0.02582796f, 0.04690889f, 0.15147236f, 
    0.09455207f, 0.01009251f, -0.00573465f, 0.02563728f, -0.26676217f, -0.09569032f, 0.18728785f, -0.13807869f, 
    -0.08995550f, 0.06496404f, 0.06302778f, -0.14630908f, -0.00395760f, 0.01060573f, 0.07298606f, 0.06711207f, 
    -0.07610840f, -0.01208179f, 0.20839930f, 0.42816374f, 0.01283805f, -0.02440415f, -0.04319825f, -0.13187453f, 
    0.19415158f, 0.03189882f, -0.03096230f, 0.22023842f, -0.00289942f, -0.13481151f, 0.05859344f, -0.00933371f, 
    0.14678222f, 0.12442591f, -0.03106009f, -0.01883159f, -0.08479082f, -0.01598634f, 0.07168370f, -0.09188891f, 
    -0.19588974f, -0.01414719f, 0.05104143f, -0.06920735f, -0.06509601f, -0.02299482f, 0.07969726f, 0.00717290f, 
    0.09062381f, 0.01072956f, 0.07897110f, 0.05041817f, 0.00908241f, -0.08541234f, -0.13324881f, -0.13259925f, 
    0.14287193f, 0.11563954f, -0.01082485f, 0.06986425f, -0.03285119f, -0.06600130f, -0.06847534f, -0.09283359f, 
    0.03503925f, 0.05030434f, 0.20119576f, -0.04003270f, -0.03608790f, -0.14816847f, 0.15529121f, 0.22651798f, 
    -0.03904216f, 0.05551634f, 0.01704179f, -0.04651172f, -0.09683959f, -0.23607284f, -0.12727691f, 0.23233746f, 
    -0.01249052f, 0.22316016f, 0.07767149f, -0.14749195f, 0.06848638f, -0.06864382f, -0.09447850f, -0.06266096f, 
    -0.16735505f, -0.12693541f, -0.19460517f, -0.33285657f, -0.08037210f, -0.11522151f, -0.01802409f, -0.06773321f, 
    0.08050410f, -0.03922449f, 0.09590000f, 0.05325031f, 0.19557142f, 0.02753737f, -0.12931809f, -0.07066638f, 
    0.06465621f, -0.07079145f, -0.02758089f, 0.04914042f, -0.01816577f, 0.06068199f, 0.14766578f, 0.12394274f, 
    0.03351104f, -0.12351496f, 0.10678827f, -0.11057124f, 0.10258802f, 0.19209722f, 0.10532394f, 0.02056527f, 
    0.12129696f, 0.01243780f, 0.04551877f, 0.00131814f, -0.00931755f, 0.01334081f, 0.15897818f, 0.04544548f, 
    -0.00440203f, 0.00584860f, 0.04196449f, 0.01969149f, 0.03020044f, 0.18114100f, 0.19719113f, 0.15498064f, 
    -0.22184908f, 0.13652706f, -0.32767379f, 0.15023300f, 0.09981442f, -0.10333616f, 0.12747699f, -0.04497198f, 
    0.14389332f, -0.11573786f, -0.02770128f, -0.10397240f, -0.07577958f, -0.13412039f, 0.08599534f, 0.09268557f, 
    0.06271739f, 0.02994887f, 0.03504888f, -0.12354508f, 0.04971508f, -0.17276768f, -0.04255229f, -0.06969360f, 
    0.18914720f, -0.06212243f, -0.16458137f, -0.15891004f, 0.12363450f, -0.14588641f, -0.07045411f, 0.13273917f, 
    0.06191045f, 0.02842200f, -0.00819728f, -0.07353000f, -0.14650634f, 0.04134003f, 0.01226241f, 0.12169594f, 
    0.07870086f, 0.02587724f, -0.06351840f, -0.09483764f, -0.02336361f, -0.02283474f, 0.05878498f, -0.05086378f, 
    0.27330592f, 0.11919673f, 0.38206258f, 0.02023529f, 0.02081094f, -0.12849353f, -0.15430143f, -0.11437493f, 
    -0.09492154f, -0.03636064f, 0.13603240f, 0.06548098f, 0.19988559f, -0.11530866f, -0.19650961f, -0.26363379f, 
    0.14508806f, -0.15723877f, 0.06345157f, -0.07877333f, -0.03376156f, -0.02440709f, -0.17877008f, -0.15981244f, 
    0.19435537f, -0.24597383f, 0.00991320f, -0.32045937f, 0.14654157f, -0.05322284f, -0.12102024f, 0.00125137f, 
    -0.06083378f, -0.08033124f, -0.06084235f, -0.02931200f, -0.06404357f, 0.02456452f, 0.35627818f, 0.21224107f, 
    0.02987207f, -0.08279657f, -0.15132019f, -0.14165837f, 0.13473229f, -0.01822765f, -0.14360265f, 0.02640336f, 
    -0.13508750f, -0.16985320f, -0.03433618f, -0.13166234f, 0.01247088f, 0.02141976f, 0.05635823f, 0.08367760f, 
    -0.12175321f, -0.01174508f, -0.09538397f, -0.10098802f, 0.13171940f, -0.16627048f, 0.29100478f, 0.32688022f, 
    0.05585359f, 0.10920546f, -0.24979284f, -0.04405720f, 0.18538480f, -0.03926802f, 0.02865798f, 0.06358737f, 
    0.07977031f, -0.18779922f, 0.17661695f, 0.11730239f, 0.02931710f, -0.13039398f, 0.15126453f, 0.05342997f, 
    -0.06545456f, 0.07078441f, -0.09341011f, 0.00139313f, -0.12307645f, -0.02086906f, -0.16293658f, -0.16476697f, 
    -0.09458847f, 0.03524299f, -0.08001810f, -0.04181046f, 0.03076736f, 0.09521809f, -0.04744911f, 0.02863056f, 
    -0.01812711f, -0.10900503f, 0.11263082f, -0.17752793f, 0.05197356f, -0.00386390f, 0.06638929f, -0.00117777f, 
    -0.02246451f, -0.12596177f, 0.01098978f, -0.02980550f, 0.04543677f, 0.07313585f, -0.18941350f, 0.01324878f, 
    -0.09438094f, -0.10671581f, -0.11255628f, 0.10008910f, -0.28881797f, -0.19177645f, -0.42326671f, -0.10915279f, 
    -0.16858791f, -0.22152536f, -0.03221557f, 0.02669024f, -0.04887567f, 0.03491178f, -0.10388029f, -0.06909578f, 
    0.05346501f, 0.14627641f, 0.05582755f, 0.07202683f, -0.27848271f, 0.20876926f, -0.11221752f, -0.01770788f, 
    -0.01226521f, -0.13101673f, -0.01709511f, -0.03993393f, -0.14871523f, 0.18569373f, 0.16643499f, 0.01977607f, 
    0.18277854f, 0.25037521f, 0.30343390f, -0.06172754f, -0.01581764f, -0.02656011f, 0.03540797f, 0.21784677f, 
    -0.02217851f, 0.18697548f, 0.13838199f, 0.08493954f, 0.07063525f, 0.11400653f, 0.11583593f, -0.09656788f, 
    -0.16299413f, -0.07262123f, 0.22403106f, -0.02339307f, 0.08998359f, 0.17736615f, 0.16242084f, 0.09874092f, 
    -0.29795191f, 0.27405906f, -0.05669507f, 0.18012822f, 0.13384219f, -0.03840869f, -0.12756298f, 0.16601065f, 
    -0.07408588f, 0.06568657f, -0.03387725f, -0.07583342f, 0.08390887f, 0.18051922f, -0.04459892f, 0.08491367f, 
    -0.19119106f, -0.07691591f, 0.06800664f, -0.08836690f, -0.11462884f, -0.02004867f, -0.03080061f, 0.07607768f, 
    -0.19578639f, 0.27309453f, 0.13965920f, 0.28304601f, -0.07519454f, -0.10294340f, 0.09373510f, 0.05635387f, 
    0.02705606f, -0.12993167f, 0.08809515f, 0.13993815f, -0.11482363f, 0.25831965f, 0.06227097f, 0.21287443f, 
    0.08896866f, 0.00778260f, -0.14461599f, 0.09775361f, -0.03205096f, 0.12942691f, 0.11154579f, 0.04158903f, 
    -0.02877919f, 0.18648726f, 0.07802793f, -0.01201533f, -0.00725233f, 0.04407339f, 0.03151596f, 0.10709908f, 
    0.01724082f, 0.05462434f, 0.13796836f, 0.03897828f, 0.05547534f, -0.09516089f, 0.02446384f, 0.07225841f, 
    -0.03261075f, -0.17017192f, -0.05269419f, -0.01716851f, -0.15776537f, 0.10307797f, -0.10016935f, -0.19442934f, 
    -0.18690373f, -0.33071122f, 0.12247518f, 0.13512690f, -0.06927324f, 0.12859423f, -0.18982846f, 0.12780112f, 
    -0.04872573f, -0.01357339f, 0.05186243f, -0.05770900f, 0.16408359f, -0.12964348f, 0.11030142f, -0.01858991f, 
    -0.21099693f, 0.02415706f, 0.12503266f, 0.11490062f, 0.04833998f, -0.00619884f, 0.08147964f, -0.02485992f, 
    -0.04346474f, 0.04728910f, -0.12099777f, 0.05160661f, 0.04617482f, 0.14198634f, 0.07057916f, -0.03406834f, 
    -0.10732094f, 0.09954504f, -0.21393102f, -0.19500174f, -0.27096334f, 0.20971955f, 0.17504853f, 0.24370663f, 
    -0.00284272f, -0.04258598f, -0.26632866f, 0.24824524f, 0.14283469f, 0.02998964f, 0.18644819f, 0.00331040f, 
    -0.16071485f, -0.08345824f, -0.50655127f, 0.06276631f, -0.06460435f, 0.03964391f, -0.00115642f, -0.06030877f, 
    0.12157939f, 0.12525244f, -0.05632155f, -0.02884605f, -0.07351967f, 0.26083824f, 0.08887448f, 0.07840716f, 
    0.04878237f, -0.07146680f, -0.02819000f, 0.04078989f, 0.10936425f, -0.01543578f, 0.02516884f, 0.13961945f, 
    -0.12092677f, 0.12431865f, -0.23173654f, -0.07491793f, -0.18505138f, -0.08245404f, -0.08775446f, -0.11582769f, 
    -0.15729885f, -0.05361663f, -0.17360388f, -0.15951824f, -0.08300334f, -0.51903009f, 0.06458747f, -0.05837342f, 
    -0.11260285f, 0.04680168f, 0.19285953f, -0.11431658f, -0.07736484f, 0.02751178f, 0.01944259f, 0.00645212f, 
    0.04102081f, -0.07029483f, -0.09769925f, 0.09490059f, -0.15086330f, 0.08884852f, 0.06626453f, 0.03074672f, 
    0.05020240f, 0.11174794f, -0.05605777f, 0.11676604f, -0.15469068f, 0.10842805f, 0.05934505f, -0.15300618f, 
    -0.05445714f, -0.02230697f, 0.02024499f, 0.01429416f, -0.08856888f, 0.13941050f, 0.05773531f, 0.08556782f, 
    -0.04489733f, -0.11764755f, 0.05813598f, 0.00000936f, -0.05749328f, -0.09383001f, -0.04305185f, 0.03646543f, 
    -0.00232518f, -0.06522361f, 0.01439307f, 0.06742133f, -0.07158326f, -0.04509927f, -0.24397309f, 0.08120417f, 
    0.01846919f, -0.10797564f, 0.03431313f, 0.20334704f, 0.00403577f, 0.09313793f, 0.05361542f, -0.06305992f, 
    -0.02682048f, 0.22784841f, -0.37228271f, 0.15961963f, -0.00214377f, -0.09743883f, -0.00187419f, -0.10081244f, 
    0.05247241f, -0.00986038f, 0.01520635f, 0.08210333f, 0.18114418f, 0.11377500f, 0.17075786f, 0.10354613f, 
    -0.06258050f, -0.14715435f, 0.06358520f, -0.07072379f, -0.11768015f, -0.12098594f, -0.04282174f, 0.14581253f, 
    -0.05747949f, 0.02260661f, 0.11310506f, 0.05136836f, -0.17128919f, -0.01922912f, -0.02868479f, 0.14360310f, 
    0.01858590f, 0.11387854f, 0.15214352f, 0.11763785f, -0.13473396f, 0.26457009f, 0.26292893f, -0.19707260f, 
    -0.18398514f, -0.01510741f, -0.09257663f, -0.01267854f, 0.11842582f, 0.08427268f, -0.04559218f, 0.02519514f, 
    0.15580735f, -0.46469554f, -0.05935024f, 0.15111680f, 0.04262858f, -0.08473268f, -0.10971668f, -0.04571259f, 
    -0.08223180f, 0.11673968f, -0.03781614f, -0.25323710f, 0.04918183f, 0.22264352f, 0.20624755f, -0.15386379f, 
    -0.02260745f, -0.02672440f, 0.05578426f, 0.05858775f, -0.08677118f, -0.15003328f, -0.25610656f, -0.20164454f, 
    0.12390629f, -0.13867359f, 0.04180306f, -0.06465960f, -0.06801040f, -0.06730361f, 0.18558517f, 0.13588887f, 
    0.00472311f, 0.02014964f, 0.00008854f, -0.10372756f, -0.49587336f, 0.29223731f, 0.10865510f, 0.02548439f, 
    -0.02553837f, 0.02148710f, 0.35113925f, 0.02289865f, -0.07605551f, 0.03739674f, -0.05527065f, -0.06316568f, 
    -0.15506750f, -0.23705734f, 0.36763284f, -0.23728161f, -0.05364799f, -0.01385068f, 0.13157170f, 0.13202694f, 
    0.13567464f, -0.26289782f, 0.04433441f, 0.18960859f, -0.25969630f, -0.25905716f, 0.19705294f, 0.06795305f, 
    -0.02120549f, 0.02011624f, 0.02696466f, 0.08492771f, -0.09909512f, -0.12493689f, -0.11932087f, -0.01272778f, 
    0.13430226f, -0.08951648f, 0.32314256f, -0.23194778f, -0.11590849f, 0.13002594f, -0.01874956f, 0.00754079f, 
    0.01280773f, 0.09458213f, 0.05097513f, 0.04606887f, -0.06489959f, -0.21012114f, -0.13818105f, -0.02887507f, 
    -0.07465643f, -0.03371651f, 0.05462649f, 0.01754471f, -0.00572755f, 0.05631425f, 0.11746874f, 0.08111922f, 
    0.06288354f, 0.21584146f, 0.07044266f, -0.08472885f, 0.00481978f, -0.19895186f, 0.07795540f, -0.00853041f, 
    -0.06565410f, 0.01175034f, -0.17806408f, -0.30761582f, -0.02882387f, 0.01945106f, -0.11490320f, -0.04962826f, 
    -0.15909694f, -0.12195769f, 0.03363056f, -0.14223900f, -0.05040410f, 0.11572782f, -0.00217427f, 0.06909198f, 
    0.03380252f, 0.38627779f, -0.22717924f, -0.12094780f, 0.06231508f, -0.12198340f, -0.01308117f, 0.10351472f, 
    -0.18104172f, 0.06499533f, -0.34194553f, -0.31384417f, -0.24370861f, 0.05874202f, -0.02069205f, -0.03798462f, 
    0.03759263f, 0.13584431f, -0.08537733f, -0.00350307f, -0.00811771f, -0.05511542f, -0.15654282f, -0.21198982f, 
    0.15697394f, -0.20074029f, 0.35366800f, 0.00851267f, 0.07413998f, 0.06902876f, -0.12364402f, 0.00781116f, 
    -0.00394791f, -0.09708598f, -0.13819881f, -0.06875661f, -0.26031056f, 0.02620269f, -0.02836899f, -0.23913652f, 
    -0.04719163f, 0.11533825f, 0.28648499f, 0.03460102f, -0.01753291f, -0.09252876f, 0.12326197f, 0.13079330f, 
    -0.12021180f, 0.10295577f, 0.06478810f, -0.25901577f, 0.01154801f, 0.01364008f, 0.01497346f, -0.20515560f, 
    -0.05965002f, -0.14853813f, -0.10742109f, -0.37894663f, -0.07975604f, -0.07740647f, 0.01733914f, 0.04203812f, 
    -0.07808017f, -0.06782528f, -0.00036360f, -0.04295504f, 0.09983133f, 0.12086730f, 0.04149597f, 0.06954610f, 
    0.27590334f, -0.35783511f, 0.26343048f, -0.11063988f, -0.11911252f, 0.02055962f, 0.05470659f, 0.08544835f, 
    -0.19150761f, -0.04431374f, -0.20332286f, 0.00271264f, -0.03123332f, -0.05797332f, -0.08581627f, 0.23058106f, 
    -0.10100266f, -0.01446030f, -0.01661228f, 0.13184552f, 0.02562849f, 0.02602109f, 0.12690119f, 0.21063411f, 
    -0.28857899f, -0.03655521f, -0.31418324f, 0.09891761f, 0.00912030f, -0.10757182f, -0.10923608f, 0.08234806f, 
    -0.00473349f, 0.07434019f, -0.03423564f, 0.02708958f, -0.28715888f, -0.05894869f, -0.11645051f, -0.16828962f, 
    -0.02065051f, 0.05888340f, 0.08273157f, 0.00587157f, 0.02595446f, 0.11435044f, 0.08473856f, 0.18001702f, 
    0.16688612f, -0.25120208f, 0.23533936f, 0.22484104f, -0.10211369f, 0.03074621f, 0.06135673f, -0.03353898f, 
    -0.01809706f, 0.19680706f, -0.05380389f, -0.15918535f, -0.18935347f, 0.25265992f, -0.03952168f, -0.14736170f, 
    -0.03150962f, 0.00273418f, 0.00070073f, 0.04078894f, -0.02132512f, -0.11822996f, -0.32750118f, -0.26702693f, 
    -0.22295739f, -0.34047890f, -0.24925326f, -0.20080566f, -0.14105786f, -0.08918488f, -0.15867794f, -0.07694913f, 
    -0.00523148f, 0.06823689f, -0.03053803f, -0.04131069f, 0.02948141f, 0.15780491f, 0.05653023f, -0.21142896f, 
    0.03588190f, -0.04574720f, 0.04140861f, 0.02647419f, -0.09957844f, -0.18770476f, -0.22665542f, -0.27513722f, 
    -0.18677996f, 0.31813627f, 0.20000803f, 0.00129072f, -0.02619277f, 0.08383077f, 0.11859721f, -0.05631224f, 
    -0.02439758f, 0.18690260f, 0.09409259f, 0.10553052f, -0.10184119f, 0.23874155f, 0.07299058f, 0.03797796f, 
    -0.15185913f, -0.00066103f, 0.17973757f, -0.10663109f, 0.11121818f, 0.19739936f, 0.04206103f, 0.09868376f, 
    -0.27809390f, 0.05195814f, -0.11915878f, 0.26073271f, 0.04753233f, 0.11563800f, -0.17849971f, 0.12753154f, 
    -0.13005382f, 0.07191800f, -0.04685085f, 0.07377427f, -0.39603865f, 0.31361160f, -0.13699974f, 0.11447623f, 
    -0.03932312f, 0.01867831f, -0.01043896f, 0.00818767f, -0.17680885f, -0.09417348f, -0.10610194f, -0.02334023f, 
    -0.04523455f, 0.09354862f, 0.04538706f, -0.06685417f, -0.04238852f, 0.02294014f, -0.20143193f, -0.07472884f, 
    -0.00263762f, 0.09419136f, 0.04320484f, -0.19237964f, -0.47695050f, 0.53268224f, 0.39378414f, 0.31465915f, 
    0.00308998f, -0.10297827f, -0.01263076f, -0.06425735f, -0.03553356f, 0.09276426f, 0.18800610f, 0.02789140f, 
    -0.43368891f, 0.20717841f, -0.00188876f, -0.05457598f, 0.06286211f, 0.07420333f, -0.08675638f, 0.14022230f, 
    -0.03126796f, 0.03923840f, 0.12730967f, -0.05938010f, -0.34426674f, 0.07187962f, 0.19406106f, -0.22438942f, 
    -0.01375323f, 0.13195646f, 0.02548563f, 0.04110073f, -0.06053009f, -0.08800494f, 0.02464343f, -0.04706429f, 
    0.05580468f, -0.02359917f, -0.00099985f, 0.14601451f, -0.10514181f, 0.00346010f, -0.01006793f, 0.05444721f, 
    -0.16910310f, 0.08339540f, 0.02990670f, 0.03411158f, -0.36246863f, 0.04938051f, -0.14896353f, 0.12145820f, 
    0.15751296f, 0.10166991f, -0.02004879f, -0.04680957f, -0.13124080f, 0.00848774f, 0.03932153f, -0.09400453f, 
    0.28753224f, -0.04617959f, 0.54423642f, -0.06188350f, 0.01593312f, -0.14466995f, -0.07346568f, 0.05143220f, 
    -0.06614106f, -0.06439917f, -0.01627306f, -0.01916540f, 0.30851358f, 0.01567848f, 0.10901868f, -0.02335487f, 
    0.04574681f, -0.06380307f, -0.00706036f, 0.02292194f, -0.05527993f, 0.06470333f, -0.02562662f, -0.03492806f, 
    -0.43959662f, -0.37750164f, -0.16827722f, -0.12881613f, -0.00325096f, 0.05096661f, -0.05713628f, 0.08554663f, 
    -0.11661374f, 0.16546834f, 0.10450741f, 0.04363553f, 0.26626036f, -0.07918131f, 0.14943142f, 0.02097047f, 
    0.02563562f, 0.00499193f, -0.01583334f, 0.10688139f, 0.00345582f, 0.11289831f, 0.16614631f, 0.08645796f, 
    -0.21190226f, -0.41531047f, 0.05827496f, 0.00876923f, -0.08577373f, -0.11348079f, -0.02415131f, -0.14638680f, 
    0.00619983f, 0.01263074f, -0.06242950f, -0.01689044f, -0.27608132f, 0.16048275f, -0.24541892f, 0.14034888f, 
    0.10071533f, 0.07865968f, 0.17634524f, -0.21530680f, 0.01710100f, 0.02795405f, -0.22170493f, -0.05377257f, 
    -0.00547479f, -0.10194054f, 0.28353578f, -0.17261612f, 0.14892146f, 0.15533237f, 0.03018185f, -0.00631811f, 
    -0.07510030f, -0.09153751f, -0.11728332f, -0.08799870f, -0.21972650f, -0.00627608f, -0.00745486f, -0.03592618f, 
    0.06185721f, 0.03186584f, 0.15021886f, -0.08814193f, -0.20747675f, -0.14317638f, -0.04490351f, -0.00190357f, 
    -0.65894252f, 0.17525372f, -0.24106754f, 0.23172081f, 0.00653236f, 0.03598929f, 0.06692159f, 0.21525107f, 
    -0.34120059f, -0.07027338f, -0.00132242f, 0.09174553f, -0.11266074f, -0.18932076f, 0.22209240f, 0.42045489f, 
    -0.04248384f, 0.05314226f, 0.05048543f, 0.04833054f, -0.08325557f, -0.22522266f, 0.06224132f, -0.01283798f, 
    -0.28675941f, -0.42333937f, 0.24768314f, 0.07233398f, 0.09450935f, -0.05594967f, -0.12297232f, 0.18200758f, 
    -0.07653569f, 0.10137349f, 0.10181484f, -0.26116741f, -0.30214038f, 0.18618117f, -0.08914864f, 0.28221655f, 
    0.00878265f, -0.07186528f, 0.03670157f, 0.05209771f, -0.22930138f, -0.09929178f, -0.07243590f, -0.01482371f, 
    -0.06925680f, -0.05667635f, 0.10755517f, 0.05589430f, -0.09146138f, -0.02218264f, 0.05496337f, 0.10656802f, 
    -0.11841371f, -0.06364115f, -0.13014163f, 0.01251250f, -0.13017325f, 0.10241260f, -0.07036760f, 0.08251920f, 
    -0.02228700f, -0.03802834f, 0.15857981f, -0.07461175f, -0.12593317f, -0.02032440f, 0.10663380f, 0.14865765f, 
    0.17142078f, 0.03804478f, -0.04089561f, 0.02012395f, -0.11009158f, 0.04335506f, -0.04965897f, 0.05357555f, 
    -0.00690365f, 0.06335525f, -0.11968757f, -0.09949586f, 0.18298903f, -0.15389617f, 0.04770320f, -0.18877603f, 
    -0.00505556f, 0.02706489f, -0.03772119f, 0.13250931f, -0.19305447f, -0.11985814f, 0.00617108f, -0.14449055f, 
    0.03858317f, -0.10862549f, -0.03391674f, 0.19440539f, 0.00879812f, -0.02678532f, -0.04709516f, -0.00456944f, 
    -0.02074832f, 0.05252821f, 0.03624557f, 0.05265065f, -0.02143289f, 0.21100624f, 0.21568751f, 0.00333904f, 
    -0.08854408f, -0.11259235f, -0.00755223f, 0.07807077f, -0.02735525f, 0.13885616f, 0.05429768f, -0.11030830f, 
    -0.31427175f, -0.54685497f, 0.01569474f, 0.06942949f, -0.17557496f, -0.03101279f, -0.22977680f, -0.09660274f, 
    -0.01678491f, -0.03651341f, 0.00726615f, 0.02431515f, -0.34262207f, -0.09825504f, -0.14171197f, 0.00736496f, 
    0.24324368f, 0.01522681f, -0.00300861f, -0.08585748f, -0.02727646f, 0.08367252f, 0.06053309f, 0.11967153f, 
    0.26132274f, 0.10464676f, 0.07735027f, -0.00689261f, -0.01624960f, -0.02621779f, -0.03961673f, 0.10582720f, 
    -0.00695906f, 0.06394897f, 0.05779080f, -0.04458921f, 0.28689975f, -0.09677640f, 0.47199723f, -0.21007124f, 
    0.02800808f, 0.15949149f, -0.21865335f, 0.03793600f, -0.14368424f, 0.07032642f, 0.08719405f, 0.05630727f, 
    0.03563127f, -0.04971524f, 0.09470221f, -0.34848115f, -0.22166668f, -0.02518863f, -0.23028815f, -0.16637161f, 
    0.02740050f, -0.00566894f, -0.04051887f, -0.14278498f, 0.34511894f, -0.13999549f, 0.44542938f, -0.11531323f, 
    0.06630711f, 0.02162986f, 0.06882179f, 0.00530727f, -0.07912752f, 0.04769999f, 0.00829675f, -0.00912001f, 
    0.06867361f, 0.12241259f, 0.16444486f, -0.02863435f, 0.00366940f, -0.00130706f, -0.07375369f, 0.07832475f, 
    -0.07064462f, 0.10207497f, 0.08920550f, 0.01583022f, -0.46226352f, -0.24792276f, 0.02176360f, 0.00471889f, 
    -0.23683652f, 0.00342329f, -0.09396362f, -0.11474238f, -0.08372744f, 0.04947116f, 0.15420048f, 0.06258065f, 
    0.07260243f, 0.03845665f, 0.17142117f, 0.15335467f, -0.03700792f, 0.01047450f, -0.10161524f, 0.04029867f, 
    -0.08074555f, -0.02592209f, -0.02543624f, -0.04963255f, -0.41559568f, 0.30340207f, -0.23846903f, 0.01046330f, 
    -0.01578810f, -0.01784942f, 0.11376975f, -0.09241705f, -0.08984716f, 0.07698359f, 0.07709520f, -0.13011137f, 
    -0.02795537f, -0.13385989f, 0.17189653f, -0.13993679f, 0.01468496f, 0.01535288f, -0.24493557f, 0.03731278f, 
    -0.01508223f, -0.05611666f, -0.14712736f, -0.15694787f, -0.00356796f, -0.09497884f, 0.14316083f, -0.21181448f, 
    0.11292954f, 0.16448675f, -0.09053664f, 0.03318655f, -0.13848978f, -0.02445511f, -0.07352067f, -0.09821356f, 
    -0.02116462f, 0.09011994f, -0.15257968f, -0.44985789f, -0.04951958f, 0.00246352f, 0.17249160f, -0.08165354f, 
    -0.01357580f, 0.03247821f, 0.14458051f, -0.04216906f, 0.06461439f, -0.46863377f, 0.20893924f, -0.23722254f, 
    0.12786178f, -0.01689163f, -0.04561160f, 0.15613598f, -0.06228612f, 0.11449124f, 0.14619336f, 0.15077457f, 
    -0.18714724f, 0.16372976f, 0.09742165f, -0.19828227f, -0.12320068f, -0.09495565f, -0.00430029f, 0.01460082f, 
    0.03910877f, -0.03112777f, -0.04278688f, -0.00083372f, 0.03488949f, 0.23221144f, 0.07187396f, 0.23349111f, 
    0.01088454f, -0.02865364f, 0.04643448f, -0.15689340f, -0.04121545f, 0.05367967f, 0.04156759f, 0.09169658f, 
    -0.16409267f, 0.07759124f, 0.04555506f, -0.21233776f, -0.05841345f, 0.14172658f, -0.11260673f, -0.00831308f, 
    -0.11169077f, -0.03929158f, 0.21188708f, -0.06954402f, -0.01699449f, -0.01808028f, 0.18315740f, -0.12350123f, 
    0.04368088f, -0.02592832f, 0.18553261f, 0.05179933f, -0.01951155f, 0.04047025f, 0.17399757f, 0.08339492f, 
    -0.18688640f, -0.02919587f, -0.21051906f, 0.00425456f, 0.08284248f, -0.04333272f, -0.01040681f, 0.01401793f, 
    0.09455240f, 0.01908152f, -0.01744038f, -0.02218311f, 0.23788154f, 0.17559473f, 0.19410257f, -0.06115462f, 
    -0.02200912f, 0.07209025f, -0.03087928f, -0.00396116f, -0.10421538f, 0.06779730f, -0.02630979f, -0.03147915f, 
    -0.23098910f, -0.06002519f, -0.04530595f, 0.15823565f, -0.03290194f, 0.08765006f, 0.02898326f, 0.03735146f, 
    -0.09595431f, -0.00727170f, 0.08200809f, 0.00283113f, 0.13653561f, 0.20825671f, 0.04560032f, 0.04032688f, 
    -0.00500555f, 0.10269313f, -0.07467814f, -0.01796576f, -0.00748895f, 0.03322805f, -0.09190366f, 0.00706397f, 
    -0.22936291f, -0.08855581f, 0.18152061f, 0.03290228f, 0.00067103f, -0.21550600f, 0.07731687f, -0.15386789f, 
    0.03337775f, -0.08473156f, 0.02316115f, -0.01181338f, -0.23113132f, -0.43194038f, -0.25823638f, 0.11281771f, 
    -0.08124726f, -0.01682165f, 0.02047761f, -0.03628321f, -0.09640434f, 0.05336685f, 0.03116094f, -0.00941029f, 
    -0.16648977f, -0.21296348f, 0.06381387f, -0.01364122f, 0.02757707f, -0.00440676f, 0.07753053f, -0.12341329f, 
    0.12685567f, 0.04609833f, 0.04470360f, -0.00408776f, -0.13301672f, 0.10236628f, 0.00224295f, -0.01563050f, 
    0.11757101f, -0.12109420f, 0.05173173f, -0.04154022f, 0.06430874f, 0.09921069f, -0.03441551f, -0.09605224f, 
    0.01265492f, -0.05538081f, -0.25630680f, 0.05240909f, 0.10448481f, 0.10420354f, 0.09426691f, -0.07999307f, 
    -0.04812393f, 0.11072221f, 0.25276875f, 0.14839740f, -0.08233519f, 0.17387237f, -0.15491861f, -0.03073119f, 
    0.05832006f, 0.16734016f, 0.02469942f, -0.03720688f, 0.04011910f, 0.08253531f, -0.06762663f, 0.00533663f, 
    0.06124704f, 0.21847822f, -0.01825598f, -0.09834668f, -0.02712658f, 0.05700313f, 0.07355800f, 0.08890948f, 
    -0.04975874f, 0.10651487f, 0.16842912f, 0.01935745f, 0.20640562f, 0.13280480f, 0.25568977f, -0.10759497f, 
    -0.08194264f, 0.01950808f, -0.05773368f, 0.17334908f, -0.06452310f, 0.07239120f, -0.14771187f, -0.06198312f, 
    -0.01116186f, -0.39072078f, 0.08824982f, -0.01636227f, -0.12065867f, -0.10745461f, -0.19200899f, -0.12996396f, 
    0.04396939f, -0.00383150f, -0.01699985f, -0.04164723f, 0.12665029f, 0.17263232f, -0.02419735f, -0.03828269f, 
    -0.05518387f, 0.00727649f, -0.00933559f, 0.08635315f, -0.14089304f, -0.06647962f, -0.09763033f, -0.08274990f, 
    0.04197534f, -0.03194717f, 0.46109247f, -0.50318879f, 0.05632064f, 0.03004956f, -0.05441087f, 0.04922320f, 
    -0.03347087f, -0.03058824f, -0.02291014f, 0.07244506f, 0.12471338f, 0.12189654f, -0.12454316f, 0.06941295f, 
    0.08878437f, -0.03902499f, 0.10305906f, 0.13520691f, 0.07376559f, 0.19312307f, 0.01401811f, 0.06870119f, 
    0.18714657f, 0.19053194f, 0.02892759f, -0.11228991f, -0.06942056f, -0.00066583f, 0.01155712f, 0.06797016f, 
    -0.03748442f, -0.02980886f, 0.00769016f, -0.02923092f, -0.00901105f, -0.06818253f, -0.01798351f, -0.07054226f, 
    0.03781138f, -0.01883737f, -0.01756562f, -0.03952230f, 0.00715617f, 0.05626635f, 0.00131722f, -0.01307809f, 
    0.33373642f, -0.11970919f, 0.26879686f, -0.08174636f, 0.02012043f, 0.06840980f, -0.12984055f, 0.17825690f, 
    -0.03471393f, 0.04735757f, 0.03424672f, -0.02181414f, 0.24961461f, -0.22000922f, 0.10871590f, 0.27829525f, 
    0.16461523f, -0.00691033f, -0.10230742f, 0.08068667f, 0.08633123f, 0.13457441f, -0.06681327f, 0.06393651f, 
    0.08655039f, -0.15233944f, 0.28224614f, -0.00716770f, -0.21344931f, 0.11601356f, -0.21711501f, 0.17317463f, 
    0.01307219f, -0.06149722f, 0.07622796f, 0.04445552f, -0.33230802f, -0.12707348f, -0.16849850f, 0.21068653f, 
    0.09639642f, -0.15996709f, 0.17467622f, -0.18494116f, 0.03762693f, 0.05992555f, 0.16694169f, 0.07494371f, 
    -0.24473429f, -0.17037259f, -0.10836485f, -0.13020003f, 0.06073936f, -0.11020247f, -0.01232405f, 0.01259967f, 
    -0.07888889f, -0.01258907f, -0.12464888f, -0.07157815f, 0.10001222f, -0.33125931f, -0.08224874f, 0.61292773f, 
    -0.04261005f, 0.11981822f, -0.22059184f, 0.12155394f, -0.11685015f, -0.09655806f, -0.02844447f, 0.06602295f, 
    -0.08361822f, 0.23338637f, -0.18811494f, 0.21475889f, 0.08275498f, -0.16764773f, 0.15896815f, 0.21037957f, 
    -0.01894499f, 0.00636411f, -0.09815085f, 0.01055010f, -0.18403733f, -0.21212916f, -0.31546411f, -0.06802828f, 
    0.18054268f, -0.00558147f, 0.02327522f, -0.00554289f, 0.06245537f, 0.01712009f, 0.12104908f, -0.10265461f, 
    0.26419562f, 0.10829395f, -0.03046854f, 0.05257514f, -0.12583710f, 0.12865092f, -0.14124624f, 0.15557395f, 
    0.09810938f, -0.11485846f, -0.04441955f, -0.14248784f, -0.47378632f, -0.03823986f, -0.30684412f, 0.23003149f, 
    0.13563041f, 0.01793609f, 0.10731228f, -0.01524805f, -0.15333340f, 0.00594952f, 0.17691071f, 0.00483321f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10116634f, 0.08223861f, 0.10481894f, -0.09440991f, -0.06030487f, 0.07098015f, -0.00621239f, -0.15593547f, 
    0.06073943f, 0.03484483f, 0.04018977f, -0.03044967f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
