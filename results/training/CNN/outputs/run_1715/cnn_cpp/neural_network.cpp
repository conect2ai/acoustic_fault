#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.32427114f, -0.93316078f, -0.75202447f, -0.28461733f, -0.63690871f, 0.79256696f, 0.76716501f, -0.14145103f, 
    0.36974970f, -0.14115801f, 0.13434067f, 0.06052291f, 0.25588796f, -0.07065438f, 0.06671153f, -0.19736253f, 
    0.05428072f, -0.05775319f, -0.22443458f, 0.01948299f, -0.08114005f, -0.00763518f, -0.13741496f, 0.31368548f, 
    0.00979151f, 0.71948093f, 0.36116856f, 0.24657215f, 0.32858831f, -0.49744162f, -0.22915810f, -0.05926028f, 
    -0.23123379f, -0.37069643f, -0.18410791f, 0.20154388f, 0.03602570f, -0.08725785f, -0.18508987f, 0.31810603f, 
    -0.08307305f, -0.00312811f, -0.13430306f, -0.14197400f, 0.17429018f, -0.02144583f, -0.23742554f, 0.06205874f, 
    0.27358612f, 0.12120121f, -0.32343504f, -0.02446969f, -0.14225660f, -0.15350921f, 0.28760761f, 0.41931981f, 
    -0.41725120f, -0.23632312f, 0.40869367f, 0.27868783f, -0.14791635f, 0.25116244f, -0.11557826f, -0.27125615f, 
    -0.01799533f, -0.33927363f, -0.09503768f, 0.25447363f, 0.12682337f, -0.13711500f, -0.12753446f, 0.19813569f, 
    0.12232890f, 0.20913044f, 0.02490322f, 0.12726080f, -0.08671550f, -0.32047784f, 0.42156497f, 0.04617938f, 
    -0.62887001f, -0.10032628f, -0.03910922f, 0.61706132f, 0.09283198f, -0.24333470f, -0.39637521f, -0.32495376f, 
    0.29818070f, 0.02309980f, -0.31044486f, -0.31061721f, 0.11967689f, -0.24835204f, -0.51585835f, -0.32701814f, 
    -0.01881896f, 0.11800934f, -0.25657010f, -0.29511204f, 0.15627715f, 0.59347063f, -0.26164323f, -0.73549759f, 
    -0.40391850f, 0.15406951f, -0.04866105f, 0.15787898f, 0.21684726f, 0.15833442f, 0.24952199f, -0.40172106f, 
    0.59443653f, -0.56132084f, -0.37885901f, 0.05949248f, -0.12631877f, -0.16780822f, 0.00494790f, 0.30313599f, 
    -0.05634334f, -0.09156545f, -0.09562663f, 0.06261139f, 0.37750667f, -0.79594398f, -0.03999921f, 0.45367074f, 
    0.48069519f, -0.18449488f, -0.70673299f, -0.65623730f, -0.02784625f, 0.68346119f, 0.55929196f, 0.02299847f, 
    -0.11274200f, -0.07010794f, 0.47267666f, 0.01624026f, -0.14025967f, -0.11713471f, 0.09318946f, 0.09587403f, 
    -0.35394907f, 0.08430477f, 0.18391332f, 0.06300574f, -0.06584112f, -0.00136313f, 0.25119451f, 0.23808500f, 
    -0.41293296f, -0.50443673f, -0.26551175f, 0.22050969f, 0.03546334f, 0.32542533f, 0.42283428f, 0.15700713f, 
    -0.22221674f, -0.03809591f, -0.37653682f, -0.25134125f, -0.12540053f, 0.28984705f, -0.20875138f, -0.08404864f, 
    -0.10545319f, -0.14417496f, -0.42563415f, -0.03163449f, -0.11987191f, -0.35384279f, -0.57736963f, 0.70715207f, 
    -0.57807589f, -0.31627238f, -0.42020881f, -0.54008710f, 0.48300079f, -0.02677143f, -0.11137678f, 0.01120318f, 
    0.38056365f, 0.29146743f, -0.16073552f, -0.02781915f, 0.09312808f, 0.17421331f, 0.07174665f, -0.26665512f, 
    -0.22356844f, -0.19537804f, -0.34080166f, 0.15196848f, -0.22500376f, 0.02590957f, 0.32796723f, 0.31738508f, 
    -0.41527978f, -0.83928323f, -0.08366978f, 0.90672100f, 0.68664038f, -0.40850246f, -0.46421635f, -0.36873269f, 
    -0.30548072f, 0.29721716f, -0.07127723f, -0.23287648f, 0.03425444f, 0.21258640f, 0.35138780f, -0.20863411f, 
    -0.32766885f, 0.02103747f, 0.06347819f, 0.19304746f, -0.04535403f, -0.13048370f, -0.00002522f, 0.14153385f, 
    -0.39627594f, 0.91843772f, 0.28061071f, 0.29439196f, -0.04005627f, -0.29380527f, -0.00515075f, 0.40118119f, 
    -0.25056499f, -0.44254622f, -0.54298508f, -0.22931121f, 0.06540339f, -0.04820033f, -0.02751667f, -0.10588829f, 
    0.16955842f, -0.22317959f, 0.02776252f, 0.24326329f, 0.00763282f, -0.14638905f, -0.02142306f, -0.21323788f, 
    0.01367388f, 0.11719561f, -0.93376464f, -0.48014966f, -0.36556983f, -0.37800136f, 0.04036822f, 0.61731625f, 
    0.26032752f, -0.25004873f, 0.46863765f, 0.29808661f, 0.22915341f, 0.03971747f, -0.15856011f, 0.18860792f, 
    -0.38995093f, -0.30837008f, 0.16656803f, -0.24295796f, -0.38599727f, 0.16318186f, -0.11276977f, 0.16044927f, 
    0.20246947f, 0.23799093f, 0.05389303f, 0.28720462f, 0.34750047f, -0.06537523f, -0.04411455f, -0.42026833f, 
    -0.10579479f, 0.42188171f, -0.17223191f, 0.13755836f, -0.10661262f, 0.02294569f, -0.11231967f, 0.00180726f, 
    -0.12447625f, 0.29625776f, 0.16155328f, -0.09480853f, -0.12692925f, -0.21871126f, 0.15559715f, 0.01217717f, 
    0.04004429f, 0.10524225f, -0.26421610f, 0.18356204f, 0.63856190f, 0.12693393f, 0.00351363f, -0.09808238f, 
    -0.09325334f, 0.12059188f, -0.16373792f, 0.41196859f, -0.41791415f, -0.19730534f, -0.24983518f, 0.21855302f, 
    -0.06760608f, -0.20711954f, 0.18307671f, 0.00942423f, 0.10097951f, -0.00513296f, 0.00058067f, -0.24726988f, 
    0.09089392f, 0.04403381f, 0.00898758f, -0.17726392f, -0.31198478f, 0.06768685f, -0.85273325f, -0.79690671f, 
    -0.22651453f, -0.81376922f, -0.09184319f, -0.18800661f, -0.12887193f, 0.18276480f, 0.67177039f, -0.18415335f, 
    -0.08617615f, -0.48070145f, -0.23679030f, 0.12462803f, 0.18182252f, 0.01953310f, -0.03715705f, 0.12937672f, 
    0.03799635f, -0.17881322f, -0.25204515f, -0.35760358f, -0.03814729f, -0.31572273f, -0.11429536f, -0.05931401f, 
    0.18092087f, 0.39870366f, -0.06077131f, 0.42233750f, -0.36735034f, -0.12167869f, -0.31743178f, 0.29113880f, 
    -0.30187055f, -0.11739001f, -0.08577681f, 0.17269565f, 0.27294531f, 0.11376214f, -0.19022433f, 0.15569967f, 
    0.00186223f, -0.35421708f, -0.25125358f, -0.23487297f, -0.13818774f, 0.03691314f, 0.21995020f, 0.67194945f, 
    0.18965621f, -0.53479522f, -0.51346892f, 0.50060451f, -0.13556875f, -0.17447065f, 0.02720856f, 0.24288291f, 
    -0.09706776f, -0.34499684f, 0.31779283f, 0.10742048f, -0.42610541f, -0.06057696f, 0.14660230f, 0.21228936f, 
    0.09493472f, -0.36656469f, -0.01258000f, -0.19719657f, 0.15118854f, 0.12162286f, 0.28898323f, -0.33548826f, 
    0.55644733f, -0.60907185f, -0.10942697f, 0.10535901f, 0.51474714f, -0.20807438f, 0.45219472f, -0.09079564f, 
    -0.32627916f, -0.58825713f, -0.10417386f, -0.09928748f, 0.55512804f, -0.39159206f, 0.03426236f, 0.25081599f, 
    0.21519831f, 0.02095359f, 0.18442339f, -0.12902433f, -0.18261230f, -0.28221926f, -0.15946645f, -0.00308041f, 
    0.02186484f, 0.00812308f, -0.59662664f, -0.24386397f, 0.20454751f, 0.36123765f, -0.40643758f, 0.23139732f, 
    0.30436254f, 0.18696187f, 0.15700288f, -0.29646260f, 0.36477450f, 0.06944349f, 0.01734003f, -0.26512006f, 
    0.21792556f, 0.06350830f, -0.12484040f, -0.40562806f, 0.05683032f, -0.16418441f, 0.09897234f, 0.00497093f, 
    0.08801966f, 0.09541861f, 0.70157796f, 0.42853484f, 0.00639473f, -0.71746290f, -0.88446683f, 0.14142744f, 
    0.28050488f, -0.00237259f, 0.07378471f, -0.16518535f, -0.01029936f, 0.05522795f, -0.08146655f, -0.10435987f, 
    0.04769304f, 0.15542360f, -0.24026775f, 0.00348088f, 0.05148255f, -0.14685524f, -0.11929508f, 0.19391774f, 
    -0.05620828f, -0.24548094f, 0.40348196f, -0.38574338f, 0.58250135f, 0.09772552f, -0.22733466f, 0.24352881f, 
    -0.33778259f, -0.52103329f, -0.31400314f, 0.40764138f, 0.25798631f, 0.02392165f, 0.06200594f, -0.20013605f, 
    -0.22666617f, 0.17163078f, -0.28277138f, 0.16131614f, -0.00736390f, -0.06636195f, -0.08473887f, -0.34180486f, 
    -0.52729660f, -0.30688661f, -0.62746751f, -0.62928247f, 0.01315765f, -0.32661608f, -0.69656843f, -0.62597215f, 
    -0.40658972f, 0.64057809f, 0.12739590f, 0.45162448f, 0.10524496f, 0.12775935f, -0.03436064f, 0.15591906f, 
    0.06519391f, -0.01380436f, -0.22551687f, 0.00757096f, -0.09428398f, 0.31995913f, 0.04645019f, -0.04475405f, 
    -0.09815777f, 0.01444874f, -0.09784337f, -0.11789147f, -0.01846849f, -0.53029275f, -0.09997170f, -0.74833804f, 
    -0.62367952f, -0.55456758f, -0.21974126f, -0.26575544f, 0.04844783f, -0.50921571f, -0.48029718f, 0.10149908f, 
    -0.08652288f, -0.03188071f, -0.04156086f, 0.29246360f, 0.09562940f, -0.06702618f, 0.07203981f, 0.08570508f, 
    0.00371101f, -0.08394253f, 0.12271316f, 0.30627295f, 0.10005812f, -0.01837366f, -0.32991421f, -0.51181895f, 
    0.02587705f, 0.78950453f, -0.10407845f, 0.22403924f, -0.34600866f, -0.54760599f, -0.26811606f, -0.22120598f, 
    -0.00692553f, 0.43531784f, -0.31487706f, -0.13382080f, 0.13831465f, -0.03476101f, 0.16970901f, -0.27620202f, 
    0.07577495f, -0.25515386f, 0.12735122f, -0.07982925f, -0.09938407f, 0.22004779f, 0.21015622f, -0.53414786f, 
    -0.57303578f, -0.14168410f, -0.27502006f, 0.02241106f, -0.65822172f, -0.50820470f, 0.01539886f, -0.02125431f, 
    -0.17314987f, -0.30976802f, -0.04869436f, -0.55416441f, -0.17136036f, 0.48281470f, -0.15932989f, -0.26516265f, 
    -0.04387689f, -0.49040177f, -0.17696500f, -0.18512018f, 0.06567325f, -0.29180869f, -0.42033178f, -0.46692917f, 
    0.27287388f, 0.46368796f, 0.36859277f, 0.35957766f, 0.38708618f, 0.02750545f, -0.00553347f, 0.04421534f, 
    0.39161637f, 0.03392863f, 0.06629042f, -0.10542683f, 0.06453897f, 0.23056780f, 0.08491787f, -0.08941355f, 
    0.03388139f, -0.04053096f, -0.14147584f, -0.17509048f, 0.09038332f, 0.07651781f, -0.15444882f, 0.25465199f, 
    -0.19290836f, 0.42262048f, 0.05298638f, -0.76008075f, -0.59898537f, 0.42928931f, -0.27110341f, 0.35803717f, 
    0.60328323f, 0.11708494f, -0.25247276f, -0.32787016f, -0.02821019f, 0.14702474f, -0.13532859f, -0.32144067f, 
    0.15621136f, 0.19008707f, 0.05961401f, -0.05129836f, 0.13387892f, 0.01775359f, -0.23683678f, -0.22426179f, 
    0.54320455f, -0.15660460f, -0.47815058f, -0.03261873f, 0.17744841f, -0.66766655f, -0.32565394f, 0.19063096f, 
    -0.55006206f, -0.65393049f, -0.49333373f, 0.15561235f, -0.05320225f, 0.17859602f, -0.16686721f, -0.09635802f, 
    -0.11863627f, -0.36986843f, -0.55731428f, -0.34882253f, -0.43634376f, -0.53028178f, -0.01242975f, -0.07167759f, 
    -0.32010227f, -0.14495596f, 0.18577673f, -0.22762799f, -0.43223789f, -0.51488298f, -0.30846947f, 0.39824560f, 
    -0.15019538f, 0.20065017f, 0.00603696f, 0.26530358f, 0.34348226f, 0.17219380f, -0.03008091f, -0.18474911f, 
    0.08375704f, 0.09332017f, -0.12124524f, -0.18321098f, -0.01626884f, -0.03545373f, 0.06766403f, 0.04676801f, 
    -0.21731910f, -0.04646108f, 0.20650412f, -0.03735456f, -1.10846353f, 0.57295316f, -0.23175724f, 0.02694009f, 
    0.50013489f, -0.27102882f, 0.40419886f, 0.18702795f, -0.06549925f, -0.18865143f, 0.16340052f, -0.27135760f, 
    0.29565924f, -0.31512091f, -0.20558538f, 0.24287370f, -0.22997299f, 0.28241110f, -0.39034367f, 0.09946468f, 
    -0.06514178f, 0.10588787f, -0.08674183f, -0.06566928f, 0.31723195f, 0.65538758f, 0.57214344f, 0.30658582f, 
    -0.62519997f, -0.57278192f, 0.09325919f, 0.05809171f, 0.02767949f, -0.09903598f, -0.17693253f, 0.26668462f, 
    -0.10859112f, -0.21025757f, 0.37363091f, -0.22880879f, -0.30591467f, 0.00301659f, 0.16792233f, 0.20296055f, 
    -0.04937454f, 0.08780995f, 0.05635610f, -0.17680798f, -0.17663422f, -0.09529838f, -0.99268794f, -0.40972635f, 
    -0.53560299f, -0.78923404f, -0.61454028f, 0.40797421f, 0.47785947f, -0.21266775f, 0.17087640f, 0.54150170f, 
    -0.25662699f, -0.26700139f, -0.44515502f, -0.25967893f, -0.05045471f, -0.21714227f, 0.09684016f, -0.33961385f, 
    -0.01374016f, -0.09360705f, 0.01167403f, 0.04093305f, 0.04821505f, 0.25935578f, -0.27278692f, -1.07650781f, 
    -0.83132559f, 0.44686657f, 0.43332672f, 0.31723860f, 0.72842461f, 0.00514703f, -0.09996871f, 0.03233010f, 
    0.37897286f, 0.14994688f, -0.15000531f, 0.24052279f, 0.05589265f, -0.41777262f, -0.04909452f, -0.03865991f, 
    -0.12065303f, 0.06560253f, -0.02710855f, -0.14864649f, 0.19882989f, -0.07922535f, 0.01429986f, -0.10959449f, 
    -0.33146319f, -0.40984839f, -0.42072389f, -0.06085387f, 0.02325304f, -0.49170449f, -0.36427641f, -0.47142071f, 
    -0.31228200f, -0.79463446f, 0.29335970f, 0.33125103f, 0.22238064f, -0.13391732f, 0.14645194f, 0.16433294f, 
    -0.17499110f, -0.12634198f, -0.04761067f, -0.14605248f, -0.03075318f, 0.14373443f, 0.00900296f, 0.09573594f, 
    0.21572380f, 0.49723279f, -0.63892466f, 0.26949453f, -0.01928988f, 0.00809147f, 0.64351130f, 0.68929875f, 
    -0.24131900f, -0.65470427f, -0.14183281f, -0.26244721f, -0.18364401f, 0.01436154f, -0.25704712f, 0.22677317f, 
    -0.30643889f, 0.07771093f, 0.02198246f, -0.16393919f, 0.00216195f, 0.06304245f, -0.32160223f, 0.26565322f, 
    -0.09032600f, 0.05910705f, -0.64272791f, -0.38014838f, 0.27679700f, -0.34396717f, -0.08502191f, -0.15660930f, 
    0.08542272f, 0.15452012f, 0.25436112f, 0.37794113f, 0.12795077f, 0.18592654f, 0.00325798f, -0.20275500f, 
    -0.03792740f, -0.25728810f, -0.12867676f, -0.09541816f, -0.02894217f, -0.35534674f, -0.03439903f, 0.37163460f, 
    0.40346327f, 0.39463696f, 0.09019645f, 0.09099873f, 0.47034198f, 0.04681409f, -0.32719201f, -0.69591218f, 
    -0.81562859f, -0.37931922f, -0.33368635f, -0.60855746f, -0.67865199f, 0.18489064f, -0.13798913f, -0.06664104f, 
    -0.23665474f, 0.08182026f, 0.05094923f, 0.22496565f, -0.08338416f, -0.00685650f, -0.25377715f, -0.22942676f, 
    0.05538993f, -0.07394963f, 0.06257813f, -0.35681406f, 0.01159524f, 0.47883117f, 0.12390586f, 0.12260018f, 
    -0.08157246f, -0.64680308f, -0.54331094f, 0.03718203f, -0.10465389f, 0.17571360f, -0.33138266f, -0.35027036f, 
    -0.25364870f, 0.14059661f, 0.54331392f, 0.33008263f, 0.14129573f, 0.25761393f, -0.21323089f, -0.10217763f, 
    -0.15870836f, -0.21520144f, -0.33392885f, -0.14284499f, -0.10011124f, -0.41392288f, -0.37896261f, -0.47398248f, 
    -0.46736747f, -0.53511387f, 0.01731028f, 0.09198394f, 0.48984459f, 0.26458758f, -0.40311500f, -0.18507390f, 
    -0.30129606f, -0.14938056f, -0.00693364f, 0.19608845f, 0.28714466f, 0.24251144f, -0.06178484f, -0.15957211f, 
    0.21483940f, 0.06364016f, -0.03028940f, 0.24892987f, 0.07262097f, 0.01347120f, -0.34886771f, -0.36542249f, 
    0.03156877f, 0.15326573f, -0.52313966f, -0.17216870f, 0.04913291f, 0.23434892f, 0.32560202f, 0.35297242f, 
    -0.21830206f, 0.09443828f, -0.15229680f, 0.12370146f, 0.02567405f, -0.12596212f, -0.25048944f, 0.03656993f, 
    0.01546227f, 0.11174148f, 0.09139643f, -0.04906922f, -0.38039285f, 0.07438162f, 0.54649186f, -0.43141642f, 
    -0.12544179f, -0.28303710f, 0.25173393f, -0.25523600f, -0.19736655f, -0.56130648f, -0.49868459f, 0.01545964f, 
    0.07050336f, -0.15746169f, -0.40542099f, -0.31508061f, -0.15384108f, -0.35641655f, -0.22522362f, -0.23296317f, 
    -0.06813335f, -0.02299015f, -0.10456152f, -0.13137887f, -0.11744085f, 0.05112046f, -0.00604240f, 0.01871970f, 
    -0.18475230f, 0.54810184f, 0.45028266f, -0.60790962f, -0.77624857f, 0.00217709f, 0.38281423f, -0.30909422f, 
    -0.02124043f, -0.09001045f, 0.25683242f, 0.03917103f, 0.16934928f, -0.06093762f, 0.28793222f, 0.33076000f, 
    -0.16856131f, -0.38777205f, -0.23962826f, 0.01286146f, -0.30575383f, 0.08640027f, 0.20897627f, -0.03234813f, 
    0.43883497f, -0.63439298f, 0.02833856f, -0.58348966f, -0.12486508f, -0.70704252f, 0.34987327f, -0.03162764f, 
    -0.58743936f, -0.29298368f, 0.21993111f, 0.04623004f, 0.15818146f, 0.09152009f, -0.16587777f, -0.19434638f, 
    0.15894625f, -0.04671403f, 0.02883059f, -0.01048210f, 0.20736951f, -0.23960419f, -0.20449002f, -0.27227670f, 
    -0.19128777f, -0.08667701f, 0.77753836f, 0.22510754f, -0.17308615f, -0.27386200f, 0.37857446f, -0.31604034f, 
    -0.06820506f, -0.04387735f, -0.37858024f, -0.49288216f, 0.20485750f, 0.21893658f, 0.35138947f, -0.28876442f, 
    0.06577847f, -0.22983126f, -0.00445879f, 0.09756996f, 0.05288932f, 0.15476339f, 0.07411898f, -0.06586161f, 
    -0.05397806f, 0.07780582f, -0.19026519f, 0.10442431f, 0.84530348f, 0.40957069f, -0.68584675f, -0.27148992f, 
    -0.68895936f, -0.53429955f, -0.52963042f, -0.56826729f, -0.73899615f, 0.27627382f, 0.33346739f, -0.24207951f, 
    0.42295143f, 0.02090737f, -0.09629606f, 0.08573495f, 0.06039817f, 0.08798449f, -0.28851387f, -0.01183918f, 
    0.06697538f, 0.08324742f, -0.16942275f, 0.07919765f, -0.38561344f, -0.08240503f, 0.20118244f, 0.23788767f, 
    0.01477544f, -0.04570950f, -0.03668610f, -0.10800990f, -0.34184441f, -0.00341262f, 0.11311978f, 0.02517044f, 
    0.30545732f, -0.25646901f, -0.11784047f, 0.30322257f, 0.18264158f, 0.16116747f, -0.08334143f, -0.32006297f, 
    0.10164930f, -0.04049066f, -0.29825738f, 0.11421683f, 0.25703004f, 0.48210540f, 0.10635911f, -0.60024977f, 
    -0.05442667f, 0.42126137f, 0.23066109f, -0.29335535f, -0.39119312f, -0.32736453f, -0.38832182f, -0.03116235f, 
    0.27629393f, -0.17322116f, -0.20946312f, -0.12450492f, 0.26236472f, 0.36695108f, -0.06450966f, 0.22441222f, 
    0.18131299f, -0.07933625f, 0.23805267f, -0.05387081f, -0.20241058f, -0.23422256f, 0.31154242f, 0.35015926f, 
    -0.10427850f, -0.10077608f, -0.39683259f, -0.26321343f, -0.07504779f, 0.11394486f, -0.15080883f, 0.14527689f, 
    0.22436227f, -0.17811827f, 0.31443098f, 0.00618019f, 0.11670543f, -0.17117609f, 0.06505448f, 0.28872654f, 
    0.30816960f, 0.08876399f, 0.43102902f, 0.33829892f, 0.17216299f, -0.34680855f, -0.36110801f, 0.79323411f, 
    -0.46238193f, -0.34935495f, -0.56453645f, -0.31463015f, 0.07036686f, -0.00044761f, -0.20910347f, 0.26913887f, 
    0.00592632f, 0.47342423f, 0.24629715f, 0.13488932f, 0.07556658f, 0.07825578f, 0.07064349f, 0.18462317f, 
    -0.04646377f, -0.15300331f, -0.37301573f, 0.01705289f, 0.32853904f, 0.00717765f, -0.19386807f, -0.32822657f, 
    -0.20573144f, 0.05007153f, -0.50469667f, -0.66247994f, -0.50857377f, 0.03178590f, -0.17744233f, 0.22151901f, 
    0.34276155f, -0.30353627f, -0.28881720f, -0.21428134f, 0.09615620f, 0.01705182f, 0.20068718f, -0.46622965f, 
    -0.01566898f, -0.36524808f, -0.50758129f, -0.41251564f, -0.06913318f, 0.36026344f, 0.14539438f, 0.17769141f, 
    0.26277456f, 0.54768848f, 0.67513967f, 0.00951666f, 0.08261754f, -0.95739931f, -0.05566246f, -0.43559542f, 
    -0.38837627f, -0.04000223f, 0.18633106f, 0.26394713f, 0.20197266f, 0.02207904f, 0.30625814f, 0.09358792f, 
    -0.43964753f, -0.01273299f, -0.13781643f, 0.11985315f, -0.09774948f, 0.26757142f, -0.07105284f, -0.28434542f, 
    -0.12520705f, 0.11480408f, 0.23261979f, 0.74547714f, 0.27834994f, -0.60185170f, -0.79940736f, -0.14077559f, 
    0.11467303f, 0.64731151f, -0.30213827f, -0.57496291f, -0.23070279f, 0.20160775f, -0.29651266f, -0.38171044f, 
    0.43782058f, 0.24550152f, 0.36368394f, 0.10963549f, -0.09896724f, 0.04198460f, -0.13442896f, -0.25880608f, 
    -0.35497594f, -0.11296246f, 0.36273637f, 0.75994527f, -0.37657425f, 0.03230643f, 0.13197158f, -0.68022186f, 
    0.23796616f, -0.34953085f, 0.11153691f, 0.38720435f, -0.49413893f, 0.18073435f, -0.06119185f, -0.10526386f, 
    0.11094495f, -0.19065098f, -0.19297436f, 0.09388001f, 0.12849708f, -0.17598969f, -0.07034545f, -0.05115275f, 
    0.03377490f, -0.13546811f, -0.32357556f, -0.45200175f, 0.45138052f, 0.29069051f, -0.28044954f, 0.19472380f, 
    0.14678651f, -0.27777830f, -0.23483576f, 0.22033665f, 0.36390188f, -0.37443042f, -0.13607413f, -0.04288656f, 
    -0.11748031f, 0.00165779f, -0.15271322f, 0.00194074f, 0.12907723f, 0.01124701f, 0.12357876f, -0.14883912f, 
    -0.06937149f, 0.04228034f, -0.07993519f, -0.30040529f, -0.15157199f, -0.44473085f, 0.23097204f, -0.01262037f, 
    0.26150224f, 0.50498819f, 0.48884854f, 0.05757409f, -0.24889067f, -0.48207077f, -0.39378250f, -0.38147712f, 
    -0.28424004f, 0.34514195f, -0.48966983f, -0.01606469f, 0.01043837f, -0.19917892f, -0.06772784f, 0.22204955f, 
    0.20660034f, 0.22516243f, 0.15741377f, -0.27399167f, -0.05580497f, -0.30228359f, -1.02796602f, -0.55757463f, 
    0.00633021f, 0.28667057f, 0.26896143f, 0.30655068f, -0.23273049f, -0.24802607f, -0.29912513f, 0.16060545f, 
    -0.62566394f, 0.10408534f, -0.20661753f, 0.37405342f, -0.54517055f, -0.10454098f, 0.04116718f, 0.10115181f, 
    -0.16915455f, 0.03682731f, -0.01620371f, -0.22473687f, -0.08020253f, -0.26994380f, -0.20909822f, -0.89790899f, 
    -0.37362859f, -0.29980394f, 0.43525502f, 0.10637944f, 0.64003497f, 0.10858395f, -0.05215475f, -0.00580009f, 
    0.29053304f, -0.34131745f, 0.29719481f, -0.50807309f, -0.38166270f, -0.07803961f, -0.12899873f, 0.33328170f, 
    0.12274498f, 0.12973191f, -0.02168592f, 0.06240904f, -0.01445909f, 0.01002429f, 0.07580358f, 0.02238169f, 
    0.77260023f, -0.58816677f, -0.23060311f, -0.24185389f, -0.51009238f, 0.44572222f, 0.36423072f, -0.11634870f, 
    -0.35852930f, -0.45994931f, 0.22018424f, 0.32626402f, 0.16485463f, -0.04226350f, -0.18509600f, 0.12941603f, 
    -0.38985974f, -0.19678308f, -0.23562717f, 0.06934369f, -0.21480253f, -0.37167051f, -0.29429302f, 0.06679884f, 
    -0.48511896f, 0.14266863f, -0.06527052f, 0.19538239f, -0.12703285f, 0.05124179f, -0.14708659f, -0.13830252f, 
    0.19804867f, 0.06434776f, -0.13113806f, -0.04145082f, 0.15483098f, -0.06948913f, -0.08297586f, -0.17503533f, 
    0.13868663f, 0.13310936f, -0.18592760f, -0.45044228f, 0.40027168f, -0.05945097f, 0.34998688f, -0.20013463f, 
    -0.24458769f, 0.24119277f, -0.30047819f, -0.06849652f, -0.45529860f, -0.50554377f, -0.51529610f, -0.23580627f, 
    -0.07956664f, 0.35938576f, 0.48395386f, 0.34211820f, 0.19895810f, 0.09370533f, 0.17422520f, 0.03903051f, 
    -0.17463480f, -0.22004393f, 0.01213019f, -0.12781608f, -0.04280106f, 0.21793841f, -0.09089620f, -0.09863048f, 
    -0.22680835f, -0.14013903f, -0.33487087f, 0.08303753f, 0.30520096f, 0.34031460f, -0.04085251f, -0.62919950f, 
    0.70544016f, -0.07290037f, -0.22185154f, 0.03475788f, 0.32672399f, -0.11019352f, -0.20678350f, -0.20430294f, 
    -0.46092558f, -0.15057573f, 0.30616608f, 0.03552723f, 0.00191492f, -0.12220351f, -0.04260214f, -0.26969606f, 
    -0.07418890f, 0.19385326f, -0.11645034f, 0.09129306f, -0.07252907f, 0.59533548f, 0.41364646f, 0.03684769f, 
    0.09027523f, -0.68659073f, -0.25269645f, -0.25037298f, 0.30015486f, -0.09744627f, 0.25201318f, -0.37792635f, 
    0.30895382f, -0.14695905f, -0.38997290f, 0.12386271f, -0.47996715f, 0.05976219f, 0.39520183f, -0.12446389f, 
    -0.11801501f, 0.05587820f, 0.12973848f, -0.08862740f, -0.01944519f, 0.18723153f, 0.19178389f, 0.08031735f, 
    0.03572332f, -0.30131316f, -0.41710514f, 0.07145304f, -0.15604584f, 0.16463415f, 0.31536296f, -0.07002706f, 
    0.05682288f, 0.49969396f, -0.03902677f, -0.33371696f, -0.16442150f, -0.15932612f, 0.37637922f, -0.05308127f, 
    -0.16757278f, -0.20534322f, 0.36424160f, -0.17852291f, -0.15422046f, 0.26368770f, -0.40578458f, -0.54206592f, 
    -0.14902636f, -0.14696485f, 0.55801839f, -0.05337717f, -0.29427105f, -0.68605548f, -0.31778449f, -0.39856476f, 
    -0.00244645f, 0.44191533f, -0.02285295f, 0.61118561f, 0.02262827f, -0.20700254f, -0.30666605f, -0.41034892f, 
    0.35480607f, -0.23943415f, 0.12906916f, -0.26138550f, -0.49527761f, 0.32029471f, 0.12173317f, -0.78238988f, 
    -0.29106930f, -0.70343059f, -0.73398542f, 0.06030677f, 0.42617375f, 0.23351759f, -0.14008015f, 0.11973975f, 
    0.40133628f, 0.45970958f, -0.41231897f, -0.27836916f, -0.25689235f, 0.24034691f, -0.18121387f, -0.01724221f, 
    -0.15028468f, -0.06684253f, -0.49437788f, -0.08745886f, -0.37743279f, 0.09424166f, -0.14281906f, -0.17456190f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30560023f, 0.12008274f, 0.12847576f, -0.16339141f, 0.23934098f, 0.31038916f, -0.03499192f, 0.09473772f, 
    0.27625096f, 0.09294853f, 0.33369631f, -0.11021972f, 0.03108917f, -0.05070027f, 0.02196884f, 0.25864562f, 
    0.11686686f, 0.42667353f, 0.49510959f, -0.26034996f, 0.04112300f, -0.47759610f, 0.13401940f, -0.23355912f, 
    -0.04307731f, 0.08138151f, -0.02974372f, 0.32042700f, 0.19032009f, 0.05850938f, -0.28719705f, 0.11198810f, 
    -0.00086908f, 0.27226248f, 0.02661998f, -0.22711772f, -0.09358709f, -0.31384167f, 0.19998167f, -0.01498392f, 
    0.13965915f, -0.10307490f, -0.11069535f, 0.06867423f, 0.10547847f, -0.02870507f, 0.01823967f, 0.24603845f, 
    -0.22763848f, 0.02827795f, 0.09991293f, 0.11104503f, 0.13047062f, -0.07579042f, -0.01518992f, -0.02027765f, 
    0.01399396f, 0.21845032f, -0.03605653f, 0.29556397f, 0.07104436f, 0.25351152f, 0.13379584f, 0.10578577f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14071921f, -0.07621550f, -0.43314153f, 0.05178959f, 0.09191319f, 0.02969295f, -0.02869792f, -0.16329731f, 
    -0.07917018f, -0.02672277f, -0.08256302f, 0.03262504f, -0.23314239f, -0.39560264f, -0.09322376f, -0.19362974f, 
    -0.10675211f, 0.04980613f, -0.00476809f, -0.05684684f, -0.05003545f, 0.05671665f, 0.05449299f, -0.00326728f, 
    -0.09917308f, 0.08718839f, -0.03828053f, -0.15219937f, -0.14102088f, 0.06575809f, 0.06600142f, 0.04842018f, 
    0.07585445f, -0.01547246f, -0.03495761f, -0.04855813f, 0.10636931f, 0.15374051f, 0.21232834f, -0.04752971f, 
    -0.03367568f, -0.04247547f, 0.00211517f, -0.02445469f, 0.07149644f, -0.04906109f, -0.16472600f, 0.08285284f, 
    -0.25410292f, -0.26620176f, -0.15368193f, -0.13084604f, 0.08417889f, -0.00347883f, 0.05234354f, -0.01340342f, 
    -0.00997305f, -0.16834667f, -0.03121506f, -0.21282974f, -0.19518104f, 0.13523480f, 0.29282299f, -0.31136566f, 
    -0.10759468f, -0.07895729f, 0.04729955f, -0.00199468f, -0.04032617f, -0.30290055f, -0.12777126f, -0.19872430f, 
    -0.42398229f, -0.26466268f, -0.09335998f, 0.02959902f, 0.05266136f, 0.12169877f, 0.02804854f, 0.06340510f, 
    0.03887515f, 0.08949851f, -0.01749006f, 0.03995845f, -0.00902386f, -0.13987301f, -0.27480802f, 0.04586485f, 
    0.02645296f, 0.02463569f, -0.05062458f, -0.20584176f, -0.09904013f, -0.06709483f, -0.18021816f, -0.04499849f, 
    0.31266153f, 0.18399049f, 0.18406764f, -0.37870371f, -0.09392040f, -0.11753759f, -0.08452959f, -0.25002003f, 
    -0.01009894f, -0.08094279f, -0.05674599f, -0.01916462f, -0.50087756f, -0.57953596f, -0.14928988f, -0.03837489f, 
    0.08441553f, 0.01823466f, -0.01251337f, -0.11848182f, -0.03620929f, 0.05000388f, 0.00811007f, 0.01510892f, 
    0.20852815f, 0.04218220f, 0.00791166f, -0.11938950f, 0.04650887f, 0.16718934f, -0.00570393f, -0.03400933f, 
    -0.03608900f, -0.02064428f, -0.03516657f, -0.10417956f, -0.11483750f, 0.02220869f, -0.00054358f, 0.02886503f, 
    -0.04455175f, 0.04429505f, -0.01513065f, -0.01281539f, -0.10743078f, 0.07965872f, -0.20724267f, -0.08824107f, 
    -0.16382952f, -0.18732125f, -0.12904403f, 0.17538050f, 0.05367882f, 0.07894411f, 0.04637954f, -0.00676712f, 
    -0.10213467f, 0.01750976f, 0.06825791f, -0.09360868f, 0.26914087f, 0.15827322f, -0.00570490f, -0.03000783f, 
    0.24387577f, 0.05993795f, -0.00199265f, 0.05298869f, -0.01070331f, 0.09146617f, 0.00474841f, 0.12196899f, 
    -0.28138894f, -0.12445155f, 0.07729935f, -0.09902973f, -0.04377393f, -0.02155076f, 0.02486368f, 0.00338589f, 
    -0.07304838f, -0.14482024f, 0.19393696f, 0.02521164f, -0.23563787f, 0.09542325f, -0.65308756f, 0.26771259f, 
    -0.03955955f, 0.00128230f, -0.00216187f, 0.00933314f, -0.03722522f, -0.08358540f, 0.02870879f, 0.03609688f, 
    0.09248652f, -0.06520180f, -0.07878759f, -0.02838698f, 0.04084310f, -0.18189716f, -0.12626907f, 0.00265495f, 
    -0.12107059f, 0.10049119f, -0.05380926f, 0.01943384f, -0.18307436f, 0.19839595f, -0.05643192f, -0.02297975f, 
    0.00836689f, -0.01844390f, 0.04164521f, -0.01263700f, -0.16312106f, -0.15109879f, -0.14455140f, -0.13687815f, 
    -0.14548944f, -0.83133906f, -0.27709109f, 0.08690407f, -0.00392711f, 0.01308479f, -0.00854608f, -0.08803114f, 
    -0.17074920f, -0.16008918f, -0.25307474f, -0.04998565f, -0.22006714f, 0.17587100f, 0.08964884f, 0.05289867f, 
    0.01639108f, -0.01495944f, 0.01538248f, 0.09291687f, 0.02555914f, -0.03840598f, 0.06935717f, 0.12849703f, 
    0.16195372f, -0.12924789f, -0.15246229f, 0.03345948f, 0.07454176f, 0.15479399f, 0.01890836f, 0.02640825f, 
    0.03328405f, 0.09097393f, 0.03014774f, 0.04530559f, 0.24519351f, 0.14393122f, -0.07268754f, -0.12967229f, 
    0.10703625f, 0.14689186f, -0.02207394f, -0.02625589f, -0.01322511f, 0.01169306f, 0.03432199f, 0.06177108f, 
    0.19143869f, 0.17858613f, 0.03635704f, -0.27296820f, -0.06237842f, -0.12600645f, 0.02754676f, -0.05068656f, 
    -0.00274295f, -0.05974390f, -0.00533222f, -0.12900646f, 0.24756351f, 0.13883586f, 0.14275825f, -0.05176928f, 
    0.05641864f, 0.02058854f, -0.02798985f, -0.03440047f, -0.12337560f, -0.16285317f, -0.14944829f, -0.03562715f, 
    -0.15600285f, -0.11485574f, 0.00917273f, 0.07118400f, 0.09349575f, 0.03390709f, 0.02574682f, 0.05169388f, 
    -0.00698912f, 0.01083451f, 0.00421729f, 0.02435581f, -0.01031348f, 0.03801893f, -0.28912690f, 0.12742664f, 
    -0.06819946f, 0.09186176f, 0.03795586f, -0.02716162f, 0.07152467f, -0.02940106f, 0.01514297f, 0.00529910f, 
    0.20031683f, 0.15294750f, -0.09286191f, -0.16504252f, -0.07189701f, 0.02109944f, -0.11362541f, -0.07346391f, 
    -0.18767445f, -0.14636807f, -0.00405120f, -0.02878297f, -0.10124973f, 0.10464684f, 0.01631580f, 0.03111500f, 
    0.05375455f, 0.06164894f, -0.02673179f, 0.00207234f, -0.07959214f, -0.09718985f, -0.10371499f, -0.03044510f, 
    -0.15761270f, 0.20941347f, 0.25460806f, -0.04948883f, -0.07008190f, -0.08930235f, 0.12201863f, -0.02641520f, 
    -0.10488994f, -0.09005428f, -0.09403533f, -0.14552626f, -0.03848979f, -0.17833737f, -0.23867978f, 0.15400501f, 
    0.06775493f, 0.14700516f, 0.02952063f, -0.14692250f, -0.08639960f, 0.01954999f, -0.07521074f, 0.02499967f, 
    0.17409413f, 0.07456964f, -0.03712868f, -0.00835211f, 0.17142361f, 0.26205543f, 0.06704514f, 0.09783809f, 
    -0.01825415f, 0.01196323f, 0.02331581f, 0.05327316f, 0.43231145f, 0.09974077f, 0.08897024f, -0.08542677f, 
    -0.05692120f, -0.00057541f, 0.01785387f, 0.04707438f, 0.07017146f, 0.00433481f, -0.15402508f, -0.12805599f, 
    0.35530362f, 0.20675294f, -0.22084285f, -0.14544544f, -0.02846306f, -0.08496288f, 0.01881329f, -0.06798748f, 
    0.00039261f, 0.00505134f, 0.01315316f, -0.04258826f, 0.34499213f, -0.25022551f, -0.34470871f, -0.08595975f, 
    -0.01713624f, -0.06756552f, 0.03866541f, 0.00085480f, 0.04396985f, -0.07211582f, 0.06126695f, 0.09579965f, 
    -0.09215835f, -0.10627794f, 0.18900651f, 0.00270257f, 0.05038806f, 0.09906536f, 0.02864263f, -0.02664619f, 
    -0.04695480f, -0.33255216f, -0.13031945f, -0.14507495f, 0.13981721f, 0.09232537f, -0.02758383f, -0.07820914f, 
    -0.02247411f, 0.06747279f, -0.10180592f, 0.07728141f, -0.01143299f, 0.03208288f, 0.05566555f, -0.01039450f, 
    -0.30653697f, 0.23002635f, 0.29497439f, -0.15627652f, -0.13441181f, -0.05343261f, 0.00634601f, 0.09558219f, 
    0.01399656f, 0.04702799f, 0.06089848f, 0.01550805f, 0.22156636f, 0.06687187f, 0.11353323f, 0.02374457f, 
    0.13162588f, 0.18392254f, -0.04622581f, 0.00094699f, -0.04113206f, 0.02310153f, 0.08053190f, 0.02857904f, 
    -0.07583696f, -0.01974605f, 0.15825313f, 0.04411277f, 0.12981445f, -0.02868633f, -0.00833384f, 0.00576353f, 
    -0.12806572f, -0.09562198f, -0.00595318f, -0.15986902f, 0.24816738f, 0.27671522f, 0.09652594f, -0.29971677f, 
    -0.01021090f, -0.05808292f, -0.09999660f, -0.06552866f, -0.07376162f, -0.08512319f, -0.11063667f, -0.10620211f, 
    0.19280988f, -0.16752915f, -0.01656373f, 0.06774284f, -0.09131817f, -0.04377727f, -0.10397587f, -0.20305979f, 
    -0.27692628f, -0.11004964f, -0.00264529f, -0.07764547f, 0.26540473f, 0.20414741f, -0.17614178f, -0.18238191f, 
    -0.02917150f, 0.04829287f, 0.13334706f, -0.13856728f, 0.03511266f, 0.04360596f, 0.00788749f, 0.03759789f, 
    -0.02002233f, 0.04271535f, -0.27458784f, 0.09150295f, -0.17396905f, -0.12796740f, -0.22267520f, -0.08595996f, 
    0.00555580f, 0.07543752f, -0.00280718f, -0.02372358f, 0.19993758f, 0.13229087f, -0.30650297f, -0.05379095f, 
    0.01024637f, -0.02712638f, -0.11013898f, 0.07620621f, -0.00644105f, 0.09887193f, 0.00260719f, -0.02814385f, 
    0.13523853f, 0.07061261f, -0.02979214f, -0.06554569f, -0.13747318f, -0.24748854f, 0.01117103f, 0.15564306f, 
    0.04257632f, -0.11316952f, 0.00404050f, -0.02237005f, 0.03139196f, -0.01355959f, -0.33302820f, 0.17604703f, 
    -0.06250631f, -0.06809477f, 0.16686574f, -0.02739956f, -0.03169011f, 0.09827963f, 0.03168340f, 0.00950785f, 
    -0.00963664f, -0.01243837f, 0.01526239f, 0.02424695f, -0.29274860f, -0.35748309f, 0.15447749f, -0.08908881f, 
    0.04142655f, 0.00727040f, -0.04906924f, -0.01867764f, 0.12909149f, 0.03081781f, -0.22804202f, 0.07160187f, 
    -0.00866929f, 0.02257502f, 0.07133459f, -0.02400120f, -0.19624573f, 0.07169814f, 0.01685426f, 0.00017820f, 
    0.18075722f, -0.06308071f, 0.09277941f, -0.00128927f, 0.08733674f, 0.06853150f, -0.29488507f, -0.27408904f, 
    -0.14377949f, -0.11062815f, -0.03243040f, -0.04468321f, 0.06763551f, -0.30175483f, -0.20481671f, -0.02958638f, 
    -0.11658300f, 0.10313026f, 0.02178533f, 0.00018103f, -0.04705584f, -0.00157791f, -0.02400291f, -0.03281353f, 
    0.02860181f, -0.04419119f, 0.19338143f, -0.01574794f, -0.10723901f, 0.06667397f, -0.13888475f, -0.03444445f, 
    0.02011703f, 0.06685684f, 0.10995039f, -0.13733836f, 0.01769217f, -0.25706804f, -0.15412085f, -0.06023795f, 
    0.05677561f, -0.10397509f, -0.22878198f, 0.15908499f, -0.10084839f, 0.09671184f, -0.04544578f, 0.05728815f, 
    -0.35001287f, -0.16912889f, 0.00391288f, -0.01732836f, 0.02341512f, 0.06053327f, 0.03193886f, 0.03363270f, 
    -0.02760437f, 0.04534420f, -0.03942268f, -0.07280125f, 0.35613218f, 0.38017038f, -0.25548518f, 0.32554451f, 
    -0.02884183f, -0.12444136f, 0.03654974f, 0.07586926f, -0.00701006f, 0.07428368f, 0.00329058f, 0.04751092f, 
    0.49346077f, 0.16569465f, -0.01479104f, -0.18342724f, 0.07906295f, 0.04753115f, 0.06599740f, 0.03375129f, 
    -0.01131204f, -0.08611646f, -0.00641502f, -0.16105409f, 0.24338077f, 0.21589705f, 0.00490547f, -0.22090311f, 
    -0.09866192f, -0.02624334f, 0.12087497f, 0.03474282f, -0.00680043f, 0.06398826f, -0.05760297f, -0.18813011f, 
    0.17845587f, -0.13145365f, -0.28968391f, -0.01396813f, -0.00636435f, -0.03657326f, -0.02607894f, -0.07749505f, 
    0.04335397f, 0.07033019f, -0.02209132f, 0.04187921f, -0.04407036f, 0.03320752f, 0.03568544f, -0.01515270f, 
    -0.23058689f, -0.06207523f, -0.08264843f, 0.02808647f, -0.05320660f, -0.07248192f, -0.03575086f, -0.06583056f, 
    0.05899976f, -0.03134848f, 0.10185887f, 0.03776072f, 0.08084244f, 0.03052893f, -0.02830256f, -0.03074629f, 
    -0.01672488f, 0.00435226f, 0.10321509f, 0.04004691f, -0.35966775f, 0.22452018f, -0.52002293f, -0.25989041f, 
    0.04823346f, 0.04904351f, -0.00637144f, 0.07993130f, -0.03803083f, 0.06575587f, -0.04265195f, 0.05184317f, 
    -0.70583123f, 0.33303902f, 0.26174769f, -0.10119253f, 0.10025480f, -0.03493462f, -0.07089356f, 0.11126437f, 
    -0.02454063f, 0.04705112f, -0.00849551f, 0.03362487f, -0.43966404f, -0.35160086f, 0.08898280f, -0.03333080f, 
    0.06282923f, 0.01870194f, -0.02392954f, -0.02532439f, -0.06476901f, -0.07658928f, 0.04293074f, 0.00260839f, 
    0.31036201f, 0.25877219f, -0.22813123f, -0.21653476f, 0.06382716f, 0.00584600f, -0.03976271f, -0.04180383f, 
    0.05988985f, -0.05213270f, -0.02757428f, -0.06379204f, 0.16135989f, 0.07334197f, -0.09795360f, -0.09906161f, 
    0.04494184f, 0.17547543f, 0.02494016f, -0.16089346f, 0.02142937f, 0.00547714f, 0.08037355f, 0.01382717f, 
    0.47465175f, -0.48337421f, -0.57732463f, -0.13660112f, -0.00403076f, -0.02827000f, 0.10622059f, -0.07151490f, 
    0.18138428f, 0.10478939f, 0.09326577f, -0.07467841f, 0.26508486f, 0.00916989f, 0.08953686f, -0.01249185f, 
    -0.15445064f, -0.03731244f, -0.00764498f, -0.11963256f, 0.05037289f, -0.02999006f, -0.00039209f, 0.03179881f, 
    -0.11150896f, 0.27060091f, -0.02023751f, 0.08516864f, 0.02331357f, 0.01516463f, 0.00950021f, 0.04773027f, 
    -0.10499971f, 0.03690574f, 0.00863150f, -0.04470081f, -0.28207901f, 0.19638474f, 0.02710251f, -0.20019422f, 
    -0.00199513f, 0.03297496f, -0.02784353f, -0.02098654f, 0.09814020f, 0.14606054f, -0.12813121f, -0.38490269f, 
    0.06761722f, -0.01129977f, -0.11095621f, -0.21672399f, -0.09961236f, 0.10420494f, 0.07863583f, -0.08359248f, 
    -0.12411705f, 0.11357244f, 0.00408003f, 0.01156709f, -0.74661833f, 0.03760275f, -0.00383505f, -0.30736226f, 
    0.03498238f, -0.00520469f, 0.10444567f, 0.15794702f, 0.08529166f, 0.00259880f, 0.15214428f, -0.09162264f, 
    -0.07184418f, 0.21595360f, 0.12049223f, -0.06276909f, 0.02087988f, 0.03353602f, -0.05597116f, -0.09427558f, 
    -0.31284502f, -0.20490514f, -0.15769915f, -0.07190723f, 0.24579705f, -0.25245208f, -0.07697847f, -0.31418398f, 
    -0.05146503f, 0.05041339f, 0.10768262f, 0.03212302f, 0.14384027f, 0.03843747f, 0.11458629f, -0.20484957f, 
    -0.34252205f, 0.18790394f, -0.08939434f, -0.17094463f, -0.12739372f, -0.06846195f, 0.01764151f, 0.01988774f, 
    -0.07215286f, 0.00710446f, 0.17276418f, -0.03290973f, 0.59437478f, -0.04617459f, 0.16047487f, -0.02412448f, 
    -0.17056519f, -0.03228081f, -0.02773752f, -0.09678380f, -0.02506908f, 0.00545577f, -0.00066608f, 0.00744864f, 
    0.03436350f, 0.03328288f, -0.36321282f, -0.27693281f, -0.04214164f, -0.01714925f, 0.08743041f, 0.07723148f, 
    -0.00290075f, 0.03477859f, 0.01480463f, -0.15736295f, 0.15895076f, 0.01933057f, 0.04038187f, 0.08681126f, 
    -0.03966213f, -0.01314195f, -0.00738574f, -0.01731659f, -0.01458919f, 0.09806699f, 0.03585633f, -0.06866181f, 
    0.26434916f, 0.05550940f, 0.05313938f, -0.05261815f, 0.02866510f, -0.06667499f, -0.02928660f, -0.02659468f, 
    0.01493873f, 0.13445753f, -0.07018111f, 0.03463172f, 0.12678498f, 0.18562819f, 0.01152895f, -0.01483142f, 
    -0.01074680f, -0.09839793f, -0.32856151f, -0.44017655f, 0.05680974f, -0.11095425f, 0.03062524f, -0.04638841f, 
    0.00150824f, 0.13187096f, -0.02352707f, 0.24477351f, 0.07739693f, -0.00305294f, -0.03942629f, -0.10928980f, 
    0.16022049f, 0.11027737f, -0.00957496f, 0.03670616f, 0.26829314f, -0.01876231f, 0.09581178f, 0.11372024f, 
    0.01870058f, -0.12819783f, 0.01065945f, -0.06630918f, -0.03320433f, 0.17015633f, -0.06977391f, 0.05931843f, 
    0.02994760f, -0.03502956f, -0.15375866f, 0.02096304f, -0.13564044f, 0.09046945f, 0.23267956f, -0.13839261f, 
    0.28726164f, -0.21701361f, 0.04772449f, 0.00443790f, 0.09876838f, -0.00282774f, 0.03591062f, -0.00427635f, 
    -0.05026647f, 0.01928334f, 0.02013406f, 0.02984510f, -0.03911940f, 0.01210030f, 0.02546935f, 0.14846243f, 
    0.49326131f, -0.16820790f, 0.31911185f, -0.09770161f, -0.03825852f, 0.02394079f, 0.00348009f, -0.00450001f, 
    0.02169613f, 0.22171138f, -0.20885937f, -0.09621553f, -0.13653506f, 0.00984617f, 0.04142184f, -0.02742776f, 
    0.04198234f, 0.01194115f, -0.11082505f, 0.07212387f, -0.39803880f, -0.20720178f, -0.37997630f, 0.07775363f, 
    0.18119802f, -0.00888124f, -0.13961373f, -0.10557167f, -0.04881347f, 0.00833471f, 0.01232520f, -0.23503982f, 
    -0.04349521f, -0.00408658f, -0.06400874f, -0.05243137f, 0.04495626f, 0.22146867f, 0.32481197f, 0.14158598f, 
    0.01684917f, 0.09632343f, -0.18092231f, -0.31612661f, -0.07366676f, -0.02438038f, -0.00557407f, 0.00238074f, 
    -0.24020959f, -0.02541883f, -0.13576391f, -0.00818847f, 0.02247728f, -0.17816989f, -0.02965518f, 0.31132707f, 
    0.00606875f, -0.04339291f, -0.02038064f, -0.02245943f, -0.16438338f, 0.21722470f, 0.04755225f, -0.03895890f, 
    -0.04681506f, 0.04678950f, -0.07874356f, 0.26816380f, 0.00288790f, 0.03585572f, 0.07560787f, -0.07912189f, 
    0.18540715f, 0.18591709f, 0.16363969f, 0.20062709f, -0.03344217f, 0.00683029f, -0.00746944f, -0.05631658f, 
    0.04400776f, -0.00724552f, 0.07339174f, -0.00234725f, 0.27909428f, -0.13841510f, 0.15315263f, 0.14052668f, 
    -0.00779705f, -0.16147304f, 0.15130468f, -0.07623405f, -0.00114397f, -0.00802960f, -0.03856396f, 0.00435997f, 
    -0.03743121f, -0.11537463f, -0.09533896f, 0.37397206f, 0.02276754f, 0.04183256f, -0.02563017f, 0.25790349f, 
    -0.00070058f, -0.09488960f, -0.00684743f, -0.13726738f, -0.01988596f, -0.07262477f, 0.00817025f, -0.06981783f, 
    -0.05688305f, 0.08139785f, 0.02248511f, 0.03490372f, 0.17008179f, 0.04749714f, -0.00748384f, 0.06599788f, 
    -0.39945155f, -0.34972617f, -0.05208519f, -0.00556995f, 0.01106405f, 0.06634338f, 0.01721450f, -0.16016637f, 
    -0.00714184f, 0.07695284f, -0.02341038f, 0.11204695f, 0.24836425f, -0.12013204f, -0.02513864f, -0.17898172f, 
    -0.05056686f, -0.06960098f, 0.01296701f, 0.16732925f, 0.05910349f, -0.01208815f, 0.02712967f, -0.05004011f, 
    0.43448707f, 0.30285922f, 0.18202707f, -0.16968723f, -0.00980343f, -0.02876329f, -0.07122937f, 0.14683068f, 
    -0.02419139f, -0.02831808f, -0.00367117f, -0.13537008f, 0.26294532f, 0.07028133f, -0.11927918f, 0.13429642f, 
    -0.06985839f, 0.01577679f, 0.02294490f, 0.00507579f, -0.12506764f, -0.15452439f, 0.01953196f, 0.11574677f, 
    -0.11705571f, 0.06304240f, 0.05387084f, 0.13386089f, -0.12843923f, 0.14501677f, -0.07386280f, 0.03889349f, 
    -0.02772808f, -0.00641173f, -0.01538870f, 0.03689412f, 0.54420215f, -0.24610175f, 0.48769754f, 0.21772335f, 
    -0.07338808f, 0.03216538f, -0.04794091f, -0.01695462f, 0.06295398f, 0.05296044f, 0.06136098f, -0.06605353f, 
    -0.08832692f, 0.06971551f, -0.04150202f, -0.16354142f, -0.03339221f, -0.03298653f, -0.01165823f, 0.08596528f, 
    -0.14503737f, 0.09286772f, -0.09882331f, -0.00866553f, -0.01504781f, -0.11705319f, 0.06427323f, -0.32620734f, 
    -0.12978876f, -0.18617330f, -0.17085090f, -0.07979776f, -0.02742457f, 0.05142711f, -0.02081903f, 0.05740109f, 
    -0.10094219f, -0.03023932f, -0.00667578f, -0.17875834f, 0.23185816f, 0.11850412f, -0.03077246f, 0.00530983f, 
    0.12829450f, 0.14888322f, 0.00330843f, 0.00460794f, 0.01807654f, 0.28926170f, 0.26911145f, 0.12867680f, 
    -0.03988046f, -0.04465250f, 0.08403293f, -0.16396964f, -0.08175932f, -0.02189059f, 0.00015730f, -0.10759018f, 
    -0.13496180f, 0.10728845f, -0.05827961f, -0.11260229f, -0.09728391f, 0.10882124f, 0.04785081f, -0.04819773f, 
    0.03970237f, -0.06822749f, 0.08282442f, -0.04792170f, 0.00600403f, 0.18849197f, -0.15451947f, -0.00869454f, 
    0.15740061f, -0.12130243f, -0.00647173f, -0.08954087f, 0.01281881f, 0.04094967f, 0.01057811f, -0.01657661f, 
    0.17381251f, -0.10578007f, -0.00869000f, -0.07069301f, 0.01021253f, 0.06765272f, -0.05891328f, 0.00602343f, 
    0.04728563f, 0.06685314f, 0.00707379f, -0.02657292f, 0.15852135f, 0.25175893f, 0.08272494f, 0.13632867f, 
    -0.14338219f, -0.00656340f, -0.33316177f, -0.20681736f, 0.05979405f, -0.03816824f, -0.12261770f, -0.02850275f, 
    0.16031997f, 0.06544147f, -0.18754770f, 0.07643634f, -0.02399214f, -0.09225219f, 0.05540974f, -0.14552571f, 
    -0.07932948f, -0.02752187f, -0.02771547f, 0.13985501f, 0.06767044f, -0.33592007f, -0.33085904f, -0.26640981f, 
    -0.22587751f, -0.08900211f, -0.17816700f, 0.10556973f, -0.06318331f, -0.06169855f, -0.04602249f, 0.13732870f, 
    -0.11584140f, 0.01024235f, -0.02154197f, 0.03352670f, 0.04739631f, -0.02027920f, 0.17725097f, -0.01490394f, 
    0.06730517f, -0.05919626f, 0.04650890f, 0.04125188f, -0.03189640f, -0.06999451f, -0.51588011f, -0.12378648f, 
    -0.15559794f, -0.15286717f, -0.07696605f, -0.04268531f, -0.00270220f, -0.00294210f, -0.11837844f, 0.03329573f, 
    0.03600731f, -0.00160725f, 0.08315486f, -0.04009773f, 0.05403696f, 0.08297483f, -0.13169073f, 0.00269260f, 
    -0.21256498f, -0.05354366f, 0.03286332f, 0.00017524f, -0.01288024f, -0.18593517f, -0.06583009f, -0.09606224f, 
    -0.07519888f, 0.00992673f, -0.01472440f, 0.13016245f, 0.14601162f, 0.17832342f, -0.11700945f, 0.05785755f, 
    -0.12956467f, 0.20857631f, 0.13085417f, 0.01546259f, 0.10186592f, 0.15540035f, 0.16516605f, 0.16898267f, 
    -0.09317736f, 0.02669983f, 0.00448261f, -0.08177675f, -0.02697023f, -0.07538532f, 0.10475985f, -0.20812413f, 
    0.04299536f, 0.02326097f, -0.14462239f, 0.14236698f, 0.03105091f, -0.08802775f, 0.13357779f, 0.12540582f, 
    0.25718382f, -0.12732632f, 0.04156139f, -0.17181845f, 0.04541900f, -0.05023851f, 0.04699691f, -0.25984201f, 
    0.06647602f, 0.04078117f, -0.22091599f, -0.03303159f, 0.14808275f, 0.00528774f, 0.02116016f, -0.16662085f, 
    -0.04613476f, -0.02352057f, -0.02646682f, 0.04347466f, -0.06034777f, -0.00695775f, -0.00527543f, -0.09339454f, 
    -0.00522236f, 0.16656455f, 0.16066767f, 0.10773458f, 0.04750841f, -0.00955467f, -0.01030337f, -0.07532009f, 
    0.06222333f, 0.01093620f, 0.01469830f, 0.04452743f, -0.01270978f, -0.31427288f, -0.29804265f, 0.13217634f, 
    -0.05050676f, -0.08528189f, 0.02038780f, -0.08896817f, 0.05587725f, -0.00013958f, -0.00505410f, -0.05613936f, 
    -0.11276615f, -0.04836830f, 0.00471001f, 0.06321499f, 0.01539272f, -0.00051717f, 0.05986912f, -0.07128728f, 
    0.13250230f, -0.20613956f, -0.11058778f, -0.02444815f, -0.02836032f, 0.02303723f, 0.00958270f, 0.01829360f, 
    -0.14723778f, 0.09983777f, -0.01904652f, 0.11057498f, 0.14445035f, -0.06139522f, -0.25272962f, -0.02885053f, 
    0.27916294f, -0.13903682f, -0.15035948f, -0.18595488f, -0.03984544f, 0.04481763f, 0.05543400f, 0.02143493f, 
    0.04583918f, -0.18370621f, 0.00889839f, 0.04645945f, 0.03165104f, 0.02108904f, 0.02954126f, 0.04734436f, 
    0.04451199f, -0.02031767f, -0.15978761f, 0.00785642f, -0.04365051f, 0.01892913f, -0.08978125f, 0.05727733f, 
    -0.15962593f, -0.19699605f, -0.01224847f, -0.11263989f, 0.00093320f, 0.01327548f, -0.00052071f, -0.07015339f, 
    0.13922554f, -0.12342851f, -0.14281203f, -0.01084499f, 0.29506528f, 0.41075325f, 0.31207758f, 0.00726061f, 
    -0.02978358f, 0.04811912f, -0.03341047f, -0.00167709f, 0.03121760f, 0.10276186f, -0.00635135f, 0.06679939f, 
    0.20506665f, 0.01810374f, 0.16233133f, -0.07173721f, -0.01100641f, 0.03864649f, -0.01242988f, -0.06231568f, 
    0.01237369f, -0.00089286f, 0.04530150f, -0.01095687f, 0.10781743f, 0.11883833f, 0.16759238f, -0.09702067f, 
    -0.03897896f, 0.09038822f, 0.01198433f, -0.06910508f, 0.01149398f, 0.04786798f, 0.07791831f, -0.01758932f, 
    -0.19231816f, -0.28085208f, -0.05084011f, 0.14205906f, -0.09127483f, 0.09295521f, -0.04760233f, 0.11292091f, 
    0.05871674f, -0.16738191f, 0.06206847f, 0.05020774f, 0.08712721f, -0.06338917f, -0.11562396f, -0.33593485f, 
    0.04081940f, 0.05247429f, -0.07602799f, 0.02651101f, -0.14920044f, 0.01876777f, -0.14189081f, -0.17540495f, 
    -0.14902791f, 0.15962391f, 0.37530091f, 0.10105073f, 0.00922041f, -0.09084073f, 0.09028233f, 0.02690426f, 
    -0.12240390f, 0.00609482f, 0.07213727f, -0.00121846f, -0.73309708f, 0.07114292f, 0.20986131f, -0.22304241f, 
    0.07928659f, 0.02493534f, -0.05785395f, -0.00506322f, -0.02432445f, 0.05669190f, -0.05485344f, 0.01982155f, 
    -0.19137625f, 0.00731758f, -0.00353478f, -0.00899103f, 0.02014300f, 0.00118084f, 0.02293673f, 0.00054649f, 
    -0.00596253f, 0.04330226f, 0.14506297f, -0.09248812f, -0.18442723f, -0.07966381f, 0.02508757f, -0.00508702f, 
    0.00534948f, 0.02210354f, 0.02154204f, -0.10200689f, -0.07499223f, -0.10719460f, 0.09972984f, 0.01155882f, 
    0.14684671f, 0.15141602f, -0.02398194f, 0.20663500f, 0.00015614f, 0.00111791f, 0.01082348f, 0.00432370f, 
    0.01517054f, 0.09683184f, -0.09072793f, 0.08507501f, 0.20799111f, 0.02934677f, -0.16544114f, 0.24242091f, 
    0.00788230f, 0.09721532f, -0.10065267f, -0.01712844f, -0.03540230f, -0.11205593f, 0.04925332f, 0.10979777f, 
    0.00392264f, 0.08581931f, -0.02588264f, 0.05781317f, 0.00958127f, 0.01164105f, 0.06454276f, -0.09008342f, 
    0.07845572f, 0.18403758f, -0.11345090f, 0.21725824f, -0.39080626f, 0.39488998f, 0.09237058f, -0.13704546f, 
    0.04982738f, 0.09035180f, -0.10870957f, -0.05267192f, -0.04988364f, -0.17570513f, -0.15499142f, 0.11927591f, 
    0.03466573f, 0.02347929f, -0.21464868f, 0.13790347f, -0.03196757f, -0.10815015f, -0.08011468f, 0.09308726f, 
    -0.01274569f, 0.06242704f, 0.02008395f, -0.09056014f, -0.60394382f, 0.04589417f, 0.14766851f, -0.51381552f, 
    0.00834462f, 0.01287465f, -0.04505469f, 0.08061266f, -0.04490309f, -0.01058496f, 0.02248641f, -0.05361950f, 
    -0.03377801f, 0.04751483f, 0.27533981f, 0.33853862f, 0.05337529f, -0.01063532f, 0.04772766f, 0.03086093f, 
    0.09125833f, -0.07774894f, -0.08303384f, 0.05091967f, -0.07602992f, -0.13190500f, -0.06218260f, -0.10773801f, 
    0.01018471f, 0.00884380f, -0.03415671f, -0.01621271f, -0.02994204f, 0.03237373f, -0.11817874f, 0.22548169f, 
    -0.08555257f, -0.07060596f, -0.05045931f, -0.14069711f, 0.02692897f, -0.07407778f, 0.04979991f, 0.04951845f, 
    -0.00705127f, -0.00891731f, -0.10386951f, 0.08512857f, -0.20511502f, 0.17414764f, 0.27402470f, 0.18203744f, 
    -0.07149969f, -0.06329788f, 0.16193964f, -0.05235285f, -0.01507203f, 0.07891271f, -0.01724821f, 0.08527273f, 
    -0.05911870f, 0.05879285f, -0.15952270f, -0.06858861f, 0.04506280f, 0.05822445f, -0.05495348f, 0.04080655f, 
    -0.06593926f, -0.01077518f, 0.15553455f, -0.10441570f, -0.00977543f, -0.16495429f, 0.32046956f, 0.05946498f, 
    0.03121091f, -0.12114955f, 0.07949508f, 0.00372202f, -0.04445829f, 0.10314630f, -0.07401466f, 0.06556908f, 
    -0.02735795f, -0.00016551f, -0.06601208f, -0.03469861f, -0.09367127f, -0.01001084f, 0.02482222f, -0.08100016f, 
    0.08847464f, -0.06553775f, 0.16027707f, -0.07497011f, 0.24274546f, -0.06601350f, -0.04194634f, 0.07365223f, 
    -0.08678762f, 0.09877066f, 0.12084080f, 0.00169771f, 0.03619415f, 0.03392738f, -0.09449352f, -0.01439590f, 
    -0.15853414f, 0.32110390f, 0.00781182f, -0.27958712f, 0.04884947f, -0.09085776f, -0.04073325f, 0.10046436f, 
    0.00707024f, 0.06558696f, -0.12880290f, 0.00608442f, -0.02389869f, -0.06675793f, 0.03932602f, 0.05102885f, 
    -0.01146864f, -0.05816648f, -0.08128289f, -0.07734660f, 0.20937006f, 0.17353827f, 0.00606477f, 0.18772392f, 
    -0.18053526f, 0.26518947f, 0.25977844f, 0.13461232f, 0.04026816f, -0.00730565f, 0.05714114f, 0.05627509f, 
    0.09564000f, 0.00104898f, 0.07483656f, -0.02793282f, -0.84759581f, -0.21521768f, 0.01263466f, -0.37416616f, 
    -0.20397371f, -0.04192660f, 0.12871189f, -0.13682520f, -0.02992077f, 0.02064686f, 0.04319864f, -0.04912603f, 
    -0.16960654f, 0.09325535f, -0.22400124f, -0.03971548f, 0.12645201f, -0.15691118f, -0.04553506f, 0.15570717f, 
    -0.00585625f, -0.02722152f, -0.03507881f, 0.05545153f, -0.44579166f, -0.27738222f, 0.07825748f, -0.01224377f, 
    -0.22286901f, -0.12748310f, -0.18927869f, 0.07425436f, -0.14164889f, 0.06097591f, -0.12869160f, -0.03968111f, 
    -0.20016584f, -0.00232864f, -0.01568018f, 0.05121658f, -0.00092573f, -0.05124615f, 0.05897392f, 0.09873073f, 
    -0.04757395f, -0.02747119f, 0.01209466f, 0.04479657f, 0.00467285f, 0.16116744f, 0.26545992f, 0.11782928f, 
    0.09257454f, -0.26281020f, 0.13538769f, -0.03458108f, 0.00776399f, -0.01967643f, 0.09345098f, -0.09857668f, 
    0.19497934f, -0.24099052f, 0.07556461f, 0.05617638f, 0.13093852f, 0.04314213f, -0.26742932f, -0.06538219f, 
    -0.05259242f, -0.01434047f, -0.03967831f, -0.06150848f, 0.01880326f, 0.10018802f, 0.11218498f, 0.10791083f, 
    0.02465238f, -0.02709275f, 0.05723934f, 0.06078087f, -0.16543819f, 0.06624796f, -0.09324210f, 0.03585873f, 
    0.12677565f, -0.26814535f, -0.44110212f, -0.14482248f, 0.24078767f, 0.12707253f, -0.05146606f, 0.01944086f, 
    -0.14883266f, 0.07106694f, 0.07522254f, 0.02072174f, -0.07856759f, -0.00507850f, 0.13106291f, -0.30543023f, 
    0.08645938f, -0.21777347f, -0.11485664f, 0.03089356f, 0.08305811f, -0.11084065f, 0.00916632f, -0.01267030f, 
    -0.12865576f, 0.26852709f, 0.55175608f, 0.43006626f, 0.03039205f, -0.05234239f, 0.01311054f, 0.00818178f, 
    0.03171173f, -0.04540866f, -0.03493421f, -0.03277282f, 0.09629357f, -0.02140646f, 0.09354165f, 0.14464718f, 
    0.10231069f, -0.05534242f, -0.04766779f, 0.12219437f, -0.05873917f, -0.12525940f, 0.14782155f, -0.10657721f, 
    -0.40210494f, -0.38964146f, -0.38378170f, -0.28406209f, -0.04811884f, -0.03848745f, 0.12266163f, 0.01396520f, 
    0.02716757f, 0.00468779f, -0.04431759f, 0.01526881f, 0.15721153f, -0.02262195f, -0.05959270f, -0.08726181f, 
    0.08789682f, 0.06036310f, -0.00850880f, 0.00647573f, -0.05598962f, 0.03103230f, -0.00782967f, -0.19113187f, 
    0.02415309f, -0.08920822f, -0.27098861f, 0.00836050f, 0.04260829f, 0.04550711f, -0.07244251f, -0.02026726f, 
    -0.09389298f, -0.19351421f, -0.15383901f, 0.00589218f, -0.70428711f, -0.73147202f, 0.04599250f, -0.44014677f, 
    -0.11652441f, -0.04654864f, -0.09107368f, -0.19568279f, -0.01263954f, -0.06728061f, -0.02914723f, -0.00530049f, 
    -0.12947884f, -0.23951605f, -0.01751982f, 0.01604051f, -0.09763365f, -0.02932883f, -0.29765910f, -0.10945020f, 
    0.03937430f, 0.07462882f, 0.02864276f, -0.00869788f, -0.07652461f, 0.18311436f, 0.23499519f, 0.16650163f, 
    -0.09912384f, 0.18471439f, 0.26915297f, -0.09433699f, 0.00128138f, 0.05412010f, -0.03609550f, -0.04568021f, 
    0.11227794f, 0.05094464f, -0.00306736f, 0.09056558f, -0.00795801f, 0.15446913f, -0.08276095f, 0.05354568f, 
    -0.10981049f, -0.00101379f, -0.05846268f, 0.05761673f, -0.35110828f, -0.16605261f, -0.04776843f, -0.07071627f, 
    -0.01291962f, 0.07175216f, 0.01501207f, -0.01592712f, -0.08070333f, -0.05290239f, 0.05995702f, -0.08146481f, 
    0.16817734f, -0.23645574f, 0.06289827f, -0.01716019f, 0.05599663f, -0.14669481f, -0.08309056f, -0.16529854f, 
    -0.06193854f, 0.03453876f, -0.06955849f, 0.06043733f, 0.18510053f, -0.11084241f, 0.13334781f, 0.34510344f, 
    0.04279213f, -0.09057556f, -0.08607336f, 0.00520996f, 0.03496876f, 0.10593062f, 0.01149563f, 0.10315373f, 
    -0.23073709f, -0.14234601f, 0.01654160f, -0.04340732f, -0.24614093f, -0.07869636f, -0.20916025f, 0.02140994f, 
    0.03695820f, -0.01317945f, -0.01704031f, -0.01138692f, -0.28641534f, -0.46261749f, 0.23138794f, -0.43858907f, 
    0.21719018f, -0.09295364f, -0.23796579f, -0.29305530f, 0.12091350f, -0.07048647f, 0.06335666f, 0.03286797f, 
    -0.03220528f, -0.07016596f, 0.07179496f, 0.05569938f, 0.02743064f, 0.05010808f, -0.21311852f, 0.11111733f, 
    0.00275161f, -0.01338545f, 0.07603180f, 0.01955634f, -0.39120165f, -0.15488468f, 0.08485606f, -0.03135064f, 
    -0.08192611f, -0.17177993f, 0.02775734f, 0.03722848f, 0.04335635f, -0.06793422f, -0.03030320f, 0.06589183f, 
    -0.13408796f, -0.00352361f, 0.03778902f, 0.01038454f, 0.05202803f, 0.01188829f, -0.12823565f, -0.06108216f, 
    0.11079423f, -0.00038467f, 0.04954259f, 0.06143134f, -0.11662423f, 0.20854458f, 0.03409651f, 0.03379570f, 
    -0.01078840f, -0.03904210f, -0.10384861f, -0.22143225f, 0.12994798f, -0.07065454f, -0.10658295f, 0.15924765f, 
    -0.27503136f, 0.23788111f, 0.01501925f, 0.14261238f, -0.20040192f, 0.10715414f, 0.03739285f, -0.24924691f, 
    -0.05643656f, -0.06514700f, -0.08937571f, -0.13408826f, -0.16156988f, 0.16332453f, 0.19887330f, -0.16481663f, 
    0.18488750f, -0.12181408f, -0.56207025f, -0.09627748f, 0.11474420f, -0.05792698f, 0.02510449f, 0.10558116f, 
    0.08466881f, 0.01547296f, 0.13314448f, -0.43023056f, 0.14898980f, -0.04160944f, -0.10018641f, -0.22438215f, 
    0.03450751f, 0.02739560f, -0.04651206f, -0.06557610f, -0.15387189f, 0.21531311f, -0.08205236f, -0.02120508f, 
    -0.05349823f, -0.05978241f, 0.05006910f, -0.01650463f, 0.06641508f, 0.11723036f, 0.21160313f, 0.18182211f, 
    -0.10730601f, -0.04819623f, 0.02755425f, 0.03861682f, -0.02755729f, 0.00629102f, 0.00988696f, 0.02172926f, 
    0.00823604f, -0.04416754f, 0.03281410f, 0.04366518f, 0.10976339f, 0.34171569f, -0.43554410f, -0.31338957f, 
    0.07393989f, -0.04450470f, 0.00286826f, 0.03375633f, 0.02677879f, 0.03720250f, 0.06880455f, -0.12133699f, 
    -0.01425714f, -0.26854223f, 0.25915313f, 0.30562451f, -0.03813565f, 0.04360274f, 0.00861796f, 0.21705838f, 
    0.02676126f, 0.04094658f, 0.05784233f, 0.06332646f, -0.11774646f, -0.11202759f, 0.16440086f, 0.13112113f, 
    0.01842974f, -0.09599630f, -0.07085209f, -0.01247585f, 0.03430277f, 0.06356856f, -0.10849968f, 0.04827494f, 
    -0.01621607f, 0.01291273f, 0.12840931f, -0.12978314f, -0.03015347f, -0.08076300f, 0.01755440f, -0.05156023f, 
    0.03658708f, 0.02239637f, 0.10902924f, 0.15743560f, 0.04282856f, -0.00251718f, -0.04877049f, -0.00315141f, 
    -0.08872497f, 0.12161201f, -0.04086205f, 0.09838267f, 0.00509802f, 0.00407213f, -0.07007571f, 0.04396893f, 
    0.06444680f, 0.26719135f, 0.00872349f, 0.22356129f, 0.01947943f, 0.00559515f, 0.04562729f, -0.06620593f, 
    0.05262153f, 0.05013219f, 0.03201143f, 0.06557929f, -0.11352857f, 0.05736593f, 0.11738750f, -0.18298551f, 
    0.06316812f, 0.00212173f, -0.04336039f, 0.05352245f, -0.00319367f, 0.19274069f, 0.02608029f, -0.01359909f, 
    -0.30397570f, -0.16140157f, 0.29745418f, -0.22541291f, -0.03495966f, 0.11285020f, 0.08188948f, 0.02059851f, 
    -0.04811241f, -0.05882924f, 0.06511354f, -0.02436745f, -0.20188829f, 0.09344319f, 0.10303262f, 0.11904064f, 
    0.03884801f, 0.07051250f, -0.07973266f, -0.00431670f, 0.09740242f, -0.21403487f, 0.31039420f, -0.05606838f, 
    -0.13641922f, -0.39472640f, -0.24629126f, -0.07725413f, 0.25688016f, -0.08904019f, -0.08372902f, 0.09800847f, 
    -0.10494009f, -0.05627412f, 0.00934649f, -0.07201216f, 0.01113143f, 0.15944906f, 0.30483344f, 0.15985097f, 
    0.00223689f, -0.04511816f, 0.03940778f, 0.10036507f, -0.07382037f, -0.02237447f, -0.04553676f, 0.09588097f, 
    -0.29862005f, 0.13363177f, -0.01634093f, 0.13036326f, 0.11028679f, 0.07430184f, 0.04476438f, 0.00318710f, 
    -0.04913822f, 0.01048886f, -0.13079089f, -0.00030892f, -0.20885366f, -0.31693545f, 0.08782113f, 0.36974415f, 
    0.01871084f, -0.20452563f, 0.07229967f, 0.00445834f, -0.01995103f, 0.02577379f, -0.08370318f, 0.00934869f, 
    0.15662037f, -0.10255517f, 0.02485599f, -0.28712425f, 0.07824414f, -0.04896028f, -0.02625151f, -0.07282168f, 
    -0.06504831f, -0.03085461f, -0.03568512f, -0.04887486f, -0.10133979f, 0.06628152f, -0.27171203f, 0.01220644f, 
    -0.12135967f, -0.07659986f, -0.15957963f, 0.03837138f, -0.16543934f, 0.08356032f, 0.08779541f, 0.02666103f, 
    0.22036491f, -0.00938723f, -0.15719984f, 0.30339313f, 0.03720912f, 0.02572791f, -0.27864888f, 0.02283919f, 
    0.09490754f, 0.08642714f, 0.10305871f, -0.05022103f, 0.38926116f, 0.09238376f, 0.02207669f, -0.32965150f, 
    -0.23687220f, -0.11090029f, -0.06619895f, -0.17525570f, 0.02922931f, -0.06260675f, 0.13556837f, -0.10123578f, 
    0.26024261f, -0.11974005f, -0.02484971f, 0.10048206f, 0.09943829f, 0.16096681f, 0.03802765f, 0.10688689f, 
    -0.02353211f, 0.04636126f, 0.12896760f, 0.06955124f, -0.37203789f, 0.01204531f, 0.18221658f, 0.18008892f, 
    -0.02470946f, -0.01902241f, 0.08701465f, -0.05742096f, -0.03998952f, 0.08962259f, 0.12110406f, 0.05743973f, 
    -0.19898355f, 0.21862350f, -0.45271960f, 0.03061530f, 0.07819131f, 0.01978458f, -0.06083415f, -0.18530303f, 
    0.05868940f, -0.10328589f, 0.01102950f, 0.08833997f, -0.27816063f, 0.01879356f, 0.31222600f, 0.45859772f, 
    0.03801895f, -0.11843053f, 0.05680333f, 0.00740494f, 0.13305283f, 0.01179056f, 0.13291988f, 0.01255198f, 
    0.00233472f, -0.05549283f, -0.15430799f, -0.00528471f, 0.21092927f, 0.09393833f, -0.08567733f, 0.11760235f, 
    -0.07411757f, 0.09218172f, -0.09745612f, -0.05649601f, -0.15492521f, -0.16639911f, -0.22935313f, -0.02885679f, 
    0.20597807f, -0.02188480f, -0.32262936f, 0.09050980f, -0.09558396f, -0.08158782f, 0.06332517f, -0.17355202f, 
    -0.43525246f, 0.13517073f, 0.12481102f, 0.10069977f, 0.03693718f, 0.09366974f, -0.19387586f, 0.05505565f, 
    0.17623211f, 0.07688259f, -0.10047362f, 0.12655158f, -0.25423935f, -0.16196750f, 0.03023014f, 0.12007891f, 
    -0.05886622f, -0.03002326f, 0.03133157f, -0.07859194f, 0.07477763f, 0.11491468f, 0.16332003f, 0.11290506f, 
    -0.26401928f, 0.38392022f, 0.10185862f, -0.05408972f, 0.02568685f, -0.16643642f, -0.00705788f, 0.04739307f, 
    -0.13806435f, 0.05339838f, 0.01160734f, -0.06711981f, -0.14543809f, 0.14253996f, 0.35813114f, -0.16511236f, 
    -0.18243755f, -0.04541764f, -0.09804438f, -0.07172877f, -0.02862429f, 0.21010453f, -0.14468187f, -0.06458246f, 
    -0.21480726f, 0.57831746f, -0.12403939f, 0.36956164f, 0.02254405f, -0.16747648f, 0.12801497f, -0.08920892f, 
    -0.03997495f, 0.17172904f, -0.12174566f, -0.11078402f, -0.13669449f, -0.01733709f, -0.12613809f, -0.49480802f, 
    -0.14022934f, -0.11393987f, -0.03690325f, 0.01670592f, -0.24617001f, 0.04417325f, -0.23864958f, -0.12925464f, 
    -0.26664472f, 0.05932938f, 0.06866306f, 0.38457415f, 0.06515136f, -0.00836716f, -0.38078663f, -0.00753255f, 
    -0.02359884f, -0.13444625f, 0.12977251f, -0.09562539f, 0.17156860f, -0.08551898f, 0.07402789f, -0.18822093f, 
    -0.08217018f, 0.04397201f, -0.08754154f, -0.08755740f, 0.06168544f, 0.05130137f, -0.15150908f, 0.11087723f, 
    0.18927699f, -0.17416424f, -0.00927681f, 0.15008213f, 0.12800337f, 0.07864846f, -0.00423448f, 0.08034167f, 
    0.00911013f, 0.00195207f, 0.09203915f, -0.00634724f, 0.11296071f, -0.26676753f, -0.12464942f, 0.21902449f, 
    0.05491769f, -0.08776055f, 0.05209604f, -0.04130285f, 0.15539850f, -0.04468043f, 0.00297031f, -0.01251324f, 
    -0.10310829f, 0.28232193f, -0.22125125f, 0.24493209f, -0.05583471f, -0.13129410f, -0.04348057f, -0.08196017f, 
    -0.19825192f, -0.00476958f, -0.13189830f, 0.21238622f, 0.04142075f, -0.06808555f, -0.06630132f, 0.00181756f, 
    0.04212781f, 0.00161221f, 0.06856362f, 0.06217448f, 0.01347046f, 0.01695701f, -0.04880465f, -0.03563274f, 
    -0.43401527f, -0.52055383f, -0.17340919f, -0.21067914f, -0.24302125f, -0.09889954f, -0.07349900f, -0.06292399f, 
    -0.03988165f, -0.00850649f, -0.01893364f, 0.06028098f, 0.53411990f, 0.27434605f, -0.00479421f, 0.06230986f, 
    -0.09184621f, -0.05938035f, 0.20577197f, -0.03503418f, -0.08320352f, -0.04022944f, -0.12390435f, -0.08190743f, 
    -0.02175622f, -0.04925259f, 0.00637402f, 0.16224425f, -0.03355028f, -0.04934746f, -0.01502756f, 0.05602505f, 
    -0.07967235f, 0.01088164f, -0.15428682f, 0.01873382f, 0.02422588f, 0.05355468f, -0.23671964f, -0.07091406f, 
    0.06763010f, -0.06053969f, 0.08663736f, -0.24761355f, -0.18154921f, -0.03996300f, -0.04978886f, -0.15355533f, 
    0.49011809f, -0.24209541f, -0.31261843f, -0.45684507f, -0.01606904f, -0.14424312f, -0.04689045f, -0.18487915f, 
    -0.22652374f, 0.18012211f, 0.09034850f, -0.08512831f, -0.72321296f, 0.04576035f, 0.28622681f, 0.06278128f, 
    -0.12450060f, 0.03601103f, -0.11656859f, -0.01580405f, 0.00257996f, -0.02327954f, -0.05536139f, -0.08684794f, 
    0.31679839f, -0.10783778f, 0.01676730f, 0.20525514f, 0.07054743f, -0.02627916f, -0.02960887f, -0.07529904f, 
    0.02653570f, 0.06798710f, 0.07903909f, 0.25113079f, -0.73616493f, 0.57081091f, -0.09072136f, -0.79751796f, 
    0.26171711f, 0.27615970f, -0.13160314f, 0.15489189f, -0.24983610f, -0.12460010f, 0.00104785f, -0.14414248f, 
    -0.05408557f, -0.12572289f, -0.04576452f, 0.04861450f, 0.08011650f, 0.09390374f, 0.00308777f, 0.13697745f, 
    0.04367546f, -0.00524096f, 0.00482901f, -0.14665569f, -0.70777267f, 0.58246022f, -0.41178164f, 0.21993276f, 
    0.15663716f, -0.11978626f, 0.15074183f, -0.03352912f, -0.13690485f, -0.13327947f, -0.05899008f, -0.09214590f, 
    0.35940948f, 0.09266301f, 0.11198910f, 0.11625344f, 0.12707095f, 0.02093490f, -0.06020043f, -0.03729634f, 
    0.12899643f, 0.07886930f, -0.10269432f, 0.13704973f, 0.03791848f, -0.28109324f, 0.09719015f, 0.14626162f, 
    -0.08343174f, 0.07021510f, 0.08384305f, 0.16273822f, -0.04763119f, -0.02530248f, -0.13632604f, -0.04355940f, 
    0.13793994f, -0.23153789f, 0.10862441f, -0.12673679f, -0.23478340f, -0.04322304f, 0.10744556f, 0.08896367f, 
    0.06849205f, 0.06363115f, 0.08572487f, -0.01074771f, 0.24324277f, -0.08044667f, -0.01484180f, 0.09635301f, 
    0.05817415f, -0.18465662f, -0.16865592f, -0.11468092f, 0.06517106f, 0.09112225f, -0.11534008f, 0.04928632f, 
    0.07270941f, -0.09415394f, 0.07362568f, 0.06468731f, 0.01325956f, -0.13760592f, -0.10103188f, -0.00434510f, 
    -0.04012970f, 0.10653941f, -0.04729521f, -0.18236515f, -0.05283227f, -0.06094801f, -0.08767056f, 0.12857851f, 
    -0.04645804f, 0.02768465f, 0.02816588f, -0.02569747f, -0.07605044f, 0.02320817f, -0.02777586f, -0.12697291f, 
    0.27407879f, -0.13369633f, 0.30602533f, 0.23004656f, -0.04391697f, 0.03658034f, -0.30807844f, -0.02542485f, 
    -0.02683442f, -0.05554747f, 0.11349577f, -0.19936746f, -0.14978796f, -0.19397062f, -0.05132214f, 0.15116324f, 
    0.09333699f, 0.03982965f, -0.06585906f, -0.06257540f, -0.07974412f, 0.11107952f, -0.02136736f, 0.08340377f, 
    -0.27765894f, 0.06272587f, 0.55911165f, 0.46419489f, 0.02166699f, -0.05953550f, 0.07291554f, -0.05108436f, 
    0.04391905f, 0.02551582f, -0.04156307f, 0.01638628f, 0.03780189f, -0.19619477f, 0.27800420f, 0.09415071f, 
    -0.03505437f, 0.23282111f, -0.13352227f, 0.12543157f, 0.04603256f, -0.08522148f, 0.06026950f, -0.02527240f, 
    0.11546322f, 0.01467027f, 0.06203361f, 0.12910870f, -0.04133065f, -0.12847658f, -0.22429273f, -0.16050492f, 
    -0.10646006f, 0.12985283f, -0.09853554f, 0.03598923f, 0.04882446f, 0.03392343f, 0.15137687f, 0.19260561f, 
    -0.00966604f, -0.02824300f, -0.09788881f, 0.10660102f, 0.09304370f, 0.01987173f, -0.05425365f, 0.06193640f, 
    -0.19344898f, 0.16664633f, -0.00340735f, -0.07923494f, -0.05573004f, 0.18879105f, -0.19415277f, -0.18687069f, 
    0.01392260f, -0.20396501f, 0.09779626f, 0.06000485f, -0.33590454f, 0.01929350f, -0.11967362f, 0.14484932f, 
    -0.02197278f, 0.04418150f, 0.08917505f, -0.00439968f, -0.03133453f, 0.00963812f, -0.07041851f, 0.12671784f, 
    0.21462610f, -0.03943928f, 0.05082651f, 0.27188063f, -0.02294991f, -0.06291495f, -0.10583322f, 0.18114336f, 
    0.02095789f, -0.05209533f, -0.00590876f, 0.11843096f, -0.30208933f, 0.07560363f, -0.17765808f, 0.10245416f, 
    -0.03259167f, 0.05118157f, -0.17143869f, -0.03091591f, 0.05472576f, -0.04822576f, -0.26952806f, 0.10737932f, 
    0.10841843f, -0.31085846f, 0.16769168f, 0.15605180f, -0.08897250f, -0.16862534f, -0.15349485f, 0.08178742f, 
    0.04262036f, -0.13293065f, -0.15837909f, -0.01369529f, -0.36775067f, -0.26527423f, 0.07263648f, 0.18249148f, 
    -0.16022721f, 0.15252203f, -0.05278181f, 0.02940680f, -0.03362256f, 0.09574996f, -0.07507964f, 0.10661770f, 
    0.15987679f, -0.09781933f, 0.18230243f, 0.14285247f, -0.23655865f, 0.02404219f, -0.24491552f, 0.06645337f, 
    -0.01251411f, 0.19548111f, -0.02561671f, -0.01002953f, -0.00881338f, 0.14613391f, -0.01881544f, 0.16574062f, 
    0.03029054f, 0.23236205f, -0.18140860f, -0.00162679f, -0.08742110f, 0.08828204f, 0.07974990f, 0.06374889f, 
    -0.16666366f, 0.20776969f, -0.23628014f, -0.03183267f, -0.03910979f, 0.06939753f, -0.00469460f, -0.02815532f, 
    -0.25111139f, 0.13382316f, -0.02621346f, -0.03554045f, 0.16119681f, 0.35259089f, -0.03408953f, -0.44378334f, 
    0.24055202f, 0.14994565f, 0.11295702f, 0.07646455f, -0.43176287f, -0.00762447f, -0.03333209f, -0.08953623f, 
    -0.38925931f, 0.04704437f, 0.06760169f, 0.34610483f, 0.05783815f, 0.02770373f, 0.13617429f, 0.05260142f, 
    -0.00455157f, -0.01455274f, 0.09291505f, 0.02503652f, -0.09586370f, -0.22600047f, 0.05808050f, -0.19982222f, 
    -0.00009937f, -0.09439503f, -0.09469350f, -0.07942556f, -0.00419806f, 0.12977006f, -0.17050321f, -0.17580231f, 
    0.25429848f, -0.19132468f, 0.00099894f, 0.12530474f, 0.05282815f, 0.05281373f, 0.03384852f, -0.04396520f, 
    -0.03078246f, 0.00629317f, -0.10315102f, 0.03673831f, 0.03392287f, -0.12864999f, 0.33826730f, -0.05277788f, 
    0.03673977f, 0.16633159f, 0.00603422f, 0.06719543f, 0.05676820f, 0.02319606f, 0.09137136f, -0.23467012f, 
    0.03622789f, -0.15840685f, 0.16935268f, -0.14974450f, -0.07936206f, 0.02664441f, -0.24105127f, -0.02718735f, 
    0.04244907f, 0.03566650f, 0.18384221f, -0.06886487f, -0.10108010f, 0.01994426f, -0.43402326f, 0.01756203f, 
    -0.07514231f, -0.08272675f, -0.23430653f, -0.12775666f, 0.03266168f, -0.09538505f, -0.00187650f, -0.13679761f, 
    -0.16500117f, -0.02934911f, -0.14576043f, 0.09253433f, 0.07977464f, -0.00018242f, 0.14217442f, 0.11549833f, 
    -0.15392220f, -0.14657958f, -0.04266836f, 0.02112083f, 0.16076466f, -0.14051306f, -0.08793630f, 0.08715387f, 
    0.13910033f, -0.03194616f, 0.04591339f, -0.22760949f, -0.00444593f, 0.09143383f, -0.08318922f, 0.07426646f, 
    0.13967825f, -0.04526341f, 0.28118107f, 0.03127708f, -0.05289284f, -0.08943740f, 0.01730474f, -0.00845351f, 
    -0.00976091f, -0.07911772f, 0.00036910f, 0.08700498f, -0.31437564f, 0.22460903f, 0.20831978f, 0.20744236f, 
    -0.00095231f, 0.09200227f, -0.02966420f, 0.07148694f, -0.00411033f, 0.04289747f, -0.03644002f, -0.03106087f, 
    0.08543321f, -0.00409354f, -0.20183969f, 0.05780809f, -0.03286637f, 0.04821064f, 0.07265659f, 0.02086750f, 
    -0.06500289f, -0.12767451f, -0.15661983f, -0.14801653f, -0.33185989f, -0.06570940f, 0.03684390f, -0.17526822f, 
    -0.06388944f, 0.05771580f, 0.04621872f, -0.03836030f, -0.09088386f, -0.08890966f, -0.02174188f, 0.25146058f, 
    -0.16300327f, 0.00812697f, -0.11953578f, -0.20797558f, 0.00618244f, -0.00440336f, -0.07814046f, 0.11872098f, 
    0.03897557f, -0.31178379f, -0.06302340f, -0.22476749f, -0.42310083f, -0.07702708f, -0.22739474f, -0.03035705f, 
    -0.07907623f, 0.11484049f, -0.03534748f, -0.12878418f, -0.04337168f, -0.10266603f, -0.12028414f, 0.12003960f, 
    -0.18814079f, -0.08164957f, -0.27920404f, -0.05352456f, 0.05787987f, 0.02312524f, 0.01428220f, 0.07364839f, 
    0.07505056f, -0.03745988f, 0.06969479f, 0.24950857f, 0.12175673f, -0.00929781f, 0.02689181f, 0.29965621f, 
    0.01240196f, -0.07849460f, -0.08010806f, 0.06576557f, -0.28168944f, -0.11372413f, -0.14567383f, 0.00635110f, 
    -0.10419183f, -0.14738198f, 0.18085536f, 0.10849381f, -0.12068405f, -0.07158415f, -0.20366722f, 0.01052959f, 
    -0.28259671f, -0.02187275f, -0.07053795f, 0.07222281f, 0.16436329f, 0.31795719f, -0.44851270f, -0.06714492f, 
    0.08602677f, 0.08919478f, 0.06839632f, 0.17911878f, 0.00893092f, 0.02373282f, -0.04666417f, 0.01576932f, 
    0.28672433f, 0.14891997f, 0.05580264f, 0.14502677f, -0.11349826f, -0.15151031f, 0.02642253f, -0.17025997f, 
    -0.00598858f, -0.15643482f, -0.04355471f, 0.01956861f, 0.01427905f, 0.05889777f, 0.06152989f, 0.04101551f, 
    0.03883728f, 0.10220862f, 0.03537976f, 0.03294644f, 0.13410662f, 0.02987159f, -0.00645035f, -0.01868778f, 
    0.06634884f, -0.03074225f, -0.32586119f, -0.10023150f, 0.06670619f, 0.01070255f, 0.06066619f, -0.10914894f, 
    0.11762732f, 0.00796168f, -0.00713157f, 0.05156523f, -0.08402309f, 0.04348095f, -0.01095424f, 0.13404308f, 
    -0.00542670f, 0.05839184f, -0.04137663f, 0.01516761f, -0.04201457f, -0.03032513f, -0.13129523f, 0.10919091f, 
    0.01469534f, -0.14660935f, -0.16452168f, 0.02519645f, -0.04915982f, -0.01257579f, 0.06049651f, -0.00723595f, 
    -0.09995284f, 0.04793395f, -0.23022398f, 0.12993547f, -0.03001706f, -0.03640956f, -0.14918520f, -0.24335198f, 
    0.02008990f, 0.03228823f, -0.07845322f, -0.00977825f, 0.06856636f, -0.05869276f, 0.03478209f, -0.15206498f, 
    0.14733672f, -0.04506153f, 0.22403572f, -0.09580371f, -0.13318467f, 0.03995062f, -0.09386376f, 0.09362113f, 
    -0.18537822f, -0.13132343f, -0.04710250f, 0.01711679f, 0.06985462f, -0.29880729f, 0.02913097f, -0.08737412f, 
    -0.01443966f, 0.05821943f, -0.06058206f, 0.05257023f, -0.24375919f, -0.07270937f, 0.10686710f, -0.14961426f, 
    -0.36370546f, -0.05212127f, -0.36481586f, -0.08886989f, 0.02022193f, -0.04375952f, -0.10483624f, -0.02370653f, 
    -0.10073981f, 0.12573038f, -0.01016738f, -0.07986559f, 0.21236034f, 0.02052684f, -0.12743688f, 0.21379456f, 
    0.03161877f, -0.04041686f, 0.00862371f, -0.14996731f, 0.07098547f, -0.04109113f, 0.44011191f, 0.27219787f, 
    -0.13347302f, 0.10885376f, 0.18592025f, 0.11394415f, -0.09309988f, -0.08505999f, -0.03627411f, -0.04011375f, 
    -0.19214752f, -0.13046527f, -0.10678088f, 0.01678321f, 0.07255776f, 0.11860611f, 0.13486223f, 0.09374133f, 
    -0.11100006f, -0.07709322f, -0.01909898f, 0.07182367f, 0.04018051f, 0.02081899f, -0.01814071f, 0.05562967f, 
    0.14478585f, -0.14460337f, 0.16183244f, 0.12603799f, 0.00345607f, 0.01685265f, 0.07129439f, 0.00846620f, 
    -0.20619358f, -0.10041860f, -0.06940976f, -0.08400254f, -0.09645601f, -0.04055759f, -0.00318993f, 0.05281420f, 
    0.01241159f, 0.09146290f, 0.04000423f, -0.13838460f, 0.04679779f, -0.00410784f, 0.05240191f, 0.22993846f, 
    -0.06449145f, -0.07858241f, -0.02047062f, -0.00221326f, 0.11765332f, 0.09143534f, 0.05738186f, 0.08553978f, 
    0.08537704f, 0.06228861f, 0.04224650f, 0.07109833f, -0.50713360f, -0.12298445f, -0.05296468f, -0.22946241f, 
    0.01427634f, 0.09118742f, -0.38457456f, 0.18805930f, 0.05763062f, 0.13928643f, -0.01440175f, -0.14181069f, 
    0.09958299f, 0.14991309f, 0.08101684f, 0.12518461f, 0.10981354f, -0.11303389f, 0.07311273f, -0.19481231f, 
    0.02187834f, 0.00345599f, 0.06174760f, 0.07823666f, 0.01871604f, -0.00057250f, -0.13563564f, 0.00522639f, 
    -0.04632179f, -0.03743301f, -0.02373201f, 0.04065365f, -0.09223902f, -0.06419717f, -0.11422953f, -0.09213373f, 
    -0.02699508f, -0.04686960f, -0.09273273f, -0.02935387f, 0.05546862f, 0.00632186f, -0.29677120f, 0.01096250f, 
    -0.02004055f, -0.19666506f, -0.19945623f, -0.15705693f, 0.03854087f, 0.13641204f, -0.09151212f, 0.07713624f, 
    0.16202645f, 0.19706354f, -0.05270818f, -0.31279701f, 0.16149159f, 0.06491359f, -0.01897511f, -0.03752535f, 
    -0.23667818f, -0.01126757f, -0.01675806f, 0.11392140f, -0.15728760f, -0.12082190f, 0.00860225f, -0.14007729f, 
    0.03082041f, 0.00582735f, -0.03802158f, 0.03612211f, 0.20868030f, -0.23140790f, -0.08414374f, -0.00058072f, 
    -0.04526019f, -0.05620380f, 0.08089599f, -0.02987022f, -0.02437109f, 0.17344850f, 0.03088678f, -0.00013240f, 
    0.15877867f, 0.15003213f, 0.26856250f, 0.13771115f, -0.05015707f, -0.17343140f, -0.07368275f, 0.09467799f, 
    0.01011624f, -0.01439325f, 0.01565918f, 0.04816455f, -0.26074839f, -0.09056286f, -0.27759320f, -0.31024945f, 
    0.13063623f, 0.10350751f, 0.01601635f, 0.01890986f, -0.07360066f, 0.03957104f, 0.03267739f, -0.15418121f, 
    0.21886906f, 0.22157329f, -0.07207557f, 0.11946575f, 0.06771661f, 0.01183336f, 0.10791086f, -0.04955597f, 
    -0.12186790f, -0.26569554f, -0.13157250f, -0.06734716f, 0.13035847f, 0.37773752f, 0.02283779f, 0.16562082f, 
    0.12265643f, 0.10829710f, 0.07144551f, 0.03639656f, 0.01635053f, -0.06306683f, 0.00790615f, -0.03114982f, 
    0.14100632f, 0.22191058f, -0.24550119f, 0.20754234f, -0.12438913f, 0.09936120f, -0.10249119f, -0.13049552f, 
    0.05401229f, -0.07756622f, -0.12624539f, 0.06275890f, -0.11039195f, -0.09856924f, 0.00395752f, 0.04630641f, 
    -0.11077834f, -0.20258288f, 0.06153655f, -0.01906445f, 0.06150342f, 0.05627516f, 0.03647221f, 0.06248050f, 
    0.07086337f, 0.10164191f, 0.04141986f, -0.10070283f, -0.19321208f, -0.08887466f, -0.05608382f, 0.03209449f, 
    -0.12073068f, 0.06929050f, -0.04880729f, -0.07785197f, -0.04486914f, -0.14209716f, 0.04149616f, 0.08328552f, 
    -0.03366829f, 0.06895403f, 0.06208326f, 0.03321007f, 0.01310800f, -0.05371641f, 0.00116308f, 0.05725891f, 
    -0.09922597f, 0.20879096f, -0.22449407f, 0.18611249f, 0.06903224f, -0.00753002f, -0.02733238f, -0.01760333f, 
    -0.01198674f, -0.14678691f, 0.04739597f, 0.00719519f, 0.06480537f, -0.07638214f, 0.09533529f, 0.23260050f, 
    -0.03460870f, -0.12352194f, -0.01255871f, 0.02761620f, -0.08802947f, -0.00906193f, -0.00692482f, 0.08466717f, 
    0.15091306f, 0.11133652f, 0.01316885f, -0.10298890f, 0.09776038f, 0.04261407f, 0.24580821f, -0.19898124f, 
    0.07419156f, -0.01805855f, 0.03795755f, -0.07102241f, 0.06130222f, 0.34651247f, 0.06068253f, 0.36134848f, 
    0.11827251f, 0.05338586f, 0.19162862f, -0.01999230f, 0.06012647f, -0.11305717f, -0.01523469f, -0.12581450f, 
    0.03766654f, 0.07661869f, 0.05392303f, 0.03450108f, -0.07702727f, -0.01999480f, -0.00704950f, -0.04388515f, 
    -0.05921134f, -0.02069310f, -0.10397301f, -0.08261634f, 0.04873453f, 0.03983353f, 0.16541004f, 0.06028787f, 
    0.04901992f, -0.02438385f, -0.05232791f, -0.08218044f, 0.09911025f, -0.08541473f, 0.03908147f, -0.12926158f, 
    0.04465492f, 0.01167609f, 0.05699659f, 0.07212145f, 0.04568826f, 0.09248617f, 0.00446296f, -0.06267108f, 
    0.16924079f, 0.04297299f, -0.06049975f, -0.01809371f, 0.08777943f, -0.04212803f, 0.06799906f, 0.00923474f, 
    0.01667458f, -0.05772017f, 0.08207730f, -0.08881135f, 0.16322789f, -0.11161993f, -0.07671627f, -0.03972849f, 
    0.00624743f, 0.07168706f, 0.09185337f, 0.14870834f, -0.06027412f, 0.00386616f, -0.06406299f, 0.03477081f, 
    0.03022327f, 0.01281443f, 0.05923106f, -0.10565095f, -0.21434481f, -0.09389979f, 0.03844915f, 0.20834263f, 
    0.06255959f, 0.13252254f, -0.02519918f, 0.00788227f, -0.05775397f, 0.09196378f, -0.12930748f, -0.11916871f, 
    0.07406644f, 0.24788381f, -0.42212820f, 0.02557928f, -0.09858933f, 0.06512768f, 0.05775690f, -0.05754536f, 
    -0.11560179f, -0.06583025f, 0.02208501f, -0.17950979f, 0.01758645f, -0.05366810f, 0.18430953f, -0.10833445f, 
    0.04014915f, 0.01719664f, -0.03418210f, -0.11280364f, 0.07779562f, -0.16899361f, -0.03924045f, 0.13105507f, 
    -0.01918334f, -0.02303090f, -0.17071420f, -0.08273713f, 0.04463826f, 0.08704668f, 0.07294150f, -0.03037396f, 
    0.11783788f, -0.06710710f, 0.11805809f, 0.03337761f, 0.20841531f, -0.51595193f, 0.20042570f, -0.00966109f, 
    0.05073543f, -0.00269226f, 0.09523533f, 0.10081956f, -0.00412182f, -0.01602904f, -0.00779781f, 0.09933831f, 
    -0.16844217f, -0.28028864f, 0.25638410f, -0.06570350f, -0.11717506f, 0.01538452f, -0.03025045f, -0.15123485f, 
    -0.04315877f, 0.00415807f, 0.08634172f, 0.11914964f, 0.09650189f, -0.33575189f, 0.03051464f, 0.15778415f, 
    -0.12137364f, 0.01483418f, 0.07727325f, 0.00856333f, -0.02635217f, -0.00850900f, 0.04152560f, -0.12003503f, 
    0.00835992f, 0.01480764f, -0.01424940f, 0.01402518f, -0.00230498f, -0.04269535f, -0.08377887f, -0.00218442f, 
    0.06820110f, 0.04172847f, -0.17058560f, 0.19606921f, 0.02691040f, 0.00901066f, 0.03618237f, 0.04267829f, 
    -0.18010175f, 0.01630833f, 0.04893123f, -0.06500570f, 0.01664925f, -0.07670484f, -0.03182605f, -0.10926242f, 
    -0.06620899f, 0.05328123f, -0.03604497f, 0.01403950f, 0.02322844f, -0.02085816f, 0.02553633f, 0.16081066f, 
    0.10667904f, 0.01475539f, -0.00391295f, 0.10818329f, 0.11685708f, -0.59959716f, -0.53641009f, -0.04117862f, 
    0.04108186f, 0.00975125f, 0.07995941f, 0.04478023f, -0.09689561f, -0.09023595f, 0.00354208f, -0.02319671f, 
    0.11862728f, -0.43629673f, 0.08182281f, 0.29940397f, -0.11187315f, 0.00917831f, 0.08149283f, 0.01498801f, 
    0.06224308f, -0.01251299f, 0.04293954f, 0.01890565f, -0.13575099f, -0.22422282f, -0.24770859f, 0.04673235f, 
    -0.01400015f, -0.06701963f, 0.07324746f, -0.05737562f, -0.10017383f, 0.03443861f, -0.15510660f, -0.15231715f, 
    0.15163167f, 0.01999735f, 0.17972741f, 0.23957944f, -0.26130193f, -0.10201593f, -0.19723654f, 0.03349418f, 
    0.00924880f, 0.15629852f, -0.11721401f, -0.00251379f, -0.00473458f, 0.04880220f, 0.07175353f, 0.13904475f, 
    -0.13737415f, -0.03595592f, -0.08413912f, -0.00360767f, 0.07083634f, -0.14193575f, 0.01842086f, 0.06018300f, 
    -0.16118442f, -0.07581077f, -0.11730683f, -0.22508702f, -0.01236246f, 0.09485165f, -0.13339145f, 0.10504071f, 
    0.07884727f, 0.02869634f, -0.04297527f, -0.13086061f, 0.11620068f, -0.07949901f, -0.30447158f, -0.00676930f, 
    0.28335699f, -0.06562751f, -0.06208818f, 0.08131603f, 0.03539347f, -0.00270102f, 0.01593611f, 0.03251778f, 
    -0.09605428f, -0.14526413f, 0.13963971f, 0.00088290f, -0.10311064f, -0.04938597f, -0.04328607f, -0.02057685f, 
    0.20252739f, 0.04609796f, 0.09527053f, 0.08683600f, 0.53709221f, -0.29161635f, 0.10528761f, 0.20188852f, 
    0.06916682f, -0.00806615f, 0.09687565f, 0.08426357f, -0.02057144f, 0.04044714f, -0.12746938f, -0.20158310f, 
    0.07911000f, -0.12122221f, -0.07474215f, 0.08798017f, 0.07811432f, -0.08981729f, -0.10512404f, -0.07470232f, 
    0.09413600f, 0.05284208f, -0.10387747f, 0.41671082f, -0.02388187f, -0.29673731f, 0.26137847f, 0.29331020f, 
    -0.02164386f, -0.20589925f, -0.06445889f, 0.08978488f, -0.03206323f, 0.09791186f, -0.16411394f, -0.01478577f, 
    0.31101790f, -0.13703181f, -0.20795687f, -0.16150317f, -0.05055143f, 0.00725650f, 0.06366853f, 0.12695754f, 
    0.02671566f, -0.28821999f, -0.30407235f, -0.43438044f, -0.06174394f, -0.01193861f, -0.01046220f, -0.19628914f, 
    0.02525316f, 0.06680123f, -0.14293391f, 0.01998305f, 0.27271101f, 0.05328696f, -0.05166592f, -0.03448517f, 
    0.20622195f, -0.23020330f, 0.30290136f, 0.04882335f, 0.17873809f, 0.00566307f, 0.09986205f, 0.11020696f, 
    0.17039791f, 0.02603291f, -0.09082933f, 0.01308128f, -0.05118170f, 0.02333211f, -0.56993032f, 0.15584591f, 
    0.04715745f, 0.05631113f, 0.02243657f, -0.02710174f, 0.08309995f, 0.01130670f, -0.04150981f, -0.04016149f, 
    -0.52017289f, -0.22527437f, 0.05488727f, 0.00996812f, -0.04889719f, -0.01465206f, 0.01695839f, -0.09861538f, 
    0.10501955f, 0.02552508f, 0.06479182f, 0.14123148f, -0.04129232f, -0.08110644f, -0.14769602f, 0.05243820f, 
    0.04809245f, 0.01562821f, -0.02170299f, 0.02851715f, 0.11091116f, -0.09664205f, -0.08070895f, 0.23910850f, 
    -0.03734843f, -0.20856501f, 0.01158565f, 0.14598119f, 0.00065989f, 0.10315003f, 0.00503935f, 0.06078989f, 
    -0.05478006f, -0.00711965f, 0.24889627f, -0.17487195f, 0.15954496f, -0.12540942f, 0.14468719f, -0.15944774f, 
    -0.07321221f, -0.04633740f, -0.06689057f, 0.21814454f, -0.12785183f, -0.05290511f, -0.03501814f, -0.21512672f, 
    -0.07655859f, -0.09822029f, 0.20551698f, -0.12780534f, -0.04387125f, 0.03075375f, -0.03465584f, 0.09590907f, 
    0.10589030f, -0.14733194f, -0.02107316f, 0.14004335f, 0.19239652f, 0.19142628f, -0.14307322f, -0.18440124f, 
    0.00304920f, 0.22458011f, -0.06856544f, -0.02076614f, 0.06388859f, -0.22206393f, 0.11942556f, 0.00887096f, 
    -0.02484093f, -0.09461138f, 0.09191781f, -0.14671211f, 0.03614442f, -0.06030646f, -0.20093630f, -0.08714275f, 
    -0.13050145f, 0.12640555f, 0.02585673f, 0.03341508f, -0.03293451f, -0.06276349f, 0.08362093f, 0.15015320f, 
    0.10245234f, -0.05599437f, 0.04845618f, -0.03054881f, 0.26681489f, -0.06757791f, 0.03661371f, 0.10294659f, 
    0.10648178f, -0.01353461f, -0.49019396f, -0.13729165f, -0.00536315f, 0.06503925f, 0.04253773f, 0.06653359f, 
    0.26054868f, -0.10392451f, 0.00351256f, 0.11080742f, -0.12250168f, -0.05413821f, 0.07268402f, 0.01566423f, 
    -0.01374704f, -0.06040413f, 0.00724621f, 0.10718987f, 0.03607398f, -0.11925443f, -0.10821952f, -0.53653169f, 
    -0.14185826f, -0.14096697f, -0.29969531f, -0.25919536f, 0.11557879f, 0.03584208f, -0.00882604f, 0.12280700f, 
    0.06239936f, -0.09364940f, 0.08281723f, -0.05722753f, -0.04117500f, 0.22509225f, -0.06935105f, -0.07975387f, 
    0.07542022f, 0.07862295f, 0.12133145f, 0.09067854f, 0.03662774f, -0.01876926f, 0.07464880f, 0.03119556f, 
    0.10184406f, -0.07909495f, 0.21919698f, -0.13635413f, 0.06707360f, 0.28405780f, 0.10431986f, -0.20054127f, 
    0.13604322f, 0.06690461f, 0.06748267f, 0.14766143f, 0.19261476f, 0.02062893f, 0.21833710f, 0.16189048f, 
    0.00104738f, -0.20785651f, -0.08118030f, -0.07628829f, 0.09815503f, -0.02712971f, -0.10817631f, -0.27007237f, 
    -0.21779734f, -0.22792725f, 0.04853837f, 0.06142541f, -0.02135902f, 0.03641729f, -0.05720634f, 0.04639410f, 
    -0.05370895f, -0.00593966f, 0.08819740f, 0.00746942f, 0.00172507f, 0.07562290f, -0.34961322f, -0.13564922f, 
    -0.08537142f, 0.12277370f, -0.04275947f, -0.09890511f, 0.01386531f, -0.19600320f, -0.09660097f, 0.11239658f, 
    -0.02950723f, 0.08661537f, 0.12973812f, -0.38142616f, -0.06647670f, 0.01565227f, 0.01445154f, 0.07675767f, 
    0.03537313f, -0.03145437f, -0.07000158f, -0.06525522f, -0.16157196f, -0.23485352f, 0.06530232f, -0.01041009f, 
    -0.01711583f, -0.01784194f, 0.04270408f, 0.07721319f, 0.04683198f, -0.02714814f, 0.08663061f, 0.03048453f, 
    -0.16658957f, 0.55255473f, 0.19634141f, 0.23037092f, -0.02640317f, -0.13372746f, 0.04443752f, 0.20823406f, 
    0.17239781f, -0.14223355f, 0.13616428f, 0.31887633f, -0.11760267f, 0.06977633f, -0.20039187f, 0.19773702f, 
    0.04790063f, -0.02513577f, -0.01897605f, -0.05530591f, -0.13104004f, 0.08540924f, -0.08177827f, -0.03692937f, 
    -0.31983566f, -0.03835180f, -0.10368126f, -0.13189241f, 0.04361593f, -0.01503941f, 0.02367577f, -0.00215700f, 
    0.05021924f, -0.00024528f, -0.00897610f, -0.03423968f, -0.50250494f, -0.27413917f, 0.19973269f, -0.00851460f, 
    0.04221601f, 0.02554833f, -0.06243457f, -0.02147724f, 0.15715559f, 0.07546099f, -0.13334937f, 0.05998700f, 
    0.07128212f, 0.07475544f, 0.08723567f, -0.04840757f, 0.26390302f, 0.14332135f, 0.21603715f, -0.09419055f, 
    0.03625208f, -0.01415156f, -0.02984774f, 0.04473660f, -0.00813284f, -0.10048405f, -0.44813496f, -0.15120178f, 
    -0.02022202f, -0.03874481f, -0.01466975f, 0.09504488f, 0.08781821f, -0.04543392f, -0.07020922f, -0.04289502f, 
    -0.20793539f, -0.21519773f, 0.09910508f, 0.08948534f, -0.25319913f, -0.13207373f, -0.14639242f, -0.00933083f, 
    0.24773863f, 0.06352528f, 0.14501213f, -0.14096516f, 0.04236370f, 0.18836868f, 0.07736265f, 0.07169610f, 
    0.14063144f, -0.00605875f, -0.00388599f, 0.01901110f, 0.01614506f, 0.02948364f, 0.10163455f, -0.02369501f, 
    -0.08285142f, -0.15498310f, 0.05144322f, 0.25072926f, 0.02904602f, -0.13679667f, -0.20378049f, -0.03923382f, 
    -0.11552049f, -0.06843036f, -0.01032785f, -0.09966235f, -0.00716304f, -0.00019263f, -0.33104110f, -0.14273655f, 
    0.12691571f, 0.08343140f, -0.03624406f, 0.14232230f, 0.03818891f, -0.05099498f, 0.00296801f, 0.13165782f, 
    -0.10991886f, -0.38717100f, -0.01103408f, 0.18054752f, 0.10037611f, 0.00409828f, -0.07059696f, 0.07474661f, 
    -0.01031267f, -0.06301088f, -0.04312430f, 0.25795075f, 0.11407650f, 0.06793857f, 0.19540668f, 0.09414570f, 
    -0.14944652f, -0.00544203f, -0.06961313f, 0.10754435f, 0.05655155f, 0.04859646f, 0.05142940f, 0.06217436f, 
    -0.28087661f, 0.10767602f, -0.19782364f, -0.12439013f, 0.10875414f, -0.05998855f, 0.06688152f, 0.11761604f, 
    0.13463423f, 0.10406604f, -0.08918443f, 0.13115741f, -0.14139012f, 0.05200812f, -0.01163945f, -0.32295471f, 
    0.04454338f, 0.04042102f, 0.00702100f, 0.15963140f, -0.08943178f, -0.10457443f, -0.01112597f, -0.07567904f, 
    -0.06283148f, -0.11173490f, -0.13146670f, -0.18321645f, 0.24461532f, 0.20101365f, -0.11835407f, 0.16331843f, 
    -0.05751580f, -0.07446938f, 0.00240294f, -0.10583457f, -0.12956610f, 0.15989132f, 0.09767076f, -0.02770065f, 
    0.03536262f, -0.16012640f, 0.01562882f, -0.11605068f, -0.05075090f, 0.10246796f, 0.04845098f, -0.04546582f, 
    0.05362500f, -0.06901040f, -0.06194570f, -0.08459432f, 0.14446488f, 0.19715925f, -0.17039721f, 0.06392578f, 
    -0.04127017f, 0.07520686f, 0.08179730f, 0.09413214f, 0.17553987f, 0.23134899f, 0.21563429f, -0.40004572f, 
    0.16461812f, 0.16551122f, 0.14969143f, 0.09639896f, -0.06515579f, 0.05386771f, 0.06591876f, -0.02567077f, 
    0.01185963f, -0.10808554f, -0.07900210f, -0.07112708f, 0.04178641f, -0.07850017f, 0.24785838f, 0.23688900f, 
    -0.01018565f, 0.09411072f, 0.10816628f, -0.07017860f, 0.11304556f, -0.03182071f, -0.01626085f, -0.15013304f, 
    0.06111198f, 0.07446110f, -0.01427648f, -0.09229595f, -0.14940628f, -0.23372316f, 0.18493143f, -0.17201830f, 
    0.05214746f, -0.01039358f, -0.16276491f, -0.17001279f, 0.07374234f, -0.01214748f, 0.00611610f, -0.11003729f, 
    0.13119888f, 0.04609490f, 0.06616723f, -0.02024042f, 0.29673773f, 0.04308954f, -0.28885204f, 0.12774010f, 
    -0.13027813f, 0.10757433f, 0.13021389f, -0.04364038f, -0.08419794f, 0.00359830f, -0.02664900f, -0.19125247f, 
    -0.13421132f, 0.08944243f, -0.18424027f, 0.12634358f, 0.05655073f, -0.02648553f, -0.16440715f, 0.26204097f, 
    -0.06212848f, -0.11850426f, 0.14383943f, 0.18035646f, 0.10382188f, -0.05456978f, -0.30565581f, 0.02188460f, 
    0.00089175f, 0.09693601f, -0.00150393f, -0.11292604f, -0.08501968f, -0.25497189f, 0.06487326f, -0.35293883f, 
    0.23732060f, -0.16714495f, -0.07973879f, -0.03561029f, -0.02432787f, 0.03872575f, 0.03911385f, 0.01270446f, 
    0.01969244f, 0.00488089f, -0.06016689f, -0.11884694f, -0.44163370f, 0.34318775f, 0.22926585f, -0.05366147f, 
    -0.05843609f, -0.02242252f, -0.02198929f, 0.07453095f, 0.03036980f, -0.02101496f, -0.04992608f, -0.13391496f, 
    -0.10182393f, 0.06780450f, 0.17971542f, 0.01980950f, 0.02220584f, -0.18358900f, -0.05927022f, -0.05398025f, 
    -0.06255551f, 0.09510669f, 0.03711130f, -0.23188743f, -0.26668882f, 0.02815299f, 0.02283492f, -0.01006082f, 
    0.06131940f, -0.05447575f, -0.01777765f, -0.14789955f, 0.00300601f, -0.02940248f, 0.19768296f, 0.11980496f, 
    0.07934721f, 0.09202671f, -0.14720441f, -0.11454224f, 0.07870195f, 0.13542332f, -0.08153599f, -0.08810386f, 
    -0.11541734f, -0.02438786f, 0.05529211f, -0.26988861f, -0.06999151f, -0.09951220f, -0.03767280f, 0.10953954f, 
    0.18795253f, -0.03220371f, 0.14485617f, -0.15121888f, 0.04181911f, 0.04523951f, 0.16309083f, 0.14167549f, 
    -0.11605655f, -0.13720244f, -0.15709925f, -0.02269262f, 0.03320667f, -0.03377755f, 0.01043647f, 0.11048763f, 
    -0.26278991f, -0.05040945f, 0.12834819f, -0.11527918f, 0.12621729f, -0.30205831f, -0.51483113f, -0.11484329f, 
    -0.03625724f, -0.02453601f, -0.01361096f, -0.03138931f, 0.08863365f, -0.15607469f, -0.12360541f, 0.02631595f, 
    -0.41427964f, 0.13350771f, -0.37396938f, 0.09645271f, 0.09457439f, -0.14502943f, 0.03319861f, 0.04848655f, 
    0.01024638f, 0.03690435f, -0.06810138f, 0.14936864f, 0.04067807f, -0.09952746f, -0.14836101f, 0.17643833f, 
    -0.07157699f, -0.13612783f, -0.03501366f, 0.17068516f, 0.01674176f, -0.06562573f, -0.02044373f, 0.23639864f, 
    0.09561702f, 0.25859633f, 0.13198850f, -0.26595390f, 0.10280919f, 0.11059811f, 0.07562923f, -0.15143025f, 
    -0.02618778f, 0.10901680f, 0.00193945f, 0.04511908f, -0.40566209f, 0.14502656f, -0.02600851f, -0.14765903f, 
    -0.08271258f, -0.04743623f, 0.14462973f, 0.04006304f, 0.07859610f, -0.11453023f, -0.12848371f, -0.07334493f, 
    -0.44275746f, 0.54958200f, 0.18749627f, 0.05930703f, -0.00388491f, -0.06906494f, -0.02673739f, -0.15328994f, 
    -0.01671696f, 0.00444518f, 0.09036451f, 0.15210459f, 0.32233149f, -0.22407712f, -0.09898115f, -0.15961184f, 
    -0.00765729f, 0.01557113f, 0.21695103f, -0.06904216f, -0.03852709f, -0.02079871f, -0.03615844f, -0.04381733f, 
    -0.05783569f, -0.06253112f, -0.09780718f, 0.16929169f, 0.06575544f, -0.02626927f, -0.02529625f, 0.02818322f, 
    0.02070089f, 0.00986247f, 0.04096409f, 0.00326207f, -0.09976969f, 0.11204261f, -0.23346935f, -0.24133012f, 
    -0.02949985f, 0.01263318f, -0.08289649f, 0.04277756f, -0.14504324f, -0.00766839f, 0.05277830f, 0.08505902f, 
    0.17421745f, -0.04614276f, 0.06304130f, 0.58494580f, -0.02421300f, -0.07513811f, 0.01739421f, 0.13170822f, 
    0.01308517f, 0.07382669f, 0.05888667f, -0.11784931f, 0.02477407f, -0.24477859f, -0.13805470f, 0.11594143f, 
    -0.09891834f, 0.02664052f, 0.03574986f, 0.02246225f, -0.05987941f, 0.04151323f, -0.03715168f, -0.09556133f, 
    0.07629064f, 0.11738516f, 0.02540251f, 0.07732873f, -0.00086720f, 0.04945741f, -0.08639856f, 0.01913054f, 
    0.07420535f, 0.16977225f, 0.23235159f, 0.00012725f, 0.24852692f, 0.34385607f, -0.02271948f, 0.09608028f, 
    0.06674058f, -0.12936312f, 0.14162567f, 0.18212168f, 0.03296479f, 0.09643220f, 0.12504990f, -0.07903848f, 
    -0.37013438f, -0.21164140f, -0.26121992f, 0.50582397f, 0.07062072f, 0.15839531f, 0.12620847f, 0.00512849f, 
    0.05121461f, -0.03187544f, 0.01627148f, 0.12497062f, -0.09882899f, -0.40305585f, -0.04696433f, 0.00821826f, 
    0.08421583f, 0.07159002f, 0.17056446f, -0.23713753f, -0.03575706f, -0.05302487f, -0.02912403f, 0.07274907f, 
    -0.29770863f, 0.10501140f, 0.43626383f, 0.05712143f, -0.00131401f, -0.08156683f, -0.09604584f, 0.12498149f, 
    -0.21085490f, 0.00408320f, 0.10478083f, -0.03111710f, 0.29301685f, -0.01420935f, 0.03448449f, 0.07052594f, 
    -0.05445072f, -0.05620996f, 0.12987620f, -0.01278282f, 0.00475878f, -0.01021559f, -0.06733666f, -0.25594592f, 
    0.07364083f, 0.01609688f, 0.07183446f, -0.12307058f, 0.03034142f, 0.04520775f, 0.10092006f, -0.01185483f, 
    -0.02053820f, -0.07260589f, -0.04700572f, -0.02801086f, -0.28150573f, -0.19043332f, -0.46673805f, 0.39503396f, 
    -0.09199438f, 0.23360370f, 0.16342051f, 0.17685694f, 0.08261859f, -0.00819285f, 0.14365958f, -0.13037540f, 
    0.07227546f, -0.12606424f, -0.11524323f, 0.08649988f, -0.05872787f, 0.01326617f, 0.04844049f, 0.10416398f, 
    -0.05957288f, 0.05305800f, -0.07006045f, -0.04817311f, -0.02348353f, -0.03352192f, -0.05240475f, -0.23180157f, 
    -0.09320044f, -0.02117579f, -0.10155848f, 0.15532349f, -0.06474029f, 0.01392783f, 0.00974624f, -0.12967043f, 
    -0.20724057f, -0.08224592f, -0.20371236f, 0.17888573f, 0.09907547f, -0.07973705f, -0.04056534f, 0.09459900f, 
    0.04137462f, 0.03796482f, 0.00920044f, 0.03724320f, -0.05501949f, -0.02049193f, 0.06395428f, -0.00815713f, 
    -0.01132771f, -0.05970352f, -0.01413091f, 0.22728805f, -0.00439358f, 0.08584526f, 0.11587499f, -0.06878756f, 
    0.39137328f, 0.14616621f, 0.15803978f, 0.02075778f, 0.11588260f, -0.10985279f, 0.12879412f, -0.00313211f, 
    0.11993064f, 0.07419597f, 0.10022496f, -0.00235728f, 0.00666177f, -0.08794458f, -0.17272271f, -0.00203155f, 
    -0.03330570f, 0.08192464f, 0.04342350f, 0.15315542f, 0.06796902f, 0.14349374f, 0.15580767f, -0.02156273f, 
    -0.16510256f, 0.26389390f, 0.18163998f, 0.17001383f, 0.01910548f, 0.01455063f, -0.04412318f, 0.14083852f, 
    0.03692309f, 0.13055694f, -0.18499087f, 0.12712307f, -0.34787288f, -0.45601445f, -0.46765122f, -0.40822676f, 
    -0.21522956f, -0.01385905f, -0.19045532f, -0.24319978f, 0.01967401f, -0.03840503f, 0.02056528f, -0.00248552f, 
    -0.34717241f, -0.30951622f, -0.01589997f, 0.10911158f, 0.01126308f, 0.07728764f, -0.10418066f, -0.19384757f, 
    0.02484976f, 0.03334307f, -0.00119239f, -0.09539758f, -0.27903736f, -0.50815523f, -0.63975835f, -0.15665990f, 
    -0.28133318f, 0.15847433f, -0.01048268f, -0.28102180f, -0.12895015f, -0.11031007f, 0.13647908f, -0.09508115f, 
    0.00024507f, -0.01882322f, -0.09225497f, -0.09156188f, -0.00647903f, 0.02809478f, 0.00696851f, -0.01210283f, 
    -0.06545821f, -0.11956125f, -0.17438777f, -0.12359393f, -0.11032690f, 0.14020361f, -0.06994917f, -0.17928720f, 
    -0.01062860f, -0.05379467f, -0.03112821f, 0.16255336f, 0.11567994f, 0.15579338f, -0.08561092f, -0.11033973f, 
    -0.18781574f, -0.54015088f, -0.30286342f, -0.23599140f, -0.09375495f, -0.27311015f, 0.09894144f, -0.09303863f, 
    0.03100416f, 0.04201781f, 0.04334923f, -0.07298335f, -0.14346366f, 0.18825437f, 0.08129508f, 0.08912278f, 
    -0.00995283f, 0.02085794f, -0.03920522f, 0.06966954f, 0.08999760f, 0.02574383f, 0.07911441f, -0.04698301f, 
    -0.14056240f, -0.12127860f, 0.35788721f, -0.20354828f, -0.02524344f, -0.16925330f, 0.10595116f, 0.05762589f, 
    0.02897812f, 0.04588374f, 0.06376187f, -0.07258381f, 0.31478137f, -0.04083455f, -0.05711761f, -0.24791311f, 
    0.09655286f, -0.07663404f, 0.12282411f, -0.01837773f, 0.05762568f, 0.02381980f, -0.00679879f, 0.01185817f, 
    -0.49339357f, -0.49769124f, -0.30241179f, 0.08607402f, -0.04458696f, 0.04392496f, -0.11243978f, -0.10163424f, 
    0.01667583f, -0.00389209f, 0.03233012f, -0.07867704f, -0.08700389f, -0.01877169f, 0.31307551f, -0.11670722f, 
    0.00406382f, 0.02818260f, -0.02265842f, 0.03113577f, 0.13831975f, 0.10848541f, 0.01451119f, -0.02774137f, 
    -0.59193784f, -0.29698771f, -0.22226925f, -0.10204174f, -0.31374639f, -0.33318281f, -0.44594344f, -0.35385203f, 
    -0.06472999f, -0.05792728f, -0.01905902f, -0.02763011f, -0.19345330f, -0.07043055f, 0.01732351f, 0.08453146f, 
    0.06977273f, 0.05962228f, 0.02022102f, 0.07467097f, 0.03238194f, -0.06475426f, -0.00765741f, 0.11096074f, 
    -0.07487236f, -0.08114882f, 0.07292600f, 0.11259164f, 0.00626383f, -0.09283689f, -0.14533736f, 0.06751686f, 
    0.04860466f, 0.15119796f, 0.03218145f, -0.03778504f, -0.45663559f, -0.69087201f, -0.34892619f, -0.21675116f, 
    -0.07478954f, 0.23914428f, 0.04847033f, -0.24357794f, 0.00746996f, -0.05574914f, 0.01547099f, 0.02487194f, 
    0.13516594f, -0.22403339f, -0.32687426f, 0.09267151f, -0.26800719f, 0.12162223f, 0.20628953f, 0.03155093f, 
    -0.07308678f, -0.06181122f, 0.06180411f, 0.05359884f, -0.26834971f, -0.16058205f, -0.14334184f, 0.01600834f, 
    -0.05936094f, -0.07370562f, -0.09807597f, -0.05224077f, 0.06245156f, 0.00731561f, 0.02472918f, -0.04928492f, 
    -0.07295882f, -0.00163375f, 0.02061718f, 0.25124803f, 0.07956715f, -0.18919359f, 0.24192838f, -0.06480018f, 
    0.01634514f, -0.02431612f, -0.08085380f, 0.06251345f, -0.01835565f, -0.34361640f, -0.46130678f, -0.16152267f, 
    -0.13768308f, -0.06353131f, -0.11617297f, -0.02910017f, -0.05869018f, 0.00008924f, 0.05843987f, 0.04468129f, 
    0.21871078f, -0.09248564f, 0.18403143f, 0.04368165f, -0.04511227f, -0.23284322f, -0.00228597f, -0.11934584f, 
    0.00806561f, -0.15583503f, 0.03841652f, -0.08125857f, -0.53290313f, -0.27007627f, 0.16281345f, 0.05192087f, 
    -0.12173676f, 0.05940780f, 0.08161791f, 0.05561814f, -0.01728935f, 0.06244652f, -0.08983529f, 0.02550924f, 
    0.01931704f, -0.07863843f, -0.05860949f, -0.08358037f, 0.11622644f, 0.03256678f, 0.09289081f, -0.10916451f, 
    -0.03925826f, -0.06101834f, -0.01569761f, 0.00756657f, -0.13017651f, -0.80753148f, -0.41828358f, -0.48172015f, 
    0.10750190f, 0.22523372f, 0.06419639f, -0.23846138f, 0.07406436f, -0.06767766f, -0.02733454f, -0.03034279f, 
    -0.01059523f, -0.03447344f, 0.05900785f, -0.02771747f, -0.12984185f, -0.13046351f, -0.01384610f, -0.13068512f, 
    -0.01763894f, 0.01481430f, -0.08516033f, -0.02476258f, -0.19306599f, -0.49955744f, 0.10152840f, 0.07675386f, 
    0.05243913f, 0.09461962f, 0.03205543f, -0.13714287f, 0.02617759f, 0.03904105f, 0.07575776f, 0.06051513f, 
    0.21558306f, -0.03648970f, -0.08974079f, -0.02876868f, -0.22508720f, -0.03234288f, 0.03713537f, -0.02045042f, 
    0.11790791f, -0.01209266f, -0.05557282f, 0.05363799f, 0.25259644f, 0.30909744f, -0.08375081f, -0.13586809f, 
    0.05853854f, -0.01104726f, -0.03514309f, -0.04262703f, 0.01930590f, -0.00195533f, 0.00670768f, -0.00306486f, 
    -0.38415959f, 0.04951143f, -0.25878119f, -0.31644216f, 0.09311754f, -0.40405571f, -0.05464472f, 0.00306087f, 
    -0.05179753f, -0.00472672f, 0.05582454f, -0.00333952f, 0.52995205f, -0.25784743f, -0.19270559f, 0.01414463f, 
    0.04143231f, -0.11317690f, 0.15872534f, 0.00230879f, 0.11519632f, -0.02627848f, -0.03051855f, -0.08083666f, 
    0.18953900f, -0.16780666f, 0.11117668f, -0.18282554f, -0.15512072f, 0.00706032f, 0.15846407f, -0.08629754f, 
    0.06481562f, 0.00583091f, 0.11236561f, 0.16885607f, 0.01210177f, 0.19512138f, 0.06021490f, -0.23496068f, 
    0.03274973f, 0.07561796f, 0.11443924f, -0.21974359f, 0.13995197f, 0.21383715f, 0.06031615f, 0.06006826f, 
    -0.03943715f, 0.10886062f, 0.00270508f, -0.11676119f, 0.01785334f, 0.01326443f, 0.07104047f, 0.02983043f, 
    -0.11910050f, -0.01278759f, 0.03022963f, -0.05495900f, -0.35477597f, -0.27445516f, -0.10904198f, 0.22849903f, 
    0.13656060f, 0.07178439f, 0.05683666f, -0.24850218f, 0.02076290f, -0.02836335f, 0.05446959f, 0.08947761f, 
    -0.05636430f, -0.49884269f, 0.02105706f, 0.15264058f, -0.19073866f, 0.01308641f, 0.09085486f, -0.13516919f, 
    -0.01720610f, 0.12564991f, -0.02020452f, 0.03245258f, -0.05982485f, 0.03266840f, -0.07340753f, 0.22098716f, 
    0.14482343f, 0.01352085f, -0.09979416f, 0.03816018f, -0.02383220f, 0.02934406f, 0.11541900f, 0.01507025f, 
    -0.08286720f, 0.30984604f, 0.13611111f, 0.06232179f, 0.02947026f, 0.01673434f, -0.02404458f, -0.10768650f, 
    -0.00550927f, -0.02805614f, 0.09265389f, 0.10033927f, 0.10641848f, -0.03466287f, 0.00548843f, -0.05815900f, 
    -0.05810962f, 0.04823121f, 0.04989078f, 0.07483979f, 0.11243790f, -0.12368087f, 0.09588205f, -0.08822078f, 
    0.10727007f, 0.18740970f, 0.11214716f, 0.10875269f, -0.01257907f, 0.05313632f, -0.03246876f, -0.05492501f, 
    0.02994393f, 0.03663799f, -0.04509348f, -0.04499256f, 0.04494039f, 0.05923320f, 0.11579323f, -0.03760767f, 
    0.02797846f, -0.01802602f, 0.02595002f, -0.03564487f, -0.13563779f, -0.00728329f, 0.06368921f, -0.04932275f, 
    -0.16600533f, -0.37108269f, -0.51536590f, -0.32341343f, 0.01903088f, 0.01370716f, 0.16737953f, -0.03910230f, 
    -0.07525361f, 0.04771625f, -0.01335823f, -0.05878310f, 0.24434732f, -0.02914149f, -0.03971843f, -0.13703769f, 
    -0.01198997f, -0.08605742f, 0.14508556f, 0.06369613f, 0.03701174f, 0.11195994f, -0.26113200f, -0.02374583f, 
    -0.49120080f, -0.56204087f, 0.12538671f, 0.09400316f, -0.07670049f, -0.13937065f, -0.11562718f, -0.13325384f, 
    0.03838519f, -0.00097899f, -0.01305284f, 0.08313815f, -0.25786152f, 0.20843132f, 0.19372414f, 0.14517620f, 
    -0.01080800f, 0.07011163f, 0.03786140f, 0.00431058f, -0.01158399f, 0.02927892f, 0.16463163f, 0.02640961f, 
    -0.01330876f, -0.30803007f, -0.16250187f, -0.05795442f, -0.02554037f, -0.00470693f, 0.01028664f, -0.02053509f, 
    0.00572909f, -0.00395390f, -0.03841839f, 0.07118434f, -0.03900728f, 0.07166433f, -0.01755705f, -0.11088278f, 
    -0.03040893f, 0.04507502f, -0.09935319f, 0.00728007f, 0.03827197f, 0.03657934f, 0.00434743f, 0.01164882f, 
    0.19682471f, -0.13925061f, 0.19972768f, -0.30949974f, 0.06810535f, -0.00149611f, 0.03268234f, 0.05729540f, 
    -0.03339399f, -0.03758115f, 0.00805952f, -0.14726394f, 0.12287577f, -0.16086209f, 0.21054657f, 0.05352098f, 
    0.03617196f, -0.05496310f, -0.08093543f, -0.06169583f, 0.08864856f, -0.13381340f, -0.01285717f, 0.01702582f, 
    -0.39314911f, 0.04709844f, -0.19518185f, 0.03706151f, -0.05732941f, 0.09448215f, 0.10383732f, 0.02859135f, 
    0.02001131f, -0.19512291f, 0.00626946f, -0.08183767f, 0.32480052f, -0.40029901f, -0.01530549f, 0.10693695f, 
    -0.02199034f, 0.03103272f, -0.05003691f, -0.16507754f, -0.10727406f, 0.05757279f, -0.10633893f, -0.04408497f, 
    -0.09473611f, -0.04562674f, 0.13865381f, 0.09285423f, 0.01302431f, -0.01983548f, 0.00343747f, -0.10354183f, 
    0.08310378f, -0.04122094f, 0.10620838f, 0.01113036f, -0.17724848f, -0.31343675f, 0.08956584f, -0.17214508f, 
    -0.04926748f, 0.05514279f, 0.05889513f, 0.02978269f, -0.08814009f, 0.13944042f, -0.01743134f, 0.09095974f, 
    0.42641604f, -0.60760099f, 0.00034532f, -0.13536938f, 0.01545373f, 0.13788116f, -0.02299997f, -0.09251172f, 
    0.01223223f, 0.07197288f, 0.02080879f, -0.06655587f, -0.03766803f, 0.27799067f, 0.05256402f, -0.11437695f, 
    -0.00154168f, -0.08494031f, 0.00308421f, -0.05939518f, 0.01776998f, 0.03021965f, 0.04614621f, 0.07189564f, 
    0.51439130f, -0.21557206f, -0.33727664f, -0.35476249f, -0.18712685f, -0.09074120f, -0.08980799f, 0.04908230f, 
    0.01290318f, 0.09425217f, -0.03239182f, -0.04471913f, 0.00364067f, 0.10934896f, 0.01466485f, -0.03206782f, 
    0.01340336f, 0.01956655f, -0.02752280f, 0.03953552f, 0.04459215f, -0.02070912f, -0.03431640f, -0.04435608f, 
    -0.01969288f, 0.11685760f, 0.01932437f, -0.00371877f, -0.04954331f, -0.11183402f, -0.01177774f, -0.03553662f, 
    0.07213051f, -0.10296325f, 0.07949664f, 0.00664231f, -0.39132589f, -0.46886024f, -0.28819001f, -0.32223061f, 
    -0.01285947f, 0.06167732f, 0.11141143f, -0.01497876f, 0.00891456f, -0.00697090f, -0.08302055f, 0.00092979f, 
    0.11345202f, -0.17877384f, 0.12124869f, -0.17378321f, 0.00242090f, 0.00588066f, -0.01042419f, -0.03439503f, 
    -0.13910066f, -0.02497058f, -0.01108980f, 0.01343156f, -0.26421797f, 0.00413829f, 0.04290332f, -0.02871927f, 
    0.05267921f, -0.03482215f, 0.01132595f, 0.02230676f, 0.11168667f, -0.03689750f, 0.07294924f, 0.00058619f, 
    -0.02771588f, 0.03588358f, 0.08767776f, -0.08113387f, 0.09145328f, -0.20857517f, -0.01083065f, 0.06877263f, 
    -0.27185059f, 0.09878106f, -0.03576268f, 0.00468061f, 0.05087400f, 0.00224084f, -0.03934582f, -0.07654779f, 
    -0.04256900f, 0.02210045f, 0.02310910f, -0.02115975f, -0.01083301f, -0.04392481f, 0.03293205f, -0.27416986f, 
    -0.18728545f, 0.17281008f, -0.04168307f, 0.22671901f, 0.00264403f, 0.03208420f, 0.02422610f, -0.03464266f, 
    -0.06456817f, -0.15635888f, -0.00005394f, -0.03105189f, 0.23492506f, -0.01895752f, 0.04177575f, -0.06451662f, 
    0.00072088f, 0.01302684f, 0.00274069f, -0.01957059f, 0.13552155f, 0.00544677f, 0.05123805f, 0.07898670f, 
    -0.02330222f, -0.01886895f, -0.04130109f, -0.10918694f, -0.12687156f, -0.05006592f, 0.03042911f, -0.01216612f, 
    0.10236222f, 0.00507974f, -0.04088104f, 0.02010092f, -0.24448499f, -0.18412295f, -0.22779182f, -0.02760991f, 
    0.24086598f, -0.05851402f, 0.04403141f, -0.02938367f, 0.05332072f, 0.00224335f, -0.03930471f, -0.01294199f, 
    -0.01209195f, -0.26730791f, 0.36359632f, -0.19251263f, -0.18365751f, 0.08123463f, -0.06684469f, 0.01731999f, 
    -0.04940289f, 0.05499469f, -0.00848956f, -0.04564665f, -0.06922615f, -0.27945226f, -0.26817599f, 0.25312346f, 
    0.16145790f, 0.05464636f, 0.11044971f, 0.01944395f, 0.06737252f, -0.02476851f, -0.08487766f, 0.02997779f, 
    0.04371523f, 0.03515306f, 0.03524543f, -0.09200111f, 0.00589437f, -0.03677212f, -0.04295656f, -0.03988643f, 
    0.04523752f, 0.00629642f, 0.02107353f, -0.02013974f, -0.28642642f, 0.01396478f, -0.12916653f, 0.18440893f, 
    -0.05073814f, 0.03244121f, 0.15281439f, -0.04829555f, 0.00333326f, 0.10799382f, -0.00037587f, 0.08401600f, 
    -0.35125181f, -0.18196674f, 0.40359065f, 0.35047263f, 0.01867222f, 0.04015099f, -0.18675855f, 0.03601294f, 
    -0.03844640f, -0.14265209f, 0.03497376f, 0.07738508f, 0.24506952f, -0.07358050f, -0.08272143f, -0.18087700f, 
    0.06218519f, -0.10638255f, 0.02670904f, -0.10784750f, -0.00615091f, 0.13486728f, -0.18733469f, -0.07322309f, 
    0.43045211f, 0.28014994f, -0.33436200f, 0.03450185f, -0.12777080f, -0.07347483f, 0.21056738f, -0.14025055f, 
    -0.16732118f, -0.01886130f, -0.06164879f, -0.18130016f, -0.12973964f, 0.15637536f, -0.07067675f, 0.00630518f, 
    -0.12661543f, 0.02176662f, 0.09512532f, 0.08480625f, -0.00171160f, 0.05858513f, 0.10159537f, 0.02841434f, 
    -0.00421291f, -0.36775237f, -0.41495684f, -0.35445127f, -0.01419896f, -0.04900252f, -0.08348344f, 0.06546364f, 
    0.04047967f, -0.02490335f, -0.05315330f, -0.04680504f, 0.19311506f, 0.10375840f, -0.01992708f, -0.26400480f, 
    0.02186745f, 0.08474597f, -0.07713365f, 0.03586573f, 0.02560299f, 0.01889793f, 0.06530727f, -0.14811043f, 
    -0.40674359f, -0.32553533f, -0.21237187f, 0.12713368f, 0.06301688f, -0.07763784f, 0.04396992f, 0.01961313f, 
    -0.00307935f, 0.06689283f, -0.00202710f, 0.03627519f, 0.14358418f, 0.02941983f, 0.11983477f, -0.06421028f, 
    0.03083753f, 0.01686136f, 0.07301238f, 0.01074015f, -0.08367046f, -0.02177936f, -0.02274129f, -0.07110973f, 
    0.19774225f, -0.08727976f, -0.10330679f, -0.01656557f, -0.00531023f, 0.03387360f, 0.05300452f, 0.01284122f, 
    -0.02777008f, -0.00053046f, 0.15172194f, 0.05478881f, -0.37082875f, 0.07242984f, -0.27822933f, 0.60071915f, 
    0.12964584f, 0.08349060f, 0.09540857f, 0.00325552f, 0.03270964f, -0.09167803f, -0.07928737f, -0.04860372f, 
    0.00601309f, -0.07369605f, -0.03983457f, -0.03989546f, -0.05400093f, 0.10322597f, 0.01286894f, -0.04483191f, 
    -0.03592610f, 0.02622459f, -0.05118503f, 0.06023123f, -0.05056528f, -0.22952564f, -0.26368803f, -0.19316085f, 
    0.03796019f, -0.05904559f, 0.07561214f, -0.02472769f, 0.06204538f, 0.11299101f, 0.02086113f, 0.05203494f, 
    0.22827590f, 0.03782885f, -0.16654049f, -0.13050811f, 0.00012578f, 0.11442040f, -0.04186937f, -0.07938389f, 
    0.05880573f, 0.10833093f, -0.03557973f, -0.00116915f, -0.18987441f, -0.27205667f, 0.42880392f, 0.23856510f, 
    -0.02552251f, 0.03678129f, -0.13958457f, 0.03408818f, -0.04458030f, -0.08908515f, -0.09869986f, -0.05887917f, 
    -0.16530341f, 0.25671074f, -0.01275661f, 0.06313946f, -0.16338269f, 0.05705381f, 0.19384055f, -0.04372665f, 
    -0.09514794f, 0.02599239f, 0.10651746f, 0.09153908f, -0.07149929f, -0.54957974f, 0.06825401f, -0.33191693f, 
    -0.07232816f, 0.05907813f, -0.05852246f, 0.19921665f, 0.00507933f, -0.09795794f, -0.07042938f, -0.03373731f, 
    -0.12741750f, 0.11040397f, 0.10068467f, 0.00303729f, -0.01577397f, -0.15941389f, -0.07160572f, 0.17891467f, 
    0.08244684f, 0.06435421f, 0.06970633f, -0.01835673f, -0.87795067f, 0.39666075f, -0.42561880f, 0.46044970f, 
    -0.07367049f, -0.05224501f, -0.06812923f, 0.03789804f, 0.05202939f, -0.11471000f, 0.03578992f, -0.04039323f, 
    -0.01891682f, 0.03119921f, 0.05604528f, 0.04803845f, -0.05055748f, -0.11283364f, -0.12066045f, -0.04103782f, 
    0.00163636f, 0.03014060f, 0.03421319f, 0.02811827f, -0.29377243f, -0.00686795f, 0.07398021f, -0.17994621f, 
    0.10280228f, -0.03563011f, 0.01805666f, -0.02174957f, -0.00066755f, -0.02166238f, 0.10603625f, 0.01968186f, 
    -0.09471962f, -0.00186186f, 0.00455570f, -0.02306228f, -0.08831937f, -0.09906913f, -0.08307060f, -0.05645129f, 
    0.03891376f, -0.00558927f, 0.05850125f, 0.00651003f, -0.13164037f, -0.25764623f, 0.11943328f, -0.04109783f, 
    0.02971206f, -0.03037302f, -0.04370803f, -0.09789588f, -0.22442596f, -0.08614022f, 0.10689889f, 0.03229767f, 
    -0.57260990f, 0.09836622f, -0.22097963f, -0.05042341f, -0.03142393f, 0.05451987f, 0.22547835f, -0.06108578f, 
    0.00735931f, -0.08078958f, 0.00757476f, 0.05638205f, -0.15818472f, -0.00313058f, 0.11156315f, -0.01827143f, 
    -0.04800227f, -0.04661786f, -0.05942335f, 0.13925000f, 0.06669237f, 0.02313476f, 0.05739014f, -0.01113931f, 
    -0.21459647f, 0.50544196f, -0.27966502f, 0.25070685f, 0.02270257f, 0.00337620f, 0.15359145f, -0.00552766f, 
    -0.03488220f, 0.01309243f, -0.18029992f, -0.06563472f, 0.08544607f, -0.01837902f, 0.04960284f, 0.05910500f, 
    -0.07158113f, -0.09178222f, 0.03414026f, -0.01908423f, -0.11440112f, 0.00901842f, -0.10708020f, 0.03905202f, 
    0.03881868f, -0.02902341f, 0.06482790f, -0.00440875f, 0.03206222f, -0.03095924f, -0.03875404f, -0.08786827f, 
    -0.00005433f, 0.06450183f, 0.01124662f, 0.06682944f, 0.12374847f, 0.04815805f, -0.13348733f, -0.05702670f, 
    0.06905375f, -0.10906171f, -0.05021519f, -0.05042782f, -0.01549969f, 0.06236077f, 0.01558814f, 0.01792702f, 
    0.54442936f, -0.29395124f, 0.12526523f, -0.60533422f, 0.04263733f, 0.16754830f, -0.23917204f, 0.11103165f, 
    -0.02203224f, -0.08940037f, -0.05159180f, -0.01258369f, 0.29116878f, -0.05587330f, 0.08343176f, -0.23990203f, 
    0.07446957f, -0.03827572f, -0.00968930f, 0.09710447f, 0.05285747f, 0.00860108f, 0.05638900f, -0.28409424f, 
    -0.26435867f, 0.00058777f, 0.01151186f, 0.03397863f, -0.01828171f, -0.01895677f, 0.04526744f, 0.13382846f, 
    0.06658956f, 0.12231347f, 0.01949566f, -0.08430122f, 0.00292862f, 0.04747811f, -0.01272082f, 0.01781580f, 
    -0.09959905f, -0.01826712f, -0.01096592f, -0.06168717f, -0.03200235f, 0.05921847f, 0.01891997f, -0.02752843f, 
    0.24750769f, -0.13907735f, -0.21544629f, -0.11693731f, -0.02286141f, -0.00876410f, -0.04504946f, -0.04413967f, 
    0.11199519f, 0.00868482f, -0.11716475f, 0.06232122f, 0.06511877f, 0.21945581f, 0.14917982f, -0.02961756f, 
    0.02815660f, 0.10796656f, -0.04484497f, 0.00989212f, 0.05119291f, -0.12096290f, 0.05394503f, 0.08129412f, 
    -0.17097399f, -0.04692324f, -0.15892567f, -0.08568654f, -0.01502136f, -0.04660095f, -0.08602127f, -0.00425801f, 
    -0.01246382f, 0.07855213f, 0.02129755f, -0.03370228f, -0.00010938f, -0.09323582f, -0.12806609f, -0.07343558f, 
    -0.00346725f, 0.01069914f, -0.01004601f, -0.04220681f, -0.04809538f, -0.04736137f, -0.03008324f, -0.07531656f, 
    -0.54291356f, -0.31169325f, 0.23027432f, 0.20979516f, 0.15079340f, 0.04893894f, 0.03315808f, 0.03661655f, 
    -0.13008106f, 0.05358503f, -0.03397970f, -0.00537145f, 0.63319284f, -0.73441112f, -0.31125796f, -0.19824903f, 
    -0.13926867f, -0.14224802f, -0.03124303f, -0.04960006f, 0.19175613f, 0.00779427f, 0.03069647f, -0.03942172f, 
    -0.31193903f, -0.40370265f, -0.04123440f, 0.13453217f, -0.05394092f, 0.14532928f, 0.14067772f, 0.12138349f, 
    0.14405961f, 0.00756737f, 0.00544409f, 0.05421776f, -0.24688460f, 0.13872330f, 0.13479027f, 0.14357108f, 
    -0.01134261f, -0.10560211f, -0.09913128f, -0.12816390f, 0.07409152f, -0.06643295f, 0.13364395f, 0.02078220f, 
    0.19015662f, 0.02037991f, -0.06546755f, -0.00359007f, -0.01857640f, -0.20789777f, -0.03278386f, -0.02009843f, 
    0.07780313f, 0.07988512f, 0.06966527f, 0.15524273f, -0.02769624f, 0.16809988f, -0.06308909f, -0.27317509f, 
    0.00046283f, -0.02947394f, 0.03426682f, -0.01219011f, 0.14356981f, 0.05283555f, -0.11729637f, 0.07122710f, 
    -0.11833189f, 0.03417773f, -0.09472840f, 0.20774277f, -0.04890072f, 0.01480347f, 0.06098212f, -0.10798679f, 
    -0.02500572f, -0.06617650f, 0.05152652f, 0.05096179f, 0.54686326f, 0.11192529f, -0.19730090f, -0.20814367f, 
    0.30640903f, -0.02205195f, -0.01573570f, 0.05421520f, 0.00805835f, 0.12129201f, 0.22111607f, 0.04924069f, 
    -0.30868295f, -0.13888615f, 0.06040858f, -0.00567720f, -0.00972150f, -0.10378232f, -0.03176492f, -0.03950064f, 
    -0.23911874f, 0.09818823f, -0.19332986f, -0.39984763f, -0.05884394f, -0.24492225f, -0.02964909f, 0.05541503f, 
    0.14864944f, 0.07729911f, 0.02853834f, -0.05808342f, 0.08229751f, -0.04467129f, 0.02578312f, 0.06101127f, 
    0.50783807f, 0.11003981f, -0.19432050f, -0.10515596f, 0.03732168f, 0.06164328f, 0.08955441f, -0.20673846f, 
    0.11133325f, -0.06313952f, -0.02743375f, 0.01294380f, -0.61073500f, -0.04505455f, 0.27222639f, 0.17139243f, 
    -0.01824502f, -0.07613225f, -0.19799802f, -0.19482715f, -0.09808192f, -0.10143927f, 0.03963212f, 0.01740436f, 
    -0.23054004f, -0.26047742f, -0.19829558f, 0.07850324f, -0.05341847f, 0.11732194f, 0.15393144f, 0.12556259f, 
    0.12002851f, 0.05978626f, -0.03380630f, 0.08518863f, -0.36669931f, 0.11615752f, 0.02867766f, 0.01466866f, 
    0.03730337f, -0.04266242f, -0.10279939f, -0.04345265f, -0.08193694f, 0.02468392f, 0.12257746f, 0.11652612f, 
    -0.34967217f, -0.04501088f, 0.13711925f, 0.01981329f, -0.03416341f, -0.01778250f, -0.06123676f, -0.07011706f, 
    -0.04112130f, -0.10989936f, -0.10656445f, 0.01932686f, -0.05024412f, -0.39407453f, -0.26979756f, 0.13057853f, 
    0.02642399f, 0.07081142f, 0.11249343f, -0.04374798f, -0.03432907f, -0.11484941f, -0.13234624f, -0.20720199f, 
    0.14139687f, -0.19094002f, -0.07628226f, -0.10592875f, 0.06334331f, -0.07632166f, -0.06702323f, 0.05023796f, 
    0.00404022f, -0.03952212f, 0.04139499f, -0.11861832f, -0.56029391f, 0.05119453f, 0.08350883f, 0.10953896f, 
    -0.01065196f, -0.10709113f, 0.05345082f, -0.04089621f, 0.09935816f, 0.09453461f, -0.04807002f, 0.05759083f, 
    0.08125520f, -0.03172829f, -0.07724768f, 0.04261017f, 0.03791241f, 0.09272019f, 0.03457377f, -0.08043303f, 
    0.10062203f, -0.08355689f, -0.08470753f, 0.01665407f, 0.12626009f, -0.01253406f, -0.04822909f, -0.02946800f, 
    0.01446260f, 0.07338475f, -0.00312588f, -0.12815291f, 0.14300750f, 0.16316204f, -0.07714596f, 0.13603950f, 
    -0.75706697f, 0.19507566f, 0.14888100f, 0.30705062f, 0.01993601f, 0.00577338f, -0.02628385f, 0.05891216f, 
    -0.00657865f, 0.05121950f, 0.12110291f, 0.17735131f, -0.02555537f, 0.04409930f, -0.09232610f, -0.08710915f, 
    0.10974696f, -0.05392155f, 0.02237937f, -0.02567325f, -0.24483785f, 0.01025244f, -0.30394015f, -0.37831461f, 
    -0.17600074f, -0.33384976f, -0.12560114f, 0.05894180f, -0.04660926f, 0.05219743f, 0.14482760f, 0.03345577f, 
    0.04285196f, 0.03438225f, -0.03881935f, 0.03273009f, -0.26195851f, -0.57166290f, -0.29918376f, -0.12330145f, 
    -0.06741808f, 0.09852505f, -0.04898281f, 0.01773121f, -0.05423370f, 0.00671011f, -0.04337624f, 0.05610766f, 
    0.30140319f, -0.02270790f, -0.05664369f, -0.31224972f, -0.17788440f, -0.19531773f, -0.10531844f, -0.05856735f, 
    0.09435413f, 0.19040774f, 0.05364450f, 0.08499848f, 0.14793693f, -0.19047503f, -0.28952682f, -0.32427189f, 
    0.18658048f, 0.01630200f, 0.04678695f, 0.06470624f, 0.04423473f, -0.03163720f, -0.11497252f, -0.19439337f, 
    -0.01114288f, 0.10599358f, 0.00959478f, -0.18569738f, 0.03194515f, -0.10547677f, 0.00643726f, -0.00691141f, 
    -0.02667236f, 0.04516569f, 0.07116893f, 0.04731247f, -0.07202350f, -0.13585241f, 0.11759838f, 0.12609091f, 
    0.07032692f, 0.00555751f, -0.06703258f, -0.27797735f, 0.08029528f, -0.04028301f, 0.14962265f, 0.11344390f, 
    -0.15991952f, -0.45682773f, -0.47563770f, -0.40497044f, 0.10521995f, 0.07120548f, 0.11553226f, 0.16653493f, 
    0.04368462f, 0.13975289f, 0.08819566f, -0.13091807f, -0.02282747f, -0.25514114f, -0.05964460f, -0.16386922f, 
    0.01490108f, 0.09076114f, 0.05944401f, 0.02972746f, 0.14273301f, 0.01650268f, 0.07132150f, -0.10594337f, 
    0.53727448f, 0.01479079f, -0.24151821f, -0.30486140f, -0.16794549f, 0.03209393f, 0.03869617f, -0.02084611f, 
    0.17082773f, 0.12456642f, -0.09206887f, 0.11433315f, -0.29001379f, 0.07400616f, 0.10767043f, 0.10246536f, 
    0.11865783f, 0.06217925f, -0.20988694f, 0.12857841f, -0.01082728f, -0.11493710f, 0.04540417f, 0.03844531f, 
    -0.22336447f, -0.49205139f, -0.36958781f, 0.11230177f, -0.00151631f, 0.14246103f, 0.05838925f, 0.04656068f, 
    -0.02828752f, -0.00820604f, -0.01655976f, 0.03464167f, -0.06124749f, -0.02491124f, -0.20002027f, -0.23578849f, 
    -0.07555263f, -0.07176969f, -0.02097549f, -0.02918290f, 0.08963167f, 0.14671183f, 0.04463672f, -0.02385349f, 
    0.00501987f, -0.48076627f, -0.30198485f, 0.04517629f, -0.04720090f, 0.08801817f, -0.08161212f, 0.09682942f, 
    0.02346987f, 0.02947980f, 0.00905319f, 0.06382138f, -0.17897159f, -0.06707091f, 0.16388932f, 0.09511129f, 
    -0.19489089f, -0.04071302f, -0.11621536f, -0.03293230f, 0.00945963f, -0.14882365f, 0.04189721f, 0.16909604f, 
    -0.04372542f, -0.10420451f, -0.20613106f, -0.04296596f, 0.03360958f, 0.04763460f, -0.04161267f, 0.02544229f, 
    0.13305855f, 0.07967078f, 0.16595553f, 0.09966611f, -0.31468645f, -0.13613574f, -0.07246548f, -0.07768437f, 
    0.00288242f, -0.03108568f, -0.10138224f, -0.15070505f, -0.03308606f, -0.02635160f, 0.03497932f, 0.03226393f, 
    -0.30489856f, -0.06530549f, 0.12450317f, 0.03621198f, 0.13983829f, -0.09661032f, -0.01850315f, -0.11896395f, 
    -0.22848824f, -0.11918783f, -0.03279398f, -0.18828054f, -0.08775994f, -0.40397438f, -0.23629318f, 0.02916707f, 
    -0.07564416f, 0.23151819f, 0.07178418f, -0.00685707f, -0.04980221f, 0.00962053f, 0.02455659f, 0.01176197f, 
    0.01394471f, -0.05808854f, -0.07516269f, 0.02200170f, 0.09020026f, 0.01218359f, 0.09913064f, 0.07538591f, 
    0.14251371f, -0.02228790f, 0.01981390f, -0.05659750f, 0.16345318f, -0.07871337f, -0.11704697f, -0.27658755f, 
    0.14868416f, -0.04367838f, -0.01430524f, 0.05371051f, 0.08996402f, 0.03734920f, 0.07901047f, 0.11839747f, 
    -0.28783640f, -0.06749655f, -0.00779013f, 0.14401373f, 0.12614892f, -0.02721702f, -0.04411352f, 0.13198483f, 
    0.16855609f, 0.10358901f, 0.14822710f, -0.05494819f, 0.04025609f, -0.25068805f, -0.36458257f, 0.21408743f, 
    0.30130133f, 0.00289537f, 0.10663549f, -0.08482617f, -0.15835837f, -0.22280662f, -0.06665412f, -0.13798621f, 
    -0.15802714f, -0.09464589f, 0.02309928f, 0.08151154f, -0.03792737f, -0.12446564f, 0.01914465f, -0.16791882f, 
    0.00841382f, 0.05395461f, -0.00874790f, 0.00138343f, -0.21264018f, 0.17718247f, 0.09049021f, -0.23575529f, 
    0.13930847f, -0.04511355f, -0.03455448f, 0.07728440f, -0.03195393f, 0.10298049f, 0.05217170f, 0.01942839f, 
    0.07413734f, 0.08861376f, 0.08482313f, 0.02192342f, -0.07961522f, -0.09788890f, 0.03227145f, 0.08201532f, 
    0.04946782f, 0.07649036f, -0.02682769f, 0.00246151f, -0.05416616f, 0.01797737f, -0.00397138f, 0.03814431f, 
    -0.12432456f, 0.04499336f, -0.03601945f, -0.16511562f, -0.05399622f, -0.02213505f, -0.03769081f, -0.03598377f, 
    -0.08195124f, -0.06184195f, 0.00258336f, 0.04321515f, 0.02206909f, 0.06688955f, 0.03042489f, 0.06253956f, 
    -0.09522125f, -0.01064199f, 0.07699745f, 0.05854780f, -0.07765748f, -0.14799023f, -0.06179802f, -0.02631608f, 
    0.02482609f, 0.05977780f, -0.04113384f, 0.08268832f, -0.11804121f, -0.02579806f, -0.20197265f, -0.13477612f, 
    -0.50751209f, -0.59884763f, -0.30999190f, -0.06435204f, 0.24097531f, 0.18074447f, -0.03829572f, 0.16532288f, 
    0.09613838f, 0.09945039f, -0.01459516f, 0.13025917f, -0.19595785f, 0.00549581f, 0.03774871f, 0.06603840f, 
    0.13974728f, -0.06222145f, -0.05899318f, 0.04919851f, -0.00650802f, 0.00120886f, 0.15294755f, 0.03813699f, 
    -0.53435022f, -0.18394233f, 0.22918442f, 0.32142454f, 0.02489208f, 0.00870046f, -0.03132250f, -0.00684997f, 
    -0.09063046f, -0.06112204f, 0.15003237f, 0.02312366f, -0.17572919f, -0.03944562f, -0.01914100f, 0.08875951f, 
    0.13412587f, 0.10057250f, -0.00407902f, 0.01804751f, 0.13417381f, -0.00162742f, -0.12016894f, -0.28149179f, 
    -0.30025318f, 0.02141025f, 0.01674516f, -0.07622627f, -0.00753291f, -0.00589682f, -0.00971949f, -0.18516649f, 
    -0.16046911f, -0.16052279f, -0.12759236f, -0.12206209f, 0.31518623f, 0.18944722f, 0.09445135f, -0.17870273f, 
    -0.11730180f, -0.15462576f, -0.04764606f, -0.10242529f, -0.07996278f, -0.07516188f, -0.07185824f, 0.01164164f, 
    0.22023064f, 0.22989964f, -0.55406582f, -0.03482847f, -0.00528496f, -0.08183614f, 0.07599363f, 0.06003221f, 
    0.04701371f, -0.08091374f, -0.11867809f, -0.02031481f, 0.09686824f, 0.10648084f, -0.13462956f, -0.02328704f, 
    -0.08021249f, -0.16796704f, -0.00012633f, -0.08517127f, 0.11527824f, 0.10602875f, 0.05930422f, 0.10662939f, 
    -0.17361341f, -0.08137935f, -0.06692822f, 0.09191194f, -0.06885810f, 0.07790976f, 0.02358523f, 0.03772696f, 
    -0.17345430f, -0.28034705f, -0.13213146f, -0.20214537f, -0.02217715f, 0.06775362f, 0.05660262f, 0.04463338f, 
    0.00766053f, -0.08951101f, -0.00349600f, -0.01368426f, 0.01916134f, 0.04076773f, 0.06856361f, 0.06772722f, 
    -0.19031446f, -0.07877485f, -0.05325999f, -0.00912645f, 0.05280678f, 0.11548251f, 0.03896314f, 0.14400479f, 
    -0.16422716f, -0.13493806f, -0.11738537f, -0.30017734f, -0.41116330f, 0.07464109f, 0.16308567f, 0.29062715f, 
    -0.05871736f, -0.15059799f, -0.09236401f, -0.03388959f, -0.00272012f, 0.15341201f, 0.01808149f, -0.02957354f, 
    0.45619962f, 0.22400098f, 0.04719882f, -0.00403114f, -0.08931654f, -0.06393945f, -0.08709251f, -0.09710655f, 
    -0.03061377f, -0.00639880f, 0.01104322f, 0.02747612f, 0.01669003f, 0.17770848f, -0.24452466f, 0.12804207f, 
    0.13161908f, -0.01278156f, 0.00897796f, -0.02561258f, 0.01285561f, 0.16717529f, 0.02433305f, 0.11613212f, 
    0.38841671f, -0.19521888f, -0.28159550f, -0.25385931f, -0.15610240f, -0.08692094f, 0.01103773f, 0.02015094f, 
    0.09751248f, 0.02552168f, 0.02434148f, 0.09409096f, -0.15988448f, -0.32879755f, -0.08575000f, 0.01105386f, 
    0.05993300f, 0.13858283f, 0.11482520f, 0.08727688f, -0.19068378f, -0.08688831f, -0.07860882f, -0.42567468f, 
    0.33551687f, 0.04609545f, 0.08354259f, -0.08806039f, 0.02098628f, 0.01424003f, -0.32468346f, 0.03878405f, 
    -0.08736447f, -0.09034611f, 0.07413057f, 0.04296124f, 0.05053331f, -0.23738503f, -0.09011859f, -0.07768160f, 
    -0.06392476f, 0.12750006f, 0.04263345f, 0.15519853f, 0.05001256f, -0.14756607f, -0.04495338f, -0.03261606f, 
    0.11899969f, -0.41753447f, 0.05017901f, -0.08006065f, 0.03920049f, -0.04939844f, 0.18170662f, -0.10670146f, 
    -0.05831668f, -0.08355850f, -0.13412477f, 0.13790098f, -0.10699629f, -0.21260381f, -0.26877707f, 0.22948414f, 
    0.10502603f, 0.02445307f, 0.08584789f, -0.04392054f, 0.10048471f, -0.08530433f, 0.04178960f, 0.04103701f, 
    -0.06249542f, 0.34023994f, 0.04635656f, -0.69497943f, 0.01555480f, -0.21270432f, 0.21564648f, -0.00849059f, 
    -0.16836514f, 0.10568075f, -0.18061775f, -0.15287411f, -0.00782583f, 0.24461927f, -0.21611318f, 0.17983544f, 
    -0.03938811f, 0.01890264f, 0.01421107f, -0.14929305f, 0.17952257f, -0.06269011f, 0.03519165f, 0.08438990f, 
    0.02566502f, 0.07451827f, 0.20236400f, 0.00522455f, 0.03389077f, -0.05419661f, 0.09647559f, -0.02676658f, 
    0.04616011f, 0.06524913f, 0.24097349f, 0.13057198f, 0.29508218f, -0.11270997f, 0.30041227f, -0.48870108f, 
    -0.12923016f, -0.14417590f, -0.06597463f, -0.15145940f, -0.15196194f, -0.00963400f, 0.01690346f, -0.00602387f, 
    0.01085827f, -0.49900508f, 0.17415826f, -0.24258888f, -0.02782333f, 0.02226466f, -0.09168172f, 0.02166739f, 
    -0.11028323f, -0.02186608f, -0.02676356f, -0.00903259f, 0.10199746f, -0.26651907f, -0.01989052f, -0.23480186f, 
    0.16864580f, -0.02156780f, 0.04711889f, 0.19555321f, 0.02293748f, 0.00474336f, -0.11263722f, 0.10046037f, 
    0.09909489f, 0.18737037f, 0.17051299f, 0.08061597f, 0.08209210f, -0.02778745f, -0.25076479f, -0.07700900f, 
    -0.07071494f, -0.13340220f, 0.00593656f, 0.06396985f, -0.15840681f, 0.08165330f, -0.31988341f, -0.26995456f, 
    -0.02837957f, 0.02734115f, 0.04469487f, 0.06237564f, 0.16346742f, -0.09782649f, 0.06024874f, 0.03664533f, 
    -0.05085004f, -0.11701269f, -0.02222395f, -0.02016132f, 0.09376724f, 0.06345052f, 0.12258254f, 0.02922232f, 
    0.09917567f, -0.19129173f, -0.08883785f, 0.02479492f, 0.05864023f, -0.16724879f, 0.41284573f, -0.29507568f, 
    -0.09197839f, -0.19919604f, -0.19304574f, -0.05216249f, 0.04274932f, 0.03339376f, 0.08549544f, 0.03833333f, 
    0.18817119f, -0.15404989f, 0.10765504f, -0.05647115f, -0.01201975f, 0.04289230f, 0.11094406f, -0.01423379f, 
    -0.13514750f, -0.03334527f, 0.03643795f, -0.07726115f, -0.03928724f, -0.08796757f, -0.14326516f, -0.09155072f, 
    0.29822206f, -0.15538928f, 0.34658477f, -0.17269048f, 0.07809040f, -0.14612016f, -0.01118067f, -0.02953668f, 
    -0.09963255f, -0.29981893f, 0.05085236f, -0.32221267f, 0.19264917f, -0.01861187f, 0.23893905f, 0.00575844f, 
    0.02791552f, 0.10567145f, -0.14078136f, 0.01160296f, -0.08891013f, 0.16230944f, 0.11309519f, 0.17047033f, 
    0.15909219f, -0.14554225f, -0.15655637f, -0.17409430f, 0.09971006f, -0.03194871f, -0.04741101f, -0.03104894f, 
    -0.13250129f, 0.02119445f, -0.07376304f, -0.36762881f, -0.08252346f, -0.07345650f, 0.09529100f, 0.04849091f, 
    -0.02224630f, 0.00281366f, 0.05858952f, -0.01192696f, -0.00114417f, -0.16823307f, 0.07441648f, 0.07817940f, 
    0.02933175f, 0.02889878f, 0.05802755f, -0.04575004f, -0.00918379f, 0.02866508f, 0.08672117f, 0.02382784f, 
    0.30672899f, 0.08865771f, 0.39173850f, -0.23213230f, 0.04154950f, -0.16053008f, -0.13469239f, -0.07599591f, 
    0.10343640f, 0.04743295f, 0.06542553f, 0.14080015f, -0.38665405f, -0.10824440f, 0.11396485f, -0.21669361f, 
    -0.07109851f, -0.07470542f, 0.06893202f, 0.28139457f, -0.01032098f, -0.01466044f, 0.06271981f, 0.03666156f, 
    0.07598286f, -0.45940650f, -0.07161599f, -0.04608607f, -0.07797220f, -0.01658515f, -0.08609164f, 0.07012557f, 
    -0.13072489f, 0.00858659f, -0.06369325f, -0.10158714f, -0.17902803f, -0.02124725f, 0.03863986f, 0.17690566f, 
    0.12031287f, -0.12134233f, 0.12519909f, 0.01085719f, 0.11525803f, 0.02351875f, 0.10116518f, 0.14292668f, 
    -0.12125009f, -0.05896201f, -0.16782136f, 0.16094583f, 0.12836422f, 0.11764801f, 0.13025683f, -0.01087031f, 
    0.14468555f, -0.05761794f, 0.04537556f, -0.02618415f, -0.34526786f, -0.13336137f, 0.23383941f, -0.33641952f, 
    0.31617522f, -0.38394123f, 0.15515877f, -0.07190225f, -0.07530769f, 0.08856747f, -0.07774305f, -0.01512856f, 
    -0.07791391f, 0.08378976f, 0.04113110f, -0.42453650f, -0.22198433f, 0.06740543f, -0.01952411f, -0.08764030f, 
    0.08893564f, 0.24557348f, -0.12779658f, 0.03323462f, 0.27429935f, 0.14114083f, 0.48112980f, 0.19378193f, 
    0.16998902f, -0.15194699f, -0.05388828f, -0.21982589f, -0.14608599f, -0.13061894f, 0.03958657f, 0.08504033f, 
    -0.82546192f, -0.07018609f, -0.02692327f, 0.27992731f, 0.09830888f, -0.06297974f, -0.08319375f, -0.23509185f, 
    0.10748778f, -0.00358789f, -0.22633015f, -0.21687593f, -0.18759111f, 0.23469320f, -0.34724513f, -0.16149558f, 
    -0.14080895f, 0.01424684f, 0.26011103f, 0.01402396f, 0.06420875f, -0.07335484f, -0.08253543f, 0.11236056f, 
    0.02114130f, -0.13599361f, -0.05134121f, -0.14804670f, -0.18569121f, -0.03036972f, 0.00796268f, 0.10454838f, 
    0.04890732f, -0.00552605f, 0.09117159f, -0.04797685f, -0.18333781f, 0.02336246f, -0.01323769f, 0.44827497f, 
    -0.15839279f, 0.17439850f, -0.10676153f, -0.06284999f, 0.00406045f, -0.00982466f, -0.03868058f, -0.02738357f, 
    -0.31454590f, -0.00161079f, 0.03291490f, -0.28312820f, 0.05805586f, -0.13516524f, 0.16060783f, 0.17703216f, 
    -0.02033220f, -0.03364904f, 0.02182486f, -0.01366393f, 0.04865799f, -0.42024606f, 0.19560872f, -0.28802586f, 
    -0.03213794f, 0.07497244f, -0.20027688f, -0.06421203f, -0.07043731f, -0.07548086f, -0.03700138f, 0.06129098f, 
    -0.00606499f, 0.17258070f, 0.17802180f, 0.16590403f, 0.15871526f, -0.10610612f, -0.05522968f, -0.05771631f, 
    -0.12228469f, -0.11350265f, -0.20108001f, 0.07959783f, -0.00826187f, 0.36514038f, -0.36158508f, -0.11599153f, 
    -0.03822263f, -0.11771265f, 0.10577730f, 0.17726122f, -0.01386322f, 0.07436973f, -0.03395537f, 0.01956464f, 
    -0.02782213f, 0.09903175f, -0.44115144f, -0.04861487f, 0.15346149f, -0.05054838f, 0.09866363f, 0.01033729f, 
    0.09298877f, -0.01700302f, 0.02335037f, 0.08106403f, -0.24585503f, 0.07047261f, -0.21323532f, -0.04728981f, 
    -0.13695380f, -0.12789349f, -0.08372011f, 0.12549426f, 0.02795218f, -0.04176528f, 0.08210377f, 0.04934166f, 
    0.18505712f, 0.18059407f, -0.01404069f, -0.05389347f, -0.18984263f, -0.08439563f, -0.14097536f, -0.06519525f, 
    0.10744085f, -0.00315845f, 0.00929037f, 0.05862105f, -0.16605763f, -0.07574653f, -0.01041974f, 0.19523008f, 
    -0.08158148f, 0.01312665f, 0.00976337f, 0.02696954f, 0.00655212f, 0.06232057f, 0.03846718f, 0.02143201f, 
    -0.17771366f, 0.32416230f, -0.17427815f, -0.37221327f, -0.28153622f, 0.02638152f, 0.03814837f, 0.20878755f, 
    0.02226660f, -0.15323639f, 0.03613117f, -0.06135971f, -0.11760196f, 0.00732491f, 0.06019577f, -0.65796334f, 
    -0.26050469f, -0.13841443f, 0.09561135f, 0.05183739f, 0.16654487f, 0.02150429f, 0.11663737f, 0.00504180f, 
    -0.04793836f, -0.04053365f, -0.21224488f, -0.11733375f, 0.03485858f, -0.03439444f, 0.16537075f, -0.00617381f, 
    0.12331801f, -0.06775407f, -0.12896638f, -0.08979457f, 0.00553433f, 0.48091775f, -0.48363402f, 0.01156547f, 
    -0.20864183f, -0.07747266f, 0.16058199f, 0.03440816f, 0.05653732f, 0.03663166f, -0.07794343f, -0.11524861f, 
    -0.13047199f, -0.23810430f, -0.11692840f, 0.04587490f, 0.06643646f, 0.02930952f, 0.15340550f, 0.07689262f, 
    0.09511693f, 0.05770460f, -0.11782835f, -0.16718340f, 0.10541039f, -0.22843251f, -0.04900457f, -0.13773446f, 
    0.04537585f, 0.02294963f, 0.02018647f, 0.10297527f, 0.02558261f, 0.06328844f, -0.02567821f, -0.07798959f, 
    0.04727912f, 0.34300575f, -0.11003797f, -0.19036855f, 0.15319312f, 0.00187895f, -0.03337683f, -0.12337392f, 
    0.15160529f, 0.14418396f, -0.17362547f, 0.01156864f, 0.13092127f, 0.13160165f, 0.40005291f, -0.18724884f, 
    0.01307161f, -0.12845954f, -0.11358821f, -0.03149145f, 0.08169856f, 0.18659429f, 0.06290337f, 0.03224754f, 
    0.06024610f, -0.00489484f, -0.09761732f, -0.38404468f, -0.20737343f, -0.37547079f, 0.03991751f, 0.09335338f, 
    0.06346954f, -0.04339066f, 0.06626429f, 0.02436284f, -0.07976415f, 0.52150750f, -0.18454497f, -0.05714406f, 
    -0.10929718f, 0.06192505f, 0.13266300f, 0.01840772f, 0.08100442f, 0.06071620f, -0.15117669f, -0.01998293f, 
    -0.50949043f, 0.01050463f, -0.21700504f, -0.05853819f, 0.06869023f, -0.05429695f, 0.18179631f, 0.09071299f, 
    0.03603065f, -0.09216741f, -0.02236180f, -0.00924364f, 0.01093279f, -0.07701164f, -0.06693290f, -0.00948115f, 
    -0.03677313f, -0.05166444f, 0.11336766f, 0.08365565f, 0.01738681f, 0.01867974f, -0.00307854f, 0.16533749f, 
    -0.15362123f, -0.14668202f, -0.24071459f, 0.16735230f, 0.08432783f, 0.04694285f, 0.12694079f, 0.05089093f, 
    0.04045383f, -0.00942427f, -0.01903044f, 0.08692560f, -0.39725348f, -0.32165968f, 0.25932831f, -0.04459623f, 
    0.06774038f, 0.10295261f, -0.08785462f, 0.03462648f, -0.03878177f, -0.06412888f, 0.00583087f, 0.14367609f, 
    -0.20842803f, -0.22696452f, -0.19409351f, 0.03370901f, -0.04453713f, 0.03611144f, -0.15496908f, 0.00892334f, 
    0.13856454f, -0.01868894f, -0.00308162f, 0.01948377f, 0.11339262f, -0.16871797f, 0.20070954f, 0.05712671f, 
    -0.08393431f, 0.05838509f, -0.00764973f, 0.05075538f, 0.12551141f, -0.01919893f, -0.01854584f, 0.04141266f, 
    0.16900602f, 0.09674283f, 0.21298596f, -0.27024013f, -0.02488857f, -0.03973042f, -0.07511567f, 0.06167692f, 
    0.14042309f, 0.04305893f, 0.05131055f, 0.02819048f, -0.26368797f, 0.06558099f, -0.19067614f, 0.09356611f, 
    0.13043727f, -0.07154479f, -0.05625062f, 0.00037710f, -0.03591798f, -0.00215838f, -0.03291633f, -0.00274304f, 
    -0.06063089f, 0.24800247f, 0.35272610f, -0.15349261f, -0.01597773f, -0.19706708f, -0.10188794f, -0.09116126f, 
    -0.00050739f, -0.00373911f, 0.08189011f, 0.10870565f, -0.16225904f, -0.27009651f, -0.14003137f, 0.05261859f, 
    -0.04823765f, 0.05810328f, 0.15230744f, 0.04574707f, 0.13695551f, 0.03326860f, -0.03314835f, -0.06788642f, 
    -0.26341003f, -0.21133351f, -0.63141471f, 0.19973066f, 0.08841451f, 0.18487655f, -0.01261386f, 0.11751252f, 
    0.02105833f, -0.06348695f, -0.06347445f, -0.09995624f, -0.06714465f, 0.16978335f, -0.11402229f, -0.05297614f, 
    -0.00317681f, -0.11475831f, -0.05252840f, -0.06475155f, 0.05680905f, 0.11244751f, -0.38887912f, -0.06046863f, 
    -0.35393667f, -0.05645508f, -0.05067448f, -0.08055598f, -0.01701120f, -0.22631517f, 0.09153726f, 0.09448576f, 
    -0.08353982f, 0.04962005f, 0.00841917f, -0.02371218f, 0.20533706f, -0.19917512f, 0.39119035f, 0.05667805f, 
    0.00756477f, -0.00082032f, -0.08407178f, -0.24252337f, 0.04804011f, 0.06676959f, 0.02592191f, 0.05969156f, 
    0.00075819f, 0.42641276f, 0.24292281f, 0.07893819f, 0.03886241f, -0.02071426f, -0.09676149f, 0.07282782f, 
    -0.15899773f, 0.05013084f, 0.03620598f, 0.01185314f, -0.12984386f, -0.19600837f, -0.07720595f, -0.15237583f, 
    -0.13517170f, 0.00301693f, -0.17899129f, -0.02072659f, 0.02871778f, 0.13588807f, 0.12182948f, 0.00159231f, 
    0.03149790f, 0.12426169f, -0.20987740f, 0.20711470f, 0.02017942f, 0.05193487f, 0.18216167f, -0.10141011f, 
    0.00877039f, 0.08806052f, -0.06212530f, 0.10211631f, -0.37588766f, 0.16207163f, -0.01248693f, -0.05542209f, 
    -0.05103563f, 0.02687139f, 0.11044059f, 0.02927557f, -0.11936726f, -0.21134852f, 0.00052424f, -0.17791967f, 
    0.12785040f, -0.00230766f, 0.31726038f, 0.21308681f, -0.16183364f, -0.06035707f, 0.12153435f, -0.10660222f, 
    0.10441393f, -0.19713052f, 0.09293388f, 0.04128290f, -0.32435337f, 0.25940979f, -0.15168624f, -0.34218603f, 
    -0.10458049f, 0.00906827f, 0.07883231f, 0.03531405f, -0.09723041f, 0.01678091f, -0.16248190f, 0.10701803f, 
    -0.02567617f, -0.01535289f, 0.08391395f, 0.01479183f, -0.04806354f, -0.07013286f, -0.06238201f, -0.07196986f, 
    -0.07278339f, -0.12399957f, -0.18137465f, -0.23328951f, -0.05386206f, 0.25954223f, -0.15763947f, 0.13383332f, 
    -0.05505474f, 0.03257765f, -0.08471975f, 0.08057536f, 0.02660516f, 0.04365806f, -0.15126188f, 0.00774580f, 
    -0.89661729f, 0.18168445f, -0.15257770f, -0.10928241f, -0.14607580f, 0.12314686f, -0.08680638f, 0.00001743f, 
    0.01660115f, 0.01958851f, -0.09929448f, 0.04929581f, -0.08281263f, -0.11821009f, 0.21577530f, -0.17086233f, 
    -0.17264000f, -0.01259071f, -0.17202294f, 0.13614434f, 0.05510750f, -0.02025499f, -0.02694277f, -0.09419456f, 
    0.07552067f, 0.24328837f, 0.12362424f, -0.13568413f, 0.07754421f, -0.10879481f, 0.04935801f, 0.04150777f, 
    -0.12622617f, 0.13284259f, 0.07790693f, -0.03938020f, -0.01028804f, -0.13354644f, 0.46627429f, -0.09650372f, 
    -0.00530673f, 0.02563211f, 0.12100492f, -0.00056620f, -0.03806246f, -0.12364487f, 0.04668539f, -0.00453986f, 
    -0.19187199f, 0.01765038f, 0.07303558f, 0.11436165f, -0.03257991f, -0.04080526f, -0.16482203f, 0.08363429f, 
    -0.17557731f, -0.09397011f, -0.14231081f, -0.09059806f, -0.41884732f, 0.18677960f, -0.24768382f, -0.11171161f, 
    0.02002918f, 0.03028496f, -0.14922081f, -0.00455453f, 0.04162955f, -0.16253097f, -0.28604659f, -0.50037622f, 
    -0.26777864f, 0.20489505f, -0.02938111f, 0.19494070f, -0.06777282f, 0.10835407f, 0.01122700f, -0.02099916f, 
    0.06825900f, -0.15288198f, -0.18980391f, -0.14775090f, -0.03059793f, 0.10276724f, -0.13411751f, 0.09753988f, 
    -0.17967932f, 0.10541087f, -0.04652229f, 0.14236614f, -0.06090352f, 0.14786905f, 0.16246425f, 0.14723143f, 
    -0.22144374f, 0.29483908f, 0.06786522f, 0.06908937f, 0.02235368f, 0.13701355f, -0.21773942f, 0.20046301f, 
    -0.03649998f, -0.09269932f, 0.11855578f, 0.00258104f, -0.42631498f, 0.20406334f, 0.14579594f, 0.02538232f, 
    0.03269124f, 0.06377666f, -0.08360541f, 0.06172853f, -0.04458146f, -0.01878547f, -0.01629888f, 0.12448340f, 
    0.05840960f, -0.19828589f, 0.15074107f, -0.00394356f, -0.06333406f, -0.00123522f, 0.06069715f, -0.02421054f, 
    -0.00633053f, -0.13528095f, -0.06849489f, -0.04767449f, -0.10358775f, 0.20438553f, -0.11240796f, -0.14284213f, 
    -0.06980524f, 0.00976843f, 0.08686277f, -0.08181944f, -0.17995298f, -0.10822110f, -0.16937685f, -0.24329662f, 
    0.05123632f, -0.09069153f, -0.03819348f, 0.39881000f, 0.06609511f, -0.21627933f, 0.02951900f, -0.07366127f, 
    0.02085523f, 0.06479493f, 0.02437183f, -0.09907037f, -0.06005701f, -0.38740331f, -0.10221492f, 0.11745818f, 
    -0.08355162f, -0.24441229f, 0.01210529f, 0.26843929f, 0.06568158f, 0.07842491f, 0.02198014f, 0.09869320f, 
    -0.26831505f, 0.11419066f, -0.06945729f, 0.11982330f, 0.03463089f, 0.19755575f, -0.12446734f, -0.07652776f, 
    -0.01856502f, 0.03897209f, 0.22559145f, 0.07065614f, -0.18580954f, 0.03916862f, -0.22690082f, -0.06544161f, 
    -0.05087927f, 0.04471780f, -0.02732151f, 0.03243241f, -0.10944252f, -0.00459884f, -0.11249076f, -0.06454484f, 
    -0.31504980f, -0.10847396f, -0.69480962f, -0.50922865f, -0.29071042f, 0.04459463f, 0.09009330f, -0.10761996f, 
    0.00358256f, 0.08138941f, -0.13058682f, -0.00972914f, 0.01559526f, -0.07682480f, 0.06479281f, 0.12884443f, 
    -0.08233887f, 0.17071299f, -0.22321439f, 0.01765497f, 0.04988891f, 0.02965364f, -0.02996462f, 0.10192680f, 
    -0.01424174f, -0.14871190f, -0.02816736f, -0.14737420f, -0.04239488f, 0.01547468f, 0.18623321f, -0.05024325f, 
    -0.00634092f, -0.01392347f, -0.05189388f, -0.01392719f, -0.13440533f, 0.18848357f, 0.00853690f, -0.05514196f, 
    -0.07177687f, 0.02336300f, -0.04122283f, -0.07813957f, 0.05133522f, -0.01774907f, 0.08259911f, -0.10345080f, 
    0.51487219f, -0.29289824f, 0.34721845f, 0.19132234f, -0.23539202f, 0.19325538f, 0.28840548f, 0.22023413f, 
    -0.02775187f, -0.19548057f, 0.11783513f, 0.08449928f, 0.23893225f, -0.31118736f, 0.06534932f, 0.21017660f, 
    -0.19476925f, -0.15763354f, -0.07370696f, -0.06044023f, -0.03338741f, 0.09587547f, -0.11623683f, -0.11263136f, 
    -0.08840531f, -0.09660617f, 0.07183978f, -0.09363272f, -0.01810659f, -0.04060703f, 0.00464817f, 0.09022662f, 
    0.00872417f, 0.07778821f, -0.01340459f, -0.12821181f, 0.06652799f, 0.21082619f, 0.05664288f, -0.00753865f, 
    0.17868826f, -0.12592468f, 0.04443058f, -0.04632169f, -0.16601299f, 0.00991290f, -0.11338668f, -0.04361856f, 
    -0.25366127f, -0.01205317f, 0.08744141f, 0.13113396f, -0.10799043f, -0.02188475f, -0.01931080f, -0.02354101f, 
    -0.00478512f, 0.14571275f, 0.06243738f, 0.07941851f, -0.21702695f, 0.48145810f, 0.17026152f, 0.04951453f, 
    0.03948434f, -0.07099225f, 0.03070434f, 0.26667655f, 0.03524852f, 0.11257336f, 0.10957818f, 0.10319605f, 
    0.06160361f, 0.08768689f, 0.07366166f, -0.33918238f, -0.12385641f, -0.03957838f, 0.05590935f, -0.13687845f, 
    -0.02493551f, 0.10057829f, 0.14285985f, 0.25566325f, -0.00849325f, -0.48350698f, -0.20243700f, 0.08300372f, 
    -0.04212340f, -0.00222478f, 0.07174888f, -0.26038912f, -0.02960551f, 0.04655032f, 0.01282595f, 0.05753886f, 
    -0.17361468f, 0.03090401f, -0.03013979f, -0.14809282f, -0.06809832f, -0.00716632f, 0.08320523f, -0.01622575f, 
    -0.27918696f, -0.22108093f, -0.10435255f, -0.19837193f, 0.05411319f, -0.06953105f, 0.03775295f, 0.03129381f, 
    -0.05479852f, 0.02961011f, -0.06496993f, 0.27932024f, 0.06598341f, 0.07183569f, 0.01676676f, -0.02390052f, 
    -0.10358039f, 0.15027419f, 0.10672618f, -0.04848688f, -0.04989376f, -0.00121504f, -0.15185052f, -0.07829749f, 
    0.14759660f, -0.01490878f, 0.19169641f, -0.18329912f, -0.27690911f, -0.06717640f, -0.34474075f, -0.15610464f, 
    0.01562148f, 0.11945150f, 0.12314215f, -0.07015264f, 0.01582863f, 0.06219586f, -0.08935354f, -0.00997599f, 
    0.20797777f, -0.23373686f, 0.42396146f, -0.04421207f, 0.00977935f, 0.03004900f, 0.19209962f, 0.05523032f, 
    -0.00270147f, 0.12192457f, 0.09648903f, 0.24945618f, -0.04163593f, -0.11691829f, -0.16804874f, 0.04367876f, 
    0.09398452f, 0.22448191f, 0.21127766f, 0.02733819f, -0.05491691f, -0.13690582f, -0.05856942f, -0.07343157f, 
    -0.23796248f, -0.20802675f, 0.07596336f, 0.16784254f, -0.08044730f, 0.02836328f, -0.11491752f, 0.17045417f, 
    0.04540265f, -0.17600963f, 0.20780486f, 0.02235937f, -0.05017633f, -0.38123137f, 0.30346775f, -0.03439886f, 
    -0.01290913f, -0.12412567f, 0.18248892f, -0.10425002f, -0.05092492f, 0.08336074f, 0.03066988f, -0.00043904f, 
    -0.05391965f, -0.23150198f, 0.12499089f, 0.03433175f, 0.00290413f, 0.15237553f, 0.09746423f, -0.06758182f, 
    -0.07382014f, -0.06363681f, 0.13629973f, 0.11033288f, -0.06305915f, -0.09032467f, 0.01647721f, 0.12227911f, 
    0.03900919f, -0.15030654f, -0.18287081f, -0.11425530f, -0.02262674f, -0.04158953f, -0.03629972f, -0.03447488f, 
    -0.08699359f, 0.04091590f, 0.12472835f, 0.29057166f, 0.06491303f, -0.22271076f, 0.02708743f, -0.00031769f, 
    0.00782547f, -0.01579116f, -0.06117333f, 0.13675624f, -0.29748926f, 0.07485901f, -0.10152045f, 0.24579231f, 
    0.05531617f, -0.12133455f, -0.00406681f, 0.21777417f, -0.27463669f, -0.08642250f, -0.07287280f, 0.01544794f, 
    0.07551748f, -0.08898617f, 0.11228978f, -0.09134360f, -0.11962876f, 0.13354284f, 0.05326409f, -0.06286715f, 
    0.08523731f, 0.04315266f, -0.05521595f, 0.17956266f, 0.04227993f, -0.11189602f, -0.14022487f, -0.00623949f, 
    -0.10980432f, 0.09074723f, 0.35642517f, -0.21940608f, -0.11196389f, 0.06107753f, 0.11684198f, 0.19375516f, 
    0.07169677f, -0.36512882f, 0.24947180f, -0.00227757f, 0.00703204f, 0.23418331f, 0.17728367f, -0.02651728f, 
    -0.02901382f, 0.00208837f, 0.02566858f, 0.00514437f, -0.12467143f, 0.40191150f, -0.37176281f, 0.22294813f, 
    -0.00782048f, -0.05149513f, 0.03094370f, 0.10537846f, -0.29554307f, -0.17943154f, -0.12473352f, -0.41606000f, 
    -0.19787492f, 0.30873492f, -0.20696540f, -0.15197843f, -0.09806351f, -0.08303588f, -0.11111937f, -0.08430427f, 
    0.00081914f, 0.04745930f, -0.10678732f, -0.14051922f, 0.02301609f, -0.55828571f, 0.00266208f, -0.06098764f, 
    -0.23937088f, 0.12137285f, -0.09641361f, -0.17186637f, 0.10063234f, -0.21429589f, -0.11251029f, 0.04331936f, 
    -0.21549371f, 0.52079767f, -0.17393172f, 0.16473885f, -0.03355026f, -0.07793374f, -0.11078852f, 0.02951647f, 
    -0.16738096f, 0.08800329f, -0.03631697f, -0.06941956f, -0.10056738f, -0.18440992f, 0.07835373f, 0.22146277f, 
    0.03121777f, 0.13260654f, -0.00274048f, 0.09592952f, -0.27495667f, 0.03042328f, 0.07055884f, 0.00141860f, 
    -0.09168132f, -0.08224439f, -0.01640916f, -0.01189378f, 0.08771195f, 0.03042401f, -0.15369758f, 0.13679489f, 
    -0.15171406f, -0.27220023f, -0.50450647f, -0.25933325f, -0.13262364f, 0.03891231f, 0.07771362f, -0.03634723f, 
    -0.11522643f, -0.07492101f, 0.17103074f, 0.19132870f, -0.06147278f, 0.11592805f, 0.19836879f, 0.00345656f, 
    -0.01699320f, 0.04016795f, -0.07552351f, -0.10618852f, -0.05132755f, -0.13963042f, -0.03362235f, 0.06923085f, 
    -0.00445165f, -0.06921402f, -0.25783038f, -0.40107527f, 0.11079378f, -0.02313786f, -0.05517202f, 0.27592602f, 
    0.02035428f, 0.12387702f, -0.03139547f, -0.15974344f, 0.01918889f, -0.16837133f, -0.16666605f, 0.04922404f, 
    -0.23569015f, 0.17206690f, 0.17925027f, 0.09524468f, -0.19362549f, -0.01686095f, -0.01377515f, -0.01237463f, 
    -0.05498663f, 0.13554496f, -0.02071066f, 0.17819385f, -0.11348204f, 0.19216920f, 0.30104247f, -0.04135760f, 
    -0.10988466f, -0.05679520f, 0.11266728f, -0.02363390f, 0.01462895f, -0.08817248f, 0.14524499f, 0.17137598f, 
    -0.26200995f, 0.11398882f, 0.28299281f, 0.15057214f, -0.13903937f, 0.00496032f, -0.06599369f, -0.11615483f, 
    0.18785372f, 0.14979510f, 0.12629579f, -0.13899140f, -0.06590120f, 0.23509812f, -0.30416197f, 0.24822038f, 
    -0.02047047f, -0.10893030f, 0.05963420f, 0.02825427f, -0.14199615f, 0.01138520f, -0.23374222f, -0.24481919f, 
    -0.56362164f, -0.18135488f, 0.20063491f, 0.28822255f, -0.03278077f, -0.04681274f, -0.04469164f, 0.13449048f, 
    -0.15746820f, -0.02857313f, -0.22001055f, -0.12093671f, 0.31218737f, 0.22149986f, 0.04061198f, 0.01340844f, 
    0.05141181f, -0.05017171f, 0.24436666f, 0.00773511f, -0.10080884f, 0.00779941f, -0.04583216f, 0.03955992f, 
    -0.04881801f, 0.04440225f, 0.09278036f, 0.22939391f, 0.03737037f, 0.11927975f, -0.00352875f, -0.00310169f, 
    -0.22862858f, -0.14222455f, -0.11556292f, -0.15549260f, 0.14645082f, -0.41032290f, -0.04613421f, 0.15358897f, 
    0.08697397f, -0.03271607f, 0.00202570f, 0.09200055f, 0.02659056f, 0.11613403f, 0.24253556f, -0.01319903f, 
    0.07434841f, -0.09295248f, 0.44451991f, -0.55132532f, 0.07282443f, -0.01050252f, -0.23376599f, 0.16075738f, 
    -0.07960859f, 0.12870839f, 0.08458702f, -0.16037329f, 0.11081759f, -0.20016325f, 0.10824611f, 0.20226733f, 
    0.15324479f, 0.07735161f, 0.07306147f, -0.01120617f, -0.05350120f, 0.12322073f, 0.09794471f, 0.03950005f, 
    -0.00269193f, -0.12870795f, 0.01822210f, 0.00721994f, 0.02950625f, -0.07418425f, -0.11369456f, 0.01277230f, 
    -0.06498123f, 0.16162847f, 0.12066758f, 0.15458980f, -0.41664469f, 0.06157450f, -0.04118665f, 0.12919772f, 
    0.02173422f, -0.01200840f, 0.13132560f, 0.01630511f, -0.31616956f, -0.08027049f, -0.07117207f, 0.19616908f, 
    -0.09123557f, -0.03525787f, -0.27108964f, 0.07792705f, -0.02751871f, -0.12776606f, -0.03097431f, 0.04485058f, 
    0.03729856f, 0.10108124f, 0.08726429f, 0.02933406f, 0.28562132f, 0.28996724f, 0.07655191f, -0.00536271f, 
    -0.09977630f, -0.08128180f, -0.10536403f, 0.03935267f, 0.01121191f, 0.12739661f, 0.01114300f, -0.01282399f, 
    -0.33009312f, -0.08110394f, -0.01032496f, 0.18901204f, 0.14588276f, 0.00334644f, -0.02275484f, -0.03201028f, 
    -0.13494086f, -0.11013429f, -0.07669306f, -0.06373087f, -0.03174917f, -0.03247307f, -0.03510687f, -0.06972662f, 
    0.04857004f, 0.08375424f, -0.00134968f, 0.00800901f, -0.06569510f, -0.03545822f, 0.04506322f, -0.04671924f, 
    0.05466114f, 0.08227479f, -0.09506781f, -0.03135920f, -0.02018841f, -0.02256639f, -0.03245753f, 0.10209122f, 
    0.00340337f, 0.13920513f, 0.15651549f, -0.00626290f, 0.18165483f, 0.23352665f, -0.18462113f, -0.30183628f, 
    0.05485097f, -0.12648866f, 0.11903763f, 0.23904639f, 0.04987679f, 0.14908476f, 0.08915339f, 0.09681696f, 
    -0.02978026f, 0.15841086f, -0.08928072f, -0.10804335f, 0.08872242f, -0.11984605f, 0.16410661f, -0.06996222f, 
    0.08461852f, 0.17854556f, 0.07555207f, 0.01072071f, 0.28019682f, -0.22255535f, 0.10360623f, 0.28117877f, 
    -0.05344060f, 0.22468545f, -0.20510088f, 0.17142443f, -0.13252106f, 0.10666928f, -0.00580627f, -0.07370895f, 
    -0.01149543f, 0.13540228f, 0.19734745f, -0.01108016f, -0.10164411f, 0.08827999f, -0.13261019f, 0.06636963f, 
    -0.08048766f, 0.18622047f, -0.14832464f, -0.05662472f, -0.17512497f, 0.02192192f, -0.25996405f, 0.03287155f, 
    0.10511165f, 0.04587347f, -0.08018061f, 0.01144015f, 0.01088016f, -0.07200405f, 0.08936409f, -0.02523516f, 
    -0.14298002f, -0.22963053f, 0.12019708f, -0.14894962f, -0.00019355f, 0.03527515f, -0.01251339f, 0.03097901f, 
    -0.13637632f, -0.05928440f, 0.09694134f, -0.06372185f, 0.16975950f, 0.08230889f, -0.00943134f, -0.02111856f, 
    0.02409181f, 0.03328345f, -0.02860377f, 0.00937112f, 0.08359131f, 0.09107709f, -0.01385936f, -0.03204568f, 
    -0.23900121f, 0.03045745f, -0.07795017f, -0.10200607f, -0.13820507f, 0.02371640f, 0.09229612f, 0.06368590f, 
    -0.14836049f, 0.04301485f, 0.01183172f, -0.08609878f, -0.04789674f, -0.06205850f, 0.02384321f, -0.30533051f, 
    -0.08038562f, -0.16882935f, -0.06673184f, -0.05052264f, -0.00450050f, 0.00746484f, -0.09179352f, -0.09940646f, 
    -0.20351824f, 0.29206058f, -0.26054254f, 0.23150663f, 0.14604165f, -0.23553781f, 0.25115991f, -0.09952636f, 
    -0.09333973f, -0.02574177f, -0.21407028f, 0.01346365f, -0.15944429f, -0.29906550f, 0.04945991f, -0.36989978f, 
    -0.07678784f, -0.13585229f, -0.06025128f, -0.08655314f, 0.00572033f, 0.10693406f, 0.11193234f, 0.06809937f, 
    0.27420333f, 0.03988715f, 0.01395105f, -0.18738136f, 0.00931442f, 0.04863324f, -0.02240507f, 0.04275519f, 
    -0.02226876f, 0.06531870f, -0.08905410f, -0.12006843f, 0.10031006f, -0.01459995f, 0.10831994f, -0.09289748f, 
    0.01478241f, 0.27046388f, -0.18955395f, 0.21979591f, -0.30455345f, 0.11826243f, 0.04469819f, 0.00864402f, 
    -0.75636369f, -0.35663712f, -0.12311561f, 0.02733241f, -0.08035935f, -0.07649483f, 0.04906686f, -0.20578928f, 
    -0.02362266f, 0.05592157f, 0.08365607f, 0.11429755f, -0.23434535f, -0.05499712f, -0.28140971f, 0.01334798f, 
    0.03630192f, 0.05275565f, 0.01880960f, 0.03780013f, -0.01468486f, 0.07664504f, -0.05231446f, 0.14253421f, 
    -0.09752655f, -0.17220835f, 0.00121009f, 0.05750704f, 0.12533207f, 0.04521614f, -0.27429178f, 0.24613501f, 
    -0.00624760f, 0.12995645f, 0.20784017f, -0.16574284f, 0.01185366f, -0.24089946f, 0.51812774f, 0.21563436f, 
    0.00518811f, -0.02553104f, -0.12544297f, -0.03361482f, -0.07475857f, -0.17990315f, 0.23682447f, 0.13463579f, 
    -0.06492694f, 0.26654890f, -0.11677254f, -0.38997796f, 0.05233837f, 0.06644653f, 0.12179235f, -0.11445225f, 
    -0.00206463f, -0.01161517f, -0.00056268f, 0.04704815f, -0.47057724f, -0.17071743f, -0.39403331f, 0.25810498f, 
    0.08889310f, -0.06228825f, 0.08028215f, 0.00505525f, 0.04892527f, -0.12011749f, 0.13420376f, 0.05140837f, 
    -0.05738055f, -0.12357768f, 0.05357013f, 0.00927990f, -0.19490229f, -0.02565518f, -0.15001397f, -0.11437544f, 
    -0.07286943f, -0.08761185f, -0.05985291f, -0.13575123f, -0.62119967f, 0.39302567f, -0.40022951f, 0.04297815f, 
    0.08115855f, -0.06342147f, 0.13394868f, -0.17823604f, -0.13828674f, 0.09584337f, -0.13411111f, 0.13469893f, 
    -0.11254505f, -0.04156597f, -0.14625762f, -0.00248817f, 0.06013680f, 0.06192448f, 0.13957097f, -0.10292424f, 
    -0.11609001f, 0.12449002f, -0.07191231f, -0.22256118f, 0.08967395f, -0.32532799f, 0.16327047f, -0.34292364f, 
    -0.13231227f, -0.33635852f, -0.17003796f, 0.03959758f, 0.00828774f, 0.03277756f, 0.02313836f, -0.00339882f, 
    0.58576322f, 0.06385540f, 0.06823163f, -0.26542357f, 0.12469181f, -0.05948232f, 0.03652406f, 0.14637904f, 
    0.06555827f, 0.08017429f, 0.16767855f, -0.02132536f, 0.01382977f, -0.08863530f, 0.35418206f, -0.31167468f, 
    -0.03903404f, -0.03085919f, -0.02569300f, 0.02578394f, -0.13121976f, -0.09001084f, -0.11956475f, -0.16814531f, 
    0.01675809f, 0.00390536f, -0.07498240f, -0.06990881f, 0.09289350f, -0.11701258f, 0.03346337f, -0.04822786f, 
    0.00325421f, -0.02082259f, -0.11162829f, -0.03447068f, 0.11956348f, -0.44364512f, -0.17418675f, 0.11573174f, 
    0.04674330f, -0.10575841f, 0.03584306f, -0.11755341f, 0.01762118f, -0.02211095f, 0.00499658f, -0.01898855f, 
    -0.10954648f, -0.00380429f, 0.08713563f, -0.16955437f, -0.04175214f, 0.18659098f, 0.19078463f, -0.09161321f, 
    -0.02468785f, -0.03997000f, -0.10192742f, -0.04086589f, -0.21736832f, 0.01590185f, -0.11779161f, 0.01694013f, 
    -0.13890028f, -0.09991683f, 0.05710539f, -0.11166048f, 0.15656894f, -0.01846458f, 0.00006919f, -0.05016617f, 
    0.39720127f, 0.11482508f, 0.38029310f, -0.01863017f, -0.26747203f, 0.21576534f, -0.17267154f, 0.10946698f, 
    -0.06303010f, 0.08212189f, -0.02236270f, 0.06513818f, 0.21032952f, -0.28420210f, 0.51766723f, -0.23080422f, 
    -0.09515477f, -0.00065901f, -0.15090953f, -0.07880954f, -0.04863488f, -0.00847532f, 0.15636267f, 0.07178992f, 
    -0.02359844f, 0.08482851f, -0.01059121f, -0.00075360f, -0.00379496f, -0.09229988f, 0.07871056f, -0.12053699f, 
    -0.10251207f, 0.00654460f, 0.11070323f, -0.20485388f, -0.12044664f, 0.08327231f, 0.02002989f, 0.13487600f, 
    -0.18092674f, 0.12550044f, -0.08601496f, -0.01443388f, -0.00580635f, 0.02206539f, -0.02015532f, 0.01672842f, 
    -0.02546409f, 0.01387647f, 0.20634170f, 0.15137812f, -0.03496624f, 0.04210979f, 0.05977571f, -0.02675014f, 
    -0.00135733f, -0.04942590f, -0.13910972f, -0.17708661f, -0.28320578f, -0.21232225f, -0.07984388f, 0.28179714f, 
    -0.12662290f, 0.12685737f, -0.02271511f, 0.03550199f, 0.05138445f, 0.08284730f, 0.01962879f, -0.06597045f, 
    0.05875221f, -0.16130084f, 0.27005863f, -0.47044566f, -0.10827310f, -0.21124664f, -0.14376815f, -0.01050970f, 
    -0.04156023f, -0.02530074f, -0.01909395f, 0.02359185f, 0.02662012f, 0.02945717f, 0.36174256f, 0.20478413f, 
    0.12077670f, -0.08111202f, 0.13460696f, -0.14933528f, -0.12253458f, 0.05190448f, -0.06885909f, 0.13675852f, 
    0.01039321f, 0.18269722f, 0.30838728f, -0.26232138f, -0.02370205f, -0.01894008f, -0.03980871f, 0.04353172f, 
    -0.00323438f, 0.03366321f, 0.06324276f, 0.03578029f, 0.05432480f, -0.10898688f, 0.34413463f, 0.47375503f, 
    0.15846807f, -0.12839127f, 0.06511252f, 0.20528945f, -0.00492407f, 0.10934933f, 0.05451668f, 0.17215382f, 
    0.23752238f, -0.06914322f, -0.07310139f, 0.08106101f, -0.00461558f, -0.06106404f, -0.09767818f, 0.20588179f, 
    -0.02575761f, 0.06333207f, -0.01174856f, -0.03324495f, -0.41110560f, 0.10513425f, 0.05623347f, -0.41347712f, 
    -0.04042315f, -0.02225424f, -0.02101592f, -0.04555352f, -0.07385953f, 0.04771284f, -0.09020578f, 0.03832566f, 
    -0.18487968f, -0.09909596f, -0.23128876f, 0.05660734f, 0.11954514f, -0.07900036f, 0.12377355f, -0.13973045f, 
    -0.05506974f, -0.02442636f, 0.15548906f, 0.10844909f, -0.37669504f, 0.17218278f, -0.38973731f, 0.13178122f, 
    0.14728393f, 0.04848009f, 0.10881601f, -0.06602711f, -0.21871182f, -0.06986286f, 0.09226544f, 0.03930959f, 
    -0.36421698f, -0.17560735f, -0.02260081f, 0.05933512f, -0.09722509f, 0.03937878f, 0.11832410f, 0.04209141f, 
    -0.19326754f, 0.08514318f, 0.05679810f, 0.03110937f, 0.12540859f, -0.03865736f, 0.10441873f, -0.11857504f, 
    -0.04603012f, 0.04029588f, -0.00117897f, 0.09356804f, -0.06091070f, -0.05410142f, -0.03183185f, -0.18148853f, 
    0.17014845f, -0.16992947f, -0.03439495f, -0.28477225f, -0.06587261f, -0.01800988f, -0.03728978f, -0.07075649f, 
    0.03351890f, 0.13721874f, 0.01657427f, 0.02087466f, -0.26372391f, -0.03241719f, 0.06716897f, -0.02782687f, 
    -0.07712464f, -0.04510969f, -0.01800150f, -0.10787667f, 0.02008959f, 0.03788162f, 0.00665244f, -0.02719355f, 
    0.51647657f, 0.21022668f, 0.40785247f, -0.09732820f, 0.01045386f, -0.13855979f, -0.10964406f, -0.00473675f, 
    -0.17748557f, -0.08316077f, -0.02038197f, 0.02220424f, 0.14551143f, -0.08583274f, 0.36752608f, -0.01655026f, 
    0.03497173f, 0.12946580f, -0.03070252f, 0.05133752f, -0.15551725f, 0.10491750f, 0.04310925f, -0.21576367f, 
    -0.15665244f, -0.28791603f, -0.11448872f, 0.10482945f, 0.15140487f, 0.02153441f, -0.00388885f, -0.17936511f, 
    0.05164111f, -0.01711531f, -0.08224498f, 0.06442212f, -0.36285055f, 0.06343741f, -0.20381442f, -0.19935586f, 
    -0.03491073f, -0.04646084f, -0.05691468f, 0.06605081f, -0.02900079f, 0.07132965f, 0.23205464f, 0.22519983f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13582599f, 0.11402167f, 0.07693907f, -0.05939355f, -0.13380240f, 0.02319328f, 0.00558457f, -0.16262123f, 
    0.08026079f, 0.01385593f, 0.05851064f, -0.06607980f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
