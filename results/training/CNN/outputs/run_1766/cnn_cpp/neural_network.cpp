#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78584933f, -0.24775685f, -0.08118341f, 0.32599309f, 0.25240988f, 0.54119259f, 0.33444637f, 0.46115023f, 
    0.23795672f, 0.87925756f, -0.43857840f, -0.96565992f, -0.50053102f, -0.49084657f, -0.25948891f, -0.19178690f, 
    -0.39866546f, -0.55191773f, -1.14651573f, 0.03710727f, 0.01077746f, -0.71672726f, 0.31079835f, -0.81554300f, 
    0.37887502f, -0.32386932f, -0.07042292f, -1.32204640f, 1.53275144f, -0.56959856f, 0.20219420f, -0.10591017f, 
    -0.13797650f, -0.07125162f, 0.18047336f, -0.05663896f, 0.07441359f, 0.20774624f, 0.01937891f, 0.44743201f, 
    -0.37184522f, -0.43427384f, 0.51687193f, 0.37883183f, 0.69940817f, -0.17679729f, 1.27990258f, -0.78132582f, 
    -0.02746017f, -0.10794806f, 0.44817743f, -0.16917758f, -0.53048122f, 0.75864136f, 0.77888417f, 0.62984037f, 
    0.51641387f, 0.16399981f, -0.49014762f, -0.52788085f, -0.08193985f, -0.19648944f, 0.19747816f, 0.78961027f, 
    -0.84360528f, -0.94689298f, -0.58459288f, -0.23607102f, 0.82589668f, -0.10834786f, 0.08077765f, 0.46724689f, 
    -0.06241680f, -0.65299189f, 0.15617841f, -0.76625818f, -1.27975047f, -1.05391908f, -0.04889934f, 0.75646740f, 
    0.28101218f, 0.81280774f, 0.22150458f, -0.13243289f, 0.79601830f, 0.26535177f, 0.45541483f, 0.11115459f, 
    0.43361166f, -0.31169915f, -1.32787824f, -0.13141556f, 1.18768787f, -0.36656028f, 0.14687364f, 0.85006464f, 
    -0.29236746f, 0.12793432f, -0.21319401f, -0.28031781f, -0.13914678f, 0.69366604f, -1.01393592f, -0.78888637f, 
    1.07920289f, 0.50804549f, 0.01690646f, -0.04794835f, 0.20123315f, 0.14533527f, 0.43716270f, -0.18352473f, 
    0.27683491f, -0.28767094f, 0.45818889f, 0.50527674f, 0.06923455f, -0.45628780f, -0.46148354f, -0.25055751f, 
    -0.52679241f, -0.76874673f, -0.44041198f, -0.25241232f, -0.46814141f, 0.31650165f, 0.47754404f, 0.40741652f, 
    0.80340689f, -1.30450320f, 0.61403948f, 0.34926406f, -0.10530891f, 0.27640921f, 0.10108504f, -0.96626699f, 
    0.55843192f, 0.55186111f, -0.84026736f, -0.96386498f, 0.80898339f, -0.20152318f, -0.32423154f, -0.69404775f, 
    -0.10245529f, 0.59672403f, -0.36470118f, 0.04110275f, -0.11244746f, -0.08976611f, 0.04157456f, 0.88905716f, 
    -0.82675046f, -0.70620793f, -0.10742111f, -0.36566877f, 0.78773791f, 0.93139613f, 1.01445687f, 0.15478560f, 
    0.15570202f, 0.02539282f, -0.43524790f, -0.08495813f, 0.00625951f, -0.60078579f, 0.10470589f, 0.49403271f, 
    0.04223518f, 0.33615109f, 0.89264709f, 0.36918595f, 0.12714866f, 0.34419695f, -1.07821727f, -0.18386653f, 
    0.26665702f, -0.09358241f, 0.25907013f, 1.03555894f, 1.03611326f, 0.11218385f, 0.50253218f, -0.52210271f, 
    -0.54783571f, -0.80952364f, 0.31423238f, 0.33285522f, -0.14309096f, 0.30412790f, 0.46874893f, -0.03281724f, 
    0.76104474f, -0.18126196f, -0.04156946f, -0.03042489f, 0.32150298f, -0.24508090f, -1.23109376f, -1.13461244f, 
    -1.10210359f, 0.74249423f, 0.30632403f, 0.01078182f, 0.40590164f, -0.38046896f, 0.63648432f, 1.02301288f, 
    -0.94394130f, -0.65010804f, 0.11472225f, -0.09152532f, 0.61106950f, 0.08344224f, -0.01708199f, -0.20641179f, 
    -0.57254493f, -1.13480353f, -0.97397268f, -0.64891845f, 0.68425214f, -0.02128371f, 0.55131960f, 0.90606725f, 
    -0.13763373f, 0.56959808f, 0.72217286f, 0.06139121f, -0.69184339f, 0.63883090f, -0.18535849f, -0.29835632f, 
    -0.27878544f, -0.30077121f, -0.12461206f, 1.36978698f, -1.12805402f, 0.40731904f, -0.25513658f, -0.10774220f, 
    -0.20607360f, 0.48967749f, -0.03779122f, -0.62482810f, -0.79111820f, -0.45658189f, 0.81810147f, 0.14043508f, 
    0.49729747f, -0.23438388f, -0.79952270f, -0.78721213f, -1.26834226f, -0.63795251f, 0.15799196f, 0.07683919f, 
    0.84096867f, -0.93588716f, -0.37001824f, -0.73275352f, -0.66332281f, 0.53184146f, -0.99661243f, -1.02291954f, 
    0.52856117f, 0.86797464f, 0.85816032f, -0.47048971f, -0.11897367f, -0.43564600f, -0.04457795f, 0.43703800f, 
    0.37877473f, 0.18848702f, 0.34254065f, -0.43397146f, 0.57318532f, -0.95568812f, -0.35223430f, 0.09810025f, 
    -0.65919042f, -0.76303482f, -0.69650793f, 0.35161901f, -0.96595556f, -0.13586625f, 0.63470823f, 0.31692508f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.61749858f, 0.41141835f, -0.29219002f, -0.09349541f, 0.38578451f, 0.13371560f, 0.43904150f, 0.18610746f, 
    0.13680477f, -0.47194606f, 0.02871855f, -0.09121270f, -0.47315019f, -0.44201925f, 0.34055629f, -0.20295696f, 
    0.31049746f, -0.29501003f, 0.62959027f, 0.40624356f, -0.00755410f, 0.48556486f, 0.72123277f, 0.45890993f, 
    0.12634943f, 0.16417643f, 0.27451015f, 0.15490294f, 0.31642476f, -0.09259273f, 0.27263838f, 0.13836437f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04231917f, 0.14521793f, -0.09065232f, -0.01901554f, -0.04376224f, -0.15847883f, -0.00926496f, 0.05358371f, 
    -0.08523798f, -0.12629372f, -0.22972918f, 0.21571159f, -0.16881251f, 0.15856721f, 0.24537273f, 0.10246245f, 
    0.08564742f, -0.02791519f, -0.04317924f, -0.08351074f, 0.29112917f, -0.42800727f, 0.13162550f, -0.14996384f, 
    0.05471367f, 0.05303121f, 0.03888897f, -0.35626584f, -0.30464393f, -0.49572036f, -0.41322526f, 0.10109800f, 
    0.45899290f, 0.10928026f, 0.13279817f, 0.08192126f, -0.21997018f, -0.01239622f, 0.03172797f, 0.00432476f, 
    0.10908246f, -0.22299732f, -0.07722666f, -0.13116741f, 0.10290573f, -0.18002437f, 0.56548429f, -0.56839412f, 
    0.12449282f, -0.28895262f, 0.28449106f, 0.15802187f, -0.13409969f, -0.04961949f, 0.22022925f, 0.42884201f, 
    -0.04841151f, -0.09349334f, -0.13506728f, 0.00442523f, 0.04668789f, 0.11316478f, -0.08259480f, -0.27916399f, 
    0.29041576f, -0.24296749f, -0.13046408f, -0.02843294f, 0.39151600f, -0.14231692f, 0.03149080f, 0.00083180f, 
    -0.46294367f, -0.31247824f, 0.48292327f, -0.19374454f, -0.06713711f, -0.28217575f, 0.30691287f, -0.14595643f, 
    0.10607424f, -0.06044462f, -0.11883190f, 0.06425306f, -0.05614399f, -0.02882294f, -0.09024435f, 0.01317656f, 
    -0.08980805f, -0.02420930f, -0.15403481f, 0.63838208f, -0.85698473f, 0.28242853f, 0.30722195f, -0.22162467f, 
    0.06583007f, -0.04579264f, 0.24869494f, -0.57676721f, 0.27749228f, -0.11541406f, -0.10310221f, 0.09193594f, 
    -0.02459817f, -0.08790778f, 0.13440669f, 0.04256980f, -0.02342432f, -0.13316678f, -0.07678737f, -0.03065527f, 
    -0.03289752f, -0.13300930f, -0.13631201f, -0.01221852f, -0.16004312f, 0.23660521f, -0.01722150f, 0.25708455f, 
    -0.23282589f, -0.27557474f, 0.09538594f, 0.10849430f, 0.04591767f, 0.02407988f, 0.01715324f, 0.12861024f, 
    -0.19787702f, -0.00320223f, 0.01196948f, -0.05895860f, -0.03582445f, -0.02041373f, -0.11684033f, -0.11398317f, 
    0.60915226f, 0.16659582f, -0.26135647f, -0.26365301f, 0.03974401f, 0.12733862f, 0.08199970f, 0.21439226f, 
    -0.16991712f, 0.24878430f, 0.46785673f, -0.02074669f, 0.28682977f, -0.32883921f, -0.03777635f, 0.20450182f, 
    0.26905525f, 0.04703626f, 0.07127417f, -0.36365923f, -0.09984979f, -0.07868865f, -0.16085230f, 0.02067432f, 
    -0.08468807f, -0.05214504f, -0.01720667f, 0.14317161f, -0.16681144f, 0.11338159f, 0.08644002f, 0.01791593f, 
    0.17425549f, -0.03207365f, 0.13546358f, -0.12102406f, 0.19933781f, -0.23492172f, 0.12193473f, 0.05371691f, 
    -0.12079944f, -0.04636718f, 0.04708290f, -0.02210319f, 0.15038384f, -0.04862357f, 0.15705249f, -0.03427423f, 
    -0.08071800f, -0.15007935f, 0.04161088f, 0.15669179f, -0.03191051f, -0.12173446f, 0.07724729f, 0.11943533f, 
    0.00369057f, 0.02705371f, -0.13898845f, -0.05191259f, 0.08721188f, -0.01151356f, 0.39522314f, 0.06234676f, 
    -0.02344947f, -0.11787560f, -0.00756422f, -0.33409673f, -0.09038883f, 0.01841808f, -0.10556082f, -0.30750310f, 
    -0.17570649f, 0.13666709f, -0.09023128f, -0.05479715f, 0.36591229f, -0.21379818f, -0.00545708f, 0.06792183f, 
    -0.09520654f, -0.11295893f, 0.19836488f, 0.04904608f, -0.22355849f, 0.20611133f, -0.05434500f, 0.18516974f, 
    0.09250682f, -0.05330407f, -0.06687158f, 0.21147190f, -0.04340568f, -0.06584647f, -0.06817739f, 0.18864889f, 
    0.09299508f, -0.00441239f, -0.20913611f, -0.00002627f, 0.06014309f, -0.00011937f, 0.08924315f, 0.17652845f, 
    0.12456793f, 0.19833121f, -0.02831973f, 0.11471780f, -0.15726160f, 0.05875847f, 0.13287242f, 0.10392931f, 
    -0.01358634f, -0.07731533f, 0.15976426f, 0.26927230f, -0.01745971f, 0.01302872f, 0.34560353f, 0.06891245f, 
    0.35483718f, -0.53053999f, -0.01088848f, 0.19428053f, 0.23977755f, -0.27422935f, -0.77902353f, -0.45334256f, 
    0.13174489f, 0.00317611f, 0.26488554f, -0.32487690f, 0.09445281f, 0.31151780f, -0.27342433f, 0.12518233f, 
    0.13438968f, -0.15944709f, 0.05997643f, -0.03528869f, 0.12291241f, 0.20611271f, 0.15179677f, -0.04599936f, 
    -0.25421438f, 0.51876378f, -0.10407893f, 0.13281347f, 0.09068654f, -0.03833824f, -0.10289794f, 0.02818586f, 
    -0.18995526f, -0.36300313f, -0.25480121f, 0.17241776f, 0.04864178f, 0.03522106f, 0.06476629f, 0.03762255f, 
    0.13125080f, 0.12718195f, 0.23866627f, 0.14994702f, 0.13922562f, -0.14125112f, -0.11895842f, 0.03035662f, 
    -0.03077398f, 0.11283325f, 0.40137210f, 0.27084705f, 0.37247247f, 0.16562913f, -0.02445216f, 0.33643994f, 
    -0.05714175f, 0.05225330f, -0.00826478f, -0.36047381f, 0.50119013f, -0.42203397f, -0.36955652f, -0.45763460f, 
    0.19876163f, -0.00016529f, 0.21007609f, -0.02797136f, 0.09745857f, -0.00145194f, 0.01017969f, -0.07619655f, 
    -0.00518840f, 0.09010093f, 0.01709347f, 0.04640169f, 0.12377890f, -0.07575095f, -0.16287528f, -0.25089416f, 
    0.11589389f, -0.07836068f, -0.12059339f, 0.04496475f, 0.15568416f, -0.01728610f, -0.29027098f, -0.17876638f, 
    -0.05499197f, 0.08313134f, 0.03768494f, -0.09625554f, 0.14846785f, -0.01235982f, 0.21166499f, 0.13182069f, 
    0.04002309f, -0.27827349f, -0.04577928f, -0.22661558f, -0.04191980f, 0.00183527f, 0.23466903f, -0.05576842f, 
    0.50532383f, 0.26824573f, 0.11751774f, -0.05538579f, -0.08660680f, -0.07538116f, 0.04711009f, -0.14353806f, 
    0.05142197f, 0.20254754f, -0.01565718f, -0.34839857f, 0.13538101f, -0.03864097f, 0.06297643f, 0.04811199f, 
    -0.05272061f, -0.07672827f, 0.00658420f, -0.20920935f, 0.20622055f, 0.09422141f, -0.35680532f, -0.09629200f, 
    0.06088075f, -0.15918240f, -0.09734425f, 0.60951698f, -0.41149342f, 0.35648549f, -0.13741866f, -0.20171334f, 
    -0.43545711f, 0.00998111f, 0.10828213f, -0.14980839f, 0.20665567f, -0.01010352f, -0.24729197f, 0.06863437f, 
    0.09149852f, 0.17243704f, -0.29615957f, 0.03684833f, 0.18785222f, 0.20359522f, 0.21002521f, 0.04822456f, 
    0.27340347f, 0.04957771f, -0.00379873f, -0.02329491f, -0.01558173f, 0.00510304f, -0.06431660f, -0.58010477f, 
    0.01840547f, 0.08634897f, -0.17610624f, -0.02343588f, 0.06736866f, 0.16711326f, 0.16207860f, -0.16680197f, 
    0.25094461f, 0.20641407f, -0.13390590f, -0.27805626f, -0.19298644f, 0.06999500f, 0.09892921f, 0.00568367f, 
    0.01557704f, -0.13917460f, -0.34837422f, 0.02475400f, -0.09499212f, -0.13778804f, 0.12763402f, -0.09931350f, 
    -0.05050226f, -0.12502013f, -0.59135550f, -0.57206231f, 0.14015779f, -0.02052965f, -0.00365787f, -0.02049812f, 
    0.07078929f, 0.00265356f, 0.01761031f, -0.16258256f, 0.10713185f, 0.05546603f, -0.14124495f, 0.15210511f, 
    0.01965614f, 0.13759109f, -0.13679062f, 0.16253018f, -0.17256910f, 0.05153548f, -0.04818256f, -0.05850611f, 
    0.06943363f, 0.01542049f, 0.39725843f, 0.07408774f, -0.03225837f, -0.08416759f, -0.24309903f, -0.23309813f, 
    -0.13313301f, -0.02505054f, -0.00901796f, -0.00742422f, 0.06441912f, 0.07703163f, -0.15784682f, -0.18282643f, 
    0.02276320f, -0.04330870f, 0.00577546f, 0.12551576f, 0.16763605f, 0.12687729f, -0.15482678f, -0.13704903f, 
    -0.40993533f, 0.26971513f, 0.09890851f, 0.18920280f, 0.23457541f, 0.04431812f, 0.09762792f, -0.02355889f, 
    -0.21827787f, -0.38654178f, 0.12012204f, -0.17706655f, -0.07412259f, 0.07082999f, 0.11696316f, 0.14367819f, 
    0.01122629f, 0.07371748f, -0.05210768f, 0.14190756f, 0.06100735f, 0.11584179f, 0.03729703f, -0.12019548f, 
    0.03625295f, 0.04239846f, -0.30785730f, 0.04143355f, 0.21004927f, -0.11974201f, -0.08635747f, 0.11652981f, 
    -0.03719395f, 0.13252595f, -0.15232371f, -0.19129993f, -0.57457942f, -0.12222170f, -0.16257457f, -0.00005764f, 
    -0.00699857f, 0.19892068f, -0.12106267f, 0.19139595f, -0.02870919f, -0.13577452f, 0.00885554f, 0.08701435f, 
    0.08451845f, 0.00715254f, 0.00039807f, 0.10199834f, 0.39859205f, 0.19621332f, -0.23592564f, 0.06726659f, 
    0.00396158f, 0.18508446f, 0.03879041f, 0.02497424f, -0.02183440f, 0.38042098f, -0.71792406f, -1.06885970f, 
    0.05894873f, -0.03151826f, 0.00047102f, 0.03105144f, 0.14826031f, -0.13507624f, -0.01051397f, 0.09842351f, 
    -0.20594656f, -0.04557247f, 0.03662249f, -0.04444694f, 0.09066827f, -0.07528731f, 0.28193665f, 0.01491949f, 
    0.37441513f, -0.07478397f, 0.22363544f, 0.06476320f, 0.19257158f, -0.08538183f, 0.09021942f, -0.10288467f, 
    0.01162689f, 0.13058922f, -0.01798214f, -0.05111723f, 0.05095164f, -0.02251709f, 0.08601663f, 0.01307811f, 
    0.09534836f, -0.39592561f, -0.14138196f, -0.15881675f, -0.07150365f, 0.15344299f, 0.22577906f, 0.28248382f, 
    0.00159302f, 0.37283921f, -0.75002283f, -0.31447685f, -0.21387924f, -0.07678833f, -0.12262852f, -0.08176256f, 
    0.00651202f, -0.08158642f, -0.11342382f, -0.64412653f, 0.06760713f, 0.12744358f, -0.16976920f, -0.24484035f, 
    0.07852188f, 0.31507757f, 0.21804762f, -0.10261443f, 0.09476794f, 0.04570327f, -0.00394676f, -0.13118717f, 
    -0.11554597f, -0.02150882f, 0.00966187f, -0.07224800f, -0.19326781f, 0.04907127f, 0.09131026f, -0.15345532f, 
    -0.02997005f, -0.20083767f, 0.28108549f, 0.11771304f, 0.16172642f, -0.23324244f, 0.24111380f, -0.14790340f, 
    -0.06870195f, 0.09914628f, 0.21043184f, -0.02702158f, 0.16009338f, 0.06947679f, -0.05506062f, 0.10256687f, 
    0.55301547f, -0.46249241f, -0.22959229f, -0.09417671f, 0.11277286f, 0.09020851f, 0.18802100f, -0.09122197f, 
    -0.40387902f, -0.59398520f, -0.34871125f, -0.22864942f, -0.03825615f, -0.11395406f, 0.04850340f, -0.07714988f, 
    -0.02844460f, 0.10472021f, 0.03210248f, -0.08749945f, -0.07358919f, -0.31728944f, -0.28851208f, 0.10477372f, 
    0.06471330f, 0.09864376f, -0.16116911f, 0.09575015f, -0.15330106f, 0.09174926f, 0.22828048f, 0.17165910f, 
    0.13215132f, 0.08662328f, 0.12526278f, -0.02171605f, -0.31798276f, 0.31632251f, -0.19399883f, 0.13717918f, 
    0.14811863f, -0.11872934f, 0.11507829f, 0.01501017f, 0.02748136f, -0.03611162f, 0.04592300f, -0.23988442f, 
    -0.18451308f, -0.13753632f, -0.07086957f, -0.08116779f, -0.07070888f, 0.01825607f, -0.21451737f, -0.26278591f, 
    -0.06826463f, 0.01364728f, -0.14322060f, -0.09801547f, -0.07006261f, -0.03991384f, 0.09266253f, -0.21166484f, 
    -0.23436604f, 0.01907204f, 0.03770721f, -0.08371194f, 0.01985350f, 0.11959589f, -0.07409377f, -0.44213435f, 
    -0.39779302f, -0.17444219f, -0.13062663f, 0.08028028f, 0.10038690f, -0.01050663f, -0.03376500f, 0.17673947f, 
    0.28432313f, -0.06941185f, 0.20751055f, 0.46847138f, -0.09515184f, -0.06434546f, 0.10073742f, 0.07737889f, 
    0.13365254f, -0.11637755f, 0.05903952f, -0.18563540f, -0.08749084f, -0.13626678f, -0.28390801f, 0.08525874f, 
    0.10289799f, 0.10210147f, 0.01323798f, 0.19232984f, -0.05762150f, 0.04157443f, -0.04328350f, 0.09490658f, 
    0.02430852f, 0.00698447f, -0.13337398f, 0.28264505f, 0.02671046f, -0.46052900f, -0.04060658f, -0.14819087f, 
    0.06946841f, 0.06836712f, 0.02523323f, -0.14853607f, 0.66045779f, -0.76180935f, -0.32477525f, 0.08535918f, 
    0.10956622f, 0.01272465f, 0.06409273f, 0.09716909f, -0.25914037f, 0.00820264f, 0.00484735f, 0.05282261f, 
    0.00106248f, 0.01579350f, -0.05643202f, 0.13962609f, 0.07311861f, -0.01678364f, -0.44752815f, 0.27750188f, 
    0.38213801f, 0.05665377f, -0.00286806f, -0.03034374f, 0.00559777f, 0.10775487f, 0.06910285f, 0.12219467f, 
    0.17551479f, -0.05953753f, 0.01051421f, 0.18764786f, 0.24273926f, 0.04326038f, 0.16572793f, 0.12782539f, 
    -0.53071302f, 0.14150722f, 0.43448874f, -0.15280639f, 0.01575563f, -0.02958051f, 0.04796275f, 0.10310840f, 
    -0.07683887f, -0.08378287f, -0.09097065f, -0.07771526f, 0.01603550f, 0.04913555f, -0.04411647f, 0.31061149f, 
    0.13444576f, 0.08557806f, 0.26388106f, 0.10710901f, -0.02351776f, 0.24531932f, 0.05872693f, 0.39756972f, 
    0.24464093f, 0.15464845f, -0.21030295f, -0.14781782f, 0.03068102f, -0.09393582f, -0.03246651f, 0.01245936f, 
    0.04958622f, -0.10086773f, 0.22252354f, 0.43386939f, -0.30284694f, -0.31936622f, -0.00705016f, 0.00591486f, 
    0.01040817f, 0.02279564f, 0.00725327f, 0.08651839f, 0.07786482f, -0.32312110f, 0.07047223f, -0.28287521f, 
    -0.14300002f, 0.12805368f, 0.39759788f, 0.08029079f, 0.20227444f, 0.24965475f, -0.08372435f, 0.00096965f, 
    0.04609467f, 0.00987799f, 0.04876020f, -0.16261035f, 0.13722566f, 0.11639462f, 0.41246289f, -0.70335847f, 
    -0.37067050f, -0.23453066f, -0.03020293f, 0.00846065f, -0.03855207f, -0.03194368f, -0.06449620f, -0.08674735f, 
    0.05314673f, -0.05558800f, 0.02151523f, 0.00783587f, -0.05735787f, -0.03143685f, -0.03120823f, -0.02605306f, 
    -0.00712446f, -0.00932635f, 0.02138042f, 0.01530257f, -0.03805264f, 0.03453529f, -0.00645691f, -0.00988671f, 
    -0.03330485f, 0.02515660f, -0.00932056f, -0.04200836f, 0.00763011f, 0.04399846f, -0.00776670f, 0.01173807f, 
    0.02864014f, -0.03302936f, 0.00516199f, -0.02395226f, -0.01130713f, -0.03870776f, 0.00183760f, -0.03808635f, 
    -0.01978912f, -0.04815624f, -0.05287354f, -0.01996171f, -0.04037043f, 0.01285237f, -0.00542754f, 0.05990380f, 
    -0.05894801f, 0.01619274f, 0.00727826f, 0.04570345f, -0.01874180f, -0.05746479f, -0.05883823f, -0.02329330f, 
    0.04147128f, 0.04027572f, 0.02769919f, -0.03994962f, -0.01074370f, -0.05481889f, -0.00018085f, 0.03421308f, 
    -0.01546935f, 0.02317124f, -0.04895783f, 0.00715899f, -0.03626493f, 0.03527255f, 0.00946435f, 0.03731640f, 
    -0.05583042f, 0.00327514f, -0.04184145f, 0.02308614f, 0.02885197f, -0.04019193f, -0.06229808f, 0.00516060f, 
    -0.04750784f, 0.04014603f, -0.00126615f, -0.02670138f, 0.04121857f, -0.00494039f, -0.00332031f, -0.00712485f, 
    -0.05952565f, -0.03841466f, 0.03009139f, -0.03969708f, 0.01957861f, 0.05464172f, 0.03830139f, -0.05572889f, 
    0.02073195f, 0.03091103f, -0.05543941f, -0.05847421f, 0.02158704f, -0.02761854f, -0.00248804f, -0.06387399f, 
    0.02135343f, 0.02228935f, -0.00877305f, 0.04934898f, 0.04731406f, 0.04431053f, 0.04284814f, 0.03735129f, 
    -0.04087148f, -0.01548693f, -0.05455558f, -0.00688699f, -0.02833360f, -0.02668281f, 0.00731587f, -0.01060034f, 
    -0.06513510f, -0.03759234f, -0.05939182f, -0.02973388f, -0.01342683f, -0.05708042f, 0.04745227f, -0.05510698f, 
    0.04691685f, -0.01653090f, -0.06149758f, -0.02744304f, -0.00010328f, -0.02537619f, -0.04524146f, 0.03471903f, 
    -0.02116505f, 0.04458846f, -0.01589541f, 0.03481513f, 0.02437615f, -0.00391816f, 0.01516611f, 0.02057755f, 
    -0.00129351f, 0.01499158f, -0.03925036f, 0.01937820f, -0.01496176f, -0.03316820f, -0.06230904f, 0.00451449f, 
    0.02528709f, 0.02281683f, 0.03847240f, -0.02707876f, -0.01618633f, -0.05279967f, -0.01202321f, 0.00905959f, 
    -0.04978757f, 0.05531074f, -0.00099154f, -0.02753804f, -0.04135817f, -0.00413155f, -0.01985137f, 0.04774198f, 
    0.03517194f, -0.03816559f, 0.05073297f, 0.03776647f, -0.00241787f, -0.00453582f, -0.03184536f, -0.02293712f, 
    0.03789862f, -0.06183790f, 0.04723441f, 0.06248064f, -0.02530519f, -0.03466890f, -0.06478839f, -0.01627107f, 
    -0.05637898f, 0.05642769f, -0.05064184f, 0.03080317f, -0.03194852f, 0.01846486f, -0.02366205f, -0.04329474f, 
    -0.01879512f, -0.02362401f, -0.02598137f, -0.03587262f, 0.02060518f, -0.03179996f, 0.05575668f, 0.03512193f, 
    -0.00210301f, -0.00627677f, -0.02874585f, -0.01063663f, -0.01655423f, 0.00223620f, -0.02683466f, 0.03831101f, 
    0.00700490f, 0.04355103f, 0.04564047f, -0.01068109f, -0.05531497f, -0.00013989f, -0.04247520f, -0.00911962f, 
    0.01619647f, 0.00077563f, -0.00946063f, 0.00575744f, 0.00410552f, -0.03916731f, -0.00561532f, 0.00700913f, 
    -0.06105324f, 0.00410176f, -0.03888035f, -0.01450139f, -0.01920039f, 0.02201302f, 0.01603448f, -0.03864471f, 
    -0.03652079f, -0.01751218f, 0.00151220f, -0.04253120f, 0.02012474f, -0.01559080f, 0.03190482f, -0.04508644f, 
    -0.02127596f, -0.05821243f, -0.05039049f, -0.03345040f, 0.04671527f, -0.03024542f, -0.03603721f, -0.00050817f, 
    0.02931170f, -0.03562827f, 0.04896237f, -0.00735716f, 0.02360965f, 0.01395203f, 0.00525146f, -0.03466156f, 
    0.02003339f, 0.02216210f, 0.00237309f, -0.06691713f, -0.03708785f, -0.03625262f, -0.04059457f, 0.00893590f, 
    -0.01520060f, 0.01529378f, -0.05066139f, 0.04587414f, -0.06514170f, 0.01320851f, -0.02312738f, -0.01250508f, 
    0.02985390f, -0.00552112f, 0.03613350f, -0.06637083f, -0.05409643f, -0.01705257f, 0.04260818f, 0.00821369f, 
    0.01799273f, 0.01894172f, 0.02707643f, 0.01268650f, 0.04186539f, -0.06239890f, -0.04818787f, 0.02049241f, 
    -0.02792255f, 0.00154624f, -0.01534921f, -0.00636753f, 0.02555080f, 0.00431687f, -0.04674418f, -0.03200068f, 
    0.23585606f, -0.07949533f, -0.02192086f, -0.03729477f, 0.17002036f, 0.17185494f, -0.02328350f, 0.16798431f, 
    0.07511657f, 0.28398418f, 0.21695825f, 0.18941684f, 0.12447044f, 0.04086740f, 0.05098536f, 0.10034209f, 
    -0.04979959f, -0.13316871f, -0.02563284f, 0.11402801f, -0.09370848f, -0.14739577f, -0.23660886f, 0.19457981f, 
    -0.15077560f, 0.00917167f, 0.08782182f, -0.20965099f, -0.17321244f, 0.12720951f, -0.18118107f, 0.00152485f, 
    0.26737013f, 0.02782132f, -0.01324821f, 0.06320392f, -0.18542118f, -0.35277787f, -0.09453177f, -0.06851024f, 
    0.11470507f, 0.14715004f, -0.01886240f, 0.09363435f, 0.17451198f, -0.49659809f, -0.36764228f, 0.06753156f, 
    0.14595820f, 0.04310207f, 0.35895449f, 0.13213144f, -0.12454861f, -0.03447800f, -0.42775604f, 0.00539256f, 
    -0.52460849f, 0.00942708f, -0.27844390f, -0.02098938f, 0.21032900f, 0.09215700f, 0.05286748f, 0.47568089f, 
    0.20883437f, 0.07501940f, -0.01702541f, 0.09805863f, -0.22917598f, 0.09337778f, 0.16172327f, 0.08719635f, 
    -0.13510498f, -0.11502077f, -0.45003602f, 0.00583566f, 0.02879984f, -0.19589847f, 0.08410305f, 0.04070361f, 
    0.16411050f, -0.20361304f, -0.04682532f, 0.03503251f, -0.44824326f, -0.56494260f, -0.45938420f, 0.09277206f, 
    0.01052276f, 0.13916139f, 0.16465680f, -0.35316059f, -0.00050274f, 0.06161925f, -0.14915131f, -0.09992646f, 
    0.07234060f, -0.05136256f, -0.12096105f, -0.10247543f, -0.60682541f, 0.41280746f, -0.00222864f, 0.13177258f, 
    -0.46770576f, -0.05685355f, -0.02047239f, 0.15481487f, -0.21435162f, 0.01921985f, 0.20808899f, -0.18942827f, 
    -0.12103038f, -0.34076580f, -0.32515511f, -0.03377523f, -0.20474021f, 0.09182423f, 0.06124994f, 0.06179755f, 
    -0.19429579f, -0.01258277f, -0.13523184f, 0.00544933f, 0.09303836f, -0.02859250f, -0.42766860f, -0.27073923f, 
    0.42823511f, -0.22062173f, -0.09671493f, -0.05306114f, -0.01588635f, 0.36285162f, 0.05184829f, -0.66119099f, 
    0.04052867f, 0.33431107f, 0.00609037f, -0.05906834f, -0.04312823f, 0.14008193f, -0.17258996f, 0.24938999f, 
    0.03637729f, -0.11825676f, 0.21746533f, 0.06216254f, -0.15588060f, -0.14210495f, 0.14659643f, 0.01085442f, 
    0.29737139f, -0.03491639f, 0.09702042f, 0.02319906f, -0.40742993f, -0.21104664f, -0.24970381f, -0.00745642f, 
    0.07500707f, -0.15239862f, 0.04905208f, -0.22837742f, 0.31606078f, 0.03950994f, 0.22403233f, -0.08124273f, 
    0.03664814f, 0.09824009f, 0.08864329f, -0.27632049f, -0.22680701f, 0.24003689f, 0.12265036f, 0.20485376f, 
    -0.38649455f, 0.02651823f, 0.24987581f, 0.19566144f, -0.47534239f, 0.06394770f, -0.77099049f, -0.12433496f, 
    -0.19433282f, -0.08916754f, -0.21184237f, 0.14301071f, 0.29401460f, -0.12448326f, -0.12065355f, 0.08485004f, 
    -0.08011795f, -0.28835011f, 0.16132739f, 0.09669586f, 0.11404431f, 0.07071566f, 0.01596428f, 0.18875274f, 
    0.17827870f, -0.01533812f, 0.18578056f, 0.22740600f, 0.02155521f, 0.20180793f, -0.01473299f, 0.61729991f, 
    0.16823448f, -0.17142498f, -0.03405814f, -0.06269822f, -0.09071487f, 0.02814913f, -0.03037813f, 0.09326972f, 
    -0.09346864f, 0.10298195f, -0.21244924f, 0.00857574f, -0.20607796f, 0.00108794f, -0.07495005f, 0.10588712f, 
    0.05031721f, -0.42921150f, -0.41960132f, 0.18262047f, -0.18174434f, -0.27171487f, -0.04853982f, -0.12806836f, 
    0.03232012f, 0.01198419f, -0.27208787f, -0.38390657f, -0.07651670f, 0.09662333f, -0.19138521f, 0.13714139f, 
    0.13533802f, 0.06913231f, -0.04122584f, 0.12664175f, 0.32739654f, 0.16152193f, 0.03256711f, 0.12040265f, 
    -0.05649503f, 0.17572346f, -0.07723275f, -0.17218831f, 0.21805786f, 0.36515766f, 0.15497799f, 0.04758175f, 
    -0.08193944f, 0.10256623f, 0.15695229f, -0.10041062f, -0.15495090f, 0.63962209f, 0.06748052f, 0.04217288f, 
    0.11400196f, -0.16920151f, -0.22930981f, -0.04005263f, -0.07399372f, 0.07026121f, -0.30262169f, 0.04190717f, 
    0.05419681f, -0.06960280f, -0.14484923f, -0.07323641f, 0.20769018f, -0.09566260f, 0.33084181f, -0.07893098f, 
    -0.08929431f, -0.20594260f, -0.06678166f, 0.08530995f, -0.09213044f, -0.16658151f, 0.11871913f, 0.04699760f, 
    -0.03016248f, 0.05325579f, -0.03112426f, 0.06062739f, 0.03079957f, 0.00600128f, 0.24609622f, -0.12306940f, 
    -0.05239901f, 0.05479202f, 0.36708829f, 0.14572604f, 0.27011901f, 0.11292227f, 0.14353138f, -0.02797581f, 
    0.05926890f, -0.06960464f, -0.11651725f, 0.27654386f, 0.68559873f, 0.12731650f, -0.19679886f, 0.32549143f, 
    -0.01848673f, -0.09927501f, 0.09875853f, -0.06206297f, -0.20521614f, 0.06001288f, -0.13927597f, -0.01175686f, 
    0.19793780f, 0.12195083f, -0.01755479f, 0.30655247f, -0.02345065f, -0.00808309f, 0.02775870f, -0.03847864f, 
    -0.04556762f, -0.02446464f, 0.03153706f, -0.04634044f, -0.47763062f, 0.52480811f, -0.17192677f, -0.16323584f, 
    0.01936479f, 0.05390497f, -0.01628527f, 0.03891956f, 0.02108594f, -0.10366237f, 0.25356364f, -0.03020680f, 
    0.05211662f, 0.02358156f, 0.04980463f, 0.13343558f, 0.06758030f, -0.01418684f, -0.04407039f, -0.06750876f, 
    -0.07332938f, 0.09201363f, 0.16300441f, -0.09808513f, -0.40270159f, -0.09376955f, 0.12331573f, -0.21804039f, 
    0.25964072f, 0.08312440f, 0.43561810f, 0.20465721f, 0.05860956f, -0.20171227f, -0.15470462f, -0.29534370f, 
    -0.11063410f, 0.07081683f, 0.04718808f, -0.01590743f, 0.08402169f, 0.13527618f, 0.02347375f, 0.33471599f, 
    -0.05620113f, 0.14626774f, 0.13450585f, -0.08438088f, -0.04687791f, 0.20137869f, -0.07111046f, -0.07794090f, 
    -0.14257765f, 0.01450067f, -0.07227255f, 0.33485821f, -0.10483672f, -0.46810362f, 0.17249863f, -0.53117615f, 
    -0.35855961f, -0.15832490f, 0.03823597f, -0.08531027f, 0.06673142f, 0.07214361f, 0.03117011f, 0.04984523f, 
    0.13016643f, 0.03307422f, 0.08545254f, 0.02919768f, -0.18393618f, 0.09409850f, 0.16883318f, 0.54452288f, 
    0.23646949f, 0.01898675f, -0.00444738f, -0.03377426f, -0.12699690f, 0.14126989f, -0.02245918f, -0.22294390f, 
    -0.21000092f, 0.10651863f, 0.06446874f, -0.08153017f, -0.02742719f, 0.01372109f, -0.02747456f, 0.38479227f, 
    0.03648543f, 0.16111280f, 0.01611508f, -0.08397087f, 0.09437747f, -0.07185531f, -0.04220443f, 0.10465366f, 
    0.03183677f, 0.20238721f, -0.23396528f, -0.05040889f, -0.02875297f, 0.00471667f, 0.09535715f, -0.08087016f, 
    0.14930189f, 0.08553285f, 0.07602818f, -0.09749527f, 0.05013611f, 0.03628334f, 0.11255240f, 0.07523827f, 
    -0.05581179f, 0.10195842f, 0.05110832f, -0.05831393f, -0.03189344f, -0.01658984f, -0.03539202f, -0.04285803f, 
    0.04048974f, -0.22305214f, -0.47200766f, 0.02705692f, -0.00792810f, -0.12870626f, 0.05054983f, -0.03016477f, 
    -0.17707647f, -0.10727791f, 0.06197046f, -0.46080220f, 0.31521222f, 0.07987599f, -0.03451055f, 0.04228760f, 
    -0.00935983f, -0.05458815f, 0.11857110f, 0.00734820f, -0.04033085f, -0.02279432f, -0.12292957f, -0.10115924f, 
    0.03242706f, 0.01657291f, -0.03451743f, 0.08702988f, 0.03397523f, 0.09645955f, -0.05558942f, 0.00971968f, 
    0.06397458f, 0.02354082f, -0.10374318f, -0.12173617f, 0.07162006f, -0.04326423f, -0.09168857f, -0.27630016f, 
    -0.02501155f, -0.20162635f, -0.05040843f, -0.04463399f, 0.02722426f, 0.04752265f, -0.03240752f, 0.15900470f, 
    0.04808372f, -0.01022440f, 0.45782515f, -0.14317326f, -0.09441523f, 0.07176339f, 0.01979768f, -0.06289172f, 
    0.13281125f, 0.48236251f, -0.11850947f, -0.23642953f, 0.17236854f, 0.08057930f, -0.03604862f, -0.00355317f, 
    0.00182304f, 0.02954335f, 0.08573981f, -0.01528952f, -0.11325040f, -0.08409893f, 0.04227325f, -0.03738172f, 
    -0.10976388f, -0.10144493f, 0.17804328f, -0.31795952f, 0.15910426f, -0.10214152f, 0.03008480f, -0.07143255f, 
    0.14036259f, -0.07080414f, -0.02908662f, 0.12757483f, -0.44560960f, 0.14257595f, 0.19680329f, 0.03319413f, 
    -0.13008688f, 0.11356700f, -0.06167508f, 0.06501158f, 0.22257711f, -0.50737184f, 0.18455966f, -0.37351125f, 
    -0.06017843f, -0.00227098f, 0.07718217f, 0.05078053f, 0.03090381f, 0.31130069f, 0.13753660f, 0.00553713f, 
    -0.01193846f, 0.11322456f, 0.09185509f, -0.05792265f, -0.01277820f, 0.04625608f, 0.12796848f, 0.11570798f, 
    0.07685528f, 0.44021592f, -0.09983499f, 0.16971602f, -0.01715615f, -0.03411619f, 0.11083940f, 0.03243141f, 
    0.19485836f, -0.09352782f, -0.16228150f, -0.07046130f, 0.04945720f, 0.08660133f, 0.19306676f, 0.02854841f, 
    -0.06572278f, -0.01077804f, -0.37838066f, 0.01349716f, -0.04768474f, 0.05579302f, 0.13499440f, 0.12346172f, 
    0.18133150f, 0.01337034f, 0.37874830f, -0.17648225f, -0.01396332f, 0.06105748f, -0.18086511f, -0.06290601f, 
    -0.07185639f, 0.03343689f, -0.00303799f, 0.87406284f, -0.16687843f, -0.25737095f, -0.22638281f, 0.09185450f, 
    -0.03625662f, 0.18136033f, -0.02017536f, 0.03025880f, -0.17961980f, -0.02780238f, -0.09146222f, -0.06038022f, 
    0.00837022f, -0.07179807f, 0.02140780f, 0.13469775f, -0.19277221f, -0.00437761f, -0.30756843f, -0.21569176f, 
    0.12319703f, 0.18063059f, -0.05069148f, -0.06807186f, 0.03245077f, 0.06859732f, -0.35818386f, 0.05573126f, 
    0.20514308f, -0.15371880f, -0.18702753f, -0.02099520f, 0.14794324f, 0.05303766f, -0.05534914f, -0.14641246f, 
    -0.62615544f, -0.09936987f, 0.19388071f, 0.12089989f, -0.17507063f, 0.05986569f, 0.03335162f, 0.13549361f, 
    -0.05237652f, -0.28024259f, 0.04854571f, -0.06456020f, -0.08685235f, -0.09607902f, -0.05387075f, 0.27754903f, 
    0.02257694f, -0.42970765f, -0.05379638f, 0.09511598f, -0.28509486f, -0.10553853f, -0.07098672f, 0.23100966f, 
    0.14821742f, 0.03940644f, 0.91684729f, -0.03218224f, -0.55057800f, -0.15277159f, 0.15252350f, -0.00164111f, 
    -0.08064035f, -0.00530853f, -0.07983278f, 0.23740663f, 0.02548957f, -0.22262391f, 0.06982285f, 0.10922229f, 
    0.04795565f, 0.36694783f, -0.02509225f, -0.08096357f, -0.14439261f, -0.01890378f, -0.29286942f, -0.11319530f, 
    -0.00805582f, -0.17843354f, -0.08611321f, -0.08721660f, 0.01396711f, -0.04008969f, -0.04850135f, -0.45747709f, 
    -0.08815559f, -0.24334966f, -0.16227005f, -0.07611811f, 0.06661487f, 0.05367428f, -0.39662355f, 0.24780630f, 
    -0.25276721f, -0.14848688f, 0.17482492f, -0.19160798f, -0.08213465f, -0.04474644f, 0.00582958f, 0.48894295f, 
    0.12915613f, 0.16417816f, 0.02778280f, 0.09739623f, 0.00199288f, 0.01172285f, 0.11796819f, 0.06243332f, 
    -0.01142504f, 0.28761324f, 0.22371201f, 0.03796627f, 0.36347759f, -0.00957947f, -0.09014638f, 0.28054899f, 
    0.14153725f, 0.18406725f, -0.26376215f, -0.11307551f, -0.17339462f, 0.03454864f, 0.15928315f, 0.10022219f, 
    0.01817533f, -0.06622273f, 0.08493819f, -0.07195121f, -0.01120672f, -0.09719034f, 0.00107689f, -0.05991811f, 
    0.17129952f, -0.22935334f, 0.06166480f, -0.37154675f, 0.00302522f, 0.05823270f, 0.00745240f, -0.01582952f, 
    -0.09141279f, -0.14569525f, 0.03630443f, 0.24706505f, -0.15932420f, -0.07036891f, 0.12495755f, 0.13906915f, 
    0.00927486f, 0.23537691f, 0.00996641f, 0.11891565f, 0.01167526f, -0.41992030f, 0.12784946f, 0.06537041f, 
    -0.15585518f, -0.08196145f, 0.03527090f, 0.09728268f, 0.02838579f, 0.02458634f, 0.60174263f, -0.42517409f, 
    -0.47859535f, 0.18198194f, 0.13778290f, 0.14872847f, -0.12326495f, -0.16557205f, 0.05841123f, 0.09537273f, 
    -0.54724759f, -0.04025897f, -0.01835124f, 0.33613446f, 0.01838654f, 0.22987591f, 0.09285533f, 0.08847233f, 
    0.30877307f, -0.64424729f, -0.21771179f, -0.03534777f, 0.10706127f, 0.15960357f, 0.01899176f, -0.12392861f, 
    0.11317978f, -0.65468717f, 0.09175301f, 0.23716047f, -0.26065043f, 0.13614132f, -0.07252543f, -0.07753627f, 
    -0.00681233f, 0.00645154f, -0.28643131f, -0.26784000f, -0.06064692f, -0.18372305f, 0.10009958f, 0.17198798f, 
    0.03317329f, 0.08242049f, 0.11874299f, 0.24227087f, -0.22342475f, -0.31642365f, 0.08543539f, 0.09761250f, 
    0.21700916f, -0.00492427f, 0.16882268f, 0.10640255f, 0.26292688f, 0.06464652f, -0.26082963f, -0.00650546f, 
    -0.12797081f, -0.08629651f, -0.03208788f, 0.11831789f, 0.06435377f, 0.17682697f, -0.62572509f, -0.08307146f, 
    -0.08317693f, 0.33316851f, 0.21993239f, -0.05764377f, -0.06516084f, 0.21104909f, -0.27260020f, 0.18066420f, 
    0.01663586f, -0.06630278f, 0.10511985f, -0.13461787f, 0.31183606f, 0.12712483f, 0.31004566f, -0.07226350f, 
    -0.31009349f, -0.28028744f, 0.17151919f, -0.01106382f, -0.00730796f, 0.14460690f, 0.01208712f, -0.01861715f, 
    -0.13361332f, 0.16988361f, 0.23757629f, 0.01945696f, -0.01379945f, 0.00837223f, 0.02160962f, -0.07003414f, 
    -0.02347799f, -0.00345158f, -0.04194633f, -0.74484968f, 0.05287415f, 0.24874204f, -0.06238857f, 0.17088872f, 
    0.12873332f, 0.07211417f, -0.41871485f, -0.26144442f, -0.64183569f, -0.19091359f, -0.14087787f, -0.23616853f, 
    0.00828381f, -0.03275663f, 0.03551972f, -0.30088755f, -0.20382249f, -0.09045585f, -0.03845154f, -0.16274801f, 
    0.07110007f, 0.19690844f, -0.12742931f, 0.11057273f, 0.07632602f, 0.01491007f, 0.08702619f, 0.05369209f, 
    -0.05254207f, -0.08245146f, -0.05850130f, -0.06473303f, -0.10218154f, 0.16898599f, -0.28854224f, 0.05024264f, 
    -0.00404186f, -0.09569062f, 0.14359125f, -0.00445611f, 0.02495816f, 0.06756960f, 0.25178739f, -0.04463865f, 
    0.10198773f, 0.10983853f, 0.14970367f, 0.04853572f, 0.01175735f, 0.01700072f, 0.01007782f, 0.11326396f, 
    0.57240486f, -0.20907256f, -0.32326892f, 0.19091447f, -0.19195279f, -0.02453494f, 0.06002901f, -0.00167795f, 
    -0.53421456f, -0.56675768f, -1.02898061f, -0.13121469f, -0.06058412f, -0.14765865f, -0.06090284f, -0.25845456f, 
    -0.03129062f, -0.02371479f, -0.00401182f, 0.03672604f, 0.03426670f, 0.03375660f, -0.13239489f, -0.30893224f, 
    -0.02292303f, -0.17649218f, -0.20266685f, -0.35744020f, 0.00333017f, -0.22615664f, -0.01423034f, -0.04927941f, 
    0.15343809f, -0.15299189f, -0.00998437f, 0.06854806f, -0.01001867f, -0.45692807f, -0.22679625f, -0.07307065f, 
    -0.04996884f, -0.12079389f, -0.06963245f, 0.07826250f, 0.07951970f, -0.04408703f, 0.07211629f, -0.03709904f, 
    -0.14421876f, -0.10178541f, -0.35315803f, -0.21921426f, -0.18600537f, -0.23756161f, -0.05858807f, -0.46107197f, 
    -0.26849532f, -0.24836904f, -0.28769270f, 0.13482672f, 0.09356081f, 0.09098291f, 0.26797029f, -0.06769951f, 
    0.01262508f, 0.10545690f, -0.04515120f, -0.03551346f, 0.01968726f, 0.07052163f, -0.07213018f, 0.25096512f, 
    -0.43416002f, -0.84515518f, -0.28770274f, 0.20637062f, 0.11586065f, 0.11162818f, 0.04268261f, 0.04867011f, 
    0.21666434f, -0.19971153f, 0.14966239f, 0.10721935f, 0.02235265f, 0.19882408f, 0.17974775f, -0.02106212f, 
    0.46294159f, -0.33641595f, -0.04138165f, 0.15832293f, -0.08260109f, 0.03776048f, -0.07878852f, -0.03206275f, 
    -0.13553986f, 0.01239161f, -0.02824079f, 0.06538124f, 0.01185368f, 0.00632367f, 0.01823220f, 0.01400744f, 
    -0.00887267f, 0.09550987f, 0.02202164f, 0.25933322f, 0.04070156f, -0.24130033f, 0.05259284f, -0.03170523f, 
    -0.03980809f, -0.09252614f, 0.00421791f, -0.00520671f, 0.32585964f, -0.14719957f, -0.19661619f, 0.03618843f, 
    0.08452859f, 0.11325483f, 0.00628219f, -0.00583531f, -0.11559567f, 0.11555691f, -0.07503957f, 0.12988202f, 
    -0.02062940f, 0.10935781f, 0.04358681f, 0.02662743f, 0.03542849f, -0.01532161f, -0.45178586f, 0.53042001f, 
    0.70102161f, 0.08145301f, 0.18131074f, 0.17537650f, 0.04755450f, -0.00511857f, 0.03829822f, 0.15458448f, 
    0.44799855f, 0.11888786f, 0.02778769f, 0.36894977f, -0.01141459f, 0.17166360f, 0.16410416f, 0.21833272f, 
    -0.46467113f, 0.50174332f, 0.57621008f, -0.21411352f, 0.02942337f, -0.04578152f, -0.01313665f, -0.05685211f, 
    -0.14642063f, -0.01999095f, -0.10577141f, 0.23201275f, 0.05821958f, 0.02426439f, 0.04501877f, 0.09452573f, 
    -0.08985167f, 0.01216726f, 0.25741875f, -0.21983851f, -0.08931997f, 0.19575551f, 0.05388784f, 0.11644971f, 
    0.16696757f, -0.02437230f, 0.08561526f, -0.09709074f, -0.15282598f, 0.09001229f, 0.01941338f, -0.04692694f, 
    -0.08664026f, 0.16222021f, 0.21644638f, 0.36232144f, 0.22041100f, -0.09591033f, -0.09817432f, 0.02894439f, 
    0.00075159f, 0.05391379f, -0.01455765f, 0.13605253f, 0.28704384f, -0.17282249f, 0.03776925f, 0.36063567f, 
    -0.03079769f, -0.24306704f, -0.28994310f, 0.17237829f, 0.08999376f, -0.09671328f, -0.14135320f, 0.19262934f, 
    0.10716639f, 0.09628560f, 0.02885624f, 0.00274089f, 0.06845246f, -0.00092427f, 0.24561480f, -0.54489106f, 
    -0.32642257f, -0.56513500f, 0.04681067f, -0.19031765f, -0.10842939f, -0.10281987f, -0.04683730f, 0.00410888f, 
    -0.01240607f, 0.23467715f, 0.14731368f, 0.07200590f, 0.11075120f, -0.04956018f, 0.05851349f, 0.14065853f, 
    0.07780302f, 0.07331114f, -0.01137922f, -0.22664486f, 0.01971185f, 0.16554883f, 0.03311755f, 0.08196293f, 
    0.11677727f, 0.09069218f, -0.36003068f, -0.22341807f, -0.22516243f, -0.11081231f, -0.11480121f, -0.06219009f, 
    0.09145141f, -0.20814568f, 0.03428628f, -0.80308157f, 0.16238719f, -0.35317206f, 0.18796740f, -0.23087199f, 
    -0.02351859f, 0.17347188f, 0.05901166f, -0.13777950f, -0.05315568f, -0.21902284f, -0.05771131f, 0.00976293f, 
    0.02115451f, 0.11723367f, 0.17072475f, 0.05106891f, 0.06123052f, 0.12102474f, -0.58414775f, -0.12817085f, 
    -0.14125857f, -0.00208430f, -0.09864215f, -0.05482840f, 0.09753978f, 0.19310950f, -0.04856270f, -0.06165754f, 
    -0.11205762f, 0.03818661f, 0.03026802f, -0.07174732f, 0.03976771f, -0.09866033f, 0.10639270f, 0.69773608f, 
    0.11564839f, -0.40505540f, 0.04368902f, -0.13865276f, 0.12167905f, 0.18045884f, 0.09000148f, 0.02471882f, 
    -0.25017190f, -0.67730874f, -0.22904256f, -0.23519717f, 0.08292866f, -0.29903632f, 0.12511584f, -0.11674665f, 
    0.06588363f, -0.13765709f, -0.08594366f, -0.21669237f, -0.21415295f, -0.46367809f, -0.33858514f, -0.02202279f, 
    0.03820973f, -0.09407637f, -0.02450066f, -0.71027333f, -0.62953991f, -0.19017990f, -0.29291874f, -0.07282326f, 
    0.10175643f, 0.01957795f, -0.03607883f, -0.38797396f, -0.73114073f, -0.67585504f, 0.02778553f, 0.20161752f, 
    -0.02398895f, -0.01559162f, 0.02638101f, 0.02280957f, -0.33272630f, -0.34615782f, -0.06586709f, -0.34125838f, 
    -0.27517742f, -0.20823999f, 0.00034235f, -0.08326402f, -0.13804972f, -0.07107049f, -0.06500479f, 0.04029496f, 
    -0.28864858f, -0.22733948f, -0.09849477f, 0.22244915f, -0.07974204f, 0.06502087f, -0.10307264f, -0.25665087f, 
    -0.27686632f, -0.15868214f, -0.25654331f, -0.00747127f, 0.13184051f, 0.19036666f, 0.17372055f, -0.52387011f, 
    -0.57383931f, -0.36081707f, 0.03671306f, 0.03133799f, 0.10247741f, 0.05780443f, 0.14656740f, 0.05730808f, 
    0.00995545f, -0.21733139f, -0.14420757f, 0.07223228f, -0.02533170f, 0.24215069f, 0.15715711f, 0.40341368f, 
    0.21307845f, -0.46067652f, -0.01246859f, -0.00759717f, -0.40034044f, -0.29026741f, -0.32359061f, -0.00405301f, 
    -0.01326990f, 0.03870972f, -0.07355743f, 0.06863380f, -0.04721308f, 0.08135390f, 0.20199730f, 0.03273074f, 
    0.15555179f, 0.07747368f, 0.28468284f, 0.26244271f, -0.47278813f, -0.30499452f, -0.16206445f, 0.24908337f, 
    0.11506358f, 0.21473524f, -0.01381419f, 0.19234507f, -0.04363107f, -0.55251974f, -0.27968889f, 0.00823136f, 
    -0.00902151f, -0.47020414f, 0.04359745f, 0.07983749f, -0.11683935f, 0.03066502f, -0.10834635f, -0.17247535f, 
    0.09565707f, 0.01428298f, -0.09593695f, 0.21220645f, 0.22767587f, 0.00988924f, -0.16742611f, 0.52439290f, 
    0.36312404f, 0.26786485f, 0.17397493f, 0.07875689f, 0.13320176f, 0.14884397f, 0.11946737f, 0.62975925f, 
    0.31963435f, -0.19478247f, 0.00860169f, 0.10093419f, 0.20402427f, 0.11119066f, 0.08901864f, 0.17823273f, 
    -0.54519349f, 0.54805583f, 0.33601430f, 0.07553975f, 0.15508124f, -0.22430788f, -0.08069350f, 0.11600898f, 
    -0.07026809f, -0.38981110f, -0.23347367f, -0.04137208f, -0.01994179f, 0.02069140f, 0.02671978f, -0.14902219f, 
    -0.06169852f, 0.18562599f, 0.46063384f, -0.27851796f, -0.46747151f, 0.05493848f, -0.07134822f, 0.22603919f, 
    0.11047141f, 0.10482803f, 0.06525655f, 0.25390992f, 0.02383180f, 0.08753548f, -0.03638139f, -0.15041421f, 
    0.07730771f, 0.28306851f, 0.11419100f, 0.13938922f, 0.01964924f, -0.09008472f, 0.00586453f, 0.14485309f, 
    -0.16003007f, -0.08229257f, 0.00566630f, 0.04601805f, 0.13053064f, 0.20887980f, -0.05656597f, 0.10834204f, 
    -0.26819646f, -0.11439212f, -0.04625366f, -0.00764762f, -0.01567328f, -0.05902595f, -0.20615178f, 0.16247301f, 
    -0.09846067f, -0.00511347f, -0.05990182f, 0.17278466f, 0.00280107f, 0.17775907f, 0.19280671f, -0.29222474f, 
    -0.22942095f, -0.07262655f, 0.20347100f, 0.08416522f, -0.01301443f, -0.12967461f, -0.07584772f, -0.04837466f, 
    -0.04727778f, -0.05235777f, -0.01189537f, -0.06008042f, -0.06135215f, -0.05279637f, 0.00769332f, -0.05372297f, 
    -0.04098884f, -0.03089341f, 0.01613676f, -0.00058404f, -0.03614586f, 0.00693994f, -0.05703769f, -0.01666386f, 
    0.01710003f, -0.01389203f, -0.03087258f, -0.05081211f, -0.00057847f, 0.04300386f, 0.04498715f, -0.04411165f, 
    -0.01260506f, -0.01142698f, -0.01823900f, 0.00820957f, 0.05364903f, -0.01106192f, 0.03725432f, -0.02956725f, 
    -0.03271931f, 0.00590342f, 0.05127838f, -0.00931274f, 0.01572146f, -0.05671468f, 0.02344852f, -0.03505171f, 
    0.04465397f, -0.04818520f, -0.04604521f, -0.00746034f, 0.05637468f, -0.05453461f, 0.00216062f, 0.00854827f, 
    -0.00824591f, 0.00516505f, -0.02990664f, 0.00227881f, 0.05249847f, -0.01789173f, 0.05811763f, -0.04044858f, 
    0.05654907f, -0.00419137f, -0.04569571f, -0.06116069f, 0.01980286f, -0.01682738f, -0.02569226f, -0.03264987f, 
    0.03356777f, -0.01667455f, 0.00135890f, -0.06438302f, -0.01553783f, 0.04873991f, -0.00839994f, -0.04526321f, 
    0.01857755f, -0.00618612f, -0.06269617f, -0.01885287f, 0.02427992f, 0.02205155f, 0.04962096f, 0.02770198f, 
    -0.04977898f, 0.00547850f, -0.01186448f, 0.01557794f, 0.00962733f, 0.02779619f, -0.02010381f, -0.00591811f, 
    0.02478157f, -0.04735373f, -0.02993938f, -0.05905692f, -0.04752049f, -0.04043532f, -0.05164535f, -0.00100134f, 
    0.04830045f, -0.05039847f, 0.04360122f, 0.00395390f, -0.05742046f, -0.01722781f, -0.02298415f, -0.05840436f, 
    -0.01704648f, 0.04644753f, -0.01341096f, 0.00174217f, -0.04102207f, -0.05568582f, 0.04519489f, 0.05759617f, 
    0.02051064f, -0.00478899f, 0.00063245f, 0.05189221f, 0.04419539f, -0.01610966f, -0.01089233f, 0.03191949f, 
    -0.02018211f, 0.00893969f, -0.03912588f, 0.02297923f, 0.03780212f, -0.03631714f, -0.02101547f, 0.04408588f, 
    0.05394629f, -0.03377348f, -0.02641269f, -0.04385671f, -0.03091797f, -0.04330269f, -0.03252413f, -0.01224837f, 
    0.04760607f, 0.01731997f, -0.02741564f, -0.05084396f, -0.03660331f, -0.02543624f, -0.05011407f, 0.04519118f, 
    0.05300034f, -0.01895036f, 0.00262693f, 0.03819131f, -0.04334874f, 0.02412889f, -0.05092144f, -0.04452288f, 
    -0.00509576f, -0.01787942f, -0.05044172f, -0.05425384f, -0.01099391f, -0.01808402f, 0.01139850f, 0.02813884f, 
    -0.05507752f, -0.01591974f, -0.04712813f, 0.00720435f, 0.01730811f, -0.01251525f, -0.04700591f, 0.05233249f, 
    -0.01594540f, -0.04155387f, -0.04278168f, -0.00545785f, -0.04448129f, -0.05786117f, -0.02701193f, -0.00888172f, 
    0.00164063f, 0.02521361f, -0.03625615f, -0.04571671f, 0.00501196f, -0.02227781f, 0.04476766f, -0.01146195f, 
    0.04958165f, 0.03001257f, -0.01155000f, 0.00416404f, 0.05288683f, 0.01794656f, -0.03909241f, 0.04083372f, 
    -0.04297164f, -0.01342172f, -0.01187675f, -0.03707949f, -0.03838527f, 0.04529440f, -0.01908796f, -0.05227464f, 
    0.04917380f, -0.00821119f, -0.06330642f, 0.01672902f, -0.05352057f, 0.00652866f, -0.00613164f, 0.02182662f, 
    -0.00073360f, 0.01921466f, -0.03895359f, -0.04489867f, 0.02489157f, 0.00803542f, -0.02090281f, 0.04078098f, 
    -0.03636221f, 0.03554656f, -0.00359282f, 0.05272680f, -0.01357270f, -0.05582538f, -0.04446566f, -0.04585331f, 
    0.00331544f, -0.01070024f, 0.02422262f, -0.04623287f, -0.05222988f, 0.02854659f, -0.05240035f, -0.03727952f, 
    -0.02032882f, -0.04975367f, -0.04911745f, 0.00322648f, 0.03967770f, -0.05275525f, 0.02831660f, -0.05316247f, 
    0.01198055f, 0.03243161f, 0.01443270f, 0.00477722f, 0.01773620f, -0.05199558f, -0.06034024f, -0.00369342f, 
    -0.02345687f, -0.04595417f, 0.01089988f, 0.04808872f, 0.01737579f, 0.04364933f, -0.03190980f, -0.00081266f, 
    0.01240642f, 0.04126311f, 0.05239102f, 0.03425574f, -0.04936496f, 0.03038691f, -0.03950865f, 0.03512699f, 
    0.03604160f, -0.03899500f, -0.06357312f, 0.04726971f, 0.04701330f, -0.02574123f, 0.03219236f, -0.02606053f, 
    -0.04813284f, -0.06046136f, -0.03771925f, 0.00491149f, -0.01117507f, 0.01408903f, 0.02978364f, -0.05083897f, 
    0.01685144f, -0.04225986f, 0.01797470f, -0.05211417f, -0.06241620f, -0.02370372f, -0.04693133f, 0.03657157f, 
    -0.00796779f, -0.13668835f, -0.02609431f, 0.08652244f, -0.10745979f, -0.14475670f, 0.00713072f, 0.20722590f, 
    0.06779528f, 0.25242826f, -0.06700291f, -0.28366458f, 0.08710808f, 0.07231802f, 0.06551289f, 0.08552497f, 
    0.09508348f, 0.06600852f, -0.31142718f, -0.17765363f, -0.12447401f, -0.13308957f, -0.16883230f, -0.00750756f, 
    0.00178296f, 0.08173781f, 0.16074912f, -0.49533546f, -0.79572028f, -1.08588064f, 0.06645007f, 0.14046887f, 
    0.34872270f, -0.01358873f, -0.05318334f, -0.29789004f, 0.10856799f, 0.03973565f, -0.04079057f, 0.07241040f, 
    0.15170804f, 0.06443728f, 0.01168277f, 0.05295702f, 0.04534515f, -0.31979859f, 0.10101925f, -0.39361027f, 
    0.09654318f, -0.18213379f, 0.10208064f, 0.14955918f, -0.29114917f, -0.09067183f, 0.43614802f, -0.45164746f, 
    -0.30580080f, 0.13025287f, 0.05896971f, 0.11690240f, -0.00796428f, 0.01803965f, -0.03621241f, -0.43083873f, 
    -0.13808440f, 0.31746176f, 0.29144409f, -0.13556257f, 0.01757715f, 0.08020642f, -0.04185502f, -0.07752065f, 
    -0.01956673f, 0.19961147f, 0.32375854f, -0.11744923f, -0.11584293f, 0.03924054f, 0.00663797f, 0.12229392f, 
    0.04267142f, -0.15848766f, -0.21857674f, 0.04348176f, -0.18950045f, -0.05478058f, -0.13659830f, 0.11411430f, 
    0.15701942f, 0.28352690f, -1.05029130f, 0.30221635f, -0.45445889f, 0.04156902f, -0.26695848f, 0.13941428f, 
    0.13602984f, 0.13696881f, 0.09148591f, -0.37072983f, -0.30732322f, -0.01685398f, -0.21012050f, -0.01587731f, 
    0.13113509f, 0.13948290f, 0.10463274f, 0.04451511f, -0.04984603f, -0.06874687f, -0.17284413f, -0.07955470f, 
    0.00499125f, -0.06409160f, 0.04570070f, 0.12712203f, -0.24760804f, -0.01601348f, 0.04086974f, 0.08007751f, 
    -0.21082366f, 0.04123038f, -0.05020781f, 0.03805502f, 0.14916354f, 0.03038298f, -0.40402326f, 0.02635724f, 
    -0.31006554f, 0.04378917f, 0.09990314f, 0.05664450f, 0.16146787f, -0.06460103f, -0.01020240f, -0.10638571f, 
    -0.15065609f, -0.23280531f, -0.07584326f, -0.07379439f, 0.04273533f, 0.21547993f, 0.09963152f, 0.13733347f, 
    -0.08017366f, -0.04390020f, 0.22708425f, -0.07491386f, 0.09444861f, 0.14769439f, 0.00187243f, 0.02302420f, 
    0.15060519f, 0.02691096f, 0.33050808f, -0.00128614f, -0.12792027f, -0.14837994f, -0.28737822f, 0.21584648f, 
    0.11003200f, 0.09088743f, -0.08916190f, -0.02784967f, -0.01813104f, 0.11493247f, 0.09537618f, 0.04335171f, 
    -0.08569460f, 0.14634235f, 0.01502271f, -0.25307345f, 0.17581071f, -0.20018579f, 0.24535626f, 0.11868513f, 
    0.07359640f, -0.04307850f, 0.03114863f, -0.10385195f, 0.35063833f, -0.39764926f, -0.29469264f, -0.07743444f, 
    0.04135885f, 0.27422568f, -0.15888597f, -0.04291252f, 0.06544232f, -0.23061666f, -0.29761758f, 0.05636368f, 
    -0.04424250f, 0.00373298f, 0.06810772f, 0.05541706f, 0.07043075f, 0.14228123f, 0.30793521f, -0.06189499f, 
    0.23280610f, -0.08507050f, 0.06050076f, -0.01006580f, -0.02791284f, -0.04749827f, 0.03827190f, 0.21623772f, 
    -0.42904511f, 0.31931031f, 0.07474577f, -0.05550888f, -0.01100182f, 0.03706427f, 0.04720871f, -0.07700531f, 
    -0.14449398f, -0.45399410f, 0.36796439f, 0.11203471f, -0.17344207f, -0.03803605f, -0.07601067f, 0.18204881f, 
    0.01534577f, -0.02565278f, -0.41995263f, -0.33856055f, 0.08471588f, -0.16292360f, -0.01779452f, 0.09739253f, 
    -0.01862255f, 0.05106490f, 0.02763593f, -0.20441291f, -0.59841067f, -0.00229881f, 0.16497071f, 0.30931705f, 
    0.08066820f, 0.04391515f, 0.04646073f, -0.04004597f, 0.12232601f, 0.08046429f, -0.05812272f, 0.00496495f, 
    0.03845020f, 0.21897167f, -0.03994144f, 0.15145886f, -0.26455551f, 0.02247756f, 0.18774647f, -0.00666692f, 
    0.06667277f, 0.09245260f, 0.19357923f, 0.03850299f, 0.08540157f, -0.15315837f, -0.44399980f, -0.05489907f, 
    0.04131328f, -0.14059465f, -0.20412484f, 0.02320651f, -0.16508916f, 0.16351819f, -0.17919019f, -0.18596022f, 
    0.02775286f, -0.04901537f, -0.04609778f, -0.01843234f, -0.00161040f, -0.02795119f, -0.02436876f, -0.16114411f, 
    -0.07284994f, 0.43191749f, -0.10710324f, -0.03160141f, -0.14509201f, 0.10086457f, -0.02070881f, 0.06049068f, 
    0.09645467f, -0.01995036f, -0.17832194f, 0.06183212f, 0.08600784f, -0.07025803f, 0.14865141f, 0.00491741f, 
    0.05717674f, -0.22772077f, 0.10205261f, -0.54221803f, -0.03561259f, 0.02847568f, 0.06906870f, 0.01010015f, 
    -0.00323763f, -0.25182119f, -0.12259194f, 0.27049670f, 0.05467696f, -0.06138312f, -0.11809984f, 0.01974835f, 
    -0.00055704f, 0.15608536f, -0.22721903f, -0.07395512f, -0.12086114f, 0.02324878f, 0.13744232f, -0.32748026f, 
    0.63618183f, 0.21552236f, -0.23643449f, 0.13077796f, -0.08320450f, 0.03578456f, -0.02019983f, 0.12227368f, 
    0.16789545f, 0.15410224f, 0.11340290f, 0.17173074f, 0.31819010f, -0.18406130f, 0.21513207f, -0.25225267f, 
    0.05050955f, 0.23614104f, 0.42008096f, 0.40090492f, -0.16577776f, -0.19860308f, 0.07582008f, 0.03349781f, 
    -0.04425538f, -0.01274894f, -0.01611515f, -0.00671193f, 0.17534727f, 0.11651760f, 0.18283631f, 0.24212399f, 
    -0.03807745f, -0.61458379f, -0.03522004f, 0.09378719f, 0.06995241f, 0.24078657f, -0.00060063f, -0.11990145f, 
    -0.14908496f, -0.40480649f, -0.04108964f, 0.17953427f, -0.02447072f, 0.03865364f, 0.02567660f, -0.09496031f, 
    0.11912342f, 0.14429113f, 0.07957728f, 0.19228554f, -0.06463020f, -0.05926292f, -0.04575562f, -0.07278538f, 
    -0.08358637f, -0.15602146f, 0.32112098f, 0.25859404f, -0.08404208f, 0.24341379f, -0.02383966f, 0.10660762f, 
    0.21545908f, -0.09285672f, -0.29444620f, -0.13948886f, 0.40315253f, 0.31862971f, 0.04664017f, -0.06440529f, 
    0.01204069f, -0.04181331f, 0.05697194f, 0.08086055f, 0.04772727f, -0.10177661f, -0.00690755f, 0.01176353f, 
    0.01234740f, -0.00420747f, 0.05814100f, -0.00726074f, 0.23110461f, 0.15887302f, 0.40699631f, -0.16883734f, 
    -0.09800579f, -0.05178894f, -0.06902540f, 0.09777362f, 0.07793156f, -0.05193847f, 0.30324093f, -0.03857332f, 
    0.10155208f, -0.01967659f, -0.03976481f, -0.10951546f, 0.16340707f, -0.01220992f, 0.17129596f, -0.13486300f, 
    -0.09208940f, 0.01481597f, -0.02278122f, -0.12409728f, -0.05367374f, 0.01142845f, 0.20657167f, -0.20343518f, 
    0.18146643f, 0.10327489f, 0.50967455f, 0.23395298f, -0.15252420f, 0.05870904f, 0.06299324f, 0.27266616f, 
    0.18176147f, -0.10003491f, -0.15377748f, -0.19985816f, -0.07124688f, -0.01748018f, -0.25410840f, 0.08036657f, 
    -0.11456192f, -0.01280170f, 0.00606070f, 0.01516387f, -0.10218107f, 0.22995368f, 0.11082785f, 0.04756871f, 
    0.33843327f, 0.22256316f, 0.10837607f, 0.05088987f, 0.04273579f, -0.06091399f, 0.09488102f, 0.13890232f, 
    0.13259791f, 0.18257718f, 0.21716435f, 0.31930709f, 0.04308123f, -0.26578209f, 0.21699990f, -0.15602647f, 
    0.09132014f, 0.22117975f, -0.10829061f, 0.11658854f, 0.30002165f, 0.02094645f, 0.17338401f, 0.19974191f, 
    -0.01301548f, -0.10881406f, -0.08351730f, 0.06801917f, 0.09336688f, 0.01453597f, -0.00488487f, 0.01180203f, 
    -0.45184970f, -0.21557614f, 0.27114710f, -0.06597665f, -0.00127686f, 0.06638728f, -0.07507027f, 0.28140947f, 
    0.09484816f, -0.16462326f, 0.00080493f, -0.04042679f, 0.14589524f, -0.08708630f, 0.04004240f, -0.09497090f, 
    0.04472825f, 0.18915784f, -0.27700496f, 0.10979147f, 0.03957547f, -0.02995763f, 0.10448330f, -0.07332226f, 
    -0.05411832f, 0.01262278f, 0.05369073f, 0.21943523f, -0.00021294f, -0.08941869f, -0.12222845f, 0.01597028f, 
    -0.07318436f, 0.00560651f, -0.31972358f, 0.03857773f, 0.06936034f, 0.17120467f, -0.00182224f, 0.52251273f, 
    0.32002580f, 0.01130255f, -0.00625925f, -0.12089372f, -0.07596733f, -0.40169594f, -0.22205429f, -0.05382631f, 
    -0.29766187f, -0.15443718f, -0.05838327f, -0.08101577f, -0.08471681f, -0.23811497f, 0.03294639f, -0.08882854f, 
    0.01705316f, -0.31267184f, -0.01165544f, -0.04558878f, -0.11845364f, 0.07759024f, -0.18800658f, -0.33361861f, 
    -0.30612692f, -0.00575238f, -0.08320251f, -0.24539004f, -0.23014019f, -0.05714171f, 0.03611578f, -0.04452804f, 
    0.16370587f, -0.05117596f, -0.02909485f, -0.06930444f, -0.05494967f, 0.25070634f, 0.01958358f, 0.26785576f, 
    -0.06692391f, -0.42490378f, 0.02178117f, -0.06825095f, 0.02882511f, 0.09202155f, -0.09158047f, 0.13933142f, 
    -0.03516101f, 0.00574411f, -0.04708674f, 0.01352233f, -0.00262989f, 0.02496986f, -0.02969305f, 0.00190155f, 
    0.01693512f, -0.01838179f, 0.05088625f, 0.04981463f, -0.00348649f, -0.06483794f, 0.02794225f, 0.04483630f, 
    0.02181568f, -0.06573796f, 0.00879079f, -0.03867058f, -0.03690263f, 0.01646909f, -0.05825703f, 0.02067532f, 
    -0.00060689f, -0.01878048f, 0.04244602f, 0.00062614f, -0.05656358f, 0.01534521f, -0.01007477f, -0.04595808f, 
    -0.04804398f, -0.00896368f, 0.01402767f, 0.01731578f, -0.04870821f, -0.02615584f, -0.03222878f, 0.00837742f, 
    -0.04174196f, -0.04883194f, 0.02689509f, 0.02640471f, 0.04627906f, 0.00360863f, -0.04791902f, 0.02818275f, 
    -0.06030031f, -0.00047808f, 0.00527697f, 0.03801064f, -0.06121635f, -0.05507610f, -0.06537563f, 0.04878891f, 
    0.05082372f, 0.03374350f, 0.02901889f, 0.04764237f, 0.04784532f, -0.05891043f, 0.04002142f, 0.04548462f, 
    -0.02885920f, 0.03534113f, 0.03965897f, 0.03093122f, 0.03963868f, -0.00369422f, 0.00870664f, 0.04299059f, 
    0.02939204f, 0.00244647f, 0.02573763f, -0.03028101f, 0.04074329f, -0.05440098f, -0.05038906f, -0.02367748f, 
    -0.04227134f, 0.04542356f, -0.04948744f, -0.02290162f, -0.04971803f, -0.02255632f, 0.00976876f, 0.03235840f, 
    0.04915507f, -0.02661947f, -0.05335734f, -0.01517320f, 0.03706263f, 0.02434539f, -0.04586977f, 0.02970155f, 
    -0.05078673f, 0.00125484f, -0.01639391f, -0.05365048f, -0.03536447f, 0.01557402f, -0.05281445f, -0.06143951f, 
    0.03741368f, -0.01875734f, -0.04630132f, 0.03424116f, 0.03036644f, -0.04975232f, -0.02310930f, 0.01616696f, 
    -0.01800760f, -0.04454330f, 0.03294362f, 0.00877724f, -0.03807820f, -0.00671609f, -0.01408441f, -0.03416997f, 
    -0.00579786f, -0.01623127f, 0.02472404f, 0.03206658f, -0.00746248f, 0.03638791f, -0.02497063f, 0.03371972f, 
    -0.00546721f, -0.05042633f, 0.05075809f, 0.03234607f, 0.04302075f, -0.05606280f, -0.00269165f, -0.04331075f, 
    0.05070048f, -0.02660586f, -0.05853392f, 0.03654872f, -0.05526770f, 0.01805769f, -0.05099938f, 0.00712498f, 
    -0.03686744f, 0.01890779f, -0.01629079f, -0.02563763f, -0.02954422f, 0.04338381f, -0.01363616f, -0.00012686f, 
    -0.02461640f, 0.04666965f, 0.00549858f, -0.03351258f, -0.04163094f, -0.03747615f, -0.02204612f, 0.04349431f, 
    0.03314858f, -0.04144722f, -0.00776384f, -0.03809106f, -0.02486704f, 0.02152747f, -0.03551516f, -0.04830813f, 
    0.01803565f, -0.06086920f, -0.03390286f, -0.04046277f, -0.02432097f, 0.01361853f, 0.01344690f, 0.00900808f, 
    0.03258388f, -0.05708669f, 0.02467668f, -0.02136049f, 0.01401433f, 0.03717506f, -0.04699494f, -0.01125211f, 
    -0.00689525f, -0.01991934f, -0.02472218f, 0.01066803f, -0.02992223f, -0.02441186f, 0.03749298f, -0.04036061f, 
    0.04511634f, 0.05233036f, 0.03214601f, 0.00703675f, 0.02331817f, 0.00074994f, -0.00659892f, -0.06169190f, 
    -0.00079250f, 0.02836743f, 0.01267846f, 0.02233443f, 0.02636450f, -0.04474823f, -0.05463147f, -0.02799540f, 
    -0.02766489f, -0.05082487f, 0.01023853f, -0.04962749f, 0.01653718f, -0.05753551f, -0.02990774f, 0.04855196f, 
    -0.00440549f, 0.02455983f, 0.02731555f, 0.01725451f, -0.03702613f, 0.00938945f, 0.03233670f, -0.01283412f, 
    0.03527874f, -0.01645763f, -0.00053058f, 0.00904801f, -0.01495535f, -0.03170867f, 0.03185202f, -0.03237499f, 
    -0.03430756f, -0.03945598f, -0.04664967f, -0.03227352f, -0.03339570f, 0.00097476f, -0.04107088f, -0.01091723f, 
    -0.04477114f, 0.03729993f, 0.00422066f, -0.01141591f, 0.01802237f, -0.02666469f, -0.00111509f, -0.01645889f, 
    0.02634021f, -0.05240935f, 0.01289516f, 0.02680503f, 0.00835341f, -0.05604691f, -0.06586432f, -0.06198239f, 
    -0.00462158f, -0.04702425f, -0.03444945f, 0.04230160f, -0.02402475f, -0.00492710f, 0.01516624f, 0.00075694f, 
    -0.02629771f, 0.02612632f, -0.01930478f, -0.06145792f, 0.01863515f, -0.04086006f, -0.01165876f, -0.01899856f, 
    -0.02760890f, -0.00362529f, -0.05695730f, 0.00444056f, -0.00285329f, -0.03846699f, -0.01299096f, 0.02431502f, 
    -0.06067712f, 0.02913764f, -0.05715609f, -0.04371542f, -0.00679451f, -0.05794734f, 0.05067706f, -0.04284054f, 
    -0.06782268f, 0.00846863f, -0.04120652f, 0.11701959f, 0.07628139f, 0.08093841f, 0.01638346f, 0.13062958f, 
    0.20628993f, 0.10671555f, -0.04962125f, 0.13611169f, 0.14742018f, 0.07110154f, 0.11319242f, -0.05093050f, 
    0.11923214f, -0.09505317f, -0.33385813f, -0.42718470f, -0.00778838f, 0.07656822f, -0.02492142f, 0.01505645f, 
    0.08491451f, 0.09797184f, 0.18974580f, -0.35572058f, -0.05492042f, 0.01199659f, 0.48644918f, -0.00260339f, 
    -0.13548596f, 0.08487845f, 0.12480080f, 0.13345915f, -0.15577182f, -0.00739667f, -0.00725211f, -0.15960541f, 
    0.02722966f, 0.02254774f, 0.37400451f, 0.20876537f, 0.11844771f, 0.36333966f, -0.06711434f, -0.07786484f, 
    0.12897153f, -0.26043537f, 0.32628891f, -0.04013303f, 0.06756213f, 0.04794292f, 0.06582586f, 0.02363680f, 
    -0.06091476f, -0.11829967f, -0.01529109f, -0.03703772f, 0.04853150f, 0.02707573f, -0.05266164f, 0.17908669f, 
    -0.20837121f, 0.21474083f, 0.09255679f, -0.14869973f, 0.19194232f, 0.32367495f, 0.21731625f, -0.07876521f, 
    0.07167621f, -0.18815045f, -0.08144598f, -0.02566441f, 0.13959989f, 0.01129838f, 0.19168210f, 0.04099724f, 
    0.09660260f, -0.23287810f, -0.04570889f, -0.11695735f, -0.12143662f, 0.09977760f, -0.03843812f, 0.10180216f, 
    -0.01157933f, 0.16151311f, 0.07848519f, -0.20960452f, -0.18961838f, 0.39837486f, -0.03182811f, 0.01518876f, 
    0.04664718f, -0.15987051f, -0.14191437f, 0.21122380f, -0.14564399f, -0.12750003f, 0.22804813f, -0.02555488f, 
    0.15149979f, 0.33529496f, 0.25508457f, 0.03770520f, -0.20938523f, -0.22176118f, -0.12400798f, -0.13406493f, 
    -0.08731773f, -0.18702893f, 0.13391902f, 0.07442094f, 0.20607246f, -0.30453947f, -0.30410877f, -0.16121523f, 
    0.06211789f, 0.04137681f, 0.00607356f, 0.11015644f, 0.00087151f, 0.00237666f, 0.09058905f, -0.19817734f, 
    -0.13885505f, 0.09233409f, 0.04637185f, -0.04861326f, -0.06704875f, 0.18353006f, 0.07717042f, -0.16795610f, 
    -0.23262572f, 0.15829577f, 0.16600749f, 0.11626127f, 0.13792965f, -0.10538414f, 0.05513422f, 0.01582818f, 
    0.08722585f, -0.00639370f, 0.43234015f, 0.39213192f, 0.23138666f, -0.15621972f, 0.41939881f, 0.06117178f, 
    0.13225558f, -0.08257532f, -0.05864373f, -0.21699455f, 0.04127607f, 0.23321119f, -0.00182181f, -0.03665397f, 
    -0.01488628f, 0.06990994f, 0.05384995f, -0.02632926f, -0.07250679f, 0.09997537f, -0.01023829f, 0.06863300f, 
    0.18384431f, 0.30727655f, 0.16963384f, 0.11167540f, 0.17672583f, -0.13319762f, -0.07818368f, -0.04881829f, 
    0.09120969f, 0.28750587f, 0.29530382f, 0.04692137f, -0.13202375f, 0.00322451f, 0.24827529f, -0.10741302f, 
    0.01549417f, -0.20222552f, 0.20178242f, 0.09480435f, 0.25549790f, -0.01716433f, 0.02444854f, -0.08030512f, 
    -0.15719678f, 0.14865592f, -0.05845328f, 0.21913202f, 0.16598178f, -0.03663401f, -0.27862889f, -0.08444018f, 
    0.05967841f, 0.08182007f, -0.02739215f, -0.21791688f, 0.01537455f, 0.09613967f, 0.13001201f, 0.02140561f, 
    0.01153369f, 0.17423335f, 0.08165079f, 0.14297347f, 0.10597016f, 0.06366609f, 0.03942571f, -0.01871778f, 
    -0.19743435f, -0.05400743f, 0.00065563f, 0.05517423f, -0.18509334f, 0.10001203f, 0.11037257f, 0.01382584f, 
    0.10442183f, 0.02529287f, -0.16464354f, -0.16082199f, -0.11662950f, -0.08143946f, -0.08595155f, -0.17613995f, 
    -0.22893226f, -0.26119691f, 0.11729205f, 0.25852349f, -0.02940219f, 0.15368907f, -0.10015601f, 0.17294052f, 
    0.39139736f, 0.12284223f, 0.11936621f, -0.03709981f, 0.27181900f, 0.11401296f, 0.01255529f, 0.00175286f, 
    0.05356814f, -0.17874317f, -0.28981805f, 0.04062310f, -0.23846465f, -0.05839058f, 0.30260020f, 0.09607632f, 
    0.05980411f, 0.03195016f, -0.01766027f, -0.06816442f, -0.16038762f, -0.35462835f, -0.02425335f, -0.08978431f, 
    -0.08923520f, 0.05687176f, 0.14319266f, -0.16024180f, -0.29005787f, -0.25095358f, -0.04421968f, -0.14570788f, 
    -0.07779546f, -0.07727047f, 0.08260475f, -0.00196906f, 0.06057768f, -0.13769901f, -0.17380828f, 0.04875438f, 
    -0.00936778f, 0.14055163f, -0.04962094f, 0.06127292f, -0.00658487f, 0.07198752f, 0.07121045f, 0.16943376f, 
    -0.15644887f, -0.52120739f, -0.26665837f, -0.11718775f, 0.04711708f, -0.00217369f, -0.27074212f, -0.01184819f, 
    -0.09912661f, 0.02441726f, 0.34345871f, 0.11770207f, 0.06272294f, 0.06546639f, -0.14700413f, -0.07442375f, 
    -0.00821991f, -0.01189522f, 0.24735618f, 0.35261130f, 0.08794839f, -0.21491626f, 0.00194584f, -0.19780363f, 
    0.06899110f, 0.08095646f, 0.04826567f, -0.85975468f, -0.25365549f, -0.40131333f, 0.11650178f, -0.22470044f, 
    0.00156630f, -0.06485666f, 0.28219914f, 0.11699998f, 0.19470382f, -0.03368340f, 0.02288127f, -0.01457945f, 
    -0.01725704f, -0.01982808f, -0.27320513f, 0.09165992f, 0.10617975f, -0.87152499f, -0.30061075f, -0.08980862f, 
    0.02016932f, -0.21787477f, -0.24179773f, 0.07397126f, -0.01998380f, -0.15129052f, 0.04534773f, -0.37077370f, 
    -0.32503226f, 0.15016823f, -0.24310926f, -0.10560246f, -0.03131028f, 0.08083009f, 0.02235788f, 0.39858094f, 
    0.40891522f, -0.10917894f, 0.04779410f, 0.04609061f, -0.00702579f, -0.06869588f, -0.02401191f, 0.03575917f, 
    0.14083500f, 0.42769122f, 0.07093683f, -0.23037033f, -0.21553795f, -0.02889697f, -0.12094475f, 0.00126580f, 
    0.07446226f, -0.01566558f, 0.09412748f, -0.12013806f, -0.10001171f, 0.00958759f, 0.11850441f, -0.11506487f, 
    0.08381277f, 0.17657757f, -1.04379976f, -0.55148000f, 0.17231244f, -0.04305009f, 0.04154020f, 0.27270210f, 
    -0.11704727f, 0.19927718f, 0.19640414f, -0.85337162f, 0.02023557f, 0.41211945f, -0.43568078f, 0.23983259f, 
    0.15294148f, 0.13603452f, -0.10863971f, -0.07000928f, 0.23636465f, -0.00348522f, -0.06270617f, 0.05327689f, 
    -0.08986904f, -0.00846526f, -0.02062190f, 0.06063646f, 0.22240585f, 0.33571264f, 0.40775728f, 0.18994267f, 
    -0.12089700f, 0.08479853f, 0.02454504f, -0.04997432f, 0.07016231f, 0.06493821f, 0.55261707f, -0.11613999f, 
    -0.22107364f, 0.01835516f, 0.02433111f, -0.08082166f, 0.01116890f, -0.03856807f, -0.00787900f, -0.25510332f, 
    0.23390521f, 0.16522750f, 0.01284243f, 0.06725713f, -0.03916464f, -0.03849474f, -0.13126478f, 0.18930352f, 
    -0.11479294f, -0.31841630f, 0.05539529f, -0.11213246f, 0.06097926f, -0.12654555f, -0.26303107f, -0.18225202f, 
    -0.02641792f, -0.14142257f, -0.47643834f, 0.16335469f, -0.04018828f, 0.05236728f, 0.10553508f, -0.00541441f, 
    0.11214299f, 0.04446226f, -0.24727482f, -0.07688881f, -0.14990909f, -0.00249409f, -0.08805835f, 0.02167037f, 
    -0.00737877f, -0.08625037f, -0.09351253f, 0.05020489f, -0.04574860f, -0.10169107f, 0.06682427f, -0.18292469f, 
    -0.22443357f, -0.16971780f, -0.11696301f, 0.03181212f, 0.10419527f, 0.01090430f, -0.18140924f, -0.34286103f, 
    -0.16250791f, -0.31818992f, -0.08210245f, 0.05230604f, 0.13350083f, 0.17607763f, -0.12950189f, -0.40321362f, 
    -0.07070111f, -0.06443741f, 0.12201365f, -0.26768866f, -0.01966503f, -0.15448572f, 0.41024289f, 0.10216329f, 
    0.08512887f, -0.03396183f, 0.09778532f, 0.19602382f, -0.07409924f, 0.01281855f, -0.03106299f, 0.62999785f, 
    0.09838793f, -0.44318244f, -0.09789334f, 0.06899049f, -0.06155320f, -0.05898911f, -0.04178887f, -0.07608715f, 
    0.19618516f, 0.17379227f, -0.12164979f, 0.05040893f, -0.09412044f, 0.06442074f, 0.05769110f, 0.12870750f, 
    0.06097117f, 0.01451443f, -0.18126267f, -0.22631244f, 0.00562891f, -0.03518684f, -0.06912361f, 0.04068765f, 
    0.11460407f, -0.04439214f, -0.33321708f, -0.33248982f, -0.62819952f, -0.07121520f, -0.31513289f, 0.09451082f, 
    -0.07541503f, 0.15475160f, -0.18162119f, 0.31671774f, -0.05377376f, 0.35417509f, 0.00696951f, 0.02793742f, 
    0.10665101f, 0.13759854f, 0.13031629f, -0.05187777f, 0.43284783f, -0.10325394f, 0.27201119f, 0.02508525f, 
    -0.03517418f, -0.04255339f, 0.13811348f, -0.02145340f, 0.06525251f, 0.94397670f, -0.20910524f, 0.08480022f, 
    0.01690257f, 0.13753246f, 0.20298921f, 0.25391185f, 0.04003580f, 0.12056110f, -0.05852866f, -0.43193752f, 
    0.03024564f, -0.17077093f, -0.10549392f, -0.01512366f, 0.11874726f, -0.26514310f, -0.07795472f, 0.24904707f, 
    0.29836902f, -0.00514595f, -0.12463384f, -0.06330300f, 0.01272466f, 0.09811396f, -0.02772702f, 0.19349180f, 
    -0.17058772f, -0.11460401f, -0.08407835f, 0.03077598f, 0.05812848f, -0.04856199f, 0.11090676f, -0.00035745f, 
    -0.33893532f, -0.15052021f, 0.11279356f, 0.24127427f, 0.18697488f, 0.15035667f, -0.17492302f, -0.06566407f, 
    0.08748199f, -0.05381751f, 0.29928944f, -0.02119787f, -0.21501419f, -0.01331130f, 0.05199216f, 0.13022980f, 
    0.13753235f, -0.16741855f, 0.06023887f, 0.15720761f, 0.04894060f, -0.57122886f, 0.14644125f, 0.04072567f, 
    -0.21394464f, 0.11068434f, -0.14412825f, 0.02425850f, 0.02139174f, 0.03306065f, -0.07831992f, 0.20000295f, 
    0.01593810f, -0.14077370f, -0.43119261f, -0.11467256f, -0.03010062f, -0.22571154f, -0.08243062f, -0.09179921f, 
    0.17683844f, -0.02401279f, 0.09550061f, 0.34642965f, 0.06764331f, -0.16977587f, 0.34353590f, 0.46183506f, 
    0.17223482f, -0.16199055f, -0.12569499f, -0.06211515f, 0.12847202f, 0.13086745f, -0.12063783f, -0.02851258f, 
    -0.11575352f, 0.20445929f, 0.03476277f, 0.25164530f, -0.35093969f, -0.15339127f, -0.17321010f, -0.11493737f, 
    0.13744625f, 0.09104702f, 0.12638745f, 0.03389812f, 0.00871100f, -0.00001783f, -0.19195071f, -0.07943703f, 
    -0.07595895f, -0.23295185f, -0.12455755f, 0.04866654f, 0.13695481f, 0.20099942f, 0.16174775f, 0.13863215f, 
    0.05881088f, -0.14356090f, 0.20421904f, -0.06023757f, -0.25342405f, 0.12024770f, 0.03356015f, -0.00290943f, 
    -0.01293889f, -0.41624448f, -0.06664782f, 0.25054282f, 0.28244355f, -0.16447981f, -0.00933034f, 0.29265949f, 
    -0.16864051f, 0.10467818f, -0.30025288f, -0.19172487f, -0.04560066f, -0.06308079f, -0.07065953f, 0.12644506f, 
    0.09749988f, 0.02813860f, 0.00420356f, -0.01250198f, 0.06965276f, 0.16526310f, -0.00411002f, 0.06361683f, 
    -0.04164355f, 0.22855000f, 0.21407673f, -0.05431379f, -0.09609119f, 0.08233403f, 0.30823946f, 0.54318160f, 
    -0.14206378f, -0.02221357f, -0.03453520f, -0.07124195f, 0.22319596f, -0.12627488f, -0.23307367f, 0.47476891f, 
    0.00869874f, -0.00045946f, -0.03718508f, 0.20361248f, 0.25256312f, 0.19638257f, -0.09222898f, -0.17430414f, 
    -0.07259652f, -0.12858351f, -0.00648058f, 0.02587842f, 0.07709564f, 0.00086987f, -0.01085566f, -0.00215524f, 
    -0.05605906f, -0.24094985f, -0.10430828f, -0.05085013f, 0.01637817f, 0.11379164f, 0.08661800f, 0.14372940f, 
    -0.02098710f, -0.27246425f, -0.06282325f, -0.09589463f, -0.04138635f, 0.02134968f, 0.07272575f, -0.10758457f, 
    -0.20024341f, -0.45781857f, -0.07100257f, 0.06683828f, 0.15147643f, 0.04859619f, -0.06398650f, 0.00388435f, 
    -0.09725756f, 0.04041563f, -0.34101051f, 0.00616800f, 0.18324018f, 0.39912951f, -0.02427362f, -0.20547085f, 
    0.02294260f, -0.16259894f, 0.02013249f, -0.15176383f, -0.12682560f, 0.05880474f, 0.20279868f, 0.02225756f, 
    0.11915763f, 0.05319055f, 0.10637207f, -0.09717227f, 0.06512496f, -0.25264695f, 0.34802336f, -0.16199119f, 
    -0.16559596f, 0.01536298f, -0.14660758f, 0.02310646f, 0.04060596f, 0.00432798f, -0.06033414f, -0.24218591f, 
    -0.09547962f, 0.23597609f, 0.02632214f, 0.05478689f, -0.18748175f, 0.03404162f, -0.04768947f, -0.03827840f, 
    0.16086240f, -0.15038538f, 0.03924581f, -0.03420646f, 0.02932237f, 0.01311322f, 0.17721084f, -0.20955306f, 
    -0.00474560f, 0.01258608f, 0.59836584f, 0.13136476f, 0.00567773f, -0.00759214f, -0.00799236f, 0.17862220f, 
    0.04902492f, -0.04756333f, -0.06734043f, -0.09770103f, -0.05574965f, 0.22774312f, 0.05729020f, -0.17714854f, 
    -0.00979029f, -0.02363986f, 0.16430177f, -0.02553824f, -0.13591857f, -0.23599972f, 0.06014667f, 0.02400360f, 
    0.05851188f, 0.23841856f, 0.19505028f, 0.05924239f, 0.13889091f, -0.15805462f, 0.01085743f, 0.16327348f, 
    0.02170723f, 0.01859566f, 0.08644699f, 0.13678327f, 0.21916291f, -0.47959557f, -0.27329811f, 0.16897389f, 
    0.08315634f, 0.13209957f, -0.11097936f, 0.11230733f, 0.10212939f, -0.02910218f, 0.17797142f, 0.25882685f, 
    0.06914631f, 0.07017077f, 0.04214434f, 0.06829477f, 0.09600268f, -0.07723089f, -0.13833892f, -0.08587186f, 
    -0.20439108f, 0.06528424f, 0.01740824f, 0.22929141f, 0.11056705f, 0.08039622f, 0.01179288f, 0.11323775f, 
    0.28702813f, 0.05366589f, -0.01652099f, -0.02054676f, -0.15882623f, -0.02574649f, 0.13488176f, 0.03305479f, 
    0.13613771f, 0.36593705f, 0.17015988f, 0.01188817f, 0.18578719f, 0.13610622f, -0.17102087f, 0.15511367f, 
    0.00256097f, 0.02329255f, -0.38312262f, -0.02109264f, 0.38001963f, -0.13290615f, -0.02751772f, 0.15782398f, 
    0.08798455f, -0.02335849f, 0.11950161f, 0.44534388f, 0.22174375f, 0.01904704f, -0.07270367f, 0.29177284f, 
    0.18715507f, 0.16803715f, 0.31005538f, -0.01064886f, -0.02126706f, -0.08987851f, -0.15031707f, -0.31545991f, 
    -0.18113160f, 0.04268339f, 0.07235882f, 0.20182614f, 0.25766519f, 0.30896932f, 0.13338795f, -0.01435252f, 
    -0.10378160f, 0.25317913f, 0.13194342f, -0.19548264f, 0.05577508f, -0.13021877f, 0.17607643f, -0.09939373f, 
    0.01695741f, -0.03663541f, -0.15642604f, -0.17991649f, -0.00788452f, 0.04438943f, 0.02418655f, 0.06644026f, 
    -0.41272411f, 0.04215709f, 0.16625108f, 0.01897360f, -0.10599449f, 0.08463049f, 0.06955031f, 0.04915434f, 
    -0.07950301f, -0.09447800f, 0.48627546f, -0.10200743f, 0.11878467f, -0.08072136f, 0.09801958f, 0.11054073f, 
    -0.01893617f, 0.02854122f, 0.19491345f, 0.10253468f, 0.10375849f, -0.17136928f, -0.09676743f, 0.13638043f, 
    0.00231314f, 0.02692353f, 0.21112932f, -0.30524564f, -0.15498298f, -0.07146434f, 0.02273758f, 0.11113127f, 
    -0.22199042f, -0.09867955f, -0.16324648f, -0.33475402f, -0.31998259f, 0.10724856f, 0.07741580f, -0.15240031f, 
    0.11653928f, -0.13752520f, 0.01991364f, 0.09337111f, 0.09860793f, 0.08690999f, 0.04454267f, 0.23663037f, 
    -0.22438426f, -0.06636529f, -0.04836988f, 0.16431570f, 0.06326866f, -0.02938827f, 0.04340898f, 0.39620078f, 
    -0.13618122f, -0.03812475f, 0.10460797f, 0.06448163f, -0.06924602f, -0.11195828f, -0.28337765f, -0.14726566f, 
    0.01476884f, 0.06197997f, -0.09478816f, -0.06938187f, 0.01941894f, -0.03175732f, 0.07065064f, -0.25468010f, 
    -0.08923607f, 0.14542206f, 0.18039788f, 0.08682456f, -0.00901810f, 0.08936848f, 0.09713836f, -0.01791346f, 
    0.40258762f, 0.40530482f, 0.21282724f, 0.09141563f, 0.12764373f, 0.07234494f, -0.07773330f, -0.00541653f, 
    0.38902867f, 0.15867417f, 0.12564735f, -0.00762526f, -0.22155647f, -0.12701067f, -0.12964325f, 0.06952201f, 
    0.09807821f, 0.02377298f, 0.10121972f, -0.13708924f, -0.06734323f, -0.24604811f, -0.02034867f, -0.02800779f, 
    0.15480137f, 0.01263870f, -0.03326454f, -0.40672901f, -0.36401951f, 0.17388169f, -0.11622918f, -0.01503842f, 
    -0.12702394f, 0.02771377f, -0.02998574f, 0.07718091f, -0.29252082f, -0.14716350f, -0.07193486f, 0.13850665f, 
    -0.05988970f, -0.21047717f, -0.08122647f, 0.11109239f, 0.29815078f, 0.06343276f, 0.00150370f, 0.04798232f, 
    0.03204281f, -0.21966268f, -0.04470160f, 0.10436638f, -0.06818628f, 0.02155601f, -0.17887360f, -0.08625434f, 
    0.10880189f, 0.02653258f, 0.02550101f, 0.02352184f, 0.07366997f, -0.06017061f, 0.09020701f, 0.23002480f, 
    -0.16155644f, 0.07711030f, 0.07733888f, 0.04729788f, -0.17448735f, 0.00651728f, -0.11415523f, 0.05477696f, 
    0.14807352f, -0.19255556f, 0.15462539f, -0.01670680f, 0.21982861f, -0.10179505f, 0.04573170f, 0.16387542f, 
    0.09918505f, 0.12758411f, 0.17629062f, 0.04138714f, 0.13263726f, -0.05991965f, -0.11843442f, 0.03358201f, 
    -0.29363507f, -0.27708629f, 0.59838802f, 0.29710582f, -0.24664606f, 0.00216169f, 0.08657270f, 0.29666576f, 
    -0.06149900f, 0.06060949f, 0.17235416f, -0.29509780f, -0.19829060f, -0.12245291f, -0.13159385f, 0.04209862f, 
    -0.05978362f, -0.12883024f, -0.20098718f, -0.19480196f, -0.46075016f, -0.04910724f, 0.21374315f, -0.10212325f, 
    -0.12952013f, -0.10348332f, -0.07349092f, 0.09764788f, -0.07608370f, -0.29713961f, -0.09063687f, 0.09806001f, 
    0.05364481f, 0.23733743f, -0.23603421f, -0.10564665f, -0.05825358f, -0.09118237f, 0.15974551f, 0.09588657f, 
    -0.14107923f, 0.00881254f, -0.23034814f, 0.00499327f, -0.03135429f, -0.39730656f, -0.53349066f, 0.08530874f, 
    -0.28649598f, 0.27263185f, 0.09265416f, 0.17933737f, -0.10160657f, -0.01796451f, 0.10256563f, -0.08576146f, 
    -0.00447657f, 0.02807755f, 0.04033840f, -0.02785786f, 0.00854734f, 0.00310834f, 0.02549092f, -0.01583482f, 
    -0.06271090f, -0.02016575f, 0.03784047f, -0.05760553f, -0.00363660f, -0.03015860f, -0.03908595f, -0.05339228f, 
    -0.00167983f, 0.01453241f, -0.04111814f, 0.00447917f, -0.00432645f, -0.03857357f, -0.01886532f, -0.05445404f, 
    0.01106096f, -0.00844315f, 0.00929303f, -0.03809950f, 0.01416910f, -0.06374449f, -0.00358397f, 0.00017732f, 
    -0.03996963f, -0.06443813f, -0.04203214f, 0.04158776f, 0.00347116f, -0.01213537f, -0.02269169f, -0.01610294f, 
    -0.04810775f, 0.02933243f, -0.06567951f, 0.03358663f, -0.06676403f, 0.00536956f, -0.06511137f, -0.04119136f, 
    0.01250604f, -0.03038289f, 0.03716525f, -0.01420982f, -0.02395787f, 0.03746811f, -0.01804860f, 0.02334684f, 
    0.01788861f, 0.03174235f, 0.04561280f, -0.03239467f, 0.02067913f, -0.06583751f, -0.00933849f, 0.01206890f, 
    0.01341828f, -0.05626524f, -0.04339551f, 0.02515162f, -0.02446231f, -0.05299842f, -0.02774741f, -0.06907757f, 
    0.04463742f, 0.02257945f, 0.01096062f, 0.01165329f, -0.00340457f, 0.00959407f, -0.04047011f, 0.00779049f, 
    -0.00834658f, -0.06289263f, 0.01520194f, -0.05044599f, -0.00982260f, -0.06293365f, -0.00608532f, 0.03000198f, 
    0.04082073f, 0.02448651f, -0.01928277f, -0.00014650f, -0.02921320f, -0.03947646f, -0.03314459f, -0.01506620f, 
    0.02266946f, 0.03931072f, -0.00923046f, -0.01612269f, 0.03817509f, -0.02390228f, 0.01840890f, 0.04340766f, 
    0.00165983f, -0.04133095f, -0.03084888f, -0.04924329f, -0.03132932f, 0.03094446f, 0.00525481f, -0.00336158f, 
    -0.03589181f, 0.03399601f, 0.02958260f, -0.01537305f, -0.02810695f, 0.01615171f, -0.05493955f, 0.02142994f, 
    -0.03128524f, 0.00376227f, 0.00067606f, -0.01068587f, -0.01459383f, -0.03264562f, -0.05872809f, 0.03243401f, 
    0.02515249f, -0.05712035f, -0.01522867f, 0.03405223f, 0.01343806f, -0.03747402f, 0.00209319f, -0.06404710f, 
    -0.04181822f, -0.05596299f, -0.04529313f, -0.02482723f, -0.01263405f, 0.03128540f, -0.01854371f, -0.04265985f, 
    0.00039931f, -0.01825209f, 0.04274316f, -0.03159228f, -0.04422209f, 0.02050783f, -0.00409724f, -0.05700635f, 
    0.04305450f, 0.02488017f, -0.02727512f, -0.04051044f, -0.06080289f, -0.00299732f, -0.04429798f, 0.02065675f, 
    0.04568491f, 0.03422896f, -0.00697697f, 0.02872217f, 0.01465784f, -0.00064767f, -0.03502708f, -0.06572622f, 
    0.03639726f, 0.04037393f, -0.05894169f, 0.04038006f, -0.03272257f, 0.00469515f, 0.04199988f, 0.03771840f, 
    -0.05513673f, -0.03209952f, -0.02952194f, 0.03704581f, -0.01488870f, -0.06166792f, 0.02753287f, -0.02981517f, 
    -0.02450144f, 0.03457999f, 0.02001063f, -0.02700076f, -0.05471352f, -0.02387262f, 0.01298435f, -0.00883962f, 
    0.00354899f, 0.00080627f, 0.01113705f, 0.02763497f, -0.04254645f, 0.04929865f, -0.04760236f, -0.03880849f, 
    -0.00250466f, 0.04886127f, -0.03299652f, -0.05392129f, -0.02069821f, 0.01822178f, -0.02829756f, -0.05703525f, 
    -0.03599764f, -0.02393996f, 0.04630749f, 0.04519840f, 0.01011951f, -0.02373469f, -0.04771867f, 0.02396721f, 
    0.04272077f, -0.00345158f, 0.02317398f, -0.06361845f, -0.00941351f, -0.05222980f, -0.03225218f, -0.00861415f, 
    -0.00031043f, -0.02792986f, -0.05129889f, -0.03405424f, 0.01430896f, 0.01966689f, -0.01426597f, -0.03806921f, 
    -0.04753091f, -0.05992605f, -0.04153471f, 0.02076646f, -0.03913039f, -0.01466113f, 0.03016857f, -0.02479801f, 
    0.02159884f, -0.06567721f, -0.06286940f, -0.04302603f, -0.02729046f, 0.04575705f, -0.03241797f, 0.01320588f, 
    -0.00558172f, 0.04890688f, 0.00270777f, -0.04183327f, 0.02128005f, 0.03440736f, -0.02217842f, -0.06239785f, 
    -0.04119600f, 0.03329981f, 0.04228313f, 0.02923029f, 0.03473983f, -0.01325249f, 0.02423831f, -0.03111098f, 
    0.03943174f, 0.03050745f, -0.04993520f, -0.03435012f, 0.01835301f, -0.06432324f, -0.04743343f, -0.02109740f, 
    -0.04690667f, -0.01285251f, 0.03306620f, -0.02287266f, 0.00619229f, -0.01483248f, 0.00316477f, -0.04180931f, 
    -0.00370939f, 0.00214420f, -0.04233257f, -0.04152532f, 0.04350836f, -0.02557387f, 0.02563004f, -0.01843541f, 
    -0.00666713f, -0.01102074f, 0.17140310f, -0.03481267f, 0.10022802f, 0.00720122f, -0.02875590f, 0.01011978f, 
    -0.11566701f, 0.19742887f, 0.13304234f, 0.18637113f, -0.01409310f, 0.13025454f, 0.09080723f, -0.07280011f, 
    -0.09346129f, -0.03334152f, 0.03895061f, 0.16117358f, 0.24269052f, 0.03340748f, 0.11283883f, -0.08797837f, 
    -0.03415111f, 0.05597235f, -0.18822995f, 0.37794682f, -0.24689370f, 0.36804086f, -0.08676792f, 0.05705286f, 
    0.14426145f, -0.02908283f, -0.11367459f, 0.16783649f, 0.04144678f, -0.02498105f, -0.00491935f, 0.07856324f, 
    0.03125728f, -0.00686876f, -0.16700161f, -0.14633740f, -0.07682467f, -0.21473676f, 0.00414243f, 0.12394877f, 
    0.13897629f, -0.01848938f, 0.02473771f, 0.10877662f, 0.10253391f, -0.00567435f, -0.30562526f, -0.16459255f, 
    -0.04903961f, -0.02983959f, 0.14697075f, -0.00303581f, 0.03871604f, 0.13500872f, 0.02981775f, -0.17283171f, 
    0.10443057f, 0.20950809f, -0.19341908f, 0.08671224f, -0.03437432f, 0.06697518f, 0.02182456f, -0.10672846f, 
    -0.07384425f, -0.00691203f, 0.23243997f, 0.03009430f, 0.05144468f, 0.06096709f, -0.09473187f, -0.10128701f, 
    -0.08368403f, 0.07323601f, -0.00125627f, 0.13062416f, 0.08390749f, 0.15041968f, 0.13079299f, 0.06901127f, 
    0.00402680f, 0.08120440f, 0.29527876f, 0.02761196f, -0.12267693f, -0.24277860f, 0.05346972f, 0.13204296f, 
    0.23432560f, 0.13297340f, -0.07434106f, -0.34550193f, -0.34579065f, 0.05860449f, -0.16948713f, -0.06053930f, 
    0.09733424f, -0.14917493f, 0.04360932f, -0.29413348f, -0.02540083f, 0.13438433f, 0.10593910f, 0.13475725f, 
    0.03311431f, 0.02934844f, -0.04579805f, -0.15395322f, -0.06039261f, -0.20492905f, 0.01684151f, 0.20265558f, 
    -0.16261843f, 0.07570664f, 0.14888385f, -0.07208052f, 0.01060957f, -0.25605631f, -0.27529448f, -0.02021604f, 
    -0.01816863f, -0.00333534f, 0.05262600f, -0.05295489f, -0.14288263f, -0.01195167f, 0.09401864f, 0.47234875f, 
    -0.09160544f, -0.12374894f, -0.06319425f, 0.01340803f, 0.05507467f, -0.10753486f, 0.08733264f, -0.13362873f, 
    0.04463600f, 0.00571853f, 0.41405946f, -0.08514672f, 0.23128156f, 0.07563782f, -0.44757903f, -0.07736445f, 
    0.21808764f, -0.05556644f, 0.04458591f, 0.17089036f, -0.07004978f, -0.00695782f, -0.05809166f, -0.01999622f, 
    -0.00035952f, -0.15123186f, 0.08849788f, -0.01846740f, 0.07068174f, 0.05936779f, 0.11017403f, 0.06172728f, 
    0.04186840f, 0.01144747f, -0.15672326f, -0.11254958f, -0.16811021f, -0.09849806f, -0.05633957f, 0.06457607f, 
    -0.03793162f, -0.14273123f, -0.22536549f, -0.19613355f, -0.44293189f, -0.29091129f, 0.45810458f, -0.00023866f, 
    -0.00760244f, 0.04728675f, -0.10873960f, -0.22814800f, -0.02801483f, -0.03630425f, -0.14320923f, 0.07055224f, 
    0.14657277f, 0.10044732f, 0.00326692f, -0.06662329f, 0.05834406f, 0.08037152f, -0.27554110f, 0.01068451f, 
    0.22337127f, 0.14129172f, 0.09985548f, -0.16121961f, 0.03503734f, 0.19390392f, 0.08886871f, -0.11566920f, 
    0.18017559f, 0.33893245f, -0.14915115f, -0.01725370f, 0.07072651f, 0.11733802f, 0.16850887f, -0.04115089f, 
    -0.17442432f, 0.22305572f, 0.26918501f, 0.04887570f, -0.04355992f, -0.11968297f, 0.20707622f, -0.02251139f, 
    0.08743655f, -0.17150046f, -0.20889412f, 0.17488447f, -0.03825735f, 0.04238569f, 0.04752548f, -0.03931024f, 
    0.04643710f, -0.03044032f, 0.10511953f, 0.12463333f, 0.37441781f, 0.13479553f, -0.09782152f, 0.13578005f, 
    -0.03411477f, -0.17237507f, 0.01433903f, -0.12390058f, -0.02214801f, 0.04119606f, 0.05372779f, 0.16474771f, 
    -0.21989869f, 0.04952074f, 0.01956677f, -0.11365093f, 0.00353933f, 0.21414277f, 0.20046104f, 0.14196509f, 
    0.18193363f, -0.06212912f, -0.13111357f, 0.12594150f, 0.00811782f, -0.19382709f, 0.07551739f, 0.24391082f, 
    -0.17339388f, -0.32796288f, -0.16883300f, 0.00605778f, -0.08588309f, -0.07567609f, -0.01978428f, -0.01873324f, 
    0.10121432f, 0.11778223f, 0.16958645f, 0.12880898f, 0.29799941f, -0.11595716f, 0.13133013f, 0.01612225f, 
    0.12635322f, 0.20440741f, 0.09092185f, 0.11213534f, -0.01021227f, 0.06227728f, -0.13291550f, 0.19357848f, 
    0.04755540f, -0.02294890f, 0.03603469f, 0.01745761f, -0.00912395f, -0.01936403f, -0.05524354f, -0.01047056f, 
    0.02538748f, -0.02119471f, 0.03994111f, 0.02220774f, -0.05258791f, -0.06935301f, -0.03357381f, -0.05514314f, 
    -0.06654369f, 0.02085373f, -0.05638264f, 0.03842734f, 0.02649974f, 0.04196746f, -0.05251516f, 0.03554176f, 
    0.02620099f, -0.06199981f, 0.03621699f, -0.00581355f, -0.00975342f, 0.00421031f, 0.02198763f, -0.03667988f, 
    -0.04081458f, -0.03680759f, -0.02193254f, -0.04214396f, -0.05995438f, -0.00864388f, -0.03857031f, 0.01532930f, 
    -0.03866299f, -0.05734415f, -0.05100484f, 0.04159449f, 0.04795652f, 0.03591573f, -0.05822174f, -0.03645077f, 
    -0.03188711f, 0.00752050f, -0.04298515f, 0.02752227f, -0.05326439f, -0.06600155f, 0.04418160f, 0.03278062f, 
    0.05284325f, 0.04521628f, -0.04284801f, 0.01757869f, 0.00599780f, -0.03542236f, -0.03626641f, 0.01938665f, 
    -0.00478731f, 0.03174730f, 0.04463265f, -0.01441256f, 0.01973106f, -0.06082247f, 0.03147156f, -0.03546362f, 
    0.02800000f, -0.05307901f, 0.03144860f, 0.02058540f, -0.06152754f, 0.04510960f, -0.00038445f, 0.00420670f, 
    0.03288335f, 0.03647860f, -0.03266053f, 0.03017476f, -0.01380695f, 0.00423364f, -0.05575289f, -0.00606687f, 
    -0.02837445f, -0.03949014f, 0.00320910f, 0.03216837f, -0.05864776f, 0.04785737f, -0.04427800f, -0.00132597f, 
    -0.06602552f, 0.03324847f, -0.06231731f, 0.01161812f, 0.03723895f, -0.04098586f, 0.02208441f, 0.02909165f, 
    0.04634605f, 0.03131479f, -0.01095361f, 0.00084639f, -0.04325592f, -0.00245079f, -0.02219532f, -0.02568020f, 
    -0.04700588f, -0.01261796f, -0.01051123f, -0.00082097f, -0.03930395f, -0.01910459f, -0.00437919f, 0.00651017f, 
    -0.05876900f, 0.03514095f, -0.05256427f, -0.02219169f, 0.00691442f, -0.01834078f, -0.00232233f, 0.02753826f, 
    -0.05340781f, -0.01800681f, 0.01498337f, 0.02077490f, -0.03766517f, -0.02198921f, 0.01127285f, 0.04287657f, 
    -0.04723307f, -0.03914244f, -0.05521157f, 0.01615123f, 0.00833590f, -0.04099916f, 0.00289149f, 0.03902364f, 
    0.02836755f, 0.02588691f, 0.02807119f, -0.04530066f, -0.03003986f, -0.05777973f, -0.03487797f, -0.00962043f, 
    -0.03176035f, 0.00738651f, 0.03172510f, -0.01059451f, 0.03643566f, -0.05693344f, -0.03991451f, 0.04201495f, 
    -0.06202677f, -0.03224124f, 0.04457479f, 0.00639649f, -0.06137041f, 0.00482131f, -0.01249555f, -0.00585553f, 
    0.00972776f, -0.00137576f, -0.00936409f, -0.02557096f, -0.01042429f, 0.03253036f, 0.00788217f, 0.04565612f, 
    -0.01248598f, -0.06635147f, 0.03113540f, -0.03267958f, -0.05051466f, 0.04854866f, -0.00707095f, 0.02990593f, 
    -0.03040693f, 0.00352580f, 0.00025715f, -0.03177668f, 0.00305081f, 0.00166438f, -0.04944193f, -0.02161991f, 
    -0.05602370f, -0.04182344f, -0.00464740f, 0.04715080f, -0.01168135f, 0.05229896f, -0.01345700f, -0.01603516f, 
    -0.05894494f, -0.04220913f, 0.04459774f, -0.00099006f, -0.03535880f, 0.00096366f, 0.03990925f, -0.06752286f, 
    -0.05133434f, -0.02702257f, 0.00963856f, -0.06304273f, 0.00302192f, -0.02014024f, -0.02965117f, 0.03004328f, 
    -0.02067211f, 0.01939390f, 0.03004815f, 0.01857088f, -0.06339125f, 0.00346465f, -0.03517703f, 0.01487220f, 
    -0.02207375f, 0.01666619f, -0.05113478f, 0.04586432f, 0.02295417f, 0.03301797f, -0.03085516f, -0.06653573f, 
    0.04424432f, 0.01961610f, -0.02266169f, -0.04355392f, -0.01303146f, -0.06657726f, 0.03514255f, -0.02021769f, 
    0.00185439f, -0.04296512f, -0.05675802f, -0.05488008f, 0.03707891f, 0.03303835f, 0.02290917f, 0.03815141f, 
    -0.01220930f, -0.03855328f, 0.01976958f, -0.06990486f, 0.00810981f, -0.02160073f, -0.04186464f, 0.03458809f, 
    -0.03998841f, -0.04360986f, -0.04158812f, 0.00718812f, -0.03795157f, 0.03128701f, 0.03836413f, -0.02590733f, 
    0.03215944f, -0.02519728f, 0.00510454f, -0.06481197f, -0.00160251f, -0.01447781f, -0.02315231f, 0.00383584f, 
    -0.03726668f, 0.01003677f, -0.04174726f, -0.00905504f, -0.05820873f, -0.03101474f, -0.05066615f, -0.06604641f, 
    0.04345549f, 0.03047525f, 0.04365130f, -0.00029585f, -0.03093689f, 0.03008239f, -0.02197696f, 0.00501164f, 
    0.09184464f, 0.06085268f, 0.09633773f, -0.09194246f, 0.12277620f, -0.05628274f, -0.09049202f, -0.03783844f, 
    0.15356857f, -0.06721227f, -0.00154122f, 0.13386203f, -0.05633330f, 0.02119413f, 0.13964063f, -0.11981840f, 
    -0.08425654f, 0.00467197f, 0.20721705f, 0.22929746f, 0.12192843f, 0.04009338f, 0.00985430f, 0.02560663f, 
    -0.06477495f, 0.01529230f, -0.01914352f, 0.00276656f, 0.35832077f, 0.58281177f, 0.12600896f, -0.08499340f, 
    0.16586562f, -0.36475873f, 0.08149068f, 0.01180563f, -0.10382682f, 0.08461467f, -0.01377229f, 0.00362701f, 
    -0.04439312f, -0.12929177f, 0.13465686f, 0.20506945f, -0.00914550f, -0.11169979f, 0.43566647f, 0.20906729f, 
    0.18268123f, 0.00560510f, 0.08574753f, -0.22518671f, 0.26394987f, 0.02736969f, -0.54289150f, 0.00413685f, 
    -0.03845860f, -0.02038735f, 0.14277068f, 0.01298254f, 0.00918658f, 0.08200108f, -0.22291638f, 0.31626225f, 
    -0.05721418f, 0.14339454f, 0.23399647f, 0.01911273f, -0.16851865f, 0.04888422f, 0.09519620f, 0.02198148f, 
    0.09533306f, -0.35341290f, -0.40643120f, 0.17179485f, 0.18774243f, -0.01729154f, 0.17530003f, 0.12062892f, 
    0.18673404f, -0.02867152f, -0.01638111f, 0.02071789f, 0.05803055f, 0.16482249f, 0.21750668f, -0.00554415f, 
    0.03843783f, -0.02199677f, 0.18424243f, 0.16959742f, 0.12583759f, 0.09924375f, 0.17311303f, -0.08253845f, 
    0.13354838f, 0.05117933f, -0.03279078f, 0.22323191f, -0.04100684f, 0.01622974f, 0.13270174f, 0.30166766f, 
    -0.18216437f, -0.01169039f, 0.16570811f, 0.06578647f, 0.03770722f, 0.06408355f, 0.09336139f, -0.05828446f, 
    0.10011370f, -0.05973795f, -0.12275112f, -0.04554800f, 0.11009663f, 0.18819973f, -0.09331386f, -0.30070269f, 
    0.01704667f, -0.02213402f, -0.02588302f, 0.05626768f, -0.08156751f, -0.13062879f, -0.05051849f, 0.03948248f, 
    0.16922246f, -0.07656311f, 0.05140231f, 0.00918137f, 0.18372764f, 0.07861386f, -0.01877370f, -0.15126042f, 
    -0.02236161f, 0.28599364f, 0.17632915f, 0.08916003f, -0.06133841f, -0.09973928f, -0.20147677f, -0.26345724f, 
    0.10222507f, 0.11074343f, 0.06244291f, 0.03988815f, 0.11255343f, 0.10079918f, 0.01213790f, -0.15342957f, 
    0.21841714f, -0.09701169f, 0.02653265f, 0.03741992f, 0.20171331f, 0.14839421f, -0.00414811f, -0.18947186f, 
    -0.05788434f, 0.08213504f, 0.10918199f, 0.02967159f, 0.10842454f, 0.04585033f, -0.01019896f, -0.19191800f, 
    0.18275473f, 0.10517745f, 0.19402212f, -0.06913567f, 0.05177933f, 0.02106224f, 0.00904470f, 0.12483695f, 
    -0.13248764f, 0.17658439f, 0.10851982f, 0.18762359f, -0.41740876f, -0.08927189f, 0.20430367f, -0.06141187f, 
    0.11070211f, 0.12000795f, 0.01622934f, 0.29204440f, 0.06092948f, -0.15033624f, -0.07748666f, 0.02369236f, 
    0.14330994f, 0.02490399f, 0.12944458f, -0.05553274f, 0.14241886f, -0.15577018f, -0.00305583f, 0.12861551f, 
    0.16043583f, -0.13949414f, 0.10840589f, -0.06501638f, -0.07802720f, -0.00263625f, 0.06038750f, 0.19112346f, 
    0.04087155f, 0.12961088f, 0.10021295f, 0.17923635f, -0.08281223f, 0.11314748f, 0.12544580f, -0.02423059f, 
    0.17765374f, 0.19089785f, 0.21010137f, -0.23744741f, 0.23363586f, -0.33256695f, 0.14290537f, -0.03534027f, 
    0.06302159f, -0.26937288f, -0.23303716f, 0.03972794f, -0.10801664f, -0.14881954f, -0.08422314f, -0.02862925f, 
    -0.05814341f, -0.11486984f, -0.16830160f, 0.22679730f, 0.22353055f, 0.15573578f, -0.06707697f, 0.11412337f, 
    -0.01234467f, 0.20543744f, 0.05940741f, -0.01004220f, 0.20323855f, -0.15064766f, -0.00747318f, -0.03904887f, 
    -0.05306904f, -0.07555865f, -0.01656336f, -0.02920811f, -0.03401327f, 0.31806687f, -0.03068208f, 0.09666487f, 
    -0.08971371f, 0.10614931f, -0.08324951f, 0.08555236f, -0.10989904f, 0.02780252f, 0.00007950f, -0.14851001f, 
    0.03601221f, 0.16664359f, -0.24665560f, -0.07686017f, -0.08415228f, -0.13824561f, -0.05970965f, 0.04051987f, 
    0.00117766f, 0.12135717f, 0.04074115f, 0.02720367f, -0.20401415f, -0.02521272f, -0.27927643f, 0.19245338f, 
    0.07868568f, 0.10890892f, -0.03030498f, 0.12705635f, -0.04982536f, 0.14725305f, -0.06281814f, 0.10946413f, 
    0.06706422f, -0.21484797f, 0.09789250f, 0.04898268f, -0.00106715f, 0.01871003f, -0.05883542f, -0.10834727f, 
    -0.04383799f, -0.09946834f, 0.25483543f, 0.17366727f, 0.17133169f, -0.08786285f, -0.05262537f, 0.03333215f, 
    0.06930781f, -0.13906007f, 0.27482611f, 0.23724991f, 0.21521963f, 0.03179023f, -0.10335204f, 0.22845756f, 
    0.06912214f, -0.00492425f, 0.06104610f, 0.32263723f, 0.20214498f, -0.28360453f, -0.14106153f, -0.12106968f, 
    -0.04052665f, 0.09605499f, -0.01971565f, 0.46391463f, 0.12464283f, 0.02814534f, 0.00478085f, 0.12876000f, 
    0.04411798f, 0.10544091f, -0.12133105f, -0.15144113f, -0.24800938f, -0.24256241f, 0.18769722f, -0.48848057f, 
    -0.14270091f, 0.19550686f, 0.06622962f, 0.08067174f, 0.31194907f, -0.14898634f, 0.04359927f, 0.10694872f, 
    -0.00044155f, 0.02571311f, -0.10539868f, -0.00021520f, 0.00044560f, 0.14008585f, 0.01317388f, -0.38069969f, 
    0.14465687f, 0.05548565f, 0.12500647f, -0.12760240f, -0.16631538f, -0.15481529f, 0.04116392f, -0.36418527f, 
    0.23325282f, 0.21078953f, 0.10276674f, 0.05118799f, 0.00999532f, 0.09898987f, -0.19130298f, -0.24954800f, 
    -0.32527354f, 0.17430152f, 0.04565663f, 0.00538809f, 0.18672599f, 0.13907956f, 0.19521101f, 0.09557891f, 
    -0.09289574f, 0.02673999f, 0.21333615f, -0.37407893f, -0.36694300f, -0.09386530f, -0.25011888f, -0.18260971f, 
    -0.03394426f, 0.00724041f, 0.20762040f, 0.23503557f, -0.12432587f, -0.35575712f, 0.05064794f, -0.26799154f, 
    -0.03739572f, -0.13038404f, -0.04584977f, -0.01379059f, 0.13620493f, -0.01392781f, 0.04009566f, 0.09580889f, 
    0.10563570f, 0.05074678f, -0.00640253f, -0.02861401f, -0.09990557f, -0.15073922f, 0.06744230f, 0.33329281f, 
    0.05613869f, -0.01965903f, 0.30987725f, -0.09275930f, 0.01496791f, -0.00908086f, -0.16442861f, -0.02538188f, 
    -0.26802251f, 0.01386807f, -0.05632929f, 0.14538406f, -0.00494081f, -0.06648877f, 0.14889732f, 0.23711638f, 
    0.06145192f, -0.31692171f, -0.01939746f, -0.13593425f, -0.03620173f, -0.04414364f, 0.02115258f, 0.16803417f, 
    0.05800124f, 0.09099647f, 0.07317331f, -0.06459001f, 0.09833577f, 0.02067653f, 0.18648498f, 0.00616732f, 
    0.00726841f, 0.15941489f, 0.03828113f, 0.08289212f, 0.07792051f, 0.11573450f, 0.09878456f, -0.35868442f, 
    -0.31876764f, -0.16826054f, -0.02279114f, 0.02582469f, -0.03565306f, -0.03863280f, 0.05134588f, 0.03724756f, 
    -0.08488405f, -0.14878629f, -0.26102495f, -0.15680230f, 0.16043703f, -0.05217047f, 0.03247572f, 0.04034653f, 
    -0.02679067f, -0.19724658f, -0.16292095f, -0.27267304f, 0.23378401f, 0.00639885f, -0.07213514f, -0.07846796f, 
    -0.05025174f, 0.16125935f, 0.00667398f, -0.19947033f, -0.02469279f, 0.18273492f, -0.07846951f, -0.02073305f, 
    0.19044922f, 0.00208888f, 0.14454421f, 0.05969407f, 0.04153577f, 0.00178169f, -0.01130372f, -0.18035553f, 
    0.27846247f, 0.07465414f, 0.02910639f, 0.08553430f, 0.17538320f, -0.01219713f, -0.02066277f, -0.20015679f, 
    0.16138901f, 0.16507038f, -0.03236331f, 0.00653983f, 0.00789206f, 0.05973812f, 0.13494091f, -0.09157095f, 
    -0.12339000f, -0.20973450f, 0.29428363f, -0.00164420f, 0.16917741f, -0.10409504f, 0.17145814f, 0.20564894f, 
    -0.07952657f, 0.06252862f, 0.16276170f, -0.01712842f, 0.28963003f, -0.07123390f, 0.12715121f, 0.02835510f, 
    0.11631301f, 0.17061424f, 0.17548603f, 0.15534230f, -0.22058448f, 0.02417122f, -0.01376101f, 0.04853348f, 
    -0.13762997f, -0.01405597f, -0.13826852f, -0.17504352f, 0.11564951f, 0.03266589f, -0.03811392f, 0.21371540f, 
    -0.01399308f, 0.02961924f, 0.14227656f, 0.21993569f, -0.05809929f, 0.12216649f, 0.13812689f, -0.18596199f, 
    0.03837981f, -0.09030778f, 0.08311298f, 0.11724278f, 0.16694665f, -0.21841538f, 0.20041284f, 0.10063788f, 
    0.12586191f, 0.11379143f, 0.06296961f, -0.12226147f, -0.06076516f, 0.03143566f, 0.47628704f, 0.29247758f, 
    0.11941484f, 0.16657004f, 0.03189134f, -0.10349943f, 0.01789761f, 0.14630738f, 0.20426330f, -0.15158692f, 
    0.02887220f, 0.31574440f, -0.04081000f, 0.35351312f, 0.32603672f, 0.04418920f, 0.06463226f, -0.16528091f, 
    -0.15725699f, -0.16788504f, -0.06171178f, 0.02950020f, -0.01410666f, 0.09846444f, -0.03299852f, 0.16001974f, 
    -0.12530079f, 0.24214117f, 0.28836134f, 0.16502172f, -0.04448213f, -0.10833001f, -0.07763746f, 0.01525879f, 
    0.18455431f, 0.18345243f, -0.12170622f, -0.03584232f, -0.14443478f, 0.15504332f, 0.09332125f, -0.25223121f, 
    -0.03081270f, 0.15738316f, -0.00702816f, 0.25468084f, -0.51079702f, -0.27544713f, 0.16450696f, -0.16540582f, 
    -0.10835030f, -0.24472491f, 0.02310783f, -0.12348403f, 0.01979724f, 0.04625270f, -0.10792203f, 0.10005916f, 
    0.02440381f, 0.01806652f, 0.07604527f, 0.19179794f, 0.00063880f, -0.14846931f, -0.44263193f, -0.05567546f, 
    0.25157359f, -0.19801810f, 0.01735673f, 0.11543646f, 0.04340623f, 0.17828329f, -0.06664283f, -0.19819953f, 
    -0.09036391f, -0.07226950f, 0.01934115f, 0.01676581f, -0.00886580f, 0.11140918f, 0.15188344f, 0.10197692f, 
    0.16806698f, 0.26102233f, -0.12985480f, 0.18437704f, 0.25583920f, -0.05615010f, 0.03016793f, 0.07606819f, 
    -0.22040668f, 0.00632484f, -0.05493753f, -0.35370374f, -0.06719746f, 0.09951273f, -0.05249314f, 0.06206139f, 
    -0.01532165f, 0.00271867f, -0.05876267f, -0.01748115f, -0.00216788f, -0.00155394f, -0.05282006f, 0.09707894f, 
    0.19567610f, -0.12344249f, -0.13486391f, -0.30562827f, -0.78569400f, -0.13745712f, -0.15056364f, -0.14459617f, 
    -0.01321043f, -0.07854546f, -0.21333003f, 0.26614615f, -0.16640358f, -0.32782644f, -0.03955659f, -0.08231063f, 
    -0.23815431f, 0.24718653f, 0.00842221f, 0.05724796f, -0.08566234f, -0.16406721f, -0.04397809f, -0.03123636f, 
    -0.08574668f, -0.07567618f, 0.16384366f, 0.06928306f, -0.15581806f, -0.17072769f, 0.03300195f, 0.21319823f, 
    -0.20089471f, -0.22550620f, -0.00660074f, 0.07421173f, 0.05811306f, 0.02046785f, 0.27895656f, -0.12956440f, 
    -0.10310581f, -0.10828342f, -0.14951177f, -0.05549610f, 0.05942720f, -0.10915520f, 0.07091351f, 0.07754209f, 
    -0.07862263f, -0.37249413f, -0.02793387f, -0.15019231f, -0.08663321f, 0.20404409f, 0.00512490f, 0.10146653f, 
    0.28382626f, -0.33550569f, -0.02926063f, -0.16880520f, -0.03869890f, 0.01018134f, 0.21495296f, -0.11598957f, 
    0.05368820f, -0.33475032f, -0.27665457f, -0.12207945f, -0.03859731f, -0.06844193f, -0.01822209f, -0.01782949f, 
    0.05915018f, 0.11149003f, -0.04287250f, -0.04752595f, -0.06752624f, 0.09060564f, 0.19009162f, 0.11262170f, 
    0.04538471f, 0.05471622f, 0.19905077f, 0.22319970f, -0.07688348f, -0.17520365f, 0.04373147f, 0.06715229f, 
    0.02785108f, -0.02248368f, -0.15479158f, 0.19834185f, -0.10913496f, -0.06691203f, -0.11366027f, -0.21670082f, 
    -0.08410476f, 0.02678668f, -0.01104913f, -0.09384519f, 0.03972820f, 0.04479517f, -0.08477244f, -0.02513051f, 
    0.09088097f, -0.10500466f, 0.04847370f, 0.21904808f, 0.01562122f, -0.07091889f, -0.46618575f, 0.01445532f, 
    0.36207405f, -0.03178797f, 0.22216870f, 0.34945703f, 0.19273829f, -0.06523300f, 0.06309047f, 0.46200332f, 
    0.36904064f, 0.24458024f, -0.13430117f, 0.15118922f, 0.29734766f, 0.00208833f, 0.31667835f, 0.01563390f, 
    -0.22551978f, -0.02576108f, 0.33029431f, -0.10087381f, 0.19435365f, 0.14740899f, 0.03299619f, -0.10863819f, 
    -0.18340559f, -0.17603379f, -0.35074496f, -0.11635101f, -0.08976286f, -0.13615170f, -0.07016587f, -0.01943365f, 
    0.08526322f, 0.06387204f, -0.10131721f, -0.37895191f, 0.05049407f, 0.16822988f, -0.10909176f, -0.14846766f, 
    0.14438027f, -0.04383142f, -0.08680837f, -0.06770914f, 0.26224101f, 0.41220516f, 0.16552301f, -0.13189277f, 
    0.12697603f, 0.21185446f, 0.04813471f, 0.02177103f, 0.06923338f, 0.22127153f, 0.14879376f, 0.29853138f, 
    -0.02407816f, 0.04371127f, 0.14754611f, 0.03601805f, 0.18831474f, 0.37725696f, 0.17432545f, 0.60722601f, 
    -0.27211839f, -0.26497495f, -0.04936403f, 0.20610788f, -0.16716534f, -0.27871490f, -0.25403059f, -0.06462111f, 
    0.04486513f, 0.02615191f, 0.16678283f, -0.03375052f, -0.01966038f, 0.22702627f, 0.30845472f, -0.07159103f, 
    0.07753296f, 0.09489994f, 0.00793296f, 0.24703230f, 0.23350435f, 0.07617711f, -0.11657529f, 0.03262710f, 
    -0.01739222f, -0.09339941f, -0.12200890f, 0.00074746f, -0.03815363f, 0.07842910f, 0.12145867f, -0.04008435f, 
    0.14113861f, 0.11085782f, 0.13086616f, -0.00369919f, 0.11127342f, 0.10080016f, 0.01126764f, 0.09918897f, 
    0.01620968f, -0.03141928f, 0.08389731f, 0.19457301f, 0.33474353f, -0.14761676f, -0.09627105f, 0.06989852f, 
    0.09629979f, 0.06584417f, -0.05688123f, -0.24054296f, -0.28973323f, -0.84481734f, -0.06308687f, -0.39430150f, 
    0.13704215f, 0.21584477f, 0.08757676f, -0.17413571f, 0.01011654f, 0.00530067f, -0.16584332f, 0.02552367f, 
    -0.00797629f, -0.05821470f, 0.26778623f, 0.26127887f, 0.30502683f, 0.32688546f, -0.32814378f, -0.32724515f, 
    0.15194300f, 0.02846536f, -0.26473200f, 0.04894799f, -0.19970395f, -0.15146410f, 0.19591543f, -0.60415584f, 
    -0.27520555f, 0.00969482f, 0.07584839f, -0.08009925f, 0.03990771f, -0.05975426f, -0.08293515f, 0.28282136f, 
    0.04631191f, -0.11450956f, 0.04392097f, 0.06114743f, 0.03943475f, -0.06072669f, 0.03145412f, 0.12867936f, 
    0.45955476f, 0.39114404f, 0.65942246f, -0.11043061f, 0.35175920f, -0.09936762f, 0.08495928f, 0.15022627f, 
    0.14311002f, -0.22312877f, -0.15350902f, -0.11911256f, -0.01572399f, 0.04687607f, -0.02620169f, 0.17704245f, 
    -0.14319289f, -0.17712830f, 0.17232919f, -0.84389353f, 0.31492874f, -0.02918115f, -0.14560512f, 0.26724792f, 
    0.01641877f, -0.03881814f, 0.23682718f, -0.41862059f, -0.18434934f, 0.41345921f, -0.16306546f, -0.15929206f, 
    -0.23509614f, -0.05647152f, 0.01817877f, -0.02968636f, 0.02634616f, 0.03663613f, -0.12560739f, 0.19192991f, 
    -0.08849951f, 0.06246058f, 0.12600081f, 0.13218555f, 0.04767566f, 0.23835056f, 0.30366436f, 0.41699997f, 
    -0.08850316f, 0.18089288f, -0.01066232f, 0.09248296f, -0.09736020f, -0.13460763f, -0.19310340f, -0.39498901f, 
    -0.24303845f, 0.04949585f, -0.08957262f, -0.01034428f, 0.10181627f, 0.07916092f, 0.05430590f, -0.22193906f, 
    0.01435693f, 0.20524092f, -0.08132578f, 0.25437835f, -0.13086970f, 0.00200235f, -0.08090867f, -0.09657007f, 
    0.02732337f, -0.12555745f, -0.22686596f, -0.17364725f, 0.00547414f, 0.03229823f, -0.10380670f, 0.19696535f, 
    0.13713640f, 0.29371622f, 0.03259862f, -0.09784440f, -0.10854115f, -0.09595110f, 0.05144247f, 0.12702583f, 
    -0.11428608f, 0.19507821f, -0.12228833f, 0.03754674f, 0.02209690f, -0.00785384f, -0.01736217f, -0.16483133f, 
    0.16157374f, 0.05377804f, 0.21230456f, -0.16303007f, -0.17234227f, -0.08756894f, -0.02307551f, 0.02266887f, 
    -0.08764216f, 0.10830102f, 0.06233911f, 0.19710588f, 0.17752381f, -0.28201798f, -0.07253535f, -0.05992079f, 
    0.14370054f, 0.01092406f, 0.15585178f, 0.06876998f, 0.14881237f, -0.16505083f, -0.32072312f, -0.15159668f, 
    -0.03935945f, -0.00210087f, -0.09043341f, 0.14790371f, -0.04287910f, 0.07959022f, 0.49250242f, 0.18059184f, 
    -0.16404065f, 0.00998016f, -0.10008239f, 0.17211305f, 0.10255312f, -0.06974888f, 0.04610660f, 0.09504785f, 
    -0.38409215f, -0.45063061f, -0.02531946f, -0.00673319f, -0.05860560f, -0.00151904f, 0.03055316f, -0.02238721f, 
    0.33752903f, 0.21544610f, 0.08142271f, -0.03429767f, 0.17748813f, 0.04910240f, 0.16318642f, 0.02110056f, 
    -0.05909021f, -0.14317113f, -0.20205478f, -0.59391153f, 0.09774528f, -0.16252233f, -0.05189257f, 0.08704723f, 
    0.06778794f, -0.05353466f, 0.36571670f, -0.33508989f, -1.35689974f, -0.24342272f, -0.02138861f, 0.14236028f, 
    0.10442543f, 0.07773769f, 0.00409572f, 0.24620891f, -0.25421077f, 0.03319772f, -0.15459706f, -0.06099317f, 
    0.18049556f, -0.01440036f, -0.03930602f, -0.13768744f, 0.07503129f, -0.09009063f, 0.09889919f, 0.07579803f, 
    -0.08087238f, 0.09074466f, 0.11287404f, -0.02708899f, -0.16920927f, -0.02877978f, -0.97848839f, -0.40527323f, 
    -0.08988150f, -0.08611936f, 0.02042034f, 0.10086603f, -0.02067253f, -0.03643788f, -0.24989712f, -0.14370929f, 
    -0.11721799f, 0.06951474f, -0.15098804f, -0.08227309f, 0.13370548f, -0.14281681f, -0.08418827f, 0.31019136f, 
    0.18820085f, 0.30422750f, -0.00694394f, 0.18740866f, -0.08467664f, 0.02349345f, -0.06813737f, 0.08165398f, 
    -0.02465921f, -0.02439588f, -0.01582407f, -0.02714571f, -0.20106991f, -0.15484276f, 0.04251609f, 0.07404149f, 
    0.08873638f, -0.01219055f, 0.08542681f, 0.15906003f, 0.09411295f, 0.00112693f, 0.16566274f, 0.07366771f, 
    -0.06630541f, -0.23920140f, 0.14266254f, 0.19572817f, 0.12111391f, 0.18047467f, 0.00491248f, 0.22050987f, 
    -0.00955491f, 0.13300565f, 0.13066569f, -0.34532079f, 0.53372675f, 0.24377528f, 0.08070721f, 0.01386983f, 
    0.21729958f, -0.04377884f, 0.14715201f, -0.12949662f, -0.09824024f, 0.04015204f, 0.10134242f, -0.17027073f, 
    -0.10577577f, 0.02305916f, 0.03303738f, 0.17607948f, 0.08276940f, -0.05595204f, 0.16955611f, 0.21108033f, 
    -0.12511735f, 0.30284178f, 0.22863308f, -0.16468276f, -0.22022869f, 0.12221036f, -0.25091639f, -0.29234913f, 
    -0.01865753f, -0.03083135f, 0.07386644f, 0.17854613f, -0.21198411f, -0.08975556f, -0.10255244f, 0.02170296f, 
    -0.12856629f, 0.06182505f, -0.07105468f, -0.19507512f, 0.23952074f, 0.22296424f, 0.00975206f, 0.07142064f, 
    0.21088202f, 0.23636815f, -0.01283515f, -0.08132834f, 0.14844064f, 0.15191165f, 0.08380432f, 0.05334701f, 
    0.01664743f, -0.00575111f, -0.10177829f, -0.02556181f, 0.07724164f, -0.19737238f, 0.05409920f, -0.21465036f, 
    -0.07372383f, -0.06069809f, -0.38752407f, 0.22369346f, 0.34944093f, 0.21498252f, -0.22571908f, 0.13720576f, 
    -0.29279208f, 0.03957766f, -0.03779988f, -0.27762339f, 0.38160083f, 0.40658006f, -0.00155614f, -0.19196965f, 
    0.00352501f, 0.00249638f, 0.00047697f, 0.03430857f, -0.09241474f, -0.10896207f, -0.04890557f, -0.20946625f, 
    0.08969345f, -0.05836758f, -0.18703644f, 0.10827816f, 0.00777312f, 0.34131774f, 0.19053970f, -0.05372784f, 
    0.15261604f, 0.12275288f, 0.08583222f, 0.14837852f, 0.21072246f, -0.12647280f, -0.21886839f, -0.11873525f, 
    0.03186057f, 0.13948399f, 0.14699148f, -0.05464643f, 0.11211774f, 0.02667931f, 0.11074278f, -0.29959548f, 
    0.15511684f, 0.08132643f, 0.15646245f, -0.02641097f, 0.18894394f, -0.09482957f, 0.03790016f, -0.55191815f, 
    -0.06309222f, 0.23193902f, 0.19148584f, 0.03116992f, -0.02971296f, 0.14736925f, 0.18517229f, 0.06296618f, 
    -0.00215648f, -0.01798716f, -0.14985049f, -0.12366533f, 0.11346751f, 0.23822163f, -0.09921430f, -0.09428991f, 
    -0.00054412f, 0.00587081f, -0.11170530f, 0.13669498f, 0.12584826f, -0.25709036f, -0.15586935f, -0.17821866f, 
    0.16683155f, 0.05945264f, 0.15548421f, -0.16873951f, 0.09074853f, 0.18445477f, 0.01605718f, 0.15888776f, 
    -0.10706258f, -0.01922706f, 0.04028182f, 0.06904116f, -0.35342276f, -0.23926501f, -0.31202433f, -0.10216343f, 
    0.07313912f, 0.17312311f, -0.07824278f, 0.05406607f, -0.10103919f, -0.11840221f, -0.01647666f, -0.02327500f, 
    0.02793162f, 0.03514356f, 0.11900203f, 0.04426058f, -0.00619696f, -0.10316283f, 0.35406327f, 0.00707975f, 
    -0.43136984f, 0.12583685f, -0.16396238f, -0.06313451f, 0.08812369f, 0.09405302f, 0.05749583f, 0.03554288f, 
    -0.19235918f, -0.01641170f, 0.04066342f, -0.23704807f, 0.23731579f, -0.02343115f, -0.12556942f, -0.01584739f, 
    0.19408153f, 0.08706076f, -0.17067175f, -0.06051138f, -0.07729538f, -0.02406599f, 0.11249720f, 0.09728785f, 
    0.14547338f, -0.18562292f, -0.16223326f, -0.10732199f, 0.07058308f, 0.01784152f, 0.04548862f, -0.35086915f, 
    -0.09392952f, -0.12543607f, -0.20366322f, 0.32356670f, 0.00193101f, -0.17766729f, 0.20875843f, 0.04999762f, 
    -0.06778351f, 0.27941695f, 0.15655823f, 0.01609223f, -0.05726844f, -0.16663224f, 0.17278273f, -0.02133795f, 
    -0.04136929f, -0.31905222f, -0.40491322f, -0.17685626f, 0.15338324f, 0.09796555f, -0.04742293f, 0.20822415f, 
    0.03571604f, 0.17424099f, -0.21067482f, -0.09257349f, -0.11042129f, 0.01026850f, -0.41533902f, -0.35510567f, 
    0.18220758f, 0.16466480f, -0.07367627f, -0.12812400f, -0.36844975f, -0.09300467f, -0.17278232f, -0.09075862f, 
    0.06377446f, -0.08595420f, 0.01198158f, -0.02480143f, -0.61766690f, 0.29851454f, -0.27760056f, 0.05793928f, 
    0.23408569f, 0.07726653f, 0.07469779f, 0.02800631f, 0.14138463f, 0.04774990f, 0.14091526f, 0.07933867f, 
    -0.17876637f, -0.19622216f, 0.07558434f, 0.00215925f, 0.09940346f, 0.12524782f, -0.02166753f, 0.02740170f, 
    0.02019442f, 0.06404005f, 0.22361422f, 0.19041128f, 0.01795096f, 0.09881783f, -0.16282679f, 0.00797707f, 
    -0.09125531f, -0.17987958f, 0.63505954f, 0.28048792f, 0.23896596f, -0.13494582f, 0.00898362f, -0.28235123f, 
    0.03954396f, 0.03941206f, -0.13746037f, 0.33351472f, -0.10873477f, -0.28976053f, -0.32247442f, -0.16066027f, 
    0.06430659f, -0.06968980f, 0.08112679f, -0.02326721f, 0.11681061f, -0.12395530f, -0.13251078f, -0.00216594f, 
    -0.16805607f, -0.02572753f, -0.10384221f, -0.10546045f, -0.05022071f, -0.45260781f, 0.06999411f, -0.62878466f, 
    0.08906513f, -0.28859147f, 0.05956033f, 0.19778612f, 0.10931238f, -0.04109608f, -0.42660683f, -0.35678285f, 
    -0.06021113f, -0.02580550f, -0.05385644f, 0.07107296f, 0.05668079f, -0.00475225f, -0.09455786f, 0.12036870f, 
    0.67742622f, -0.19010045f, -0.01116507f, 0.03617144f, -0.05991231f, 0.15655066f, 0.16331726f, -0.22821231f, 
    0.21768309f, 0.24281947f, 0.25143245f, -0.00323245f, -0.01062013f, 0.05491020f, -0.15774931f, -0.35901904f, 
    -0.05004444f, -0.16774845f, 0.03827263f, -0.22783014f, 0.21166649f, 0.04670902f, 0.09489133f, -0.01957951f, 
    -0.01670425f, 0.17461352f, 0.17511348f, -0.02581092f, -0.15693407f, 0.14409341f, -0.03333578f, -0.23376884f, 
    0.06569739f, 0.18465182f, 0.19383462f, 0.17832626f, 0.11497202f, -0.18288271f, 0.04109631f, -0.21901684f, 
    -0.15045430f, 0.10327583f, 0.06949800f, -0.05816298f, 0.18772043f, 0.17073005f, 0.18561287f, 0.19815472f, 
    -0.10903335f, -0.11721092f, 0.09407206f, -0.06829808f, 0.02222423f, 0.21092798f, 0.37546921f, 0.18065001f, 
    0.03136476f, 0.09295276f, -0.16573614f, 0.18352120f, -0.11004987f, -0.18175204f, -0.21777697f, -0.35266593f, 
    -0.17985196f, 0.10222399f, -0.13656168f, -0.16832015f, -0.10911839f, 0.20043468f, 0.06274224f, 0.38735285f, 
    0.01301025f, -0.04606967f, 0.06622590f, -0.19655539f, -0.01647513f, -0.01754746f, 0.05208497f, 0.09950846f, 
    -0.00549113f, -0.26131618f, 0.00440283f, 0.01908072f, 0.10059271f, -0.05894656f, -0.22301735f, -0.12481242f, 
    0.00921948f, -0.15620628f, -0.27258161f, 0.24694593f, 0.22800663f, 0.18867998f, 0.19015782f, -0.16234004f, 
    0.04196307f, 0.20174667f, 0.03672010f, -0.07756718f, -0.28885850f, 0.03725401f, 0.10333929f, -0.02383427f, 
    -0.00975771f, -0.10359760f, -0.08904988f, -0.09860606f, -0.19578236f, -0.36631164f, 0.00596731f, -0.05725962f, 
    -0.19290675f, -0.09363698f, -0.06217333f, -0.15643096f, -0.30746406f, -0.08176439f, 0.10751150f, -0.10675884f, 
    -0.17684227f, -0.06935320f, -0.00879155f, -0.18906686f, 0.01474694f, -0.32121825f, -0.23205565f, -0.21767747f, 
    0.18598942f, 0.10780109f, -0.03794210f, -0.14985661f, -0.07493041f, 0.05926985f, 0.02528240f, 0.03658266f, 
    0.19217235f, 0.14501441f, 0.12041470f, -0.01554687f, 0.13203239f, 0.23671682f, 0.03151445f, -0.08529260f, 
    0.35784313f, -0.19419654f, -0.06281498f, 0.08392748f, -0.13267773f, 0.04232140f, 0.05755449f, 0.04541564f, 
    0.09386913f, 0.01070481f, 0.21304320f, 0.05315134f, 0.13813978f, 0.17061223f, 0.18880616f, 0.00707700f, 
    0.18844010f, -0.43088672f, -0.36181828f, 0.04933002f, 0.13545673f, 0.02834487f, 0.12214886f, 0.03604246f, 
    -0.02260190f, -0.06957298f, -0.29296017f, 0.05712964f, -0.35107061f, -0.04841755f, -0.03874100f, -0.07186039f, 
    -0.14525519f, -0.02971705f, -0.10864139f, 0.02961395f, 0.14532851f, 0.18063900f, 0.29507548f, 0.14930518f, 
    -0.01835629f, 0.25470257f, 0.08457099f, -0.03157295f, 0.23717535f, 0.09910830f, 0.18040055f, 0.20429306f, 
    -0.00089817f, -0.16588221f, 0.01968544f, 0.21525781f, -0.07755179f, 0.14859119f, 0.41073924f, 0.20972686f, 
    0.21598621f, -0.07089216f, -0.11474495f, 0.15419707f, 0.11368580f, 0.25261009f, 0.02740379f, -0.11332336f, 
    0.18765388f, 0.20525110f, 0.01416280f, -0.12959194f, 0.13291745f, -0.12949191f, 0.09451064f, 0.12780407f, 
    0.03587585f, 0.27272972f, -0.00193302f, 0.04228791f, 0.12822384f, 0.15139621f, -0.05728586f, 0.11353069f, 
    0.14393890f, 0.04558371f, 0.33659267f, 0.04356749f, -0.03149693f, -0.01482750f, 0.07459501f, 0.03799995f, 
    0.22179489f, 0.17786457f, 0.11199953f, -0.45709798f, -0.04408632f, -0.07044890f, -0.01417457f, -0.00277316f, 
    0.08417052f, -0.13509890f, -0.37671736f, -0.10596693f, -0.16781484f, -0.03959204f, -0.20790529f, 0.08247271f, 
    0.07495322f, 0.04904325f, -0.04826491f, -0.54017901f, -0.10221480f, -0.47774383f, -0.13240036f, 0.40074232f, 
    0.12556086f, 0.25248727f, 0.01971268f, -0.37230441f, 0.04949811f, 0.00231957f, -0.05984312f, 0.09566747f, 
    0.05944992f, 0.24777459f, 0.09809321f, 0.06956355f, -0.10244585f, -0.14490166f, -0.02045169f, 0.03796613f, 
    0.01851735f, -0.04638786f, 0.03635655f, 0.13707338f, -0.27945879f, -0.08880468f, 0.03844000f, -0.05438288f, 
    0.03981264f, 0.21083410f, 0.07531246f, 0.06196827f, 0.02597998f, 0.01486443f, 0.09987876f, -0.14792393f, 
    -0.16549100f, 0.28495261f, 0.13420241f, -0.04309328f, -0.15628797f, 0.05033976f, -0.19874151f, 0.03330233f, 
    0.13946544f, 0.14022532f, -0.21059196f, -0.16446617f, -0.06253523f, 0.07887707f, -0.14285927f, 0.08545433f, 
    -0.11817242f, -0.19013119f, 0.00633863f, 0.13293466f, -0.07767487f, -0.10574584f, 0.05298497f, -0.06723074f, 
    0.04920097f, -0.03104349f, -0.69186914f, -0.29054916f, 0.20000200f, -0.11666488f, -0.38901582f, 0.26536363f, 
    0.03191625f, -0.14099951f, 0.09538825f, -0.26013684f, -0.15242741f, -0.07052395f, -0.24347474f, -0.01819962f, 
    -0.04445563f, -0.31015515f, 0.06628992f, -0.15133329f, -0.05445004f, -0.00272689f, -0.00531621f, -0.02853679f, 
    -0.03022642f, 0.10328854f, -0.00947880f, 0.04114425f, -0.26512623f, -0.10921244f, 0.12294145f, 0.05198679f, 
    -0.19745772f, -0.28882319f, -0.00106380f, 0.05752694f, 0.02008404f, -0.09239521f, -0.31877035f, 0.07481243f, 
    0.10585519f, 0.13653389f, 0.10048586f, 0.05428452f, 0.13130343f, -0.01534946f, 0.16364513f, -0.40703663f, 
    -0.23013650f, 0.12512773f, -0.08538079f, -0.07096311f, 0.00810684f, -0.04446660f, 0.07628733f, 0.12001592f, 
    -0.21783824f, 0.03886436f, 0.21906231f, -0.21459496f, 0.12752815f, 0.02561976f, 0.06108512f, 0.06122348f, 
    0.06954415f, 0.10525791f, 0.21125239f, 0.41111475f, -0.08090111f, -0.08197165f, -0.19943470f, 0.02213381f, 
    -0.02885189f, 0.19088003f, 0.06018164f, -0.10063794f, 0.35083252f, 0.01796274f, 0.15147904f, -0.00144989f, 
    0.10833294f, 0.09741744f, 0.15886317f, -0.27533829f, -0.02614737f, 0.15709166f, 0.21916725f, 0.14798206f, 
    -0.06319907f, -0.12280175f, -0.05838840f, 0.06261319f, -0.18049476f, -0.30320704f, -0.35376641f, 0.01422788f, 
    -0.17462331f, -0.04447350f, -0.23103051f, 0.12999322f, -0.05687714f, -0.03078422f, -0.04797238f, 0.16094051f, 
    -0.05174060f, 0.06105779f, 0.12098014f, 0.01054343f, 0.09960083f, 0.15045908f, 0.24214901f, 0.26072723f, 
    0.21256381f, 0.12044314f, -0.09391683f, -0.11798019f, -0.09291391f, 0.05068361f, 0.17967810f, 0.15160142f, 
    -0.16914344f, 0.23062371f, 0.16277796f, -0.04453480f, -0.05347148f, 0.03477332f, -0.02315797f, -0.05366808f, 
    -0.24756546f, -0.06435165f, 0.15379463f, 0.05636138f, -0.19602406f, -0.06198690f, -0.10682606f, -0.04882776f, 
    0.04066430f, 0.01734497f, -0.09154358f, 0.03199925f, 0.05140835f, 0.02214654f, 0.04292158f, 0.09868225f, 
    0.05120165f, 0.16552386f, 0.03061541f, -0.09276557f, -0.34361589f, -0.01255161f, 0.27448648f, 0.38932624f, 
    -0.09984589f, 0.03060641f, -0.08673643f, -0.10338698f, 0.20760448f, 0.36204705f, -0.02679039f, -0.03741034f, 
    -0.12272331f, 0.13346799f, -0.02274450f, -0.00419423f, -0.15611920f, 0.08516857f, 0.16760141f, 0.13985671f, 
    -0.03051123f, 0.11383057f, 0.09324010f, 0.07746557f, -0.02199797f, 0.06582505f, -0.30359966f, 0.16637306f, 
    0.12539981f, -0.39897105f, -0.20664553f, 0.03045735f, -0.03357334f, -0.02838694f, 0.02243529f, -0.20475246f, 
    0.12543957f, -0.09230934f, 0.03654717f, 0.06540594f, 0.03820865f, 0.13759808f, -0.01168143f, -0.04911839f, 
    0.07039337f, 0.08823051f, -0.17259528f, -0.04295030f, -0.02617054f, -0.06067155f, -0.02397604f, 0.04010816f, 
    0.17591757f, -0.20432545f, -0.19720712f, 0.05298181f, -0.02625556f, 0.10020860f, 0.14129511f, 0.00205636f, 
    -0.08466525f, -0.29118842f, -0.19364335f, -0.04641975f, 0.06794782f, 0.16984774f, 0.23155034f, 0.03802098f, 
    0.07442657f, -0.01610931f, 0.14646472f, -0.26574031f, -0.23085982f, 0.05561997f, 0.04641227f, 0.05886646f, 
    0.15525961f, 0.03243882f, -0.09233981f, -0.08234743f, -0.14419083f, -0.40010726f, -0.12724064f, -0.02539933f, 
    0.17261504f, 0.05032256f, 0.00814372f, -0.00982674f, 0.00535626f, 0.00532888f, -0.11718298f, 0.05685355f, 
    -0.01237302f, 0.06677809f, 0.09528533f, 0.05093849f, -0.10581176f, 0.20667775f, -0.14444390f, 0.06516220f, 
    0.14425139f, 0.35550064f, 0.08060447f, -0.15687717f, 0.15198070f, 0.04122746f, 0.36754623f, 0.39465308f, 
    0.19539775f, 0.06929798f, -0.08863018f, -0.06785232f, 0.05341161f, 0.03968622f, 0.06157215f, 0.04184007f, 
    -0.45987222f, -0.03791852f, 0.08841173f, 0.36869445f, -0.04689727f, -0.02758423f, -0.04089657f, 0.04378787f, 
    0.14770348f, 0.21809103f, 0.19530432f, -0.10556106f, -0.06784798f, -0.01581089f, -0.03894870f, -0.04092536f, 
    0.15723892f, 0.17857805f, 0.25475362f, 0.12040099f, 0.02450224f, -0.14611137f, -0.01634793f, 0.12658538f, 
    -0.27659485f, -0.23433647f, 0.39860794f, -0.28987160f, -0.07888687f, 0.01037364f, 0.10532344f, 0.17860498f, 
    0.07192256f, -0.11077999f, -0.08093399f, 0.15530266f, 0.08321930f, 0.41510591f, 0.04452044f, 0.03690294f, 
    -0.22164086f, -0.10037068f, -0.10489217f, 0.22940506f, 0.05275610f, 0.00545392f, -0.09608439f, -0.04412686f, 
    -0.10893732f, 0.03446037f, 0.03296529f, -0.05512843f, -0.15257467f, 0.17497014f, -0.21030982f, -0.23737669f, 
    0.09716202f, -0.08067424f, 0.01295071f, 0.02456151f, -0.08365823f, -0.00691884f, 0.42446625f, 0.15011999f, 
    0.25822774f, 0.05451978f, -0.11678414f, -0.12422157f, 0.11662647f, -0.08058303f, 0.05151137f, -0.06319906f, 
    -0.08438352f, 0.42518735f, 0.14275751f, 0.03471087f, 0.06109216f, 0.08433901f, 0.12830532f, 0.21192822f, 
    -0.18928459f, 0.21581107f, -0.06166746f, 0.05566315f, 0.02255106f, -0.10857618f, 0.17503278f, 0.12759036f, 
    0.05358654f, 0.08645958f, -0.28981569f, -0.27168795f, -0.15246247f, -0.15813202f, -0.05136618f, -0.03362719f, 
    -0.08354424f, -0.01616083f, 0.12786169f, -0.32662588f, 0.02738621f, 0.00053035f, 0.02399750f, 0.01354304f, 
    0.19774988f, -0.05686289f, 0.09475657f, 0.22123814f, -0.11514784f, 0.08847351f, -0.05195827f, -0.05087218f, 
    0.03907467f, 0.07548531f, -0.12604421f, 0.18360771f, 0.12071730f, 0.44340253f, 0.15226386f, -0.13842754f, 
    -0.14130276f, -0.04546800f, -0.09437128f, -0.07030490f, -0.06577192f, 0.26283097f, 0.36975387f, 0.26907653f, 
    0.02292880f, -0.02666385f, 0.04910364f, 0.08681186f, -0.10603501f, -0.06221000f, -0.26317737f, -0.54258126f, 
    -0.61252749f, -0.04179525f, -0.00790274f, 0.14921863f, 0.05948681f, -0.10344193f, -0.13861462f, 0.27132297f, 
    -0.18231304f, -0.10307099f, -0.04685150f, 0.33168012f, -0.24766268f, 0.04030724f, 0.08264529f, -0.01845192f, 
    0.06437273f, -0.44244698f, -0.41071010f, -0.17515171f, 0.10540166f, 0.21847928f, -0.05534273f, -0.13244408f, 
    -0.12689865f, 0.32530788f, 0.26634687f, 0.37828073f, 0.07824466f, -0.06141930f, -0.15167719f, -0.06517227f, 
    0.02119824f, 0.22368188f, 0.00109619f, 0.09046914f, -0.16879790f, -0.06957084f, 0.10699790f, 0.10734760f, 
    0.10420129f, -0.03814989f, -0.03167970f, -0.45155576f, -0.42452607f, -0.69269115f, -0.15126173f, -0.09376604f, 
    0.01237570f, 0.08939797f, 0.10483835f, -0.10527572f, -0.35101739f, -0.45061809f, -0.48910457f, 0.05498607f, 
    -0.00053875f, 0.09703533f, 0.08701007f, 0.08226792f, -0.03637950f, -0.08332260f, -0.69662064f, -0.44836301f, 
    -0.41582346f, 0.15762940f, -0.06524169f, -0.02176486f, -0.09697018f, -0.13875858f, 0.24931803f, 0.48842993f, 
    0.12275892f, 0.10023456f, -0.09335733f, -0.03572286f, 0.02128933f, 0.05531675f, 0.18416531f, 0.01887989f, 
    -0.18640339f, -0.39801681f, -0.02484930f, -0.03743324f, 0.22936976f, 0.05412721f, -0.07997987f, 0.08795685f, 
    -0.09656769f, -0.03127132f, 0.18027410f, 0.03542934f, 0.03971682f, 0.04430687f, -0.04454756f, -0.29396975f, 
    -0.18611869f, 0.02776684f, 0.10117587f, -0.04465957f, 0.07085571f, -0.08085544f, 0.16415158f, -0.02918943f, 
    0.12312040f, 0.17210785f, 0.17865330f, 0.11325343f, -0.16829841f, -0.10562744f, 0.16878007f, -0.25933671f, 
    -0.05169700f, 0.01411778f, 0.05303780f, 0.16522494f, -0.10843929f, -0.04286066f, -0.06078263f, -0.04398055f, 
    -0.16716062f, -0.04133778f, -0.15207210f, 0.07713538f, 0.07375073f, -0.00921039f, 0.02809096f, 0.05911971f, 
    0.11182678f, 0.11883641f, -0.57452905f, -0.47426331f, -0.24549153f, -0.30942291f, 0.03547935f, -0.28932971f, 
    0.07487351f, 0.12653747f, -0.02743506f, 0.21252474f, -0.09757724f, -0.00963310f, -0.07444832f, -0.03145517f, 
    -0.16161364f, -0.16867432f, 0.01499013f, 0.02980256f, 0.07961207f, 0.12123872f, 0.09653852f, -0.10056868f, 
    0.14224946f, 0.08963834f, -0.04751850f, 0.02643882f, -0.01829894f, 0.14431074f, -0.11322838f, 0.07374791f, 
    0.13953228f, 0.09571967f, -0.18561403f, 0.06944486f, -0.14787832f, 0.13012438f, -0.11857140f, -0.18547285f, 
    -0.14064363f, -0.05750078f, 0.00094722f, 0.19194372f, 0.13360041f, 0.05035246f, 0.27844200f, 0.16827884f, 
    -0.13414240f, 0.01514254f, 0.39689735f, 0.24629344f, -0.02843947f, 0.00338511f, 0.29488620f, 0.28351352f, 
    -0.04176009f, 0.02515278f, 0.05107230f, -0.05368567f, 0.20308720f, -0.13461693f, 0.23586045f, -0.15146597f, 
    0.05677209f, 0.25894308f, 0.18252884f, -0.38339716f, -0.09942730f, -0.04128173f, 0.09576561f, 0.09212241f, 
    0.16875342f, 0.16655990f, -0.05998884f, -0.21717031f, 0.31447521f, 0.19799381f, 0.07832408f, -0.17595103f, 
    -0.02431286f, 0.05836536f, 0.30183923f, -0.07463908f, 0.00268956f, 0.04117118f, -0.11972803f, 0.09202059f, 
    -0.13928296f, 0.02587374f, 0.10482103f, -0.15228871f, 0.14466015f, -0.12901545f, 0.07275178f, 0.40631977f, 
    0.07038110f, -0.09687736f, -0.06750484f, -0.04467309f, 0.24260025f, 0.14684772f, 0.05938408f, 0.10537094f, 
    -0.18861431f, -0.05278279f, 0.00134220f, -0.20170519f, -0.14024349f, 0.06521685f, -0.01134420f, -0.21254024f, 
    -0.27721354f, -0.00912667f, 0.08821908f, 0.36882189f, 0.02511538f, 0.16326833f, 0.17606917f, -0.21808700f, 
    -0.15324181f, -0.18822476f, -0.13364790f, 0.03462783f, -0.02057613f, 0.17851372f, 0.14970005f, 0.02631349f, 
    -0.29396975f, -0.72540486f, -0.11443332f, -0.14367893f, -0.00164205f, -0.05939613f, 0.02766955f, 0.05982780f, 
    -0.11881062f, 0.01583124f, -0.28133011f, -0.21431448f, -0.00179983f, 0.13953666f, -0.04851247f, -0.06253126f, 
    -0.30784920f, 0.01501115f, 0.17196563f, 0.05759156f, -0.00159612f, 0.00090201f, -0.08527659f, -0.05864771f, 
    -0.03104925f, -0.00692535f, 0.13628966f, 0.05259509f, 0.05984205f, -0.03269043f, 0.05010723f, 0.02400544f, 
    0.05724217f, -0.03333782f, 0.04133731f, -0.01298912f, 0.22472101f, -0.00921375f, -0.08675984f, -0.04427161f, 
    0.20191547f, -0.05429965f, -0.04017360f, -0.06054442f, 0.01215309f, -0.05646783f, 0.10645945f, 0.21838365f, 
    0.12921417f, 0.08933783f, -0.11544118f, 0.15368919f, 0.14677067f, -0.19652613f, 0.15398423f, 0.01093745f, 
    0.01959498f, -0.32889250f, -0.08290236f, -0.24791107f, 0.00781396f, 0.02683976f, 0.10378766f, 0.26232702f, 
    0.02914437f, -0.01073553f, -0.20711939f, -0.10910151f, 0.05369058f, -0.05557048f, -0.11375906f, -0.19364038f, 
    0.07622565f, 0.11120282f, 0.01997454f, 0.10578369f, 0.09446799f, 0.00195827f, 0.10691094f, 0.20053282f, 
    -0.06082604f, 0.15829360f, 0.23668687f, 0.23154129f, 0.13079359f, 0.02751215f, -0.08441024f, -0.11702236f, 
    0.09140615f, -0.04281574f, -0.02158376f, 0.08258732f, 0.14705750f, 0.04777135f, 0.34156960f, 0.23565705f, 
    0.17676207f, 0.07260461f, 0.08398734f, 0.00115585f, 0.14159179f, 0.11914042f, -0.14697632f, -0.23585711f, 
    -0.16120097f, 0.03190194f, 0.13386562f, 0.13321576f, 0.21058965f, 0.10371121f, -0.13381320f, 0.03234279f, 
    0.01088130f, -0.34054515f, 0.12365277f, -0.02506275f, 0.16417789f, -0.03322374f, -0.08090164f, 0.04757454f, 
    0.22054994f, 0.17310935f, 0.00845442f, -0.03086708f, -0.08153561f, -0.07639843f, 0.05145261f, -0.06268781f, 
    -0.03228561f, -0.09144536f, -0.22569355f, -0.12536053f, 0.06900564f, -0.10826856f, 0.00224509f, -0.00367297f, 
    -0.00812702f, -0.16126211f, 0.27467507f, 0.34542161f, 0.37311468f, -0.18107668f, -0.06019707f, -0.08402429f, 
    -0.00699629f, -0.00718419f, 0.07034615f, 0.28904283f, -0.26295510f, -0.31772810f, -0.33971396f, 0.66240299f, 
    0.04077761f, -0.03531721f, 0.16779499f, -0.17303084f, 0.03960954f, 0.03269548f, 0.11938938f, -0.00270804f, 
    0.14288650f, -0.01047494f, 0.16419913f, -0.01778387f, 0.19577827f, -0.30716386f, 0.20412970f, -0.08976068f, 
    -0.14105363f, 0.26251084f, -0.11664904f, -0.21928704f, 0.03113795f, 0.04877081f, -0.20221786f, -0.19097000f, 
    0.04726342f, 0.04596998f, 0.01264426f, 0.10004703f, 0.08447480f, -0.06988680f, 0.08433990f, -0.39528394f, 
    -0.01031634f, -0.12920196f, 0.18684015f, -0.07746078f, 0.01787833f, -0.13335548f, -0.03029376f, -0.06038709f, 
    0.01365548f, 0.08081844f, 0.22799547f, -0.10923986f, 0.07196993f, 0.03827034f, -0.03573183f, -0.05996021f, 
    0.03873521f, 0.14622998f, 0.05505089f, 0.02920633f, -0.18322459f, -0.36114791f, -0.26295769f, 0.01708309f, 
    -0.06821328f, -0.05764861f, 0.29546452f, 0.46144259f, -0.13104843f, -0.22696598f, -0.07976451f, -0.51531512f, 
    0.04975295f, 0.07241077f, -0.12050711f, -0.60286403f, -0.07352668f, -0.37223774f, -0.12817958f, -0.17761227f, 
    0.05700117f, 0.01097459f, 0.10703494f, 0.01007942f, 0.11118474f, 0.07729093f, 0.04864121f, 0.05110030f, 
    -0.05021722f, 0.03912416f, 0.30473375f, 0.06038747f, 0.00553936f, 0.24073012f, 0.32626224f, 0.55987298f, 
    -0.17881018f, 0.01693455f, -0.12703434f, 0.01630611f, 0.15180860f, 0.16936316f, -0.26227489f, -0.13535263f, 
    -0.16056114f, 0.09957566f, 0.04337433f, 0.11812272f, 0.14058979f, 0.16430882f, -0.04946541f, -0.04107864f, 
    0.00017350f, -0.11176279f, -0.17845438f, -0.11565960f, -0.16391885f, -0.02683598f, 0.08641383f, 0.35430458f, 
    -0.07392796f, 0.50629389f, 0.17953569f, -0.15594529f, 0.14944439f, -0.04076607f, 0.03496256f, 0.28353518f, 
    -0.15248236f, 0.21891835f, 0.14557207f, 0.12912326f, -0.39434046f, -0.44745430f, -0.41876066f, 0.03048736f, 
    -0.09073742f, -0.07611436f, -0.00501047f, 0.18584651f, -0.06153854f, 0.14586689f, 0.03351331f, -0.10046242f, 
    0.11553037f, -0.03881149f, 0.05375204f, -0.24476203f, 0.14969581f, -0.10939501f, 0.12001538f, -0.08054230f, 
    0.00766369f, -0.10740711f, 0.07044304f, 0.12107452f, -0.18321820f, -0.16642855f, 0.35087812f, -0.09840275f, 
    0.15698600f, 0.18696515f, 0.21163110f, -0.00145548f, -0.06311844f, -0.04866974f, 0.02334654f, 0.22306238f, 
    -0.01726816f, -0.00142492f, -0.19778028f, -0.04480863f, -0.06205619f, 0.01678788f, 0.42370105f, -0.15178339f, 
    0.08327302f, 0.00197802f, 0.10271879f, -0.16932087f, 0.09775420f, 0.07798421f, 0.10257103f, -0.14241232f, 
    -0.02829882f, -0.19315097f, -0.08721288f, -0.17943217f, 0.16315268f, -0.11682928f, -0.19908109f, 0.05963715f, 
    0.32716304f, 0.09253649f, 0.12457662f, -0.02234667f, -0.23365125f, 0.03787185f, 0.05575225f, 0.08911373f, 
    -0.01749450f, 0.01607816f, 0.15719092f, -0.09096481f, 0.17792405f, 0.07431069f, 0.01819657f, -0.07992242f, 
    -0.15069328f, 0.04936251f, -0.04694102f, 0.14696595f, 0.02609364f, -0.07353239f, 0.56204814f, 0.12360136f, 
    -0.12958235f, 0.18347906f, -0.09448123f, 0.14845389f, 0.06356373f, -0.01200402f, -0.04292296f, -0.10992316f, 
    -0.23546284f, 0.02484364f, -0.08114877f, 0.10944609f, 0.14156453f, 0.05961540f, -0.14567451f, -0.03028148f, 
    0.00340646f, -0.19758536f, 0.03235167f, -0.04368877f, -0.09854240f, 0.32562304f, -0.03317811f, -0.00304216f, 
    0.09753298f, -0.29026797f, 0.03917737f, -0.02635583f, 0.01119333f, 0.01187487f, -0.04123182f, 0.09661517f, 
    0.24630819f, -0.03952603f, 0.09636448f, -0.17124009f, 0.03308928f, -0.10944735f, 0.17256473f, 0.03975119f, 
    0.22335123f, 0.29088879f, -0.08873945f, -0.14343785f, -0.06265292f, -0.01419086f, -0.04393648f, -0.12110008f, 
    -0.00739113f, -0.03823776f, -0.01735139f, -0.01961307f, -0.03661250f, -0.00861738f, 0.03764187f, -0.04324849f, 
    0.02359164f, 0.02619322f, -0.00486565f, -0.04646195f, -0.00273553f, 0.00048286f, 0.01604152f, -0.04600159f, 
    0.00486310f, 0.05218373f, -0.04856740f, -0.05646040f, -0.00406777f, -0.06760527f, -0.02552762f, 0.02584761f, 
    -0.01151723f, -0.04880477f, -0.02958771f, -0.01083242f, 0.00037422f, -0.01725614f, 0.05510182f, -0.03869771f, 
    -0.05073120f, 0.01395804f, -0.03726828f, -0.00573411f, 0.03529186f, -0.01724079f, 0.04701833f, -0.00103163f, 
    0.03941485f, -0.03292102f, -0.05180119f, 0.00227584f, -0.01836938f, 0.04321346f, -0.05138757f, 0.02584443f, 
    -0.01776060f, -0.04179028f, 0.02149496f, 0.02903186f, 0.01853210f, -0.04767795f, -0.02423894f, -0.06694014f, 
    -0.01290382f, -0.00760896f, -0.00781880f, 0.03301884f, -0.03511137f, -0.02868608f, -0.03338267f, 0.01042711f, 
    -0.05148345f, -0.02216315f, 0.02083363f, -0.06447896f, -0.00848552f, 0.01502482f, -0.00013503f, -0.04599072f, 
    0.01393667f, 0.02248723f, 0.02996826f, 0.03639976f, -0.03132058f, -0.04175321f, 0.01563750f, -0.05256020f, 
    0.00922547f, -0.05861567f, 0.04453091f, -0.03549735f, 0.02997223f, 0.02363508f, -0.01080763f, 0.02631419f, 
    0.03191484f, -0.02831784f, 0.00272206f, 0.03127420f, -0.01288148f, -0.05952927f, 0.01600947f, 0.01343798f, 
    0.04363933f, 0.00596035f, -0.01535774f, -0.05149111f, -0.02865197f, -0.00528610f, 0.04584518f, -0.03532585f, 
    0.04465121f, 0.03320593f, -0.04024503f, -0.04805058f, 0.00264434f, 0.04719492f, -0.05694623f, 0.02114773f, 
    -0.04173495f, 0.03796780f, -0.01527883f, 0.01706546f, 0.00082889f, 0.05097889f, 0.01155701f, 0.00226161f, 
    0.01638019f, -0.04121120f, -0.02531479f, 0.00331682f, -0.02265087f, -0.01761391f, 0.01267855f, 0.03497889f, 
    -0.01423779f, -0.04575671f, -0.01831188f, -0.04245422f, 0.03429427f, -0.02063292f, 0.04545007f, -0.01810333f, 
    -0.02795076f, 0.00813471f, -0.00730916f, -0.06635059f, 0.01660895f, 0.01805205f, -0.06093789f, 0.04903433f, 
    0.02009796f, -0.04482770f, -0.03298200f, -0.06231132f, -0.04228644f, -0.00206525f, 0.01260591f, -0.02042481f, 
    -0.02575954f, -0.05716521f, 0.00071947f, -0.03979551f, 0.02497653f, -0.01078953f, 0.03972445f, 0.00127370f, 
    -0.05466281f, 0.01721678f, 0.05074934f, -0.00861866f, -0.05071007f, 0.01530315f, 0.04001733f, 0.00473346f, 
    0.01664502f, -0.01837330f, -0.02968343f, -0.02219072f, -0.01791650f, 0.01876169f, 0.00296821f, 0.04024316f, 
    -0.03093229f, -0.04829301f, -0.04067632f, 0.04980610f, 0.03009422f, -0.05770967f, -0.00283014f, -0.00594837f, 
    0.01675155f, -0.01914765f, -0.06303237f, -0.00291120f, -0.04162945f, -0.04891792f, 0.00767193f, -0.00757661f, 
    -0.03404886f, 0.03179488f, 0.03332355f, -0.00925481f, 0.00216399f, -0.04887294f, 0.00006823f, 0.00665474f, 
    -0.03110190f, 0.02356172f, 0.04812708f, 0.01442536f, -0.03856836f, -0.00311981f, 0.02177004f, 0.03883508f, 
    -0.04377274f, -0.02311046f, -0.03741632f, -0.02042932f, -0.01758821f, 0.01117313f, 0.02163755f, -0.00666734f, 
    -0.05064379f, 0.04912722f, -0.03051454f, -0.03954672f, 0.02643300f, 0.01903528f, -0.06129991f, 0.00047719f, 
    0.02199954f, -0.00666382f, 0.00210927f, 0.03429632f, 0.01048383f, 0.02364927f, -0.06653063f, -0.04780120f, 
    -0.02586839f, -0.05552731f, 0.03112345f, -0.02768255f, 0.01438620f, -0.04454399f, 0.02341203f, 0.03330202f, 
    0.03845772f, -0.04484514f, -0.04551392f, 0.00570008f, -0.01786093f, 0.02836381f, -0.06074692f, 0.00302913f, 
    0.03661336f, 0.00405815f, 0.00570395f, -0.02394685f, -0.02961703f, 0.02456885f, 0.02178720f, -0.06421936f, 
    0.02876174f, 0.03125111f, -0.00009136f, -0.00835377f, -0.02578027f, -0.04229206f, 0.02516316f, -0.03299021f, 
    0.01402969f, -0.05619505f, -0.01852357f, 0.02464584f, 0.03851715f, -0.00740488f, -0.05493764f, 0.03016729f, 
    -0.02495378f, -0.00927267f, 0.02913185f, -0.02855776f, -0.06491724f, 0.05280919f, 0.03563557f, 0.04584133f, 
    -0.01773822f, -0.02911224f, 0.00178294f, -0.01566194f, 0.01626696f, 0.01785081f, -0.06080480f, -0.03887888f, 
    -0.03078614f, 0.00414835f, -0.01017984f, -0.05313326f, -0.04748815f, 0.01057214f, 0.02472013f, -0.04227138f, 
    -0.01677642f, 0.03725660f, 0.04450443f, -0.02020112f, 0.03626607f, -0.05876336f, -0.02331467f, 0.01885869f, 
    -0.05439761f, -0.01738899f, 0.01692256f, -0.06206872f, 0.02812903f, -0.04887846f, -0.02056134f, 0.02357136f, 
    -0.01241604f, -0.04193595f, 0.03978768f, 0.04483270f, -0.00811377f, 0.00835146f, 0.03786360f, -0.03302974f, 
    -0.04420821f, -0.02294490f, 0.01248300f, 0.02720853f, 0.04537852f, -0.04026419f, 0.00778381f, -0.03955173f, 
    -0.04682941f, -0.01043814f, -0.05927797f, -0.02408210f, 0.01363268f, -0.01197005f, -0.06517929f, -0.02103742f, 
    0.02436212f, -0.02964726f, 0.03768375f, 0.02145598f, 0.01981589f, -0.06085703f, 0.02205411f, 0.02558417f, 
    0.02194499f, -0.03349718f, -0.03941233f, 0.03293255f, -0.03294777f, -0.02181394f, 0.03646212f, 0.03998658f, 
    0.02131747f, 0.04847767f, -0.05690210f, 0.02671766f, 0.03683827f, 0.02514486f, 0.02545390f, 0.04724717f, 
    0.00503000f, 0.03908491f, 0.02461459f, -0.04659123f, -0.00606473f, -0.05101423f, 0.05454964f, -0.03585037f, 
    0.00660681f, -0.03061002f, 0.02271502f, 0.03120127f, 0.00484337f, -0.05900206f, 0.00606914f, -0.04061769f, 
    -0.05078067f, 0.01504234f, -0.05505689f, 0.02090065f, 0.00012327f, -0.00129498f, -0.05677802f, 0.00331116f, 
    -0.00077495f, -0.04638627f, -0.03963438f, -0.05371013f, -0.06898370f, -0.02739117f, -0.06549489f, -0.06534251f, 
    0.00113430f, -0.07077330f, 0.04402881f, -0.04677597f, -0.05019335f, -0.02097671f, -0.03187545f, 0.00308356f, 
    0.03288254f, -0.00247738f, -0.04799494f, 0.00519331f, -0.00744932f, -0.02213424f, -0.01137741f, -0.03284859f, 
    0.00214191f, -0.03805103f, 0.00053925f, 0.01142802f, 0.01413230f, 0.00723704f, -0.01176833f, -0.01931231f, 
    -0.02079439f, -0.02574894f, -0.04642952f, -0.06518943f, 0.02674976f, 0.04758302f, 0.01426092f, -0.01414909f, 
    -0.04309999f, 0.04093386f, 0.04686492f, -0.03558362f, -0.01348487f, 0.03940221f, -0.00614170f, -0.05346967f, 
    0.04084856f, -0.01487950f, -0.02969948f, -0.00914902f, -0.03868448f, -0.01151734f, 0.03199988f, -0.02320038f, 
    0.04311481f, -0.00382464f, 0.01472029f, -0.06159376f, 0.01254066f, -0.06418752f, -0.01167657f, 0.00224980f, 
    0.02098148f, 0.03739246f, 0.00930185f, -0.03030222f, 0.01119323f, -0.00922624f, -0.06066445f, 0.03539443f, 
    -0.03988009f, 0.02496358f, 0.03167099f, -0.04331012f, 0.04060867f, -0.02639660f, -0.04629452f, 0.00287242f, 
    -0.06355143f, 0.00455675f, 0.00333528f, -0.04829155f, -0.00294935f, -0.05406508f, -0.03052166f, -0.00902093f, 
    0.02825521f, 0.03194122f, -0.02862611f, -0.03016830f, -0.00798260f, -0.02539350f, 0.00478140f, 0.02140804f, 
    -0.02962531f, 0.02131917f, 0.03953555f, -0.05104880f, 0.00777178f, -0.05085393f, 0.02549811f, -0.02035494f, 
    0.06270798f, -0.02206731f, 0.02982378f, -0.06255739f, -0.00810640f, 0.02704356f, -0.05798364f, 0.01994423f, 
    0.04845244f, 0.00952907f, -0.05561332f, 0.04338546f, 0.01807468f, -0.04753692f, 0.01119568f, -0.00543066f, 
    -0.06367692f, -0.02912225f, 0.00522183f, -0.03100180f, 0.03822692f, -0.03309282f, 0.02657739f, -0.05075176f, 
    -0.01321027f, 0.03581140f, 0.04011527f, 0.00563381f, 0.01833001f, -0.05620518f, -0.03365950f, -0.04982460f, 
    -0.05296377f, 0.01575094f, -0.05579263f, -0.02725546f, 0.04169516f, 0.01574410f, 0.02715263f, 0.05255720f, 
    -0.04356188f, -0.05202200f, -0.01740616f, 0.03714445f, -0.06326371f, -0.01193035f, -0.03068362f, -0.01052229f, 
    -0.01518533f, -0.02319824f, -0.00712906f, -0.00204621f, 0.05661504f, 0.01618355f, -0.06145046f, -0.03209854f, 
    -0.02857262f, -0.04639284f, -0.04981292f, -0.01893057f, 0.01797995f, 0.00666580f, 0.02976101f, 0.04972601f, 
    0.03403091f, 0.03204158f, 0.04531933f, 0.01405438f, 0.00646104f, 0.03697383f, -0.03126786f, -0.00903654f, 
    0.00440482f, 0.02646060f, -0.04109120f, -0.01475037f, 0.02790178f, -0.00752615f, -0.05977697f, 0.03180407f, 
    -0.04316566f, 0.00592861f, -0.06986339f, -0.00284227f, 0.01544702f, -0.06308979f, -0.05599698f, -0.06213417f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00924001f, 0.06373638f, 0.10345642f, 0.03941806f, 0.13854115f, 0.02895136f, 0.11835050f, 0.36975050f, 
    0.38303962f, 0.02278021f, 0.21971484f, 0.20480122f, 0.00834786f, 0.23980525f, -0.15315126f, -0.06755365f, 
    0.06813539f, -0.06235971f, 0.10699338f, -0.05496363f, 0.02519126f, 0.04205235f, 0.11785973f, 0.09955078f, 
    0.06056127f, -0.14419994f, 0.32196647f, 0.15536757f, -0.22946702f, -0.02098214f, -0.05351823f, -0.01023726f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.38554230f, 0.45473364f, 0.28592336f, -0.03706218f, 0.30786124f, -0.29245687f, -0.22175929f, -0.07908713f, 
    -0.77688807f, -0.10897491f, -0.39702919f, -0.23510952f, 0.12643389f, -0.50033802f, 0.56318581f, 0.18043894f, 
    -0.16857436f, 0.12733316f, -0.26979247f, 0.07436148f, 0.06089660f, -0.05389280f, -0.57105893f, 0.47978270f, 
    0.32284406f, 0.05731346f, 0.11911517f, 0.00845226f, 0.29310262f, 0.17258649f, 0.03193665f, -0.10861972f, 
    -0.30665973f, 0.14918534f, -0.16654585f, -0.15699852f, 0.33391637f, -0.64882815f, -0.59472144f, 0.07084874f, 
    0.06103920f, 0.09290353f, 0.05210153f, 0.43841490f, -0.06913815f, -0.07619971f, 0.51767218f, -0.12174441f, 
    -0.05749552f, -0.09568397f, 0.09011556f, 0.07014459f, -0.05412584f, -0.05450600f, 0.30667722f, -0.18613595f, 
    0.19303028f, 0.17317571f, 0.04025716f, 0.42252174f, -0.12875193f, -0.08662182f, -0.09847037f, -0.13008469f, 
    -0.33209839f, -0.23147678f, -0.09004179f, -0.10049230f, 0.79677820f, -0.18811207f, -0.30212095f, 0.34663042f, 
    0.53420079f, 0.16196153f, -0.68329966f, -0.36466989f, 0.03598530f, 0.01350808f, -0.35826647f, -0.18044496f, 
    0.14872825f, 0.17583279f, 0.27825367f, -0.11589192f, 0.04566099f, 0.14165349f, 0.28237447f, -0.78560007f, 
    -0.36510772f, 0.12410986f, 0.16470078f, -0.30414638f, 0.31706420f, -0.20880742f, 0.01725515f, 0.05436609f, 
    -0.07286107f, 0.30650610f, -0.89766145f, -0.16407727f, -0.18639959f, 0.20591375f, 0.53424281f, -0.61086822f, 
    -0.29093790f, -0.01450396f, -0.80240524f, -0.18149857f, 0.14556411f, -0.14076187f, -0.26435184f, 0.05194423f, 
    -0.63104886f, -0.18238991f, 0.27943552f, 0.06056406f, 0.11493158f, 0.42299947f, 0.20698681f, -0.45147264f, 
    -0.03652374f, 0.30634606f, -0.44485444f, -0.71100605f, 0.29834661f, 0.24316384f, 0.15302731f, 0.16622585f, 
    0.08703537f, -0.22610681f, -0.22224247f, 0.11169256f, -0.47254950f, 0.15544748f, -0.21009706f, -0.16989474f, 
    -0.70047760f, -0.03701098f, 0.64860100f, -0.15374616f, -0.07136734f, -0.29227492f, 0.13853686f, 0.16023004f, 
    0.24274285f, -0.11420455f, 0.20892102f, -0.11237467f, -0.28086004f, 0.12389912f, -0.17411788f, 0.47461438f, 
    -0.08778104f, 0.34850988f, 0.23636812f, -0.03389697f, 0.10454415f, 0.31191099f, 0.05559517f, -0.10656008f, 
    -0.13857888f, 0.45110786f, -0.10944638f, -0.06646317f, 0.08894636f, 0.46966416f, -0.35664091f, -0.28873402f, 
    0.11223074f, -0.12324992f, -0.04648567f, -0.22622274f, 0.03255113f, 0.20976608f, -0.36618733f, -0.41735402f, 
    0.28515252f, 0.15868701f, -0.19146584f, 0.12541044f, 0.15858135f, 0.14956170f, -0.29737407f, 0.13984360f, 
    0.48022458f, -0.00186863f, 0.03996830f, 0.07844190f, -0.36382499f, -0.20413834f, 0.10115028f, 0.00497061f, 
    -0.04055820f, -0.42038122f, 0.63888079f, 0.14373964f, -0.58046454f, -0.19673508f, -0.13318607f, 0.71894515f, 
    0.85856295f, -0.06266919f, -0.38323873f, -0.04635857f, -0.11016581f, -0.10630434f, 0.13726626f, 0.12398738f, 
    -0.08175001f, -0.13233967f, -0.15225446f, 0.13938084f, -0.12625679f, 0.07183494f, 0.04386376f, -0.81296653f, 
    -0.18017256f, -0.61782897f, -0.04840178f, -0.41023737f, 0.31710064f, -0.38998246f, 0.17472191f, -0.09365235f, 
    0.17787671f, -0.52599472f, 0.25526628f, -0.02185834f, -0.67177629f, 0.11175918f, 0.54267800f, -0.46518490f, 
    -0.60113144f, -0.10678239f, -0.28911105f, 0.10649583f, -0.01399778f, -0.15208443f, 0.81066370f, -0.22036946f, 
    0.33213267f, 0.00498354f, -0.09835819f, -0.10893227f, -0.08354879f, -0.18864201f, -0.26680049f, -0.55903333f, 
    -0.16690047f, 0.51608306f, -0.33233467f, 0.35000706f, 0.24469656f, 0.27778128f, -0.01578424f, -0.11347695f, 
    -0.18486397f, -0.31180149f, -0.28304946f, 0.07129873f, -0.11717492f, -0.47024602f, 0.96170539f, -0.19102249f, 
    -0.40313771f, 0.11588937f, -0.15681407f, 0.04318850f, 0.16538790f, 0.35833842f, -0.48089489f, 0.12673204f, 
    0.14651527f, 0.07742231f, -0.25009879f, -0.15214516f, 0.34725818f, -0.31599036f, 0.07519951f, 0.23349379f, 
    0.26472214f, -0.68920881f, 0.01628453f, 0.14448366f, -0.19318148f, -0.72099292f, 0.13448633f, -0.07707583f, 
    0.14872251f, -0.50257409f, -0.00846757f, -0.07713851f, -0.25949457f, 0.14718193f, -0.06651350f, -0.00972983f, 
    0.20112547f, 0.04156188f, 1.01349902f, -0.49197048f, 0.04093358f, 0.07352585f, 0.07994945f, 0.56458580f, 
    -0.46227592f, 0.14161865f, -0.37582964f, -0.07037275f, -0.31850141f, 0.25989896f, -0.02370859f, -0.04557321f, 
    -0.17048809f, -0.19326647f, 0.76360786f, 0.01896817f, -0.04435382f, 0.13055423f, -0.08221640f, 0.00351515f, 
    0.36087793f, -0.59628099f, -0.15627559f, -0.12078085f, 0.54495442f, -0.35521150f, 0.06960864f, -0.31266952f, 
    -0.18563901f, 0.01594170f, 0.13204344f, -0.03466584f, -0.02704028f, 0.10940043f, -0.67160445f, -0.86971420f, 
    0.37708199f, -0.08905987f, 0.36901984f, -0.13380536f, 0.31979850f, -0.13191096f, -0.38050926f, -0.40723786f, 
    0.36187321f, -0.23720698f, 0.16775063f, -1.02945876f, -0.54171830f, 0.60675377f, 0.09907919f, 0.08578024f, 
    0.92823493f, -0.08785207f, 0.09105939f, 0.09834760f, -0.68967742f, -0.02485698f, -0.39928150f, -0.08926714f, 
    -0.80888003f, 0.02517111f, 0.17416507f, 0.17050372f, -0.09318490f, 0.21151280f, -0.34640065f, -0.00417491f, 
    -0.63273895f, 0.10534564f, 0.41490126f, 0.14046685f, 0.27179918f, -0.22169694f, 0.33446565f, -0.32280570f, 
    -0.36862984f, -0.42949092f, -0.23765454f, -0.14167532f, 0.13314570f, -0.74696797f, -0.06066971f, -0.10286526f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35913467f, 0.10633978f, -0.08878262f, -0.04969029f, 0.04113592f, 0.19543466f, -0.15683684f, -0.18065330f, 
    -0.01057754f, 0.01709909f, 0.18548372f, 0.21183325f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
