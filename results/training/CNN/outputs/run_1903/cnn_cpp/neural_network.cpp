#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.83006781f, -0.46819571f, -0.24359855f, -0.41921574f, -0.50508249f, 0.69090003f, 0.13420153f, -0.11332484f, 
    0.27132440f, 0.17605817f, -0.04191288f, -0.43994284f, -0.26580021f, -0.35677782f, -0.45143700f, 0.02747556f, 
    -0.01072851f, -0.14135717f, 0.14869621f, 0.16215515f, -0.15216321f, 0.02101422f, 0.05553835f, 0.10773323f, 
    0.16146557f, -0.07138115f, 0.18237613f, -0.35165009f, -0.63021541f, -0.28876960f, 0.35249910f, 0.32748631f, 
    0.29647765f, -0.30878526f, -0.54136384f, 0.21419379f, 0.46961996f, -0.18715154f, 0.26248431f, -0.11356003f, 
    -0.11026901f, -0.12943567f, -0.21653077f, -0.30628747f, -0.37543982f, -0.06650709f, -0.04510073f, 0.25682175f, 
    0.29111636f, 0.42998046f, -0.75129426f, -0.17841817f, 0.65921861f, 0.46468452f, -0.23343284f, 0.39237010f, 
    -0.76489651f, -0.39999297f, 0.07889590f, 0.31815559f, -0.08984291f, -0.16286163f, -0.09053319f, 0.42085132f, 
    0.13655649f, 0.00733225f, -0.12660091f, 0.15530249f, -0.14856455f, -0.14410575f, 0.04595103f, 0.20556374f, 
    0.05259166f, 0.03613622f, -0.13005951f, 0.38896662f, 0.30790001f, -0.14466800f, -0.56606710f, 0.45439875f, 
    -0.03653255f, 0.15504424f, 0.05951157f, 0.00114157f, -0.33005086f, -0.17913656f, -0.16986915f, 0.15281703f, 
    0.16734901f, -0.06194064f, 0.00874241f, -0.03317420f, 0.15837251f, 0.17915486f, 0.17940040f, -0.11991955f, 
    0.00726152f, -0.12883587f, -0.04729364f, -0.25310817f, -0.44149926f, -0.84752709f, -0.08152444f, 0.37214822f, 
    0.46764290f, -0.31474417f, -0.07076117f, -0.39844596f, -0.17449895f, 0.14590879f, -0.52823716f, -0.17549114f, 
    0.17997685f, -0.35988531f, -0.10777328f, -0.15112410f, 0.13941832f, -0.18574841f, -0.17450310f, -0.03795161f, 
    -0.10882133f, -0.28402519f, -0.34472561f, -0.19158064f, 0.01282220f, 0.15558249f, 0.28827283f, 0.30870456f, 
    0.23406024f, 0.41995180f, -0.26338845f, 0.13263729f, 0.13413176f, 0.22591874f, 0.09395896f, -0.14033507f, 
    0.23711917f, 0.11118622f, -0.16973175f, -0.17691067f, 0.14642702f, 0.25616381f, 0.06109613f, -0.18945870f, 
    0.15110107f, -0.24705423f, -0.14427479f, 0.17228115f, -0.08760738f, 0.02506566f, 0.12266520f, 0.96695787f, 
    0.60491359f, -0.60689217f, 0.11579262f, -0.58139455f, -0.29365766f, 0.14658818f, 0.07121035f, -0.05564626f, 
    0.13385586f, -0.06712882f, 0.01381088f, 0.12913513f, -0.24547966f, -0.07837956f, 0.00473868f, -0.09987957f, 
    0.34053096f, -0.19508353f, -0.19194081f, 0.05811501f, 0.13789652f, 0.08924534f, 0.17014210f, 0.35352316f, 
    0.08267888f, -0.27428699f, -0.40356600f, 0.22520055f, 0.19587737f, 0.28499767f, -0.01093595f, 0.22687458f, 
    -0.20617744f, -0.04110900f, 0.02563880f, 0.10146235f, 0.11842644f, -0.10616452f, 0.16765018f, -0.00407574f, 
    -0.11148031f, -0.19388258f, 0.29748520f, 0.18388788f, 0.19002303f, 0.32647792f, 0.26945019f, 0.21542574f, 
    0.39746624f, 0.04005963f, -0.22644232f, 0.07102803f, -0.26135099f, -0.57725924f, -0.55539066f, -0.59430492f, 
    -0.34814656f, -0.71978092f, 0.22136252f, 0.10375590f, -0.18110166f, 0.52299112f, -0.13097350f, 0.16054605f, 
    0.43551546f, -0.01730939f, -0.24837172f, -0.11521073f, -0.35757929f, 0.00040056f, 0.27014548f, 0.06945265f, 
    -0.00629833f, -0.06308542f, 0.14065792f, 0.85319519f, -0.12202595f, -0.55263066f, -0.46461365f, -0.17803955f, 
    0.06653137f, -0.23060471f, 0.23090373f, -0.12784857f, -0.35186097f, 0.05735227f, 0.42984864f, -0.27009261f, 
    0.17924531f, -0.15227593f, 0.02211575f, 0.25962460f, -0.24757053f, -0.00698406f, -0.16338143f, -0.05009295f, 
    -0.00503930f, 0.24298269f, -0.95551515f, -0.75026327f, -0.71919668f, -0.12256435f, -0.06025483f, 0.13893452f, 
    0.00778101f, 0.15136786f, 0.00379720f, 0.81995076f, 0.23619798f, -0.05226345f, 0.09477973f, -0.13490328f, 
    0.16423546f, -0.15818335f, -0.09641162f, -0.14557625f, -0.16425610f, -0.08628221f, -0.09693979f, -0.06389514f, 
    0.05970276f, -0.01559661f, 0.08351567f, 0.21451385f, 0.65362799f, 0.02011237f, -0.12672931f, -0.20044383f, 
    -0.57701951f, -0.13006864f, 0.42655829f, 0.02958608f, -0.16892739f, -0.11153729f, 0.09996520f, -0.06357817f, 
    -0.38534901f, -0.08270750f, 0.16255204f, 0.00553008f, -0.12269265f, -0.14120159f, -0.25151187f, -0.36327335f, 
    -0.01746882f, -0.04315887f, 0.13946408f, -0.39647445f, -0.15979348f, 0.28453648f, 0.27333620f, 0.33736068f, 
    0.24391940f, 0.40784901f, -0.17308551f, -0.70904309f, -0.33949119f, -0.10589516f, -0.20592581f, 0.54222435f, 
    -0.15919827f, -0.28366813f, -0.28698885f, -0.06930358f, 0.00310648f, 0.19866921f, 0.30442765f, 0.39470148f, 
    0.11438219f, -0.17297128f, -0.26374739f, -0.10364239f, -0.39147463f, -0.35521635f, -0.31906229f, 0.10236198f, 
    0.53753418f, 0.26208457f, 0.36667430f, 0.31102428f, -0.48780563f, -0.54129696f, -0.04792227f, 0.39371455f, 
    -0.24743351f, 0.16801207f, -0.18878540f, 0.26638332f, -0.13563143f, -0.05296372f, 0.19510229f, -0.10982636f, 
    -0.16458499f, 0.03145925f, -0.35474426f, 0.26912567f, 0.04034604f, -0.35549349f, 0.38969246f, 0.66277242f, 
    0.61368024f, 0.02988774f, -0.67277706f, 0.02485770f, 0.17047612f, -0.20619108f, -0.14320698f, -0.36405131f, 
    0.05945074f, -0.26136953f, -0.18305667f, 0.24239142f, -0.21471080f, 0.09218646f, -0.11087510f, 0.00424550f, 
    -0.07502727f, 0.11491797f, -0.01926682f, -0.12459155f, 0.18202324f, 0.00550500f, 0.19353978f, -0.24791178f, 
    -0.22282179f, 0.27209961f, -0.09014420f, 0.28176242f, 0.05443810f, 0.11680268f, -0.17840046f, -0.22021189f, 
    -0.03881248f, 0.15697598f, -0.02990215f, -0.18494040f, -0.04559780f, 0.02449649f, -0.23298317f, -0.00768106f, 
    0.01306564f, -0.05295459f, -0.27993429f, -0.25762802f, -0.20491175f, -0.20991114f, -0.27582318f, -0.43975699f, 
    0.09019379f, 0.18356968f, 0.31145939f, 0.15363321f, -0.72560799f, 0.33782393f, -0.41887543f, -0.20236962f, 
    0.09482736f, -0.08044636f, -0.09843691f, 0.23196517f, 0.02049814f, -0.01749696f, -0.03898357f, 0.01574273f, 
    0.12498043f, -0.25239182f, 0.01799683f, -0.26173884f, -0.13718218f, 0.25420621f, 0.32303819f, 0.25269562f, 
    0.00483008f, -0.05361689f, -0.28537455f, -0.02523116f, 0.08547033f, 0.18370990f, -0.23320208f, -0.11462229f, 
    0.40378550f, 0.16813329f, -0.28583303f, 0.16174886f, -0.21164611f, -0.21175314f, 0.74528301f, -0.28861299f, 
    -0.31348577f, 0.01036907f, 0.12670971f, 0.17175736f, 0.05503648f, -0.21579270f, 0.03158582f, 0.01459429f, 
    0.14435801f, -0.06534997f, 0.06925970f, 0.06189791f, 0.42841113f, 0.52989662f, -0.58943862f, -0.32364604f, 
    -0.25741053f, -0.22705702f, -0.34092402f, -0.61166042f, 0.45796412f, 0.38648063f, -0.13614146f, 0.32181519f, 
    -0.17600845f, -0.13792212f, -0.13246658f, 0.12484203f, -0.30925563f, -0.44995421f, 0.01785184f, -0.08157039f, 
    -0.00499604f, 0.00302780f, -0.20283240f, -1.26134610f, 0.83877754f, -0.02596976f, -0.70682311f, -0.17953350f, 
    0.16165993f, 0.54390675f, 0.18343058f, 0.02628171f, 0.02800279f, -0.38632274f, -0.02675802f, -0.34891614f, 
    -0.07816843f, 0.37708935f, 0.14957443f, -0.06136296f, -0.08508366f, -0.03035892f, -0.08007590f, -0.05532688f, 
    0.03226251f, 0.19444768f, -0.17441504f, -0.29388314f, -0.03386772f, 0.13441820f, -0.37929264f, -0.40896109f, 
    -0.38124070f, -0.48610112f, -0.56333482f, 0.09291837f, -0.41716710f, -0.21858071f, 0.34116280f, 0.49507886f, 
    0.18888001f, -0.03632577f, -0.05672240f, 0.12634365f, -0.03776288f, -0.15426554f, 0.11818852f, -0.01723825f, 
    0.06482882f, 0.15166530f, -0.07274204f, -0.10624196f, -0.18541710f, 0.49944854f, -0.41981915f, 0.29755890f, 
    -0.27126229f, -0.13538393f, 0.23819239f, -0.23176597f, 0.13212883f, 0.45883045f, -0.24838459f, 0.18190002f, 
    -0.27693397f, 0.28684294f, -0.14468160f, 0.09114184f, -0.28269154f, 0.04613273f, 0.10576024f, 0.09248197f, 
    -0.13244624f, -0.18502302f, 0.21636337f, 0.09943115f, -0.02686692f, 0.12705652f, -0.52019262f, -0.22898045f, 
    -0.17911734f, -0.10684111f, -0.16008304f, -0.46085560f, -0.20632921f, -0.22640014f, -0.30036107f, -0.56964636f, 
    0.35745484f, -0.20645547f, 0.35047883f, -0.35053924f, -0.12325877f, -0.08213133f, -0.22289558f, -0.18310934f, 
    -0.31036314f, -0.30921006f, -0.04483367f, 0.09516254f, -0.12543912f, 0.03314445f, 0.13185702f, -0.82817787f, 
    -0.17246075f, -0.04527253f, 0.18355367f, 0.66627669f, 0.08811054f, 0.15031441f, 0.53008038f, 0.47623795f, 
    0.25771603f, -0.25933674f, -0.00517848f, -0.07982495f, 0.46722695f, -0.10462302f, -0.20689560f, 0.08465302f, 
    -0.10619685f, -0.32239047f, -0.01924848f, 0.37969953f, -0.31993222f, -0.03453349f, 0.23324253f, -0.03363790f, 
    0.97856379f, -0.98616713f, -0.35805252f, -0.02671261f, -0.70965016f, 0.69311744f, 0.24116673f, 0.19948232f, 
    -0.06560477f, -0.07495125f, 0.31038907f, 0.05647182f, 0.07503463f, -0.35275576f, -0.32670709f, 0.28735551f, 
    -0.20759906f, 0.10164175f, -0.21150643f, -0.18152623f, -0.27180266f, 0.20263062f, -0.05765807f, 0.23536007f, 
    -0.28453353f, -0.40802965f, -0.20563184f, -0.19829030f, 0.55116737f, 0.08594593f, 0.59683055f, -0.35654202f, 
    -0.16979773f, 0.17061026f, -0.17027251f, -0.07580109f, 0.00326846f, 0.04225152f, 0.23412110f, -0.33137089f, 
    -0.05020938f, -0.16709247f, 0.38169587f, 0.07481772f, -0.03959915f, -0.20238224f, 0.03765545f, 0.01089470f, 
    -0.02793678f, 0.22728248f, -0.48779535f, -0.10155468f, -0.36858147f, -0.40952951f, -0.35309958f, 0.82448131f, 
    -0.10950268f, -0.33319911f, -0.19344690f, -0.23046666f, -0.06623860f, 0.14579727f, 0.29520911f, 0.15553407f, 
    0.35222137f, 0.00302271f, 0.04440692f, 0.01914825f, -0.23926048f, -0.13027233f, 0.19290110f, -0.24821016f, 
    -0.22746117f, 0.05685797f, 0.21198995f, -0.65590334f, -0.29684448f, 0.29465005f, -0.38256264f, -0.00925442f, 
    -0.37918043f, 0.01329704f, -0.21570562f, -0.37287927f, -0.17121066f, 0.08233070f, 0.30551338f, 0.06828330f, 
    -0.10391334f, 0.01256118f, 0.13100484f, 0.06269637f, -0.13224481f, -0.25265855f, -0.00969404f, 0.27979821f, 
    0.31219798f, 0.26547793f, -0.09799946f, 0.20363814f, -0.57727170f, 0.23150121f, -0.20841840f, -0.58037037f, 
    -0.45295143f, -0.04015458f, -0.13602817f, 0.04224737f, 0.12403705f, 0.13669425f, -0.20875680f, -0.23349853f, 
    -0.04897072f, -0.25013497f, -0.29524073f, 0.29287860f, 0.04897799f, 0.27978832f, 0.12056341f, -0.09578423f, 
    -0.02423647f, -0.11646363f, -0.41005129f, -0.16201556f, -0.38524958f, 0.16490865f, 0.35840297f, 0.53996962f, 
    -0.31362623f, -0.32065001f, -0.26176515f, 0.14512523f, 0.26714635f, -0.18632416f, 0.41226679f, 0.10806441f, 
    0.28433076f, -0.08376501f, -0.38590649f, 0.04859030f, -0.03267390f, 0.14340645f, -0.38318327f, -0.03044807f, 
    -0.03126266f, -0.03730963f, 0.50011283f, -0.05446335f, -0.26741430f, -0.21687818f, -0.12110974f, 0.18716370f, 
    -0.19938780f, 0.37803635f, 0.30453065f, -0.19058834f, -0.46245915f, -0.14569536f, 0.10273059f, 0.20525041f, 
    0.26265988f, -0.27283406f, -0.24440730f, 0.14769399f, 0.00510462f, -0.37417227f, 0.25203171f, 0.25467274f, 
    -0.28359887f, -0.26004159f, 0.14587301f, 0.16854982f, 0.38761926f, 0.10602246f, 0.12471481f, 0.91239917f, 
    -0.63238764f, -0.50109732f, -0.29390499f, 0.06967830f, 0.18073519f, 0.07647512f, -0.11193673f, 0.10870063f, 
    0.38071489f, -0.07372560f, 0.24823305f, -0.35847974f, -0.23457003f, 0.56466013f, -0.13071004f, -0.22227103f, 
    0.10589025f, 0.10136734f, -0.16895621f, 0.07871292f, -0.02483439f, -0.11162242f, -0.04208137f, 0.23414046f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24391894f, 0.17405206f, -0.07177389f, 0.16761707f, -0.06119434f, -0.04455380f, 0.12655629f, -0.29554147f, 
    -0.08506919f, 0.16771300f, 0.27542284f, 0.14953704f, 0.10324323f, 0.03083168f, 0.17775737f, 0.07498600f, 
    -0.13218357f, 0.10251164f, -0.14410090f, -0.08275975f, 0.24726863f, 0.16957469f, -0.14573914f, 0.24371101f, 
    -0.00061639f, 0.26919568f, 0.02825822f, -0.01501147f, -0.28238955f, 0.27604032f, 0.06638911f, 0.16768284f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.31530920f, -0.03818497f, 0.02939411f, 0.01193383f, 0.06060468f, 0.02403761f, 0.03415342f, -0.11258655f, 
    0.01317389f, -0.07178724f, 0.06462313f, 0.21953279f, 0.21315667f, 0.30064753f, 0.01973509f, -0.10501808f, 
    0.00676845f, 0.10876221f, -0.00679614f, -0.02236645f, 0.04591580f, 0.10800792f, 0.10363901f, 0.02737868f, 
    0.14064068f, -0.23331447f, 0.03359241f, 0.05491941f, -0.06274229f, 0.09059544f, 0.03523441f, 0.08600714f, 
    0.12200889f, -0.12405741f, -0.23327279f, 0.06215792f, -0.32946524f, -0.00459289f, -0.18913676f, -0.34325558f, 
    0.07751993f, 0.13322645f, 0.03693784f, 0.09003755f, 0.02964378f, 0.12162828f, 0.05878641f, 0.03611502f, 
    0.22220494f, 0.05786001f, 0.41695818f, 0.04743758f, -0.01932651f, -0.04796915f, -0.01460918f, 0.12731436f, 
    0.11890130f, -0.02811335f, 0.12807621f, 0.05463262f, -0.20401125f, -0.13493909f, -0.14802821f, 0.03442923f, 
    0.05666270f, 0.00262336f, -0.10556507f, -0.00689239f, -0.04589279f, -0.17603621f, 0.01750409f, 0.07345310f, 
    -0.21136928f, 0.00022666f, -0.45860991f, 0.33015773f, 0.13614087f, 0.00061496f, 0.02538656f, -0.23738694f, 
    -0.13901323f, 0.04220058f, -0.17013186f, 0.14378382f, -0.21135013f, -0.17009926f, -0.09652632f, -0.01989462f, 
    -0.13348295f, 0.12789333f, 0.09816357f, -0.10889522f, 0.08672231f, -0.11844081f, -0.19604555f, 0.03792247f, 
    -0.09075471f, 0.23412703f, 0.15201558f, -0.07062959f, 0.09262963f, 0.18073197f, 0.00334971f, -0.08483017f, 
    -0.04893020f, -0.03256602f, 0.07734999f, -0.10689296f, -0.10608786f, 0.20533863f, -0.08596363f, 0.27410319f, 
    0.24395555f, -0.01710260f, 0.14499897f, 0.16227281f, -0.06175402f, 0.14303242f, -0.17750224f, 0.20291522f, 
    -0.14946106f, 0.20186141f, 0.22133763f, 0.05764623f, -0.05491918f, 0.02885518f, 0.00339556f, 0.27671188f, 
    0.11282291f, -0.02639592f, 0.00832419f, 0.10313543f, 0.26572371f, 0.20959866f, -0.18149135f, 0.27784812f, 
    -0.00519417f, 0.06624166f, 0.03279297f, 0.11422282f, 0.10696759f, -0.07225669f, 0.13568327f, 0.00242857f, 
    -0.05738147f, -0.37862751f, 0.04473329f, -0.12998620f, 0.15072706f, 0.08170895f, 0.00446176f, 0.09911562f, 
    0.07287716f, 0.14335455f, 0.07851739f, -0.17356977f, 0.13005665f, 0.05025336f, 0.21830747f, 0.13640842f, 
    0.00130782f, -0.08344852f, 0.11771818f, -0.01641412f, 0.07354137f, 0.02770721f, 0.05646059f, 0.12999359f, 
    0.02096449f, 0.11464189f, -0.25385040f, 0.27862996f, 0.11234185f, 0.03067978f, 0.07833119f, 0.04404384f, 
    0.04080093f, -0.04343021f, -0.20111522f, 0.11204885f, 0.05512844f, 0.08188869f, 0.13017908f, -0.03159828f, 
    0.04634532f, 0.10519796f, 0.10409270f, 0.06466199f, 0.01401739f, 0.04201327f, 0.00193360f, -0.00208234f, 
    0.06544400f, -0.10666274f, -0.27978769f, 0.01376558f, 0.02417578f, 0.16107626f, 0.03992595f, -0.10153867f, 
    0.07414515f, -0.13546079f, -0.15654631f, -0.01394534f, 0.20119660f, 0.13287707f, 0.01427479f, 0.01210535f, 
    0.15695594f, -0.09103642f, -0.14695591f, 0.07873411f, -0.01884061f, 0.26429138f, 0.10879406f, -0.02997545f, 
    0.20223172f, 0.18029806f, 0.16762193f, 0.07323416f, 0.11129216f, 0.11938009f, -0.03776217f, -0.33505821f, 
    -0.05998760f, -0.04903705f, 0.02986661f, -0.01865570f, -0.37106881f, 0.19797698f, -0.06574586f, -0.14815241f, 
    -0.11210428f, -0.04681599f, 0.11177385f, 0.22539644f, 0.27451876f, 0.02909435f, -0.01246713f, 0.08523483f, 
    0.05310690f, 0.14685075f, 0.21573667f, 0.06250419f, 0.04721842f, 0.09503057f, 0.10290500f, 0.04822163f, 
    -0.15696064f, 0.09136030f, 0.07372001f, -0.02461156f, 0.27769703f, -0.08777907f, -0.10745826f, 0.19375814f, 
    -0.10995958f, -0.13927433f, 0.03141754f, -0.04911325f, 0.12913324f, -0.17877226f, 0.16709504f, 0.05208012f, 
    0.01627502f, 0.14798869f, 0.15391484f, 0.01636146f, 0.05159542f, 0.07588269f, 0.02634811f, -0.03499912f, 
    0.12416756f, -0.08428560f, 0.02084522f, 0.15046623f, 0.02950634f, -0.00324479f, 0.17123449f, 0.18861282f, 
    -0.07503887f, -0.23534878f, -0.09864412f, -0.03636351f, 0.25213292f, 0.19171165f, 0.18291730f, 0.14198461f, 
    0.21965463f, -0.09019046f, -0.16856478f, -0.12670867f, 0.05336529f, 0.08995981f, -0.16177423f, 0.02408768f, 
    0.09142832f, -0.02396563f, -0.06897423f, -0.12928770f, 0.05970923f, -0.01655769f, 0.04536164f, 0.02062240f, 
    0.05035852f, 0.27681431f, 0.05052460f, -0.06847627f, 0.11670927f, 0.00024189f, -0.03397543f, 0.10235140f, 
    0.02782637f, 0.27130684f, -0.01204893f, -0.18864229f, 0.06276130f, 0.02067088f, -0.01969806f, 0.06344906f, 
    0.01023961f, -0.09415152f, -0.05544874f, -0.00203021f, -0.09691131f, 0.05216360f, 0.10031235f, 0.05965768f, 
    0.11039252f, 0.12677883f, 0.14871101f, 0.06106494f, -0.05005929f, -0.11585917f, 0.08488525f, 0.06263030f, 
    -0.10305770f, 0.07770704f, 0.00588421f, -0.16754512f, -0.02537300f, -0.06064314f, 0.04940893f, 0.11544130f, 
    -0.01963238f, -0.09316781f, -0.00316834f, -0.01864827f, -0.11205392f, 0.01698766f, -0.21406160f, 0.29094583f, 
    -0.00170782f, -0.07081895f, 0.10124862f, -0.07138289f, 0.17258123f, 0.12155170f, 0.12064777f, 0.21485677f, 
    -0.02127359f, -0.17000367f, -0.19661629f, -0.06629919f, -0.02849438f, 0.09304581f, 0.04654388f, 0.10286669f, 
    0.05734960f, -0.02138341f, 0.02745957f, 0.00693964f, -0.02052986f, -0.02653484f, 0.03952966f, -0.25297341f, 
    -0.04378447f, -0.08975000f, 0.03198817f, 0.17659600f, 0.12953664f, -0.16094106f, 0.05319478f, 0.07683451f, 
    -0.22649974f, -0.35405582f, -0.08963684f, 0.00919158f, 0.09255508f, 0.02196886f, -0.01192664f, 0.07527177f, 
    0.02667636f, 0.05618788f, 0.06424594f, 0.13611144f, -0.24833213f, 0.13750841f, 0.05376174f, 0.13744324f, 
    -0.05001110f, -0.04105226f, 0.10645576f, 0.11103743f, 0.13206160f, 0.07356998f, 0.09337799f, -0.01492846f, 
    0.10738762f, -0.05922580f, 0.29837090f, 0.51446134f, 0.03711003f, 0.02754874f, 0.05360001f, -0.05771597f, 
    0.03246197f, 0.03363912f, -0.12978041f, 0.05105631f, 0.04656091f, -0.01962978f, 0.05609024f, -0.02411149f, 
    0.15318562f, 0.12251992f, -0.06559362f, -0.08425977f, -0.09031348f, -0.08378708f, 0.04219630f, 0.14739418f, 
    -0.23063843f, -0.15813802f, 0.00438498f, 0.10540017f, 0.02887168f, 0.10298789f, -0.08220487f, 0.02794824f, 
    0.08513995f, 0.16341200f, 0.15224242f, 0.06230833f, 0.05215331f, 0.09900957f, 0.00843247f, -0.10213310f, 
    -0.20314263f, -0.10726668f, 0.02445709f, -0.03228504f, -0.00751292f, 0.05125608f, -0.09075876f, -0.09652172f, 
    0.15472832f, 0.12012807f, 0.14510067f, -0.15360172f, -0.09106079f, 0.03302157f, -0.18216570f, 0.05255144f, 
    -0.06340591f, -0.08485480f, -0.04989527f, -0.11644331f, -0.25526628f, -0.13201329f, -0.03987483f, -0.21740292f, 
    -0.04843742f, 0.08443929f, -0.12599629f, 0.04182632f, -0.00951083f, 0.07794569f, -0.22218239f, -0.12617682f, 
    -0.08025400f, -0.16564628f, 0.20775788f, 0.22956176f, -0.03310347f, 0.02494226f, 0.00042847f, 0.10993199f, 
    0.12865438f, -0.05877255f, 0.11938151f, 0.03397062f, -0.03270588f, 0.03056053f, 0.17369959f, 0.31367135f, 
    0.09104482f, 0.12107416f, 0.12354786f, -0.01144251f, 0.07973015f, 0.09390044f, -0.03790472f, -0.01547542f, 
    -0.02446401f, -0.20742843f, -0.14774492f, 0.04988913f, -0.03844438f, -0.07031593f, 0.00803962f, 0.03540835f, 
    0.15419433f, 0.07246554f, -0.04397140f, -0.00343694f, 0.32449043f, 0.16467060f, -0.03205919f, -0.04318649f, 
    0.06610584f, 0.05083996f, -0.08877024f, 0.05064826f, 0.00887449f, 0.11662385f, 0.01592551f, -0.04036098f, 
    -0.05008758f, -0.00567233f, 0.14014240f, -0.00644578f, -0.06090582f, 0.17092784f, 0.02845412f, -0.13875815f, 
    -0.09298371f, -0.07978216f, -0.05222823f, 0.12400754f, -0.16916078f, 0.03347088f, -0.11554091f, 0.08606080f, 
    0.02800567f, -0.09466304f, 0.04365458f, 0.00810086f, 0.13353057f, 0.06352653f, -0.03394860f, -0.00194712f, 
    -0.05228976f, 0.21828052f, 0.20209815f, 0.07803416f, -0.01668847f, -0.12297151f, -0.02198980f, -0.05187603f, 
    -0.01389118f, 0.04412479f, 0.06205114f, -0.07354598f, -0.10425551f, -0.01593484f, 0.05199986f, 0.16732420f, 
    0.05356639f, 0.07277700f, 0.00018323f, 0.06289055f, 0.18341422f, 0.08737942f, -0.01573763f, 0.03171855f, 
    -0.18902624f, 0.09124389f, 0.17609537f, 0.12936810f, 0.05117412f, 0.13622370f, 0.02163159f, -0.00543948f, 
    -0.04763114f, 0.08711288f, -0.02868535f, -0.04525457f, 0.21353874f, -0.23184498f, -0.07045063f, 0.11040872f, 
    0.03248787f, 0.17591518f, -0.16193040f, 0.03609476f, -0.03647830f, 0.18394947f, 0.01559521f, 0.00347072f, 
    0.01471785f, 0.13819842f, 0.15231276f, 0.44930443f, 0.09916206f, -0.08399016f, 0.00398887f, 0.02709574f, 
    0.15259825f, -0.05696357f, 0.10813235f, 0.03049101f, 0.47014546f, 0.01000521f, -0.19239172f, 0.12052082f, 
    0.02783565f, -0.08561636f, 0.15267190f, -0.11703577f, 0.09694365f, -0.07027284f, -0.00694517f, 0.07659905f, 
    -0.19149897f, -0.15641762f, 0.00931809f, 0.10555867f, 0.00371444f, 0.05434509f, 0.10451735f, -0.10383812f, 
    0.07773608f, 0.04531510f, 0.06920092f, 0.01776007f, 0.12693824f, -0.07754911f, 0.15303573f, 0.09387945f, 
    0.04974229f, 0.02493974f, -0.18389659f, -0.01692184f, -0.14508350f, -0.01148051f, 0.06571370f, 0.02265033f, 
    -0.09854332f, -0.20357217f, 0.10996158f, 0.21762420f, -0.14140543f, -0.10945521f, -0.08840739f, 0.04217812f, 
    0.03399045f, 0.14764915f, 0.03623128f, -0.01401114f, 0.20980549f, 0.17155781f, -0.21395664f, -0.20011631f, 
    0.09062396f, 0.00715121f, -0.01793696f, -0.05211252f, 0.07936211f, 0.03844654f, -0.01388878f, 0.09763448f, 
    -0.53154504f, 0.08949180f, 0.44115716f, 0.06061416f, -0.06573455f, 0.14069271f, 0.08420573f, 0.06772670f, 
    -0.06408381f, 0.09628672f, 0.02443874f, 0.00225911f, -0.02360848f, -0.06102214f, 0.08341286f, -0.04887522f, 
    0.08161239f, 0.00764071f, -0.24647918f, 0.05606094f, -0.21178328f, 0.00402966f, -0.00339242f, 0.00680684f, 
    -0.18669459f, -0.07485164f, 0.15975487f, 0.16298951f, 0.02766525f, -0.06415027f, 0.13851474f, 0.05751960f, 
    -0.04737233f, 0.06386703f, -0.11708088f, 0.12987687f, 0.02829521f, -0.22478889f, -0.09998521f, 0.06551794f, 
    -0.05541528f, 0.00504054f, 0.02073880f, -0.02781571f, 0.06823130f, 0.07774870f, -0.06817576f, -0.01006188f, 
    0.12800106f, -0.20971768f, -0.03206015f, 0.06066553f, -0.06097195f, -0.15703845f, 0.05335434f, -0.00313534f, 
    0.08692911f, 0.01974832f, 0.03304763f, 0.02787762f, -0.10803070f, 0.17852272f, 0.05461155f, -0.02184498f, 
    -0.07400637f, 0.04194425f, 0.03827526f, -0.07674780f, -0.06312728f, 0.04646181f, 0.10394262f, 0.05077427f, 
    0.25484809f, -0.16059382f, 0.03272928f, -0.17509335f, 0.03050239f, -0.13009936f, -0.06979614f, 0.06869452f, 
    0.02310210f, -0.16283622f, -0.10936613f, -0.12832108f, -0.37463450f, -0.18250421f, 0.27948365f, 0.13114874f, 
    0.08619117f, -0.05872377f, 0.05147310f, -0.03634177f, -0.29430839f, 0.04862684f, 0.22666362f, 0.13010237f, 
    0.00055459f, 0.31593972f, 0.20234258f, 0.09938819f, -0.06607544f, -0.01559173f, 0.06483854f, 0.12204237f, 
    -0.05304290f, 0.03284595f, 0.03976604f, -0.15234981f, 0.29227063f, 0.04829832f, 0.23043354f, -0.33267340f, 
    0.13494436f, -0.04643061f, -0.09851617f, 0.12914707f, -0.08703148f, -0.00958361f, 0.10075661f, -0.13382910f, 
    -0.48735714f, -0.16539571f, -0.33352107f, 0.35816762f, 0.04401898f, 0.15057003f, 0.04461825f, -0.01886801f, 
    0.08493870f, -0.05292891f, 0.05186560f, 0.02524506f, -0.07761093f, 0.03406305f, -0.06990588f, -0.07736919f, 
    0.16414474f, 0.04447754f, 0.01712873f, 0.14352043f, 0.05382549f, 0.12527917f, 0.00617959f, 0.07766324f, 
    0.16333964f, -0.12529963f, -0.03004166f, 0.04006999f, -0.03125804f, 0.04550591f, 0.04524338f, 0.01981969f, 
    -0.11918014f, -0.03883091f, 0.07267948f, 0.08408626f, -0.00299480f, -0.13795069f, -0.07030845f, 0.06550033f, 
    0.10069688f, 0.12706405f, 0.02090738f, 0.16469927f, -0.03424895f, -0.07091914f, -0.01737739f, -0.01070305f, 
    0.32632908f, -0.10866712f, -0.28224462f, -0.14727159f, 0.05321567f, 0.12348285f, 0.14388655f, 0.07274414f, 
    -0.15518966f, 0.04012068f, -0.11586569f, -0.03940135f, 0.15874541f, 0.04458732f, 0.01310412f, 0.01595063f, 
    -0.04603748f, 0.01179382f, -0.00790375f, -0.00279948f, -0.00177102f, -0.17726526f, 0.05846753f, -0.14160654f, 
    0.01880816f, 0.12723853f, 0.02648851f, -0.20331521f, -0.07315074f, -0.04574737f, -0.06796762f, -0.06194207f, 
    0.03881406f, 0.00599765f, -0.08126950f, -0.04556311f, 0.10199969f, 0.00466297f, -0.17995228f, -0.15113720f, 
    0.05158333f, 0.02602843f, 0.08763757f, 0.09267321f, 0.01476637f, 0.00697801f, -0.14778611f, 0.14465383f, 
    -0.01003823f, 0.42541781f, 0.41861022f, 0.17256963f, -0.15636146f, -0.04014073f, -0.02665035f, 0.01469492f, 
    -0.12954417f, -0.00773900f, 0.09619750f, 0.09747647f, -0.05366062f, 0.04946176f, -0.20347722f, -0.11689464f, 
    -0.02587651f, 0.04608445f, 0.03524362f, 0.01046532f, 0.02698470f, -0.07035296f, 0.13083915f, -0.01810719f, 
    0.08904672f, -0.33751473f, -0.11440574f, 0.10358419f, 0.22502708f, 0.07880117f, 0.12632318f, -0.04776098f, 
    0.11045875f, 0.02619986f, 0.04532306f, 0.06144633f, 0.01642001f, -0.10726120f, 0.10774149f, 0.16561061f, 
    0.11966690f, -0.02976931f, -0.08006036f, -0.01284899f, -0.06416655f, 0.16915172f, 0.06948853f, 0.00694525f, 
    0.34542912f, -0.09618710f, 0.04976147f, -0.16094156f, -0.01057035f, 0.17252129f, 0.09869843f, 0.06225123f, 
    0.06026446f, 0.09498402f, -0.14093480f, 0.07082694f, 0.02097588f, -0.02023498f, 0.05545691f, -0.02692854f, 
    0.04392497f, -0.00655397f, 0.02840331f, -0.02622937f, 0.11365589f, 0.00752327f, 0.21057552f, 0.21524557f, 
    0.21762246f, -0.06101099f, -0.15525001f, -0.21892343f, 0.02798576f, -0.01313917f, 0.16628194f, 0.00160860f, 
    0.09351023f, -0.03454484f, -0.02479689f, -0.15614752f, -0.45409518f, 0.12699203f, 0.14762403f, 0.24116962f, 
    0.03551207f, 0.02429105f, -0.01633910f, 0.05790773f, 0.19537012f, 0.04539081f, 0.09963356f, 0.03995284f, 
    -0.03277412f, -0.13911718f, 0.23225620f, -0.33872747f, 0.04087028f, 0.14436904f, 0.10542018f, -0.06676991f, 
    -0.02404340f, 0.15388428f, -0.00681174f, 0.02362260f, -0.56355411f, -0.17073604f, 0.18164997f, -0.05068061f, 
    -0.09422572f, 0.05549471f, -0.01013080f, 0.00195252f, 0.13481633f, 0.00394613f, 0.15258260f, 0.12710458f, 
    -0.00472107f, 0.16000752f, 0.09685521f, -0.05140804f, -0.18629111f, -0.11070772f, 0.01002477f, -0.03151050f, 
    0.12738162f, -0.00352588f, 0.02521965f, 0.00681110f, 0.02606423f, 0.15258858f, -0.07049937f, 0.07230411f, 
    -0.10228185f, -0.04068607f, 0.17151201f, 0.03458865f, 0.07974567f, -0.03431915f, -0.09247597f, -0.01254944f, 
    -0.05054009f, 0.11058162f, -0.02572290f, -0.12067965f, 0.01639549f, -0.14278242f, -0.06190543f, -0.09648930f, 
    -0.00614426f, -0.09910893f, -0.00392297f, -0.06906101f, -0.18723592f, -0.21063428f, 0.25939783f, 0.47925818f, 
    -0.04855882f, -0.00538058f, 0.06349860f, 0.06012147f, -0.00458633f, 0.02728451f, 0.00366488f, 0.09993932f, 
    0.39216527f, 0.16558497f, -0.01098175f, -0.00401801f, 0.07870214f, -0.11218166f, -0.04070348f, 0.06785876f, 
    0.02328404f, 0.01212467f, 0.23597540f, 0.18333688f, -0.20336162f, -0.25103232f, 0.14837392f, 0.25075218f, 
    0.07144427f, 0.01631924f, 0.21219161f, 0.03875443f, -0.01245016f, 0.14544296f, -0.15358920f, 0.07757322f, 
    0.08363794f, 0.16267088f, 0.04349621f, -0.06465757f, -0.07615301f, -0.16540284f, -0.01816110f, 0.01365828f, 
    0.02549670f, 0.00758765f, 0.04042016f, 0.01730282f, -0.17130563f, 0.10025616f, 0.12493204f, -0.00860691f, 
    -0.18385714f, -0.06632704f, -0.09662249f, -0.13656630f, -0.06647789f, -0.18689099f, -0.04131047f, -0.07571005f, 
    -0.08636128f, 0.21327914f, 0.00497320f, -0.06202894f, 0.00623454f, 0.16171093f, -0.04742544f, 0.05519351f, 
    0.03534372f, 0.13772759f, 0.07020546f, 0.08408112f, 0.42302033f, 0.02666631f, -0.10252658f, -0.12440644f, 
    -0.01084142f, -0.00563722f, 0.06288292f, -0.05388973f, 0.11549463f, 0.02800153f, 0.14093596f, 0.11333320f, 
    -0.17710695f, 0.01524037f, -0.17703219f, 0.13479875f, -0.00151073f, 0.04988069f, 0.03970337f, 0.09086837f, 
    -0.07375342f, -0.06126807f, -0.09732278f, -0.18627769f, 0.37473169f, 0.27310511f, -0.06940801f, -0.01769019f, 
    -0.00381930f, 0.05514535f, 0.08615263f, 0.05453233f, -0.03340281f, 0.00185360f, -0.08391055f, -0.04677891f, 
    0.10810922f, 0.01880098f, 0.03948461f, 0.20140916f, 0.11027689f, 0.06173453f, 0.02697759f, -0.00345676f, 
    -0.04729948f, 0.02770203f, -0.09974247f, 0.04417557f, -0.16624503f, -0.17271674f, 0.16730130f, 0.06717501f, 
    0.08024922f, 0.12230512f, 0.06240796f, 0.10147829f, 0.19389364f, 0.15307479f, -0.03033465f, 0.15269807f, 
    -0.24600096f, 0.19639206f, -0.05768592f, 0.20914370f, 0.27283683f, -0.03402342f, 0.19712210f, 0.05811711f, 
    -0.06481677f, 0.06958751f, 0.18572877f, 0.08411770f, 0.11541658f, -0.14243148f, -0.02175784f, 0.13057455f, 
    -0.10859536f, 0.03458240f, 0.00291130f, 0.12587994f, -0.10041869f, 0.01941375f, -0.01798666f, -0.17979558f, 
    -0.10021456f, 0.02045613f, -0.07821682f, 0.21081851f, -0.02573955f, -0.00158162f, 0.04921501f, 0.05249216f, 
    0.02774248f, 0.02976286f, 0.03833456f, 0.06119385f, 0.21776059f, 0.20071264f, 0.22867416f, 0.04032649f, 
    -0.17076620f, -0.23411015f, -0.10189134f, -0.13785528f, -0.07104327f, 0.01503874f, -0.15704997f, -0.14289667f, 
    0.40568519f, -0.11231898f, 0.45486116f, -0.26178560f, 0.03776082f, 0.03407442f, -0.14438030f, 0.10379574f, 
    -0.04740323f, -0.02030201f, -0.04247564f, -0.02675107f, -0.16358174f, -0.11356291f, -0.15303595f, -0.14591481f, 
    -0.04905163f, -0.01972364f, -0.14186940f, -0.21737358f, -0.10123551f, 0.08669222f, -0.01446896f, -0.04970952f, 
    -0.25120771f, -0.18682452f, -0.11972632f, -0.03535559f, -0.04119475f, 0.05697962f, 0.06106446f, -0.26674137f, 
    0.10660890f, -0.11972766f, -0.01285764f, 0.21268289f, 0.30374739f, -0.04204032f, 0.34870377f, 0.01770967f, 
    0.11447722f, 0.12462554f, 0.11208614f, 0.13798837f, 0.05525328f, 0.04887117f, 0.05750742f, -0.08155196f, 
    -0.20080666f, -0.17913401f, -0.26087859f, -0.05116918f, -0.04762961f, 0.10161404f, -0.04477201f, 0.05974083f, 
    0.00641591f, 0.16441827f, 0.09603617f, -0.10054299f, 0.31753919f, -0.10472754f, 0.39036927f, -0.03589629f, 
    0.00100607f, 0.04467839f, -0.08743611f, 0.05595324f, -0.11748936f, 0.03473969f, -0.10910586f, -0.01918800f, 
    -0.19536313f, 0.24566264f, 0.05512649f, 0.03906324f, 0.03933310f, 0.04722586f, 0.02448014f, -0.06661848f, 
    -0.04797896f, -0.17991284f, -0.03528326f, -0.11439987f, -0.17952541f, 0.52837127f, 0.11002226f, 0.06150430f, 
    0.05233150f, -0.02371684f, -0.01192800f, 0.03583216f, 0.16409622f, 0.00749267f, 0.01594804f, 0.08119550f, 
    0.00736052f, 0.08327169f, 0.44315952f, -0.13337226f, -0.05265330f, -0.12285199f, -0.22857410f, -0.12449870f, 
    -0.04230101f, -0.07564624f, -0.00136948f, 0.00993649f, 0.02736941f, 0.19784467f, -0.05154558f, -0.15187967f, 
    -0.00369053f, 0.02635786f, 0.00147731f, 0.09602059f, -0.03210969f, -0.09662283f, -0.15231235f, -0.18602040f, 
    -0.29883128f, 0.02800337f, 0.10710496f, -0.18496841f, 0.15915360f, -0.08010244f, -0.11150279f, -0.12060492f, 
    -0.10268729f, 0.18769841f, 0.14902599f, 0.06820071f, -0.02162391f, 0.33331531f, 0.12909411f, -0.03346158f, 
    0.00076377f, 0.18144795f, 0.18123591f, 0.00135003f, 0.03475661f, 0.18831681f, -0.00400769f, 0.01644213f, 
    -0.09779046f, -0.20459068f, 0.13380831f, -0.28180870f, 0.14338525f, -0.00301730f, -0.10137682f, -0.09286410f, 
    -0.12402346f, -0.05703111f, 0.12799679f, 0.08494546f, 0.26374149f, 0.01572656f, 0.32518291f, -0.13838866f, 
    0.07510637f, -0.08311987f, 0.09344612f, 0.04607144f, -0.06999887f, 0.14332974f, -0.08112706f, -0.14666326f, 
    -0.08309672f, -0.44469160f, -0.13989630f, 0.04373223f, -0.01050693f, 0.11118314f, 0.02542992f, -0.01189483f, 
    0.00046886f, -0.14499940f, -0.06888013f, -0.02904804f, 0.01176843f, 0.34500599f, 0.22056763f, 0.28522399f, 
    -0.11578062f, 0.04373760f, -0.00317925f, 0.10199494f, 0.05916475f, 0.18965554f, 0.06738947f, 0.12899745f, 
    -0.16625461f, -0.36645895f, -0.07665589f, 0.04589589f, -0.00884369f, 0.05374517f, -0.04096057f, -0.15611531f, 
    -0.06296887f, -0.02820919f, 0.02457294f, 0.18947144f, -0.08072445f, -0.15742840f, -0.02618496f, -0.22883898f, 
    -0.09625649f, -0.08452199f, -0.00482205f, 0.01226795f, 0.12514403f, 0.01518531f, 0.07116408f, 0.06017304f, 
    0.02173186f, 0.24474090f, -0.23814610f, 0.09937171f, -0.07531983f, 0.04753803f, 0.06849273f, -0.07843905f, 
    0.11258022f, 0.04921857f, -0.04555968f, 0.06072690f, -0.02599495f, 0.41556051f, -0.18331517f, 0.07444282f, 
    0.15046044f, -0.09331266f, 0.12659001f, -0.00109757f, 0.07535075f, 0.15862671f, 0.15163292f, 0.28441671f, 
    -0.25932360f, -0.16063438f, 0.16104524f, 0.17492078f, 0.24703842f, 0.02884400f, -0.01229116f, -0.03656339f, 
    -0.08685113f, 0.00930873f, -0.02665045f, -0.00906750f, -0.08482190f, -0.25107583f, -0.07460294f, 0.01644305f, 
    -0.11971577f, -0.11815884f, 0.04358880f, 0.11008112f, -0.08496174f, 0.12350830f, 0.02539204f, 0.02571697f, 
    0.09534397f, -0.05506298f, -0.03546145f, 0.00160719f, -0.01592967f, 0.05131569f, -0.01182925f, 0.10268608f, 
    -0.12621260f, -0.05366552f, -0.17104135f, -0.05991911f, 0.38617641f, 0.08021115f, 0.28791863f, 0.11928879f, 
    0.00201764f, -0.11664841f, -0.11196554f, 0.08395859f, -0.07714157f, 0.12341868f, -0.04481896f, -0.03341089f, 
    -0.14552765f, -0.01578119f, -0.10968582f, -0.04664297f, 0.09143637f, 0.00015663f, 0.03927666f, -0.07079894f, 
    -0.00267956f, 0.10856586f, 0.01672426f, 0.14645122f, 0.13522877f, 0.40446037f, -0.19819961f, 0.47603706f, 
    0.01600465f, 0.27226189f, -0.02187562f, 0.03700477f, 0.26536939f, 0.08350646f, 0.21159945f, 0.18668668f, 
    0.16690454f, 0.32031080f, 0.14962114f, 0.25868243f, -0.03774361f, -0.02235533f, 0.01715879f, 0.04503174f, 
    0.06769079f, 0.03933192f, -0.10574638f, -0.19280329f, 0.14874789f, -0.08951840f, 0.15105879f, -0.17486408f, 
    0.06686528f, 0.02759525f, 0.03819647f, -0.02063865f, -0.10083041f, -0.01467741f, -0.03451842f, 0.03480619f, 
    -0.48928136f, 0.13424985f, -0.31616759f, 0.31244349f, 0.17981493f, -0.10735874f, -0.00045260f, 0.08562841f, 
    0.07358758f, -0.05195532f, 0.07164253f, 0.04479065f, 0.03566161f, -0.00182719f, -0.05751320f, 0.13425060f, 
    0.02195194f, -0.03094500f, -0.08814695f, 0.01044400f, -0.13439426f, 0.05828482f, -0.01610778f, -0.16500500f, 
    0.24561827f, -0.12668417f, -0.00942384f, 0.09425233f, -0.10387989f, -0.04574247f, 0.09820716f, 0.05633657f, 
    -0.03333995f, -0.11727542f, 0.00908900f, -0.01955291f, 0.12467917f, 0.04241852f, 0.18840915f, 0.07356604f, 
    0.03247783f, -0.01955617f, 0.03075719f, -0.04568480f, 0.02019157f, 0.08130085f, 0.06828140f, -0.08047802f, 
    0.17938349f, -0.25883293f, 0.24585693f, -0.14182028f, 0.03569118f, 0.05499696f, 0.05017623f, 0.06732424f, 
    0.03022156f, 0.11027138f, -0.01269085f, 0.14247966f, 0.14732824f, 0.06564321f, 0.03552690f, 0.02184482f, 
    -0.06461205f, -0.04772411f, 0.04217736f, -0.05882232f, -0.11167736f, 0.00852703f, 0.11801013f, -0.02741527f, 
    -0.26610684f, 0.04358553f, -0.16387613f, -0.25081062f, 0.00500963f, -0.02383748f, 0.08757240f, -0.18937369f, 
    -0.00526384f, -0.07217561f, -0.07737809f, 0.10454330f, 0.12231243f, -0.14516287f, 0.01581395f, -0.12233590f, 
    0.00610037f, 0.09206275f, -0.04806551f, 0.05886047f, 0.17740561f, 0.03672234f, -0.03523947f, -0.01872257f, 
    -0.02662634f, 0.17077622f, 0.01087527f, 0.00200553f, -0.18351479f, 0.10002817f, -0.00845036f, -0.05001697f, 
    -0.04230452f, -0.01999359f, 0.07614217f, -0.05856121f, -0.09538997f, -0.16463944f, 0.18244354f, -0.03250725f, 
    0.04230531f, -0.12754920f, 0.01577549f, -0.04694834f, 0.04102015f, -0.02939840f, -0.11316071f, -0.01928679f, 
    0.10307049f, 0.07367954f, -0.05026354f, -0.07725650f, 0.10718203f, -0.12626740f, -0.05274180f, -0.04245486f, 
    -0.02323186f, -0.01064167f, 0.11052810f, -0.05517201f, -0.00614113f, 0.35938463f, 0.10654899f, -0.10378966f, 
    0.02278570f, -0.00724462f, -0.03054321f, 0.07159502f, -0.02190477f, 0.08325208f, -0.02969994f, 0.02888753f, 
    0.04376896f, -0.07164694f, 0.20083539f, -0.17095259f, -0.12325697f, -0.06069694f, -0.15266016f, -0.00112307f, 
    0.03543021f, 0.07882072f, 0.02783051f, 0.13648361f, 0.06257738f, 0.01933637f, -0.08773217f, -0.19919531f, 
    -0.05333415f, -0.11743491f, -0.06655594f, 0.02083988f, -0.07347584f, -0.02520897f, -0.00868305f, -0.09220298f, 
    -0.01147570f, 0.01063441f, 0.14976804f, -0.19711107f, 0.14728864f, 0.04040289f, 0.13398512f, -0.02102451f, 
    0.00527755f, 0.07890596f, 0.09031279f, 0.06825326f, -0.24030297f, 0.27879003f, 0.13148901f, -0.01738221f, 
    -0.19172378f, 0.06894087f, 0.17648308f, -0.08252680f, 0.12165771f, 0.01938125f, 0.06399486f, -0.04626682f, 
    -0.33569393f, -0.31479067f, 0.12009853f, -0.45144084f, -0.00842095f, 0.00164516f, -0.09983926f, -0.03954370f, 
    0.04240650f, -0.03716255f, 0.07030389f, -0.02635955f, -0.04063741f, -0.20690678f, 0.33914524f, -0.08957940f, 
    0.09561308f, -0.04310906f, -0.09434339f, -0.00550282f, 0.04835481f, 0.06873160f, -0.07689928f, -0.14673641f, 
    -0.06126261f, -0.20471935f, -0.15202816f, -0.01391017f, -0.18907385f, 0.02453938f, -0.09227796f, -0.02188405f, 
    -0.00887251f, -0.08903072f, -0.08321055f, 0.07840658f, -0.08990513f, 0.21023622f, 0.09179745f, 0.11791281f, 
    -0.09744351f, 0.01196547f, 0.11747082f, 0.16398962f, 0.05214441f, 0.16558234f, 0.04480498f, 0.13644335f, 
    -0.08946297f, -0.10782821f, 0.01146537f, 0.04847140f, -0.07666668f, -0.00503609f, 0.03881964f, -0.10353019f, 
    -0.04662006f, -0.08563955f, 0.04497432f, 0.10459553f, -0.26663461f, -0.25530571f, 0.16994832f, 0.12683979f, 
    -0.08533508f, 0.06387225f, 0.07469930f, 0.10692821f, 0.04185528f, -0.00236547f, -0.02574797f, -0.08139914f, 
    0.34543601f, 0.18621530f, -0.34125400f, 0.11788752f, -0.11165711f, -0.09869687f, 0.00591746f, -0.14960302f, 
    0.03803033f, -0.10572593f, -0.00173096f, 0.11013605f, -0.10645686f, 0.06896587f, -0.08429631f, 0.15753676f, 
    0.01417249f, -0.07690149f, 0.11993439f, 0.01280212f, 0.15158057f, 0.05988986f, 0.04220858f, 0.18643543f, 
    -0.06521548f, -0.11627320f, 0.24044518f, 0.15059957f, 0.08779045f, -0.07256567f, -0.12870854f, 0.02268419f, 
    -0.07228102f, -0.02458331f, 0.14469086f, 0.01668592f, 0.00481522f, 0.05034738f, 0.13003455f, 0.12856758f, 
    -0.23004285f, -0.10134110f, 0.04961728f, 0.08978685f, -0.05338444f, -0.01809821f, 0.03212518f, 0.09465427f, 
    -0.05979283f, 0.09774522f, 0.00305860f, 0.04116607f, -0.06403068f, 0.21968278f, -0.08985293f, 0.07675991f, 
    -0.03420534f, -0.01783941f, -0.03514647f, -0.07966433f, 0.32068989f, -0.02547796f, 0.23555288f, -0.04686194f, 
    0.03259318f, -0.04368617f, 0.01849640f, 0.03939939f, -0.00642652f, -0.06346168f, -0.04951738f, -0.11947973f, 
    -0.13276756f, 0.12449335f, -0.03260152f, 0.10391130f, -0.02581164f, -0.04141958f, 0.08240706f, 0.02863763f, 
    0.04922958f, 0.01485958f, 0.11722440f, 0.11603709f, 0.16395220f, 0.42033327f, -0.22041363f, 0.29482424f, 
    -0.15703946f, 0.35128793f, -0.07917596f, -0.07121757f, -0.03455174f, 0.20018728f, -0.08914240f, 0.01518380f, 
    -0.05411550f, 0.01368346f, 0.03296995f, 0.00273020f, 0.03677877f, -0.04365870f, 0.00002248f, 0.04069091f, 
    0.01368908f, -0.01095993f, 0.01530914f, -0.05292153f, 0.00681890f, -0.00182009f, -0.04798489f, -0.05082259f, 
    -0.03665501f, -0.02765960f, -0.03497427f, -0.00744542f, -0.03308637f, 0.00050520f, -0.00255667f, -0.01574213f, 
    -0.05308901f, -0.02636347f, -0.02023396f, -0.03218786f, 0.03849244f, -0.03719231f, 0.03478901f, 0.03827975f, 
    0.03741059f, -0.01835803f, 0.01113798f, -0.05167622f, -0.02252401f, -0.03682293f, 0.00593795f, -0.01364354f, 
    -0.05652144f, -0.02387828f, 0.01226780f, 0.01692610f, -0.04012354f, -0.05122890f, -0.04705649f, -0.01428354f, 
    0.00637409f, -0.02773765f, -0.00805559f, -0.05603992f, 0.01796835f, 0.03998218f, -0.03746044f, 0.01569080f, 
    0.03642894f, -0.03251546f, 0.03462608f, 0.02008446f, 0.00627610f, 0.00510967f, -0.02012667f, -0.04284117f, 
    -0.05162125f, -0.01851399f, -0.05256172f, -0.00784320f, -0.04020223f, -0.04096964f, -0.05549470f, -0.00844000f, 
    -0.00457282f, 0.01825617f, -0.00660567f, -0.05614970f, 0.02161444f, -0.04775256f, -0.01839419f, 0.01113296f, 
    -0.03724084f, 0.01118613f, 0.00282095f, -0.04939173f, -0.04493383f, 0.03100272f, -0.04288448f, -0.02589813f, 
    -0.03604347f, -0.04822868f, 0.00497434f, -0.04154971f, -0.00285989f, 0.02122181f, 0.01378845f, 0.00747687f, 
    -0.04551504f, -0.00961449f, 0.02126116f, 0.02850329f, -0.00783825f, 0.00404215f, 0.00380467f, 0.00275653f, 
    0.02638686f, -0.00323632f, -0.03089055f, -0.02125687f, -0.05177611f, -0.04854948f, 0.03022754f, -0.05199080f, 
    -0.05345491f, 0.01606130f, -0.00400928f, 0.04003711f, 0.00851876f, -0.01434749f, -0.05106644f, -0.01298902f, 
    -0.00440193f, -0.00917450f, -0.02478808f, -0.04212663f, -0.02006948f, 0.03213692f, -0.00088622f, 0.03144799f, 
    -0.01212843f, -0.05612829f, 0.03644788f, 0.00698546f, -0.02610043f, 0.00341281f, -0.00740862f, -0.04965726f, 
    -0.02405362f, 0.02110087f, -0.01441751f, -0.00377248f, -0.00734259f, -0.05279970f, -0.01006769f, 0.03014731f, 
    -0.02794149f, -0.01322111f, 0.03873304f, 0.01779520f, 0.02385159f, 0.00952386f, 0.00761086f, 0.01692790f, 
    -0.00106190f, -0.03530682f, -0.03814064f, -0.04047326f, -0.05415237f, -0.04023292f, -0.02873415f, 0.01986890f, 
    -0.05415241f, -0.03932165f, 0.00520115f, -0.01139309f, 0.02454801f, -0.04816542f, 0.00152699f, -0.03982122f, 
    0.01217254f, 0.01594085f, 0.00036350f, 0.00895311f, 0.02312363f, 0.02402602f, 0.03063514f, -0.02188542f, 
    0.02433578f, 0.02777478f, -0.05158850f, 0.03928233f, 0.03176639f, -0.04097583f, -0.05662213f, -0.01158811f, 
    0.03491017f, 0.02615329f, -0.03262011f, 0.02344266f, 0.01837713f, 0.00831845f, 0.04203321f, 0.02292646f, 
    -0.03426191f, 0.03872230f, -0.02643395f, -0.03002677f, 0.03432249f, 0.00685458f, -0.04188235f, -0.04029847f, 
    0.03541951f, -0.01014569f, -0.04220876f, -0.01902058f, -0.00943154f, -0.04222001f, 0.02100990f, 0.04399989f, 
    -0.00766296f, -0.04580026f, -0.01496801f, -0.01320389f, 0.02654349f, 0.04240321f, -0.00270948f, -0.00685161f, 
    0.00735960f, 0.04407740f, 0.02642941f, -0.04588405f, 0.01576214f, 0.02741954f, -0.05026710f, 0.03599739f, 
    -0.05580153f, -0.05570547f, 0.03380903f, -0.00010302f, 0.00607936f, 0.01510010f, 0.01642526f, 0.02315557f, 
    0.00500980f, 0.01120251f, -0.03462142f, 0.04207497f, -0.03335352f, 0.03328501f, 0.04039469f, -0.01660080f, 
    0.02888912f, 0.02770696f, -0.02387156f, 0.00845725f, -0.01872684f, 0.01183310f, -0.03293788f, 0.01953797f, 
    -0.05115160f, -0.04354260f, -0.00371365f, -0.01761473f, -0.01518483f, -0.03549381f, 0.04011825f, 0.00232835f, 
    -0.02603889f, -0.02275975f, -0.00292472f, 0.01230265f, -0.02595303f, -0.05337689f, 0.00953823f, 0.03320711f, 
    0.00270975f, -0.04886238f, -0.00667261f, -0.00116923f, -0.05517641f, -0.04356453f, 0.00129592f, -0.00655830f, 
    -0.00755463f, 0.02349771f, -0.00283153f, 0.03862536f, 0.03786778f, 0.03638074f, 0.00956664f, -0.01936997f, 
    -0.03788646f, 0.00661518f, 0.04429255f, -0.02278190f, -0.03362588f, -0.05106432f, 0.01646085f, 0.04111232f, 
    -0.04409513f, -0.03026536f, -0.02186774f, 0.00738299f, 0.02859342f, 0.03609679f, -0.00044491f, -0.05641441f, 
    0.01658063f, 0.00032183f, -0.01093391f, -0.02732798f, -0.02062137f, 0.02252056f, -0.00280772f, -0.01667018f, 
    0.02701179f, 0.02209229f, -0.05361558f, 0.01580000f, 0.02984894f, 0.03830341f, -0.02947142f, -0.00652965f, 
    -0.05449316f, -0.01704081f, -0.03044483f, -0.00369730f, -0.01476731f, -0.04084754f, 0.00641870f, -0.04711803f, 
    0.03003360f, 0.01542893f, 0.02829222f, -0.04437348f, 0.02270539f, 0.01097634f, 0.01097950f, 0.02637047f, 
    -0.00392953f, 0.01047979f, -0.05544176f, 0.00583060f, 0.00054590f, 0.04429116f, -0.03394091f, -0.01783824f, 
    0.03166061f, 0.02368906f, -0.00725151f, 0.00501759f, -0.01319613f, -0.05656273f, -0.04623054f, 0.02816649f, 
    0.00393273f, -0.01822294f, -0.05558043f, 0.01451889f, -0.03147896f, -0.04871346f, -0.01345512f, -0.05105884f, 
    -0.02215776f, -0.05240855f, 0.03618964f, -0.00487076f, 0.00149953f, -0.02523226f, 0.02786648f, 0.00577241f, 
    -0.00903620f, -0.05048414f, -0.02019667f, -0.01505112f, -0.03224123f, 0.00279128f, 0.01754430f, 0.01589959f, 
    0.03347158f, -0.03991276f, 0.03349826f, 0.00026432f, -0.02574919f, -0.00299486f, -0.04852790f, -0.04027159f, 
    -0.01546846f, 0.03021424f, 0.03423784f, 0.00669959f, -0.05170490f, 0.00394836f, 0.02826837f, 0.00422872f, 
    -0.45525467f, -0.16223171f, 0.04777150f, 0.02340225f, -0.21797220f, -0.18727519f, -0.04748722f, -0.00442407f, 
    0.01982865f, -0.03826921f, 0.00061531f, -0.07657687f, 0.19516815f, 0.17119378f, 0.12140045f, -0.05423721f, 
    0.00774753f, -0.12278962f, -0.09490178f, -0.00150103f, -0.05029614f, -0.10756455f, 0.12010217f, -0.17853877f, 
    0.00686782f, -0.37794501f, -0.31226894f, 0.13182566f, -0.26958436f, 0.21074055f, 0.03994913f, -0.26786757f, 
    -0.00038530f, -0.13190052f, -0.28568456f, -0.09036490f, -0.09512924f, 0.24356768f, -0.00148566f, -0.15818663f, 
    0.18767725f, 0.05364383f, 0.00437984f, -0.11349414f, 0.17504375f, 0.08477271f, 0.06533906f, 0.10869434f, 
    -0.21676785f, -0.23990473f, 0.17371795f, 0.00483903f, 0.13899520f, 0.04591958f, -0.13316755f, 0.05829889f, 
    0.11128698f, 0.21414670f, 0.09485338f, 0.07913252f, 0.00531320f, -0.16158170f, -0.12497417f, 0.10621039f, 
    0.11833760f, 0.07271099f, 0.07353850f, 0.00267215f, 0.11620788f, -0.14146690f, 0.09169885f, 0.15215863f, 
    0.08095055f, 0.25637233f, -0.45929641f, 0.36518577f, -0.00850458f, -0.05076125f, 0.15289070f, -0.32853690f, 
    -0.09749801f, -0.04962302f, -0.12228309f, -0.10459338f, 0.17953682f, 0.09715983f, 0.16227503f, 0.12917317f, 
    0.05008121f, 0.02930660f, -0.04917799f, 0.00909304f, 0.02059290f, -0.17379573f, -0.10197674f, -0.15359847f, 
    0.02057441f, 0.27799505f, 0.13257858f, 0.13723300f, 0.07774585f, 0.03112622f, 0.00451404f, 0.18105805f, 
    -0.05343327f, 0.06593961f, 0.07913493f, -0.11571079f, -0.21167547f, 0.22542457f, -0.45562169f, 0.06996118f, 
    0.00371722f, -0.04852422f, 0.14950028f, -0.04504263f, -0.11160010f, 0.06485126f, -0.06705253f, 0.04845891f, 
    -0.05658130f, 0.24142948f, 0.37145603f, 0.23378766f, -0.31454381f, -0.23466516f, -0.06090118f, 0.07521876f, 
    -0.04954079f, 0.00183581f, -0.05030785f, 0.17318961f, 0.08314388f, 0.36847115f, -0.31895936f, -0.01407403f, 
    0.11411376f, 0.06294110f, 0.17135885f, -0.02391972f, 0.13233542f, -0.09245817f, 0.18298011f, 0.07185172f, 
    0.18189995f, -0.57748479f, 0.17496140f, 0.12854530f, 0.08052601f, 0.09418785f, -0.04327121f, 0.06402510f, 
    0.13788432f, 0.12837622f, 0.08039599f, 0.16928799f, 0.30386990f, -0.46301630f, 0.15590760f, 0.36293435f, 
    0.02352358f, 0.00483504f, -0.17157112f, -0.09312268f, -0.06336411f, 0.18131241f, -0.06311097f, -0.03603329f, 
    0.55342585f, 0.17143354f, -0.23943527f, 0.27402535f, 0.06637542f, 0.09823468f, 0.14727023f, 0.06339979f, 
    0.03629358f, -0.07930571f, -0.14183947f, -0.13603280f, 0.06592380f, -0.04468152f, 0.20570350f, 0.29787335f, 
    0.06449274f, 0.04308980f, 0.11885780f, -0.09693427f, 0.11680204f, 0.14779946f, 0.13066806f, 0.21539487f, 
    0.09847970f, -0.02424970f, -0.52537954f, 0.01818400f, 0.00791120f, 0.17347589f, 0.26432660f, 0.00123551f, 
    0.00183063f, -0.28849643f, -0.12045249f, -0.24782544f, -0.25468343f, -0.18029378f, 0.04624243f, 0.06647243f, 
    0.03504112f, -0.12483421f, -0.08330075f, 0.04542050f, -0.01115027f, 0.00835354f, 0.19904870f, 0.03071635f, 
    0.17049707f, 0.19487068f, 0.20545766f, 0.39562500f, 0.04153720f, 0.07251098f, 0.10295431f, -0.07459950f, 
    0.03164045f, -0.00056622f, -0.00401552f, -0.04345369f, -0.49366623f, -0.02853763f, -0.22084127f, 0.06420154f, 
    -0.15321003f, -0.18758538f, 0.00374891f, 0.08374530f, 0.23103300f, -0.07041956f, 0.08776131f, 0.21085776f, 
    0.03013328f, 0.39967877f, 0.28169012f, 0.07431574f, 0.06639264f, -0.09272601f, 0.12545516f, 0.07408430f, 
    0.06584293f, 0.15442523f, 0.03626803f, -0.00134110f, 0.29969093f, -0.01494055f, 0.14329156f, 0.02996611f, 
    0.03961871f, -0.13350666f, 0.05054592f, -0.12546994f, 0.00937660f, -0.12952410f, 0.04942436f, -0.13729875f, 
    -0.08234850f, 0.08761005f, 0.19040869f, 0.10458390f, 0.01811926f, -0.03117043f, 0.05464106f, 0.07044744f, 
    0.15677078f, -0.04005155f, -0.02875991f, -0.00989128f, 0.21235609f, 0.38748625f, 0.27048305f, 0.56808716f, 
    -0.09048016f, -0.13246185f, -0.12369982f, -0.05643122f, -0.06272285f, 0.03127804f, 0.04911004f, 0.02562445f, 
    0.19874834f, -0.06079518f, 0.43616760f, -0.09340972f, 0.00790550f, -0.08826204f, -0.27294374f, 0.05234217f, 
    0.07199840f, -0.01254465f, 0.01770318f, 0.09118955f, 0.08826612f, -0.38327911f, 0.22402313f, 0.24591991f, 
    -0.06138149f, 0.23715237f, -0.03660825f, -0.24195433f, 0.05465994f, -0.04643237f, -0.07371875f, -0.12512077f, 
    0.12472102f, 0.15680625f, -0.02157475f, -0.14151929f, -0.15876456f, 0.01170695f, -0.05748782f, 0.12249721f, 
    0.20518893f, 0.01230510f, -0.00944435f, 0.05711664f, -0.21285351f, 0.03431422f, 0.14529115f, 0.07552356f, 
    0.05836471f, 0.20834622f, -0.04175305f, 0.01842487f, 0.05898796f, -0.15268849f, -0.04565838f, 0.00623818f, 
    -0.26926222f, -0.02122590f, -0.03015771f, 0.00282078f, 0.02100427f, -0.23907828f, 0.00122636f, -0.06340090f, 
    0.22553951f, 0.06971039f, 0.19294132f, 0.15135439f, 0.12656435f, 0.12972808f, -0.21854940f, -0.08794800f, 
    0.03124688f, -0.07498152f, 0.12191530f, -0.00151938f, 0.17419478f, 0.00703556f, 0.08446778f, 0.24033757f, 
    -0.07110892f, -0.11323704f, -0.19175340f, 0.11646420f, 0.08638155f, 0.04819915f, 0.02055885f, 0.04127538f, 
    -0.08592011f, -0.09449107f, -0.17801201f, -0.16437976f, 0.20036630f, 0.04230077f, 0.40480903f, -0.52574325f, 
    -0.15765947f, -0.19114454f, -0.04438081f, -0.04219386f, 0.02201232f, 0.00490805f, -0.17062093f, 0.00131349f, 
    0.10797102f, -0.02406248f, -0.14037502f, -0.08587525f, 0.01769696f, 0.18908970f, 0.09066023f, -0.03399252f, 
    0.13086674f, 0.04369358f, 0.06871505f, 0.21292052f, -0.23405422f, -0.09334304f, -0.16139443f, 0.15699920f, 
    -0.06093520f, 0.16829582f, 0.09903405f, -0.00028065f, 0.15725709f, 0.01122981f, -0.07355051f, 0.15035482f, 
    0.77261919f, -0.11662126f, 0.08751056f, -0.52776653f, -0.00887285f, -0.02600351f, 0.04495138f, 0.07994717f, 
    -0.03263548f, 0.07229906f, -0.03245049f, -0.06778435f, -0.12184100f, -0.11996324f, 0.03978012f, -0.18338868f, 
    0.17714299f, 0.06921799f, 0.13155587f, 0.10869551f, -0.03054275f, -0.03858734f, 0.01501161f, 0.08560424f, 
    0.34673715f, 0.37549391f, 0.14005846f, -0.10885072f, 0.22298881f, 0.02982981f, -0.00188947f, 0.05788876f, 
    0.28612822f, 0.08373784f, -0.10523515f, 0.00409595f, -0.19867280f, -0.02656551f, -0.10520630f, 0.02462577f, 
    0.06463243f, 0.08928000f, -0.04230166f, -0.05656739f, 0.04398963f, 0.01737485f, 0.01750858f, 0.06265103f, 
    -0.25453484f, 0.26283729f, -0.18824065f, 0.25139657f, -0.02587717f, -0.25322077f, 0.01383483f, 0.03234138f, 
    0.09760797f, -0.04480073f, 0.12749775f, 0.12623264f, -0.26399079f, -0.11931397f, -0.05762660f, -0.08535418f, 
    0.08109304f, 0.04460746f, 0.02351638f, -0.04610026f, -0.03304355f, 0.04674032f, 0.10387728f, 0.16142468f, 
    0.21837226f, 0.10416903f, 0.07978244f, -0.06958617f, 0.18123607f, 0.00994053f, -0.04152068f, 0.17679438f, 
    -0.07631609f, 0.10703410f, 0.07960963f, -0.01772669f, -0.02675341f, 0.12539443f, 0.22515067f, 0.13302583f, 
    0.19567183f, -0.10155529f, 0.06685904f, 0.24094848f, 0.06750111f, -0.04949833f, 0.20901790f, 0.03498596f, 
    0.07985470f, -0.22818634f, -0.08387523f, -0.09323580f, 0.20611902f, 0.21892139f, 0.11082143f, 0.02259574f, 
    0.14109378f, -0.08762974f, 0.05415774f, 0.17344521f, -0.13861893f, -0.04562058f, 0.05096708f, 0.39370850f, 
    -0.02097385f, -0.02694639f, 0.08841845f, 0.08250619f, 0.04214655f, 0.00804190f, -0.00912599f, 0.05816602f, 
    -0.11612862f, -0.01341617f, -0.11388505f, -0.15164198f, -0.17528100f, 0.13011380f, 0.14739068f, 0.24145891f, 
    -0.06387959f, 0.00811348f, -0.03022288f, -0.09386204f, 0.25681594f, -0.15353432f, 0.03176273f, -0.00057721f, 
    -0.17920494f, -0.03816352f, -0.02929337f, -0.10400897f, 0.09014826f, -0.10115533f, 0.06492459f, 0.00941459f, 
    -0.36748418f, 0.05007976f, -0.18044281f, 0.27438787f, -0.02220922f, -0.08987370f, 0.05486448f, -0.01441606f, 
    -0.11897580f, 0.05000010f, 0.13422649f, 0.06237968f, 0.15851760f, -0.03950093f, 0.11191624f, -0.03495848f, 
    0.06764579f, 0.08547723f, 0.00893754f, 0.00346781f, -0.17644639f, -0.08258589f, -0.05626079f, -0.18362539f, 
    -0.01276688f, 0.02475188f, -0.09898185f, 0.27037463f, -0.10951611f, -0.05591514f, -0.07286364f, 0.05036677f, 
    0.05818612f, 0.10568911f, 0.01565937f, 0.03086432f, 0.43792003f, -0.06415681f, -0.16345637f, -0.04947600f, 
    0.26810652f, -0.04158144f, 0.06448855f, -0.00092332f, 0.18320911f, -0.17003956f, 0.02274083f, 0.09519931f, 
    0.23615450f, 0.24516377f, -0.32262334f, -0.09462057f, -0.03758175f, -0.04552330f, 0.08022323f, 0.00258693f, 
    -0.00901584f, -0.07833488f, -0.13943332f, -0.08149582f, -0.37112749f, 0.30647922f, -0.09748048f, 0.03940453f, 
    0.03013070f, 0.08660788f, -0.07467237f, 0.27098429f, 0.09886079f, 0.04881706f, 0.04211502f, -0.15846126f, 
    0.13813268f, 0.27078557f, 0.03064602f, 0.02334444f, 0.07201670f, 0.07418228f, 0.05336588f, 0.17914318f, 
    -0.24437685f, -0.06769531f, 0.05429061f, -0.05361619f, -0.00899415f, -0.16062520f, -0.16717073f, -0.11404387f, 
    0.03898828f, 0.02588064f, -0.05972161f, -0.03520676f, 0.03411934f, 0.20164217f, 0.00246723f, 0.10291986f, 
    0.11227208f, 0.16811596f, -0.10818928f, -0.25807071f, -0.00051383f, 0.03186286f, 0.07048177f, 0.13767251f, 
    0.05716777f, 0.03824522f, -0.06355434f, 0.01643906f, 0.23049875f, 0.04478257f, -0.02452623f, 0.00151427f, 
    0.03367100f, -0.10507805f, -0.02895420f, -0.06195894f, 0.20252696f, 0.07720814f, 0.19979788f, 0.07064798f, 
    0.20945722f, -0.29248682f, 0.07246117f, 0.10967273f, -0.09833577f, -0.01571168f, -0.09520984f, 0.07307445f, 
    0.14391395f, 0.02489684f, -0.01617152f, -0.10335599f, 0.22021632f, -0.00585119f, -0.04513131f, -0.12682669f, 
    0.11295789f, 0.16742404f, 0.03207587f, -0.00420560f, 0.25161591f, -0.01805748f, 0.09226805f, 0.07700264f, 
    0.12173568f, 0.17691864f, -0.17825761f, -0.18482009f, -0.03076699f, 0.24562250f, 0.13814133f, 0.00593492f, 
    -0.04320261f, -0.14938706f, -0.02450084f, -0.08716445f, 0.06471995f, 0.12404831f, 0.02821740f, -0.05909780f, 
    0.23421653f, 0.22712062f, 0.05691056f, 0.18081081f, -0.07466812f, -0.02431999f, -0.02438991f, 0.05206605f, 
    -0.15378508f, 0.20959307f, 0.13239424f, -0.12464049f, 0.10741775f, -0.00255482f, 0.02921157f, 0.07153407f, 
    -0.06214142f, 0.01337756f, -0.03445081f, -0.16259772f, -0.59944004f, 0.04728827f, -0.07665379f, 0.09726135f, 
    -0.00854182f, 0.04572952f, -0.11613350f, -0.00865771f, 0.07061705f, 0.21124768f, 0.07315554f, 0.17858641f, 
    0.05806685f, 0.08987737f, 0.01790810f, -0.06361480f, 0.08698052f, 0.01208973f, -0.00196595f, -0.04668744f, 
    0.02129105f, 0.16080226f, 0.08164944f, 0.18069372f, 0.05057867f, -0.50783068f, 0.14329968f, -0.25011149f, 
    0.07852469f, -0.18794629f, -0.01192840f, 0.20717834f, 0.08271350f, -0.02309879f, 0.06210458f, 0.21245827f, 
    0.29495585f, 0.10034102f, 0.01479404f, -0.00325414f, 0.01818903f, 0.14725697f, 0.03629642f, -0.03174348f, 
    -0.03151494f, 0.04006531f, 0.12145197f, -0.11689933f, 0.33062351f, -0.01248361f, -0.04654514f, 0.12822965f, 
    0.02665498f, -0.05265684f, -0.03535163f, 0.00565956f, 0.07535385f, 0.10990522f, 0.05504855f, -0.08258433f, 
    0.09072456f, 0.57934976f, 0.14623263f, -0.11011120f, -0.04454855f, -0.02144266f, -0.02149775f, -0.14384012f, 
    -0.03727879f, -0.14489061f, -0.05430066f, 0.25645092f, 0.07578781f, -0.13962308f, 0.02730118f, 0.16452065f, 
    -0.07828297f, -0.06607236f, -0.06127409f, -0.01970707f, 0.13472979f, 0.13358831f, 0.05101977f, 0.01993710f, 
    -0.13235530f, 0.17541333f, -0.29294223f, -0.03245451f, -0.03589354f, 0.06071448f, 0.15849863f, -0.03689321f, 
    -0.12918416f, 0.03452392f, -0.10254914f, 0.00269465f, -0.22156429f, -0.20795122f, -0.12372850f, -0.26996410f, 
    -0.19094092f, -0.03941728f, 0.00386889f, -0.02483929f, 0.02766222f, 0.06879050f, -0.03497984f, 0.04362421f, 
    -0.18399180f, -0.14154795f, -0.06034815f, -0.08932544f, -0.24639122f, 0.12845372f, -0.14236630f, -0.05070229f, 
    0.09772361f, 0.01026082f, -0.03784833f, -0.14401889f, 0.05428154f, 0.10966277f, -0.04649828f, -0.02034784f, 
    0.08342769f, -0.11055028f, -0.13017911f, 0.04092603f, -0.02801861f, -0.03925650f, 0.08014975f, -0.02535823f, 
    0.18817508f, -0.08321512f, -0.18641593f, 0.07490315f, 0.05153013f, 0.01397340f, 0.11852819f, 0.07609227f, 
    0.00197110f, 0.14097969f, 0.02424220f, -0.01289649f, 0.10116775f, 0.10640099f, -0.07344697f, -0.13964073f, 
    -0.15894632f, 0.01308423f, -0.13360906f, -0.17831196f, 0.04442863f, -0.12351449f, 0.08075928f, -0.07988496f, 
    0.20245530f, 0.10794981f, 0.11890331f, -0.01110532f, 0.19482678f, -0.03501639f, 0.07165135f, -0.09118282f, 
    -0.06460094f, 0.02408098f, 0.05024956f, -0.01195302f, -0.46127149f, -0.17355345f, -0.09133127f, -0.09194288f, 
    -0.26952907f, -0.09963431f, -0.11575848f, -0.02375334f, -0.08679808f, 0.02433632f, -0.11285520f, 0.13249262f, 
    -0.11129408f, 0.28883311f, -0.01578252f, 0.22879498f, 0.10245694f, 0.01372520f, -0.02141730f, -0.00091925f, 
    0.07775347f, 0.10726248f, 0.07537822f, 0.04140691f, 0.04043883f, 0.20140295f, -0.02050634f, 0.12851916f, 
    0.13155323f, 0.11340660f, -0.01306608f, 0.01644538f, -0.07973013f, 0.12683053f, 0.01124027f, 0.05459154f, 
    -0.25489318f, -0.28102952f, -0.03374308f, -0.01900496f, -0.02866511f, -0.08747486f, -0.06040550f, -0.07154983f, 
    -0.11789543f, -0.05333607f, 0.00368905f, -0.06983322f, 0.00296367f, 0.07200854f, -0.02092383f, 0.18138051f, 
    -0.03983280f, 0.01912754f, 0.00499312f, -0.00577058f, 0.04299977f, 0.09213935f, -0.04599635f, 0.03301689f, 
    0.25307390f, -0.11169520f, 0.18466865f, 0.05843819f, 0.04267823f, 0.11817721f, -0.10210741f, 0.08383572f, 
    -0.13749520f, -0.06572649f, 0.02028070f, 0.20856796f, -0.24198860f, 0.04362171f, -0.04309687f, -0.18920642f, 
    -0.26247576f, 0.02883083f, 0.00276832f, 0.05298518f, 0.06018803f, 0.00104835f, -0.01598256f, -0.10938839f, 
    0.12930904f, -0.00844862f, -0.08894013f, 0.01311823f, 0.11818463f, 0.23573108f, -0.00795493f, 0.18796746f, 
    0.02780786f, 0.10659056f, -0.01088957f, 0.07371674f, 0.86917955f, -0.02237746f, 0.01957076f, 0.15452974f, 
    0.03430830f, 0.17427327f, 0.02716065f, 0.09404656f, -0.22153991f, 0.04867485f, 0.10659896f, 0.16202077f, 
    0.15139470f, 0.05318603f, -0.14544223f, -0.11143394f, 0.08334942f, 0.02236069f, 0.05680027f, -0.06919775f, 
    0.14102438f, 0.09438147f, -0.04692918f, 0.02736217f, -0.27985081f, 0.10457722f, -0.04297795f, -0.15995926f, 
    -0.03363612f, -0.00104473f, 0.00218974f, 0.07499550f, -0.00144838f, 0.06278477f, 0.01132885f, 0.01211999f, 
    0.18256588f, 0.05544199f, -0.06448084f, -0.01562156f, 0.12200567f, 0.04708493f, -0.02889967f, 0.00017906f, 
    -0.10930463f, 0.16711897f, 0.02603844f, -0.04925177f, 0.16518457f, 0.44852722f, -0.05612763f, -0.33584151f, 
    0.09393260f, 0.08596213f, 0.05815738f, 0.04872900f, -0.13565573f, 0.06065596f, -0.07505817f, -0.01915010f, 
    -0.38841766f, 0.12081351f, -0.09241445f, 0.14798717f, 0.05723642f, 0.01746019f, -0.01242101f, -0.07928252f, 
    -0.02079450f, 0.19821395f, 0.00211919f, 0.00912745f, -0.22038911f, 0.33764663f, -0.12303155f, -0.19173920f, 
    -0.06254263f, 0.06207500f, -0.03210913f, 0.07617497f, -0.16091168f, -0.00498920f, 0.09766888f, -0.18567306f, 
    0.15166862f, -0.02908769f, -0.21121882f, 0.10351170f, -0.01338028f, 0.08883052f, 0.02763231f, 0.08408371f, 
    -0.20605102f, 0.02470996f, -0.08203626f, 0.03269092f, 0.20728429f, 0.01018459f, -0.00217515f, -0.09613826f, 
    0.03398103f, -0.05278880f, 0.06716882f, -0.01091990f, -0.04224386f, 0.04596635f, -0.04027563f, -0.00233116f, 
    0.30122435f, -0.04689324f, -0.01758744f, 0.14848225f, 0.00585129f, 0.16076542f, 0.06166242f, 0.02342821f, 
    0.08056899f, 0.07958087f, 0.07962211f, 0.22185045f, 0.19092044f, -0.07244317f, -0.03006472f, -0.04103411f, 
    -0.15633275f, -0.07372549f, -0.09974449f, -0.10568992f, -0.04510123f, -0.01616914f, -0.07189453f, 0.10090559f, 
    -0.14406729f, -0.12976222f, 0.00542088f, -0.02966465f, -0.06439873f, 0.09753210f, 0.04286661f, -0.18995933f, 
    -0.11506748f, -0.15713997f, -0.07516915f, 0.03108438f, -0.36462545f, 0.41668588f, 0.04056366f, 0.10825866f, 
    -0.00171409f, -0.21910369f, -0.03005397f, -0.09654839f, 0.03864550f, 0.08930171f, 0.13033007f, -0.15692358f, 
    0.12026036f, 0.44154927f, 0.16963829f, 0.02473317f, 0.04444492f, 0.18584107f, 0.09698691f, 0.09323676f, 
    0.11070915f, -0.03595320f, -0.03769482f, 0.05278658f, -0.03923455f, -0.03242746f, -0.07877377f, 0.07135838f, 
    -0.01144312f, 0.16402210f, 0.21998996f, -0.03189509f, -0.13915400f, -0.13827100f, -0.09929580f, 0.00438109f, 
    0.13673002f, 0.26131099f, 0.09498735f, 0.11536686f, 0.37958211f, -0.02224730f, 0.09882744f, 0.29712075f, 
    0.04094899f, -0.04568115f, 0.09827909f, -0.07113769f, 0.10083850f, -0.06059911f, -0.00582806f, 0.02229204f, 
    -0.11683583f, 0.02922701f, 0.07556839f, 0.06069075f, 0.12342467f, 0.11563878f, 0.12056773f, -0.00301224f, 
    -0.15178886f, 0.10041229f, 0.01692862f, 0.21268946f, 0.06018393f, 0.11721638f, -0.01483224f, -0.06422906f, 
    0.06930766f, -0.01973237f, -0.01934324f, -0.07871322f, 0.06070597f, -0.02910527f, -0.00324308f, 0.07834519f, 
    -0.09477768f, -0.05871856f, -0.09484763f, -0.15896094f, 0.00453810f, 0.13085333f, 0.10479598f, 0.03860855f, 
    0.05022400f, -0.13365352f, 0.56089681f, 0.08703157f, 0.05755203f, -0.07905106f, -0.19160739f, -0.08089961f, 
    0.08887024f, -0.07924347f, -0.03115087f, -0.08063307f, 0.08202390f, -0.10585772f, -0.12358046f, -0.16127405f, 
    0.21534336f, 0.10241373f, 0.02584494f, -0.01052856f, -0.00564601f, 0.03059895f, -0.06877536f, -0.13061146f, 
    0.17851101f, 0.01996968f, -0.05415444f, 0.17563853f, -0.09558834f, -0.06385046f, 0.21730949f, 0.02969504f, 
    -0.02302012f, 0.03432221f, 0.04380936f, 0.03275014f, 0.15548711f, -0.12342343f, 0.38849106f, 0.17318708f, 
    0.17792401f, 0.09868070f, -0.13092056f, 0.03662151f, 0.12650286f, -0.11402417f, 0.08090681f, -0.13506761f, 
    0.12883669f, -0.21681961f, -0.10351994f, 0.17000544f, 0.12036432f, 0.00638527f, 0.01134042f, -0.10103893f, 
    0.08653428f, -0.05456541f, -0.05149384f, -0.00633574f, 0.03925443f, -0.17974202f, 0.25502434f, 0.08803436f, 
    0.01947473f, -0.01861766f, -0.08704557f, -0.14912289f, 0.07713520f, 0.11437371f, -0.18683030f, 0.07869278f, 
    0.03163221f, 0.46236092f, 0.03281796f, -0.13975793f, -0.10624237f, -0.08561026f, -0.05070234f, 0.28932920f, 
    0.05226266f, 0.03170494f, 0.05776972f, -0.01782732f, 0.01814471f, 0.27118102f, -0.02379636f, 0.00412858f, 
    -0.02088542f, -0.10508109f, 0.08111774f, -0.03097415f, -0.03248995f, 0.02258658f, 0.16001765f, 0.07139912f, 
    0.00870750f, -0.06034242f, -0.03246927f, 0.05640296f, 0.00490272f, -0.07913851f, -0.05994731f, -0.02251082f, 
    0.03853336f, -0.06223429f, 0.03333716f, -0.16816178f, 0.03780041f, 0.03618838f, -0.00352323f, 0.02634337f, 
    -0.04641493f, 0.04355586f, -0.06875042f, -0.04525343f, -0.09232922f, -0.00725699f, -0.09572023f, 0.02967704f, 
    -0.12950379f, 0.02982986f, 0.19626060f, 0.16689764f, 0.13619353f, 0.07320280f, -0.03711779f, 0.17809562f, 
    -0.14595282f, -0.03931242f, -0.24392082f, 0.01419034f, 0.02575051f, -0.32143086f, -0.26215616f, 0.13692027f, 
    -0.05004171f, 0.20082611f, 0.20641693f, 0.03062214f, -0.07019977f, -0.18738854f, 0.08789898f, 0.05704461f, 
    -0.21870968f, 0.16702536f, -0.04722999f, 0.13754304f, -0.01487921f, -0.13410486f, -0.05047726f, 0.16506930f, 
    -0.01713406f, -0.11135065f, -0.00374290f, 0.21010682f, 0.19554631f, 0.23253427f, 0.09194360f, 0.21471825f, 
    0.19187731f, 0.04965067f, -0.00065288f, -0.10638802f, -0.10459026f, 0.08304279f, -0.10762140f, 0.02265254f, 
    0.00719824f, 0.09032894f, -0.06613687f, 0.06798714f, 0.14918862f, -0.00023239f, 0.02883998f, 0.04688274f, 
    -0.01298581f, 0.06934845f, -0.00751365f, 0.09675722f, -0.19413067f, -0.00766395f, -0.13899490f, -0.11673439f, 
    -0.04891519f, 0.07466449f, -0.12059948f, -0.17874192f, -0.02950316f, 0.04172578f, -0.00083119f, -0.08540995f, 
    0.09349455f, 0.12051520f, 0.03520454f, 0.09993424f, 0.15877208f, 0.16319530f, 0.06235394f, 0.02281969f, 
    0.02371500f, 0.01056817f, -0.01883673f, -0.04296095f, -0.13303460f, -0.21368030f, -0.13389832f, 0.08735364f, 
    0.08614311f, 0.01011458f, 0.01788174f, -0.05401194f, 0.05432820f, -0.06473468f, -0.15342434f, 0.07812692f, 
    0.09189884f, 0.10215832f, 0.18110350f, -0.08438519f, -0.09183234f, -0.05691689f, 0.17774175f, 0.03951157f, 
    0.00600791f, -0.00866880f, 0.05804157f, 0.13154057f, -0.03161544f, 0.04100623f, -0.12555452f, -0.00819239f, 
    0.12800275f, -0.07636491f, -0.09123179f, 0.28522938f, 0.08459248f, -0.04878355f, 0.15779349f, -0.10979366f, 
    0.04432733f, -0.08657451f, 0.29219624f, 0.30155641f, 0.13411103f, 0.19790679f, 0.04664733f, 0.16169488f, 
    0.08250919f, -0.01393019f, 0.04197181f, -0.03412851f, 0.26128495f, 0.24743667f, 0.08635581f, 0.11932743f, 
    0.14077108f, -0.00190952f, 0.06451894f, 0.21561140f, 0.09255345f, 0.02595749f, -0.09378348f, -0.04719871f, 
    0.18682739f, 0.17318119f, 0.29574344f, 0.21590964f, 0.14556064f, 0.02437833f, -0.02105180f, -0.13062987f, 
    0.01427233f, 0.05554949f, 0.13968647f, 0.09240230f, 0.04991553f, 0.07846806f, 0.06845704f, -0.08869959f, 
    0.04365918f, -0.02641321f, -0.05112657f, -0.13531807f, 0.08444890f, -0.02792240f, -0.01466577f, 0.04232370f, 
    -0.04578579f, -0.04097466f, 0.19155362f, -0.00121625f, 0.08647908f, 0.07089045f, -0.02006652f, -0.03973160f, 
    0.01502719f, -0.03566858f, 0.02544631f, -0.09970512f, -0.06431015f, -0.04756842f, -0.02814316f, -0.03450220f, 
    -0.03968146f, 0.12081864f, -0.21669242f, -0.09798426f, 0.02603090f, 0.18006143f, -0.14667900f, 0.01866846f, 
    -0.38073486f, -0.19270599f, 0.40188006f, 0.35640824f, -0.02492536f, -0.16206555f, -0.05557341f, -0.06168377f, 
    -0.09412790f, 0.02659572f, 0.08941348f, 0.20639288f, -0.06244748f, 0.37024397f, 0.19296509f, -0.11554936f, 
    -0.08362063f, -0.07369555f, -0.09400000f, -0.22794788f, -0.05209206f, 0.01447945f, -0.07672487f, -0.10602265f, 
    0.24237746f, -0.20249088f, 0.21599644f, 0.52185166f, -0.06661332f, -0.00586631f, -0.19371703f, -0.02605647f, 
    0.14523056f, -0.11063960f, -0.14385721f, 0.00903646f, -0.06440768f, 0.13680771f, 0.11492143f, -0.05304800f, 
    0.13791640f, -0.00941559f, 0.00886699f, 0.00461880f, 0.09968645f, 0.06486801f, 0.08656381f, -0.04060894f, 
    -0.16967280f, -0.14368132f, -0.01888200f, 0.12895916f, -0.12250106f, -0.03959993f, -0.14377376f, 0.07022665f, 
    0.13615407f, 0.14616100f, 0.15298676f, 0.15240614f, -0.17661588f, -0.16602060f, -0.11231463f, -0.30056447f, 
    -0.09907001f, -0.05064519f, 0.08823314f, 0.07816143f, 0.09930916f, -0.01319833f, 0.08250794f, 0.08344135f, 
    -0.00499731f, -0.08946682f, -0.28372461f, -0.16428362f, -0.03986807f, 0.05335715f, -0.19355415f, -0.12389974f, 
    -0.18184665f, -0.10300678f, -0.05979284f, -0.14776020f, -0.24842039f, -0.16336626f, -0.07284277f, -0.03971385f, 
    -0.03856032f, 0.01404500f, 0.07390933f, -0.00108264f, 0.12896715f, 0.00803208f, -0.34488404f, -0.16906013f, 
    -0.33712259f, -0.22486390f, 0.13684818f, 0.17278592f, -0.02004211f, 0.19991204f, -0.03904469f, -0.16244692f, 
    0.09068851f, -0.12150008f, 0.16140822f, -0.11191939f, 0.11474790f, -0.01023231f, -0.19699746f, 0.04287314f, 
    -0.10481453f, 0.12039520f, -0.12228542f, -0.15404817f, -0.00975241f, 0.04755468f, -0.02467755f, 0.06125671f, 
    -0.16478270f, -0.03467153f, 0.48617920f, 0.49177006f, -0.10028084f, -0.01655962f, 0.10494345f, 0.36369777f, 
    -0.02411040f, 0.03630010f, -0.05153272f, 0.04220989f, 0.30041555f, 0.18334436f, -0.36213207f, -0.22763346f, 
    -0.03788407f, 0.10181921f, -0.12459359f, 0.04449069f, 0.07135850f, 0.17369565f, 0.20629925f, -0.01157034f, 
    -0.18548848f, -0.27102485f, 0.15629621f, -0.00002346f, 0.12005503f, 0.20784293f, 0.03678247f, 0.00342538f, 
    0.20007542f, 0.14132038f, 0.05706872f, 0.04351120f, -0.25411400f, -0.08391791f, 0.22415711f, -0.03029995f, 
    0.21464206f, 0.04967206f, 0.12338853f, -0.07663013f, 0.12644984f, 0.15930592f, 0.07101273f, 0.03020560f, 
    -0.04398736f, 0.18018387f, 0.02025768f, -0.19072707f, 0.09130691f, -0.19717288f, -0.02739392f, -0.13664943f, 
    -0.06081538f, -0.09398028f, -0.05962467f, -0.10294356f, -0.20160073f, -0.03006469f, 0.08791602f, 0.00109459f, 
    0.10491449f, -0.00744031f, 0.01216690f, -0.01961029f, 0.05548687f, 0.10145533f, 0.06969566f, 0.17524981f, 
    0.07996968f, 0.18412717f, -0.05663497f, -0.28024098f, -0.15839602f, -0.09786813f, -0.08626872f, -0.22652641f, 
    0.19484457f, -0.11530796f, -0.14238402f, -0.02619795f, -0.07090457f, -0.12688853f, -0.00549167f, -0.10670992f, 
    0.10803738f, 0.04910719f, -0.05407548f, 0.10183915f, -0.04749723f, 0.11722743f, 0.15813510f, -0.00259815f, 
    -0.07775564f, -0.08008395f, -0.01392945f, 0.32323858f, 0.04595708f, -0.08578268f, -0.03998443f, -0.29149854f, 
    -0.00489028f, -0.02679798f, 0.05607366f, -0.02773945f, 0.41017538f, 0.01384191f, 0.07019503f, 0.14351846f, 
    -0.07401538f, -0.13959524f, 0.06408417f, 0.10239823f, 0.04791281f, -0.07973377f, 0.11648267f, 0.23786233f, 
    0.00990846f, 0.18803115f, -0.05351647f, 0.18174459f, 0.13140924f, 0.15531921f, 0.14359695f, -0.20339018f, 
    0.16785997f, 0.04314235f, 0.04932337f, -0.13464886f, -0.03815598f, 0.01396467f, -0.06742719f, -0.26859838f, 
    0.11715177f, 0.01646646f, -0.03418474f, -0.17599513f, 0.10256863f, -0.07109986f, 0.11572878f, 0.13128044f, 
    -0.13181537f, -0.07933359f, 0.03980802f, 0.01134526f, -0.08684692f, -0.12841064f, -0.05078395f, -0.14556067f, 
    0.02005285f, -0.00612088f, 0.01581217f, -0.03403461f, 0.18057454f, 0.10496463f, -0.11818361f, -0.08963831f, 
    0.04633728f, -0.14271380f, 0.10573264f, 0.11673090f, -0.01526158f, 0.23941150f, 0.12558256f, 0.18033056f, 
    -0.51316464f, 0.49582997f, 0.56269145f, -0.30812067f, -0.05340646f, 0.18578802f, 0.13566332f, -0.18583931f, 
    0.14401886f, 0.10533437f, 0.15289792f, 0.06198405f, -0.18627821f, 0.03989029f, 0.21039756f, -0.10796186f, 
    0.09460502f, -0.06605390f, 0.00706628f, 0.05951764f, -0.02421519f, 0.03513204f, -0.03966765f, -0.04670896f, 
    -0.14103749f, -0.01136668f, 0.25232384f, 0.09420775f, 0.07085976f, -0.00559375f, -0.00044327f, 0.01649666f, 
    0.02710053f, -0.00971658f, -0.28428200f, 0.09204957f, 0.04684747f, -0.17063197f, -0.01147596f, 0.07353926f, 
    0.11142352f, -0.05146349f, -0.04571066f, -0.17387706f, -0.00743618f, -0.03868766f, -0.14166762f, -0.03037534f, 
    0.08126009f, -0.20265011f, -0.01205864f, 0.10647660f, -0.10061880f, -0.08570132f, 0.18406051f, 0.04751147f, 
    -0.07753175f, -0.08122156f, 0.11360823f, 0.11686043f, 0.25269526f, -0.06701618f, -0.40904886f, 0.04568648f, 
    -0.02515594f, 0.07797799f, 0.18517084f, 0.01111904f, 0.16421928f, 0.15377335f, 0.09064288f, 0.34224567f, 
    0.02115567f, -0.41258520f, -0.11863661f, -0.02026449f, -0.11939005f, 0.00431858f, -0.10296519f, 0.14042281f, 
    0.14323278f, -0.18133532f, -0.13410033f, 0.04455527f, -0.23876257f, 0.12766734f, 0.23463273f, -0.01944051f, 
    0.04331686f, 0.09866317f, 0.14268282f, 0.06334283f, 0.12496594f, -0.02892735f, 0.20110835f, 0.19594176f, 
    0.01483688f, -0.04939213f, 0.00376035f, 0.00280713f, 0.02113210f, 0.04486705f, -0.03854375f, 0.00313666f, 
    -0.02464323f, -0.05220908f, -0.04622547f, 0.02819353f, 0.00465883f, -0.04000494f, -0.03374374f, -0.05264737f, 
    0.00373013f, 0.02127068f, -0.00491209f, 0.00183274f, -0.03876657f, -0.05613925f, -0.00898620f, -0.05103659f, 
    -0.02486684f, 0.04674640f, -0.01535107f, -0.00413776f, 0.04825270f, -0.01380164f, -0.02657664f, -0.02334086f, 
    -0.05586448f, 0.03391333f, -0.02513784f, -0.04232031f, -0.04621513f, 0.00374434f, 0.03409538f, -0.04726194f, 
    0.02878201f, 0.03246288f, -0.03827095f, -0.04379467f, -0.03624025f, -0.04477863f, -0.02469231f, 0.02781631f, 
    -0.04731247f, 0.04391710f, -0.02832587f, -0.00637676f, -0.02003951f, -0.02529350f, -0.00374051f, -0.02181933f, 
    -0.01566884f, -0.05150076f, 0.00335527f, -0.04326903f, -0.00116744f, -0.05194187f, 0.03411145f, -0.01520377f, 
    0.02183938f, -0.04714988f, 0.00596374f, 0.03710299f, -0.04709257f, 0.04326914f, -0.01067190f, 0.02688530f, 
    0.03153062f, -0.05022942f, 0.03337799f, -0.02901983f, -0.01813219f, 0.01083591f, -0.02622087f, 0.04564409f, 
    0.01648978f, -0.01346637f, 0.02858204f, -0.00465306f, 0.01800800f, 0.04232429f, -0.05119768f, -0.03140372f, 
    -0.03122868f, 0.00050601f, -0.01979194f, -0.01984314f, -0.04006009f, 0.00809050f, -0.04558457f, -0.04997254f, 
    0.00317617f, -0.03666439f, -0.03843530f, -0.01604133f, 0.02657715f, -0.02039530f, -0.01618028f, 0.00730979f, 
    0.03062658f, -0.01615307f, 0.02243845f, 0.04004012f, -0.03528109f, -0.05094382f, 0.01379891f, 0.04472669f, 
    0.03600607f, 0.03684848f, 0.02074287f, -0.03681394f, 0.00152330f, -0.01804949f, -0.00993204f, 0.03923376f, 
    -0.02399606f, -0.02010589f, 0.00146020f, -0.04127994f, 0.03207888f, -0.02743423f, 0.04334034f, -0.04883978f, 
    0.00094183f, -0.04906298f, 0.02317761f, 0.00433782f, -0.02672182f, -0.04539453f, 0.01474246f, -0.00230313f, 
    0.02233616f, 0.02953698f, 0.00857095f, -0.03878589f, -0.04002522f, -0.01933346f, -0.01962421f, -0.00397672f, 
    0.01310843f, -0.05013590f, -0.03046841f, 0.04458499f, 0.04220942f, -0.03178123f, -0.03414696f, 0.04239481f, 
    0.00145857f, -0.03056045f, 0.02070761f, -0.04571120f, -0.01815029f, 0.03028517f, 0.00546350f, -0.02141902f, 
    0.01880594f, 0.00693883f, -0.03350959f, -0.02473463f, -0.03280691f, 0.03985200f, -0.01192637f, -0.01442644f, 
    0.02285307f, -0.05472158f, 0.00056249f, -0.02328017f, -0.03590660f, -0.03608012f, -0.02214262f, 0.02275531f, 
    -0.00411066f, 0.04324650f, 0.01297304f, -0.00113699f, 0.01033021f, -0.01838604f, -0.00790563f, -0.03472353f, 
    0.00671616f, -0.04885674f, -0.04688296f, -0.02716934f, -0.01982583f, 0.03182415f, 0.02470644f, 0.00082740f, 
    0.03402868f, -0.04758229f, -0.04338492f, 0.02692066f, 0.02652679f, -0.02373721f, -0.00093301f, 0.02692600f, 
    -0.00945245f, -0.02757107f, 0.02375806f, 0.02083852f, -0.01805762f, -0.02530218f, 0.01016617f, 0.01037540f, 
    0.04116907f, -0.01385771f, 0.02022094f, -0.03064306f, 0.01653784f, 0.04569358f, 0.03592544f, -0.04134138f, 
    -0.03788541f, 0.01612634f, 0.00596233f, -0.01241359f, -0.03511949f, 0.04263841f, 0.00388413f, -0.02169571f, 
    0.01086370f, -0.03484833f, -0.00286354f, -0.03925568f, -0.01903120f, -0.02655821f, 0.01842898f, -0.03354399f, 
    -0.00398045f, 0.00541265f, 0.03322473f, -0.02331716f, -0.02497251f, 0.00464654f, -0.03424522f, -0.02311178f, 
    -0.05242481f, -0.04337244f, -0.02915791f, 0.01957907f, 0.03935106f, 0.00906233f, -0.03860633f, -0.01210839f, 
    -0.02680791f, -0.02784911f, -0.01039672f, 0.03243254f, -0.02134155f, 0.03125688f, -0.00696240f, -0.00858950f, 
    -0.04641845f, 0.03692847f, -0.00870371f, -0.02126681f, 0.02532133f, -0.03439543f, -0.00992470f, -0.04212705f, 
    0.00929064f, -0.02439788f, 0.03671014f, 0.04580167f, -0.01682066f, -0.00983571f, -0.04477295f, -0.01288348f, 
    -0.02329885f, -0.01484673f, 0.01415773f, -0.00588048f, -0.04670105f, 0.00075663f, -0.03652179f, -0.04017498f, 
    -0.02611900f, -0.03960035f, -0.04374696f, -0.02485387f, 0.00653317f, 0.01889316f, 0.01976576f, -0.04554756f, 
    0.00077796f, -0.02057429f, 0.04565851f, 0.04418152f, 0.04215339f, 0.02849560f, -0.00513717f, 0.03459136f, 
    0.00982083f, 0.00288951f, 0.03468866f, -0.02389928f, -0.01700598f, 0.01354820f, -0.04740992f, -0.00497707f, 
    0.01646139f, -0.01904903f, 0.03843447f, -0.01041353f, 0.03424907f, 0.01646443f, 0.02665001f, -0.03178568f, 
    -0.01044835f, 0.01730969f, -0.02163885f, 0.02162745f, -0.04915010f, -0.04719842f, 0.00777761f, 0.00351961f, 
    0.01030773f, -0.03343203f, 0.02669563f, -0.04548922f, -0.05286063f, -0.04443013f, -0.02574500f, -0.03438125f, 
    -0.02885067f, 0.01354964f, -0.02864166f, -0.05507413f, -0.02287142f, -0.01003957f, -0.04695901f, -0.00131926f, 
    0.02107338f, 0.01081023f, 0.01962139f, -0.05277202f, -0.01232361f, -0.02247439f, -0.03562968f, -0.01653858f, 
    0.01832157f, -0.00868051f, 0.01731886f, -0.02164649f, 0.02595080f, 0.02576932f, -0.04570118f, -0.00369153f, 
    -0.02246706f, -0.02078462f, 0.01769355f, -0.01316060f, 0.03377588f, -0.02531318f, 0.01714322f, 0.00854308f, 
    -0.03323930f, 0.00951716f, -0.04483370f, 0.04509740f, 0.04562536f, -0.03310268f, -0.00366541f, 0.00498277f, 
    0.04134085f, -0.01877052f, -0.05505999f, -0.04927170f, -0.03076957f, -0.04540915f, 0.02208723f, 0.03404341f, 
    0.03955295f, -0.01680193f, -0.00634808f, -0.00496830f, -0.00206838f, -0.02630939f, 0.01702341f, 0.03799378f, 
    0.23472489f, 0.35891286f, 0.16048177f, 0.10214774f, -0.05176268f, 0.05750426f, -0.00932770f, 0.22261722f, 
    0.05907230f, -0.04484324f, -0.00893638f, -0.11175947f, 0.28276858f, 0.08218201f, 0.07950322f, 0.05271479f, 
    -0.00975373f, -0.01769716f, 0.01194213f, -0.00833742f, -0.07518540f, -0.04523818f, 0.00281040f, -0.05537711f, 
    0.20301865f, 0.17999783f, -0.09571347f, -0.11265244f, -0.00959880f, 0.07322586f, -0.08312103f, 0.18976036f, 
    0.07340896f, 0.01202984f, 0.03350429f, 0.01055439f, -0.05807862f, -0.08766550f, 0.01284135f, -0.05531600f, 
    -0.04244880f, -0.12074097f, 0.11552298f, -0.01869435f, 0.14751387f, 0.01475017f, 0.10453079f, 0.11543802f, 
    0.12051393f, 0.06373449f, -0.11560718f, 0.04353069f, 0.10819176f, 0.00034888f, -0.00582208f, -0.00349506f, 
    0.00583395f, 0.03077824f, -0.12098828f, -0.07875980f, -0.13884705f, -0.16004895f, -0.08285215f, -0.08043234f, 
    0.00499715f, 0.05634454f, 0.00552713f, -0.16991027f, -0.04150129f, 0.03884327f, 0.05213856f, -0.00300343f, 
    -0.33360177f, -0.03880043f, -0.09793498f, 0.08806715f, -0.07690523f, -0.00877898f, -0.02807108f, -0.14976718f, 
    0.00390278f, 0.01466877f, -0.06884030f, -0.11689172f, 0.08374281f, 0.06035480f, -0.16526374f, -0.06650770f, 
    0.10683674f, -0.06652164f, 0.02269359f, 0.01318544f, -0.04192588f, -0.13589808f, 0.15292440f, -0.02246201f, 
    0.06339304f, 0.01561889f, -0.15908918f, -0.04663044f, 0.00814599f, -0.10285774f, 0.15894885f, 0.14493626f, 
    0.03149800f, 0.13632248f, -0.05998144f, 0.02302772f, 0.06855096f, 0.03944391f, -0.20838755f, -0.13371000f, 
    0.01837534f, 0.18676412f, -0.04719726f, 0.06423941f, 0.08657529f, -0.08654616f, 0.07771483f, 0.00124297f, 
    0.34119806f, 0.04747916f, 0.26095554f, 0.18917434f, -0.00744946f, 0.03407874f, -0.05697951f, -0.06253298f, 
    0.00494571f, 0.04481536f, 0.01586755f, 0.12956613f, -0.49905857f, -0.04775497f, 0.10139235f, 0.08786462f, 
    -0.07225386f, -0.09930357f, 0.10154658f, -0.10223554f, 0.01618774f, 0.01890172f, -0.10385162f, 0.06670915f, 
    0.09391335f, 0.12709688f, -0.02698903f, -0.10624968f, 0.11725964f, -0.05149944f, 0.03298950f, 0.25461084f, 
    0.04272132f, 0.04372536f, 0.14383104f, -0.03187548f, 0.35664159f, -0.04782931f, 0.33859614f, -0.00903136f, 
    0.02518019f, 0.05769738f, -0.10452817f, 0.01880640f, -0.14495532f, 0.10125360f, 0.13286820f, 0.07459777f, 
    -0.11198124f, -0.12096016f, -0.22078243f, -0.05283597f, -0.06952737f, 0.11520708f, 0.11246257f, 0.04978381f, 
    -0.21571836f, -0.09805352f, -0.04990819f, -0.09930516f, 0.13689327f, -0.00392077f, 0.08347955f, 0.15642652f, 
    0.00837960f, -0.00032956f, -0.05570418f, -0.01165806f, -0.10172838f, -0.02119499f, 0.07234891f, 0.12866028f, 
    0.16010341f, -0.04440808f, 0.05101830f, 0.00608867f, -0.07016815f, 0.02361533f, -0.03530366f, 0.19126104f, 
    -0.12428491f, -0.12275482f, -0.17473838f, -0.02258382f, -0.28809878f, 0.00223600f, -0.21495251f, -0.07606281f, 
    -0.08564233f, -0.01504654f, 0.23609024f, 0.00503675f, 0.09807187f, -0.21535990f, 0.08276447f, -0.04381363f, 
    -0.14749824f, 0.05685531f, -0.23705611f, -0.08211856f, -0.05974536f, -0.03260026f, 0.01042563f, 0.32369897f, 
    -0.00707910f, -0.03206428f, -0.04523453f, 0.10667199f, 0.13375638f, 0.10635186f, 0.23469599f, 0.27816629f, 
    0.15079388f, 0.13343966f, -0.04249464f, -0.08847667f, -0.04465375f, 0.06367157f, 0.10624075f, 0.08991595f, 
    0.07748646f, 0.26892489f, -0.08144769f, -0.00960259f, 0.05747368f, -0.05531637f, 0.00574176f, 0.03997385f, 
    0.06381795f, -0.01279765f, 0.09870335f, 0.07712086f, -0.14293273f, 0.12759031f, -0.14068078f, -0.33338669f, 
    -0.06445407f, -0.05626371f, -0.01206633f, -0.11050382f, 0.02465504f, 0.05541893f, -0.01393177f, -0.01611426f, 
    0.08697688f, 0.20026606f, -0.00746547f, -0.01931746f, 0.14088443f, 0.09161647f, 0.06852300f, 0.18411714f, 
    -0.05650577f, 0.03531682f, -0.10533885f, -0.05840030f, 0.18907410f, 0.28591448f, 0.09697990f, 0.28854752f, 
    -0.11141562f, -0.03711548f, -0.07082789f, -0.06176386f, -0.01178173f, -0.01104826f, -0.09361164f, -0.10223456f, 
    0.25537694f, 0.14281835f, 0.27815628f, 0.07841367f, -0.07053626f, -0.20309965f, -0.04966515f, -0.02452775f, 
    0.09683993f, 0.05179441f, 0.03675326f, 0.14344697f, -0.03525067f, -0.00149235f, -0.01174478f, -0.21507257f, 
    0.02150048f, 0.02003549f, 0.09684357f, 0.19588910f, 0.09380549f, 0.08396479f, 0.02200317f, -0.16241837f, 
    0.20528938f, -0.04794999f, 0.00986050f, 0.00227520f, -0.06620815f, 0.07096951f, 0.05502175f, 0.21078268f, 
    0.03106212f, 0.05111283f, 0.08111389f, 0.06627849f, 0.02216635f, 0.14691460f, -0.00637065f, 0.03519635f, 
    0.13424337f, 0.01390196f, 0.00956710f, 0.21170400f, -0.01228118f, 0.01078474f, -0.07927760f, -0.01016196f, 
    -0.01437361f, 0.16150686f, 0.11073800f, 0.22625165f, 0.08900749f, 0.23072191f, -0.03761338f, -0.08363916f, 
    0.11728872f, 0.13565004f, 0.09326994f, 0.08091044f, 0.24954356f, -0.02292191f, 0.07772762f, 0.06763420f, 
    -0.07559980f, -0.00415102f, -0.09709206f, -0.07781688f, 0.24699016f, -0.04092800f, -0.06490408f, 0.06288804f, 
    -0.35912916f, -0.16947535f, 0.04922218f, -0.01863380f, 0.04667100f, 0.19812579f, 0.03904935f, -0.19456425f, 
    -0.08738479f, -0.04174972f, -0.11484026f, -0.13976069f, 0.20178847f, 0.08859444f, 0.30161628f, -0.28338933f, 
    -0.17715915f, -0.04499792f, -0.13084777f, -0.11725714f, 0.08977232f, 0.17067178f, -0.07232624f, -0.03489694f, 
    -0.02299771f, -0.04925229f, 0.04458151f, 0.00860708f, -0.04873812f, -0.03882115f, 0.02500552f, -0.03177515f, 
    0.01775204f, -0.01083653f, 0.02174165f, 0.02097197f, -0.03554301f, 0.00657498f, 0.00820256f, 0.02207291f, 
    0.02310801f, 0.01610853f, 0.02767123f, -0.05079559f, -0.01208515f, 0.00820722f, -0.00565872f, -0.02534521f, 
    -0.03242582f, 0.04531336f, 0.04343031f, -0.02269056f, 0.01515304f, -0.04405405f, -0.00859050f, 0.03100795f, 
    0.03137959f, -0.00651596f, -0.04962277f, 0.01062661f, 0.02756896f, 0.01159298f, -0.02556561f, 0.02054167f, 
    0.03526057f, 0.03825459f, 0.03468885f, -0.01290340f, -0.02752851f, -0.01251322f, -0.03601250f, -0.02524721f, 
    0.03704085f, -0.00046394f, -0.03389129f, -0.00986091f, -0.01145447f, -0.03827543f, -0.00515743f, -0.04203166f, 
    0.02723896f, -0.00584705f, -0.01779305f, -0.00916064f, -0.04503336f, 0.04402693f, -0.03662383f, -0.03690706f, 
    -0.02388283f, -0.02830477f, -0.00452133f, 0.00127859f, -0.00162868f, 0.03569709f, -0.03616799f, 0.01291764f, 
    0.03703743f, -0.05179087f, -0.02892816f, -0.00236455f, 0.02147802f, 0.03387228f, 0.03115738f, 0.03308308f, 
    -0.04089934f, -0.03192203f, -0.04216004f, 0.02732285f, 0.00995030f, -0.02466544f, 0.04132907f, 0.01473616f, 
    -0.03402460f, 0.00809557f, -0.03220917f, -0.02047554f, 0.04513640f, 0.00978016f, -0.02019968f, -0.03777309f, 
    -0.04820010f, 0.04553443f, 0.03941097f, 0.02914253f, 0.04878476f, 0.01865731f, 0.01434764f, -0.00148341f, 
    -0.03210411f, 0.04608927f, -0.02433179f, -0.02556754f, 0.01116629f, -0.01663768f, -0.04401441f, -0.03246688f, 
    0.01657357f, 0.01297619f, 0.00075991f, -0.01730542f, -0.01819036f, -0.05320472f, 0.02459096f, -0.01967296f, 
    0.05108722f, 0.01283862f, -0.03960677f, 0.01907203f, 0.02730549f, 0.01515780f, -0.01644414f, 0.00410222f, 
    -0.01656526f, -0.03763608f, -0.05577067f, 0.03542566f, -0.00509247f, -0.01454938f, -0.01012424f, 0.03339876f, 
    -0.04215754f, 0.02107236f, -0.02097555f, 0.00219612f, 0.04492516f, 0.01592201f, 0.02118239f, 0.01234659f, 
    0.00558130f, -0.02249828f, -0.01424540f, -0.03349611f, -0.02671589f, 0.00305812f, 0.01348070f, -0.00851407f, 
    -0.04519435f, -0.02429799f, -0.04780609f, 0.04576159f, 0.04066065f, 0.01056989f, -0.04753516f, 0.01554884f, 
    -0.03467528f, 0.03189273f, 0.01339360f, 0.01847870f, -0.03682349f, -0.03276848f, -0.01358109f, -0.02297662f, 
    0.00344891f, 0.00354264f, 0.02544741f, -0.05019546f, -0.04461615f, -0.02217980f, -0.03325828f, -0.02144546f, 
    0.00485599f, 0.04252377f, 0.02227407f, -0.03786251f, 0.00082741f, -0.04339623f, -0.02701000f, 0.03789498f, 
    -0.00225114f, -0.05168587f, -0.04334502f, 0.00096337f, -0.00857633f, -0.02228598f, 0.03987084f, 0.01340126f, 
    0.02795357f, 0.02960848f, 0.00727846f, -0.01880944f, -0.04645324f, -0.04173227f, 0.01109498f, -0.02466731f, 
    0.01994062f, -0.00299316f, -0.05269879f, 0.02796366f, 0.01369058f, 0.00685210f, 0.03893794f, -0.03625448f, 
    -0.00783590f, 0.03018975f, 0.03818697f, -0.00132581f, 0.04300948f, 0.03551165f, 0.01753368f, -0.02019559f, 
    -0.02648781f, -0.03605098f, 0.05236589f, -0.02429785f, -0.04577658f, 0.02263841f, 0.04119276f, -0.05368771f, 
    0.00530344f, -0.03256233f, -0.04038920f, -0.02126743f, -0.03877272f, -0.01516998f, 0.03964826f, -0.03252052f, 
    -0.04384182f, 0.02035438f, 0.00781481f, -0.00750873f, -0.00388661f, 0.01245480f, 0.00009116f, -0.02372801f, 
    -0.04414379f, -0.03492939f, 0.03453622f, 0.03812321f, -0.00926704f, -0.00516490f, -0.02624429f, -0.02675293f, 
    -0.01871978f, -0.03916705f, 0.03154091f, 0.01207062f, 0.03390776f, -0.04716181f, -0.04024941f, -0.03043750f, 
    -0.00358384f, 0.00331612f, -0.00507196f, -0.04936163f, 0.00138833f, -0.02653494f, -0.01666618f, -0.04397491f, 
    0.03581236f, 0.03498714f, 0.03135603f, -0.03629096f, -0.02890924f, 0.00269800f, 0.04290007f, -0.02938021f, 
    -0.02553340f, -0.02622324f, -0.05919588f, 0.02217625f, -0.00534292f, 0.00284635f, -0.03951591f, 0.03752121f, 
    -0.03248733f, -0.04930889f, -0.05418003f, -0.05260120f, 0.01029661f, -0.05328578f, -0.00084887f, -0.04219219f, 
    0.04463419f, -0.01214721f, 0.02444251f, 0.02457812f, -0.02407504f, -0.04025169f, -0.01819628f, 0.01157236f, 
    0.00601513f, -0.00282211f, -0.02364003f, -0.03183945f, -0.00618775f, 0.00831254f, 0.02800110f, -0.05057700f, 
    -0.00234061f, -0.05126766f, 0.03829652f, 0.04225366f, -0.00250778f, 0.01865154f, 0.03647262f, 0.00991814f, 
    0.01297433f, -0.01421667f, -0.02425294f, -0.05186597f, -0.03508165f, -0.02178951f, -0.05087586f, 0.00093535f, 
    0.01740017f, -0.03521433f, -0.04595117f, -0.02429437f, -0.00050898f, 0.03355033f, 0.00299599f, 0.00310376f, 
    0.01072600f, 0.02301005f, -0.01237654f, 0.04004345f, -0.01418109f, -0.03488005f, -0.03917809f, 0.01611728f, 
    0.03896130f, -0.00540005f, -0.03569778f, 0.02027684f, 0.02295669f, -0.05039253f, 0.03732530f, 0.00097962f, 
    0.02659710f, -0.03406754f, -0.03221839f, -0.02813113f, 0.01540779f, -0.03252030f, -0.01038677f, 0.00994919f, 
    0.02240168f, -0.02314284f, 0.04042319f, -0.01284479f, 0.02966768f, -0.05289430f, -0.03887462f, -0.04725575f, 
    0.01921207f, -0.02193517f, -0.00337606f, -0.02556843f, -0.03559209f, -0.00342552f, -0.05401606f, -0.04426400f, 
    0.00049197f, -0.02916963f, 0.02791925f, 0.04305544f, 0.00864644f, 0.02871112f, 0.00402810f, 0.01119656f, 
    0.01027708f, 0.01799567f, -0.05426739f, 0.01806500f, -0.02506877f, 0.00507333f, -0.01117566f, -0.00315032f, 
    0.02275827f, -0.02685687f, -0.00820375f, 0.00094462f, 0.01726629f, -0.01039550f, 0.02496579f, -0.04994739f, 
    -0.02159390f, 0.03385229f, 0.03774819f, -0.02273919f, -0.02293068f, -0.05489074f, 0.00033474f, 0.02229095f, 
    0.02494613f, -0.03223393f, -0.05078878f, 0.00433880f, -0.04785869f, -0.01629167f, -0.02764366f, -0.05883376f, 
    0.00910146f, -0.05643813f, -0.00798571f, 0.04514983f, -0.03668333f, -0.04312668f, 0.02723006f, -0.00833704f, 
    -0.01964304f, 0.01320785f, -0.05082139f, -0.01716928f, -0.00149139f, -0.00119254f, 0.01909991f, -0.03611028f, 
    0.03973579f, -0.01218800f, 0.02734248f, -0.00248463f, -0.01297639f, 0.00676778f, -0.00771745f, -0.02560689f, 
    0.03857347f, 0.03288357f, -0.05016599f, 0.01662015f, 0.01779479f, -0.02894395f, -0.02989790f, 0.02182922f, 
    -0.00826868f, 0.01600550f, 0.02384593f, -0.00095541f, -0.01609415f, -0.02699352f, 0.01949800f, -0.00114069f, 
    0.03773290f, -0.04586637f, 0.02033057f, -0.06129114f, -0.01046487f, -0.03346000f, 0.01557541f, -0.04061414f, 
    -0.05484490f, 0.01914557f, -0.03174578f, -0.02786945f, -0.05291462f, -0.03512940f, -0.01535321f, 0.01812890f, 
    -0.01125437f, 0.03298584f, -0.01242175f, -0.01229190f, -0.04409541f, 0.00197703f, 0.00701527f, 0.01374404f, 
    -0.01154892f, -0.02549473f, 0.02932960f, 0.02442468f, -0.02583970f, -0.01480529f, -0.02364970f, -0.04763354f, 
    0.00308478f, -0.04136880f, 0.01752575f, 0.01172633f, -0.01607217f, 0.00548278f, 0.00411896f, -0.00430955f, 
    -0.04298693f, 0.02367928f, 0.00074576f, -0.03924476f, -0.05136371f, -0.04105191f, -0.04282312f, -0.00103465f, 
    -0.01143380f, -0.04990237f, 0.02690610f, 0.01770299f, 0.01870553f, -0.02181371f, -0.03734484f, -0.00214986f, 
    -0.05767379f, -0.04891780f, 0.01336284f, -0.02538808f, 0.03213526f, 0.02889767f, -0.00411539f, -0.02794939f, 
    -0.04805560f, 0.03232905f, -0.04897367f, 0.02809071f, 0.02508811f, -0.02072390f, 0.03939713f, 0.02664053f, 
    0.01370576f, -0.03849335f, 0.01008174f, 0.01378412f, -0.03542118f, -0.02742407f, -0.03341836f, 0.02702346f, 
    -0.00244986f, 0.00799588f, 0.02778864f, 0.00260522f, -0.05243599f, 0.01240738f, 0.01116252f, 0.01384102f, 
    -0.01311664f, -0.03620918f, -0.00072098f, -0.02425084f, 0.03085798f, 0.01298564f, -0.00706280f, -0.03891278f, 
    0.03404256f, -0.03609821f, -0.00831084f, 0.00501576f, -0.01776557f, -0.01994331f, 0.00544658f, -0.04222286f, 
    -0.04811037f, 0.04116472f, -0.04855650f, -0.01265144f, -0.04131885f, 0.02110587f, 0.02309213f, 0.03550211f, 
    0.01909808f, -0.05267509f, -0.00111284f, -0.04028074f, 0.03793353f, 0.04407767f, -0.02439892f, 0.03812215f, 
    -0.01298597f, -0.05172142f, -0.04594025f, 0.02149288f, -0.05325840f, 0.01284072f, -0.03716976f, -0.01279398f, 
    0.03618672f, 0.01443353f, 0.00314000f, -0.02329880f, 0.01365336f, -0.05547321f, 0.03807636f, -0.04644855f, 
    -0.05405625f, -0.02919614f, 0.01046806f, 0.00798758f, -0.05358835f, 0.01485231f, -0.00916320f, -0.02564282f, 
    0.00529066f, 0.03226669f, -0.02644136f, 0.03440660f, 0.03826162f, -0.04751120f, 0.00473667f, -0.04032757f, 
    0.01059122f, -0.02537826f, -0.05617872f, -0.05228187f, -0.01264658f, -0.03711378f, 0.02038962f, 0.02487032f, 
    0.00374414f, 0.02619732f, -0.00692085f, 0.01121682f, -0.04994137f, -0.01242789f, -0.04265023f, 0.03116630f, 
    -0.01933381f, 0.02668623f, 0.03374809f, -0.02079646f, -0.04324805f, -0.04443758f, 0.00278904f, -0.03754351f, 
    0.02724451f, -0.04214115f, -0.02688864f, 0.02590471f, -0.03222553f, 0.01015428f, 0.03671810f, -0.01406202f, 
    -0.04860015f, 0.01993417f, -0.03356166f, -0.02079866f, -0.01359674f, 0.02183539f, -0.05669710f, -0.01050546f, 
    -0.00922127f, -0.01843494f, -0.04646714f, -0.04509095f, -0.06273722f, 0.03325753f, 0.01209824f, -0.04957891f, 
    -0.04714125f, 0.04769289f, 0.00720281f, 0.01519266f, -0.02300332f, -0.04257460f, -0.04143221f, -0.04597260f, 
    0.03167387f, 0.03265893f, -0.03340396f, -0.04854117f, 0.01888830f, 0.02429558f, -0.04916932f, -0.04489474f, 
    0.00769362f, -0.01390354f, 0.03818000f, 0.03243784f, 0.03384813f, -0.02837257f, -0.00374842f, -0.05169535f, 
    0.01966264f, -0.04093995f, 0.02000418f, -0.04992526f, 0.02595844f, -0.05363178f, -0.05199277f, 0.02638833f, 
    -0.05101524f, -0.03866986f, -0.00642330f, 0.04126166f, 0.03579383f, -0.03267320f, -0.03679927f, 0.02624335f, 
    0.01834403f, -0.03986875f, 0.03766575f, -0.02130779f, -0.04674764f, 0.01528563f, -0.04312588f, 0.00946752f, 
    -0.06194533f, -0.05821124f, 0.02736042f, -0.01087818f, -0.03110018f, -0.03198816f, 0.03494546f, -0.00029665f, 
    0.02097381f, 0.03184818f, -0.01674381f, 0.00666261f, -0.05252340f, -0.01672096f, -0.03281202f, -0.02183975f, 
    0.01471256f, -0.03056091f, -0.02014337f, 0.03303885f, 0.00540432f, 0.02311446f, -0.04643990f, 0.02140253f, 
    0.02477200f, -0.00298097f, 0.00884341f, 0.00055697f, 0.02595963f, 0.01789093f, -0.00105501f, 0.02585682f, 
    0.04456725f, 0.00855515f, -0.03624242f, -0.04941985f, 0.04634948f, 0.02869661f, -0.00013471f, -0.00573944f, 
    -0.00426452f, -0.01838809f, 0.02221215f, -0.02166405f, 0.01811288f, -0.01319013f, -0.03129546f, -0.01727859f, 
    -0.00902371f, -0.05474129f, 0.00108581f, -0.04701878f, -0.02108959f, 0.01766302f, 0.02001297f, -0.04647496f, 
    -0.01185882f, -0.03116426f, -0.03294647f, 0.00529312f, 0.01190934f, 0.00942399f, 0.02643736f, 0.03258817f, 
    0.01228817f, 0.02482678f, -0.05201570f, -0.04791925f, 0.03683912f, -0.01242292f, -0.04374341f, 0.03188685f, 
    -0.06868368f, 0.19719391f, 0.01905492f, -0.13293970f, 0.02217052f, 0.05003404f, 0.07545489f, 0.03042958f, 
    0.05972822f, -0.04214812f, 0.01317298f, 0.05243006f, 0.16523392f, 0.15910821f, -0.14121735f, -0.16150557f, 
    0.05351991f, 0.15008654f, 0.13930614f, -0.09630767f, -0.13280217f, -0.15526763f, -0.05551181f, -0.03824992f, 
    0.00669860f, -0.06327513f, 0.11898956f, -0.03700935f, 0.09125118f, -0.03670089f, -0.06201950f, 0.17722611f, 
    0.19458771f, -0.07288642f, 0.08539486f, -0.02605433f, -0.13104452f, 0.07664749f, -0.12957112f, -0.23166381f, 
    -0.05227076f, 0.23139833f, 0.05459584f, 0.05969360f, -0.04640855f, 0.15229584f, 0.07598218f, 0.00405795f, 
    0.27381217f, 0.07519604f, 0.32274577f, -0.01915308f, 0.04795255f, 0.00443486f, 0.04595582f, 0.06234061f, 
    0.00528023f, -0.12494110f, 0.07279857f, 0.03046888f, -0.04496643f, -0.28794494f, -0.07954531f, 0.11999075f, 
    0.06006772f, 0.06482027f, -0.03758778f, -0.00737502f, -0.02929094f, -0.12782711f, -0.00694761f, -0.04764951f, 
    -0.26766112f, -0.20797552f, -0.14388147f, 0.38514379f, 0.11839579f, -0.01563616f, -0.07187429f, -0.04114703f, 
    -0.04386214f, 0.06837945f, -0.11070921f, 0.00250641f, 0.07260201f, -0.06516816f, -0.16888519f, -0.09480447f, 
    -0.01819791f, 0.23407325f, -0.00511484f, -0.01085162f, 0.14876412f, -0.14210066f, -0.06995863f, -0.02771981f, 
    0.16822016f, 0.36499962f, 0.18347435f, -0.02776168f, 0.05311799f, 0.03765737f, -0.01401096f, -0.06449148f, 
    -0.07425019f, 0.03436161f, -0.00319124f, -0.06453567f, -0.09910846f, 0.05293181f, 0.06383733f, 0.16826843f, 
    0.18377131f, -0.02112105f, -0.04411291f, 0.18407609f, -0.00363496f, 0.00974365f, -0.08714402f, 0.08608381f, 
    -0.04275132f, 0.21415800f, 0.17400475f, 0.09506796f, 0.04942703f, 0.05170818f, 0.03506596f, 0.21552630f, 
    -0.02835842f, -0.12727551f, -0.10796218f, 0.04553144f, 0.11839565f, -0.09983632f, -0.09560737f, 0.26710615f, 
    -0.00061293f, 0.02367785f, 0.01269033f, -0.08146952f, 0.13448237f, -0.08115943f, 0.09476893f, 0.08402211f, 
    0.14122087f, -0.07261886f, -0.13271697f, -0.10127639f, 0.14185275f, -0.16200757f, 0.04683768f, 0.29446763f, 
    0.04591990f, 0.08091529f, 0.01574477f, -0.05315242f, 0.00160944f, 0.16919072f, 0.09203217f, -0.01492356f, 
    -0.07524000f, -0.16601762f, 0.10709459f, -0.03460246f, -0.12304686f, -0.01626360f, 0.10333376f, 0.05422958f, 
    0.24908456f, -0.07066352f, -0.42391062f, 0.18942893f, 0.04687994f, 0.11634798f, 0.00741784f, 0.12465168f, 
    0.00506131f, 0.01287749f, -0.10703922f, -0.01319589f, 0.05806969f, 0.04175044f, 0.04870331f, 0.08106028f, 
    0.06612713f, -0.05392306f, 0.08353350f, 0.00862723f, -0.04110914f, -0.02741641f, 0.02064499f, 0.03678602f, 
    0.07719355f, -0.06011051f, -0.16783299f, -0.04087910f, 0.02255583f, 0.01381086f, 0.01278699f, -0.02221041f, 
    0.00606310f, -0.03559156f, -0.00857491f, 0.03607638f, 0.05798159f, -0.09599900f, -0.08828112f, 0.15259019f, 
    0.02081418f, 0.00235007f, 0.06290595f, -0.07164661f, 0.02953141f, 0.07963200f, -0.01157097f, -0.01735021f, 
    0.08310512f, 0.24908876f, 0.13245676f, -0.02735982f, 0.05900447f, -0.01084852f, -0.08096630f, -0.14464778f, 
    -0.05942539f, -0.04916453f, -0.01709809f, 0.03225008f, -0.63466859f, 0.19768016f, -0.07638063f, -0.02616123f, 
    -0.00652583f, -0.04002814f, 0.04937698f, 0.20913781f, 0.12807664f, 0.04558945f, 0.02256292f, 0.07488326f, 
    0.19447348f, 0.31564063f, 0.28631896f, 0.04836907f, 0.02550057f, -0.06492884f, -0.08413665f, 0.05041496f, 
    -0.02392951f, 0.01895183f, -0.05236402f, 0.08350170f, 0.02292270f, -0.30149448f, -0.34736615f, -0.05556156f, 
    -0.05976360f, -0.00773301f, 0.10002087f, -0.12256320f, 0.04573436f, -0.08673974f, 0.13082109f, -0.07570276f, 
    0.06982014f, 0.29502973f, 0.13777618f, 0.01484415f, 0.08618259f, 0.13619937f, 0.07246869f, -0.05369033f, 
    0.01298539f, -0.08665132f, -0.05840486f, 0.04756231f, -0.38921213f, -0.51436484f, 0.03019020f, 0.33442986f, 
    -0.01215583f, 0.00390130f, -0.04244728f, 0.01747730f, 0.05865138f, 0.07273353f, -0.01252069f, -0.04319154f, 
    0.49316826f, -0.23540831f, -0.31534845f, -0.06640739f, -0.06790907f, -0.00550378f, -0.01615664f, 0.09986860f, 
    0.01623126f, -0.14231192f, 0.00826155f, -0.02408190f, 0.11567956f, -0.20418152f, 0.07503683f, 0.02903919f, 
    0.08533096f, 0.19406620f, 0.13753860f, 0.12016153f, 0.03889265f, 0.01721078f, 0.00413481f, -0.02503604f, 
    0.24278288f, 0.28544930f, 0.17501849f, -0.05797961f, -0.03424832f, 0.09777580f, -0.07400674f, -0.02350536f, 
    -0.01842422f, -0.13344859f, 0.05013701f, -0.03301824f, 0.05938473f, 0.29765737f, 0.15970674f, 0.07851633f, 
    0.03627259f, 0.06300315f, 0.10729988f, 0.01841694f, 0.13771155f, -0.12765869f, -0.04475056f, -0.06685139f, 
    -0.02627909f, 0.34410977f, 0.11355553f, 0.03728475f, 0.03691204f, 0.13084070f, -0.01257434f, 0.11720335f, 
    -0.02190881f, -0.12724479f, 0.14534476f, 0.07396967f, -0.16245866f, -0.25418136f, -0.16809958f, 0.01322476f, 
    0.16230501f, -0.00953814f, 0.03399906f, -0.08789735f, 0.10870029f, -0.04296695f, 0.14903472f, 0.01812252f, 
    -0.03058806f, -0.02784547f, 0.10753929f, 0.08603933f, -0.00441659f, 0.12836286f, -0.01500295f, 0.06495384f, 
    0.04974606f, -0.01953032f, -0.06796200f, -0.12407132f, -0.28968796f, -0.14015211f, -0.21474355f, -0.16144708f, 
    -0.05798419f, 0.05896554f, -0.14881037f, 0.17363529f, 0.06762576f, -0.07686149f, -0.19283859f, -0.02920167f, 
    0.03158028f, 0.20711713f, 0.17576662f, 0.33687776f, 0.13460964f, 0.01535208f, 0.06034892f, -0.04853536f, 
    -0.12185281f, -0.00610578f, -0.11422604f, 0.05788253f, -0.11920313f, -0.23000437f, 0.24347378f, -0.03114132f, 
    -0.07691839f, -0.02824035f, 0.10380990f, 0.17000549f, 0.09499437f, -0.02898538f, 0.02769140f, 0.03014475f, 
    -0.56595427f, 0.06219338f, -0.45941448f, 0.33106789f, 0.33930328f, 0.07639126f, 0.15080656f, 0.10857366f, 
    -0.16519476f, -0.11123405f, 0.10585876f, -0.07494012f, 0.13636768f, 0.06166133f, 0.00012912f, 0.00347029f, 
    0.05438845f, 0.15131979f, -0.02893934f, 0.17696626f, -0.05943182f, 0.07410409f, -0.02089646f, -0.17615680f, 
    -0.16529977f, -0.14264253f, -0.02957976f, 0.20289738f, -0.01952648f, 0.10191409f, 0.08538640f, 0.02330096f, 
    0.08840900f, 0.03590131f, 0.10000261f, 0.10708844f, 0.15662739f, 0.04323338f, 0.16560873f, 0.06278528f, 
    -0.13407582f, -0.00254156f, -0.00629409f, -0.01399136f, 0.05350126f, 0.11017477f, 0.00397191f, -0.04047642f, 
    0.49528939f, -0.05841998f, 0.35033330f, -0.05729441f, 0.09635857f, -0.08970492f, -0.02589821f, -0.00598145f, 
    -0.05825793f, -0.05574971f, 0.00440936f, 0.13949895f, 0.00957799f, -0.02402200f, -0.00004635f, 0.01540683f, 
    0.10052299f, 0.15632282f, 0.00321919f, -0.05933661f, -0.07193184f, -0.00424230f, -0.00997636f, -0.07968211f, 
    -0.18262413f, 0.03037640f, 0.00916687f, 0.02295687f, 0.01299124f, -0.08322746f, 0.03838239f, -0.24980022f, 
    -0.03581177f, -0.07695732f, 0.06675918f, 0.16781910f, 0.30962691f, -0.11195683f, 0.31465483f, 0.05576766f, 
    0.17642498f, -0.01005296f, 0.14013548f, 0.10825849f, 0.02793612f, 0.03935249f, 0.03432007f, -0.10103039f, 
    -0.33983400f, 0.01604356f, -0.09493700f, 0.09443147f, -0.13986667f, -0.00341117f, 0.05522998f, 0.00797290f, 
    -0.04700869f, -0.00987345f, 0.04050914f, -0.14357266f, 0.38965973f, -0.07850156f, 0.21920535f, -0.11111052f, 
    -0.02798996f, -0.08382083f, -0.01527815f, -0.01351731f, -0.02100910f, 0.01690715f, 0.01580668f, 0.09824146f, 
    0.06384761f, -0.00044131f, 0.14382301f, 0.06346902f, -0.13544005f, -0.00399761f, -0.04818857f, -0.02852835f, 
    0.10840249f, -0.04160483f, -0.12322154f, -0.04408678f, -0.26277241f, 0.26559711f, -0.04997547f, 0.15848115f, 
    0.03777470f, -0.17562823f, -0.00512325f, -0.04964035f, 0.06886677f, 0.07682293f, 0.01842617f, 0.12484179f, 
    0.21207808f, 0.09827206f, 0.33941656f, 0.00901588f, -0.11217283f, -0.17932668f, -0.07909473f, -0.11295749f, 
    0.02085009f, 0.03935115f, -0.01003501f, -0.04655735f, -0.04247976f, 0.13978191f, 0.07448482f, -0.20326804f, 
    -0.02665556f, -0.05738792f, -0.00067683f, -0.01593731f, -0.01174345f, -0.02195353f, -0.01481303f, -0.17028534f, 
    -0.16233470f, 0.07325405f, -0.14008953f, -0.17314465f, 0.32990474f, 0.02502254f, -0.04627572f, -0.19234426f, 
    -0.21836218f, 0.06837423f, -0.02863274f, -0.00508564f, -0.03329715f, 0.04288893f, 0.11356115f, 0.02392394f, 
    -0.00151304f, 0.11579877f, 0.18134139f, 0.01278299f, -0.01215098f, 0.06504697f, 0.09225631f, -0.01253155f, 
    -0.10265873f, -0.15312204f, 0.23064135f, -0.24951033f, 0.18594252f, -0.04990632f, -0.12439057f, -0.17185605f, 
    -0.09661584f, 0.00964799f, 0.03581125f, 0.17430498f, -0.31376636f, -0.02815856f, 0.24333100f, -0.06438639f, 
    0.06544922f, -0.05610181f, -0.03357883f, 0.14920947f, 0.02036373f, 0.07493474f, -0.04228267f, -0.13852632f, 
    -0.18318337f, -0.36289209f, 0.12407415f, 0.11452743f, -0.03121133f, 0.03110209f, -0.01477567f, -0.06908122f, 
    -0.02583380f, -0.04894023f, -0.14068264f, -0.01015079f, 0.01522098f, 0.22248690f, 0.14451872f, 0.20031349f, 
    -0.07150079f, 0.05755200f, -0.00728856f, 0.05647865f, -0.01617191f, 0.18234368f, 0.07979792f, 0.22300585f, 
    -0.12140597f, -0.18825006f, 0.16723152f, 0.18807407f, -0.16470653f, -0.07176621f, 0.00004486f, -0.12807277f, 
    -0.01865432f, 0.06708875f, 0.04709566f, 0.08696055f, -0.22234677f, -0.30599201f, 0.16615961f, 0.06629761f, 
    -0.00267686f, -0.00340572f, 0.01749820f, 0.08019842f, 0.17342940f, -0.06900971f, 0.11214259f, 0.05831487f, 
    0.16628052f, 0.12975903f, -0.23539309f, 0.02212821f, -0.10109140f, -0.08017723f, 0.03920555f, -0.01590659f, 
    0.12046976f, -0.07097868f, 0.01300596f, 0.08550449f, -0.14709990f, 0.19819656f, -0.06605569f, 0.31454295f, 
    0.23488833f, 0.02159349f, 0.16001736f, 0.07733276f, 0.11033431f, 0.05937374f, 0.17227709f, 0.26142561f, 
    -0.19438387f, -0.09188180f, 0.20257203f, 0.19886653f, 0.24118790f, -0.02653668f, -0.02569056f, -0.00394391f, 
    0.00047859f, -0.10264385f, -0.09717603f, -0.09315435f, 0.00036962f, -0.03568551f, 0.13284503f, 0.07150074f, 
    -0.08087192f, -0.00631379f, 0.00393977f, 0.07102361f, -0.09728648f, -0.05777674f, -0.08213151f, -0.02136501f, 
    0.02084028f, -0.00739482f, 0.03774837f, 0.08207013f, -0.02597174f, -0.15302311f, -0.16163702f, -0.05770886f, 
    -0.15331428f, 0.03932001f, 0.01885374f, -0.08392833f, 0.30225587f, 0.16137788f, 0.08141034f, -0.15124978f, 
    -0.03580682f, -0.00917464f, 0.06998917f, 0.09537721f, 0.18841246f, 0.01866641f, 0.02564026f, 0.09245451f, 
    -0.06850831f, 0.16928986f, -0.07791383f, -0.00830747f, 0.16356525f, -0.02262172f, 0.06740781f, -0.05025173f, 
    -0.12172978f, 0.02233145f, -0.02446609f, 0.01754980f, 0.22678864f, 0.50329256f, -0.24403104f, 0.32738674f, 
    -0.08704589f, 0.21229146f, -0.01171263f, 0.24477245f, 0.14247745f, 0.10410304f, 0.01508576f, 0.12914157f, 
    -0.19244175f, -0.29473710f, -0.18738848f, -0.03769072f, 0.06145108f, -0.11728609f, -0.06876171f, -0.16808560f, 
    -0.06326531f, -0.02308487f, 0.15539755f, 0.21597138f, 0.05285357f, 0.27491602f, 0.02948806f, 0.26453117f, 
    -0.00307300f, 0.06402242f, -0.06137463f, -0.03145644f, -0.06735525f, 0.07303085f, 0.23676518f, -0.01243577f, 
    0.28706023f, 0.14397630f, 0.09342599f, 0.06032620f, -0.17319381f, 0.11746395f, 0.06765938f, -0.31976417f, 
    -0.12467600f, 0.05750493f, -0.12285631f, 0.09924205f, -0.00167145f, -0.00868208f, -0.00210167f, -0.14633691f, 
    -0.05128067f, 0.22935222f, 0.07428844f, -0.05250363f, -0.05782815f, 0.03801012f, -0.07200987f, 0.16034061f, 
    -0.18027468f, -0.02658176f, 0.23489691f, 0.03789325f, -0.09676314f, -0.04181848f, -0.07195774f, 0.04244349f, 
    -0.05326379f, 0.03244181f, 0.14179136f, 0.10612223f, 0.07017514f, 0.06265492f, -0.09646861f, -0.05863732f, 
    -0.03653936f, 0.01279437f, 0.09557452f, -0.03598696f, 0.07744561f, -0.02658382f, -0.00512704f, -0.04333780f, 
    -0.12151070f, 0.11971942f, 0.00496832f, 0.20753062f, -0.00715632f, 0.02139121f, -0.07460775f, 0.00437949f, 
    0.04095939f, 0.14302139f, -0.08341871f, 0.04231752f, -0.03881556f, 0.06368235f, 0.01358498f, -0.04819743f, 
    0.09707922f, 0.27881208f, 0.01458979f, 0.04802521f, 0.16647768f, 0.10106164f, -0.04882182f, 0.07420202f, 
    0.15588616f, 0.25247204f, 0.41336632f, 0.35124603f, 0.04183035f, 0.01840578f, -0.07560820f, 0.09638280f, 
    0.05040497f, 0.00154311f, 0.05769892f, -0.10220743f, -0.23777281f, 0.30612314f, 0.21405560f, 0.44661203f, 
    0.03970983f, -0.16671062f, 0.04409252f, 0.08375119f, -0.01465940f, 0.09224378f, -0.14362068f, 0.03936446f, 
    -0.14451118f, 0.09044064f, -0.03359346f, -0.03334901f, -0.12992336f, -0.15215892f, -0.10195931f, 0.11239439f, 
    0.03735509f, -0.04306867f, -0.13649346f, 0.03606930f, 0.26956695f, 0.24060188f, -0.21336462f, 0.01740387f, 
    0.00693509f, 0.11395545f, -0.17194745f, 0.05375263f, -0.00735594f, -0.09809238f, 0.20862195f, 0.01248574f, 
    0.10159880f, -0.06535781f, 0.12997885f, 0.26469338f, 0.03411423f, -0.03470664f, 0.11401081f, 0.03352313f, 
    -0.20503916f, 0.07482407f, -0.14473897f, -0.05318698f, -0.23844114f, 0.16768005f, -0.03319121f, 0.20096074f, 
    -0.02165679f, -0.02502035f, 0.01855869f, -0.10086583f, 0.20516187f, -0.06567667f, -0.10144147f, 0.09262032f, 
    -0.20460203f, 0.20719840f, 0.04412652f, 0.30485404f, 0.13145417f, 0.00305739f, -0.11921840f, 0.10616817f, 
    0.12093673f, 0.06089298f, -0.03320593f, 0.04226848f, -0.11374907f, 0.03384196f, 0.05600360f, 0.22122097f, 
    0.02931353f, 0.02042000f, 0.07929811f, -0.03110026f, 0.27348348f, 0.14009365f, -0.00551420f, 0.05368473f, 
    -0.08272851f, 0.04688768f, -0.07389931f, 0.13086559f, 0.11749031f, 0.09989027f, -0.04158564f, -0.16402121f, 
    -0.05905661f, 0.06540777f, 0.17644922f, -0.01201277f, 0.28117824f, -0.04392889f, 0.05201314f, 0.04966037f, 
    0.01743451f, -0.07888765f, -0.11219931f, 0.05608249f, -0.05796569f, 0.21902864f, -0.28578076f, -0.00417118f, 
    0.21038899f, 0.43614763f, 0.31190932f, 0.57052851f, 0.16105330f, -0.02040358f, -0.05528335f, -0.11525413f, 
    -0.02057699f, 0.05196349f, 0.18510792f, -0.07446157f, 0.36906528f, 0.09308609f, -0.33108360f, 0.07233274f, 
    -0.13035734f, -0.11016218f, 0.08220253f, 0.04804847f, 0.02168332f, -0.10936992f, -0.05433495f, 0.10895522f, 
    0.01010803f, -0.03670350f, 0.37640035f, 0.16900188f, 0.09264375f, 0.04499599f, 0.17663644f, 0.01609451f, 
    0.02615844f, 0.08884098f, 0.02562381f, -0.03252338f, 0.07718730f, -0.18955080f, 0.12975504f, 0.24796106f, 
    0.07306065f, 0.03211101f, 0.06556582f, 0.02269626f, 0.03945811f, -0.10710394f, 0.06446180f, -0.09442545f, 
    0.12576038f, -0.03777432f, 0.27117327f, 0.26112449f, -0.04956130f, -0.01570099f, -0.01776288f, 0.04339950f, 
    0.12799810f, 0.04061304f, 0.22244729f, 0.11393803f, 0.22356603f, 0.17843507f, -0.12349208f, -0.22105540f, 
    0.13248798f, -0.05728628f, -0.10858911f, -0.01621736f, 0.02780352f, 0.15043809f, 0.06063969f, 0.02351723f, 
    -0.41568929f, -0.24468555f, 0.06526660f, 0.09311307f, 0.09469406f, 0.22520223f, -0.07400327f, 0.01281393f, 
    -0.12694937f, -0.09217833f, -0.07906143f, -0.16435342f, 0.15394033f, -0.05327572f, -0.00130716f, 0.08156334f, 
    -0.01811679f, 0.10932061f, 0.04260788f, -0.12691945f, -0.13998225f, 0.09052923f, -0.14684325f, -0.01982008f, 
    0.07572418f, 0.30886614f, -0.05920019f, 0.00449079f, -0.10152867f, 0.02814800f, -0.10339206f, -0.03665365f, 
    -0.04562891f, -0.01243923f, 0.00582695f, 0.01804009f, 0.00575329f, -0.01236319f, 0.04491266f, -0.00533363f, 
    -0.08190701f, 0.03851000f, 0.13941137f, -0.07826409f, 0.09647181f, 0.03728726f, 0.08727434f, 0.00031578f, 
    0.15211827f, -0.10663429f, -0.00496568f, -0.12586255f, -0.05036642f, -0.27657744f, 0.09006300f, -0.00230187f, 
    -0.01625861f, -0.08528899f, 0.05902090f, 0.05890225f, -0.18367089f, 0.11662439f, -0.06071194f, 0.09186922f, 
    0.01775557f, 0.02285842f, 0.08632100f, -0.09836911f, -0.17641337f, 0.10050859f, 0.11295301f, 0.00436180f, 
    0.24657139f, 0.00137198f, -0.05314696f, -0.09412405f, 0.06833420f, -0.02159485f, -0.05130393f, 0.08624780f, 
    0.05147340f, -0.00238533f, -0.08272997f, -0.03092921f, -0.54034811f, -0.15440165f, 0.11550321f, 0.07768711f, 
    0.02123900f, -0.07155042f, 0.06246435f, 0.21034269f, -0.04141553f, -0.25812411f, 0.06112351f, 0.11019281f, 
    0.06326018f, -0.15854323f, -0.00197497f, 0.01576730f, 0.12467508f, 0.02212174f, 0.01852652f, 0.01887018f, 
    -0.09292776f, -0.08021861f, 0.03319450f, -0.08023932f, -0.11884547f, -0.10179031f, -0.09166417f, 0.15091985f, 
    -0.01600214f, -0.08907425f, 0.05051819f, 0.10523271f, -0.06180568f, 0.03465169f, -0.04477854f, -0.10520203f, 
    -0.05069213f, 0.25234789f, 0.10063534f, 0.16987181f, 0.10566679f, -0.00974376f, 0.06581152f, -0.04397199f, 
    -0.06782395f, -0.02586544f, 0.14913107f, 0.02019245f, 0.26651034f, 0.02732403f, 0.21900602f, 0.31250784f, 
    0.01420190f, -0.05167380f, 0.06786739f, -0.01661835f, 0.09384917f, 0.05855969f, 0.05550060f, -0.03336872f, 
    -0.24255554f, -0.00613068f, -0.21348999f, 0.04304827f, 0.11403508f, 0.10637335f, 0.05396601f, -0.04925925f, 
    0.00146534f, 0.13766092f, 0.06497002f, 0.15278572f, 0.24467759f, 0.13108847f, 0.10181799f, 0.07534605f, 
    -0.12936030f, -0.06133862f, 0.06437427f, 0.12289044f, 0.05433828f, 0.10707379f, 0.04589069f, 0.03799683f, 
    0.49150172f, 0.07598817f, 0.46992955f, -0.16940254f, -0.07989170f, -0.00274709f, -0.17046909f, 0.09973927f, 
    -0.06481250f, -0.18600217f, 0.02355585f, -0.18252878f, 0.11241815f, 0.07145697f, 0.07462931f, 0.03182196f, 
    0.12509039f, 0.03131747f, -0.08191986f, 0.05111207f, -0.10221528f, -0.07865338f, -0.15805002f, -0.30318952f, 
    0.06299236f, -0.27370155f, -0.05974844f, 0.15704317f, -0.07754926f, 0.04095833f, 0.01176612f, 0.05329795f, 
    0.00347334f, -0.03476974f, 0.04639469f, 0.06199555f, 0.08783583f, -0.10355267f, 0.26915669f, -0.08763696f, 
    -0.09580167f, 0.06913906f, -0.00671152f, -0.17481504f, 0.02871659f, -0.01408865f, 0.11671139f, -0.08803675f, 
    0.14346139f, -0.05110692f, -0.13669775f, 0.01156310f, 0.10392603f, -0.11452550f, 0.05144216f, -0.13967770f, 
    -0.03489639f, 0.08776609f, 0.05511891f, -0.10902124f, 0.19943446f, 0.06967106f, 0.10788638f, -0.18691728f, 
    -0.07103101f, -0.01042045f, -0.12054077f, 0.03206791f, -0.06560146f, 0.15063593f, -0.00173231f, 0.14616688f, 
    0.00535472f, 0.33951646f, 0.07474758f, 0.21898434f, -0.12344470f, 0.14215595f, 0.08544557f, -0.06942445f, 
    0.12763120f, -0.05666601f, -0.09533770f, 0.10396715f, -0.16018783f, 0.19559816f, -0.20011632f, 0.04190638f, 
    0.09160817f, 0.00341012f, -0.02937139f, 0.07331309f, 0.00239208f, 0.16197759f, 0.10381403f, -0.01118926f, 
    0.17866673f, 0.05811089f, 0.37523687f, -0.10494369f, -0.00398717f, -0.15554948f, -0.05947235f, -0.06269524f, 
    -0.13134202f, -0.13786854f, 0.06180153f, -0.09746139f, -0.09360084f, -0.02133044f, -0.04433870f, 0.16796198f, 
    -0.09809554f, -0.08220992f, -0.09428388f, -0.03926051f, 0.20038491f, 0.17173807f, 0.06795105f, 0.20465277f, 
    -0.08640885f, 0.05897051f, 0.23909566f, 0.07865924f, 0.17050906f, 0.11219142f, -0.06609428f, 0.05246498f, 
    -0.21042727f, -0.04405377f, -0.15240420f, -0.04702088f, -0.08639230f, -0.12914103f, 0.09473214f, 0.01160015f, 
    -0.06204124f, 0.08153729f, 0.09759067f, 0.09558751f, 0.06371038f, -0.11161447f, 0.10736416f, 0.03482198f, 
    -0.09127259f, -0.07393583f, 0.12382862f, 0.15728621f, 0.07250194f, -0.05945402f, 0.02579486f, 0.10707486f, 
    0.00704640f, 0.04812296f, 0.07194745f, 0.18042466f, 0.57020998f, -0.06449305f, -0.00529682f, 0.13959514f, 
    0.08704878f, -0.03351278f, -0.01552206f, -0.10399570f, -0.07272010f, 0.07752007f, 0.11445764f, 0.25675514f, 
    -0.07415871f, -0.11662462f, -0.06077497f, -0.13883376f, 0.04321605f, 0.07579576f, 0.00849489f, -0.11849523f, 
    0.16368490f, 0.01538830f, -0.05159768f, -0.01847793f, -0.04355326f, 0.09461399f, 0.26857388f, 0.02916569f, 
    0.03178016f, 0.09204954f, -0.13860966f, -0.03855246f, -0.10577098f, 0.02647932f, -0.01160989f, -0.04393497f, 
    0.05138926f, -0.17787126f, -0.09267987f, 0.08892988f, 0.08109226f, 0.10063495f, 0.02010748f, 0.07545495f, 
    -0.06813715f, 0.06816588f, 0.03443660f, -0.09360904f, 0.05052794f, 0.09528147f, -0.01209714f, -0.12203280f, 
    0.06089414f, 0.09644782f, 0.12418503f, -0.02167397f, -0.16680317f, -0.01478633f, -0.18457763f, 0.12093235f, 
    -0.41334254f, 0.21954076f, 0.15392640f, 0.09413665f, -0.05495246f, 0.00080963f, 0.14256394f, 0.03540127f, 
    -0.07690497f, 0.22423133f, 0.20686688f, 0.09906451f, -0.14241339f, 0.06288241f, 0.04487655f, 0.03821646f, 
    -0.00008240f, -0.11846697f, -0.04838580f, 0.24430390f, -0.12061598f, -0.04153685f, 0.12015862f, -0.13538456f, 
    0.00292224f, -0.15810154f, -0.00221956f, 0.18456949f, 0.04993718f, -0.00450297f, 0.16021703f, 0.06189270f, 
    -0.05528879f, 0.03228251f, -0.15549418f, -0.06134079f, 0.09263724f, -0.02405944f, -0.12069252f, -0.17845894f, 
    -0.03657980f, -0.02160632f, -0.09088945f, -0.11105227f, -0.01188971f, -0.02909737f, -0.23006871f, -0.15668999f, 
    0.28161952f, -0.09438215f, 0.01641321f, 0.15581614f, 0.04210933f, 0.01128881f, 0.13563737f, -0.02157892f, 
    0.01129611f, 0.15195230f, 0.13010451f, 0.20570979f, 0.22025737f, 0.13080290f, 0.07779232f, -0.12832679f, 
    -0.07833185f, 0.12978745f, 0.08954057f, -0.03771115f, 0.02982191f, 0.12846529f, 0.02919207f, 0.09289332f, 
    0.14654349f, 0.00680594f, 0.16985747f, 0.02431650f, -0.02713039f, 0.08004007f, -0.06342236f, -0.04850144f, 
    -0.17625485f, -0.24433112f, -0.11658184f, -0.25655094f, -0.15615483f, 0.21338968f, -0.00544939f, 0.37051293f, 
    0.08399872f, 0.00111599f, 0.04986073f, -0.13479944f, -0.05629225f, 0.07501803f, 0.15269341f, -0.01908237f, 
    -0.08006616f, -0.13721129f, 0.13894378f, 0.22009341f, 0.07518187f, -0.08416641f, -0.00635920f, 0.04488114f, 
    -0.05760821f, 0.05546913f, 0.05591808f, 0.03647651f, -0.23161063f, -0.11840212f, 0.27969024f, -0.07949556f, 
    -0.09120408f, -0.07567414f, 0.04122001f, 0.21245076f, 0.11754066f, -0.01624675f, -0.00660236f, 0.00650843f, 
    -0.32626209f, -0.19508466f, -0.45601413f, 0.47550336f, 0.15916415f, 0.05069406f, 0.08440879f, -0.03135754f, 
    -0.06955990f, -0.01465394f, -0.00819960f, 0.03325311f, -0.00340786f, 0.01628454f, -0.00411307f, -0.08455284f, 
    0.22438358f, -0.04429355f, 0.10027200f, -0.01623624f, 0.07555342f, 0.04418864f, -0.04095085f, 0.08118379f, 
    -0.18654092f, -0.22729115f, -0.18099499f, 0.10378473f, 0.12851760f, 0.16949800f, 0.04317953f, -0.03655849f, 
    0.00427067f, 0.18397231f, 0.20686685f, 0.13756429f, 0.04196491f, 0.13750592f, 0.02933566f, -0.01652928f, 
    0.02378265f, 0.01837872f, -0.05944937f, 0.07729124f, -0.07646264f, -0.00781486f, -0.14580213f, -0.02399684f, 
    0.45669475f, -0.03052576f, 0.20299247f, -0.38843614f, -0.02486636f, 0.08232411f, 0.05840868f, 0.07182700f, 
    -0.02411361f, -0.10876385f, 0.01869825f, -0.03757352f, -0.13387369f, -0.08847155f, 0.04120228f, -0.13615951f, 
    -0.03699228f, -0.01155249f, 0.01121092f, 0.07259552f, -0.07227626f, 0.09338773f, -0.01640921f, -0.12018342f, 
    -0.16951577f, -0.28264332f, 0.04063522f, -0.00809793f, 0.04601788f, -0.06673986f, -0.07982522f, 0.03327797f, 
    0.07864542f, -0.04765843f, 0.08041041f, 0.04390888f, 0.01592411f, -0.08519281f, 0.20587723f, -0.06123686f, 
    0.13349263f, 0.11585661f, 0.39621669f, 0.12816772f, 0.02553952f, 0.02165348f, -0.02860148f, 0.06821711f, 
    -0.08766618f, -0.03303361f, 0.04327251f, 0.16978621f, -0.13252860f, -0.06117888f, -0.02316081f, 0.05703245f, 
    -0.01240466f, 0.02878775f, 0.21304618f, 0.09869627f, 0.26221812f, 0.13585205f, 0.05938878f, -0.16669543f, 
    0.05631728f, 0.11854043f, -0.00271487f, 0.02647801f, -0.09099077f, -0.00412977f, -0.00649396f, 0.04302443f, 
    -0.09273858f, -0.16600822f, 0.05631289f, 0.05318141f, 0.02619444f, 0.29011130f, 0.11082985f, -0.17602438f, 
    0.08164939f, -0.12440694f, -0.03771989f, 0.10927149f, -0.00141326f, -0.14228937f, 0.03211572f, 0.25487438f, 
    -0.00298574f, -0.00784347f, -0.05067380f, -0.01887356f, 0.00030255f, 0.09775265f, 0.01670211f, -0.02736553f, 
    -0.08469774f, 0.00482254f, 0.40123093f, -0.22348130f, -0.00061158f, -0.00682447f, 0.06813366f, 0.01129976f, 
    -0.02429328f, 0.04866791f, -0.08785719f, 0.00299889f, -0.03384605f, 0.11224548f, 0.13126490f, 0.05093782f, 
    0.04710200f, 0.03680838f, -0.02056216f, 0.01985319f, 0.21365511f, 0.14540938f, 0.15894420f, 0.04523222f, 
    -0.30755922f, -0.03147917f, -0.10531057f, -0.08081608f, 0.12478808f, -0.04973027f, 0.03004625f, 0.01387134f, 
    0.03505081f, 0.05492927f, -0.03636169f, -0.02495852f, -0.11778516f, 0.00414595f, 0.06525226f, 0.17219630f, 
    0.07602620f, 0.13293537f, -0.01943851f, 0.12825336f, 0.05659254f, -0.03298961f, 0.13490093f, 0.11222805f, 
    -0.03003666f, -0.08659388f, 0.10143161f, -0.14935063f, 0.02099769f, 0.01703156f, 0.03787835f, 0.04554243f, 
    0.10641229f, 0.09447177f, -0.04710444f, 0.17366003f, -0.07310673f, -0.16214529f, 0.11383607f, 0.07245211f, 
    -0.07654475f, 0.07165246f, 0.12448335f, 0.00887972f, 0.12441213f, 0.03064352f, 0.15662685f, 0.11968639f, 
    -0.19612209f, -0.22169621f, 0.07862981f, -0.05776213f, -0.15065065f, -0.02664155f, 0.12566264f, 0.03212120f, 
    0.02999388f, 0.01294040f, 0.03826936f, -0.03979777f, -0.04373197f, 0.01125144f, 0.05672174f, 0.22318386f, 
    -0.02558235f, -0.01307723f, -0.00706005f, 0.03069213f, -0.03361992f, 0.04373744f, -0.11580106f, 0.13069835f, 
    -0.16233207f, -0.35013500f, -0.07495222f, -0.04424129f, -0.19723167f, -0.21363662f, -0.14677964f, 0.01938557f, 
    0.01979937f, 0.00335964f, 0.03935880f, -0.09082288f, 0.04173989f, -0.09252123f, 0.01111018f, 0.17665435f, 
    0.01298293f, -0.06793626f, -0.06422063f, -0.08995749f, -0.00759740f, -0.09516986f, 0.15160736f, 0.11747289f, 
    -0.27931097f, 0.29788840f, 0.47626379f, 0.19771881f, 0.02557462f, -0.01357157f, 0.00470001f, 0.19290757f, 
    0.14543508f, 0.09468433f, 0.21303008f, 0.15349157f, -0.18002082f, -0.12806311f, -0.01791487f, 0.27289566f, 
    0.12991475f, -0.09665804f, -0.03277125f, 0.12708074f, 0.01993000f, 0.06940370f, -0.07585239f, 0.18396553f, 
    -0.21310075f, -0.13468339f, 0.18938556f, 0.21004088f, -0.04130684f, -0.25263122f, 0.05694225f, 0.08821125f, 
    -0.03020199f, -0.00280470f, -0.02423344f, -0.00567691f, -0.22760727f, -0.28552574f, -0.11401504f, -0.10028251f, 
    -0.23934093f, 0.00961170f, -0.11191298f, -0.28503305f, -0.01091981f, -0.06048203f, 0.01688519f, -0.01548627f, 
    0.01388318f, -0.09223125f, -0.03595974f, -0.04463078f, -0.03120438f, -0.12010694f, -0.03115374f, -0.05062483f, 
    0.11979636f, 0.17920919f, 0.07085453f, -0.03377467f, 0.19235753f, 0.31347644f, 0.14556408f, -0.16755283f, 
    -0.04150268f, 0.08737603f, 0.02211092f, 0.01561104f, 0.05087173f, 0.04276274f, 0.09939597f, 0.11857249f, 
    -0.03172826f, -0.04455628f, -0.16683283f, -0.04678095f, 0.06985816f, -0.00340723f, 0.01659066f, 0.02042332f, 
    0.02310516f, -0.04460230f, -0.11225671f, -0.01646804f, 0.12383150f, 0.13415444f, 0.15663455f, 0.12451299f, 
    0.04572883f, -0.03378822f, 0.00626788f, 0.14340137f, -0.16770528f, 0.02884523f, 0.12083707f, 0.21197368f, 
    -0.05347371f, -0.14725088f, 0.01619315f, 0.01690133f, 0.14401375f, -0.02552466f, 0.04053740f, 0.04170080f, 
    -0.08297701f, 0.02694032f, -0.05513610f, 0.03690447f, -0.43130025f, -0.14671190f, 0.09573688f, -0.10806375f, 
    -0.15052141f, -0.14262971f, 0.19775134f, 0.29019028f, 0.16590826f, 0.15852855f, 0.03629657f, 0.02395500f, 
    -0.13460007f, -0.43024763f, 0.25382090f, -0.02123326f, 0.03737734f, 0.10072950f, 0.08775221f, 0.26727286f, 
    0.01256183f, -0.05485485f, 0.18441397f, -0.09842923f, 0.03644136f, 0.04191942f, -0.03854819f, 0.06420559f, 
    0.17449073f, -0.01151875f, 0.10744820f, 0.01169010f, 0.06317739f, 0.03169091f, 0.11539421f, -0.00664637f, 
    -0.01242625f, 0.05978067f, -0.08497681f, 0.03404041f, 0.01134313f, -0.01993598f, 0.10897201f, 0.13893573f, 
    0.14690967f, 0.04575269f, 0.08422343f, 0.19074853f, 0.13835214f, 0.17182469f, 0.11956862f, 0.06929679f, 
    -0.01880497f, -0.01943142f, -0.00700891f, -0.01701746f, 0.03630812f, 0.19020674f, -0.01379955f, 0.07322623f, 
    0.42152077f, 0.28633204f, 0.15783611f, -0.09819102f, -0.04576538f, -0.05455188f, -0.05059958f, -0.03048743f, 
    -0.08440883f, -0.05703181f, 0.12724735f, -0.05306959f, -0.11270292f, -0.09113730f, -0.02481242f, -0.07062747f, 
    0.04935494f, -0.08978801f, 0.17193270f, 0.05261236f, 0.04808732f, 0.10464194f, -0.03461589f, -0.02364155f, 
    -0.10133249f, -0.31336218f, -0.01051538f, 0.02043767f, -0.05975145f, 0.03799788f, 0.01991658f, -0.06170392f, 
    -0.02779671f, -0.10297474f, 0.03385502f, 0.02981458f, 0.23110317f, -0.15917993f, 0.13263293f, 0.04440739f, 
    0.15442541f, 0.12735985f, 0.29523769f, 0.05044740f, -0.02396691f, 0.03818933f, 0.09547481f, 0.02341348f, 
    -0.12283490f, -0.22728059f, -0.09231962f, -0.06424180f, -0.06173197f, -0.01476487f, -0.00990081f, 0.06888027f, 
    0.04893402f, 0.04228235f, 0.20052232f, -0.13776799f, 0.27315444f, -0.00148812f, 0.20222940f, -0.02230400f, 
    0.03739965f, 0.00742708f, 0.02900518f, 0.09387080f, -0.07713789f, 0.15236239f, -0.03059619f, -0.01476168f, 
    -0.08986433f, 0.02284293f, 0.14985670f, -0.00083032f, -0.23952743f, 0.29940382f, 0.10954674f, -0.08807684f, 
    0.20510697f, 0.00017690f, 0.02181769f, 0.03176934f, -0.09748693f, -0.25675124f, 0.04959822f, -0.00854056f, 
    -0.05027074f, -0.01977289f, -0.04900827f, 0.04352290f, 0.12615618f, 0.15374520f, 0.05481411f, -0.05044823f, 
    0.23751508f, 0.19949917f, 0.31327030f, 0.06631993f, -0.14460197f, -0.16987999f, 0.06864972f, -0.16428769f, 
    -0.09876250f, 0.01503498f, 0.03581192f, 0.02869831f, -0.04153053f, -0.06375736f, 0.00303503f, -0.19532651f, 
    0.07203408f, 0.05740638f, 0.03264632f, 0.13984874f, 0.00402252f, 0.01661712f, 0.13000929f, 0.00698809f, 
    0.01847545f, 0.11718822f, 0.07693627f, -0.11657746f, -0.07194357f, -0.06490066f, 0.06452216f, 0.03425111f, 
    -0.00634031f, 0.03276880f, 0.06123007f, -0.06007465f, 0.06865228f, 0.07614139f, 0.14149234f, -0.08348510f, 
    0.23644327f, 0.19776942f, 0.06408760f, 0.06561516f, -0.05297955f, -0.00908155f, 0.27021897f, 0.02435194f, 
    -0.03219297f, -0.18610089f, -0.07817752f, -0.08364680f, -0.05309584f, -0.01674152f, 0.16593844f, -0.03780029f, 
    -0.07162271f, -0.10168342f, -0.12992169f, 0.16867261f, -0.11848114f, -0.07408845f, 0.15021604f, 0.04644228f, 
    -0.08955894f, -0.07846642f, -0.04877387f, 0.00877440f, 0.13097207f, 0.00421224f, 0.10646263f, -0.14170024f, 
    -0.19996051f, -0.25696295f, -0.10746940f, 0.03946405f, -0.00866550f, 0.10839543f, 0.04152440f, 0.05615237f, 
    -0.07727361f, -0.01614142f, -0.00284282f, -0.03895300f, 0.32355744f, 0.14642118f, 0.25438929f, -0.08063977f, 
    0.05849735f, -0.00731498f, -0.03289148f, -0.04685064f, 0.00844764f, 0.18251626f, 0.12740818f, 0.24559887f, 
    -0.24114715f, -0.22161007f, -0.06979270f, -0.03302677f, -0.07810739f, -0.11892756f, 0.01252157f, 0.11133574f, 
    -0.04319781f, -0.06093666f, -0.14160705f, -0.12334676f, 0.29067531f, 0.16956361f, -0.01642756f, 0.02610818f, 
    -0.02694795f, -0.06475223f, -0.00456582f, -0.14997581f, 0.15951838f, 0.05094632f, 0.21277778f, 0.27877012f, 
    0.00723828f, 0.27535301f, 0.21398754f, -0.22776221f, -0.09584688f, 0.03358802f, 0.18923405f, 0.10164263f, 
    0.13111529f, 0.29259241f, 0.18662903f, 0.04467577f, -0.02173932f, 0.07842503f, 0.10988692f, -0.13778487f, 
    0.20277843f, 0.03678050f, 0.04037835f, 0.06749114f, 0.15648958f, 0.10136487f, 0.12596224f, 0.19145457f, 
    -0.42133370f, -0.19800684f, 0.07710222f, -0.16484831f, 0.23259929f, -0.02601443f, 0.25886631f, 0.04365523f, 
    -0.09442688f, 0.03177226f, -0.02602068f, 0.00247947f, -0.17483355f, -0.16755906f, -0.13983348f, -0.04014640f, 
    -0.01383413f, -0.04495846f, -0.14773004f, -0.00370404f, -0.16633551f, -0.01668433f, -0.01952565f, -0.01503049f, 
    -0.05641223f, -0.06094913f, -0.03137039f, -0.03481232f, -0.04441677f, 0.04625664f, 0.10754846f, 0.09427287f, 
    -0.16945967f, -0.09556132f, -0.22111373f, -0.05353843f, 0.17164977f, 0.13900055f, 0.00976714f, 0.12558809f, 
    -0.03741207f, 0.10082160f, -0.08568183f, 0.08450970f, 0.17978474f, 0.21774796f, 0.15787490f, 0.03715806f, 
    0.00325533f, 0.01460763f, 0.12801704f, -0.08330579f, 0.01548705f, 0.01674865f, -0.03945323f, 0.09299451f, 
    -0.01608376f, -0.05294396f, 0.00865817f, 0.02440201f, 0.69184142f, -0.15915810f, 0.06103844f, 0.10095639f, 
    0.01997167f, -0.11896233f, 0.17993294f, 0.14914492f, 0.22616099f, 0.25257340f, 0.23371759f, 0.08499070f, 
    0.21582790f, 0.20913026f, -0.10044699f, -0.10536739f, 0.08994123f, -0.05982135f, -0.03080324f, -0.06174731f, 
    0.02293211f, -0.00596829f, 0.00012928f, -0.11794417f, 0.37426713f, -0.05610501f, 0.12956606f, 0.08763479f, 
    0.09120539f, -0.07655720f, 0.08973785f, 0.27012819f, -0.08886419f, -0.06705303f, 0.14943248f, -0.00670260f, 
    -0.65750539f, 0.24872978f, -0.37824395f, 0.23849316f, 0.08741305f, 0.09533885f, 0.15562806f, -0.11023590f, 
    -0.10529234f, -0.04703358f, 0.04203521f, -0.00672401f, 0.04222719f, 0.08536161f, -0.20034719f, -0.02545490f, 
    -0.08720835f, 0.10024526f, 0.00597594f, 0.03024701f, -0.10706465f, 0.01959920f, -0.10589684f, 0.07103739f, 
    -0.04775224f, -0.02373802f, 0.10748833f, 0.05574428f, 0.05951960f, 0.16122152f, 0.13991962f, -0.01015677f, 
    -0.14253138f, 0.06876064f, 0.08825627f, -0.01411720f, 0.08430501f, -0.03631472f, -0.07612309f, -0.01191239f, 
    -0.03490972f, -0.07005082f, -0.07667653f, -0.09267026f, -0.04865301f, 0.04725694f, 0.01531405f, -0.01543874f, 
    0.34126872f, -0.14264093f, -0.04827795f, 0.07479024f, -0.13669060f, 0.01231076f, 0.10558053f, -0.00590637f, 
    0.02804624f, 0.11449985f, -0.13563044f, 0.07223636f, 0.29279649f, 0.12710997f, -0.05118102f, -0.01489223f, 
    0.02889811f, 0.16662337f, -0.19229916f, -0.01362611f, -0.15202691f, -0.11310497f, 0.14242703f, -0.10858651f, 
    0.30460203f, 0.36865830f, 0.08648852f, 0.15754016f, -0.00345694f, 0.00845578f, 0.05593412f, 0.20202409f, 
    -0.01832951f, 0.14180823f, -0.12313507f, 0.04403323f, -0.02804651f, 0.19634582f, 0.07428496f, 0.13170059f, 
    0.01700974f, -0.02754937f, 0.15142073f, 0.02619980f, 0.05406921f, 0.10066658f, -0.12085206f, -0.04584793f, 
    -0.01859550f, 0.42527807f, -0.06483734f, -0.19376794f, -0.08432578f, -0.05974671f, 0.02979866f, -0.08678941f, 
    -0.07796685f, -0.00199282f, 0.05849696f, -0.05420962f, -0.08115222f, -0.04275249f, -0.00887612f, -0.12351321f, 
    -0.06406263f, -0.03518775f, -0.00758055f, -0.06258715f, 0.05226942f, 0.01166844f, -0.01828109f, 0.10455023f, 
    0.12585768f, -0.14676537f, -0.02427005f, 0.27710193f, 0.10741217f, -0.13862371f, 0.09964601f, -0.05034251f, 
    -0.00419736f, -0.07049984f, -0.04063896f, 0.02788195f, -0.17886831f, 0.11410884f, -0.04705507f, 0.24349687f, 
    0.00166910f, -0.07408243f, -0.08503374f, -0.03082123f, -0.18851188f, 0.04158383f, -0.10210574f, 0.15821378f, 
    0.29243606f, -0.20847751f, -0.00893935f, 0.09241291f, -0.21102938f, 0.08343473f, -0.00624692f, 0.04859214f, 
    0.04411855f, 0.00823348f, -0.11613537f, -0.04923351f, 0.06120895f, 0.11702774f, -0.02778212f, 0.02162327f, 
    0.00758882f, -0.01375476f, 0.00999226f, -0.02282934f, 0.16879985f, 0.03007154f, 0.01214482f, 0.03745108f, 
    0.06323583f, 0.03176221f, -0.05420107f, -0.01431695f, 0.25989121f, 0.16240083f, 0.21417159f, 0.08348628f, 
    -0.21037053f, -0.01014025f, 0.15826121f, -0.10336687f, -0.18139125f, 0.08965019f, 0.07810150f, 0.06990988f, 
    -0.04227596f, 0.07924834f, -0.01858567f, 0.08059902f, 0.02395237f, 0.15790226f, -0.05477316f, 0.03481123f, 
    0.13845573f, 0.15520963f, 0.42595363f, 0.00702598f, -0.06059976f, 0.08755493f, -0.01632909f, 0.08355280f, 
    -0.01703367f, 0.07250258f, 0.11630657f, 0.14151827f, -0.18177763f, -0.02363402f, -0.00180857f, -0.07101016f, 
    -0.06080588f, 0.08982012f, 0.03094072f, 0.06078535f, 0.06267569f, 0.03151805f, 0.06489197f, 0.05860084f, 
    -0.00389466f, -0.07076498f, 0.22127482f, 0.00793356f, -0.01687197f, -0.08250239f, 0.01525827f, 0.06553993f, 
    -0.03578757f, -0.00631424f, -0.01883330f, 0.07472196f, 0.10039265f, 0.03261491f, 0.17691794f, 0.33627602f, 
    -0.27340955f, -0.07189374f, 0.15772715f, 0.16045830f, -0.11016203f, -0.02290728f, 0.05668897f, -0.02400261f, 
    0.09514979f, 0.06624424f, 0.19614747f, 0.22000852f, -0.03130389f, 0.02170262f, 0.00601655f, -0.02097984f, 
    0.02533039f, 0.00265213f, 0.06579015f, 0.09686633f, -0.20541514f, -0.00126288f, 0.25113964f, 0.01622954f, 
    -0.01378967f, 0.01753777f, -0.14384377f, 0.00282024f, -0.00940908f, 0.01283272f, -0.03795376f, -0.06933982f, 
    0.37005204f, -0.11310537f, -0.36914667f, 0.26333886f, 0.09047206f, -0.11474762f, -0.01739863f, 0.15144716f, 
    -0.03942227f, -0.02226833f, -0.00635924f, 0.09109324f, -0.05885481f, -0.01245447f, -0.07217427f, 0.44757470f, 
    0.01555029f, 0.09780589f, 0.08093260f, -0.08817482f, 0.00079297f, -0.00080753f, -0.04312873f, 0.02002174f, 
    0.16795363f, 0.20879060f, -0.03583520f, 0.05728441f, 0.01239487f, 0.01615536f, -0.01758135f, 0.13643315f, 
    -0.02898047f, -0.02468143f, -0.00018571f, -0.06865507f, -0.08672839f, 0.11960069f, 0.25384620f, 0.15736668f, 
    -0.11643936f, 0.08183052f, 0.02599843f, -0.01625342f, -0.12248521f, -0.05350870f, 0.12775892f, -0.00891016f, 
    0.16089164f, 0.03171577f, 0.08813144f, 0.06080545f, 0.07609560f, 0.09195510f, -0.01479300f, -0.04463293f, 
    0.09300690f, 0.10844449f, 0.04881215f, 0.08051796f, 0.18440130f, 0.01018874f, 0.07384123f, -0.28215745f, 
    -0.05430732f, -0.09607675f, 0.03153591f, -0.06222754f, -0.10199264f, -0.01075769f, 0.08078289f, -0.07741547f, 
    -0.11100031f, 0.10312065f, -0.11360071f, 0.09164116f, 0.11431034f, -0.03464515f, 0.03770836f, -0.13677710f, 
    -0.09467275f, 0.03313997f, -0.04777037f, -0.21812402f, 0.03227467f, 0.28299543f, -0.31849712f, 0.08525306f, 
    -0.10773960f, -0.04497816f, -0.09247058f, 0.02188459f, -0.05279201f, -0.11778417f, -0.12330053f, -0.16419183f, 
    -0.40017861f, -0.35742065f, 0.02027832f, -0.07686049f, -0.07772034f, 0.02823311f, 0.05895421f, 0.12797150f, 
    0.00701795f, 0.04384941f, 0.05799466f, 0.18351653f, -0.28516006f, 0.18656121f, -0.07108014f, -0.07259994f, 
    -0.03228236f, -0.01112047f, 0.12574944f, -0.06478761f, 0.23086046f, 0.12301470f, -0.04845607f, 0.10195529f, 
    0.45231521f, -0.51950783f, 0.33391234f, -0.14108434f, -0.27201083f, 0.07435718f, -0.11048486f, 0.12680618f, 
    -0.03173220f, 0.11711791f, -0.09129415f, -0.02513663f, -0.06598821f, 0.10625016f, 0.01304329f, -0.08035780f, 
    0.07066999f, -0.12267940f, 0.09725566f, -0.03374716f, 0.17155804f, -0.08030802f, 0.18572360f, 0.15343326f, 
    -0.08430756f, -0.07245774f, 0.11038519f, 0.02300812f, 0.05050642f, -0.06834669f, -0.10575905f, 0.06426144f, 
    0.03340826f, -0.00446728f, -0.02127053f, 0.03777154f, 0.02563124f, 0.13453373f, 0.06222829f, 0.08970851f, 
    0.05751037f, -0.04850844f, 0.01976343f, -0.01428454f, -0.00123857f, -0.09807561f, 0.01784856f, 0.07956508f, 
    -0.22999939f, 0.38367432f, -0.18240426f, 0.20986161f, 0.04191918f, 0.11984356f, -0.04439216f, -0.15986092f, 
    0.03760801f, -0.03306545f, -0.02246629f, -0.04628940f, -0.08682926f, -0.01795026f, -0.01762858f, -0.00776922f, 
    -0.02007727f, -0.03260249f, 0.12274808f, 0.00700564f, 0.10602682f, 0.01270770f, -0.03965390f, 0.02331495f, 
    -0.15426923f, -0.17461263f, 0.17342477f, 0.11628084f, 0.10995464f, 0.10508687f, 0.07319789f, 0.02957956f, 
    -0.00740987f, -0.08586403f, 0.05180033f, -0.02201428f, -0.09487562f, 0.09458677f, -0.17951141f, 0.19586967f, 
    -0.03405875f, 0.23189540f, 0.00252793f, 0.08203223f, -0.05833235f, 0.12287057f, -0.00751124f, 0.04955549f, 
    -0.03446125f, -0.34021416f, 0.18483253f, 0.17858672f, 0.02322542f, -0.04969592f, -0.15778174f, 0.19129214f, 
    0.10834131f, 0.10383176f, -0.05483853f, 0.04526526f, 0.25895962f, 0.24513760f, -0.04836261f, 0.21359779f, 
    0.02634980f, 0.08246757f, 0.07692125f, -0.01430210f, 0.00464804f, -0.02734641f, 0.14979498f, -0.04218509f, 
    -0.00812605f, -0.11586264f, 0.14432344f, -0.09259078f, 0.23652077f, 0.19218393f, -0.09857054f, 0.23650502f, 
    0.02308407f, 0.10107649f, 0.11305780f, -0.02869465f, 0.33289665f, -0.30398992f, 0.33583209f, -0.11876065f, 
    -0.05106176f, 0.09161383f, -0.05792606f, 0.04375951f, 0.12244564f, 0.00443313f, 0.05151213f, -0.11447463f, 
    0.11908551f, 0.32824731f, -0.24742469f, 0.11009333f, 0.05729652f, 0.15669173f, 0.02202520f, 0.02257393f, 
    -0.03833834f, -0.06123149f, 0.04978294f, -0.06359252f, 0.14801367f, -0.04650532f, 0.19156431f, 0.12605688f, 
    0.03402028f, -0.00839540f, 0.03069349f, -0.01036588f, 0.01622303f, -0.09040766f, 0.00097205f, 0.00404022f, 
    -0.14463827f, -0.00194004f, 0.05367204f, 0.02805275f, -0.22297868f, -0.05181572f, -0.05621869f, 0.16303495f, 
    0.08703199f, -0.11618043f, 0.00460039f, 0.00402512f, 0.09223565f, -0.02452656f, -0.09396619f, -0.04699108f, 
    0.16559939f, -0.01399098f, -0.05208189f, 0.05597642f, 0.00984767f, 0.05506758f, 0.19447176f, -0.01872919f, 
    0.07897983f, 0.11480796f, -0.23333520f, 0.44943899f, 0.07388328f, -0.02678731f, 0.12018877f, 0.08066636f, 
    -0.02940741f, -0.08916738f, -0.06896869f, -0.07348490f, -0.10238346f, 0.14589384f, -0.08410300f, 0.15127349f, 
    -0.09105328f, -0.16111481f, 0.21407869f, -0.12360688f, 0.12075839f, -0.07225296f, -0.12972075f, -0.03484283f, 
    -0.19490199f, 0.13930716f, -0.03347239f, 0.18807279f, 0.22339760f, 0.12529796f, 0.09742408f, 0.06122989f, 
    0.08499219f, 0.08133951f, 0.06463207f, -0.04243680f, 0.28524378f, 0.01734613f, 0.04948672f, -0.06254565f, 
    0.14528781f, 0.00250012f, -0.14886203f, -0.10269479f, 0.08975654f, -0.12446392f, 0.04187432f, -0.02022065f, 
    -0.14948961f, 0.09485890f, -0.00119154f, -0.04189206f, 0.13335122f, 0.11506162f, 0.03585046f, 0.14111261f, 
    0.02258296f, 0.00464272f, 0.04681318f, 0.06985235f, 0.49137416f, 0.43434304f, -0.02462930f, 0.18726616f, 
    -0.01738713f, -0.06250733f, -0.08340140f, -0.04751080f, 0.02328902f, 0.16546836f, 0.13537116f, 0.01294814f, 
    0.00606014f, -0.05276201f, 0.47002780f, -0.25964725f, 0.05729017f, 0.03298007f, -0.00295763f, 0.13918850f, 
    0.07371085f, -0.02909195f, -0.02603575f, -0.09484626f, 0.20461361f, 0.00781540f, 0.07162214f, -0.24490778f, 
    0.04547968f, 0.07765248f, -0.00019304f, 0.06389178f, 0.00766683f, 0.15661596f, 0.05276236f, 0.02447275f, 
    -0.13395879f, -0.05264892f, 0.09404723f, -0.27046669f, 0.00419530f, 0.05296140f, 0.08773234f, 0.01958942f, 
    0.20623434f, 0.04274132f, -0.11178014f, 0.07896559f, -0.17194141f, -0.30513754f, -0.16240060f, -0.09917833f, 
    0.20832145f, 0.16029498f, 0.04583926f, 0.19156709f, 0.04553923f, -0.03311142f, -0.02719440f, 0.06862675f, 
    -0.25597519f, -0.05723489f, -0.06966458f, 0.02301801f, 0.08557870f, -0.12887557f, 0.06254976f, 0.11305529f, 
    -0.02223859f, -0.13052940f, -0.04077101f, -0.04937403f, 0.05401106f, 0.20280968f, -0.10831484f, 0.25178233f, 
    0.01094684f, -0.00097090f, -0.09915588f, 0.06587085f, 0.08381051f, -0.04465576f, 0.05135634f, 0.19830331f, 
    0.02774081f, -0.13967438f, 0.07731783f, 0.03826689f, 0.15440744f, 0.16900493f, -0.06944697f, 0.00172315f, 
    -0.01837249f, -0.00684908f, -0.03359464f, -0.00206730f, 0.12212420f, -0.35915914f, 0.49367601f, -0.50833499f, 
    0.00147905f, -0.13637732f, 0.01175211f, -0.10430743f, 0.17018843f, 0.06995825f, 0.07748789f, 0.16628863f, 
    -0.00552567f, -0.05337399f, 0.00427127f, -0.03666143f, -0.02841422f, -0.00131832f, 0.04818146f, 0.02999679f, 
    0.02840949f, -0.04778131f, -0.00331625f, 0.03609823f, 0.03145713f, -0.02336395f, 0.00519258f, -0.02542512f, 
    -0.05156373f, 0.00995727f, -0.04451245f, -0.03156116f, 0.00119917f, -0.02145681f, -0.01158349f, 0.03465559f, 
    -0.02688242f, -0.03780778f, -0.00909365f, -0.04160805f, 0.03464640f, -0.03607441f, -0.01649290f, -0.02283359f, 
    0.00493336f, -0.02139033f, -0.01582278f, -0.03578706f, 0.04932000f, 0.00318045f, -0.00868982f, -0.00581331f, 
    0.00982494f, -0.02277977f, -0.04427601f, -0.02384138f, 0.02982229f, -0.02347558f, -0.03635935f, -0.02282078f, 
    0.04166082f, -0.03311396f, 0.01920389f, 0.00612396f, -0.01783363f, 0.02230668f, 0.03926228f, -0.02125239f, 
    -0.04117237f, -0.04665555f, -0.03233257f, -0.02986262f, 0.02058779f, -0.04074019f, -0.01683812f, 0.00930871f, 
    -0.03961098f, 0.04581641f, -0.02286443f, -0.02590002f, 0.02450735f, 0.00898870f, -0.02198394f, 0.01075661f, 
    -0.03649053f, -0.01237918f, 0.05432413f, -0.03495726f, -0.04825092f, 0.02968979f, 0.05025011f, -0.01473492f, 
    -0.05114295f, -0.05485547f, 0.03862601f, -0.02370528f, 0.03285594f, -0.00636222f, -0.03275014f, -0.00000372f, 
    -0.01752567f, 0.04401826f, -0.05518082f, -0.02384980f, 0.00348610f, 0.03514652f, -0.04470714f, 0.03895899f, 
    -0.03534048f, -0.00389233f, 0.01357574f, 0.03783107f, -0.01661164f, -0.02176047f, 0.04408161f, 0.01874328f, 
    -0.01352704f, -0.02121433f, 0.01173234f, -0.00285847f, 0.04145064f, -0.01260038f, 0.00172120f, -0.00390368f, 
    0.02784040f, 0.00838630f, -0.01509005f, 0.00645597f, 0.01325973f, -0.00627940f, -0.02892542f, 0.04055776f, 
    -0.03253393f, 0.01674520f, 0.00748638f, -0.00116052f, 0.00229137f, -0.02470645f, -0.01531881f, -0.05201700f, 
    -0.03769067f, 0.04597136f, -0.00870811f, -0.03314529f, -0.04698527f, -0.02573660f, 0.01763920f, -0.01346459f, 
    0.01139131f, 0.01065987f, 0.00041411f, 0.00655221f, 0.01313026f, -0.03762198f, -0.02694832f, -0.01540740f, 
    -0.04972155f, -0.03525654f, 0.04326320f, -0.01502326f, 0.02637563f, -0.02720257f, -0.05419358f, 0.02234938f, 
    -0.04846384f, 0.01547720f, 0.01407751f, -0.01668953f, 0.02730830f, -0.02324301f, -0.01134411f, 0.04474649f, 
    -0.00603572f, 0.01925478f, 0.00240890f, -0.02540737f, 0.03438817f, 0.03530634f, -0.01019106f, -0.05879646f, 
    -0.05174387f, 0.02982076f, 0.02128736f, 0.03490973f, -0.02844936f, 0.00044924f, -0.04919500f, 0.03941817f, 
    -0.00374557f, 0.00720986f, -0.00972636f, -0.03781846f, 0.00390883f, 0.01390677f, 0.01881091f, -0.04768877f, 
    -0.00042625f, 0.03378206f, -0.04640718f, -0.00206430f, -0.05790629f, -0.02283336f, -0.04501374f, -0.00378600f, 
    0.04319959f, -0.03101652f, 0.02306125f, -0.02433374f, -0.02709815f, 0.04365988f, 0.00684191f, -0.01916734f, 
    0.04992265f, 0.03676985f, -0.03008609f, 0.00577731f, -0.04854723f, -0.03712182f, -0.00394305f, 0.02689330f, 
    0.02004143f, -0.05123429f, 0.03213292f, 0.03206759f, 0.00812092f, 0.03187075f, 0.03644485f, -0.02573019f, 
    0.00209009f, -0.03606641f, -0.01820599f, -0.03511246f, -0.01917524f, 0.01885976f, 0.02173809f, -0.00127280f, 
    0.01395098f, 0.02565524f, -0.03471138f, -0.01587013f, -0.02779883f, 0.03105202f, -0.03272578f, 0.00180580f, 
    0.03147866f, -0.02741857f, -0.03232229f, -0.02997847f, -0.04579785f, -0.05281536f, 0.03261697f, -0.00056807f, 
    -0.04469930f, -0.01677087f, 0.01698229f, -0.00200998f, -0.04413305f, 0.00514489f, -0.02228969f, 0.02116514f, 
    0.01852154f, -0.03684660f, 0.03860504f, 0.02426298f, -0.03213455f, -0.03219686f, 0.02450127f, 0.01417136f, 
    0.03223947f, 0.01694303f, -0.03006784f, 0.02112275f, -0.04142796f, -0.01148027f, 0.04570948f, -0.04157228f, 
    0.04141784f, -0.03498168f, -0.03104996f, -0.02897995f, -0.00512894f, -0.00855681f, 0.01462260f, -0.03399555f, 
    0.00729570f, -0.02061098f, 0.03983095f, -0.03534062f, -0.02219304f, 0.02288021f, -0.04159562f, -0.02389190f, 
    -0.02564079f, 0.03585541f, -0.01171523f, -0.04405056f, -0.00856366f, 0.03804671f, 0.04355843f, 0.01998410f, 
    0.01377808f, 0.02386020f, 0.01007506f, -0.01494764f, 0.01998707f, -0.01990012f, -0.02669152f, 0.03709107f, 
    -0.04319079f, 0.04162694f, -0.04693568f, -0.00115028f, -0.03564398f, 0.03855834f, -0.04346369f, -0.02514725f, 
    -0.03234179f, -0.00854821f, -0.04040793f, 0.04475670f, -0.04704584f, 0.00708316f, 0.03475787f, 0.01943513f, 
    0.04016549f, 0.02695405f, -0.02939205f, 0.04002485f, -0.04092339f, 0.00370813f, -0.00411582f, 0.00985598f, 
    0.02668889f, -0.00515955f, -0.01596907f, 0.02631638f, -0.02379113f, -0.03037378f, -0.02997700f, -0.01848735f, 
    -0.02686731f, 0.04157352f, 0.01440101f, -0.04288701f, 0.02455418f, 0.03664334f, 0.03069150f, -0.00381777f, 
    -0.02910523f, -0.05027145f, -0.04219949f, -0.06009556f, -0.03688794f, -0.04471927f, -0.00639601f, 0.00516269f, 
    -0.02322533f, -0.00340687f, 0.01905425f, -0.05349960f, -0.01859738f, -0.00048216f, 0.00096006f, 0.03753734f, 
    0.04775942f, -0.05594098f, -0.03426685f, -0.01323402f, -0.04612720f, 0.03170966f, -0.05265759f, -0.04158057f, 
    0.03110138f, 0.02053115f, 0.05284107f, 0.03428546f, 0.00066663f, 0.02446294f, 0.00719540f, -0.00918253f, 
    -0.02568745f, -0.04786813f, 0.04237797f, -0.04135285f, -0.04241398f, 0.03165130f, -0.04141459f, 0.01157830f, 
    -0.05633847f, 0.01548668f, -0.03507716f, -0.00125974f, 0.01033253f, 0.03114380f, -0.02295356f, 0.01005750f, 
    0.01345482f, 0.00939965f, -0.02435298f, -0.02854214f, -0.04754064f, 0.01340952f, -0.05449701f, 0.01354376f, 
    0.00316134f, -0.02913333f, 0.01191895f, 0.03498106f, 0.00885422f, 0.00897609f, 0.00003690f, 0.03404239f, 
    0.01987705f, -0.01008319f, -0.05036034f, -0.01735576f, -0.01771994f, -0.03461242f, -0.04219122f, 0.04152167f, 
    0.04852098f, 0.01279350f, 0.03184632f, -0.01874965f, 0.00830362f, 0.01733277f, -0.00024966f, -0.04704945f, 
    0.04140298f, 0.00147941f, -0.00579415f, -0.02514383f, 0.01151482f, 0.02964690f, 0.04158077f, 0.00134834f, 
    -0.01572809f, -0.02935141f, 0.00756053f, 0.03917968f, -0.02418498f, -0.03651327f, 0.00844301f, 0.01041374f, 
    0.02753943f, -0.00892840f, -0.02187316f, -0.00955128f, 0.03417743f, -0.01422030f, 0.01018212f, -0.03582769f, 
    -0.02124834f, -0.01280363f, -0.01882183f, 0.01483145f, 0.03026122f, 0.03321068f, -0.00401742f, 0.03354154f, 
    -0.04661047f, -0.04517397f, -0.01989397f, -0.05584462f, 0.00420313f, -0.03837206f, -0.01888411f, -0.05180244f, 
    0.02003544f, -0.02252148f, 0.01466363f, -0.01900350f, 0.01500158f, -0.00980757f, -0.00638622f, 0.02292330f, 
    0.03579342f, -0.03824883f, -0.02081020f, 0.01002565f, -0.04042922f, -0.02737581f, 0.00228148f, 0.01748190f, 
    0.02642879f, -0.04311537f, -0.00584518f, -0.01068135f, 0.04417779f, -0.02127980f, -0.03462245f, -0.01906395f, 
    -0.04498806f, -0.00437065f, 0.03357928f, 0.02836340f, 0.00478578f, 0.00582965f, 0.00203457f, -0.00484267f, 
    -0.04822492f, 0.03964022f, -0.04478801f, 0.00891034f, -0.01657840f, -0.01904916f, -0.00358134f, -0.02683063f, 
    0.03234401f, -0.01223287f, 0.00608441f, 0.00260649f, -0.02217787f, 0.00586396f, -0.02745313f, -0.04878119f, 
    -0.05216414f, 0.01479544f, -0.02711147f, 0.01419512f, 0.04331363f, -0.02800421f, 0.01179111f, -0.01973729f, 
    0.02032253f, 0.01797977f, -0.01717869f, 0.03220720f, -0.05426325f, -0.00706657f, -0.02984561f, -0.03140667f, 
    -0.05099164f, -0.02675553f, -0.05038596f, 0.00599913f, -0.00707327f, -0.00716496f, 0.03097731f, 0.00524447f, 
    -0.00766722f, -0.01405208f, 0.03452977f, -0.02469849f, -0.01502714f, -0.02429657f, 0.03824669f, -0.01463736f, 
    0.02156962f, 0.04262265f, -0.05181160f, -0.01417489f, 0.00502693f, 0.00257594f, -0.04308606f, -0.01769864f, 
    -0.03066283f, -0.00178717f, -0.01046780f, -0.05251411f, -0.04359166f, -0.04257278f, -0.03495893f, -0.04260492f, 
    -0.00899106f, -0.04401698f, -0.01990434f, -0.04845487f, 0.00875198f, -0.00338424f, 0.02009034f, -0.02369491f, 
    0.00572304f, -0.02390691f, -0.01926308f, -0.04059258f, 0.02258639f, -0.02080855f, 0.04149949f, -0.01736000f, 
    0.01087634f, 0.03188432f, -0.00244623f, 0.02484382f, -0.03333947f, -0.02826386f, 0.03903809f, -0.03076355f, 
    -0.03777349f, 0.04316939f, -0.02515170f, 0.03964662f, 0.01622606f, 0.04066069f, -0.02332079f, 0.00802362f, 
    0.03835705f, -0.02356566f, -0.04104043f, -0.04076748f, -0.02864884f, 0.00423048f, -0.01749074f, -0.02243768f, 
    0.03054067f, -0.00371047f, 0.01896621f, 0.01674480f, 0.03347272f, 0.03729536f, 0.01525280f, -0.00555729f, 
    0.00859508f, 0.00431455f, 0.01790503f, 0.02635692f, 0.01307664f, -0.00739003f, 0.00469351f, -0.05371064f, 
    -0.05397947f, 0.00210140f, -0.05320134f, -0.01318061f, -0.01270585f, -0.02779074f, -0.01411488f, 0.00803330f, 
    -0.05207354f, -0.02700252f, -0.00510003f, 0.01733573f, -0.00146743f, -0.02038398f, -0.05275244f, 0.03469699f, 
    -0.00007293f, 0.02351166f, -0.01838068f, 0.01721704f, -0.03985127f, -0.03673632f, 0.03368898f, 0.03581764f, 
    0.01167716f, 0.03767131f, 0.02097977f, -0.04893916f, -0.00963187f, -0.03964496f, -0.04368342f, -0.02802327f, 
    -0.02779261f, 0.03699579f, -0.01913239f, 0.01047287f, 0.00474121f, -0.01990594f, 0.00908691f, 0.03036050f, 
    -0.02855648f, -0.05295132f, 0.02686950f, -0.04546559f, 0.04176829f, -0.03064453f, 0.01179297f, -0.05280025f, 
    0.01885732f, 0.04137142f, -0.01502284f, 0.02482263f, -0.04021015f, -0.02965501f, -0.05142364f, -0.02449321f, 
    0.03151196f, -0.01276825f, -0.01838052f, -0.03697447f, 0.00305377f, -0.00849303f, -0.03661112f, -0.02036995f, 
    -0.03059775f, -0.01610801f, 0.02934935f, -0.02479425f, 0.03121935f, -0.00208048f, -0.00632208f, -0.04575448f, 
    -0.01767190f, -0.04031453f, -0.01304725f, 0.02750670f, -0.04280746f, 0.02554905f, -0.00635012f, -0.01331134f, 
    -0.05587850f, 0.00240241f, -0.01834060f, 0.01378017f, -0.03264375f, 0.01887010f, -0.05463396f, -0.05313236f, 
    -0.03275600f, -0.02635913f, 0.01707791f, 0.03997457f, 0.00345233f, -0.03473879f, 0.04355192f, 0.00025331f, 
    0.02225780f, -0.04577477f, 0.01490639f, -0.03440831f, -0.04520353f, -0.01983362f, -0.01749862f, -0.04679223f, 
    -0.03188314f, 0.00661777f, 0.03400320f, 0.03093546f, 0.00421547f, -0.05700369f, 0.00864451f, 0.01677805f, 
    -0.05332289f, 0.02298373f, -0.04781856f, 0.01311361f, 0.03217815f, 0.02171008f, -0.02491744f, -0.03278659f, 
    -0.03962502f, 0.00322904f, -0.01144669f, -0.04150267f, -0.01441276f, -0.05507283f, -0.00678701f, -0.00192336f, 
    -0.01681745f, -0.05407999f, -0.02192197f, -0.01229538f, 0.00316906f, -0.01620750f, -0.02805435f, -0.01753400f, 
    -0.04117830f, -0.01484489f, -0.02414261f, -0.02934065f, -0.00933208f, 0.03644222f, 0.02284065f, -0.04820947f, 
    -0.01446493f, -0.05655150f, 0.04405066f, 0.01333228f, 0.02003361f, 0.02295890f, -0.00454196f, 0.01902209f, 
    0.02461208f, -0.00294410f, 0.00872000f, -0.00801211f, 0.04621975f, -0.01079839f, -0.01158020f, -0.01790938f, 
    0.33905247f, 0.40244907f, 0.17533289f, 0.06306686f, 0.02153599f, 0.18031976f, 0.04581945f, 0.25861537f, 
    0.08164499f, -0.07926850f, -0.04237128f, -0.01317827f, 0.09690623f, -0.04699142f, -0.08169641f, 0.00040656f, 
    0.02278807f, 0.04385214f, 0.08313734f, 0.03154670f, -0.03884604f, -0.12222715f, -0.08831289f, 0.04223208f, 
    0.23905192f, 0.15340021f, 0.13618845f, -0.21387155f, 0.20294793f, -0.00843898f, -0.06397116f, 0.25536811f, 
    0.13838932f, 0.02447259f, 0.18600611f, -0.12841859f, -0.06692526f, -0.18839043f, -0.06784270f, -0.10057490f, 
    -0.08602828f, -0.06366152f, 0.06696287f, 0.11925667f, 0.05827052f, 0.15894839f, 0.07895232f, 0.04329521f, 
    0.29416019f, 0.13367052f, -0.03213331f, 0.08822893f, 0.02094184f, 0.02444119f, 0.05401158f, 0.02002749f, 
    0.03833199f, -0.10171794f, -0.17513464f, 0.02954763f, -0.39586550f, -0.48006400f, -0.23766665f, -0.06993035f, 
    0.03008923f, 0.03682587f, -0.09749740f, -0.16719857f, -0.02655422f, 0.04168979f, 0.03727907f, -0.04356149f, 
    -0.45496711f, -0.23644094f, 0.09011132f, -0.00898620f, 0.10653657f, -0.08312984f, -0.11016990f, 0.04957194f, 
    0.00258626f, -0.03012208f, 0.03011996f, -0.00939873f, -0.16253731f, -0.20095780f, -0.26785436f, -0.26643977f, 
    0.15582229f, -0.07578705f, 0.08870408f, -0.02002364f, -0.13636614f, -0.10356688f, 0.13317598f, -0.05546347f, 
    0.11729096f, -0.00714310f, -0.11875644f, -0.05778655f, -0.10997885f, -0.00951921f, 0.08395068f, 0.02047565f, 
    -0.10629479f, 0.07642025f, -0.00548844f, 0.02903206f, 0.10485540f, -0.07800633f, 0.13801089f, -0.10647655f, 
    0.15686677f, 0.11028498f, -0.13167360f, 0.09797554f, 0.05094555f, -0.09938533f, 0.10661861f, -0.02227071f, 
    0.30306268f, 0.02691125f, 0.07382669f, 0.10586074f, 0.07936516f, 0.06923003f, 0.05187183f, -0.03883415f, 
    -0.04131181f, -0.04097151f, 0.01484694f, 0.10506461f, -0.36421698f, -0.36894163f, 0.11575003f, 0.20002715f, 
    -0.07857540f, -0.10261929f, -0.00864548f, -0.14979179f, -0.04162799f, 0.06762417f, -0.13801935f, 0.16428679f, 
    0.03241580f, 0.50602615f, -0.15593153f, -0.28258008f, 0.02598142f, -0.11725766f, -0.00133530f, 0.29252684f, 
    0.06636804f, 0.12549102f, 0.09981301f, -0.08986305f, 0.23778430f, 0.08480229f, 0.11436345f, -0.11785621f, 
    0.03132721f, -0.04287992f, -0.02654798f, 0.06867754f, -0.09992772f, -0.05017162f, 0.17483613f, 0.00964654f, 
    -0.36284435f, -0.31433329f, -0.34692940f, -0.12940964f, 0.00743549f, 0.01092245f, 0.05791704f, -0.08560708f, 
    -0.11367901f, -0.03372346f, 0.09892638f, -0.01277968f, 0.13853803f, -0.03699260f, 0.03417996f, 0.04045792f, 
    0.02968257f, -0.00486197f, -0.05902218f, -0.00038852f, -0.07734173f, -0.03647308f, 0.03679425f, 0.09043267f, 
    0.05226583f, -0.07200669f, 0.08108398f, 0.03969872f, -0.14757462f, 0.01624299f, -0.11057898f, 0.18865742f, 
    -0.15632480f, 0.03175591f, -0.15551805f, 0.06331068f, -0.10372028f, -0.11356083f, -0.28697801f, 0.00092136f, 
    0.02979518f, 0.10455973f, 0.21962173f, -0.03223432f, 0.03376924f, -0.26810297f, -0.03349837f, -0.01239168f, 
    -0.11078213f, 0.04907485f, -0.27455780f, -0.27526969f, -0.05804508f, 0.00319494f, 0.00181122f, 0.16699889f, 
    -0.00028217f, -0.04835706f, 0.00247596f, 0.21199127f, -0.11250564f, 0.15174296f, 0.13600855f, 0.28058866f, 
    0.12237898f, 0.19479163f, -0.03079964f, -0.06056392f, -0.10952622f, 0.06296451f, 0.07378677f, 0.07506032f, 
    0.17968667f, 0.30463284f, -0.03014915f, 0.02768571f, 0.07612251f, -0.04704836f, -0.00953187f, 0.06924478f, 
    0.01654936f, -0.01145298f, 0.07851934f, 0.09063469f, -0.45389447f, -0.08818351f, -0.42477846f, -0.40714461f, 
    -0.14835739f, 0.16676992f, -0.08660688f, -0.16576163f, 0.07089403f, 0.11202377f, -0.00711431f, -0.06294151f, 
    0.06860116f, 0.23475534f, -0.07487734f, -0.15437143f, 0.06515115f, 0.08992510f, 0.09144197f, 0.15071042f, 
    -0.10624358f, -0.10419011f, -0.07130318f, -0.06365404f, -0.01553807f, -0.28990713f, -0.17825577f, 0.22476196f, 
    0.03173763f, 0.03139836f, 0.00433827f, -0.01274962f, -0.01984575f, 0.01627031f, -0.07168767f, 0.05570117f, 
    0.33588001f, 0.09370534f, 0.04816572f, -0.06051011f, -0.10320398f, -0.10885277f, 0.16250226f, -0.01024857f, 
    0.03301356f, 0.06003435f, 0.15158755f, 0.15679432f, -0.06289531f, 0.06202710f, -0.05498305f, -0.21353316f, 
    0.06284042f, -0.04610572f, 0.04428118f, 0.31248334f, 0.09380756f, 0.04044582f, 0.05467805f, -0.18724918f, 
    0.20427160f, -0.04314968f, 0.10432187f, -0.03596084f, -0.06328840f, 0.07971814f, 0.08928543f, 0.19855182f, 
    -0.06505709f, 0.00180861f, 0.13071626f, 0.01838495f, 0.10496926f, 0.23434740f, -0.00608147f, -0.06060810f, 
    0.12418431f, -0.03604415f, -0.06430869f, 0.10560158f, 0.02137107f, -0.02726967f, -0.09087483f, -0.10853349f, 
    0.02677626f, 0.34082523f, 0.17156684f, 0.22019109f, 0.13394406f, 0.24172081f, 0.03193524f, -0.03285084f, 
    -0.06269491f, 0.00911980f, 0.06517658f, 0.06133107f, 0.07400174f, -0.16636565f, -0.02483589f, 0.03601229f, 
    0.01501707f, 0.10886861f, -0.12553264f, -0.10719452f, 0.11516209f, 0.05344898f, -0.07035205f, 0.07327063f, 
    -0.24805726f, -0.13025768f, 0.24459250f, -0.00050638f, -0.05122335f, 0.12430606f, 0.00123228f, -0.21530968f, 
    0.10970446f, -0.04010610f, -0.02543470f, -0.20115685f, 0.09016155f, -0.19734560f, 0.07239420f, -0.09723438f, 
    -0.03396944f, 0.07108746f, -0.12765190f, -0.05858177f, 0.05153548f, 0.08562252f, -0.09956980f, 0.00950673f, 
    -0.20899817f, -0.01868511f, -0.13888961f, -0.19429025f, -0.04812166f, 0.03517142f, 0.09865727f, 0.02165048f, 
    0.04766753f, 0.00776424f, -0.06388830f, 0.08076180f, -0.18025345f, -0.06641114f, -0.29333180f, -0.10643023f, 
    0.04444196f, 0.21556503f, 0.06523187f, -0.17668132f, 0.04550010f, 0.10341309f, -0.19324580f, -0.06161359f, 
    0.15044932f, 0.02542559f, 0.44925749f, -0.39880300f, -0.03529021f, -0.06313322f, -0.04452466f, 0.25255668f, 
    0.15678148f, -0.11741949f, 0.12730041f, -0.03093755f, 0.00171555f, 0.03655396f, -0.02971885f, 0.03441193f, 
    -0.11981973f, 0.07849299f, -0.14711618f, -0.10241917f, 0.05265917f, 0.05081388f, 0.02121020f, -0.16378456f, 
    0.25409877f, 0.20216978f, 0.13569398f, 0.00717565f, -0.04954502f, -0.13192402f, -0.14874926f, 0.13751222f, 
    0.15468141f, -0.02634136f, -0.17765941f, -0.11763820f, 0.09161203f, -0.01050786f, 0.15271521f, 0.17616417f, 
    -0.08227787f, -0.07387885f, -0.04375601f, -0.06506673f, 0.06020796f, -0.03549059f, 0.05790392f, 0.04221541f, 
    -0.03375257f, 0.12399779f, 0.18121639f, 0.22986303f, 0.08987638f, -0.08118284f, -0.04881910f, -0.00680856f, 
    0.00165124f, 0.03526301f, 0.04441094f, 0.08185121f, -0.01913778f, -0.04331462f, -0.06649397f, 0.10106223f, 
    -0.03468050f, -0.17629027f, -0.01932860f, -0.11768261f, -0.06168158f, -0.06171542f, -0.09808125f, -0.01277273f, 
    -0.02803705f, -0.03491682f, -0.10883357f, -0.01436038f, 0.09050646f, 0.13352713f, 0.26571697f, -0.10101398f, 
    0.01578399f, -0.03603019f, -0.01136337f, 0.09589945f, 0.19083883f, 0.00277943f, 0.10406252f, 0.01238186f, 
    0.11800043f, -0.02349046f, -0.25857279f, -0.01037504f, -0.01050559f, -0.01012147f, 0.08154078f, 0.04171916f, 
    -0.04143152f, -0.27770042f, -0.18291263f, -0.08355699f, 0.12538105f, 0.17543000f, 0.09313428f, 0.15443708f, 
    0.20768391f, -0.01408733f, -0.17080373f, -0.04865616f, 0.28353018f, -0.00967436f, 0.35700399f, 0.39858618f, 
    0.01501568f, -0.03687214f, 0.02154309f, -0.06118950f, 0.02583213f, 0.11865538f, -0.09351406f, -0.07766175f, 
    0.03760819f, 0.22817995f, 0.17048688f, -0.17537712f, -0.15882868f, -0.29387087f, -0.20313409f, 0.22713260f, 
    0.14909099f, 0.08365083f, 0.10481776f, -0.13112222f, 0.07870100f, 0.22922499f, 0.04659982f, -0.30678019f, 
    0.08775411f, 0.08301643f, -0.00492821f, 0.17037666f, 0.09826586f, -0.04917146f, 0.03990191f, 0.00282396f, 
    0.41252652f, 0.13239351f, -0.07436703f, 0.23653044f, 0.01134642f, -0.01165743f, -0.09722964f, -0.02069341f, 
    -0.02288070f, -0.07483207f, 0.02847322f, 0.07408221f, 0.09814849f, 0.08295853f, -0.02784944f, -0.18209599f, 
    0.05782628f, 0.05556478f, 0.03256936f, 0.04933785f, -0.14947304f, -0.27816567f, -0.18882334f, -0.14331901f, 
    0.06793239f, 0.04632868f, 0.01875693f, 0.00579703f, -0.16505341f, 0.02456150f, -0.07600621f, -0.05451097f, 
    0.02392663f, -0.12788674f, -0.02130790f, 0.09149026f, 0.06647874f, 0.10241766f, 0.04660542f, -0.16245821f, 
    -0.01609361f, -0.06371064f, 0.14076582f, -0.13067785f, -0.09684285f, 0.03671816f, 0.04840326f, 0.10062651f, 
    -0.09030522f, -0.01759876f, -0.25511363f, 0.21073133f, -0.01698559f, -0.06831984f, -0.02590298f, -0.15427199f, 
    -0.15142065f, -0.17868459f, -0.05484875f, -0.02537268f, -0.29140499f, 0.27648312f, 0.06836481f, -0.07887942f, 
    0.10585562f, -0.11155109f, -0.05810705f, 0.05154264f, -0.04256486f, 0.02411312f, -0.27785870f, -0.25953659f, 
    0.16439317f, 0.18895531f, -0.17598985f, 0.10750751f, 0.29118958f, 0.08417580f, 0.02324958f, 0.02731831f, 
    0.03739887f, -0.01210125f, -0.03286203f, 0.04935199f, 0.20161311f, 0.03745212f, 0.01970891f, -0.08955368f, 
    -0.02934466f, 0.03568469f, -0.06495416f, -0.05897547f, 0.05593234f, -0.09192445f, 0.14258894f, -0.03334620f, 
    0.02148948f, 0.22401847f, -0.03487279f, -0.06188052f, 0.30033112f, 0.38104475f, 0.21195525f, 0.02845259f, 
    -0.00313036f, -0.05359335f, -0.00186705f, 0.01833621f, -0.08711518f, 0.08164266f, 0.10122148f, 0.04780694f, 
    -0.09957055f, -0.10430335f, -0.03563108f, -0.00985995f, 0.04708833f, -0.00340332f, -0.07426707f, -0.05036715f, 
    0.44818226f, -0.18046252f, -0.30652043f, -0.39468649f, -0.10795489f, 0.00498688f, 0.05118394f, -0.18074514f, 
    0.08124010f, -0.09023584f, -0.17256512f, -0.07828148f, 0.12359486f, 0.14915594f, 0.00249785f, -0.21076268f, 
    -0.05396399f, -0.03720138f, -0.03367028f, -0.07076097f, 0.06912641f, -0.09654488f, 0.18865843f, -0.03421188f, 
    -0.11754189f, -0.12611756f, -0.00940657f, -0.15180515f, 0.34221977f, 0.35258415f, 0.14217047f, 0.00389585f, 
    0.13649173f, 0.03641877f, 0.04432072f, -0.01762311f, 0.13262561f, 0.07046041f, -0.00010613f, 0.06807131f, 
    0.35622108f, 0.17599639f, 0.18958133f, 0.29949144f, 0.05951834f, 0.02361782f, 0.04277004f, 0.03293069f, 
    -0.24710611f, 0.05444084f, 0.02786244f, -0.05612387f, 0.12473375f, 0.13992116f, -0.04314290f, 0.09654264f, 
    -0.14658134f, -0.13587049f, -0.02743633f, -0.06462270f, -0.01316712f, -0.22085521f, -0.02258649f, 0.28995171f, 
    0.10217884f, -0.11425412f, -0.05796044f, 0.12761636f, 0.15288280f, -0.09152846f, -0.04918832f, -0.12189309f, 
    -0.01867447f, -0.04501690f, 0.13634554f, 0.05563716f, -0.09069213f, 0.07224206f, -0.13834642f, 0.01120524f, 
    -0.00878821f, -0.05536265f, 0.04287782f, 0.01624757f, 0.11161702f, -0.00946257f, -0.08575495f, -0.11863220f, 
    -0.08890128f, 0.06299352f, 0.01200762f, -0.04444271f, 0.36257166f, 0.02597302f, 0.00310865f, -0.04716322f, 
    0.09105557f, -0.00642169f, 0.16238578f, 0.15953973f, 0.15207082f, 0.06830977f, -0.05698163f, -0.05598294f, 
    0.01599583f, 0.05402225f, -0.08319685f, 0.01037904f, 0.20848085f, 0.35642672f, 0.01428229f, 0.25706047f, 
    -0.04216027f, 0.06936239f, 0.13713750f, 0.02893601f, 0.14312530f, 0.01836925f, -0.03055128f, 0.15988530f, 
    0.26779753f, 0.36848328f, 0.30796736f, 0.32457495f, 0.15115584f, -0.02778523f, 0.00182339f, 0.09961559f, 
    -0.13136314f, 0.03456023f, -0.11841254f, 0.24431199f, -0.02483663f, -0.10581892f, -0.01892770f, -0.02476779f, 
    -0.05634787f, 0.21465047f, -0.02604523f, -0.01948686f, -0.09170457f, 0.04039424f, 0.09362876f, -0.02195050f, 
    -0.13712525f, 0.02442849f, 0.13488638f, 0.14783667f, -0.10718306f, -0.00285899f, -0.04036837f, -0.06582829f, 
    0.05068079f, -0.00042773f, -0.00000571f, -0.10518728f, -0.05905223f, 0.06397790f, -0.00825559f, -0.19895951f, 
    -0.19203959f, -0.20583743f, -0.06631073f, -0.14279252f, 0.03000285f, -0.02953553f, 0.01261772f, -0.07248078f, 
    -0.19245215f, -0.02354684f, 0.14962126f, 0.10366923f, -0.03100787f, 0.10855799f, -0.10862771f, -0.03482886f, 
    -0.02679048f, 0.11810309f, 0.04585230f, -0.00318620f, -0.17117912f, -0.06575819f, -0.10616300f, -0.20002550f, 
    -0.17713378f, 0.04593341f, 0.03158120f, -0.02436380f, -0.03973828f, 0.00825558f, -0.04437688f, 0.06739189f, 
    -0.17514156f, -0.01531773f, 0.20253199f, 0.30132467f, -0.02328197f, 0.10467768f, -0.01180242f, -0.07992126f, 
    -0.03457903f, -0.06247173f, 0.00087122f, -0.00801593f, -0.09550281f, 0.17867805f, 0.25037557f, 0.32956615f, 
    0.03652784f, 0.14395030f, -0.09862722f, -0.01138979f, -0.05766061f, 0.07268081f, -0.00612400f, -0.00531838f, 
    0.07739937f, -0.00820394f, -0.05331802f, 0.08342893f, 0.00701643f, -0.03008569f, -0.01845970f, 0.02479754f, 
    0.05290629f, 0.09698330f, -0.01209517f, -0.17856544f, -0.00050643f, -0.00002476f, -0.01939758f, 0.07092585f, 
    -0.02646004f, 0.00185115f, -0.21381421f, -0.04605589f, 0.03824505f, -0.05912279f, -0.02554336f, -0.09783628f, 
    -0.10597529f, 0.20764183f, 0.12557903f, -0.06382827f, 0.19839729f, -0.07931501f, -0.07708418f, 0.12270243f, 
    -0.05904663f, -0.01363070f, -0.07379167f, -0.17965868f, -0.07372453f, 0.41011959f, 0.17542399f, 0.07677977f, 
    0.00001549f, -0.12170944f, 0.16271803f, 0.06607394f, 0.15598877f, 0.06085093f, -0.02186817f, 0.14589055f, 
    -0.42472264f, 0.20095500f, 0.11676298f, 0.04631190f, -0.00469208f, -0.10177094f, -0.19118127f, 0.00410418f, 
    0.02368830f, 0.05241403f, -0.03127352f, -0.08611017f, -0.06428809f, 0.08236114f, -0.01329828f, -0.03498710f, 
    0.02857615f, -0.10391381f, -0.00949045f, -0.04587869f, 0.19698033f, 0.02793123f, -0.18394601f, -0.14485532f, 
    -0.18783237f, 0.11222569f, 0.19750485f, 0.21292445f, 0.12459185f, 0.18135992f, -0.08222003f, -0.02365263f, 
    -0.11771902f, 0.06576211f, 0.08662481f, 0.30160674f, 0.04424392f, -0.00057104f, -0.03078895f, 0.00063050f, 
    -0.19033767f, 0.09672181f, 0.00147915f, 0.02809408f, -0.08077834f, 0.09939820f, 0.03162068f, -0.05220800f, 
    -0.11090626f, 0.27127430f, 0.00248383f, 0.29231396f, 0.15178065f, 0.07281870f, -0.11389985f, 0.03104595f, 
    0.01930509f, -0.05259758f, -0.01560753f, 0.00789406f, 0.97117937f, 0.04769200f, 0.08763295f, 0.20446587f, 
    0.03155037f, -0.08643945f, 0.07803943f, 0.09209878f, -0.00861752f, 0.00660246f, -0.11527149f, 0.07804274f, 
    -0.09135883f, -0.17635792f, -0.09543953f, 0.29059401f, 0.08161021f, 0.10745478f, 0.11374335f, -0.06401546f, 
    -0.08014424f, -0.00542600f, -0.08343381f, -0.02121261f, -0.07544979f, 0.20959064f, 0.16212636f, 0.17007551f, 
    -0.09419288f, -0.00766040f, -0.05364045f, 0.09363493f, -0.01807280f, -0.06652633f, 0.15003955f, 0.13737701f, 
    0.15023813f, -0.11194886f, 0.19612136f, 0.28106517f, 0.00798305f, 0.09959161f, 0.01676916f, -0.06033454f, 
    0.03313946f, 0.03526067f, -0.00149669f, 0.04888363f, 0.10821659f, 0.08393946f, -0.10810830f, -0.30151683f, 
    0.02186580f, 0.04638708f, -0.03072809f, 0.06643015f, 0.05727125f, 0.23257732f, -0.03285773f, -0.07140693f, 
    -0.43423703f, 0.16275157f, 0.03347706f, 0.24569781f, 0.00395613f, 0.07774608f, -0.04599589f, -0.05248883f, 
    -0.07657501f, -0.13056181f, -0.18836576f, -0.03214306f, 0.05838626f, 0.40948299f, -0.09984400f, -0.09580974f, 
    0.00618642f, 0.12841159f, 0.04932701f, 0.15060177f, -0.22165298f, 0.05655760f, 0.12373127f, 0.03234583f, 
    0.12347345f, 0.04789278f, 0.16688851f, 0.23482534f, 0.11218580f, 0.06358209f, -0.02958602f, 0.14688644f, 
    -0.09699231f, -0.02489141f, -0.08138317f, 0.01126271f, 0.19995883f, -0.13407001f, 0.11625886f, 0.22847027f, 
    0.02515400f, 0.01061987f, 0.26861307f, 0.17079318f, -0.03836208f, 0.12956014f, 0.01308015f, 0.14422344f, 
    0.25471452f, -0.16151616f, -0.02163968f, 0.12893599f, 0.01758269f, -0.11253177f, 0.04334659f, -0.07399494f, 
    -0.10460095f, -0.16297558f, -0.03381819f, -0.08794314f, 0.12137993f, 0.17777942f, 0.18340302f, 0.13030249f, 
    0.06840923f, -0.06453509f, -0.08778756f, -0.09134849f, -0.05510398f, -0.07870088f, -0.06370894f, 0.12763965f, 
    0.09938771f, -0.04121400f, -0.05205766f, -0.10714143f, 0.07407415f, -0.06936208f, -0.01947401f, -0.04238271f, 
    -0.04799167f, -0.07962184f, -0.03770978f, 0.14474878f, -0.43695682f, 0.29599831f, 0.31130365f, 0.14712368f, 
    -0.02655918f, 0.19034597f, -0.07735010f, 0.13088331f, -0.11853769f, -0.03399421f, 0.16608806f, 0.00739660f, 
    0.18461737f, 0.16952397f, 0.12894133f, 0.31058416f, -0.00742172f, -0.03997580f, 0.06337450f, 0.06038112f, 
    0.07839376f, 0.07211808f, -0.02403885f, 0.02740918f, 0.08492626f, -0.06065187f, 0.28039083f, -0.11073146f, 
    -0.01568717f, -0.00342100f, 0.08463996f, 0.15832981f, 0.29395258f, 0.11308867f, 0.06946094f, 0.18624361f, 
    -0.24949662f, -0.16365299f, -0.49998701f, 0.12625220f, 0.02567801f, 0.02490354f, -0.01396828f, 0.05406841f, 
    -0.07533723f, 0.03912261f, -0.00319416f, 0.09273057f, -0.05899845f, -0.08462029f, -0.10689344f, -0.04072056f, 
    -0.09207929f, -0.12176745f, -0.01075643f, 0.11061629f, 0.01615500f, -0.05246646f, -0.15660064f, -0.07952139f, 
    0.19980292f, -0.08740493f, 0.00485861f, 0.12603535f, 0.01139590f, 0.09398478f, 0.09919374f, 0.01248765f, 
    0.10381464f, 0.01097347f, 0.00563746f, 0.04781896f, -0.17365979f, -0.13841802f, -0.10048854f, -0.15503184f, 
    -0.00390217f, -0.03059406f, -0.08595731f, -0.06017787f, -0.15603296f, -0.11827566f, -0.11426990f, -0.04036324f, 
    -0.14834283f, -0.13500340f, -0.33953410f, -0.19988160f, -0.04346838f, -0.04006194f, 0.14480612f, -0.09259588f, 
    0.05956763f, 0.09297896f, 0.00776634f, 0.15687856f, -0.17220455f, -0.14646202f, -0.09828041f, -0.08744726f, 
    -0.23289223f, -0.13784204f, 0.07752831f, -0.13670936f, -0.01185045f, 0.05844833f, 0.18573764f, 0.09183558f, 
    -0.29014841f, 0.11833522f, -0.19364721f, -0.15200104f, 0.06549195f, -0.05454737f, 0.05950143f, -0.11932196f, 
    0.08259927f, 0.05211186f, -0.00237053f, 0.07921021f, 0.20647089f, 0.09068080f, -0.21056481f, -0.01252446f, 
    0.04597041f, 0.06434593f, 0.15898491f, 0.17807128f, -0.03667861f, 0.12444165f, -0.06595775f, 0.03300243f, 
    -0.08057211f, 0.22534007f, 0.19863242f, 0.02588009f, -0.05931445f, 0.14356427f, -0.09558813f, 0.03486665f, 
    -0.04776197f, 0.04852638f, 0.09457813f, -0.09255932f, -0.14810342f, -0.11790731f, -0.09043746f, -0.10039449f, 
    -0.04744816f, 0.00518103f, 0.06722615f, 0.03123145f, -0.11324114f, -0.09258020f, 0.04556087f, -0.06505000f, 
    -0.08788855f, -0.30514196f, 0.01804716f, 0.06615301f, 0.07494092f, 0.02378322f, 0.02706574f, 0.01250230f, 
    0.00084553f, -0.06453544f, -0.03143466f, -0.11892984f, 0.00293660f, -0.10316639f, 0.38458872f, 0.13894036f, 
    -0.05953234f, 0.11141730f, -0.05609335f, 0.03480140f, 0.06084178f, 0.01718243f, -0.04216515f, 0.09742229f, 
    -0.15099107f, -0.08557712f, 0.00460277f, -0.21243289f, -0.10482042f, 0.02388979f, -0.07825404f, -0.06764062f, 
    0.01546383f, -0.01827133f, -0.04049461f, 0.10888589f, 0.14477234f, 0.15693720f, 0.16875099f, -0.09787005f, 
    0.11983652f, 0.05263696f, 0.10014454f, 0.12177996f, -0.05464584f, -0.03088271f, 0.00652294f, -0.10263473f, 
    -0.06989212f, 0.05718632f, -0.14326964f, -0.21657826f, 0.05539449f, -0.07001396f, 0.11335094f, -0.05308902f, 
    0.12359782f, 0.06859425f, 0.10123265f, 0.09705934f, -0.26154065f, 0.42482573f, 0.02640260f, -0.18043007f, 
    0.11012317f, 0.04343688f, 0.07345115f, 0.06806894f, 0.15250300f, 0.20119275f, -0.01924616f, 0.04338156f, 
    -0.06495589f, -0.17169520f, -0.11500436f, -0.41544867f, -0.01569895f, 0.01391432f, -0.04349085f, 0.00719706f, 
    -0.01225475f, 0.03838696f, -0.05861624f, -0.03309361f, -0.09996060f, -0.11238945f, 0.37873733f, -0.15981774f, 
    -0.01895407f, 0.12291745f, -0.00445384f, 0.21898851f, 0.05343468f, -0.03269202f, -0.05961606f, -0.17720219f, 
    -0.14877653f, -0.19082838f, -0.00267510f, 0.04616019f, -0.06851860f, 0.11535981f, 0.04953633f, 0.10603530f, 
    -0.07618945f, -0.01107598f, -0.00403838f, 0.03445156f, -0.01447452f, 0.19423288f, 0.00420086f, 0.09055347f, 
    -0.12534994f, -0.08148210f, 0.07359201f, 0.09232200f, 0.05350807f, 0.15966733f, 0.00781064f, 0.19935045f, 
    -0.18576518f, -0.16274643f, 0.01497992f, 0.04316894f, -0.10027067f, -0.16610126f, -0.08450954f, -0.03830170f, 
    0.01248604f, 0.02201431f, 0.06505210f, 0.17393795f, -0.05525975f, -0.01203579f, 0.16765231f, 0.01536273f, 
    -0.09005951f, -0.03765861f, -0.15824124f, -0.01015985f, 0.18205392f, -0.02504527f, 0.26939422f, -0.04746614f, 
    0.28243402f, 0.23121238f, -0.07805197f, 0.11545377f, 0.02289744f, -0.00924365f, -0.10753419f, 0.01510648f, 
    0.13393930f, -0.05085740f, -0.06615911f, -0.00131521f, -0.05612265f, 0.19868301f, -0.15301834f, 0.07050076f, 
    0.03364025f, 0.05013194f, 0.19911645f, -0.10873102f, 0.13916878f, 0.24486156f, 0.01890264f, 0.19818565f, 
    -0.12616569f, 0.01424305f, 0.01010665f, -0.03802347f, 0.05661660f, -0.06654705f, 0.06621647f, -0.02422238f, 
    0.07690965f, -0.01147425f, 0.14521162f, 0.04978933f, -0.19221231f, -0.21349181f, 0.05720530f, -0.02861000f, 
    -0.10163718f, -0.05375656f, 0.06781451f, 0.17358594f, -0.02355997f, 0.10633039f, 0.14678109f, 0.17870909f, 
    -0.17247285f, 0.05508682f, -0.10512845f, 0.00231762f, -0.05883851f, 0.08009337f, -0.14931153f, 0.05512587f, 
    -0.10181593f, 0.06773897f, -0.17055364f, -0.20872714f, 0.25443742f, 0.11701139f, 0.11289437f, -0.04219207f, 
    -0.12533668f, -0.18908563f, -0.05577439f, 0.16439836f, 0.04552291f, 0.00042099f, 0.03322444f, 0.05063299f, 
    -0.17007269f, -0.03403744f, -0.33044621f, -0.12334948f, 0.06785617f, 0.04641310f, 0.07927712f, -0.00039326f, 
    0.03470202f, 0.23569138f, 0.10301927f, 0.17579377f, 0.43881938f, 0.31761298f, 0.10912610f, -0.12594235f, 
    -0.12338418f, 0.09498059f, -0.02137412f, 0.15343767f, 0.15754713f, -0.06981000f, 0.03234506f, 0.05568402f, 
    -0.04861888f, -0.03887079f, 0.01586790f, 0.02225010f, -0.00690403f, -0.02378550f, 0.04529344f, -0.02700987f, 
    -0.00633644f, 0.04350044f, 0.01795806f, -0.02029651f, -0.01046508f, 0.05830325f, 0.03405634f, -0.02237035f, 
    0.00892321f, -0.05117511f, 0.00303554f, -0.02227317f, 0.01111585f, -0.03634876f, -0.00654218f, -0.03975128f, 
    -0.01530889f, -0.02084551f, 0.00086188f, 0.01246503f, -0.03537336f, 0.00789065f, -0.01294451f, -0.01974094f, 
    0.01249546f, 0.02214183f, -0.00167731f, -0.05584207f, -0.03481879f, -0.02569558f, -0.02912613f, 0.00246392f, 
    -0.03170475f, 0.01088695f, -0.00601735f, 0.02154096f, 0.00507799f, 0.00949907f, -0.00457565f, 0.00534202f, 
    0.00858704f, 0.00349204f, -0.00896739f, -0.01264073f, 0.00129317f, -0.03131082f, -0.00671390f, 0.01929632f, 
    -0.00893820f, 0.01646496f, -0.04234023f, -0.03482655f, -0.01429542f, 0.03067391f, 0.01567801f, 0.04210182f, 
    0.04125451f, -0.00054095f, 0.01226333f, 0.04149637f, 0.04324289f, 0.01198478f, 0.02863050f, -0.03543053f, 
    -0.02605351f, 0.02401666f, -0.04000397f, -0.00463304f, -0.02769484f, 0.03959619f, 0.02888768f, -0.02405724f, 
    -0.04652411f, -0.02652148f, 0.02616237f, 0.00159589f, 0.01773067f, -0.01579975f, 0.03022779f, -0.04481511f, 
    -0.03711278f, 0.00623260f, 0.01303297f, 0.00821234f, 0.00293133f, -0.04604868f, 0.03494902f, -0.04521039f, 
    0.00256823f, -0.03952472f, 0.01939130f, -0.00422714f, 0.02653345f, -0.01503393f, 0.00337287f, -0.01651686f, 
    0.03383563f, -0.02319069f, -0.04916647f, -0.02896318f, -0.04237881f, 0.05426235f, 0.04300658f, -0.01974097f, 
    0.03637340f, -0.03496729f, 0.03116562f, 0.01740665f, -0.00586186f, -0.05003368f, -0.03553127f, 0.01124666f, 
    0.01237727f, -0.03171644f, -0.04680488f, 0.04159635f, -0.01442083f, 0.03449145f, -0.04463195f, -0.04409676f, 
    0.03349357f, -0.02515217f, 0.00720582f, -0.05631351f, 0.02733864f, -0.03069756f, -0.04718713f, 0.00336841f, 
    -0.03414875f, 0.01413695f, 0.00955348f, 0.00286649f, -0.02087667f, -0.00457893f, 0.01564862f, 0.03028171f, 
    -0.02198446f, -0.03237353f, -0.03625188f, 0.01677682f, -0.05334304f, 0.02396619f, 0.01210452f, -0.04522315f, 
    0.00674546f, 0.04047370f, -0.04812117f, -0.05112063f, -0.04709205f, 0.02722178f, -0.04122042f, -0.00052135f, 
    0.00244987f, 0.03665401f, 0.03815133f, 0.00297372f, 0.02720916f, -0.00766984f, 0.00592262f, 0.00548361f, 
    0.01569183f, -0.00884609f, -0.02216958f, 0.04655423f, -0.03564649f, 0.03472881f, -0.00998457f, 0.01322211f, 
    -0.02835741f, -0.05628415f, -0.03427357f, -0.01040529f, -0.01355505f, 0.02737397f, -0.05743698f, -0.04809507f, 
    0.01504800f, -0.04536147f, 0.01675573f, -0.03918986f, -0.00919723f, -0.02364228f, 0.03549413f, -0.02878174f, 
    -0.03205847f, -0.02395779f, -0.02305541f, -0.01519056f, 0.04058941f, -0.02686171f, 0.01930464f, 0.02970854f, 
    -0.00675726f, 0.04073662f, 0.03890621f, 0.03986156f, -0.04716763f, -0.03458848f, -0.02417496f, -0.01155227f, 
    0.04356030f, 0.03441664f, 0.00670655f, -0.02670815f, 0.02553983f, 0.01310572f, -0.03734634f, -0.05148485f, 
    -0.02086870f, 0.01203369f, 0.01921253f, 0.02071315f, 0.03341388f, 0.00808471f, -0.01163574f, 0.02028526f, 
    0.00881792f, -0.04003540f, 0.00553901f, 0.03558324f, 0.03079210f, -0.03208733f, -0.01325123f, 0.01103090f, 
    -0.03643673f, 0.03901671f, 0.00846132f, -0.01106629f, -0.02640604f, -0.01901669f, 0.00648549f, 0.02937024f, 
    -0.04689725f, -0.00835956f, 0.02723880f, -0.02675641f, 0.02407346f, 0.02850363f, 0.02882794f, -0.03026061f, 
    -0.00924168f, -0.01537517f, 0.01084325f, 0.01173454f, -0.04256983f, -0.04307675f, -0.03960970f, -0.01077058f, 
    -0.00784023f, -0.03071797f, -0.03887928f, -0.03022286f, 0.00100827f, -0.04978717f, 0.00492923f, 0.03861897f, 
    0.03000459f, 0.03836676f, 0.04467164f, -0.02814945f, 0.00921719f, 0.01647290f, -0.00779178f, 0.00555369f, 
    0.03387974f, -0.02608272f, -0.02794913f, 0.02240879f, -0.02863581f, 0.03754948f, -0.03582022f, 0.03745646f, 
    0.03940564f, -0.00498537f, -0.05460024f, 0.00658648f, -0.00768371f, -0.00285018f, -0.02962037f, -0.04966680f, 
    -0.01365160f, -0.01666585f, 0.02562301f, 0.02400462f, 0.00141402f, 0.04472457f, 0.00828677f, 0.02401397f, 
    -0.04134973f, 0.00882511f, -0.05283863f, 0.03604145f, -0.05259375f, -0.04408524f, -0.01169416f, 0.02488119f, 
    -0.02367797f, 0.04625791f, 0.01084332f, -0.01131598f, -0.00842834f, -0.00084289f, -0.04832597f, 0.04448515f, 
    -0.00515022f, -0.01043349f, -0.04003258f, -0.04087899f, -0.01451401f, -0.02876231f, 0.03921755f, -0.04636365f, 
    0.03957109f, 0.02391721f, -0.01593399f, 0.01311137f, 0.02577085f, 0.01427740f, -0.05207912f, 0.00584448f, 
    -0.02035190f, -0.01869508f, 0.01902692f, -0.04435676f, 0.00492652f, 0.02787484f, 0.04386967f, 0.03014055f, 
    0.00656945f, 0.00982833f, 0.00738176f, -0.04641687f, -0.03326417f, 0.03107434f, 0.01812577f, -0.04066161f, 
    -0.00627706f, 0.04210039f, -0.05754759f, -0.03842776f, 0.02399234f, -0.03067850f, -0.00983640f, -0.00784429f, 
    -0.03187395f, -0.01018179f, 0.00817188f, -0.01905966f, 0.02271831f, -0.01644690f, -0.05538068f, -0.03289231f, 
    0.04296296f, -0.00444398f, -0.04559252f, -0.03500757f, -0.02529019f, -0.01993961f, 0.02213603f, 0.00683551f, 
    0.02273230f, -0.05557682f, 0.03679147f, -0.05088532f, 0.03363190f, -0.04002239f, -0.01715329f, -0.00268244f, 
    0.03557297f, -0.04498300f, -0.02065814f, 0.00294839f, -0.04584863f, 0.04091279f, -0.00395193f, -0.00198010f, 
    -0.01640444f, -0.07595339f, -0.02445777f, -0.05803398f, 0.02401901f, 0.03563876f, -0.12925711f, 0.01587158f, 
    0.01549072f, -0.08672938f, -0.16181555f, -0.09532222f, 0.00697294f, 0.05587313f, -0.05319612f, 0.14264423f, 
    -0.01528336f, 0.02433357f, 0.09210943f, 0.03853763f, -0.16377874f, -0.03844428f, 0.05974094f, 0.03786466f, 
    -0.05133414f, 0.38265926f, 0.02056147f, 0.37808415f, 0.09893154f, -0.00226602f, 0.17124592f, -0.00054223f, 
    -0.08959120f, 0.07022335f, 0.12410723f, 0.01743415f, 0.23496500f, 0.03005588f, 0.12986572f, 0.14096445f, 
    -0.15103212f, -0.10846492f, -0.03514054f, -0.11757886f, -0.01065297f, 0.02737134f, 0.07817832f, -0.02994781f, 
    -0.39440078f, -0.09166477f, -0.13425273f, 0.10137297f, -0.00892310f, 0.08562000f, -0.09158015f, -0.01652705f, 
    -0.01339328f, 0.02460581f, -0.01764304f, -0.04147254f, 0.16221489f, 0.08026280f, 0.03675790f, 0.04781859f, 
    -0.15887107f, -0.06506358f, 0.07442467f, -0.00388107f, 0.13830814f, 0.12218898f, 0.09792478f, 0.00064945f, 
    0.15454921f, -0.15013121f, 0.34988967f, -0.09277541f, -0.06594858f, 0.07778674f, -0.13875361f, -0.08991001f, 
    0.07738595f, -0.00763108f, -0.08139738f, -0.08516797f, 0.16542608f, 0.12061546f, 0.02630202f, 0.02994226f, 
    0.10163413f, 0.14287415f, 0.03364617f, 0.08648159f, 0.02996179f, 0.01331375f, -0.04973669f, -0.11127403f, 
    0.05492887f, -0.06847903f, 0.07495150f, 0.36439982f, -0.06499549f, 0.04034915f, 0.07349404f, 0.05586019f, 
    -0.03700464f, 0.01240610f, -0.09481860f, -0.02751126f, 0.06003245f, -0.01452113f, 0.10193950f, 0.11648306f, 
    -0.01262925f, 0.05823458f, -0.17041507f, -0.17800921f, 0.04329360f, 0.04669483f, 0.00975830f, -0.07619769f, 
    0.15204179f, -0.12888819f, -0.13975541f, 0.12969129f, 0.03205405f, -0.16980687f, -0.04339661f, -0.11136539f, 
    0.07796794f, 0.03570276f, -0.01762951f, -0.02878294f, 0.10219920f, 0.05811913f, 0.16394918f, -0.13248083f, 
    -0.01398075f, -0.01607877f, -0.16007711f, -0.12053036f, 0.02533709f, -0.00066294f, -0.08055284f, 0.21860382f, 
    0.10059746f, 0.30109316f, 0.04349413f, 0.03444609f, -0.05717457f, -0.14805137f, -0.15846868f, -0.01882584f, 
    0.13240150f, 0.06884380f, -0.00601702f, 0.07902414f, -0.04806409f, 0.19731139f, -0.15639250f, -0.06169819f, 
    0.04131148f, -0.00295106f, 0.00306403f, -0.03120781f, 0.00590332f, 0.05998661f, -0.01932932f, -0.08988120f, 
    0.22176442f, -0.01557186f, 0.09073076f, -0.10974751f, -0.03209930f, -0.03263895f, -0.12381703f, 0.04426698f, 
    0.05344621f, 0.04118160f, 0.05734443f, -0.11949033f, -0.11944818f, -0.05478930f, -0.13386633f, 0.10554247f, 
    -0.08607951f, -0.06338245f, -0.06420291f, -0.09636455f, 0.09432408f, 0.03180873f, -0.11234681f, -0.00146417f, 
    -0.05142386f, 0.17321132f, 0.22816889f, 0.12501772f, 0.07261574f, 0.11873224f, 0.10987812f, 0.11910692f, 
    -0.16469236f, -0.07430671f, -0.04145086f, -0.05907428f, -0.10213908f, -0.12386507f, -0.04333264f, 0.02860299f, 
    -0.14259568f, 0.00158331f, 0.13415864f, -0.02987035f, -0.02617763f, 0.06976257f, 0.01163931f, -0.04197416f, 
    -0.22322944f, 0.06273516f, 0.10883091f, 0.27792040f, -0.04293854f, -0.12717636f, -0.07884853f, 0.09093849f, 
    -0.04393585f, -0.10982490f, 0.07498841f, 0.19368018f, 0.71582282f, -0.06034264f, 0.01086015f, 0.16712846f, 
    0.21462238f, -0.11612200f, 0.01186237f, -0.27188617f, -0.15651521f, 0.10538507f, -0.15598404f, 0.12540530f, 
    -0.06554598f, -0.05524708f, -0.02350480f, 0.08939036f, 0.10313585f, 0.00449245f, 0.09966846f, -0.06267182f, 
    0.08715104f, 0.00925344f, 0.03413737f, 0.06899654f, -0.08520219f, 0.11020266f, 0.15305313f, 0.00797037f, 
    -0.05272967f, 0.06554697f, -0.07318095f, -0.05676692f, 0.00596876f, -0.10571633f, 0.07888754f, -0.22103715f, 
    -0.06003173f, -0.06120826f, 0.05076949f, 0.27966988f, 0.04807685f, 0.06042147f, 0.04518692f, 0.09349763f, 
    -0.03307468f, -0.05893074f, -0.03084047f, 0.02831693f, 0.06564999f, 0.15540987f, -0.01695118f, -0.03032043f, 
    0.08061653f, 0.09720569f, 0.03168236f, 0.02713933f, -0.22843073f, -0.06811205f, -0.30349922f, -0.07306083f, 
    -0.23632914f, 0.16487141f, 0.24530722f, 0.01117374f, 0.01037029f, 0.01260078f, 0.08071350f, -0.05451856f, 
    -0.06193432f, -0.01652081f, -0.03058154f, 0.09631368f, 0.00577747f, 0.04767393f, -0.01455757f, 0.08228102f, 
    0.02344959f, -0.08164307f, -0.05825005f, 0.05799715f, -0.04991464f, -0.15360065f, 0.09243105f, -0.06483945f, 
    0.01892960f, -0.11617503f, 0.18592030f, 0.35091245f, 0.17486833f, 0.16309519f, -0.02303721f, 0.14995070f, 
    0.07928046f, 0.06504732f, 0.03535666f, 0.03645301f, 0.19525999f, 0.04855506f, 0.06914160f, 0.21498673f, 
    -0.05239417f, -0.00525129f, 0.04362561f, 0.10877711f, 0.09212811f, 0.03681396f, -0.01342858f, -0.00612232f, 
    0.22482459f, -0.20319521f, 0.03592783f, 0.16394165f, -0.01153136f, -0.02889879f, -0.01457923f, -0.14681582f, 
    0.08119889f, -0.03852012f, -0.00398508f, 0.18077147f, 0.21490474f, 0.07696255f, 0.22354124f, -0.11250217f, 
    0.03322090f, 0.07569246f, 0.08334320f, 0.00932746f, -0.06439906f, -0.04483660f, -0.12829769f, -0.08853041f, 
    0.02403290f, -0.02666713f, 0.15267852f, 0.08717724f, 0.02920398f, 0.00971468f, 0.11395217f, -0.02378727f, 
    -0.02022487f, -0.15041661f, -0.04058773f, -0.08925366f, -0.17573878f, 0.16105707f, 0.01431760f, 0.13794473f, 
    -0.04639354f, 0.11368657f, -0.11240631f, -0.11895895f, -0.06358873f, 0.20568778f, -0.04955916f, 0.02665925f, 
    0.03545460f, -0.03656705f, 0.13590255f, 0.01154335f, -0.02446776f, 0.02804949f, -0.06014133f, 0.05117831f, 
    0.03528494f, -0.05398214f, 0.00551120f, -0.12733075f, 0.12198165f, 0.08556971f, -0.10463636f, -0.06158146f, 
    -0.12133723f, -0.12681185f, -0.07498905f, -0.10313870f, -0.01412999f, -0.10334801f, -0.12562084f, -0.07698920f, 
    0.17056917f, 0.22679760f, 0.09492434f, -0.12937380f, -0.03947811f, 0.07428010f, -0.01278911f, -0.02980178f, 
    0.00595895f, -0.01515252f, -0.03420026f, 0.10378496f, 0.00367110f, -0.02038831f, 0.18585105f, 0.10500949f, 
    0.17733960f, -0.08037347f, 0.03664548f, -0.14485234f, 0.15873931f, 0.20258152f, 0.20542094f, -0.01400076f, 
    0.01060276f, -0.00964431f, -0.13288391f, -0.03096440f, 0.08642980f, 0.06100406f, -0.00888538f, -0.06999213f, 
    0.09560583f, 0.07309344f, 0.00306624f, 0.04188602f, -0.02257476f, -0.04855803f, -0.05625745f, 0.04034707f, 
    -0.11779694f, 0.09419781f, 0.10035774f, 0.04950317f, 0.01042114f, 0.00336177f, 0.18256105f, 0.02705099f, 
    -0.08819608f, 0.12799302f, 0.07498817f, 0.01756198f, -0.00744543f, 0.02761574f, -0.16120400f, -0.07718477f, 
    -0.07488245f, -0.22656447f, -0.08663618f, -0.30440235f, -0.09446304f, 0.00994684f, -0.02674040f, 0.05502419f, 
    0.08274886f, -0.05746756f, -0.05050567f, 0.15248053f, -0.21358559f, -0.28817376f, -0.22216554f, -0.43902501f, 
    0.07104543f, -0.20268780f, -0.11994810f, 0.00957736f, -0.06295195f, 0.14460865f, 0.11259296f, 0.06274975f, 
    -0.03557865f, -0.06850771f, 0.02699500f, 0.05791592f, -0.02961656f, 0.12558153f, -0.15554819f, -0.09782132f, 
    -0.08103202f, 0.12067021f, -0.00559009f, -0.08751945f, -0.13244005f, -0.07776739f, 0.11643837f, -0.03339028f, 
    0.28019008f, 0.09777443f, 0.32064947f, 0.17307261f, 0.02818923f, -0.14934324f, -0.00541676f, -0.05361344f, 
    0.12420839f, 0.00662182f, -0.11178744f, 0.03138871f, -0.16242270f, 0.15041147f, -0.01650153f, 0.06075692f, 
    -0.05117193f, -0.00044505f, -0.03915570f, 0.02308399f, 0.03566426f, 0.08162493f, 0.05573970f, 0.15377358f, 
    -0.05336804f, 0.15479410f, -0.02391923f, 0.12180142f, 0.03062988f, 0.05779020f, 0.03736629f, 0.08376317f, 
    0.16581047f, 0.11781154f, 0.06266526f, 0.02639501f, 0.11446938f, 0.10039875f, 0.07932491f, 0.11850738f, 
    0.08735172f, 0.03243341f, 0.01157507f, 0.00701785f, 0.00007000f, 0.24112546f, 0.14251244f, 0.11338898f, 
    -0.03608065f, 0.05620817f, 0.04706515f, -0.04644603f, 0.11107208f, 0.01213468f, 0.08027259f, -0.00214368f, 
    -0.23880479f, -0.19582278f, -0.08518813f, -0.14798024f, 0.02847824f, -0.03102931f, -0.06695255f, 0.24270579f, 
    -0.06418791f, 0.01065413f, 0.05422202f, -0.01184945f, 0.15504679f, 0.21760906f, 0.07867894f, 0.20192084f, 
    0.13158147f, -0.15671100f, 0.06503235f, 0.00612069f, -0.01434619f, 0.02550252f, 0.01654098f, 0.06478747f, 
    -0.09976739f, -0.25601575f, -0.25005022f, -0.11228473f, -0.12122008f, -0.07248801f, -0.02224167f, -0.01021705f, 
    -0.06687780f, 0.03207998f, 0.11652129f, 0.07728525f, 0.08355486f, -0.01057042f, 0.17289700f, 0.01853368f, 
    0.01320599f, -0.05626884f, -0.13067801f, 0.14617456f, -0.00592958f, -0.07213429f, 0.02108968f, 0.09526284f, 
    0.05467997f, 0.00657111f, 0.00539476f, 0.21977179f, 0.49289900f, 0.00444980f, 0.06001111f, 0.18260501f, 
    0.01261683f, -0.01390481f, 0.02428258f, -0.05341253f, 0.05414946f, 0.09484276f, 0.11545035f, 0.34945419f, 
    0.10148837f, 0.18228470f, -0.16214919f, -0.10890238f, 0.05986390f, -0.12534127f, 0.06713580f, -0.05843369f, 
    0.16717121f, 0.03721333f, 0.03730613f, 0.01534835f, -0.13283618f, -0.00954307f, -0.01056734f, -0.24304402f, 
    0.02984058f, -0.02879742f, -0.10798514f, -0.19184370f, -0.02186836f, -0.07557612f, -0.05707892f, -0.00877564f, 
    0.12612315f, 0.08059163f, -0.10097913f, -0.14029863f, 0.05468534f, 0.04078352f, -0.00170479f, 0.01104177f, 
    -0.06851950f, 0.02876475f, -0.11981986f, -0.06547737f, 0.27597961f, 0.42586857f, 0.09713269f, 0.02693280f, 
    0.01761678f, 0.07979461f, -0.02305745f, -0.05917435f, 0.00739552f, 0.16537786f, -0.13441126f, 0.10645359f, 
    -0.32976380f, 0.12266663f, 0.35762447f, -0.01531005f, -0.12079782f, -0.04087663f, 0.02509696f, -0.06696263f, 
    0.10140439f, 0.13517785f, 0.10042946f, 0.24049531f, -0.03194554f, 0.01106125f, 0.15410885f, -0.18721434f, 
    -0.08707821f, 0.06076162f, -0.04505017f, 0.07668563f, -0.06290239f, -0.02794449f, 0.06067517f, -0.21855558f, 
    0.12924844f, -0.12893546f, -0.10373770f, -0.07143103f, -0.20788331f, -0.01067492f, 0.03808298f, 0.07100230f, 
    0.05327738f, 0.09251916f, -0.08478209f, 0.15787756f, 0.09209892f, -0.06314459f, -0.20245036f, -0.23402438f, 
    0.09299971f, 0.01211849f, 0.02993950f, -0.05061162f, -0.18028608f, -0.16625254f, -0.24121936f, -0.18234009f, 
    0.10511048f, -0.04317312f, -0.03021648f, 0.09276631f, 0.11381901f, -0.03248869f, 0.04230065f, 0.04519552f, 
    0.08602395f, 0.12745853f, 0.17537957f, 0.23255746f, 0.04924819f, -0.07144180f, -0.04157792f, 0.08074141f, 
    -0.10696711f, -0.09214737f, -0.00859920f, -0.03104672f, 0.10718522f, 0.04093790f, 0.07535849f, 0.23175542f, 
    -0.24880515f, -0.29044411f, 0.12235018f, 0.13102990f, -0.07750683f, 0.21543069f, 0.04140544f, -0.04287487f, 
    -0.25735590f, -0.33499098f, -0.30158314f, -0.38559544f, -0.22490458f, 0.14317995f, 0.16668192f, -0.14592409f, 
    0.00804257f, -0.03780635f, 0.01061058f, -0.13111465f, -0.05157163f, 0.08022815f, -0.03534811f, 0.03693442f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16995172f, -0.00233845f, 0.05061584f, 0.07179922f, -0.04725469f, -0.04336046f, 0.13544385f, 0.14044553f, 
    -0.17893070f, 0.01857199f, 0.14347883f, -0.00996202f, 0.03446919f, -0.02941416f, -0.00542567f, 0.08595573f, 
    0.23857637f, -0.05379979f, -0.04434147f, 0.15070309f, 0.22763056f, -0.00160273f, 0.21480301f, 0.03327847f, 
    -0.01154816f, -0.01408000f, 0.08471495f, -0.01779727f, 0.18866213f, -0.02909564f, -0.09320636f, -0.05112503f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05993958f, -0.15194112f, 0.04697806f, -0.17060843f, -0.07570156f, 0.11704426f, -0.16579813f, 0.03721599f, 
    0.11678775f, -0.12529199f, -0.08156264f, 0.10715448f, -0.07783464f, -0.04504438f, -0.00219866f, -0.00654806f, 
    0.03432995f, -0.04540091f, -0.13974527f, -0.17846105f, -0.22173545f, 0.00273739f, -0.06731672f, 0.02678255f, 
    -0.14421953f, 0.09726202f, 0.03881612f, 0.14699535f, -0.08092462f, 0.16229057f, -0.23237632f, -0.18175662f, 
    -0.22351891f, 0.37510428f, -0.15492637f, 0.17702681f, -0.03911273f, 0.12814212f, -0.22324559f, 0.17131886f, 
    -0.28406024f, 0.05340791f, -0.17366980f, 0.06907837f, -0.31058070f, 0.12655653f, 0.14363633f, 0.01839175f, 
    0.20441012f, 0.10479161f, 0.40742779f, 0.12456515f, 0.20682737f, 0.01303123f, -0.01310747f, -0.13815977f, 
    0.07595322f, -0.16549340f, 0.09075113f, -0.28191063f, -0.31494799f, 0.06298546f, 0.13303289f, 0.11314400f, 
    -0.01725403f, 0.39658523f, -0.35406694f, 0.31757656f, -0.04286835f, -0.03596637f, -0.20491794f, -0.10844304f, 
    0.17833383f, 0.18757415f, 0.33467105f, 0.15542024f, -0.18215221f, 0.04144309f, -0.10833953f, -0.06838604f, 
    0.14797266f, 0.27871490f, 0.20364879f, 0.17273252f, 0.17383562f, -0.12154702f, 0.27296996f, 0.14862783f, 
    -0.14167614f, -0.19048767f, -0.13503399f, 0.36418495f, -0.00157804f, 0.09975430f, 0.29571080f, -0.15492618f, 
    -0.37701491f, 0.08679277f, 0.01508020f, -0.51724380f, -0.10138562f, 0.11128846f, -0.16906369f, 0.25219861f, 
    0.13371821f, 0.11114614f, -0.03807930f, -0.09051269f, -0.48919693f, 0.01095475f, -0.07601138f, 0.34253681f, 
    -0.08659980f, 0.11140287f, 0.15017945f, 0.06653100f, -0.07991392f, 0.02572456f, 0.02468634f, -0.00199637f, 
    -0.06447165f, -0.36270773f, -0.19917282f, -0.02082109f, 0.20031865f, 0.04557344f, -0.18435043f, -0.26989427f, 
    -0.03893106f, -0.15264499f, -0.20811677f, 0.18879567f, 0.03121393f, -0.01376083f, -0.21347815f, 0.18419050f, 
    0.02973755f, 0.36424112f, -0.02405875f, 0.02193362f, 0.32357290f, 0.11643247f, 0.12341157f, 0.14278966f, 
    0.09207762f, -0.35144624f, 0.29965663f, -0.15679266f, 0.18072882f, -0.30372134f, 0.17205739f, 0.05214418f, 
    0.16245940f, 0.48067245f, 0.28642622f, -0.13203467f, -0.03151423f, 0.15320255f, 0.29158145f, 0.13098848f, 
    0.25033924f, 0.00060419f, -0.41136286f, 0.22789508f, -0.28899091f, 0.03897339f, -0.07772736f, 0.37397617f, 
    -0.02772560f, -0.05286213f, 0.18275292f, 0.10359886f, -0.03674183f, 0.11248166f, 0.07574342f, 0.08436427f, 
    0.07285334f, 0.10235722f, -0.27270636f, -0.22907551f, 0.10066859f, -0.13186914f, 0.26904848f, -0.03293717f, 
    -0.01184650f, -0.05490339f, 0.17361625f, -0.01658499f, 0.00002213f, -0.04884841f, -0.43685362f, -0.03760786f, 
    0.07728912f, -0.34854764f, -0.16337596f, 0.09185350f, 0.10846040f, -0.08222370f, -0.20959878f, 0.10640352f, 
    0.52048391f, 0.31165913f, -0.56751078f, -0.15508594f, 0.39581254f, -0.10525192f, -0.01863666f, 0.02701283f, 
    0.08371305f, 0.05453274f, -0.07901257f, -0.18084864f, -0.05871322f, 0.36340246f, -0.40525663f, -0.14623943f, 
    -0.04168751f, 0.18143740f, 0.18093236f, 0.28995910f, 0.05481555f, 0.15660173f, 0.11499134f, 0.06913766f, 
    -0.03898592f, 0.27498466f, 0.02276914f, -0.25700793f, -0.37022176f, 0.04400380f, 0.16632964f, 0.00209625f, 
    0.25129220f, 0.17079091f, 0.20871232f, 0.05423399f, 0.13564831f, -0.03604974f, -0.02954319f, -0.14276507f, 
    -0.16020192f, 0.06904083f, 0.43521675f, 0.02034776f, 0.04654183f, -0.06060521f, -0.01053480f, -0.04538867f, 
    0.13418296f, 0.07880589f, -0.30701241f, 0.16535863f, -0.42607507f, -0.02104043f, 0.10198378f, 0.56001097f, 
    0.01462325f, -0.24477288f, 0.05538665f, 0.06732905f, -0.07077980f, -0.10600617f, -0.47118333f, 0.10959047f, 
    -0.03607437f, 0.17222397f, -0.25143832f, 0.04529515f, 0.14067291f, -0.08755403f, 0.13523431f, 0.22813262f, 
    0.04373171f, -0.30006510f, -0.23071739f, -0.06190090f, 0.02730414f, 0.10635934f, -0.25169179f, -0.05089826f, 
    -0.16754995f, 0.29312676f, -0.22654122f, -0.00082594f, 0.15583624f, -0.16312176f, -0.05057659f, -0.33979949f, 
    0.29819778f, 0.04251812f, 0.27917361f, -0.00733740f, -0.12408421f, 0.06362035f, 0.25413212f, 0.13685343f, 
    -0.26139939f, -0.09362841f, -0.06279722f, 0.03032817f, -0.22771615f, -0.12368519f, -0.15497573f, 0.14978462f, 
    0.26346767f, 0.19384894f, -0.11343794f, 0.06185831f, 0.09908625f, 0.35795489f, -0.05706115f, 0.12870525f, 
    -0.14888372f, -0.27391893f, -0.44103479f, -0.10784350f, 0.11375806f, 0.15255637f, -0.12476805f, -0.29222053f, 
    0.05495059f, 0.01467905f, 0.57383698f, 0.13543570f, 0.19819529f, -0.03773918f, 0.22804998f, -0.35277152f, 
    -0.11180139f, 0.09139927f, 0.09335455f, -0.07255080f, -0.14537241f, 0.17337160f, 0.15128008f, 0.34351707f, 
    0.16535901f, -0.04076247f, 0.10254132f, 0.19580300f, -0.02885236f, 0.08823089f, -0.05535779f, 0.16914807f, 
    0.04625184f, -0.11097181f, 0.13309897f, -0.21535352f, -0.25654903f, 0.09934473f, 0.01643849f, 0.21618937f, 
    0.09310765f, 0.29494253f, -0.35067827f, 0.35422972f, -0.03719224f, -0.10380740f, -0.08249991f, 0.09231063f, 
    0.05019560f, 0.08519692f, -0.26780245f, -0.06314589f, -0.23751624f, 0.05437975f, -0.13173938f, 0.15173642f, 
    0.27454293f, 0.30646831f, 0.24851629f, 0.17344153f, -0.13919266f, 0.04003671f, -0.17668374f, -0.07454648f, 
    0.01324226f, -0.15309437f, -0.09661728f, 0.45729271f, -0.00243886f, 0.01930954f, -0.07769337f, -0.14975798f, 
    0.14669377f, -0.07319292f, 0.07001780f, 0.10889068f, -0.13400376f, 0.08389515f, 0.03268634f, -0.09233732f, 
    -0.10599817f, 0.02163813f, -0.11730132f, -0.06709911f, 0.05918680f, -0.02543486f, -0.13926029f, -0.13865249f, 
    -0.14537205f, -0.06385757f, -0.14291516f, -0.16382720f, -0.11172197f, -0.02662328f, -0.05071457f, -0.08303205f, 
    -0.11588672f, 0.00190679f, -0.00155063f, 0.00050751f, -0.16396837f, -0.14300403f, -0.04090288f, -0.13294931f, 
    0.14155227f, -0.04443749f, 0.02191390f, -0.13599510f, 0.05947729f, 0.07857468f, 0.18844543f, -0.00862583f, 
    0.33952758f, -0.03829235f, -0.21167774f, 0.05474968f, 0.02096576f, 0.14080654f, 0.08157256f, 0.26801249f, 
    0.00087269f, 0.36075151f, 0.04808854f, -0.19436558f, -0.13273229f, 0.41680914f, -0.33581626f, -0.05953656f, 
    -0.14717981f, 0.04830549f, -0.03436913f, 0.17681739f, 0.01859459f, 0.01329252f, 0.22372980f, 0.03850457f, 
    0.18258315f, -0.24973619f, -0.00544036f, 0.22533907f, -0.03262223f, 0.09241796f, 0.03486238f, 0.32384315f, 
    -0.04170237f, -0.05676740f, -0.16792782f, 0.12895186f, -0.12488947f, 0.12513809f, 0.12628436f, 0.29765230f, 
    -0.03075199f, 0.13724221f, -0.48249060f, -0.03312537f, 0.00217028f, -0.11009832f, 0.09938382f, -0.06172098f, 
    -0.06886612f, 0.16550216f, 0.29404798f, 0.02014330f, 0.15895419f, -0.10936052f, -0.32379285f, -0.18614121f, 
    0.09788065f, -0.11526573f, 0.12391762f, -0.06426477f, -0.02741572f, 0.15875404f, 0.02970960f, 0.00412122f, 
    -0.26426867f, 0.16600725f, -0.00487927f, 0.00288539f, 0.24774405f, -0.06482672f, -0.04217918f, 0.37812677f, 
    -0.01537311f, -0.04704621f, -0.61388528f, -0.19534594f, -0.03772941f, 0.26401934f, -0.03219214f, 0.08215965f, 
    -0.01406152f, 0.34254080f, -0.21260703f, 0.14023869f, -0.04373045f, -0.16807674f, -0.36397260f, -0.43806976f, 
    -0.01005699f, 0.00281351f, 0.19371149f, -0.16677317f, -0.14903580f, -0.11315784f, 0.47930062f, -0.05047468f, 
    -0.05584617f, 0.21892287f, 0.22394784f, -0.16144373f, 0.24191888f, -0.13270684f, 0.05617196f, 0.26969936f, 
    0.15788676f, 0.25814721f, -0.02369816f, 0.04195626f, -0.24514870f, 0.16671473f, 0.00468094f, 0.00469041f, 
    -0.15317026f, -0.02856240f, -0.34437162f, -0.00153713f, -0.03549872f, 0.00005734f, 0.18174402f, 0.08535422f, 
    0.28081748f, -0.00052604f, 0.32896620f, -0.38568529f, -0.33988696f, -0.02455090f, 0.00331217f, 0.26107290f, 
    0.18499154f, 0.23212206f, 0.16348895f, 0.11655457f, -0.09091363f, -0.05082705f, -0.03841053f, 0.43437999f, 
    0.03994339f, 0.13825800f, -0.14794496f, -0.27184620f, -0.24445817f, 0.16872787f, -0.03302398f, 0.04245913f, 
    0.00199635f, 0.18599381f, 0.03045709f, 0.03823052f, -0.31550038f, -0.15340818f, -0.27128369f, 0.17588389f, 
    0.10808635f, -0.26155439f, 0.48789242f, -0.41230384f, -0.06108937f, -0.15355384f, 0.27205214f, 0.15314247f, 
    0.16420840f, -0.22195117f, 0.41410059f, -0.07003549f, 0.23765002f, 0.07264690f, 0.11696339f, 0.12890889f, 
    -0.16509248f, -0.17466292f, -0.11267202f, 0.29362914f, 0.12245283f, -0.20081151f, 0.13626130f, 0.04615460f, 
    -0.10997025f, 0.21172106f, -0.31146380f, -0.26922411f, 0.28827149f, 0.01504998f, -0.34947520f, 0.22655454f, 
    -0.10696481f, -0.16573882f, -0.10479640f, 0.23052676f, -0.04191159f, 0.08516711f, 0.36939400f, -0.24102792f, 
    -0.00964667f, -0.25073069f, -0.06536496f, 0.13920623f, -0.00833247f, -0.15304866f, -0.11239154f, -0.26556042f, 
    0.11825155f, -0.19292215f, 0.24065825f, -0.00588249f, 0.28888261f, 0.14345826f, 0.35786432f, -0.03925534f, 
    0.12945461f, -0.38488320f, 0.29922581f, -0.55151963f, 0.18108062f, 0.00471982f, -0.12663089f, -0.03840426f, 
    0.20774646f, 0.06927232f, 0.22364342f, 0.16192439f, 0.07350433f, -0.10496394f, 0.04830555f, -0.34709030f, 
    0.15813327f, -0.30670142f, 0.42515677f, 0.09011989f, 0.08408223f, 0.03390124f, 0.14176489f, -0.02862846f, 
    -0.18240464f, 0.08072708f, -0.05806288f, -0.10108844f, -0.10741378f, 0.20375581f, 0.23136869f, -0.06236127f, 
    -0.14391463f, -0.44875532f, 0.06511292f, 0.13810290f, 0.25951800f, 0.05815340f, 0.14712049f, 0.33673319f, 
    0.10860567f, 0.21179290f, 0.11246210f, -0.11923998f, -0.23465014f, 0.07835446f, 0.32903343f, 0.11508975f, 
    -0.11022398f, -0.30934992f, -0.19025460f, 0.00875451f, -0.09831854f, 0.11063667f, 0.16396324f, -0.07570509f, 
    -0.14454445f, 0.07311010f, 0.06802887f, 0.09393282f, 0.35926583f, -0.09247398f, 0.38579592f, -0.09956320f, 
    -0.18131419f, -0.28819761f, 0.00880705f, -0.38948098f, -0.05300752f, 0.03971593f, -0.09326193f, 0.00561987f, 
    -0.02875063f, 0.36844450f, -0.01540232f, 0.33006606f, 0.00701881f, 0.12264694f, -0.21260071f, -0.01181404f, 
    0.17107065f, 0.01519492f, 0.45160463f, -0.10198771f, -0.00319082f, 0.08078381f, -0.00410370f, -0.23216319f, 
    0.01739755f, -0.08906076f, 0.42008036f, 0.29649305f, 0.28537330f, -0.04213154f, -0.13163172f, 0.09053551f, 
    0.00629868f, 0.06467896f, -0.33090240f, 0.10112819f, -0.08882347f, 0.01015598f, 0.03637568f, 0.10842042f, 
    -0.05843173f, 0.16217831f, -0.14442626f, -0.06206851f, 0.09843849f, 0.12399291f, 0.22920805f, -0.17902473f, 
    -0.26606390f, -0.09981516f, -0.22370088f, 0.12602916f, -0.19818699f, 0.09341390f, 0.03148149f, 0.09281152f, 
    0.07430881f, 0.06733540f, -0.08147282f, -0.11358015f, 0.18199553f, -0.07082387f, -0.00618775f, 0.05884380f, 
    0.15634784f, -0.02371238f, 0.34137487f, -0.13846986f, -0.08184919f, -0.17061944f, 0.30579469f, 0.07577795f, 
    0.00688902f, -0.03471097f, 0.00737062f, 0.12330514f, -0.22929172f, 0.07879604f, 0.20124403f, -0.08326456f, 
    -0.24350700f, 0.26261836f, -0.61839753f, 0.10803974f, -0.11342663f, -0.15886991f, 0.06067397f, 0.04529908f, 
    0.25896683f, -0.13085055f, 0.26472363f, 0.20068505f, 0.07396168f, 0.36222658f, -0.04902118f, 0.11199203f, 
    -0.09618197f, 0.02211297f, 0.12901148f, -0.30629724f, -0.15226135f, -0.12938358f, 0.13470726f, -0.19731650f, 
    -0.07017815f, -0.02451742f, -0.02279158f, 0.07433729f, -0.15724622f, 0.01630832f, -0.19080189f, 0.09218488f, 
    -0.15717995f, -0.15761437f, -0.02779213f, -0.04827462f, 0.14824151f, -0.15702213f, 0.16263558f, -0.04003975f, 
    -0.00292605f, -0.09793379f, -0.09954022f, -0.14382909f, -0.11005123f, -0.06562707f, -0.13100904f, -0.14327441f, 
    0.15588304f, -0.05696731f, 0.05243489f, 0.03628218f, -0.12505862f, 0.04284103f, 0.03579966f, 0.15068063f, 
    0.02442481f, 0.34522104f, -0.35785130f, -0.50434595f, -0.64853412f, 0.02841056f, 0.31728518f, 0.27489001f, 
    0.24202780f, 0.12936608f, -0.07103670f, -0.17557079f, 0.19131081f, 0.09230469f, 0.13517602f, 0.03852806f, 
    -0.39259988f, 0.23764524f, 0.04580800f, -0.01949987f, -0.11926757f, 0.16191450f, 0.28845197f, 0.13278900f, 
    -0.07668313f, 0.14863332f, -0.02261461f, 0.04931475f, -0.35734192f, -0.09663006f, 0.16499673f, 0.17644703f, 
    0.27972737f, 0.33699715f, 0.06741898f, -0.15681134f, -0.08962439f, 0.11743923f, 0.18931140f, 0.14481607f, 
    -0.22723998f, -0.11186396f, 0.14784664f, -0.10099673f, -0.24202478f, -0.12626249f, -0.13546892f, -0.07405269f, 
    0.25710359f, 0.31142086f, -0.32898378f, 0.34693950f, 0.20534216f, 0.13211600f, 0.11235050f, -0.07506279f, 
    -0.00503499f, -0.21526556f, 0.02901912f, 0.08616930f, 0.22350325f, -0.06644458f, -0.05722618f, -0.34137541f, 
    0.29763535f, 0.19792613f, -0.13853319f, -0.30662870f, -0.14473565f, -0.13610716f, 0.20999829f, -0.04417121f, 
    -0.26271856f, 0.15291139f, 0.23258166f, 0.05355229f, 0.08733226f, -0.12023568f, 0.04904322f, 0.34178278f, 
    -0.30946732f, 0.22474638f, -0.33158740f, -0.11880686f, -0.02470326f, -0.26673678f, 0.35115811f, -0.06702425f, 
    0.07011674f, 0.03467337f, 0.32770473f, 0.12856801f, -0.35016578f, 0.16889328f, 0.24967693f, 0.06006765f, 
    0.04785119f, 0.40107343f, -0.23859359f, 0.25375235f, -0.14128996f, -0.12406801f, 0.09470116f, 0.08276106f, 
    -0.06034508f, 0.15250945f, 0.45671234f, -0.10280194f, -0.04525671f, -0.11045226f, -0.11905070f, -0.14076047f, 
    0.28322035f, 0.03218137f, -0.13907312f, 0.08661222f, 0.07566894f, -0.21618667f, 0.19448271f, 0.09082517f, 
    -0.10901584f, -0.13819456f, 0.21473461f, 0.14249784f, 0.05899258f, -0.00927857f, -0.01702432f, -0.00677733f, 
    0.10983551f, -0.17484927f, 0.24169931f, 0.09255348f, 0.15506315f, 0.16387938f, 0.23861246f, 0.27331501f, 
    -0.31993094f, 0.05205258f, -0.17316400f, 0.08436339f, 0.37120914f, -0.05273625f, 0.13893878f, -0.15272276f, 
    0.27504984f, -0.23546387f, -0.36468694f, 0.14482760f, -0.07337605f, -0.16357790f, 0.19606788f, 0.10155153f, 
    0.07619857f, 0.24502301f, 0.08737229f, 0.12815396f, 0.60887462f, 0.01780976f, -0.07131920f, -0.21282813f, 
    0.01755602f, 0.05259730f, 0.17016008f, 0.30567470f, 0.05719406f, -0.01580244f, 0.10839917f, -0.44506153f, 
    0.21344021f, -0.00539551f, 0.12054675f, 0.02873855f, -0.06109623f, -0.06333655f, -0.04264881f, -0.05049137f, 
    0.27968320f, -0.01153449f, 0.19735837f, 0.11948221f, -0.01157837f, 0.29355642f, -0.24605611f, 0.14223081f, 
    0.07868311f, 0.12372046f, -0.26977643f, 0.20799464f, 0.13367236f, -0.06890375f, 0.29055458f, -0.09690627f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01846202f, 0.01420247f, -0.04633158f, 0.08416425f, 0.22790667f, 0.22633766f, 0.07968386f, -0.00717540f, 
    -0.20716785f, 0.21334434f, 0.13786453f, 0.09800392f, -0.11263767f, -0.15393090f, 0.17409168f, -0.11194818f, 
    0.03616699f, 0.02783557f, 0.14261299f, 0.20232685f, 0.02778980f, 0.18628049f, 0.01172472f, -0.06373317f, 
    -0.03467024f, -0.05048965f, -0.15331039f, 0.04135111f, -0.03702164f, 0.15963928f, 0.07596286f, -0.17463204f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.02517893f, 0.06498423f, -0.55494857f, 0.03293804f, 0.04442635f, -0.01544077f, 0.31761679f, 0.07964669f, 
    0.18760759f, -0.31073904f, 0.13294326f, 0.04455540f, -0.12556937f, 0.20852381f, 0.08240440f, -0.04229652f, 
    -0.00690067f, 0.20972925f, 0.00920979f, -0.20054227f, -0.04326211f, -0.14490753f, -0.38921544f, 0.27743235f, 
    0.08714040f, -0.04622876f, 0.02318479f, -0.54122704f, -0.09259164f, -0.41760334f, -0.07765228f, -0.04142639f, 
    -0.13329391f, -0.00248106f, -0.17970061f, -0.18398328f, 0.25656548f, -0.14432636f, 0.24328978f, -0.76279432f, 
    0.49651828f, -0.11100160f, 0.07695481f, -0.06605585f, 0.03921555f, -0.08743832f, 0.07893195f, 0.40386754f, 
    -0.06173361f, -0.08229514f, -0.23812711f, 0.41317207f, -0.25192079f, 0.16705853f, -0.03694649f, -0.06743333f, 
    0.42464843f, -0.05574125f, -0.55356848f, -0.05451905f, -0.22509363f, 0.13555124f, 0.14448316f, 0.20840923f, 
    0.02442085f, -0.41570780f, -0.02487271f, 0.23396744f, 0.27036485f, -0.14205125f, -0.37799895f, 0.06982931f, 
    -0.10558512f, -0.43115816f, 0.25613728f, -0.13203749f, -0.10082991f, -0.31129745f, -0.04769320f, -0.51966262f, 
    0.09762202f, -0.13732371f, 0.13102303f, -0.40722036f, 0.11147608f, -0.61521697f, 0.19106774f, -0.23638815f, 
    -0.58934212f, -0.16632135f, -0.41641065f, -0.13337685f, 0.02931084f, 0.27177113f, 0.27889976f, 0.33534592f, 
    -0.14627621f, -0.08810631f, 0.21082097f, 0.05469782f, 0.09663863f, -0.13461088f, 0.09695767f, 0.24768342f, 
    -0.10896032f, -0.57313830f, -0.20860900f, 0.11679097f, 0.16602270f, 0.09010474f, -0.32642984f, -0.29929531f, 
    0.10999606f, 0.03587181f, -0.41523805f, -0.39893213f, 0.01098772f, -0.42233968f, 0.12067417f, -0.16188620f, 
    -0.42433798f, 0.10344083f, 0.21866868f, -0.25922468f, -0.05689923f, 0.13368766f, -0.23403971f, 0.14015275f, 
    -0.03263868f, 0.20257153f, -0.13448116f, 0.50343758f, -0.23631497f, -0.32858780f, -0.07618083f, 0.01437893f, 
    -0.50387138f, 0.09126565f, 0.16658968f, 0.08506180f, -0.07146525f, 0.15929610f, -0.18888840f, 0.06049002f, 
    0.28267449f, 0.12800978f, -0.03508254f, 0.18591832f, 0.07515683f, -0.32092029f, -0.55918539f, 0.10906772f, 
    -0.31930405f, -0.22057627f, 0.14114986f, -0.02593317f, 0.20920312f, -0.06021710f, -0.11604196f, 0.11175911f, 
    -0.12203348f, -0.41565993f, -0.09798446f, -0.17357039f, -0.07392723f, 0.48729023f, -0.10617271f, -0.52218485f, 
    -0.01400795f, 0.07213168f, 0.09787934f, 0.01859679f, -0.00073259f, -0.03554656f, 0.37865406f, 0.22553410f, 
    -0.12719828f, 0.14762400f, -0.11549260f, 0.01393876f, 0.04529791f, -0.26953524f, -0.40696213f, -0.07923449f, 
    -0.22708510f, 0.01402567f, -0.14227100f, 0.17065740f, 0.35245082f, 0.20687445f, 0.01924684f, -0.19549152f, 
    0.06509986f, -0.15286781f, -0.12636566f, -0.24921809f, -0.25430894f, -0.20307027f, -0.25463310f, -0.05957087f, 
    -0.03939671f, 0.13860111f, 0.25611773f, -0.35513800f, -0.18403681f, -0.82025826f, -0.26999801f, -0.31820327f, 
    -0.22067818f, -0.28815666f, 0.32772943f, 0.19941291f, 0.36718506f, 0.08658548f, 0.27795923f, -0.19996315f, 
    -0.51683754f, 0.09297763f, -0.77102000f, 0.16546074f, -0.39970967f, 0.06832116f, -0.09762792f, 0.21196179f, 
    -0.20320946f, -0.01128907f, 0.20761082f, -0.07755510f, 0.10907885f, 0.14781077f, -0.39968917f, 0.28695706f, 
    -0.14816162f, -0.36402166f, -0.12533078f, -0.17487800f, -0.09505623f, -0.22440806f, -0.27074462f, -0.28422862f, 
    -0.35558677f, -0.59723449f, -0.25439873f, -0.13375908f, 0.18674138f, 0.13963896f, 0.00988630f, -0.07669132f, 
    -0.49696094f, -0.03676401f, 0.37306356f, -0.13059480f, 0.38575649f, 0.08501069f, -0.18223330f, -0.36418879f, 
    0.15078448f, 0.05275740f, 0.21126407f, 0.23249808f, -0.01503499f, 0.48589167f, -0.23715717f, -0.32239592f, 
    0.02779464f, 0.05782290f, -0.58202302f, 0.39499703f, -0.15407282f, -0.30562669f, 0.14761120f, -0.23840837f, 
    -0.80704862f, -0.45574841f, -0.06983472f, -0.20487817f, -0.60527372f, -0.05034761f, 0.21048725f, -0.31439593f, 
    -0.45104921f, 0.05518872f, 0.07372170f, 0.23593472f, -0.30637437f, 0.09044521f, 0.09288848f, -0.32586080f, 
    -0.00131617f, -0.23040350f, -0.29519504f, -0.04189091f, -0.22798841f, -0.06063719f, -0.52353126f, 0.13369144f, 
    0.03104278f, 0.15894154f, -0.10113918f, -0.57014310f, -0.17920607f, -0.09689797f, 0.08095530f, -0.14265603f, 
    0.24190766f, 0.09252127f, 0.44087276f, 0.05230236f, -0.15090923f, 0.13785404f, -0.11502856f, -0.11284187f, 
    -0.02385629f, -0.23271942f, 0.32327569f, 0.07549042f, -0.01539771f, -0.16445878f, 0.10427626f, -0.33766603f, 
    0.00608160f, -0.70083946f, 0.18153314f, -0.18484236f, -0.48981798f, -0.13271295f, 0.35227761f, -0.49295023f, 
    -0.13411535f, 0.25617820f, -0.17789300f, 0.32371855f, -0.01313953f, 0.18145415f, -0.09729403f, -0.12003970f, 
    -0.08288851f, -0.26403376f, -0.47001550f, -0.21176957f, 0.41607624f, -0.42955658f, -0.03009016f, -0.49901816f, 
    -0.24547140f, 0.08398725f, -0.38489300f, 0.11883958f, -0.67249036f, 0.00406342f, 0.02985637f, 0.41724265f, 
    -0.14142857f, 0.20296717f, 0.14616840f, 0.06888199f, -0.26809624f, -0.34776887f, -0.25903556f, -0.01864976f, 
    0.10446505f, 0.28004333f, 0.29893616f, 0.24383241f, 0.13315515f, -0.02013871f, -0.35619447f, -0.09105219f, 
    -0.02547223f, 0.09980167f, -0.28698921f, -0.35678703f, -0.35740507f, -0.02463985f, 0.23939416f, -0.21584915f, 
    0.30906573f, 0.08767709f, -0.22723502f, 0.05563620f, -0.17728199f, 0.03535581f, -0.33134153f, 0.20410982f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06709086f, 0.06005710f, 0.19372886f, -0.05459507f, 0.03733663f, 0.02084301f, -0.04113346f, -0.13109681f, 
    0.28713876f, 0.04711546f, -0.09282818f, -0.13505602f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
