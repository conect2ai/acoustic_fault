#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.32171154f, 0.74579835f, 0.33019617f, -0.36815596f, 0.26484215f, -0.21305771f, -0.14951563f, -0.00281618f, 
    -0.06789588f, 0.62330180f, -0.47331792f, -0.23425618f, -0.84652144f, -0.56916183f, -0.04191956f, -0.13239785f, 
    -0.37516603f, 0.40603769f, -0.82923746f, -1.06100953f, 0.21278925f, 0.86613977f, 0.97792798f, 0.35774428f, 
    -0.29038322f, -0.42291316f, -0.10633877f, -1.15479505f, 0.74106854f, -0.45706412f, 0.59349650f, -0.12122694f, 
    -0.57728338f, 0.04942720f, -0.03221005f, -0.46311039f, 0.33001378f, -1.01096690f, 0.00818349f, -0.59855312f, 
    -0.34278643f, -0.63675916f, -0.32169044f, 0.13164316f, -0.55320573f, -0.36544928f, 0.10253749f, -0.42119849f, 
    -0.76900041f, -0.70750636f, -0.61100036f, 0.44158128f, 0.26592055f, -0.35114101f, 0.92216152f, -0.09188759f, 
    -0.90892661f, 0.74986255f, -0.02689540f, -0.56226599f, 0.09390248f, 0.12080326f, 0.24936108f, -0.39091522f, 
    -0.45808855f, -0.86015129f, 0.44886279f, -0.53629720f, 0.17196287f, -0.43475339f, -0.27694461f, -0.31487322f, 
    0.86063713f, 0.87982446f, -1.07480931f, -0.43941665f, -0.24047649f, 0.85373330f, -0.20140798f, 0.33071494f, 
    0.12486508f, 0.74963498f, -0.96422750f, 0.77667254f, 0.50081354f, -0.64232236f, 0.62192571f, 0.09475514f, 
    -0.08981774f, -0.17766309f, -0.23793712f, -1.37306499f, -0.61244237f, 0.08820812f, 0.59147888f, 0.06643268f, 
    -0.40121067f, 0.33818316f, 0.04700962f, -0.57793772f, 0.02055315f, -0.40207246f, 0.50371075f, -0.54084647f, 
    -0.58072931f, -0.42416552f, 0.51342505f, 0.72880137f, -0.13381647f, -0.48752609f, 0.64394403f, -0.89487213f, 
    -0.02828508f, 0.67361069f, 0.06712379f, 0.32052696f, -0.29727343f, 0.79130828f, 0.63233286f, 0.95234311f, 
    0.70295024f, -0.12929513f, 0.12971011f, -0.07994279f, -0.12732957f, -0.20093162f, -0.35285842f, 0.08742287f, 
    -0.70128566f, -0.34654814f, -0.31961334f, -0.69085509f, -0.42505506f, 0.21465826f, -0.05041009f, -0.84352964f, 
    -0.86033881f, -1.00764596f, -0.77997732f, -0.01024901f, 0.49115136f, 0.58877242f, 0.19131403f, 0.36982757f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12380258f, -0.11625376f, -0.07544933f, -0.08147304f, -0.01347206f, -0.18690361f, 0.18349673f, -0.00009637f, 
    -0.11213499f, 0.25130409f, 0.22487742f, 0.13438886f, 0.01409838f, 0.30215603f, 0.12202411f, 0.10425451f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.51742733f, -0.17621420f, -0.16938862f, -0.27770141f, -0.23730761f, 0.23159295f, 0.15118670f, 0.14507495f, 
    -0.15554166f, -0.10506544f, -0.13511519f, 0.04918203f, 0.00690960f, 0.13141949f, -0.00994429f, -0.02173864f, 
    -0.01614686f, 0.16512814f, -0.11796644f, -0.03880915f, 0.02612816f, 0.10439838f, -0.03960557f, -0.16113777f, 
    -0.07511760f, 0.06154362f, 0.14327866f, 0.04355734f, 0.17113252f, 0.11676304f, 0.00228722f, -0.01636936f, 
    -0.06302359f, 0.03234222f, -0.07299087f, 0.07018426f, 0.00784870f, 0.00124546f, -0.15052558f, 0.07763795f, 
    0.53940165f, 0.19708183f, 0.06013028f, -0.01007947f, 0.19312738f, -0.05735819f, -0.09794614f, -0.08146653f, 
    0.04461404f, 0.05541025f, 0.09328505f, 0.08983570f, 0.05580078f, -0.06990142f, -0.05044520f, 0.00799496f, 
    -0.08038843f, -0.04340043f, -0.04645852f, -0.01599376f, -0.53457814f, -0.13237247f, -0.10035462f, 0.17681277f, 
    0.17005578f, 0.01001176f, -0.00618535f, 0.03849628f, -0.11859696f, -0.01192477f, -0.05430366f, -0.00808259f, 
    0.04757770f, -0.05637598f, 0.00301589f, 0.07214883f, -0.05217120f, -0.02396282f, 0.09471577f, 0.14092818f, 
    0.17271760f, 0.00949008f, -0.01956135f, -0.13966130f, 0.09868470f, -0.13745935f, 0.10939759f, 0.01513141f, 
    0.02944999f, -0.05100475f, 0.03490372f, -0.02942225f, 0.06666882f, 0.09923272f, -0.03647789f, 0.01569399f, 
    0.13286117f, -0.04091734f, 0.04993255f, -0.19282837f, 0.21053426f, 0.11151514f, 0.11939938f, -0.14522892f, 
    -0.02233698f, 0.12948640f, -0.08937823f, 0.05762985f, -0.04946345f, 0.00535596f, 0.00029462f, 0.13249850f, 
    -0.06161413f, 0.03593612f, -0.05284216f, 0.05462989f, 0.06912687f, -0.04723321f, 0.00600938f, -0.18444236f, 
    -0.06562579f, -0.09049153f, 0.19648683f, -0.20551595f, 0.04830502f, 0.14944215f, -0.07494371f, 0.00567494f, 
    -0.12007675f, 0.11705066f, 0.17018723f, 0.03147930f, -0.03135109f, -0.05128357f, 0.07421632f, 0.08901809f, 
    0.01438551f, -0.05422413f, 0.06334998f, 0.01806408f, 0.00965250f, 0.35172290f, 0.33906412f, 0.02410905f, 
    0.05542923f, -0.07715999f, 0.06148856f, -0.07775442f, -0.00099535f, 0.03111367f, -0.05902614f, -0.02667287f, 
    -0.04365151f, 0.10513932f, 0.00408389f, 0.10670818f, -0.08119101f, -0.07697000f, -0.08927213f, -0.01563454f, 
    -0.27423328f, 0.20788364f, -0.00191754f, 0.07296910f, 0.03387410f, 0.17972668f, 0.01017123f, 0.05653872f, 
    0.11057699f, -0.03327115f, 0.08939977f, -0.03556722f, 0.07768324f, 0.00906437f, -0.06977113f, 0.13365859f, 
    0.05746257f, 0.07658570f, 0.06884224f, 0.16313776f, -0.20364203f, 0.13853063f, -0.19584037f, 0.00668177f, 
    -0.00286369f, 0.06220704f, -0.05577713f, 0.00822983f, 0.15466136f, -0.05352298f, -0.00968639f, -0.00274134f, 
    0.12369794f, -0.01144985f, 0.11361929f, 0.05055381f, -0.03297074f, 0.01501399f, 0.04821441f, 0.07189142f, 
    0.59163362f, -0.19818719f, 0.06844061f, -0.00962954f, 0.19293424f, -0.27637541f, 0.12705265f, 0.05999862f, 
    -0.01532626f, -0.02906168f, 0.00736136f, 0.04020505f, -0.11056315f, -0.00666091f, 0.01056651f, -0.06640644f, 
    0.11022852f, -0.01718540f, -0.01043910f, -0.05599406f, 0.15062439f, 0.22727390f, -0.11883625f, 0.06364786f, 
    -0.00323474f, 0.18393497f, -0.03442592f, 0.13224819f, 0.06708912f, 0.12461064f, -0.00727559f, 0.06045014f, 
    0.09397864f, -0.07020617f, -0.03775907f, -0.00434248f, 0.06011469f, 0.14338750f, 0.13723385f, 0.00927170f, 
    0.42392755f, 0.13984810f, -0.06945284f, -0.01202820f, 0.02346199f, 0.08162808f, -0.00865647f, -0.11337145f, 
    0.10760368f, -0.00136527f, -0.02345217f, 0.03656796f, -0.06022250f, 0.05623430f, 0.06260010f, 0.05365336f, 
    0.05404982f, 0.04804070f, -0.01705591f, 0.14857480f, -0.20273347f, -0.26831511f, -0.14716220f, -0.26050082f, 
    -0.33786920f, 0.17070648f, 0.17213710f, 0.04001074f, -0.08219837f, -0.04999730f, -0.01963522f, 0.00842231f, 
    0.01988531f, 0.05327987f, 0.00433085f, -0.01099155f, -0.11727548f, 0.03472524f, -0.09741561f, -0.04017487f, 
    -0.11034465f, 0.01965610f, -0.07546370f, -0.03682218f, 0.13094741f, 0.10909074f, -0.03969610f, 0.01016484f, 
    0.00844125f, -0.06456187f, -0.00910033f, 0.01309722f, -0.00841065f, -0.00725995f, -0.07247437f, -0.00367738f, 
    -0.06352297f, -0.11151754f, 0.00648991f, -0.02442509f, 0.43421823f, -0.14985584f, 0.22480002f, 0.03734858f, 
    -0.06487672f, -0.18193358f, -0.04311065f, -0.02441615f, -0.06248181f, 0.07808757f, -0.01692753f, 0.01676476f, 
    0.03739397f, -0.01332920f, 0.04410502f, 0.00467335f, 0.15148425f, 0.06031534f, 0.02670602f, 0.14599399f, 
    -0.43052435f, -0.27300757f, 0.23487206f, 0.09229313f, -0.24638917f, 0.00025328f, -0.01459162f, -0.05074526f, 
    0.00675479f, 0.05986027f, 0.02769570f, -0.02684485f, 0.03103786f, -0.04393956f, 0.14082837f, 0.05429840f, 
    0.03774893f, 0.00773428f, 0.07352902f, -0.07013984f, 0.20775886f, -0.00474124f, 0.10721104f, 0.26872417f, 
    0.09488037f, -0.03975644f, 0.08000143f, -0.06584489f, -0.10345694f, -0.00271677f, -0.00573840f, -0.09856679f, 
    0.01389393f, 0.12009126f, 0.10814893f, 0.05972403f, -0.04150534f, -0.10934583f, -0.11789056f, 0.01809611f, 
    -0.19483036f, 0.26026800f, 0.01947762f, 0.04725664f, 0.07219363f, 0.05482376f, 0.01407637f, 0.08240814f, 
    0.03984410f, -0.10702755f, 0.02125989f, -0.10236058f, 0.00683625f, 0.00513496f, -0.02235897f, 0.01706692f, 
    0.06162299f, 0.01396839f, 0.05344909f, 0.02914545f, -0.08314580f, -0.02405228f, 0.36909744f, 0.14849329f, 
    -0.25133649f, 0.07963918f, 0.02783323f, 0.10084079f, -0.01307652f, 0.03029335f, -0.03372340f, -0.01853638f, 
    0.01062838f, -0.00957037f, 0.00621772f, -0.05829685f, 0.10895523f, 0.05244576f, 0.03413836f, 0.01469811f, 
    0.05976679f, 0.00377329f, -0.19003767f, 0.32697949f, 0.01707563f, 0.08609313f, 0.01569843f, 0.04894965f, 
    0.12391464f, 0.08995978f, 0.00234656f, 0.03723707f, -0.06530955f, -0.04318711f, 0.13334163f, -0.08378463f, 
    -0.07538321f, 0.00200971f, -0.15990885f, -0.12039211f, 0.20139706f, -0.05472753f, 0.23681517f, 0.09577837f, 
    0.27690181f, 0.00156771f, -0.04812846f, -0.01467111f, 0.06493807f, -0.02668392f, -0.03929895f, 0.03063012f, 
    0.04568844f, 0.05618362f, 0.10465015f, -0.10925177f, -0.02359359f, 0.04581921f, -0.09661535f, 0.12556677f, 
    -0.27048916f, 0.19946140f, -0.22466961f, 0.09715086f, 0.20435169f, -0.16904750f, 0.11572647f, 0.03777313f, 
    0.02989333f, 0.02153133f, 0.03692568f, 0.08421922f, 0.10302722f, -0.00070410f, 0.02380405f, 0.08040236f, 
    0.00730985f, 0.13408744f, 0.02230162f, 0.10168435f, 0.04947446f, 0.07914066f, 0.03032150f, 0.18546468f, 
    0.10093252f, 0.06580960f, 0.12557244f, 0.12931308f, -0.00400812f, -0.00491651f, -0.06311093f, -0.00942179f, 
    -0.01353439f, 0.00022712f, -0.07776790f, 0.05768004f, -0.05554605f, -0.02000829f, -0.03254852f, 0.02461068f, 
    -0.07740077f, -0.14062929f, 0.06551646f, -0.02577770f, -0.00338876f, -0.09377252f, 0.02940531f, -0.09201968f, 
    -0.17971407f, 0.08967887f, -0.06544739f, -0.01830358f, -0.00940697f, 0.01777073f, 0.07136098f, 0.13763960f, 
    0.07748817f, 0.07977553f, -0.00454013f, 0.10630605f, -0.25516111f, -0.27117950f, 0.03969762f, 0.12826429f, 
    -0.07768302f, -0.00464219f, 0.01338506f, 0.00176270f, -0.02208117f, -0.06650360f, -0.03892373f, 0.06388744f, 
    -0.07141317f, 0.01365594f, -0.03588345f, -0.01292590f, -0.06002937f, -0.06677713f, -0.07789419f, 0.04288168f, 
    -0.33009404f, 0.15553674f, -0.01216391f, -0.07797023f, 0.21531282f, 0.05974166f, 0.06870259f, -0.06080769f, 
    0.06076729f, -0.02864508f, -0.02736264f, 0.13835157f, -0.08718686f, -0.13451248f, 0.05022112f, -0.01016495f, 
    -0.10096139f, -0.02289513f, 0.15559286f, -0.12331977f, -0.07771960f, 0.00213919f, -0.00854684f, 0.04472448f, 
    -0.04240922f, 0.03307446f, 0.05975575f, -0.04538215f, 0.02630898f, 0.12059942f, -0.05722348f, 0.04670612f, 
    0.03447811f, -0.07053261f, -0.03604000f, -0.00466643f, 0.07186044f, 0.05175342f, 0.05231887f, 0.01240635f, 
    0.49889183f, -0.17306858f, -0.03237085f, -0.04423112f, -0.19306242f, -0.05427203f, -0.00360936f, 0.02364078f, 
    0.01233526f, 0.03727811f, 0.04821649f, 0.11154468f, 0.06070578f, -0.08036887f, 0.00477248f, -0.02653122f, 
    0.18710463f, 0.07427225f, -0.08898663f, 0.03350387f, -0.17569293f, 0.08941008f, 0.11561754f, -0.00700353f, 
    -0.35616574f, 0.10143851f, 0.04072801f, 0.00579449f, -0.02984388f, 0.02319319f, -0.00881655f, 0.02175065f, 
    -0.03554487f, -0.02584758f, 0.05005006f, 0.04084053f, -0.14460705f, 0.12018812f, 0.01573030f, 0.02912314f, 
    0.01449413f, -0.10208311f, 0.19118844f, 0.14801255f, 0.05186051f, -0.00339804f, 0.11319321f, 0.02229818f, 
    0.09606003f, 0.03173552f, -0.04059618f, 0.09340763f, 0.01571139f, -0.02190544f, -0.01066338f, -0.00713328f, 
    -0.02751699f, -0.02307623f, 0.07684994f, -0.05985856f, -0.23082532f, -0.12159795f, -0.08475035f, 0.04010975f, 
    0.14816685f, 0.11010205f, 0.14165229f, -0.03240332f, 0.17911980f, 0.03125519f, -0.01867357f, 0.13955936f, 
    -0.15951046f, -0.02356908f, -0.13961318f, -0.11314518f, 0.04465623f, 0.05022784f, -0.15146436f, 0.11202755f, 
    -0.03887796f, -0.03203791f, 0.02084357f, -0.05422982f, -0.00019584f, -0.05464816f, 0.00326693f, -0.03702391f, 
    0.03749895f, 0.02954336f, -0.00283199f, 0.03807845f, -0.04010990f, 0.00827722f, 0.04335734f, 0.02375575f, 
    -0.01668898f, -0.05226504f, 0.04056745f, -0.02292760f, 0.01593202f, 0.01734204f, -0.02562938f, -0.00604516f, 
    -0.05046518f, 0.00791827f, -0.02981017f, 0.04333546f, -0.01420098f, 0.03731098f, -0.00788822f, 0.03717710f, 
    0.03853210f, 0.00706121f, -0.05239833f, -0.01139545f, 0.03241185f, 0.01135894f, 0.02502088f, 0.03384947f, 
    0.01150606f, -0.03723527f, -0.05719085f, 0.00208652f, -0.05239405f, 0.02077933f, 0.03701533f, -0.02143040f, 
    -0.05198596f, -0.03149573f, -0.05127960f, -0.05270793f, 0.01799045f, 0.02843530f, -0.01729618f, 0.04371697f, 
    -0.04817946f, -0.00806969f, -0.01653663f, 0.01135503f, -0.04534423f, -0.01144712f, -0.04712319f, -0.01367497f, 
    -0.01275911f, -0.01008175f, -0.04509529f, 0.00917028f, -0.00678751f, -0.00710662f, 0.01963725f, -0.01870774f, 
    -0.00951611f, -0.03491378f, -0.01110374f, -0.02149786f, 0.02812748f, -0.02534278f, 0.04343612f, 0.01421358f, 
    0.01998536f, 0.02934147f, -0.00528925f, 0.02040228f, -0.06014987f, 0.04906673f, -0.01553266f, 0.03404446f, 
    -0.05087646f, 0.00840025f, -0.05066457f, -0.02273887f, 0.04709527f, -0.04545191f, -0.02566114f, 0.00537620f, 
    0.03689456f, 0.03881652f, 0.02139906f, 0.00604782f, -0.00015732f, -0.05586639f, 0.04474873f, 0.03924876f, 
    0.02991315f, -0.05301597f, 0.01216235f, -0.04223022f, 0.04007152f, -0.04693373f, -0.01368474f, 0.04688799f, 
    -0.02068604f, -0.03457254f, -0.03996880f, -0.04655885f, 0.01685692f, -0.04566396f, 0.01855583f, 0.04860334f, 
    -0.04070495f, 0.00068490f, 0.02725425f, 0.04387815f, -0.05517849f, 0.02434893f, -0.03218104f, -0.02585481f, 
    -0.04159293f, 0.01445421f, 0.00039664f, 0.04037913f, -0.02422973f, -0.04867025f, -0.01014614f, -0.06081577f, 
    0.01887007f, -0.02373562f, -0.02630452f, -0.00635009f, -0.02550122f, 0.01711931f, -0.05242493f, -0.04814889f, 
    0.00854852f, -0.03154105f, 0.02361574f, -0.03185052f, 0.00962450f, -0.03636263f, -0.00146141f, -0.05278695f, 
    0.02141697f, -0.01909448f, -0.03679883f, -0.01692592f, -0.00676804f, -0.02557509f, 0.04766894f, -0.05538955f, 
    -0.05309680f, -0.02144138f, -0.05877578f, 0.00689898f, 0.00449592f, 0.03287643f, -0.00677624f, 0.01603631f, 
    -0.04987383f, -0.01469276f, -0.02774477f, 0.03970081f, -0.03081011f, -0.02788291f, -0.05064459f, -0.04906492f, 
    -0.01860973f, 0.00441263f, -0.04069289f, -0.00496377f, 0.02525492f, -0.01769046f, -0.01098776f, -0.02482051f, 
    0.03443999f, -0.01803977f, -0.04601287f, -0.00495220f, -0.00927809f, -0.06122156f, -0.02948142f, 0.01565433f, 
    -0.04316514f, -0.02290012f, -0.05260734f, -0.02947229f, -0.05925796f, 0.02237700f, 0.02728570f, -0.00666506f, 
    -0.06103760f, 0.03967526f, -0.02455863f, 0.03634504f, -0.00223388f, 0.04303234f, 0.00939511f, -0.04420675f, 
    0.03061218f, -0.05578814f, -0.02784203f, 0.02804668f, -0.01336972f, 0.03621512f, -0.03719321f, -0.00813956f, 
    0.04125001f, -0.05111151f, -0.01980336f, -0.03507376f, -0.05874777f, 0.01931388f, -0.01755118f, 0.01403178f, 
    -0.00821520f, -0.00422496f, 0.04644931f, -0.04599770f, -0.04859427f, -0.05215769f, -0.00210547f, -0.02058815f, 
    -0.05289116f, 0.01467827f, -0.03808967f, 0.03006698f, -0.03446256f, 0.02915863f, 0.02744251f, 0.04139382f, 
    0.04310777f, 0.02398299f, -0.01676470f, 0.01087971f, -0.03892311f, 0.00185215f, -0.00236225f, -0.00367226f, 
    0.00674559f, -0.02394457f, 0.04817024f, 0.03736676f, -0.00398232f, -0.04059885f, -0.02482526f, -0.03889408f, 
    -0.02015422f, 0.04149834f, 0.03234844f, -0.05345490f, 0.01848784f, 0.00278182f, -0.01201528f, 0.04875971f, 
    -0.02517371f, 0.04060109f, -0.03621702f, 0.01496730f, -0.03504260f, -0.00781423f, -0.04539182f, -0.05630541f, 
    -0.00393852f, 0.02594308f, 0.01936439f, -0.04425744f, -0.00886364f, -0.05060450f, -0.04868008f, -0.01285914f, 
    0.02800482f, -0.01277692f, -0.00677688f, -0.02542920f, 0.02273247f, 0.03053882f, 0.04134212f, 0.01566902f, 
    -0.03626105f, -0.04108058f, 0.02917399f, 0.02065509f, 0.03962360f, -0.01028047f, 0.00250244f, 0.01529528f, 
    0.00409654f, -0.01024439f, -0.03806591f, 0.00796849f, 0.03530886f, -0.04720003f, 0.01300131f, 0.02318081f, 
    0.03715910f, 0.00047388f, 0.04932035f, -0.00330266f, 0.01902962f, -0.05907732f, 0.03022691f, 0.05393752f, 
    -0.01528887f, -0.01352430f, 0.00651052f, -0.02105278f, -0.04599159f, -0.01616073f, 0.02483364f, 0.00328381f, 
    -0.03635468f, -0.01577897f, -0.00130793f, -0.03689976f, 0.04444343f, -0.04335691f, -0.03320515f, -0.04462463f, 
    -0.01319692f, -0.00150447f, 0.00882388f, -0.01679801f, -0.02916259f, -0.05999516f, -0.04550714f, 0.02019235f, 
    0.02781170f, 0.00710937f, -0.04391553f, 0.03568467f, -0.01975712f, 0.02544713f, 0.01096678f, -0.06277235f, 
    -0.02868920f, 0.04444588f, 0.03912996f, -0.04878073f, 0.01333083f, -0.04647233f, -0.01239466f, -0.00891102f, 
    -0.01321761f, 0.04958587f, 0.02729756f, 0.01850287f, -0.00555809f, -0.03801247f, 0.02270911f, 0.03895852f, 
    -0.04456175f, 0.00753808f, 0.04082281f, -0.03901096f, -0.03527820f, 0.04290933f, 0.01625512f, -0.03652336f, 
    0.03877062f, 0.01718130f, 0.05490253f, 0.02141167f, -0.04178056f, 0.03141469f, 0.02774391f, 0.03128073f, 
    0.05234831f, 0.03753750f, 0.01402756f, -0.04059673f, 0.02050061f, -0.04188027f, -0.04299853f, -0.04176215f, 
    0.01523064f, -0.06361544f, 0.00678617f, -0.03388550f, 0.02435469f, 0.00262111f, -0.04742876f, 0.00214769f, 
    0.02305761f, -0.04430170f, -0.01521006f, 0.01654842f, -0.01952976f, 0.02646637f, -0.02201972f, -0.01292086f, 
    -0.03172966f, -0.05143122f, 0.00248216f, -0.04673046f, 0.01982374f, 0.03169915f, -0.02452474f, 0.01714304f, 
    -0.04206511f, -0.03847123f, -0.01973153f, -0.02400331f, -0.00387531f, 0.01866220f, -0.05712634f, 0.02691180f, 
    0.05335843f, 0.02391739f, 0.01289018f, 0.04164284f, 0.05143637f, 0.04592395f, -0.01290859f, 0.03270396f, 
    0.03759721f, 0.04605658f, -0.04934956f, 0.02226770f, -0.01272157f, 0.01736407f, 0.04143068f, 0.00883109f, 
    -0.04495881f, 0.03776833f, -0.04973237f, 0.04986501f, -0.01150743f, -0.02493998f, -0.00014795f, 0.04024905f, 
    0.04407610f, -0.05963605f, -0.03713100f, -0.00608357f, -0.01784216f, -0.00757176f, 0.02927593f, -0.03397023f, 
    0.01699842f, -0.05937695f, -0.00612519f, -0.02849224f, 0.02330774f, -0.02618528f, 0.00188403f, -0.04058908f, 
    -0.02075427f, -0.05257057f, 0.02058072f, 0.04007613f, 0.02570640f, -0.00176465f, 0.01581861f, -0.01070195f, 
    0.04122480f, -0.04286044f, 0.04009734f, -0.05020138f, -0.03275361f, 0.00069405f, 0.02449061f, -0.04019965f, 
    -0.03419941f, -0.03175688f, 0.03581545f, -0.05007089f, -0.04776099f, 0.02728382f, -0.00853487f, -0.00785338f, 
    -0.06218496f, 0.02904982f, 0.03018174f, -0.03696319f, -0.03856157f, -0.00031932f, -0.03535222f, 0.03500247f, 
    -0.04745656f, 0.01404266f, -0.03937695f, 0.00755999f, 0.02306882f, -0.05788958f, -0.01053759f, -0.04719402f, 
    0.01220614f, -0.05184536f, -0.04563257f, -0.03624050f, -0.03600112f, -0.05760630f, 0.02176724f, -0.03148900f, 
    0.04163027f, 0.01727537f, 0.03022720f, -0.00359215f, 0.02638042f, -0.03084082f, -0.03002660f, 0.00142135f, 
    -0.05253020f, 0.04015351f, -0.04172302f, 0.00273957f, 0.01264008f, -0.01024944f, -0.01340150f, -0.05240942f, 
    -0.03502896f, -0.05748805f, -0.05329532f, 0.00395092f, 0.01597054f, -0.03559003f, 0.03224966f, -0.01480027f, 
    -0.01296800f, 0.01338662f, -0.03870832f, 0.04892904f, -0.01244316f, -0.05927823f, 0.04567274f, 0.01363757f, 
    0.01858666f, -0.04472278f, -0.06803264f, 0.04267631f, -0.01235809f, -0.00747084f, -0.01303879f, 0.02071928f, 
    0.02817187f, -0.02537200f, -0.03852722f, 0.02392379f, -0.03067533f, 0.02399491f, -0.04590798f, 0.02185953f, 
    -0.02831982f, 0.04115265f, 0.00898551f, 0.02957762f, 0.02668644f, 0.02145006f, -0.02290563f, 0.04470702f, 
    0.02260818f, -0.04657763f, -0.05980097f, 0.03588319f, 0.03255241f, 0.01980456f, -0.01090982f, -0.00218282f, 
    -0.04629909f, 0.00995256f, -0.05959950f, 0.03650682f, -0.03836961f, 0.04355324f, -0.01273291f, -0.00632697f, 
    -0.04365291f, -0.04432458f, 0.01671161f, -0.05970653f, -0.02775495f, 0.02922486f, -0.06402698f, -0.01411300f, 
    0.03531598f, 0.00215379f, 0.01508722f, -0.01453470f, -0.04040673f, 0.02185781f, 0.04720443f, -0.04736821f, 
    -0.04738259f, 0.03624719f, 0.02357374f, 0.01119981f, 0.02076212f, 0.04409808f, 0.01730940f, 0.00852659f, 
    0.00440996f, 0.00849545f, -0.00840986f, -0.02723735f, -0.01917759f, 0.04163348f, 0.02351616f, -0.03750179f, 
    0.04658594f, -0.00058313f, -0.05111230f, 0.01700784f, -0.04642947f, -0.03894788f, 0.00122833f, 0.01749507f, 
    -0.05151012f, 0.04536453f, -0.06211828f, -0.02290873f, -0.05208979f, -0.04535523f, -0.04729062f, -0.02516115f, 
    -0.04672772f, 0.05244011f, -0.04441070f, -0.04580076f, 0.02495129f, -0.04413376f, -0.04772660f, -0.00506166f, 
    -0.05802982f, -0.00652026f, -0.01724764f, -0.02457974f, 0.00273445f, 0.00932024f, -0.04545057f, 0.04061452f, 
    0.04655851f, -0.02174474f, -0.01517490f, -0.00326991f, 0.03420091f, -0.03168403f, -0.03289207f, -0.01325991f, 
    0.05719142f, -0.00114713f, -0.02284099f, 0.03716694f, -0.02573813f, -0.03719000f, 0.01221693f, -0.00420199f, 
    0.04186086f, -0.04709812f, 0.04818314f, 0.03510495f, -0.01924728f, -0.05987254f, 0.02637510f, 0.01663554f, 
    -0.00751581f, -0.00195201f, -0.01849855f, 0.01518613f, -0.01209021f, -0.05679314f, -0.04125958f, 0.01551116f, 
    -0.05122116f, 0.01329890f, -0.03347655f, -0.03501956f, 0.00971532f, 0.03024308f, 0.00902457f, -0.04435852f, 
    -0.03755776f, 0.02695295f, -0.03086260f, 0.03487996f, 0.00732848f, -0.05257181f, -0.04274076f, 0.02637667f, 
    -0.01027158f, -0.05492124f, 0.01455608f, 0.05211750f, -0.01291677f, -0.05658686f, -0.04831374f, 0.01411428f, 
    -0.05815859f, 0.04203286f, -0.02668726f, -0.02318082f, -0.05597809f, 0.04095128f, -0.04742001f, -0.01902126f, 
    0.03896349f, -0.04071847f, -0.05970140f, 0.03513961f, -0.00733808f, -0.05696932f, -0.04341377f, -0.00728168f, 
    0.03707276f, 0.04239852f, -0.04144289f, -0.01787331f, 0.02603531f, -0.05881452f, -0.01974794f, 0.02019667f, 
    -0.01895388f, -0.03930633f, 0.02844017f, 0.02642837f, -0.01476237f, 0.01554220f, -0.05944600f, 0.00217032f, 
    0.01639283f, 0.02569176f, 0.04208788f, 0.03757673f, -0.00862025f, 0.02847666f, 0.02791874f, -0.00155001f, 
    -0.05237702f, -0.05496632f, 0.04210507f, -0.01106624f, -0.00626998f, 0.04557300f, 0.00432968f, -0.05528045f, 
    0.01478283f, -0.02798770f, -0.00044718f, -0.02053648f, -0.00502895f, 0.00397376f, -0.03014554f, -0.02462769f, 
    0.00814917f, -0.04623526f, -0.05418199f, 0.02845794f, -0.01461168f, 0.01934718f, -0.04828548f, 0.01190694f, 
    -0.03045023f, 0.02377205f, -0.04670407f, -0.01090260f, -0.03793393f, -0.05060809f, 0.00641218f, -0.00398004f, 
    -0.05281004f, -0.03190409f, 0.02442214f, 0.03296728f, 0.04099233f, 0.02180699f, -0.04480309f, -0.04246585f, 
    0.02192538f, -0.02633565f, -0.02443955f, 0.00570905f, -0.02734730f, -0.01517560f, 0.03576659f, -0.02005501f, 
    0.01293617f, 0.03554061f, -0.04018667f, -0.01245771f, 0.02897075f, 0.04153317f, 0.00037492f, 0.02692805f, 
    -0.03487778f, -0.04887051f, 0.02339229f, 0.02575124f, -0.03088759f, -0.03897082f, -0.01994857f, 0.01448197f, 
    0.04024200f, 0.00379135f, -0.03825684f, -0.01045420f, -0.01600248f, -0.05382771f, -0.04489229f, 0.01087352f, 
    -0.02303928f, -0.01445374f, -0.02289054f, -0.04416827f, -0.05437917f, -0.05860713f, 0.02487476f, -0.01825496f, 
    -0.01458029f, 0.02814924f, 0.04311230f, 0.00833069f, -0.02320511f, 0.00724847f, 0.01396181f, -0.05765956f, 
    0.02872054f, -0.03977811f, -0.02833831f, -0.05196199f, -0.03483650f, -0.01727276f, 0.01088644f, 0.04180865f, 
    -0.00350535f, 0.01067006f, 0.02691747f, -0.04953902f, -0.03905676f, 0.01886385f, 0.00890710f, -0.03994047f, 
    -0.02783407f, 0.00359105f, -0.00768775f, -0.01189345f, -0.00616745f, 0.00727344f, -0.04620979f, -0.00947961f, 
    0.03394489f, -0.01396951f, 0.03893817f, 0.01497648f, -0.05043694f, -0.06004445f, -0.01503130f, -0.03756368f, 
    0.00719268f, 0.04169932f, 0.01273493f, 0.00956802f, 0.02682065f, 0.00293917f, -0.06270508f, 0.00692198f, 
    -0.01438504f, 0.02704670f, 0.00028941f, 0.03198007f, 0.00361080f, -0.00302336f, -0.01110471f, -0.05745580f, 
    0.00190673f, -0.00029607f, -0.04824294f, -0.03415964f, -0.03532290f, 0.02126926f, -0.02907666f, -0.02876549f, 
    -0.05706718f, 0.02411361f, -0.00973166f, -0.02141252f, -0.00302965f, 0.00204279f, 0.01480156f, 0.00989849f, 
    -0.03054584f, -0.04286085f, 0.03507015f, -0.01237267f, -0.03523362f, 0.03515778f, 0.02531447f, -0.02957277f, 
    -0.04630377f, 0.00939023f, 0.02460091f, -0.04335023f, 0.03451889f, -0.01956340f, -0.02561283f, -0.00371057f, 
    0.02011471f, 0.00355450f, -0.00614657f, 0.02615992f, 0.02262337f, 0.02930373f, 0.00882081f, 0.03006247f, 
    -0.02936339f, -0.02333905f, -0.04792607f, -0.02848938f, 0.04658959f, 0.00413157f, -0.04703056f, -0.00551200f, 
    0.03499565f, -0.06085084f, 0.00093599f, 0.03962662f, -0.01548437f, 0.03627306f, 0.00152421f, -0.05921343f, 
    -0.00452030f, 0.03683942f, -0.03279901f, 0.02784318f, 0.03111962f, -0.05547699f, 0.04333142f, -0.02082319f, 
    -0.01069405f, -0.01229837f, -0.04086912f, -0.03242132f, 0.02464001f, -0.04956444f, 0.01272950f, -0.05629891f, 
    0.03661866f, -0.00341121f, 0.03688522f, 0.03887469f, -0.00897114f, -0.06010397f, 0.04481417f, 0.00332469f, 
    -0.04600343f, -0.05961147f, 0.01045864f, -0.03318718f, 0.00387742f, -0.00135186f, 0.01158978f, 0.02757110f, 
    -0.21357432f, -0.36442280f, -0.14655209f, 0.14186141f, -0.07902454f, 0.09247094f, 0.15284002f, -0.05053815f, 
    -0.18274204f, -0.02063312f, 0.24191763f, 0.08135445f, 0.02934970f, 0.06258361f, 0.18876594f, 0.00560938f, 
    0.02604144f, 0.05232468f, 0.01482179f, -0.02333504f, -0.19450839f, 0.16259897f, 0.05188971f, 0.00034131f, 
    0.06846257f, 0.02589198f, -0.03537143f, 0.02260019f, 0.02805004f, -0.06777308f, 0.18455324f, 0.00984566f, 
    -0.04338407f, 0.10705560f, 0.02141219f, 0.11733142f, 0.09040727f, 0.06959023f, -0.15074126f, 0.05280674f, 
    -0.35352954f, 0.14502309f, -0.14176375f, 0.01812596f, 0.06784789f, -0.13658738f, -0.12276019f, 0.06823807f, 
    0.06976255f, 0.01565715f, -0.07320395f, -0.10577462f, 0.00769055f, -0.12414546f, 0.02465427f, 0.02543969f, 
    -0.10041271f, 0.05553741f, -0.00104398f, -0.00577676f, -0.31855339f, -0.02266927f, -0.09390271f, 0.09605307f, 
    -0.16148423f, -0.07652496f, -0.01979893f, -0.01408494f, 0.06967153f, -0.07133529f, -0.05743086f, -0.06696022f, 
    -0.01488638f, 0.04171546f, 0.08335731f, -0.00770123f, 0.06172218f, -0.07548653f, -0.02096172f, 0.03714261f, 
    -0.34559885f, 0.11781044f, -0.00753746f, -0.04629970f, 0.19108629f, 0.12456945f, -0.09393522f, -0.07371885f, 
    -0.01984717f, -0.05393657f, 0.03674877f, 0.05012926f, 0.01137110f, 0.00263680f, 0.05811800f, -0.03227446f, 
    0.01605906f, -0.12142403f, -0.11902922f, -0.13609245f, 0.30885547f, 0.26536843f, 0.04894409f, -0.10600433f, 
    0.00324891f, -0.04946377f, -0.03484606f, 0.05032105f, 0.13749692f, -0.11696321f, -0.08761472f, 0.05822350f, 
    -0.09912070f, 0.07313953f, 0.12691990f, 0.13245207f, 0.04962005f, -0.05467895f, -0.05088980f, -0.01553265f, 
    0.07180911f, 0.46723482f, 0.11382463f, 0.05768094f, -0.02968277f, 0.16107494f, -0.02358928f, 0.04369108f, 
    -0.01964628f, 0.10669932f, 0.10049855f, -0.00615606f, 0.07798557f, 0.05378989f, 0.04015185f, -0.04644882f, 
    0.13714175f, -0.05957616f, 0.17914854f, 0.03662264f, 0.21275996f, 0.04755519f, 0.03477686f, -0.13748007f, 
    0.05898651f, 0.06495099f, 0.04154047f, 0.04195473f, -0.09536113f, 0.07008791f, -0.03838948f, 0.11172628f, 
    0.08701033f, -0.09183621f, 0.00833586f, -0.04880789f, 0.03428391f, -0.05899174f, -0.04628648f, 0.07321282f, 
    -0.18067089f, 0.08125442f, -0.20150603f, 0.21402708f, 0.05944519f, 0.11376552f, 0.16509216f, 0.00141587f, 
    -0.02510391f, -0.02739837f, 0.09739577f, 0.01525877f, -0.05059550f, 0.12431238f, 0.17786863f, 0.08752639f, 
    0.02501212f, -0.04754468f, 0.09796457f, 0.09260746f, -0.09725974f, -0.02912420f, -0.14549054f, 0.04072016f, 
    0.02675195f, 0.05905627f, 0.05431949f, -0.05941775f, 0.03258104f, -0.00116274f, 0.20257849f, 0.00549042f, 
    0.02752252f, 0.09676149f, -0.03630546f, 0.07203317f, 0.01422886f, 0.04167810f, 0.00296792f, 0.00528842f, 
    -0.18426141f, 0.24637021f, -0.30006877f, 0.21344453f, -0.17623670f, 0.05247721f, -0.12039303f, 0.12261833f, 
    -0.04991941f, -0.00866978f, -0.04871605f, 0.04801851f, 0.00434600f, -0.13299227f, 0.04353692f, -0.00790056f, 
    0.04621656f, -0.01373756f, 0.07436053f, -0.09162728f, 0.09222472f, 0.08755112f, -0.16383211f, 0.14228551f, 
    -0.12891716f, -0.02771923f, 0.16460584f, 0.04829916f, 0.16866124f, 0.10003456f, 0.11053779f, 0.10235125f, 
    0.02796650f, 0.07061913f, 0.03906154f, 0.06165865f, -0.01139432f, 0.07135609f, 0.05300132f, 0.08232351f, 
    -0.19848314f, 0.14726210f, 0.06661119f, -0.21039836f, 0.09769492f, 0.05938496f, 0.05511204f, -0.02192363f, 
    0.08044063f, 0.16020827f, -0.01437898f, 0.07323301f, -0.01533408f, 0.04772426f, 0.06575480f, 0.07456549f, 
    0.08638101f, 0.04105498f, -0.20121713f, 0.10569736f, 0.15752727f, -0.25066850f, -0.11185191f, 0.04634335f, 
    -0.20512082f, 0.11835911f, 0.16656220f, -0.09015397f, -0.09890473f, 0.04173281f, 0.07021731f, -0.04428913f, 
    0.01921803f, 0.03078901f, 0.06515893f, -0.00588525f, 0.08541964f, 0.17311689f, 0.06102078f, 0.02838665f, 
    0.30530611f, 0.16216464f, -0.02475496f, 0.11297384f, -0.15399916f, -0.03052039f, 0.01376580f, 0.01913134f, 
    0.01501413f, -0.05741489f, -0.00961169f, 0.13460675f, 0.10030184f, -0.03596048f, 0.00739108f, -0.05750109f, 
    0.00757057f, -0.13203247f, -0.01420086f, 0.03153101f, -0.23632254f, 0.09115626f, 0.04260706f, -0.08967422f, 
    -0.00560726f, -0.04797506f, -0.06688794f, 0.00059744f, 0.00216855f, -0.11187485f, 0.05909144f, 0.07013781f, 
    -0.03971580f, 0.00751236f, -0.05180611f, -0.03667325f, 0.15634985f, 0.06950757f, -0.10368798f, 0.13520715f, 
    0.03918632f, 0.31174484f, 0.02065302f, 0.24064367f, -0.16875124f, 0.01268248f, 0.04525732f, -0.08415014f, 
    0.01758749f, 0.05166078f, 0.13916680f, -0.03578787f, 0.14181025f, 0.00420239f, 0.09928951f, -0.09209315f, 
    -0.03152478f, -0.03524056f, -0.04702889f, 0.03581446f, -0.11394213f, 0.07773394f, 0.02133003f, -0.22905181f, 
    0.18353346f, 0.02636264f, -0.05306878f, -0.03878458f, 0.05420641f, 0.03328386f, 0.14381295f, 0.02516617f, 
    0.07321739f, 0.02218622f, 0.03250637f, 0.02831642f, 0.14662047f, -0.00812983f, -0.10536318f, 0.02213455f, 
    -0.39077562f, -0.40241069f, -0.26551998f, -0.01455792f, -0.01601013f, -0.04051878f, 0.15547161f, 0.07610987f, 
    0.04119258f, 0.03986692f, -0.08769533f, -0.02157096f, 0.02951861f, 0.02315585f, 0.09400950f, 0.06556369f, 
    0.00502724f, -0.01758706f, -0.11113581f, 0.03328890f, -0.09258581f, 0.06473892f, 0.03050411f, 0.12252217f, 
    -0.07437606f, -0.06679273f, 0.06002470f, -0.06252889f, -0.00037832f, -0.08739295f, 0.08772542f, 0.10303659f, 
    0.05104038f, -0.04555771f, -0.00196202f, 0.02887807f, 0.04020051f, 0.07530716f, -0.04442315f, 0.10213055f, 
    -0.18718359f, 0.21738023f, -0.29988724f, -0.24930242f, 0.51916528f, 0.12201432f, -0.17190021f, -0.03386733f, 
    0.00137497f, -0.00548141f, -0.01394188f, 0.03175471f, 0.00382732f, -0.12272017f, -0.00663859f, 0.02837368f, 
    -0.10267208f, 0.09806446f, 0.00964633f, 0.08004910f, -0.10279321f, 0.11369725f, -0.11921638f, -0.12675801f, 
    0.13439339f, 0.07152136f, -0.02920945f, -0.11405008f, -0.05363486f, -0.05754195f, -0.02021426f, 0.00132877f, 
    -0.11873182f, 0.17715406f, 0.10507340f, -0.03799871f, 0.03070502f, 0.13033204f, -0.01310515f, 0.17046691f, 
    0.23854615f, -0.27667117f, -0.27510080f, -0.00166230f, 0.09005483f, -0.04561877f, 0.12733141f, 0.03753027f, 
    -0.02896800f, 0.04421329f, 0.10161825f, -0.02699383f, -0.11197711f, -0.02397243f, -0.11230946f, -0.03662489f, 
    0.01771519f, -0.02130613f, 0.03472018f, 0.02765851f, 0.09204534f, 0.11413805f, -0.14553112f, -0.22873253f, 
    0.21333869f, -0.00138896f, -0.12481116f, 0.05962109f, -0.12453454f, -0.00101545f, 0.08515777f, -0.01443153f, 
    0.07923796f, -0.02590427f, 0.04189239f, -0.05292742f, 0.10972427f, -0.03019278f, 0.14854637f, 0.06977677f, 
    -0.14983118f, 0.40364176f, -0.14835827f, 0.15113936f, -0.05566461f, 0.05354890f, 0.18182255f, -0.03049667f, 
    -0.10362491f, -0.00754301f, 0.03787784f, -0.01118612f, -0.04813585f, -0.04987879f, -0.07837393f, 0.01960402f, 
    -0.00374483f, 0.03931620f, -0.13390723f, -0.04205282f, -0.45061618f, -0.10430364f, 0.25246254f, 0.08957764f, 
    0.35144705f, 0.09017822f, -0.07913528f, 0.00821343f, 0.05176691f, 0.09827300f, 0.02671221f, -0.01339989f, 
    0.01473203f, -0.01026221f, 0.11399735f, -0.05519584f, -0.03649358f, -0.03658367f, 0.01134387f, -0.01561453f, 
    -0.16880992f, 0.11766052f, 0.12573418f, -0.20155361f, 0.26923746f, 0.10421263f, 0.04518703f, 0.05124243f, 
    -0.00171576f, -0.13057631f, -0.01309646f, -0.03681221f, -0.03234949f, 0.06552578f, 0.01119951f, 0.08645587f, 
    0.06826667f, -0.08766376f, -0.00680447f, 0.02212553f, 0.04350279f, -0.01133445f, -0.01529020f, -0.02755771f, 
    0.05074593f, -0.10602333f, 0.15291390f, -0.01655322f, -0.06183970f, -0.15591593f, 0.06218303f, 0.08659372f, 
    -0.00917582f, 0.06227096f, 0.00583339f, -0.09288765f, 0.07730157f, -0.07483175f, -0.01138922f, -0.05089400f, 
    -0.04605122f, 0.17585637f, -0.08387033f, -0.09026150f, 0.07207368f, 0.00165238f, -0.08499723f, 0.01171257f, 
    0.07443368f, 0.04566373f, -0.06126764f, 0.02346765f, -0.01350095f, 0.05523888f, 0.05634371f, -0.05325920f, 
    0.01308600f, 0.08475578f, -0.00283346f, -0.08345956f, 0.06716198f, 0.35997695f, -0.00306458f, 0.31780919f, 
    -0.22548266f, -0.01753155f, -0.03151690f, -0.00301268f, 0.07209009f, -0.01048694f, 0.08807977f, 0.04733065f, 
    0.09185000f, 0.04486653f, 0.24863981f, -0.12668434f, 0.03889578f, 0.07621063f, 0.13709778f, -0.03202830f, 
    0.06979559f, 0.12422476f, -0.13981390f, -0.08783329f, 0.01154112f, -0.16318834f, -0.02104810f, -0.01501232f, 
    0.02848941f, -0.10614525f, 0.02172615f, 0.06791183f, 0.04429338f, -0.01758451f, 0.08062643f, 0.05198218f, 
    -0.05365673f, -0.02649692f, 0.06490651f, -0.07124358f, -0.43289509f, 0.23450644f, 0.09649652f, -0.26270592f, 
    0.25645551f, 0.11773086f, 0.02219505f, 0.11784562f, -0.11867840f, -0.01330153f, 0.05723921f, 0.07032630f, 
    0.08999345f, -0.00317309f, -0.06545898f, 0.02953020f, -0.01244034f, -0.04723569f, -0.05328715f, -0.03760935f, 
    0.42435658f, 0.12478746f, -0.10093397f, -0.15080974f, 0.43847606f, -0.04630895f, -0.15718938f, 0.08350243f, 
    0.05035954f, 0.11582796f, 0.00666040f, -0.01958813f, -0.01443397f, 0.15799515f, -0.06261513f, 0.11667921f, 
    -0.05014467f, -0.04332327f, -0.04892116f, 0.03948265f, 0.13446483f, -0.02581284f, 0.09957433f, -0.02148761f, 
    0.21463403f, 0.10993844f, 0.00129772f, 0.11083005f, 0.07372545f, 0.09958171f, 0.01371998f, -0.03443461f, 
    -0.04360573f, 0.05057583f, -0.07750823f, -0.01378241f, -0.11457673f, -0.01771243f, 0.03955332f, -0.04946565f, 
    0.04409022f, 0.23637301f, 0.01765949f, -0.02592666f, -0.38346732f, -0.02503017f, 0.05598965f, 0.01996758f, 
    0.03108313f, -0.09889818f, 0.09647473f, 0.06966603f, -0.03833408f, -0.08268803f, 0.09075993f, 0.06711826f, 
    0.01956080f, 0.02301206f, -0.10624240f, 0.00273817f, 0.27839059f, 0.09526265f, -0.17181742f, -0.00456210f, 
    0.02669244f, 0.00718429f, -0.05161629f, 0.10664494f, 0.03977427f, 0.02021464f, 0.05057345f, 0.09057300f, 
    0.05751788f, -0.03272248f, 0.00148498f, 0.04118355f, -0.09193636f, 0.02575767f, -0.01829022f, 0.02265487f, 
    0.03388308f, -0.16581079f, 0.19259618f, 0.14934991f, 0.18192022f, -0.03329222f, -0.05408449f, 0.03378725f, 
    -0.05166695f, -0.02853890f, -0.03182781f, -0.07864001f, 0.01671298f, -0.06948382f, 0.01054011f, 0.05316847f, 
    0.02548322f, 0.00632594f, -0.05508207f, 0.08120342f, 0.00976690f, 0.08449557f, -0.05881186f, 0.04278994f, 
    0.03071957f, -0.01668210f, -0.16316053f, 0.06598653f, -0.02269026f, 0.09549665f, -0.02398408f, -0.07856927f, 
    -0.11358240f, 0.17113836f, 0.05587524f, 0.04116398f, 0.03518585f, -0.01747233f, -0.06332448f, -0.09985583f, 
    0.34314692f, -0.62603754f, 0.08721075f, -0.12287436f, 0.19750357f, 0.02080499f, -0.11223424f, -0.02628397f, 
    0.03751351f, 0.04802400f, 0.00760591f, 0.08313427f, -0.06468483f, 0.04505307f, -0.10801952f, 0.01295254f, 
    0.04717151f, -0.13422099f, 0.12574705f, -0.01975009f, 0.34273461f, 0.05779190f, -0.17154425f, 0.02678678f, 
    -0.17778191f, -0.00754898f, -0.07750790f, -0.05516810f, 0.04620752f, 0.02279081f, 0.17313525f, 0.07779039f, 
    -0.01797729f, 0.02012860f, -0.08001496f, -0.04612868f, 0.11140046f, -0.04827979f, -0.02863299f, -0.05569152f, 
    -0.01818824f, 0.14749900f, 0.09513188f, -0.14219543f, 0.27239421f, 0.08322370f, 0.00054144f, 0.04262403f, 
    0.06588137f, -0.02960520f, -0.07387208f, -0.03351301f, -0.00194090f, -0.02797102f, 0.02288749f, 0.03646924f, 
    -0.02326295f, 0.08247451f, -0.06451631f, 0.02315140f, -0.25848114f, -0.08640603f, 0.11362386f, 0.08359271f, 
    0.06428918f, -0.04110495f, 0.08192799f, -0.07558360f, 0.01213420f, 0.19725321f, -0.00764334f, 0.00764300f, 
    0.09149285f, 0.02625987f, 0.04177757f, 0.11760915f, 0.00392292f, 0.06822416f, -0.00742066f, 0.03494418f, 
    0.26742038f, -0.09812964f, -0.31031880f, 0.02489856f, -0.25873128f, -0.01698026f, 0.04062599f, 0.02975416f, 
    0.00180481f, 0.04488203f, 0.02233741f, -0.00666578f, 0.05849925f, 0.08349421f, 0.03989950f, -0.02490948f, 
    0.14775862f, -0.01274003f, -0.03180024f, 0.03069117f, 0.15694922f, -0.06347716f, 0.07406686f, 0.04226942f, 
    0.11705179f, 0.00134325f, 0.04928886f, 0.07301015f, -0.05342166f, -0.03626716f, -0.22213143f, 0.05851037f, 
    0.13205650f, 0.06999151f, 0.03841086f, 0.02367265f, 0.02569159f, -0.00371175f, 0.02345653f, -0.12155817f, 
    -0.36695620f, 0.51178670f, -0.13870905f, 0.06878337f, 0.06220835f, -0.16326885f, -0.01121270f, -0.00243360f, 
    0.03364079f, 0.02143108f, -0.05144183f, -0.12840204f, -0.01280474f, 0.05596261f, -0.06772840f, -0.02121955f, 
    -0.10982843f, 0.05083619f, -0.01537692f, 0.03828724f, -0.07621923f, -0.25646213f, -0.09167165f, 0.02968394f, 
    0.11553166f, -0.15554434f, -0.10011332f, 0.21910149f, 0.06591012f, 0.01087673f, 0.02976723f, 0.01413721f, 
    0.03650874f, -0.01434812f, 0.09795237f, 0.06869514f, 0.01575432f, 0.04426752f, -0.00811975f, 0.05890022f, 
    0.24180509f, 0.02624341f, -0.07155287f, -0.05499502f, -0.05590672f, 0.06712059f, -0.07600179f, 0.08615312f, 
    -0.06715077f, 0.05572806f, -0.11216854f, -0.07298868f, 0.06415749f, 0.03017617f, -0.01608549f, 0.00228914f, 
    0.10598540f, 0.00271238f, -0.01012908f, -0.07498085f, 0.06447481f, 0.08902555f, -0.08828620f, -0.11165256f, 
    -0.20566696f, -0.03430151f, -0.09965438f, -0.02366685f, -0.05766494f, 0.07901356f, -0.03998131f, -0.05546031f, 
    0.00166286f, -0.01474394f, -0.02419880f, 0.16379972f, 0.02405262f, -0.02627245f, 0.07738640f, -0.10641866f, 
    -0.41124943f, -0.01324508f, 0.03634698f, -0.01302266f, -0.23150913f, -0.05366837f, 0.13002644f, 0.08110280f, 
    0.06624112f, -0.06203907f, -0.10905194f, -0.03919390f, 0.01536916f, 0.06300288f, -0.17114274f, 0.01596683f, 
    0.04555677f, -0.05367274f, -0.08216927f, -0.01791976f, 0.19537999f, 0.05644803f, -0.06532672f, -0.07471963f, 
    -0.03879786f, 0.04739341f, 0.05338120f, 0.00945841f, -0.07799539f, 0.14030798f, -0.03960824f, -0.02324804f, 
    -0.05557889f, -0.09887031f, -0.05206411f, 0.07247275f, 0.07598808f, 0.13249987f, 0.14699540f, 0.04138694f, 
    0.28966883f, -0.41343760f, -0.24630211f, -0.00266143f, 0.04286027f, 0.07693101f, -0.05968997f, -0.09008282f, 
    0.00307188f, 0.11111919f, -0.03631126f, 0.17472044f, 0.05909445f, 0.16256547f, 0.02633379f, 0.00427551f, 
    0.07726377f, 0.01376801f, -0.04690622f, -0.07878677f, 0.15908642f, 0.23993956f, -0.11332146f, 0.09398910f, 
    0.42625496f, -0.03482879f, 0.11546762f, -0.02692444f, 0.04070974f, 0.05577282f, -0.03086505f, 0.01996983f, 
    0.02336816f, 0.00519443f, 0.02420185f, -0.01849367f, 0.00230712f, 0.03793246f, 0.03560242f, 0.08712187f, 
    0.06655596f, 0.25834742f, 0.06257565f, -0.05082979f, -0.03676886f, -0.08081245f, 0.12163018f, 0.04813584f, 
    -0.10786796f, 0.13287237f, -0.04073958f, -0.00187553f, -0.03992386f, 0.05533390f, -0.07157262f, 0.11325847f, 
    -0.11555653f, 0.08271126f, 0.21378238f, 0.15054116f, -0.09592052f, 0.15058145f, -0.09246843f, 0.09132725f, 
    0.00871252f, 0.12697765f, 0.19089714f, -0.01242229f, -0.07208423f, 0.02705686f, -0.00450909f, -0.01770582f, 
    0.23098196f, -0.14111347f, -0.15893465f, -0.09073918f, 0.01537262f, 0.18045005f, 0.17215936f, 0.06214697f, 
    -0.06591575f, 0.19938478f, -0.12031881f, 0.01933504f, 0.01122138f, 0.01152758f, -0.01439562f, -0.09142183f, 
    0.02468028f, -0.00797773f, -0.11412533f, -0.01012646f, -0.02104024f, -0.06084757f, 0.13037719f, 0.00542584f, 
    -0.04735882f, 0.06006644f, -0.22099768f, 0.01471818f, -0.32686260f, 0.13833533f, -0.12260336f, 0.03060517f, 
    0.15292825f, -0.13602367f, -0.05412585f, 0.03994140f, 0.03352436f, -0.01609174f, -0.11378709f, -0.10844752f, 
    0.01628408f, 0.02662831f, 0.12940899f, -0.02610567f, -0.07047664f, 0.14477779f, 0.05892268f, 0.10632959f, 
    0.20066805f, -0.38985333f, 0.13029104f, 0.16831297f, -0.00837083f, -0.15019612f, -0.09631402f, 0.13667803f, 
    0.09613171f, 0.06862354f, 0.07320812f, 0.04503349f, 0.07065602f, -0.01963299f, -0.00397570f, 0.02692112f, 
    0.03694598f, -0.03359594f, -0.13101251f, -0.02635469f, 0.27881879f, 0.11551408f, -0.18073669f, 0.04673411f, 
    0.17419986f, -0.08010645f, -0.01398162f, 0.13047400f, 0.10104304f, -0.10464225f, -0.16016732f, 0.02447605f, 
    -0.06169816f, -0.00109764f, 0.04922911f, -0.00437218f, -0.02192035f, -0.02820111f, 0.04875901f, -0.04335274f, 
    0.41860518f, -0.28034392f, 0.15420388f, -0.05511080f, 0.11289437f, -0.00164912f, 0.04512166f, -0.19607675f, 
    -0.10498576f, 0.02113385f, -0.10106160f, 0.09444602f, -0.05351682f, 0.15786113f, -0.03300980f, 0.05296977f, 
    -0.06392720f, 0.04758639f, -0.00374232f, 0.01741884f, 0.17296161f, 0.24225898f, 0.00452045f, 0.06452981f, 
    0.08387403f, -0.02522621f, -0.07719982f, -0.04351982f, -0.00277242f, -0.06382543f, 0.09324321f, -0.05098327f, 
    -0.08767407f, -0.02099136f, -0.03785841f, -0.03681581f, 0.02905595f, 0.12132786f, -0.00749418f, 0.00685505f, 
    0.23175241f, -0.08545817f, 0.27557388f, 0.06808035f, 0.03510543f, 0.20689879f, -0.02023176f, 0.02084558f, 
    -0.12447751f, -0.11384277f, -0.07023730f, -0.05400460f, 0.04133647f, 0.01039545f, 0.01717571f, -0.05637289f, 
    0.05751073f, -0.09805686f, 0.22210386f, -0.05211538f, -0.34223303f, 0.04790547f, -0.06954242f, -0.04252311f, 
    0.05598463f, -0.08606310f, 0.02433446f, -0.03507733f, 0.12346531f, -0.05095999f, -0.07478698f, -0.01426613f, 
    0.03123469f, 0.05819760f, -0.08612513f, 0.05001694f, 0.01500182f, -0.18260601f, -0.06821769f, 0.02555202f, 
    -0.03340869f, 0.09773310f, 0.08712914f, 0.00386229f, 0.16825895f, 0.00057524f, 0.05086827f, 0.03792812f, 
    -0.00457335f, 0.04731639f, -0.03570041f, -0.07209115f, 0.07521450f, 0.03596395f, 0.09911150f, 0.12042309f, 
    -0.01151779f, 0.23960069f, 0.21565615f, 0.12832975f, 0.38019824f, -0.10366353f, 0.06022803f, 0.17104095f, 
    0.15163228f, -0.06761900f, -0.00390171f, -0.10455876f, -0.14556293f, 0.05340115f, -0.04508064f, -0.00983698f, 
    0.11162724f, -0.03238247f, 0.02834177f, -0.07014520f, -0.00777572f, 0.03497266f, 0.14871126f, 0.02939139f, 
    -0.01737905f, -0.20646265f, 0.00921405f, 0.14649050f, 0.23748899f, 0.02534947f, -0.00364043f, -0.17720810f, 
    -0.03869724f, 0.05543775f, 0.07346564f, -0.05186541f, 0.09872112f, 0.13583674f, 0.04657997f, -0.06613767f, 
    0.02231410f, -0.09051184f, 0.09222310f, -0.09624456f, -0.15983650f, -0.35053292f, 0.23433229f, 0.09146112f, 
    -0.16724351f, 0.03963248f, 0.06976306f, 0.02103412f, -0.02209153f, -0.08698066f, -0.00032004f, -0.01766592f, 
    -0.05059792f, 0.07326248f, 0.01757267f, 0.01686719f, -0.03337631f, -0.13253118f, -0.07740977f, 0.01417410f, 
    0.09952112f, 0.21072832f, 0.21662818f, -0.00897467f, -0.16056073f, -0.09780723f, -0.00850850f, 0.04724557f, 
    -0.01943040f, -0.02163804f, -0.00598315f, 0.01524161f, -0.01983025f, -0.14413108f, 0.08329450f, 0.03677655f, 
    0.08874803f, 0.03626300f, 0.06681357f, 0.06635581f, 0.17499624f, 0.09976868f, 0.28724968f, 0.09370496f, 
    -0.20726377f, -0.01791449f, -0.03563140f, -0.08922180f, 0.03070760f, 0.11069217f, 0.09919883f, 0.04369342f, 
    -0.04335055f, 0.00423691f, 0.16376074f, -0.03080944f, 0.01781639f, -0.13348551f, -0.01101328f, 0.02453865f, 
    0.15390448f, -0.06188398f, 0.23718664f, 0.04039822f, -0.37779638f, 0.05229440f, 0.10377870f, -0.02119414f, 
    0.04414610f, 0.16915254f, 0.01247839f, 0.02397614f, 0.02270391f, -0.06685391f, 0.09511894f, -0.04641591f, 
    -0.05071957f, -0.05329625f, -0.27078387f, 0.12325516f, -0.14528832f, 0.02098015f, 0.21795496f, 0.02176572f, 
    -0.02003923f, 0.00081153f, -0.12549625f, -0.02281148f, 0.09890072f, -0.03011072f, 0.04075187f, -0.01616718f, 
    -0.07097393f, 0.11231617f, 0.06902523f, 0.11150291f, 0.03665220f, -0.08545752f, -0.10294903f, 0.03854779f, 
    -0.03341454f, 0.24003503f, -0.01267553f, 0.18681094f, 0.05478214f, -0.24551246f, 0.18183121f, 0.05542115f, 
    0.04594608f, -0.05871575f, 0.11840630f, 0.15986978f, 0.14000051f, 0.03821821f, -0.02320881f, -0.00069431f, 
    0.07089439f, -0.05385010f, 0.21228433f, 0.02032819f, -0.06152013f, -0.01762892f, 0.08066744f, -0.06908889f, 
    -0.27047622f, 0.11201612f, 0.06286412f, 0.02084778f, -0.01085299f, -0.02387309f, 0.06852718f, 0.04762143f, 
    -0.15280382f, -0.02767077f, -0.10925763f, -0.00475139f, 0.03659862f, 0.02516210f, -0.04922290f, -0.11160429f, 
    -0.03665914f, -0.06453805f, -0.15991373f, -0.05708653f, 0.33090577f, -0.03893248f, -0.00463431f, -0.31317732f, 
    -0.07902009f, 0.09534569f, -0.05385357f, -0.01061054f, -0.07880723f, 0.20182933f, 0.09005099f, -0.10911348f, 
    0.01115662f, -0.09458629f, 0.20907953f, -0.00194613f, 0.17714638f, -0.05955655f, 0.10674366f, 0.16131230f, 
    0.05595192f, 0.04241296f, 0.13588345f, -0.01961000f, -0.10609604f, -0.02348005f, 0.08172242f, 0.14885475f, 
    -0.00960274f, -0.01371724f, -0.00477589f, -0.03634418f, 0.03709095f, 0.17932664f, 0.06387231f, -0.02590103f, 
    -0.25901079f, 0.25972742f, -0.03606466f, -0.23073657f, -0.26023594f, -0.00407984f, -0.01768551f, 0.16927832f, 
    0.12871169f, -0.01680113f, -0.02031471f, -0.00500664f, 0.03779849f, -0.13639978f, -0.00685036f, -0.08320282f, 
    0.11999746f, 0.01608684f, 0.03930964f, 0.07937026f, -0.02323292f, -0.13429292f, -0.02492986f, -0.06243842f, 
    -0.04872021f, -0.01625306f, -0.02097275f, -0.04826687f, -0.04847034f, 0.07948456f, 0.06805918f, 0.03398779f, 
    0.12967245f, 0.02901102f, 0.04807011f, 0.08072992f, 0.06137403f, -0.02676731f, 0.03801089f, 0.04935886f, 
    -0.08372120f, -0.18543275f, 0.07487224f, 0.16296887f, -0.07322810f, 0.08050497f, 0.12795861f, -0.03152904f, 
    -0.07174334f, -0.02567232f, 0.05096359f, 0.19326928f, 0.07839136f, 0.03797228f, -0.04976566f, 0.09466818f, 
    0.11502317f, 0.06738372f, -0.17052050f, 0.13613832f, -0.09693532f, 0.18252249f, -0.00414943f, 0.25455034f, 
    0.17463362f, -0.02258964f, -0.06241741f, -0.03017580f, -0.03766639f, 0.04827370f, 0.07374799f, 0.05120254f, 
    -0.00468097f, 0.00595169f, 0.09755916f, -0.03577804f, 0.03724924f, 0.13916323f, 0.04847337f, 0.03531558f, 
    0.09009731f, -0.01740300f, 0.14597219f, 0.05545769f, -0.01369532f, -0.00135601f, 0.00154023f, -0.07681167f, 
    -0.00231592f, 0.08178435f, -0.07933506f, 0.03806170f, -0.11479357f, -0.05718510f, -0.05852870f, -0.09337602f, 
    0.06466047f, -0.13890462f, -0.02604435f, 0.03237272f, -0.46509284f, 0.09718447f, 0.12233104f, -0.17741717f, 
    -0.02628020f, 0.02449742f, 0.06095063f, 0.16159441f, 0.14218651f, -0.02105523f, 0.05414303f, -0.03968043f, 
    -0.02806010f, 0.11490185f, 0.05263042f, -0.00966097f, 0.07689679f, -0.09857286f, -0.18072528f, 0.10566751f, 
    0.01730659f, 0.02401073f, 0.16735959f, -0.00629181f, 0.19674096f, -0.09490486f, -0.06789283f, 0.08825022f, 
    -0.02990577f, -0.01506495f, 0.04446919f, -0.09442087f, 0.09209094f, 0.18926100f, -0.03341589f, 0.04442612f, 
    0.05805319f, 0.08975372f, 0.03203664f, -0.05178917f, -0.23470779f, -0.36259660f, 0.18761641f, 0.20131449f, 
    -0.00678212f, -0.01294599f, 0.07872159f, 0.02147348f, -0.05762694f, 0.00762089f, 0.02853659f, -0.03227950f, 
    0.00626277f, -0.05585047f, 0.02234266f, 0.20299770f, -0.17667626f, 0.03528715f, -0.06559143f, 0.05951870f, 
    -0.03134834f, 0.16879930f, -0.21814226f, -0.04498556f, -0.32098627f, 0.08971268f, -0.12944311f, 0.03395173f, 
    0.05186039f, 0.06424445f, 0.02833834f, 0.09323916f, -0.03117565f, -0.03555411f, 0.02402132f, 0.07597042f, 
    0.10841736f, -0.04280538f, -0.04044823f, 0.03218007f, 0.05068744f, -0.03319670f, -0.04141544f, -0.15822946f, 
    0.14195400f, 0.08681439f, 0.02339520f, 0.00600179f, -0.06325567f, 0.11499970f, -0.05835126f, 0.05965408f, 
    -0.07528209f, -0.02720814f, 0.10095007f, -0.04878514f, -0.14452004f, 0.02124575f, 0.01957837f, -0.01927043f, 
    -0.20747282f, -0.14816537f, 0.21612227f, 0.19139887f, -0.26872376f, 0.12247927f, -0.01399114f, 0.03717168f, 
    -0.07153500f, 0.06738241f, 0.04663345f, -0.12799251f, 0.05855273f, 0.14222929f, 0.06905116f, -0.05946863f, 
    0.06510628f, 0.00415815f, 0.05574553f, 0.12736893f, 0.02249545f, -0.13433737f, 0.14832571f, 0.19132499f, 
    -0.05111888f, -0.00293383f, 0.00285637f, 0.02377235f, 0.14407614f, 0.01843282f, 0.06329244f, 0.02875321f, 
    -0.06244051f, -0.00754206f, 0.09566411f, -0.02678155f, 0.10077287f, -0.08172037f, -0.02596150f, 0.00968082f, 
    -0.03887129f, -0.02202241f, 0.30054510f, -0.09438033f, 0.07053745f, 0.13160305f, -0.10318044f, 0.14151967f, 
    0.15318511f, -0.04854344f, 0.05230976f, 0.04194464f, 0.11647856f, 0.05480843f, 0.08108740f, -0.02246741f, 
    0.05609364f, 0.01301537f, 0.03299741f, 0.10883728f, -0.05018672f, -0.11819278f, -0.14540112f, -0.00551457f, 
    -0.19904679f, 0.00613977f, 0.02218727f, -0.06001569f, -0.00441249f, 0.15996924f, 0.14150359f, 0.04605413f, 
    -0.06065271f, -0.10371846f, 0.11349098f, 0.07478804f, 0.09819846f, 0.20385827f, 0.00529773f, 0.00062122f, 
    0.17161649f, -0.44189110f, 0.24866204f, -0.05532201f, 0.12181696f, -0.03282427f, -0.09213850f, 0.05830744f, 
    -0.02075999f, -0.10618951f, 0.04514609f, -0.11828675f, 0.02169285f, 0.14192840f, 0.01391800f, -0.00504043f, 
    0.03178454f, 0.07055099f, 0.04221052f, -0.02803130f, 0.37361881f, -0.01774021f, 0.15232806f, 0.08563529f, 
    -0.19188619f, 0.05492239f, 0.10911628f, 0.09320219f, -0.02733312f, 0.05538734f, 0.12960991f, -0.03568719f, 
    0.07866254f, 0.06600586f, 0.03115009f, 0.05311562f, 0.10592690f, 0.06663600f, 0.02823454f, 0.03408369f, 
    -0.12138250f, -0.09846469f, -0.39647377f, 0.02040704f, -0.35931346f, 0.12239135f, 0.00039738f, 0.02162702f, 
    0.08546400f, 0.08007415f, -0.04271132f, -0.01275816f, -0.03768971f, -0.05445496f, 0.06811415f, 0.18701142f, 
    -0.00553078f, 0.06591237f, 0.04428867f, 0.11942710f, 0.02064941f, -0.09951902f, -0.05063770f, 0.04778394f, 
    0.11941922f, 0.03615684f, -0.03070289f, 0.10914933f, -0.00798416f, 0.10434625f, -0.03316116f, -0.03367322f, 
    0.01358283f, -0.00497932f, 0.01927364f, -0.07941970f, 0.04205021f, 0.09632123f, -0.00658702f, 0.10942294f, 
    -0.28498945f, 0.15226255f, -0.04570046f, 0.18356726f, -0.13056652f, 0.04916908f, 0.07246245f, -0.02066746f, 
    0.03119027f, 0.00032149f, 0.11875703f, 0.01611990f, -0.02654238f, -0.04449677f, -0.04415458f, 0.06447630f, 
    -0.10799108f, 0.05683709f, 0.12998222f, 0.17064710f, -0.05039407f, -0.23147047f, 0.16464257f, 0.02033903f, 
    0.06421092f, -0.13538212f, 0.03938482f, 0.09343790f, 0.03289342f, 0.05192788f, -0.03666879f, 0.02390089f, 
    0.08619212f, 0.12213130f, 0.04328373f, 0.12807120f, 0.08618657f, 0.07424715f, -0.01177269f, 0.17404154f, 
    0.20524058f, -0.16229509f, 0.13371676f, 0.15261763f, -0.07039382f, 0.00543441f, 0.01523384f, 0.13721292f, 
    -0.06133631f, 0.07679144f, -0.06591171f, -0.01787125f, 0.01794000f, 0.08390152f, 0.12319648f, -0.02066943f, 
    0.15468670f, 0.10472447f, 0.01845605f, 0.14848107f, -0.23585418f, -0.16538356f, -0.30433831f, 0.09005948f, 
    -0.14991148f, 0.06354551f, -0.03532101f, 0.01561871f, 0.19280285f, 0.05891067f, 0.04484680f, -0.11368748f, 
    -0.09449150f, -0.06454236f, 0.00827805f, 0.11701107f, 0.09265766f, 0.05536836f, -0.02258372f, 0.08263089f, 
    -0.00403393f, 0.22266215f, 0.27688715f, 0.38154534f, -0.10054802f, 0.07005584f, 0.09430110f, 0.03188386f, 
    -0.04176504f, -0.06776664f, -0.04596665f, -0.11979456f, 0.01272458f, 0.18715811f, -0.04751187f, -0.05532254f, 
    0.05523823f, 0.10251369f, -0.02037333f, -0.10399783f, -0.17996027f, -0.15707663f, -0.13931379f, -0.32131472f, 
    0.10546934f, 0.03620442f, 0.00553128f, -0.03665436f, 0.15238318f, -0.02745794f, -0.04991826f, -0.09265189f, 
    -0.15400647f, 0.01593609f, -0.07671323f, -0.07686482f, -0.13261510f, 0.02138762f, -0.05678858f, 0.07882350f, 
    0.02017781f, -0.38033372f, -0.38303575f, -0.09139512f, -0.14765418f, 0.00350653f, 0.07695777f, -0.11464912f, 
    -0.07013968f, 0.20083433f, -0.08354948f, 0.09685572f, -0.04993062f, 0.02949464f, 0.06407300f, 0.08447669f, 
    0.06179349f, -0.10926005f, -0.06053156f, 0.00531555f, -0.38951069f, -0.22098929f, -0.20919053f, 0.13845401f, 
    0.13901751f, 0.14992930f, 0.18048525f, -0.08195725f, 0.09512399f, -0.01239040f, 0.03290457f, 0.01955566f, 
    0.08009367f, -0.16093811f, 0.01626875f, 0.04909315f, -0.07928204f, 0.02075079f, -0.04923077f, 0.00540772f, 
    -0.05684976f, 0.20756173f, -0.10918041f, -0.31809148f, 0.25415385f, 0.10423906f, 0.05708288f, 0.00717792f, 
    -0.01794578f, -0.01472262f, -0.00959325f, -0.17415197f, -0.05912215f, -0.09270259f, -0.07504960f, 0.03142660f, 
    -0.08384872f, 0.07779396f, -0.00127597f, 0.16118212f, -0.06956825f, 0.02119575f, -0.19683161f, -0.13451330f, 
    0.06739435f, 0.12332498f, 0.00669541f, -0.01209815f, 0.11470437f, 0.01331013f, 0.01313258f, 0.04998036f, 
    -0.03508585f, 0.00550978f, -0.07567238f, -0.06070429f, -0.03204058f, 0.00944967f, -0.15921471f, 0.08897586f, 
    0.02020985f, -0.33076277f, -0.12393896f, -0.07754478f, -0.04678793f, 0.01361751f, 0.14671148f, 0.07769165f, 
    0.06558823f, 0.01763587f, 0.13602920f, 0.00021549f, -0.07175275f, 0.05344208f, -0.03952982f, -0.01250834f, 
    0.05743384f, -0.06798115f, 0.05534719f, -0.03592727f, -0.26216745f, 0.00928402f, 0.00463119f, -0.44771290f, 
    0.09775905f, 0.03295746f, -0.12293080f, -0.00251760f, 0.01155581f, -0.04400555f, 0.08627133f, 0.01300966f, 
    -0.06843416f, 0.03097146f, 0.02726971f, -0.09374707f, 0.06410010f, 0.05191023f, -0.00218868f, -0.02708647f, 
    -0.16218410f, 0.08035261f, -0.03583847f, 0.08208178f, 0.04069066f, 0.02913258f, -0.00283126f, 0.07602940f, 
    0.04987512f, -0.11370537f, -0.00740782f, -0.03915804f, -0.02855012f, 0.06304296f, -0.17061430f, 0.08490605f, 
    -0.00032847f, 0.06980325f, -0.03559133f, -0.02296577f, -0.21596971f, 0.13172805f, 0.31989360f, 0.15620129f, 
    0.25847861f, 0.06972214f, -0.02698188f, 0.10689334f, 0.01194441f, 0.05672981f, 0.11084877f, -0.07900361f, 
    0.09644286f, -0.00324542f, 0.05335009f, 0.05758779f, 0.15745968f, 0.10389867f, 0.20462249f, -0.04633836f, 
    -0.14792888f, -0.40674943f, 0.07862850f, -0.23095222f, 0.04826757f, 0.20477679f, 0.15921967f, 0.00913949f, 
    0.06611041f, 0.03629601f, 0.03845971f, -0.02760948f, -0.06103057f, 0.07482325f, -0.08642352f, 0.15860958f, 
    -0.01928455f, -0.10414752f, -0.06394897f, 0.09259395f, 0.06773288f, -0.13271013f, -0.06413112f, -0.06258337f, 
    0.11173765f, 0.00320537f, -0.01059114f, 0.13480330f, -0.03349992f, -0.00860630f, -0.04431922f, 0.10639701f, 
    0.07155523f, 0.00462388f, 0.00118968f, -0.11181844f, 0.05131725f, -0.08085685f, 0.10118987f, 0.03319753f, 
    -0.00168728f, -0.02898338f, -0.01192904f, -0.08269297f, 0.05415652f, 0.16207458f, -0.08731581f, -0.05619705f, 
    0.05348026f, -0.02439492f, -0.10810100f, -0.06646626f, -0.07260341f, 0.05071727f, 0.03957915f, 0.00829086f, 
    -0.07180317f, 0.11123892f, 0.06273901f, -0.00003944f, -0.07490151f, 0.50923014f, 0.30227739f, 0.32565308f, 
    0.05982151f, -0.07601044f, -0.01561529f, 0.07805380f, 0.01608923f, -0.04870094f, 0.01305027f, -0.04937674f, 
    -0.02580149f, 0.07254683f, 0.16847029f, -0.05274601f, 0.08611855f, 0.03312171f, 0.17160226f, 0.09316376f, 
    0.08558856f, 0.06961761f, -0.25271052f, -0.05950772f, 0.10708616f, 0.07102879f, 0.03046969f, -0.04031129f, 
    0.09855577f, 0.03769163f, 0.01165790f, -0.05886755f, 0.00561398f, -0.05173014f, 0.05509445f, 0.06017705f, 
    -0.01774384f, 0.01356031f, 0.03954145f, 0.02749315f, -0.12080306f, -0.08038853f, 0.07327539f, -0.15007523f, 
    0.07200610f, 0.13447407f, 0.13837579f, 0.07781190f, 0.05526276f, -0.05198397f, -0.02696473f, -0.06470747f, 
    0.01424660f, 0.00023755f, -0.05758176f, 0.05106384f, 0.10656410f, -0.19485907f, 0.03309840f, 0.11850338f, 
    -0.04223563f, -0.05247093f, 0.03514647f, -0.05977491f, 0.02925152f, -0.05058178f, -0.02707748f, 0.01203143f, 
    -0.05137524f, -0.03250496f, 0.04846234f, -0.02684304f, -0.04338210f, -0.02891002f, -0.00634512f, 0.02547681f, 
    0.04239262f, -0.00177657f, -0.02037020f, -0.05082383f, -0.04249263f, 0.03039192f, 0.03394335f, -0.02715863f, 
    -0.02461435f, 0.02785993f, -0.05579763f, -0.05401492f, 0.03860036f, -0.05049059f, -0.00235817f, 0.00519375f, 
    -0.00504476f, -0.01219810f, -0.04717291f, 0.03027887f, 0.02708839f, -0.05434556f, 0.02533349f, -0.02971187f, 
    0.00858935f, -0.03733622f, 0.01504685f, -0.04397297f, -0.04690328f, 0.03985232f, -0.01089159f, -0.04162901f, 
    0.02843617f, 0.00985446f, 0.00313920f, -0.02184008f, 0.00212381f, -0.03641909f, 0.00763366f, -0.04322936f, 
    -0.03980146f, -0.05537299f, -0.05124542f, 0.02301889f, -0.02222803f, -0.01079376f, -0.03350164f, 0.03367640f, 
    0.03450720f, 0.03439212f, -0.04282425f, 0.02176271f, 0.00773778f, -0.02262039f, -0.01280535f, -0.03497244f, 
    0.03352186f, -0.04065174f, 0.05211366f, -0.03426172f, 0.02312418f, 0.01569710f, 0.01693952f, -0.00462616f, 
    -0.05189935f, -0.04058930f, 0.02158224f, -0.04279017f, -0.01756120f, 0.02237241f, -0.00520144f, -0.00869982f, 
    -0.03745294f, 0.02030659f, -0.05745497f, -0.02701917f, -0.04251435f, -0.04560309f, -0.02738548f, 0.01355449f, 
    -0.03704509f, -0.01457605f, 0.00062435f, -0.05146265f, -0.00499037f, 0.03346708f, 0.01025842f, -0.02472894f, 
    -0.03449656f, 0.02631474f, -0.01227109f, 0.05030465f, -0.02206798f, -0.03780559f, -0.04531248f, 0.01398825f, 
    0.00879139f, -0.00057065f, -0.00457651f, -0.00202337f, -0.04799099f, 0.04242100f, 0.01425381f, -0.00112679f, 
    0.00889245f, -0.00085450f, -0.01684072f, 0.00230756f, -0.01950426f, -0.03240300f, -0.04293286f, 0.04100927f, 
    0.04935034f, 0.04986307f, 0.01685864f, -0.05195163f, -0.03387034f, -0.05750295f, -0.05034793f, 0.04631615f, 
    0.02950791f, -0.01475806f, 0.02538908f, 0.01247985f, 0.00330588f, 0.03187920f, -0.02045515f, -0.00431259f, 
    -0.04423182f, -0.05750762f, -0.05702852f, -0.05810074f, -0.03990059f, -0.00489760f, 0.02452001f, -0.03311740f, 
    -0.04155619f, -0.02802600f, 0.04013296f, -0.04044736f, 0.04819339f, 0.03015015f, 0.03970249f, 0.00541131f, 
    -0.01143044f, 0.03089054f, 0.00425984f, 0.01627802f, 0.03305440f, 0.02603225f, -0.04792145f, 0.03131315f, 
    0.00908342f, 0.01543169f, 0.02918752f, -0.05329993f, -0.00126467f, -0.02016125f, 0.03359236f, 0.02454000f, 
    -0.04863504f, 0.02360765f, -0.03966092f, -0.03949290f, 0.02206492f, -0.02325204f, -0.01374635f, 0.01676794f, 
    -0.02532084f, -0.02395720f, -0.04442894f, -0.01509359f, -0.00364284f, -0.06025241f, -0.03305141f, 0.03749338f, 
    -0.03868422f, 0.02858211f, 0.04635342f, -0.01204765f, -0.03033430f, -0.01709251f, 0.00040754f, 0.01000093f, 
    -0.03059892f, -0.00417894f, -0.06014096f, 0.03052032f, 0.03267547f, -0.02763762f, -0.00148676f, -0.06064113f, 
    0.00107436f, -0.05410485f, -0.04664650f, -0.03404144f, 0.03840313f, 0.04555263f, -0.03954261f, -0.02019994f, 
    -0.03547891f, -0.03231708f, -0.05016611f, 0.04214575f, -0.00964150f, -0.05247246f, 0.02926672f, 0.03805955f, 
    -0.06090940f, 0.02645278f, 0.04330665f, 0.04500867f, -0.04674960f, -0.04297846f, -0.03446061f, 0.03218793f, 
    0.01722809f, 0.03458735f, -0.01357053f, -0.05584462f, -0.02005821f, -0.01834451f, -0.01919481f, 0.00421669f, 
    -0.05317461f, 0.03904259f, -0.01118111f, -0.03657950f, -0.03763583f, -0.03871432f, -0.00601165f, -0.02905404f, 
    -0.00049136f, 0.02940568f, 0.04137795f, 0.02970283f, 0.00813464f, -0.00085288f, -0.03265579f, 0.04868434f, 
    -0.04017528f, 0.01819780f, -0.05793919f, 0.04360498f, -0.02306922f, 0.03681392f, 0.03672159f, -0.04759865f, 
    0.00423271f, -0.01294813f, -0.02562291f, 0.00141254f, -0.04989565f, 0.00182292f, 0.03601063f, -0.00573375f, 
    -0.01657427f, -0.05038050f, 0.00676583f, 0.04159202f, 0.02451082f, -0.05096067f, 0.02913182f, -0.00235265f, 
    -0.05017989f, 0.00310814f, 0.04770466f, -0.04423334f, 0.03225467f, -0.01622873f, 0.00660809f, -0.00017589f, 
    -0.05157628f, -0.01536840f, -0.02640138f, 0.01552541f, -0.00099888f, 0.02253844f, -0.05746966f, -0.00510369f, 
    -0.03601347f, -0.02432404f, -0.04246444f, 0.04720572f, 0.04082135f, 0.03922908f, -0.00480882f, 0.05005095f, 
    -0.00730864f, 0.01175326f, -0.00086365f, -0.01616466f, -0.05729357f, 0.01585529f, -0.00100984f, 0.03200814f, 
    -0.01182456f, -0.04339621f, 0.02941666f, 0.01102895f, -0.01205699f, 0.00673626f, -0.02706967f, 0.02418020f, 
    0.31229150f, -0.16876504f, 0.30775437f, 0.10013371f, 0.30574372f, -0.03965879f, -0.13966425f, -0.04853423f, 
    0.08508381f, 0.06435923f, 0.07935429f, -0.07002651f, 0.10355476f, 0.07406084f, 0.01585365f, 0.07377568f, 
    -0.02425901f, 0.00133547f, 0.01383271f, -0.05613742f, -0.02723552f, -0.38428453f, 0.10148625f, 0.30774462f, 
    -0.00151712f, -0.00214010f, 0.02572970f, 0.11008033f, -0.01734729f, -0.05592904f, 0.05436499f, -0.03790824f, 
    0.02995420f, 0.08471376f, -0.01024610f, 0.05182846f, -0.22456819f, -0.08982927f, -0.02475451f, -0.01673224f, 
    -0.19176412f, 0.40212715f, -0.08888443f, -0.02827085f, -0.37453505f, 0.03468024f, -0.06957006f, 0.04954586f, 
    0.07905450f, -0.03273137f, 0.09163336f, -0.06450250f, -0.04694420f, -0.04264040f, 0.11072809f, 0.05227945f, 
    0.05238945f, -0.02338544f, -0.01431028f, 0.02682984f, 0.23306553f, -0.10970810f, 0.19172360f, -0.11762335f, 
    -0.24825788f, 0.02550747f, -0.03447315f, 0.07398108f, -0.08630645f, 0.08372325f, 0.04342169f, 0.03839495f, 
    0.01720169f, 0.01122045f, 0.06571699f, -0.13434109f, -0.07599218f, -0.06175574f, -0.00204472f, -0.01966561f, 
    0.00111404f, -0.26543486f, 0.03653603f, 0.25470304f, -0.15747255f, 0.12284630f, -0.05707419f, 0.05028415f, 
    0.02893807f, 0.02180983f, 0.00250846f, -0.03429348f, 0.07111453f, 0.02448791f, 0.14515166f, -0.00050419f, 
    0.00139415f, -0.06203301f, -0.13409860f, 0.06882609f, 0.12010775f, -0.19538240f, 0.06071481f, 0.18721901f, 
    0.00214089f, -0.09019949f, -0.02167556f, 0.02582068f, 0.13393658f, 0.07552188f, -0.01320209f, -0.00226317f, 
    -0.09458528f, 0.08512847f, 0.04163751f, 0.06095072f, 0.05235738f, -0.09942618f, -0.14064468f, 0.01104370f, 
    0.19464484f, -0.17458567f, 0.07284252f, 0.06440552f, 0.11629698f, 0.01957130f, -0.00922664f, 0.12470831f, 
    0.07945876f, -0.01239090f, 0.08317582f, 0.02642413f, 0.08209507f, 0.06379842f, -0.00165528f, 0.06901062f, 
    0.05016790f, -0.11094248f, 0.13481507f, 0.05255800f, 0.18964672f, -0.26615614f, -0.18591461f, 0.02809498f, 
    -0.16833560f, 0.09605707f, 0.02028799f, 0.10118838f, 0.06854215f, 0.12408330f, 0.17120682f, 0.12522811f, 
    0.02118817f, -0.01696448f, -0.03084128f, -0.00764743f, 0.10547598f, -0.00819234f, 0.00729938f, 0.03010086f, 
    0.16844572f, -0.24996933f, 0.09135896f, -0.15449399f, 0.14510584f, -0.13073030f, -0.01142764f, -0.09214039f, 
    -0.15518872f, 0.01298216f, -0.07139627f, -0.03687141f, -0.01375476f, 0.13789277f, 0.03464158f, -0.00911832f, 
    0.05069631f, -0.00314910f, -0.01897590f, -0.05471940f, 0.03323516f, -0.32122469f, 0.25302052f, 0.13188362f, 
    -0.16645241f, 0.01206411f, 0.10191674f, -0.04091975f, -0.10131273f, 0.15693669f, 0.12237454f, -0.03562606f, 
    -0.02703660f, 0.06806156f, -0.03676403f, 0.00419041f, 0.01463383f, 0.04487977f, 0.00498503f, -0.02682579f, 
    -0.31662041f, 0.14121594f, -0.34373158f, -0.02340351f, -0.38120207f, 0.08022757f, -0.02799423f, 0.08819080f, 
    0.04926533f, -0.01860435f, -0.00658199f, 0.04122021f, 0.13052884f, -0.14684522f, 0.11529332f, 0.03430410f, 
    -0.00117016f, 0.02031534f, 0.00745134f, 0.03635351f, -0.01966396f, -0.24475649f, 0.00149572f, -0.09174567f, 
    0.05772410f, -0.04062222f, 0.10505477f, 0.06119035f, -0.00628965f, 0.07343706f, -0.06355502f, -0.03104765f, 
    0.12089922f, 0.04602621f, 0.06689294f, 0.01827777f, 0.00033693f, -0.02460653f, 0.01360505f, 0.08750737f, 
    -0.29454330f, 0.10641233f, -0.13683832f, 0.11927862f, -0.13526003f, -0.09471708f, 0.06102524f, -0.05462861f, 
    0.03434988f, -0.00394399f, 0.04405108f, 0.08712076f, 0.03756331f, -0.13408367f, -0.03837241f, 0.01984912f, 
    0.03411898f, 0.00952516f, -0.00620036f, 0.08856070f, -0.04790857f, -0.01596756f, 0.21600963f, 0.11280052f, 
    0.08832981f, -0.08009706f, 0.03597350f, 0.11651047f, 0.07177941f, 0.16438743f, 0.05526663f, -0.03626379f, 
    0.03837737f, -0.00829329f, 0.08499151f, 0.09961429f, -0.01341547f, 0.10620390f, -0.03168513f, 0.03964930f, 
    0.19682479f, -0.18516536f, 0.06461928f, 0.07185125f, -0.15727712f, 0.00210544f, 0.07445055f, 0.13512105f, 
    0.00908129f, 0.16988270f, -0.02814635f, 0.01605890f, 0.04221504f, 0.09607888f, 0.03895168f, -0.04935114f, 
    0.06099608f, -0.05233682f, 0.00041814f, 0.01801296f, -0.37134740f, -0.05629767f, -0.29652253f, -0.06134449f, 
    -0.08532530f, 0.11927111f, 0.03216046f, 0.00426575f, 0.24411635f, 0.04512497f, 0.05810853f, -0.00316924f, 
    -0.12745409f, -0.05397464f, 0.03408564f, 0.09525147f, -0.02181923f, -0.09400023f, -0.02910047f, 0.11143106f, 
    0.01138726f, -0.03432452f, -0.03836785f, -0.00992979f, -0.06009657f, -0.03164956f, 0.03310892f, -0.02035274f, 
    0.00239138f, -0.00426448f, -0.00046707f, -0.04046783f, -0.01801370f, 0.02891539f, -0.05131276f, -0.03728512f, 
    0.04407761f, -0.02847287f, -0.04977508f, -0.01587929f, -0.01801135f, -0.02822689f, 0.00446568f, -0.04447890f, 
    0.02549062f, 0.00144198f, -0.03655785f, 0.05053481f, 0.01893236f, -0.01110380f, -0.00546861f, -0.04663186f, 
    -0.05612671f, -0.04877613f, 0.00003156f, -0.04186564f, 0.00724744f, -0.01198471f, -0.04863638f, 0.04231101f, 
    -0.05062737f, -0.01589827f, 0.03250653f, 0.03433198f, -0.04475294f, 0.03745788f, -0.03266550f, -0.03137532f, 
    -0.05934517f, 0.02870567f, 0.03117835f, 0.03964316f, 0.03189233f, 0.01496851f, -0.05699847f, -0.00475644f, 
    0.01048836f, 0.03530419f, -0.05018442f, -0.01413053f, 0.00008886f, 0.00989150f, 0.04499220f, 0.02221921f, 
    -0.05626383f, 0.02749133f, -0.05396289f, -0.04554968f, 0.02214699f, -0.00706396f, 0.04243910f, -0.03214283f, 
    -0.01470929f, -0.02075540f, -0.02710158f, 0.04980956f, -0.01549225f, 0.01265176f, -0.05693686f, -0.04021861f, 
    0.04478178f, 0.03226956f, -0.04022690f, -0.03831360f, 0.02163536f, 0.02803114f, 0.01305050f, 0.03264539f, 
    -0.01660766f, 0.00193235f, 0.00099950f, -0.02508569f, 0.02807348f, -0.01882709f, 0.03915609f, -0.03772741f, 
    0.03662409f, -0.02174563f, -0.00630429f, 0.02891797f, 0.01125421f, 0.00810568f, 0.02565272f, 0.03420236f, 
    -0.01881241f, -0.06050533f, 0.00932437f, 0.01298224f, -0.03542132f, 0.02015061f, -0.01726953f, 0.01412309f, 
    -0.05572302f, 0.01802682f, -0.03923419f, -0.04855054f, 0.00850433f, -0.03801418f, -0.02279213f, 0.04074139f, 
    0.01344459f, 0.00878472f, -0.01728753f, -0.03834893f, 0.04214827f, -0.05102123f, -0.02158486f, -0.01084046f, 
    -0.05078451f, 0.02438840f, 0.02859528f, 0.02508374f, 0.03536401f, 0.04964535f, -0.05622417f, -0.01936167f, 
    0.04989773f, -0.02259393f, -0.04114933f, -0.00588853f, -0.00030115f, -0.02676854f, -0.02555143f, -0.00781014f, 
    -0.04077115f, 0.01629683f, -0.05343535f, 0.00735917f, -0.02843574f, 0.02143425f, -0.04159394f, -0.04234586f, 
    -0.01844696f, 0.04966238f, -0.05546819f, 0.01459657f, -0.02301579f, 0.03602861f, 0.01777293f, 0.02067847f, 
    0.03305358f, 0.01631775f, 0.03416335f, 0.00441726f, 0.02600669f, 0.00656240f, 0.01553593f, 0.00589196f, 
    0.00616451f, 0.04470032f, 0.04759406f, -0.05279952f, -0.02877791f, 0.03631630f, -0.00686162f, 0.01207389f, 
    -0.03641143f, 0.00363117f, -0.01709184f, -0.00601051f, -0.02100892f, -0.02926668f, 0.02134761f, -0.00338451f, 
    -0.04289183f, -0.01971968f, 0.04885488f, 0.01677509f, 0.00580078f, 0.04608408f, -0.02336205f, -0.01846013f, 
    0.00543384f, 0.02899016f, -0.03011342f, -0.00289387f, 0.03215937f, -0.04251532f, -0.02515987f, 0.03328697f, 
    -0.02415323f, -0.02642513f, 0.00596965f, -0.05682980f, -0.02964458f, 0.02457914f, 0.02463875f, 0.01004685f, 
    0.01458451f, 0.03076667f, 0.02518955f, -0.00235396f, -0.02603438f, 0.00776859f, 0.01830761f, 0.03097022f, 
    -0.03669031f, -0.01772849f, 0.01109549f, -0.05922672f, -0.05187918f, -0.03545054f, -0.06067620f, 0.04705186f, 
    -0.00470229f, 0.02642026f, -0.04092275f, -0.00639357f, -0.05350536f, -0.02770798f, -0.05790947f, -0.01605802f, 
    -0.02227214f, -0.04069034f, -0.02094397f, -0.05366987f, 0.04823208f, 0.01755836f, 0.01901629f, -0.01319070f, 
    -0.00739121f, -0.04178509f, -0.05269542f, 0.00055749f, -0.04390770f, -0.06072165f, -0.02902427f, -0.02328191f, 
    0.04426446f, -0.00194747f, -0.03462043f, -0.05039890f, -0.00115977f, 0.00888496f, -0.00751097f, -0.00004876f, 
    0.04353519f, -0.01517096f, -0.00731579f, 0.04758577f, 0.01018757f, -0.02440804f, 0.04021726f, -0.02557318f, 
    -0.03038935f, -0.05997088f, 0.03417356f, -0.02591223f, 0.01323982f, 0.04259605f, -0.03383715f, 0.02054821f, 
    -0.01569324f, 0.01338767f, 0.02554834f, 0.02072719f, -0.04287404f, -0.05706764f, 0.04936307f, -0.05827602f, 
    -0.04315945f, -0.02604613f, 0.00945193f, 0.02246877f, -0.03770809f, -0.02033139f, -0.03802701f, 0.03766622f, 
    -0.04539840f, -0.05466753f, -0.00682814f, -0.01490417f, 0.02465838f, -0.03235564f, 0.00028466f, 0.04313913f, 
    -0.05566731f, 0.01818414f, 0.01302565f, 0.01802025f, -0.05467807f, -0.02345000f, -0.02836609f, -0.03298911f, 
    -0.02593227f, -0.04917522f, -0.02477768f, 0.00391693f, 0.01826108f, 0.00051060f, -0.03023650f, -0.01825665f, 
    -0.02609140f, 0.02149881f, -0.00754263f, 0.01254988f, -0.02311262f, -0.05389089f, -0.04903190f, -0.04474581f, 
    -0.04143947f, -0.18691857f, -0.22829956f, -0.17696232f, 0.37130311f, -0.09477249f, -0.03828796f, -0.07640095f, 
    -0.00070430f, -0.04015093f, -0.07184318f, -0.05001865f, 0.03859610f, 0.10460818f, -0.12295640f, 0.03873472f, 
    -0.06959438f, -0.12182516f, -0.05265678f, -0.04694211f, 0.09762434f, -0.20168297f, 0.18390071f, 0.11281890f, 
    -0.08877261f, 0.01848204f, 0.21441473f, 0.07989766f, 0.02110871f, 0.09128378f, -0.06873615f, 0.02470830f, 
    -0.01167833f, -0.03986991f, 0.06054305f, -0.03296475f, -0.03498611f, -0.01529316f, -0.00891214f, -0.12495951f, 
    0.48270881f, 0.32421157f, 0.28566495f, 0.11328543f, -0.28860903f, -0.23260950f, -0.05295445f, -0.17706141f, 
    -0.00091749f, -0.12872893f, 0.09849572f, 0.10614426f, 0.00394101f, -0.10789344f, 0.07459925f, 0.02617447f, 
    0.03853356f, -0.01014409f, 0.03800604f, 0.05775725f, 0.10031331f, 0.23457935f, 0.06996332f, 0.02552418f, 
    -0.01975107f, 0.09582655f, -0.12188403f, 0.02358815f, 0.03002760f, 0.05659585f, 0.12082374f, 0.16223389f, 
    0.04484808f, -0.02517380f, 0.10375714f, -0.03767590f, -0.02200945f, -0.08468404f, -0.02172611f, -0.00791615f, 
    0.30668539f, -0.17861977f, 0.26942518f, 0.20249680f, -0.19019131f, -0.08842067f, 0.04860260f, 0.07968561f, 
    -0.04464592f, 0.19158019f, -0.05034801f, -0.05772585f, 0.03118629f, -0.08910834f, -0.04502190f, -0.04850829f, 
    -0.01252013f, -0.04784508f, -0.15694247f, 0.11471851f, -0.10427701f, -0.02960570f, 0.02276717f, -0.01341674f, 
    -0.02744107f, 0.09167848f, -0.15251288f, 0.06152902f, -0.03492657f, 0.10929471f, 0.03168379f, -0.06620374f, 
    -0.03586728f, 0.07864820f, -0.01393655f, 0.04848939f, 0.06606409f, -0.00779103f, -0.05894627f, -0.14113718f, 
    0.09456923f, -0.14889936f, 0.02298447f, -0.03424009f, 0.04606650f, -0.19090548f, 0.00263487f, 0.02330493f, 
    0.04377550f, -0.01151962f, 0.08373024f, 0.12003300f, 0.04913033f, -0.05340196f, 0.01188979f, 0.06573974f, 
    -0.03428362f, 0.01576116f, 0.20679031f, 0.05910897f, 0.08585719f, 0.18846561f, 0.19290392f, 0.12218019f, 
    -0.18212533f, 0.04688374f, 0.01891872f, 0.04541607f, -0.02301465f, -0.00531272f, 0.12741137f, 0.04571383f, 
    -0.15616147f, 0.03255231f, -0.10406660f, -0.06296457f, -0.04207165f, -0.10607098f, -0.12603477f, -0.17538983f, 
    0.07273607f, -0.21240398f, -0.10394152f, -0.17967781f, 0.25779510f, -0.03463643f, 0.03616739f, -0.19817166f, 
    0.06598290f, -0.02413649f, -0.13674194f, -0.04207493f, -0.09519430f, 0.04384916f, 0.07501865f, 0.05916648f, 
    -0.02791107f, 0.00819716f, 0.08770760f, 0.11942737f, -0.07321150f, -0.00820982f, -0.03193094f, 0.16556881f, 
    -0.09144728f, -0.10015935f, 0.12109680f, 0.01025168f, -0.02254107f, 0.06330649f, -0.05484198f, 0.12776612f, 
    0.00754173f, -0.05654745f, 0.06064026f, -0.01714107f, -0.02615017f, 0.15081266f, 0.01824456f, -0.00289404f, 
    0.38195133f, 0.01786275f, 0.13619477f, -0.14752795f, -0.21636339f, -0.19861616f, 0.09016692f, 0.04409820f, 
    -0.00123596f, -0.10216742f, 0.09052031f, 0.00211896f, 0.07497665f, 0.02774949f, -0.01989858f, -0.02159740f, 
    0.12130776f, -0.01282679f, -0.01673346f, 0.07958356f, 0.12585767f, 0.01468546f, -0.01463141f, 0.00988237f, 
    0.05999834f, -0.01331512f, -0.16527900f, 0.04110040f, -0.05993855f, -0.02178349f, -0.17838420f, 0.05550191f, 
    0.16224858f, -0.03552738f, -0.00684433f, 0.07560254f, 0.16680574f, 0.03360843f, 0.09002779f, -0.03703357f, 
    -0.02310541f, 0.07191925f, 0.05146544f, 0.14538793f, -0.00909571f, 0.02034625f, 0.02889410f, -0.00439670f, 
    -0.00264393f, -0.14273366f, -0.08980613f, 0.10627147f, 0.01240059f, 0.08412094f, -0.03006582f, -0.00613179f, 
    -0.01067506f, 0.10502717f, -0.01558861f, 0.10361046f, -0.21811359f, -0.06596367f, -0.13143691f, 0.00839571f, 
    0.28014699f, -0.10203464f, -0.11759899f, -0.01953354f, -0.03263192f, 0.00697717f, -0.03556340f, 0.03639772f, 
    -0.01930581f, 0.05447340f, 0.00091224f, -0.07519670f, -0.12174576f, -0.01530422f, -0.06888581f, 0.06251424f, 
    0.04384446f, -0.02803047f, -0.05065319f, -0.00616739f, 0.06229120f, 0.15295996f, -0.03163153f, 0.02512475f, 
    -0.03947389f, 0.16042018f, -0.14597756f, 0.00834361f, -0.01555752f, -0.02954660f, -0.00731567f, -0.08656351f, 
    0.09590628f, -0.00528021f, -0.07270603f, -0.06135989f, 0.13953839f, 0.06264453f, 0.15467671f, -0.10684709f, 
    -0.17383578f, -0.07983024f, -0.08667846f, 0.06693461f, 0.12652752f, 0.05880482f, 0.00915620f, -0.01571096f, 
    -0.00773724f, 0.10980064f, 0.05430095f, 0.01218887f, 0.07164889f, 0.08779292f, 0.09992107f, 0.00519926f, 
    0.14123777f, -0.14245899f, -0.06793204f, 0.02092119f, -0.01638795f, 0.00419806f, 0.02122401f, 0.09751687f, 
    0.00402830f, -0.01801131f, 0.17777887f, 0.05962821f, 0.07136742f, -0.18687749f, 0.20692566f, 0.03606822f, 
    0.09465331f, 0.01714914f, 0.11044583f, 0.12558270f, 0.06687674f, 0.26553276f, -0.06767595f, 0.16794467f, 
    0.22809526f, -0.07907012f, -0.12615255f, -0.13305582f, -0.02958062f, -0.07523292f, 0.15199566f, 0.08922167f, 
    0.00946817f, -0.02015505f, -0.02379685f, -0.06829110f, 0.09697118f, 0.04205115f, -0.08421576f, 0.01473346f, 
    -0.51906645f, 0.23249492f, 0.21750484f, 0.11547639f, 0.31148639f, -0.01178311f, 0.02360753f, 0.06122616f, 
    0.14275837f, -0.09027559f, -0.00780708f, -0.14302029f, 0.04492265f, -0.11072547f, -0.07560800f, -0.00475585f, 
    -0.05031904f, 0.07448370f, 0.11147335f, 0.04291481f, 0.20090817f, 0.07181251f, 0.18860783f, -0.01479842f, 
    -0.39113304f, 0.00401510f, -0.01927756f, 0.03100049f, -0.00803603f, -0.05747784f, -0.04351227f, -0.13528672f, 
    0.03852265f, 0.02643264f, -0.02654346f, 0.00590993f, 0.06297331f, 0.05374874f, 0.04231336f, 0.00420529f, 
    -0.23280880f, -0.04936738f, -0.13224530f, 0.29445899f, 0.17057075f, 0.07720830f, -0.10947789f, -0.08633526f, 
    0.01820686f, -0.19141972f, 0.07200680f, 0.19561845f, 0.00070902f, -0.02327448f, 0.10497637f, 0.07318523f, 
    -0.00389381f, 0.02904374f, -0.02888731f, -0.10303137f, 0.13740401f, -0.05458521f, 0.02897807f, -0.03550509f, 
    0.00639595f, -0.09858608f, 0.00910135f, 0.03234480f, 0.01411639f, -0.08120470f, -0.02312627f, 0.00628614f, 
    -0.04350863f, -0.01066697f, 0.10274115f, 0.08601081f, 0.00949233f, 0.03650750f, -0.04220572f, -0.02690594f, 
    -0.08224142f, 0.24276851f, 0.05685924f, -0.00322596f, -0.12246451f, 0.00639134f, 0.02837684f, 0.01966583f, 
    -0.07520914f, 0.07225607f, 0.00019998f, 0.00399216f, 0.03842088f, 0.08893593f, -0.04693441f, 0.06692699f, 
    -0.00665624f, 0.05744304f, 0.13523017f, 0.11556934f, 0.23030160f, -0.08064073f, -0.01706818f, 0.39819530f, 
    0.17263596f, 0.08104578f, 0.03693115f, 0.08510856f, -0.04315811f, 0.04991779f, -0.07585362f, -0.02057665f, 
    0.02752409f, 0.00292127f, -0.07104892f, -0.02679256f, 0.04584932f, -0.05466103f, 0.01237910f, 0.03847430f, 
    0.00399066f, 0.32903576f, -0.17107791f, 0.03107269f, -0.19555639f, 0.07006458f, 0.15049540f, 0.14182633f, 
    -0.14054880f, 0.15423520f, 0.05977551f, 0.03026912f, -0.01289486f, -0.02349368f, 0.11569070f, 0.13233086f, 
    -0.02324688f, -0.00466953f, 0.07005564f, 0.01568251f, -0.42637151f, 0.12557416f, -0.03743401f, -0.11640195f, 
    -0.11836483f, 0.00729018f, 0.05152646f, -0.10405385f, 0.05226507f, 0.07009482f, 0.12206072f, 0.02760970f, 
    -0.00134190f, -0.01729777f, -0.06440374f, -0.06707319f, -0.01431389f, -0.15080535f, -0.15244611f, 0.01140100f, 
    -0.43083924f, 0.45119157f, 0.08310338f, 0.18122599f, 0.14901741f, 0.02484877f, -0.13235578f, 0.03555072f, 
    0.08440822f, 0.06207892f, 0.02223008f, -0.02106602f, -0.07615368f, -0.10183956f, 0.02564525f, -0.09737569f, 
    -0.01646128f, -0.03301701f, 0.05969356f, -0.12644778f, -0.16295719f, -0.01654061f, 0.02509010f, -0.08974474f, 
    -0.14616016f, 0.05830539f, 0.10944629f, -0.01040757f, 0.08489760f, 0.13572367f, 0.00072313f, 0.02554830f, 
    -0.01847349f, 0.02448168f, 0.02354224f, 0.01862591f, -0.06295840f, -0.03609741f, -0.01044394f, 0.01120642f, 
    -0.00443625f, 0.12168118f, -0.17872776f, -0.11970083f, 0.15984474f, -0.08911204f, 0.06942939f, 0.05087441f, 
    0.10739770f, 0.15551268f, 0.04489514f, 0.02230856f, 0.04649574f, -0.03743850f, -0.00247871f, 0.02196339f, 
    0.05755253f, -0.05307745f, -0.09562219f, -0.01437803f, 0.16545381f, -0.08500138f, 0.03475374f, -0.18413979f, 
    -0.06920422f, 0.31143260f, 0.15826577f, -0.08615579f, -0.07886644f, -0.05864790f, 0.08151994f, 0.00517572f, 
    0.12229709f, -0.06284021f, 0.07100214f, -0.03099869f, -0.03030631f, 0.11863711f, 0.04515946f, -0.03614998f, 
    0.05229807f, 0.04901594f, -0.02408336f, -0.01147489f, -0.15547724f, 0.02897200f, -0.04529399f, -0.09398778f, 
    0.02407452f, -0.12390909f, 0.07921731f, 0.12426928f, -0.00622770f, -0.01723903f, -0.01577865f, 0.00304652f, 
    0.00951821f, -0.11404902f, 0.00037911f, -0.02747181f, -0.05592795f, 0.04999471f, -0.00853519f, -0.13394381f, 
    -0.03081855f, 0.10955735f, 0.05455007f, -0.06010136f, 0.01319862f, 0.03115588f, 0.04051395f, 0.15795603f, 
    -0.09887636f, -0.03274602f, -0.12000283f, 0.05524483f, -0.00498416f, 0.12078186f, -0.06997264f, 0.01948887f, 
    -0.07619530f, -0.05171148f, -0.01286276f, -0.00954436f, 0.03498570f, -0.03033513f, 0.02493946f, -0.03826289f, 
    -0.05364166f, -0.04324612f, -0.06761180f, 0.04470015f, 0.04704610f, 0.00004434f, 0.03075126f, -0.05049448f, 
    0.00889251f, -0.05819513f, -0.05245903f, 0.01070816f, -0.02892570f, 0.00735173f, -0.01370674f, -0.00806549f, 
    -0.03458185f, 0.03793978f, 0.02221690f, 0.01162339f, -0.02060751f, -0.05939813f, -0.05760261f, 0.03784686f, 
    0.04317832f, -0.05762223f, -0.05576888f, 0.00710575f, -0.02935091f, 0.04036082f, -0.00070759f, -0.01624754f, 
    0.02827886f, -0.00794354f, 0.03955976f, -0.03908701f, 0.03441353f, -0.01219626f, 0.01645256f, -0.00705730f, 
    -0.00521922f, -0.05004841f, 0.02224608f, 0.03019084f, -0.04046179f, -0.04275639f, -0.00715386f, -0.02800048f, 
    0.04365082f, 0.03100592f, 0.03952724f, 0.01305507f, 0.02899767f, -0.01918993f, 0.00005171f, -0.04351499f, 
    -0.00316956f, 0.02072486f, -0.03129527f, 0.01258224f, -0.03376885f, 0.00923420f, -0.04695977f, 0.02965911f, 
    -0.02205257f, 0.00830465f, 0.01185889f, 0.01377712f, 0.04458848f, -0.05084601f, 0.01944960f, -0.05316026f, 
    -0.01357483f, 0.03034133f, -0.05238654f, -0.03061522f, -0.03298772f, 0.01347343f, -0.01547819f, 0.03619386f, 
    -0.01320924f, 0.03438149f, -0.01807741f, 0.02700567f, -0.00609905f, 0.01778522f, -0.01129516f, -0.06293617f, 
    0.03198775f, -0.04488312f, 0.04720745f, 0.01856408f, -0.05621640f, 0.01465966f, 0.04848178f, 0.02824559f, 
    -0.02266131f, -0.06518595f, 0.02165928f, -0.05133830f, 0.03182322f, -0.01999065f, -0.04655359f, 0.03448229f, 
    0.01190799f, 0.01761812f, 0.01562404f, -0.00223277f, -0.01308209f, -0.03353138f, -0.00690242f, 0.03506240f, 
    -0.05659478f, -0.02157944f, -0.03771938f, -0.01749670f, 0.02379510f, -0.06251477f, 0.01926659f, 0.04589417f, 
    0.00240958f, -0.05496160f, -0.02813826f, -0.00360497f, -0.06001897f, 0.00333230f, 0.01942403f, 0.03973133f, 
    0.03904361f, -0.02248068f, 0.01300661f, -0.04038056f, -0.03293366f, 0.00457760f, 0.00399353f, 0.04701377f, 
    -0.03910963f, -0.00763422f, 0.04131156f, 0.01460438f, -0.02881742f, 0.05009662f, -0.03637869f, -0.00247679f, 
    0.03019766f, -0.06058700f, -0.02344059f, -0.04779159f, 0.00791293f, 0.03881822f, 0.00463176f, -0.03524353f, 
    -0.04613532f, -0.06139298f, -0.06192383f, 0.03308191f, -0.01072350f, -0.04480724f, 0.02931695f, 0.04130420f, 
    -0.02320490f, 0.02287978f, 0.00561226f, 0.03985421f, -0.02871992f, 0.04868700f, -0.01275660f, 0.01680960f, 
    0.01776551f, 0.01910670f, 0.00639595f, -0.05139150f, 0.03048198f, 0.04848650f, -0.05095157f, -0.06102884f, 
    -0.03731918f, -0.02799644f, 0.00646272f, -0.05402269f, 0.01028894f, -0.02070414f, -0.06086989f, -0.03001877f, 
    -0.02457644f, 0.01547945f, -0.04638923f, 0.04803726f, 0.01348508f, -0.01188883f, 0.01625178f, -0.01650881f, 
    -0.04369287f, 0.01802669f, -0.00589609f, 0.00464066f, 0.02083752f, 0.00575097f, 0.04794733f, -0.04302969f, 
    -0.03190468f, 0.03825700f, 0.00020013f, 0.05297280f, 0.03131292f, 0.03999200f, 0.02552822f, -0.00819528f, 
    -0.00106678f, 0.02985529f, -0.01488922f, -0.06046019f, 0.02347030f, -0.06514816f, -0.06855318f, 0.04073447f, 
    0.03906310f, -0.01222152f, -0.00131659f, -0.02383930f, -0.00217117f, -0.03340182f, 0.03193704f, -0.00694258f, 
    0.01384073f, -0.05392626f, -0.03776513f, -0.05691860f, -0.01459646f, -0.02437776f, 0.01319783f, -0.02509979f, 
    0.02152859f, 0.00503770f, 0.00352990f, 0.03543549f, -0.04064195f, -0.04041747f, -0.02868990f, -0.02631078f, 
    -0.04793103f, -0.01366973f, -0.05578642f, 0.02914448f, -0.03499433f, 0.02027856f, 0.00749099f, 0.01883275f, 
    0.00265890f, 0.00082119f, -0.01132846f, 0.01344840f, -0.02819154f, 0.00921772f, -0.04731989f, -0.04651930f, 
    -0.01534085f, 0.04100517f, -0.01858562f, 0.01441674f, 0.02539162f, 0.01149848f, -0.03432483f, -0.00692839f, 
    -0.04879199f, -0.05188132f, -0.02009527f, 0.00849112f, -0.05861469f, 0.03094539f, -0.00435267f, 0.00747172f, 
    -0.02433482f, 0.02325677f, -0.01937669f, 0.01049200f, -0.00091030f, -0.03751931f, -0.01138315f, 0.01065243f, 
    0.01956487f, -0.05244490f, -0.03967969f, 0.04572886f, 0.01268350f, 0.00584752f, 0.01390685f, -0.05149470f, 
    0.00434099f, -0.03551817f, 0.01038008f, -0.05174027f, 0.02923307f, 0.02950813f, 0.00135997f, 0.01138830f, 
    -0.03179880f, 0.03870248f, 0.00293934f, 0.03390329f, 0.02506475f, -0.01322756f, 0.04597629f, 0.02923064f, 
    -0.02314898f, 0.03628027f, -0.05025553f, -0.00339399f, -0.02381880f, -0.03378213f, 0.00482227f, 0.01779301f, 
    0.28560171f, -0.05959346f, -0.39371961f, -0.16620646f, 0.18289994f, -0.18058765f, 0.02133807f, -0.15358029f, 
    -0.06356551f, -0.17237653f, 0.00658178f, -0.03672558f, -0.14231528f, -0.00027403f, 0.03013660f, 0.02344988f, 
    -0.00743476f, 0.00940159f, -0.02419126f, -0.05276904f, 0.06602141f, 0.21822244f, 0.05563780f, -0.11504992f, 
    0.20173047f, 0.02274849f, 0.01978396f, 0.01029427f, 0.01995323f, -0.18852615f, 0.00802096f, 0.07412445f, 
    0.04224306f, 0.06075764f, -0.06897052f, -0.08576112f, 0.04646982f, 0.05367164f, 0.02691304f, -0.06859355f, 
    -0.01729212f, 0.25462174f, 0.31136283f, 0.17780307f, 0.03111137f, 0.01161873f, -0.05998933f, -0.05226716f, 
    0.02040220f, -0.15352198f, -0.10782658f, -0.05414291f, 0.03406496f, -0.02549331f, -0.10063243f, -0.09751140f, 
    -0.03681544f, 0.04046037f, -0.00671271f, -0.07560603f, -0.12749709f, 0.19718213f, -0.21549313f, 0.08915670f, 
    0.07129693f, 0.01083749f, -0.03142552f, 0.02888343f, -0.00137397f, 0.02061545f, -0.01891455f, -0.03085888f, 
    0.01227541f, 0.01669120f, 0.08512918f, -0.05082753f, 0.02834819f, -0.01671056f, -0.00998262f, -0.07366231f, 
    0.10865695f, -0.06665687f, 0.29737046f, 0.02698199f, 0.29734501f, 0.07360898f, 0.08698475f, -0.00807051f, 
    -0.03943603f, -0.08634286f, -0.01938082f, -0.05326553f, 0.01311711f, 0.12568086f, 0.04392656f, 0.09072141f, 
    0.02763951f, -0.03453395f, 0.07811707f, 0.15328957f, 0.00732109f, 0.11767159f, -0.06733836f, -0.14466661f, 
    0.04542618f, 0.14135022f, -0.13052736f, 0.02280245f, -0.01817254f, 0.00669738f, 0.00834853f, -0.00218991f, 
    -0.08694923f, -0.05542460f, -0.01874189f, 0.14512792f, -0.03996206f, -0.06215489f, 0.18284027f, -0.01012905f, 
    0.00243304f, 0.09361726f, 0.04006039f, -0.06288034f, 0.06852186f, 0.04556952f, -0.03155221f, -0.09949584f, 
    0.04408556f, 0.04441692f, 0.02860392f, -0.00777952f, 0.01193146f, 0.02716807f, 0.07805011f, 0.09761599f, 
    -0.02944582f, 0.07595373f, -0.01280699f, -0.08435631f, 0.30902722f, 0.08093102f, 0.16075228f, 0.24249646f, 
    0.07672379f, 0.01136789f, 0.06878927f, -0.02165602f, 0.03380309f, 0.00668553f, -0.08563990f, 0.01688340f, 
    -0.01122772f, 0.05716669f, -0.01887481f, 0.04390140f, -0.09339494f, 0.03064786f, 0.08963012f, -0.00977165f, 
    0.06217340f, 0.22195406f, 0.02985084f, -0.06070201f, 0.13037702f, 0.11299548f, 0.11832530f, -0.01766070f, 
    0.02133982f, -0.10277311f, 0.02492453f, -0.00993888f, -0.05791087f, 0.05707531f, 0.19342656f, -0.11462986f, 
    -0.03159525f, 0.03960835f, 0.14531830f, 0.05516832f, 0.10226578f, 0.09717003f, -0.34294003f, -0.17664012f, 
    -0.21956375f, -0.04127447f, -0.12068589f, -0.04964702f, 0.04898286f, 0.05864588f, -0.13041307f, -0.00546174f, 
    -0.00250439f, 0.12611957f, -0.05069818f, 0.01599777f, 0.03299708f, 0.01581254f, -0.05146217f, -0.06470294f, 
    0.37950799f, 0.06733539f, 0.14079890f, 0.26525196f, -0.01176834f, -0.08832190f, 0.00260668f, 0.12237975f, 
    0.06150920f, 0.14634942f, -0.14014737f, -0.02698565f, 0.06747522f, 0.06597091f, -0.02984891f, -0.06133019f, 
    0.04173324f, 0.10411290f, -0.12653443f, 0.07544166f, 0.12114546f, 0.21809234f, -0.02034226f, 0.08248025f, 
    0.13418517f, -0.03816830f, -0.07902998f, 0.10337152f, 0.02064198f, 0.03679390f, -0.03160805f, 0.01255505f, 
    -0.02839990f, -0.11474860f, 0.04195655f, -0.00947599f, -0.01594399f, -0.02848267f, 0.06925519f, 0.02963902f, 
    -0.32756141f, 0.18176034f, -0.09917559f, -0.00414115f, 0.16885805f, 0.04389742f, 0.06268194f, 0.04559448f, 
    0.01015570f, 0.03869721f, -0.21706170f, -0.00094643f, -0.03603416f, 0.10497335f, -0.04857374f, 0.03162624f, 
    -0.02531729f, 0.00195630f, -0.01094448f, 0.04270754f, 0.33093494f, -0.38973632f, -0.31369984f, -0.35526627f, 
    0.05095632f, -0.09726989f, -0.07238947f, -0.09288792f, -0.16431689f, -0.08902857f, -0.06964927f, -0.11986711f, 
    0.05863588f, 0.06588317f, -0.00384867f, 0.10592681f, 0.03420682f, 0.00446664f, -0.04724686f, -0.06559943f, 
    0.11561000f, 0.17951976f, -0.04792961f, -0.08380055f, 0.15617427f, 0.09102008f, -0.10090815f, -0.00966728f, 
    -0.11789785f, 0.05281550f, 0.03635117f, 0.01489902f, -0.08225471f, -0.01680145f, -0.03409925f, -0.09055247f, 
    0.09617133f, 0.03711034f, 0.02482408f, 0.03410307f, 0.38065821f, 0.14741306f, 0.18489511f, 0.07995171f, 
    -0.13486433f, 0.03631705f, -0.15614608f, -0.00556266f, -0.05500098f, 0.00292267f, -0.13070346f, -0.00624130f, 
    0.05937153f, -0.03426732f, -0.01155264f, 0.09955090f, -0.02138519f, 0.05742614f, 0.15168960f, -0.07827918f, 
    -0.00676003f, 0.01524632f, 0.03891373f, 0.04556599f, -0.06242790f, 0.00842794f, -0.02175561f, -0.04171653f, 
    -0.00544998f, 0.03233540f, 0.04002562f, 0.01068386f, -0.01762445f, -0.05277676f, 0.02468392f, 0.04294496f, 
    -0.01966751f, -0.02037443f, -0.04312773f, -0.01106848f, -0.05056932f, 0.02178736f, -0.02780803f, 0.01167092f, 
    0.01102870f, -0.02531502f, 0.00809179f, 0.03816037f, 0.00313480f, 0.04721804f, -0.00301317f, 0.02132980f, 
    0.01736738f, 0.01808720f, 0.03468914f, -0.02258096f, -0.04049363f, 0.00611483f, 0.00291819f, -0.01480618f, 
    0.03323761f, -0.04939340f, -0.02405765f, 0.00645693f, -0.00557144f, 0.03433052f, -0.01510713f, -0.00211261f, 
    -0.05227683f, 0.02948060f, -0.00623156f, 0.01214549f, 0.01834850f, -0.05118903f, 0.01669145f, 0.02948373f, 
    0.01369603f, 0.03302240f, 0.03072304f, -0.02256041f, -0.01908604f, -0.03907612f, 0.00460762f, -0.02128287f, 
    -0.01648087f, -0.02459029f, 0.02981788f, 0.02761179f, 0.00422806f, -0.00730167f, 0.02032081f, -0.00854865f, 
    -0.01307496f, -0.00844406f, -0.05218843f, 0.02523458f, -0.00019398f, -0.05765587f, 0.04422194f, 0.01355173f, 
    -0.02206245f, -0.06382062f, 0.03100168f, 0.03261731f, -0.02884135f, 0.00702380f, -0.05313678f, -0.00399903f, 
    0.02939332f, 0.01798683f, -0.06271204f, 0.03913820f, -0.00092710f, -0.00638881f, 0.03019181f, -0.06035402f, 
    -0.04193234f, 0.00543244f, 0.01092405f, -0.01865181f, 0.02186017f, 0.04404723f, 0.03914887f, -0.04648567f, 
    -0.02257432f, -0.03844326f, 0.00752028f, 0.00253977f, 0.03052396f, 0.02669956f, -0.00142574f, -0.01661692f, 
    -0.05468446f, 0.03095752f, -0.06478502f, 0.02092738f, 0.00796232f, -0.04663995f, -0.01951799f, 0.04542456f, 
    -0.00592756f, -0.05826939f, -0.00362294f, -0.02944114f, -0.06720272f, 0.03854442f, -0.05885689f, 0.01832910f, 
    -0.03750610f, -0.03464880f, 0.04399075f, 0.01668236f, -0.00800844f, 0.00463301f, -0.02860030f, 0.02008847f, 
    0.02182409f, -0.03278830f, -0.02839589f, 0.01795197f, -0.01528614f, -0.04315475f, -0.01303582f, -0.03925388f, 
    0.00133906f, -0.06073574f, -0.02763110f, -0.06256635f, 0.04396846f, 0.02717886f, 0.00435164f, 0.01728509f, 
    -0.02349875f, 0.02358822f, -0.05157771f, -0.03440923f, 0.01634979f, -0.02480964f, -0.03992319f, 0.02588964f, 
    0.00111041f, 0.02780429f, -0.02031179f, -0.06214586f, -0.05963401f, 0.03546615f, -0.02788543f, -0.05979988f, 
    -0.01832701f, -0.06034205f, -0.01890559f, 0.01691260f, 0.02432547f, -0.04656098f, -0.00799194f, -0.00600089f, 
    0.01917641f, -0.01594228f, -0.06038763f, 0.02205112f, -0.04378440f, -0.00546994f, -0.06135282f, 0.01771615f, 
    0.00617711f, 0.01883142f, 0.03328984f, 0.02363397f, -0.04220568f, -0.02563574f, 0.02641110f, -0.04319376f, 
    -0.04788558f, 0.00139817f, -0.05955159f, -0.04255778f, 0.03254710f, -0.03321205f, -0.00459308f, -0.06516229f, 
    0.00997277f, -0.02817062f, -0.02548038f, 0.04097892f, 0.04412508f, 0.00976065f, -0.00384575f, 0.03734861f, 
    -0.05865820f, 0.01483019f, -0.04316311f, 0.00294372f, -0.01628996f, 0.00522326f, 0.01349332f, -0.03282949f, 
    0.02331862f, -0.04667274f, -0.05624219f, -0.02694782f, -0.01787475f, 0.01137174f, -0.04963971f, 0.00034580f, 
    0.01720168f, 0.02519235f, -0.04046412f, 0.01747159f, -0.03374951f, 0.01984852f, 0.00387665f, -0.01668501f, 
    -0.02198129f, 0.03841842f, -0.05357853f, -0.04795725f, 0.03922099f, -0.05034040f, -0.01845116f, -0.05714652f, 
    0.02816204f, -0.00910919f, 0.00790719f, 0.03401127f, -0.05681950f, -0.00047449f, -0.01967947f, -0.06590304f, 
    -0.05954794f, -0.06542800f, 0.01981460f, 0.00936554f, 0.00330371f, -0.00392174f, 0.04712372f, -0.03711016f, 
    0.02316832f, -0.03389325f, 0.04688278f, -0.03072701f, 0.04480421f, 0.00546683f, -0.00489692f, 0.00235566f, 
    -0.06495131f, 0.00917700f, -0.03656446f, 0.00615698f, 0.00102245f, -0.05000021f, -0.05691095f, -0.01348316f, 
    -0.02927437f, -0.02889340f, -0.01573673f, -0.02992642f, 0.01448194f, 0.00049676f, -0.00285222f, -0.01803418f, 
    0.02548740f, -0.03043122f, -0.02355012f, -0.04185474f, -0.01730783f, 0.00406701f, -0.05033538f, 0.02777450f, 
    -0.03853191f, -0.03740131f, -0.03235607f, -0.04809913f, 0.03404853f, 0.04287772f, -0.01202596f, -0.01003686f, 
    0.00403630f, 0.01877164f, -0.01746719f, -0.02002058f, 0.02522675f, 0.04444135f, 0.02366743f, -0.02337197f, 
    0.02017091f, -0.00377087f, 0.02192496f, 0.03239772f, -0.00774321f, 0.05853866f, -0.01887587f, -0.06072931f, 
    -0.06040828f, -0.03716021f, -0.01954375f, 0.02192893f, 0.00393573f, -0.01271820f, 0.03815880f, 0.00053390f, 
    0.33848450f, 0.56185758f, 0.14314032f, -0.05290289f, 0.14416215f, 0.15269710f, -0.03031958f, 0.10235819f, 
    0.09103967f, -0.05163941f, -0.06982805f, 0.03357079f, 0.05727637f, 0.04039525f, -0.03969885f, 0.01623251f, 
    0.00776125f, 0.00801659f, -0.01762386f, 0.00947197f, -0.15497443f, 0.02743441f, -0.08728202f, -0.00177011f, 
    -0.20845915f, -0.04720607f, -0.09721819f, -0.09732305f, 0.11416753f, 0.00406760f, -0.03056123f, 0.00569161f, 
    -0.04324690f, -0.07852774f, 0.02296835f, -0.06520614f, -0.08476765f, 0.12346879f, 0.17375526f, -0.00135330f, 
    0.38421524f, 0.02749500f, 0.25965855f, -0.06455798f, -0.02991956f, 0.19087115f, 0.16678387f, -0.01010669f, 
    -0.01656058f, 0.16399625f, -0.08499551f, 0.19245505f, -0.01100367f, 0.10596431f, 0.01958469f, 0.01927979f, 
    0.02386162f, -0.05509878f, -0.07740794f, 0.01209724f, -0.42087188f, -0.45058084f, -0.05898796f, -0.05203617f, 
    0.17077917f, -0.00229605f, -0.00154831f, 0.05220110f, -0.08320224f, -0.02655739f, 0.00287595f, 0.06772643f, 
    -0.05599770f, -0.01216387f, -0.08287881f, 0.12882474f, 0.01576928f, 0.07670737f, -0.03464046f, 0.03255504f, 
    0.00610993f, -0.24211302f, 0.01992891f, -0.16741408f, -0.20391674f, -0.11327212f, -0.02681203f, -0.04778174f, 
    -0.05825720f, -0.08322643f, -0.10834982f, -0.01200420f, -0.00834169f, 0.03978712f, 0.05115009f, 0.11472669f, 
    0.09241395f, 0.15664938f, 0.12967212f, 0.00801469f, -0.30918279f, -0.20631263f, 0.00093445f, -0.16020375f, 
    -0.18201019f, -0.10149104f, -0.09703885f, -0.05672903f, 0.02324249f, 0.03853485f, 0.02857389f, 0.09586757f, 
    0.06635093f, -0.07863783f, -0.03555607f, -0.01084904f, 0.02827204f, -0.03791432f, 0.16093616f, -0.02080817f, 
    -0.21162489f, -0.29957911f, 0.29804584f, -0.10311794f, 0.16337383f, 0.23875540f, -0.00303048f, -0.06098798f, 
    -0.01192144f, 0.04977611f, -0.00122414f, 0.12440639f, 0.02662378f, -0.01718479f, 0.11767648f, 0.01671693f, 
    -0.02279381f, 0.06674824f, -0.11108617f, 0.00732005f, -0.06994368f, -0.16111125f, 0.06205894f, -0.05381132f, 
    -0.20668487f, 0.03986213f, -0.05060197f, -0.13768807f, 0.05334590f, 0.06021053f, 0.03842699f, -0.05399614f, 
    0.04344083f, 0.06373584f, 0.11057770f, 0.16060822f, 0.03424020f, 0.03480414f, -0.00906871f, 0.05635033f, 
    -0.07299950f, 0.16926721f, 0.33610758f, -0.01608610f, 0.02422627f, 0.16700035f, -0.07390341f, 0.03198747f, 
    0.16501066f, 0.07699806f, 0.03591726f, 0.07876583f, 0.15543625f, -0.00552418f, -0.07529885f, -0.08918040f, 
    -0.07811936f, -0.02753065f, 0.01407204f, 0.00236178f, 0.41594866f, 0.21237034f, 0.07447015f, 0.03293622f, 
    -0.23572175f, 0.10583052f, -0.01845982f, 0.15251729f, 0.08079574f, 0.13223480f, -0.05003924f, -0.01707594f, 
    0.05932033f, 0.00457556f, 0.11415650f, 0.09047297f, 0.09639245f, 0.12459666f, 0.01377402f, 0.08209334f, 
    0.16639903f, -0.45213675f, -0.04581620f, -0.12452447f, -0.13584913f, 0.13049078f, 0.10284829f, 0.08493116f, 
    0.06527733f, 0.05535255f, 0.04270595f, -0.03454563f, -0.07001350f, 0.05935911f, -0.05995333f, 0.11368034f, 
    -0.00357531f, 0.10324350f, -0.01518438f, 0.10720758f, -0.09274672f, 0.01622606f, -0.01535166f, -0.00581691f, 
    0.08792952f, -0.07427260f, -0.05626850f, 0.05653726f, -0.03598576f, -0.07716486f, 0.08556714f, -0.02566767f, 
    -0.05687681f, 0.03870442f, -0.08048642f, 0.03781499f, -0.05831195f, 0.03436180f, -0.00473576f, -0.02673656f, 
    -0.09451186f, 0.00909698f, -0.03300865f, 0.07482924f, -0.06963676f, -0.08749036f, 0.00322035f, -0.01838128f, 
    0.06727479f, -0.02669819f, 0.14114863f, -0.00661287f, 0.08016878f, -0.05696484f, -0.02413603f, 0.05221844f, 
    -0.03398602f, -0.00840192f, 0.14775535f, 0.02975199f, 0.49313462f, 0.10137426f, 0.35829693f, -0.08386160f, 
    0.23167114f, -0.08232092f, 0.09686986f, 0.07785337f, 0.00254232f, 0.03701001f, -0.01827620f, 0.11163098f, 
    0.01330885f, 0.04928996f, -0.03984299f, 0.03853105f, 0.08613247f, -0.12644139f, -0.06194509f, 0.07596947f, 
    -0.41898981f, -0.26355258f, -0.10021052f, -0.09729838f, 0.01551169f, 0.01404411f, -0.02549095f, 0.04679530f, 
    -0.00455210f, 0.05731013f, 0.12301312f, -0.02795102f, -0.05129463f, 0.04543286f, 0.00130606f, -0.04691878f, 
    0.07757338f, 0.09205771f, 0.07797550f, 0.09678709f, 0.08304616f, -0.09680171f, -0.21635661f, 0.12471445f, 
    -0.13309817f, -0.08359917f, -0.04821934f, -0.03622054f, 0.05999317f, 0.02651551f, -0.02433110f, -0.04041234f, 
    -0.07253955f, -0.00375070f, 0.04795456f, 0.00438254f, -0.06762219f, 0.10800043f, 0.30339366f, -0.00757336f, 
    0.00939398f, -0.03697542f, 0.03699102f, 0.12826706f, 0.13518347f, -0.04601805f, 0.01421988f, -0.09557647f, 
    0.00566966f, -0.03439460f, -0.10368951f, -0.14183316f, -0.01099097f, 0.15541358f, 0.06121903f, 0.04752411f, 
    -0.10826530f, -0.03211432f, 0.03371260f, -0.06502369f, 0.21008210f, -0.00864021f, 0.11243929f, -0.03053755f, 
    0.10063497f, -0.06637222f, 0.07565179f, -0.11636575f, 0.01580399f, 0.06830144f, -0.13267832f, -0.16708806f, 
    -0.03252599f, 0.06756054f, 0.02758182f, 0.12028087f, -0.25766805f, 0.02602435f, -0.12720822f, 0.01830260f, 
    0.00250904f, 0.43797529f, 0.04034968f, -0.07492422f, -0.24029179f, 0.14951582f, 0.06377452f, 0.07798782f, 
    -0.11700621f, -0.07180289f, 0.03607313f, 0.04899071f, -0.01430916f, -0.02665316f, -0.10066738f, 0.04730212f, 
    0.12038244f, -0.02043814f, 0.00300660f, -0.07224417f, -0.46345806f, -0.08943034f, 0.24734822f, 0.03952125f, 
    -0.03831101f, 0.08907679f, -0.03654036f, 0.05307683f, -0.04667854f, 0.03516836f, 0.01292885f, 0.14533576f, 
    0.12041607f, -0.06711944f, -0.03699001f, -0.03352155f, -0.00511814f, -0.03630415f, 0.11909123f, 0.08330148f, 
    0.21718967f, -0.07172526f, -0.04286738f, 0.15409213f, 0.01275278f, -0.02726635f, 0.00066377f, 0.05774859f, 
    0.02501929f, 0.17485774f, -0.06761469f, 0.02301846f, 0.08359174f, -0.02318326f, 0.18165842f, -0.14895269f, 
    -0.02611629f, -0.05226824f, -0.14293438f, 0.01254342f, 0.06796451f, -0.09314787f, 0.14267857f, 0.03734054f, 
    0.26471034f, -0.07721393f, -0.12570986f, -0.20885994f, 0.05767914f, 0.10485538f, -0.03124096f, 0.03760811f, 
    -0.04843173f, 0.03069156f, 0.08410614f, -0.04722646f, 0.00303987f, -0.12960140f, -0.09781352f, 0.00993796f, 
    -0.16296476f, 0.08632292f, 0.06858806f, 0.08946777f, 0.37598813f, -0.05513953f, 0.14584035f, -0.07839428f, 
    0.04584432f, 0.01281769f, 0.05174214f, 0.14292011f, 0.08305177f, -0.02279209f, 0.01980456f, 0.03155480f, 
    0.06180760f, -0.04372581f, 0.04692651f, -0.01316741f, 0.16690607f, 0.25316268f, 0.07377625f, -0.06320982f, 
    -0.03712612f, 0.11613704f, 0.19356564f, 0.07084857f, -0.04707779f, 0.12022161f, 0.01392171f, 0.02372525f, 
    0.05397455f, -0.02926777f, -0.02001257f, 0.11408989f, -0.01652745f, 0.05700004f, -0.18077761f, -0.02225522f, 
    -0.12388128f, 0.14104018f, 0.25693113f, -0.15736762f, 0.17216164f, -0.10271647f, 0.04624108f, -0.24867183f, 
    -0.01432728f, 0.05771952f, -0.12557927f, -0.05189738f, -0.03209220f, 0.13374799f, -0.03488866f, 0.05907595f, 
    0.00732423f, 0.02643425f, -0.06274526f, 0.07752810f, 0.26115260f, -0.07634976f, -0.02947071f, 0.21264362f, 
    -0.17587718f, -0.03081597f, 0.08309612f, -0.06691040f, -0.03544417f, 0.00381583f, -0.00983149f, 0.01637993f, 
    0.01638935f, 0.10267354f, -0.03184746f, 0.10014474f, -0.10726904f, -0.01959252f, -0.00054586f, 0.01804017f, 
    -0.19067328f, -0.19193168f, -0.23815119f, -0.20734689f, -0.02641820f, 0.03654737f, 0.20365660f, 0.00848411f, 
    -0.04928688f, -0.00363166f, -0.04006430f, 0.13340358f, -0.04145643f, -0.01615238f, -0.07215905f, -0.08340700f, 
    0.05734489f, 0.03455430f, 0.07139359f, 0.02508020f, -0.04417051f, -0.07499463f, -0.05673220f, 0.09035610f, 
    0.06728923f, -0.07073228f, -0.03814272f, 0.04163765f, 0.02947858f, 0.08155692f, -0.12249318f, 0.07997648f, 
    0.11338578f, -0.07315335f, -0.11813407f, -0.01142087f, -0.02471700f, 0.09530775f, 0.00210676f, -0.10517535f, 
    0.43366513f, -0.02334500f, -0.00177112f, 0.23821627f, -0.22590181f, -0.10110120f, -0.13932832f, -0.08482154f, 
    0.04989922f, -0.05763214f, -0.01368673f, -0.00819829f, -0.00608759f, 0.01137980f, -0.01986127f, -0.09136195f, 
    0.08148567f, 0.08727787f, 0.03774244f, 0.10873112f, 0.25693056f, 0.13361569f, 0.19394901f, 0.04153046f, 
    -0.13981377f, -0.10648534f, -0.04479283f, 0.10871413f, -0.00736534f, -0.09417487f, 0.01581732f, 0.06320921f, 
    -0.11247050f, 0.05180645f, 0.08416051f, 0.06581566f, -0.03956165f, 0.05864748f, -0.08033060f, 0.05647191f, 
    -0.07026862f, -0.15218875f, 0.04395838f, -0.00260458f, 0.26039049f, 0.11722194f, 0.03506759f, 0.02945512f, 
    -0.03408230f, 0.08939561f, -0.12412975f, 0.09054281f, -0.00672356f, 0.05042707f, -0.04842860f, -0.15163150f, 
    -0.05164387f, -0.03376128f, -0.05568723f, -0.09069931f, -0.31965452f, -0.23341626f, -0.06290477f, 0.02285238f, 
    0.07987411f, 0.09428322f, 0.00337847f, -0.01646981f, 0.11898887f, 0.10708032f, -0.01728096f, 0.02267396f, 
    -0.07394241f, 0.05492364f, 0.00160960f, 0.09421351f, 0.06717473f, -0.07920449f, -0.04779879f, 0.01939253f, 
    0.00065941f, -0.04292939f, 0.00801057f, 0.01291383f, -0.02431207f, 0.00616541f, -0.05352248f, 0.03140274f, 
    0.03650408f, -0.00473899f, 0.00832244f, 0.05012487f, 0.01292040f, 0.02983966f, 0.02954781f, 0.02204024f, 
    0.03045238f, 0.05033928f, 0.02028383f, 0.04905712f, 0.04005431f, 0.00740460f, -0.01842840f, -0.01536151f, 
    -0.04645536f, 0.00180269f, 0.05000624f, -0.01865548f, 0.00096492f, -0.02188323f, 0.02135644f, 0.03611427f, 
    0.01170818f, -0.00588436f, -0.05769437f, -0.05738281f, -0.01408516f, 0.04509090f, 0.01513591f, 0.03255844f, 
    -0.02726266f, 0.03941066f, 0.02668769f, -0.01704098f, -0.05086005f, -0.04049259f, 0.04590641f, 0.02250346f, 
    0.02277535f, -0.05817152f, 0.02004405f, -0.03307181f, 0.03153172f, -0.01281109f, -0.02885128f, -0.04097487f, 
    -0.00950958f, 0.01640594f, -0.01555187f, 0.00664215f, -0.00432443f, 0.01345715f, -0.03170602f, 0.02413771f, 
    -0.04353439f, 0.01187961f, -0.04036129f, -0.01292668f, 0.02865619f, 0.00195152f, -0.02965330f, 0.00172087f, 
    0.05129188f, -0.03920406f, -0.04859183f, -0.02696013f, -0.04574668f, 0.02031016f, 0.03502107f, 0.04255474f, 
    0.00427903f, -0.00049424f, 0.04206252f, -0.00947746f, -0.05333395f, -0.05709383f, 0.01462317f, 0.01899475f, 
    0.00143871f, 0.04364449f, -0.03505499f, 0.00354162f, 0.01636815f, -0.01761605f, 0.01399303f, 0.02485631f, 
    -0.05763336f, -0.00051395f, 0.02124894f, 0.04885519f, -0.03765902f, -0.01476031f, 0.02014573f, -0.02874881f, 
    0.00948436f, -0.00168051f, 0.03180379f, 0.04282374f, -0.04684018f, -0.01442608f, 0.02771490f, 0.04529791f, 
    -0.03234509f, 0.02261372f, 0.04666487f, 0.03040029f, -0.00781609f, 0.01579146f, 0.04642719f, -0.03571850f, 
    -0.01202751f, -0.01551272f, -0.04715859f, -0.02470951f, -0.00640002f, -0.03286026f, -0.04660168f, 0.02149734f, 
    -0.00822083f, -0.01838226f, 0.04209568f, -0.03352785f, 0.04586088f, 0.05201439f, -0.00989472f, -0.01020817f, 
    -0.01490974f, -0.02971828f, -0.03048896f, -0.05429650f, -0.05235637f, -0.03859619f, -0.03857405f, 0.02404029f, 
    0.00862648f, 0.00144112f, 0.00464891f, 0.03225199f, 0.04280878f, 0.02378939f, -0.05916668f, 0.02011203f, 
    -0.04306285f, -0.05220216f, -0.06050179f, -0.03261632f, -0.00438848f, 0.03394989f, -0.04864506f, 0.01276285f, 
    0.00853699f, 0.04605453f, -0.02684949f, 0.00124886f, -0.04257932f, -0.01240946f, -0.02149284f, -0.03890610f, 
    0.05074820f, 0.04621139f, -0.02314239f, 0.03967433f, -0.03958693f, -0.03136263f, -0.01291815f, 0.04978279f, 
    -0.03765909f, -0.05068059f, -0.01707823f, -0.02572553f, 0.03594515f, 0.02302902f, -0.00595554f, -0.05317928f, 
    0.03709839f, -0.04458506f, 0.01795193f, -0.05388945f, -0.01722183f, 0.01175648f, -0.04721208f, -0.00221188f, 
    -0.02730041f, -0.06016294f, -0.02059716f, 0.01978191f, -0.05537051f, -0.05521551f, 0.03024531f, -0.03662415f, 
    -0.00401018f, -0.01038850f, -0.03878138f, 0.03822600f, 0.02564992f, -0.02240155f, 0.02174428f, 0.01625012f, 
    0.01135962f, -0.00264364f, 0.01430827f, 0.02043547f, 0.04307618f, 0.02074741f, -0.02955590f, -0.04596886f, 
    0.00423290f, 0.05040556f, -0.02361136f, -0.05565595f, 0.03058843f, -0.02436198f, -0.01545653f, 0.01775363f, 
    -0.05013750f, -0.05241162f, -0.04257850f, -0.00185213f, -0.05192753f, 0.03684799f, -0.01843905f, -0.02733033f, 
    -0.03245486f, 0.04003325f, -0.02827252f, -0.00110162f, -0.05484335f, 0.02708635f, 0.04290642f, -0.04861924f, 
    0.00651340f, -0.02004462f, -0.06025460f, -0.03086695f, -0.00380592f, -0.05188666f, -0.00390531f, -0.00506575f, 
    -0.05614224f, 0.04452845f, -0.02851131f, 0.03072896f, 0.02079846f, 0.02638844f, 0.01775495f, 0.01096513f, 
    -0.05670701f, 0.04585107f, -0.02327512f, 0.01466680f, 0.00075313f, -0.00017281f, 0.04950564f, -0.00728190f, 
    -0.04970480f, 0.00777269f, 0.04735614f, 0.02955602f, -0.02205812f, -0.02219556f, -0.05074097f, -0.02160050f, 
    -0.04687017f, -0.01754252f, 0.02486491f, -0.00086083f, -0.00284066f, -0.00738812f, -0.04502409f, 0.01688000f, 
    0.01261141f, -0.00296603f, -0.00021006f, -0.05287107f, 0.00671099f, 0.00432616f, -0.02092745f, 0.04169116f, 
    -0.03510058f, -0.04537112f, -0.03007706f, 0.00871431f, -0.01591345f, -0.01689166f, -0.00548008f, 0.02529991f, 
    -0.04400507f, 0.01056062f, 0.04017624f, -0.02144488f, -0.01436588f, 0.02280114f, -0.00038071f, -0.01602247f, 
    0.04039138f, -0.03454275f, 0.02222222f, 0.05283889f, -0.04987716f, -0.04490987f, 0.01329928f, -0.04669471f, 
    0.03855324f, 0.04324086f, 0.02582484f, -0.02432888f, -0.04869878f, -0.01804106f, 0.03393938f, 0.04742707f, 
    -0.03188404f, 0.37281245f, -0.05075072f, 0.09718265f, -0.13111004f, 0.24555904f, 0.14659820f, 0.12963474f, 
    -0.05491566f, -0.01701509f, -0.04970568f, 0.05863563f, 0.09608511f, 0.09091485f, 0.02593180f, -0.07807148f, 
    -0.11677890f, 0.12372436f, -0.07299236f, -0.08719584f, -0.15708072f, 0.22405893f, -0.01436120f, -0.17268758f, 
    0.07362816f, 0.02925986f, -0.03686918f, -0.05531191f, 0.13921021f, 0.18771347f, 0.04919604f, -0.11743753f, 
    -0.06177513f, 0.12819648f, -0.04092200f, 0.04435935f, 0.00387029f, 0.00150491f, -0.14149688f, 0.10586036f, 
    0.13770194f, -0.19762644f, -0.14131151f, -0.19559310f, 0.12207658f, -0.03479202f, 0.12506025f, 0.04452432f, 
    0.01517864f, 0.14906578f, -0.01545339f, 0.05455881f, 0.04702750f, -0.08223002f, -0.02023537f, 0.01336379f, 
    -0.05288963f, -0.17570053f, -0.13441694f, 0.02650079f, -0.49026841f, -0.21149661f, 0.00310918f, 0.19599093f, 
    -0.05679264f, -0.00536012f, 0.14622456f, -0.00036065f, -0.11507829f, 0.02411941f, -0.03368481f, 0.05439487f, 
    0.06106145f, -0.03190655f, -0.05220883f, 0.09830046f, 0.05532228f, -0.06152810f, -0.03992712f, 0.03692745f, 
    -0.09669771f, 0.07596522f, -0.08756105f, -0.27559397f, 0.31038126f, 0.00503361f, -0.14162844f, 0.01232032f, 
    -0.00479189f, -0.05469118f, -0.05906593f, 0.01305914f, 0.03473784f, -0.01802341f, 0.04259130f, 0.06773364f, 
    0.01255153f, 0.11274657f, 0.02845153f, -0.15103553f, -0.01554724f, 0.06759099f, 0.10446440f, -0.13789870f, 
    0.03364033f, -0.00697885f, -0.03054786f, -0.01841588f, -0.02299837f, -0.02014245f, -0.07278700f, 0.02575951f, 
    -0.14023630f, 0.10120559f, 0.06064321f, -0.02972135f, -0.01753336f, -0.05052791f, 0.05577584f, -0.08944740f, 
    0.10477837f, -0.33443874f, 0.14386755f, -0.18668070f, 0.01745995f, 0.08877437f, 0.00881354f, 0.02340498f, 
    -0.04872825f, 0.06303760f, 0.00154608f, 0.03163563f, -0.01516337f, -0.02038134f, -0.01079174f, -0.00866058f, 
    -0.04854416f, -0.03299188f, 0.13181144f, -0.05549262f, -0.03765436f, 0.09363537f, 0.15693809f, -0.29143676f, 
    0.03067204f, 0.05520047f, -0.07423802f, -0.05436512f, -0.08814058f, 0.01390958f, -0.01200691f, 0.06727298f, 
    0.08428261f, 0.08936028f, 0.05216491f, 0.05719854f, 0.04419378f, 0.01054537f, 0.02752969f, -0.03960110f, 
    -0.36096454f, 0.61878812f, -0.01329658f, 0.17395356f, -0.07744142f, 0.24712712f, 0.05346122f, 0.13049011f, 
    0.05362974f, -0.02613805f, 0.03464524f, 0.00869137f, 0.06354002f, 0.01556023f, -0.15512770f, 0.03990548f, 
    -0.02288346f, 0.00809410f, -0.13328801f, 0.08377876f, -0.33545467f, 0.15879887f, 0.16956937f, 0.03267306f, 
    0.20892285f, 0.07968377f, 0.00064074f, 0.02554490f, 0.08861294f, 0.01572268f, 0.02271341f, 0.01536156f, 
    0.21507791f, 0.02188606f, 0.09112212f, 0.07495219f, 0.06482729f, 0.04791000f, -0.03884671f, -0.03847368f, 
    -0.00389645f, -0.19215438f, -0.02075911f, -0.17880094f, 0.27188331f, 0.08477519f, 0.11825577f, 0.06424653f, 
    0.01833772f, -0.07137031f, 0.03433619f, 0.00563173f, -0.06997877f, -0.02613811f, -0.03115721f, -0.01210952f, 
    0.03229251f, -0.18216987f, -0.00134743f, 0.01422740f, -0.01308558f, 0.03857050f, -0.05168493f, -0.03251972f, 
    -0.06998983f, -0.05374913f, 0.11023300f, 0.10646717f, -0.08411220f, -0.02222455f, -0.06533535f, 0.10507214f, 
    -0.00043726f, -0.03024128f, 0.05728825f, -0.01557537f, 0.01104920f, 0.06341688f, 0.11300076f, -0.03348851f, 
    0.23782004f, 0.24861005f, -0.04636891f, -0.05742332f, 0.02412793f, 0.00086784f, -0.12599248f, 0.01931748f, 
    0.04364339f, 0.04458307f, 0.06222944f, -0.01088114f, -0.05509679f, 0.00663662f, 0.17668422f, -0.00550783f, 
    -0.05261375f, 0.00845915f, -0.05419048f, 0.11582373f, 0.23384310f, 0.24196322f, 0.11885754f, 0.19693090f, 
    -0.15420265f, 0.12463445f, 0.10816348f, 0.05727095f, -0.05967856f, -0.03384975f, -0.01569229f, 0.10541091f, 
    0.04084603f, 0.06306309f, 0.12037463f, -0.04567734f, 0.03769375f, 0.01836580f, -0.06960379f, -0.00662052f, 
    -0.18552954f, 0.05251896f, -0.23689456f, -0.09023210f, 0.03026884f, 0.04862201f, -0.00070098f, 0.08559066f, 
    -0.02219590f, -0.09923148f, -0.07710083f, -0.03537299f, 0.02457456f, -0.00155531f, -0.01261452f, 0.04706627f, 
    -0.08482692f, -0.00153071f, 0.08292422f, -0.13394815f, -0.05924840f, -0.03239292f, 0.10520884f, -0.10521773f, 
    -0.04166003f, -0.02131110f, 0.04546599f, 0.04352213f, -0.02157231f, -0.09399947f, 0.05271300f, -0.02219271f, 
    -0.02332070f, 0.06921746f, -0.04325208f, 0.03771934f, 0.08316834f, -0.01324670f, 0.01600469f, 0.14144993f, 
    0.01428936f, 0.01692732f, 0.01845248f, -0.05720180f, -0.02102129f, -0.02641127f, -0.00644631f, 0.02474678f, 
    -0.05269603f, 0.01978617f, -0.00947609f, -0.01464767f, -0.00272247f, 0.00045729f, 0.02390322f, -0.00867727f, 
    -0.06347598f, -0.03280900f, -0.05549961f, -0.00737158f, -0.03676733f, 0.02652117f, 0.02522315f, 0.01063048f, 
    0.01888486f, -0.00142836f, -0.03726532f, -0.06529922f, -0.03387106f, 0.02528531f, -0.03473790f, -0.01118042f, 
    -0.05813846f, -0.05888599f, -0.02458842f, -0.03743164f, -0.05943095f, 0.01035169f, 0.01242097f, 0.03738791f, 
    0.00008916f, -0.02642633f, -0.01480303f, -0.03087741f, -0.04160910f, 0.02644941f, 0.01147150f, 0.00261286f, 
    0.00991478f, -0.05935275f, -0.04568904f, 0.02499082f, 0.01217677f, 0.01870110f, -0.01663969f, -0.02497134f, 
    -0.05933103f, 0.02466543f, -0.05780008f, 0.02644383f, 0.03305730f, -0.02288318f, -0.03889533f, 0.04012426f, 
    -0.01005880f, 0.03268415f, 0.00433519f, -0.05829059f, -0.05457682f, 0.00452782f, -0.00486719f, -0.02146099f, 
    0.03122576f, -0.04649741f, -0.01078825f, 0.03690582f, -0.03839754f, -0.02128915f, -0.01409733f, -0.02563742f, 
    0.01796620f, -0.03925892f, 0.01912647f, 0.02523469f, -0.02783530f, -0.01354500f, -0.06197533f, -0.07225739f, 
    -0.02471249f, -0.03714268f, -0.05907470f, -0.03335497f, 0.01390763f, -0.03620454f, -0.00667641f, -0.03662372f, 
    0.02404901f, -0.02131655f, -0.01006518f, -0.05896154f, -0.01345170f, 0.03718262f, 0.02167786f, 0.00029174f, 
    -0.07421599f, 0.03305709f, -0.05301433f, 0.02354181f, 0.04677476f, 0.02199970f, 0.01230461f, -0.00315746f, 
    -0.05052090f, -0.05043868f, 0.02811199f, 0.00043549f, 0.02169320f, -0.06799136f, -0.02208265f, -0.01481410f, 
    0.05111127f, 0.03286644f, -0.00475727f, -0.02387684f, 0.00429813f, -0.04726500f, -0.01561513f, 0.01246085f, 
    0.04402740f, 0.01778305f, 0.00260648f, 0.05340633f, -0.00372414f, 0.03047997f, -0.05396478f, -0.00188695f, 
    0.01425614f, -0.00297011f, -0.03726338f, -0.00776385f, -0.03278621f, 0.02893265f, -0.06305944f, 0.01392024f, 
    0.03165794f, -0.01575812f, 0.04208836f, -0.03849478f, 0.03635011f, 0.00044450f, 0.03836961f, 0.01536525f, 
    0.00517738f, 0.01532805f, -0.05963487f, 0.00770306f, 0.03945101f, -0.00990894f, 0.02826008f, 0.04652691f, 
    -0.02745298f, -0.03423478f, 0.01197178f, 0.01324217f, 0.04113188f, 0.00544565f, 0.03728978f, -0.01737465f, 
    -0.05385625f, -0.04453482f, 0.04342512f, 0.04432091f, -0.00596637f, -0.00603026f, -0.06536008f, 0.02773388f, 
    0.02747235f, 0.02621914f, -0.05848965f, -0.02447652f, -0.02884336f, -0.00318941f, 0.01052767f, 0.03249399f, 
    -0.01420175f, -0.05699029f, 0.01038331f, -0.00590128f, 0.02982228f, -0.06314112f, -0.02081035f, -0.03426265f, 
    0.04485974f, -0.01990850f, -0.04978689f, 0.00973487f, 0.03879943f, -0.02589993f, -0.06251552f, -0.04309790f, 
    -0.04308208f, 0.03172112f, 0.02687713f, 0.01676263f, -0.01358111f, 0.03441293f, -0.02218249f, 0.01347018f, 
    -0.03508227f, 0.02589077f, 0.02573526f, 0.00563780f, 0.04125506f, -0.03625048f, 0.01885754f, -0.04816904f, 
    -0.01744685f, -0.02694632f, -0.01603808f, -0.00092883f, 0.02171386f, 0.04024544f, 0.03814350f, -0.05249096f, 
    -0.03223886f, 0.00682930f, 0.00861403f, 0.03560008f, 0.00087615f, -0.04749249f, 0.00996712f, -0.04542444f, 
    0.01394322f, 0.04320529f, -0.03449170f, -0.01574377f, -0.04580844f, 0.01953267f, 0.01608884f, 0.04572753f, 
    0.00273198f, 0.00274743f, 0.04144792f, 0.03075392f, -0.02451570f, 0.04443297f, -0.04975187f, -0.02020794f, 
    -0.01562903f, -0.00203161f, -0.01159180f, -0.03938513f, -0.03528302f, -0.04403294f, -0.04865820f, 0.02364841f, 
    0.04476944f, -0.02120261f, 0.03777577f, -0.02873153f, -0.01584014f, 0.02517810f, 0.02411593f, -0.01555247f, 
    -0.03725779f, -0.02860451f, -0.03412526f, -0.00043214f, 0.01973385f, 0.03326185f, -0.01416739f, 0.01932345f, 
    -0.02756008f, 0.03288803f, -0.04611542f, -0.05745092f, 0.02539116f, -0.03063992f, -0.01616937f, 0.04713829f, 
    -0.04499837f, 0.01212415f, -0.06054062f, 0.02529298f, 0.02658688f, -0.05091481f, 0.03345062f, -0.01760231f, 
    0.00756737f, -0.06172940f, 0.00342955f, -0.01756157f, -0.03813843f, -0.04857549f, 0.00264919f, -0.00985311f, 
    -0.01069176f, 0.01741175f, -0.02836607f, -0.03757811f, -0.05255917f, -0.03500101f, 0.04359197f, 0.05100968f, 
    -0.02740804f, 0.03961360f, -0.01312837f, -0.06660715f, -0.00252527f, 0.00613753f, -0.00144355f, -0.03733386f, 
    -0.05901446f, 0.03458133f, -0.04986232f, 0.01015334f, -0.03895320f, -0.00075158f, -0.03443396f, -0.00529515f, 
    0.11040200f, -0.06106810f, -0.21232267f, 0.13394924f, 0.02458052f, 0.00969466f, 0.13689698f, -0.07557169f, 
    0.04685492f, -0.10058060f, -0.04517541f, -0.00497157f, 0.02617559f, 0.07467718f, 0.11963515f, -0.03159181f, 
    -0.02744630f, 0.05945443f, 0.08689477f, 0.05754364f, 0.03617781f, 0.36474824f, -0.05522000f, -0.01111428f, 
    0.02815790f, -0.09130142f, -0.03908540f, -0.07397063f, 0.04882647f, 0.00585287f, -0.00760446f, -0.10472324f, 
    0.03381118f, -0.03629832f, 0.09757207f, 0.11003822f, 0.00218324f, 0.07151248f, -0.08221866f, 0.14067219f, 
    -0.31850278f, 0.10783409f, 0.09206983f, -0.06783361f, 0.13151947f, 0.11243404f, -0.04531343f, 0.07347252f, 
    0.02533428f, -0.01736370f, -0.07240303f, -0.08467916f, 0.01752335f, -0.10757200f, 0.00829018f, -0.01636064f, 
    -0.03570989f, -0.05635417f, 0.16447857f, -0.02331034f, -0.41703755f, -0.03405844f, 0.09635869f, -0.04116609f, 
    -0.11264862f, -0.06475738f, 0.05219684f, -0.01140708f, 0.02259021f, -0.02171195f, -0.16544266f, -0.11585014f, 
    0.01346183f, 0.01821791f, -0.02588140f, 0.02622416f, 0.17318432f, 0.03792808f, 0.01216158f, 0.10216317f, 
    -0.28468609f, 0.18669204f, -0.06191533f, 0.02836281f, 0.03061397f, -0.03804949f, -0.04881475f, -0.06471717f, 
    -0.01648032f, 0.01363031f, -0.00218313f, 0.11984392f, 0.00652334f, 0.01345873f, 0.11067021f, -0.15839450f, 
    0.12037821f, 0.05264920f, -0.07983065f, -0.14518009f, 0.01120018f, 0.03743741f, 0.02741320f, -0.00157812f, 
    0.17059444f, -0.18914108f, -0.04533199f, -0.04161020f, 0.06754459f, 0.00022324f, -0.04020031f, 0.05879937f, 
    -0.05533564f, -0.09085150f, 0.11340210f, 0.09297486f, 0.08973246f, -0.03936682f, -0.03295317f, 0.04151152f, 
    -0.20770502f, 0.66537255f, 0.27880839f, 0.16105908f, 0.04902477f, 0.06202210f, 0.08490451f, 0.02696748f, 
    0.01389782f, 0.03075834f, -0.04863166f, 0.03723593f, 0.13101558f, 0.02536838f, 0.05627862f, -0.02692954f, 
    0.08817594f, 0.07032347f, 0.01034620f, -0.05680677f, 0.09413594f, 0.20419250f, 0.03099221f, 0.02218111f, 
    -0.00633191f, 0.01553911f, 0.16285339f, -0.02830245f, 0.02182023f, 0.17707165f, -0.11859813f, -0.00848393f, 
    0.14499629f, -0.10060242f, 0.10410409f, 0.05572997f, -0.03793020f, 0.16485885f, -0.06513207f, 0.09364329f, 
    0.01904674f, 0.14103705f, 0.01886407f, 0.05388902f, -0.23679312f, 0.03692370f, -0.01311959f, -0.02720964f, 
    0.01757697f, 0.10464814f, 0.03331551f, -0.00988610f, -0.02752257f, 0.02692660f, 0.14433898f, 0.03755266f, 
    -0.09705471f, -0.07223708f, 0.00274593f, 0.10342360f, 0.49494860f, 0.03607871f, -0.25489086f, -0.01997505f, 
    -0.18016092f, -0.05886927f, 0.03591971f, -0.01000277f, 0.09397754f, -0.15000425f, 0.09178516f, -0.07379215f, 
    0.03953814f, 0.08424050f, -0.11520045f, 0.05464866f, 0.02636074f, -0.08272183f, -0.13657850f, -0.02473804f, 
    -0.42364269f, 0.08040895f, -0.29098073f, 0.26238140f, -0.02313649f, 0.19232947f, -0.00935480f, -0.09799430f, 
    -0.09797977f, 0.04872337f, -0.02732730f, 0.18145132f, 0.03059860f, -0.03827810f, 0.06685703f, -0.05559067f, 
    -0.01637927f, 0.04448361f, 0.04368040f, -0.04797840f, -0.16318762f, -0.03418614f, -0.08169370f, 0.13941658f, 
    -0.18925168f, -0.03763303f, 0.02721383f, 0.01734757f, 0.11701208f, 0.16040599f, 0.06849346f, 0.04368281f, 
    0.02603650f, -0.04199169f, -0.07946346f, -0.00621857f, -0.13299611f, 0.06069703f, 0.07233565f, -0.03987372f, 
    0.21212746f, -0.14786541f, 0.11551050f, -0.05000003f, -0.02183049f, -0.01312669f, -0.07835380f, 0.02688739f, 
    0.03341017f, 0.10115346f, 0.01638377f, -0.00988285f, 0.01065756f, 0.01726007f, 0.02121160f, 0.04831894f, 
    0.05677341f, -0.04887805f, -0.08128981f, -0.05224150f, 0.53299272f, -0.10241320f, 0.02493555f, 0.07751838f, 
    0.01829172f, 0.13128208f, 0.15563051f, -0.05206466f, -0.05411422f, -0.10147010f, 0.06385268f, 0.01827819f, 
    -0.02552767f, 0.00039472f, -0.06379203f, 0.12554242f, 0.09345941f, 0.04605448f, 0.04128604f, -0.01207283f, 
    0.00539720f, 0.04792249f, -0.04749209f, 0.07355361f, -0.03126093f, 0.03218951f, 0.07680490f, 0.04506732f, 
    0.03462915f, 0.00993688f, 0.09620938f, 0.11512548f, -0.08412581f, 0.06280220f, 0.00752527f, -0.06381682f, 
    0.02970624f, 0.06483573f, 0.00151613f, 0.11328868f, -0.31380078f, -0.18260051f, 0.02964009f, 0.08489013f, 
    0.06955774f, -0.00940322f, -0.08418897f, -0.12885545f, -0.04618985f, -0.06603939f, 0.06033005f, 0.10951297f, 
    -0.02517086f, 0.01112037f, 0.00595788f, -0.03954137f, 0.14278485f, 0.04442092f, -0.07450061f, 0.06616949f, 
    0.35491461f, 0.09133425f, -0.17784321f, -0.01039974f, 0.25928566f, -0.21628134f, -0.19773118f, -0.00799040f, 
    0.11222163f, 0.09145755f, -0.02653378f, -0.00598993f, -0.02100684f, 0.10954925f, -0.06251475f, 0.13373092f, 
    0.10857905f, -0.04830869f, 0.03229674f, 0.00540293f, 0.32584730f, 0.14640687f, 0.07814226f, -0.01022943f, 
    0.38636702f, 0.01021960f, 0.05689790f, -0.01732812f, -0.05834159f, 0.03745798f, -0.00334760f, -0.00305840f, 
    0.01458690f, -0.04700991f, -0.06109715f, 0.06393205f, 0.03120093f, 0.10533347f, 0.08466537f, -0.03604815f, 
    -0.26804373f, 0.16643639f, 0.13479879f, 0.09718316f, -0.33888862f, 0.05325371f, 0.05192716f, -0.01895539f, 
    0.00336243f, -0.19473319f, -0.05607189f, 0.12066966f, 0.06992675f, 0.14796655f, -0.05361114f, 0.05939175f, 
    0.13211524f, 0.02585890f, -0.04787492f, 0.00438867f, 0.16532083f, 0.29488194f, 0.01069181f, 0.08935993f, 
    0.17990479f, 0.05189239f, -0.07316080f, 0.07324507f, 0.09735233f, 0.04097469f, 0.14143392f, 0.02255900f, 
    0.20440866f, 0.01009113f, -0.05366179f, -0.10456891f, -0.04572484f, 0.11872787f, 0.04552854f, -0.02402875f, 
    0.06562659f, -0.02304959f, 0.23275281f, 0.19272763f, 0.32971519f, 0.01586560f, -0.02722979f, 0.01559026f, 
    -0.10467719f, 0.06707580f, -0.11674317f, -0.06972890f, -0.09248931f, -0.04666870f, 0.05431093f, 0.04548860f, 
    -0.20531976f, 0.05709036f, -0.04548318f, 0.19707169f, -0.12651828f, 0.00412144f, -0.24165499f, 0.05236831f, 
    0.24335207f, 0.03549129f, -0.09703403f, -0.03544600f, -0.04311456f, 0.12368374f, 0.02024761f, -0.13318919f, 
    0.04613856f, -0.07591905f, -0.02207298f, 0.05323644f, 0.03587129f, 0.00597039f, 0.03118804f, 0.02045803f, 
    0.19114600f, -0.20156108f, -0.06012642f, 0.05166216f, 0.25980911f, -0.11959169f, -0.00836782f, -0.19532676f, 
    0.06551464f, 0.06995554f, -0.05966580f, 0.12509768f, -0.00367422f, -0.00588190f, -0.11988017f, -0.04520369f, 
    0.00703347f, 0.07505292f, -0.02330077f, -0.02124609f, 0.31975600f, 0.21857296f, -0.02292973f, 0.09385523f, 
    0.05499921f, -0.02379550f, 0.04748358f, -0.02532815f, -0.00832134f, -0.03756288f, 0.08578514f, -0.05974938f, 
    0.12901604f, 0.02481329f, -0.04465216f, -0.03485947f, 0.02042568f, 0.02943607f, 0.03702573f, -0.05799825f, 
    0.08345501f, 0.18109991f, 0.14686333f, -0.19528098f, 0.24368426f, -0.05373322f, 0.04009318f, -0.08736178f, 
    0.07397446f, -0.01750197f, -0.15489416f, 0.03244745f, 0.02625391f, -0.01394680f, 0.00726393f, -0.04922309f, 
    -0.09290292f, 0.06110548f, -0.10251300f, 0.02419849f, -0.02701580f, -0.01394464f, -0.03753455f, 0.09394890f, 
    0.13428389f, 0.00600462f, -0.00818932f, -0.06162089f, 0.04527244f, 0.06133166f, -0.13562439f, 0.03096981f, 
    -0.03755109f, -0.03639814f, -0.05245647f, 0.03913456f, -0.03243362f, 0.04137061f, 0.06880093f, -0.07208597f, 
    0.19261920f, -0.03933008f, -0.03812379f, -0.05228391f, -0.16425623f, 0.00156134f, 0.06376772f, -0.02014157f, 
    -0.09457295f, 0.05873330f, 0.03553012f, 0.09572292f, 0.02386483f, 0.16149037f, -0.02982845f, -0.05190247f, 
    0.12362866f, 0.06510487f, -0.11706877f, 0.09181866f, 0.10316860f, 0.02583490f, 0.03375189f, 0.13036825f, 
    0.27907145f, -0.05359205f, -0.03319435f, 0.00757281f, -0.02528805f, -0.10625689f, -0.07813326f, 0.01237037f, 
    0.01514100f, -0.03668390f, -0.06142356f, -0.03992394f, -0.01931109f, 0.07715458f, -0.01183536f, -0.08092596f, 
    -0.12855510f, 0.15216798f, -0.01370199f, 0.09161000f, 0.04998532f, -0.10817956f, 0.00590048f, -0.01647565f, 
    0.04673510f, -0.01322253f, -0.06197919f, -0.07395871f, 0.06125230f, 0.07825080f, -0.09481281f, -0.04468053f, 
    -0.12593558f, 0.01199638f, 0.12156410f, -0.08533599f, 0.08387146f, -0.09530180f, -0.19872786f, 0.07466011f, 
    0.09476927f, -0.29494819f, -0.18445909f, 0.11151797f, 0.07669367f, 0.00195121f, -0.02598174f, 0.01813540f, 
    -0.05697022f, -0.02100147f, 0.00306917f, 0.04109887f, -0.01771018f, 0.02084738f, 0.05626395f, 0.03746375f, 
    0.10930648f, 0.05433417f, 0.03725212f, 0.02372842f, 0.22326523f, 0.01826395f, -0.13021860f, 0.06358723f, 
    -0.11706085f, 0.10809276f, -0.05553331f, -0.04550171f, -0.04556496f, 0.03776274f, -0.01659433f, -0.02267786f, 
    -0.05920153f, 0.05547854f, 0.03034062f, 0.01668821f, -0.07697956f, 0.09527212f, 0.08646086f, -0.05422499f, 
    -0.07219218f, -0.03774042f, -0.19107564f, -0.05759044f, -0.05168045f, 0.05352721f, -0.03645477f, -0.05196266f, 
    0.00163955f, -0.04296086f, 0.04109247f, 0.14584081f, 0.01109816f, 0.01269248f, 0.06128503f, -0.14391407f, 
    -0.31182891f, -0.15836012f, 0.02726502f, -0.16778320f, -0.13980208f, 0.02245276f, 0.06633499f, 0.15568295f, 
    -0.01609521f, -0.05116327f, 0.14995223f, 0.12844718f, -0.06584307f, 0.05597311f, -0.04899895f, -0.00012677f, 
    -0.00686836f, 0.09382958f, -0.12330075f, 0.04306613f, -0.12283592f, -0.09599651f, 0.05497368f, 0.15869908f, 
    -0.05694949f, 0.01462740f, 0.01378949f, 0.14686361f, 0.01627007f, 0.02634284f, -0.02782678f, 0.10072148f, 
    -0.06837646f, -0.01703895f, -0.13652194f, 0.03001170f, -0.04736641f, 0.05768412f, -0.02368310f, 0.01747076f, 
    0.27247173f, 0.06959060f, -0.19800265f, -0.02363019f, -0.01171945f, -0.04901230f, -0.11933129f, -0.09225289f, 
    0.01052994f, 0.00079294f, 0.08354881f, 0.05267527f, -0.04108265f, 0.04714245f, 0.00262164f, -0.05079191f, 
    -0.08411365f, 0.00874266f, -0.09318149f, -0.07988937f, 0.15603979f, 0.05167471f, -0.21999794f, -0.03473007f, 
    0.25311887f, -0.05002307f, 0.10940059f, 0.02665192f, -0.10641252f, 0.07190254f, -0.03079793f, 0.02666597f, 
    -0.01722275f, -0.07938576f, 0.09182338f, 0.10682094f, -0.08856928f, -0.03578646f, -0.00172850f, -0.07121689f, 
    -0.08952807f, -0.04983930f, 0.19027953f, 0.06961463f, -0.19557634f, -0.07011760f, 0.05916460f, 0.05415320f, 
    0.01058314f, 0.02295077f, 0.10431685f, -0.04817141f, 0.08488443f, 0.08604365f, -0.12729804f, 0.04568417f, 
    0.01592711f, -0.09479833f, 0.14599591f, -0.04239189f, 0.29903910f, 0.11542089f, 0.06039005f, -0.00767894f, 
    -0.18653958f, -0.06487489f, 0.13579708f, 0.29815391f, 0.05062190f, -0.02001296f, 0.02641372f, -0.01249244f, 
    0.07482040f, -0.07166934f, -0.09936813f, -0.08992331f, 0.00543044f, -0.07917462f, 0.06133826f, -0.09145770f, 
    0.00574338f, -0.06739885f, 0.17006287f, -0.08448095f, 0.03819971f, 0.27370828f, -0.07097127f, 0.15771715f, 
    0.12156805f, -0.01931232f, 0.00175650f, -0.07343198f, -0.02964611f, -0.00177657f, 0.10126895f, 0.10409845f, 
    0.04020689f, 0.02999151f, 0.01119412f, 0.14300688f, -0.02110224f, -0.22827017f, -0.03801065f, 0.16131593f, 
    -0.05718414f, -0.12866269f, -0.15826762f, 0.01625141f, 0.07239735f, -0.03861554f, 0.03189136f, -0.07676625f, 
    0.00172893f, 0.03742000f, 0.12199948f, -0.01252399f, 0.01054382f, -0.12995107f, 0.02110966f, 0.07573493f, 
    0.00616044f, -0.47405797f, 0.10858189f, 0.06491632f, 0.13680139f, 0.05975958f, -0.03179374f, 0.12478388f, 
    0.07738305f, -0.06156734f, 0.14438428f, 0.06635288f, 0.08800437f, 0.02135379f, 0.11144653f, 0.01257121f, 
    0.09036339f, 0.05568760f, -0.04224820f, 0.03886815f, 0.02197051f, 0.01534158f, -0.07488010f, -0.04720300f, 
    -0.16565043f, 0.01313452f, 0.07121939f, 0.11889456f, -0.00205548f, 0.08997625f, 0.01998873f, -0.02046524f, 
    0.10542148f, -0.06876998f, 0.15414943f, 0.06867191f, 0.07561585f, -0.01606864f, 0.00201279f, 0.11876708f, 
    0.42447254f, -0.06684824f, -0.16864444f, 0.19182591f, -0.14506473f, -0.08436194f, -0.10957240f, -0.05393524f, 
    0.02332751f, 0.10888992f, -0.04626917f, -0.03433672f, 0.09108829f, 0.02851706f, 0.06919701f, 0.07427716f, 
    -0.05437275f, 0.08100034f, -0.13180424f, 0.00688626f, 0.25064576f, 0.20524073f, 0.04361312f, 0.06118507f, 
    0.12408911f, 0.06455704f, 0.03835256f, 0.08411841f, 0.03527476f, 0.12860687f, -0.08541326f, -0.07961170f, 
    -0.05635911f, 0.01565971f, 0.08191632f, 0.09885488f, -0.00200692f, 0.02537905f, 0.02511463f, 0.06748196f, 
    -0.18650463f, 0.21656476f, -0.03379806f, -0.07912785f, 0.13265406f, 0.08287074f, 0.10481289f, -0.05383200f, 
    0.05951048f, -0.05339588f, -0.02610858f, 0.05991093f, -0.03891910f, -0.07173506f, 0.02938528f, 0.05618496f, 
    0.02208194f, -0.02778866f, 0.05502458f, -0.04189904f, -0.25545719f, -0.45828652f, -0.03874695f, -0.26924559f, 
    -0.08873648f, 0.08934541f, 0.11394842f, 0.08875465f, -0.00133692f, 0.05553373f, -0.04434632f, -0.02729602f, 
    0.00780452f, 0.00209703f, -0.07618058f, 0.04016195f, -0.03778147f, -0.01310772f, 0.00749958f, 0.04480565f, 
    0.14305720f, 0.07876654f, 0.02777955f, 0.08455478f, -0.06164505f, -0.04549522f, 0.09414184f, 0.12768742f, 
    0.02580435f, 0.03798873f, 0.10076675f, -0.03239948f, 0.02451375f, 0.00487547f, 0.00459850f, 0.06173719f, 
    0.12192468f, -0.00738294f, -0.08175616f, 0.04013319f, 0.50386465f, -0.02629022f, -0.20869170f, 0.14258590f, 
    -0.13714050f, -0.12815987f, -0.07260108f, -0.12610845f, 0.03379378f, 0.07134329f, -0.05802773f, -0.05496284f, 
    0.03066884f, -0.13463926f, 0.09508841f, -0.00367024f, 0.00868333f, 0.06690089f, 0.11552590f, -0.00326563f, 
    -0.03398895f, -0.33626351f, -0.02115837f, 0.06010409f, 0.27493992f, 0.05341907f, 0.13241161f, 0.05041555f, 
    -0.08822634f, 0.03746248f, -0.03085584f, -0.06485560f, 0.08611576f, 0.04813110f, 0.06374060f, -0.02104487f, 
    0.06213957f, 0.00779604f, 0.05116582f, -0.01746878f, 0.10794607f, -0.21390872f, 0.00722080f, 0.06441880f, 
    0.00713967f, -0.01254973f, 0.08105092f, 0.01994259f, -0.04530356f, -0.00754293f, 0.08017439f, -0.14930955f, 
    0.02961532f, 0.07349148f, -0.00129648f, -0.00895490f, 0.00890768f, 0.00754655f, -0.02498007f, 0.11432458f, 
    -0.02587622f, 0.09614982f, -0.01102349f, -0.02084079f, 0.15946718f, -0.16670074f, -0.14355834f, 0.01028475f, 
    0.02824064f, -0.07152123f, 0.10483144f, -0.14599569f, -0.07245038f, -0.18831742f, 0.07831478f, 0.03419787f, 
    0.02341221f, 0.05701096f, 0.11352491f, 0.07229841f, 0.38474965f, 0.24212994f, 0.17925000f, -0.09797631f, 
    -0.34870774f, 0.09279600f, 0.10707323f, -0.02155651f, -0.04595355f, -0.00253774f, -0.03620114f, -0.00912613f, 
    0.01722108f, -0.01078757f, -0.01306654f, -0.10529618f, 0.08281291f, 0.03383770f, 0.12434942f, 0.13185671f, 
    -0.15353756f, 0.20104147f, 0.01566363f, 0.09711418f, 0.00292110f, 0.09538715f, -0.02875993f, 0.03597330f, 
    0.08011480f, 0.03503923f, 0.11593050f, 0.04270491f, -0.01489964f, -0.09464777f, 0.04077210f, -0.06476415f, 
    0.00760858f, -0.01795174f, -0.04825741f, -0.11664241f, -0.13817979f, 0.05271748f, 0.13493751f, 0.15060727f, 
    0.06622443f, 0.08908436f, -0.06120101f, -0.08881695f, 0.05390818f, -0.01480175f, -0.10325399f, 0.10373053f, 
    -0.04780490f, 0.15660487f, 0.18792272f, 0.06842065f, 0.02066665f, 0.13807997f, -0.22112136f, 0.08450191f, 
    0.13385347f, 0.11920352f, -0.00260637f, -0.05357707f, -0.18116947f, -0.16933568f, -0.05884711f, 0.08999822f, 
    0.04325218f, 0.07466520f, 0.06284549f, -0.00584990f, 0.03376444f, -0.02228150f, -0.02874653f, -0.02598539f, 
    -0.01900071f, -0.00123477f, 0.12743305f, 0.04041948f, -0.30552083f, -0.02117014f, -0.13264063f, 0.13631195f, 
    0.10606767f, 0.06327670f, 0.04558045f, 0.15148100f, -0.03834042f, 0.07139340f, 0.02314379f, 0.07287871f, 
    -0.10329591f, -0.05504687f, -0.01041601f, -0.02536131f, 0.09524313f, 0.09826360f, -0.02329533f, -0.10025351f, 
    0.24318814f, -0.11799917f, -0.23363411f, 0.02252732f, -0.23843989f, -0.13579522f, 0.04151839f, 0.16679406f, 
    -0.08695471f, 0.07446342f, -0.04974861f, -0.05586089f, -0.04422657f, 0.06737306f, -0.02225254f, 0.14367221f, 
    -0.01917094f, 0.10172485f, 0.08310419f, 0.08766644f, -0.54477048f, 0.10985646f, 0.19509506f, 0.08008026f, 
    0.22808379f, -0.00893627f, 0.08980128f, -0.08207621f, -0.15555044f, -0.03743228f, 0.17870539f, 0.04714380f, 
    0.05483043f, 0.01618628f, -0.01168468f, 0.00352448f, -0.06988183f, -0.05026758f, 0.03655688f, -0.05578544f, 
    -0.37615579f, 0.16922556f, -0.06606331f, 0.00131211f, 0.13476247f, -0.05981100f, -0.02241693f, -0.10267942f, 
    0.07341510f, -0.09846167f, -0.03037841f, 0.01763813f, 0.01494021f, -0.09584961f, -0.02459626f, -0.06174794f, 
    0.12285256f, -0.02725630f, 0.14460149f, -0.00222862f, -0.14993007f, -0.04133796f, 0.04351252f, -0.01618518f, 
    -0.13629425f, 0.09988328f, 0.06329065f, -0.10754073f, 0.00630871f, 0.11831158f, -0.15021288f, 0.15799224f, 
    0.10673279f, 0.01787458f, 0.03426801f, 0.06422667f, 0.10058092f, 0.00603224f, 0.05354220f, 0.05969774f, 
    0.35352546f, 0.00640533f, 0.04260551f, 0.15607153f, -0.01413164f, -0.02695764f, 0.00572031f, 0.03382109f, 
    -0.01906108f, 0.04141613f, -0.00051284f, 0.04279544f, -0.09069714f, 0.01618621f, -0.05356278f, -0.03327651f, 
    0.00465966f, -0.01572722f, -0.07773028f, 0.06441002f, -0.27596581f, 0.17199726f, 0.03184648f, 0.34447196f, 
    0.02313458f, 0.23648277f, 0.10572634f, -0.01059378f, 0.04723038f, -0.02535753f, 0.04878431f, 0.00681893f, 
    0.07114454f, -0.02438966f, 0.14982614f, -0.02658187f, -0.02181430f, 0.19574352f, 0.03820767f, -0.06563355f, 
    -0.00930707f, -0.03432404f, 0.02838434f, -0.05388939f, -0.17726417f, 0.07505663f, 0.04977331f, -0.11011796f, 
    0.02886718f, -0.04389237f, -0.11552900f, 0.12502168f, 0.07724179f, -0.00285475f, 0.11916412f, -0.02638978f, 
    -0.02631804f, 0.00910833f, -0.04485709f, -0.06484744f, -0.03115145f, -0.22139844f, 0.04777597f, -0.19616596f, 
    -0.02285639f, 0.05211765f, 0.13465394f, -0.10908782f, 0.04436920f, -0.09870684f, 0.10054678f, 0.07035267f, 
    0.00673945f, 0.06631014f, -0.06343378f, 0.05696604f, 0.10624906f, 0.05979241f, -0.24097650f, 0.18447530f, 
    0.35113552f, 0.21846591f, -0.12450708f, 0.04569987f, 0.19435087f, 0.10695369f, 0.05476391f, 0.07710689f, 
    -0.01632473f, 0.06525900f, 0.02008564f, 0.04773753f, 0.00066088f, 0.15893903f, -0.03267458f, 0.00746898f, 
    -0.12048035f, 0.06799761f, -0.08589003f, 0.01953809f, -0.05153224f, 0.06445118f, -0.11367233f, -0.26118669f, 
    0.07933386f, 0.05233004f, -0.09197152f, 0.04834111f, 0.08312698f, 0.00738920f, 0.03499816f, 0.05749581f, 
    0.02402101f, 0.07705283f, -0.11363315f, -0.05572946f, -0.11137547f, -0.03266551f, -0.04049053f, 0.02963834f, 
    0.01846200f, -0.01094254f, -0.13816729f, 0.01527780f, -0.05610741f, -0.00392266f, -0.03124032f, -0.07399701f, 
    0.00585016f, -0.01314253f, 0.05384957f, 0.14610507f, 0.00486360f, -0.08618979f, 0.05046263f, 0.10307828f, 
    -0.03731217f, -0.12841497f, -0.06222051f, 0.00827493f, -0.34954628f, -0.09715538f, -0.30957875f, -0.02018520f, 
    0.12246232f, 0.04872175f, -0.00485653f, 0.00821131f, -0.08912354f, -0.05755537f, 0.06514668f, 0.07673194f, 
    0.02452807f, -0.06446815f, -0.10792358f, 0.12332673f, -0.15424077f, 0.03066903f, 0.00948775f, 0.03198148f, 
    0.09997950f, -0.05013358f, 0.04786268f, -0.18198039f, 0.40382406f, 0.06117211f, -0.04871532f, -0.07376426f, 
    -0.06533775f, -0.12509297f, -0.08668455f, 0.00893899f, 0.05642382f, 0.08893088f, 0.02754813f, -0.03465283f, 
    0.04411348f, -0.06006882f, -0.00453517f, -0.07782481f, 0.04160571f, 0.02961999f, -0.15724669f, -0.09664237f, 
    -0.01718508f, 0.04809466f, -0.11056496f, -0.06188373f, 0.05703449f, 0.01805516f, -0.00283449f, 0.00213472f, 
    -0.02528202f, 0.16910991f, 0.05129000f, 0.04399033f, -0.04374417f, -0.11442414f, -0.07756630f, -0.11565985f, 
    0.26256451f, -0.50717038f, 0.14099452f, -0.11687673f, 0.10428563f, 0.19200332f, -0.10205305f, 0.02833408f, 
    0.00698077f, 0.07411280f, 0.05506622f, 0.09903593f, -0.02573851f, 0.00935025f, -0.12404165f, -0.07752155f, 
    0.05800637f, -0.16122720f, 0.13469236f, -0.09272290f, 0.16415808f, 0.10205007f, 0.01561469f, -0.22240601f, 
    0.00946442f, -0.01192118f, -0.02751228f, -0.08857159f, 0.02287878f, 0.03373723f, 0.06222318f, 0.12017610f, 
    0.04497734f, 0.03027786f, -0.00168397f, -0.08854275f, 0.10941135f, -0.06751129f, -0.00053570f, -0.11139950f, 
    -0.06517547f, 0.36031947f, -0.05525602f, 0.04087207f, -0.00081301f, 0.19983830f, -0.03294092f, -0.02301626f, 
    0.11525369f, -0.11295819f, -0.03303087f, -0.02195147f, -0.10071290f, 0.04762554f, -0.02007104f, 0.02910082f, 
    0.01673494f, 0.07688166f, -0.05314985f, 0.03151762f, -0.29898378f, 0.16595122f, 0.05997668f, -0.00012903f, 
    -0.03000343f, 0.00666442f, -0.11401841f, -0.10164611f, 0.09017517f, 0.18860780f, 0.10419764f, -0.02009059f, 
    0.16573256f, -0.06686099f, 0.04733327f, 0.12336678f, 0.01458410f, 0.07462831f, 0.06249819f, 0.02084127f, 
    0.29458943f, -0.20979844f, -0.14835653f, 0.07753317f, 0.08993167f, 0.02827090f, 0.05728717f, 0.00308291f, 
    -0.01173701f, -0.00125964f, 0.07851820f, -0.07829983f, 0.09630316f, 0.03267381f, -0.03308860f, -0.05031939f, 
    0.21658221f, -0.05132994f, -0.05120801f, 0.02384359f, -0.02102532f, -0.01113648f, -0.01610431f, -0.04652507f, 
    0.18723376f, -0.02574423f, 0.01788138f, 0.09376792f, -0.00193919f, -0.09824420f, -0.08780203f, 0.07259961f, 
    0.06762019f, -0.00735345f, -0.03005683f, -0.12592579f, 0.02779035f, 0.01834497f, 0.11218913f, -0.05137637f, 
    -0.31130180f, 0.35905665f, -0.19890857f, -0.00443536f, 0.04264811f, -0.06675678f, -0.04596232f, 0.00310989f, 
    0.03550135f, 0.00373689f, -0.01216208f, -0.13701411f, -0.16909838f, 0.03363837f, 0.05959510f, -0.05946306f, 
    -0.12972093f, 0.03917495f, -0.01609937f, -0.01763051f, 0.12191255f, -0.04000027f, 0.08561756f, 0.06521866f, 
    0.04452742f, -0.05186805f, 0.10681386f, 0.15527621f, 0.01751315f, 0.11884417f, 0.05339776f, 0.02950105f, 
    0.10122401f, 0.02075385f, 0.08154738f, 0.05671816f, -0.01114734f, 0.05653827f, 0.05292556f, 0.00379938f, 
    0.08095983f, 0.05221079f, -0.24345061f, -0.21832725f, 0.04028623f, 0.07810803f, -0.17253734f, 0.04629809f, 
    -0.07534094f, -0.06985176f, -0.06203153f, 0.02839219f, 0.05048233f, 0.09065580f, 0.00913707f, -0.00488080f, 
    0.05498169f, -0.02308955f, -0.08627510f, -0.03517639f, 0.24947633f, 0.07472277f, 0.01257026f, -0.03146939f, 
    -0.05844877f, -0.03273693f, -0.08211359f, 0.04342972f, -0.05119278f, 0.05676865f, 0.00101778f, -0.06664437f, 
    0.10151388f, -0.01557302f, -0.02159108f, 0.12807880f, 0.06244955f, 0.00451248f, 0.04044136f, 0.00003791f, 
    -0.59917957f, 0.09405808f, 0.16011733f, 0.04835991f, -0.61520737f, 0.12130647f, 0.13509782f, -0.12541436f, 
    -0.05820127f, -0.03649302f, 0.09683397f, 0.07802291f, 0.01082784f, -0.09375518f, -0.01595082f, -0.01331998f, 
    0.06710827f, 0.04835968f, -0.01943498f, -0.07456078f, -0.35023350f, 0.05638781f, -0.14175317f, -0.01264659f, 
    -0.26043060f, 0.06085325f, 0.07984801f, -0.04057971f, 0.08314942f, 0.08001941f, 0.02312693f, 0.06224150f, 
    -0.02359124f, 0.04414170f, 0.02679247f, 0.03377911f, 0.15451676f, 0.00048226f, 0.06771307f, 0.00610805f, 
    0.38866746f, -0.37098268f, -0.24709879f, -0.05247822f, 0.29681492f, 0.00458617f, -0.01020578f, -0.06253805f, 
    -0.06192356f, 0.18182380f, -0.03665759f, 0.00027351f, 0.13696218f, 0.10298296f, -0.01623335f, -0.04712607f, 
    -0.03054781f, 0.01086214f, -0.13514109f, -0.03364094f, -0.43616557f, -0.26602381f, -0.06626700f, 0.10440955f, 
    0.18253420f, -0.12389033f, 0.11038020f, -0.14168741f, -0.02811315f, 0.00845670f, 0.06139439f, 0.00817791f, 
    -0.08310533f, 0.04921318f, 0.04869923f, 0.10619824f, 0.02825687f, -0.02167615f, 0.00991196f, 0.03084550f, 
    -0.00848167f, 0.09449826f, -0.26238441f, -0.25297630f, -0.25486642f, 0.02304619f, 0.04019371f, -0.02347870f, 
    -0.02169153f, 0.01417825f, 0.05787820f, -0.01613506f, -0.00304587f, 0.00975177f, -0.00937632f, 0.03154209f, 
    0.03112321f, 0.01872224f, 0.12822410f, 0.04445087f, 0.14869000f, 0.12167675f, 0.11231668f, -0.13472834f, 
    -0.16572858f, 0.06314331f, 0.20235276f, 0.01382290f, 0.01467657f, -0.00887330f, 0.04309953f, 0.01193269f, 
    0.03852164f, -0.04080479f, -0.07096568f, -0.02393080f, 0.04059411f, 0.04560630f, 0.15826595f, 0.07151977f, 
    -0.33689451f, 0.27993378f, -0.12053545f, 0.06666682f, -0.13631848f, 0.03282262f, 0.13396536f, 0.00328430f, 
    -0.11590636f, 0.04442251f, 0.05880129f, -0.09248640f, -0.01269455f, 0.04506918f, 0.11613173f, 0.06036063f, 
    0.01120172f, 0.10147899f, -0.06252914f, -0.00782440f, -0.37603867f, -0.03468790f, 0.21629843f, -0.18927254f, 
    -0.00256491f, 0.01308193f, -0.04732074f, 0.04378186f, 0.05661414f, -0.09230575f, -0.08618826f, -0.03141520f, 
    -0.04741880f, 0.06458686f, 0.03971820f, 0.08819217f, -0.06238078f, -0.10198734f, 0.05674250f, 0.19272646f, 
    -0.27281341f, -0.00846957f, -0.10821140f, 0.15406261f, -0.02311949f, 0.10899504f, -0.00743267f, -0.06072614f, 
    0.03071352f, -0.04580140f, 0.14630997f, 0.05798039f, 0.09600685f, -0.02557296f, -0.04960435f, 0.01565040f, 
    0.07868581f, -0.06496494f, 0.02955561f, -0.05798171f, 0.25986546f, 0.06523320f, -0.04544898f, -0.00213523f, 
    0.16282491f, 0.03797741f, -0.02180904f, 0.11953375f, 0.04760878f, -0.15466616f, -0.02971079f, 0.00102304f, 
    -0.00740824f, 0.10549957f, 0.16380595f, 0.00086867f, 0.15116692f, -0.00314811f, 0.05712976f, 0.09741570f, 
    0.11886191f, -0.09623270f, 0.38967997f, -0.08943674f, 0.13325122f, -0.04741525f, -0.01076446f, 0.04488287f, 
    0.00211867f, 0.02021016f, 0.01569039f, 0.04654443f, -0.09822834f, 0.04723564f, -0.03648371f, 0.16073515f, 
    -0.06763953f, -0.09809764f, -0.00000283f, 0.03514577f, 0.15029837f, 0.15738752f, -0.02597260f, 0.00614712f, 
    0.05208838f, 0.05880110f, -0.03879829f, 0.05445677f, 0.02213887f, 0.02539899f, 0.18241328f, -0.04992744f, 
    -0.09153490f, -0.03410706f, 0.05298083f, -0.00013431f, 0.05075465f, 0.03612448f, -0.03883288f, 0.12226669f, 
    0.11150669f, -0.22724971f, 0.07595327f, -0.12670070f, 0.03662211f, 0.18373542f, -0.02416001f, 0.04403660f, 
    -0.09631778f, -0.02118593f, 0.03206914f, 0.05885141f, 0.10809296f, -0.11057810f, 0.10793366f, 0.03704231f, 
    0.18485387f, 0.09702678f, 0.02300044f, 0.13136373f, -0.04538200f, 0.22013390f, 0.00046450f, -0.19411299f, 
    -0.22885387f, 0.08183448f, 0.03808467f, -0.17446955f, -0.06173526f, 0.10294916f, -0.00155959f, 0.05588634f, 
    -0.01709313f, 0.10569464f, -0.04336113f, -0.08504750f, 0.03312114f, -0.06582807f, 0.02002414f, -0.02659159f, 
    -0.15351929f, 0.07127025f, 0.00372190f, 0.04801411f, 0.10751912f, -0.11673761f, 0.13969542f, -0.01926751f, 
    0.07702357f, -0.02831453f, 0.15011300f, 0.00132068f, -0.02859615f, -0.00679502f, -0.00071583f, 0.10819462f, 
    -0.04773285f, -0.08020651f, 0.07909727f, 0.06667316f, 0.13807830f, 0.14234321f, 0.12406588f, 0.11842308f, 
    0.18306454f, -0.00819258f, 0.16501130f, 0.16475013f, 0.03494234f, 0.03437364f, 0.07094950f, 0.00803306f, 
    0.06831408f, -0.05514165f, 0.04671436f, -0.14667763f, -0.03408686f, 0.03111076f, 0.06578167f, 0.02228508f, 
    0.28228930f, -0.12019356f, 0.27151048f, 0.14669256f, -0.10912105f, -0.01155107f, -0.13152693f, -0.00112439f, 
    -0.10168246f, -0.03818079f, 0.21537034f, 0.00271393f, 0.02697951f, -0.11895082f, 0.06924404f, 0.00022537f, 
    0.07889976f, -0.04491612f, -0.03942428f, -0.03586261f, -0.12047909f, -0.35120249f, -0.14887038f, 0.02741700f, 
    -0.08975463f, -0.07531381f, 0.04469785f, 0.06435707f, -0.04442001f, -0.18175276f, -0.04565861f, 0.15050760f, 
    0.06132545f, 0.10323013f, 0.02821209f, -0.08671208f, -0.01051791f, -0.05592393f, -0.00751677f, -0.09430407f, 
    -0.19038749f, 0.20145848f, -0.23956715f, 0.18630961f, 0.14313966f, -0.16578311f, 0.04885313f, -0.07270780f, 
    0.01314183f, 0.01722514f, 0.02013873f, 0.04904619f, -0.04488396f, 0.05296394f, 0.06382455f, -0.04964820f, 
    -0.00415221f, 0.13016801f, 0.01572528f, -0.04755385f, -0.09117284f, -0.02677534f, -0.23006269f, -0.17662953f, 
    -0.15012366f, 0.04440309f, 0.08302326f, -0.04288210f, 0.02776355f, 0.04728706f, 0.15067118f, 0.04700099f, 
    -0.01778840f, -0.03738621f, 0.07600028f, -0.00797146f, -0.01937029f, -0.06391166f, -0.07653215f, -0.04037923f, 
    -0.05463266f, -0.12469696f, -0.05695892f, 0.03430534f, 0.04203711f, 0.08113959f, -0.00468130f, 0.02812649f, 
    0.00408394f, -0.10056022f, -0.08300741f, 0.03049256f, 0.09650574f, 0.13112926f, -0.11883800f, 0.03072060f, 
    -0.02799417f, -0.04906381f, -0.02911067f, -0.02734569f, 0.23238944f, -0.04693303f, -0.08536623f, -0.16924582f, 
    -0.25428948f, 0.07601145f, 0.02762296f, 0.10754334f, 0.03617570f, -0.09774513f, 0.07000352f, -0.01510060f, 
    0.03245457f, 0.24453855f, 0.00251681f, 0.01825539f, -0.08422153f, -0.06798045f, -0.07170121f, 0.00563697f, 
    0.08163407f, -0.04190252f, -0.14921603f, -0.12396146f, -0.19516189f, -0.02201207f, -0.09051847f, 0.05934061f, 
    -0.01041053f, 0.07117131f, 0.02518113f, -0.05402674f, -0.05633146f, 0.11880326f, -0.03737405f, -0.03749820f, 
    0.03121640f, -0.09179793f, 0.19401336f, 0.01918873f, -0.13710856f, -0.18408342f, 0.04318220f, 0.04226527f, 
    0.09107559f, 0.07147159f, -0.15770145f, 0.01136867f, 0.03993659f, -0.00198812f, 0.15442897f, 0.03698613f, 
    -0.06664732f, 0.04559268f, 0.01383655f, -0.10125245f, 0.09081586f, -0.18598349f, 0.08550318f, 0.03808174f, 
    0.17873232f, -0.13016820f, -0.23735142f, -0.01162835f, -0.09308414f, 0.14133184f, 0.00969741f, 0.04809872f, 
    -0.09606437f, -0.14333229f, 0.01199001f, 0.02035502f, -0.05257167f, -0.02222968f, 0.04462286f, 0.09041605f, 
    0.07635330f, 0.15774308f, 0.08059052f, -0.14221267f, -0.49994513f, 0.22877523f, 0.25839338f, -0.14036936f, 
    0.02337533f, 0.01663182f, 0.00759353f, -0.03093559f, -0.14205533f, 0.17727265f, 0.11893576f, 0.02231337f, 
    -0.00564360f, 0.00030345f, 0.04279220f, -0.05686570f, -0.01971698f, 0.01033993f, -0.02794710f, 0.03168127f, 
    0.01427610f, 0.28555313f, 0.28945348f, 0.07736778f, 0.06394128f, 0.03628841f, 0.02217283f, 0.11158591f, 
    0.13426402f, 0.11509158f, -0.08798363f, -0.04580077f, -0.01056032f, 0.00067558f, -0.03977843f, 0.05137027f, 
    0.08496807f, 0.02691584f, -0.09405295f, 0.02757868f, -0.16726111f, -0.00148473f, 0.01086424f, -0.28236410f, 
    0.06212682f, -0.04580421f, -0.02561059f, 0.04837431f, -0.00552311f, -0.03941580f, 0.06664826f, 0.01316772f, 
    0.08908929f, -0.01688541f, 0.21519187f, -0.00820104f, 0.18287292f, -0.06964151f, 0.05503161f, 0.17452484f, 
    -0.47839895f, -0.01505943f, -0.16905312f, -0.16415253f, 0.21234544f, 0.11642106f, 0.02862729f, 0.07985462f, 
    0.03860158f, 0.05595944f, -0.06320705f, 0.14271455f, 0.01044978f, -0.01886042f, -0.03460899f, -0.01442379f, 
    0.04495120f, 0.09870882f, -0.04447441f, 0.06575403f, -0.10271074f, 0.17234640f, 0.08804738f, -0.15938930f, 
    0.18045910f, 0.10568663f, 0.01822769f, -0.00927715f, -0.01396901f, 0.17675658f, 0.06539567f, 0.00205344f, 
    0.02777100f, 0.06915364f, 0.09343428f, -0.07695185f, -0.01944764f, 0.03558851f, 0.16799866f, 0.01988405f, 
    0.12642255f, 0.02825367f, -0.05560989f, -0.08600134f, -0.11848616f, -0.02527271f, -0.03779564f, -0.03747846f, 
    0.04770981f, -0.00208523f, 0.02117750f, -0.01872261f, 0.13613343f, -0.03642957f, 0.05911753f, -0.03067341f, 
    0.09053465f, -0.21688923f, -0.13176538f, -0.04930302f, 0.35743120f, 0.27773681f, 0.10428197f, -0.00143718f, 
    0.01469245f, 0.18117931f, 0.17077735f, 0.09472102f, 0.10176127f, 0.06628414f, 0.02979205f, -0.06792225f, 
    0.10515402f, -0.02126308f, -0.08818518f, 0.06460543f, -0.01926032f, 0.04803644f, 0.00279731f, -0.05634211f, 
    -0.14110786f, 0.22664106f, 0.01428966f, 0.03882323f, -0.27389157f, -0.02410369f, 0.02602489f, -0.12436228f, 
    -0.08114460f, -0.09861536f, 0.13598694f, 0.09330531f, 0.03075588f, -0.01897710f, 0.06055566f, 0.10274077f, 
    0.12667154f, -0.10708524f, -0.21006289f, 0.04375365f, 0.11540687f, 0.31421113f, -0.28639111f, 0.23883562f, 
    0.02722299f, 0.06443380f, -0.01077424f, -0.04873827f, -0.01474857f, -0.05893834f, -0.16594069f, 0.10547455f, 
    -0.10107751f, -0.05188325f, 0.07210977f, 0.04600036f, 0.27296191f, 0.13808689f, 0.13870884f, 0.12009946f, 
    -0.00707971f, -0.35455501f, 0.01669950f, -0.18342000f, 0.20928878f, 0.17631768f, 0.07030789f, 0.05032399f, 
    0.10945525f, 0.07488771f, -0.16074432f, -0.09080457f, 0.11439940f, 0.18839215f, -0.02316855f, -0.00275004f, 
    0.08317136f, 0.02173425f, -0.07003444f, -0.02777243f, 0.28876686f, -0.11314002f, 0.05802548f, -0.06176977f, 
    0.06495740f, -0.04091679f, -0.08756919f, 0.02132997f, 0.05009539f, 0.00155222f, -0.16194306f, -0.07277723f, 
    -0.04198442f, 0.09188715f, 0.02548135f, 0.12361339f, 0.09279391f, -0.01185423f, -0.02539015f, 0.06769306f, 
    0.02502126f, 0.06269328f, -0.08623550f, 0.02496824f, -0.01083335f, -0.03568032f, -0.02885733f, -0.05868208f, 
    -0.02439522f, -0.07823609f, -0.06199737f, -0.00038175f, -0.08118639f, -0.01179517f, 0.04815701f, 0.10639513f, 
    0.00620330f, 0.04637766f, 0.19052345f, 0.18135685f, -0.06723753f, -0.04269479f, -0.08987343f, -0.07169069f, 
    -0.08703454f, -0.05815905f, 0.14739724f, -0.05955478f, -0.13682218f, -0.05778578f, -0.04031539f, -0.01889809f, 
    0.09762517f, -0.18431719f, -0.09481894f, -0.01517856f, -0.03280741f, 0.16103463f, 0.24524491f, 0.19751143f, 
    -0.26495641f, 0.37544683f, -0.10150363f, 0.08573947f, -0.08536966f, 0.12418642f, -0.05022242f, -0.06473032f, 
    0.06008662f, -0.05437412f, -0.03742904f, -0.07924853f, -0.00596223f, -0.05162473f, 0.16501470f, 0.03450743f, 
    0.07255017f, 0.28076088f, -0.28222984f, 0.04655306f, 0.08355381f, -0.10401765f, -0.00331201f, 0.16079961f, 
    0.15261291f, -0.06109551f, -0.07526267f, 0.03085005f, 0.02269876f, -0.01207890f, -0.17450112f, -0.15100150f, 
    0.06189633f, -0.02552858f, 0.08520129f, 0.19514354f, -0.04859141f, 0.07494701f, 0.18298869f, 0.19751234f, 
    0.01652645f, 0.19626273f, -0.08411101f, 0.10031854f, -0.04860931f, 0.01336998f, 0.07818339f, 0.08453672f, 
    -0.11848148f, 0.02596821f, -0.00856961f, 0.07827551f, 0.10257791f, 0.00690407f, 0.22188412f, 0.01446449f, 
    0.09083398f, -0.14677337f, -0.12194192f, -0.04393785f, 0.39930752f, 0.10452765f, -0.33068463f, -0.19042191f, 
    0.03467799f, -0.00379789f, 0.02199654f, 0.15309894f, 0.04204650f, -0.10717782f, -0.03737875f, 0.04766635f, 
    -0.10597949f, 0.10116144f, 0.01351954f, 0.04903732f, 0.08688273f, -0.21838786f, -0.10835763f, -0.08063955f, 
    0.01987146f, 0.10176745f, 0.23216927f, 0.04524030f, 0.20747231f, 0.11519400f, -0.05386297f, -0.10302011f, 
    -0.00284314f, 0.04994102f, -0.07450890f, 0.00193773f, -0.07479360f, 0.02093008f, 0.02066225f, -0.01673331f, 
    -0.04971170f, 0.06912577f, -0.01697744f, -0.01442073f, 0.13909444f, 0.15755835f, -0.03172158f, 0.01670063f, 
    -0.03908205f, 0.03301624f, 0.00265135f, -0.08590091f, 0.10622492f, -0.11563338f, 0.18591918f, -0.05789949f, 
    -0.12926798f, 0.07154316f, 0.05165499f, 0.01905191f, -0.02039908f, 0.16605769f, -0.03469200f, 0.09557501f, 
    0.23496287f, -0.20289744f, -0.06399588f, -0.13643537f, 0.11029427f, 0.06241175f, 0.10210347f, 0.03043132f, 
    -0.09199788f, 0.03019473f, -0.03576762f, 0.08440062f, 0.15460065f, 0.04417719f, 0.07498971f, 0.06524448f, 
    0.10528262f, -0.23935877f, 0.16107616f, -0.11148153f, 0.19233894f, -0.02491459f, -0.09880445f, -0.34661752f, 
    -0.18797956f, -0.02099279f, 0.05084418f, -0.11554796f, -0.12679449f, -0.08128896f, 0.02665498f, 0.01236479f, 
    0.04288689f, 0.10373747f, -0.04822652f, 0.15408115f, 0.11309114f, -0.26913455f, -0.22364658f, -0.11345453f, 
    -0.11522917f, 0.05823094f, 0.09503906f, 0.15537243f, 0.04772142f, -0.14503203f, 0.01501492f, -0.13929310f, 
    -0.03993082f, -0.04974595f, 0.08021368f, 0.02414007f, -0.10201038f, 0.03365970f, 0.03396819f, 0.18234530f, 
    -0.06644372f, 0.20796669f, 0.21179834f, 0.24394627f, 0.01562861f, 0.16865842f, -0.01605696f, 0.01110555f, 
    0.13352971f, 0.04945854f, -0.01755744f, -0.02199271f, -0.12886012f, -0.00981348f, -0.06490480f, -0.00549375f, 
    0.00323059f, -0.11025732f, 0.06922504f, -0.13593131f, -0.09319961f, 0.05032448f, 0.13570765f, -0.05459230f, 
    -0.04313691f, 0.03931362f, -0.02184475f, 0.04754738f, -0.00353029f, -0.02471372f, 0.04739415f, -0.00087522f, 
    0.04930872f, 0.01281091f, -0.00643378f, -0.02865627f, 0.02816700f, 0.01320375f, 0.04629021f, -0.01209545f, 
    -0.02248200f, 0.03075577f, 0.00986019f, -0.00174763f, -0.01221690f, -0.04919653f, 0.00689193f, 0.01239850f, 
    0.02082473f, -0.04533476f, 0.01314516f, 0.00338962f, -0.05033635f, 0.01830583f, -0.02253977f, 0.04290869f, 
    0.01488361f, -0.05615959f, -0.02178859f, -0.05258941f, -0.02486896f, -0.03693568f, -0.03100923f, -0.02461037f, 
    -0.05937970f, -0.00673915f, -0.01109995f, 0.02042465f, -0.01374606f, 0.04356172f, 0.02926885f, -0.04567619f, 
    -0.02948791f, -0.05945713f, -0.03981473f, -0.05867896f, 0.01922604f, 0.04195447f, -0.01970948f, 0.02603739f, 
    -0.05834958f, -0.02783317f, 0.02466023f, -0.06157400f, -0.03237113f, -0.00452847f, -0.01383478f, -0.01949751f, 
    -0.04892954f, -0.00779412f, -0.03705626f, -0.02854053f, -0.01855813f, -0.05198684f, -0.02506910f, -0.03083081f, 
    0.02576769f, -0.02563805f, 0.01636625f, -0.03635469f, -0.01303866f, -0.02213120f, 0.03891280f, 0.04919956f, 
    -0.02023382f, -0.01659578f, -0.05057304f, -0.04741687f, -0.04729487f, -0.04075749f, 0.00817641f, -0.03231004f, 
    -0.00964096f, 0.02580764f, 0.01031675f, -0.03674113f, -0.01892880f, 0.03599187f, -0.04935865f, 0.04366886f, 
    0.02034384f, -0.04763106f, -0.03470896f, 0.03272369f, 0.02738227f, 0.02444856f, 0.01394938f, 0.03353766f, 
    -0.04426201f, 0.00139206f, 0.04153597f, 0.00386138f, -0.03227283f, -0.02037811f, -0.00777073f, -0.02095610f, 
    -0.04143142f, -0.03510566f, -0.02936912f, -0.03117651f, 0.00559051f, 0.02848255f, -0.04849922f, 0.01150060f, 
    0.02683896f, 0.01743265f, -0.00109082f, 0.02690359f, -0.02889649f, -0.05000646f, -0.00785075f, -0.02560074f, 
    0.03421212f, -0.05927461f, -0.05638747f, 0.04944887f, -0.04815552f, 0.00049532f, -0.01436217f, 0.04553864f, 
    0.03567342f, -0.03528642f, 0.01712331f, 0.01442043f, -0.03655376f, -0.04947499f, 0.04814061f, -0.01411847f, 
    -0.02831310f, -0.03224849f, 0.03849941f, 0.01982422f, 0.00375504f, -0.04187365f, -0.02370248f, 0.04590829f, 
    0.04731205f, 0.02775511f, 0.03232807f, -0.02183869f, -0.02414088f, -0.01535808f, 0.01883214f, 0.00758078f, 
    -0.03944076f, -0.01330364f, -0.04350698f, 0.04894731f, 0.00280191f, -0.05626650f, -0.02000538f, -0.02132564f, 
    -0.05486596f, 0.00436614f, 0.02931244f, -0.00572987f, -0.05683857f, 0.00397822f, 0.04024718f, 0.01546411f, 
    0.00307154f, 0.04209887f, -0.03859528f, 0.04363077f, -0.04624622f, 0.04248425f, -0.06144142f, 0.02327450f, 
    0.00893464f, -0.04201159f, 0.02939299f, 0.04117015f, -0.02005658f, -0.05450898f, -0.05737552f, 0.03894235f, 
    -0.03371376f, 0.03383292f, 0.00752872f, 0.04869098f, -0.04239953f, 0.02132384f, 0.00687303f, -0.01068963f, 
    -0.05941984f, -0.03643089f, -0.04556374f, -0.02597998f, 0.03904460f, 0.02883706f, -0.00810821f, -0.05797795f, 
    -0.05621654f, -0.03366587f, -0.00708467f, -0.00109167f, 0.02966997f, 0.01616356f, 0.01774739f, -0.06100797f, 
    0.00739900f, -0.01009566f, -0.01199128f, 0.01359203f, -0.03162812f, 0.00748053f, 0.01762171f, -0.06125870f, 
    0.00356812f, 0.02147920f, -0.02540899f, -0.02385268f, -0.00872281f, 0.04865310f, -0.00352241f, -0.02218016f, 
    0.01304310f, -0.03843176f, 0.02678658f, 0.02994215f, -0.03854225f, 0.03074458f, -0.02323693f, 0.01920218f, 
    -0.03821471f, 0.02979052f, -0.02208447f, 0.01572706f, -0.04064708f, -0.03572090f, 0.03318902f, 0.00879039f, 
    0.02601092f, -0.03556990f, 0.04476328f, 0.02958284f, 0.04917545f, -0.05080850f, 0.03002138f, -0.05311673f, 
    -0.02689012f, -0.00279420f, -0.01440271f, -0.04696790f, -0.04718227f, -0.03540802f, -0.03339459f, -0.00753868f, 
    -0.01650780f, -0.00948532f, 0.02145941f, 0.02456750f, -0.05928787f, -0.04003251f, 0.04729091f, 0.00496502f, 
    -0.02601551f, 0.03472228f, -0.01036838f, 0.00265675f, -0.01465021f, -0.02853641f, -0.05516586f, -0.04973273f, 
    -0.01508469f, -0.00066265f, -0.02767502f, -0.06048448f, -0.05087911f, 0.04478518f, -0.02785247f, 0.00069412f, 
    -0.00814120f, -0.05718882f, -0.01600436f, 0.04419653f, -0.05959939f, -0.00176536f, -0.01855759f, -0.02214576f, 
    -0.03757060f, -0.01878986f, 0.03893423f, 0.04387812f, -0.01533273f, 0.00841144f, 0.00289366f, 0.04973376f, 
    0.03662335f, -0.05412494f, -0.00838454f, -0.04921056f, -0.06046630f, 0.03066463f, 0.01569308f, 0.01627984f, 
    -0.03840978f, 0.04011254f, -0.03628089f, 0.00236413f, -0.04137110f, 0.02826174f, 0.01195090f, -0.02884043f, 
    -0.03986639f, -0.01243556f, 0.03931280f, -0.00182627f, 0.03788384f, 0.00411815f, 0.00639646f, -0.00873928f, 
    -0.01822107f, -0.00620679f, 0.00240420f, -0.00977419f, -0.02139208f, 0.04692689f, -0.05203606f, 0.03773191f, 
    0.01863872f, 0.03428289f, 0.02969322f, 0.01190611f, 0.03255117f, -0.04766569f, 0.00642598f, -0.00766020f, 
    -0.03322706f, 0.01332761f, -0.01154196f, -0.04435954f, -0.03755143f, -0.03993930f, -0.05779016f, 0.03902769f, 
    0.00482693f, -0.05006675f, -0.03660406f, -0.01735666f, -0.00267219f, 0.01579644f, 0.01539425f, -0.02083013f, 
    -0.01000529f, 0.02448881f, -0.04154363f, -0.04491674f, 0.01817720f, -0.01963529f, 0.04389392f, 0.03265543f, 
    0.04351595f, 0.00089693f, 0.01002152f, 0.04910116f, -0.00108052f, 0.03979145f, -0.00713702f, 0.03127563f, 
    0.01925350f, -0.04285045f, 0.01728977f, -0.02619518f, -0.04839094f, 0.04570156f, -0.06153750f, 0.00369012f, 
    0.03842081f, -0.05885798f, -0.04126385f, -0.04225629f, 0.01975730f, 0.04027949f, -0.05762848f, -0.06240975f, 
    0.01608557f, 0.00197465f, -0.02919531f, -0.01703873f, -0.00673254f, -0.04629543f, 0.04533391f, -0.05552792f, 
    -0.05189763f, 0.02186496f, -0.05840063f, 0.02756920f, -0.05698663f, -0.05251197f, -0.02616307f, -0.05051908f, 
    0.03874667f, -0.01698625f, -0.01312057f, 0.04515362f, 0.02701237f, -0.05654263f, -0.00380040f, -0.02115730f, 
    0.03563558f, 0.00757142f, 0.00195503f, 0.04376097f, -0.06151145f, 0.00650434f, 0.00196379f, -0.01116035f, 
    0.01205856f, -0.03492329f, 0.00270386f, 0.02552751f, 0.01683537f, -0.02497051f, -0.02462805f, -0.01168388f, 
    0.02914359f, -0.01713466f, -0.02496081f, -0.00903008f, -0.01204572f, 0.01269206f, -0.05874633f, -0.05235256f, 
    0.00524217f, -0.05744270f, -0.03544152f, 0.01026749f, -0.00609446f, -0.02898646f, -0.04787923f, 0.00047580f, 
    -0.02751234f, -0.03208735f, -0.00699091f, 0.00568931f, -0.04835590f, -0.03000304f, 0.00705799f, -0.00458800f, 
    -0.02337711f, 0.03005967f, 0.06202506f, 0.00710500f, 0.04511390f, 0.01715733f, -0.05363082f, 0.01367046f, 
    0.02664238f, 0.01748786f, 0.04463929f, -0.04200305f, 0.01393556f, 0.00940657f, -0.04820615f, -0.02673331f, 
    0.01691046f, -0.05119443f, -0.00664774f, 0.03502385f, 0.03365381f, 0.02225594f, 0.02203398f, 0.01650814f, 
    0.01013324f, -0.00059267f, -0.03606588f, 0.00893125f, 0.04184344f, -0.04409496f, -0.03133255f, 0.01981885f, 
    -0.00407122f, -0.00802186f, 0.02528808f, -0.03874220f, -0.04503126f, -0.00032356f, -0.00157922f, 0.00536081f, 
    0.04836816f, 0.02851447f, -0.05634735f, -0.00880480f, -0.03528327f, 0.02836475f, 0.00935123f, -0.03827407f, 
    -0.04801008f, 0.00443108f, -0.00960463f, 0.01267809f, -0.05205103f, -0.04026961f, -0.01685286f, -0.01516190f, 
    0.03682307f, -0.04855096f, -0.01230034f, -0.06284305f, -0.00037774f, -0.04849414f, 0.00270942f, 0.03289192f, 
    0.02348901f, 0.02076565f, 0.01347908f, 0.04241247f, 0.04578952f, 0.00549848f, 0.00275430f, -0.04791173f, 
    -0.03732826f, 0.02067199f, -0.04693377f, 0.00470132f, 0.03944487f, -0.02947892f, 0.03700312f, -0.00273239f, 
    -0.03531786f, -0.00456461f, 0.04035206f, -0.02739387f, -0.05974872f, 0.04111317f, -0.05926026f, 0.00759361f, 
    0.00018215f, -0.00396187f, 0.03543005f, -0.02471318f, 0.03385388f, -0.02287048f, 0.02265782f, 0.01905291f, 
    -0.01851499f, 0.03323395f, -0.04181777f, 0.02436084f, -0.01112797f, 0.02057994f, -0.02657546f, -0.04010498f, 
    0.01391703f, -0.01884016f, -0.05617061f, 0.00556698f, -0.05597169f, -0.04778842f, -0.00296469f, 0.02755541f, 
    0.03520878f, 0.03785308f, -0.05360987f, 0.04034397f, -0.02670305f, -0.02452858f, -0.00604083f, 0.03568065f, 
    0.00746024f, 0.00376247f, -0.02685071f, -0.00935108f, -0.05240580f, -0.05946750f, -0.03900634f, -0.04864748f, 
    -0.03035296f, -0.05489989f, -0.04255884f, -0.00101956f, -0.05860132f, -0.05575873f, -0.03640240f, -0.05956834f, 
    0.00045219f, -0.01825831f, -0.04349095f, -0.04418512f, -0.04102824f, -0.01068636f, 0.00028263f, 0.04276780f, 
    0.03268775f, 0.02398444f, -0.03867663f, -0.06285714f, 0.04368426f, -0.01643148f, -0.02342447f, -0.05531584f, 
    -0.02867204f, 0.04784836f, -0.01621609f, 0.02134383f, 0.01365100f, -0.00190724f, -0.00027713f, -0.01946007f, 
    0.03878406f, 0.03735067f, 0.03536157f, -0.04177849f, -0.02908397f, -0.03240821f, 0.03097069f, -0.01699259f, 
    -0.03818346f, -0.00661582f, 0.02862042f, 0.04646410f, 0.01035566f, -0.03235991f, 0.04829492f, 0.00424185f, 
    0.01007255f, 0.01767124f, 0.03620824f, 0.03925103f, -0.00304565f, -0.00776451f, 0.00591585f, 0.00393535f, 
    -0.05073960f, -0.02979566f, -0.05828862f, 0.04201173f, -0.03291925f, 0.00695518f, -0.03734830f, 0.01308893f, 
    0.02850263f, 0.03802513f, -0.00851249f, -0.03918301f, 0.03581649f, -0.00549368f, 0.02551584f, -0.02052650f, 
    -0.07604829f, 0.01309109f, -0.02672120f, -0.02848726f, -0.05255274f, -0.06538442f, -0.05090411f, 0.00071124f, 
    0.03118305f, -0.05394362f, -0.06615719f, -0.04527933f, 0.00360648f, 0.00818065f, 0.03878167f, -0.04674008f, 
    -0.04005060f, 0.02112064f, -0.03901268f, 0.05186852f, 0.01155986f, 0.01819476f, 0.00920611f, -0.01153120f, 
    -0.01667010f, -0.02898452f, -0.02480337f, 0.03990135f, 0.05632954f, -0.00272867f, 0.00384375f, -0.04721657f, 
    -0.03290418f, 0.01135105f, -0.00541162f, 0.02099149f, -0.00184328f, -0.02106173f, 0.03443312f, 0.02976899f, 
    0.05379613f, 0.01753637f, 0.02059011f, 0.03014718f, 0.00536394f, -0.03636067f, -0.04440653f, -0.02003750f, 
    -0.01448590f, 0.01582981f, -0.04743494f, -0.05895500f, -0.04330133f, -0.04586900f, -0.01653030f, -0.04262166f, 
    -0.02670986f, -0.05493464f, -0.00254665f, -0.06482438f, 0.00194936f, -0.07009843f, -0.03126001f, 0.00671472f, 
    -0.00950933f, -0.01717831f, -0.01091806f, -0.03785076f, 0.02638078f, -0.00427321f, -0.07428885f, 0.03396712f, 
    -0.05045297f, -0.00633574f, 0.03572415f, 0.01980259f, -0.02936023f, -0.03061993f, -0.02540580f, 0.01232738f, 
    -0.01723735f, -0.06333509f, 0.01455645f, -0.07447914f, -0.03528026f, -0.00950951f, 0.03347192f, -0.00093545f, 
    -0.01140268f, -0.03281657f, 0.00731493f, -0.05611876f, 0.03230408f, -0.00048220f, 0.01516023f, 0.02001233f, 
    0.00379348f, 0.01589013f, -0.04177988f, 0.04934883f, 0.00339693f, -0.00056706f, -0.05600048f, 0.01597324f, 
    -0.04912446f, 0.03681776f, -0.01009790f, -0.00470353f, 0.06516752f, -0.03482089f, 0.05402608f, -0.01704088f, 
    0.02111361f, -0.01592940f, -0.05529916f, -0.05476712f, 0.00964464f, -0.02744693f, 0.06079536f, 0.02463863f, 
    -0.03493153f, 0.00069064f, -0.04427452f, 0.03144170f, -0.05079067f, 0.00632648f, -0.03200712f, -0.05187937f, 
    -0.06206168f, 0.01180102f, -0.05225191f, 0.04058393f, -0.06180693f, -0.03584199f, 0.04420336f, 0.00092214f, 
    -0.07210810f, -0.07103306f, -0.04156999f, -0.07346529f, -0.05216210f, -0.03617899f, -0.03347875f, -0.04093625f, 
    0.03747353f, -0.06381822f, -0.00762906f, -0.01322213f, -0.05418757f, -0.03371415f, -0.04059255f, -0.07502497f, 
    -0.03705250f, -0.04690176f, -0.04723217f, -0.02226946f, -0.00775977f, 0.02165259f, -0.02120426f, 0.03735999f, 
    0.03410251f, -0.06244953f, 0.05141098f, 0.00541974f, -0.02377895f, 0.00834271f, -0.01044234f, -0.02378512f, 
    -0.03540085f, -0.02239164f, -0.01841968f, -0.00657436f, -0.05571084f, 0.02265812f, -0.00546665f, -0.02343260f, 
    -0.00743648f, -0.05456439f, -0.01529897f, 0.00685054f, -0.06837191f, -0.02695376f, 0.03377788f, 0.05728596f, 
    0.03964134f, -0.05628349f, -0.04744638f, -0.04496563f, 0.02585202f, 0.01498344f, 0.06197995f, 0.04961029f, 
    0.04066435f, -0.04658102f, -0.04198841f, -0.01668227f, -0.03279633f, -0.00610755f, 0.04298585f, -0.01012562f, 
    0.01256693f, 0.00387234f, 0.02675553f, 0.03970445f, -0.01537829f, -0.06659380f, 0.01680388f, -0.01690268f, 
    0.02017844f, -0.01610757f, -0.01474570f, -0.01166002f, -0.01475491f, 0.02495630f, -0.02702544f, -0.01375274f, 
    0.03942808f, 0.03118297f, -0.05086760f, 0.05058843f, -0.06213623f, -0.04180509f, -0.05452803f, -0.06048140f, 
    -0.01518998f, -0.05638443f, -0.04518052f, -0.01816698f, 0.02789373f, 0.00466891f, -0.02253531f, -0.00658589f, 
    -0.03305998f, 0.00862650f, -0.03650778f, 0.02663590f, -0.04638329f, 0.03091816f, -0.04895993f, -0.03844783f, 
    0.03298414f, 0.04705274f, 0.01904186f, -0.04699100f, 0.01060089f, -0.03812671f, -0.05018919f, -0.00210868f, 
    0.00172647f, -0.01844140f, 0.02865457f, 0.00853800f, -0.02442923f, 0.00817828f, -0.03279375f, -0.00053024f, 
    -0.01920823f, 0.01415517f, -0.05304113f, -0.06269293f, 0.01114774f, -0.01713147f, -0.04170448f, 0.01525440f, 
    0.01602975f, -0.02541568f, -0.02559174f, -0.03251683f, -0.00185690f, 0.01119404f, -0.00345565f, 0.00625711f, 
    -0.00058073f, 0.02164921f, 0.00005492f, -0.01226324f, -0.07286941f, 0.01208592f, -0.03015022f, 0.03495888f, 
    0.02691712f, -0.03002260f, -0.06716131f, -0.03060137f, -0.02479915f, -0.02378793f, 0.03451637f, 0.00336636f, 
    0.03906906f, -0.02517018f, 0.00504967f, -0.02372262f, -0.00219006f, -0.07077003f, -0.04620824f, -0.06154744f, 
    -0.04431758f, 0.04973052f, 0.00497379f, -0.04604181f, -0.01232597f, 0.01894891f, -0.00177434f, -0.00699107f, 
    0.30730173f, 0.23608805f, 0.02036547f, -0.16771221f, 0.15319549f, 0.16008030f, 0.02785940f, 0.02819207f, 
    0.00607292f, 0.06585557f, -0.07682709f, 0.07206436f, 0.00942805f, 0.10937166f, -0.07065255f, 0.02257778f, 
    -0.04582500f, 0.15468870f, -0.02204107f, 0.02788408f, -0.12057756f, -0.06156590f, 0.09540609f, 0.09309768f, 
    -0.14249206f, 0.00758037f, -0.04475552f, 0.00707074f, 0.17563921f, 0.10530940f, -0.01882624f, 0.08173661f, 
    -0.06964377f, 0.05086200f, 0.02057364f, 0.03184651f, -0.11948851f, -0.03824268f, -0.03130344f, -0.00503443f, 
    0.27626348f, 0.38777497f, 0.26726431f, -0.08070116f, -0.05124295f, 0.07504763f, 0.02115400f, 0.04162825f, 
    -0.06636856f, 0.07013316f, 0.05051616f, 0.03319654f, -0.06347656f, -0.04873937f, 0.02406696f, 0.04106994f, 
    -0.04856537f, -0.11182825f, -0.08544987f, -0.03943705f, -0.27489108f, -0.36765438f, -0.05784778f, -0.03061449f, 
    0.01675899f, 0.04327794f, -0.03320551f, 0.14687663f, -0.10589564f, -0.07773815f, -0.03890849f, 0.06506968f, 
    -0.09022192f, -0.07972247f, 0.04776951f, 0.08962125f, -0.09155682f, -0.06640943f, -0.02473723f, -0.09336239f, 
    -0.00435531f, -0.34284297f, 0.02960860f, 0.01639836f, -0.20060159f, 0.02105034f, 0.03259155f, 0.01031129f, 
    -0.04087217f, 0.02149963f, -0.02354389f, 0.00949916f, 0.12711331f, 0.07726952f, 0.09928632f, 0.00742188f, 
    0.17168143f, -0.06607255f, 0.03702665f, -0.14243169f, 0.15111426f, -0.15811940f, 0.14686590f, -0.02393655f, 
    -0.13475376f, -0.05405865f, -0.04894670f, 0.03679796f, 0.09742855f, 0.04067615f, 0.01562437f, 0.04221679f, 
    0.01259265f, -0.01591153f, -0.03304727f, 0.06576454f, 0.01495128f, -0.22903025f, 0.05248897f, -0.14496940f, 
    -0.05014812f, -0.20092712f, 0.39452979f, -0.02322136f, 0.12200860f, 0.22880264f, -0.05609394f, 0.07248908f, 
    0.02226119f, -0.02041980f, 0.04804027f, 0.04047775f, 0.08563454f, 0.04348633f, 0.01735978f, 0.13534968f, 
    0.05219556f, -0.00648353f, 0.02024584f, 0.03695618f, 0.29434055f, -0.16082817f, 0.14477976f, -0.00570483f, 
    -0.26724684f, 0.02770960f, 0.06558169f, -0.10664293f, 0.00873916f, 0.08282045f, 0.05530874f, 0.08837452f, 
    0.00404652f, 0.04854171f, 0.01452343f, 0.15485899f, 0.02293347f, 0.03431412f, -0.11709816f, 0.04378311f, 
    -0.24485931f, 0.20456085f, 0.14546396f, -0.13598014f, 0.09752012f, 0.23743108f, -0.01635501f, -0.06172787f, 
    0.07368861f, -0.00454054f, 0.04856890f, -0.03753573f, 0.00933774f, 0.04394140f, 0.01217314f, -0.08285658f, 
    -0.02842081f, -0.01865493f, 0.02644731f, 0.12398168f, 0.29685184f, -0.01692812f, -0.00695881f, -0.00187999f, 
    -0.41007280f, 0.06239987f, 0.02974382f, 0.04111964f, 0.05812097f, 0.06767973f, -0.01490311f, -0.07761070f, 
    0.13994573f, 0.01606093f, -0.00187172f, 0.14109090f, 0.12008215f, 0.04770482f, 0.00398837f, 0.08332209f, 
    0.04976170f, -0.11716002f, -0.33717775f, 0.04872063f, -0.26826248f, 0.06668097f, 0.10188481f, 0.14851844f, 
    0.02261333f, 0.05933166f, 0.10459697f, -0.01467408f, 0.00708486f, -0.04408678f, 0.06214699f, 0.01144951f, 
    0.05601618f, 0.01570784f, 0.04751344f, -0.03635118f, 0.01924838f, 0.00138907f, 0.01390483f, -0.00115771f, 
    -0.02523727f, 0.07538527f, 0.02018646f, 0.10247683f, 0.01084203f, 0.18698113f, 0.04853020f, 0.03393117f, 
    -0.02025077f, -0.02052387f, -0.03037602f, 0.07218249f, -0.08070680f, 0.07539071f, 0.06035343f, -0.02347137f, 
    -0.18393916f, 0.16053157f, -0.18178502f, 0.01467006f, -0.03130408f, -0.05975590f, 0.07974362f, -0.04711599f, 
    0.11955439f, 0.04371297f, 0.08640783f, 0.03642375f, -0.01735663f, -0.03969106f, -0.00151016f, 0.05612612f, 
    0.04295437f, -0.04456592f, -0.00503136f, 0.09940436f, 0.41477332f, -0.27253720f, 0.20477633f, -0.18135661f, 
    0.05279939f, 0.05254807f, 0.12728640f, 0.11375316f, -0.12210753f, 0.08161215f, -0.06065568f, -0.00649809f, 
    -0.02473856f, 0.03657662f, -0.02766985f, 0.11644980f, 0.08357177f, -0.03208530f, -0.13153498f, 0.05510406f, 
    -0.07318239f, -0.19139811f, -0.06402057f, 0.06679591f, -0.03497982f, 0.06511743f, 0.03410074f, 0.06260585f, 
    -0.08231705f, 0.06976188f, 0.04486870f, 0.08021911f, -0.01781354f, 0.06803562f, -0.07541610f, -0.06900361f, 
    0.14496912f, -0.00669316f, -0.11164496f, 0.02027710f, -0.04622522f, -0.12259265f, -0.16883209f, 0.13942763f, 
    -0.20642658f, -0.04939413f, -0.05085656f, 0.03619915f, 0.09787086f, 0.03171800f, -0.00232645f, -0.00207733f, 
    -0.10999297f, -0.04769265f, 0.08054275f, 0.06407803f, 0.06076423f, 0.09825957f, 0.10642470f, 0.05972848f, 
    -0.05316465f, 0.04912864f, -0.01784966f, 0.03836977f, -0.04019510f, -0.05162153f, 0.01422351f, -0.02366468f, 
    0.00637828f, -0.01087426f, 0.04461416f, -0.00756958f, -0.03686232f, 0.00510882f, 0.03012552f, -0.04955315f, 
    0.02227408f, -0.04399119f, -0.05530832f, -0.01054331f, -0.02222042f, -0.03117403f, 0.00983006f, -0.04525026f, 
    0.04533984f, 0.00710858f, 0.01727089f, 0.00453088f, 0.01903013f, 0.03529166f, 0.00676840f, 0.01872307f, 
    -0.01464107f, -0.03803161f, 0.03722780f, -0.04142594f, -0.03819374f, 0.00648081f, 0.02848012f, 0.04071885f, 
    -0.00447678f, -0.04477962f, 0.00859657f, 0.00945403f, -0.05965416f, 0.03401126f, 0.04011143f, 0.03170130f, 
    -0.02451704f, -0.02431217f, -0.00997958f, -0.03167624f, -0.00974154f, 0.00875805f, 0.04368294f, -0.03885739f, 
    -0.02650511f, 0.03233703f, -0.01114513f, 0.01189431f, -0.03139877f, -0.01008033f, -0.05252074f, -0.02631954f, 
    -0.05621035f, 0.02148613f, 0.03528631f, 0.04489657f, -0.04075858f, -0.02753552f, -0.01437118f, 0.01366866f, 
    0.04106496f, 0.01725207f, -0.01607068f, -0.01539744f, 0.04588102f, -0.03188253f, -0.02828889f, -0.01208417f, 
    -0.02467405f, 0.04705095f, 0.02659036f, -0.02944578f, -0.01866664f, -0.05114930f, 0.00294155f, 0.01622679f, 
    -0.04261399f, -0.00485616f, 0.02290161f, -0.05441428f, 0.03145995f, -0.05984645f, -0.04242473f, -0.04945310f, 
    0.03950356f, -0.05807689f, -0.04854609f, 0.00918826f, -0.03463606f, 0.01168157f, 0.04877482f, 0.01229936f, 
    -0.01112597f, -0.01513562f, -0.01291908f, 0.00562308f, -0.00385940f, 0.00901013f, 0.01708611f, 0.02416791f, 
    0.03994690f, 0.01393279f, -0.04896660f, 0.02830225f, 0.02524819f, -0.03557732f, -0.01186075f, -0.03533655f, 
    0.02419205f, -0.03216962f, 0.02047145f, -0.03437556f, 0.04034618f, 0.04203798f, -0.00391770f, 0.02658213f, 
    0.00098596f, -0.01827351f, -0.02124146f, -0.03335798f, 0.00858214f, -0.00683385f, 0.01842464f, -0.04265567f, 
    -0.02209150f, -0.04024367f, 0.04335550f, -0.01095690f, 0.02181835f, -0.03478187f, -0.02319189f, 0.01494933f, 
    0.04224557f, -0.04737109f, 0.01884780f, -0.04468304f, -0.05290454f, 0.03087552f, -0.04565406f, 0.02145076f, 
    -0.00187472f, -0.00933141f, 0.03120014f, 0.03664632f, -0.02140158f, 0.03836795f, 0.04753447f, 0.04439218f, 
    0.03823326f, 0.01447001f, 0.01353211f, 0.03131875f, -0.00734026f, -0.00666296f, -0.03615643f, 0.03034619f, 
    0.01319662f, 0.01061433f, -0.03954467f, -0.03735612f, -0.02645165f, -0.01820254f, -0.01891639f, -0.04260645f, 
    0.02058410f, -0.03482197f, -0.01822523f, 0.02601393f, 0.02548369f, 0.04151991f, -0.04880200f, -0.00473415f, 
    -0.05517276f, 0.00574328f, -0.04078249f, 0.04413116f, 0.02405775f, -0.02967792f, -0.03827415f, -0.01150107f, 
    -0.03029225f, -0.01456326f, 0.00814194f, -0.04952385f, -0.00093871f, 0.00204834f, -0.03337917f, -0.02618009f, 
    -0.04987545f, -0.02917021f, -0.04833029f, -0.03969578f, -0.05987914f, -0.00141948f, 0.00495410f, -0.05683473f, 
    -0.02469714f, -0.03560029f, -0.03000416f, -0.00811927f, -0.01863950f, -0.00840865f, -0.05197195f, -0.04314180f, 
    -0.05442854f, 0.03410105f, -0.01912055f, -0.02485238f, -0.00664481f, -0.06021262f, -0.03639758f, -0.05125762f, 
    -0.01532898f, 0.02062125f, 0.00789505f, -0.03386720f, 0.04702958f, 0.03180451f, -0.03485816f, 0.01523623f, 
    -0.00884401f, -0.02322341f, 0.04987681f, 0.03686750f, 0.02747599f, -0.02369406f, -0.02066346f, -0.01613780f, 
    -0.05103969f, -0.00819465f, -0.01461667f, 0.03011011f, -0.00460305f, 0.04531327f, -0.05271946f, -0.02718763f, 
    -0.00280013f, -0.00093854f, -0.01697362f, -0.04747288f, -0.05516681f, 0.02720354f, -0.03460405f, -0.05608630f, 
    0.00169834f, -0.04473124f, -0.02464772f, 0.05028201f, 0.04516408f, -0.04031349f, -0.01288846f, 0.05008889f, 
    0.03037724f, 0.02760721f, 0.04009224f, -0.02734275f, 0.00536667f, -0.01860488f, 0.01406910f, -0.00398463f, 
    0.01085014f, 0.03588425f, 0.02435957f, 0.02219260f, -0.04900971f, -0.00510885f, -0.05913461f, 0.00101156f, 
    -0.03970599f, 0.03666752f, 0.04518104f, -0.04036973f, -0.05762883f, 0.00996473f, -0.01661444f, -0.00662105f, 
    0.00298492f, -0.04494912f, -0.01314915f, -0.05358541f, -0.06096516f, -0.01462216f, 0.03971478f, -0.03273139f, 
    0.02489087f, 0.01327786f, -0.00410112f, 0.04626339f, -0.03292765f, -0.05469533f, 0.03743183f, 0.02474332f, 
    -0.02803188f, -0.04258040f, 0.01630943f, 0.02266608f, -0.05838745f, -0.01074818f, 0.03423671f, -0.05158977f, 
    -0.03246009f, 0.00989275f, -0.03055035f, -0.05134153f, -0.05601460f, -0.00710422f, -0.05242435f, 0.02228251f, 
    0.14144062f, -0.00095543f, 0.40682000f, 0.14823796f, 0.09194986f, 0.03000644f, -0.07057977f, 0.03296521f, 
    0.01339624f, 0.02514860f, 0.03792217f, -0.11823992f, 0.13039948f, 0.00289053f, 0.01483880f, 0.01690600f, 
    -0.04302643f, -0.09216497f, 0.05425005f, -0.14000045f, -0.02476843f, -0.40175784f, 0.06556651f, 0.01736195f, 
    -0.13167018f, 0.05184199f, 0.09941612f, 0.04342170f, 0.00146242f, 0.02509672f, -0.07753711f, -0.11503174f, 
    0.00847561f, 0.08343463f, -0.00183849f, -0.05085150f, -0.16244391f, -0.15109092f, 0.03267735f, -0.05658324f, 
    0.18941188f, -0.08655906f, -0.20822015f, 0.01752322f, -0.00265863f, -0.10231338f, 0.13141347f, 0.03098229f, 
    -0.05595129f, 0.04004532f, 0.10722894f, 0.09257347f, -0.07003978f, -0.00511116f, 0.14375648f, 0.04839570f, 
    0.11482567f, 0.05336733f, -0.00849959f, 0.03681872f, 0.00792243f, 0.02892395f, 0.24154197f, -0.05388783f, 
    -0.06782175f, 0.13203889f, 0.03907456f, -0.06995771f, -0.02790475f, 0.06062947f, 0.06133761f, 0.12692197f, 
    -0.00314710f, 0.00471861f, 0.01725004f, 0.03498724f, -0.05168459f, -0.08030959f, -0.02605779f, 0.05537403f, 
    0.20844571f, -0.07566766f, -0.06017939f, -0.05680183f, -0.08923868f, 0.06859417f, 0.05734557f, 0.05708285f, 
    0.02523638f, 0.11350486f, -0.00115499f, -0.04355754f, -0.02106182f, -0.09622653f, -0.03219257f, -0.02856619f, 
    -0.06177745f, 0.01665805f, -0.06666577f, 0.13178399f, -0.14675650f, -0.08998146f, 0.09093747f, 0.14735322f, 
    0.03413855f, 0.16010527f, -0.05823320f, -0.14094062f, -0.02241976f, 0.04641743f, 0.00505293f, 0.00293349f, 
    0.05441673f, 0.15468439f, 0.03422488f, -0.07889035f, -0.05655541f, 0.07405256f, -0.12119500f, 0.04672466f, 
    0.08268201f, -0.22731248f, -0.21426611f, -0.02145535f, 0.06208485f, -0.19615513f, 0.05459291f, 0.09830336f, 
    0.01460174f, -0.00827075f, 0.13655160f, 0.11521642f, 0.03153871f, 0.06904572f, -0.01852885f, -0.03615819f, 
    0.06179581f, -0.06090512f, 0.13967253f, 0.03517824f, -0.27661973f, -0.07829705f, -0.06426902f, -0.17077558f, 
    0.02788105f, 0.11235528f, 0.00304413f, 0.12155405f, 0.02871963f, -0.01621934f, 0.16493987f, 0.07749945f, 
    -0.12420564f, -0.02702332f, -0.02328306f, -0.06584278f, 0.10007845f, 0.01278544f, 0.05851086f, -0.17509262f, 
    0.21359673f, -0.20176645f, 0.02742720f, -0.06525119f, 0.06624471f, -0.09044383f, -0.05220890f, -0.05326953f, 
    -0.00709410f, 0.00547021f, -0.04355717f, -0.05322140f, -0.02390599f, 0.04444083f, -0.15651233f, 0.03515927f, 
    0.04941662f, 0.05167615f, -0.02013165f, -0.04540288f, -0.20827624f, -0.06800112f, 0.41144446f, 0.18947560f, 
    0.15134782f, 0.07460345f, 0.10865346f, 0.03665935f, -0.13040642f, 0.06959394f, 0.11367880f, 0.11068720f, 
    -0.01954814f, -0.00151378f, 0.13713682f, -0.01260708f, -0.04631876f, 0.02436560f, 0.04690134f, 0.00295405f, 
    -0.14019006f, -0.02154698f, 0.10214294f, -0.20649861f, 0.11282183f, -0.00041798f, 0.14950825f, 0.04354519f, 
    0.14728768f, -0.05871339f, 0.02967756f, -0.04134886f, 0.02513048f, 0.01390679f, -0.05607680f, 0.02429239f, 
    0.01434347f, -0.03986827f, 0.00582686f, 0.05026678f, -0.02283831f, -0.18084650f, 0.09981028f, -0.13186401f, 
    0.11313706f, -0.08517549f, 0.00901145f, -0.03027398f, -0.10258199f, -0.05302654f, -0.04132746f, 0.03229170f, 
    0.14466184f, -0.01425786f, 0.11864061f, -0.03869535f, 0.18455048f, -0.09281220f, 0.03046857f, 0.05462447f, 
    0.03823620f, -0.18064865f, -0.03444615f, 0.22421896f, -0.05409746f, 0.09251105f, -0.04392651f, 0.03444698f, 
    -0.03636565f, -0.14219421f, 0.04640446f, 0.05635792f, -0.00549482f, 0.03163313f, -0.08634187f, -0.00128108f, 
    -0.02769159f, 0.13417223f, -0.00962176f, 0.09925744f, -0.28421780f, 0.54586864f, 0.19309442f, 0.28419620f, 
    0.16108692f, -0.03202176f, 0.02087798f, 0.10341050f, 0.10705491f, 0.11884137f, -0.00370676f, -0.03061854f, 
    0.04623082f, 0.05991856f, 0.12777191f, -0.02762066f, -0.04817029f, 0.01951665f, 0.05628452f, 0.01716670f, 
    -0.02152392f, -0.07508904f, 0.03966200f, -0.02483822f, 0.00627596f, 0.02843810f, 0.05016393f, -0.02572930f, 
    -0.00216764f, 0.05347559f, -0.08012370f, -0.04437523f, 0.03775729f, 0.03476476f, 0.05568223f, 0.03308899f, 
    -0.02907101f, -0.06324217f, -0.01875705f, 0.01256159f, -0.05948197f, 0.03429965f, -0.01432442f, -0.01888250f, 
    0.07134294f, 0.21220185f, 0.14733855f, 0.08837596f, 0.14386494f, 0.02932632f, 0.05291176f, -0.03451478f, 
    0.05314939f, 0.09425910f, -0.03638889f, 0.01804390f, -0.01799716f, -0.05742223f, -0.10682909f, 0.13055801f, 
    -0.21391715f, 0.17308033f, -0.07400649f, -0.08709652f, -0.16194911f, -0.02263297f, 0.00876427f, -0.12056535f, 
    0.08805984f, -0.00286497f, 0.04873682f, 0.05980738f, -0.04063192f, -0.02374547f, 0.02266633f, 0.14577894f, 
    0.02974990f, -0.02344140f, 0.01577219f, 0.09063298f, 0.02029386f, 0.34131628f, 0.11605579f, 0.21371058f, 
    0.21179545f, 0.06157120f, 0.01569996f, -0.04903765f, 0.03678420f, 0.05703436f, -0.04502239f, 0.09523062f, 
    -0.00279925f, -0.10776416f, 0.03467751f, 0.01873819f, 0.15768810f, -0.03417449f, -0.03189626f, -0.02502871f, 
    0.02810893f, 0.01136606f, 0.18782772f, -0.03207501f, -0.08581673f, 0.18787113f, 0.14207692f, 0.10719749f, 
    0.09507465f, -0.06529468f, -0.08782686f, -0.06254444f, 0.06456679f, 0.11094591f, -0.12331351f, -0.01585457f, 
    0.07257014f, -0.03812554f, -0.06226739f, 0.07166162f, -0.01649096f, -0.06227937f, 0.15281038f, 0.17996079f, 
    0.11673379f, -0.09762284f, -0.03907752f, 0.06464635f, 0.07502638f, -0.04934233f, 0.02903648f, 0.05392471f, 
    -0.00060868f, 0.07960710f, 0.02306568f, 0.01213310f, 0.08835829f, 0.04526477f, 0.00812143f, -0.05595849f, 
    0.12304089f, -0.01437277f, 0.01870462f, 0.16090342f, -0.01000496f, -0.08327540f, 0.02500729f, 0.03932338f, 
    0.01097595f, 0.10425323f, -0.07899228f, 0.06294870f, -0.10494132f, -0.03566707f, 0.04235657f, 0.05392212f, 
    -0.03873625f, -0.03650457f, -0.06090719f, 0.05868693f, 0.10150127f, -0.03879095f, 0.10509218f, 0.00078708f, 
    0.09445108f, -0.11269158f, 0.05029567f, 0.05166003f, -0.04543485f, 0.02497237f, -0.06184618f, -0.07776652f, 
    -0.06875167f, -0.14258265f, -0.04529091f, 0.01580226f, 0.01324775f, -0.00925095f, 0.19081907f, -0.00157092f, 
    -0.20443673f, 0.02823375f, -0.04143709f, 0.13565207f, 0.24272278f, 0.04642118f, 0.12684372f, -0.04816449f, 
    -0.03602845f, -0.03992724f, 0.00495070f, -0.01206846f, 0.00926508f, 0.05291150f, 0.07428731f, 0.05497072f, 
    0.01243979f, 0.12737174f, -0.18214954f, 0.01367883f, 0.38616842f, 0.09197570f, 0.09423009f, 0.08448923f, 
    -0.02271028f, -0.01509583f, 0.06183768f, 0.02390599f, -0.02196311f, -0.04602655f, -0.07254387f, -0.10505392f, 
    0.06350316f, 0.08696721f, -0.03435126f, 0.19675021f, -0.15434292f, 0.01778594f, 0.00232960f, 0.16581933f, 
    -0.29494447f, 0.26003259f, 0.09699168f, 0.02256447f, 0.34696892f, 0.06923113f, 0.15049694f, -0.18067999f, 
    -0.00301237f, -0.02778281f, 0.02609497f, 0.03475576f, 0.02431401f, 0.02503393f, 0.09719248f, -0.08526561f, 
    0.08641211f, -0.09054430f, -0.01156687f, 0.06465181f, 0.31720060f, -0.28761894f, -0.11991370f, -0.03050969f, 
    -0.09023878f, -0.01705098f, -0.02740141f, 0.00768692f, 0.11462536f, 0.00719925f, -0.19000100f, 0.09961727f, 
    0.01114899f, 0.04238286f, 0.01152337f, 0.10055306f, 0.06012336f, 0.02139815f, -0.01953556f, -0.02703522f, 
    0.01568935f, 0.05917038f, 0.03024692f, -0.07923345f, -0.11871967f, 0.05647539f, -0.03493158f, 0.10421121f, 
    -0.09257586f, 0.04694738f, 0.05845665f, 0.05495403f, -0.07108766f, -0.00177035f, 0.06045633f, 0.03146996f, 
    -0.10089497f, 0.03207491f, -0.04104323f, -0.00135748f, 0.19211936f, 0.10897612f, -0.02588794f, 0.23023464f, 
    0.10240730f, 0.06076674f, -0.02457195f, 0.06263267f, 0.06919994f, -0.01265936f, 0.05081625f, -0.10423835f, 
    -0.03997464f, 0.02741591f, -0.03914542f, 0.05534850f, 0.00733935f, 0.17304838f, -0.10386851f, -0.02307606f, 
    0.09515939f, 0.05378535f, 0.02182098f, -0.03596332f, 0.02778481f, -0.10980609f, 0.06703809f, 0.01809443f, 
    0.04032288f, 0.03087041f, 0.07442956f, 0.06779988f, 0.09760235f, -0.02553678f, 0.04942140f, 0.03009701f, 
    0.04835991f, -0.09100685f, -0.07615236f, 0.06141197f, 0.18149848f, -0.22816265f, -0.14706017f, -0.28978530f, 
    -0.20251916f, -0.12474570f, -0.11780693f, 0.01591117f, 0.01598765f, 0.04485829f, 0.01011091f, 0.01376395f, 
    -0.02410164f, 0.01669875f, 0.01934770f, 0.02858851f, 0.02157427f, -0.03283808f, -0.07412009f, 0.04078741f, 
    0.06970385f, -0.00046842f, 0.07057545f, 0.19612108f, 0.22052965f, -0.03920918f, 0.11752526f, 0.02403999f, 
    -0.04969062f, -0.00846475f, 0.01862418f, 0.04542261f, -0.09139960f, 0.04256279f, -0.09071365f, -0.00319148f, 
    -0.03648178f, 0.00833691f, 0.19402261f, 0.09425206f, -0.26230592f, 0.07817686f, -0.02777427f, 0.04313094f, 
    -0.02431462f, -0.04473837f, -0.07475230f, 0.12827636f, -0.08067014f, 0.01304421f, -0.06581140f, 0.03677374f, 
    -0.11373346f, 0.02509377f, 0.03038003f, -0.09554326f, -0.06640573f, -0.02145644f, 0.10074002f, -0.15272193f, 
    -0.34293294f, -0.37298942f, -0.37683424f, -0.05740331f, -0.05109113f, 0.04604270f, 0.11032183f, -0.10653567f, 
    -0.21829349f, -0.01986308f, 0.15064715f, 0.06148178f, 0.06322362f, 0.08157781f, 0.03114619f, 0.00369087f, 
    0.09709918f, -0.05623119f, -0.00678420f, -0.04906527f, -0.20766199f, 0.13279346f, 0.07016582f, 0.02278245f, 
    0.15651065f, -0.01064335f, 0.11283000f, 0.18424584f, -0.02005699f, 0.00818928f, 0.07857585f, 0.09654544f, 
    0.03384455f, 0.03139219f, -0.04128602f, 0.03504004f, 0.14695376f, 0.01942335f, -0.12941411f, -0.02370166f, 
    0.00030959f, -0.02946292f, 0.02376251f, 0.11675123f, 0.03238943f, -0.17681135f, -0.19858232f, -0.06914648f, 
    0.03286783f, -0.11473621f, -0.04652975f, -0.04150185f, 0.07631845f, -0.13907860f, 0.04093686f, -0.07761261f, 
    -0.10081498f, 0.03918987f, 0.03574035f, 0.09607427f, -0.02180110f, 0.33023632f, -0.18843347f, 0.16433264f, 
    0.01531054f, -0.16998887f, -0.07743586f, -0.10041033f, 0.09507274f, 0.09247613f, 0.06301665f, -0.05568731f, 
    -0.03352367f, 0.05321851f, 0.02700997f, 0.05677294f, -0.07965083f, -0.17641686f, 0.00707590f, -0.02687638f, 
    -0.04457958f, 0.12398650f, 0.23043716f, -0.01491626f, 0.10259363f, -0.06756244f, 0.01080092f, 0.04137056f, 
    -0.12643851f, 0.02972813f, 0.02935384f, -0.05475146f, 0.04292956f, 0.11933991f, -0.12732545f, 0.05168942f, 
    -0.06055948f, -0.02737529f, -0.01199955f, 0.07313619f, 0.10164861f, 0.36203939f, 0.07124651f, -0.13405278f, 
    -0.14047256f, 0.05717175f, 0.05222538f, 0.12583178f, -0.00806390f, -0.06139359f, -0.01578180f, 0.02296752f, 
    -0.06538915f, 0.12494755f, -0.11088242f, 0.13563202f, 0.02466446f, 0.03983581f, 0.02398730f, -0.04846559f, 
    0.21861036f, 0.12312888f, -0.15829271f, -0.00561877f, -0.29209423f, 0.03146635f, -0.00671134f, 0.04394489f, 
    0.02080453f, 0.01291791f, 0.14434995f, -0.01252829f, 0.05165103f, -0.04637264f, -0.04266440f, 0.04744187f, 
    -0.02146315f, 0.06158500f, 0.05385611f, -0.02342055f, 0.12064844f, 0.18143316f, 0.13526282f, 0.06788070f, 
    0.07798102f, -0.06220794f, -0.12483880f, 0.05566366f, 0.02826028f, -0.03670524f, 0.04191238f, -0.00407941f, 
    0.01531758f, 0.02585301f, -0.05752915f, -0.06677241f, 0.01713991f, -0.00737670f, 0.03818830f, 0.04474629f, 
    -0.01939666f, -0.05117776f, -0.30014038f, 0.25857303f, 0.09270826f, 0.06861133f, 0.10803869f, 0.04009368f, 
    0.04058323f, -0.08190507f, 0.20551269f, 0.04149630f, -0.02704735f, 0.09644589f, 0.17740741f, -0.06721696f, 
    0.14713706f, -0.08440902f, 0.18570097f, 0.03320270f, -0.22867195f, 0.07757020f, -0.12339684f, -0.08028109f, 
    0.09556042f, 0.02582673f, -0.15537298f, -0.02665969f, -0.00616775f, 0.10965337f, 0.04059502f, 0.00497426f, 
    0.10572199f, 0.03320967f, 0.09058255f, -0.02572580f, -0.04949906f, 0.09569666f, 0.08228327f, 0.06286036f, 
    0.28639784f, 0.13367768f, 0.10062437f, 0.11145774f, -0.06737532f, -0.21923672f, -0.16003016f, 0.16218475f, 
    0.04177834f, -0.00196141f, -0.00951347f, -0.08524958f, 0.00257940f, -0.05078800f, 0.09233349f, 0.04813024f, 
    0.10841424f, 0.04871992f, -0.10335993f, 0.04579965f, 0.15257645f, 0.20612279f, -0.08012269f, 0.04927298f, 
    -0.04257169f, -0.00581421f, 0.05181681f, 0.01652710f, 0.09688648f, -0.04550458f, -0.00958117f, 0.04764124f, 
    0.06674301f, 0.01018992f, 0.10289511f, 0.05803229f, -0.03440990f, -0.00627716f, 0.01234059f, 0.05818899f, 
    -0.29579610f, 0.18413332f, 0.11679992f, -0.13875881f, 0.28897282f, 0.11623698f, 0.03372800f, 0.01508967f, 
    0.05921867f, 0.00607648f, -0.16045152f, 0.12211668f, -0.08055366f, 0.10072832f, 0.01011741f, 0.05863939f, 
    -0.01366033f, 0.05638899f, -0.10784601f, -0.05880748f, -0.16992326f, -0.27278322f, -0.44661206f, -0.15691002f, 
    -0.04972747f, 0.13672566f, 0.06864329f, -0.11768326f, -0.08125932f, 0.07331182f, 0.02895989f, -0.03923988f, 
    0.04446583f, 0.06981460f, 0.03069309f, -0.09766840f, 0.02990402f, 0.04854736f, -0.00820710f, -0.03133820f, 
    0.14639033f, 0.37885058f, -0.13594045f, 0.05337725f, -0.01236743f, -0.10337073f, -0.11664055f, -0.02291743f, 
    -0.03926295f, -0.08885676f, 0.04338799f, 0.01344428f, 0.14653407f, -0.10642200f, -0.03164563f, 0.00619808f, 
    0.02793642f, -0.07388775f, 0.00655964f, 0.01020124f, 0.08686993f, 0.15503225f, 0.31091604f, -0.02478612f, 
    -0.04653854f, -0.12456317f, -0.05271009f, 0.12940690f, -0.17430779f, -0.03400092f, -0.01912478f, -0.00688915f, 
    0.13514495f, 0.03579554f, 0.12402976f, 0.00591195f, 0.08129878f, 0.09274547f, 0.01239122f, 0.00742805f, 
    -0.23395804f, -0.02231424f, 0.02955324f, -0.01751774f, 0.03718343f, -0.13682562f, -0.02244048f, -0.00548796f, 
    0.06415161f, 0.01110615f, -0.15729742f, 0.04055210f, 0.03035140f, -0.09420883f, -0.00777992f, -0.04052524f, 
    0.12159251f, -0.10430631f, 0.06179269f, 0.02332732f, 0.31689823f, 0.07876834f, 0.06840660f, 0.11530481f, 
    0.11576445f, -0.00474219f, 0.06267964f, -0.05016995f, -0.14439575f, 0.13382591f, 0.04746313f, -0.03880463f, 
    0.03640021f, -0.12425747f, 0.03798493f, 0.04004427f, 0.18165307f, 0.02150238f, 0.08356167f, 0.03414745f, 
    0.03264335f, -0.23012064f, 0.19717400f, -0.01231239f, 0.13854319f, 0.06135941f, 0.05370801f, 0.00178701f, 
    0.09608360f, -0.02331021f, -0.01069077f, -0.01392773f, -0.00748417f, 0.13771692f, 0.06702957f, -0.04829811f, 
    0.06358548f, -0.01425301f, 0.06580955f, -0.01981952f, 0.67694819f, 0.26021263f, 0.30163443f, 0.03910597f, 
    0.05790686f, 0.06672437f, 0.05991819f, -0.02368153f, 0.14207175f, 0.08226974f, -0.07050061f, -0.07396305f, 
    0.01334869f, 0.12780030f, -0.05100041f, -0.05927105f, 0.16145344f, 0.09020332f, 0.03681906f, 0.08140040f, 
    0.06881390f, 0.14579646f, 0.01328078f, 0.17572886f, -0.12924844f, 0.00492863f, 0.03223406f, 0.02694523f, 
    -0.00621882f, 0.02261242f, 0.10703041f, 0.07882236f, -0.11297165f, -0.11317635f, 0.04200488f, 0.10794961f, 
    -0.05351725f, 0.14037742f, 0.07073665f, 0.11559971f, -0.17885932f, -0.01337833f, -0.02896279f, 0.17393990f, 
    0.06836251f, 0.08340544f, 0.06052981f, -0.00550915f, -0.13626637f, 0.11095104f, 0.00001490f, -0.04723759f, 
    0.11636369f, -0.16543998f, 0.05878228f, -0.08834691f, 0.05564022f, 0.27199432f, 0.03694566f, 0.13742501f, 
    -0.03277503f, 0.09189638f, -0.20199347f, 0.06196821f, -0.06113721f, -0.19379272f, 0.06867212f, -0.10880876f, 
    0.06830466f, -0.05145422f, -0.14533824f, -0.00070618f, -0.00927145f, 0.05811650f, -0.05629988f, 0.04894137f, 
    -0.05687268f, 0.18265666f, -0.26288787f, 0.10844329f, -0.14194910f, -0.03800632f, -0.11153391f, 0.26337492f, 
    0.11320998f, 0.04785454f, 0.03481829f, 0.03137716f, 0.11056913f, 0.03057486f, -0.07068136f, -0.11002452f, 
    -0.07432456f, 0.04921115f, 0.04341775f, 0.10322907f, 0.02721484f, 0.11490627f, 0.16935271f, 0.00871687f, 
    0.25320929f, -0.17873760f, -0.08445125f, 0.08420473f, -0.06910880f, -0.12739612f, -0.01251877f, 0.18310109f, 
    -0.01601442f, 0.11231616f, -0.04812790f, 0.07309598f, 0.11264807f, -0.04991101f, -0.02286308f, 0.04696101f, 
    -0.06411236f, -0.01627262f, 0.00662512f, -0.08125148f, -0.10764267f, -0.00209914f, 0.01570786f, -0.05349638f, 
    0.14927913f, 0.00707175f, 0.11600233f, 0.01885403f, -0.02289940f, -0.10497963f, -0.17690019f, -0.01541194f, 
    -0.08096211f, -0.09907455f, 0.00923570f, -0.09401197f, -0.02456099f, -0.08612639f, -0.00445105f, -0.06403509f, 
    -0.13577344f, 0.05202060f, 0.14068915f, -0.07297729f, 0.11116842f, -0.01592374f, -0.04434472f, -0.05325584f, 
    -0.05705607f, -0.04666512f, 0.04962421f, 0.04292876f, -0.07528479f, 0.09455112f, 0.00832973f, -0.04209203f, 
    -0.05462960f, 0.11072057f, 0.08061165f, 0.00392853f, -0.01113242f, -0.01207825f, 0.09494196f, 0.03947883f, 
    -0.00842259f, 0.01178547f, -0.00537731f, -0.13022840f, 0.04385099f, -0.03465669f, -0.00633022f, 0.00096269f, 
    -0.11621778f, 0.00302992f, 0.01298119f, 0.06010462f, -0.02103765f, -0.02554730f, -0.15857682f, 0.02993904f, 
    0.42159641f, -0.15579149f, 0.10361231f, 0.11544866f, 0.02035080f, -0.04157510f, 0.11579417f, 0.02454563f, 
    -0.01614318f, -0.00898903f, -0.02176232f, -0.02809641f, 0.12286715f, 0.04057825f, 0.01486533f, 0.02174571f, 
    0.07678827f, -0.10543397f, 0.13937238f, -0.16979370f, -0.30687076f, 0.13865975f, -0.00762824f, 0.08697819f, 
    0.09647161f, -0.01484590f, -0.12168019f, -0.00144443f, 0.09724168f, -0.17008910f, -0.04978259f, -0.00335301f, 
    0.10115533f, -0.06574833f, -0.01955565f, -0.00979631f, 0.02866005f, -0.02503763f, -0.09043999f, 0.00189662f, 
    -0.05756356f, -0.05369653f, 0.12179855f, -0.02616730f, 0.00075183f, -0.04258307f, 0.06685919f, -0.09724750f, 
    -0.05017275f, 0.04195700f, 0.06327395f, -0.01729193f, -0.02922977f, -0.00251681f, 0.08012142f, 0.09473532f, 
    -0.10060570f, 0.28816935f, 0.19632630f, 0.07600277f, 0.01659245f, -0.12835677f, -0.04175589f, -0.05454595f, 
    0.05551462f, -0.05585291f, 0.02098688f, -0.07596962f, -0.10355590f, -0.00719877f, -0.02625339f, 0.10177518f, 
    -0.04770093f, -0.02913204f, 0.05627349f, -0.04019045f, -0.08989422f, 0.01371294f, 0.05584707f, -0.04538307f, 
    0.04663502f, -0.03876902f, 0.01752766f, 0.02405274f, -0.05488027f, 0.02901736f, -0.05226989f, -0.03781557f, 
    0.01386640f, 0.02227247f, 0.02439762f, 0.03197117f, -0.01069353f, -0.03944415f, 0.03802614f, 0.00682369f, 
    -0.05818387f, -0.01455937f, 0.00838346f, -0.02496725f, 0.02555882f, 0.04443898f, -0.01842440f, 0.01863295f, 
    0.00831425f, -0.02490741f, -0.05407843f, -0.02753074f, -0.04645227f, 0.01361832f, 0.05159001f, 0.00451734f, 
    0.02151218f, 0.04792834f, 0.01180413f, 0.02373539f, -0.05969074f, 0.01974105f, -0.00494940f, -0.04689290f, 
    0.00295668f, -0.01791088f, -0.00999437f, -0.01275478f, 0.04139608f, 0.02698977f, 0.01200108f, 0.01949050f, 
    -0.00314367f, 0.02900148f, -0.05921023f, 0.00761850f, 0.01659572f, 0.01558389f, -0.00731817f, 0.01806703f, 
    -0.02970064f, -0.06204227f, 0.03675814f, -0.05794824f, -0.05005755f, -0.02550147f, 0.04594271f, -0.00342428f, 
    0.04226684f, -0.00791146f, -0.02364624f, 0.03694341f, -0.02769568f, -0.00561054f, 0.00417427f, 0.00894906f, 
    0.04875338f, 0.00169646f, -0.04060510f, 0.01942371f, 0.03874505f, -0.03071969f, -0.01640627f, 0.03569891f, 
    0.04948392f, -0.05260839f, -0.00972211f, 0.04585730f, 0.02347649f, 0.04888925f, 0.02490473f, 0.03815681f, 
    -0.03348978f, -0.01362796f, 0.01500080f, -0.04879502f, -0.03442860f, 0.03759865f, 0.02326160f, -0.00171935f, 
    -0.05681038f, 0.05081836f, 0.03846094f, -0.04940042f, -0.01289693f, 0.03144400f, -0.00155248f, -0.03290398f, 
    -0.03049906f, 0.05180996f, -0.02260619f, -0.04909098f, 0.02241750f, 0.04337306f, -0.00818773f, -0.05462934f, 
    0.00526353f, -0.05178842f, -0.01606246f, 0.01116800f, 0.03689357f, 0.04330036f, 0.02977145f, -0.00288094f, 
    -0.01871896f, 0.04718396f, -0.05620361f, -0.04430778f, 0.01006493f, -0.04948127f, 0.00647118f, -0.03211394f, 
    0.01576257f, -0.03180294f, -0.00254970f, -0.05133608f, 0.02283715f, -0.01640254f, 0.01028382f, -0.02439229f, 
    0.03168268f, -0.05624094f, -0.05320830f, 0.02334346f, -0.01110126f, -0.00829997f, -0.01787214f, -0.05700877f, 
    0.01567508f, 0.04503314f, -0.00049217f, -0.00436723f, -0.05784293f, -0.00672736f, -0.00345820f, -0.01251684f, 
    -0.03850836f, -0.00154569f, -0.05260037f, -0.04314816f, -0.03537539f, -0.00825413f, -0.05338782f, -0.05153168f, 
    0.04856783f, -0.05871219f, -0.03498775f, 0.00559072f, -0.04153996f, -0.04620836f, -0.04835608f, -0.05096703f, 
    -0.01267031f, -0.04595812f, 0.01958203f, -0.05822057f, -0.01274696f, -0.00842737f, 0.00965956f, 0.01561233f, 
    0.03917136f, 0.04694049f, -0.03444641f, 0.03524718f, 0.03437316f, -0.05266324f, -0.03580360f, -0.04719362f, 
    -0.04562304f, 0.00351938f, 0.01715366f, -0.00834573f, 0.03842720f, 0.01393662f, 0.01450499f, 0.02485232f, 
    -0.04832406f, 0.04940320f, 0.05137849f, -0.01976426f, 0.03884140f, -0.05059579f, -0.01965316f, -0.04436064f, 
    -0.01488816f, 0.04614129f, -0.01657944f, -0.01194143f, -0.04940836f, 0.03405943f, -0.02842220f, 0.03565564f, 
    -0.02794989f, 0.03643969f, 0.04191608f, -0.02506053f, 0.02641583f, 0.00955592f, -0.00576168f, -0.01715643f, 
    -0.01341475f, -0.01293254f, 0.02190396f, -0.05732319f, -0.03151104f, -0.01356207f, -0.04303511f, -0.00366282f, 
    0.02894732f, 0.04855668f, -0.00460323f, 0.02190063f, 0.02835170f, -0.00461262f, -0.01112905f, -0.03443141f, 
    -0.00855678f, -0.01913663f, 0.04054945f, -0.00178672f, 0.00214887f, 0.02201913f, -0.02117284f, -0.04083907f, 
    0.04852883f, 0.03748305f, 0.03821088f, -0.00753353f, -0.02748589f, 0.01531365f, -0.02627534f, -0.05930822f, 
    -0.02963313f, -0.03746441f, 0.04674439f, 0.02403388f, -0.04442405f, 0.00227325f, 0.01641554f, -0.02926583f, 
    -0.03965074f, 0.00307803f, 0.01983188f, -0.00708891f, -0.03175304f, 0.00145560f, -0.00849573f, -0.02630296f, 
    0.02818898f, 0.02564237f, -0.00555051f, -0.02845539f, -0.05390557f, 0.01476739f, -0.02125775f, -0.02888397f, 
    0.03127408f, 0.00883448f, -0.03409266f, 0.04076938f, -0.05661860f, -0.05056365f, -0.00985817f, -0.04403260f, 
    0.04210273f, -0.02231680f, 0.03952813f, 0.02524695f, -0.02880669f, 0.03900794f, -0.05515294f, -0.00899981f, 
    -0.00136404f, -0.01446965f, -0.03232456f, 0.00031089f, 0.00680368f, -0.02817391f, -0.05015753f, -0.01753880f, 
    -0.00982783f, -0.05153632f, -0.02471283f, -0.06004497f, -0.00055287f, -0.01826502f, -0.00962254f, -0.05595777f, 
    0.00162677f, -0.00798391f, -0.05871516f, -0.05284614f, -0.02803862f, -0.02430133f, -0.03037897f, -0.05816377f, 
    -0.03912197f, -0.03097449f, -0.00964005f, -0.00992662f, -0.01282457f, 0.02052032f, -0.03668310f, 0.03719245f, 
    0.32263413f, 0.20365182f, -0.27706316f, 0.05772738f, 0.18408430f, 0.14545935f, 0.09065925f, 0.06535639f, 
    -0.00294997f, -0.07460755f, 0.01400623f, 0.07766613f, 0.08550221f, -0.00164978f, -0.00588278f, -0.14027265f, 
    0.03487514f, -0.03794872f, 0.04157137f, 0.03075261f, -0.01948310f, 0.19990449f, -0.07889704f, -0.26360962f, 
    0.15289359f, 0.06228625f, -0.06037173f, -0.04801684f, -0.01520410f, -0.01957127f, 0.06870629f, 0.07504334f, 
    0.01779110f, -0.04889730f, 0.00322832f, -0.05190063f, 0.15503909f, 0.04907206f, 0.06127796f, 0.02146668f, 
    0.05845536f, -0.48559996f, 0.07243274f, 0.06252289f, 0.23753722f, -0.16984624f, 0.05002974f, -0.03440151f, 
    0.02306969f, 0.01055866f, -0.01824861f, -0.03148155f, -0.00733382f, -0.00889515f, 0.06472349f, 0.02323200f, 
    -0.04596274f, 0.01654562f, 0.00006353f, 0.14596890f, 0.32219526f, 0.26567912f, -0.20309392f, -0.00786829f, 
    -0.05281322f, 0.02776255f, 0.02040884f, -0.09910664f, 0.10667437f, -0.00051087f, 0.09867677f, -0.07394494f, 
    0.05018955f, 0.01613486f, -0.08715272f, 0.04429656f, 0.00512730f, 0.01726243f, 0.07973264f, 0.05489057f, 
    -0.08964884f, 0.31845278f, -0.01571776f, -0.32224184f, 0.23627871f, -0.04091223f, -0.08883958f, -0.08818612f, 
    -0.06411203f, -0.11497063f, 0.09124069f, 0.05043839f, -0.11356334f, 0.00519431f, -0.04837159f, 0.04579947f, 
    -0.00297945f, 0.09799517f, 0.08617057f, 0.05386972f, -0.32724094f, 0.17207433f, -0.14022800f, -0.10564154f, 
    -0.12319202f, 0.17817542f, 0.01639572f, -0.10566936f, -0.04028257f, -0.01965174f, 0.07165153f, 0.02862571f, 
    0.04637007f, 0.02840728f, 0.08103225f, 0.08114094f, -0.05687274f, 0.20287405f, 0.01990383f, 0.01352812f, 
    0.35144836f, -0.16058742f, 0.03640023f, -0.12760442f, -0.34419429f, -0.01578191f, -0.06011917f, -0.03748264f, 
    -0.07306032f, -0.02570269f, -0.04436124f, -0.07950050f, -0.08383939f, 0.02153320f, -0.04333383f, -0.05789196f, 
    -0.10684445f, 0.06775644f, -0.04133103f, -0.03634072f, -0.17240909f, 0.05582217f, 0.03500855f, -0.13624188f, 
    0.02179028f, -0.10883987f, -0.10269700f, -0.04626201f, -0.00237875f, -0.10519781f, 0.02178925f, -0.01124393f, 
    -0.07338557f, 0.02051502f, 0.13035749f, -0.11885904f, 0.05165690f, 0.02674408f, 0.11778057f, 0.00058157f, 
    0.17416838f, 0.24054219f, -0.27001795f, 0.15494460f, -0.14744061f, 0.06991160f, 0.04769736f, 0.26456192f, 
    0.14488806f, 0.04121120f, 0.08827755f, 0.06028062f, -0.02698318f, -0.05625314f, -0.05924125f, 0.00366375f, 
    -0.11682582f, -0.02667031f, 0.06003111f, -0.06599092f, -0.29526454f, 0.29320744f, 0.04298441f, -0.06419272f, 
    0.33470505f, 0.03733764f, -0.03614914f, -0.03440336f, 0.08622610f, -0.04152487f, 0.02372136f, -0.03667808f, 
    0.11607926f, 0.00391317f, 0.04837143f, -0.02216832f, 0.07179647f, -0.01981619f, 0.10759410f, -0.01319642f, 
    0.19744438f, 0.06072621f, 0.32145613f, -0.02811744f, 0.18594013f, -0.05755005f, 0.01752953f, -0.01828837f, 
    0.05447245f, -0.10709101f, 0.08273671f, -0.11664306f, 0.04492929f, 0.06577950f, 0.01750286f, -0.02066378f, 
    -0.00205813f, -0.08027949f, -0.03480872f, 0.04062989f, 0.01627475f, 0.05145330f, 0.03653532f, -0.00748468f, 
    -0.11843982f, -0.05191105f, -0.00317782f, -0.07894241f, 0.03558148f, -0.14551732f, 0.06039871f, 0.03296795f, 
    -0.06267459f, 0.12778573f, 0.06333471f, -0.05468545f, 0.03400596f, -0.04883245f, 0.02344104f, -0.01230326f, 
    -0.13065082f, 0.11282501f, 0.02943383f, 0.02335560f, 0.23894267f, 0.09635792f, -0.02861312f, -0.02953592f, 
    -0.02136117f, -0.00433601f, -0.11478033f, -0.05147396f, -0.06034604f, 0.11427547f, 0.07673042f, 0.02368098f, 
    -0.10248445f, -0.01216704f, 0.03101233f, -0.09824732f, -0.01407471f, 0.26543573f, -0.18276292f, 0.30720049f, 
    0.28964281f, 0.10349592f, -0.00073562f, -0.04373013f, 0.05942239f, 0.01043934f, 0.01603877f, 0.00944941f, 
    0.06838436f, -0.04438394f, 0.06042131f, -0.09205814f, 0.04409692f, 0.02191858f, 0.02420239f, -0.07276434f, 
    -0.09386480f, 0.25629655f, -0.10126863f, -0.17529224f, -0.18446389f, -0.00907505f, -0.11055552f, -0.08786060f, 
    -0.06763500f, -0.11112487f, 0.02590442f, 0.01995540f, 0.08303653f, -0.05276009f, 0.13015933f, 0.03256406f, 
    -0.03570184f, 0.18912603f, 0.04943166f, -0.00174520f, 0.17435960f, 0.11710475f, 0.22107305f, -0.12597758f, 
    -0.04941992f, -0.07830997f, 0.05007171f, 0.02725209f, -0.17360002f, -0.12835728f, 0.07593982f, -0.07005434f, 
    0.15946019f, 0.02421093f, 0.04602702f, 0.02598119f, 0.00718693f, -0.00903145f, -0.02717553f, 0.03773771f, 
    0.04450508f, -0.03691517f, 0.02142435f, -0.01339282f, -0.03397371f, -0.00963488f, -0.04384708f, -0.00188886f, 
    0.01131164f, -0.04850361f, -0.05168903f, 0.02240628f, 0.02323548f, -0.02842555f, 0.04611990f, -0.06880854f, 
    0.00887365f, 0.00508755f, 0.02537318f, 0.01093479f, -0.01058133f, -0.02820593f, 0.02488291f, 0.05769960f, 
    0.02069215f, -0.00050252f, -0.01973966f, -0.01761011f, 0.03500585f, -0.04622051f, 0.01584388f, -0.03917883f, 
    0.00799329f, -0.00920818f, -0.02102029f, 0.02207405f, 0.04398353f, 0.04554618f, -0.02246064f, 0.00038978f, 
    -0.07422200f, 0.00699453f, 0.02797609f, -0.03993222f, -0.05454852f, -0.06476825f, -0.05360224f, -0.02085410f, 
    0.02646714f, -0.06009044f, 0.02881562f, -0.06287033f, 0.01291280f, 0.03739919f, -0.01630409f, -0.02673822f, 
    0.02510674f, -0.01111791f, 0.02741793f, 0.00411179f, 0.03896847f, -0.03970941f, -0.03959955f, -0.02112592f, 
    0.00901993f, 0.04089342f, -0.04221446f, 0.02167909f, -0.04741699f, -0.07487731f, -0.00092271f, -0.00365562f, 
    -0.01576270f, -0.03203787f, -0.02550950f, 0.00940009f, -0.06021883f, -0.01047146f, 0.00138201f, -0.03918134f, 
    -0.04839584f, -0.00027742f, -0.03345439f, -0.00032731f, 0.02827504f, 0.04188124f, 0.03375768f, 0.02529399f, 
    -0.06607287f, -0.02559160f, 0.01423059f, 0.01972472f, 0.00039674f, -0.05131174f, -0.00376685f, 0.04856296f, 
    -0.01631627f, -0.02680013f, 0.03149433f, -0.01043043f, -0.01463776f, -0.02444489f, -0.02337524f, -0.05920307f, 
    -0.02566182f, 0.00772743f, 0.04730032f, -0.01802049f, 0.00022984f, -0.06210200f, 0.01256083f, -0.04030407f, 
    0.04600075f, -0.00316730f, -0.00434216f, -0.04082729f, -0.02491086f, -0.00464280f, 0.03197161f, 0.05701013f, 
    -0.05497399f, -0.05109152f, 0.02751298f, -0.05964918f, -0.01660198f, 0.05551823f, 0.02463918f, 0.05403857f, 
    -0.05065916f, -0.01389820f, -0.00113408f, 0.04633814f, 0.04894980f, -0.05280795f, -0.05869516f, 0.00613681f, 
    0.04755846f, 0.01615314f, 0.02671379f, 0.01665286f, 0.00155813f, -0.02747937f, -0.00112624f, -0.00050034f, 
    0.03185285f, 0.01804557f, -0.04950158f, 0.02954869f, -0.00561218f, -0.02327323f, -0.03863684f, -0.05514269f, 
    -0.04553917f, 0.00946400f, -0.00145451f, -0.02485510f, 0.01810113f, 0.04624540f, -0.03550791f, 0.00866881f, 
    -0.03776733f, -0.05519372f, 0.00236743f, -0.01951898f, -0.06419459f, 0.04560164f, -0.01927260f, -0.09216836f, 
    -0.04592287f, 0.00542111f, -0.06010723f, 0.01576590f, -0.03889298f, -0.05840996f, -0.03001743f, -0.07385063f, 
    -0.03940110f, -0.00785275f, 0.00641724f, -0.02637129f, -0.04938085f, 0.01307964f, -0.02567573f, -0.00204036f, 
    -0.01207082f, -0.06275181f, -0.04569777f, 0.02608617f, -0.07307167f, 0.03838232f, 0.03689613f, -0.00943858f, 
    -0.05029987f, -0.03328188f, 0.04534860f, -0.02979368f, -0.04369573f, -0.05055093f, 0.01604117f, 0.00557497f, 
    -0.03820268f, -0.02438584f, -0.05941544f, -0.03756436f, 0.02356426f, 0.07543799f, -0.05020823f, -0.00513028f, 
    -0.02444314f, 0.01299125f, 0.02874516f, -0.01151536f, -0.02241723f, -0.01947919f, -0.02964255f, 0.03808676f, 
    -0.02410519f, -0.08407444f, 0.03739359f, 0.09261142f, 0.03703474f, -0.01308274f, -0.07252557f, 0.03389993f, 
    0.01115642f, 0.00444007f, 0.02060667f, -0.03235026f, -0.00245099f, -0.02401063f, -0.05372825f, 0.03315233f, 
    -0.03923396f, 0.02366449f, -0.06818054f, -0.00313341f, 0.02491767f, 0.02499230f, -0.03402528f, -0.00895327f, 
    -0.07257433f, -0.04371184f, -0.07920589f, -0.03477384f, 0.02906624f, 0.04628377f, -0.01794876f, -0.00897455f, 
    0.02937633f, -0.05486186f, 0.00511207f, 0.02344561f, 0.01481174f, 0.00612839f, -0.01896805f, -0.04803796f, 
    -0.05244807f, -0.03302542f, -0.06847955f, -0.02811662f, -0.00758239f, -0.05908409f, 0.01915911f, -0.06008327f, 
    -0.06095941f, -0.06305269f, -0.06985012f, -0.03271317f, -0.07047434f, 0.02581123f, 0.03676650f, 0.04410608f, 
    -0.00489998f, -0.02698134f, -0.02372120f, 0.00908264f, -0.06380533f, -0.04891806f, -0.03522265f, -0.08039438f, 
    0.03723628f, -0.03018462f, 0.00257490f, -0.04138172f, -0.02349651f, 0.04769276f, 0.01210591f, -0.00922188f, 
    -0.05808076f, -0.04178800f, 0.01805485f, -0.02729759f, -0.03047694f, 0.03406367f, -0.06021550f, -0.02165092f, 
    0.03734369f, -0.02364656f, 0.00913037f, 0.01756836f, -0.03625215f, -0.06251244f, 0.01012848f, 0.01824892f, 
    -0.00397110f, 0.05042361f, 0.00036948f, -0.03143894f, 0.02926650f, -0.00181598f, -0.03666740f, -0.03962377f, 
    0.04352501f, 0.03330196f, -0.04057851f, 0.03616004f, -0.01523667f, -0.04789730f, -0.00163928f, -0.02378483f, 
    0.25838518f, 0.40266827f, 0.27244383f, -0.05854406f, -0.02268376f, 0.18365170f, -0.05355367f, 0.04250685f, 
    0.01489593f, 0.04782395f, 0.03586114f, 0.03144277f, -0.03852037f, 0.01163097f, -0.11144868f, 0.01613791f, 
    0.05495383f, 0.03626728f, -0.04564242f, -0.11463863f, -0.10398290f, -0.25292251f, -0.17545190f, -0.09531477f, 
    -0.26955086f, 0.00868383f, 0.06380125f, 0.06552635f, 0.10949638f, 0.00569235f, -0.03189876f, 0.02550079f, 
    -0.04324134f, 0.04806241f, -0.01930065f, -0.16354132f, -0.06785696f, -0.07540925f, 0.09647730f, -0.06180475f, 
    0.36587307f, 0.19341353f, 0.08952380f, 0.01838510f, 0.13405031f, -0.06970291f, 0.20259616f, -0.14633383f, 
    -0.19864869f, 0.17775089f, 0.08359268f, 0.12729929f, 0.04546179f, 0.09705154f, 0.00163441f, 0.04123439f, 
    0.01083531f, -0.01920291f, -0.13149855f, -0.02368088f, -0.31931362f, -0.24965264f, -0.07215272f, -0.05828939f, 
    0.15374783f, 0.10400576f, -0.00674199f, -0.00291820f, -0.04215516f, 0.09289028f, 0.05757569f, 0.07713705f, 
    -0.05422542f, -0.01971960f, 0.00100084f, 0.13289019f, -0.11246875f, -0.02969176f, -0.00359194f, -0.11885694f, 
    0.16522591f, -0.32915017f, -0.06163231f, -0.11938386f, -0.13822259f, -0.02736858f, 0.03057431f, 0.00115094f, 
    0.13220797f, 0.01450184f, -0.12390710f, -0.02904777f, 0.11088978f, 0.05251393f, 0.02257350f, 0.10545136f, 
    0.03609544f, 0.02948941f, 0.03330077f, 0.02456887f, -0.03469237f, -0.26476002f, 0.04150520f, -0.13158271f, 
    -0.31942806f, 0.06017682f, -0.05676624f, -0.03118885f, -0.01940473f, 0.03293660f, 0.09301154f, -0.02259862f, 
    0.04807112f, 0.10542796f, -0.07537045f, -0.02104314f, -0.13576573f, -0.09697743f, 0.06835187f, -0.09702516f, 
    -0.02625520f, -0.48917580f, 0.05164830f, -0.23251016f, -0.06084522f, 0.12217379f, -0.04223898f, -0.01318673f, 
    0.08689746f, 0.10743175f, -0.01242497f, 0.06583852f, -0.14882074f, 0.06582849f, 0.03008128f, -0.02640113f, 
    0.00500802f, 0.02054168f, 0.00082713f, 0.07776544f, -0.20214245f, -0.05881343f, 0.17703317f, -0.13486874f, 
    -0.17779438f, -0.03232888f, -0.11445267f, -0.13000275f, 0.01572401f, -0.02657500f, 0.14470303f, 0.02238678f, 
    -0.02934674f, 0.06710470f, 0.08961774f, 0.03352742f, -0.05916724f, -0.17767929f, -0.02669724f, -0.01148100f, 
    0.07714159f, 0.04408937f, 0.08262375f, -0.14390448f, 0.01805239f, 0.19318983f, -0.00737647f, 0.06399596f, 
    0.01466254f, -0.10901004f, -0.00641116f, 0.06288558f, 0.00620236f, -0.00308774f, -0.17693050f, 0.01623038f, 
    0.06080488f, 0.07722760f, 0.00341545f, -0.04829140f, -0.18994641f, 0.26454031f, 0.31002021f, 0.01633159f, 
    0.00741769f, 0.10887020f, 0.03161513f, 0.08938155f, -0.08254081f, 0.19059481f, -0.02447819f, 0.01238452f, 
    0.05940814f, -0.02936093f, 0.09609429f, 0.01475043f, 0.04264361f, 0.05140548f, 0.00226046f, 0.01928183f, 
    0.37573484f, -0.16928366f, 0.34870222f, -0.09165774f, -0.02969499f, -0.12446507f, 0.15359259f, 0.01591662f, 
    0.07359853f, 0.11229192f, -0.00375364f, -0.14614163f, -0.06844471f, 0.02465928f, -0.03098586f, 0.00701225f, 
    0.01885304f, 0.03476921f, -0.07201006f, 0.02573164f, -0.07575379f, -0.04889210f, 0.10338776f, -0.24792348f, 
    0.17870878f, -0.03685164f, -0.13489306f, 0.08582206f, -0.09086378f, -0.01684027f, -0.01435029f, -0.02092927f, 
    0.02567431f, -0.06483380f, 0.07133010f, -0.01457254f, 0.14435419f, -0.07909330f, 0.07889343f, -0.00246832f, 
    -0.15464607f, -0.03599237f, -0.14178042f, 0.00586641f, 0.03642648f, -0.06089760f, -0.00932618f, -0.05362170f, 
    -0.00050109f, -0.03509069f, 0.01278695f, 0.06512667f, 0.01941811f, -0.03803135f, -0.07990889f, 0.09884325f, 
    -0.04370323f, 0.08361627f, 0.08175497f, 0.02542833f, 0.04272241f, 0.32634723f, 0.24814413f, -0.07739182f, 
    0.17995739f, 0.07194366f, 0.07542834f, 0.00371280f, -0.02058068f, 0.14027464f, -0.10957477f, 0.09095612f, 
    0.02763336f, 0.10007621f, 0.04385262f, 0.00814297f, 0.00700277f, -0.04159209f, 0.01578032f, 0.03011129f, 
    -0.25464451f, -0.26534721f, -0.06639247f, -0.27073777f, -0.09504882f, 0.12040775f, -0.07988479f, 0.04904087f, 
    0.11110663f, 0.04614572f, 0.08970007f, -0.09502731f, 0.02021928f, 0.05696078f, 0.00208915f, -0.00280716f, 
    0.07806765f, -0.14437021f, -0.08909126f, -0.03652703f, 0.43341029f, 0.04239973f, 0.09504669f, 0.09536561f, 
    -0.15460511f, 0.05456618f, 0.05471851f, 0.06560166f, 0.18643093f, 0.17043896f, -0.00387812f, -0.00082987f, 
    0.04824818f, -0.00928890f, 0.06545946f, 0.01897516f, -0.01375528f, 0.09205832f, 0.17024578f, 0.06589327f, 
    0.00777389f, -0.02208143f, 0.04355240f, 0.02159169f, -0.04564562f, -0.00039531f, 0.01740032f, -0.05208475f, 
    -0.05189268f, 0.01933615f, -0.06195953f, -0.03127321f, 0.01608687f, -0.04646233f, 0.01493485f, 0.01183938f, 
    0.01465675f, 0.03676878f, 0.04527373f, 0.04756746f, -0.00254647f, 0.04779959f, -0.00065446f, -0.05246438f, 
    -0.03011585f, -0.03118406f, -0.03776455f, 0.02211348f, -0.03356606f, -0.00362395f, 0.04454555f, 0.02635387f, 
    -0.00444230f, 0.03073271f, 0.03386923f, 0.01075564f, 0.02498433f, 0.04931699f, -0.02732496f, -0.01200882f, 
    0.04192014f, 0.03571502f, -0.00285811f, 0.00815811f, 0.02771766f, -0.04654080f, -0.03329185f, -0.05237776f, 
    -0.04127215f, -0.00320857f, -0.04976906f, 0.00230113f, 0.03872973f, 0.00499581f, 0.02014687f, -0.03230118f, 
    0.00269825f, -0.05839833f, -0.04883287f, 0.01220080f, 0.00602488f, 0.04374028f, 0.01267864f, 0.01217862f, 
    -0.00827590f, -0.00741900f, -0.02923248f, -0.00823739f, -0.00164637f, 0.03619419f, -0.00373997f, 0.01897057f, 
    -0.04358183f, 0.01874143f, -0.04077880f, 0.03406050f, 0.00836481f, 0.01839462f, -0.00812843f, -0.03888037f, 
    0.02715079f, -0.06085683f, -0.02101027f, 0.01795483f, -0.04760909f, 0.04939891f, -0.01552099f, -0.04656436f, 
    0.02592792f, -0.00028242f, -0.03392627f, 0.04599169f, -0.03125627f, -0.04807913f, -0.02862439f, -0.03728056f, 
    0.04392346f, 0.02426242f, -0.05284889f, 0.00819783f, 0.03778315f, -0.03319542f, 0.02458092f, 0.01630937f, 
    -0.01503946f, 0.00439824f, -0.00784503f, 0.00279267f, -0.02365100f, -0.02151855f, 0.00207598f, 0.02496611f, 
    -0.02947752f, 0.03497057f, -0.05425289f, 0.03048490f, -0.04547626f, -0.02138801f, -0.02157193f, 0.00629511f, 
    0.00627687f, 0.01031499f, -0.06087834f, -0.00273474f, -0.03509887f, -0.05889110f, 0.04140165f, -0.01954431f, 
    -0.03012288f, -0.01017371f, -0.02719333f, 0.01742055f, 0.02977121f, 0.03117348f, 0.04400814f, 0.03383301f, 
    -0.00095596f, 0.03506566f, 0.03648762f, -0.05285075f, -0.00499555f, -0.00261048f, -0.00523924f, 0.03452955f, 
    -0.04065579f, -0.05001830f, -0.05746562f, -0.00505340f, 0.00856772f, -0.01545721f, 0.01424048f, 0.00105432f, 
    0.00435300f, -0.00825384f, 0.02327237f, 0.01068497f, -0.03301654f, 0.02365446f, 0.03379979f, -0.02190859f, 
    0.04320823f, -0.05579444f, 0.01860201f, -0.00762575f, -0.04443462f, 0.00495364f, -0.00650266f, -0.03020214f, 
    0.01897599f, 0.03160138f, 0.02156346f, 0.04707722f, -0.04382285f, -0.02516942f, -0.04159785f, -0.01344129f, 
    0.03944792f, -0.05771060f, -0.02647877f, 0.01597860f, -0.02674884f, -0.01209265f, -0.02119110f, -0.01823438f, 
    -0.02595042f, -0.04481274f, 0.02839127f, 0.01606608f, 0.00291045f, -0.01899822f, 0.03012596f, 0.03496968f, 
    -0.02528694f, 0.04936416f, -0.03033660f, -0.05602723f, 0.04778738f, -0.04783756f, -0.04910154f, -0.00622508f, 
    -0.05828612f, 0.03414167f, -0.04557170f, 0.04112864f, -0.05699395f, -0.05762343f, 0.03428731f, 0.02434483f, 
    -0.03171724f, -0.00317259f, 0.02320272f, -0.05634240f, 0.01132385f, -0.05612981f, 0.04569543f, -0.02111212f, 
    -0.02672003f, -0.01404932f, -0.04568280f, 0.00600660f, -0.01423795f, -0.03310162f, 0.00585141f, 0.00696745f, 
    -0.01743416f, -0.00565301f, -0.05227552f, -0.03522342f, 0.04353280f, 0.01979040f, 0.04876529f, -0.03894790f, 
    -0.03014253f, 0.00239176f, -0.02501337f, -0.04763197f, 0.01278581f, -0.04770883f, -0.05516097f, 0.03098273f, 
    0.04104309f, -0.03166792f, -0.01591966f, 0.02678641f, -0.01427407f, -0.04441338f, -0.03557504f, 0.03552892f, 
    -0.05872360f, 0.00849895f, 0.02090537f, -0.04693037f, -0.03117176f, -0.02019570f, -0.01466970f, 0.01652651f, 
    0.03140164f, 0.00589932f, -0.02514352f, -0.05648492f, 0.04245359f, -0.03665089f, -0.06035907f, -0.04754689f, 
    -0.04888424f, 0.03596177f, 0.04529731f, 0.00939662f, -0.04520385f, -0.01797587f, -0.01531542f, -0.03759561f, 
    -0.05252481f, -0.02529198f, 0.03022877f, -0.02566230f, -0.02286632f, -0.04632807f, -0.05161071f, -0.00818573f, 
    -0.00863814f, 0.02400140f, -0.03265401f, 0.03581365f, -0.02577771f, -0.03011256f, 0.00290986f, -0.02675528f, 
    0.03377687f, -0.01821003f, -0.01148622f, -0.00929247f, 0.00768683f, 0.00487297f, 0.03723974f, 0.05248535f, 
    -0.02603997f, 0.00724185f, -0.03746055f, 0.02904711f, -0.05648796f, 0.00607299f, 0.04723110f, -0.02021929f, 
    -0.04335031f, 0.02905827f, -0.01538236f, -0.04086681f, -0.02272570f, -0.00218600f, 0.01496652f, 0.02760092f, 
    -0.01257943f, 0.01640815f, -0.05120266f, -0.00970577f, 0.02152463f, -0.02502965f, 0.01471051f, -0.04613917f, 
    0.00573474f, 0.23553590f, -0.15813896f, 0.01730899f, 0.05246819f, 0.07365105f, 0.00180302f, -0.05470988f, 
    0.10405373f, 0.09657538f, 0.01910554f, 0.00305033f, 0.06071822f, 0.00022978f, 0.01778944f, 0.14750858f, 
    0.08167601f, -0.07318060f, -0.05744357f, 0.04260223f, 0.12895335f, 0.31861231f, 0.00093936f, 0.18585651f, 
    0.20347269f, 0.04860643f, -0.12402214f, -0.01402504f, 0.03437036f, 0.13557257f, -0.06506654f, -0.10739853f, 
    0.06365884f, -0.12534295f, 0.07359385f, 0.11561082f, 0.25775570f, 0.06886262f, 0.04250256f, 0.11154269f, 
    -0.15202761f, -0.13838705f, 0.26882333f, -0.18137427f, -0.19404031f, 0.06090146f, 0.09808838f, 0.09341795f, 
    0.16739689f, -0.06118862f, -0.04088469f, -0.23223101f, 0.12033042f, 0.14757210f, -0.06042162f, 0.08502674f, 
    0.04605132f, -0.07993716f, -0.12688409f, -0.00400317f, 0.44005677f, 0.05573975f, 0.35838500f, 0.24456558f, 
    -0.19083187f, -0.08573849f, 0.00240161f, -0.03332090f, 0.01820449f, 0.00493188f, -0.12045010f, 0.05963088f, 
    -0.00119971f, 0.13357192f, 0.04871791f, 0.02380796f, 0.09988952f, 0.11268966f, 0.07341712f, 0.04031856f, 
    -0.03978521f, 0.08035550f, -0.12360934f, 0.05374490f, 0.09479980f, 0.03422718f, -0.07759932f, 0.08117775f, 
    0.03943044f, 0.05386329f, -0.07929846f, 0.13286485f, -0.03879814f, -0.09093548f, 0.15523271f, 0.03215085f, 
    0.02135714f, 0.14496653f, 0.05082589f, 0.05736668f, -0.16646589f, -0.05004587f, 0.14447756f, 0.14439484f, 
    0.12157717f, -0.09578811f, 0.04950234f, -0.07696271f, -0.04123781f, 0.07611022f, -0.16349268f, -0.02215376f, 
    -0.03877232f, 0.00705998f, 0.18265671f, -0.00409562f, 0.02405444f, 0.15397692f, 0.08863303f, 0.16902857f, 
    0.06058752f, 0.06006197f, -0.08964844f, 0.15139316f, 0.23294462f, -0.00472757f, 0.11018312f, -0.06423879f, 
    -0.05939061f, 0.03476553f, 0.09003769f, 0.06954986f, 0.01455890f, -0.00581114f, -0.01577236f, -0.07547381f, 
    0.14994247f, 0.14365210f, -0.15384337f, 0.07934767f, 0.31522340f, -0.02936063f, -0.09547430f, -0.07551815f, 
    0.05965731f, -0.09908324f, 0.11622911f, 0.11449752f, -0.03371640f, 0.03175320f, -0.04915773f, -0.11080069f, 
    0.12108621f, 0.02351216f, -0.04047519f, 0.14800645f, -0.07123516f, 0.09906650f, -0.00621891f, 0.12935419f, 
    -0.17873079f, 0.55992383f, -0.00260611f, 0.14625640f, 0.03034113f, -0.00380467f, 0.14049515f, -0.09105903f, 
    -0.10531475f, 0.00706831f, -0.14881566f, 0.04069412f, 0.01881828f, -0.02964327f, 0.02407367f, 0.00412638f, 
    0.00915915f, -0.14009579f, -0.05654511f, -0.04118659f, 0.20603886f, -0.27319911f, -0.16127151f, 0.03164819f, 
    0.20582770f, 0.04079963f, 0.08850241f, -0.07320419f, 0.09360254f, -0.04572597f, -0.05001251f, 0.03756988f, 
    -0.07038291f, 0.03132352f, -0.08757794f, 0.01771493f, -0.05139137f, -0.11034270f, -0.17532016f, -0.11659528f, 
    -0.18040198f, 0.22560281f, -0.10905147f, -0.21209864f, 0.01912065f, 0.00704888f, -0.00775312f, -0.06299806f, 
    -0.11759134f, -0.08642137f, 0.05115419f, 0.08421776f, 0.04794355f, 0.02218869f, 0.02397766f, -0.07821410f, 
    -0.03528534f, 0.04875078f, 0.06181761f, 0.04189446f, 0.05680169f, -0.05943617f, -0.04965281f, 0.18710822f, 
    -0.09966996f, -0.09482910f, 0.15271701f, -0.11492310f, 0.05378722f, -0.14703465f, 0.11714438f, -0.00247017f, 
    -0.00651821f, 0.17882629f, 0.01175543f, -0.00140667f, -0.03456530f, 0.08575912f, -0.10234658f, -0.13262583f, 
    0.43053424f, 0.03774353f, -0.01615351f, 0.13317603f, -0.06444602f, -0.09931735f, -0.02450510f, -0.01019267f, 
    0.10104134f, 0.10277142f, 0.10312983f, 0.00233453f, 0.18170108f, -0.07213391f, 0.12652823f, 0.04951172f, 
    0.01218398f, -0.15500347f, 0.03185242f, -0.08119833f, 0.23305292f, 0.11469378f, -0.09173203f, 0.03691225f, 
    -0.15654778f, 0.01239106f, -0.09597401f, -0.02604111f, -0.02324512f, 0.01256383f, 0.09332002f, 0.11122677f, 
    -0.10142343f, -0.07292026f, 0.03953776f, 0.01825553f, 0.05556509f, -0.02945483f, -0.15211120f, -0.16708329f, 
    -0.13353324f, -0.03211945f, 0.13585907f, 0.09909941f, 0.01207844f, -0.12560090f, 0.12523174f, 0.02741188f, 
    -0.03068239f, -0.02713208f, -0.03751139f, 0.11934844f, -0.03265842f, 0.04281184f, 0.08878885f, 0.03343959f, 
    -0.06812822f, 0.17027813f, 0.26475278f, 0.02489848f, -0.56933522f, 0.07678132f, -0.14742585f, -0.17418955f, 
    0.11542404f, -0.09132924f, -0.13346198f, -0.02071877f, -0.17124473f, -0.08387888f, -0.07081604f, 0.19016589f, 
    0.02721537f, 0.00974878f, 0.03330121f, -0.06213081f, -0.08263195f, -0.12741917f, -0.00907515f, -0.04279871f, 
    -0.00581731f, -0.04821300f, 0.01267949f, -0.00902173f, 0.04590202f, -0.01636060f, 0.04023312f, -0.05830775f, 
    -0.00077358f, 0.01021629f, -0.06252097f, 0.02119172f, 0.02613794f, -0.02219144f, 0.01855365f, 0.00038912f, 
    -0.05672913f, -0.04854933f, 0.04506356f, -0.04250545f, -0.02043284f, -0.03701352f, -0.01414794f, -0.01381685f, 
    -0.05893334f, -0.01977215f, 0.00954711f, -0.03562719f, 0.02358277f, 0.00838556f, -0.06398478f, -0.04699463f, 
    -0.00823709f, -0.02301828f, 0.02699287f, -0.02513412f, -0.05055492f, -0.01107715f, -0.00062555f, 0.02213840f, 
    -0.05503933f, 0.03161528f, -0.04552200f, -0.02557003f, -0.00253221f, -0.05928786f, -0.00220243f, 0.04421874f, 
    0.04331212f, -0.03142123f, -0.01854541f, 0.04615255f, -0.04515337f, 0.01703529f, -0.00493939f, -0.02214287f, 
    0.00672437f, 0.00200119f, 0.00351025f, -0.01840705f, -0.05876607f, -0.00728829f, 0.03100735f, -0.03130365f, 
    0.03440187f, 0.03669389f, -0.00144900f, 0.00064224f, -0.04182639f, 0.04565262f, 0.00107743f, 0.00779956f, 
    0.00287794f, -0.04461450f, 0.04171894f, 0.02892272f, 0.03010858f, 0.00905356f, 0.00083249f, -0.03607076f, 
    0.02003875f, 0.02800177f, 0.01460012f, 0.04064886f, -0.01624573f, 0.02368002f, -0.03629112f, 0.01153096f, 
    -0.02910262f, -0.03055645f, 0.03126904f, -0.04581683f, 0.02718543f, 0.04322032f, -0.05144754f, 0.03028326f, 
    0.02479193f, -0.01845841f, -0.04884994f, -0.05281064f, 0.01520482f, -0.03961534f, 0.03389508f, -0.03752389f, 
    0.02675465f, -0.06281018f, 0.01983009f, -0.03825403f, 0.02353765f, 0.01790077f, -0.00434323f, 0.04270468f, 
    -0.05405490f, 0.01362355f, 0.01246226f, -0.00411705f, -0.05154600f, -0.03390174f, 0.00457725f, -0.05478705f, 
    -0.00221474f, -0.01905125f, -0.02531646f, -0.01644474f, -0.03886404f, -0.04047768f, -0.01083024f, -0.00815460f, 
    -0.05257278f, -0.00431338f, 0.04088661f, -0.02492851f, 0.04713278f, 0.00572180f, 0.03866459f, 0.02583391f, 
    -0.03879989f, 0.03647453f, -0.01990879f, -0.06378187f, -0.01437952f, -0.00440962f, -0.04838884f, -0.00007899f, 
    0.02910317f, 0.03026411f, 0.02893381f, 0.02002967f, 0.04613671f, 0.02600763f, -0.05478471f, 0.04209795f, 
    0.01309494f, 0.01391199f, -0.04440269f, 0.01407664f, -0.02261617f, 0.02039756f, 0.01412134f, 0.01412635f, 
    -0.04323620f, 0.03901596f, -0.03455649f, -0.01658285f, 0.03915443f, -0.05931438f, 0.03515915f, 0.03433092f, 
    -0.04440365f, -0.00455134f, 0.03331896f, -0.06121741f, 0.04234412f, -0.06190854f, -0.05803107f, -0.04825855f, 
    -0.02403996f, 0.03487557f, -0.04438844f, -0.04197470f, 0.03234759f, -0.02593397f, 0.02370847f, -0.04640846f, 
    0.00725391f, 0.04021424f, -0.03722164f, -0.05546234f, 0.01827744f, 0.00420937f, 0.01384303f, 0.02882463f, 
    -0.01444323f, -0.02705970f, 0.00785509f, -0.03745757f, 0.00792825f, -0.00680541f, -0.05472213f, 0.03899838f, 
    -0.00752840f, 0.00472330f, -0.03924306f, -0.02401362f, 0.01582797f, -0.04100648f, -0.03882907f, -0.01371025f, 
    0.01454694f, 0.02718154f, -0.04043589f, 0.02875445f, -0.04739625f, 0.00517278f, -0.02022284f, -0.01332948f, 
    -0.03701640f, -0.04718444f, -0.04732489f, -0.06606010f, -0.02977766f, 0.02791029f, -0.03087343f, 0.01016633f, 
    0.02054669f, 0.02263735f, 0.02143968f, 0.00829887f, -0.04416554f, -0.04478694f, -0.06241572f, -0.03137341f, 
    -0.01115794f, -0.02281757f, 0.02325803f, -0.03153446f, -0.01016167f, -0.00743755f, -0.00929925f, -0.05871078f, 
    -0.05246881f, 0.01326668f, 0.00123192f, 0.03521632f, -0.03261578f, 0.01763505f, -0.03733880f, -0.00431113f, 
    -0.04314772f, -0.05256486f, 0.00911254f, -0.01212895f, 0.02876779f, 0.01039066f, -0.02557332f, 0.04012804f, 
    -0.04586929f, 0.03208214f, -0.01955329f, -0.03366924f, -0.05218419f, 0.01462938f, -0.05598986f, -0.01845913f, 
    0.03080091f, -0.04014449f, -0.03330816f, 0.03256829f, 0.00440562f, -0.00899729f, -0.00980832f, -0.05197607f, 
    0.02056592f, -0.03565071f, -0.00561307f, 0.03539981f, -0.05095136f, 0.00098832f, -0.01211480f, -0.01333753f, 
    0.04038486f, -0.05514643f, -0.01393823f, 0.02658807f, -0.02127117f, 0.01860462f, 0.03471823f, 0.03310813f, 
    0.00794056f, -0.00168711f, 0.03906592f, -0.05079765f, 0.03532787f, -0.03895170f, 0.00079572f, -0.02545540f, 
    0.01604836f, -0.00298954f, -0.01071796f, -0.00599323f, -0.00614595f, -0.00650773f, 0.01122162f, 0.03392833f, 
    0.02652767f, 0.01171213f, -0.02268090f, -0.01880182f, 0.01559362f, 0.00441028f, -0.01556173f, -0.02121462f, 
    0.02912394f, -0.03648739f, -0.02829818f, -0.00440655f, -0.04206257f, 0.01817611f, 0.03063738f, -0.03336114f, 
    -0.04155165f, -0.14479770f, 0.17396536f, 0.33806089f, -0.22141190f, -0.07148453f, -0.03381012f, 0.00430761f, 
    -0.04304395f, 0.06085391f, 0.11512277f, -0.06603663f, 0.01325395f, 0.08384401f, 0.08301995f, 0.10049583f, 
    0.00598329f, -0.04026822f, -0.07015727f, -0.04146345f, -0.09442078f, -0.09157361f, 0.01105899f, 0.04539621f, 
    0.12366008f, -0.03762577f, 0.00402969f, -0.00584121f, -0.01526587f, -0.05936496f, -0.04032988f, 0.01287394f, 
    0.04534268f, 0.14286210f, 0.01757616f, 0.20178673f, -0.06967578f, 0.09120119f, -0.11225916f, -0.02866974f, 
    -0.47952911f, -0.04813753f, -0.50557196f, 0.00507996f, -0.14049754f, 0.02089828f, -0.07248356f, -0.00328016f, 
    -0.00130499f, -0.05174368f, -0.03985291f, 0.01620173f, -0.03693357f, 0.06749323f, 0.01754111f, 0.04338313f, 
    0.09645795f, 0.01240318f, -0.10726294f, 0.05779596f, -0.33678743f, 0.02284666f, -0.08655336f, -0.02306239f, 
    0.06667300f, -0.03326575f, 0.14282908f, 0.08386511f, 0.07228131f, -0.02480666f, 0.00802749f, -0.04430607f, 
    0.18773055f, -0.03561125f, 0.04488397f, -0.07204006f, 0.01702885f, -0.04505909f, -0.02607542f, 0.05405105f, 
    -0.24156182f, 0.26411432f, -0.14407082f, 0.17753033f, 0.33616295f, 0.19598348f, -0.03959460f, 0.05380185f, 
    0.05964994f, 0.05192722f, -0.07006902f, 0.02812455f, 0.15234347f, 0.04209225f, -0.00135505f, -0.02455151f, 
    0.00075637f, 0.00713176f, -0.06044524f, 0.06125266f, 0.33178568f, 0.06795612f, -0.16723032f, -0.00872942f, 
    0.13161027f, -0.05346840f, 0.04786629f, 0.05668171f, 0.09860428f, -0.04967878f, 0.07783305f, 0.02225097f, 
    0.06969867f, 0.17545946f, -0.05090440f, -0.10216096f, -0.04840768f, -0.02046821f, -0.04186891f, 0.08962546f, 
    0.19085826f, 0.07309264f, -0.09722383f, 0.11151847f, 0.11999703f, 0.12108219f, 0.05466771f, 0.11414385f, 
    -0.04958728f, 0.11246551f, 0.06207928f, -0.02719714f, 0.05051755f, -0.02395758f, 0.07602065f, -0.02435271f, 
    0.12908158f, -0.08160577f, -0.01262767f, -0.02474723f, 0.09811281f, -0.00855737f, -0.20362550f, -0.16226520f, 
    0.17876665f, 0.06330239f, -0.03255699f, 0.04303524f, 0.06061493f, 0.12888111f, 0.07732226f, 0.09229133f, 
    0.16854742f, -0.04690004f, 0.01223079f, -0.08669154f, -0.01430535f, 0.00404625f, 0.05850318f, 0.04357166f, 
    0.02296571f, -0.18619935f, 0.07731301f, 0.01825613f, 0.01317041f, -0.08762269f, 0.13690300f, 0.02097398f, 
    -0.14753227f, -0.07603665f, -0.08940100f, -0.00976328f, -0.08837719f, 0.04386845f, 0.08170314f, 0.09947539f, 
    -0.00647447f, 0.09838573f, -0.15846375f, 0.01925798f, 0.02480974f, -0.15772539f, 0.07005419f, 0.10352065f, 
    0.09027125f, 0.00154720f, -0.07535627f, -0.02122036f, 0.00370302f, 0.09919513f, 0.07128137f, -0.04603612f, 
    0.08996486f, 0.12426794f, 0.04293563f, 0.12843370f, 0.02252808f, -0.03815521f, -0.03583929f, 0.02306654f, 
    -0.13788590f, -0.01067188f, -0.27144095f, 0.21836336f, 0.02131808f, 0.10797742f, -0.10841785f, -0.02397417f, 
    -0.05702481f, 0.09673827f, -0.04453024f, 0.05889351f, 0.02291771f, -0.01259455f, 0.06541142f, 0.07593954f, 
    0.04201040f, -0.03286193f, -0.00802615f, -0.11263527f, 0.01023090f, -0.04415327f, -0.04839778f, 0.13149625f, 
    0.14908569f, -0.13680035f, 0.10269497f, 0.07172505f, 0.03359465f, -0.03862439f, -0.03227372f, 0.07524654f, 
    0.01517402f, 0.05060480f, 0.06824306f, -0.09468989f, 0.11187221f, 0.01938840f, -0.03372148f, 0.06456497f, 
    -0.28857449f, 0.06187388f, 0.02038975f, -0.09886550f, 0.09149168f, 0.04221819f, -0.00777096f, 0.04664379f, 
    0.01325040f, 0.01035126f, -0.00591486f, 0.04549501f, -0.10627674f, 0.06609081f, 0.04259245f, -0.06470391f, 
    0.01090881f, 0.05621452f, -0.03210390f, 0.03764023f, -0.05483463f, 0.05298900f, 0.05075551f, 0.07611088f, 
    -0.19734457f, -0.05056668f, 0.08300290f, 0.05000862f, -0.01392557f, 0.13733108f, 0.02892219f, -0.02821929f, 
    0.02006504f, 0.05603593f, 0.14826012f, 0.06530590f, -0.02848224f, 0.00100907f, 0.18827493f, 0.06612749f, 
    0.44222367f, 0.06606869f, 0.00700424f, 0.07179117f, 0.07757096f, -0.06779835f, 0.01737919f, 0.06922545f, 
    0.10429804f, 0.04625028f, 0.07070801f, 0.08298813f, 0.15827528f, 0.12345994f, 0.09337791f, 0.05009571f, 
    0.00440617f, -0.10138252f, -0.07625615f, 0.04783759f, -0.16617189f, 0.11661224f, -0.20065649f, -0.07729433f, 
    0.19140831f, 0.19637573f, -0.01123117f, 0.00166923f, 0.06370240f, -0.05371806f, 0.01344048f, 0.00861167f, 
    0.02262356f, -0.05344202f, -0.07523042f, -0.01584673f, 0.04285641f, -0.04513583f, -0.02642406f, -0.02326047f, 
    0.40614924f, 0.03382727f, -0.00689202f, 0.01685639f, 0.03516791f, -0.04064174f, -0.04954156f, 0.08990029f, 
    -0.04908615f, -0.03704327f, 0.14898130f, 0.13591976f, 0.00689491f, -0.14301801f, -0.02192661f, -0.01391262f, 
    0.11964130f, -0.00556335f, 0.01783395f, 0.11678290f, -0.04785787f, 0.05097028f, -0.21304281f, 0.10599542f, 
    -0.03391919f, -0.05250885f, -0.05062787f, 0.05157927f, -0.08235488f, -0.15877077f, 0.01369419f, 0.19467372f, 
    -0.02549479f, 0.00082576f, 0.01828134f, -0.17802547f, 0.04628960f, 0.03764972f, 0.09248208f, -0.06783929f, 
    -0.12869580f, 0.07504217f, 0.07053118f, 0.14919613f, 0.20836601f, -0.06719215f, -0.03304071f, -0.07331523f, 
    0.04269409f, 0.09919251f, 0.01021657f, -0.03292156f, -0.01870289f, 0.07262123f, 0.04712122f, -0.03025771f, 
    -0.03047891f, 0.07787525f, 0.01197746f, -0.08226709f, 0.30876917f, -0.05679157f, -0.22003824f, -0.28197402f, 
    -0.08745703f, 0.07666551f, 0.00595451f, 0.01792566f, 0.02847796f, 0.09417512f, 0.00808123f, -0.13697009f, 
    -0.04190215f, 0.03538660f, -0.02057324f, 0.05227049f, 0.03629814f, -0.03528510f, -0.06867979f, -0.11385450f, 
    -0.19540803f, -0.05269164f, 0.06933407f, 0.09099578f, -0.06916274f, 0.01775213f, 0.06818694f, -0.07490829f, 
    0.04098065f, -0.20501675f, 0.09430902f, 0.03695576f, 0.01909032f, 0.15620999f, -0.00396800f, 0.05856053f, 
    0.10634454f, -0.00427240f, 0.11739369f, -0.02054568f, 0.04088527f, -0.10330719f, -0.16154018f, -0.11967156f, 
    -0.24370189f, 0.02908376f, 0.09064218f, 0.16843753f, -0.00973490f, -0.10654313f, 0.06820592f, 0.03117116f, 
    0.12658319f, -0.01004454f, -0.02318625f, 0.04764374f, -0.03257034f, 0.01017296f, 0.08883505f, 0.00672956f, 
    -0.02453007f, 0.14640160f, 0.06685407f, -0.08252698f, -0.38824013f, 0.10135955f, -0.11152089f, 0.01375131f, 
    -0.01154065f, 0.00631188f, -0.09785489f, -0.10990809f, -0.00200123f, 0.11030646f, -0.01452013f, 0.01343442f, 
    -0.03554181f, 0.01260991f, -0.01175991f, 0.09644970f, -0.09253462f, -0.30381992f, -0.04082298f, 0.25418109f, 
    0.05344253f, 0.00275009f, -0.03883982f, 0.01365421f, 0.12844470f, -0.03887820f, -0.03076502f, 0.04145269f, 
    0.01460338f, -0.01118021f, 0.02472371f, -0.06237125f, 0.04981786f, -0.04071655f, 0.07278168f, 0.08979454f, 
    0.29936710f, -0.10274830f, -0.21225488f, -0.03382140f, -0.22709654f, 0.17026161f, -0.00234161f, 0.18147472f, 
    0.03217879f, -0.04478427f, 0.07391337f, 0.08708259f, 0.01616882f, -0.09153719f, 0.12376264f, -0.00378208f, 
    0.01581396f, 0.03647786f, 0.02739111f, -0.09302305f, -0.13111407f, 0.37494141f, 0.00190219f, -0.26901245f, 
    -0.15880808f, 0.01913878f, 0.00072844f, -0.00177070f, -0.02536204f, 0.04818964f, 0.08898438f, -0.00956457f, 
    -0.06114928f, -0.00525900f, -0.01894152f, -0.00743042f, 0.02284973f, -0.01627334f, -0.02595183f, 0.10349196f, 
    0.05737542f, 0.19363421f, 0.34488946f, 0.40492457f, 0.01022058f, 0.10089806f, -0.10048053f, 0.04851646f, 
    0.07543451f, 0.15141018f, -0.05078050f, -0.12438403f, 0.02526674f, 0.07444018f, -0.04898606f, 0.10222386f, 
    -0.07656849f, 0.02673532f, -0.08353908f, 0.06107923f, -0.15457658f, -0.00143540f, 0.10711066f, -0.21180037f, 
    -0.10719869f, 0.05561209f, -0.02723785f, 0.01729373f, 0.05459036f, -0.01530602f, 0.13518240f, -0.06002080f, 
    -0.09773950f, 0.07395603f, 0.10872801f, 0.03614334f, -0.02426442f, -0.07496338f, 0.08864005f, 0.17062823f, 
    -0.48674068f, -0.03944442f, -0.10122760f, -0.16668487f, 0.25645921f, 0.07060397f, 0.14792134f, 0.07991339f, 
    -0.02193074f, 0.04880148f, -0.04348832f, 0.08227937f, -0.00458395f, -0.01669289f, -0.07765687f, 0.11774127f, 
    0.06599305f, -0.02976904f, 0.04436132f, -0.01245721f, 0.14013048f, -0.09762967f, 0.01277885f, -0.23045820f, 
    0.32841155f, 0.05548305f, 0.08159824f, -0.06745624f, -0.00941381f, 0.04982457f, -0.05040442f, -0.07301436f, 
    0.08233476f, 0.03870413f, -0.13081947f, 0.04510827f, 0.05735317f, -0.03621800f, 0.04815479f, 0.05838573f, 
    0.02618467f, 0.05664827f, -0.01483584f, -0.05737032f, -0.24497890f, -0.00212089f, -0.07697546f, -0.07551333f, 
    0.06698555f, -0.08830521f, 0.12150630f, 0.01266568f, 0.01389939f, -0.03666021f, -0.01834935f, -0.02843829f, 
    0.10869653f, -0.08169378f, -0.08820933f, -0.01101590f, 0.52768463f, 0.18037061f, 0.05310692f, 0.09096134f, 
    -0.09040908f, 0.12921886f, 0.08253135f, -0.02033103f, 0.04563228f, 0.04720336f, -0.05616210f, -0.08733898f, 
    0.10262128f, -0.09512401f, 0.04527908f, 0.10004649f, -0.09928893f, 0.13666493f, 0.08903421f, 0.01166921f, 
    0.04577950f, -0.03424088f, 0.04355351f, -0.04847129f, -0.01877169f, -0.04840047f, -0.04503770f, -0.01621080f, 
    -0.03398298f, -0.04352502f, 0.00173761f, -0.04428322f, -0.02892071f, -0.04260943f, 0.00063262f, 0.01804857f, 
    -0.03181639f, -0.01572507f, 0.00773208f, 0.04174988f, 0.02153112f, -0.03191468f, -0.01627118f, -0.02655430f, 
    0.03461596f, 0.01412462f, 0.00719351f, -0.00545768f, -0.05007750f, 0.00995786f, -0.05301759f, -0.04773350f, 
    0.01755634f, -0.00594206f, -0.02438399f, 0.03100319f, -0.04162745f, -0.00778026f, -0.02970365f, -0.06054257f, 
    -0.02980250f, 0.00465889f, -0.02242381f, -0.04898977f, -0.03617971f, 0.02391867f, -0.00523692f, -0.02927881f, 
    -0.05066609f, -0.01616977f, 0.00078469f, -0.03547636f, -0.04232487f, -0.03887337f, -0.02161345f, -0.02050369f, 
    -0.03372303f, -0.05318992f, -0.05842085f, 0.01043883f, 0.00953132f, 0.02817366f, 0.02180707f, -0.04187661f, 
    0.01605210f, 0.04434868f, -0.04083546f, -0.03959646f, 0.05243163f, 0.04114414f, -0.00004664f, 0.04800679f, 
    0.02828100f, -0.02103510f, -0.03774448f, -0.00344142f, -0.01050879f, -0.02635593f, -0.05513022f, -0.03366477f, 
    -0.04490153f, -0.02912736f, -0.00321162f, -0.00039689f, -0.04396100f, 0.00146230f, -0.00536773f, -0.05488288f, 
    0.03223007f, -0.05962268f, -0.04999454f, 0.03869761f, 0.01841345f, 0.03401404f, -0.04563962f, -0.05848988f, 
    0.04390980f, 0.02633976f, 0.00283167f, -0.03731399f, 0.04357205f, -0.05198291f, -0.00094527f, 0.04389978f, 
    0.04118645f, -0.05066132f, 0.00921536f, -0.04694176f, 0.01111825f, -0.02733944f, 0.00953192f, -0.06118102f, 
    0.04202855f, 0.02731121f, -0.05245975f, -0.02952059f, 0.00356652f, 0.02920241f, -0.04332165f, -0.05377962f, 
    -0.01922787f, -0.03401797f, -0.03876441f, -0.06114382f, 0.01771524f, 0.02272282f, 0.00449495f, 0.00357233f, 
    -0.00057818f, -0.01849015f, -0.05348332f, -0.04908185f, 0.03862881f, 0.03611134f, -0.03635148f, 0.03614096f, 
    0.03415088f, -0.01224909f, -0.05599643f, 0.04159898f, 0.02186036f, 0.04151686f, 0.00957558f, -0.05896147f, 
    -0.02658198f, 0.04639288f, 0.04908129f, 0.01526039f, 0.03711806f, -0.01593043f, -0.00439496f, -0.01741628f, 
    0.02217333f, 0.01083319f, 0.04878578f, -0.02495492f, 0.02960200f, 0.04195481f, -0.04006674f, -0.02899747f, 
    0.04384250f, -0.01989858f, 0.03565729f, 0.00361203f, 0.01970837f, -0.05203063f, 0.03710285f, 0.03562288f, 
    0.04757540f, -0.02731344f, -0.04056901f, 0.02581280f, 0.04913289f, -0.03847182f, 0.01122949f, 0.02985069f, 
    -0.00053190f, 0.01079012f, -0.06390953f, -0.05615316f, 0.01526480f, -0.02766229f, -0.05592754f, 0.00949987f, 
    0.00002891f, 0.03208712f, 0.04368067f, 0.04728251f, 0.00938612f, 0.00883167f, 0.01857975f, -0.04942940f, 
    0.02112038f, -0.06038915f, -0.03197214f, 0.02185715f, 0.02005726f, -0.01780232f, 0.04845975f, -0.04615130f, 
    0.01391617f, -0.03637095f, 0.00086669f, 0.01776912f, 0.02299241f, 0.02216309f, 0.00191570f, 0.03014680f, 
    -0.04738675f, -0.05396118f, 0.00474513f, 0.02867656f, -0.01633596f, 0.01726720f, 0.01299415f, 0.02793361f, 
    -0.02370301f, -0.05912369f, 0.02341508f, -0.03417098f, -0.06083834f, 0.02011700f, -0.05231073f, -0.06188232f, 
    0.01078316f, -0.03521375f, 0.00561323f, -0.02726422f, -0.05626709f, 0.00099475f, 0.00699908f, -0.01242964f, 
    0.01410799f, -0.00699149f, 0.04271130f, 0.02179677f, -0.00198649f, 0.02489020f, -0.01005803f, 0.01279809f, 
    0.01010763f, -0.00112913f, 0.00940074f, -0.03130236f, -0.05599581f, -0.03498641f, -0.04874632f, 0.02329995f, 
    -0.02751610f, 0.04254623f, 0.03305323f, 0.02502020f, -0.02317194f, -0.01790094f, -0.05711545f, 0.03809302f, 
    -0.05986736f, -0.02150682f, -0.03163569f, 0.04610540f, 0.01184314f, -0.02302338f, 0.01232887f, -0.01447199f, 
    -0.02655188f, -0.01333678f, 0.04388202f, 0.00027984f, -0.04392969f, -0.03085629f, -0.00467065f, -0.00078866f, 
    -0.02414010f, -0.03868251f, 0.04250844f, -0.05533041f, 0.02643669f, 0.02024611f, -0.00115535f, -0.00422305f, 
    0.03069978f, -0.04448506f, 0.00010862f, 0.00844867f, -0.02492814f, 0.00515520f, -0.03705212f, -0.02907447f, 
    -0.05745411f, 0.04951529f, -0.05565622f, 0.02508829f, -0.03338280f, 0.01174757f, -0.01865642f, 0.03986558f, 
    -0.00999350f, -0.01965070f, -0.03375942f, -0.04132972f, 0.01773724f, -0.02835661f, -0.04001431f, 0.03929481f, 
    0.00879178f, -0.05398981f, 0.04977712f, -0.00070045f, -0.03032282f, 0.02966296f, 0.04242181f, -0.00248097f, 
    0.02484970f, 0.02525033f, 0.04398537f, 0.03387188f, -0.00121600f, 0.00890726f, 0.04183058f, -0.06262465f, 
    -0.20811281f, 0.03345738f, -0.24999213f, -0.02614861f, -0.04427344f, 0.10777827f, 0.01979665f, -0.09983702f, 
    -0.01971047f, -0.02147199f, -0.04610963f, -0.04315661f, -0.03720737f, 0.07558975f, -0.13920870f, 0.01082513f, 
    -0.01051245f, -0.03105957f, -0.06668597f, -0.05875302f, -0.24603039f, -0.03276027f, 0.06331708f, -0.06433610f, 
    -0.05367593f, 0.16729769f, -0.03995850f, 0.04327047f, 0.08179077f, 0.07260407f, 0.02826017f, -0.05323068f, 
    0.02340211f, -0.05337160f, -0.06244219f, 0.12249490f, 0.03979379f, -0.03571650f, 0.00202180f, 0.03132505f, 
    0.27830729f, -0.41621786f, -0.20778500f, -0.14990960f, -0.16676082f, -0.09563262f, -0.08261948f, -0.05438460f, 
    0.04680936f, -0.01331906f, -0.11606224f, 0.03289568f, -0.01770579f, -0.04416007f, 0.00321018f, -0.04217298f, 
    0.00992336f, -0.00067540f, -0.16431920f, 0.08221629f, -0.09689809f, -0.02371852f, -0.16799293f, 0.08586042f, 
    0.13926849f, -0.09510580f, -0.02273142f, -0.12577239f, 0.05218419f, 0.04428218f, 0.04500899f, 0.08163871f, 
    -0.09985857f, 0.04415385f, 0.07937093f, 0.02405982f, -0.09834360f, -0.10202131f, 0.00197055f, 0.04797893f, 
    -0.00920654f, 0.16066863f, 0.04097410f, -0.25025412f, -0.18332891f, -0.04198002f, -0.02786804f, 0.00653996f, 
    -0.09240902f, 0.07132536f, -0.03920928f, -0.01647157f, -0.01381064f, -0.00698052f, -0.05124927f, -0.08858434f, 
    -0.01162143f, 0.02884344f, 0.08001091f, 0.09222021f, -0.05650977f, 0.11882110f, 0.00529251f, -0.02871828f, 
    -0.17849295f, 0.06621655f, 0.04190607f, 0.06627337f, 0.05826041f, 0.09463256f, -0.07510444f, -0.05349135f, 
    0.03459996f, 0.04165084f, -0.06827709f, -0.07465774f, 0.04216161f, -0.10749646f, 0.12224237f, 0.00522564f, 
    0.22436517f, -0.02113414f, -0.00274050f, 0.06729814f, -0.05453333f, 0.07470178f, 0.04642451f, -0.03016766f, 
    -0.02573689f, -0.04680767f, 0.07938558f, -0.02420027f, 0.02072293f, -0.01382796f, 0.01966933f, -0.08189987f, 
    -0.07100661f, -0.02922805f, -0.04429531f, -0.04132070f, 0.00228691f, -0.04682479f, 0.02218793f, -0.34523144f, 
    -0.22790535f, -0.07005522f, -0.16046484f, 0.03070142f, -0.03694031f, -0.03976993f, -0.02755198f, -0.00460641f, 
    -0.00762678f, 0.03430220f, 0.08582507f, 0.01103337f, 0.03594366f, 0.05267378f, -0.06730318f, 0.00983336f, 
    -0.24434704f, 0.04523909f, -0.03644964f, 0.13183790f, 0.23001128f, -0.00826729f, -0.07413411f, -0.14502226f, 
    0.03438663f, -0.09388870f, 0.01828198f, 0.00969145f, -0.03989325f, 0.04521667f, 0.00967860f, -0.14723004f, 
    -0.01773022f, -0.12987804f, 0.01912622f, -0.03217329f, 0.30509505f, -0.17011444f, -0.02531072f, 0.07688728f, 
    0.13443092f, 0.00066575f, -0.05130212f, 0.01605996f, 0.04010802f, -0.09130901f, -0.01195890f, 0.02975848f, 
    0.00669523f, 0.06262553f, 0.04276295f, 0.04560556f, 0.10964242f, 0.05589471f, 0.03911907f, -0.04741251f, 
    0.18105032f, -0.04929756f, -0.13603035f, -0.13430904f, -0.16319774f, -0.10038262f, -0.06176476f, 0.03443471f, 
    -0.01549768f, -0.07228849f, 0.02851245f, -0.08504722f, 0.04975938f, 0.03332113f, 0.05246741f, 0.03870624f, 
    -0.05573016f, -0.07171924f, -0.08958656f, 0.06925599f, 0.16679105f, 0.02673555f, -0.10383717f, 0.14875220f, 
    0.02145126f, -0.06216757f, 0.01735470f, 0.03970649f, -0.07334368f, -0.06381148f, 0.04850679f, -0.08968494f, 
    -0.00743026f, -0.03389333f, -0.06111929f, -0.01974860f, -0.03286386f, -0.01518586f, -0.03512152f, -0.04052078f, 
    -0.07847267f, 0.11248671f, 0.15636152f, -0.05866450f, 0.01207625f, 0.09735782f, -0.04849004f, -0.08499681f, 
    -0.03126311f, -0.09172433f, -0.01782360f, -0.06872963f, -0.06476259f, 0.02603021f, 0.09043280f, 0.06240032f, 
    -0.00449239f, -0.00018044f, -0.05502864f, 0.06741294f, -0.08585350f, -0.11910724f, -0.24666674f, 0.09202870f, 
    -0.09687047f, -0.13823241f, -0.05768454f, -0.05644836f, -0.01672386f, 0.00647106f, 0.03638113f, -0.05376940f, 
    -0.08961125f, -0.01343051f, -0.05684234f, -0.00029618f, 0.08348122f, -0.01253903f, -0.03801416f, -0.05551280f, 
    0.06368101f, 0.09236018f, -0.07647618f, 0.01041235f, -0.03058905f, -0.09939500f, -0.01727864f, 0.07921167f, 
    0.00996403f, 0.00587972f, -0.04255309f, -0.03068157f, -0.01933140f, -0.05029621f, -0.01306004f, 0.04235547f, 
    -0.08319543f, 0.05075299f, 0.05097887f, 0.03645149f, -0.19947161f, 0.12910727f, 0.02381251f, -0.07451876f, 
    -0.11648095f, -0.17275050f, -0.11980516f, 0.03225483f, -0.12394682f, -0.06031451f, -0.05130320f, -0.05402667f, 
    0.06775151f, -0.04603743f, 0.06039082f, -0.01781253f, 0.03097578f, -0.16990988f, 0.01158046f, 0.01052980f, 
    -0.18726550f, -0.01886693f, 0.11791305f, 0.16774918f, -0.24371101f, 0.00803896f, 0.04621780f, 0.01652212f, 
    -0.03266644f, -0.09855489f, 0.01560872f, -0.01295171f, 0.03357440f, -0.08229718f, -0.00566455f, -0.04853260f, 
    0.04698914f, 0.03368818f, 0.05678256f, 0.01551251f, -0.14380600f, -0.02171275f, -0.23995845f, 0.05247047f, 
    -0.20176964f, -0.09725630f, -0.00733789f, -0.06831329f, -0.05454350f, -0.10098986f, -0.02268145f, 0.05897794f, 
    -0.01993326f, -0.05780943f, 0.06227827f, -0.09554275f, 0.11173853f, 0.09074117f, 0.14870648f, 0.03477762f, 
    0.09859064f, -0.22064443f, -0.00728855f, 0.04465989f, 0.24626379f, 0.12715742f, -0.02605328f, 0.01382149f, 
    -0.11314397f, 0.12258224f, -0.05424193f, -0.02543773f, -0.03976189f, 0.10424745f, -0.01726660f, -0.05306123f, 
    0.04523374f, 0.01656057f, 0.07559804f, -0.05722757f, -0.03110199f, -0.10508296f, 0.03425273f, -0.11865349f, 
    0.10807835f, -0.01212586f, -0.00379371f, -0.04073802f, 0.05040200f, 0.03660789f, -0.06692541f, -0.11367321f, 
    -0.03555907f, 0.03098907f, 0.06303639f, -0.04167270f, 0.09252042f, -0.05072465f, 0.07161204f, -0.01963552f, 
    -0.02973388f, 0.02598395f, 0.00963927f, -0.10817654f, -0.35579503f, -0.05540052f, 0.17414200f, 0.01061420f, 
    -0.01528192f, 0.00415149f, 0.11817172f, -0.05325291f, -0.01061537f, 0.07631963f, -0.02142763f, -0.03048854f, 
    -0.02357475f, 0.00375045f, 0.16467546f, 0.02381128f, -0.09090399f, -0.06967616f, -0.09320346f, -0.01149842f, 
    -0.18454853f, 0.00007253f, 0.18459895f, -0.00108190f, 0.06850643f, -0.03522691f, 0.03590022f, 0.07825198f, 
    0.15258846f, -0.13797203f, -0.12122653f, -0.03798262f, 0.04529368f, 0.12491585f, 0.08209626f, 0.11883608f, 
    -0.35816199f, 0.56389517f, 0.03025935f, 0.08502408f, -0.26493207f, 0.04644101f, 0.11516370f, -0.01441707f, 
    0.04891504f, -0.13289361f, -0.14696044f, -0.09913217f, 0.02977825f, -0.01206295f, 0.09332730f, 0.07145846f, 
    -0.00371982f, 0.12438279f, -0.13063127f, 0.05696274f, -0.47033298f, -0.08589764f, 0.07353917f, 0.09487075f, 
    0.02776283f, -0.01397305f, 0.02468617f, -0.04331147f, 0.07463424f, 0.02358484f, -0.11474714f, -0.01960933f, 
    0.04505808f, -0.05936475f, 0.04530710f, 0.07060080f, 0.01138346f, 0.07652482f, 0.02556560f, 0.11824583f, 
    0.21603611f, -0.36139303f, 0.01821264f, 0.04799184f, -0.27015787f, -0.08989149f, -0.09082922f, 0.04361700f, 
    0.02172927f, 0.03859113f, 0.07347623f, 0.07610554f, 0.11455677f, 0.00139913f, 0.05231225f, 0.00536543f, 
    0.02987821f, -0.03343401f, 0.08353039f, -0.02200573f, 0.45459265f, 0.20337918f, -0.16922125f, -0.04722948f, 
    -0.07493617f, 0.03010957f, 0.04667391f, 0.12600572f, 0.00209874f, -0.09952607f, -0.01221143f, 0.05533199f, 
    -0.12284981f, -0.02306397f, 0.03305170f, 0.00388123f, 0.01163386f, -0.03725065f, 0.02512301f, 0.04902748f, 
    -0.17941949f, -0.03599633f, 0.36623168f, 0.18036062f, 0.09290986f, 0.06973988f, -0.04194143f, -0.05162305f, 
    0.01275334f, 0.17363685f, -0.01714691f, 0.02995910f, -0.07771693f, 0.04010030f, -0.03046069f, 0.05302996f, 
    -0.14947174f, 0.00877537f, -0.01984202f, 0.00030345f, -0.10904157f, 0.03246773f, -0.00330270f, -0.15145430f, 
    -0.05271955f, 0.00558601f, -0.06506606f, -0.03586332f, 0.11294811f, -0.00390315f, 0.20017597f, -0.04648301f, 
    -0.09401939f, -0.02539724f, 0.05470869f, 0.07705475f, -0.01404818f, -0.01192552f, 0.03000331f, 0.12265036f, 
    0.10657684f, -0.45288014f, 0.15877476f, -0.01636618f, -0.01799254f, 0.11026286f, 0.03194667f, 0.07917243f, 
    -0.08805084f, -0.05041704f, 0.03658815f, 0.11091632f, 0.07981802f, 0.01352814f, 0.05398599f, 0.08919575f, 
    0.13895714f, -0.06056398f, 0.06894074f, 0.04526231f, 0.03245357f, 0.17428499f, 0.10078444f, -0.09846620f, 
    0.25380924f, 0.08490297f, 0.10933910f, -0.12538920f, -0.02239141f, -0.09860638f, -0.08547546f, -0.04433754f, 
    0.08624186f, -0.00145784f, -0.16429940f, 0.07293892f, 0.07615284f, -0.12465300f, -0.00670688f, -0.00757550f, 
    -0.13584913f, -0.04771724f, 0.08661898f, 0.07795680f, -0.08891255f, -0.06268165f, 0.02747479f, -0.04884323f, 
    0.12959819f, 0.04682956f, 0.14460720f, -0.08868647f, -0.06233288f, 0.06241137f, 0.00879818f, 0.04577268f, 
    -0.02488913f, 0.12645251f, 0.08551609f, 0.12314397f, 0.24492958f, -0.05755055f, 0.12810688f, 0.21683854f, 
    0.16226022f, 0.06767829f, 0.02580629f, -0.02940926f, 0.09034466f, 0.04441731f, 0.01478320f, -0.01752747f, 
    0.07101311f, -0.03807332f, 0.05004476f, -0.09948909f, -0.09998620f, -0.02086328f, 0.05127012f, 0.01227621f, 
    0.21429843f, -0.17882630f, -0.01736899f, 0.20466956f, 0.12702602f, 0.03049433f, 0.17019077f, 0.02191711f, 
    -0.12076638f, -0.02282238f, 0.03073170f, -0.11015732f, -0.00819956f, 0.12920305f, 0.04125871f, -0.06160547f, 
    -0.10003236f, 0.04736784f, 0.03120634f, -0.06326970f, -0.17197293f, -0.23330157f, -0.05723220f, -0.05921701f, 
    -0.12952894f, -0.00933459f, -0.00020428f, 0.00229137f, 0.04574864f, -0.00579595f, -0.04218879f, -0.03525079f, 
    -0.04218150f, 0.05448938f, 0.05485388f, 0.09312040f, -0.18196590f, 0.06547895f, -0.09852485f, 0.03304117f, 
    -0.02968987f, 0.01260621f, -0.32612965f, -0.07336397f, -0.11841134f, 0.01742248f, -0.12643550f, -0.08058343f, 
    -0.04684165f, 0.16531560f, -0.04156527f, 0.02860069f, -0.10198235f, -0.09526905f, 0.04810222f, 0.05262566f, 
    0.00791949f, -0.08018062f, 0.06216211f, 0.02724629f, -0.46537834f, -0.07361532f, -0.12270998f, -0.21438740f, 
    0.02968217f, 0.03353269f, 0.08431866f, -0.05629879f, 0.01276100f, 0.06112171f, -0.02844856f, -0.00272186f, 
    0.00397540f, -0.12530409f, 0.14731039f, 0.02336154f, -0.08452068f, -0.10683521f, 0.05468198f, 0.11981609f, 
    -0.05008739f, 0.06660731f, 0.14748974f, -0.09570210f, -0.15164869f, 0.01361781f, 0.06149793f, 0.03348957f, 
    0.02923021f, 0.05342174f, 0.02994718f, -0.00287394f, 0.12580305f, 0.19820741f, 0.04573631f, -0.08537389f, 
    0.11885001f, -0.00628608f, -0.00222289f, 0.03306167f, 0.07099561f, 0.14011388f, -0.05937686f, -0.07975808f, 
    -0.03375023f, -0.02789064f, 0.01835139f, -0.03331726f, 0.20253246f, 0.06484625f, -0.00684067f, 0.17374195f, 
    0.04742291f, 0.13865063f, 0.00804606f, -0.02931153f, 0.11669694f, -0.15837003f, -0.17010762f, -0.02008817f, 
    0.04736147f, 0.38460773f, 0.18207331f, -0.04428394f, -0.06253546f, 0.01820807f, 0.03678472f, 0.00317446f, 
    0.10137542f, -0.02691195f, 0.12898639f, 0.04416760f, 0.09752187f, -0.02524113f, 0.11624888f, -0.09246792f, 
    0.05613170f, -0.17897832f, 0.08307690f, -0.07227329f, -0.18500952f, 0.06080367f, 0.00179384f, -0.32905009f, 
    -0.19229104f, 0.03184483f, 0.04886087f, -0.03581592f, -0.00826210f, 0.11883704f, 0.05588181f, 0.09642779f, 
    0.02615103f, -0.01060383f, 0.09035219f, -0.03588023f, 0.13439229f, 0.15865341f, -0.14273192f, -0.01126803f, 
    0.25332126f, -0.22342773f, 0.04238906f, -0.01919644f, -0.11107892f, -0.05856751f, -0.11373008f, -0.00993680f, 
    0.06950952f, -0.06251378f, 0.07209226f, -0.03874660f, -0.12637369f, 0.18628369f, 0.06582733f, 0.03731122f, 
    0.00312886f, -0.03296628f, 0.07090386f, -0.01274739f, 0.32728997f, 0.19049226f, -0.04157880f, 0.14314295f, 
    -0.03561907f, -0.03008651f, 0.06835330f, 0.03700658f, -0.05695328f, -0.04599724f, 0.25877219f, -0.10550456f, 
    0.04441241f, 0.06146606f, -0.08541358f, 0.12187678f, 0.10174720f, 0.03719224f, 0.00306097f, -0.01936936f, 
    -0.06964791f, -0.02600000f, -0.21013063f, 0.17516316f, -0.18982884f, 0.06709234f, 0.06250859f, -0.00540838f, 
    0.03965310f, 0.12635303f, 0.02415876f, -0.04002018f, 0.04993317f, -0.04573793f, 0.02773981f, 0.10228781f, 
    0.03899164f, -0.08774681f, 0.07754654f, 0.03402084f, -0.13084409f, -0.08542675f, -0.09010319f, -0.02335978f, 
    0.01215547f, -0.06710430f, 0.03342625f, 0.14266875f, 0.11041513f, 0.17604624f, 0.01585572f, 0.11502860f, 
    0.03593668f, 0.02286623f, 0.04837830f, 0.03461136f, 0.02939469f, -0.04855449f, 0.15972191f, 0.06868577f, 
    -0.23478064f, -0.07056018f, 0.04177503f, 0.03538459f, -0.05441291f, 0.18088551f, -0.00403177f, 0.01780948f, 
    -0.00700119f, 0.01110038f, -0.02355802f, -0.03627759f, -0.16969284f, 0.08186934f, -0.01128861f, 0.00962577f, 
    0.02819601f, 0.03071435f, -0.07333004f, 0.07048904f, 0.17294173f, -0.00915013f, 0.17375560f, 0.14429104f, 
    0.24006994f, 0.09000865f, 0.21499452f, 0.02951541f, -0.02300241f, 0.00816388f, -0.01923819f, -0.07349784f, 
    0.01617438f, 0.05309222f, -0.01161173f, 0.07306921f, 0.12954278f, 0.03711303f, 0.09390730f, 0.01379368f, 
    0.08514800f, 0.04283664f, -0.00862271f, 0.05784447f, -0.02092975f, 0.05400781f, -0.07081191f, 0.10069575f, 
    0.11730281f, 0.11673959f, 0.01510124f, 0.00780952f, 0.18025708f, 0.06259815f, 0.01751202f, -0.01295769f, 
    0.13734227f, -0.09890950f, -0.18157247f, 0.06911614f, -0.01079755f, -0.09421988f, 0.02642676f, 0.05707907f, 
    -0.00524462f, 0.07758804f, -0.00835873f, -0.11318576f, 0.10366026f, -0.04715816f, -0.03824879f, -0.07393829f, 
    0.11662855f, 0.01963109f, 0.01535535f, 0.07229970f, 0.16047706f, -0.00076093f, -0.10318578f, 0.13396442f, 
    0.31290957f, -0.34251314f, 0.10603318f, 0.15584409f, -0.10912865f, -0.22525917f, -0.12323364f, -0.10113332f, 
    0.06365098f, 0.07714777f, -0.08075100f, 0.01391227f, -0.19590734f, -0.04656743f, -0.07560188f, 0.00225216f, 
    0.03991156f, -0.12648161f, -0.08615209f, 0.01994823f, 0.33131245f, 0.28112042f, 0.05113991f, 0.10074010f, 
    0.21802084f, -0.13501385f, -0.06170139f, -0.03655270f, -0.05040558f, -0.07005919f, -0.04165897f, -0.04229699f, 
    -0.10372702f, -0.07809406f, -0.00130414f, -0.08158273f, -0.05295914f, 0.07151022f, -0.06690819f, -0.03243886f, 
    -0.27537027f, 0.19068360f, -0.06475341f, 0.09821237f, 0.17039470f, -0.03324234f, 0.07690708f, 0.11509142f, 
    -0.08827809f, -0.10773917f, 0.08801411f, 0.02767721f, -0.07533840f, 0.02037965f, 0.06822655f, 0.08799535f, 
    0.05280197f, -0.07541066f, 0.03436490f, -0.03149356f, -0.01409250f, 0.26789191f, 0.25912440f, -0.05160448f, 
    0.06767710f, 0.15049125f, 0.08105509f, 0.10452105f, -0.00001976f, 0.15480092f, -0.09568951f, -0.00107467f, 
    0.06049282f, -0.06253953f, -0.01294280f, 0.05880497f, -0.11423415f, -0.03831678f, 0.14133567f, 0.05135157f, 
    0.31040516f, 0.21773905f, 0.25825664f, 0.25784338f, 0.38659552f, 0.01927247f, -0.01707367f, -0.01839430f, 
    0.10780804f, -0.06332313f, -0.09987222f, 0.03062652f, 0.19884212f, -0.16064809f, -0.00599759f, 0.08611589f, 
    -0.07819030f, -0.05382410f, -0.04571394f, -0.06500841f, 0.36534199f, 0.24739064f, 0.09971597f, 0.17838393f, 
    0.27515543f, -0.07765843f, -0.03893444f, -0.12200933f, 0.06546474f, -0.02030821f, 0.04961638f, -0.06208192f, 
    0.08064443f, 0.07039243f, -0.07676055f, 0.06529804f, -0.06891505f, -0.05522565f, -0.04431819f, 0.06689910f, 
    0.02120553f, 0.25752965f, -0.18989868f, -0.00453662f, -0.04049154f, -0.12519826f, 0.00926566f, -0.09580389f, 
    -0.04670268f, 0.00312697f, -0.06504314f, -0.08836387f, 0.00263932f, -0.12408601f, 0.05735096f, -0.16189468f, 
    -0.11093373f, -0.04192237f, -0.19545145f, -0.07238889f, 0.08915441f, 0.33156452f, 0.26865342f, 0.25155821f, 
    0.30753106f, 0.07429080f, 0.14488053f, 0.14330329f, -0.01386031f, 0.04433106f, -0.00243476f, -0.05398019f, 
    0.16271101f, -0.00223674f, -0.01219990f, -0.06754581f, -0.05836795f, 0.06671105f, 0.07608405f, 0.03110725f, 
    0.35908636f, -0.16638058f, -0.01220794f, -0.13256530f, -0.18522885f, -0.09598732f, -0.11949553f, 0.03426113f, 
    -0.13085160f, 0.01335763f, -0.08683984f, -0.10513464f, -0.11097948f, 0.02002398f, -0.03745687f, 0.00843909f, 
    -0.01824765f, 0.07888728f, 0.00575197f, 0.07081904f, -0.25940052f, 0.04820525f, 0.01035048f, -0.14478898f, 
    0.02490012f, -0.23246276f, -0.13653940f, -0.19781791f, -0.09552407f, 0.00997995f, 0.02301301f, -0.05079219f, 
    -0.12115984f, -0.11064969f, -0.11526901f, -0.13687244f, -0.21708378f, -0.22061208f, -0.26755154f, -0.03604860f, 
    0.15014602f, 0.14868885f, 0.18485880f, 0.23490347f, 0.32773393f, 0.07284524f, 0.27000299f, 0.01171944f, 
    0.14726366f, 0.02168624f, -0.09749389f, -0.03238179f, -0.16660070f, -0.00127772f, 0.00775887f, 0.09139471f, 
    0.10992001f, 0.05087456f, 0.00234184f, 0.14551526f, -0.05880572f, 0.08391615f, 0.12360728f, -0.03475592f, 
    0.14829212f, 0.01946059f, -0.05662712f, -0.02038945f, 0.02238313f, -0.01428958f, -0.03797194f, 0.01198599f, 
    -0.02046472f, -0.04408816f, 0.03195830f, -0.06778656f, -0.04068505f, -0.02366930f, -0.03180737f, -0.05434685f, 
    -0.03570063f, -0.14622396f, 0.22245893f, -0.01962718f, 0.13514431f, -0.01068421f, -0.05560565f, -0.09495044f, 
    0.13809580f, -0.09906706f, -0.04075008f, 0.11511818f, -0.12901957f, -0.04060414f, -0.02857280f, -0.11163251f, 
    -0.12494027f, -0.12090775f, -0.06015574f, -0.02505448f, -0.22258076f, -0.10646661f, -0.07103530f, -0.02783857f, 
    -0.02947213f, -0.09870491f, -0.07326738f, 0.06265204f, 0.00123999f, 0.05085594f, -0.16335212f, -0.02230335f, 
    0.03661854f, -0.04870329f, -0.05531337f, -0.00164408f, -0.13973707f, -0.07402519f, -0.04940286f, -0.09219576f, 
    0.20192578f, 0.20656234f, 0.30102640f, -0.01563561f, 0.15959665f, 0.09692188f, -0.04422880f, -0.01605253f, 
    0.06394798f, 0.09793872f, 0.15620257f, 0.02520203f, 0.00116389f, 0.05648701f, -0.03173257f, -0.03167767f, 
    -0.03043345f, -0.04175825f, -0.06623893f, 0.07022440f, 0.17012948f, 0.19772545f, 0.31324217f, 0.08710875f, 
    0.33482876f, 0.22935939f, 0.12653302f, 0.03316374f, 0.17693992f, -0.10262625f, -0.00592571f, 0.03862084f, 
    -0.01757927f, -0.15361097f, -0.11391000f, -0.10098081f, -0.11776138f, 0.08355929f, -0.14564572f, -0.08339842f, 
    -0.04711991f, -0.13474764f, 0.10731823f, 0.13093431f, 0.08473593f, -0.05073127f, 0.12714826f, 0.01297756f, 
    0.05962292f, -0.09911492f, -0.13119395f, -0.05364713f, -0.02226103f, -0.08601824f, -0.01141050f, -0.04810779f, 
    -0.02649218f, -0.00341245f, 0.08920492f, -0.01642860f, 0.08274561f, -0.05751333f, -0.21300961f, 0.04793322f, 
    -0.13743119f, -0.14713509f, 0.06799909f, -0.03338246f, -0.04228884f, 0.01801323f, -0.12699848f, -0.02652037f, 
    -0.00041984f, 0.06143261f, 0.08337329f, 0.03835018f, -0.06417944f, 0.08226334f, -0.03264644f, 0.07371333f, 
    -0.02901023f, 0.15621775f, 0.03696702f, 0.01456623f, 0.14943835f, 0.11250412f, -0.01717431f, -0.04697115f, 
    -0.03490988f, 0.11197799f, -0.01808145f, -0.04368685f, -0.03580382f, -0.02377839f, -0.00002356f, -0.03544267f, 
    0.05290454f, -0.02711385f, 0.14857683f, -0.10763828f, -0.07768285f, -0.10602395f, 0.10345672f, -0.20700310f, 
    -0.09924736f, 0.01828641f, 0.05257497f, 0.07723261f, 0.08951579f, 0.03406845f, -0.26998577f, -0.14361875f, 
    0.02067986f, -0.05049065f, -0.00106983f, -0.01628909f, 0.07808638f, 0.06876178f, 0.15355612f, 0.09594223f, 
    -0.03020541f, 0.07122018f, 0.00620411f, 0.05527741f, -0.12086416f, -0.02930278f, 0.10988043f, -0.02027986f, 
    0.04976127f, 0.03580594f, 0.01390579f, 0.00070845f, 0.00127678f, 0.06130366f, 0.06919282f, -0.07040056f, 
    0.08816015f, 0.11467310f, 0.07788636f, -0.08518997f, -0.01552579f, -0.02436782f, -0.02515390f, 0.01900416f, 
    -0.05122684f, -0.00631958f, 0.09027124f, -0.02275339f, 0.03257417f, 0.06756102f, 0.00480193f, 0.17613339f, 
    0.20188868f, -0.08202697f, 0.02759062f, 0.03282712f, 0.10308950f, 0.04920155f, -0.05015390f, 0.00882846f, 
    -0.24491943f, 0.51248944f, 0.17315520f, 0.01173632f, -0.15319303f, -0.05913465f, -0.02189661f, 0.04107913f, 
    0.04180383f, -0.02956276f, -0.11760060f, 0.04865037f, 0.03174803f, -0.03963817f, 0.07176567f, 0.06445361f, 
    0.03119658f, 0.00680050f, -0.04337429f, -0.03267507f, -0.38376647f, -0.00258987f, -0.02278228f, 0.15225777f, 
    0.08118401f, 0.04378268f, 0.13278107f, -0.00787337f, 0.09127877f, 0.18740520f, -0.07647716f, 0.00671435f, 
    0.01569181f, -0.06271321f, 0.08113833f, -0.00231964f, -0.02191406f, 0.13257866f, -0.00999047f, 0.05039444f, 
    0.42519799f, -0.33156145f, 0.07969741f, -0.03800880f, -0.40947309f, -0.11867053f, -0.05325406f, 0.16067865f, 
    0.00598324f, 0.16803242f, 0.01776049f, 0.04525288f, 0.10489562f, -0.01910457f, 0.04374610f, 0.08367793f, 
    -0.09047635f, 0.05827770f, 0.02436559f, -0.01856005f, 0.24509218f, 0.17182270f, -0.13572623f, -0.02362445f, 
    -0.16590920f, -0.03857950f, 0.09517369f, 0.04831664f, 0.00834691f, -0.08384606f, 0.06663739f, -0.08163751f, 
    -0.01227355f, 0.02659752f, -0.14050536f, -0.03539871f, -0.00780719f, -0.10653235f, -0.10266001f, 0.03840479f, 
    -0.33133206f, -0.08423841f, 0.05484165f, 0.14177896f, 0.03123043f, 0.15443705f, 0.02163159f, -0.12900534f, 
    0.01784395f, 0.08214540f, -0.10503124f, 0.07945886f, -0.06488843f, 0.02283439f, 0.02754722f, 0.03254468f, 
    -0.09755445f, 0.07930857f, 0.03803500f, -0.07497086f, -0.21331900f, -0.04143485f, 0.02537269f, -0.07848524f, 
    -0.10779504f, 0.07629581f, -0.02469879f, -0.01740842f, 0.12758556f, 0.14464760f, 0.09995855f, -0.00119744f, 
    0.03544829f, -0.04940026f, 0.03864674f, 0.08669639f, 0.00628008f, -0.01294304f, 0.11667985f, 0.08152209f, 
    0.24456285f, -0.30826238f, 0.03789093f, 0.06150851f, -0.07393912f, 0.05796516f, 0.00359767f, 0.04062140f, 
    0.04358640f, 0.01966666f, -0.05019048f, 0.05138792f, -0.06528582f, 0.00565040f, -0.04394948f, -0.01457298f, 
    0.12894873f, -0.06529444f, 0.09627070f, 0.05514915f, 0.03745676f, 0.11334453f, 0.26498204f, -0.04334725f, 
    0.16694842f, 0.19732615f, 0.10803287f, -0.11798903f, -0.03379486f, -0.12230855f, -0.08726182f, -0.06641711f, 
    0.06670556f, 0.01457161f, -0.08027362f, 0.08716559f, 0.06433731f, -0.00303654f, -0.01111706f, 0.07912011f, 
    -0.14287192f, -0.11444948f, 0.11553020f, 0.02373281f, -0.08174081f, 0.06369311f, 0.08224089f, 0.05126385f, 
    0.12783393f, -0.00867877f, 0.14294325f, 0.07665988f, -0.02053560f, 0.06928603f, 0.07913549f, 0.04608717f, 
    0.11180211f, 0.12207848f, -0.01183321f, 0.09575962f, 0.22153328f, -0.27685329f, -0.01677939f, 0.20813936f, 
    0.04096434f, 0.08824173f, -0.02603503f, -0.14286254f, 0.03500786f, -0.00946840f, -0.00689972f, 0.08209104f, 
    -0.01645688f, 0.06360386f, 0.03424687f, -0.02920960f, -0.00843695f, 0.13342419f, -0.02920233f, 0.03491735f, 
    -0.54792845f, -0.00463548f, 0.12393636f, 0.00617834f, -0.35794696f, 0.11864794f, 0.07827444f, 0.12227843f, 
    -0.03872795f, -0.01205356f, 0.21108629f, 0.02742411f, 0.08327848f, -0.02949705f, 0.09283602f, 0.12422781f, 
    -0.00677929f, 0.05095059f, -0.05869428f, 0.06863176f, -0.02675872f, 0.08312877f, 0.07020023f, 0.17992666f, 
    0.03459531f, 0.06495803f, -0.02050716f, -0.03257476f, -0.11310413f, 0.10135114f, 0.11938261f, 0.01479233f, 
    0.00197487f, -0.02955164f, -0.06145177f, 0.19142233f, 0.24767914f, -0.01522958f, -0.01028586f, 0.07155822f, 
    0.01063242f, -0.47179210f, -0.40372044f, -0.08643693f, 0.06483310f, -0.02049327f, -0.04797007f, 0.14567925f, 
    0.25985864f, 0.03386234f, 0.10472652f, -0.11400962f, 0.07198051f, 0.13151394f, 0.03489582f, -0.04141270f, 
    -0.07321208f, 0.03612627f, -0.11619127f, -0.01553827f, 0.52375203f, 0.09890118f, 0.16026932f, 0.14383365f, 
    0.12218396f, -0.11675137f, 0.11001564f, 0.00114511f, 0.06948114f, -0.07130305f, 0.01193770f, -0.00048130f, 
    -0.05832196f, 0.14802049f, -0.02038472f, 0.07034124f, 0.04522336f, 0.12500650f, -0.01110779f, 0.15756482f, 
    -0.21503593f, 0.21651541f, -0.17169796f, 0.01094866f, 0.05906589f, 0.03012610f, -0.07081382f, -0.03060571f, 
    -0.05187705f, -0.03174653f, 0.09048427f, 0.01110771f, -0.08719263f, -0.13467483f, -0.05422869f, 0.06135689f, 
    -0.06293231f, 0.08995832f, 0.24571040f, -0.00041814f, 0.08207036f, 0.16001971f, 0.06538033f, 0.12961398f, 
    -0.05950701f, 0.01971753f, 0.18670282f, -0.05216020f, -0.08111846f, -0.08427422f, -0.08386718f, 0.01992100f, 
    -0.00917044f, -0.01503230f, -0.04181558f, -0.07788876f, -0.01233925f, 0.22001959f, 0.06461667f, 0.15339024f, 
    0.08797647f, -0.06355495f, -0.21800768f, 0.01937408f, -0.03978786f, 0.08677886f, -0.01920327f, 0.13964692f, 
    -0.03904303f, 0.01644442f, 0.10918280f, -0.03607178f, -0.07141670f, 0.00975383f, -0.01151578f, 0.04954020f, 
    0.01995516f, 0.14513090f, -0.13944528f, 0.16800657f, -0.25710499f, -0.22023600f, -0.24523146f, -0.02938722f, 
    0.15104622f, -0.12491222f, -0.11830138f, 0.12672740f, -0.06030832f, -0.07853969f, -0.01277161f, 0.00978089f, 
    0.00825260f, 0.04827333f, -0.00126592f, 0.07857001f, 0.01408526f, -0.01124334f, 0.14120460f, 0.09228668f, 
    -0.18889096f, -0.18791313f, -0.04694511f, 0.36075974f, -0.04575863f, -0.03130911f, 0.10047513f, 0.29065198f, 
    -0.03163913f, 0.09792843f, -0.00052903f, 0.05327910f, 0.02865470f, -0.05018659f, 0.00805015f, 0.12087696f, 
    0.16525108f, 0.01645898f, -0.07505062f, 0.04168673f, -0.32763076f, -0.24362361f, 0.04782184f, 0.01146698f, 
    0.35709321f, 0.15808025f, 0.02227945f, 0.14613053f, 0.09834828f, -0.05451093f, 0.02132810f, 0.01550604f, 
    -0.00909221f, -0.00703561f, 0.10000052f, -0.02262506f, 0.03319090f, -0.11114167f, 0.02842832f, -0.00553462f, 
    -0.00821469f, 0.13837624f, -0.00605935f, -0.02240179f, 0.24922156f, -0.06276584f, -0.11502652f, -0.07648704f, 
    -0.01057545f, -0.06642193f, -0.01383116f, -0.01507514f, 0.02088810f, 0.03317035f, 0.02393626f, 0.06176471f, 
    -0.06497759f, 0.01394688f, 0.07630812f, -0.06542604f, 0.24612828f, 0.15043736f, 0.11670059f, 0.11563736f, 
    -0.00047827f, -0.00182583f, 0.14369817f, -0.06079797f, 0.03582216f, -0.07834233f, 0.04758508f, -0.08460490f, 
    -0.09589156f, 0.13327466f, 0.10229190f, -0.05496904f, 0.14716792f, 0.01900028f, 0.00054890f, 0.03353643f, 
    0.27043790f, 0.14954977f, 0.14510681f, -0.08709174f, 0.02667019f, 0.03243923f, 0.09919938f, -0.01173506f, 
    -0.01030261f, 0.02387545f, 0.09118091f, 0.00740980f, 0.03987411f, -0.05696702f, 0.09304562f, 0.02940563f, 
    0.08203018f, -0.02097019f, 0.17550290f, -0.03558825f, -0.49282655f, 0.05932301f, -0.14968894f, 0.01247620f, 
    -0.38661286f, 0.17184225f, 0.06316970f, -0.00397045f, 0.12684946f, 0.06219267f, 0.14831169f, -0.00819239f, 
    -0.02622509f, 0.03538660f, 0.10828038f, 0.08337598f, 0.00799220f, -0.06677347f, -0.06677261f, -0.04317119f, 
    0.16380422f, 0.10434347f, 0.12734419f, 0.17102525f, -0.02830699f, -0.24644303f, 0.19312266f, -0.01459812f, 
    0.01588014f, -0.07023257f, -0.02847289f, 0.09159844f, 0.05395488f, 0.00895158f, 0.13206558f, 0.16852075f, 
    -0.08250039f, 0.12960525f, 0.17357847f, 0.02552055f, -0.02221919f, -0.02005397f, -0.22120923f, -0.10836992f, 
    0.09320548f, 0.02704454f, 0.07066642f, -0.06656171f, -0.11957632f, -0.12443438f, 0.03402884f, 0.05027876f, 
    -0.01531777f, -0.10193773f, 0.03400249f, -0.18688497f, -0.10040437f, 0.02581626f, -0.02790479f, 0.05856375f, 
    0.02694414f, 0.04969668f, 0.03750733f, -0.02434329f, -0.05168033f, -0.02572639f, -0.03624049f, -0.02633356f, 
    0.04827684f, -0.03559924f, 0.00353426f, -0.02803316f, 0.03579924f, 0.02234374f, 0.03836705f, -0.04139218f, 
    0.02174319f, 0.04043923f, -0.02489970f, -0.01314764f, -0.01984980f, -0.02349071f, -0.00586059f, -0.03272311f, 
    -0.03390727f, -0.01197684f, -0.03887810f, 0.03850957f, -0.01428020f, 0.00609992f, -0.06140610f, 0.02423811f, 
    0.00460569f, 0.01140227f, 0.03115973f, 0.00178560f, -0.05641666f, 0.01093517f, -0.00432787f, -0.02515214f, 
    -0.03979338f, -0.00883182f, -0.04075484f, -0.01590357f, 0.01450490f, -0.05053032f, 0.00572216f, -0.04519083f, 
    -0.02127091f, 0.03436257f, 0.01102986f, 0.02534941f, 0.03056881f, -0.01665931f, 0.03421437f, -0.03678072f, 
    0.03548366f, 0.03719378f, 0.01847054f, 0.03277059f, 0.03549093f, 0.01733494f, 0.03545191f, -0.02807981f, 
    0.03364038f, 0.01882361f, -0.05542497f, -0.00235242f, -0.02563071f, -0.03380698f, 0.02159146f, -0.01721367f, 
    0.00875390f, 0.00600421f, -0.05243870f, -0.04954335f, -0.04957385f, -0.01996762f, -0.04123642f, 0.04170594f, 
    0.01934414f, 0.00263241f, -0.01695092f, -0.01650485f, 0.01480062f, -0.03897022f, -0.05966664f, 0.00043838f, 
    -0.04023845f, -0.04911338f, 0.04746021f, -0.04456590f, -0.03483861f, -0.04963005f, -0.03215422f, 0.02809709f, 
    -0.01697169f, -0.05668584f, 0.04910829f, 0.00957373f, -0.02056157f, 0.04291216f, -0.00360912f, 0.01069526f, 
    0.02283482f, -0.04910413f, -0.04641019f, 0.04589266f, -0.00675549f, -0.00351853f, -0.04573862f, 0.00051884f, 
    0.03451552f, 0.03887492f, -0.00891376f, -0.02430757f, 0.02151422f, -0.00901583f, -0.00865319f, -0.00660172f, 
    0.00219342f, 0.03533999f, -0.03648198f, -0.04422256f, 0.02132679f, -0.02615278f, 0.02390814f, 0.00674083f, 
    0.02324712f, 0.02247481f, 0.01602507f, -0.03130157f, -0.03443368f, 0.00081989f, -0.02868745f, 0.01642156f, 
    -0.02747127f, 0.01221669f, 0.04452498f, 0.00200054f, -0.02677554f, 0.00646647f, -0.05264670f, 0.04275427f, 
    0.01988496f, 0.03442875f, 0.04076406f, -0.02660877f, -0.03140234f, -0.02353357f, -0.02973191f, 0.02626112f, 
    0.04269388f, 0.03697012f, -0.03376099f, 0.01015063f, 0.00509825f, 0.04878094f, -0.02739205f, -0.05477595f, 
    0.03677554f, -0.00845357f, 0.01681387f, 0.00922161f, 0.01505720f, -0.02552886f, -0.04991519f, -0.05465728f, 
    -0.05146106f, 0.01499015f, -0.05120137f, -0.03549238f, -0.01076419f, -0.04423586f, 0.02999338f, 0.00875015f, 
    0.00825899f, -0.02889607f, 0.01995755f, -0.06088775f, -0.03983729f, -0.04808053f, -0.05195593f, 0.01390756f, 
    -0.02903148f, -0.02875039f, -0.02665198f, 0.01128800f, -0.05516538f, 0.04633327f, -0.03959581f, 0.02863897f, 
    0.00704299f, 0.02102144f, -0.04786783f, -0.06001543f, -0.05846824f, -0.02385803f, -0.05305876f, -0.03055841f, 
    -0.03523494f, -0.00481608f, 0.01199642f, -0.01502441f, 0.01738995f, -0.03742545f, 0.05235126f, 0.03009746f, 
    -0.05309523f, -0.04746598f, -0.05462557f, 0.01852989f, -0.01073426f, -0.03730877f, 0.05314923f, 0.00957746f, 
    -0.05896556f, -0.02095326f, 0.03385603f, 0.04488257f, 0.02935517f, 0.04390468f, -0.05547533f, 0.03522379f, 
    -0.04379373f, 0.01171891f, 0.00308601f, -0.02345680f, 0.03086683f, -0.00722155f, -0.03202287f, -0.02858082f, 
    0.01685784f, 0.03327657f, -0.04400897f, -0.05046477f, -0.03877204f, -0.03645523f, 0.00682403f, 0.00347285f, 
    0.02755323f, 0.02005053f, -0.00875327f, 0.03902371f, 0.02473216f, -0.03332974f, -0.00799347f, 0.02509491f, 
    -0.01340522f, -0.02916436f, -0.05565993f, -0.04212022f, 0.03544234f, 0.04499699f, -0.02364350f, 0.03359852f, 
    -0.04424142f, -0.01823821f, 0.01271439f, 0.03228712f, 0.04695651f, -0.00572035f, 0.02954223f, -0.03773556f, 
    0.03086774f, -0.02777317f, -0.02476224f, -0.02586949f, -0.00767490f, 0.04380601f, -0.01973294f, 0.01149000f, 
    0.03725330f, 0.02502706f, -0.03389033f, -0.04242254f, 0.02134868f, -0.01026156f, 0.03983616f, -0.01591416f, 
    -0.01817692f, -0.05209867f, -0.04795520f, -0.05671315f, 0.04516551f, -0.01995558f, 0.01711636f, -0.00943922f, 
    0.00660449f, -0.04359896f, -0.02495200f, -0.04788319f, -0.02598461f, -0.05912813f, -0.03916117f, -0.01293009f, 
    0.04458287f, 0.03414345f, -0.05516847f, 0.04477769f, -0.05761343f, -0.00339781f, -0.01924245f, -0.03244968f, 
    0.03308718f, -0.04272873f, -0.00532838f, -0.04237441f, -0.02682112f, -0.05302349f, 0.00127558f, -0.05861210f, 
    0.03964649f, -0.06064891f, -0.03009982f, -0.01307417f, 0.01619818f, 0.01610271f, -0.01565833f, -0.01187218f, 
    -0.56704420f, -0.04402817f, -0.28411201f, -0.03564659f, -0.33685854f, 0.12470404f, 0.21771909f, -0.02522445f, 
    0.04741701f, -0.03367866f, -0.02669808f, -0.00107902f, -0.00631383f, -0.01205467f, 0.02904498f, 0.00810056f, 
    -0.11132156f, -0.02077134f, 0.08501623f, -0.03312843f, -0.04964456f, 0.38582888f, 0.12185539f, -0.14272861f, 
    0.13178447f, 0.06583622f, 0.04290260f, -0.03849393f, 0.10654236f, 0.14831437f, 0.08845779f, -0.11985820f, 
    -0.01026370f, -0.02517565f, -0.03683444f, 0.16590056f, 0.27293625f, 0.02357807f, -0.10961916f, 0.11024360f, 
    0.27103448f, -0.27758512f, 0.12416431f, -0.02505652f, 0.03235464f, 0.02771164f, 0.04095475f, 0.06478860f, 
    0.13183349f, -0.05265165f, -0.04642957f, -0.06758244f, 0.19239731f, -0.06914572f, -0.11860671f, -0.06209053f, 
    0.05774513f, 0.02589019f, -0.02757514f, 0.05435633f, -0.14789659f, 0.07728352f, 0.07992582f, 0.50763714f, 
    0.13757004f, -0.03209948f, -0.03010298f, 0.01895581f, 0.05934357f, -0.06478373f, -0.03200125f, -0.02605964f, 
    -0.01005790f, 0.13286819f, 0.00497995f, 0.10171335f, 0.00299488f, 0.02663291f, 0.02499978f, 0.01443530f, 
    0.04902931f, 0.29312593f, -0.10429264f, -0.20397416f, 0.09779176f, -0.07918226f, 0.01662807f, -0.03008501f, 
    0.04186019f, 0.06621403f, 0.03681998f, 0.07748847f, -0.04671577f, -0.10418585f, 0.01325025f, 0.00823637f, 
    -0.03040931f, 0.04448661f, -0.02535067f, -0.01609154f, -0.05390932f, 0.26572916f, 0.08195832f, 0.00365421f, 
    0.24785145f, 0.03654000f, -0.01065068f, -0.05189672f, 0.00515868f, 0.01047437f, -0.10957796f, -0.09117767f, 
    -0.09385242f, -0.09547538f, 0.00784608f, -0.00000220f, 0.10014106f, -0.00120761f, 0.14973794f, 0.04747337f, 
    -0.16756848f, 0.22397292f, -0.04393458f, 0.09070351f, 0.17940407f, -0.10761912f, 0.08487144f, -0.06544872f, 
    0.00413597f, 0.02785467f, 0.11501287f, 0.11362618f, 0.05741310f, 0.03150343f, 0.01979637f, -0.04080526f, 
    -0.02823741f, 0.13020521f, -0.06014339f, 0.03014921f, 0.06172704f, 0.29827037f, 0.14620034f, -0.17038499f, 
    0.13560674f, -0.06095530f, 0.02243953f, 0.06888182f, -0.05221492f, -0.07416057f, -0.15403913f, -0.06259700f, 
    0.05648716f, -0.01345124f, -0.11074552f, 0.08224197f, -0.15643817f, 0.04032505f, -0.02975381f, -0.04290523f, 
    -0.39563522f, 0.40347016f, -0.04626227f, 0.21310353f, 0.19741780f, 0.03663138f, 0.11979254f, -0.12272927f, 
    0.03936046f, 0.06807811f, 0.01214977f, 0.04124910f, 0.09722923f, -0.00458304f, -0.06158279f, -0.00765391f, 
    0.04083404f, -0.12426417f, 0.01471226f, 0.14208798f, 0.04511240f, -0.20293260f, -0.23735450f, 0.11882942f, 
    0.30306569f, 0.03990246f, -0.04491575f, 0.05573190f, 0.15503719f, -0.16961928f, -0.12820931f, 0.07477763f, 
    0.03203583f, 0.07373084f, 0.06356998f, -0.01257255f, -0.01460458f, 0.04504355f, 0.09520712f, -0.02820344f, 
    0.18082693f, -0.02629111f, 0.04342568f, -0.27421558f, 0.14003763f, -0.06300455f, -0.05519422f, 0.05875003f, 
    -0.15216239f, -0.10515513f, 0.07890881f, 0.12215260f, -0.05593653f, 0.04331969f, 0.06087505f, -0.05336732f, 
    -0.04508775f, -0.04794287f, 0.08966123f, -0.00167017f, 0.25947148f, 0.26176828f, -0.06008657f, 0.25237349f, 
    -0.06113190f, 0.05849007f, 0.05435259f, -0.03495237f, 0.05229728f, -0.06408802f, 0.06585634f, 0.04787590f, 
    0.07752614f, -0.05990835f, -0.03293286f, 0.02515133f, -0.02706776f, 0.17241457f, -0.03148055f, -0.07878198f, 
    0.53907835f, 0.07356575f, 0.14150566f, -0.01696774f, -0.00503032f, 0.07058572f, 0.00251652f, -0.07857732f, 
    -0.00283800f, 0.07656666f, -0.00172694f, -0.05537832f, 0.14244187f, 0.10417867f, 0.13631503f, -0.00437845f, 
    0.03816331f, 0.05507543f, -0.00211915f, -0.00275483f, -0.13335560f, -0.07331557f, -0.28784484f, 0.02077317f, 
    -0.30028781f, 0.03480986f, -0.01263669f, -0.03954191f, -0.02820211f, -0.10193360f, -0.01757422f, 0.11966609f, 
    -0.02808389f, 0.00019313f, 0.00833443f, 0.02539313f, -0.08658693f, 0.00956827f, 0.03165787f, -0.09393884f, 
    -0.02266736f, 0.09840467f, 0.01456506f, 0.08778310f, 0.24291345f, 0.01387756f, 0.13675646f, 0.03237618f, 
    -0.04953920f, -0.05221311f, -0.01735900f, 0.03365823f, -0.00605900f, -0.08795191f, -0.00209220f, 0.16254300f, 
    -0.07693117f, 0.09476136f, 0.19892879f, 0.03851552f, -0.14610371f, -0.00220984f, 0.13462627f, -0.12299289f, 
    0.08886348f, -0.15851784f, -0.04391989f, 0.08501022f, -0.15893279f, -0.07005285f, 0.06652544f, 0.10713488f, 
    -0.00888607f, 0.04923715f, 0.06555289f, -0.08866476f, 0.08773391f, -0.04133416f, 0.01167789f, 0.05291044f, 
    0.07183804f, -0.00669941f, -0.06380096f, -0.23657702f, 0.25470367f, -0.25293413f, -0.08978057f, 0.08946814f, 
    -0.18634646f, -0.05327137f, -0.01134253f, 0.14024878f, 0.07485286f, -0.00281964f, 0.01361793f, 0.10861534f, 
    0.13089073f, -0.16644439f, -0.11985963f, -0.00654239f, 0.31103414f, -0.18932208f, -0.09695622f, 0.19134937f, 
    0.08601282f, 0.05131980f, 0.12580450f, 0.11422257f, -0.22723091f, -0.02104402f, -0.04975048f, 0.23177999f, 
    0.02206938f, -0.10168863f, -0.14494611f, -0.03292800f, 0.13375834f, 0.09585827f, 0.08820397f, 0.00082150f, 
    0.15421098f, 0.04131461f, 0.19006933f, -0.12182013f, -0.02041668f, -0.15539899f, 0.03160418f, -0.03892111f, 
    0.13193880f, 0.08958689f, 0.11004127f, -0.03235953f, -0.03859988f, 0.07573958f, 0.07637379f, -0.02446546f, 
    0.15494518f, -0.09430796f, -0.04659477f, -0.06366156f, 0.98994195f, 0.22706796f, 0.13595116f, -0.14165957f, 
    -0.02111527f, 0.05143842f, 0.01584550f, -0.12713747f, 0.07756490f, 0.07704651f, 0.03872466f, 0.09249655f, 
    -0.00383718f, 0.07061711f, 0.02780033f, -0.00073988f, 0.01904936f, 0.10823893f, -0.11208140f, 0.10101653f, 
    0.08940323f, -0.11460429f, 0.17385159f, 0.23698916f, -0.15797387f, -0.01635667f, 0.11893882f, -0.04606162f, 
    -0.10067900f, 0.00243097f, -0.00610651f, 0.03313512f, -0.10162455f, -0.09671929f, -0.09875104f, 0.15457183f, 
    -0.08240690f, -0.01238832f, 0.11735023f, 0.15224931f, -0.11467843f, -0.06858677f, -0.10095733f, 0.16462390f, 
    -0.17183582f, 0.07061015f, 0.05401012f, 0.01736796f, -0.14593552f, -0.06244089f, -0.01939689f, 0.10436232f, 
    0.06954738f, -0.15855983f, -0.06290640f, -0.02802559f, -0.03851489f, 0.10987265f, 0.11290647f, 0.13116045f, 
    0.16082223f, -0.40757656f, -0.05255854f, -0.11985749f, -0.08683128f, -0.10054875f, -0.13132246f, 0.03837515f, 
    0.00988040f, -0.03292583f, 0.00502434f, 0.04335831f, -0.02642441f, -0.03970304f, -0.02059612f, 0.13725141f, 
    -0.03417493f, 0.16814217f, -0.19280268f, 0.15165175f, -0.00160516f, -0.17405479f, -0.20343453f, 0.34579349f, 
    0.03617107f, 0.00209692f, -0.04575716f, 0.08490702f, 0.06255508f, -0.09618204f, 0.15640353f, 0.05106991f, 
    -0.07394605f, -0.04773244f, -0.04366026f, 0.01477418f, 0.08028939f, -0.02124755f, 0.06780210f, -0.12605760f, 
    0.31439683f, -0.23012203f, -0.25885877f, -0.01844837f, 0.06790701f, -0.14048386f, 0.00972610f, 0.20871346f, 
    -0.12231880f, 0.05400251f, -0.04372377f, 0.00356981f, 0.02889602f, 0.02387708f, 0.16681324f, 0.05230706f, 
    0.14983486f, -0.12305979f, -0.07813304f, -0.04500785f, -0.16158079f, 0.05626489f, -0.04768812f, -0.08349717f, 
    0.09225114f, -0.00717646f, 0.18582471f, 0.08599124f, -0.12382629f, 0.07240490f, -0.02076063f, 0.19031584f, 
    -0.12301786f, -0.04081964f, 0.12274786f, -0.00535686f, 0.04753017f, -0.11960041f, -0.03508145f, 0.03785927f, 
    0.15032440f, 0.13211997f, 0.06474692f, -0.09848567f, 0.01051259f, -0.10812784f, -0.10539429f, -0.12318363f, 
    0.11867788f, 0.12080880f, 0.02236631f, -0.05393822f, 0.00033416f, -0.02022777f, -0.00343463f, 0.02276440f, 
    0.03058057f, 0.01545008f, 0.01173580f, 0.05973912f, 0.15538728f, 0.03618369f, 0.04599744f, -0.12754367f, 
    0.02794353f, 0.11103727f, -0.02900524f, -0.11905751f, 0.02494859f, -0.14950065f, 0.07062074f, 0.07698119f, 
    -0.12266518f, 0.08107889f, -0.00959462f, 0.10245250f, 0.08140361f, -0.00047616f, -0.08119931f, 0.09625915f, 
    0.07630302f, 0.16872106f, -0.15058038f, 0.05066306f, -0.02439352f, 0.06167075f, 0.16422799f, 0.04423990f, 
    -0.02734982f, -0.06203374f, -0.01265545f, 0.10798000f, 0.10594223f, 0.08401009f, -0.02189589f, 0.07784910f, 
    0.00418136f, -0.24581988f, 0.14455964f, -0.02693003f, -0.34885356f, -0.05705963f, -0.06419475f, -0.16758092f, 
    0.10793969f, -0.00635215f, -0.03866723f, -0.11308364f, 0.01394674f, -0.05447029f, -0.04022953f, 0.08481096f, 
    0.02700599f, 0.00869513f, -0.04931152f, -0.00341036f, 0.01527713f, -0.21029237f, -0.19485883f, -0.02529952f, 
    0.00238120f, -0.04627678f, 0.16801021f, 0.03305762f, -0.08196656f, 0.07758458f, 0.00896165f, -0.06860744f, 
    -0.07765005f, -0.08571611f, -0.02194460f, 0.04177257f, -0.03357598f, -0.01777528f, 0.03645112f, 0.02444445f, 
    -0.03551360f, 0.17541908f, 0.07569554f, 0.12574084f, 0.27157873f, 0.00612059f, -0.20912132f, -0.13880245f, 
    -0.20250346f, -0.04989780f, -0.08218415f, -0.11066049f, 0.09625512f, 0.08798692f, 0.08623514f, 0.04814207f, 
    0.00366606f, -0.11862417f, 0.05915366f, 0.01285620f, -0.06762970f, -0.02251463f, 0.11037131f, 0.00859711f, 
    0.33083564f, 0.12264425f, -0.17010598f, -0.09276950f, 0.15861352f, -0.05420031f, -0.05068068f, -0.01688058f, 
    0.02712405f, 0.04860556f, -0.08162642f, -0.05543538f, 0.01864223f, 0.04568371f, -0.00200822f, 0.02232553f, 
    -0.00827216f, -0.12021856f, -0.00648772f, -0.08457463f, 0.08017248f, -0.09823207f, 0.10143233f, -0.17658179f, 
    0.16528268f, -0.04413953f, -0.01356951f, 0.00298445f, -0.03231936f, -0.00325083f, 0.01143385f, -0.04148633f, 
    -0.06162009f, -0.00101726f, -0.01501994f, -0.06397542f, -0.04213659f, -0.07067118f, -0.02145360f, -0.05683983f, 
    0.00577513f, 0.08917151f, 0.24876732f, 0.02687716f, -0.05771898f, -0.13702737f, 0.08654707f, -0.03784388f, 
    -0.03618918f, -0.10234578f, 0.00863041f, -0.00521866f, -0.04161445f, -0.11641457f, 0.01987403f, -0.05172508f, 
    0.03647380f, -0.02144336f, -0.05132192f, 0.08034517f, -0.02226894f, 0.12546225f, 0.08798373f, 0.16232584f, 
    -0.12809341f, 0.07760465f, -0.04087617f, -0.07913753f, -0.05905204f, 0.04842442f, 0.18474346f, 0.08320549f, 
    -0.02766231f, 0.00490629f, -0.06325063f, -0.04145887f, -0.02585626f, 0.00775578f, -0.04580974f, -0.04773596f, 
    0.15782131f, -0.08045489f, 0.02307309f, 0.01839647f, 0.26086876f, -0.10476384f, -0.03726504f, 0.00207863f, 
    -0.05094127f, -0.05473511f, -0.06647060f, 0.00222624f, -0.08480527f, -0.22798741f, 0.01164664f, 0.04063723f, 
    -0.01041894f, 0.01006982f, -0.11841264f, 0.00122691f, -0.26933441f, -0.02576650f, -0.01226346f, 0.04822791f, 
    0.16773525f, 0.05053735f, -0.15656093f, -0.13387819f, -0.15464817f, 0.01647830f, -0.02405652f, -0.10643242f, 
    -0.14749305f, 0.10707915f, 0.15517683f, 0.08973493f, 0.04000803f, -0.01934097f, -0.04358287f, -0.00955463f, 
    0.17794301f, -0.36765027f, -0.10508442f, 0.06630903f, 0.10211143f, -0.12645704f, 0.03929542f, -0.01659078f, 
    -0.04872823f, 0.07193100f, 0.11407087f, 0.09416500f, -0.13243520f, -0.03033085f, -0.16541396f, -0.10080489f, 
    0.02008789f, -0.05494076f, 0.24706362f, -0.01285115f, 0.22167984f, 0.12328395f, 0.12141916f, -0.08925908f, 
    0.06117608f, -0.00264127f, -0.06774797f, -0.04420977f, -0.11957245f, -0.13001281f, 0.15812196f, 0.04499671f, 
    -0.15937828f, -0.00554155f, -0.10270818f, -0.12830776f, 0.09086718f, -0.06487764f, -0.02709170f, -0.20871881f, 
    -0.06455887f, 0.42920762f, -0.10489076f, -0.08553176f, 0.14536379f, 0.06086437f, 0.05521659f, -0.20242527f, 
    -0.10238776f, -0.06749892f, -0.14343791f, 0.01484298f, -0.08283304f, -0.00456172f, -0.02315913f, 0.00035702f, 
    -0.04535116f, -0.02621464f, 0.04290741f, 0.00213231f, -0.35354307f, 0.03933390f, 0.12206443f, 0.03623375f, 
    0.19575688f, -0.01421788f, 0.01446946f, -0.08482760f, -0.07647695f, 0.10216605f, -0.00826453f, 0.09828679f, 
    0.01151726f, -0.03730392f, 0.03298455f, -0.05012235f, -0.06918705f, 0.07570847f, 0.02159675f, -0.05815260f, 
    0.14891131f, 0.06225121f, 0.10053007f, -0.15614691f, 0.10466225f, -0.06377293f, 0.02137417f, 0.05253556f, 
    0.04921886f, -0.16004433f, 0.02699754f, -0.01508532f, 0.02247016f, 0.05386442f, -0.09182040f, -0.12779343f, 
    0.08123093f, -0.07332141f, -0.01078379f, 0.05784172f, -0.01970655f, -0.14527591f, -0.00212966f, 0.04060389f, 
    0.10472132f, -0.07230163f, 0.01234319f, -0.03039085f, -0.16349953f, -0.16902961f, -0.16626409f, 0.00673227f, 
    -0.01704033f, -0.06466822f, -0.01393329f, -0.02412909f, 0.07998495f, -0.07240502f, 0.02277420f, -0.13542251f, 
    0.05698989f, 0.09163385f, -0.05483178f, 0.13718717f, 0.04641334f, -0.16909486f, -0.01116740f, -0.02747183f, 
    0.04970981f, 0.04085641f, -0.06718359f, -0.03341609f, 0.03870557f, 0.02241750f, -0.03736344f, -0.02173758f, 
    -0.04387576f, 0.06365290f, -0.09153821f, 0.01441687f, -0.01572797f, 0.27382922f, -0.10482967f, 0.19443256f, 
    -0.03253302f, -0.07276686f, -0.15175453f, 0.02915435f, 0.00718682f, 0.04816871f, -0.02659141f, 0.10112389f, 
    0.02879984f, 0.07717312f, 0.12479264f, -0.09915285f, -0.10199793f, 0.04116916f, 0.02033008f, 0.00287637f, 
    -0.07054245f, 0.00936094f, -0.08563372f, -0.13366704f, 0.05434750f, -0.01900112f, -0.05308687f, -0.03321236f, 
    -0.15668048f, -0.11190624f, -0.13001850f, -0.04073569f, -0.05515621f, -0.06689465f, -0.02227570f, -0.01125511f, 
    0.00015033f, -0.00460038f, -0.00248863f, -0.18017736f, -0.25421593f, 0.12112594f, 0.22539647f, -0.21720995f, 
    -0.00338728f, -0.05106948f, -0.00789916f, 0.12588556f, 0.01564553f, -0.00555661f, -0.01512211f, 0.03965072f, 
    -0.02629975f, 0.02240598f, -0.05100568f, 0.07787869f, -0.04464059f, -0.10119357f, 0.00142060f, -0.01080892f, 
    0.23248065f, 0.17895736f, 0.09514528f, 0.09078291f, -0.04489277f, -0.20266101f, -0.16725814f, 0.04035942f, 
    0.06436687f, 0.17546529f, 0.18089025f, 0.04149544f, -0.00901108f, -0.00700918f, 0.02794432f, 0.08438028f, 
    0.09791916f, -0.04439192f, 0.01442338f, 0.09405047f, -0.05435836f, -0.06984978f, 0.16612819f, 0.25749436f, 
    0.19314519f, 0.08660965f, 0.01988777f, 0.06212848f, -0.08986023f, -0.01892325f, 0.05457808f, 0.08305416f, 
    0.05818515f, -0.07279297f, -0.01039464f, 0.02600590f, -0.02780539f, 0.06761037f, 0.09541412f, -0.04347802f, 
    -0.34159386f, -0.07210326f, -0.17637102f, -0.02437335f, -0.31477866f, 0.07446820f, 0.12602943f, 0.04602505f, 
    0.02549789f, -0.11114089f, -0.04220067f, 0.08400309f, -0.01727383f, 0.28352082f, 0.08549804f, -0.00535857f, 
    0.06956858f, 0.04136556f, -0.06785610f, 0.01485540f, 0.50756997f, 0.12540200f, -0.10112621f, -0.00810535f, 
    0.18115468f, -0.12318575f, -0.04522521f, 0.02884475f, 0.10955455f, -0.00042777f, 0.12158927f, 0.00797943f, 
    0.03178170f, 0.08498832f, 0.00375724f, -0.11609711f, -0.05548093f, 0.06983273f, -0.12759900f, -0.09653375f, 
    -0.08025801f, 0.01156929f, 0.15503995f, 0.18366501f, 0.08339807f, 0.06369486f, -0.10562517f, 0.09812409f, 
    -0.07062523f, -0.00689147f, -0.06031547f, -0.08451815f, 0.04516191f, -0.03386226f, -0.08316119f, 0.13416722f, 
    -0.15793660f, -0.03092930f, 0.03050165f, 0.22308004f, 0.06423466f, -0.01177901f, -0.20371307f, 0.08668442f, 
    -0.01318636f, -0.14445823f, 0.12745821f, 0.18342240f, -0.00394675f, 0.08672308f, 0.08807436f, -0.16890441f, 
    0.09817284f, -0.02037922f, -0.04251238f, -0.09246106f, -0.06195702f, 0.04276058f, 0.10607161f, 0.08610909f, 
    0.29170510f, -0.17873773f, -0.11962327f, 0.08425286f, 0.14940640f, 0.04547773f, -0.00314738f, 0.04477572f, 
    0.06367912f, -0.07596262f, -0.10772146f, 0.00885351f, -0.01766700f, 0.05027810f, -0.02939646f, -0.05230357f, 
    0.02254482f, 0.07521094f, -0.06861014f, -0.00219456f, 0.25851724f, -0.20128849f, -0.19579628f, 0.04135365f, 
    0.00363181f, -0.02925905f, -0.14252472f, 0.03355112f, 0.05817463f, -0.03078275f, 0.14221473f, -0.03774668f, 
    0.12205472f, 0.01921644f, -0.04063125f, -0.05259807f, 0.00843210f, -0.04284000f, 0.05018401f, 0.09450043f, 
    0.07677941f, -0.18222620f, 0.13197696f, -0.08127769f, 0.19053543f, -0.02394824f, 0.07620277f, -0.02796284f, 
    0.00815789f, -0.05419646f, -0.05434137f, 0.06653408f, 0.04681816f, -0.03703690f, 0.01922952f, -0.11077532f, 
    -0.03847155f, -0.04551351f, -0.05147403f, -0.07195540f, 0.19302703f, -0.20281674f, 0.14481640f, -0.06130625f, 
    0.09218225f, 0.07058321f, 0.04162855f, 0.12492166f, 0.02253308f, 0.14638063f, -0.01684649f, 0.01390940f, 
    -0.04053056f, 0.03811797f, 0.04622257f, 0.02797249f, 0.08101916f, 0.06941026f, 0.06337369f, -0.02851330f, 
    0.06634927f, 0.03900054f, -0.14266303f, 0.06733675f, -0.33712497f, 0.04054935f, -0.09174059f, 0.02857999f, 
    -0.02001937f, 0.03381718f, -0.03991234f, 0.03326099f, 0.08295214f, 0.04547837f, -0.03952577f, 0.13315010f, 
    -0.08650380f, 0.06193078f, -0.11041833f, 0.07978312f, 0.16800773f, -0.03114942f, 0.01942165f, 0.01356083f, 
    0.24358690f, -0.10504202f, 0.02314172f, 0.04826694f, -0.10274498f, -0.08939523f, -0.00917615f, -0.03182305f, 
    -0.10004415f, 0.13365152f, -0.00230805f, -0.09750240f, 0.08244851f, -0.01229417f, -0.08833268f, 0.03466696f, 
    -0.46825469f, 0.21774979f, -0.03943270f, -0.01490183f, 0.06511840f, 0.00187173f, 0.13465591f, 0.08873285f, 
    0.01609379f, -0.08251628f, 0.03898490f, -0.02967790f, 0.04357749f, -0.00776376f, -0.00651747f, -0.02692430f, 
    -0.07347852f, -0.05331302f, 0.05667875f, -0.03768215f, -0.00166512f, -0.06837103f, -0.05769243f, -0.04565874f, 
    0.09311117f, -0.22227381f, -0.18886459f, 0.04705369f, 0.06518113f, 0.13900016f, 0.08995336f, 0.00175506f, 
    -0.02256532f, 0.05363261f, 0.01679156f, 0.08562832f, 0.10024687f, -0.09932593f, 0.07100557f, 0.06980584f, 
    0.36147010f, 0.08038011f, 0.15860455f, 0.08546401f, -0.00804933f, -0.10563417f, -0.03417175f, 0.05436269f, 
    0.02556279f, 0.15096200f, -0.03961774f, -0.08562671f, -0.00039864f, 0.10085771f, -0.01500005f, 0.07898749f, 
    0.05066521f, 0.02215054f, 0.08472495f, 0.06033209f, -0.24781910f, 0.35780546f, -0.15535967f, -0.07948390f, 
    -0.04824108f, 0.01276133f, -0.03687026f, 0.05193977f, -0.03246473f, 0.00492807f, -0.05039671f, -0.10971927f, 
    -0.00780935f, -0.15764336f, -0.00144888f, 0.08700213f, -0.12679785f, -0.05286763f, 0.12233669f, -0.14361805f, 
    0.54245448f, 0.19779259f, 0.09701183f, -0.00047913f, 0.31982514f, 0.10967668f, -0.05020025f, 0.09291194f, 
    0.07712942f, 0.06103844f, 0.00961520f, 0.02706029f, 0.08446506f, -0.01902515f, 0.05382644f, -0.00931208f, 
    0.06153561f, 0.03561504f, 0.06911958f, 0.08436361f, 0.10201786f, 0.04205206f, 0.02087450f, 0.18631749f, 
    0.02508896f, -0.05975923f, -0.15600774f, -0.06910138f, -0.06353287f, -0.03256243f, 0.16512080f, 0.01715755f, 
    -0.02319811f, 0.04703303f, 0.02442982f, 0.07005490f, -0.02434377f, 0.01042698f, 0.09472474f, 0.06635374f, 
    -0.32657072f, 0.01610668f, 0.20170367f, -0.01678419f, 0.17273657f, 0.03415193f, 0.09034640f, 0.13395467f, 
    0.07337466f, 0.03199146f, 0.07586993f, -0.12125500f, -0.03739256f, 0.00647659f, 0.11888152f, 0.06842817f, 
    -0.00707173f, -0.04841714f, 0.09583799f, -0.03773265f, 0.48939058f, 0.01450425f, 0.25577000f, -0.18799403f, 
    -0.29678652f, 0.00823810f, -0.01229434f, 0.05873794f, -0.06766301f, 0.00349556f, -0.10814965f, -0.07292592f, 
    -0.00106030f, 0.05835434f, -0.04033684f, -0.00038146f, 0.11013940f, 0.10366752f, 0.00987203f, -0.00882150f, 
    -0.22630747f, -0.06413842f, -0.01603705f, 0.14902419f, -0.06049865f, 0.07894234f, -0.10839053f, -0.00929974f, 
    0.03227587f, -0.12967572f, 0.05647604f, 0.16899690f, -0.03128320f, 0.02194677f, 0.15922469f, 0.04089932f, 
    0.10415664f, 0.15945539f, 0.05783898f, -0.02339157f, -0.11681411f, -0.18552348f, 0.01670271f, 0.15616874f, 
    -0.10044038f, -0.16782816f, 0.03451950f, 0.06571604f, 0.03788247f, 0.01528234f, 0.02190513f, 0.07354978f, 
    -0.03799562f, 0.01677131f, 0.17143054f, 0.04592129f, -0.03919672f, 0.03067947f, -0.05255556f, 0.01944599f, 
    0.13043661f, -0.05688961f, 0.10021590f, 0.01145172f, -0.10529505f, 0.02881750f, -0.08521276f, 0.12018104f, 
    0.06759912f, -0.06101820f, -0.09016574f, -0.09323122f, 0.07894409f, 0.06269777f, -0.04140005f, 0.05643762f, 
    -0.03601620f, 0.02265265f, -0.02128554f, 0.05062230f, -0.02221815f, -0.31956095f, -0.18918367f, 0.18738176f, 
    0.06219683f, 0.02471509f, 0.06205047f, 0.08872991f, 0.01125853f, 0.13106632f, 0.04374133f, 0.05274861f, 
    0.06111912f, -0.00350277f, 0.17323096f, 0.05203200f, 0.09365755f, 0.09961989f, 0.11837260f, 0.07417299f, 
    0.32045573f, 0.10245562f, 0.03687153f, -0.00983274f, -0.28806469f, -0.01116473f, 0.02367389f, 0.20905668f, 
    -0.06490889f, 0.19837649f, 0.01510651f, 0.02350328f, 0.02037061f, -0.05430951f, 0.05514854f, -0.05426827f, 
    -0.13607726f, 0.03438811f, -0.05697033f, -0.05123365f, -0.08279496f, -0.01541312f, 0.06848134f, -0.11267986f, 
    -0.18442073f, 0.06281537f, 0.00738250f, -0.05025205f, 0.02994175f, 0.04374303f, 0.09662277f, -0.05488414f, 
    -0.06050102f, -0.02675436f, -0.08645348f, -0.01610206f, -0.02543607f, -0.07014573f, -0.05390182f, 0.00732871f, 
    -0.52336895f, 0.26332411f, -0.23430698f, 0.22178626f, -0.00780511f, 0.10127908f, 0.00749192f, -0.08105140f, 
    -0.01626082f, 0.01435542f, 0.01281024f, 0.03075924f, 0.01917452f, 0.03320107f, 0.07356542f, -0.05847145f, 
    0.01177275f, -0.03413777f, 0.08673164f, 0.00902483f, -0.16083835f, -0.18970200f, 0.21135223f, -0.09538397f, 
    -0.25996831f, -0.04373795f, 0.20144886f, -0.10012037f, 0.09102535f, 0.06004632f, 0.05424208f, 0.03662766f, 
    -0.07977191f, 0.10457053f, 0.02723434f, -0.00562693f, -0.07919633f, -0.06193793f, 0.00593403f, 0.05451779f, 
    -0.01212837f, 0.02206033f, -0.08924796f, 0.06922626f, -0.01654871f, -0.16747895f, 0.05039436f, 0.03099053f, 
    0.11912587f, 0.06887899f, 0.13153332f, -0.02767594f, -0.01630827f, -0.11671098f, 0.04935252f, 0.02064830f, 
    -0.05800433f, -0.19807225f, 0.03847238f, -0.06878006f, 0.29149377f, -0.05575314f, 0.16231863f, 0.12523369f, 
    0.15878730f, 0.10951175f, 0.10705870f, 0.07039368f, 0.06591853f, -0.03547912f, 0.10337900f, 0.00410946f, 
    0.05373847f, -0.07306473f, -0.00389895f, 0.07755549f, 0.11429130f, 0.01411955f, -0.02896515f, 0.06268223f, 
    -0.06207855f, -0.10995775f, 0.05119584f, 0.06492951f, -0.26356801f, 0.03942986f, 0.02583893f, 0.01202646f, 
    -0.00509761f, -0.08400115f, 0.06593669f, 0.10844436f, 0.00111751f, 0.06541838f, 0.14177760f, 0.03463215f, 
    0.05519311f, 0.12282386f, -0.01963499f, -0.00959756f, -0.18074200f, -0.02553110f, -0.27029651f, 0.02553057f, 
    0.03218121f, 0.02121705f, -0.03493644f, -0.07211379f, 0.06696761f, -0.05021159f, 0.02288814f, 0.06732627f, 
    -0.03272318f, -0.02188788f, -0.01391909f, 0.04462574f, -0.06309074f, 0.02404089f, -0.02513202f, 0.02678257f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04894274f, 0.01972141f, -0.06180004f, -0.05844799f, -0.02284675f, 0.09980510f, 0.03574207f, 0.03418849f, 
    0.03992322f, 0.00686973f, 0.15674560f, 0.04633839f, -0.02738317f, 0.07685445f, 0.04023933f, 0.02909700f, 
    0.04671936f, -0.04462659f, 0.04944862f, 0.03023775f, -0.03172636f, -0.00099308f, -0.04647216f, 0.02937024f, 
    0.01555764f, -0.02852291f, -0.02484478f, 0.05032180f, 0.06863007f, 0.02098584f, 0.05990889f, 0.14028850f, 
    -0.04242279f, -0.06167473f, -0.00958859f, -0.01369678f, 0.06908208f, 0.04501519f, 0.02447602f, -0.08432395f, 
    0.11845309f, -0.11953066f, -0.00936822f, 0.00041990f, -0.01904753f, 0.02976788f, -0.04983458f, 0.00569513f, 
    0.01540954f, 0.05513467f, -0.00164791f, 0.04530276f, 0.05728786f, 0.00577523f, 0.08879194f, -0.00619486f, 
    0.01289529f, 0.10588807f, -0.05706121f, 0.01201367f, 0.01965025f, -0.09053987f, 0.00955756f, -0.04206232f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.47321990f, 0.02066114f, -0.07785480f, -0.02163557f, -0.10697718f, -0.36316735f, -0.41806561f, 0.32157224f, 
    -0.33454081f, 0.24546662f, 0.19141737f, -0.32227346f, -0.12642302f, 0.28125119f, 0.08777671f, 0.29613879f, 
    -0.03488649f, -0.01402648f, 0.18664633f, -0.12436485f, 0.26047537f, 0.27814555f, -0.01252558f, -0.30358511f, 
    -0.06664692f, -0.07468972f, 0.24971177f, -0.08348608f, -0.20121038f, -0.10356703f, -0.43776986f, -0.29821393f, 
    0.00419635f, 0.00332604f, 0.06634557f, 0.05281961f, 0.29067108f, -0.04472281f, 0.02855195f, 0.26853648f, 
    -0.55834544f, 0.08979028f, -0.05185640f, -0.34911251f, 0.09099980f, 0.06139859f, 0.08666476f, 0.25580361f, 
    0.00500848f, -0.19088028f, -0.06719060f, 0.12124739f, -0.08556471f, -0.15577200f, -0.14631282f, -0.51291150f, 
    -0.09513970f, -0.35426030f, -0.03087227f, -0.19781384f, 0.28839588f, 0.21589582f, 0.23692240f, 0.13665655f, 
    -0.10457707f, -0.31802362f, -0.10281567f, 0.02010372f, -0.10710941f, -0.24840982f, -0.09376691f, 0.27718848f, 
    -0.00051604f, -0.13315995f, 0.21066892f, 0.31808195f, -0.06513726f, 0.09295057f, -0.10810414f, 0.13683085f, 
    -0.29127011f, -0.09350446f, 0.19341308f, 0.03150557f, 0.24870704f, 0.04744529f, -0.03191053f, 0.02910146f, 
    0.05146508f, -0.15997234f, 0.11878786f, 0.05718696f, -0.19707893f, 0.33805230f, -0.15190466f, 0.28642306f, 
    -0.40570280f, -0.01497535f, 0.09731376f, -0.04339701f, 0.13576029f, 0.00885431f, 0.11829597f, -0.30567256f, 
    0.01790409f, -0.33505082f, 0.00575988f, -0.03170716f, -0.05232282f, 0.28976086f, 0.09624476f, -0.56504506f, 
    0.07541724f, 0.14366782f, 0.11342357f, -0.06251594f, -0.01021309f, -0.05039304f, 0.24293087f, 0.31116170f, 
    -0.01573687f, -0.37846568f, -0.06431794f, -0.58201611f, -0.13553515f, 0.02845283f, 0.14984797f, -0.09670742f, 
    0.37439421f, -0.15985093f, 0.06724621f, 0.02516380f, 0.02838427f, -0.52246565f, -0.37850398f, 0.04320785f, 
    0.03413095f, -0.44861338f, -0.18301779f, -0.14644526f, -0.07610051f, -0.18622735f, -0.03307359f, 0.03070492f, 
    0.11882678f, 0.04515163f, 0.04025785f, -0.03191248f, 0.21919854f, -0.34652990f, -0.00124609f, 0.20722139f, 
    -0.07323780f, -0.26365927f, -0.34328645f, 0.19206032f, 0.20518181f, 0.16806130f, -0.03934589f, -0.01365463f, 
    -0.02921063f, -0.03715591f, -0.10182979f, -0.03346911f, 0.17586857f, -0.04273601f, -0.03175185f, -0.43038243f, 
    -0.09054180f, 0.18128450f, -0.04021963f, 0.22446059f, -0.07750725f, 0.31116876f, -0.01972928f, -0.19937240f, 
    0.06573219f, -0.57573438f, 0.25048798f, -0.02989093f, -0.28526717f, 0.02650602f, -0.19409724f, -0.39139378f, 
    0.11871467f, 0.04208150f, 0.08810703f, -0.20563242f, 0.37369949f, 0.01528045f, -0.44010407f, 0.19337052f, 
    -0.07014720f, -0.23671184f, -0.00859589f, -0.02216121f, -0.00288225f, 0.12913927f, -0.28236303f, 0.21588987f, 
    0.29622975f, -0.00427726f, 0.19533102f, -0.44465742f, 0.07382850f, -0.03071179f, -0.08071784f, 0.15999904f, 
    -0.13458239f, 0.04918878f, 0.13378187f, 0.00728046f, -0.74360996f, -0.23721462f, 0.02972838f, -0.62815505f, 
    0.10735608f, 0.04917154f, 0.18284892f, 0.20602690f, 0.19039789f, -0.00843829f, -0.33128428f, -0.47061694f, 
    0.02646863f, -0.05433879f, -0.05175796f, -0.07982086f, -0.28808299f, -0.07890718f, -0.25183222f, -0.08604143f, 
    0.28368986f, 0.23635077f, 0.06167314f, 0.16967270f, -0.08224971f, -0.86754680f, 0.00438375f, 0.05478650f, 
    -0.01137862f, 0.04830710f, -0.04754080f, -0.05896931f, 0.26397976f, -0.01907368f, 0.10660270f, -0.10359988f, 
    0.00896215f, 0.14379074f, -0.10600841f, 0.16765724f, 0.36824131f, -0.14811210f, 0.18834598f, -0.08158245f, 
    -0.58634174f, 0.15206058f, -0.00394808f, -0.06865006f, -0.10594075f, -0.03160860f, 0.03592766f, -0.25131431f, 
    -0.01165090f, -0.08762413f, 0.01958390f, -0.15527597f, -0.09504735f, 0.10616435f, -0.10430277f, -0.35672432f, 
    0.30832088f, 0.03567736f, -0.19452210f, -0.07775131f, -0.24205816f, -0.23935537f, 0.00236567f, -0.31474447f, 
    -0.03878226f, 0.00191896f, -0.12397397f, -0.01757602f, 0.14335459f, -0.47476116f, 0.01112363f, 0.38585722f, 
    0.21351364f, 0.02017409f, -0.06621252f, -0.04559781f, -0.24914184f, -0.04859889f, 0.07398753f, -0.14648052f, 
    -0.21613646f, 0.22130398f, -0.08026878f, -0.02083367f, 0.05860526f, -0.10315433f, 0.08410209f, 0.01057267f, 
    0.03136710f, 0.16990453f, 0.29731786f, 0.01083009f, -0.26343906f, 0.25074226f, -0.03504504f, 0.35088739f, 
    0.16101341f, 0.20462173f, -0.00658376f, -0.35991940f, 0.13958383f, -0.18485963f, 0.17106855f, 0.25198421f, 
    -0.05275001f, 0.28473672f, -0.06785838f, 0.03808585f, -0.07071879f, 0.18280719f, 0.16931656f, 0.10213014f, 
    -0.36488566f, 0.02689896f, 0.11115224f, 0.14281999f, -0.11490736f, 0.21467735f, -0.09753688f, -0.06778644f, 
    0.23256628f, 0.10233189f, -0.34988391f, 0.03993886f, -0.17307723f, 0.36559966f, 0.00928330f, 0.21555966f, 
    -0.05065463f, 0.26773769f, -0.00372072f, -0.29457611f, 0.32307860f, 0.12319781f, -0.34350416f, -0.17977610f, 
    -0.46522158f, 0.03595472f, 0.03476849f, 0.06387666f, 0.05552985f, 0.01712043f, 0.09445900f, -0.17162918f, 
    -0.38075310f, -0.11651526f, -0.06426751f, -0.20133692f, 0.00554586f, -0.20114158f, 0.01031402f, 0.20037632f, 
    -0.01751700f, 0.23861778f, -0.35348222f, 0.00640357f, -0.12800060f, -0.30817446f, 0.15966725f, 0.28326419f, 
    0.06676149f, -0.04748814f, 0.03149138f, -0.02936587f, -0.58270532f, 0.12082250f, -0.09331620f, 0.19579974f, 
    -0.08027626f, 0.00205661f, 0.07691505f, 0.03862094f, -0.10614700f, -0.37237442f, 0.35111794f, -0.06656720f, 
    0.27225256f, -0.00259309f, -0.11650600f, 0.35759333f, 0.04198403f, -0.11239974f, 0.11628767f, 0.14650001f, 
    -0.48097479f, 0.01921651f, -0.64959902f, -0.05339641f, 0.01241282f, 0.04433939f, -0.09267079f, 0.21743393f, 
    0.04394807f, -0.26380673f, 0.08248692f, -0.27034849f, -0.10018271f, -0.07801673f, 0.28492272f, -0.30283377f, 
    0.14811511f, -0.06906774f, 0.05743730f, -0.08405473f, -0.30067191f, 0.09711646f, 0.24891427f, 0.08696643f, 
    -0.07906962f, 0.23192216f, -0.11033083f, 0.16892505f, -0.10576717f, 0.06903882f, -0.00125811f, 0.27325851f, 
    0.09119052f, 0.05785924f, -0.42329454f, -0.02183428f, 0.26744226f, -0.02858972f, -0.18032503f, -0.61846340f, 
    -0.23540276f, 0.27592140f, -0.04402047f, 0.38355222f, 0.03121991f, 0.23853180f, 0.14509204f, -0.19909580f, 
    0.31184474f, 0.17757611f, -0.08553438f, -0.04041241f, -0.08318426f, -0.10971853f, -0.14918418f, -0.15065545f, 
    0.10434925f, -0.21830508f, -0.80714470f, -0.23687589f, -0.03930294f, -0.40050939f, -0.01671460f, 0.17482641f, 
    0.18495414f, 0.03643663f, 0.26977623f, -0.01795078f, -0.04752634f, 0.20304188f, -0.11880526f, -0.07791534f, 
    -0.10027073f, 0.06851883f, 0.21629938f, -0.15469477f, -0.09403180f, -0.01368091f, 0.00297922f, -0.06840914f, 
    0.24677894f, -0.12951513f, -0.00481371f, 0.11018624f, -0.27116898f, 0.06788015f, -0.22221981f, 0.10466117f, 
    0.06133319f, 0.13012895f, 0.01711481f, -0.06400937f, -0.09311841f, 0.12046168f, 0.05995693f, 0.02353352f, 
    -0.02323415f, -0.11856827f, 0.01039705f, -0.10161646f, -0.38967752f, 0.05301130f, -0.30359378f, 0.25416604f, 
    0.05794854f, -0.23049244f, 0.10002284f, 0.27200547f, -0.01716338f, 0.15214762f, -0.19926852f, -0.37467772f, 
    -0.04938447f, -0.26694915f, -0.04056209f, -0.10847247f, 0.02712886f, 0.18468244f, 0.03751962f, -0.30433801f, 
    -0.37012497f, 0.37075064f, -0.38095844f, 0.22609061f, 0.09576543f, -0.15816599f, -0.05126932f, 0.13864344f, 
    0.14718536f, 0.08423221f, 0.07018109f, -0.08749229f, -0.07314840f, -0.20837609f, -0.02399910f, 0.22742665f, 
    -0.11908194f, 0.13068065f, -0.33911282f, -0.44514713f, 0.19862260f, 0.07243108f, 0.21687137f, 0.19655164f, 
    -0.07564127f, -0.08097231f, 0.04343706f, 0.00876340f, -0.01216569f, -0.06304853f, 0.06984562f, -0.39068508f, 
    0.25422803f, -0.22366476f, -0.03041650f, 0.35818326f, -0.04549498f, 0.05687659f, 0.01217771f, -0.15533596f, 
    0.07001305f, -0.30799609f, 0.19304778f, -0.01623128f, 0.15606372f, 0.21092011f, 0.26476943f, -0.12871617f, 
    0.04240101f, -0.56266141f, 0.02608160f, 0.00439396f, -0.43599689f, 0.22345911f, -0.42583954f, -0.05752733f, 
    0.11928346f, 0.00226471f, -0.09898200f, -0.08279359f, -0.05032482f, 0.01390057f, -0.39178023f, -0.61762846f, 
    0.20778055f, -0.17576036f, 0.16199192f, -0.04264717f, -0.04983295f, -0.07772241f, 0.02357793f, -0.34776211f, 
    -0.21769781f, 0.10764787f, 0.02410857f, 0.08811376f, 0.29826930f, 0.11054714f, -0.00756924f, -0.06331270f, 
    -0.08431160f, 0.30910236f, -0.28640872f, 0.16472553f, -0.39878577f, -0.23852514f, 0.36152446f, -0.42759031f, 
    0.27189052f, 0.04469723f, 0.10056509f, 0.08789210f, 0.21512195f, -0.08608226f, -0.17617154f, 0.12706099f, 
    -0.28851041f, -0.13467863f, -0.04288701f, -0.33973253f, -0.05774199f, -0.01845968f, -0.04810952f, -0.05274341f, 
    0.06878512f, 0.07321867f, -0.02054408f, 0.04692627f, 0.10307364f, 0.36461791f, 0.24330494f, -0.12328406f, 
    0.21660875f, -0.04776859f, -0.02244922f, 0.09137978f, -0.38964802f, -0.48113286f, -0.05349397f, -0.07015307f, 
    0.38679513f, 0.26654768f, -0.02142248f, 0.05407366f, 0.10589603f, 0.29032689f, -0.17918997f, 0.06764907f, 
    -0.11695955f, 0.12785578f, 0.06598861f, -0.13487138f, -0.12863670f, 0.09268515f, 0.04797364f, 0.22934130f, 
    -0.02669958f, 0.01383003f, 0.05038639f, 0.10953560f, -0.62328315f, -0.05575701f, -0.06095561f, -0.06903891f, 
    0.10920556f, -0.41768044f, -0.22392830f, 0.36352119f, -0.03101619f, 0.01391100f, 0.31327102f, 0.32691792f, 
    -0.19958644f, -0.03412554f, 0.06190713f, 0.10275387f, 0.03485734f, 0.02212677f, 0.03346859f, 0.07112440f, 
    0.32419515f, -0.35195613f, 0.04053689f, -0.46442416f, 0.06010310f, 0.08175990f, 0.08321968f, -0.38124681f, 
    0.01464077f, 0.17497696f, -0.12631924f, -0.04118049f, 0.15048912f, -0.24451363f, -0.08064525f, -0.08231083f, 
    -0.29119998f, 0.21186303f, 0.05859168f, 0.15606454f, -0.04146639f, -0.07112125f, 0.01352832f, -0.61339855f, 
    -0.04077886f, -0.27246886f, -0.03351784f, 0.09953021f, 0.04797453f, 0.27461743f, 0.31350783f, 0.24216487f, 
    -0.29696518f, -0.38828659f, -0.21647176f, -0.22644141f, -0.05127322f, -0.12291358f, 0.00489722f, -0.26824149f, 
    0.28973120f, -0.10644513f, 0.25778010f, -0.07777094f, -0.00628192f, -0.32944521f, -0.08888062f, 0.21259296f, 
    0.11832096f, 0.10869589f, 0.14607559f, -0.02897567f, -0.47547728f, 0.31468299f, -0.04567043f, -0.04010432f, 
    0.23541370f, -0.10570320f, 0.03773077f, -0.08762427f, 0.15939087f, -0.11224734f, -0.48248658f, 0.28154987f, 
    0.12805477f, -0.27727181f, 0.05586504f, 0.16114983f, 0.06842577f, -0.16840868f, -0.11964428f, 0.30568641f, 
    0.00967012f, 0.13533893f, 0.11864833f, -0.04809767f, 0.17479621f, -0.33845603f, -0.25070089f, -0.21333194f, 
    -0.36804676f, 0.03056983f, 0.09471958f, 0.15640153f, -0.27789447f, 0.11837655f, 0.23338638f, 0.06810261f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.08248735f, 0.07895651f, -0.05206512f, -0.08623602f, 0.00167130f, -0.06185417f, 0.02485567f, -0.04977977f, 
    -0.02271793f, 0.00954066f, 0.07517318f, 0.00130514f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
