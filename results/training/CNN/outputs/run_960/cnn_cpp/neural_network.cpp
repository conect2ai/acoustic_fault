#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.61451954f, -0.21398467f, -0.03356943f, -0.46592078f, -0.45329121f, -0.06630190f, -0.27953848f, 0.41633749f, 
    -0.44903308f, -0.11847659f, 0.21894315f, -0.19634572f, -0.10298991f, -0.22142592f, -0.25845358f, 0.04400028f, 
    0.17497028f, 0.20668963f, 0.18043432f, -0.20584983f, 0.32188821f, 0.13952236f, 0.03044257f, 0.09551992f, 
    -0.15993027f, -0.17960441f, -0.24584402f, -0.30710384f, -0.53986567f, -0.30715382f, 0.57629609f, 0.02818753f, 
    -0.30800238f, -0.51646525f, -0.45584646f, -0.16197738f, -0.34098527f, 0.53880554f, 0.21400012f, 0.20757878f, 
    -0.18474782f, -0.04362444f, 0.08446387f, 0.09351898f, 0.13896658f, 0.12629035f, 0.08924921f, -0.21694529f, 
    -0.12398440f, -0.10918856f, 1.01209950f, -0.10792020f, -0.11628757f, 0.91274410f, 0.50918502f, -0.11874716f, 
    0.26411048f, 0.06502673f, 0.32839110f, 0.10386870f, -0.28335327f, -0.04529728f, 0.26924273f, 0.00652172f, 
    -0.15861453f, -0.19459978f, 0.02416966f, 0.02407277f, -0.12443729f, -0.09614345f, -0.20653991f, -0.01876429f, 
    -0.28644028f, 0.41554818f, 0.07348523f, 0.48705631f, 0.64574265f, -0.06644460f, 0.01085841f, 0.61020666f, 
    -0.32038391f, -0.46185118f, -0.61235791f, -0.09787618f, 0.01417637f, 0.22057621f, 0.56727260f, 0.22197524f, 
    0.28191051f, -0.14939550f, -0.12790082f, 0.24315035f, -0.04364174f, 0.13657364f, -0.16440921f, -0.00760027f, 
    -0.06649904f, 0.11032914f, 0.00781037f, 0.30786279f, 0.50224042f, 0.60388857f, 0.01861622f, 0.57821113f, 
    0.23681888f, -0.52355307f, 0.02097433f, -0.03944675f, 0.15179579f, 0.37127987f, -0.25044000f, -0.18946943f, 
    0.17747296f, 0.02288060f, 0.16932318f, -0.06613032f, -0.18558629f, -0.09570246f, -0.02697000f, -0.11456875f, 
    0.43045217f, 0.08430818f, -0.00800462f, 0.34808227f, 0.06577872f, 0.00427126f, 0.21533756f, -0.19587623f, 
    -0.20088063f, 0.47362414f, -0.52424198f, -0.91805279f, -0.32395768f, -0.61244696f, -0.19264649f, -0.06861445f, 
    0.47787794f, 0.17480467f, -0.14301212f, 0.06111612f, 0.22226785f, -0.05400096f, -0.03731517f, -0.28415924f, 
    -0.04514835f, -0.12701115f, 0.01108527f, 0.17223802f, 0.25162774f, 0.07147861f, -0.33694693f, -0.58476245f, 
    0.26160872f, -0.12437700f, -0.41121411f, -0.07944461f, 0.11103775f, -0.37443697f, -0.24105541f, -0.05192534f, 
    -0.19063833f, 0.25890726f, -0.39408579f, -0.19066851f, -0.46867794f, -0.26679569f, 0.04023874f, 0.06470457f, 
    0.35145357f, -0.39515701f, 0.32078850f, -0.06486478f, 0.01098234f, -0.12383940f, 0.02490905f, 0.54837972f, 
    0.66638261f, 0.08681055f, -0.07072794f, 0.43738249f, -0.20734012f, -0.09531543f, -0.15717213f, -0.51883614f, 
    -0.16757308f, -0.10118808f, 0.07141256f, 0.06433505f, 0.11909027f, 0.22091986f, 0.08908636f, -0.24459809f, 
    -0.31724685f, -0.22379303f, 0.35625401f, -0.62849534f, 0.33627772f, 0.23196785f, -0.39690205f, 0.19936249f, 
    -0.42642373f, 0.63213044f, -0.08494819f, -0.69074559f, 0.35945004f, 0.31563109f, -0.50274706f, -0.64346808f, 
    -0.21167284f, -0.22680375f, -0.14750366f, 0.16946110f, -0.21979509f, 0.15349948f, 0.01809120f, -0.20267494f, 
    0.15673791f, -0.12818983f, -0.01832091f, 0.35195282f, -0.11438987f, 0.16001122f, -0.17686151f, 0.02233531f, 
    -0.22756799f, -0.41914335f, -0.82617778f, -0.15407602f, 0.75106853f, 0.44907913f, -0.60802853f, -0.09397914f, 
    -0.14539094f, -0.41444778f, -0.13268232f, 0.35805869f, 0.24954610f, 0.19495644f, 0.10373995f, 0.08998763f, 
    -0.20700587f, -0.13823788f, -0.01971244f, 0.05341718f, 0.15594202f, -0.16811757f, 0.15632284f, 0.29560986f, 
    0.23190361f, 0.15802118f, 0.01137104f, 0.76683903f, -0.38613713f, -0.71931469f, -0.22462702f, -0.22390969f, 
    -0.11838477f, -0.25960463f, -0.31229350f, -0.40928575f, 0.33013821f, -0.44166988f, -0.26954898f, -0.04332435f, 
    0.12408265f, 0.11913025f, 0.23651011f, -0.35471174f, 0.28459293f, 0.35525402f, -0.05234823f, -0.05666322f, 
    -0.16351642f, -0.26187840f, 0.18184398f, 0.54035854f, 0.01238019f, -0.22243661f, -0.44755429f, -0.36268443f, 
    -0.17593712f, -0.39735386f, 0.42852184f, -0.25706103f, 0.28833690f, 0.20346090f, 0.36523828f, 0.46337411f, 
    -0.28222832f, -0.38545275f, 0.24272370f, 0.14739738f, -0.01567437f, 0.02872725f, 0.27841210f, -0.21016647f, 
    0.34072483f, 0.12457643f, 0.16685483f, -0.09012789f, -0.10964924f, -0.32758465f, -0.04217711f, 0.50255144f, 
    0.19097459f, 0.01603566f, 0.05145957f, 0.11761346f, 0.24787903f, 0.20723253f, -0.35649422f, -0.16338977f, 
    -0.05002738f, -0.49800432f, -0.19599093f, -0.52527273f, -0.08909936f, -0.07181139f, 0.32727373f, -0.01300435f, 
    0.37296703f, -0.07970180f, 0.03662630f, -0.48434156f, -0.27747896f, -0.40828010f, -0.34363341f, -0.01066757f, 
    -0.30894685f, 0.14996085f, -0.19265518f, 0.52178323f, -0.21151397f, 0.31915042f, 0.35846490f, 0.08368034f, 
    -0.01970555f, -0.29677665f, -0.29836732f, -0.52777982f, -0.18797690f, 0.39429986f, -0.08828284f, 0.40609193f, 
    0.05650835f, -0.26529917f, -0.21554148f, -0.02582103f, -0.20821586f, -0.28328142f, -0.53379065f, 0.08012300f, 
    0.46841443f, 0.12704015f, 0.46809399f, -0.84804708f, 0.20051616f, 0.40399575f, 0.24863799f, -0.66247559f, 
    0.10743093f, -0.30861273f, -0.08478981f, 0.19677588f, -0.16059302f, 0.19595394f, 0.16081126f, 0.08774766f, 
    -0.08678608f, 0.01083330f, 0.06312528f, 0.12168467f, -0.10551139f, 0.13326398f, 0.02835364f, 0.64693433f, 
    -0.01104098f, 0.20139474f, 0.54502392f, 0.03106171f, 0.74315989f, 0.66993654f, 0.16695434f, -0.02552987f, 
    0.36269233f, -0.45446452f, -0.10950147f, -0.15697917f, -0.28158981f, -0.51032823f, -0.09014215f, -0.01011733f, 
    0.05438340f, -0.20118019f, -0.12012167f, -0.06046000f, -0.06578603f, 0.02400378f, -0.02014577f, 0.03771980f, 
    0.40209937f, 0.45460147f, 0.47089359f, 0.95186090f, 0.39911044f, 0.61200714f, -0.45225540f, -0.24213107f, 
    -0.24370724f, -0.14841650f, -0.08901196f, 0.09757786f, 0.16091000f, 0.06504476f, -0.30629823f, 0.21285459f, 
    0.41098174f, 0.25812349f, -0.25014654f, 0.19914538f, -0.35615852f, 0.01959962f, 0.07998161f, -0.19285935f, 
    -0.05044058f, -0.38485825f, 0.15623745f, -0.08167212f, -0.61301285f, -0.23825513f, 0.66351241f, 0.84131181f, 
    0.59679902f, 0.28690931f, 0.18697305f, -0.13289659f, -0.26243511f, -0.40540510f, -0.21931985f, -0.09501133f, 
    -0.08999468f, -0.35387009f, 0.08026902f, 0.06460077f, -0.01652355f, 0.09208624f, -0.05713981f, -0.04460989f, 
    -0.23010428f, 0.19551757f, 0.80525976f, 0.10041619f, 0.71169192f, 0.63418883f, 0.56967765f, 0.60956526f, 
    0.10480431f, -0.63624406f, -0.14111853f, -0.01012963f, -0.15972504f, 0.26003259f, 0.09548093f, 0.14366622f, 
    -0.33189943f, -0.01510195f, -0.04448736f, 0.01482749f, 0.07341885f, -0.28014183f, 0.32790178f, 0.07079899f, 
    -0.04805138f, -0.17231536f, 0.13004161f, -0.32014871f, -0.11075657f, -0.50730312f, 0.27045605f, 0.01399025f, 
    -0.97812277f, 0.12506415f, 0.19594033f, -0.48162505f, -0.39262807f, 0.41365162f, -0.00526473f, 0.09584313f, 
    0.23557691f, 0.37134114f, 0.02460554f, 0.31996781f, 0.28457609f, 0.20694374f, -0.10883393f, 0.10945389f, 
    0.06681120f, -0.06407519f, 0.05299824f, 0.02287417f, -0.27990142f, -0.85043406f, -0.65097439f, -0.19747457f, 
    -0.24595605f, -0.87566507f, 0.66082728f, 0.66125578f, -0.48817125f, 0.36959615f, 0.50664550f, 0.00465820f, 
    0.06568756f, -0.11048663f, 0.28703567f, 0.07765660f, 0.23040037f, -0.01305019f, 0.00997116f, -0.17804401f, 
    0.18880856f, 0.11318120f, -0.06467793f, 0.27254233f, 0.09938173f, -0.31373423f, -0.94183409f, -0.61963189f, 
    -0.43548417f, -0.47416756f, 0.19725868f, 0.12383143f, 0.29169118f, 0.41415682f, 0.10492404f, 0.23778692f, 
    0.16762845f, 0.11674336f, 0.28459406f, 0.03560007f, -0.12246232f, 0.23449203f, -0.08070260f, -0.15812446f, 
    0.44118601f, -0.25177509f, 0.04959597f, 0.02869411f, 0.10788327f, -0.03343589f, 0.26886147f, 0.07849749f, 
    -0.15990071f, -0.23097761f, -0.29339522f, -0.52246732f, -0.26076138f, -0.33745444f, 0.18901040f, -0.48841235f, 
    -0.14382370f, -0.35331702f, 0.26073602f, -0.11084753f, 0.13356513f, -0.25355229f, -0.38071576f, -0.50560480f, 
    0.07871325f, 0.12955624f, -0.01609590f, 0.48256272f, -0.27496228f, -0.15565294f, -0.06955604f, 0.81844568f, 
    0.34233183f, -0.77659994f, -0.61372739f, -0.61259544f, -0.13776107f, -0.12839769f, 0.11768865f, -0.13386367f, 
    -0.37559438f, 0.05412640f, 0.27036932f, 0.28912938f, 0.12325142f, -0.02305167f, -0.01612489f, -0.11859962f, 
    0.04541156f, 0.03059308f, 0.16032873f, -0.05466450f, -0.05544487f, 0.13969807f, -0.08852246f, -0.12103175f, 
    -0.22927703f, 0.24284267f, 0.12708093f, 0.06348052f, -0.47402504f, -0.35180560f, 0.10604873f, -0.24955079f, 
    -0.09980633f, 0.11713429f, -0.17158549f, -0.09955238f, -0.38306302f, -0.36203536f, 0.02363683f, 0.05601872f, 
    0.39816487f, 0.38417208f, 0.20400442f, -0.13665307f, -0.29908368f, -0.12749894f, 0.34557864f, -0.10337657f, 
    0.29414356f, 0.81340867f, 0.67780316f, 0.76792651f, -0.36269504f, -0.65982521f, -0.08436970f, -0.44839013f, 
    -0.07042319f, -0.35301030f, 0.37775272f, 0.36968467f, 0.21586761f, -0.18502584f, -0.05306832f, 0.08062153f, 
    -0.21467997f, 0.03855398f, 0.01380452f, 0.09616161f, 0.01779379f, 0.03171960f, 0.18489443f, 0.02305787f, 
    0.24845830f, -0.00907335f, -0.69693637f, 0.62304538f, -0.56329399f, 0.59343451f, -0.52597600f, 0.58989662f, 
    -0.05517118f, -0.23683198f, 0.21938460f, 0.24109240f, -0.34288487f, -0.12585010f, -0.14387403f, 0.28790388f, 
    -0.53956515f, -0.18997242f, 0.00669603f, -0.12852214f, 0.07140103f, -0.07762083f, -0.08052347f, 0.11047869f, 
    -0.16755457f, -0.18345392f, -0.17912182f, -0.29632363f, 0.31717044f, 0.29933390f, 0.28099602f, 0.45527309f, 
    -0.49364528f, -0.41768062f, -0.66040158f, 0.20838490f, -0.29203141f, 0.31997854f, 0.13287397f, 0.20098181f, 
    -0.30836055f, 0.11708239f, -0.23843399f, 0.09483561f, 0.32482979f, -0.29509139f, 0.03644457f, 0.03879055f, 
    0.14763823f, 0.24902867f, 0.03337843f, -0.27712238f, -0.60531366f, 0.05926068f, -0.36742875f, -0.56825471f, 
    -0.30480456f, 0.43453225f, 0.34466052f, 0.25323015f, 0.40945330f, 0.56651628f, 0.45914242f, 0.04865638f, 
    -0.17149203f, -0.15246439f, 0.17996213f, 0.34717926f, -0.29768711f, -0.05878553f, 0.03609585f, 0.22347309f, 
    -0.31886435f, -0.16314156f, 0.17656913f, 0.31148624f, 0.08126473f, 0.26303554f, 0.11336221f, 0.31656960f, 
    0.84587181f, 0.33602169f, 0.03824788f, 0.39032230f, -0.20344771f, 0.46526310f, 0.37731186f, 0.15139461f, 
    -0.23387173f, -0.29186678f, -0.34286195f, -0.45789710f, -0.00121463f, -0.02873098f, 0.09978390f, 0.10922975f, 
    0.47317967f, -0.07305013f, -0.09415633f, 0.27408984f, 0.16340365f, 0.08433731f, 0.91047049f, 0.34522694f, 
    -0.00442048f, -0.20768739f, 0.73143160f, -0.26495421f, -0.10911582f, 0.33476424f, 0.37521639f, 0.42208648f, 
    -0.18347825f, -0.33366257f, -0.09399977f, 0.05040070f, 0.38331300f, 0.23537156f, 0.18468714f, -0.17927498f, 
    -0.25107417f, 0.18928380f, 0.21181917f, 0.10441021f, 0.14228633f, 0.09904869f, -0.08927946f, 0.87640101f, 
    0.69575250f, 0.04927829f, 0.78804916f, 0.18033449f, -0.07689079f, 0.25564435f, 0.28137562f, 0.24885835f, 
    -0.13512348f, 0.11303013f, -0.12887634f, -0.29421872f, -0.12956537f, -0.28992173f, -0.07419022f, -0.13543680f, 
    -0.03200361f, 0.13155453f, -0.24510121f, 0.19051394f, -0.27783185f, -0.29123208f, -0.23462495f, -0.10448053f, 
    0.47239885f, -0.10998382f, -0.63880086f, -0.67789257f, -0.57564914f, 0.40202883f, 0.36523893f, 0.43745777f, 
    0.81440514f, 0.27115139f, -0.07820231f, -0.11144008f, -0.24135055f, -0.16463132f, 0.01746355f, 0.12652075f, 
    -0.11237570f, 0.17807314f, 0.15566902f, 0.17762080f, 0.17724799f, 0.08681093f, 0.14310768f, 0.20471935f, 
    -0.22543602f, -0.10411312f, -0.29009330f, -0.29917240f, -0.50492609f, -0.21847394f, -0.23361591f, -0.48118603f, 
    -0.38586751f, 0.07406897f, -0.48955312f, -0.29871514f, -0.15987922f, 0.08062481f, 0.16976759f, -0.38060066f, 
    -0.10211869f, 0.10004786f, -0.02745506f, 0.10579946f, 0.31104058f, -0.10515895f, -0.00205662f, 0.38143811f, 
    0.18352620f, 0.15741435f, -0.75869393f, -0.18624143f, 0.12687469f, 0.26781484f, 0.17693940f, 0.35517207f, 
    0.62139994f, -0.17327178f, -0.14308777f, 0.27190006f, 0.02220778f, -0.08005603f, 0.39193711f, -0.34584633f, 
    -0.04097575f, 0.03427725f, -0.22368151f, 0.25651881f, -0.39565402f, -0.35359579f, -0.24335101f, -0.25679046f, 
    -0.34573942f, -0.10749603f, -0.26236907f, 0.35560179f, -0.16134843f, -0.53127599f, -0.47483999f, -0.26387674f, 
    -0.53607559f, 0.30903724f, 0.18875197f, 0.21013692f, 0.39533556f, -0.25916493f, -0.15621178f, -0.02745372f, 
    -0.37414944f, -0.21923748f, -0.02113526f, 0.31471550f, 0.11585213f, 0.08202641f, 0.09669682f, 0.04564133f, 
    -0.40221444f, -0.15220636f, -0.42263943f, 0.31697789f, -0.71704006f, 0.49167034f, -0.37676048f, -0.62605900f, 
    0.03250340f, 0.28012758f, 0.58361274f, -0.66411364f, 0.40387154f, 0.47929934f, 0.13717434f, -0.08965822f, 
    -0.20106331f, -0.18465063f, -0.22880562f, 0.10491788f, 0.11544024f, 0.16244569f, 0.23405673f, -0.06509125f, 
    0.18520971f, 0.00198611f, -0.19313367f, -0.17822176f, -0.11952899f, -0.33952323f, 0.83403796f, 0.01346122f, 
    -0.16580214f, 0.58362728f, -0.55227566f, 0.39670500f, 0.49902502f, 0.14475530f, 0.31850064f, -0.21081115f, 
    -0.25503024f, 0.50031096f, -0.35985872f, 0.46708372f, 0.05511009f, -0.22336611f, -0.22033590f, -0.19796754f, 
    -0.42005804f, -0.16332558f, -0.29295188f, -0.16823840f, 0.05675047f, -0.01583994f, -0.47032645f, -0.01735638f, 
    -0.35433549f, -0.50074470f, -0.53872359f, 0.46683633f, 0.58116722f, -0.29625604f, 0.16309579f, 0.64041477f, 
    -0.18245620f, -0.34698015f, -0.05282534f, -0.26835531f, 0.17702530f, 0.00403687f, 0.25332642f, -0.09528220f, 
    -0.21772644f, 0.06209017f, -0.06976911f, -0.21071580f, 0.01610315f, -0.09112969f, 0.36479542f, -0.24586780f, 
    -0.14309567f, 0.28550237f, 0.29271501f, 0.46781728f, -1.02661014f, -0.20650266f, -0.25184476f, -0.63588589f, 
    0.04435872f, 0.45161873f, 0.26241356f, -0.35896897f, 0.12141234f, -0.38882697f, 0.20292911f, -0.12833813f, 
    0.01161601f, -0.15913032f, 0.40085384f, 0.16624768f, -0.13971588f, 0.16152914f, -0.30558616f, -0.10912341f, 
    -0.50274462f, -0.47528347f, -0.26129630f, -0.05208595f, 0.02893888f, -0.05592965f, -0.46630633f, -0.61427730f, 
    -0.04585589f, -0.17252553f, 0.30481163f, 0.29068479f, -0.18755865f, -0.18517983f, -0.33021870f, -0.21716420f, 
    -0.00947688f, -0.39173344f, -0.31939206f, -0.30040908f, -0.04501499f, 0.34158185f, 0.19385995f, -0.08387816f, 
    -0.04216337f, 0.76209056f, 0.35789320f, 0.07673796f, -0.18230906f, 0.92121416f, 0.29233232f, -0.22121195f, 
    0.34125730f, -0.03855823f, 0.33028820f, -0.16788109f, 0.31889921f, 0.05174438f, 0.00767240f, 0.08694427f, 
    0.19103299f, -0.19313034f, -0.04924947f, 0.26838297f, 0.01578876f, 0.23335275f, -0.02090207f, -0.03222363f, 
    0.06341684f, -0.03025950f, -0.58824140f, 0.45224214f, 0.58295906f, 0.13005905f, 0.67609555f, 0.62784177f, 
    -0.13051736f, 0.52545708f, -0.68120712f, 0.11152942f, -0.19686301f, 0.12117516f, 0.09986224f, 0.19012418f, 
    0.10852883f, -0.02136354f, 0.15758486f, 0.07987319f, 0.23375867f, 0.21239866f, 0.38423702f, -0.25325221f, 
    -0.15620092f, -0.10593742f, -0.02576087f, -0.90856600f, -0.99854350f, -0.34879181f, 0.68699682f, 0.19545409f, 
    0.83558297f, 0.49854857f, 0.16493779f, 0.27764037f, -0.29566047f, -0.05191185f, 0.24852581f, -0.09278342f, 
    0.42043629f, 0.35389701f, -0.26104125f, -0.00995244f, -0.23890570f, -0.21364282f, 0.10545190f, -0.07180462f, 
    -0.09945491f, 0.07424267f, -0.02778237f, -0.17260264f, 0.57155764f, -0.59899509f, -0.63701612f, -0.58718300f, 
    0.62296480f, 0.50592119f, -0.40022731f, -0.02960520f, -0.02907961f, 0.08062873f, -0.07162091f, 0.17933756f, 
    0.03291208f, -0.12654702f, -0.10447781f, 0.02198939f, -0.03037956f, -0.07105224f, 0.02711003f, -0.12667704f, 
    -0.11587093f, -0.09942369f, 0.29427150f, 0.31440711f, -0.24092227f, 0.90077293f, 0.68041962f, -0.47204682f, 
    -0.41332930f, -0.65810370f, 0.15058510f, 0.27118972f, -0.27011839f, 0.19145769f, 0.43479586f, -0.02794343f, 
    0.26989666f, -0.29053283f, 0.09227764f, 0.17605013f, -0.03545484f, -0.13491802f, -0.24852215f, 0.02159102f, 
    -0.05388959f, -0.15827380f, 0.16295590f, -0.30585724f, 0.05880891f, 0.33924004f, 0.74094003f, 0.40695724f, 
    0.46569026f, 0.45291755f, 0.62072396f, 0.27214372f, -0.35687470f, -0.52397513f, 0.39503413f, -0.09578347f, 
    0.11421184f, -0.36193275f, -0.08932236f, 0.27283588f, -0.25172836f, -0.08220404f, 0.02894937f, -0.03479911f, 
    0.28711295f, 0.13817316f, 0.29932559f, 0.18617670f, 0.14728428f, 0.02914604f, 0.06848225f, 0.74244058f, 
    0.72592938f, 0.43731946f, 0.26433942f, -0.45749664f, -0.27695638f, -0.19664825f, -0.36060172f, -0.38879687f, 
    0.13509832f, 0.24310595f, 0.28356057f, -0.07887559f, 0.05954543f, -0.23469447f, 0.10160852f, -0.14553797f, 
    0.31626830f, 0.03302243f, 0.23419455f, 0.02372576f, 0.00496295f, 0.29559186f, -0.03037960f, 0.22863753f, 
    0.78320783f, -0.16590369f, 0.37128320f, 0.21573569f, -0.17162260f, -0.40256760f, -0.61723477f, 0.23499264f, 
    0.36272687f, 0.25023356f, 0.14010276f, 0.09002955f, 0.12152977f, 0.13542525f, 0.08980792f, 0.33042067f, 
    -0.14622463f, -0.46462092f, 0.20192671f, 0.49432269f, -0.46093205f, -0.16773689f, 0.26165399f, -0.21078971f, 
    -0.30820855f, -0.89753157f, 0.90102768f, 0.44687983f, -0.37843958f, -0.28196102f, -0.67786127f, 0.67165995f, 
    0.08068408f, -0.26088730f, -0.51920748f, -0.12849133f, 0.19897461f, -0.16271441f, 0.05971568f, 0.28649285f, 
    -0.16516542f, -0.14327401f, 0.27618828f, -0.08095324f, -0.27083719f, -0.02726323f, 0.02190437f, -0.09292404f, 
    0.20601082f, 0.21928357f, 0.81325310f, 0.12311407f, 0.33400497f, -0.41204554f, 0.18481252f, 0.33575702f, 
    -0.32177976f, 0.12594941f, 0.50805134f, 0.50714439f, -0.40616605f, 0.17273751f, -0.29801700f, -0.21451434f, 
    -0.12342786f, -0.07836328f, -0.04729212f, -0.31367141f, -0.22588587f, -0.17686842f, -0.26396656f, -0.16974710f, 
    -0.15808803f, -0.12202004f, -0.23454674f, 0.58943743f, -1.13415730f, 0.16158114f, 0.24928991f, 0.36727864f, 
    0.19791579f, 0.64099729f, 0.18017825f, -0.02488902f, 0.11253330f, 0.26731884f, 0.10900884f, -0.25662768f, 
    -0.18395844f, -0.05050644f, -0.25604546f, -0.35280788f, 0.04789485f, -0.08551416f, 0.00178073f, -0.01785938f, 
    0.00107287f, 0.01136788f, -0.07400282f, 0.17313409f, 0.18078774f, 0.76127017f, -0.73006606f, 0.18404964f, 
    -0.34072810f, 0.25861686f, -0.70541084f, -0.13242611f, -0.48345727f, -0.07354071f, 0.02447759f, 0.07081370f, 
    0.33504710f, 0.27139652f, -0.22759561f, -0.19203189f, -0.30222064f, 0.08530322f, 0.11147323f, 0.04519325f, 
    0.16330695f, 0.14870039f, 0.11162949f, -0.08243909f, -0.15156806f, 0.36319569f, 0.36130539f, 0.49185777f, 
    -0.10336710f, -0.10143370f, -0.61324245f, -0.33030966f, -0.43436491f, -0.26701862f, 0.05575735f, 0.24219203f, 
    0.17930716f, 0.29424343f, 0.21650876f, 0.16662109f, 0.02623268f, -0.26540709f, -0.05992369f, -0.07694659f, 
    -0.44640589f, 0.33537534f, -0.13532878f, 0.06713988f, 0.05457052f, 0.25420818f, 0.18177390f, 0.08318335f, 
    0.52050233f, -0.76455671f, -0.09285606f, 0.51005971f, -0.69751090f, 0.33965591f, 0.70660454f, -0.15830687f, 
    -0.34315756f, 0.13363273f, -0.28068352f, -0.43829310f, -0.33125782f, -0.23576723f, 0.09390146f, 0.12547615f, 
    -0.28629997f, -0.28918746f, 0.28476351f, 0.26286951f, -0.19758356f, 0.20593846f, 0.01192193f, -0.18033728f, 
    0.54164481f, -0.54687899f, -0.46565583f, -0.32661200f, 0.33342183f, -0.34295547f, -0.52482271f, 0.20970699f, 
    0.22729078f, -0.00244522f, -0.14762534f, -0.15961449f, 0.08303466f, -0.23295715f, 0.04437915f, 0.43160170f, 
    0.18103808f, 0.21094130f, -0.35731199f, -0.47247532f, 0.17816682f, 0.34841907f, 0.16705047f, 0.13596101f, 
    -0.15885796f, -0.10905791f, -0.38396490f, -0.19175139f, -0.28230453f, -0.36822852f, -0.42220455f, 0.17644705f, 
    0.05059308f, 0.12165537f, -0.28564012f, -0.03720856f, -0.03911389f, -0.36629775f, -0.47777933f, -0.04619348f, 
    -0.42804667f, -0.17116541f, -0.43848225f, -0.45410120f, -0.37650323f, 0.33786377f, 0.24680659f, 0.24109542f, 
    -0.10137001f, 0.47775984f, 0.41709611f, -0.83290350f, -0.51490021f, 0.02739504f, -0.52813965f, -0.04541854f, 
    0.18925154f, 0.53960973f, -0.37468490f, -0.22324821f, -0.10068525f, 0.10634525f, -0.01626586f, -0.38795432f, 
    0.22251679f, -0.18607379f, -0.11292692f, -0.07985431f, -0.34563190f, 0.07775719f, -0.02139824f, 0.15429220f, 
    0.05921859f, 0.21025379f, -0.19362265f, 0.05187021f, -0.28360367f, -0.39502254f, -0.27789614f, -0.23522276f, 
    0.44483906f, 0.12615643f, -0.37977958f, 0.38159186f, -0.28153121f, 0.37604690f, -0.41744506f, 0.21827276f, 
    -0.21625507f, 0.00943740f, -0.33819529f, 0.42890960f, 0.08025277f, -0.37006640f, -0.38212636f, -0.24762225f, 
    -0.44319382f, -0.40407243f, -0.01597238f, -0.09312531f, -0.37104744f, 0.54991758f, -0.18172425f, -0.35593048f, 
    0.02164645f, -0.47643575f, 0.44570342f, 0.16885318f, 0.34960034f, 0.08676532f, -0.26868224f, 0.15008189f, 
    0.21049307f, -0.26683962f, -0.09204333f, 0.20277415f, -0.28233048f, 0.02484661f, 0.49786124f, -0.20752792f, 
    0.19997385f, -0.02489886f, -0.17535388f, 0.49292150f, 0.41768816f, 0.15619498f, -0.34970352f, 0.55411255f, 
    0.19265771f, -0.07373496f, -0.84678048f, -0.00306255f, -0.21928500f, -0.04766412f, 0.13983558f, -0.45273989f, 
    0.10611745f, -0.03019636f, 0.24513839f, 0.44895101f, -0.12849554f, -0.30891088f, 0.01863400f, 0.36316431f, 
    0.40207663f, 0.40932414f, 0.21894979f, -0.28610271f, 0.24594544f, 0.16849874f, 0.62625593f, 0.21019396f, 
    0.24985479f, 0.64039284f, 0.20165049f, 0.39300433f, 0.51719290f, -0.43390894f, -0.07015051f, -0.10815682f, 
    -0.34527814f, 0.09160518f, 0.11986790f, -0.12440569f, 0.14691678f, -0.10226413f, 0.15876600f, 0.13022584f, 
    -0.31058913f, 0.02937526f, -0.32275516f, 0.32051581f, 0.21143232f, 0.18062514f, 0.52229351f, 0.59939247f, 
    0.44141626f, 0.54713911f, 0.02978306f, -0.34646642f, 0.12312383f, -0.41649389f, 0.28865552f, -0.19571325f, 
    0.29767239f, 0.10614203f, -0.17311150f, 0.11397705f, 0.04515009f, 0.34252879f, 0.16873609f, -0.02420169f, 
    0.06792504f, -0.32781848f, 0.09090786f, 0.03036165f, -0.08465059f, 0.19418743f, 0.27748278f, -0.08097421f, 
    0.24601354f, 0.86930555f, -0.45084447f, -0.67483664f, -0.33879325f, 0.06302333f, -0.35437018f, 0.07314590f, 
    -0.12389746f, 0.30081335f, 0.48974016f, -0.60925388f, 0.09985095f, 0.00290795f, 0.12810028f, -0.13837905f, 
    -0.08133432f, -0.21034193f, -0.04610721f, -0.08451838f, 0.23166533f, 0.18398789f, 0.01356291f, -0.08444155f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10447925f, 0.26949781f, 0.19960760f, -0.10802597f, 0.26104712f, 0.17847560f, 0.07547213f, 0.14661852f, 
    0.28200561f, 0.17539649f, 0.15559289f, -0.00437238f, 0.19160041f, 0.11388674f, 0.31053302f, 0.15867159f, 
    0.06202094f, 0.07933932f, 0.04553513f, 0.26911950f, 0.12773362f, 0.12002008f, -0.00766988f, 0.20264210f, 
    0.08405910f, 0.05203803f, -0.14957081f, 0.09971110f, -0.08811877f, -0.06271078f, 0.12044803f, 0.16461445f, 
    0.22898439f, -0.08004158f, 0.09189168f, 0.02686262f, -0.17252195f, -0.04982712f, 0.06186809f, 0.02044668f, 
    0.14120220f, 0.14589550f, -0.07191064f, 0.37361184f, 0.28693846f, 0.09459037f, 0.14050543f, 0.27827114f, 
    0.00771588f, 0.08327265f, 0.08773983f, 0.01124576f, 0.03181267f, 0.22911115f, 0.05390755f, 0.12488203f, 
    -0.03934055f, 0.03737750f, -0.09230631f, 0.09420337f, 0.08133277f, -0.03677773f, 0.19352354f, 0.11125200f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16404930f, -0.02451254f, -0.09862831f, 0.26892620f, 0.06498188f, -0.01754471f, 0.12714840f, 0.01038590f, 
    -0.06532147f, -0.00555819f, 0.01558145f, 0.06854977f, 0.35313284f, 0.11055205f, -0.00732328f, 0.18778904f, 
    0.07221897f, 0.03446575f, 0.08396938f, -0.00376724f, -0.11214086f, -0.07800847f, -0.08585345f, 0.01889709f, 
    -0.22027338f, -0.01752111f, -0.03478289f, -0.21357216f, -0.00120244f, 0.04787204f, -0.06124032f, 0.04393472f, 
    0.10681705f, 0.12248231f, -0.09075247f, 0.12899703f, 0.05814420f, 0.05433645f, -0.09334067f, 0.07589649f, 
    0.00313413f, -0.06501124f, -0.11115499f, -0.04558448f, 0.09981494f, 0.05565880f, -0.09818920f, -0.11268485f, 
    -0.03436882f, 0.04682450f, -0.05917006f, -0.04582948f, -0.00025177f, 0.05025262f, -0.00413375f, 0.03265340f, 
    -0.03888747f, -0.04602018f, -0.11027357f, 0.11764509f, 0.19818898f, -0.01106614f, -0.05028390f, 0.01087704f, 
    0.01023157f, 0.05185801f, 0.05224626f, 0.02652559f, 0.03641730f, 0.08592363f, 0.00471884f, -0.01708742f, 
    0.21588694f, 0.18840300f, -0.00911389f, 0.02314964f, 0.10829642f, 0.04256451f, -0.09442683f, 0.03202803f, 
    0.02974272f, 0.07248660f, 0.09872255f, 0.04825122f, -0.03849265f, 0.00175491f, -0.02855822f, -0.01193393f, 
    0.06332389f, 0.01009091f, 0.07648610f, -0.05351186f, 0.11604243f, -0.02663210f, 0.00838229f, 0.05842197f, 
    0.26546323f, 0.01019068f, -0.05056171f, 0.10804874f, -0.00045775f, 0.04627329f, -0.03526362f, 0.15493028f, 
    0.12918058f, -0.05028977f, 0.04771194f, -0.02812137f, -0.20459534f, 0.12515131f, -0.01537073f, 0.05077370f, 
    0.04790801f, -0.05979955f, 0.03100013f, 0.06486500f, 0.08425421f, -0.00515994f, 0.04015969f, -0.07538404f, 
    0.17172548f, -0.17494835f, -0.04397405f, 0.09556938f, -0.01535397f, 0.14303561f, 0.07361562f, 0.03086953f, 
    0.06678955f, -0.06228867f, -0.08607194f, -0.06971730f, 0.03205440f, -0.10401194f, -0.12720180f, 0.05764201f, 
    0.04153865f, 0.08987801f, 0.02770676f, 0.05858431f, -0.14552894f, 0.09572557f, 0.00374302f, -0.13832900f, 
    0.05734190f, 0.03190927f, 0.05342227f, -0.05218671f, -0.03802583f, -0.03042087f, 0.10657250f, -0.07803874f, 
    0.02315237f, 0.01136487f, 0.06532810f, 0.19047894f, -0.02476837f, 0.01102607f, 0.00138690f, 0.13763270f, 
    0.06938408f, 0.01233036f, 0.03140098f, 0.10678180f, 0.06860647f, 0.08186667f, 0.04236214f, 0.00008421f, 
    0.00342423f, 0.04380307f, 0.12101395f, -0.04148569f, 0.01467608f, 0.02555954f, 0.02282294f, 0.06177006f, 
    -0.07971346f, 0.00597130f, 0.00835577f, -0.07058683f, -0.17416310f, -0.01252100f, -0.08315409f, -0.09195636f, 
    -0.01258732f, 0.06117075f, 0.06016197f, -0.01810100f, 0.08591323f, -0.05976261f, 0.09723771f, 0.01420389f, 
    0.02565369f, -0.00688256f, -0.07053927f, -0.30024514f, 0.05414389f, -0.06127340f, 0.02682072f, 0.02908696f, 
    -0.01797567f, -0.08379019f, 0.00109206f, -0.13260664f, -0.35011938f, -0.14124085f, -0.04750639f, -0.03634907f, 
    0.04426187f, 0.07584543f, 0.01903728f, -0.02546834f, 0.02685583f, 0.04668618f, 0.07458094f, 0.03343102f, 
    -0.07251229f, 0.07171175f, -0.11466551f, -0.25554842f, -0.02496284f, 0.02263836f, -0.04909023f, -0.05738127f, 
    0.00336187f, -0.09951275f, 0.00471522f, 0.00052554f, -0.20628904f, -0.00328346f, 0.12979421f, 0.14501916f, 
    -0.00312972f, 0.08257383f, 0.10032875f, -0.00326003f, -0.07437354f, -0.11065807f, -0.04069032f, -0.12694761f, 
    0.13094620f, -0.19590321f, -0.08726174f, 0.01980130f, -0.02943317f, 0.08751159f, 0.08565225f, -0.08707304f, 
    0.00550421f, 0.02792954f, 0.00939544f, -0.04852825f, 0.19010833f, -0.02623883f, 0.01354744f, -0.00710500f, 
    0.08505043f, 0.05320026f, -0.03478216f, 0.03168315f, 0.09232960f, -0.05574277f, -0.03066983f, -0.02148288f, 
    0.15636306f, 0.11967838f, 0.01268247f, -0.03542689f, -0.03899474f, -0.06732759f, -0.03524491f, -0.05626747f, 
    -0.05997133f, 0.05562514f, 0.00697536f, 0.13261935f, 0.30047509f, -0.17806891f, 0.11813743f, 0.12887314f, 
    0.03397012f, 0.08088109f, 0.02830932f, 0.06624961f, 0.03514891f, 0.01507797f, 0.03424824f, -0.02369675f, 
    0.11236200f, -0.06467239f, 0.17845289f, 0.16478799f, -0.06800342f, 0.08398946f, 0.03311385f, -0.06994593f, 
    -0.02613536f, -0.03983023f, 0.07114992f, -0.11187290f, 0.20626445f, -0.08844870f, 0.03361194f, 0.14709729f, 
    -0.00836830f, -0.00808926f, -0.04068263f, 0.01227243f, -0.01076260f, 0.12594397f, 0.04443714f, -0.01758550f, 
    -0.49101514f, -0.16318637f, 0.04257264f, 0.06982358f, -0.10262045f, 0.12401585f, 0.12997247f, 0.04457244f, 
    0.04651800f, 0.03279651f, -0.02854894f, 0.12236302f, 0.07807258f, 0.06364416f, -0.01796521f, 0.03909363f, 
    -0.00257622f, 0.05638572f, 0.05308894f, -0.00478732f, -0.07098923f, 0.00488147f, 0.07311492f, -0.09056198f, 
    -0.26858988f, -0.22871763f, -0.11098143f, -0.13839032f, -0.03845335f, -0.00714643f, -0.08303107f, 0.09314660f, 
    0.08374892f, -0.03540709f, 0.10812256f, -0.11711057f, -0.09511572f, -0.00368449f, -0.01213539f, -0.21555108f, 
    0.03211688f, -0.00707876f, 0.04498488f, -0.08607076f, -0.07563525f, -0.13455027f, -0.08135816f, -0.04413245f, 
    -0.07312815f, 0.00389774f, 0.01265955f, 0.19005021f, 0.03161298f, 0.07460299f, -0.05696080f, -0.01293649f, 
    -0.09642348f, -0.04753502f, 0.03085584f, 0.03184221f, -0.17798625f, -0.03296470f, -0.01956685f, -0.09633875f, 
    -0.03163635f, 0.04643641f, 0.05835977f, -0.00002502f, 0.16818218f, 0.01038121f, -0.11992813f, 0.08498058f, 
    -0.15350883f, -0.21479683f, 0.14097285f, -0.09612132f, 0.04389623f, -0.02745522f, -0.02475729f, 0.09712472f, 
    -0.01874293f, 0.03405586f, 0.00678273f, 0.03671581f, 0.28860465f, 0.15131289f, 0.02940854f, 0.07581556f, 
    -0.00639044f, -0.01852232f, -0.10831441f, 0.06218881f, -0.00013523f, -0.00519061f, 0.00459079f, -0.00355827f, 
    0.04928665f, 0.12133641f, -0.11268431f, 0.02222036f, -0.01956685f, 0.10348374f, -0.02142178f, 0.07942263f, 
    -0.03485464f, 0.08038612f, 0.03916686f, 0.15030196f, 0.00525091f, -0.00888659f, 0.03931481f, 0.01663002f, 
    0.06069759f, -0.03274195f, 0.10074256f, 0.00927072f, -0.08774400f, 0.03966868f, 0.08159861f, -0.02188989f, 
    -0.39750242f, -0.12249438f, -0.09532949f, -0.02522193f, 0.00074546f, -0.02531104f, -0.04330627f, 0.10967661f, 
    -0.13773769f, 0.11404409f, -0.04576895f, -0.02216757f, 0.14610526f, -0.04107418f, -0.04064556f, -0.06490222f, 
    0.03040632f, 0.04477118f, -0.01795057f, 0.23902774f, -0.02188951f, -0.02257907f, -0.05455139f, 0.07410806f, 
    -0.23796320f, -0.03983924f, -0.04209496f, -0.04938541f, 0.03821363f, -0.13947678f, 0.14880782f, -0.01218810f, 
    0.00389126f, -0.01704852f, 0.08028373f, -0.07667486f, -0.14341265f, 0.16056080f, 0.11582018f, -0.06426603f, 
    0.07107373f, -0.00496803f, -0.07024568f, 0.05698569f, 0.04208481f, -0.06052858f, 0.05714358f, -0.10085780f, 
    0.28787896f, 0.24245673f, -0.13094150f, 0.14006814f, 0.01658310f, 0.06767434f, 0.05554105f, 0.03423969f, 
    0.05191701f, -0.06481293f, 0.03215058f, -0.01805282f, -0.06582889f, 0.14245825f, -0.14370513f, 0.18332301f, 
    -0.03830276f, 0.01654237f, 0.14187647f, -0.01389729f, 0.04048345f, -0.03626869f, -0.02215258f, 0.05058604f, 
    0.24203762f, -0.01905476f, -0.29868481f, -0.06376471f, 0.01889376f, 0.05112967f, -0.02412135f, 0.02602690f, 
    -0.02886025f, 0.02218994f, 0.03390199f, 0.06900509f, 0.36758173f, 0.08805373f, -0.08434611f, 0.16769743f, 
    0.12394883f, -0.02874740f, -0.02551805f, 0.03724425f, -0.04254460f, 0.00199628f, 0.02812943f, 0.03951596f, 
    0.18434481f, 0.13773577f, -0.08443800f, 0.24544412f, 0.11040025f, -0.08303665f, -0.03504526f, 0.04422020f, 
    0.07814826f, 0.06158433f, -0.00171737f, 0.00401862f, -0.04751261f, 0.03160384f, 0.18692052f, 0.13973689f, 
    0.01495825f, -0.04691440f, -0.06264642f, 0.08190528f, 0.12136355f, 0.00963743f, -0.10052643f, -0.01356863f, 
    0.01919823f, 0.06890353f, 0.02934970f, -0.19085348f, -0.03621138f, 0.07219210f, 0.05452163f, 0.02111480f, 
    -0.09154376f, -0.02812051f, -0.10398483f, -0.05879783f, 0.07812987f, -0.04191511f, 0.05417729f, 0.02420556f, 
    0.08223478f, -0.00732567f, 0.04550517f, -0.01508809f, 0.05562162f, 0.12877120f, -0.00564853f, 0.07681736f, 
    -0.00996598f, 0.01824358f, 0.12827343f, -0.09332525f, 0.05414377f, -0.06339002f, 0.10097626f, 0.05855425f, 
    0.00431988f, -0.05209712f, 0.06382923f, 0.01794621f, -0.00768345f, -0.09488789f, 0.13295755f, -0.04462614f, 
    -0.04730589f, 0.09759604f, 0.06717515f, 0.03771914f, -0.01378150f, -0.05782706f, -0.01826889f, 0.03904235f, 
    -0.12272853f, 0.13910030f, -0.05609637f, 0.04534469f, -0.04123371f, 0.04308911f, 0.00992355f, 0.01757433f, 
    0.13763060f, 0.02324507f, 0.02047482f, 0.05322319f, 0.25542378f, -0.13487504f, -0.07509499f, -0.03310933f, 
    0.03859407f, 0.08280212f, 0.11788266f, 0.04320633f, -0.05066941f, 0.07831299f, 0.07583258f, 0.02730229f, 
    0.12443016f, -0.12092502f, 0.02598155f, 0.19559324f, 0.12605223f, 0.00373965f, 0.01725203f, -0.00991150f, 
    0.04694160f, 0.07050539f, -0.03392626f, 0.09116788f, 0.04309485f, -0.06581002f, 0.03385529f, 0.04042660f, 
    0.05905695f, 0.06402636f, -0.07037231f, 0.01005244f, 0.09231256f, 0.13159409f, -0.02170961f, 0.02478337f, 
    -0.06488622f, -0.01951310f, -0.04881383f, -0.08259018f, -0.04895219f, 0.05241990f, -0.02346051f, 0.04555625f, 
    0.04005062f, 0.05018050f, 0.09115046f, 0.01807795f, -0.03989534f, -0.08286900f, 0.03774351f, 0.12385941f, 
    -0.03141537f, -0.00905666f, -0.00562692f, 0.00784680f, 0.04643833f, 0.04372806f, 0.04582500f, -0.01432828f, 
    0.01752012f, 0.11859656f, 0.04125574f, -0.00473360f, -0.00212889f, -0.09150661f, -0.05121992f, -0.01159181f, 
    -0.02227350f, -0.01300040f, 0.03309792f, 0.03999982f, 0.20829274f, -0.09204900f, 0.18592399f, 0.13129561f, 
    -0.06558186f, -0.00915489f, -0.07497301f, 0.06759561f, -0.04169798f, 0.02283281f, -0.02088353f, 0.04115403f, 
    0.03252959f, -0.08084513f, 0.19565497f, -0.00404032f, -0.07900967f, 0.03014763f, 0.03415057f, -0.03836470f, 
    0.07289609f, -0.01762173f, 0.01815333f, -0.00090950f, 0.06307688f, 0.03044092f, 0.03057725f, -0.09366705f, 
    0.02788070f, 0.01279657f, 0.11129048f, 0.15625596f, 0.04687428f, 0.05742166f, -0.02977267f, -0.03349146f, 
    0.03647141f, 0.03828885f, -0.01612865f, -0.05988714f, -0.09107959f, -0.03742112f, 0.10786016f, 0.00001683f, 
    -0.08795953f, -0.13051704f, 0.03281249f, -0.00955327f, -0.15176649f, -0.05662488f, -0.22674079f, -0.13157092f, 
    -0.00506098f, 0.07065579f, -0.05177061f, 0.09669420f, -0.12235805f, 0.11918487f, -0.04878499f, -0.01118347f, 
    0.00472416f, 0.05829405f, 0.07667158f, -0.09595659f, -0.08900806f, 0.05978801f, -0.01659421f, 0.02750705f, 
    0.02502664f, 0.04159108f, 0.02842472f, -0.02754451f, 0.19330785f, -0.02802975f, 0.06588205f, 0.11226752f, 
    0.05904867f, -0.07157978f, 0.02911052f, -0.01923501f, -0.05235208f, 0.05507797f, 0.12188014f, -0.08674549f, 
    0.02373989f, 0.01413889f, -0.03898760f, 0.01858098f, -0.03109554f, -0.00645427f, -0.01589074f, 0.03230100f, 
    0.01857373f, -0.01563152f, -0.01605813f, -0.02005422f, 0.02453008f, 0.02138329f, -0.00702725f, -0.04082619f, 
    -0.01303137f, -0.00620921f, 0.02381576f, 0.02873945f, -0.02746696f, 0.00555221f, 0.00089208f, -0.01673098f, 
    0.02068502f, -0.01575829f, -0.03322068f, -0.03851548f, -0.04105454f, -0.03166647f, -0.00071948f, -0.03428889f, 
    0.00094353f, -0.04231812f, -0.01461988f, -0.00180327f, -0.02729717f, 0.00986766f, -0.03977567f, -0.03686049f, 
    0.02299160f, -0.00068156f, -0.00964770f, 0.00364316f, 0.01868487f, -0.03855726f, 0.01670718f, -0.00157548f, 
    -0.02917459f, -0.01933545f, 0.01273983f, -0.01990571f, -0.01729288f, -0.02575245f, 0.02168933f, -0.01020567f, 
    -0.01718134f, -0.00675630f, 0.00110808f, -0.03859030f, -0.00031043f, -0.04208561f, 0.02128241f, 0.00164880f, 
    0.02442293f, 0.01117623f, 0.04224137f, 0.00157766f, -0.02214956f, -0.03187412f, -0.04116280f, 0.01241420f, 
    0.01659452f, 0.02652420f, -0.01921329f, -0.00284349f, 0.01128232f, 0.00684432f, 0.00160265f, 0.02850927f, 
    -0.00553981f, -0.02244144f, 0.00722223f, -0.01200305f, 0.02131907f, -0.02715183f, 0.01323612f, -0.04187926f, 
    -0.04321193f, 0.00218366f, 0.00304085f, -0.03118746f, -0.02189846f, 0.01428307f, -0.01024668f, -0.03158055f, 
    -0.03213848f, -0.02631017f, 0.00897179f, -0.04105801f, -0.03645523f, 0.01100234f, 0.02959206f, -0.00136853f, 
    0.02554127f, 0.02573202f, 0.01717723f, -0.02778888f, -0.00101743f, -0.01980417f, -0.02723295f, -0.00814546f, 
    -0.00652007f, -0.01866635f, -0.02883502f, -0.01067675f, -0.00683562f, -0.00482105f, 0.02911794f, 0.00533275f, 
    -0.02828275f, 0.02780619f, 0.02163449f, 0.00341400f, 0.01607907f, -0.01821258f, 0.01110786f, -0.02244383f, 
    0.04162734f, -0.01316760f, 0.03760587f, 0.01691946f, -0.01752867f, -0.03132246f, 0.00727239f, 0.00865476f, 
    0.00857060f, 0.02476011f, 0.01844958f, 0.02528019f, -0.01026325f, 0.01689148f, 0.01068274f, 0.02650411f, 
    -0.01586365f, -0.02680035f, -0.00336755f, -0.03847391f, -0.03267780f, -0.03271347f, 0.00954215f, 0.00444555f, 
    0.02086651f, 0.01161497f, 0.00756036f, 0.01255937f, -0.03436329f, -0.03397691f, -0.04159774f, 0.02324085f, 
    0.00296988f, -0.04008944f, 0.00032852f, -0.01305523f, 0.02867432f, -0.01375880f, 0.00608815f, 0.00745337f, 
    -0.02904718f, -0.02614174f, 0.00099238f, 0.02762429f, -0.02981805f, 0.01578406f, -0.00675232f, -0.02055657f, 
    -0.03531542f, -0.01288074f, -0.02496414f, -0.01554720f, 0.00889245f, -0.00412673f, -0.02571409f, 0.01051651f, 
    -0.00719693f, 0.00187157f, -0.01853184f, -0.00027376f, 0.01012469f, -0.01818906f, -0.01549669f, 0.02534303f, 
    -0.03670897f, 0.00365103f, -0.00497166f, 0.00616216f, -0.03678332f, 0.00018264f, -0.03795817f, 0.00765283f, 
    0.00875227f, 0.00771927f, -0.00300862f, 0.02310691f, 0.00016685f, -0.03985590f, -0.03997520f, -0.00598765f, 
    -0.03464497f, -0.02343847f, 0.02986125f, -0.00775568f, 0.02552463f, -0.01443066f, -0.00015950f, -0.03768295f, 
    -0.02034198f, -0.02808559f, -0.01567118f, -0.01202784f, 0.02666554f, -0.02631900f, 0.00761756f, 0.01049870f, 
    -0.03328083f, 0.00665729f, 0.02066837f, -0.01788324f, -0.02627190f, -0.01031638f, -0.00911452f, -0.00955562f, 
    -0.00342516f, -0.03447718f, -0.03861460f, 0.03100957f, -0.02023483f, -0.01410859f, -0.02398072f, 0.02995952f, 
    0.01095553f, -0.02643427f, -0.01450029f, -0.00928804f, -0.02942903f, -0.00485109f, -0.02578436f, 0.02738032f, 
    0.02836094f, -0.01315547f, 0.01730949f, 0.00516854f, -0.01735941f, 0.02842125f, 0.01146826f, -0.00706532f, 
    -0.00794135f, 0.01247586f, -0.00533984f, 0.01238899f, -0.04000153f, 0.01881739f, 0.00356625f, -0.00621026f, 
    0.00393398f, -0.03567458f, -0.03703543f, 0.01339203f, -0.00372256f, -0.00052507f, 0.00728355f, 0.00270224f, 
    0.01813881f, -0.01913778f, -0.02596142f, -0.03180134f, 0.02352222f, -0.00613687f, -0.00914816f, -0.02041700f, 
    -0.01536818f, 0.00971087f, 0.01079227f, -0.03410196f, 0.02163241f, -0.01750649f, -0.01845219f, -0.01500109f, 
    -0.00686536f, -0.02897816f, -0.00121335f, -0.02238490f, -0.02602001f, -0.02445580f, 0.02726569f, 0.02840186f, 
    -0.04158612f, -0.00660072f, -0.01677178f, -0.04451553f, -0.03312502f, 0.00559928f, -0.03677446f, -0.00098682f, 
    -0.03300069f, -0.01079941f, -0.02315491f, 0.01370757f, -0.03250274f, -0.02253427f, 0.00403865f, -0.02088750f, 
    0.00579314f, -0.02802695f, -0.01133072f, -0.01519145f, -0.00178249f, 0.03425850f, -0.00577872f, -0.04067086f, 
    0.02459836f, -0.01065717f, 0.02562904f, 0.00970060f, -0.00419981f, 0.02176172f, -0.03394438f, -0.01234911f, 
    -0.01438600f, -0.01738172f, -0.03093317f, 0.01534477f, -0.04123244f, -0.01262815f, 0.01936578f, -0.03588830f, 
    0.02167050f, -0.01065741f, 0.01872489f, -0.00208320f, 0.00576581f, 0.03121224f, -0.03281596f, -0.00349941f, 
    0.00570469f, -0.03903175f, -0.02402070f, 0.02458884f, -0.03344189f, 0.01692312f, -0.02328100f, -0.00701495f, 
    -0.02575560f, -0.02720504f, 0.01899928f, 0.00174858f, -0.03096386f, -0.03616786f, -0.04138803f, -0.00420475f, 
    -0.03357147f, -0.00784695f, 0.02761621f, -0.00718843f, -0.03843968f, 0.01351671f, 0.00264087f, -0.00035781f, 
    -0.03238620f, -0.00199747f, 0.01036076f, -0.01781228f, -0.03738810f, -0.03760489f, -0.03036983f, 0.01764426f, 
    0.00833852f, -0.03888878f, -0.02924683f, 0.02042820f, -0.01304925f, -0.01028141f, 0.02348432f, 0.02981001f, 
    -0.00832461f, -0.03586871f, -0.03676220f, 0.01067873f, 0.00569590f, -0.01522925f, 0.01664131f, 0.02841930f, 
    -0.01461426f, 0.00901136f, 0.02756434f, 0.02038928f, -0.03836394f, -0.01237927f, -0.00530632f, -0.02337336f, 
    -0.02468768f, 0.02157458f, -0.01813418f, -0.00677631f, 0.01142405f, -0.02237060f, -0.01928491f, 0.01969982f, 
    -0.02900004f, -0.01372785f, 0.00543396f, 0.02318488f, -0.04084829f, 0.00999462f, -0.01954322f, -0.01300161f, 
    0.00785597f, -0.01892540f, 0.02756952f, -0.02718544f, -0.00629563f, 0.02377251f, 0.00336709f, -0.01989133f, 
    0.01246738f, -0.02493243f, -0.00729942f, -0.01258332f, -0.02030116f, 0.02566704f, 0.00365861f, -0.00616195f, 
    0.00905147f, -0.01873165f, -0.03092636f, -0.03422076f, -0.03530190f, -0.02428378f, 0.01782520f, 0.02471151f, 
    -0.01032926f, -0.03140812f, -0.00373363f, -0.01591686f, -0.00685552f, 0.01173735f, 0.01991100f, 0.00401252f, 
    0.01517475f, 0.00292720f, 0.01801740f, -0.01508617f, -0.04073407f, -0.03417240f, -0.00485598f, 0.02419390f, 
    0.01236771f, -0.03219427f, -0.04189385f, -0.03557958f, -0.01940500f, 0.02719906f, -0.03464478f, -0.01546873f, 
    -0.03733315f, -0.02606946f, -0.03765836f, -0.00224290f, 0.01444790f, 0.02823324f, -0.04092305f, -0.03772721f, 
    -0.01435335f, 0.02253829f, 0.03095889f, 0.02587093f, -0.00018297f, -0.01893638f, 0.02082037f, 0.02285576f, 
    0.02552258f, 0.00062484f, -0.00576510f, -0.01382105f, 0.00133481f, -0.01280601f, -0.02443689f, 0.00962152f, 
    -0.01966171f, -0.01922825f, -0.00968262f, -0.01607233f, 0.00202542f, -0.02649326f, -0.03636380f, 0.01856526f, 
    0.02508450f, 0.00334920f, -0.04059901f, 0.02476780f, 0.00260011f, -0.02427765f, 0.00283611f, 0.01917879f, 
    -0.01114459f, 0.00208838f, 0.01603424f, -0.01884348f, -0.01952802f, 0.02254881f, 0.00182874f, 0.01419969f, 
    0.02353752f, -0.00828729f, -0.03008318f, -0.03588972f, 0.00353150f, 0.00841768f, -0.00420960f, 0.02092609f, 
    -0.00139890f, 0.00122611f, -0.01098233f, 0.00184960f, 0.02618469f, 0.02429051f, 0.02460098f, -0.00973856f, 
    0.02556650f, 0.02828597f, 0.02831752f, 0.02069396f, -0.02884774f, 0.01534553f, 0.02212531f, -0.03178538f, 
    -0.00498289f, -0.02458297f, 0.01522416f, 0.00787050f, 0.01565432f, 0.00094690f, -0.00261825f, -0.02329413f, 
    -0.01213447f, -0.01707239f, -0.02688623f, 0.02822261f, -0.02303643f, -0.00193142f, 0.00166366f, -0.00275330f, 
    -0.04134908f, -0.00949258f, -0.01543052f, 0.01595115f, 0.01378893f, -0.01730214f, 0.02438587f, 0.02517542f, 
    -0.00635187f, -0.01932313f, -0.02059261f, -0.04166367f, -0.02520091f, 0.01283198f, -0.03917498f, 0.02503287f, 
    0.01895116f, -0.00092536f, 0.01385144f, -0.00942392f, -0.00775160f, -0.03830085f, 0.02594684f, 0.02402753f, 
    -0.02690848f, -0.02211539f, -0.02935349f, -0.03996887f, -0.03179896f, 0.01198354f, -0.02900460f, -0.04029431f, 
    0.01680525f, -0.00082934f, 0.00972242f, -0.03194396f, 0.02665416f, -0.02087073f, -0.03185882f, 0.02454343f, 
    0.02689154f, -0.03437505f, -0.00534651f, -0.03730103f, 0.01691530f, 0.01098038f, -0.02667135f, 0.00688624f, 
    0.01612081f, 0.02118144f, 0.02610025f, 0.02562406f, -0.00008935f, -0.03199396f, -0.02827937f, -0.03087302f, 
    0.01924789f, -0.00987991f, -0.02271261f, 0.00777184f, -0.02648603f, 0.01700011f, 0.02545775f, -0.00326702f, 
    -0.00284189f, 0.02624896f, -0.03243235f, -0.01096299f, 0.01554017f, -0.03108747f, -0.00128516f, -0.03858234f, 
    0.01198244f, 0.00592064f, 0.02543207f, -0.00186588f, -0.02946426f, 0.00311900f, -0.03267438f, 0.00283510f, 
    0.00056251f, -0.02721234f, -0.01571225f, -0.02587945f, -0.03492289f, -0.00923520f, -0.03093975f, 0.00331377f, 
    -0.00779568f, -0.00913971f, -0.01215799f, 0.01075331f, 0.02698352f, -0.03212880f, -0.01201205f, 0.00347218f, 
    0.02254622f, 0.02366175f, -0.02918600f, -0.00477742f, 0.00759954f, 0.01305139f, 0.00464975f, -0.04140511f, 
    -0.01536480f, 0.02471724f, -0.01527496f, -0.01394976f, 0.02128190f, 0.01819195f, -0.03377641f, -0.00239395f, 
    -0.01774558f, -0.00013958f, -0.00626343f, 0.01452095f, -0.02477941f, 0.01318959f, 0.02805226f, 0.01021755f, 
    0.00011928f, 0.01725097f, 0.02856950f, -0.00195960f, 0.03746663f, -0.03631449f, 0.02152148f, -0.00840644f, 
    0.00840452f, -0.01383777f, -0.02931127f, 0.01525521f, -0.02507378f, 0.00509460f, -0.00580959f, -0.00470589f, 
    0.01232805f, 0.00410002f, -0.01900180f, -0.02997252f, -0.03514650f, -0.02100955f, -0.02995823f, 0.02861851f, 
    -0.03680389f, -0.02142424f, 0.02529563f, 0.00574450f, -0.01699503f, -0.01540316f, 0.01098650f, -0.04001904f, 
    -0.03716001f, -0.03132377f, 0.03024869f, -0.03652239f, -0.00563179f, 0.00489858f, 0.01344633f, 0.01892754f, 
    -0.03345848f, 0.01533721f, -0.02089517f, -0.02615094f, -0.03555537f, 0.02607562f, 0.01598406f, 0.01377387f, 
    0.00305213f, -0.01925450f, 0.01907782f, -0.00374773f, 0.02004158f, -0.00890950f, -0.00173488f, 0.01352517f, 
    0.02180230f, 0.03164510f, -0.04208820f, -0.02980642f, 0.01546329f, -0.00147385f, -0.01835254f, -0.02125581f, 
    -0.02383002f, 0.01134018f, 0.01940378f, -0.01855769f, -0.02423615f, 0.00714153f, 0.02806546f, -0.00627512f, 
    -0.00545244f, 0.03235306f, 0.00854993f, -0.00366555f, 0.02329163f, 0.01850910f, -0.03626338f, 0.02545034f, 
    -0.00121564f, -0.03467444f, -0.02889011f, -0.02243952f, -0.02562345f, 0.00302875f, 0.01808273f, -0.00680760f, 
    -0.00624219f, -0.03038116f, 0.02463940f, -0.03948734f, -0.00227890f, -0.01804280f, -0.02423430f, -0.00008993f, 
    0.04512045f, -0.16277198f, 0.00062850f, 0.09093158f, -0.01843795f, -0.01265111f, -0.07591514f, 0.19389857f, 
    0.10052776f, -0.00565899f, -0.08999269f, 0.00448754f, 0.10484666f, 0.13710782f, -0.12133524f, 0.02067368f, 
    0.02077761f, 0.04256356f, -0.07184432f, 0.01231954f, -0.01739414f, 0.03763333f, 0.08100887f, -0.04671736f, 
    0.12754464f, -0.03881197f, 0.11471722f, -0.25323552f, -0.13708179f, 0.04513183f, 0.11363897f, -0.09024139f, 
    0.02834356f, 0.02514932f, -0.01504270f, -0.03017229f, -0.03881827f, -0.01430407f, -0.19836541f, 0.16760944f, 
    0.08635107f, 0.11648247f, 0.06452049f, 0.04406691f, -0.16178846f, -0.03874983f, -0.03408342f, 0.12887190f, 
    -0.21757154f, 0.06227684f, 0.04510609f, -0.11621264f, 0.07551608f, 0.01083931f, -0.00023133f, 0.01157897f, 
    -0.00908250f, -0.00522683f, 0.09172368f, -0.02612410f, 0.04662528f, 0.05983624f, -0.04179825f, 0.18471237f, 
    -0.02640254f, 0.03610079f, -0.03557388f, -0.02132219f, -0.09136325f, -0.09949331f, -0.04371512f, 0.11341480f, 
    0.16607900f, 0.16470820f, 0.04428806f, -0.00819348f, 0.00172487f, 0.06990410f, -0.02949992f, 0.04731371f, 
    0.06824204f, -0.04047326f, 0.01838183f, -0.07289712f, -0.11186393f, 0.04165903f, 0.00850221f, 0.24187450f, 
    -0.06724688f, 0.09420638f, 0.00580477f, -0.06473552f, -0.06435687f, 0.00377229f, 0.08291707f, 0.00657912f, 
    0.26845351f, 0.02072328f, 0.01515251f, 0.17507385f, 0.08925240f, -0.02460945f, -0.08707405f, 0.04173118f, 
    -0.04136735f, 0.08669990f, -0.07649503f, 0.00345038f, 0.24809353f, -0.00756602f, 0.24720204f, -0.18754908f, 
    -0.00175361f, 0.04837561f, 0.06432481f, -0.07638976f, 0.07785246f, -0.03664977f, 0.01191913f, 0.00461802f, 
    0.00255034f, 0.09272460f, -0.05753696f, 0.27368611f, 0.21648821f, -0.12066483f, 0.01031575f, -0.03907765f, 
    -0.01766978f, 0.03607528f, -0.04952804f, 0.05051662f, 0.10344138f, 0.08832590f, 0.04619106f, 0.12143188f, 
    -0.15168454f, 0.03595426f, -0.08256688f, 0.05668699f, 0.09901138f, -0.08252186f, -0.04674081f, 0.09026809f, 
    0.17210661f, 0.06504482f, 0.00764495f, -0.17687020f, -0.06092333f, 0.00160925f, -0.00182238f, 0.06686660f, 
    0.09223149f, 0.09793014f, 0.03748623f, -0.17978944f, -0.02945498f, 0.28665635f, 0.03567155f, 0.01605218f, 
    -0.10252775f, -0.07067508f, 0.02940963f, -0.13181801f, 0.09825753f, -0.02478000f, 0.03988177f, 0.08266767f, 
    0.05046505f, -0.12941183f, 0.17317717f, 0.10118082f, 0.17687227f, 0.08880562f, 0.03054109f, -0.02132927f, 
    0.00852977f, 0.03653455f, -0.03624526f, -0.02108321f, 0.08958796f, -0.13934815f, 0.02790556f, -0.11738334f, 
    -0.03790122f, -0.08788872f, -0.08638106f, -0.06448568f, 0.02652748f, -0.05808050f, -0.03458315f, 0.11618045f, 
    -0.06874038f, -0.06284092f, 0.16931966f, 0.11313559f, 0.06663304f, 0.05391051f, 0.07860748f, -0.06378491f, 
    -0.01631383f, -0.01265393f, 0.10887277f, 0.12461834f, 0.06149654f, 0.11941337f, -0.17798050f, 0.10138722f, 
    -0.13386215f, -0.02988726f, -0.05612221f, 0.01642028f, 0.06149253f, -0.05860624f, 0.01881257f, -0.07125280f, 
    -0.09369569f, -0.20712249f, 0.06036139f, 0.17274030f, 0.12903291f, 0.03734824f, 0.00279806f, -0.01826727f, 
    0.06222679f, -0.14402622f, 0.07999453f, 0.03021201f, 0.09363423f, 0.03589811f, 0.17145287f, -0.05508862f, 
    0.02890230f, -0.00818448f, -0.03977451f, 0.02212605f, 0.04099090f, 0.05508324f, -0.01847783f, 0.07916351f, 
    0.05491955f, 0.11519666f, 0.22713007f, -0.15114306f, -0.01080567f, -0.07009837f, 0.06247938f, 0.04187505f, 
    0.02791072f, 0.03502234f, -0.00251786f, 0.05591191f, -0.08349488f, 0.12727442f, 0.01560440f, 0.02280103f, 
    -0.10899573f, -0.00782849f, 0.04513146f, -0.11035569f, -0.02549457f, 0.01711736f, 0.04726401f, 0.12581109f, 
    0.20923883f, 0.05997657f, -0.00649303f, 0.17085028f, 0.12070744f, 0.02295646f, -0.00298403f, 0.06778070f, 
    -0.03458000f, -0.01545008f, 0.08840826f, -0.05016323f, 0.11729731f, 0.00253098f, -0.22345856f, 0.17881705f, 
    0.01286626f, -0.01905553f, -0.01143536f, 0.01663876f, 0.11165462f, 0.08300526f, -0.04159068f, 0.04079393f, 
    -0.09168008f, 0.11482926f, 0.02578391f, -0.06995033f, 0.05596311f, -0.00541051f, 0.07063662f, 0.05388233f, 
    -0.03259693f, 0.03232447f, -0.13060494f, 0.06838659f, -0.37662667f, -0.09810641f, -0.19300669f, 0.10290398f, 
    0.15173295f, 0.06287542f, -0.06754789f, 0.09814753f, 0.05849387f, 0.01347152f, -0.12592018f, -0.08588962f, 
    0.14032397f, 0.18687579f, 0.24447675f, 0.03098911f, 0.09815702f, -0.04806989f, -0.01423570f, 0.11039992f, 
    -0.08542192f, 0.05008907f, 0.18682702f, -0.03681309f, 0.08634993f, 0.02813705f, 0.04702436f, 0.05992011f, 
    0.12077017f, 0.07781451f, -0.01344011f, 0.04827582f, -0.03157665f, 0.09282688f, -0.03211755f, 0.12368518f, 
    -0.11490635f, 0.21642643f, 0.03523254f, 0.16687509f, 0.01787068f, -0.03796031f, 0.01811418f, -0.14361021f, 
    -0.01990147f, 0.02964160f, 0.06158591f, 0.16111925f, -0.04175720f, 0.01711841f, -0.06002701f, -0.26632878f, 
    0.02961712f, -0.04525030f, -0.05409334f, 0.01210941f, 0.08696932f, -0.04828643f, 0.09887300f, 0.02589375f, 
    -0.26949257f, -0.01017785f, 0.05576214f, -0.01072419f, 0.06931093f, -0.03923479f, 0.09176483f, -0.02457278f, 
    0.02574601f, 0.08238052f, -0.02057527f, 0.00511390f, 0.05626216f, -0.03694363f, 0.00966227f, -0.07337287f, 
    0.05715217f, 0.04506810f, 0.01813216f, 0.00447383f, -0.12985015f, 0.00648159f, 0.03331382f, 0.08664527f, 
    -0.07720081f, 0.03975367f, -0.11938985f, 0.11119798f, -0.13235775f, -0.01315560f, 0.00173172f, -0.02259412f, 
    0.03441152f, 0.01860318f, -0.04430765f, -0.01527605f, 0.12973391f, 0.13112618f, 0.01025174f, 0.03802197f, 
    0.00123095f, 0.01013300f, -0.05460261f, -0.10309767f, 0.10346823f, -0.02131338f, -0.02166982f, -0.03337520f, 
    -0.16620317f, -0.04167247f, 0.12396723f, -0.01994532f, 0.10627742f, -0.00858493f, 0.02811317f, -0.09100275f, 
    -0.03310788f, -0.04318466f, -0.01487695f, 0.04190068f, -0.03153908f, -0.11786661f, 0.00951786f, 0.05998788f, 
    -0.03500425f, 0.12037151f, -0.04867991f, -0.04995782f, 0.08487557f, 0.00829777f, -0.00349323f, 0.01364120f, 
    -0.26861456f, 0.28570539f, -0.09854987f, 0.13929303f, 0.00255388f, -0.04123640f, 0.00665884f, -0.02175870f, 
    0.04499179f, -0.06738420f, -0.01008048f, -0.01079974f, -0.32510534f, 0.19660066f, -0.01489671f, 0.25188527f, 
    -0.04487399f, 0.02741237f, -0.02206636f, -0.10328305f, -0.12047344f, -0.03898937f, -0.09413642f, 0.03069174f, 
    -0.29161626f, 0.20439462f, -0.08566359f, 0.22333717f, -0.16103804f, 0.12674960f, -0.07905260f, -0.04014145f, 
    -0.07605366f, -0.06701466f, -0.00137633f, -0.04447588f, 0.19836220f, 0.06347911f, -0.05124278f, 0.01276373f, 
    0.06557781f, 0.04925410f, 0.04075563f, 0.02733767f, -0.13660321f, 0.12394609f, -0.01466861f, 0.09220089f, 
    0.23376667f, 0.17985429f, 0.20748150f, -0.12917142f, 0.05231294f, 0.00939996f, -0.06308297f, 0.07682618f, 
    -0.05672523f, -0.08190314f, 0.04382491f, 0.09670787f, -0.17256086f, -0.10070916f, 0.12407585f, 0.08403585f, 
    -0.00915613f, 0.00462309f, -0.05400760f, -0.03671911f, -0.05887007f, -0.03674180f, -0.01889591f, 0.00058910f, 
    -0.02136869f, 0.04190284f, 0.20153807f, 0.11078024f, 0.05161026f, 0.02157769f, 0.10957561f, 0.00498249f, 
    0.02073354f, -0.00782855f, 0.07022689f, -0.03429724f, -0.12597103f, -0.12361745f, 0.19423270f, -0.20191041f, 
    -0.13377221f, -0.03274844f, 0.19472176f, -0.07090494f, 0.05978057f, 0.03301541f, 0.00396446f, -0.02465771f, 
    -0.19792204f, 0.03753957f, -0.08331246f, -0.03371535f, -0.04323311f, 0.00253752f, -0.13002698f, 0.07199083f, 
    0.04825631f, -0.00196025f, -0.00725114f, -0.00042371f, -0.27398276f, -0.04481293f, -0.32974997f, 0.23581520f, 
    0.03414585f, 0.08784035f, -0.00808206f, 0.05540406f, 0.00636727f, -0.04131336f, -0.02178519f, -0.02397855f, 
    -0.29301700f, -0.04325488f, -0.08634645f, 0.04270947f, 0.01691996f, 0.08597314f, 0.03162219f, -0.03498767f, 
    0.03546388f, 0.08914540f, 0.09087128f, 0.06792570f, -0.18870710f, -0.13184732f, -0.13034013f, 0.05766201f, 
    0.02575248f, 0.10739868f, 0.04510486f, -0.05226509f, 0.07388783f, -0.02109935f, -0.02588037f, -0.07603551f, 
    -0.16397588f, 0.12599927f, -0.11683255f, -0.06172757f, 0.03744458f, 0.17139412f, 0.03994616f, -0.10129265f, 
    0.03320676f, 0.13414745f, -0.02656851f, 0.01692956f, 0.15169552f, -0.01579225f, 0.12990990f, 0.05832707f, 
    0.10886300f, -0.13517141f, 0.00526342f, 0.02853408f, 0.13195881f, 0.06043175f, -0.01046896f, 0.07465554f, 
    -0.31734926f, -0.08628344f, -0.12798601f, 0.09803490f, 0.10814249f, 0.09693724f, 0.06617468f, -0.17517807f, 
    -0.05851434f, 0.02273672f, -0.02140456f, 0.03748820f, 0.00179202f, 0.10107987f, 0.03990157f, -0.08649559f, 
    -0.04918957f, 0.05836042f, -0.08965317f, -0.09079721f, 0.09542955f, -0.05626430f, 0.06672855f, 0.03589233f, 
    0.07327090f, 0.20687422f, -0.08924326f, 0.40837163f, -0.06856414f, 0.03664137f, -0.01615656f, 0.05987263f, 
    -0.01332602f, -0.07682864f, 0.05453163f, -0.00529421f, 0.01806232f, -0.02713714f, -0.06261335f, 0.16654073f, 
    0.01570256f, -0.02604818f, 0.09297121f, -0.02540612f, 0.02234554f, -0.13709329f, 0.04782258f, 0.04834237f, 
    -0.08447477f, -0.22870776f, -0.17086785f, 0.24251737f, 0.06504147f, -0.05565943f, -0.01903779f, -0.02816128f, 
    0.00207497f, 0.00717401f, 0.03631281f, -0.02394116f, -0.03982791f, 0.26325646f, -0.14386472f, 0.27398327f, 
    -0.03261378f, 0.02703355f, -0.02118925f, -0.03971980f, 0.04579897f, -0.06573500f, 0.02444611f, 0.11341061f, 
    0.01849795f, 0.07980394f, 0.07512611f, 0.07724138f, -0.02098767f, 0.08439079f, 0.14570135f, 0.00199389f, 
    -0.00466642f, -0.02938352f, -0.07493033f, -0.02079551f, 0.11908844f, -0.14881323f, -0.14364703f, 0.15467468f, 
    0.13358338f, 0.16322014f, 0.12856132f, -0.09667638f, -0.01607434f, -0.04460459f, -0.07765770f, 0.03800674f, 
    0.06894722f, 0.13540873f, -0.09484094f, 0.12817906f, 0.13411143f, 0.03911538f, -0.06357198f, 0.07303616f, 
    0.04011057f, -0.02042590f, 0.04689058f, 0.16734262f, -0.09711952f, -0.10710517f, -0.02039050f, 0.08491112f, 
    -0.05080351f, 0.07054697f, -0.00082842f, -0.11049638f, 0.12504111f, -0.04014875f, 0.00272364f, -0.00765214f, 
    0.01740406f, 0.00582842f, -0.02121676f, 0.00222980f, 0.09378198f, 0.02618093f, -0.06187980f, -0.02125433f, 
    0.18052629f, 0.11375427f, -0.05623754f, -0.05499525f, -0.12617357f, 0.07799457f, 0.20492734f, 0.00814269f, 
    -0.05096250f, 0.00169731f, -0.00592953f, -0.06454845f, 0.15834144f, -0.12693755f, -0.00089019f, 0.09561402f, 
    -0.15113145f, 0.00802088f, -0.01366852f, 0.04797543f, 0.10719674f, 0.13794684f, 0.10946628f, 0.07008076f, 
    -0.02013223f, -0.03128676f, 0.03101611f, 0.08017167f, -0.01433319f, 0.14379792f, -0.09534543f, 0.07048491f, 
    0.06916553f, -0.00923412f, 0.06908154f, 0.01542231f, -0.07144625f, 0.00130607f, 0.00259377f, 0.06950473f, 
    -0.02853701f, 0.02793538f, 0.00418949f, 0.00990112f, -0.00198117f, 0.00766383f, 0.03033039f, 0.01856355f, 
    -0.03884560f, -0.01157506f, 0.02801325f, -0.02717456f, -0.02972462f, -0.00328567f, -0.02080188f, -0.01020733f, 
    0.00040128f, -0.00435798f, 0.02407828f, -0.01864023f, -0.03564683f, 0.01712939f, 0.01782355f, -0.03254217f, 
    -0.01261091f, -0.01044718f, -0.03852159f, 0.02048800f, -0.01206788f, 0.01364581f, -0.00415023f, -0.03283298f, 
    0.00599237f, -0.02194315f, -0.00803060f, 0.00108047f, -0.01860291f, -0.02674411f, -0.00606962f, 0.01531545f, 
    0.01891463f, -0.01917694f, -0.00633009f, 0.00949606f, -0.03517627f, 0.01473031f, -0.03732138f, 0.02450957f, 
    0.01019584f, 0.02537555f, -0.03830598f, -0.03323924f, -0.02414845f, -0.00729583f, 0.00778818f, 0.01888323f, 
    -0.02289917f, -0.02821649f, 0.00446101f, -0.03196641f, -0.02198937f, 0.01793036f, -0.00442990f, 0.02565389f, 
    0.00609857f, 0.02484756f, 0.01269064f, -0.04285573f, -0.04327295f, 0.00469765f, 0.02487634f, -0.01752317f, 
    0.01899828f, -0.03773945f, -0.02554849f, -0.03198733f, -0.01786786f, -0.03981582f, -0.01462715f, 0.02295791f, 
    0.00736063f, 0.00013132f, -0.01928282f, 0.00087762f, 0.03028245f, 0.00059608f, -0.00479963f, -0.01672500f, 
    -0.04268252f, -0.00281526f, 0.02261185f, 0.01811060f, -0.02295052f, -0.00312316f, 0.00698975f, 0.01717331f, 
    -0.00343564f, -0.00975178f, -0.03058212f, 0.02249263f, -0.00487247f, -0.02267058f, -0.02854124f, -0.01081102f, 
    0.01095162f, -0.00854468f, -0.00945531f, -0.02964918f, -0.00676573f, -0.01463081f, 0.02112753f, 0.01781379f, 
    0.01638712f, 0.02461968f, -0.00288953f, 0.00303899f, 0.02666996f, -0.03517584f, -0.00399271f, 0.02130434f, 
    0.00824365f, -0.00737286f, -0.03723696f, 0.02818760f, 0.02382911f, 0.00575364f, -0.03180285f, -0.02087721f, 
    0.02507269f, 0.00101811f, 0.01051900f, 0.02009216f, -0.00046754f, -0.00161634f, -0.03693827f, 0.02961455f, 
    -0.03592737f, 0.00905664f, 0.02957024f, 0.01779733f, -0.01382054f, -0.03895066f, 0.02834679f, 0.02286417f, 
    0.02838696f, -0.02778739f, -0.02814985f, 0.02884551f, -0.01027484f, -0.03120772f, 0.00909993f, -0.03935182f, 
    -0.03084013f, 0.01668557f, -0.03404506f, 0.00607703f, 0.00784134f, 0.02550357f, -0.04122048f, -0.00064547f, 
    0.02333754f, -0.02592693f, 0.02651582f, -0.03103114f, 0.01825049f, 0.01048443f, 0.02503303f, 0.00393605f, 
    -0.02450153f, 0.00371610f, 0.02025503f, 0.01267987f, -0.03180898f, -0.02920542f, -0.00841014f, 0.02432688f, 
    -0.00639112f, -0.02746437f, 0.00445374f, -0.03302018f, -0.00793020f, -0.00233858f, -0.00776543f, 0.00963215f, 
    -0.00603800f, 0.02449188f, -0.01326894f, 0.02012540f, 0.00271018f, -0.02080564f, -0.02901611f, -0.01252652f, 
    0.01868602f, -0.00168994f, 0.01619132f, -0.00572591f, 0.02942278f, -0.01373447f, 0.02792170f, -0.01780570f, 
    -0.02830052f, 0.00808230f, -0.04238186f, 0.01238405f, 0.00162962f, -0.03356646f, 0.02054244f, -0.02208163f, 
    -0.03743284f, -0.04119941f, -0.02851659f, 0.01673559f, 0.02266808f, -0.00533291f, 0.01050295f, -0.02234512f, 
    0.01319227f, 0.00777475f, -0.01868833f, -0.02351938f, -0.03604906f, -0.02284254f, -0.00670451f, 0.01762841f, 
    -0.02639060f, 0.00548438f, 0.01723463f, -0.00533966f, -0.00677022f, 0.00061960f, -0.03282649f, 0.02883972f, 
    -0.03282776f, 0.01580832f, 0.02663316f, 0.00970649f, -0.02720970f, -0.03297513f, 0.02573341f, 0.02810230f, 
    0.00627526f, -0.00828764f, -0.02308396f, -0.02147047f, 0.01992998f, 0.01486190f, -0.03422596f, -0.01314776f, 
    -0.02287120f, -0.00313350f, -0.01219683f, -0.03442711f, -0.02572235f, 0.00215968f, -0.00105651f, 0.02821622f, 
    -0.03908838f, -0.02238510f, -0.01831727f, -0.03692136f, -0.03805941f, 0.02733160f, 0.01149086f, -0.02269096f, 
    -0.04097373f, 0.02099717f, -0.03649472f, -0.03427741f, 0.00947548f, -0.00703585f, 0.02731312f, -0.03451926f, 
    -0.00246656f, 0.01869908f, 0.01914019f, 0.02536595f, -0.03430495f, -0.02475799f, -0.03347387f, 0.02534732f, 
    -0.00702841f, -0.01207895f, -0.03863665f, 0.00667070f, 0.02739141f, -0.03644989f, -0.01506942f, -0.00780828f, 
    -0.01207108f, 0.00044038f, 0.00387579f, -0.00891710f, -0.01242784f, -0.02490410f, 0.01855887f, 0.02081615f, 
    0.02867231f, -0.03568751f, -0.03982159f, 0.01904405f, -0.02360502f, -0.03971291f, -0.03358673f, -0.02733300f, 
    0.01065191f, -0.02262383f, -0.02232593f, -0.02599045f, 0.01807179f, 0.02424651f, -0.01132654f, 0.01324261f, 
    0.00166975f, 0.01860866f, -0.01496487f, 0.00767560f, -0.00208843f, 0.02687789f, 0.01738550f, -0.01926403f, 
    -0.02316930f, -0.03927318f, 0.01634239f, 0.02484784f, -0.00101450f, 0.01206954f, -0.02433199f, 0.02359147f, 
    -0.03249102f, -0.03576955f, 0.02411607f, -0.02638351f, 0.01233071f, -0.01512229f, 0.01634335f, 0.00427525f, 
    -0.02475211f, -0.01670833f, -0.03351539f, -0.01828936f, -0.02613036f, 0.01569542f, -0.02459365f, -0.03214384f, 
    -0.01501697f, 0.00035577f, 0.01970319f, 0.02731900f, -0.00203888f, 0.01064010f, -0.03906190f, -0.03118815f, 
    0.00572479f, -0.00637842f, 0.02739750f, -0.03012685f, 0.01359972f, -0.02767654f, -0.01042125f, 0.00623464f, 
    -0.02885148f, 0.00068118f, -0.03337982f, 0.01835375f, 0.02237160f, -0.01656212f, -0.00815377f, -0.00926587f, 
    0.02049006f, -0.03794782f, 0.02934670f, -0.00182129f, -0.00458221f, 0.01731898f, 0.02773211f, -0.03136477f, 
    0.02981174f, -0.00133791f, 0.00479529f, -0.02206115f, -0.01850240f, 0.02667942f, -0.01537025f, 0.02648371f, 
    0.01581300f, -0.00851586f, -0.00895698f, -0.01145463f, -0.00224845f, -0.00132541f, -0.02333954f, -0.01090380f, 
    -0.02546031f, 0.01550744f, -0.03259059f, -0.03886991f, 0.01137175f, 0.00516227f, 0.01956505f, -0.04261785f, 
    0.02721610f, 0.01692004f, 0.01466987f, -0.02596032f, -0.03736403f, -0.00608651f, 0.00996840f, 0.01282966f, 
    0.00013847f, -0.03751143f, 0.01206652f, -0.01472919f, -0.02508958f, -0.02542097f, 0.00626044f, -0.02515169f, 
    0.02981999f, 0.01217929f, -0.00899062f, 0.00430237f, -0.00994031f, 0.02562032f, 0.00730600f, -0.01568707f, 
    -0.01950012f, -0.02797939f, -0.02597792f, -0.03489257f, -0.02701350f, 0.02094638f, -0.02483427f, -0.03193542f, 
    0.00609787f, -0.03718843f, 0.02856153f, -0.02750672f, 0.02144539f, -0.00354793f, -0.00089929f, -0.02428580f, 
    0.00580151f, 0.00615414f, 0.00798880f, 0.01379465f, -0.01813000f, 0.02090624f, 0.02801485f, -0.01487030f, 
    -0.01023952f, -0.01716912f, 0.02511035f, -0.01275691f, 0.00521285f, 0.00856072f, -0.02255652f, -0.02021373f, 
    -0.00284560f, -0.02250489f, -0.00402424f, -0.04131442f, 0.01853350f, -0.03244574f, 0.01311830f, -0.00137446f, 
    0.02401924f, -0.02890865f, -0.01592471f, 0.00475303f, 0.01445160f, -0.03757705f, -0.00429550f, 0.02787361f, 
    -0.02818134f, -0.02333585f, 0.02741826f, -0.03957487f, -0.02475580f, -0.03041457f, -0.02682201f, 0.00468817f, 
    -0.01668321f, -0.01311711f, -0.00946587f, -0.00462645f, -0.00177611f, -0.01646226f, -0.03873263f, 0.01028397f, 
    0.01054857f, -0.01782354f, 0.00206026f, -0.02208097f, -0.00531040f, 0.00760059f, -0.02140807f, -0.00924176f, 
    0.00901625f, 0.01560340f, -0.03745684f, 0.00348452f, -0.02633817f, -0.02553295f, 0.02898209f, 0.01389388f, 
    0.00011874f, -0.02768511f, 0.00153826f, -0.01340393f, -0.00399972f, -0.01346353f, 0.00053577f, 0.01378593f, 
    0.02739581f, -0.00621127f, 0.01600284f, 0.02313902f, 0.02202477f, -0.01186462f, -0.01712279f, -0.03042531f, 
    -0.02452216f, -0.02457455f, -0.01266964f, 0.02470479f, -0.00354788f, -0.02587768f, -0.02591058f, 0.01445797f, 
    0.02513778f, -0.00686789f, 0.00929835f, 0.00942027f, -0.00434514f, -0.03010129f, -0.01313979f, -0.02463918f, 
    0.00373711f, 0.00298358f, 0.00385368f, -0.03008423f, 0.02464120f, -0.03934680f, 0.01390202f, 0.00885127f, 
    -0.02192022f, -0.02720268f, 0.01984929f, 0.01846650f, -0.01846123f, -0.00562271f, 0.01010243f, 0.01308370f, 
    0.00680212f, -0.00775426f, -0.00350846f, -0.03305950f, -0.00647855f, -0.03222208f, 0.01678390f, 0.01020009f, 
    0.00950313f, -0.02351294f, 0.00339726f, 0.01241574f, 0.02224910f, 0.00904620f, 0.02846541f, 0.00613328f, 
    -0.00374892f, 0.01263410f, 0.01591947f, 0.01266303f, -0.02661875f, -0.03403952f, -0.03054324f, 0.02518798f, 
    0.02781802f, -0.03184904f, 0.02706874f, -0.01915220f, 0.02850924f, 0.00864065f, 0.01359230f, -0.04026062f, 
    -0.03953727f, 0.00163917f, 0.00036461f, 0.03030190f, 0.02190295f, 0.00823383f, -0.00331720f, 0.02730087f, 
    -0.02443537f, 0.02196705f, -0.01568757f, -0.01211879f, 0.00835654f, -0.02117255f, 0.02025390f, 0.01168636f, 
    -0.01008259f, -0.00117144f, 0.00378974f, -0.01067077f, 0.02203361f, -0.03939408f, -0.02956651f, 0.02143661f, 
    -0.03488232f, -0.01419750f, -0.02441304f, -0.00476023f, -0.02556977f, -0.02879545f, -0.01727154f, -0.00396181f, 
    0.00092104f, -0.04251083f, 0.00529218f, -0.01950447f, 0.01873699f, -0.02567625f, 0.00935261f, 0.02863524f, 
    -0.03585326f, 0.01908200f, 0.02826072f, 0.02719479f, 0.02852712f, -0.01826563f, -0.02546116f, -0.02012083f, 
    -0.00032921f, 0.01189615f, 0.01060213f, -0.02595115f, 0.00990995f, -0.04338433f, 0.02152194f, -0.00130608f, 
    -0.00234064f, -0.01211097f, 0.00902870f, -0.03216829f, -0.03158865f, -0.01225208f, -0.01704310f, 0.00340080f, 
    -0.03590009f, 0.01432567f, -0.04071128f, -0.00944299f, 0.00573132f, -0.00857965f, -0.00257741f, 0.01305517f, 
    -0.03410026f, 0.01897612f, -0.03197799f, 0.02903581f, 0.00624974f, -0.00433483f, -0.03150428f, 0.00179175f, 
    0.00785239f, -0.01814623f, -0.01739663f, 0.00094380f, -0.00285092f, 0.00686936f, -0.00387033f, -0.04075846f, 
    -0.02154478f, -0.03918862f, -0.02325863f, 0.02156980f, -0.00212187f, -0.02950135f, -0.01478879f, 0.00181867f, 
    0.02471980f, 0.02345635f, 0.01456971f, 0.00597594f, -0.01866281f, 0.00018452f, -0.01627702f, 0.00362648f, 
    -0.03112260f, -0.01708476f, 0.02397778f, -0.03342343f, -0.01984231f, -0.00480245f, -0.03984921f, -0.02791375f, 
    0.00497911f, -0.02337764f, 0.01717863f, -0.00417517f, -0.03837213f, 0.02021386f, 0.02860447f, -0.03384253f, 
    0.02601080f, -0.01475972f, -0.00029054f, -0.00902240f, 0.00408799f, -0.02667542f, -0.02228157f, -0.04049783f, 
    0.02181117f, -0.00075300f, 0.00898529f, 0.01544531f, -0.00092260f, -0.03909850f, -0.02177684f, -0.01787028f, 
    -0.03723428f, -0.01933530f, -0.03692653f, 0.01481374f, 0.00216327f, -0.00500712f, -0.00282506f, -0.03763482f, 
    0.00754632f, -0.03092708f, 0.02805986f, -0.03565168f, -0.01083517f, -0.02397823f, -0.03269636f, 0.00495313f, 
    0.00995541f, -0.01792329f, -0.00377892f, -0.03240118f, 0.01279731f, 0.01581138f, 0.00139850f, -0.03375355f, 
    -0.00891642f, 0.01386452f, -0.01288741f, 0.01981610f, 0.02442371f, 0.00045054f, 0.02357068f, -0.02755057f, 
    -0.03725655f, 0.02304531f, -0.01028592f, 0.00772678f, 0.02727269f, -0.00279757f, -0.02183609f, -0.01050026f, 
    0.00574864f, 0.00431554f, -0.03783294f, -0.01610705f, 0.02394509f, -0.04077288f, -0.03482566f, 0.00020504f, 
    0.03295761f, 0.01422089f, 0.01925639f, 0.00796243f, 0.01884868f, -0.01298634f, -0.02975535f, 0.02319469f, 
    -0.03230779f, -0.00296802f, -0.00920580f, -0.00046972f, 0.01088169f, 0.02692914f, -0.02216754f, 0.00404608f, 
    0.00659504f, -0.04195257f, -0.01876259f, 0.02156314f, 0.00738259f, -0.01528028f, 0.01643959f, -0.00680179f, 
    -0.01477409f, -0.00312713f, 0.02248440f, 0.02403373f, 0.01471792f, -0.02897829f, -0.00311971f, -0.03745892f, 
    0.02349472f, 0.01383378f, 0.01866421f, -0.01551999f, 0.01346836f, -0.02238736f, 0.02898772f, -0.02058557f, 
    -0.02608856f, 0.02919189f, 0.01158353f, -0.02195775f, 0.01139178f, -0.00322899f, -0.02620129f, 0.01421655f, 
    -0.03414423f, 0.02949606f, 0.00703332f, -0.01919901f, -0.00003472f, 0.01346495f, -0.03803197f, -0.03674130f, 
    0.01427721f, 0.00879962f, 0.02848204f, -0.03632285f, -0.04100806f, 0.00780517f, -0.02905470f, 0.00681229f, 
    -0.03304462f, -0.01724223f, 0.02589112f, -0.01100093f, -0.01708857f, 0.00501487f, -0.03232093f, 0.02976696f, 
    0.03558069f, 0.02247775f, 0.01974953f, 0.02998335f, -0.00853979f, -0.03654012f, 0.02367945f, -0.01483428f, 
    0.01468101f, 0.02103470f, -0.00095803f, -0.01079939f, -0.03570183f, -0.03722140f, -0.01571159f, 0.02368718f, 
    -0.02925960f, -0.01300924f, 0.00932106f, 0.02508866f, -0.02182738f, 0.02263056f, -0.02474450f, 0.00893212f, 
    0.00338854f, -0.00150138f, 0.02399751f, 0.01604872f, -0.02114718f, -0.03306491f, 0.00994507f, 0.01109435f, 
    -0.03483152f, 0.01964295f, 0.01414203f, -0.01337348f, -0.02458403f, -0.02437590f, -0.01264231f, -0.01342176f, 
    0.00054736f, -0.02062949f, -0.03458739f, 0.03507245f, -0.02176359f, -0.03071292f, -0.01754238f, -0.00967632f, 
    0.02165901f, -0.01279167f, 0.02137724f, 0.01884038f, 0.01546559f, -0.02338875f, 0.00107916f, 0.00645503f, 
    -0.01207992f, -0.02837401f, -0.00571375f, 0.00211002f, 0.04020810f, 0.01951068f, -0.02096446f, -0.00636617f, 
    -0.02514368f, -0.00580481f, -0.00144979f, 0.02000211f, 0.02344398f, 0.00543811f, 0.00715972f, -0.00197267f, 
    -0.04156404f, 0.01080838f, 0.02787929f, -0.02397722f, -0.02644916f, -0.04459335f, -0.01916774f, -0.01244599f, 
    -0.00566234f, -0.00972715f, -0.02425423f, 0.00348575f, 0.02672253f, -0.00621934f, -0.02777223f, -0.03463749f, 
    -0.00406743f, -0.00511917f, -0.04183064f, 0.00381336f, -0.03919787f, -0.00203373f, -0.04136657f, -0.02417872f, 
    -0.04314924f, 0.02369970f, 0.02608301f, 0.01863454f, -0.03595540f, -0.03831255f, -0.00326650f, -0.00791635f, 
    -0.03856542f, -0.03661825f, 0.01500195f, -0.02145951f, -0.01071184f, 0.01673710f, 0.02527176f, -0.01964835f, 
    -0.01330412f, 0.00381024f, 0.01130532f, -0.00478553f, 0.01987942f, 0.02019810f, 0.01683900f, -0.00224445f, 
    0.01712755f, -0.00653506f, -0.03012704f, -0.01466448f, -0.01447841f, 0.01352405f, 0.00544822f, -0.03358485f, 
    0.01315859f, -0.01922604f, -0.01588542f, -0.01677854f, 0.02875430f, 0.02312318f, -0.01026367f, -0.00281733f, 
    -0.00858505f, 0.02576246f, 0.00670923f, 0.01196953f, 0.01559970f, -0.02707107f, -0.03629002f, -0.01176574f, 
    0.02644309f, -0.03678763f, -0.03326545f, 0.00126515f, 0.01501001f, -0.03573825f, -0.04372498f, 0.03126261f, 
    -0.02712547f, -0.04374754f, 0.01413780f, 0.02809554f, 0.02152348f, -0.01683270f, -0.02554140f, 0.00121619f, 
    0.00840432f, 0.02184203f, 0.01905463f, -0.01877388f, 0.02085689f, -0.00589315f, -0.00966498f, 0.02224753f, 
    -0.00163635f, 0.04074726f, -0.00130444f, 0.00809949f, -0.03183074f, -0.01953024f, 0.01685731f, -0.01014441f, 
    -0.02933786f, 0.01801880f, 0.01745450f, 0.01340323f, 0.02497901f, 0.04037900f, 0.00647086f, 0.02974756f, 
    -0.04229586f, -0.02146635f, 0.03127334f, 0.00504998f, -0.00459880f, 0.01246711f, -0.02307511f, -0.02710889f, 
    -0.02433760f, -0.01087721f, 0.02307419f, -0.02215288f, -0.03554088f, -0.00690097f, -0.00283127f, -0.03463848f, 
    -0.01369901f, 0.00604909f, -0.04393591f, 0.00216129f, -0.01748942f, -0.02985925f, 0.03133622f, 0.02045320f, 
    0.01705874f, 0.00380073f, 0.01512643f, -0.00870241f, -0.03279580f, 0.01189466f, 0.01231075f, -0.04054442f, 
    -0.00813288f, -0.01082634f, -0.00373143f, 0.00404390f, -0.03113240f, -0.02732240f, 0.00899873f, -0.01699305f, 
    0.00270649f, -0.01748290f, 0.01911783f, -0.00813387f, 0.01564280f, 0.00261299f, -0.01386448f, -0.04399657f, 
    0.00969155f, 0.02717126f, -0.02020831f, -0.01076935f, -0.02371292f, 0.00461492f, -0.01626557f, -0.00109990f, 
    0.02399963f, 0.00231346f, 0.02230702f, -0.01005484f, 0.00160178f, -0.00698780f, -0.01045695f, -0.02937333f, 
    0.02328543f, 0.00184110f, -0.04077962f, 0.02028591f, 0.02066604f, 0.00895252f, -0.00527515f, 0.01124947f, 
    0.02730040f, -0.03461280f, -0.03041043f, -0.02344197f, -0.02307791f, -0.00578875f, -0.02309401f, -0.00862366f, 
    0.02159256f, -0.02290289f, 0.01623378f, 0.02011120f, 0.00330103f, 0.01163492f, 0.03221004f, 0.01617553f, 
    -0.01485300f, 0.02421935f, -0.03443744f, 0.00482299f, -0.03282013f, 0.01191126f, -0.04024892f, 0.02759574f, 
    -0.04378793f, -0.01491502f, -0.03138923f, -0.03417341f, -0.02324186f, 0.01367781f, 0.01975711f, -0.02046933f, 
    0.00309621f, 0.00437800f, -0.03999222f, -0.01261794f, -0.00000988f, -0.01136211f, -0.02090140f, 0.03237675f, 
    0.01309438f, 0.00389942f, -0.02886193f, 0.01187004f, -0.01812965f, -0.00508391f, -0.01369092f, -0.01428360f, 
    0.00910592f, 0.01156418f, 0.02800690f, 0.03539252f, 0.02913372f, -0.00632206f, -0.02102169f, 0.02113195f, 
    -0.01849820f, 0.02763113f, -0.03596560f, 0.00440579f, -0.01031337f, -0.02649610f, 0.01922720f, -0.01353445f, 
    -0.01613534f, -0.01038268f, 0.01602264f, -0.00588616f, 0.03046691f, -0.02238072f, -0.00405522f, 0.01814670f, 
    -0.03657657f, 0.01745290f, 0.00673327f, -0.03087894f, -0.01978043f, -0.01974521f, 0.01712465f, 0.00344000f, 
    -0.01175309f, 0.00612132f, 0.01543595f, 0.01284444f, 0.01890329f, -0.00591971f, -0.02879505f, -0.04467603f, 
    -0.03281873f, -0.02126705f, 0.02345333f, -0.00091254f, 0.00377647f, 0.01880362f, 0.02504393f, -0.03950493f, 
    0.01089377f, -0.03462110f, -0.01773587f, 0.01170206f, -0.01698200f, 0.00119444f, -0.03188992f, -0.00627759f, 
    -0.00095087f, -0.02384489f, -0.03513745f, -0.00822255f, -0.00295524f, 0.02408773f, -0.03483260f, -0.01090119f, 
    -0.02134758f, 0.01783066f, 0.03388120f, 0.02264140f, 0.02117730f, -0.02726433f, 0.00017725f, 0.00661433f, 
    0.01090987f, -0.02682602f, -0.02994806f, -0.02240323f, -0.01524095f, 0.01703396f, 0.01795732f, 0.01570398f, 
    0.01152000f, 0.00217982f, -0.03568429f, -0.01893457f, -0.01957432f, 0.02451787f, 0.01272467f, 0.01142857f, 
    -0.04004984f, -0.02474477f, -0.01662563f, 0.01487294f, -0.01729153f, -0.01002040f, -0.00385793f, 0.00792222f, 
    -0.02397481f, -0.00161814f, -0.00426094f, 0.01809449f, -0.01777652f, 0.00522388f, -0.01178993f, 0.01528344f, 
    -0.03376924f, 0.02825657f, 0.00592695f, -0.00671982f, -0.00636812f, -0.02889495f, 0.01169602f, 0.00962500f, 
    0.01391671f, 0.00234151f, -0.04246427f, 0.02621781f, -0.04321701f, 0.01929312f, 0.00492606f, -0.01026360f, 
    -0.01053263f, 0.02960029f, 0.02099461f, 0.00581130f, -0.02760001f, -0.03075020f, -0.03912923f, -0.00700806f, 
    0.01169876f, -0.00278273f, 0.02330666f, 0.03089835f, 0.01682950f, 0.01717287f, 0.00910232f, -0.01140633f, 
    -0.02575209f, -0.03694908f, 0.02004605f, -0.01493881f, -0.03411876f, -0.02723981f, -0.03123511f, -0.02313871f, 
    -0.02240663f, -0.01569559f, 0.01422815f, 0.00900253f, 0.02144455f, 0.03054908f, 0.01235563f, -0.00904877f, 
    0.02631719f, 0.01045084f, 0.02687910f, -0.03622572f, -0.01854393f, 0.02247033f, 0.01232729f, -0.03147256f, 
    -0.03425800f, 0.01365900f, -0.03647923f, -0.03207261f, -0.02652558f, 0.02209633f, -0.03404279f, -0.01120707f, 
    0.01981167f, -0.01272510f, -0.01895463f, 0.01505272f, 0.01538621f, 0.02529124f, -0.03467663f, -0.00401634f, 
    -0.02838819f, -0.01699478f, 0.00817279f, -0.02057929f, 0.00558514f, -0.01259863f, 0.00148694f, -0.00250452f, 
    -0.03586693f, -0.03341068f, 0.00838076f, -0.04112816f, 0.01955144f, 0.02528450f, -0.02243325f, -0.00645930f, 
    0.01975972f, -0.01734642f, -0.01893345f, 0.01412824f, -0.03815759f, -0.01317627f, -0.03050660f, -0.01520942f, 
    0.01414415f, -0.02208716f, 0.01409159f, -0.00010894f, -0.02944049f, 0.00578130f, 0.01355105f, 0.00978045f, 
    0.02736167f, -0.03589214f, -0.03499911f, -0.03297019f, -0.01482622f, 0.03123091f, 0.00748432f, -0.03071320f, 
    -0.02633134f, -0.03422445f, -0.02778345f, -0.02194410f, 0.02329751f, -0.02432939f, -0.04080619f, -0.01965340f, 
    -0.02661856f, -0.02559424f, 0.00099636f, -0.01448370f, -0.04154354f, -0.04397184f, -0.00718890f, 0.02146489f, 
    -0.04333302f, 0.02394568f, -0.02500184f, -0.00576487f, 0.01174295f, -0.01845535f, -0.01196551f, 0.01809594f, 
    -0.01144265f, -0.03393745f, 0.00733226f, 0.01776369f, -0.02762480f, -0.02633129f, -0.02164355f, -0.03859974f, 
    0.00132560f, -0.01809116f, 0.00236601f, 0.01317908f, -0.00794244f, -0.01356083f, 0.01111264f, 0.03550898f, 
    0.01403173f, 0.00537906f, -0.00380320f, -0.04357756f, 0.01305113f, -0.02251522f, -0.02751744f, 0.00701002f, 
    0.02498166f, 0.02464860f, -0.00352462f, 0.00412644f, 0.02680835f, -0.03843824f, -0.00946195f, -0.03412234f, 
    0.00867157f, -0.01000462f, 0.01281344f, -0.02700188f, 0.02684575f, -0.03960170f, -0.00634984f, -0.01635269f, 
    -0.00536760f, -0.03847149f, -0.01167929f, 0.02176068f, 0.01786949f, 0.03791688f, 0.00921600f, 0.00531543f, 
    -0.02875345f, -0.03778682f, 0.01276627f, -0.01600219f, -0.00949396f, 0.01893171f, 0.03065455f, -0.02280567f, 
    -0.00821800f, -0.00709857f, 0.00222618f, 0.02758370f, -0.04075791f, -0.04365086f, 0.00139362f, -0.02985270f, 
    -0.00436094f, -0.03160843f, 0.01935459f, -0.03145678f, 0.02005554f, -0.00959003f, -0.00188418f, -0.04197429f, 
    -0.02949529f, -0.00959718f, 0.01577676f, 0.00009073f, -0.03630871f, 0.00726473f, -0.01306435f, -0.03075371f, 
    0.01878825f, -0.02157436f, -0.02928903f, 0.00387990f, -0.03764064f, 0.01563914f, -0.03806285f, -0.00601824f, 
    -0.02353080f, 0.02644537f, 0.02342776f, 0.02146210f, 0.03031825f, 0.00552077f, -0.00397852f, -0.01676013f, 
    -0.03712347f, -0.01734205f, 0.00920651f, -0.01831804f, 0.00085243f, -0.00536809f, -0.01358319f, 0.01266357f, 
    -0.03216907f, -0.02184339f, -0.02538784f, 0.00405634f, -0.01862966f, -0.00881778f, -0.03677718f, -0.02055532f, 
    -0.03471577f, -0.01273289f, -0.03331409f, 0.01862238f, 0.02559808f, -0.03042402f, 0.00645901f, 0.02620903f, 
    0.00429346f, -0.00757893f, -0.03261270f, 0.00202220f, -0.02128516f, -0.00075213f, 0.02922385f, 0.01134972f, 
    -0.00146151f, -0.02576381f, -0.00601636f, -0.02524199f, 0.00178922f, -0.01502874f, 0.01367227f, 0.03377762f, 
    -0.02290364f, 0.01722794f, 0.00110795f, 0.02483234f, -0.03413647f, -0.02273113f, 0.01322429f, -0.01007476f, 
    -0.01990632f, 0.02330537f, -0.01999515f, -0.00557668f, 0.00044254f, -0.02310462f, 0.01325499f, 0.03262319f, 
    0.00660405f, -0.00117203f, -0.03149235f, 0.00254828f, -0.03307702f, -0.04251374f, -0.03865987f, 0.00593946f, 
    0.00028970f, 0.02909956f, -0.03151945f, -0.03411457f, -0.00177796f, -0.01881483f, 0.01058714f, -0.04194471f, 
    -0.03606867f, -0.00573159f, -0.03892228f, 0.01246304f, -0.03720726f, -0.01240859f, -0.01663526f, -0.03147965f, 
    0.01648293f, -0.00936252f, 0.00025045f, -0.00804120f, -0.01568738f, 0.00879711f, -0.02065101f, 0.02252152f, 
    0.00912947f, -0.01978777f, 0.00816302f, -0.03806503f, 0.01430822f, -0.02122324f, 0.01870324f, 0.02996338f, 
    0.00246229f, 0.02495410f, -0.03206425f, 0.02198930f, 0.01392272f, 0.01627673f, 0.01807771f, -0.02135547f, 
    0.01753580f, -0.02914349f, -0.00331252f, -0.02941472f, -0.00367751f, 0.01382456f, 0.00097527f, -0.02740233f, 
    -0.01394533f, -0.03106955f, 0.01477602f, 0.00238314f, -0.02224327f, 0.00673170f, -0.01452054f, 0.01432990f, 
    0.02761024f, 0.01924140f, -0.00822198f, 0.00983305f, 0.00154540f, -0.03759838f, -0.00795923f, 0.01568666f, 
    -0.02438708f, -0.01586964f, -0.03567345f, 0.01532686f, 0.01119572f, 0.00800524f, -0.02243033f, 0.01076287f, 
    0.00222356f, 0.00949918f, 0.01075138f, 0.00956568f, 0.02470427f, 0.01747192f, -0.02039947f, 0.01738279f, 
    -0.03738238f, -0.00340624f, -0.01069458f, -0.00199788f, -0.02737084f, -0.00618479f, -0.03752371f, 0.01322059f, 
    -0.03754148f, 0.02310804f, 0.02467886f, -0.01174522f, -0.00353248f, -0.02553304f, -0.01006350f, -0.00477506f, 
    -0.04060189f, -0.01817850f, -0.00281409f, -0.04067854f, -0.00164492f, -0.01868535f, -0.03555557f, 0.01127257f, 
    -0.00847657f, 0.01252076f, -0.02418566f, 0.00744604f, -0.00504167f, 0.01207274f, 0.00842750f, -0.04162821f, 
    0.02234753f, 0.02189525f, 0.00611085f, -0.04039839f, 0.00252975f, 0.00641704f, 0.02506733f, -0.01754252f, 
    0.01099220f, 0.00108097f, 0.01496686f, -0.02621641f, -0.01209771f, -0.00027741f, 0.00288997f, 0.01758377f, 
    -0.01134260f, 0.02990675f, -0.02773913f, -0.03894286f, 0.02737532f, -0.04392111f, -0.01967959f, 0.00366864f, 
    0.00990351f, -0.01177186f, -0.01400451f, -0.00583082f, -0.03685898f, -0.01029460f, 0.01176603f, -0.03279501f, 
    -0.03847510f, -0.03936518f, 0.01827352f, -0.03716538f, 0.00001863f, 0.01285444f, 0.00988013f, -0.03698379f, 
    -0.02730873f, -0.00412599f, 0.02683615f, 0.01516526f, 0.00407247f, -0.01880483f, -0.02699224f, -0.02282647f, 
    -0.02819450f, 0.02646915f, 0.02318551f, -0.01151079f, -0.02350528f, 0.01925301f, -0.03303924f, 0.02690144f, 
    -0.01562796f, 0.01144570f, 0.01170103f, -0.01831008f, -0.02554406f, 0.00748422f, -0.04052385f, -0.03830599f, 
    -0.00368861f, -0.00729377f, -0.00974230f, -0.02953388f, -0.03138643f, 0.01932684f, 0.00431483f, 0.01522906f, 
    -0.00928066f, 0.00461303f, 0.02693358f, -0.04224102f, -0.03276179f, -0.03441955f, -0.01121983f, -0.02586703f, 
    0.01169867f, -0.03957988f, -0.00053773f, 0.01024628f, 0.00985801f, 0.02422829f, 0.00041824f, 0.02785840f, 
    -0.00854575f, 0.01348006f, -0.02175458f, 0.01001413f, 0.02092766f, -0.02639627f, -0.01133985f, -0.00745945f, 
    0.01316184f, -0.04160892f, -0.01053652f, -0.02203640f, -0.00276220f, 0.01102349f, -0.02707985f, -0.02841432f, 
    -0.02361139f, -0.03263548f, 0.01356750f, -0.00283056f, -0.00544871f, -0.03970909f, -0.01772489f, -0.02519160f, 
    0.00629417f, -0.01852974f, -0.00401825f, -0.00127964f, 0.00484295f, 0.01232851f, 0.02031552f, 0.02058299f, 
    0.00208505f, 0.00481646f, 0.01615153f, 0.02070800f, -0.01045563f, -0.03732109f, -0.02625977f, -0.00533398f, 
    0.01202595f, -0.02665186f, -0.01895978f, 0.01993066f, 0.00302657f, -0.03428383f, 0.00027780f, -0.03132464f, 
    0.02371652f, -0.00583560f, -0.04220027f, -0.01013131f, -0.03053846f, -0.00089753f, 0.01631586f, -0.02624822f, 
    0.00084830f, -0.03487256f, 0.00975306f, -0.04251915f, -0.02806055f, 0.02279387f, -0.00628961f, -0.00018447f, 
    -0.03907653f, -0.01659378f, 0.02616199f, -0.02541107f, -0.00337986f, 0.01701081f, -0.01387041f, -0.00293021f, 
    0.01918983f, 0.00396705f, 0.00182723f, -0.04167885f, 0.02468428f, 0.02311005f, 0.01854473f, 0.00821736f, 
    -0.03254354f, -0.01645864f, 0.01814783f, 0.02411331f, 0.02470491f, -0.00099191f, -0.03020752f, -0.02388888f, 
    -0.04383921f, -0.00892617f, -0.00521155f, -0.04395965f, -0.02881019f, 0.01170669f, 0.00269118f, 0.01815818f, 
    0.01483433f, 0.00002283f, 0.03103723f, 0.01741241f, -0.01516449f, -0.02756092f, 0.01985102f, -0.00314659f, 
    0.00073232f, 0.01057728f, 0.00073575f, -0.01536711f, 0.00893161f, 0.00871760f, -0.01464516f, 0.01023558f, 
    -0.03371226f, -0.01654266f, 0.00538778f, -0.04002690f, -0.01525249f, -0.03378226f, -0.01513120f, -0.04098829f, 
    0.00554597f, -0.02934631f, -0.03881821f, 0.00439124f, 0.01418392f, -0.03965269f, 0.02608906f, 0.00185437f, 
    -0.01327134f, -0.01784350f, -0.02358943f, -0.00390470f, 0.01693524f, 0.01925346f, -0.03978785f, 0.00534951f, 
    -0.02840940f, 0.00720093f, -0.04396603f, 0.02257005f, 0.02249149f, -0.00551717f, 0.01218812f, 0.01447737f, 
    -0.00192022f, 0.00936072f, -0.01098174f, 0.00964168f, 0.02109273f, 0.02125195f, -0.01426374f, 0.01088848f, 
    -0.00927458f, -0.00682468f, -0.03386251f, 0.02262438f, -0.03135961f, -0.02707223f, -0.02365817f, 0.02076089f, 
    0.00587109f, -0.03441202f, 0.00407938f, 0.02720056f, -0.03741324f, -0.00063740f, 0.00946482f, -0.01063575f, 
    -0.02185895f, -0.00370457f, -0.02871483f, -0.01477353f, -0.02655368f, -0.04218546f, 0.01156780f, -0.02110805f, 
    -0.04098218f, -0.03281661f, -0.02135396f, 0.00933679f, -0.04143254f, 0.00118235f, -0.03449565f, -0.04342404f, 
    -0.04085136f, -0.01851300f, 0.01328431f, 0.02249933f, -0.04054149f, -0.04169909f, 0.02723664f, -0.01347064f, 
    0.01957763f, -0.02476817f, -0.03788764f, 0.00128373f, -0.00799560f, 0.02445840f, -0.03996967f, 0.01708329f, 
    -0.00361134f, -0.00680063f, -0.02791172f, -0.02295608f, -0.02779509f, 0.02446283f, 0.02768414f, -0.02514390f, 
    -0.02983287f, 0.01402853f, -0.02596651f, 0.00114656f, -0.03262359f, 0.01826152f, 0.01503772f, 0.01597624f, 
    0.02559029f, -0.03285968f, -0.00316949f, -0.03313564f, -0.01448621f, -0.02799066f, -0.03867660f, -0.01606583f, 
    0.02054886f, -0.01551812f, -0.00972525f, -0.03415938f, 0.00703094f, 0.01456603f, 0.02727471f, -0.01781010f, 
    0.02342095f, 0.01966786f, 0.01791166f, -0.01465209f, -0.01048673f, -0.02484971f, 0.02334082f, -0.02217033f, 
    0.00402892f, 0.00975015f, -0.00972022f, -0.02613941f, -0.02790580f, 0.01929736f, 0.02313544f, -0.00337687f, 
    -0.00745938f, 0.01283354f, -0.00438610f, 0.02533352f, -0.02998846f, 0.02853169f, -0.01906035f, -0.00558386f, 
    0.02643528f, 0.01273807f, 0.00081949f, -0.02552731f, -0.03106210f, 0.01127305f, -0.00364305f, 0.02803155f, 
    -0.03958391f, 0.01061687f, 0.01376945f, -0.00609400f, -0.03020073f, 0.01232040f, -0.01423234f, 0.01122226f, 
    -0.02135814f, -0.02214054f, 0.02774765f, -0.02271540f, -0.01872958f, 0.00428495f, 0.01724360f, 0.00974440f, 
    -0.03728370f, 0.02784709f, -0.01297617f, -0.03376449f, 0.03001675f, 0.01912505f, -0.02623810f, -0.04126481f, 
    -0.02297107f, 0.01932873f, -0.02125706f, -0.01970931f, -0.02291746f, -0.03115563f, -0.02494041f, 0.01895389f, 
    -0.01224515f, 0.01223287f, -0.01629502f, -0.02889150f, 0.00634584f, -0.00486322f, 0.02354978f, -0.00647069f, 
    -0.02391395f, -0.03112484f, -0.03196698f, -0.01330610f, -0.02262247f, -0.00371538f, 0.02691398f, 0.02654360f, 
    -0.02791134f, -0.00642189f, -0.01465905f, -0.00544297f, -0.04085546f, -0.03162986f, -0.03061788f, -0.02713844f, 
    0.02381203f, 0.02524237f, -0.01192320f, -0.02974526f, -0.01924353f, 0.00556509f, 0.01808844f, -0.02678279f, 
    -0.04362158f, 0.02205705f, -0.01081131f, 0.02079168f, -0.02997603f, -0.03180004f, 0.01529444f, -0.02427393f, 
    -0.03321489f, -0.01718485f, -0.02929785f, -0.00537842f, 0.01269352f, -0.02374953f, 0.00481493f, -0.00875953f, 
    0.01398178f, 0.02289507f, -0.02890320f, -0.00281377f, 0.02741506f, -0.00078717f, 0.01843868f, 0.02417889f, 
    -0.03339563f, -0.00461748f, -0.04010332f, -0.00901771f, -0.01956900f, -0.01219345f, 0.02406492f, -0.02834450f, 
    0.01641763f, -0.00482524f, -0.00504296f, -0.02770052f, -0.01998440f, -0.01422607f, -0.02722716f, -0.00786945f, 
    -0.00744733f, 0.00375452f, 0.01141648f, -0.00397559f, -0.00529651f, -0.02412508f, -0.01678762f, -0.04245149f, 
    0.00612776f, -0.00458768f, -0.04194787f, -0.00865883f, -0.02266075f, 0.02426579f, -0.03853607f, 0.02911318f, 
    -0.03251405f, 0.01923095f, -0.02836159f, 0.00782518f, 0.01231960f, 0.02156749f, -0.01591034f, -0.03439953f, 
    0.00758126f, -0.00036945f, -0.00308092f, 0.02117004f, -0.02720561f, -0.01589608f, 0.02742136f, -0.04269680f, 
    0.00588026f, 0.00375170f, -0.01056050f, -0.04190594f, 0.01051131f, -0.03582666f, -0.01809359f, 0.02201456f, 
    0.00358682f, -0.04192428f, -0.00836621f, 0.00314531f, -0.00968402f, 0.02250316f, 0.00840676f, 0.02438291f, 
    -0.00093965f, 0.02267051f, 0.02495282f, 0.02347581f, 0.02449142f, 0.00656134f, -0.02895598f, -0.00627462f, 
    0.01743231f, -0.00627833f, -0.01701672f, 0.01700429f, -0.01104124f, 0.00888143f, -0.02905240f, -0.01974252f, 
    -0.02283669f, -0.02686458f, -0.00133533f, 0.02567854f, -0.01227014f, -0.02595031f, 0.02534226f, -0.03472806f, 
    0.01528202f, -0.00069378f, 0.01256773f, -0.04193142f, -0.01686962f, 0.00809778f, 0.00766417f, 0.02158356f, 
    0.00109805f, 0.02310577f, -0.01601257f, 0.01700739f, -0.03212516f, 0.01219529f, -0.02573231f, -0.02072671f, 
    -0.00766817f, 0.00050937f, 0.02721586f, 0.01344902f, -0.04143108f, 0.01324726f, -0.03791198f, -0.00894495f, 
    0.00855210f, 0.01835994f, -0.00365406f, 0.01682600f, -0.02507406f, -0.00947522f, -0.03761974f, 0.01469159f, 
    -0.03651556f, -0.02967034f, 0.01993077f, -0.02189507f, -0.00442361f, 0.02304821f, 0.00532699f, 0.02310084f, 
    -0.01096357f, 0.00792065f, -0.00723623f, -0.01483174f, -0.03228607f, 0.02123574f, -0.00488865f, -0.03196577f, 
    -0.00478048f, 0.00028261f, -0.03224045f, -0.01138398f, -0.03519351f, -0.01398984f, -0.02470117f, 0.02164213f, 
    -0.01995721f, 0.02063541f, 0.01292574f, 0.00851032f, 0.01657526f, -0.02379057f, -0.00452953f, 0.01633209f, 
    -0.03677810f, -0.02763339f, 0.00382684f, 0.00145003f, -0.02304575f, -0.04073532f, -0.03781307f, 0.00871611f, 
    -0.00351556f, -0.00906670f, 0.01228241f, 0.00773169f, -0.03172610f, 0.02589017f, 0.00731518f, -0.03693956f, 
    -0.02303900f, -0.04051786f, 0.00272222f, -0.00376588f, 0.01178938f, 0.00691090f, -0.01848242f, 0.00116593f, 
    -0.00897681f, -0.01666501f, -0.02924882f, 0.02511696f, 0.02232473f, 0.01688658f, -0.03966710f, -0.01621898f, 
    -0.04067653f, -0.03502228f, -0.01077488f, 0.02399150f, 0.02640782f, 0.00400970f, -0.01335725f, -0.03778550f, 
    -0.02267782f, 0.00703166f, -0.04081161f, 0.00190598f, 0.00321207f, -0.01304026f, 0.02260846f, -0.01271053f, 
    0.01324493f, -0.03970059f, -0.03354217f, -0.02371513f, -0.02203832f, -0.00663698f, -0.00949513f, 0.00513952f, 
    -0.03023778f, -0.01291261f, -0.03008666f, 0.02665504f, 0.00140084f, 0.00323257f, -0.01750461f, 0.01257904f, 
    -0.01775189f, -0.02874357f, 0.00607820f, -0.02324809f, 0.01708403f, 0.01913689f, 0.01381556f, -0.00535241f, 
    0.02675381f, -0.01751986f, -0.02775371f, 0.01073511f, -0.00512623f, 0.01099042f, -0.01879952f, 0.01867728f, 
    -0.02483325f, -0.01750094f, 0.01613025f, 0.01997228f, -0.00497002f, 0.00573632f, 0.00436905f, -0.02649414f, 
    -0.02476095f, 0.00154472f, -0.01104347f, 0.00666014f, -0.01502611f, -0.01364053f, 0.00204885f, -0.01034014f, 
    0.00424621f, -0.03047892f, 0.00776965f, 0.00116256f, -0.01945260f, 0.02709001f, -0.02587822f, 0.02647599f, 
    -0.01787488f, -0.02289587f, 0.00990637f, 0.01029607f, 0.02942781f, -0.02268795f, 0.00935030f, 0.02313730f, 
    -0.03245042f, -0.03178135f, -0.01423185f, 0.00508096f, 0.02185585f, -0.03362501f, -0.01164417f, 0.02706026f, 
    0.00085310f, 0.02904077f, 0.03358364f, 0.02049196f, -0.03766264f, 0.00059063f, 0.01547958f, 0.02464796f, 
    0.01541092f, 0.02353877f, 0.01415488f, 0.02418917f, -0.01224593f, 0.00861849f, 0.00272564f, 0.01178233f, 
    -0.03365097f, 0.01797631f, 0.02729049f, -0.03092065f, -0.01617001f, -0.00428223f, -0.01021745f, -0.00449831f, 
    -0.00741393f, -0.01952790f, -0.03538679f, 0.01908392f, 0.00724864f, 0.00622163f, 0.00182582f, -0.01099552f, 
    -0.01128210f, -0.03500625f, -0.03498990f, -0.01806388f, 0.03744526f, -0.01806132f, -0.00442119f, -0.02742495f, 
    0.03200647f, -0.03613517f, -0.00536637f, -0.01256051f, 0.02569158f, -0.04215947f, -0.01595781f, -0.00890604f, 
    0.02469320f, 0.03070782f, -0.03057107f, -0.01472471f, -0.02512462f, -0.00898511f, -0.04178362f, -0.02583514f, 
    -0.02420223f, 0.00660906f, 0.02254446f, 0.01757941f, 0.01613521f, -0.00464641f, 0.00277667f, -0.02975583f, 
    -0.02700259f, -0.00452132f, 0.00050569f, 0.00746378f, 0.03128007f, -0.02016558f, 0.00615483f, -0.01919485f, 
    0.02611483f, -0.00853267f, -0.03124953f, -0.02822839f, 0.00091581f, 0.02399367f, 0.01277126f, 0.02989862f, 
    0.02505243f, -0.02815887f, -0.00271712f, 0.02173960f, -0.00136286f, -0.03457010f, -0.01376715f, 0.01420084f, 
    -0.02775447f, -0.02190596f, -0.01024281f, -0.02675633f, 0.00119915f, -0.02320252f, -0.00205368f, -0.01510959f, 
    0.02411979f, -0.00887124f, 0.00360784f, 0.02166218f, -0.03962462f, -0.01783231f, -0.03832724f, -0.00134686f, 
    0.02117133f, -0.01059918f, 0.02772075f, 0.00396466f, -0.02471973f, 0.00018352f, 0.02267242f, -0.03212411f, 
    -0.01561619f, -0.03663718f, 0.01756609f, -0.03255277f, -0.03825873f, -0.03005669f, -0.00262148f, -0.00715707f, 
    0.01137930f, 0.01055508f, -0.01400880f, 0.03245296f, -0.01929302f, -0.01733712f, -0.00695641f, 0.01329680f, 
    -0.03024124f, -0.03057423f, -0.01437759f, -0.02497763f, 0.02185208f, 0.01397329f, 0.02705320f, -0.00264093f, 
    -0.02057838f, -0.02861553f, 0.01261029f, -0.02494944f, 0.03164152f, -0.03272640f, -0.00514731f, 0.01528416f, 
    -0.02693951f, -0.00535662f, 0.02523521f, -0.02938349f, 0.03476999f, 0.00857154f, 0.00085288f, 0.02531552f, 
    0.01102006f, -0.03543789f, 0.01988681f, 0.01313980f, 0.03562674f, -0.03369254f, -0.01461072f, -0.01251030f, 
    -0.01921753f, 0.01227298f, 0.00343202f, -0.03032221f, -0.03577980f, -0.02068856f, 0.02558580f, -0.03219071f, 
    -0.03124992f, 0.02515546f, -0.01457996f, -0.02460989f, 0.01220554f, -0.03756504f, -0.00491546f, -0.02334733f, 
    -0.02883424f, -0.03265607f, 0.01475671f, 0.01052246f, 0.00428551f, 0.00408023f, -0.00436750f, -0.01337146f, 
    -0.03304767f, -0.00355404f, 0.01849308f, 0.00147814f, 0.02308720f, -0.04052017f, -0.03660234f, 0.00744966f, 
    -0.00324051f, -0.03902850f, -0.00895775f, -0.01349220f, -0.03684085f, -0.03396398f, 0.01930030f, -0.04498761f, 
    -0.03380107f, -0.00904358f, -0.02465952f, -0.01321134f, -0.01201378f, -0.03930824f, 0.00537239f, -0.01901410f, 
    0.01275744f, -0.03215124f, -0.02238473f, -0.02582157f, 0.00284607f, 0.02363130f, -0.02959467f, -0.02284155f, 
    0.01531187f, -0.03798330f, 0.02458657f, 0.00076321f, -0.03092404f, 0.00673538f, 0.01316329f, 0.00164754f, 
    -0.03440912f, 0.00346122f, 0.01925634f, -0.00682851f, 0.02033927f, -0.03260189f, -0.00463857f, -0.02028463f, 
    -0.01920306f, -0.00225607f, -0.00040871f, 0.02443560f, -0.00365377f, -0.00616039f, 0.00049227f, -0.02978067f, 
    0.02381148f, 0.00500596f, -0.03789569f, 0.02392587f, 0.01301887f, 0.01768353f, 0.03504857f, -0.03433772f, 
    -0.03527262f, 0.01631456f, 0.02483050f, -0.03725673f, -0.00225125f, -0.00024401f, -0.00207838f, 0.00080831f, 
    -0.00595327f, -0.01290066f, -0.01960075f, 0.02246633f, 0.00890241f, 0.01510035f, 0.01206343f, 0.00000048f, 
    0.02622715f, -0.00059258f, -0.03382470f, 0.01926778f, -0.03912429f, -0.01881182f, 0.03200490f, 0.02314343f, 
    0.03770440f, 0.02270655f, 0.01491231f, 0.02888315f, 0.01006407f, -0.03933904f, 0.02170547f, -0.02624224f, 
    -0.02767324f, -0.02496049f, -0.00654591f, -0.01502057f, 0.01972441f, 0.02557049f, 0.03214692f, 0.02119927f, 
    0.01626678f, -0.00701234f, -0.00939464f, 0.00604681f, -0.00743611f, 0.01400377f, -0.03176974f, -0.01206377f, 
    -0.00427296f, 0.02708293f, -0.00271741f, -0.01631481f, -0.04161470f, -0.03746909f, 0.00298151f, -0.02579630f, 
    0.03223579f, -0.02045897f, -0.00842540f, 0.02809678f, -0.00437507f, -0.03161991f, 0.01233100f, -0.03720405f, 
    -0.01403878f, 0.00049942f, 0.00589519f, 0.01769689f, -0.00957055f, -0.00714809f, -0.03660044f, -0.00884689f, 
    -0.01540372f, 0.00242518f, -0.01431529f, -0.00759616f, 0.01958861f, -0.01153342f, -0.02887755f, -0.04356981f, 
    -0.03890125f, -0.03023574f, 0.01881912f, -0.01289454f, -0.01052771f, 0.01339528f, -0.03650787f, 0.00509475f, 
    0.02153590f, -0.03020488f, 0.01891092f, -0.02026623f, 0.00907386f, 0.01133187f, -0.00180574f, 0.00705347f, 
    0.01467527f, 0.00904436f, 0.01332126f, -0.01142258f, -0.00986566f, -0.00003998f, 0.02155702f, -0.02509403f, 
    0.03030827f, -0.00023586f, -0.03104639f, -0.01141749f, -0.03250264f, 0.00903195f, -0.03366932f, -0.01125174f, 
    0.03115390f, -0.01088062f, 0.02285743f, 0.00528108f, -0.03220234f, 0.01047935f, -0.02927674f, 0.01613610f, 
    0.00709744f, -0.02886588f, 0.00896689f, -0.00825752f, 0.03459546f, -0.04180430f, -0.01740626f, 0.01405027f, 
    -0.02318556f, -0.00494459f, -0.01988182f, 0.00322611f, 0.00404895f, -0.00934644f, -0.02998237f, -0.00864521f, 
    0.02633567f, 0.01721094f, 0.00692724f, 0.02318693f, 0.01028549f, 0.01486796f, -0.04222743f, 0.01397445f, 
    0.01301340f, 0.01455157f, 0.01454766f, -0.00176353f, -0.02016894f, -0.01442070f, 0.01084106f, 0.01047282f, 
    0.01403453f, 0.02469937f, 0.00158856f, 0.02410109f, -0.00660542f, -0.01452256f, 0.00404103f, -0.01609338f, 
    0.03181545f, -0.01624243f, -0.02435339f, 0.02143787f, -0.01574694f, 0.02171271f, -0.03565021f, 0.03062997f, 
    0.02132578f, -0.02283479f, -0.01176293f, -0.01622697f, -0.03994742f, 0.02122992f, -0.01471921f, -0.02840871f, 
    -0.02685074f, 0.02042632f, 0.01209181f, 0.02273803f, -0.03209271f, 0.02667591f, 0.01898719f, 0.03279017f, 
    0.03291053f, 0.03061691f, -0.00844918f, -0.02013876f, 0.02694596f, -0.02752827f, 0.03513462f, -0.03259845f, 
    -0.00392207f, 0.01065887f, 0.00557540f, 0.01587034f, -0.02676945f, 0.02251997f, -0.00731287f, -0.02958002f, 
    -0.02351783f, 0.00134140f, -0.00588251f, 0.01700532f, 0.00544581f, 0.00881917f, 0.01527116f, -0.01580667f, 
    -0.01172462f, -0.00413620f, 0.00420360f, -0.01905135f, 0.02959537f, 0.00594005f, 0.01095204f, 0.02579555f, 
    -0.01518439f, -0.04210568f, 0.02000733f, -0.00689179f, 0.02486551f, -0.01842178f, -0.01394183f, 0.01844446f, 
    -0.01215202f, -0.02770303f, -0.01657475f, -0.03521674f, 0.00951098f, -0.04216837f, -0.02462775f, 0.00654846f, 
    0.03407413f, 0.01138382f, -0.03545694f, 0.02428207f, -0.01692812f, 0.00455906f, -0.01576521f, -0.00382433f, 
    -0.01271240f, -0.01104412f, 0.03353008f, 0.01293129f, -0.02198021f, 0.01245196f, 0.01100505f, -0.01695022f, 
    -0.03071241f, -0.01267307f, -0.01335214f, -0.00657745f, 0.02172676f, 0.01713249f, 0.01273510f, 0.01946282f, 
    -0.00035800f, -0.01698471f, -0.03422877f, -0.03293857f, 0.00054390f, -0.03850082f, -0.01151246f, 0.00910388f, 
    0.02554920f, -0.02099633f, -0.02073980f, -0.02487242f, 0.02894846f, -0.00656039f, -0.02433881f, -0.02800452f, 
    -0.02528864f, -0.01381658f, 0.01950596f, 0.00120889f, -0.00276057f, -0.01164199f, -0.02258088f, -0.02315447f, 
    0.02978347f, -0.01563893f, -0.01658242f, -0.00729128f, 0.01164403f, 0.02197769f, -0.01547691f, 0.01794018f, 
    0.01671385f, -0.02089981f, -0.03374814f, 0.01922138f, 0.01106758f, 0.01614244f, 0.02254404f, -0.01891051f, 
    -0.00712869f, -0.01664029f, -0.01341801f, 0.01250592f, 0.02464079f, -0.00847841f, 0.02449987f, -0.00449432f, 
    0.02582143f, -0.00094353f, -0.03741353f, 0.03648372f, -0.02735757f, -0.00624325f, -0.04140020f, -0.02778465f, 
    -0.01399682f, 0.00231206f, 0.02057320f, -0.01063406f, 0.00238229f, 0.02527742f, 0.00911262f, 0.01678778f, 
    0.01446755f, 0.02646178f, -0.02767391f, 0.02481437f, -0.03905727f, -0.03685850f, -0.02697740f, 0.00432987f, 
    -0.03526834f, 0.01824064f, 0.02109946f, -0.01946122f, -0.03680728f, 0.02030998f, -0.00152760f, -0.03331663f, 
    -0.00597672f, 0.00331625f, -0.03145649f, 0.01366038f, -0.03928751f, -0.02180146f, 0.00527040f, -0.00278623f, 
    -0.04073685f, -0.02365897f, -0.01606973f, -0.01782887f, -0.03809028f, 0.00380518f, 0.00664451f, -0.02541676f, 
    0.00248080f, 0.02743770f, -0.03637626f, 0.01579107f, -0.03174509f, -0.03878672f, -0.03455602f, 0.02614204f, 
    -0.04382412f, -0.03624671f, -0.01538820f, 0.03004589f, -0.01589898f, -0.03180023f, -0.03385163f, 0.01760720f, 
    -0.04051059f, -0.00955417f, -0.00429903f, -0.03838738f, -0.03566479f, 0.01901006f, -0.02320958f, 0.01577717f, 
    -0.02916369f, -0.01587407f, -0.02040600f, -0.00895358f, 0.00543615f, 0.02924880f, 0.00476972f, 0.01484744f, 
    -0.04016043f, -0.03141746f, -0.01450657f, -0.02169165f, 0.01309711f, 0.02581381f, 0.02294981f, 0.03332205f, 
    -0.03428824f, 0.00484722f, -0.02315198f, -0.03740578f, -0.01284846f, -0.01622094f, -0.02975489f, 0.01314242f, 
    0.03139024f, -0.00686772f, 0.02374534f, -0.00809807f, -0.03080524f, 0.02514798f, -0.03774794f, -0.02576406f, 
    -0.03496508f, 0.00937919f, -0.01286068f, 0.00125217f, 0.02243114f, -0.02012842f, 0.01257418f, -0.00864521f, 
    -0.03408906f, 0.00862810f, -0.00165439f, 0.00727955f, 0.02830555f, 0.00176117f, 0.01818048f, -0.00736537f, 
    0.00516773f, 0.00987255f, -0.02805356f, -0.02299637f, -0.03341393f, -0.00617203f, 0.00056035f, -0.01756461f, 
    0.02291681f, -0.02377923f, -0.03123327f, -0.01301970f, 0.01972349f, -0.01494060f, -0.01582767f, -0.01869778f, 
    0.01428950f, -0.02890109f, -0.01570626f, 0.02845763f, -0.01892854f, -0.03977924f, -0.02125795f, 0.02523902f, 
    0.01130220f, 0.01291429f, 0.03798503f, -0.03318324f, 0.01807648f, 0.01068089f, -0.03399772f, -0.02114046f, 
    0.01959701f, 0.02576919f, 0.01558692f, -0.03580475f, -0.01718489f, 0.00007302f, 0.01151021f, -0.00471206f, 
    0.02242147f, 0.03983967f, -0.00476126f, -0.00136778f, 0.00944981f, -0.02080172f, -0.01171362f, -0.03171296f, 
    0.00307874f, -0.02501437f, 0.00236424f, 0.02413386f, -0.01190707f, -0.00605430f, -0.01859078f, 0.00568015f, 
    0.01131083f, 0.02640044f, -0.03063386f, 0.02094093f, 0.01298144f, -0.02857150f, 0.01129381f, -0.02821689f, 
    -0.02760531f, -0.02367298f, 0.00488891f, 0.02248305f, 0.01922617f, 0.02127167f, 0.00934312f, 0.01357193f, 
    0.01505956f, 0.02703521f, -0.02964697f, -0.01977470f, -0.00598252f, -0.01302458f, -0.03925189f, 0.01490477f, 
    -0.00839688f, 0.01710886f, -0.04204024f, -0.03286930f, -0.03936209f, 0.02322252f, 0.00664059f, -0.03612902f, 
    -0.03320822f, 0.02858174f, 0.01520362f, 0.00283021f, 0.01878165f, -0.02836020f, 0.01050643f, -0.03373919f, 
    0.02480976f, 0.01687690f, -0.00251625f, -0.02874836f, -0.01680846f, 0.02766717f, -0.03242424f, 0.01831138f, 
    -0.02805383f, -0.01088724f, 0.00830432f, 0.00798883f, -0.03130865f, -0.02860645f, 0.00065418f, -0.02355507f, 
    -0.01917259f, -0.03056948f, -0.00202118f, -0.01649021f, -0.00117490f, -0.01765226f, -0.00287401f, -0.03975821f, 
    0.02260179f, -0.02595604f, -0.01371112f, -0.02421212f, 0.02165394f, 0.02819602f, 0.01134613f, 0.02225565f, 
    -0.02552849f, -0.00662126f, -0.02645667f, -0.00035709f, -0.01200368f, -0.03571476f, 0.00385176f, 0.00147128f, 
    -0.00100099f, 0.02254302f, -0.01605441f, -0.00623041f, -0.03145307f, 0.02612826f, -0.00583756f, 0.00104634f, 
    -0.01973217f, 0.00091923f, 0.01401266f, -0.00586244f, 0.02590274f, -0.02673588f, 0.01919644f, 0.01540532f, 
    0.02499516f, -0.01939075f, -0.02575867f, 0.02534132f, -0.03955424f, -0.00583252f, 0.00297109f, 0.01311028f, 
    0.00719345f, -0.04079205f, 0.01323163f, -0.03889421f, -0.01647068f, 0.00186788f, 0.00212281f, -0.01024718f, 
    0.02070208f, -0.00019518f, 0.00447162f, -0.01774941f, -0.01312666f, 0.03697471f, -0.04034314f, 0.00821973f, 
    -0.01920685f, 0.02767660f, 0.02869925f, -0.01922924f, 0.02236205f, -0.01136611f, -0.03493757f, 0.00869078f, 
    -0.03397427f, -0.04005843f, -0.03339719f, -0.00567447f, -0.03635412f, -0.00165576f, 0.01695643f, 0.01305449f, 
    -0.01199944f, -0.02281782f, 0.00969265f, 0.01292213f, -0.02541270f, 0.02697701f, 0.01182701f, -0.01913828f, 
    -0.02202338f, -0.01792327f, -0.02371364f, -0.01291278f, -0.00219285f, 0.01994038f, -0.00247061f, -0.00947291f, 
    0.00271623f, 0.01261297f, 0.00048881f, 0.02707257f, -0.02362314f, -0.01576254f, 0.00368662f, 0.00251579f, 
    0.02467713f, -0.00183797f, -0.04012565f, -0.00074345f, 0.01549334f, -0.01811482f, 0.02006346f, 0.01440573f, 
    -0.00812705f, 0.00787577f, 0.00882258f, 0.02114466f, 0.01979917f, -0.03060342f, -0.03343481f, -0.03629448f, 
    -0.02394945f, 0.02667795f, -0.02372387f, 0.01618970f, -0.00795094f, -0.03435192f, 0.01380100f, 0.00047184f, 
    0.02005065f, 0.00958145f, -0.04157979f, -0.02284079f, 0.01295668f, 0.02094047f, -0.03972565f, -0.00020236f, 
    0.00815345f, -0.02821111f, 0.00643960f, 0.02838103f, 0.01204997f, 0.02780283f, -0.03651903f, 0.01846025f, 
    -0.00477299f, 0.02163506f, 0.02713214f, -0.03689696f, -0.03613865f, -0.03405717f, 0.00359050f, 0.02734298f, 
    0.02660851f, 0.00992359f, -0.03419290f, -0.04176409f, -0.00839049f, -0.02482500f, 0.01290145f, -0.02991669f, 
    -0.01569102f, -0.02810180f, -0.02593267f, 0.00431358f, 0.02458168f, 0.02414149f, 0.00076674f, -0.00998144f, 
    -0.01070818f, 0.00424318f, -0.00392869f, 0.02015097f, 0.00060165f, -0.03627212f, 0.00032187f, -0.02657296f, 
    -0.00043261f, -0.00082193f, -0.03361386f, 0.02854651f, 0.02898654f, -0.01345269f, -0.02716810f, 0.02042529f, 
    -0.04046316f, -0.03802062f, -0.02557795f, 0.02132143f, 0.02662372f, 0.00787736f, -0.02539588f, -0.03518521f, 
    -0.00501890f, 0.01379610f, 0.00607156f, -0.03530844f, 0.02383622f, -0.00297788f, 0.01742683f, 0.01968231f, 
    0.00992654f, -0.00230144f, 0.00635914f, 0.02500956f, -0.02846889f, -0.01373747f, -0.02824010f, -0.02290575f, 
    -0.00852327f, 0.00611008f, 0.02642096f, 0.01207377f, 0.00334019f, 0.01969468f, -0.01614905f, 0.02281956f, 
    -0.03332818f, 0.01573257f, -0.02341996f, -0.03342526f, -0.00160812f, -0.03438084f, 0.00187394f, -0.00475556f, 
    -0.00493243f, -0.02280815f, -0.02830880f, 0.01266559f, -0.02701750f, 0.00409942f, 0.00647326f, 0.01979543f, 
    -0.01296118f, -0.01537321f, 0.02280083f, -0.02958929f, -0.01281201f, -0.02192252f, -0.00347142f, -0.01711882f, 
    -0.00094875f, -0.01685026f, -0.03194880f, 0.02993498f, -0.00176259f, -0.02697115f, -0.01447033f, 0.02286065f, 
    0.01468545f, -0.01742251f, 0.02756224f, -0.02693541f, -0.01318634f, -0.04169585f, 0.02273426f, 0.00867885f, 
    -0.01456565f, -0.01262763f, -0.03783887f, -0.01586971f, -0.03317031f, -0.02382203f, -0.03700704f, -0.02072330f, 
    -0.03081110f, 0.00336194f, 0.02440775f, -0.03198664f, 0.00514381f, 0.01066724f, -0.01739705f, 0.00530820f, 
    0.00540319f, 0.01317007f, -0.02814222f, -0.00092292f, -0.00498092f, -0.02522517f, 0.01776858f, 0.02968955f, 
    0.02091662f, 0.02642616f, -0.04176626f, -0.02909793f, 0.02753490f, 0.01969725f, -0.03419968f, 0.02420007f, 
    -0.02906820f, 0.02777548f, -0.01986671f, -0.02901565f, -0.03794973f, 0.01458331f, -0.00126971f, -0.02844618f, 
    0.01238746f, 0.00164122f, -0.03638185f, -0.02966394f, -0.00417747f, -0.03521083f, 0.01697593f, 0.01100923f, 
    -0.00120967f, -0.00034190f, -0.00809962f, -0.00762144f, -0.00950847f, -0.03264064f, -0.01386959f, 0.01175754f, 
    -0.01551625f, -0.03445814f, -0.00794438f, -0.03277909f, -0.03651767f, -0.00197171f, -0.03050529f, 0.02378822f, 
    -0.01385920f, -0.00948295f, 0.00972070f, 0.01911541f, -0.00978485f, 0.01448646f, 0.02378921f, 0.01507775f, 
    -0.01442507f, -0.01355536f, 0.02492093f, -0.03871512f, 0.02707885f, -0.03439825f, -0.02981768f, -0.01054229f, 
    -0.01344576f, 0.00559633f, -0.03880120f, -0.01949768f, -0.01329462f, -0.00745683f, 0.00167241f, -0.00413156f, 
    -0.02956919f, 0.02419353f, -0.02833599f, 0.00031970f, 0.01196988f, -0.03771031f, -0.03452109f, 0.00874742f, 
    -0.02120735f, 0.01877303f, -0.00378594f, 0.01662286f, -0.03602975f, -0.01045671f, -0.01780342f, 0.02973720f, 
    -0.04126351f, 0.02713071f, 0.00085435f, 0.02056517f, 0.02106472f, -0.01202896f, -0.01662412f, -0.00683099f, 
    -0.00385762f, -0.01140170f, 0.01574130f, 0.01934194f, -0.03379040f, 0.01863959f, -0.01415184f, -0.02807923f, 
    0.01484702f, -0.03283062f, -0.03710862f, 0.02705255f, -0.01733840f, -0.03550592f, 0.01991264f, -0.01704886f, 
    -0.02771127f, 0.02815334f, -0.01926241f, -0.03832092f, -0.03029220f, -0.04001322f, 0.00518654f, 0.01524376f, 
    -0.02343196f, 0.02549685f, -0.00135605f, -0.00926969f, -0.00289321f, -0.03811160f, 0.00177749f, 0.01191519f, 
    -0.01121095f, 0.00243965f, -0.02961870f, 0.01384032f, -0.00114332f, 0.01289013f, 0.02208610f, -0.03212079f, 
    -0.00957149f, -0.02373687f, 0.01343016f, -0.00441090f, -0.01038660f, 0.00022580f, 0.01007134f, -0.00902627f, 
    -0.00282545f, -0.03454614f, -0.03609160f, 0.02247259f, -0.03099730f, 0.00487636f, -0.01546255f, 0.02406537f, 
    -0.03977778f, 0.02626025f, 0.02316278f, 0.00891771f, -0.02682595f, 0.02946116f, 0.01712715f, 0.00791391f, 
    -0.01893147f, -0.01655831f, -0.01418842f, -0.00804222f, -0.01607054f, 0.00907393f, 0.00333926f, 0.00943445f, 
    0.00179506f, -0.00834661f, -0.04040752f, -0.04000048f, 0.01698777f, -0.03946917f, 0.02634789f, 0.02788316f, 
    0.01049954f, -0.01815124f, 0.02034362f, -0.01458248f, -0.02545583f, -0.01691876f, -0.04168808f, -0.03157734f, 
    -0.01791216f, -0.01083610f, -0.00855700f, 0.02094983f, -0.02322866f, -0.03633487f, -0.03672510f, 0.01881289f, 
    0.00339879f, -0.03171584f, -0.03212182f, -0.00076635f, -0.02775476f, -0.01664238f, -0.01222304f, 0.01607715f, 
    -0.04176947f, 0.01735851f, -0.03942412f, -0.00562485f, -0.00478396f, -0.04189543f, -0.03848393f, 0.00600198f, 
    -0.02190418f, 0.00804059f, 0.02253281f, -0.01313521f, 0.01119022f, 0.01131728f, -0.03828396f, -0.00466679f, 
    0.00016859f, -0.01854846f, -0.03869900f, 0.02356913f, 0.00420198f, 0.02153282f, -0.03378678f, -0.01946947f, 
    0.02897079f, 0.00878385f, 0.00604939f, -0.00437190f, -0.03743178f, -0.02681011f, -0.02507718f, 0.00857391f, 
    0.00608388f, 0.01299029f, 0.00112275f, 0.00680144f, 0.02792291f, 0.00498495f, 0.00237862f, -0.03660367f, 
    -0.00403700f, -0.01970773f, -0.03919844f, -0.01897998f, -0.03321426f, -0.01197759f, -0.03290556f, 0.02114781f, 
    -0.00349677f, -0.00102334f, 0.00073456f, 0.02294218f, 0.00680524f, 0.01684703f, -0.00885627f, -0.01537764f, 
    -0.04046571f, 0.01402134f, -0.03898023f, 0.02140278f, -0.00111957f, -0.01479465f, 0.01248945f, -0.02033914f, 
    -0.02275791f, -0.03743765f, 0.01768003f, -0.03019894f, 0.01819735f, -0.01666776f, -0.00872284f, -0.02990531f, 
    -0.01294292f, -0.03462781f, 0.02751586f, 0.01748581f, -0.03440704f, -0.03318023f, -0.01439420f, -0.01350329f, 
    0.01095495f, -0.00420884f, -0.03258704f, 0.00286146f, -0.02565323f, -0.01917198f, -0.01869353f, -0.02869707f, 
    0.01576866f, 0.00559866f, 0.01103082f, 0.00285055f, -0.02204345f, -0.02168402f, 0.01257850f, -0.02408274f, 
    0.01285265f, 0.02975465f, 0.01367960f, 0.02028509f, -0.03387160f, -0.00228988f, -0.02841102f, 0.02910509f, 
    -0.00277163f, -0.01839242f, -0.03845308f, 0.00924983f, 0.00598405f, -0.02349590f, -0.01624870f, -0.01205314f, 
    -0.03729294f, -0.03183786f, -0.01713589f, 0.01747352f, -0.02860725f, -0.00702555f, -0.01692989f, 0.01110780f, 
    -0.03151243f, 0.01311968f, 0.01576716f, 0.01954433f, 0.03401978f, 0.01230882f, 0.01986670f, -0.01819929f, 
    -0.00202561f, -0.02915159f, -0.02012078f, -0.01586873f, -0.00524408f, -0.02921877f, 0.00571248f, 0.00214211f, 
    -0.03294320f, -0.03141937f, -0.02464673f, 0.02551980f, -0.03089774f, -0.02460318f, -0.01303103f, 0.00812477f, 
    0.02737981f, -0.01239941f, 0.01473719f, -0.02227021f, 0.00716095f, -0.02043413f, -0.02952317f, 0.00510280f, 
    0.02130857f, -0.02289781f, 0.02672723f, 0.02293247f, -0.02373996f, -0.03260750f, -0.02502913f, 0.01547130f, 
    -0.03248808f, -0.00867421f, -0.00859046f, 0.01503730f, -0.02333944f, -0.01742587f, -0.02215788f, -0.02253206f, 
    -0.00747791f, -0.02781565f, 0.00884833f, -0.03410345f, -0.01547454f, 0.01961092f, -0.02324184f, -0.00857419f, 
    0.02022469f, 0.01846665f, 0.01903982f, 0.02159229f, -0.00100576f, -0.03066666f, -0.02131217f, -0.00451421f, 
    0.00962413f, 0.02640589f, -0.01728143f, -0.04165380f, 0.00171588f, 0.01412743f, 0.02127707f, -0.03743416f, 
    -0.03272849f, -0.01613352f, -0.03172465f, -0.03873989f, -0.01141224f, 0.02037777f, -0.01529565f, -0.00714735f, 
    -0.00575300f, 0.01614000f, 0.00708243f, -0.02621778f, -0.00890942f, 0.00593286f, -0.02190568f, -0.01088116f, 
    -0.00343816f, 0.01725440f, 0.00613843f, 0.01224354f, -0.00717225f, -0.01687784f, -0.01018196f, -0.01154559f, 
    -0.07579315f, 0.15345263f, 0.01215452f, -0.00858935f, -0.10229908f, -0.09316602f, -0.08653452f, -0.08703783f, 
    -0.15345989f, -0.01727891f, 0.07338633f, 0.02578530f, 0.02766627f, 0.08392288f, 0.06901751f, -0.08606751f, 
    -0.07107171f, -0.02325031f, -0.02371633f, 0.04043606f, -0.05048074f, -0.04396376f, -0.02193252f, 0.11944837f, 
    0.15271659f, 0.14366537f, 0.05064266f, -0.16578659f, -0.03452888f, 0.02886481f, 0.07656834f, 0.03179429f, 
    -0.06916363f, 0.10515220f, 0.08149628f, -0.07621813f, -0.12580702f, 0.01441282f, -0.12853961f, -0.01515749f, 
    0.08683479f, 0.07643638f, -0.05502799f, 0.03205257f, -0.07927507f, 0.13877921f, 0.05867039f, -0.01634244f, 
    -0.20080905f, 0.15016232f, 0.07176878f, -0.14275041f, 0.03277157f, 0.00934718f, -0.02273056f, -0.03677724f, 
    -0.00402867f, 0.12661941f, 0.05008355f, -0.11819685f, -0.13102263f, 0.05619481f, -0.12713425f, -0.00977450f, 
    0.02413255f, 0.05565389f, -0.06960780f, -0.10805300f, -0.03344974f, -0.07801524f, 0.05187524f, -0.03429456f, 
    0.12960705f, -0.01083206f, 0.11581030f, -0.16204561f, -0.04939080f, 0.14036004f, -0.00421608f, -0.11840130f, 
    0.02677708f, 0.11225580f, 0.00723739f, -0.00206900f, -0.22959343f, 0.10352634f, -0.07796942f, 0.06339177f, 
    -0.04171043f, 0.04750005f, -0.07500522f, 0.01383006f, -0.03120306f, 0.01628773f, 0.10535670f, -0.08237822f, 
    0.00164869f, -0.00964694f, -0.08506618f, 0.06955995f, 0.02822787f, 0.06748293f, 0.00469366f, 0.05547750f, 
    -0.02445882f, -0.05182719f, -0.12959728f, -0.00253825f, 0.35016483f, -0.01871584f, 0.03746017f, -0.06447787f, 
    -0.02560977f, 0.04680995f, 0.01894812f, -0.07353158f, 0.04581151f, -0.11375063f, -0.12408953f, -0.14938971f, 
    -0.04301115f, -0.05265889f, -0.03233654f, 0.31212938f, 0.09333416f, -0.08719368f, 0.02605556f, -0.04780504f, 
    -0.00112776f, -0.11009903f, -0.05472027f, -0.10547971f, -0.21300085f, 0.15444238f, 0.04126773f, 0.14832330f, 
    -0.04099397f, 0.19885215f, -0.07020840f, -0.08016153f, -0.04724415f, 0.16988909f, -0.02098393f, -0.08897693f, 
    0.04549179f, 0.00846161f, 0.10248492f, -0.11435543f, -0.11836074f, 0.15579854f, 0.11004852f, -0.03483409f, 
    -0.05773204f, 0.04636480f, 0.03526708f, 0.03993878f, -0.03032703f, 0.04360996f, 0.09995088f, 0.04789460f, 
    -0.05210206f, 0.05584968f, 0.07329837f, -0.00884770f, -0.10946544f, 0.03656376f, 0.07588887f, 0.00840929f, 
    0.27977490f, -0.13817006f, -0.03923460f, 0.04516020f, 0.05493697f, 0.00842966f, 0.03556515f, -0.11257157f, 
    0.03727262f, -0.00947020f, 0.00963194f, 0.00743634f, -0.09567968f, -0.03189892f, 0.00015989f, -0.17662439f, 
    0.00867071f, -0.03441442f, -0.01189133f, 0.01088997f, -0.07656202f, -0.00200714f, 0.04164059f, 0.12036934f, 
    -0.10727572f, 0.08257816f, 0.10454167f, -0.32755527f, -0.03715608f, 0.04548851f, -0.03713882f, -0.01291315f, 
    0.06685906f, 0.05707631f, -0.06392083f, -0.09539016f, 0.20498323f, 0.10260995f, -0.12301134f, 0.28934297f, 
    -0.12579183f, -0.05415862f, 0.06980637f, 0.03659679f, -0.02164524f, -0.07424679f, 0.10763277f, 0.14059311f, 
    -0.07556321f, 0.13042614f, -0.02696841f, -0.21777107f, 0.04462440f, -0.03710803f, 0.02855850f, -0.02135405f, 
    0.03699755f, 0.02728727f, 0.06923683f, -0.04789203f, 0.30799192f, 0.03531406f, 0.02285647f, 0.01308309f, 
    0.00288635f, 0.03197289f, 0.11019474f, -0.06897292f, 0.05547354f, -0.06638104f, -0.07869833f, -0.08157728f, 
    0.23771606f, 0.22878888f, 0.18760465f, 0.01263996f, 0.06038380f, 0.06484172f, 0.12045246f, -0.02971974f, 
    0.02176369f, -0.09704246f, 0.03332338f, -0.05981686f, 0.00251839f, 0.25548783f, 0.18360689f, 0.12146602f, 
    -0.03430188f, 0.01248293f, -0.00793121f, 0.01773995f, 0.02431457f, -0.03589140f, -0.03547727f, -0.10006996f, 
    -0.03287027f, 0.04131843f, -0.07201051f, 0.05713787f, 0.08770811f, 0.07810903f, 0.00240680f, 0.00854462f, 
    0.01062827f, -0.07126262f, 0.09155639f, 0.00419593f, -0.18844026f, 0.04488141f, -0.16596311f, 0.07749660f, 
    0.04666082f, 0.09057585f, 0.01484073f, -0.08604098f, 0.03843224f, -0.04020673f, 0.04225428f, 0.00585625f, 
    0.03790502f, -0.03422133f, 0.14019011f, 0.15529424f, 0.06676699f, -0.10317557f, 0.00511455f, 0.04147758f, 
    -0.08224471f, 0.08052979f, -0.17039034f, 0.04345176f, -0.33261934f, -0.13772467f, 0.09919861f, -0.12374618f, 
    0.00984124f, 0.13426094f, -0.02949893f, -0.02042925f, 0.10787639f, 0.02754811f, -0.15987676f, -0.02734803f, 
    0.33128357f, -0.04157317f, 0.11053451f, -0.03258601f, -0.02962920f, -0.01770656f, -0.02099226f, -0.00598333f, 
    -0.06979143f, 0.11597651f, 0.13816729f, 0.22395000f, -0.11078295f, -0.06463856f, 0.01981582f, -0.06746380f, 
    0.10541721f, 0.01112755f, -0.06541724f, -0.10442827f, -0.04972683f, 0.05606171f, -0.13645187f, 0.08982110f, 
    0.13482837f, 0.19883956f, 0.10602730f, 0.35274914f, -0.05137289f, 0.03490923f, -0.01902800f, 0.07747703f, 
    -0.08177190f, 0.02488408f, 0.14856948f, -0.07719693f, 0.06267373f, -0.01804827f, 0.08642704f, -0.20300752f, 
    0.04548780f, 0.03134264f, 0.04214121f, 0.07306155f, -0.16029245f, -0.12482724f, 0.12465589f, -0.09885239f, 
    -0.15724061f, 0.01787823f, 0.09921307f, 0.06629070f, 0.08445603f, -0.08284045f, 0.08777323f, 0.06383331f, 
    0.04042714f, 0.05183130f, 0.05953418f, -0.03931334f, 0.01819090f, 0.13893557f, 0.04192203f, -0.29801294f, 
    0.01641669f, 0.04633287f, 0.17032985f, 0.03213769f, -0.03782022f, 0.07507700f, 0.03041857f, 0.05910035f, 
    -0.25939494f, 0.23942219f, 0.08825242f, 0.27448970f, -0.06229659f, -0.01301872f, 0.01366795f, -0.01922524f, 
    -0.03822110f, -0.04820707f, 0.09295758f, 0.01543813f, 0.13444580f, 0.21521376f, -0.10207538f, 0.06556125f, 
    -0.03177505f, 0.01995564f, -0.02143035f, -0.10466854f, 0.01849085f, 0.07667549f, -0.05093407f, 0.05951772f, 
    0.18327014f, -0.02795336f, 0.03116012f, -0.03044629f, -0.04681955f, -0.04887072f, 0.10558247f, 0.10519787f, 
    0.07325806f, 0.15789920f, -0.00269027f, 0.10155322f, -0.11848918f, 0.05721607f, 0.14856684f, 0.18358751f, 
    0.00733801f, -0.08122919f, 0.25021762f, -0.01166109f, -0.03551937f, -0.05020796f, 0.07592120f, -0.02580568f, 
    -0.12580243f, 0.04496823f, 0.00824070f, 0.22300413f, 0.10749474f, 0.06107402f, 0.21669124f, -0.08411282f, 
    -0.11707805f, 0.12053181f, 0.01637108f, 0.05046852f, -0.13520007f, 0.00523378f, -0.03248338f, 0.21257040f, 
    -0.06924807f, -0.10131828f, 0.04391655f, -0.07810594f, -0.05742285f, 0.09025243f, 0.01349482f, 0.04265841f, 
    0.16716549f, 0.07123563f, 0.07875541f, 0.35309529f, -0.03772624f, 0.05125301f, 0.04949384f, 0.09672172f, 
    -0.03290537f, 0.02420588f, 0.01903019f, 0.03377175f, 0.32752997f, -0.01238176f, -0.20490864f, -0.08297450f, 
    0.03612889f, 0.10443586f, 0.00811116f, 0.01916896f, -0.11773347f, -0.00242962f, 0.02178990f, -0.11828814f, 
    0.02868132f, 0.00639626f, 0.09504600f, -0.15179770f, 0.00419266f, -0.02665308f, -0.09506317f, -0.03330807f, 
    -0.06898274f, 0.07389359f, 0.04466997f, 0.07102478f, -0.07089636f, -0.00231154f, 0.02417669f, -0.01948158f, 
    -0.01839973f, -0.02358392f, 0.07831437f, -0.03552465f, 0.00390213f, 0.01908727f, 0.03184256f, -0.12567127f, 
    0.15563402f, 0.05992755f, -0.09914912f, 0.00231235f, -0.07948623f, -0.02987873f, 0.08298175f, 0.05550084f, 
    0.13755003f, -0.14681022f, -0.01843421f, -0.08094519f, 0.13539100f, -0.16042906f, 0.15820721f, -0.00155080f, 
    -0.07035679f, -0.02519211f, 0.00301158f, 0.17278931f, 0.09726765f, -0.03872789f, -0.11099790f, -0.02472587f, 
    -0.15360977f, -0.15227807f, -0.06270659f, -0.00621093f, 0.00904290f, -0.01160792f, -0.10521948f, -0.03839358f, 
    -0.03081392f, 0.00413046f, -0.07720842f, -0.03713878f, -0.32465327f, 0.13697118f, -0.08544202f, 0.31643817f, 
    0.06893743f, -0.00896280f, 0.02280340f, 0.04847781f, 0.12305219f, -0.13398656f, 0.06137060f, -0.09375816f, 
    -0.16326170f, 0.21974705f, 0.03994370f, -0.05816982f, -0.04361952f, -0.00548677f, -0.01212164f, -0.06426498f, 
    0.05103869f, 0.05433054f, -0.03780417f, -0.00648530f, -0.27974093f, -0.01055977f, 0.05867209f, -0.15894522f, 
    0.01050153f, 0.04381003f, -0.00732581f, -0.07042374f, 0.01095049f, 0.06642807f, -0.10497531f, -0.14806776f, 
    -0.35248178f, 0.14532094f, -0.01586525f, -0.06828899f, -0.01725997f, 0.18413146f, 0.01182590f, 0.09747060f, 
    0.02291232f, -0.00659909f, -0.00656287f, -0.04779280f, 0.46793282f, -0.06529971f, 0.01705278f, -0.00129372f, 
    0.15193081f, -0.02505189f, 0.10850159f, -0.16561185f, 0.05329304f, 0.07863901f, -0.03274975f, -0.14542015f, 
    -0.28226718f, -0.02510485f, -0.04120996f, -0.00749194f, -0.01711796f, 0.05830862f, 0.06078828f, 0.07494134f, 
    0.05858533f, 0.07675568f, 0.15378343f, 0.12825389f, 0.10127541f, 0.02887747f, 0.13740005f, -0.12464388f, 
    0.10838739f, -0.13549827f, 0.11792486f, 0.01687478f, -0.02618563f, 0.02142916f, 0.01176043f, 0.06257368f, 
    -0.19191192f, 0.13462278f, -0.00290694f, 0.04934024f, 0.01032022f, -0.08135624f, -0.07781716f, -0.11466870f, 
    -0.10155729f, 0.02498065f, 0.02171820f, 0.04001829f, -0.03860278f, -0.14481656f, -0.09288473f, -0.01534993f, 
    0.01812366f, 0.02298217f, -0.01797362f, -0.12249019f, 0.11314494f, -0.01144140f, 0.00375933f, -0.04725258f, 
    0.20046361f, 0.26401776f, -0.21537654f, 0.10330231f, 0.05850413f, -0.03063245f, -0.03085236f, -0.09825592f, 
    -0.11359514f, 0.08955015f, 0.11556634f, 0.03997156f, 0.02431585f, 0.11210209f, -0.01148357f, 0.33022204f, 
    -0.01283065f, 0.06988563f, 0.07202443f, -0.01225596f, -0.08193590f, 0.15876222f, 0.07450577f, 0.03777939f, 
    -0.01218003f, 0.05205976f, 0.06766541f, 0.26245317f, -0.03018051f, 0.04327526f, 0.04389638f, 0.02544391f, 
    -0.12356037f, 0.28955346f, 0.15487631f, 0.14422683f, -0.07442798f, 0.03877967f, -0.18653460f, 0.18487477f, 
    0.02279570f, -0.06208230f, 0.03905054f, -0.11063728f, 0.02769283f, 0.05543696f, 0.03003563f, -0.01915842f, 
    0.17224237f, -0.01182539f, 0.07456673f, 0.19089876f, 0.11385099f, -0.11461264f, 0.11091504f, 0.10798680f, 
    0.01007948f, 0.02384238f, -0.01643132f, 0.07486840f, 0.01485278f, -0.01351257f, 0.00604206f, 0.12921326f, 
    -0.00559097f, 0.09498350f, -0.06321631f, -0.03036757f, 0.06327825f, -0.00774380f, -0.11439095f, -0.14285448f, 
    -0.14559548f, -0.03316929f, -0.00588202f, -0.14389846f, 0.01024923f, -0.00370781f, -0.10462512f, 0.01490664f, 
    0.10441396f, -0.11839496f, 0.07706851f, -0.09591811f, 0.06253657f, 0.01313434f, -0.04334942f, -0.06743078f, 
    0.03553144f, -0.14020506f, -0.03002739f, 0.04388115f, -0.01530638f, -0.03893684f, -0.04966778f, 0.03149218f, 
    -0.08515835f, 0.14257722f, 0.07705195f, -0.08971077f, 0.03212780f, -0.06767581f, -0.03726268f, 0.01926308f, 
    0.08410462f, 0.02790930f, 0.00940041f, -0.07024322f, 0.29274037f, -0.18041758f, 0.03659431f, -0.00978179f, 
    -0.01779685f, 0.12165927f, 0.01348565f, -0.13067217f, -0.08193128f, 0.04877188f, 0.15181006f, 0.02254946f, 
    0.04546671f, -0.14661723f, 0.17069159f, 0.11594380f, 0.01023174f, -0.06272047f, -0.03365824f, 0.08348495f, 
    0.02091006f, 0.01889767f, -0.06231459f, 0.01643187f, 0.23274562f, 0.03858570f, -0.04010267f, 0.23718630f, 
    -0.00006779f, 0.14401954f, 0.06948075f, 0.04235196f, 0.02074750f, 0.05508832f, 0.06071716f, 0.06530326f, 
    0.11050673f, -0.03204624f, -0.02998675f, -0.29517210f, 0.01552415f, 0.06873613f, 0.05044528f, -0.02651023f, 
    0.05407977f, 0.07065570f, -0.10258859f, -0.02980687f, 0.13208911f, -0.13798274f, -0.20263630f, 0.45293248f, 
    -0.01453895f, -0.01927705f, 0.15564339f, 0.11906245f, -0.02748877f, 0.01136885f, -0.01604087f, -0.00260543f, 
    0.06157410f, 0.07212406f, -0.11895137f, -0.00970876f, 0.06216407f, -0.03749199f, 0.04674208f, 0.06390389f, 
    0.06179189f, 0.04000362f, -0.00199776f, 0.06216937f, 0.11478255f, 0.08727273f, -0.06636176f, 0.32531592f, 
    0.07005636f, -0.03701852f, 0.04604918f, -0.02201025f, 0.01458019f, 0.02147611f, -0.01530995f, -0.04021898f, 
    0.04251751f, 0.29040790f, 0.13713013f, 0.11541049f, 0.00277896f, 0.02010604f, -0.11587965f, 0.11453311f, 
    0.09038755f, 0.04345261f, 0.03895795f, -0.12951070f, 0.08603580f, -0.05286220f, 0.04372915f, 0.28446978f, 
    0.01618090f, -0.05241435f, 0.12390240f, -0.10347099f, 0.03891930f, 0.03204289f, 0.08905730f, 0.00226291f, 
    0.42109963f, 0.06911601f, 0.04008555f, 0.41109076f, 0.07250752f, -0.04318755f, -0.08195429f, -0.00903739f, 
    -0.02408358f, 0.03993069f, -0.00729432f, -0.04560115f, 0.04833572f, 0.09470876f, 0.12714608f, -0.05065922f, 
    0.04860513f, 0.00216960f, 0.02359573f, 0.01015688f, 0.05512124f, -0.02929359f, 0.01653156f, 0.07206465f, 
    0.07230447f, 0.03868093f, 0.04267469f, 0.27935112f, 0.17770925f, -0.01354831f, 0.05014702f, -0.07731905f, 
    0.02975010f, 0.08015478f, -0.04266329f, 0.01038224f, 0.16094828f, 0.05674442f, 0.04185301f, -0.01313719f, 
    -0.08764848f, -0.13950835f, -0.07811657f, -0.00567724f, 0.00938753f, 0.03138798f, 0.03496798f, -0.04332241f, 
    0.07843586f, 0.09158897f, -0.03063497f, -0.18569301f, 0.05090890f, 0.02754224f, 0.03763444f, 0.12478220f, 
    0.06153135f, 0.07037122f, 0.10695652f, -0.10637935f, 0.03247023f, 0.35810798f, -0.00754257f, 0.05684588f, 
    -0.05597100f, -0.17428133f, -0.00904703f, -0.07759705f, -0.01538928f, 0.05817189f, 0.00924965f, -0.01429605f, 
    -0.28426155f, 0.14413957f, 0.07567009f, 0.02150553f, 0.13419573f, 0.07855681f, -0.01822826f, 0.00212528f, 
    -0.02498922f, -0.03060387f, -0.04572690f, -0.02742338f, -0.10643875f, -0.29537514f, 0.02426644f, -0.17872843f, 
    0.02811821f, -0.07020688f, -0.01258419f, 0.01070826f, 0.00578343f, 0.03867036f, -0.00212396f, -0.05227906f, 
    0.07562693f, -0.20053016f, 0.07803475f, 0.23079272f, 0.06161293f, 0.10096749f, 0.13038643f, -0.01808437f, 
    -0.10442682f, -0.01207326f, 0.12448403f, 0.19791023f, -0.20579879f, 0.02890266f, -0.10003091f, 0.00990404f, 
    -0.14217779f, -0.00899899f, 0.03746631f, -0.01402265f, 0.05685125f, 0.05683409f, 0.00777475f, -0.10691579f, 
    0.11834264f, -0.32018793f, -0.05095077f, 0.17696632f, -0.00134431f, 0.06239507f, 0.00486756f, 0.04642038f, 
    0.14335014f, -0.03365278f, -0.01977856f, 0.15296894f, -0.04166550f, 0.12608558f, 0.09715413f, -0.00252514f, 
    0.12680189f, 0.07020202f, -0.06287889f, -0.00757845f, -0.00420874f, -0.07446303f, -0.12559931f, 0.03578162f, 
    0.20208408f, 0.22390537f, 0.00479137f, 0.06348484f, 0.00789420f, -0.07131107f, -0.06433979f, -0.02549587f, 
    -0.01425664f, 0.01360415f, -0.02590878f, -0.09397300f, 0.04285805f, 0.06345417f, -0.02883779f, 0.15161282f, 
    -0.08802650f, -0.05607596f, -0.00998859f, 0.02006669f, 0.09835897f, 0.03441771f, 0.05481314f, -0.05036003f, 
    0.33408830f, 0.16975752f, -0.04271574f, 0.18442976f, 0.05827371f, 0.04450089f, 0.01740588f, -0.01328225f, 
    -0.03431891f, 0.10467964f, 0.10378605f, -0.02024329f, 0.15958458f, -0.07206668f, -0.13769810f, 0.04662713f, 
    0.05350888f, -0.07195992f, 0.05986347f, 0.03426335f, -0.04651151f, 0.16418411f, -0.02550015f, -0.03435737f, 
    -0.08925657f, 0.10173982f, -0.03023277f, -0.08806501f, -0.02263829f, 0.08211818f, 0.11207235f, -0.01978480f, 
    -0.11301638f, 0.05799949f, -0.02988045f, 0.04405146f, -0.04962707f, -0.33206436f, -0.06346977f, -0.02194190f, 
    -0.03385562f, -0.00154507f, -0.06749583f, 0.08788012f, 0.07031255f, 0.09228532f, 0.06698030f, -0.14638284f, 
    -0.06160178f, 0.12950189f, -0.15757133f, -0.01425730f, -0.06333969f, 0.10835200f, 0.12191553f, 0.12904944f, 
    -0.10714044f, -0.00530698f, 0.15309715f, -0.00053741f, 0.13986053f, 0.02542407f, 0.01332668f, 0.24118833f, 
    0.04749204f, 0.12320367f, -0.00065988f, -0.00008850f, 0.02012689f, 0.05687029f, -0.02119500f, 0.03167239f, 
    0.02145045f, 0.12765367f, 0.08744642f, 0.06933271f, 0.01198108f, -0.01729942f, -0.05081991f, 0.03594683f, 
    0.00304896f, 0.08361180f, -0.00339313f, -0.09556521f, 0.03736975f, 0.05100134f, -0.19861239f, -0.39000282f, 
    -0.00897815f, 0.01446526f, 0.00766768f, 0.09785320f, 0.02594097f, -0.08017670f, 0.10074543f, 0.00205268f, 
    0.11212412f, -0.05659132f, -0.13772795f, -0.04296025f, 0.02720936f, -0.11878607f, 0.15650594f, -0.01963130f, 
    0.03863316f, 0.06314741f, -0.04506834f, 0.00322813f, 0.16492780f, -0.14545457f, -0.02699015f, -0.25568554f, 
    0.01249498f, 0.08037826f, 0.02664660f, -0.00803851f, 0.06695247f, 0.05528729f, 0.13323924f, 0.04078203f, 
    -0.01940891f, -0.20840535f, 0.04396924f, 0.08107952f, -0.07358126f, -0.01460980f, -0.00018940f, -0.01065223f, 
    0.00931072f, 0.10729412f, -0.12325320f, -0.01446693f, 0.17150067f, 0.15239102f, -0.02319653f, 0.15729146f, 
    -0.07679126f, -0.05373648f, -0.08400630f, -0.08487052f, 0.05886380f, 0.04083038f, 0.04180363f, -0.04534347f, 
    -0.25719279f, 0.15447196f, 0.07893368f, -0.01938691f, 0.05509350f, -0.11523515f, 0.00719853f, -0.01699285f, 
    -0.13303623f, -0.00251844f, -0.04285015f, 0.02485867f, 0.05457364f, 0.07431604f, 0.05776151f, 0.07093276f, 
    -0.07716533f, 0.11734133f, -0.00488572f, -0.06596009f, -0.00815438f, -0.02136645f, -0.09389066f, -0.07145909f, 
    0.10721648f, 0.21804588f, -0.03613330f, 0.03628899f, -0.12488783f, -0.11357421f, 0.03957270f, 0.03053112f, 
    0.00615977f, -0.04034874f, -0.11651325f, -0.11522367f, -0.44810081f, 0.36931092f, -0.13216543f, 0.07781736f, 
    -0.06287479f, 0.11675383f, 0.02138781f, 0.09392820f, -0.03209693f, -0.00784751f, -0.15321448f, -0.04846403f, 
    -0.20973155f, 0.00476235f, -0.04308128f, 0.19217896f, -0.08289868f, 0.01264559f, 0.03471144f, 0.04880869f, 
    -0.04955433f, -0.07858480f, -0.02167162f, -0.19227949f, 0.03461375f, 0.09975790f, -0.07630113f, 0.18021680f, 
    0.08665289f, -0.04055952f, -0.08555514f, 0.05127655f, -0.10925982f, 0.05729170f, 0.04677607f, 0.03046922f, 
    0.29606399f, 0.14381844f, 0.10847943f, -0.07543363f, -0.02814231f, 0.11295592f, 0.02367904f, 0.01559390f, 
    -0.00178938f, -0.06182747f, 0.05356244f, 0.10606147f, -0.06073920f, -0.31809118f, -0.11666080f, 0.17611015f, 
    0.14645015f, -0.13993052f, 0.05676191f, 0.01041296f, 0.03085688f, -0.06115690f, -0.10613537f, 0.01177440f, 
    -0.11842412f, -0.07443034f, 0.03016418f, 0.19250178f, -0.00999725f, 0.05235834f, 0.05626811f, 0.01702697f, 
    -0.08592221f, 0.13406432f, 0.13703939f, -0.07540158f, 0.01988290f, 0.06043553f, 0.00608335f, -0.23087575f, 
    -0.03883675f, -0.05098125f, 0.12106267f, 0.01455810f, -0.03287418f, -0.02314120f, 0.02963831f, 0.07087122f, 
    0.02795248f, -0.25113147f, -0.16154529f, 0.12969662f, 0.11796920f, -0.10650574f, 0.01247891f, 0.08689253f, 
    -0.05083208f, -0.01064354f, -0.02657430f, -0.05235154f, -0.06924549f, -0.32447994f, -0.15153341f, 0.02008214f, 
    -0.04605054f, -0.03211149f, 0.12868153f, 0.01867533f, -0.05381858f, 0.03494418f, 0.01567938f, -0.00311040f, 
    0.25747347f, -0.20926413f, -0.15064706f, 0.18545559f, 0.06703883f, 0.03666068f, 0.05564157f, -0.01946872f, 
    0.06767380f, 0.08313458f, 0.16309233f, 0.11492314f, 0.12543286f, -0.21919923f, -0.16908057f, 0.15954357f, 
    -0.00045112f, 0.04066057f, 0.05455599f, -0.02307179f, 0.05575767f, 0.00788829f, 0.08462749f, -0.00277233f, 
    0.01965357f, 0.23357126f, -0.15863213f, -0.03463351f, 0.09926917f, 0.04727884f, 0.01576247f, 0.03185446f, 
    0.00935530f, 0.04980070f, -0.02841345f, -0.05167339f, -0.19350904f, 0.40207395f, 0.05082780f, -0.04039501f, 
    -0.07047815f, -0.03216872f, -0.05636549f, 0.06707660f, 0.10538751f, 0.06920745f, 0.09986689f, 0.01507831f, 
    -0.20616767f, -0.21855904f, -0.08436745f, -0.01602287f, 0.04062515f, 0.00170259f, 0.08577682f, -0.03880373f, 
    -0.01456870f, -0.00337256f, 0.01537182f, -0.01990282f, -0.47622082f, -0.07423810f, 0.00165961f, -0.17410077f, 
    -0.01287805f, 0.17474774f, -0.02551828f, -0.01561273f, 0.04176218f, -0.05288992f, 0.04432474f, -0.02116557f, 
    0.22113265f, 0.06261466f, -0.17684552f, 0.30027992f, 0.04036035f, -0.05215527f, 0.08444975f, 0.04793184f, 
    0.06678155f, -0.01906083f, 0.05285003f, -0.07064862f, 0.17399535f, 0.01979699f, -0.06297469f, 0.17820649f, 
    0.01402912f, -0.15626679f, 0.13995737f, -0.08266909f, 0.05340738f, -0.04509705f, 0.00717352f, 0.09470890f, 
    -0.18965201f, -0.26571727f, -0.06046325f, 0.00673167f, 0.02583316f, 0.05495543f, -0.11106981f, -0.05974969f, 
    -0.08059756f, -0.05104829f, -0.00543423f, -0.02258310f, 0.27046987f, 0.04221486f, -0.15585178f, 0.09873717f, 
    -0.05620544f, -0.04329333f, -0.01353930f, -0.09051929f, -0.01303869f, 0.00864412f, -0.00848961f, 0.06602210f, 
    0.12511458f, 0.15760954f, 0.02353998f, 0.13947037f, 0.01628722f, 0.10651222f, -0.00626496f, -0.08868355f, 
    -0.03911954f, 0.02660951f, -0.04988722f, 0.00125568f, 0.31193626f, 0.00778019f, -0.09140893f, 0.07949444f, 
    -0.06884554f, 0.08941936f, 0.21293457f, -0.10757948f, -0.05847086f, 0.01979619f, -0.09915873f, 0.05101088f, 
    0.12130773f, 0.28510270f, 0.07614172f, 0.21099401f, 0.10342268f, 0.05174856f, 0.00480449f, 0.06681879f, 
    -0.02921637f, 0.01535309f, -0.01091347f, 0.05424818f, -0.15224634f, 0.11033786f, -0.14039095f, 0.00171110f, 
    -0.05928977f, 0.05994911f, -0.12929818f, 0.00932610f, 0.17522460f, 0.06687458f, 0.04594162f, -0.04654758f, 
    0.36726174f, 0.05225846f, -0.00718953f, 0.20067304f, 0.10896420f, -0.10091118f, -0.03308040f, -0.10832281f, 
    0.15552956f, 0.05677601f, -0.01314687f, 0.04347083f, -0.22642423f, -0.09100614f, 0.12096801f, 0.01912778f, 
    0.04666906f, -0.02056640f, 0.05209834f, 0.03603643f, 0.10255302f, -0.07243344f, -0.02520127f, 0.04330795f, 
    0.06856702f, -0.06749300f, -0.04943554f, -0.03503729f, -0.01971482f, 0.07516444f, 0.15810834f, 0.03219936f, 
    -0.05577322f, 0.01215427f, -0.07514754f, 0.08119719f, 0.19099802f, 0.20344603f, 0.04855341f, 0.11503394f, 
    -0.11533251f, -0.06379377f, 0.02621033f, 0.03414836f, -0.02706833f, 0.01490473f, -0.03105207f, -0.00544237f, 
    0.02616579f, -0.03159574f, 0.00551301f, -0.03824751f, -0.00224373f, -0.01444911f, -0.00992271f, 0.02511551f, 
    -0.01425332f, -0.03741241f, 0.00663639f, 0.00280383f, -0.01666466f, -0.00784398f, -0.00902227f, 0.00455753f, 
    -0.01958317f, -0.04191990f, -0.01054963f, 0.02018427f, -0.02361188f, -0.00617978f, 0.02035340f, 0.00628560f, 
    -0.00090648f, -0.02594094f, -0.02350163f, 0.00469103f, 0.02790505f, -0.03378137f, -0.00127231f, 0.01647399f, 
    0.02650011f, -0.02261546f, -0.02134958f, 0.01617506f, 0.02450810f, 0.00428629f, 0.02519797f, 0.00231691f, 
    0.02018562f, -0.00194695f, 0.01811361f, 0.01156366f, 0.00288629f, -0.01818440f, -0.03386745f, -0.01039728f, 
    -0.01708492f, 0.00112800f, -0.02357986f, -0.00999032f, -0.01642576f, -0.01519824f, -0.01272458f, 0.02848547f, 
    -0.01932772f, -0.01421307f, -0.02616461f, -0.03136314f, -0.02131049f, 0.02605712f, -0.01752580f, -0.00137276f, 
    -0.03413261f, -0.00429392f, -0.02205153f, -0.03053893f, -0.02629628f, 0.00915268f, 0.00381718f, -0.03754646f, 
    0.00824514f, 0.01016964f, 0.00710440f, 0.01912583f, -0.03928407f, -0.00956106f, -0.02532465f, -0.03269564f, 
    -0.04070116f, -0.01954372f, -0.01661388f, -0.02068992f, -0.02780318f, -0.02490291f, -0.03773368f, 0.00202026f, 
    -0.01218310f, 0.01213793f, 0.02770956f, -0.00580217f, -0.02387643f, 0.00593925f, 0.02397506f, -0.01990932f, 
    -0.01774652f, 0.02804170f, 0.00200899f, -0.00868899f, -0.00024922f, -0.00152149f, 0.01985884f, 0.00748903f, 
    -0.02294500f, 0.01459904f, 0.02196847f, -0.01207713f, -0.03153579f, 0.01711042f, 0.02833434f, 0.01935673f, 
    -0.00394563f, 0.01363504f, 0.00999485f, -0.04029536f, -0.03049639f, -0.03008967f, -0.00893314f, 0.02466910f, 
    0.01043917f, -0.03330805f, -0.01519940f, 0.00714766f, -0.00823766f, 0.01916231f, 0.01656303f, 0.01870800f, 
    -0.01623487f, -0.00843288f, 0.00207758f, -0.01560011f, 0.01187789f, 0.01026936f, 0.00714170f, 0.02480448f, 
    0.01399176f, -0.02762068f, 0.01034298f, -0.02860028f, 0.00316364f, -0.02699254f, -0.00066637f, 0.01012081f, 
    0.01492835f, -0.01739657f, 0.01718551f, 0.00693931f, 0.01280400f, 0.00894798f, -0.03637074f, 0.00063172f, 
    0.00448784f, -0.00283931f, -0.03190057f, -0.02096219f, -0.01866396f, 0.02240326f, -0.01670413f, 0.01637345f, 
    -0.01876569f, -0.02484911f, -0.01619282f, -0.04423867f, -0.02159838f, 0.00436646f, -0.00285732f, -0.03809642f, 
    -0.02244777f, 0.00063331f, 0.02269702f, -0.02480956f, 0.00682379f, 0.00512986f, -0.01039293f, 0.01670041f, 
    -0.03579257f, 0.02773959f, 0.02077192f, 0.00850752f, 0.00567442f, 0.01440686f, 0.00345903f, -0.01602520f, 
    -0.02418182f, 0.00600081f, 0.01156597f, -0.00000113f, -0.02636208f, -0.00435139f, -0.01719013f, -0.01787179f, 
    0.01885950f, 0.01574683f, -0.00853752f, 0.02387236f, -0.01671058f, -0.03917669f, -0.03591558f, -0.00422986f, 
    -0.03624232f, -0.01213221f, 0.01906872f, -0.03336810f, 0.01698835f, 0.00380406f, -0.03308672f, -0.04177900f, 
    -0.01650035f, -0.02201513f, 0.01112930f, -0.02912628f, -0.01449118f, -0.04290280f, 0.01053528f, -0.03751268f, 
    -0.00953754f, 0.01644218f, -0.02852654f, 0.01526546f, -0.03594485f, -0.02859827f, -0.00350851f, -0.01705817f, 
    -0.00406030f, -0.03827050f, 0.01878269f, -0.03084118f, 0.01487492f, 0.00978475f, 0.01346379f, -0.00523728f, 
    0.02267272f, 0.01369560f, -0.01045468f, -0.00928061f, 0.01480440f, -0.01253231f, -0.01662337f, -0.03267239f, 
    0.01539458f, 0.00399357f, -0.00298412f, 0.02617602f, -0.03213308f, -0.02410761f, -0.03825027f, -0.02389506f, 
    0.02603362f, -0.03246672f, -0.03130566f, -0.00799481f, 0.02056349f, -0.03204784f, 0.01314757f, 0.02284562f, 
    -0.02401243f, -0.02481497f, -0.02900012f, -0.00618877f, 0.01495062f, 0.01579752f, 0.00570996f, 0.01477845f, 
    -0.03716614f, -0.00685251f, 0.02747499f, -0.01581765f, 0.02677605f, 0.00881422f, -0.02497871f, -0.02488547f, 
    0.02415858f, 0.01354811f, -0.04277030f, 0.00015815f, -0.02911971f, -0.00233299f, -0.00201011f, -0.03136833f, 
    0.00747465f, -0.00652075f, -0.02044371f, -0.02674099f, 0.02336298f, -0.04156592f, -0.00139380f, -0.01287754f, 
    0.02316539f, -0.01575050f, -0.01345614f, -0.00266018f, 0.02800485f, -0.02565770f, 0.01597148f, -0.04300590f, 
    0.00176030f, 0.01333221f, -0.00115889f, 0.02789290f, 0.02824353f, -0.00979772f, -0.02118643f, 0.02093906f, 
    -0.01362253f, 0.03335252f, -0.03308790f, -0.00027976f, -0.04140624f, -0.00989078f, -0.02638629f, 0.01540871f, 
    0.01356989f, 0.02196759f, 0.02077253f, -0.03569362f, -0.01041613f, 0.01160629f, -0.03800644f, 0.01697165f, 
    -0.00596416f, 0.00761935f, 0.00984717f, -0.02593278f, -0.00451491f, -0.03814773f, -0.04230912f, -0.00551833f, 
    -0.02322754f, -0.04438258f, -0.02055709f, 0.01416574f, 0.00956644f, 0.02040511f, 0.01218108f, -0.01488048f, 
    -0.00385936f, 0.03165222f, -0.02788798f, -0.00688694f, 0.00332759f, 0.02506501f, 0.02657996f, 0.02666830f, 
    -0.00688410f, -0.02373286f, -0.03006937f, -0.01711650f, 0.00890380f, -0.02130639f, -0.01547246f, 0.03729367f, 
    -0.01933116f, -0.02768457f, 0.03065450f, 0.00516672f, -0.03933217f, 0.00389910f, -0.03903202f, 0.01709406f, 
    0.00125910f, 0.00354540f, 0.00666209f, -0.00631768f, -0.03703088f, 0.01749913f, 0.02179316f, -0.00251664f, 
    0.02535452f, -0.02058517f, 0.00262776f, -0.02552678f, -0.04051628f, 0.02674633f, 0.01846565f, -0.01306154f, 
    0.00382425f, -0.02669440f, -0.00525865f, 0.02140208f, 0.02732612f, 0.00350837f, -0.02625925f, -0.01923504f, 
    -0.02924043f, -0.03139102f, -0.02746575f, -0.01168191f, -0.01387479f, -0.01080316f, 0.01959021f, 0.00778393f, 
    -0.02450700f, 0.02879383f, -0.02018862f, 0.02456714f, 0.00378816f, 0.02128315f, -0.04417301f, 0.02195157f, 
    -0.04049489f, -0.00136878f, -0.04179015f, -0.01851012f, -0.03135952f, -0.01531931f, 0.01223309f, 0.01218256f, 
    0.00877217f, 0.02547533f, 0.00538621f, -0.03415743f, 0.02226764f, -0.01740135f, -0.03549393f, 0.02412102f, 
    -0.00684849f, -0.02304852f, -0.00339310f, -0.02405192f, -0.01430633f, 0.02242767f, -0.01387488f, -0.01330381f, 
    0.01751544f, 0.02473622f, 0.01608496f, -0.03678542f, -0.00028761f, 0.00457845f, -0.01947270f, -0.03264957f, 
    -0.01335566f, -0.01080391f, 0.02098745f, -0.00453610f, -0.00005923f, 0.01510685f, -0.02870491f, -0.03105623f, 
    0.02808875f, 0.01013626f, 0.00307378f, 0.02019678f, 0.01231689f, 0.02037044f, 0.00661609f, 0.02023015f, 
    -0.03429255f, 0.01413380f, -0.03203243f, -0.02443113f, -0.01079250f, -0.03516349f, -0.01186827f, -0.02719719f, 
    -0.04248230f, 0.00965704f, -0.03340265f, -0.02972057f, -0.04037606f, 0.02182690f, -0.00802982f, -0.02665765f, 
    -0.03786393f, -0.00411361f, -0.02886654f, -0.03122575f, -0.00865497f, -0.04225278f, 0.00694663f, 0.00711024f, 
    -0.00595440f, -0.01811926f, -0.03851707f, 0.01197492f, -0.01289794f, -0.03447666f, -0.02333060f, 0.03403498f, 
    -0.00928292f, -0.00527545f, -0.02563633f, 0.01731964f, -0.02677204f, 0.00598387f, -0.00753185f, -0.04336870f, 
    0.02281858f, -0.00252995f, 0.00689802f, 0.00146092f, 0.00414646f, -0.03947203f, -0.00380372f, 0.02680585f, 
    0.01682278f, -0.02315653f, -0.04105910f, 0.00327332f, 0.01164438f, -0.02860323f, -0.02038152f, -0.01259169f, 
    -0.01773546f, -0.01265868f, 0.02701306f, 0.01480910f, -0.03789567f, 0.01666139f, -0.02180255f, -0.01242370f, 
    0.02669560f, -0.02558350f, 0.00080447f, 0.02193735f, 0.01866437f, 0.01972380f, -0.01363538f, -0.00533685f, 
    0.02093966f, -0.01648860f, 0.02192948f, 0.00685105f, -0.02306148f, 0.01086548f, 0.00269152f, -0.02562509f, 
    -0.00768041f, -0.00508566f, 0.02066870f, -0.00937793f, 0.02756128f, -0.00864571f, 0.02204680f, -0.02014720f, 
    -0.00274284f, -0.02271590f, -0.03567397f, 0.01866809f, -0.03740195f, -0.02225166f, -0.00462978f, 0.02752190f, 
    0.03090186f, 0.01653618f, -0.01640083f, -0.03530747f, -0.00144961f, 0.00696200f, 0.01241597f, -0.03664126f, 
    -0.03545809f, 0.01648412f, -0.00367198f, -0.03447860f, -0.00204481f, 0.00759400f, -0.01044604f, -0.02088846f, 
    -0.00251648f, 0.01523365f, -0.02930489f, 0.00170228f, -0.03392448f, 0.01284780f, 0.00609231f, 0.02230994f, 
    -0.00747546f, -0.03180204f, 0.01936526f, 0.01957789f, 0.02203519f, -0.00480848f, -0.03690268f, 0.00951534f, 
    -0.01070137f, -0.01808387f, -0.01898729f, -0.02859688f, 0.00187359f, 0.01941524f, -0.02370796f, -0.01485957f, 
    0.01166564f, 0.00393835f, -0.03805879f, 0.01378852f, -0.04159563f, -0.00650644f, 0.02465977f, 0.02227269f, 
    -0.02872057f, 0.00590074f, -0.03968190f, -0.02353608f, 0.03254223f, -0.03935745f, -0.00008519f, -0.02437543f, 
    -0.02974677f, 0.02646145f, -0.00078752f, 0.01985078f, 0.00036862f, -0.03112227f, -0.02668104f, -0.03629286f, 
    -0.03723236f, 0.02854937f, 0.02367731f, 0.01955823f, -0.03584651f, -0.02386382f, -0.00692709f, 0.01597445f, 
    -0.00324771f, 0.02926686f, -0.02578970f, -0.00530094f, -0.03033053f, -0.02847854f, -0.04042763f, 0.02295173f, 
    0.02259644f, -0.04060549f, -0.02438624f, 0.02149945f, -0.00913768f, -0.03228007f, 0.01109409f, -0.01525009f, 
    -0.03103925f, -0.01923019f, 0.02925195f, 0.00327621f, 0.02409944f, -0.00150915f, -0.02038402f, -0.02777360f, 
    -0.00344344f, -0.04121838f, 0.02276064f, -0.00614950f, 0.01735744f, -0.04127649f, -0.02472176f, -0.01508838f, 
    -0.01605888f, 0.00866948f, 0.02350024f, -0.00793072f, -0.04156312f, -0.00394167f, 0.02260125f, -0.02359472f, 
    0.01908197f, -0.00145220f, -0.00264677f, -0.00857377f, -0.01801084f, 0.01094243f, -0.01314940f, -0.02905877f, 
    -0.02832025f, 0.00182710f, 0.00306710f, -0.00162974f, -0.03581922f, -0.02468555f, -0.02877010f, -0.03112563f, 
    -0.00123713f, 0.00718209f, -0.03907354f, -0.01928351f, -0.00984764f, -0.03645724f, 0.00970351f, 0.02253398f, 
    0.02200872f, -0.00790221f, -0.02878943f, 0.01771843f, 0.02376602f, -0.04317997f, 0.02661560f, -0.00231320f, 
    -0.02612646f, -0.01774267f, -0.04117181f, -0.04091455f, 0.01535934f, -0.02410465f, 0.02668018f, -0.00112818f, 
    0.01405622f, 0.00021001f, -0.00450276f, 0.01493332f, 0.03074007f, 0.02708916f, -0.03271673f, -0.02514433f, 
    0.00918908f, 0.01260715f, 0.02128321f, -0.04024082f, -0.01248227f, 0.01826141f, -0.04237209f, -0.01380717f, 
    -0.01096872f, 0.00642087f, 0.02153872f, -0.01276781f, 0.02440400f, -0.00702992f, 0.00019148f, 0.02220375f, 
    -0.03621815f, -0.03327060f, 0.00078152f, 0.00832025f, -0.04051799f, 0.00689402f, 0.01002565f, -0.02246083f, 
    -0.03927477f, 0.02461580f, -0.01788154f, 0.00535876f, 0.01743007f, 0.00556844f, -0.00995131f, 0.01183829f, 
    0.00229441f, 0.00768814f, -0.04131170f, -0.04212743f, 0.01840452f, 0.02682602f, -0.03584915f, 0.00646120f, 
    0.00214898f, -0.01350394f, -0.02088705f, -0.02784254f, -0.02467884f, -0.00084303f, 0.00070934f, 0.02823277f, 
    -0.02138127f, -0.03688597f, -0.04074345f, 0.00774036f, -0.03528057f, -0.04083949f, 0.01972109f, 0.01222103f, 
    -0.02650746f, -0.00020263f, -0.01424850f, -0.02736286f, -0.01686856f, 0.00084321f, -0.00732652f, 0.01902999f, 
    0.00410445f, 0.11537370f, -0.08558480f, 0.01821239f, -0.01609027f, 0.04108815f, 0.04077670f, 0.07313041f, 
    0.03699069f, 0.00731333f, 0.09770732f, 0.13227615f, 0.07220854f, 0.17155100f, 0.02394697f, -0.09358326f, 
    0.05426304f, 0.02073370f, 0.10079334f, -0.02402260f, -0.07026763f, -0.01780707f, -0.10165854f, -0.01628440f, 
    0.10182089f, -0.00783006f, 0.04713155f, -0.03418026f, -0.07344950f, 0.05091608f, 0.01068400f, -0.00702925f, 
    0.04735007f, -0.00285284f, 0.00919817f, 0.08429252f, -0.07134870f, -0.06142493f, -0.00579733f, -0.07423755f, 
    0.01945476f, 0.05277896f, -0.08927158f, 0.01117312f, 0.03410125f, 0.06040055f, -0.00652260f, -0.05469469f, 
    -0.00273707f, -0.03100106f, 0.13776357f, 0.17263928f, -0.02216111f, 0.02505342f, 0.03655645f, -0.00300303f, 
    0.08845538f, 0.08248828f, -0.06806435f, 0.05735582f, 0.08664496f, 0.00400873f, 0.00331831f, -0.12837611f, 
    -0.08597148f, 0.09969391f, 0.07564906f, -0.02885590f, 0.11118916f, 0.03661989f, 0.02297091f, -0.03298618f, 
    0.21853320f, -0.06171885f, 0.03041912f, -0.02669583f, 0.12035136f, 0.06429300f, -0.06869835f, 0.02923082f, 
    0.03260798f, 0.02804325f, 0.04060639f, 0.10563029f, -0.15329963f, 0.01254739f, 0.07507269f, -0.03445350f, 
    0.08490800f, 0.02942486f, 0.05513136f, -0.10163277f, 0.06174722f, -0.00116980f, 0.07042195f, 0.12103871f, 
    0.10104319f, -0.00288239f, -0.16121991f, -0.16208966f, -0.04747552f, 0.05346359f, 0.00708611f, 0.10035460f, 
    0.05394213f, 0.05391057f, 0.00029983f, -0.05820044f, -0.17528255f, 0.11283971f, 0.07327992f, 0.01264807f, 
    -0.05253538f, 0.01154749f, 0.02876861f, 0.06364690f, 0.08750627f, 0.00783474f, -0.04026684f, -0.04108572f, 
    0.03978115f, -0.03131324f, -0.03963448f, -0.12474500f, -0.01729714f, -0.00743876f, 0.07375930f, -0.06377557f, 
    0.04157961f, -0.09520335f, -0.02444444f, -0.06765732f, 0.16177370f, -0.06890925f, -0.14317389f, 0.02736025f, 
    -0.00760393f, 0.16588537f, 0.06521478f, 0.02446912f, -0.04770481f, 0.11191450f, 0.08720303f, -0.00773219f, 
    0.04454483f, -0.04681737f, 0.05576129f, 0.09782783f, -0.08423463f, 0.02951143f, 0.06283718f, -0.00575395f, 
    0.03985486f, 0.02991795f, 0.10083028f, 0.07984216f, 0.04555434f, -0.05850474f, 0.06713387f, 0.17300041f, 
    0.08644381f, -0.03486029f, -0.01510049f, 0.09710414f, 0.10953764f, 0.05833678f, 0.10033122f, -0.06379054f, 
    0.11788021f, 0.02854924f, -0.08453104f, 0.05554516f, 0.02690491f, 0.05158510f, 0.04819312f, 0.00632936f, 
    0.00093147f, -0.03192339f, 0.02450243f, 0.04800912f, 0.05429849f, 0.18727781f, -0.00321792f, 0.06363500f, 
    0.05843059f, 0.08951396f, -0.06580807f, -0.00392395f, 0.04904236f, -0.01916165f, 0.04344616f, 0.10581059f, 
    -0.11516977f, 0.11984656f, 0.04146965f, -0.20849799f, 0.06120507f, -0.02039278f, -0.02535770f, 0.01617803f, 
    0.02574757f, -0.07338127f, 0.07552807f, -0.11823352f, -0.09832057f, 0.01884052f, -0.08659077f, 0.15205342f, 
    0.08863767f, -0.01263614f, 0.06520665f, 0.03152863f, -0.03547367f, -0.00463926f, 0.04227199f, 0.09011314f, 
    -0.13340314f, 0.23519321f, 0.00755856f, -0.11476321f, 0.01193584f, 0.07429472f, -0.04124205f, 0.02269868f, 
    0.03208177f, -0.09656154f, 0.07603285f, -0.05087597f, -0.00554319f, -0.04468536f, -0.01427028f, 0.05302490f, 
    -0.01932064f, 0.06105646f, 0.02758186f, 0.08541758f, 0.07116243f, 0.03625045f, 0.07688784f, -0.02841854f, 
    0.28883475f, -0.21524025f, -0.00623326f, 0.04688063f, -0.06581996f, 0.04284200f, 0.02687040f, 0.04934608f, 
    0.07632655f, 0.01632373f, 0.08576375f, -0.00686714f, 0.02870340f, 0.06001686f, 0.16297211f, 0.13017222f, 
    0.13099381f, 0.02578697f, 0.00063182f, 0.04465378f, 0.08460686f, -0.02529879f, -0.01901743f, 0.00408439f, 
    -0.12355377f, -0.08176921f, 0.02094317f, -0.08480073f, 0.02186769f, -0.06028937f, 0.01724260f, -0.11062047f, 
    -0.09830015f, 0.07619295f, -0.07341933f, 0.11183999f, 0.22435531f, -0.00296874f, 0.06075900f, 0.03570958f, 
    -0.05607839f, 0.14550111f, 0.08191625f, 0.04313932f, 0.04178555f, -0.03441022f, 0.03805731f, -0.06013653f, 
    -0.06731071f, -0.19375490f, 0.09457006f, 0.07872431f, -0.06434467f, 0.02082041f, 0.06021095f, -0.06140595f, 
    0.02282622f, -0.04052151f, 0.10683255f, 0.01702095f, -0.10409871f, -0.11521973f, 0.12716880f, -0.00454222f, 
    -0.00695635f, 0.09058207f, 0.01409119f, -0.05242346f, 0.03667770f, 0.03316714f, -0.07416621f, -0.01293198f, 
    -0.30670053f, -0.26908338f, 0.05441591f, -0.00369498f, -0.10023004f, 0.01404607f, -0.04988602f, 0.09449232f, 
    0.03112322f, -0.08394320f, 0.04168616f, 0.02742445f, -0.11520812f, -0.00571744f, 0.12000328f, -0.05711742f, 
    0.05794106f, 0.02664468f, -0.00828274f, -0.08546812f, 0.00460371f, -0.02204607f, -0.02603969f, 0.00112482f, 
    -0.09233582f, -0.09695145f, -0.02678695f, 0.16131532f, -0.00420521f, 0.01620230f, -0.04782136f, 0.15482135f, 
    -0.05560980f, -0.03211912f, 0.09135500f, 0.01173952f, 0.00902226f, 0.01432499f, -0.01597266f, 0.12126548f, 
    0.07135560f, -0.02474255f, 0.00877576f, -0.03250250f, -0.07802808f, -0.10956580f, -0.05930296f, -0.00089489f, 
    0.03149154f, -0.22004479f, 0.03900752f, 0.17736036f, 0.00044390f, -0.02410676f, -0.01104436f, -0.00077750f, 
    0.02409196f, 0.04169503f, -0.02997686f, 0.04153884f, -0.07105362f, -0.12147062f, 0.05452496f, 0.10194805f, 
    0.11229903f, -0.06705173f, 0.07710961f, 0.08010182f, 0.09679108f, -0.05432798f, -0.09119467f, 0.04013946f, 
    -0.17667140f, -0.08495052f, 0.21973473f, 0.17208369f, -0.06777750f, 0.09443753f, 0.01229642f, 0.06052300f, 
    0.08630423f, -0.02471725f, 0.04087233f, -0.00515399f, 0.09965548f, -0.04575477f, 0.06132953f, -0.12812693f, 
    0.01472955f, -0.05684825f, -0.05642343f, 0.05806709f, 0.08118850f, 0.07731801f, 0.10787567f, 0.11400454f, 
    0.04159695f, 0.14374876f, -0.17520687f, -0.03244068f, 0.00116077f, 0.02721919f, -0.07892788f, 0.06827607f, 
    -0.03742740f, 0.02522433f, -0.05937813f, 0.09175154f, -0.05080606f, -0.13894783f, 0.18561196f, 0.04417829f, 
    0.05343931f, -0.09121364f, 0.05649875f, -0.00925434f, -0.10061355f, 0.08945210f, 0.09194380f, 0.01414987f, 
    -0.35230553f, -0.08372691f, -0.01309673f, 0.07627987f, 0.04196299f, -0.07484134f, -0.00376567f, 0.16996117f, 
    0.02847953f, 0.08360476f, -0.01463214f, 0.00462840f, 0.33847645f, -0.08517471f, -0.14618613f, 0.10443239f, 
    0.00080340f, 0.07234497f, -0.02623734f, 0.08994588f, -0.08252228f, 0.01684304f, 0.02695967f, 0.00040173f, 
    -0.36517814f, -0.18778600f, 0.08851572f, 0.18875040f, 0.01666181f, -0.17227605f, 0.04221865f, 0.04846717f, 
    0.00191866f, 0.04664594f, 0.03491556f, 0.09554165f, -0.22114135f, 0.03902303f, 0.10493260f, -0.07754973f, 
    0.06128082f, -0.04685582f, -0.02619785f, 0.01391289f, -0.00808237f, 0.07276397f, 0.00960074f, -0.00699210f, 
    0.13927662f, 0.18353558f, -0.00419776f, -0.08049816f, 0.03868046f, 0.03891709f, -0.06058112f, 0.04516835f, 
    0.01845988f, -0.07468712f, -0.03422407f, -0.01479949f, -0.08313274f, -0.01216923f, -0.17915526f, 0.10740482f, 
    -0.03639815f, -0.00144641f, 0.06481598f, -0.00270991f, 0.09942509f, -0.00013503f, -0.02133344f, 0.01586029f, 
    0.40384474f, 0.08648735f, -0.34167701f, -0.09812445f, 0.00607457f, -0.02999700f, -0.06026019f, 0.06205844f, 
    0.04150144f, 0.11781026f, 0.00601146f, -0.01452889f, 0.15257286f, 0.04480485f, -0.13759330f, 0.12560502f, 
    -0.03510328f, -0.02662447f, -0.00025791f, -0.00181408f, -0.01142244f, 0.02067344f, -0.10480400f, 0.05929774f, 
    -0.17283656f, 0.06268989f, -0.14327702f, 0.10617311f, 0.06827000f, 0.01532732f, -0.06008890f, -0.03158399f, 
    0.05791387f, 0.05432995f, -0.02198965f, 0.05334003f, -0.08204059f, 0.04327144f, 0.10112424f, 0.03693816f, 
    0.04709941f, 0.01384118f, -0.03632061f, 0.01083754f, 0.00851746f, -0.08129077f, -0.11979012f, -0.00756303f, 
    -0.20925464f, 0.06372527f, 0.15557414f, 0.04329380f, -0.00623212f, 0.05768554f, 0.03565182f, 0.05482145f, 
    -0.11195774f, -0.02959567f, -0.01297086f, -0.07796951f, -0.23646046f, -0.09787165f, 0.14017788f, -0.03228899f, 
    0.05566585f, 0.08486985f, 0.07920589f, -0.03225105f, 0.05379167f, 0.10911355f, -0.00102551f, 0.02183818f, 
    -0.22985917f, -0.09358656f, 0.10878735f, -0.03160334f, 0.05410535f, 0.01597660f, 0.05952929f, -0.11891656f, 
    -0.01797059f, -0.01090729f, -0.01082509f, 0.06230658f, 0.04714381f, -0.02320889f, 0.05698386f, -0.30037045f, 
    -0.00534297f, 0.08811340f, 0.07375311f, -0.05701229f, 0.04132685f, -0.09779476f, -0.09886269f, 0.00945046f, 
    -0.18529457f, 0.00299106f, 0.07180130f, 0.01627623f, 0.00623322f, 0.14009430f, -0.00158626f, 0.00668276f, 
    0.06170853f, 0.04552810f, 0.05108061f, 0.05005532f, 0.18952931f, 0.01151404f, -0.07903963f, -0.02447046f, 
    0.05667354f, 0.04614906f, 0.06918010f, -0.02919676f, -0.03034728f, -0.01476332f, 0.06764328f, -0.05307817f, 
    -0.21462935f, -0.21298793f, -0.06145191f, -0.04873426f, 0.01494305f, 0.00724711f, -0.00397410f, -0.05299279f, 
    -0.01518572f, 0.01172873f, 0.06251228f, -0.00632178f, -0.04835222f, -0.13939369f, 0.12406626f, -0.04256308f, 
    0.03948092f, 0.09764859f, -0.03689003f, -0.00873271f, 0.11067211f, 0.04154532f, 0.03040216f, -0.00651712f, 
    0.04732034f, 0.02803625f, -0.10295694f, -0.12561239f, -0.07319643f, -0.02163243f, 0.06004746f, 0.01936351f, 
    -0.00119173f, 0.04070644f, 0.11132321f, 0.06195247f, -0.14884049f, -0.09216031f, 0.07937191f, 0.11162230f, 
    -0.01506852f, 0.01026631f, 0.05180710f, 0.01153949f, 0.07252462f, -0.02533871f, 0.06795622f, 0.04677724f, 
    -0.05224089f, 0.03305317f, -0.04821182f, 0.07575564f, 0.02978684f, -0.04822491f, 0.04254052f, 0.07605691f, 
    -0.07892362f, -0.01557058f, -0.10988476f, -0.01243144f, 0.07039250f, -0.22764041f, 0.00199199f, 0.05691388f, 
    -0.18162236f, -0.05822917f, -0.05544416f, 0.13057373f, -0.06644181f, -0.05067358f, -0.03658980f, 0.07363567f, 
    -0.01535706f, -0.04794852f, 0.17435673f, 0.04990545f, 0.08454758f, -0.08626103f, -0.01554383f, -0.00497773f, 
    0.01625664f, 0.04657673f, -0.07234514f, 0.06777903f, 0.04061153f, -0.03481140f, 0.13845682f, -0.04544313f, 
    -0.07092047f, -0.02068727f, -0.02015354f, 0.06126475f, -0.06320875f, 0.04361807f, 0.07668579f, -0.07530071f, 
    -0.14521600f, -0.07238396f, 0.00540822f, 0.02650973f, -0.14557980f, -0.00591907f, 0.05650505f, -0.01776007f, 
    0.04173647f, -0.04572516f, -0.01136059f, 0.00533581f, 0.17060019f, 0.15754704f, -0.23845583f, -0.00904423f, 
    -0.03017343f, 0.05392545f, -0.09193954f, 0.06472515f, -0.09079855f, 0.07039640f, 0.04595470f, 0.01193553f, 
    -0.05518162f, 0.00179248f, 0.18231040f, 0.13817084f, 0.01478094f, 0.06941880f, -0.03521187f, 0.00790190f, 
    0.07787690f, 0.05224318f, 0.05294886f, -0.02744905f, 0.10630313f, -0.04375491f, 0.03262464f, -0.24892329f, 
    -0.01807011f, -0.14722343f, 0.10211555f, -0.12997752f, -0.05355228f, 0.05964649f, -0.00848242f, 0.01825421f, 
    0.10189549f, 0.07306283f, 0.05805693f, 0.02633187f, 0.03574219f, -0.00954864f, 0.09421579f, 0.12845074f, 
    0.24704421f, 0.03111715f, 0.00394917f, -0.02424224f, -0.08137016f, 0.18113947f, 0.02321613f, 0.05706108f, 
    -0.01126315f, 0.01796981f, 0.00386621f, 0.03173825f, 0.08577762f, 0.12995267f, 0.09233933f, -0.22376397f, 
    0.08622276f, -0.01578409f, 0.01478187f, -0.02192042f, -0.03916483f, 0.11289134f, -0.08187809f, -0.13687839f, 
    0.07071029f, -0.04976823f, -0.07853115f, -0.04731027f, -0.00144101f, 0.11324278f, 0.00157134f, -0.01763457f, 
    0.12021959f, -0.16781081f, 0.08693975f, 0.02930796f, -0.06844483f, -0.13419455f, 0.10573507f, 0.02656277f, 
    0.01456125f, -0.00095957f, 0.02468420f, -0.00558252f, 0.00324215f, -0.01690240f, 0.06343569f, 0.10637895f, 
    0.06491280f, -0.05685591f, 0.02677479f, 0.08333536f, 0.02265229f, -0.01698888f, 0.04390863f, -0.13156036f, 
    0.02282286f, -0.02158890f, 0.00117581f, 0.02273675f, -0.03671808f, -0.04992907f, 0.02909855f, 0.09658735f, 
    0.05257260f, 0.07345933f, -0.13447027f, 0.23863661f, 0.10818787f, 0.05560375f, 0.16511530f, 0.09965716f, 
    0.04519392f, -0.24062553f, 0.02414052f, -0.13244916f, 0.01598536f, -0.06189994f, 0.12422290f, -0.00613826f, 
    -0.00645195f, 0.00570935f, 0.17061602f, -0.16589040f, -0.10124091f, 0.06432048f, -0.07248514f, 0.17626351f, 
    -0.19716595f, -0.08791244f, -0.01605447f, -0.02202043f, 0.04873392f, -0.11598789f, -0.01713696f, -0.09533115f, 
    -0.02308353f, 0.14370818f, 0.02721804f, -0.10105944f, 0.27577466f, -0.07059839f, -0.01826994f, -0.14321887f, 
    -0.03722071f, 0.05383454f, -0.10069117f, 0.00451054f, -0.05009509f, 0.11732011f, 0.12897713f, 0.16841540f, 
    -0.05642430f, -0.02673792f, 0.04824654f, -0.00610865f, 0.07647021f, -0.02560885f, -0.11630531f, 0.00759759f, 
    -0.11427579f, 0.17387564f, -0.03043805f, 0.10361160f, 0.06736696f, -0.04367348f, 0.20119631f, -0.13803950f, 
    0.04042148f, -0.11153278f, 0.06846117f, 0.11181103f, 0.10224588f, -0.14813636f, 0.08350579f, 0.05069292f, 
    0.15025315f, 0.03897259f, -0.06249284f, 0.01951530f, 0.08401516f, -0.07589330f, -0.20249820f, 0.04672437f, 
    0.02514554f, -0.03044960f, -0.02918466f, -0.17656714f, 0.21346207f, -0.00764929f, -0.03674291f, 0.01139735f, 
    0.07398199f, -0.03784439f, -0.08104677f, -0.09405097f, 0.11556846f, -0.10755805f, -0.08642308f, 0.05623572f, 
    -0.00610595f, -0.14974344f, -0.15643518f, 0.05392815f, 0.11053503f, 0.08968291f, -0.11930933f, 0.17896222f, 
    0.01192779f, 0.00076530f, 0.04291684f, 0.06413800f, 0.38875902f, 0.04907826f, 0.11225875f, 0.05378455f, 
    -0.01262459f, 0.01383232f, -0.00930690f, -0.07054794f, 0.07406811f, -0.03886924f, -0.06449483f, -0.09717032f, 
    -0.10183217f, -0.02335048f, 0.09789486f, 0.06641912f, 0.08540702f, 0.00992714f, -0.00812112f, -0.10763256f, 
    -0.07629629f, 0.05259004f, 0.17112373f, 0.09992731f, 0.27654988f, 0.19251938f, -0.00109672f, -0.08578499f, 
    -0.01986556f, 0.01252313f, -0.05605933f, 0.02153445f, 0.10756778f, 0.08302352f, -0.13996185f, -0.17070679f, 
    -0.06259192f, -0.09587912f, 0.25113514f, 0.05875455f, 0.09601166f, 0.06947678f, -0.00148956f, 0.03436727f, 
    0.05876129f, 0.05052202f, 0.04662539f, -0.01048199f, 0.23924610f, -0.02152245f, -0.02821989f, -0.01219822f, 
    -0.03024490f, 0.05791820f, -0.19475542f, 0.10319788f, 0.00297815f, 0.16634969f, 0.13134088f, 0.16492699f, 
    0.44470203f, 0.00060894f, 0.05184285f, 0.04010542f, 0.02218212f, 0.06253044f, -0.08086556f, 0.12190387f, 
    0.04536648f, 0.14102344f, -0.00814235f, 0.07582118f, 0.00128640f, 0.08261992f, 0.06112505f, 0.18025018f, 
    0.06881683f, 0.02319943f, 0.13212989f, -0.10541615f, -0.00345212f, 0.11791309f, -0.00976083f, 0.16005498f, 
    0.05450885f, -0.09208508f, 0.11186329f, 0.14988835f, 0.07133699f, -0.07159305f, 0.00237272f, 0.11233929f, 
    -0.18196253f, 0.11119095f, -0.09083374f, -0.09157274f, 0.14220950f, 0.06785981f, 0.11880647f, -0.00678176f, 
    0.01429241f, -0.07304796f, -0.01683164f, 0.05368412f, -0.04864707f, 0.02967842f, 0.00402150f, -0.09280637f, 
    -0.08873242f, 0.11753611f, -0.20089766f, -0.04533378f, 0.10482996f, -0.04518099f, 0.00124982f, -0.04582608f, 
    -0.01963342f, -0.02197794f, 0.06816585f, -0.02521919f, -0.16749051f, 0.16015697f, -0.06131664f, -0.00928606f, 
    0.03700808f, -0.03185682f, 0.11682849f, 0.00227972f, 0.00923833f, 0.00472023f, 0.15635532f, 0.01152753f, 
    -0.25590566f, 0.04592067f, 0.03429250f, 0.06602234f, 0.14072703f, -0.22879025f, -0.13540672f, 0.03445651f, 
    -0.03599766f, 0.03932314f, -0.09904151f, -0.34622461f, 0.07454436f, -0.06033746f, -0.12754974f, -0.14161570f, 
    -0.00380341f, 0.03102281f, 0.02034180f, 0.14961261f, -0.03093654f, -0.06119745f, 0.26026881f, 0.06334725f, 
    -0.01158547f, 0.05913600f, 0.04755708f, -0.02901433f, 0.08888645f, -0.07785189f, 0.13058099f, -0.15507592f, 
    0.05120363f, 0.03392174f, -0.06639290f, 0.19261830f, 0.01782500f, 0.01871956f, 0.02207271f, 0.11765984f, 
    0.00366028f, -0.04256855f, 0.00915951f, -0.04089972f, 0.13641407f, 0.17147572f, -0.02451085f, 0.12343420f, 
    0.05533234f, 0.00322705f, 0.03582846f, -0.08922184f, 0.00227749f, -0.09799722f, -0.03606787f, -0.01932610f, 
    0.00492191f, -0.00875185f, 0.00102511f, 0.08217117f, -0.09724432f, -0.02279739f, 0.05126425f, 0.16060847f, 
    0.01504104f, -0.01927388f, -0.18889304f, -0.07158248f, -0.01651034f, -0.14326671f, -0.09099232f, 0.07210304f, 
    0.39821714f, 0.02174616f, 0.00983050f, -0.09022280f, -0.04212627f, -0.03536492f, 0.06962209f, 0.01750278f, 
    0.11955631f, 0.05559332f, -0.11834672f, 0.02543699f, 0.01892444f, 0.04044328f, 0.08036947f, 0.01231837f, 
    0.19998977f, 0.09484915f, 0.06334829f, 0.08165698f, -0.10804383f, 0.04843069f, 0.01907673f, 0.02933142f, 
    0.02734588f, -0.02146120f, 0.02662644f, 0.04064802f, 0.16043244f, 0.06841620f, -0.08285658f, -0.13132149f, 
    -0.16492796f, -0.17749758f, 0.03183028f, -0.19478977f, 0.38860071f, -0.11468232f, -0.09889469f, -0.10079093f, 
    0.01404197f, 0.09868209f, -0.24694413f, 0.08239474f, 0.00168870f, -0.07844253f, -0.09433176f, -0.08195730f, 
    -0.19515404f, 0.02197075f, -0.04420102f, -0.11190616f, 0.14402336f, -0.09736666f, -0.16899690f, 0.03068087f, 
    0.19052143f, -0.09646707f, 0.13105395f, -0.06958270f, 0.15817113f, 0.12487617f, -0.00786903f, -0.06028848f, 
    0.13581282f, 0.11770161f, -0.08406961f, -0.06103013f, 0.08313482f, -0.19752796f, -0.13031779f, -0.02065222f, 
    -0.07921601f, 0.17404689f, 0.00715370f, -0.09702799f, 0.08787974f, 0.03660797f, -0.07841307f, -0.11751851f, 
    0.01053743f, 0.04013477f, -0.05602392f, -0.03164486f, 0.11163191f, -0.18776508f, -0.13916463f, -0.01828190f, 
    -0.03134739f, -0.10281889f, -0.05065597f, 0.03792790f, 0.00274066f, -0.03249606f, -0.01361716f, 0.32537127f, 
    -0.03311102f, 0.02632347f, 0.05068827f, 0.03031205f, 0.12001049f, 0.08875600f, 0.12338199f, 0.00421783f, 
    0.02602186f, -0.19957609f, -0.12872724f, -0.04249554f, -0.02261494f, 0.13361695f, 0.28121683f, -0.12658294f, 
    0.10345875f, -0.00674045f, -0.08279755f, 0.01306931f, -0.01556716f, 0.00060512f, 0.00856533f, 0.15292332f, 
    0.06801598f, 0.11088791f, 0.17269535f, -0.04561017f, 0.07085662f, -0.07537506f, -0.05463222f, -0.02330072f, 
    -0.07370296f, 0.22555393f, -0.00257923f, 0.09748472f, 0.06904669f, 0.08893289f, 0.11882372f, 0.05867474f, 
    -0.10026537f, -0.00878624f, 0.09648743f, -0.04751281f, -0.07725056f, 0.12767123f, -0.03824836f, -0.06083724f, 
    0.08803108f, -0.13086353f, 0.29027990f, -0.15435182f, -0.09571195f, 0.05149628f, -0.01243225f, -0.00391407f, 
    0.07686500f, -0.04036665f, 0.00231590f, 0.07646024f, 0.13558973f, -0.07382218f, -0.15451933f, -0.19439670f, 
    0.01633359f, 0.04745135f, 0.05973578f, -0.07438079f, -0.06686497f, 0.03702760f, 0.00643238f, 0.09791257f, 
    -0.20839076f, -0.10277303f, 0.04720595f, 0.05789406f, -0.02596584f, 0.00424212f, 0.08640519f, 0.00520457f, 
    0.02192635f, 0.11968362f, 0.02089003f, 0.11170376f, -0.03596842f, 0.02265302f, -0.02823878f, -0.02379475f, 
    0.01155720f, -0.08963996f, 0.06591195f, -0.00737409f, 0.02029325f, -0.02677188f, 0.13331331f, 0.07298628f, 
    0.05011802f, 0.04280019f, -0.14944004f, 0.04291171f, 0.00674240f, -0.07178218f, 0.06941544f, -0.22229956f, 
    -0.09938375f, 0.06959632f, -0.01628856f, 0.06643216f, 0.02271148f, -0.09679671f, -0.28278440f, 0.11265232f, 
    0.02170358f, 0.09866796f, -0.05630206f, 0.00105069f, 0.07702428f, 0.02008283f, -0.01130496f, 0.05132459f, 
    0.27877122f, -0.04081399f, 0.09279262f, 0.03184965f, 0.06372316f, 0.02791549f, -0.02921638f, -0.19085284f, 
    -0.02136339f, -0.18372732f, -0.18728355f, -0.13669376f, 0.09835775f, 0.04264250f, 0.06830143f, 0.11331356f, 
    -0.13109757f, 0.05508549f, -0.11196826f, -0.03090598f, 0.06590644f, -0.07575791f, -0.04781109f, -0.07453368f, 
    -0.32428920f, 0.06747296f, 0.10292649f, -0.04544349f, -0.07601829f, -0.00796437f, 0.12143228f, 0.11397859f, 
    -0.00857051f, 0.02831122f, 0.05882458f, -0.12043840f, 0.09065886f, 0.15205161f, 0.01861633f, -0.04013360f, 
    0.04790336f, -0.03506366f, 0.09889577f, 0.19547325f, -0.13851352f, -0.10746948f, 0.07240897f, 0.04274391f, 
    -0.00787929f, -0.08795116f, 0.00981749f, 0.09876030f, 0.03346556f, -0.01539562f, 0.05895309f, 0.04375010f, 
    0.23715213f, -0.16525801f, 0.04533514f, -0.04788915f, -0.30147827f, 0.06624104f, 0.02319442f, -0.08538268f, 
    0.16698347f, -0.04396221f, 0.04259493f, -0.01072203f, -0.01438953f, -0.15151453f, 0.07010906f, 0.03125063f, 
    0.08757195f, -0.03569987f, 0.02596132f, -0.03057723f, 0.15554184f, 0.10379346f, 0.13447297f, -0.03042126f, 
    0.07688104f, -0.27318719f, -0.19150423f, -0.21996517f, 0.09922714f, -0.07219813f, 0.03074138f, 0.04449415f, 
    0.15080097f, 0.19628346f, -0.00153059f, 0.15807568f, -0.02908387f, -0.17648715f, 0.00693275f, 0.02679294f, 
    0.20878486f, 0.19848150f, -0.12325582f, -0.05293319f, 0.08372225f, 0.20941646f, -0.12925756f, -0.07490296f, 
    -0.12228730f, -0.16322958f, -0.01711947f, -0.15120868f, -0.17577185f, 0.13443826f, 0.04536939f, 0.06424338f, 
    0.01174817f, -0.10925099f, 0.05134590f, 0.02870779f, 0.02029000f, 0.07513014f, 0.04265713f, 0.13853416f, 
    -0.29366225f, 0.06839438f, 0.01639116f, -0.02216198f, 0.02503296f, -0.08301190f, 0.02854709f, 0.03002772f, 
    -0.01069640f, 0.23374699f, -0.07270897f, 0.28585619f, 0.10851385f, 0.15633327f, 0.16644600f, 0.12054063f, 
    0.07651445f, 0.15514787f, 0.02552957f, -0.07979175f, 0.13819881f, 0.01602680f, 0.05427056f, 0.08257136f, 
    0.00797328f, -0.11806186f, -0.01318079f, 0.00264879f, 0.07709487f, 0.07959863f, -0.00368506f, -0.01001960f, 
    0.02493086f, -0.04689598f, 0.03541970f, 0.23935464f, -0.25517556f, 0.07688288f, -0.16647105f, 0.06169595f, 
    0.06553905f, 0.07180125f, 0.08176693f, 0.05977388f, 0.01139814f, -0.12482026f, -0.16451435f, 0.06643081f, 
    0.01291030f, -0.02325129f, 0.02045380f, -0.02073279f, -0.01979411f, -0.03306784f, 0.01020948f, -0.03188921f, 
    0.01648879f, -0.02726745f, 0.01623508f, 0.01322046f, 0.02287792f, -0.03255706f, -0.03253045f, 0.02539746f, 
    0.01537655f, 0.01772905f, -0.04011051f, -0.02047585f, -0.02234052f, 0.01914024f, 0.01426479f, -0.03795697f, 
    -0.03964567f, 0.01887717f, -0.02507398f, -0.02574124f, -0.02626651f, 0.02222076f, 0.00745117f, -0.02976123f, 
    -0.00692694f, 0.00206067f, 0.00073345f, -0.02201674f, 0.02571343f, -0.03972965f, -0.01085155f, 0.00358241f, 
    0.01269221f, -0.00098745f, 0.00528511f, -0.00213822f, -0.02427397f, -0.00189828f, -0.02328586f, -0.03285629f, 
    0.01815535f, 0.00864638f, -0.03618706f, -0.01127725f, -0.02129620f, -0.02889173f, 0.02372473f, 0.00369942f, 
    -0.02569764f, -0.03726456f, -0.03202793f, 0.02348286f, 0.02161345f, -0.01389934f, 0.01018732f, -0.00938205f, 
    -0.02061024f, 0.01469944f, -0.01329631f, -0.00023614f, -0.04409572f, -0.01528950f, 0.01722618f, -0.02364890f, 
    -0.02327024f, -0.02915341f, 0.00638280f, 0.00817771f, 0.01322775f, 0.01514286f, -0.00087169f, -0.02919956f, 
    -0.02741725f, -0.00079091f, -0.00509916f, 0.00243116f, -0.04258437f, 0.01953331f, -0.03477409f, -0.02534808f, 
    -0.03422787f, -0.03648565f, -0.03995211f, -0.01111814f, -0.01243351f, 0.00524095f, 0.00916922f, -0.04125395f, 
    -0.01905490f, -0.00322762f, -0.02434107f, -0.01613822f, -0.00028170f, -0.01702212f, -0.02169485f, -0.02231920f, 
    0.02212064f, 0.02087880f, 0.02597246f, -0.00105079f, 0.00655570f, 0.01222812f, 0.02166849f, -0.01184732f, 
    0.00702410f, 0.02365740f, -0.00859749f, 0.00955641f, -0.02450272f, 0.02255331f, -0.02426617f, 0.01448981f, 
    -0.00793535f, 0.01056319f, -0.02152532f, -0.04171190f, -0.03781193f, -0.01615512f, -0.02704335f, 0.00530323f, 
    -0.01970270f, -0.02418248f, -0.04160255f, 0.02273468f, -0.03501628f, -0.00250655f, 0.02278694f, -0.03878979f, 
    -0.02794146f, -0.01673640f, -0.00358930f, -0.01478403f, 0.00979260f, 0.01008047f, 0.01106910f, 0.00482357f, 
    -0.02028858f, -0.02832767f, -0.03838903f, -0.04360734f, 0.02300533f, 0.00946177f, -0.00462966f, -0.04047596f, 
    0.00448152f, -0.03217879f, 0.00754009f, -0.02099769f, -0.00597206f, -0.01988683f, 0.00288583f, -0.03358708f, 
    -0.01188011f, -0.00329268f, -0.02567762f, 0.00032006f, -0.04050690f, 0.01370722f, -0.01385575f, -0.01075624f, 
    -0.03167180f, 0.02605061f, -0.03625121f, -0.03500855f, -0.01274266f, -0.01271533f, -0.00100041f, 0.01548697f, 
    -0.00955669f, 0.00461045f, -0.01462287f, -0.00777836f, -0.02174046f, 0.02605199f, -0.01843014f, 0.01007471f, 
    -0.03315434f, -0.00258614f, -0.04047102f, 0.02053813f, 0.00850128f, -0.03010286f, 0.01769318f, 0.00817825f, 
    -0.00274306f, -0.01058449f, 0.00481072f, -0.00367094f, -0.01161933f, -0.01390785f, 0.02497500f, 0.02581412f, 
    -0.03262236f, 0.00510477f, 0.00333869f, 0.00456602f, 0.00575520f, -0.04058474f, -0.01848467f, 0.00556540f, 
    -0.02628926f, 0.01405799f, 0.00721338f, 0.01157126f, 0.01381708f, 0.02712888f, 0.02292750f, 0.01249395f, 
    -0.00950039f, 0.01625802f, -0.02686567f, -0.02824944f, -0.01495603f, 0.01132275f, -0.01635260f, 0.00392220f, 
    0.01136380f, -0.01317158f, 0.02946381f, 0.01737270f, -0.00892236f, -0.04414931f, -0.02546682f, 0.02997258f, 
    0.01167501f, -0.03646692f, 0.01050913f, 0.02217311f, 0.01218778f, 0.00143840f, 0.00721703f, 0.01717773f, 
    -0.01526678f, -0.00412999f, 0.03778991f, 0.02896585f, 0.00514662f, -0.02357212f, -0.00756698f, -0.03911649f, 
    -0.03068488f, -0.02990164f, 0.00990310f, 0.02393834f, -0.01708813f, -0.01264416f, 0.01753007f, 0.03297756f, 
    0.00557269f, 0.02672451f, 0.03429113f, -0.01784623f, -0.02724081f, -0.00125627f, -0.02183461f, 0.02624599f, 
    0.01872525f, -0.03767361f, 0.00370705f, -0.03098368f, -0.04064475f, 0.00047927f, -0.02695633f, -0.01114533f, 
    -0.03575545f, 0.01060873f, -0.02173183f, -0.01816995f, 0.00165264f, 0.01730647f, 0.00157068f, -0.00718551f, 
    -0.01879307f, -0.03185083f, -0.03896556f, 0.01555721f, 0.01278236f, 0.00388858f, -0.03687145f, 0.02792551f, 
    -0.03074262f, 0.02130095f, -0.01173243f, -0.00902781f, -0.03569946f, -0.00214307f, -0.03725240f, -0.00962988f, 
    0.01479972f, 0.02648186f, -0.00188802f, -0.03053314f, -0.03434482f, 0.02597132f, -0.00821772f, 0.00316227f, 
    -0.03206188f, -0.04330903f, -0.01095689f, -0.02304912f, 0.01983137f, 0.01050696f, -0.02207809f, 0.02743817f, 
    -0.01614422f, -0.02298801f, 0.01141246f, 0.01235188f, 0.01028624f, -0.03104344f, 0.01426398f, 0.02386714f, 
    0.02503858f, -0.02037074f, 0.02432293f, -0.01964211f, 0.00680465f, 0.00390477f, -0.02047147f, 0.00731600f, 
    -0.02957725f, 0.01426799f, -0.01840272f, -0.01997280f, -0.01027659f, -0.00630911f, -0.00675392f, -0.03577912f, 
    -0.03853024f, -0.02692873f, 0.02930461f, 0.01594456f, 0.00100255f, 0.02229591f, 0.01092327f, -0.03316363f, 
    -0.02090625f, 0.01841357f, -0.02571556f, 0.01661113f, -0.00644467f, 0.02242757f, 0.02835965f, 0.00570394f, 
    -0.03130060f, -0.01613786f, -0.01015247f, 0.02459224f, -0.01000279f, -0.01102371f, 0.02000721f, -0.01993003f, 
    -0.03073367f, -0.01097696f, -0.00053844f, 0.01372340f, -0.01458926f, 0.00771408f, -0.02130307f, 0.01800513f, 
    0.02310793f, -0.02341213f, 0.00437965f, -0.00021980f, -0.02963502f, -0.03284520f, 0.02693057f, -0.01840034f, 
    -0.01741749f, -0.02575996f, -0.01962662f, 0.00696375f, 0.02936576f, -0.03281847f, -0.02629025f, -0.00373227f, 
    -0.01658655f, -0.02299602f, -0.01753368f, -0.03818591f, 0.03063814f, -0.03816309f, 0.01743035f, 0.02609161f, 
    -0.02346690f, -0.02075951f, -0.02362966f, -0.01721358f, 0.02952763f, 0.03900042f, 0.00758444f, -0.03829175f, 
    -0.02892916f, -0.02475716f, 0.02494609f, 0.01028098f, 0.01335629f, -0.03998522f, -0.01961015f, 0.02293435f, 
    -0.04264835f, 0.01290463f, 0.00226479f, 0.03103246f, -0.04335897f, -0.02514622f, 0.02417139f, -0.02127825f, 
    -0.03955693f, 0.00645753f, 0.02030201f, -0.01999599f, 0.00815995f, 0.02428731f, -0.03078173f, -0.00665403f, 
    -0.00072165f, 0.00818869f, -0.01433081f, 0.00146216f, 0.02503992f, -0.02654527f, -0.03091899f, -0.00600603f, 
    -0.03213245f, 0.02011235f, 0.02883097f, -0.01537240f, -0.03176517f, 0.02398847f, 0.01097828f, 0.00498304f, 
    -0.00840283f, -0.02870021f, -0.01224115f, -0.03545386f, -0.03091356f, -0.04348169f, -0.03088746f, -0.02408665f, 
    -0.04167664f, -0.01838037f, -0.01243556f, 0.01703073f, -0.01784839f, -0.03554750f, -0.01428869f, 0.02250459f, 
    -0.01876624f, -0.02774811f, 0.01118459f, -0.01321730f, -0.02974498f, 0.01077025f, -0.02142320f, 0.01393896f, 
    -0.00561183f, 0.02104881f, -0.04193853f, 0.01424011f, -0.01920923f, 0.00752018f, 0.00149745f, 0.01159150f, 
    -0.00267654f, -0.02532024f, -0.03943333f, 0.00015296f, 0.01593307f, 0.02366183f, -0.02345376f, 0.01258630f, 
    0.01352015f, -0.02224906f, -0.03560765f, 0.01771156f, -0.00177990f, 0.01490515f, -0.03352904f, -0.03788856f, 
    -0.02908218f, -0.00489650f, -0.00733256f, -0.02044379f, 0.00571746f, 0.00349571f, 0.00065737f, -0.01816238f, 
    0.02503352f, -0.00505150f, -0.00579522f, 0.01185024f, -0.01245077f, -0.02982011f, -0.03724670f, -0.02804466f, 
    -0.01641017f, -0.03244378f, -0.01939915f, -0.04127020f, -0.02596043f, -0.02663537f, -0.00767176f, -0.00235391f, 
    -0.03306340f, -0.01298956f, -0.01453783f, -0.01572740f, 0.02786253f, -0.02582094f, 0.03196377f, 0.02189470f, 
    -0.01690890f, -0.03565000f, -0.00354683f, -0.04328551f, -0.02382642f, 0.01794281f, 0.00124794f, -0.03564491f, 
    -0.01165689f, -0.02944539f, 0.01447977f, -0.00805339f, -0.02670822f, -0.01089266f, -0.00472146f, 0.02706502f, 
    0.02454363f, 0.00756681f, -0.01068546f, -0.03520581f, 0.00601856f, 0.01728860f, -0.02694388f, 0.00696627f, 
    -0.02724992f, -0.00844252f, -0.01029666f, 0.00170758f, 0.02720061f, -0.01072168f, 0.01125613f, 0.02384602f, 
    -0.01413375f, 0.02104800f, 0.01128620f, 0.02066355f, 0.01092659f, -0.00925287f, 0.02512441f, -0.04025747f, 
    -0.03958897f, 0.00764658f, -0.01810774f, -0.01537563f, 0.00090038f, -0.01614690f, -0.00988074f, 0.02084267f, 
    -0.03538951f, 0.01594846f, -0.03680157f, -0.00370903f, 0.01110850f, 0.01532035f, 0.01650597f, -0.02051451f, 
    -0.01421908f, 0.02888443f, -0.01210967f, 0.00186438f, 0.02604670f, 0.01450823f, 0.02389343f, -0.00535460f, 
    0.02208700f, -0.01534147f, 0.00656277f, 0.01366036f, 0.01032807f, -0.00458229f, 0.01070812f, 0.00619909f, 
    0.02366760f, -0.04029189f, -0.00276001f, 0.02507888f, 0.00733661f, 0.00766821f, -0.00543256f, 0.00030716f, 
    -0.00711784f, -0.00040319f, 0.00379610f, 0.00769767f, 0.00501354f, -0.02060447f, -0.02917003f, -0.02376455f, 
    -0.03265375f, 0.00190679f, -0.01124168f, -0.03357403f, -0.01862325f, -0.01762294f, 0.01552631f, -0.03272245f, 
    0.02752757f, 0.00068802f, -0.02499088f, 0.01357942f, 0.01333192f, 0.02750107f, 0.00774344f, 0.01665657f, 
    -0.00029914f, 0.01383727f, -0.04012135f, 0.02707308f, -0.03193231f, 0.00725697f, -0.02128893f, 0.01757715f, 
    -0.03237709f, -0.00570485f, -0.02270468f, 0.01961484f, 0.00018430f, 0.00826136f, -0.04161739f, 0.02207903f, 
    0.00177265f, -0.01004843f, -0.04193829f, -0.00620232f, -0.03144618f, -0.01799784f, 0.02689345f, -0.00620270f, 
    0.00467046f, -0.01811644f, -0.02710917f, -0.02746777f, -0.03023291f, -0.00911755f, 0.01881686f, 0.02503229f, 
    -0.00302181f, 0.01123909f, -0.03086457f, 0.01722706f, -0.01122819f, -0.03742763f, 0.00440101f, -0.02761990f, 
    0.00279844f, 0.02054830f, -0.02242168f, -0.03448239f, 0.02233482f, -0.03072832f, -0.01759597f, 0.00883310f, 
    0.00324994f, 0.00051010f, 0.02544513f, 0.01005934f, -0.00727355f, 0.02191449f, 0.02594300f, -0.00775239f, 
    0.02303565f, -0.03798203f, -0.01765302f, 0.01989142f, 0.02599102f, 0.01365234f, -0.04014743f, -0.03974590f, 
    0.01285868f, -0.00997652f, -0.01985842f, 0.02766253f, 0.00884448f, -0.04279399f, -0.01061923f, -0.01655374f, 
    -0.03179419f, -0.03214876f, -0.02574427f, -0.01730389f, 0.02382332f, -0.03498491f, 0.00837563f, -0.02228865f, 
    -0.02028350f, 0.00679355f, -0.02492313f, 0.00863941f, 0.00661389f, -0.01942792f, -0.00061666f, -0.02235748f, 
    -0.02608400f, 0.01757655f, 0.02835669f, -0.00173582f, -0.00463330f, -0.03934675f, 0.00253138f, -0.03034458f, 
    -0.02904156f, 0.00875978f, -0.03321220f, -0.03340203f, 0.01537667f, -0.01625412f, 0.02624190f, -0.00693477f, 
    -0.00112669f, 0.01237451f, 0.00813836f, -0.01749977f, 0.02869262f, 0.02544213f, -0.01976402f, -0.02347248f, 
    -0.03957496f, 0.02816314f, -0.00236329f, -0.02247340f, -0.00870588f, -0.03832782f, -0.04182676f, 0.02296814f, 
    -0.00572960f, 0.00557071f, -0.04116766f, 0.01552535f, -0.01190235f, -0.03150462f, -0.02962215f, -0.03795530f, 
    -0.03215846f, 0.02462158f, -0.01096530f, 0.02453128f, 0.00820107f, -0.03230611f, 0.00764200f, -0.02748529f, 
    0.02550721f, -0.00387017f, -0.00906990f, -0.02500492f, -0.03746929f, -0.03438647f, 0.02525457f, 0.02444698f, 
    -0.01948565f, -0.10640117f, 0.29324484f, -0.11452654f, 0.01454802f, 0.08022526f, -0.06885159f, -0.01947495f, 
    -0.01790759f, 0.13919877f, 0.00713862f, -0.00662295f, -0.15791839f, -0.00156095f, 0.10126358f, 0.02606511f, 
    0.02524727f, 0.09479322f, 0.07778816f, 0.04077643f, 0.01398151f, -0.00069838f, -0.04105432f, 0.09985960f, 
    0.17729154f, 0.07458343f, -0.14159939f, 0.20013979f, -0.08210769f, -0.02683067f, 0.00157922f, 0.07068741f, 
    -0.08010205f, -0.05715923f, 0.09600507f, -0.08493189f, -0.02187090f, -0.14965487f, 0.16932261f, 0.14815670f, 
    -0.17426498f, 0.10373369f, 0.06701734f, 0.03610588f, 0.03536076f, -0.04087019f, -0.03146225f, 0.03639016f, 
    0.01629938f, -0.11931005f, 0.01080008f, 0.04183770f, -0.04253759f, -0.04432712f, -0.02806468f, -0.09585602f, 
    0.05689434f, -0.03187232f, 0.04935807f, -0.08469606f, 0.00681590f, -0.09982929f, 0.24605021f, 0.34675065f, 
    -0.05210849f, -0.09415691f, -0.00875852f, -0.06069186f, -0.00425253f, 0.08375134f, -0.03780827f, -0.04124981f, 
    0.00095447f, 0.12918654f, 0.25087780f, 0.05486779f, 0.00708932f, 0.01300229f, 0.01343527f, 0.06737217f, 
    -0.04091458f, 0.07338539f, -0.07091402f, -0.02372011f, 0.08825179f, -0.17649254f, 0.08753732f, 0.13829231f, 
    -0.07026254f, -0.08322155f, -0.01191438f, 0.17232959f, -0.00267591f, -0.04975208f, 0.04084591f, -0.06259912f, 
    0.11844230f, 0.14305510f, 0.08932046f, 0.11749015f, 0.00152268f, -0.02223565f, 0.01695133f, -0.10995660f, 
    -0.05320595f, -0.08883117f, -0.04539007f, 0.04864886f, -0.25541309f, -0.07947651f, 0.21231541f, 0.14193337f, 
    0.04487284f, -0.01208694f, -0.02101339f, 0.01646853f, 0.01233937f, -0.05402001f, -0.00838136f, 0.06504115f, 
    -0.00497302f, 0.22531646f, 0.18976337f, -0.03934433f, -0.02519084f, 0.03125783f, 0.07694791f, 0.08990611f, 
    0.05473408f, -0.00879568f, 0.06650857f, 0.00728083f, 0.11163524f, -0.10654527f, -0.02494832f, -0.01215063f, 
    -0.09532944f, -0.05990161f, -0.02668995f, -0.08924344f, 0.02352770f, 0.09450872f, -0.01655243f, -0.03312638f, 
    -0.04943236f, 0.09339979f, 0.03639172f, 0.08963033f, 0.09096839f, 0.05210547f, 0.05312234f, 0.14303654f, 
    -0.04787579f, 0.08005103f, 0.10959034f, -0.05918755f, -0.02436858f, 0.19167113f, -0.05290933f, -0.07893475f, 
    0.00092867f, 0.05210245f, 0.04621026f, 0.03474524f, 0.00337485f, 0.09076265f, 0.04216557f, -0.06776154f, 
    -0.16006139f, 0.12022205f, 0.03357552f, 0.15580904f, -0.05967342f, -0.03891863f, 0.01910586f, -0.05075431f, 
    0.03929548f, -0.00936420f, -0.03681187f, -0.05889690f, -0.16099265f, 0.08431391f, -0.02908763f, 0.08695141f, 
    -0.00950076f, -0.12329046f, -0.11089340f, 0.04844511f, 0.03245929f, 0.12827465f, -0.03875701f, -0.00445763f, 
    0.00699434f, 0.00860657f, -0.08440036f, 0.36368504f, -0.01093054f, 0.03146287f, 0.02399047f, 0.05939605f, 
    -0.00830623f, 0.01062307f, 0.00967259f, 0.22165109f, -0.05874279f, 0.16193913f, 0.07755467f, -0.09500449f, 
    0.00256639f, 0.01184424f, 0.13671337f, 0.01457985f, 0.02062606f, 0.05075889f, 0.01081617f, 0.02280063f, 
    0.07445408f, -0.10217460f, -0.05395406f, 0.21298619f, 0.04021095f, 0.01368191f, 0.01094271f, 0.00073771f, 
    -0.02115983f, 0.06591083f, -0.08780861f, 0.12155538f, -0.12739222f, 0.00002075f, 0.06785602f, -0.06455350f, 
    0.10038117f, -0.04784351f, -0.02351088f, -0.04383451f, 0.11879899f, 0.00338319f, -0.06214282f, 0.06542155f, 
    -0.40231943f, 0.10870694f, 0.04117744f, -0.04486624f, 0.06041233f, -0.02243224f, -0.06437580f, 0.06656860f, 
    -0.00072311f, -0.01513213f, -0.10883633f, 0.00952552f, -0.11602488f, 0.01598300f, -0.11080481f, 0.06920741f, 
    0.05443780f, 0.04257137f, -0.01048391f, 0.11161139f, 0.01948261f, 0.05231112f, -0.01219833f, -0.01806694f, 
    0.14462894f, 0.01298502f, -0.03520544f, 0.02268294f, 0.03351544f, 0.09590080f, 0.07030687f, -0.03694297f, 
    0.03077671f, 0.01196584f, 0.05736860f, -0.02241761f, -0.06137517f, 0.04538870f, 0.01854444f, -0.01640503f, 
    -0.13223599f, -0.00744857f, 0.00508749f, 0.00994035f, -0.05574964f, 0.05773079f, -0.04015651f, -0.00843709f, 
    0.00843538f, 0.04276930f, 0.05230307f, -0.04092106f, 0.04152833f, 0.10768769f, 0.03606559f, 0.15383090f, 
    0.10464472f, 0.17163321f, 0.09240647f, 0.12997341f, -0.18749051f, -0.22614163f, -0.02648548f, -0.09518917f, 
    -0.04171530f, -0.02760616f, 0.02155011f, -0.01659449f, 0.07484861f, -0.07820309f, -0.05093032f, -0.03980705f, 
    0.35831833f, 0.20344397f, -0.19930705f, 0.04492874f, 0.03739537f, 0.08533420f, 0.09835064f, 0.01259001f, 
    -0.00838775f, -0.16595645f, 0.09283678f, 0.03779583f, -0.16230503f, -0.00684146f, 0.14581816f, 0.09977910f, 
    0.03152955f, -0.04663344f, -0.03965353f, -0.05288998f, 0.09665300f, 0.03350020f, -0.08113617f, 0.03187714f, 
    0.16722213f, 0.09996532f, 0.03833823f, -0.04818513f, 0.11868952f, 0.04730009f, 0.03151078f, 0.06203195f, 
    0.01622823f, -0.06194786f, 0.06641160f, -0.06257755f, -0.10094379f, 0.15789542f, 0.00862578f, 0.05313433f, 
    -0.12864603f, 0.04634748f, -0.05320904f, 0.09881233f, 0.06939404f, 0.07298951f, 0.03009617f, -0.03143026f, 
    0.30988634f, -0.18996736f, -0.14491548f, -0.11206454f, -0.01334345f, 0.01194655f, 0.06670681f, -0.09939058f, 
    0.07126448f, 0.07627426f, -0.01046474f, -0.01943149f, 0.18106546f, -0.02535887f, 0.12389112f, -0.00956243f, 
    -0.08860736f, -0.01989176f, 0.00498268f, -0.05335180f, -0.04610950f, 0.08378100f, 0.18638338f, -0.10436960f, 
    0.07076571f, 0.07932846f, -0.01715959f, -0.04958133f, -0.00165655f, 0.08922424f, -0.02228298f, -0.09487136f, 
    -0.03453198f, 0.08398800f, 0.01713436f, -0.00800291f, 0.03881152f, 0.09080116f, 0.14137164f, 0.19044660f, 
    0.03096900f, 0.08805992f, 0.03870842f, 0.03763097f, 0.06240106f, -0.07931519f, 0.04719856f, -0.02611601f, 
    -0.34658417f, 0.14186448f, 0.05235249f, -0.10781834f, 0.06774273f, -0.12286325f, 0.04430827f, 0.01212577f, 
    0.08735213f, -0.02350500f, -0.00533643f, -0.00179644f, -0.08433019f, 0.04300666f, 0.17828318f, 0.07917232f, 
    -0.01293235f, 0.04839482f, 0.03628261f, 0.05879949f, 0.03346539f, 0.09311367f, -0.02053799f, 0.09806606f, 
    0.36273497f, 0.29239708f, 0.25569618f, -0.06239534f, -0.03886441f, 0.02159337f, 0.09915084f, -0.06056497f, 
    0.05316290f, 0.00672235f, -0.05004449f, 0.02827999f, -0.07124793f, 0.04370324f, -0.02953673f, 0.06338984f, 
    -0.06470120f, -0.00775743f, 0.12770133f, -0.05628288f, -0.00666108f, 0.14537838f, 0.02940370f, 0.02394639f, 
    -0.04177950f, -0.01092137f, 0.11136985f, 0.08733748f, 0.05303348f, 0.06488935f, -0.00140003f, 0.01451396f, 
    0.01942450f, -0.04183888f, 0.00109144f, 0.06782738f, -0.15530454f, -0.10308402f, 0.20128644f, 0.20400101f, 
    -0.07525767f, -0.04836948f, -0.00968987f, -0.08927135f, 0.02336731f, 0.03765450f, -0.04713865f, -0.09927822f, 
    -0.02215093f, 0.01112959f, 0.16236793f, 0.13511170f, -0.06686015f, 0.06432735f, 0.00374720f, 0.04872895f, 
    -0.04441472f, 0.13394456f, 0.08190344f, 0.07047946f, 0.06225960f, -0.30187622f, -0.17348255f, 0.03369159f, 
    -0.05317337f, -0.04815540f, -0.04867477f, -0.01605826f, 0.04426863f, 0.02232761f, -0.07683508f, -0.06211140f, 
    -0.36121860f, -0.02614128f, 0.01370181f, 0.09645937f, 0.08091599f, 0.00078735f, 0.05281135f, 0.00621304f, 
    0.01711208f, -0.00975411f, 0.00496956f, -0.12470815f, -0.47484612f, 0.06906942f, -0.11443665f, -0.18043198f, 
    0.04815147f, -0.00073065f, 0.04037869f, 0.05982124f, 0.00140953f, -0.09869850f, 0.11341925f, 0.03708941f, 
    -0.01178662f, 0.06123424f, -0.14741555f, 0.07563654f, 0.08895061f, 0.06276487f, 0.07365780f, 0.01315872f, 
    -0.01671336f, -0.04996940f, -0.01981590f, -0.08724260f, -0.15392181f, -0.28668797f, 0.01635665f, -0.13742909f, 
    -0.05799541f, 0.01078902f, 0.07412735f, 0.00227095f, -0.10557632f, -0.02522670f, 0.02278119f, -0.00402540f, 
    0.18784317f, -0.10542668f, -0.02260769f, 0.15968373f, 0.03548071f, -0.09042227f, -0.07355705f, -0.02612277f, 
    0.09966377f, -0.07715956f, 0.08632195f, 0.05558800f, -0.11898373f, -0.18279637f, 0.02715186f, 0.15171427f, 
    -0.12083159f, 0.03057859f, -0.02887498f, 0.01918044f, -0.00542220f, -0.07943108f, -0.01508676f, -0.06734421f, 
    0.20263846f, -0.17884094f, -0.13146865f, 0.16183896f, 0.00330574f, 0.03400267f, -0.07037582f, 0.04447987f, 
    0.14470012f, 0.03697187f, 0.03208885f, -0.02942654f, -0.14233603f, 0.29891127f, 0.31910795f, 0.04390708f, 
    0.01154502f, -0.03470546f, -0.02380348f, 0.03503128f, 0.00317411f, -0.00118489f, 0.03270419f, -0.05050142f, 
    0.11667272f, -0.24944806f, -0.05331114f, -0.07703296f, 0.00656414f, -0.03023515f, 0.02266798f, 0.06280555f, 
    -0.10867187f, 0.06386206f, 0.06330433f, 0.02523476f, -0.52247488f, 0.23058149f, -0.04547860f, -0.05123080f, 
    -0.11924824f, 0.08528589f, -0.01627501f, -0.00555851f, 0.04064748f, -0.03360775f, -0.05049902f, -0.04654526f, 
    0.18683469f, 0.00975246f, -0.00831524f, -0.01118089f, -0.07692866f, -0.03921667f, -0.00600706f, -0.01233012f, 
    -0.02480238f, -0.09442991f, 0.09788083f, 0.04219246f, -0.06778184f, -0.17838387f, 0.02151565f, 0.09998799f, 
    -0.15765864f, -0.07565142f, 0.03594055f, -0.18952547f, -0.00606681f, -0.02027103f, 0.05178847f, 0.01923307f, 
    0.32995951f, -0.04429561f, 0.08224184f, -0.11742191f, 0.01960893f, 0.05933826f, -0.01389322f, -0.03295157f, 
    -0.16021796f, -0.01161851f, -0.05055203f, 0.00962478f, 0.29015335f, 0.06736691f, 0.00897211f, -0.01893580f, 
    -0.05200873f, 0.01015909f, 0.05273642f, 0.06026010f, 0.05277473f, 0.00979847f, -0.08932793f, 0.06885726f, 
    0.17655225f, 0.00814461f, -0.05770538f, 0.14696276f, 0.03749540f, 0.09414379f, 0.03198128f, 0.04438737f, 
    -0.11999071f, 0.12821068f, -0.02202609f, -0.02691085f, 0.13787587f, 0.05550596f, -0.08057224f, -0.08562096f, 
    -0.13326223f, -0.08762423f, 0.14242432f, -0.07081210f, -0.01364723f, 0.06462364f, 0.00142848f, -0.00582311f, 
    -0.11238851f, 0.04348843f, 0.24856888f, -0.02037337f, 0.09964100f, 0.04483639f, 0.05559788f, 0.15262446f, 
    0.02883890f, 0.16286799f, -0.02764548f, 0.13586204f, 0.19028352f, -0.08620224f, -0.08219390f, -0.06850987f, 
    0.03675029f, 0.00090919f, -0.20142424f, -0.13640526f, -0.01043176f, -0.00361506f, 0.07381906f, 0.02604583f, 
    0.38388819f, -0.04452577f, 0.03772480f, 0.22253655f, 0.04286713f, 0.00927761f, -0.05830846f, -0.03499098f, 
    0.06007168f, 0.00561100f, 0.01901168f, -0.03582623f, 0.02537028f, -0.02365022f, 0.13840123f, 0.09454670f, 
    -0.15488097f, -0.06430310f, 0.02066750f, -0.02963262f, 0.04354297f, -0.10691942f, 0.01506997f, -0.06344927f, 
    -0.14746809f, -0.05106979f, -0.05615586f, 0.09186558f, -0.09958580f, -0.11459074f, 0.03142397f, -0.02179614f, 
    -0.03247013f, 0.02370687f, -0.08513159f, -0.08563060f, 0.02916050f, 0.12104890f, 0.18305430f, 0.08103466f, 
    -0.04271822f, 0.00852896f, -0.06824764f, 0.00741616f, 0.01403510f, 0.00801824f, -0.01351952f, 0.07359327f, 
    -0.10612145f, 0.15439263f, -0.05664975f, 0.17940032f, 0.02925558f, 0.03345009f, -0.03829418f, -0.09636587f, 
    -0.05089301f, -0.03798176f, -0.01502803f, 0.01518496f, 0.06773987f, 0.00009012f, -0.02116611f, 0.01555215f, 
    -0.06574133f, -0.01662629f, -0.01702588f, 0.03455043f, 0.09922829f, -0.09840263f, -0.06582439f, -0.02499030f, 
    -0.51936370f, -0.04010527f, 0.01705496f, -0.13201781f, 0.22741570f, -0.07926955f, 0.06403352f, -0.05304968f, 
    0.02851867f, 0.04072608f, 0.05011756f, 0.05673579f, -0.00355301f, 0.29041395f, -0.22192487f, -0.16401447f, 
    0.17050408f, 0.08107902f, -0.08542421f, -0.02926306f, -0.00244056f, 0.05620500f, 0.12921816f, 0.09866312f, 
    -0.11101941f, -0.05024620f, -0.10088876f, -0.22660375f, 0.09958985f, 0.04332106f, -0.01128031f, 0.00466984f, 
    0.04121099f, -0.02342135f, 0.09166493f, 0.01666013f, 0.09459762f, 0.08035545f, -0.22627968f, -0.06407008f, 
    0.08147494f, -0.01770779f, -0.06332056f, 0.04038035f, -0.02961864f, -0.01302182f, 0.08114303f, 0.01876940f, 
    -0.11891881f, -0.07259534f, 0.02058951f, -0.06604402f, -0.08635117f, -0.02850448f, 0.19466352f, -0.11370622f, 
    -0.03912215f, -0.01001986f, 0.04345782f, 0.02584488f, -0.12597963f, 0.00178772f, -0.18347336f, -0.05750518f, 
    0.11367850f, 0.20760408f, -0.15031491f, 0.05578128f, -0.01033980f, 0.09824533f, -0.09543064f, -0.09578908f, 
    -0.10243309f, -0.09472945f, -0.06820567f, 0.09894299f, 0.04663290f, 0.05356994f, -0.05693336f, 0.06706817f, 
    0.06814469f, -0.01921263f, -0.06094223f, 0.04249336f, 0.28774336f, 0.10217251f, -0.11000270f, -0.01098177f, 
    -0.09247805f, -0.02082284f, 0.09129554f, -0.06060841f, -0.00752013f, 0.06048559f, 0.02556565f, 0.00216768f, 
    0.08005777f, -0.05055728f, 0.02256849f, 0.10356528f, 0.02573754f, 0.05104940f, -0.15427190f, 0.08239859f, 
    -0.03189168f, -0.03270877f, -0.03331514f, -0.00196806f, -0.25088862f, 0.21126121f, 0.01067574f, 0.12552555f, 
    0.04767893f, 0.06250576f, 0.07085349f, -0.01511712f, 0.10809466f, -0.00599769f, -0.06727435f, 0.09166215f, 
    -0.00905745f, 0.00016006f, 0.13130808f, -0.00609175f, -0.08263302f, -0.04771223f, -0.02438396f, -0.07311757f, 
    0.05364786f, 0.00460897f, -0.03510927f, 0.04930938f, -0.03980430f, -0.08128884f, 0.09086934f, 0.04529342f, 
    -0.04644044f, 0.07336394f, 0.01779162f, 0.07792585f, -0.05947777f, 0.03930071f, -0.01714314f, 0.11554874f, 
    0.17829563f, -0.18907855f, 0.03867876f, -0.03743231f, 0.00623783f, -0.05110910f, 0.05242473f, 0.04327393f, 
    -0.02021562f, 0.09609266f, 0.14531860f, 0.12199276f, -0.18038093f, -0.07733119f, -0.11353727f, -0.18450135f, 
    0.01419807f, 0.02087817f, 0.03637391f, -0.07621045f, 0.02007078f, 0.03967870f, 0.02208560f, -0.03074090f, 
    -0.14713036f, -0.09085733f, -0.09970796f, -0.15741533f, 0.08240920f, -0.14981554f, -0.05482043f, -0.00061955f, 
    0.03221060f, 0.04607638f, -0.06995721f, -0.04419003f, 0.14706045f, 0.02191067f, 0.02253963f, -0.02619306f, 
    -0.05740988f, 0.06956314f, -0.08059388f, 0.05526834f, -0.11916377f, 0.03501732f, 0.02266028f, -0.03255101f, 
    -0.22467344f, 0.01597536f, -0.23595430f, -0.11645664f, 0.07610698f, 0.05210280f, 0.01485593f, -0.06208097f, 
    -0.06347907f, 0.08765204f, 0.08269940f, -0.06014539f, 0.19423279f, 0.05723779f, -0.00314408f, -0.07776826f, 
    -0.10231393f, -0.07672808f, 0.07967529f, -0.10410880f, -0.08077727f, -0.03858694f, 0.01050448f, 0.02532286f, 
    0.04921298f, 0.11731411f, 0.09584162f, -0.01691087f, 0.03741075f, -0.03450869f, 0.05601344f, -0.04850380f, 
    -0.01714773f, 0.09921966f, 0.04605207f, 0.02089536f, 0.16862325f, 0.05433983f, 0.09185046f, -0.14015506f, 
    -0.10721108f, -0.07165567f, -0.03167684f, -0.03856380f, -0.03260341f, -0.00990564f, 0.05207580f, -0.09157031f, 
    -0.04057593f, 0.16165632f, 0.06557759f, 0.06832354f, -0.01459529f, 0.03181789f, -0.08136080f, -0.01143316f, 
    0.21894887f, 0.01952861f, 0.05116321f, 0.02149988f, -0.27073202f, 0.26624721f, -0.01689986f, 0.00415312f, 
    0.07196159f, 0.08303154f, -0.08884641f, 0.01524373f, 0.17742509f, -0.10316054f, -0.03730128f, 0.07371355f, 
    0.10586537f, -0.01020593f, 0.16616657f, 0.15095755f, 0.07071187f, 0.00054608f, -0.04071251f, 0.01702630f, 
    -0.00156477f, -0.02883759f, -0.03371454f, -0.00023608f, 0.33132681f, 0.17429318f, -0.05506616f, 0.08239898f, 
    0.11786504f, -0.01323703f, 0.05829793f, 0.01112727f, -0.02508010f, -0.03041234f, -0.04677201f, 0.15781435f, 
    0.09549486f, 0.04294304f, 0.19134015f, -0.08763249f, 0.05779340f, -0.08910258f, -0.02807225f, -0.08553300f, 
    0.05686250f, 0.03543265f, -0.07576906f, 0.12854652f, 0.08862580f, 0.04797194f, -0.03717756f, -0.08360857f, 
    0.06815828f, -0.01586638f, -0.01630476f, 0.10135065f, 0.05991039f, 0.04634779f, 0.13396537f, -0.12108274f, 
    -0.01466780f, 0.08819655f, 0.07318308f, 0.08542514f, -0.07350042f, -0.03763068f, 0.04277917f, 0.00219989f, 
    0.07823773f, -0.02149336f, 0.01515058f, -0.03230959f, -0.18117669f, -0.08611053f, 0.04282954f, -0.15505911f, 
    0.17393190f, 0.01742526f, -0.05517922f, -0.03096847f, 0.03016740f, 0.10912843f, -0.02829555f, 0.04210570f, 
    -0.31674549f, 0.23059684f, -0.05273578f, 0.07988512f, 0.11857561f, 0.16447994f, -0.13184644f, -0.00613351f, 
    0.01052214f, -0.06517691f, 0.10830182f, -0.01404515f, -0.32823265f, 0.00094907f, -0.18874969f, -0.15059893f, 
    0.06162753f, 0.00800889f, -0.01801258f, -0.09457465f, -0.09995103f, -0.00084027f, 0.01245050f, 0.04526389f, 
    0.01191862f, 0.31316051f, -0.10145988f, 0.03274935f, -0.01890704f, -0.00921998f, 0.02811829f, 0.14112513f, 
    -0.09785609f, -0.08134855f, -0.02297698f, -0.01087607f, 0.06001003f, 0.09794071f, -0.04605751f, 0.06130305f, 
    -0.00603428f, 0.10970259f, -0.08517209f, -0.01450465f, -0.00827765f, 0.03346574f, -0.14760597f, -0.15830564f, 
    0.29758677f, -0.08190166f, 0.01110206f, 0.08307899f, -0.05878933f, -0.01508538f, 0.06892583f, 0.02447760f, 
    0.11059985f, 0.08642986f, 0.02703422f, -0.08039013f, -0.11005459f, 0.20247415f, -0.09513273f, -0.03578881f, 
    0.00348556f, 0.09004448f, 0.07229756f, 0.02083766f, 0.04945600f, 0.06807893f, -0.12108805f, 0.06875843f, 
    0.09071812f, -0.08181699f, 0.06124267f, 0.15476346f, 0.03730811f, 0.09393332f, -0.02878765f, -0.02828874f, 
    -0.13854551f, -0.07588272f, 0.06776865f, 0.04356420f, 0.10766791f, -0.30405003f, 0.04583306f, -0.05648720f, 
    0.11188469f, -0.12367322f, -0.07728227f, -0.04751569f, 0.09409166f, 0.06474116f, 0.09570769f, 0.00830902f, 
    0.34643143f, 0.19740127f, 0.04650249f, -0.01250576f, -0.00939512f, 0.07624445f, 0.01022286f, 0.01916330f, 
    0.04169079f, 0.03996531f, -0.00142671f, 0.00250610f, 0.30181873f, 0.18610488f, 0.01429232f, -0.06362736f, 
    0.05759374f, 0.08693278f, 0.06542463f, 0.04652258f, 0.05893998f, 0.06652206f, 0.07849645f, -0.02819552f, 
    -0.14003764f, -0.03071189f, 0.05066328f, 0.26119247f, -0.07908987f, -0.02836428f, 0.01421421f, -0.05195557f, 
    0.06748359f, 0.03956899f, 0.04350331f, -0.01380230f, -0.20620121f, 0.26150090f, -0.03609820f, 0.08973340f, 
    0.02901143f, 0.08294149f, -0.00918768f, -0.07043198f, -0.04789582f, 0.04721136f, 0.08918828f, -0.03154823f, 
    -0.11208060f, -0.06713501f, 0.14774574f, 0.00458376f, -0.02890828f, -0.00562587f, 0.03081818f, 0.04513855f, 
    0.04753589f, -0.19821075f, 0.01559421f, 0.04916913f, 0.24756856f, -0.05573412f, 0.24407695f, 0.11718062f, 
    0.00721104f, -0.04108589f, 0.00807227f, 0.06007409f, 0.01993387f, 0.01972811f, 0.09750225f, -0.08025465f, 
    -0.02113639f, 0.37039992f, -0.01643203f, 0.26604322f, -0.11644042f, -0.01429070f, -0.00567499f, 0.02292801f, 
    0.07990095f, 0.06773796f, 0.06197494f, 0.01896013f, -0.10651486f, 0.35931319f, 0.11756562f, 0.21585216f, 
    -0.01121660f, 0.09137475f, -0.02470582f, 0.03415691f, 0.28313115f, 0.02047454f, 0.00934031f, 0.03110983f, 
    -0.12217665f, 0.02577304f, -0.12442537f, -0.22325037f, 0.12619661f, 0.07620269f, -0.04213079f, -0.06760356f, 
    0.00842579f, -0.04568861f, -0.06952876f, -0.04420384f, 0.13689539f, 0.15671729f, -0.01038118f, -0.06978603f, 
    0.16747469f, -0.00395940f, -0.09420083f, -0.02294930f, -0.03048309f, 0.07487211f, -0.01493917f, 0.05859372f, 
    -0.04703018f, -0.06736778f, 0.02725750f, -0.12565830f, 0.04714653f, 0.10910903f, 0.08487020f, 0.12913638f, 
    0.04704366f, -0.07451548f, 0.07134379f, 0.00854076f, 0.41535619f, -0.30683261f, 0.10592107f, 0.27428636f, 
    0.00011383f, 0.04130764f, -0.06972595f, 0.07491692f, -0.03160663f, 0.08310890f, 0.02488921f, 0.06672186f, 
    -0.04831476f, 0.17557213f, -0.18155386f, -0.01438427f, -0.03826160f, 0.02771571f, 0.01931089f, 0.03396999f, 
    0.06642585f, -0.02176272f, -0.01488177f, 0.01121878f, 0.04677720f, 0.09393258f, -0.05109781f, 0.07939699f, 
    0.07033626f, -0.09576825f, 0.05968862f, 0.02240257f, 0.03098537f, 0.11917307f, 0.04331212f, 0.04048394f, 
    0.06983317f, 0.26988971f, 0.11368030f, -0.11221997f, 0.11227274f, 0.13198458f, -0.07853574f, -0.00277419f, 
    0.07353547f, 0.01123563f, -0.01776776f, 0.09269816f, 0.14610527f, 0.11272917f, -0.09362265f, -0.10176763f, 
    0.01407417f, 0.08831284f, -0.05754768f, 0.01447693f, -0.04691025f, 0.05811160f, 0.05605948f, 0.02594305f, 
    0.19600286f, 0.15404497f, 0.11691497f, -0.05254431f, 0.05919038f, 0.09284825f, 0.00016336f, 0.18880391f, 
    -0.04524367f, 0.17309532f, -0.06574389f, 0.01966429f, -0.13827991f, 0.11257900f, 0.07996368f, 0.01064531f, 
    -0.01286886f, 0.05861811f, -0.03144957f, 0.07161930f, -0.01102030f, -0.04837338f, 0.06947142f, -0.00100531f, 
    -0.02112410f, 0.07662776f, 0.12274778f, 0.03900382f, -0.04636948f, 0.04718536f, -0.04633890f, -0.02579763f, 
    0.13530064f, 0.05455316f, 0.19724980f, 0.04820459f, -0.26844317f, 0.21527065f, 0.11633100f, 0.21805122f, 
    0.10855116f, 0.08900002f, -0.08838224f, -0.01995366f, 0.07479491f, 0.17059518f, 0.04114480f, 0.10276732f, 
    0.19366995f, -0.05744368f, -0.11497860f, 0.03328398f, -0.19063257f, 0.01294088f, 0.04526569f, 0.05693084f, 
    0.04907432f, 0.00611892f, 0.08879393f, -0.09920169f, 0.28144461f, 0.05369125f, 0.05291329f, 0.02855514f, 
    0.10774904f, 0.07544861f, 0.12359098f, 0.10091289f, 0.04199361f, 0.01976983f, -0.09208050f, 0.11159826f, 
    -0.08550681f, 0.06204734f, -0.03985673f, -0.24238235f, 0.07574040f, 0.00901568f, 0.07649884f, 0.04051675f, 
    -0.01067745f, 0.01382186f, 0.05224834f, -0.00995111f, -0.21196684f, -0.30002320f, -0.13200681f, -0.09176338f, 
    0.09458524f, 0.01349335f, -0.07055621f, -0.13108952f, 0.01410369f, -0.00159200f, -0.00515644f, -0.07120541f, 
    -0.07995586f, -0.04223876f, -0.07176669f, -0.27297872f, 0.10674162f, -0.09334286f, -0.08765505f, -0.07195079f, 
    -0.09856747f, -0.10088280f, 0.04133795f, 0.05339720f, 0.38563165f, -0.15780455f, 0.17364380f, 0.08679749f, 
    0.14085585f, 0.07796103f, 0.02707496f, 0.05834163f, 0.02547500f, 0.00063466f, 0.09441731f, 0.13707227f, 
    0.00665383f, -0.01099236f, -0.00120535f, 0.02187369f, 0.01728707f, 0.02871762f, -0.01237274f, -0.02405943f, 
    -0.01888797f, -0.00498556f, 0.00563866f, -0.04213165f, 0.01143051f, -0.03739144f, 0.01792737f, -0.01797599f, 
    -0.02149865f, -0.01742064f, -0.03104055f, 0.02565593f, -0.03746194f, -0.04060432f, 0.02329610f, -0.02388287f, 
    -0.00959862f, -0.00304657f, 0.02560565f, 0.00156627f, 0.01340334f, -0.01015508f, -0.02314454f, -0.01259987f, 
    -0.02960863f, 0.01204962f, -0.02909017f, 0.02384603f, -0.00981574f, -0.02719692f, 0.02239838f, 0.00324415f, 
    -0.02574636f, -0.04112280f, 0.01934628f, 0.01945253f, -0.02797666f, 0.01149096f, 0.00387888f, -0.01183818f, 
    0.01970409f, -0.03505867f, -0.03417427f, 0.01565772f, 0.00609557f, -0.00994821f, -0.03166654f, -0.01255145f, 
    -0.03272574f, -0.01893504f, -0.00967737f, 0.02140902f, 0.01817972f, 0.02006496f, -0.01843793f, 0.02043714f, 
    0.02032533f, -0.00766181f, 0.01131645f, -0.01659168f, -0.02724737f, -0.02082155f, 0.01051543f, -0.01220545f, 
    0.02011487f, 0.00544455f, -0.00703567f, 0.02277282f, 0.01526092f, 0.01425294f, 0.02108732f, -0.00899878f, 
    -0.02560334f, -0.01369027f, 0.01410162f, -0.03669550f, -0.02374963f, 0.01403787f, 0.01393397f, -0.02954168f, 
    0.00791674f, -0.04408710f, -0.02240099f, 0.02436126f, -0.00573649f, -0.03497161f, 0.01070959f, -0.01931999f, 
    0.00539502f, -0.01719061f, 0.02410608f, -0.00271862f, 0.02583323f, 0.01887731f, -0.02430524f, -0.03750108f, 
    -0.01652511f, -0.01350931f, -0.00858734f, -0.01351982f, 0.02932683f, 0.02363699f, -0.03456664f, -0.03220467f, 
    0.03079684f, 0.00768577f, -0.00417051f, 0.00176037f, -0.02363224f, 0.02205752f, -0.02988440f, -0.02305559f, 
    -0.04191175f, -0.03127003f, 0.00933920f, -0.00597097f, -0.02416921f, -0.03266230f, -0.02311960f, 0.02713918f, 
    0.01361305f, 0.01371804f, 0.02485348f, -0.02326568f, -0.00245514f, -0.03345071f, 0.02573697f, 0.00353201f, 
    -0.02591229f, -0.01991639f, -0.03654886f, 0.02695915f, -0.01844680f, 0.00952948f, -0.01026770f, 0.02788978f, 
    0.01931169f, 0.02825754f, 0.01364994f, 0.02959979f, 0.01506396f, -0.02417038f, 0.02326031f, -0.02775100f, 
    -0.00007727f, 0.00337115f, -0.03056462f, -0.01308101f, -0.03231198f, -0.02904991f, -0.04074458f, -0.00909244f, 
    -0.01624564f, -0.03907717f, -0.01488579f, -0.01264539f, 0.02459819f, -0.03020304f, 0.01216917f, 0.00858300f, 
    0.00641669f, -0.00504401f, -0.03580921f, -0.01941917f, -0.03021531f, 0.01676302f, -0.02239066f, -0.01092282f, 
    -0.02084757f, -0.01001070f, -0.01660407f, -0.03925590f, -0.00508948f, 0.01884290f, -0.02669396f, -0.02519998f, 
    -0.00981276f, -0.02620017f, 0.01426169f, -0.01791193f, 0.00379278f, -0.01343208f, 0.00436997f, -0.02402160f, 
    0.01123659f, -0.03982586f, 0.00184686f, -0.04329947f, -0.04017718f, 0.00038809f, 0.02694402f, -0.00391080f, 
    -0.02453215f, 0.02775844f, -0.01486677f, -0.03035054f, -0.01320743f, 0.01637385f, -0.01605467f, 0.00210641f, 
    0.02602944f, 0.01520538f, 0.01227694f, -0.00988989f, -0.03870441f, 0.01063658f, -0.01423508f, 0.00582389f, 
    0.01078718f, -0.01767718f, 0.01279161f, 0.01802802f, -0.03614128f, -0.02958245f, -0.01701613f, 0.01393618f, 
    -0.02991569f, -0.02760612f, -0.03046457f, -0.02127553f, 0.01979172f, -0.02756494f, -0.01772153f, -0.03661630f, 
    -0.00452776f, 0.00292139f, -0.01969527f, -0.02223708f, -0.03743031f, -0.00099265f, -0.01202723f, 0.02051815f, 
    -0.04058552f, 0.01018390f, 0.00516746f, -0.01650092f, -0.04011571f, -0.02054315f, -0.00144266f, -0.01539876f, 
    -0.03561827f, 0.01457827f, -0.03959170f, 0.02068909f, -0.01062904f, 0.01902687f, 0.00265695f, -0.02611075f, 
    -0.02992431f, -0.01508689f, -0.01172670f, 0.02518282f, 0.02408244f, -0.03009072f, 0.01354483f, 0.00030572f, 
    0.00545093f, -0.03758609f, -0.00340728f, -0.00034092f, -0.00697626f, -0.02671051f, 0.01881524f, -0.03814876f, 
    0.00213457f, 0.02473734f, 0.03042432f, 0.00088786f, 0.00256742f, 0.02008814f, 0.00672663f, -0.04253175f, 
    0.02362306f, -0.00151910f, -0.01373609f, -0.00614650f, 0.02196854f, -0.00755157f, 0.00825060f, -0.02079672f, 
    0.02825529f, -0.03102490f, 0.01880119f, -0.03166988f, -0.00675851f, -0.01241114f, -0.01324835f, -0.00899669f, 
    0.02023194f, -0.00799307f, 0.01881724f, 0.00218944f, -0.03295407f, -0.04240350f, 0.01758691f, -0.01397399f, 
    0.00057023f, -0.03244083f, -0.03542249f, 0.01571718f, -0.00889233f, 0.00910098f, -0.01303156f, -0.03294691f, 
    -0.02007278f, -0.02935804f, -0.02761242f, 0.01846251f, -0.01204107f, -0.00904058f, 0.00342238f, -0.01562751f, 
    0.01011276f, 0.01378871f, -0.02885038f, -0.00504984f, -0.00047139f, -0.00121946f, -0.00747004f, -0.02246638f, 
    -0.00490819f, 0.01503376f, 0.00507288f, 0.01250948f, 0.02395502f, 0.01010739f, 0.00583007f, -0.00581307f, 
    -0.01990607f, -0.00844797f, 0.01486050f, 0.01931188f, 0.02169408f, 0.02771320f, 0.00662956f, -0.00808332f, 
    -0.03986326f, 0.01875592f, 0.01412932f, 0.00003209f, -0.02068798f, -0.01563344f, 0.00578400f, 0.00837148f, 
    0.00700466f, 0.02598725f, -0.00092775f, -0.02976477f, 0.00264147f, 0.02074930f, -0.03138378f, -0.02348115f, 
    0.01941270f, 0.00056905f, -0.03477447f, -0.02355305f, -0.03021052f, 0.00561540f, -0.00011544f, -0.01568227f, 
    0.01224240f, -0.03557609f, -0.02825283f, -0.00081186f, -0.01817387f, 0.02703228f, -0.00439642f, 0.02174148f, 
    0.01184505f, 0.01033612f, -0.02772401f, -0.00522900f, 0.02337805f, 0.00000520f, -0.02376773f, -0.00730755f, 
    -0.01757020f, 0.01604521f, -0.00208654f, -0.00423754f, 0.02460193f, -0.02692755f, -0.02793449f, 0.00517853f, 
    0.01341012f, -0.00541974f, 0.00682556f, 0.01454888f, 0.02893997f, -0.01314836f, -0.01913158f, 0.00604497f, 
    -0.03831889f, -0.00352954f, 0.00413529f, -0.03319164f, -0.03697558f, -0.00399857f, -0.03821749f, -0.02422312f, 
    -0.03705921f, -0.01354300f, -0.00591076f, 0.02532086f, 0.01372511f, 0.02333117f, -0.00601550f, 0.01155221f, 
    0.00976982f, 0.02151184f, 0.00350691f, 0.01760349f, 0.02116533f, 0.02454004f, -0.00025975f, -0.03949470f, 
    0.01387121f, 0.02062561f, 0.00844382f, -0.03999453f, 0.01008947f, -0.00283384f, -0.01040422f, 0.01822518f, 
    -0.01110431f, -0.04586365f, -0.03356626f, -0.01462246f, -0.03696074f, -0.02605972f, 0.01044365f, 0.01422188f, 
    -0.03382065f, 0.02616938f, -0.01202133f, 0.01268522f, 0.02743932f, -0.02707199f, 0.02374004f, 0.00666318f, 
    -0.03453180f, -0.02130745f, 0.01710231f, 0.02524022f, 0.00259176f, 0.01083089f, -0.04277024f, -0.01192572f, 
    -0.01665851f, -0.01289117f, 0.01993075f, -0.01052302f, 0.01453780f, -0.03815518f, 0.02490787f, 0.00338795f, 
    0.01097515f, 0.02192037f, -0.02990638f, -0.02858905f, -0.01522796f, 0.02826759f, 0.01681217f, -0.01842224f, 
    -0.03992129f, -0.01506627f, -0.02833692f, -0.01464918f, 0.02151153f, -0.03398291f, -0.00556029f, -0.01165494f, 
    -0.02030116f, -0.02286799f, -0.03525745f, 0.02904350f, 0.00961579f, -0.04065618f, -0.00770024f, -0.02194957f, 
    -0.01597453f, -0.00874189f, -0.03456692f, -0.02069608f, -0.00078253f, -0.03272370f, 0.02002782f, -0.00622463f, 
    0.00150547f, 0.01172337f, -0.01818787f, 0.02356970f, -0.02955244f, 0.02439209f, 0.00705269f, 0.00157051f, 
    -0.00481835f, 0.03068428f, 0.02703945f, 0.01972504f, -0.04078022f, -0.00503503f, 0.02441020f, 0.01761808f, 
    0.01948820f, 0.01977585f, -0.01758517f, -0.02332482f, 0.00491464f, -0.00097630f, -0.03804762f, -0.00583727f, 
    0.01949621f, 0.00552060f, -0.01048548f, 0.00303035f, -0.03119957f, -0.03303492f, -0.02307746f, -0.03384056f, 
    0.01811888f, 0.00089383f, -0.00655805f, -0.02096676f, 0.01534483f, 0.01291286f, -0.00464797f, 0.01813392f, 
    -0.02199317f, -0.02676030f, 0.02698061f, -0.01208112f, -0.01922631f, 0.00530734f, -0.01631631f, -0.03052115f, 
    -0.02375788f, -0.01223197f, -0.00908893f, 0.00492493f, -0.01799658f, -0.00097028f, -0.02400160f, 0.00397730f, 
    -0.02405914f, 0.01902067f, -0.03773402f, 0.00297145f, 0.01712442f, 0.02209403f, 0.00961699f, -0.04378299f, 
    -0.03342233f, -0.02886604f, 0.02040782f, 0.02064989f, -0.01828577f, -0.02190985f, 0.00376660f, 0.01502646f, 
    -0.02506466f, -0.01738974f, -0.00689880f, 0.02344296f, 0.00224217f, 0.01053363f, -0.03638958f, -0.04086636f, 
    -0.02133563f, 0.00101695f, -0.03106775f, 0.01497549f, -0.03037835f, 0.02013413f, 0.01329698f, -0.04003578f, 
    -0.02150924f, -0.00218744f, -0.04103564f, -0.00866363f, 0.00477728f, 0.02307554f, -0.03709285f, -0.04166207f, 
    0.02714737f, 0.02232833f, 0.02735237f, 0.01816845f, -0.03960554f, -0.02874002f, -0.02152933f, -0.03797697f, 
    -0.00620190f, -0.00073808f, -0.03342380f, -0.01607722f, -0.02966566f, 0.00643769f, -0.00519654f, 0.02422628f, 
    0.02025336f, -0.00376443f, 0.02849596f, 0.02467060f, 0.01185472f, -0.03852138f, -0.02022043f, -0.03967468f, 
    -0.00006849f, -0.01099310f, -0.02307830f, -0.01410172f, -0.04097276f, -0.02384643f, -0.03528478f, -0.01514280f, 
    -0.03181591f, -0.01323851f, -0.03875266f, 0.00861470f, -0.02198775f, 0.02617969f, -0.02031612f, 0.02300103f, 
    0.01412240f, -0.03797979f, 0.00499132f, -0.03858202f, 0.02807407f, 0.02021796f, 0.00784649f, 0.00098724f, 
    -0.01352842f, 0.00915063f, 0.01397422f, -0.00231960f, -0.01359640f, -0.02059536f, 0.01117122f, -0.02718310f, 
    0.02465553f, 0.01845834f, -0.02320939f, -0.01305706f, -0.02781768f, -0.02658115f, -0.03906169f, -0.01140180f, 
    0.01587424f, -0.02210787f, -0.02434796f, 0.01970115f, -0.00659961f, -0.01664849f, 0.00426000f, -0.00885304f, 
    0.00764800f, 0.01372453f, 0.02532510f, -0.02631642f, 0.00192945f, -0.00664268f, 0.00928693f, -0.02182434f, 
    -0.00135311f, -0.02483544f, 0.01492187f, 0.02984109f, 0.02593498f, -0.02898286f, 0.00204665f, 0.01816864f, 
    -0.01538247f, -0.04130596f, -0.00453756f, 0.02169307f, 0.02113745f, -0.02829396f, 0.01529375f, 0.01473681f, 
    0.01500540f, -0.00588108f, 0.01496920f, 0.00665249f, -0.00500774f, -0.00895083f, 0.01896353f, 0.01730120f, 
    0.00432267f, -0.00469613f, -0.01509919f, -0.01592989f, 0.02906919f, -0.01245003f, 0.02617712f, 0.02724274f, 
    -0.00574911f, 0.02751464f, -0.02409681f, 0.00832630f, -0.00418635f, -0.01091679f, -0.01391425f, 0.02563398f, 
    -0.02545005f, 0.01032944f, 0.02734849f, -0.01733666f, -0.02656749f, 0.00500941f, 0.00658970f, -0.02906983f, 
    -0.02254110f, 0.01210340f, 0.00360388f, -0.01812374f, -0.00026733f, -0.01170879f, -0.00049635f, -0.01855094f, 
    -0.02295150f, 0.01746668f, -0.01800526f, 0.01774910f, -0.03148748f, 0.00151408f, -0.03836015f, -0.03955143f, 
    -0.02708936f, 0.02803012f, -0.03324606f, 0.00617809f, 0.00077560f, -0.03446956f, -0.03418351f, -0.00761239f, 
    -0.02899317f, 0.00705371f, 0.02488095f, -0.01880706f, -0.01124781f, -0.01416367f, -0.02871632f, 0.01366302f, 
    0.00554950f, 0.01846787f, -0.03620646f, 0.02417009f, 0.00430010f, 0.00399804f, 0.02584692f, 0.01937392f, 
    -0.00728462f, -0.01133069f, -0.00418939f, -0.01767814f, -0.02787376f, 0.00285250f, 0.02929240f, 0.00524378f, 
    -0.04945061f, 0.17952853f, 0.05687702f, -0.12527643f, 0.00106415f, 0.01449938f, 0.10136030f, -0.02128285f, 
    0.04642675f, 0.06891403f, 0.11637302f, 0.08009774f, -0.17865638f, -0.06874038f, 0.19998720f, -0.21725075f, 
    -0.00062518f, 0.00195778f, 0.05986162f, 0.05658017f, 0.07414900f, 0.07628952f, -0.04649261f, 0.06073005f, 
    0.21738927f, 0.05293119f, 0.02844433f, 0.44632268f, 0.10764842f, -0.00041926f, 0.01626346f, 0.13338217f, 
    0.02096292f, 0.00906782f, 0.06747771f, 0.03340847f, 0.07813966f, -0.03846108f, 0.28064668f, -0.00974667f, 
    0.03666830f, -0.00938237f, 0.08166967f, 0.04148575f, 0.14651327f, 0.00287487f, 0.04683379f, -0.04186026f, 
    0.33156157f, -0.00820917f, 0.01833491f, 0.30276525f, -0.00912602f, 0.02219722f, 0.02833508f, -0.03303029f, 
    0.02954530f, -0.00001801f, 0.00571933f, 0.02331262f, -0.12111656f, -0.02852522f, 0.08245529f, -0.18670303f, 
    0.14292897f, -0.03336133f, 0.08091571f, 0.07052490f, 0.17988464f, 0.13171890f, -0.01638236f, -0.12321044f, 
    -0.16456127f, -0.14231661f, 0.06504438f, 0.05322948f, 0.00997882f, -0.03564554f, 0.01952759f, 0.08774526f, 
    0.03981949f, 0.04386839f, 0.04136288f, 0.13518862f, 0.22829287f, 0.05556887f, 0.06057114f, -0.11985925f, 
    0.13203761f, -0.03662650f, 0.01528032f, 0.03682479f, 0.08263818f, 0.08347466f, 0.03379304f, 0.01754325f, 
    -0.15867646f, 0.05769202f, 0.00538934f, -0.19894044f, 0.03707871f, 0.06746575f, 0.08379032f, 0.00440477f, 
    0.09497570f, 0.01029418f, 0.11326613f, -0.02658171f, -0.15371880f, -0.02722783f, -0.04532649f, 0.15775488f, 
    0.10128643f, 0.05633223f, -0.00008091f, 0.05919480f, 0.03888738f, 0.05857483f, 0.03783647f, 0.03671538f, 
    -0.05864891f, 0.14218456f, 0.01014468f, -0.37892509f, -0.09803726f, 0.12008943f, 0.09276019f, 0.04121549f, 
    0.10545023f, -0.03202156f, 0.11973705f, 0.00641620f, 0.09207123f, 0.08103929f, -0.01452211f, -0.12218886f, 
    0.18167199f, -0.00729030f, 0.13918750f, 0.07483717f, -0.02909251f, 0.07878189f, 0.13891377f, 0.03719428f, 
    -0.12375162f, -0.03983675f, -0.02183490f, 0.29688799f, 0.13735180f, 0.01490698f, 0.05960801f, 0.04771508f, 
    0.04863020f, 0.01797519f, 0.09913047f, 0.13470408f, -0.00709758f, -0.08079332f, 0.02472374f, 0.08232412f, 
    0.06892237f, 0.02986610f, 0.01384811f, 0.13042521f, 0.03564123f, 0.01876944f, 0.02446350f, -0.01104368f, 
    -0.14534430f, 0.18313459f, -0.09942056f, 0.14294037f, -0.02942238f, 0.02891911f, -0.06426237f, -0.04557838f, 
    0.02403612f, 0.05757391f, -0.02828908f, 0.08393981f, 0.17873503f, 0.14393175f, 0.01678866f, 0.20457634f, 
    0.08987224f, 0.06582879f, 0.06481884f, 0.02451100f, 0.03020662f, 0.12197050f, 0.04309634f, -0.00255661f, 
    0.19519900f, 0.09897750f, 0.04322792f, 0.30605248f, 0.02680757f, 0.09161892f, -0.07391515f, 0.11352962f, 
    0.00030725f, 0.12064020f, 0.01149203f, 0.06132734f, 0.12239800f, 0.09061822f, 0.21310838f, 0.02622272f, 
    0.10532483f, 0.02738781f, 0.12896013f, 0.06818643f, -0.00675478f, 0.06252627f, 0.03983991f, 0.09647947f, 
    0.26408803f, 0.13308237f, 0.13253346f, 0.26750648f, 0.01237302f, 0.06000331f, -0.00921433f, 0.04234815f, 
    0.05073359f, 0.13618749f, -0.00067162f, -0.00676535f, 0.04600400f, 0.04879562f, -0.17160231f, -0.06652264f, 
    0.06250543f, 0.02294775f, 0.05084026f, 0.04462284f, -0.01002617f, 0.03941631f, 0.00988709f, 0.03268433f, 
    0.32370654f, 0.06229124f, -0.06573085f, 0.25621328f, -0.04145347f, 0.00983212f, -0.02352941f, 0.08816785f, 
    0.08111185f, 0.02483183f, 0.07621444f, 0.04488476f, 0.14999071f, 0.04978165f, 0.18476309f, 0.06369243f, 
    0.06711823f, 0.05564414f, 0.04580821f, 0.18604258f, 0.01022412f, 0.01641378f, 0.10366045f, -0.02339288f, 
    -0.19872296f, -0.09511301f, -0.08163595f, -0.19518830f, -0.05989919f, 0.05656157f, 0.05143907f, 0.03757253f, 
    0.09112391f, 0.06142723f, -0.04675367f, 0.00414843f, 0.01028833f, 0.15401752f, 0.14328721f, -0.26662311f, 
    0.00637381f, 0.06975102f, 0.11503357f, 0.02281748f, -0.03514450f, 0.07079190f, 0.06402406f, -0.01434401f, 
    -0.00015305f, -0.06154408f, -0.12058116f, -0.04168378f, -0.01832337f, -0.04887245f, 0.07110792f, 0.02286062f, 
    0.07484020f, 0.07022683f, 0.15594359f, 0.03128940f, 0.26648128f, 0.13960728f, 0.10837810f, -0.07685459f, 
    -0.07075110f, 0.00882963f, 0.12140881f, 0.00567976f, -0.06182663f, 0.06359079f, 0.11850932f, 0.07233798f, 
    0.06549125f, -0.04036263f, -0.31324884f, 0.08089665f, 0.10026123f, 0.13272269f, -0.03764015f, -0.01616894f, 
    0.10423286f, 0.03675394f, -0.00720755f, 0.00776954f, -0.05108433f, -0.08378843f, -0.04158582f, 0.13341236f, 
    -0.00108715f, -0.02475320f, 0.02790918f, -0.01734394f, 0.06919202f, -0.02194930f, 0.08185319f, 0.01073741f, 
    0.20807849f, 0.09840319f, 0.10159597f, 0.05217412f, -0.01792429f, 0.08866554f, 0.03366939f, 0.23883088f, 
    0.03819036f, 0.05145772f, -0.03399011f, -0.03771935f, 0.26333210f, -0.05548625f, 0.07568992f, 0.42108777f, 
    -0.00110554f, 0.02379122f, 0.09267484f, -0.02200061f, -0.02183555f, 0.10944214f, 0.07134340f, 0.02510646f, 
    0.29497886f, -0.08606344f, -0.01739236f, 0.06482380f, 0.01277928f, 0.04209642f, 0.07409277f, 0.09346507f, 
    0.05891064f, -0.03352399f, -0.03288883f, 0.08284376f, 0.33366972f, -0.02434461f, 0.05175912f, 0.23152453f, 
    0.11822733f, -0.05522573f, 0.06784320f, 0.10142002f, 0.05070387f, 0.00299277f, 0.14082783f, 0.00220030f, 
    0.11133198f, 0.06271855f, 0.23712878f, 0.05429796f, 0.06626655f, 0.09790487f, 0.12607440f, 0.07139230f, 
    0.01681058f, 0.08614399f, 0.07087781f, 0.09981150f, -0.24066614f, -0.16179144f, 0.03167528f, -0.12325663f, 
    0.08048469f, -0.00335558f, 0.07272917f, 0.14025220f, -0.06093075f, 0.09738651f, 0.14778657f, 0.02360534f, 
    0.16659796f, 0.05442173f, 0.01735035f, 0.03019042f, -0.01664679f, 0.01639464f, -0.01259504f, 0.11490109f, 
    0.01048325f, 0.06647819f, 0.05866923f, 0.03829316f, 0.03177691f, 0.12186410f, 0.11308553f, 0.08867981f, 
    0.02706872f, 0.00759603f, 0.04455560f, 0.07647812f, 0.03799685f, 0.07523310f, 0.06514334f, 0.02653696f, 
    0.30277333f, -0.00507559f, 0.15711591f, -0.04305258f, -0.00185631f, -0.03958980f, 0.03298511f, 0.14933261f, 
    0.14082961f, 0.02444968f, 0.08848413f, 0.05093398f, 0.31980693f, 0.01680458f, -0.03224061f, -0.06126412f, 
    0.07609352f, 0.14170742f, 0.01996131f, 0.06100488f, 0.12944093f, 0.10415789f, 0.10888718f, 0.03135011f, 
    0.26788718f, -0.07245079f, 0.28498030f, -0.10032154f, 0.16599950f, -0.08710779f, 0.05826850f, 0.12175176f, 
    0.07474425f, 0.13463672f, 0.01710879f, 0.09654343f, -0.21165282f, -0.09393572f, 0.03793486f, 0.20533326f, 
    0.05582814f, 0.07636283f, -0.02555345f, 0.04124155f, 0.09261278f, -0.03236434f, 0.03987473f, -0.00061270f, 
    -0.16910659f, -0.14544559f, -0.03995224f, -0.00063019f, -0.02783415f, 0.09363413f, -0.01742787f, -0.00432334f, 
    0.05751540f, 0.09153672f, 0.04531019f, 0.01068232f, 0.29760441f, 0.00583932f, -0.06677353f, 0.04343378f, 
    0.10683871f, -0.00324340f, 0.06042223f, 0.00825361f, 0.11521126f, 0.05052137f, -0.00707694f, 0.08281230f, 
    0.30107236f, 0.00032039f, -0.04172327f, 0.15396349f, -0.06411158f, -0.08057038f, -0.01913984f, -0.00640201f, 
    0.05750195f, 0.05149306f, 0.01170437f, 0.07346039f, 0.21845309f, 0.17832756f, -0.08077281f, 0.11328654f, 
    0.06795446f, 0.00710379f, -0.07530677f, 0.11210108f, -0.01400261f, 0.00987732f, 0.04455766f, 0.08775637f, 
    0.06740575f, 0.01492483f, 0.19189268f, -0.00520501f, 0.07263055f, 0.05886519f, 0.13445663f, 0.00453564f, 
    -0.01728126f, 0.02349314f, 0.06544207f, 0.11006347f, 0.43305624f, 0.05040534f, 0.21261859f, -0.34099069f, 
    -0.00927540f, 0.00989690f, 0.06003740f, 0.00463348f, -0.11577769f, 0.04807272f, 0.10033029f, 0.07234914f, 
    0.35012528f, 0.00909125f, 0.23717219f, 0.32698917f, 0.10255766f, 0.04533980f, 0.04134890f, 0.07384919f, 
    -0.05019563f, 0.02930440f, 0.04481068f, -0.03843328f, 0.19545670f, 0.12129910f, 0.08924843f, 0.03782921f, 
    0.03160686f, 0.04571824f, 0.05418500f, 0.06171763f, -0.05479516f, 0.00012019f, 0.06206069f, 0.07895581f, 
    0.16503584f, -0.04332512f, -0.00741933f, 0.07272028f, 0.06162320f, -0.01802493f, 0.06899281f, 0.10774112f, 
    -0.05226497f, -0.01938201f, -0.01794568f, 0.07481772f, -0.22174358f, 0.34428012f, -0.26025245f, -0.26443487f, 
    0.04181469f, 0.13670652f, -0.00657349f, 0.05456739f, -0.11132700f, 0.02979085f, 0.05100672f, 0.09256259f, 
    0.33522150f, -0.00352901f, 0.08637028f, -0.13114049f, 0.03644989f, -0.00215406f, 0.01942787f, 0.16522744f, 
    0.04392381f, 0.06351094f, 0.08570456f, 0.03505579f, 0.09718523f, 0.07052319f, 0.08064498f, 0.11206560f, 
    0.09994855f, 0.04970736f, 0.04033610f, 0.14036770f, -0.02039164f, 0.02692061f, 0.01470035f, 0.05556906f, 
    -0.02478453f, -0.04035609f, -0.04222655f, -0.33825803f, 0.07249378f, 0.06214094f, 0.10095946f, 0.05083187f, 
    0.03572222f, 0.10241372f, 0.02657567f, -0.06507417f, -0.03606112f, 0.08777925f, 0.06742832f, -0.16917767f, 
    0.06040798f, 0.07267909f, 0.06377321f, 0.04937423f, 0.07098759f, 0.08511603f, 0.01363226f, -0.04327643f, 
    0.03007254f, 0.20464674f, 0.13308066f, -0.19905302f, 0.03053303f, 0.07981787f, 0.04359811f, -0.00568725f, 
    0.03438025f, -0.00723997f, -0.02412763f, 0.09659803f, 0.09497647f, -0.13349235f, 0.16418135f, -0.20054138f, 
    0.05712976f, -0.01520940f, 0.06072430f, 0.07614264f, 0.08382008f, 0.08473524f, 0.00649096f, -0.00523498f, 
    -0.01411984f, -0.10136293f, -0.04503749f, -0.04332312f, 0.08408188f, -0.05386594f, -0.06920269f, 0.11382878f, 
    0.03073583f, 0.02526370f, 0.02838221f, 0.05580107f, -0.00245664f, 0.17492419f, -0.07787867f, -0.16426656f, 
    -0.08302368f, -0.12525956f, -0.03539425f, 0.16594659f, 0.08812918f, 0.00425647f, 0.09827972f, 0.05785884f, 
    -0.02090328f, 0.09512667f, 0.05506155f, -0.11293172f, 0.04694706f, -0.02736074f, 0.14017244f, -0.01017712f, 
    0.00252353f, 0.11796313f, 0.02115841f, -0.06079842f, 0.01024056f, 0.12434607f, 0.06470562f, 0.03007024f, 
    0.03036587f, -0.04285052f, -0.04790169f, 0.08746706f, -0.10536937f, 0.07200956f, 0.13473180f, 0.03244656f, 
    0.02634656f, -0.07731526f, 0.06536428f, 0.13724692f, 0.01541962f, 0.05623966f, 0.08010800f, 0.04233243f, 
    0.02794267f, -0.02207307f, 0.05708173f, 0.00657346f, 0.22756270f, 0.12074425f, -0.01585856f, 0.20293579f, 
    0.18776384f, 0.07363386f, 0.02300618f, 0.01730863f, -0.15544368f, 0.13500382f, 0.18152235f, 0.07183745f, 
    0.29240718f, -0.06151064f, -0.03080701f, 0.21980873f, -0.05217475f, -0.07382414f, 0.03451841f, -0.02286100f, 
    0.02974967f, 0.03392509f, -0.01389539f, 0.02808213f, 0.08493420f, -0.02109743f, -0.01376996f, -0.15988682f, 
    -0.01794956f, 0.09394988f, 0.00986114f, 0.06037444f, 0.18546101f, -0.00065199f, 0.01378525f, 0.01528846f, 
    -0.01352344f, -0.02863980f, -0.00160388f, 0.02886591f, 0.01108764f, -0.02629538f, -0.00403302f, -0.01923557f, 
    -0.00584513f, -0.00629841f, 0.00324506f, 0.02071065f, 0.01540017f, 0.00181479f, 0.02965477f, -0.03091703f, 
    -0.00645457f, -0.01619307f, -0.02020581f, -0.02317660f, 0.00649265f, 0.02923888f, -0.02360130f, -0.02518643f, 
    -0.00390289f, 0.00981147f, -0.00625625f, -0.04002472f, -0.03047975f, 0.00240732f, 0.00408459f, 0.01674761f, 
    0.02354393f, -0.04084545f, -0.03318047f, -0.03010255f, -0.02538057f, -0.02122777f, -0.02727662f, -0.02080022f, 
    -0.03666091f, -0.00974014f, -0.00503597f, 0.00466334f, -0.01760147f, -0.03454329f, 0.01318558f, 0.00523554f, 
    -0.03309801f, -0.03237739f, 0.00735345f, 0.01761896f, -0.02868383f, -0.00885835f, 0.00853451f, -0.01305685f, 
    -0.03754966f, -0.00474193f, 0.02260761f, 0.00467800f, 0.01743054f, -0.00071970f, -0.02282857f, -0.01708599f, 
    0.01784074f, -0.00173428f, -0.00906749f, -0.01658213f, 0.01995453f, -0.01011710f, -0.00288821f, -0.02559215f, 
    0.02746337f, -0.00251986f, 0.00441022f, -0.00244893f, 0.01256415f, -0.03226521f, 0.00632310f, -0.02541694f, 
    -0.02493301f, -0.02195811f, -0.02419843f, 0.02503566f, 0.00848884f, 0.03444145f, 0.00069173f, -0.04177171f, 
    0.01829440f, -0.03915136f, 0.02551435f, -0.03601595f, 0.01413454f, 0.00731502f, -0.03582364f, -0.03731705f, 
    -0.03243317f, -0.01687361f, -0.01371722f, -0.03849672f, -0.01587045f, -0.03127637f, -0.03963609f, -0.00957343f, 
    0.01753763f, -0.03616493f, 0.02610137f, -0.02934032f, 0.01926955f, 0.00773787f, -0.00196006f, 0.02923257f, 
    0.02966841f, -0.01499197f, -0.01141530f, -0.03581234f, -0.02453951f, -0.01295029f, 0.00795148f, -0.04132695f, 
    -0.00646331f, 0.02946017f, -0.03085257f, -0.01280227f, -0.00269549f, -0.01202749f, 0.02904204f, -0.02052410f, 
    0.01913755f, -0.00945034f, 0.01009847f, 0.01103574f, -0.03399470f, 0.02801414f, -0.00286971f, 0.02487404f, 
    0.02827451f, -0.02195791f, 0.00012329f, -0.03885041f, -0.00416978f, -0.00666633f, -0.02839084f, -0.02096953f, 
    -0.01363481f, 0.01196476f, -0.03972831f, 0.03678267f, 0.01698639f, -0.02201813f, 0.01744806f, 0.02666052f, 
    0.01953097f, -0.02858618f, 0.01237478f, 0.01665917f, 0.02124416f, -0.00008635f, -0.01249137f, -0.01947986f, 
    0.00683894f, 0.00230632f, -0.01822005f, 0.01314561f, 0.02705224f, -0.00873282f, -0.03556306f, 0.02174765f, 
    -0.03714500f, 0.00045071f, -0.03684852f, -0.02659170f, -0.02097328f, 0.02225463f, -0.00213716f, 0.00285709f, 
    0.02346910f, 0.02169207f, -0.04038134f, -0.03058004f, -0.03361040f, -0.01105328f, -0.02508904f, 0.00272350f, 
    -0.03192626f, 0.02004544f, -0.03120849f, -0.03800832f, 0.01254426f, -0.01210106f, -0.03238618f, 0.02162290f, 
    -0.03349270f, -0.01848501f, -0.00784361f, 0.01655504f, -0.01720894f, -0.03271202f, -0.02862453f, 0.02279290f, 
    -0.00473623f, 0.01049598f, -0.01860783f, -0.01018394f, -0.01471539f, -0.01584392f, 0.01448807f, 0.00835915f, 
    -0.03114504f, 0.00857107f, -0.02243100f, -0.00835364f, 0.01217569f, -0.01930838f, 0.00745150f, 0.00953010f, 
    -0.02891813f, -0.01993325f, 0.00078898f, -0.02101476f, 0.00756245f, -0.03528055f, -0.03675726f, 0.00330290f, 
    -0.00832172f, -0.02385649f, 0.01048799f, 0.02778510f, -0.03568577f, -0.00013864f, 0.02276687f, 0.01056903f, 
    0.01110651f, 0.02149528f, -0.00859846f, -0.02781450f, -0.00310607f, 0.01206712f, 0.02164757f, -0.03141119f, 
    0.00703407f, -0.02556536f, -0.01202759f, -0.01404506f, 0.02725009f, -0.01395232f, 0.01123016f, 0.01039260f, 
    0.00048484f, 0.01917666f, 0.01718650f, -0.02643648f, -0.03248519f, -0.01477685f, -0.00454358f, -0.00443680f, 
    0.01040099f, -0.02036332f, -0.01444005f, -0.01363069f, 0.01692439f, 0.01529180f, -0.03658685f, 0.02265918f, 
    0.00650789f, 0.00279696f, -0.02194468f, -0.02867300f, -0.01363585f, -0.01110752f, -0.01195765f, -0.00663364f, 
    -0.03962156f, -0.00584030f, -0.01345415f, 0.00736019f, -0.02319664f, -0.04067226f, -0.02070273f, -0.03059981f, 
    -0.02828400f, -0.02321111f, 0.01439825f, -0.00736991f, 0.00436538f, 0.02887465f, 0.01968707f, -0.02746951f, 
    -0.01922752f, -0.02312597f, -0.03732206f, -0.02105131f, 0.00001013f, 0.00253883f, 0.00516719f, -0.03109270f, 
    -0.02931139f, 0.01956584f, 0.00786836f, -0.03477465f, 0.00687132f, 0.01338217f, -0.02413449f, 0.01253522f, 
    0.01279566f, -0.03337606f, 0.01867521f, 0.01250191f, -0.03328806f, -0.01250328f, -0.01986450f, -0.02361118f, 
    -0.03811947f, -0.01325130f, -0.04040513f, 0.01366517f, 0.00593029f, 0.01508999f, 0.02834698f, -0.03252706f, 
    0.02015147f, -0.00915682f, -0.02710966f, -0.00463478f, -0.01298195f, -0.01724732f, -0.01408386f, 0.01851238f, 
    -0.00445630f, -0.03064845f, -0.03303554f, 0.00296182f, -0.03474717f, 0.02745933f, 0.00125171f, -0.03009564f, 
    -0.01145619f, -0.00145268f, -0.02141090f, 0.02198194f, 0.02733009f, 0.00092346f, 0.01673536f, -0.03953138f, 
    0.01643498f, 0.00077938f, -0.02968924f, -0.02430711f, 0.02828799f, -0.02600376f, -0.00330235f, 0.01064044f, 
    -0.00001500f, -0.01951614f, -0.02192676f, 0.01492691f, 0.00570964f, -0.00238083f, -0.03596546f, 0.00445899f, 
    -0.01673283f, -0.02149502f, -0.00546478f, -0.00801811f, -0.03072286f, -0.02405029f, -0.01022543f, -0.00712863f, 
    -0.00612844f, 0.02260934f, -0.00000317f, 0.02684255f, -0.02176348f, 0.02423503f, -0.03000684f, 0.03936004f, 
    0.01508595f, 0.01121877f, 0.01192383f, 0.01132461f, -0.01039270f, -0.01219586f, -0.03419209f, -0.02949939f, 
    0.00414077f, -0.03581692f, 0.00365143f, -0.00842581f, -0.02475059f, -0.03758698f, -0.02327218f, -0.01546034f, 
    -0.01025397f, -0.00902360f, 0.01530365f, 0.00888044f, 0.01118390f, 0.02709002f, -0.01595831f, 0.02155425f, 
    0.02686862f, -0.00774239f, -0.03177023f, 0.00623665f, -0.02143501f, -0.02084991f, 0.02895692f, -0.02569716f, 
    -0.00056635f, 0.01193700f, 0.01325391f, -0.02301044f, 0.01874548f, 0.01750605f, 0.02287624f, -0.00050321f, 
    -0.02111769f, -0.01477314f, -0.00050059f, -0.02715504f, 0.01768749f, 0.02388406f, -0.01729664f, -0.02206103f, 
    -0.00086331f, -0.00379272f, 0.00351101f, -0.02948847f, -0.03636199f, 0.02935836f, 0.01874620f, -0.02359034f, 
    0.00656942f, -0.01949083f, -0.00496771f, 0.00535509f, -0.00817372f, 0.00729833f, -0.02520969f, -0.03268659f, 
    -0.01396529f, 0.00007652f, 0.02126925f, 0.02683695f, -0.00591613f, -0.02363689f, -0.02524976f, -0.00176884f, 
    -0.01471402f, 0.02404908f, -0.00728269f, -0.02254997f, -0.00492015f, -0.02164845f, -0.02555108f, -0.03882507f, 
    -0.04069523f, 0.00159462f, 0.01744580f, -0.04179846f, -0.03142912f, 0.02766890f, -0.03853586f, 0.01896785f, 
    0.00645722f, 0.01000924f, 0.02534254f, -0.02680071f, 0.00415511f, 0.00682113f, 0.02605217f, 0.01928841f, 
    -0.04080760f, -0.03812821f, 0.01554432f, -0.01940370f, -0.00732597f, -0.02667449f, 0.02207703f, -0.00775977f, 
    -0.03847386f, 0.01867136f, -0.01038072f, -0.02229279f, -0.03591515f, -0.01586919f, 0.02164511f, -0.02619686f, 
    0.02449561f, 0.01646289f, -0.02828856f, -0.02382920f, 0.02100399f, 0.02498274f, -0.00202786f, -0.01332640f, 
    0.02749808f, -0.01700349f, 0.00860247f, 0.00671123f, -0.00132141f, -0.03067362f, -0.02998630f, 0.02324721f, 
    0.03607987f, 0.02673911f, -0.03208657f, -0.01698394f, -0.02007793f, 0.02227911f, 0.00843349f, -0.00647203f, 
    0.01473381f, 0.01838391f, -0.01781024f, -0.01254075f, -0.00093495f, -0.02610471f, 0.00942221f, -0.02409894f, 
    0.01227320f, 0.02183702f, -0.00848971f, 0.00624655f, 0.01791528f, -0.01967729f, -0.00512699f, -0.04095275f, 
    -0.00666821f, -0.03110730f, 0.02009952f, -0.04095325f, 0.02824753f, -0.01011734f, 0.00465615f, -0.04089243f, 
    0.02769293f, 0.00733070f, -0.01651440f, -0.03366019f, -0.01274649f, -0.01296412f, 0.02867132f, -0.01832944f, 
    -0.02020879f, 0.02302506f, -0.02522233f, 0.01731444f, 0.00292042f, 0.02215142f, -0.03728313f, 0.00762980f, 
    -0.02949375f, -0.03546762f, 0.01530662f, -0.02312211f, 0.02495691f, -0.02462472f, -0.02815019f, 0.02456884f, 
    -0.00358619f, 0.01230834f, 0.00659304f, -0.01541909f, 0.02828711f, -0.00018686f, -0.03647546f, 0.01890957f, 
    -0.01614704f, 0.02194929f, 0.02847778f, -0.03854621f, -0.02401388f, 0.01777604f, 0.00035910f, -0.01901361f, 
    -0.03006709f, -0.03909042f, -0.00606613f, -0.00133764f, -0.03794900f, 0.02740101f, 0.00866222f, -0.01618972f, 
    0.00125762f, -0.03400604f, -0.02534023f, 0.00029326f, -0.01649074f, 0.01755805f, -0.02799520f, -0.00095242f, 
    0.02301719f, -0.00214172f, -0.03436319f, -0.00917589f, -0.04142264f, -0.03376067f, 0.02539317f, 0.00840178f, 
    -0.01634171f, -0.01830719f, 0.01837416f, 0.00104761f, 0.00418132f, -0.02680189f, 0.01407566f, -0.00167077f, 
    0.01938348f, -0.02452427f, 0.01185213f, 0.00076977f, -0.02414784f, 0.01731798f, 0.00123154f, -0.01715562f, 
    -0.01366690f, 0.01628762f, 0.01813412f, -0.01814214f, -0.03616135f, -0.02807318f, -0.01548497f, 0.02124173f, 
    -0.00766316f, -0.03835479f, -0.04099400f, -0.02280028f, -0.01326360f, 0.00099288f, -0.01711519f, -0.01760904f, 
    -0.04078297f, -0.00720357f, 0.00952275f, 0.03076006f, 0.00533862f, -0.00983304f, -0.01476026f, -0.01834102f, 
    -0.02755139f, -0.01891493f, 0.01058075f, 0.02135962f, -0.00462553f, -0.00121043f, -0.03544897f, -0.02293551f, 
    0.00422321f, -0.01476645f, -0.03204291f, -0.04133623f, -0.01970738f, 0.01461100f, 0.00768766f, 0.04155441f, 
    -0.02161752f, -0.02346076f, -0.01708101f, 0.00406585f, 0.01153443f, -0.04167207f, -0.01306016f, 0.00365780f, 
    0.01930257f, 0.01696281f, 0.01548420f, 0.00758763f, -0.00289571f, -0.01143803f, -0.02061050f, -0.02377890f, 
    -0.00806650f, 0.00894563f, 0.00448788f, 0.02352376f, -0.02052370f, 0.01157552f, -0.02711338f, 0.02504122f, 
    -0.01999111f, 0.03528979f, -0.03331501f, -0.02523048f, -0.01370837f, -0.03927102f, -0.00682242f, -0.03494520f, 
    -0.02657588f, -0.03544127f, 0.01466446f, -0.03987619f, 0.00772038f, -0.02679931f, 0.01061261f, 0.01750262f, 
    -0.01278944f, 0.00986184f, 0.02897781f, -0.02806606f, -0.03653803f, -0.03705584f, -0.02483120f, 0.01222253f, 
    0.00658422f, 0.02339697f, -0.00077892f, 0.02370411f, 0.01634747f, 0.00525834f, 0.00821123f, 0.00669770f, 
    0.02300134f, 0.00379589f, -0.02877783f, 0.01709250f, -0.01316427f, 0.00396653f, 0.01394770f, 0.03005017f, 
    0.02413957f, -0.00369127f, 0.00304951f, 0.01619398f, -0.02845429f, 0.00071057f, -0.03692515f, 0.00133627f, 
    -0.03007407f, -0.00380038f, -0.02446754f, 0.02177784f, -0.01942298f, -0.00926586f, 0.02350255f, -0.02567736f, 
    0.02610009f, -0.01956035f, -0.01319314f, 0.01002724f, 0.00235486f, -0.03080124f, 0.01100338f, 0.02824980f, 
    0.00621221f, 0.01989725f, 0.00721539f, 0.02473097f, -0.01961556f, 0.01581357f, -0.03489204f, -0.03446772f, 
    0.00775133f, 0.00725399f, -0.00018361f, 0.02855693f, 0.02480651f, -0.01947039f, -0.02026751f, -0.03335674f, 
    -0.03648148f, -0.00044821f, -0.00500128f, -0.01401800f, -0.00825515f, -0.00343206f, -0.00849182f, -0.04207534f, 
    -0.04596643f, 0.00765747f, -0.03662329f, -0.01280203f, -0.01604149f, -0.02433024f, 0.02026395f, -0.00757817f, 
    -0.03411319f, -0.04749426f, -0.00213992f, 0.03408155f, 0.02481140f, 0.01853585f, -0.03872661f, 0.02050348f, 
    0.03273349f, -0.00393516f, -0.03612062f, 0.01088593f, 0.01911974f, 0.03813178f, 0.02497351f, -0.00895427f, 
    -0.00384728f, -0.00884093f, -0.00095511f, -0.02109401f, 0.02557438f, -0.02906203f, -0.00491816f, -0.01398985f, 
    0.00885126f, -0.00905861f, 0.03740603f, 0.02362244f, -0.00446171f, 0.01264811f, -0.01029229f, 0.00059822f, 
    -0.02847640f, -0.03435130f, 0.02276064f, 0.02350988f, 0.02944067f, 0.02004701f, -0.02762081f, 0.00143714f, 
    -0.00818503f, 0.00273790f, 0.00392115f, -0.01638245f, 0.00502564f, 0.00326054f, 0.00918807f, 0.01219714f, 
    -0.01713581f, -0.02064171f, 0.01043142f, -0.02213618f, 0.01278364f, -0.01290633f, 0.02324188f, -0.00936578f, 
    -0.01307824f, 0.03067290f, -0.00709153f, 0.00501479f, -0.00924268f, 0.03089423f, -0.03339463f, -0.01294452f, 
    -0.00231551f, -0.02961060f, 0.01746159f, -0.01587270f, -0.01561655f, 0.02222182f, -0.01038480f, -0.03314349f, 
    -0.03044051f, -0.01094232f, -0.01417705f, -0.02438712f, -0.03660075f, -0.02743853f, -0.01366119f, -0.02844342f, 
    0.02624160f, -0.01218224f, 0.02267235f, 0.00302938f, -0.01922183f, -0.01507383f, -0.00547627f, -0.03852211f, 
    -0.00201569f, 0.04084077f, -0.01709567f, 0.01765571f, -0.03366988f, 0.02915022f, -0.00221338f, -0.02296150f, 
    0.03278535f, 0.01299647f, -0.01755292f, -0.03028693f, 0.02438684f, -0.00377017f, -0.00959389f, -0.04170721f, 
    0.01075159f, 0.03532968f, -0.00957457f, -0.00243944f, -0.00198444f, -0.02300041f, 0.00433585f, -0.02744741f, 
    -0.03302768f, 0.00612246f, -0.03891839f, -0.03510309f, -0.00379605f, 0.00328133f, 0.00380931f, -0.02019078f, 
    -0.02591720f, 0.03515384f, 0.02332069f, -0.01526857f, 0.00219205f, 0.01129101f, 0.02319754f, -0.03884851f, 
    0.01195820f, -0.01728263f, 0.00499054f, 0.01993137f, 0.00478814f, -0.01615560f, 0.03570817f, 0.02475920f, 
    -0.03346473f, 0.01191721f, -0.01061262f, -0.01266677f, -0.02398125f, -0.02765042f, 0.00111666f, 0.02130492f, 
    0.01079721f, 0.00987409f, 0.01314761f, -0.03992457f, 0.00146177f, -0.03078606f, 0.02942175f, -0.03108459f, 
    -0.00737740f, -0.01581890f, 0.01505696f, -0.01147804f, 0.01876887f, -0.00652912f, -0.02995758f, 0.01633939f, 
    -0.03665365f, -0.02364901f, -0.03164517f, -0.01297663f, -0.03140967f, 0.01175020f, 0.01907196f, -0.03908544f, 
    -0.03789737f, -0.03886480f, -0.03117662f, 0.01785598f, -0.02397331f, 0.01225600f, 0.02186241f, 0.00477020f, 
    -0.02949201f, 0.01375055f, 0.00967291f, -0.03278387f, -0.02565025f, 0.00205802f, 0.02719482f, 0.03079222f, 
    -0.00543574f, 0.02926847f, 0.03705163f, -0.00409712f, -0.02927849f, 0.02265023f, 0.00943491f, 0.00856100f, 
    -0.00014017f, 0.00499029f, -0.03270108f, -0.02650780f, -0.02171748f, -0.01006814f, -0.02836877f, -0.00976122f, 
    -0.00408837f, 0.02513535f, 0.01880454f, 0.02235665f, 0.01568145f, 0.02701309f, -0.01090404f, 0.00383094f, 
    0.01472306f, 0.02272544f, -0.03286949f, 0.00356891f, -0.02091169f, -0.00185427f, 0.01653004f, -0.00718129f, 
    -0.00920960f, -0.01289931f, 0.03268951f, 0.02011087f, -0.02879458f, 0.01706714f, 0.00513182f, -0.02074599f, 
    0.02227085f, -0.01140948f, 0.02557079f, -0.01728268f, -0.01698196f, 0.03030499f, 0.00776553f, -0.01904679f, 
    -0.02045669f, -0.01043966f, -0.00892337f, 0.02226369f, -0.03392294f, -0.01807646f, -0.00186808f, -0.00133514f, 
    -0.02784245f, 0.01583481f, -0.03263775f, 0.00142580f, -0.02907802f, -0.01977394f, 0.01528432f, -0.02627955f, 
    -0.02372658f, 0.02076004f, 0.02461031f, -0.01495034f, -0.03157026f, 0.00407226f, 0.03031569f, -0.00235068f, 
    -0.02607680f, 0.02285705f, 0.01542930f, 0.01595876f, -0.01663928f, -0.00366151f, 0.02074727f, -0.03112874f, 
    0.00475053f, 0.02706300f, -0.03373569f, 0.00443870f, 0.00505397f, 0.04285954f, -0.03760758f, -0.03873403f, 
    -0.02743116f, 0.01570005f, 0.00103995f, -0.00556505f, -0.03344387f, -0.02234265f, -0.00012994f, 0.00675688f, 
    0.00285317f, 0.01264608f, -0.02719764f, -0.02178247f, -0.00466288f, -0.00855179f, 0.02855521f, 0.02919124f, 
    0.03367543f, 0.01155999f, 0.00563001f, -0.00115282f, 0.01953216f, 0.02239252f, 0.02547506f, -0.02064152f, 
    -0.02657769f, -0.01912660f, -0.01371879f, -0.00488535f, 0.00272554f, 0.01176169f, -0.02505096f, 0.00880024f, 
    0.00869057f, 0.00846975f, -0.02009705f, 0.03562607f, 0.02850345f, -0.02843116f, 0.00667735f, -0.04018642f, 
    0.03640945f, 0.00660824f, 0.01672164f, 0.00617535f, -0.02625997f, 0.01103964f, 0.01516741f, 0.02741197f, 
    0.03703785f, 0.02508773f, 0.02132952f, -0.01057649f, -0.03455959f, 0.03408964f, 0.02669807f, -0.03126063f, 
    -0.03250213f, 0.01213488f, -0.02722487f, 0.00770141f, -0.03487066f, 0.02743199f, -0.03026099f, -0.02263113f, 
    0.02759772f, 0.01099140f, -0.02195050f, -0.00902920f, 0.01960445f, 0.02391472f, -0.00752836f, 0.01451131f, 
    0.01739588f, -0.01502438f, 0.04393524f, -0.02639127f, 0.02419539f, -0.00335745f, -0.00853760f, 0.02545958f, 
    0.01275077f, -0.00734443f, 0.01690868f, -0.01743795f, 0.03515759f, -0.00204521f, 0.02220625f, -0.03511170f, 
    -0.02493425f, 0.01102044f, -0.01410979f, -0.01444443f, -0.00264111f, -0.01759267f, -0.01713637f, 0.02672198f, 
    0.00929256f, -0.03267503f, 0.00146673f, -0.01435075f, 0.01811196f, -0.00098523f, 0.01118887f, -0.00634974f, 
    -0.02425899f, 0.02184674f, 0.01861067f, 0.02237391f, -0.03288030f, -0.01288822f, 0.01039540f, 0.00443130f, 
    -0.00320756f, -0.00443556f, -0.01415260f, 0.01685729f, -0.01150476f, -0.02985727f, -0.03050001f, 0.01545023f, 
    -0.00398858f, 0.02800845f, 0.03709708f, -0.00875317f, 0.03456590f, 0.01256370f, -0.03218721f, 0.00060998f, 
    -0.01926305f, -0.01648675f, -0.00050743f, -0.01600506f, 0.01690232f, -0.00739821f, -0.01633619f, 0.00299519f, 
    -0.01335444f, -0.02062732f, 0.03073575f, -0.02709261f, 0.01304447f, 0.01831907f, 0.01036632f, -0.02957203f, 
    0.01364864f, -0.02090294f, 0.02907731f, -0.02088534f, -0.03249678f, -0.01884243f, 0.03253274f, -0.03634978f, 
    0.02404119f, 0.01343868f, 0.03534121f, 0.01467441f, 0.01771828f, 0.01037341f, -0.03193352f, -0.01260618f, 
    -0.03541504f, 0.02473549f, -0.00120861f, 0.00731741f, 0.00175044f, 0.00913358f, -0.03449600f, 0.01160778f, 
    0.02150255f, -0.03499313f, 0.02633841f, 0.01135442f, -0.04034207f, -0.02335641f, -0.01833987f, -0.00643598f, 
    0.00963515f, 0.03686688f, -0.02346963f, 0.01103932f, -0.02010976f, -0.00983960f, -0.00139903f, -0.03625227f, 
    -0.03357524f, -0.02345888f, -0.02312856f, -0.02864798f, 0.00413209f, -0.01388198f, -0.02376161f, 0.00507622f, 
    0.00119720f, -0.00422007f, 0.00326300f, 0.00670370f, 0.02837117f, -0.00317578f, -0.02980994f, 0.02281733f, 
    -0.00623621f, -0.00662864f, -0.00430488f, -0.01177532f, 0.03290264f, -0.01690943f, -0.00341113f, 0.00985399f, 
    -0.00022834f, 0.02523350f, -0.00393243f, 0.00478575f, -0.00426381f, -0.01133973f, -0.02304452f, 0.01406418f, 
    0.02417226f, -0.03704936f, -0.00468034f, 0.02534056f, -0.03189425f, 0.00774102f, -0.03110314f, 0.00794893f, 
    -0.01154216f, -0.03203461f, 0.00362083f, 0.03930303f, 0.01915657f, -0.00110624f, -0.01913456f, 0.00969668f, 
    0.01839045f, -0.02639979f, 0.01315397f, -0.01356563f, -0.00476312f, 0.03565624f, -0.01315692f, -0.01434135f, 
    -0.01601409f, -0.01568557f, -0.01363632f, -0.01691613f, 0.03260521f, 0.02425996f, -0.03069003f, -0.02047273f, 
    -0.01495664f, 0.01958317f, 0.00242547f, -0.02078990f, 0.02007311f, -0.02190625f, -0.03112407f, -0.02584743f, 
    0.00926006f, 0.02653876f, 0.02402728f, -0.01519354f, 0.02357916f, -0.00221560f, -0.00255427f, 0.00118248f, 
    0.02912789f, -0.02246968f, -0.03128717f, -0.03484513f, -0.01029951f, 0.02655792f, 0.01313820f, -0.00999636f, 
    -0.00605815f, 0.02260522f, -0.02395150f, 0.00712304f, -0.00508053f, 0.03661060f, 0.01940695f, 0.02731450f, 
    -0.01917651f, -0.01187632f, -0.02669489f, 0.00351247f, -0.01459948f, -0.03313532f, 0.03006868f, 0.02085453f, 
    0.00155318f, -0.00747483f, -0.01159877f, -0.02784478f, -0.03807421f, 0.01634880f, 0.00346825f, -0.01538902f, 
    -0.02764048f, 0.02824483f, -0.02126876f, -0.00631413f, -0.01983980f, 0.01317243f, 0.02245556f, -0.00257930f, 
    -0.03919387f, -0.00266152f, 0.00487739f, -0.01434932f, 0.03561499f, 0.02245206f, 0.02615233f, -0.03746734f, 
    -0.02250705f, 0.00343284f, -0.03511398f, -0.03356683f, 0.00635414f, -0.03113648f, -0.00873850f, -0.02705699f, 
    0.01156645f, -0.01069203f, 0.02992276f, -0.00800243f, -0.00794699f, 0.01516959f, -0.00711694f, 0.00418474f, 
    0.02932598f, 0.03086659f, 0.01187707f, -0.01402719f, 0.00707157f, -0.02353660f, -0.02496143f, 0.01578945f, 
    0.02518518f, -0.00192067f, -0.02638895f, -0.03397466f, 0.03566987f, -0.02617126f, -0.00391618f, 0.02736780f, 
    0.01812766f, 0.00073814f, 0.01277330f, 0.01118207f, -0.02014941f, -0.03360683f, -0.01015478f, -0.03419019f, 
    0.01211024f, 0.01616026f, -0.00373070f, -0.00856299f, 0.00410977f, 0.01001994f, -0.01369669f, -0.04076352f, 
    0.00287399f, 0.00388638f, 0.03071041f, -0.02468126f, 0.00403478f, -0.00410529f, -0.03589616f, 0.00735337f, 
    -0.01636839f, 0.03250973f, -0.01868493f, 0.00716384f, -0.01456513f, -0.01304878f, -0.03026192f, 0.02710544f, 
    -0.02710724f, -0.03346207f, -0.02053738f, -0.01644107f, 0.01482617f, -0.02726169f, -0.03609961f, 0.01143035f, 
    0.00781856f, -0.02460303f, -0.02419546f, -0.02177705f, -0.02727758f, 0.00251386f, 0.02862652f, -0.00862583f, 
    -0.00815084f, -0.01644938f, 0.01557084f, 0.01980121f, 0.03698880f, -0.03194243f, -0.03031935f, -0.03327234f, 
    0.01965821f, -0.04148988f, -0.03943087f, 0.00224569f, -0.01014389f, 0.00551023f, -0.03493369f, 0.02761777f, 
    -0.00037075f, 0.00718141f, -0.02336441f, -0.01324567f, -0.02239837f, 0.00359935f, -0.01336330f, -0.02217576f, 
    0.03147331f, -0.01001082f, -0.00982516f, -0.03976881f, 0.01820099f, -0.01505850f, 0.01631075f, 0.02199593f, 
    -0.01351964f, -0.00291561f, -0.02860623f, -0.02130084f, 0.01016348f, -0.02413644f, 0.00504876f, -0.03424536f, 
    -0.03322294f, 0.02923674f, -0.02687059f, 0.02658331f, 0.00485700f, -0.02052228f, 0.02254864f, -0.00325116f, 
    -0.02944186f, 0.00905496f, -0.00513638f, -0.01488106f, 0.01376698f, 0.02054889f, -0.01709299f, -0.02152645f, 
    0.00533705f, 0.01438819f, 0.02933655f, 0.02978925f, 0.01730996f, 0.03830497f, -0.03005522f, 0.01157048f, 
    0.00874720f, -0.01331125f, 0.01053151f, -0.00309330f, -0.00270369f, 0.00510633f, -0.01057909f, 0.02163875f, 
    0.01567655f, -0.03321702f, 0.01228886f, 0.00850428f, -0.03335183f, 0.03463439f, 0.00982402f, -0.02318572f, 
    -0.03249331f, 0.00301123f, 0.00895312f, 0.02484111f, -0.04418144f, -0.03359070f, 0.01466826f, -0.02612233f, 
    -0.03719009f, -0.03508404f, -0.01798550f, 0.01706650f, 0.02407391f, -0.00576360f, -0.01193713f, -0.01752125f, 
    0.21522537f, -0.11272460f, -0.02005864f, -0.00214517f, -0.05621215f, 0.03476095f, 0.00310531f, 0.10114823f, 
    -0.05965219f, 0.05459441f, 0.07645294f, 0.00907414f, -0.12538719f, 0.10246056f, 0.04813380f, 0.00410244f, 
    0.12982279f, -0.04487202f, -0.02714080f, -0.00227723f, -0.10931478f, -0.01955345f, 0.00156990f, 0.10996392f, 
    0.32597107f, 0.13212077f, -0.00363663f, 0.17321901f, -0.14673583f, 0.06451104f, 0.00651530f, -0.01083695f, 
    -0.15318574f, -0.00862329f, 0.14384194f, -0.03011202f, -0.16414671f, 0.08411220f, 0.30823317f, -0.08585722f, 
    -0.14708449f, 0.00451258f, -0.08827612f, 0.02016720f, 0.02096188f, -0.08366136f, -0.16359071f, -0.04562872f, 
    -0.06548890f, -0.04002102f, 0.16673015f, 0.03341268f, -0.05818712f, 0.00252103f, 0.03506294f, -0.06842832f, 
    -0.03844734f, -0.02047354f, 0.04037826f, -0.03059681f, -0.14569996f, -0.09621777f, 0.26585677f, 0.05274583f, 
    -0.10379924f, 0.00333011f, -0.04748984f, -0.11137311f, 0.00940308f, -0.06671218f, -0.00454716f, 0.03836054f, 
    0.18595944f, 0.05414645f, 0.05774943f, -0.01653149f, 0.16944668f, 0.01250200f, -0.05486196f, 0.01472557f, 
    -0.08406757f, 0.13713181f, 0.03910384f, 0.13423698f, -0.04974975f, 0.00539412f, 0.11841100f, -0.05882380f, 
    -0.04028698f, -0.01248313f, 0.07119407f, 0.09869343f, -0.03122210f, -0.10877589f, 0.03387723f, 0.02989664f, 
    -0.05416597f, 0.15637720f, 0.08227979f, -0.21718761f, -0.11247819f, -0.00358093f, 0.06883612f, -0.00199677f, 
    -0.01356090f, -0.07442488f, 0.07229064f, 0.04892917f, -0.22453062f, -0.13241838f, 0.21663573f, 0.07187098f, 
    -0.05168629f, 0.00597917f, -0.04426955f, 0.02012424f, 0.00679901f, -0.04610645f, -0.00822819f, -0.07225736f, 
    -0.09177596f, 0.11083600f, 0.06622855f, -0.01244515f, -0.09688567f, -0.03194340f, 0.12411384f, 0.14259428f, 
    0.06216813f, -0.04258426f, 0.07435358f, -0.06216686f, 0.23147866f, -0.12791346f, 0.04811372f, 0.01331573f, 
    -0.00853340f, 0.11198934f, -0.01824048f, 0.10060453f, -0.12775213f, 0.07792334f, -0.07912052f, -0.07249091f, 
    -0.06777601f, 0.04751263f, 0.04087489f, 0.07545178f, 0.08128556f, 0.10481501f, 0.07126004f, -0.06444308f, 
    -0.18171589f, 0.03017585f, -0.00434605f, 0.08479446f, -0.03956481f, -0.06849027f, -0.04831164f, -0.05000924f, 
    0.10926968f, 0.19890960f, 0.02445515f, 0.04198347f, 0.05377514f, 0.01546228f, 0.03524116f, 0.00349263f, 
    0.21059996f, -0.00869723f, 0.06086914f, 0.13771185f, -0.08330873f, -0.07527377f, 0.03109156f, -0.09951857f, 
    -0.01101513f, 0.00238941f, 0.00126372f, -0.10666707f, 0.14027154f, 0.32659438f, 0.05046012f, 0.20461646f, 
    -0.07070144f, 0.02016338f, -0.05612468f, 0.11315733f, 0.00442793f, 0.04279865f, 0.02935999f, 0.09154788f, 
    0.07749055f, 0.32286280f, 0.00660711f, -0.03121343f, -0.04808233f, 0.08048686f, 0.09654485f, 0.04010777f, 
    0.08824256f, -0.01260246f, -0.08138653f, -0.03427786f, -0.04811788f, 0.06682120f, -0.01487415f, -0.03351853f, 
    0.17271416f, -0.03252179f, 0.07969131f, -0.08520395f, 0.15361576f, -0.02948011f, 0.02601282f, 0.15808132f, 
    0.01126204f, 0.29955244f, 0.13626303f, 0.00180751f, -0.00028447f, 0.04244401f, 0.00202052f, 0.01461180f, 
    -0.09133551f, -0.01016237f, -0.08456969f, 0.03940064f, -0.03249490f, -0.14713025f, 0.13995005f, 0.12788194f, 
    -0.05700592f, -0.07864742f, 0.00831116f, 0.07683841f, 0.17020653f, 0.03003502f, 0.03399879f, -0.08618903f, 
    -0.08567173f, -0.19018438f, -0.01612234f, -0.03816697f, 0.00485251f, 0.03077962f, -0.07218263f, 0.04775062f, 
    0.06320522f, 0.01263671f, -0.00349602f, 0.00669705f, -0.14544478f, -0.02258449f, -0.13284180f, 0.03433755f, 
    0.17400908f, 0.07466668f, -0.04498694f, 0.07269870f, 0.09781438f, 0.00616815f, -0.03333210f, 0.03215585f, 
    0.07931755f, -0.13261144f, -0.13125356f, -0.07603237f, -0.04369152f, -0.02957123f, 0.11927081f, -0.10087928f, 
    -0.16176403f, -0.09648465f, -0.04972447f, 0.03519855f, 0.13379773f, -0.12018632f, 0.13931890f, 0.16149434f, 
    -0.09418070f, -0.00269932f, 0.06160891f, 0.06550798f, -0.07931080f, -0.02482401f, 0.05238748f, 0.03728358f, 
    0.04152009f, -0.02924010f, -0.02584065f, 0.05879805f, 0.06603640f, 0.02456092f, -0.06430151f, 0.17712381f, 
    0.07419927f, 0.01396435f, 0.10408965f, -0.03149477f, -0.14504728f, -0.03243862f, 0.02419867f, 0.04297787f, 
    -0.01256665f, 0.06461151f, 0.06116828f, 0.01887757f, -0.05936516f, -0.06713545f, -0.06407773f, -0.10799912f, 
    0.03278263f, 0.09290072f, 0.00286920f, 0.18460393f, -0.01661879f, 0.06878377f, 0.12379158f, 0.05380194f, 
    -0.00199523f, -0.02319085f, 0.11949287f, 0.10479430f, -0.10360684f, -0.07975457f, 0.11341935f, -0.14494301f, 
    -0.02600429f, -0.06943666f, -0.02924935f, -0.12293961f, -0.07883437f, -0.01383932f, -0.10215723f, 0.10214502f, 
    0.00431794f, -0.00719971f, -0.12712869f, -0.12364023f, 0.14545111f, 0.08692387f, 0.02629887f, -0.04814722f, 
    0.02308274f, -0.08032463f, 0.07708497f, 0.02800030f, -0.11791842f, 0.23995985f, 0.11488113f, 0.16952558f, 
    -0.10987378f, 0.00963393f, -0.02404076f, 0.00416850f, 0.02206795f, -0.04607236f, 0.05597426f, -0.07335892f, 
    0.08893122f, -0.12759422f, 0.09821246f, -0.06626341f, 0.02711092f, 0.13894534f, -0.03450503f, -0.05180005f, 
    -0.09062534f, 0.01784422f, 0.12146637f, 0.04122642f, 0.04852430f, 0.16835891f, 0.21855555f, 0.17937239f, 
    -0.09407265f, -0.04664176f, 0.07811977f, 0.06374996f, 0.02634420f, 0.07646400f, -0.02530445f, -0.09983024f, 
    0.02077268f, 0.02355237f, -0.03276481f, -0.14522344f, 0.14350885f, 0.06213531f, -0.04625956f, -0.07089629f, 
    0.08208746f, -0.01859577f, 0.10185326f, 0.02402263f, 0.07407468f, 0.10958101f, 0.13330817f, 0.03498897f, 
    0.09907045f, -0.09485868f, 0.06723895f, 0.08331521f, 0.05364580f, -0.06080150f, 0.05305015f, 0.15839869f, 
    -0.13924530f, 0.01437240f, 0.06899024f, -0.12900588f, 0.06082332f, 0.07450931f, 0.03611700f, 0.03043339f, 
    0.07211797f, 0.01854264f, 0.01161745f, 0.05698416f, 0.09843270f, -0.21263728f, 0.09913009f, -0.00055577f, 
    0.12421711f, -0.08736106f, 0.03852677f, 0.12184234f, -0.02130201f, 0.00257993f, 0.10428789f, -0.01521372f, 
    -0.24389474f, 0.12505147f, 0.13679706f, -0.14001328f, 0.13442537f, 0.12076116f, 0.01094539f, 0.06074905f, 
    0.10957712f, 0.13296279f, -0.03721252f, 0.06785781f, 0.24038368f, -0.06037770f, 0.18126932f, 0.02652614f, 
    0.02117746f, 0.00857492f, 0.15188238f, 0.04790166f, -0.08231220f, -0.02088016f, 0.05641379f, 0.14728029f, 
    -0.18147917f, 0.02312326f, -0.04681022f, -0.04596104f, 0.14134066f, 0.04751561f, -0.01890763f, 0.02397089f, 
    0.07089335f, 0.03362295f, 0.08061928f, 0.12174363f, -0.17729293f, -0.22897521f, 0.23114786f, 0.04358747f, 
    -0.08408019f, 0.03914677f, -0.00145631f, -0.09611782f, -0.02185267f, 0.01113611f, -0.06032248f, -0.08461305f, 
    -0.11728241f, 0.04785312f, -0.05658302f, 0.10714494f, 0.02466357f, -0.01167857f, -0.02606795f, 0.04183338f, 
    -0.08076752f, 0.09692632f, -0.01708515f, 0.01783576f, 0.08944076f, 0.08325446f, -0.00256091f, -0.12174081f, 
    -0.07161493f, 0.08987239f, -0.00792304f, 0.02736380f, 0.01238159f, -0.04416122f, -0.03904213f, -0.02237563f, 
    0.10490199f, 0.14514981f, -0.20024399f, 0.01639910f, 0.13229112f, 0.07376218f, 0.06857695f, -0.09508713f, 
    -0.00030617f, -0.02796322f, -0.07380901f, -0.01788741f, -0.24540707f, 0.05126460f, -0.20041409f, -0.02697559f, 
    0.07020272f, 0.10824100f, -0.01577695f, -0.00464696f, 0.04716025f, 0.03685717f, 0.01100146f, -0.03233293f, 
    0.10905607f, 0.05968827f, 0.01340482f, -0.15642048f, 0.02770467f, 0.11508457f, -0.03889707f, -0.03032010f, 
    0.04581850f, 0.00060764f, -0.04683726f, -0.05157557f, -0.05924353f, -0.08807047f, 0.03559511f, 0.04857717f, 
    0.03361682f, -0.03361659f, -0.00138246f, 0.07203382f, -0.09076770f, -0.01276261f, -0.02366380f, -0.02302399f, 
    -0.12248455f, 0.18660264f, 0.08433929f, -0.05880968f, -0.05509851f, -0.02525550f, -0.00320157f, 0.04915499f, 
    -0.07255200f, -0.05412288f, -0.08407481f, 0.02700860f, -0.20926298f, -0.00636572f, 0.10320164f, 0.09118802f, 
    -0.10694189f, 0.05052865f, 0.05118185f, 0.08661567f, -0.02860152f, 0.01883189f, -0.05547365f, -0.10341403f, 
    0.12656139f, 0.00860648f, 0.06011329f, 0.11127923f, -0.07964211f, -0.00195605f, 0.01140539f, -0.04756732f, 
    0.00624314f, -0.00941332f, 0.04095152f, -0.06938031f, 0.10404281f, 0.00701645f, 0.22879010f, 0.01123469f, 
    0.23074420f, -0.05394156f, 0.08250694f, -0.05468933f, 0.00713211f, -0.08238392f, -0.03110873f, -0.03840859f, 
    0.16586764f, 0.04388926f, 0.12768708f, 0.02408943f, 0.01644230f, 0.03574874f, 0.02602906f, 0.06716525f, 
    0.01197812f, 0.06166718f, 0.04319831f, 0.00240316f, 0.19679065f, 0.09904595f, 0.09432697f, -0.02892032f, 
    -0.06534321f, 0.02619149f, 0.00281396f, 0.03790696f, -0.00842534f, 0.05466199f, 0.03404878f, 0.01926169f, 
    -0.15738943f, -0.06280132f, 0.19584034f, 0.08868594f, -0.13953394f, -0.04447340f, -0.01588966f, -0.05136878f, 
    -0.12888160f, -0.05999134f, 0.01164735f, 0.10789797f, -0.26572940f, -0.17950055f, 0.14773522f, 0.10242333f, 
    0.02025220f, 0.03076019f, -0.05899592f, -0.10326191f, -0.07599358f, -0.05019355f, -0.05949981f, -0.01995695f, 
    0.23704085f, 0.00784869f, -0.14146617f, 0.01815646f, -0.04005457f, -0.12431598f, 0.11600687f, -0.05147645f, 
    0.03394742f, 0.03568077f, 0.03640951f, 0.08113011f, -0.08534671f, 0.06294364f, 0.10937600f, 0.03025456f, 
    0.03966346f, 0.02730788f, -0.00149821f, 0.17020665f, 0.04551382f, 0.00476357f, 0.05553886f, 0.04076613f, 
    0.06731481f, -0.06345145f, -0.03539807f, -0.04233132f, -0.00023421f, -0.05237524f, 0.07912868f, 0.12114345f, 
    -0.12362742f, 0.05056364f, -0.06126126f, 0.02772113f, 0.22403269f, -0.11451404f, -0.00092768f, 0.00161524f, 
    0.00814773f, -0.07646471f, -0.04514200f, 0.01094459f, -0.05859765f, -0.02312117f, 0.03706605f, -0.06404101f, 
    -0.14255410f, -0.11349468f, 0.24785447f, -0.15257838f, 0.06175693f, -0.02475615f, 0.04175982f, 0.04501199f, 
    0.06162649f, 0.04515424f, -0.03767192f, 0.16209145f, 0.03100361f, -0.14133911f, 0.06296080f, -0.03313388f, 
    0.07528560f, -0.00481546f, 0.02076262f, -0.11396883f, -0.06774401f, 0.03323399f, -0.00764257f, 0.01851258f, 
    -0.02242300f, 0.03476386f, 0.05398770f, 0.03322272f, -0.17273484f, 0.08781767f, -0.01166279f, -0.02828870f, 
    -0.16371790f, -0.05791210f, 0.04387178f, 0.00229242f, 0.18067302f, 0.14921020f, 0.06253827f, 0.05623714f, 
    -0.05512586f, 0.01126073f, 0.05416603f, 0.10621585f, -0.02903116f, 0.04686775f, 0.01976226f, -0.00792592f, 
    -0.08953149f, 0.16443646f, 0.10150645f, 0.20475067f, 0.04321192f, 0.05120720f, -0.02314436f, 0.01326517f, 
    0.05668805f, 0.15058000f, 0.05717003f, -0.11958465f, -0.23938873f, 0.05831391f, 0.00866073f, 0.08977186f, 
    0.04890683f, -0.03596640f, -0.07701301f, -0.10257993f, -0.11841703f, 0.05968398f, 0.04518259f, -0.13540041f, 
    -0.01777523f, 0.00159793f, -0.01929109f, -0.03673925f, -0.01885434f, -0.02251882f, 0.00010688f, -0.01187901f, 
    0.01012699f, -0.03452641f, -0.02329203f, -0.03615480f, -0.03920253f, 0.01107333f, 0.00172301f, 0.00462944f, 
    -0.02197910f, -0.01991543f, -0.01768609f, 0.01861224f, 0.02278006f, 0.02545181f, -0.02179124f, 0.02376354f, 
    -0.01026882f, 0.02329517f, -0.04181785f, -0.01317618f, -0.00115606f, -0.01257247f, -0.04142464f, -0.03729700f, 
    0.01122485f, -0.00845071f, 0.00672978f, -0.00831738f, -0.02095308f, 0.02944299f, -0.01160468f, 0.01219874f, 
    0.00417420f, 0.01406102f, 0.01484231f, -0.03180822f, 0.02858897f, -0.01062876f, 0.01881192f, -0.00602939f, 
    -0.01929793f, -0.03918481f, -0.02190886f, -0.02377473f, 0.00024324f, -0.02634238f, -0.00401917f, 0.02123490f, 
    0.00746544f, -0.03909774f, 0.01853121f, 0.02604538f, 0.00437380f, -0.00171569f, 0.02327673f, 0.01826601f, 
    -0.02639049f, -0.03091390f, -0.00151831f, 0.01919770f, -0.03867013f, -0.04042355f, 0.00822166f, -0.01659260f, 
    0.02551658f, -0.00473574f, -0.03678568f, 0.02731012f, -0.02123234f, 0.01305780f, -0.03425736f, 0.00457852f, 
    -0.02729835f, -0.02976136f, 0.01944645f, -0.02039948f, 0.00737282f, 0.02181995f, -0.01952999f, -0.03947700f, 
    -0.03618718f, -0.01909204f, 0.02358539f, -0.02227772f, 0.02620537f, 0.02635974f, 0.00468881f, -0.01001869f, 
    -0.00934122f, 0.01209015f, -0.02844493f, -0.02228389f, -0.03178227f, -0.03567650f, -0.01681974f, -0.00747946f, 
    -0.01644716f, 0.02723824f, -0.01739513f, 0.00661613f, -0.02379486f, -0.01469460f, -0.01719089f, -0.03561018f, 
    0.02402463f, 0.00199258f, 0.01293887f, -0.01388155f, -0.03389277f, 0.00793923f, 0.02763857f, -0.03640349f, 
    0.01787499f, 0.02546058f, -0.03994594f, -0.02793605f, -0.04083249f, 0.00729499f, 0.00666784f, -0.02882534f, 
    -0.00636031f, -0.00382074f, -0.03740056f, 0.00286943f, 0.00487980f, -0.02484278f, -0.03739087f, -0.00654106f, 
    -0.01904142f, -0.00260733f, -0.00780614f, -0.00649063f, 0.02570916f, -0.01558948f, -0.01684146f, 0.00688729f, 
    -0.00999593f, -0.02005427f, -0.01232283f, -0.01811491f, -0.00103284f, -0.01341995f, 0.02650486f, -0.02834486f, 
    0.02668026f, 0.02258660f, -0.03272486f, -0.02372309f, 0.01761819f, -0.01811078f, -0.02953744f, 0.00168778f, 
    0.02713606f, 0.02263648f, 0.02286551f, 0.00794914f, 0.01460324f, -0.02390113f, -0.02796637f, -0.02805139f, 
    0.00506993f, -0.02156864f, -0.03912361f, -0.00924339f, -0.03964992f, -0.03147701f, -0.02549063f, -0.00350488f, 
    0.02211787f, 0.00768401f, -0.03047995f, 0.01091603f, 0.01713314f, -0.00719561f, 0.02447328f, -0.02436225f, 
    -0.02060869f, 0.00065421f, -0.02281042f, -0.01339768f, 0.00029296f, -0.02918463f, 0.00052026f, -0.02987992f, 
    0.02163574f, -0.02780097f, 0.00306655f, 0.01766380f, -0.01224830f, 0.01500602f, -0.02080515f, -0.02167519f, 
    0.01935882f, -0.01405655f, 0.01148698f, 0.01809638f, -0.02115222f, 0.02469781f, -0.01306632f, 0.00330945f, 
    0.01098385f, -0.02618244f, 0.00008670f, -0.02648879f, 0.00605711f, -0.03117429f, 0.01190162f, 0.01330947f, 
    -0.01837361f, 0.02069453f, -0.00475218f, 0.01603833f, -0.01888149f, 0.00864941f, 0.02836377f, 0.02650839f, 
    -0.02995707f, -0.02731537f, -0.00089950f, 0.01889425f, 0.00277059f, -0.01130498f, -0.01958138f, -0.03770737f, 
    -0.00497313f, 0.02231953f, -0.01472213f, -0.02684062f, -0.03009699f, -0.03667488f, -0.02852780f, 0.02353057f, 
    0.02615727f, 0.01787142f, -0.03386237f, 0.00226898f, -0.01482460f, -0.02430216f, 0.00924550f, 0.01182432f, 
    -0.00856517f, -0.03796377f, -0.03473013f, -0.03937685f, -0.01578485f, -0.01542878f, -0.01658844f, -0.00806950f, 
    -0.00629867f, -0.02732171f, -0.00017798f, 0.00986885f, -0.04025567f, -0.03388381f, -0.02432135f, 0.00381023f, 
    -0.01067232f, -0.03601052f, -0.01330369f, -0.01921736f, -0.03073863f, 0.00085336f, -0.02357822f, 0.02303984f, 
    0.01651152f, -0.00965672f, -0.03086964f, -0.00717004f, 0.01061089f, 0.00044612f, -0.00175063f, -0.01724813f, 
    -0.02366539f, -0.03859315f, -0.01799981f, -0.01631073f, -0.01196407f, -0.02496260f, -0.03238105f, -0.01020136f, 
    -0.00311751f, 0.02787685f, -0.01920486f, 0.01060960f, 0.01638290f, 0.02719271f, -0.02222803f, -0.01915790f, 
    -0.04115883f, -0.01035651f, -0.03829443f, 0.01755986f, -0.01271650f, 0.01260871f, -0.00110557f, -0.02939490f, 
    -0.01149293f, -0.00566823f, 0.00206583f, 0.02281659f, 0.01861451f, 0.01078939f, -0.02039824f, -0.02666012f, 
    -0.00059584f, -0.03143831f, 0.00259041f, 0.00846627f, -0.01837589f, -0.02100181f, -0.02884346f, 0.00859608f, 
    -0.03385026f, 0.02427102f, 0.00899777f, -0.03481966f, -0.03335089f, -0.01189980f, 0.00333131f, -0.01145506f, 
    -0.03207212f, 0.01421917f, 0.00518817f, -0.00996860f, 0.00771614f, 0.00309328f, -0.03943550f, -0.01712767f, 
    -0.04037638f, 0.00557691f, -0.02299004f, -0.03022360f, -0.00119844f, -0.03437133f, -0.03906995f, -0.01526561f, 
    -0.01587127f, -0.01712980f, -0.04185343f, -0.00755357f, -0.00698111f, -0.00184220f, 0.00756828f, 0.01123904f, 
    -0.01250096f, 0.01487098f, -0.02552868f, 0.01358645f, -0.03201695f, -0.00674231f, -0.02977505f, 0.02571739f, 
    -0.01363096f, -0.00039863f, 0.02289679f, -0.02961691f, 0.00209653f, 0.02784509f, 0.00284772f, -0.02206695f, 
    0.00335794f, 0.01675555f, -0.03564975f, -0.03749494f, -0.03199334f, 0.02292087f, -0.01398700f, 0.02894726f, 
    0.00432929f, -0.03068205f, -0.01730963f, -0.00004251f, 0.00777449f, 0.02042015f, -0.01544813f, 0.01304483f, 
    -0.02809709f, -0.02996374f, -0.01439540f, -0.03483369f, -0.03085338f, 0.01805518f, 0.02050236f, -0.02253858f, 
    0.02887894f, 0.02469135f, 0.00023432f, -0.00902256f, -0.02549353f, 0.00381826f, -0.01324836f, -0.01102227f, 
    -0.00031705f, -0.02544989f, -0.02585397f, -0.02839845f, 0.00646540f, 0.02212830f, -0.02428736f, 0.02602017f, 
    -0.00084907f, 0.02818607f, -0.00432306f, -0.00657534f, -0.02276552f, 0.02560622f, -0.00187947f, -0.00008088f, 
    -0.01543431f, 0.02634291f, 0.02253366f, -0.01584905f, -0.01746883f, -0.03628540f, -0.00249517f, 0.02075813f, 
    0.02195986f, 0.02703396f, -0.01116536f, 0.02824699f, -0.03227856f, -0.04041579f, -0.02213433f, -0.02672698f, 
    0.01078098f, 0.00031920f, -0.03680013f, 0.02111286f, 0.02364800f, -0.02076784f, -0.02201816f, -0.02914337f, 
    0.01309108f, 0.00468952f, 0.01547748f, 0.02102935f, -0.00660899f, 0.02729463f, -0.03327666f, -0.03975089f, 
    0.02408467f, -0.00798520f, 0.02915924f, -0.00775696f, -0.03472979f, 0.02961632f, -0.00508820f, -0.01227802f, 
    0.02245861f, -0.00535101f, 0.02768321f, -0.01227786f, 0.01084660f, 0.01941195f, -0.01465104f, -0.02945145f, 
    -0.03060693f, -0.02209669f, 0.02304442f, 0.02451296f, -0.02817895f, 0.00019409f, 0.02382467f, 0.02690113f, 
    -0.03835653f, -0.00816738f, 0.01425662f, 0.01263944f, -0.03836364f, -0.01855821f, -0.03738299f, -0.00904072f, 
    -0.01429831f, 0.01167321f, -0.02503357f, -0.04026355f, -0.00123182f, -0.01196375f, 0.00029620f, 0.00129316f, 
    0.01403113f, -0.00366619f, -0.01637481f, 0.02405365f, -0.03387605f, -0.02223939f, 0.02169539f, 0.02586101f, 
    0.02238703f, 0.00158117f, 0.00281190f, 0.00423105f, 0.00302167f, -0.00446120f, 0.01427360f, -0.03093361f, 
    -0.03364941f, 0.00520753f, -0.01764933f, -0.02299247f, -0.01298168f, -0.01185913f, 0.00932858f, 0.01582458f, 
    0.01289930f, 0.00971148f, 0.01111628f, 0.01745538f, -0.03340769f, -0.00072702f, -0.01640738f, 0.00224312f, 
    0.01730698f, -0.04100448f, -0.04029488f, -0.03963926f, 0.02064534f, 0.00410231f, -0.02903830f, -0.00605628f, 
    -0.01136158f, -0.01420713f, 0.00803429f, -0.02018135f, -0.03810508f, 0.01166617f, 0.01342999f, -0.01325279f, 
    0.02234668f, -0.02707584f, 0.02225606f, 0.00085700f, -0.00087967f, 0.02632122f, 0.01119552f, -0.02040199f, 
    -0.02836321f, 0.02150899f, 0.02733481f, 0.00033270f, -0.04165904f, 0.02523828f, -0.00637774f, 0.00134233f, 
    0.01461877f, 0.00862727f, 0.01212894f, -0.00541989f, 0.01262277f, 0.00652987f, -0.02140317f, 0.01285931f, 
    0.01666296f, 0.00575964f, -0.03870848f, -0.01744925f, 0.02717240f, 0.02348280f, 0.02997583f, -0.01689775f, 
    0.01705510f, -0.00747413f, -0.01093700f, -0.01183179f, 0.00025932f, 0.01083735f, -0.03237217f, -0.01695141f, 
    0.00169953f, -0.04104586f, -0.01973570f, 0.02084193f, 0.02318066f, -0.01494891f, 0.00537474f, 0.00485386f, 
    -0.00608212f, -0.01110868f, -0.01083779f, -0.02770486f, 0.00959858f, -0.02675365f, 0.01457824f, -0.02937680f, 
    -0.02464963f, -0.03673356f, -0.01276579f, 0.02429016f, -0.02500607f, -0.01915882f, -0.04076050f, -0.03467814f, 
    0.00167258f, -0.02919926f, 0.00790385f, 0.02740559f, -0.03217025f, 0.02771064f, 0.00626460f, -0.00100119f, 
    0.00188113f, -0.03000194f, -0.01673008f, -0.03307025f, 0.01896972f, -0.00733275f, -0.01804769f, -0.03580512f, 
    -0.03270328f, -0.04174143f, -0.02792535f, -0.01933250f, -0.03433296f, 0.02021350f, -0.01523125f, -0.03457676f, 
    -0.02228041f, 0.00111566f, -0.00685210f, 0.00660822f, 0.01279777f, -0.01151012f, -0.01943332f, 0.02807310f, 
    0.01473698f, 0.00176879f, 0.01535673f, -0.03083361f, 0.01376650f, 0.02664980f, 0.00698878f, 0.00502323f, 
    -0.02007646f, -0.02673720f, 0.00553899f, 0.00845773f, -0.01189317f, -0.02592839f, -0.00869914f, -0.02239714f, 
    -0.00395989f, -0.01095084f, 0.02319697f, 0.01421315f, -0.00554125f, -0.01380385f, 0.02639504f, -0.02519977f, 
    -0.03991944f, 0.00580721f, -0.00631906f, -0.01690284f, -0.01088643f, 0.02323894f, -0.01066283f, 0.00031558f, 
    0.00153009f, -0.00758999f, -0.01600949f, -0.04082464f, -0.01809186f, -0.01449781f, -0.02968148f, 0.02367072f, 
    -0.00005300f, -0.00897678f, -0.02961875f, -0.03168681f, 0.00254659f, 0.01540001f, -0.01911069f, 0.02084777f, 
    0.00556439f, -0.03866659f, -0.00221692f, 0.00413303f, -0.02826169f, -0.03326821f, -0.00442292f, 0.02143161f, 
    0.01343786f, 0.02591606f, 0.00303580f, -0.01525169f, -0.03631243f, 0.02790209f, 0.02481271f, -0.00562084f, 
    -0.02092778f, -0.01888966f, -0.03430627f, 0.00828102f, -0.03238970f, -0.00383563f, 0.00424497f, -0.00464727f, 
    -0.01890058f, -0.03465916f, -0.02972521f, -0.01902629f, 0.02269812f, -0.01507438f, -0.01536082f, 0.01039483f, 
    0.00627402f, -0.02873391f, -0.03015695f, -0.01381672f, -0.01223884f, -0.02933689f, 0.02206655f, -0.02584193f, 
    -0.01629542f, -0.01757238f, -0.00892496f, 0.01017818f, 0.01935085f, -0.02401560f, 0.00481368f, 0.02804158f, 
    -0.01485407f, -0.00794401f, 0.01688518f, 0.01741066f, -0.01967911f, -0.02351049f, -0.00868400f, 0.01384803f, 
    0.02002244f, -0.01159918f, -0.03542187f, -0.01975720f, 0.00214182f, -0.00711389f, 0.01893307f, -0.03020769f, 
    -0.02525568f, -0.01135497f, 0.02405922f, 0.01526536f, 0.00391126f, -0.01170929f, -0.04100947f, -0.02490786f, 
    -0.01126041f, -0.02307727f, 0.01811464f, -0.02727610f, 0.01007387f, -0.00885549f, 0.00146122f, 0.00275790f, 
    0.01118876f, 0.02338089f, -0.02625308f, 0.02713826f, 0.02422264f, -0.03303640f, 0.02829019f, -0.00096237f, 
    -0.01502603f, -0.24993612f, -0.01548190f, 0.20039508f, -0.07142139f, 0.00455702f, -0.07173406f, -0.09326302f, 
    -0.09775871f, 0.01359440f, 0.01896296f, -0.00332750f, 0.19242720f, -0.05728021f, -0.02584919f, -0.01932184f, 
    0.00088829f, -0.08987492f, -0.07054863f, 0.00517149f, -0.05658925f, -0.07858825f, -0.01431086f, 0.10773788f, 
    -0.31708956f, -0.14283584f, -0.03308730f, -0.00599891f, -0.00934628f, 0.01293475f, -0.02826707f, 0.06038801f, 
    -0.01361587f, 0.16227011f, 0.01805739f, 0.06365395f, 0.19307126f, 0.03560847f, 0.19060178f, -0.20068820f, 
    -0.03522822f, 0.03627389f, 0.06444742f, -0.04998241f, 0.00525790f, 0.08196507f, 0.03628209f, -0.07476619f, 
    -0.11374643f, 0.00258959f, -0.10674142f, -0.02390002f, 0.07641514f, 0.06611612f, 0.01780597f, -0.02824995f, 
    -0.08281947f, 0.04078213f, 0.07104769f, 0.02961531f, 0.28012395f, 0.05288924f, 0.08186635f, -0.03600312f, 
    0.09392864f, 0.17331177f, -0.06887130f, -0.00297134f, 0.00965166f, -0.04236446f, 0.06902315f, -0.04236929f, 
    -0.01988508f, 0.01185913f, -0.01625064f, -0.17072420f, -0.04841912f, -0.04977267f, -0.06507763f, -0.04817471f, 
    -0.01444575f, 0.17477340f, 0.02083544f, 0.08677472f, -0.09823541f, 0.10036355f, -0.13104886f, -0.29291353f, 
    -0.01570316f, 0.05266223f, -0.05924405f, 0.10804730f, 0.09780180f, -0.01779705f, 0.00562691f, -0.03543200f, 
    0.20533584f, 0.09077345f, 0.14609464f, -0.14068648f, 0.04594778f, 0.15879257f, 0.15005594f, 0.01067996f, 
    0.06047304f, -0.04741535f, 0.02393903f, 0.09897325f, 0.36521938f, 0.02900065f, -0.07657353f, 0.22918750f, 
    0.00875422f, 0.07251907f, -0.01109631f, 0.03363128f, 0.00427007f, 0.02957110f, -0.00459445f, -0.16266668f, 
    -0.03478777f, -0.09952995f, 0.02149617f, -0.09308656f, -0.00201141f, 0.05345088f, 0.13371728f, 0.06094329f, 
    0.07827200f, -0.03008586f, 0.00457816f, -0.08024882f, -0.17974500f, -0.12340536f, 0.03149733f, 0.16128054f, 
    -0.05780192f, 0.09225923f, 0.03438168f, 0.08766552f, -0.05400867f, -0.09881045f, -0.04477161f, -0.04620661f, 
    0.02124284f, -0.07591140f, -0.07798951f, 0.03355790f, -0.05359779f, 0.01011759f, 0.04896171f, -0.09706650f, 
    0.01873473f, -0.01131643f, -0.05338816f, 0.17822778f, -0.01095651f, 0.00266518f, 0.06200254f, -0.00428091f, 
    -0.06582450f, 0.10447216f, 0.05283545f, 0.13086984f, -0.00675380f, 0.02010160f, -0.01259118f, 0.11560521f, 
    0.13086446f, 0.21844953f, -0.04395387f, -0.04982104f, -0.00500084f, -0.03201770f, 0.08955770f, 0.01301972f, 
    -0.08989833f, 0.03475061f, 0.01173958f, -0.05675111f, -0.21348664f, -0.09193600f, -0.00705222f, -0.06229934f, 
    -0.03282754f, 0.08001628f, 0.05587437f, 0.08353776f, 0.00166849f, -0.04357200f, 0.11209265f, 0.07441750f, 
    0.09139299f, -0.00748822f, -0.17852758f, 0.08331887f, 0.03048350f, 0.04965781f, 0.03545693f, 0.02921595f, 
    0.14660099f, -0.01786826f, -0.14793487f, -0.09185605f, 0.07146589f, -0.05214599f, 0.03266554f, -0.16003150f, 
    -0.00460065f, -0.05367978f, 0.01079432f, 0.05166951f, -0.03880432f, -0.04542835f, 0.00900511f, 0.08980561f, 
    -0.18139054f, -0.13714384f, 0.01474835f, -0.16116376f, -0.01203414f, -0.05330612f, 0.02617598f, -0.07100824f, 
    -0.07121377f, 0.04515145f, -0.00111531f, 0.04584333f, 0.07767213f, -0.00726740f, 0.02864186f, 0.18825196f, 
    0.00903650f, 0.06724151f, 0.17824185f, 0.01722673f, -0.03248033f, -0.04009084f, 0.00309775f, -0.03518067f, 
    0.25746256f, -0.18449879f, -0.04449207f, -0.02411465f, -0.10765510f, -0.08693784f, 0.06868288f, -0.08880024f, 
    0.02079821f, 0.01777972f, 0.01132672f, -0.02849203f, 0.16861369f, -0.07877598f, -0.06901573f, -0.29655391f, 
    -0.19778092f, -0.02775181f, -0.02219501f, 0.08706405f, 0.06496512f, -0.02906361f, 0.07007767f, -0.01623232f, 
    -0.13318628f, 0.10694524f, 0.04213903f, -0.13163337f, 0.05422082f, 0.03796406f, 0.12809035f, 0.00214195f, 
    0.03737398f, -0.06437190f, -0.01924546f, 0.14604582f, -0.01392118f, -0.25590339f, 0.12957375f, 0.08779779f, 
    0.05408285f, 0.00176295f, 0.06407213f, 0.07305226f, 0.00483711f, -0.08115537f, 0.00629646f, 0.13616179f, 
    0.00544407f, -0.02563838f, 0.08601593f, 0.09433987f, -0.02123355f, 0.08897085f, -0.09515768f, 0.09257687f, 
    0.03965569f, -0.01378665f, -0.01590638f, -0.04590827f, -0.30714056f, 0.15717793f, 0.08859096f, 0.26333699f, 
    -0.02871032f, 0.07346843f, 0.06401738f, 0.06049664f, -0.10918298f, 0.00548748f, -0.04839618f, 0.01075022f, 
    0.21946424f, 0.26307029f, 0.00050487f, 0.08846894f, -0.04024183f, 0.15929858f, 0.09477263f, -0.03222201f, 
    -0.00008765f, 0.08938358f, -0.01137271f, 0.17125320f, 0.27189863f, 0.24776763f, -0.08955532f, 0.06656062f, 
    0.02588679f, 0.03681776f, 0.00828461f, -0.00943443f, -0.18132527f, 0.00726496f, -0.00296614f, 0.04064809f, 
    0.18589823f, -0.13099192f, -0.04550834f, -0.25176468f, -0.15733081f, -0.05794653f, -0.08181567f, -0.02377924f, 
    0.07621774f, 0.00302246f, 0.02035636f, -0.01174894f, -0.02090904f, -0.04295097f, 0.02463708f, -0.13146935f, 
    0.03923910f, -0.01236263f, 0.00643435f, 0.04361502f, -0.09348544f, 0.01430640f, 0.00391655f, 0.02444429f, 
    -0.41329339f, 0.07650665f, 0.08453979f, 0.02737580f, 0.08595122f, 0.06695021f, 0.07666238f, 0.00906538f, 
    -0.07092435f, -0.15470140f, 0.12533885f, 0.00015308f, -0.23279867f, -0.04046329f, -0.09927953f, -0.13030756f, 
    -0.03232313f, 0.07956485f, 0.08206514f, 0.03912496f, 0.00473650f, 0.08807375f, -0.04584209f, 0.06409217f, 
    -0.09193692f, -0.06231468f, -0.00915851f, -0.09966129f, -0.01509231f, 0.01932627f, 0.04735519f, 0.01629647f, 
    0.02256119f, -0.01678770f, 0.10978464f, -0.02312124f, -0.10928696f, -0.14922965f, -0.04926142f, -0.20376545f, 
    -0.01657343f, -0.03439654f, -0.02630737f, 0.02114106f, 0.06592482f, 0.06526430f, 0.01127619f, 0.06823042f, 
    0.34587416f, -0.03172289f, -0.04851498f, 0.12950905f, 0.04385316f, -0.02343227f, -0.01797974f, 0.10367141f, 
    0.13165663f, 0.09385813f, -0.05673814f, -0.01862190f, -0.03575592f, -0.07484418f, -0.02353269f, -0.03361256f, 
    0.03252970f, -0.03121922f, 0.11580141f, -0.00037657f, 0.03176083f, -0.01521980f, 0.05218253f, 0.07647406f, 
    0.19031674f, -0.14538556f, -0.00260376f, -0.10892235f, 0.02054773f, 0.08989133f, -0.01061177f, -0.08815058f, 
    -0.09722881f, 0.04482131f, -0.08333631f, 0.12922126f, -0.06294809f, -0.04652357f, -0.00980535f, -0.11486437f, 
    0.00182218f, -0.09924964f, 0.05863221f, 0.03654597f, 0.08090117f, 0.01746110f, -0.00081643f, 0.02961169f, 
    0.29439992f, 0.01144641f, -0.03454746f, -0.20577994f, -0.03034711f, -0.04289491f, 0.00474321f, 0.09600075f, 
    0.05765159f, 0.00977719f, 0.14293157f, 0.03546102f, 0.25380227f, 0.31962839f, 0.16791292f, 0.03322538f, 
    0.08391556f, 0.18199055f, -0.01498025f, 0.02312925f, -0.03219717f, -0.09410264f, 0.08723933f, -0.06309262f, 
    0.18174404f, 0.05326476f, -0.09033147f, 0.04458868f, -0.01152528f, -0.04919598f, -0.01219556f, 0.00755529f, 
    0.07649449f, 0.13009472f, 0.11372092f, -0.02015178f, -0.16818573f, -0.00326277f, 0.15759365f, -0.08576135f, 
    -0.04291318f, 0.05794700f, 0.10276660f, 0.02702676f, -0.03387784f, -0.03587033f, 0.10253853f, 0.08741400f, 
    0.01317434f, 0.01420779f, 0.09801871f, 0.03830900f, 0.07697512f, -0.00892953f, 0.01392056f, 0.02435079f, 
    0.11826307f, -0.19257066f, -0.04470223f, 0.11117081f, 0.51255935f, 0.01370117f, -0.02171088f, 0.11599513f, 
    0.07242353f, -0.00702863f, -0.12916496f, 0.03077311f, 0.04976738f, -0.06767832f, 0.03501298f, -0.09234218f, 
    -0.04088628f, 0.05958553f, 0.10491779f, -0.06319087f, -0.03858015f, 0.08844685f, 0.00843984f, 0.06315225f, 
    -0.01563598f, 0.06424752f, 0.06658968f, -0.04663150f, -0.18249005f, -0.05472320f, 0.24816439f, 0.16556799f, 
    0.01567471f, 0.01175331f, 0.04565833f, 0.12231167f, 0.07887386f, 0.07004257f, 0.03631588f, -0.03798546f, 
    -0.05793875f, 0.05108080f, 0.03675986f, -0.20264700f, 0.11357496f, -0.00098480f, -0.03270706f, -0.00724113f, 
    0.09693824f, -0.02256575f, -0.05904710f, 0.01823100f, -0.13505295f, 0.13797159f, 0.04524778f, -0.04712555f, 
    0.01382825f, 0.05754723f, 0.00351849f, 0.08597853f, 0.05413216f, 0.08214436f, -0.05337247f, 0.05034033f, 
    -0.13840979f, 0.01544825f, 0.04871691f, 0.05445684f, 0.01563094f, 0.00009512f, 0.11698300f, 0.14027546f, 
    -0.04464637f, -0.09724504f, 0.03197475f, -0.03916286f, -0.10984600f, 0.18183203f, -0.04165307f, -0.03260259f, 
    0.04804330f, 0.10834192f, 0.12198021f, 0.05662391f, -0.07828563f, 0.04335732f, -0.07500448f, -0.00548065f, 
    -0.24624699f, 0.17390457f, 0.04266002f, 0.13635799f, -0.03272706f, 0.06402230f, 0.08386102f, 0.09144123f, 
    0.09150341f, 0.10002852f, 0.00993561f, 0.05025044f, 0.43149599f, -0.10944867f, 0.07300940f, 0.02010903f, 
    0.01397542f, -0.00787725f, -0.04495812f, 0.14327361f, 0.01920805f, 0.12183737f, 0.10345959f, 0.04109877f, 
    0.33009455f, -0.01286520f, 0.07953550f, 0.08173478f, 0.10406461f, 0.11138649f, 0.01526093f, 0.02050382f, 
    0.08574002f, 0.02689491f, -0.13160570f, 0.08740541f, -0.12756565f, 0.02723034f, 0.07518750f, 0.05895237f, 
    0.08512219f, 0.19753265f, -0.02952420f, -0.01828906f, 0.00766752f, 0.12398934f, -0.05462329f, -0.09646661f, 
    -0.33261782f, 0.15333091f, 0.12073156f, 0.07548171f, -0.02738024f, 0.07839063f, 0.01189471f, -0.01774099f, 
    0.02316461f, 0.23918851f, -0.06165317f, 0.02363782f, -0.13793471f, -0.03498423f, 0.08287901f, 0.01589549f, 
    -0.03359129f, 0.01681980f, -0.00616666f, -0.02129636f, 0.03147732f, 0.10701830f, 0.01745542f, 0.00407552f, 
    0.03660575f, -0.00677820f, 0.00988073f, 0.01458811f, -0.16928151f, -0.03299890f, -0.13082853f, -0.03796748f, 
    0.13215609f, 0.09037787f, 0.12446340f, 0.11726303f, -0.10676837f, 0.03085894f, 0.31599361f, 0.04730988f, 
    0.01303100f, -0.11598378f, 0.11783772f, -0.09752596f, -0.00061324f, 0.10140052f, 0.07075262f, -0.00928354f, 
    -0.10851193f, -0.13754833f, -0.01941995f, -0.10562672f, -0.17384984f, -0.04539346f, 0.05813828f, 0.02109450f, 
    0.07316121f, 0.05521605f, 0.07149520f, -0.01445690f, 0.04516323f, 0.13677011f, 0.00172494f, 0.02553221f, 
    0.19534285f, 0.05657569f, 0.24797228f, 0.00309132f, -0.02898530f, 0.02442181f, 0.01263240f, -0.00021330f, 
    0.25653613f, -0.00624976f, -0.06262239f, -0.10441384f, 0.02170070f, 0.10553719f, 0.12461793f, -0.00800785f, 
    -0.06242313f, -0.06243978f, 0.13925509f, -0.12809914f, -0.27986154f, -0.15403154f, -0.05069881f, -0.28740236f, 
    -0.02233706f, -0.05695919f, -0.03905526f, 0.05783897f, 0.00180970f, 0.15961887f, -0.11491877f, 0.02253623f, 
    -0.07085151f, 0.08871888f, -0.06957056f, -0.00249252f, 0.06194047f, 0.03964470f, 0.00619122f, 0.02759101f, 
    -0.01032765f, 0.06916177f, 0.05700393f, -0.15188076f, -0.33106697f, 0.10190226f, 0.00020475f, 0.13470723f, 
    0.07873302f, 0.12184644f, -0.05174851f, 0.05450806f, -0.07413241f, 0.00848126f, 0.07124516f, -0.19604881f, 
    -0.12164886f, 0.06443699f, -0.00885501f, -0.02599961f, 0.06033253f, 0.00322552f, 0.05778616f, 0.03733597f, 
    0.20247717f, -0.05608349f, 0.03102519f, -0.00257813f, -0.00250589f, 0.01628231f, -0.14273329f, 0.03256638f, 
    0.05404010f, 0.03573115f, 0.03451421f, 0.01481745f, 0.07089521f, 0.07760292f, 0.14526540f, -0.11558027f, 
    -0.08844835f, -0.02326501f, 0.04446109f, -0.15708601f, -0.03471531f, 0.03503073f, -0.03023620f, -0.06386849f, 
    0.10393178f, 0.04760351f, 0.03163100f, 0.08789573f, 0.10589873f, 0.00097986f, -0.06194695f, -0.05223997f, 
    0.07772595f, -0.04830230f, 0.01776214f, -0.02798642f, -0.05546897f, 0.05869723f, 0.08491500f, 0.03629004f, 
    -0.03394291f, 0.08200535f, 0.13338302f, 0.14135593f, -0.01511507f, 0.06568443f, 0.08380979f, 0.09541894f, 
    0.09338773f, 0.13829361f, -0.03113156f, 0.08573412f, 0.15116750f, 0.12699777f, -0.02902368f, -0.08410086f, 
    -0.05943705f, 0.09147748f, 0.00906915f, -0.04084808f, -0.04779376f, -0.01667995f, 0.04083684f, 0.16239142f, 
    0.01719457f, -0.04916345f, -0.16588543f, 0.05172842f, 0.04101053f, 0.09740488f, 0.02612078f, -0.02202156f, 
    0.09752452f, -0.08248390f, 0.01229684f, -0.12451010f, -0.04592807f, 0.16733809f, 0.05293205f, 0.05910401f, 
    -0.05445866f, -0.00006216f, 0.14894423f, -0.19164495f, 0.00316125f, 0.09001735f, 0.02669053f, 0.21292940f, 
    -0.15259057f, -0.13107146f, -0.04760168f, -0.01250560f, 0.01412228f, -0.00533460f, 0.03840845f, 0.00998396f, 
    0.07175944f, 0.19879280f, 0.01298945f, 0.04428355f, 0.22789969f, 0.07778373f, -0.10809159f, -0.06320723f, 
    0.00957456f, 0.06044667f, -0.00780421f, 0.01361309f, -0.00511371f, 0.09144983f, 0.13296773f, 0.11519407f, 
    0.00383666f, -0.20078926f, 0.07376862f, 0.09545791f, 0.07732347f, -0.08570195f, 0.00954929f, -0.10385530f, 
    -0.04532668f, 0.11893256f, -0.08938666f, 0.16414024f, -0.14326952f, -0.08755986f, -0.00462152f, 0.01783893f, 
    -0.02836315f, 0.06393468f, 0.14382082f, -0.04069054f, 0.15425757f, -0.11552437f, 0.08421648f, -0.00538930f, 
    0.17601672f, -0.02151341f, -0.06003588f, 0.05639191f, 0.00232280f, -0.01352354f, -0.15054029f, 0.03343628f, 
    0.09375428f, -0.07474156f, -0.04894674f, -0.09850664f, 0.21821733f, -0.15033579f, -0.01689246f, 0.07133792f, 
    0.01426745f, -0.04900702f, -0.04560719f, -0.04790256f, 0.00075351f, -0.07442439f, -0.00316719f, -0.01061947f, 
    0.14457521f, 0.02614446f, -0.20546897f, -0.04751810f, 0.14088657f, 0.08480500f, -0.01296628f, 0.16489236f, 
    0.10084895f, 0.03011216f, 0.10307804f, 0.11147644f, 0.19015642f, 0.05921794f, 0.10489120f, -0.08378282f, 
    0.01341745f, 0.08150124f, 0.03693108f, -0.07239375f, -0.00870460f, -0.10524299f, -0.01587549f, -0.00480710f, 
    -0.18222885f, -0.03053123f, 0.15834908f, -0.28020003f, 0.06508084f, -0.02344986f, -0.04992720f, -0.13381182f, 
    0.03852096f, -0.05877963f, 0.12892745f, 0.02322380f, 0.25315994f, -0.06547423f, -0.16610612f, -0.01083437f, 
    -0.07049258f, -0.02814073f, -0.01110706f, 0.08051082f, 0.02495221f, -0.02071340f, -0.08242629f, -0.01096465f, 
    -0.12826140f, 0.05614091f, 0.17698610f, -0.22916897f, 0.04797648f, 0.01489139f, -0.00136429f, 0.06191221f, 
    0.13061853f, 0.00959258f, 0.14930660f, 0.00720085f, 0.00511872f, 0.03252830f, -0.03598147f, 0.14211887f, 
    0.04193752f, 0.13098316f, -0.09078038f, 0.14231445f, 0.00827215f, 0.15427734f, 0.17802338f, 0.11866152f, 
    -0.08399549f, -0.00160878f, -0.14448622f, -0.03037762f, 0.09078519f, 0.11871990f, 0.06768222f, 0.14367738f, 
    0.00772878f, 0.08612619f, 0.13164112f, 0.02089108f, -0.09054034f, -0.07862176f, 0.08816183f, -0.03279071f, 
    0.07718788f, 0.00953252f, 0.07103531f, -0.11786438f, -0.01391318f, 0.10329890f, 0.00991600f, 0.11929899f, 
    -0.04360856f, -0.03906485f, 0.26500413f, 0.16244446f, 0.20576845f, -0.08353924f, -0.03088293f, 0.01741575f, 
    -0.10873245f, 0.06851060f, -0.09156727f, 0.00082314f, -0.04624690f, -0.00822474f, 0.07340933f, 0.01690111f, 
    0.02541270f, -0.00386672f, -0.00674141f, -0.08080299f, 0.05449802f, 0.00937883f, 0.07006038f, -0.00813925f, 
    -0.08710770f, -0.02734414f, 0.00953780f, 0.04273450f, 0.01883977f, 0.02942047f, 0.11073451f, -0.11861359f, 
    0.01465807f, -0.03310138f, -0.05419961f, 0.00032506f, -0.25573763f, 0.12929699f, 0.14535493f, 0.07638750f, 
    0.05813864f, 0.01430519f, -0.06449001f, -0.02873575f, 0.07308247f, 0.07902166f, -0.00294857f, 0.05094840f, 
    -0.26164365f, -0.17164981f, 0.25829715f, -0.04833043f, -0.04536858f, -0.05058061f, -0.14529945f, 0.03531913f, 
    -0.04439733f, 0.05566023f, -0.14309663f, -0.18959087f, 0.13972068f, 0.18209159f, 0.00813244f, -0.08653645f, 
    0.02043468f, 0.02407800f, 0.02878615f, 0.12813793f, 0.06847893f, 0.00593556f, 0.06478000f, 0.13535681f, 
    -0.01361314f, -0.19110264f, -0.01341289f, 0.06496917f, 0.01454441f, -0.05870976f, 0.01612549f, -0.10469203f, 
    -0.06286366f, 0.08114919f, -0.01719807f, 0.17548411f, 0.13100675f, -0.07456835f, -0.04019570f, -0.01135102f, 
    0.10594457f, 0.00216554f, 0.00577497f, -0.05732008f, 0.05787742f, 0.00971396f, -0.07184147f, 0.12900811f, 
    -0.04605882f, 0.01302686f, 0.17996006f, 0.09267360f, -0.01420544f, -0.16593450f, 0.11863513f, 0.01093157f, 
    0.09151439f, 0.04420733f, 0.00205515f, 0.08103372f, -0.16401689f, 0.04355289f, 0.01117545f, 0.06000632f, 
    0.01291451f, 0.01544380f, -0.14471895f, -0.02578298f, 0.08057551f, -0.08492431f, -0.07771442f, 0.10931287f, 
    0.02210098f, -0.12484305f, -0.01992824f, 0.04903303f, -0.04142047f, -0.07792085f, 0.01174177f, 0.06231908f, 
    0.13355593f, 0.05243396f, -0.06525432f, 0.04186539f, -0.06553555f, -0.09468370f, -0.01689191f, -0.07555088f, 
    0.03913239f, 0.02441547f, -0.02737369f, -0.04748729f, -0.00527202f, 0.09920243f, -0.01740301f, 0.07383604f, 
    0.03265511f, 0.01530419f, -0.13340691f, 0.05250276f, 0.06087575f, 0.01315188f, -0.08453914f, 0.01395398f, 
    -0.08895012f, -0.12634493f, 0.00016439f, -0.00758874f, 0.01910073f, -0.17456196f, -0.05031737f, 0.03480799f, 
    -0.01277513f, 0.03484847f, -0.06823561f, -0.03046031f, -0.01945236f, -0.13032289f, 0.04184090f, -0.02600037f, 
    -0.19837728f, -0.31084839f, -0.14483768f, 0.03091086f, 0.00629262f, -0.09376900f, -0.02539327f, 0.01489966f, 
    -0.00922363f, 0.00747334f, 0.03844716f, -0.05859361f, 0.08083606f, 0.10714655f, -0.11476743f, 0.07579207f, 
    -0.00842213f, 0.08441163f, -0.10971065f, -0.00366046f, -0.03426942f, -0.08434781f, -0.06121175f, -0.06544785f, 
    -0.15098020f, -0.06556617f, -0.09839872f, -0.03076722f, -0.07255080f, 0.02415709f, 0.04971911f, -0.13636442f, 
    -0.02324767f, 0.06467786f, -0.00527526f, -0.06410810f, 0.24229892f, 0.11101060f, -0.06594343f, -0.16978590f, 
    0.00302765f, -0.14267500f, 0.01739735f, 0.04737358f, -0.00073044f, 0.03777801f, 0.00778190f, 0.24292834f, 
    0.14124703f, 0.06826998f, 0.04499890f, -0.17327574f, 0.09935453f, -0.01730813f, 0.04603077f, 0.02020621f, 
    0.07536640f, -0.15257485f, -0.06443181f, 0.07262949f, -0.11028206f, -0.06934233f, 0.34183955f, -0.07984477f, 
    0.10402148f, -0.03988849f, -0.02416161f, -0.00402042f, 0.11095501f, 0.08567862f, 0.00574665f, 0.15626535f, 
    0.02083021f, 0.18904269f, 0.08207145f, -0.25454181f, 0.06759961f, -0.00463734f, -0.13501224f, 0.08882780f, 
    -0.01949903f, 0.21681112f, 0.17362599f, 0.05624515f, -0.03874225f, -0.08619975f, 0.05042422f, 0.02418514f, 
    -0.02266767f, 0.03897883f, 0.12943438f, 0.02045811f, 0.04998143f, 0.07283460f, -0.08259530f, -0.00684157f, 
    -0.13551867f, -0.16822712f, 0.12588531f, -0.11076654f, 0.04041913f, -0.06542098f, -0.00392630f, 0.04243942f, 
    0.12485075f, -0.01952628f, 0.03586885f, 0.10389904f, -0.07619188f, -0.08266031f, -0.05003813f, 0.06146490f, 
    0.11896218f, 0.06222027f, 0.07502075f, -0.10620604f, 0.01685410f, -0.09963518f, -0.02835483f, 0.03123365f, 
    -0.26036626f, 0.00985229f, 0.15759073f, -0.05859840f, -0.02003326f, -0.00546129f, 0.11809009f, 0.04064212f, 
    0.14090833f, 0.10722938f, 0.07569609f, 0.05831340f, -0.11299721f, 0.11659917f, 0.22950919f, -0.14175661f, 
    0.06767038f, 0.03695540f, 0.03550672f, -0.04808088f, 0.13777396f, 0.08572257f, 0.09466986f, 0.05960392f, 
    -0.33422670f, 0.02995144f, 0.14213274f, 0.06336045f, 0.06054533f, -0.02577740f, 0.04596282f, -0.29927289f, 
    -0.02254075f, 0.06633414f, -0.02605168f, 0.13259411f, -0.10143694f, -0.16664551f, -0.23482375f, 0.01866901f, 
    -0.11492597f, 0.07224526f, 0.07944386f, 0.03491681f, 0.17209744f, 0.08836738f, -0.03107883f, -0.01928748f, 
    -0.26924369f, -0.06416980f, 0.15317614f, 0.14249693f, 0.06502338f, 0.07879822f, -0.00083752f, -0.19610918f, 
    0.09567561f, -0.13024217f, -0.06954203f, -0.00306572f, 0.09200621f, -0.08613287f, 0.04366452f, -0.01506917f, 
    0.09672042f, -0.01840308f, -0.07138084f, -0.04358550f, 0.03500021f, -0.08994303f, 0.00904082f, -0.07334973f, 
    -0.22118926f, -0.04955941f, 0.01827155f, -0.03817162f, -0.01938485f, 0.07472234f, 0.11895706f, -0.02170291f, 
    0.13363564f, 0.04252501f, 0.00181437f, -0.06904676f, 0.07156202f, 0.13805316f, 0.15676074f, 0.01106932f, 
    0.05428750f, 0.11978976f, -0.03110220f, 0.24797781f, 0.00154976f, -0.05128062f, 0.02408965f, 0.10799389f, 
    -0.23429550f, -0.04167407f, -0.05573789f, 0.18271191f, 0.04775888f, -0.03694777f, 0.03680668f, 0.00668491f, 
    0.15296657f, -0.06855292f, 0.12128296f, 0.02032940f, -0.21573699f, -0.10085683f, 0.01842831f, 0.10663745f, 
    0.06042947f, 0.03561029f, 0.12898958f, -0.11916405f, -0.04051356f, -0.03502974f, 0.03421326f, 0.01114952f, 
    -0.13594002f, 0.07966042f, -0.00455931f, -0.03368435f, 0.01685728f, 0.06581390f, 0.18679585f, 0.01669383f, 
    0.12107145f, -0.19532956f, -0.11030042f, -0.10657749f, -0.14656247f, -0.19215780f, 0.06996483f, -0.01510972f, 
    0.03247192f, 0.12724064f, 0.05642652f, 0.06661990f, 0.00393259f, -0.13757077f, -0.02346945f, 0.05275363f, 
    0.06964938f, -0.00793163f, -0.20585909f, 0.06696555f, 0.06278171f, 0.07896725f, -0.14500131f, -0.06317999f, 
    -0.01183123f, -0.13568774f, -0.05201679f, -0.11231541f, -0.10873810f, 0.01279818f, 0.07125703f, 0.10328486f, 
    -0.06999726f, 0.05491425f, 0.04530289f, 0.03473350f, 0.08132381f, 0.03008985f, -0.03958017f, 0.00199665f, 
    -0.16971417f, -0.00220942f, 0.07869360f, 0.08989459f, 0.07007664f, -0.11367732f, 0.04036011f, -0.00721662f, 
    0.11140202f, 0.08318793f, -0.05028746f, 0.13806504f, 0.15771949f, 0.22617117f, -0.04307613f, -0.07748739f, 
    0.03460757f, 0.04571533f, -0.05345229f, -0.00267136f, 0.07251500f, 0.07433589f, 0.02189028f, 0.10318597f, 
    -0.01666315f, 0.11388080f, 0.28666911f, 0.05800063f, 0.11314713f, 0.11831629f, 0.03207937f, 0.05589183f, 
    0.11504105f, -0.00689148f, 0.04590769f, 0.13889897f, -0.20732652f, 0.06551343f, -0.05581143f, -0.18725121f, 
    0.02238742f, -0.09917766f, 0.08436240f, -0.02778714f, 0.04257436f, 0.00513252f, -0.13561842f, 0.07090451f, 
    -0.02495211f, 0.02164311f, -0.02422761f, -0.01698477f, 0.03045735f, 0.02196870f, 0.01743949f, 0.00357246f, 
    -0.02514063f, 0.02354900f, -0.01841259f, 0.01692501f, 0.02607913f, -0.00336436f, 0.00680354f, -0.01002472f, 
    -0.01761483f, -0.02195349f, -0.02994488f, 0.03182942f, 0.01271830f, -0.02579809f, 0.00300404f, 0.01132807f, 
    -0.00042944f, -0.03831288f, 0.00828109f, 0.00565429f, -0.03485217f, 0.01383950f, 0.00880325f, -0.03315907f, 
    -0.03844102f, 0.00587815f, -0.04425414f, -0.00354804f, 0.02516239f, -0.02257898f, -0.02247342f, -0.02565404f, 
    0.02724127f, -0.01980892f, -0.01883597f, 0.02373031f, 0.00288738f, 0.01460432f, -0.00739662f, 0.01357486f, 
    0.03107798f, -0.03631417f, 0.03318485f, -0.00407194f, -0.00517935f, 0.01765990f, -0.00691495f, 0.00775566f, 
    0.01792130f, 0.02616120f, 0.01211931f, -0.02283265f, 0.00047163f, -0.01239469f, 0.01654475f, 0.02680042f, 
    -0.01129770f, -0.02094258f, -0.01398631f, -0.03032370f, -0.00553484f, -0.02080103f, -0.03485480f, 0.03849011f, 
    0.03102423f, 0.01861771f, 0.03627761f, -0.03963093f, 0.00740712f, 0.02804602f, 0.02968628f, 0.00663071f, 
    -0.03702913f, -0.01426507f, 0.01044772f, -0.02052902f, -0.03027745f, 0.00479846f, -0.00814266f, 0.02306020f, 
    0.01520130f, -0.02796062f, 0.00608254f, 0.02735587f, 0.01329653f, -0.02325453f, 0.02492274f, 0.01491059f, 
    -0.01826080f, 0.02440844f, -0.03197259f, -0.00164611f, 0.00662142f, 0.03323257f, -0.00140351f, 0.03862128f, 
    -0.00759640f, -0.03454253f, -0.01522665f, -0.02597358f, -0.03428537f, 0.02414882f, -0.00364510f, 0.03251408f, 
    0.00724066f, -0.02578269f, -0.02973254f, 0.03709305f, -0.03881313f, -0.00049975f, -0.03705801f, -0.00666476f, 
    -0.01085407f, -0.02070018f, -0.00992328f, -0.00827773f, -0.03677696f, 0.00909411f, -0.00155714f, 0.00255751f, 
    -0.01147083f, -0.00266583f, -0.02207734f, -0.01455101f, -0.02007013f, 0.01222667f, -0.01454921f, 0.02468690f, 
    0.00563667f, -0.02299587f, -0.03686259f, -0.04170969f, 0.01159311f, -0.02538455f, 0.00854384f, -0.01830520f, 
    -0.03098479f, -0.01033153f, -0.02381264f, 0.01225300f, 0.01135431f, -0.03087606f, 0.03195640f, -0.00184862f, 
    -0.02661773f, 0.02747632f, 0.00836110f, 0.00786526f, 0.02397908f, 0.00735636f, -0.02234173f, -0.03285491f, 
    0.01513062f, 0.01206350f, 0.02815226f, -0.02359779f, 0.02483663f, -0.01300706f, 0.02758676f, -0.00322636f, 
    -0.01278588f, 0.01723401f, -0.01044054f, -0.02644441f, 0.01144606f, 0.00083055f, -0.02809208f, -0.00709397f, 
    -0.03715898f, 0.01509439f, -0.03090237f, 0.00334921f, 0.01879057f, 0.00118631f, -0.03843458f, -0.01331923f, 
    -0.02433647f, 0.02755203f, -0.02264388f, -0.03122490f, -0.02821283f, -0.02443727f, -0.01372760f, -0.01658957f, 
    0.02201174f, 0.02363903f, -0.00594468f, 0.00081692f, -0.00111432f, 0.00587889f, 0.02448534f, -0.01393761f, 
    -0.00802845f, 0.00402563f, 0.01648682f, -0.01785523f, -0.01342967f, 0.02140862f, 0.01474838f, 0.01078803f, 
    -0.00858660f, -0.03694476f, -0.02544059f, -0.02342430f, 0.02139327f, -0.03188975f, -0.01313935f, 0.01613333f, 
    0.00043270f, 0.01718721f, 0.02182216f, -0.01148023f, -0.03966434f, -0.03833879f, 0.01637467f, -0.00148109f, 
    0.00644546f, -0.03943142f, -0.02499142f, 0.01515484f, 0.03066699f, 0.01731816f, 0.00313647f, 0.02317440f, 
    0.03166541f, 0.02054092f, -0.00379019f, -0.02970519f, -0.02206383f, 0.00051238f, -0.00137926f, 0.01240561f, 
    -0.02491911f, -0.01930574f, 0.03959150f, 0.01770153f, 0.00881931f, 0.00084049f, 0.01937169f, -0.00989574f, 
    -0.00704176f, 0.01306513f, 0.02906519f, -0.03029942f, -0.01036482f, -0.00673837f, 0.02651837f, 0.00081110f, 
    -0.03907061f, -0.02948174f, 0.02823372f, -0.00073732f, -0.01445169f, 0.00823314f, -0.01459913f, 0.01304847f, 
    -0.01120334f, 0.02182556f, 0.00862376f, 0.01008345f, 0.00284890f, 0.02018024f, 0.03422322f, 0.03455968f, 
    -0.03582429f, 0.02284377f, -0.02816486f, 0.01876217f, 0.01899499f, -0.00402808f, 0.00599245f, 0.02751725f, 
    0.02361058f, 0.01617000f, -0.02373097f, -0.02607488f, 0.01329770f, -0.02449208f, 0.02127712f, 0.01622227f, 
    -0.02876411f, -0.00355244f, -0.03087446f, 0.01898326f, 0.01376013f, -0.02199049f, -0.00245845f, -0.01342558f, 
    -0.00347177f, -0.02268865f, -0.02028356f, -0.02957079f, -0.02589623f, -0.00779353f, 0.02791137f, -0.03491599f, 
    -0.02814965f, -0.01437119f, -0.00502513f, -0.01587651f, 0.02748074f, -0.02731644f, -0.01482030f, -0.01226779f, 
    -0.01519423f, -0.03032088f, -0.02672216f, 0.00398059f, -0.01259694f, 0.02672422f, -0.01341223f, -0.02212528f, 
    0.00320748f, -0.03253794f, 0.00556997f, -0.03492745f, 0.01363576f, -0.00444774f, -0.04038309f, -0.03802090f, 
    0.00950446f, -0.03556613f, 0.01455322f, -0.00160510f, -0.02582416f, 0.01442633f, 0.01428183f, 0.02707084f, 
    0.00626118f, 0.00562957f, 0.02784170f, 0.01399192f, 0.00297387f, -0.03156677f, -0.03824735f, -0.02647404f, 
    -0.00772625f, 0.00284575f, -0.00683322f, -0.01747371f, -0.04394507f, 0.01446557f, 0.00164898f, 0.02385713f, 
    0.02015759f, 0.01350959f, 0.00697981f, -0.00557221f, 0.00199984f, -0.02939519f, -0.01318329f, 0.02881521f, 
    -0.00133606f, -0.00987091f, -0.03768363f, -0.00926644f, 0.02415971f, 0.01163770f, 0.02028997f, -0.00606384f, 
    -0.00914080f, -0.03183209f, 0.01156269f, 0.00359247f, -0.03810515f, -0.00419847f, 0.00108048f, -0.00387485f, 
    -0.01579706f, 0.01292475f, 0.01548845f, -0.03974114f, -0.02992150f, 0.00302800f, 0.01299626f, 0.01332027f, 
    -0.02909840f, -0.00246856f, -0.02036160f, 0.00104429f, 0.02640690f, -0.00856472f, -0.00114336f, 0.01573117f, 
    0.02252327f, -0.01538627f, 0.01512175f, 0.01475647f, -0.01258146f, 0.00072246f, 0.03078955f, 0.01335377f, 
    -0.01122574f, 0.02170059f, -0.00309642f, -0.02689484f, 0.02545742f, 0.00096726f, -0.01065054f, -0.03143947f, 
    0.00817439f, 0.02201634f, -0.02823227f, -0.01770495f, -0.00141954f, -0.02515642f, -0.00617415f, 0.02250562f, 
    0.01236378f, 0.01134377f, 0.01419448f, -0.03885575f, 0.01458022f, -0.00197636f, -0.01827025f, -0.04053391f, 
    0.03598337f, -0.03319617f, -0.01654602f, -0.00486878f, -0.03872864f, -0.00994660f, -0.02025194f, 0.03769185f, 
    -0.00179772f, 0.03382729f, -0.03433887f, -0.03483180f, 0.00176520f, -0.01508013f, 0.01071811f, 0.01804967f, 
    0.01853830f, -0.03858903f, 0.02206980f, 0.00416337f, -0.00232696f, -0.00983920f, -0.03963279f, 0.00768280f, 
    -0.01742037f, 0.00178444f, -0.00356244f, -0.03796552f, -0.02581666f, -0.01806138f, 0.00976219f, -0.03565186f, 
    -0.03179229f, 0.03065014f, 0.00306048f, 0.01049706f, 0.00794963f, -0.01510391f, -0.03023700f, -0.02812983f, 
    0.00618538f, -0.03930435f, 0.02555135f, 0.03389922f, -0.00586599f, 0.00384180f, -0.00165376f, -0.00938624f, 
    0.02763219f, -0.02781742f, -0.03408461f, 0.01228858f, 0.01357869f, 0.03155402f, -0.00106201f, 0.00043782f, 
    0.02149392f, 0.02645488f, 0.02043731f, 0.00470098f, -0.02252578f, 0.00705171f, -0.01061102f, 0.00011734f, 
    -0.02051629f, 0.00877095f, -0.00696747f, -0.01174956f, 0.00506241f, -0.04299102f, 0.02555493f, -0.03838478f, 
    0.01172746f, 0.01497173f, -0.03722627f, -0.01660297f, -0.02522826f, 0.02491938f, 0.00148764f, 0.01317357f, 
    -0.03005219f, -0.01754192f, 0.00608332f, -0.03064326f, 0.01675963f, -0.03079732f, 0.00589860f, 0.00722632f, 
    0.01826831f, 0.01898727f, 0.01931492f, 0.01655051f, -0.02055139f, 0.00196635f, -0.00626424f, -0.01734338f, 
    0.01970813f, -0.00170731f, 0.01731485f, -0.02828206f, 0.00161732f, -0.01173337f, -0.03525286f, 0.01703811f, 
    -0.02664276f, -0.00216480f, 0.01971658f, -0.03779716f, -0.02974442f, 0.00262162f, 0.00389928f, -0.01670888f, 
    0.02098672f, 0.02410899f, -0.02994909f, 0.00715196f, -0.00928829f, 0.01002251f, -0.00177813f, -0.02206256f, 
    0.00070200f, 0.03852875f, -0.04447874f, 0.02088010f, -0.01173391f, -0.00884853f, -0.03784778f, -0.02080533f, 
    -0.03563295f, -0.03484012f, -0.02045240f, 0.00999871f, 0.01132773f, 0.01916478f, 0.02909491f, 0.01296707f, 
    -0.00168608f, -0.02923981f, 0.03156058f, -0.03115941f, 0.00813085f, -0.02933859f, 0.00567644f, 0.02609290f, 
    0.01088739f, -0.00660256f, -0.00838599f, -0.02244278f, -0.02722893f, -0.00649810f, -0.01993056f, 0.00073031f, 
    0.02928639f, -0.03799673f, -0.01628104f, 0.02149141f, 0.03118377f, 0.00120682f, -0.01388169f, -0.01517367f, 
    0.02126726f, -0.03579220f, -0.01909118f, -0.00236973f, 0.03769201f, 0.00614309f, 0.02308705f, -0.00315800f, 
    0.03133297f, -0.00055278f, -0.00432319f, -0.02436110f, 0.01590939f, 0.02475012f, -0.00980223f, -0.04023479f, 
    0.01202776f, -0.02005528f, -0.02869163f, -0.01655188f, -0.01053768f, -0.03485414f, 0.02155519f, -0.02981225f, 
    -0.03594257f, 0.01287095f, -0.00168995f, 0.02407314f, -0.03759151f, -0.00128170f, -0.01347762f, -0.02586335f, 
    0.00798345f, -0.00579264f, 0.02660363f, 0.02155719f, -0.03575088f, -0.00191574f, -0.03732224f, 0.01645837f, 
    -0.00971289f, -0.03021679f, -0.02520175f, -0.00719193f, 0.00775028f, -0.00554182f, 0.00988777f, 0.01224456f, 
    0.01366459f, 0.00348728f, -0.02162557f, -0.03533471f, -0.01169219f, 0.01170528f, -0.01975580f, -0.01840019f, 
    0.02398990f, -0.01463666f, -0.02608588f, -0.00945659f, -0.01061184f, 0.03023508f, 0.00633417f, -0.02370536f, 
    -0.00706192f, 0.02437519f, 0.02367089f, -0.02055609f, -0.03129578f, 0.00559832f, 0.00157990f, -0.00486384f, 
    0.01707326f, 0.01193335f, -0.00037169f, 0.00073159f, 0.00192599f, 0.02857153f, -0.01413029f, -0.00013314f, 
    -0.02365850f, 0.00289726f, -0.03107847f, 0.00679867f, 0.02468151f, 0.00679917f, 0.00972285f, 0.02063974f, 
    -0.01743957f, -0.01206246f, 0.00305202f, -0.02644216f, -0.02662130f, 0.01415617f, 0.03021364f, -0.00514798f, 
    0.03206967f, -0.03589093f, -0.00210973f, -0.01500331f, 0.00907956f, 0.00253854f, 0.00297963f, -0.00277817f, 
    -0.04174516f, -0.00236540f, 0.00704806f, -0.00683908f, -0.03465680f, 0.00205265f, 0.03202782f, -0.01114191f, 
    0.00277976f, -0.02344106f, 0.01048237f, 0.01679557f, 0.02891085f, -0.02596843f, -0.03260250f, 0.00454992f, 
    -0.02823229f, 0.03225368f, -0.04100268f, -0.02164000f, -0.01320922f, 0.02645816f, 0.02601133f, 0.02076562f, 
    0.00286771f, -0.03068360f, -0.00110649f, -0.00112752f, -0.02125814f, -0.03580603f, 0.00143696f, 0.02614284f, 
    -0.02835741f, -0.00044665f, -0.01066537f, 0.02811724f, 0.02297678f, -0.03872959f, -0.01181909f, -0.00936098f, 
    0.00716023f, -0.00691789f, 0.00277165f, -0.00066994f, -0.03365406f, -0.00269613f, 0.00786762f, 0.02476764f, 
    -0.01699389f, -0.01089395f, -0.03729919f, 0.01673583f, -0.01330700f, -0.01686402f, 0.02048965f, 0.02064574f, 
    -0.00683640f, 0.00415280f, -0.01037076f, -0.00489722f, -0.03060970f, -0.03921195f, -0.00587544f, -0.03040621f, 
    -0.03828144f, 0.03198095f, -0.01709863f, 0.00368161f, 0.00543481f, 0.00609107f, -0.00390092f, 0.01471316f, 
    0.02046927f, -0.03455576f, 0.02144894f, 0.01854263f, 0.00109638f, -0.02518193f, 0.00689215f, -0.03434829f, 
    -0.01513400f, -0.02646098f, 0.02122678f, 0.02194204f, -0.01522970f, -0.00775664f, -0.00778708f, 0.02761087f, 
    0.01423035f, 0.00219461f, -0.02295713f, 0.02826698f, -0.01693261f, -0.00503395f, -0.00137572f, -0.02280729f, 
    -0.01423836f, -0.00876995f, 0.00349851f, 0.02573544f, 0.00886141f, 0.01044175f, -0.02171727f, 0.01435658f, 
    0.02498128f, 0.01276086f, 0.03396621f, -0.02254307f, 0.00665091f, 0.02055770f, -0.01968954f, -0.03455559f, 
    -0.03685579f, 0.01679312f, 0.01911649f, 0.01686555f, -0.02544659f, 0.03356487f, -0.01324823f, -0.03291348f, 
    -0.02408528f, 0.03268372f, 0.00375673f, -0.00610150f, -0.02450952f, -0.04055461f, -0.02066096f, -0.03603009f, 
    0.01824505f, -0.00616097f, -0.01151601f, -0.02290528f, 0.00696497f, -0.03804797f, -0.01661790f, -0.04191598f, 
    0.02211492f, -0.03816669f, -0.03012045f, 0.02647215f, 0.00918941f, -0.02474136f, -0.01406776f, 0.02564003f, 
    -0.01778438f, 0.02297931f, 0.02167548f, -0.02726628f, 0.01627132f, 0.02634552f, -0.00858475f, 0.02107931f, 
    -0.00590304f, -0.03970793f, 0.01399174f, 0.02773421f, 0.00934716f, -0.03367038f, 0.02825898f, -0.03413606f, 
    -0.03027884f, -0.03682682f, 0.02415456f, -0.03015828f, 0.01556184f, 0.01045414f, 0.01336383f, -0.02817725f, 
    -0.01187601f, -0.02045530f, 0.00506072f, -0.00277792f, -0.03211050f, 0.00003912f, -0.03155237f, -0.00359651f, 
    -0.00821718f, 0.02912646f, 0.00910045f, -0.03639368f, -0.02579443f, 0.01029082f, -0.02750581f, 0.00194205f, 
    -0.01286700f, 0.01177726f, 0.02554563f, 0.02312629f, -0.01883814f, 0.02612509f, -0.02965718f, -0.03321820f, 
    -0.00602425f, 0.01823391f, -0.00155367f, 0.01758755f, -0.02056286f, 0.02087855f, 0.00109732f, -0.01862445f, 
    0.00998496f, -0.02501312f, 0.01489499f, -0.02169731f, -0.01148841f, -0.03078291f, 0.00321394f, -0.03843495f, 
    -0.02535453f, 0.01460686f, -0.04182157f, 0.00399673f, -0.03289947f, -0.03179372f, -0.00350517f, 0.01116942f, 
    -0.02672420f, -0.03309208f, -0.00622474f, -0.01826594f, 0.02061440f, -0.03735030f, 0.00952213f, 0.02517346f, 
    0.01115081f, 0.00213168f, -0.02751299f, 0.02648398f, -0.03584715f, 0.01117518f, -0.03034559f, -0.01811062f, 
    -0.03747807f, -0.00707952f, -0.00790030f, -0.01342302f, 0.01102368f, -0.03604544f, 0.02217373f, 0.00041870f, 
    0.00343646f, -0.02091715f, 0.00357837f, 0.02415835f, 0.01490246f, 0.00914741f, -0.02081191f, -0.03430957f, 
    -0.03595357f, -0.03430285f, -0.00703124f, 0.01022005f, -0.01536094f, 0.02033244f, -0.00089291f, 0.00306751f, 
    -0.01770540f, 0.01488939f, 0.00881654f, -0.01852342f, 0.00941583f, -0.02474862f, 0.02500222f, -0.02713694f, 
    -0.03898681f, -0.00358269f, -0.03603616f, 0.00272315f, 0.01680232f, -0.02610206f, 0.00911295f, -0.01996356f, 
    -0.00145920f, 0.00161601f, -0.00401222f, -0.02131200f, -0.02061821f, -0.02643822f, -0.00282957f, -0.03643305f, 
    -0.04288844f, -0.03541299f, 0.00103515f, 0.00295924f, 0.01846556f, 0.01811368f, 0.01592915f, 0.02266791f, 
    -0.01844530f, -0.03839763f, -0.02310648f, -0.02096429f, 0.00137195f, -0.03274645f, -0.03104419f, -0.04036147f, 
    0.00419022f, 0.00758409f, 0.02666639f, -0.01873412f, 0.00611888f, 0.02931126f, -0.00530108f, -0.00024685f, 
    -0.01928778f, -0.03164028f, 0.00880572f, -0.01361010f, 0.03008814f, -0.00520534f, -0.00728564f, -0.00533641f, 
    -0.03340355f, 0.00316366f, 0.02754103f, 0.01196819f, -0.03806448f, -0.00039643f, -0.03906624f, -0.02335595f, 
    -0.03168464f, -0.01554094f, -0.04046949f, -0.02445916f, 0.01906423f, 0.02358151f, 0.00675465f, -0.03443342f, 
    -0.01284510f, 0.00356017f, -0.02306682f, -0.03214118f, 0.02065243f, -0.02687119f, -0.01423631f, -0.04010504f, 
    0.02138443f, -0.01575484f, -0.02590569f, 0.00862964f, -0.04115256f, 0.01922377f, -0.03215734f, 0.00043203f, 
    -0.03495093f, 0.00217871f, -0.00585413f, 0.01636190f, 0.00925984f, 0.00258109f, 0.01738760f, -0.03262754f, 
    -0.02008882f, -0.01921995f, -0.02734795f, -0.02223701f, 0.00122917f, 0.01345721f, -0.03519926f, -0.02884464f, 
    0.01827381f, 0.01308289f, -0.00677540f, 0.02756478f, 0.00492619f, -0.01475927f, 0.01127386f, 0.01168214f, 
    -0.02108940f, 0.02417274f, -0.02040210f, 0.01479851f, 0.00109586f, -0.01809289f, -0.04261316f, -0.01300525f, 
    0.01047390f, 0.00557469f, -0.00064907f, -0.03384921f, 0.01012676f, -0.00927639f, 0.00909181f, 0.01078085f, 
    0.00607427f, 0.01109124f, -0.04149928f, 0.02731503f, 0.01702868f, -0.04141675f, -0.03975948f, -0.01960263f, 
    -0.00110365f, -0.00475956f, -0.04381771f, -0.02280078f, 0.00736098f, -0.03532740f, 0.00361449f, 0.00194875f, 
    0.01589416f, -0.02855919f, -0.01063738f, -0.03819460f, -0.01341016f, 0.02738298f, -0.02526962f, -0.01997425f, 
    -0.03444830f, 0.00564245f, 0.00326108f, 0.02077679f, 0.00172648f, 0.01189868f, -0.02425423f, -0.00165351f, 
    -0.03072328f, 0.00700481f, 0.02453032f, -0.04217894f, -0.01919785f, -0.04123988f, 0.00772173f, -0.02951170f, 
    -0.03961076f, -0.00289573f, 0.02061844f, 0.01764167f, 0.00532290f, -0.01401023f, 0.02016788f, 0.03640287f, 
    -0.01266186f, -0.03015941f, 0.01852752f, -0.00094621f, 0.02519551f, -0.00472732f, -0.00148626f, -0.03589412f, 
    0.02095547f, -0.03052081f, 0.02007271f, 0.02403811f, -0.02273001f, -0.03673886f, -0.00969037f, -0.03104173f, 
    -0.03056945f, -0.03323960f, -0.03161208f, 0.01015527f, -0.01886322f, 0.02035264f, -0.00668721f, -0.00994044f, 
    0.01669697f, -0.03798138f, 0.02616595f, -0.01317026f, 0.00129097f, -0.03599175f, -0.00151887f, -0.03926879f, 
    0.01544614f, 0.02054774f, -0.03287238f, -0.03000227f, -0.00392270f, 0.00816930f, 0.00605519f, -0.00033286f, 
    -0.02760384f, -0.01360833f, -0.03466301f, 0.00143601f, -0.01102358f, 0.02909971f, -0.03190413f, -0.03904976f, 
    0.01099745f, 0.02855294f, -0.00613381f, -0.01646798f, -0.02818287f, -0.01054316f, -0.00234654f, 0.00778669f, 
    0.01465188f, -0.02245584f, -0.01512605f, -0.01983569f, -0.00527133f, 0.01472316f, -0.02182296f, -0.02257522f, 
    0.02261440f, 0.00752573f, -0.02042271f, 0.00898183f, 0.01953918f, 0.01195552f, -0.03217741f, 0.02622204f, 
    -0.02976749f, -0.02856659f, -0.03107543f, 0.02330650f, 0.01386682f, 0.00991720f, -0.01637395f, -0.00245358f, 
    -0.02600268f, -0.02003271f, -0.02759651f, -0.04244509f, -0.02615139f, 0.00096892f, -0.01856943f, -0.00517167f, 
    -0.02642826f, 0.02348869f, -0.02280031f, -0.03015520f, 0.00458874f, 0.02322090f, 0.00030799f, -0.02833593f, 
    0.02144500f, -0.02437013f, 0.01777054f, 0.01848328f, 0.00944430f, -0.01624509f, 0.01241491f, -0.01039110f, 
    0.01557487f, 0.01041960f, 0.01306421f, 0.02650598f, -0.02978498f, 0.01914276f, -0.04186847f, 0.01514448f, 
    -0.02313160f, -0.02937927f, 0.01431531f, -0.01280243f, 0.00828066f, 0.00095052f, 0.00153176f, -0.02635682f, 
    0.01014805f, -0.04126754f, -0.01639612f, -0.02137042f, -0.03341109f, 0.02743359f, 0.01599083f, 0.00436388f, 
    0.02683331f, -0.01061928f, 0.00489766f, -0.02256575f, -0.03514826f, 0.00570900f, 0.01422071f, -0.00147061f, 
    -0.01970249f, -0.03701212f, 0.01635528f, -0.01689375f, -0.03535185f, -0.02290348f, 0.02431421f, 0.01366012f, 
    -0.00697346f, 0.02044307f, 0.00005726f, 0.01845454f, -0.03244006f, -0.00029358f, -0.02485804f, 0.01510863f, 
    -0.01782134f, 0.02291255f, 0.01786241f, -0.03561010f, -0.01771729f, -0.01792022f, 0.01962238f, -0.02480805f, 
    -0.00063047f, 0.02435279f, 0.00356989f, 0.00359953f, -0.00556667f, -0.02320642f, -0.02050357f, -0.02569819f, 
    -0.03682042f, -0.01678154f, -0.01042806f, -0.02067317f, -0.02534303f, -0.00375647f, -0.03411269f, 0.02923894f, 
    0.01115789f, -0.02246561f, 0.00451990f, -0.00763988f, -0.03659658f, -0.03048120f, 0.02054863f, 0.00138093f, 
    -0.02151905f, -0.02380399f, 0.00617577f, -0.02808161f, -0.02173045f, -0.01303917f, -0.01341135f, -0.00865799f, 
    0.02479742f, -0.03204348f, 0.01985887f, -0.00116702f, 0.00998846f, -0.02824353f, -0.02712899f, -0.03347606f, 
    -0.01830676f, 0.01973384f, -0.04378482f, -0.00629742f, -0.01311427f, -0.02130100f, -0.03988761f, 0.00986640f, 
    0.03789276f, -0.02376468f, -0.01387687f, -0.01002981f, -0.04255465f, 0.02725955f, 0.02758294f, -0.01014870f, 
    -0.04033188f, 0.01060668f, -0.03066149f, 0.01698575f, -0.02707293f, -0.03493222f, -0.03766590f, -0.00717154f, 
    -0.01734734f, -0.02332003f, -0.01115147f, 0.02464651f, -0.01490912f, -0.00250358f, 0.00315517f, 0.02441286f, 
    0.01932194f, 0.02751946f, 0.00821155f, -0.01915956f, -0.02028756f, 0.02058996f, -0.00302934f, 0.01107170f, 
    -0.04285076f, -0.00087612f, -0.00454045f, 0.02994173f, -0.01014871f, 0.03430278f, -0.00593661f, -0.01627539f, 
    -0.03146083f, 0.01360722f, 0.01323494f, -0.03398105f, 0.01642322f, 0.02738800f, -0.01242725f, -0.04211344f, 
    -0.04071278f, -0.02305169f, 0.02768729f, -0.03195327f, -0.00981633f, -0.01895554f, -0.01886577f, 0.02620685f, 
    -0.00420340f, -0.00554598f, -0.01398181f, 0.02652439f, 0.00494092f, -0.00450044f, -0.01125582f, 0.00981944f, 
    -0.02684763f, 0.00814070f, -0.00347629f, 0.02896892f, 0.01416899f, -0.02200863f, -0.03218195f, -0.01756276f, 
    0.02150453f, -0.02818141f, 0.00004009f, 0.02023340f, 0.02659174f, 0.02653717f, -0.04267837f, -0.00839252f, 
    0.01369551f, 0.00230451f, 0.01676940f, -0.01771164f, -0.02607704f, -0.04145596f, 0.02313839f, -0.03677768f, 
    -0.02368088f, -0.03270801f, -0.01640856f, 0.00619604f, 0.02483591f, -0.00044046f, 0.02853816f, -0.03087594f, 
    0.00312389f, -0.01766545f, 0.02701528f, 0.01795820f, -0.03338992f, -0.02184424f, 0.00590051f, 0.00682673f, 
    0.00729346f, 0.02728263f, 0.02163235f, -0.01780218f, 0.00977264f, 0.02533716f, 0.01524230f, 0.02635028f, 
    -0.02557651f, -0.03408836f, -0.04179414f, 0.02061721f, -0.00393881f, 0.01098330f, -0.02303344f, -0.01972369f, 
    -0.02956709f, 0.01067743f, 0.01868046f, -0.03659465f, -0.01684687f, -0.00043152f, 0.00022235f, -0.01534447f, 
    0.00007872f, -0.04210003f, 0.00186940f, -0.01335959f, -0.02296414f, 0.01177268f, -0.00585735f, -0.02621003f, 
    -0.01808027f, -0.00153532f, 0.02378878f, 0.00705824f, -0.04361993f, -0.00688539f, -0.04158917f, -0.02143934f, 
    -0.00344584f, 0.01124950f, -0.03872966f, 0.02406504f, 0.02277412f, 0.00807338f, 0.01352278f, -0.02643473f, 
    0.00082897f, 0.00490353f, 0.00769651f, 0.00639606f, 0.00215689f, -0.01233576f, -0.00460670f, -0.04192455f, 
    -0.02817120f, -0.02920414f, -0.02883227f, -0.00170553f, -0.03755118f, -0.04290862f, -0.03373065f, 0.03777937f, 
    0.01596879f, -0.02879684f, -0.02282212f, -0.03394895f, 0.00315471f, -0.01381559f, 0.02194384f, 0.03259189f, 
    -0.02907401f, 0.02497263f, -0.03627295f, -0.02155460f, -0.04100214f, 0.02659480f, 0.01308323f, -0.01084527f, 
    -0.01869636f, -0.02174164f, 0.01193307f, -0.03885350f, -0.02221988f, -0.00824593f, -0.00179103f, 0.01259338f, 
    0.01410528f, 0.01101129f, -0.00611017f, 0.02884305f, -0.03591295f, 0.02174316f, 0.01256050f, -0.04232856f, 
    -0.03209144f, 0.01654578f, 0.02347778f, 0.00507671f, 0.01250623f, 0.02387124f, 0.02813368f, -0.01327878f, 
    0.06711425f, 0.21667795f, 0.07881977f, 0.07275289f, 0.08354479f, -0.05465629f, 0.05913349f, -0.01796777f, 
    -0.04705077f, 0.04411447f, 0.04164082f, -0.03073463f, -0.19091323f, -0.04622481f, 0.09767831f, 0.12788789f, 
    0.05990281f, 0.01750606f, 0.03582218f, 0.07135604f, 0.12470704f, 0.01448350f, 0.01976013f, 0.05288454f, 
    -0.20115352f, 0.30798581f, -0.04691033f, -0.26740843f, 0.14121829f, -0.05928367f, 0.04087315f, 0.03642971f, 
    -0.09057254f, -0.02792964f, 0.11041252f, -0.00559232f, -0.15985370f, 0.22640270f, -0.14754370f, 0.01030005f, 
    0.02083704f, 0.07727448f, 0.00776028f, -0.01376618f, -0.04116196f, -0.02701290f, -0.10745058f, 0.09316741f, 
    -0.00989142f, 0.02536044f, 0.11877240f, -0.20760983f, -0.00721135f, 0.01686515f, 0.03354971f, -0.00068194f, 
    0.00435892f, -0.04245659f, -0.02609298f, -0.01219570f, -0.18968566f, -0.05566902f, -0.07159204f, 0.20026682f, 
    -0.11336806f, -0.07406737f, 0.03549596f, -0.03761250f, -0.03552334f, -0.04595095f, -0.00023805f, -0.01479055f, 
    -0.03117857f, -0.09772868f, -0.07785664f, 0.05330957f, 0.03689420f, 0.12331149f, 0.08132543f, -0.03712175f, 
    -0.00996226f, -0.00448485f, 0.05476707f, -0.00703001f, -0.03996706f, -0.08564249f, 0.06196525f, 0.22383316f, 
    0.00831755f, 0.11237393f, 0.02424749f, -0.03054046f, -0.11972034f, 0.01875301f, 0.05583337f, 0.01836612f, 
    -0.21255934f, -0.20629381f, -0.01925523f, 0.21855804f, -0.11440583f, -0.09062336f, -0.09185231f, 0.00966228f, 
    0.00780131f, -0.05139394f, -0.05436829f, 0.09395290f, -0.24942824f, 0.02557647f, 0.01767731f, -0.05855009f, 
    -0.09196033f, -0.13453576f, 0.01746725f, -0.06413866f, 0.00938360f, 0.02807629f, 0.02091060f, 0.09733047f, 
    0.07625403f, -0.12557349f, 0.07345024f, 0.32491326f, -0.01970470f, -0.01712603f, -0.15171197f, 0.01439344f, 
    0.01242231f, 0.00644741f, 0.00246545f, -0.04130017f, -0.05477870f, 0.14645444f, -0.05257095f, 0.08040743f, 
    -0.06852590f, -0.01401982f, 0.06584960f, -0.16285226f, -0.01787261f, 0.11814770f, -0.09502709f, -0.01133355f, 
    -0.08705197f, 0.06186661f, 0.08248968f, -0.04312034f, 0.04170070f, 0.17598982f, 0.03542719f, -0.01649488f, 
    -0.08506937f, 0.06387947f, 0.06370503f, 0.03697866f, 0.05706018f, -0.15973578f, -0.09796386f, 0.00286485f, 
    0.05360860f, 0.06133555f, 0.04942026f, 0.05334675f, -0.09835842f, 0.09425028f, 0.03704873f, -0.00133269f, 
    0.26416361f, -0.23891211f, -0.03738483f, 0.01335345f, -0.04066502f, -0.07843163f, 0.08396409f, -0.01606521f, 
    0.12796557f, 0.06157858f, 0.12790357f, 0.00810819f, -0.15417738f, 0.10702408f, -0.04411593f, -0.15158942f, 
    0.15921600f, -0.00760506f, 0.06215702f, 0.03420226f, 0.01353237f, 0.08673424f, -0.02957500f, -0.05951535f, 
    -0.09698132f, 0.26498166f, 0.04932219f, -0.36216220f, 0.05404098f, -0.00077545f, -0.00203794f, 0.01408604f, 
    -0.05547911f, 0.00953523f, 0.00284288f, 0.09278362f, -0.07763006f, -0.05058930f, 0.00882349f, 0.17274626f, 
    0.12373286f, 0.05323064f, -0.04016946f, 0.05614278f, 0.00277636f, 0.01207037f, 0.11425578f, -0.02277457f, 
    -0.00019348f, 0.32377106f, -0.17792828f, -0.16353860f, 0.19003864f, 0.11753209f, 0.00023063f, -0.03267467f, 
    -0.03809201f, 0.04648796f, -0.05187589f, 0.07849731f, 0.16525538f, -0.09829862f, -0.02553223f, -0.10522094f, 
    -0.00661062f, -0.07421959f, -0.07788502f, -0.06168981f, 0.03738246f, -0.01330688f, 0.02876945f, -0.08726230f, 
    -0.37570763f, 0.02920246f, 0.01264148f, 0.09299069f, 0.07365876f, -0.03461120f, -0.06135419f, 0.02822940f, 
    -0.09401903f, -0.01937753f, -0.00500035f, -0.06969696f, -0.21968243f, -0.03682566f, 0.02988479f, 0.24430878f, 
    0.16448624f, 0.00096570f, -0.11800768f, 0.02855766f, -0.05376282f, 0.05085843f, -0.06475829f, -0.11879085f, 
    0.16119835f, 0.06185527f, 0.01865678f, 0.22194400f, -0.05698684f, -0.00341740f, 0.04404472f, -0.11543322f, 
    0.03706348f, 0.14855742f, 0.01266213f, 0.03900423f, -0.24125037f, 0.28484899f, 0.07391093f, 0.11321171f, 
    -0.06404394f, 0.05860763f, -0.03512489f, -0.07031047f, 0.05226032f, -0.00269172f, 0.01136348f, -0.06035557f, 
    0.10710070f, -0.07349231f, 0.09089187f, 0.08148711f, 0.05344398f, -0.02172365f, 0.02299384f, 0.15927607f, 
    -0.07893558f, 0.09827683f, 0.00129781f, 0.02776083f, 0.53949076f, -0.14686871f, 0.20560829f, -0.25278857f, 
    0.00066086f, 0.10632358f, 0.01293122f, 0.00831953f, 0.11656462f, -0.06413903f, 0.01826403f, 0.02542264f, 
    -0.12003715f, -0.19321932f, 0.15695490f, -0.22370215f, -0.01328607f, 0.01901912f, 0.10358942f, -0.03958695f, 
    0.02097393f, -0.12540931f, -0.04019124f, 0.08875854f, -0.13033354f, -0.03090727f, 0.07983979f, -0.17962159f, 
    -0.11972197f, 0.03493403f, -0.07113636f, 0.01399027f, 0.21592395f, -0.00654579f, -0.00695066f, -0.09061853f, 
    -0.13801819f, -0.03457843f, 0.01818596f, 0.24164234f, 0.18481547f, 0.06773999f, 0.08173474f, 0.06406647f, 
    0.00656197f, -0.00501783f, 0.07648735f, -0.20120755f, -0.14051859f, 0.12036727f, 0.08463541f, -0.26758638f, 
    0.10230158f, 0.09677027f, 0.05406060f, 0.07368336f, 0.03164631f, -0.02308336f, -0.05953890f, -0.04610419f, 
    0.30117103f, 0.13291660f, -0.07963415f, 0.06261655f, 0.13386026f, 0.06450173f, -0.07199083f, -0.05876429f, 
    0.10711603f, 0.07780867f, 0.05251845f, -0.01072095f, -0.02824705f, 0.17502138f, 0.16535293f, -0.11990555f, 
    0.08849769f, -0.02885492f, 0.06437919f, -0.05256610f, 0.04671704f, 0.05247862f, 0.00750262f, -0.00732731f, 
    -0.11254307f, 0.21310101f, 0.03059257f, 0.21823573f, 0.12995213f, -0.11136276f, -0.13269755f, 0.11717706f, 
    -0.02701250f, 0.03756237f, 0.05361842f, 0.00963198f, 0.12864158f, 0.07905737f, -0.05713505f, 0.31337595f, 
    -0.03403756f, 0.06304888f, -0.09278557f, -0.00829063f, 0.05381616f, -0.14680670f, -0.02544166f, 0.00169824f, 
    -0.09332528f, 0.06254378f, 0.03127085f, -0.18409444f, -0.03898876f, 0.04455101f, 0.14315571f, 0.02761752f, 
    0.11423238f, 0.14587212f, 0.00762007f, 0.09065303f, 0.00063125f, 0.06688149f, 0.01930004f, 0.23640761f, 
    -0.04868950f, 0.06088636f, 0.06933703f, 0.01464003f, -0.09783758f, 0.08736446f, -0.01876621f, 0.02568542f, 
    -0.00590190f, -0.15330920f, 0.19527428f, 0.03212956f, 0.02326127f, 0.08391353f, 0.04689630f, 0.05953405f, 
    -0.09177812f, -0.00208095f, 0.04186964f, 0.01197151f, 0.40002173f, -0.31056195f, 0.16282147f, 0.06465305f, 
    0.02155017f, 0.01917784f, 0.10683722f, 0.00327746f, -0.03763004f, 0.06741872f, 0.10499977f, 0.02193571f, 
    -0.12281163f, -0.18550353f, 0.07313976f, 0.21834420f, 0.09843256f, 0.05606864f, 0.06241621f, 0.03282484f, 
    0.06681806f, -0.02550616f, -0.04913168f, 0.04182298f, -0.01200167f, -0.16339779f, -0.00851891f, -0.02968270f, 
    -0.09229663f, -0.11368628f, -0.00802436f, -0.06586748f, 0.15749808f, 0.12106668f, -0.01998024f, -0.06929478f, 
    -0.16031721f, -0.08222563f, 0.00852065f, 0.14522761f, -0.06523638f, 0.06714998f, -0.03249791f, -0.02886665f, 
    0.00564051f, 0.03814802f, 0.04704652f, 0.10192859f, -0.05675601f, 0.28960964f, -0.14931546f, 0.08078087f, 
    0.10362320f, 0.05903072f, 0.02650443f, -0.06313130f, -0.01693663f, 0.02280891f, -0.02960505f, -0.13355806f, 
    -0.01107773f, -0.00140782f, -0.11185411f, -0.15149888f, -0.06953229f, 0.13955881f, 0.01841082f, 0.07908795f, 
    -0.15787368f, 0.02378055f, 0.01253677f, 0.00652313f, -0.49105486f, -0.07179031f, 0.05126604f, -0.03103957f, 
    0.06881817f, 0.06366409f, 0.14352715f, 0.01574602f, 0.06760023f, 0.03146599f, 0.07126541f, 0.07698629f, 
    -0.14086100f, 0.08538049f, -0.23077948f, 0.39270395f, -0.00211116f, -0.01369221f, -0.11142380f, 0.01505761f, 
    0.14859319f, 0.04165229f, 0.03050759f, 0.02598253f, -0.09957659f, 0.15827541f, 0.27596202f, 0.15197140f, 
    -0.05111877f, 0.04924159f, 0.06677309f, -0.06156686f, 0.10633573f, -0.07618736f, -0.01615013f, -0.00432309f, 
    0.00899523f, 0.20383573f, -0.07725740f, -0.12133875f, 0.09623165f, 0.11213909f, -0.00112587f, -0.04593652f, 
    -0.05773590f, -0.11804386f, -0.13980655f, -0.01136274f, 0.06821363f, 0.05170694f, 0.23474710f, -0.07562824f, 
    -0.02937458f, 0.08171688f, 0.01824423f, -0.04472526f, 0.01839316f, -0.05219134f, -0.01164785f, -0.10083386f, 
    0.09398876f, 0.04949421f, 0.08558358f, -0.08078770f, 0.00615856f, 0.09224165f, -0.03921362f, 0.00231338f, 
    0.11381675f, -0.06851234f, 0.12634164f, -0.03524400f, 0.56043476f, -0.35782927f, 0.23070766f, 0.21592124f, 
    -0.00543077f, -0.08612973f, -0.04441437f, 0.10272247f, 0.03535013f, 0.01601620f, 0.04485571f, -0.02124130f, 
    0.13778882f, 0.04839271f, -0.05413704f, -0.09301475f, -0.01766524f, 0.03651324f, 0.03730552f, 0.10364188f, 
    0.01267670f, 0.06558976f, 0.12112356f, 0.03281686f, -0.57412350f, 0.25594345f, -0.08034711f, -0.16064772f, 
    0.12234601f, 0.05914114f, 0.15196091f, -0.04292389f, -0.08255270f, -0.03019593f, 0.02323238f, 0.02664309f, 
    -0.36701369f, 0.09985457f, 0.13549502f, -0.06555402f, -0.02992317f, -0.04594150f, 0.09204477f, -0.07564870f, 
    -0.07944393f, -0.11889007f, 0.03014610f, 0.05675819f, 0.10467002f, -0.03675088f, 0.02578630f, -0.01550134f, 
    -0.15742882f, -0.06333037f, -0.03878509f, -0.12097450f, -0.06165244f, -0.02632085f, 0.00398446f, 0.06186914f, 
    0.50815630f, -0.03433101f, -0.02268791f, 0.00069008f, 0.08821602f, -0.00163117f, -0.02656773f, 0.12464210f, 
    -0.09266116f, -0.02249802f, 0.06843942f, 0.09079184f, 0.04170916f, -0.09702662f, 0.06134292f, 0.11864743f, 
    0.00056634f, 0.04316767f, -0.00656081f, 0.19569995f, -0.09871568f, -0.00187025f, -0.04016879f, 0.01987050f, 
    -0.00843477f, 0.01706067f, -0.01491913f, 0.20741075f, 0.09382980f, 0.08864366f, 0.02493097f, 0.08424166f, 
    -0.14984475f, 0.15364394f, 0.05663431f, -0.02873319f, -0.05396936f, 0.08053560f, -0.19690299f, 0.18127419f, 
    0.01867791f, 0.08077618f, -0.05969910f, -0.02783767f, 0.03759641f, 0.11337374f, 0.00912835f, 0.05017838f, 
    0.15475452f, -0.10887510f, 0.12058458f, 0.20604564f, 0.03341448f, 0.07760724f, 0.07139257f, 0.16823535f, 
    0.03053447f, 0.09677204f, 0.02902662f, -0.01549499f, 0.24699070f, -0.07614192f, 0.05338712f, -0.02457398f, 
    -0.02355850f, 0.04466773f, -0.12464190f, -0.00888308f, 0.02466924f, 0.05319161f, 0.02526525f, 0.00363619f, 
    -0.21898098f, 0.04148959f, 0.09857175f, -0.05637791f, 0.03917519f, -0.11944032f, -0.01822907f, -0.03428558f, 
    -0.00033825f, 0.01649860f, -0.08840003f, 0.09317348f, 0.17946956f, -0.03634204f, -0.03874689f, -0.01144761f, 
    0.10837267f, 0.02760330f, 0.02610848f, -0.02763033f, 0.00591656f, -0.12065555f, -0.00108519f, -0.06173485f, 
    0.05005878f, 0.10413647f, 0.15144125f, -0.16152760f, -0.00834818f, 0.01918393f, 0.00105604f, -0.00114196f, 
    0.00993120f, -0.05793619f, -0.01625094f, -0.00874952f, 0.56877887f, -0.27039167f, 0.25942755f, -0.02856161f, 
    -0.05931635f, 0.00358645f, -0.03819640f, -0.00958579f, 0.02565979f, -0.00261142f, 0.03478283f, 0.14438814f, 
    -0.07909834f, 0.10592445f, -0.25317454f, -0.08228863f, 0.05692996f, -0.02886804f, 0.09222748f, 0.00018842f, 
    0.05485934f, -0.07561979f, -0.02345832f, 0.09402875f, 0.24027160f, -0.10476984f, -0.23309405f, 0.06163742f, 
    -0.05374843f, 0.09782635f, -0.01358788f, -0.09567518f, -0.01283902f, 0.03505862f, 0.14368550f, 0.05722272f, 
    0.05583564f, -0.03112253f, 0.27910110f, -0.03252930f, 0.04573841f, 0.05687591f, 0.08768681f, 0.01809368f, 
    0.16603132f, 0.15136153f, -0.04793590f, 0.07614054f, 0.15864637f, 0.00362283f, -0.13869622f, 0.19769551f, 
    0.07734726f, 0.03890776f, -0.02850124f, 0.06136536f, 0.07634746f, 0.06799170f, 0.01700740f, 0.04675411f, 
    0.07629558f, 0.22785217f, 0.00918611f, 0.11796080f, 0.01842116f, -0.01123267f, 0.04263645f, 0.18702576f, 
    -0.07177079f, 0.03046167f, -0.04847783f, 0.01745259f, -0.15444110f, 0.10923505f, -0.12930892f, -0.12375356f, 
    0.09795913f, 0.03203361f, 0.04075586f, 0.12739849f, 0.01562371f, 0.02369746f, -0.02098505f, 0.19226858f, 
    -0.08817264f, 0.03340567f, -0.17178480f, -0.17840388f, -0.01953987f, -0.07285967f, -0.06907292f, 0.05714216f, 
    0.02398781f, 0.01275998f, 0.01438699f, 0.00514731f, 0.15508015f, 0.24858770f, -0.10728724f, 0.08201894f, 
    -0.02740645f, -0.00960261f, -0.00263130f, 0.00596956f, 0.11335370f, -0.00001043f, 0.09442567f, -0.02065440f, 
    0.04849982f, -0.03057030f, 0.03916163f, 0.16800818f, 0.02331088f, 0.07446560f, -0.02018752f, 0.12870404f, 
    0.10778609f, 0.08157928f, 0.07673866f, 0.03840483f, -0.26990709f, 0.12443586f, -0.07381661f, -0.05354951f, 
    0.13733098f, 0.04529322f, 0.09163837f, -0.01555315f, 0.03778264f, 0.03922728f, 0.11068933f, -0.01279593f, 
    0.15434134f, -0.03071908f, -0.28183821f, 0.15596227f, 0.06470574f, 0.02441345f, 0.05013970f, -0.02983903f, 
    0.03824642f, -0.01164983f, -0.03810670f, 0.13892309f, 0.02988428f, 0.03909172f, -0.08777975f, -0.07216668f, 
    0.13816139f, -0.05756408f, -0.07977840f, 0.01362157f, 0.12297192f, -0.04552284f, 0.09993014f, 0.06601124f, 
    0.04600842f, -0.01038494f, -0.03423437f, -0.22296280f, 0.05485582f, -0.09458516f, 0.03175515f, 0.04014953f, 
    0.04134590f, -0.02975381f, -0.04107510f, -0.01663934f, -0.08796407f, 0.06688681f, -0.01382004f, 0.00445460f, 
    -0.06306139f, -0.10906336f, 0.08259486f, -0.03848961f, 0.03003231f, -0.06879190f, -0.01785974f, 0.01995007f, 
    -0.11726458f, 0.18338193f, 0.27380949f, -0.14271112f, 0.08125646f, 0.08187852f, 0.01368583f, 0.08356897f, 
    0.01297338f, -0.01323450f, -0.04691131f, 0.07575724f, 0.15559232f, -0.13185079f, 0.08879117f, 0.00992815f, 
    0.02564782f, 0.06255537f, 0.07406650f, 0.00637484f, -0.01821158f, -0.07968280f, -0.00653256f, 0.05407416f, 
    0.30914965f, -0.05206950f, 0.16159195f, -0.11116762f, -0.04249492f, -0.01956991f, 0.03297425f, -0.02486121f, 
    0.06393652f, 0.01652212f, 0.12421203f, -0.06549060f, -0.16546102f, -0.33544138f, -0.17233039f, 0.04259337f, 
    0.00014335f, 0.10834508f, 0.00033474f, -0.02397400f, 0.00190407f, 0.02466167f, -0.04557679f, -0.02191242f, 
    0.37200859f, -0.06906893f, 0.10741461f, 0.14375195f, -0.17916469f, -0.06478402f, 0.00151616f, 0.04931608f, 
    0.10385386f, -0.03856399f, 0.15770790f, -0.11498468f, -0.39309546f, 0.12775265f, 0.05336769f, 0.06640120f, 
    0.09928147f, 0.08259886f, 0.08422163f, 0.00726723f, -0.05574351f, -0.05542247f, -0.01443009f, 0.02744252f, 
    -0.45725656f, 0.17365956f, -0.16096088f, -0.15397932f, 0.11442725f, 0.07360373f, 0.17172077f, -0.07972852f, 
    0.01914314f, -0.08068755f, 0.09373090f, 0.03086442f, 0.01989291f, -0.05916583f, -0.08398247f, -0.26582009f, 
    -0.01874748f, 0.06537941f, 0.10706960f, -0.14135404f, -0.02394473f, -0.02090177f, 0.01833406f, 0.11291912f, 
    0.02217497f, 0.08013788f, 0.03917890f, -0.02721264f, 0.06750484f, 0.01418754f, -0.14048634f, 0.12931018f, 
    0.18481666f, -0.05586799f, 0.10480001f, 0.03345325f, 0.21992140f, -0.06332136f, -0.26837695f, 0.07129832f, 
    0.23127384f, 0.01166871f, -0.05768390f, 0.01032982f, 0.06307045f, 0.02498082f, 0.05675161f, 0.09440084f, 
    0.13069110f, 0.12310636f, -0.05924883f, -0.07490361f, -0.04139683f, -0.05454434f, 0.05795450f, -0.17056119f, 
    0.00849364f, -0.05528598f, -0.17041896f, -0.03981065f, 0.37974861f, 0.24409053f, -0.17444579f, 0.14874840f, 
    0.09464428f, -0.10256656f, -0.11774513f, 0.09017099f, 0.04036741f, 0.13013582f, 0.02574368f, 0.03690692f, 
    -0.09155174f, -0.10991214f, 0.19724564f, -0.01961668f, -0.01094109f, 0.03503584f, 0.00243695f, -0.03085359f, 
    -0.00452922f, 0.17567526f, -0.00977781f, -0.11711210f, 0.11251221f, -0.03321576f, -0.00189019f, 0.11106247f, 
    0.02022137f, 0.07612525f, 0.16407934f, 0.00809930f, 0.01856088f, 0.05667230f, -0.05037489f, 0.04242779f, 
    -0.27312315f, -0.15544818f, -0.09524854f, 0.03091485f, -0.04873128f, 0.03258594f, -0.01438642f, -0.10679144f, 
    -0.03386817f, 0.09798175f, -0.07247023f, 0.05874662f, 0.27629137f, -0.06283808f, 0.00387879f, -0.03597627f, 
    0.04129579f, -0.01483240f, 0.11409714f, 0.01238488f, 0.00533061f, -0.06254160f, -0.03458113f, -0.01394677f, 
    -0.07027337f, 0.24841285f, 0.19635393f, 0.08756899f, -0.05703267f, -0.04240937f, 0.10533778f, 0.14870787f, 
    0.00791173f, -0.00068663f, -0.03329031f, 0.05094606f, 0.24003828f, 0.12654248f, -0.07332848f, 0.12766534f, 
    0.02955805f, 0.05794103f, -0.02427163f, 0.07513405f, 0.09714066f, 0.04634779f, 0.00286489f, 0.12200171f, 
    -0.13052127f, -0.12637308f, -0.18461449f, -0.05586698f, 0.11493759f, 0.00824492f, 0.02544321f, -0.05020497f, 
    0.04257592f, -0.01488864f, -0.03616769f, 0.00605222f, -0.07517446f, -0.10852356f, -0.13525316f, -0.14260352f, 
    -0.11344551f, -0.09076778f, 0.08719830f, -0.07931937f, -0.00462304f, 0.01333726f, -0.04275397f, -0.02438545f, 
    -0.07549439f, -0.10622898f, 0.01268950f, 0.08263578f, -0.10141964f, 0.15614468f, 0.01169235f, 0.02243352f, 
    -0.09019800f, 0.00253916f, 0.14019829f, 0.12059854f, -0.11481058f, 0.10985518f, -0.15044171f, -0.11072824f, 
    0.09524005f, -0.05763822f, 0.02173062f, -0.10925779f, 0.07935833f, -0.10952218f, 0.09697271f, -0.03452998f, 
    -0.07124165f, -0.09107997f, -0.28614822f, 0.03861826f, -0.02037120f, 0.02178377f, -0.00397522f, 0.04719174f, 
    -0.05197730f, 0.03131420f, -0.07103838f, -0.04380928f, -0.46718264f, 0.25838262f, 0.13060828f, 0.03645782f, 
    -0.12520131f, 0.01247590f, -0.08092295f, 0.13852669f, -0.02015009f, -0.06726548f, -0.00313288f, -0.02824860f, 
    0.03147078f, -0.02031264f, -0.26344889f, -0.12373330f, -0.13692576f, 0.07739145f, 0.06858919f, -0.09639972f, 
    -0.08394075f, 0.05471835f, 0.02126586f, -0.08137731f, -0.04373730f, 0.13579793f, -0.23090382f, -0.17504707f, 
    0.08148906f, 0.00960555f, 0.08630776f, 0.13505648f, -0.02250248f, -0.00183942f, 0.07077940f, 0.04630077f, 
    0.07217649f, 0.03276604f, -0.05250422f, -0.21160084f, 0.04812393f, -0.06781224f, 0.04783783f, 0.02862039f, 
    0.05016567f, -0.00610059f, -0.05806430f, 0.02080599f, 0.16730653f, 0.04118906f, 0.11597452f, 0.10028846f, 
    -0.04482885f, 0.02117809f, -0.00071984f, 0.15377231f, -0.00865642f, 0.08610766f, 0.05229410f, 0.04908609f, 
    -0.05245352f, -0.10308542f, 0.18631865f, 0.01465678f, -0.04989987f, 0.11466829f, -0.02244223f, -0.04217398f, 
    -0.00497682f, -0.03067877f, 0.07714278f, 0.06927986f, 0.03558598f, -0.12868863f, 0.08660769f, -0.00017251f, 
    0.01600169f, 0.06321509f, 0.10786422f, -0.11287709f, -0.01709649f, 0.13919364f, -0.03304757f, 0.08652648f, 
    0.15336542f, -0.06569464f, 0.02501105f, -0.18463729f, 0.03911203f, -0.04310471f, 0.02531723f, 0.08577953f, 
    -0.00816920f, 0.01425656f, -0.00017522f, 0.07378060f, 0.31056073f, 0.23464799f, -0.28823745f, 0.25578225f, 
    0.07773980f, 0.02729399f, -0.12995233f, 0.03221953f, 0.06029209f, 0.07050522f, 0.01787540f, -0.00440108f, 
    0.24291416f, -0.00479532f, 0.03482231f, 0.11346538f, -0.15892003f, 0.03845968f, 0.00365784f, 0.08004632f, 
    -0.02599403f, 0.07458014f, 0.11625542f, -0.02463422f, 0.45323423f, 0.12594782f, -0.13496602f, 0.09910754f, 
    0.12783723f, -0.02817832f, -0.02464417f, -0.06370755f, 0.07073203f, 0.02248415f, 0.07236946f, 0.12236252f, 
    0.06689254f, 0.10749179f, 0.17960031f, -0.06419878f, 0.05895779f, -0.12577009f, 0.03253427f, 0.09060269f, 
    -0.01823204f, 0.13378671f, -0.02120772f, 0.03583018f, -0.23413546f, -0.09427588f, -0.05778977f, 0.07515901f, 
    -0.08753271f, -0.03782814f, 0.03088048f, 0.00758089f, 0.06981762f, 0.02837675f, 0.08498234f, 0.14066632f, 
    -0.09686395f, 0.15625089f, 0.02163020f, 0.13002209f, 0.03002996f, -0.03348687f, -0.01566582f, 0.05052771f, 
    0.01984391f, -0.01212043f, 0.07208228f, 0.12989733f, 0.33670411f, -0.25165701f, 0.06599575f, 0.14586093f, 
    0.06599755f, -0.02044537f, 0.07849538f, 0.03154943f, 0.11589537f, 0.01467337f, -0.03508050f, 0.13806170f, 
    0.31237388f, -0.04051082f, -0.18977937f, 0.29862863f, 0.11754598f, -0.05416882f, -0.11740310f, 0.01061515f, 
    0.15870030f, 0.13438469f, -0.01743610f, -0.01864456f, 0.18607113f, 0.24882416f, -0.13061047f, 0.03963973f, 
    0.19276637f, -0.02232794f, 0.02736999f, 0.25386751f, 0.13656524f, 0.04901342f, 0.00938082f, 0.10074291f, 
    -0.37157536f, -0.06334000f, -0.02559177f, 0.12191664f, 0.02176930f, 0.05564803f, 0.04601098f, 0.05354696f, 
    0.10578639f, -0.04976004f, 0.07765654f, -0.04954765f, 0.24658471f, 0.03072559f, -0.17900653f, 0.02783124f, 
    -0.09041055f, 0.01154894f, -0.05134027f, -0.11442124f, 0.05033154f, 0.04407199f, 0.04951005f, -0.06913950f, 
    -0.23427707f, 0.13123995f, 0.02080143f, -0.30289513f, 0.02238232f, -0.17248745f, 0.05781186f, -0.00945222f, 
    0.12562658f, -0.06733436f, 0.03951494f, 0.07765767f, -0.10527547f, 0.08972059f, 0.05299355f, -0.07396287f, 
    0.19699925f, 0.06551070f, -0.04452725f, -0.06049391f, 0.04789348f, 0.02498068f, 0.05998667f, 0.02789014f, 
    -0.11673186f, -0.01317924f, -0.28446263f, 0.05496551f, -0.03584899f, -0.05252297f, -0.08360989f, -0.12381485f, 
    0.09754137f, -0.04941379f, -0.00560499f, 0.04728462f, -0.17123300f, -0.16088213f, 0.00055537f, -0.02796683f, 
    -0.11513064f, 0.10428935f, 0.10959259f, 0.12174214f, 0.09725447f, -0.03200030f, -0.05036527f, -0.01174905f, 
    0.01006362f, 0.10435110f, 0.04879991f, 0.04369976f, 0.00671762f, 0.08613963f, 0.00659786f, 0.12396500f, 
    0.04760331f, 0.02503292f, -0.01893873f, -0.01950788f, 0.02918853f, 0.06007214f, 0.06166013f, 0.14160140f, 
    -0.00484402f, -0.00705880f, 0.10114393f, 0.02589197f, 0.01829251f, -0.01090119f, -0.00477365f, 0.08467881f, 
    0.30775777f, 0.15655509f, 0.05906610f, 0.03344828f, 0.02460325f, 0.06523544f, 0.10409276f, 0.01282618f, 
    0.03995584f, -0.01399282f, -0.01097250f, 0.05606290f, -0.00929729f, -0.04954122f, -0.16645993f, 0.05443269f, 
    0.08905409f, -0.01673572f, 0.04995345f, -0.00625645f, 0.05156935f, 0.11747530f, 0.06986912f, -0.04719615f, 
    -0.04193093f, -0.02145038f, -0.01938183f, 0.00224420f, 0.02379542f, 0.01021313f, -0.04277569f, 0.00856508f, 
    -0.01668100f, -0.03571828f, -0.03144648f, -0.03121858f, 0.02363474f, -0.02618240f, -0.01987814f, -0.02542425f, 
    -0.01154660f, -0.01981417f, 0.02547601f, 0.02010685f, 0.02210861f, -0.03702157f, -0.03181414f, -0.03236510f, 
    0.01653233f, 0.00604708f, 0.02664609f, -0.03023135f, -0.03785813f, -0.03562715f, 0.02450724f, -0.03167577f, 
    0.02259710f, -0.03809227f, -0.04367536f, 0.00682266f, 0.02735739f, 0.02159011f, 0.00935128f, -0.03334814f, 
    -0.04347898f, -0.01706835f, -0.01608563f, 0.01419453f, -0.02608339f, -0.03534572f, -0.04402972f, -0.00085193f, 
    0.01426584f, 0.00478685f, 0.00314958f, -0.03479605f, 0.02005601f, 0.02512893f, -0.03572485f, -0.02691296f, 
    -0.01767169f, -0.02587857f, -0.01935506f, -0.00246332f, -0.00662591f, 0.02850376f, -0.03727098f, -0.02137499f, 
    -0.02130441f, 0.02720813f, 0.00400979f, 0.01776953f, -0.00809974f, -0.02510097f, -0.01740323f, 0.00362361f, 
    -0.00700631f, -0.00139865f, -0.02376178f, -0.00681196f, 0.01773681f, -0.02431781f, 0.01284161f, 0.00593436f, 
    -0.02317141f, -0.01744278f, 0.01339733f, -0.00948930f, 0.02048334f, -0.00352825f, -0.03946773f, -0.02077504f, 
    0.01882514f, -0.00068069f, 0.01639491f, -0.01014546f, -0.00530463f, 0.00362414f, -0.00228422f, 0.01764582f, 
    -0.01512752f, -0.02103036f, -0.03699633f, -0.02928045f, -0.00909299f, 0.02032511f, -0.01574534f, 0.01552948f, 
    -0.02384174f, -0.00096048f, -0.03592023f, -0.03001316f, -0.00130964f, -0.02893607f, -0.02818643f, -0.04302029f, 
    -0.02700266f, 0.01547642f, 0.02282790f, -0.01403061f, -0.02027956f, 0.01072500f, 0.00223917f, 0.01679731f, 
    -0.04372779f, -0.03493663f, -0.03910118f, 0.02180240f, 0.00596590f, 0.01222172f, 0.02239468f, -0.00681927f, 
    -0.04235700f, -0.00629973f, 0.01308277f, 0.02314745f, -0.04209111f, 0.00674512f, 0.00605203f, -0.04076376f, 
    0.00218256f, -0.01178691f, 0.01729287f, 0.00880052f, -0.02921529f, 0.02581061f, -0.00879116f, 0.01820979f, 
    0.00599136f, -0.00702821f, -0.00826079f, 0.00868865f, -0.03448050f, -0.03553205f, 0.02179095f, -0.02179215f, 
    0.00242063f, 0.00177012f, 0.00967150f, -0.00849135f, -0.04170384f, -0.02389069f, -0.00688609f, -0.02270071f, 
    -0.01169542f, 0.02275852f, -0.03009937f, 0.01995442f, 0.02243649f, -0.01764767f, -0.04382349f, -0.02330856f, 
    -0.03266069f, 0.01319798f, -0.01404392f, -0.03895956f, -0.00214399f, -0.00777471f, 0.01640880f, 0.00332256f, 
    -0.03171660f, 0.02112458f, 0.00387298f, -0.02824035f, -0.03864609f, 0.00860965f, -0.02151815f, -0.03028138f, 
    0.02164419f, 0.02313273f, 0.01896207f, 0.01249016f, -0.01533272f, 0.01683501f, -0.01682874f, -0.03666288f, 
    -0.02912060f, -0.03213921f, 0.02033355f, -0.02065111f, -0.02706554f, -0.04339539f, 0.02695914f, -0.01105214f, 
    -0.04084960f, -0.00408710f, -0.01281778f, 0.01845660f, -0.01713959f, -0.04131090f, 0.01496044f, 0.02690864f, 
    0.00790691f, -0.01510034f, 0.01853754f, 0.00223026f, -0.01214509f, 0.02594728f, -0.03175233f, -0.02678487f, 
    0.00008228f, 0.02273013f, -0.02203471f, -0.03913679f, -0.03085314f, 0.00644700f, -0.03492576f, 0.02289664f, 
    -0.00343764f, -0.02011579f, -0.01287319f, 0.02748225f, -0.01341334f, -0.03759258f, -0.01251470f, 0.01695863f, 
    0.01728706f, 0.02708625f, -0.02108357f, 0.01930938f, -0.00832210f, 0.02434146f, -0.04067165f, 0.01689865f, 
    -0.02585312f, -0.03887696f, -0.03931561f, 0.01764921f, -0.02733760f, -0.03963089f, 0.01758289f, 0.02264476f, 
    -0.01076674f, -0.02300028f, 0.02064128f, 0.01296483f, -0.00337035f, 0.01582324f, -0.02243488f, 0.01150242f, 
    0.00389036f, -0.04114752f, 0.00332348f, 0.01751298f, 0.02300636f, -0.02912909f, -0.00374807f, -0.00850824f, 
    -0.01873809f, -0.00720124f, -0.02645517f, -0.03434225f, 0.00924028f, 0.00781227f, 0.00586678f, -0.02145987f, 
    0.00998511f, 0.02154275f, -0.02996802f, -0.01724908f, 0.01182096f, 0.02204523f, 0.03035238f, -0.02161156f, 
    0.01239038f, 0.00302910f, 0.01986501f, -0.00657204f, -0.02898107f, 0.02190318f, 0.00295687f, -0.03397393f, 
    0.01568611f, -0.00679052f, 0.01106614f, 0.00573466f, -0.00944920f, -0.00200033f, -0.01388967f, -0.00143040f, 
    -0.03864798f, -0.02594873f, 0.02245239f, -0.02254133f, -0.02873250f, -0.00745975f, -0.03358679f, -0.01190510f, 
    -0.01577625f, -0.03209374f, -0.03835867f, 0.02602329f, 0.00373510f, 0.00747596f, -0.01998376f, -0.00137063f, 
    -0.01690559f, -0.00176314f, -0.03154718f, -0.01488688f, 0.02760677f, -0.02126204f, -0.04357475f, 0.02308221f, 
    -0.01949351f, 0.00993337f, 0.02616307f, 0.02577612f, -0.00974813f, -0.00713568f, -0.02894405f, -0.03360731f, 
    0.01732711f, 0.01168806f, 0.00022562f, -0.03975962f, -0.02250938f, 0.02370256f, -0.00800722f, -0.02623094f, 
    -0.03811792f, 0.02337763f, 0.02042052f, 0.02013436f, 0.00322855f, -0.02830667f, -0.03101801f, -0.00339572f, 
    -0.03637821f, -0.01542625f, 0.00893689f, -0.02573376f, -0.00946487f, 0.02024966f, -0.04333927f, 0.00625707f, 
    -0.02824139f, -0.01870389f, 0.01477822f, -0.01894893f, 0.02342239f, -0.03867297f, -0.03338014f, -0.00542764f, 
    0.01412214f, 0.01507786f, 0.02564993f, 0.00577407f, 0.00293396f, 0.00854489f, -0.03197944f, 0.02319041f, 
    0.00126055f, -0.00971327f, -0.03488343f, 0.01944610f, 0.00596678f, -0.02351584f, -0.01466854f, -0.01665915f, 
    0.00035690f, 0.01062191f, 0.00810701f, 0.02694172f, -0.01152332f, -0.02056932f, 0.00032414f, 0.02536401f, 
    -0.01232416f, 0.00120356f, -0.02075408f, -0.00060435f, -0.01771581f, -0.04162144f, 0.01132710f, -0.00838928f, 
    0.01238997f, -0.02300804f, -0.03248093f, 0.02146011f, -0.04276559f, 0.02073886f, 0.02794870f, 0.00338339f, 
    0.01622060f, -0.02774763f, 0.01201230f, -0.00353809f, -0.00974637f, 0.02365744f, -0.02776903f, 0.01146388f, 
    -0.00973848f, 0.00499551f, -0.00009920f, 0.01723241f, 0.00183754f, -0.01913770f, 0.02471546f, -0.03492986f, 
    0.00674364f, -0.00583769f, 0.02186012f, -0.04159129f, 0.01630108f, 0.00563194f, 0.02721936f, -0.00072545f, 
    0.00450035f, -0.01221158f, -0.04118685f, -0.02624541f, 0.01084497f, -0.04138734f, 0.01003425f, -0.03791431f, 
    0.00170821f, 0.01366100f, -0.02351104f, -0.01304227f, -0.01240856f, -0.02701398f, 0.00121403f, 0.01073177f, 
    0.02466758f, -0.03166809f, 0.02754546f, 0.00097978f, 0.01177942f, -0.01856729f, 0.00643619f, -0.00770648f, 
    0.01033622f, -0.01975534f, 0.01650039f, -0.02000177f, 0.01472614f, 0.01301574f, -0.02855717f, 0.00649343f, 
    -0.00397295f, -0.01126404f, -0.00174744f, 0.00351812f, 0.01886166f, -0.00697706f, 0.01430071f, 0.00892313f, 
    -0.03194643f, 0.00406178f, -0.03606441f, -0.01701147f, -0.03459989f, -0.03283289f, -0.02558378f, -0.02618126f, 
    0.02515874f, 0.01169454f, -0.04215368f, 0.00750769f, -0.01086894f, 0.02481615f, -0.02058268f, -0.03347602f, 
    -0.03450004f, 0.01091289f, -0.02647711f, 0.00761798f, -0.03205509f, 0.01936563f, -0.04381972f, -0.01770655f, 
    0.02731154f, 0.01694567f, 0.00214449f, -0.00492368f, -0.02972516f, -0.02768381f, 0.00719598f, 0.02767450f, 
    0.00395641f, 0.02464496f, -0.03606430f, -0.01072930f, 0.01130377f, 0.02200711f, -0.03722722f, -0.01450437f, 
    0.01799059f, -0.01231943f, 0.01001354f, -0.03633261f, 0.00872482f, 0.02267143f, 0.00342452f, -0.02554427f, 
    -0.01532627f, 0.02155638f, -0.03350156f, -0.02344893f, 0.01619535f, -0.03062054f, 0.01428838f, 0.02217492f, 
    0.01099013f, 0.01599084f, 0.01272020f, 0.00113976f, 0.00301723f, 0.01611276f, 0.02082425f, -0.02362200f, 
    -0.03909591f, -0.00537980f, -0.03523205f, -0.00986001f, -0.01430567f, -0.00971479f, -0.03805428f, -0.03521186f, 
    -0.00885395f, -0.02899316f, 0.02728012f, -0.02635675f, -0.03773827f, 0.00192492f, -0.01644646f, 0.01722251f, 
    -0.01788719f, -0.01125054f, -0.01490689f, -0.00651140f, -0.01141935f, -0.03698501f, 0.00419530f, 0.00248879f, 
    -0.03259342f, -0.03999030f, -0.04036081f, -0.01553050f, 0.00345386f, 0.00133981f, 0.01185909f, -0.03670092f, 
    0.02234182f, 0.02163293f, 0.02069457f, -0.00253843f, -0.02546992f, 0.02482262f, 0.02683876f, 0.02524733f, 
    0.02680427f, -0.03668597f, 0.00706842f, -0.00243905f, 0.01065528f, -0.00234794f, -0.01288228f, -0.01716972f, 
    0.00648232f, -0.01742505f, 0.02174869f, -0.03467623f, -0.03997923f, 0.02592461f, -0.03340541f, -0.03482557f, 
    -0.03931113f, -0.01128679f, -0.00332536f, -0.00113791f, -0.01083097f, 0.01698721f, 0.02722953f, -0.02644428f, 
    -0.03613129f, -0.02753374f, 0.01044529f, 0.01435321f, 0.01140991f, -0.04319187f, -0.04407947f, 0.00127652f, 
    0.00760140f, -0.00353671f, 0.00431143f, 0.01835877f, -0.01021646f, -0.02094381f, 0.00035789f, -0.03184290f, 
    0.02308442f, -0.03181314f, 0.00820240f, -0.01755052f, -0.03348494f, 0.01611072f, 0.02642719f, -0.01679756f, 
    -0.03583539f, -0.01779143f, -0.02297812f, -0.00166077f, -0.03056552f, -0.01540434f, 0.00503402f, -0.04392988f, 
    -0.01768010f, 0.02075871f, -0.01811851f, 0.00030873f, -0.00985118f, -0.01496980f, -0.03462272f, 0.01721553f, 
    -0.00550629f, -0.01761749f, -0.02908319f, -0.01372278f, 0.01837756f, -0.00746711f, -0.02525341f, -0.01339008f, 
    -0.03994465f, 0.01092832f, -0.01922384f, 0.00844907f, 0.01955151f, -0.04279009f, 0.02285503f, -0.01134722f, 
    -0.03070067f, -0.03514909f, -0.04363720f, 0.02470109f, -0.04331738f, 0.01216219f, -0.04402256f, 0.02573374f, 
    -0.01889222f, -0.02805129f, 0.02095100f, -0.02471575f, -0.04241884f, 0.00177746f, -0.04303600f, 0.00760829f, 
    0.01085872f, 0.01983183f, -0.03840197f, -0.03574705f, -0.00055285f, 0.02086862f, 0.02524705f, -0.01452890f, 
    -0.02585543f, 0.01555224f, -0.04231865f, -0.03940354f, 0.00589191f, 0.00879325f, -0.03838816f, 0.01496655f, 
    0.01380027f, -0.02467375f, -0.02641510f, -0.00846158f, -0.03045961f, -0.00695011f, -0.00494284f, -0.00433120f, 
    0.02258500f, -0.01562761f, -0.02392642f, -0.02978027f, -0.01773942f, -0.02646234f, -0.00351427f, -0.00166430f, 
    -0.01929315f, -0.00817367f, -0.00395250f, -0.03832969f, -0.00591730f, -0.03493644f, -0.03564109f, -0.01343774f, 
    -0.02907679f, -0.02375118f, -0.00185249f, 0.01006555f, 0.00010303f, -0.04087465f, -0.02617421f, 0.00808162f, 
    0.00148773f, -0.00306749f, 0.00466797f, -0.04105234f, -0.04439064f, -0.03511355f, -0.03597263f, -0.02734117f, 
    -0.03909871f, -0.02146058f, 0.01574503f, -0.02916854f, -0.01104687f, 0.01055522f, -0.03828913f, -0.03901046f, 
    -0.00580103f, -0.02906269f, 0.01009688f, -0.00961861f, -0.04024753f, 0.02500527f, -0.00859327f, 0.01112113f, 
    -0.01811865f, -0.01946367f, 0.01239860f, -0.00077140f, -0.01497304f, -0.03619277f, 0.01550630f, 0.01608653f, 
    -0.03780580f, -0.02523125f, -0.01680501f, 0.00619057f, 0.02458438f, -0.03441442f, -0.02019273f, 0.02632662f, 
    0.01341825f, -0.01687209f, -0.03451316f, -0.03697979f, -0.03288614f, 0.01228946f, 0.01731716f, -0.01364021f, 
    -0.00021530f, 0.00981146f, -0.00305236f, 0.00356817f, -0.00969081f, -0.03952380f, 0.00301864f, -0.04090169f, 
    -0.07026605f, -0.13613343f, 0.27685603f, -0.00095350f, 0.08446863f, 0.15983966f, -0.14562677f, -0.00834869f, 
    -0.01398620f, 0.12196158f, 0.01317355f, -0.08883522f, -0.02462729f, 0.02054935f, -0.06026943f, 0.17460942f, 
    0.05989856f, 0.02626955f, 0.09783310f, 0.03809677f, 0.02995812f, 0.04871540f, 0.07805299f, 0.03062610f, 
    0.01514431f, 0.00624531f, -0.12205028f, 0.05363749f, -0.08028913f, -0.03272238f, 0.04776653f, 0.00370067f, 
    -0.07185244f, -0.05824343f, 0.12309560f, 0.03286975f, -0.08539170f, -0.11720217f, 0.08509974f, 0.02853566f, 
    -0.13631240f, 0.07699639f, 0.02950631f, 0.05947186f, 0.00376074f, 0.06629616f, -0.04730743f, 0.15724839f, 
    -0.15132113f, -0.09794197f, 0.10790651f, 0.02679357f, 0.04984315f, -0.00718000f, 0.01415056f, 0.03070098f, 
    0.09275216f, 0.01532809f, 0.08983067f, 0.06437643f, 0.20752840f, -0.10601471f, 0.24752043f, 0.38773635f, 
    -0.11993435f, -0.00250847f, -0.02514784f, -0.06165662f, -0.08514804f, 0.02927209f, 0.04433435f, 0.16090381f, 
    0.07578785f, 0.22436905f, 0.17022522f, 0.05482561f, 0.06509528f, 0.05249042f, 0.07509124f, -0.03548888f, 
    -0.04604695f, 0.06700622f, -0.05057882f, -0.07853810f, -0.00103730f, -0.19646977f, 0.11001384f, 0.02769823f, 
    -0.11771254f, -0.05511614f, -0.00901894f, 0.21424018f, 0.01672060f, -0.04306097f, 0.04696718f, -0.05611229f, 
    0.10961520f, 0.12868054f, 0.17051318f, 0.14466737f, 0.00548893f, -0.01728225f, 0.02335831f, -0.07057314f, 
    0.02105113f, -0.01073236f, -0.02022655f, 0.09147247f, -0.14568350f, 0.01765946f, 0.05684738f, 0.18236691f, 
    0.04740940f, -0.05290995f, 0.02244184f, 0.10970739f, 0.00555956f, 0.03570883f, 0.02024918f, 0.07945992f, 
    0.01255607f, 0.06812634f, 0.36457938f, 0.12411252f, 0.06991567f, -0.00052527f, -0.01920842f, 0.09044685f, 
    0.03617903f, 0.10762031f, 0.04714274f, 0.03466885f, 0.03776508f, -0.22969544f, 0.02185906f, 0.04924553f, 
    -0.08595447f, -0.05990975f, -0.04481428f, -0.12351964f, 0.08040345f, 0.06836820f, -0.03085361f, 0.02672380f, 
    0.11212216f, 0.14036885f, 0.03066983f, -0.03895347f, 0.03762850f, -0.02283760f, -0.06740514f, 0.03060694f, 
    -0.00797385f, 0.05103063f, 0.02838412f, -0.09735300f, 0.01319583f, 0.12284081f, -0.08750139f, -0.14163581f, 
    0.09046272f, 0.07266176f, 0.06125498f, -0.00905784f, 0.00852566f, 0.07266071f, -0.00053420f, -0.05920903f, 
    0.05090049f, -0.00437510f, 0.08233488f, 0.02508183f, 0.02957019f, -0.03827575f, 0.10892127f, 0.13035814f, 
    0.06356554f, 0.04844636f, 0.09361061f, -0.01804118f, -0.15075682f, 0.12893072f, 0.00648037f, 0.06785475f, 
    -0.07720223f, -0.00104299f, -0.03615690f, -0.01177092f, 0.03424327f, -0.04910715f, -0.01774323f, 0.02649485f, 
    -0.09948017f, 0.00047060f, -0.11699449f, -0.02727704f, -0.02122165f, -0.08395603f, 0.13049573f, 0.04769449f, 
    -0.01435761f, 0.05398115f, 0.06212624f, 0.18166642f, 0.00074930f, 0.09428404f, 0.01244998f, -0.25663495f, 
    0.01851868f, -0.01333007f, 0.04606278f, -0.05839007f, 0.03885418f, -0.00500845f, -0.09694442f, -0.02104012f, 
    -0.10892978f, -0.03657837f, -0.04982207f, -0.04168399f, 0.01871561f, -0.01022848f, 0.02980821f, 0.10774462f, 
    0.00466963f, 0.03025940f, -0.00941119f, 0.15166549f, -0.36399642f, -0.05945750f, 0.19977471f, 0.08439401f, 
    0.00552128f, -0.03272539f, -0.02720171f, 0.04861951f, 0.10429630f, 0.10411066f, 0.03690701f, 0.07959263f, 
    -0.59938085f, 0.07736351f, 0.00991216f, -0.19623631f, 0.06867388f, 0.04683786f, -0.08267692f, 0.10033800f, 
    -0.02239995f, 0.03422664f, -0.03186226f, 0.03289179f, -0.08852179f, -0.06880266f, -0.22448789f, -0.08607009f, 
    0.09531646f, 0.05957497f, 0.00512911f, -0.03335165f, 0.04866488f, 0.03005215f, -0.01849040f, 0.06051541f, 
    0.17555115f, -0.00228989f, 0.16408184f, 0.19163829f, 0.07756675f, 0.06855904f, 0.02370439f, 0.02473735f, 
    -0.01860136f, -0.04944629f, 0.07261626f, -0.01461876f, -0.11299074f, -0.11892647f, 0.07700759f, 0.12785223f, 
    -0.07193247f, 0.03321109f, -0.05492646f, -0.04321789f, -0.00122516f, 0.01776722f, -0.05503963f, 0.12673400f, 
    0.05010212f, 0.04451116f, 0.11059871f, 0.04899292f, 0.01337192f, 0.16720232f, -0.00425863f, 0.05466806f, 
    0.11928278f, 0.08622056f, 0.07572823f, 0.03516003f, -0.24092829f, -0.10867723f, -0.03613741f, 0.10667711f, 
    0.06374006f, -0.01637055f, 0.01342325f, -0.03474270f, 0.11262566f, -0.04506778f, -0.04450274f, 0.07476611f, 
    0.24696638f, 0.19222878f, 0.09279868f, 0.09654018f, -0.01227275f, -0.04875945f, 0.10281800f, 0.03288549f, 
    0.02817244f, -0.21950629f, -0.00949725f, 0.00758323f, -0.04385168f, 0.16404043f, 0.16117039f, 0.00774082f, 
    0.07471712f, -0.06979209f, 0.01196992f, 0.07685407f, 0.10024901f, 0.11328737f, 0.00629556f, 0.03313776f, 
    0.07625180f, -0.03124069f, -0.07872333f, -0.24280299f, 0.10732024f, 0.05110607f, 0.07642578f, -0.12227751f, 
    0.02288647f, 0.00233332f, 0.01591778f, 0.01498492f, -0.23084278f, 0.22227624f, 0.01742756f, -0.05420838f, 
    -0.03904609f, 0.05616380f, -0.01313237f, 0.07906494f, 0.17419589f, 0.09203526f, -0.04884863f, 0.05639054f, 
    0.12610899f, -0.11833442f, -0.12269031f, -0.04422763f, -0.00986736f, 0.06944896f, -0.00948359f, -0.02121519f, 
    0.04670039f, 0.12815103f, 0.02092510f, 0.07624339f, -0.21084808f, 0.04435674f, 0.14733554f, -0.10060604f, 
    -0.14399330f, 0.01209815f, -0.08455665f, -0.07631874f, -0.02156902f, 0.03253586f, 0.08616898f, -0.03766519f, 
    0.14102992f, -0.01676555f, -0.13124722f, -0.27019390f, 0.05323195f, 0.04660064f, -0.07869946f, -0.11264116f, 
    0.09548967f, 0.04745479f, 0.02963208f, -0.00128856f, 0.16392459f, 0.10318872f, 0.18451487f, 0.24648580f, 
    -0.04226768f, 0.06681092f, 0.04926286f, -0.00058015f, 0.14031866f, -0.04942891f, -0.03457975f, -0.01915338f, 
    -0.21237008f, 0.21609506f, 0.00876323f, -0.01687090f, 0.04937234f, -0.10073948f, 0.03077077f, -0.07482091f, 
    0.08698074f, -0.03556552f, -0.01271534f, -0.03546154f, -0.07214893f, -0.13920964f, 0.05521696f, -0.05535716f, 
    0.06916444f, 0.03511859f, -0.01636327f, 0.01975589f, 0.06434687f, 0.01212414f, -0.02232210f, 0.11186389f, 
    0.14953847f, 0.15340061f, 0.07606793f, -0.02515322f, 0.02154808f, 0.04301751f, 0.03340188f, -0.07450220f, 
    0.05221485f, 0.05030063f, 0.00366622f, 0.04302194f, -0.11987650f, 0.07115725f, 0.03928129f, 0.05208109f, 
    -0.00100227f, -0.06981986f, 0.07984283f, -0.01324882f, -0.05385700f, 0.04844594f, -0.02836923f, 0.00247076f, 
    -0.04501922f, 0.08598500f, -0.07637600f, -0.04005402f, -0.02927137f, 0.13019586f, -0.00121897f, -0.08407445f, 
    0.12919903f, -0.05998174f, 0.02871468f, 0.09211133f, 0.01711665f, -0.04060716f, 0.22176905f, -0.02645159f, 
    -0.04981023f, -0.14878602f, 0.03366556f, 0.00225596f, 0.08950553f, 0.05316709f, 0.00826379f, 0.02841381f, 
    0.14178306f, 0.16848341f, 0.15582678f, 0.23532981f, -0.05526523f, -0.00038450f, 0.08208290f, 0.16002885f, 
    -0.05494634f, 0.04187294f, 0.02117984f, 0.03953795f, -0.05869462f, -0.19690719f, 0.03867662f, -0.03466542f, 
    -0.09012634f, 0.00772351f, -0.02596695f, 0.04600567f, 0.00481733f, 0.05067698f, 0.03957428f, -0.03518995f, 
    -0.50919628f, 0.11868641f, 0.10510008f, -0.09733485f, 0.23325509f, 0.06804377f, 0.02749784f, 0.06787397f, 
    0.06432179f, -0.00304410f, 0.09687469f, -0.03107015f, -0.38322586f, 0.10509637f, -0.04313160f, -0.04419515f, 
    0.13241072f, 0.09930699f, 0.08118889f, 0.02978188f, 0.06116286f, 0.03164804f, 0.12964286f, 0.03639403f, 
    0.19018909f, 0.07733904f, -0.00576966f, 0.09191629f, 0.07964574f, 0.02704221f, -0.00677130f, 0.07143523f, 
    0.05143879f, -0.04539371f, 0.05661411f, -0.09420625f, -0.37692031f, -0.20065805f, 0.03143284f, 0.03748981f, 
    0.05406622f, 0.05139886f, 0.07221983f, 0.01830290f, 0.04456398f, -0.02873442f, -0.02670704f, 0.10087354f, 
    -0.08989609f, -0.08650298f, -0.01524908f, -0.15623014f, 0.05473185f, -0.06440210f, -0.04256026f, -0.00305481f, 
    0.20089416f, 0.02725302f, 0.02610026f, 0.06550435f, -0.20597649f, -0.09752785f, 0.13149802f, 0.09420933f, 
    -0.04776765f, -0.00163316f, -0.03971053f, 0.00289848f, 0.09214316f, -0.02918018f, 0.04593872f, 0.04517473f, 
    0.21722156f, -0.17650063f, -0.06558326f, 0.20391856f, 0.00280929f, -0.04805873f, -0.06643233f, -0.03192302f, 
    0.15289399f, 0.05954054f, 0.04116614f, 0.11630812f, -0.19330487f, -0.02352009f, 0.46900287f, 0.22782898f, 
    0.04743785f, -0.02976851f, 0.03384571f, -0.02277206f, 0.06863374f, 0.04954737f, -0.05385154f, -0.07933746f, 
    -0.00916773f, -0.18150927f, -0.01915951f, 0.06335688f, -0.05395046f, -0.03425914f, 0.02769797f, -0.11402467f, 
    -0.06326618f, -0.08524945f, -0.06255613f, 0.04653324f, -0.32791197f, 0.19600894f, -0.00008617f, 0.10768177f, 
    -0.09799167f, 0.00902359f, 0.03880071f, -0.04151965f, 0.02991748f, 0.06663426f, -0.14389944f, -0.05983913f, 
    0.14648826f, 0.01157870f, 0.14781073f, 0.16713014f, -0.05783043f, 0.06215470f, 0.00520595f, -0.00006271f, 
    0.05988653f, -0.06973220f, 0.08240737f, 0.09179433f, -0.06075805f, -0.15190990f, 0.16271125f, 0.19016355f, 
    -0.10780288f, -0.02169956f, 0.04546194f, -0.05928292f, -0.06667574f, -0.05379150f, 0.04763173f, 0.10931458f, 
    0.27875283f, -0.08727250f, 0.11390284f, 0.04580071f, 0.07484869f, 0.00697933f, -0.02664138f, -0.01970271f, 
    -0.03761652f, -0.00723789f, -0.04372004f, -0.00382139f, 0.13108283f, 0.10955130f, -0.06834666f, 0.05082009f, 
    0.00000809f, 0.08592121f, 0.04283464f, -0.01770190f, 0.01766055f, 0.03439694f, -0.04101691f, 0.05309562f, 
    0.23123407f, 0.09173723f, -0.01166729f, 0.04462032f, 0.00540578f, 0.07100116f, 0.21603322f, -0.04380943f, 
    -0.08266959f, 0.01103652f, -0.07061172f, -0.09031887f, 0.00987798f, -0.13509564f, 0.18523766f, -0.06087379f, 
    0.02595744f, 0.03992312f, 0.09898151f, -0.08060993f, -0.03298049f, -0.04285103f, 0.05077385f, -0.02436081f, 
    -0.10551941f, -0.07417930f, 0.10475399f, -0.09041385f, -0.03573024f, 0.09395844f, -0.11295948f, 0.07505424f, 
    0.02085882f, 0.04325270f, -0.12353157f, 0.10421427f, 0.18902686f, -0.11680886f, -0.03086603f, -0.07507337f, 
    0.07527570f, -0.03732092f, -0.02899088f, -0.07524693f, 0.10196261f, 0.06360652f, -0.01556239f, 0.08182552f, 
    0.29120234f, -0.06779453f, 0.07082783f, 0.15060298f, 0.07289440f, 0.03863339f, 0.01669519f, 0.04422794f, 
    0.02008845f, 0.05422111f, 0.07797983f, 0.07164009f, -0.08155537f, -0.00325156f, 0.13547815f, -0.07775775f, 
    -0.14773092f, -0.01107009f, -0.01071034f, 0.01713773f, 0.08557127f, -0.09026373f, 0.00270407f, -0.05032779f, 
    -0.27302682f, 0.02134121f, 0.15467045f, 0.06170770f, -0.01664194f, -0.00631961f, 0.04277901f, 0.08678163f, 
    0.03370273f, 0.06007346f, 0.02986157f, 0.09138000f, -0.28149867f, 0.18221867f, 0.20830275f, 0.23464656f, 
    0.02794911f, -0.04033480f, 0.01526160f, -0.02612188f, -0.06755311f, 0.10903393f, 0.00337274f, 0.08564590f, 
    -0.01076503f, -0.01799099f, 0.02804191f, -0.03711123f, 0.01169484f, -0.02606619f, -0.03876590f, 0.00168264f, 
    -0.01197962f, -0.01899391f, -0.03606294f, 0.01850857f, -0.00835755f, 0.00925156f, 0.02567128f, 0.02784056f, 
    -0.03185874f, 0.00525303f, -0.02605192f, 0.03995077f, -0.02030340f, -0.01705155f, -0.02410535f, -0.02555045f, 
    0.02251795f, 0.01157452f, 0.00094342f, -0.03708768f, 0.01449222f, -0.03854959f, -0.03122950f, 0.02596765f, 
    -0.01417368f, -0.01122959f, 0.01874058f, -0.01071289f, 0.01711773f, 0.01312299f, -0.03966373f, 0.02726396f, 
    0.00642980f, -0.00337148f, -0.00880784f, 0.00124077f, 0.03581393f, -0.00909319f, 0.02929362f, 0.02694499f, 
    -0.02013329f, -0.03728595f, 0.02432912f, -0.00947972f, -0.02330009f, 0.01183484f, -0.01727484f, 0.01504807f, 
    -0.03837498f, -0.01786115f, -0.04208927f, -0.04044810f, 0.01736876f, 0.01376965f, -0.00545079f, -0.00006707f, 
    -0.02444752f, -0.01728898f, -0.00831995f, -0.01664767f, 0.01237919f, 0.02692823f, 0.00536017f, 0.02425062f, 
    0.02186323f, 0.04199377f, 0.01136950f, 0.02070840f, -0.02008493f, -0.02587980f, -0.02243626f, 0.00274438f, 
    -0.01853515f, 0.02102727f, 0.02398028f, -0.03147632f, -0.03070179f, -0.03662755f, -0.01901773f, 0.01359039f, 
    0.00927757f, 0.00469777f, 0.02012688f, -0.00518284f, -0.03200799f, -0.00264763f, 0.01087924f, 0.01464879f, 
    0.00160358f, 0.01995437f, -0.03707503f, -0.01923693f, 0.02695958f, 0.01417157f, -0.00838298f, -0.00898214f, 
    0.00648258f, -0.02589497f, -0.01699120f, 0.01137728f, 0.03240747f, 0.02451263f, 0.00632835f, -0.02448561f, 
    0.00427404f, 0.00598885f, -0.03796516f, -0.02238133f, -0.00365634f, -0.01497577f, 0.00868273f, -0.00328460f, 
    0.00432826f, -0.03180105f, 0.01610820f, -0.00664504f, -0.02093997f, -0.04120158f, 0.00958874f, -0.00463537f, 
    0.01097798f, -0.03239645f, 0.00440270f, 0.00466120f, -0.01765158f, -0.01685093f, -0.02486156f, -0.02999951f, 
    -0.01722600f, 0.02909560f, 0.00355103f, 0.01006586f, -0.03979525f, 0.00624209f, 0.01115610f, 0.02780665f, 
    0.01079974f, -0.01959215f, 0.02625204f, 0.00950828f, -0.03396032f, -0.03734481f, -0.02723073f, -0.00442179f, 
    -0.01226977f, 0.02421054f, -0.01332968f, -0.01411919f, -0.03441573f, 0.02210136f, 0.00814234f, -0.03621974f, 
    -0.00677135f, 0.00189108f, 0.02037050f, -0.01763865f, 0.01544468f, -0.03868169f, 0.00952955f, -0.00989179f, 
    0.02948004f, -0.00219846f, 0.01491217f, -0.03492104f, -0.00888346f, 0.00815283f, 0.00536504f, -0.03343141f, 
    0.02171848f, -0.01984544f, 0.00596286f, -0.01164600f, -0.00867038f, 0.01677207f, -0.03550366f, -0.01755703f, 
    0.00062907f, -0.01376515f, 0.02220486f, -0.02069381f, -0.00520319f, -0.02186497f, -0.03838354f, 0.02998925f, 
    -0.02009965f, -0.03985908f, -0.01553924f, 0.01263065f, 0.02345692f, 0.01187008f, -0.03302401f, -0.00311596f, 
    0.00308817f, -0.00060522f, 0.02029668f, 0.01449728f, 0.01543015f, -0.02923602f, -0.01003348f, -0.01195271f, 
    -0.03497566f, -0.02213676f, -0.04087172f, -0.02735036f, -0.01440089f, -0.03890631f, 0.01307600f, -0.03949938f, 
    -0.03208302f, -0.02219866f, -0.03629919f, -0.00242692f, -0.03010112f, 0.00763430f, -0.01805994f, -0.02356830f, 
    -0.01532456f, -0.00878056f, 0.02938014f, -0.00585131f, -0.01759784f, -0.02155418f, 0.03793831f, 0.02773700f, 
    -0.00148821f, -0.02055139f, 0.01542633f, 0.02178852f, 0.02435776f, -0.03047797f, -0.01797928f, -0.03542865f, 
    0.00860342f, -0.03720550f, 0.02029189f, -0.02077482f, 0.01284558f, -0.00598522f, 0.02977671f, 0.02631461f, 
    -0.02444585f, -0.00271410f, 0.00779492f, -0.03380549f, -0.01461247f, 0.00544433f, 0.02630623f, -0.02707524f, 
    -0.04207121f, -0.02855558f, -0.03412254f, 0.00193822f, -0.04132148f, 0.00944822f, -0.02908128f, 0.00878736f, 
    -0.00310734f, -0.02488299f, -0.00172368f, -0.01038170f, 0.02957580f, -0.01027829f, -0.00566280f, 0.00261232f, 
    -0.03974892f, -0.03430203f, 0.01463728f, -0.02497268f, -0.03345420f, 0.00516340f, -0.03124848f, -0.03678161f, 
    0.00548762f, 0.00809555f, -0.03239317f, -0.02332769f, 0.02703758f, 0.02948396f, -0.03240117f, 0.01039750f, 
    0.02616144f, -0.00510366f, -0.02418785f, 0.02285753f, 0.00322491f, -0.01907057f, 0.00924042f, 0.00850400f, 
    0.02500569f, 0.00192245f, -0.00650132f, -0.01832729f, -0.01487217f, 0.00198810f, -0.01033775f, -0.00701055f, 
    -0.03111961f, -0.01640087f, -0.03054437f, 0.01386723f, 0.02919180f, 0.00562973f, -0.03464874f, 0.01436885f, 
    0.00408388f, -0.00437709f, -0.00783408f, 0.00098208f, -0.00529041f, -0.02026188f, -0.03968421f, -0.01188919f, 
    -0.01732030f, 0.01310448f, -0.01402584f, 0.01813595f, 0.00363867f, -0.00533266f, 0.00069597f, -0.01957645f, 
    0.02389122f, -0.02049796f, 0.01627825f, 0.02555260f, -0.01080594f, 0.00155063f, -0.02499762f, 0.02965713f, 
    0.00635086f, -0.00669137f, 0.02773628f, -0.00407949f, -0.00214021f, 0.01029229f, 0.00521070f, 0.00167173f, 
    -0.02639345f, -0.03494124f, 0.02409583f, 0.02612069f, -0.02106846f, -0.03183477f, -0.03142346f, -0.02236922f, 
    -0.02564062f, -0.03616221f, -0.03179661f, -0.01932592f, 0.01546476f, -0.01665800f, 0.02436308f, -0.00889756f, 
    0.00737674f, -0.03764417f, 0.02100241f, -0.00326532f, -0.03760841f, -0.01403298f, 0.02326672f, -0.02579007f, 
    -0.02655611f, 0.03003662f, 0.01906605f, 0.01248763f, 0.01688179f, -0.02497868f, 0.01007542f, 0.00559139f, 
    -0.01662558f, -0.03904105f, -0.02139017f, 0.01054531f, 0.00266350f, -0.00211606f, 0.02195926f, -0.00977237f, 
    -0.01474990f, 0.02220809f, -0.02669117f, 0.00234037f, -0.01844210f, 0.02434785f, -0.01748984f, -0.03841519f, 
    0.00071874f, -0.02909200f, -0.04190599f, -0.01655920f, -0.03601628f, 0.02290635f, 0.01914160f, 0.01373301f, 
    -0.03212437f, 0.02564471f, -0.00133285f, -0.00523299f, 0.02877348f, -0.00151389f, -0.00500004f, -0.02565982f, 
    0.01342546f, -0.00980587f, -0.00175396f, -0.00072545f, -0.01248028f, -0.00663424f, -0.03206583f, -0.02394009f, 
    -0.01697854f, -0.01540595f, -0.03376083f, 0.00234708f, -0.00490463f, -0.00539097f, 0.01930541f, 0.00680665f, 
    0.01279877f, -0.00881128f, 0.02116689f, -0.00502860f, 0.01098370f, 0.01055981f, -0.03539900f, 0.00611969f, 
    0.02820152f, -0.03397117f, -0.02788207f, -0.00222564f, 0.02425833f, 0.00180407f, 0.01766991f, -0.01915227f, 
    0.00525028f, 0.00794754f, -0.02712535f, 0.03316785f, 0.02378507f, 0.02279302f, -0.03385473f, -0.02370666f, 
    0.00423368f, 0.01080209f, -0.01521511f, 0.00924019f, -0.04120483f, 0.01861122f, -0.03847533f, 0.03566337f, 
    -0.03819849f, -0.01999735f, 0.02883734f, 0.02760326f, 0.02919922f, -0.02334751f, -0.00737806f, -0.03195780f, 
    -0.03244501f, -0.02180227f, -0.00453171f, 0.02389487f, -0.00627511f, 0.01917431f, 0.02102425f, 0.00682100f, 
    -0.00000591f, 0.03670279f, -0.01996073f, -0.04133997f, 0.00648046f, -0.03293473f, -0.00548344f, -0.00726414f, 
    0.01310046f, -0.00126867f, -0.02649868f, 0.01861452f, 0.02586429f, -0.03832300f, -0.02918022f, -0.00278549f, 
    0.01583775f, -0.02532066f, 0.01558613f, 0.03684049f, 0.02129691f, -0.00418886f, -0.02133758f, -0.01397536f, 
    0.00553810f, -0.00774642f, -0.00905785f, 0.01814221f, 0.02484008f, 0.01590435f, -0.03397160f, 0.02402129f, 
    -0.03485588f, -0.00955556f, -0.01632807f, -0.01988424f, -0.00717449f, -0.03806934f, -0.01914231f, -0.01569015f, 
    -0.00017656f, -0.01402811f, -0.02447949f, 0.00740156f, -0.02715066f, -0.00977481f, -0.03789314f, -0.03906124f, 
    -0.02606289f, -0.00302957f, 0.01884684f, -0.04196807f, 0.00409735f, -0.03368213f, -0.03672104f, -0.02535570f, 
    -0.01436873f, -0.01437875f, 0.02505669f, 0.02639423f, -0.01364049f, 0.01372269f, -0.03010572f, -0.03703679f, 
    0.02528354f, 0.02395649f, -0.01931535f, -0.00960673f, 0.00003227f, 0.01282129f, -0.03287946f, -0.02435347f, 
    -0.02444933f, -0.00536084f, 0.00360887f, -0.00236085f, -0.01818554f, 0.02926485f, 0.02214180f, 0.01766219f, 
    0.01441341f, 0.03004146f, 0.01691283f, 0.02334988f, 0.02575673f, -0.01357066f, -0.00908333f, -0.02225690f, 
    -0.00433730f, -0.03400970f, -0.02553372f, -0.03072859f, -0.02849778f, 0.01550109f, -0.02844851f, -0.03365912f, 
    -0.01330885f, -0.02326584f, 0.01063348f, 0.00301304f, -0.01660566f, 0.01036128f, 0.01139997f, -0.02622821f, 
    0.00897246f, -0.00369625f, -0.00916651f, -0.01177726f, 0.02256191f, -0.02168355f, 0.02844351f, -0.04020354f, 
    -0.01490937f, -0.00467234f, 0.02917883f, -0.02375368f, 0.00696835f, -0.03671381f, -0.00354346f, -0.03770297f, 
    -0.02632891f, -0.00112650f, -0.00073783f, -0.02361922f, -0.03877165f, -0.04138775f, -0.03777157f, 0.01817075f, 
    -0.03261909f, -0.00257704f, -0.03220517f, -0.00873643f, 0.02946527f, 0.01250216f, -0.02888081f, -0.02391780f, 
    -0.03374345f, -0.03791878f, -0.00323958f, 0.00999527f, 0.03215605f, -0.00411510f, 0.02871593f, 0.03738002f, 
    0.00639769f, -0.02441753f, 0.02256970f, -0.02196185f, -0.02852693f, 0.00825554f, 0.02119113f, 0.00254616f, 
    -0.03066590f, -0.03088895f, -0.02224965f, 0.00639518f, -0.04115965f, -0.00302220f, 0.02464655f, 0.00894611f, 
    -0.00166886f, -0.02846726f, -0.03934624f, 0.02026494f, -0.00276977f, -0.01861766f, 0.00952130f, -0.02236884f, 
    -0.02682129f, 0.01393291f, 0.01334799f, -0.01077061f, 0.02793464f, 0.00408766f, 0.00270386f, 0.01157951f, 
    0.00095173f, -0.01739014f, 0.01130032f, -0.03425869f, 0.01193079f, 0.02483114f, -0.00141405f, 0.00946446f, 
    -0.01635399f, 0.01918942f, -0.00415787f, -0.03908779f, -0.02406345f, 0.02738873f, -0.01143955f, -0.02709751f, 
    -0.03384413f, 0.00336634f, 0.00497832f, 0.01872510f, -0.03124108f, -0.03221374f, -0.00014073f, 0.02891240f, 
    -0.04167747f, 0.03528433f, 0.00570542f, -0.00808617f, -0.02442677f, -0.01016080f, -0.01738341f, 0.00004123f, 
    -0.00740815f, 0.03364462f, 0.00390068f, 0.01371267f, 0.00965575f, -0.01250063f, -0.04147895f, 0.02432588f, 
    0.00949636f, 0.01803773f, 0.02677005f, -0.02086022f, -0.00808627f, -0.02868824f, -0.01172021f, -0.02568060f, 
    -0.01999852f, -0.01092028f, 0.00261943f, 0.03446069f, -0.03210549f, -0.00513404f, -0.02028761f, 0.00048245f, 
    -0.01352856f, 0.01043115f, -0.00126886f, -0.01599030f, -0.04195438f, 0.01247664f, -0.01552626f, -0.03066853f, 
    -0.02282787f, 0.01888149f, -0.01235100f, 0.00689675f, -0.00755986f, 0.00170139f, 0.02190576f, -0.00473741f, 
    -0.02640269f, -0.02342113f, -0.02374358f, -0.01222066f, -0.01654455f, -0.01102119f, -0.03523488f, 0.01639209f, 
    0.01538737f, -0.00098119f, 0.01480981f, 0.02664345f, -0.00480383f, -0.03823821f, -0.03963956f, -0.00652779f, 
    -0.01025828f, 0.02327194f, 0.01823726f, -0.00860295f, -0.00297108f, 0.00767902f, -0.03533360f, -0.01587874f, 
    -0.00330523f, 0.02390264f, -0.02797593f, 0.00521553f, -0.02734361f, 0.01734560f, 0.00643092f, -0.00810648f, 
    0.00010497f, -0.03778828f, -0.02208362f, 0.00344290f, -0.00074411f, -0.03770838f, -0.02010663f, -0.03556619f, 
    0.02079197f, 0.01989867f, -0.01862988f, -0.03557937f, -0.00619832f, -0.01243470f, -0.03644388f, 0.01167009f, 
    0.03592838f, -0.17864391f, -0.05861459f, 0.05612993f, 0.02205836f, -0.04090864f, -0.02401291f, 0.05965943f, 
    0.02671770f, -0.04871202f, -0.06415357f, -0.07352065f, -0.06958845f, -0.09572113f, -0.04176676f, 0.05728133f, 
    0.06526574f, -0.02698429f, -0.08650625f, 0.01089436f, 0.09781948f, 0.05958944f, 0.17068057f, 0.02934047f, 
    0.04377347f, 0.16148922f, 0.15446131f, -0.13776028f, -0.04580180f, 0.04205684f, 0.01093164f, -0.05736732f, 
    0.00306604f, 0.07102092f, 0.09332468f, 0.03679152f, 0.03079405f, 0.15986191f, 0.17863990f, 0.02317876f, 
    -0.04296833f, -0.10853146f, 0.07605145f, -0.02462117f, -0.13898140f, -0.05240820f, 0.04536242f, -0.01307352f, 
    0.00378847f, 0.17643437f, 0.10482776f, -0.07839001f, -0.00082021f, 0.04489559f, 0.10107899f, 0.00837440f, 
    -0.08050032f, -0.01827470f, 0.07417148f, -0.08849207f, -0.12070540f, 0.02014505f, 0.06244633f, 0.02265674f, 
    -0.07573590f, 0.03217226f, -0.02429643f, 0.06133005f, -0.09813414f, -0.13739097f, 0.04902615f, 0.12309325f, 
    -0.20654301f, -0.11427452f, -0.22565071f, -0.03773773f, 0.01998279f, 0.00075232f, -0.00841014f, -0.02393517f, 
    0.00062806f, 0.07553482f, -0.02026059f, 0.02153298f, 0.07513756f, 0.21393375f, 0.06469291f, 0.10431429f, 
    -0.14840770f, -0.00230085f, 0.06873109f, -0.00624050f, -0.05907390f, -0.00719822f, 0.03258674f, -0.02591239f, 
    -0.11959476f, -0.15287673f, 0.15042709f, 0.05355493f, -0.04070185f, 0.00871261f, 0.15043131f, -0.04777077f, 
    -0.01306801f, 0.03509573f, 0.02278654f, 0.07215761f, 0.12682088f, -0.11564688f, -0.03689155f, -0.11109044f, 
    0.01117278f, 0.07380386f, -0.00365245f, -0.06988656f, -0.01879043f, 0.00360977f, 0.05606710f, -0.03502377f, 
    -0.07340312f, -0.23235886f, -0.01768541f, 0.24341615f, 0.07828211f, -0.08763256f, 0.06871909f, 0.05303907f, 
    0.00013993f, 0.08137820f, 0.05011611f, 0.02867878f, -0.18272662f, -0.00997473f, 0.14404429f, 0.07843465f, 
    -0.08544404f, -0.08928920f, 0.03368371f, 0.08127319f, 0.03771028f, -0.17984529f, -0.12232020f, -0.05752831f, 
    -0.01170824f, 0.00936405f, -0.15337175f, -0.11599684f, 0.05334753f, 0.07911088f, -0.00669888f, 0.02621759f, 
    -0.03527045f, 0.03958891f, -0.07413200f, -0.01534185f, 0.09498747f, -0.11756263f, -0.10272931f, -0.10874446f, 
    -0.04654723f, 0.09142246f, -0.03152066f, -0.05373708f, -0.05357322f, -0.07109046f, -0.02291025f, 0.05864151f, 
    0.20715916f, 0.06579258f, 0.00923412f, -0.09299015f, 0.04091915f, 0.04502562f, 0.08495628f, -0.00889934f, 
    0.03822936f, -0.00485086f, 0.02042620f, -0.01607772f, 0.12991235f, -0.04553301f, 0.11208700f, -0.02287612f, 
    -0.00198418f, 0.00933662f, 0.06139999f, 0.12263298f, -0.02547412f, 0.03266931f, -0.01831736f, 0.04334363f, 
    0.15679254f, 0.16070104f, 0.14453925f, 0.01976679f, -0.08529730f, 0.14274517f, 0.07274794f, -0.04911841f, 
    0.08547489f, 0.00030643f, -0.05091794f, 0.13455059f, 0.21861738f, -0.10238642f, -0.05812012f, -0.03718430f, 
    0.05207729f, -0.01308450f, -0.02167575f, -0.00240980f, 0.04433341f, -0.04860872f, 0.01400831f, -0.00146496f, 
    0.14829259f, 0.06656881f, 0.19628471f, -0.04689718f, -0.02797040f, -0.04970612f, 0.04208581f, 0.05960105f, 
    0.03293003f, 0.02784504f, 0.01957575f, 0.08261428f, 0.04579083f, 0.01784108f, -0.09640928f, 0.10741399f, 
    -0.01921099f, -0.02650325f, -0.01673670f, 0.05038534f, 0.00662992f, 0.05326517f, -0.02520707f, -0.02519730f, 
    -0.33260304f, -0.09737632f, -0.18674484f, -0.14124683f, 0.04068877f, -0.03898773f, 0.09858068f, 0.08068417f, 
    0.02103595f, -0.04492266f, -0.01792920f, -0.06450171f, -0.32576132f, -0.20683269f, -0.29513180f, -0.15306722f, 
    -0.00581084f, 0.01836980f, 0.02317143f, -0.10102245f, -0.04245139f, 0.10957754f, 0.00184870f, 0.04122173f, 
    -0.02873654f, -0.02187063f, 0.00112690f, 0.13847707f, 0.08986741f, -0.00734246f, 0.09907155f, 0.09521795f, 
    0.03153843f, 0.01416200f, 0.00371950f, 0.02777960f, -0.10849411f, -0.02674314f, 0.02004279f, 0.18492942f, 
    -0.00489667f, -0.13572584f, 0.06563895f, 0.02234626f, 0.01663695f, -0.08188345f, -0.02390932f, 0.07770389f, 
    -0.00585783f, 0.06543090f, -0.03092290f, 0.03517568f, 0.07487187f, -0.02132465f, 0.01984775f, 0.10043154f, 
    -0.05882661f, -0.00234810f, -0.14678395f, -0.06041353f, -0.06975371f, 0.20061159f, 0.07857721f, 0.13760540f, 
    -0.08751640f, 0.02528370f, 0.01323126f, 0.10321313f, -0.03621686f, -0.07274380f, -0.03308336f, -0.12030777f, 
    0.23453218f, 0.21658991f, 0.16471319f, -0.10507080f, 0.03717367f, 0.10045598f, 0.01779100f, -0.01793899f, 
    -0.01405411f, 0.20552731f, -0.01153815f, 0.01079128f, 0.13518763f, 0.07659359f, -0.09203722f, -0.02595627f, 
    -0.05320536f, 0.07985688f, 0.00066505f, 0.06901053f, -0.01357603f, 0.05662277f, -0.03626114f, 0.11636248f, 
    0.00371217f, -0.22299844f, -0.07425737f, -0.14925496f, 0.02320724f, 0.01680759f, 0.04164580f, -0.13229530f, 
    -0.05722643f, 0.06196020f, -0.00489690f, -0.05948561f, 0.14132695f, 0.07573575f, 0.12870176f, -0.12458213f, 
    0.00996050f, 0.05876700f, 0.06084238f, 0.03699699f, 0.09004072f, 0.00718988f, 0.04998153f, -0.00031490f, 
    0.04453825f, 0.29420945f, 0.23005305f, -0.07604310f, 0.03819019f, -0.06556419f, 0.12520425f, -0.01438425f, 
    0.02493202f, -0.02458300f, 0.15081613f, -0.01018287f, 0.13807672f, 0.25014177f, 0.11954049f, -0.02816036f, 
    -0.05115823f, 0.06739455f, 0.02371068f, -0.01034686f, -0.00214125f, 0.09411048f, -0.02494334f, 0.07924838f, 
    0.03705998f, 0.01132487f, -0.19626464f, -0.00560729f, 0.08728244f, -0.06940491f, 0.01383903f, 0.02666304f, 
    0.00407814f, -0.07167543f, -0.03098848f, -0.03983673f, -0.21328609f, -0.14381455f, -0.14241749f, 0.08140620f, 
    0.03139715f, -0.05859139f, 0.03702834f, -0.01196648f, -0.01881414f, -0.09359005f, -0.05425962f, 0.01656257f, 
    0.01905715f, -0.18882558f, 0.04948891f, -0.15256871f, 0.03769585f, 0.03390992f, 0.06994485f, -0.02186397f, 
    0.06834020f, 0.01195055f, 0.07051782f, -0.04243529f, 0.08992352f, -0.11334005f, -0.14063464f, 0.04127140f, 
    0.00371218f, 0.04501250f, 0.01476142f, 0.02873618f, 0.03658953f, -0.07022667f, -0.05464655f, -0.00289005f, 
    0.12029120f, -0.33538827f, -0.01847045f, -0.20614669f, 0.06362854f, 0.07395489f, 0.06881708f, -0.09972759f, 
    -0.03247277f, -0.04946123f, -0.03329799f, -0.04797199f, -0.16166146f, 0.11766293f, 0.16542748f, -0.09130911f, 
    -0.00471400f, -0.05147454f, 0.11309954f, -0.07960351f, -0.01004342f, -0.04148030f, 0.02872248f, -0.00332677f, 
    0.15107955f, -0.06624286f, -0.17485288f, -0.16161208f, 0.03059929f, 0.14863263f, -0.01353322f, -0.00885160f, 
    -0.01837346f, 0.02092270f, 0.02101562f, -0.10294608f, 0.23882726f, 0.00533401f, -0.04488005f, 0.03370800f, 
    -0.04755123f, 0.08623026f, -0.00241828f, -0.12908305f, 0.00022974f, -0.03446588f, -0.02180466f, 0.05518480f, 
    -0.17349491f, -0.12405701f, -0.01708649f, 0.00159934f, 0.04220565f, -0.04071214f, 0.00466575f, 0.00782057f, 
    0.08870114f, 0.05114998f, -0.01369310f, 0.12494887f, 0.02452316f, 0.19045384f, 0.35579130f, -0.20163606f, 
    -0.01387696f, 0.00279480f, 0.00480269f, 0.04431769f, -0.02342698f, -0.00376620f, 0.09438181f, 0.00130465f, 
    -0.09634260f, 0.01354381f, 0.31773001f, -0.09898335f, 0.03130436f, 0.05477328f, 0.00483489f, -0.03651669f, 
    -0.04358541f, -0.09298769f, -0.01656875f, 0.02471962f, -0.30309513f, -0.19854407f, 0.02288838f, -0.25258777f, 
    0.06314082f, 0.09540083f, -0.00658797f, -0.04228856f, 0.08053840f, 0.04530517f, 0.06813639f, -0.01855449f, 
    -0.04328154f, -0.14297938f, 0.11257661f, -0.29353526f, -0.01311104f, 0.05512138f, -0.01499894f, 0.03370714f, 
    0.11293891f, 0.03559522f, 0.02937294f, -0.03442433f, 0.13194637f, -0.06243294f, -0.00350310f, 0.17664921f, 
    0.02272135f, 0.05597582f, 0.05706338f, -0.01706163f, -0.06103208f, 0.07264917f, 0.05116368f, -0.06593560f, 
    0.08746330f, 0.14100261f, -0.02002091f, -0.07694483f, -0.03967188f, -0.07347208f, -0.00477853f, 0.00949496f, 
    0.09349298f, -0.01298944f, 0.03886146f, 0.07596491f, 0.06452960f, 0.21821176f, 0.02180303f, 0.04612492f, 
    -0.12417435f, -0.02403532f, 0.02595268f, -0.00101355f, -0.04273431f, -0.05189195f, -0.05059858f, -0.08266337f, 
    -0.04532136f, 0.22869335f, 0.04036012f, 0.08948083f, -0.05567991f, -0.01566081f, 0.03702612f, 0.02334627f, 
    -0.03417132f, -0.00278673f, 0.02454832f, -0.14964154f, 0.10800815f, -0.16567224f, -0.07025972f, 0.21508113f, 
    -0.05471507f, -0.06275565f, 0.00126582f, 0.14695078f, 0.01032391f, 0.12639111f, 0.04186717f, -0.06515016f, 
    -0.00342017f, 0.19890824f, 0.16868150f, 0.17072482f, 0.09277966f, -0.00219618f, 0.09134138f, -0.02452782f, 
    0.02996551f, 0.03537091f, 0.00417724f, -0.00170406f, 0.08517404f, -0.00007768f, 0.18263188f, -0.07148101f, 
    0.01360797f, -0.04307452f, -0.01406465f, 0.06984052f, 0.09924710f, -0.03217618f, 0.09361613f, 0.08584743f, 
    -0.02880113f, 0.10334656f, 0.16449495f, 0.30148870f, -0.08944441f, -0.05149618f, 0.01860831f, 0.01587198f, 
    0.01086991f, -0.06061322f, -0.10236980f, 0.04837738f, -0.02313945f, 0.15270869f, 0.10694855f, 0.13660669f, 
    -0.05598414f, -0.04674103f, 0.07347111f, 0.05363119f, -0.05614905f, -0.05936814f, -0.02434538f, 0.03395856f, 
    -0.21029378f, -0.08184187f, 0.06837091f, 0.39480472f, -0.01430756f, -0.09731913f, 0.07804702f, -0.03368000f, 
    0.05035425f, -0.00122583f, 0.02783502f, 0.06470805f, -0.02270011f, -0.00652620f, -0.05759219f, 0.09345087f, 
    0.05246067f, 0.02951048f, 0.06000146f, 0.00656927f, -0.00827796f, 0.06516835f, -0.07430410f, -0.04942876f, 
    -0.17993484f, -0.03268427f, -0.05914067f, -0.06749487f, -0.04337292f, 0.05220823f, 0.05523727f, 0.06321310f, 
    0.09511516f, 0.01089823f, 0.04988280f, 0.02978473f, -0.09823194f, 0.09544027f, 0.06333061f, 0.01671785f, 
    0.20540749f, 0.06380490f, 0.09065733f, -0.10828556f, 0.01761586f, 0.06798275f, 0.08137059f, -0.09925898f, 
    -0.06951427f, -0.08703126f, -0.24405830f, -0.04340835f, 0.03300461f, 0.01336632f, -0.00293542f, 0.05094704f, 
    0.00427699f, 0.02454492f, 0.10404244f, -0.04082345f, -0.16799422f, -0.05645283f, -0.05746441f, 0.03361965f, 
    0.03974944f, 0.08704054f, 0.09178556f, -0.14044553f, 0.04812498f, -0.03484849f, -0.05755704f, 0.04714300f, 
    -0.04689395f, 0.05960981f, 0.07809405f, 0.00011343f, 0.02631153f, 0.02001025f, 0.01816293f, -0.01999111f, 
    0.01239491f, -0.02826469f, 0.02040163f, -0.07047065f, 0.06089377f, 0.02398631f, 0.26739848f, -0.11472262f, 
    0.01634813f, -0.03627216f, 0.11851636f, 0.01602129f, 0.10403203f, -0.08352561f, -0.03883686f, 0.09077396f, 
    0.17100953f, 0.25476873f, 0.06867739f, 0.02861751f, 0.06657312f, 0.03651290f, -0.01531895f, -0.02459542f, 
    0.02639187f, 0.04809381f, 0.04193641f, 0.00335881f, -0.34984711f, -0.01296136f, -0.03932040f, 0.14069122f, 
    -0.04218283f, 0.05295319f, -0.10215051f, 0.00661077f, -0.03917826f, -0.02526241f, -0.06285927f, -0.02792637f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04435724f, 0.01724480f, 0.03066818f, -0.01869878f, 0.02293248f, -0.00199638f, 0.00080084f, 0.00229588f, 
    -0.00386378f, 0.01226287f, -0.03109106f, 0.05332531f, 0.01638504f, -0.03763166f, -0.02451184f, 0.01463874f, 
    -0.03997368f, -0.00949804f, 0.02303551f, 0.01310001f, 0.00317968f, -0.01454305f, 0.04651445f, 0.09915189f, 
    -0.00783039f, 0.00424600f, -0.00403030f, 0.07567139f, 0.01170042f, 0.03252618f, -0.00850680f, 0.03494522f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.44798458f, 0.17021026f, -0.53817713f, 0.09555050f, 0.03396370f, 0.09685701f, 0.01040573f, -0.16154277f, 
    -0.27310851f, -0.31430912f, 0.01822314f, -0.53757960f, -0.11793847f, -0.11773855f, 0.32492515f, 0.02676585f, 
    0.12099408f, 0.24599376f, 0.13294490f, 0.06439646f, 0.16250660f, -0.11866370f, 0.13417515f, -0.21256213f, 
    -0.11110318f, 0.08477467f, -0.19468448f, -0.07787988f, 0.12217102f, 0.31378615f, -0.14860338f, 0.07385000f, 
    0.19548513f, 0.14802651f, -0.25833070f, -0.13664663f, -0.00072774f, 0.12317222f, 0.09854240f, 0.15200311f, 
    -0.53926176f, 0.03109790f, 0.09868164f, 0.25640613f, 0.33828634f, -0.12314299f, -0.27482015f, -0.53990060f, 
    -0.05605194f, 0.21259129f, 0.14480872f, 0.04880382f, 0.17679891f, 0.00399698f, -0.11209264f, 0.14687686f, 
    -0.05524743f, 0.05361538f, -0.34412137f, 0.06000094f, -0.04217279f, -0.19797194f, -0.14370656f, -0.08135433f, 
    -0.40200216f, 0.11708808f, -0.11318720f, -0.01096740f, -0.08534404f, 0.04065913f, 0.10761786f, 0.13817896f, 
    0.43920457f, 0.00316570f, 0.09438170f, -0.01522973f, 0.02891993f, 0.06324157f, -0.26370969f, 0.16618034f, 
    0.13285546f, 0.20713262f, 0.16552547f, -0.03068437f, -0.20049958f, 0.10897808f, 0.25554952f, 0.05089312f, 
    -0.17495030f, 0.02339523f, 0.04090748f, -0.38808784f, 0.02778719f, -0.65569687f, 0.16794330f, 0.09906916f, 
    0.15215842f, -0.00957502f, 0.27517018f, -0.08818955f, 0.01480445f, -0.11033223f, -0.16195649f, 0.11641357f, 
    -0.23819502f, 0.38184845f, -0.05235044f, -0.13478674f, -0.37245768f, 0.09480809f, 0.29951224f, 0.02540308f, 
    0.03893926f, -0.08005174f, 0.08422859f, 0.07356305f, 0.02762596f, 0.08992943f, 0.28563082f, -0.56143081f, 
    0.17339660f, 0.02474282f, -0.32671392f, -0.13298717f, 0.00700445f, 0.19530590f, 0.14996874f, -0.48400030f, 
    0.00044598f, -0.04317848f, 0.00205026f, -0.02815332f, 0.02085997f, -0.10369369f, -0.02220258f, 0.01867978f, 
    0.23064169f, 0.14517936f, -0.03117552f, 0.40994444f, -0.45047599f, -0.06659193f, 0.31727505f, -0.42496631f, 
    0.12727885f, 0.01424341f, 0.01206308f, -0.04722052f, 0.23110580f, 0.09725416f, -0.30838338f, -0.01274501f, 
    0.08730356f, 0.09837197f, 0.27959397f, -0.18040349f, -0.15878984f, 0.17353980f, 0.10321106f, -0.23429042f, 
    -0.29986930f, 0.09068187f, 0.26217604f, -0.12442503f, -0.09214859f, 0.02610365f, -0.05347268f, 0.10604516f, 
    -0.28628799f, 0.11917227f, -0.15107951f, -0.40757275f, 0.34078458f, 0.17268863f, 0.01467319f, -0.09250236f, 
    0.10174966f, -0.20825848f, -0.07569984f, -0.06179111f, 0.06653698f, -0.07012130f, -0.22154216f, 0.25728899f, 
    -0.12718630f, -0.14271393f, 0.21259211f, -0.01267972f, -0.01778137f, 0.21673538f, 0.11241296f, 0.42949679f, 
    0.16680393f, -0.00624107f, 0.19327305f, 0.15974504f, -0.16585487f, 0.10856573f, -0.02362846f, -0.08647545f, 
    0.41164270f, -0.21217747f, -0.10333199f, 0.06769371f, -0.43036002f, -0.12706593f, -0.52276897f, 0.07863961f, 
    -0.13321334f, -0.23878355f, 0.02863945f, 0.03628748f, 0.14961627f, 0.13732256f, 0.36818635f, 0.11545021f, 
    -0.06340618f, -0.11347372f, -0.19732985f, 0.24710412f, -0.13628395f, -0.09988528f, -0.04628283f, 0.31136900f, 
    0.01857729f, -0.13656066f, 0.30507362f, -0.13944069f, 0.10639119f, 0.12189627f, 0.00002285f, -0.02673920f, 
    0.50586802f, 0.14460221f, 0.01368446f, -0.15244335f, 0.23560588f, 0.02598703f, 0.07464947f, 0.20749211f, 
    -0.08825089f, -0.23486103f, -0.12388737f, -0.03617292f, 0.21315344f, -0.02519207f, -0.41950148f, -0.48829743f, 
    -0.00338067f, -0.14019340f, 0.27156165f, -0.39161149f, 0.00606754f, 0.11248608f, -0.00534353f, -0.52723318f, 
    -0.50859833f, -0.03524721f, 0.22749153f, -0.02848571f, 0.05505241f, 0.01381430f, 0.13217728f, -0.02882523f, 
    -0.03022992f, -0.18967763f, 0.14747447f, 0.20511572f, 0.20803073f, -0.14233935f, -0.24103992f, 0.30261683f, 
    -0.15758772f, 0.19988506f, -0.18231487f, 0.11502856f, -0.33426747f, 0.02426305f, -0.72156507f, 0.13857594f, 
    0.06031275f, 0.14715813f, -0.00551203f, 0.14339308f, -0.02154285f, -0.33538648f, -0.01961772f, -0.45053825f, 
    0.33768544f, -0.07496073f, -0.49081597f, -0.09589712f, -0.13574289f, 0.13793322f, 0.15533325f, -0.10240211f, 
    -0.07604637f, -0.50034732f, -0.13857198f, 0.30835044f, -0.26187840f, -0.14411825f, -0.23391189f, 0.40496057f, 
    -0.05999041f, 0.01210173f, -0.06245220f, -0.14957516f, 0.16911007f, -0.17073269f, 0.09710313f, -0.04140574f, 
    0.05926434f, -0.09559546f, 0.41724113f, -0.23465820f, -0.08071879f, 0.00029343f, 0.04877788f, -0.16296257f, 
    0.18644729f, 0.18209133f, 0.14838803f, 0.08062933f, -0.01235849f, 0.05584644f, 0.08604014f, 0.16115788f, 
    0.06756297f, 0.13122243f, 0.13669498f, 0.21503161f, 0.20080741f, -0.10307903f, -0.26516014f, 0.19984931f, 
    -0.00695026f, -0.25181824f, -0.11834704f, -0.09306913f, -0.40389043f, 0.03516632f, 0.26504627f, 0.50175929f, 
    0.15098363f, 0.11427000f, -0.39101475f, -0.15042017f, -0.15584373f, 0.22303122f, 0.02552876f, -0.53171754f, 
    0.22835405f, -0.16031572f, -0.18197984f, 0.14635001f, -0.09606367f, 0.15501283f, -0.15598759f, 0.14109936f, 
    0.01241892f, 0.36859167f, 0.03686892f, -0.39205515f, -0.46630087f, 0.18165857f, -0.09356765f, 0.26690876f, 
    -0.16000055f, 0.04223721f, 0.09688912f, -0.03608351f, -0.55617279f, 0.06247865f, -0.17927037f, -0.14460069f, 
    0.14043291f, -0.02886496f, 0.24309914f, 0.31088564f, 0.06638723f, -0.12645292f, 0.17044136f, -0.15700850f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06500994f, 0.12589660f, 0.01997623f, 0.07341181f, 0.08224397f, -0.17946006f, -0.14577483f, 0.05261917f, 
    -0.07163188f, 0.01091644f, 0.19366729f, 0.15513058f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
