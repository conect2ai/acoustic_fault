#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40997294f, 0.63127518f, -0.88316822f, -1.02239454f, 0.96869493f, -0.99732304f, -0.25968865f, -0.23568426f, 
    -0.17117782f, -0.05804392f, 0.64613342f, 0.68953574f, -0.11968689f, 0.26947647f, -0.10696142f, 0.19570851f, 
    0.27240106f, -0.38330999f, 0.06195367f, -0.04390604f, 0.13751055f, 0.77617693f, 0.86574078f, 0.26657024f, 
    -0.23956169f, -0.35070357f, -0.00290148f, -0.29679462f, -0.69914025f, -0.99190050f, 0.57992345f, 0.84365141f, 
    0.69416142f, -0.03018762f, 0.34451666f, -1.06533289f, -1.15097523f, -0.04752545f, 1.09681153f, -0.31331080f, 
    -0.65709704f, 0.22242376f, 0.16493797f, -0.79222643f, -0.40019548f, 0.65189600f, 0.08052391f, 0.51687068f, 
    -0.19375224f, 0.62747335f, 0.57915670f, 0.35372618f, 0.19476908f, -0.16419263f, -1.17877555f, -0.22479719f, 
    0.48721525f, 0.56058872f, 0.52344531f, 0.94879037f, 0.22486174f, 0.23831654f, 0.16915870f, 0.13479516f, 
    0.40590575f, -0.31416669f, -0.49116039f, 0.48581713f, 0.18405114f, 0.58313984f, 0.21416171f, 0.36831912f, 
    -0.51188302f, 0.53163874f, 0.55697757f, -0.88147771f, 0.63976347f, -0.10583138f, 0.40634599f, -0.03487863f, 
    0.06879754f, 0.16210307f, 0.36479583f, -0.08489313f, -0.93138313f, -0.70974767f, -1.12964058f, -0.17162022f, 
    -0.53635895f, 0.95839173f, 0.50459504f, -0.44765925f, -0.99775165f, -0.28543147f, 0.43988049f, 0.58529902f, 
    -0.39749017f, -0.82206744f, -0.63904929f, -0.38859290f, 0.63056797f, 0.80721712f, 0.58291626f, -0.14138581f, 
    -0.46435490f, -0.39572415f, -0.40397689f, -0.13760482f, 0.29012057f, 0.72822917f, 0.31062436f, -0.60321891f, 
    -0.48671237f, -0.17583220f, 0.03946351f, 0.50827056f, 0.57889789f, -1.18362367f, -0.31529698f, 0.41090268f, 
    -0.53348374f, -0.33839327f, -0.57211429f, -0.54022980f, 0.47016561f, -0.76539689f, 0.55373818f, 0.45603970f, 
    0.74844956f, -0.21339275f, 0.31987962f, -0.02240719f, 0.25777754f, -0.00494680f, 0.16950409f, -0.05600548f, 
    0.18402386f, 0.16546588f, 0.49541497f, 0.54415059f, -0.96597546f, 0.47519600f, 0.19758233f, 0.62477440f, 
    -0.08838785f, -0.39608842f, -0.40955955f, -0.80531782f, -0.88362634f, 0.02096663f, 0.70370746f, 0.16676277f, 
    0.80766582f, -0.37271366f, -0.45389989f, -0.06089961f, -0.79985893f, -0.43539986f, -1.03846025f, 0.75586414f, 
    0.01147091f, 0.24092069f, 1.56236541f, -1.33408308f, -0.33707309f, 0.69854742f, -0.38514668f, -0.06580522f, 
    -0.00339742f, 0.05939848f, -0.08448496f, -0.01175228f, 0.07279894f, 0.15909395f, 0.66241056f, -0.12621607f, 
    -0.37471899f, 0.21449427f, 0.81381994f, -0.63419664f, -0.58462965f, -0.22919713f, -0.76608515f, -0.58355427f, 
    -0.56326145f, -0.56441307f, -0.16777426f, -0.10845114f, 0.47403857f, -0.43221888f, -0.92339033f, 0.46048355f, 
    -0.09920964f, 0.30797809f, -0.42859995f, 0.18291813f, -0.25061688f, 0.72434115f, 0.60246634f, -0.12482350f, 
    0.57244897f, 0.30956465f, -0.55867803f, 0.03527894f, -0.05631935f, -0.29180145f, 0.37217069f, 0.92536992f, 
    0.70810771f, -0.99098086f, -0.25853401f, -0.04126955f, 0.07756551f, -0.34451512f, 0.25684741f, 0.16955367f, 
    -0.04090860f, 0.51270586f, 0.72685564f, -0.10441646f, 0.43652862f, 0.24221322f, -0.21924955f, -0.96684968f, 
    -0.50001568f, -1.13176858f, -0.73163074f, -0.46490645f, 0.14370193f, -0.33859316f, -0.51636809f, -0.55973905f, 
    -0.62581474f, -0.65830761f, 0.74133134f, 0.03971501f, -0.61655718f, -0.59844917f, -0.51848900f, -0.88134414f, 
    0.65104645f, 0.35494012f, 0.26759169f, 0.33864063f, -1.74194479f, 1.43462586f, -0.00986089f, -0.06595188f, 
    -0.35333669f, 0.05275321f, -0.11993735f, -0.02656034f, -0.24239115f, -0.25582317f, 0.51390731f, -0.46603015f, 
    -0.35955417f, -0.41444144f, 0.25174344f, 0.61930227f, 0.72668654f, 1.10259879f, 1.32205236f, -0.05542131f, 
    -0.57471293f, -0.46468523f, -0.42516014f, 0.06487464f, 0.21757333f, 0.04412220f, 0.63431126f, -0.42676297f, 
    0.54566282f, -0.64779067f, -0.08006539f, 0.20615414f, -0.38928318f, 0.93343449f, -0.61047143f, -1.27376342f, 
    -0.35791180f, 1.31853008f, 0.62523913f, -0.10074632f, 0.30669889f, -0.28791350f, -0.38505083f, 0.45125821f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17964345f, 0.52356684f, 0.38648590f, -0.02819626f, 0.34943414f, 0.76550829f, 0.02279436f, -0.26527506f, 
    0.32617238f, 0.15568265f, 0.28078395f, 0.07779276f, 0.13311492f, -0.68331349f, -0.01905540f, -0.09092753f, 
    0.07295218f, -0.05930536f, 0.01765532f, 0.67734760f, -0.42453381f, 0.36011782f, 0.48361689f, 0.06832551f, 
    -0.03918866f, -0.41738528f, 0.55991203f, -0.09133874f, 0.10986461f, 0.36085781f, 0.12632532f, -0.05989893f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05117977f, -0.11341973f, 0.18572144f, 0.07836033f, -0.04880020f, 0.03112870f, -0.03473917f, 0.28467607f, 
    -0.23908430f, -0.01419454f, 0.17940709f, 0.05107428f, 0.10748145f, -0.01041838f, -0.08704992f, 0.04406444f, 
    0.15118553f, -0.16610435f, 0.12288979f, -0.06023613f, 0.04328586f, -0.02937320f, -0.29381269f, 0.02324279f, 
    0.08274370f, -0.02403546f, 0.03981246f, -0.07191253f, -0.14499293f, 0.19905883f, -0.04094795f, 0.08669221f, 
    -0.11864305f, 0.08562635f, -0.04741631f, 0.05786160f, -0.32852289f, -0.01520822f, 0.29680938f, -0.08958632f, 
    0.00874881f, 0.18157803f, -0.03333480f, -0.06760024f, 0.09448736f, 0.06812572f, 0.10490049f, 0.09762397f, 
    -0.01691897f, -0.04446117f, -0.20997192f, -0.02057215f, -0.04229788f, -0.14111041f, 0.06794811f, 0.06975628f, 
    -0.32213399f, 0.33674425f, -0.27443451f, -0.19904631f, 0.04524822f, 0.04925579f, 0.07500791f, 0.17131974f, 
    0.06703826f, -0.10521466f, -0.25064376f, -0.24192624f, 0.01069725f, 0.05889584f, -0.01537187f, -0.06792527f, 
    0.32259268f, 0.40428898f, 0.06671312f, -0.05921264f, -0.07089660f, -0.11008834f, -0.02797268f, 0.11418045f, 
    -0.30103973f, -0.25070101f, -0.09332733f, 0.14367530f, 0.08418576f, 0.03641012f, -0.16588236f, -0.02236267f, 
    -0.14440057f, -0.08541035f, -0.01236025f, -0.01855817f, 0.00331334f, -0.04398272f, -0.05126459f, 0.31778547f, 
    -0.11026990f, 0.18064183f, -0.02168717f, -0.04548300f, 0.14786011f, -0.02378714f, -0.03015612f, 0.01954807f, 
    0.01928703f, 0.05150694f, 0.08557061f, 0.09267521f, 0.05156220f, 0.35360220f, 0.12024852f, 0.08543104f, 
    0.09712383f, -0.08211569f, 0.07140831f, 0.01466623f, 0.10249548f, -0.19886151f, -0.08957919f, -0.43426955f, 
    0.08444954f, 0.22975659f, 0.00776688f, 0.01458479f, -0.51736873f, 0.25195095f, 0.03217533f, 0.12083351f, 
    -0.01328449f, 0.16266602f, 0.01809011f, -0.10825891f, -0.02609758f, 0.00214206f, -0.01518042f, 0.16871683f, 
    0.14103986f, -0.04041877f, -0.07331517f, 0.02643575f, 0.00424744f, -0.05718269f, -0.10548829f, -0.12760496f, 
    -0.06111171f, -0.28074887f, -0.15768495f, -0.22792107f, -0.02936689f, 0.13233869f, 0.02921143f, -0.19496651f, 
    -0.18467440f, -0.24013659f, -0.32696143f, -0.50491244f, 0.03646545f, 0.05163115f, 0.13636729f, 0.10942993f, 
    -0.23593065f, 0.03701599f, 0.09837770f, -0.16581565f, 0.97524315f, -0.07135462f, 0.10729954f, 0.28132656f, 
    -0.09579994f, -0.17660280f, 0.24243802f, 0.09152369f, 0.19812290f, 0.23786318f, 0.11539784f, 0.00351703f, 
    -0.16007668f, -0.14919977f, 0.01384271f, -0.15358661f, -0.15680869f, -0.12862267f, -0.20077674f, 0.07249243f, 
    0.12565546f, -0.07703718f, -0.01136318f, -0.29769209f, 0.00431453f, -0.16336118f, -0.20720321f, 0.07461484f, 
    0.18706141f, 0.22969772f, 0.08056487f, -0.11872444f, 0.01551391f, -0.17583019f, -0.06512116f, 0.08937611f, 
    0.17481756f, 0.09951767f, -0.04530673f, -0.19064072f, -0.21271464f, -0.01337294f, 0.06873511f, -0.03589358f, 
    -0.02049221f, 0.37192163f, 0.09307326f, -0.01757042f, 0.14996582f, 0.15892804f, 0.08681141f, -0.01143068f, 
    0.05406919f, 0.03814387f, 0.09462040f, -0.03922294f, -0.10481149f, -0.07535471f, -0.03845892f, -0.13194419f, 
    -0.16441834f, -0.00783082f, -0.03105539f, -0.49410737f, 0.12283579f, -0.02251771f, -0.04389625f, -0.00754818f, 
    -0.17957653f, 0.21651995f, -0.32781073f, -0.26038706f, 0.22549793f, -0.05342482f, 0.11532096f, 0.08902824f, 
    0.00149969f, -0.06663505f, 0.00213263f, -0.52168012f, 0.42191589f, 0.81853777f, -0.05842490f, 0.11559246f, 
    0.07298374f, 0.14349261f, 0.15375158f, -0.01674774f, -0.00102084f, 0.12076753f, 0.02040219f, -0.00033367f, 
    0.07020321f, 0.10118136f, 0.11075153f, -0.09045178f, -0.05309292f, -0.13750271f, 0.00236832f, 0.05105895f, 
    0.17550628f, -0.05112348f, -0.00607079f, 0.03766966f, 0.22846438f, 0.06261427f, -0.20542145f, 0.02460124f, 
    0.42148051f, 0.11560874f, 0.21047175f, -0.10015084f, 0.26428178f, -0.16097631f, -0.21668373f, 0.09335645f, 
    0.14132658f, -0.22702098f, 0.18282564f, 0.08398078f, -0.01006689f, -0.07428613f, 0.09628922f, -0.08264363f, 
    0.03354627f, 0.10617781f, 0.24580187f, 0.00386468f, -0.07515313f, 0.23689416f, 0.07670015f, -0.29727232f, 
    0.03530624f, -0.17503060f, -0.15470511f, -0.00169448f, 0.16332842f, -0.01752196f, 0.27732822f, 0.09756070f, 
    -0.05974176f, 0.07127637f, 0.10995761f, -0.07598630f, -0.19605380f, 0.07496435f, -0.02432770f, 0.14623155f, 
    -0.16778027f, -0.16274031f, -0.21005619f, -0.40241873f, 0.14117116f, -0.40206715f, -0.00643444f, -0.13596322f, 
    0.38696605f, -0.27506411f, -0.32994395f, -0.13733736f, -0.24787503f, -0.16527423f, 0.42208758f, 0.10758696f, 
    -0.07183440f, 0.14894924f, 0.03217036f, -0.08234892f, -0.06878772f, -0.05528140f, -0.23636192f, -0.09549563f, 
    0.12243596f, 0.05422941f, 0.18149617f, 0.05068994f, 0.02075344f, 0.03312369f, 0.08174257f, -0.02376581f, 
    -0.06895579f, 0.26919666f, -0.11405245f, 0.04221779f, 0.12133905f, 0.09818745f, 0.15940700f, 0.13450578f, 
    0.01705702f, -0.01351652f, 0.15455109f, 0.16466501f, 0.01658605f, 0.01120843f, 0.14322282f, 0.07314651f, 
    -0.20990410f, -0.28653827f, -0.23836233f, 0.16408144f, -0.14605840f, 0.18229081f, 0.09385307f, 0.06787266f, 
    0.08260657f, 0.19197436f, 0.08708455f, 0.47006541f, 0.01807935f, 0.14450197f, 0.09601171f, -0.05928868f, 
    0.02364117f, -0.26398975f, 0.10756598f, -0.00099221f, -0.12486630f, -0.08074943f, 0.00960963f, 0.03063594f, 
    -0.18050796f, -0.10577279f, -0.21881498f, -0.00192667f, -0.27429122f, 0.11934932f, 0.08632179f, 0.02093381f, 
    0.20046970f, 0.14953728f, -0.25403607f, -0.45736954f, -0.05955366f, -0.03496000f, 0.22506858f, 0.10581743f, 
    -0.20137753f, -0.08589309f, -0.08921055f, 0.02171890f, -0.11942718f, -0.27066407f, -0.30921856f, 0.18025216f, 
    0.17904049f, 0.03646625f, -0.02273580f, 0.03748750f, 0.14793669f, -0.14654933f, -0.19527322f, -0.12666796f, 
    -0.08076201f, 0.02630294f, -0.09102470f, 0.20053957f, 0.02242890f, -0.00412918f, -0.08748730f, 0.05545361f, 
    -0.03015812f, -0.06094212f, 0.16688977f, -0.01480589f, -0.19379589f, 0.23341396f, 0.12116496f, 0.17126159f, 
    0.33356342f, -0.29502225f, 0.25113717f, 0.05995710f, 0.10563266f, -0.07614847f, 0.08480489f, 0.14669482f, 
    0.00899655f, 0.20701474f, -0.12148105f, 0.30359870f, 0.02610612f, 0.04723543f, 0.19954123f, -0.03042107f, 
    0.07232178f, -0.17010517f, 0.26344600f, -0.24535707f, -0.59585416f, -0.08501816f, 0.02503867f, -0.24703670f, 
    0.20275319f, -0.30648407f, -0.00268325f, 0.08335798f, 0.02091953f, 0.04746155f, 0.17576902f, 0.00171255f, 
    0.04602557f, 0.36562100f, 0.08745956f, 0.18248399f, -0.01918295f, -0.23708333f, 0.47918674f, 0.07260779f, 
    -0.01102878f, 0.09342323f, 0.10828339f, 0.02676463f, -0.00857896f, 0.02754395f, -0.15884762f, 0.18579987f, 
    0.05191421f, 0.13280389f, -0.17329122f, 0.08356370f, 0.19559146f, 0.19770871f, 0.04272554f, -0.20140871f, 
    -0.06832181f, 0.11421835f, -0.06771135f, 0.02373369f, 0.00393911f, 0.04873520f, -0.23214731f, 0.71238565f, 
    0.02450312f, -0.36617705f, 0.13976644f, 0.09230322f, -0.03256956f, -0.02371681f, -0.09167542f, 0.03906615f, 
    -0.03949533f, -0.25058198f, -0.05578407f, 0.04782499f, 0.12289820f, 0.17460187f, -0.19794936f, -0.37561265f, 
    -0.16393602f, -0.49224481f, -0.10929886f, 0.24326997f, 0.09239838f, 0.00087255f, -0.03197658f, 0.02183707f, 
    0.15826133f, -0.26557475f, 0.03997357f, -0.01543443f, 0.21516968f, -0.05846175f, 0.03793695f, -0.07393657f, 
    -0.00543015f, 0.15390512f, 0.04086855f, 0.61090094f, -0.49581444f, 0.39249933f, -0.07485952f, -0.09855560f, 
    -0.01499970f, -0.31738544f, 0.25038436f, -0.25678834f, -0.01685421f, -0.16271943f, 0.19012265f, -0.22982424f, 
    0.01788699f, -0.05460475f, 0.09674083f, 0.19516206f, 0.01478033f, 0.13206388f, -0.05888579f, -0.07484074f, 
    0.19202255f, 0.04194141f, 0.09082808f, 0.03477084f, 0.02939157f, 0.07848060f, 0.37114346f, -0.22810610f, 
    0.06593441f, 0.25802833f, -0.07594982f, 0.13118970f, -0.13379019f, -0.10556138f, -0.04323441f, -0.21152407f, 
    -0.19024920f, 0.12305868f, 0.16517375f, -0.18993475f, -0.18151143f, 0.04036972f, -0.05767689f, -0.19363916f, 
    0.14354697f, 0.14292715f, 0.27502638f, 0.13905698f, 0.00447410f, -0.18050088f, -0.16463439f, 0.09002196f, 
    -0.16544802f, 0.07103123f, 0.12644912f, 0.36097118f, 0.10539506f, 0.08593290f, -0.01199041f, -0.13848519f, 
    0.00859882f, -0.02665945f, -0.10468190f, -0.11441322f, 0.01055558f, 0.15622589f, 0.02006599f, -0.06960320f, 
    -0.06750533f, -0.16104534f, -0.29982725f, -0.38182333f, -0.29189649f, -0.18812424f, -0.06881282f, -0.06792250f, 
    -0.40998113f, -0.32790315f, -0.41782615f, -0.09661210f, -0.36860907f, 0.12226252f, 0.13754208f, 0.07258207f, 
    0.06685919f, 0.13729052f, 0.04409727f, 0.02441235f, 0.00320562f, 0.13869156f, 0.17469852f, 0.18200915f, 
    -0.09689780f, 0.16305527f, 0.07364973f, -0.25029600f, -0.10177534f, 0.13553286f, -0.10401767f, -0.05490463f, 
    -0.13117655f, 0.15525475f, 0.05567456f, -0.13821831f, -0.10648663f, 0.05254073f, 0.14388382f, 0.06491339f, 
    0.01085297f, 0.02489370f, 0.00500133f, -0.07497278f, -0.10534957f, -0.12092018f, 0.10977783f, 0.10974175f, 
    0.25192317f, 0.08758163f, 0.46725121f, 0.13986021f, -0.01052626f, -0.10367788f, -0.15005220f, 0.26238310f, 
    0.14023316f, -0.06150474f, 0.20775720f, -0.11704635f, 0.02519235f, 0.06298531f, 0.04627477f, 0.10395990f, 
    0.13034937f, -0.00500726f, -0.15832929f, -0.00411536f, -0.10284361f, -0.03390241f, -0.06263553f, -0.06988045f, 
    -0.27336481f, -0.39323092f, -0.28627124f, -0.12414846f, -0.11121531f, 0.16316094f, 0.13264498f, 0.06346072f, 
    -0.00159380f, 0.03487841f, -0.16500193f, -0.19794713f, -0.00276619f, 0.09611270f, 0.23859382f, 0.16634096f, 
    0.00875468f, 0.01699991f, 0.09490937f, 0.12625641f, 0.18319036f, 0.01109503f, -0.54034221f, 0.20919225f, 
    0.05052217f, 0.05514804f, -0.04907305f, 0.03661597f, -0.15983841f, -0.12432347f, 0.05675330f, 0.12159389f, 
    0.19387965f, -0.01291663f, -0.05517348f, -0.08655934f, -0.05780742f, -0.20321071f, 0.00931971f, 0.12692636f, 
    0.08097749f, 0.07088938f, 0.12913765f, -0.15723430f, -0.00462707f, 0.00153622f, 0.15205830f, 0.15061776f, 
    -0.09792408f, -0.14723182f, -0.16016294f, -0.01430050f, 0.02107147f, 0.02026574f, 0.10726640f, 0.14959276f, 
    0.05398329f, 0.00616257f, 0.20165730f, -0.02960434f, -0.01855357f, 0.02999865f, -0.09279681f, 0.09687266f, 
    0.12653753f, 0.02023164f, -0.03785516f, -0.24686848f, 0.16541693f, -0.14897101f, 0.19313730f, 0.18522345f, 
    0.00340133f, -0.03640258f, 0.11082585f, 0.00703966f, 0.15444216f, 0.29963446f, 0.15907401f, 0.17653362f, 
    -0.07639147f, -0.10064248f, 0.03744550f, 0.12880753f, 0.19553699f, 0.19439267f, 0.04049305f, -0.20777605f, 
    -0.04766287f, -0.00952438f, 0.18192855f, 0.10064963f, -0.02508558f, 0.11060353f, -0.09753162f, 0.11173400f, 
    -0.11519536f, 0.05168490f, 0.04103566f, -0.04018577f, 0.12785399f, 0.13054948f, -0.00285721f, 0.11128438f, 
    0.07435008f, 0.05342882f, 0.00350869f, 0.00308846f, 0.15194157f, 0.04519925f, -0.06676104f, 0.10036962f, 
    -0.30841669f, 0.27285227f, 0.11635001f, 0.18999703f, 0.20800740f, 0.08694817f, 0.12299971f, -0.18440989f, 
    -0.05894226f, -0.09586991f, 0.14133020f, 0.04559734f, 0.01301757f, -0.00028135f, -0.03087221f, -0.24703623f, 
    -0.28329185f, -0.27452627f, -0.10435846f, 0.06557985f, -0.05593979f, -0.08155879f, -0.26341325f, -0.09171513f, 
    -0.06666324f, -0.27886665f, -0.34963125f, -0.13482399f, -0.14405222f, 0.06818141f, 0.05751508f, 0.08014378f, 
    0.07397506f, 0.17658222f, 0.09774443f, 0.42061797f, 0.47979960f, 0.20221443f, 0.02979847f, 0.45439178f, 
    0.46087703f, -0.23383170f, -0.06579442f, 0.17618705f, 0.18652248f, 0.03901268f, -0.08100179f, 0.05047069f, 
    0.08391925f, -0.01039146f, 0.18229011f, 0.09395004f, 0.22689769f, 0.01385011f, -0.10315830f, 0.09824125f, 
    0.02489791f, 0.00469680f, 0.10411558f, -0.00265880f, 0.22884414f, -0.00532665f, 0.41933307f, -0.06140424f, 
    0.38288099f, 0.20342647f, 0.13206910f, 0.02056091f, 0.04555811f, -0.21681303f, 0.27030608f, -0.19809669f, 
    0.07163750f, 0.04688220f, 0.18611149f, 0.03162765f, 0.03515455f, -0.02613040f, -0.09166757f, -0.21028922f, 
    -0.89166033f, -0.74496228f, -0.66050518f, 0.11670044f, 0.24772486f, 0.02071061f, 0.05936399f, 0.07585464f, 
    0.04072189f, 0.00280474f, -0.13198051f, -0.14317678f, -0.08081783f, 0.11666700f, 0.04706617f, 0.08951780f, 
    0.15729845f, -0.05793188f, 0.03208560f, 0.27234945f, 0.07677224f, -0.16727497f, -0.01939820f, -0.08090238f, 
    0.18197474f, 0.08000413f, 0.45480138f, 0.30347133f, 0.06524203f, 0.67480952f, -0.11820338f, -0.20149048f, 
    -0.08724255f, -0.05536731f, 0.13768040f, 0.58834183f, -0.45688170f, -0.13578433f, -0.63568795f, 0.18056971f, 
    0.07247695f, 0.19101575f, 0.08946463f, 0.05433222f, 0.21870367f, 0.14632638f, 0.04555662f, -0.14949086f, 
    -0.01989168f, 0.14685747f, 0.09700702f, 0.05616695f, 0.12610590f, 0.19306850f, -0.40320262f, 0.17956981f, 
    0.27334446f, -0.09404381f, -0.18813106f, -0.03789344f, 0.07411845f, 0.06849211f, 0.04713814f, 0.09119585f, 
    0.08505040f, -0.27032301f, -0.10523283f, -0.06870940f, -0.03700226f, 0.05156526f, 0.17709160f, -0.35532010f, 
    -0.21270876f, -0.39407167f, -0.20956075f, 0.07944643f, 0.20862070f, 0.09089072f, 0.15123118f, 0.13643284f, 
    0.07557770f, 0.28534573f, -0.47251916f, -1.23784614f, 0.08347983f, 0.03058708f, 0.00515394f, 0.12456428f, 
    -0.05321917f, -0.10676862f, -0.01893359f, -0.51901627f, -0.23777181f, -0.13056073f, 0.03798706f, 0.11058892f, 
    0.30856305f, 0.16368476f, 0.32067394f, -0.48639500f, 0.06057602f, 0.16734798f, -0.01173940f, 0.23528422f, 
    -0.00260944f, 0.06918692f, 0.04146352f, 0.05500215f, 0.31283495f, -0.26512057f, -0.59484172f, -0.04872920f, 
    0.10105950f, 0.11465891f, 0.11478114f, 0.01585378f, -0.35928249f, -0.62358433f, 0.34904966f, -0.54986268f, 
    -0.28314888f, -0.17361255f, -0.02153120f, -0.02258435f, 0.10759836f, 0.00104866f, 0.23138247f, -0.36802331f, 
    -0.17858905f, 0.01293594f, 0.13655975f, -0.01215542f, 0.00198026f, 0.10282174f, -0.21824065f, -0.17907824f, 
    -0.44550684f, -0.03307431f, 0.00380307f, 0.00879291f, -0.25480327f, 0.17358746f, 0.13359207f, -0.29945406f, 
    -0.01279484f, 0.52983534f, -0.08064652f, -0.22971211f, -0.05051433f, -0.16574791f, -0.14089499f, -0.12743150f, 
    -0.13083097f, -0.36631927f, -0.44203526f, -0.31323975f, -0.19995588f, -0.21458365f, -0.43810311f, -0.00966749f, 
    -0.02578081f, -0.06453492f, 0.21209168f, 0.12580024f, 0.12742837f, 0.18896054f, 0.02835197f, 0.23774967f, 
    0.01919534f, -0.00074791f, -0.00889766f, 0.01069251f, -0.18796664f, 0.06925110f, 0.22627918f, 0.15660605f, 
    0.04983300f, 0.33140180f, 0.01815171f, 0.09548756f, -0.29946303f, 0.10193171f, -0.26130462f, -0.13836671f, 
    -0.18774046f, -0.24668036f, -0.06274890f, -0.00450714f, 0.04716942f, -0.38726658f, -0.24499248f, 0.08981598f, 
    0.03846131f, 0.21916950f, -0.04190394f, 0.08792644f, -0.02317993f, -0.09022518f, 0.17292233f, -0.21023673f, 
    0.39932036f, 0.13686766f, 0.22124310f, 0.19295681f, 0.01797436f, 0.05514343f, -0.19991857f, 0.70175648f, 
    0.36953372f, -0.42347777f, 0.09298415f, -0.23944999f, 0.24096908f, 0.13890050f, 0.16453847f, -0.18905710f, 
    -0.23268571f, 0.30365509f, -0.31547329f, -0.07218391f, 0.07827362f, 0.02759593f, -0.06749829f, -0.09137377f, 
    0.33042622f, 0.78461677f, -0.22530517f, -0.06280678f, -0.17645696f, 0.07037425f, 0.07113806f, -0.01382019f, 
    0.07954397f, 0.14923233f, 0.78716028f, 0.31443438f, -0.37317476f, 0.10175779f, 0.04127201f, 0.09174131f, 
    0.01165721f, -0.01739412f, -0.15077870f, -0.93714398f, -1.82993972f, -1.05621624f, 0.13890994f, -0.04660799f, 
    0.34507933f, 0.10484868f, -0.16152093f, -0.18615271f, 0.11069515f, -0.10842801f, -0.34999025f, -0.04902612f, 
    -0.05136511f, -0.18934639f, -0.01177683f, -0.15204856f, -0.08551137f, 0.76535314f, -0.22094281f, -0.38073081f, 
    0.03160611f, 0.09037937f, 0.30282855f, 0.08844382f, 0.10839720f, -0.20441492f, -0.01063977f, -0.33499092f, 
    -0.37434649f, 0.13609901f, 0.05794919f, 0.19947690f, -0.00940331f, 0.02202478f, 0.11179892f, -0.44124153f, 
    0.00034156f, -0.06808341f, -0.18772586f, -0.04330615f, 0.20637062f, 0.15112661f, -0.07756206f, -0.19349487f, 
    -0.16356857f, 0.27085122f, 0.10031823f, -0.36645487f, -0.19287068f, 0.25746241f, -0.08072495f, 0.02678317f, 
    0.18769544f, -0.01382821f, 0.02455419f, 0.05289115f, -0.01949596f, 0.08994794f, 0.00892137f, 0.00517256f, 
    -0.25563404f, 0.19905795f, -0.01903233f, -0.13822952f, -0.12462809f, 0.02049670f, 0.00602693f, -0.11470205f, 
    0.19475603f, -0.11315864f, 0.04976162f, -0.21298480f, -0.19696656f, -0.53785133f, 0.15805818f, -0.00062023f, 
    -0.20875002f, 0.05493906f, -0.28953132f, 0.28345311f, 0.42436886f, 0.32383779f, 0.31927341f, 0.04689291f, 
    0.04140164f, -0.01903295f, 0.24304664f, -0.12299460f, -0.04296332f, -0.06557651f, -0.07566844f, -0.36813399f, 
    0.17895338f, -0.09179079f, -0.26839578f, -0.11449126f, 0.02852443f, 0.12261672f, -0.47937423f, -0.26381910f, 
    0.02490092f, 0.09193578f, -0.11519159f, 0.01524744f, 0.00098281f, 0.02356565f, 0.24824822f, 0.18634994f, 
    0.02906069f, -0.07246408f, -0.34442118f, 0.11028917f, -0.06996091f, -0.37442720f, 0.45163032f, -0.13909078f, 
    -0.06543192f, 0.15443693f, 0.25965273f, -0.16799918f, 0.15009253f, -0.13555102f, -0.16944164f, 0.08745942f, 
    0.04846975f, 0.08673373f, -0.11131510f, -0.15845023f, 0.14064310f, -0.05105140f, -0.17733948f, 0.09846386f, 
    -0.06592740f, 0.00030831f, 0.09766049f, -0.05143264f, -0.08301953f, 0.20803541f, 0.09633225f, -0.08745098f, 
    0.19937986f, 0.01194268f, -0.08097266f, -0.32377610f, -0.10002581f, -0.22334091f, -0.42117071f, -0.04015325f, 
    -0.11189585f, 0.22928631f, -0.00994245f, 0.06694307f, -0.07156904f, -0.18519820f, -0.29074770f, -0.07505707f, 
    0.11234322f, 0.15664539f, 0.02626577f, 0.05526778f, -0.11554784f, 0.10006699f, 0.03996659f, 0.17551892f, 
    0.16755176f, -0.03726985f, 0.17357911f, -0.03068328f, 0.24050282f, -0.14388266f, -0.32639807f, -0.32805356f, 
    -0.28872740f, 0.12349103f, -0.04579505f, 0.07684284f, -0.18066610f, -0.20742920f, -0.07133880f, 0.01954134f, 
    -0.02648557f, -0.19166243f, -0.04865712f, -0.16452819f, 0.19935250f, 0.26941660f, -0.22298506f, -0.39882267f, 
    0.32469150f, 0.13669021f, -0.02544703f, -0.11034808f, -0.01078689f, -0.04131284f, -0.00458619f, -0.03362694f, 
    -0.23568213f, 0.11967801f, 0.32527915f, 0.14785409f, 0.09723548f, 0.07105553f, -0.00737163f, -0.07393438f, 
    -0.12406970f, 0.13165812f, -0.23208274f, 0.45565799f, -0.52763569f, 0.26613325f, 0.12506635f, -0.23888876f, 
    0.04775953f, 0.00938947f, 0.07756107f, -0.10230823f, -0.13450225f, 0.07719604f, 0.09910155f, 0.03776251f, 
    -0.12400175f, 0.25707242f, -0.08630237f, 0.06782921f, -0.17770998f, -0.11684392f, -0.11564144f, 0.31218308f, 
    -0.08416102f, 0.06970185f, -0.03704003f, -0.20313151f, -0.05214575f, 0.08925467f, 0.16235681f, -0.17887449f, 
    0.18008634f, -0.05943839f, 0.13501985f, 0.18370211f, 0.09994202f, -0.02834583f, -0.22993635f, -0.27050790f, 
    -0.10966606f, -0.10928375f, 0.11308938f, 0.13129069f, 0.03535727f, 0.12961504f, 0.10994999f, -0.11012167f, 
    0.41279304f, -0.35247970f, 0.16238345f, 0.01119672f, 0.09459663f, 0.23546982f, -0.05545165f, -0.30290008f, 
    0.12892491f, -0.01536850f, -0.06567340f, 0.18582562f, -0.18487734f, -0.27235153f, 0.00930347f, -0.02561020f, 
    0.13767004f, 0.18448831f, 0.07054051f, 0.22877388f, -0.02405568f, -0.10441105f, 0.14435992f, -0.12609503f, 
    0.10162055f, -0.16744632f, 0.14451106f, 0.12586921f, 0.02326444f, 0.03650519f, 0.04344187f, -0.04158298f, 
    -0.03892346f, -0.02670638f, 0.05104451f, 0.65929657f, -0.01239725f, -0.15816161f, 0.14367402f, 0.11797804f, 
    0.14574154f, 0.32493410f, 0.10817090f, 0.11382506f, -0.01430007f, 0.14493744f, 0.16870244f, -0.10536502f, 
    0.04489988f, 0.08878492f, 0.03230600f, 0.00720279f, -0.25005493f, 0.08053118f, -0.26085821f, -0.40057608f, 
    -0.04613708f, -0.07319350f, 0.03842276f, 0.05478805f, 0.07257041f, 0.27837589f, -0.24259043f, -0.25101608f, 
    0.16975957f, 0.16739455f, -0.05040278f, 0.13626273f, -0.04182431f, -0.13918021f, -0.07002539f, 0.33149597f, 
    0.06388961f, 0.43145424f, 0.06456299f, -0.03261250f, 0.09181190f, 0.19508997f, 0.15329280f, 0.11297704f, 
    0.04571360f, -0.03632669f, 0.00036122f, -0.05049067f, 0.03019862f, -0.03245980f, 0.02096171f, 0.04079589f, 
    0.00326806f, -0.03486757f, -0.04992148f, -0.00709598f, 0.00178544f, 0.00006713f, 0.02489621f, 0.00037321f, 
    -0.02534462f, 0.00883341f, 0.03588784f, 0.04111302f, -0.02133703f, -0.01349674f, 0.02004498f, -0.00455687f, 
    -0.01084009f, -0.02531124f, -0.02220490f, -0.03465331f, 0.04831294f, 0.00461655f, -0.01639106f, -0.03893644f, 
    0.02350509f, 0.01286188f, 0.03756020f, 0.04328425f, 0.00689872f, 0.02654758f, -0.06532022f, -0.03143976f, 
    0.01648882f, -0.06775997f, -0.05839673f, -0.05233020f, -0.01096883f, 0.01118809f, -0.06106334f, 0.02705926f, 
    0.03032070f, 0.04249860f, -0.00463422f, 0.01860270f, 0.04367925f, 0.04649628f, -0.00571037f, -0.06381691f, 
    0.02005197f, 0.04538389f, -0.05012342f, -0.04176564f, -0.04802686f, -0.01333680f, 0.04077472f, -0.04127192f, 
    -0.05294014f, 0.00534270f, -0.05368813f, 0.01577537f, -0.06469072f, -0.02707749f, 0.04669667f, -0.00554080f, 
    0.01497840f, -0.03615459f, 0.01289227f, -0.02370975f, -0.01186582f, -0.03554573f, 0.03970998f, -0.05202964f, 
    0.02023264f, 0.01442851f, 0.03105544f, -0.00790815f, -0.00013616f, 0.03887962f, -0.03403487f, -0.01591474f, 
    0.02120162f, -0.05479612f, -0.06634311f, -0.04719055f, 0.01100028f, 0.00185202f, 0.02487200f, 0.01009898f, 
    -0.02789804f, -0.03246777f, -0.00250158f, 0.03400000f, -0.00790020f, -0.00747812f, -0.02247345f, -0.01592125f, 
    -0.05775848f, 0.02526601f, 0.03770177f, -0.00546402f, 0.02261713f, -0.06206841f, 0.03754790f, -0.03544603f, 
    0.01022058f, -0.03661397f, -0.05360963f, -0.03898693f, 0.01636271f, -0.04955367f, -0.00985030f, 0.02128490f, 
    -0.02102137f, -0.05993851f, -0.04278166f, -0.01663935f, 0.00517929f, 0.00084566f, 0.02267206f, -0.01677688f, 
    -0.01631231f, -0.02454509f, -0.03829964f, 0.01796422f, -0.00499873f, -0.05449753f, -0.02406967f, -0.00672945f, 
    -0.03517994f, 0.00802864f, -0.04808370f, -0.00118380f, 0.01068094f, 0.01016111f, 0.02881776f, 0.02899827f, 
    -0.01747421f, 0.04968140f, -0.01702200f, 0.03895278f, -0.03411413f, 0.04384232f, 0.03236729f, -0.03269058f, 
    -0.03646407f, 0.00705368f, -0.01563075f, -0.04203178f, 0.04014577f, 0.00851594f, -0.01871305f, 0.01301095f, 
    -0.03190266f, 0.03738759f, -0.01839501f, -0.00263483f, 0.03394851f, -0.05961158f, -0.02070192f, -0.02640261f, 
    -0.03201563f, 0.05322901f, -0.03856315f, 0.02487580f, -0.04921480f, 0.00078112f, -0.04220447f, 0.04249294f, 
    -0.04592469f, -0.03623887f, 0.03495951f, -0.04522553f, 0.00341139f, -0.01752160f, -0.01983620f, -0.04892573f, 
    -0.04756109f, 0.01145643f, -0.06675652f, 0.00423711f, 0.02520584f, -0.00265790f, -0.01412679f, -0.01560354f, 
    0.04442257f, 0.04010048f, -0.00077670f, 0.04922235f, -0.00705703f, -0.00832620f, -0.02091724f, -0.05702988f, 
    0.05557232f, -0.05855882f, 0.00162213f, -0.01441155f, -0.04219583f, -0.01225919f, 0.03203388f, -0.04831626f, 
    0.05016627f, 0.03858808f, 0.00239469f, 0.04054594f, 0.02791161f, 0.00383438f, -0.03728203f, 0.05121078f, 
    0.04050208f, 0.04462417f, -0.04811508f, 0.01151979f, 0.02772498f, 0.02176915f, -0.01555636f, -0.02794902f, 
    0.01755348f, -0.03567857f, -0.06031748f, -0.03975846f, -0.02164818f, 0.02412603f, -0.03040996f, -0.00881903f, 
    0.00843332f, -0.06023576f, 0.00039333f, -0.00018822f, -0.06332652f, 0.00038525f, -0.00037306f, 0.01969319f, 
    0.04485785f, -0.02932158f, -0.04822158f, -0.06589033f, -0.00452407f, -0.02927719f, -0.01036521f, -0.00317910f, 
    -0.04481985f, -0.04492459f, -0.06409650f, -0.05781342f, -0.02840391f, -0.02144091f, -0.04625644f, 0.01523982f, 
    0.05172249f, 0.04392188f, -0.06726501f, 0.04906228f, 0.02896223f, 0.00480793f, -0.01279462f, 0.03314570f, 
    0.00225208f, 0.02625981f, 0.05042647f, -0.06194724f, -0.02535404f, -0.01229538f, -0.02013660f, -0.02788982f, 
    -0.05228931f, 0.04170723f, 0.03270718f, 0.04167520f, 0.03428129f, 0.00619620f, -0.02398900f, -0.03252480f, 
    -0.03143538f, 0.00679419f, 0.02860389f, -0.02723144f, -0.05307397f, -0.02261050f, 0.03481114f, -0.01005695f, 
    -0.52228284f, -0.30998313f, -0.23737757f, 0.08332764f, 0.10189669f, 0.20471570f, -0.01090190f, -0.27638412f, 
    0.21954657f, 0.14501539f, -0.11734406f, 0.15625551f, 0.08130243f, 0.07730833f, -0.02849795f, -0.14287980f, 
    0.12366796f, 0.21814068f, 0.14371417f, 0.08462971f, -0.00732902f, -0.16303758f, 0.02763791f, -0.11253955f, 
    0.00466427f, -0.08260988f, 0.03353379f, -0.51903856f, -0.12874381f, 0.30739868f, -0.12125535f, -0.28088564f, 
    -0.01899966f, -0.06916211f, 0.06972876f, 0.25779465f, -0.27570283f, -0.57512581f, 0.00204516f, 0.06332307f, 
    0.33218136f, 0.07593320f, 0.12775186f, 0.06676578f, 0.17059945f, 0.28850320f, 0.04989569f, -0.01027953f, 
    -0.07046030f, 0.00279697f, -0.09771863f, -0.05683343f, -0.02650342f, 0.09906086f, -0.01458108f, 0.05587695f, 
    -0.01525877f, -0.32280698f, -0.19246802f, -0.08384278f, 0.18318768f, -0.00656064f, 0.02059199f, 0.04778976f, 
    -0.11227806f, -0.12576343f, -0.19623700f, -0.24091995f, -0.09583413f, 0.06318092f, -0.07481986f, -0.04718067f, 
    -0.10182221f, -0.22356501f, 0.05646391f, -0.00282507f, 0.02350184f, -0.10906925f, -0.14198503f, 0.07262272f, 
    0.18769313f, -0.36741528f, -0.49789384f, -0.33768627f, -0.03374397f, -0.01020090f, 0.03661024f, 0.15846136f, 
    -0.02530324f, -0.06019628f, -0.16975302f, 0.14281328f, -0.22429045f, 0.07856406f, -0.02383887f, -0.05413691f, 
    0.20381831f, 0.09124246f, 0.27471694f, -0.00473123f, 0.06814802f, -0.01167445f, 0.09799632f, 0.10073836f, 
    -0.12039927f, 0.12517659f, -0.04183570f, 0.27202544f, -0.14383550f, -0.44482481f, 0.10242181f, -0.06361336f, 
    0.08647289f, 0.11656982f, 0.02725860f, -0.12725082f, 0.01904506f, -0.33157116f, -0.28597146f, 0.14999713f, 
    -0.02141914f, 0.05161512f, -0.08862023f, -0.02980726f, -0.04206843f, -0.27818218f, 0.17280756f, 0.00045180f, 
    0.03059520f, -0.05689298f, -0.06632102f, -0.11655004f, -0.12155151f, -0.05359388f, 0.15705514f, -0.04242841f, 
    0.04835179f, 0.09318401f, -0.30298135f, -0.08605838f, -0.03802857f, 0.08858066f, 0.11824778f, 0.19894886f, 
    -0.08643305f, 0.10596165f, -0.27048573f, -0.18796226f, 0.08106714f, 0.00071698f, 0.08798426f, -0.09383067f, 
    -0.14768325f, -0.22816133f, -0.00570471f, -0.42874345f, 0.07993184f, -0.02700918f, -0.04460358f, 0.00185340f, 
    0.06738296f, -0.03867552f, 0.99471021f, 0.32477963f, -0.18577200f, 0.00348114f, -0.08275311f, 0.03601427f, 
    0.11070591f, -0.27213624f, 0.10099380f, 0.00157318f, -0.05053600f, 0.34404299f, 0.23947255f, -0.00458662f, 
    0.06741363f, -0.00955899f, 0.04208962f, 0.21985891f, -0.13999712f, 0.17772217f, -0.04710996f, 0.01193791f, 
    0.06091904f, -0.14191230f, 0.02383436f, 0.11135344f, -0.11045076f, -0.26895857f, 0.08277240f, 0.31244493f, 
    0.22021063f, 0.07284746f, 0.23792058f, 0.11137642f, 0.11467242f, -0.05852352f, 0.17114429f, 0.08613990f, 
    0.02772205f, 0.06776585f, 0.11765996f, 0.14527681f, 0.03628781f, 0.13027193f, 0.06441538f, 0.36735246f, 
    0.07364164f, -0.23702461f, 0.00575775f, -0.08256362f, 0.17142628f, 0.22817439f, -0.25926352f, -0.23960803f, 
    0.11999261f, 0.11100569f, -0.09878161f, -0.16954874f, 0.09976229f, -0.13425948f, 0.28264648f, 0.11538728f, 
    0.05745533f, -0.27892178f, -0.01458772f, -0.18130803f, 0.05183661f, -0.02176438f, -0.30495533f, 0.09572696f, 
    0.22628906f, 0.15610337f, 0.15246683f, -0.21312797f, -0.04620997f, 0.17058575f, 0.07151972f, 0.05933769f, 
    -0.00943915f, -0.01438438f, 0.24199592f, -0.58256054f, -0.23440897f, -0.42406377f, -0.12961721f, -0.15230957f, 
    0.26598629f, -0.08895831f, -0.32697773f, 0.15695326f, -0.23679039f, -0.07674365f, 0.07040981f, -0.01434330f, 
    0.11259905f, 0.17540300f, -0.03420985f, 0.07472216f, 0.08129520f, 0.15362753f, -0.43703490f, 0.08667936f, 
    0.07673183f, 0.19412053f, 0.13391218f, 0.08211112f, -0.15263656f, 0.05048670f, 0.00469061f, -0.13224071f, 
    -0.24294242f, -0.01902352f, 0.06099425f, 0.12653631f, 0.07913126f, 0.11113896f, 0.23259206f, -0.03550824f, 
    -0.13940978f, 0.06265306f, -0.34728655f, 0.01244321f, -0.28071970f, 0.30242062f, -0.07579702f, -0.03857594f, 
    0.04795844f, 0.01961939f, -0.02320576f, 0.01795091f, -0.04658892f, 0.00370304f, 0.03885710f, -0.01233282f, 
    -0.01822074f, -0.04841205f, -0.00475363f, 0.01749077f, -0.00151998f, 0.05030046f, -0.03023706f, -0.05481324f, 
    0.00765259f, 0.00700564f, 0.03679584f, 0.02711510f, 0.02649316f, -0.05930488f, -0.03260619f, -0.04844138f, 
    -0.04430398f, 0.01257561f, -0.07195621f, 0.00785798f, -0.05436394f, -0.01930162f, -0.05435336f, -0.01152218f, 
    0.05494133f, 0.00707649f, -0.01770431f, -0.01334171f, -0.00091640f, -0.06518972f, -0.00904237f, 0.03385445f, 
    0.03741436f, -0.05631176f, -0.01953812f, -0.03068843f, -0.03926095f, -0.05794086f, 0.01756575f, -0.07125098f, 
    0.01079646f, 0.02753547f, -0.00836115f, -0.06285800f, -0.05538711f, -0.06962541f, -0.04296196f, -0.07293501f, 
    0.05138612f, 0.05287398f, 0.04551228f, -0.03390807f, -0.04237641f, 0.04929944f, 0.01892257f, 0.00105910f, 
    -0.06421568f, 0.00093565f, -0.04461857f, 0.02571345f, 0.02539055f, -0.05386129f, 0.02791577f, 0.05505341f, 
    -0.00449563f, 0.01633342f, -0.01822862f, -0.01658617f, 0.01237205f, 0.02764934f, -0.02307805f, -0.03823551f, 
    0.01355240f, 0.03739493f, 0.00416251f, -0.03894766f, -0.00830439f, -0.00755136f, 0.00909600f, -0.00354638f, 
    -0.03410934f, -0.02128523f, -0.02779207f, -0.03444976f, -0.07309234f, 0.01723681f, -0.00719985f, -0.01800592f, 
    0.04253431f, -0.03247302f, -0.04860418f, -0.00223420f, -0.00326986f, -0.02381726f, 0.03036469f, -0.06879128f, 
    -0.05931531f, 0.00560979f, -0.01299374f, 0.02515738f, -0.04702258f, -0.00881726f, 0.04303182f, 0.04544498f, 
    -0.00750498f, 0.00795531f, -0.04777260f, 0.04148676f, 0.04534687f, -0.02034749f, -0.02820038f, -0.04219289f, 
    0.02504669f, 0.01849748f, 0.01894494f, 0.02344215f, -0.04845354f, 0.02382232f, 0.03759519f, 0.03475311f, 
    -0.01991527f, -0.05028762f, -0.04952842f, -0.05841217f, -0.02872780f, -0.00991653f, 0.02581347f, -0.01585363f, 
    -0.01207704f, 0.01673975f, -0.01499928f, 0.03492872f, 0.01855367f, -0.03959579f, 0.00164683f, 0.03769317f, 
    -0.02035211f, -0.02539376f, -0.01966691f, -0.04561137f, -0.06499232f, -0.05522720f, 0.04854630f, -0.00197543f, 
    -0.00015398f, -0.06626867f, -0.06491353f, -0.06726686f, 0.03482749f, -0.06396794f, -0.04572728f, 0.00047940f, 
    0.00285027f, -0.05467031f, -0.03352656f, -0.01476749f, 0.05291586f, 0.02145593f, -0.03125869f, -0.02775361f, 
    -0.02551367f, -0.03156876f, -0.00720823f, -0.00772163f, -0.05455371f, 0.00172195f, -0.06202934f, 0.02663299f, 
    0.01485156f, -0.06536657f, 0.01978004f, -0.03252314f, 0.02640879f, 0.00634517f, -0.00960083f, -0.04348539f, 
    0.03972413f, 0.04188687f, -0.00282134f, -0.00888641f, -0.01157671f, -0.02187483f, -0.00734899f, -0.00515177f, 
    -0.04999506f, -0.00975750f, -0.00079945f, 0.01024163f, -0.01193256f, 0.03647269f, -0.06574519f, 0.03873834f, 
    -0.00453530f, 0.02156899f, -0.00352708f, 0.00797788f, 0.01332928f, 0.02177486f, 0.02973455f, -0.05820557f, 
    0.04086030f, 0.02709309f, 0.03295896f, 0.01972463f, 0.01900984f, -0.00971819f, -0.01383830f, 0.00709036f, 
    0.02952568f, 0.03180781f, 0.02979836f, -0.00437157f, 0.03126316f, -0.01923928f, -0.00778846f, 0.04148493f, 
    0.03143633f, -0.00225357f, 0.02307907f, 0.04355932f, 0.02922679f, -0.03700134f, 0.00070230f, 0.04211979f, 
    -0.01899124f, -0.06277336f, -0.05020575f, -0.06206682f, 0.01564486f, -0.04215435f, -0.03698547f, 0.00724985f, 
    -0.00845601f, 0.04556883f, -0.06271162f, -0.05366938f, 0.00221593f, 0.01330202f, -0.04945175f, -0.01424552f, 
    -0.03689321f, 0.00637927f, -0.00400507f, 0.01886625f, 0.00464470f, 0.00959149f, -0.03916303f, -0.01736758f, 
    -0.02035832f, -0.00405003f, -0.05566114f, -0.02278049f, -0.03964916f, -0.02860477f, 0.04036601f, 0.01612586f, 
    0.01679680f, -0.03968174f, -0.04720282f, -0.04975406f, -0.01582881f, -0.02289367f, -0.02132522f, -0.06563551f, 
    -0.00397221f, -0.05683421f, 0.00464134f, -0.02816117f, -0.06369797f, 0.00061955f, -0.05333086f, -0.00475901f, 
    0.04182573f, -0.00516264f, -0.00033516f, -0.05335426f, 0.03613022f, 0.02620753f, -0.03232319f, -0.02657411f, 
    0.28820059f, -0.08496289f, 0.32003757f, 0.18347411f, 0.27527905f, 0.06175623f, 0.11720470f, 0.03818718f, 
    0.37707675f, -0.09720045f, 0.03774088f, 0.17173594f, -0.07593761f, -0.01487885f, -0.03011050f, 0.11683832f, 
    -0.10559390f, 0.03392511f, -0.03694074f, -0.11612782f, -0.01610413f, 0.18523222f, 0.15914072f, -0.00365156f, 
    -0.05804618f, -0.09541698f, 0.06828360f, 0.16353633f, -0.02536976f, 0.47711053f, 0.16604754f, -0.06556366f, 
    0.36816067f, 0.13231981f, 0.13302647f, 0.10682358f, 0.22799818f, 0.19379598f, -0.18702985f, -0.18658614f, 
    0.10134251f, 0.10984731f, 0.23509082f, 0.03025682f, -0.03150862f, -0.05814039f, 0.03245663f, 0.16531783f, 
    0.10033753f, 0.09255781f, 0.03614270f, -0.00739847f, -0.03533020f, -0.06687451f, -0.04479545f, 0.22158712f, 
    0.46164542f, 0.03066492f, -0.00915129f, 0.08918080f, -0.26322120f, 0.10735945f, -0.57309365f, 0.01410877f, 
    -0.04163611f, 0.11587675f, 0.01070852f, 0.04152959f, -0.00247294f, -0.21106182f, -0.64969200f, -0.09862817f, 
    0.04832203f, 0.08817325f, -0.06348380f, -0.00561787f, 0.15967274f, 0.12125998f, 0.15524773f, -0.25469333f, 
    0.18549058f, -0.18717197f, -0.19410299f, 0.06273101f, 0.11079793f, 0.08051442f, -0.08775559f, -0.09922669f, 
    -0.04877136f, -0.00616880f, 0.18493651f, -0.16556785f, 0.06194077f, 0.30329758f, -0.02568325f, 0.26147604f, 
    0.04163506f, 0.21873471f, 0.47685280f, 0.08045325f, -0.07221076f, 0.02378931f, 0.19807306f, 0.24720821f, 
    -0.02266509f, 0.16317968f, 0.10651286f, 0.00784436f, 0.08631330f, 0.10203113f, -0.16148920f, -0.01991901f, 
    -0.14600299f, -0.17007650f, 0.00532151f, -0.29304430f, -0.16826345f, 0.29162332f, 0.42144555f, 0.07400249f, 
    -0.24413784f, -0.00054491f, 0.07397039f, -0.05143499f, 0.00242976f, 0.02887002f, -0.03067337f, -0.03220042f, 
    0.16819893f, -0.03948116f, -0.03250925f, 0.04876154f, 0.07944683f, 0.07699871f, 0.02289987f, -0.01499794f, 
    -0.04805769f, 0.09380298f, 0.09120120f, 0.02123412f, 0.13755091f, -0.59938627f, -0.35236588f, 0.03439899f, 
    -0.11503045f, -0.09493877f, -0.08745999f, 0.02696804f, 0.23488680f, 0.02308073f, -0.05459843f, -0.18617961f, 
    -0.11373800f, -0.17540208f, -0.29767039f, -0.06467556f, 0.13343540f, 0.26806876f, 0.11088145f, 0.04860444f, 
    -0.05579498f, -0.02640484f, -0.04455658f, 0.12789530f, 0.49628890f, -0.34719235f, -0.04475370f, 0.03771561f, 
    0.08313845f, 0.28892526f, 0.53938651f, -0.08413150f, -0.06732834f, 0.20698214f, 0.04070378f, -0.07008789f, 
    0.08337924f, 0.01987265f, -0.01265343f, 0.15641135f, -0.23179072f, -0.27181137f, 0.06050491f, 0.31394416f, 
    0.08372066f, -0.13780433f, -0.01255818f, -0.08023527f, 0.06403508f, -0.01215236f, 0.10560571f, 0.07470640f, 
    0.04379980f, -0.04082946f, 0.04667238f, 0.31604639f, 0.07332699f, 0.05663003f, 0.00695886f, -0.08274414f, 
    -0.00239833f, 0.03886647f, 0.14465794f, 0.09052930f, 0.01691813f, 0.27649909f, 0.09195423f, 0.00667400f, 
    0.08373382f, 0.06793427f, -0.20244771f, -0.14859800f, -0.07756957f, 0.23120420f, 0.02901086f, 0.09425054f, 
    -0.21790028f, -0.38240680f, -0.27799568f, 0.20635806f, 0.17097682f, 0.01535445f, 0.07464886f, 0.15546189f, 
    -0.05670745f, 0.23887357f, 0.40436396f, -0.07495835f, 0.03028292f, 0.13552713f, 0.11413129f, 0.08486161f, 
    0.12818584f, 0.18867332f, 0.03684310f, -0.03097986f, -0.02232753f, -0.00142274f, 0.16714588f, -0.04679645f, 
    0.02234994f, -0.17517129f, -0.12590177f, -0.76805741f, 0.51276278f, 0.17280824f, -0.18747312f, -0.18678366f, 
    -0.17552593f, 0.12876770f, 0.27775937f, 0.31842440f, -0.00276869f, -0.02062934f, -0.00299693f, 0.10471822f, 
    -0.10742394f, -0.06432864f, -0.82020396f, -0.70370871f, -0.23024175f, 0.04728591f, -0.05257464f, 0.17697738f, 
    -0.27934733f, -0.04132687f, 0.03351495f, 0.15566759f, -0.04565966f, -0.18350387f, -0.42109418f, 0.13870321f, 
    0.23938327f, -0.25859609f, -0.24786863f, 0.30450964f, 0.15484737f, 0.21965377f, 0.16804712f, 0.09269197f, 
    0.25166181f, -0.14406413f, 0.04498797f, 0.25770962f, 0.23013896f, 0.17217200f, 0.02694330f, 0.02246473f, 
    0.05261032f, 0.05891524f, 0.38826463f, 0.07016290f, -0.03074061f, 0.07335976f, -0.09228098f, 0.10908090f, 
    -0.26838258f, -0.45466259f, -0.27499691f, -0.02191208f, 0.08380228f, 0.00080314f, 0.02262288f, -0.13366915f, 
    -0.11354005f, -0.01030319f, -0.06430161f, -0.00780890f, -0.01949274f, -0.01572620f, 0.05915613f, 0.04424980f, 
    -0.21796668f, -0.12553664f, -0.22175524f, 0.02707380f, -0.07123416f, 0.05040259f, 0.07344813f, -0.06207233f, 
    -0.03900915f, -0.00973072f, -0.06276654f, -0.04069466f, 0.28824618f, 0.01232698f, -0.21895604f, -0.15006998f, 
    -0.00014354f, -0.16262312f, -0.04898462f, -0.03939829f, -0.17672695f, -0.18707074f, -0.23538889f, -0.08473274f, 
    0.09394807f, -0.05374488f, -0.02231557f, -0.13743982f, -0.01995961f, -0.03068488f, 0.01541442f, 0.00289266f, 
    -0.00349054f, 0.12172505f, 0.03957473f, -0.05214933f, -0.08461554f, -0.01247245f, 0.12651646f, 0.04782404f, 
    0.06896245f, 0.00456824f, 0.10764156f, 0.01850735f, 0.00346233f, -0.14009330f, 0.02750815f, 0.02014305f, 
    -0.18021758f, -0.21359125f, 0.00416831f, 0.10917935f, -0.14149016f, 0.02980069f, 0.01921916f, 0.00456504f, 
    0.01994481f, 0.25631464f, 0.25886604f, 0.43573880f, 0.01730324f, -0.10882616f, 0.17415212f, 0.11943421f, 
    0.15512018f, -0.09058908f, 0.27334282f, 0.03623465f, 0.08833883f, -0.06957538f, -0.27183753f, 0.02095049f, 
    -0.10234974f, -0.08754937f, -0.00552079f, 0.08779584f, -0.20054977f, 0.04775574f, 0.01580785f, -0.06480369f, 
    0.12177530f, 0.00486176f, -0.05110063f, -0.14835028f, -0.14944091f, -0.14596650f, 0.09112933f, -0.13423860f, 
    0.01421024f, -0.08900727f, 0.14625303f, 0.18307006f, 0.17094940f, 0.63945180f, 0.28787455f, 0.17064381f, 
    0.15959160f, 0.22661698f, 0.08282039f, 0.01944924f, 0.04649587f, 0.02628948f, -0.37422976f, -0.22876637f, 
    -0.04108113f, 0.18244953f, -0.04240960f, -0.05239117f, 0.05489609f, 0.03570674f, -0.17433062f, 0.05626528f, 
    0.08550314f, 0.11978637f, 0.12859517f, -0.10123221f, 0.02663893f, -0.01001668f, 0.30432311f, 0.27321714f, 
    0.51934797f, 0.26404878f, 0.01702467f, -0.25300422f, 0.05323491f, 0.05966214f, 0.09337047f, 0.20085548f, 
    0.18468569f, 0.60288942f, 0.32167536f, 0.24378018f, 0.01199947f, 0.15638465f, 0.12801440f, 0.09552810f, 
    0.18205726f, 0.13458961f, 0.34426272f, -0.13814858f, -0.34774283f, 0.17943363f, 0.03039645f, -0.17142339f, 
    -0.18271659f, 0.04175545f, -0.07908607f, -0.11893329f, -0.13589372f, 0.02384432f, -0.05678100f, 0.03604011f, 
    -0.13740149f, -0.39025784f, 0.03396735f, -0.10712222f, 0.55952901f, 0.30722502f, 0.28293711f, 0.17192240f, 
    0.06541681f, 0.22117037f, 0.09637832f, 0.03061326f, 0.09155101f, 0.06455410f, 0.07239601f, 0.04831863f, 
    0.00165531f, 0.08360331f, -0.10149970f, -0.14695932f, 0.08029938f, -0.10658004f, -0.24695700f, -0.19038925f, 
    -0.29721284f, 0.12025011f, -0.04477809f, -0.05385666f, -0.04791308f, -0.07472852f, -0.07363665f, -0.60769838f, 
    -0.50744766f, -0.20872027f, -0.13067560f, -0.02662142f, 0.07901391f, -0.08311355f, 0.18676354f, 0.05022410f, 
    -0.12153404f, -0.16647145f, 0.05784832f, -0.06032826f, 0.01037936f, 0.07879728f, 0.06409371f, 0.08858870f, 
    -0.00686494f, 0.53530502f, 0.26585209f, -0.16921017f, 0.13985494f, 0.05259049f, -0.11200117f, 0.00723490f, 
    -0.04503293f, -0.14145245f, 0.23587374f, -0.05591909f, 0.04165483f, -0.23737663f, -0.00910643f, 0.02261117f, 
    -0.04355042f, 0.26117611f, 0.24486215f, 0.09219228f, -0.00450111f, -0.49694082f, -0.02499780f, 0.09066222f, 
    -0.02602989f, -0.06337872f, 0.18830520f, -0.12945890f, 0.15090171f, 0.14679965f, 0.10348285f, 0.14283717f, 
    0.07015555f, 0.00922662f, 0.37071317f, 0.20075805f, 0.14078459f, -0.58951020f, -0.34904751f, 0.17880900f, 
    0.02674068f, -0.00082600f, -0.01142841f, 0.00193961f, 0.09782829f, -0.02522356f, 0.07476807f, -0.36192140f, 
    -0.04385969f, 0.05427998f, -0.01287522f, -0.00203013f, 0.00325923f, 0.01956795f, -0.02098486f, -0.00373260f, 
    -0.10431644f, -0.36754566f, -0.20524172f, 0.04198203f, -0.15678900f, -0.13543202f, 0.19692181f, -0.13352112f, 
    0.03935789f, -0.37875265f, -0.32047772f, 0.02359806f, 0.20542152f, -0.07162436f, -0.10894236f, -0.19019614f, 
    -0.25864455f, 0.05787529f, 0.01877899f, 0.20218797f, -0.01391161f, 0.11594359f, 0.05573992f, 0.10929229f, 
    0.06307901f, 0.09097907f, 0.15319486f, 0.11115827f, 0.06454124f, 0.04405259f, 0.06804269f, 0.02435657f, 
    0.09650242f, -0.31933528f, -0.07716951f, -0.49771571f, -0.18679462f, 0.16367285f, -0.25003475f, -0.19507709f, 
    -0.32869607f, 0.14629392f, -0.02642204f, -0.22863981f, -0.33232996f, 0.16276462f, -0.32938609f, 0.07762716f, 
    0.12607075f, -0.01884759f, 0.15131895f, 0.03730075f, -0.00933134f, 0.11554034f, 0.09621192f, 0.17514630f, 
    0.02791727f, 0.01377867f, 0.08252880f, 0.02346946f, -0.12425563f, 0.12502915f, 0.01506332f, -0.01847561f, 
    -0.07189848f, -0.13737255f, -0.04679022f, 0.05067467f, 0.14882874f, -0.06611436f, -0.01955628f, -0.02131593f, 
    -0.09552805f, 0.00774355f, 0.20089366f, 0.16097544f, 0.04227597f, 0.03925303f, -0.19358534f, -0.05856808f, 
    0.09161196f, 0.02853867f, 0.17155258f, -0.09536213f, 0.05252256f, -0.16177104f, -0.11871547f, 0.08441147f, 
    0.23471251f, -0.11313327f, -0.41520303f, -0.17557484f, 0.03968976f, -0.02623542f, -0.12151621f, 0.02148370f, 
    0.05221391f, -0.11922868f, -0.10192871f, 0.08848204f, -0.14104524f, -0.09825301f, 0.08276051f, -0.21907288f, 
    -0.06205952f, -0.12054026f, 0.14374489f, -0.06570081f, -0.01455573f, 0.00051485f, 0.08554792f, 0.08300391f, 
    -0.14906049f, 0.08144221f, 0.05560677f, -0.08214808f, -0.00199925f, -0.04621954f, 0.15733157f, 0.02956526f, 
    0.08613921f, 0.02180571f, 0.07874020f, -0.02580414f, 0.11737434f, -0.27082190f, -0.33555666f, 0.23901467f, 
    -0.00961386f, 0.18589254f, 0.13302757f, 0.16160314f, -0.15980929f, -0.41275042f, 0.08391978f, -0.01302468f, 
    0.06440192f, 0.01644054f, -0.00255464f, -0.09603827f, 0.23979597f, 0.05817454f, 0.08585455f, 0.06211262f, 
    0.12631838f, 0.09928336f, -0.08613098f, 0.05883363f, 0.18714927f, 0.18104316f, 0.19391382f, 0.00516114f, 
    0.08847971f, 0.12678127f, -0.00709398f, -0.03830435f, 0.06381432f, 0.02674985f, 0.07729301f, -0.10096202f, 
    -0.14281103f, -0.32148087f, -0.06991018f, -0.08196558f, -0.00298665f, -0.02654681f, -0.06695883f, 0.07789341f, 
    0.17024790f, -0.06065065f, 0.53268880f, 0.27592409f, -0.02643780f, -0.11131279f, 0.15242769f, 0.27478015f, 
    -0.03658516f, -0.03294556f, -0.12620778f, 0.08482401f, 0.10747085f, 0.24259527f, -0.04802102f, 0.09627356f, 
    0.07481146f, 0.15485653f, 0.05693382f, 0.17860503f, -0.12197724f, 0.05858972f, -0.21681079f, -0.05636180f, 
    0.08730866f, -0.02751639f, 0.09586312f, 0.00761596f, -0.12888221f, -0.11121531f, 0.28515345f, 0.13551630f, 
    -0.25633112f, 0.23169081f, 0.11421608f, -0.00663256f, 0.23608248f, -0.10657322f, 0.09100811f, 0.12837300f, 
    0.02891188f, 0.09407772f, 0.12413070f, 0.15623704f, 0.06621840f, 0.25678879f, 0.22714794f, 0.04972037f, 
    -0.03014713f, -0.12402335f, -0.01937961f, -0.02602426f, 0.24793898f, -0.19457535f, 0.10627665f, 0.01503958f, 
    0.05864935f, 0.10524943f, -0.02475397f, -0.05596737f, 0.06576426f, -0.11909515f, 0.14384042f, -0.14162572f, 
    0.07594312f, -0.24687512f, 0.06376016f, 0.10764892f, 0.00665686f, 0.02028638f, 0.13444184f, 0.04868589f, 
    -0.01110312f, 0.03491671f, -0.01305803f, -0.23638248f, -0.01335652f, 0.10045295f, 0.03634696f, 0.11257084f, 
    0.06289695f, 0.07612507f, 0.13528866f, -0.20985539f, 0.14343758f, -0.11816389f, -0.30063957f, 0.16528375f, 
    0.10851999f, 0.04280102f, 0.04422663f, -0.05380728f, -0.18412690f, 0.08894670f, 0.19991800f, 0.18846574f, 
    0.08435407f, 0.10077793f, 0.06249514f, 0.05906258f, 0.13016643f, 0.12070458f, -0.28957433f, 0.22364332f, 
    -0.04375840f, -0.09918786f, -0.00396585f, 0.10795964f, 0.04907683f, 0.12784779f, 0.16050768f, -0.01785529f, 
    0.07335094f, -0.31196702f, 0.18665321f, 0.11555471f, 0.11406843f, 0.21285354f, 0.32034087f, 0.12766783f, 
    0.08430909f, -0.03863792f, -0.07580888f, 0.05751886f, 0.13695568f, 0.13334483f, -0.09556489f, -0.15289254f, 
    -0.03493763f, 0.02434663f, -0.04323959f, -0.00504123f, -0.04728205f, 0.01021348f, -0.03373664f, 0.03909537f, 
    -0.03155115f, 0.04725689f, -0.01591302f, 0.03219660f, -0.04068632f, -0.02243166f, 0.01136500f, 0.00806481f, 
    0.00470323f, 0.02203365f, -0.01884025f, -0.00175014f, 0.02355877f, 0.02710146f, -0.03673699f, 0.02618315f, 
    -0.04876577f, -0.04473501f, -0.04679589f, -0.00916921f, 0.00407381f, -0.06067440f, -0.00224900f, -0.01470185f, 
    -0.01476674f, -0.01814640f, 0.05573756f, -0.00366021f, 0.04048575f, -0.02537053f, -0.02703420f, -0.02023581f, 
    -0.02086999f, -0.03677309f, 0.01624704f, 0.01213228f, -0.00821548f, -0.04006898f, 0.00886550f, -0.00411668f, 
    -0.01684098f, 0.01957799f, -0.03837024f, 0.02767173f, -0.03911101f, -0.03864912f, 0.03605247f, -0.05974868f, 
    0.04507301f, -0.01960763f, 0.00372284f, -0.00267156f, -0.00017570f, 0.00161393f, -0.00014507f, 0.03006314f, 
    0.00891310f, 0.04716364f, 0.03140488f, -0.06035523f, 0.02782421f, 0.03383781f, 0.05379928f, -0.03233168f, 
    0.04875315f, 0.04929683f, 0.04638305f, -0.05947968f, 0.05058157f, 0.00950193f, 0.00862721f, 0.04404229f, 
    -0.01544905f, 0.01931377f, 0.03957087f, 0.03163135f, 0.02111956f, -0.00900918f, -0.01057652f, -0.00558213f, 
    -0.04827710f, -0.00938039f, 0.04675078f, -0.04288203f, 0.01176860f, -0.02094342f, 0.03366565f, 0.01150027f, 
    -0.05205568f, -0.00673444f, -0.00226173f, 0.00510070f, 0.00284913f, 0.00973453f, -0.05962895f, -0.01314311f, 
    0.03373402f, -0.05590824f, 0.00199888f, -0.01328911f, 0.00421847f, -0.03526090f, 0.03594084f, 0.04443541f, 
    -0.00483084f, -0.00221999f, 0.01763377f, 0.03213121f, 0.00860609f, -0.00303775f, 0.02131489f, -0.02506894f, 
    -0.03085477f, -0.02705279f, 0.00046229f, 0.05371459f, 0.03599709f, -0.04969547f, -0.00195092f, 0.01018143f, 
    -0.05778182f, -0.01124594f, -0.00822367f, -0.05862863f, -0.03850802f, 0.03544748f, -0.00027825f, -0.00400469f, 
    -0.02564278f, 0.00158854f, -0.01292230f, -0.01491459f, -0.02919003f, -0.00742224f, 0.01088205f, 0.02926295f, 
    -0.03500804f, -0.01951998f, 0.02317834f, -0.05436628f, 0.01869543f, -0.04806277f, -0.04615290f, 0.02669026f, 
    0.00850791f, -0.06063186f, 0.01041668f, -0.04550724f, -0.02650946f, 0.01579528f, 0.04894800f, 0.00220052f, 
    -0.00748808f, 0.04728498f, -0.04245604f, -0.00088258f, 0.00406501f, 0.04681667f, -0.04827010f, 0.04350283f, 
    -0.04374200f, -0.02612573f, -0.05772884f, 0.00652433f, -0.03831591f, -0.01261577f, -0.05723529f, 0.02399910f, 
    -0.00458097f, 0.00321154f, -0.00936837f, 0.02593289f, 0.03362861f, -0.03635142f, 0.00574752f, 0.05593563f, 
    -0.03848998f, -0.03966431f, 0.05293128f, -0.04927910f, -0.03553345f, -0.02193732f, 0.04652590f, -0.02150325f, 
    -0.04763972f, -0.05704474f, -0.04499016f, -0.04641750f, 0.04343964f, 0.02678378f, -0.01624621f, -0.05261177f, 
    -0.04161367f, -0.00224660f, -0.04310562f, -0.00971423f, -0.04691264f, 0.00874508f, 0.02428020f, -0.05808528f, 
    -0.00879904f, 0.00414069f, -0.04010046f, 0.02217405f, -0.06110111f, 0.02872252f, -0.00515373f, 0.03807948f, 
    -0.03865547f, 0.04935911f, -0.02449914f, -0.02063728f, 0.01833916f, 0.01474959f, 0.00605790f, -0.00763736f, 
    -0.06878123f, -0.04832587f, -0.04594927f, 0.00162960f, -0.05816900f, -0.05657753f, -0.06260144f, 0.00851658f, 
    0.03286887f, 0.01709647f, 0.04951266f, -0.01644675f, -0.00076145f, 0.05095140f, -0.04853806f, 0.03990651f, 
    -0.05203960f, 0.02303751f, 0.01811837f, 0.05590139f, 0.02969972f, 0.04505504f, 0.02805608f, 0.04841515f, 
    0.02267789f, -0.01458122f, 0.03963298f, 0.03150360f, -0.00023117f, -0.05852410f, 0.02344061f, 0.02175697f, 
    -0.06720703f, -0.06426297f, -0.05362169f, -0.04335918f, -0.04550617f, -0.06175801f, 0.02037914f, -0.01282485f, 
    0.03019482f, 0.00254674f, -0.06768740f, -0.03469095f, 0.01362077f, 0.00726146f, -0.01866359f, -0.04478432f, 
    0.03243451f, 0.04916537f, 0.00590809f, -0.04698089f, -0.00980547f, -0.05888195f, -0.01459056f, -0.06057032f, 
    0.01673614f, 0.02688009f, -0.05072646f, -0.00711203f, -0.03720398f, 0.03182885f, -0.03800160f, 0.00460573f, 
    -0.34443486f, -0.58025318f, 0.31994987f, -0.04424147f, 0.07928376f, -0.05609621f, 0.17061850f, 0.03136181f, 
    0.08083457f, 0.05556637f, 0.10522790f, -0.09501976f, -0.03058653f, 0.00006393f, -0.03446178f, -0.02058000f, 
    0.13929568f, -0.06903668f, -0.10405850f, 0.04660471f, 0.03077860f, -0.01235310f, 0.03607942f, -0.14919671f, 
    0.02159389f, -0.06023297f, 0.01497229f, -0.40593773f, 0.07013087f, 0.23895448f, 0.16081172f, 0.25496408f, 
    -0.07354215f, 0.02723557f, -0.08659218f, 0.19790824f, 0.55296141f, 0.12836464f, -0.25899890f, 0.00338069f, 
    0.00117061f, -0.01438086f, 0.04315054f, 0.06338952f, 0.21760598f, 0.12338333f, 0.07072917f, 0.00110813f, 
    -0.18486826f, 0.01602096f, 0.07009342f, 0.07210394f, -0.01044271f, 0.09460242f, -0.00500932f, -0.07414731f, 
    -0.18101269f, 0.11982254f, 0.08897331f, 0.05889383f, 0.03939286f, 0.09096137f, 0.08640042f, 0.03552149f, 
    -0.12742685f, -0.01517961f, -0.44047835f, -0.10454724f, 0.01547237f, 0.05196993f, 0.13356259f, 0.06955939f, 
    0.19021666f, 0.05374698f, -0.02666877f, 0.06682026f, -0.06392469f, 0.13377367f, 0.03523862f, 0.06106076f, 
    -0.11275971f, -0.54332930f, -0.49972019f, 0.23141167f, -0.06085458f, -0.01522661f, -0.07841504f, 0.04279265f, 
    0.01531846f, 0.04766186f, -0.13290505f, 0.26044041f, 0.16817397f, 0.18893602f, 0.20385727f, -0.17514050f, 
    0.08715397f, 0.01071170f, 0.26516601f, 0.05224319f, 0.09524819f, -0.15080357f, -0.06438074f, -0.07619536f, 
    -0.07381082f, 0.25697392f, -0.04284753f, 0.10762765f, 0.05535499f, -0.34248316f, -0.02774548f, 0.00044355f, 
    0.15088172f, -0.01472353f, -0.11763106f, 0.10860779f, 0.01445718f, 0.02337968f, -0.18928827f, 0.01840570f, 
    -0.07126877f, -0.20031340f, -0.24647909f, 0.00254425f, -0.14270149f, 0.02503767f, 0.06529260f, -0.03336184f, 
    -0.07932788f, -0.10990141f, -0.01630653f, 0.04416793f, -0.14192814f, 0.04618692f, -0.05948981f, -0.11250871f, 
    0.08962975f, 0.05524543f, -0.04035125f, -0.14764534f, -0.13511650f, 0.13336967f, 0.15370491f, 0.05505328f, 
    -0.69290042f, -0.40160227f, 0.39539662f, -0.17213891f, 0.06458286f, 0.01320034f, 0.11718480f, 0.05132802f, 
    0.08620444f, -1.14669549f, -0.79294515f, -0.13499029f, 0.07946033f, -0.05518436f, -0.18103793f, 0.06556853f, 
    -0.07001323f, 0.03745180f, -0.68926400f, 0.61347818f, 0.03051674f, -0.24537359f, 0.38203928f, 0.05582619f, 
    0.27802128f, -0.00662822f, 0.23386934f, -0.27167234f, 0.21757662f, -0.12160504f, 0.25252602f, 0.06421021f, 
    -0.09979474f, -0.12996656f, 0.13232498f, 0.11528341f, -0.97682250f, -0.46039391f, -0.44555181f, -0.04179491f, 
    0.03422824f, -0.21347977f, -0.01370058f, -0.12332762f, 0.00464375f, 0.07551327f, 0.26254794f, 0.28211582f, 
    0.19725382f, -0.04955542f, -0.10438309f, 0.05638689f, -0.00909994f, 0.09804026f, 0.05747516f, 0.06400684f, 
    -0.04280244f, -0.04973286f, 0.01506872f, 0.06506935f, 0.08315127f, 0.03479104f, 0.13336837f, 0.28586292f, 
    -0.11753763f, 0.14771734f, -0.19871484f, 0.18403736f, -0.10395668f, -0.02653144f, 0.27009863f, 0.05564081f, 
    0.05624339f, 0.14346810f, -0.02388129f, 0.02388294f, -0.09908555f, -0.16207723f, -0.00695550f, -0.01301564f, 
    -0.03561646f, -0.42061913f, -0.16627803f, -0.64316136f, -0.20891359f, -0.12250680f, -0.17843673f, 0.00929553f, 
    -0.04208376f, 0.01115054f, -0.09756079f, -0.10211458f, -0.08941282f, 0.09778101f, 0.04403702f, -0.13442187f, 
    0.14545485f, 0.03446965f, -0.10843941f, -0.58182287f, -0.13671598f, -0.72658485f, -0.06260202f, -0.14550568f, 
    -0.14240929f, 0.06228884f, 0.16096911f, -0.15291795f, -0.07127345f, -0.15472738f, 0.03880734f, -0.01500714f, 
    0.07592101f, 0.00371053f, 0.03623966f, -0.03129696f, -0.05794755f, 0.04689247f, -0.21080996f, -0.25146738f, 
    -0.07215769f, 0.12582839f, 0.08141749f, 0.13628086f, 0.08901467f, 0.09020042f, -0.00263269f, -0.16295835f, 
    -0.26769325f, -0.01663036f, 0.07133065f, 0.07141043f, -0.01763665f, -0.06374160f, 0.16224930f, 0.41861308f, 
    0.10254301f, -0.42287824f, 0.29919952f, 0.10897148f, 0.18862481f, 0.03252663f, 0.14819367f, 0.17079884f, 
    -0.22853704f, -0.19099149f, -0.58112705f, 0.03639842f, 0.03769698f, -0.04758226f, -0.16412261f, -0.25657436f, 
    -0.12670158f, 0.07563294f, 0.24059859f, 0.06978174f, -0.04941740f, -0.08203691f, -0.11262149f, -0.11270433f, 
    0.07045975f, -0.04700410f, 0.13583000f, 0.05261566f, 0.29777217f, -0.05207536f, 0.08984374f, -0.19604668f, 
    0.16787663f, -0.13963397f, -0.02773926f, -0.03105862f, -0.46959725f, -0.30620578f, -0.10451060f, 0.05277140f, 
    -0.29391211f, 0.20149502f, 0.20794901f, -0.01453852f, 0.35322493f, 0.08651974f, 0.05259270f, 0.08579500f, 
    -0.17864490f, 0.03449387f, 0.10834258f, 0.07757391f, 0.06105623f, 0.08358740f, 0.08783079f, 0.11730859f, 
    0.03931189f, -0.07115229f, -0.21511479f, -0.01161604f, -0.06263100f, -0.04560006f, 0.37515342f, -0.00349615f, 
    -0.31319365f, -0.19808885f, -0.12383243f, -0.09744739f, 0.19919372f, -0.10061404f, -0.18973148f, -0.12453999f, 
    -0.10913689f, 0.01929668f, 0.25964108f, -0.11469820f, 0.00691316f, -0.01849793f, -0.18422237f, -0.03380582f, 
    0.22573397f, 0.25776184f, 0.15591505f, 0.20862581f, 0.08731323f, 0.00694476f, -0.10856592f, -0.06052273f, 
    -0.04435057f, -0.26960751f, -0.06492909f, -0.24215460f, 0.07228283f, 0.16907890f, -0.07507620f, -0.10132240f, 
    -0.08480281f, 0.21300393f, -0.08232822f, -0.12940045f, 0.05126167f, -0.07351952f, 0.18564792f, -0.06993646f, 
    -0.08590304f, 0.07291207f, 0.05137635f, -0.05001855f, 0.08598093f, 0.09119650f, 0.04367957f, 0.05024445f, 
    0.05200559f, -0.13177863f, 0.18381698f, -0.03947570f, -0.16654894f, 0.22308816f, 0.11772327f, 0.04345818f, 
    0.17086129f, 0.03702814f, 0.05408671f, -0.22595176f, 0.05666189f, 0.72513884f, -0.13533664f, -0.09152605f, 
    0.08219169f, -0.28276360f, 0.01694256f, 0.05407731f, -0.13305029f, -0.09388275f, 0.06292222f, 0.03601807f, 
    0.11647059f, -0.02231560f, -0.12646297f, -0.13187583f, 0.10664734f, 0.00000204f, -0.00597487f, 0.22654663f, 
    0.14613040f, 0.06789762f, 0.11608779f, -0.04966744f, 0.07192706f, 0.15470451f, -0.03360591f, -0.11275933f, 
    -0.06296482f, -0.33077186f, -0.13695094f, -0.06438283f, 0.12615551f, 0.04915599f, -0.09339918f, -0.06072238f, 
    -0.05115296f, 0.36733252f, 0.02310952f, -0.01617771f, -0.04368573f, -0.03362284f, 0.04215970f, 0.04965289f, 
    0.01017076f, -0.15511426f, -0.19803020f, -0.48778337f, -0.27196956f, -0.14079596f, 0.33276930f, 0.07182625f, 
    0.19221133f, 0.33557284f, 0.17585155f, 0.01293499f, 0.15065856f, 0.08894724f, -0.04981687f, -0.07939304f, 
    -0.10421720f, 0.16269779f, 0.00031956f, -0.14193001f, 0.26562279f, -0.11155496f, -0.34276810f, -0.06175041f, 
    0.03909750f, -0.18644001f, 0.03998063f, -0.12358265f, -0.02572192f, 0.19863969f, 0.14990349f, -0.39021790f, 
    0.00068888f, -0.01053904f, -0.03842565f, 0.07023817f, 0.21629205f, 0.00967255f, -0.05013093f, -0.10153176f, 
    -0.14727306f, -0.05972716f, -0.12512624f, 0.05244507f, 0.17578265f, 0.24562071f, 0.17590399f, -0.15146084f, 
    -0.33598191f, 0.35872892f, -0.24872372f, -0.17985532f, 0.17572060f, 0.19024979f, -0.32838687f, 0.26841757f, 
    -0.07736029f, 0.15055333f, 0.17480913f, 0.02921714f, 0.10997128f, -0.08174990f, 0.10543481f, 0.06531565f, 
    0.31759584f, 0.62215835f, 0.04936047f, -0.26294905f, 0.07810474f, -0.13143307f, -0.05361803f, -0.20457207f, 
    0.17523068f, 0.17213725f, -0.23867343f, -0.15222982f, 0.16228177f, -0.14990126f, 0.16037846f, 0.06182993f, 
    -0.02683841f, 0.01285111f, 0.11653729f, 0.07281704f, 0.00664788f, -1.05401087f, -0.07122808f, -0.02323623f, 
    0.24135111f, 0.37586147f, 0.24011853f, -0.41501305f, 0.06818356f, 0.12395363f, -0.11047123f, 0.16833645f, 
    -0.01849768f, 0.02367624f, -0.03507555f, -0.09737848f, 0.27923447f, -0.05042906f, -0.18994150f, 0.21193641f, 
    -0.04467414f, -0.09613501f, -0.02487806f, -0.02880576f, -0.01013978f, 0.24279699f, 0.14356613f, 0.12591311f, 
    0.07733275f, -0.10359817f, -0.11959346f, -0.07246970f, 0.11037609f, -0.15743475f, -0.02277863f, 0.59625041f, 
    0.13040677f, -0.24043411f, -0.09657494f, 0.12968463f, 0.17323652f, 0.30054969f, 0.17117465f, 0.00573578f, 
    -0.33072260f, -0.26660076f, 0.20662989f, 0.01148877f, 0.20479353f, -0.04896421f, 0.16786040f, 0.02907287f, 
    -0.38674459f, 0.23691753f, -0.02892803f, 0.24966815f, -0.00379859f, 0.01601665f, 0.03483634f, 0.02470380f, 
    0.01127134f, 0.05246868f, -0.30499357f, -0.15444997f, -0.14304481f, 0.00099235f, 0.05922069f, -0.16274121f, 
    0.15066673f, 0.01181967f, 0.08278097f, -0.36975059f, -0.09893251f, -0.02564234f, 0.15448569f, 0.16485848f, 
    -0.28215575f, -0.03262508f, -0.08987126f, 0.17878121f, 0.03167450f, -0.21370433f, -0.01401885f, -0.17825580f, 
    -0.04611484f, 0.14327447f, 0.17739365f, 0.13781905f, 0.18414669f, 0.20864743f, 0.10084000f, 0.14753355f, 
    -0.14109403f, 0.04833735f, 0.07862914f, -0.03038159f, 0.04758215f, 0.10314630f, -0.37254828f, -0.30498168f, 
    -0.00605168f, 0.02596934f, 0.11457578f, 0.08773424f, 0.10182989f, -0.00415808f, 0.07489827f, -0.00336752f, 
    0.04043092f, 0.01123312f, -0.23521261f, 0.04869713f, -0.14849551f, 0.09406971f, 0.29510626f, 0.08025911f, 
    0.03895499f, -0.03268710f, 0.12221891f, -0.10926344f, -0.11395325f, -0.00854587f, -0.01486115f, 0.06897272f, 
    -0.25460291f, 0.07047956f, -0.08867974f, 0.14148460f, 0.08986407f, -0.29287875f, 0.11796016f, -0.04354161f, 
    0.04503544f, 0.17948933f, 0.00838071f, 0.32696569f, -0.02960547f, 0.08841733f, -0.04511960f, -0.32461679f, 
    0.11760569f, -0.17911550f, 0.11512348f, -0.03749862f, -0.37204462f, 0.04517039f, -0.00981700f, -0.00899521f, 
    -0.05675019f, 0.03198461f, 0.14804539f, 0.14838094f, 0.35899869f, 0.07276510f, 0.17704552f, -0.15980461f, 
    -0.09754235f, -0.01758913f, -0.05198072f, 0.30149871f, 0.06703789f, 0.08311669f, 0.29476577f, 0.28129444f, 
    -0.27470371f, -0.14114492f, -0.34244069f, -0.05488129f, 0.11726440f, 0.16906643f, 0.33276346f, 0.07742208f, 
    0.25213400f, -0.21032524f, 0.04848405f, -0.05919786f, -0.06049563f, 0.02860049f, -0.13700658f, -0.21655089f, 
    -0.16427192f, 0.11525101f, -0.15950558f, 0.00572514f, -0.03036835f, 0.08048667f, 0.05613432f, 0.02319770f, 
    -0.24188785f, -0.25653172f, 0.01849288f, 0.03928652f, -0.08201173f, -0.12131673f, 0.04004933f, -0.10052083f, 
    -0.03791053f, -0.27781945f, -0.18544529f, -0.28776318f, 0.10884355f, -0.09786289f, -0.15311950f, 0.00529519f, 
    -0.00423490f, 0.07851508f, 0.09764874f, 0.00326286f, -0.77560455f, 0.17364413f, -0.51437122f, 0.42444625f, 
    -0.07634954f, -0.05988299f, -0.12057479f, 0.01548816f, -0.03445645f, 0.08847152f, 0.02078833f, 0.11932503f, 
    0.10815708f, 0.17797758f, -0.17938843f, 0.32613751f, 0.02530616f, -0.12244139f, -0.21959278f, 0.04825192f, 
    -0.01422642f, 0.04340680f, -0.01130498f, -0.02702861f, 0.13150452f, 0.08620413f, -0.43206459f, 0.37309709f, 
    0.03610151f, -0.15806852f, 0.16577178f, 0.10581539f, -0.14275916f, 0.15013348f, 0.43558282f, 0.13950200f, 
    0.22963706f, -0.00336732f, 0.05599536f, 0.14283516f, 0.12373085f, 0.13338099f, 0.05274986f, 0.91298354f, 
    -0.39659420f, 0.06102771f, 0.08878085f, 0.12858200f, -0.16941901f, -0.02582473f, 0.06979627f, 0.06912108f, 
    0.02852499f, -0.19108346f, -0.03811765f, -0.19554630f, 0.00179798f, -0.17273434f, -0.02908473f, -0.07170675f, 
    0.10518165f, 0.13555385f, 0.15663554f, -0.12905474f, -0.23936656f, -0.04821112f, -0.15535145f, 0.07787841f, 
    0.14201131f, 0.04070847f, 0.08938538f, -0.15140727f, -0.42659244f, 0.07051291f, 0.09090810f, -0.04265774f, 
    -0.02254660f, 0.06535105f, 0.06525753f, -0.25372392f, -0.26659921f, -0.46364558f, -0.01597798f, -0.06656933f, 
    0.64971972f, 0.06208042f, -0.16619064f, -0.10545026f, -0.07545579f, 0.00709697f, -0.18277109f, 0.02904337f, 
    0.05825152f, 0.10458569f, 0.01972333f, -0.04377876f, 0.13431685f, 0.52485335f, -0.07050552f, 0.09427618f, 
    -0.16692320f, -0.16932052f, -0.00026456f, -0.10355247f, 0.12509061f, 0.09194409f, 0.14817472f, -0.09853530f, 
    -0.10965206f, 0.14223731f, -0.00145606f, 0.13560611f, -0.00318492f, -0.04706758f, 0.14364992f, -0.36300033f, 
    -0.51792932f, 0.19987933f, 0.02936894f, 0.00565455f, -0.05800094f, -0.06454097f, -0.11971391f, -0.22137541f, 
    -0.48560566f, -0.12308756f, -0.26246062f, -0.07002726f, 0.08821897f, -0.02494399f, 0.02490067f, -0.14637324f, 
    0.11144097f, 0.04303527f, 0.25896201f, 0.11358430f, 0.04041954f, -0.05840572f, -0.08859245f, -0.07297075f, 
    -0.12827130f, 0.04448904f, 0.20320071f, 0.08580115f, 0.00885648f, -0.28555420f, -0.21506333f, -0.20573980f, 
    -0.04081972f, -0.10522234f, -0.00351080f, 0.25781590f, -0.41992027f, -0.61823386f, -0.34273651f, 0.04026831f, 
    -0.02049443f, -0.09160866f, 0.08704471f, 0.19742562f, -0.35236761f, 0.30368787f, 0.36649033f, 0.16119869f, 
    -0.06129355f, -0.01873833f, 0.15751031f, -0.14522721f, -0.20939894f, 0.21920103f, 0.19347306f, 0.17316942f, 
    -0.05212083f, -0.02372341f, -0.16768298f, 0.13824344f, -0.17150962f, -0.03014683f, 0.41757810f, -0.15219656f, 
    -0.36820778f, -0.02718076f, -0.16319504f, -0.35867220f, -0.03519531f, -0.11007106f, -0.06495532f, 0.22065900f, 
    0.00553858f, 0.04833056f, 0.09563531f, 0.08698937f, -0.24402522f, 0.25087130f, 0.01794293f, -0.02989578f, 
    0.02912125f, 0.11748282f, 0.17231697f, -0.15726164f, -0.02996180f, -0.05534402f, 0.07596490f, -0.30631739f, 
    0.11568882f, -0.20115124f, 0.19418204f, 0.16265406f, -0.04651455f, -0.08598443f, -0.05885053f, -0.05701015f, 
    -0.05760374f, 0.03160683f, 0.18700331f, -0.09610305f, 0.15695243f, -0.27833945f, 0.14041720f, 0.00015792f, 
    -0.05957577f, -0.14818597f, 0.23755951f, 0.17180546f, 0.20562536f, 0.13289352f, 0.02322716f, -0.00063083f, 
    -0.19045591f, -0.11944525f, -0.09926749f, 0.13735448f, 0.34625432f, 0.36579463f, 0.42206168f, 0.04355501f, 
    0.06584452f, 0.03094703f, 0.05333938f, -0.07456028f, -0.04161963f, 0.34907597f, -0.13943860f, 0.15766574f, 
    0.02357136f, -0.00429150f, 0.23313436f, 0.11126797f, -0.00931388f, -0.08433277f, 0.24425519f, 0.22715804f, 
    0.12068919f, 0.14155088f, -0.02675942f, 0.03726462f, 0.22643232f, -0.13080962f, 0.04693904f, 0.29707035f, 
    0.32689151f, -0.01786966f, 0.02462706f, -0.18270697f, -0.17440298f, 0.06145855f, 0.03416827f, 0.00246620f, 
    0.14307164f, -0.00846461f, 0.06847586f, -0.08986159f, -0.14985605f, -0.19120666f, 0.08656763f, -0.01478539f, 
    0.07498413f, 0.38979289f, 0.03498069f, 0.43467394f, -0.06024906f, 0.07979412f, -0.04462953f, 0.07524603f, 
    -0.02659903f, -0.03745639f, -0.59563404f, 0.19173834f, -0.14953153f, -0.07005088f, 0.23414735f, 0.01401171f, 
    0.25167373f, 0.02764753f, -0.08993743f, 0.09421160f, 0.33464822f, -0.13416985f, -0.07156634f, -0.13835107f, 
    -0.21385238f, 0.01677738f, 0.01667240f, 0.11820943f, 0.26127905f, 0.31279439f, 0.26880234f, 0.01810095f, 
    -0.12082546f, 0.06220683f, -0.00720849f, 0.05556441f, 0.09742630f, -0.21638004f, -0.05306865f, -0.21208553f, 
    0.01664605f, 0.08694221f, -0.24706230f, -0.03790094f, -0.18527091f, 0.02423613f, 0.07024682f, -0.02035492f, 
    -0.19367190f, 0.09599024f, -0.11638180f, -0.09693001f, 0.28996867f, 0.10166506f, -0.10945655f, 0.23255232f, 
    0.17284641f, 0.24550565f, 0.19840698f, 0.00620844f, 0.17156403f, 0.07740646f, -0.09900503f, -0.39279032f, 
    0.14948744f, 0.22049274f, 0.18910843f, 0.11992887f, 0.03124410f, -0.15080281f, 0.03338938f, 0.04134338f, 
    0.03017806f, 0.31549287f, 0.01743622f, -0.15577760f, 0.11043376f, -0.01701449f, 0.29031417f, 0.13089369f, 
    0.11858736f, 0.05450092f, -0.37140065f, 0.09576179f, 0.27806357f, -0.04910694f, -0.06378427f, 0.13991700f, 
    0.06399135f, -0.05177205f, -0.09227545f, -0.46688548f, 0.29556379f, -0.29025054f, 0.33507112f, 0.05291316f, 
    0.05371144f, 0.21536958f, -0.06489161f, -0.19225241f, 0.13495316f, 0.25584444f, 0.21937774f, 0.00398803f, 
    0.10933063f, 0.05953695f, 0.03651704f, -0.05028896f, -0.17538451f, 0.15507808f, -0.05329200f, 0.13746975f, 
    0.01925577f, -0.11013605f, -0.05575935f, 0.07414436f, -0.00656259f, -0.10264537f, -0.04710400f, -0.00832430f, 
    -0.10334942f, 0.10413289f, 0.02741650f, -0.19292057f, -0.18100205f, 0.04104061f, -0.03911548f, 0.47835335f, 
    -0.08837171f, -0.26530087f, 0.21113142f, -0.05208270f, -0.00973922f, 0.06716211f, -0.19686575f, 0.01019309f, 
    -0.07145817f, 0.24403390f, 0.23416282f, -0.01034399f, 0.07055970f, 0.11176175f, 0.01832108f, 0.09891420f, 
    0.08053754f, -0.00415030f, -0.05537299f, -0.17196317f, -0.03020141f, 0.14751272f, 0.12980142f, 0.08930489f, 
    0.07151343f, 0.01869066f, -0.07099766f, -0.05442912f, -0.05237401f, 0.12354743f, 0.09065212f, 0.07018853f, 
    -0.16035733f, 0.02205138f, 0.09260327f, -0.43623567f, -0.15472646f, -0.04317882f, -0.06118458f, 0.14231122f, 
    -0.02971668f, 0.27908075f, 0.06855578f, 0.38031152f, 0.18641400f, 0.03708932f, 0.12780885f, -0.19472921f, 
    -0.03664178f, 0.14937767f, 0.05692387f, 0.14016260f, 0.01732573f, 0.12536076f, -0.01727309f, -0.17027757f, 
    0.08330081f, 0.10311608f, 0.14557528f, 0.15480261f, 0.11222294f, 0.05411956f, 0.03337035f, 0.07076696f, 
    0.13373445f, 0.03367503f, 0.19653946f, 0.09752014f, 0.14039317f, -0.30971870f, -0.23424102f, 0.06515022f, 
    -0.02964617f, 0.12401690f, 0.07516106f, 0.11144658f, 0.10113893f, -0.03741192f, -0.11525138f, -0.49485973f, 
    0.02538194f, 0.08587532f, -0.11460049f, 0.06600893f, 0.06934362f, 0.11335885f, 0.36186022f, -0.01828957f, 
    0.08197816f, -0.14363731f, 0.21260186f, 0.33907917f, -0.00406861f, 0.14692473f, -0.00371907f, 0.02273771f, 
    -0.10941037f, -0.00223677f, -0.28430226f, -0.13214725f, 0.12293071f, 0.13420793f, -0.00787067f, 0.01901821f, 
    -0.03885372f, 0.28751770f, 0.02412992f, 0.24977905f, -0.24370794f, -0.04995558f, 0.02296787f, 0.21726091f, 
    0.15546910f, 0.16209629f, 0.02667367f, 0.01366782f, -0.00756834f, 0.08866546f, 0.04182069f, -0.05566839f, 
    -0.11884099f, -0.09877997f, 0.17315698f, -0.08204142f, -0.23269781f, -0.21558039f, -0.02921548f, -0.01213355f, 
    0.18515341f, 0.08994409f, 0.28612339f, -0.05355507f, 0.03290515f, 0.14236866f, 0.00193060f, 0.04112767f, 
    -0.10400257f, 0.10590330f, 0.09600803f, 0.08446713f, 0.09716842f, 0.06298488f, -0.00129320f, 0.06326418f, 
    0.05137208f, 0.01923670f, 0.11125825f, 0.05786801f, 0.14860658f, -0.13850221f, -0.45643365f, -0.53186113f, 
    0.01562761f, 0.08258069f, 0.09876689f, -0.03063862f, -0.08683824f, -0.06655764f, 0.03847465f, 0.01164653f, 
    -0.29501343f, 0.05839076f, -0.10104542f, 0.12216677f, 0.04448000f, 0.09558212f, 0.02559688f, 0.04803245f, 
    -0.16552401f, -0.09745090f, -0.51388931f, -0.14012611f, 0.44493547f, 0.25108573f, -0.23420984f, 0.16950981f, 
    -0.09591730f, -0.05018368f, 0.03497846f, -0.08339657f, -0.01106900f, -0.06073517f, 0.07797401f, 0.28610864f, 
    -0.10303400f, 0.13851446f, -0.07177133f, 0.02601601f, -0.12729372f, -0.01671629f, 0.22223933f, 0.05897268f, 
    0.06181754f, 0.03116358f, -0.13811067f, -0.13309745f, -0.02291354f, 0.13427426f, -0.06973170f, 0.05530421f, 
    0.05292744f, -0.09150762f, -0.25984076f, 0.15409227f, -0.06588236f, -0.16638079f, -0.10146543f, -0.01028826f, 
    0.02943408f, 0.11632571f, 0.04974630f, 0.20044203f, 0.07697364f, 0.02349601f, 0.00372534f, -0.05209988f, 
    0.23831983f, -0.12841533f, -0.01856055f, 0.09948859f, -0.16497207f, 0.18579446f, -0.06017176f, -0.02290054f, 
    0.07831304f, -0.16604973f, -0.67313051f, 0.02451714f, 0.11625560f, 0.11544246f, 0.18331717f, 0.05029614f, 
    -0.00877213f, -0.41376388f, -0.21568227f, 0.19038701f, 0.07894436f, 0.23689835f, 0.34983340f, -0.04911416f, 
    0.05047905f, 0.09232584f, 0.14098787f, 0.16018240f, 0.19295038f, -0.04614306f, 0.04330331f, -0.08243869f, 
    0.20598917f, -0.14220464f, -0.24635136f, -0.02911025f, -0.24903496f, -0.35259610f, -0.16074294f, 0.07946558f, 
    -0.26764917f, 0.09134914f, -0.26912624f, 0.23491447f, -0.03954475f, 0.08213718f, 0.12242027f, -0.04713088f, 
    -0.03265861f, -0.21513805f, -0.07838494f, -0.46355075f, -0.27699423f, 0.27461892f, 0.06490495f, -0.10325026f, 
    -0.06354496f, -0.14861992f, 0.12628053f, 0.10047720f, 0.07182022f, -0.06158702f, -0.13678357f, -0.18266186f, 
    -0.22373609f, 0.13046794f, -0.04485881f, 0.18213399f, 0.06232632f, 0.04372452f, 0.19417107f, 0.10118229f, 
    -0.15484492f, -0.22555368f, -0.13952649f, 0.09116534f, 0.16514951f, 0.06507692f, 0.05402752f, -0.05001094f, 
    0.00637903f, -0.00661464f, -0.03011114f, -0.05820129f, -0.01640288f, 0.03355784f, -0.04651575f, -0.02103279f, 
    0.01097482f, -0.01119842f, -0.00831833f, -0.04361311f, 0.04222047f, 0.00491205f, 0.01935421f, 0.02277244f, 
    0.00088830f, 0.02848965f, 0.01300179f, 0.00607410f, -0.04668180f, 0.02819318f, -0.06446265f, 0.02967241f, 
    -0.00109021f, 0.04717275f, 0.02376666f, -0.02720963f, -0.05241128f, -0.05606444f, 0.00247252f, -0.03799710f, 
    -0.06086248f, -0.05225682f, -0.00823115f, 0.00845570f, -0.00447668f, -0.01742197f, 0.04879896f, -0.01512438f, 
    0.00304180f, -0.00627746f, 0.00601781f, -0.04663894f, 0.02959911f, 0.03502030f, -0.00535523f, 0.01700563f, 
    -0.03411656f, -0.02188204f, 0.04223182f, -0.02246130f, -0.04819006f, -0.00553958f, 0.03223876f, -0.00068954f, 
    -0.03948418f, -0.01795697f, -0.01182107f, -0.04762299f, 0.01944041f, -0.03386248f, 0.02013195f, -0.05068010f, 
    -0.02881480f, -0.03940851f, -0.00251788f, -0.00950672f, -0.05991190f, 0.01261541f, -0.06239151f, 0.03629045f, 
    -0.00370246f, -0.03365274f, -0.03347556f, 0.03045018f, -0.01016840f, 0.03651836f, -0.03993905f, 0.04748779f, 
    -0.05469947f, -0.00768353f, 0.01796754f, -0.00648701f, 0.04829116f, -0.06042644f, 0.02316790f, 0.03958444f, 
    -0.00254499f, 0.01580594f, -0.04248372f, -0.00066460f, -0.06594530f, -0.06365401f, -0.04617612f, -0.03818959f, 
    -0.04163733f, 0.03708721f, 0.00120012f, -0.03786431f, 0.03591201f, -0.02439089f, -0.00136304f, -0.05108969f, 
    0.04519641f, 0.02676564f, -0.02396426f, -0.02552050f, -0.06598642f, -0.05405818f, -0.01362236f, -0.05587252f, 
    -0.02154747f, -0.05630856f, -0.06337778f, -0.02970828f, -0.01474141f, -0.02842346f, -0.04546972f, -0.04231579f, 
    0.00760079f, -0.05296366f, 0.03981525f, 0.03130220f, 0.04147410f, -0.06052739f, -0.02686996f, -0.04724816f, 
    -0.01142101f, 0.02844862f, -0.03267165f, -0.04853268f, -0.03254577f, 0.02813470f, 0.00097790f, 0.01111743f, 
    0.03847242f, 0.03398355f, 0.01560605f, 0.03578249f, 0.02091753f, -0.05384982f, 0.00403519f, 0.00900843f, 
    0.00071927f, -0.00512261f, -0.00075136f, 0.01334750f, -0.04891794f, 0.00246682f, -0.03683572f, -0.06177568f, 
    -0.00317605f, 0.01165066f, -0.04971756f, 0.00966701f, -0.06394222f, 0.05065994f, -0.05367274f, 0.01106319f, 
    -0.05417278f, 0.03059402f, -0.01771924f, -0.05688589f, 0.05253016f, -0.01812333f, 0.05426572f, 0.01607468f, 
    -0.04011851f, 0.01112809f, 0.03907915f, 0.00872838f, -0.04564924f, -0.00662503f, -0.04859287f, 0.01220693f, 
    -0.06018817f, -0.05554414f, -0.05899052f, -0.01036370f, -0.05891690f, -0.00970989f, -0.02483372f, -0.00445801f, 
    0.04131587f, -0.03284378f, 0.03433645f, -0.01287172f, 0.01658884f, 0.01815600f, 0.01443339f, -0.00941551f, 
    0.04854634f, -0.04193390f, -0.03285264f, -0.00367264f, -0.02921612f, 0.00123055f, -0.01881222f, 0.00959381f, 
    0.04831214f, -0.01766634f, -0.05878423f, 0.02368733f, -0.05017258f, 0.01818110f, -0.03900224f, -0.03302408f, 
    -0.03156212f, -0.06025103f, 0.01458970f, -0.01168104f, -0.01483458f, -0.05656003f, -0.02308007f, 0.02286733f, 
    0.04714916f, -0.03039167f, -0.06598496f, -0.00012786f, 0.04022367f, 0.00515601f, 0.03248137f, -0.06220473f, 
    -0.01656170f, -0.02300655f, 0.05441027f, -0.01539688f, 0.01977299f, -0.00765915f, -0.01978780f, 0.04608925f, 
    0.04486509f, -0.06435007f, 0.00139882f, -0.01142186f, -0.01803814f, -0.01431598f, -0.06084020f, -0.03356671f, 
    -0.02343093f, -0.03609770f, 0.03325757f, -0.01681053f, -0.02256242f, -0.05635234f, -0.00342227f, -0.03720955f, 
    0.02574518f, -0.03640676f, -0.01829173f, -0.01045575f, -0.04367071f, -0.05959628f, -0.05976649f, -0.00410480f, 
    -0.01641273f, 0.04640539f, -0.05037343f, 0.00760711f, -0.04884918f, -0.04787543f, -0.04399376f, 0.03888828f, 
    -0.00055788f, 0.01644610f, 0.02706088f, 0.03949974f, 0.02008172f, 0.03346213f, -0.03164168f, 0.02826283f, 
    -0.03740212f, -0.02184288f, 0.01605969f, -0.05100224f, -0.04757926f, 0.00116831f, 0.03225566f, 0.00111353f, 
    -0.02300079f, -0.04538037f, 0.03557143f, -0.01008473f, 0.01115198f, -0.00539379f, 0.00216062f, -0.01941955f, 
    0.01113339f, 0.00881096f, -0.03029823f, 0.03985209f, -0.05702887f, -0.05253569f, -0.04334943f, 0.03894762f, 
    -0.06325752f, 0.03130675f, -0.00705336f, 0.01499788f, 0.02439084f, -0.01452087f, 0.02717834f, -0.02726367f, 
    -0.04625120f, 0.04016940f, -0.01930351f, 0.00824110f, 0.02288174f, 0.04686321f, 0.04617917f, 0.04599423f, 
    0.03513657f, -0.02949960f, -0.02848940f, -0.01848054f, 0.00984521f, -0.03834097f, -0.04626186f, -0.01912859f, 
    0.01692352f, -0.06426993f, -0.05414741f, 0.03767193f, -0.05707868f, -0.00876175f, 0.05328804f, 0.04832443f, 
    -0.00565489f, 0.03173076f, -0.05715357f, 0.02153070f, 0.01209606f, -0.02681435f, -0.01350123f, -0.00126548f, 
    -0.00559913f, -0.06833577f, -0.00359512f, -0.06002307f, -0.00752612f, 0.02901219f, 0.00481920f, 0.01000777f, 
    -0.03789606f, 0.04996125f, 0.04064301f, -0.07054218f, -0.05454018f, 0.00306102f, 0.04972317f, -0.03146549f, 
    0.02712423f, 0.01696501f, -0.00155638f, -0.05811570f, -0.03097305f, -0.00989866f, 0.00914801f, -0.04801035f, 
    -0.04276376f, 0.04080173f, 0.04994836f, -0.06143124f, 0.01402402f, 0.03206958f, -0.05873484f, -0.04498364f, 
    -0.06457113f, -0.02537334f, -0.05374835f, -0.07291600f, -0.01097813f, 0.01075158f, -0.02693889f, -0.03187792f, 
    0.03416944f, -0.06110377f, -0.01873207f, 0.03367520f, -0.00086266f, 0.03813465f, 0.02168390f, -0.05033850f, 
    -0.05241590f, -0.00672611f, 0.01912851f, -0.00369162f, 0.02712554f, -0.03429696f, -0.01754621f, 0.02437179f, 
    -0.01939138f, 0.01960506f, -0.05646884f, -0.02496868f, 0.00708041f, 0.04495422f, -0.04797108f, -0.01000713f, 
    -0.04761252f, 0.03218538f, -0.02844820f, -0.04165517f, -0.03890230f, -0.00288119f, -0.00389434f, 0.01756814f, 
    0.00059877f, 0.04648068f, -0.04294134f, 0.04120257f, 0.03868690f, 0.03027385f, -0.04766114f, 0.02213934f, 
    -0.02444839f, 0.01498959f, -0.04353879f, -0.02873853f, 0.04427066f, -0.02840941f, -0.04099987f, -0.04791417f, 
    0.03758096f, -0.04732944f, -0.03938693f, 0.01008087f, 0.02100480f, 0.01503137f, 0.05398903f, -0.01861909f, 
    0.05843744f, 0.00876598f, -0.03968600f, 0.05143534f, -0.03577865f, 0.02386381f, 0.03676174f, -0.03307977f, 
    -0.04330318f, -0.01420512f, 0.05884017f, -0.05335039f, -0.05089425f, -0.04404908f, 0.05913405f, 0.01958983f, 
    -0.06409054f, 0.00357218f, 0.03509504f, -0.04052294f, 0.03195632f, -0.01943941f, -0.02753000f, 0.02434326f, 
    0.04138203f, -0.00998331f, 0.02099513f, -0.02855804f, 0.03394404f, -0.00445706f, 0.01182103f, -0.01255993f, 
    0.05446579f, -0.01167204f, -0.00441359f, -0.03462307f, -0.01620455f, -0.01314593f, -0.05415221f, 0.05296922f, 
    -0.00779777f, -0.03952711f, 0.00604696f, 0.00846951f, -0.00885684f, -0.00705172f, 0.02906046f, 0.03733808f, 
    -0.01000803f, -0.02052138f, 0.01086622f, -0.00195389f, 0.04474545f, 0.03270175f, -0.01144309f, -0.01090973f, 
    0.04593455f, 0.02635840f, -0.01387310f, 0.04946981f, -0.00183104f, -0.01432436f, 0.03869840f, 0.03998104f, 
    -0.04363323f, -0.03944332f, 0.01818770f, 0.01942451f, 0.03531322f, -0.01854385f, -0.03227317f, 0.02513992f, 
    -0.06284210f, -0.00281492f, -0.00301103f, 0.01521710f, -0.04142359f, 0.00290410f, -0.00908490f, -0.02182596f, 
    -0.02297494f, -0.00835499f, -0.02954038f, -0.00862345f, -0.03525198f, -0.03538560f, -0.00343308f, 0.00609826f, 
    0.03317232f, -0.02524432f, 0.03799775f, -0.00755377f, 0.03847601f, -0.00658102f, 0.00490971f, -0.00219314f, 
    -0.03139158f, -0.02507542f, -0.05041141f, -0.00739785f, -0.02285714f, 0.03859575f, -0.05408476f, -0.02029757f, 
    0.00741339f, 0.00447437f, 0.02632147f, 0.00393640f, 0.00764481f, -0.01463606f, -0.01073218f, -0.06634712f, 
    -0.00704619f, -0.02769035f, -0.01601274f, 0.02999943f, -0.01166758f, -0.03696712f, 0.03340437f, -0.04648842f, 
    0.02059224f, 0.02808781f, 0.03838278f, 0.03096367f, -0.01292972f, -0.04306117f, 0.02538386f, -0.03368276f, 
    -0.04149091f, -0.00241320f, -0.01925296f, -0.05387982f, -0.02703395f, -0.02907707f, 0.00087900f, 0.00751519f, 
    0.01171572f, -0.02042811f, -0.05457789f, -0.06162612f, -0.03593480f, -0.03018931f, -0.06129842f, -0.04210557f, 
    0.06981190f, -0.01069051f, 0.07087929f, -0.05312939f, -0.09693392f, -0.17343748f, -0.19606686f, -0.12247633f, 
    0.09426283f, -0.23855886f, -0.11787955f, 0.13229273f, -0.02635919f, 0.03063461f, 0.00070726f, 0.03150281f, 
    0.17029470f, 0.05993550f, 0.02238085f, 0.03714849f, 0.07021139f, -0.19396548f, -0.27206850f, -0.13924129f, 
    0.24040870f, 0.06025138f, 0.26082498f, -0.05273632f, 0.38308045f, 0.05144937f, -0.09663200f, -0.40666762f, 
    -0.33281034f, 0.02872095f, 0.06467541f, 0.23153055f, -0.11043940f, 0.07902725f, 0.12859958f, 0.10867823f, 
    0.08048482f, -0.15586588f, 0.18483685f, 0.05338965f, 0.20982639f, -0.17010021f, -0.02816632f, -0.02098940f, 
    -0.20157775f, -0.03158995f, -0.05715158f, 0.18253563f, -0.00687408f, -0.00434541f, 0.09384211f, 0.17220183f, 
    -0.02096923f, -0.30523536f, -0.12383675f, -0.04260693f, 0.08256788f, -0.03449731f, 0.10324684f, 0.02686488f, 
    0.22625269f, 0.21566603f, -0.24834077f, -0.16453399f, -0.05884404f, 0.09903267f, 0.07483350f, 0.13501732f, 
    -0.29650277f, -0.00140544f, 0.17051154f, -0.26098156f, 0.15305337f, -0.06289683f, -0.00728882f, 0.10473884f, 
    0.11121032f, 0.29293615f, 0.39458263f, 0.18403062f, 0.11350285f, -0.00222197f, 0.06214498f, -0.10474432f, 
    -0.10253735f, -0.18453369f, -0.04112995f, -0.32168415f, -0.35426378f, -0.06503361f, -0.23337643f, 0.30997202f, 
    0.20708619f, -0.01928115f, 0.39999601f, -0.27844271f, -0.16391651f, 0.14282304f, -0.00253052f, 0.07916205f, 
    -0.15947349f, 0.10660963f, -0.12079117f, 0.18228662f, -0.08147372f, 0.08583198f, 0.19314510f, -0.07773581f, 
    -0.04304498f, 0.09021948f, -0.08396738f, 0.14433427f, -0.20395975f, -0.01680911f, 0.43660125f, 0.21481666f, 
    -0.17603229f, 0.19036449f, -0.37869087f, 0.03417156f, 0.18075487f, -0.23398004f, -0.10942276f, -0.00764772f, 
    -0.00274478f, 0.14908247f, 0.09881124f, 0.10739603f, 0.00808454f, -0.04350477f, 0.06372512f, 0.09262471f, 
    0.08904903f, -0.01934268f, -0.33765712f, -0.19703069f, -0.15954277f, 0.27925205f, 0.06520092f, 0.05683909f, 
    0.41895732f, 0.46631509f, 0.26210958f, 0.07674279f, -0.29032055f, -0.14817011f, 0.01903177f, 0.05724366f, 
    -0.07590333f, 0.40913060f, 0.26073843f, 0.38116330f, -0.04320983f, -0.14373346f, -0.12006047f, -0.08258837f, 
    -0.04257131f, 0.06501839f, -0.70332992f, -0.49167842f, -0.37327588f, 0.04160679f, -0.00629256f, 0.16391003f, 
    0.37718350f, -0.18971553f, -0.21669272f, 0.07516039f, -0.09163162f, 0.08778374f, 0.10265571f, 0.21249110f, 
    -0.04610899f, 0.15891153f, 0.25189576f, 0.06947093f, 0.39804703f, 0.35981539f, 0.05615520f, 0.00218770f, 
    0.02453994f, -0.08251576f, -0.11700808f, -0.12160015f, 0.00127335f, 0.11675969f, -0.15782134f, 0.02970568f, 
    0.02877807f, -0.01707713f, -0.34342852f, 0.04253350f, -0.13840452f, 0.03882550f, -0.35448593f, -0.22221605f, 
    0.05649024f, -0.01521282f, -0.00264113f, 0.05090304f, 0.08067045f, -0.23738687f, -0.08541170f, -0.10866870f, 
    -0.37621209f, -0.43015578f, 0.15103824f, -0.09929568f, -0.14080626f, -0.08241579f, 0.15437250f, -0.18835457f, 
    -0.09866367f, -0.05130700f, 0.03915738f, -0.07854102f, -0.02809091f, 0.00873829f, -0.06534823f, -0.05531617f, 
    0.35648248f, -0.18964085f, -0.22499466f, 0.06688910f, -0.00754941f, -0.00251604f, -0.03917466f, 0.14980935f, 
    0.01671859f, 0.20749813f, 0.29262689f, 0.24977501f, 0.27999279f, 0.08330393f, -0.10151121f, 0.05097466f, 
    -0.02317367f, 0.17490199f, -0.10508697f, -0.47646621f, -0.71618485f, -0.70186490f, -0.06326983f, -0.01051723f, 
    -0.00160630f, 0.05952820f, -0.27767515f, -0.25004023f, -0.03179689f, 0.16002139f, 0.11043376f, -0.09960919f, 
    -0.06960742f, 0.06698714f, 0.00462823f, 0.08061684f, -0.06363104f, 0.29176885f, -0.20730647f, 0.07509355f, 
    0.08276235f, 0.02817632f, -0.02663943f, -0.01562105f, 0.05927608f, -0.01933438f, -0.63908130f, 0.09685282f, 
    0.36798531f, 0.04113262f, 0.18135095f, 0.00297717f, 0.00230622f, 0.31096029f, -0.26386669f, -0.22813000f, 
    -0.11597259f, -0.23297440f, -0.22252116f, -0.06620225f, -0.20855495f, 0.06019476f, -0.15315995f, -0.07901607f, 
    -0.03639432f, 0.02988188f, 0.01026412f, -0.01813968f, -0.02056799f, -0.02586455f, -0.05216858f, 0.00342291f, 
    0.04333141f, 0.02459032f, -0.03041703f, -0.04205490f, 0.00793910f, -0.04301799f, 0.03963759f, -0.03297906f, 
    -0.04048976f, -0.00932555f, -0.04419031f, -0.06076834f, 0.03496769f, 0.04623177f, -0.04445845f, -0.02784408f, 
    -0.00077057f, 0.04438791f, -0.02031513f, -0.01673214f, 0.04831450f, 0.05920913f, -0.04754175f, 0.00550104f, 
    0.01565794f, 0.01644425f, 0.04725730f, -0.02052052f, 0.01033288f, 0.03247380f, 0.02536764f, -0.01963233f, 
    -0.05561116f, -0.00140633f, -0.01690170f, 0.02740864f, -0.04914502f, 0.03214771f, 0.00909842f, -0.04270757f, 
    0.00174977f, 0.03913067f, 0.03895705f, -0.06162294f, 0.04691838f, -0.06122862f, -0.03123999f, 0.00626774f, 
    0.02041976f, 0.01721470f, -0.02974087f, -0.05012161f, -0.01007155f, -0.02663768f, 0.00708538f, -0.03583724f, 
    -0.01012625f, 0.00892813f, -0.02787681f, 0.03241497f, -0.00926194f, -0.05722150f, -0.00522630f, 0.02732733f, 
    -0.01070418f, -0.02717264f, 0.03609077f, 0.02475559f, 0.03405837f, 0.00326204f, -0.00171028f, -0.01058019f, 
    -0.01523118f, -0.06339570f, 0.02218356f, 0.04564273f, -0.03865865f, -0.06730703f, -0.06096567f, 0.04394283f, 
    -0.05690325f, -0.05326035f, 0.00827707f, 0.01084932f, -0.04755704f, -0.01967870f, -0.00638727f, 0.02327137f, 
    0.00132859f, 0.02198697f, 0.00017189f, 0.03955298f, -0.06661984f, 0.03726262f, -0.06039198f, 0.01179350f, 
    0.01970378f, 0.04675831f, -0.05792433f, -0.00045418f, 0.00499327f, -0.01481459f, -0.06202776f, 0.02475167f, 
    0.00848382f, 0.00673283f, 0.01717728f, 0.03056426f, 0.04739344f, -0.03284721f, 0.04607078f, -0.04835261f, 
    0.05314644f, 0.03019926f, -0.03607447f, 0.00253298f, -0.01109564f, 0.03898609f, -0.02305865f, 0.02364527f, 
    0.04244999f, -0.05677702f, 0.03104003f, -0.05019733f, 0.01182015f, -0.05418358f, -0.06022353f, -0.05799195f, 
    -0.02491853f, 0.01933392f, 0.04052737f, -0.04399244f, -0.01331920f, 0.02595340f, -0.02478329f, -0.04139379f, 
    -0.03397088f, -0.01503781f, -0.03526582f, 0.01948015f, -0.03017334f, -0.02735118f, -0.02375966f, 0.03785444f, 
    -0.01178001f, 0.00036391f, 0.04385649f, 0.00080733f, -0.05705203f, -0.03861495f, -0.00984231f, -0.03301317f, 
    -0.04827057f, -0.02884675f, 0.02421052f, -0.00167560f, -0.03974432f, 0.01167197f, 0.01883384f, -0.03608046f, 
    0.04484577f, -0.05814133f, 0.02325571f, 0.03552609f, -0.00909869f, -0.02674145f, 0.00478860f, -0.04683811f, 
    0.01563730f, -0.01144802f, 0.00359469f, 0.04622041f, 0.05238883f, 0.00837873f, 0.02448816f, -0.05983341f, 
    0.03970802f, 0.00590454f, 0.03741094f, -0.04858807f, 0.00647433f, 0.03621332f, 0.03667486f, -0.00009560f, 
    0.01799112f, -0.03724008f, -0.00295997f, 0.02391381f, -0.01100657f, 0.00668774f, -0.03088793f, -0.06520217f, 
    0.01714715f, -0.00266726f, -0.01013781f, -0.03292260f, 0.03935764f, -0.01419226f, -0.04387767f, -0.01831224f, 
    0.01930516f, 0.03199465f, 0.02926119f, -0.01916317f, 0.03640060f, 0.01548363f, 0.04116491f, 0.00571486f, 
    0.00784074f, -0.04334172f, -0.06092960f, 0.02518825f, 0.02562671f, -0.01770723f, -0.00603929f, -0.02389206f, 
    -0.05939677f, -0.04249161f, 0.02907221f, 0.04854034f, -0.02196754f, 0.01510043f, 0.03415036f, -0.01546220f, 
    -0.02202005f, -0.05235039f, 0.00536965f, 0.01136800f, 0.03002039f, -0.02979296f, -0.00485080f, -0.02743417f, 
    -0.03292056f, -0.00992450f, -0.04163394f, 0.06172336f, -0.01372680f, 0.02567433f, -0.00899942f, 0.00434483f, 
    -0.03272197f, -0.05340028f, -0.01313708f, -0.04725159f, -0.04315234f, 0.02674705f, -0.02216993f, -0.03080891f, 
    0.00269465f, 0.04730725f, -0.00027718f, 0.03659239f, -0.00568030f, -0.02225914f, 0.04602125f, -0.03683912f, 
    0.02162160f, -0.03269964f, -0.03190306f, -0.02861466f, 0.02884337f, -0.06623846f, 0.01893324f, -0.01889457f, 
    0.02485416f, 0.01263589f, -0.05561263f, -0.03183691f, 0.01679133f, -0.01004463f, 0.01599673f, 0.04061854f, 
    -0.01038217f, -0.04930592f, 0.01425171f, -0.01403950f, 0.00894204f, -0.06335809f, -0.06248662f, -0.01382220f, 
    -0.23460411f, 0.50939828f, 0.69959486f, -0.03728120f, -0.07045646f, 0.20943798f, 0.05329073f, 0.01888016f, 
    -0.02642106f, -0.25400078f, 0.19176832f, -0.18149775f, -0.03666422f, 0.02309029f, -0.18783462f, 0.02323277f, 
    0.22972497f, 0.03633253f, -0.11349029f, -0.08631478f, -0.10931330f, 0.02640042f, -0.02577190f, 0.02886641f, 
    -0.19840357f, 0.00125338f, -0.11218110f, 0.28820467f, -0.46803331f, -0.32757935f, 0.07466143f, 0.05286615f, 
    0.18465407f, -0.54476285f, 0.17607126f, 0.20216480f, -0.12830457f, 0.53487152f, 0.40017563f, -0.13679922f, 
    0.00104950f, -0.11920083f, -0.00562629f, -0.03403479f, -0.16230646f, -0.01999573f, 0.08853263f, 0.03409152f, 
    -0.13007990f, -0.06986535f, -0.02060322f, -0.06083627f, 0.06931746f, -0.05245604f, 0.01766856f, -0.03969213f, 
    -0.34101331f, 0.02178607f, -0.00091125f, -0.15944575f, 0.23385179f, 0.02934589f, 0.27304497f, -0.08722458f, 
    -0.08385525f, -0.08749836f, 0.01891189f, -0.08166954f, 0.19245063f, 0.13457564f, 0.43540734f, 0.06521751f, 
    -0.32009241f, 0.15884316f, 0.20266397f, -0.04457339f, -0.09704529f, -0.18484147f, -0.05759900f, 0.15729351f, 
    0.19605446f, -0.17382735f, 0.23937434f, 0.10360767f, 0.01648373f, 0.18831262f, 0.04860714f, 0.13048546f, 
    0.08315757f, 0.15730430f, -0.02920367f, -0.44981802f, -0.05312563f, 0.16627282f, 0.12929787f, 0.00854792f, 
    -0.17469278f, -0.13209540f, -0.17639737f, -0.48775077f, 0.34589386f, -0.02597762f, -0.06761171f, -0.14990415f, 
    -0.03121560f, 0.06310384f, 0.13903427f, 0.14990696f, -0.00941847f, 0.24031489f, 0.04826663f, 0.05966484f, 
    0.19871482f, -0.08478767f, 0.15488620f, 0.19073080f, 0.02134692f, 0.04066206f, -0.00947187f, 0.01362597f, 
    0.10412706f, -0.09097243f, -0.00486482f, 0.02393251f, 0.29593816f, 0.18466778f, 0.06280632f, 0.27674547f, 
    -0.08988469f, -0.11204821f, 0.00102745f, -0.19780311f, -0.10647920f, 0.10706186f, 0.02598013f, -0.05112175f, 
    0.03428813f, -0.05471971f, 0.08599633f, -0.05773943f, 0.01376106f, 0.21825263f, 0.20289330f, 0.07217766f, 
    -0.38335189f, -0.03202563f, -0.13503250f, -0.24005717f, -0.24169309f, -0.15573987f, 0.21642742f, -0.02406026f, 
    0.13269395f, -0.16393550f, 0.06432553f, 0.08193310f, -0.21002477f, -0.09665576f, -0.29726899f, 0.12475047f, 
    -0.01069847f, 0.04426551f, -0.52777410f, -0.42107707f, 0.58602554f, -0.02524640f, 0.07908690f, 0.43047851f, 
    -0.39740825f, -0.15560088f, -0.20143707f, -0.06235113f, 0.12964436f, 0.14508587f, -0.01809832f, 0.29749459f, 
    -0.27442473f, 0.07134897f, 0.03244644f, -0.00519343f, 0.10016047f, 0.23952469f, -0.19947831f, -0.15611725f, 
    0.05916090f, 0.04112114f, 0.16189598f, 0.06961958f, 0.17213897f, -0.32303402f, -0.18532059f, -0.09533090f, 
    0.02061024f, -0.03553218f, -0.13278908f, 0.20546211f, 0.03748042f, 0.08365288f, -0.16949143f, 0.08792058f, 
    0.28117546f, -0.14499816f, -0.13952114f, -0.14851657f, 0.02907825f, -0.14191917f, 0.01506601f, 0.08832667f, 
    -0.07419454f, 0.40108410f, 0.00550728f, 0.21188779f, 0.38762322f, 0.15198632f, 0.24279307f, -0.02564078f, 
    -0.29401869f, 0.20909692f, 0.17260440f, -0.16338407f, -0.21214741f, -0.08211377f, -0.01187749f, 0.06968922f, 
    0.12781397f, 0.01436072f, -0.35931882f, -0.50895566f, -0.03566275f, -0.04596628f, -0.24040718f, 0.01261976f, 
    0.08761098f, -0.19332582f, -0.30476603f, -0.20778480f, 0.04471533f, -0.07314354f, -0.01663913f, -0.09182355f, 
    0.10076890f, -0.03071077f, 0.01306426f, -0.19908404f, -0.14941710f, 0.33766687f, 0.00153163f, 0.53390819f, 
    0.06018751f, -0.00358570f, -0.12423778f, 0.19963703f, -0.18974674f, 0.04556605f, -0.05553376f, 0.11303551f, 
    0.20032077f, -0.06767781f, 0.12082843f, -0.06015643f, 0.21592893f, -0.08122017f, 0.14370553f, 0.02433666f, 
    -0.09233642f, 0.07868812f, -0.21329390f, 0.06434898f, 0.17014407f, 0.08943247f, -0.00957417f, 0.15782717f, 
    0.53983170f, 0.07347880f, 0.03193186f, 0.16636799f, -0.07656200f, 0.15252991f, 0.33517799f, -0.35576484f, 
    0.29516539f, -0.18555956f, -0.00960701f, 0.02823232f, -0.06121151f, 0.00670150f, -0.12366008f, -0.15375669f, 
    0.41593969f, 0.11707731f, -0.00929182f, -0.17340519f, -0.22294860f, 0.19292107f, 0.01116847f, -0.05607921f, 
    0.01030988f, -0.00031913f, -0.12804471f, -0.05307090f, -0.04077547f, 0.14599763f, -0.04919966f, -0.07330276f, 
    0.00719693f, 0.02055787f, -0.01802242f, -0.18138263f, -0.12125441f, 0.02728905f, 0.03343903f, -0.04499667f, 
    0.11877050f, -0.11638769f, 0.17361988f, -0.26318684f, -0.24957059f, -0.04820981f, -0.04725509f, 0.10811223f, 
    -0.37400937f, 0.17390954f, 0.04328054f, 0.10476397f, 0.09063504f, 0.14033909f, 0.00051118f, -0.06628098f, 
    -0.18048714f, -0.15572734f, -0.10341914f, -0.08694831f, 0.11965023f, 0.05546642f, -0.14751573f, 0.29280132f, 
    0.16062582f, 0.09001164f, -0.08144296f, -0.08472641f, -0.04954687f, 0.26321015f, -0.11738300f, 0.09679095f, 
    0.19234124f, 0.14033629f, -0.03203836f, 0.08409001f, -0.12024921f, -0.12766811f, 0.01371942f, 0.20191404f, 
    0.06855045f, 0.11655968f, 0.00300996f, -0.09020577f, -0.01447527f, -0.06065336f, 0.01597407f, -0.15567730f, 
    -0.09918216f, -0.18392177f, 0.27579042f, -0.12436721f, 0.03552305f, 0.01785749f, -0.17137021f, 0.17488496f, 
    0.11229597f, -0.09912198f, -0.05232630f, -0.21737505f, -0.13585368f, -0.35544857f, 0.26533419f, -0.06905704f, 
    -0.03948203f, 0.02671902f, 0.13652630f, -0.16685221f, -0.22357672f, 0.21026376f, 0.03833123f, 0.05625043f, 
    0.09575908f, -0.16142108f, 0.17436209f, 0.13073996f, 0.13663125f, -0.11916690f, 0.11614522f, 0.12054036f, 
    -0.07438387f, 0.09424828f, 0.02293690f, 0.16555916f, -0.03692520f, 0.15545279f, 0.13268913f, -0.14299652f, 
    -0.17096627f, 0.05212047f, 0.01942293f, 0.03949751f, -0.05108948f, 0.41988379f, 0.57390881f, 0.06422976f, 
    0.00420635f, -0.34680250f, -0.08526517f, -0.21279472f, 0.00089037f, 0.05814407f, 0.11965809f, 0.00132227f, 
    0.15081587f, 0.09583085f, 0.11428206f, -0.08979828f, -0.08305223f, -0.02858129f, 0.03294532f, 0.07133505f, 
    0.02417175f, 0.06224495f, 0.00039821f, -0.00153144f, 0.04498576f, -0.23633875f, 0.09985330f, -0.18069181f, 
    0.04921086f, 0.33736211f, 0.03955178f, 0.14413153f, -0.24357098f, -0.10301699f, 0.21519786f, -0.23839833f, 
    -0.19623670f, 0.05891206f, 0.13243173f, -0.31006727f, 0.38023108f, -0.18932095f, -0.17430671f, 0.02671457f, 
    -0.00438687f, 0.06872043f, 0.06116695f, -0.19116598f, -0.60849738f, -0.04259783f, -0.32582498f, 0.04505137f, 
    0.11779179f, 0.08520857f, -0.09732993f, 0.10734940f, -0.13403548f, -0.13385563f, -0.03804456f, 0.02676683f, 
    0.06998159f, 0.13423869f, 0.14070238f, -0.01702202f, 0.35699034f, 0.22257297f, -0.32167697f, 0.26300395f, 
    -0.17592479f, 0.09730884f, 0.12836555f, 0.05092545f, 0.03350467f, -0.13560991f, 0.00299045f, -0.06825042f, 
    0.05828643f, -0.12361132f, 0.32807997f, 0.00777256f, -0.01671607f, 0.07336918f, 0.02376149f, 0.22223127f, 
    0.12850608f, -0.02421476f, 0.16966726f, -0.04728719f, -0.01438047f, -0.02056505f, 0.07709759f, 0.13911080f, 
    -0.24941915f, -0.08225754f, 0.32352227f, -0.14204237f, 0.15567377f, -0.17428954f, 0.22682217f, -0.18252242f, 
    0.32147470f, -0.22842646f, -0.05833503f, 0.08715480f, 0.04492599f, -0.07516290f, 0.04849407f, -0.15407386f, 
    0.02911633f, 0.39693329f, 0.39804941f, -0.09202551f, 0.02569043f, -0.10800646f, -0.13280906f, -0.01464266f, 
    0.10387293f, 0.05468879f, 0.09274017f, 0.26124626f, -0.25459784f, 0.21748078f, 0.03830489f, 0.16365881f, 
    0.06948145f, -0.06094913f, -0.11548913f, -0.39287955f, 0.23797844f, -0.24598964f, -0.16153488f, 0.07869291f, 
    0.33580923f, -0.06154674f, -0.10268219f, 0.32948774f, -0.00635188f, 0.12946376f, -0.06533855f, -0.03081819f, 
    -0.03995136f, 0.02119807f, -0.10567003f, -0.22853231f, 0.02556928f, 0.03531262f, -0.01892805f, -0.01712557f, 
    0.09318142f, 0.06632587f, 0.04076812f, 0.01932162f, 0.10062243f, -0.12077313f, -0.56352371f, -0.10074741f, 
    0.16423817f, -0.05690395f, 0.03322743f, 0.04346937f, 0.06338602f, 0.09137794f, 0.33439657f, -0.21802519f, 
    -0.17581524f, 0.29628393f, -0.10220481f, -0.07677753f, 0.05271878f, 0.18792059f, -0.00078385f, -0.09655741f, 
    0.03235376f, -0.37938961f, -0.19009207f, -0.09889846f, -0.14976764f, 0.08892072f, -0.01228858f, 0.04470345f, 
    -0.02152349f, -0.11547472f, -0.07206147f, 0.14820381f, 0.06662041f, -0.03624645f, 0.00562480f, -0.00124734f, 
    0.09468113f, 0.18985146f, -0.02816659f, -0.08109929f, 0.06395168f, 0.00551410f, 0.04596900f, 0.07228451f, 
    0.11429503f, -0.18040730f, -0.02140111f, -0.07602695f, 0.03591231f, 0.48090872f, -0.04741710f, 0.15983710f, 
    -0.14199007f, -0.29681680f, -0.12381517f, 0.11129677f, 0.06064454f, 0.05617248f, -0.11128847f, 0.22879212f, 
    0.03627492f, -0.06197551f, -0.04561667f, 0.20834310f, -0.10857401f, -0.05177768f, -0.01741304f, 0.05577786f, 
    0.24140401f, 0.14901054f, -0.02693077f, -0.08094499f, 0.01504537f, 0.35118294f, -0.14565501f, -0.12839091f, 
    -0.14596619f, 0.13991754f, -0.08388034f, -0.02438414f, -0.01655843f, -0.02367907f, 0.15562703f, -0.09787715f, 
    -0.15334781f, -0.08504473f, 0.03306268f, -0.05394746f, -0.11912508f, -0.08882152f, -0.07863636f, 0.21769319f, 
    0.03970521f, -0.07285766f, 0.01818568f, -0.06290255f, 0.06036472f, -0.07650258f, 0.12724538f, 0.33485460f, 
    0.29954287f, -0.31965101f, -0.49420267f, -0.16020067f, -0.00788383f, 0.19743441f, 0.13788328f, 0.28602606f, 
    0.10851471f, 0.28384995f, 0.19566570f, -0.09502783f, 0.30702370f, -0.09377458f, -0.05428895f, 0.15471886f, 
    0.08577596f, -0.06038928f, 0.07543273f, -0.37300232f, -0.02504638f, 0.13183990f, 0.04911295f, 0.03573003f, 
    -0.02094936f, 0.04224030f, -0.12408539f, -0.01235547f, -0.00387847f, -0.18949367f, -0.18022902f, -0.09462906f, 
    -0.05915463f, 0.01382628f, 0.18296103f, 0.16776678f, 0.12992147f, -0.14796798f, -0.34829274f, -0.47564882f, 
    0.08314966f, -0.10521083f, -0.20360249f, 0.10164142f, -0.04435508f, -0.09638276f, -0.22089092f, -0.21913193f, 
    -0.01946278f, -0.04011301f, -0.09497023f, 0.00067941f, -0.10973059f, 0.02744846f, 0.09819992f, -0.11580323f, 
    -0.14762010f, -0.07848494f, 0.02471798f, 0.04790869f, -0.09579799f, 0.06910896f, 0.32658800f, 0.33727151f, 
    0.06578175f, 0.02535489f, -0.10370842f, -0.14727072f, 0.14491551f, 0.16877307f, 0.23655862f, 0.23211379f, 
    0.16904899f, -0.05134909f, -0.10807678f, -0.21443623f, -0.03911020f, 0.09868583f, 0.06248933f, 0.09190658f, 
    0.15292436f, 0.01755438f, 0.10034733f, 0.62492621f, -0.62861007f, 0.03021475f, -0.11806803f, -0.08150510f, 
    0.45623717f, 0.34686148f, 0.37712601f, 0.04175636f, 0.06972013f, 0.01056114f, 0.15773271f, 0.35691801f, 
    0.13967645f, 0.31762531f, 0.34254143f, 0.37512130f, -0.19843546f, -0.33481890f, -0.18776977f, -0.01305300f, 
    -0.00118962f, 0.04834710f, 0.02712682f, -0.02544090f, 0.11454615f, 0.21417117f, 0.12070365f, 0.16850974f, 
    0.14625238f, 0.23266953f, -0.04110149f, 0.32715303f, 0.09580800f, 0.40237415f, -0.00008932f, -0.09224420f, 
    0.04503297f, 0.12601623f, 0.00641709f, 0.01483199f, 0.17755304f, 0.17972212f, 0.07983623f, 0.07980684f, 
    -0.06195374f, -0.19851959f, -0.00823415f, 0.03507352f, 0.05754247f, 0.12230117f, 0.04718486f, 0.17946804f, 
    -0.14651380f, -0.15006898f, 0.01405240f, -0.07778554f, 0.09844413f, 0.01921233f, 0.08415171f, -0.06288102f, 
    -0.11316068f, -0.08875269f, -0.22274004f, 0.03628661f, -0.00484269f, -0.04908288f, -0.00896368f, -0.08049569f, 
    -0.06714719f, -0.13767356f, 0.19080724f, 0.28785113f, -0.00994046f, -0.13090467f, 0.15993257f, 0.15447907f, 
    0.17642197f, 0.23748527f, 0.14331976f, 0.77935129f, -0.18987243f, -0.66653723f, 0.01022969f, -0.25109133f, 
    -0.20238356f, 0.18779728f, 0.26723078f, -0.21864958f, 0.06387348f, -0.17707255f, -0.10264205f, -0.38692224f, 
    -0.05744248f, -0.02916604f, 0.19431952f, 0.12273676f, 0.26819143f, -0.19129364f, -0.14605722f, 0.11136832f, 
    0.05238727f, 0.12604909f, 0.04319939f, 0.10054621f, -0.01774913f, -0.01017871f, -0.13821024f, -0.20240855f, 
    -0.50364310f, 0.09283849f, 0.01384966f, 0.00716070f, 0.19331533f, 0.15932475f, 0.31769952f, 0.05459664f, 
    0.18621756f, -0.23530671f, 0.02940256f, -0.03400950f, -0.26003632f, 0.25115943f, -0.31851658f, -0.15855297f, 
    -0.05170832f, 0.02567939f, -0.03195882f, -0.02527879f, -0.03976823f, 0.00785747f, 0.01500927f, 0.01998588f, 
    -0.03816669f, -0.05869980f, -0.05129282f, -0.02337210f, -0.06150993f, -0.01850221f, -0.00786550f, -0.06253850f, 
    -0.03222627f, -0.02394042f, -0.01935714f, -0.06186790f, -0.03640403f, -0.03297266f, -0.01074373f, -0.00589181f, 
    0.04417355f, -0.01264579f, -0.03982327f, -0.02177984f, 0.04835863f, 0.00911218f, 0.04348343f, 0.02572444f, 
    0.02497189f, 0.02971975f, 0.01786885f, -0.00194482f, 0.00504500f, -0.02652358f, -0.06337744f, -0.04211425f, 
    0.05015456f, 0.01948679f, -0.00316137f, 0.04007226f, 0.04332921f, -0.05585866f, 0.00293577f, -0.01100275f, 
    -0.01046748f, -0.05182331f, 0.00949681f, -0.02114085f, 0.03834934f, 0.04078273f, 0.03156910f, 0.00897046f, 
    0.05261076f, -0.00846253f, 0.02508616f, -0.05443129f, -0.03467653f, -0.00125607f, 0.04185343f, -0.02575204f, 
    -0.05876890f, -0.00767051f, -0.05015251f, -0.05017088f, 0.03981909f, 0.02034932f, -0.04276214f, -0.05090204f, 
    -0.03139620f, -0.06078068f, -0.04496307f, 0.03347562f, 0.03322200f, 0.03879689f, -0.02009780f, -0.04007867f, 
    -0.03294671f, 0.04034671f, -0.04088784f, 0.00551574f, 0.04112149f, -0.04672153f, -0.06393882f, 0.02940747f, 
    0.02710123f, -0.03698174f, 0.00390155f, -0.05499159f, -0.00087934f, 0.04184392f, -0.02555067f, -0.04019003f, 
    -0.03323578f, -0.02842643f, -0.00056034f, -0.03710791f, -0.06442787f, 0.02244489f, 0.01389913f, -0.05172418f, 
    -0.06099441f, 0.01549129f, -0.04447064f, 0.00612984f, 0.00854327f, 0.01171513f, -0.05343122f, -0.04599971f, 
    -0.05497133f, 0.04930250f, -0.04450133f, 0.00400299f, 0.00278320f, 0.03390304f, 0.02843444f, 0.04068742f, 
    -0.06006017f, -0.05695896f, -0.02531070f, 0.01417354f, -0.02171620f, 0.02292977f, 0.01531606f, 0.00716569f, 
    0.00297599f, -0.01593569f, -0.00492572f, -0.06014793f, -0.03555835f, -0.00021818f, 0.03748278f, -0.05712548f, 
    -0.01243232f, -0.02193266f, -0.03523816f, 0.03368473f, 0.04727680f, -0.04869725f, -0.05588304f, -0.01137360f, 
    -0.02599139f, 0.02409894f, -0.05472526f, -0.00032634f, -0.01732052f, -0.02890162f, -0.01435488f, -0.03251246f, 
    -0.00079939f, -0.05480781f, 0.04574192f, -0.02237917f, -0.01488842f, -0.00406705f, 0.04632434f, -0.03215554f, 
    0.02274504f, 0.04365490f, -0.00131260f, 0.00668664f, -0.05102730f, -0.00559741f, -0.04595624f, 0.05044830f, 
    -0.02913256f, 0.02810440f, 0.03109067f, 0.03057125f, -0.03180658f, -0.04411206f, 0.03544015f, -0.01501513f, 
    0.03721499f, -0.05301732f, -0.01865292f, -0.04209853f, -0.00584736f, 0.00562122f, -0.04974482f, 0.03305892f, 
    0.04862515f, 0.04724318f, -0.03022909f, -0.04231805f, 0.00395166f, 0.03226545f, 0.00013190f, 0.00703313f, 
    -0.04742470f, -0.04212822f, 0.01238035f, -0.03118934f, -0.01467441f, -0.00658283f, -0.04136350f, -0.04198476f, 
    -0.04740160f, -0.01745030f, -0.01595817f, 0.04979427f, -0.01676826f, 0.02930453f, -0.00714506f, -0.03227217f, 
    0.00345646f, -0.03007258f, -0.00894001f, -0.02037366f, 0.02007052f, 0.01891128f, 0.04725893f, 0.00910095f, 
    0.00833821f, -0.02469655f, -0.00391508f, 0.00297279f, 0.00791583f, -0.01993390f, -0.04537209f, 0.04412667f, 
    0.03707403f, -0.02995865f, -0.03543351f, 0.03488543f, 0.00182982f, 0.04661558f, -0.00026545f, -0.01413662f, 
    0.00834339f, -0.01688685f, 0.00299592f, 0.04263075f, 0.04479875f, -0.05293356f, 0.02835364f, 0.02503585f, 
    0.01563593f, -0.01655198f, -0.04728486f, -0.06349340f, -0.04214146f, -0.05526885f, -0.00175142f, 0.01904725f, 
    0.04510387f, 0.03636484f, 0.04912692f, 0.02457373f, 0.04382786f, -0.02038290f, 0.03021356f, -0.06393601f, 
    -0.00444149f, -0.06187079f, -0.06086565f, -0.04877840f, 0.03756136f, -0.02418772f, 0.00944237f, 0.03180869f, 
    0.03847508f, 0.05192357f, 0.00212779f, -0.04634985f, 0.04277997f, -0.03415536f, -0.01562476f, -0.03147827f, 
    -0.00832519f, 0.04205619f, 0.04358922f, 0.00693328f, -0.04421776f, -0.03317478f, -0.05689254f, -0.04833707f, 
    -0.02556224f, -0.00046625f, -0.00479525f, -0.02524188f, -0.02137023f, -0.01053639f, -0.03197501f, -0.00964578f, 
    -0.18355706f, 0.38643381f, 0.14515240f, 0.09082005f, -0.03302322f, -0.31776193f, 0.06229188f, -0.05856158f, 
    -0.37025419f, -0.47942346f, 0.06176018f, -0.17805451f, 0.05907930f, -0.10794552f, -0.05763629f, 0.01191188f, 
    0.02797961f, 0.19921114f, 0.17428724f, -0.23307358f, 0.00552962f, 0.24596819f, 0.13704687f, 0.01475574f, 
    0.04030323f, -0.06005380f, 0.01696639f, 0.07596502f, 0.05140024f, 0.14760081f, 0.06676300f, 0.05847585f, 
    0.11848764f, 0.21780209f, 0.22151178f, -0.01149474f, -0.10604288f, 0.00917634f, -0.32005101f, -0.06191242f, 
    -0.02306750f, -0.33199117f, 0.01765228f, -0.17375043f, -0.01951210f, -0.21643546f, -0.09871586f, -0.08259408f, 
    0.13939267f, -0.08228315f, 0.03098882f, 0.12572943f, 0.03178415f, 0.27725753f, -0.38482440f, 0.11535897f, 
    -0.17755876f, -0.02038908f, 0.16141868f, 0.05677061f, 0.12126600f, 0.04506317f, -0.01133369f, -0.01198452f, 
    0.08245496f, -0.00503567f, 0.22562605f, -0.18723167f, 0.00770700f, 0.13390356f, -0.25490242f, -0.03735463f, 
    -0.32731429f, 0.39334619f, -0.18533804f, 0.21912900f, -0.12528035f, -0.06163847f, 0.03003458f, -0.00682929f, 
    0.15272564f, -0.21886079f, 0.14152990f, 0.20052917f, -0.22286366f, -0.22440760f, -0.15467632f, -0.22098875f, 
    0.06376736f, -0.05344145f, 0.18493664f, 0.25000641f, 0.44309512f, 0.09013078f, -0.11958248f, 0.07176286f, 
    0.03844406f, -0.17999516f, -0.00097688f, -0.05250394f, -0.11802225f, 0.14935489f, -0.07001264f, -0.01766843f, 
    -0.11305266f, 0.11788263f, 0.12361474f, 0.00403082f, -0.27620244f, -0.13662173f, -0.11961336f, -0.16317332f, 
    -0.11776891f, 0.01552492f, -0.00037971f, 0.07127886f, 0.23215915f, 0.58963919f, -0.07514265f, 0.03488243f, 
    -0.00361810f, 0.12987638f, -0.05251999f, 0.00894908f, -0.09610960f, 0.04359676f, -0.30617377f, -0.09748790f, 
    -0.02722406f, -0.00385631f, -0.13320643f, -0.04813234f, 0.12304389f, -0.05560311f, 0.26839426f, -0.02964251f, 
    0.08467302f, -0.13129522f, 0.03905218f, 0.03160760f, 0.01795834f, -0.06780528f, -0.06942420f, 0.06831517f, 
    0.18291487f, 0.32614213f, 0.20935529f, -0.01965901f, 0.03619358f, 0.13699740f, 0.07560147f, -0.00023035f, 
    0.07129541f, 0.32020324f, -0.00451427f, 0.19001105f, -0.05731725f, -0.05476454f, 0.16198339f, 0.06321262f, 
    -0.17329617f, 0.04144373f, 0.24997692f, -0.72045279f, 0.15105268f, -0.36681616f, -0.17043488f, 0.26743910f, 
    0.25135583f, 0.23502526f, -0.36527070f, 0.10854116f, 0.10756255f, 0.14425258f, -0.18443693f, 0.04441671f, 
    -0.11308838f, 0.02194498f, 0.23619002f, 0.13315551f, 0.22549872f, 0.08925198f, 0.47636330f, 0.18383428f, 
    0.02764268f, 0.12729952f, 0.05378371f, 0.07123909f, 0.03767192f, 0.13931432f, 0.34599891f, 0.02562384f, 
    0.02065543f, 0.22675590f, 0.02263704f, -0.00642032f, 0.20233168f, 0.00147002f, -0.39712065f, -0.11001058f, 
    -0.05038005f, -0.10441180f, 0.00890623f, 0.06942278f, 0.00584392f, 0.21004930f, 0.01502539f, -0.18162121f, 
    -0.51611257f, -0.08968121f, -0.07144018f, 0.01767400f, 0.02350814f, 0.06788833f, 0.15815744f, 0.00514626f, 
    -0.35571957f, -0.37884274f, -0.00047348f, 0.13390850f, -0.07474470f, -0.17490719f, -0.04630308f, -0.14437366f, 
    0.05170476f, 0.61046070f, 0.04208503f, 0.39292842f, -0.02007261f, 0.17715134f, -0.28721207f, 0.07664565f, 
    -0.20623431f, -0.26229924f, 0.11864422f, -0.18917768f, 0.29185408f, -0.07505680f, -0.07736395f, 0.16950557f, 
    -0.12933865f, -0.06063098f, 0.09429568f, -0.49636105f, 0.08895927f, -0.35978907f, -0.43163219f, 0.47003132f, 
    0.26077071f, 0.07450148f, -0.07017650f, -0.28625554f, -0.06144923f, 0.10994354f, -0.00503227f, 0.12347925f, 
    -0.00689163f, 0.22864607f, 0.04256074f, -0.12072997f, 0.15863316f, -0.70072889f, -0.45577654f, -0.05177337f, 
    -0.11446229f, -0.15394914f, -0.09587029f, 0.10794500f, -0.02282981f, 0.12935649f, -0.06678129f, 0.42924580f, 
    -0.32572791f, -0.20527752f, -0.20252997f, -0.11608199f, 0.26549971f, 0.32449356f, 0.19739409f, -0.47011003f, 
    0.34430745f, -0.30525222f, 0.05750808f, 0.19319381f, -0.29117829f, 0.25371313f, 0.30770889f, -0.28633764f, 
    -0.06144808f, -0.91342437f, -0.71373081f, 0.00777474f, 0.09248304f, 0.03610234f, 0.11902903f, 0.02410791f, 
    -0.01423116f, 0.25660712f, 0.23494676f, 0.24080320f, -0.03215450f, 0.03506961f, -0.01264462f, 0.06049287f, 
    0.03895510f, 0.19606581f, -0.39375246f, -0.08405946f, -0.17948532f, 0.00253203f, 0.06190973f, 0.07480796f, 
    0.25274220f, -0.12128468f, -0.04053374f, 0.15863036f, -0.21609658f, -0.31711215f, -0.10834403f, 0.07589041f, 
    -0.09199691f, 0.10071519f, -0.34802270f, 0.25217938f, 0.35020509f, -0.05124414f, -0.02238137f, 0.06566764f, 
    -0.14826384f, 0.11283821f, 0.10254055f, 0.15939155f, 0.21646507f, 0.07046834f, 0.36814883f, 0.02565755f, 
    -0.09187670f, 0.07773910f, 0.04223032f, -0.07001150f, 0.05414008f, 0.17618442f, -0.49518344f, -0.22487119f, 
    -0.37523812f, 0.08470190f, 0.10614303f, 0.03193180f, 0.10859278f, -0.06046129f, 0.02511968f, -0.00760669f, 
    -0.02346957f, -0.08788921f, -0.01971946f, -0.09228684f, -0.13981858f, -0.12735289f, 0.01212762f, -0.01756187f, 
    0.37575737f, 0.04736879f, -0.04435331f, 0.00880263f, 0.06961384f, 0.00958506f, 0.13129137f, 0.00599708f, 
    0.11101731f, 0.20098476f, -0.29058501f, 0.20040271f, -0.17980157f, -0.19930853f, -0.07347630f, 0.01835469f, 
    0.03662904f, 0.06399070f, 0.15995696f, -0.42487127f, 0.17347835f, -0.09174696f, 0.06920304f, -0.12486549f, 
    0.06305778f, -0.09150594f, 0.19693168f, 0.07193498f, 0.21936159f, 0.30447760f, -0.04241029f, -0.04120510f, 
    0.04424084f, -0.04391677f, -0.02469420f, 0.06407098f, 0.52216893f, 0.06751837f, 0.20636898f, 0.15268561f, 
    -0.15428749f, -0.17008375f, 0.00390632f, 0.06085869f, -0.14471836f, 0.26961571f, -0.26325533f, -0.30299231f, 
    0.11067506f, -0.05657265f, -0.06860371f, 0.13160563f, -0.17171140f, 0.06525608f, 0.37911960f, 0.27405289f, 
    0.07487388f, -0.02483396f, 0.07227307f, -0.04093545f, -0.11207339f, -0.08321995f, 0.09033444f, -0.30617908f, 
    -0.14658247f, -0.11468811f, -0.17348035f, -0.02964487f, -0.11054320f, 0.05797944f, 0.04921038f, -0.13719228f, 
    0.21437651f, -0.48156068f, 0.16511561f, 0.00248733f, 0.08797032f, 0.09749562f, 0.01622398f, -0.04487993f, 
    -0.01260764f, 0.14667127f, -0.39661613f, 0.07863330f, -0.13095674f, -0.12519953f, 0.13405244f, -0.05385314f, 
    0.00841894f, -0.13765113f, -0.21540686f, -0.76923203f, -0.58762622f, 0.12743114f, -0.12634730f, -0.05851737f, 
    -0.06117069f, 0.10962668f, -0.09921416f, -0.18680102f, 0.06680503f, -0.12401258f, 0.05140088f, 0.11330955f, 
    0.13515821f, 0.18103863f, 0.04531644f, 0.29651612f, 0.02225819f, -0.18326442f, -0.09792079f, 0.07466188f, 
    -0.06420311f, 0.17509098f, 0.04052478f, -0.09862343f, -0.09736669f, 0.15958150f, 0.02971853f, -0.09479725f, 
    -0.06562700f, -0.12257089f, 0.20046294f, -0.05622798f, -0.05954330f, 0.03231841f, 0.40204331f, 0.07919239f, 
    0.13964619f, -0.08217709f, -0.09834585f, 0.12738153f, 0.17953381f, 0.17739427f, 0.03182909f, -0.06449872f, 
    -0.44915864f, 0.24806869f, 0.17420986f, -0.15096746f, -0.07480364f, -0.28394160f, 0.03761977f, -0.03663397f, 
    -0.04677977f, 0.03218304f, 0.13024174f, -0.17699325f, 0.00061354f, -0.13768297f, -0.09914988f, -0.08807904f, 
    0.09735220f, 0.37300643f, 0.13335626f, -0.06349577f, 0.01587581f, -0.03901865f, 0.20851718f, 0.12791155f, 
    0.08091093f, 0.00110538f, 0.01661450f, -0.21385106f, 0.05418837f, -0.06347984f, 0.12077221f, 0.12690951f, 
    0.07419488f, 0.08640534f, -0.07252625f, 0.67878580f, -0.52480376f, -0.95247656f, -0.07560500f, -0.38987377f, 
    0.52400899f, -0.07826869f, 0.01291208f, -0.30448890f, 0.22809438f, -0.18431880f, -0.15257473f, -0.12289179f, 
    -0.24320747f, 0.08538973f, -0.04413461f, 0.09296704f, -0.19761357f, 0.21582961f, 0.21686338f, 0.34710988f, 
    0.03632111f, -0.07697814f, -0.06772148f, -0.00908893f, -0.00976255f, -0.03218938f, 0.40946463f, 0.06000276f, 
    -0.21413837f, 0.06087533f, -0.29840663f, -0.17061824f, 0.04038544f, -0.21582904f, -0.07278398f, -0.49899352f, 
    -0.38207006f, -0.49767715f, 0.20994975f, 0.22994284f, 0.07375060f, 0.29992208f, -0.03796769f, 0.23982200f, 
    -0.36888635f, 0.03062257f, -0.05569342f, -0.03202851f, -0.05399565f, 0.24317575f, 0.17509606f, 0.08546674f, 
    -0.10115055f, -0.14689530f, -0.26509413f, -0.02435051f, 0.09591857f, 0.15594549f, -0.09578011f, 0.03700776f, 
    0.29145923f, -0.06538136f, -0.28326741f, -0.03473945f, -0.25215498f, -0.29515058f, -0.37187245f, -0.24598245f, 
    0.01806421f, 0.23688351f, 0.31340280f, 0.01706491f, -0.47273624f, -0.09761496f, -0.06544220f, 0.03313541f, 
    0.07611455f, 0.11379160f, -0.10706937f, -0.17121392f, -0.39114612f, 0.02073913f, 0.10913167f, -0.09156898f, 
    0.05527016f, 0.17405993f, 0.13351157f, 0.10792203f, -0.09489966f, -0.18622538f, -0.42302695f, -0.23005830f, 
    -0.04118488f, 0.07281775f, 0.09440315f, 0.12754881f, 0.25685841f, 0.14192557f, -0.34522963f, -0.34908089f, 
    -0.29549116f, -0.42922077f, -0.05579317f, -0.02634052f, 0.13129336f, 0.05478304f, 0.31482783f, 0.17620665f, 
    -0.13815828f, -0.66476053f, -0.11475277f, -0.05642449f, -0.13553810f, 0.50373822f, 0.06072826f, 0.11373807f, 
    -0.62445629f, -0.46892601f, 0.00109526f, 0.00673005f, 0.12783164f, -0.05799233f, 0.00045133f, 0.15265974f, 
    0.03649129f, 0.18717685f, -0.00697660f, -0.04838054f, 0.11611652f, 0.08666033f, -0.30495700f, -0.07913508f, 
    -0.16196640f, 0.20376301f, 0.08136225f, -0.04838762f, 0.04897147f, 0.24712980f, 0.04689326f, 0.16969764f, 
    0.20393606f, 0.27614859f, 0.06452771f, -1.09543324f, -0.34416136f, -0.40916869f, 0.01062733f, -0.14037746f, 
    0.06521168f, -0.06825627f, -0.00424054f, -0.22574563f, -0.05006090f, -0.69665480f, -0.31197652f, -0.14121348f, 
    0.10336602f, -0.17536287f, -0.10216152f, -0.04405209f, 0.07441948f, -0.21176961f, -0.06230135f, 0.39338279f, 
    -0.39266464f, 0.16358240f, -0.01535760f, 0.29929549f, 0.12534787f, 0.17593695f, -0.04201089f, -0.74882019f, 
    -0.00182596f, 0.09102293f, 0.10266445f, -0.39567715f, -0.02761376f, -0.03622775f, 0.32065675f, -0.29157916f, 
    -0.21036801f, -0.20195347f, -0.09343376f, -0.42456079f, 0.02330887f, 0.35869288f, 0.03835694f, 0.33479553f, 
    0.07731567f, 0.21668138f, 0.17046975f, -0.05053625f, 0.22315688f, -0.05237236f, -0.02157633f, -0.02554424f, 
    -0.04497525f, 0.05098135f, 0.39531434f, 0.36975083f, -0.06904112f, -0.05759227f, 0.01465322f, 0.10660383f, 
    -0.02314625f, 0.15880591f, 0.72174472f, -0.86769664f, -0.87487292f, -0.23863858f, 0.02216760f, -0.03032599f, 
    0.06830315f, 0.05966831f, -0.05042264f, -0.02556987f, -0.01692180f, 0.04711659f, -0.02609952f, 0.05773803f, 
    0.09450903f, 0.03080380f, 0.13436095f, 0.15748298f, -0.10794244f, 0.32705703f, 0.20204556f, -0.16146486f, 
    0.08685991f, 0.06141103f, 0.02565218f, -0.08401176f, 0.15337540f, 0.23506673f, 0.13260932f, 0.22565652f, 
    -0.01933893f, 0.10231039f, 0.19526199f, 0.09064720f, 0.12649944f, 0.25221580f, -0.06215868f, -0.45615831f, 
    0.02452360f, -0.08881185f, 0.15734459f, -0.10407306f, -0.02138745f, 0.06593734f, -0.05869136f, 0.48929876f, 
    -0.54893678f, -1.60536754f, -0.10495781f, -0.03990247f, 0.18089229f, -0.13466986f, 0.20175035f, 0.01719822f, 
    -0.69661260f, 0.01120797f, 0.06723360f, -0.05690048f, -0.28698006f, -0.19833918f, -0.02127026f, -0.02594543f, 
    -0.31475809f, 0.06535797f, 0.12605809f, 0.24832366f, -0.00068477f, -0.13706890f, 0.26337120f, 0.35823888f, 
    -0.03110044f, 0.19754958f, -0.02521610f, 0.16928011f, 0.08529364f, -0.00661275f, -0.02186100f, 0.14412785f, 
    0.20752627f, -0.05983679f, 0.02362102f, 0.64332348f, -1.18088067f, -0.78505802f, -0.25054678f, 0.04599236f, 
    0.35578731f, 0.12871699f, 0.10600000f, -0.16368727f, -0.04574277f, 0.20535553f, 0.23396328f, -0.03807967f, 
    0.03864721f, -0.21755990f, 0.07099190f, 0.07769623f, 0.10055863f, 0.73522860f, -1.07551455f, -0.88050455f, 
    -0.11772619f, 0.00423081f, -0.28879803f, -0.10491665f, -0.01974904f, 0.12098827f, -0.13936670f, -0.34219337f, 
    0.25700277f, -0.15589356f, -0.20065990f, -0.03873058f, 0.15451989f, -0.02419526f, 0.08398645f, -0.80344921f, 
    -0.18415084f, -0.04455263f, -0.25983867f, -0.04139442f, 0.31345209f, 0.22152668f, 0.25257406f, 0.00626411f, 
    -0.02940313f, 0.39167318f, -0.08898804f, 0.32808876f, 0.10599952f, -0.08398685f, -0.00975120f, 0.10486614f, 
    -0.22474587f, -0.39338115f, 0.00423299f, -0.17952055f, -0.00474970f, 0.06199871f, -0.09600005f, 0.03475286f, 
    0.12842196f, -0.10893234f, -0.52229726f, 0.13693170f, -0.09567078f, 0.11520974f, -0.10086036f, -0.04742079f, 
    0.17126201f, -0.10776892f, 0.08261430f, -0.30199343f, 0.72714925f, 0.22846980f, 0.08169164f, -0.26364878f, 
    -0.09294195f, 0.07000241f, 0.05674070f, -0.01835063f, -0.19480430f, -0.36491969f, 0.18161900f, 0.21279384f, 
    0.23583859f, 0.01595892f, 0.06517511f, 0.05840883f, 0.09945397f, -0.45525950f, 0.10700093f, -0.08979546f, 
    0.02928039f, 0.01276708f, -0.01898060f, 0.07808489f, -0.04970752f, -0.02634456f, -0.33051449f, 0.00348429f, 
    -0.07141411f, -0.04934683f, 0.03873328f, -0.12960537f, 0.09811530f, 0.07671959f, 0.07899357f, -0.16811399f, 
    0.06183683f, -0.04696114f, 0.02166187f, -0.06069184f, -0.11068039f, 0.02922065f, 0.02130190f, 0.32567883f, 
    0.33330551f, -0.23947433f, -0.24375804f, 0.24167222f, 0.06886771f, -0.22245428f, -0.01173722f, 0.26156369f, 
    0.09896044f, -0.01650083f, 0.34980378f, 0.37938330f, 0.21392427f, 0.05105658f, -0.01929675f, 0.11213402f, 
    0.13726349f, -0.10186597f, 0.07370146f, 0.11614811f, -0.08664165f, -0.00157418f, -0.33811921f, 0.08187910f, 
    -0.00505164f, -0.06572329f, -0.16738766f, -0.42053029f, -0.37577727f, 0.32101020f, -0.13376276f, 0.08242578f, 
    -0.10095572f, 0.15624222f, -0.01475481f, -0.12902318f, 0.01355421f, 0.19112383f, -0.21387170f, 0.04178697f, 
    -0.02188259f, 0.00391478f, -0.09769567f, 0.10467505f, 0.03401955f, -0.47829929f, 0.15549828f, 0.51851857f, 
    0.06411640f, -0.08846714f, -0.15746349f, 0.31277409f, 0.06517997f, -0.00060428f, -0.37255082f, 0.15717790f, 
    -0.21583019f, -0.15382658f, 0.10372104f, -0.04053009f, 0.11735325f, -0.05945570f, -0.21040846f, -0.10116142f, 
    0.01024396f, -0.36272135f, 0.12655419f, 0.06670631f, -0.21270075f, -0.03320911f, 0.14879543f, 0.31294185f, 
    -0.12435465f, 0.02997691f, 0.59532410f, 0.21455245f, 0.17750774f, 0.13448104f, 0.01327926f, 0.12254191f, 
    0.04932905f, -0.17957194f, -0.26293629f, 0.55990535f, -0.11863451f, -0.12801135f, 0.09357987f, 0.24441676f, 
    0.12283220f, -0.05877648f, 0.28120390f, -1.15779364f, 0.32456413f, 0.00300857f, -0.29513621f, 0.46001634f, 
    -0.37774116f, -0.10659383f, 0.13134608f, 0.04409515f, 0.09405413f, 0.15146083f, 0.04022630f, 0.07428580f, 
    0.17129424f, 0.16596630f, 0.09459487f, 0.16168962f, -0.38144597f, 0.21604626f, 0.33237448f, -0.18195347f, 
    -0.03956906f, 0.00207127f, 0.25141111f, 0.19109845f, -0.10473787f, -0.22066237f, 0.00326950f, 0.27877516f, 
    -0.09417713f, 0.20479308f, 0.00292941f, 0.17344256f, 0.10615111f, 0.34639409f, -0.20897774f, -0.26734644f, 
    0.10477945f, -0.07117612f, 0.08970315f, 0.15118277f, 0.10370760f, 0.15986700f, -0.02577904f, -0.04189366f, 
    -0.09207738f, -0.22251993f, -0.00865828f, 0.06722211f, -0.15546185f, -0.02461006f, 0.00888023f, 0.16125439f, 
    -0.61491853f, -0.13423447f, -0.23961431f, -0.22766960f, -0.12754858f, -0.07183354f, -0.05692371f, -0.09343353f, 
    -0.09217915f, -0.37522957f, -0.29139900f, 0.33964211f, 0.13073479f, 0.04890696f, -0.02108154f, 0.20797415f, 
    0.02366778f, 0.00089813f, 0.02005073f, 0.15606587f, 0.37640667f, 0.12523060f, -0.05999043f, 0.18527153f, 
    0.00375286f, 0.12455548f, 0.08633975f, -0.89897233f, -0.54021436f, 0.36538288f, -0.28073958f, -0.02487008f, 
    0.11859158f, -0.04997030f, 0.00459530f, -0.09690442f, -0.13536908f, 0.00588854f, -0.05336777f, 0.06016731f, 
    0.10487353f, 0.07840756f, -0.02296352f, 0.12404164f, 0.01975325f, -0.17569561f, 0.11395928f, 0.04292257f, 
    0.14424962f, 0.08110284f, -0.01512080f, -0.12266306f, 0.08271824f, 0.06040668f, 0.20054951f, -0.02343627f, 
    0.10788492f, 0.34264848f, 0.10033926f, -0.07769610f, -0.08164802f, 0.24199383f, -0.11108404f, -0.74565059f, 
    -0.18066679f, -0.32489127f, -0.39026079f, 0.08435590f, -0.24307752f, -0.16847205f, -0.20087220f, 0.15578677f, 
    0.01430054f, -0.01316229f, 0.01461438f, -0.04384447f, -0.05849050f, 0.21571809f, 0.19328824f, 0.19315936f, 
    -0.20727894f, 0.10396782f, -0.09230655f, 0.07173825f, 0.11594521f, 0.07111745f, 0.05885882f, 0.16462818f, 
    0.09203425f, -0.01699374f, 0.12205140f, 0.05328174f, 0.30962542f, -0.04947218f, -0.07866380f, -0.17153154f, 
    -0.01117807f, -0.05937983f, -0.07423772f, 0.40176895f, -0.76188976f, 0.14248265f, 0.06362203f, -0.27745438f, 
    -0.43864456f, 0.00458074f, -0.05576934f, -0.03707471f, -0.10908251f, 0.05382549f, -0.00449157f, -0.05897983f, 
    -0.16174360f, -0.11247159f, 0.13169418f, -0.07710303f, 0.04838923f, 0.00411674f, 0.16284253f, 0.27562839f, 
    0.01518199f, 0.00827905f, -0.09927656f, -0.00212684f, -0.08901090f, 0.00404859f, 0.24574815f, 0.18527734f, 
    0.16188304f, -0.07275565f, -0.14918211f, -0.06403456f, 0.05252916f, 0.03532388f, 0.00116849f, 0.07112648f, 
    0.13821551f, 0.20256983f, 0.06555880f, -0.16697246f, 0.00817614f, 0.10295217f, 0.16814418f, 0.06022073f, 
    -0.12344465f, 0.03380774f, 0.09456334f, -0.07220232f, 0.09392002f, 0.16307461f, 0.13637455f, 0.22615875f, 
    -0.12005208f, -0.02355033f, 0.04783180f, 0.24307746f, 0.07813118f, 0.11673095f, 0.01658243f, -0.10904957f, 
    -0.10253511f, 0.02409115f, 0.07563062f, -0.53761166f, -0.11472090f, 0.05225950f, -0.09777407f, -0.03869746f, 
    -0.10365846f, -0.05425801f, 0.02365978f, -0.15865661f, -0.34972829f, -0.00421317f, 0.13589299f, -0.00708229f, 
    0.09592660f, -0.06430833f, -0.18503208f, -0.20980535f, -0.33360973f, -0.02303839f, 0.02035867f, 0.15213953f, 
    0.04812938f, 0.04799085f, -0.00014305f, 0.13459714f, 0.07358249f, 0.37925148f, 0.45208079f, 0.08125658f, 
    -0.04097274f, -0.00157919f, -0.05321432f, 0.10361223f, 0.00291731f, 0.10849597f, -0.01037209f, 0.13549349f, 
    0.21040206f, 0.15551770f, 0.06339575f, 0.01566483f, 0.04325586f, 0.02657591f, -0.08597437f, 0.23949493f, 
    0.06071685f, 0.14635098f, -0.11048224f, 0.05749746f, -0.02214758f, 0.22764583f, 0.12700367f, 0.09980243f, 
    0.09379592f, 0.11823296f, 0.21438102f, -0.16172788f, 0.06146257f, 0.04813021f, 0.00316556f, 0.15352005f, 
    -0.08322482f, 0.24259268f, 0.31986508f, 0.03637398f, -0.02342464f, 0.04274459f, 0.00651839f, 0.12783991f, 
    0.16391139f, 0.11734390f, 0.25511304f, -0.48933670f, -0.51577199f, 0.02840790f, -0.32436231f, 0.01365970f, 
    0.28112966f, -0.09699722f, -0.28190669f, 0.16857268f, -0.17590670f, 0.18541603f, -0.24643658f, 0.15911414f, 
    -0.15354413f, 0.11839090f, -0.22649446f, 0.02576207f, 0.13931623f, 0.30296215f, 0.19509891f, -0.08525392f, 
    0.00453955f, 0.11536984f, 0.07376922f, 0.12591521f, 0.03552352f, 0.27710083f, -0.03936741f, -0.37214372f, 
    -0.24493015f, 0.03764686f, 0.05381546f, -0.09117033f, -0.03881951f, 0.11177783f, -0.11278067f, -0.25382504f, 
    0.02837050f, 0.05629494f, -0.12026607f, 0.05424743f, 0.00642230f, -0.20897301f, 0.02806874f, -0.61365575f, 
    -0.14802004f, -0.55584276f, 0.13868538f, -0.17746827f, 0.10968845f, -0.27677789f, -0.13726611f, -0.14440168f, 
    -0.18493062f, -0.07096722f, 0.14974937f, -0.00838852f, 0.00581900f, 0.13088106f, -0.02083182f, 0.11190387f, 
    -0.16040304f, 0.42698559f, 0.30217886f, -0.41893497f, 0.03395436f, 0.07368148f, -0.12285002f, -0.00487540f, 
    -0.04885326f, -0.12649408f, 0.16420753f, 0.02886676f, -0.08361439f, -0.06584020f, 0.09077280f, 0.18681607f, 
    -0.01857052f, 0.19971344f, -0.08268847f, 0.80972892f, -0.68361205f, -0.71138489f, -0.24369207f, -0.26709574f, 
    0.33547795f, -0.14396060f, 0.24008645f, -0.23663217f, 0.06938193f, 0.13569675f, -0.04948002f, 0.25607404f, 
    0.17344341f, 0.10064219f, 0.10752858f, 0.10827985f, 0.11463331f, -0.00514854f, -0.09268355f, -0.22729142f, 
    0.12800997f, 0.02641456f, 0.10911048f, -0.14508669f, 0.08554665f, 0.06598905f, -0.22308461f, -0.06223937f, 
    0.53510821f, 0.08003891f, -0.14162177f, -0.01489045f, -0.04219741f, -0.05007284f, 0.28686249f, 0.11446422f, 
    0.02481306f, 0.01230750f, -0.40893647f, -0.16983590f, -0.04794596f, 0.05986783f, -0.18478259f, -0.08477349f, 
    0.03100234f, -0.01540932f, -0.05017260f, -0.05838478f, -0.05255139f, 0.05447013f, -0.03298761f, -0.00408310f, 
    -0.04513834f, 0.04404804f, 0.03421398f, 0.02630248f, 0.02874706f, 0.04965068f, 0.01043936f, -0.01006119f, 
    -0.05453572f, 0.03136279f, -0.05491840f, 0.04791421f, 0.01829376f, -0.04710535f, 0.04237539f, 0.04144504f, 
    -0.00202240f, -0.01383694f, -0.02203234f, 0.00054662f, 0.05124751f, -0.03682495f, -0.02716387f, 0.01065497f, 
    -0.03559391f, -0.02923946f, -0.02175207f, 0.00736362f, 0.02422012f, -0.00553541f, 0.03509374f, -0.01229916f, 
    0.04221760f, 0.03023949f, -0.05574966f, -0.06167691f, -0.04704652f, -0.02545371f, -0.01379073f, -0.04510052f, 
    -0.06112148f, -0.03018263f, -0.04518649f, 0.02293977f, 0.02972445f, -0.02741797f, -0.00278419f, -0.00567193f, 
    0.04828368f, -0.06301374f, -0.03906330f, 0.01995495f, -0.00247442f, -0.02608861f, 0.02984651f, -0.02323852f, 
    -0.03592696f, 0.00709554f, 0.00121908f, 0.02218405f, -0.01103612f, -0.04341920f, -0.03377271f, -0.02355510f, 
    -0.02324004f, 0.00164513f, -0.06274138f, -0.05640889f, -0.00237511f, 0.00582950f, -0.01728578f, -0.02954428f, 
    -0.02991687f, 0.05092794f, -0.02595387f, -0.02925270f, -0.01692074f, 0.04309596f, -0.05364554f, 0.04364455f, 
    -0.01445483f, -0.01706879f, -0.04133092f, 0.04460157f, -0.06467275f, -0.02255049f, -0.02927540f, -0.00402240f, 
    -0.05711876f, 0.01352774f, -0.03266773f, -0.06611987f, 0.03917380f, 0.01791586f, -0.05886940f, -0.05528679f, 
    -0.06294179f, 0.04104513f, -0.03568279f, 0.01339034f, 0.02989240f, -0.03127786f, 0.00377976f, -0.04127844f, 
    0.01806495f, 0.04853149f, 0.04499766f, 0.00432650f, -0.05639696f, -0.02512680f, 0.04941306f, -0.05214347f, 
    -0.04793446f, -0.00349568f, -0.03500021f, 0.04309304f, 0.01822852f, -0.03990621f, 0.03926519f, 0.03312960f, 
    -0.02130371f, -0.02567155f, -0.02022829f, -0.01368802f, -0.02520792f, 0.05268081f, 0.05169554f, -0.01925939f, 
    0.04465122f, 0.01661658f, -0.03613710f, 0.04166758f, -0.02718857f, 0.00939739f, 0.04187313f, -0.05848294f, 
    -0.00829241f, 0.01116088f, 0.04544811f, 0.05186261f, 0.04506315f, -0.02971580f, -0.02051590f, -0.03232399f, 
    0.01363213f, -0.03468702f, -0.01241350f, -0.05815335f, 0.03313081f, 0.00128785f, -0.04783285f, -0.05287530f, 
    0.00075950f, 0.04841581f, 0.00789182f, 0.03820048f, -0.00150832f, 0.00959995f, 0.01653246f, 0.03092437f, 
    0.03930570f, 0.05099889f, 0.00584533f, 0.00229465f, -0.05232676f, -0.00743932f, 0.03828649f, 0.04882253f, 
    0.03818626f, -0.02882528f, -0.06541112f, 0.01792891f, 0.00862255f, 0.01097075f, -0.04867677f, -0.05903882f, 
    0.04977260f, 0.04713262f, 0.04482309f, -0.00369946f, -0.02742469f, 0.04624750f, -0.06067313f, -0.03198672f, 
    0.02602549f, -0.05486925f, 0.00343413f, -0.02434011f, -0.06696106f, -0.04455560f, -0.06089392f, -0.02780143f, 
    0.03031550f, 0.03629195f, -0.05900729f, -0.04658397f, -0.05355616f, 0.02183320f, -0.02519743f, -0.01669257f, 
    0.02946248f, -0.01351850f, -0.00131496f, 0.01000786f, -0.01836709f, -0.01694061f, -0.00381212f, -0.03768205f, 
    -0.00995130f, -0.01884732f, -0.03958772f, 0.00534799f, -0.02389574f, 0.02948596f, 0.03715847f, -0.06119753f, 
    0.03639395f, -0.03262915f, -0.04778251f, 0.02631745f, -0.01254215f, -0.06414352f, 0.05278182f, 0.04042598f, 
    0.03691567f, -0.02516026f, -0.05220405f, -0.01074596f, -0.01364454f, -0.04819348f, 0.01901544f, -0.00274600f, 
    0.00885923f, -0.05816845f, 0.04847357f, 0.05477110f, 0.01834626f, -0.00302779f, 0.02498705f, 0.01534229f, 
    -0.02336348f, 0.02354625f, 0.04094277f, 0.00923330f, -0.05281025f, 0.01686935f, -0.05689626f, -0.01761397f, 
    -0.01718017f, 0.01508381f, -0.06409398f, -0.00079459f, -0.02129121f, -0.05082929f, -0.00217089f, 0.01016173f, 
    -0.04524266f, 0.00489213f, 0.02190878f, 0.00651741f, -0.04531233f, -0.00919627f, 0.01075385f, 0.04319648f, 
    0.04725986f, 0.01446295f, 0.04782108f, -0.04307920f, -0.05009035f, -0.01181389f, -0.05147017f, -0.00731164f, 
    0.03026202f, 0.02312881f, -0.04090064f, 0.03239023f, 0.02183519f, 0.00935018f, -0.00415060f, -0.01952444f, 
    -0.82592809f, 0.15079471f, 0.45198891f, 0.01479069f, 0.04444283f, 0.28256133f, -0.12163527f, 0.27417240f, 
    0.07440070f, 0.00643939f, 0.17164630f, -0.02890057f, 0.12998614f, -0.06732140f, -0.08497020f, -0.05903338f, 
    -0.01691357f, 0.06439236f, 0.03227234f, 0.12916386f, -0.02811436f, -0.24119666f, -0.26120454f, 0.24130353f, 
    -0.07787628f, 0.08485740f, 0.10844006f, -0.08829566f, 0.35644278f, 0.28867966f, 0.02328404f, 0.26113713f, 
    -0.26584935f, -0.02897916f, 0.13850349f, 0.11245725f, 0.35124451f, 0.08810885f, 0.32535303f, 0.03572614f, 
    -0.18979526f, 0.06164879f, 0.17416926f, -0.01523661f, 0.08172733f, 0.02811274f, 0.03168546f, -0.14399217f, 
    0.00746508f, 0.05496717f, -0.01200119f, 0.03664704f, 0.07072312f, -0.00695663f, 0.04259349f, 0.02352046f, 
    -0.18894333f, 0.00597762f, 0.07351729f, 0.01726749f, 0.14437750f, 0.03654203f, 0.05282960f, -0.11638154f, 
    -0.00920689f, -0.17176865f, -0.41775867f, -0.42180386f, 0.09771906f, 0.14064358f, 0.22820221f, -0.02999917f, 
    -0.17017598f, 0.04371524f, -0.02242042f, 0.15277943f, 0.09135978f, -0.06787566f, 0.09155387f, 0.14353050f, 
    -0.10530595f, -0.32123488f, 0.24665071f, 0.33894116f, 0.10878970f, 0.03158489f, -0.08320951f, 0.03637884f, 
    -0.05043854f, -0.10038052f, 0.04965237f, 0.14665948f, -0.02361833f, 0.00721595f, 0.13407229f, -0.20671818f, 
    0.18058510f, -0.00552249f, -0.05629006f, 0.08155359f, 0.14219247f, -0.06928445f, 0.09307448f, -0.15833801f, 
    0.01799127f, 0.10387276f, -0.20015973f, -0.08626232f, -0.38605860f, -0.14399074f, -0.20548062f, -0.02971949f, 
    0.06803260f, -0.12280136f, -0.01155365f, 0.05137439f, 0.25951004f, -0.65817475f, -0.06638188f, 0.12060432f, 
    -0.11263433f, -0.03813892f, -0.04897894f, 0.11291018f, -0.12410721f, 0.01044165f, -0.07633562f, 0.02445232f, 
    -0.08925551f, -0.00463143f, -0.04905537f, -0.13229200f, 0.08561126f, -0.15037914f, -0.03798470f, -0.04714042f, 
    0.10340353f, -0.07118424f, -0.35531053f, -0.23402418f, -0.11746325f, 0.14508867f, 0.09239373f, 0.04552757f, 
    0.05706967f, -0.24923798f, 0.07104282f, 0.06507932f, -0.06881981f, -0.06246083f, 0.05877781f, -0.02544414f, 
    0.08517475f, -0.17924637f, -0.47667274f, 0.04539957f, -0.05706953f, 0.05561185f, -0.11161845f, -0.00170186f, 
    -0.00300838f, -0.12996432f, -0.31499207f, 0.32980594f, -0.45399392f, -0.23877573f, 0.35109088f, -0.01974086f, 
    0.00013964f, -0.03146442f, 0.00909216f, -0.14433680f, 0.26595232f, 0.05776880f, 0.34766832f, 0.18303573f, 
    -0.15684426f, -0.16618328f, 0.11692479f, 0.22492550f, -0.29068953f, -0.40932289f, -0.24821022f, -0.00269221f, 
    -0.00452729f, -0.00588261f, -0.10663787f, -0.12671246f, 0.01933496f, 0.30474743f, -0.04623585f, 0.05352979f, 
    0.09374441f, 0.05169588f, 0.06728896f, 0.02073579f, 0.03548009f, 0.13544530f, 0.02017211f, 0.05955059f, 
    0.18447763f, 0.08226273f, -0.11001068f, -0.08771499f, 0.03143898f, -0.03856556f, 0.07783148f, -0.11783320f, 
    0.07458001f, -0.23091370f, -0.02452832f, 0.25671330f, -0.01656187f, 0.05944327f, -0.08064526f, -0.25662869f, 
    0.15849647f, 0.13725655f, 0.04051948f, 0.07974827f, -0.10428833f, 0.11695124f, -0.05321164f, 0.01210888f, 
    -0.04561916f, -0.63757002f, -0.17464325f, -0.46990526f, -0.25422722f, -0.10827588f, -0.04024857f, 0.17618191f, 
    -0.06204898f, -0.16839194f, 0.12661259f, 0.11474651f, 0.10568577f, 0.07741836f, -0.09338158f, -0.15380315f, 
    -0.04462390f, 0.13410981f, -0.03592060f, 0.57917243f, -0.57845038f, -0.31742644f, -0.12019984f, -0.28098059f, 
    0.09238093f, 0.11269927f, -0.10019357f, -0.05283844f, 0.00878796f, -0.24270751f, -0.00581290f, -0.16368337f, 
    -0.29651040f, -0.03138136f, 0.19469592f, 0.01490381f, 0.21286814f, -0.20533845f, 0.02878053f, -0.06253376f, 
    0.08282933f, 0.13947862f, -0.07599835f, -0.06518779f, 0.09541335f, 0.21363187f, -0.01376084f, -0.17439012f, 
    0.11538481f, -0.02576639f, 0.19494948f, -0.05532777f, -0.18325813f, -0.00747820f, 0.13500406f, 0.23525165f, 
    -0.22204910f, -0.08509176f, -0.06454665f, -0.15064093f, -0.00722994f, 0.12930237f, 0.07688784f, 0.11634422f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04480170f, 0.12805483f, 0.18502873f, 0.29109809f, -0.03408222f, -0.00162486f, 0.33584365f, 0.03176324f, 
    0.02461394f, -0.25673622f, 0.21435194f, -0.06484991f, -0.07197502f, -0.03371718f, 0.21486910f, -0.11024228f, 
    0.07505303f, -0.04556718f, -0.05594128f, 0.19751237f, -0.00362489f, -0.07961567f, 0.02135722f, 0.36255753f, 
    -0.03762063f, 0.04566013f, 0.22107510f, 0.19673780f, 0.28959042f, 0.00191086f, -0.01822917f, 0.09980723f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00896781f, -0.24328028f, -0.04171121f, -0.36228389f, 0.38488311f, -0.14881192f, -0.10127065f, -0.09509811f, 
    -0.09510923f, 0.36731362f, -0.16087726f, -0.01370599f, -0.21549408f, 0.40765589f, -0.17284726f, 0.19792899f, 
    -0.12997083f, -0.08407548f, -0.01792957f, 0.02238237f, 0.13663062f, -0.39237171f, 0.25497672f, -0.27954134f, 
    -0.07204015f, 0.36824480f, -0.17798796f, 0.26083168f, -0.92794710f, 0.55986965f, -0.16675822f, -0.13522208f, 
    -0.09979274f, -0.10871345f, 0.19495019f, -0.13984439f, -0.06125142f, -0.15109646f, 0.24325654f, 0.05008776f, 
    -0.25246701f, 0.20909871f, 0.38807186f, -0.15961012f, -0.24985395f, 0.16743463f, 0.18101157f, 0.13225913f, 
    -0.41427681f, -0.07472736f, -0.04350062f, -0.74912012f, -0.16336325f, -0.31853020f, 0.07729272f, 0.14297608f, 
    -0.06333738f, 0.42214677f, 0.05619897f, 0.40438592f, 0.03745907f, -0.09323180f, -0.12532678f, -0.42467278f, 
    -0.28144446f, 0.05003859f, -0.09338254f, -0.49715063f, 0.25456595f, 0.06117606f, -0.02560397f, -0.06995764f, 
    0.32912755f, -0.29578105f, 0.07607984f, 0.11062203f, 0.15792185f, -0.07522418f, -0.23100290f, -0.45226893f, 
    0.31065094f, -0.03207283f, -0.15495011f, -0.54952806f, -0.02290452f, -0.91542184f, 0.13724403f, 0.42284182f, 
    0.11174306f, -0.08103364f, -0.35743234f, -0.79482532f, 0.14133018f, -0.33175588f, -0.17961642f, 0.23995860f, 
    -0.73004651f, -0.04739083f, -0.43776333f, -0.33479342f, 0.07806464f, 0.02109034f, -0.70904475f, 0.10614741f, 
    0.29788890f, 0.33369875f, -0.15851299f, -0.10342802f, -0.24490477f, 0.32607228f, -0.77696770f, 0.44268695f, 
    0.08076148f, -0.07409394f, -0.07656603f, -0.10721486f, 0.02774280f, 0.13413896f, 0.18134849f, 0.36658001f, 
    -0.00465156f, 0.43342614f, 0.00967507f, -1.05521917f, -0.21102096f, -0.09549559f, 0.11087099f, -0.40388918f, 
    0.16373682f, 0.01533533f, -0.15051098f, -0.21444272f, -0.24151962f, -0.13873573f, -0.06626321f, -0.18347338f, 
    0.03239599f, 0.10233084f, 0.05512828f, -0.10854728f, -0.19297731f, -0.19602139f, -0.12624685f, 0.13450228f, 
    0.34844646f, 0.16789722f, 0.15112725f, 0.69694871f, -0.15590967f, -0.21561007f, -0.08795328f, -0.49030775f, 
    0.00237431f, -0.09031036f, 0.07089104f, 0.26486099f, 0.22689916f, 0.23980868f, 0.14927188f, 0.06720337f, 
    -0.18410061f, 0.50968635f, 0.14711733f, -0.41673884f, 0.50408345f, -0.13382266f, 0.07696774f, 0.14419262f, 
    -0.39041245f, -0.13166605f, -0.18764982f, 0.14470415f, -0.55184567f, -0.34632847f, 0.18242958f, 0.12876712f, 
    0.06375886f, -0.13472618f, 0.15476365f, 0.04011675f, -0.09973007f, 0.51250559f, 0.22466806f, 0.16457036f, 
    -0.05684844f, -0.23806818f, -0.30499345f, 0.58083469f, -0.20938282f, -0.10597776f, 0.06974228f, 0.25628981f, 
    -0.01240648f, -0.49590886f, -0.39212263f, 0.82953250f, -0.55810988f, 0.10079643f, 0.43636140f, -0.03618106f, 
    0.13603534f, -0.39340916f, 0.05571725f, -0.01926965f, 0.28060097f, -0.29989931f, 0.00617073f, -0.41424438f, 
    0.07299275f, 0.09664375f, 0.02235549f, -0.48722687f, 0.10978465f, -0.09164573f, 0.37207684f, 0.14880061f, 
    -0.10139740f, -0.71741527f, -0.53303713f, -0.89999771f, -0.32836956f, -0.36694503f, -0.01099579f, 0.28860623f, 
    0.35344842f, -0.14833486f, -0.15523422f, -0.69950032f, 0.35524333f, 0.12651639f, 0.10099641f, -0.09395587f, 
    -0.13312095f, -0.09977269f, 0.05676851f, -0.10436489f, 0.46263045f, 0.33881414f, -0.37263617f, 0.39257926f, 
    -0.01680633f, 0.11716517f, -0.00761137f, -0.07752814f, -0.05986767f, 0.12039728f, -0.33530942f, -0.06537183f, 
    -0.01599652f, -0.31260812f, -0.33025813f, -0.09074689f, -0.28703058f, -0.18833986f, 0.04422431f, 0.31050429f, 
    -0.20339717f, 0.44161248f, 0.34232768f, -0.26878238f, -0.31535235f, -0.04204116f, -0.20984167f, 0.13206358f, 
    -0.44464242f, 0.57410729f, -0.09012371f, 0.11797307f, 0.37325820f, 0.21785966f, 0.02248217f, -0.39763471f, 
    -0.29677421f, -0.07606108f, 0.07027292f, -0.71109682f, 0.00101778f, 0.01364973f, -0.47111017f, 0.21747649f, 
    0.11300611f, -0.41642103f, 0.75528359f, -0.97379947f, 0.32607365f, 0.20276886f, 0.02048498f, 0.34676930f, 
    0.05400137f, -0.11153890f, -0.30764082f, 0.59630328f, -0.01256183f, -0.11148086f, -0.03174330f, -0.01963441f, 
    0.14006165f, -0.62697440f, -0.04978226f, -0.05511341f, -0.60516280f, 0.03057730f, -0.79480767f, 0.15145011f, 
    0.31749159f, 0.07093268f, 0.16230020f, 0.42785054f, -0.02443517f, -0.16073190f, -0.21765611f, 0.15900311f, 
    0.11875011f, -0.41089806f, 0.30385903f, 0.47335273f, 0.13118678f, 0.09032685f, 0.12898475f, -0.18307798f, 
    0.52051115f, -0.01956053f, 0.26661482f, -0.66315478f, -0.27330166f, -0.03537880f, 0.09638447f, 0.14115411f, 
    -0.10632814f, -0.19582309f, 0.02429802f, 0.11979965f, 0.01471848f, -0.66017574f, 0.47295821f, -0.51643348f, 
    -0.42468119f, 0.13162646f, 0.09683291f, -0.07256489f, 0.05040979f, 0.52644688f, -0.15665604f, -0.13980184f, 
    0.13051569f, 0.49528006f, -1.10664654f, -0.58219916f, 0.48778045f, 0.20081492f, -0.09629918f, 0.00845949f, 
    0.06881200f, -0.01303528f, 0.12802443f, -0.16549690f, -0.68899858f, 0.02553696f, -0.47517529f, -0.00388502f, 
    0.27237478f, -0.28533050f, -0.08671863f, 0.14131951f, 0.12990648f, -0.37593517f, 0.82807380f, 0.08168420f, 
    0.01496430f, 0.16502506f, -0.15208825f, -0.15588698f, 0.04395474f, 0.49258053f, 0.20323503f, -0.13214515f, 
    0.01605177f, -0.08568902f, 0.57274294f, -0.84469706f, 0.09723592f, -0.72246903f, -0.05481449f, -0.61322451f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.51171309f, 0.36712238f, 0.14026847f, 0.17887343f, 0.08478784f, -0.08768266f, -0.12995830f, -0.41080204f, 
    -0.01132021f, 0.04307560f, 0.06023238f, 0.00646167f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
