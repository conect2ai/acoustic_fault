#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.45690203f, -1.14015698f, -1.30988705f, -0.80287421f, -1.11043954f, 0.85951722f, 0.23921035f, 0.88432676f, 
    0.23236293f, -0.09745982f, 0.21858822f, 0.12438655f, 0.27810848f, -0.21363819f, 0.60396534f, 0.06596798f, 
    0.00775192f, 0.02912776f, -0.36286554f, 0.00111551f, 0.05516313f, -0.48118833f, -0.14919415f, 0.50968212f, 
    -0.01458746f, 0.10789517f, -1.05480802f, 0.80498803f, -0.70586729f, 0.36477196f, -0.42237917f, -0.57754099f, 
    -0.19719552f, -0.21052724f, 1.10205984f, -0.55501151f, 0.07610083f, -0.45457679f, -0.20190060f, 0.57821113f, 
    -0.09564605f, 0.09903806f, -0.35489318f, 0.25508016f, -0.59588820f, 0.21681790f, -0.16394733f, -0.26036018f, 
    -0.13638818f, 0.14353129f, 1.56396353f, 0.22842629f, -0.31356874f, 0.39307514f, 0.15250376f, -0.16940346f, 
    0.91962099f, -0.52397120f, -0.87205839f, -0.73139399f, -0.03761400f, -0.13458161f, -0.21806067f, -0.42722043f, 
    0.12043436f, -0.10558432f, -0.13252242f, 0.09941117f, 0.29778090f, -0.08553723f, 0.09805951f, -0.37359613f, 
    0.11579273f, 0.03028175f, -0.09667008f, 0.98385113f, -0.59828240f, -0.03147138f, 0.54772478f, 0.09103002f, 
    -0.65188551f, -0.32270104f, 0.34305695f, 0.55994534f, 0.22351006f, -0.35191986f, 0.16971463f, -0.19447902f, 
    -0.12405935f, 0.44283134f, -0.22065477f, -0.20389685f, -0.04214686f, 0.20685929f, -0.27515432f, -0.02820192f, 
    -0.54242224f, -0.26867381f, -0.33044955f, -0.14621972f, -2.07559085f, -0.13188145f, -0.44222724f, -1.70683610f, 
    -1.07020760f, 0.45417383f, -0.26537609f, -0.92258018f, -0.76177436f, 0.18514737f, -0.49726617f, -0.51369798f, 
    -0.29962230f, -0.54440123f, -0.23859362f, 0.09156586f, -0.11386131f, -0.17389162f, -0.23259388f, -0.19828887f, 
    -0.20000167f, 0.08081929f, -0.12418588f, -0.31771752f, -0.01482796f, 0.33173296f, -0.24712108f, -0.06528319f, 
    0.47924578f, 0.01100908f, -0.60020566f, -0.79354346f, -0.97668147f, -0.45795658f, -0.63137716f, -0.34613383f, 
    0.09183959f, -0.19146831f, -0.40701652f, 0.16518082f, 0.19495915f, 0.69883138f, 0.00289904f, -0.23686932f, 
    -0.21918525f, -0.31072122f, -0.28025523f, -0.38557228f, -0.55037445f, -0.46283600f, 0.50969440f, 0.63312131f, 
    0.63107806f, 0.24347788f, 0.43078196f, -0.06470728f, -0.04632384f, 0.37546721f, 0.12785424f, -0.17689148f, 
    0.10912538f, -0.15941933f, -0.00178646f, -0.01376070f, 0.09368177f, 0.32824126f, 0.45616961f, -0.21069893f, 
    -0.33417356f, 0.15138631f, -0.26168686f, 0.17984089f, -0.03700723f, -0.02073872f, -0.05538373f, -1.60429800f, 
    -1.28095961f, -0.55191213f, 0.26752582f, 0.54589391f, 0.30462420f, -0.00002511f, 0.11672562f, 0.90597028f, 
    0.71740884f, 0.41287917f, -0.08044654f, -0.16328637f, -0.05008060f, -0.01483674f, -0.58826220f, -0.31809610f, 
    -0.47382295f, -0.16788024f, -0.23459563f, -0.06568417f, -0.17283010f, 0.07076288f, -0.24004546f, -0.11838718f, 
    0.57444870f, -0.15761973f, 0.19232154f, -0.40127823f, 0.38293612f, -0.10983841f, -0.46156541f, -0.24367937f, 
    0.55409598f, -0.42398274f, 0.09222251f, 0.25360423f, -0.05999004f, -0.20104322f, 0.51853257f, 0.18739018f, 
    0.44845134f, 0.17604817f, -0.11988059f, -0.05221771f, -0.17204340f, 0.50248313f, 0.02534448f, 0.10879637f, 
    0.48939693f, 0.92896754f, 0.88085330f, 0.56492651f, 0.34436947f, -0.97767437f, -0.57866460f, -0.16806799f, 
    0.22770017f, -0.29001522f, -0.27488592f, 0.41460204f, 0.19415833f, -0.30084461f, -0.05663158f, -0.04667817f, 
    -0.26739717f, -0.23088247f, -0.33319965f, 0.23924057f, 0.00791366f, 0.05872053f, 0.38281682f, -0.16593552f, 
    0.02440819f, -0.39996120f, -0.71223217f, -0.19682953f, -0.43092746f, -0.68469876f, -0.88261324f, 0.11820310f, 
    0.44893762f, 0.36043692f, 0.31848738f, 0.24564041f, -0.24063781f, -0.41694880f, -0.46924451f, 0.11297161f, 
    -0.07781235f, -0.20234221f, 0.00076985f, 0.02577334f, 0.02331919f, -0.26884452f, -0.72271091f, -0.39091885f, 
    -0.24382220f, -0.75058591f, -0.85174799f, 0.03468234f, -0.32365382f, 0.45352000f, 0.36102873f, -0.04808533f, 
    -0.20807599f, 0.43153945f, 0.52997041f, 0.40012473f, 0.68830359f, 0.38651326f, -0.01353011f, 0.09593049f, 
    -0.14642549f, -0.13214393f, -0.10107930f, 0.56377012f, -0.25442699f, -0.40285209f, 0.18225619f, -0.32561412f, 
    0.36793786f, 0.39179042f, -0.17198081f, 0.06550525f, -1.22700775f, 1.44585001f, 0.85007250f, 0.01410527f, 
    0.51123542f, -0.41914919f, -0.97260028f, -0.21058135f, 0.17569123f, 0.22396523f, -0.42608005f, -0.03250347f, 
    -0.21690495f, 0.17339385f, -0.16380467f, 0.02295747f, 0.14822359f, 0.38595423f, 0.09377325f, -0.06398162f, 
    -0.18568546f, -0.15555857f, 0.10175020f, -0.40883714f, -0.27282283f, -1.19914687f, -0.39415374f, -0.89010513f, 
    -1.03126657f, -0.44320309f, 0.94483680f, 0.23518299f, -0.07905542f, -0.20750318f, 0.88744354f, -0.01666277f, 
    -0.22555749f, -0.11220861f, 0.03323068f, -0.29340065f, -0.09448075f, -0.14332642f, 0.05708486f, -0.00494969f, 
    -0.21102543f, 0.34876379f, 0.42976505f, 0.34166873f, 0.40747327f, 0.02248313f, 0.42149469f, -1.30108738f, 
    0.45414883f, 0.35554379f, -0.56318504f, 0.09946759f, -1.53489327f, -1.55830276f, -0.57352620f, -0.50518018f, 
    -0.18610536f, -0.32723063f, -0.56976128f, -0.39540553f, -0.51370633f, -0.24207389f, -0.49414912f, -0.18622404f, 
    0.12855379f, -0.73593217f, -0.19251366f, -0.00438582f, -0.29550958f, 0.16829908f, -0.09428071f, 0.05106301f, 
    0.06933042f, 0.01289221f, -0.13965811f, -1.42067206f, -1.40700006f, -0.78115946f, -0.46179700f, -0.63845414f, 
    -1.36067104f, 0.19705848f, -0.46801367f, -0.24630167f, 0.60785294f, 0.57623905f, 0.06615150f, -0.09997777f, 
    -0.02389892f, 0.18248102f, 0.26346517f, -0.01296536f, -0.23000574f, -0.02267771f, 0.26117036f, 0.25926417f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.47867656f, 0.58436745f, 0.28727064f, 0.41858339f, 0.27431095f, -0.43016100f, -0.22168508f, 0.29448941f, 
    0.49663845f, 0.89634794f, -0.16899434f, 0.49977866f, 0.57088977f, -0.18726508f, 0.00155955f, 0.34956041f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19686282f, -0.27913421f, -0.31036940f, 0.19362913f, 0.16944610f, 0.12604266f, -0.15004998f, -0.12446619f, 
    -0.04904801f, -0.01353481f, -0.09630630f, 0.15364526f, -0.12329806f, 0.26883221f, 0.05660611f, -0.24360128f, 
    -0.29877418f, -0.32478607f, -0.10354269f, -0.59778118f, -0.23881502f, -0.09967840f, -0.04526139f, -0.20488133f, 
    -0.64837766f, -0.70941120f, -0.08121344f, 0.10760400f, -0.04598461f, -0.05351153f, 0.16496463f, -0.02280520f, 
    -0.06869592f, 0.14512481f, -0.04662357f, 0.03578171f, -0.86028218f, -0.16974761f, 0.22144425f, 0.04801948f, 
    0.03130342f, 0.05202905f, 0.09440911f, -0.02191697f, -0.02136227f, -0.06656521f, -0.00625216f, -0.02768153f, 
    0.34045127f, 0.35053003f, -0.14849789f, -0.27558830f, 0.18341514f, 0.52232879f, -0.00501213f, 0.03788327f, 
    -0.04533365f, -0.08179022f, -0.02314097f, -0.06927166f, 0.23037109f, 0.29983789f, 0.11230062f, -0.00698442f, 
    -0.12255849f, -0.02907781f, -0.05279643f, 0.11294999f, -0.17815872f, 0.01751430f, 0.01830510f, 0.05369828f, 
    -0.04762739f, 0.00313167f, 0.04361931f, 0.12446713f, 0.14045373f, 0.09214976f, 0.07709017f, 0.04625708f, 
    0.05259445f, -0.00940680f, -0.01135854f, 0.05660858f, 0.44629309f, 0.30035648f, 0.19486207f, -0.22258244f, 
    0.16642171f, 0.15071255f, 0.05097724f, -0.02313650f, 0.03709688f, -0.01966063f, -0.04471335f, -0.10844599f, 
    0.12485293f, -0.01807260f, 0.02660326f, -0.06003606f, -0.57526755f, -0.35241386f, -0.24445246f, -0.21308725f, 
    0.04743367f, -0.07399756f, -0.06808439f, -0.15150975f, -0.87191480f, -0.84642029f, 0.15252730f, -0.07621890f, 
    -0.00119333f, 0.03948662f, -0.06189524f, -0.14848858f, -0.04175589f, 0.00569730f, 0.05412872f, -0.01531171f, 
    0.15657793f, -0.28427017f, -0.00531079f, -0.06795413f, 0.22481193f, 0.26915571f, -0.12104604f, -0.07302377f, 
    0.14649439f, 0.36857361f, 0.07098182f, 0.34577659f, -0.17618710f, -0.08638773f, 0.01928789f, -0.04521358f, 
    -0.11043290f, -0.03701052f, 0.01248803f, 0.02626227f, -0.22715488f, -0.15624644f, -0.38171467f, -0.44455782f, 
    -0.99131203f, 0.54995251f, 0.10856768f, 0.04439767f, -0.00962609f, -0.02971623f, -0.24649979f, -0.07163873f, 
    0.05710942f, -0.08615729f, 0.01312156f, -0.04222931f, 0.28781369f, 0.17916469f, -0.06815388f, -0.00261277f, 
    0.10645938f, 0.36769968f, 0.01353616f, -0.03835666f, -0.05953218f, -0.00361634f, -0.08672217f, 0.04501947f, 
    0.50920659f, 0.28168476f, -0.21362615f, -0.43972498f, 0.08334328f, -0.21522206f, -0.09506799f, -0.19008198f, 
    -0.22617635f, -0.23336621f, -0.05525361f, -0.05491516f, 0.35187253f, 0.10316431f, 0.09452235f, -0.52039129f, 
    -0.02300255f, -0.03324772f, -0.13203800f, 0.01759896f, 0.07633115f, 0.01413713f, -0.07258354f, -0.04321942f, 
    0.87880123f, -0.49468753f, -0.09028347f, -0.16923100f, -0.12854567f, 0.04556216f, 0.15350860f, -0.40526465f, 
    0.27082148f, 0.07483292f, 0.07439629f, -0.11640886f, -0.46826518f, -0.13294494f, -0.00108935f, -0.29445395f, 
    0.28201783f, 0.31541502f, -0.32189822f, 0.15284602f, -0.00972131f, 0.18270002f, 0.06545939f, -0.13531038f, 
    0.93325561f, -0.10988331f, 0.04565394f, 0.14458105f, -0.11305348f, -0.12806134f, -0.17385527f, -0.17042346f, 
    -0.12545963f, -0.06587709f, 0.08265603f, 0.12003394f, 0.18952365f, 0.28110081f, 0.19150269f, -0.03798730f, 
    -0.08967018f, 0.03954500f, -0.07754669f, -0.17326981f, 0.19798459f, -0.05829546f, 0.22457279f, -0.01506111f, 
    0.31867144f, 0.48387378f, 0.36136270f, 0.41081268f, 0.38093340f, 0.29087570f, -0.34623912f, -0.01551775f, 
    -0.03323907f, 0.05587896f, -0.04628026f, -0.09762803f, -0.05828298f, 0.09506922f, -0.26488891f, -0.46798584f, 
    0.21953809f, 0.04370790f, -0.13315949f, 0.04815196f, 0.04166644f, 0.04300756f, -0.19812129f, 0.14193100f, 
    0.15089002f, 0.13474865f, 0.26170897f, 0.14680287f, -0.11041356f, -0.07761063f, -0.00788662f, 0.00358786f, 
    -0.04135073f, 0.07487433f, -0.16988103f, 0.00672120f, -0.38797575f, -0.19003959f, -0.91765124f, -0.24159607f, 
    -0.15490749f, 0.02426879f, 0.02407164f, 0.02753548f, -0.19639824f, -0.08750350f, -0.27058747f, -0.09175877f, 
    0.03998065f, 0.04380574f, -0.10216752f, -0.08342104f, 0.10520247f, -0.01584410f, -0.05827602f, -0.14241078f, 
    -0.29755506f, 0.19141452f, -0.03504386f, 0.02249626f, 0.53047162f, -0.12062190f, 0.37125954f, -0.27729246f, 
    -0.02104799f, -0.25797793f, -0.12933175f, 0.15221164f, 0.00788308f, -0.08785070f, 0.07359815f, 0.03184376f, 
    0.00236815f, 0.14583184f, 0.09588798f, 0.03176004f, 0.05861089f, 0.08444602f, -0.23087497f, -0.20568138f, 
    -0.20377357f, -0.14333528f, -0.15573189f, -0.39586559f, 0.07214402f, 0.01529925f, 0.27354959f, 0.16152270f, 
    -0.15870573f, 0.05826522f, -0.03318742f, 0.04494850f, -0.14563043f, 0.05271430f, -0.08646420f, 0.24207033f, 
    -0.40012085f, 0.00507183f, -0.00508708f, -0.10329252f, 0.10829609f, -0.02737499f, -0.06095308f, 0.25145555f, 
    -0.06033381f, -0.02100025f, -0.02317526f, 0.03850428f, 0.11102859f, 0.28450799f, 0.36876783f, -0.33371064f, 
    -0.19404130f, -0.00287267f, 0.14462429f, 0.20108119f, -0.14174610f, -0.11343374f, 0.06690334f, -0.09835777f, 
    -0.32320896f, -0.22177826f, -0.50367343f, -0.00831700f, -0.15154211f, -0.09539230f, 0.12158260f, 0.33698228f, 
    -0.00923374f, -0.09369557f, 0.02100755f, 0.00350956f, -0.15103267f, 0.03565919f, 0.20322610f, -0.36590213f, 
    -0.11824912f, -0.20038676f, 0.16625457f, -0.07905081f, -0.07415154f, -0.03194154f, 0.06391660f, 0.04213986f, 
    -0.20235819f, 0.62874019f, 0.43233135f, -0.00414178f, -0.15882505f, -0.04645800f, 0.20984483f, -0.43797496f, 
    -0.00799622f, 0.19813901f, -0.10726240f, 0.11970669f, 0.48172700f, -0.29711869f, 0.16891092f, 0.19703750f, 
    -0.15550393f, 0.24157566f, -0.29513001f, 0.06036043f, -0.01229916f, 0.00360409f, -0.23463875f, -0.08184203f, 
    -0.66109776f, 0.02014978f, 0.03726362f, -0.48616642f, 0.00510018f, -0.01540009f, 0.05634646f, -0.01852675f, 
    0.07230594f, -0.08265731f, -0.07869820f, -0.13067572f, -0.41313362f, 0.17963612f, -0.05979199f, 0.19978853f, 
    -0.21622679f, 0.04067623f, -0.11445212f, 0.06263404f, -0.01200829f, 0.07909512f, 0.14360256f, 0.16557930f, 
    0.03764075f, 0.13196316f, 0.46764281f, 0.91088188f, 0.02637178f, 0.10587115f, -0.09041786f, 0.07171168f, 
    0.01104272f, 0.03022505f, -0.12095164f, 0.09458572f, -0.65423769f, -0.33806470f, 0.13619220f, -0.20697987f, 
    -0.21000853f, -0.17975797f, -0.19271620f, -0.30615473f, 0.01437164f, -0.00692321f, -0.20035875f, 0.02588547f, 
    -0.20975669f, -0.11983290f, -0.10415548f, -0.04081686f, -0.03395591f, -0.06301119f, 0.05241312f, 0.10012492f, 
    -0.08881696f, -0.06527705f, -0.17628571f, 0.08037128f, 0.08658671f, -0.00316641f, 0.27590171f, 0.46766800f, 
    0.10953036f, 0.04972806f, 0.13200837f, 0.06658047f, -0.03905796f, -0.01758923f, -0.08256762f, 0.00408029f, 
    -0.17133445f, -0.08394217f, 0.15739086f, 0.07976744f, -0.30552918f, -0.08541410f, -0.24603814f, -0.17456777f, 
    0.06283162f, 0.01199964f, 0.05457888f, -0.00979332f, -0.50596434f, 0.11061662f, 0.34090611f, -0.32166323f, 
    0.02854872f, 0.08467700f, -0.04190656f, 0.05810186f, 0.19477227f, -0.03263717f, -0.10445426f, 0.18866466f, 
    -0.03153194f, 0.38064387f, 0.15297846f, 0.15651767f, -0.06383411f, -0.12443656f, 0.27065033f, -0.08924253f, 
    -0.07710121f, 0.08185342f, 0.06259678f, 0.08837558f, -0.03616239f, 0.02673541f, -0.13198192f, 0.11406735f, 
    -0.01810575f, 0.12367359f, 0.00990254f, -0.01803079f, 0.14399678f, -0.20369810f, -0.09766168f, 0.29760596f, 
    0.14292641f, 0.10845111f, 0.09440669f, -0.06201779f, 0.03887555f, 0.05140982f, 0.14805676f, -0.00606890f, 
    0.00368984f, -0.09108258f, 0.07729767f, -0.06655137f, -0.25887480f, -0.29731923f, 0.64730006f, 0.43424547f, 
    0.03170575f, -0.03205660f, -0.03761407f, -0.06030126f, 0.04843401f, -0.20311733f, -0.06635161f, -0.11058708f, 
    -1.16812479f, 0.19457404f, -0.13693300f, -0.49853122f, 0.18953769f, -0.19508044f, -0.18738885f, 0.02097613f, 
    -0.02345628f, -0.08473167f, 0.07974007f, -0.07458515f, -1.77762377f, -0.31781816f, -0.42553574f, -0.29271862f, 
    0.03675077f, 0.16613530f, 0.08468223f, -0.41863841f, -0.03231350f, 0.02451378f, -0.02618479f, -0.04518493f, 
    -0.87593031f, -0.06460869f, 0.00053028f, 0.51581091f, 0.23762196f, -0.01346728f, 0.29832250f, -0.36654475f, 
    -0.16037296f, 0.04955778f, 0.09732729f, 0.12760653f, -0.34210530f, -0.20106848f, -0.14840832f, -0.21542694f, 
    -0.06206450f, 0.08410759f, -0.13871652f, -0.06599371f, -0.20177783f, -0.06280186f, -0.24272561f, 0.28678763f, 
    -0.43379167f, 0.47968164f, -0.03037794f, 1.09892464f, -0.04404459f, -0.17883074f, -0.10791755f, 0.07425700f, 
    0.25024286f, -0.10983602f, 0.16037069f, -0.00544479f, -0.65264767f, -0.33118507f, -0.33853778f, -0.09210068f, 
    -0.11033516f, 0.07438947f, -0.16524148f, -0.05316366f, 0.14438589f, 0.18636496f, -0.00149340f, -0.13132358f, 
    0.40989509f, -0.41614103f, -0.00506179f, 0.25063971f, 0.00560445f, -0.17006671f, -0.22206849f, -0.06317352f, 
    -0.15142336f, 0.14197601f, 0.03271874f, 0.18862759f, -0.12902242f, -0.21189506f, -0.12301604f, 0.27656215f, 
    -0.10949117f, 0.25178334f, 0.26770863f, 0.17707740f, 0.12214183f, 0.25707412f, -0.16058293f, 0.07333596f, 
    -0.30534008f, -0.44374949f, 0.02614603f, -0.06633375f, -0.57735485f, -0.12557478f, -0.19183257f, 0.11970808f, 
    0.06643225f, 0.04485259f, 0.25094381f, -0.06862208f, -0.06840535f, 0.14917070f, 0.04638065f, -0.33021250f, 
    0.19176348f, 0.13418977f, 0.09494278f, -0.18116930f, -0.20457976f, 0.13091648f, -0.09155234f, -0.16364570f, 
    -0.08690576f, -0.22696270f, 0.17085360f, -0.20323171f, -0.14265053f, 0.03112879f, -0.01813542f, -0.01814645f, 
    -0.16990352f, -0.04377169f, -0.31801739f, -0.12010065f, -0.38437194f, -0.12657095f, 0.14478600f, 0.08454741f, 
    -0.33559930f, -0.08107831f, -0.34921816f, 0.04416842f, -0.03286853f, -0.00055823f, -0.10572137f, -0.04988257f, 
    0.52685755f, -0.10302347f, 0.05793522f, 0.26708221f, 0.11511807f, 0.24157962f, 0.13441609f, -0.18398803f, 
    -0.08914682f, -0.07431059f, 0.02047109f, 0.08947157f, -0.08308522f, -0.50965679f, -0.00323207f, -0.00540614f, 
    0.08691415f, 0.06104183f, -0.06994047f, 0.41614187f, -0.21571678f, 0.00243221f, -0.12154401f, -0.31818822f, 
    0.66728818f, 0.54844373f, 0.55415404f, -0.85069638f, -0.33731860f, 0.20993817f, -0.11292589f, -0.16940592f, 
    0.13427819f, -0.04236515f, -0.05955639f, 0.25424814f, 0.61606467f, -0.27046534f, -0.04085689f, 0.19623831f, 
    0.38037395f, 0.05180887f, -0.01517456f, -0.32717767f, -0.14560202f, 0.03908022f, 0.19924830f, 0.27009702f, 
    -0.62034470f, -0.03421562f, 0.09629492f, 0.58485985f, 0.04470687f, -0.04643006f, 0.18170007f, -0.08110382f, 
    0.03525288f, 0.06045799f, -0.09428998f, -0.08596181f, 0.04916165f, -0.43247175f, 0.10010708f, 0.09237888f, 
    0.03272448f, 0.02639853f, 0.10081309f, 0.17742109f, -0.03912215f, -0.29664484f, -0.05544730f, -0.29453537f, 
    0.10102124f, 0.04909453f, 0.13555160f, 0.06907253f, -0.04200166f, -0.19987972f, -0.15094453f, -0.06502187f, 
    -0.11116234f, -0.24795593f, -0.13887158f, 0.15827636f, -0.43076733f, -0.04616420f, -0.38559994f, 0.13323562f, 
    -0.37967429f, -0.09765210f, -0.05622447f, -0.13804467f, -0.40764081f, -0.08156493f, -0.13457371f, -0.17007184f, 
    -0.11666240f, 0.35707039f, -0.64014912f, -0.44170710f, 0.18842916f, -0.01045918f, 0.14573854f, 0.11633042f, 
    0.01774834f, -0.05650888f, -0.06446248f, -0.01811611f, 0.09854253f, -0.10473822f, -0.13263667f, -0.27431050f, 
    -0.00874780f, 0.06934072f, 0.11541515f, 0.02666895f, -0.02083588f, 0.13622627f, -0.19366436f, 0.11278750f, 
    -0.25587595f, -0.13877477f, -0.02554613f, 0.05464908f, -0.15758178f, -0.20907065f, -0.02728107f, -0.11738811f, 
    0.07091337f, -0.06575815f, 0.06924681f, 0.15559928f, 0.39643356f, 0.31196344f, 0.26154527f, 0.20592052f, 
    -0.01874653f, 0.10484290f, -0.07344764f, -0.05582500f, -0.09992348f, 0.04718031f, 0.23238364f, -0.03922628f, 
    -0.00325915f, 0.07799537f, 0.05553893f, 0.12199127f, 0.16233002f, 0.10268680f, 0.04380268f, 0.02672525f, 
    0.22831281f, 0.09234702f, -0.00074741f, 0.07189056f, 0.05325826f, 0.30335245f, -0.03272820f, 0.12754653f, 
    -0.14838764f, 0.03801270f, 0.01524713f, 0.00047748f, 0.15150586f, 0.00621152f, -0.09367666f, 0.08434125f, 
    0.10647967f, 0.03605777f, 0.09060480f, -0.02283766f, 0.15490311f, -0.12316244f, 0.09877244f, -0.15009518f, 
    0.03292485f, -0.14073691f, -0.18333213f, -0.23065493f, -0.49857679f, -0.30828857f, -0.31377062f, 0.05637537f, 
    0.20355017f, 0.02142777f, 0.27714121f, -0.17974763f, 0.04315123f, 0.13987719f, 0.06096393f, -0.28482580f, 
    -0.30556953f, 0.07355588f, -0.05711334f, -0.10023685f, -0.17023633f, -0.12078562f, 0.08962926f, -0.11760327f, 
    0.04466522f, 0.16665870f, 0.08081773f, 0.42584103f, 0.24789506f, -0.08503567f, -0.13032144f, -0.27406859f, 
    -0.11419591f, -0.06946722f, 0.11246192f, 0.01852240f, -0.18559152f, -0.30909291f, -0.30135307f, -0.27873641f, 
    0.47810349f, -0.59174711f, -0.34374127f, 0.69286352f, 0.01940711f, -0.19351219f, 0.09960848f, -0.49722141f, 
    0.10859201f, -0.17178343f, -0.02196773f, 0.06758896f, -0.18387446f, 0.24060538f, 0.11016826f, 0.24560659f, 
    0.02845862f, -0.12807740f, 0.14250058f, -0.05507975f, 0.11991713f, 0.00401877f, -0.03735310f, -0.00049011f, 
    0.34058079f, 0.00323316f, 0.28097281f, -0.08985700f, 0.14222033f, 0.19308715f, 0.02424302f, 0.10893447f, 
    -0.11443309f, 0.04305036f, -0.08663077f, -0.14395763f, 0.13664261f, 0.47314021f, 0.14606684f, 0.37077612f, 
    -0.22295448f, 0.11353847f, -0.12996733f, 0.20843531f, 0.00084796f, 0.04921879f, -0.12561756f, -0.06029591f, 
    -0.23847461f, -0.31896383f, -0.50009537f, -0.28478867f, 0.07323495f, 0.07927289f, -0.25888199f, 0.32266816f, 
    0.14399573f, -0.01830009f, 0.01267348f, -0.13237396f, 0.33872271f, 0.05554495f, 0.33492672f, 0.05348099f, 
    0.04737029f, -0.11184077f, -0.04838172f, 0.51757079f, 0.19547899f, -0.10066283f, 0.10075508f, 0.13416897f, 
    -0.23891492f, -0.51888508f, -0.57642180f, -0.58833873f, 0.08493993f, 0.28826213f, 0.08676562f, 0.27050731f, 
    0.09738833f, 0.12898938f, -0.15457623f, -0.08897506f, 0.13570209f, -0.50207067f, 0.20955446f, 0.08419986f, 
    0.23911425f, 0.04704021f, 0.13592781f, 0.08245009f, -0.06909768f, 0.22028342f, -0.22303769f, -0.28899491f, 
    -0.28523648f, 0.27093688f, 0.19002131f, -0.43495667f, -0.00104246f, -0.07182804f, 0.19935916f, 0.15125349f, 
    0.01116321f, 0.03890781f, -0.00072772f, 0.00586363f, 0.08405843f, -0.18526238f, 0.25322896f, -0.02612446f, 
    0.05556859f, -0.17996417f, -0.33792979f, -0.13991354f, -0.02512385f, -0.28575605f, 0.12813854f, -0.19513491f, 
    -0.17274170f, -0.23683716f, -0.12150692f, 0.12127284f, 0.15415786f, 0.07569185f, -0.13937140f, -0.11969657f, 
    0.03855645f, -0.24382450f, 0.12252609f, 0.08107928f, -0.44509670f, -0.47663078f, 0.26869568f, 0.09042899f, 
    0.01489182f, -0.14892940f, -0.05193782f, -0.04371833f, 0.08952630f, -0.09246854f, 0.00438945f, 0.00894907f, 
    -0.06343186f, -0.08561755f, -0.06057056f, 0.04522721f, 0.00782069f, 0.33857372f, 0.02412497f, 0.17288074f, 
    0.08339821f, -0.01438646f, 0.18155159f, 0.14048249f, 0.11864002f, -0.06606764f, -0.43829530f, 0.51809609f, 
    0.19214351f, 0.13719502f, -0.04929416f, -0.06717022f, -0.02784378f, 0.03542932f, -0.09747852f, 0.07019877f, 
    -0.30099583f, -0.05229707f, -0.26095980f, -0.35411388f, -0.16124098f, -0.01669178f, 0.03286834f, 0.15170355f, 
    0.04312062f, -0.28446251f, -0.06408497f, -0.49486953f, -0.13038829f, -0.40611744f, -0.14035334f, 0.25819457f, 
    0.19506818f, -0.24583514f, -0.04935338f, -0.12273172f, 0.26634696f, -0.05310651f, 0.22110301f, -0.08932526f, 
    -0.68948120f, -0.31422386f, 0.30860135f, 0.26481575f, 0.09294605f, -0.19090560f, -0.00654002f, 0.19652736f, 
    0.01018408f, 0.19866648f, -0.08219385f, -0.05098757f, -0.67170107f, -0.10073822f, -0.13713236f, -0.30245990f, 
    0.01347660f, -0.02162497f, -0.03828570f, -0.06129967f, 0.18990897f, 0.08359998f, 0.00862010f, 0.00102297f, 
    0.41868848f, 0.38099039f, 0.28718817f, -0.36860952f, -0.04784039f, 0.08432256f, -0.01406831f, -0.10032651f, 
    0.14307287f, 0.13109347f, -0.09814972f, 0.12938182f, 0.15448558f, 0.04392500f, 0.03893014f, 0.27546194f, 
    0.21707772f, 0.24427693f, -0.10527622f, -0.03392579f, -0.09257443f, 0.06840765f, -0.02747816f, 0.03264014f, 
    0.12352087f, 1.17018008f, -0.18206649f, 0.18423057f, -0.13081616f, -0.02831823f, -0.11505885f, 0.04550535f, 
    0.10964089f, -0.08612877f, 0.34963456f, -0.05864334f, 0.47471854f, -0.44246200f, -0.85770518f, 0.24376145f, 
    -0.37156337f, -0.00019435f, 0.47790939f, 0.49424407f, 0.07375766f, -0.09503129f, 0.14431150f, -0.09433070f, 
    -0.23127280f, -0.69534796f, -0.13838355f, 0.35014454f, 0.26571029f, 0.12013086f, 0.14129786f, -0.19403668f, 
    0.04785328f, -0.02467967f, -0.02004902f, 0.14656417f, 0.18803665f, 0.14697140f, -0.29879275f, -0.13545898f, 
    0.01765161f, -0.02909411f, 0.16979122f, 0.07643558f, -0.15401019f, -0.07995433f, 0.24722895f, 0.33187836f, 
    -1.63113415f, -0.94460100f, 0.31479093f, 0.15899043f, 0.11900491f, -0.36141315f, 0.21432324f, -0.23250450f, 
    0.00266382f, -0.05435933f, 0.07718696f, 0.00363475f, -0.38192549f, -0.56011850f, -0.81495231f, 0.28241155f, 
    -0.38569421f, 0.20903222f, 0.23795724f, -0.39818272f, -0.04953703f, -0.12702931f, 0.03141661f, 0.12882678f, 
    0.00717188f, -0.12786511f, -0.18932635f, -0.14043127f, 0.00170526f, 0.04657769f, 0.05681792f, -0.06094129f, 
    -0.11559711f, -0.22122014f, -0.08685143f, -0.24324876f, -0.73673218f, 0.16027263f, 0.28278574f, 0.07866303f, 
    -0.08840071f, 0.06913778f, -0.11918136f, 0.21379651f, -0.04784607f, 0.31034607f, 0.39640039f, 0.17036758f, 
    0.13672405f, -0.10056879f, -0.08695187f, -0.01441804f, -0.05980773f, -0.10718032f, 0.16794498f, 0.10827991f, 
    0.03299661f, -0.23824464f, -0.05447546f, -0.17498305f, 0.73960435f, -0.14946158f, -0.31049091f, -0.54519778f, 
    -0.00978540f, 0.09500000f, 0.10618207f, -0.16229878f, 0.04042044f, -0.03146084f, 0.17137201f, -0.17251083f, 
    -0.45746046f, 0.07109737f, 0.22952791f, 0.15449238f, -0.27650300f, 0.07116581f, 0.16015805f, -0.02663499f, 
    -0.00109193f, 0.04225102f, -0.05091218f, -0.01612453f, 0.11995421f, -0.07299246f, -0.14706005f, 0.12494306f, 
    0.11400756f, 0.06666187f, -0.00316942f, 0.19029677f, 0.22596507f, 0.00265944f, 0.24966143f, -0.10613985f, 
    -0.08944847f, -0.37603232f, -0.52392918f, 0.15477438f, -0.15333578f, 0.25035298f, -0.03202203f, 0.29922658f, 
    0.01584035f, 0.04093385f, -0.01598862f, 0.00493072f, -0.91955179f, -0.12249331f, 0.32706788f, -0.21963137f, 
    0.08576594f, -0.26614541f, -0.40087456f, 0.26482967f, -0.13751669f, 0.04426382f, -0.07909779f, -0.02905034f, 
    -0.15706326f, -1.54407704f, -0.34134510f, -0.14065410f, 0.33624852f, 0.02150191f, 0.08342551f, -0.42752400f, 
    0.08378215f, 0.19096093f, -0.00626988f, 0.05051173f, -0.36319491f, -1.78425229f, -1.08515596f, -0.15006351f, 
    0.14385979f, -0.21946132f, -0.04694838f, -0.68701911f, -0.00097309f, -0.16947015f, 0.01024140f, -0.00243024f, 
    -0.34605715f, -0.21102579f, -0.27143541f, -0.18111189f, -0.03182846f, -0.10826927f, 0.05960487f, 0.06441195f, 
    -0.09104574f, 0.13066976f, -0.00417099f, 0.10700396f, -0.27108809f, -0.54875392f, 0.12762521f, 0.03585621f, 
    0.06048994f, 0.30126846f, -0.39145836f, -0.44769496f, 0.00563461f, -0.01011825f, -0.11753001f, 0.02414931f, 
    -0.26122710f, 0.50085950f, 0.23174478f, -0.44079146f, -0.08681493f, -0.12013601f, -0.03366186f, 0.00421889f, 
    0.15708688f, 0.11836386f, 0.09570346f, -0.04240435f, 0.26231217f, -0.04197915f, 0.02323470f, -0.08807594f, 
    -0.00417676f, -0.10773489f, 0.04076696f, -0.13531490f, -0.12686197f, 0.09509663f, 0.14062193f, -0.05591015f, 
    -0.17196377f, -0.18928112f, -0.03471374f, -0.49731949f, 0.04346848f, -0.29210931f, -0.02667024f, -0.00913526f, 
    0.08308529f, -0.02929165f, -0.11866072f, -0.02294088f, -0.22373804f, -0.21653566f, 0.26649868f, -0.16268684f, 
    -0.04931581f, 0.30031529f, 0.12917331f, 0.00564125f, -0.12600380f, -0.14471555f, 0.09302361f, 0.14498438f, 
    0.09074983f, 0.10615548f, 0.00791881f, -0.00020835f, 0.01866044f, -0.03696210f, 0.05386833f, -0.00173724f, 
    0.00819019f, -0.00359613f, 0.01351220f, 0.04878820f, 1.01994312f, -0.84238213f, -0.47989768f, -1.07413352f, 
    0.13688724f, -0.12216412f, -0.09857662f, -0.11446390f, 0.23221011f, 0.16968429f, 0.08654980f, -0.16331974f, 
    0.01422375f, -0.01165710f, 0.00721553f, -0.11529510f, -0.00715469f, -0.36582837f, -0.08437789f, 0.20807032f, 
    0.12201056f, 0.12021170f, -0.04708044f, -0.04789722f, -0.22896792f, 0.33864623f, -0.39444217f, -0.12754861f, 
    -0.10223470f, 0.04970168f, -0.02844472f, 0.17149253f, 0.11009678f, 0.08432125f, 0.04215518f, -0.08914068f, 
    0.21390669f, -0.31559971f, -0.30237925f, 0.03565101f, -0.04051780f, -0.16370198f, -0.07151698f, -0.00487410f, 
    0.07947688f, -0.03899302f, -0.11219797f, 0.13695398f, 0.07849153f, 0.08551652f, 0.11567482f, -0.07162365f, 
    -0.09295037f, 0.00874090f, 0.00028786f, -0.09354042f, -0.08145025f, -0.12913121f, -0.15788601f, -0.47054011f, 
    0.27946255f, -0.16697335f, -0.29152161f, -0.07401493f, -0.06849630f, 0.01468103f, -0.16876355f, 0.00274192f, 
    -0.11385894f, 0.11304496f, 0.03968423f, -0.05024831f, 0.89113683f, -1.05057144f, -0.61038792f, -0.27922913f, 
    -0.04267951f, -0.12096102f, -0.08436661f, 0.53087115f, 0.05431640f, 0.08351261f, 0.13563859f, 0.07867245f, 
    -0.19113982f, -0.65614527f, 1.19733763f, 0.06814867f, 0.12826259f, 0.18099746f, -0.08932397f, -0.06047403f, 
    -0.03168467f, -0.03606450f, -0.00355413f, -0.06415091f, -1.15667748f, 0.29537213f, -0.40747052f, 0.70449644f, 
    0.14502203f, 0.11786362f, -0.01042560f, -0.00185980f, 0.02052341f, 0.01557383f, -0.14412382f, -0.10690816f, 
    -0.61984932f, -0.45994845f, -0.06827096f, 0.11452293f, 0.04369446f, 0.23001125f, 0.17310891f, 0.20080495f, 
    0.08091189f, -0.20892020f, -0.00534343f, -0.16522248f, 1.53122580f, -0.04911065f, 0.22551078f, 0.06636462f, 
    0.41287479f, -0.00112911f, -0.09409675f, 0.18365662f, 0.33869419f, -0.08281431f, 0.50600809f, 0.04595771f, 
    -0.97472239f, -0.00417172f, 0.38590765f, 0.16928987f, -0.22285831f, 0.10043990f, -0.13571155f, -0.39474115f, 
    -0.12096583f, 0.00983086f, -0.01210274f, 0.00566734f, -0.02598727f, -0.13740060f, 0.08004393f, -0.40270370f, 
    0.07768375f, -0.00655980f, -0.08068173f, -0.22985482f, -0.26846606f, 0.05891485f, -0.04460086f, -0.27060282f, 
    0.08309762f, -0.70376027f, -0.96441966f, -0.28375995f, -0.22759455f, -0.02657524f, 0.14063190f, 0.01152343f, 
    -0.11778728f, -0.06395549f, -0.07498349f, -0.04927354f, -0.26033446f, 0.13682018f, 0.32573745f, 0.09976925f, 
    0.36238375f, 0.19203195f, 0.01751243f, -0.41145909f, -0.04861128f, -0.02148809f, -0.13765219f, -0.03141947f, 
    -0.47185877f, 0.06198119f, -0.04765143f, -0.08097612f, -0.04957585f, -0.08702610f, -0.04591063f, -0.03471087f, 
    -0.07882983f, -0.20993444f, 0.04629326f, -0.02798680f, 0.14419106f, -0.48575664f, -0.74566114f, -0.43738705f, 
    -0.06504238f, 0.03879088f, 0.06884236f, -0.01884883f, 0.23596559f, -0.02330792f, 0.14362296f, -0.27279094f, 
    -0.19278032f, 0.03327270f, 0.01866806f, 0.00131161f, 0.24249862f, -0.10192261f, 0.00435346f, 0.05132911f, 
    0.13502057f, 0.16466697f, 0.06637266f, 0.23704971f, -0.23877987f, 0.44209984f, 0.10149876f, 0.13557692f, 
    0.00500126f, 0.09439916f, -0.31205651f, 0.04157807f, -0.11878914f, 0.00646288f, 0.14000107f, 0.04480082f, 
    0.00516183f, -0.15367381f, 0.08662637f, 0.15047838f, 0.12779380f, 0.16534469f, 0.06698591f, 0.27871668f, 
    -0.51473659f, -0.05314853f, -0.25195944f, -0.54343104f, -0.13867307f, 0.40486681f, -0.02389956f, -0.14795034f, 
    -0.08056453f, -0.03921306f, -0.11704098f, -0.03836604f, 0.31035003f, 0.21460769f, 0.04598911f, 0.39245528f, 
    0.57935369f, 0.35754853f, 0.13672698f, -0.31326294f, 0.11465383f, -0.20422070f, -0.01196568f, 0.03015303f, 
    -0.08485043f, 0.03581769f, -0.13470219f, -0.02727252f, -0.28164002f, -1.03704166f, -0.72458613f, 0.40451390f, 
    -0.34956351f, 0.13728718f, 0.20446736f, -0.03261369f, -0.01908471f, 0.00199661f, -0.03222231f, 0.11020534f, 
    0.54304868f, -0.68049091f, -0.14371637f, -1.06219256f, 0.05863706f, 0.19856314f, -0.09107579f, -0.06733888f, 
    0.06872763f, 0.04346855f, 0.07035144f, 0.05093505f, -0.29745913f, -0.10413622f, 0.33720577f, 0.04294113f, 
    -0.01304688f, 0.13307604f, -0.12477578f, 0.03709494f, -0.07915344f, -0.06052516f, 0.18958248f, -0.00662143f, 
    0.12882757f, -0.11892281f, 0.82048756f, -0.65827554f, 0.03166631f, -0.61483848f, -0.28440741f, 0.02809286f, 
    -0.32545364f, 0.06497461f, 0.20119864f, 0.02638225f, 0.26549375f, -0.74540323f, 0.05262233f, -0.01180955f, 
    -0.13993573f, -0.15247954f, -0.39157671f, -0.62887323f, 0.00558767f, -0.07064377f, -0.14494699f, -0.09833538f, 
    0.52057379f, -0.82171649f, 0.32739517f, -1.11192179f, 0.16164565f, 0.02223463f, -0.04985656f, -0.02858177f, 
    -0.24467906f, -0.05350161f, -0.09799163f, 0.15661676f, -0.03237385f, -0.34383583f, -0.18491727f, 0.05173461f, 
    0.11045094f, 0.06833640f, 0.23793451f, -0.11127596f, 0.11971842f, -0.32022634f, -0.01270213f, 0.19444232f, 
    -0.58989882f, 0.03758346f, -0.19037245f, -0.42360422f, -0.23082946f, 0.01655965f, -0.02643293f, 0.06342673f, 
    0.23865081f, 0.08263557f, 0.18989657f, -0.05622489f, 0.05936214f, -0.35424292f, -0.39879578f, -0.02403053f, 
    0.10834107f, -0.11524978f, 0.15402052f, 0.42862651f, 0.08668081f, 0.31668720f, 0.11257132f, -0.09296283f, 
    -0.30516943f, -0.06911529f, -0.59115106f, 0.02148948f, 0.18138033f, 0.19842455f, 0.33753169f, 0.12815830f, 
    0.11041133f, 0.10587924f, 0.23875517f, 0.19438903f, -0.05286183f, -0.01913417f, 0.89551616f, 0.85846841f, 
    0.10040163f, -0.12107603f, -0.31074214f, -0.26820463f, -0.11343038f, -0.00175603f, 0.15636311f, 0.19076279f, 
    0.03362843f, -0.11534067f, -0.21924521f, -0.19676006f, 0.16218451f, -0.06616506f, 0.16498649f, -0.00173131f, 
    -0.03130973f, -0.22139747f, -0.33910015f, -0.15304656f, -0.09198921f, 0.31299025f, -0.73289150f, 0.13313602f, 
    -0.00921511f, 0.37169173f, 0.04602350f, 0.06762193f, 0.17662364f, -0.20985852f, -0.01687721f, -0.16472971f, 
    0.10361062f, -0.06512371f, 0.08472987f, 0.22715865f, -0.11729985f, -0.13442899f, -0.06877256f, -0.07875083f, 
    0.12261874f, -0.11322557f, 0.09878122f, 0.29168096f, 0.03436368f, 0.27118009f, 0.10511326f, 0.14718069f, 
    0.12625574f, 0.07142995f, -0.03888085f, -0.02760164f, 0.03227089f, -0.01489413f, -0.06140201f, -0.28968745f, 
    -0.09887280f, -0.03756997f, -0.44173804f, 0.29007807f, 0.08086421f, 0.28682846f, 0.04895848f, -0.20880125f, 
    -0.02676661f, -0.21664894f, 0.00166220f, 0.08000290f, 0.22345091f, -0.26175964f, -0.17451042f, -0.09325820f, 
    -0.08818112f, -0.08979189f, -0.16030557f, -0.30684218f, 0.01611299f, -0.16808166f, -0.07727068f, 0.07958233f, 
    0.37789804f, -0.53653824f, -0.00022707f, 0.16565605f, -0.59242707f, 0.25753656f, -0.06357890f, 0.06931359f, 
    0.05245959f, 0.11753984f, 0.02119601f, 0.01198927f, 0.10563651f, 0.40076017f, -0.47583479f, -0.03338880f, 
    0.06267408f, -0.17415217f, 0.21712264f, 0.08958301f, -0.06433180f, -0.01975348f, 0.12832488f, -0.06344980f, 
    -0.30080628f, 0.53774434f, -0.06193710f, 0.53196120f, -0.02582994f, 0.18306918f, -0.37774894f, 0.33747798f, 
    0.06709944f, 0.00718466f, -0.05157546f, -0.21356083f, -1.15478015f, 0.45097852f, 0.48049989f, 0.16379149f, 
    -0.19812427f, 0.12353451f, 0.77953202f, 0.41947630f, 0.05489291f, 0.06626052f, 0.08008768f, 0.00266247f, 
    -0.10325827f, 0.52914810f, 0.65964258f, 0.40819049f, -0.11597310f, -0.15830651f, -0.24498843f, 0.06666487f, 
    -0.00805499f, 0.00227630f, 0.05194421f, 0.01513741f, -0.96953070f, 0.68298817f, -0.26326719f, -0.25090683f, 
    -0.11071547f, -0.19241661f, -0.38490528f, 0.20111489f, -0.21684247f, -0.00950639f, 0.13245471f, -0.26971141f, 
    0.40512002f, -0.42125744f, -0.22910614f, 0.05049480f, -0.15123773f, 0.02171241f, 0.06672651f, 0.23217356f, 
    -0.04163038f, 0.14076298f, 0.09100360f, -0.08780240f, -0.01758231f, 0.28041217f, -0.52396297f, -0.18150201f, 
    0.03720520f, 0.05337999f, 0.01234091f, -0.05449103f, -0.04883871f, -0.10087183f, -0.06100426f, -0.18712607f, 
    0.31855771f, -0.72867745f, -0.57021612f, -0.73805672f, -0.43275121f, -0.30264935f, 0.08292343f, -0.16380785f, 
    -0.27501795f, 0.14244336f, -0.04945285f, -0.15507817f, -0.41670156f, 0.33471265f, -0.39542347f, -0.39963967f, 
    0.24421456f, -0.02391842f, -0.02364914f, -0.01475409f, -0.11150154f, -0.16807409f, -0.40127814f, -0.15626603f, 
    -0.31813017f, 0.61718309f, -0.02350046f, 0.12988307f, -0.03396419f, -0.09029815f, 0.42456907f, 0.24481422f, 
    -0.07024689f, 0.23894510f, 0.33936676f, 0.45927507f, 0.14285530f, -0.80302036f, 0.11857709f, -0.12375037f, 
    -0.11412819f, 0.14811251f, 0.34417477f, -0.16834319f, -0.24942221f, 0.05904998f, 0.04082280f, 0.10283592f, 
    0.05177680f, 0.02896882f, -0.04911799f, -0.28954718f, 0.12203522f, -0.01972236f, -0.19146830f, 0.11707671f, 
    -0.11397740f, -0.06227844f, -0.36831203f, -0.86411202f, -0.32316640f, -0.24425863f, 0.42611784f, -0.46897265f, 
    -0.34521559f, -0.13691157f, 0.20739006f, -0.04939120f, -0.27894056f, 0.06132521f, 0.21121469f, 0.19653378f, 
    -0.15195265f, 0.13995293f, -0.31456620f, -0.21916743f, -0.45257533f, -0.12832996f, 0.30896941f, 0.00808571f, 
    -0.23813754f, 0.06900445f, -0.21948342f, 0.25068402f, -0.18475862f, 0.18109258f, 0.14592288f, 0.29169369f, 
    0.03207903f, -0.32299635f, 0.08462629f, 0.15172784f, -0.04142316f, 0.33392006f, 0.11148758f, -0.06587238f, 
    -0.41597745f, -0.30835062f, -0.75312901f, 0.24215624f, 0.18629074f, -0.13645813f, -0.06864924f, 0.42469141f, 
    0.22139524f, 0.04559357f, -0.24518168f, -0.03786301f, -0.03806308f, -0.31185496f, -0.15360595f, 0.07689863f, 
    0.07143111f, 0.14436105f, 0.17410639f, -0.12783785f, -0.07115421f, -0.03126637f, -0.02294280f, 0.09133806f, 
    -0.68023700f, -0.40634102f, 0.56035912f, 0.20279175f, -0.01621361f, -0.04278943f, 0.10066370f, 0.29265276f, 
    -0.22639376f, 0.00181144f, -0.22620428f, -0.13923988f, -0.29997751f, 0.67084026f, -0.25867972f, -0.21172586f, 
    0.49867940f, -0.43857491f, 0.89387763f, -0.44200736f, 0.20251359f, 0.46124282f, 0.05943906f, 0.30904797f, 
    0.37565291f, 0.52330905f, -0.27858409f, 0.20752011f, -0.01219152f, 0.07289824f, -0.08632387f, 0.27128127f, 
    -0.14027081f, 0.02474320f, -0.01701242f, -0.10402805f, 0.22926883f, -0.12208605f, -0.37775457f, 0.51961124f, 
    0.13379087f, -0.13033214f, 0.12945232f, 0.50426298f, 0.04000480f, -0.09418651f, -0.12701581f, 0.19850700f, 
    -0.16954133f, 0.08976831f, 0.03441211f, -0.61040509f, -0.26044965f, -0.11267424f, 0.36944100f, -0.14457440f, 
    0.03438665f, 0.05110120f, 0.00927206f, -0.04550107f, -0.16631858f, -0.19674265f, -0.06422211f, 0.01846857f, 
    -0.35379902f, -0.41229892f, 0.05301896f, -0.04645761f, 0.13437702f, 0.19808573f, -0.04745857f, 0.09200217f, 
    0.53400636f, -0.01702972f, -0.14677054f, -0.44136012f, -0.09790327f, 0.06976607f, -0.28865698f, 0.22764485f, 
    -0.15890332f, 0.21228781f, -0.08438805f, -0.20087765f, -0.45750633f, -0.43426833f, -0.80855042f, 0.05663384f, 
    0.03766797f, -0.16408390f, 0.01564633f, -0.33950177f, -0.15202473f, 0.05469859f, 0.22754134f, 0.18705849f, 
    0.41319194f, 0.06325519f, 0.33348042f, 0.24064338f, 0.01826060f, 0.35477808f, -0.12942092f, 0.12031384f, 
    -0.12973221f, -0.40113503f, -0.09927037f, -0.40377519f, 0.22076908f, 0.30961257f, 0.56386733f, 0.05111669f, 
    -0.25445101f, -0.15023498f, 0.18585852f, -0.02098188f, -0.37834087f, -0.08989061f, 0.00964368f, 0.12318116f, 
    0.31783956f, 0.25518653f, -0.06219725f, -0.06472319f, 0.00587939f, -0.38115785f, 0.01301501f, -0.02870787f, 
    -0.06374099f, 0.08851002f, 0.16340421f, 0.16617322f, -0.35901651f, -0.09569252f, -0.26096177f, 0.08722389f, 
    0.17463472f, 0.04596044f, 0.20417970f, 0.16681224f, -0.04430930f, 0.07508185f, 0.10011968f, -0.18396172f, 
    0.31601581f, -0.09450486f, 0.33688667f, -0.52901858f, 0.05636609f, 0.07900879f, 0.03467068f, 0.04942861f, 
    -0.21808898f, 0.02829349f, 0.09780416f, -0.27421623f, -0.35734695f, 0.69381899f, -0.27153757f, -0.34851006f, 
    0.17154592f, -0.03184049f, 0.00796131f, 0.05193858f, -0.11885590f, -0.11782341f, -0.10065322f, -0.11591288f, 
    -0.06836659f, -0.42491916f, -0.32060817f, 0.75548011f, 0.08958801f, -0.39669475f, 0.14279941f, -0.28273708f, 
    -0.08395130f, 0.12416070f, -0.04553971f, -0.00118986f, 0.04163378f, -0.29589972f, 0.21112461f, -0.10586846f, 
    -0.01278766f, -0.38404050f, -0.09045732f, -0.18947679f, 0.17301379f, -0.22202641f, -0.22819407f, 0.16790926f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.34935430f, 0.13867380f, 0.15073608f, -0.10767969f, -0.26583406f, 0.12665302f, 0.10510466f, -0.16223118f, 
    0.17440817f, 0.03970509f, 0.05497449f, -0.03882443f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
