#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12503116f, 0.44146711f, -0.54737544f, -0.77831537f, -0.54659986f, -0.51851946f, 0.98170799f, 0.91811889f, 
    0.54520679f, -0.56187308f, -1.05739141f, -0.41448584f, -0.59379327f, -0.95289516f, -0.90306914f, -0.70678413f, 
    -0.45822591f, -0.27551290f, 1.02668214f, -0.07298241f, 0.05885625f, 0.75866801f, -0.22997937f, 0.70866221f, 
    -0.36852467f, 0.46910608f, -1.03963614f, 1.07220960f, 0.84440643f, 0.76829320f, -0.32364523f, -0.03377490f, 
    -0.14544205f, 0.41101804f, -0.74996603f, -0.46517512f, 0.13188720f, 0.35278732f, 0.48029673f, 0.23885721f, 
    0.22249018f, -0.75052083f, -0.56988311f, 0.12503006f, 1.21127391f, -0.72266650f, -0.17749633f, -1.02949727f, 
    -1.04573882f, -0.86816716f, -0.89606929f, 0.08782878f, -0.54031837f, 0.47592464f, -1.54747915f, 1.91937923f, 
    -1.11543548f, 0.19191302f, 0.09281516f, 0.07507950f, -0.03688722f, -0.03169575f, 0.10612483f, -1.67330611f, 
    -0.62865144f, -0.84279162f, 0.44812104f, -0.04655917f, -0.42084628f, -0.31960991f, -0.45623559f, -0.75182414f, 
    -0.89234680f, 0.47282854f, -0.53966516f, 0.83566958f, 1.04841781f, 0.67131937f, -0.22438952f, -0.03516601f, 
    -0.04519658f, 1.69959342f, -0.75271273f, 1.61105371f, -0.19908755f, -0.62308705f, 0.14738306f, 0.09304427f, 
    -0.04915690f, 0.06171771f, 0.70910054f, -0.19871263f, 0.27138582f, -0.33796224f, 0.95602423f, -0.75301898f, 
    0.39725804f, -0.17685159f, -0.85438359f, 1.34470141f, -0.44020206f, -0.00788289f, -1.11914992f, -0.95202744f, 
    -1.08908391f, -0.21727264f, 0.25267479f, -0.33406642f, 0.61468661f, -0.48643374f, -0.12264965f, 1.01138854f, 
    -0.34361300f, -0.44806334f, -0.24998561f, 0.20206466f, 0.13766290f, -1.25457120f, -1.14130950f, -1.56411099f, 
    0.80401880f, 0.02424966f, 0.28973225f, 0.37881324f, 0.38079029f, 0.51278597f, 0.01450042f, -0.27943766f, 
    0.42971665f, 1.07171547f, 0.55330950f, 0.27771354f, 0.92137533f, -0.37021500f, 0.29993409f, 0.84313661f, 
    -0.56858373f, 0.58871216f, -1.31332219f, 0.56020421f, 0.13806790f, -0.60046077f, 0.01222214f, 0.68372661f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.71497691f, 0.05865364f, 0.09090743f, 0.09511609f, -0.00240347f, -0.63252324f, -0.14743462f, 0.17738421f, 
    0.96206218f, 0.84255165f, 0.51640707f, 0.13820393f, 1.04253089f, 0.73982173f, -0.33806604f, 0.04276535f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.15869497f, 0.04699411f, 0.04811251f, 0.25975707f, 0.13189000f, -0.21940275f, -0.33581299f, -0.71817315f, 
    -0.75353217f, -0.15421931f, 0.13799331f, 0.46555564f, -0.05149059f, 0.33041891f, 0.05084160f, 0.04028675f, 
    0.07134055f, 0.17746316f, -0.14220615f, 0.34197605f, -0.10713078f, 0.04432135f, 0.09559000f, 0.17503364f, 
    0.38930935f, 0.11425861f, -0.14496008f, 0.18638191f, 0.49629050f, 0.07840009f, 0.08652149f, 0.03494341f, 
    0.08971632f, 0.28003058f, 0.16019073f, -0.04784236f, 0.22815238f, 0.21458693f, 0.03028348f, 0.16533533f, 
    0.32001153f, 0.06387025f, 0.04477619f, -0.27041084f, -0.15780364f, -0.31109211f, -0.23822315f, -0.14391421f, 
    0.23374493f, 0.20957582f, -0.08756462f, -0.18660156f, -0.29237902f, -0.17083277f, 0.00710544f, -0.55099648f, 
    -0.34734628f, 0.35101017f, -0.37702101f, -0.11525684f, 0.07032005f, -0.22012059f, 0.30178636f, -0.08523139f, 
    -0.10785327f, 0.13452052f, -0.11365537f, 0.06774591f, 0.17514949f, 0.22905457f, 0.10498212f, 0.43063623f, 
    -0.05832905f, 0.01685492f, 0.01067764f, 0.09158917f, -0.08558231f, 0.38662687f, 0.04918280f, 0.03358026f, 
    -0.08179677f, 0.26022831f, 0.39930335f, -0.39041904f, -0.04889194f, -0.08789959f, -0.10666247f, 0.23524348f, 
    0.04677315f, -0.16887590f, -0.31898624f, 0.04052990f, -0.34501326f, 0.11315759f, -0.01211345f, 0.16075893f, 
    0.32113171f, -0.00438157f, -0.09386938f, 0.48125401f, 0.50818568f, 0.12757304f, 0.29691133f, 0.07634397f, 
    0.14548679f, 0.10160892f, 0.00693476f, 0.14883716f, 0.02742535f, -0.18032922f, 0.40644827f, -0.02575716f, 
    0.07663683f, -0.02365849f, -0.28093526f, -0.14904228f, -0.00317812f, 0.35174108f, -0.05289516f, 0.30276188f, 
    0.09986252f, -0.13126962f, -0.34403259f, 0.10647961f, -0.10128145f, -0.14352182f, -0.13824895f, -0.00146328f, 
    0.06270616f, 0.21636799f, 0.22173223f, 0.12310587f, -0.37791634f, -0.31744447f, -0.76312596f, -0.12338895f, 
    0.15783019f, -0.09876575f, 0.23010641f, 0.00870461f, -0.17746712f, 0.27784619f, -0.32194018f, -0.25999337f, 
    0.34273326f, 0.14351089f, 0.05160360f, -0.03698100f, 0.03781348f, -0.16138360f, -0.09231792f, 0.02042037f, 
    -0.32429001f, 0.29978910f, 0.10649138f, 0.22036575f, 0.14596558f, 0.19521300f, 0.07041118f, 0.15476096f, 
    0.13360727f, -0.11540254f, 0.05125207f, 0.16855840f, -0.41265285f, -0.14588979f, 0.09139429f, -0.13964969f, 
    0.04536303f, -0.27459589f, 0.31140223f, 0.35617054f, -0.08831594f, 0.05143746f, 0.17389408f, 0.11600897f, 
    -0.08377066f, -0.05734299f, -0.02289048f, 0.05314723f, 0.24243341f, -0.38326672f, -0.11704780f, -0.12070125f, 
    -0.08700149f, 0.04638012f, 0.00829643f, 0.02855545f, -0.01565169f, 0.04210250f, 0.16159093f, 0.46222273f, 
    0.07810742f, -0.21351703f, -0.05004498f, -0.09078255f, -0.16456600f, 0.04966947f, -0.88409954f, 1.26679873f, 
    -0.21472265f, -0.10275845f, -0.50128716f, 0.23040506f, 0.09279873f, -0.02497466f, 0.26877192f, -0.38106287f, 
    0.08604271f, 0.31849310f, 0.22194767f, -0.08620542f, 0.28124756f, -0.16173556f, 0.06801838f, -0.00408938f, 
    -0.81512314f, 0.22627442f, -0.70063359f, -0.15422896f, 0.00579912f, 0.10322656f, 0.12782088f, 0.08579918f, 
    0.19702959f, 0.42883009f, -0.54051977f, -0.98835105f, 0.11544494f, -0.04687933f, 0.21229339f, -0.02592596f, 
    -0.20405982f, -0.09823331f, 0.36572203f, -0.29567617f, 0.28972074f, 0.27057010f, -0.01112078f, -0.02737102f, 
    0.16692530f, 0.06024205f, 0.15142320f, 0.09053749f, 0.13384877f, -0.24744944f, 0.02012345f, 0.06093688f, 
    -0.17364182f, 0.12299104f, 0.04595098f, 0.05535659f, 0.00161328f, 0.07499406f, -0.34354061f, -0.27378750f, 
    0.23662914f, 0.00889089f, -0.03036236f, -0.07073779f, -0.19053054f, -0.26223549f, 0.18916337f, 0.00784849f, 
    0.18019882f, -0.02834939f, 0.15649150f, -0.14811873f, 0.10818266f, -0.00283014f, -0.11060678f, 0.11338528f, 
    -0.22317509f, 0.22087812f, -0.29932532f, -0.00898226f, 0.21815558f, 0.02722773f, 0.23522905f, 0.31978795f, 
    -0.13676690f, -0.48047686f, 0.49255002f, -0.13166298f, 0.01446496f, -0.01867253f, 0.32588908f, 0.11358986f, 
    0.03200014f, 0.01617197f, 0.01437683f, -0.00239442f, -0.05115671f, 0.02192925f, -0.02040783f, -0.06693045f, 
    -0.05827314f, 0.03758994f, 0.04921255f, -0.09613933f, -0.01148591f, 0.00882409f, -0.02661552f, 0.06217655f, 
    -0.05083331f, -0.07458988f, -0.01214743f, -0.05772638f, -0.07887315f, -0.07060443f, 0.07618548f, -0.07381491f, 
    -0.00513759f, 0.03607870f, -0.04955598f, -0.02330074f, 0.04572018f, -0.00300667f, -0.06302834f, -0.00230501f, 
    -0.08342241f, 0.00987358f, -0.05979529f, -0.04431518f, 0.03313129f, 0.01806986f, 0.02685987f, -0.07794379f, 
    -0.08611840f, 0.01701594f, 0.02980830f, 0.02071771f, -0.07092570f, 0.04609197f, -0.04188512f, 0.04559511f, 
    0.04824832f, -0.04656111f, 0.06134092f, -0.00645712f, -0.08444463f, -0.05234560f, 0.05218131f, -0.02662534f, 
    0.07948963f, 0.06296264f, -0.01932558f, 0.02134603f, -0.01788388f, -0.06766406f, 0.04027940f, -0.04849180f, 
    -0.07803543f, -0.06639989f, 0.02985688f, 0.01922328f, 0.05929906f, 0.02205273f, -0.04181597f, -0.07343521f, 
    -0.06330925f, -0.07483134f, -0.02147703f, -0.06699595f, 0.01347241f, -0.06543133f, -0.00277399f, -0.08590708f, 
    0.02754479f, -0.06397758f, -0.06176416f, -0.00921248f, -0.00312079f, 0.07472963f, -0.07899073f, 0.04929733f, 
    -0.06288254f, 0.06053680f, 0.04586675f, -0.07602502f, 0.01595309f, 0.01017171f, -0.02608183f, -0.07469473f, 
    -0.04982146f, -0.03083102f, 0.05276967f, 0.05466644f, -0.06162158f, 0.00258578f, 0.04674312f, 0.01595474f, 
    0.04235248f, -0.05661310f, -0.03899364f, 0.02239162f, -0.07812557f, -0.04398938f, -0.03114574f, 0.05944181f, 
    0.00218780f, -0.00738134f, 0.01420444f, 0.02694558f, -0.08674189f, 0.02817826f, -0.08123101f, -0.00752691f, 
    -0.06286056f, -0.04635881f, -0.05172410f, -0.02002498f, -0.01302510f, 0.04545761f, -0.05307906f, -0.02381025f, 
    0.00349982f, -0.09176309f, 0.03656377f, -0.06238669f, -0.01181668f, -0.10179955f, 0.00377966f, 0.07518931f, 
    -0.08763127f, -0.05713996f, -0.06460494f, -0.03168811f, -0.02978477f, -0.08908605f, 0.05692983f, 0.01414459f, 
    -0.06782154f, -0.33710620f, 0.17415468f, -0.06754771f, 0.01942984f, 0.09902225f, 0.30737552f, 0.13046008f, 
    0.13979107f, 0.32299796f, -0.04093194f, -0.07819725f, -0.19635604f, -0.26558882f, 0.13838483f, 0.12263176f, 
    0.07680341f, -0.05481170f, -0.74454606f, -0.28445017f, 0.33409920f, -0.14234492f, -0.00997408f, 0.02770013f, 
    -0.16482982f, 0.00709869f, 0.29018232f, -0.16441892f, 0.32817525f, 0.29775211f, -0.04516491f, -0.12159827f, 
    -0.24346530f, -0.05614584f, 0.00258403f, 0.18968917f, 0.09306683f, 0.20379123f, 0.21180739f, -0.11612740f, 
    0.01023122f, 0.04069907f, 0.12816136f, -0.17153767f, 0.01226760f, -0.25623518f, -0.24476343f, -0.13058199f, 
    -0.48471764f, -0.23610219f, -0.34423509f, -0.03006240f, 0.00106426f, 0.15000965f, 0.01858276f, -1.39315224f, 
    -2.04926419f, 0.29192245f, -0.23134908f, 0.15448263f, 0.36248258f, 0.11323967f, -0.42379484f, 0.06268676f, 
    -0.11330500f, -0.91271311f, -0.10120922f, 0.08352800f, 0.11410473f, -0.02814089f, 0.01004241f, -0.04924804f, 
    -0.18921027f, -0.14165485f, -0.23586614f, -0.02937309f, 0.08573943f, -0.09491464f, -0.06026551f, -0.39586255f, 
    0.06194283f, 0.96171969f, 0.33837226f, 0.06698418f, -0.02802528f, 0.07926033f, -0.09316419f, 0.20998295f, 
    0.22501057f, -0.05938295f, -0.44260693f, -0.09942375f, 0.16186206f, -0.03427763f, 0.29379192f, -0.05683138f, 
    -0.05230919f, 0.29439986f, 0.24729700f, 0.39083654f, -0.05732557f, 0.44404355f, 0.05724735f, -0.00035426f, 
    0.25637648f, -0.07331806f, 0.15168805f, 0.01982830f, -0.31701547f, -0.10936230f, 0.31654108f, -0.17658833f, 
    0.09658942f, 0.37405026f, 0.21469642f, 0.08514807f, -0.25542724f, 0.16828094f, -0.90822315f, -0.77178329f, 
    -0.22001719f, 0.02872393f, 0.11140239f, 0.20376596f, -0.24229629f, -0.13802090f, -0.26149645f, -0.07126828f, 
    -0.24088563f, -0.20327790f, 0.13063133f, -0.22260405f, 0.55396461f, -0.12593846f, 0.04633596f, 0.52879703f, 
    0.43943557f, 0.00010621f, 0.14843155f, 0.20257205f, 0.01696973f, -0.02226113f, -0.04497832f, 0.03116681f, 
    -0.19522470f, 0.06703821f, -0.10004567f, 0.13439457f, 0.10020029f, 0.19119215f, 0.31435525f, 0.37389609f, 
    0.09220294f, -0.00668849f, 0.25713423f, -0.12935174f, 0.28104246f, -0.03839888f, 0.11262604f, -0.15115106f, 
    0.19397849f, -0.14770629f, 0.32733807f, -0.04856906f, -0.19538765f, -0.11318832f, 0.16400205f, 0.10065351f, 
    -0.20599797f, -0.34502840f, -0.43121845f, 0.08997890f, -0.15923023f, 0.16354205f, 0.06753518f, 0.12429118f, 
    0.07481094f, 0.25345320f, 0.20355381f, 0.19268164f, -0.04269816f, -0.32411000f, 0.23706369f, -0.09301504f, 
    -0.09159832f, -0.00550747f, 0.28353268f, 0.00724868f, 0.10830659f, -0.28854209f, 0.46911573f, 0.22790003f, 
    0.03949423f, -0.16506396f, 0.18132481f, 0.14389162f, -0.00471925f, -0.09524190f, -1.23722458f, -0.29447505f, 
    -0.37168667f, 0.38329217f, -0.31205505f, -0.22299303f, 0.41106731f, -0.32547486f, -0.18478324f, -0.13405602f, 
    0.37965077f, 0.09920811f, -0.13377650f, -0.33626276f, -0.17579572f, -0.36816812f, -0.20923668f, -0.31347018f, 
    -0.01196939f, 0.15282492f, -0.07821837f, 0.17250775f, -0.05785150f, 0.47794083f, -0.01038802f, -0.13765469f, 
    0.01807113f, 0.36385149f, -0.04033573f, 0.01662534f, 0.04361206f, -0.03953024f, 0.21710575f, 0.21318558f, 
    0.01007322f, -0.05233138f, 0.10128747f, -0.24383105f, 0.09546989f, 0.02698166f, 0.28998134f, 0.01292111f, 
    -0.24550812f, 0.08246629f, -0.22516954f, -0.02312160f, -0.84796828f, -0.86975336f, 0.11107326f, 0.17711124f, 
    0.08156389f, -0.09833254f, -0.06622277f, -0.12435682f, 0.38870755f, -0.17511499f, 0.03737615f, 0.04917902f, 
    0.30459878f, 0.31656694f, 0.50901240f, -0.06595372f, 0.24583913f, -0.60235423f, 0.32168630f, -0.26963249f, 
    -0.09835104f, -0.05196250f, -0.11584553f, 0.16922781f, 0.28295606f, 0.15520920f, 0.12814495f, 0.04100811f, 
    0.14664613f, 0.19798034f, 0.15495700f, 0.06647853f, 0.07421649f, -0.26210734f, -0.14786269f, 0.22690614f, 
    -0.31203201f, -0.39856425f, -0.00417691f, -0.01917701f, 0.11317205f, 0.26761886f, -0.04142427f, 0.04483327f, 
    0.64253360f, 0.43944150f, 0.09677336f, -0.07910921f, 0.09442759f, -0.05595982f, 0.13953312f, 0.08258380f, 
    -0.01497154f, 0.21449272f, 0.21187969f, 0.21293770f, 0.24054229f, 0.24203897f, 0.03634018f, 0.08221899f, 
    -0.14663665f, -0.11524164f, -0.27731773f, -0.39680278f, 0.36223400f, -0.10560296f, -0.10782690f, -0.07761022f, 
    -0.04221381f, -0.09515621f, 0.08892174f, -1.02537012f, -0.54286194f, 0.41436636f, 0.08626116f, 0.06492752f, 
    -0.07757144f, 0.05437732f, -0.17572679f, -0.04159608f, -0.02092090f, -0.27881193f, -0.18051763f, 0.28669488f, 
    0.22520375f, 0.31232131f, 0.08671603f, 0.26008704f, -0.10819626f, 0.57620037f, 0.36962512f, 0.42706582f, 
    0.12054753f, -0.25151005f, -0.08588519f, 0.10258003f, -0.13734588f, -0.06919895f, -0.15058374f, 0.10925042f, 
    0.12026846f, 0.24395156f, -0.03819310f, -0.02004259f, 0.13828406f, 0.20520666f, 0.11561182f, 0.64345247f, 
    0.20133232f, -0.40484002f, 0.19018793f, 0.03915074f, 0.34319276f, 0.05825144f, -0.00554778f, 0.06468435f, 
    0.62588441f, 0.08885703f, -0.15146153f, -0.04517234f, -0.31046882f, -0.03853454f, -0.00564868f, -0.00102217f, 
    -0.14235038f, -1.11781633f, -0.56213087f, 0.31628346f, -0.02633123f, 0.37765431f, -0.12660094f, -0.04860144f, 
    -0.00264949f, -0.07508056f, -0.51499408f, -0.12146402f, 0.06484269f, 0.01186043f, 0.17115308f, 0.17299640f, 
    -0.09711273f, -0.09597570f, 0.33302566f, -0.55927247f, 0.00337338f, 0.38680920f, -0.44167000f, 0.05112042f, 
    0.07776079f, -0.00107362f, 0.08327347f, 0.25467700f, -0.44989690f, 0.08618299f, -0.33201253f, -0.01369619f, 
    0.06486183f, -0.10708379f, -0.05877260f, 0.15759574f, -0.02702374f, -0.09530934f, -0.12388484f, -0.35271427f, 
    -0.05044183f, 0.01455892f, 0.07786029f, -0.24886605f, -0.04579670f, 0.02598613f, -0.00289855f, 0.23099521f, 
    -0.01895573f, 0.16279992f, -0.00422867f, -0.17769977f, 0.18589556f, 0.24999602f, -0.05254170f, -0.35166135f, 
    -0.11299782f, 0.45831817f, -0.08286958f, -0.08518990f, -0.20165041f, 0.04654026f, 0.22221230f, 0.02786485f, 
    -0.06526361f, -0.09585334f, -0.05594037f, 0.00409066f, -0.03949865f, -0.04617570f, 0.00556465f, -0.07309069f, 
    0.02250290f, 0.02370978f, -0.02421627f, -0.05717849f, 0.00631465f, -0.03144662f, -0.06502305f, -0.07198285f, 
    0.03042772f, 0.05287189f, -0.00755041f, 0.04460552f, -0.04092027f, 0.03123447f, 0.04607327f, -0.03451136f, 
    0.05705076f, 0.04760885f, -0.09066127f, 0.05584405f, -0.02121412f, 0.02993748f, -0.05845097f, -0.06745412f, 
    -0.01010101f, -0.04332453f, 0.01680948f, 0.04238591f, -0.04098231f, -0.04123478f, -0.09247130f, -0.01618528f, 
    -0.01168657f, 0.02187935f, -0.03090713f, -0.01344278f, -0.08753987f, -0.09191322f, -0.02620913f, 0.02451990f, 
    -0.01154349f, -0.04523006f, -0.07432017f, -0.03571166f, -0.07511015f, -0.02285445f, 0.01045813f, 0.02408080f, 
    -0.07051093f, -0.01648895f, -0.07439460f, 0.01337188f, -0.07451697f, 0.04275194f, 0.02902259f, -0.04084555f, 
    0.03925961f, -0.06350274f, -0.06496008f, -0.06581852f, -0.03183205f, 0.06795903f, -0.06026164f, 0.01638814f, 
    -0.10219157f, -0.03595515f, -0.01948581f, 0.04698794f, 0.03280458f, -0.09421014f, -0.10288683f, 0.03378934f, 
    -0.08276018f, -0.03371447f, -0.00967276f, 0.01350402f, -0.03674377f, -0.09803496f, 0.03310260f, -0.06296804f, 
    -0.03894952f, -0.05271140f, 0.03298346f, 0.03241330f, -0.07177833f, 0.00295460f, 0.01061211f, -0.08387304f, 
    -0.10445402f, -0.00366571f, -0.07220548f, -0.05864685f, -0.02521057f, -0.04817422f, 0.05263289f, -0.08325614f, 
    0.02193388f, 0.01149435f, -0.03803319f, 0.00222374f, -0.08502647f, -0.08891629f, -0.06378996f, -0.01948917f, 
    -0.00401193f, -0.03081735f, -0.09307537f, 0.05206747f, 0.05035770f, 0.02183368f, 0.03064870f, -0.09549814f, 
    -0.03319785f, -0.01091457f, -0.07845567f, -0.04433639f, -0.03096833f, -0.06119394f, -0.01300782f, -0.02714447f, 
    0.00515840f, -0.01538560f, 0.04832954f, 0.02746433f, -0.02292332f, 0.04067743f, -0.05580360f, 0.04948511f, 
    -0.00609340f, -0.05649996f, 0.01838873f, -0.00509672f, 0.06529005f, -0.07855177f, 0.01165722f, 0.00484913f, 
    0.07318345f, -0.04962641f, -0.00338801f, -0.07744765f, -0.06947225f, -0.08447829f, 0.00188300f, -0.04356271f, 
    -0.01941820f, 0.01510391f, -0.01351521f, 0.03191265f, -0.05593681f, 0.02339453f, -0.01467570f, 0.00461892f, 
    0.02434197f, -0.01782216f, -0.02752422f, -0.03312903f, 0.01770870f, -0.07524789f, -0.08138031f, -0.02579481f, 
    0.04262558f, 0.04781453f, -0.06920775f, 0.01872214f, 0.00032673f, -0.01963140f, 0.07013287f, 0.02158221f, 
    -0.04675901f, 0.03186043f, -0.01432641f, 0.02032416f, 0.00926273f, 0.01054599f, 0.02176647f, 0.06972184f, 
    -0.02082331f, -0.00123534f, -0.07996679f, -0.02662443f, 0.04393458f, -0.03571028f, 0.01512887f, 0.01487624f, 
    -0.05223799f, -0.03175500f, 0.03027021f, -0.04181141f, -0.04459362f, -0.02674834f, -0.04972097f, -0.07126955f, 
    -0.02160443f, -0.07895580f, -0.05937908f, -0.06252916f, 0.03102322f, 0.04997284f, -0.00261831f, 0.04331010f, 
    -0.04631523f, 0.05293023f, -0.02261510f, -0.01987825f, -0.00777844f, 0.05734904f, -0.06260565f, -0.06989619f, 
    -0.08841724f, 0.00747307f, 0.00715201f, 0.02029800f, 0.04247874f, -0.00609388f, -0.06342144f, -0.00306042f, 
    0.04563474f, -0.02361898f, -0.08437619f, -0.02511462f, -0.03102586f, -0.00256459f, -0.07468335f, -0.01247476f, 
    -0.08750340f, -0.06855635f, -0.02053102f, -0.07287329f, -0.02671183f, -0.00261801f, 0.04316337f, -0.05501430f, 
    -0.08072045f, -0.02588468f, 0.00641067f, 0.04975283f, -0.01191190f, 0.06725484f, -0.03840017f, -0.08873271f, 
    -0.04345296f, 0.06553139f, -0.05740475f, 0.06498095f, -0.05608463f, 0.03648888f, 0.05214205f, 0.00857665f, 
    0.05822824f, -0.00282309f, -0.06485425f, -0.07346123f, -0.00607769f, -0.06507766f, -0.01403104f, 0.05771415f, 
    -0.08910512f, 0.01378351f, 0.05096800f, 0.01401517f, -0.08011353f, 0.06866116f, -0.02909078f, 0.03110811f, 
    -0.01466705f, 0.07256193f, -0.01411807f, -0.04032351f, -0.04835513f, -0.06963162f, 0.01484156f, -0.04324573f, 
    0.03484260f, 0.05565701f, -0.02358179f, -0.01537329f, 0.04607562f, 0.03176492f, 0.04337330f, -0.07181633f, 
    0.06475811f, -0.35534948f, 0.03866134f, 0.19908600f, 0.03852696f, 0.31334642f, 0.06462244f, 0.00411444f, 
    0.19112435f, 0.02492232f, 0.08109949f, 0.01285544f, -0.05378833f, -0.05306363f, -0.11603637f, 0.07701648f, 
    0.00580357f, -0.06523017f, 0.05585537f, 0.18834507f, 0.31869617f, -0.17727876f, 0.09340785f, 0.11878806f, 
    -0.13620822f, 0.06748303f, 0.09825482f, 0.04023051f, 0.18258934f, 0.16847172f, 0.00484722f, -0.06068344f, 
    -0.08130881f, -0.06909090f, -0.02499124f, 0.19381796f, 0.00124619f, 0.27912372f, 0.00926760f, -0.03570494f, 
    -0.00589704f, -0.07691764f, 0.40029714f, 0.17363830f, -0.01550318f, -0.02702262f, 0.37459680f, -0.48580578f, 
    -0.08471452f, 0.05925807f, -0.16170232f, 0.18885174f, 0.11592550f, -0.27528656f, -0.08585422f, 0.15261997f, 
    -0.32456663f, -0.10614882f, -0.35703060f, 0.51137793f, 0.26694253f, -0.31142354f, 0.18648194f, -0.28301662f, 
    0.21291827f, 0.17509057f, 0.06382339f, -0.10172638f, -0.29857999f, 0.04258042f, -0.02755133f, -0.03312977f, 
    0.14495042f, -0.04376766f, -0.34543219f, -0.03959381f, -0.37510824f, -0.41740185f, 0.04468970f, -0.52313608f, 
    -0.06925456f, 0.12244167f, -0.03043350f, -0.00332399f, -0.11612608f, 0.21933626f, 0.27449813f, -0.05576626f, 
    0.28675783f, 0.22068016f, -0.02128332f, -0.05643835f, 0.27747455f, 0.03242784f, 0.31009635f, -0.04843374f, 
    0.22795163f, 0.21624082f, 0.24062827f, -0.78913271f, -0.98914486f, -0.20407002f, 0.02480663f, 0.13785741f, 
    0.06824762f, -0.09850700f, -0.01803100f, 0.02804933f, 0.41234744f, 0.52719235f, 0.56331056f, -0.19188878f, 
    0.09661032f, 0.20549980f, 0.14777872f, 0.21827449f, 0.37456176f, -0.25181615f, 0.27603987f, -0.00796134f, 
    -0.22633876f, 0.10046259f, -0.26367775f, 0.03975183f, 0.06024719f, -0.04434353f, -0.10762093f, 0.12463093f, 
    -0.09429688f, -0.15307519f, 0.05912244f, -0.04055757f, -0.10819899f, 0.12388491f, -0.26038474f, 0.07108904f, 
    0.12552546f, 0.48006555f, -0.28763711f, 0.12826598f, -0.00971380f, -0.13599721f, 0.23863173f, 0.13021383f, 
    0.07121617f, -0.13169292f, -0.15099852f, -0.16398260f, 0.02893990f, -0.23413360f, 0.10361797f, 0.38830209f, 
    0.12673630f, 0.08913654f, -0.00429404f, 0.02965634f, 0.03121552f, -0.18029533f, -0.02056185f, 0.14587146f, 
    -0.01315876f, 0.23974678f, -0.23517358f, 0.03240295f, -0.06452782f, -0.11519193f, -0.21127251f, 0.01318710f, 
    -0.08173631f, 0.36961451f, -0.37145194f, -0.33056211f, -0.46947020f, -0.05502068f, -0.03026664f, -0.14442438f, 
    -0.17322476f, 0.10149164f, -0.12275705f, 0.24050421f, -0.18334140f, 0.16607836f, -0.12881541f, 0.00046206f, 
    0.10623995f, -0.17851917f, 0.10889576f, 0.06921175f, 0.16104473f, -0.10710705f, 0.56314451f, 0.41254520f, 
    0.11543220f, 0.06325246f, 0.07377078f, 0.04073023f, -0.03100044f, 0.17452952f, -0.62031823f, 0.19699235f, 
    0.57984340f, 0.31108949f, 0.73822522f, 0.34776375f, 0.04711924f, -0.02355127f, 0.39201206f, -0.19598572f, 
    -0.24335963f, 0.10572179f, -0.11357576f, 0.14286846f, 0.06282840f, -0.14114700f, -0.29968590f, -0.28335541f, 
    -0.41071421f, 0.03944392f, -0.21634355f, 0.09607962f, 0.12476533f, 0.12738180f, -0.03678926f, -0.12294132f, 
    0.31221274f, -0.25939777f, -0.06966736f, 0.04626806f, -0.08966060f, 0.31931841f, 0.19693415f, -0.08457119f, 
    -0.04409749f, -0.24420372f, 0.24761146f, 0.58540416f, 0.22057490f, -0.05472158f, -0.51662678f, 0.23231792f, 
    -0.40577111f, 0.06699479f, 0.01938016f, 0.05629938f, 0.09740888f, 0.01674527f, 0.04156506f, -0.05985908f, 
    0.20735854f, -0.11159787f, 0.13497493f, -0.23110919f, 0.00437769f, 0.04182833f, 0.42436600f, -0.22652599f, 
    -0.10455050f, 0.33094570f, -0.03197970f, -0.05247169f, -0.13760543f, 0.34670347f, 0.34103024f, -0.13897069f, 
    -0.24202314f, 0.05749363f, -0.24530187f, 0.37500042f, 0.14824045f, -0.11966797f, 0.04109967f, 0.02336225f, 
    0.07286056f, 0.09193812f, 0.18860579f, 0.22469427f, -0.09774289f, -0.03639039f, 0.07632550f, -0.87411433f, 
    0.43274564f, 0.36135158f, -0.06254319f, -0.11121326f, -0.00893989f, -0.06641315f, -0.28583729f, 0.15681677f, 
    0.17154571f, -0.19720241f, -0.36309761f, 0.15370026f, 0.03077951f, -0.03099383f, 0.00389548f, 0.20348254f, 
    0.15889430f, -0.10228804f, -0.20725541f, -0.00540567f, 0.18499459f, -0.02779647f, 0.00647718f, 0.26302680f, 
    0.29186410f, 0.00424019f, -0.49846554f, 0.07140414f, -0.11896555f, -0.14712746f, -0.30812901f, 0.01062352f, 
    -0.08876958f, -0.28093615f, 0.04744195f, -0.76647854f, -0.34670180f, -0.23201254f, -0.16771014f, -0.10236607f, 
    -0.20517214f, -0.15120831f, -0.05401189f, -0.00239234f, -0.35614055f, -0.52601194f, -0.04699411f, -0.15883245f, 
    -0.02190974f, -0.18692794f, 0.13579801f, 0.06469712f, -0.14056468f, -0.28484464f, -0.64169097f, -0.28885826f, 
    0.21846312f, -0.18549043f, -0.09399853f, -0.02147900f, 0.03713932f, 0.14707609f, 0.79897374f, -0.79940104f, 
    -0.68833369f, 0.29839367f, -0.17269951f, -0.30661750f, 0.21095741f, -0.02885729f, -0.05422205f, -0.08599919f, 
    0.05406060f, 0.43162712f, 0.05354711f, -0.09870539f, 0.10052936f, -0.10750253f, -0.01528074f, -0.02703055f, 
    0.02240759f, -0.05724101f, -0.04050370f, 0.29765859f, 0.32217172f, 0.03605099f, 0.05122241f, -0.05848746f, 
    0.12232476f, -0.00338291f, -0.07084944f, -0.02357229f, -0.03716256f, 0.01370262f, 0.13704063f, 0.09118959f, 
    0.12723999f, 0.21364106f, -0.16596496f, -0.07527302f, -0.14643143f, 0.06677057f, 0.10425949f, 0.11690898f, 
    0.16680349f, 0.11530412f, 0.32001528f, -0.06521504f, -0.22773026f, 0.15809853f, -0.09613039f, 0.15401235f, 
    0.05595584f, 0.14221177f, 0.05253063f, 0.02102187f, 0.04898266f, 0.30081415f, -0.09984827f, 0.14353117f, 
    0.22249325f, 0.22700547f, 0.46073741f, 0.51164609f, 0.24386826f, -0.69027025f, -0.09906496f, 0.38121811f, 
    0.00270059f, 0.18588385f, 0.13787518f, 0.01158016f, 0.08086944f, 0.17377058f, -0.27573481f, -0.23411240f, 
    -0.10330097f, -0.16646725f, -0.45211908f, -0.13792247f, 0.20146674f, 0.05965638f, 0.25366724f, 0.33087853f, 
    -0.23061006f, -0.87551057f, -0.09006099f, 0.07523794f, 0.13470389f, 0.08644865f, 0.26399246f, 0.12753510f, 
    -0.05064930f, 0.12514274f, 0.16906676f, 0.13681547f, 0.06594126f, 0.26293024f, 0.10722111f, 0.15622142f, 
    0.36426601f, 0.46061209f, 0.29640913f, -0.07169547f, -0.23094949f, -0.00671876f, -0.27122506f, 0.10729679f, 
    0.31335542f, -0.20405969f, 0.05629026f, 0.11620253f, 0.34875008f, 0.26040271f, -0.02772881f, 0.10298701f, 
    0.03281349f, -0.24500509f, -0.31405306f, 0.07516439f, 0.00242731f, 0.35052562f, 0.19498581f, 0.19083847f, 
    0.12212452f, -0.12257899f, 0.14386797f, -0.07160956f, 0.08685432f, -0.05072341f, 0.02557172f, 0.09256389f, 
    0.10144729f, -0.21499826f, 0.20846954f, 0.20366015f, 0.12480816f, 0.53738022f, 0.53638142f, 0.31469578f, 
    -0.26908895f, -0.05571263f, 0.00085060f, -0.02259750f, 0.14359361f, 0.14748381f, 0.86887842f, 1.09395516f, 
    -0.04119400f, -0.56720906f, 0.19906747f, 0.11039469f, 0.29839355f, 0.36659727f, -0.18853633f, 0.65398771f, 
    -0.29349977f, -0.38397884f, -0.18271825f, -0.08419708f, -0.31616327f, 0.09389541f, 0.00254707f, -0.07315158f, 
    0.11349931f, 0.03594632f, 0.13338690f, -0.07224385f, -0.19490303f, -0.37038162f, 0.12539041f, -0.11808065f, 
    -0.02451745f, -0.11416765f, -0.15101978f, -0.12941453f, 0.15889198f, 0.20985205f, 0.03389527f, 0.13108835f, 
    0.07889318f, 0.10514383f, -0.20699705f, -0.25189191f, 0.18584794f, -0.27683753f, -0.16789192f, 0.13342038f, 
    -0.51864910f, -0.06696308f, -0.05692092f, -0.53540713f, 0.25043362f, -0.25507718f, 0.04186982f, 0.03439239f, 
    0.01429669f, -0.35359645f, -0.30528727f, -0.39592326f, 0.08061279f, -0.37704045f, -0.00511184f, -0.14819355f, 
    0.03737656f, -0.12585650f, 0.06093965f, -0.11662975f, -0.01354360f, 0.71124816f, -0.31375307f, -0.54589683f, 
    -0.02154228f, 0.00604368f, 0.02204438f, 0.26766759f, 0.05816070f, 0.20407043f, 0.19791573f, 0.11581690f, 
    0.03093226f, -0.53450841f, -0.14507385f, -0.62467498f, -0.10856247f, -0.02887205f, -0.07770465f, -0.38216853f, 
    0.00643557f, -0.18473032f, 0.18154210f, 0.03893172f, -0.20027725f, 0.05319861f, 0.21744211f, 0.14719826f, 
    -0.05116128f, 0.51764286f, -0.06568587f, 0.03878790f, -0.08433388f, 0.13632759f, 0.03841254f, 0.08543729f, 
    -0.06586478f, -0.30228579f, 0.16964217f, -0.04926495f, -0.03619246f, -0.07622305f, 0.13712293f, 0.32161078f, 
    0.05081077f, 0.08340447f, -0.09173669f, -0.28270653f, 0.04771620f, -0.23256917f, -0.09547962f, -0.17581591f, 
    -0.00186409f, 0.25863689f, 0.31793204f, 0.21336269f, -0.53713876f, -0.35386944f, -0.14429367f, 0.08375096f, 
    -0.02069130f, 0.01575924f, -0.14453499f, -0.09957364f, -0.46707582f, -0.77175951f, 0.03020649f, -0.17768194f, 
    0.15253523f, -0.12413596f, 0.04276489f, -0.23113571f, -0.30766308f, -0.55700946f, 0.75421476f, 0.32796985f, 
    -0.34328514f, -0.14708364f, -0.23680332f, 0.10481678f, -0.07429368f, 0.08153870f, -0.86378407f, -0.97982997f, 
    -1.56132793f, -0.28998855f, 0.32122669f, 0.08699997f, 0.18470959f, 0.11127421f, -0.36124238f, -0.51601994f, 
    -0.18422557f, -0.04372034f, -0.15480162f, -0.13469765f, 0.19749908f, 0.11203367f, 0.09481024f, 0.15934405f, 
    -0.01231874f, 0.58616775f, 0.28377771f, -0.23945956f, -0.14604796f, -0.19272545f, 0.13554685f, 0.09607016f, 
    0.27240658f, 0.72442091f, -0.59031671f, -0.21786797f, -0.07158128f, 0.13035449f, 0.18007854f, -0.06054192f, 
    -0.00938762f, 0.04329473f, -0.15555109f, -0.54961866f, 0.32260013f, 0.08548331f, 0.16943447f, -0.03811602f, 
    0.14656574f, 0.34530932f, 0.33113486f, 0.48948309f, -0.35731384f, -0.25627309f, -0.03573766f, -0.01091872f, 
    -0.13548306f, -0.07249262f, -0.02075515f, -0.17138857f, 0.13805465f, -0.41094342f, 0.24623264f, -0.08030605f, 
    0.18797888f, 0.31827343f, 0.40348628f, 0.26006085f, 0.43716252f, -0.19834141f, 0.27775300f, 0.44933444f, 
    0.15895200f, -0.08901859f, -0.15103352f, 0.00111301f, 0.02609153f, 0.02166225f, -0.05216601f, 0.11992665f, 
    0.43998563f, -0.13048415f, -0.10486925f, -0.34531623f, -0.08705528f, -0.04883236f, 0.01150433f, -0.97592717f, 
    -0.56352651f, -0.37024963f, 0.17490092f, -0.19026133f, 0.14004856f, 0.00727742f, 0.01537691f, -0.02482451f, 
    -0.04232410f, -0.04212270f, -0.04770869f, 0.00274365f, 0.01748259f, 0.02742672f, -0.08678662f, -0.04485368f, 
    0.07259142f, -0.06645497f, -0.04458723f, -0.06795534f, 0.02732775f, -0.06297086f, -0.04402665f, -0.05512681f, 
    0.06232632f, 0.04836176f, -0.06565554f, -0.04407072f, 0.07330874f, -0.07020049f, -0.00813856f, 0.02546221f, 
    -0.00564284f, -0.05432304f, -0.02362512f, -0.05225710f, -0.04116280f, -0.05272831f, -0.00432118f, 0.02655514f, 
    0.02382602f, 0.02976459f, -0.06679566f, 0.01242323f, -0.05455966f, -0.08400222f, -0.03254840f, 0.07632989f, 
    -0.06681762f, -0.07691074f, -0.06633157f, 0.02966815f, -0.01737535f, -0.03404676f, -0.03835024f, 0.07262992f, 
    -0.07857584f, -0.03429281f, 0.08243477f, -0.01538862f, -0.00971516f, -0.07438128f, 0.05839535f, 0.07406475f, 
    -0.01183955f, -0.03020668f, -0.08426437f, -0.08053843f, 0.04684480f, 0.06081088f, -0.01769374f, 0.02116852f, 
    -0.06837810f, 0.02088897f, -0.07440993f, -0.07985994f, 0.05081014f, 0.02082394f, 0.05830223f, -0.03759076f, 
    -0.04710350f, -0.02897129f, 0.05482309f, -0.04154333f, -0.05879198f, 0.05619595f, -0.05604305f, 0.00654342f, 
    0.00811851f, -0.02857674f, 0.04115988f, -0.05793891f, 0.03331801f, -0.05460774f, -0.04695566f, 0.04051527f, 
    -0.01930905f, 0.05125780f, 0.01453378f, 0.02831613f, -0.04993669f, -0.05716447f, -0.05048586f, 0.07146008f, 
    0.01692839f, -0.07416561f, -0.06736869f, 0.06103171f, -0.03255874f, 0.01762031f, -0.06642957f, 0.05365864f, 
    -0.08292877f, -0.03732520f, 0.01982055f, -0.03166236f, -0.06430819f, -0.06832754f, 0.01737884f, -0.06824969f, 
    -0.01474457f, 0.06249727f, -0.01496986f, 0.01509940f, -0.03886205f, -0.02683271f, -0.03684155f, 0.06743228f, 
    -0.00233095f, -0.08033603f, -0.01671458f, -0.05439521f, -0.08268942f, -0.03863351f, 0.06074244f, 0.07853436f, 
    0.08263648f, 0.01975110f, 0.03607222f, 0.05369784f, -0.04728801f, 0.01711670f, -0.04890985f, -0.03808948f, 
    0.00635811f, -0.06235827f, 0.00714383f, -0.02148537f, 0.05843886f, 0.01244494f, -0.00863439f, 0.05795026f, 
    0.09838952f, -0.16550499f, 0.30595067f, 0.23524293f, 0.00690360f, 0.19058190f, 0.04090028f, -0.09010203f, 
    0.16865462f, 0.24105653f, 0.16171494f, 0.50127465f, -0.10948438f, 0.36175862f, -0.03168734f, 0.16972725f, 
    0.06850566f, -0.31192604f, 0.02912496f, -0.21885878f, -0.16479076f, -0.16217686f, 0.16628300f, -0.22100656f, 
    0.11485609f, -0.11306380f, 0.05558686f, -0.76860082f, -0.78502542f, 0.52305675f, -0.03041106f, -0.17754465f, 
    0.18474579f, -0.03175778f, -0.19840597f, 0.25142637f, -0.47392869f, -0.44728470f, -0.07916865f, -0.16828053f, 
    -0.23450883f, -0.20560032f, 0.04918220f, 0.12938954f, -0.00267903f, 0.32314366f, 0.17679450f, 0.56360501f, 
    -0.31132936f, 0.20441329f, -0.17023027f, 0.24589184f, 0.01169816f, 0.00098242f, 0.83282894f, -1.29736447f, 
    -0.20802432f, -0.09026599f, -0.01049605f, 0.11012384f, -0.06013234f, 0.25570592f, 0.03491576f, 0.29200187f, 
    -0.01847556f, 0.41209292f, 0.20823775f, -0.16500002f, -0.18175562f, 0.29048008f, 0.14645295f, -0.16912073f, 
    -0.19817847f, -0.19457574f, 0.55123144f, 0.24094968f, 0.07083394f, -0.08302593f, 0.11723276f, -0.11273443f, 
    0.03899627f, -0.65444380f, -0.66630340f, -0.40189591f, -0.09013715f, 0.11907614f, -0.14150943f, -0.04131712f, 
    0.11041414f, 0.01400067f, -0.24355212f, -0.45116788f, 0.06970197f, -0.18565671f, 0.03365792f, -0.15761657f, 
    0.12189344f, 0.10967828f, 0.02473780f, -0.15090588f, -0.24692604f, 0.22033697f, -0.21405178f, -0.08810491f, 
    0.24172874f, -0.16938284f, -0.15814826f, 0.09545432f, -0.14885837f, -0.30967018f, 0.02835680f, 0.41322663f, 
    0.00287698f, 0.05652934f, 0.26953170f, 0.05943607f, 0.16949645f, 0.18251093f, -0.06670822f, 0.67156702f, 
    0.13469237f, 0.13449739f, 0.11194523f, -0.02701592f, 0.27754730f, 0.19049726f, 0.05209026f, -0.39662966f, 
    -0.31411856f, -0.09524964f, -0.14937899f, -0.06921594f, 0.15256985f, 0.20459014f, 0.12324214f, -0.82036531f, 
    -0.04467544f, -0.74343699f, 0.22756019f, 0.09850799f, -0.31217742f, -0.10457619f, 0.22175337f, -0.11317174f, 
    0.28247240f, -0.16583030f, 0.05089552f, -0.03641934f, 0.14741920f, -0.06846626f, 0.26577607f, -0.03267808f, 
    -0.18200487f, -0.35347748f, -0.07127737f, 0.43762365f, 0.07454389f, -0.08238774f, -0.10652223f, -0.04157706f, 
    -0.01950404f, 0.10228030f, 0.05246473f, 0.24910578f, 0.02932460f, 0.23938662f, -0.23723470f, 0.14088862f, 
    0.05461522f, 0.27687505f, 0.69202429f, -0.21145095f, 0.04502346f, -0.09787116f, 0.17782338f, -0.15465397f, 
    0.14149842f, -0.10881510f, -0.25106609f, 0.24583492f, 0.11488210f, 0.02165309f, -0.07371046f, -0.14825045f, 
    0.01627394f, -0.18265434f, -0.20960349f, -0.03180887f, 0.00672174f, -0.04881222f, -0.36278611f, 0.30191484f, 
    0.04377569f, -0.11618191f, -0.21559303f, -0.20688757f, -0.04859869f, -0.16436081f, 0.78680229f, -0.57507342f, 
    0.41403452f, -0.05284187f, 0.11375064f, 0.31939164f, -0.09778100f, 0.17281289f, -0.11589925f, -0.33289170f, 
    -0.26018012f, 0.07041219f, 0.21724401f, 0.10187331f, 0.06394559f, -0.14252804f, 0.13874096f, 0.36496979f, 
    0.21146248f, 0.12898803f, 0.19171703f, -0.14085586f, -0.08731194f, 0.10065900f, -0.02904900f, 0.15452333f, 
    0.14776711f, -0.28929830f, 0.03311091f, -0.05376222f, 0.06227344f, 0.00262606f, -0.02743622f, 0.14932868f, 
    -0.25999010f, -0.29926351f, -0.19336642f, -0.28803831f, 0.11556745f, 0.01655258f, 0.08872164f, 0.07471733f, 
    0.21067788f, 0.27974856f, 0.53905004f, -0.26144317f, 0.54627723f, 0.73810798f, -0.02262679f, 0.05321025f, 
    -0.01632868f, -0.01534129f, -0.29267365f, 0.06536952f, -0.01285274f, 0.18865958f, 0.09442490f, -0.14799318f, 
    0.27051663f, -0.37155277f, 0.27073812f, -0.09504350f, 0.04270541f, -0.61866707f, 0.02205194f, 0.67124730f, 
    0.24811156f, 0.07428510f, -0.25677931f, -0.10732320f, 0.00647223f, 0.12420408f, 0.27068999f, 0.11019768f, 
    -0.07597572f, -0.30148280f, -0.55077749f, -0.08775586f, 0.24167232f, 0.14529543f, 0.17319761f, -0.31567594f, 
    -0.00953534f, -0.17997126f, -0.07450056f, -0.00664929f, 0.16514018f, -0.15472268f, 0.11960816f, 0.04098560f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.13308628f, 0.04136714f, -0.06950644f, 0.31177053f, 0.44960430f, 0.06314623f, 0.00354958f, 0.01055381f, 
    0.10330110f, -0.09110587f, 0.57899100f, -0.12264656f, 0.56485617f, -0.07858682f, 0.20548059f, -0.01834400f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17866446f, 0.03014293f, -0.20044151f, -0.29407445f, -0.04424231f, 0.78786576f, -0.24311107f, -0.22679138f, 
    -0.30796653f, -0.00361896f, -1.16626000f, 0.60516173f, -0.55689353f, -0.05727422f, 0.22593564f, -0.91132456f, 
    -0.33427119f, 0.23728819f, 0.10973693f, 0.22650099f, 0.41918254f, -0.15724806f, 0.06578247f, -0.12353589f, 
    0.37911209f, -0.23394962f, -0.10611443f, 0.09701701f, -0.27663162f, 0.04367356f, 0.47573438f, -0.55736762f, 
    0.31199703f, -0.44042945f, 0.06199312f, -1.33299565f, -0.15021116f, -1.00657713f, -0.13075411f, 0.02365347f, 
    0.16902243f, -0.26568589f, 0.74386919f, -0.27481684f, -0.44225502f, 0.20987536f, 0.13224317f, 0.48279029f, 
    0.08060974f, -0.38422614f, 0.22607075f, -0.18179417f, -0.42085716f, 0.34699124f, -0.14299378f, 0.09975728f, 
    -0.21707295f, -0.38910908f, -0.01570562f, 0.22928298f, -0.77258277f, 0.24235015f, 0.34986344f, 0.47112688f, 
    0.37745816f, -0.18823904f, -0.02565541f, -0.19709180f, -0.01103782f, -0.03777149f, 0.22748640f, 0.12132383f, 
    -0.42643723f, 0.05560005f, -0.94746268f, 0.05579785f, 0.39608786f, 0.23473865f, 0.50666833f, 0.00901944f, 
    -0.31647024f, 0.70971340f, -0.08436526f, -0.04149071f, 0.47615060f, 0.03625524f, -0.01449571f, -0.19752297f, 
    -0.33546892f, 0.09163295f, -0.01162045f, 0.10607304f, -0.04534063f, 0.22956476f, -0.16234532f, -0.10959832f, 
    0.37846565f, -0.18945169f, 0.17766556f, -0.90484017f, 0.27909797f, -1.72243285f, 0.07870872f, -0.05348463f, 
    0.10333505f, 0.04931714f, 0.30156237f, -0.60353911f, 0.91888905f, -0.03492314f, -1.89603853f, 0.16702594f, 
    -0.10632513f, 0.49480659f, -0.03137318f, 0.36367819f, -0.55778635f, -0.34650898f, -0.06902684f, 0.02366135f, 
    0.34429967f, -0.02542389f, -0.22565806f, 0.34562722f, -1.24727428f, 0.20820610f, -0.38118577f, 0.22259477f, 
    -0.53529894f, -0.21932046f, -0.20552962f, 1.20957732f, 0.37907466f, -0.09916783f, -0.15032522f, 0.07445574f, 
    -0.26774099f, 0.59870982f, 0.49802780f, 0.03273098f, -0.53007334f, -0.08274707f, -0.27659047f, -0.71551126f, 
    0.48761693f, -0.03199102f, 0.13599995f, -0.40882647f, 0.23606952f, -0.21027111f, -0.09047574f, 0.11513777f, 
    -0.27069953f, -0.53282076f, -0.26928753f, -0.34019259f, 1.16500235f, -0.11870866f, -0.21421276f, -0.02083809f, 
    -0.78005004f, -1.12620044f, 0.06553454f, -0.56616914f, -0.25339913f, -0.08030767f, -0.06889662f, -0.02205203f, 
    0.16410166f, 0.97987223f, -0.05055463f, 0.37908778f, 0.26113933f, 0.07386021f, 0.01915732f, 0.06718324f, 
    0.28804496f, -0.70500594f, -0.04938223f, 0.54905605f, -0.27763477f, 0.48923972f, 0.22852294f, -0.18962695f, 
    0.42438069f, 0.25374871f, 0.08603603f, -1.10990810f, -0.40612915f, -0.15218471f, -0.82623345f, 0.28263202f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.42233193f, 0.34926644f, 0.16730058f, 0.30462885f, -0.60972691f, 0.13387479f, -0.12711145f, -0.43223810f, 
    -0.05719049f, 0.31690472f, 0.09297846f, 0.25148526f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
