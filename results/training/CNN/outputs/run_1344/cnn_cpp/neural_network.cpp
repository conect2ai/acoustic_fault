#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.11292338f, 0.86852723f, 0.28997540f, 0.38004956f, -0.06098767f, -0.44118989f, 0.03022098f, -0.43507552f, 
    -0.03897837f, 0.45565408f, 0.11038173f, 0.26166776f, -0.38617256f, -0.13809246f, 0.55454844f, 0.49984974f, 
    -0.41200969f, 0.31811440f, 0.72120082f, -1.09530377f, 0.44672146f, 0.39451814f, -0.35055628f, 0.44738299f, 
    -0.28060558f, -0.11187816f, -0.15917800f, 0.41974756f, -0.27371585f, 0.85608661f, -0.98430347f, -0.73072928f, 
    -0.39394051f, 0.37313640f, -0.18361992f, 0.23287523f, -0.72540253f, 0.02312302f, -0.82275379f, 0.28727210f, 
    0.13017409f, 0.37383744f, 0.43450820f, 0.00867440f, 0.46275431f, 0.37132871f, 0.07634635f, 0.26787466f, 
    -0.78858209f, 0.53109735f, -0.28663215f, -0.19791086f, -0.03340057f, 0.15613876f, -1.20721292f, 0.26598546f, 
    0.76153404f, -0.27328813f, 0.39264867f, 0.09831586f, -0.17018326f, -0.22511397f, 0.18312290f, 0.19714043f, 
    0.75374162f, 0.34793344f, -0.47629800f, -0.08142344f, 0.04845639f, -0.23921211f, -0.33386582f, -0.22500527f, 
    -0.35918385f, 0.81218559f, 0.39052916f, -0.90391320f, -0.34103116f, 0.79984784f, -0.46061280f, 0.05728264f, 
    0.54783136f, -0.31082103f, -0.61218506f, 0.44228095f, -0.33167109f, -0.74429417f, 0.43077174f, 0.37404394f, 
    0.48113903f, 0.13821383f, 0.74449164f, 1.15472341f, -0.67305911f, -0.11120324f, -0.52109563f, -0.35667413f, 
    0.06845796f, 0.05817777f, -0.03654874f, -0.16815959f, -0.03831692f, 0.18666172f, -0.71322411f, 0.18266635f, 
    0.32373041f, 0.78084618f, -0.70346725f, -0.28361207f, -0.28889385f, 0.70322615f, -0.71332479f, -0.54229051f, 
    -0.65686905f, -0.39202797f, -0.05336210f, -0.43137735f, -0.39791197f, -0.21850657f, -0.25390986f, -0.51627684f, 
    -0.39355332f, -0.76589280f, -0.36656433f, 0.05770323f, 0.61874181f, 0.08012879f, -0.64659423f, -0.83206534f, 
    -0.52393627f, -0.41739017f, -0.03008240f, 0.65566510f, 0.23816563f, 0.31420666f, 0.54426658f, 1.23698807f, 
    -0.71758449f, -0.94550002f, -0.01724974f, 0.10700233f, -0.48218840f, 0.24532437f, 0.17912364f, 0.21747881f, 
    -0.14775349f, 0.59214842f, -0.25319740f, 0.01253980f, 0.56687433f, -0.44084439f, 0.50021327f, -0.48732826f, 
    0.14426185f, -0.85113782f, -0.39049280f, 0.36908844f, 0.49647659f, -0.42855617f, 0.66066188f, -0.52184963f, 
    0.40494823f, 0.19317585f, 0.65316421f, 0.58054227f, -0.87574250f, -0.48795953f, 0.10390305f, 0.24691918f, 
    0.44161746f, -0.54040056f, 0.26808953f, 0.25861049f, 0.68194008f, -0.59659421f, -0.76699555f, 0.76110834f, 
    0.01348161f, 0.22271229f, 0.34549960f, -0.32274389f, -0.62190700f, -0.17774242f, -0.55987328f, 0.09999537f, 
    -0.36971682f, 0.60351831f, -0.20704278f, -0.57110459f, 0.25118896f, 0.56663090f, 0.21913701f, 0.07527159f, 
    -0.01660512f, 0.58103442f, -0.55049348f, 0.17060593f, 0.18998212f, -0.31158763f, 0.12785818f, 0.15443896f, 
    0.21830370f, 0.17196906f, 0.43945959f, 0.24116111f, -0.22288476f, -0.29329345f, 0.22994067f, 0.34160805f, 
    0.58470625f, 0.58661067f, -0.21394917f, -0.30439159f, 0.57519805f, -0.06077560f, -0.26601657f, 0.04296992f, 
    -0.62822199f, -0.46091205f, -0.08239324f, 0.13651025f, -0.19888975f, -0.43086478f, -0.43836522f, -0.05350507f, 
    -0.24161471f, -0.63449401f, -0.32533574f, -0.24660079f, 1.06849205f, -0.76921093f, -0.20170482f, 0.07357850f, 
    -0.21569242f, -0.16051765f, -0.47047815f, -0.01628057f, -0.11266445f, 0.54755270f, 0.65720755f, 0.39454550f, 
    -0.08066152f, 0.08163391f, -0.46554807f, 0.25741866f, 0.09380838f, 0.52895319f, 0.20747203f, -0.15893044f, 
    0.12317644f, 0.25150880f, -0.29970130f, 0.29298559f, -0.15185547f, 0.71143162f, -0.23534688f, 0.17626826f, 
    -0.21737485f, -0.02741756f, 0.30681995f, -0.21994121f, 0.06689116f, 0.31132534f, 0.40674448f, -0.38436389f, 
    0.37006342f, -0.19561349f, 0.31669930f, -0.00380939f, 0.10302427f, 0.42655140f, -0.84064186f, -0.37705493f, 
    -0.34332252f, 0.34300452f, 0.70842642f, -0.44798943f, -0.35567406f, -0.23357357f, -0.50259435f, 0.18163317f, 
    0.33041182f, 0.28194037f, -0.36629263f, -0.11065514f, -0.32593673f, -0.35287666f, 0.25317773f, 0.74733776f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11760079f, -0.25016445f, -0.04110181f, -0.06110250f, 0.04498859f, 0.09093063f, -0.10912701f, 0.25260702f, 
    0.11267307f, 0.09351973f, 0.26409170f, 0.08317766f, -0.26398894f, -0.19281545f, 0.04250309f, 0.21961461f, 
    -0.19673760f, -0.18294711f, -0.08708192f, -0.02174688f, 0.17529751f, -0.11104356f, -0.02042549f, -0.35597932f, 
    -0.45234144f, 0.20292050f, -0.05679019f, -0.23349908f, 0.33115667f, -0.32306838f, -0.04691983f, -0.11302857f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12017082f, -0.27062038f, -0.07162732f, 0.28570446f, -0.42282650f, 0.08130877f, -0.02149722f, 0.12046558f, 
    0.00187667f, 0.05955266f, 0.03324111f, -0.15108660f, -0.07004157f, 0.04357960f, -0.21474667f, 0.10898390f, 
    0.03593316f, -0.03213333f, 0.10876172f, -0.04263381f, -0.14137784f, 0.01287942f, -0.11202234f, -0.09671535f, 
    -0.00561499f, 0.00776261f, -0.03826674f, 0.06779240f, 0.04486878f, 0.05194827f, -0.01895408f, 0.05696259f, 
    -0.02279897f, -0.03563784f, 0.14255109f, 0.02960066f, 0.00176139f, -0.08826157f, -0.04814155f, 0.00960673f, 
    0.14273529f, -0.24542043f, -0.14564218f, -0.20390448f, 0.07669286f, -0.00194600f, -0.01110163f, 0.00285561f, 
    -0.05962866f, -0.08109640f, -0.03178299f, 0.01434081f, 0.08329364f, -0.00899743f, 0.07467216f, -0.07424162f, 
    -0.06066035f, -0.07450620f, -0.01335292f, 0.16306210f, 0.11768650f, 0.08346137f, -0.28306907f, 0.48047602f, 
    0.03957276f, 0.11065517f, 0.05365160f, 0.18447019f, -0.01996371f, 0.06474324f, 0.10621970f, 0.08536337f, 
    -0.07977869f, -0.02949331f, -0.01627027f, -0.00634810f, 0.09305733f, -0.03072249f, -0.04704526f, -0.01826532f, 
    0.23117541f, 0.24064292f, 0.30350804f, 0.15228914f, -0.09646562f, 0.04170379f, 0.02484195f, -0.17749828f, 
    -0.12154195f, 0.02253737f, 0.09402094f, -0.07919250f, 0.11964009f, 0.07498427f, 0.02430716f, -0.01249667f, 
    -0.05842014f, -0.00096427f, -0.05630398f, -0.05580565f, -0.14397077f, 0.16939518f, -0.17300357f, -0.06906518f, 
    0.20339900f, 0.25029197f, 0.12596935f, 0.04616391f, 0.09609527f, 0.07901618f, 0.18825285f, -0.04542923f, 
    0.00496929f, -0.01788890f, -0.00494615f, -0.06440663f, -0.00500496f, 0.11005642f, 0.00544796f, -0.00304285f, 
    -0.38708788f, -0.03969593f, -0.10403882f, 0.27798852f, -0.45549026f, 0.13416247f, -0.10661521f, 0.00931972f, 
    0.11670715f, 0.11644271f, 0.10643561f, -0.01697238f, 0.04555695f, -0.00103286f, 0.08287803f, -0.02967882f, 
    0.00363961f, 0.00709467f, 0.14766224f, 0.13046336f, 0.03238240f, 0.42020673f, -0.36150196f, 0.16088443f, 
    0.08490552f, 0.16646108f, 0.11431020f, 0.07311267f, 0.10129531f, 0.07906768f, 0.06932052f, 0.02637018f, 
    0.01311968f, -0.02045597f, -0.03358324f, -0.01885525f, -0.00071916f, 0.14034276f, 0.00876023f, 0.04272307f, 
    -0.43428922f, 0.26671487f, -0.52214336f, 0.04543301f, -0.11487987f, 0.10559905f, -0.03048728f, 0.02787316f, 
    -0.06552681f, 0.14444099f, 0.00486891f, -0.03539331f, 0.00882373f, 0.02024938f, 0.02461676f, 0.01972301f, 
    -0.04170667f, 0.08034142f, 0.03304362f, 0.05941782f, 0.26292124f, -0.01912056f, 0.13068588f, 0.34105337f, 
    -0.02854262f, 0.09029305f, -0.04502733f, 0.07541245f, -0.17449082f, -0.00624693f, -0.03888229f, -0.03196941f, 
    0.02403942f, -0.08837135f, 0.04120298f, 0.02304196f, -0.01559564f, -0.12991314f, 0.11281157f, -0.06984562f, 
    0.38923505f, 0.37358055f, -0.32526204f, -0.07104298f, 0.16832452f, -0.07503640f, 0.20075859f, 0.10939641f, 
    0.09924062f, 0.13177229f, 0.08017652f, 0.06503249f, 0.09055751f, -0.12521666f, -0.06276594f, 0.09603367f, 
    -0.00357663f, 0.06083092f, 0.03872797f, -0.02085447f, 0.03400432f, -0.05350793f, 0.06889755f, 0.06307960f, 
    -0.12406676f, 0.01612297f, -0.07156928f, 0.08589103f, 0.09590251f, -0.00943630f, 0.11054391f, -0.01491628f, 
    0.08103374f, -0.02741151f, -0.00897250f, -0.00985836f, 0.14313665f, -0.09155516f, 0.01538355f, 0.12335248f, 
    0.14446154f, 0.00852958f, 0.10683557f, 0.37342042f, 0.04710475f, 0.04170279f, -0.04447270f, 0.08963150f, 
    0.06749532f, 0.16071247f, 0.00966900f, 0.01740250f, -0.00024968f, 0.03995901f, -0.15734112f, 0.11091381f, 
    0.12748408f, 0.06710549f, 0.03889448f, 0.07627471f, 0.05226751f, 0.00712114f, 0.41772750f, -0.00393238f, 
    -0.02786489f, -0.06606601f, -0.00717408f, 0.20224865f, 0.07543109f, 0.18607427f, 0.01242051f, -0.02186114f, 
    -0.08050604f, -0.06981106f, -0.10588096f, -0.04677839f, 0.04888317f, -0.01283225f, -0.04086030f, -0.12521718f, 
    0.22971101f, -0.09266895f, 0.25558501f, 0.24031334f, -0.10155864f, 0.14064352f, -0.09781460f, -0.15443295f, 
    0.10608364f, 0.12954588f, 0.11987106f, -0.03472302f, 0.00089354f, -0.00066190f, -0.07962050f, -0.07009144f, 
    0.00655629f, -0.03013432f, 0.06689277f, 0.00712274f, 0.03891402f, -0.18658233f, 0.63439459f, -0.29384771f, 
    0.02058028f, 0.05746983f, 0.00256062f, 0.04618060f, -0.03548732f, 0.08528041f, -0.08043195f, -0.02695783f, 
    0.00587388f, 0.01983342f, -0.09951388f, 0.00470411f, 0.04372310f, -0.08786288f, -0.16558912f, -0.08930603f, 
    -0.00914190f, -0.06711602f, -0.02325966f, -0.05110953f, -0.04800786f, 0.03882412f, -0.01457363f, 0.06834107f, 
    0.00618153f, -0.00449406f, -0.02507979f, 0.01720164f, -0.13109274f, -0.00784900f, 0.13164288f, 0.13124977f, 
    -0.02701486f, 0.07496201f, -0.03395403f, 0.02983521f, 0.13396145f, -0.03626533f, -0.22910291f, 0.22897683f, 
    -0.03117749f, 0.02361020f, 0.04006043f, -0.07422922f, -0.03229909f, 0.10128539f, 0.16278924f, 0.03961497f, 
    -0.02431720f, 0.04429176f, 0.02548603f, 0.00070239f, -0.12921087f, -0.07254161f, 0.00383690f, 0.12326597f, 
    0.18772939f, 0.12264393f, -0.14486760f, -0.38604099f, 0.21830404f, -0.06343304f, -0.21349190f, -0.10561673f, 
    0.01042713f, -0.02234218f, 0.13085812f, 0.06182814f, -0.07868910f, -0.02063109f, 0.10562403f, 0.09480740f, 
    0.19407262f, -0.14819497f, -0.00001787f, 0.05886419f, -0.13682130f, 0.19570804f, -0.35464221f, -0.13879436f, 
    0.15866984f, 0.09119464f, -0.02119389f, 0.11545924f, -0.07745291f, 0.01809434f, 0.00091490f, 0.03218956f, 
    -0.00737466f, -0.02272764f, 0.02927919f, 0.24468870f, -0.03924489f, 0.01210056f, 0.00838755f, -0.10558708f, 
    0.00217848f, -0.05256345f, -0.06294674f, 0.05674069f, -0.17973801f, 0.01327716f, -0.05242195f, -0.06299591f, 
    0.10238933f, 0.18511038f, -0.01339663f, -0.08352632f, -0.10302683f, 0.09544741f, 0.02043665f, -0.15415956f, 
    -0.02442711f, 0.05113079f, 0.04988724f, 0.06728067f, -0.01979989f, -0.09320977f, -0.07148310f, -0.03577131f, 
    0.03204824f, 0.14630233f, 0.14179367f, 0.03781919f, 0.01451089f, 0.02570773f, 0.05547789f, -0.04595859f, 
    -0.00698107f, 0.02870450f, 0.03955866f, -0.00727799f, -0.06066709f, 0.04255066f, -0.04575107f, -0.01387196f, 
    -0.11843235f, 0.04964981f, -0.05918086f, 0.01047355f, -0.01563695f, 0.03922064f, 0.01396691f, 0.03747908f, 
    -0.06940740f, 0.08314317f, -0.04419888f, 0.02835073f, -0.02332768f, 0.09964034f, -0.05451966f, -0.02628817f, 
    -0.03446253f, 0.11361033f, 0.08103824f, 0.10154110f, -0.25887394f, 0.05982385f, -0.12170377f, -0.01187076f, 
    -0.13346192f, 0.03957388f, 0.05864611f, 0.05569831f, 0.06785556f, 0.07005684f, -0.07504731f, -0.06397540f, 
    0.08175735f, -0.01473795f, -0.01668962f, -0.03840181f, 0.03743286f, 0.14284086f, 0.09717625f, 0.09745602f, 
    -0.14028475f, -0.34827268f, 0.08769467f, -0.04337569f, -0.00286458f, 0.00264047f, -0.07604935f, -0.02146499f, 
    -0.06657557f, 0.08068115f, 0.05615209f, -0.09872334f, -0.04072926f, 0.04536655f, -0.03201255f, 0.03917538f, 
    0.13736899f, 0.03192861f, 0.08471914f, 0.10757982f, -0.01120603f, -0.34807971f, 0.13329117f, -0.03268557f, 
    -0.26636663f, -0.04610292f, 0.01593476f, -0.09508218f, -0.01048218f, 0.05902432f, 0.14496143f, -0.06775213f, 
    -0.08360035f, 0.17578785f, 0.12085861f, 0.05038704f, -0.00051061f, -0.03749397f, -0.09822319f, 0.00205228f, 
    -0.09980000f, 0.11310215f, 0.07143105f, 0.01887584f, 0.08432042f, -0.07403408f, 0.02480599f, -0.06476037f, 
    -0.05126394f, -0.06395971f, 0.10309080f, 0.00659569f, 0.05100672f, 0.09781025f, -0.02487890f, 0.03439211f, 
    0.04442809f, 0.13732208f, 0.04882950f, 0.10984607f, -0.06128215f, -0.01302152f, -0.09300468f, -0.17289841f, 
    -0.11817063f, 0.07629593f, 0.10588073f, 0.10082773f, 0.10490282f, -0.03703026f, -0.05877134f, -0.05469973f, 
    -0.03533132f, -0.00238319f, 0.02438689f, 0.03119749f, -0.02006841f, -0.00939856f, -0.07199591f, -0.01510604f, 
    0.03790668f, 0.12309477f, -0.33125421f, 0.00266774f, 0.00541567f, 0.01070882f, 0.07569104f, 0.03231153f, 
    0.00484043f, 0.05676676f, 0.03054560f, 0.05046391f, 0.04601986f, -0.07300734f, 0.01220687f, 0.08622779f, 
    -0.00074918f, 0.05651574f, 0.02859177f, -0.03708908f, -0.05983427f, 0.15623811f, 0.07228285f, -0.03218121f, 
    -0.06927130f, -0.03812146f, 0.00896078f, -0.09184362f, -0.01695535f, 0.00509482f, 0.03348029f, -0.01370593f, 
    0.06691459f, 0.03184276f, 0.12534629f, 0.19613339f, -0.03916295f, -0.20652290f, -0.00602369f, 0.05333911f, 
    -0.37797996f, -0.18333389f, -0.13585784f, -0.06958756f, -0.11314886f, -0.08170368f, -0.08585112f, -0.12594540f, 
    -0.06636333f, 0.02989061f, 0.02810700f, -0.10724946f, 0.00495611f, 0.04226913f, -0.01283212f, -0.05771726f, 
    0.13598005f, 0.07827157f, 0.03149839f, -0.06683221f, -0.17625141f, 0.13626108f, -0.18283680f, 0.00761501f, 
    0.04862881f, -0.13099644f, 0.02013364f, 0.01253822f, 0.09537299f, -0.03587184f, 0.10049858f, -0.09894191f, 
    -0.01470910f, -0.17262208f, -0.03865834f, 0.10871731f, -0.21945001f, 0.08954597f, -0.12375008f, 0.05462526f, 
    -0.26899719f, 0.04134260f, -0.24332173f, 0.03428708f, -0.02599289f, -0.11046161f, 0.07224030f, 0.02575293f, 
    0.04397296f, 0.11183767f, 0.12624863f, 0.04913816f, 0.08497401f, 0.01267469f, 0.10094200f, -0.03207889f, 
    0.02953178f, 0.25272688f, -0.07510047f, -0.02149824f, 0.27839464f, -0.04592745f, -0.14321844f, -0.03311912f, 
    0.07331525f, -0.14418577f, 0.02849909f, 0.13625254f, 0.05091726f, -0.17202638f, -0.02208968f, -0.06912352f, 
    -0.07650918f, -0.06084126f, -0.04334791f, 0.05338781f, -0.01424119f, -0.07147488f, 0.14884101f, -0.03805170f, 
    0.09252014f, -0.19203500f, 0.23109904f, 0.06329130f, 0.22925055f, -0.03057535f, -0.02351817f, -0.02658631f, 
    0.01699944f, 0.00998593f, 0.07571660f, 0.02245984f, 0.09405675f, 0.13131209f, -0.17243782f, 0.06752174f, 
    0.18965207f, -0.10296609f, 0.07461090f, 0.07859465f, 0.12771299f, 0.17716862f, -0.12395469f, -0.40119261f, 
    0.18426661f, -0.10875538f, 0.08325335f, 0.04930894f, 0.19527541f, 0.09167921f, -0.07330249f, 0.00772195f, 
    -0.05171825f, -0.02964134f, 0.04012371f, 0.07090116f, -0.02729154f, -0.01787631f, 0.20806791f, 0.05576488f, 
    -0.00170515f, 0.04231491f, -0.07421087f, -0.18615641f, -0.18988064f, -0.04027779f, 0.03578826f, -0.09076069f, 
    -0.12247939f, -0.05345598f, -0.03050787f, -0.01871892f, 0.06465514f, 0.09463296f, 0.09815891f, -0.04602392f, 
    0.04156140f, 0.03868303f, -0.09484211f, -0.06725218f, 0.26202643f, 0.03912308f, 0.00510778f, -0.21236515f, 
    -0.16601428f, 0.00315850f, -0.05011728f, 0.10247122f, -0.06683063f, -0.04241912f, -0.05532911f, 0.09385864f, 
    0.04433046f, 0.00669583f, -0.04450091f, 0.04250675f, -0.00616332f, -0.02037992f, 0.07049160f, 0.06873047f, 
    -0.12401596f, 0.04389903f, 0.01111817f, -0.01942228f, 0.21372916f, -0.00605582f, 0.16254997f, 0.08718766f, 
    -0.02165513f, 0.08268081f, 0.05780779f, 0.19132160f, -0.05481438f, -0.02204535f, -0.07165702f, 0.10221863f, 
    -0.04231711f, 0.11164134f, 0.08427031f, -0.04650756f, -0.22937272f, 0.00482538f, -0.15986359f, -0.17954724f, 
    0.00045922f, -0.09544460f, -0.03314411f, 0.04489857f, -0.11295512f, -0.09441001f, -0.03521176f, 0.02898834f, 
    0.03287175f, -0.00109255f, 0.03295068f, 0.11973575f, -0.02360985f, -0.13269757f, 0.01904448f, 0.04646854f, 
    -0.25579244f, 0.04180030f, 0.07423323f, 0.03435590f, -0.10778320f, -0.05542886f, -0.06394268f, 0.14130847f, 
    -0.08595316f, -0.20746706f, -0.01232079f, 0.01092847f, 0.07566607f, -0.04658608f, -0.05845490f, -0.00750309f, 
    0.11030373f, -0.12237792f, 0.07917938f, -0.08667587f, -0.55819160f, 0.11717816f, 0.14032890f, -0.19869871f, 
    -0.08353402f, -0.18965906f, 0.02180541f, 0.06091963f, 0.01933021f, -0.00134063f, 0.11108963f, 0.01012687f, 
    -0.02269720f, 0.05968221f, -0.04600758f, 0.01676553f, 0.03930863f, -0.09472056f, 0.02325080f, -0.17742078f, 
    0.12416957f, -0.13027886f, -0.33100331f, 0.12347162f, -0.45691410f, 0.00145355f, -0.13982728f, 0.22922136f, 
    0.00857407f, 0.03319429f, -0.03696460f, -0.04313359f, -0.01295446f, -0.02650345f, 0.13747463f, -0.01825255f, 
    -0.00941488f, 0.04130781f, 0.10249733f, 0.08051270f, -0.07238179f, 0.03939021f, 0.14416428f, 0.09156445f, 
    0.18595172f, -0.01590756f, 0.08331169f, 0.05352578f, 0.10794825f, 0.02718331f, -0.05739965f, 0.13410398f, 
    -0.00515870f, -0.00563269f, 0.23465937f, 0.13008088f, 0.05204560f, 0.05241472f, -0.01834252f, 0.01129697f, 
    -0.10841644f, 0.20545405f, -0.01110072f, -0.15838669f, -0.12500876f, 0.05551469f, 0.12679891f, 0.10487942f, 
    -0.06614391f, 0.18619122f, 0.03741701f, -0.07262201f, -0.02876154f, 0.01036772f, 0.08967613f, -0.04683845f, 
    0.02340565f, 0.18716981f, -0.12083366f, 0.00758161f, 0.04969687f, 0.27434468f, 0.03268470f, -0.15751413f, 
    -0.05216382f, -0.02620349f, 0.00543078f, -0.13278244f, 0.16919932f, 0.18865651f, -0.05719397f, -0.07848150f, 
    -0.00637450f, 0.05614749f, 0.03831665f, 0.01938179f, -0.01111656f, 0.03242517f, 0.06425975f, -0.08053190f, 
    -0.10073797f, 0.29248288f, -0.00923890f, -0.11911049f, -0.30840936f, -0.04871539f, 0.04219924f, -0.00219110f, 
    -0.08295754f, 0.03175629f, -0.02209501f, 0.00495315f, -0.02202277f, 0.06896395f, 0.03286247f, 0.07779027f, 
    0.01007605f, -0.08185615f, 0.06568833f, -0.09189034f, 0.24673223f, 0.29959309f, -0.25002590f, 0.10942444f, 
    -0.07470820f, 0.01174876f, -0.03462064f, 0.04299081f, 0.09430923f, 0.08347344f, 0.01615844f, -0.01610876f, 
    -0.08138026f, 0.10020757f, 0.20158942f, -0.01024982f, -0.04739209f, 0.04928922f, -0.06448860f, 0.17367649f, 
    0.02275842f, -0.09553621f, 0.30801097f, 0.07109746f, -0.09808712f, -0.29881468f, -0.00313508f, 0.07355301f, 
    -0.08427536f, -0.15178111f, -0.05082672f, -0.01554312f, -0.02392543f, 0.13052313f, -0.09082527f, -0.03753706f, 
    0.03569610f, 0.05574935f, -0.25176084f, -0.16657077f, 0.05783098f, 0.43904290f, 0.25471646f, -0.25464633f, 
    0.02861942f, -0.19479579f, 0.07275892f, -0.07641306f, -0.14019078f, -0.09570122f, 0.12905420f, 0.09199851f, 
    0.16792506f, -0.00327237f, -0.04774527f, -0.02734382f, 0.12808880f, 0.07635935f, 0.03607830f, -0.00376503f, 
    -0.08135887f, 0.12425032f, -0.02007970f, 0.17203128f, -0.16904125f, 0.03303475f, -0.07731368f, 0.17642395f, 
    0.11192269f, -0.07174444f, 0.08570002f, 0.07620350f, 0.13797258f, -0.01099509f, 0.08133351f, -0.05161226f, 
    -0.03787026f, 0.03145826f, -0.00800422f, -0.01643094f, -0.14619270f, -0.15783837f, 0.30934793f, 0.00373475f, 
    -0.30431929f, -0.06209582f, 0.00382157f, 0.02081617f, 0.08410334f, 0.01935229f, 0.16421898f, 0.11822864f, 
    -0.12603167f, -0.09617946f, 0.01232631f, -0.12259860f, 0.11784659f, -0.12212595f, 0.07437688f, 0.11396429f, 
    0.13110659f, 0.11358971f, 0.12196547f, -0.07938450f, -0.06738319f, 0.04838485f, 0.04746029f, 0.06163849f, 
    -0.04148300f, -0.03020996f, 0.00545672f, 0.01351133f, 0.00388987f, -0.04079188f, -0.01297062f, 0.20256135f, 
    0.15124899f, 0.12286898f, 0.04183624f, 0.01206766f, 0.31372458f, -0.15723486f, 0.10466999f, 0.09966894f, 
    -0.10798506f, -0.21170132f, -0.01485385f, 0.03500416f, -0.02436847f, -0.07552484f, -0.18313022f, 0.05898468f, 
    0.02679593f, 0.02520990f, -0.10364246f, -0.01838673f, 0.08327429f, -0.00728328f, -0.01250734f, 0.01604014f, 
    0.06485789f, 0.04818368f, 0.08060155f, -0.02587691f, -0.03096596f, -0.09495455f, 0.00143055f, -0.07926897f, 
    -0.04200109f, -0.19886354f, 0.09345986f, 0.13990861f, 0.11261608f, 0.05002634f, -0.10720905f, 0.09754232f, 
    -0.02634215f, -0.05859787f, -0.11768073f, -0.04062568f, 0.20750079f, 0.02516036f, -0.25481623f, 0.04977128f, 
    -0.02142702f, -0.14750199f, -0.09444071f, 0.03639771f, -0.11003164f, -0.15870592f, -0.03884023f, 0.09803432f, 
    -0.00678857f, 0.00624582f, -0.09161182f, 0.10869643f, -0.03044169f, -0.22375736f, 0.05494977f, -0.00925973f, 
    0.36905709f, 0.36717269f, -0.01504730f, -0.06320030f, 0.00782264f, 0.05865168f, 0.16139685f, 0.10912818f, 
    0.15359107f, 0.15879829f, 0.09719975f, 0.08089605f, 0.00654125f, -0.04631003f, -0.02333757f, -0.01293402f, 
    -0.13215092f, 0.05268604f, 0.10034983f, 0.02202757f, 0.41403577f, 0.26770350f, 0.01062544f, -0.23556089f, 
    0.09555595f, -0.08009552f, 0.09070411f, 0.05960272f, 0.07570935f, 0.08462414f, 0.05012992f, 0.01089377f, 
    0.06068921f, -0.09507538f, 0.03610896f, 0.11948991f, 0.16500117f, -0.03141990f, 0.05829645f, 0.05699489f, 
    0.29064992f, 0.11585066f, 0.00041309f, 0.17597547f, -0.02556119f, -0.19197580f, -0.10639592f, -0.17567317f, 
    -0.13429272f, -0.14725809f, 0.06517759f, 0.15170246f, 0.12288038f, 0.11156602f, 0.04048172f, 0.15516976f, 
    0.06692757f, -0.13634947f, 0.01879002f, 0.01035369f, 0.04083558f, -0.09155618f, -0.07868499f, 0.08206461f, 
    -0.01962906f, -0.15154424f, 0.11653145f, 0.00501444f, -0.02508827f, -0.09445681f, -0.07071583f, 0.04442671f, 
    -0.11158019f, 0.03937112f, -0.13368909f, -0.02926090f, -0.05883225f, -0.00869151f, 0.13996105f, -0.05329631f, 
    -0.08158539f, -0.17485557f, 0.13897318f, 0.17386927f, -0.01407058f, -0.10219882f, -0.05657145f, 0.16172975f, 
    -0.06611039f, -0.04886883f, -0.01011821f, -0.03494384f, -0.03213317f, 0.01774637f, 0.01430023f, 0.01745156f, 
    0.08189131f, 0.03256611f, -0.03096860f, 0.01410564f, -0.02153647f, 0.06997834f, -0.08555605f, -0.07893130f, 
    -0.08185348f, -0.08960386f, -0.18993220f, -0.02393903f, -0.01171139f, -0.09358358f, -0.02179119f, 0.04702910f, 
    0.10361082f, 0.03718346f, -0.13764313f, -0.18459459f, -0.11203381f, -0.07055676f, 0.14138898f, -0.05353389f, 
    0.52526128f, 0.08559911f, 0.02862871f, -0.02251893f, -0.04495696f, 0.17734665f, 0.11042479f, -0.01441008f, 
    0.23927817f, 0.13067153f, 0.12996508f, 0.01276273f, -0.05611230f, -0.06680864f, 0.07359098f, 0.18493108f, 
    0.11723968f, 0.06553886f, 0.14856935f, 0.13800317f, -0.01524749f, -0.04977075f, -0.12173951f, 0.04902364f, 
    -0.18021715f, 0.13943733f, 0.09972292f, 0.16676927f, -0.06934526f, -0.12110907f, -0.08301642f, 0.06850890f, 
    -0.02372354f, 0.11691302f, -0.10236250f, -0.09483416f, 0.11526210f, -0.04455481f, 0.15559013f, -0.07218350f, 
    -0.17431414f, -0.03924551f, -0.08867369f, -0.11183630f, 0.31986746f, 0.00725605f, 0.15743621f, 0.11407480f, 
    0.00530652f, -0.08303380f, 0.19958401f, 0.15711890f, 0.08399308f, -0.00680460f, 0.13882199f, -0.08367743f, 
    0.17549178f, 0.06393389f, 0.21593964f, 0.04574975f, 0.29313344f, -0.03585839f, 0.18484513f, 0.05060303f, 
    0.10022166f, -0.07934225f, 0.04771527f, -0.06123479f, 0.00555390f, 0.08281800f, 0.02953966f, -0.03324053f, 
    -0.08692441f, 0.02629457f, -0.00693886f, -0.15232007f, 0.04013290f, -0.09072688f, -0.06159520f, -0.02361726f, 
    -0.07156423f, 0.24796043f, 0.20444769f, 0.12838277f, -0.33010888f, -0.06880173f, 0.05380617f, -0.05766966f, 
    0.14005116f, 0.09564579f, 0.07683983f, 0.01608596f, 0.03978666f, 0.14947428f, 0.12962011f, 0.14342591f, 
    0.18325262f, 0.09637986f, -0.00038527f, 0.05663031f, 0.15903100f, -0.28492454f, 0.28287959f, -0.35578924f, 
    0.29342863f, -0.08285732f, -0.02418994f, -0.06753472f, 0.01377553f, -0.20260076f, -0.11386676f, -0.11034242f, 
    -0.07070296f, 0.00286642f, 0.08885070f, 0.03362653f, 0.00243895f, 0.04985034f, 0.09356529f, -0.03277798f, 
    -0.47178531f, 0.11150786f, 0.06913557f, -0.05404096f, 0.08254337f, -0.10809605f, -0.09422264f, 0.05455808f, 
    0.07281200f, 0.11632470f, -0.15882933f, -0.04008983f, 0.02679281f, -0.09137610f, -0.08655619f, -0.08453041f, 
    -0.12127816f, -0.06304026f, -0.13346367f, -0.08386964f, 0.39952365f, -0.05349170f, 0.11028530f, 0.17329998f, 
    0.09172384f, -0.19668855f, -0.24683121f, 0.14963697f, 0.07473569f, -0.19868138f, -0.06681370f, -0.07446382f, 
    -0.04377090f, 0.07514742f, 0.06199089f, 0.09687546f, 0.06382900f, 0.02935402f, 0.13032891f, 0.07913848f, 
    -0.02031387f, -0.29963607f, -0.21269707f, -0.13959360f, 0.58922058f, -0.06066598f, 0.33252588f, 0.20863231f, 
    -0.26000151f, -0.06365457f, 0.07444164f, -0.05767179f, -0.00880828f, 0.08046240f, 0.04589590f, -0.00380278f, 
    0.29313415f, 0.04092836f, 0.28880617f, -0.02998214f, 0.43037218f, -0.11497363f, 0.33733913f, -0.19735949f, 
    0.16824973f, -0.27414009f, -0.18443576f, 0.02467074f, -0.00096128f, -0.00671548f, -0.09997017f, -0.00422242f, 
    0.00712214f, -0.00489799f, 0.05475215f, -0.02105135f, 0.15828381f, -0.06191218f, 0.02379412f, -0.07486672f, 
    0.30621615f, -0.18814941f, 0.47910869f, -0.27829289f, 0.25003067f, -0.06826200f, 0.02722635f, 0.02618943f, 
    0.16365805f, -0.00513081f, -0.04808989f, -0.03999375f, -0.03306139f, -0.02437620f, 0.04955128f, -0.01108890f, 
    0.18316056f, -0.06352440f, -0.00960425f, -0.07362940f, -0.33479029f, -0.01588509f, 0.18372355f, -0.22894005f, 
    0.02232684f, -0.07538100f, 0.20189753f, -0.03060548f, 0.21556555f, 0.04746620f, 0.06609595f, -0.02136646f, 
    -0.13417116f, -0.00355929f, -0.03866901f, -0.03616428f, 0.02680576f, -0.02816525f, -0.04264768f, -0.07962656f, 
    0.31574184f, -0.19529460f, 0.28388977f, 0.03548679f, 0.02180549f, 0.12751503f, -0.13477872f, -0.13497443f, 
    0.04848021f, -0.15494916f, -0.04504844f, 0.00029565f, -0.06335906f, 0.08423780f, 0.06049821f, 0.09669045f, 
    0.16039236f, 0.09406460f, 0.15143400f, 0.10501205f, -0.02313223f, 0.18205416f, -0.20396256f, 0.05676113f, 
    0.08626834f, -0.06528161f, -0.10225544f, 0.06779901f, -0.00966061f, -0.01897431f, 0.16582161f, 0.05302215f, 
    0.09787977f, -0.15157993f, 0.04509473f, 0.20264621f, -0.01421845f, 0.07753874f, 0.25551349f, -0.05822876f, 
    -0.20882022f, -0.35040939f, -0.44373930f, -0.45069736f, 0.15452673f, -0.14595874f, 0.06553975f, -0.06202540f, 
    0.13057558f, -0.32302076f, -0.06085760f, -0.07718200f, 0.08086536f, -0.11106636f, -0.05581583f, -0.01842068f, 
    -0.06520856f, 0.10021408f, 0.29647252f, 0.04020026f, -0.35964549f, -0.13599773f, -0.40211582f, 0.05510288f, 
    -0.06593534f, 0.09276427f, -0.06176323f, -0.24940826f, -0.10303760f, -0.22897676f, -0.00233426f, -0.02562845f, 
    -0.12705503f, -0.04862995f, -0.01748199f, -0.05482363f, -0.09915084f, 0.16106956f, -0.04206979f, -0.13446046f, 
    -0.52867651f, 0.50486797f, 0.14452653f, -0.07980067f, 0.08306829f, -0.23973002f, 0.07876612f, 0.17751263f, 
    -0.02454370f, 0.09613788f, -0.13144548f, 0.03412392f, 0.05362592f, -0.04894228f, -0.06921230f, -0.06565256f, 
    -0.00520952f, -0.06396762f, 0.02891251f, -0.08931206f, 0.04299921f, 0.29666018f, -0.53514624f, 0.34519345f, 
    -0.12050810f, 0.10285326f, 0.22711012f, 0.00559782f, 0.08259758f, -0.14987093f, 0.12407550f, -0.06239574f, 
    -0.02776806f, -0.08554139f, 0.07410540f, 0.08791019f, -0.04257771f, 0.20257708f, 0.06057288f, -0.08719282f, 
    -0.10337269f, -0.07834331f, -0.02057177f, 0.08991598f, 0.04780365f, 0.04519037f, 0.08886528f, -0.07634641f, 
    0.07301498f, 0.03362692f, -0.03322678f, 0.06457412f, 0.12394220f, 0.02615950f, -0.01213322f, 0.14644817f, 
    -0.10030713f, -0.08586132f, 0.06570862f, 0.00187981f, -0.39943454f, -0.07372361f, 0.33063409f, 0.09892613f, 
    0.03709938f, 0.16908732f, -0.05847424f, 0.12619805f, -0.02573306f, 0.14665845f, -0.18543059f, -0.18479903f, 
    -0.12636814f, 0.18837848f, 0.03988606f, -0.10325261f, 0.07737164f, 0.03005819f, -0.12323192f, 0.02084024f, 
    0.22019617f, -0.07356245f, 0.14883558f, 0.12650004f, -0.05791173f, -0.01572866f, 0.12057500f, 0.14408982f, 
    0.19593258f, 0.00084843f, -0.04695543f, 0.00275822f, -0.03235547f, 0.01449018f, -0.08302712f, -0.06214022f, 
    -0.00609396f, 0.02950882f, -0.02227438f, -0.11440387f, 0.34204796f, -0.21096092f, 0.02354602f, 0.12794892f, 
    0.00163238f, -0.06376305f, 0.11476595f, -0.03621318f, 0.13186051f, 0.10156103f, 0.19039021f, 0.02002832f, 
    0.03735568f, -0.00939572f, -0.00653794f, -0.20950766f, 0.09067038f, -0.14168227f, 0.12122852f, 0.06717599f, 
    -0.02994774f, -0.08090959f, 0.13894661f, -0.01639169f, 0.10238411f, -0.13942108f, -0.04314020f, 0.01312115f, 
    -0.05793141f, -0.07993138f, -0.07688453f, -0.00263434f, 0.06242628f, -0.00587347f, -0.08055598f, 0.03083842f, 
    0.18687293f, 0.01840644f, 0.08937103f, 0.10692832f, 0.32107148f, 0.01627645f, -0.03004061f, 0.17940909f, 
    -0.00027277f, -0.05639134f, 0.04963708f, 0.01919086f, -0.06563830f, -0.02610773f, -0.05739176f, 0.00747375f, 
    0.00263766f, -0.03358236f, 0.04609858f, 0.00081609f, 0.04191673f, 0.07556996f, -0.01447398f, -0.04100838f, 
    0.15829290f, 0.00013456f, 0.08313931f, -0.09808879f, 0.07496938f, 0.06787122f, -0.02307081f, 0.00345157f, 
    0.04099182f, 0.09868460f, 0.03819026f, 0.04256037f, 0.14145726f, 0.05481440f, 0.17762427f, 0.04900946f, 
    -0.00308564f, -0.11863855f, -0.01465173f, -0.08292950f, 0.40169221f, -0.07143647f, 0.18236490f, -0.13553356f, 
    0.10877386f, -0.18659508f, -0.08168004f, -0.04043845f, 0.05943783f, 0.00784150f, 0.01294830f, 0.03777021f, 
    -0.01654588f, 0.03042084f, 0.03527208f, 0.04636164f, -0.03646607f, -0.06646234f, -0.13625374f, -0.10586001f, 
    -0.11287663f, 0.06662973f, -0.21048781f, 0.05774033f, 0.07539943f, 0.01785668f, 0.06572320f, 0.16578485f, 
    -0.13100985f, -0.12359159f, -0.22175016f, -0.03586952f, -0.04657330f, 0.07020573f, -0.14916316f, -0.13016993f, 
    -0.11324935f, 0.14093548f, 0.12460752f, 0.18632266f, -0.27750602f, 0.11938147f, 0.02031314f, 0.24148433f, 
    0.01876705f, 0.10759557f, -0.25147891f, 0.08279401f, -0.08571177f, 0.11990472f, -0.09212140f, 0.00262371f, 
    -0.04944628f, -0.08613354f, -0.14370343f, 0.12375750f, 0.10897167f, 0.27600685f, 0.00625695f, 0.02319472f, 
    -0.17355272f, -0.07839447f, -0.07630999f, -0.06058135f, 0.07253585f, 0.11369281f, 0.06744148f, 0.05548015f, 
    0.00442714f, 0.21926795f, -0.14301571f, -0.03963989f, 0.08379917f, 0.10415327f, 0.04384810f, -0.08728161f, 
    -0.07756361f, -0.12441496f, -0.04229245f, 0.02087217f, 0.20174547f, -0.02604619f, 0.14886011f, 0.08536145f, 
    0.18283832f, -0.03707556f, -0.02257654f, -0.02239605f, -0.09110808f, 0.10588026f, -0.04127196f, 0.12541780f, 
    -0.00611750f, 0.06773020f, 0.05629138f, -0.05355155f, -0.01911719f, -0.08196189f, 0.04734415f, -0.08523525f, 
    0.02350220f, -0.02318699f, 0.22332332f, 0.01215213f, 0.03849036f, 0.02252287f, -0.01395670f, -0.04529500f, 
    0.10413041f, 0.05182049f, 0.01377272f, 0.05158899f, 0.08118004f, 0.11614767f, 0.01895360f, 0.20096768f, 
    0.00721632f, -0.11147156f, -0.00354827f, 0.08484773f, 0.07769633f, -0.04792005f, 0.03949813f, -0.03916581f, 
    0.04268181f, -0.01863440f, 0.00294395f, 0.01464329f, 0.06360723f, 0.08676831f, 0.02554806f, 0.13130140f, 
    -0.06530780f, -0.06127628f, -0.05041488f, -0.12497744f, -0.20338346f, -0.04912400f, -0.06953689f, -0.07545782f, 
    -0.00951506f, -0.16164783f, -0.08195755f, 0.23176463f, 0.25118458f, 0.17292120f, 0.13118517f, 0.13001511f, 
    -0.18389732f, 0.01134221f, -0.03993643f, 0.03069614f, -0.00824895f, 0.14995956f, -0.08414133f, 0.15012027f, 
    0.04256452f, -0.02861162f, 0.11747050f, 0.06065029f, 0.22178045f, -0.13790219f, 0.19602367f, -0.10445596f, 
    0.19980241f, 0.03401704f, 0.09226552f, -0.00105348f, 0.08848680f, 0.05142334f, -0.10160474f, -0.03309146f, 
    -0.03558528f, 0.10637096f, 0.07377207f, -0.19450800f, -0.11057800f, -0.10163978f, 0.05078287f, -0.17822391f, 
    -0.02806315f, 0.56053156f, 0.36297548f, -0.18925862f, 0.30243975f, 0.05224788f, 0.09283938f, -0.08284762f, 
    0.20052466f, -0.02175710f, 0.00537048f, -0.04303201f, 0.09675511f, -0.00923595f, 0.06209703f, -0.02956335f, 
    -0.03732132f, 0.07740252f, 0.00491759f, -0.00613084f, -0.42948720f, 0.07101225f, 0.01088464f, -0.10541528f, 
    0.00991164f, -0.01539323f, -0.27808952f, -0.15052593f, -0.33542204f, -0.06703168f, 0.01826627f, -0.04053769f, 
    0.01270169f, 0.12454148f, -0.04021850f, -0.11228158f, -0.02460960f, 0.13941683f, -0.05484176f, 0.02800876f, 
    0.41661495f, 0.35822043f, -0.04427939f, -0.14295560f, 0.09040985f, 0.01766255f, -0.22130802f, -0.05292100f, 
    -0.13743882f, 0.14674611f, -0.02257087f, 0.06884816f, 0.00373672f, 0.02224633f, -0.04539927f, -0.00495105f, 
    0.03079725f, 0.07403845f, -0.05329015f, -0.17201488f, 0.15525259f, 0.02148658f, 0.08420280f, -0.11276212f, 
    -0.26665020f, 0.02005351f, -0.00501062f, -0.14761904f, -0.08264510f, 0.02178507f, 0.08366238f, -0.09870131f, 
    0.08622567f, 0.00736465f, -0.10536551f, -0.07894184f, 0.07067586f, 0.15717359f, -0.10047816f, 0.12588546f, 
    -0.25692597f, -0.18377933f, -0.31594923f, -0.13110492f, 0.05156697f, 0.01697530f, -0.01169277f, 0.08424784f, 
    0.04166597f, 0.00847626f, 0.02445314f, 0.08379883f, 0.00358969f, 0.10565630f, 0.04654696f, -0.00729372f, 
    0.02136246f, -0.08712750f, 0.03983339f, 0.05291133f, -0.08171360f, -0.01320673f, 0.05972001f, 0.22823560f, 
    -0.10526692f, -0.03825689f, 0.04253260f, -0.03104394f, -0.06036354f, 0.22917829f, -0.06564570f, 0.00696413f, 
    0.07483955f, 0.07737358f, 0.03145838f, -0.02695253f, 0.05695830f, 0.00681921f, 0.06496919f, 0.08064843f, 
    0.39808941f, 0.27983430f, 0.12793139f, -0.06731196f, 0.00009734f, -0.00054986f, -0.00601364f, -0.14251943f, 
    0.38610268f, 0.00678431f, 0.01162141f, 0.05039774f, -0.00854345f, 0.00667580f, -0.03893889f, 0.16278407f, 
    0.06465980f, 0.05759593f, -0.07372139f, 0.07577181f, -0.15193702f, -0.12808834f, 0.31784871f, 0.09687934f, 
    -0.09390441f, -0.03798005f, -0.08103994f, -0.21915030f, 0.00613223f, 0.03348556f, -0.04873580f, -0.09826881f, 
    -0.03725710f, 0.04313680f, -0.06297246f, 0.03323392f, -0.02414489f, 0.03557345f, 0.08397263f, 0.01483880f, 
    0.18061604f, 0.08302335f, 0.19268440f, 0.17932805f, 0.01053984f, -0.00154831f, 0.07847437f, 0.04850187f, 
    0.02008647f, 0.10820302f, -0.01303433f, 0.07063346f, -0.02504639f, 0.03825688f, 0.03767871f, -0.01626549f, 
    0.01885158f, 0.14469056f, -0.03579662f, 0.17480494f, 0.25961617f, 0.04207075f, -0.36307278f, -0.11789621f, 
    -0.03670892f, 0.04957304f, -0.02340910f, -0.06286068f, 0.01703667f, 0.13826883f, 0.00789270f, -0.01254266f, 
    0.01314643f, 0.06520563f, 0.07227555f, -0.05514171f, 0.12505560f, 0.08590448f, -0.04940975f, 0.12617487f, 
    -0.38587573f, -0.05888030f, 0.36784247f, -0.08327588f, 0.05072887f, -0.04836076f, 0.02360291f, -0.15903552f, 
    -0.05473117f, -0.03076794f, 0.12591180f, -0.08801340f, -0.01098476f, 0.01336294f, -0.04487192f, 0.02418742f, 
    0.04863955f, -0.00713558f, 0.01529307f, 0.04064158f, 0.21100052f, 0.09985077f, -0.05058667f, -0.11499465f, 
    0.07601436f, 0.10449944f, 0.18957110f, 0.02041934f, 0.03965672f, 0.12664562f, 0.09297331f, 0.08040456f, 
    -0.01810267f, -0.01624198f, 0.02941669f, 0.07582996f, -0.08205657f, 0.18371934f, 0.02578508f, -0.09862811f, 
    -0.04558332f, -0.02294977f, 0.13456337f, -0.12537353f, -0.13760273f, 0.06063997f, 0.02086459f, -0.08666105f, 
    -0.14965415f, -0.11679084f, 0.04147567f, -0.01918194f, -0.10035752f, -0.10487235f, 0.08875034f, -0.06960476f, 
    -0.03126141f, 0.00798818f, -0.06965453f, -0.12869424f, 0.06707604f, -0.07154131f, -0.42384449f, -0.07455287f, 
    -0.05969765f, 0.15878421f, 0.09747829f, 0.06443170f, 0.02860503f, -0.12196625f, -0.00577795f, -0.11216946f, 
    -0.00342390f, -0.00507255f, 0.02915601f, -0.03590427f, -0.00799778f, -0.03338014f, -0.01502268f, 0.10567351f, 
    -0.02565867f, -0.02827226f, -0.36510238f, -0.02295662f, 0.10822549f, -0.01698387f, 0.10360176f, 0.14421472f, 
    0.05847301f, 0.06976546f, -0.01803367f, -0.02887238f, 0.02224148f, 0.04733079f, 0.06434570f, 0.00076365f, 
    0.05570652f, 0.04217720f, -0.04260268f, 0.03350377f, 0.05115961f, 0.03245219f, -0.25281009f, -0.03568978f, 
    -0.01184697f, 0.13078789f, 0.11430220f, 0.06231714f, -0.03513354f, 0.06217961f, 0.04164365f, 0.12684023f, 
    0.04743636f, 0.06945463f, -0.06236452f, 0.09140544f, 0.13909936f, 0.09594388f, 0.10662153f, 0.07011668f, 
    -0.08412034f, 0.13971724f, -0.27692342f, -0.20720102f, 0.13800943f, -0.01558746f, -0.18137281f, -0.19387969f, 
    -0.07769392f, -0.03706803f, 0.03200923f, 0.05415369f, 0.20928320f, -0.00941620f, 0.08024367f, 0.05888819f, 
    -0.07125058f, -0.15513247f, 0.20726614f, 0.06944621f, -0.23890740f, -0.09080989f, -0.33818126f, -0.09117005f, 
    -0.01717297f, -0.02005378f, -0.04265040f, 0.00658261f, 0.06926893f, -0.09229650f, 0.01471776f, 0.03959493f, 
    0.07705813f, 0.01770290f, 0.11903588f, 0.09298475f, 0.07601248f, -0.00516012f, 0.04924743f, -0.03775646f, 
    -0.18575574f, 0.08890498f, 0.07966323f, -0.06722944f, 0.12746589f, 0.06676987f, 0.09510057f, -0.10450422f, 
    -0.10290033f, 0.06590094f, -0.06834685f, 0.09946490f, 0.07042791f, 0.09332602f, 0.05992474f, 0.09194321f, 
    0.03875969f, 0.10838404f, 0.08071822f, 0.00219829f, 0.02906336f, 0.13598381f, 0.11955461f, 0.11767695f, 
    -0.03691761f, -0.07416361f, -0.11175207f, -0.15691741f, -0.13313642f, 0.04215256f, 0.04401992f, 0.01637978f, 
    -0.04856474f, 0.21214992f, 0.01153881f, 0.06171099f, 0.06626994f, 0.03742927f, 0.18258093f, 0.05252318f, 
    -0.03715811f, 0.15111300f, -0.03559454f, 0.04313894f, 0.10846301f, 0.11643941f, 0.05099924f, 0.10994392f, 
    0.07422810f, 0.03041421f, 0.06025277f, 0.05713153f, 0.08569552f, -0.03745195f, -0.02277686f, 0.06573422f, 
    -0.02169261f, 0.08569009f, -0.01715106f, 0.01124231f, -0.44865638f, 0.08358892f, 0.01348198f, -0.01183972f, 
    0.05670127f, -0.11551928f, -0.16290328f, -0.06840937f, -0.04485332f, -0.10929757f, 0.07627288f, -0.00747691f, 
    -0.05171437f, -0.03870158f, -0.08830426f, -0.06439947f, -0.07541888f, 0.00810801f, 0.08168785f, 0.06124478f, 
    -0.06302635f, 0.02539084f, 0.04530407f, 0.10520093f, 0.10764176f, -0.06996363f, -0.19056542f, -0.19851118f, 
    -0.14554565f, -0.12781072f, -0.01949825f, -0.01121696f, 0.11620455f, 0.02420841f, 0.10799839f, 0.06518054f, 
    -0.06195210f, 0.00057931f, 0.04897197f, 0.06682012f, -0.32561389f, 0.11296818f, 0.11644503f, 0.03643282f, 
    0.08795987f, 0.05596190f, -0.12634496f, -0.19042231f, -0.26729161f, -0.08456142f, -0.01435636f, -0.03336843f, 
    -0.14228794f, -0.02066212f, 0.04964738f, -0.10406602f, -0.04541694f, 0.08170038f, 0.00657604f, -0.02494140f, 
    0.01775668f, 0.14018390f, 0.06051696f, -0.00819987f, -0.08107781f, 0.18370219f, -0.08648904f, -0.05747645f, 
    0.15730432f, -0.13706544f, 0.08436108f, -0.14420694f, -0.06535636f, -0.13729726f, 0.01643033f, 0.01515895f, 
    -0.04527046f, -0.06310532f, -0.11357245f, -0.08459742f, -0.12393619f, 0.25998101f, -0.03829252f, -0.14635487f, 
    0.06427775f, 0.10671686f, 0.03153925f, 0.11192068f, 0.24495396f, -0.04755450f, 0.10531687f, 0.09652569f, 
    0.15504266f, -0.05929659f, 0.05510627f, -0.03065594f, -0.07041721f, 0.05386030f, -0.00880633f, 0.02188160f, 
    -0.05817974f, -0.18427587f, 0.05807970f, 0.01007288f, 0.02955840f, -0.15426362f, -0.17476977f, -0.10868773f, 
    0.01035606f, -0.19789098f, 0.06676503f, 0.02830176f, 0.04618980f, 0.03062053f, 0.12671112f, 0.00547233f, 
    -0.09114493f, -0.09413426f, 0.00622966f, -0.08281503f, -0.25528136f, 0.02250628f, -0.04672328f, 0.05832966f, 
    0.15182944f, -0.13066185f, -0.41064155f, -0.23733477f, -0.26772672f, -0.26379403f, 0.00448124f, -0.09211215f, 
    0.02599102f, 0.00304518f, 0.00071457f, -0.09281361f, 0.04270886f, 0.06771411f, -0.00755832f, 0.21287398f, 
    -0.07156464f, 0.10712113f, 0.19187349f, -0.14059320f, 0.12968901f, 0.12554432f, 0.06151274f, -0.07699555f, 
    -0.01075524f, -0.01344524f, 0.02399227f, 0.00476842f, -0.02887678f, 0.10326023f, 0.05742010f, 0.02590229f, 
    0.03195948f, 0.04375644f, 0.13650995f, 0.04443677f, -0.19534273f, -0.26800227f, -0.04369849f, -0.06002164f, 
    0.04658639f, -0.18738335f, -0.23888804f, -0.05389544f, -0.27929842f, -0.23984788f, 0.02458798f, -0.02335561f, 
    0.05522917f, 0.08946531f, 0.06037059f, -0.12294371f, -0.08780144f, -0.00208513f, -0.10436331f, 0.05654539f, 
    0.15014754f, 0.24486345f, 0.03271991f, -0.07685776f, -0.09456354f, 0.05713737f, 0.03819479f, 0.02054035f, 
    0.15228646f, 0.00113440f, 0.00795372f, -0.04414050f, -0.05483331f, -0.12905027f, -0.01356324f, 0.10028655f, 
    -0.18702397f, -0.07873114f, 0.04436428f, -0.09208822f, -0.02010425f, -0.16977644f, -0.18440622f, 0.02865356f, 
    -0.07983405f, -0.07125576f, -0.13184775f, -0.12546052f, -0.04485448f, 0.01944982f, -0.06924786f, -0.03436776f, 
    0.02742804f, -0.00461712f, 0.10743457f, -0.06947163f, 0.09935024f, -0.00405941f, 0.00438948f, 0.26270780f, 
    0.04202011f, 0.24234635f, -0.02521882f, 0.14883400f, 0.19584341f, 0.13247886f, -0.16993375f, -0.25981289f, 
    0.31893167f, -0.11581826f, -0.01317137f, 0.05532342f, -0.01239280f, -0.03873463f, 0.05322304f, -0.02235008f, 
    0.03290113f, -0.03395745f, -0.06495874f, 0.16022524f, -0.21558389f, -0.19648626f, 0.02632802f, -0.02467074f, 
    -0.02772149f, -0.06436030f, 0.06523712f, 0.05685955f, -0.05413790f, -0.01389009f, 0.07930613f, 0.12527668f, 
    0.04888043f, 0.15446259f, 0.06529969f, 0.00171527f, 0.00678517f, -0.06600308f, 0.00982942f, -0.00926869f, 
    0.02896443f, -0.14957702f, -0.12390508f, -0.15179400f, -0.15497978f, -0.03420327f, 0.07657518f, -0.00969818f, 
    -0.08217072f, 0.12184137f, 0.00449391f, 0.09134258f, 0.05450749f, 0.03107682f, -0.27400079f, -0.01801861f, 
    0.07873725f, -0.02275485f, 0.00755525f, 0.09316576f, -0.06074758f, 0.33384594f, 0.49385291f, -0.21069942f, 
    0.06669130f, -0.20455267f, 0.13538472f, -0.20283549f, 0.09843446f, 0.19617006f, 0.05721223f, -0.01950882f, 
    0.05639813f, 0.01656352f, 0.02109110f, -0.11815249f, -0.09321913f, 0.03050135f, 0.00955214f, -0.07419447f, 
    0.07920194f, 0.05809547f, -0.19492781f, 0.10352986f, 0.22642794f, 0.16411239f, 0.11569928f, 0.15528464f, 
    0.13469487f, -0.01277401f, -0.06482863f, 0.01740045f, -0.03485139f, 0.05221923f, 0.10410619f, -0.01609945f, 
    0.06254566f, 0.03549545f, -0.03061924f, -0.05957258f, -0.04334076f, -0.14263743f, 0.09421735f, -0.00855520f, 
    -0.29145822f, -0.14862999f, -0.02055106f, -0.13449308f, 0.00429145f, 0.05306160f, -0.04323994f, 0.06059135f, 
    0.03549060f, 0.04867724f, 0.02091650f, 0.05596269f, -0.02256955f, -0.13485885f, 0.07893629f, 0.02049877f, 
    0.06756945f, 0.07259935f, 0.20167968f, 0.00150655f, 0.25297436f, 0.15456358f, -0.14777702f, 0.00503799f, 
    0.12730570f, -0.07464440f, -0.06514117f, 0.11010151f, -0.01432281f, -0.11727309f, -0.17305827f, -0.01566647f, 
    -0.09008718f, 0.06982759f, -0.06833228f, 0.09159657f, -0.18420663f, -0.25236136f, -0.03516239f, 0.05375479f, 
    -0.02831620f, 0.09134212f, -0.09527297f, -0.19972315f, 0.04519376f, 0.07331801f, 0.10168023f, 0.07801118f, 
    0.02429051f, 0.00006930f, -0.01460863f, 0.05339926f, 0.06115267f, 0.02243403f, 0.11179401f, 0.05499268f, 
    -0.02610854f, -0.36762768f, 0.19476879f, 0.13784824f, -0.04689593f, 0.11475012f, -0.02340009f, -0.25293785f, 
    -0.14313792f, -0.02641465f, 0.10992613f, 0.08986402f, 0.04481147f, 0.03484184f, -0.00704579f, -0.14207101f, 
    0.06585585f, -0.03764371f, -0.01845709f, 0.05430238f, 0.03364113f, 0.22078107f, 0.19370216f, -0.10289087f, 
    0.15060720f, 0.00552923f, 0.03945420f, 0.16029759f, -0.01508252f, 0.05063145f, 0.10437176f, 0.14470258f, 
    -0.07441991f, -0.01597281f, -0.02498550f, 0.02978656f, -0.07508446f, 0.03259957f, -0.09792102f, 0.04590749f, 
    -0.48048341f, -0.31534097f, 0.03779272f, -0.06477769f, -0.30304900f, 0.04430238f, 0.07605208f, -0.12243000f, 
    -0.15001652f, -0.03334720f, 0.00741011f, 0.00407761f, -0.00708631f, 0.02882402f, 0.08295032f, -0.07275993f, 
    -0.01391938f, -0.02259295f, -0.00531078f, -0.07665500f, -0.08283622f, 0.08935736f, 0.02373205f, -0.07356717f, 
    -0.01493816f, 0.01251800f, -0.00711565f, -0.05130867f, -0.14616349f, -0.02331699f, -0.08956269f, 0.04638221f, 
    -0.16346695f, 0.00974346f, 0.13552715f, 0.04645910f, -0.05764827f, -0.21653287f, -0.08102660f, -0.07941782f, 
    -0.05138823f, 0.28479800f, 0.30407774f, -0.01707367f, -0.08648372f, 0.07504826f, 0.16196534f, -0.10127792f, 
    -0.00278545f, 0.24642912f, -0.09991460f, 0.01322962f, -0.02722672f, -0.00187240f, 0.06125935f, -0.16774963f, 
    -0.00398717f, 0.00509938f, -0.16537437f, 0.10359547f, 0.38443631f, 0.46455431f, 0.04196228f, 0.17644645f, 
    0.16484989f, 0.15481530f, 0.07820126f, -0.09323636f, 0.05572966f, 0.07087300f, 0.11180197f, 0.13842942f, 
    0.03280852f, -0.00713220f, 0.06375203f, 0.03355316f, -0.00164376f, -0.01838885f, 0.07866704f, 0.11954749f, 
    0.34120378f, 0.45285863f, -0.00313697f, 0.09599611f, 0.28220198f, 0.21057254f, 0.18654066f, 0.32094070f, 
    -0.01764853f, -0.07953784f, 0.04568302f, 0.01607927f, -0.04593404f, 0.02627720f, 0.07175206f, 0.01157801f, 
    -0.03515229f, -0.00607947f, -0.07663607f, -0.04053304f, 0.26679215f, 0.33171931f, -0.07251851f, 0.12966445f, 
    -0.02519960f, -0.02180695f, -0.01301420f, 0.09858581f, -0.04784631f, -0.04699304f, 0.03138850f, 0.05207726f, 
    0.06374655f, -0.04119440f, 0.03965321f, 0.05754238f, -0.08113931f, -0.06524699f, 0.17387182f, 0.15921800f, 
    -0.19472188f, -0.09092312f, -0.21316467f, -0.11459351f, -0.01748931f, 0.06028593f, 0.00644506f, -0.16201286f, 
    0.05798327f, 0.03948626f, -0.01230297f, 0.01250761f, 0.06157636f, 0.02862140f, -0.15739092f, -0.01236234f, 
    0.06510413f, -0.18021281f, -0.04210551f, 0.02451046f, -0.28711861f, 0.01313394f, 0.30782858f, -0.03099081f, 
    0.14285505f, 0.01687215f, 0.19946067f, 0.29100072f, 0.14814575f, -0.07380044f, -0.02447676f, 0.08068138f, 
    -0.06184474f, 0.04252170f, 0.09441457f, -0.10353732f, 0.00289702f, 0.04806565f, -0.07456902f, -0.14208491f, 
    -0.48709309f, -0.12795754f, -0.00399954f, 0.06631641f, -0.40768799f, -0.06099330f, 0.06160795f, 0.07049662f, 
    -0.06644417f, -0.09613339f, -0.06667906f, -0.06076835f, 0.06321562f, 0.04326878f, 0.03898963f, -0.05323460f, 
    -0.15893909f, -0.08240975f, -0.00629896f, -0.17745242f, -0.16565825f, -0.18514930f, -0.03388537f, 0.20066814f, 
    -0.37188831f, 0.08190003f, -0.22910291f, -0.03171879f, -0.00931397f, 0.08987363f, 0.07932130f, -0.00407342f, 
    -0.01171574f, 0.01833757f, -0.03681772f, 0.03857156f, -0.07044242f, -0.13441859f, -0.14769386f, 0.03031465f, 
    0.10797258f, 0.21451716f, 0.29487678f, 0.05359134f, 0.01972952f, -0.02203763f, 0.18757431f, 0.19236338f, 
    0.00750340f, -0.13037387f, 0.14473331f, 0.01901297f, 0.04438165f, -0.11496360f, 0.07182078f, 0.03188959f, 
    0.06203932f, -0.02664531f, -0.02654618f, -0.05690169f, -0.24530526f, -0.22842185f, -0.31643561f, -0.23187223f, 
    -0.15372162f, 0.00906555f, -0.05717913f, 0.05446222f, 0.01476123f, -0.02850772f, 0.01583394f, 0.00043294f, 
    0.08256194f, -0.00303880f, 0.03122435f, 0.05504299f, 0.04931360f, -0.14265361f, -0.07308368f, 0.00595586f, 
    -0.08574557f, -0.30717090f, -0.35628584f, -0.17822687f, -0.07073479f, 0.12967396f, 0.05052153f, -0.01121167f, 
    0.02161672f, 0.00916103f, 0.01143556f, 0.00297215f, 0.06521120f, -0.12240037f, 0.03706922f, 0.03051556f, 
    -0.01350740f, -0.08693255f, -0.01154425f, 0.04465270f, -0.24624638f, -0.54330760f, -0.35827616f, -0.06382354f, 
    -0.07658331f, 0.14038782f, 0.05613055f, -0.11527646f, -0.00748909f, 0.02263992f, 0.11946489f, 0.14993262f, 
    0.00964547f, 0.06749948f, 0.06897822f, -0.04730083f, 0.02346897f, -0.03146185f, 0.01847622f, 0.00781095f, 
    0.35512364f, 0.35035792f, 0.35959524f, 0.14449042f, 0.06674121f, 0.10359210f, 0.18576035f, 0.17623913f, 
    0.13034293f, 0.00818842f, 0.05669937f, 0.01939294f, 0.03963622f, -0.02291324f, 0.00135764f, -0.07580723f, 
    0.07861290f, 0.14657784f, -0.14037231f, -0.01225789f, 0.23270170f, 0.46727577f, 0.26598361f, -0.03401833f, 
    0.12123255f, -0.01055778f, 0.12568778f, 0.11261840f, 0.18335818f, -0.22073323f, 0.02632620f, 0.06384519f, 
    0.03760765f, -0.08247244f, 0.00702793f, -0.06843695f, 0.02980866f, 0.07596954f, -0.00033964f, -0.06486872f, 
    0.03701442f, -0.12651919f, -0.16615523f, 0.01060208f, -0.02851601f, 0.11560337f, -0.00335075f, 0.14927094f, 
    0.11598986f, 0.01196349f, 0.02000647f, 0.08839130f, 0.04852375f, -0.10394205f, 0.00938116f, 0.07443970f, 
    0.03713075f, -0.11909158f, -0.02417834f, -0.02474760f, -0.23000748f, -0.21260503f, -0.12810509f, -0.09709541f, 
    0.01131117f, 0.07031715f, 0.06766899f, -0.03242064f, -0.04020871f, 0.02793816f, 0.02647602f, 0.05153955f, 
    0.07662724f, 0.11492912f, 0.11045571f, 0.00564050f, 0.05122792f, -0.02598397f, 0.03032402f, 0.01986492f, 
    -0.30595735f, -0.29816878f, 0.06419647f, -0.09937747f, -0.15547837f, 0.02737345f, 0.00285869f, -0.11940989f, 
    -0.05574616f, -0.00062919f, -0.08250248f, -0.03625064f, 0.00374970f, 0.06278267f, -0.04084750f, -0.01418255f, 
    0.04578409f, -0.12478590f, -0.04426650f, -0.03317095f, -0.04798773f, -0.18349336f, -0.13468628f, -0.04216770f, 
    -0.04670577f, 0.03682117f, 0.05238586f, 0.04341312f, -0.01166540f, -0.04308557f, -0.00464512f, 0.03672126f, 
    0.01707010f, 0.02894039f, -0.01431275f, -0.04585683f, 0.03990326f, -0.02107664f, -0.07332164f, -0.09090987f, 
    0.47933626f, 0.25818279f, 0.31817889f, 0.09449707f, 0.01676290f, 0.11176620f, 0.01637753f, 0.06940813f, 
    0.13092852f, 0.02497716f, 0.07119515f, 0.04151079f, -0.01050996f, -0.04111573f, 0.04018879f, -0.04602310f, 
    -0.01578077f, -0.04153149f, 0.00867470f, 0.00599594f, 0.22126843f, -0.06027607f, -0.05110545f, -0.08839432f, 
    -0.02916602f, -0.05943346f, -0.03919113f, -0.02880568f, -0.07725955f, 0.15170386f, 0.02718824f, 0.09214477f, 
    -0.03733586f, -0.03772691f, 0.16732822f, -0.05903389f, -0.12617232f, -0.07122950f, -0.04569785f, 0.00744975f, 
    0.01284466f, 0.02675148f, 0.00619654f, -0.00818737f, -0.02356203f, -0.03354593f, 0.01451247f, -0.00867777f, 
    0.01868592f, -0.00280468f, 0.02244878f, 0.02905628f, 0.02171358f, 0.01152819f, -0.02971564f, 0.01513126f, 
    -0.02130963f, -0.03056545f, -0.02540270f, 0.03984413f, 0.00755071f, -0.02642544f, -0.01827156f, -0.00949582f, 
    -0.04399936f, -0.03332697f, 0.01614681f, -0.02016312f, -0.04172367f, -0.03901466f, -0.01828093f, -0.03078017f, 
    0.00358470f, -0.01430545f, -0.02003192f, 0.02288236f, -0.00814077f, 0.02025469f, -0.02473526f, 0.00387343f, 
    -0.03902658f, -0.00638382f, 0.02097732f, -0.04203845f, -0.03834022f, 0.02367765f, -0.04097908f, -0.01824896f, 
    -0.02672131f, 0.02716414f, -0.01603397f, -0.03399416f, -0.00888421f, -0.00083976f, 0.00137873f, 0.01767571f, 
    -0.00406209f, 0.00095849f, -0.02921362f, -0.02209303f, -0.03180657f, 0.00902915f, 0.02401570f, -0.04653390f, 
    -0.00028095f, 0.01791494f, -0.00850380f, -0.03356398f, 0.00418763f, -0.01900208f, -0.03931263f, -0.00909072f, 
    -0.00484650f, 0.02999936f, -0.02186892f, -0.00247414f, 0.03681618f, -0.00235542f, -0.03309545f, 0.00986935f, 
    -0.01341032f, -0.00747569f, -0.01822014f, 0.01709879f, -0.02491542f, 0.01832161f, -0.04283264f, 0.03023505f, 
    -0.03625869f, -0.02589214f, 0.02268126f, 0.04265281f, -0.02507131f, 0.00717872f, -0.03868799f, -0.04060607f, 
    -0.00750366f, 0.02097267f, 0.00271739f, -0.03021454f, -0.00268197f, -0.01410326f, -0.00580657f, -0.02898929f, 
    -0.00871379f, 0.00444483f, 0.00112756f, -0.00028942f, -0.02859903f, -0.02878449f, 0.02924553f, -0.03948369f, 
    0.01630921f, -0.00528624f, -0.01266068f, 0.03590335f, -0.00213669f, 0.02645961f, 0.00092196f, -0.00865276f, 
    0.01741867f, -0.04229866f, 0.02210424f, -0.00260001f, -0.02194642f, -0.01837962f, 0.00028075f, 0.03547491f, 
    0.02365688f, -0.03539953f, -0.04521933f, -0.01540895f, 0.01245343f, -0.00095899f, -0.00357224f, -0.01637895f, 
    -0.00814082f, -0.01556130f, -0.00817136f, 0.02490140f, -0.02421140f, 0.00397948f, 0.00066231f, -0.01522050f, 
    -0.03724549f, -0.03899313f, -0.03352764f, -0.03152694f, -0.01077961f, 0.03244751f, -0.01699790f, -0.01275837f, 
    -0.00367467f, 0.02584759f, 0.02448430f, -0.02311211f, -0.01772305f, -0.02906153f, 0.01901839f, 0.03783466f, 
    -0.01770761f, 0.00592935f, -0.02144381f, -0.01017273f, 0.02964035f, 0.00618332f, -0.04386010f, -0.01267834f, 
    0.02757473f, 0.01021966f, -0.01698922f, -0.02362284f, 0.03182498f, -0.03015044f, -0.02396210f, 0.03499610f, 
    0.01527919f, -0.03064798f, -0.01254760f, 0.01846837f, 0.02545411f, -0.03881576f, 0.01160441f, 0.01828593f, 
    -0.03416489f, -0.03342460f, -0.01587113f, -0.01706059f, 0.00526712f, -0.00074073f, -0.01483292f, 0.03627985f, 
    -0.00868700f, 0.01790398f, 0.02354900f, 0.00035532f, -0.01206148f, 0.02222644f, 0.02157238f, 0.03303649f, 
    0.00615447f, 0.02051217f, -0.00793441f, -0.03613019f, -0.03555932f, 0.03433272f, -0.02176611f, -0.00389355f, 
    -0.01737247f, 0.00778668f, 0.02038761f, -0.00626871f, -0.00026962f, -0.00044552f, -0.01674188f, 0.03244948f, 
    -0.01741222f, 0.02686334f, 0.00615443f, -0.01168530f, -0.02130354f, -0.01797577f, -0.02757327f, -0.02713239f, 
    0.02700863f, 0.01295274f, 0.00606424f, 0.00776223f, 0.02271655f, 0.02349333f, -0.03214539f, 0.00784072f, 
    -0.00258169f, -0.02617363f, 0.01938473f, -0.02648799f, -0.03190103f, 0.03522386f, 0.00104687f, 0.02510871f, 
    0.02047339f, -0.03536735f, 0.01079859f, -0.01478365f, 0.00916895f, -0.01501257f, -0.01502444f, 0.00186913f, 
    -0.01070289f, 0.00208410f, -0.00059037f, -0.02548841f, -0.01266888f, 0.01822262f, 0.00200253f, 0.00908000f, 
    0.00536074f, -0.00942393f, 0.00186910f, -0.04767147f, -0.00384839f, -0.00460773f, 0.00162416f, 0.00442360f, 
    0.01564626f, -0.01975099f, 0.02289083f, -0.01680328f, 0.02309165f, 0.00484654f, 0.02670820f, -0.03282382f, 
    -0.04210771f, -0.00452312f, 0.00720457f, -0.03609233f, -0.03405886f, 0.01551321f, -0.02215342f, -0.01452292f, 
    0.02578482f, -0.01403234f, 0.00519249f, -0.02688132f, -0.03486006f, 0.02646890f, -0.01128421f, -0.03477825f, 
    -0.03190947f, 0.00590057f, 0.01913415f, 0.02374823f, -0.03121276f, 0.02224526f, 0.00784452f, -0.01688183f, 
    0.00070817f, -0.01797590f, -0.01898036f, -0.03742964f, -0.03476420f, -0.03207736f, -0.02961085f, -0.03105028f, 
    -0.00316114f, -0.03707125f, -0.03574491f, 0.03506650f, 0.02514317f, -0.01271702f, -0.03025552f, 0.03439702f, 
    0.00979529f, -0.03876530f, 0.01035410f, -0.02986898f, 0.01971584f, -0.00091303f, -0.03289860f, 0.01027868f, 
    0.01062194f, -0.01189056f, 0.02043100f, 0.01451504f, 0.00298604f, -0.02936034f, -0.01022475f, 0.01624843f, 
    0.00442216f, -0.04380979f, -0.01049142f, -0.00215146f, -0.01985576f, -0.00596181f, -0.01901983f, -0.01247844f, 
    0.01957186f, -0.00800136f, 0.00347645f, -0.00356650f, 0.01983744f, -0.02295060f, -0.03820624f, -0.01576058f, 
    0.02726528f, -0.03302628f, -0.03633200f, 0.01424893f, 0.02059347f, 0.01386868f, 0.01445810f, 0.03840354f, 
    -0.03366753f, 0.03290445f, -0.00671285f, 0.01910784f, -0.02714467f, -0.00620512f, -0.00221341f, 0.00181626f, 
    -0.01598173f, -0.00385050f, -0.01999527f, -0.02398697f, -0.03562662f, -0.01556550f, -0.04145182f, -0.02884633f, 
    0.02987969f, -0.03730527f, -0.02540106f, -0.03973039f, 0.01103684f, 0.02597318f, 0.03189597f, 0.02810076f, 
    0.03306554f, -0.00649271f, -0.01473043f, -0.00652707f, 0.02958286f, 0.00302321f, 0.03246091f, 0.03111232f, 
    -0.01050264f, -0.03575528f, -0.02919887f, -0.03731627f, 0.01517103f, 0.01410552f, -0.03134950f, 0.02916097f, 
    0.03003718f, 0.00318460f, -0.00711950f, -0.00944786f, -0.02454641f, -0.04246169f, 0.01500976f, 0.02053952f, 
    -0.00092382f, -0.03028378f, 0.03820029f, -0.01538762f, -0.00408571f, -0.03083532f, -0.00273474f, -0.03684267f, 
    0.02438453f, 0.02947046f, -0.01427847f, 0.02425033f, -0.03183620f, 0.01547435f, -0.03798599f, -0.02421412f, 
    -0.01940692f, 0.03380250f, 0.03426145f, -0.03719024f, 0.03082359f, 0.01472293f, -0.01049497f, -0.01404960f, 
    0.01235937f, -0.02659911f, 0.03038081f, 0.02814889f, 0.00971843f, -0.01442998f, 0.01473140f, 0.00483885f, 
    -0.00652543f, 0.02084697f, 0.00169155f, 0.02832507f, 0.03389493f, 0.03161283f, -0.02292081f, -0.01656052f, 
    -0.01485453f, -0.00679625f, 0.02426761f, -0.03423853f, 0.00813807f, -0.02063240f, -0.02604686f, -0.04680277f, 
    0.01952968f, 0.00349785f, -0.01326626f, 0.03399684f, 0.01658355f, -0.02138812f, -0.03048671f, -0.00812488f, 
    -0.03290376f, -0.02453680f, -0.04333503f, 0.02624534f, 0.01744908f, -0.01907307f, -0.01466479f, -0.00150710f, 
    -0.02142637f, -0.02225714f, -0.03095551f, 0.01969540f, 0.01021253f, 0.02918767f, 0.03121418f, 0.01425819f, 
    -0.01821319f, -0.01415516f, 0.03125332f, 0.02555079f, -0.01912877f, 0.00071020f, -0.00445797f, -0.01174756f, 
    0.01137193f, 0.02239492f, 0.03524163f, -0.01552031f, -0.01988328f, -0.00615303f, 0.02176815f, -0.00410500f, 
    0.01386884f, 0.02299119f, -0.02694814f, -0.03866928f, 0.01232600f, 0.01330926f, -0.03804373f, 0.01632519f, 
    0.01840099f, -0.01521450f, 0.00991635f, 0.02162405f, -0.01016831f, -0.00369944f, -0.01214579f, 0.03103913f, 
    0.02484855f, -0.03205099f, -0.00301780f, -0.03077982f, 0.01262700f, 0.00061571f, -0.00077485f, -0.00916152f, 
    -0.03456837f, -0.01483167f, -0.03756277f, 0.00671913f, 0.01866971f, -0.00805018f, -0.00040069f, 0.02435708f, 
    -0.02075157f, 0.00671660f, 0.02826149f, -0.03822515f, 0.03473729f, -0.04567428f, -0.01721474f, 0.01762679f, 
    0.03451368f, 0.00814632f, -0.00879191f, -0.01941069f, 0.03150831f, 0.01223964f, -0.03296498f, -0.01998591f, 
    -0.01320234f, 0.01788532f, -0.02154195f, -0.02441706f, -0.00693275f, 0.00027651f, 0.00152340f, -0.02608760f, 
    -0.01378270f, -0.01435532f, 0.00568591f, -0.00139373f, -0.00528887f, 0.00201434f, -0.00709957f, -0.01484709f, 
    -0.01104033f, -0.03472387f, -0.01019657f, -0.03512614f, -0.03371807f, 0.02526149f, 0.01940686f, 0.02208951f, 
    0.01410179f, -0.03343027f, -0.02870391f, -0.03843173f, -0.00238686f, -0.03390600f, -0.01047015f, 0.01513439f, 
    0.03244177f, 0.01709636f, 0.02848731f, 0.02896947f, -0.03002558f, -0.01685549f, -0.02071933f, 0.03368260f, 
    0.03018502f, 0.03554560f, -0.03287448f, -0.03195569f, -0.03819485f, -0.00620999f, -0.00456522f, -0.03028673f, 
    0.02768539f, -0.03046625f, 0.02048910f, 0.00158369f, 0.02587388f, -0.00582271f, -0.01328988f, 0.00360568f, 
    0.02018511f, 0.02793049f, -0.02236307f, 0.01017548f, -0.01949121f, -0.03371925f, -0.04012591f, -0.02005529f, 
    0.02540172f, 0.01602418f, -0.02030401f, -0.03647289f, -0.03156419f, -0.02003519f, -0.04252903f, 0.02490659f, 
    0.03572183f, 0.01087325f, -0.04624204f, -0.00568351f, 0.01935797f, -0.00382414f, -0.04025587f, -0.03493142f, 
    0.02399619f, -0.02582057f, 0.00350343f, 0.01130078f, 0.00320469f, -0.02038705f, -0.00688369f, -0.03627490f, 
    0.01734549f, -0.00337851f, -0.02530842f, 0.01074694f, 0.02697534f, 0.03158652f, 0.01500848f, -0.00598623f, 
    0.01430729f, -0.02268459f, -0.02953922f, -0.00124162f, 0.01226508f, 0.03477153f, -0.01797361f, -0.01691585f, 
    -0.49211222f, -0.29601327f, -0.19390282f, 0.15607481f, 0.19337876f, -0.20911071f, 0.29385772f, 0.10503312f, 
    -0.36049423f, 0.09028401f, 0.05556503f, 0.00591919f, 0.06802946f, -0.03151496f, -0.01976364f, 0.00204733f, 
    0.00751343f, 0.16977437f, 0.18382704f, 0.04364081f, 0.01990763f, -0.04516402f, -0.15935890f, -0.13325141f, 
    0.07951151f, -0.04920251f, -0.05383631f, 0.07394011f, 0.08512408f, 0.06022293f, 0.04353629f, 0.02198607f, 
    -0.13156646f, -0.02158290f, -0.13960338f, -0.07422797f, 0.08390205f, 0.04330355f, 0.03124287f, 0.02895483f, 
    -0.05915190f, 0.29314381f, -0.05175249f, -0.18522131f, -0.05076587f, -0.02803416f, -0.01234442f, -0.00354430f, 
    0.03123502f, -0.03706270f, -0.06929860f, -0.07210102f, -0.00433054f, -0.01228698f, -0.03418963f, 0.14191741f, 
    0.17863016f, 0.13725419f, 0.15124172f, 0.03781406f, 0.00579290f, 0.02949074f, -0.57326764f, -0.33019084f, 
    -0.02330030f, 0.13925660f, 0.18112567f, 0.15762518f, 0.12063338f, -0.06912777f, -0.02133710f, 0.03469647f, 
    0.03165484f, 0.02894367f, 0.01401959f, 0.00709352f, 0.07955786f, 0.03823223f, -0.06053768f, -0.11185586f, 
    -0.32309431f, 0.19894078f, 0.45548052f, 0.14866312f, 0.07669061f, -0.05880538f, -0.07075648f, -0.06528611f, 
    -0.03526320f, -0.23754704f, 0.04242079f, -0.03864244f, 0.26075178f, 0.07484227f, 0.16879424f, 0.02724146f, 
    -0.03980019f, -0.06796494f, -0.03488623f, 0.01329098f, 0.00591407f, -0.12237620f, -0.23168179f, -0.25113106f, 
    0.16289441f, 0.21099995f, -0.02447094f, 0.25145847f, 0.10715308f, 0.01038817f, 0.06178987f, -0.01366797f, 
    -0.02071541f, 0.03567400f, 0.05583249f, 0.09988021f, -0.04649083f, 0.00621345f, 0.06882934f, -0.01997063f, 
    -0.35650909f, -0.06841742f, -0.32262322f, -0.01486823f, 0.10955477f, -0.15083729f, 0.42870995f, -0.08245761f, 
    -0.09650873f, 0.08510001f, 0.09892154f, -0.02639370f, -0.01301306f, -0.17023112f, 0.02925816f, 0.06513913f, 
    0.04760930f, 0.07618467f, 0.14623359f, -0.14403039f, -0.15261251f, -0.08824930f, -0.26428097f, -0.14950792f, 
    0.14323428f, -0.05145292f, 0.02547703f, 0.19158041f, 0.00982409f, 0.02256072f, 0.02465934f, -0.01599875f, 
    -0.01550428f, 0.01217099f, 0.02283867f, 0.05706865f, 0.07020036f, 0.02562594f, 0.06137856f, 0.09965168f, 
    -0.16997781f, 0.26356584f, -0.22031786f, -0.23966007f, 0.27660790f, -0.17441657f, 0.04833002f, 0.28267270f, 
    0.10229664f, 0.04124038f, 0.02758424f, -0.07756744f, -0.01387876f, -0.02502503f, -0.06038911f, 0.04684849f, 
    0.33675981f, -0.02958176f, 0.14461303f, 0.00003015f, -0.15339367f, 0.21607062f, -0.06526764f, -0.03165835f, 
    0.09924338f, -0.12589990f, 0.08224328f, -0.26791757f, -0.06930129f, -0.00974837f, -0.10734244f, 0.03152996f, 
    0.00044076f, -0.00319796f, -0.02426286f, 0.02327110f, -0.01680832f, -0.00111872f, 0.02227515f, -0.03936277f, 
    0.23117433f, -0.01814522f, -0.05000033f, -0.04466856f, -0.14393207f, -0.02543590f, 0.01014230f, 0.17784685f, 
    0.08460506f, 0.07374396f, 0.03008581f, 0.05862125f, -0.10519639f, -0.01039427f, 0.08423875f, 0.13232377f, 
    0.09627707f, 0.01072734f, -0.05667050f, -0.03372817f, -0.10781999f, 0.09839440f, -0.28900498f, -0.06549415f, 
    0.13269721f, 0.15483530f, 0.10050678f, 0.17646125f, -0.01229035f, 0.12481216f, 0.02580649f, 0.14608921f, 
    0.20349765f, 0.05367626f, -0.05736051f, 0.21635960f, -0.04171863f, 0.13146694f, 0.29132912f, 0.15401232f, 
    -0.53783363f, -0.63615662f, -0.48099366f, -0.39769560f, -0.13703181f, -0.07478978f, -0.00800849f, -0.14242145f, 
    -0.10848200f, -0.23056290f, -0.00162619f, -0.01254946f, -0.01990838f, -0.00496767f, 0.03158621f, -0.02526385f, 
    -0.14635292f, 0.15360874f, 0.18428947f, 0.14322302f, -0.51123226f, -0.44637504f, -0.33169124f, -0.42090732f, 
    -0.43525615f, 0.02892851f, -0.26032087f, -0.05151346f, 0.05191441f, -0.05992919f, -0.07980283f, 0.02587108f, 
    -0.01450057f, -0.05602976f, -0.02061890f, -0.02818145f, -0.07034291f, 0.07349021f, -0.10370913f, -0.25794831f, 
    -0.37687063f, 0.34380040f, 0.27510101f, 0.10199959f, -0.06091479f, -0.16583289f, -0.08109446f, -0.07030462f, 
    -0.15245609f, 0.18664013f, -0.00901153f, 0.11555976f, 0.06740627f, -0.00179455f, 0.13329130f, 0.04260789f, 
    -0.06585552f, -0.05369077f, 0.02701112f, -0.02835116f, -0.03879383f, 0.36466643f, -0.08453729f, -0.07080288f, 
    -0.22683288f, 0.13783169f, -0.00376123f, -0.22106452f, 0.01729748f, -0.20087005f, 0.05305345f, 0.16496429f, 
    -0.01996588f, -0.04231590f, 0.11898804f, -0.07471921f, 0.10014106f, 0.09546791f, -0.07149766f, -0.04031173f, 
    0.03980421f, -0.20033602f, 0.13968784f, -0.09615024f, 0.04106668f, -0.01441417f, -0.06694540f, 0.03989808f, 
    -0.00722610f, 0.04919915f, 0.04549180f, 0.09435575f, -0.00847209f, -0.03294253f, 0.00619749f, 0.04972956f, 
    -0.00946090f, 0.00526443f, -0.01146001f, -0.05618792f, -0.25482088f, 0.29613537f, -0.09632418f, 0.35246602f, 
    0.21959668f, -0.00702800f, -0.10311905f, 0.00146557f, -0.08086127f, 0.02455598f, 0.06143076f, 0.14853349f, 
    0.14545837f, 0.21823135f, -0.06054528f, 0.07085036f, -0.02727703f, -0.01319928f, -0.04220423f, 0.11763211f, 
    0.08318720f, 0.18186387f, -0.04130494f, -0.15062557f, 0.01371251f, 0.03126163f, -0.15768453f, 0.05762424f, 
    -0.00686018f, 0.09530064f, 0.24342528f, 0.11435530f, -0.18459553f, -0.06418251f, -0.13617679f, 0.17549574f, 
    0.17501542f, 0.06098842f, 0.12315278f, -0.00762232f, 0.06306987f, -0.07273391f, 0.13393794f, -0.21948065f, 
    0.12139173f, -0.06027384f, 0.03636602f, -0.06203232f, 0.07922252f, 0.05227745f, 0.20266135f, 0.05409364f, 
    -0.15929815f, -0.04758109f, -0.18795472f, -0.04002667f, 0.07219650f, 0.04314167f, 0.17036489f, 0.03658788f, 
    -0.05028920f, 0.07874864f, -0.01942679f, 0.24686189f, -0.05719040f, -0.14396790f, -0.19358024f, -0.05808337f, 
    -0.01540059f, 0.08155338f, 0.05026110f, 0.04302359f, 0.07545058f, 0.11734118f, 0.03719972f, -0.02646140f, 
    0.09876828f, 0.01423578f, 0.06131932f, -0.09479254f, 0.05811130f, -0.22849882f, 0.06540503f, -0.05170030f, 
    0.05265565f, -0.03673572f, 0.02349849f, 0.02307636f, -0.00502459f, 0.07110679f, -0.03897975f, 0.02359896f, 
    -0.10687281f, -0.01276528f, -0.07551090f, -0.03642488f, -0.11213986f, 0.06029373f, 0.04988463f, 0.05327290f, 
    -0.01918827f, 0.00741338f, 0.01257005f, -0.02004278f, 0.09292705f, 0.00337034f, -0.05340048f, -0.01427954f, 
    0.03246045f, 0.05523008f, 0.08117038f, -0.00352685f, 0.05605600f, -0.12719327f, -0.10486620f, 0.04934162f, 
    0.05293749f, 0.03144275f, 0.06028188f, 0.09977075f, -0.06617200f, -0.09174934f, -0.20581068f, -0.21004757f, 
    0.06632321f, -0.15861686f, 0.00619083f, 0.13052922f, 0.02125615f, 0.05236261f, 0.00671488f, -0.08751686f, 
    -0.06140767f, -0.02844560f, -0.04368822f, -0.02261839f, -0.01393897f, -0.19165285f, 0.09781080f, 0.02446637f, 
    -0.12307068f, -0.53012270f, -0.30912149f, 0.09257083f, -0.20010933f, -0.12028213f, -0.20227805f, -0.06856783f, 
    -0.22494805f, -0.02082508f, -0.03395114f, 0.05395459f, -0.02562470f, 0.07918500f, -0.06537198f, -0.08394306f, 
    -0.11456576f, 0.03051138f, 0.08801326f, 0.08963561f, -0.08567815f, -0.20331630f, 0.04435746f, 0.00013659f, 
    -0.21460135f, -0.12522796f, -0.26350352f, -0.04073776f, -0.09112731f, 0.09120759f, -0.01118154f, 0.03226073f, 
    0.03986077f, 0.11394500f, -0.01154720f, 0.05490571f, -0.02129424f, 0.15654463f, -0.02656685f, -0.02615898f, 
    -0.05649379f, 0.04142649f, 0.38541541f, 0.13443382f, 0.24265793f, -0.02278286f, -0.06241514f, -0.03936620f, 
    -0.08411877f, 0.07485627f, 0.07214542f, 0.07268631f, 0.16917457f, 0.13270096f, -0.04704316f, 0.08159208f, 
    0.11460702f, 0.08378868f, 0.03912259f, 0.13214010f, 0.01890252f, -0.06687185f, -0.10040821f, -0.05369199f, 
    0.06807332f, -0.12525086f, -0.07128402f, 0.04781212f, 0.02459463f, 0.03089360f, 0.06801455f, -0.05346909f, 
    -0.04961835f, 0.02194259f, -0.05118444f, -0.15808102f, -0.03127144f, 0.06447966f, 0.01959127f, 0.05242744f, 
    -0.03239127f, 0.00456549f, -0.02344358f, 0.01381726f, 0.07132158f, -0.05281288f, -0.05188922f, 0.06421366f, 
    0.01552199f, 0.08663883f, 0.14423640f, -0.02573404f, -0.00672083f, 0.02647756f, 0.01202890f, 0.06819439f, 
    0.04181134f, -0.02426823f, -0.02645778f, 0.00926082f, -0.07846647f, 0.05864184f, 0.07298998f, -0.06890005f, 
    0.05025074f, 0.01327818f, -0.12040678f, -0.03674885f, 0.03328212f, -0.01331098f, 0.16876142f, 0.09715267f, 
    -0.00839122f, -0.02056722f, -0.04417293f, 0.04319192f, -0.09602293f, -0.08531695f, 0.00884261f, -0.00552047f, 
    -0.04741005f, -0.44574973f, -0.02682837f, 0.10297840f, 0.16138813f, -0.06869509f, 0.12235151f, -0.14913420f, 
    0.00846297f, -0.00131372f, 0.08038297f, 0.02380218f, 0.04121092f, 0.02515579f, -0.11963919f, 0.09931308f, 
    0.06006211f, 0.16922832f, 0.04454204f, 0.07889532f, -0.11839240f, -0.01396880f, -0.12054080f, -0.10937916f, 
    0.20117250f, 0.07800598f, -0.03623537f, 0.00392147f, 0.05666235f, 0.07942703f, 0.09459892f, -0.13076045f, 
    -0.09817790f, -0.02677939f, 0.03412647f, 0.04020643f, 0.11450520f, 0.04696350f, -0.02353866f, -0.04844933f, 
    -0.77504325f, 0.12048657f, 0.10285556f, 0.16576985f, -0.29046068f, -0.17574556f, 0.08972716f, -0.08767235f, 
    0.29066679f, 0.06734163f, 0.08967651f, -0.19345453f, -0.04575561f, -0.04979621f, -0.01899242f, 0.03076242f, 
    -0.01577974f, 0.10854989f, 0.10023673f, 0.03146667f, -0.16245046f, -0.14026117f, -0.12462649f, 0.00612206f, 
    0.08126522f, 0.07350437f, -0.01871798f, -0.02229441f, 0.00291740f, -0.01459401f, -0.05111679f, 0.11680751f, 
    0.05986969f, 0.10894901f, 0.17762330f, 0.00936077f, 0.11410838f, -0.02896278f, -0.07288011f, -0.03009614f, 
    0.35245878f, -0.60875881f, -0.09624644f, -0.34649336f, 0.18372552f, 0.04227531f, -0.06122524f, 0.14033279f, 
    -0.03261863f, -0.12848753f, 0.14224944f, 0.02176151f, -0.09040741f, 0.03723758f, -0.12853105f, -0.08918239f, 
    0.00194921f, 0.01557529f, -0.03115608f, -0.09234074f, 0.40323654f, 0.67319494f, 0.21115042f, -0.05897771f, 
    -0.19271800f, -0.00981364f, -0.02381853f, 0.05668455f, 0.05972693f, 0.06166421f, 0.01895034f, 0.04817282f, 
    -0.02095217f, -0.02989069f, -0.02371395f, -0.02443718f, -0.01716251f, 0.00679630f, 0.05423969f, 0.00434281f, 
    -0.14093082f, 0.01807610f, -0.32692298f, -0.09047896f, -0.29897463f, 0.10267595f, -0.01197276f, -0.10620705f, 
    -0.10840911f, 0.01498643f, -0.17588326f, -0.01346960f, 0.10661157f, 0.00497368f, -0.09989210f, -0.05781072f, 
    0.05262676f, -0.05580435f, -0.09486442f, 0.01754904f, 0.10376496f, 0.04693707f, -0.32890883f, 0.02743228f, 
    0.04186163f, 0.20611362f, 0.02635500f, -0.03301368f, -0.13949223f, 0.04892995f, -0.06604892f, 0.08131476f, 
    -0.00524159f, -0.00603770f, -0.07816426f, -0.09682045f, -0.04006574f, 0.09218393f, 0.01544558f, 0.04165244f, 
    -0.58955961f, 0.16998310f, 0.41101408f, 0.24119568f, -0.27326509f, 0.10134914f, -0.04255210f, 0.00271160f, 
    0.34969470f, 0.13764161f, 0.06803616f, 0.01939827f, -0.12349958f, -0.05835738f, 0.05833717f, 0.03845889f, 
    -0.03570646f, -0.03759855f, 0.07949075f, 0.22690113f, -0.09931190f, 0.06056578f, -0.40375155f, 0.25835460f, 
    0.03180575f, 0.15958095f, -0.00368061f, -0.13009939f, -0.00384657f, 0.01105693f, 0.02454331f, 0.04861012f, 
    0.00831971f, 0.00220636f, -0.05832170f, -0.15960009f, -0.08600444f, 0.04486528f, 0.09571626f, 0.11943600f, 
    -0.59503496f, -0.07054830f, -0.06683492f, 0.29328436f, -0.13972437f, 0.20258708f, -0.09761981f, -0.18420318f, 
    -0.05164578f, 0.13818055f, 0.05590111f, 0.06845587f, -0.04031232f, 0.06396885f, -0.06586343f, -0.01871026f, 
    0.12406085f, -0.01243273f, -0.13682930f, 0.09339278f, 0.04352460f, 0.13198331f, 0.56815797f, 0.00136472f, 
    -0.08412224f, 0.02361070f, -0.10032842f, 0.05341212f, -0.18614024f, -0.03557167f, 0.06736958f, 0.07611550f, 
    -0.01465044f, 0.05789971f, -0.04954854f, 0.13542996f, -0.04826643f, -0.10468586f, -0.01984339f, -0.10607739f, 
    0.35374063f, 0.12741290f, -0.61012745f, 0.06499176f, -0.17063978f, -0.06243584f, 0.13595290f, 0.01901145f, 
    -0.05711029f, 0.16564129f, -0.08275154f, -0.02758053f, 0.06838395f, -0.04365863f, 0.08708673f, 0.05258431f, 
    0.10360473f, -0.01707432f, 0.05982346f, -0.03151957f, 0.09316634f, -0.03319291f, 0.11720142f, 0.15112957f, 
    0.01827813f, 0.11016598f, -0.05957583f, -0.03655492f, -0.10114971f, -0.02169887f, 0.06862642f, 0.04642949f, 
    0.11308281f, 0.02632115f, 0.11898269f, 0.03854211f, 0.02083819f, -0.06832412f, -0.12700975f, -0.01168221f, 
    0.20427258f, 0.64727968f, 0.55219632f, 0.27964872f, -0.00620964f, 0.02506096f, -0.04981914f, 0.07507097f, 
    0.04918259f, 0.30736005f, 0.06258750f, 0.06620412f, -0.04109773f, 0.07747696f, -0.08674412f, 0.04130976f, 
    -0.01166742f, 0.12597887f, -0.17600515f, 0.08396393f, 0.53237510f, 0.47429779f, 0.51714820f, -0.05419268f, 
    0.00849327f, 0.03130963f, 0.00451455f, 0.18670745f, 0.11784156f, 0.23089269f, -0.06464749f, 0.04126990f, 
    0.00787523f, 0.05018020f, 0.01789719f, -0.00592147f, -0.02032177f, -0.12339963f, 0.00885510f, 0.02655243f, 
    0.08948734f, 0.00572741f, 0.01536417f, 0.07248964f, -0.33953410f, 0.22667286f, 0.05001586f, -0.05757080f, 
    0.00287039f, 0.06927110f, -0.08710355f, -0.06662739f, -0.00158636f, 0.04479062f, 0.02582193f, -0.03658096f, 
    0.14818147f, -0.06409393f, -0.08305047f, 0.04999747f, 0.42742509f, 0.02059622f, 0.27470878f, -0.33310094f, 
    -0.12430270f, -0.07905702f, -0.04284701f, 0.07326888f, 0.09422063f, 0.19012913f, -0.03440119f, 0.12843533f, 
    -0.03893203f, -0.05946895f, 0.06157722f, 0.00581026f, -0.12244353f, 0.03041421f, -0.04983604f, 0.17930202f, 
    -0.23609765f, -0.03530093f, -0.21364410f, 0.10746279f, 0.05337198f, 0.00678748f, 0.01603589f, -0.04328783f, 
    -0.02544946f, -0.06384449f, -0.00209419f, 0.00717088f, -0.07204826f, 0.02950698f, 0.00812141f, -0.10547526f, 
    0.14035682f, 0.01582635f, -0.10346057f, -0.15332031f, -0.35912526f, 0.23259860f, 0.04910169f, -0.16585433f, 
    -0.11572865f, 0.12137531f, 0.18312298f, 0.02483491f, -0.15294367f, -0.09142184f, 0.06817452f, 0.05821731f, 
    0.07436919f, 0.13532792f, -0.11926035f, 0.05352248f, 0.06142822f, -0.03100587f, -0.03354352f, -0.00377955f, 
    0.10351492f, -0.10000698f, -0.10612070f, -0.15743734f, -0.04242459f, 0.03878804f, -0.06614184f, -0.04444365f, 
    0.02994869f, -0.08002374f, 0.04078475f, 0.10660592f, 0.03838918f, 0.08321432f, 0.21588653f, -0.04647983f, 
    0.21585497f, -0.02871561f, 0.02508126f, -0.02457141f, -0.27786109f, -0.14928354f, -0.33679679f, 0.24885190f, 
    -0.00577658f, 0.01748076f, -0.08261888f, 0.06470941f, -0.12768197f, -0.00348367f, -0.02680251f, 0.13336195f, 
    -0.14228505f, 0.11715619f, -0.07097750f, 0.02239085f, 0.02428024f, -0.01802936f, -0.10275419f, -0.12819152f, 
    0.05933683f, 0.30405846f, 0.24283467f, -0.13919334f, -0.34435636f, 0.19562185f, 0.14099537f, 0.00450047f, 
    0.13913830f, 0.08273055f, -0.00269840f, -0.06602437f, -0.01902396f, 0.00732419f, 0.04297185f, 0.00630213f, 
    0.05483500f, 0.15372926f, 0.04650205f, 0.03840841f, -0.12257422f, -0.17641465f, -0.43968570f, -0.02777535f, 
    0.16348934f, -0.00137133f, 0.11198454f, 0.23588921f, -0.00778992f, -0.00083644f, 0.03002973f, 0.07237065f, 
    -0.09896779f, 0.03595169f, -0.07596437f, 0.05631738f, 0.07737867f, -0.00067756f, -0.07379418f, -0.11811014f, 
    -0.22598994f, -0.35245076f, -0.17767985f, 0.03433921f, 0.10161566f, 0.05438592f, -0.00695176f, -0.07322523f, 
    -0.08864680f, -0.13086937f, 0.03707297f, 0.14864153f, -0.01422450f, 0.07881849f, -0.00158712f, -0.13963677f, 
    -0.03421193f, -0.04215555f, -0.04251309f, -0.05559885f, -0.25927716f, -0.35416189f, -0.34275883f, 0.18112329f, 
    0.07508912f, 0.21573775f, 0.13053679f, 0.04532885f, -0.04896070f, -0.01455635f, 0.02762938f, 0.03006201f, 
    0.07402964f, -0.02672844f, -0.09120481f, -0.07695829f, 0.08732454f, 0.01716217f, 0.03258045f, 0.03823782f, 
    0.49607977f, 0.26500306f, 0.31464532f, -0.07161438f, -0.06903496f, 0.17153554f, 0.13000441f, 0.18890284f, 
    -0.01009642f, 0.11396102f, 0.11101370f, -0.12228592f, 0.02951109f, -0.02353437f, -0.00573212f, 0.13021533f, 
    0.16972193f, 0.05677545f, 0.15680650f, 0.09517252f, 0.24032918f, 0.23448840f, 0.06353361f, -0.37629858f, 
    -0.13503923f, -0.05748161f, 0.33412471f, 0.14428240f, 0.00630099f, -0.02234455f, 0.21453029f, -0.11599721f, 
    0.04686284f, 0.07731876f, 0.03793206f, 0.08984064f, -0.03640268f, 0.03712121f, 0.04764779f, 0.04094669f, 
    -0.10856445f, 0.04765552f, -0.48996189f, -0.08692980f, -0.09870259f, 0.06234036f, 0.08158600f, -0.06883973f, 
    -0.13467234f, -0.17089772f, 0.05869653f, 0.01777673f, 0.11366332f, 0.13111137f, 0.01565362f, 0.03308811f, 
    0.00605365f, 0.08604391f, 0.02092167f, -0.09346119f, -0.18584347f, -0.28313166f, -0.17730229f, -0.01713978f, 
    -0.09482466f, 0.18136856f, 0.17215440f, 0.11004831f, 0.03629726f, -0.03394490f, -0.01056326f, -0.08235910f, 
    0.01869675f, 0.02249546f, 0.19370164f, 0.08709309f, 0.09357683f, 0.02017779f, -0.06350829f, -0.03613156f, 
    -0.32905617f, -0.11264407f, -0.29846099f, 0.19754638f, -0.07309161f, 0.01178551f, 0.01151920f, -0.10970329f, 
    -0.03860929f, 0.08263707f, -0.00151002f, -0.05726580f, 0.03392266f, -0.06643488f, 0.05656325f, 0.00543119f, 
    0.22154039f, 0.09053596f, -0.06798922f, -0.08041292f, -0.03822710f, -0.18334405f, -0.04229761f, -0.05072320f, 
    -0.09546696f, -0.03341752f, 0.06768727f, -0.08973792f, -0.08239818f, -0.06115173f, 0.00465418f, 0.00139471f, 
    0.17027427f, -0.03877911f, 0.06390938f, 0.03863725f, 0.12310747f, -0.23947912f, -0.07257625f, -0.03896422f, 
    0.20297486f, 0.46560019f, -0.02960659f, -0.11388294f, -0.46492311f, 0.07825930f, 0.03631826f, 0.06192983f, 
    0.05775350f, 0.03696797f, -0.00725766f, -0.07585125f, -0.01992149f, 0.03680275f, 0.10104845f, -0.03847656f, 
    0.07509749f, 0.08309612f, 0.13377906f, 0.12969849f, 0.11984631f, 0.16534966f, -0.21725385f, 0.08062870f, 
    -0.09056883f, 0.03677541f, -0.05092433f, 0.04271128f, -0.02300073f, -0.00047201f, 0.03149418f, 0.10981593f, 
    -0.04230087f, -0.08444898f, 0.06277166f, -0.08843478f, -0.08082700f, -0.01546986f, -0.15210405f, 0.10482515f, 
    -0.03210331f, -0.00416705f, -0.03747100f, 0.00705594f, -0.01289491f, 0.01700627f, -0.00474086f, 0.00709961f, 
    -0.04197082f, -0.01292934f, -0.02719321f, 0.01071525f, -0.01065517f, -0.00113898f, -0.00233659f, -0.02663081f, 
    -0.00441993f, -0.03351676f, -0.02807252f, -0.01052048f, -0.03376905f, 0.03217592f, -0.02042616f, -0.00029254f, 
    -0.03813206f, 0.01281733f, -0.00307431f, -0.00730715f, -0.01101997f, -0.01141358f, 0.01562766f, 0.01777264f, 
    -0.02388054f, 0.01782172f, 0.00246410f, 0.02474307f, 0.01648976f, -0.01201028f, -0.02854395f, -0.01135448f, 
    -0.03782372f, -0.01023601f, 0.02440506f, -0.04215448f, -0.01482150f, 0.02793582f, 0.01978137f, -0.02401393f, 
    0.01306501f, 0.00001269f, -0.00773147f, 0.01446504f, -0.00909404f, -0.04404001f, -0.00399153f, -0.01208344f, 
    -0.02785790f, -0.03901102f, 0.02630536f, -0.03448684f, -0.02574425f, 0.02633605f, -0.01563913f, -0.03593507f, 
    0.01494244f, -0.02994559f, -0.00985576f, 0.00303842f, -0.00780451f, -0.00927518f, -0.02109928f, 0.01253384f, 
    -0.00736549f, -0.00938805f, -0.03613645f, -0.04872106f, 0.00233127f, -0.04272888f, 0.00191034f, -0.03899636f, 
    -0.03864691f, -0.03993861f, 0.01820607f, 0.02895007f, 0.02210153f, -0.00784958f, -0.02069047f, 0.01889598f, 
    0.02989803f, 0.00078787f, -0.04639977f, 0.02109491f, 0.00693344f, -0.03965431f, -0.03986770f, -0.02041828f, 
    -0.01211560f, 0.01777157f, -0.01447053f, 0.01057557f, -0.03337121f, -0.03511611f, 0.02615283f, 0.02464446f, 
    -0.01324550f, 0.02147520f, -0.00017469f, -0.04420451f, 0.01477474f, 0.02306186f, -0.01909273f, -0.02317663f, 
    0.02744171f, 0.00364814f, 0.02247867f, 0.01334722f, 0.01503036f, 0.02684437f, -0.02072399f, -0.03232041f, 
    -0.03977799f, -0.02902939f, -0.02208911f, 0.00939707f, -0.00029075f, 0.01203772f, 0.02164520f, 0.00237270f, 
    0.01510477f, -0.01804841f, 0.00516772f, 0.01610935f, -0.01212501f, 0.02715488f, -0.02049985f, -0.02304607f, 
    0.03354044f, 0.00331608f, 0.03235754f, -0.00601262f, 0.01974894f, -0.01518700f, -0.02851369f, -0.00471536f, 
    0.01165532f, -0.02263914f, 0.01303882f, -0.04514336f, -0.04082193f, 0.00635819f, -0.03310824f, 0.01110203f, 
    0.01195455f, -0.03241235f, 0.01418747f, -0.01686622f, -0.01395026f, -0.01059684f, -0.00728812f, -0.02160790f, 
    0.01216033f, -0.04356524f, 0.01834498f, -0.03130158f, 0.01400331f, 0.00595786f, -0.00555941f, 0.02309987f, 
    -0.04252766f, -0.00231847f, -0.03762282f, 0.00893204f, -0.02881985f, 0.03208675f, 0.01697286f, -0.00550754f, 
    -0.00387583f, -0.00123533f, 0.02698053f, -0.04562578f, -0.00247449f, -0.00883774f, 0.01604987f, -0.02678914f, 
    -0.00737386f, -0.01056037f, 0.01723901f, -0.00876588f, 0.03051418f, 0.02038541f, 0.01592974f, 0.03230456f, 
    -0.01057645f, -0.03057921f, 0.01644061f, 0.01448965f, 0.01624756f, -0.00219738f, 0.03018283f, -0.00893273f, 
    0.01523277f, 0.00387639f, -0.01643577f, 0.00382261f, -0.01245094f, -0.01263872f, -0.01384330f, -0.03813783f, 
    -0.01598758f, -0.01638253f, 0.03013482f, -0.02977943f, 0.02143057f, -0.01682647f, 0.02406674f, 0.01310307f, 
    0.03069513f, -0.04090714f, 0.02748455f, 0.02732075f, -0.04560442f, 0.02260933f, 0.00610505f, 0.00343335f, 
    -0.02866406f, -0.03831927f, -0.04096624f, -0.01461342f, -0.03823782f, -0.01277300f, -0.02371290f, -0.01447103f, 
    -0.02423996f, -0.01405810f, 0.02022182f, 0.02585385f, -0.02464333f, -0.04644264f, 0.00866948f, -0.02770036f, 
    0.03515784f, 0.02876851f, 0.02300711f, 0.00878399f, -0.03553911f, 0.00728998f, -0.04004521f, -0.03720522f, 
    0.02197528f, -0.00312317f, 0.01734463f, -0.02955630f, 0.00707508f, 0.02687241f, -0.02407084f, -0.04073911f, 
    0.02921610f, -0.02134946f, 0.00200361f, -0.02101294f, 0.00951231f, 0.04058252f, -0.00955617f, -0.03459821f, 
    -0.02664955f, -0.00255387f, -0.02273620f, 0.00944641f, -0.03554998f, -0.01495592f, 0.00268707f, -0.00868305f, 
    -0.00654576f, 0.00467889f, -0.02572600f, -0.01666109f, 0.03310592f, 0.00996866f, 0.00788644f, -0.04627614f, 
    0.00421879f, -0.01722957f, 0.02612036f, 0.03652355f, -0.02538264f, -0.02988421f, -0.00114757f, 0.02756592f, 
    -0.01235104f, -0.04627718f, -0.02783318f, -0.01797456f, 0.00324774f, -0.02262677f, -0.00902349f, -0.00766818f, 
    0.02665342f, -0.02019392f, -0.00544863f, -0.03015713f, -0.02221381f, 0.02058994f, 0.00004300f, 0.03007350f, 
    0.03176560f, -0.02091993f, -0.01247921f, -0.03404934f, -0.01464400f, 0.01505160f, -0.00352386f, 0.00202821f, 
    -0.00776320f, 0.02605335f, -0.00567732f, -0.01205793f, -0.03791490f, 0.00589967f, 0.01674449f, -0.03051634f, 
    0.01359727f, 0.00852416f, -0.03335770f, 0.02228031f, -0.01489405f, 0.00302687f, -0.04546456f, 0.00981760f, 
    -0.04760258f, -0.01104056f, -0.03610186f, 0.02130441f, -0.04476395f, -0.00713512f, -0.03614068f, -0.03310560f, 
    -0.01548783f, -0.00570052f, -0.01255442f, -0.02268751f, 0.01656197f, -0.03228065f, -0.01856558f, -0.01262276f, 
    0.02861750f, 0.02680411f, -0.03533253f, 0.01552189f, -0.03389804f, -0.03783512f, 0.02738169f, 0.02697540f, 
    -0.02644991f, 0.02478940f, 0.02289203f, -0.01715556f, 0.00582911f, -0.03333526f, -0.01001408f, -0.00630248f, 
    -0.03926779f, 0.01333447f, -0.01130116f, 0.01204790f, -0.03635754f, -0.03542307f, -0.04491409f, -0.04717791f, 
    0.02277324f, 0.01342869f, -0.01902970f, 0.00785248f, -0.04020277f, -0.04232626f, -0.03789162f, 0.03133713f, 
    -0.01475476f, -0.00076010f, 0.01221969f, -0.03497977f, 0.02643648f, 0.01703897f, -0.02324608f, -0.01493721f, 
    0.00088711f, -0.03442914f, -0.02978499f, -0.04710209f, -0.03434834f, -0.02652263f, 0.00020407f, -0.00796691f, 
    -0.01618809f, -0.00299088f, -0.01213225f, -0.03780285f, 0.02405594f, 0.00293029f, 0.01210774f, 0.01272193f, 
    0.01729868f, -0.02048078f, 0.02931221f, -0.03900747f, -0.04366858f, 0.00428535f, -0.01361444f, 0.01261733f, 
    -0.04339482f, 0.02774687f, -0.01447697f, -0.01448951f, -0.00405739f, -0.03834382f, 0.00621097f, -0.01299178f, 
    -0.01750685f, 0.00134540f, 0.02071009f, 0.00387103f, 0.00869679f, 0.02533168f, -0.03371082f, 0.02705698f, 
    -0.01098518f, 0.01444898f, 0.02951115f, 0.02227288f, 0.02046015f, -0.01249164f, -0.00160263f, -0.02743529f, 
    -0.01238532f, -0.02529358f, 0.00418338f, 0.02303910f, -0.03299657f, 0.01595822f, -0.02626816f, 0.00950037f, 
    0.02914446f, 0.00637233f, -0.04277981f, -0.00107287f, 0.01461305f, -0.04093227f, -0.04647832f, -0.03940673f, 
    -0.01180650f, -0.00753429f, 0.00130960f, -0.00084669f, 0.01121882f, 0.01092405f, 0.01517551f, 0.00620641f, 
    -0.02299126f, -0.04298097f, 0.02446002f, -0.00848664f, 0.02006702f, -0.00260449f, -0.03847469f, 0.00306997f, 
    -0.02096268f, 0.01894793f, 0.01799406f, -0.04142221f, -0.04141391f, -0.03033071f, 0.01286222f, -0.04023737f, 
    0.02983386f, 0.01351720f, -0.03596751f, 0.01086070f, 0.03196119f, -0.00749492f, -0.02061642f, 0.02905367f, 
    0.01167668f, 0.04075539f, 0.00770140f, 0.00238544f, 0.01788060f, 0.01826132f, -0.03018365f, 0.01008564f, 
    0.03655313f, -0.03696497f, -0.01924957f, 0.00241754f, -0.03081650f, 0.01973899f, -0.00259584f, 0.01104457f, 
    0.01917253f, -0.01228034f, -0.00150299f, 0.01207532f, 0.00004649f, 0.02914771f, -0.03029012f, -0.00825244f, 
    0.01079631f, -0.04453092f, -0.04647560f, -0.00522057f, 0.00485595f, -0.01433922f, -0.02466379f, -0.00653946f, 
    -0.01713794f, -0.02799140f, -0.03743834f, -0.00722192f, 0.00673275f, -0.00050079f, 0.00879955f, -0.01761736f, 
    -0.03740590f, 0.00945537f, 0.02296590f, -0.01289795f, 0.01619657f, -0.00651219f, -0.00036244f, -0.03080146f, 
    -0.01638777f, 0.00642034f, -0.03260345f, 0.01729017f, 0.02572059f, -0.01906874f, -0.03061704f, -0.02855457f, 
    -0.01877038f, 0.00256366f, 0.02475549f, 0.02722719f, 0.00751442f, -0.03305961f, -0.02915939f, -0.03591862f, 
    0.00894333f, 0.02428356f, -0.03520321f, -0.01513564f, -0.00101076f, -0.03095946f, -0.01297585f, -0.00252590f, 
    -0.01583540f, -0.02377478f, -0.02217921f, 0.00978694f, -0.03921762f, 0.02522774f, -0.01918481f, -0.01963257f, 
    -0.02932329f, -0.03781658f, 0.02687366f, -0.04646562f, -0.04665325f, 0.01944172f, -0.00529960f, -0.02076676f, 
    0.00384163f, 0.03458868f, -0.04870025f, -0.02487623f, -0.03077441f, -0.00001335f, 0.03083992f, 0.02864011f, 
    0.02241617f, -0.01207602f, -0.02397112f, 0.00489218f, -0.02651557f, -0.00399509f, -0.03529158f, -0.03828257f, 
    -0.01325817f, 0.03461957f, 0.03130344f, -0.04105389f, -0.00839995f, -0.01124722f, 0.00750694f, -0.01297960f, 
    0.02268277f, 0.01334037f, 0.03220943f, -0.01694281f, -0.03180726f, 0.02176261f, -0.04409224f, 0.03044122f, 
    -0.02717083f, -0.00242575f, -0.00775226f, -0.04242397f, -0.00881085f, -0.03166322f, -0.04178634f, -0.02410170f, 
    -0.01402118f, -0.04042000f, 0.02552124f, -0.02666131f, 0.01995338f, -0.04787188f, -0.00564213f, 0.01582380f, 
    0.00639726f, 0.02595417f, 0.01601369f, -0.01645019f, 0.03006659f, 0.01764858f, 0.02099353f, -0.01746609f, 
    -0.02469458f, -0.01535784f, -0.03974222f, -0.01020235f, 0.00926421f, -0.00817681f, 0.02350608f, -0.04010091f, 
    0.00183810f, 0.04217951f, 0.01751592f, 0.01549823f, 0.02990658f, -0.02406464f, -0.02526033f, 0.02226976f, 
    -0.03347711f, -0.02829884f, -0.03714904f, 0.01382299f, 0.01662342f, 0.00908076f, -0.03187114f, -0.03852491f, 
    0.04420662f, 0.01236876f, -0.04174341f, -0.01933837f, -0.00788685f, 0.00603544f, -0.04436791f, -0.00026802f, 
    -0.03718413f, -0.02640375f, -0.00755680f, -0.03513392f, -0.03609194f, 0.02743535f, 0.00429339f, 0.01592675f, 
    -0.02277063f, -0.00614694f, -0.02346181f, -0.01628259f, 0.00660133f, -0.03603417f, 0.02877104f, -0.00959911f, 
    0.00586769f, -0.03485895f, -0.01002225f, 0.00439170f, -0.04599183f, 0.02238133f, 0.02267445f, 0.01263414f, 
    -0.02134155f, 0.00131529f, -0.01599599f, 0.01277656f, 0.02705328f, -0.02928456f, 0.01935670f, 0.00636989f, 
    -0.03549399f, -0.02497164f, 0.01368046f, -0.00937491f, -0.02072985f, -0.00624723f, 0.01601875f, -0.04192022f, 
    -0.00021496f, -0.01698706f, -0.02977535f, -0.03009952f, -0.00499783f, -0.02590093f, 0.01216211f, 0.01445222f, 
    -0.03618468f, 0.00751302f, 0.00225238f, -0.01562517f, -0.02763629f, 0.02124771f, -0.03185387f, -0.04316557f, 
    0.01360284f, -0.04306541f, 0.00734885f, -0.00132755f, -0.02355693f, -0.02942216f, 0.00647416f, 0.02197556f, 
    -0.03929751f, 0.02498430f, 0.01742395f, 0.03925715f, 0.00030460f, -0.01991886f, -0.02523783f, -0.01111428f, 
    -0.03404053f, -0.04597863f, -0.01604406f, 0.00126968f, 0.01203580f, 0.02582293f, -0.00581535f, -0.03000233f, 
    0.03020635f, -0.03612829f, 0.03052604f, -0.02370266f, -0.01975995f, 0.00977638f, -0.04469642f, -0.01882568f, 
    0.03104277f, 0.03224807f, 0.01481315f, -0.04316787f, -0.00566682f, -0.02489038f, -0.00846286f, -0.03227928f, 
    -0.01780463f, 0.00680754f, 0.00074486f, -0.01855313f, -0.00696607f, -0.04647670f, -0.02485958f, -0.04395846f, 
    0.03571062f, -0.03619192f, -0.02519358f, 0.01981251f, 0.01430036f, -0.00683370f, 0.02176846f, 0.03216458f, 
    -0.03547223f, -0.04344828f, -0.04314061f, -0.01950885f, -0.00553232f, -0.02173418f, -0.01555934f, -0.01051543f, 
    0.00878427f, -0.01769806f, -0.04211482f, 0.02503380f, 0.02209944f, 0.02512598f, 0.01992366f, 0.01353969f, 
    -0.00069660f, -0.01273726f, 0.00278095f, -0.04700613f, 0.00827688f, 0.02367356f, -0.01142005f, 0.03041677f, 
    -0.03001634f, -0.04633969f, 0.00758811f, -0.00626558f, -0.02070968f, 0.01932266f, 0.00833520f, -0.02879252f, 
    0.02114152f, 0.01225535f, -0.00307693f, -0.03133519f, -0.04488028f, -0.02824914f, 0.01541824f, -0.01462532f, 
    0.01880690f, 0.01670735f, 0.02927497f, -0.03428670f, 0.01519002f, -0.04304965f, 0.01802658f, -0.04441373f, 
    -0.01245672f, -0.00099480f, 0.01242732f, -0.00960740f, -0.01210864f, -0.00364281f, -0.02762784f, 0.03198109f, 
    -0.00173799f, -0.03813791f, -0.01921849f, -0.01590353f, -0.04939445f, -0.01666297f, 0.00037367f, -0.03496637f, 
    -0.00713111f, -0.04301377f, -0.02694659f, 0.01280913f, -0.01278667f, 0.01662263f, 0.01642011f, 0.02397429f, 
    0.00903174f, 0.01326956f, -0.04435429f, -0.04890984f, 0.00999860f, 0.02325048f, -0.02113976f, -0.03985115f, 
    -0.01129011f, -0.04049626f, -0.04224044f, 0.01207039f, -0.04588829f, -0.00859070f, 0.00495967f, -0.00280901f, 
    0.03245718f, 0.00196169f, -0.02751849f, -0.01061288f, 0.02530287f, 0.01465349f, -0.00220882f, -0.01207474f, 
    0.01963708f, 0.00355040f, -0.03609881f, -0.04587132f, 0.01208242f, -0.02098542f, -0.04245634f, 0.01233949f, 
    0.03285278f, 0.00809023f, 0.01754405f, 0.02078412f, 0.00112364f, -0.02253293f, 0.02893052f, -0.03211122f, 
    0.03117802f, -0.00613741f, -0.00066785f, -0.01341706f, 0.01396220f, -0.01238792f, 0.00628419f, 0.03820224f, 
    0.03154837f, -0.02162332f, 0.00886176f, 0.02942218f, 0.00949650f, -0.04178180f, -0.03814103f, -0.02528871f, 
    0.00255285f, 0.00845646f, -0.03942639f, 0.00141285f, 0.01391782f, -0.04061952f, 0.01219476f, 0.03414113f, 
    -0.01397222f, -0.02474926f, 0.02596077f, -0.03375364f, -0.04365594f, 0.04171283f, -0.00228772f, 0.04769421f, 
    -0.02526191f, 0.02311916f, -0.02616808f, -0.04170023f, 0.03026504f, 0.02980639f, 0.00261440f, 0.01647172f, 
    0.03814463f, -0.02871148f, 0.02488999f, -0.00311163f, -0.03257345f, -0.03307272f, 0.00610671f, -0.04371492f, 
    0.00287490f, 0.02387273f, -0.04065666f, -0.03997704f, 0.00454255f, 0.02200041f, -0.03217398f, -0.04112170f, 
    0.02335212f, -0.03232524f, 0.02583731f, 0.02762275f, -0.04144051f, 0.00047239f, -0.01834098f, 0.02276130f, 
    -0.01031092f, 0.00118491f, -0.03795943f, 0.01384837f, -0.04015198f, 0.03010436f, 0.02548409f, 0.00067625f, 
    0.02153387f, -0.00128704f, -0.00280393f, 0.00114824f, -0.02465371f, -0.02777312f, -0.03801437f, -0.00077661f, 
    0.01444489f, -0.02867542f, 0.00870162f, -0.00705747f, -0.01826547f, -0.03797992f, 0.02478738f, 0.02737334f, 
    -0.03321582f, -0.03499333f, -0.03274709f, -0.01520674f, -0.01738814f, -0.00810321f, 0.00897109f, 0.00703991f, 
    0.02534103f, -0.02104641f, 0.01584564f, 0.02999089f, -0.02861537f, 0.00337892f, 0.00646873f, -0.03561386f, 
    -0.03093484f, 0.01617485f, 0.01477264f, 0.01496810f, 0.00817665f, 0.01263382f, 0.00436325f, -0.00126295f, 
    -0.03964873f, 0.03960392f, -0.02522543f, -0.03805745f, 0.02863049f, 0.01715128f, -0.03426433f, -0.03581398f, 
    -0.00346249f, 0.01898926f, -0.02218152f, 0.01211138f, -0.02607931f, -0.02688867f, 0.02778551f, 0.02936495f, 
    0.01545442f, 0.01930282f, -0.01789793f, 0.00804852f, 0.02901578f, 0.00988397f, 0.01996819f, -0.03196266f, 
    -0.04026956f, -0.03924559f, -0.00063712f, 0.00329595f, -0.03774051f, 0.01771863f, -0.02113795f, -0.03051977f, 
    0.00576419f, -0.04493611f, 0.02303266f, -0.03882578f, -0.01189317f, 0.00076351f, -0.03151400f, -0.03534108f, 
    0.03328339f, -0.04074232f, 0.00537362f, 0.00296896f, 0.02600035f, 0.00690293f, 0.00366013f, -0.01776048f, 
    -0.00634067f, 0.00565648f, 0.01122381f, -0.02359140f, -0.03033989f, -0.03542665f, -0.02959999f, 0.00814336f, 
    -0.02427942f, -0.01729066f, 0.02563485f, 0.01877945f, -0.04179973f, -0.01722509f, 0.00762494f, 0.02813848f, 
    -0.04029638f, -0.04345249f, -0.00967680f, -0.01501476f, 0.00158159f, -0.04008074f, 0.02997916f, 0.01160552f, 
    -0.02156493f, -0.00678574f, 0.00250563f, -0.00583907f, -0.04143776f, -0.02203005f, 0.00213045f, -0.01315057f, 
    -0.03412341f, 0.02120796f, 0.01864697f, -0.02731852f, -0.02852672f, 0.00834641f, -0.00787038f, 0.01359436f, 
    -0.03477549f, 0.00780794f, 0.02488593f, -0.04196295f, -0.01296864f, 0.01109960f, 0.02729200f, -0.00716854f, 
    0.02600578f, -0.01609186f, -0.01265251f, -0.00047595f, -0.03166375f, -0.03846512f, 0.00040299f, -0.03503029f, 
    0.00789490f, 0.02619216f, -0.03089262f, -0.01918031f, -0.03783839f, -0.03150633f, 0.01778536f, -0.03669909f, 
    0.00364897f, -0.03172809f, 0.02849045f, 0.00798227f, 0.01692573f, 0.00586265f, 0.01972469f, 0.02824284f, 
    -0.01926314f, 0.01107901f, 0.01953252f, -0.01521133f, -0.01708381f, 0.00815258f, -0.04304637f, 0.00380715f, 
    0.01499751f, -0.02253213f, -0.02824969f, -0.03468066f, -0.00865782f, 0.00580587f, -0.02781742f, -0.01334733f, 
    -0.00462888f, -0.00658831f, -0.00148200f, -0.01093779f, 0.01775448f, -0.03938165f, -0.01602083f, 0.03630270f, 
    0.02687787f, 0.03760506f, 0.01894086f, -0.03161540f, 0.03362886f, -0.02697992f, -0.02904146f, 0.00057309f, 
    -0.01263430f, 0.02281533f, 0.02821936f, -0.03063834f, 0.00858447f, 0.01657217f, -0.01924985f, -0.02865104f, 
    0.03212488f, 0.02745195f, 0.02332498f, -0.03570703f, 0.03139647f, 0.01690079f, -0.02836949f, -0.04483524f, 
    0.03017622f, -0.03469940f, 0.02349052f, -0.02318418f, 0.00655638f, -0.01839128f, -0.00903399f, -0.00041566f, 
    0.00756705f, -0.02530160f, -0.03278721f, 0.01508246f, 0.00300118f, 0.00500587f, -0.03772067f, 0.00900463f, 
    0.01977038f, -0.00152615f, -0.02374744f, 0.00398047f, 0.02036691f, -0.00768704f, 0.00504560f, -0.04741731f, 
    -0.00143585f, 0.02039005f, 0.00797300f, 0.01460460f, -0.01133035f, 0.02957829f, -0.04246794f, 0.03078494f, 
    -0.01498594f, 0.02209065f, -0.02974110f, -0.02557970f, -0.01170833f, -0.03525762f, -0.00660394f, -0.01283118f, 
    -0.01818534f, -0.00687915f, -0.01834827f, -0.00510743f, -0.02565911f, -0.04451142f, 0.02037793f, 0.00644631f, 
    -0.01991688f, 0.00909566f, 0.01528979f, 0.00917917f, 0.02253004f, 0.02197876f, -0.04330393f, -0.00022221f, 
    -0.00195097f, -0.01382250f, 0.00838515f, -0.02723512f, -0.01871103f, 0.02172499f, 0.00169676f, 0.00408595f, 
    0.01573728f, -0.03341836f, -0.00548505f, -0.00522784f, -0.02089727f, 0.00366170f, -0.01630305f, 0.02415943f, 
    0.00128828f, -0.04682648f, -0.04350380f, -0.00797125f, -0.04472635f, 0.03042529f, 0.02048799f, 0.00616275f, 
    -0.03664511f, 0.01675933f, -0.02593849f, 0.01240731f, -0.00834377f, -0.00381921f, -0.00087146f, 0.00663610f, 
    -0.02148390f, 0.03483501f, -0.01528397f, -0.02551856f, 0.00270147f, -0.02633036f, 0.00061075f, -0.03201364f, 
    -0.03502318f, 0.00586177f, -0.03484629f, 0.00710139f, 0.01339021f, -0.02322150f, -0.04588275f, -0.04465003f, 
    -0.04790980f, -0.04403135f, -0.00830705f, 0.02720064f, 0.02629988f, 0.01009324f, 0.01892166f, -0.01108975f, 
    -0.03960216f, -0.02151649f, -0.04468995f, 0.03172979f, 0.00877353f, 0.00758001f, -0.03777941f, 0.01949138f, 
    -0.02542707f, 0.00739325f, -0.04284117f, 0.00121165f, -0.02586570f, -0.03081571f, -0.03595356f, -0.03492786f, 
    -0.03421460f, -0.01290084f, 0.01599689f, -0.03875969f, -0.02074513f, 0.00032236f, -0.00192199f, 0.00358270f, 
    -0.00452006f, -0.03927139f, 0.01076944f, 0.00339155f, 0.03523001f, -0.03343553f, -0.03488912f, 0.02506957f, 
    0.01070243f, -0.01759001f, -0.03167154f, 0.00443288f, 0.02650942f, -0.03512904f, -0.00113972f, 0.02650175f, 
    -0.02124153f, -0.02803737f, -0.00785697f, -0.00556883f, -0.02340232f, -0.02987887f, 0.01841521f, -0.01237270f, 
    0.02115114f, -0.02822984f, 0.01237936f, -0.00213927f, 0.02219766f, 0.00831794f, -0.03014930f, 0.01999639f, 
    0.02801369f, -0.04094911f, -0.01305023f, 0.00582479f, 0.01247987f, -0.00107402f, 0.00634397f, -0.02650760f, 
    -0.03235105f, 0.02266014f, -0.03678415f, -0.03630071f, 0.00522467f, -0.03627583f, -0.03765639f, -0.01351124f, 
    0.00042741f, -0.01232897f, -0.02133784f, 0.02860799f, -0.01642857f, -0.02922221f, 0.02210812f, -0.01326031f, 
    -0.01022707f, -0.03339367f, -0.04497238f, -0.03621934f, -0.01434631f, 0.00648809f, 0.03178683f, 0.02791235f, 
    -0.04526123f, -0.01719240f, 0.02227578f, -0.01582417f, 0.02903618f, 0.02520300f, -0.02713048f, -0.04175934f, 
    -0.04516716f, -0.00774240f, -0.02259547f, -0.03709142f, -0.02547906f, -0.00738262f, 0.00372515f, 0.01880766f, 
    0.00234856f, -0.01852387f, 0.01932905f, 0.03316771f, -0.01102037f, 0.00139221f, 0.01913285f, 0.01730047f, 
    -0.02932659f, 0.01396468f, 0.02344316f, -0.00577070f, 0.01821828f, 0.01905613f, 0.00460792f, 0.02593424f, 
    0.00386213f, 0.01022443f, -0.00616797f, -0.03324839f, -0.03799283f, -0.03719927f, 0.03303870f, 0.03252766f, 
    -0.02517102f, -0.01391942f, -0.00683734f, -0.03342067f, -0.04253544f, 0.02559764f, -0.02607593f, 0.00788138f, 
    0.00205682f, -0.01477520f, -0.00008513f, -0.00900451f, -0.03578441f, -0.00199292f, 0.01736127f, -0.02359511f, 
    0.01026548f, 0.03245645f, -0.02677196f, 0.01906559f, -0.02072209f, 0.02029484f, -0.01935484f, -0.01708607f, 
    0.01640131f, -0.01170326f, 0.01315125f, 0.01977360f, 0.01625900f, -0.00190921f, -0.04023945f, 0.01420041f, 
    -0.00931673f, -0.04285254f, -0.03113342f, -0.02291955f, -0.02498128f, 0.02048830f, -0.01697879f, 0.02829842f, 
    -0.02807603f, 0.01297794f, -0.03165130f, -0.03546640f, 0.03252415f, -0.01387642f, 0.02277028f, 0.03265378f, 
    0.03490938f, 0.02162720f, 0.00417917f, 0.02585853f, -0.00212369f, 0.02861705f, 0.02562018f, -0.02649489f, 
    -0.03275332f, 0.00024638f, -0.00497695f, -0.02969429f, -0.00809310f, 0.00922769f, -0.01564723f, 0.01608688f, 
    0.01180194f, -0.01330112f, -0.01468541f, 0.01199789f, 0.02893545f, 0.01381473f, -0.03595144f, -0.04331018f, 
    -0.01947782f, -0.01871250f, 0.03792008f, -0.02059593f, 0.00851494f, -0.00335279f, 0.00803651f, 0.00257031f, 
    -0.02096969f, -0.02453179f, -0.03188944f, 0.02348712f, -0.01896286f, 0.01462550f, 0.00974344f, -0.03200028f, 
    0.00202960f, 0.00030182f, -0.02748158f, -0.01813733f, 0.03058211f, -0.02359088f, 0.00823385f, -0.02835549f, 
    -0.00346390f, -0.04440760f, -0.04171891f, 0.01141536f, -0.03405439f, -0.02484903f, -0.00380105f, -0.00851186f, 
    -0.04358018f, -0.03083101f, -0.03236789f, -0.00171563f, -0.00265426f, 0.02810151f, -0.04018419f, 0.02696480f, 
    0.03116518f, -0.01633541f, 0.02006870f, -0.02746840f, 0.00535400f, 0.01631911f, -0.04269771f, 0.01261564f, 
    -0.01976385f, -0.00102005f, -0.01876391f, 0.00224553f, 0.02275981f, 0.03339250f, 0.02815774f, -0.04224947f, 
    0.00020468f, 0.00817213f, -0.02313522f, 0.01524857f, -0.00190772f, -0.03044810f, -0.01872625f, -0.00524576f, 
    0.02946128f, 0.02469539f, -0.03035766f, 0.02572558f, -0.02511552f, 0.01722605f, 0.02281882f, -0.01072648f, 
    0.00003823f, 0.01700700f, -0.02347087f, 0.03046295f, 0.01584348f, -0.00550653f, 0.01687670f, -0.02855642f, 
    -0.02031592f, 0.02742442f, 0.01386767f, 0.03801716f, 0.00464810f, -0.03787832f, 0.02975024f, 0.03333232f, 
    -0.02144834f, -0.00115877f, -0.01326240f, 0.00898664f, -0.03610259f, -0.02437133f, -0.01874100f, 0.00321295f, 
    0.01062130f, -0.03494512f, -0.00441509f, -0.02578642f, -0.02403884f, 0.03620414f, -0.01202112f, 0.01052225f, 
    -0.00275456f, -0.00686902f, 0.01279612f, -0.03379774f, 0.01551159f, -0.04510716f, 0.02619728f, 0.02483579f, 
    -0.01782308f, -0.01168730f, 0.00109110f, -0.00621536f, -0.02231905f, -0.01514531f, -0.04497308f, -0.03109800f, 
    0.01408448f, -0.01123201f, -0.03231358f, -0.00993068f, 0.03250516f, -0.00021267f, -0.02756213f, -0.04356380f, 
    0.00679493f, -0.03088291f, -0.00611095f, -0.03973097f, -0.02837577f, 0.01169263f, 0.00868900f, 0.00748767f, 
    -0.00784249f, 0.01084559f, 0.01111958f, 0.00822326f, 0.01592148f, 0.02525324f, -0.02427053f, -0.02733934f, 
    -0.00667971f, -0.02335825f, -0.02285760f, 0.00851028f, -0.02254143f, -0.02370976f, -0.04200778f, -0.00149457f, 
    0.02459086f, 0.00644373f, -0.02161906f, 0.01445433f, -0.03264450f, 0.01799198f, -0.00862398f, 0.00490729f, 
    0.00007898f, -0.00237693f, -0.00652035f, -0.03461335f, -0.01576392f, 0.01662309f, -0.01656683f, 0.00355552f, 
    -0.03728296f, -0.02836608f, 0.01176080f, 0.02789523f, -0.00587524f, -0.03506406f, 0.01877056f, 0.01412348f, 
    0.01658953f, -0.01660127f, 0.01354061f, 0.01684071f, -0.04352137f, 0.00595875f, -0.03806056f, 0.00357467f, 
    0.00383718f, -0.02427360f, -0.01477073f, 0.01671424f, -0.01080515f, -0.03594510f, -0.02169713f, -0.01724680f, 
    -0.02343203f, -0.02630508f, -0.01310760f, -0.00670611f, 0.02741364f, -0.02564807f, -0.00138264f, -0.02875053f, 
    -0.00780090f, -0.03132087f, -0.01056414f, 0.01344517f, 0.00719525f, -0.04334403f, -0.01972930f, 0.00832403f, 
    -0.03639856f, -0.00589671f, -0.03569508f, 0.00062202f, 0.01259368f, -0.00074353f, -0.00442490f, 0.00064433f, 
    0.02918141f, -0.01800022f, -0.03609611f, 0.01590982f, -0.03461562f, -0.04484731f, 0.01400028f, 0.00063242f, 
    -0.01644648f, 0.01045069f, -0.00865005f, -0.00707755f, -0.03651914f, 0.02488182f, 0.01590505f, -0.00202618f, 
    -0.03001788f, -0.00124373f, 0.01330117f, 0.02892038f, 0.02713881f, -0.03733409f, 0.02920410f, 0.01385758f, 
    0.03238098f, -0.02994675f, -0.00558901f, -0.03510270f, -0.01611533f, -0.00160428f, -0.03649915f, -0.03064361f, 
    -0.03351628f, 0.02418680f, 0.01894234f, -0.00714894f, 0.01799096f, -0.04264681f, -0.03365631f, -0.01465606f, 
    -0.01194169f, -0.04307696f, 0.02498629f, -0.00459162f, -0.02627921f, -0.00941708f, -0.04085466f, 0.03071979f, 
    -0.02704176f, 0.02524453f, 0.02847875f, -0.03711846f, 0.02185804f, 0.02711703f, 0.03087994f, -0.02992682f, 
    0.01370103f, 0.01738682f, -0.03134665f, 0.03847696f, -0.02342368f, -0.02039267f, 0.02847728f, -0.00221576f, 
    -0.00431142f, -0.02102388f, -0.02712819f, -0.04329731f, -0.01334943f, -0.01990554f, 0.00185397f, 0.02264133f, 
    0.03043949f, 0.03832180f, 0.02938677f, 0.01841423f, -0.02008134f, 0.02348346f, 0.01208040f, 0.01328707f, 
    0.02174009f, -0.03017192f, 0.03252166f, 0.00519332f, 0.01421613f, -0.01384244f, -0.01668725f, -0.01638794f, 
    -0.01821784f, -0.01042949f, -0.01280973f, -0.01175561f, 0.01697953f, -0.02525854f, -0.01910639f, -0.01638757f, 
    0.01634307f, 0.02465534f, -0.02407917f, -0.02105999f, -0.00444643f, -0.02777367f, 0.00377381f, 0.02924976f, 
    0.02831313f, 0.02375034f, -0.03953308f, -0.00727793f, 0.01816583f, 0.00428099f, -0.01404552f, -0.02328224f, 
    0.02313234f, -0.03678587f, 0.01611347f, 0.01455909f, -0.04488990f, 0.00625224f, 0.02921378f, -0.02562628f, 
    -0.01630905f, 0.00629875f, -0.03664948f, 0.00045308f, -0.02247566f, -0.02991258f, -0.02831808f, -0.00046956f, 
    0.01623964f, -0.04500431f, -0.02927590f, -0.01773611f, 0.02108697f, -0.00587045f, -0.00303619f, -0.02248972f, 
    -0.03058224f, 0.00362225f, -0.00813433f, 0.01826587f, -0.01816326f, -0.04328684f, -0.01055550f, -0.01960036f, 
    -0.01715328f, -0.02444277f, -0.02152725f, 0.02695495f, -0.01431048f, -0.01025443f, 0.02161239f, 0.01532155f, 
    0.02647148f, -0.00113807f, -0.02829382f, -0.01435112f, -0.00568362f, 0.01901683f, 0.01771540f, 0.01272273f, 
    -0.02971615f, -0.00566474f, -0.01921229f, 0.02333273f, 0.02300865f, 0.03205607f, -0.02374230f, -0.03255570f, 
    -0.04447440f, 0.00864677f, 0.00600018f, -0.04261337f, -0.00565251f, 0.02404254f, -0.01980818f, -0.02693924f, 
    0.01809022f, -0.03664451f, 0.02900970f, 0.01995472f, -0.00020940f, -0.01802362f, 0.00261063f, -0.03780900f, 
    0.01651803f, 0.02337722f, 0.02212945f, -0.03044711f, 0.01745215f, -0.01633894f, 0.03588679f, -0.02872793f, 
    0.02308713f, 0.00948656f, 0.02801197f, -0.02713142f, -0.02305879f, -0.01908264f, -0.00094616f, -0.01043538f, 
    -0.01438525f, -0.03452004f, -0.01009666f, -0.04252729f, -0.04410838f, -0.00540649f, -0.01114001f, -0.02003305f, 
    -0.03316391f, 0.01180881f, 0.02125223f, 0.03024449f, 0.03170733f, 0.02066839f, -0.02256155f, -0.01949531f, 
    -0.03451392f, 0.02112569f, -0.02705052f, -0.03133611f, -0.02979627f, -0.02138163f, 0.03739667f, -0.01244824f, 
    0.00725115f, -0.00253396f, 0.02507619f, -0.02337901f, -0.00918597f, 0.02075213f, -0.02123182f, -0.00960853f, 
    0.00383823f, -0.00605776f, 0.02776712f, -0.01314923f, -0.02529105f, -0.03430870f, 0.01413473f, 0.05033011f, 
    0.01742562f, -0.01821720f, -0.00084829f, -0.03428143f, 0.00179691f, 0.00289054f, -0.01294536f, 0.00178351f, 
    -0.02109461f, -0.04345728f, -0.03276981f, 0.02774948f, -0.01261058f, -0.03476468f, 0.03322065f, -0.02059531f, 
    -0.02670561f, -0.03448653f, -0.03168627f, -0.03718159f, -0.01240715f, 0.03837024f, 0.00531732f, -0.04324098f, 
    0.00165410f, 0.02213766f, -0.02490595f, -0.02762004f, 0.02514277f, 0.01737335f, -0.02958298f, 0.03151613f, 
    0.01246155f, -0.03201130f, 0.03184169f, 0.03001137f, -0.01886814f, 0.00534045f, 0.02096546f, -0.02408066f, 
    0.04128685f, 0.01202000f, -0.04252559f, -0.01720482f, -0.00834551f, 0.02184878f, -0.02798886f, -0.03580139f, 
    0.01006565f, -0.04107144f, -0.00549516f, 0.03119970f, -0.02876658f, 0.03604402f, -0.03535601f, -0.01353194f, 
    0.02206854f, -0.00409172f, -0.02527373f, -0.02522727f, -0.00333120f, 0.03019829f, -0.02386189f, -0.03273771f, 
    -0.00469143f, -0.05036253f, 0.02019101f, -0.01783909f, 0.02740098f, -0.00886124f, -0.03491007f, -0.03540827f, 
    0.00782181f, -0.00276326f, -0.01919121f, -0.04730452f, 0.00821572f, -0.02765844f, -0.00571353f, 0.02593435f, 
    0.02119075f, -0.03301468f, -0.00488360f, -0.03435452f, -0.03382444f, -0.01158671f, 0.01488576f, 0.03243127f, 
    0.02958100f, -0.01790554f, -0.00349250f, -0.01258268f, -0.03712313f, 0.03474659f, -0.00293517f, 0.04485185f, 
    -0.03344517f, -0.02282975f, -0.01343859f, -0.02075786f, -0.02899038f, -0.01457115f, 0.02396663f, -0.02193066f, 
    0.02601164f, -0.02269158f, -0.02365148f, 0.01961032f, 0.02843746f, 0.03414898f, -0.03280241f, -0.00342394f, 
    0.06018037f, -0.02279028f, -0.01850505f, 0.00045425f, -0.06237677f, -0.01937978f, -0.02392569f, -0.04175015f, 
    -0.00186821f, 0.01135148f, 0.01476412f, 0.02093153f, -0.01642702f, 0.00435062f, -0.03980636f, -0.00758676f, 
    -0.02144400f, -0.02662434f, -0.03647728f, -0.04699336f, 0.00880000f, 0.04617461f, -0.02355929f, 0.02943311f, 
    0.00090293f, 0.00682142f, -0.04846587f, -0.03407094f, -0.04456948f, 0.02780139f, -0.01650953f, -0.02170034f, 
    -0.03586226f, 0.02494541f, -0.04108706f, -0.02810360f, -0.02404464f, 0.03609934f, 0.02495738f, -0.03372489f, 
    0.00377749f, 0.04444279f, -0.01452245f, 0.04188095f, -0.04679210f, -0.00721154f, -0.01946656f, -0.04811747f, 
    -0.03507925f, 0.02244439f, 0.01951582f, 0.02129435f, -0.03456246f, -0.03346954f, 0.00099135f, -0.01455022f, 
    -0.01489247f, 0.01987595f, 0.03502363f, -0.01993435f, -0.02024825f, 0.00441239f, -0.00995645f, -0.03511551f, 
    -0.00325054f, -0.02138567f, -0.02807992f, 0.03359977f, -0.00730166f, -0.02015150f, 0.00635497f, 0.01660101f, 
    0.00389716f, 0.00927415f, -0.03431308f, -0.00603899f, 0.03224508f, -0.02958387f, -0.02614476f, 0.02052698f, 
    -0.05612554f, -0.00381076f, -0.02392709f, 0.02417266f, 0.04473525f, -0.03669953f, -0.00690077f, -0.03867777f, 
    -0.01674853f, 0.01686804f, 0.03178665f, 0.00567058f, 0.00173803f, -0.01370981f, 0.02035827f, -0.00941822f, 
    0.03367863f, -0.02151461f, -0.02859435f, -0.00991727f, -0.02808980f, 0.03472164f, -0.03295993f, 0.01716514f, 
    -0.01988820f, -0.03146360f, 0.02001333f, -0.00516621f, -0.01225084f, 0.02533347f, -0.02584613f, 0.02103635f, 
    -0.03903936f, -0.02175293f, 0.03174857f, 0.01909440f, -0.01741819f, 0.01918910f, 0.01296163f, -0.03580542f, 
    -0.02754861f, 0.00761291f, 0.01785198f, 0.03320701f, -0.03655216f, -0.03849741f, -0.02540595f, 0.01835186f, 
    -0.01541284f, -0.03591279f, 0.00353170f, -0.03120942f, -0.00532180f, -0.03829688f, -0.01273149f, -0.03209041f, 
    0.03285690f, -0.01536214f, 0.00864414f, 0.00677705f, 0.01203628f, -0.01244793f, -0.04637028f, 0.01155260f, 
    0.03244804f, 0.04378009f, 0.00920246f, 0.01287594f, -0.00076855f, 0.02888167f, -0.02406029f, -0.02850306f, 
    -0.02040641f, 0.00280885f, -0.01671044f, 0.02774799f, -0.02429741f, 0.01671558f, -0.00889099f, 0.02305248f, 
    -0.00496994f, -0.04038498f, -0.02281838f, -0.02571437f, -0.02629386f, 0.03685315f, -0.02701554f, -0.00583862f, 
    -0.03302961f, -0.01991872f, -0.02890750f, 0.03224872f, -0.02052149f, 0.03748278f, -0.03855120f, 0.02576057f, 
    -0.02907575f, -0.01552968f, 0.03513140f, 0.01627859f, 0.00580482f, -0.01318897f, -0.03843090f, -0.01031892f, 
    -0.00927546f, 0.03557461f, 0.00322828f, -0.03941334f, 0.00336987f, 0.02439865f, 0.01672064f, -0.00168164f, 
    0.00837689f, 0.00947581f, 0.01600775f, 0.00471148f, 0.00109811f, 0.00583399f, 0.02576522f, 0.04278862f, 
    -0.00393822f, 0.00381136f, -0.00203323f, 0.04256617f, 0.01126034f, -0.02812771f, -0.04449877f, 0.02922178f, 
    -0.04218033f, 0.04021920f, -0.00855047f, -0.02126674f, 0.03002518f, 0.03810659f, -0.01352581f, 0.01494324f, 
    0.01745964f, 0.02009604f, 0.01824832f, -0.00164063f, 0.02499101f, -0.03107763f, 0.01485995f, -0.00310497f, 
    0.02856660f, 0.00950396f, 0.02933688f, -0.00194344f, 0.03465209f, -0.02383167f, -0.01950154f, -0.01772240f, 
    0.03327663f, 0.01969212f, -0.02400879f, 0.02859147f, 0.02565573f, 0.01184406f, -0.02158467f, -0.02932392f, 
    -0.01451512f, 0.02344865f, 0.01795429f, 0.03227544f, 0.03058853f, 0.01182129f, -0.03245939f, -0.02522768f, 
    -0.03580079f, 0.00006468f, -0.01807010f, -0.01970511f, 0.03344052f, -0.03204763f, -0.00787489f, -0.02935842f, 
    0.00532362f, 0.03317866f, -0.03451130f, 0.02561606f, -0.00812259f, 0.01562440f, 0.00957577f, 0.01437531f, 
    -0.01873234f, -0.02642346f, 0.02992764f, 0.03752796f, 0.00610885f, 0.03730581f, 0.02592734f, 0.02622973f, 
    0.01940045f, 0.02587459f, 0.01193974f, -0.01587641f, -0.04715769f, 0.02378041f, 0.01638146f, 0.03931328f, 
    0.01301140f, 0.00294897f, 0.00409603f, -0.02169026f, 0.01676768f, 0.01298158f, -0.02766648f, 0.02699356f, 
    0.02617628f, 0.02176432f, 0.00473987f, 0.02357805f, -0.00179914f, -0.01527867f, 0.01753334f, 0.03668562f, 
    0.02218641f, 0.00073925f, 0.02356209f, 0.02940381f, -0.00381948f, 0.02078596f, 0.04272664f, 0.01447382f, 
    -0.01997704f, -0.01815675f, -0.01810499f, -0.04971926f, -0.03846952f, -0.04422649f, 0.02670515f, 0.04123392f, 
    -0.01517976f, -0.03551414f, -0.00639387f, -0.02434571f, 0.00627935f, -0.01741818f, 0.03034411f, -0.03198989f, 
    -0.04000375f, -0.00994466f, -0.00629224f, -0.02341957f, 0.02372042f, 0.00856890f, -0.02726658f, -0.01836881f, 
    -0.03042339f, -0.01466866f, -0.02169214f, -0.03661832f, 0.03051983f, -0.00172599f, 0.01136555f, -0.02505392f, 
    0.01990503f, 0.02247506f, -0.01203525f, 0.01125960f, -0.00053917f, -0.01856090f, -0.01017448f, 0.00160132f, 
    -0.00700833f, -0.03411200f, -0.02113283f, 0.00970432f, -0.02839017f, -0.03787087f, -0.01784492f, -0.04105306f, 
    -0.02435505f, -0.04047875f, -0.03601985f, -0.02177322f, -0.01275074f, -0.01376318f, -0.03111350f, 0.02516139f, 
    0.02112115f, -0.00774741f, -0.00266738f, -0.01622498f, 0.00164044f, 0.02513201f, -0.01255951f, -0.01661194f, 
    -0.02524229f, 0.00132198f, -0.03624811f, -0.00950184f, 0.00797712f, -0.03754569f, -0.02328411f, -0.01564855f, 
    0.02744685f, -0.00437578f, 0.01472198f, -0.04630772f, -0.02175026f, -0.03376205f, 0.01655659f, -0.01450096f, 
    -0.01821092f, 0.01072247f, -0.01542226f, -0.00060449f, -0.02654095f, 0.00945642f, -0.03762199f, 0.01718867f, 
    0.02678474f, -0.00889759f, 0.01076302f, -0.02560837f, -0.03435532f, -0.01206760f, 0.02602142f, 0.00303155f, 
    0.02056377f, -0.03067635f, -0.01566866f, -0.02104770f, -0.04261018f, 0.01846342f, 0.02687120f, 0.03312385f, 
    0.03490663f, -0.00283748f, 0.00298714f, -0.00155449f, 0.02616428f, 0.00726901f, 0.01847077f, 0.02665004f, 
    -0.00998480f, -0.03201010f, -0.03898404f, -0.01498045f, -0.02561545f, -0.01738201f, 0.02829145f, 0.00177776f, 
    0.02158420f, -0.04112311f, -0.04819753f, -0.05993665f, -0.02734469f, -0.03120648f, -0.02541869f, 0.03230438f, 
    -0.04480877f, 0.02966384f, 0.02641264f, 0.01641720f, -0.00448087f, 0.02696278f, 0.02325828f, 0.01430479f, 
    0.02628113f, 0.01733459f, -0.01495572f, -0.03502991f, 0.03629506f, -0.02011221f, -0.02675165f, 0.01297184f, 
    0.01907981f, -0.02701500f, -0.00799434f, 0.02119747f, -0.01769218f, -0.01607068f, -0.00495765f, -0.04304434f, 
    0.03719851f, 0.03774242f, 0.00543807f, -0.00286787f, 0.01846084f, -0.03031339f, -0.01356533f, 0.00896088f, 
    -0.03057545f, 0.00217116f, 0.00174398f, 0.00301148f, -0.02966167f, -0.00385230f, -0.02156050f, -0.02702752f, 
    -0.03342428f, -0.02618755f, -0.02239476f, 0.01179721f, -0.01064938f, 0.01623558f, -0.02085972f, -0.00409517f, 
    -0.02098479f, -0.00096957f, 0.01342101f, -0.02510747f, -0.02928960f, -0.02187649f, 0.01301300f, -0.02289156f, 
    -0.00997272f, -0.02975150f, -0.03588939f, 0.01966279f, -0.00274173f, -0.01668532f, 0.00806626f, -0.00559715f, 
    -0.01442792f, -0.01942020f, 0.02626396f, -0.04328933f, 0.02608287f, -0.02740211f, -0.01648727f, -0.01508098f, 
    -0.02268022f, 0.01987819f, 0.02572357f, -0.02166479f, -0.01062566f, 0.01101997f, -0.02989066f, 0.00229231f, 
    -0.00697235f, 0.03246053f, -0.04035820f, -0.01352821f, -0.02416226f, -0.00446457f, -0.00170913f, -0.01492096f, 
    0.00416262f, -0.00092788f, 0.00951246f, -0.03485706f, 0.00596199f, -0.02496960f, 0.00220474f, 0.03045851f, 
    0.01338714f, 0.03039189f, 0.02450839f, -0.01056920f, -0.01441692f, -0.02538615f, 0.00326821f, 0.01244238f, 
    -0.03195030f, -0.03147690f, -0.03491233f, 0.00334705f, -0.01990224f, 0.01581933f, -0.01728873f, -0.04220297f, 
    0.01706915f, -0.02711183f, -0.03346780f, -0.04284729f, 0.01863199f, -0.00056067f, -0.02442089f, -0.03209395f, 
    -0.03758024f, -0.00543684f, 0.01205622f, 0.03072988f, -0.03949355f, 0.03158434f, -0.02834361f, 0.00200782f, 
    -0.01767720f, -0.02968704f, -0.02311997f, 0.03247395f, -0.04447274f, 0.00089492f, -0.02297506f, 0.01089643f, 
    0.00272311f, -0.03539254f, 0.03089909f, 0.01898795f, -0.04478763f, 0.00536499f, -0.02865435f, 0.02224153f, 
    0.02029539f, -0.04062039f, 0.00575546f, -0.00479061f, -0.02635160f, 0.01469750f, -0.03900585f, 0.02808713f, 
    -0.01722175f, -0.01460184f, -0.02660693f, 0.02306720f, 0.02710455f, -0.02882390f, 0.03495688f, -0.01027767f, 
    -0.03239411f, 0.01793707f, 0.00540884f, 0.02612988f, -0.00301787f, -0.04287597f, -0.03088669f, 0.01971556f, 
    -0.04594940f, 0.01413502f, -0.03969624f, 0.03233896f, 0.00904350f, -0.00310171f, 0.03510839f, -0.03559556f, 
    -0.01330376f, -0.03397800f, -0.00854695f, -0.03774393f, -0.01935998f, -0.00698656f, 0.03205670f, -0.01712380f, 
    -0.01692410f, 0.02438579f, 0.00987589f, 0.03067703f, 0.01590827f, -0.04191349f, -0.03159107f, 0.03396867f, 
    -0.00236443f, -0.00740416f, -0.02304034f, -0.03450159f, -0.04251969f, 0.00842427f, -0.04021907f, 0.03277181f, 
    0.01398593f, -0.02393747f, -0.01958783f, 0.00997125f, 0.01573122f, -0.02781317f, 0.01439622f, -0.03680653f, 
    -0.02547386f, -0.02200753f, 0.02192499f, -0.00255713f, -0.01145018f, -0.02132694f, 0.00721311f, 0.02017365f, 
    -0.03244241f, 0.00182807f, 0.04120596f, -0.02500470f, 0.02178901f, 0.01885095f, -0.04088171f, -0.04228753f, 
    -0.03520120f, -0.03102247f, -0.01054492f, 0.02848809f, 0.00673675f, 0.02294492f, -0.02885356f, 0.00248036f, 
    0.01532011f, -0.03123746f, -0.04365275f, -0.02079388f, -0.01401010f, 0.02398842f, 0.00419311f, -0.02668036f, 
    -0.03503105f, -0.00265642f, -0.01546067f, 0.03435503f, 0.03197454f, -0.02558058f, -0.03376350f, 0.02352112f, 
    -0.04198257f, 0.01338272f, -0.03321765f, 0.03286606f, -0.02297902f, 0.01845613f, -0.03599707f, -0.02354635f, 
    0.01291110f, -0.03711484f, 0.01769830f, -0.00121483f, 0.01653880f, 0.02171431f, -0.04312433f, 0.02367076f, 
    0.03524831f, -0.01179208f, -0.01259185f, -0.00375267f, 0.01873119f, -0.00821116f, -0.01142072f, -0.02725779f, 
    -0.04005235f, 0.02018922f, -0.01928701f, -0.04602122f, 0.00528981f, -0.04120528f, -0.02028165f, -0.02591227f, 
    0.00461425f, -0.01041710f, 0.00879658f, 0.02134269f, -0.01075188f, -0.01718483f, -0.01980551f, 0.01902081f, 
    0.00673063f, 0.01767691f, -0.01504764f, -0.03844697f, 0.01804051f, 0.02321122f, -0.03032508f, 0.00566132f, 
    -0.02372924f, 0.03025689f, -0.00300686f, 0.01381821f, -0.02394014f, 0.03065195f, -0.03595617f, -0.02221791f, 
    -0.03831991f, -0.03494768f, -0.04147307f, -0.03490350f, -0.00457483f, -0.03978401f, 0.00099082f, -0.02703736f, 
    0.01601268f, -0.03934438f, -0.00660985f, -0.03726878f, 0.02332020f, 0.01334440f, -0.04177161f, -0.02249242f, 
    0.02823729f, -0.02376927f, -0.00762853f, -0.02420562f, 0.03399242f, -0.01375504f, -0.00640754f, -0.02177886f, 
    -0.01367715f, 0.01780947f, -0.00406373f, 0.03001409f, -0.02886956f, -0.01986836f, 0.01244122f, -0.01860571f, 
    0.03425175f, 0.02564487f, 0.03229809f, -0.01833718f, 0.00968626f, 0.01671958f, 0.00227579f, -0.03223490f, 
    -0.00061894f, -0.03845856f, 0.02128272f, 0.03465835f, -0.00450132f, 0.00705147f, -0.02203208f, -0.00575628f, 
    0.02314294f, -0.02522779f, 0.00356790f, -0.04311870f, 0.02382918f, -0.03486244f, -0.01804995f, 0.00926408f, 
    -0.02156590f, -0.03444302f, -0.01139694f, -0.00932736f, -0.00183716f, -0.00271004f, -0.02779570f, 0.02769698f, 
    0.02438874f, 0.01481549f, 0.01480082f, -0.03644069f, 0.03126659f, -0.04074564f, -0.03835852f, -0.02933007f, 
    0.03225190f, 0.02108542f, -0.01684899f, -0.02913164f, 0.03849521f, 0.02472659f, -0.02826010f, -0.03500006f, 
    0.03471243f, -0.00335928f, -0.00289033f, 0.01549677f, -0.00093156f, -0.00179275f, -0.02464110f, -0.04034033f, 
    -0.00356061f, 0.01803947f, -0.03262976f, 0.02181860f, -0.02666140f, -0.02177205f, -0.02951795f, -0.00862368f, 
    -0.01861436f, -0.00488083f, -0.03192437f, -0.01640285f, -0.00809942f, -0.00740265f, 0.02696944f, -0.04263532f, 
    0.00134439f, -0.02352781f, -0.01940814f, -0.01407400f, 0.00995827f, -0.02282894f, -0.03704254f, 0.02158635f, 
    0.01140989f, -0.04023466f, 0.01965776f, -0.01775062f, -0.03856373f, 0.00239112f, -0.01910916f, -0.01999431f, 
    -0.00351615f, -0.03179539f, -0.04065386f, -0.02680024f, -0.01726738f, -0.01724954f, 0.02445776f, -0.03638976f, 
    -0.01803072f, 0.00261631f, 0.00904377f, 0.01866316f, -0.01265008f, 0.02015294f, -0.00068222f, -0.03058744f, 
    0.00333259f, -0.02509930f, 0.02757180f, 0.00015207f, 0.00067730f, -0.03291209f, -0.00455502f, 0.01533954f, 
    0.00406500f, 0.01328667f, 0.01291186f, -0.02827658f, -0.02933523f, -0.03763846f, -0.03696821f, -0.01518034f, 
    -0.02989842f, -0.04208334f, -0.00810741f, 0.02884062f, -0.00473719f, 0.01523301f, -0.03397275f, -0.03031084f, 
    -0.02882692f, 0.02356784f, -0.01321662f, 0.03544853f, -0.00459015f, 0.03242388f, 0.00259145f, -0.00110981f, 
    0.02448440f, 0.01687954f, -0.01679600f, 0.03441748f, 0.01753375f, -0.02745651f, -0.00477766f, 0.00662807f, 
    0.02848011f, -0.00935491f, -0.00128058f, 0.02994302f, -0.01935270f, 0.00316027f, -0.04729794f, 0.02787455f, 
    -0.02192369f, -0.03335882f, 0.02058307f, -0.00474204f, -0.02933071f, -0.03922940f, 0.00158718f, -0.03221154f, 
    -0.02946067f, 0.01323024f, -0.03355653f, -0.01962394f, 0.01220573f, -0.03165968f, 0.02626051f, -0.02077245f, 
    -0.02916468f, -0.04002204f, 0.01915045f, 0.03447783f, -0.03619255f, -0.00735046f, -0.00585683f, -0.04246071f, 
    -0.02916527f, -0.03410915f, -0.00177569f, -0.04042426f, -0.00830806f, 0.01936110f, 0.02921112f, -0.01986427f, 
    -0.03607811f, 0.00519065f, -0.02476448f, -0.00888918f, -0.02754111f, 0.01937555f, 0.00941836f, 0.00646279f, 
    -0.00961453f, -0.01451219f, 0.01108821f, 0.00586544f, 0.00647858f, -0.02080820f, 0.02363356f, -0.00990293f, 
    -0.03728706f, 0.02210053f, -0.00390324f, 0.01042624f, -0.03220049f, 0.01899705f, 0.02360105f, -0.00641730f, 
    0.02253567f, 0.01509713f, -0.01195395f, -0.01553832f, 0.01575436f, -0.01363004f, -0.03712700f, -0.01144791f, 
    -0.03302690f, 0.00438329f, 0.02362380f, -0.04571210f, 0.01531423f, 0.00138277f, 0.00106247f, -0.03061034f, 
    0.01066324f, 0.00178154f, -0.03955358f, 0.00987255f, 0.00352728f, 0.03223491f, -0.02759983f, -0.02353422f, 
    0.01249374f, -0.00024339f, 0.01299004f, -0.03082633f, -0.04242661f, -0.02939172f, 0.02374000f, 0.03278974f, 
    -0.02535115f, 0.01695428f, -0.02641040f, 0.00656224f, 0.02851659f, -0.03072068f, -0.03265760f, -0.02842810f, 
    0.00993553f, 0.02067630f, -0.03840601f, -0.04158503f, -0.01646689f, 0.02745037f, -0.03240247f, -0.04421645f, 
    -0.03406928f, -0.02205754f, -0.03608276f, -0.03944167f, -0.03256103f, -0.01225438f, -0.03973851f, -0.01884140f, 
    -0.00541025f, 0.02001502f, -0.01591032f, -0.02926277f, 0.01553887f, -0.00629514f, 0.02453262f, 0.02998978f, 
    0.00063263f, 0.00668259f, 0.02503881f, -0.02629830f, 0.01407267f, -0.01675092f, 0.00249413f, 0.03400476f, 
    -0.01086169f, 0.00568874f, 0.02386838f, 0.01084253f, 0.02025633f, 0.03317906f, 0.02379698f, -0.02070369f, 
    -0.04048199f, -0.03055655f, -0.03389489f, 0.03252111f, -0.02017299f, -0.01795837f, -0.02180450f, 0.02257711f, 
    -0.01308928f, -0.02791504f, 0.00611881f, 0.03028553f, -0.02850696f, 0.02874201f, 0.01862118f, 0.01880668f, 
    -0.02719102f, 0.01912370f, -0.00484408f, 0.00397784f, -0.03336183f, 0.01551226f, -0.03231306f, 0.01622484f, 
    0.01600066f, 0.00592885f, -0.03030591f, 0.02818946f, 0.00554566f, 0.00982653f, 0.01211154f, 0.01746941f, 
    0.00584087f, -0.02954324f, -0.04306273f, -0.02966550f, -0.00123199f, 0.00856551f, -0.01535834f, -0.02052607f, 
    0.00839743f, 0.01440948f, 0.02315130f, 0.00511263f, -0.01541612f, -0.01248974f, -0.03740789f, 0.00177316f, 
    -0.01373987f, 0.01240843f, -0.01921590f, 0.03168071f, 0.01776846f, 0.02702071f, 0.00375360f, 0.01741632f, 
    -0.01368963f, 0.02476518f, -0.04012761f, -0.02104659f, 0.02996789f, 0.02610216f, -0.00417543f, 0.03810482f, 
    0.02315885f, 0.01850018f, 0.01736154f, -0.01369678f, 0.01662651f, -0.03063344f, -0.03503263f, -0.01084767f, 
    0.00867302f, 0.00685730f, 0.00929910f, -0.00378184f, 0.00753922f, -0.01066650f, -0.03996585f, -0.01865814f, 
    -0.01021975f, -0.03398343f, 0.01602672f, -0.00922032f, 0.02370634f, -0.02300824f, -0.03253262f, 0.02394625f, 
    0.01704653f, -0.00373811f, -0.03579596f, -0.00039441f, -0.00074261f, -0.03636521f, -0.02640647f, -0.01693935f, 
    -0.01766981f, 0.02115677f, -0.02573670f, 0.01966337f, -0.00847577f, 0.01083974f, 0.03529260f, -0.03201443f, 
    0.69397670f, 0.14184314f, 0.15782151f, -0.37851125f, 0.10054190f, -0.03172854f, 0.06583975f, 0.11955766f, 
    -0.00805986f, 0.13949209f, -0.12124915f, 0.17280164f, -0.07076760f, 0.05408232f, 0.09226878f, -0.00574189f, 
    -0.09026738f, -0.00388727f, -0.11583921f, -0.05553890f, 0.09069734f, 0.17906338f, 0.16628259f, 0.15406422f, 
    -0.15949167f, 0.15153953f, 0.04853861f, -0.08032471f, 0.04542342f, -0.15539695f, -0.00678398f, -0.00733658f, 
    0.07183055f, 0.02916657f, 0.08593772f, 0.14070237f, 0.11405789f, 0.19591013f, 0.09646248f, -0.07733171f, 
    -0.37465847f, -0.06637635f, 0.12116171f, 0.33312505f, 0.16614576f, 0.19009784f, -0.14920919f, 0.08751503f, 
    -0.00449419f, -0.13936898f, 0.07153235f, -0.08679877f, -0.06845713f, -0.02156503f, 0.03040519f, 0.01210056f, 
    -0.00107028f, 0.04878766f, -0.22193196f, -0.21403621f, 0.32540286f, 0.07106879f, 0.38494694f, 0.21281612f, 
    0.04623334f, 0.07378720f, -0.24494000f, 0.02143615f, -0.04955081f, -0.04176963f, 0.02384514f, 0.03577954f, 
    0.08374990f, 0.02421273f, -0.06818423f, 0.03177254f, 0.02520266f, -0.01514709f, 0.03597463f, 0.14042340f, 
    0.44351035f, -0.39970905f, -0.34203508f, -0.13383535f, -0.07409672f, 0.00650959f, 0.06432312f, 0.02677420f, 
    0.06586222f, 0.14115921f, 0.10658348f, 0.09836812f, 0.01106767f, -0.13785666f, -0.15138341f, -0.01311884f, 
    -0.01511102f, 0.02484764f, 0.13948701f, -0.00604070f, -0.02359917f, 0.23192279f, 0.18346180f, 0.08408664f, 
    -0.18340157f, -0.04511328f, -0.00607760f, -0.12340172f, 0.03593640f, -0.00878020f, -0.13779041f, 0.09142447f, 
    0.04572007f, -0.00565322f, -0.09236281f, 0.00829884f, 0.08588900f, -0.03747077f, 0.08962023f, 0.08009507f, 
    0.64695710f, 0.26699853f, 0.06139057f, -0.09609304f, 0.07945501f, -0.07455033f, 0.01916814f, 0.13158360f, 
    -0.01505653f, 0.09602556f, 0.04348673f, -0.00905201f, 0.00489848f, 0.21023157f, 0.12829432f, 0.00137372f, 
    -0.06578945f, 0.02522559f, -0.05929605f, -0.12212245f, 0.04250691f, -0.01757623f, 0.24967492f, 0.03921491f, 
    -0.09967354f, -0.12366211f, 0.00681405f, -0.05873026f, -0.06138429f, -0.16639654f, -0.09400888f, -0.04050624f, 
    -0.00359621f, -0.08444637f, -0.03066662f, 0.05013714f, -0.06565105f, -0.15420511f, -0.12913541f, -0.09832545f, 
    0.34564042f, 0.13854852f, 0.18703364f, -0.02176372f, -0.22520085f, 0.07199596f, 0.16402285f, -0.02692231f, 
    0.11020333f, -0.21392308f, -0.02376285f, 0.00601774f, 0.04904966f, 0.06229365f, -0.00758595f, 0.16839027f, 
    -0.19270509f, 0.07387250f, -0.01655021f, -0.21293263f, 0.13432804f, -0.30132732f, -0.06989582f, -0.06865038f, 
    0.01534258f, 0.13220645f, -0.10369978f, -0.15734728f, 0.00010103f, -0.01484816f, 0.08831017f, 0.02383854f, 
    0.03722072f, -0.07269734f, 0.06540641f, -0.01219039f, 0.04572851f, 0.06510796f, 0.04429241f, 0.02276612f, 
    -0.44246167f, 0.08797005f, 0.18030153f, 0.26133522f, 0.09594284f, -0.08257753f, -0.05981493f, 0.05760063f, 
    0.15125239f, -0.01719578f, -0.02689212f, 0.04011364f, 0.05443360f, -0.04054748f, -0.04532278f, -0.07051258f, 
    -0.10499879f, 0.03282294f, 0.10688310f, 0.13779640f, 0.27070436f, -0.16115610f, 0.23184168f, 0.10662013f, 
    0.05041564f, 0.02275440f, 0.11857871f, -0.05750851f, 0.20216377f, 0.00384553f, -0.06252924f, 0.05510865f, 
    -0.11535586f, 0.09118647f, -0.02054060f, -0.23425397f, 0.06407141f, 0.06365891f, 0.00094893f, 0.19368014f, 
    0.24391264f, -0.15006736f, -0.18363637f, 0.01516929f, 0.29661924f, -0.07799632f, -0.11788907f, 0.23843007f, 
    -0.03007364f, -0.09808660f, 0.03593149f, 0.00392676f, -0.00529072f, 0.03206249f, 0.02919712f, 0.11872835f, 
    0.10583195f, -0.00068838f, -0.04625946f, -0.24523865f, -0.03868395f, -0.20248501f, -0.17274819f, -0.07962391f, 
    0.24695857f, -0.03205456f, -0.05474710f, -0.04269271f, -0.01163476f, 0.02769365f, -0.05179838f, -0.01898703f, 
    0.00278324f, -0.06049045f, -0.05849840f, 0.01290709f, 0.03273326f, -0.06750438f, 0.09852368f, 0.17882916f, 
    0.40597862f, -0.54066598f, -0.18773036f, -0.18973815f, 0.03084066f, 0.02278718f, -0.03252501f, -0.09692302f, 
    0.09288998f, -0.06572974f, 0.10985707f, -0.02416432f, 0.04590532f, -0.13652690f, -0.13649184f, 0.05261274f, 
    -0.04762033f, -0.00100015f, 0.05670246f, -0.07142775f, -0.35767823f, -0.40507481f, -0.02611371f, 0.42087790f, 
    0.54142845f, -0.14051570f, -0.16237134f, 0.03446555f, 0.09328670f, 0.21364459f, -0.11013738f, -0.01450511f, 
    0.02510617f, -0.01856676f, -0.03937549f, 0.06815183f, 0.01547014f, -0.03940366f, 0.07832056f, -0.03200549f, 
    0.08303862f, 0.24920127f, 0.15190390f, 0.16196819f, -0.05007889f, -0.09164897f, 0.05664380f, 0.10055646f, 
    0.08130382f, -0.01933849f, 0.07592326f, 0.10404561f, -0.04664120f, 0.13099359f, 0.07240836f, -0.12764208f, 
    -0.05680105f, -0.00764995f, 0.05284671f, 0.04144134f, 0.49101526f, 0.07529107f, 0.02910907f, -0.33042005f, 
    -0.14490145f, 0.07129035f, 0.06165600f, -0.05483552f, 0.03468934f, 0.11951331f, 0.04729713f, -0.08891252f, 
    0.12052416f, -0.10455850f, 0.02640164f, -0.06047476f, 0.02635510f, -0.07864161f, 0.12562358f, -0.18415608f, 
    -0.15627608f, -0.00416930f, 0.16896379f, 0.24745329f, 0.24182710f, 0.09464225f, 0.19408165f, -0.02924629f, 
    0.15662989f, -0.10977580f, -0.02543321f, 0.01202870f, 0.05492407f, 0.07233886f, 0.18081766f, 0.01304934f, 
    -0.02686272f, 0.13892992f, 0.15302166f, 0.11249088f, -0.20630488f, 0.18253352f, 0.13036560f, 0.15191934f, 
    0.14006682f, -0.06720787f, 0.27255109f, 0.01262362f, 0.15428677f, -0.13269672f, -0.09937170f, -0.02022824f, 
    0.08820225f, 0.17786999f, 0.14740863f, -0.03866675f, 0.08509367f, 0.07602268f, 0.07026339f, 0.04549754f, 
    0.23915128f, -0.20309983f, -0.30071601f, -0.29012856f, 0.22687741f, 0.11843628f, -0.01669466f, -0.00635179f, 
    0.03540808f, -0.08148411f, -0.08695171f, 0.05397436f, -0.00869909f, -0.03275079f, -0.06567151f, 0.13981196f, 
    -0.06592557f, -0.06403545f, -0.09199666f, 0.00175315f, -0.19924793f, 0.36724392f, 0.13997777f, 0.11403614f, 
    -0.15730599f, -0.07643458f, -0.03126374f, -0.04623010f, 0.08454704f, -0.01369219f, -0.11894906f, 0.03201281f, 
    0.07600287f, 0.02341622f, 0.02093033f, 0.00391548f, 0.13510484f, 0.11978163f, 0.01009569f, 0.10425791f, 
    -0.02305024f, 0.13028973f, 0.09213364f, 0.14664091f, -0.18312488f, -0.04302963f, -0.01179841f, 0.04180945f, 
    0.00988468f, -0.07162586f, -0.08618333f, -0.00780953f, 0.01597872f, 0.15040995f, 0.16239093f, 0.07546889f, 
    0.08754672f, 0.03651837f, -0.05380819f, -0.12052719f, 0.10537119f, 0.18343866f, 0.17553996f, 0.13001740f, 
    -0.17454979f, 0.06346910f, -0.00200757f, -0.06374902f, 0.02139519f, -0.12915772f, -0.08272163f, -0.00917872f, 
    0.01297728f, -0.05921519f, 0.04640769f, 0.16182613f, 0.05753210f, 0.08026375f, -0.00244722f, -0.12443862f, 
    -0.03662229f, 0.25282881f, -0.28263485f, -0.22641154f, 0.19279048f, -0.04285030f, -0.01634397f, 0.18012810f, 
    0.19009128f, -0.02042678f, 0.00229426f, 0.01841788f, -0.04665847f, -0.05815791f, 0.06640907f, 0.11860245f, 
    0.04707802f, 0.08058002f, 0.01143234f, -0.21717663f, 0.04209756f, -0.08523826f, -0.26507822f, 0.00555546f, 
    0.21457070f, 0.03664011f, 0.01914077f, 0.07716052f, -0.08044408f, 0.10000286f, -0.13558647f, -0.05372480f, 
    -0.06856672f, -0.03600542f, 0.04250228f, -0.05617841f, 0.05084011f, -0.01449401f, 0.04024413f, 0.09169662f, 
    0.08299232f, 0.10083893f, -0.29716685f, -0.00607773f, -0.26129052f, 0.05221345f, 0.15444931f, 0.09554386f, 
    0.03973349f, -0.09559082f, -0.08672912f, -0.05633083f, 0.01556832f, 0.01127912f, 0.05903175f, -0.12431543f, 
    -0.06013123f, -0.06764028f, 0.04297178f, 0.07210326f, 0.05803438f, 0.17753889f, 0.12116249f, 0.11753502f, 
    -0.20670535f, 0.07018108f, -0.00264738f, 0.03865967f, 0.05000409f, -0.15643381f, -0.03597354f, 0.02885418f, 
    0.06785643f, -0.00453532f, 0.01831688f, 0.18733557f, 0.22803828f, 0.03292718f, -0.03070143f, -0.01822065f, 
    0.10786667f, 0.10989216f, 0.09908409f, 0.07374410f, 0.00277850f, -0.04922047f, 0.05539870f, 0.14717266f, 
    0.06708579f, -0.12043282f, -0.00219224f, 0.11111139f, -0.07595658f, -0.05205015f, 0.05736886f, -0.10833747f, 
    -0.00838529f, 0.01934232f, 0.00028709f, -0.01159548f, -0.06267922f, -0.03526567f, -0.00201508f, 0.15753345f, 
    -0.09361586f, -0.02166438f, 0.06126235f, 0.03636290f, 0.02016336f, 0.04116540f, -0.00498165f, -0.00711889f, 
    0.06325056f, 0.11876304f, 0.06669591f, -0.06874992f, 0.11741196f, 0.15158026f, 0.05839000f, -0.00949322f, 
    0.06141157f, 0.30044177f, -0.31041172f, -0.07833764f, 0.02768327f, 0.03748997f, 0.04605997f, 0.02846385f, 
    -0.00716355f, 0.07039657f, -0.13154516f, -0.03735778f, -0.08312596f, 0.11754298f, 0.10707790f, -0.01451589f, 
    0.13080329f, 0.10646848f, -0.02662247f, 0.04777907f, -0.03701572f, 0.19266795f, 0.29185212f, 0.12974796f, 
    -0.29984280f, -0.02451880f, 0.04559593f, 0.03280251f, 0.02874475f, -0.04671808f, -0.01436870f, 0.11275432f, 
    0.11778279f, 0.12470173f, 0.00281221f, -0.01168126f, 0.10942003f, 0.12207176f, 0.29137859f, 0.08859257f, 
    0.35708115f, 0.48774901f, 0.37690711f, -0.28168422f, 0.51037198f, -0.02409677f, 0.08328348f, 0.00748608f, 
    0.02114025f, 0.08119860f, 0.00969861f, 0.20208396f, 0.09387847f, -0.00668585f, 0.12711309f, -0.03885605f, 
    0.03560648f, 0.09532848f, 0.08520721f, 0.13225032f, -0.14952694f, -0.06683401f, 0.09983788f, 0.06550243f, 
    -0.21366997f, -0.12522121f, -0.08156053f, -0.18133172f, -0.06445695f, -0.17339490f, -0.00352642f, 0.00398224f, 
    -0.04217678f, 0.01670689f, -0.15615076f, -0.01493270f, 0.06387396f, 0.12650275f, 0.01323637f, -0.16436760f, 
    -0.57643503f, 0.40031767f, 0.17131263f, 0.09683315f, -0.08155987f, -0.03761736f, -0.04059531f, 0.09371372f, 
    0.05097132f, 0.02849917f, 0.02883203f, 0.07619901f, -0.04598423f, -0.03583391f, 0.01395456f, 0.10101584f, 
    0.20375469f, 0.20039813f, -0.02453105f, -0.14174125f, 0.10714848f, 0.07650611f, 0.36734262f, -0.24821307f, 
    0.09511289f, 0.05011763f, 0.14285839f, 0.06750932f, 0.14485079f, 0.06951447f, 0.06314217f, -0.06908973f, 
    0.10922287f, 0.10301092f, 0.00824233f, -0.05694588f, 0.01987341f, 0.23574144f, 0.03645632f, 0.14881195f, 
    -0.06245077f, -0.22007918f, -0.30296934f, -0.06899708f, 0.22280903f, 0.10706386f, 0.02906188f, 0.07050344f, 
    -0.02439735f, 0.00308671f, -0.11441281f, 0.05251789f, -0.02327845f, -0.09205852f, -0.01532841f, -0.02589681f, 
    0.05399049f, -0.01091044f, 0.02862226f, -0.00305968f, -0.14146663f, -0.08853490f, 0.24924222f, 0.16021611f, 
    -0.15310918f, -0.08901343f, -0.02294177f, 0.01661486f, 0.17695647f, 0.07797606f, -0.13497505f, 0.10055441f, 
    0.00920402f, -0.02161888f, 0.08064769f, 0.09143044f, 0.07598102f, -0.04263192f, 0.12818116f, -0.01537064f, 
    0.62217665f, 0.37767932f, 0.22726718f, -0.24092010f, 0.35280153f, -0.07151517f, 0.01689846f, -0.06553756f, 
    0.07276829f, -0.05563196f, -0.03033754f, 0.06502180f, -0.00995685f, -0.00438209f, 0.05006427f, 0.07272880f, 
    0.12817849f, 0.04290061f, 0.06435275f, -0.05373909f, -0.04032252f, -0.40913638f, 0.46496034f, -0.04138351f, 
    -0.04354020f, -0.14097793f, -0.03972681f, -0.07344230f, 0.02004671f, -0.02107234f, -0.05449584f, -0.00365921f, 
    -0.05326178f, 0.07789223f, 0.06299783f, 0.06471573f, -0.01067623f, -0.03715551f, 0.04121151f, -0.13314705f, 
    0.41037881f, -0.22241482f, 0.50434101f, -0.13339615f, -0.05314364f, -0.02088082f, 0.10408906f, -0.03484656f, 
    0.15377285f, -0.17454484f, -0.01074796f, 0.06764103f, -0.01222769f, 0.02383572f, 0.03782387f, 0.01706622f, 
    0.02498528f, -0.04580213f, 0.05610714f, -0.14825493f, 0.05325921f, 0.05078037f, -0.14141910f, -0.28289923f, 
    0.11400342f, 0.04117233f, 0.03802749f, -0.09450294f, 0.15241370f, 0.02030046f, 0.03701467f, 0.01991848f, 
    -0.12820949f, 0.02811078f, 0.03447210f, 0.04818599f, 0.10605437f, 0.13827699f, -0.01815917f, 0.15699483f, 
    -0.61854386f, -0.33578959f, 0.43168357f, 0.17389449f, 0.11969496f, -0.02983059f, 0.08640100f, 0.06070767f, 
    0.05759882f, -0.00917442f, -0.01764685f, -0.03925770f, -0.09027383f, 0.08033132f, 0.07131489f, -0.07593851f, 
    0.07559907f, 0.05667656f, -0.02049869f, 0.00940189f, 0.19237033f, 0.00263369f, 0.02297617f, -0.08495086f, 
    0.16271016f, 0.20925429f, 0.16523193f, -0.07592567f, 0.01251843f, 0.05297095f, 0.02082301f, 0.12676477f, 
    -0.02968165f, 0.08812288f, 0.03968056f, -0.11476351f, -0.04187247f, 0.11301801f, 0.13576756f, 0.06061524f, 
    0.05538034f, -0.12001636f, -0.06345216f, -0.28025687f, 0.13899784f, -0.13784987f, 0.01545892f, -0.02584231f, 
    -0.06596571f, -0.11369073f, -0.03342893f, -0.01543590f, -0.11540957f, -0.06430529f, 0.09266783f, -0.10389074f, 
    -0.14861056f, 0.05871180f, 0.03411104f, -0.06174064f, 0.02939731f, -0.01591169f, -0.39265960f, -0.06523704f, 
    0.14400050f, 0.26047397f, 0.07080384f, -0.03534970f, -0.02011706f, -0.10872271f, 0.00460835f, 0.05319392f, 
    -0.01508279f, 0.04000684f, 0.03928763f, 0.04043595f, 0.00823928f, 0.08810361f, 0.07793386f, 0.24916106f, 
    0.07857642f, 0.12545717f, -0.17736240f, -0.12846020f, 0.30914342f, 0.06910683f, 0.09044086f, 0.06297620f, 
    -0.03097910f, -0.02385741f, -0.10355868f, 0.08557583f, -0.01392846f, 0.03581234f, 0.08732706f, 0.13000777f, 
    -0.05047229f, -0.04048533f, 0.01114610f, 0.01152277f, -0.12269469f, 0.19632545f, -0.45387363f, 0.39418072f, 
    0.23401326f, -0.03935710f, 0.00269614f, 0.07455798f, 0.17372999f, 0.09036469f, 0.06217180f, 0.01329827f, 
    0.01365267f, -0.00717803f, -0.05937402f, 0.12066321f, 0.05114682f, 0.14652334f, 0.25103843f, 0.17906305f, 
    -0.20114999f, 0.01270257f, -0.07456139f, 0.03581652f, -0.03665618f, -0.10495231f, -0.00829580f, -0.02164097f, 
    -0.04057243f, 0.07213610f, 0.02795550f, 0.08495495f, 0.13184099f, -0.00066249f, -0.09692292f, -0.15906355f, 
    -0.02800739f, -0.08114467f, 0.12088256f, 0.03676416f, -0.20188712f, 0.22063255f, 0.09828299f, -0.16830295f, 
    0.06971563f, 0.16924655f, 0.11672345f, 0.08529416f, 0.08873896f, -0.16110568f, -0.10362962f, 0.02300057f, 
    -0.00966704f, 0.10548145f, 0.13409807f, -0.00506727f, 0.12324107f, 0.05560639f, -0.02919400f, -0.09551690f, 
    -0.33009973f, -0.08653519f, 0.06854355f, 0.34162182f, -0.07542524f, -0.09631407f, 0.09009151f, -0.04243774f, 
    -0.00399876f, 0.03202906f, -0.08917406f, 0.12959102f, -0.00615522f, 0.02470607f, -0.02095628f, 0.05445245f, 
    -0.12202211f, 0.13039222f, 0.21945862f, -0.06960606f, -0.10535033f, -0.02467071f, 0.26433542f, 0.13730751f, 
    -0.09072217f, -0.10480446f, 0.08918234f, -0.07652079f, 0.11264971f, 0.00419989f, 0.00459270f, 0.02713425f, 
    -0.00671257f, 0.00267418f, -0.02297147f, -0.05743590f, 0.08517221f, 0.07555659f, 0.16955790f, -0.02732908f, 
    0.17549871f, 0.10392772f, -0.00663888f, -0.02988338f, 0.23883866f, 0.06030821f, 0.08480886f, 0.10907526f, 
    0.04826130f, -0.09795626f, 0.00450730f, 0.07087155f, 0.05625328f, 0.00672944f, 0.06384712f, 0.14283758f, 
    0.08060019f, -0.04032060f, 0.00339816f, -0.05703492f, -0.43414092f, 0.03475548f, -0.01740730f, 0.01391395f, 
    -0.11950284f, -0.18064053f, -0.13741790f, -0.10281702f, -0.01946901f, -0.05702105f, -0.17302211f, -0.12066004f, 
    0.04642545f, -0.05967769f, -0.05890701f, -0.04410888f, 0.03027527f, -0.01153709f, -0.03169424f, 0.00292638f, 
    -0.13517490f, -0.13923267f, -0.05636579f, -0.06255652f, -0.14069970f, -0.00817450f, -0.04164209f, -0.10253297f, 
    -0.00629320f, -0.09140331f, -0.01980134f, 0.01665718f, 0.07839338f, -0.01262443f, 0.06224972f, 0.01122924f, 
    0.00883878f, -0.06008425f, -0.05147577f, -0.12471201f, -0.11431568f, -0.25474778f, 0.01178109f, -0.06483687f, 
    -0.17495100f, -0.03730744f, -0.09374879f, -0.14000474f, -0.02481068f, -0.08684865f, 0.01596608f, -0.02459919f, 
    -0.08009191f, 0.03451013f, 0.01430537f, 0.00656111f, -0.07298938f, -0.06391558f, -0.08787765f, -0.23637393f, 
    0.08845720f, 0.34224534f, -0.12080052f, -0.07463589f, 0.07194129f, -0.02173165f, -0.01173208f, 0.09140144f, 
    -0.00725943f, -0.08957291f, -0.00454574f, -0.01874237f, -0.04101698f, -0.00426364f, -0.02202035f, -0.02937106f, 
    -0.08620739f, 0.05305119f, -0.08646256f, -0.02495568f, -0.03913303f, 0.36065525f, -0.06773698f, -0.00634678f, 
    0.32125103f, 0.12154991f, 0.08429234f, 0.07155922f, 0.00167423f, 0.00963691f, -0.09246720f, 0.08525654f, 
    0.00595621f, -0.00106741f, 0.00426622f, -0.05690158f, 0.01091676f, 0.15632075f, 0.08852676f, 0.15717360f, 
    -0.05096251f, -0.05297523f, -0.19285245f, -0.07949588f, -0.14234768f, 0.11447801f, 0.03185609f, 0.12268165f, 
    0.07712916f, -0.02546485f, -0.10338534f, 0.04769992f, 0.06656496f, -0.00991356f, 0.06198571f, -0.05278853f, 
    -0.01583210f, -0.09698162f, -0.04336880f, -0.03859964f, -0.18245280f, -0.09934342f, 0.07243267f, 0.02096406f, 
    -0.09329082f, -0.09116510f, -0.18694840f, -0.08763187f, -0.13056681f, -0.12715769f, -0.04260929f, -0.01792279f, 
    0.03639982f, -0.07869599f, -0.12034968f, -0.04384106f, 0.15447767f, -0.05651029f, -0.11274719f, -0.09039966f, 
    -0.15844996f, -0.09316570f, 0.24002761f, -0.03780757f, -0.00729942f, -0.00280824f, 0.03426367f, -0.00825661f, 
    0.02365853f, -0.03857151f, 0.01349446f, 0.06451679f, -0.11501661f, 0.10899296f, -0.00130921f, -0.09827577f, 
    0.07378957f, 0.01601446f, 0.00748289f, 0.05190279f, -0.17586000f, -0.29256415f, -0.12418494f, -0.04288292f, 
    -0.12011059f, -0.12876244f, -0.07977057f, -0.09333242f, -0.08366159f, -0.05496291f, -0.02710019f, 0.03980158f, 
    -0.09038174f, -0.01887145f, -0.19069138f, -0.20211932f, 0.05635910f, 0.15767877f, -0.02372992f, -0.12657411f, 
    0.28896895f, 0.34928712f, -0.01304561f, -0.03513981f, 0.09655314f, 0.12662534f, 0.07671189f, 0.12182061f, 
    0.02720134f, 0.07609294f, -0.01300861f, 0.03907321f, 0.01626298f, 0.03823313f, 0.08937187f, 0.03714422f, 
    0.00802616f, 0.08818043f, 0.07461364f, 0.05974698f, 0.13839069f, -0.17235458f, 0.22667505f, -0.03407206f, 
    -0.21955347f, 0.00977998f, -0.09327328f, 0.01813927f, -0.03330905f, 0.02237817f, -0.06755055f, 0.10718408f, 
    0.06931987f, 0.13487382f, 0.01605049f, -0.00675417f, 0.19940677f, -0.00337183f, 0.12089332f, -0.01591347f, 
    -0.27994600f, -0.08772722f, 0.28746048f, -0.00410616f, 0.23217630f, 0.10574852f, 0.04734128f, 0.06421110f, 
    -0.15894103f, 0.02546098f, -0.01897312f, 0.05358986f, -0.03866708f, -0.03369518f, -0.04110888f, 0.07614261f, 
    -0.08772136f, -0.02333256f, 0.10880135f, 0.06866796f, 0.02846985f, 0.07947151f, 0.13998961f, -0.17014602f, 
    -0.03203126f, 0.10308774f, 0.01104573f, -0.09970477f, 0.02547557f, -0.08982751f, -0.00875324f, 0.01126879f, 
    0.04202567f, -0.02057748f, -0.10037078f, -0.04990727f, 0.03303145f, -0.01779756f, -0.15797549f, -0.12484816f, 
    -0.21370417f, 0.22002237f, -0.24762426f, -0.06829662f, -0.33727178f, 0.00793873f, -0.04271093f, -0.10185699f, 
    -0.04069872f, -0.21388997f, -0.21125379f, -0.02964665f, -0.08621884f, 0.05866225f, 0.13518997f, 0.17173952f, 
    -0.07430072f, 0.10481605f, -0.06831023f, -0.02295683f, 0.45088232f, 0.13690715f, 0.09288017f, 0.18186702f, 
    -0.02179270f, 0.17415759f, -0.22286372f, -0.04129494f, 0.00677559f, -0.21572040f, -0.01208365f, -0.08051451f, 
    0.03533754f, 0.00114561f, -0.04688972f, -0.07637403f, -0.03443289f, -0.01684623f, -0.02891974f, -0.03299121f, 
    -0.41177294f, -0.09793489f, 0.19618988f, 0.17971024f, 0.05391937f, 0.03537429f, 0.01127992f, -0.02773781f, 
    0.01514813f, -0.02510482f, -0.00885882f, 0.00849731f, -0.00323432f, -0.09433072f, -0.13667116f, -0.08579897f, 
    -0.09847146f, -0.14452685f, -0.10831597f, -0.02555349f, 0.33028185f, 0.15480433f, -0.36351976f, 0.08788268f, 
    0.27112961f, 0.10191940f, 0.05507772f, 0.08184779f, 0.22455117f, 0.02173007f, 0.00309264f, -0.11703297f, 
    -0.00323059f, -0.09464324f, -0.08378368f, -0.00787400f, -0.04912600f, 0.05358990f, 0.12977596f, 0.03062169f, 
    -0.28421730f, -0.01946032f, -0.02859498f, 0.18200153f, 0.14610381f, 0.19780363f, 0.03298888f, -0.05025737f, 
    -0.07195652f, -0.00299437f, -0.01257806f, -0.04192814f, 0.05028952f, 0.07383632f, 0.19389820f, 0.04209219f, 
    0.14491804f, 0.03383600f, -0.03640301f, 0.06339898f, 0.48100355f, -0.38809818f, 0.03596205f, -0.04814180f, 
    0.14324702f, 0.10158323f, -0.00935643f, 0.00148691f, 0.13833095f, 0.03928524f, -0.11336254f, -0.10041662f, 
    -0.08213662f, -0.13240173f, -0.09563219f, -0.08423728f, 0.11423036f, 0.24959095f, 0.14456956f, 0.06213424f, 
    0.49297896f, 0.03696113f, 0.09849134f, -0.44650787f, 0.16664843f, 0.27661449f, 0.24328387f, -0.10568322f, 
    0.12736215f, 0.10385510f, -0.06927466f, 0.10899726f, -0.03332219f, -0.03761060f, 0.00818917f, -0.00105932f, 
    0.11713708f, -0.00378916f, 0.02503665f, 0.10394987f, 0.21449737f, -0.12877223f, -0.08318700f, 0.24546726f, 
    0.05827846f, 0.11000286f, -0.10005439f, -0.19039665f, -0.00481303f, -0.16906469f, 0.01564215f, 0.01920855f, 
    -0.04148627f, -0.13962750f, 0.01699379f, -0.00362247f, 0.00429800f, -0.00438019f, -0.19052437f, -0.03484232f, 
    0.21919177f, 0.04745417f, 0.50433779f, 0.07748707f, 0.18827546f, -0.03503541f, 0.10713547f, -0.18456136f, 
    0.17231207f, 0.03645645f, -0.10664957f, -0.03493371f, -0.06539023f, 0.02519177f, -0.00782781f, 0.08420681f, 
    0.06800974f, -0.01106121f, -0.00789737f, 0.06592542f, 0.22424862f, 0.05272816f, -0.25335407f, 0.03163917f, 
    0.07337711f, -0.10883003f, -0.08517458f, 0.09208980f, -0.00349360f, 0.06568106f, 0.11728127f, -0.01805360f, 
    0.02272670f, -0.17092198f, -0.12072744f, 0.02459236f, -0.00024908f, 0.11237997f, 0.06932741f, 0.00514149f, 
    0.02733405f, -0.21520831f, -0.06453510f, 0.11402650f, 0.26814142f, -0.02180819f, -0.27559841f, -0.18143392f, 
    0.06504729f, -0.03000799f, -0.02558552f, 0.07445890f, 0.02163348f, -0.05049814f, -0.02839707f, 0.15953857f, 
    -0.02884683f, -0.02746039f, 0.17872182f, 0.02642828f, -0.03685498f, -0.24093409f, 0.02204479f, 0.27220830f, 
    0.12887010f, -0.06455024f, -0.21618944f, -0.01106674f, 0.00883167f, -0.06126828f, 0.10475983f, 0.01104820f, 
    -0.06752394f, -0.11525429f, -0.05208139f, 0.09224407f, -0.00364957f, -0.01380963f, -0.11437722f, -0.00504376f, 
    -0.11081980f, -0.21393977f, -0.01213226f, 0.29817900f, 0.16916740f, 0.08271820f, -0.00650002f, -0.04989569f, 
    0.01782841f, 0.02854561f, 0.01912379f, -0.02000730f, 0.06427950f, -0.18108088f, -0.09494941f, 0.01167716f, 
    0.07134362f, 0.00368972f, -0.12045547f, 0.02608426f, -0.05650863f, -0.13459262f, 0.32368726f, 0.03364997f, 
    -0.04677681f, -0.08844147f, -0.01302753f, 0.04043248f, 0.04201858f, 0.04498379f, -0.03305608f, -0.02518385f, 
    0.11435702f, -0.08452848f, -0.03639015f, 0.03493338f, 0.08420661f, 0.05598347f, 0.08321954f, -0.20307338f, 
    -0.33883914f, 0.05641108f, -0.35070536f, -0.17129928f, 0.11603072f, 0.11921914f, 0.10591153f, -0.16993314f, 
    0.05314045f, 0.09662993f, -0.00453149f, 0.00572980f, 0.20949206f, -0.06589605f, -0.01608653f, 0.06060855f, 
    -0.06068379f, -0.04815564f, 0.11334287f, 0.09665346f, -0.51582217f, -0.23773979f, -0.25501463f, 0.29609671f, 
    -0.05388887f, 0.35494488f, 0.10610853f, 0.01433760f, -0.02230553f, -0.10191642f, -0.07211802f, -0.17897031f, 
    -0.06772083f, -0.00293225f, 0.13347498f, 0.03964388f, 0.06912842f, -0.10596317f, -0.02544883f, -0.03405201f, 
    0.13123205f, -0.03465598f, 0.21865211f, -0.28242677f, -0.00501076f, 0.04393280f, 0.06332830f, -0.19247632f, 
    0.08451442f, -0.03277837f, -0.20843975f, -0.03273062f, -0.04653256f, 0.00387005f, -0.09332847f, 0.08046684f, 
    0.08590897f, -0.02697816f, 0.03059458f, -0.04700995f, 0.04254831f, -0.02146466f, -0.28236672f, -0.04855038f, 
    0.36742082f, 0.01654492f, 0.18480621f, -0.18667881f, 0.00475158f, 0.08675741f, -0.15154931f, -0.06295337f, 
    0.09229528f, 0.04504164f, 0.00190909f, 0.13901553f, 0.06686717f, -0.01236423f, -0.00285509f, -0.05049014f, 
    0.02900924f, 0.03149219f, 0.05611677f, 0.13208099f, 0.00979875f, 0.04501455f, -0.04649463f, -0.08189572f, 
    0.05816153f, -0.01753693f, 0.05462291f, -0.02017901f, 0.05244295f, 0.09562505f, 0.14527391f, -0.07435782f, 
    0.02998485f, -0.02002714f, 0.14685343f, 0.13206357f, -0.05664911f, 0.08809996f, -0.28437486f, -0.02299513f, 
    0.15175937f, -0.04363848f, 0.16744637f, 0.09972519f, 0.04159941f, 0.04219073f, -0.01905528f, -0.06814815f, 
    -0.11567789f, -0.04698773f, 0.07797588f, 0.12463524f, 0.08576700f, 0.15297431f, -0.00920543f, -0.07880681f, 
    -0.14767627f, -0.18291314f, -0.05860217f, -0.10166575f, 0.20425928f, 0.10345683f, 0.04021222f, 0.04457518f, 
    -0.01465207f, -0.04043931f, -0.10157567f, 0.00483062f, 0.08112710f, -0.13975830f, 0.06948645f, 0.04164564f, 
    0.06402658f, -0.02228353f, -0.04670868f, -0.05584768f, 0.22943014f, -0.21087924f, 0.12141936f, -0.20952673f, 
    0.04041002f, 0.05528397f, 0.05095695f, 0.00770652f, 0.11587904f, -0.03749080f, -0.11809295f, -0.09460522f, 
    -0.05377112f, -0.13488171f, -0.15381499f, -0.03415060f, 0.17920955f, 0.22605737f, -0.11809719f, -0.00663113f, 
    -0.29184872f, -0.16951676f, 0.11172627f, 0.27474177f, 0.07066080f, -0.01090581f, -0.19828269f, -0.01293475f, 
    -0.05102184f, -0.09115575f, -0.00688910f, -0.09980696f, 0.00330140f, 0.02308219f, 0.05806243f, 0.14753956f, 
    0.18718444f, 0.14724718f, 0.05572292f, 0.07513209f, -0.35555395f, -0.01921946f, -0.08096927f, 0.26946408f, 
    -0.05661119f, 0.18619177f, -0.16025759f, 0.14595269f, 0.03008081f, 0.08707871f, -0.01760292f, -0.10156046f, 
    -0.01368940f, 0.12243725f, -0.06146371f, 0.13207403f, -0.04797095f, 0.15679924f, 0.12996268f, -0.02057133f, 
    -0.53009862f, -0.06636198f, -0.23338586f, -0.07446304f, 0.02900151f, 0.24827075f, 0.18582354f, 0.12519199f, 
    -0.20013800f, -0.07262936f, 0.01716938f, -0.15917124f, -0.03492449f, 0.02252672f, 0.06676517f, -0.04674964f, 
    -0.03803590f, 0.02918867f, -0.04983481f, 0.03673413f, 0.06327118f, 0.02210213f, 0.09028696f, -0.18540888f, 
    -0.08900192f, 0.06616054f, 0.02467376f, 0.10189229f, -0.10542520f, -0.08362026f, -0.09323098f, 0.01430616f, 
    0.12615693f, -0.10166491f, -0.05936795f, 0.07096450f, 0.22878928f, 0.01787834f, -0.13209291f, -0.14305092f, 
    -0.05538281f, 0.26594105f, 0.04226311f, -0.20144574f, 0.04543755f, 0.11779486f, 0.05806939f, -0.08566555f, 
    0.09991799f, 0.09179381f, 0.02251181f, 0.06735700f, -0.00421098f, 0.08390209f, 0.01458906f, 0.11718005f, 
    -0.02024464f, -0.03276029f, 0.07709443f, 0.01218617f, -0.07708449f, -0.16755901f, 0.19321141f, -0.20310687f, 
    -0.00863294f, -0.03003784f, 0.19775957f, -0.09703813f, -0.02992219f, -0.05801759f, 0.07660080f, 0.11892708f, 
    0.01443628f, -0.07519013f, 0.01103696f, -0.13775817f, 0.02643861f, -0.02905684f, -0.31828213f, -0.14651842f, 
    -0.36234504f, 0.04880366f, -0.01222411f, 0.22600363f, 0.08165751f, 0.07149012f, -0.06043557f, 0.04380821f, 
    -0.16806298f, -0.00095167f, 0.09193497f, -0.12261543f, -0.00135541f, 0.15252784f, 0.08416694f, 0.08059546f, 
    0.03681510f, 0.05636217f, 0.12150685f, 0.12344274f, 0.46724075f, 0.31561437f, 0.16069606f, -0.24633718f, 
    0.07800961f, -0.10316320f, 0.03693490f, -0.06649747f, -0.13103998f, 0.02953513f, -0.02734175f, 0.00792804f, 
    0.07308917f, -0.08079149f, 0.14700364f, -0.04094652f, -0.12716164f, -0.06781616f, -0.22964559f, 0.05309434f, 
    0.03758413f, -0.22298865f, -0.35477853f, 0.08149732f, -0.25983098f, 0.07891677f, 0.01254536f, -0.14013427f, 
    0.01036466f, 0.00291136f, 0.03660731f, 0.02833486f, -0.02134519f, 0.00651405f, -0.09738811f, 0.16275156f, 
    0.18335448f, 0.07469749f, 0.11084321f, 0.19691812f, 0.16468428f, -0.00612616f, -0.27833179f, -0.02490182f, 
    0.01367747f, 0.07940242f, 0.18790333f, 0.16973954f, 0.09972626f, -0.07247692f, -0.02675626f, 0.04657463f, 
    -0.08929875f, -0.12151057f, 0.08355588f, -0.07722773f, -0.02915770f, -0.23755711f, -0.11284013f, -0.12792647f, 
    -0.24103966f, -0.38563380f, 0.00778371f, -0.12069277f, 0.02269915f, 0.00008211f, -0.05156876f, 0.00866339f, 
    -0.09065964f, -0.10073300f, 0.18120641f, 0.02655705f, 0.08685544f, 0.08265273f, 0.04365321f, -0.05051931f, 
    0.15248373f, 0.08279295f, -0.11678898f, 0.10846446f, 0.10872657f, 0.14729571f, 0.08256362f, 0.02936225f, 
    0.16648336f, -0.01466530f, 0.19382992f, 0.07317229f, 0.00729853f, 0.08449623f, -0.05789263f, -0.06984752f, 
    -0.03984163f, -0.09483627f, -0.00431003f, 0.03974855f, 0.06659459f, -0.06993101f, 0.09052360f, -0.00167148f, 
    0.33842546f, 0.28425837f, 0.22754049f, 0.03254570f, -0.01167135f, -0.11950674f, -0.11095776f, -0.07447737f, 
    -0.03264945f, -0.11827051f, 0.00799080f, -0.17803222f, -0.05255219f, -0.07864231f, 0.05653837f, 0.00335837f, 
    -0.10820509f, -0.08463813f, -0.19775082f, -0.28437483f, -0.01021655f, 0.19586979f, 0.13888900f, -0.10130797f, 
    0.03991628f, 0.16285822f, 0.04494515f, 0.04423149f, -0.08319750f, -0.07594019f, 0.08561469f, -0.07328328f, 
    -0.17266142f, -0.04518385f, -0.04775457f, 0.12522851f, 0.02520092f, 0.10072587f, 0.04729650f, 0.06281203f, 
    -0.27518275f, 0.01265473f, -0.22937030f, 0.02128597f, -0.04235495f, 0.00412541f, 0.06332296f, 0.08825786f, 
    -0.14568099f, 0.10164849f, 0.08385023f, 0.04922601f, -0.12147398f, 0.06539923f, -0.04992494f, -0.10573853f, 
    0.02443848f, 0.02990851f, 0.20605409f, 0.10713730f, -0.08323868f, 0.38771570f, -0.05150429f, 0.05434075f, 
    0.08074465f, 0.03896761f, 0.07907484f, 0.06926419f, -0.03470500f, -0.09654900f, 0.00470635f, -0.04836498f, 
    0.04463899f, -0.07345708f, 0.03075360f, 0.17762657f, 0.16202857f, 0.12987921f, 0.03243181f, 0.21243963f, 
    -0.26813641f, 0.15910506f, -0.17017791f, 0.02318825f, 0.07390431f, 0.03546127f, -0.16458924f, -0.07887339f, 
    -0.08590025f, -0.21529788f, -0.00733298f, -0.16585001f, -0.06499314f, -0.04102736f, -0.04474877f, 0.00308392f, 
    0.02798274f, -0.14445783f, -0.04074038f, -0.06929541f, 0.04807233f, 0.10165042f, 0.15840000f, -0.09935606f, 
    -0.04405445f, -0.08786114f, -0.19427007f, 0.14333564f, -0.00394148f, -0.07101200f, -0.01876615f, 0.14302230f, 
    0.07403223f, -0.12078540f, -0.08341657f, -0.09378991f, -0.34865201f, -0.25245497f, -0.00119773f, -0.28494588f, 
    0.08864331f, 0.14963037f, -0.04790921f, 0.11406711f, -0.12929939f, 0.16373865f, 0.00350557f, -0.00103620f, 
    0.02452873f, 0.07853107f, -0.08475846f, -0.13320039f, -0.01004288f, -0.05975964f, -0.02842059f, 0.06059421f, 
    0.02741314f, 0.05982752f, 0.00783098f, -0.04506338f, -0.04584749f, -0.00835790f, 0.10854387f, -0.02301486f, 
    -0.05991850f, -0.01171231f, -0.11170337f, 0.00963452f, 0.06187599f, -0.07516208f, -0.00664131f, 0.08082774f, 
    0.07012939f, -0.02653066f, 0.04206457f, 0.04332805f, 0.18146066f, -0.13624057f, 0.13922247f, 0.27752590f, 
    0.06280921f, 0.22348715f, 0.11271657f, 0.03849725f, -0.01340764f, -0.02601867f, 0.12173820f, 0.02302493f, 
    0.16660604f, 0.06664894f, -0.03489606f, -0.06563158f, 0.04696909f, 0.08708071f, -0.13781843f, 0.09194761f, 
    0.15562271f, 0.20964389f, 0.22366503f, 0.26699799f, 0.31305251f, 0.17529602f, 0.18585080f, -0.09167053f, 
    -0.00225336f, -0.04782823f, -0.08092950f, 0.04056972f, 0.06512419f, 0.25186282f, 0.01286381f, -0.01656535f, 
    0.04674292f, -0.02348960f, -0.02608501f, 0.01984069f, -0.09646276f, -0.02519991f, -0.02190170f, -0.14472276f, 
    0.32400599f, 0.27213430f, 0.18176450f, 0.05850049f, -0.13248979f, -0.02757479f, -0.19016862f, 0.12611173f, 
    -0.08717499f, -0.06326290f, -0.08029671f, -0.03647876f, -0.02112488f, -0.10761292f, 0.01933278f, -0.07543544f, 
    -0.19328047f, -0.12576224f, 0.02883372f, -0.19804232f, 0.09142978f, 0.08443709f, 0.26308310f, -0.08512166f, 
    -0.03427365f, 0.04266199f, -0.11334205f, 0.02292617f, -0.05632136f, -0.04232315f, 0.07804992f, 0.01865453f, 
    -0.03870055f, -0.07414699f, 0.07480339f, -0.11460733f, -0.16090915f, 0.05524644f, -0.17163922f, -0.11692617f, 
    0.10996060f, -0.16713712f, 0.24823707f, -0.04497997f, -0.13870546f, 0.05635837f, 0.04112492f, -0.02820410f, 
    0.03103169f, -0.07382356f, 0.07264043f, 0.01383021f, 0.06007820f, 0.04796690f, 0.08567808f, -0.01753523f, 
    -0.14456797f, -0.08105955f, -0.33534679f, -0.42237204f, 0.39005283f, 0.25125909f, 0.18197797f, -0.00470533f, 
    0.05962818f, -0.18669842f, -0.09277645f, -0.06692194f, -0.11668117f, -0.05103378f, 0.09163480f, -0.07441577f, 
    -0.14752245f, 0.04640987f, 0.01030088f, -0.17112841f, -0.09855510f, -0.01397388f, -0.08245645f, 0.00535868f, 
    -0.20458438f, 0.17180087f, -0.14069083f, -0.19120471f, -0.29327023f, 0.12642656f, -0.09617823f, -0.04106988f, 
    0.08274062f, -0.00997024f, 0.13781993f, 0.03931532f, -0.02262572f, -0.16359201f, 0.07323713f, -0.03599658f, 
    -0.06589865f, -0.04297731f, -0.06339888f, -0.11961123f, -0.23479001f, 0.05731802f, -0.24408542f, -0.13843583f, 
    -0.02763974f, 0.08106963f, -0.00762823f, -0.02490930f, 0.01878395f, 0.01085170f, 0.18516105f, -0.05182981f, 
    -0.00805068f, -0.07761857f, 0.01250094f, 0.05076006f, -0.17173710f, -0.17300102f, -0.10136773f, -0.12428038f, 
    0.20843014f, -0.00968677f, 0.09843004f, 0.05960422f, -0.09010089f, -0.11122837f, -0.00610401f, 0.02237628f, 
    -0.01181367f, 0.01063256f, -0.06296530f, -0.05137516f, 0.02876149f, 0.06283367f, 0.13412251f, 0.02357484f, 
    0.16546364f, 0.03686891f, 0.08732516f, 0.01274081f, 0.25525448f, -0.08758863f, 0.05875069f, 0.04285888f, 
    0.01090795f, 0.08082215f, 0.09011809f, 0.03485929f, -0.13271406f, 0.01521822f, 0.01319533f, -0.10198038f, 
    0.10704092f, 0.10906303f, -0.01009123f, 0.10938621f, -0.00815619f, -0.04723808f, -0.15256715f, 0.00280500f, 
    -0.03739354f, 0.07536547f, -0.00533945f, -0.12173157f, 0.01156874f, 0.00901647f, 0.01400691f, 0.00518444f, 
    0.05146749f, 0.04095807f, 0.07889527f, 0.05139571f, 0.10612855f, 0.01541982f, 0.00525391f, 0.01023296f, 
    0.03794952f, -0.10212900f, -0.29526600f, -0.15153390f, 0.03161740f, 0.04386884f, -0.04738523f, -0.01041247f, 
    0.03853672f, -0.09938216f, -0.03350134f, 0.08169985f, -0.01553263f, -0.12134483f, -0.03471450f, -0.01727111f, 
    0.09883603f, 0.01814784f, 0.09242640f, 0.07364541f, 0.16095795f, -0.05521527f, -0.07147843f, 0.04107663f, 
    0.34766498f, -0.00123745f, 0.00673073f, -0.09983668f, 0.01851759f, -0.13250291f, 0.09140531f, 0.16337746f, 
    -0.05386692f, 0.14723426f, -0.05342766f, 0.00634656f, -0.06632779f, 0.15525752f, -0.00375992f, 0.06025752f, 
    0.10487701f, 0.30805528f, 0.25725538f, 0.22482753f, 0.39965126f, -0.15275426f, 0.14477178f, -0.04219093f, 
    -0.09158117f, -0.11022009f, -0.00402231f, -0.05290557f, 0.02397398f, 0.02982489f, 0.06930690f, -0.10020787f, 
    -0.09373742f, 0.00829571f, 0.02086265f, 0.04916595f, 0.20081553f, 0.13658699f, -0.01061836f, 0.08420107f, 
    0.09639293f, 0.22595735f, 0.14250822f, 0.05929821f, 0.11228199f, -0.07284907f, -0.00973308f, 0.03994297f, 
    0.03845098f, 0.14937672f, 0.13524131f, -0.00559261f, 0.05287388f, 0.07796130f, -0.05148387f, 0.22095867f, 
    0.20364945f, -0.05773612f, -0.03038275f, 0.15264158f, 0.02368879f, 0.06484410f, -0.10348940f, -0.14052516f, 
    -0.12797491f, 0.04127636f, 0.16582230f, 0.05620544f, 0.07912660f, 0.02108360f, 0.01355417f, -0.03135149f, 
    -0.04994877f, 0.07001452f, 0.06410673f, -0.04903321f, -0.06918414f, -0.19623211f, -0.21649110f, -0.21674395f, 
    0.03293756f, -0.10931194f, 0.02235296f, 0.04558538f, -0.11059531f, -0.02591892f, -0.00401656f, -0.03701485f, 
    0.06438001f, -0.10050248f, 0.05960195f, -0.09539131f, 0.10124668f, -0.11287475f, -0.05005867f, -0.00324410f, 
    0.00710374f, -0.04649907f, -0.14850996f, -0.09165327f, -0.08804612f, 0.23816995f, 0.04710231f, -0.21275677f, 
    -0.11483149f, 0.02804157f, 0.00092531f, 0.06376592f, -0.00548122f, -0.06408877f, -0.02241361f, -0.01475290f, 
    -0.07386814f, 0.09004606f, 0.02838150f, 0.06648401f, -0.15588880f, -0.14528084f, -0.17549646f, -0.38612905f, 
    0.21682459f, -0.19018210f, -0.13112088f, 0.08722536f, 0.10331055f, -0.00690937f, -0.01601171f, -0.05261422f, 
    -0.00352256f, 0.05863697f, 0.08290938f, -0.09524947f, 0.03142218f, 0.13613103f, 0.09665304f, 0.01883826f, 
    0.23097838f, 0.14508532f, 0.12376972f, 0.29420334f, -0.10430869f, 0.05855063f, -0.01511819f, -0.01130332f, 
    -0.12358671f, 0.09849074f, 0.04738554f, 0.10072400f, 0.04758072f, 0.00608249f, -0.07532679f, -0.08713771f, 
    -0.18004337f, -0.04647728f, -0.12202287f, -0.00914268f, -0.32548401f, -0.08706351f, -0.14343852f, -0.31288218f, 
    0.53852046f, -0.03340506f, 0.37686205f, 0.01333375f, -0.18052843f, -0.12507544f, 0.07265489f, 0.15577012f, 
    -0.01302836f, 0.23389556f, -0.07630708f, -0.10633765f, -0.02543395f, -0.05576717f, -0.04060721f, 0.06864694f, 
    0.00634318f, -0.09159514f, 0.15058543f, -0.02244731f, -0.23810160f, -0.05025082f, -0.18528031f, 0.10802924f, 
    -0.14715655f, 0.00542274f, -0.06160026f, -0.09621269f, 0.08907136f, -0.05812044f, -0.12064929f, 0.04472747f, 
    0.05820124f, -0.07423877f, 0.06240061f, 0.12950453f, -0.01587474f, -0.02643424f, -0.05023021f, -0.06556993f, 
    -0.30925578f, -0.03681049f, 0.10794307f, 0.07937200f, 0.20686655f, -0.06906625f, -0.03765768f, 0.10729129f, 
    0.04860417f, -0.16161364f, 0.10971108f, 0.07229547f, 0.00508927f, 0.00926520f, 0.16754927f, -0.06460056f, 
    -0.11190180f, 0.03192224f, 0.04470511f, 0.02527101f, -0.29046014f, -0.13778296f, -0.00452323f, 0.50373119f, 
    0.01206616f, 0.17213647f, 0.15242986f, 0.32564995f, 0.02332768f, 0.16040207f, -0.01139041f, 0.05630591f, 
    -0.18438284f, 0.00767012f, 0.01529210f, 0.07757511f, 0.08377447f, 0.03929417f, -0.12153334f, 0.09018502f, 
    0.41775662f, 0.00957496f, 0.05927461f, 0.06764013f, -0.07045473f, 0.02808524f, -0.01694420f, -0.08760750f, 
    -0.06749118f, 0.05512745f, 0.04995069f, -0.00533428f, 0.04148803f, -0.03271798f, -0.09418101f, -0.01776927f, 
    -0.01248838f, 0.00642757f, 0.11938371f, 0.07111811f, -0.48507893f, -0.00832295f, 0.05159253f, 0.12314647f, 
    0.12137546f, 0.10551896f, 0.01385519f, 0.07871544f, 0.04359973f, 0.02348125f, 0.03886422f, 0.03026635f, 
    0.01519083f, -0.04736160f, -0.02676973f, -0.05356809f, 0.06289672f, 0.17105334f, -0.08646142f, -0.10673946f, 
    0.22869644f, 0.27388179f, 0.25967187f, 0.15111893f, -0.41582698f, -0.10284942f, -0.06661026f, -0.03952370f, 
    0.09090656f, 0.16969658f, -0.04185661f, -0.06002332f, -0.02474114f, 0.01459677f, 0.12573865f, -0.05937049f, 
    -0.01392091f, -0.07163692f, 0.18687049f, 0.05661727f, -0.05901318f, 0.14270639f, -0.14181945f, 0.21202226f, 
    0.07270414f, -0.06681507f, 0.11962314f, 0.07186278f, -0.03311547f, 0.02724098f, 0.04338098f, 0.05340735f, 
    -0.03071795f, 0.01598339f, 0.07440393f, -0.07155441f, -0.04990311f, 0.08815224f, -0.04253464f, -0.00272094f, 
    -0.43558478f, 0.13925387f, -0.36742994f, 0.21369214f, -0.16205455f, -0.13534790f, -0.05597239f, -0.02825495f, 
    -0.13102649f, 0.06017441f, 0.05470352f, -0.08822820f, -0.02405264f, 0.08399834f, 0.07145757f, 0.01379693f, 
    -0.14397129f, 0.11067861f, -0.00530228f, -0.05745816f, 0.20683193f, -0.18313842f, 0.15404683f, 0.14477864f, 
    -0.13285464f, 0.09269164f, -0.02263857f, 0.11302298f, -0.08810467f, 0.01942639f, -0.07130296f, -0.03305711f, 
    -0.12170172f, -0.04174032f, 0.03310502f, 0.04388469f, -0.00299692f, 0.07693638f, 0.14550561f, 0.10610123f, 
    0.14834012f, 0.22813033f, -0.43293086f, 0.14460658f, 0.45472986f, -0.09148283f, 0.09072372f, 0.24244320f, 
    -0.03407746f, 0.09146395f, 0.09423699f, 0.04396419f, 0.02557420f, -0.15789956f, -0.02711616f, 0.01259827f, 
    -0.02713511f, 0.10880084f, -0.04840289f, -0.05620944f, 0.01885910f, -0.21395394f, 0.21810091f, 0.13293459f, 
    -0.20118533f, 0.15273567f, 0.03190481f, -0.00382335f, 0.09451558f, 0.05902959f, -0.01870413f, 0.05767694f, 
    0.03815024f, 0.09098416f, -0.03606240f, -0.12059896f, 0.12864710f, -0.06994667f, 0.00108336f, 0.21681605f, 
    0.46811864f, -0.02518073f, -0.02388406f, 0.40172493f, 0.38415343f, -0.07844611f, 0.04377636f, 0.32296485f, 
    0.02854257f, 0.12072901f, 0.06482040f, 0.07905842f, -0.03925102f, 0.01189066f, -0.12762183f, 0.10004344f, 
    0.08328950f, 0.02206539f, 0.03036470f, 0.00653938f, 0.03801243f, -0.07002492f, 0.35577813f, -0.16985323f, 
    0.15441744f, 0.15800004f, 0.14906201f, 0.31983590f, 0.10544827f, 0.21169361f, -0.02838688f, 0.02275510f, 
    -0.01387622f, -0.03409944f, -0.03064838f, -0.02203923f, 0.03425811f, 0.01376592f, 0.08832365f, 0.05253058f, 
    0.27005062f, -0.27679190f, 0.21208464f, -0.07377870f, 0.02283883f, 0.22084872f, -0.06921254f, -0.22597733f, 
    0.17984051f, 0.05682785f, -0.08176596f, 0.05416508f, -0.09154815f, 0.04782711f, 0.03145433f, -0.02335395f, 
    0.07573159f, 0.04743923f, 0.17313530f, 0.16365741f, -0.30600667f, -0.14611581f, 0.43903795f, -0.00330332f, 
    0.34626073f, -0.01888384f, -0.10343656f, 0.10437609f, 0.10355587f, 0.19882417f, -0.09286010f, 0.01622494f, 
    -0.02409576f, -0.03934147f, -0.08939385f, 0.08202392f, 0.01647344f, -0.04178832f, -0.04881163f, 0.04218508f, 
    0.10622945f, 0.03117749f, 0.19431484f, 0.05536048f, -0.08000186f, 0.04847050f, -0.13242184f, 0.19103944f, 
    -0.11838339f, -0.01920993f, 0.06249120f, -0.03708650f, -0.16683701f, 0.00611998f, 0.13598835f, -0.13680378f, 
    0.01907483f, 0.16235031f, 0.01009411f, 0.05244374f, 0.37329209f, 0.17876582f, -0.03296281f, -0.01855566f, 
    0.01743489f, 0.04364330f, 0.02530867f, -0.17566565f, 0.03611930f, 0.06039746f, 0.11818822f, 0.02118199f, 
    0.00771462f, -0.02249867f, -0.10814461f, 0.00675595f, -0.16859937f, -0.05098837f, 0.12658486f, 0.09228961f, 
    0.22363687f, 0.11067041f, -0.28738326f, 0.04923704f, 0.31746712f, -0.10667703f, -0.19372723f, 0.04383138f, 
    -0.14420168f, -0.00620891f, 0.13597108f, 0.14004476f, -0.03264503f, 0.02898216f, 0.12356254f, 0.11040757f, 
    0.13023195f, -0.01182934f, -0.00540553f, 0.17621623f, -0.00612441f, 0.18530250f, -0.24086097f, 0.08926497f, 
    0.19414978f, 0.00592493f, -0.16271426f, 0.34775737f, -0.12301145f, -0.08057742f, -0.13859203f, 0.03597683f, 
    0.08653371f, 0.01919509f, 0.04704933f, 0.10539681f, -0.11370198f, 0.18620963f, -0.01395394f, -0.15133494f, 
    0.12630528f, -0.07368563f, -0.17396432f, -0.04981551f, 0.01554585f, 0.09184563f, 0.02507325f, -0.18119304f, 
    0.10224840f, 0.14723837f, -0.17305364f, -0.05723302f, -0.18233329f, 0.15041187f, 0.02973618f, -0.16152778f, 
    -0.12919968f, 0.02410441f, 0.02883022f, 0.05846146f, -0.23710307f, -0.06625134f, 0.06043684f, -0.11079322f, 
    0.01499281f, 0.09400917f, -0.09847864f, -0.08422290f, 0.00779573f, -0.04506756f, 0.00917247f, -0.11370240f, 
    0.02796338f, 0.03381982f, 0.00965066f, -0.06614079f, -0.09580178f, 0.06757153f, -0.04986427f, -0.10056937f, 
    -0.10876518f, 0.03506165f, -0.02626993f, 0.07056187f, -0.19447628f, -0.06545736f, -0.07604928f, -0.01225400f, 
    -0.07907227f, 0.00467052f, -0.00632850f, 0.08127245f, -0.02308950f, 0.11963915f, -0.00972386f, -0.13981532f, 
    0.00676747f, 0.14010824f, 0.12803975f, 0.02836451f, -0.35869941f, -0.01543142f, -0.15640403f, 0.14004087f, 
    -0.20542514f, -0.12626024f, -0.00539335f, -0.06560436f, -0.03116171f, 0.04900162f, -0.01478549f, -0.02013049f, 
    0.09577172f, 0.01011423f, 0.06778049f, -0.02257311f, -0.06737134f, 0.04553996f, 0.04134926f, 0.00967958f, 
    -0.13253920f, -0.17004563f, -0.17430188f, -0.20168425f, 0.06290749f, -0.01291664f, 0.00526371f, -0.06507123f, 
    -0.13037439f, 0.10443341f, -0.14836872f, -0.03662460f, 0.00004529f, -0.01295323f, 0.12325447f, 0.18191695f, 
    0.23514606f, -0.08186292f, 0.03929840f, -0.00104258f, -0.08423609f, -0.29618022f, 0.05053629f, -0.09593203f, 
    0.01491566f, -0.03982911f, 0.15651113f, -0.12995438f, -0.17440978f, 0.01734790f, 0.04066640f, -0.09166566f, 
    -0.06743869f, 0.16246024f, 0.19307795f, -0.04558370f, -0.12851277f, -0.11854092f, 0.05015711f, 0.13274227f, 
    0.19750015f, 0.22266817f, -0.03212590f, -0.09473325f, -0.14829035f, -0.06658407f, -0.05669567f, -0.00537892f, 
    -0.06399122f, -0.08218773f, -0.03236482f, 0.00615555f, 0.05489371f, 0.10870571f, -0.03820251f, -0.18805459f, 
    -0.02280828f, 0.18761995f, 0.05091892f, -0.00192356f, -0.17868727f, -0.08640315f, -0.15741207f, -0.05673995f, 
    -0.30016243f, 0.00029532f, 0.01992384f, -0.00445313f, 0.12195143f, -0.04541590f, -0.06882601f, -0.13848871f, 
    -0.01925631f, -0.09057085f, 0.03183419f, 0.02874737f, -0.01824122f, -0.00626883f, -0.09708820f, -0.09328143f, 
    0.05512204f, 0.02329775f, -0.28428033f, 0.12859619f, 0.03528481f, -0.11278556f, 0.04803571f, 0.13233738f, 
    -0.14134678f, -0.03155369f, 0.07738017f, -0.00635553f, -0.03636413f, -0.14194509f, 0.10763291f, -0.09423729f, 
    -0.00262088f, 0.16567256f, -0.03075702f, -0.07186721f, -0.12114157f, 0.10585832f, -0.17203730f, 0.15927610f, 
    -0.12210809f, -0.05547108f, 0.01039216f, -0.09789148f, -0.02615991f, 0.08043741f, 0.01957787f, -0.12850590f, 
    0.08653062f, -0.01152033f, 0.02678003f, 0.14488664f, 0.01936988f, 0.03783607f, -0.00636763f, 0.01233521f, 
    -0.36818886f, 0.05068728f, -0.10489959f, -0.20850097f, -0.16976772f, -0.04458650f, -0.07034734f, -0.01882907f, 
    -0.05219154f, 0.08450188f, -0.25097308f, -0.06406011f, 0.00872508f, 0.09883355f, 0.11750337f, -0.17589642f, 
    0.09721545f, 0.19980857f, -0.00584698f, -0.04717235f, -0.61725408f, -0.00571880f, -0.13155974f, 0.05007945f, 
    -0.01634165f, 0.00103995f, 0.02909991f, 0.02728017f, 0.09217737f, -0.10631836f, 0.02763835f, -0.14734216f, 
    0.01769497f, -0.14292017f, -0.09429973f, 0.08542893f, 0.00068297f, 0.13902025f, -0.08420130f, 0.05405510f, 
    0.25359413f, -0.20728259f, -0.01727375f, 0.31824318f, -0.22675245f, 0.26740605f, -0.12513104f, 0.03837431f, 
    0.23832047f, -0.00367603f, -0.04449476f, 0.00296995f, -0.18346305f, 0.10108631f, -0.07809315f, 0.10093866f, 
    0.13658711f, -0.09254637f, 0.06012991f, 0.26547623f, -0.09159775f, -0.11549950f, -0.06901567f, 0.05681453f, 
    -0.06520100f, -0.08430573f, -0.02041688f, -0.19846267f, -0.07486500f, 0.13306238f, -0.19801836f, -0.08325941f, 
    -0.03455054f, -0.03455959f, 0.07060654f, 0.12502433f, -0.02444829f, -0.04241213f, -0.14687945f, 0.04658915f, 
    -0.03361021f, -0.14148295f, -0.00809869f, 0.29649448f, -0.03963432f, -0.18411912f, 0.00321726f, -0.00940403f, 
    0.07575285f, -0.07410935f, 0.08726320f, 0.09096561f, -0.00647385f, -0.11916777f, 0.13193548f, -0.10869005f, 
    -0.13458630f, 0.14936922f, 0.29164147f, 0.16582893f, -0.32936960f, -0.18624967f, 0.18101335f, 0.38334408f, 
    -0.00657545f, 0.05003243f, 0.10529772f, 0.08977305f, 0.03835243f, 0.08247380f, -0.07610208f, 0.11737493f, 
    -0.08453546f, 0.01846341f, 0.04425442f, -0.04205608f, 0.03430232f, -0.03586530f, -0.01399268f, 0.19473453f, 
    0.10496359f, 0.20584938f, 0.28819108f, 0.12899308f, 0.09400595f, -0.09127580f, -0.04259656f, -0.00125643f, 
    0.18527900f, 0.13246714f, 0.10453624f, 0.00195255f, -0.02061916f, -0.18459243f, -0.04826541f, -0.05928670f, 
    -0.01104586f, -0.02151080f, 0.00150182f, 0.04479353f, -0.28296912f, -0.05651366f, 0.24039981f, 0.29432362f, 
    0.29603586f, 0.14059635f, 0.08562943f, -0.03070685f, 0.00098222f, 0.03133920f, 0.01761757f, -0.08732040f, 
    -0.10858145f, -0.09580985f, 0.03751407f, 0.03305363f, 0.08644880f, 0.17614858f, -0.07021815f, 0.07798296f, 
    0.04824634f, -0.23946899f, 0.02230104f, 0.25323766f, -0.07705592f, -0.02289622f, -0.02359922f, 0.09912895f, 
    0.01329021f, -0.06501544f, 0.02933523f, -0.08694344f, 0.00100919f, 0.09315827f, 0.10751133f, 0.01189841f, 
    0.19277601f, 0.01217377f, 0.12189390f, 0.27355465f, 0.13492905f, 0.36492011f, -0.00428138f, 0.26828554f, 
    0.10891683f, 0.13373446f, 0.04464448f, -0.10865662f, -0.02736454f, 0.00298116f, 0.00328122f, -0.00940028f, 
    -0.13817079f, -0.11623105f, 0.00413653f, 0.00088128f, -0.01036321f, 0.13449183f, -0.18292038f, 0.07144716f, 
    -0.05693885f, -0.25141785f, -0.12964155f, 0.05734252f, 0.19967856f, 0.02220851f, 0.06448649f, -0.14762060f, 
    0.06815509f, 0.20121226f, -0.11101511f, -0.06285792f, -0.02294017f, -0.07959669f, 0.04660618f, 0.06724460f, 
    -0.09149995f, 0.08412600f, -0.07979457f, 0.10082826f, 0.19145764f, -0.01733151f, 0.15964186f, 0.22461753f, 
    0.09789322f, 0.01130189f, 0.03847259f, 0.00742481f, -0.12032674f, -0.01901050f, -0.07397540f, 0.03473757f, 
    0.01297498f, -0.04617956f, 0.00804941f, 0.00010085f, -0.00078632f, -0.02896777f, 0.09015074f, 0.05613583f, 
    0.31188390f, 0.08834794f, -0.28613672f, 0.07885733f, 0.17172551f, -0.00883645f, 0.25786883f, -0.03188199f, 
    -0.05125693f, 0.04732684f, 0.01683400f, 0.12122779f, 0.04627127f, -0.08735406f, -0.02658971f, 0.04850814f, 
    -0.04265684f, 0.11752689f, -0.01433310f, 0.00619451f, 0.07191782f, 0.16662981f, 0.08397675f, 0.22676791f, 
    0.00490729f, 0.03081655f, -0.01515604f, 0.04665336f, 0.08482345f, 0.20021676f, 0.13921614f, -0.06041263f, 
    0.04957984f, 0.25270292f, 0.00958604f, 0.14877100f, 0.11401305f, -0.03302553f, 0.04644924f, 0.15279964f, 
    0.19625087f, 0.08862758f, 0.03712761f, 0.13323863f, -0.03266093f, -0.03852329f, 0.05790979f, 0.20339301f, 
    0.22543538f, -0.07184918f, 0.09291627f, 0.05702513f, 0.09936040f, 0.06462342f, -0.11265372f, 0.21800576f, 
    0.11585499f, -0.01747628f, 0.08736257f, 0.23134795f, 0.11476996f, 0.10135964f, 0.37011591f, 0.07900557f, 
    -0.00728461f, -0.03932476f, 0.15129849f, 0.09978499f, -0.12668909f, -0.18810390f, -0.03352160f, 0.03528021f, 
    -0.04482273f, -0.05348409f, -0.02029626f, -0.01027122f, 0.07255211f, -0.14967376f, 0.16248843f, -0.10187960f, 
    0.30010948f, 0.05533438f, 0.36231872f, 0.13386019f, 0.12620777f, 0.01026592f, -0.00673991f, -0.08243728f, 
    0.19975661f, 0.17060506f, 0.03005440f, 0.01817220f, -0.06969141f, -0.08896375f, -0.10252080f, -0.02936043f, 
    0.17980021f, -0.00101033f, -0.00180718f, 0.05970286f, -0.14833979f, 0.03024994f, 0.28262365f, 0.02713048f, 
    0.09708345f, 0.07408393f, 0.18710926f, -0.03374156f, 0.09110647f, -0.02098512f, -0.12406000f, -0.02907877f, 
    0.06344017f, -0.04344958f, -0.00065148f, 0.02310360f, 0.05013015f, -0.09606493f, 0.14195935f, 0.00141707f, 
    0.00220606f, -0.19863170f, 0.10511345f, 0.00221865f, -0.05248012f, 0.21793966f, -0.11708850f, 0.12070113f, 
    0.07714906f, 0.04537480f, 0.05057613f, -0.06053369f, -0.17466457f, 0.13031584f, 0.27046812f, -0.03288214f, 
    0.21880804f, 0.13232605f, -0.01407986f, 0.06452207f, 0.46961868f, -0.38462752f, 0.15813434f, 0.43758678f, 
    -0.09535267f, -0.00813693f, -0.11025205f, 0.08037637f, 0.00761384f, 0.54958230f, 0.07179967f, 0.11063219f, 
    0.05525469f, -0.01498065f, -0.05684536f, 0.04080315f, -0.16635665f, -0.04370778f, 0.02322340f, 0.14499034f, 
    0.45483828f, -0.20269661f, -0.07542602f, 0.19008082f, 0.14192249f, -0.07667640f, 0.08553148f, -0.10347236f, 
    -0.04303421f, -0.00718893f, 0.06019280f, -0.04735972f, -0.03759331f, 0.07709730f, 0.12378190f, 0.07887358f, 
    0.15032320f, -0.05631088f, -0.09549736f, 0.14628795f, 0.44247550f, -0.07942471f, -0.17026496f, 0.06630155f, 
    0.25578663f, 0.13209428f, -0.06178399f, 0.17835855f, -0.03119849f, -0.03733120f, -0.02311088f, -0.03381050f, 
    0.17751788f, 0.03056500f, 0.08778396f, 0.13746020f, -0.15381098f, 0.13418496f, -0.16231844f, -0.07401095f, 
    -0.02734592f, -0.08347712f, 0.18944737f, 0.07983644f, 0.05704218f, -0.00258929f, 0.01408353f, 0.03961780f, 
    0.15493122f, 0.19184865f, -0.00060834f, -0.01653394f, -0.02958455f, 0.04633401f, -0.06300417f, -0.06427213f, 
    -0.08595062f, -0.08405256f, 0.11240518f, 0.12540080f, -0.24315006f, -0.07756692f, 0.21644625f, -0.22844256f, 
    -0.04888126f, 0.17111911f, -0.04670161f, -0.09125482f, -0.11274285f, 0.04184096f, -0.06456930f, -0.21734209f, 
    -0.04810779f, -0.00752530f, -0.02929015f, 0.04092109f, -0.08054717f, 0.07940613f, -0.03212096f, -0.00872520f, 
    -0.00850446f, -0.00744531f, -0.06663553f, -0.20986988f, -0.13090384f, -0.01378979f, -0.10249705f, 0.01268023f, 
    -0.05459973f, 0.14509805f, -0.03846395f, 0.02295073f, -0.17116600f, 0.12461259f, 0.09738644f, -0.03378488f, 
    0.07505389f, 0.14246486f, 0.14133088f, 0.02825442f, -0.15266979f, -0.18295641f, 0.03110770f, -0.17576320f, 
    -0.06608096f, -0.10996943f, -0.00444363f, -0.17838733f, -0.05556225f, 0.13216622f, -0.15921639f, -0.16733691f, 
    -0.11337736f, -0.11849568f, -0.07549941f, -0.04244614f, -0.06949963f, -0.00238643f, -0.07917485f, 0.08593598f, 
    -0.14593531f, -0.28097796f, 0.13245392f, 0.00720668f, -0.05889930f, -0.05419460f, -0.00070868f, -0.01986054f, 
    -0.18678828f, -0.14614293f, -0.16115874f, -0.02754525f, 0.11838765f, 0.05511940f, 0.07615221f, 0.22838992f, 
    0.26852769f, -0.04766074f, 0.02597232f, -0.07009061f, -0.07103255f, -0.17336099f, 0.24043132f, 0.41312167f, 
    -0.07173494f, 0.01867615f, 0.06474286f, 0.04834571f, -0.10189831f, 0.14530340f, -0.02937465f, 0.03193355f, 
    -0.05503508f, 0.13434716f, 0.05414525f, 0.07061941f, 0.01714889f, 0.01730557f, 0.01076309f, 0.05503467f, 
    -0.10087444f, -0.13162166f, 0.18194079f, -0.25426385f, -0.03156079f, -0.08226457f, -0.11286045f, 0.01504486f, 
    -0.09899840f, 0.10887316f, 0.11803460f, 0.14053272f, -0.01855105f, 0.13174991f, 0.02125209f, -0.10881002f, 
    -0.01805649f, 0.28994924f, -0.14852719f, -0.05611220f, -0.09308836f, -0.09434541f, -0.04475697f, -0.20735563f, 
    -0.12189789f, 0.00103531f, 0.01593943f, -0.08863805f, 0.02914979f, 0.05836298f, -0.11917777f, -0.18822473f, 
    -0.00218275f, -0.11476532f, 0.01971385f, -0.01376655f, -0.08370327f, -0.18495215f, -0.06754355f, -0.01256338f, 
    0.29486635f, 0.07495181f, -0.32837459f, 0.16646761f, -0.03866789f, 0.09019823f, 0.04762271f, 0.01860173f, 
    0.04884206f, 0.14201246f, 0.02944207f, 0.01781496f, 0.01813212f, 0.04642286f, 0.07978711f, 0.04353872f, 
    0.07909113f, 0.09814907f, 0.00436130f, 0.04183861f, -0.05023190f, -0.03991269f, -0.16748607f, 0.02707307f, 
    -0.07814471f, -0.10262196f, 0.04528735f, -0.12324257f, -0.03784542f, 0.08622024f, -0.01236701f, -0.06725019f, 
    0.07118573f, 0.03009279f, 0.19159377f, 0.22505423f, 0.02419337f, -0.07765297f, 0.00059359f, 0.01211053f, 
    -0.35743880f, -0.17673120f, 0.12787773f, 0.11511632f, 0.04888249f, -0.01136929f, 0.00455881f, 0.08676373f, 
    -0.10710156f, -0.03328722f, -0.15552299f, 0.11631733f, 0.13168268f, 0.01491691f, 0.00544692f, -0.08149703f, 
    0.06777653f, 0.16204467f, -0.04923913f, -0.09199923f, -0.18092582f, -0.17781539f, -0.04551020f, 0.03735988f, 
    0.24467035f, 0.03995084f, 0.03109309f, -0.23628095f, 0.00427700f, -0.04177655f, -0.08763456f, -0.05104900f, 
    0.03339551f, -0.18040822f, 0.07807290f, 0.07922280f, -0.00908170f, 0.00646016f, -0.10343067f, -0.00714651f, 
    0.75226575f, -0.30350092f, 0.04490950f, 0.04038829f, 0.17782177f, 0.06947617f, 0.12159386f, 0.10729913f, 
    -0.20127980f, 0.18263535f, 0.03366344f, 0.20416418f, 0.08948770f, -0.03004747f, -0.05449220f, 0.09503833f, 
    0.06745251f, -0.02569074f, 0.07371898f, 0.04094421f, 0.22712795f, -0.05651503f, 0.30563045f, 0.02960878f, 
    -0.26711476f, 0.01981585f, 0.23086146f, -0.13710533f, -0.01963573f, -0.27287501f, 0.01326481f, 0.03016461f, 
    -0.01637943f, -0.00407079f, -0.05571575f, 0.07162648f, -0.05629741f, -0.07892276f, -0.08697262f, -0.09380746f, 
    -0.68938792f, 0.08701295f, -0.04315091f, 0.37380594f, -0.18293114f, 0.05830215f, 0.12581217f, 0.14905901f, 
    0.14437106f, -0.19620517f, -0.20052966f, 0.02106897f, -0.02126350f, -0.00064238f, 0.07360780f, -0.03841630f, 
    0.01183575f, 0.08625179f, 0.03015170f, 0.12336224f, -0.18490864f, -0.20879821f, 0.31384990f, 0.42073625f, 
    0.29691985f, 0.03099552f, -0.06743893f, 0.00816601f, 0.14536978f, 0.09985805f, -0.07769091f, 0.02512794f, 
    -0.00768286f, -0.00169167f, 0.05766344f, 0.00555295f, -0.08875619f, -0.16554096f, 0.09347146f, 0.00931851f, 
    0.32754359f, -0.23144172f, -0.11907721f, 0.05392285f, 0.07720881f, -0.03813214f, -0.03049831f, -0.09865934f, 
    -0.06957817f, -0.04498298f, 0.07068190f, 0.02211429f, 0.05309559f, -0.01593753f, 0.07748134f, 0.10390859f, 
    -0.01142893f, -0.06682922f, -0.06026824f, -0.12904935f, 0.10741336f, 0.13961177f, 0.05345435f, -0.03115179f, 
    -0.06951284f, -0.12633660f, -0.12508671f, 0.06678765f, 0.18037090f, -0.13093421f, 0.07836671f, 0.04559521f, 
    0.00646316f, -0.04644681f, -0.03404772f, -0.04622023f, 0.00067322f, 0.03433516f, 0.18633270f, 0.13764542f, 
    0.33206865f, -0.15684861f, -0.06748483f, 0.08792157f, 0.23038967f, 0.05938641f, 0.24587831f, 0.09571131f, 
    -0.51468599f, 0.15904836f, -0.03205037f, 0.04103120f, 0.14858681f, 0.05467929f, 0.00035066f, -0.14755176f, 
    0.03532117f, 0.01555154f, -0.02321431f, 0.01073366f, 0.39288461f, -0.19687895f, 0.05083703f, -0.09832031f, 
    -0.07586770f, -0.08616111f, -0.00916942f, -0.00337752f, -0.01230974f, -0.05237220f, 0.11614481f, 0.00951421f, 
    -0.03010524f, -0.06794316f, 0.01754451f, 0.01478151f, 0.12165967f, 0.06917508f, 0.05999872f, 0.19206376f, 
    0.42311585f, 0.06013401f, 0.03990423f, -0.38433394f, -0.00774397f, -0.06078526f, 0.09575880f, -0.14618991f, 
    -0.10358125f, -0.14261077f, 0.16732137f, -0.03769829f, 0.03260306f, 0.00704775f, 0.03187118f, -0.12080008f, 
    0.00044239f, 0.01592703f, 0.07544839f, -0.03679147f, -0.02966966f, -0.35412651f, -0.05500712f, 0.02838263f, 
    0.21015263f, 0.15171796f, 0.06922550f, -0.10944884f, 0.04203340f, -0.00713502f, 0.07495208f, 0.12207435f, 
    0.00812140f, 0.02208036f, 0.03801394f, 0.09764580f, -0.15473370f, 0.02362681f, -0.22806646f, -0.16390973f, 
    -0.16576771f, -0.02341463f, 0.44845188f, 0.12246782f, 0.19452702f, -0.04308447f, -0.04733809f, 0.03994038f, 
    0.10222688f, 0.05905233f, -0.02391904f, 0.01927373f, 0.04195891f, -0.00592858f, 0.00239503f, 0.00290252f, 
    -0.07627731f, 0.02634047f, -0.03064895f, 0.20380805f, 0.03376953f, 0.01319178f, 0.19538085f, 0.17214908f, 
    -0.20995396f, -0.20985456f, -0.06546935f, 0.05139765f, 0.09828399f, 0.03880275f, -0.07805490f, -0.00375049f, 
    -0.04050889f, -0.10325441f, -0.19161260f, -0.03243402f, 0.03072345f, -0.06938638f, 0.09574351f, 0.02247807f, 
    0.13356216f, -0.23365773f, -0.11561881f, 0.35018447f, 0.47180912f, 0.04502964f, 0.08780153f, 0.06197273f, 
    0.25638410f, 0.18574879f, 0.00621404f, -0.01493520f, 0.00656964f, -0.04743433f, -0.00126451f, 0.09621027f, 
    0.13937803f, -0.10339155f, 0.11434892f, 0.02069544f, -0.07453179f, -0.08467191f, 0.18120481f, 0.27285433f, 
    0.38261852f, -0.05660307f, 0.02567293f, -0.05050964f, 0.15677300f, 0.29548922f, 0.13870284f, 0.16093452f, 
    0.00901045f, 0.02152134f, 0.05211382f, 0.12489816f, -0.02374039f, 0.01828750f, -0.07991083f, -0.10657493f, 
    0.19611877f, -0.29222089f, 0.08051631f, -0.00078565f, 0.32571641f, -0.01182954f, -0.02643970f, -0.24689507f, 
    -0.01045114f, -0.01746174f, 0.13785028f, 0.16724324f, 0.08239149f, 0.02246911f, 0.09180731f, 0.03291847f, 
    -0.08066619f, 0.01347109f, -0.04378361f, -0.02984264f, -0.37345737f, -0.25830218f, 0.28653345f, 0.31311554f, 
    0.32754910f, -0.01869077f, -0.09721228f, 0.12532620f, 0.16730587f, 0.01444056f, -0.07631665f, 0.00818724f, 
    0.18086480f, 0.03799118f, 0.05289855f, 0.03988721f, -0.01696097f, -0.10463580f, -0.02824602f, -0.26763964f, 
    0.03282767f, 0.11799111f, 0.09314737f, -0.00769895f, -0.24200508f, 0.03433178f, 0.13760266f, 0.01682877f, 
    0.06245978f, 0.00410447f, 0.12535715f, -0.04038718f, 0.01745368f, -0.02070449f, 0.00255474f, 0.03101440f, 
    0.01336791f, -0.01352084f, -0.06659541f, 0.00705509f, 0.33270910f, 0.13457616f, -0.01303360f, 0.09357510f, 
    -0.06630451f, 0.01010283f, 0.01779093f, -0.00732572f, 0.02627135f, 0.03418882f, -0.11902669f, -0.03758543f, 
    -0.10911949f, -0.01011368f, 0.09598489f, -0.05341358f, -0.12703559f, 0.04566682f, -0.02024634f, -0.12169702f, 
    -0.09101386f, -0.09238522f, 0.29874024f, 0.22698455f, -0.13041574f, -0.14884795f, 0.04133180f, 0.09069891f, 
    0.03613859f, -0.28911868f, -0.00903515f, -0.14387420f, -0.01140569f, 0.00853754f, -0.13064851f, -0.09215920f, 
    -0.15659679f, -0.05190254f, -0.07521739f, -0.06421866f, 0.15319231f, -0.01195550f, -0.03551512f, 0.06050164f, 
    -0.03195617f, 0.10675815f, -0.00367049f, 0.17106219f, 0.02373549f, -0.07637041f, -0.06086294f, -0.15624626f, 
    0.16081768f, 0.00824344f, 0.09441891f, -0.01437846f, -0.08932116f, -0.05939696f, -0.32408792f, 0.14912920f, 
    0.11492115f, -0.15277119f, 0.05584685f, 0.06173356f, 0.16366179f, -0.06923074f, 0.03644740f, -0.19171678f, 
    0.04603764f, -0.11438470f, 0.02974615f, 0.06797320f, 0.05850635f, 0.03285503f, 0.09079637f, -0.08077700f, 
    0.08811206f, -0.03486426f, 0.00045031f, 0.00729677f, 0.03211538f, 0.19892058f, 0.06767085f, -0.05797459f, 
    -0.15356202f, -0.01979811f, -0.10687245f, -0.07096563f, 0.03928828f, -0.05371729f, -0.00392362f, -0.04856344f, 
    0.06406670f, -0.05841917f, 0.08872760f, 0.17981052f, 0.07651792f, 0.06316125f, 0.12256495f, 0.06226136f, 
    0.07493556f, 0.04690556f, -0.16810787f, -0.09688337f, -0.25811651f, 0.05993069f, 0.06107410f, 0.08789559f, 
    -0.01701126f, 0.00053086f, -0.07378495f, -0.13704661f, -0.07152972f, -0.07553175f, 0.00259035f, 0.00387418f, 
    0.01190782f, -0.07832737f, -0.06647380f, -0.04055289f, 0.30360922f, -0.09159707f, 0.06541602f, -0.07029315f, 
    -0.15246387f, -0.05120769f, 0.01623868f, -0.17165302f, 0.04913474f, -0.12721814f, 0.16044445f, 0.04921886f, 
    0.09997470f, -0.07752822f, -0.01846863f, 0.05621975f, 0.08029870f, 0.14473520f, -0.02827295f, 0.07412054f, 
    -0.34469631f, -0.17699027f, 0.00604968f, 0.20789811f, 0.30119783f, -0.16021959f, 0.07282599f, -0.00510439f, 
    0.05747280f, 0.11525081f, -0.02476248f, 0.15126212f, 0.09142688f, 0.09401913f, 0.07179642f, 0.06589631f, 
    0.19604267f, 0.16010456f, 0.02971004f, 0.07591604f, -0.04209202f, -0.12676688f, 0.13548870f, 0.38885280f, 
    0.12301920f, -0.00377738f, -0.07460859f, -0.14411582f, -0.02449239f, -0.08901017f, -0.10279836f, 0.06290988f, 
    -0.05060544f, 0.08731263f, 0.01914222f, 0.01091487f, 0.08280252f, 0.05729379f, 0.11481208f, -0.13238916f, 
    0.02908695f, 0.13034159f, -0.16800021f, -0.20672162f, -0.19960263f, 0.24020483f, 0.04427335f, 0.19979282f, 
    0.03187094f, 0.13300136f, -0.14312544f, -0.16165707f, -0.08997753f, -0.07769633f, -0.08489701f, -0.06442926f, 
    -0.11371256f, -0.15887484f, -0.00803536f, 0.15331236f, 0.10146074f, 0.10112656f, 0.21354923f, -0.11560996f, 
    -0.30442289f, 0.01917064f, 0.18512198f, -0.07232438f, -0.11312261f, -0.05910263f, 0.04042265f, 0.08996088f, 
    0.06505261f, -0.12947387f, 0.02007816f, 0.11104007f, 0.12479091f, -0.02541032f, 0.04015567f, -0.14917362f, 
    0.18798737f, 0.06743336f, 0.22144492f, -0.09926675f, -0.22761655f, -0.11634750f, 0.05501371f, 0.01537832f, 
    0.03566614f, -0.12440332f, 0.03958132f, 0.02132819f, -0.00402304f, -0.00485056f, 0.00639540f, -0.01706080f, 
    -0.09028254f, -0.00050801f, -0.07468115f, -0.07089089f, 0.04428022f, -0.01882290f, -0.05767928f, -0.04583582f, 
    -0.13612632f, -0.01458240f, 0.13764358f, -0.01326503f, 0.02067183f, -0.06589768f, 0.09960609f, 0.03047515f, 
    -0.01897122f, 0.03961893f, -0.03991791f, 0.09720109f, 0.02139925f, 0.11648867f, -0.20674370f, -0.19809917f, 
    -0.15469462f, -0.10689157f, 0.12597141f, 0.26605743f, 0.27824473f, 0.09594072f, 0.02038260f, -0.00634187f, 
    -0.13811211f, 0.08767408f, -0.06467597f, 0.09317705f, 0.05176363f, 0.14335400f, 0.08314490f, -0.03944394f, 
    0.10450797f, 0.12778051f, -0.01824666f, 0.14482264f, 0.04648579f, 0.25304574f, 0.28412032f, -0.25513941f, 
    -0.06139546f, -0.01381521f, 0.09893544f, 0.10720506f, -0.00464712f, 0.12794052f, 0.04736786f, 0.04495703f, 
    0.06152897f, 0.00997215f, 0.08934997f, -0.09549120f, -0.22814441f, -0.00680949f, -0.01129065f, -0.07368529f, 
    -0.37844169f, -0.30083537f, -0.45704526f, 0.57696700f, 0.05359956f, 0.24306743f, -0.15586816f, -0.07456969f, 
    0.13199869f, -0.05828952f, 0.04865758f, 0.07468133f, -0.09791274f, -0.00808940f, -0.00098732f, 0.12794486f, 
    0.04425321f, 0.03905544f, -0.15938915f, 0.08897848f, -0.17320831f, -0.20230038f, 0.03061178f, -0.09133140f, 
    0.01862738f, -0.19918711f, 0.13921796f, 0.15303977f, -0.02314296f, -0.05622115f, -0.02020540f, -0.02168463f, 
    -0.01080104f, 0.10085206f, 0.06636671f, -0.01751781f, -0.03006223f, -0.10568169f, 0.07066989f, -0.00441795f, 
    0.29044014f, -0.20857374f, -0.28915176f, 0.15002277f, -0.07228196f, -0.10921114f, 0.01377305f, -0.15415592f, 
    0.04204297f, -0.11020689f, -0.15821195f, -0.06158725f, 0.04669624f, 0.05482833f, -0.20374918f, 0.10095782f, 
    0.07747974f, -0.04390871f, 0.19242533f, 0.21780686f, -0.22557668f, 0.27264935f, -0.10048542f, -0.17089482f, 
    -0.02270477f, -0.03301428f, -0.01941180f, -0.08266407f, 0.23658855f, 0.16585128f, -0.05410131f, -0.11292906f, 
    0.05995487f, 0.06413632f, 0.03068397f, 0.06591374f, -0.13171569f, -0.07411111f, 0.17802583f, 0.00938700f, 
    -0.15262473f, 0.18077917f, 0.37905583f, 0.21360993f, -0.01561858f, -0.10355160f, -0.07608303f, -0.07067498f, 
    0.12128977f, -0.00118361f, 0.03025050f, -0.01169425f, 0.09290630f, 0.07863802f, 0.04922858f, -0.03879958f, 
    -0.03913191f, 0.06699431f, -0.06430474f, -0.10537723f, 0.24730308f, -0.01893233f, 0.03567909f, -0.15243068f, 
    0.05487978f, 0.03247120f, 0.11847513f, -0.12369312f, 0.06981880f, 0.07056373f, -0.02324866f, -0.06730149f, 
    0.03246718f, -0.06586412f, -0.04531050f, 0.10768086f, -0.02404995f, -0.01112795f, 0.08955751f, 0.10634166f, 
    -0.39637223f, -0.30036327f, -0.10795894f, 0.25506246f, 0.28559071f, 0.11339609f, 0.06309796f, 0.12600224f, 
    -0.04725164f, 0.01298784f, 0.07450298f, -0.01907724f, -0.07394290f, -0.17961872f, -0.07132989f, 0.07026359f, 
    -0.08727062f, 0.20575967f, -0.16160354f, 0.11824686f, -0.04889065f, 0.01269190f, -0.38054141f, -0.00420671f, 
    0.13012680f, 0.05014917f, -0.10718423f, -0.04494759f, -0.02829599f, 0.02488403f, -0.02099466f, 0.02369904f, 
    -0.04414794f, -0.03799796f, -0.00352329f, 0.13192338f, 0.06196663f, 0.09300838f, 0.14515495f, 0.10193988f, 
    -0.07219007f, -0.17405786f, 0.07560880f, -0.14489742f, 0.20180483f, 0.19887413f, 0.02946820f, -0.06392757f, 
    -0.01342204f, 0.00985920f, -0.04641259f, -0.01092519f, 0.02026716f, -0.08587267f, -0.05152218f, 0.02906109f, 
    0.23020282f, 0.02938562f, 0.02507497f, 0.02516490f, -0.35998222f, 0.20676364f, 0.05946758f, 0.06405348f, 
    0.08520251f, -0.10101259f, -0.00985086f, 0.13401198f, 0.06833332f, 0.02881786f, -0.02936059f, -0.00000876f, 
    0.12135019f, -0.04022347f, -0.07438082f, -0.03686420f, -0.10854310f, -0.03804926f, -0.14805473f, 0.00098543f, 
    -0.04059228f, -0.08286424f, -0.05167348f, 0.01064724f, -0.49323919f, 0.07900377f, 0.05011580f, -0.03636393f, 
    0.02640314f, 0.16971540f, -0.13833936f, 0.00403537f, -0.00726429f, 0.05641778f, 0.10979468f, 0.01281833f, 
    0.03808603f, -0.05278984f, 0.15553731f, -0.00222636f, -0.22530916f, 0.16346648f, -0.09596437f, 0.25773028f, 
    0.28013733f, -0.18878402f, -0.05626671f, 0.06767317f, 0.07067780f, 0.09845638f, 0.00610566f, -0.03743672f, 
    -0.06057889f, 0.13493337f, 0.22428715f, 0.28487393f, 0.00289188f, 0.01796194f, -0.09757669f, 0.08076085f, 
    -0.28529260f, 0.16072437f, 0.01531347f, -0.04362697f, -0.24921410f, 0.16524582f, -0.04596331f, -0.05448074f, 
    0.00797634f, 0.21715787f, -0.06289498f, 0.09261265f, 0.05524656f, 0.01627759f, 0.06185320f, -0.02414898f, 
    -0.06092007f, -0.05550841f, -0.02352643f, 0.29717898f, -0.07182381f, 0.22938985f, 0.20022707f, 0.29818738f, 
    -0.03277590f, -0.19137657f, -0.14661168f, -0.25200400f, 0.04302705f, 0.03069481f, -0.06357084f, 0.04379507f, 
    -0.02418936f, -0.00763261f, 0.03090457f, 0.00882515f, -0.00303120f, -0.16021872f, -0.16413878f, -0.16456868f, 
    -0.11608113f, 0.39015031f, 0.31075507f, 0.30938545f, -0.03389076f, -0.16009229f, -0.03259327f, 0.04031226f, 
    -0.05668866f, 0.07977333f, 0.14405672f, -0.08812177f, 0.10243098f, 0.03006346f, -0.06030551f, -0.09920204f, 
    0.01354798f, -0.04013931f, -0.17634602f, -0.06564533f, 0.29913193f, 0.33637801f, 0.03127730f, -0.00372923f, 
    -0.38177991f, -0.00310376f, 0.09708320f, 0.01835429f, 0.23126791f, -0.01909744f, -0.01040707f, -0.05159439f, 
    0.06784519f, 0.03740398f, 0.12135217f, -0.17596616f, -0.02566163f, -0.18590902f, 0.20935525f, 0.12373039f, 
    -0.04103877f, -0.27403879f, 0.00184554f, 0.08588595f, 0.00281245f, -0.12482126f, 0.01949181f, 0.00590395f, 
    0.00862851f, -0.01803631f, -0.00968073f, 0.04105972f, 0.04538724f, 0.24416833f, -0.00634979f, 0.13037053f, 
    0.12576200f, -0.08254746f, -0.12897734f, -0.16059612f, 0.04456647f, 0.08499181f, 0.33875531f, 0.39013153f, 
    0.03541666f, -0.25610173f, -0.17489073f, 0.16086838f, -0.10143654f, 0.09350128f, -0.00630782f, 0.06487275f, 
    0.07050809f, -0.02997739f, 0.07160047f, -0.06938870f, -0.01041896f, 0.04546278f, -0.08942682f, -0.02734072f, 
    -0.30041131f, -0.11941060f, 0.12675224f, 0.00628822f, -0.43245685f, -0.04181277f, -0.01130286f, 0.22608186f, 
    0.02828555f, 0.02592106f, -0.06742410f, -0.06051756f, 0.03175417f, 0.17848524f, 0.01099236f, -0.02927539f, 
    -0.06598588f, -0.06582569f, 0.04061001f, -0.08055423f, -0.11137595f, -0.36575484f, 0.22500181f, -0.12262351f, 
    -0.08179803f, 0.09846601f, 0.11944246f, -0.05766319f, 0.17247237f, 0.06010505f, 0.17060003f, 0.04672563f, 
    -0.04958054f, 0.12439729f, 0.08272450f, -0.01283647f, 0.02907796f, -0.11771383f, -0.07330526f, 0.13588931f, 
    -0.07376263f, 0.25327349f, 0.48189345f, 0.36783233f, -0.05451386f, -0.09142206f, 0.02542479f, 0.15802971f, 
    0.01826963f, 0.02614450f, 0.14594150f, -0.05418117f, 0.09775081f, -0.21332769f, 0.00871509f, 0.14746805f, 
    0.08301713f, 0.07996233f, -0.03352856f, 0.04070209f, 0.13859339f, -0.24993506f, 0.01677171f, -0.17250329f, 
    -0.04904238f, -0.10520198f, 0.09312335f, 0.04174330f, -0.01585270f, 0.03614260f, -0.02472316f, 0.12914720f, 
    -0.06667297f, 0.04451212f, 0.00808359f, 0.03938482f, 0.10265972f, -0.06256636f, 0.13603204f, 0.04925665f, 
    0.02560731f, -0.17065039f, -0.03482055f, -0.12523264f, 0.10533876f, -0.07919335f, -0.04969126f, 0.05538230f, 
    0.02738980f, -0.02668396f, 0.04915154f, 0.06897994f, 0.01662455f, -0.06660032f, -0.00151917f, 0.15969580f, 
    0.03608258f, 0.07700979f, 0.04264119f, 0.01477398f, 0.07077710f, -0.37884635f, -0.16847245f, -0.18948704f, 
    0.13811082f, -0.07721193f, -0.10278852f, -0.02558141f, -0.01339589f, -0.01970381f, -0.04195870f, -0.04182682f, 
    -0.07073098f, -0.03104511f, -0.05334053f, 0.06988737f, 0.04662660f, 0.06708117f, 0.05587409f, 0.07560282f, 
    0.11894985f, -0.04286370f, 0.22582273f, 0.40211630f, -0.10804712f, -0.06105471f, 0.11086168f, 0.03682207f, 
    0.01528449f, -0.00656774f, 0.12877057f, -0.03365125f, 0.08339658f, -0.07315887f, -0.06233809f, -0.16167369f, 
    -0.03839749f, -0.06350631f, -0.08584204f, 0.12171079f, 0.21610987f, 0.35360354f, 0.12271386f, 0.40964186f, 
    0.00984929f, 0.03024683f, 0.03525670f, 0.05174601f, 0.15635413f, 0.05888074f, -0.00145365f, -0.00197942f, 
    0.00334211f, -0.04861130f, -0.01464335f, 0.23482087f, 0.01665997f, -0.00839948f, 0.09154264f, -0.01434724f, 
    0.00837588f, -0.01266457f, 0.39238849f, 0.17249130f, 0.14446042f, -0.12177995f, -0.13066627f, -0.11918591f, 
    -0.00109394f, 0.02108158f, 0.15443802f, 0.09629720f, -0.03988406f, 0.01499430f, 0.04187366f, 0.19094820f, 
    0.05760531f, -0.04545735f, 0.02596207f, -0.06998929f, -0.04790844f, -0.18091425f, -0.07096063f, -0.12650941f, 
    -0.00647070f, -0.08357123f, 0.00219576f, 0.09708341f, -0.05722002f, -0.05847149f, 0.02692877f, 0.07694575f, 
    0.05864951f, 0.18283804f, 0.06498544f, -0.08135739f, -0.04910533f, 0.07919217f, 0.09810060f, -0.00595376f, 
    -0.04489997f, -0.12224860f, -0.01772068f, 0.11175898f, -0.06748942f, 0.02938827f, 0.03491126f, 0.02747208f, 
    -0.01573583f, 0.03827085f, -0.04457765f, -0.06660319f, 0.00874360f, 0.21464320f, 0.04895880f, 0.10319122f, 
    0.08851043f, -0.00651445f, 0.01455932f, 0.09467616f, -0.09726217f, -0.08838397f, 0.04917000f, -0.07849950f, 
    0.00084155f, -0.04894641f, -0.06807216f, 0.06442324f, -0.00012950f, -0.10549290f, 0.01765823f, 0.12777695f, 
    0.06503509f, 0.07369156f, 0.06353811f, -0.08218352f, -0.03053021f, -0.13217962f, 0.11805233f, -0.05368422f, 
    0.26066884f, -0.03983758f, 0.52784783f, 0.41698313f, 0.10144708f, 0.04761667f, 0.10492343f, -0.07979880f, 
    0.05281252f, -0.08446326f, 0.19883981f, -0.05117814f, -0.00311390f, -0.15675604f, 0.06804305f, 0.13998622f, 
    0.10312681f, -0.05949698f, -0.07843681f, 0.03843338f, 0.19124578f, -0.06612395f, 0.00646087f, -0.06561980f, 
    0.06053605f, 0.15286261f, 0.15362799f, 0.01843769f, -0.03815325f, 0.01200753f, -0.06681692f, -0.05458688f, 
    0.05719197f, -0.06179701f, 0.05785004f, -0.02464171f, -0.14587869f, -0.14746734f, 0.00812523f, -0.11297415f, 
    0.62822318f, 0.09875587f, 0.23193765f, 0.10183320f, 0.10614526f, -0.10182045f, 0.02631635f, 0.03887762f, 
    -0.11442929f, 0.08941650f, -0.04719107f, -0.02124614f, -0.02684899f, -0.10633871f, -0.16347581f, 0.07135792f, 
    0.08925738f, -0.21096085f, 0.14692296f, 0.13375184f, -0.48379865f, -0.01118477f, -0.15829521f, 0.04436206f, 
    -0.14600746f, 0.13412583f, 0.02823901f, 0.05775254f, -0.09961225f, -0.11876950f, 0.12071019f, 0.10933996f, 
    0.08912043f, -0.03743760f, 0.05073116f, 0.03322572f, 0.05458439f, -0.03314068f, -0.12027985f, -0.28002423f, 
    -0.58240730f, 0.28333455f, -0.08749502f, -0.20545056f, 0.08291307f, -0.00661149f, -0.07325571f, -0.08855262f, 
    -0.09073294f, -0.19935504f, 0.02606272f, 0.04874786f, 0.07724191f, 0.02042949f, 0.18559846f, 0.00184805f, 
    0.02827285f, 0.22458944f, -0.06987729f, 0.17713661f, -0.30925745f, 0.02801403f, 0.12737280f, 0.35220465f, 
    0.20885113f, 0.04507071f, 0.12795974f, 0.02722200f, -0.10928692f, 0.14553003f, 0.07138972f, -0.07675359f, 
    0.00029893f, -0.07448535f, -0.11858868f, -0.06061894f, 0.03338135f, -0.09391005f, -0.16799439f, -0.09752406f, 
    0.47738662f, 0.14652659f, 0.25160816f, 0.21703447f, 0.29099393f, 0.02292551f, -0.13726008f, -0.05220530f, 
    -0.07681917f, -0.25053668f, -0.00105136f, 0.02841723f, 0.08037151f, 0.02574538f, 0.10929444f, -0.00299399f, 
    -0.19648673f, -0.10634736f, -0.11404533f, -0.21377352f, -0.50053757f, 0.01594730f, 0.13726175f, 0.10100988f, 
    0.08993148f, 0.16519193f, -0.01810469f, 0.10026094f, 0.07940248f, -0.10243540f, 0.08676022f, -0.01090827f, 
    -0.05718728f, -0.01055798f, 0.01455666f, 0.09758411f, 0.04738379f, 0.10503679f, 0.02638711f, -0.01310603f, 
    0.23660263f, 0.36098373f, 0.03630602f, 0.05928119f, -0.21807925f, -0.10268122f, -0.04087756f, -0.08328783f, 
    -0.06693663f, 0.09089387f, -0.04083098f, -0.00591909f, -0.00466510f, 0.01528497f, 0.02583329f, -0.04124486f, 
    0.08714057f, 0.06297567f, 0.11022115f, 0.10097530f, -0.06625119f, 0.04439030f, 0.00986696f, 0.17175236f, 
    0.11971210f, 0.07634164f, -0.00454373f, 0.05141423f, 0.01506435f, 0.05024584f, 0.06744184f, -0.07863306f, 
    -0.00043699f, 0.01349042f, 0.06564421f, 0.02201667f, 0.16285159f, 0.20809020f, 0.10680835f, 0.13293076f, 
    -0.19371442f, 0.24985217f, -0.08313771f, 0.17717260f, 0.00851329f, -0.01540912f, -0.16393794f, -0.09394737f, 
    -0.28831044f, -0.16203229f, 0.09694852f, -0.06319293f, 0.02454225f, 0.03354386f, 0.03200005f, -0.01159618f, 
    -0.01321849f, 0.09178200f, -0.04781681f, -0.05825974f, 0.38457716f, 0.03296201f, -0.11849396f, -0.05231222f, 
    -0.04688580f, 0.00791626f, -0.13368502f, 0.06642221f, -0.03715381f, -0.05041952f, -0.03764235f, 0.05619758f, 
    -0.04958269f, -0.09824945f, -0.00168318f, -0.07737779f, -0.43012172f, -0.12099598f, -0.24499194f, -0.17086355f, 
    -0.20954898f, 0.20183387f, 0.31072947f, 0.13550912f, 0.44104287f, -0.00634846f, 0.13510549f, -0.04105506f, 
    -0.06583398f, 0.00791713f, 0.08227167f, 0.02214547f, 0.00823089f, -0.13552012f, -0.08569098f, 0.11641835f, 
    0.02149380f, -0.00557853f, -0.04256025f, 0.02560340f, 0.06145822f, -0.09722571f, -0.02377972f, -0.06660824f, 
    -0.19182701f, 0.06431295f, -0.02261851f, 0.04855781f, 0.14318240f, -0.02007443f, 0.11801022f, 0.04180134f, 
    -0.04288508f, -0.09799727f, -0.11842925f, -0.04418644f, 0.16484576f, -0.20141958f, 0.16048507f, 0.12047763f, 
    0.20705549f, -0.10667755f, 0.11312491f, 0.21590060f, 0.51217359f, -0.02487801f, 0.14855011f, 0.10544045f, 
    0.07545707f, 0.14382970f, 0.11254703f, 0.05752841f, -0.02614256f, 0.01997069f, -0.02929252f, 0.08739781f, 
    0.12173065f, -0.03846689f, 0.05219673f, 0.14903998f, 0.06876776f, -0.10939302f, 0.06220255f, -0.09159515f, 
    0.16469084f, 0.13013738f, -0.04430402f, 0.14190224f, 0.13306271f, 0.26315263f, 0.07093383f, 0.10387178f, 
    0.00018354f, -0.04716206f, 0.02854882f, 0.02177367f, -0.09171012f, -0.09610745f, -0.13414830f, -0.03141150f, 
    0.16358502f, -0.01363538f, 0.15108135f, 0.08225141f, 0.36838096f, 0.00955166f, -0.16606659f, 0.02342995f, 
    0.01658172f, -0.13042991f, -0.05479014f, 0.05811700f, -0.04880865f, -0.02569197f, 0.09790366f, -0.01334910f, 
    -0.06231059f, 0.03588242f, -0.00834172f, -0.07514873f, -0.30612278f, 0.07597763f, 0.36718225f, -0.04763117f, 
    0.18310682f, -0.00162091f, -0.02084406f, 0.06215246f, -0.08137741f, 0.13837056f, -0.00285874f, -0.03919157f, 
    0.07151575f, -0.02740538f, -0.08527544f, -0.02160659f, -0.09127247f, -0.13232592f, -0.18304650f, -0.16287811f, 
    0.29396218f, -0.02682407f, 0.09720003f, -0.14422868f, -0.16664380f, 0.17763920f, -0.23171097f, -0.05248750f, 
    0.02726414f, -0.09232256f, 0.11815359f, 0.04685897f, 0.02666113f, -0.15954968f, 0.12437933f, 0.01837384f, 
    -0.15988168f, -0.21480322f, 0.08518510f, -0.27318829f, 0.29820350f, 0.26965946f, -0.11945788f, 0.19854510f, 
    0.12808856f, -0.03562199f, -0.11444022f, -0.04881623f, 0.04033280f, -0.19515902f, 0.11207546f, -0.01583008f, 
    -0.19653371f, 0.08519286f, -0.09695888f, -0.06480340f, -0.15512595f, 0.16331671f, -0.07036295f, -0.10050789f, 
    -0.19275895f, 0.33458328f, -0.12854077f, -0.13056985f, -0.01421307f, -0.04451243f, -0.21420760f, 0.01232518f, 
    -0.13896318f, -0.03804413f, 0.03137996f, 0.03939121f, 0.07182007f, -0.14453655f, -0.01305858f, 0.01816900f, 
    -0.02166418f, -0.08448749f, 0.00036171f, -0.10864531f, 0.00984657f, 0.32098764f, -0.10433894f, -0.03435498f, 
    0.10771797f, 0.06765730f, -0.20928833f, 0.07952261f, -0.17984152f, -0.02139520f, -0.16996348f, 0.06568683f, 
    0.12337526f, 0.04106078f, -0.00245330f, 0.06477520f, -0.11681893f, -0.10032889f, 0.03067708f, -0.15443839f, 
    0.07231412f, 0.04015196f, -0.07947128f, 0.14164644f, 0.18045694f, -0.03064315f, 0.06201849f, -0.04689189f, 
    -0.00184620f, 0.03402426f, 0.04148911f, -0.00615643f, 0.07356875f, 0.05550184f, 0.13285618f, -0.15625514f, 
    0.10980429f, 0.06528990f, 0.03884958f, 0.01222436f, -0.11397181f, -0.03845276f, 0.06466120f, -0.13465416f, 
    0.10472594f, 0.21911968f, -0.15935190f, -0.04036632f, -0.04854582f, 0.09337732f, 0.12437729f, -0.10897529f, 
    0.05818352f, 0.03041471f, 0.02873331f, 0.14224021f, 0.02382415f, -0.02504961f, 0.11633788f, -0.03154425f, 
    0.03944721f, 0.08088147f, -0.08303599f, -0.01021576f, -0.08312042f, 0.09692964f, -0.11576477f, -0.07832758f, 
    -0.02295443f, 0.00130164f, -0.03921281f, 0.10557122f, 0.08131941f, 0.02714656f, 0.03599844f, -0.06586556f, 
    0.07252900f, 0.02431685f, 0.14745119f, 0.00943737f, -0.30979189f, -0.04142273f, -0.01886157f, 0.14112301f, 
    -0.09242070f, -0.10211498f, -0.10235633f, -0.00488558f, -0.01811821f, -0.06547381f, 0.02155200f, -0.01677187f, 
    0.07848506f, -0.00694075f, 0.20090747f, 0.06067585f, 0.16233064f, 0.11755496f, 0.04634243f, -0.05778423f, 
    -0.12497976f, -0.08723280f, -0.05081211f, 0.00925642f, 0.30734473f, -0.17769775f, 0.07287961f, 0.03902672f, 
    -0.06959219f, 0.16921075f, 0.03441548f, 0.06108335f, -0.00604809f, 0.12542991f, 0.08059774f, 0.07667292f, 
    0.21474148f, 0.18133996f, 0.10195774f, 0.22821663f, -0.07887745f, -0.13002050f, 0.13961054f, 0.11652985f, 
    0.08698887f, 0.02671507f, 0.01742034f, -0.17203897f, 0.07314144f, -0.08396159f, 0.00855183f, -0.02771384f, 
    -0.05175513f, 0.18586107f, 0.01737455f, -0.10460154f, 0.01160629f, 0.09550970f, 0.01254124f, 0.11244791f, 
    0.17720626f, 0.26043087f, 0.32400945f, -0.14106837f, 0.13875626f, 0.03615018f, -0.18179761f, 0.03825105f, 
    -0.06256525f, -0.06925333f, 0.01674389f, 0.01893598f, 0.07699520f, 0.03449144f, -0.02818449f, 0.01207186f, 
    -0.02483629f, 0.06237599f, 0.11176370f, 0.09491488f, -0.15297951f, -0.00901035f, -0.00610086f, -0.26523778f, 
    -0.02523832f, 0.13915822f, -0.01308249f, -0.11336729f, 0.05146918f, -0.22138406f, 0.07316125f, -0.00450719f, 
    0.18352239f, 0.01387977f, 0.11192027f, 0.07194853f, 0.04660552f, -0.09116837f, -0.16954923f, -0.25982228f, 
    0.04803965f, -0.01397492f, -0.00627689f, -0.10617999f, -0.01681125f, -0.03962535f, -0.04084811f, -0.08461291f, 
    -0.05586880f, -0.14525044f, -0.01399115f, -0.03261980f, -0.01100538f, 0.00370495f, 0.02427564f, -0.06723491f, 
    -0.05999176f, -0.12812982f, -0.02424228f, -0.17107067f, -0.21294895f, 0.10010915f, -0.02716727f, -0.02865828f, 
    0.03788808f, 0.01267007f, 0.02963567f, 0.04919514f, -0.17645976f, -0.01838225f, 0.05613165f, -0.01729644f, 
    0.07683611f, 0.18072107f, 0.06999763f, 0.24338807f, -0.12455595f, -0.03099306f, -0.41404629f, -0.29991028f, 
    -0.15740000f, 0.00531806f, 0.04925579f, 0.00892696f, 0.19450508f, -0.07609250f, 0.01036549f, 0.03364062f, 
    -0.07181650f, 0.11085515f, -0.09949294f, 0.12692875f, 0.10739809f, 0.04997515f, 0.10524361f, -0.03302261f, 
    0.18240696f, 0.11501507f, 0.10873491f, 0.15882696f, -0.43640947f, 0.05800636f, 0.05450819f, -0.16548115f, 
    0.19596206f, 0.07016940f, 0.00956436f, 0.06656242f, 0.01896192f, 0.17171091f, 0.08378868f, -0.03449516f, 
    -0.09056494f, -0.11779689f, -0.10199871f, -0.11381117f, -0.24603805f, -0.02808700f, -0.39044571f, -0.23018178f, 
    -0.03432938f, 0.02416582f, -0.02633736f, -0.03973579f, 0.02417569f, 0.02001020f, -0.01895164f, -0.02291495f, 
    -0.04338610f, -0.02732330f, -0.00171179f, -0.03378673f, 0.00340414f, -0.00354978f, 0.02416546f, 0.00977720f, 
    0.03824349f, 0.00469046f, -0.02336035f, 0.00180565f, 0.03588700f, 0.00416446f, -0.03912903f, -0.03328456f, 
    -0.02543279f, -0.04497999f, -0.03428619f, 0.03187539f, -0.02096513f, 0.00795606f, -0.02348359f, 0.00082998f, 
    0.01483288f, -0.04107584f, -0.01976486f, -0.04057427f, -0.03529019f, -0.04648612f, 0.01715128f, 0.02619780f, 
    0.00039164f, -0.01301926f, 0.01435347f, -0.02815841f, -0.04633085f, 0.00263931f, 0.00080704f, -0.03060935f, 
    -0.04776369f, -0.05058764f, 0.00500662f, -0.02398737f, 0.01417685f, -0.02375764f, -0.03806560f, -0.02169022f, 
    0.02859803f, 0.02643572f, -0.01102636f, 0.01844098f, 0.00075379f, -0.02726824f, -0.04020891f, 0.01233967f, 
    -0.02991997f, 0.00261633f, -0.01638448f, -0.03033725f, 0.02216536f, -0.00270378f, 0.03220079f, -0.03079693f, 
    -0.00425860f, -0.04406481f, -0.01029486f, -0.04115392f, 0.01219083f, -0.02978695f, -0.00130278f, -0.00146726f, 
    -0.00401310f, -0.00683654f, -0.01267577f, -0.03584359f, -0.01855729f, -0.00849955f, -0.01435133f, -0.00818776f, 
    -0.04066483f, 0.00415931f, -0.03310345f, 0.00583410f, 0.02967490f, 0.00094509f, 0.00881931f, -0.03205958f, 
    -0.03923563f, 0.01523379f, -0.02817824f, -0.02391862f, -0.00724162f, 0.01998700f, 0.00837049f, -0.02048374f, 
    0.01906808f, 0.00893066f, -0.01946361f, 0.01811698f, 0.00444047f, 0.00615891f, -0.03746071f, 0.00353894f, 
    0.00462896f, -0.00677784f, -0.02100526f, -0.01140766f, 0.02299808f, 0.00452064f, 0.00784618f, 0.00236091f, 
    0.02251257f, -0.03313831f, 0.01108772f, -0.01753409f, -0.02650955f, 0.03447260f, -0.02034204f, -0.00295077f, 
    -0.01901465f, -0.00054087f, 0.02596487f, -0.00331735f, -0.02986438f, -0.03568299f, 0.00494025f, -0.02329285f, 
    0.03061149f, -0.03737114f, 0.03011667f, 0.01548273f, -0.01613243f, -0.02051046f, -0.04070200f, -0.01071859f, 
    -0.02908724f, -0.01603476f, -0.03772333f, -0.02630445f, -0.01805235f, -0.04629606f, 0.02197289f, 0.03188379f, 
    0.02446977f, 0.02816169f, 0.03124795f, -0.02656985f, -0.01984892f, 0.01633303f, 0.02625722f, -0.04408833f, 
    0.00029167f, -0.02301181f, 0.01685894f, -0.01195368f, 0.01942741f, -0.01597059f, 0.01764255f, -0.03232742f, 
    0.02606627f, 0.02993646f, -0.00262763f, -0.03655230f, 0.02915198f, 0.03078653f, -0.01294518f, 0.00694425f, 
    -0.00687725f, -0.02739307f, 0.01280034f, -0.03094780f, 0.00564745f, -0.02481832f, 0.04278528f, 0.03853180f, 
    -0.00975386f, -0.01795735f, -0.02718099f, 0.02365580f, -0.02879953f, 0.00977218f, -0.00428042f, 0.01940551f, 
    0.01201242f, -0.00035736f, -0.03306557f, 0.02807775f, -0.01132574f, 0.01597631f, 0.01526409f, -0.04638601f, 
    0.01730876f, 0.02520888f, 0.02442058f, 0.02521112f, -0.01166865f, -0.01771386f, 0.02820226f, 0.01263294f, 
    -0.04404455f, -0.03771579f, 0.02373137f, 0.02713812f, 0.01687184f, -0.01503426f, 0.00556957f, -0.04798611f, 
    0.01025237f, 0.02721232f, 0.01550512f, -0.03425425f, -0.04896997f, -0.01651809f, -0.04172396f, 0.00769594f, 
    -0.03867935f, 0.00012762f, 0.00987153f, -0.01618267f, -0.01001416f, 0.00243635f, -0.00190918f, -0.04087759f, 
    0.02376300f, 0.02698357f, 0.01713365f, -0.01574261f, -0.02887994f, -0.04433683f, 0.01618129f, 0.01682315f, 
    -0.00040893f, -0.02049314f, 0.01853415f, -0.01589654f, -0.00863057f, 0.01589953f, -0.02512341f, -0.01066368f, 
    0.02703596f, -0.04599811f, -0.00004461f, 0.00477458f, 0.00092262f, -0.00614844f, -0.01706835f, -0.01006203f, 
    0.02356277f, -0.03398824f, -0.00887368f, 0.01111684f, 0.00116279f, 0.00714186f, -0.00613833f, -0.01273473f, 
    0.00173694f, 0.01790982f, -0.02370425f, -0.03604570f, -0.02679625f, -0.00206224f, 0.02474274f, -0.02144512f, 
    0.01817200f, -0.00036447f, -0.03889836f, 0.00315035f, 0.01353904f, -0.03076023f, 0.00443592f, 0.01342453f, 
    -0.00320234f, 0.03587859f, -0.01688122f, -0.01282081f, -0.02060017f, 0.01001960f, -0.03298156f, 0.01042361f, 
    0.02336197f, 0.00155059f, -0.03120467f, 0.00077527f, 0.02141427f, 0.01163782f, 0.01071711f, -0.01856635f, 
    0.02032082f, -0.02205926f, -0.02491267f, -0.00128190f, 0.01898293f, 0.02385561f, -0.04123663f, -0.03147725f, 
    0.02333009f, 0.02419862f, -0.01810304f, -0.03424339f, -0.01296570f, -0.00115445f, 0.00118820f, 0.02891984f, 
    0.01062797f, -0.02407619f, -0.01048075f, 0.01740806f, -0.03072768f, -0.01367672f, -0.00841619f, 0.00790590f, 
    -0.04362453f, -0.01648655f, -0.00198045f, -0.00030184f, -0.04881467f, -0.03951931f, 0.00752844f, 0.00688175f, 
    0.00303916f, 0.00821433f, -0.03015379f, -0.00792109f, -0.00011191f, -0.03488608f, -0.04132222f, -0.02405073f, 
    0.00399434f, 0.01251600f, 0.01306731f, -0.03663102f, 0.01123093f, -0.01100454f, -0.02747940f, -0.04492867f, 
    -0.03893499f, -0.00697441f, 0.02557143f, 0.00983640f, -0.00049380f, 0.02828925f, -0.03789563f, 0.02021617f, 
    -0.01377054f, -0.02469752f, 0.01018150f, -0.01341702f, -0.00168037f, 0.03089957f, 0.01191350f, -0.03972723f, 
    0.02021147f, -0.02644865f, -0.00024965f, -0.00254548f, -0.04182899f, -0.00868438f, -0.00223804f, 0.00686959f, 
    0.02088830f, 0.00171083f, 0.00511770f, 0.01141103f, 0.02560593f, -0.01506593f, -0.03040648f, -0.04053136f, 
    0.01015514f, -0.01527558f, 0.01878681f, -0.02022971f, -0.00710103f, 0.02110252f, -0.04283519f, -0.04744098f, 
    0.00529069f, 0.01794523f, -0.01453867f, 0.02078632f, 0.02251518f, -0.00863011f, -0.02932765f, 0.02070912f, 
    0.00125794f, 0.00637811f, -0.03118839f, -0.02900687f, 0.02798729f, 0.02613479f, 0.00205550f, -0.02375417f, 
    0.03027937f, -0.00813217f, 0.00102914f, 0.00158189f, -0.03207703f, 0.01977730f, 0.00024747f, -0.03159561f, 
    -0.00770119f, -0.00448742f, 0.01164388f, 0.02455218f, -0.03431120f, -0.00782882f, -0.00413524f, -0.01501950f, 
    0.00240317f, -0.00788485f, -0.04138011f, -0.02504728f, -0.04834124f, 0.02332806f, 0.02573024f, -0.02062195f, 
    -0.00754319f, 0.02384299f, -0.04087091f, -0.01476136f, -0.02501602f, -0.02694780f, -0.02761536f, 0.01377051f, 
    -0.03934057f, 0.01022954f, -0.00225502f, -0.04743227f, -0.01223121f, -0.01686118f, -0.01999070f, -0.03080446f, 
    -0.03193680f, -0.01221128f, 0.01933526f, -0.02017167f, 0.02353173f, -0.01451642f, -0.02770452f, 0.02809717f, 
    -0.02617345f, -0.01141697f, -0.02883287f, 0.02521808f, 0.00309848f, -0.04180561f, -0.01505174f, -0.01043580f, 
    -0.02157128f, 0.00260580f, 0.01438238f, 0.00444142f, -0.03893045f, -0.04076338f, -0.04768172f, -0.02355319f, 
    -0.02965446f, 0.03216067f, 0.00976215f, -0.03040099f, -0.01230550f, 0.02591141f, -0.03212976f, -0.02598068f, 
    0.03267631f, -0.02169698f, 0.01068529f, 0.00802790f, -0.02628278f, 0.00666456f, -0.03173326f, -0.00716185f, 
    0.01782247f, 0.03299362f, 0.04129379f, 0.00569283f, 0.01038460f, -0.02841482f, 0.03724618f, 0.03320105f, 
    -0.04079407f, -0.04406317f, 0.02961159f, -0.00813372f, 0.02179503f, -0.01600674f, 0.00975560f, 0.04015535f, 
    0.02237155f, -0.04456673f, 0.02447572f, 0.03272538f, 0.01128945f, 0.01603460f, -0.03854366f, -0.00075667f, 
    -0.00083422f, -0.02203015f, -0.00306654f, 0.02424847f, -0.03300537f, 0.00519179f, -0.00169001f, -0.01076326f, 
    0.02810528f, -0.03491826f, -0.02340350f, -0.03734353f, -0.00346912f, -0.03879322f, -0.01533678f, 0.00832910f, 
    0.02154665f, 0.01643399f, 0.00166047f, 0.01519761f, 0.01348685f, 0.00384033f, -0.02337211f, -0.03980583f, 
    0.01270342f, -0.02623373f, -0.01657364f, -0.02456204f, -0.00941861f, -0.03956155f, -0.01855130f, 0.00928302f, 
    -0.02380229f, -0.00973837f, 0.02592126f, -0.01685262f, 0.01579475f, 0.02481440f, 0.02844047f, 0.02656396f, 
    -0.03957845f, 0.00164979f, -0.02468303f, 0.00435373f, -0.00030312f, -0.04258759f, 0.02156328f, 0.02544025f, 
    0.00916159f, -0.00022047f, -0.00899023f, 0.00740030f, -0.03647230f, -0.01655238f, 0.00341992f, 0.00946961f, 
    -0.00620357f, -0.01303355f, 0.02838107f, 0.01658881f, -0.00368705f, 0.00286622f, -0.04261350f, 0.01004967f, 
    -0.03159267f, -0.03158731f, 0.02162048f, -0.01934413f, -0.03425198f, -0.03697500f, -0.00839958f, 0.00085054f, 
    0.01432279f, -0.04215134f, -0.04128721f, -0.02740915f, 0.02509056f, 0.03195334f, 0.00826558f, -0.04144127f, 
    0.00974705f, -0.02972039f, -0.00453365f, -0.02408044f, 0.02797121f, -0.01211504f, -0.00342397f, -0.00879263f, 
    0.00561126f, 0.02706683f, 0.01338323f, -0.02100330f, -0.04599340f, -0.02360723f, -0.02305493f, -0.02994606f, 
    0.01614125f, -0.01911143f, -0.03172265f, 0.02126542f, -0.04174739f, 0.01275486f, -0.02007723f, 0.02572127f, 
    -0.01339525f, -0.03055971f, 0.01301215f, 0.01254572f, -0.01334990f, -0.04426633f, 0.01908598f, -0.02677477f, 
    -0.00206538f, 0.02520040f, -0.00206252f, 0.03090611f, -0.00555986f, -0.02842364f, -0.04895478f, 0.00325498f, 
    -0.00691065f, -0.02510550f, 0.01478720f, 0.00275413f, 0.01805851f, -0.03925920f, -0.02294372f, -0.02799554f, 
    -0.01785712f, -0.00209151f, -0.02158906f, -0.01260928f, -0.04600671f, 0.03262735f, -0.04125263f, -0.04066123f, 
    -0.27546790f, 0.32871413f, 0.13451542f, 0.04996395f, 0.01343702f, 0.35732672f, -0.12948294f, -0.00895045f, 
    0.06348351f, -0.15926015f, 0.00131270f, 0.01760946f, 0.03676153f, 0.10950796f, 0.05595952f, -0.06590179f, 
    -0.13789192f, -0.13173190f, 0.01402352f, -0.09612455f, -0.20655252f, 0.04778849f, -0.18109637f, -0.05397462f, 
    -0.00505434f, -0.04719640f, -0.23140986f, -0.09712674f, -0.09296141f, 0.02558198f, -0.10047068f, -0.10022823f, 
    0.04471645f, -0.03088317f, -0.04695335f, -0.09553353f, -0.05456724f, -0.02174628f, 0.05543447f, 0.10353848f, 
    0.66519004f, 0.20741773f, 0.10880092f, -0.06933646f, 0.13571885f, -0.03875614f, -0.03109784f, -0.19125478f, 
    -0.04847660f, -0.00845036f, 0.05268052f, -0.01946734f, -0.00089655f, 0.09464490f, -0.02103383f, 0.06445449f, 
    -0.04045583f, -0.34483144f, 0.02200020f, -0.09604834f, 0.31115311f, 0.02994673f, -0.28692636f, 0.00030021f, 
    -0.29048207f, 0.03419504f, -0.13290836f, 0.01973466f, -0.02828213f, -0.05949429f, 0.01550546f, -0.03024532f, 
    0.01022237f, 0.00804533f, -0.03671794f, 0.00584943f, 0.12554421f, 0.08732205f, 0.03734335f, 0.10942185f, 
    -0.17746641f, -0.09674733f, -0.02352776f, -0.13814968f, -0.14458147f, -0.09088498f, -0.01177776f, 0.02100903f, 
    0.05908241f, 0.09478505f, 0.06420592f, 0.05134546f, -0.04634583f, 0.06630377f, -0.01694677f, 0.01499185f, 
    0.04117997f, 0.04500690f, 0.09998086f, 0.06439894f, 0.15954071f, 0.04013593f, -0.03904306f, 0.13972570f, 
    0.02405686f, 0.00762394f, 0.22767046f, 0.00714982f, -0.02291987f, 0.11304709f, -0.02599623f, 0.00560959f, 
    0.05247292f, -0.02132920f, -0.00200507f, 0.01391058f, 0.10446198f, -0.03241507f, -0.12335474f, -0.02742559f, 
    -0.03012803f, 0.19865626f, 0.04619294f, 0.08377012f, -0.16519749f, 0.11830741f, -0.14913173f, -0.07802100f, 
    0.40306425f, -0.02860842f, -0.05690417f, 0.17371719f, 0.05019962f, -0.03079792f, 0.10088631f, 0.21171717f, 
    0.08609547f, -0.05403671f, -0.02221804f, -0.03184944f, -0.12373257f, 0.12551647f, 0.06154337f, -0.02327615f, 
    -0.04333742f, 0.04418994f, 0.08745208f, 0.05163849f, -0.00964569f, 0.01989361f, -0.11548037f, 0.04194340f, 
    -0.00482322f, -0.00736925f, -0.02234671f, 0.00104353f, -0.16943075f, -0.04699041f, 0.02299572f, -0.11622145f, 
    0.11847691f, 0.07853559f, -0.15129758f, 0.17843910f, -0.11412267f, -0.00129203f, 0.15155923f, 0.28198329f, 
    0.07912622f, 0.16569149f, -0.20545085f, 0.06719644f, -0.00464425f, -0.01372405f, -0.01465559f, 0.14493540f, 
    -0.04074017f, -0.00727062f, 0.12191803f, 0.07947370f, 0.07888192f, -0.07290752f, -0.23957483f, 0.17944250f, 
    -0.08655570f, -0.05109248f, -0.05057421f, -0.04035016f, 0.19229524f, 0.12501654f, -0.09063429f, -0.09368955f, 
    0.01096203f, 0.07708008f, 0.02363873f, -0.08523623f, 0.24816175f, 0.04709355f, 0.22049837f, 0.15033624f, 
    0.02944794f, 0.15434018f, 0.02574178f, -0.13043135f, -0.02774355f, -0.03404933f, 0.10902926f, 0.10940720f, 
    0.03030063f, -0.07569700f, 0.13360226f, -0.02954928f, 0.01917986f, 0.02468073f, -0.05416194f, -0.02020101f, 
    -0.05933089f, -0.01085063f, 0.02441043f, 0.05373803f, 0.11854333f, 0.09637896f, -0.22530064f, 0.17775302f, 
    0.27716807f, 0.14179656f, 0.14870699f, 0.08137870f, 0.16881713f, 0.08348635f, 0.02987270f, 0.04732938f, 
    0.07243516f, 0.05575504f, 0.13665056f, -0.01762587f, 0.09591255f, 0.22279462f, -0.03518476f, -0.06136113f, 
    -0.10845948f, -0.13690415f, -0.17565879f, -0.16287211f, -0.30739477f, -0.03529250f, -0.25180423f, -0.03720284f, 
    -0.27713865f, -0.17804153f, 0.07417580f, 0.11591145f, 0.07904697f, 0.08439117f, 0.13841528f, 0.17724311f, 
    0.05847858f, -0.02440507f, -0.14458552f, -0.17531139f, -0.27189776f, -0.20101851f, -0.11381035f, 0.09416722f, 
    -0.06776146f, -0.11755311f, 0.02610477f, -0.01213684f, -0.05802454f, -0.23263894f, 0.02644279f, -0.02836874f, 
    -0.01087064f, 0.00275530f, 0.00396728f, 0.08681411f, 0.19687732f, 0.07959574f, 0.10273786f, 0.16321993f, 
    -0.20993647f, -0.17833298f, -0.17689896f, -0.00368493f, -0.26138920f, 0.00795352f, -0.02247419f, 0.02785795f, 
    0.24737328f, 0.18385035f, 0.09959215f, 0.03583734f, -0.05684566f, -0.02415279f, -0.05519172f, 0.06083904f, 
    0.09871774f, 0.06981341f, 0.05467764f, 0.06369513f, 0.14945161f, -0.01065908f, -0.03454732f, -0.07770804f, 
    -0.13487014f, 0.03851012f, 0.07392561f, 0.02311894f, 0.07753426f, 0.14305389f, 0.16484703f, 0.01337617f, 
    -0.06165604f, 0.11130098f, 0.01532657f, 0.07358041f, 0.11876171f, 0.05304080f, 0.06083960f, 0.24626099f, 
    -0.04734014f, 0.04875209f, -0.07657367f, -0.06325413f, 0.05574839f, -0.12612966f, -0.01926970f, 0.02865444f, 
    -0.11167054f, -0.05878461f, -0.08911414f, 0.04366600f, -0.01581149f, -0.01864472f, 0.06281609f, 0.14812197f, 
    -0.08783412f, -0.07593399f, 0.16772258f, 0.12372059f, -0.05039206f, -0.24906793f, -0.37914547f, -0.01493524f, 
    -0.16066240f, -0.08752556f, -0.08647778f, -0.09347179f, 0.08939387f, 0.03440607f, 0.01286866f, 0.08680689f, 
    0.01136934f, 0.00522917f, 0.02696199f, 0.03988563f, 0.14185609f, -0.05564222f, 0.13463859f, 0.13037083f, 
    0.02073200f, 0.12906961f, -0.19120102f, -0.08076653f, 0.20201519f, 0.02851442f, 0.01867632f, 0.01012221f, 
    0.00112180f, 0.08392646f, -0.00267123f, 0.13449535f, -0.02343980f, 0.11324987f, 0.06066617f, 0.07311197f, 
    0.02706880f, 0.01583933f, 0.01520473f, 0.19001697f, -0.09043960f, 0.16560318f, 0.10469963f, -0.12085585f, 
    0.04350136f, -0.08129521f, 0.08270935f, -0.12568244f, -0.02857736f, -0.08187740f, 0.03663671f, 0.12314159f, 
    -0.05157965f, 0.10072196f, 0.08102309f, 0.09150465f, -0.02068403f, 0.00692064f, 0.30061096f, -0.04391849f, 
    -0.18428363f, 0.11270133f, -0.14564930f, 0.10120720f, 0.04891574f, 0.18178740f, -0.07464489f, 0.06715037f, 
    0.02249201f, 0.13995381f, 0.06244798f, 0.12074105f, -0.06669413f, 0.12327927f, -0.02302240f, 0.15059501f, 
    -0.04531326f, 0.06980528f, 0.07163431f, 0.07524642f, -0.15765159f, -0.01414408f, 0.07133838f, 0.02416567f, 
    -0.03570797f, -0.01071100f, -0.01975984f, -0.03775240f, 0.00605530f, -0.07325116f, 0.03619937f, -0.01943175f, 
    -0.06873027f, -0.00079997f, 0.04961283f, -0.12469506f, -0.02431250f, 0.01955467f, 0.06718587f, 0.01180896f, 
    -0.06578775f, 0.02145062f, 0.08261394f, 0.10642853f, 0.00781988f, -0.15960228f, -0.08809251f, -0.02171594f, 
    -0.09274031f, -0.04677391f, -0.02416157f, -0.07679627f, -0.02382617f, 0.06803968f, -0.00127875f, 0.09617259f, 
    0.00279508f, 0.02581730f, 0.08166233f, 0.05587322f, -0.26147729f, 0.13623923f, 0.08283059f, 0.03163396f, 
    -0.04771853f, 0.04099356f, -0.04462253f, 0.00870024f, -0.07637356f, -0.06647959f, -0.14763175f, -0.07141796f, 
    -0.09587791f, -0.01524464f, -0.01842330f, 0.01857112f, -0.07788201f, -0.13638242f, 0.02659831f, -0.04158746f, 
    -0.14367278f, -0.05477703f, -0.05724407f, 0.01215507f, -0.19915630f, 0.15032989f, -0.22762057f, -0.22325045f, 
    0.05181352f, -0.12989859f, 0.13848457f, 0.05367099f, 0.04948569f, -0.04617627f, 0.07026531f, 0.05283001f, 
    0.01132885f, -0.02903799f, -0.13885798f, -0.17680405f, -0.18269700f, 0.04431016f, -0.17599396f, 0.04734856f, 
    -0.06100486f, 0.13280585f, 0.02920424f, 0.09364187f, 0.20502964f, 0.10962409f, 0.21580639f, 0.06736961f, 
    0.16136286f, -0.00715718f, 0.09063272f, 0.05739590f, 0.03983281f, -0.06870928f, 0.01892764f, 0.17759311f, 
    -0.02989360f, -0.16811575f, 0.23929654f, 0.08065666f, -0.02227154f, -0.18026769f, -0.06497525f, -0.14687787f, 
    -0.08418788f, -0.19105823f, 0.18918848f, 0.12447694f, 0.03251313f, 0.01299853f, 0.12320685f, -0.02236655f, 
    0.00308626f, 0.03812227f, 0.10552745f, -0.07171284f, -0.04633028f, 0.01982856f, -0.13246481f, -0.02459063f, 
    0.02888830f, -0.03798900f, -0.18815316f, -0.05532211f, -0.03043579f, -0.07115515f, -0.17483373f, -0.16647559f, 
    -0.11300546f, -0.03035210f, -0.13049090f, -0.11616912f, -0.01270328f, 0.05195500f, -0.03739057f, 0.12347198f, 
    -0.01203439f, 0.14261910f, -0.11984466f, 0.01677698f, 0.21839909f, 0.12946911f, 0.00953380f, 0.10323174f, 
    0.05149194f, 0.01349277f, 0.02114772f, 0.06086053f, -0.03023755f, 0.05512337f, 0.03434487f, -0.02376787f, 
    0.04504651f, 0.03857499f, 0.19711578f, 0.17221913f, -0.03943821f, -0.01579891f, -0.07441270f, -0.03603851f, 
    -0.06719245f, -0.10935503f, -0.04127260f, -0.01150203f, -0.11240840f, -0.04572179f, 0.15699631f, 0.05962562f, 
    0.04134991f, -0.00885869f, 0.09776327f, -0.09192753f, 0.05194197f, 0.02041800f, 0.03058487f, 0.20613617f, 
    -0.09491280f, 0.03214535f, 0.06110485f, -0.04570661f, -0.06347071f, -0.12458584f, -0.03714518f, -0.10919954f, 
    0.11255497f, -0.08422949f, 0.16069198f, 0.01683516f, -0.04788683f, -0.20036823f, 0.02378190f, 0.18370143f, 
    -0.07557663f, -0.09947696f, 0.09003943f, -0.12564094f, 0.01197076f, -0.12203824f, -0.15662213f, 0.06062147f, 
    -0.09769768f, -0.22447199f, -0.08509963f, -0.04397769f, -0.04413027f, -0.11218353f, -0.18682754f, -0.16381967f, 
    -0.00364288f, -0.09249993f, -0.09380356f, 0.10685591f, 0.14943282f, 0.02494360f, 0.04404133f, 0.16822104f, 
    0.05804102f, -0.15901217f, 0.14185676f, 0.09673937f, 0.00451309f, 0.04030738f, 0.06330539f, 0.10503774f, 
    0.00410010f, 0.08377510f, -0.04003236f, 0.09866270f, 0.06850559f, 0.03618930f, -0.14558038f, 0.09865008f, 
    0.13218012f, 0.06031584f, 0.20803142f, 0.14066771f, 0.20727839f, -0.00338853f, 0.01353313f, -0.16515519f, 
    -0.07164942f, -0.01656882f, -0.03302706f, -0.11462695f, 0.17964551f, 0.01900629f, 0.00847047f, 0.00952215f, 
    0.00223224f, -0.06574687f, -0.05556719f, -0.03929250f, -0.08388534f, -0.09447155f, -0.08858237f, -0.10489506f, 
    -0.21590577f, 0.16847828f, 0.08977406f, 0.07896350f, -0.08193901f, -0.10488311f, 0.02578126f, 0.00227748f, 
    -0.10886622f, -0.04121301f, 0.01476963f, 0.02123882f, 0.14984296f, -0.02550120f, 0.22148831f, 0.07645323f, 
    -0.05698897f, 0.07215263f, 0.04902029f, 0.14116205f, -0.21429192f, -0.42171410f, -0.20098267f, 0.23233099f, 
    0.13678169f, 0.25363177f, 0.05118315f, 0.15206653f, -0.04268633f, -0.08327899f, 0.07061342f, 0.02528723f, 
    -0.11943048f, 0.04468922f, 0.01450462f, -0.02842909f, 0.03629869f, 0.01861936f, -0.03088398f, -0.04658933f, 
    0.02385611f, 0.26019514f, 0.43628290f, 0.12774375f, 0.03955786f, -0.09110157f, -0.11366862f, -0.16672879f, 
    -0.02319143f, 0.02308311f, 0.08563770f, 0.05131472f, 0.09937104f, -0.03046821f, 0.02735857f, -0.03277352f, 
    -0.09677221f, -0.14250199f, -0.10651248f, -0.09507009f, -0.00824781f, -0.08335042f, 0.03094851f, 0.07358377f, 
    0.15731274f, 0.12862270f, -0.00804904f, 0.11459664f, 0.04768801f, 0.04488225f, 0.12144464f, -0.04304063f, 
    -0.05596759f, 0.01494340f, 0.03317055f, 0.08971415f, 0.01716608f, 0.08953408f, 0.02827303f, 0.01206063f, 
    0.00767236f, -0.01832364f, -0.19204968f, 0.16428229f, -0.05562102f, 0.08759473f, 0.07939731f, -0.00270164f, 
    -0.05267957f, 0.04997642f, 0.05486982f, -0.01808316f, 0.10280851f, 0.08784293f, 0.07354786f, 0.00752281f, 
    0.20792213f, -0.00134087f, 0.24485214f, 0.08581281f, 0.10203729f, 0.01603860f, 0.05258279f, -0.03917406f, 
    0.07303898f, -0.00983571f, 0.03934817f, 0.02196612f, 0.06156065f, 0.09274034f, 0.03016159f, -0.00686521f, 
    0.00568607f, -0.05672565f, 0.00564033f, 0.04937432f, 0.11558761f, 0.09757736f, 0.04284798f, 0.02580209f, 
    0.10909209f, 0.10576949f, -0.20679778f, -0.16201292f, 0.05118264f, 0.01961959f, -0.02538378f, -0.00478869f, 
    0.06234766f, 0.04145301f, 0.01700816f, 0.05534810f, -0.02094374f, -0.06928141f, -0.04175449f, 0.07601165f, 
    0.04195282f, -0.01730272f, 0.07748809f, -0.00077372f, 0.10049006f, -0.11093215f, -0.09741791f, 0.09304355f, 
    0.06469677f, 0.04434254f, 0.03354164f, 0.05247502f, 0.00378199f, -0.04499176f, -0.04400893f, -0.02080343f, 
    0.00611726f, -0.11809584f, -0.01849320f, -0.00045204f, -0.00746051f, -0.02393162f, -0.06917345f, -0.13376735f, 
    0.42051774f, 0.14766435f, 0.16055250f, 0.00831040f, 0.26351103f, 0.01291050f, 0.08434524f, -0.04973895f, 
    0.10515636f, -0.03383268f, 0.05667626f, 0.10946602f, -0.01039514f, 0.03845138f, 0.00415294f, 0.04419011f, 
    -0.01427094f, 0.09358636f, -0.07089801f, 0.01318543f, 0.03739185f, 0.11379211f, -0.02031879f, 0.09314437f, 
    -0.03596960f, 0.05944866f, -0.00677736f, 0.18947507f, 0.13016972f, 0.16462715f, 0.07136033f, -0.00359997f, 
    0.10368166f, -0.05681136f, 0.00471834f, -0.03245376f, 0.13538592f, 0.07769723f, 0.19936025f, 0.08157192f, 
    0.11163487f, -0.25482073f, -0.16141516f, 0.07846021f, 0.19728662f, -0.00975551f, 0.01068973f, 0.07895651f, 
    0.15416209f, -0.07500274f, 0.07297045f, -0.00255635f, 0.01808942f, -0.04231535f, -0.07047071f, 0.15279937f, 
    -0.02733968f, -0.00239942f, 0.31884068f, 0.11717543f, -0.23724261f, -0.34481865f, 0.01156338f, -0.04965406f, 
    -0.08983026f, 0.04421581f, 0.07760398f, 0.22532226f, 0.01975689f, -0.05208605f, 0.07926954f, -0.06744089f, 
    -0.10022349f, -0.07158508f, -0.05027419f, 0.00553111f, 0.00132856f, 0.08991116f, -0.07605898f, -0.23560350f, 
    0.10476264f, 0.04454664f, 0.30411935f, 0.09974797f, 0.00787666f, 0.01883287f, -0.07790780f, -0.11926118f, 
    0.09802545f, 0.15151966f, 0.02041748f, 0.11318063f, -0.02299639f, -0.12070278f, -0.00528853f, -0.06589478f, 
    0.03335851f, -0.02467337f, 0.01731103f, -0.00574931f, -0.34831682f, 0.02020675f, 0.27333948f, 0.00865326f, 
    0.04860331f, 0.03398605f, 0.12684414f, 0.04468948f, 0.05578726f, -0.05275023f, 0.00206458f, -0.02454622f, 
    -0.02436043f, 0.01103559f, 0.01378003f, 0.06948341f, 0.06485227f, 0.08194724f, -0.15136354f, -0.11888013f, 
    -0.03175977f, -0.02160433f, 0.15036869f, -0.19104162f, -0.06798051f, 0.05692041f, -0.07044715f, 0.04138742f, 
    0.06558814f, 0.03075238f, -0.01345465f, -0.01266945f, -0.01881001f, -0.00480150f, 0.09834564f, -0.01224772f, 
    -0.05507468f, 0.05638544f, 0.02086743f, 0.05226577f, 0.23704821f, 0.06619849f, -0.05786331f, 0.21273363f, 
    -0.00623471f, 0.11840937f, -0.00107575f, -0.16248129f, -0.06901188f, 0.18366741f, 0.12917629f, -0.09140124f, 
    0.01932871f, 0.02732862f, -0.00662878f, 0.07430747f, -0.09497306f, -0.08040076f, -0.05022410f, 0.16612144f, 
    0.39679441f, 0.13029788f, -0.10757940f, -0.07401266f, 0.03432940f, -0.05448838f, -0.07503642f, -0.08858025f, 
    -0.01089578f, 0.01918142f, 0.10131025f, 0.03437110f, -0.04895633f, -0.03782653f, -0.03048644f, 0.17473148f, 
    0.11159834f, -0.10383933f, -0.01092808f, 0.07440870f, 0.36289006f, 0.15618631f, -0.21399595f, 0.01660420f, 
    0.16468900f, -0.04181812f, 0.06520056f, 0.04819197f, 0.03830541f, 0.02962578f, -0.07124200f, -0.01903855f, 
    0.17805600f, -0.05351469f, 0.05003053f, 0.05252117f, -0.08424766f, 0.05236313f, 0.04186137f, -0.09276739f, 
    0.09818725f, -0.06751516f, -0.05492031f, 0.09640640f, 0.02755582f, 0.06160352f, -0.02034887f, -0.09043312f, 
    0.04752681f, 0.08486752f, 0.03063313f, -0.03739638f, -0.02152147f, 0.17215301f, 0.03589133f, -0.02939295f, 
    0.06332295f, 0.02601453f, 0.13572912f, 0.06075480f, 0.10977150f, 0.02304660f, 0.18690503f, 0.04144430f, 
    0.05096377f, 0.05956281f, 0.02820935f, -0.10327771f, -0.07326403f, 0.03424534f, -0.03371632f, -0.14576524f, 
    -0.03715585f, 0.02069477f, 0.02175177f, 0.07733761f, -0.09489704f, 0.12697834f, 0.02550315f, -0.10768150f, 
    0.03446422f, 0.18163557f, 0.12509394f, 0.02435634f, -0.03964528f, -0.00343962f, -0.02346899f, 0.00160575f, 
    -0.05452263f, 0.10360829f, -0.04826612f, 0.00666152f, 0.00664294f, 0.07718637f, -0.03620193f, 0.05140382f, 
    0.03351676f, -0.04029661f, 0.12807368f, -0.02769100f, 0.01493400f, 0.04310615f, 0.15405001f, -0.12307432f, 
    -0.14502119f, -0.22338784f, -0.03235187f, -0.05146941f, 0.07112011f, 0.11956328f, -0.04916387f, -0.04932571f, 
    0.03696182f, -0.07225913f, -0.08900304f, -0.03809917f, -0.00698101f, 0.00227479f, -0.01178113f, 0.00538607f, 
    -0.21247993f, -0.38855404f, -0.19059016f, -0.06960990f, -0.07084928f, 0.01791124f, -0.08596213f, -0.04275042f, 
    -0.14413518f, 0.02228750f, -0.11299450f, -0.03031612f, -0.08852437f, 0.07711087f, -0.02337189f, 0.15156537f, 
    0.02836128f, 0.05118102f, 0.06672312f, 0.15765736f, -0.04991550f, -0.36805502f, 0.16410792f, 0.17784759f, 
    -0.13358231f, 0.02697609f, -0.05571140f, -0.09232644f, -0.05141393f, 0.11685675f, 0.03062334f, 0.00589751f, 
    -0.05148669f, 0.19276772f, 0.05235381f, 0.03916287f, 0.04583596f, 0.10488460f, -0.03952019f, 0.02715964f, 
    -0.12254350f, 0.05899214f, 0.24977434f, -0.02794825f, 0.08472020f, -0.02265767f, -0.09459745f, -0.09040722f, 
    -0.17180286f, 0.03005979f, 0.08021852f, 0.00585111f, 0.06169231f, 0.18229216f, -0.04646479f, -0.06724566f, 
    0.05572588f, 0.09364740f, -0.04631500f, 0.08063479f, 0.09415299f, 0.08620509f, 0.10720415f, -0.17328872f, 
    -0.11508360f, -0.05054728f, -0.01245854f, -0.01449998f, 0.05921400f, -0.03342672f, -0.07508956f, -0.03946494f, 
    0.04717642f, -0.10279183f, -0.14969188f, -0.05533423f, -0.08723404f, -0.06733191f, -0.12874493f, -0.14298877f, 
    0.12078159f, 0.13618660f, -0.00461680f, -0.00560147f, 0.07794553f, -0.03961932f, 0.06358057f, 0.02583036f, 
    0.10741884f, 0.06090974f, 0.09117810f, 0.07934159f, 0.05123929f, -0.05283218f, 0.03341696f, 0.05516772f, 
    -0.04114226f, 0.00545453f, -0.02844133f, -0.02114139f, 0.07798707f, 0.13402708f, 0.04939604f, -0.10868061f, 
    0.03084518f, -0.06524218f, -0.06741437f, -0.09452031f, 0.05237667f, -0.00468914f, 0.09971187f, -0.05038308f, 
    0.00563904f, 0.01193215f, 0.06598670f, 0.03358963f, -0.09322371f, -0.11177106f, -0.16910107f, -0.10843890f, 
    -0.29084033f, -0.33966002f, -0.05336334f, -0.00112947f, 0.07165410f, 0.07517090f, -0.01635638f, 0.01510674f, 
    -0.10480949f, 0.00208566f, -0.01663057f, 0.05413055f, 0.03496904f, 0.12985000f, 0.02776796f, 0.06419858f, 
    0.18699218f, 0.06653967f, 0.02309851f, 0.01501617f, -0.12452895f, -0.06152061f, -0.05550344f, -0.08169577f, 
    0.03145806f, -0.02482691f, -0.03036808f, 0.00546122f, 0.05627581f, -0.08511594f, -0.00331629f, -0.05661223f, 
    -0.04923648f, -0.01456994f, -0.06193610f, 0.02536161f, -0.07835300f, -0.03089242f, -0.23219688f, -0.14903794f, 
    -0.28533813f, 0.01563685f, -0.06743331f, -0.04709431f, 0.24125165f, 0.04813676f, -0.03110540f, 0.27506572f, 
    -0.03985869f, -0.03732852f, -0.02398701f, -0.10506697f, -0.25786445f, -0.13960274f, 0.02284527f, 0.12866338f, 
    -0.07828805f, 0.02757666f, 0.12086068f, -0.12783134f, -0.13216862f, -0.02283677f, 0.10225312f, 0.10717936f, 
    0.17634489f, 0.04840820f, -0.15600939f, -0.02637401f, -0.04858162f, -0.05732213f, -0.04356259f, 0.07714327f, 
    -0.01430990f, 0.01668311f, 0.01860558f, 0.06978535f, -0.00535535f, 0.02190913f, -0.07747497f, -0.15865688f, 
    0.40405935f, 0.15440516f, -0.02138879f, -0.04493514f, 0.05676166f, -0.00487437f, -0.13593917f, -0.08570974f, 
    0.22873494f, -0.12262718f, -0.15644678f, 0.10165525f, -0.06470637f, -0.20062630f, 0.01942277f, 0.24068391f, 
    0.06236435f, 0.00042768f, -0.09565333f, -0.05582811f, -0.01411066f, 0.69331294f, -0.00088003f, -0.07110292f, 
    -0.10694893f, 0.12649988f, -0.02392524f, 0.05514338f, 0.21998259f, 0.13546051f, -0.06882838f, -0.08936728f, 
    0.00327996f, -0.01598188f, -0.08943875f, -0.00866489f, -0.27904242f, -0.06510478f, -0.10551494f, 0.01205471f, 
    -0.01170483f, -0.22341831f, -0.13289496f, 0.00601415f, -0.41238770f, -0.05958797f, -0.05052613f, 0.03057189f, 
    0.02034408f, -0.02450765f, -0.01873592f, -0.03486957f, -0.00152634f, 0.02135746f, -0.00485482f, -0.05186736f, 
    0.01903062f, 0.15143597f, 0.02622373f, 0.00793247f, 0.22937565f, 0.14806898f, 0.14851053f, -0.01482267f, 
    0.17810018f, 0.05738524f, 0.10662325f, -0.00753015f, 0.04488661f, 0.02450663f, 0.02246207f, -0.08055906f, 
    0.07652050f, 0.02832181f, -0.04637441f, 0.02703432f, 0.14583653f, -0.02957631f, -0.02704719f, -0.00401200f, 
    -0.77262497f, -0.10012513f, 0.34043741f, -0.29402626f, -0.21913952f, 0.02255959f, -0.02642357f, 0.14390679f, 
    0.00737126f, -0.21608822f, 0.09252154f, -0.04930069f, -0.27250582f, -0.12591380f, -0.00883360f, 0.16030715f, 
    -0.08032034f, 0.04981801f, -0.05582606f, -0.08884368f, 0.40611112f, 0.18193007f, 0.07787554f, 0.18868242f, 
    0.27732533f, 0.00478853f, -0.10146018f, 0.04775239f, 0.06979667f, 0.02059991f, 0.01849638f, 0.01137586f, 
    -0.00897603f, 0.01946746f, 0.01652181f, 0.07181963f, -0.01364016f, 0.09792581f, 0.12468512f, 0.08325050f, 
    -0.04142673f, 0.03238774f, 0.42394066f, 0.07476105f, 0.01855444f, 0.04447234f, -0.04305837f, -0.11989768f, 
    -0.05615178f, -0.04318195f, 0.06105082f, -0.08013254f, -0.09848595f, 0.06346203f, -0.08298340f, 0.17544910f, 
    0.13104416f, 0.02219396f, -0.01969681f, 0.07676337f, -0.19803421f, -0.15571700f, 0.06918866f, -0.24896508f, 
    -0.29383373f, 0.09367017f, -0.03553026f, 0.10032378f, 0.06458476f, 0.00055211f, 0.03693118f, 0.01282435f, 
    -0.12663187f, 0.03983359f, 0.04332521f, -0.03554152f, -0.10861013f, -0.01139377f, -0.02227984f, 0.07139021f, 
    0.10334119f, 0.20615448f, -0.08469199f, 0.11597767f, 0.15443847f, 0.06340235f, 0.01363468f, -0.06445693f, 
    0.16243227f, 0.18962024f, 0.06882241f, -0.05214743f, -0.05343053f, 0.02642732f, -0.10365492f, -0.00033236f, 
    0.07124150f, -0.03197062f, 0.04642929f, 0.11184037f, 0.02369253f, -0.24799088f, -0.18684183f, 0.04045513f, 
    0.09723639f, 0.21905723f, 0.02409618f, -0.03782415f, -0.08716242f, -0.11745942f, -0.06692999f, 0.12819202f, 
    0.01679429f, 0.13780923f, -0.00564107f, 0.12956150f, -0.02886325f, 0.23190668f, 0.09773824f, -0.04328254f, 
    -0.21724784f, 0.11457100f, -0.30628178f, -0.52983904f, -0.00895358f, 0.03520717f, 0.05125880f, 0.06183220f, 
    -0.06066394f, 0.24677975f, -0.12792632f, 0.14593519f, 0.14387830f, 0.11087676f, 0.01651619f, 0.04239811f, 
    -0.13013904f, 0.12719066f, -0.11639479f, 0.11564071f, -0.09068602f, -0.27242357f, -0.18552922f, -0.27979067f, 
    -0.23183797f, 0.07460269f, 0.02795548f, 0.12828903f, 0.08447172f, 0.21066913f, -0.04182065f, 0.02169551f, 
    -0.00969899f, -0.00353774f, -0.05029066f, -0.10533652f, -0.02112943f, -0.09717017f, -0.17662577f, 0.26305988f, 
    -0.32972491f, -0.78450519f, -0.25855184f, -0.17404452f, -0.61214799f, -0.06336085f, -0.11892207f, 0.09334341f, 
    -0.01010590f, -0.22744130f, -0.02621552f, 0.02305447f, -0.00118874f, 0.06709111f, 0.07887413f, -0.07814302f, 
    0.01982800f, 0.06899888f, -0.03663579f, 0.00609246f, 0.42310625f, -0.18594819f, -0.14969611f, -0.41704333f, 
    -0.50477588f, 0.22311920f, -0.02310635f, -0.05323481f, 0.06453799f, 0.31283078f, 0.21997817f, 0.14078739f, 
    0.03215414f, -0.08586503f, -0.16099142f, -0.12221245f, 0.08256934f, -0.13127227f, 0.16578899f, 0.14420831f, 
    0.10665543f, 0.07742051f, -0.09223243f, 0.24450658f, 0.10186677f, -0.12717885f, 0.05027632f, -0.07192484f, 
    -0.20838274f, 0.06654445f, -0.11667986f, 0.03318601f, 0.00299928f, 0.05357105f, -0.07516328f, -0.09775152f, 
    0.00442883f, -0.10055995f, 0.05781121f, -0.00519270f, -0.19956808f, -0.22548105f, 0.06311410f, -0.09006079f, 
    -0.18451585f, 0.00669367f, -0.24083871f, -0.03583740f, -0.05444872f, -0.45489538f, -0.00450227f, -0.09535876f, 
    -0.16721711f, 0.08509134f, 0.15400590f, 0.15537156f, 0.04689977f, 0.07866893f, -0.02789518f, -0.28509569f, 
    -0.07771171f, -0.04167155f, 0.14223719f, 0.03108771f, 0.00822918f, 0.00223872f, -0.02226990f, -0.05873542f, 
    -0.08447368f, 0.21470445f, 0.00197232f, -0.14013773f, -0.12783423f, 0.15690334f, -0.09592253f, -0.01945724f, 
    0.08765570f, 0.19121298f, 0.08554395f, -0.08094572f, -0.19872756f, 0.01942921f, 0.12114780f, -0.10197599f, 
    0.10602095f, 0.02682959f, 0.00240677f, -0.16949305f, -0.08446047f, 0.03248184f, -0.08113100f, 0.00463033f, 
    -0.08331091f, 0.17992258f, -0.13700163f, 0.03519143f, 0.19245411f, 0.04115358f, 0.07582353f, -0.04107632f, 
    -0.69033533f, -0.22460413f, -0.21613833f, -0.04549050f, -0.56641716f, -0.11464581f, -0.01206550f, 0.00734966f, 
    -0.03879882f, 0.01240998f, 0.02015997f, -0.00201409f, 0.04230376f, -0.01697228f, 0.11794534f, 0.14657173f, 
    0.01269742f, 0.01248184f, -0.05389155f, 0.06882205f, 0.19418125f, 0.03703182f, -0.01569668f, 0.12442491f, 
    0.26115623f, -0.02417574f, -0.08654187f, -0.05006885f, 0.01742427f, -0.03784925f, 0.11642925f, 0.03339065f, 
    -0.03411250f, 0.09180171f, -0.04927398f, -0.09610277f, 0.10951563f, -0.13719386f, 0.03033044f, 0.02316833f, 
    0.15035416f, -0.09619492f, 0.10116230f, 0.22018740f, 0.21150765f, -0.10462370f, -0.05833475f, 0.05586759f, 
    -0.02149028f, -0.04536101f, 0.00779691f, 0.04340898f, 0.01378216f, -0.08805180f, -0.03514626f, 0.00614513f, 
    0.06153384f, -0.00507318f, 0.04130868f, 0.01202242f, 0.19599670f, 0.03400262f, 0.12224032f, 0.22398151f, 
    0.28637397f, -0.05785374f, -0.13206670f, 0.04786209f, 0.04442265f, -0.02814611f, 0.04245133f, -0.02409042f, 
    -0.08169769f, -0.01853460f, 0.00524243f, 0.05963653f, 0.06907706f, 0.10889832f, -0.03481796f, 0.00541139f, 
    -0.56030595f, -0.11411434f, -0.51773387f, -0.02490264f, -0.22599225f, -0.14653730f, -0.00905313f, 0.00345092f, 
    -0.13928601f, -0.02940592f, 0.06648718f, -0.05569548f, 0.11265206f, 0.03540236f, 0.00782418f, 0.01750525f, 
    -0.05146227f, 0.04099547f, -0.03445179f, 0.10893913f, -0.38906536f, 0.21972489f, -0.92772079f, -0.09094100f, 
    -0.15894604f, 0.08560001f, 0.04310263f, -0.06022927f, -0.09040929f, 0.03186234f, -0.00872679f, 0.02695979f, 
    0.01951765f, -0.01929053f, 0.06216171f, 0.14881675f, -0.08245138f, 0.01316932f, 0.02003929f, 0.11145982f, 
    0.10299528f, 0.00458041f, 0.10186141f, 0.14360310f, 0.07742482f, 0.00148271f, -0.05707600f, -0.09063178f, 
    -0.06731597f, -0.18457682f, 0.05409229f, -0.19184905f, -0.23989347f, -0.05483050f, -0.04069282f, 0.07774791f, 
    0.08891729f, 0.02641241f, 0.10026184f, -0.09711788f, 0.04992945f, -0.00374546f, 0.01837401f, 0.18172586f, 
    0.20395996f, -0.04555188f, -0.17656450f, -0.01561980f, -0.02056493f, -0.07406714f, 0.04707247f, 0.08374237f, 
    0.02801386f, 0.00931185f, 0.08610675f, 0.03966640f, 0.06524912f, -0.00558632f, -0.05605268f, -0.05396897f, 
    -0.04435760f, 0.15640768f, -0.05384531f, 0.22817385f, 0.15085714f, 0.03713685f, -0.01455117f, 0.08727936f, 
    -0.12821646f, 0.11068403f, -0.06745402f, 0.00163141f, -0.05614026f, 0.10037984f, -0.01035519f, 0.16610694f, 
    0.08190963f, -0.05213522f, 0.10663674f, -0.01105086f, -0.00806987f, -0.02039960f, 0.04354778f, 0.06089769f, 
    -0.01306967f, 0.01557932f, -0.09749971f, -0.00877408f, -0.08278071f, 0.00582783f, -0.00863774f, 0.04103715f, 
    0.03320941f, 0.00226613f, 0.01510908f, -0.01530828f, -0.02766710f, 0.03298553f, 0.03000551f, -0.07342138f, 
    -0.60074890f, 0.25729665f, -0.33170921f, -0.02887304f, -0.47642633f, -0.01982166f, -0.01152112f, -0.17224649f, 
    -0.11725070f, 0.03491799f, 0.06873045f, -0.11087067f, 0.03324216f, -0.04392203f, -0.00493396f, 0.12217285f, 
    0.07030188f, 0.09224116f, -0.03622685f, 0.07876942f, -0.03123375f, -0.03153997f, 0.12071500f, 0.05542909f, 
    0.07190517f, 0.02706873f, -0.04357602f, -0.14468877f, -0.04118052f, 0.10833295f, 0.07433823f, -0.13753580f, 
    0.03645187f, 0.05123373f, -0.09553228f, -0.07454827f, 0.01611744f, -0.08376338f, -0.17300384f, -0.01993634f, 
    -0.03757602f, 0.00362171f, -0.00634584f, 0.00227513f, -0.00162524f, -0.03492236f, -0.02606489f, 0.02723739f, 
    -0.04038295f, -0.00273018f, -0.01787764f, 0.02157430f, -0.00362539f, -0.03495323f, -0.01371371f, 0.02181884f, 
    -0.01503947f, 0.01658223f, -0.00662530f, 0.02528485f, -0.01580229f, 0.02928797f, 0.01824133f, -0.03524254f, 
    0.00244414f, 0.03218405f, 0.03505065f, -0.00221476f, 0.00952251f, 0.00540410f, 0.00592442f, 0.03823061f, 
    -0.03060981f, -0.02622659f, 0.00954394f, -0.03186453f, -0.01312953f, -0.03967034f, 0.03247756f, -0.00377292f, 
    -0.01319797f, -0.00967534f, 0.01622687f, -0.04444711f, -0.00287270f, -0.02134765f, -0.01908384f, 0.02426887f, 
    -0.03861875f, -0.01816009f, -0.04237693f, 0.01689490f, -0.01377615f, -0.00651342f, -0.02086510f, 0.03198002f, 
    0.01195186f, -0.02394239f, -0.00654099f, -0.01449331f, 0.04095981f, 0.03099427f, -0.01357703f, 0.00931649f, 
    -0.01922370f, -0.03088511f, -0.00135830f, -0.03123709f, 0.02782289f, 0.00848920f, 0.00698759f, 0.00374887f, 
    0.02209262f, 0.00452504f, 0.02366839f, 0.01280829f, -0.01912285f, -0.01205864f, -0.03275443f, 0.02775173f, 
    0.02237611f, 0.00622305f, 0.03177385f, -0.04174931f, 0.03519350f, 0.02596176f, 0.01796797f, -0.02263737f, 
    -0.01978093f, -0.00320931f, -0.02836621f, 0.00906749f, -0.00426267f, 0.01253001f, -0.02648001f, -0.01525459f, 
    -0.02773196f, 0.01772671f, -0.00561820f, -0.01802750f, -0.01409215f, 0.03376185f, 0.00089669f, -0.03056863f, 
    0.02672071f, 0.01607545f, 0.00179756f, 0.00677817f, 0.00702839f, -0.00167019f, 0.02672812f, 0.02088118f, 
    0.03458165f, 0.02328640f, -0.01034090f, 0.02832668f, 0.00238449f, 0.03115796f, -0.00505053f, -0.00683372f, 
    0.01216518f, -0.00186001f, 0.03000894f, -0.01314770f, -0.00114055f, -0.01326940f, -0.01596201f, -0.02486952f, 
    -0.03867433f, -0.04193255f, 0.03505120f, -0.02833755f, 0.00111207f, -0.02212400f, -0.03623136f, 0.01520295f, 
    -0.02433497f, 0.02187717f, -0.02155019f, -0.01634919f, -0.01298214f, -0.02509832f, 0.01526905f, -0.00014304f, 
    -0.00673103f, -0.01413514f, -0.02755270f, -0.01748751f, -0.00711324f, 0.03271157f, -0.01563318f, -0.01511396f, 
    -0.03432106f, -0.01450484f, -0.00303722f, -0.03032713f, 0.00496627f, -0.00353135f, -0.00898839f, -0.04285472f, 
    0.00194866f, 0.01005629f, -0.04042192f, -0.00918978f, 0.03372421f, -0.03932906f, 0.03602540f, -0.04441440f, 
    0.01812307f, 0.01860499f, 0.01191727f, 0.01479432f, 0.02596354f, 0.03193777f, -0.00455435f, 0.03295729f, 
    0.01737577f, -0.01239584f, 0.00553598f, 0.00334374f, 0.03461821f, -0.00955251f, 0.00272812f, -0.03714696f, 
    -0.02114622f, -0.00905448f, 0.02311651f, -0.01534504f, 0.00628727f, 0.00721812f, -0.02882970f, 0.01632393f, 
    -0.03309717f, 0.02004360f, -0.02400582f, 0.02892301f, 0.02549916f, -0.00320493f, -0.01939343f, 0.02034513f, 
    -0.02667735f, 0.01567183f, 0.03148948f, 0.02324572f, -0.04557489f, -0.01147978f, -0.00127373f, 0.02921502f, 
    -0.02948792f, -0.03043202f, 0.02955100f, 0.02701507f, -0.02743172f, -0.00440869f, 0.01639727f, -0.03420809f, 
    0.03363002f, 0.02735063f, -0.03346352f, -0.04146617f, 0.00224820f, 0.03482779f, -0.02166518f, -0.01377957f, 
    -0.04384787f, -0.03575628f, 0.01006487f, -0.03913980f, -0.01373950f, -0.01283260f, -0.00027688f, 0.01498130f, 
    -0.03418156f, 0.00095144f, 0.02575139f, 0.02091655f, -0.03455395f, -0.00591581f, 0.02441202f, 0.02071700f, 
    0.01849750f, -0.00000359f, -0.01680391f, 0.03269911f, -0.02604045f, 0.01116660f, -0.01728685f, 0.00920521f, 
    0.03965662f, -0.00518975f, 0.00150008f, 0.02049311f, -0.02284327f, 0.03081511f, -0.01812137f, -0.00433837f, 
    -0.01033883f, -0.04137562f, 0.01678162f, 0.00183172f, -0.02432808f, -0.02706677f, -0.02439519f, 0.00581462f, 
    -0.03168232f, 0.00501612f, 0.00596435f, 0.02680434f, -0.02571297f, -0.01317198f, 0.01974405f, -0.01343065f, 
    -0.04380269f, -0.01665578f, -0.01321296f, -0.00265761f, -0.02106709f, 0.03774721f, 0.00836224f, -0.02613978f, 
    -0.04140296f, 0.00572593f, -0.00489604f, -0.01581674f, -0.01369284f, -0.03145912f, 0.00957953f, 0.03270383f, 
    -0.04419741f, -0.00838105f, 0.01785716f, -0.01175172f, 0.00061066f, 0.03170786f, -0.03848221f, 0.00221509f, 
    0.01688575f, -0.02305201f, -0.00701864f, -0.02796921f, -0.03300154f, -0.03168543f, 0.03543591f, 0.03228843f, 
    0.00447987f, -0.03334399f, 0.03269295f, 0.02171293f, -0.00117914f, 0.01036530f, -0.01594177f, 0.02202353f, 
    -0.00020646f, 0.02161372f, 0.00056356f, 0.02144166f, -0.04014176f, -0.02196703f, -0.03033011f, 0.01565225f, 
    -0.02774033f, 0.00316487f, 0.01488671f, -0.03679971f, 0.02151690f, -0.00070959f, 0.04271311f, 0.00536874f, 
    -0.00447840f, 0.01142810f, 0.02498862f, -0.01662508f, -0.03945386f, 0.01776242f, 0.02236905f, 0.04241547f, 
    -0.03206153f, -0.02839231f, -0.02767908f, 0.04703761f, 0.02673849f, -0.01629841f, -0.00673314f, -0.01492922f, 
    0.00743715f, 0.02092796f, -0.03245360f, 0.02224793f, 0.02884093f, 0.02374166f, -0.03730393f, -0.04440587f, 
    -0.00602849f, -0.01725553f, 0.01979510f, 0.03183554f, -0.01536803f, 0.01973226f, -0.03658537f, -0.02523703f, 
    -0.02938893f, -0.02506487f, -0.00829241f, 0.02948717f, 0.02847718f, 0.01031949f, -0.00296549f, 0.01898027f, 
    0.01611584f, 0.02965838f, 0.00669897f, -0.02807394f, -0.03914144f, -0.00988105f, 0.01454154f, 0.00162637f, 
    -0.00812135f, -0.01488683f, -0.01594367f, -0.03022831f, -0.00595460f, 0.03024944f, -0.01970801f, -0.01596612f, 
    -0.02628992f, 0.04065421f, 0.00635666f, -0.03011860f, -0.02318549f, 0.01073797f, -0.01096269f, 0.01736207f, 
    -0.00723185f, -0.01846817f, 0.00883862f, 0.00730417f, -0.03016321f, 0.02255943f, 0.00690252f, -0.00303307f, 
    -0.02034330f, -0.03269107f, -0.03966725f, -0.01276321f, 0.03155906f, -0.01349667f, -0.02324586f, 0.03028628f, 
    0.02380129f, 0.02852230f, -0.00345124f, -0.01738827f, -0.00602704f, 0.01287408f, 0.00640144f, -0.00400858f, 
    0.03540787f, 0.00910487f, 0.01684886f, 0.00091446f, -0.01237871f, 0.03249067f, -0.01576855f, 0.03280557f, 
    -0.02632760f, 0.00016299f, 0.03026701f, 0.01235540f, -0.03774835f, -0.03169434f, -0.02470130f, -0.00874453f, 
    0.01569550f, -0.02243369f, -0.01154290f, -0.00673457f, 0.03113502f, -0.00268724f, -0.02764540f, -0.01823273f, 
    -0.03574030f, 0.01581854f, 0.01681955f, 0.02816297f, -0.00656261f, -0.00002162f, -0.02854933f, 0.01552045f, 
    -0.01897077f, 0.00969567f, -0.02829544f, -0.00949038f, -0.03179937f, 0.01376566f, 0.02692683f, 0.03243659f, 
    -0.02176421f, 0.00740478f, 0.01327740f, -0.01560241f, -0.02207659f, -0.04389056f, -0.02575973f, -0.02943787f, 
    -0.03513358f, -0.03757410f, 0.00165877f, -0.04031193f, 0.02701523f, -0.00079214f, -0.00542528f, 0.01142492f, 
    0.02171557f, -0.01784772f, -0.03723653f, -0.01954957f, -0.04206764f, -0.01672014f, -0.03534774f, -0.01119520f, 
    0.02347659f, -0.03781528f, -0.03064333f, -0.01036791f, -0.03623448f, 0.02031436f, 0.01529244f, -0.04360843f, 
    -0.02240933f, 0.04514508f, -0.01106122f, -0.01037563f, -0.01776533f, 0.01757839f, 0.02904153f, -0.01556866f, 
    0.02621499f, -0.03775360f, -0.01876806f, -0.02557604f, 0.00794781f, 0.03303270f, 0.01118538f, 0.02146833f, 
    -0.04000840f, 0.02300628f, -0.02699163f, 0.03217293f, -0.02302180f, -0.02504830f, -0.02057964f, -0.01909189f, 
    -0.00526920f, 0.01255207f, 0.03157768f, 0.01064634f, -0.01603657f, 0.00024336f, -0.03633911f, 0.01788206f, 
    0.02445169f, -0.02997707f, -0.00916789f, 0.02425633f, 0.03323766f, -0.02072218f, -0.02203935f, 0.03466477f, 
    -0.03678480f, -0.00601507f, -0.03749354f, -0.03953055f, -0.04461785f, -0.03975651f, -0.00620355f, -0.04048973f, 
    -0.00463822f, -0.01440848f, -0.00516680f, -0.03019227f, 0.00437346f, -0.04247138f, -0.01655557f, -0.00964305f, 
    -0.02406618f, -0.00713684f, 0.00147657f, -0.00922153f, -0.03173487f, -0.01392765f, -0.04215124f, -0.02503803f, 
    0.03758772f, 0.00716480f, 0.01819267f, -0.03954268f, 0.03210038f, -0.00919575f, -0.03962714f, -0.01964274f, 
    -0.01533372f, -0.02870903f, -0.01415333f, 0.02449987f, -0.00997759f, 0.01512900f, 0.02661457f, 0.01528025f, 
    -0.00140575f, 0.02574010f, -0.04082430f, 0.02146562f, 0.00264262f, 0.00727624f, 0.01219106f, 0.00246008f, 
    -0.03238378f, 0.02238877f, -0.02379271f, 0.02284669f, -0.04233094f, -0.02015619f, -0.00866723f, -0.02326948f, 
    -0.02482621f, 0.01858372f, 0.02276879f, -0.03333890f, 0.00093020f, 0.01431101f, -0.02928191f, -0.01210279f, 
    0.00731976f, 0.00402080f, -0.02840409f, 0.01709292f, 0.02732682f, -0.01535728f, -0.00840607f, 0.01758831f, 
    -0.04538478f, 0.03013586f, 0.02190184f, -0.03412429f, 0.02757070f, -0.04249155f, 0.01806151f, -0.00186053f, 
    -0.00488473f, -0.01101209f, -0.00842935f, -0.00343731f, -0.02089600f, -0.02679975f, 0.01430650f, -0.00417472f, 
    -0.01264515f, 0.00003678f, -0.03082525f, 0.03242663f, 0.03438800f, 0.02970133f, -0.01770377f, -0.02397293f, 
    0.03253627f, 0.03021299f, 0.00156982f, -0.04437500f, 0.01188968f, 0.01351804f, 0.00642485f, -0.00911409f, 
    0.02593767f, 0.00042139f, -0.04262111f, 0.02509979f, -0.01390653f, 0.03325891f, -0.02116958f, -0.01546707f, 
    0.01374150f, 0.02142538f, 0.02570733f, 0.00256395f, 0.01474901f, -0.03834614f, -0.02326881f, -0.03932583f, 
    -0.01866405f, 0.03260028f, -0.02043344f, -0.02897294f, 0.00982159f, 0.02964129f, 0.02572193f, -0.03157222f, 
    -0.04189080f, -0.00843095f, 0.03244497f, 0.02046212f, -0.00189569f, -0.02977616f, 0.00688661f, 0.02827717f, 
    0.03104536f, -0.00714019f, 0.00086847f, 0.02486824f, -0.00195067f, -0.01917254f, -0.00139003f, 0.00855098f, 
    -0.00521515f, -0.04114789f, 0.02987687f, 0.02236928f, 0.02352283f, -0.03170790f, -0.00314083f, 0.02381823f, 
    -0.03630216f, 0.01698853f, 0.01669325f, 0.00762277f, 0.02281566f, -0.04310239f, -0.03602736f, 0.01839610f, 
    0.00507098f, 0.01418624f, 0.02063663f, 0.01195714f, -0.02393010f, -0.01478643f, -0.03033021f, 0.03348560f, 
    -0.03731673f, -0.00908439f, -0.00208806f, -0.00336693f, 0.02211688f, -0.01021209f, -0.01111672f, 0.01109462f, 
    -0.02257901f, 0.02813909f, 0.01015945f, -0.02118043f, -0.02904990f, -0.01200239f, -0.01986522f, -0.02943564f, 
    -0.00156017f, 0.00326338f, -0.03831673f, -0.01065395f, 0.00914495f, -0.04287634f, 0.00044354f, 0.00997265f, 
    0.01166645f, -0.02012556f, -0.00498884f, -0.01004410f, -0.01174372f, 0.00553293f, -0.04495148f, -0.02795611f, 
    0.01542570f, -0.04021906f, 0.01983761f, 0.00121705f, -0.00882017f, -0.04382259f, -0.01188357f, -0.01402141f, 
    -0.04221981f, 0.01934594f, 0.00589821f, 0.00893239f, -0.00681710f, -0.00152206f, -0.04376015f, -0.02712228f, 
    -0.01732181f, -0.01414749f, -0.01258284f, -0.03933069f, 0.00195282f, 0.00846581f, -0.03726100f, -0.01676997f, 
    0.00943430f, -0.00273892f, -0.04461989f, -0.03006997f, -0.01296364f, 0.02831418f, -0.02990478f, -0.01593795f, 
    0.00009879f, 0.00394559f, 0.02989703f, 0.02696713f, 0.02237436f, 0.02256810f, -0.03512939f, -0.00844525f, 
    -0.03194865f, 0.01063792f, -0.00756093f, 0.00888991f, -0.03751382f, -0.00950676f, 0.03081662f, 0.01922921f, 
    -0.01383712f, -0.01655694f, -0.03419058f, -0.02212190f, -0.03523503f, 0.02134751f, -0.01438251f, -0.01893399f, 
    0.02712072f, 0.03038184f, -0.00079275f, -0.04102719f, -0.03717862f, 0.01806836f, 0.00181252f, 0.01144026f, 
    -0.01509472f, 0.02290033f, -0.03947343f, 0.01297390f, -0.01284352f, -0.03291495f, -0.03966198f, 0.00804717f, 
    -0.03878827f, 0.00186159f, -0.01448052f, 0.01978857f, -0.04489900f, -0.01211741f, 0.02390920f, 0.00494059f, 
    -0.01490969f, 0.02044737f, -0.02859884f, 0.02272079f, -0.04191744f, 0.00735099f, 0.00748919f, -0.00573407f, 
    -0.00799563f, 0.00736335f, 0.01452691f, -0.01143534f, -0.01488914f, -0.03550583f, -0.00507001f, -0.04544406f, 
    0.03368863f, -0.00667953f, -0.02447935f, -0.00857782f, -0.03455060f, -0.01157050f, 0.02649211f, -0.02717617f, 
    0.02855965f, -0.02288288f, -0.00898009f, -0.01166324f, 0.02782706f, 0.02088483f, 0.00386298f, 0.03173841f, 
    0.01267418f, -0.00481804f, 0.01474200f, -0.01629069f, -0.03976480f, -0.01242421f, 0.01045507f, 0.01148553f, 
    0.00628211f, -0.04550874f, -0.01231160f, 0.00896305f, -0.04310822f, -0.03790300f, -0.03510125f, -0.03641402f, 
    0.00537704f, -0.00065730f, -0.01296875f, -0.02419986f, -0.01958735f, -0.00556642f, 0.00284147f, -0.00496395f, 
    -0.00911950f, -0.03739449f, 0.00700702f, 0.01952399f, 0.00465003f, -0.03351806f, 0.02412134f, -0.02859166f, 
    0.01146010f, 0.01029024f, 0.02515745f, 0.00713255f, -0.01928105f, -0.02123844f, -0.02590497f, 0.00777510f, 
    -0.02351454f, -0.03193250f, -0.03664292f, 0.00177500f, 0.01203643f, -0.03907263f, 0.03259333f, 0.03061574f, 
    0.02980128f, 0.02252138f, 0.02605735f, 0.01765702f, -0.04158532f, -0.02051950f, 0.00967060f, -0.01789052f, 
    0.00229417f, 0.01630893f, -0.04203893f, -0.04147509f, 0.03645263f, 0.04184644f, 0.03532422f, 0.03056649f, 
    0.01677199f, -0.02776676f, -0.04043954f, -0.03651698f, 0.02694548f, -0.03148604f, 0.02581907f, 0.01914439f, 
    0.01757819f, -0.01551069f, 0.01113004f, -0.02869751f, 0.02708110f, -0.03216371f, -0.04200305f, 0.00722298f, 
    -0.01962912f, 0.02198904f, -0.00654397f, 0.03637224f, 0.02808367f, 0.02359323f, -0.03976593f, 0.02677467f, 
    0.03162587f, 0.03349712f, 0.03295542f, 0.00011900f, -0.02947555f, -0.00513172f, 0.00756240f, 0.00811158f, 
    -0.04221905f, -0.00471700f, 0.00116349f, 0.01155310f, 0.03061666f, 0.00171198f, -0.03672377f, -0.00398487f, 
    -0.04329795f, -0.01256934f, -0.02874725f, 0.02181578f, 0.02508314f, 0.00842372f, 0.02519771f, -0.02258225f, 
    0.01392030f, -0.00488896f, -0.04374054f, 0.00824542f, -0.02067135f, -0.00969986f, -0.03923890f, 0.01669040f, 
    -0.03059239f, 0.01759720f, 0.03146515f, -0.01524993f, -0.03009277f, -0.03678623f, 0.02592197f, -0.01294733f, 
    0.02156868f, -0.02161942f, 0.02544686f, 0.02891777f, 0.01414224f, -0.00657258f, -0.01485689f, 0.01378757f, 
    -0.01534452f, -0.02757787f, 0.00454009f, 0.02703999f, -0.01452449f, 0.02451473f, -0.02362919f, -0.01513130f, 
    0.04073492f, -0.04212614f, 0.02675293f, -0.02329501f, -0.02625368f, -0.00784964f, -0.01039074f, 0.01924224f, 
    -0.00764848f, -0.03960651f, -0.04149890f, 0.01452417f, -0.02987208f, 0.02649399f, -0.00354307f, 0.00423485f, 
    -0.04409679f, -0.03183148f, 0.02748388f, 0.02637202f, 0.00118670f, -0.02480260f, -0.04339877f, -0.00155174f, 
    0.00587186f, 0.02755008f, -0.02770622f, -0.03541077f, -0.00930002f, 0.01459111f, 0.02233830f, 0.01605506f, 
    0.03043869f, -0.00237001f, -0.02051245f, 0.02654786f, 0.01568604f, -0.02356754f, -0.00544782f, 0.00264483f, 
    0.00084266f, -0.03159883f, 0.02917014f, -0.04228283f, -0.03328996f, 0.00788085f, 0.01845965f, 0.02979511f, 
    -0.01514979f, 0.01596412f, -0.01256720f, 0.00603177f, 0.02519596f, -0.03651389f, -0.00896531f, -0.02151676f, 
    -0.01857476f, -0.01680955f, -0.01328880f, 0.00491804f, -0.00686785f, -0.04356134f, 0.01021283f, 0.00613125f, 
    -0.00341141f, 0.02468028f, 0.00932886f, -0.04085117f, 0.01874628f, -0.04331640f, -0.00513737f, 0.01489597f, 
    0.01037843f, 0.00955123f, -0.00119450f, -0.02335487f, 0.02630720f, -0.02144049f, 0.02380580f, -0.03020694f, 
    0.01972160f, 0.01131695f, 0.02716072f, -0.00510747f, 0.03203896f, 0.03991782f, -0.03818854f, -0.04297000f, 
    -0.04254368f, -0.01896723f, -0.01493771f, 0.02283770f, 0.01894348f, 0.03010797f, -0.03702397f, -0.01049254f, 
    0.01097689f, -0.03488612f, -0.00565348f, 0.02169038f, -0.01312132f, 0.02947385f, 0.02829387f, 0.00914999f, 
    0.02945020f, -0.03127509f, 0.00623908f, -0.02829594f, 0.01680884f, -0.01620388f, -0.02741377f, -0.02286069f, 
    0.01156751f, -0.04279771f, -0.00324285f, 0.01478956f, -0.00544480f, -0.04448392f, 0.01019509f, -0.01038469f, 
    -0.04339097f, 0.03129357f, -0.03577838f, 0.02175389f, 0.00058862f, -0.01858371f, -0.02794499f, -0.00931364f, 
    0.02363234f, -0.00410417f, 0.03190690f, -0.02758665f, 0.01183204f, 0.02595361f, -0.03844532f, -0.03032329f, 
    0.02991378f, -0.03841791f, 0.03018391f, -0.02262110f, 0.04388039f, 0.02600080f, 0.02290683f, 0.03347094f, 
    0.01972512f, 0.00109924f, -0.01783655f, -0.01280261f, -0.01562895f, -0.04527831f, 0.01024452f, 0.00250647f, 
    -0.04014301f, 0.02599559f, -0.01535734f, -0.01619869f, -0.02655078f, -0.04521525f, -0.00051769f, 0.01077090f, 
    0.00589564f, -0.03298115f, -0.03412388f, 0.00786975f, -0.03123954f, -0.02013740f, -0.03810268f, -0.01061160f, 
    -0.00770045f, -0.01778845f, -0.01129284f, -0.03787239f, -0.02861088f, 0.01405238f, -0.00744672f, 0.02675435f, 
    0.01042161f, -0.04393759f, -0.02866942f, 0.00658130f, 0.02605361f, -0.01896874f, -0.00854333f, -0.02355665f, 
    0.02638058f, -0.00938029f, 0.02032903f, -0.02154516f, -0.01283053f, 0.01854526f, -0.02562749f, 0.00321089f, 
    -0.02192702f, -0.03284293f, 0.01373594f, -0.04334245f, -0.03118671f, -0.02852110f, 0.01906632f, 0.01084350f, 
    -0.03852230f, -0.03567767f, -0.03535426f, -0.01022815f, -0.01874670f, 0.00249599f, -0.03031624f, -0.00107991f, 
    -0.00206191f, -0.02754644f, -0.02497555f, 0.00716638f, 0.00438234f, 0.00700842f, 0.00910305f, -0.03310191f, 
    -0.03513500f, -0.01353308f, -0.04250005f, 0.02132317f, -0.00561231f, 0.01733259f, -0.03564342f, -0.04136832f, 
    0.02218117f, -0.01137205f, -0.02305159f, -0.03968695f, 0.01478149f, -0.02004593f, 0.00296209f, -0.04044767f, 
    -0.01118646f, 0.03268404f, -0.00178966f, -0.02513092f, 0.01221336f, -0.00896618f, 0.03076698f, 0.01475664f, 
    -0.02782880f, -0.01613691f, 0.02077009f, -0.03986432f, 0.00426897f, -0.01731062f, 0.01588756f, -0.00834288f, 
    -0.00574908f, -0.02088332f, -0.02324662f, -0.02336257f, -0.03402087f, -0.04301199f, 0.00040823f, -0.02126989f, 
    -0.02151355f, -0.00609452f, -0.00322263f, 0.02159402f, -0.00710845f, -0.02006509f, -0.01500720f, -0.00529299f, 
    0.00090258f, -0.01041935f, -0.02200858f, -0.02467071f, 0.00802870f, 0.00398013f, -0.02575597f, 0.00003859f, 
    -0.03839290f, 0.03326792f, 0.00987542f, 0.00212226f, -0.03046189f, 0.02286465f, -0.02494052f, -0.02553654f, 
    0.01646207f, -0.02612638f, 0.01533280f, 0.02815236f, 0.01990052f, -0.00305499f, 0.01970018f, -0.02293118f, 
    -0.01949310f, -0.02230977f, 0.01058768f, 0.00559712f, -0.02814843f, 0.02429211f, 0.02017633f, -0.02854750f, 
    0.26854825f, -0.02345528f, -0.24798514f, -0.22564542f, -0.13553634f, -0.18546714f, -0.12757276f, 0.11160927f, 
    0.05894014f, 0.07214781f, -0.03546333f, -0.06078104f, 0.07049762f, 0.03101198f, 0.04179921f, -0.02355941f, 
    0.07236513f, 0.05942770f, -0.06793665f, -0.09293826f, 0.33381367f, 0.10547203f, 0.19930926f, 0.11582226f, 
    0.12228692f, 0.09507123f, -0.03319388f, -0.04571548f, 0.00597382f, 0.10721759f, 0.03610014f, 0.03408596f, 
    0.05695456f, -0.05932486f, -0.03331754f, -0.05804960f, -0.09724560f, -0.01160897f, -0.04956847f, 0.02980525f, 
    0.44385731f, 0.02267899f, 0.28046399f, 0.20360446f, -0.04965841f, 0.02523928f, 0.06746646f, 0.06654381f, 
    0.11584499f, 0.13679354f, 0.18218289f, 0.03443614f, 0.05864931f, -0.01423008f, 0.15348439f, 0.01390507f, 
    -0.07245724f, 0.02478169f, -0.20742212f, -0.14906538f, 0.39053166f, -0.24687113f, 0.12203284f, -0.00329283f, 
    0.29917884f, 0.06689086f, -0.18587299f, -0.00180763f, -0.00802061f, -0.14071138f, 0.01077701f, 0.08449071f, 
    0.08211090f, -0.00901988f, 0.09626964f, 0.00418714f, 0.14203535f, -0.01749401f, 0.17224282f, 0.19163193f, 
    -0.03939918f, -0.14868958f, -0.19611217f, -0.15526377f, 0.02151998f, 0.09059391f, 0.09053307f, 0.03219625f, 
    -0.00145267f, 0.15670452f, 0.01338146f, -0.02450379f, -0.20543714f, -0.03442505f, -0.09487510f, 0.05795062f, 
    0.01686074f, -0.03901878f, -0.03374585f, 0.03099443f, 0.37509102f, 0.23411207f, 0.29547516f, 0.24369383f, 
    0.10482152f, -0.18850385f, -0.13041088f, -0.10492431f, -0.07341625f, 0.05978619f, 0.10351074f, 0.05122617f, 
    0.07371645f, 0.07574735f, 0.08105511f, 0.08590763f, 0.04862238f, 0.07948064f, -0.02292659f, 0.04047361f, 
    0.25114366f, -0.22158174f, -0.53385234f, -0.17582916f, 0.06320528f, -0.14244604f, -0.17387490f, 0.12977499f, 
    -0.19173540f, -0.02376917f, -0.08191477f, -0.03352962f, 0.04091842f, -0.01262340f, 0.01043720f, -0.10545479f, 
    -0.14831196f, -0.10874446f, 0.02500159f, -0.08157007f, 0.25761119f, 0.30391923f, 0.34542450f, -0.05661305f, 
    0.04868542f, -0.03954540f, -0.09893604f, -0.05207989f, 0.00871197f, 0.02855273f, 0.08868259f, 0.06083170f, 
    0.13262944f, 0.01915911f, 0.10615744f, 0.07984101f, 0.09030563f, -0.12456633f, -0.01412251f, 0.08806650f, 
    0.40223283f, 0.02677920f, 0.31117234f, 0.07820264f, 0.01003496f, -0.13153021f, -0.20648737f, -0.01233734f, 
    0.09728946f, 0.08455615f, -0.03194930f, 0.06665334f, -0.01684680f, 0.04628192f, 0.10885342f, -0.12970959f, 
    -0.09434501f, -0.00828141f, -0.02859927f, 0.08853973f, 0.02963688f, -0.19042614f, -0.08993107f, -0.13212849f, 
    -0.08221115f, 0.16363022f, 0.12010138f, 0.26813146f, 0.16883306f, 0.05022410f, 0.10683177f, -0.01175955f, 
    0.17708725f, 0.11154586f, 0.05681838f, -0.06896907f, 0.11714757f, 0.05423429f, -0.01270354f, 0.06861284f, 
    0.25137123f, 0.08493385f, 0.12168589f, 0.12254962f, 0.13966173f, 0.01622717f, -0.16844293f, -0.11333848f, 
    0.02501623f, -0.19873235f, 0.06174084f, 0.05211761f, 0.09671284f, 0.12302195f, 0.00330373f, -0.00845462f, 
    -0.00482584f, 0.02224268f, 0.00234372f, 0.01519006f, 0.04654206f, 0.09763531f, 0.14325735f, -0.12746054f, 
    -0.03711371f, -0.09849817f, 0.00053323f, -0.04316759f, -0.05861019f, -0.07613609f, -0.08847317f, -0.06337895f, 
    0.16812983f, -0.19139723f, -0.14958113f, -0.06522609f, 0.07221927f, 0.10190692f, -0.10402145f, -0.07369962f, 
    -0.17917429f, -0.26444739f, -0.26243708f, -0.03959802f, -0.05797134f, 0.14617522f, 0.06390870f, 0.02786486f, 
    0.28881353f, -0.11490961f, 0.02322780f, -0.08786197f, -0.04481677f, -0.04669745f, -0.02401104f, -0.19220293f, 
    -0.04582963f, -0.02561428f, 0.21776621f, -0.06578898f, -0.12123020f, -0.08620665f, -0.39401871f, -0.14131254f, 
    -0.11812031f, -0.14312336f, 0.12006861f, -0.13414542f, -0.08065198f, -0.03285722f, 0.11418191f, -0.05838082f, 
    0.06768171f, 0.10972628f, 0.03861662f, -0.05563181f, 0.02329301f, 0.03157601f, 0.17043255f, 0.11886988f, 
    -0.05017745f, -0.35631591f, -0.26996288f, -0.28184801f, -0.02621474f, 0.09182815f, 0.21469066f, 0.15845482f, 
    -0.11365282f, -0.06666849f, -0.03678575f, -0.13623661f, -0.02961130f, -0.01024362f, 0.02950444f, 0.03877204f, 
    0.03612371f, 0.03382376f, 0.02204178f, 0.08881567f, 0.18050927f, -0.33993959f, -0.32687309f, -0.05781036f, 
    0.08197454f, 0.15948509f, 0.24410063f, -0.03938696f, -0.05395554f, -0.11181878f, 0.11166517f, -0.01830323f, 
    -0.06523997f, 0.09193338f, 0.04860684f, 0.01754913f, -0.02054244f, 0.05499019f, -0.04785613f, -0.04641871f, 
    0.10576748f, 0.17059630f, 0.01874763f, 0.15584049f, 0.01665326f, 0.02831796f, 0.18627484f, 0.03107668f, 
    0.05145343f, 0.04737513f, -0.00027574f, 0.01300780f, -0.01741855f, -0.10405955f, -0.08382060f, 0.07598703f, 
    -0.12412760f, 0.09570403f, -0.04146713f, 0.03456212f, 0.04828911f, -0.40290850f, -0.02615941f, -0.16394223f, 
    0.02657473f, 0.10147995f, -0.03696456f, 0.12836537f, -0.04134011f, 0.14334916f, -0.09221482f, -0.08617678f, 
    -0.02854879f, -0.19741018f, 0.04397939f, -0.02479476f, 0.02701841f, 0.03282787f, 0.02517870f, 0.01686760f, 
    0.20676605f, -0.00688432f, 0.19531271f, 0.08462641f, 0.14561918f, -0.00577417f, 0.21285520f, -0.10419399f, 
    0.00875279f, -0.04732440f, 0.00635743f, -0.04842491f, 0.08373612f, -0.05528349f, 0.01119476f, -0.16003262f, 
    -0.05944954f, 0.07416435f, -0.15422823f, -0.01942431f, 0.27381790f, 0.05943771f, 0.03998509f, 0.14090723f, 
    -0.02035154f, -0.07908979f, 0.04072443f, -0.01624746f, 0.11432020f, -0.02119229f, 0.04805508f, -0.04191447f, 
    0.13005441f, -0.08506963f, -0.01216552f, -0.17488369f, -0.00530197f, 0.07208353f, -0.14442499f, 0.10154541f, 
    0.10225515f, -0.30924115f, -0.27660388f, -0.29987377f, -0.04892413f, 0.01382642f, -0.02858801f, 0.08824431f, 
    0.03758942f, 0.07696976f, -0.09405658f, -0.02745348f, 0.01639839f, -0.04454789f, -0.05304493f, -0.12108824f, 
    -0.16137224f, -0.01940835f, 0.02814262f, 0.07644127f, 0.20752934f, 0.31143793f, 0.12467632f, 0.24519721f, 
    0.08306890f, 0.05995726f, 0.02323832f, -0.01421922f, 0.01998068f, -0.02017596f, 0.11675768f, 0.11828722f, 
    0.06889257f, 0.04810301f, 0.11073156f, -0.04177890f, -0.10547819f, -0.03901020f, -0.04647199f, -0.07563452f, 
    0.21987663f, 0.24230659f, 0.25591767f, 0.13131596f, 0.07713865f, 0.08877392f, 0.09170508f, 0.06773818f, 
    0.02929701f, 0.14408427f, 0.10350096f, 0.00105209f, -0.01561688f, -0.03796712f, 0.02667031f, -0.00889188f, 
    -0.16827953f, -0.19712040f, -0.13243404f, -0.04997170f, 0.36547270f, 0.39953706f, 0.33198813f, 0.09115786f, 
    0.07941560f, -0.01243846f, 0.01609494f, 0.00177498f, 0.08836863f, 0.06094234f, 0.08343052f, 0.12035599f, 
    0.06985418f, 0.04369327f, 0.12400794f, -0.06331531f, -0.18725535f, -0.07542016f, -0.01830018f, 0.07159974f, 
    -0.09896635f, 0.05372785f, -0.37906849f, -0.45414013f, -0.13770431f, 0.20352390f, 0.11128303f, 0.07984583f, 
    0.17363590f, 0.08013566f, -0.08438864f, -0.03264318f, -0.06268446f, 0.01892192f, -0.05336056f, -0.06123437f, 
    -0.15207684f, -0.06448104f, 0.21457084f, 0.10300895f, -0.01214557f, -0.34862539f, -0.26739463f, -0.06140983f, 
    -0.15308353f, -0.00132465f, -0.16728477f, 0.08151994f, 0.01865366f, 0.12775239f, -0.02399438f, 0.00633520f, 
    -0.00720186f, -0.14320770f, -0.04401832f, -0.13190639f, 0.00112852f, 0.01368005f, 0.03828012f, -0.06986646f, 
    0.04152201f, 0.01984760f, -0.08964728f, 0.03790053f, -0.01158626f, 0.09291407f, 0.10346744f, 0.05028338f, 
    0.08570475f, 0.16457616f, -0.13084772f, -0.13476548f, -0.18898274f, -0.02819963f, -0.10983772f, -0.05456679f, 
    -0.10022788f, -0.12297723f, -0.12104611f, -0.10339426f, 0.21296649f, 0.16804014f, 0.15037388f, 0.16218433f, 
    0.17078766f, 0.07713304f, -0.01894865f, -0.09032695f, 0.05655018f, 0.13373069f, 0.08571324f, 0.05696142f, 
    -0.01700326f, -0.01239678f, 0.05091630f, -0.04599084f, -0.23384051f, -0.01095988f, -0.00537042f, 0.03128475f, 
    0.22760397f, 0.11666927f, 0.13997446f, 0.07541568f, 0.07059985f, 0.09652491f, -0.02028062f, 0.02007643f, 
    0.08341707f, 0.02118390f, 0.03260022f, 0.07656986f, 0.05545210f, -0.03228826f, 0.00529879f, -0.00515042f, 
    -0.06779632f, 0.08316228f, -0.01404995f, 0.00150165f, 0.10259956f, 0.08164024f, 0.08506127f, 0.08326288f, 
    0.11581961f, 0.11427660f, 0.07826983f, 0.05621430f, 0.06181896f, 0.14567772f, -0.11378115f, -0.09581438f, 
    -0.26762736f, -0.10227557f, -0.09898307f, -0.01107801f, -0.06846481f, 0.02249059f, 0.01240521f, 0.01877566f, 
    0.09343803f, -0.16193125f, -0.57172090f, -0.07609961f, -0.01866556f, -0.05801739f, 0.03072369f, 0.17481641f, 
    -0.03741753f, -0.02889465f, -0.14318909f, 0.05156003f, -0.11829935f, 0.13036279f, -0.09443901f, -0.18365499f, 
    -0.32175529f, -0.14912841f, -0.04270853f, -0.08976458f, 0.06098216f, 0.05348980f, 0.14582299f, 0.07976414f, 
    0.10141651f, -0.02208416f, 0.02691204f, 0.05257923f, 0.05447137f, 0.01478909f, 0.04203295f, 0.16673015f, 
    0.00727248f, 0.10816978f, -0.02840261f, -0.09621352f, 0.03968985f, -0.01073326f, 0.07303758f, -0.05662285f, 
    -0.25772679f, 0.09494796f, 0.37477648f, 0.00199687f, 0.10354425f, -0.07336221f, 0.05717605f, 0.08394499f, 
    -0.03764362f, 0.00784293f, 0.03748266f, 0.03322024f, 0.16594999f, -0.00275711f, -0.02262230f, -0.00438291f, 
    -0.05416518f, 0.08585586f, 0.14567094f, -0.03539071f, -0.03301613f, 0.16522732f, -0.07750791f, -0.25869954f, 
    0.04686197f, 0.05278198f, -0.03832605f, 0.08586519f, -0.10177046f, 0.01533632f, 0.08933900f, 0.02223492f, 
    0.04359064f, -0.03680941f, -0.13121499f, -0.04495066f, -0.01543982f, -0.03402008f, -0.08509780f, -0.00124915f, 
    0.48898292f, 0.55604661f, -0.11714264f, -0.30018336f, -0.03333881f, -0.14213799f, -0.05299736f, -0.17337477f, 
    -0.16887033f, -0.00529199f, -0.12814027f, 0.07871157f, 0.06194413f, 0.05183902f, 0.06689152f, 0.09578873f, 
    0.03751901f, -0.06146196f, -0.05134797f, 0.05501956f, 0.35631791f, -0.00423988f, -0.24848633f, 0.21282226f, 
    -0.07590661f, 0.14289741f, -0.00342855f, 0.01517832f, -0.11652132f, -0.07288799f, -0.02380730f, -0.16495290f, 
    -0.07007807f, -0.01241372f, 0.00917735f, -0.05138727f, 0.11052244f, 0.06393514f, -0.04260571f, -0.01112436f, 
    -0.33149213f, 0.00049676f, -0.04203778f, -0.12266789f, -0.08550879f, 0.02734001f, 0.05048103f, 0.04239580f, 
    -0.04177660f, 0.00165008f, 0.12434745f, 0.11243577f, -0.02046951f, 0.08761250f, -0.02290584f, -0.05892478f, 
    -0.05184428f, -0.08452222f, -0.07910424f, -0.10666981f, 0.35007760f, 0.14719668f, -0.31802636f, 0.05430729f, 
    0.09397157f, 0.10017497f, 0.03404440f, 0.18606478f, 0.10154259f, 0.12640841f, 0.05434090f, -0.06475082f, 
    -0.01923458f, 0.05945793f, 0.06111616f, -0.02142411f, 0.02681044f, 0.05537109f, 0.00811011f, 0.02639795f, 
    -0.17496516f, 0.10331859f, 0.00219335f, 0.06920297f, -0.03291680f, 0.19226104f, 0.00134557f, -0.13821280f, 
    0.14466612f, 0.14312075f, 0.07096910f, 0.09172467f, 0.07317753f, -0.03076667f, 0.07310227f, 0.04910226f, 
    0.10610888f, 0.04657594f, -0.02731084f, -0.02974795f, 0.31360012f, -0.08129700f, 0.08706404f, -0.00669744f, 
    -0.00788442f, -0.04130576f, -0.06981447f, 0.10877101f, 0.01334314f, 0.13611615f, 0.00433967f, -0.01171480f, 
    0.09387197f, 0.06563760f, -0.03016791f, -0.03284464f, -0.03510306f, 0.00980061f, 0.06101414f, -0.04769190f, 
    0.38882148f, 0.33844793f, -0.16236930f, -0.13986591f, 0.02603624f, 0.12341461f, 0.10135954f, 0.19206059f, 
    -0.07237563f, 0.16294383f, 0.04800051f, 0.09731351f, -0.01215036f, -0.04826664f, -0.06087349f, -0.01057143f, 
    0.02349886f, 0.01508249f, 0.08830337f, 0.10918786f, 0.17212951f, -0.04927585f, -0.27001396f, 0.19337511f, 
    -0.03097839f, 0.04494403f, 0.03349954f, -0.06910270f, 0.04605344f, 0.11363818f, -0.03156029f, -0.10564888f, 
    -0.03478741f, -0.10355618f, -0.00351258f, -0.01296063f, 0.12739152f, -0.04052282f, -0.03122822f, 0.00292626f, 
    0.26849663f, 0.24881183f, 0.53048682f, -0.13385147f, 0.22523899f, 0.06782147f, 0.04219926f, -0.00112492f, 
    0.15165696f, -0.08131456f, 0.07069571f, -0.05232127f, 0.00420663f, 0.05249401f, 0.02290485f, 0.09267326f, 
    0.11510964f, -0.05891690f, -0.08540753f, 0.05795372f, 0.17906824f, 0.10410112f, -0.12397911f, 0.03013717f, 
    0.10484419f, 0.09502411f, 0.15686424f, 0.17601569f, 0.07473492f, 0.14310656f, 0.04951580f, 0.12853627f, 
    0.15024607f, -0.13597707f, 0.00076628f, 0.05841376f, 0.08163812f, 0.23494181f, 0.10728874f, -0.08457617f, 
    -0.04100446f, -0.28189710f, -0.04991652f, 0.08719945f, 0.07516707f, 0.01516353f, -0.14145003f, -0.12236460f, 
    -0.04226050f, 0.02091702f, -0.02693368f, 0.02267761f, -0.02336514f, -0.01697790f, 0.07322484f, -0.01213813f, 
    -0.06858704f, -0.01350071f, 0.07757926f, -0.19903255f, -0.19213098f, -0.34414250f, -0.14291593f, 0.17080986f, 
    0.01226186f, 0.03727238f, -0.01602363f, 0.00726097f, 0.07316061f, 0.04129237f, 0.01035444f, -0.18585736f, 
    -0.15184127f, -0.06951215f, -0.12719551f, 0.02323739f, 0.10402747f, 0.16221686f, -0.08728161f, 0.04564298f, 
    -0.15523882f, -0.17632617f, -0.20145583f, 0.11857112f, -0.01835521f, 0.05266275f, 0.03158129f, 0.09112953f, 
    0.12684432f, 0.15586841f, 0.00131033f, -0.01598489f, -0.03164078f, -0.02241390f, -0.00704655f, -0.05476267f, 
    0.02175327f, 0.05792754f, -0.09249810f, -0.01790629f, 0.09828690f, -0.06274255f, 0.15171067f, -0.11966342f, 
    -0.01410557f, 0.08361348f, 0.10597084f, 0.06923559f, -0.06402352f, 0.10861058f, 0.18007874f, 0.05983374f, 
    0.04349272f, 0.07172056f, -0.08972193f, 0.08564411f, 0.20374069f, 0.14483275f, -0.05667124f, -0.01992945f, 
    -0.15201290f, 0.18168913f, -0.27644798f, -0.39698473f, 0.00399477f, -0.06345443f, 0.03143526f, -0.04707591f, 
    -0.06722643f, -0.09806746f, 0.05046057f, 0.09078849f, 0.25042161f, -0.12707818f, 0.02853794f, 0.17937639f, 
    -0.04370322f, -0.06162083f, 0.14464070f, 0.03682126f, -0.52660984f, -0.16048332f, -0.46679771f, 0.02038678f, 
    -0.08687326f, 0.09810388f, 0.03365058f, -0.06821904f, 0.10494109f, 0.00000353f, -0.00070001f, -0.08112949f, 
    -0.07263011f, 0.05991792f, 0.13721623f, 0.08885003f, 0.15483786f, -0.09143572f, -0.05015061f, 0.00299146f, 
    0.19684875f, 0.20989726f, 0.04663508f, -0.35610330f, 0.12167880f, 0.10042519f, 0.04015328f, -0.05426058f, 
    0.03332333f, 0.03355138f, 0.06077197f, 0.09217846f, 0.11716218f, 0.07055584f, -0.11911934f, 0.14460063f, 
    0.13277039f, 0.00754479f, -0.05546687f, 0.05541589f, 0.05476242f, 0.27318051f, -0.00260895f, -0.17825799f, 
    0.00438729f, -0.05469368f, 0.04826110f, -0.09533352f, -0.10982285f, -0.02388722f, 0.07371690f, 0.14603515f, 
    0.07161475f, 0.07972781f, 0.04437635f, 0.10437287f, 0.17047064f, -0.02229641f, 0.17937984f, 0.00786999f, 
    -0.09130349f, 0.02455970f, -0.15580624f, 0.06144516f, 0.01540511f, 0.10058673f, -0.01879565f, -0.05591654f, 
    0.08109750f, 0.06675068f, -0.03791559f, -0.01574719f, -0.00694098f, 0.05204600f, 0.11776010f, -0.07749419f, 
    0.08740524f, 0.03120508f, 0.05789150f, 0.07332764f, 0.02846707f, 0.04603057f, -0.12504798f, -0.00670038f, 
    0.12635686f, 0.02786347f, 0.11285977f, 0.05097029f, 0.06932077f, -0.10926505f, 0.16865471f, 0.07938725f, 
    -0.07715840f, -0.00212216f, 0.01952026f, 0.02079685f, 0.02919963f, 0.01158236f, 0.06850274f, -0.12637916f, 
    -0.07184394f, 0.06864346f, 0.03991587f, 0.09267125f, 0.13221964f, -0.01536686f, -0.00038031f, -0.05088483f, 
    -0.15158416f, -0.05622275f, 0.10273767f, 0.13308494f, 0.16972214f, 0.00492063f, 0.03069838f, 0.13374819f, 
    -0.00432771f, -0.09537636f, -0.03631220f, 0.08796300f, 0.00095189f, 0.26129961f, 0.08277071f, -0.04928001f, 
    -0.03824579f, 0.00292545f, 0.00442014f, 0.06307927f, -0.04639407f, -0.01770476f, 0.01116506f, -0.00562764f, 
    -0.01489375f, -0.02403255f, -0.07745415f, -0.07822938f, 0.06257565f, 0.02682484f, -0.04981015f, -0.09222299f, 
    -0.30247810f, -0.16977884f, 0.04385501f, 0.10155620f, 0.04942195f, 0.12207108f, -0.10895437f, -0.19512641f, 
    0.12367388f, 0.00430808f, 0.04445068f, -0.07755096f, -0.15281673f, 0.02189590f, 0.09244857f, -0.06984693f, 
    0.01955953f, 0.04650471f, 0.09184360f, 0.04257977f, -0.30663744f, -0.05703614f, 0.02649825f, -0.02484191f, 
    0.00805577f, 0.17132384f, -0.01601403f, 0.04582741f, 0.33070111f, 0.10128282f, 0.13049391f, -0.01598109f, 
    0.01328169f, 0.14772385f, 0.04250052f, 0.00103006f, 0.01231026f, 0.13205314f, 0.08125692f, -0.03170105f, 
    -0.27752575f, -0.20299083f, 0.07769358f, 0.01622849f, 0.00438332f, 0.02766174f, 0.00424506f, -0.02144196f, 
    -0.08713569f, -0.19526517f, 0.22433093f, 0.06289049f, 0.08017067f, 0.05902811f, 0.16635989f, 0.06302581f, 
    0.01514146f, -0.02978353f, 0.04795695f, -0.07113158f, -0.00832114f, 0.06528384f, -0.06317393f, -0.04557577f, 
    0.08356822f, -0.01211513f, -0.05990267f, -0.03272540f, -0.05598325f, -0.07262663f, 0.06571560f, 0.09832136f, 
    0.01719695f, -0.05343301f, 0.00528288f, 0.03504671f, 0.07729679f, 0.01951534f, -0.08478344f, -0.04796503f, 
    -0.01024250f, 0.36664340f, 0.23641141f, -0.24922942f, 0.20743556f, 0.10863072f, 0.06235309f, 0.02145273f, 
    0.01812073f, 0.02315026f, 0.06840670f, 0.11462515f, 0.12345238f, 0.03228644f, 0.04138205f, 0.11046154f, 
    0.05759211f, -0.02930988f, 0.08388814f, 0.02927393f, 0.02530320f, -0.00294753f, 0.04409179f, -0.20101157f, 
    0.05173650f, 0.01037005f, -0.05359278f, -0.06152473f, -0.12448808f, -0.15208334f, 0.24242900f, 0.12975495f, 
    0.03466114f, 0.00095472f, 0.04479812f, -0.09296880f, 0.01246747f, -0.09682674f, -0.14992490f, 0.02777863f, 
    -0.23260120f, -0.03522579f, -0.01576612f, 0.03583156f, 0.02678117f, 0.01652717f, 0.00081960f, 0.02478831f, 
    0.12983359f, 0.13637003f, 0.09430899f, -0.12365635f, -0.08022708f, -0.04283132f, 0.06720133f, 0.06091275f, 
    -0.07152396f, -0.09850898f, 0.12819014f, -0.02453141f, 0.25348279f, 0.11351892f, -0.06720384f, -0.21048558f, 
    0.03153158f, 0.00428024f, -0.06181739f, 0.08184726f, -0.02938128f, -0.08808574f, -0.06634731f, -0.04327373f, 
    -0.05023414f, -0.09450194f, -0.02246724f, 0.02364874f, 0.01009283f, -0.03859980f, -0.20917301f, 0.04271120f, 
    -0.08971277f, -0.24797960f, -0.20756377f, 0.24230070f, -0.24317819f, 0.16157074f, -0.06098075f, 0.16069652f, 
    0.21205525f, -0.07075887f, 0.01906521f, -0.04283645f, -0.08613946f, 0.08328903f, 0.00381635f, -0.07032332f, 
    0.05457113f, -0.01332346f, -0.06669006f, 0.00561794f, 0.29944494f, -0.12097257f, 0.00515934f, 0.15244396f, 
    0.09903961f, -0.06435467f, -0.07168675f, -0.12135062f, 0.03224041f, 0.09176538f, -0.13907617f, -0.06573460f, 
    0.04803036f, -0.00171449f, 0.17806521f, 0.13731751f, 0.01568617f, -0.07310206f, 0.00353393f, 0.08701696f, 
    0.55629379f, -0.12226523f, 0.10349295f, 0.36642748f, 0.17344025f, -0.12844923f, 0.00144375f, -0.12415831f, 
    0.08435261f, -0.04206552f, -0.03649232f, -0.00279299f, -0.11854784f, -0.07959943f, -0.01679151f, -0.06998395f, 
    -0.12601015f, -0.04852933f, 0.21230708f, 0.16986121f, -0.25273058f, -0.28718945f, -0.07848439f, 0.20216523f, 
    0.03716584f, -0.00870332f, -0.03288681f, 0.08701423f, -0.01486629f, -0.07932515f, -0.11312230f, 0.06495655f, 
    -0.14212924f, 0.03346311f, 0.03797061f, 0.11483855f, -0.00729073f, 0.04763466f, 0.06195653f, 0.19229454f, 
    -0.09101637f, -0.01009149f, 0.02456664f, -0.08661940f, -0.24710964f, -0.15720217f, -0.01572037f, -0.02942196f, 
    0.12346119f, 0.14563416f, 0.12182932f, -0.00845857f, -0.01669727f, -0.05012245f, -0.07011145f, -0.11740854f, 
    -0.00293321f, 0.09060118f, 0.04886063f, 0.05059587f, 0.10474646f, -0.09906662f, 0.09232706f, 0.11157399f, 
    0.09843799f, 0.06754769f, -0.02733947f, 0.01781807f, -0.03196159f, -0.10245424f, -0.05596167f, -0.04082596f, 
    -0.05327922f, -0.06667690f, 0.00084818f, -0.02304928f, 0.07927039f, 0.09760617f, -0.09819426f, -0.07496367f, 
    -0.24126185f, -0.34575397f, 0.13252147f, 0.17038150f, -0.05496054f, 0.10341085f, -0.05206098f, 0.26030642f, 
    -0.05493169f, -0.07592177f, 0.10279278f, -0.01336594f, -0.02540927f, -0.01433781f, 0.04195439f, -0.00108249f, 
    0.07396057f, -0.01666639f, 0.00927407f, -0.02985598f, 0.13714893f, 0.30249664f, -0.21851344f, 0.04844949f, 
    0.04886881f, 0.02882641f, 0.01583788f, 0.01155656f, -0.10058923f, -0.11970413f, -0.07332119f, 0.00493898f, 
    -0.07953032f, -0.14638382f, 0.01111738f, -0.00454152f, -0.19268900f, -0.07975639f, -0.16745004f, -0.08382452f, 
    -0.22588550f, -0.30353910f, -0.07785697f, 0.12137097f, 0.01059051f, 0.02389362f, 0.03572768f, 0.11783744f, 
    0.04258193f, 0.15780143f, -0.16357063f, -0.03410615f, -0.07161183f, -0.10485574f, -0.02505230f, 0.15387487f, 
    -0.07362729f, 0.07324793f, 0.04423399f, -0.09312000f, -0.35090929f, -0.11216055f, 0.23623106f, 0.14963679f, 
    -0.02912006f, -0.12154052f, 0.08209502f, 0.12346447f, -0.11277290f, 0.02567814f, -0.02430579f, -0.08036060f, 
    -0.09801374f, 0.03313645f, 0.01475926f, -0.02273213f, 0.06028848f, 0.07623380f, 0.09707960f, 0.08636422f, 
    0.64740759f, 0.03373976f, -0.53451651f, -0.08200272f, -0.03636367f, 0.12229882f, -0.03278339f, 0.16423561f, 
    -0.06237159f, -0.07408150f, 0.02594645f, 0.04359227f, 0.11702962f, -0.02302421f, -0.09530967f, 0.04135726f, 
    -0.03302490f, 0.14341499f, -0.01457084f, -0.02844469f, -0.06383787f, 0.10507550f, 0.20554958f, 0.31893790f, 
    0.09011181f, 0.01208836f, 0.01006792f, 0.05075258f, 0.01493936f, 0.09300745f, 0.01235762f, -0.08171675f, 
    0.09725256f, 0.17627552f, 0.13685788f, 0.11358394f, -0.03508296f, 0.12236092f, -0.08975808f, -0.08217555f, 
    0.04005339f, 0.19874871f, -0.03714079f, 0.12325292f, -0.08396538f, 0.06000819f, -0.07596078f, 0.17124711f, 
    0.17365156f, 0.00384113f, 0.07901899f, 0.07652098f, 0.11820927f, 0.13949896f, 0.02744553f, 0.08063889f, 
    -0.02288453f, -0.03745339f, -0.12007108f, -0.06915691f, -0.11925328f, 0.17911966f, 0.35241255f, 0.12748057f, 
    -0.03916955f, -0.10433113f, 0.20364705f, -0.06721647f, -0.12344523f, -0.17720413f, -0.05803378f, -0.01120649f, 
    -0.07136650f, 0.11137277f, -0.01116189f, -0.07821684f, 0.04913525f, -0.02925014f, 0.06541961f, 0.00863901f, 
    -0.12616242f, -0.10116794f, 0.23587345f, -0.06039147f, -0.26057222f, -0.09247656f, 0.10467949f, -0.04803138f, 
    0.04030643f, 0.17142758f, 0.07574254f, 0.00072111f, -0.15240790f, -0.06816444f, -0.19800597f, -0.12805678f, 
    0.08970211f, -0.01692088f, 0.05916645f, -0.02992713f, 0.16066396f, -0.11633109f, 0.00575168f, -0.01876291f, 
    0.02531290f, 0.05390168f, 0.16302747f, -0.00465345f, 0.03659626f, -0.05930099f, -0.06436793f, -0.02276207f, 
    -0.13710749f, -0.00191680f, 0.03223484f, -0.06485106f, -0.08095060f, -0.00728877f, 0.07883295f, 0.15141238f, 
    0.14615637f, -0.00677859f, 0.13323176f, 0.14722148f, -0.01031881f, 0.00564615f, -0.00913720f, 0.07920437f, 
    -0.00495268f, -0.05247960f, 0.04541200f, -0.07580077f, -0.09990517f, 0.19189359f, 0.11631137f, 0.00919590f, 
    0.20990777f, 0.21757489f, -0.04380906f, 0.16010383f, 0.08877172f, -0.48438585f, 0.24509718f, 0.08780271f, 
    -0.27783647f, 0.04796071f, -0.09686680f, -0.05334263f, -0.01946315f, 0.39016753f, 0.07725647f, 0.08430465f, 
    0.03927993f, -0.00900139f, -0.11154249f, -0.02001105f, -0.06576221f, -0.04164014f, 0.00953831f, 0.02766286f, 
    0.64855886f, -0.28392696f, -0.05270660f, 0.28970745f, 0.24343075f, 0.02138105f, 0.01942247f, 0.11690051f, 
    0.08248731f, -0.03515962f, 0.12817813f, -0.06349806f, 0.14289737f, 0.13646933f, 0.05824310f, 0.04696596f, 
    0.14522409f, -0.01136070f, -0.13901180f, 0.16220462f, 0.44622004f, -0.30621150f, 0.01920266f, 0.05460665f, 
    0.05921806f, 0.16366281f, -0.08478218f, 0.29373768f, -0.00377927f, -0.18488723f, 0.05931077f, 0.02304580f, 
    0.18424395f, -0.02669042f, 0.06803630f, 0.00271185f, -0.03941322f, 0.21613620f, -0.03674260f, -0.03994154f, 
    -0.19807374f, -0.02912183f, 0.14236274f, -0.01960981f, 0.00044952f, 0.08184585f, -0.01422267f, -0.00634627f, 
    0.07358734f, 0.23249184f, -0.10754613f, -0.04066908f, -0.17182337f, 0.00391223f, -0.04294404f, 0.11548951f, 
    -0.05619669f, -0.07305477f, 0.00107244f, 0.09773740f, 0.21668369f, -0.04593711f, 0.19069630f, 0.02431340f, 
    -0.08818067f, 0.15361880f, -0.02000353f, -0.06849187f, -0.07400243f, -0.05630873f, -0.02882839f, 0.00732256f, 
    -0.02235193f, -0.02898422f, 0.00996138f, -0.01272513f, -0.04777339f, 0.09448884f, -0.02973633f, -0.05264049f, 
    0.19757250f, 0.04767080f, 0.12504302f, -0.02832610f, -0.06034096f, -0.19749606f, -0.09488248f, -0.04047149f, 
    -0.03361980f, 0.06762835f, 0.02606896f, 0.01264527f, -0.17358319f, 0.11763666f, 0.03337646f, -0.00510102f, 
    0.02279966f, 0.08966102f, 0.06995467f, 0.01467186f, 0.17822510f, 0.14085877f, 0.15437572f, 0.08668403f, 
    0.13405931f, -0.03564632f, -0.04912387f, -0.00417363f, -0.02231652f, 0.07762384f, -0.14007224f, -0.08020892f, 
    -0.09357043f, -0.11331657f, -0.02688192f, 0.08444723f, -0.08146467f, -0.08830428f, -0.02813206f, -0.01420357f, 
    -0.07509658f, -0.12753715f, 0.09005950f, 0.06324735f, -0.02074815f, 0.11442985f, 0.03785530f, -0.09651276f, 
    -0.05236510f, 0.02225575f, -0.00230129f, 0.03836771f, 0.05085159f, 0.05641869f, 0.10751949f, 0.05301561f, 
    0.05652322f, -0.26961538f, 0.01054864f, -0.04067564f, -0.01785551f, -0.12370331f, 0.07700861f, 0.20607938f, 
    0.03543521f, -0.01227152f, 0.13578387f, 0.01561360f, -0.13461970f, 0.12721661f, -0.01517232f, 0.01470962f, 
    -0.04987506f, 0.11287133f, -0.02311331f, 0.15186290f, -0.00924874f, -0.12861213f, 0.00378648f, 0.08744604f, 
    -0.01439018f, -0.22860876f, -0.01515854f, -0.04927870f, -0.09977113f, -0.14285402f, -0.06011012f, -0.11025314f, 
    -0.08706913f, -0.00543755f, 0.06271694f, 0.15361917f, -0.09256221f, 0.11739127f, -0.01253719f, -0.14519106f, 
    -0.10230056f, 0.18812507f, -0.10117982f, -0.24333917f, 0.05539611f, -0.00529220f, 0.01237323f, 0.12255438f, 
    -0.01043388f, -0.02973813f, 0.01039746f, -0.07454246f, 0.04961875f, 0.10254159f, -0.05315137f, -0.03570220f, 
    0.00739592f, 0.01607417f, 0.03781505f, 0.10929278f, -0.11685926f, 0.02202696f, -0.00999910f, 0.06061417f, 
    0.24958503f, 0.07919951f, -0.22053117f, 0.23310800f, 0.01030231f, 0.02472300f, -0.00957554f, 0.08785492f, 
    -0.02117077f, 0.09921969f, 0.01207262f, -0.01958043f, 0.12303343f, -0.00010624f, 0.12288076f, 0.06390233f, 
    0.07257549f, 0.16273321f, 0.07080924f, 0.09907592f, 0.19117418f, 0.01986859f, -0.12066772f, 0.11536338f, 
    -0.03995878f, 0.02921956f, -0.05684307f, 0.03689657f, 0.03228035f, 0.08709992f, 0.06206008f, 0.06136264f, 
    0.21129456f, -0.01753934f, 0.18100052f, 0.06023645f, -0.01165118f, -0.14110595f, 0.20834932f, 0.08095905f, 
    -0.20905896f, -0.16859898f, 0.11507978f, 0.00998012f, -0.00196700f, 0.05929641f, 0.05777054f, 0.00856709f, 
    -0.00541354f, -0.01563049f, -0.03180167f, 0.03068100f, 0.04956459f, -0.03675754f, -0.05871157f, -0.06893406f, 
    0.00024788f, 0.04067597f, -0.09444913f, -0.17040502f, -0.13508897f, -0.22779070f, 0.04064881f, 0.16746186f, 
    0.06901976f, 0.04209081f, -0.02307106f, -0.13310374f, 0.01943278f, -0.20053214f, -0.12175803f, -0.04717001f, 
    0.02207656f, -0.07203294f, -0.07737845f, 0.11542169f, 0.09173356f, 0.09520822f, 0.05338284f, -0.06062386f, 
    0.02793294f, 0.02261334f, -0.01019913f, 0.00087958f, 0.00090022f, 0.00120643f, -0.02023909f, -0.01693400f, 
    0.01938582f, -0.03770019f, 0.03362967f, 0.01755599f, -0.01331205f, 0.02234622f, -0.02465077f, -0.01264259f, 
    -0.02884312f, 0.01108623f, -0.03778046f, -0.02472122f, 0.00558020f, 0.01630169f, 0.01712158f, -0.00227192f, 
    -0.00399123f, -0.00816746f, 0.03056362f, 0.02159453f, -0.01747253f, -0.01672244f, 0.01281283f, -0.03435200f, 
    0.01415697f, -0.00863245f, 0.02923852f, 0.00845056f, -0.00241883f, 0.00726680f, -0.04390424f, -0.02883264f, 
    0.00480909f, 0.04165403f, -0.02548700f, -0.02960150f, -0.02530290f, 0.02720583f, -0.03188307f, 0.00971224f, 
    0.03506912f, -0.01192480f, -0.02860231f, 0.01598792f, -0.00808640f, -0.00144173f, 0.02424504f, 0.00364465f, 
    0.02479682f, -0.02011604f, 0.01508370f, 0.02844707f, 0.01479215f, 0.00280690f, 0.02840826f, 0.02868664f, 
    -0.02273442f, -0.00870442f, 0.01446194f, -0.01513814f, 0.00654403f, 0.01988586f, -0.03681998f, -0.02210682f, 
    -0.01997941f, -0.03207006f, 0.00415444f, 0.00290815f, 0.00867388f, -0.00645446f, 0.02260151f, -0.02223292f, 
    0.03645307f, 0.01765249f, 0.00235798f, 0.00703338f, -0.04224314f, -0.01562003f, 0.02344930f, -0.00261449f, 
    0.02100422f, -0.01901420f, 0.02732662f, -0.00287731f, -0.02083432f, -0.03166660f, 0.01087906f, -0.03352104f, 
    0.02148706f, -0.01986771f, 0.01440302f, 0.00109345f, -0.01804267f, -0.01580375f, -0.00800744f, -0.04003808f, 
    -0.00559469f, -0.00324891f, -0.00449010f, -0.00697473f, 0.02340337f, -0.01924518f, -0.01647866f, -0.01554426f, 
    -0.01495553f, -0.00563115f, -0.01617202f, 0.00128592f, 0.00456438f, -0.04071733f, 0.00109526f, -0.01484707f, 
    -0.04407064f, -0.01738090f, -0.00084484f, 0.02552158f, 0.00536899f, 0.02233472f, -0.02064457f, -0.01048099f, 
    -0.03414321f, -0.03073152f, 0.01358159f, -0.01995321f, 0.01094337f, -0.01170779f, 0.02184788f, 0.01640957f, 
    0.01628797f, -0.00539009f, 0.03063685f, 0.00975623f, 0.00841958f, -0.00833488f, -0.03353580f, 0.00470580f, 
    -0.02393963f, 0.00243189f, -0.02603183f, 0.01705006f, -0.00340795f, 0.02421361f, 0.01330084f, -0.00393766f, 
    -0.03239672f, -0.02333584f, -0.00892046f, 0.01093766f, 0.00428789f, -0.04629556f, -0.00857307f, -0.03763822f, 
    -0.00061360f, 0.01219056f, -0.03112357f, 0.00404261f, -0.02120266f, -0.00441847f, -0.00447850f, 0.00494600f, 
    0.02733861f, 0.01579699f, -0.02178698f, -0.03808523f, 0.01542148f, -0.03959445f, 0.00083495f, 0.01626732f, 
    -0.01611903f, -0.00790499f, -0.02195694f, -0.01152921f, 0.02782600f, -0.01930597f, 0.00529390f, -0.02770655f, 
    -0.01679204f, -0.02729182f, -0.02926427f, -0.00437448f, 0.00468954f, 0.01550233f, -0.02601032f, -0.00966767f, 
    -0.02693906f, -0.01073529f, 0.00021665f, 0.03676580f, -0.01580304f, -0.00194470f, 0.02080438f, -0.00395211f, 
    -0.02381895f, -0.01101776f, 0.01792565f, -0.01782159f, 0.00412303f, -0.01746347f, 0.01209082f, -0.01880193f, 
    -0.02668216f, -0.02796496f, 0.02214934f, -0.03477275f, -0.03932874f, -0.00805581f, -0.01702332f, -0.00778741f, 
    0.02739915f, 0.01209764f, 0.01700752f, -0.03935173f, -0.03380680f, -0.00964461f, -0.02367325f, 0.01539840f, 
    -0.04500264f, -0.03837285f, -0.04079458f, -0.01316193f, 0.00542325f, -0.01174354f, -0.03267628f, 0.02083109f, 
    -0.02669686f, -0.02475174f, 0.01121914f, -0.01172055f, -0.04451955f, -0.02449052f, -0.01772367f, -0.01180408f, 
    0.01224444f, -0.01504770f, -0.00957575f, -0.02825418f, 0.00133957f, 0.02531805f, -0.01217518f, -0.02882666f, 
    -0.01921000f, -0.00801699f, 0.00818351f, 0.02979917f, 0.00960673f, -0.01923156f, 0.04167234f, -0.01032398f, 
    0.00583726f, 0.01105659f, -0.00690306f, -0.04697483f, -0.03470979f, -0.03746644f, -0.02938620f, 0.00439993f, 
    -0.00881155f, 0.00309434f, -0.01838467f, -0.04429420f, -0.01963326f, 0.00868046f, -0.00759748f, 0.01976271f, 
    0.01189300f, 0.00842801f, -0.01147499f, 0.01181556f, 0.02496808f, -0.00122162f, 0.01709567f, 0.01892592f, 
    -0.01250381f, 0.00614714f, 0.01348775f, 0.02094112f, 0.00843459f, 0.02378803f, -0.02846929f, -0.02336079f, 
    0.01383871f, -0.03294228f, -0.04279369f, 0.02402794f, -0.00095490f, 0.00303157f, -0.04020918f, -0.01035488f, 
    -0.02995944f, -0.02961568f, -0.01875892f, -0.00758463f, -0.00204550f, 0.00979628f, 0.02475339f, -0.01359501f, 
    -0.04167138f, -0.00740979f, -0.04317151f, 0.00796366f, 0.01092390f, -0.00088689f, -0.03507653f, -0.01613259f, 
    0.01214446f, -0.01229699f, 0.01660605f, -0.01747455f, -0.00310358f, -0.04990562f, -0.01060551f, 0.01059452f, 
    0.00865233f, -0.02076677f, 0.00866230f, -0.03374680f, 0.02637882f, -0.00488393f, 0.03664467f, -0.02400369f, 
    -0.00016790f, 0.00503037f, -0.01269430f, 0.00427696f, 0.01320601f, 0.00906013f, 0.00996318f, -0.02299194f, 
    0.01034743f, 0.02729639f, -0.03469843f, -0.00448098f, -0.00677873f, -0.01290319f, -0.03432870f, -0.03404858f, 
    0.02137092f, -0.00404887f, 0.00942120f, -0.02750763f, 0.00867131f, -0.01206276f, -0.04498943f, -0.03517917f, 
    -0.02203723f, -0.04140871f, -0.00133066f, -0.00216398f, -0.00447370f, 0.02056961f, 0.02597975f, -0.00966763f, 
    0.00418862f, 0.03530860f, -0.00950130f, 0.01312980f, 0.03343539f, -0.04720916f, -0.00982747f, -0.03231988f, 
    0.00764629f, 0.02852165f, 0.02068660f, 0.01285697f, -0.03585040f, 0.01286660f, 0.02897204f, -0.01630844f, 
    -0.02788855f, -0.02901176f, -0.01131787f, -0.03000876f, 0.00965442f, -0.00734087f, -0.00358661f, -0.03671857f, 
    0.01903336f, -0.02736042f, 0.00257744f, -0.02866258f, 0.02031998f, 0.02868311f, -0.04597304f, -0.02839270f, 
    -0.03749329f, -0.00355903f, 0.00508557f, -0.02556913f, -0.04254406f, -0.03365223f, -0.02778745f, 0.00653564f, 
    0.00171739f, -0.03594927f, -0.00260429f, 0.01904562f, 0.02333461f, -0.01252520f, -0.02009895f, 0.00442610f, 
    -0.04623276f, 0.02143442f, -0.03732622f, 0.00962662f, 0.00721152f, -0.03632547f, -0.00541652f, -0.00557379f, 
    -0.02514833f, 0.00884561f, 0.00228534f, -0.02744725f, -0.02014464f, 0.00477114f, -0.01064138f, -0.02121168f, 
    0.01724152f, -0.01965396f, 0.01353034f, 0.00205219f, -0.02187809f, -0.02646551f, 0.02731214f, -0.00818839f, 
    -0.03742940f, -0.03804421f, -0.04426382f, -0.01330062f, 0.02005683f, 0.01759326f, -0.03375462f, -0.03548987f, 
    0.00591049f, -0.02525698f, 0.01387148f, 0.01638986f, -0.02991553f, 0.01223933f, -0.00646429f, -0.03036125f, 
    -0.01468949f, -0.02409776f, -0.03655554f, -0.00140636f, -0.02934434f, -0.02198565f, 0.01802307f, -0.03547558f, 
    0.02067797f, 0.02676876f, -0.02672381f, 0.00267210f, 0.02269951f, -0.00382711f, 0.02098621f, 0.01824644f, 
    0.01300268f, -0.01751906f, 0.01596394f, -0.04377935f, -0.03394206f, 0.00011123f, -0.02359533f, -0.02096293f, 
    0.02551094f, -0.04524755f, -0.00647656f, -0.02723902f, 0.01342336f, -0.00029852f, 0.01306679f, 0.01596173f, 
    -0.01310227f, -0.04498970f, -0.04047414f, 0.01008281f, -0.00334649f, -0.02968215f, -0.01915544f, -0.04273182f, 
    0.01087400f, 0.02184434f, 0.00708558f, 0.04214733f, 0.00385927f, -0.04434193f, -0.01737214f, 0.01910450f, 
    -0.02341193f, 0.00358437f, -0.02993855f, 0.00852627f, -0.00824582f, -0.01267405f, 0.01196051f, -0.02388760f, 
    -0.02911994f, -0.00817193f, 0.01163328f, -0.03830890f, 0.01219004f, 0.01741296f, 0.00918233f, -0.03996126f, 
    -0.00773535f, 0.02216735f, -0.02320361f, 0.01658730f, 0.00294977f, 0.01849983f, 0.01122964f, 0.00805822f, 
    -0.00715863f, -0.02024224f, -0.04110494f, 0.01445528f, -0.03613301f, -0.01108895f, -0.02405033f, 0.01036834f, 
    0.02988137f, -0.01135440f, 0.00121333f, -0.04544080f, 0.00908272f, 0.02493293f, 0.01566448f, -0.03041288f, 
    -0.02556651f, 0.02862733f, -0.02543318f, -0.01793467f, -0.00315877f, -0.03189274f, -0.02769710f, -0.00767607f, 
    -0.01560739f, -0.03697012f, 0.01680601f, -0.03125685f, 0.00781049f, 0.02866860f, 0.03025842f, 0.02587226f, 
    0.00987992f, -0.01649349f, -0.03997786f, 0.01125093f, -0.04296024f, -0.04769950f, -0.03836572f, 0.01944598f, 
    0.01167956f, 0.02964017f, -0.00671739f, -0.00233712f, 0.01772279f, -0.02547042f, -0.04882314f, -0.04251898f, 
    -0.02542472f, -0.03297559f, -0.00280585f, -0.00386365f, 0.00773696f, -0.00775288f, -0.04438044f, -0.00787329f, 
    -0.00605640f, -0.00759934f, 0.00214614f, 0.00100210f, -0.01398591f, 0.00673642f, -0.03372708f, -0.01072393f, 
    -0.01719841f, -0.00713668f, 0.03460216f, 0.00447298f, -0.00380340f, -0.00743952f, 0.00464409f, -0.02713111f, 
    -0.02758332f, -0.04160321f, -0.01106928f, -0.00031690f, 0.01066454f, 0.01818611f, -0.01062604f, 0.03250866f, 
    0.00277518f, -0.00654325f, 0.02445637f, -0.03485815f, -0.01867352f, 0.01927940f, -0.04744896f, -0.00353838f, 
    -0.00500390f, -0.00657907f, -0.04368642f, -0.00549636f, -0.04094724f, -0.04079358f, -0.03014882f, -0.03376803f, 
    -0.01428064f, -0.00498092f, 0.01649371f, -0.01926801f, -0.02774978f, -0.01254199f, -0.02468687f, 0.01290922f, 
    0.00855627f, 0.03771145f, 0.00873842f, -0.01850812f, -0.04383696f, -0.04809218f, -0.02567837f, -0.03630118f, 
    0.00680623f, -0.04179997f, 0.01828499f, 0.02117478f, -0.00659345f, -0.01251994f, -0.04497579f, -0.00799071f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07132429f, 0.03823601f, 0.07242232f, 0.06178803f, -0.08593076f, -0.02534512f, 0.09739592f, -0.03247290f, 
    -0.02436122f, 0.03123141f, -0.03154521f, -0.02789896f, -0.01201829f, -0.11420728f, -0.02213868f, 0.09278125f, 
    -0.01297138f, 0.03511538f, 0.10383885f, -0.04670673f, 0.10098771f, -0.00756701f, 0.00483387f, 0.12499251f, 
    0.13401458f, 0.07489611f, -0.02195225f, -0.04010284f, 0.00431004f, 0.16870716f, 0.06855528f, -0.04593612f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11090856f, 0.08289811f, -0.26655978f, 0.29676181f, 0.32585737f, 0.07113124f, -0.04339726f, 0.36923489f, 
    0.17336835f, 0.15584324f, 0.16005705f, -0.10536712f, -0.09046383f, -0.25565284f, 0.20570633f, -0.13736998f, 
    -0.02289785f, 0.19103923f, 0.10313460f, -0.07178717f, 0.27356362f, 0.18696254f, -0.08986916f, -0.22005323f, 
    -0.00406760f, 0.18668565f, -0.07329723f, -0.10767851f, -0.59565973f, 0.16084112f, -0.05297150f, -0.00204885f, 
    0.17178972f, -0.05706368f, -0.33856356f, 0.29018945f, -0.06529786f, 0.05673390f, -0.26754808f, 0.19173189f, 
    0.01928668f, 0.15037298f, -0.12476329f, -0.10722788f, 0.15829271f, 0.22368965f, -0.02343581f, 0.00867305f, 
    -0.42826757f, 0.16400051f, 0.25728628f, -0.38439453f, -0.18539335f, -0.26705411f, 0.10400664f, 0.14690062f, 
    -0.14425260f, 0.06517523f, 0.16951299f, -0.11672569f, -0.10219759f, 0.20198353f, 0.27596390f, -0.00499880f, 
    0.59610581f, 0.05231834f, -0.21272378f, -0.27600074f, -0.24228159f, -0.04616859f, -0.16374315f, 0.01766037f, 
    0.12688287f, -0.13880384f, -0.14855504f, -0.10307779f, -0.16785456f, -0.03577149f, -0.21356997f, 0.18307613f, 
    0.01867814f, 0.25384483f, 0.33479038f, 0.23222642f, -0.04506877f, 0.01765393f, 0.01586550f, -0.15600756f, 
    0.31736371f, -0.23546499f, -0.04069149f, -0.03947361f, -0.26370394f, 0.08910041f, 0.36791363f, -0.15371653f, 
    -0.10562651f, 0.24709745f, -0.01283419f, 0.02639931f, -0.23769611f, -0.12975179f, 0.11480635f, -0.06768013f, 
    -0.02367605f, 0.10131526f, -0.11040594f, -0.07686932f, -0.06779347f, -0.20553946f, -0.06709352f, -0.23444414f, 
    -0.10379989f, -0.02596921f, -0.03475003f, -0.05182828f, -0.03082939f, -0.22481059f, -0.15022199f, -0.09869772f, 
    -0.03351859f, 0.34986651f, 0.14751475f, -0.00782428f, -0.05191753f, 0.16339186f, 0.09777119f, 0.08849303f, 
    0.11218553f, -0.23644541f, 0.04075947f, -0.31199113f, -0.01933941f, 0.02137322f, -0.17125435f, 0.21729180f, 
    0.09246096f, 0.08233992f, 0.10469586f, 0.11414839f, 0.16810478f, -0.13010553f, 0.04564403f, -0.01807924f, 
    0.01151515f, -0.05776929f, -0.07674666f, -0.03973567f, -0.18730323f, 0.09150069f, 0.05962281f, 0.09836069f, 
    -0.22359411f, -0.02684400f, -0.08692807f, 0.11760821f, 0.34712723f, 0.01893712f, -0.19345239f, -0.07764456f, 
    -0.06619288f, 0.09070857f, 0.49333388f, 0.11286386f, 0.26759472f, -0.12197110f, -0.17360955f, 0.09354759f, 
    0.13877667f, -0.16417354f, -0.17700054f, 0.03252247f, 0.07387534f, -0.12598613f, 0.28570503f, -0.00370649f, 
    -0.15058950f, -0.23267215f, -0.04243307f, 0.00724976f, -0.03110619f, -0.19134486f, 0.12085352f, -0.02562088f, 
    0.07779472f, 0.26184517f, -0.08125094f, 0.03762844f, -0.00326364f, 0.25524876f, 0.02640972f, 0.13340601f, 
    -0.36672184f, 0.22317043f, -0.13125874f, 0.15794192f, 0.30341145f, -0.13688409f, -0.38814110f, 0.04377556f, 
    -0.04051898f, -0.15015756f, -0.01067637f, 0.11037968f, 0.17819926f, -0.07127642f, 0.03492187f, 0.00397223f, 
    -0.10419615f, -0.37938574f, -0.15173800f, 0.04092591f, 0.30322221f, -0.58932793f, 0.14485066f, 0.03019336f, 
    -0.43641740f, -0.29380143f, -0.17195594f, 0.11666147f, -0.36012813f, 0.14645462f, -0.15633026f, -0.10229825f, 
    0.11269049f, -0.06246969f, -0.17569187f, -0.12846315f, -0.12759925f, -0.03326308f, -0.29333213f, -0.27613479f, 
    -0.13610505f, 0.15837756f, 0.07993555f, 0.12133460f, 0.14896752f, 0.06339391f, 0.09699292f, -0.17097397f, 
    0.16589212f, 0.48987046f, 0.37187389f, 0.40532744f, -0.01802667f, 0.65817773f, 0.07086637f, -0.07231022f, 
    0.35546207f, -0.47984993f, -0.10993324f, -0.16600280f, -0.21132572f, -0.00702174f, 0.12075615f, 0.14460334f, 
    0.01610068f, 0.23478547f, 0.31942317f, 0.01242039f, -0.02875185f, 0.05910878f, 0.32528085f, 0.14666982f, 
    -0.10010017f, -0.13899484f, -0.10763448f, -0.12350069f, -0.14444859f, -0.27693164f, -0.05532818f, 0.11993269f, 
    0.30218777f, -0.30140418f, 0.08913124f, -0.31015769f, 0.31358433f, -0.24402270f, 0.14158823f, -0.05466887f, 
    0.12877724f, 0.02543057f, 0.04881996f, -0.09822938f, 0.03280878f, 0.21003862f, -0.06783748f, -0.06201052f, 
    -0.25467607f, 0.31155664f, 0.03871313f, 0.32571149f, -0.13720083f, 0.10315312f, -0.28032753f, 0.14010689f, 
    -0.00977177f, 0.10873593f, 0.15054536f, 0.14701971f, -0.10646914f, 0.43085352f, 0.40509623f, 0.00770042f, 
    -0.31447253f, 0.31867471f, 0.04112017f, 0.12836242f, -0.27830783f, -0.25884297f, -0.12761149f, 0.18097194f, 
    -0.01935494f, -0.08447718f, -0.16554610f, 0.01424265f, -0.06461395f, -0.02458709f, 0.10884947f, 0.09218319f, 
    -0.21514936f, -0.18542390f, 0.67126364f, 0.09389140f, 0.07645851f, 0.07964404f, 0.10304058f, -0.26852918f, 
    -0.15605885f, -0.11416881f, -0.01633138f, -0.04018760f, 0.04782080f, -0.08255723f, 0.16259633f, 0.39851999f, 
    -0.05889427f, -0.30424872f, 0.30058244f, 0.39956519f, 0.03699321f, -0.29958093f, -0.12085787f, -0.03171604f, 
    0.07645705f, -0.25571698f, 0.12371484f, -0.05769471f, -0.04751115f, 0.15290193f, 0.15499856f, 0.01671785f, 
    -0.12138338f, 0.28536078f, -0.19413328f, -0.14909349f, 0.33719325f, 0.11262599f, -0.20016858f, 0.16291261f, 
    0.07657177f, 0.09833740f, -0.07259135f, -0.00546737f, 0.09671886f, 0.15758559f, 0.32831386f, -0.16594633f, 
    -0.06476766f, 0.20339721f, -0.06747897f, 0.44239780f, 0.27357146f, 0.12216872f, 0.15187915f, -0.30423388f, 
    -0.37645829f, -0.01946238f, 0.12983289f, -0.09110951f, -0.18303297f, -0.29015082f, -0.10091758f, -0.01963662f, 
    -0.02808432f, 0.21066821f, 0.12405865f, -0.21609646f, -0.14894733f, -0.04939975f, -0.06720635f, 0.05639865f, 
    0.17855273f, 0.14589417f, -0.12411157f, -0.08619221f, -0.11801927f, 0.12838292f, -0.18031409f, 0.22079162f, 
    -0.06069123f, -0.06201765f, -0.01284300f, 0.21132270f, 0.25996065f, -0.51334864f, -0.07658526f, 0.17958267f, 
    0.05375524f, 0.11116347f, -0.15876815f, -0.03634582f, 0.05410009f, 0.23448767f, 0.26123732f, 0.12738150f, 
    0.34417096f, 0.20234232f, -0.05217937f, -0.10865542f, -0.14402899f, 0.11896632f, 0.25172985f, 0.27579087f, 
    0.07640290f, 0.07880566f, 0.07132489f, -0.06549958f, -0.13139738f, -0.28033692f, -0.21187422f, -0.26029611f, 
    0.24422586f, 0.29387999f, 0.27627322f, -0.33588585f, 0.11720777f, -0.13476183f, 0.06867414f, -0.02146596f, 
    0.20139121f, -0.11238290f, -0.16854165f, 0.08011756f, -0.27662641f, -0.05589646f, 0.43321428f, -0.05303638f, 
    0.18822649f, -0.01899548f, 0.04105882f, 0.40360087f, -0.15991426f, -0.09616518f, -0.29578429f, -0.28817239f, 
    -0.05053022f, 0.03199194f, 0.12841052f, -0.09806322f, -0.15907344f, 0.25200829f, -0.04471186f, -0.10586649f, 
    0.11467862f, -0.12057669f, 0.09180929f, 0.03184690f, -0.30956328f, -0.12232428f, 0.15743259f, -0.00932499f, 
    0.05421372f, 0.13777518f, 0.09400985f, 0.15790495f, -0.04181869f, 0.11330388f, 0.03089351f, 0.11064646f, 
    0.22439376f, -0.34598333f, -0.24066375f, 0.01929619f, 0.06681395f, -0.14295717f, 0.04009975f, 0.13053481f, 
    0.11819638f, 0.08651545f, 0.16577184f, -0.11870172f, 0.03017147f, 0.04379438f, 0.10862422f, 0.40123668f, 
    -0.22182514f, 0.14672704f, 0.19605519f, 0.04183846f, 0.21529788f, 0.15931319f, -0.15779823f, 0.22622235f, 
    -0.20809682f, 0.22647163f, -0.03773441f, 0.17066085f, -0.20938002f, 0.13527434f, -0.10368657f, 0.11512497f, 
    -0.44640717f, 0.04860548f, 0.09527794f, 0.43645599f, 0.23822519f, 0.16163304f, -0.09295423f, -0.35309958f, 
    0.02489869f, -0.07175089f, 0.15307289f, -0.10214531f, -0.11582811f, -0.02749286f, 0.31931806f, -0.26654804f, 
    -0.24777855f, 0.03591421f, 0.21814014f, 0.13462466f, 0.02474297f, 0.10944796f, -0.07612567f, 0.12986185f, 
    0.00412830f, 0.02827851f, -0.02317543f, -0.12505203f, -0.13226616f, 0.03407589f, 0.07346571f, 0.07310549f, 
    -0.20187901f, 0.05622791f, 0.32540965f, 0.25372183f, -0.08393914f, 0.00779450f, -0.05435419f, -0.11078236f, 
    0.00804626f, 0.15128534f, -0.15902829f, -0.13930440f, -0.16857034f, -0.39691496f, 0.13155107f, 0.33941713f, 
    -0.30314013f, -0.11891596f, 0.09799989f, -0.03959793f, 0.21160173f, -0.05756097f, 0.09687547f, 0.18766743f, 
    0.30777964f, 0.25528461f, -0.08191436f, -0.03084049f, -0.45998800f, 0.16748026f, 0.02161280f, 0.11684265f, 
    -0.05003005f, 0.27244395f, 0.44620875f, -0.32839176f, -0.27432805f, -0.09047786f, 0.26427379f, -0.08030793f, 
    -0.15506826f, 0.07151464f, 0.11511226f, -0.13512143f, -0.14081822f, -0.18680005f, -0.03275051f, 0.22843087f, 
    0.32013109f, 0.18309928f, -0.23648824f, 0.23263246f, -0.06660136f, 0.14905247f, 0.10233305f, -0.08550997f, 
    0.20659408f, -0.15846658f, 0.07175879f, -0.07969790f, -0.10818744f, 0.28993201f, -0.11120389f, -0.16177808f, 
    0.11651752f, 0.17330493f, -0.41272962f, 0.00568513f, 0.28936589f, -0.00885954f, -0.19103305f, 0.29134223f, 
    0.05040899f, -0.02709142f, -0.01410890f, -0.11358772f, 0.06237775f, -0.22455266f, -0.06231113f, -0.14869012f, 
    0.18102965f, -0.04510292f, 0.34343472f, 0.02739265f, 0.38908735f, -0.19763182f, 0.11031524f, -0.06771920f, 
    -0.17347173f, -0.16611654f, 0.03544729f, 0.03720038f, -0.05070466f, -0.29167542f, 0.28762755f, -0.16158068f, 
    0.38870493f, 0.05932470f, -0.24844854f, 0.12128246f, 0.31586361f, -0.14452550f, -0.06919187f, 0.40725791f, 
    -0.03207427f, -0.09205380f, -0.10340387f, -0.11877769f, -0.06289224f, -0.28619036f, -0.11464491f, 0.19978613f, 
    0.51534021f, 0.11791628f, 0.17794184f, 0.09182395f, -0.05084772f, 0.38269851f, 0.10924064f, -0.17773096f, 
    0.03013035f, 0.34559590f, 0.13629335f, 0.06783079f, -0.35456750f, 0.01435916f, -0.30849445f, -0.16049856f, 
    0.17868568f, -0.17359802f, 0.24659441f, -0.09136857f, 0.23909266f, 0.10302125f, 0.19011112f, 0.13753332f, 
    -0.08208624f, 0.12653178f, 0.13442802f, -0.00592772f, -0.11492971f, 0.06344745f, 0.00779198f, -0.03908552f, 
    -0.19194677f, 0.19808033f, -0.26682499f, -0.13579677f, -0.03617321f, -0.04062275f, -0.03778981f, -0.20120431f, 
    -0.03700464f, 0.10469679f, 0.02413615f, -0.08522321f, -0.03234912f, -0.13766263f, -0.18707044f, -0.03060860f, 
    0.05528146f, -0.25583360f, 0.35456648f, 0.19215514f, 0.06724873f, -0.08041500f, -0.01127689f, -0.17517646f, 
    -0.05413170f, 0.02056507f, -0.05302284f, 0.11518052f, 0.07186143f, 0.01299753f, -0.30843177f, -0.34844768f, 
    -0.29671031f, 0.01658848f, 0.06586380f, -0.04458450f, -0.21010223f, 0.05207065f, -0.09904298f, -0.00004718f, 
    -0.17496699f, 0.09946799f, -0.16634309f, -0.09365951f, -0.07719113f, 0.00951642f, 0.13968356f, -0.07089972f, 
    0.02181560f, 0.18967198f, 0.12670402f, 0.29412749f, -0.06433886f, 0.16567151f, 0.30872250f, -0.00335020f, 
    0.10571306f, -0.16935349f, 0.11085304f, 0.05816020f, -0.06651773f, -0.09948497f, 0.23867860f, 0.02457019f, 
    -0.18540865f, -0.05739279f, -0.06515145f, -0.49908817f, 0.17064556f, 0.05236363f, -0.12236513f, 0.39739224f, 
    0.06698252f, -0.01016326f, 0.04235917f, -0.10357441f, -0.11380458f, 0.15291642f, -0.05291215f, 0.15642992f, 
    0.01288439f, -0.19294496f, -0.21782874f, -0.01656416f, -0.05908375f, -0.00397459f, 0.01437301f, -0.14291166f, 
    -0.04728921f, -0.10450804f, -0.03088630f, 0.17286576f, -0.08679876f, 0.09504461f, 0.16180559f, -0.10659833f, 
    -0.02816654f, -0.14916612f, -0.20876506f, 0.06651143f, 0.02250527f, -0.07928348f, 0.05556330f, -0.20028022f, 
    -0.01786328f, -0.07929740f, 0.07245586f, -0.09058748f, -0.07906856f, -0.04336248f, -0.20284054f, -0.17611614f, 
    -0.13233435f, -0.06354867f, 0.24930061f, 0.00546953f, 0.08781061f, 0.07202610f, -0.22557436f, 0.30069417f, 
    -0.12903443f, 0.04468079f, -0.05304927f, 0.02761798f, -0.06395569f, 0.15584448f, 0.24496931f, 0.49257320f, 
    0.03668156f, 0.09742702f, -0.01416438f, 0.20007101f, -0.31972721f, 0.17688836f, -0.06753630f, -0.15293670f, 
    0.09926014f, 0.21115692f, -0.04361919f, 0.04838733f, -0.13600275f, 0.03218746f, -0.41306984f, 0.11054714f, 
    0.11306187f, 0.01294264f, -0.10270063f, 0.21452855f, 0.02011353f, -0.02062055f, 0.04517045f, -0.29759833f, 
    0.07337812f, 0.14793375f, 0.09675308f, -0.11543038f, -0.17891182f, 0.36112082f, 0.24990407f, 0.13938738f, 
    0.08613667f, -0.19503191f, -0.01904895f, 0.17294297f, 0.17832245f, 0.11570910f, -0.11405183f, -0.23353417f, 
    0.23202074f, -0.32506368f, -0.03738970f, -0.06859355f, 0.04408406f, -0.04385130f, -0.26737058f, -0.00731661f, 
    -0.21107261f, 0.28651649f, 0.31565428f, -0.26264381f, 0.15595242f, 0.15520923f, -0.18476968f, 0.27613258f, 
    0.03512761f, -0.15135919f, -0.04483556f, 0.04902562f, 0.09434426f, 0.28754425f, 0.21529756f, -0.09535141f, 
    0.35134912f, -0.12794824f, 0.04831166f, -0.02050178f, 0.11739523f, -0.26517966f, -0.00766122f, -0.26509139f, 
    -0.16965602f, -0.02034888f, -0.05284367f, -0.05579630f, -0.12755717f, -0.30216327f, 0.12661685f, -0.10351129f, 
    0.36660600f, 0.21823864f, -0.16198143f, -0.10390253f, -0.11080559f, -0.08247243f, 0.31228104f, -0.17827207f, 
    0.14160353f, -0.03463407f, -0.15463230f, -0.11521850f, 0.05410195f, 0.02391433f, -0.06076480f, -0.26467618f, 
    0.43664792f, 0.15858746f, -0.05367986f, 0.27029148f, -0.14824638f, 0.14914991f, 0.08853112f, 0.09856564f, 
    0.25921845f, -0.19742785f, 0.11787593f, 0.11475614f, -0.15875344f, 0.31858671f, -0.20772272f, 0.10340552f, 
    -0.33432695f, -0.19227237f, 0.36095738f, -0.23904292f, -0.22488227f, -0.05058408f, 0.00068378f, -0.03403493f, 
    -0.05572340f, 0.06016159f, 0.14668192f, 0.16678770f, 0.06523886f, 0.23542219f, -0.28042313f, -0.26404804f, 
    0.05979653f, -0.09277685f, -0.25289583f, -0.03407828f, -0.19015498f, -0.01945928f, 0.00040431f, -0.12099743f, 
    -0.15788564f, 0.11345266f, 0.13036457f, -0.10913990f, 0.13644734f, 0.13333637f, -0.15090068f, -0.12623692f, 
    0.37324879f, -0.09637392f, -0.33689553f, 0.21525984f, 0.02478057f, -0.04760817f, -0.09937956f, 0.26272219f, 
    -0.06526951f, 0.05778686f, -0.09703327f, -0.07492474f, -0.04671009f, -0.11706702f, -0.20213848f, 0.38692293f, 
    -0.37719044f, 0.02049333f, -0.10522155f, 0.12372304f, 0.12686156f, -0.14833026f, -0.14531067f, 0.19012718f, 
    0.03194991f, 0.77908438f, 0.14616425f, -0.12062117f, -0.13315755f, 0.35006908f, 0.04200220f, 0.11618911f, 
    0.12376044f, 0.01570162f, 0.43823877f, -0.36801279f, -0.12492713f, 0.03873156f, 0.32933515f, -0.22664620f, 
    -0.09761339f, 0.16495942f, 0.09528918f, -0.04775914f, -0.07871480f, -0.13508923f, -0.08935857f, 0.28056586f, 
    -0.00659450f, -0.02444938f, 0.21183276f, 0.17692848f, 0.37596238f, -0.07998271f, 0.04035780f, 0.04180897f, 
    0.24636438f, -0.16755690f, -0.06708197f, 0.07100495f, -0.09673429f, -0.17015570f, -0.03815103f, -0.13357343f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15442914f, 0.05860233f, 0.13541684f, 0.07596435f, 0.09386846f, -0.09564020f, -0.02961886f, 0.12425756f, 
    0.16222554f, 0.01382174f, 0.24446343f, 0.00677384f, -0.01648348f, 0.15366998f, 0.14058125f, 0.28315404f, 
    0.05109795f, 0.14863037f, 0.07601891f, 0.16640627f, 0.06400332f, -0.04411948f, 0.20032980f, 0.07663780f, 
    -0.06948013f, -0.17509960f, -0.09577325f, -0.03825524f, 0.16737868f, 0.17090592f, 0.18173493f, 0.07600206f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.25000331f, -0.26056489f, -0.61818635f, -0.33375064f, 0.08264592f, 0.08905093f, 0.01367611f, -0.19752169f, 
    0.14217219f, 0.00940723f, -0.44507313f, 0.17557248f, -0.29979411f, 0.05853863f, -0.36755013f, -0.24603362f, 
    0.08525450f, -0.41995993f, -0.26203528f, 0.22387403f, 0.25356945f, 0.03291428f, -0.08944415f, -0.09209382f, 
    -0.11178052f, 0.06738825f, 0.05540462f, 0.37395418f, -0.36739594f, -0.64158320f, -0.51950985f, -0.19220518f, 
    0.14020771f, -0.07663704f, -0.37297887f, 0.34940618f, -0.05343554f, 0.23749232f, 0.52701837f, -0.76325864f, 
    0.15320311f, -0.02648980f, 0.08759385f, 0.14924563f, 0.19435948f, -0.25598511f, 0.06602886f, -0.08302995f, 
    0.04638796f, 0.24240859f, -0.03837978f, 0.15237261f, -0.13446112f, 0.08210686f, 0.06376850f, 0.16364457f, 
    0.04758994f, -0.28166181f, -0.21039733f, -0.04793408f, -0.14383002f, 0.14020453f, 0.26538730f, -0.22389002f, 
    0.20816414f, -0.37271065f, -0.16846596f, 0.13219818f, -0.04222392f, -0.12753354f, -0.58579767f, 0.25410527f, 
    0.04997600f, -0.49899769f, 0.12879886f, -0.54238987f, -0.30021763f, -0.14699064f, -0.34183711f, 0.10987567f, 
    0.33686087f, 0.29507434f, -0.10783949f, -0.16712412f, 0.09920406f, 0.18163683f, -0.00691587f, 0.20740964f, 
    -0.17213975f, -0.24678221f, 0.19571725f, -0.50776684f, -0.06659832f, -0.33007911f, -0.17196828f, 0.15810998f, 
    0.11423469f, -0.33755562f, -0.20623960f, -0.25091794f, -0.36890319f, 0.20275562f, -0.18237610f, 0.10203408f, 
    -0.39937705f, 0.19628543f, 0.00063019f, 0.26850671f, -0.40670410f, -0.55179405f, -0.40027747f, 0.13105910f, 
    0.10859503f, -0.10185826f, 0.23802257f, -0.24186692f, 0.05157952f, -0.03555718f, -0.60986978f, -0.19729044f, 
    0.00234423f, 0.40716392f, 0.19045700f, -0.04976339f, 0.00552469f, -0.40729100f, -0.10520750f, -0.17341460f, 
    -0.05524217f, -0.37966460f, 0.20331067f, 0.08151472f, 0.10329275f, -0.08268686f, -0.30382153f, 0.17794207f, 
    -0.11385785f, -0.41988501f, -0.02329540f, 0.18347919f, 0.03661042f, 0.09054662f, -0.25012904f, 0.15030618f, 
    0.02707343f, -0.37092924f, -0.18353947f, 0.22816391f, 0.30185863f, -0.11599999f, -0.22287524f, -0.55741972f, 
    -0.20739782f, -0.04899506f, -0.14969242f, -0.02019147f, -0.16266419f, 0.13594370f, -0.04871866f, 0.04936281f, 
    0.19522555f, 0.35193273f, 0.24385774f, -0.32436249f, 0.17786548f, 0.01030270f, -0.31420577f, -0.10283802f, 
    -0.06934159f, 0.09438699f, -0.18169557f, -0.18775579f, -0.05407336f, 0.15545516f, -0.31666455f, 0.15847652f, 
    -0.00175232f, 0.04437537f, -0.37663621f, 0.12689260f, 0.05417322f, -0.29252285f, -0.06893051f, 0.06419851f, 
    -0.25028530f, 0.03414466f, -0.45212367f, -0.23291306f, -0.43688414f, -0.24036060f, 0.32982060f, -0.31544390f, 
    -0.75231528f, -0.13958807f, 0.15251201f, 0.06313753f, -0.08679597f, 0.02781059f, -0.03017763f, -0.06318699f, 
    0.31816387f, -0.26998502f, 0.20079461f, -0.36307999f, -0.10125668f, 0.30447608f, -0.34694812f, -0.36170834f, 
    -0.26178581f, 0.21360350f, 0.31967720f, -0.56251609f, -0.16202730f, -0.28841975f, -0.08400631f, 0.18308297f, 
    -0.15462583f, -0.40913737f, -0.27134374f, -0.46973935f, 0.22379662f, -0.34281898f, -0.60751826f, 0.21616445f, 
    -0.44879049f, 0.11214931f, 0.33086875f, -0.06073656f, 0.03650501f, -0.13892698f, -0.18409429f, 0.39625207f, 
    -0.62265068f, 0.24455103f, -0.42359260f, 0.05859613f, 0.08138500f, 0.08385804f, 0.00152219f, -0.31657314f, 
    -0.13064417f, -0.65672600f, 0.11325485f, -0.36763868f, -0.03884251f, -0.20836021f, -0.23059730f, -0.40618101f, 
    0.05464469f, -0.18526936f, 0.25127676f, -0.61125833f, 0.41932800f, 0.01141429f, -0.06276060f, -0.43648854f, 
    -0.56830609f, 0.35654551f, -0.34347874f, -0.33643967f, -0.24252361f, -0.00716653f, 0.05455820f, -0.29078105f, 
    -0.25990111f, 0.41206026f, -0.07692930f, -0.42710111f, -0.06649172f, -0.66247261f, 0.25978759f, 0.22555785f, 
    0.25462466f, -0.20381159f, -0.36078966f, -0.15434387f, -0.49748385f, -0.23562877f, -0.04569965f, 0.24756669f, 
    -0.10471484f, -0.02105579f, 0.30963707f, -0.07405478f, 0.08368374f, -0.19978648f, -0.10885604f, -0.37659407f, 
    0.10398345f, -0.28149775f, 0.19573304f, -0.02860794f, -0.22225595f, -0.30089173f, -0.19314663f, -0.13392894f, 
    0.18140122f, -0.49957040f, -0.60919321f, -0.32434484f, -0.05713883f, 0.32135478f, -0.27700713f, 0.11658301f, 
    -0.62149656f, -0.14611515f, 0.24287082f, -0.06611791f, 0.19820705f, -0.30401909f, -0.19654498f, 0.14957714f, 
    -0.09486205f, 0.01032678f, 0.00094151f, -0.11068074f, 0.26070341f, -0.69004500f, 0.19325806f, 0.15215619f, 
    -0.09239466f, 0.05240802f, 0.01930039f, -0.06827428f, -0.85776985f, -0.14519884f, 0.00594588f, 0.19498681f, 
    -0.33107483f, 0.26728341f, 0.04769124f, 0.20983228f, 0.11059075f, 0.11421878f, -0.47470236f, -0.03519642f, 
    0.27766588f, -0.06987876f, -0.29481924f, 0.17993744f, -0.69069535f, -0.31039709f, -0.35220677f, -0.08775874f, 
    0.02716911f, -0.45098257f, -0.07941659f, 0.26791212f, -0.22848113f, -0.60316998f, -0.37184000f, 0.22654130f, 
    -0.42287287f, -0.33769834f, 0.08925197f, -0.14798710f, -0.49448022f, 0.12846977f, -0.24132980f, -0.28115243f, 
    -0.01328060f, 0.02925116f, 0.47243470f, -0.23478794f, 0.19687699f, -0.50979894f, -0.13247655f, -0.02477424f, 
    -0.19857901f, -0.03129020f, 0.12621471f, -0.20847508f, -0.15486147f, -0.31775463f, -0.34016070f, -0.29608673f, 
    -0.20281194f, 0.36993667f, 0.24053012f, 0.28225854f, -0.30943495f, -0.47228932f, -0.07315935f, 0.33091214f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.26671392f, 0.08164690f, 0.22880441f, -0.11650024f, -0.15767513f, 0.12331015f, -0.19775535f, 0.24382780f, 
    0.18599415f, -0.08557098f, -0.04680073f, -0.04913827f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
