#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.88450986f, -1.17884755f, -1.06998467f, -0.16459376f, 0.47136575f, 0.42841774f, -0.40609473f, 0.07382860f, 
    -1.05260205f, -1.10547507f, -0.51230305f, -0.12709324f, -0.10349024f, -0.91382092f, 0.53495336f, -0.22169544f, 
    0.19556266f, 1.09336209f, -0.80631495f, 1.07801354f, -0.08588003f, 1.36960459f, 0.60795331f, -0.68677658f, 
    -0.14505032f, -0.28856981f, 0.75095314f, -1.48795497f, -1.33592439f, -1.15669298f, 0.97231770f, 0.71630847f, 
    -0.00544229f, -0.33646458f, -0.69040734f, -0.52115154f, 0.86627197f, 1.07291913f, 0.19428556f, -1.68890715f, 
    -0.37666053f, -0.52518058f, 0.08563880f, 0.29073116f, 0.56439662f, 0.72264576f, -0.03010217f, 0.06153852f, 
    0.47899115f, 0.62383395f, 1.02995670f, -0.05866199f, 1.05427015f, -0.47371015f, -0.30527064f, 0.09391556f, 
    0.18368384f, -0.62385112f, -0.79090697f, -0.08242951f, 0.34598097f, 0.87502342f, 0.61869633f, -1.34989035f, 
    0.27837595f, 0.61077708f, -0.31566036f, -1.09254098f, 0.38505980f, 0.80932176f, 0.38612401f, -0.32313156f, 
    0.55346942f, 0.84843504f, 0.80474675f, -0.65643454f, -0.60418189f, -0.11205722f, 0.16442141f, -0.76207405f, 
    -0.62357146f, -0.87220037f, -0.80107152f, -0.52263308f, -0.70719910f, -0.86860210f, -1.13357055f, -0.02199320f, 
    -0.63159019f, -0.73053843f, 0.51344818f, -0.08129558f, 0.48804465f, 0.32178909f, 0.26818952f, -0.44309768f, 
    0.28841293f, 0.40253958f, 1.07244492f, -1.67512095f, 0.33844692f, 0.68183887f, -0.57307220f, 0.36239079f, 
    -0.41147739f, -0.18320672f, 0.02827266f, 0.36969388f, 0.93655312f, 0.29952443f, -1.23200762f, -0.45482528f, 
    1.18320560f, -0.72719651f, -0.06250986f, 0.05446201f, 0.19908082f, -1.20427108f, -1.39734375f, 0.21995611f, 
    0.50610536f, 0.31259525f, 0.79057580f, 0.03491309f, -0.59677619f, 0.61001343f, -0.17815439f, 0.12634623f, 
    -0.18140094f, -0.46086916f, -1.42437196f, -1.68501449f, -0.33111957f, -0.30772778f, -0.15463741f, -1.05604291f, 
    0.01266250f, 0.80434471f, 0.20766069f, 0.11405947f, -0.14269371f, -0.34554845f, 0.46141949f, -1.10313320f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.30560276f, -0.57816350f, 0.17472787f, 0.02867858f, 0.38809642f, 1.06996262f, 0.14986968f, 0.20421188f, 
    0.37717089f, -0.65684527f, -0.15676799f, 0.72406262f, 0.49738792f, 0.79478705f, -0.04140390f, 1.18130207f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.16789430f, 0.20387591f, -0.48732328f, -0.06830883f, -0.12062753f, -0.12404112f, -0.11491720f, -0.24550751f, 
    -0.27520749f, 0.12601332f, 0.25495765f, -0.08071423f, -0.28420955f, -0.09533980f, -0.12969413f, 0.15248773f, 
    -0.09125756f, -0.06208229f, 0.08328745f, 0.13785899f, 0.21981354f, -0.27636465f, 0.12218816f, -0.04021616f, 
    0.33352178f, -0.06742108f, -0.17397945f, -0.56837046f, -0.22752459f, -0.38474697f, -0.27565965f, -0.27580681f, 
    -0.36092654f, -0.23121953f, -0.42491144f, -0.00309253f, 0.15143284f, -0.06975240f, 0.44509196f, 0.22494020f, 
    0.18430093f, -0.07997780f, 0.31042996f, 0.13221295f, 0.31792107f, 0.33068737f, 0.35351855f, 0.08951265f, 
    0.03321140f, 0.02494012f, -0.00308646f, -0.05754054f, -0.14942817f, 0.05479635f, -0.12926777f, -0.10925347f, 
    -0.03917622f, 0.29605347f, 0.04875425f, 0.17526352f, 0.25778618f, 0.06957491f, 0.51748514f, -0.53754711f, 
    0.12134152f, 0.38314003f, 0.06817520f, -0.10271429f, -0.00604164f, -0.12136176f, 0.14860578f, -0.12125988f, 
    -0.16312778f, 0.01868502f, 0.04167449f, -0.09078869f, 0.01171207f, -0.03200210f, -0.09579121f, -0.06271232f, 
    0.00461996f, -0.02313516f, 0.00813213f, -0.06595799f, -0.21029268f, -0.01395761f, 0.20049776f, 0.22643472f, 
    -0.02456257f, -0.18851316f, -0.13021255f, -0.18843435f, -0.29652622f, 0.16408157f, -0.01105549f, -0.10842495f, 
    0.13537577f, 0.22633755f, 0.15062132f, 0.07220301f, 0.30923170f, 0.64535731f, 0.20487967f, 0.22270785f, 
    0.27421093f, 0.29051119f, 0.25495216f, 0.21103674f, 0.27276132f, 0.15412679f, 0.41509125f, -0.03482113f, 
    0.19733010f, 0.39679581f, 0.12785818f, -0.16120689f, 0.19356298f, -0.57752568f, -0.58386064f, -0.54948950f, 
    0.04586210f, 0.04083702f, 0.00986397f, 0.02973506f, 0.07824911f, -0.02549525f, -0.14497496f, -0.12689355f, 
    -0.32690316f, 0.07177225f, 0.14105839f, 0.29481226f, 0.13792126f, 0.00105829f, -0.23479649f, -0.11375823f, 
    0.01843835f, 0.72381949f, 0.20247285f, 0.22524804f, 0.47364953f, 0.32320198f, 0.17169273f, 0.06260569f, 
    0.04303590f, 0.03881538f, 0.05629501f, -0.07960596f, -0.05445497f, 0.01741683f, -0.02835698f, 0.01374218f, 
    0.00748553f, 0.03516382f, -0.08885587f, -0.09053782f, -0.00077296f, -0.04443632f, 0.00655618f, 0.04558522f, 
    -0.09739672f, -0.07214057f, 0.01295200f, -0.02167940f, -0.01088427f, -0.04737221f, -0.04068749f, 0.03933501f, 
    0.02708272f, -0.07605860f, -0.11207433f, -0.02629504f, -0.00542899f, 0.04166893f, -0.01455018f, 0.04494351f, 
    0.06987927f, 0.04746025f, -0.05615525f, 0.04596372f, -0.11442624f, -0.08469319f, -0.04596245f, -0.09588711f, 
    0.04558684f, 0.01567605f, -0.10690948f, -0.04449393f, 0.00495159f, 0.00981403f, 0.00449699f, -0.02645968f, 
    -0.09973127f, -0.04083165f, -0.01500969f, -0.06193772f, -0.07054239f, 0.01035033f, -0.08725095f, -0.07825011f, 
    0.03380195f, -0.03120207f, -0.12363393f, -0.03731459f, -0.08404537f, -0.03614637f, -0.13277355f, 0.00112689f, 
    -0.05817406f, -0.03284785f, -0.01013330f, -0.00206723f, -0.06556987f, -0.12465154f, 0.04525628f, 0.05294686f, 
    -0.06012929f, -0.02382234f, -0.11257396f, -0.09861061f, -0.02002015f, -0.02576315f, -0.09392705f, -0.08953995f, 
    -0.00460047f, -0.10624344f, -0.01461464f, 0.03255602f, 0.00726513f, -0.03195630f, -0.08506791f, 0.03842290f, 
    0.03149128f, -0.00657150f, -0.06935932f, -0.12080864f, -0.03633555f, 0.03828123f, -0.07678834f, -0.00966394f, 
    0.00044580f, -0.05470789f, -0.05310265f, 0.04668467f, -0.01706490f, -0.06399952f, -0.09745750f, -0.00093386f, 
    -0.03653700f, 0.03290698f, 0.05297723f, -0.02424839f, -0.04971443f, 0.03948550f, 0.02125840f, -0.05264524f, 
    -0.05884460f, 0.05226230f, 0.05674987f, -0.02052823f, -0.05420803f, -0.02826504f, -0.03915873f, -0.05786590f, 
    0.06074357f, 0.01400606f, -0.09792188f, -0.08525679f, 0.04359165f, -0.04899312f, -0.04898607f, -0.00865333f, 
    0.03711015f, -0.09933969f, 0.04103772f, -0.07517505f, -0.00798025f, -0.05009687f, 0.03692496f, -0.05259671f, 
    -0.08562507f, -0.02680502f, -0.06360133f, -0.10506834f, -0.07167803f, 0.04658889f, -0.05432989f, -0.07852904f, 
    -0.28121156f, -0.01766759f, -0.32713979f, 0.06489474f, -0.47429326f, 0.06989737f, -0.16179307f, -0.18170862f, 
    -0.35478088f, 0.29753625f, 0.57840812f, 0.49803594f, -0.24616605f, -0.02620427f, 0.08345696f, 0.11204743f, 
    0.15069526f, -0.01435347f, 0.25997868f, -0.11926055f, 0.21005510f, -0.45381024f, -0.02515674f, -0.51351994f, 
    0.01349043f, -0.11259256f, -0.12915348f, -0.06340506f, 0.19637716f, 0.35587990f, -0.09708911f, -0.15879844f, 
    -0.18530884f, 0.07796038f, -0.22821952f, -0.09287503f, -0.42454961f, -0.32059616f, -0.41092825f, 0.22526219f, 
    -0.03996539f, 0.30573437f, -0.18324247f, 0.21408728f, 0.30754101f, -0.09456548f, 0.22148435f, 0.02888544f, 
    -0.07456774f, -0.10742179f, -0.17346050f, 0.18133035f, 0.05238302f, -0.07494032f, 0.41901907f, 0.20288903f, 
    0.10392722f, 0.31071645f, 0.19722757f, 0.08615196f, 0.13169369f, 0.15744859f, 0.09291805f, 0.60492676f, 
    0.28405991f, 0.39810172f, -0.28122917f, 0.15775244f, -0.02476431f, 0.01055781f, 0.24315950f, 0.12204725f, 
    -0.21722677f, -0.68417138f, -0.10256215f, 0.03472859f, 0.03774984f, 0.01532229f, 0.06105347f, -0.21208917f, 
    -0.12737723f, 0.21062988f, 0.32848176f, 0.61599797f, -0.04779151f, -0.11009408f, -0.03265871f, 0.21537922f, 
    0.17868552f, 0.10997152f, 0.23361142f, -0.01951556f, 0.02670107f, 0.45907474f, -0.02501860f, -0.09038056f, 
    0.32062745f, -0.01544243f, 0.41836429f, 0.03695284f, 0.14659844f, 0.16936491f, -0.15161785f, 0.03911610f, 
    0.10042579f, 0.16771832f, 0.12542105f, 0.11116949f, -0.57954109f, 0.27005264f, 0.25881216f, 0.00080406f, 
    -0.20911267f, -0.01166054f, -0.29328433f, 0.19847131f, 0.32536176f, -0.31797618f, 0.26877704f, 0.03922764f, 
    -0.27973223f, 0.08184270f, -0.31255552f, -0.01760737f, 0.02387065f, 0.08694490f, 0.48574066f, 0.24839433f, 
    0.48587149f, 0.03698689f, -0.01312871f, -0.02620195f, 0.13130136f, -0.04009863f, 0.01670789f, -0.29850906f, 
    0.20369476f, -0.01490440f, -0.16553465f, 0.26790527f, -0.06904402f, -0.10543236f, -0.06588235f, -0.20665704f, 
    0.42074016f, -0.29824781f, -0.22853348f, -0.35812524f, 0.09053575f, 0.07367539f, 0.09242139f, 0.14255072f, 
    0.09345360f, -0.04335523f, -0.44799602f, -0.69582653f, -0.03885452f, 0.02423839f, -0.10499922f, -0.17130013f, 
    0.01253056f, 0.00775310f, 0.07940627f, -0.56063479f, -0.38322520f, -0.21083662f, 0.19306408f, -0.15725937f, 
    0.02909973f, -0.04105590f, 0.07529974f, 0.36732924f, 0.10695499f, -0.37911135f, 0.00760916f, 0.08234415f, 
    0.01203929f, -0.05287770f, -0.06310964f, -0.06660279f, -0.84392476f, -0.03713277f, 0.14445062f, -0.18536930f, 
    -0.09032477f, 0.09928767f, 0.02081372f, 0.00439162f, 0.03823581f, -0.34375289f, 0.11808892f, 0.33215034f, 
    -0.15719868f, 0.18620318f, -0.06513759f, 0.28679705f, -0.03488271f, 0.26574779f, 0.02555685f, -0.24852949f, 
    -0.19743569f, -0.31665048f, -0.02802489f, 0.04984984f, 0.11231665f, -0.01178714f, 0.05811447f, 0.62222552f, 
    0.01843474f, -0.23885462f, 0.03140043f, 0.13916691f, -0.00089312f, 0.18479887f, 0.19637012f, -0.13609579f, 
    -0.35083136f, 0.10706108f, 0.35079691f, 0.08599724f, -0.14709203f, 0.03714059f, -0.00898424f, 0.10819484f, 
    0.10732939f, 0.21685527f, 0.14689420f, -0.47600529f, -0.09337030f, -0.30746600f, 0.02713431f, 0.00676990f, 
    0.26339686f, -0.10936210f, 0.39507815f, 0.02794975f, 0.10318241f, -0.05963310f, -0.23065068f, -0.20670062f, 
    0.22370991f, -0.08968410f, -0.00264354f, 0.82735831f, -0.09843278f, -0.47041184f, -0.12648284f, 0.00839201f, 
    -0.22063541f, 0.22759274f, -0.03730539f, 0.04727979f, -1.13762665f, -0.15196110f, -0.12580626f, -0.11995360f, 
    -0.05694888f, -0.15636866f, 0.16325775f, -0.09934992f, 0.17981204f, 0.43438545f, -0.34817603f, -0.52481240f, 
    0.03827576f, 0.10503104f, -0.01133678f, 0.22580464f, -0.03151961f, -0.07380351f, 0.11561997f, -0.04749418f, 
    0.18838578f, -0.16012207f, -0.17589752f, 0.05276588f, -0.07193955f, 0.11148667f, 0.02721405f, 0.73148108f, 
    0.13590696f, -0.25642627f, 0.12318034f, 0.22444203f, 0.08090498f, -0.09132226f, 0.16721366f, 0.20622306f, 
    -0.06917140f, -0.78520173f, 0.10445463f, -0.11646871f, 0.30412999f, 0.17108947f, 0.15780053f, 0.15753667f, 
    0.32877737f, -0.05494136f, 0.01477922f, -0.13405730f, -0.04729645f, 0.11027947f, -0.25158811f, 0.00538308f, 
    0.03150247f, -0.33924344f, -0.41137546f, -0.25112787f, 0.10248422f, -0.03723274f, 0.14155237f, 0.09908342f, 
    0.04126185f, -0.02829831f, -0.14055821f, -0.22005063f, -0.52876967f, -0.45076177f, -0.18190920f, 0.23051730f, 
    0.27948746f, 0.09955160f, -0.13809125f, 0.23935737f, 0.45196059f, 0.24451117f, -0.08853262f, -0.08088553f, 
    -0.05571974f, -0.31392407f, -0.13139959f, -0.03397362f, -0.17269003f, 0.15538941f, 0.31876770f, 0.19018827f, 
    0.05570113f, 0.09740686f, 0.07527173f, 0.26667094f, -0.06218212f, -0.11353141f, -0.23314531f, -0.21304972f, 
    0.03962988f, 0.23918451f, 0.13685703f, -0.18729728f, 0.11232161f, -0.08453787f, -0.27218333f, -0.09051440f, 
    -0.67643660f, 0.00523110f, 0.14347005f, -0.09146540f, 0.04109650f, 0.10668925f, -0.17391154f, -0.06694429f, 
    0.40176401f, 0.36454058f, 0.22379754f, -0.09818547f, -0.07608040f, -0.06385133f, 0.15873905f, 0.09003146f, 
    0.10515495f, 0.34932178f, -0.17250256f, -0.11240131f, -0.01032457f, 0.15001385f, 0.34941572f, -0.08472794f, 
    -0.05044073f, 0.10039414f, 0.02457470f, 0.09180494f, -0.04245811f, -0.03172358f, 0.10197499f, -0.07565982f, 
    -0.17909117f, -0.04108600f, -0.52744514f, -0.12021742f, -0.37673759f, -0.44458830f, -0.05400518f, -0.03839093f, 
    0.48171812f, 0.09623358f, 0.19691968f, -0.22481911f, 0.21084447f, 0.07887294f, 0.16782391f, -0.05860962f, 
    0.39135408f, 0.08108159f, -0.09870676f, 0.21706182f, -0.12898345f, 0.45966735f, 0.16023476f, -0.10442139f, 
    0.25606567f, -0.13288744f, 0.08570375f, -0.10512926f, -0.02568048f, 0.18914151f, -0.01802185f, -0.22190677f, 
    0.20483305f, 0.16991264f, -0.27183494f, -0.07758547f, 0.12282454f, -0.03062606f, -0.07802249f, -0.23581125f, 
    -0.14584385f, -0.74543601f, 0.12535539f, -0.04061696f, 0.29937926f, 0.25554973f, 0.08916189f, 0.22067347f, 
    0.22844028f, -0.61051446f, -0.51383799f, 0.01525959f, -0.09125749f, 0.17001288f, -0.01431114f, -0.30184439f, 
    -0.07570930f, -0.83219975f, -0.32051623f, -0.32977667f, -0.05465581f, -0.10177327f, -0.29208341f, 0.32873738f, 
    -0.15268847f, 0.06636462f, -0.61056501f, -0.30639678f, 0.27411893f, 0.39716646f, -0.05389690f, 0.08413960f, 
    0.08865448f, 0.11754309f, -0.06898745f, 0.04903321f, 0.07500775f, 0.30694935f, -0.30543002f, -0.27990699f, 
    -0.17500228f, 0.02465054f, -0.05171188f, 0.09480327f, 0.44049564f, -0.52965713f, -0.67331541f, -0.03661034f, 
    0.27226532f, 0.40442476f, 0.09249187f, 0.04280455f, 0.03405794f, 0.07337273f, -0.03867541f, -0.12423656f, 
    0.18402086f, 0.16606948f, 0.20499553f, 0.03781348f, 0.18534553f, 0.33449623f, 0.04985137f, 0.03926496f, 
    -0.12238029f, -0.06202324f, 0.13543592f, -0.12102935f, 0.28728262f, 0.07231007f, 0.29221395f, -0.52167189f, 
    -0.24247964f, 0.00500133f, -0.04031362f, -0.00338176f, -0.08197101f, 0.20128444f, -0.16145928f, 0.14960742f, 
    -0.19630478f, -0.64440203f, -0.38917094f, 0.07391208f, 0.38532493f, 0.24736360f, -0.09426033f, 0.03677421f, 
    0.24559622f, -0.20241526f, -0.13480970f, 0.04486196f, -0.06714912f, -0.07501446f, 0.12591054f, 0.16389742f, 
    -0.05900096f, 0.08480830f, -0.05516997f, -0.50564289f, -0.13037288f, -0.06070314f, 0.09035656f, -0.13319087f, 
    0.41556185f, 0.04822581f, -0.18387103f, -0.58183634f, -0.52710313f, 0.05926434f, 0.02896110f, -0.14926557f, 
    0.27982280f, 0.11003529f, 0.06145073f, 0.21033844f, 0.24244526f, 0.09575564f, -0.20403813f, -0.07143822f, 
    -0.00231782f, 0.08236335f, -0.07297270f, 0.26663828f, 0.20365268f, 0.15044257f, 0.10812061f, 0.25980154f, 
    0.29076794f, -0.02891778f, 0.06295658f, -0.02005533f, -0.13524584f, -0.12255326f, 0.51554459f, 0.37948111f, 
    -0.45804483f, 0.04459006f, 0.18848202f, -0.02529784f, 0.19079387f, 0.06082018f, 0.01258643f, -0.07225621f, 
    0.22807039f, 0.12294637f, 0.18431686f, -0.14484906f, -0.01548072f, -0.08846566f, -0.14649306f, 0.32771891f, 
    -0.09871709f, -0.17314935f, 0.08477003f, -0.13404730f, -0.11809732f, 0.07614297f, 0.03006580f, 0.08527954f, 
    -0.15769172f, 0.23080835f, -0.63760144f, 0.15771234f, 0.32646748f, -0.04947900f, -0.31596392f, 0.00882202f, 
    0.13508554f, 0.07917664f, 0.01516162f, -0.20597097f, -0.08095356f, -0.20069285f, -0.24470098f, 0.01914154f, 
    0.05498801f, 0.09782957f, -0.06277121f, -0.56873590f, 0.09556627f, -0.00862743f, -0.16533498f, -0.06431007f, 
    0.00740239f, 0.06656767f, -0.01467096f, 0.14291142f, -0.20875184f, 0.07975055f, 0.03654615f, 0.09649753f, 
    0.03689586f, 0.25725624f, 0.02352424f, 0.02476989f, -0.08188749f, -0.26259094f, -0.17481109f, -0.17580490f, 
    -0.03123526f, -0.10508106f, -0.20662178f, 0.00406078f, 0.18296319f, 0.39152193f, 0.29254973f, -0.11597563f, 
    0.09073325f, -0.15482274f, -0.06176987f, -0.15780748f, 0.08088335f, -0.04798006f, -0.07459258f, 0.44715291f, 
    0.11418444f, -0.49690557f, 0.15740106f, -0.31874889f, 0.11137048f, -0.00999284f, -0.09544494f, 0.08322631f, 
    -0.01420934f, -0.21468677f, 0.21905670f, 0.08441485f, -0.00195348f, -0.14189962f, -0.02883855f, 0.12442640f, 
    0.08105358f, -0.52323729f, -0.03453978f, 0.58601075f, -0.04253818f, -0.12992966f, -0.04609926f, 0.10890126f, 
    -0.05415829f, 0.20128764f, 0.01241394f, -0.11748902f, -0.03321419f, -0.13190009f, 0.00656267f, -0.18125004f, 
    -0.00361913f, 0.19675909f, 0.22871616f, 0.26934704f, -0.01146119f, 0.15234180f, -0.07522213f, -0.06421342f, 
    -0.08906981f, -0.02453059f, 0.08878639f, 0.00387124f, 0.08704095f, 0.03521987f, 0.34045145f, 0.19748580f, 
    0.11274136f, 0.27255124f, 0.22611932f, 0.19154255f, -0.12447443f, -0.22742617f, -0.17678645f, 0.03421009f, 
    0.23076466f, -0.11056254f, 0.00971273f, -0.06006368f, 0.01965009f, -0.05435615f, -0.00132764f, 0.11632387f, 
    0.63756233f, -0.05306630f, -0.01848413f, -0.03804331f, 0.19420514f, 0.07874963f, -0.21555218f, 0.17655234f, 
    0.35307702f, 0.22201283f, 0.11762067f, 0.08079516f, -0.11414555f, 0.04574298f, 0.00620425f, 0.02968818f, 
    0.02986021f, -0.29833931f, -0.55080771f, 0.02700313f, 0.25814378f, 0.04779400f, 0.00512408f, 0.08790789f, 
    -0.22800466f, 0.69718862f, 0.46276614f, 0.11345997f, -0.05463401f, -0.34663358f, -0.20685866f, 0.07433797f, 
    0.10528999f, 0.32019430f, 0.22389024f, 0.32888320f, -0.11935144f, -0.16348854f, -0.60188138f, -0.26797333f, 
    -0.07292128f, 0.27746397f, 0.18234523f, 0.66875005f, -0.15069687f, -0.87926036f, 0.03584529f, -0.07665557f, 
    -0.01144194f, 0.07625379f, 0.02051880f, 0.10328932f, -0.45741463f, -0.40124297f, 0.45813620f, 0.05927264f, 
    0.04387680f, -0.10324688f, -0.16255724f, 0.27790105f, 0.08034183f, 0.04887125f, 0.22036818f, 0.05071891f, 
    -0.09610035f, -0.49782842f, -0.58308154f, 0.08720849f, 0.14688751f, 0.05389819f, 0.05891185f, 0.35458234f, 
    0.18923889f, 0.08268356f, -0.03259038f, -0.14134030f, -0.06757300f, 0.15344030f, 0.18598054f, 0.29190028f, 
    0.47261739f, 0.97520596f, -0.16202395f, 0.09082041f, -0.38560471f, 0.01500552f, 0.10904865f, -0.16223173f, 
    -0.31474778f, 0.07935741f, -0.11759397f, 0.11940248f, 0.05563804f, -0.07194223f, 0.16334514f, 0.06503887f, 
    0.02321109f, 0.18619610f, 0.43216774f, 0.15087283f, -0.00136326f, 0.08166764f, 0.07671570f, 0.15721008f, 
    -0.03152773f, -0.09797533f, 0.08324231f, 0.39570063f, 0.12805022f, -0.14724785f, -0.26205304f, 0.19223677f, 
    0.05036524f, 0.12048214f, 0.07284038f, 0.08065575f, 0.01689757f, 0.15057147f, -0.56431741f, -0.34332773f, 
    0.13291726f, 0.10422710f, 0.25555021f, -0.14154144f, -0.09691273f, 0.47134784f, -0.06553830f, 0.05700279f, 
    -0.13456514f, 0.08053169f, 0.03042315f, 0.22692205f, 0.06626072f, 0.76172817f, -0.34994230f, -0.39523757f, 
    0.09751327f, -0.19483027f, 0.09287309f, 0.01987205f, -0.20008309f, -0.18443821f, -0.22199109f, 0.62071735f, 
    0.32994059f, 0.02275599f, -0.07625801f, -0.06221702f, -0.08098528f, -0.21736047f, 0.14136873f, 0.24276356f, 
    0.21285543f, -0.06806856f, -0.13117321f, -0.14473292f, 0.05729314f, 0.21641397f, -0.25697061f, -0.17703246f, 
    0.25077072f, 0.07135853f, 0.54761910f, -0.33351135f, -0.48444599f, -0.02571000f, -0.02911192f, -0.05923535f, 
    -0.13422373f, -0.32831332f, -0.20659371f, -0.04794746f, 0.00747544f, 0.28875083f, -0.01481257f, -0.18054463f, 
    -0.04547188f, -0.10271596f, 0.04973156f, -0.08882364f, -0.06171592f, -0.16317143f, -0.28295505f, -0.29597270f, 
    -0.05623304f, 0.01518084f, 0.00682488f, -0.05949222f, 0.08164342f, 1.13173497f, -0.04024785f, -0.16785124f, 
    -0.34994060f, -0.01153324f, -0.01144973f, 0.08066776f, 0.10123827f, -0.17848964f, -0.11932931f, 0.05873509f, 
    0.02023190f, -0.07004744f, -0.03224313f, -0.11280391f, 0.08957483f, 0.25192192f, 0.02731930f, 0.24114349f, 
    0.12176565f, -0.13121808f, -0.06063138f, 0.05073873f, 0.02855982f, 0.06704723f, 0.15158123f, -0.09505826f, 
    -0.37027761f, 0.08789054f, 0.19734700f, 0.09981535f, 0.03999921f, -0.06003865f, -0.02771126f, -0.06718370f, 
    -0.11435142f, -0.84367126f, 0.16155061f, -0.04435882f, 0.05391342f, 0.06242772f, 0.21865632f, -0.12468358f, 
    -0.29587948f, 0.06618671f, 0.25584495f, -0.01469204f, 0.20547792f, 0.09017074f, 0.19405128f, 0.02735029f, 
    0.08307308f, -0.37867740f, -0.00441640f, 0.20998150f, -0.10714892f, -0.03960205f, -0.15131445f, 0.04441833f, 
    -0.06862532f, -0.11593179f, 0.03113161f, 0.18287568f, 0.04329563f, 0.29125834f, -0.11043637f, -0.08780650f, 
    -0.10576916f, 0.07755101f, -0.03258209f, 0.57885730f, -0.35238183f, -0.57643598f, 0.15723716f, 0.20916972f, 
    0.04801273f, -0.21730904f, 0.23548964f, 0.17285344f, 0.14404501f, -0.40224123f, -0.75117409f, -0.10553560f, 
    -0.03618500f, -0.17293292f, -0.09469450f, -0.34058705f, -0.00449758f, 0.53197765f, -0.04422056f, 0.21004750f, 
    -0.08651780f, -0.06078429f, -0.01638967f, 0.22267386f, 0.20028071f, 0.05996394f, -0.36478743f, -0.33103138f, 
    0.47096887f, -0.02675870f, -0.05195632f, -0.24286023f, -0.03394179f, 0.29885596f, 0.07481349f, 0.37619734f, 
    -0.02911389f, -0.21204922f, 0.02482757f, 0.19908623f, 0.08422673f, 0.05087918f, 0.14160319f, 0.01584795f, 
    -0.06996793f, -0.04461335f, -0.02584720f, 0.02148699f, 0.04950938f, -0.07185383f, 0.05405295f, -0.03785474f, 
    -0.06216051f, -0.05113922f, 0.00879301f, -0.08673781f, -0.01959435f, -0.00128350f, 0.00902320f, -0.04447946f, 
    0.04615633f, -0.08022180f, 0.04874326f, 0.03841359f, 0.01756064f, 0.01865646f, -0.08033267f, -0.04052290f, 
    0.05571483f, -0.01081471f, -0.06995960f, -0.08227155f, 0.00456802f, 0.03317299f, -0.05175396f, 0.05549849f, 
    -0.02758492f, -0.05199069f, -0.03060872f, -0.04745572f, 0.02750747f, -0.00381898f, 0.05756778f, -0.08522411f, 
    -0.06599341f, -0.08771008f, -0.08812948f, -0.07785662f, -0.00807954f, 0.05905905f, -0.03030023f, 0.01843701f, 
    -0.01736557f, -0.05591810f, -0.05191783f, 0.00917286f, -0.06279954f, 0.01422970f, -0.00145525f, 0.04237435f, 
    0.06038218f, -0.01477781f, -0.07032339f, 0.03269032f, -0.05587364f, -0.05925680f, 0.05861157f, -0.01585034f, 
    0.06410567f, -0.05533800f, 0.04640364f, 0.04633074f, -0.07170563f, 0.01662386f, -0.06748978f, -0.03759419f, 
    -0.07901372f, 0.05347146f, -0.03895210f, -0.08492395f, 0.06642898f, -0.07460031f, -0.03113678f, 0.03465720f, 
    0.04767473f, 0.04659552f, 0.04391256f, 0.04228732f, -0.00817106f, -0.01636006f, -0.00905929f, 0.01907887f, 
    -0.03218589f, 0.04935315f, 0.05859296f, 0.06086398f, 0.01318141f, -0.06526627f, -0.00096046f, -0.03316087f, 
    -0.01384293f, -0.03896837f, -0.02575258f, -0.06568348f, -0.05483714f, -0.07133394f, -0.03519608f, 0.00824526f, 
    -0.03845240f, 0.05977977f, 0.05115440f, -0.03071076f, 0.06576961f, -0.06747179f, -0.02544198f, -0.06795331f, 
    0.01026367f, 0.02016632f, 0.03856207f, -0.06251051f, 0.01690565f, -0.02542530f, 0.04616924f, -0.01767656f, 
    -0.00839099f, 0.02805601f, -0.01091986f, 0.05135741f, 0.04624373f, -0.08152456f, -0.08666623f, 0.01937129f, 
    0.00211085f, -0.03098574f, 0.01583474f, 0.05648559f, -0.07311568f, 0.03451424f, 0.07822070f, -0.04434547f, 
    -0.04426534f, 0.06734370f, -0.08535615f, 0.02936941f, 0.03460791f, 0.03428230f, -0.05822121f, -0.04582489f, 
    -0.25654224f, -0.23582488f, -0.01923711f, 0.09042466f, 0.18003868f, -0.13583229f, 0.07877968f, 0.07572863f, 
    -0.32369652f, -0.36432189f, -0.23710980f, 0.21375127f, -0.05924272f, -0.02486750f, -0.13468127f, -0.10412111f, 
    -0.07776091f, 0.24455203f, 0.09735324f, -0.17593470f, -0.48052853f, -0.30916184f, -0.22597693f, -0.21717487f, 
    0.11600161f, 0.26726353f, 0.36148754f, -0.61368537f, 0.05971644f, 0.49188906f, -0.03877950f, -0.04047037f, 
    0.04791176f, 0.02095212f, 0.00319367f, -0.21183477f, -0.96720529f, -1.07880628f, 0.00324014f, -0.05950334f, 
    0.28731555f, -0.02389929f, -0.10519364f, 0.12511624f, 0.08320161f, -0.11537704f, -0.05624583f, 0.11641442f, 
    -0.31003830f, 0.02757767f, -0.16885448f, 0.07914103f, 0.15035948f, 0.22154176f, -0.44961390f, -0.37853581f, 
    -0.13256918f, 0.04100226f, -0.01926410f, -0.21272583f, 0.11967805f, 0.05287523f, 0.21753243f, -0.38468057f, 
    0.25941333f, -0.86403942f, -0.05001456f, -0.10733522f, -0.08419406f, -0.07858568f, -0.08865867f, -0.16383471f, 
    0.02787070f, 0.03949038f, -0.03380424f, 0.08267804f, -0.03537111f, -0.00873103f, 0.16040508f, 0.12792546f, 
    -0.02345533f, -0.33525586f, -0.17512396f, -0.54412502f, -0.11794959f, -0.11570057f, -0.16026828f, 0.15243769f, 
    -0.10049697f, 0.06234071f, -0.25058445f, -0.60633129f, -0.06503542f, -0.18055977f, -0.48939735f, -0.10553929f, 
    0.03509453f, -0.21598807f, 0.37726548f, 0.51385748f, 0.56037748f, -0.00019138f, -0.19189470f, 0.12367987f, 
    -0.08375307f, 0.09010803f, 0.04374762f, 0.10672538f, 0.33370173f, 0.12426189f, 0.57498342f, 0.12095954f, 
    -0.07904842f, -0.00449387f, -0.07087775f, 0.19717273f, 0.00725680f, 0.21370964f, 0.63397038f, 0.15544519f, 
    -0.07619770f, 0.05193174f, 0.10772969f, -0.07605221f, 0.06568684f, 0.16681947f, -0.44556957f, -0.55813402f, 
    0.19100693f, -0.13411149f, -0.17059778f, -0.06711545f, 0.04021658f, -0.10423408f, 0.28775850f, 0.38813111f, 
    0.45202172f, 0.60927993f, 0.03542395f, 0.07874604f, -0.12499462f, 0.01085869f, 0.29375058f, 0.11102740f, 
    0.49507058f, -0.21860838f, 0.15461196f, 0.00018480f, 0.01684920f, -0.25605261f, 0.19153094f, 0.25902420f, 
    -0.35982814f, -0.76276809f, -0.05258377f, 0.02582204f, 0.07806739f, 0.17096432f, -0.28866830f, -0.00822310f, 
    -0.07696684f, -0.04220188f, -0.88422424f, -0.05806033f, -0.10496354f, -0.01125507f, -0.09781392f, -0.21258220f, 
    0.31340596f, 0.22260295f, 0.19966815f, 0.43043160f, 0.36548460f, 0.20683081f, 0.16183044f, -0.02820240f, 
    0.20006967f, 0.24659620f, 0.04198397f, 0.02346497f, -0.01174752f, -1.00274849f, -0.85241073f, -0.18772994f, 
    -0.36181059f, -0.25323263f, -0.19473943f, -0.16966344f, 0.03704543f, 0.15386151f, -0.27382216f, -0.36508039f, 
    0.35248238f, 0.04666581f, -0.19461720f, 0.07206574f, 0.16229920f, 0.43577972f, 0.43213946f, 0.06281614f, 
    0.42838886f, -0.23320447f, 0.11102232f, -0.13868554f, -0.04061973f, -0.34139675f, 0.19922267f, -0.20860697f, 
    -0.06659611f, 0.71346462f, -0.19226274f, -0.07702938f, -0.19377838f, -0.04657982f, 0.18915482f, 0.02847924f, 
    -0.23913807f, -0.09098005f, -0.04063276f, 0.11931483f, 0.01941806f, 0.03385193f, -0.03227419f, 0.25321886f, 
    0.14980039f, 0.36446989f, 0.43804958f, 0.48664474f, -0.21231182f, 0.02969182f, 0.11740790f, 0.24299124f, 
    -0.17876646f, -0.06642867f, -0.10327537f, 0.05552731f, -0.39926538f, -0.18523765f, -0.35639927f, -0.18233699f, 
    -0.07389216f, -0.01798732f, 0.19594245f, -0.39640328f, -0.39614591f, -0.07071815f, 0.13575999f, 0.06065631f, 
    0.35184300f, -0.08369181f, 0.29600364f, 0.15424976f, 0.26035070f, -0.81349146f, -1.56613517f, -0.45723936f, 
    0.04439587f, 0.19562651f, 0.37208658f, 0.15172762f, 0.03696196f, 0.18942508f, -0.32321215f, -0.02976663f, 
    0.12128504f, 0.07873002f, 0.19565468f, 0.12486140f, 0.18002215f, 0.18320365f, 0.09680050f, 0.35533050f, 
    0.10552576f, -0.29474208f, -0.10983510f, -0.28180727f, 0.12024262f, -0.21510519f, 0.14729548f, 0.04695623f, 
    -0.03827513f, 0.30410445f, -0.04680144f, 0.03359349f, 0.00463325f, 0.07956447f, 0.00918103f, 0.06766944f, 
    0.81646204f, -0.89256710f, -0.18684909f, -0.07066881f, -0.25687134f, -0.14289807f, 0.16410823f, 0.04620406f, 
    0.11956804f, -1.03659534f, 0.17569150f, 0.02514112f, -0.11820862f, -0.46059421f, -0.00149861f, -0.18043831f, 
    -0.18904640f, -0.07653088f, -0.36007550f, -0.55143899f, 0.34287566f, -0.37109119f, -0.05408894f, -0.37364173f, 
    0.01736412f, -0.19217461f, 0.02687622f, 0.09068809f, -0.07565402f, 0.06210667f, -0.10103429f, 0.08530630f, 
    -0.22610895f, 0.17431802f, 0.12806430f, 0.22281262f, -0.22871581f, 0.03547721f, -0.37545073f, 0.17675115f, 
    0.26020080f, 0.28145263f, -0.10621757f, 0.00933427f, -0.29804021f, 0.00933000f, 0.25654095f, 0.42972332f, 
    0.13343979f, 0.10898133f, -0.03986790f, 0.18287359f, 0.29101837f, 0.23177539f, 0.00547244f, 0.23270647f, 
    -0.46268421f, -0.23509811f, -0.14635605f, -0.05056236f, -0.21345162f, -0.06066594f, -0.16625607f, -0.71962100f, 
    0.25141388f, -0.19194715f, -0.30889457f, -0.12084439f, 0.09386943f, -0.07713116f, 0.01554848f, -0.16549043f, 
    0.04153702f, -0.67896360f, -0.51166844f, 0.11535272f, 0.12638347f, -0.01565964f, -0.01607952f, 0.07440345f, 
    0.12387826f, 0.26993012f, -0.45420748f, 0.27476007f, -0.15636623f, -0.16464660f, -0.06819292f, 0.12230920f, 
    0.10172113f, 0.07814623f, 0.02128704f, -0.22142266f, -0.28374180f, 0.08738621f, 0.11451074f, -0.02674432f, 
    -0.06446247f, -0.20573859f, -0.36353406f, -0.94406462f, 0.13844451f, -0.83846492f, 0.12880236f, 0.27376023f, 
    -0.00665914f, 0.00455556f, -0.08805233f, 0.03280332f, 0.38109452f, 0.68461055f, 0.03140941f, 0.06614503f, 
    0.05968838f, 0.37020135f, 0.21114263f, 0.11079391f, -0.03896930f, 0.14172800f, 0.41200337f, 0.45277366f, 
    0.01797649f, 0.00247102f, 0.01764527f, 0.06575463f, -0.00434797f, 0.15408251f, 0.29645520f, -0.30144900f, 
    -0.91611576f, -0.46459389f, -0.24751742f, -0.10387033f, -0.03455611f, 0.02586493f, -0.13900593f, 0.20101154f, 
    0.61833483f, 0.37089792f, -0.00845284f, 0.05989591f, 0.04730191f, 0.02104612f, 0.23775087f, 0.21150674f, 
    0.30912298f, -0.39775881f, 0.20407112f, -0.03882276f, -0.17540802f, 0.22017792f, -0.11059577f, -0.00176237f, 
    0.72924179f, 0.04673885f, 0.40264541f, -0.17294627f, -0.07563363f, 0.00299757f, -0.40951997f, 0.22174621f, 
    0.19589964f, 0.00835387f, 0.08313344f, 0.07809100f, 0.19115031f, 0.29989934f, 0.29701477f, -0.09646285f, 
    -0.04738234f, -0.20303124f, 0.24003345f, 0.31039590f, -0.03853496f, -0.14096683f, -0.14267321f, 0.08425592f, 
    -0.13369752f, -0.04362386f, 0.29814479f, -0.04045803f, -0.34562236f, 0.02823384f, 0.00471474f, -0.06578396f, 
    -0.03441477f, 0.09111653f, 0.02103609f, 0.00613746f, 0.14856188f, -0.07841466f, 0.02931616f, 0.17794907f, 
    0.02048839f, -0.11841700f, 0.42674184f, -0.15385148f, 0.46055281f, -0.06955446f, -0.03736095f, -0.01202758f, 
    -0.28807777f, 0.26236022f, -0.31271189f, -0.20886219f, 0.04423613f, -0.10663266f, -0.20687161f, 0.00326958f, 
    0.02288480f, -0.07176360f, 0.02400921f, 0.10930930f, -0.12985896f, 0.22889116f, 0.33896777f, 0.04483938f, 
    -1.19230545f, -0.30540675f, -0.13719232f, -0.02799153f, -0.16120797f, 0.04736475f, 0.05621839f, 0.09442756f, 
    -0.03539197f, 0.05552792f, -0.23218958f, 0.26290876f, -0.00824712f, 0.07920539f, -0.48644245f, 0.03308085f, 
    0.04075507f, -0.01680630f, -0.01877338f, -0.02303783f, -0.19963276f, 0.07110159f, 0.09732288f, 0.16225633f, 
    0.13137187f, -0.49582469f, -0.14503326f, 0.15577407f, 0.19907743f, 0.34255111f, 0.11962290f, -0.05717329f, 
    0.01779201f, 0.04808652f, 0.09524668f, -0.02005948f, 0.04835191f, 0.11790691f, 0.62354040f, -0.07421048f, 
    0.02547432f, 0.14992455f, 0.13975105f, 0.03955868f, 0.23500635f, -0.00086420f, 0.54562682f, -0.19382782f, 
    -0.15308186f, 0.16332822f, 0.03944581f, 0.03148850f, 0.28367203f, -0.18630634f, -0.28993338f, -0.05365181f, 
    0.36969736f, -0.05715140f, 0.04318228f, -0.11981717f, -0.16379632f, -0.03183024f, 0.09889100f, 0.29972968f, 
    0.86830771f, -0.24979001f, 0.02704636f, 0.28909361f, 0.45906585f, -0.14531715f, 0.22549814f, 0.16818501f, 
    -0.07962344f, -0.08272464f, -0.03181735f, 0.03732830f, 0.04305681f, -0.08550682f, 0.04158055f, 0.06256155f, 
    -0.04914483f, 0.00602801f, 0.07700436f, 0.02885796f, 0.00846497f, 0.04341975f, 0.01378039f, -0.01122235f, 
    0.06275272f, -0.07361411f, -0.00047685f, -0.04908366f, -0.07924286f, 0.02321697f, 0.02622807f, -0.08563013f, 
    0.04006398f, -0.01645545f, -0.05941399f, -0.04984557f, 0.02090166f, -0.09344000f, 0.03885087f, -0.06673847f, 
    -0.00247054f, 0.05015682f, -0.09703194f, -0.04012215f, -0.06238263f, -0.07118204f, -0.08320543f, -0.06388713f, 
    -0.00356625f, -0.01976350f, 0.06580059f, 0.02731578f, -0.07539475f, 0.03902366f, -0.04375893f, 0.05638271f, 
    -0.07734437f, 0.01910480f, 0.05630655f, 0.06158157f, -0.05465307f, -0.01832221f, -0.00200286f, -0.05925560f, 
    0.01665739f, 0.00362970f, -0.01697123f, -0.09060897f, -0.02674007f, -0.06282602f, -0.06810343f, 0.05508040f, 
    -0.06586475f, -0.08297210f, -0.01737037f, -0.08641177f, -0.03073986f, -0.09443466f, 0.02690786f, -0.08022992f, 
    -0.01100430f, 0.03176340f, 0.01951658f, 0.02019538f, -0.05178430f, -0.09953868f, 0.06204919f, 0.02445447f, 
    -0.00608862f, 0.02013026f, -0.06472623f, 0.04005736f, -0.06852410f, -0.09001055f, -0.01011449f, 0.00360888f, 
    0.00991080f, -0.02629624f, -0.01995846f, 0.06475495f, -0.07703135f, -0.07602575f, 0.05836665f, 0.00589534f, 
    -0.07418597f, -0.01436289f, -0.06799333f, 0.01294592f, 0.01369347f, -0.08754483f, 0.04267814f, -0.02219399f, 
    -0.01899515f, -0.03209398f, -0.04285985f, 0.05066890f, 0.03298201f, 0.02288789f, -0.03062806f, 0.06334761f, 
    -0.02954917f, -0.08555178f, 0.01122018f, 0.00289835f, -0.03232250f, 0.06651887f, 0.03519014f, -0.04662142f, 
    0.00744421f, -0.01210263f, 0.01651058f, 0.04061542f, -0.00328229f, -0.01065122f, -0.06037859f, -0.03641023f, 
    -0.03007800f, -0.00331992f, -0.00434568f, -0.02080807f, -0.07846573f, 0.06449339f, 0.04384951f, -0.06189574f, 
    -0.05841686f, -0.07969490f, -0.02813579f, -0.01496117f, -0.02354583f, -0.05183427f, -0.01937021f, -0.09208268f, 
    -0.06154228f, -0.03516489f, 0.08687284f, 0.02790487f, -0.01562460f, 0.08129421f, -0.04459509f, -0.03271873f, 
    -0.04017149f, 0.07792009f, -0.04863166f, -0.03785498f, 0.00515676f, -0.06607579f, -0.08533875f, 0.04891521f, 
    0.06573260f, -0.01422414f, 0.02568309f, 0.04201382f, -0.00125550f, -0.02214131f, -0.04948249f, -0.03888723f, 
    -0.03204976f, -0.07762685f, -0.01844002f, -0.04115190f, -0.06279024f, -0.06719720f, -0.04601770f, -0.00503908f, 
    -0.01534980f, 0.01834015f, 0.02168241f, 0.01116463f, 0.00742861f, -0.04175339f, -0.05287835f, 0.06640203f, 
    -0.04308439f, -0.06217452f, -0.01080715f, -0.06703337f, -0.04186372f, -0.01736543f, 0.06515694f, -0.03778663f, 
    0.03879364f, -0.04413754f, -0.09317134f, 0.00444558f, 0.02435977f, -0.02197567f, -0.01149202f, 0.01749057f, 
    -0.04847408f, 0.02327785f, 0.02422464f, -0.01046796f, 0.07197330f, 0.03719610f, 0.00248568f, -0.02140629f, 
    -0.07037779f, -0.05780011f, -0.00095372f, 0.02623278f, 0.01065489f, -0.06562650f, -0.04738078f, -0.05430009f, 
    -0.08950652f, -0.05043272f, 0.02353360f, -0.00889675f, -0.02085188f, 0.02360028f, -0.05501654f, -0.05777677f, 
    0.03121753f, 0.00125578f, 0.02908696f, 0.06106182f, -0.04647719f, -0.00650423f, -0.03360422f, 0.05852501f, 
    -0.07300573f, -0.04920335f, -0.09093143f, 0.03712169f, -0.02159903f, 0.02428794f, -0.03648273f, -0.06813402f, 
    -0.03021392f, -0.01024644f, -0.00428785f, 0.00062175f, -0.07219620f, -0.02056068f, 0.06650860f, -0.03194792f, 
    -0.05188820f, 0.02247359f, -0.02516298f, -0.07441489f, 0.03823717f, -0.04402316f, -0.01881577f, 0.03854512f, 
    -0.00471165f, -0.00729607f, -0.00859030f, -0.05338449f, -0.04761114f, 0.07014223f, 0.07324293f, -0.02181842f, 
    -0.00870438f, -0.09168956f, 0.06403607f, 0.00341800f, -0.04673858f, -0.01671369f, -0.07200447f, -0.06990840f, 
    -0.04339716f, 0.01391697f, -0.03008547f, -0.07064469f, 0.02408531f, 0.05384288f, -0.05017275f, 0.03376318f, 
    -0.04010392f, -0.01320533f, -0.01466688f, 0.06767553f, -0.01310656f, 0.04068035f, 0.04969065f, -0.03636793f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.65990710f, -0.01638080f, -0.01780303f, 0.27440608f, 0.12707792f, 0.42414874f, 0.11233392f, -0.40305290f, 
    0.57867980f, -0.04937397f, 0.12155208f, 0.32156035f, 0.50736320f, -0.04085723f, 0.00820697f, 0.03912009f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.30730215f, -0.02754284f, 0.17779316f, 0.09176696f, -0.32444954f, -0.42018196f, -1.12450802f, 0.87194312f, 
    -0.19383483f, -0.07483898f, -0.42911997f, 0.48080835f, 0.08374611f, 0.01000875f, -0.12175630f, 0.03680513f, 
    0.70694101f, -0.13570508f, -0.00175301f, -0.23038128f, -0.13020962f, -0.22482702f, -0.60110903f, -0.46882069f, 
    0.21603006f, -0.11056060f, -0.34821773f, 0.86060482f, -0.12439682f, -0.21803570f, -0.08627158f, -0.05158933f, 
    -0.30691382f, -0.07697858f, -0.28967988f, -0.12146307f, -0.41037482f, -0.26934630f, -0.12213600f, -0.72099656f, 
    1.06320310f, 0.15792586f, 0.80180162f, -0.01601907f, -0.26522914f, 0.27924168f, -0.05327234f, 0.16637167f, 
    -0.78124636f, -0.11608991f, 0.11176956f, 0.84094840f, -0.39800298f, -0.51712531f, 0.29790395f, 0.12156282f, 
    0.31582204f, -0.19998451f, -0.47640955f, -0.25774437f, -0.45763713f, 0.59622407f, -0.07607393f, 0.19016397f, 
    -0.34628391f, -0.08638354f, 0.70062375f, -0.22570507f, 0.12982339f, -0.45946041f, -0.00291809f, -0.20174848f, 
    -0.04935152f, -0.22339860f, -0.63019013f, 0.13815753f, -0.14996113f, 0.15381745f, 0.11052914f, -0.08438335f, 
    0.16122699f, -0.02075597f, -0.24540785f, -0.43155524f, -0.33550966f, 0.23424542f, 0.53966945f, 0.24667755f, 
    -0.25441179f, 0.10045104f, -0.20302147f, 0.36598021f, -0.42988005f, 0.04594564f, -0.16124752f, 0.05962006f, 
    -0.17821009f, -0.06271216f, -1.05545509f, -0.80253929f, 0.25016993f, 0.67686349f, -0.39939451f, -0.18982011f, 
    -0.12250794f, 0.18941608f, 0.68266863f, -0.96566314f, 0.80224276f, 0.01273717f, -0.10009277f, -0.11516589f, 
    0.27037078f, 0.06700785f, 0.10278939f, 0.56033957f, 0.38087013f, -1.02213740f, 0.29681051f, 0.65755540f, 
    -0.00890290f, 0.23384151f, -0.57970923f, -0.67918378f, -1.22977030f, -0.31533456f, -0.11500599f, 0.09517181f, 
    0.25892922f, -0.12860085f, 0.16159452f, 1.48558426f, -0.05660000f, 0.43991232f, 0.02142630f, -0.52743930f, 
    -0.27271503f, -0.22039053f, -0.20743100f, -0.54912180f, -0.37422207f, -0.48239502f, -0.12915270f, -0.13232125f, 
    -0.29685608f, 0.16664994f, -0.27327657f, -0.54163277f, 0.36988616f, 0.40629894f, 0.28734538f, -0.38094038f, 
    0.19875009f, -0.00099675f, -0.63141263f, 0.43258405f, 1.10476685f, -0.40596792f, 0.04559340f, -0.22925158f, 
    -0.08767027f, 0.04405786f, 0.53631139f, -0.41227716f, -0.88188910f, -0.29493317f, 0.27306336f, -0.08428672f, 
    -1.00833726f, -0.04583766f, 0.95014858f, -0.61586547f, 0.49959642f, 0.33479908f, 0.20825058f, 0.13019551f, 
    -0.00032733f, 0.18449378f, -0.53920370f, -0.64800835f, 0.44579402f, -0.35684472f, 0.10027687f, -0.51026791f, 
    -0.11131565f, -0.04848377f, -0.62586218f, -0.51509523f, -0.29649296f, 0.74233997f, -0.08658881f, -0.19573861f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.49680799f, 0.26669386f, 0.10307492f, -0.10051189f, -0.17998557f, -0.07945459f, 0.00458706f, -0.48440537f, 
    -0.20217918f, 0.20755489f, -0.20954616f, 0.30011418f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
