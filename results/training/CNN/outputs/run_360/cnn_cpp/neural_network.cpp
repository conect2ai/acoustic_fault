#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.30846286f, -0.31492484f, -0.95046133f, -0.54838526f, 0.09632942f, -0.24120143f, -0.08508471f, -0.49627885f, 
    0.52600682f, -0.94248384f, -0.46361357f, 0.92187858f, 0.37739244f, 0.55845696f, 0.66434902f, 0.00101201f, 
    -0.19069771f, -0.39952672f, -0.46243039f, 1.25575781f, 0.89538044f, -0.12954088f, 0.21983570f, 0.05674641f, 
    -0.48699063f, -0.16438989f, -0.42477441f, -0.06635759f, -0.77772373f, -0.59189802f, 0.74996465f, 1.11538124f, 
    -0.68772787f, 0.11648338f, -0.35182059f, -0.12587689f, -0.92517751f, -0.98098153f, -1.14321089f, -0.79588616f, 
    -0.23241375f, 0.65971631f, 0.41093814f, -0.02492588f, 0.11322539f, -0.09615236f, -1.32196176f, -0.66280353f, 
    -0.54192019f, 1.14140224f, 0.76381558f, -0.06288624f, -0.02563908f, -0.25727159f, -1.18396771f, 0.27813223f, 
    -0.51136494f, -0.32188180f, 1.00404096f, -0.56067812f, -0.53118086f, 0.38536862f, 0.25533628f, -0.34233135f, 
    -0.69007027f, 0.31570172f, -0.32239828f, 0.86273694f, 1.01348937f, -0.25763246f, -0.25714606f, 0.20710206f, 
    1.20200789f, 0.94745141f, 0.24376914f, -0.80824447f, -1.03967643f, -0.12680818f, 0.08731429f, 0.63514662f, 
    -0.00231297f, 0.72525185f, 1.08527732f, 1.02019119f, -0.31437886f, 0.63880605f, -0.11866271f, 0.62927914f, 
    0.33900729f, -0.01455494f, 0.67527115f, -1.05753350f, 0.64168167f, 0.73527348f, -0.47418693f, 0.20933954f, 
    -0.59349352f, -0.34090382f, -0.97180170f, 0.58252966f, -1.14218593f, -0.82159895f, -0.60933608f, 0.21387486f, 
    -0.35523739f, -0.50805295f, 0.65007460f, -0.04851566f, -0.29543298f, 0.26151368f, 1.19162798f, 1.04708230f, 
    0.34417307f, -0.17010956f, 0.53285706f, 0.20748951f, 0.38999623f, 1.17500603f, 0.76649082f, -0.42337805f, 
    0.47655860f, 0.52374095f, -0.50794733f, 0.46081498f, -0.10666686f, -0.09954915f, -1.29386628f, 0.76023918f, 
    0.81134850f, 0.49561659f, 0.74084109f, 0.32618845f, -0.37239245f, 0.31367055f, 0.06885210f, -0.92720878f, 
    -1.27971184f, -0.75130367f, 0.59299755f, 0.65631819f, 0.67686343f, -0.28126752f, 0.43605849f, -0.12209231f, 
    0.61375684f, 0.87446576f, -1.12351310f, -0.03345374f, -0.64662760f, -0.68930054f, 0.07623404f, 0.37807661f, 
    0.26185584f, 0.78569764f, 0.84620339f, -0.74514663f, 0.78152794f, -0.22536981f, 0.26544684f, -0.41064292f, 
    0.24302733f, 0.59127611f, -0.03076493f, 0.83843482f, -0.65563756f, 0.16063833f, -0.68742889f, -0.64386475f, 
    -0.61370653f, -0.27101555f, -0.83670497f, 0.99249160f, 0.56865996f, 1.05771768f, -0.02341562f, -1.00065923f, 
    -0.10392144f, -0.27981696f, -0.19161986f, 0.37508002f, -1.32901227f, 0.54348534f, -0.38283065f, 0.89436322f, 
    1.01821828f, 0.43482831f, -0.10626788f, -0.74258000f, 0.18987849f, 0.64387518f, -0.78471166f, -0.88087493f, 
    0.38477117f, -0.64805603f, -0.80262560f, -0.25319535f, 0.12035609f, 0.08129794f, 0.73525196f, 0.75519913f, 
    -0.18532833f, 0.34088477f, 0.65305805f, 0.88298547f, -0.44216689f, 0.56970173f, -0.17687692f, -0.67049205f, 
    0.80686623f, 1.12808919f, 0.19699903f, -0.39853865f, 0.53293771f, 0.10046383f, 0.24472868f, 0.09178118f, 
    -0.26245540f, 0.98728657f, 0.02840671f, 0.47723058f, -0.86445600f, -1.23957801f, 0.43626946f, 0.16632144f, 
    0.09471944f, 1.21685135f, 0.32214013f, -0.65241796f, 0.37713167f, 0.71221507f, 0.69282228f, -0.19790365f, 
    -0.58039618f, 0.25350696f, -0.33474860f, -0.95940870f, 0.87314498f, -1.27575672f, 0.71886051f, -0.22378473f, 
    -0.01300974f, -0.21802919f, -0.17024277f, 0.89798582f, 0.34556156f, 0.53433955f, 0.51786470f, -0.87918544f, 
    0.70827281f, 0.47590512f, 0.45075494f, 0.00344104f, 0.80165744f, -1.39012814f, 1.17912364f, 0.55825508f, 
    -0.72120130f, 0.62172675f, 0.16081819f, -0.13975030f, -0.28393695f, -0.65813893f, 1.54186046f, -0.87758207f, 
    -0.23724245f, 0.53293419f, -0.61493009f, 0.23905835f, 0.01603931f, -0.05557681f, 0.81895202f, 0.94639635f, 
    0.41951218f, 0.68259460f, 0.80231410f, 0.34499335f, -0.17148454f, -0.01111474f, -0.64181215f, 0.81218553f, 
    1.30772257f, 0.32242271f, -1.14008605f, 0.66684550f, -0.19829412f, -0.37486556f, -0.09492077f, 0.09487601f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17350468f, 0.24119370f, 0.23684187f, 0.11478549f, 0.02607067f, -0.01409026f, -0.03102060f, 0.18485461f, 
    -0.09136585f, 0.19464844f, -0.10860352f, 0.29488578f, 0.03841236f, 0.10105487f, 0.26131323f, 0.11897781f, 
    -0.03694051f, 0.07909176f, -0.18877721f, -0.01806184f, -0.15882644f, 0.33034965f, 0.16648620f, -0.12836076f, 
    0.09011349f, 0.21084413f, 0.08568751f, 0.16825698f, -0.04970108f, 0.07830898f, 0.14449646f, 0.15052232f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12797192f, -0.22963960f, 0.21291125f, 0.24530880f, 0.03559015f, -0.01955284f, -0.04328309f, 0.03378938f, 
    0.03482379f, -0.00226473f, -0.00371049f, 0.01703632f, 0.08427210f, 0.11209156f, -0.03626941f, 0.01261779f, 
    -0.09495135f, -0.12759164f, -0.00503083f, -0.09801669f, -0.10006335f, 0.07911140f, 0.20510493f, 0.05674143f, 
    -0.11241995f, 0.00825427f, 0.01247627f, 0.02621360f, -0.05669576f, -0.00318634f, -0.02184397f, -0.02167955f, 
    0.03485308f, 0.00052875f, -0.06620152f, 0.03412825f, -0.08640724f, -0.15073290f, 0.14199142f, 0.06448891f, 
    -0.16819941f, 0.07870078f, 0.10418236f, 0.04863465f, 0.32735240f, -0.04620091f, -0.17074130f, -0.01931695f, 
    0.01341684f, 0.02997035f, 0.03805544f, -0.05379894f, -0.03950497f, -0.00593322f, -0.07780309f, 0.05482923f, 
    -0.03080003f, -0.03023482f, -0.01760082f, 0.05217706f, 0.03658434f, 0.24490528f, 0.22100085f, -0.04025481f, 
    -0.16699134f, -0.13658547f, 0.02294084f, -0.01063600f, 0.03508182f, -0.15586086f, -0.00108572f, 0.14551303f, 
    0.00597440f, -0.03787835f, 0.01168388f, 0.03250313f, -0.00889750f, 0.05739299f, -0.09215702f, -0.02104208f, 
    -0.39734110f, -0.04249248f, -0.19138075f, -0.03400677f, -0.34295332f, -0.13860242f, -0.03820666f, -0.04424468f, 
    0.13592778f, -0.01873268f, 0.02281968f, -0.09125104f, -0.11294065f, 0.00072551f, 0.03393603f, -0.04139387f, 
    -0.15778077f, 0.01383821f, 0.11239012f, -0.10845114f, -0.33101571f, 0.25060436f, -0.09863561f, -0.18622258f, 
    -0.35235941f, -0.07249097f, 0.09263664f, -0.05823607f, -0.00551654f, 0.08954410f, -0.00822592f, 0.00410404f, 
    0.05074671f, 0.01949379f, -0.00595868f, 0.03078487f, -0.03410828f, -0.01850386f, -0.03450963f, -0.04964341f, 
    0.50941736f, 0.07174890f, 0.04999378f, -0.22918271f, -0.08422815f, 0.02524321f, -0.00303772f, 0.01139153f, 
    0.02339405f, 0.13683832f, 0.04665764f, 0.08770338f, -0.15283874f, -0.02435309f, 0.03069785f, -0.14754236f, 
    -0.01634713f, 0.08325676f, 0.13529862f, -0.02013053f, -0.27972698f, 0.16618444f, -0.01482783f, 0.03821547f, 
    -0.16825277f, 0.03558500f, 0.06446004f, -0.03336336f, 0.08901518f, -0.17189755f, 0.06264213f, -0.02641394f, 
    -0.04547768f, -0.00729613f, 0.03084002f, -0.06329665f, 0.02899654f, -0.09839358f, 0.14070709f, -0.01092609f, 
    0.23085818f, 0.01408927f, 0.16614994f, -0.23545599f, 0.08580666f, -0.15098006f, -0.13052651f, -0.12070405f, 
    0.07057677f, -0.01237621f, -0.01983511f, 0.01785126f, 0.06235013f, -0.08232372f, 0.01748704f, -0.03754617f, 
    0.08416840f, -0.01349423f, 0.11082534f, 0.08747577f, 0.15581428f, 0.12327154f, -0.03238245f, -0.14031586f, 
    0.10388580f, -0.14485414f, -0.15219726f, -0.05058300f, 0.04608125f, -0.01618367f, -0.03047294f, 0.04020291f, 
    -0.03391050f, -0.01225778f, 0.02361200f, -0.11740150f, -0.03596226f, 0.04427177f, -0.04209978f, -0.01651523f, 
    0.23234704f, -0.23926547f, 0.15820086f, 0.18330300f, -0.43690884f, 0.05323726f, -0.05834675f, 0.00765031f, 
    -0.01085728f, 0.03084008f, -0.07860757f, 0.00575617f, 0.12373378f, 0.07083935f, -0.02639805f, 0.14953648f, 
    -0.01784506f, 0.12375193f, -0.02423301f, 0.13950551f, -0.12360983f, -0.59516096f, 0.10614401f, 0.01211908f, 
    -0.29022977f, -0.04137451f, -0.11723822f, 0.03037631f, -0.07510347f, 0.05430605f, -0.00074920f, 0.13407251f, 
    0.06229586f, -0.07484945f, 0.04881459f, -0.10813722f, -0.08395311f, -0.13772923f, 0.01006418f, -0.02380772f, 
    -0.26095730f, -0.17001908f, 0.28922397f, -0.00616773f, -0.18363956f, -0.04018321f, -0.09724738f, 0.09133463f, 
    -0.16431402f, -0.02722893f, -0.01764482f, 0.07242753f, 0.10755841f, -0.02991322f, 0.07455789f, -0.05122163f, 
    -0.00220736f, 0.04114773f, 0.01797538f, -0.00427377f, -0.01302278f, 0.17033119f, 0.07703429f, -0.03940583f, 
    0.31521514f, -0.19125569f, 0.03830312f, 0.18810283f, 0.14927992f, -0.04694546f, 0.02106613f, 0.07375916f, 
    -0.02139559f, -0.03433922f, -0.01907488f, 0.02036949f, -0.11802368f, 0.03790120f, -0.01468100f, -0.01720757f, 
    0.17853886f, 0.08513140f, 0.21610157f, 0.06867756f, 0.01431759f, 0.03101210f, 0.03678352f, 0.07013209f, 
    -0.11192252f, -0.09524085f, 0.00614326f, -0.11202023f, -0.00200814f, -0.03272640f, 0.01395183f, 0.03610496f, 
    -0.07714397f, -0.02742997f, 0.00549842f, -0.02071116f, -0.08492826f, 0.13068821f, -0.16228859f, -0.36667231f, 
    -0.50961500f, 0.08441217f, 0.07080708f, -0.02322268f, 0.20862783f, -0.04195330f, -0.00707879f, 0.00069905f, 
    0.05577701f, -0.03369850f, -0.06056553f, 0.02948138f, -0.08413645f, 0.01986797f, -0.04924688f, -0.02162746f, 
    0.02230289f, -0.21949799f, 0.16910128f, -0.12070200f, 0.22733870f, -0.21629222f, -0.02212900f, -0.10858737f, 
    0.06413164f, 0.06944712f, -0.01780270f, 0.00453993f, 0.04863063f, -0.05683682f, -0.03110677f, -0.04836793f, 
    -0.08207197f, 0.11571418f, 0.02850490f, -0.01587485f, 0.20902780f, -0.18069461f, 0.03457132f, -0.12868720f, 
    0.14614379f, -0.10149587f, -0.13545196f, -0.05637160f, 0.03716945f, -0.10151607f, -0.02663809f, 0.02357229f, 
    -0.01567942f, 0.16699557f, -0.09769292f, 0.06852022f, -0.01940545f, 0.00572037f, -0.13527773f, 0.05858551f, 
    0.05708165f, -0.04211242f, 0.30035442f, 0.08678764f, 0.19301145f, 0.03507001f, -0.24774876f, 0.04597833f, 
    -0.00130352f, 0.03682097f, -0.00429820f, 0.08947644f, -0.06367071f, 0.07543391f, -0.10038051f, -0.00476467f, 
    0.09742501f, 0.02672299f, -0.05014509f, -0.08059932f, 0.21245120f, -0.00040860f, 0.01827139f, -0.14826751f, 
    -0.06871974f, -0.12105390f, -0.17502961f, -0.11785647f, 0.00736005f, 0.00427733f, 0.00957531f, -0.00780583f, 
    0.02053407f, 0.04243888f, -0.07626133f, 0.08105837f, -0.00947032f, -0.07645606f, 0.08204121f, 0.07085644f, 
    0.67778909f, 0.11767140f, 0.23848617f, -0.09778923f, -0.12535642f, 0.08581646f, 0.01419800f, 0.02201661f, 
    -0.01329754f, -0.10744599f, 0.06095606f, -0.08230944f, -0.09160477f, -0.06517695f, 0.06987986f, 0.07938317f, 
    0.08264206f, -0.04698944f, 0.03642125f, 0.04344737f, -0.07523892f, -0.74258792f, 0.18709604f, 0.10678681f, 
    -0.04969727f, 0.07021922f, -0.08967172f, 0.02345117f, -0.03571874f, -0.05926740f, -0.15604267f, 0.02421416f, 
    -0.07606936f, 0.00808137f, 0.05089236f, -0.00409700f, -0.01464448f, 0.06297725f, -0.09473607f, -0.05047307f, 
    0.08262239f, -0.01718868f, -0.14627443f, -0.19160761f, 0.21788643f, -0.02788515f, -0.14727370f, -0.06060812f, 
    0.05016619f, 0.06969884f, -0.11537542f, -0.06836785f, 0.05386332f, -0.05961924f, 0.07277336f, -0.03860345f, 
    -0.00384005f, -0.03719184f, -0.04685433f, 0.08258240f, -0.63580585f, 0.22468933f, 0.10025275f, 0.10744603f, 
    0.17245327f, -0.03778654f, -0.03938266f, 0.05848117f, -0.01673038f, 0.03569664f, 0.10184001f, -0.11030613f, 
    0.09037848f, 0.03583683f, -0.01238676f, -0.16356605f, -0.06231038f, -0.10628100f, -0.06711772f, 0.02349888f, 
    -0.21545564f, -0.02953156f, 0.06065641f, -0.12575978f, -0.00092236f, -0.16037035f, -0.08235543f, 0.06301188f, 
    -0.14611197f, 0.00308441f, 0.01731667f, 0.10823355f, -0.02588501f, 0.03128319f, -0.00378247f, 0.00836597f, 
    -0.03790574f, 0.10899755f, -0.02182380f, -0.17282617f, -0.09082372f, 0.01089286f, -0.00682769f, -0.08044156f, 
    0.22695704f, -0.03703379f, -0.05056770f, -0.07740348f, 0.07269140f, -0.11355983f, -0.09084601f, 0.06239413f, 
    0.04906593f, -0.06892116f, -0.06446156f, 0.03345358f, 0.05923394f, -0.03260228f, -0.13282076f, 0.00394135f, 
    0.15237738f, -0.31905252f, -0.07614680f, 0.15497020f, -0.44442555f, -0.15108648f, 0.02375725f, -0.01616263f, 
    0.04040928f, -0.12466933f, 0.08699243f, 0.04657429f, -0.08908821f, -0.06109845f, -0.05329987f, -0.09047823f, 
    -0.14921600f, -0.03376116f, -0.07282582f, 0.04099480f, 0.19416933f, -0.20091921f, 0.04408027f, -0.21836360f, 
    -0.10429605f, -0.10214495f, 0.08866478f, -0.12503143f, -0.02493997f, 0.04104640f, -0.06902231f, -0.07849151f, 
    -0.01900109f, 0.06532357f, -0.03689194f, 0.00546940f, -0.10273723f, -0.02757733f, -0.01895927f, 0.03355533f, 
    0.32640842f, -0.32480967f, 0.04814626f, 0.11727195f, -0.59685183f, -0.02878708f, 0.01965341f, 0.02632006f, 
    0.04528649f, 0.00294800f, -0.24479023f, 0.13202552f, -0.12498562f, 0.02692044f, 0.02577791f, -0.07337730f, 
    -0.06068339f, 0.08139895f, -0.04542095f, -0.01515236f, 0.31464586f, 0.05696901f, 0.08681502f, -0.14203657f, 
    0.26123944f, 0.01609708f, -0.04472993f, 0.05431345f, -0.06575622f, 0.08071651f, -0.02089919f, 0.02864614f, 
    -0.14621657f, -0.06559010f, 0.18078193f, -0.13007073f, -0.10948090f, 0.13922180f, -0.03233474f, -0.22847572f, 
    0.09681261f, 0.02371811f, 0.09524786f, -0.10213485f, 0.21948928f, -0.30044490f, -0.16066775f, 0.06375580f, 
    0.05629477f, -0.01592882f, 0.03931382f, 0.12766545f, -0.05239733f, -0.03234348f, 0.11277535f, 0.06549028f, 
    0.00847166f, -0.07210845f, -0.06247294f, 0.03963781f, 0.02804971f, 0.12752236f, -0.03709040f, -0.24106917f, 
    0.22559279f, -0.26015225f, -0.09373464f, -0.12984470f, 0.05120828f, 0.04958341f, -0.00815503f, -0.03984820f, 
    0.03585312f, -0.19114733f, 0.04154811f, -0.11372577f, 0.15131846f, 0.01899165f, -0.01178990f, -0.06637141f, 
    0.29281384f, -0.58085006f, -0.06042882f, -0.25582877f, -0.13929528f, -0.07371956f, -0.07519674f, -0.02962642f, 
    -0.01879088f, -0.01872950f, -0.07696375f, 0.10474343f, -0.10382965f, 0.00365630f, 0.06300888f, -0.19834593f, 
    -0.13361655f, -0.01982149f, -0.04933447f, -0.10911863f, -0.30035025f, 0.06153832f, -0.10375077f, 0.02748184f, 
    -0.06659023f, -0.00652326f, 0.01585052f, -0.03005684f, -0.03040139f, 0.08718766f, -0.07806196f, 0.12732376f, 
    -0.13081747f, -0.01275106f, 0.06188773f, 0.03072207f, 0.03426380f, 0.06916400f, -0.03774489f, -0.03908686f, 
    0.05883062f, 0.16309403f, -0.17680588f, -0.08509845f, 0.18949872f, -0.07653128f, 0.16507241f, 0.06537671f, 
    -0.00367656f, 0.05332635f, -0.00522607f, -0.08059583f, 0.04273679f, -0.04729597f, 0.01150062f, -0.01324631f, 
    -0.09653559f, 0.07479653f, -0.09136267f, -0.01522133f, 0.11515419f, -0.34178731f, -0.29308057f, -0.01884557f, 
    -0.20531233f, 0.03349154f, 0.01189983f, -0.03821174f, 0.08679159f, 0.02382154f, 0.06155945f, 0.05727493f, 
    -0.08687773f, -0.06953314f, -0.01096891f, -0.03489092f, 0.10913987f, -0.16135909f, 0.08822274f, -0.08354152f, 
    0.23480543f, 0.06386042f, 0.00782245f, 0.06182476f, -0.16976663f, -0.02034161f, 0.04728985f, -0.02336652f, 
    0.18704289f, 0.05405556f, -0.08663057f, -0.16186398f, 0.11315566f, 0.09176826f, -0.09034011f, 0.04369586f, 
    0.05577831f, -0.09108356f, -0.05557621f, -0.09665316f, 0.32160214f, -0.47101125f, -0.09477367f, -0.02448442f, 
    -0.20764780f, -0.20328888f, 0.03143548f, -0.02931516f, 0.01075024f, -0.02177716f, 0.08404268f, -0.06853121f, 
    0.00640861f, 0.08277013f, 0.00569418f, 0.07776163f, -0.08981642f, -0.00007837f, -0.08199163f, 0.02711158f, 
    -0.34053162f, -0.06148137f, -0.23139386f, -0.23496225f, 0.14031506f, -0.01056369f, 0.01348110f, -0.02732957f, 
    -0.03684609f, 0.16980948f, -0.03201082f, -0.08972890f, 0.10825108f, -0.06301766f, 0.01732114f, -0.03379027f, 
    -0.00533042f, -0.01898658f, -0.13732363f, -0.11952778f, -0.13185182f, 0.09300005f, -0.08342672f, -0.04315554f, 
    -0.14062980f, -0.12839085f, -0.00185630f, -0.13239510f, -0.08943961f, -0.01981680f, -0.00197866f, 0.02935296f, 
    -0.06277309f, -0.05621767f, 0.00997100f, 0.04662102f, -0.10052337f, 0.06975959f, -0.04423149f, -0.00405893f, 
    0.18087700f, -0.17530824f, 0.04535006f, 0.13183704f, -0.04580690f, 0.08182611f, -0.21084838f, 0.04910333f, 
    0.06778623f, -0.06840114f, -0.00766723f, -0.06179675f, -0.06623557f, 0.14209506f, -0.01792280f, 0.08457952f, 
    -0.08860164f, -0.08343020f, -0.12479959f, -0.07502557f, 0.11164917f, 0.22924991f, 0.05029286f, 0.04033799f, 
    0.19899839f, -0.09562515f, -0.09927313f, 0.02101167f, -0.02197903f, -0.01547662f, 0.05657195f, 0.03056601f, 
    0.00415728f, -0.01543566f, -0.02997116f, -0.05404041f, 0.10137275f, 0.02552919f, -0.09911017f, 0.06842279f, 
    0.33277777f, -0.05548032f, 0.23497222f, -0.02044881f, -0.14453207f, -0.02110678f, 0.14281882f, 0.03946585f, 
    -0.01301127f, 0.09058086f, 0.08219579f, 0.06079252f, -0.01723636f, -0.05593165f, -0.11101049f, -0.01031358f, 
    -0.03236441f, -0.03356897f, 0.13571087f, 0.08839110f, 0.19533867f, -0.47681680f, -0.00549989f, -0.02837595f, 
    0.04476025f, -0.04067820f, 0.20194735f, 0.00360725f, 0.05025681f, 0.04182912f, -0.14803626f, -0.05866195f, 
    0.01199622f, 0.07872723f, -0.04636422f, 0.15631896f, 0.02569224f, 0.09361455f, 0.02406813f, 0.02945811f, 
    -0.25220451f, 0.05348187f, 0.27904812f, -0.04292774f, 0.07591666f, -0.19414452f, -0.03003215f, -0.03467719f, 
    -0.04069400f, 0.12209737f, -0.05924747f, -0.08717066f, -0.01851040f, -0.03858730f, 0.04759483f, 0.06970759f, 
    -0.05579324f, -0.01013328f, -0.03030364f, 0.14775443f, 0.34745857f, -0.36493942f, 0.16435112f, -0.08800782f, 
    0.01549004f, -0.19699951f, -0.11134174f, -0.08347315f, -0.04801738f, -0.04919584f, -0.14565401f, -0.08139218f, 
    -0.02965647f, 0.00142977f, 0.03686270f, -0.13065313f, 0.06350214f, -0.08676230f, 0.06300747f, 0.05494105f, 
    -0.36422262f, 0.21320735f, -0.06986325f, 0.01182376f, 0.01002205f, -0.08059900f, 0.03480092f, -0.02653585f, 
    -0.11612593f, 0.02624555f, -0.00468705f, 0.09281065f, 0.08514693f, -0.01671340f, -0.05439227f, 0.03585409f, 
    -0.13436259f, 0.10362043f, 0.07085924f, 0.04538830f, 0.32898113f, -0.04741305f, -0.17638662f, -0.02790524f, 
    -0.33334485f, -0.02313580f, -0.00201869f, 0.04449726f, -0.01130240f, 0.07238334f, 0.04538841f, 0.02517352f, 
    -0.04218234f, 0.10849674f, -0.10125884f, 0.08343448f, 0.24134372f, -0.02621874f, -0.00851668f, 0.02828712f, 
    0.04802211f, -0.32885000f, -0.03639711f, -0.35033101f, -0.03481102f, 0.09974956f, -0.07898647f, 0.17082685f, 
    0.03319623f, -0.00266307f, 0.02472491f, 0.00988602f, 0.06840946f, -0.04007389f, 0.08679687f, 0.01524379f, 
    -0.02593221f, -0.20758453f, -0.01718397f, -0.11886742f, 0.09849426f, -0.14606303f, 0.13116080f, -0.02200351f, 
    0.17918025f, -0.04420524f, -0.13043468f, 0.00431339f, 0.06961134f, -0.11918812f, -0.03240750f, 0.00831284f, 
    0.03739453f, -0.04836730f, 0.07798397f, 0.00068639f, 0.07605194f, 0.04704062f, 0.10765974f, -0.18790530f, 
    -0.21652444f, -0.23549658f, -0.32222232f, -0.36203372f, 0.24015678f, -0.00340742f, -0.11304539f, 0.06699363f, 
    -0.03940920f, 0.02399435f, 0.03399271f, -0.05255333f, -0.00788320f, -0.20725986f, -0.05615010f, -0.05960032f, 
    -0.10294419f, -0.13244395f, 0.12308782f, -0.15812080f, 0.07666052f, 0.09475076f, -0.01504266f, 0.07868157f, 
    0.06950258f, -0.07214848f, -0.11975633f, 0.06807131f, 0.02202665f, 0.05067850f, 0.05100488f, -0.07139481f, 
    -0.02173744f, 0.00068384f, 0.07995564f, 0.04521761f, -0.07154330f, -0.09023064f, -0.05199203f, -0.04040255f, 
    -0.49773362f, 0.10696445f, -0.12677740f, -0.02199063f, 0.01288533f, 0.04637538f, 0.02224091f, -0.07244141f, 
    -0.02189226f, -0.11750838f, 0.02761850f, 0.13319437f, -0.02760814f, -0.11587986f, 0.07954343f, 0.08598331f, 
    -0.00414042f, -0.04012165f, 0.08765873f, 0.01150377f, 0.12455133f, -0.14138825f, 0.18455207f, -0.23763756f, 
    -0.06775148f, 0.01137344f, 0.00418495f, 0.03774981f, 0.06180437f, -0.06009175f, -0.05987598f, -0.10172521f, 
    0.06967558f, -0.02325734f, -0.08302504f, -0.03846236f, 0.03341328f, -0.43235639f, 0.00035552f, -0.02591777f, 
    0.24626084f, 0.14869727f, 0.14464866f, 0.01687347f, 0.10103839f, 0.09283344f, -0.05579201f, -0.09489384f, 
    -0.02302844f, -0.00208244f, 0.03826380f, 0.07090984f, -0.05237113f, 0.08300754f, -0.12243593f, -0.00184250f, 
    0.05691390f, 0.05953142f, 0.02729956f, -0.07889344f, 0.12112710f, 0.05962625f, -0.12235580f, -0.02708341f, 
    -0.06222906f, -0.09013146f, -0.02039585f, 0.03575727f, -0.12381500f, -0.00816128f, -0.06940232f, 0.06260124f, 
    0.09218478f, -0.07099274f, 0.05700311f, 0.01392584f, -0.07307081f, 0.02664731f, -0.03940795f, 0.11826354f, 
    -0.15809037f, -0.28972882f, -0.05505308f, -0.16343631f, 0.07474225f, 0.09118296f, -0.01983866f, 0.04848313f, 
    -0.06257822f, 0.02927049f, 0.04997492f, 0.03559425f, 0.12708929f, -0.00085336f, -0.06427702f, -0.06730787f, 
    0.01429828f, -0.14482693f, -0.04254518f, 0.08713701f, 0.30898911f, -0.20918185f, 0.13970634f, 0.03895960f, 
    0.00745086f, -0.13174233f, 0.01784546f, -0.20760709f, 0.03491613f, 0.00504951f, 0.12137134f, 0.04113263f, 
    -0.07532961f, -0.00413743f, -0.01356468f, -0.09013912f, 0.00884027f, -0.02264882f, 0.06656585f, 0.08830769f, 
    -0.39487445f, -0.08773391f, 0.00772183f, 0.07926986f, -0.12622440f, -0.03064399f, -0.01583770f, -0.09069595f, 
    -0.03802881f, -0.07581685f, 0.10203866f, -0.02807680f, -0.15000249f, -0.07116409f, -0.04866396f, -0.22080666f, 
    -0.08214178f, -0.05245758f, -0.09264310f, -0.03035717f, 0.00986757f, 0.13108136f, 0.16843444f, 0.18118635f, 
    0.24391842f, -0.10281094f, -0.13353384f, -0.01288226f, -0.00043013f, -0.03505502f, 0.07095598f, 0.01367457f, 
    0.12578109f, -0.02886377f, -0.07651583f, 0.06127847f, 0.03628576f, 0.00926981f, 0.06370058f, 0.00096941f, 
    0.04293473f, 0.14808206f, 0.11114737f, -0.01946975f, -0.22720918f, -0.06114188f, -0.00590328f, 0.00104601f, 
    0.05384093f, 0.13220413f, 0.16213912f, -0.02296484f, 0.05560148f, -0.08942057f, -0.00731386f, 0.02155838f, 
    0.08025355f, -0.03435439f, 0.13755609f, 0.02861756f, -0.15213056f, -0.06027558f, -0.45349669f, -0.38053527f, 
    0.12354480f, -0.12046964f, 0.04003216f, -0.07032934f, -0.03455095f, 0.02592232f, 0.17228796f, -0.04133410f, 
    0.06270412f, 0.01720729f, 0.11100174f, 0.04820491f, 0.01624322f, -0.05962974f, -0.06286132f, -0.01914174f, 
    0.20617543f, 0.19598962f, 0.13813284f, 0.02331628f, 0.30023497f, -0.02192774f, 0.02683376f, -0.09180099f, 
    -0.01801641f, 0.03844598f, -0.10115203f, 0.00298201f, -0.04365203f, 0.07801654f, -0.08514546f, -0.03824793f, 
    0.03785514f, 0.11765911f, 0.04682489f, 0.04981121f, 0.42297307f, 0.15055148f, -0.11831254f, -0.02415756f, 
    0.11611968f, 0.03192138f, -0.09822664f, 0.03248917f, 0.04744948f, -0.06484430f, -0.00638422f, -0.02629656f, 
    -0.14165075f, 0.12870423f, -0.01739884f, -0.00991492f, 0.02737521f, 0.01188295f, -0.03929291f, 0.00840192f, 
    -0.11216972f, -0.13604802f, -0.11610855f, -0.16045572f, -0.32688734f, -0.07886340f, -0.07517440f, 0.07073294f, 
    0.09325004f, 0.07562650f, -0.07944236f, -0.00258236f, -0.07546974f, -0.00584660f, -0.07900763f, -0.05552571f, 
    -0.10899565f, 0.08807579f, 0.07426783f, 0.10187543f, 0.18896687f, -0.02448121f, 0.00004170f, 0.01610030f, 
    0.07628654f, -0.05465287f, -0.07795036f, 0.13009647f, 0.05678445f, -0.00331524f, 0.04181241f, 0.00158364f, 
    0.00288846f, -0.15567771f, 0.06020671f, 0.02778671f, -0.10447380f, -0.08723630f, -0.07219818f, -0.03150862f, 
    0.15416147f, -0.08757541f, -0.30485928f, 0.01581639f, -0.07906911f, -0.01569082f, 0.04807579f, 0.04289418f, 
    -0.01814862f, 0.04029626f, -0.04967334f, -0.06566222f, -0.01661087f, -0.04207452f, -0.06475690f, -0.06316763f, 
    0.00783107f, 0.01603733f, -0.01258908f, 0.02843937f, 0.27207807f, -0.38606873f, 0.30141333f, -0.04326285f, 
    0.18061492f, 0.08977291f, -0.12304667f, -0.08703178f, 0.02254777f, 0.05808574f, 0.06169171f, -0.06804396f, 
    -0.02287980f, 0.02180348f, 0.02810551f, 0.01632839f, -0.21357253f, 0.00533637f, -0.05633146f, -0.09062976f, 
    0.48439795f, -0.44914183f, -0.04754518f, 0.19851033f, -0.32489833f, -0.15227149f, -0.02916905f, -0.00234045f, 
    -0.12948263f, 0.08627095f, -0.05725789f, -0.01502067f, 0.13381623f, -0.07105739f, 0.01810794f, 0.00946368f, 
    -0.13423131f, 0.09159878f, 0.07074433f, 0.00831643f, 0.39708170f, 0.09129492f, 0.04356083f, 0.25577641f, 
    0.10522018f, -0.06396896f, 0.01251176f, -0.03017288f, 0.01502850f, 0.09286144f, 0.04757832f, 0.04752561f, 
    -0.00375059f, 0.08924421f, 0.00751692f, 0.02236328f, -0.05819734f, -0.07017843f, -0.12351408f, 0.04223711f, 
    0.32720247f, -0.16426261f, -0.18288867f, -0.21639720f, -0.11997759f, -0.05273549f, -0.02298969f, -0.21427165f, 
    -0.03702410f, -0.03570511f, -0.00261839f, 0.05014869f, 0.03636362f, -0.00807050f, -0.00007518f, -0.03608259f, 
    0.03903344f, 0.01682665f, -0.07479324f, -0.00256915f, 0.18308672f, 0.00737496f, 0.02354867f, 0.13624386f, 
    0.10849205f, 0.00485665f, -0.08810546f, 0.04766329f, 0.03012777f, 0.04002037f, 0.09671909f, -0.00579953f, 
    -0.02380972f, -0.06750479f, -0.01263009f, 0.01277953f, -0.02147292f, -0.16128202f, 0.06128378f, -0.05818398f, 
    -0.27803016f, 0.18301943f, -0.00118135f, -0.26567379f, -0.04097503f, 0.08504954f, 0.03498063f, 0.16197404f, 
    -0.05479221f, -0.02737220f, -0.04157913f, 0.07289065f, 0.11665771f, -0.12059370f, -0.09579097f, 0.03591461f, 
    -0.02965249f, 0.05839882f, -0.01792532f, 0.01557915f, 0.03854581f, 0.07892090f, -0.02087724f, -0.02986239f, 
    0.02967491f, -0.03389644f, 0.08510774f, 0.02377401f, 0.00074186f, -0.09354699f, 0.01038685f, -0.04240871f, 
    -0.04768971f, -0.05762693f, 0.00023452f, -0.04920613f, -0.03794862f, -0.03704280f, -0.02015275f, -0.01816111f, 
    -0.65031296f, 0.18063486f, -0.03662674f, -0.04524066f, 0.07023226f, 0.05536259f, 0.08909734f, -0.07225207f, 
    0.01699735f, -0.03984048f, -0.05168159f, -0.00659395f, 0.03133794f, -0.02713452f, 0.11128938f, -0.11745963f, 
    0.03259508f, -0.09897385f, -0.03625165f, -0.02863017f, 0.32279772f, -0.19927756f, -0.00115512f, -0.21849462f, 
    -0.11414474f, -0.21108425f, 0.05120100f, 0.11786254f, 0.02691907f, -0.06394424f, 0.06930647f, -0.03487049f, 
    0.00907624f, 0.00807655f, -0.03576312f, 0.03628749f, 0.01189704f, 0.06853392f, -0.02404851f, -0.01370837f, 
    0.25892594f, 0.01386790f, -0.05945314f, 0.04043986f, -0.07600395f, -0.16485137f, 0.17731912f, 0.07656284f, 
    0.02467428f, -0.13945892f, -0.04042891f, 0.14824833f, -0.06140774f, 0.06359047f, 0.01109095f, 0.09717413f, 
    -0.07031064f, 0.07379599f, -0.00602646f, -0.03095466f, 0.27483264f, -0.16256927f, 0.09922946f, -0.14711782f, 
    0.07171430f, 0.03176877f, -0.10397769f, 0.13154666f, 0.08324553f, 0.00788933f, -0.04539574f, -0.02726637f, 
    0.04924995f, -0.01861870f, -0.02046906f, 0.01759196f, -0.05240903f, 0.10308167f, 0.04906069f, -0.01061903f, 
    0.26120839f, -0.00019554f, -0.07375720f, -0.03216138f, 0.10118975f, -0.10645234f, -0.05753294f, -0.03072044f, 
    0.06757905f, 0.04148835f, -0.04700497f, 0.11948481f, -0.05124993f, 0.02709734f, 0.02258064f, -0.04621507f, 
    -0.11256357f, -0.14227247f, 0.04148541f, -0.00050610f, 0.15584919f, -0.01377190f, 0.21930620f, 0.14039518f, 
    0.26805621f, -0.18167172f, -0.13792731f, -0.15072094f, 0.06853748f, 0.00252919f, 0.09707716f, -0.11348252f, 
    -0.12781850f, -0.06600972f, 0.00574094f, -0.06406264f, 0.03694060f, -0.02573620f, 0.04020507f, 0.00819194f, 
    -0.09551232f, -0.21415159f, -0.10776027f, -0.31389228f, -0.26942292f, 0.11248802f, -0.16664845f, 0.12224469f, 
    -0.09959645f, 0.00866927f, -0.06670104f, 0.12178798f, -0.00482571f, -0.18808448f, -0.06871548f, 0.11325680f, 
    -0.10501301f, 0.13119651f, -0.05016808f, -0.13203366f, 0.07512246f, -0.05155269f, 0.06966614f, -0.08390397f, 
    -0.15622623f, 0.05507879f, -0.08332695f, 0.14786695f, -0.05930108f, 0.00641073f, -0.13899988f, -0.04351752f, 
    -0.01329798f, -0.03644968f, -0.03791922f, 0.01623934f, -0.04140021f, -0.00099090f, -0.09019373f, -0.04419359f, 
    -0.15634152f, -0.51081532f, -0.06959189f, -0.15785724f, -0.25518158f, 0.05460848f, 0.00875300f, 0.06666625f, 
    -0.07814609f, 0.00103681f, -0.04819059f, -0.01438091f, -0.03924255f, 0.05219866f, -0.06543525f, -0.01202008f, 
    -0.00819959f, 0.09946737f, -0.10795409f, -0.07608850f, -0.37237757f, 0.06198904f, -0.07939801f, -0.08615997f, 
    0.00275168f, 0.11700127f, 0.14074834f, 0.02294038f, -0.02414973f, -0.10246932f, -0.11477941f, 0.05686479f, 
    -0.00167411f, -0.03969337f, -0.10689998f, -0.10035443f, 0.05969615f, 0.04980129f, -0.14857957f, 0.03221329f, 
    0.32455850f, 0.05163567f, 0.11975649f, 0.07656655f, 0.31750485f, 0.06367558f, -0.05902621f, -0.07359022f, 
    0.05885630f, 0.11671375f, 0.04377089f, -0.00202358f, 0.01367625f, 0.04232185f, -0.02822920f, 0.01188067f, 
    -0.04463398f, -0.02697603f, -0.13342501f, -0.04955372f, -0.55329150f, -0.68395126f, -0.09198963f, -0.38570186f, 
    -0.37088406f, -0.03002305f, -0.01641180f, 0.00732656f, -0.01906521f, 0.07597529f, -0.02852337f, 0.10353677f, 
    -0.18451731f, -0.04818245f, -0.02124607f, -0.01194743f, -0.10374098f, 0.11872863f, -0.05334283f, -0.10560896f, 
    0.07985906f, 0.01215181f, -0.00768035f, -0.08276507f, -0.01435570f, -0.02570377f, -0.15483794f, 0.06952896f, 
    -0.00670647f, 0.07351929f, 0.00008062f, -0.07728591f, 0.14476381f, 0.05674273f, -0.00331264f, 0.00660406f, 
    -0.02093592f, -0.05291767f, -0.08021881f, -0.04886329f, 0.30375186f, 0.12861213f, -0.15677947f, 0.05990265f, 
    -0.11553995f, -0.19224566f, 0.10750013f, 0.02400186f, 0.03505384f, -0.17495906f, -0.14861880f, -0.01344184f, 
    -0.08359344f, -0.01422837f, -0.03460783f, 0.04855340f, 0.03345401f, -0.11284333f, 0.04408713f, 0.03506897f, 
    0.01200051f, 0.06245596f, -0.06921563f, -0.05000182f, -0.15084225f, 0.03833868f, 0.06034877f, 0.04656326f, 
    -0.06902798f, -0.11144593f, -0.10829107f, 0.01273689f, -0.08917775f, -0.08414576f, -0.10546232f, 0.01369680f, 
    0.00185393f, 0.05748575f, -0.00392320f, -0.00162991f, -0.05087996f, -0.07089306f, 0.05159245f, 0.03675485f, 
    -0.06767873f, 0.01560615f, -0.18134911f, 0.03190463f, 0.11185425f, 0.04838672f, -0.03025775f, -0.02666114f, 
    0.01388993f, 0.02192557f, -0.14683498f, -0.09047440f, -0.01834442f, -0.04149519f, -0.07967030f, -0.06034829f, 
    0.41635066f, 0.06259833f, -0.10237444f, -0.10219736f, -0.07926103f, -0.13452788f, 0.03407939f, 0.07403030f, 
    -0.02040709f, -0.05739845f, -0.01230386f, -0.03801614f, -0.01357053f, 0.05334720f, -0.04411593f, 0.05574922f, 
    -0.01813589f, -0.10261487f, 0.15831409f, -0.09291251f, -0.24256508f, 0.12735263f, 0.08571611f, -0.09272885f, 
    0.01628101f, 0.01025976f, -0.03647719f, 0.10921694f, 0.04308604f, 0.05661427f, -0.06820057f, -0.02321463f, 
    0.01764337f, -0.02149336f, 0.06160989f, -0.00949476f, -0.05587031f, -0.05613440f, -0.02459794f, 0.04010919f, 
    -0.74889195f, 0.24354680f, -0.00355792f, -0.08837844f, 0.01852958f, 0.01520199f, 0.10374802f, -0.04509185f, 
    -0.02176119f, 0.02684096f, 0.04406775f, -0.00186104f, -0.02898140f, -0.05425638f, 0.11356540f, 0.04096451f, 
    0.05687478f, -0.03508946f, 0.00175084f, 0.03823806f, 0.25738198f, -0.05892695f, -0.13209867f, -0.23048328f, 
    -0.13662684f, -0.00122428f, -0.07432979f, 0.04407078f, -0.15111531f, -0.02827631f, -0.03111196f, -0.03247749f, 
    0.02116788f, -0.02244145f, 0.02926834f, -0.01802937f, -0.06501840f, 0.04994490f, 0.01255507f, -0.04500912f, 
    0.11017252f, -0.16806826f, 0.03093753f, -0.20129666f, 0.01449159f, 0.09823909f, -0.06729970f, 0.09966403f, 
    0.02165741f, 0.05916094f, -0.00929354f, -0.01561069f, 0.11342400f, -0.00844999f, 0.00940560f, -0.02944141f, 
    -0.02211612f, 0.01853671f, -0.06123284f, -0.03625567f, -0.04139003f, 0.20244181f, -0.07726669f, -0.22485830f, 
    0.03126505f, 0.02126349f, 0.13217479f, 0.06196744f, -0.08238161f, -0.02564220f, -0.06293356f, -0.02373106f, 
    -0.02237732f, -0.11232797f, -0.01827653f, -0.01305900f, 0.02171219f, -0.01162158f, -0.14948006f, 0.06479356f, 
    0.13323864f, -0.03592450f, 0.19282186f, -0.02055762f, 0.08404599f, -0.00415289f, 0.05377050f, 0.00444050f, 
    -0.02305475f, 0.08150032f, -0.00999123f, -0.01979513f, -0.03846892f, -0.01789260f, -0.09131395f, 0.03624411f, 
    -0.07659104f, 0.05138581f, 0.04404167f, -0.02057842f, 0.01664388f, -0.10586534f, 0.13941188f, -0.21278386f, 
    -0.05086009f, -0.07850916f, -0.11755411f, -0.05516615f, -0.03559038f, -0.04354225f, 0.03192325f, -0.13287315f, 
    0.08651151f, -0.04754119f, 0.06552781f, -0.02526131f, 0.09449922f, -0.01865862f, 0.00846111f, 0.06467386f, 
    0.04203539f, -0.16904964f, -0.13052309f, -0.02394630f, 0.19211739f, -0.01929319f, 0.03706760f, -0.02380980f, 
    0.03067752f, -0.00318929f, -0.04564770f, -0.00453452f, 0.01780350f, 0.05190330f, -0.06642539f, -0.03134879f, 
    0.11525267f, -0.07895534f, 0.14486781f, 0.05584868f, -0.05006785f, -0.04080089f, -0.08849382f, 0.16609207f, 
    -0.01996917f, 0.00404300f, -0.20981845f, 0.10375893f, -0.06883723f, 0.01993705f, -0.11643407f, -0.00579347f, 
    -0.00529999f, 0.11749247f, -0.00144614f, -0.01403189f, 0.09944679f, 0.01203783f, -0.02281277f, -0.06802366f, 
    0.05094601f, -0.07344381f, 0.03682338f, -0.01871172f, -0.09173620f, -0.13662691f, -0.14229298f, 0.04468155f, 
    -0.18494458f, -0.09804591f, -0.12676270f, -0.10759576f, -0.03078789f, -0.07222503f, 0.10546155f, -0.03260847f, 
    0.09781313f, 0.10409363f, 0.07809409f, -0.00181034f, 0.01398375f, -0.12236575f, -0.04372882f, 0.09564216f, 
    -0.16685429f, 0.01472398f, -0.11839504f, 0.08462419f, -0.04122750f, -0.00145180f, -0.13756502f, 0.13557889f, 
    -0.05421612f, 0.07536432f, 0.07485029f, -0.03934924f, 0.03904027f, 0.02026874f, 0.06256181f, 0.00431246f, 
    -0.09561469f, 0.44447312f, 0.03842054f, 0.04044276f, -0.06965804f, -0.08594341f, -0.00966849f, -0.12902924f, 
    0.02544945f, -0.01932513f, -0.11138844f, -0.02411787f, -0.09137169f, 0.07346349f, -0.12599237f, 0.04287582f, 
    0.01039790f, -0.04377041f, 0.19023731f, -0.01519004f, 0.08211904f, -0.14306527f, 0.08403802f, 0.00107644f, 
    -0.14805977f, 0.02728070f, -0.13226195f, -0.01753639f, -0.02674660f, -0.02212127f, -0.07259908f, -0.00997801f, 
    -0.02226013f, 0.03103280f, 0.09682821f, 0.07943926f, 0.03260832f, 0.05082650f, 0.01369790f, -0.05105796f, 
    0.08447757f, -0.47707230f, -0.17443745f, 0.18369824f, 0.27329805f, 0.05250701f, 0.11947388f, 0.03726990f, 
    0.01240211f, -0.07597157f, 0.11148424f, 0.02778311f, -0.01563539f, -0.15651639f, 0.01049684f, -0.03599364f, 
    -0.05921108f, 0.04413251f, 0.06764919f, -0.01310547f, -0.56780797f, -0.18416360f, -0.08356249f, 0.10681715f, 
    0.14371206f, -0.12611806f, 0.07233865f, 0.00363992f, 0.06705983f, -0.11243002f, -0.04264444f, 0.03205752f, 
    -0.03437667f, -0.13724138f, 0.05546213f, -0.06826758f, -0.02517961f, -0.06034954f, -0.03307011f, 0.00386231f, 
    -0.16199550f, -0.21695383f, -0.21403441f, 0.11967273f, 0.01744330f, -0.10392857f, 0.08489661f, -0.01413695f, 
    -0.07127439f, 0.04821916f, 0.02722018f, 0.08032825f, -0.01374105f, -0.03796277f, 0.00545308f, -0.00560404f, 
    0.02157426f, 0.01612075f, 0.03212169f, 0.02525451f, -0.00328506f, 0.14763357f, 0.11849765f, 0.15820515f, 
    -0.08014294f, -0.03968104f, -0.09312943f, -0.13561267f, -0.02443034f, -0.02218351f, 0.04301898f, 0.00660994f, 
    0.02169420f, -0.05453116f, -0.02160299f, 0.06037461f, -0.05067003f, 0.00071006f, -0.03382224f, -0.01479549f, 
    -0.06652450f, -0.42361349f, 0.19644821f, -0.02121247f, -0.11861202f, 0.14140686f, -0.13266814f, 0.02326003f, 
    0.07664846f, -0.23349099f, 0.08484735f, 0.03619967f, -0.01547399f, 0.01074671f, -0.11274754f, -0.00657006f, 
    -0.03941555f, -0.05892885f, -0.00966532f, -0.13700084f, -0.16458532f, -0.21802138f, -0.32878613f, 0.02401888f, 
    -0.04904130f, -0.13592589f, -0.02203457f, -0.07034848f, 0.09859350f, -0.04048400f, -0.07212106f, -0.04028913f, 
    -0.02287505f, 0.04197558f, 0.05278227f, -0.03586713f, 0.02668198f, -0.01029619f, -0.02159692f, -0.01978996f, 
    -0.24038768f, 0.11473676f, -0.01546106f, -0.17602447f, -0.13291927f, -0.05687378f, -0.03988129f, -0.05350903f, 
    0.04506627f, -0.13775076f, 0.08782145f, -0.05186217f, 0.00177681f, 0.00443084f, -0.04856329f, -0.00438506f, 
    0.04507659f, -0.13909225f, -0.01182743f, -0.02494988f, 0.11403536f, -0.02414582f, -0.09436717f, -0.10304386f, 
    -0.18486197f, -0.16886468f, -0.21577223f, 0.03256811f, 0.01679281f, 0.04398572f, -0.09487389f, -0.05588214f, 
    0.10788412f, -0.10123115f, 0.13025467f, -0.04141507f, -0.09616953f, 0.01348293f, 0.05880780f, 0.02697371f, 
    0.24784875f, 0.13152869f, 0.09645438f, 0.24564050f, 0.15000792f, 0.04219869f, 0.02591870f, 0.00847382f, 
    0.12732042f, 0.03552010f, 0.05623439f, -0.01071039f, -0.01766673f, -0.02603676f, 0.02556452f, -0.00105930f, 
    0.02733390f, 0.07290100f, -0.07045642f, 0.11032361f, 0.03067921f, -0.11523974f, -0.14104512f, 0.18290223f, 
    -0.07983854f, -0.04860988f, -0.04030661f, -0.02413883f, 0.11177959f, 0.02181415f, -0.04403850f, -0.05116051f, 
    -0.10587689f, 0.04407675f, 0.06074467f, 0.04237835f, -0.04331673f, -0.00834680f, -0.11361232f, 0.01052297f, 
    0.34957638f, 0.11988725f, 0.10785482f, 0.09055281f, 0.20147893f, 0.04139903f, 0.03139164f, 0.03050636f, 
    0.01785186f, 0.13491967f, -0.06166080f, -0.00806341f, -0.12987600f, 0.00935121f, 0.03664003f, 0.08470348f, 
    0.15187432f, 0.04646584f, 0.06059547f, -0.02576562f, 0.03558846f, -0.57689798f, -0.29401496f, 0.16476814f, 
    0.27943236f, 0.13757308f, 0.09800775f, 0.13823494f, -0.04001977f, -0.11043923f, 0.04271362f, -0.00615361f, 
    -0.10693534f, -0.06294660f, -0.17161268f, 0.06356861f, 0.09324701f, 0.11251128f, -0.05139746f, 0.00794753f, 
    -0.33091277f, 0.27492163f, -0.09282345f, -0.15746549f, -0.24732301f, -0.04748644f, -0.10674890f, 0.02410867f, 
    0.08022129f, -0.00827335f, 0.01713492f, -0.16048747f, -0.05874532f, -0.03620999f, -0.08404253f, -0.03340521f, 
    0.01366903f, 0.03145747f, 0.03313197f, 0.06117195f, 0.15941529f, 0.21686412f, 0.05996708f, 0.12373254f, 
    -0.10241348f, 0.00731656f, 0.03150720f, -0.04448140f, -0.06613915f, -0.11504719f, -0.05735978f, -0.03555872f, 
    0.03318615f, -0.06583177f, -0.09700271f, 0.11092990f, 0.00504229f, 0.05621555f, -0.01620170f, -0.03115112f, 
    -0.08239026f, -0.46708184f, -0.09643123f, -0.11889252f, -0.21146196f, -0.15877734f, -0.04654538f, 0.00653617f, 
    0.05103928f, -0.05896986f, -0.17432472f, 0.02663237f, 0.05727158f, 0.08536010f, 0.11207722f, 0.07922535f, 
    -0.00004079f, -0.08435527f, -0.04953668f, 0.03300773f, -0.35973835f, -0.40861586f, -0.02598746f, 0.06826389f, 
    0.09234443f, 0.09397779f, -0.01824475f, 0.09383786f, 0.04492060f, 0.01791012f, 0.10630807f, 0.05455757f, 
    -0.05248314f, -0.04383522f, -0.06925798f, 0.02770115f, -0.02673402f, -0.09525081f, 0.08047478f, -0.10616075f, 
    0.44507283f, 0.28704154f, 0.00753754f, 0.19013554f, 0.01763432f, 0.12464932f, 0.11365045f, 0.05272802f, 
    0.09937321f, 0.03068197f, 0.00689186f, 0.02840343f, -0.06259818f, -0.13366714f, -0.07524829f, -0.01930727f, 
    -0.03948456f, 0.09772113f, 0.10790053f, -0.12750050f, -0.06050163f, -0.30504394f, -0.11386921f, -0.10341857f, 
    -0.16897121f, -0.12827656f, 0.07149553f, 0.04937131f, -0.01897448f, -0.04353439f, -0.08767663f, 0.01795235f, 
    0.02487940f, 0.08385552f, -0.04707437f, 0.05876745f, 0.01044281f, -0.01465497f, -0.01610170f, 0.09036357f, 
    -0.29538646f, 0.41430321f, 0.13109493f, 0.21061721f, 0.11080563f, 0.07847425f, 0.00545907f, -0.03604767f, 
    -0.00904177f, -0.09117791f, -0.05482877f, -0.15954906f, 0.02928669f, -0.00657270f, 0.01292727f, -0.04748461f, 
    0.07617791f, -0.06210186f, 0.19096996f, 0.05440496f, 0.05495467f, -0.39838916f, -0.33833292f, 0.14772177f, 
    0.03430717f, -0.04521591f, -0.06762225f, 0.12185819f, 0.01470624f, -0.11311867f, 0.02241921f, 0.03533987f, 
    -0.09233245f, -0.10760474f, 0.08579443f, -0.01331244f, -0.12591796f, -0.02773804f, -0.06172978f, -0.08131800f, 
    0.09957611f, -0.09625602f, -0.23133667f, 0.02801985f, 0.05783207f, -0.02662556f, 0.18486050f, 0.00906211f, 
    -0.00172932f, -0.10760379f, -0.05571779f, 0.17259921f, -0.07983220f, -0.09940192f, -0.05400224f, -0.07785121f, 
    -0.05820358f, -0.04082036f, 0.03560218f, -0.09060714f, 0.57176089f, 0.37601566f, 0.10035125f, -0.19513085f, 
    -0.01917541f, -0.00499135f, 0.06374494f, 0.03093288f, 0.12190975f, 0.02967171f, -0.03867980f, -0.08183217f, 
    -0.12577666f, 0.05286620f, -0.09544818f, -0.07395926f, -0.02704219f, -0.12042156f, 0.13433079f, 0.07155660f, 
    -0.50073457f, -0.50888360f, -0.12817900f, -0.13181782f, -0.22808710f, -0.20194873f, -0.02198882f, -0.10394771f, 
    0.03881610f, -0.00940955f, -0.11089338f, -0.05594149f, 0.12348281f, -0.02903072f, 0.02190225f, 0.04981890f, 
    -0.02892023f, -0.11829141f, -0.01658945f, 0.13007216f, -0.54091448f, -0.12485558f, -0.40791446f, -0.14435145f, 
    0.28923100f, -0.03875717f, 0.14653498f, -0.10438623f, 0.04530295f, -0.07364016f, -0.01009148f, 0.00432015f, 
    0.05981247f, 0.07015425f, -0.09212936f, 0.02708772f, -0.01189264f, -0.02405747f, 0.05487841f, 0.06726374f, 
    0.23428062f, 0.10981688f, -0.21344124f, -0.03510954f, -0.26464215f, 0.00088445f, -0.01590483f, -0.03001103f, 
    -0.01389492f, -0.17118861f, 0.02778184f, 0.01880248f, 0.10321853f, -0.04046986f, 0.05259541f, -0.02630210f, 
    0.06426939f, 0.05446648f, 0.11143651f, -0.01003178f, 0.20335698f, 0.07228249f, -0.27079386f, -0.11096994f, 
    0.09047433f, -0.08524805f, 0.05058229f, 0.02900314f, 0.08108987f, -0.07391793f, -0.01513368f, -0.06576454f, 
    0.00014308f, 0.03732338f, -0.02975623f, -0.03629925f, 0.07039436f, -0.16229768f, -0.07882047f, 0.01481840f, 
    0.17985977f, 0.34712005f, 0.04720987f, -0.06725989f, -0.05198929f, -0.08252604f, 0.02863089f, 0.16076130f, 
    0.01334131f, 0.04196751f, 0.03534630f, 0.04848054f, -0.01292346f, 0.08075345f, 0.00225309f, -0.05108541f, 
    0.03376285f, 0.06174298f, 0.03145980f, 0.09442113f, -0.75838244f, 0.01106021f, 0.17633487f, -0.02662738f, 
    -0.03228773f, -0.03231866f, -0.08787803f, -0.00553099f, 0.01687390f, -0.10698862f, -0.09638156f, -0.18272902f, 
    -0.01329206f, 0.06745255f, 0.02121434f, -0.06917854f, -0.01491856f, 0.20963949f, 0.08622436f, -0.01422482f, 
    -0.03330683f, 0.03196697f, -0.28944692f, 0.10415686f, 0.21899401f, 0.12712298f, 0.06914645f, 0.05864375f, 
    0.09812155f, 0.09980524f, 0.07824882f, 0.09020206f, 0.00381669f, -0.15559915f, -0.04057364f, -0.02897778f, 
    -0.09571979f, 0.08416054f, 0.05150756f, -0.10772239f, -0.63756496f, 0.21552607f, 0.12477940f, 0.05420329f, 
    0.23657325f, 0.04269642f, -0.01026087f, -0.09721391f, -0.01364209f, 0.19065522f, -0.05598975f, -0.06482610f, 
    0.01680310f, 0.08171307f, 0.05796568f, -0.05306527f, 0.06083019f, 0.08553558f, 0.11811047f, -0.18610676f, 
    -0.20734411f, 0.04036603f, 0.27934444f, -0.14343415f, -0.15084742f, 0.04263915f, -0.06122311f, -0.00384703f, 
    0.01059073f, 0.08038604f, -0.02402505f, 0.00466291f, -0.07552112f, 0.05157080f, 0.06431940f, -0.04506378f, 
    0.00921440f, 0.05601966f, 0.02281910f, -0.01360278f, -0.47218981f, -0.08616249f, 0.07489099f, 0.04115211f, 
    0.14902385f, -0.03013956f, 0.10524859f, 0.03028985f, 0.07008049f, 0.15474461f, -0.11019158f, -0.07655475f, 
    0.05381748f, 0.11921935f, -0.04739650f, -0.02556982f, 0.10155331f, 0.04066934f, 0.03037650f, -0.09705967f, 
    -0.19325425f, -0.57195401f, 0.12060599f, 0.27589929f, 0.02378751f, -0.38991937f, 0.03119185f, 0.08836880f, 
    -0.16645317f, -0.02255034f, 0.11300852f, 0.06406779f, 0.01646507f, -0.05726320f, 0.00686517f, -0.06985515f, 
    -0.02766217f, 0.04469464f, -0.01378004f, 0.00016051f, -0.51301140f, -0.12882650f, 0.02991473f, 0.04405669f, 
    0.09638869f, -0.06699991f, -0.09971122f, 0.12469576f, 0.04274106f, 0.03483684f, 0.11608551f, 0.01419512f, 
    -0.11954272f, -0.12925702f, -0.03777718f, 0.07495473f, 0.06517141f, -0.06606376f, 0.10656764f, 0.00191441f, 
    -0.23634243f, 0.08207780f, -0.06185142f, 0.04744561f, 0.03270610f, 0.21182927f, 0.00866705f, 0.03369725f, 
    -0.03873441f, -0.11620797f, 0.14518456f, -0.03740205f, -0.09190559f, 0.04520092f, -0.04679098f, 0.00892098f, 
    0.00096677f, 0.00320114f, -0.07990085f, 0.09561068f, -0.15998182f, 0.27783298f, -0.06817161f, 0.13106099f, 
    -0.10853372f, 0.13048242f, -0.07630908f, 0.00819666f, 0.08380245f, -0.16159622f, -0.07337430f, 0.06338292f, 
    -0.01930578f, -0.06976591f, -0.04767365f, 0.09168191f, -0.11448778f, -0.03945164f, 0.00500942f, 0.00141461f, 
    -0.02633355f, 0.53876084f, -0.37188762f, -0.30811828f, 0.12334325f, 0.04209043f, -0.15278138f, -0.03112148f, 
    0.04361904f, -0.06235021f, -0.09421793f, -0.00091821f, 0.04887519f, 0.05833194f, 0.05628389f, 0.07786322f, 
    -0.03546617f, -0.16745268f, -0.09144236f, -0.07410952f, -0.10550677f, 0.09465069f, 0.01730540f, -0.16747153f, 
    -0.19147784f, 0.00750404f, -0.02725540f, -0.08228709f, 0.14530347f, 0.06004947f, 0.02435896f, -0.00865880f, 
    -0.03077086f, -0.00361756f, -0.00472135f, 0.03969737f, 0.09092097f, -0.05920161f, -0.04627677f, 0.08430441f, 
    0.19608018f, 0.25272968f, -0.23448351f, -0.13672806f, 0.02758235f, -0.03336551f, -0.01289296f, 0.15747797f, 
    0.10689162f, -0.06691453f, -0.01288538f, 0.06650705f, -0.02606688f, 0.01461891f, 0.03308518f, 0.04171637f, 
    0.12917697f, -0.07902448f, -0.03410293f, -0.01791548f, -0.88195735f, 0.11118159f, 0.01302206f, 0.18892917f, 
    0.28676146f, 0.09296239f, -0.13657704f, 0.00725967f, 0.06046147f, 0.19143188f, 0.09211995f, 0.05489590f, 
    0.01998756f, 0.00083442f, 0.09194965f, 0.03796185f, -0.00283182f, 0.03477258f, 0.10729051f, -0.03932114f, 
    -0.17262730f, -0.21437630f, -0.09725397f, 0.01507075f, -0.33935350f, -0.21302204f, -0.04073924f, 0.03628558f, 
    -0.01238692f, -0.12456349f, -0.06452163f, -0.01470753f, 0.03078916f, -0.03863234f, 0.14534993f, -0.09999972f, 
    0.14926411f, -0.01570038f, 0.01595047f, 0.02082214f, 0.11975756f, -0.23660012f, -0.25789347f, 0.11832417f, 
    -0.25330186f, 0.00794303f, 0.01539758f, 0.08253326f, -0.01140568f, 0.02750237f, -0.12416482f, 0.08173189f, 
    0.05511490f, -0.02098102f, -0.09341762f, -0.01401779f, -0.01801826f, -0.12456004f, -0.02538302f, -0.10178711f, 
    0.14754318f, 0.12894359f, -0.00459432f, 0.13687831f, -0.06406040f, -0.04223795f, 0.09979081f, 0.04914012f, 
    0.01704748f, 0.01219299f, 0.04961550f, -0.11737823f, 0.10695060f, 0.04829349f, 0.02699571f, 0.00028457f, 
    0.03877293f, 0.03522112f, 0.09666758f, 0.14984968f, -0.15022253f, -0.13605647f, 0.17787808f, 0.18695535f, 
    0.04540787f, -0.00344218f, 0.04327814f, -0.09345379f, -0.01469625f, 0.06388123f, 0.08961265f, 0.13485502f, 
    -0.00768000f, -0.04179855f, -0.07304677f, -0.23933041f, 0.05208417f, -0.00619037f, 0.13400644f, 0.08068687f, 
    -0.12522094f, -0.01609077f, -0.21661174f, 0.18348746f, 0.12870482f, 0.22973384f, -0.02208610f, 0.11227533f, 
    -0.05387161f, -0.01180522f, -0.00871916f, -0.00923748f, 0.04968048f, 0.02635427f, -0.05223743f, 0.01602964f, 
    0.06437946f, 0.01028994f, 0.14668912f, 0.04028820f, -0.10354836f, 0.25160772f, -0.18076304f, 0.21180761f, 
    -0.15282707f, -0.06897006f, -0.04766518f, 0.03594475f, 0.06686161f, -0.07222991f, 0.06083854f, -0.12560870f, 
    0.00828673f, 0.07920695f, 0.02915839f, -0.00242769f, -0.06644769f, 0.09638506f, -0.00018478f, 0.16794857f, 
    -0.04105296f, -0.22868253f, 0.02756530f, 0.11709843f, -0.02022324f, -0.04259634f, 0.04159781f, 0.23407903f, 
    -0.05745015f, 0.08091828f, -0.02666544f, -0.08499625f, 0.03389124f, -0.03938237f, -0.05881330f, 0.08509023f, 
    -0.05723618f, -0.04640808f, -0.06084666f, -0.12326209f, 0.45492914f, 0.01078586f, -0.13408588f, -0.18758599f, 
    0.06370103f, -0.08426582f, -0.01470257f, -0.02364957f, 0.07134286f, -0.05486751f, -0.11882886f, -0.01849672f, 
    -0.05385669f, -0.07781558f, -0.04754185f, -0.00949261f, -0.15346351f, -0.04132557f, -0.05546648f, -0.01492758f, 
    -0.15402062f, -0.08959328f, 0.20608379f, -0.03500562f, -0.07596239f, -0.10798793f, 0.02075838f, -0.14298135f, 
    0.02805485f, -0.00939517f, -0.08731705f, -0.21451803f, -0.10043421f, -0.00950475f, 0.05668188f, -0.09751672f, 
    -0.03215088f, 0.11666004f, -0.06349639f, 0.05923567f, 0.35392216f, -0.06814449f, -0.08603371f, 0.08423652f, 
    -0.15839866f, 0.01834673f, -0.08515026f, -0.03813018f, -0.04655633f, 0.11213394f, -0.08506475f, 0.04784128f, 
    0.12289463f, 0.00958100f, 0.08801020f, -0.07851511f, -0.05202113f, 0.01048605f, -0.06270725f, -0.09644371f, 
    -0.46037975f, -0.03273145f, -0.10369305f, -0.17318901f, -0.05763185f, 0.01767022f, -0.09472979f, 0.00762364f, 
    0.04927176f, 0.12253162f, -0.00428163f, -0.06894258f, 0.01684639f, 0.05287934f, 0.05149589f, 0.00495714f, 
    0.03850998f, -0.02875162f, 0.08476111f, -0.06521665f, -0.11541407f, -0.20876937f, -0.10157881f, -0.06147841f, 
    0.00638354f, -0.09683941f, -0.01478322f, -0.20248580f, -0.13824926f, 0.07768276f, 0.12646900f, 0.01160746f, 
    0.01788287f, 0.10702802f, -0.00783871f, -0.05977995f, -0.11259256f, -0.06994880f, -0.08048244f, -0.03846972f, 
    -0.17128158f, 0.11125781f, -0.03298318f, -0.23403157f, -0.06714226f, 0.08452973f, -0.08496062f, -0.06333725f, 
    -0.06163012f, -0.06643239f, 0.01203493f, 0.04072399f, -0.10191487f, -0.07218138f, -0.13729212f, 0.00827679f, 
    -0.04331847f, -0.17191738f, -0.04333614f, -0.07367846f, -0.07612366f, 0.12430281f, 0.04455683f, -0.06350422f, 
    -0.20166519f, 0.10070032f, 0.00487460f, 0.08681464f, -0.15035273f, -0.02645190f, -0.04910902f, 0.06470269f, 
    -0.00330655f, -0.03772179f, -0.08900070f, -0.05053700f, 0.03670134f, 0.03087002f, -0.05960352f, 0.07283697f, 
    -0.04444375f, 0.08751693f, 0.02657450f, -0.00303624f, 0.01636868f, 0.00769971f, -0.07410058f, 0.02523874f, 
    0.12701780f, 0.09625933f, -0.02254640f, -0.06434006f, 0.06586648f, -0.02225363f, -0.04404130f, 0.05253126f, 
    0.10204506f, -0.02870860f, -0.10078070f, -0.02207199f, -0.17318198f, -0.05440534f, 0.33439535f, 0.19686274f, 
    -0.02455425f, -0.12236355f, -0.08991658f, 0.06046215f, -0.11428643f, -0.08814612f, 0.17420757f, 0.00725353f, 
    -0.09814884f, -0.16180825f, -0.05251993f, 0.04170775f, 0.03868365f, -0.12648894f, -0.02502531f, -0.09257351f, 
    -0.07343184f, -0.13549282f, 0.01829874f, 0.03766224f, 0.23451744f, -0.07322805f, -0.08757384f, -0.08072457f, 
    -0.01906011f, 0.13076761f, 0.02928760f, -0.07880500f, -0.02221177f, -0.03200229f, -0.03349265f, 0.03936874f, 
    -0.09693956f, -0.18733528f, -0.09565254f, 0.09714337f, -0.12860171f, 0.18096586f, 0.03288514f, -0.01945610f, 
    -0.36885509f, 0.11049964f, -0.10041212f, 0.10110144f, -0.17957450f, 0.04379997f, 0.02417967f, -0.09905455f, 
    -0.08126120f, -0.01971045f, -0.17510290f, -0.01077773f, -0.09974768f, 0.09555525f, 0.11439843f, -0.01071639f, 
    -0.08022774f, -0.10871847f, 0.07940017f, 0.19600460f, -0.43751597f, 0.00485851f, -0.03258745f, -0.04358708f, 
    -0.03588795f, -0.09514235f, -0.03457139f, 0.08948687f, 0.02376162f, -0.04406441f, 0.11890585f, -0.06311952f, 
    0.00553696f, 0.09625380f, 0.11982640f, -0.13724144f, -0.32680228f, 0.17137960f, -0.28831577f, -0.13580254f, 
    0.12895931f, 0.07808511f, 0.02994493f, -0.02871210f, -0.01641500f, -0.05394355f, 0.06989224f, -0.01609102f, 
    0.03911928f, -0.13974735f, -0.01737649f, -0.07903340f, 0.15895058f, -0.12229313f, -0.03409301f, 0.09232232f, 
    -0.74470061f, -0.28747135f, -0.09877259f, -0.30608037f, 0.16113448f, 0.16549495f, 0.06411257f, -0.00982341f, 
    -0.05500619f, -0.01949242f, 0.08054733f, 0.14418770f, -0.04182110f, 0.08862295f, -0.07231271f, 0.04598861f, 
    0.04305582f, -0.03079070f, -0.24742064f, 0.14510074f, -0.41721970f, 0.08092858f, -0.28278053f, -0.17371824f, 
    -0.07997376f, 0.13511007f, -0.02878997f, -0.06437881f, 0.01212974f, -0.25199333f, 0.02509124f, 0.03441205f, 
    -0.13648979f, -0.06074021f, -0.09985105f, -0.08959493f, -0.04144466f, 0.06243194f, 0.11815964f, 0.06529101f, 
    -0.28866205f, -0.30388257f, -0.21712235f, -0.13242932f, -0.00454927f, 0.08522794f, 0.14368929f, 0.10426518f, 
    0.17434599f, -0.14322998f, 0.05648765f, 0.09432155f, 0.11779979f, 0.02375509f, -0.00283795f, -0.03775199f, 
    0.00749642f, -0.19000745f, -0.11829414f, 0.01986538f, 0.05902449f, 0.08577631f, -0.09328160f, -0.07173182f, 
    -0.10878897f, 0.01170171f, 0.04396384f, 0.07417946f, 0.00588275f, -0.11417229f, 0.05551535f, 0.04039849f, 
    -0.08998247f, -0.14791328f, -0.06881419f, 0.06315146f, -0.09326362f, 0.05680735f, 0.06353989f, 0.07102325f, 
    0.16519134f, 0.25410181f, -0.02734766f, 0.03231949f, 0.10653020f, -0.10070749f, -0.03066760f, -0.06892872f, 
    0.04642949f, 0.10804532f, -0.11648584f, -0.19544107f, 0.00443915f, 0.18681277f, 0.16702889f, -0.02484570f, 
    0.03635304f, 0.05199555f, -0.00163127f, -0.07355636f, 0.03204894f, -0.05393849f, -0.02169085f, 0.07844861f, 
    -0.23258358f, -0.10209125f, 0.09183433f, 0.06067476f, 0.01042493f, 0.05163830f, -0.08158036f, -0.09768020f, 
    0.06373157f, 0.05236415f, 0.08479506f, -0.01629735f, -0.04182386f, 0.05526986f, 0.06545591f, 0.05357217f, 
    -0.18059683f, 0.23018771f, -0.02345664f, 0.10189512f, -0.00556548f, -0.02745648f, -0.10817662f, 0.02524214f, 
    -0.00803836f, 0.01415938f, 0.03119570f, 0.10797089f, 0.00574774f, -0.01295316f, 0.07700793f, -0.06498097f, 
    0.05758297f, -0.13252659f, -0.00743648f, -0.30744964f, -0.24193905f, -0.19463094f, -0.04659972f, 0.00550435f, 
    0.15026675f, 0.04684291f, -0.15050954f, 0.03884646f, 0.00473698f, 0.14738725f, 0.09659409f, -0.04949316f, 
    -0.01096712f, 0.01950253f, 0.03181259f, -0.20342815f, -0.03666940f, -0.00353947f, -0.10319247f, -0.08551697f, 
    -0.16016436f, -0.17664871f, 0.10297529f, 0.25056037f, -0.12163237f, 0.06640138f, 0.14604031f, 0.01130092f, 
    0.01150214f, 0.10743377f, 0.05042131f, 0.02051354f, 0.00286271f, -0.05950736f, 0.00444248f, -0.03844789f, 
    0.16475332f, 0.04917054f, -0.06033470f, -0.03108848f, -0.09396411f, 0.05135639f, -0.10853560f, 0.12235837f, 
    0.21608995f, 0.14183341f, -0.12615861f, -0.00788488f, -0.14935841f, 0.02073104f, -0.02096743f, -0.08923189f, 
    -0.02480157f, -0.04523932f, -0.00091750f, 0.04034435f, 0.03722348f, -0.09772602f, 0.09048446f, 0.01003947f, 
    -0.41520217f, -0.19053759f, 0.19785126f, 0.06799420f, -0.28169790f, 0.02382629f, -0.04369857f, -0.07147166f, 
    -0.01302742f, -0.10444512f, 0.03501260f, -0.06453289f, -0.01325056f, 0.01647511f, -0.02002757f, -0.11342021f, 
    0.02137657f, 0.06142280f, 0.07401460f, 0.02880955f, -0.65573597f, 0.02978065f, -0.35868067f, -0.19389351f, 
    -0.03850642f, 0.17029224f, 0.17689557f, 0.12381063f, -0.08136120f, -0.08428185f, -0.01661908f, 0.02754501f, 
    0.07110469f, -0.06247265f, 0.02682688f, 0.05628537f, -0.03476549f, -0.01899154f, -0.03597782f, -0.06322744f, 
    0.03579480f, 0.07030649f, 0.16686617f, 0.18772194f, -0.01021153f, -0.06083554f, -0.06075842f, 0.03855429f, 
    -0.01606739f, 0.16502897f, -0.06967004f, -0.18175864f, -0.06760875f, 0.05485289f, -0.11591238f, -0.01951502f, 
    -0.04638355f, -0.30416918f, -0.04473650f, -0.04476069f, -0.07180481f, 0.12123305f, 0.15804116f, -0.10280456f, 
    -0.11548515f, -0.10993134f, 0.02855099f, -0.05728624f, -0.09509193f, 0.14805685f, 0.09242360f, -0.08129594f, 
    -0.04697173f, -0.09114691f, -0.19622041f, 0.06614898f, -0.02194294f, 0.02040309f, 0.10773593f, 0.15538190f, 
    0.09689764f, 0.01334439f, 0.11859243f, 0.07304183f, -0.14254363f, -0.02209454f, -0.01657963f, 0.01091786f, 
    0.07506456f, 0.08572087f, -0.07668226f, 0.14737228f, 0.01553982f, 0.09291693f, 0.11603608f, -0.18056098f, 
    -0.09583631f, -0.07278650f, -0.07831874f, -0.08628213f, 0.22048691f, 0.06530837f, 0.06343477f, 0.08969488f, 
    0.05769766f, -0.08248047f, -0.12501222f, 0.09365126f, 0.02844300f, 0.01826225f, -0.08129023f, -0.11862561f, 
    -0.00913382f, 0.08173800f, 0.05667309f, 0.00937320f, -0.08782591f, 0.14853849f, -0.04199993f, 0.03187581f, 
    -0.43831170f, 0.21296188f, 0.13083787f, -0.10040474f, -0.18744065f, -0.00404682f, 0.02216802f, 0.21202667f, 
    -0.14329340f, -0.10129231f, 0.20302814f, -0.10427690f, -0.03615301f, -0.06993373f, -0.03495278f, 0.01282021f, 
    -0.06943084f, -0.00109241f, -0.07323751f, 0.03197491f, -0.05433349f, -0.28562889f, -0.18084082f, 0.02396185f, 
    0.24074465f, 0.00946062f, 0.00886151f, -0.03326403f, 0.11113044f, 0.17753899f, 0.18299361f, 0.15435027f, 
    0.26180232f, 0.03680455f, -0.02049272f, -0.07553443f, -0.02497603f, -0.11927863f, 0.09756061f, -0.11493502f, 
    0.18230635f, -0.03013029f, 0.14437912f, -0.02141972f, -0.03018837f, -0.04905010f, 0.23104270f, -0.10677315f, 
    -0.05083724f, -0.05921977f, 0.05820963f, 0.03293634f, -0.14320782f, 0.03754352f, 0.02524886f, 0.00968295f, 
    -0.01746063f, 0.09616967f, 0.13691519f, 0.06002586f, -0.31830451f, -0.20542410f, 0.06286231f, 0.21151313f, 
    -0.18236549f, -0.04737592f, -0.03233821f, -0.01511097f, 0.01932868f, 0.00378456f, -0.02788834f, -0.04011132f, 
    -0.09352714f, 0.07027890f, 0.04639989f, -0.08958298f, 0.09305664f, 0.12791799f, -0.02438105f, -0.08083974f, 
    -0.02036662f, 0.01431110f, -0.03124508f, 0.20149198f, -0.11252789f, -0.13026635f, -0.02585780f, 0.00668968f, 
    0.00476026f, -0.02274953f, -0.04504723f, -0.09148894f, 0.01996213f, 0.08073737f, 0.04453643f, 0.03503506f, 
    -0.00686728f, -0.11553486f, 0.01660753f, -0.01774292f, 0.24427339f, 0.35134289f, 0.11318886f, -0.10861915f, 
    0.12664396f, -0.07524469f, -0.02285901f, 0.01709986f, -0.08407774f, 0.01510705f, 0.02245979f, 0.08398140f, 
    -0.04555348f, -0.02303083f, -0.00369297f, 0.01189903f, -0.04791326f, 0.15863930f, 0.10246287f, -0.04006343f, 
    0.00442173f, 0.19839698f, -0.17640857f, -0.16486573f, -0.06947234f, 0.09875123f, 0.04183187f, 0.01908362f, 
    -0.05599616f, 0.01456331f, -0.05188585f, -0.04645066f, 0.01714817f, -0.05054059f, 0.04138973f, 0.02433771f, 
    -0.06254368f, 0.07752366f, -0.22252224f, -0.07271183f, 0.03549651f, 0.05786987f, 0.05366821f, 0.13195528f, 
    -0.07660221f, -0.03813967f, 0.00017334f, -0.04828875f, 0.01439628f, 0.04285212f, 0.01185729f, -0.09045127f, 
    -0.08712055f, -0.05809449f, -0.04404486f, 0.03748701f, 0.13284954f, 0.08408315f, -0.05192085f, 0.03275351f, 
    -0.50575244f, -0.11681975f, 0.07380073f, 0.30230492f, -0.14238970f, -0.05360441f, -0.02019529f, -0.02528952f, 
    -0.07711054f, 0.11049076f, 0.05108501f, -0.11321279f, 0.02364882f, 0.03754685f, 0.04394440f, 0.07755274f, 
    -0.03413085f, 0.01598462f, -0.16139556f, 0.03379883f, -0.06236735f, -0.14780582f, 0.27093291f, 0.24118903f, 
    -0.14929867f, -0.05713717f, -0.06647229f, 0.02914220f, 0.00755481f, 0.05184643f, 0.00649664f, 0.01342908f, 
    -0.01823455f, 0.03412480f, -0.12218770f, -0.00087995f, -0.03877472f, -0.18778233f, 0.01807661f, 0.06855594f, 
    0.22332963f, 0.07484718f, 0.00164882f, 0.05390704f, -0.08848819f, -0.01010474f, 0.00539394f, -0.01456306f, 
    -0.03667799f, -0.02803829f, 0.01629614f, 0.03183185f, -0.03877687f, 0.04969835f, 0.00045368f, 0.08536321f, 
    -0.02230102f, 0.05013224f, 0.02226591f, 0.01374553f, 0.02511117f, -0.06071925f, 0.05975017f, 0.10931545f, 
    -0.00337238f, -0.11542888f, 0.00007138f, -0.03816734f, -0.02244201f, 0.12465790f, 0.01320220f, 0.01561449f, 
    0.17188036f, 0.11094285f, 0.06491663f, -0.11681652f, -0.13063501f, 0.01813796f, 0.14117225f, 0.06928461f, 
    -0.14512776f, -0.11023962f, -0.21655229f, 0.11392978f, 0.10798918f, 0.11152147f, 0.05016716f, -0.07605664f, 
    -0.02305226f, 0.02624487f, -0.06628388f, -0.07227201f, 0.09132819f, 0.03970828f, -0.23981439f, 0.10269350f, 
    0.05975300f, -0.05035705f, 0.09324464f, 0.00184949f, 0.11216353f, -0.54188812f, -0.14503545f, 0.09306151f, 
    -0.06653547f, 0.01362251f, 0.04435996f, -0.03334675f, 0.04626277f, 0.03132373f, 0.02154819f, 0.01615449f, 
    0.03739664f, 0.03629920f, 0.19770272f, 0.01530495f, 0.07138147f, -0.04473809f, -0.06823903f, -0.06243525f, 
    0.04861442f, 0.13995160f, 0.05865446f, -0.10110842f, 0.00590026f, 0.04383245f, -0.14324376f, 0.15289249f, 
    -0.03635141f, 0.04646055f, 0.06386559f, 0.04296180f, -0.04812905f, -0.03094177f, -0.12295374f, -0.06143001f, 
    -0.04973887f, 0.01015379f, 0.05829261f, 0.07059525f, 0.34615600f, -0.25474149f, -0.13481823f, -0.11603103f, 
    0.13996463f, 0.02415124f, 0.13435487f, 0.01277073f, -0.04545366f, -0.17565931f, -0.03499643f, 0.12548737f, 
    0.05865526f, 0.04416714f, 0.09607651f, 0.05044437f, -0.02314483f, 0.10011504f, -0.19687408f, 0.15942107f, 
    -0.45910943f, 0.05971293f, -0.18996075f, -0.29305184f, 0.15144910f, 0.02642344f, -0.00821319f, 0.09869125f, 
    -0.09387945f, -0.06894422f, 0.10392965f, -0.17943263f, 0.03270129f, 0.03710587f, 0.02515962f, -0.15433539f, 
    -0.06855226f, -0.17551047f, 0.17923206f, 0.05532863f, 0.21722846f, -0.32335725f, -0.02329153f, -0.31739348f, 
    0.21176937f, 0.17135857f, -0.04321818f, 0.06643220f, -0.08168791f, -0.05963807f, 0.05583469f, -0.07221033f, 
    0.16074872f, 0.05940396f, -0.06992639f, 0.11087702f, -0.06061366f, -0.14923067f, -0.10548488f, 0.20121467f, 
    -0.06041598f, -0.21143840f, -0.06447002f, 0.03402308f, 0.07503291f, -0.03920856f, 0.12675269f, 0.03498372f, 
    -0.19671863f, -0.23068757f, -0.05352411f, -0.10130716f, -0.08534009f, 0.01650793f, 0.00579218f, 0.05160571f, 
    0.03187054f, 0.18506864f, 0.12119982f, 0.08234434f, 0.10078625f, -0.47990125f, 0.07337169f, -0.03009599f, 
    -0.02163014f, 0.10492999f, -0.08778577f, 0.00549821f, -0.14279191f, 0.02277850f, 0.03183490f, -0.04900508f, 
    0.14978313f, 0.07934337f, 0.17788596f, -0.04287912f, 0.03589178f, -0.11001541f, -0.06975465f, -0.15901460f, 
    -0.21026880f, 0.27367437f, 0.09261838f, -0.06813550f, -0.35792276f, 0.02664801f, 0.06073726f, 0.03558510f, 
    0.06362035f, 0.01082420f, -0.04537399f, 0.04671244f, 0.00543452f, 0.05259934f, -0.17281228f, 0.02216831f, 
    0.11914053f, 0.05005041f, -0.00815220f, 0.03799289f, -0.17813596f, 0.29590973f, 0.18647671f, 0.09343776f, 
    -0.18835318f, 0.06754836f, -0.10731713f, -0.06612448f, 0.01766613f, -0.01123761f, 0.05095808f, 0.02602009f, 
    -0.00965992f, 0.04039745f, -0.15217485f, -0.04124828f, -0.04840908f, -0.12443708f, -0.05612704f, -0.19067438f, 
    -0.18545614f, 0.04487874f, -0.09456946f, -0.16011314f, 0.38710865f, -0.12328880f, -0.05795112f, 0.08125846f, 
    0.00515549f, -0.06663727f, -0.09032326f, -0.14268878f, -0.21102031f, 0.10237756f, 0.21286093f, -0.05950666f, 
    0.00595130f, -0.00224251f, 0.00078287f, 0.15462953f, 0.00185949f, 0.05427665f, -0.10843644f, -0.33297122f, 
    0.20172858f, -0.06028539f, -0.05053320f, -0.03911992f, -0.07711444f, -0.09187930f, -0.03140291f, -0.08262995f, 
    -0.07620125f, -0.08199193f, -0.14365450f, -0.10674901f, 0.03472797f, 0.02333360f, 0.20190790f, 0.09464395f, 
    0.26914617f, -0.39702374f, -0.25381768f, 0.27338156f, -0.04062887f, -0.12865630f, -0.02570706f, -0.00070060f, 
    0.15578072f, -0.09836973f, 0.02141215f, 0.11590977f, -0.08177951f, 0.04163207f, -0.06078401f, -0.06816462f, 
    -0.02242897f, -0.07628020f, -0.09083769f, 0.01029600f, -0.28115204f, 0.11365159f, -0.18593229f, 0.24892546f, 
    -0.28371716f, -0.08658971f, 0.05386690f, -0.06260618f, 0.08067815f, 0.00779686f, -0.00989337f, 0.10291963f, 
    0.06704442f, -0.05724187f, -0.04246179f, -0.08175923f, -0.07748646f, 0.03511604f, -0.20091066f, -0.02873471f, 
    0.29262623f, -0.36595353f, -0.10959120f, 0.13678467f, -0.05518626f, -0.01396070f, 0.00490765f, 0.13027233f, 
    -0.00661379f, 0.16120733f, 0.04517339f, 0.11490732f, -0.09298716f, 0.05525666f, 0.02222720f, 0.05278841f, 
    0.01600272f, 0.00978874f, -0.13872702f, -0.03715491f, -0.05123336f, -0.47018200f, -0.02039632f, -0.31446576f, 
    0.06177292f, -0.08844601f, 0.03036322f, -0.07753154f, -0.04247949f, -0.14240287f, -0.01367524f, 0.00737435f, 
    -0.06624675f, 0.10492784f, 0.04575158f, -0.07789034f, -0.03727917f, -0.07118556f, -0.09389941f, 0.05221075f, 
    0.15357350f, -0.10952035f, -0.09760073f, 0.20376746f, -0.24149178f, 0.15876116f, 0.12990871f, -0.14220865f, 
    -0.07052777f, 0.10836619f, 0.12243786f, -0.02514897f, -0.02772763f, 0.06979864f, -0.01090538f, -0.05787664f, 
    -0.05100442f, 0.22389294f, -0.07803535f, 0.09841314f, -0.00261639f, 0.11205184f, -0.06740662f, 0.16088653f, 
    -0.05116204f, -0.14027135f, 0.06984413f, -0.07951562f, -0.01311399f, 0.06873230f, -0.02567169f, 0.05893267f, 
    -0.01553992f, -0.01412125f, 0.12832217f, -0.18010466f, -0.00180845f, -0.00241139f, -0.12846087f, -0.09517836f, 
    -0.20563854f, 0.01764464f, -0.16372453f, -0.00408791f, -0.10282138f, -0.06239626f, 0.11497358f, 0.03264469f, 
    -0.04313691f, -0.00755052f, 0.11436395f, -0.02312032f, 0.04426329f, -0.06306116f, -0.00898962f, 0.06959080f, 
    -0.11231194f, 0.20554635f, 0.06081387f, 0.13348536f, -0.23610905f, 0.38100579f, 0.16434860f, 0.03448398f, 
    -0.36265826f, 0.02358161f, 0.12094676f, 0.06170334f, -0.00093101f, 0.13236664f, -0.07792258f, 0.02802056f, 
    0.01582004f, -0.11323983f, 0.00856274f, 0.04370356f, 0.02273438f, -0.03543447f, 0.10212050f, -0.13610525f, 
    0.21079367f, -0.49261525f, -0.04150795f, 0.01363243f, -0.01791007f, -0.13535497f, -0.03690341f, -0.10439672f, 
    0.06447402f, 0.03680951f, -0.17458773f, 0.08044598f, 0.01423963f, 0.10811100f, 0.06377146f, 0.01347100f, 
    -0.01834802f, -0.00227037f, -0.02335018f, -0.04921761f, -0.00699749f, -0.20020337f, -0.30930877f, -0.35176364f, 
    0.25138667f, -0.11921201f, 0.06074135f, -0.09299821f, -0.16309629f, -0.05695518f, -0.05097087f, -0.10985793f, 
    -0.13965996f, -0.03433730f, 0.03099350f, -0.02848172f, 0.03740848f, 0.23531348f, -0.06313315f, 0.08967099f, 
    -0.46878669f, -0.01627156f, -0.11365801f, 0.10829702f, 0.13147952f, -0.09763814f, -0.06371005f, 0.00233339f, 
    0.07914299f, 0.00435454f, -0.03494728f, 0.03891895f, 0.10282429f, -0.08160990f, 0.01895825f, -0.03828543f, 
    -0.04636571f, -0.10670577f, -0.08959329f, -0.04549248f, 0.07415715f, 0.18754585f, -0.04456711f, 0.03405691f, 
    -0.09479947f, -0.01351161f, -0.12972392f, 0.08730354f, 0.07474518f, 0.04557969f, 0.11575106f, 0.03777992f, 
    -0.06830399f, -0.01980662f, -0.11915596f, -0.01656076f, 0.01663466f, -0.12657709f, 0.00109033f, -0.07869755f, 
    0.14919005f, 0.15285002f, 0.00167470f, 0.07208054f, 0.02656885f, 0.00252039f, 0.09482360f, -0.03228137f, 
    0.13545766f, -0.04347835f, -0.03449154f, 0.10046824f, -0.03372701f, 0.01629169f, -0.10754060f, -0.06616108f, 
    -0.10061157f, 0.02051557f, -0.04280522f, 0.04063300f, -0.43860584f, -0.09549081f, -0.04198511f, 0.17211697f, 
    0.13756941f, 0.05421766f, 0.00778328f, -0.00665174f, -0.02159502f, -0.01309203f, -0.04196995f, -0.05732514f, 
    -0.01679493f, 0.00410405f, -0.13155289f, 0.05855527f, -0.05782278f, -0.14310424f, -0.10320064f, 0.03220449f, 
    0.55767947f, -0.10452039f, 0.02170886f, -0.06406540f, -0.23255736f, 0.00735528f, 0.09774972f, 0.12967540f, 
    -0.09278376f, -0.15078096f, -0.04117681f, -0.01618602f, 0.11114667f, 0.05191899f, -0.00340752f, 0.09610560f, 
    0.01889443f, 0.08498753f, 0.01135376f, 0.06364843f, -0.23086770f, 0.20955704f, 0.00854809f, 0.21522331f, 
    0.10562082f, -0.05554653f, 0.02428267f, 0.10745418f, 0.00777263f, -0.08312981f, -0.10879106f, 0.12117466f, 
    0.01203022f, -0.06658662f, -0.00400062f, -0.02107475f, 0.06600814f, 0.01770004f, -0.04063949f, -0.09202801f, 
    0.11662867f, -0.19082060f, 0.03169091f, 0.11829003f, 0.49835548f, -0.02265774f, -0.02460053f, 0.05358358f, 
    -0.06679267f, -0.01729235f, -0.11108192f, 0.00360505f, -0.10145833f, 0.02366021f, 0.05538940f, -0.07409657f, 
    -0.08234867f, 0.10500138f, 0.17409240f, -0.03326929f, -0.23673356f, -0.05516429f, 0.00568097f, 0.25579926f, 
    0.10859788f, 0.13871454f, 0.02163203f, 0.00677712f, 0.13250415f, -0.07771529f, -0.08782154f, 0.02858674f, 
    -0.01608458f, 0.07958418f, -0.03453774f, -0.04078163f, -0.04412980f, 0.09065428f, 0.10388850f, 0.01230518f, 
    -0.37506682f, 0.13731641f, -0.00191436f, 0.18676874f, -0.29918399f, -0.01571812f, -0.10406287f, 0.03310207f, 
    0.09316453f, 0.05454171f, -0.02420965f, -0.03778288f, 0.03141739f, -0.00646566f, 0.00520408f, -0.11633921f, 
    -0.05041753f, -0.10272831f, -0.07785834f, -0.09465230f, -0.43998316f, 0.25032499f, 0.22661223f, 0.02719845f, 
    -0.53707683f, 0.21883614f, 0.04024664f, 0.14957446f, 0.07263090f, -0.10060442f, -0.13982306f, 0.05502816f, 
    -0.03590181f, 0.04853400f, -0.09419079f, 0.05539608f, -0.12145241f, -0.09106739f, -0.07645936f, -0.06524894f, 
    0.07888138f, 0.33281732f, 0.05188240f, -0.09832790f, 0.18709670f, -0.05332320f, 0.11237333f, -0.08412945f, 
    -0.01707775f, -0.07362376f, -0.06222280f, -0.03659154f, -0.06101206f, -0.09856427f, -0.04310095f, -0.00188947f, 
    0.03740123f, 0.09045482f, -0.03164466f, 0.00851119f, 0.07620627f, -0.15873659f, 0.00518792f, 0.02451900f, 
    0.13240470f, 0.07723718f, -0.00449829f, -0.11288936f, 0.03230125f, -0.08007596f, 0.01119195f, -0.07247212f, 
    -0.00318802f, -0.06301114f, -0.07121234f, -0.08583789f, -0.03129445f, -0.06391859f, -0.03721721f, 0.00896335f, 
    -0.02477128f, -0.28570127f, 0.17365983f, 0.02426630f, -0.25873175f, 0.02351351f, -0.09342228f, -0.04029950f, 
    -0.07300477f, -0.07071158f, -0.11260393f, -0.10198426f, -0.08904823f, 0.05813591f, -0.11748174f, 0.10643473f, 
    -0.01787022f, -0.05491953f, -0.02066295f, -0.10337329f, -0.36836654f, 0.32578856f, 0.30721208f, -0.02664165f, 
    0.10018908f, -0.06924635f, 0.10154187f, -0.08957110f, 0.06827377f, -0.00754298f, -0.04086024f, 0.07451325f, 
    -0.04923190f, 0.03074028f, -0.13210979f, -0.00236174f, -0.04479214f, 0.00448447f, 0.03164559f, -0.12631254f, 
    0.27311352f, 0.12967315f, 0.30673110f, 0.13154189f, 0.16065097f, 0.11971490f, 0.07452262f, -0.10778017f, 
    -0.02973549f, -0.05308687f, -0.02330382f, 0.07582425f, -0.03252472f, -0.09918511f, -0.05287036f, -0.02307921f, 
    0.00039409f, -0.02304062f, 0.10077092f, -0.09467544f, 0.30385938f, 0.09840024f, 0.30987400f, -0.06360205f, 
    0.15459137f, -0.04858721f, 0.15662235f, 0.00361235f, 0.01893592f, 0.01285572f, -0.05228164f, 0.03111340f, 
    -0.08599950f, 0.00959878f, 0.00014474f, -0.03547709f, 0.07084699f, -0.01190225f, 0.06835800f, -0.08192731f, 
    0.08862200f, -0.07437347f, 0.29548040f, 0.08481780f, 0.01888614f, 0.12517579f, -0.01416039f, 0.02500224f, 
    -0.04705583f, -0.06363015f, -0.03014083f, 0.08303773f, 0.00005517f, 0.02384454f, -0.07236069f, -0.05024426f, 
    -0.02157154f, 0.01980861f, 0.04167142f, -0.04948983f, 0.25857034f, -0.17721170f, 0.08294722f, -0.02017352f, 
    -0.00558078f, -0.04866789f, 0.05695504f, -0.02533700f, -0.06579521f, 0.01932972f, 0.04418222f, -0.01350314f, 
    -0.00821602f, -0.00919910f, -0.04756743f, -0.04084253f, 0.04268147f, -0.04391844f, 0.01142763f, -0.08620956f, 
    -0.23484761f, 0.09458155f, -0.31856260f, -0.04327092f, -0.02752016f, 0.00113277f, -0.04463486f, -0.15167639f, 
    -0.02645239f, -0.07608716f, -0.16672528f, 0.00042634f, 0.03296348f, -0.09464307f, -0.03922066f, -0.05319953f, 
    0.01771410f, -0.05918283f, 0.00457116f, 0.05161780f, -0.08580850f, -0.41372707f, -0.02339156f, -0.14752747f, 
    -0.21177122f, 0.00665750f, 0.02616293f, 0.03285822f, -0.03346287f, -0.09541968f, -0.06472239f, -0.12260331f, 
    -0.06398428f, -0.00614501f, -0.05299756f, 0.00541990f, 0.08250193f, 0.02776119f, -0.01443216f, 0.01340312f, 
    0.09481678f, 0.07126427f, -0.12305944f, -0.00695294f, 0.07675869f, -0.06626195f, -0.00811533f, -0.11352538f, 
    0.07931103f, -0.13418306f, -0.12742788f, 0.06041986f, -0.07366182f, 0.02297382f, -0.07744209f, -0.01193523f, 
    -0.13258924f, -0.09172270f, -0.11365210f, 0.00379660f, 0.15848455f, 0.16758509f, 0.20387435f, 0.01293476f, 
    0.26435083f, -0.11343060f, 0.13483074f, -0.08221448f, -0.01334558f, 0.00928237f, 0.01003056f, 0.04525086f, 
    -0.13727631f, -0.05070827f, -0.01595013f, -0.01742742f, 0.03447288f, 0.03082966f, -0.09853634f, -0.08340747f, 
    0.14544745f, -0.06372043f, 0.02427505f, -0.08829366f, 0.05870092f, 0.02865480f, -0.03415889f, 0.04065025f, 
    0.01364731f, -0.00235648f, -0.07044142f, -0.03207198f, -0.07333437f, 0.01542871f, 0.03624697f, 0.04173825f, 
    -0.10755317f, 0.07176705f, 0.07398952f, 0.06982337f, -0.57733816f, 0.08217350f, -0.00412758f, -0.10698518f, 
    -0.20389432f, -0.04640481f, 0.00549916f, -0.13978612f, -0.06835229f, -0.13158958f, -0.04901269f, 0.01501714f, 
    -0.10835243f, 0.01874985f, -0.06791467f, -0.00587538f, -0.01965002f, 0.01101451f, -0.00676505f, -0.01629946f, 
    0.04558749f, -0.29008383f, 0.01597376f, 0.00696604f, -0.13872156f, 0.02435020f, -0.09862947f, 0.01903646f, 
    -0.10645749f, -0.10096124f, 0.02857950f, 0.00470941f, -0.01346391f, -0.08220690f, -0.09707528f, 0.00791359f, 
    0.04390174f, 0.00876110f, -0.05082278f, 0.03229139f, 0.10180005f, 0.00954772f, 0.33780092f, 0.26521534f, 
    0.22817467f, 0.16840111f, 0.18617485f, 0.08356570f, 0.00221169f, -0.10130629f, -0.00924534f, 0.00472501f, 
    -0.05698936f, 0.07422321f, 0.00313768f, -0.18226846f, -0.00149518f, 0.07160956f, 0.02378178f, -0.05607877f, 
    -0.06065169f, 0.22045383f, -0.09296721f, 0.03438780f, 0.19065519f, 0.00183107f, -0.00650026f, -0.13563782f, 
    0.06309944f, -0.04420801f, -0.03116466f, 0.08620459f, -0.02056146f, -0.01057585f, -0.09544257f, 0.01892810f, 
    -0.02706264f, 0.04080295f, 0.01382513f, -0.03397402f, 0.01757811f, 0.16249768f, 0.02946083f, -0.17055698f, 
    -0.09354658f, 0.01299425f, 0.00377151f, -0.08285885f, 0.04660606f, 0.02163927f, -0.02408968f, 0.02657804f, 
    -0.06522977f, -0.03356718f, -0.02221773f, 0.02524246f, 0.02635088f, -0.01283874f, -0.03963526f, 0.03174116f, 
    0.14395177f, 0.19441131f, 0.04789737f, 0.22139812f, 0.20736368f, -0.07375392f, -0.13144897f, -0.16084504f, 
    0.02470655f, -0.06359049f, -0.04343481f, 0.04523851f, 0.01925168f, 0.05677744f, -0.13478273f, 0.04521738f, 
    -0.09506170f, -0.08247275f, 0.02193661f, -0.09821443f, -0.17975262f, -0.18565094f, -0.31329998f, -0.08306438f, 
    -0.06845539f, -0.07312578f, -0.20108394f, -0.04877038f, -0.04747007f, -0.09866048f, -0.13443416f, 0.00814059f, 
    0.11595287f, -0.03442419f, -0.05340850f, -0.05969431f, 0.03164722f, -0.03717329f, 0.02805258f, -0.00953651f, 
    -0.17190143f, -0.00081843f, 0.17913675f, 0.07954311f, -0.06400339f, 0.08666591f, -0.06367216f, 0.00149625f, 
    0.07326372f, 0.01548103f, -0.04867305f, 0.03302000f, 0.09242175f, 0.11996166f, -0.04025215f, 0.04585360f, 
    -0.01970632f, 0.00987078f, 0.02552545f, 0.02615383f, 0.09085200f, 0.23751521f, 0.01739089f, 0.07931414f, 
    0.24490960f, -0.08164814f, 0.07363492f, -0.15299167f, 0.02227376f, -0.03609515f, -0.11726528f, 0.01293312f, 
    -0.17217340f, 0.01542076f, -0.12535366f, 0.02239247f, 0.06072538f, 0.06494408f, -0.04113531f, -0.06698951f, 
    -0.20374200f, -0.01931790f, 0.07802176f, -0.05936369f, -0.04443080f, -0.11404790f, -0.13094923f, -0.04070484f, 
    -0.04854827f, -0.04710480f, 0.11200722f, 0.04328600f, -0.00352044f, -0.03477603f, -0.05255590f, 0.00895517f, 
    0.07667375f, 0.01518829f, -0.05950574f, -0.01475813f, 0.15719625f, -0.20856625f, 0.07885416f, -0.08592991f, 
    -0.12488058f, 0.13914877f, -0.00716351f, -0.01929787f, -0.04763200f, -0.00379873f, -0.01572980f, -0.04880062f, 
    -0.07992924f, -0.05660817f, -0.08958369f, -0.02620856f, 0.08288163f, 0.00450952f, 0.01545236f, -0.01975505f, 
    -0.40088782f, 0.01538545f, -0.09849773f, 0.16652270f, 0.15243383f, 0.05110260f, -0.18741342f, -0.04261461f, 
    0.03887809f, -0.05406729f, -0.02257068f, 0.03633670f, 0.00649373f, -0.06443413f, -0.00456178f, -0.00457872f, 
    -0.05866186f, 0.02856872f, 0.04364773f, 0.01604545f, -0.13128318f, 0.00088055f, -0.02694210f, -0.19865452f, 
    -0.19240387f, -0.05870745f, 0.03317961f, 0.07794202f, -0.07485841f, -0.01273009f, 0.00941509f, 0.01391542f, 
    -0.06190950f, -0.03536144f, 0.05175226f, -0.01134959f, 0.02146874f, -0.01227193f, -0.03469587f, -0.02539871f, 
    0.26356357f, -0.14223117f, 0.14861195f, -0.08257826f, 0.27080056f, -0.03366851f, 0.09478177f, 0.00885324f, 
    0.08775225f, 0.00391127f, -0.07314387f, 0.00992135f, -0.02436946f, -0.01042309f, -0.00894932f, -0.05858768f, 
    0.01505756f, 0.02295067f, -0.00243910f, -0.04411990f, -0.28938410f, -0.01711244f, -0.18565349f, -0.26130623f, 
    -0.21453457f, 0.02784685f, 0.02198023f, -0.03104193f, 0.07057641f, 0.00705323f, -0.07154118f, -0.02626362f, 
    -0.07182823f, -0.07382667f, 0.03000449f, 0.00605903f, -0.10665993f, 0.00333049f, -0.04489290f, 0.04834585f, 
    -0.07351096f, 0.09515541f, -0.34002262f, -0.02154079f, 0.15133487f, -0.04931181f, -0.13898423f, -0.07054783f, 
    0.11357721f, -0.03264572f, -0.09500317f, -0.04940636f, -0.05989072f, -0.04695786f, -0.00626019f, 0.06313421f, 
    -0.15235141f, -0.01878792f, -0.00504397f, -0.03170678f, -0.35241914f, -0.00128635f, 0.20298925f, 0.07034444f, 
    0.01143286f, 0.08262673f, -0.17403592f, -0.04757324f, 0.07129548f, -0.01580337f, -0.01739590f, -0.00748032f, 
    -0.02907336f, -0.08692336f, -0.13731343f, 0.01564509f, -0.02839424f, -0.00836252f, -0.05587245f, -0.04676893f, 
    -0.09361810f, -0.15136711f, -0.05006010f, -0.09626820f, -0.27721563f, -0.09403438f, -0.02047965f, 0.06781557f, 
    -0.02238506f, -0.12882704f, 0.07194048f, -0.01411609f, -0.07253415f, -0.00324904f, -0.01488008f, 0.00965971f, 
    0.02190098f, -0.00975767f, -0.04652814f, -0.02221933f, 0.00933347f, -0.46566045f, -0.02143844f, -0.09719599f, 
    -0.16086265f, -0.06021942f, 0.00458561f, -0.07787696f, 0.03843974f, -0.04009207f, -0.08047277f, -0.04655953f, 
    -0.04812476f, -0.08486453f, 0.01547051f, -0.02472433f, 0.02333667f, -0.07387564f, -0.02396816f, -0.04063383f, 
    -0.28180575f, 0.18624425f, -0.12116309f, -0.15144329f, -0.40020129f, -0.11992270f, -0.08355532f, -0.00673930f, 
    -0.01873820f, -0.09477039f, 0.11381685f, -0.05860478f, -0.03307576f, -0.05346920f, 0.00276552f, -0.10358691f, 
    -0.05785308f, -0.15168902f, 0.05638547f, 0.05500700f, 0.05003388f, -0.06801064f, 0.15550841f, 0.05475857f, 
    0.13995335f, -0.05764015f, -0.10991399f, -0.00389989f, -0.11701655f, 0.00281410f, 0.02634135f, 0.01998252f, 
    -0.08054803f, 0.03070270f, -0.06516366f, 0.04565843f, -0.01023114f, 0.07614174f, 0.05872244f, 0.01174774f, 
    -0.04494694f, 0.00325208f, 0.02681632f, 0.08993814f, 0.10766463f, 0.04278617f, -0.04576350f, -0.08400240f, 
    -0.02081771f, -0.06823148f, -0.00549946f, -0.02513908f, 0.02780528f, -0.09363084f, 0.08138028f, -0.06017844f, 
    -0.00526128f, 0.04110323f, 0.07425579f, -0.09563009f, 0.08595677f, -0.02994402f, 0.10624003f, 0.08187564f, 
    -0.03453514f, -0.04095880f, -0.01327158f, 0.04951287f, -0.15951914f, 0.11137804f, 0.04947230f, -0.03467559f, 
    -0.06175173f, 0.04719512f, 0.04920720f, 0.05817644f, -0.05657667f, -0.09521972f, 0.08086663f, -0.09493224f, 
    -0.41990361f, -0.12849662f, 0.24581672f, -0.09829661f, -0.01810300f, -0.04672584f, 0.01131025f, 0.06446199f, 
    -0.05798771f, -0.13314357f, 0.05366927f, 0.00777409f, -0.04571525f, 0.19622888f, 0.04667790f, -0.07730445f, 
    -0.05637492f, 0.03453629f, -0.23967016f, 0.10277261f, -0.24326223f, 0.14000896f, 0.14252622f, -0.10663418f, 
    0.16815116f, -0.09163018f, 0.00260471f, 0.07857678f, -0.03620360f, 0.05214770f, 0.13232090f, 0.01063346f, 
    -0.11393567f, 0.01298114f, 0.10615081f, 0.00128946f, 0.01266574f, 0.05467103f, 0.03627833f, 0.00056419f, 
    -0.08969489f, 0.02187371f, -0.17594823f, 0.07899310f, -0.15526742f, 0.01197579f, -0.02637312f, -0.06675950f, 
    -0.18472780f, -0.06897767f, 0.08329921f, 0.01612326f, -0.10165535f, 0.01855719f, -0.06044345f, 0.00447755f, 
    -0.04660227f, -0.11106657f, -0.01392008f, 0.02725344f, 0.07365673f, -0.06941487f, 0.13436729f, -0.01231394f, 
    0.16566284f, -0.06974066f, -0.02422249f, 0.03241689f, -0.08594804f, -0.01362349f, 0.05398904f, -0.04156819f, 
    0.03339856f, -0.09213400f, 0.02659020f, 0.07495163f, -0.00957174f, 0.02738743f, 0.00392221f, 0.01778702f, 
    -0.11838737f, -0.09217753f, -0.26864332f, -0.16422883f, -0.07191926f, 0.01608619f, -0.02813677f, -0.06438417f, 
    -0.01126549f, -0.06528658f, 0.08990260f, 0.02314052f, -0.01503024f, 0.10731713f, 0.01913314f, -0.01849093f, 
    0.09291252f, 0.05194175f, 0.03835619f, 0.02858530f, 0.13039964f, -0.02220636f, -0.19119881f, 0.07888523f, 
    0.13664052f, 0.12696679f, 0.00911430f, -0.06782465f, -0.03827611f, -0.06273647f, -0.14901169f, -0.04503268f, 
    0.03112676f, 0.03833015f, -0.07904859f, 0.07677539f, 0.00573826f, 0.03659362f, 0.05173065f, -0.03926673f, 
    -0.13390332f, 0.11788497f, 0.12971714f, -0.11518617f, -0.02021732f, -0.04355261f, 0.01226600f, -0.13874006f, 
    -0.10053498f, -0.03616333f, 0.02848900f, 0.11164933f, -0.00040808f, -0.03577281f, -0.13041356f, -0.10064839f, 
    0.01331588f, 0.02632981f, -0.03626364f, -0.23059201f, -0.15760823f, 0.31866485f, -0.11290729f, -0.24410495f, 
    -0.25439644f, -0.05584428f, 0.04030205f, -0.03876069f, -0.04764438f, -0.02703935f, 0.10699303f, 0.01159352f, 
    0.03783295f, 0.05452752f, 0.02831971f, -0.05922706f, 0.03540598f, -0.21366948f, -0.07500797f, 0.07259370f, 
    0.14183007f, 0.11191551f, -0.10614735f, 0.04883968f, 0.11587591f, 0.08496267f, -0.00805808f, -0.06852072f, 
    -0.04745601f, -0.07899505f, 0.11495072f, -0.04112200f, 0.09521041f, -0.01676336f, -0.14006327f, -0.00075215f, 
    -0.07735243f, 0.03876678f, 0.11998244f, 0.10941365f, 0.14840500f, 0.12817319f, -0.15622830f, 0.13991664f, 
    0.07052199f, 0.07839263f, 0.11055020f, -0.03028339f, -0.14988099f, -0.04546707f, -0.01785888f, -0.04152711f, 
    0.04324069f, 0.03084072f, 0.03234955f, -0.01564242f, -0.00071461f, 0.03075764f, 0.16309588f, -0.01791519f, 
    0.03804152f, -0.04449777f, 0.08060993f, 0.05090715f, 0.13289472f, -0.08489864f, -0.06305072f, -0.07084515f, 
    -0.04842852f, 0.02560018f, -0.10269851f, -0.12221342f, -0.05568047f, -0.12647766f, 0.00369736f, -0.01209699f, 
    -0.03421303f, 0.06319514f, 0.03977536f, 0.05878212f, -0.22326975f, -0.08110649f, 0.22724375f, 0.10484830f, 
    0.12217131f, -0.18818776f, -0.04155039f, -0.05932410f, -0.06709249f, -0.07807159f, 0.05679692f, 0.00075630f, 
    -0.06094909f, -0.04772995f, 0.00939413f, 0.02530008f, 0.03715013f, -0.05004318f, -0.04534189f, 0.02461993f, 
    -0.13596441f, 0.12054720f, -0.27165541f, -0.21735108f, -0.14641334f, -0.00689747f, -0.00384017f, -0.20969473f, 
    0.00675518f, -0.05732419f, 0.05501851f, -0.00743400f, 0.05182143f, -0.11669069f, 0.06208726f, 0.00657129f, 
    -0.02489772f, -0.04252770f, 0.06085352f, 0.04591743f, 0.06275641f, 0.07768296f, -0.09477237f, 0.06910541f, 
    -0.03255937f, 0.00994078f, 0.02687887f, -0.12871818f, -0.04142991f, 0.07929220f, 0.16814873f, 0.03586658f, 
    -0.04318508f, -0.03984236f, 0.05128414f, -0.06656605f, 0.03475085f, 0.04298817f, 0.12808564f, 0.00833144f, 
    -0.20169921f, -0.14937060f, -0.35994661f, -0.09206886f, -0.15692936f, 0.07969062f, -0.05674077f, -0.32675499f, 
    -0.03534629f, -0.12289291f, 0.08475565f, 0.00805583f, 0.05723847f, -0.08558952f, 0.10569271f, -0.19708230f, 
    0.08100682f, -0.14528373f, -0.02852683f, -0.10459086f, -0.13436471f, -0.14286238f, -0.09398965f, 0.02190903f, 
    0.18217912f, 0.01341802f, 0.08424009f, -0.11336505f, -0.03920178f, -0.03183032f, 0.04894742f, 0.09279644f, 
    0.01499762f, -0.01352759f, 0.09438707f, -0.10142228f, 0.11819213f, 0.09604551f, -0.01081374f, -0.06566572f, 
    -0.00708184f, 0.01602307f, 0.00254390f, 0.04498534f, 0.16641010f, -0.16496164f, -0.10174867f, -0.09400371f, 
    -0.19187328f, 0.15397461f, -0.07904701f, -0.12953228f, -0.02301000f, -0.12437984f, -0.04063369f, -0.01579968f, 
    0.07092521f, -0.02444250f, 0.07519265f, -0.05763986f, -0.21852957f, 0.28314376f, 0.12611467f, -0.11274172f, 
    -0.30260804f, -0.25399214f, 0.05082905f, -0.00601655f, -0.03234751f, -0.08021796f, 0.07975687f, 0.05072071f, 
    0.04339321f, -0.05429491f, 0.02092535f, -0.04335845f, -0.04910531f, -0.31701335f, 0.03503712f, 0.02318089f, 
    0.22996402f, 0.12472612f, -0.16490082f, 0.11432554f, 0.08939195f, -0.07560563f, -0.00563062f, -0.14927806f, 
    -0.04463326f, 0.05740091f, -0.01969323f, 0.02621242f, -0.12251239f, -0.01553007f, -0.02011181f, 0.02870476f, 
    -0.00432104f, 0.00172099f, 0.07791594f, -0.03662938f, 0.14072710f, -0.06058322f, 0.04167977f, -0.13284416f, 
    0.10885261f, 0.00423186f, -0.00002723f, -0.04613695f, 0.03604796f, -0.04878082f, 0.00431200f, -0.00157699f, 
    -0.02958128f, 0.06393825f, -0.14184837f, 0.04793702f, -0.01135612f, 0.05352091f, -0.07140365f, 0.04124940f, 
    -0.10523645f, -0.00270286f, -0.26042086f, -0.18088719f, -0.10479394f, 0.09540280f, -0.08932026f, -0.07333099f, 
    0.01529201f, -0.04321243f, 0.09662664f, 0.02791769f, 0.00163634f, 0.00112895f, -0.01647579f, 0.03883142f, 
    0.00029227f, -0.01340683f, 0.05642067f, -0.08321545f, 0.19674163f, 0.15448758f, -0.04323463f, 0.03077149f, 
    -0.01774086f, -0.03829877f, 0.00143599f, -0.10938894f, -0.07694316f, 0.00081063f, 0.06291840f, 0.05828061f, 
    -0.08542246f, -0.14903647f, -0.00713162f, -0.05256143f, -0.08161795f, 0.01058124f, 0.12233326f, -0.01391181f, 
    -0.23162971f, -0.21768743f, 0.02823390f, -0.27023622f, -0.11055612f, 0.01153125f, -0.01469011f, 0.05493059f, 
    -0.17231181f, 0.02414020f, 0.04985530f, -0.02152522f, 0.01308320f, 0.11330235f, 0.01512114f, -0.02538303f, 
    0.03110687f, -0.03789742f, -0.08482776f, 0.08195723f, 0.08939496f, 0.19316109f, -0.08329843f, -0.06137886f, 
    -0.01746353f, 0.06163564f, 0.04173007f, -0.07219476f, 0.02687870f, -0.03788890f, 0.09321987f, 0.02638693f, 
    -0.04041769f, 0.16958457f, -0.10919701f, -0.01769569f, -0.03817998f, 0.05833688f, 0.05177668f, -0.03767081f, 
    -0.12829672f, 0.17517044f, 0.12334712f, -0.15050791f, 0.04209529f, -0.04824579f, 0.02944586f, -0.13718875f, 
    -0.10483585f, -0.16324720f, 0.13279639f, 0.06851103f, -0.01854789f, 0.03238996f, -0.04893589f, -0.10766330f, 
    0.11000595f, 0.08806535f, -0.05929222f, -0.07132124f, -0.01991156f, 0.22076732f, -0.44961232f, 0.09682111f, 
    -0.06054816f, 0.01053462f, -0.12947090f, -0.20481311f, -0.09568263f, 0.02816307f, -0.01939135f, -0.02877602f, 
    0.05115834f, -0.00616038f, -0.05604889f, 0.12957473f, 0.02090470f, -0.12495037f, 0.12351043f, 0.07858394f, 
    0.23969825f, 0.15196621f, -0.14019576f, 0.18349220f, 0.16140321f, -0.00839832f, -0.02861124f, -0.12659325f, 
    -0.04391699f, -0.03912367f, -0.07801403f, -0.11525147f, -0.06053990f, -0.08513169f, 0.01323362f, -0.13243724f, 
    -0.02778694f, -0.02136903f, 0.13458115f, -0.09827758f, 0.02730279f, -0.25115427f, -0.39725313f, 0.17315404f, 
    0.06924561f, 0.08870716f, 0.00099905f, -0.07461203f, -0.14573826f, -0.00315101f, -0.04725476f, 0.05625590f, 
    0.05196623f, -0.00276432f, 0.02585337f, -0.09642782f, -0.10644741f, 0.02360940f, 0.12544732f, -0.04305364f, 
    -0.45223227f, 0.22321238f, -0.01880216f, 0.03947280f, -0.14183341f, 0.01420841f, 0.07606563f, -0.09422895f, 
    0.06664328f, 0.02907978f, -0.05938695f, -0.10666040f, 0.01806874f, 0.00212903f, 0.13300104f, 0.05630580f, 
    0.02317779f, 0.16984284f, -0.05275546f, -0.05276521f, 0.17297016f, 0.00478717f, 0.03046848f, -0.07005663f, 
    0.02172940f, 0.08063074f, -0.03856064f, 0.05356014f, -0.06818165f, 0.10026331f, 0.06239896f, 0.05732617f, 
    0.04499450f, 0.09362373f, 0.00904667f, 0.02697965f, 0.04712261f, -0.14817175f, 0.04399712f, -0.06573134f, 
    0.06647946f, -0.57609791f, 0.16331856f, -0.12562698f, 0.05485855f, 0.04217554f, 0.07629040f, -0.23207691f, 
    0.04314866f, -0.04741029f, -0.02429876f, 0.00612817f, 0.00751624f, -0.03175581f, -0.02309121f, 0.07009859f, 
    0.09889665f, -0.17115401f, -0.16080663f, -0.05222976f, -0.49419472f, 0.01330047f, -0.05657578f, 0.27050099f, 
    0.15508047f, 0.20190571f, -0.02434316f, -0.15639819f, -0.07570896f, 0.26243782f, 0.00050533f, 0.05958396f, 
    -0.03221862f, -0.04423744f, -0.03873307f, -0.02253060f, -0.14569864f, -0.01177653f, -0.00592333f, -0.04880061f, 
    0.05923085f, -0.28368622f, -0.11669024f, 0.21913193f, 0.01643513f, -0.16090375f, -0.03415400f, -0.07920045f, 
    0.09018847f, 0.04036137f, -0.06128389f, 0.10348145f, 0.06424401f, -0.09735755f, 0.08997007f, -0.06987461f, 
    0.02115526f, 0.03119075f, 0.01659156f, 0.07861112f, 0.00965160f, -0.04778356f, -0.27938360f, 0.26137003f, 
    -0.12063549f, -0.05359533f, 0.09013630f, -0.10331232f, 0.02195810f, 0.08707120f, -0.09652222f, 0.04253983f, 
    0.00354714f, -0.02236899f, 0.10576960f, 0.05448422f, -0.02004621f, -0.07065245f, 0.00947411f, -0.06397369f, 
    0.27330908f, -0.34528217f, 0.08667677f, 0.34858599f, 0.35623312f, -0.08810891f, -0.10713039f, 0.08811223f, 
    0.09762275f, -0.00241056f, 0.12534580f, 0.00088574f, -0.02996225f, 0.00425882f, -0.12674034f, -0.04764925f, 
    -0.02824686f, 0.04586399f, -0.00444739f, 0.24773256f, 0.28706777f, 0.02303068f, -0.08932574f, 0.07808526f, 
    -0.02742605f, 0.13682289f, -0.03563269f, 0.00721885f, 0.03771351f, 0.02904714f, -0.03537378f, 0.10248941f, 
    -0.02649511f, -0.03155598f, -0.07819853f, 0.03955838f, 0.05900465f, -0.13762292f, -0.07315155f, 0.06772224f, 
    -0.06996729f, -0.08731458f, 0.10932107f, -0.11674242f, -0.46629977f, -0.02005862f, 0.04335595f, 0.09920826f, 
    -0.17242223f, 0.11980556f, -0.12819561f, 0.00618929f, -0.00924095f, -0.23334424f, -0.08753501f, -0.15730378f, 
    -0.06078207f, -0.05153992f, 0.08845954f, -0.08217590f, 0.07653970f, -0.11083634f, 0.25334638f, -0.11853199f, 
    -0.25791174f, 0.16736391f, -0.02085116f, -0.16690913f, -0.07302807f, 0.01078488f, -0.19098242f, 0.05710850f, 
    -0.03878907f, 0.02393658f, 0.05962858f, -0.04836770f, -0.09391531f, 0.06648326f, 0.02699246f, 0.03824485f, 
    0.55789769f, 0.03729297f, -0.21978736f, -0.28222400f, -0.04892762f, -0.13538516f, 0.06197552f, 0.01671266f, 
    0.10799065f, 0.06339668f, -0.06726009f, -0.12796859f, 0.03553763f, 0.03142524f, -0.00181269f, 0.14235477f, 
    0.07626043f, 0.13199165f, -0.00096731f, -0.02265940f, -0.27010423f, 0.02934029f, -0.20562029f, 0.05718622f, 
    -0.17042057f, -0.03116565f, 0.05925585f, 0.02972965f, -0.08047447f, 0.07127018f, -0.03147346f, 0.00381308f, 
    0.02975649f, 0.13030832f, 0.16709483f, 0.01907836f, -0.10758505f, 0.08391783f, 0.09991419f, 0.03445428f, 
    -0.10630789f, 0.15573339f, -0.15696950f, -0.45984802f, -0.11342961f, 0.09866191f, -0.08456805f, -0.05030685f, 
    -0.10203103f, 0.01846127f, -0.08886300f, -0.04679407f, -0.00322638f, 0.18603268f, -0.10361896f, -0.04091366f, 
    0.01910737f, -0.06830987f, -0.00031755f, -0.14084059f, -0.26089242f, 0.15823828f, 0.26947713f, 0.02226897f, 
    0.05905661f, 0.06277547f, 0.05985798f, -0.05967503f, -0.01496934f, -0.01545370f, 0.02191707f, 0.04619930f, 
    -0.00181038f, -0.03550547f, -0.02802688f, 0.12135869f, -0.02439957f, 0.16096729f, -0.27581018f, -0.00105128f, 
    0.14705805f, -0.18869598f, 0.11298307f, -0.02020380f, 0.09409200f, 0.09199879f, 0.01321194f, -0.01101463f, 
    -0.02373847f, -0.08848048f, -0.08116075f, -0.04385954f, 0.08028313f, 0.11175408f, 0.06004259f, -0.00238346f, 
    -0.01720355f, -0.24121612f, -0.09964874f, -0.08889851f, 0.05763669f, -0.27177343f, -0.11453843f, 0.19989555f, 
    -0.03936641f, 0.11890458f, 0.01676855f, -0.14364408f, -0.03013224f, 0.09372672f, 0.01024924f, -0.06707252f, 
    -0.01466827f, 0.03035981f, 0.03657338f, -0.08959635f, -0.17697315f, 0.01392338f, 0.01009714f, 0.01868874f, 
    -0.62939149f, 0.18493205f, 0.21842317f, -0.22478063f, -0.10231622f, -0.03416559f, 0.06876790f, -0.03137468f, 
    0.07413899f, -0.02106316f, -0.08419561f, 0.02685976f, 0.01282848f, 0.09655722f, -0.05655196f, -0.00661487f, 
    0.00922526f, 0.12749606f, 0.13599214f, 0.05890238f, -0.30838436f, 0.18637511f, 0.18866470f, 0.00188834f, 
    0.06654605f, 0.13231158f, -0.01804316f, 0.04842051f, -0.04989143f, -0.20238143f, 0.06180714f, -0.00555304f, 
    -0.03486717f, 0.03463036f, 0.05264219f, -0.06780483f, 0.11994880f, -0.01709553f, -0.15910406f, 0.08626626f, 
    -0.26142576f, 0.01551908f, 0.14853312f, -0.19039851f, -0.14862286f, -0.26089263f, 0.08921449f, -0.14083651f, 
    0.02203804f, 0.04473115f, -0.20705971f, -0.01498227f, -0.10927010f, 0.02035408f, 0.06856896f, 0.15148997f, 
    0.13800839f, -0.05301726f, -0.04481994f, 0.07708105f, 0.06176241f, -0.14533785f, -0.00547329f, -0.30612630f, 
    -0.26231727f, -0.08209944f, 0.08209992f, -0.05513091f, -0.04450422f, -0.02993356f, 0.01978278f, -0.01844916f, 
    -0.06901368f, -0.17316249f, -0.05173157f, 0.03606382f, 0.00370461f, -0.14766428f, -0.11923627f, 0.02796549f, 
    0.13604800f, -0.36659154f, -0.11526608f, -0.02666453f, 0.03555131f, 0.00658018f, 0.04823852f, 0.02905338f, 
    0.14612035f, 0.08966420f, 0.00796168f, 0.10431457f, 0.01577468f, 0.13674362f, -0.01164031f, -0.09762497f, 
    0.03427854f, 0.07714348f, -0.08201475f, -0.00444269f, -0.20112853f, 0.16317111f, -0.00200668f, 0.10546760f, 
    -0.09038772f, 0.14003368f, 0.04313313f, 0.05487994f, -0.02741023f, -0.03725890f, -0.10520139f, -0.00218262f, 
    -0.01506448f, -0.09734125f, 0.14892682f, 0.08980883f, -0.00322372f, 0.01157547f, -0.08907744f, -0.02321968f, 
    -0.27266207f, 0.16255477f, 0.05149459f, 0.20226361f, -0.17045562f, 0.15444905f, -0.11138043f, 0.00982572f, 
    0.06447481f, -0.23503463f, 0.05572596f, 0.16858871f, 0.00908594f, -0.04140243f, 0.09884416f, -0.13100392f, 
    -0.06099351f, 0.01064361f, -0.00634878f, 0.15325260f, -0.03055058f, -0.13104042f, 0.20476444f, -0.14812434f, 
    -0.27752152f, 0.07851139f, 0.06354392f, -0.02667611f, 0.00237971f, 0.03327493f, 0.00198629f, 0.02704106f, 
    0.17064384f, 0.03522724f, -0.00263862f, 0.10233460f, 0.04337477f, -0.24219425f, -0.03046924f, -0.16864784f, 
    -0.20430225f, 0.07290956f, 0.11623694f, -0.39477268f, -0.09756348f, -0.11728705f, -0.00117224f, 0.07791041f, 
    -0.02373572f, 0.05715271f, -0.01108081f, -0.05493280f, 0.04963366f, -0.16638598f, -0.00844552f, 0.08920619f, 
    0.08774219f, 0.04856999f, -0.02882864f, -0.11631513f, -0.40863150f, 0.16180088f, 0.02312187f, 0.07118598f, 
    -0.08908252f, 0.08071117f, -0.02117757f, 0.12430619f, 0.02537611f, -0.05097594f, 0.03572267f, -0.01325738f, 
    0.02770656f, 0.01366945f, 0.07869763f, 0.02281655f, -0.02191502f, 0.02542462f, -0.14684120f, 0.08879116f, 
    -0.03283293f, -0.46134415f, 0.14565162f, 0.03849224f, 0.08114474f, -0.08707325f, 0.03890375f, 0.00733239f, 
    0.04993978f, 0.05833538f, 0.05182967f, -0.05482912f, -0.00807402f, 0.09027406f, -0.08811367f, -0.04000709f, 
    0.06127942f, 0.04770444f, 0.09974398f, 0.02823926f, 0.33277994f, 0.08817887f, -0.03110432f, -0.18329187f, 
    -0.28990147f, -0.04305542f, -0.00685942f, 0.09312071f, 0.09909152f, -0.08639103f, -0.12680957f, -0.04971626f, 
    0.00463495f, -0.12329120f, 0.07222251f, -0.02900032f, 0.01293949f, -0.11489325f, 0.05123979f, -0.08400318f, 
    0.73122072f, 0.00726726f, -0.40750444f, -0.30134875f, -0.15125926f, 0.07977930f, -0.01441911f, 0.10462776f, 
    0.12367626f, -0.12829711f, -0.08620944f, -0.09766384f, 0.00396964f, 0.10907236f, -0.08617102f, 0.02226483f, 
    0.06895515f, -0.01217766f, -0.14662166f, 0.12321460f, 0.01590976f, -0.56175101f, 0.20989917f, -0.15302356f, 
    0.15644591f, -0.11631691f, 0.06876716f, -0.03309294f, 0.14652844f, -0.11034115f, -0.08428669f, -0.06938788f, 
    -0.06204950f, -0.05282003f, -0.15210198f, 0.04741763f, 0.08645575f, 0.06186133f, -0.09676529f, 0.08602241f, 
    -0.33352605f, 0.09162485f, -0.00822270f, 0.11694034f, -0.01209206f, 0.19587514f, 0.12242486f, -0.08537764f, 
    0.02065925f, -0.24733864f, 0.00042551f, 0.02056512f, -0.07181627f, -0.02130334f, 0.11252227f, 0.09066638f, 
    -0.04180087f, -0.07350166f, -0.00738179f, 0.10286685f, 0.19307223f, -0.37211618f, 0.06814763f, -0.11141172f, 
    -0.04653741f, -0.04602484f, -0.01771657f, -0.12894955f, 0.03234230f, 0.01110070f, -0.03910906f, -0.03906059f, 
    0.05059285f, -0.09365688f, -0.15086116f, -0.03538328f, -0.06222911f, 0.08589683f, -0.09602012f, 0.02322966f, 
    -0.22112407f, -0.29366535f, 0.12822697f, 0.10255686f, 0.06221423f, 0.02391244f, 0.13323505f, 0.13454410f, 
    -0.03568976f, -0.05561154f, 0.12216592f, 0.05001019f, 0.01499204f, 0.00753189f, 0.11229435f, -0.01565083f, 
    0.02559906f, -0.06200458f, -0.05147215f, -0.00562425f, -0.01137548f, 0.07770071f, -0.07506247f, 0.04099536f, 
    0.17620082f, 0.01896497f, 0.07306794f, -0.05551951f, 0.07100780f, -0.03417776f, -0.04292892f, 0.05654159f, 
    0.00263445f, 0.01646987f, 0.01055828f, -0.11034287f, 0.00678658f, 0.11337275f, -0.06549343f, 0.06778294f, 
    -0.64276052f, 0.11855063f, -0.21238866f, -0.12007650f, 0.00142778f, 0.10700648f, 0.04564201f, -0.13432081f, 
    0.02647531f, 0.04762577f, 0.06206601f, 0.00387116f, -0.04995078f, -0.04084104f, 0.13217072f, 0.05301485f, 
    -0.05224559f, 0.00563681f, -0.05362433f, 0.01878767f, 0.41373542f, 0.17765397f, -0.29482409f, 0.11526678f, 
    -0.24612674f, -0.08887365f, -0.05424989f, 0.08291263f, 0.02906711f, -0.00620083f, 0.10267697f, -0.01767448f, 
    -0.01611392f, -0.14062406f, -0.02824371f, -0.02358373f, 0.01308564f, -0.09112985f, 0.11888415f, -0.01086486f, 
    0.13550833f, 0.11671777f, 0.01825786f, -0.10240067f, -0.06322717f, 0.10299719f, 0.03621056f, -0.07877924f, 
    0.05229158f, -0.06278037f, -0.05566329f, -0.01950257f, -0.04260278f, 0.05485954f, -0.03664245f, -0.02011622f, 
    0.03724383f, -0.11587875f, -0.13843662f, 0.03759314f, 0.32404000f, -0.16575477f, -0.04825752f, -0.04572949f, 
    0.16061287f, -0.14975563f, -0.01934064f, 0.05231792f, -0.09224677f, -0.10058568f, -0.03262301f, 0.00376598f, 
    -0.08517288f, -0.14824288f, -0.11311291f, -0.10273666f, 0.03688352f, 0.04521080f, -0.11536054f, 0.04211260f, 
    0.20322219f, 0.11708280f, -0.16673514f, 0.14114276f, 0.04413204f, -0.08848022f, -0.11484659f, -0.02121144f, 
    -0.02344699f, 0.00969075f, -0.09537265f, -0.00554223f, 0.06298934f, -0.10387734f, 0.10514928f, 0.07310895f, 
    0.07653072f, -0.16772200f, -0.13382734f, -0.13395894f, 0.16190723f, 0.02216246f, -0.03741635f, -0.04073468f, 
    0.10237782f, -0.13990314f, -0.05113985f, -0.07429221f, 0.01515681f, -0.13060844f, 0.03341217f, 0.03119608f, 
    -0.01050912f, -0.02469374f, -0.05125679f, -0.04958227f, 0.10516585f, 0.13115226f, -0.10329186f, 0.10675414f, 
    -0.37862039f, -0.03660893f, 0.03362176f, 0.01028496f, 0.08113182f, 0.16066223f, 0.03019729f, -0.03073116f, 
    -0.07121701f, -0.01115046f, 0.05132933f, 0.01439296f, -0.03497628f, 0.17022745f, -0.01612897f, 0.13598953f, 
    0.02161992f, -0.08141455f, -0.13458149f, -0.08540419f, -0.52839494f, -0.34253272f, -0.26732472f, -0.16233489f, 
    -0.17191541f, 0.13127516f, 0.06846155f, -0.09247281f, 0.00011924f, 0.09228744f, -0.00252006f, 0.07672709f, 
    -0.03152766f, 0.10756192f, -0.04701538f, 0.07980436f, 0.04215381f, 0.08586147f, 0.01072737f, 0.13418938f, 
    -0.22785296f, -0.06219922f, 0.16826329f, 0.02880716f, -0.10784834f, 0.07691395f, -0.02424569f, 0.08088232f, 
    -0.05957650f, 0.10478004f, -0.03851862f, 0.09321418f, 0.02286717f, -0.07393958f, -0.00273699f, -0.04862629f, 
    -0.03350231f, -0.06623889f, 0.09485098f, 0.00812953f, 0.11408567f, -0.10301200f, -0.13793139f, 0.04567906f, 
    0.03322747f, 0.02714988f, 0.10556111f, -0.00538045f, 0.07590152f, 0.08826184f, 0.03380984f, -0.10280739f, 
    0.04290377f, -0.02557834f, -0.03583104f, 0.03905852f, 0.04600689f, -0.12630555f, -0.03191611f, 0.01181228f, 
    -0.47915775f, -0.07709549f, -0.11248247f, -0.04396036f, 0.00381375f, 0.01066381f, 0.02695250f, -0.08853308f, 
    0.00258366f, 0.09453843f, -0.00907238f, -0.08503832f, 0.05195491f, -0.09646470f, 0.05331730f, -0.15478538f, 
    -0.00014796f, 0.15316379f, 0.15317234f, 0.13082527f, -0.53544462f, -0.46120152f, -0.29708073f, -0.13976528f, 
    -0.25848943f, 0.05363060f, -0.02543763f, 0.08857721f, -0.11069011f, -0.00136019f, 0.15719147f, -0.02899481f, 
    -0.01841123f, -0.05922376f, 0.00726636f, -0.00468214f, -0.09094266f, 0.10211319f, 0.05742820f, 0.05808726f, 
    -0.20263147f, 0.13924874f, -0.12153414f, -0.00663430f, 0.03889982f, 0.01281197f, 0.07328849f, -0.05843977f, 
    0.02566101f, 0.05544326f, 0.00685675f, 0.01383443f, 0.05560866f, -0.05605255f, 0.09826585f, -0.06051558f, 
    0.06159669f, 0.18397568f, 0.01675405f, 0.03423071f, 0.32638443f, 0.18377614f, 0.08666162f, -0.06796284f, 
    -0.13838497f, -0.17634778f, -0.08343326f, 0.03041030f, 0.09944000f, 0.00137333f, -0.10699692f, 0.03083522f, 
    -0.09220605f, -0.12836409f, -0.10237656f, 0.00261244f, 0.01199704f, -0.03730122f, -0.00394749f, -0.04342582f, 
    -0.06529208f, -0.21724606f, -0.05414364f, 0.05782625f, 0.16889133f, 0.06456612f, 0.01275347f, 0.01235782f, 
    0.03280203f, -0.09658988f, 0.04201992f, 0.05030682f, 0.02984101f, 0.02568248f, -0.06412209f, 0.05108685f, 
    0.03877674f, -0.17890231f, 0.01452305f, 0.02166940f, -0.43285170f, -0.38239443f, -0.19355397f, -0.03710047f, 
    0.21167524f, 0.05379539f, 0.10289856f, -0.03431267f, -0.01608183f, -0.09603392f, 0.08461677f, -0.09434606f, 
    0.02594157f, 0.02795217f, 0.02542876f, 0.11432380f, -0.02648544f, 0.17036785f, 0.12485833f, 0.00032842f, 
    -0.35172966f, -0.00409672f, 0.09358390f, -0.03067935f, -0.19948573f, 0.04502639f, -0.00150115f, 0.04916810f, 
    -0.05653165f, -0.08482781f, 0.01085389f, 0.02804637f, -0.09348820f, -0.11281457f, -0.06607766f, 0.07446364f, 
    -0.10726549f, -0.25286573f, -0.10049158f, -0.03450698f, -0.53012264f, -0.08830106f, 0.11657974f, -0.16666420f, 
    -0.31782866f, 0.07604729f, -0.02256950f, -0.04753840f, -0.11027672f, 0.08192530f, 0.00930541f, 0.00469245f, 
    -0.08274321f, 0.15964833f, 0.09664182f, -0.02329197f, -0.07919274f, -0.07091744f, -0.06509346f, -0.11438875f, 
    0.19001630f, 0.09943830f, -0.19964376f, 0.02096645f, -0.03184618f, -0.08200959f, -0.04290855f, -0.08434330f, 
    -0.00703688f, -0.13388044f, 0.04649112f, 0.03673469f, -0.01666538f, -0.15620345f, 0.11181264f, 0.04196593f, 
    -0.06312042f, 0.06653061f, -0.02599782f, -0.05063417f, 0.04892405f, -0.02592517f, 0.05496566f, 0.03546175f, 
    0.02944827f, 0.10493349f, 0.09857728f, 0.21185501f, 0.04529990f, 0.11691416f, 0.00307384f, -0.01850029f, 
    0.04940828f, -0.04478738f, -0.04978520f, -0.02396487f, 0.00567273f, -0.22471863f, 0.05726076f, -0.00785966f, 
    -0.15551546f, -0.15777467f, -0.15640846f, -0.09759064f, 0.02149384f, -0.02005719f, 0.06535765f, -0.02379213f, 
    -0.01251907f, 0.05258603f, -0.02214985f, -0.08625679f, -0.09740651f, -0.00342160f, 0.05605096f, -0.05192552f, 
    0.11732417f, 0.09456122f, 0.11046565f, 0.06912149f, -0.63692039f, 0.08377478f, -0.11603826f, -0.16718023f, 
    -0.05222148f, 0.08378099f, 0.04959621f, -0.04704326f, -0.07153409f, 0.05418239f, 0.04908887f, 0.00406697f, 
    0.03241554f, 0.00460782f, 0.00582850f, -0.06123121f, 0.09222091f, 0.14558844f, 0.02131438f, 0.06515434f, 
    0.02134407f, 0.13226461f, -0.04907354f, 0.00568434f, -0.00088159f, 0.09887656f, 0.00582379f, 0.04523788f, 
    -0.03203116f, 0.01044527f, 0.04864437f, 0.02037853f, 0.12204894f, 0.02633584f, -0.04144321f, -0.01765021f, 
    0.03012597f, -0.14170520f, 0.02170797f, -0.02586702f, -0.18196829f, -0.24856538f, -0.08513812f, -0.10089787f, 
    0.06167401f, -0.03533912f, 0.03867684f, 0.05565358f, -0.07702477f, -0.12388004f, 0.06246027f, -0.04688275f, 
    -0.03226294f, -0.10393678f, 0.09288569f, -0.07921244f, 0.00131525f, 0.09406444f, 0.07017840f, 0.02649402f, 
    0.10039876f, 0.12548789f, 0.01625000f, -0.01265580f, 0.07375826f, -0.04340461f, 0.06063861f, -0.01522058f, 
    0.03619658f, 0.02891946f, 0.06020175f, 0.06022403f, -0.09386744f, -0.07460838f, 0.01068023f, 0.17431827f, 
    0.02721737f, -0.03863033f, -0.16196670f, 0.09934010f, -0.41065884f, -0.32300973f, 0.02080369f, -0.03021731f, 
    0.05983688f, 0.10767379f, 0.08051635f, -0.03719379f, -0.03819121f, 0.00729697f, -0.04524985f, 0.01178787f, 
    -0.03258047f, 0.12452163f, 0.05732274f, 0.09093732f, 0.06511541f, 0.13898504f, 0.11076187f, 0.05020244f, 
    -0.52329499f, -0.28569490f, 0.24516591f, 0.03718654f, -0.02398001f, -0.01228521f, -0.03421964f, 0.03325550f, 
    -0.16485463f, 0.07577311f, -0.00877255f, 0.05683984f, 0.10678574f, -0.03833713f, 0.06913609f, -0.14335760f, 
    0.04996705f, 0.03949633f, -0.00027469f, 0.07529257f, -0.19348133f, 0.01810829f, -0.17831685f, 0.18355852f, 
    0.05662678f, 0.03956630f, 0.07399999f, -0.07194851f, 0.03580007f, -0.00415093f, 0.05459238f, 0.08418559f, 
    0.06254952f, 0.03398475f, 0.22878528f, 0.04449261f, 0.00895723f, 0.00478037f, -0.02764664f, -0.03510318f, 
    -0.46860358f, -0.38780537f, -0.32346004f, -0.24116768f, -0.22280860f, 0.00175708f, 0.11012895f, -0.08797608f, 
    -0.10615045f, -0.00199646f, 0.00462395f, -0.04286151f, -0.08567760f, -0.04390623f, -0.01690152f, -0.07031436f, 
    0.01912420f, 0.12150977f, 0.14158612f, -0.00691206f, -0.73530430f, -0.25343686f, 0.02267258f, 0.02316105f, 
    -0.11790482f, 0.13005377f, 0.07523452f, -0.00541061f, 0.05320150f, 0.07132120f, 0.03733457f, 0.04975254f, 
    -0.07638737f, 0.08095974f, 0.04470997f, 0.07752792f, -0.05025681f, 0.04147746f, -0.05209205f, -0.01873484f, 
    -0.06905928f, 0.31700501f, -0.01035187f, 0.00518938f, 0.13582052f, 0.15594989f, -0.01459094f, -0.05846040f, 
    0.02403184f, 0.05083014f, 0.10472263f, 0.10662427f, -0.10496193f, -0.06112849f, 0.07685269f, -0.02775648f, 
    0.19062650f, 0.10592531f, -0.06629741f, 0.07107028f, -0.53794837f, -0.05308636f, 0.05779425f, -0.06696757f, 
    0.06896019f, -0.07083157f, 0.05271988f, 0.00498486f, 0.13082999f, -0.02749385f, -0.02152630f, 0.08908154f, 
    0.12581490f, -0.00606089f, -0.06979211f, -0.01356706f, -0.05945263f, -0.00301261f, -0.20203015f, -0.00585958f, 
    -0.04600056f, 0.00641950f, -0.03537715f, 0.08332892f, -0.22522357f, -0.06505192f, 0.04448392f, -0.06598537f, 
    0.08101789f, -0.07000001f, 0.02926069f, -0.05199207f, 0.11386123f, 0.04136409f, -0.04115674f, 0.03223633f, 
    0.02399109f, -0.13407782f, -0.01179892f, 0.11282802f, 0.32932517f, -0.40425032f, 0.18565111f, 0.13077332f, 
    -0.04725210f, -0.06709378f, 0.11112485f, 0.13638759f, -0.16114990f, 0.00000369f, -0.21635924f, -0.18397738f, 
    -0.01641805f, 0.02839318f, -0.23360178f, -0.11603616f, -0.13390361f, 0.00230215f, -0.05842683f, -0.06982522f, 
    -0.07087427f, 0.25874799f, -0.07242332f, -0.17283334f, -0.03530619f, -0.07651822f, -0.20251738f, 0.01423612f, 
    -0.31856534f, -0.05907854f, 0.04636355f, 0.05391592f, 0.03013265f, -0.09746830f, 0.00326087f, 0.10133611f, 
    0.04937786f, -0.10364951f, 0.07880164f, -0.06818971f, -0.38335907f, 0.25351399f, 0.01435710f, 0.12989052f, 
    -0.08853269f, 0.12229516f, -0.03830912f, 0.12262600f, -0.02920200f, -0.00595803f, 0.03348452f, -0.12674959f, 
    0.08820181f, -0.07852037f, -0.00538624f, -0.05149294f, 0.10804635f, -0.11560414f, -0.04037208f, 0.03740816f, 
    0.14239891f, 0.13419582f, -0.09314885f, -0.00812671f, -0.20810887f, -0.07583208f, 0.03236464f, -0.03997857f, 
    -0.10175978f, -0.13572739f, -0.12578869f, -0.02515660f, 0.05099691f, -0.05332869f, -0.07513329f, 0.12860222f, 
    -0.03445833f, -0.01500915f, -0.06486835f, -0.05833057f, -0.48353043f, 0.20535684f, 0.02324986f, 0.00554552f, 
    0.05051688f, 0.00979320f, -0.03067338f, 0.04344477f, -0.02457228f, 0.07321595f, 0.02483714f, -0.05920991f, 
    0.04868883f, -0.11014614f, -0.09554633f, -0.09574730f, -0.01924773f, -0.05857141f, -0.10992726f, -0.04124526f, 
    0.33212769f, 0.29602823f, -0.26477692f, -0.08277138f, 0.14638756f, 0.11673876f, 0.04359863f, -0.08798563f, 
    0.09072955f, 0.02247241f, 0.16322722f, 0.07397977f, 0.02688573f, -0.11767994f, 0.10321818f, -0.00893852f, 
    -0.05476134f, 0.05603244f, -0.00562770f, 0.23098032f, 0.65800685f, -0.03398657f, -0.31626126f, 0.03649590f, 
    -0.04065101f, 0.02634273f, 0.04130042f, -0.08858716f, -0.02340692f, 0.08265922f, 0.06316695f, 0.00043658f, 
    0.01356647f, -0.03277521f, 0.03215079f, 0.08558553f, -0.08496505f, -0.02195711f, -0.01229898f, 0.04771851f, 
    -0.07011885f, -0.30739725f, 0.09139678f, -0.22599299f, 0.08313236f, -0.08484853f, -0.16032749f, -0.03108143f, 
    0.05560779f, -0.02720464f, -0.12456924f, -0.12424592f, -0.01971676f, 0.02649404f, -0.10577869f, -0.01824887f, 
    0.00670971f, 0.03533066f, 0.07336061f, -0.03586299f, -0.06044042f, 0.11098888f, -0.10008433f, -0.03146783f, 
    0.05506019f, 0.05623676f, -0.12685217f, 0.04270864f, -0.07721530f, -0.09806461f, 0.02908586f, 0.07359706f, 
    -0.00318591f, -0.03708804f, 0.07354023f, 0.08531857f, 0.06542701f, -0.05493876f, 0.00926184f, -0.11657351f, 
    0.08142065f, -0.17723523f, -0.08712005f, 0.07453741f, -0.00519563f, -0.02336413f, 0.09950456f, 0.00785935f, 
    -0.00994531f, -0.04608625f, 0.10376468f, -0.03373918f, -0.12302373f, 0.02074616f, 0.04757342f, 0.10508887f, 
    -0.02069530f, -0.09054382f, 0.01412369f, -0.11628524f, 0.32756120f, -0.31923634f, 0.04472252f, 0.06106349f, 
    -0.10394554f, 0.05394530f, 0.10869955f, 0.02648711f, -0.02605627f, 0.05489530f, 0.02091701f, 0.01023326f, 
    -0.01503383f, -0.00873167f, -0.09676952f, -0.05549110f, -0.09323899f, -0.03271835f, -0.05917830f, 0.00856765f, 
    -0.42501360f, 0.00348364f, -0.00109111f, -0.00224625f, 0.01744725f, -0.00084647f, 0.06024928f, -0.05833638f, 
    0.05169421f, -0.01903286f, -0.05221656f, -0.00705886f, 0.06375721f, 0.01261037f, 0.03469013f, -0.10982850f, 
    -0.02148767f, -0.12962064f, -0.11256832f, 0.01127016f, 0.03574331f, 0.00640541f, -0.02130409f, -0.01631603f, 
    0.04394461f, -0.00873698f, -0.00969794f, 0.03637112f, -0.16806662f, -0.18986854f, -0.13922878f, -0.04691928f, 
    0.06742051f, -0.03266325f, -0.15307975f, -0.01917470f, -0.04491989f, 0.00110455f, -0.11313356f, -0.01160239f, 
    0.12992252f, 0.24576630f, -0.21750359f, 0.19123746f, 0.30224130f, 0.14990848f, 0.00090208f, -0.07690477f, 
    -0.12890513f, -0.02163211f, 0.00826540f, 0.08397118f, 0.03306912f, 0.03262447f, -0.07334906f, 0.04335651f, 
    0.00968100f, -0.03355251f, -0.15584956f, 0.05571426f, -0.16499537f, 0.00411699f, -0.07349138f, 0.11591263f, 
    -0.08576815f, 0.18420087f, -0.02181514f, 0.01808498f, 0.01525077f, 0.03281159f, 0.00770435f, -0.03071513f, 
    -0.02402500f, 0.00194098f, 0.01366191f, -0.05619999f, -0.00099726f, -0.03126862f, -0.18624887f, 0.00012961f, 
    0.09661334f, 0.09243947f, -0.14999446f, -0.09445090f, -0.08505049f, 0.19009916f, -0.03710856f, -0.04739407f, 
    -0.02305050f, -0.11949437f, 0.10198075f, -0.11182541f, 0.02206170f, 0.03525560f, -0.10939125f, 0.11785483f, 
    0.06154939f, -0.01864927f, 0.02490714f, 0.07411964f, 0.36245185f, 0.20328061f, -0.18858382f, -0.19454540f, 
    0.08333312f, -0.16987316f, -0.11534438f, -0.08143464f, 0.14900927f, -0.01084376f, 0.10472844f, 0.04185202f, 
    0.00949098f, 0.05134448f, -0.00924838f, 0.01018024f, -0.01532450f, -0.01394252f, -0.01134768f, 0.10955130f, 
    -0.13048512f, -0.40958911f, 0.10828661f, -0.11103994f, -0.00888097f, -0.10127977f, 0.14676745f, -0.07742316f, 
    0.13776989f, -0.01446589f, -0.26600090f, -0.01238790f, 0.04007459f, 0.13413322f, 0.01280788f, -0.13889030f, 
    -0.04589208f, -0.01891873f, -0.26128700f, -0.04377476f, 0.11467247f, -0.08921685f, -0.12556365f, 0.05173530f, 
    0.10983840f, 0.01368655f, -0.19224805f, -0.09962673f, 0.02228302f, 0.05622566f, 0.02066873f, 0.03826878f, 
    -0.09918791f, 0.02311018f, -0.00203059f, -0.05713648f, 0.09915315f, 0.02469521f, -0.05537440f, -0.02714685f, 
    -0.43081346f, -0.06864434f, -0.10799266f, -0.01607358f, -0.31265089f, 0.16777146f, 0.07069480f, 0.04155563f, 
    -0.08263254f, 0.03995493f, -0.02928097f, -0.08145916f, 0.04521873f, -0.09537874f, -0.14526314f, -0.13991241f, 
    -0.04198108f, 0.01307755f, -0.14665362f, -0.11354515f, 0.08194491f, -0.06024495f, 0.07215567f, 0.09372123f, 
    0.16796818f, -0.05606927f, 0.20506391f, -0.02318888f, 0.02572513f, -0.02153331f, 0.06028553f, -0.08667117f, 
    0.02389855f, 0.01737516f, 0.02012900f, -0.00177591f, 0.02592306f, 0.00507226f, 0.05095990f, -0.06422111f, 
    0.23803370f, -0.23813981f, -0.16135120f, 0.16138384f, -0.00563337f, -0.10317633f, -0.02461098f, -0.02405389f, 
    0.01073871f, -0.03263292f, 0.09073668f, -0.05749746f, -0.04886999f, 0.05304553f, 0.05372738f, 0.13440007f, 
    -0.05559367f, 0.00105429f, 0.06172675f, 0.04111051f, -0.38529971f, -0.11481378f, -0.04077299f, 0.04438235f, 
    -0.33434853f, 0.17076218f, 0.10892174f, 0.08124771f, 0.03651008f, 0.06269567f, 0.00083315f, -0.09375101f, 
    -0.08663345f, 0.01714166f, 0.09676375f, -0.13555500f, 0.04439498f, -0.10421905f, -0.01097465f, 0.00690372f, 
    -0.31995589f, 0.29183695f, -0.11787703f, 0.02000788f, 0.44540626f, 0.02896992f, -0.18213049f, -0.09119730f, 
    0.03290914f, 0.02825700f, -0.03679534f, -0.00394949f, 0.04121137f, 0.00055835f, 0.06440382f, 0.05875059f, 
    0.06804418f, 0.04137892f, 0.03733116f, -0.11759248f, 0.19717060f, -0.23669642f, -0.10736569f, -0.20169079f, 
    -0.11524400f, 0.14975439f, 0.00573797f, -0.06017296f, 0.04853692f, 0.06544153f, 0.04716504f, -0.01893693f, 
    0.09311960f, -0.03491537f, 0.02942572f, -0.01984535f, -0.00995183f, 0.05513978f, -0.04773877f, 0.02708342f, 
    -0.27092198f, -0.29156205f, -0.06831317f, -0.17824957f, 0.21359165f, 0.00674151f, -0.14722313f, 0.00503538f, 
    0.16526982f, 0.10443813f, -0.04606308f, -0.06481477f, 0.10720868f, 0.02125247f, -0.00608225f, 0.09545568f, 
    0.06499440f, -0.02205983f, 0.00092014f, -0.09611722f, 0.01490510f, -0.01930172f, -0.13608804f, 0.18028216f, 
    -0.20435472f, -0.10097662f, 0.13268472f, 0.04132174f, -0.01566310f, -0.02213641f, -0.03467144f, -0.02182587f, 
    0.11612407f, -0.03336381f, -0.05155189f, 0.06931894f, 0.14266588f, -0.07658608f, -0.03765146f, -0.10320016f, 
    -0.04751018f, -0.35519770f, -0.12394975f, -0.21448188f, -0.36722693f, 0.05282458f, 0.00304085f, 0.16366942f, 
    -0.04145968f, 0.12780929f, 0.09905774f, 0.11639374f, 0.04901939f, -0.02158528f, -0.12813552f, -0.15909481f, 
    -0.03461723f, -0.00560452f, -0.10452019f, -0.04323613f, 0.42091018f, 0.16693681f, -0.23500657f, -0.06595460f, 
    -0.33842826f, 0.08495229f, 0.00229806f, 0.02122219f, 0.07851761f, 0.04852351f, 0.06594124f, 0.04486168f, 
    -0.11027022f, -0.00129474f, 0.14481542f, 0.02084683f, 0.05249515f, 0.03037106f, -0.04487227f, 0.03118902f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06715240f, 0.00405252f, -0.05782067f, 0.00563858f, -0.00099611f, 0.03749018f, -0.01300270f, -0.05558123f, 
    -0.02154847f, 0.00572329f, 0.07614004f, 0.02161867f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
